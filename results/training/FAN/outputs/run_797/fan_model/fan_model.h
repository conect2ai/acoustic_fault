/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.36724916e-02f, -1.20378591e-01f, -7.50211477e-02f, 8.81982595e-03f, -4.90552932e-03f, -2.00823516e-01f, -3.50605845e-01f, -2.46631682e-01f, 5.32897785e-02f, -9.92798880e-02f,
  1.14491269e-01f, 2.64656574e-01f, 1.61495909e-01f, 1.53913021e-01f, -1.05571307e-01f, -4.58289683e-02f, 1.90823093e-01f, 1.32821485e-01f, -5.54374270e-02f, -1.44269779e-01f,
  4.40663435e-02f, 2.42393613e-02f, -1.28999613e-02f, 3.60335968e-02f, 1.23281635e-01f, -2.30204854e-02f, 4.57570329e-02f, 1.29809752e-01f, 5.32748289e-02f, 3.85307938e-01f,
  4.94682118e-02f, -7.37178326e-02f, 3.30214351e-02f, -6.83346465e-02f, 5.26156947e-02f, -1.43971443e-02f, -3.03314365e-02f, 6.38868883e-02f, 5.98789863e-02f, 9.19606537e-02f,
  1.62653595e-01f, 1.19457744e-01f, 7.48307556e-02f, 3.32888141e-02f, 4.81931977e-02f, -6.91798255e-02f, -4.09657089e-03f, 8.96476582e-02f, -4.40927707e-02f, -5.33580035e-02f,
  1.40256351e-02f, 2.60514230e-03f, -3.82843912e-02f, -5.66872731e-02f, -4.70338687e-02f, 1.72622666e-01f, -4.46972623e-02f, 5.70865013e-02f, -3.99778821e-02f, -5.17812483e-02f,
  -2.73319948e-02f, 1.81969311e-02f, 5.39138652e-02f, -3.90073620e-02f, -9.16032568e-02f, -4.59391028e-02f, 2.96829827e-02f, -2.54540499e-02f, -3.90801113e-03f, -9.80189219e-02f,
  3.77039351e-02f, -1.56708956e-02f, 5.75603684e-03f, 2.37464029e-02f, 5.44797592e-02f, 1.06069667e-03f, -7.06677674e-04f, -1.05712358e-02f, 3.75026092e-02f, 5.38491942e-02f,
  -2.05809498e-04f, -3.04518938e-02f, -1.01513721e-01f, 5.00498340e-02f, -2.66541429e-02f, 5.06997667e-02f, 7.76222050e-02f, -3.76805253e-02f, 2.22644061e-02f, 2.76961457e-02f,
  -1.05619036e-01f, 1.80670053e-01f, 1.17015257e-01f, 3.31562348e-02f, 2.28122231e-02f, 2.80699469e-02f, 7.98237883e-03f, -4.01441418e-02f, 5.79771250e-02f, -3.09259165e-02f,
  -1.25420419e-03f, 2.36704443e-02f, 6.04149587e-02f, -2.39636600e-02f, -2.71613114e-02f, -2.94697806e-02f, -1.93154998e-02f, 1.49481297e-02f, 1.85986366e-02f, -1.77745391e-02f,
  1.90608166e-02f, -1.80204973e-01f, -1.06499277e-01f, -9.70502794e-02f, 9.17506870e-03f, -3.93885560e-02f, -4.34255637e-02f, -4.80748415e-02f, -1.26054630e-01f, -2.78380603e-01f,
  9.58014011e-01f, -6.28010556e-02f, 8.10682774e-02f, 3.33226651e-01f, -2.82909632e-01f, -7.49885291e-02f, -7.58069307e-02f, 3.18300910e-02f, 1.09693341e-01f, -7.89210433e-04f,
  -5.47747649e-02f, -1.28131375e-01f, 3.45913395e-02f, -2.32419983e-01f, -1.58257633e-02f, -1.60303235e-01f, -5.88972531e-02f, 1.87604483e-02f, -8.97995606e-02f, -1.73507079e-01f,
  -1.93810955e-01f, 2.41000324e-01f, 2.72664607e-01f, 5.15371114e-02f, -1.11939207e-01f, -1.81216925e-01f, 1.36261107e-02f, 6.50319383e-02f, -1.42723426e-01f, -1.87440783e-01f,
  -1.08743079e-01f, 1.45135298e-01f, -5.82818016e-02f, -3.21322791e-02f, -3.77444588e-02f, 5.93084395e-02f, -8.10960010e-02f, 3.60067673e-02f, -2.50931997e-02f, -3.79069406e-03f,
  -2.29675435e-02f, -7.47567639e-02f, 7.13219792e-02f, -8.77916366e-02f, 8.96010399e-02f, 1.85402557e-02f, 3.00111026e-02f, 1.50261998e-01f, 9.81584564e-02f, 1.01673519e-02f,
  -1.22820795e-01f, -7.53985718e-02f, 4.43493091e-02f, 1.30472649e-02f, 4.18450199e-02f, -9.84901562e-03f, -8.66966322e-03f, -1.71508384e-03f, -7.42461383e-02f, 3.47462073e-02f,
  1.71072595e-02f, -6.18278459e-02f, -9.87178367e-03f, -6.05089292e-02f, 7.33845634e-03f, -2.87609715e-02f, 2.88004410e-02f, -2.03559473e-02f, -9.31752771e-02f, 9.29891467e-02f,
  -2.52745803e-02f, -1.07659744e-02f, -3.90149624e-04f, 8.14538002e-02f, -2.60454658e-02f, -8.86412745e-04f, 1.93367153e-02f, 1.16568767e-02f, -5.93037270e-02f, 6.44015521e-02f,
  1.99769773e-02f, -3.03957444e-02f, 5.31089085e-04f, -4.09422964e-02f, -1.91880129e-02f, -8.74380348e-04f, -2.37993114e-02f, -1.17007922e-02f, 3.31907235e-02f, 1.71422381e-02f,
  1.19280867e-01f, -4.60430756e-02f, 5.87330572e-02f, -4.40231003e-02f, -4.03206274e-02f, 5.44330012e-03f, -3.28274444e-02f, -1.52803166e-02f, 4.52200733e-02f, -2.47409251e-02f,
  -7.29772225e-02f, 2.33591963e-02f, -1.93463024e-02f, -2.97674593e-02f, 1.91918276e-02f, 2.48982804e-04f, -9.86326188e-02f, -4.98546883e-02f, -5.17755970e-02f, -8.63910541e-02f,
  2.49459241e-02f, 4.71153930e-02f, 4.16667387e-02f, 1.62432380e-02f, 4.82988823e-03f, -1.07895367e-01f, -3.20503861e-02f, 3.22392173e-02f, -6.54727295e-02f, 2.03928143e-01f,
  3.36944610e-01f, -3.89087141e-01f, 4.41486001e-01f, -1.30421802e-01f, -2.80892998e-01f, 1.05090015e-01f, 2.04710532e-02f, 6.38429169e-03f, -8.12752992e-02f, -1.97862312e-01f,
  -1.20277695e-01f, -1.39809847e-01f, 5.50676091e-03f, -3.04297023e-02f, 3.26064080e-01f, 9.78476554e-02f, 1.94781095e-01f, 4.06576186e-01f, 3.40447754e-01f, -3.07011046e-02f,
  -3.43407243e-01f, 9.31373239e-02f, 1.82764396e-01f, 6.80693015e-02f, -1.28483310e-01f, -8.35436862e-03f, 8.73440132e-02f, 1.76960319e-01f, -6.35823160e-02f, -1.24193199e-01f,
  2.42074057e-01f, 7.45097846e-02f, 8.62710476e-02f, -8.73432755e-02f, -1.41658746e-02f, 2.60844342e-02f, 3.24847177e-02f, 1.24604583e-01f, -2.69755498e-02f, 1.45923700e-02f,
  1.06460722e-02f, 4.20641601e-02f, 5.63409477e-02f, -6.30283132e-02f, 8.92395303e-02f, -1.12421000e-02f, 8.16819817e-02f, 1.40150398e-01f, 1.26015231e-01f, -5.23127355e-02f,
  -2.22691789e-01f, 4.32632491e-03f, 1.26405194e-01f, 4.78003547e-02f, 5.77172041e-02f, -1.33079821e-02f, -9.05937254e-02f, 1.91976875e-02f, 8.41601640e-02f, -1.16660863e-01f,
  -6.03397638e-02f, 8.03761855e-02f, 2.46595107e-02f, -1.53188687e-02f, -4.37427498e-02f, -4.84480746e-02f, 5.60122766e-02f, -2.66636889e-02f, 5.23200072e-02f, -1.43305352e-02f,
  -8.13613236e-02f, 3.32612507e-02f, -2.82365512e-02f, 6.73606806e-03f, 1.54266041e-02f, 4.37520705e-02f, 5.97105436e-02f, -4.60257865e-02f, -1.35732191e-02f, 1.70759318e-04f,
  -1.68075354e-03f, 2.70359926e-02f, -1.30504845e-02f, 2.76478287e-02f, -9.52140689e-02f, 3.74363437e-02f, 1.37628661e-02f, -8.66507180e-03f, 2.38928404e-02f, -9.64722130e-04f,
  -1.81100816e-01f, 5.39352857e-02f, -8.15015882e-02f, 3.16192769e-02f, 1.26334997e-02f, -9.31132361e-02f, -4.32392471e-02f, -3.26826759e-02f, -2.70824283e-02f, -3.76047902e-02f,
  1.22571494e-02f, 3.46658900e-02f, -2.47384068e-02f, -1.79634560e-02f, 4.45813164e-02f, -5.01371967e-03f, -4.94106524e-02f, -2.99847182e-02f, 1.57922637e-02f, -9.30047873e-03f,
  -4.23493907e-02f, -4.63386700e-02f, -1.65739171e-02f, 2.75434367e-02f, -1.11462452e-01f, 1.47339314e-01f, 3.00390497e-02f, 1.67666730e-02f, 1.79858312e-01f, -2.50563800e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.67749569e-01f, -3.27864319e-01f, 2.08802875e-02f, 5.40557429e-02f, 1.87402312e-02f, 6.70465231e-02f, -2.66076088e-01f, -8.33881721e-02f, 9.76045728e-02f, -1.40687719e-01f,
  -8.31264630e-02f, 1.28616735e-01f, -6.51784893e-03f, 1.71585619e-01f, 7.97978863e-02f, -1.71449274e-01f, 5.08037060e-02f, 9.01564062e-02f, 2.28253275e-01f, 1.75326079e-01f,
  1.14287063e-01f, 1.11613423e-01f, 9.10797641e-02f, 5.14852442e-02f, -7.36248344e-02f, -1.53050767e-02f, -3.86341400e-02f, 2.01036558e-02f, -1.12849206e-01f, -2.09127814e-01f,
  -1.42546073e-01f, -8.41462985e-02f, 6.96623623e-02f, -4.64597195e-02f, 2.86642890e-02f, -9.17559788e-02f, -8.09377208e-02f, 4.03178819e-02f, -6.14563236e-03f, -9.50418040e-02f,
  -5.21116219e-02f, -4.67857420e-02f, -9.43845734e-02f, -2.16036942e-02f, -6.55935928e-02f, -6.28779680e-02f, 7.71231484e-03f, 7.89161474e-02f, -3.27741951e-02f, -1.04857072e-01f,
  -1.71950627e-02f, -5.30102402e-02f, -1.78322002e-01f, -1.37031395e-02f, 2.32643957e-04f, -1.06885158e-01f, -1.25830367e-01f, -6.87754825e-02f, -1.01398170e-01f, -3.31284732e-01f,
  9.15427729e-02f, -2.52933688e-02f, -9.52870119e-03f, -5.54734394e-02f, -7.42161795e-02f, 6.18429072e-02f, 4.24845144e-02f, 5.06476825e-03f, 1.18115237e-02f, 3.72791402e-02f,
  3.02266274e-02f, -3.89409624e-02f, 1.46293119e-01f, 4.02161106e-02f, 6.84736818e-02f, 2.33774595e-02f, 4.48804162e-02f, -1.69211591e-03f, -1.27805620e-02f, -9.55275202e-04f,
  7.10108951e-02f, -3.80191132e-02f, 1.45507604e-03f, 4.97214235e-02f, -7.07441866e-02f, 6.02741577e-02f, 5.94374388e-02f, -7.37336576e-02f, 6.69896081e-02f, -6.06469624e-02f,
  -1.37717620e-01f, 3.36546779e-01f, -1.60594225e-01f, -6.68258816e-02f, -8.64524245e-02f, -3.33581492e-02f, -1.39550537e-01f, 1.81012582e-02f, -7.84872007e-03f, -1.95561081e-01f,
  -7.71496966e-02f, -2.88891997e-02f, -5.94799556e-02f, -4.27217074e-02f, -4.26047016e-03f, -1.25375047e-01f, -1.02209665e-01f, -3.51632126e-02f, -2.50251871e-02f, -8.33525509e-02f,
  -6.69533387e-02f, -2.19989181e-01f, -2.87063390e-01f, -2.31517792e-01f, -1.10079870e-02f, -2.32722238e-01f, -1.50651529e-01f, -2.00891405e-01f, -2.80636072e-01f, -3.98741752e-01f,
  3.16077359e-02f, -2.61572540e-01f, -8.51914808e-02f, -7.00725913e-02f, -1.25155345e-01f, -2.15980396e-01f, -2.37066552e-01f, -5.83284236e-02f, -2.62997206e-02f, -1.15455851e-01f,
  3.77416499e-02f, -2.01170519e-02f, 4.94710766e-02f, 1.17142685e-02f, 1.44072846e-02f, -1.28212869e-01f, -1.37182310e-01f, 6.06485680e-02f, 6.35472909e-02f, -5.40656224e-02f,
  -7.74945095e-02f, 3.35240811e-02f, -2.09792648e-02f, -1.56121450e-02f, -8.95481408e-02f, -1.18281469e-01f, -1.46296278e-01f, -3.58047858e-02f, -5.73824421e-02f, -2.09679425e-01f,
  -1.54611602e-01f, 1.27767771e-01f, 3.03439423e-02f, -2.65352856e-02f, -2.05936059e-02f, 4.49273549e-02f, 4.65046279e-02f, 1.04598917e-01f, 3.12986635e-02f, 7.11614117e-02f,
  -2.13063434e-02f, 4.59379256e-02f, 1.07019199e-02f, 8.36414844e-02f, 6.86821789e-02f, 2.16348749e-02f, 1.14215977e-01f, -2.39291955e-02f, 6.70242831e-02f, -5.32239340e-02f,
  3.47761959e-02f, 1.62482094e-02f, 6.63340166e-02f, 5.21944985e-02f, 1.06082380e-01f, 4.01457436e-02f, 1.01270199e-01f, -5.47037576e-04f, 4.88029346e-02f, -1.34881571e-01f,
  -1.03331327e-01f, -5.57909757e-02f, -5.30589260e-02f, -4.20914330e-02f, 1.80204920e-02f, -6.31317124e-02f, -8.33463967e-02f, -1.59842998e-03f, 5.85981607e-02f, 9.48387664e-03f,
  -2.58414876e-02f, 4.02453467e-02f, 4.12143506e-02f, -1.29761361e-02f, -3.70976105e-02f, -9.15608834e-03f, -3.55809666e-02f, -2.86680330e-02f, -5.54689616e-02f, 6.29230076e-03f,
  -4.58930694e-02f, -2.93833539e-02f, -7.25863650e-02f, -2.96810195e-02f, -1.26890270e-02f, -4.75356057e-02f, 1.09952390e-01f, 9.35565233e-02f, 9.53021124e-02f, 3.48048061e-02f,
  2.11301167e-02f, 4.80651781e-02f, -8.24196860e-02f, -1.97248049e-02f, 2.47087236e-02f, -3.05975974e-02f, -8.89246911e-02f, 3.87976808e-03f, 6.19724253e-03f, -8.45647790e-03f,
  7.47665241e-02f, -4.96388674e-02f, -6.10404387e-02f, -6.63987845e-02f, -2.19039656e-02f, -2.26126648e-02f, 3.95716541e-02f, 3.29261050e-02f, -7.32536688e-02f, -1.07216664e-01f,
  -1.20866224e-01f, 3.11010107e-02f, 1.13260992e-01f, 1.03402488e-01f, -8.01451802e-02f, 6.13028109e-02f, -9.26080793e-02f, 1.94084621e-03f, 5.30861765e-02f, -4.45885025e-02f,
  2.75796324e-01f, 4.77371700e-02f, 1.37866318e-01f, 8.77405703e-02f, -1.94061667e-01f, -2.82826453e-01f, -4.25103486e-01f, -2.49849960e-01f, -1.14048608e-01f, 6.03695028e-02f,
  -9.14637446e-02f, 1.01934485e-01f, -2.48180609e-03f, -4.66907257e-03f, -7.00984448e-02f, 1.55613560e-03f, 9.67647210e-02f, 3.81451733e-02f, -1.00679852e-01f, -2.44744513e-02f,
  7.26180375e-02f, 1.08685680e-01f, 1.03376433e-01f, -7.33906589e-03f, 1.40123054e-01f, -1.08934022e-01f, -9.89131536e-03f, 1.28429309e-01f, -2.01317389e-02f, 4.59390581e-01f,
  2.98471719e-01f, -2.90428828e-02f, -7.74535909e-02f, 9.80342105e-02f, 2.39815805e-02f, 1.09708518e-01f, 3.00394259e-02f, 7.56692290e-02f, -1.72016900e-02f, -1.26183452e-02f,
  9.54144374e-02f, 6.33382350e-02f, 5.02151102e-02f, -8.45938548e-03f, -1.39958784e-01f, -1.45266391e-02f, -4.98012267e-02f, 1.78060811e-02f, -2.40645595e-02f, -7.37819746e-02f,
  -5.79580665e-02f, -3.06429975e-02f, -1.88306168e-01f, -2.70144552e-01f, -1.48033723e-01f, -7.75589123e-02f, -2.39445612e-01f, -5.15668243e-02f, -1.14205174e-01f, 4.03946452e-02f,
  3.03140711e-02f, 5.65491058e-02f, -4.37828712e-03f, 6.91680908e-02f, 6.19653799e-03f, 5.03389835e-02f, 4.26236354e-02f, -2.80793067e-02f, -1.85602382e-02f, 1.08695254e-02f,
  -3.07311080e-02f, 4.89275903e-02f, 2.17084382e-02f, 6.68592080e-02f, -8.54983106e-02f, 1.69649404e-02f, -7.29342550e-02f, 1.06425751e-02f, 3.74947954e-03f, 9.21255350e-03f,
  -2.53555756e-02f, 3.59114781e-02f, 5.41004054e-02f, 4.73210737e-02f, -1.68241654e-02f, 6.55205101e-02f, 6.57994524e-02f, -1.03316426e-01f, 7.12130871e-03f, 1.21584289e-01f,
  1.23196281e-01f, -1.98700398e-01f, 1.19434141e-01f, 1.57570541e-02f, 4.23647165e-02f, -1.99498255e-02f, 6.93462268e-02f, -5.50349094e-02f, 1.68286171e-02f, -5.75501025e-02f,
  -1.38675988e-01f, -5.23926690e-02f, -6.75372183e-02f, -5.86310634e-05f, -8.80896524e-02f, 8.16784985e-03f, 3.58868279e-02f, -7.97490356e-04f, -6.77171499e-02f, 4.54046912e-02f,
  -1.05344228e-01f, -2.23898873e-01f, -1.77089319e-01f, -4.26034816e-02f, -2.57547274e-02f, -1.41101345e-01f, -8.88795257e-02f, -2.34851494e-01f, -2.35133097e-01f, -1.37218744e-01f,
  -3.10964108e-01f, -2.13107824e-01f, 8.57121646e-02f, -1.20404534e-01f, 1.56451881e-01f, 1.94539338e-01f, 2.39949748e-01f, 5.90519607e-02f, -1.17070951e-01f, -7.36838728e-02f,
  4.30901460e-02f, 1.64868832e-01f, 1.25966892e-01f, 2.10563645e-01f, 1.12117581e-01f, 9.87740234e-02f, -1.41941728e-02f, 7.76977688e-02f, 3.84794831e-01f, 2.30006605e-01f,
  1.02830298e-01f, -1.45385921e-01f, -1.95148870e-01f, -1.79337393e-02f, -1.44368768e-01f, 1.46595076e-01f, 1.32025443e-02f, -1.28344178e-01f, 6.91616237e-02f, -1.91919699e-01f,
  5.20665050e-01f, -3.08740169e-01f, 8.72706473e-02f, -2.60736030e-02f, -6.78361356e-02f, -5.28090633e-02f, -5.02674133e-02f, -1.71785755e-03f, -1.30040735e-01f, 4.53937203e-02f,
  -1.25660405e-01f, -1.12475634e-01f, -1.83083117e-02f, -6.54393658e-02f, -4.29032855e-02f, -1.72850918e-02f, -1.04793258e-01f, -1.15227647e-01f, 2.74094194e-02f, 8.96475390e-02f,
  -4.77897841e-03f, -6.91135898e-02f, -6.49641305e-02f, 2.23860592e-02f, 4.28020656e-02f, -1.52794262e-02f, -4.42160740e-02f, 3.10349017e-02f, 5.55254966e-02f, -1.04013450e-01f,
  3.23797092e-02f, -1.68517195e-02f, -4.89069447e-02f, -8.64719565e-04f, 8.07790607e-02f, 4.44684317e-03f, -1.21096931e-02f, 6.79312721e-02f, 7.78575912e-02f, 6.48352550e-04f,
  1.46917999e-02f, 1.40947308e-02f, 2.02845060e-03f, -1.22386776e-02f, 3.88279743e-02f, -4.76683378e-02f, 4.78750132e-02f, 2.21920535e-02f, -3.20428871e-02f, -6.71685189e-02f,
  -3.92523818e-02f, -5.28249927e-02f, -1.07494965e-01f, 2.49777567e-02f, 7.36502232e-03f, -3.09418347e-02f, 3.29626501e-02f, -5.45666404e-02f, -8.92464910e-03f, 3.08097224e-03f,
  1.75933138e-01f, -1.77875161e-01f, 1.01925477e-01f, -1.00781895e-01f, -8.97206217e-02f, -1.43129498e-01f, 8.83177109e-03f, -7.43901804e-02f, -5.91826923e-02f, -1.91784534e-03f,
  -3.37133184e-02f, -1.34392548e-03f, -5.27810417e-02f, -6.22923002e-02f, 5.89182489e-02f, -1.15231853e-02f, -3.74950394e-02f, 6.70406893e-02f, -1.44225538e-01f, 2.83747576e-02f,
  -1.58167654e-03f, 3.15961838e-02f, 1.68647572e-01f, 1.84077889e-01f, 8.15802068e-02f, 1.50757611e-01f, 1.55199036e-01f, 2.89303064e-02f, 4.00439762e-02f, 2.16745839e-01f,
  1.10775411e-01f, -2.43833184e-01f, -5.26144505e-01f, -1.80242494e-01f, -4.78085011e-01f, -3.37359637e-01f, -3.64326298e-01f, 7.91811571e-03f, 2.36877855e-02f, -2.28334993e-01f,
  -7.03173950e-02f, 2.71175772e-01f, 1.48820654e-01f, 1.24041423e-01f, 1.46600604e-01f, -2.87796706e-01f, -4.43121076e-01f, -5.29988185e-02f, 2.05520049e-01f, 2.32338831e-02f,
  2.21731700e-02f, -5.43165319e-02f, 3.26252542e-02f, 1.77446947e-01f, -1.95435703e-01f, -6.56734779e-02f, -3.04994762e-01f, -1.31929189e-01f, -1.13025285e-01f, -4.67557937e-01f,
  -9.45410356e-02f, -1.68680921e-01f, 1.01570738e-02f, 1.08529001e-01f, -1.86097860e-01f, 2.40725887e-04f, -1.37380967e-02f, 4.04875576e-02f, -2.59457603e-02f, -6.91721514e-02f,
  -5.21019585e-02f, 1.15682617e-01f, -3.40340100e-02f, 9.07748640e-02f, -1.09078370e-01f, 3.62486802e-02f, 6.93627372e-02f, 1.89947372e-03f, -1.05578713e-01f, -3.58718261e-02f,
  -7.63219297e-02f, -1.69848248e-01f, -2.39309624e-01f, -1.18827164e-01f, 9.35162243e-04f, -8.06294903e-02f, -1.47635683e-01f, -1.76806450e-02f, -6.22194745e-02f, 2.77230237e-02f,
  -3.37430090e-02f, -6.30394071e-02f, -2.87519507e-02f, -2.94070672e-02f, 6.97658956e-02f, -1.01619055e-02f, 3.50678340e-04f, -2.31495034e-02f, 4.66025397e-02f, -7.73602910e-03f,
  1.19682990e-01f, -5.79502806e-03f, -1.87857840e-02f, -1.16521925e-01f, 2.86901165e-02f, -1.05892383e-01f, -3.00479643e-02f, -2.01217015e-03f, 2.46190820e-02f, 2.42468789e-02f,
  -3.33071239e-02f, -7.45098665e-02f, -1.90577824e-02f, 1.10441998e-01f, -8.10269564e-02f, 4.17455547e-02f, -3.49708064e-03f, 2.36732699e-02f, 1.07394002e-01f, 1.24180010e-02f,
  3.96413267e-01f, -1.05301499e-01f, 8.55706632e-02f, 1.62236780e-01f, -1.78674031e-02f, -4.86778654e-02f, 3.03307660e-02f, 3.50378528e-02f, -6.01616164e-04f, 1.55338515e-02f,
  -3.22920009e-02f, 9.13560316e-02f, -9.07296874e-03f, 3.11060995e-03f, -2.68079201e-03f, -1.22706825e-02f, 9.44294259e-02f, 1.02167018e-03f, 9.22159851e-03f, 4.13561389e-02f,
  -1.17744885e-01f, 1.18852749e-01f, 1.33629262e-01f, 4.37797271e-02f, 7.38737658e-02f, 2.08887421e-02f, 1.17468752e-01f, -9.16323345e-03f, 5.46588115e-02f, 1.56334266e-01f,
  5.39154530e-01f, 4.63644713e-02f, 1.99614450e-01f, 1.04679761e-03f, 6.01618364e-02f, 9.37413722e-02f, 1.62001085e-02f, 5.64751998e-02f, -1.65146999e-02f, 6.22049980e-02f,
  1.85396031e-01f, 8.09453502e-02f, 1.34713620e-01f, 1.42410137e-02f, 1.60313621e-01f, -1.21854097e-01f, -1.04677528e-01f, 8.66026133e-02f, 1.82749525e-01f, -1.81718147e-03f,
  -2.14538574e-01f, -1.34481415e-01f, 1.43980505e-02f, 1.57536846e-02f, -1.74607143e-01f, 8.47157091e-02f, 5.04102409e-02f, -2.37293690e-02f, 4.86558788e-02f, -2.81353801e-01f,
  6.41779751e-02f, 2.12590113e-01f, 2.05501825e-01f, -2.47650724e-02f, 1.10856563e-01f, 8.22861493e-02f, 7.71738738e-02f, -5.22381812e-02f, -6.17861487e-02f, -3.78374830e-02f,
  -3.00698224e-02f, -5.98060153e-02f, 6.59829006e-02f, -1.52434230e-01f, 1.01234019e-02f, 3.11023701e-04f, -6.03560619e-02f, 9.22977477e-02f, 1.03462987e-01f, 3.01729459e-02f,
  1.78665612e-02f, -3.72446701e-02f, 9.90368575e-02f, 1.82746965e-02f, 1.34489089e-01f, 4.72866111e-02f, 1.31197702e-02f, 1.11352772e-01f, 9.22870338e-02f, 1.11778758e-01f,
  4.73532230e-02f, 9.37526971e-02f, 1.57323983e-02f, 8.35901797e-02f, 3.50964838e-03f, 2.38166805e-02f, -8.02862830e-03f, -5.53028844e-02f, 1.80622544e-02f, -1.00619920e-01f,
  6.07610345e-02f, 8.67478997e-02f, -4.08003144e-02f, -1.21246232e-02f, 5.86286411e-02f, -7.89339915e-02f, 3.61861801e-03f, -9.02236998e-02f, -4.02682424e-02f, -6.65427893e-02f,
  9.17064399e-02f, 1.09302118e-01f, -7.84968510e-02f, -1.19957596e-01f, 4.21983041e-02f, 5.86306788e-02f, -1.88742634e-02f, 2.00358126e-02f, -4.08730023e-02f, 7.95372110e-03f,
  -1.36824936e-01f, 3.61273259e-01f, 5.21380156e-02f, -3.18537056e-02f, -1.88264363e-02f, 1.64448489e-02f, 7.61876330e-02f, -1.48674715e-02f, -6.01111427e-02f, -1.48882404e-01f,
  -1.20607158e-02f, -7.10927369e-03f, -1.20035611e-01f, -5.33953086e-02f, -1.25789657e-01f, -1.05960004e-01f, -4.94132154e-02f, 4.31599356e-02f, -8.51324871e-02f, -8.01331177e-02f,
  -8.32910985e-02f, -9.63770822e-02f, -6.09636381e-02f, -4.03291769e-02f, 3.88491303e-02f, 1.18896604e-01f, 6.64628372e-02f, -6.12078700e-03f, -7.00863777e-03f, -1.34012207e-01f,
  4.08398300e-01f, -3.58527601e-01f, 2.43887454e-01f, 2.78476536e-01f, 3.00175101e-01f, 3.74510914e-01f, 2.47933522e-01f, 6.26117960e-02f, -7.41681783e-03f, 6.00328967e-02f,
  -1.41584933e-01f, -1.65472344e-01f, -1.61751330e-01f, -2.74631411e-01f, -8.69761780e-02f, 8.59979838e-02f, 8.81526023e-02f, -4.60889377e-02f, 1.94231972e-01f, 2.30895728e-03f,
  -9.45664495e-02f, -5.57598993e-02f, 2.06952891e-03f, -7.72720799e-02f, -1.32325694e-01f, -6.24046214e-02f, -5.59116639e-02f, 1.18510379e-02f, -1.21160388e-01f, -1.93449482e-01f,
  -7.97607526e-02f, 1.78755566e-01f, 1.11110806e-01f, -1.13515690e-01f, 4.17559268e-03f, 2.59529799e-02f, 1.14566265e-02f, -9.67560112e-02f, -4.92655523e-02f, 7.46282786e-02f,
  1.17914379e-01f, -4.60459031e-02f, 2.69968715e-02f, 6.89451247e-02f, 2.48165280e-02f, 1.25113428e-02f, -4.32441868e-02f, 2.05800589e-02f, -1.20429479e-01f, -9.15452838e-02f,
  -1.57004043e-01f, -1.28389113e-02f, 1.03828356e-01f, -3.86593156e-02f, -4.70408350e-02f, 8.33998993e-03f, -6.16429336e-02f, 6.07077368e-02f, 1.01841025e-01f, -9.75775346e-02f,
  -2.12996881e-02f, -7.38681061e-03f, -6.92834612e-04f, -3.54384370e-02f, -6.06527030e-02f, -1.68910697e-02f, 6.24322370e-02f, -2.19155774e-02f, -1.17345173e-02f, 1.57278832e-02f,
  -3.77488472e-02f, 6.98588714e-02f, 1.37762493e-02f, -4.48689185e-04f, -3.93656567e-02f, -4.94778119e-02f, 4.79951352e-02f, -6.72813728e-02f, 3.18787657e-02f, -2.61089262e-02f,
  -1.12376012e-01f, 4.27830629e-02f, 6.32453933e-02f, -1.13774195e-01f, -4.80203107e-02f, 8.73181876e-03f, 5.11799976e-02f, -8.80440697e-02f, 2.14652438e-02f, 6.36869296e-02f,
  -3.08204174e-01f, 2.11899932e-02f, 6.30486906e-02f, -1.10318117e-01f, 9.13682953e-02f, -1.23392388e-01f, -6.09572493e-02f, -1.60913467e-02f, 3.28184664e-02f, -3.41431089e-02f,
  3.09903491e-02f, 8.09854642e-03f, -4.47908118e-02f, 4.91748899e-02f, 1.13052912e-01f, 8.26741308e-02f, -4.47489507e-02f, 1.61335301e-02f, -2.78261863e-03f, -3.51233557e-02f,
  -1.14941657e-01f, 1.05680481e-01f, 7.57464841e-02f, 4.08001170e-02f, 2.77873334e-02f, 7.03201070e-02f, -1.43925194e-02f, 8.05185661e-02f, 5.24368472e-02f, 4.03623423e-03f,
  2.77713716e-01f, -3.93860251e-01f, -9.79068279e-02f, 5.38343238e-03f, -1.45482332e-01f, -1.94737464e-02f, -6.17773011e-02f, 9.65615585e-02f, 6.03358448e-02f, -1.94122523e-01f,
  1.49643999e-02f, 1.87689319e-01f, 2.35648692e-01f, 1.26736239e-01f, 1.81329504e-01f, -2.09516466e-01f, -1.85319349e-01f, 4.52564843e-02f, 3.34812015e-01f, 2.03399211e-01f,
  8.57581273e-02f, 5.01942299e-02f, 2.09737703e-01f, 1.04753099e-01f, -1.95729733e-01f, 1.20058335e-01f, -9.74740610e-02f, -1.63167819e-01f, -2.03565449e-01f, -4.98451650e-01f,
  -3.64273667e-01f, -2.55907565e-01f, 2.05693185e-01f, -1.79929882e-02f, -7.65083581e-02f, 8.20745379e-02f, -1.79789141e-02f, -4.81793769e-02f, 7.13028759e-02f, -1.05229832e-01f,
  -7.39702210e-02f, 3.31792273e-02f, 6.96066916e-02f, 3.23446132e-02f, -1.62460525e-02f, -6.72995895e-02f, -8.58080164e-02f, 5.97313605e-02f, 8.19736868e-02f, -7.25560188e-02f,
  -7.19184354e-02f, -1.78371996e-01f, -9.54699144e-02f, -4.78656702e-02f, -7.37953484e-02f, -9.04041994e-03f, -2.04392016e-01f, -7.79961348e-02f, -3.47054680e-03f, -3.17253947e-01f,
  5.26313484e-02f, -8.57145898e-03f, 6.82487935e-02f, -1.08121270e-02f, 6.88265124e-03f, 5.63296117e-02f, -5.80016663e-03f, -6.14071675e-02f, -3.21093015e-02f, -1.18692391e-01f,
  1.15871727e-02f, -9.93216224e-03f, 5.66662252e-02f, 6.90388605e-02f, -6.89912960e-02f, 3.67668420e-02f, -6.27738386e-02f, -1.84709802e-02f, 2.15852298e-02f, 6.22979291e-02f,
  4.30928171e-02f, 1.16179623e-02f, -5.40392585e-02f, 7.22971931e-02f, 6.19108789e-02f, 1.09043363e-02f, 9.62058362e-03f, -6.72585797e-03f, 5.88528365e-02f, -1.51627967e-02f,
  9.70291719e-02f, 2.19207942e-01f, -6.43801019e-02f, 7.87466466e-02f, 1.11214966e-02f, 7.74771050e-02f, -6.40857145e-02f, 2.23871041e-03f, 7.67560527e-02f, 1.40834972e-02f,
  3.68903093e-02f, 6.47196025e-02f, -2.68587917e-02f, -7.86208827e-03f, 3.49031538e-02f, 1.24849811e-01f, -1.00937657e-01f, 7.48045444e-02f, 8.10553953e-02f, -1.76802967e-02f,
  5.14926091e-02f, 5.73638044e-02f, 5.29964678e-02f, 2.84895748e-02f, -5.20644635e-02f, 1.36802644e-01f, -3.21171619e-02f, -3.32861133e-02f, 5.84391132e-02f, 1.53138989e-03f,
  -5.30841470e-01f, 5.81620261e-02f, -6.83569685e-02f, -3.38746160e-01f, 1.07894033e-01f, 2.73968667e-01f, 2.46562913e-01f, 1.64817229e-01f, -3.66270393e-02f, -2.22380459e-02f,
  -9.57816616e-02f, -1.53018370e-01f, -2.48948157e-01f, 2.25987844e-02f, -1.06609218e-01f, 1.07142657e-01f, -1.58448488e-01f, -2.47211367e-01f, -1.26693264e-01f, -4.02051993e-02f,
  -1.69796199e-02f, -3.53773564e-01f, -3.51440191e-01f, -2.11955175e-01f, -1.19395860e-01f, -1.44981071e-01f, -8.01659003e-02f, -2.47675195e-01f, 4.28563766e-02f, -6.35196045e-02f,
  -4.24281769e-02f, 1.51724651e-01f, 1.13605253e-01f, -1.47524625e-01f, -3.17228921e-02f, -6.61089942e-02f, -8.57478902e-02f, 2.89656203e-02f, -8.11636299e-02f, -6.00040108e-02f,
  -8.56687278e-02f, 7.65357539e-02f, -2.96843350e-02f, -5.92164546e-02f, -5.93737997e-02f, 6.82630241e-02f, -2.63765957e-02f, -3.19916420e-02f, 6.64989650e-02f, 8.03262442e-02f,
  1.49180237e-02f, -2.46643578e-03f, 1.17555438e-02f, 4.73689362e-02f, 1.21867880e-01f, -1.05295092e-01f, 9.01845191e-03f, -5.84070152e-03f, 3.04477960e-02f, 4.15788032e-02f,
  1.69711597e-02f, 5.91876097e-02f, 4.22828123e-02f, -1.03062659e-03f, -7.41364732e-02f, 1.94859803e-02f, -3.42812575e-02f, -6.02225997e-02f, -2.70669423e-02f, -4.23726812e-02f,
  1.00330822e-01f, 3.81352119e-02f, -8.30665510e-03f, -6.56416193e-02f, -4.38066795e-02f, 3.61283449e-03f, -3.51420720e-03f, -8.66048187e-02f, -7.57727996e-02f, 3.18530798e-02f,
  -4.92974743e-03f, -2.01139953e-02f, -4.15028259e-02f, 3.74002295e-04f, -5.89088816e-03f, -2.71209963e-02f, 4.17512767e-02f, 7.75052905e-02f, 8.81581604e-02f, 8.73136073e-02f,
  -2.57986546e-01f, 1.24060318e-01f, -1.27607688e-01f, 3.13815922e-02f, -5.43581769e-02f, -1.67388301e-02f, -1.02101810e-01f, 1.93206538e-02f, -4.88677248e-02f, -1.28291631e-02f,
  -4.70162705e-02f, 1.10885017e-02f, -8.51784870e-02f, 4.09241691e-02f, 3.03587057e-02f, 4.72945273e-02f, -4.92188521e-02f, -1.03860795e-01f, 1.82082299e-02f, -1.99415665e-02f,
  -1.14756554e-01f, -4.24141437e-02f, -1.11591920e-01f, 5.38051650e-02f, -2.06218176e-02f, -1.00800216e-01f, -4.79494631e-02f, 5.70874335e-03f, 5.15898988e-02f, -1.81826413e-01f,
  -2.75080502e-01f, 5.71114540e-01f, 1.87769875e-01f, 2.06122652e-01f, 2.67982572e-01f, 2.76379138e-01f, 7.71455646e-01f, 3.30622256e-01f, -5.77717610e-02f, 7.24332407e-02f,
  4.81515378e-02f, -1.24869987e-01f, -1.49930298e-01f, 2.13881843e-02f, 2.35231310e-01f, 2.50842154e-01f, 2.00634941e-01f, -3.05108875e-02f, -1.37741670e-01f, -5.60658611e-03f,
  7.48649985e-02f, -1.82511881e-02f, -9.55373645e-02f, -4.15783413e-02f, 2.05404282e-01f, -1.50421605e-01f, 5.47974929e-03f, 1.69001922e-01f, 5.99148870e-03f, 9.29076746e-02f,
  -1.89043581e-01f, 3.31727684e-01f, -2.95388281e-01f, -1.63553208e-01f, -4.33653034e-02f, -1.31704986e-01f, -5.56910969e-02f, -1.01877034e-01f, -4.97827977e-02f, -4.57231589e-02f,
  -2.80287694e-02f, -1.70004591e-02f, 1.48892045e-01f, 6.64216420e-03f, 3.20194028e-02f, -1.22355083e-02f, 1.06523879e-01f, 5.87050356e-02f, -8.04144051e-03f, 2.12677079e-03f,
  1.51018977e-01f, 5.98615892e-02f, 6.60193563e-02f, 6.10110611e-02f, 1.85585827e-01f, -1.19722702e-01f, 1.13018684e-01f, 2.09059399e-02f, -1.94779690e-02f, -4.73099714e-03f,
  -1.63517948e-02f, -4.37749550e-03f, 3.95367444e-02f, 1.36125553e-02f, -1.02190245e-02f, -2.07402799e-02f, -2.91945017e-03f, -6.65876549e-03f, 2.17879582e-02f, 3.91133055e-02f,
  -3.19498889e-02f, -3.83438095e-02f, 6.70369575e-03f, 6.61376342e-02f, 2.17179265e-02f, 5.85465208e-02f, 6.92740455e-03f, 4.02511247e-02f, -7.78861791e-02f, -3.28297541e-03f,
  2.54553091e-02f, -6.91914484e-02f, -8.53154808e-03f, 1.42343491e-01f, 6.59079179e-02f, 5.59819378e-02f, 7.73120373e-02f, -1.88699774e-02f, 1.07218541e-01f, -2.79094018e-02f,
  -2.80343950e-01f, 7.08343163e-02f, -1.19199216e-01f, -4.56921000e-04f, -1.23661757e-02f, -1.00074440e-01f, 6.36414485e-03f, -8.98440778e-02f, -4.02614474e-02f, -7.07435282e-03f,
  5.11219651e-02f, -9.27626994e-03f, 7.71015733e-02f, 1.36756273e-02f, -5.02279587e-02f, -6.72703683e-02f, -4.18949611e-02f, -2.59645637e-02f, -7.51605406e-02f, -8.94420296e-02f,
  5.55478111e-02f, -1.76104501e-01f, -2.67841220e-01f, -7.97636136e-02f, 3.84459384e-02f, -2.19690144e-01f, -8.56965035e-02f, -1.38714954e-01f, -1.22779265e-01f, -2.76209563e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.52452600e-01f, 8.10204074e-02f, 1.14875913e-01f, 1.52993098e-01f, 4.02685165e-01f, 5.89239225e-02f, -1.00038923e-01f, 3.97943944e-01f, 2.74836319e-03f, 1.35373116e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.39673674e-01f, -2.07346439e-01f, -6.53768703e-02f, 5.13728797e-01f, -3.23356569e-01f, -4.38586950e-01f, 1.08590908e-01f, 2.04948172e-01f, 1.74845189e-01f, -3.73978347e-01f,
  -3.91782403e-01f, -3.28315288e-01f, -5.88263094e-01f, 1.29405679e-02f, 2.27423370e-01f, 1.64697900e-01f, 8.10616240e-02f, 1.63891241e-01f, -2.05583349e-01f, 3.11619073e-01f,
  5.32574177e-01f, 2.04601344e-02f, -2.59192258e-01f, 1.62566409e-01f, 3.79393101e-01f, -3.69158566e-01f, -2.46984381e-02f, -4.63730127e-01f, -1.25973448e-01f, -4.58267123e-01f,
  4.45167385e-02f, 5.03324151e-01f, -1.11050114e-01f, -1.57030284e-01f, -1.17399484e-01f, 4.35721695e-01f, 2.32214164e-02f, -2.00770795e-01f, -1.30124554e-01f, -3.06261003e-01f,
  2.96113133e-01f, -9.08855125e-02f, -3.73942912e-01f, 1.49336264e-01f, -2.34050557e-01f, -6.76660359e-01f, 5.52232563e-01f, 1.25290886e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.46035025e-01f, 3.70411277e-01f, 3.61871511e-01f, 6.67457208e-02f, -1.87796101e-01f, 3.61772269e-01f, 4.61016506e-01f, -1.77450195e-01f, 3.65958452e-01f, 1.87955737e-01f,
  -2.36353815e-01f, -3.24950576e-01f, 2.01854676e-01f, -1.19654410e-01f, -5.56132719e-02f, -1.70984522e-01f, -1.23670869e-01f, 2.54432738e-01f, 8.44837576e-02f, 3.98990542e-01f,
  2.31947750e-02f, 3.64022136e-01f, 4.98870641e-01f, 2.75288075e-01f, -1.70409277e-01f, 4.04713377e-02f, 4.18837041e-01f, 4.12235022e-01f, 1.53948292e-01f, 2.41361648e-01f,
  9.37579423e-02f, -2.24884570e-01f, -1.19908884e-01f, 4.08665948e-02f, 1.99347481e-01f, -9.15830955e-02f, 1.70848608e-01f, 5.23738563e-01f, 3.88944559e-02f, 9.18681845e-02f,
  1.23317853e-01f, 1.40984759e-01f, -2.02715799e-01f, -1.30225673e-01f, 1.82179898e-01f, 2.45434985e-01f, -2.37442311e-02f, -1.43163070e-01f, 1.57611802e-01f, 4.17121202e-01f,
  4.76340532e-01f, 1.25859201e-01f, 2.81681240e-01f, 1.78168669e-01f, 3.57412428e-01f, -2.29140684e-01f, 7.46914387e-01f, -3.77234250e-01f, 4.81048301e-02f, -1.86777413e-02f,
  -2.98961759e-01f, -4.31543648e-01f, 2.78194956e-02f, 3.00447464e-01f, 2.26985112e-01f, -1.41021311e-01f, 2.70482510e-01f, -2.76207060e-01f, -1.36898100e-01f, -3.01958054e-01f,
  3.86167914e-02f, -2.36392878e-02f, -1.94483340e-01f, -2.48611849e-02f, -8.93794745e-02f, -2.69940645e-01f, 1.47097662e-01f, -1.60050556e-01f, 1.64842680e-01f, 2.60567307e-01f,
  3.47268224e-01f, 2.77438425e-02f, 5.32884836e-01f, -2.25379586e-01f, -5.53169787e-01f, -6.81649745e-01f, 1.55171230e-01f, -4.16068919e-02f, -1.63115095e-02f, 1.44084379e-01f,
  4.49089438e-01f, -3.23349446e-01f, -2.80178517e-01f, -1.41463101e-01f, 7.68035293e-01f, -4.03310478e-01f, 4.57945049e-01f, -4.02450822e-02f, 4.05122280e-01f, 1.76546723e-01f,
  -6.88006818e-01f, -5.65414906e-01f, 5.41334808e-01f, 2.77336538e-01f, -3.40235889e-01f, 5.56363225e-01f, 1.83078095e-01f, -1.70428678e-01f, -2.88192213e-01f, 2.03208670e-01f,
  4.00711119e-01f, 6.17185712e-01f, 2.12738544e-01f, 4.44116056e-01f, -5.32634631e-02f, 4.67511825e-02f, 2.05622301e-01f, -7.34740317e-01f, 4.82647091e-01f, 1.58120930e-01f,
  6.06495403e-02f, -5.14316916e-01f, 6.24639452e-01f, -9.36762430e-03f, -2.98713505e-01f, 3.93654943e-01f, 1.98442459e-01f, -2.66493440e-01f, 8.81260395e-01f, 4.85546112e-01f,
  5.41118801e-01f, -3.63764286e-01f, 7.60908365e-01f, 4.34071600e-01f, 1.57569048e-05f, 1.30033463e-01f, -3.39995801e-01f, 3.24326038e-01f, 1.02586603e+00f, 1.64778918e-01f,
  3.31614673e-01f, 6.68247402e-01f, -2.37576976e-01f, 9.21384633e-01f, 2.75459081e-01f, 3.03056091e-01f, 1.03578143e-01f, 3.94245058e-01f, -1.01376757e-01f, 2.08199009e-01f,
  5.37281811e-01f, 3.83900285e-01f, -1.25828302e-02f, 1.35975964e-02f, 3.55698079e-01f, 4.65100795e-01f, -1.82657555e-01f, 2.37843364e-01f, -1.28712624e-01f, -2.73677826e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  7.13039413e-02f, -1.23370141e-01f, 5.60967959e-02f, 4.66604501e-01f, -9.65530127e-02f, 3.58714908e-01f, 2.29411736e-01f, 5.78755856e-01f, 4.98889744e-01f, -1.21706478e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  8.03753734e-02f, 5.39424410e-03f, -4.01284337e-01f, 3.00152928e-01f, -6.35614991e-01f, -3.23919475e-01f, -1.09427974e-01f, -4.94173884e-01f, -3.71557623e-01f, -1.23848118e-01f,
  3.42562228e-01f, 5.10049403e-01f, 9.29367468e-02f, 4.68999237e-01f, -5.77145159e-01f, -1.37171566e-01f, 5.56718647e-01f, -1.36750743e-01f, -1.58560127e-01f, 3.93891297e-02f,
  -4.73077804e-01f, 6.29019499e-01f, -4.71186161e-01f, -1.15315445e-01f, -4.19450760e-01f, -1.95445865e-01f, -1.06496982e-01f, 2.58946359e-01f, 6.21112168e-01f, 1.33002371e-01f,
  -1.26944870e-01f, 1.55298606e-01f, -9.81860831e-02f, -3.07490919e-02f, 1.72643997e-02f, 6.08703613e-01f, -1.37747386e-02f, -2.62344539e-01f, -9.29476991e-02f, -2.87927717e-01f,
  -3.12647164e-01f, -1.52213365e-01f, 4.39326525e-01f, 3.84437025e-01f, 5.25928855e-01f, 4.22089458e-01f, -6.25926197e-01f, -2.39961103e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.05100656e-01f, -2.00442642e-01f, 4.77620751e-01f, -2.59775370e-01f, 9.98695076e-01f, 8.69894505e-01f, -2.02854902e-01f, -3.67120475e-01f, -7.81579763e-02f, 6.94508851e-01f,
  1.80180490e-01f, -6.12113297e-01f, -9.57864597e-02f, -5.87388985e-02f, 1.26546168e+00f, -5.04060388e-01f, 5.72950542e-01f, 2.89709419e-01f, 7.41988003e-01f, 9.37683403e-01f,
  3.42975020e-01f, 7.69165635e-01f, 5.03032267e-01f, 1.11664020e-01f, -1.38946563e-01f, 6.81439877e-01f, -1.25944123e-01f, 5.90716302e-01f, 6.99918866e-01f, 2.32325792e-01f,
  -4.88648295e-01f, 2.68890798e-01f, 5.43549061e-01f, 2.11765543e-01f, 1.34401545e-01f, 3.15057218e-01f, 1.18701212e-01f, 6.54807836e-02f, 2.98563362e-04f, 4.07707840e-01f,
  -1.47430763e-01f, 2.09814012e-01f, -1.63073257e-01f, -2.52838314e-01f, 3.07514489e-01f, 8.58791709e-01f, 3.76132220e-01f, 7.34566927e-01f, 6.86240315e-01f, 8.48133743e-01f,
  5.18237650e-01f, -2.36968860e-01f, 5.68856478e-01f, -5.96332014e-01f, 2.38713503e-01f, 1.95054132e-02f, 1.83119327e-01f, 6.66582763e-01f, -7.53800049e-02f, -1.22809768e-01f,
  -6.33705974e-01f, 5.94436109e-01f, 3.25173438e-01f, 6.69074827e-04f, -1.16968073e-01f, 4.01365757e-02f, -3.64548564e-02f, 4.06300694e-01f, 4.81876023e-02f, 1.70074061e-01f,
  -1.10964708e-01f, -1.90317795e-01f, -2.03247026e-01f, 3.13822508e-01f, 1.41851172e-01f, 4.40878451e-01f, -1.92981362e-02f, 1.51879162e-01f, -7.90234953e-02f, 2.01357733e-02f,
  2.25458533e-01f, 3.05006921e-01f, 2.44314462e-01f, -6.47024140e-02f, -3.68960828e-01f, -4.10366178e-01f, -2.16873109e-01f, -2.53918231e-01f, 5.49702197e-02f, 6.65981323e-02f,
  -3.80622745e-02f, 7.79765725e-01f, 3.94737482e-01f, 4.89508986e-01f, -2.73371071e-01f, -6.22489750e-02f, -5.82492292e-01f, 5.19148827e-01f, -1.53831795e-01f, -3.15258354e-01f,
  -1.00151169e+00f, -7.17886984e-01f, -1.05095245e-02f, -2.56897956e-02f, 1.61676437e-01f, -2.39088073e-01f, 1.42101586e-01f, 5.51687360e-01f, 9.64815021e-01f, -9.57066119e-02f,
  1.06933284e+00f, -4.51517627e-02f, -4.83794570e-01f, 5.33553600e-01f, -2.31437653e-01f, -3.09765548e-01f, -4.49009269e-01f, -4.52786833e-01f, -9.64938551e-02f, 3.18890899e-01f,
  -6.48758262e-02f, -1.64953619e-01f, -1.27838448e-01f, 4.57260013e-02f, 3.21069658e-02f, 3.27180833e-01f, 6.90810740e-01f, 3.38715911e-01f, -2.94492215e-01f, 1.43649787e-01f,
  -1.25110611e-01f, -4.89796558e-03f, -4.21271592e-01f, 4.32009883e-02f, 1.15103349e-01f, -2.30648950e-01f, 2.87319832e-02f, -2.31581014e-02f, 9.69420075e-02f, -1.32993162e-02f,
  -2.10732192e-01f, 1.68039039e-01f, 5.08833230e-01f, -1.84863672e-01f, 9.18220058e-02f, -2.01101735e-01f, -3.02736729e-01f, -2.28542328e-01f, 1.25824800e-02f, -7.25553855e-02f,
  -2.95372099e-01f, 2.89482355e-01f, 8.58611837e-02f, -7.88964215e-04f, -5.64681813e-02f, 3.87140751e-01f, 9.82428994e-03f, 3.60883623e-01f, 1.53083935e-01f, 2.12387070e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.54068786e-01f, 6.71567321e-01f, 1.25958815e-01f, 5.33972204e-01f, 2.25621909e-02f, 4.54946831e-02f, 3.08258146e-01f, 2.36740291e-01f, -1.87607080e-01f, -2.35142037e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -8.97558928e-02f, -4.11150336e-01f, -9.73189250e-02f, 6.40026093e-01f, -1.92927286e-01f, 5.84076166e-01f, -6.49127007e-01f, -3.03976923e-01f, 4.68487948e-01f, -2.32826963e-01f,
  -4.21150438e-02f, 1.54393360e-01f, 1.96476534e-01f, 3.35035622e-01f, -1.30546793e-01f, 5.66409469e-01f, -4.93352354e-01f, 5.12602508e-01f, -3.27962458e-01f, 1.34538382e-01f,
  -2.52821863e-01f, 6.00523114e-01f, 8.44690651e-02f, -6.52383149e-01f, 3.09405744e-01f, -5.45197546e-01f, -2.31145576e-01f, -4.90467906e-01f, 3.31032723e-01f, 5.80194771e-01f,
  3.97998303e-01f, 3.21573704e-01f, -2.43621185e-01f, 2.91947216e-01f, 1.22000575e-01f, -7.61708975e-01f, -5.17151244e-02f, -8.03722978e-01f, -7.20047355e-01f, 1.05715409e-01f,
  5.72082639e-01f, 8.05924833e-01f, -4.47117776e-01f, -9.75090340e-02f, -1.36211932e-01f, 2.78423019e-02f, -2.10146412e-01f, -3.27095807e-01f, -4.53917027e-01f, -1.19338334e-01f,
  -3.89510006e-01f, 6.40291214e-01f, 2.27866441e-01f, 7.00820833e-02f, -5.35474062e-01f, 8.73732626e-01f, -4.25560832e-01f, -5.91310740e-01f, 2.80040413e-01f, 6.89976454e-01f,
  1.82592273e-01f, -3.23342234e-01f, -2.20176280e-01f, 1.70832372e-03f, 2.54144520e-01f, -7.34082282e-01f, -3.86510909e-01f, 6.94064438e-01f, 8.32433343e-01f, 1.00696909e+00f,
  -1.97169885e-01f, 5.83050907e-01f, 3.39941502e-01f, 4.01566595e-01f, 3.84615928e-01f, 3.70711148e-01f, -4.37391281e-01f, -2.39567272e-02f, 1.74827408e-02f, -7.91685935e-03f,
  8.46868515e-01f, 6.78964674e-01f, 4.04670477e-01f, -1.99395735e-02f, 1.65857658e-01f, -3.75876546e-01f, -4.12596650e-02f, -8.33919585e-01f, -5.02165854e-02f, 6.32563889e-01f,
  -3.15484330e-02f, 3.30158114e-01f, 3.95411432e-01f, 1.48084939e-01f, 5.41895032e-02f, -2.73439717e-02f, -6.37281835e-01f, 3.84065270e-01f, -6.94252670e-01f, -7.49021545e-02f,
  -5.35953164e-01f, -5.62060535e-01f, 1.13828456e+00f, 2.78408676e-01f, -6.62922487e-02f, 2.95254916e-01f, 6.12848327e-02f, -3.75577182e-01f, -1.20525360e+00f, -7.32518792e-01f,
  -3.06931615e-01f, 2.04291284e-01f, 4.74085100e-02f, -2.55454853e-02f, 3.01850021e-01f, -4.61842895e-01f, 6.58767223e-01f, 1.82953805e-01f, 5.52150965e-01f, 4.15285349e-01f,
  3.17023963e-01f, -8.03915858e-01f, 2.00970471e-02f, -4.18203473e-01f, 3.36010247e-01f, -3.66624564e-01f, -2.39115000e-01f, -2.01499239e-01f, -3.31987113e-01f, -9.66654718e-01f,
  -6.69379532e-01f, -5.19282699e-01f, -1.33774757e+00f, 1.01370388e-03f, -5.78606091e-02f, -4.89798218e-01f, -8.95008266e-01f, -1.90913975e-01f, 1.69539992e-02f, -3.38204414e-01f,
  7.87049055e-01f, 4.50102866e-01f, 3.41597974e-01f, -4.12224263e-01f, 4.38958019e-01f, 4.81518418e-01f, 9.73754168e-01f, -3.10579449e-01f, 1.67288750e-01f, -6.53677955e-02f,
  5.54178134e-02f, 1.20910227e+00f, 8.99990499e-02f, 2.99288303e-01f, 7.13766087e-03f, -2.31561914e-01f, -8.08087230e-01f, -6.03586495e-01f, 9.19577479e-02f, -2.29715869e-01f,
  6.34671867e-01f, -1.97648063e-01f, 4.46756363e-01f, 5.22616327e-01f, 8.28640223e-01f, -1.13822810e-01f, -9.48078096e-01f, -2.41403624e-01f, -4.73196238e-01f, -7.61788249e-01f,
  -2.01180294e-01f, 1.85457960e-01f, 1.08097148e+00f, 9.72024575e-02f, 1.40993342e-01f, 7.63090281e-03f, -4.76147793e-02f, 3.83026987e-01f, -2.33999878e-01f, 9.34690237e-02f,
  -3.51721853e-01f, 1.27348885e-01f, 1.11454821e+00f, -6.58496976e-01f, -2.43153423e-01f, 3.16672385e-01f, -9.39598605e-02f, -1.53519139e-01f, -1.17729455e-01f, -1.93115592e-01f,
  -1.17949158e-01f, 9.98509452e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.87620473e-01f, -4.56309170e-01f, 3.38190973e-01f, -4.38578241e-02f, -4.08166274e-02f, 2.90751606e-01f, 2.84267157e-01f, -1.31842121e-01f, 1.63212165e-01f, 1.69519261e-01f,
  -7.28261657e-03f, -3.58089469e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    