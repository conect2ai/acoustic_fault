/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.68261671e-01f, -3.91001761e-01f, 1.44582182e-01f, -6.73761219e-02f, 8.16505775e-02f, 3.26746255e-01f, 3.64775062e-01f, 5.57843521e-02f, 4.77262400e-03f, -1.70553580e-01f,
  -1.64855257e-01f, -1.72144413e-01f, -1.26172751e-01f, -1.11416347e-01f, 2.01196790e-01f, 3.72245349e-02f, -9.82896658e-04f, 1.35351360e-01f, 4.42273080e-01f, 2.93640047e-01f,
  -8.30019191e-02f, -6.43121451e-02f, 5.85815497e-02f, 1.16896227e-01f, -1.15766235e-01f, -1.33681402e-01f, -1.58932954e-01f, 4.35379967e-02f, 2.95791868e-02f, -4.91442591e-01f,
  -4.56328951e-02f, 4.61400896e-02f, 1.45880803e-01f, -5.48611097e-02f, -5.93807586e-02f, 3.65775451e-02f, 8.25157911e-02f, -2.54568420e-02f, 4.50336374e-03f, 8.36060345e-02f,
  2.08768751e-02f, -3.54250241e-03f, 1.19812988e-01f, -8.59708786e-02f, 1.78143363e-02f, 2.33802982e-02f, -5.96745731e-03f, 4.39034812e-02f, 7.17380866e-02f, -2.69236397e-02f,
  -5.35168238e-02f, 1.20732926e-01f, 1.21503271e-01f, 5.06659746e-02f, 9.21758264e-02f, -2.85963081e-02f, -4.01089303e-02f, 1.18413083e-01f, 8.11142623e-02f, -1.52989611e-01f,
  -5.45529500e-02f, 2.17544492e-02f, -7.09591201e-03f, -2.78373826e-02f, -4.19024080e-02f, 6.62629232e-02f, -9.83720645e-03f, -4.19903249e-02f, -4.60629351e-02f, -4.98885922e-02f,
  -2.47841664e-02f, -3.47069055e-02f, -5.37685007e-02f, 2.46667359e-02f, -6.57989681e-02f, 1.04147010e-02f, 2.85463054e-02f, -7.52803609e-02f, -3.17865126e-02f, -2.56073307e-02f,
  -3.91343795e-02f, 1.08424313e-01f, -2.82481182e-02f, 7.36591546e-03f, -4.35676798e-02f, -9.91490111e-03f, -1.63907539e-02f, -6.55319467e-02f, -7.55661260e-03f, 1.03511810e-01f,
  -3.52725480e-03f, 9.80880633e-02f, -5.06009795e-02f, 5.27874529e-02f, 5.50664542e-03f, -3.13085392e-02f, -1.05979517e-01f, 4.60416786e-02f, -2.07069945e-02f, 8.66422504e-02f,
  1.16526164e-01f, 4.09363620e-02f, -3.31871882e-02f, -1.58149190e-02f, 2.26419307e-02f, -2.86751427e-02f, -1.52121127e-01f, -7.28008822e-02f, 8.51167813e-02f, 9.23741888e-03f,
  -5.29858842e-03f, 6.27268776e-02f, -5.45165539e-02f, -2.40266360e-02f, 5.12863025e-02f, 1.68084249e-01f, 3.26754339e-02f, 9.30347666e-03f, 2.01818362e-01f, -8.64659697e-02f,
  -5.40996730e-01f, -1.93478733e-01f, 6.84930608e-02f, -2.17395589e-01f, 8.57368633e-02f, 8.80123749e-02f, 2.46257838e-02f, -3.98235954e-02f, -1.60544261e-01f, -1.86854854e-01f,
  -8.33704486e-04f, 2.43924007e-01f, 2.19973773e-01f, 2.90500045e-01f, 1.62470818e-01f, -9.77923274e-02f, -2.87871361e-02f, 1.61638364e-01f, 1.89958587e-01f, 1.15702771e-01f,
  1.33744225e-01f, -1.41685575e-01f, -6.58138841e-02f, 1.65730584e-02f, -3.44701737e-01f, -4.10181796e-03f, -1.35336831e-01f, -1.60273045e-01f, 8.87436792e-02f, -1.77603275e-01f,
  4.25572656e-02f, -2.41698250e-01f, 2.24410862e-01f, 4.66826372e-02f, 2.43818555e-02f, -8.70982632e-02f, 1.34846643e-02f, -5.64580299e-02f, -4.06597275e-03f, -1.23162553e-01f,
  2.42750011e-02f, -2.87115946e-02f, -4.04945798e-02f, -3.83826680e-02f, -7.09031522e-03f, -6.29787147e-02f, -1.25316188e-01f, -2.61262208e-02f, 8.26529339e-02f, -6.31670579e-02f,
  7.41080344e-02f, 4.04164307e-02f, 6.00598082e-02f, 1.56931505e-01f, 1.12079889e-01f, 1.95016339e-01f, -2.46171374e-02f, 6.95952168e-03f, 1.16892748e-01f, -2.45169491e-01f,
  4.37817648e-02f, -4.59131710e-02f, 5.90293668e-02f, -2.83571724e-02f, 2.82487031e-02f, 1.50443232e-02f, -2.70414520e-02f, 5.98719940e-02f, -2.80731474e-03f, -1.72532946e-02f,
  1.63012780e-02f, 4.14656587e-02f, 6.88557178e-02f, -8.55489969e-02f, 2.71869879e-02f, -1.65485498e-02f, -8.79180618e-03f, -2.57457756e-02f, 5.71566634e-02f, -2.88949832e-02f,
  5.10842875e-02f, -1.27121629e-02f, 1.11156162e-02f, -1.28672114e-02f, 2.19471045e-02f, 2.08975952e-02f, -9.12765320e-03f, 3.28539163e-02f, -5.87384477e-02f, -7.89656565e-02f,
  -9.36640948e-02f, 3.56411695e-01f, -1.36934772e-01f, -8.22718367e-02f, 5.24869747e-02f, -2.70055849e-02f, 3.21351737e-02f, -4.76686144e-03f, -5.30078150e-02f, -1.94544215e-02f,
  2.16422323e-02f, -4.53614853e-02f, 1.12499734e-02f, 6.32333010e-02f, 6.01781532e-02f, -5.34680858e-03f, 5.11203371e-02f, -1.05806813e-02f, -9.73745700e-05f, -1.40775785e-01f,
  -8.98666084e-02f, -3.03073488e-02f, 1.08860686e-01f, 1.02701019e-02f, -4.89445105e-02f, 3.69522236e-02f, 5.83569594e-02f, -4.15718183e-02f, 1.69833049e-01f, -7.18417764e-02f,
  6.11405730e-01f, 2.75855124e-01f, 3.08158368e-01f, 1.92610696e-02f, -2.19361961e-01f, -8.04977566e-02f, 5.54667599e-02f, -1.81895077e-01f, -7.71381706e-02f, 1.57193884e-01f,
  -1.81568876e-01f, -1.79568410e-01f, -4.52654324e-02f, -1.86280519e-01f, 3.82129438e-02f, 2.52619356e-01f, 2.16804445e-01f, 2.24816009e-01f, -4.25306298e-02f, -1.81671694e-01f,
  -1.19750656e-01f, 1.67605996e-01f, 1.53491259e-01f, -4.57979627e-02f, -5.62846661e-02f, -2.05105603e-01f, 4.04274166e-02f, 3.73075046e-02f, -2.39861663e-02f, 1.70082882e-01f,
  3.88239741e-01f, 1.51704714e-01f, -1.40331388e-01f, 1.77372135e-02f, -5.88954240e-03f, 1.10825943e-02f, 7.11091980e-02f, 1.14142530e-01f, -4.27367212e-03f, 1.01085410e-01f,
  -4.27707173e-02f, -2.84789670e-02f, 1.01137972e-02f, -2.40641348e-02f, 6.01874366e-02f, -2.67180670e-02f, -5.27145639e-02f, 1.63918823e-01f, 1.34433120e-01f, -4.12071720e-02f,
  -6.98362589e-02f, -3.60876806e-02f, 3.21647450e-02f, 2.69033611e-02f, 2.41787750e-02f, -3.58197577e-02f, 3.82197239e-02f, -1.45450652e-01f, -9.98702133e-04f, 5.57204336e-02f,
  1.34431552e-02f, -4.28761775e-03f, -1.91924628e-02f, 4.06825058e-02f, -1.14658521e-02f, -3.14956941e-02f, 5.69916740e-02f, 7.30575202e-03f, -2.24148780e-02f, 3.93060297e-02f,
  -5.84791750e-02f, 6.14187866e-02f, -9.41367645e-04f, 5.71664162e-02f, -2.43697111e-02f, 2.32137386e-02f, 1.80862043e-02f, 2.12526917e-02f, 1.84961334e-02f, -1.23276826e-04f,
  -2.91574579e-02f, -4.53133248e-02f, -8.23614281e-03f, -3.79886664e-02f, -1.64513793e-02f, 4.14061919e-02f, 1.48579264e-02f, -6.77771047e-02f, -7.86108226e-02f, 1.63973644e-02f,
  -7.53330514e-02f, 3.69740687e-02f, 1.06862314e-01f, -3.44298370e-02f, -3.17877196e-02f, -4.36210483e-02f, -2.01924816e-02f, -7.50984922e-02f, -4.51834202e-02f, 3.31684537e-02f,
  -1.81975290e-02f, 6.18881509e-02f, 1.24540024e-01f, -5.20327613e-02f, -1.01353765e-01f, -1.26326201e-03f, -4.75065038e-02f, 4.62411456e-02f, -2.47023087e-02f, -2.47034952e-02f,
  3.58908810e-02f, 4.35415804e-02f, 7.81649947e-02f, -6.07967153e-02f, -8.32669809e-02f, -5.96584678e-02f, -8.83395085e-04f, -5.68763949e-02f, 4.98341117e-03f, 1.23877436e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.46653938e-01f, -4.93595861e-02f, -5.39622307e-01f, -1.22786857e-01f, -2.48554677e-01f, -3.42737198e-01f, -2.88638771e-01f, -9.58888456e-02f, 2.27036886e-02f, -1.54401049e-01f,
  -1.38979271e-01f, 1.62775517e-02f, -3.51274647e-02f, 6.08957969e-02f, -5.62780984e-02f, -2.28665888e-01f, -2.49417737e-01f, -2.28195995e-01f, -1.91087332e-02f, -1.87331036e-01f,
  -1.96550846e-01f, -1.89728692e-01f, -6.03439752e-03f, 8.21896195e-02f, -7.79624432e-02f, -1.25665709e-01f, -2.56846398e-01f, -1.00495927e-01f, -1.09211639e-01f, -3.44787031e-01f,
  -4.28830028e-01f, -1.81301143e-02f, -1.28282726e-01f, 1.58814937e-01f, -1.84673235e-01f, 3.68206725e-02f, -1.40516981e-02f, 1.39645822e-02f, 3.07205785e-03f, -8.78481865e-02f,
  -7.39483833e-02f, 1.01264179e-01f, -2.75326762e-02f, -7.13037103e-02f, -5.91264805e-04f, -1.26859993e-01f, -4.84332964e-02f, -2.25153491e-02f, -1.44132420e-01f, -7.82292634e-02f,
  -3.91174145e-02f, -2.00030297e-01f, -3.69019844e-02f, -1.27506465e-01f, -1.59337059e-01f, -7.47134909e-02f, -1.17248027e-02f, -7.85468593e-02f, 3.94996256e-02f, -4.35813926e-02f,
  -6.59749880e-02f, -2.59034224e-02f, 6.11200593e-02f, -5.42527391e-03f, 2.53782496e-02f, -1.98193397e-02f, -1.75776836e-02f, 3.93655198e-03f, 5.69570984e-04f, 8.07418153e-02f,
  -5.15192598e-02f, -6.49243519e-02f, -6.09166473e-02f, 7.92522356e-02f, -4.04881909e-02f, -5.67228496e-02f, -2.72787306e-02f, 4.27022725e-02f, -3.48489583e-02f, 3.77166085e-02f,
  -6.32268563e-02f, -9.08236653e-02f, 2.94946302e-02f, 2.09879205e-02f, -5.94960637e-02f, 3.52567807e-02f, 1.74237099e-02f, 2.56166793e-02f, 3.37524377e-02f, 7.26498887e-02f,
  2.71498352e-01f, -1.15942573e-02f, 1.05110370e-01f, 1.17564462e-01f, -9.68352631e-02f, -2.98957303e-02f, -6.22091889e-02f, 7.31462911e-02f, 6.23808280e-02f, 5.97515004e-03f,
  -5.97761571e-02f, 1.41958026e-02f, 6.54788017e-02f, -2.21540984e-02f, -2.79783793e-02f, -8.13166127e-02f, 1.23483025e-01f, -3.32619920e-02f, -1.83975212e-02f, -1.13748260e-01f,
  1.48512209e-02f, 4.63022403e-02f, 2.37049147e-01f, 5.26780039e-02f, 5.15730074e-03f, 1.57595739e-01f, -8.01553950e-02f, 1.76700577e-02f, 1.05373889e-01f, 1.84714109e-01f,
  1.91289689e-02f, 1.32972956e-01f, 2.14475110e-01f, 4.71303891e-03f, 9.42423642e-02f, 2.06363127e-01f, 2.06372723e-01f, -7.86046982e-02f, -8.74623507e-02f, 6.20313324e-02f,
  2.62137912e-02f, -6.68820888e-02f, -1.87099963e-01f, -1.86820790e-01f, -1.25750706e-01f, -7.93502480e-02f, -7.66663179e-02f, -1.86938956e-01f, -6.32448494e-02f, -1.38577014e-01f,
  -7.60247931e-03f, -8.60260949e-02f, -4.48043533e-02f, -5.07775731e-02f, -1.35650441e-01f, -4.46537510e-02f, 9.05940756e-02f, 7.53332376e-02f, 1.32974386e-01f, 4.64486554e-02f,
  -5.81945740e-02f, 7.99677670e-02f, -1.88282758e-01f, -2.65713837e-02f, 1.91804525e-02f, -1.30180582e-01f, -7.51077831e-02f, -1.45592876e-02f, 1.50296418e-02f, -9.94521007e-02f,
  5.52145876e-02f, -1.18703850e-01f, 3.79306301e-02f, -1.09309673e-01f, -3.89520861e-02f, 2.78795287e-02f, 4.02546264e-02f, -4.81911227e-02f, -1.05514504e-01f, 1.46242846e-02f,
  -1.50938118e-02f, 8.53454694e-02f, 1.15285069e-01f, 6.21672347e-02f, -3.86023484e-02f, 4.19194587e-02f, 6.41577989e-02f, -4.90153208e-02f, 1.30714208e-01f, -1.03742518e-01f,
  3.99349853e-02f, 1.67606398e-02f, -4.06882018e-02f, -1.07650587e-03f, -4.73744571e-02f, 3.99068482e-02f, -6.07256740e-02f, -4.30604406e-02f, -7.14738369e-02f, -7.02461228e-02f,
  9.15527418e-02f, 8.94609243e-02f, -1.96852833e-02f, -1.02067530e-01f, 5.67877479e-02f, 7.54281059e-02f, -2.50954963e-02f, 4.26080152e-02f, 8.32523629e-02f, -6.19675331e-02f,
  -6.57879710e-02f, 2.61611640e-02f, 2.43851617e-02f, -1.05601422e-01f, 8.62891972e-02f, 3.39400321e-02f, 5.07633537e-02f, -6.92947907e-03f, 8.84919837e-02f, 1.02795154e-01f,
  -2.49919415e-01f, 1.32580444e-01f, -9.28142965e-02f, -1.38882905e-01f, -4.58090939e-02f, 5.13266921e-02f, 1.97399314e-02f, -8.65182355e-02f, 2.87865307e-02f, -5.77152409e-02f,
  1.82867981e-02f, 2.37083863e-02f, -2.67079268e-02f, -8.18017125e-02f, 1.47588952e-02f, 2.26901239e-03f, 4.37003933e-03f, -6.03242703e-02f, -1.15820882e-03f, -3.52369715e-03f,
  5.09779565e-02f, -1.62487328e-02f, -1.03470385e-01f, 2.13580634e-02f, 9.54297092e-03f, -1.42804254e-02f, -2.36234050e-02f, 5.18647432e-02f, -5.86053394e-02f, -6.86704889e-02f,
  1.57973424e-01f, -2.97570378e-01f, -3.50206375e-01f, -1.34179667e-01f, -2.71018088e-01f, -3.39884430e-01f, -3.03039670e-01f, -9.10066366e-02f, -9.51003563e-03f, -1.18452094e-01f,
  -5.31649776e-02f, 2.54706800e-01f, 1.05356589e-01f, 1.08812049e-01f, 1.78670630e-01f, -1.80527285e-01f, -2.50365317e-01f, 2.57598646e-02f, 2.49872997e-01f, 1.15305200e-01f,
  -5.41275404e-02f, 2.33808551e-02f, 1.53041467e-01f, 1.01706252e-01f, -1.65922880e-01f, -3.64629142e-02f, -1.99855760e-01f, -2.02746373e-02f, -1.70362011e-01f, -2.80800492e-01f,
  -1.05304174e-01f, -1.88638762e-01f, 4.77195233e-02f, 1.21120840e-01f, -9.92654338e-02f, 1.43092349e-02f, -1.18746109e-01f, -6.62625059e-02f, 3.56184430e-02f, -3.53428684e-02f,
  -7.89447352e-02f, 4.03929576e-02f, -4.50918414e-02f, 4.45513539e-02f, 2.35632043e-02f, -4.88010421e-02f, -7.08065033e-02f, 1.20280711e-02f, 2.29656491e-02f, -1.16949178e-01f,
  -1.26381904e-01f, -3.30435820e-02f, -5.24394400e-02f, -3.07599641e-02f, -1.46563230e-02f, -7.34350905e-02f, -1.16471484e-01f, -6.40864074e-02f, -8.27100202e-02f, -9.73299965e-02f,
  -9.83983651e-02f, -9.67790484e-02f, -1.05970621e-01f, 6.13457300e-02f, 2.29100976e-02f, -1.93981193e-02f, -1.97819676e-02f, 1.92764606e-02f, 2.85944957e-02f, 7.46341348e-02f,
  3.82496007e-02f, -1.27850519e-02f, 1.69628728e-02f, 2.46831793e-02f, 1.32201789e-02f, 6.95889145e-02f, 7.55922031e-03f, 7.16763409e-03f, -2.68144924e-02f, 8.59478954e-03f,
  -8.58607236e-05f, -8.98774862e-02f, 1.50988447e-02f, -3.39843184e-02f, -1.28523827e-01f, -3.09681501e-02f, 4.82483581e-02f, 4.17561941e-02f, 3.30428556e-02f, 2.24850606e-02f,
  2.41122872e-01f, -5.87386787e-02f, 3.64235677e-02f, 9.70965698e-02f, -6.15018047e-02f, -6.84832921e-03f, -2.05224939e-02f, 4.46833856e-02f, 2.20832732e-02f, -2.70873923e-02f,
  8.92010285e-04f, 7.17369989e-02f, -5.75054549e-02f, -4.33717109e-02f, 5.19040860e-02f, 1.10690761e-02f, 2.45698821e-02f, 4.72999364e-02f, 4.41629477e-02f, -1.04185238e-01f,
  -5.15415519e-02f, 5.52763380e-02f, 1.31656036e-01f, 3.54865603e-02f, -6.86129108e-02f, 3.57288755e-02f, 1.12046404e-02f, 6.05767127e-03f, 1.04938373e-01f, 1.78622320e-01f,
  -1.40783846e-01f, 1.00493975e-01f, -1.90903440e-01f, 1.22649342e-01f, 2.59238154e-01f, -4.12868559e-02f, -7.03095570e-02f, -1.12240620e-01f, 1.78983354e-03f, 7.14698732e-02f,
  1.23258993e-01f, 1.69207796e-01f, 8.32185894e-02f, -1.74367540e-02f, -6.82675913e-02f, 1.43230498e-01f, 2.43302017e-01f, 4.62960824e-02f, -1.33976176e-01f, 6.76620752e-02f,
  2.18741819e-01f, 1.80503771e-01f, 1.77210495e-02f, -8.42513442e-02f, 1.17154032e-01f, 1.14424586e-01f, -1.27539402e-02f, 1.30775809e-01f, 2.40049735e-01f, 3.85388136e-01f,
  6.64305538e-02f, -1.24026969e-01f, -1.25563905e-01f, 1.24594919e-01f, 5.16017489e-02f, -4.29076180e-02f, 2.72644823e-03f, -1.74089149e-01f, -6.53405786e-02f, 2.40976587e-02f,
  8.63512829e-02f, 3.07402760e-03f, 2.23978944e-02f, -1.31158615e-02f, -5.26210181e-02f, -7.03833476e-02f, -4.39667404e-02f, -2.55131185e-01f, -9.35140699e-02f, -6.97988197e-02f,
  2.89160699e-01f, 1.37311667e-01f, -1.77879602e-01f, -2.16145322e-01f, -2.06653163e-01f, -3.44451182e-02f, -1.70159459e-01f, -1.47472739e-01f, -2.28017703e-01f, -1.30010664e-01f,
  3.69596062e-04f, 4.33125161e-02f, -7.50452327e-03f, 2.22099274e-02f, 6.38139769e-02f, -3.36216670e-03f, 6.05334640e-02f, 1.31105140e-01f, -1.67420637e-02f, 4.43545356e-02f,
  -1.72933694e-02f, -1.36905804e-03f, -7.55384117e-02f, 8.36070813e-03f, -4.60817702e-02f, 1.72160584e-02f, -3.36760003e-03f, -4.53012921e-02f, 1.73683488e-03f, -6.47911616e-03f,
  -3.65649723e-02f, 5.95845934e-03f, 3.97448242e-02f, -5.17728962e-02f, 5.64393075e-03f, -1.10960372e-01f, -6.49682730e-02f, -3.24405357e-02f, -7.53251165e-02f, 5.12946723e-03f,
  -1.60404906e-01f, -4.20627855e-02f, -3.49972956e-02f, 4.53985669e-03f, -3.31757660e-03f, -5.42359091e-02f, 2.39857361e-02f, -1.09780565e-01f, -1.42380651e-02f, -5.59642799e-02f,
  6.60389895e-03f, -1.03387631e-01f, 1.75784098e-03f, -2.93925800e-03f, -2.86381058e-02f, 4.00888175e-02f, 8.50584954e-02f, 4.56248736e-03f, -7.71712586e-02f, -7.00474828e-02f,
  2.70854626e-02f, -5.13403825e-02f, -1.86019391e-01f, -9.38811153e-02f, 1.96269173e-02f, 6.47437572e-02f, -1.54503301e-01f, -1.14413433e-01f, -2.59159356e-01f, -2.21762881e-01f,
  9.92810875e-02f, -3.04712597e-02f, 2.89405525e-01f, 8.85436386e-02f, -2.42510647e-01f, -3.21357578e-01f, -4.44234043e-01f, -3.20454776e-01f, -2.36932650e-01f, 1.55504625e-02f,
  -1.45920083e-01f, -6.31567612e-02f, 6.34549111e-02f, 3.18616605e-03f, -3.49944979e-02f, 3.19542587e-02f, 1.94467738e-01f, 2.51997024e-01f, -1.30891651e-02f, -1.29413575e-01f,
  1.58969499e-02f, 1.07222579e-01f, 2.51469851e-01f, 1.30695879e-01f, 9.41190496e-02f, 9.55452323e-02f, 8.72153342e-02f, 2.08538994e-01f, 8.25414807e-02f, 5.05975306e-01f,
  2.09651470e-01f, 1.76796660e-01f, -1.03390962e-01f, 7.29658157e-02f, 8.06799680e-02f, -1.65541482e-03f, -1.42263826e-02f, 1.53133199e-01f, -7.57252425e-02f, -2.79769618e-02f,
  6.60879388e-02f, -1.56846959e-02f, -4.59721461e-02f, 4.14522775e-02f, -6.68048263e-02f, -8.22082609e-02f, 1.01310210e-02f, 2.06392378e-01f, 6.89140172e-04f, -9.69994590e-02f,
  2.40806788e-02f, 8.24037269e-02f, -8.80754590e-02f, -1.60987601e-01f, -6.49926588e-02f, -4.64660637e-02f, -1.36560753e-01f, -5.86396270e-02f, -6.04681782e-02f, 6.86771348e-02f,
  -2.66489666e-02f, 5.59696667e-02f, -3.40313576e-02f, 8.74335598e-03f, 1.96440089e-02f, -5.80851287e-02f, 4.19961885e-02f, -2.70661376e-02f, -1.88716296e-02f, -5.40832356e-02f,
  1.44153582e-02f, -6.26602247e-02f, -3.40799280e-02f, 3.48423086e-02f, 3.14393938e-02f, 8.45704526e-02f, 1.00081619e-02f, 2.84590814e-02f, -4.92426343e-02f, -3.89423855e-02f,
  6.95988685e-02f, 3.04918457e-02f, 8.69743526e-02f, 5.07638194e-02f, -5.18912710e-02f, 2.69558709e-02f, -2.53402144e-02f, -1.18005700e-01f, -1.04601390e-03f, 6.74091429e-02f,
  -2.52189070e-01f, 5.66492835e-03f, -1.75151229e-02f, -6.31299317e-02f, 7.23934174e-02f, -1.24171283e-02f, -4.18524332e-02f, 5.44628426e-02f, 6.52450323e-02f, -3.78401577e-02f,
  -1.27548903e-01f, -7.49748051e-02f, -3.39547209e-02f, -7.15794936e-02f, -8.66117477e-02f, -1.29160553e-01f, -2.79476773e-02f, -8.37334692e-02f, -4.94762463e-03f, -1.12693094e-01f,
  -2.00042397e-01f, -3.22144479e-01f, -2.35691771e-01f, -3.12316120e-01f, -1.45681709e-01f, -1.21559672e-01f, -2.13570088e-01f, -2.47145832e-01f, -2.79624164e-01f, -3.71533513e-01f,
  -4.12034899e-01f, 3.03403467e-01f, -1.25140892e-02f, -2.30500370e-01f, 1.73904061e-01f, 3.20998847e-01f, 3.82959127e-01f, 2.95002852e-02f, -8.58672857e-02f, 9.48420316e-02f,
  2.38556787e-02f, -1.61919832e-01f, -1.41090378e-01f, 8.76299292e-02f, 1.10359080e-01f, 2.89554715e-01f, 1.86368749e-01f, -2.57335734e-02f, -2.26570874e-01f, -2.55599879e-02f,
  8.15557986e-02f, -1.23053297e-01f, -3.28967869e-01f, -8.27426910e-02f, -4.77303676e-02f, -1.06442466e-01f, -1.15505077e-01f, -8.13600272e-02f, 1.29694015e-01f, 1.03777493e-04f,
  -1.44972116e-01f, -1.17311642e-01f, -1.09342478e-01f, -4.30982374e-02f, -4.52219024e-02f, -2.01627575e-02f, 3.23458426e-02f, -1.43572509e-01f, 1.65481418e-02f, -7.33388066e-02f,
  -1.03413768e-01f, -1.08650841e-01f, -1.38813276e-02f, 3.66690867e-02f, -1.32545173e-01f, -1.18779108e-01f, -3.33229192e-02f, 2.07134448e-02f, -1.37220830e-01f, 1.88513135e-04f,
  1.83637530e-01f, -1.52828991e-02f, -6.21546134e-02f, 1.81350000e-02f, -1.10751189e-01f, -1.48364842e-01f, -1.11179329e-01f, -1.00035071e-01f, -1.35073349e-01f, -4.35476527e-02f,
  8.67344067e-02f, 8.60645697e-02f, -5.44753484e-02f, 3.28575820e-02f, 3.27594802e-02f, 7.73740560e-03f, -1.40712662e-02f, 4.04328853e-02f, -7.58470595e-03f, -3.19698527e-02f,
  6.14883658e-03f, -3.08115557e-02f, -5.94892018e-02f, -1.80735718e-02f, -2.34698188e-02f, -4.77340296e-02f, 1.33598631e-03f, 1.03398010e-01f, -5.28693087e-02f, 2.06844676e-02f,
  -5.54006025e-02f, -8.63106921e-02f, -2.30453517e-02f, 2.49129795e-02f, -1.42644867e-02f, 3.35907564e-02f, -2.32526716e-02f, -2.41579465e-03f, -6.52294904e-02f, -2.54691038e-02f,
  -3.30497324e-01f, 4.54848036e-02f, -1.47422686e-01f, -4.69990224e-02f, -7.68870190e-02f, -1.22021750e-01f, -6.67313412e-02f, 2.47923601e-02f, -7.23497868e-02f, -6.24320768e-02f,
  -2.23745424e-02f, -2.13197935e-02f, -1.67626459e-02f, 7.63070062e-02f, -6.79873005e-02f, 3.39844860e-02f, 2.31502093e-02f, -1.58623531e-02f, 4.71074879e-02f, 3.88892158e-03f,
  7.12359846e-02f, -5.43640740e-02f, -7.35788420e-02f, 6.04528654e-03f, -4.81138639e-02f, -9.18727294e-02f, -1.63239047e-01f, -1.89991951e-01f, -1.10106699e-01f, -5.82764558e-02f,
  -4.72803181e-03f, -1.09346457e-01f, 2.90268976e-02f, 1.31588951e-01f, -1.46239772e-02f, 1.30359381e-01f, 6.72784401e-03f, 1.32376878e-02f, 5.57620302e-02f, -1.52131002e-02f,
  -1.20995954e-01f, -7.52899647e-02f, -3.40589359e-02f, -1.36797294e-01f, -9.70708281e-02f, 1.44396782e-01f, 1.35189444e-01f, -2.41743997e-02f, 4.67189252e-02f, -9.75010395e-02f,
  1.83534343e-02f, -8.57292861e-02f, -9.12299305e-02f, -8.60354528e-02f, 2.24182624e-02f, -1.07751563e-02f, 1.24839328e-01f, -3.04407142e-02f, -9.02386531e-02f, -1.47669781e-02f,
  1.67842224e-01f, -2.26440012e-01f, 2.20694719e-03f, -1.88426450e-01f, 4.38812561e-03f, -8.15730691e-02f, -6.36173263e-02f, -1.35584967e-02f, 6.88192695e-02f, 3.96650955e-02f,
  -9.06667486e-02f, -1.21011034e-01f, -1.00121908e-01f, 3.48566403e-03f, 7.62660801e-02f, -5.75773530e-02f, -1.23179313e-02f, 3.45000951e-03f, 7.82937277e-04f, -2.17291024e-02f,
  -6.66671321e-02f, -1.27191633e-01f, -7.02585801e-02f, -6.84497729e-02f, -6.01746365e-02f, -3.19335982e-02f, -7.34386686e-03f, -1.51097015e-01f, -1.13141444e-02f, 2.10628584e-02f,
  -8.93143937e-03f, -1.41349444e-02f, -5.42737320e-02f, 6.34920150e-02f, -1.38274599e-02f, -3.48089375e-02f, 4.38291319e-02f, 4.37136441e-02f, 2.06631348e-02f, -3.26190293e-02f,
  -2.60088267e-03f, -7.32985660e-02f, -7.64240026e-02f, 7.52493218e-02f, -2.17537172e-02f, -8.98080468e-02f, 2.06541251e-02f, 9.01224930e-03f, -5.53214550e-02f, -1.09107301e-01f,
  -1.21921003e-01f, 1.39847333e-02f, -3.96909267e-02f, -7.41032362e-02f, -1.29130453e-01f, -1.10468594e-02f, -6.11010939e-03f, -1.50412038e-01f, 2.49897875e-02f, 2.98917424e-02f,
  1.92587033e-01f, -2.26972491e-01f, 1.48339599e-01f, 1.71138756e-02f, -9.06626210e-02f, -1.70770347e-01f, -9.54468101e-02f, -6.18176870e-02f, 3.84814013e-03f, -2.49950439e-02f,
  -4.95775566e-02f, -7.03258887e-02f, 7.79577121e-02f, 5.98491393e-02f, 1.63061827e-01f, 3.47711220e-02f, 4.54574041e-02f, 8.29157457e-02f, -5.62394261e-02f, 2.15520937e-04f,
  3.96063551e-02f, 1.33608744e-01f, 1.36093616e-01f, 1.72785625e-01f, 9.21850577e-02f, 5.07830307e-02f, 1.13440663e-01f, 1.50255576e-01f, 6.20569065e-02f, 3.17451119e-01f,
  1.25022948e-01f, 1.80756226e-01f, 7.54671693e-02f, -4.71154600e-02f, -8.01224187e-02f, 4.53206971e-02f, -1.86340362e-02f, 1.66289583e-02f, 1.39718875e-01f, -2.36483552e-02f,
  4.11679298e-02f, 1.32726068e-02f, -7.52583444e-02f, -4.80222865e-04f, 2.30170395e-02f, 2.44343244e-02f, 1.98862795e-02f, 2.13403217e-02f, -9.95758325e-02f, 1.29075805e-02f,
  -1.93347856e-01f, 1.63626615e-02f, 4.89110053e-02f, -3.52811557e-03f, -9.13423374e-02f, -1.78568885e-01f, 2.89480090e-02f, 3.04621365e-02f, 2.37853266e-02f, -2.18247324e-01f,
  -1.38254568e-01f, 2.53933698e-01f, -6.67013004e-02f, -6.56875670e-02f, 9.11826938e-02f, 6.74599111e-02f, 9.08278599e-02f, 1.18832536e-01f, 1.25309289e-01f, 1.32342607e-01f,
  8.62721354e-02f, 4.73979115e-02f, -3.19666266e-02f, -9.86124855e-03f, 6.51583895e-02f, 3.39690074e-02f, 3.84863317e-02f, 1.21841490e-01f, 1.24474801e-01f, 1.33103430e-01f,
  -4.82138023e-02f, 4.70233224e-02f, 1.52496085e-01f, -1.11595122e-02f, 5.11548966e-02f, -8.62027854e-02f, -3.25379930e-02f, 7.93461055e-02f, 1.33354783e-01f, -8.19507241e-02f,
  -7.30471835e-02f, 7.05572590e-02f, -2.74639335e-02f, -3.68011743e-02f, -2.72822799e-03f, -1.88883990e-02f, 4.16096486e-02f, 4.19978276e-02f, 2.84789726e-02f, -4.57170084e-02f,
  -3.16681787e-02f, -9.72656012e-02f, -1.02674887e-01f, -9.49493609e-03f, -3.54696289e-02f, -6.04892671e-02f, 1.64286401e-02f, 4.83737141e-03f, -3.33133265e-02f, 4.84041795e-02f,
  5.64504154e-02f, 4.84362543e-02f, 1.38720395e-02f, 6.49286583e-02f, -4.52781767e-02f, 3.05422340e-02f, 1.64128933e-02f, 2.04820856e-02f, -9.01791304e-02f, -6.30917326e-02f,
  3.16128992e-02f, -2.48376746e-02f, -1.68374047e-01f, 6.29031492e-05f, 6.80625578e-03f, 5.05647697e-02f, -6.26723766e-02f, -3.90795730e-02f, 6.63800836e-02f, 5.75282192e-03f,
  8.28220472e-02f, 9.46267173e-02f, 1.22233927e-01f, 1.24151241e-02f, -1.08231232e-02f, -3.43033075e-02f, 5.58692217e-03f, -9.04801041e-02f, 8.17854479e-02f, 1.86197776e-02f,
  1.10869244e-01f, 7.19515160e-02f, -3.00181489e-02f, 2.81931572e-02f, -6.41347393e-02f, -8.52344707e-02f, -1.18793957e-01f, -1.01123348e-01f, 1.29341818e-02f, -7.13013336e-02f,
  -3.66952062e-01f, 1.69522092e-01f, -1.34541333e-01f, -2.45699644e-01f, 9.53461006e-02f, 1.30179122e-01f, 2.91416228e-01f, 5.25714643e-02f, 5.24839805e-03f, 1.33138597e-01f,
  -4.30332012e-02f, 6.19735569e-03f, -1.02006914e-02f, 2.94885840e-02f, 1.77766960e-02f, 1.08814143e-01f, 1.10498168e-01f, -8.67561549e-02f, -1.84753463e-01f, -1.28610143e-02f,
  5.26323505e-02f, -5.52476272e-02f, -2.95185536e-01f, -4.63596806e-02f, -6.98137879e-02f, -4.68135178e-02f, -4.54602055e-02f, -5.08052073e-02f, 5.22992723e-02f, 1.47047779e-02f,
  -1.18794702e-01f, -1.99000493e-01f, -8.82548541e-02f, 4.88452725e-02f, -2.96126343e-02f, -6.48753718e-02f, -1.62472557e-02f, -2.11681444e-02f, -4.45637256e-02f, 5.65591231e-02f,
  -9.31378007e-02f, -5.98091781e-02f, -5.44270454e-03f, -3.68396565e-02f, -2.47556046e-02f, -6.88491762e-02f, -1.17522418e-01f, -1.53498963e-01f, -2.86583100e-02f, 3.49832550e-02f,
  1.14147961e-02f, 1.05932751e-03f, -1.66276380e-01f, -6.90220669e-02f, -7.83259645e-02f, -1.43667087e-01f, -2.02657301e-02f, -3.19091487e-03f, -5.88815473e-02f, 2.72560064e-02f,
  -3.50992791e-02f, -2.60529295e-02f, 3.62121128e-02f, 6.47768304e-02f, -3.13635282e-02f, -5.09103052e-02f, 4.66796160e-02f, 5.13408007e-03f, 5.12968637e-02f, -6.94673322e-03f,
  -1.08661745e-02f, -2.72238571e-02f, -7.26940623e-03f, -3.09194461e-03f, 4.18079607e-02f, -2.18601935e-02f, 6.07976504e-02f, 1.25141084e-01f, 1.50558073e-02f, 6.66061416e-02f,
  -5.51315919e-02f, 5.49066588e-02f, -1.61692556e-02f, 4.25933897e-02f, 7.76014328e-02f, 3.87052074e-02f, 1.79310217e-02f, 5.97358942e-02f, 9.81381815e-03f, -4.35255170e-02f,
  -1.64196379e-02f, 8.96846950e-02f, 6.30397769e-03f, -1.00367911e-01f, -1.30320471e-02f, -1.56961270e-02f, 7.24375546e-02f, -7.04965070e-02f, -4.12272364e-02f, 9.00074560e-03f,
  8.26229230e-02f, -2.46011838e-02f, 7.13914335e-02f, -5.32016978e-02f, 2.77960300e-02f, 2.99741048e-02f, -1.44087635e-02f, -8.62141624e-02f, -2.73793191e-02f, -6.58298805e-02f,
  5.25366962e-02f, 5.37571609e-02f, -1.31300852e-01f, -9.05651003e-02f, -2.98412945e-02f, -9.66079235e-02f, -4.92431074e-02f, -6.57360107e-02f, 8.57270136e-03f, 9.35390219e-02f,
  -4.72255677e-01f, -3.99642773e-02f, -1.44874513e-01f, -1.08284980e-01f, -1.15915556e-02f, -6.72836229e-02f, -1.87382344e-02f, -1.47024468e-01f, -7.57308379e-02f, -2.90967058e-02f,
  8.68906528e-02f, 2.06864029e-01f, 1.72610313e-01f, 1.52410373e-01f, -9.91375819e-02f, -1.44482732e-01f, -2.50582457e-01f, -1.73115909e-01f, -1.76708412e-03f, 8.73775482e-02f,
  8.28776136e-02f, 5.57779483e-02f, -9.00833830e-02f, 6.29018480e-03f, 6.23009875e-02f, -9.61432420e-03f, -1.33288845e-01f, -8.08544382e-02f, -2.20188946e-02f, -1.00308642e-01f,
  5.81894577e-01f, -2.22211808e-01f, -8.21734518e-02f, -1.32202119e-01f, 1.40791368e-02f, -7.19361454e-02f, 7.92309120e-02f, -1.06022246e-01f, -1.79105058e-01f, -1.05634496e-01f,
  -3.49672250e-02f, -3.23407799e-02f, -9.94536728e-02f, 9.10572335e-02f, -4.80367839e-02f, -9.84373689e-02f, -2.15456218e-01f, -1.26780376e-01f, -1.14605665e-01f, 5.70689179e-02f,
  -5.24995150e-03f, -1.62858039e-01f, -2.41416357e-02f, -4.11632732e-02f, -1.50612444e-01f, -1.15958959e-01f, 1.27586098e-02f, -5.58237880e-02f, -1.22977547e-01f, 5.46395630e-02f,
  6.08989187e-02f, 1.73153896e-02f, -2.83910595e-02f, -4.65903208e-02f, -3.63943167e-02f, 5.61022805e-03f, -2.23671403e-02f, -2.96629523e-03f, 8.67789239e-02f, 9.22717154e-02f,
  1.97389070e-02f, -6.76251501e-02f, 7.33792931e-02f, -1.57909300e-02f, 6.28640875e-02f, 1.17890183e-02f, -5.17431684e-02f, 1.26262112e-02f, -5.89810088e-02f, -5.62008582e-02f,
  -4.46109548e-02f, 3.06099784e-02f, -5.15013887e-03f, 6.85921386e-02f, -1.36692360e-01f, -7.86057338e-02f, -4.58863415e-02f, 2.35238411e-02f, -4.86774780e-02f, 2.32003052e-02f,
  4.23792541e-01f, -3.33448201e-01f, 8.45031962e-02f, -4.93022166e-02f, -5.58124594e-02f, -3.04323547e-02f, -5.18542947e-03f, -1.27727076e-01f, 1.13836927e-02f, 1.25804143e-02f,
  -7.03758299e-02f, 7.61153549e-02f, 6.64183171e-03f, 6.38078079e-02f, 3.73385139e-02f, 9.81881842e-03f, -8.20156410e-02f, 3.11823888e-03f, -1.26182526e-01f, 5.45939803e-02f,
  -1.25191972e-01f, 6.38056472e-02f, 1.49454013e-01f, 1.79201335e-01f, -5.04446626e-02f, 9.33902785e-02f, 2.70996481e-01f, 1.10931776e-01f, 7.52884895e-02f, 2.36365199e-01f,
  5.33966839e-01f, 1.18937582e-01f, 5.62635176e-02f, 1.24491550e-01f, -2.04480127e-01f, -1.75031438e-01f, -1.90825924e-01f, -6.95570232e-03f, 4.37462702e-02f, -5.44457026e-02f,
  -1.12185664e-01f, -5.16643114e-02f, 1.15212969e-01f, 1.30637482e-01f, 1.50991857e-01f, 7.58735687e-02f, 1.20338216e-01f, 2.09193543e-01f, 1.92798644e-01f, 1.61467418e-01f,
  -3.79192904e-02f, 1.79643095e-01f, 2.08790585e-01f, 1.37158364e-01f, 1.14832245e-01f, -3.76539789e-02f, 3.36094759e-02f, 6.96377084e-02f, 7.13984668e-02f, 2.13965476e-01f,
  2.70392329e-01f, 7.46626705e-02f, -1.25892565e-01f, 2.19683982e-02f, -1.03144683e-01f, 1.38348147e-01f, 4.62887250e-02f, 5.50884530e-02f, -9.71792415e-02f, -8.13722983e-02f,
  5.39577566e-02f, 3.57217044e-02f, -3.10907569e-02f, -4.44610454e-02f, -3.71711934e-03f, 7.39948750e-02f, 9.43937004e-02f, 9.99082550e-02f, -1.07241711e-02f, -9.33103636e-03f,
  -7.38420859e-02f, -2.13961210e-02f, -7.40997121e-02f, -7.24977478e-02f, 5.50873531e-03f, 3.16008069e-02f, 2.60906741e-02f, 1.25283869e-02f, -2.08525322e-02f, 1.14402749e-01f,
  -6.28331974e-02f, 1.00630790e-01f, -1.41368918e-02f, 3.23293358e-02f, -4.25762162e-02f, 1.13943173e-02f, -4.12720926e-02f, 4.46354412e-02f, 4.26445268e-02f, 4.79293056e-02f,
  -3.91619131e-02f, 9.62756574e-03f, -3.97646390e-02f, 8.06334708e-03f, -3.61759923e-02f, -3.31424139e-02f, 1.03014556e-03f, 1.96732190e-02f, 1.41168442e-02f, 6.29912913e-02f,
  2.07798965e-02f, 2.77031399e-02f, -6.21239329e-03f, 4.08840850e-02f, 5.89918010e-02f, 9.83521044e-02f, -1.25875222e-02f, -6.14153333e-02f, 4.59021404e-02f, 5.81232868e-02f,
  -1.26313478e-01f, -2.06556901e-01f, 2.08985545e-02f, -1.27199348e-02f, -5.71101978e-02f, -5.69171794e-02f, 4.23346879e-03f, -5.60729653e-02f, -1.18142113e-01f, 1.09371757e-02f,
  1.50577882e-02f, 5.64484932e-02f, -7.06293881e-02f, 3.18134502e-02f, 2.50730757e-03f, -1.60876643e-02f, 5.02255093e-03f, -6.48572221e-02f, -7.53247067e-02f, 1.88652501e-02f,
  -9.90494862e-02f, -1.13219932e-01f, 4.35924483e-03f, -1.82020795e-02f, -1.21031120e-01f, -8.17083642e-02f, 1.68761518e-03f, -3.70876938e-02f, -1.97290089e-02f, -1.54399887e-01f,
  -5.91686726e-01f, 7.02283978e-02f, 5.43329455e-02f, -1.65779740e-01f, 5.60310818e-02f, 2.94405650e-02f, 1.54272523e-02f, -6.80386871e-02f, -7.13621825e-02f, 4.73567098e-02f,
  2.52170954e-02f, -8.33744630e-02f, -5.18573783e-02f, 7.31222555e-02f, -8.82652178e-02f, 2.06603035e-02f, 8.07259232e-02f, -6.98998272e-02f, -8.06548148e-02f, -4.19012122e-02f,
  -7.59176016e-02f, -2.41813168e-01f, -1.91415578e-01f, -8.33639354e-02f, -7.37963989e-02f, 2.44321693e-02f, -4.79489155e-02f, -1.14651449e-01f, 8.77581984e-02f, 8.03410187e-02f,
  1.78126231e-01f, -1.04453422e-01f, -4.11814190e-02f, -1.30971432e-01f, 8.78334977e-03f, -1.05305361e-02f, -3.75776775e-02f, -7.26915710e-03f, -7.57675096e-02f, -1.38407163e-02f,
  -6.88363193e-03f, 1.48549117e-02f, -6.07858133e-03f, 3.24621759e-02f, -4.43609543e-02f, -8.25304072e-03f, -1.32239237e-01f, -2.51516402e-02f, 3.04217860e-02f, 1.18030058e-02f,
  2.82488726e-02f, 8.67473930e-02f, -1.27307236e-01f, 6.89852685e-02f, 1.78380832e-02f, 1.33040976e-02f, -1.63268577e-02f, -3.44136991e-02f, -1.16811827e-01f, -5.29732406e-02f,
  -1.07956409e-01f, -3.79506908e-02f, 5.39671071e-02f, -4.59434427e-02f, -1.05816811e-01f, -1.91333164e-02f, 4.81617823e-02f, 4.31424053e-03f, -2.87922937e-02f, -6.43805563e-02f,
  -4.23312448e-02f, -2.86058672e-02f, 1.96174067e-02f, -6.31294970e-04f, 6.75934479e-02f, 2.45455168e-02f, 5.54611906e-02f, -8.09681267e-02f, 9.68375057e-02f, -3.69398557e-02f,
  -9.28953942e-03f, 3.94470170e-02f, -1.08718211e-02f, -5.80539219e-02f, 6.02746904e-02f, 3.61842886e-02f, 6.04333915e-02f, -4.39781882e-02f, 3.15722637e-03f, -2.23383978e-02f,
  -1.33147746e-01f, 2.06028298e-01f, -5.27032726e-02f, -1.23234145e-01f, -9.08309296e-02f, 3.69770639e-02f, -2.63843946e-02f, 3.39701399e-02f, -1.84923206e-02f, -3.19034718e-02f,
  8.23125616e-03f, -1.03012040e-01f, -1.08499013e-01f, -6.82205632e-02f, -7.56067187e-02f, -4.82954048e-02f, -1.29074827e-01f, -6.32066280e-02f, 2.50102468e-02f, -1.29259657e-02f,
  6.35683537e-02f, -9.66239423e-02f, -1.36518821e-01f, -6.66926950e-02f, -9.45261121e-03f, -1.33077621e-01f, -4.14225720e-02f, 1.54991839e-02f, -1.23041958e-01f, -1.71368867e-01f,
  6.25534773e-01f, -3.62510115e-01f, -4.03540544e-02f, 2.19949886e-01f, 1.88549444e-01f, 2.95244962e-01f, 1.31811678e-01f, 4.64868806e-02f, 8.85832608e-02f, 6.59873709e-02f,
  -3.62922311e-01f, -2.51912624e-01f, -3.32987726e-01f, -3.18682939e-01f, -1.37132883e-01f, 1.70456767e-01f, 2.13831618e-01f, 4.32675928e-02f, 1.98803749e-03f, 1.27281427e-01f,
  -7.50004798e-02f, 1.07066572e-01f, 1.33651048e-01f, -8.51286948e-02f, 2.50758138e-02f, -6.42213747e-02f, 3.25160883e-02f, -1.95354167e-02f, -2.50154406e-01f, -1.78278059e-01f,
  -3.41347188e-01f, -3.54224116e-01f, 3.45202684e-02f, -7.53401592e-02f, -1.56284302e-01f, -2.35205032e-02f, 3.53562348e-02f, -7.77585879e-02f, -1.53372690e-01f, -3.74009758e-02f,
  -7.92342350e-02f, -1.10544749e-01f, -2.22852051e-01f, -1.90554664e-01f, 1.02488622e-01f, -1.74200032e-02f, -1.72051415e-02f, -1.12322696e-01f, -2.32332081e-01f, -1.31898016e-01f,
  -2.59757072e-01f, -1.15102537e-01f, -8.77478421e-02f, -5.95751256e-02f, -2.61060566e-01f, -1.37072861e-01f, -1.53642744e-01f, -1.96154401e-01f, -1.95888981e-01f, 8.01095366e-02f,
  1.20087918e-02f, -1.14689264e-02f, 2.07612291e-02f, -4.05092724e-02f, 9.69146937e-02f, 3.17469835e-02f, -3.90749006e-03f, 2.55622789e-02f, 8.62614512e-02f, 1.18653670e-01f,
  8.59359093e-03f, 2.43490748e-02f, -7.30330274e-02f, 7.06050470e-02f, -3.87049243e-02f, 1.73145048e-02f, 3.24381255e-02f, -1.50162645e-03f, 3.12412102e-02f, 7.02688172e-02f,
  -1.71483122e-02f, -5.03002554e-02f, 1.06849886e-01f, -8.64697620e-02f, -4.19258550e-02f, 2.15997994e-02f, -6.45070989e-03f, -9.91995782e-02f, -4.82279360e-02f, 1.72277056e-02f,
  2.40413845e-01f, -1.65650919e-01f, 1.11615188e-01f, 1.47693614e-02f, -1.12600799e-03f, -5.55506982e-02f, 2.80002598e-03f, 2.22414713e-02f, -9.19941887e-02f, -8.44784901e-02f,
  -1.98952720e-01f, -6.94939271e-02f, -1.14740349e-01f, -3.97323743e-02f, 1.46829814e-01f, 5.22757210e-02f, 1.06083736e-01f, 1.01314984e-01f, 8.29758309e-03f, 4.19682683e-03f,
  4.92981337e-02f, 1.83043331e-01f, 3.43690485e-01f, 1.85719341e-01f, -4.84163500e-02f, 2.89580166e-01f, 7.00534433e-02f, 1.24968290e-01f, 2.02843413e-01f, 5.29216290e-01f,
  1.63291320e-01f, 3.39563876e-01f, 3.28410119e-01f, 3.63590419e-01f, 3.29373866e-01f, 2.79018104e-01f, 4.34228778e-01f, 3.17786127e-01f, 1.57807678e-01f, 1.29407406e-01f,
  -6.93634246e-03f, -8.10466781e-02f, 6.06040284e-02f, 6.23939224e-02f, 2.15737611e-01f, 3.08014333e-01f, 2.86010802e-01f, 1.05887301e-01f, 9.47013423e-02f, 1.49317563e-01f,
  7.28121772e-02f, 7.02196211e-02f, -3.77136655e-02f, 1.46590173e-01f, 1.77023217e-01f, -1.59533205e-03f, 1.41989455e-01f, 3.67612503e-02f, 8.22448209e-02f, 2.21497953e-01f,
  -8.00967216e-02f, 2.32278779e-01f, -1.74896434e-01f, -1.72731623e-01f, -1.46230862e-01f, -8.87218937e-02f, -4.49176133e-02f, -2.23981380e-01f, -5.82140572e-02f, -5.20097166e-02f,
  -2.22977065e-02f, -8.75119492e-02f, 5.82557619e-02f, -1.01677589e-01f, -6.33922294e-02f, -1.46670029e-01f, -3.75648029e-02f, 1.03260927e-01f, 3.97763252e-02f, -4.78347652e-02f,
  -5.45908622e-02f, 6.49015326e-03f, -5.62325167e-03f, 9.49709564e-02f, 2.03261957e-01f, -7.60218576e-02f, -8.82383659e-02f, -4.40532677e-02f, 8.88881981e-02f, -7.43060261e-02f,
  7.87715707e-03f, -5.43889664e-02f, 3.01456340e-02f, -3.36671770e-02f, -7.27154613e-02f, -9.32338163e-02f, 8.47460628e-02f, -4.20590937e-02f, 3.02201994e-02f, -2.26281993e-02f,
  4.16724570e-02f, 5.57622761e-02f, 4.41101342e-02f, -3.28042097e-02f, 3.60730737e-02f, 6.29962906e-02f, 2.70592817e-03f, -1.86211690e-02f, -2.64677801e-04f, -9.94981006e-02f,
  4.89930548e-02f, 3.38211134e-02f, -3.62982042e-02f, 4.06937338e-02f, 1.18441377e-02f, -2.43539251e-02f, 6.15850873e-02f, -1.58999860e-02f, -3.26841697e-02f, -1.25271112e-01f,
  -1.10913321e-01f, -2.27471724e-01f, 3.17503810e-02f, 2.94243116e-02f, 6.62352443e-02f, -1.56618372e-01f, 5.85732237e-02f, -1.56385563e-02f, -6.00734800e-02f, 9.98897851e-02f,
  -6.37469217e-02f, -4.45741974e-02f, 4.46758531e-02f, 9.59745795e-03f, -1.27877081e-02f, -3.94723900e-02f, -7.87370875e-02f, 6.77329302e-02f, 4.96539958e-02f, -1.59176849e-02f,
  4.12538871e-02f, -2.28979383e-02f, -1.39441311e-01f, -1.92750357e-02f, 9.11407545e-02f, -9.22745317e-02f, -1.00081638e-01f, -8.22062343e-02f, -1.32127509e-01f, -7.21092001e-02f,
  -6.27002716e-02f, 1.60725519e-01f, 8.77727941e-02f, 6.41532838e-02f, 2.31594160e-01f, 2.77435660e-01f, 2.52085000e-01f, 8.31766129e-02f, 6.15924597e-02f, 1.28440097e-01f,
  3.24582383e-02f, 9.99220759e-02f, 1.96746346e-02f, 1.26547858e-01f, 3.33462767e-02f, 2.18487024e-01f, 1.73574120e-01f, -1.36746485e-02f, 4.51671854e-02f, 6.22163452e-02f,
  2.21026503e-02f, 5.25277257e-02f, -1.58668473e-01f, 1.15097901e-02f, 1.21070202e-02f, 5.61671406e-02f, 3.49835642e-02f, -1.61293689e-02f, 4.77990918e-02f, 8.24332908e-02f,
  -5.47914617e-02f, 5.55318743e-02f, 2.94894143e-03f, -5.38686961e-02f, 1.23236142e-02f, -1.59098551e-01f, -2.22144108e-02f, -1.89771757e-01f, 2.60408651e-02f, -1.99142024e-02f,
  3.87296900e-02f, -9.74109024e-02f, -6.08493574e-02f, -3.02290777e-03f, 2.13460401e-02f, -1.03320047e-01f, -4.17208076e-02f, -4.30527516e-02f, -8.16737041e-02f, -8.62829946e-03f,
  1.68938994e-01f, 9.59023312e-02f, -7.84819722e-02f, -4.56031933e-02f, 2.72210073e-02f, 5.79404943e-02f, 8.37390944e-02f, 1.68804042e-02f, -5.55349402e-02f, -3.47335488e-02f,
  -4.45128903e-02f, 1.79918986e-02f, 1.93778693e-03f, 2.48576868e-02f, -6.27764314e-02f, 4.60630246e-02f, -3.35497223e-02f, 2.68106423e-02f, 6.33173063e-02f, -1.94952786e-02f,
  -4.60653529e-02f, 3.38840000e-02f, -6.38704225e-02f, -2.68337112e-02f, -2.13557407e-02f, 8.53926018e-02f, 4.55649346e-02f, -2.82432456e-02f, -7.92242214e-02f, -1.12779692e-01f,
  -3.67606468e-02f, -5.39155528e-02f, -1.01505607e-01f, 3.62292561e-03f, 1.96148828e-02f, -1.27426833e-02f, -4.25912812e-02f, -1.27661228e-01f, 3.12239435e-02f, -1.01700332e-02f,
  -8.32797140e-02f, 2.45155650e-03f, 4.98092733e-02f, 3.50045972e-02f, 3.35492231e-02f, -7.19012395e-02f, -3.41344438e-02f, -1.39627352e-01f, 6.29623309e-02f, 3.17932032e-02f,
  -4.13367115e-02f, -3.58721837e-02f, -2.68318877e-02f, -1.20263062e-01f, 3.27622108e-02f, 2.02784482e-02f, -1.18772453e-03f, -9.20882151e-02f, -4.00627730e-03f, -1.59333795e-01f,
  -4.83680777e-02f, 9.71606746e-03f, -9.46658291e-03f, -7.54247606e-02f, -6.68250546e-02f, -5.87781817e-02f, -1.15474954e-01f, -8.64162967e-02f, -1.63331404e-01f, -1.20705001e-01f,
  -1.99733749e-01f, -1.98194802e-01f, -1.60229236e-01f, -3.10278803e-01f, -8.96641985e-02f, 9.20432732e-02f, -2.18549538e-02f, -5.31255594e-03f, -3.22553038e-04f, -2.01192066e-01f,
  -5.21937124e-02f, -1.42791912e-01f, -2.30448306e-01f, -6.36318885e-03f, -7.71063752e-03f, -1.35833070e-01f, -2.48168811e-01f, -1.41400129e-01f, 1.89238749e-02f, -1.03405621e-02f,
  -1.00736074e-01f, -1.86882108e-01f, -9.11815837e-02f, -4.45342995e-02f, -2.63464212e-01f, -2.02392876e-01f, -1.46563187e-01f, -2.41289765e-01f, -1.62709638e-01f, -3.47240955e-01f,
  -2.63415217e-01f, 3.48602012e-02f, 6.21165968e-02f, -7.23096654e-02f, -9.13171768e-02f, -7.83462748e-02f, -9.29864272e-02f, -7.20427632e-02f, -8.49409699e-02f, -1.06614865e-01f,
  -1.21379077e-01f, 5.79184107e-02f, -1.49584383e-01f, -1.76070794e-03f, 4.14706627e-03f, 2.02867854e-02f, -3.94070894e-02f, -1.44446287e-02f, -4.54338677e-02f, 9.92301553e-02f,
  -5.09903505e-02f, -6.56928271e-02f, -1.07075557e-01f, 6.65368587e-02f, -4.98852320e-02f, -1.24179535e-01f, -9.66202468e-02f, -3.42543013e-02f, -1.24757499e-01f, -2.39359111e-01f,
  1.11766368e-01f, -5.02482057e-02f, 8.27588234e-03f, 6.71894923e-02f, 3.75536904e-02f, 2.70554442e-02f, -6.60111681e-02f, 2.77449749e-02f, 4.27070968e-02f, 4.29264549e-03f,
  3.76776792e-02f, 1.19514868e-01f, 1.89446262e-04f, -8.99526328e-02f, -6.79399446e-02f, 1.17552159e-02f, 6.69668913e-02f, -3.68401147e-02f, -8.63367021e-02f, -5.64004965e-02f,
  -2.45892368e-02f, 3.51320617e-02f, -7.58978724e-02f, 4.59644012e-02f, -4.25621606e-02f, 3.04159392e-02f, -5.31909578e-02f, 6.75658956e-02f, -6.89811632e-02f, 1.20729720e-02f,
  -2.71188289e-01f, 2.04128399e-01f, -4.92262878e-02f, -1.47426307e-01f, -1.06690884e-01f, 6.38386011e-02f, -3.93845588e-02f, 6.22446388e-02f, -7.20470697e-02f, 1.09057594e-02f,
  -6.22252412e-02f, -8.76908153e-02f, -2.56411526e-02f, 8.57480988e-02f, -1.01127159e-02f, 9.20425653e-02f, 1.03555657e-01f, -6.41479790e-02f, -2.50528138e-02f, 3.21922824e-02f,
  1.03934988e-01f, -3.77687253e-03f, -1.59478411e-01f, -1.24316067e-01f, 2.75756721e-03f, -9.42736939e-02f, -9.48337838e-02f, -1.03955977e-02f, -1.06893159e-01f, -8.98460820e-02f,
  -1.72376662e-01f, -3.11823905e-01f, -8.95465836e-02f, -9.80614722e-02f, -7.93785676e-02f, -1.16991200e-01f, -2.74056017e-01f, 2.53835209e-02f, 8.79114196e-02f, -2.26541474e-01f,
  -2.17103481e-01f, -1.81189198e-02f, -7.53950253e-02f, -3.79083231e-02f, -4.71741594e-02f, -2.33748630e-01f, -1.97322652e-01f, -1.01922140e-01f, 1.12471536e-01f, -2.41191387e-02f,
  -5.61259650e-02f, -9.78868380e-02f, 2.02295333e-02f, 2.28944849e-02f, -3.35439220e-02f, 1.14165410e-01f, 1.13701656e-01f, -4.43628728e-02f, 7.61873871e-02f, -4.96700965e-02f,
  -1.09817259e-01f, 5.91539815e-02f, 5.76440431e-03f, -2.54167300e-02f, -7.23051429e-02f, -6.65512607e-02f, -1.27857383e-02f, 6.36574253e-02f, -2.03750115e-02f, 1.97373275e-02f,
  -1.07225060e-01f, 4.07176204e-02f, -1.15561672e-01f, 3.49664427e-02f, 9.00970772e-03f, 1.72455329e-02f, 4.57671918e-02f, 1.24575302e-01f, -2.88397484e-02f, 3.05942688e-02f,
  -1.91277176e-01f, -6.71862364e-02f, 1.24573167e-02f, 1.39703199e-01f, 5.74256927e-02f, -2.05404144e-02f, 1.48582518e-01f, 1.60747916e-01f, 1.00828268e-01f, -7.39712715e-02f,
  1.45676732e-02f, 6.14680871e-02f, 1.59102380e-02f, 6.91464543e-02f, -7.37823918e-02f, 5.89413792e-02f, -2.12308709e-02f, 1.27818463e-02f, 2.16297302e-02f, 6.56111017e-02f,
  -3.54615715e-03f, 2.18937993e-02f, -4.70095761e-02f, 2.95316335e-02f, 7.08556548e-02f, 1.34170372e-02f, -5.12799423e-04f, -3.79599184e-02f, 8.73281248e-03f, -2.83235777e-02f,
  -3.66671564e-04f, 1.59069814e-03f, 7.17967376e-02f, 2.65916679e-02f, 1.96951721e-03f, 3.72274220e-02f, 4.60754447e-02f, -7.77511001e-02f, 3.13788094e-02f, -1.14024594e-01f,
  5.94643615e-02f, 8.79753847e-03f, -1.90896332e-01f, 1.99448150e-02f, -2.35829893e-02f, -4.73534409e-03f, -7.39307404e-02f, 7.98594952e-03f, -6.06307983e-02f, -2.04408616e-02f,
  4.14966233e-02f, -7.00845271e-02f, -7.38631189e-02f, 1.80334710e-02f, -8.02234262e-02f, 1.00471899e-02f, -1.33331180e-01f, 4.22224170e-03f, -2.94838706e-03f, -1.05395399e-01f,
  -1.24705896e-01f, -9.52512920e-02f, -1.81294814e-01f, -1.12754721e-02f, -3.08595672e-02f, -1.17400870e-01f, -5.98619096e-02f, -8.13279971e-02f, -6.72605559e-02f, -2.35194296e-01f,
  1.67702422e-01f, 7.00186985e-03f, -9.47886705e-02f, 5.38589321e-02f, 3.72391171e-03f, -9.48638245e-02f, -4.70700115e-02f, -3.64793874e-02f, -1.55849596e-02f, 8.67376029e-02f,
  1.24968871e-01f, 8.38098004e-02f, 1.29156083e-01f, 6.09010123e-02f, 4.72295173e-02f, -2.96049677e-02f, -1.32896965e-02f, 1.21518806e-01f, 9.90215503e-03f, 1.72165245e-01f,
  2.31287152e-01f, 6.82649612e-02f, 3.65484953e-02f, 1.33198321e-01f, 1.00532472e-01f, 1.47763938e-01f, 1.06326669e-01f, 6.44542649e-02f, 6.98173493e-02f, 1.19110644e-01f,
  -2.63297819e-02f, -6.36280924e-02f, 9.94364992e-02f, 1.34242252e-01f, 1.01943828e-01f, 1.04942001e-01f, 1.24098562e-01f, 8.95214602e-02f, 1.40836537e-01f, 1.05034329e-01f,
  1.13157295e-01f, 1.15445711e-01f, 8.97265002e-02f, -5.78364693e-02f, 2.59381719e-02f, -1.36206746e-02f, -1.26647279e-02f, -8.98782015e-02f, 1.31047284e-03f, 1.14575168e-02f,
  -1.53890206e-02f, -2.22799946e-02f, -1.00100242e-01f, 4.94048349e-04f, -8.81353393e-02f, 4.64838073e-02f, 1.05132861e-02f, -1.16230451e-01f, -2.53714994e-02f, -4.33934154e-03f,
  6.46600313e-03f, -1.02210008e-01f, 1.22755896e-02f, 3.22985016e-02f, -8.38373303e-02f, 1.88938193e-02f, -3.03341039e-02f, 1.32147223e-02f, 1.17594830e-03f, -8.53227824e-02f,
  -1.02670290e-01f, 2.37464085e-02f, -9.93168801e-02f, -6.70767501e-02f, 9.73880850e-03f, -4.25994098e-02f, -7.73989931e-02f, 2.46847933e-03f, -8.22727010e-03f, -8.17053691e-02f,
  -3.29472497e-02f, -8.35130513e-02f, -7.68024847e-02f, 4.10535596e-02f, 3.42135169e-02f, -5.82729429e-02f, 2.04760581e-02f, 5.52142859e-02f, -2.29486618e-02f, 2.18614992e-02f,
  4.56436761e-02f, -1.26607805e-01f, 1.26541510e-01f, -3.46262008e-02f, 1.61411949e-02f, -5.70427366e-02f, -8.22404493e-03f, 5.43776676e-02f, 2.96372939e-02f, -2.29672864e-02f,
  -6.72276616e-02f, -2.16773432e-02f, 5.39480634e-02f, -5.27524352e-02f, -7.21687591e-03f, 1.07717261e-01f, -2.12685317e-02f, 5.21452874e-02f, 8.53732824e-02f, -2.89431289e-02f,
  -2.48668361e-02f, 1.89446006e-02f, -6.35509193e-02f, -1.97187648e-03f, -7.77779222e-02f, 8.66410136e-02f, 7.94181451e-02f, -1.62863274e-04f, -6.00756928e-02f, -4.58019562e-02f,
  -1.39331475e-01f, 1.14046007e-01f, -7.79131576e-02f, -5.11947274e-02f, -1.11545444e-01f, 6.92510232e-02f, 1.17320672e-01f, -1.32697709e-02f, -1.90926362e-02f, 6.24896139e-02f,
  -4.77157198e-02f, 1.12332990e-02f, 1.02502391e-01f, 1.27289752e-02f, 2.65424717e-02f, 1.62306591e-03f, -7.93587565e-02f, 2.46274285e-02f, 2.35852189e-02f, -1.85768679e-02f,
  1.40560027e-02f, -1.56818498e-02f, -4.13951688e-02f, -4.42353338e-02f, -8.66192207e-02f, 1.73397902e-02f, -1.02416940e-01f, -6.23333566e-02f, 2.74632592e-02f, -4.12802137e-02f,
  1.72060728e-01f, -8.52363929e-02f, -6.01270050e-02f, -1.25023961e-01f, -3.41947526e-02f, -3.19969468e-02f, 1.65960155e-02f, -6.35987893e-02f, 2.14339662e-02f, 9.00979191e-02f,
  -9.75644514e-02f, -4.67429720e-02f, -2.54994817e-02f, -3.27248722e-02f, -8.83187950e-02f, 3.42938043e-02f, -1.05894431e-01f, -7.26896375e-02f, 5.80545664e-02f, -7.28388457e-03f,
  -6.53941110e-02f, -1.12619177e-01f, 2.84133758e-02f, 9.65377912e-02f, -4.08570701e-03f, 4.56885621e-02f, 6.38415813e-02f, -1.95589010e-02f, 1.40006375e-02f, 4.34893295e-02f,
  9.58903655e-02f, 5.91024309e-02f, 5.34677170e-02f, 1.04238026e-01f, 2.41379607e-02f, 7.36513287e-02f, 1.28663406e-02f, 5.59139214e-02f, -5.69464676e-02f, -4.36398089e-02f,
  4.27249931e-02f, 5.75727336e-02f, -3.34089734e-02f, 4.40178141e-02f, 6.13327511e-02f, 6.65281191e-02f, -5.43527603e-02f, 4.70115691e-02f, -3.59079838e-02f, -1.99839287e-02f,
  -3.15911397e-02f, -2.61994302e-02f, 3.96810696e-02f, 1.29622500e-02f, 6.23837896e-02f, 1.64490417e-02f, -4.81690168e-02f, 2.82126796e-02f, 3.95141020e-02f, 3.23587656e-02f,
  2.59222329e-01f, -6.71881065e-02f, 4.22295779e-02f, -1.50263626e-02f, -8.61885846e-02f, 4.70919982e-02f, 3.10939848e-02f, 8.52917805e-02f, -5.37709892e-02f, 1.21597042e-02f,
  -7.35834613e-02f, -6.09153621e-02f, -5.71489446e-02f, 2.26187203e-02f, -5.80575168e-02f, 6.77293167e-02f, 3.32586356e-02f, 7.03082234e-02f, 8.74414146e-02f, 1.70745905e-02f,
  8.26881826e-02f, 6.29930049e-02f, 2.10918918e-01f, 7.43964165e-02f, 5.81307597e-02f, 1.19457759e-01f, 4.08323146e-02f, 6.58121239e-03f, 1.16470829e-01f, 2.68683583e-01f,
  1.41630381e-01f, -3.55910897e-01f, -1.37738407e-01f, -3.57079096e-02f, -1.93817932e-02f, -1.60346739e-02f, -1.15956359e-01f, -1.90137734e-03f, -3.71316895e-02f, -1.91843271e-01f,
  -1.87452696e-02f, 1.88770160e-01f, -2.42574955e-03f, 5.45692667e-02f, 5.49020693e-02f, -2.20296919e-01f, -1.84223041e-01f, -1.52402911e-02f, 2.19574600e-01f, 1.50137901e-01f,
  4.67536673e-02f, 1.61739718e-02f, 2.88554300e-02f, -4.01231572e-02f, -1.62560433e-01f, -1.22961891e-03f, -1.64188057e-01f, -1.35441512e-01f, -4.89086770e-02f, -2.37742677e-01f,
  5.54662645e-02f, -1.26315340e-01f, 9.00854468e-02f, 7.97991231e-02f, 5.11412323e-02f, 5.36156371e-02f, 3.96529995e-02f, 2.20153369e-02f, 9.82443430e-03f, -1.41903549e-01f,
  -2.51789894e-02f, 2.37531867e-02f, 6.50641173e-02f, 6.68353438e-02f, -7.29069021e-03f, 5.71925975e-02f, 9.48357582e-03f, 8.76970887e-02f, 1.15266899e-02f, -8.59400406e-02f,
  -1.13505289e-01f, -4.68927845e-02f, 6.48449659e-02f, 9.47790146e-02f, 3.98185328e-02f, -9.36297327e-03f, -8.08653012e-02f, 9.27902013e-03f, 1.23354480e-01f, 3.86567414e-02f,
  5.75076602e-02f, -1.97557360e-02f, -3.79385725e-02f, 9.89885926e-02f, 6.83516189e-02f, -6.76743966e-03f, 2.58389004e-02f, 3.63294892e-02f, 6.86244741e-02f, -6.65704980e-02f,
  -3.79405245e-02f, 3.95301990e-02f, -4.00783978e-02f, -5.79150282e-02f, -6.61053658e-02f, -6.70779347e-02f, 4.69706021e-02f, -1.19285010e-01f, 7.60886446e-02f, -4.56645973e-02f,
  3.65363769e-02f, -5.94953932e-02f, -4.41864915e-02f, -4.52172309e-02f, -5.86996414e-02f, 2.38975929e-03f, 3.50828096e-02f, 2.97016688e-02f, -4.93669398e-02f, -2.73791961e-02f,
  5.72362691e-02f, -6.44867197e-02f, 3.57855018e-03f, 7.72168934e-02f, 1.45560894e-02f, -8.88074338e-02f, -8.78885686e-02f, -1.59415286e-02f, 4.28748988e-02f, -7.66964927e-02f,
  9.81851891e-02f, -4.44923975e-02f, -2.27370914e-02f, 3.49897780e-02f, 8.11905041e-02f, 7.72211552e-02f, -8.14668089e-02f, 1.91890541e-02f, -7.64536578e-03f, -3.68590131e-02f,
  -9.31042954e-02f, 4.10763137e-02f, 9.16820690e-02f, -6.61077397e-03f, 8.62655193e-02f, 1.57502875e-01f, -7.46265501e-02f, 1.86198503e-02f, 6.36399612e-02f, 3.04225106e-02f,
  5.67952394e-01f, 3.91398603e-03f, 4.27276582e-01f, 6.49695173e-02f, -2.37988025e-01f, -4.45736870e-02f, -9.61229131e-02f, 3.68542932e-02f, -4.07872088e-02f, -1.60795063e-01f,
  -8.23054276e-03f, 5.39459176e-02f, 3.37212160e-02f, 1.65727898e-01f, 3.22004586e-01f, -2.79850382e-02f, 8.79322458e-03f, 3.62090707e-01f, 2.74768531e-01f, -3.99253406e-02f,
  -1.59260213e-01f, 4.27395739e-02f, 3.70555103e-01f, 1.98599529e-02f, -2.69348353e-01f, -6.80171624e-02f, -2.17431914e-02f, -5.54846972e-03f, -1.61081642e-01f, -2.88667470e-01f,
  -9.41154286e-02f, 9.33358222e-02f, -8.74499828e-02f, -5.49310483e-02f, 2.57789586e-02f, 1.86469331e-02f, -7.78542459e-02f, 7.44102746e-02f, -4.41691726e-02f, -3.44686061e-02f,
  -1.80667445e-01f, -3.98730338e-02f, 8.73909891e-02f, -6.93981051e-02f, -7.59942532e-02f, 1.93071347e-02f, 1.40479486e-02f, 2.05875099e-01f, 1.67373419e-01f, -3.78237739e-02f,
  -1.67737216e-01f, -1.54587790e-01f, -4.77878936e-03f, 3.18313465e-02f, 5.57175353e-02f, 1.62932590e-01f, 6.32258579e-02f, -1.68141369e-02f, 1.16238706e-01f, -9.23239216e-02f,
  -6.32714331e-02f, 6.08478002e-02f, 4.02808934e-02f, 3.49599309e-02f, 1.04545476e-03f, 7.03514041e-03f, -1.23036411e-02f, -8.43561664e-02f, 6.44310415e-02f, -6.59466386e-02f,
  6.21984862e-02f, 5.05392998e-02f, -3.90656628e-02f, 2.45132539e-02f, 3.18293436e-03f, 1.40899606e-02f, -7.97254294e-02f, -6.63998649e-02f, 9.46520194e-02f, 1.05524273e-03f,
  1.05997398e-01f, 2.78528202e-02f, -1.41979503e-02f, 3.40616032e-02f, 5.23443371e-02f, 1.89038068e-02f, -2.44136062e-02f, 4.80236486e-02f, 2.42567174e-02f, -8.18725228e-02f,
  -1.96160391e-01f, 4.13800657e-01f, -1.15275986e-01f, -4.87499386e-02f, -9.80299339e-02f, 3.69976871e-02f, 2.11888589e-02f, -2.57939082e-02f, -1.02789178e-01f, -8.72640908e-02f,
  -9.74496454e-02f, 1.52570633e-02f, 4.21216302e-02f, -5.59274405e-02f, -1.78894214e-02f, 1.46161513e-02f, -2.62156110e-02f, 5.02740629e-02f, -1.15461871e-02f, -8.42091516e-02f,
  -9.71373767e-02f, -5.57140224e-02f, 1.19002908e-01f, -2.43537631e-02f, -1.64352506e-01f, 1.40392810e-01f, -1.19162099e-02f, -3.06451824e-02f, 8.05123895e-02f, -1.27666056e-01f,
  8.16233456e-02f, 3.45333442e-02f, -4.56462242e-02f, 1.67308319e-02f, 7.31913447e-02f, 1.94703089e-03f, 8.53277370e-02f, 9.59854946e-03f, 4.83108684e-02f, 7.32767209e-02f,
  -9.43669136e-07f, 1.73249602e-01f, 1.25691846e-01f, 1.41569749e-01f, 3.46441567e-02f, 1.36664093e-01f, 8.68352428e-02f, 7.05163851e-02f, 1.27063394e-01f, 9.98909622e-02f,
  7.30685741e-02f, 6.98408559e-02f, 1.15820907e-01f, 5.94410226e-02f, -4.63236943e-02f, 7.58583620e-02f, -5.04392460e-02f, -1.21509776e-01f, -4.71718758e-02f, 3.45605635e-03f,
  8.20116773e-02f, -1.71565726e-01f, 6.73917606e-02f, -6.53623566e-02f, 6.39615208e-03f, 7.20620453e-02f, -6.70136651e-03f, -9.55022052e-02f, -5.14039444e-03f, 5.96046522e-02f,
  -2.42552571e-02f, -7.60077089e-02f, -5.28826006e-02f, -2.06325669e-02f, -6.36932030e-02f, 7.13400766e-02f, -7.54131004e-02f, -1.36395797e-01f, -9.00708139e-02f, 1.50077818e-02f,
  -1.02586374e-01f, -2.42559668e-02f, -3.85167748e-02f, -6.87257275e-02f, -9.58416611e-02f, 2.77631897e-02f, -1.09080777e-01f, -1.49483755e-01f, -2.91067729e-04f, -2.11852137e-02f,
  1.28160939e-01f, 2.55538747e-02f, -1.53985694e-02f, 1.76575240e-02f, 1.91937890e-02f, 7.49544725e-02f, -2.23538708e-02f, 3.35932039e-02f, 2.49885544e-02f, -5.98231331e-02f,
  1.04482658e-03f, 3.52194756e-02f, 1.86245311e-02f, 9.81822144e-03f, 5.65916263e-02f, -9.75950658e-02f, 2.65430976e-02f, 4.96255700e-03f, 7.47388750e-02f, -2.15271115e-02f,
  8.30428079e-02f, 4.69487645e-02f, 4.88356650e-02f, -6.55253157e-02f, -3.13632493e-03f, 4.94005792e-02f, -2.04591006e-02f, 2.70738527e-02f, 8.34577754e-02f, -1.29450364e-02f,
  4.97421846e-02f, -6.78349957e-02f, 1.59681857e-01f, 6.23434484e-02f, -1.22409455e-01f, 1.89167950e-02f, 8.26106295e-02f, -7.02578723e-02f, -9.40913111e-02f, 8.99496395e-03f,
  -1.21658958e-01f, 7.99574032e-02f, 9.98121779e-03f, -9.84199811e-03f, 1.76935382e-02f, 8.40359330e-02f, -1.59101225e-02f, -1.97043512e-02f, -1.06237382e-01f, -2.28101350e-02f,
  6.10786192e-02f, 3.36585380e-02f, 1.23754360e-01f, 9.47650638e-04f, -9.10068303e-02f, 6.81597367e-03f, 3.08274608e-02f, 9.43666771e-02f, 1.15751609e-01f, 1.56103238e-01f,
  2.69775331e-01f, -8.98031071e-02f, 3.31777148e-02f, 1.40030980e-01f, -8.83052945e-02f, 6.42726347e-02f, -6.33390620e-02f, 9.31410193e-02f, -3.83912213e-02f, -3.13798077e-02f,
  -4.10851557e-03f, 1.04234703e-01f, 1.30945563e-01f, 1.40096352e-01f, 1.59395233e-01f, -8.42809081e-02f, -1.08858272e-01f, 1.39163777e-01f, 1.46508366e-01f, 1.72711406e-02f,
  4.11851741e-02f, -9.98890102e-02f, 6.08322509e-02f, -3.01932674e-02f, 1.61254383e-03f, 6.71572536e-02f, -6.19674660e-02f, -1.14645019e-01f, -1.01683252e-01f, -6.43806010e-02f,
  6.84638768e-02f, 4.03097831e-02f, 1.39154166e-01f, -1.80123039e-02f, -1.05218254e-01f, 5.55478558e-02f, -1.76274851e-02f, -6.20994009e-02f, 2.54747663e-02f, -6.66862354e-02f,
  -3.65003687e-03f, 4.72577885e-02f, 2.10487135e-02f, -7.57550225e-02f, -4.44917046e-02f, -2.35971063e-02f, -9.38313603e-02f, 7.26102665e-02f, 5.12264334e-02f, 1.16469217e-02f,
  -6.68471828e-02f, 5.21903597e-02f, 2.63967272e-02f, 5.55388257e-02f, 2.67517008e-02f, 1.48792028e-01f, 1.45109156e-02f, -6.94882199e-02f, 1.01288393e-01f, -1.27939191e-02f,
  4.14032973e-02f, -2.40378603e-02f, 1.33231357e-02f, -4.90797944e-02f, 8.93117338e-02f, -5.12877805e-03f, -1.99866984e-02f, 1.50207775e-02f, 5.11707105e-02f, -4.77082916e-02f,
  8.22932925e-03f, 9.62911770e-02f, 9.92478579e-02f, 1.93428118e-02f, -4.37301770e-02f, -2.95416601e-02f, -7.47321099e-02f, -8.17639083e-02f, -8.10045451e-02f, -1.34930043e-02f,
  -3.35223339e-02f, 4.68226336e-02f, -3.03644175e-03f, -1.73517838e-02f, 1.01650646e-02f, 2.04043519e-02f, -5.37315942e-02f, -7.43259937e-02f, -2.74410173e-02f, -4.68721315e-02f,
  -1.11470178e-01f, 1.66763917e-01f, 1.72559485e-01f, 8.22945684e-02f, 6.28732815e-02f, -6.25361800e-02f, 1.25927880e-01f, -8.22409391e-02f, -6.03567548e-02f, -1.11840293e-01f,
  1.62269995e-02f, 1.13098731e-03f, -1.15133926e-01f, -3.57212462e-02f, 8.22402388e-02f, 3.01598404e-02f, -7.92116895e-02f, 9.61069670e-03f, -6.23713620e-02f, -8.04932322e-03f,
  1.24783861e-02f, -4.83491203e-05f, 5.10220490e-02f, -1.21156005e-02f, -7.18810596e-03f, 4.17184271e-02f, -3.77420969e-02f, -4.70163263e-02f, 5.80345690e-02f, -2.79172007e-02f,
  3.86479467e-01f, 2.20785797e-01f, 2.56870508e-01f, -1.19827548e-02f, 2.11228445e-01f, 2.61247933e-01f, 3.87552023e-01f, 1.45551860e-01f, -4.59455810e-02f, -2.48404238e-02f,
  -4.48364280e-02f, -2.66212493e-01f, -2.38850728e-01f, -2.10307345e-01f, 7.20359804e-03f, 7.84821138e-02f, 2.05541197e-02f, -3.97229008e-02f, 8.94229561e-02f, -2.03854218e-02f,
  1.67109091e-02f, 1.00138955e-01f, 1.07901230e-01f, 5.43354005e-02f, -1.92303732e-02f, -1.13573812e-01f, -2.21282616e-02f, 1.63246185e-01f, 1.86821148e-02f, -6.93711117e-02f,
  2.74393130e-02f, 3.59959096e-01f, -2.27122858e-01f, -1.61154255e-01f, 8.42556506e-02f, -4.43442687e-02f, -6.18491434e-02f, -9.87314526e-03f, 5.68690756e-03f, -1.17432969e-02f,
  2.20636856e-02f, -2.93186586e-02f, 2.31639687e-02f, 1.79209914e-02f, 1.08170167e-01f, 9.73915383e-02f, 5.33935949e-02f, 7.24351779e-02f, -1.15200236e-01f, -8.98355097e-02f,
  -1.24478213e-01f, 1.93219930e-01f, 2.21655607e-01f, 5.13318442e-02f, 6.04215916e-03f, -1.53833717e-01f, 7.42982030e-02f, -8.66388343e-03f, 7.97109976e-02f, -2.66203415e-02f,
  -4.26746532e-02f, -8.28844160e-02f, 6.45771325e-02f, -5.13331294e-02f, 4.98668291e-02f, -1.06815979e-01f, -3.96627560e-02f, 2.14657523e-02f, 4.99742217e-02f, 2.35248283e-02f,
  -4.30686846e-02f, -6.03789091e-02f, 2.79483311e-02f, -7.92024210e-02f, -3.72039974e-02f, -2.63852477e-02f, -6.02025054e-02f, 2.20977385e-02f, -7.08955303e-02f, -6.55231923e-02f,
  9.25466791e-03f, 4.52333279e-02f, 6.43460080e-02f, 1.68883111e-04f, 1.17990719e-02f, -9.39204320e-02f, 1.40717309e-02f, -5.83713651e-02f, 4.30724882e-02f, 5.92942759e-02f,
  -7.40600005e-02f, -2.34651435e-02f, -9.44797397e-02f, -9.54540074e-02f, 6.77118450e-02f, -4.26199473e-02f, -8.04459527e-02f, -9.32026803e-02f, -1.15617430e-02f, 5.17721288e-02f,
  -9.38994624e-03f, -1.36969183e-02f, -5.36998920e-02f, 9.63050872e-02f, 3.80611941e-02f, -3.40150781e-02f, -8.44839141e-02f, -1.21167757e-01f, -1.05016530e-01f, -6.19017445e-02f,
  -6.81371242e-02f, 2.55156197e-02f, -4.27632518e-02f, -4.16760035e-02f, -1.63798019e-01f, -1.84059307e-01f, 7.23702908e-02f, -4.84762415e-02f, 2.13388521e-02f, -6.18180772e-03f,
  -1.35246560e-01f, 9.18971151e-02f, 6.95771649e-02f, 1.30150452e-01f, -1.34531036e-01f, -2.20345870e-01f, -3.02978963e-01f, -8.07890669e-02f, 1.86537296e-01f, 8.09439346e-02f,
  -5.51911481e-02f, -9.74929258e-02f, -2.61557978e-02f, -1.63038954e-01f, -1.91596389e-01f, -2.20152825e-01f, -7.05378428e-02f, -2.27133915e-01f, -3.57418209e-01f, -3.24194968e-01f,
  -2.46690929e-01f, -5.28078228e-02f, -1.22646540e-01f, -4.12783511e-02f, -1.08311167e-02f, 5.79696335e-02f, 3.58888805e-02f, -3.26860137e-02f, -1.62694916e-01f, 6.53480813e-02f,
  -8.64810869e-02f, -1.53319705e-02f, -1.01588130e-01f, -7.43663087e-02f, -4.01113834e-03f, -1.89429913e-02f, -7.96530321e-02f, 3.95387150e-02f, 3.78470644e-02f, -1.08709466e-02f,
  -7.71202296e-02f, -4.36758436e-02f, -3.36890630e-02f, -6.66448995e-02f, -5.42697385e-02f, -1.08581699e-01f, 7.54792020e-02f, -4.70073670e-02f, -1.03946008e-01f, -4.56189886e-02f,
  -3.20633724e-02f, -1.41210973e-01f, -1.07730635e-01f, 1.24512250e-02f, 9.53023601e-03f, -3.34210284e-02f, -7.47966096e-02f, -1.82104651e-02f, -5.46387359e-02f, 1.29238069e-01f,
  8.73309840e-03f, 1.15362667e-02f, -6.87637031e-02f, 9.17178392e-02f, 3.59388837e-03f, 1.55315146e-01f, -2.01894008e-02f, -1.15233501e-02f, -6.45274073e-02f, 1.99935045e-02f,
  1.64564341e-01f, 4.41124476e-02f, -1.39544150e-02f, -1.87365916e-02f, -8.66424106e-03f, -2.70051733e-02f, -1.09372966e-01f, -7.70562217e-02f, -1.36204418e-02f, -1.15394816e-02f,
  -1.45190805e-01f, 5.17023578e-02f, 2.13514548e-02f, -9.68870670e-02f, 2.12002732e-02f, 2.88881641e-02f, -1.06807902e-01f, -1.95592772e-02f, 2.90205088e-02f, -3.69678810e-02f,
  3.11352164e-01f, -1.35686129e-01f, -4.68014590e-02f, -1.46807954e-01f, 9.41090658e-02f, 4.24465574e-02f, 5.21905869e-02f, -4.92339469e-02f, -6.00981116e-02f, -1.25161707e-01f,
  -1.02191471e-01f, -8.35529640e-02f, 1.19250052e-01f, -4.27089632e-02f, -1.17284745e-01f, -2.08213106e-02f, -8.85095389e-04f, -1.28924593e-01f, -7.48972222e-02f, -9.78238601e-03f,
  4.63826060e-02f, -1.14027858e-01f, -1.33838370e-01f, 5.58554567e-03f, 1.85132620e-03f, -1.79394037e-01f, -1.20281177e-02f, -1.11776508e-01f, -2.08415583e-01f, 1.94545016e-01f,
  1.53611973e-01f, 3.78113128e-02f, 1.94563866e-01f, 5.03174476e-02f, 1.38672352e-01f, 9.11978185e-02f, 2.23664984e-01f, -7.14655314e-03f, 2.13911794e-02f, -2.36101393e-02f,
  -3.50583741e-03f, -8.54395330e-02f, -9.79810730e-02f, -6.93909079e-02f, -3.54240313e-02f, 4.80383486e-02f, 4.30648066e-02f, -7.45101944e-02f, -1.58714298e-02f, 6.05530702e-02f,
  -1.47847375e-02f, 8.33062381e-02f, -4.07585539e-02f, 2.33678129e-02f, -3.54751796e-02f, -4.98506762e-02f, -6.75688609e-02f, 8.24214667e-02f, 1.07019998e-01f, -4.31774259e-02f,
  6.84748292e-02f, 6.30790070e-02f, -3.78988609e-02f, -1.68409362e-01f, -2.06460264e-02f, -5.17619140e-02f, 5.97827509e-02f, -4.42530215e-02f, -9.05673280e-02f, 6.01111390e-02f,
  -1.67910587e-02f, -5.35296686e-02f, 4.14516926e-02f, 4.14481685e-02f, 9.73991230e-02f, -3.80588882e-02f, -4.77766767e-02f, -2.36356165e-03f, 1.15145035e-02f, 7.43690133e-02f,
  -4.80728410e-02f, 1.72902439e-02f, 1.33895203e-01f, -4.35708184e-03f, 4.68337797e-02f, 1.72679895e-03f, 6.61704093e-02f, 4.67465930e-02f, -6.54081702e-02f, -4.43837382e-02f,
  3.95875089e-02f, -9.61854123e-03f, 1.68569796e-02f, -1.15992986e-02f, 8.79458562e-02f, 7.62206391e-02f, 5.95750113e-04f, 2.50297179e-03f, 3.33950389e-03f, 8.49911496e-02f,
  8.86261240e-02f, 1.20044731e-01f, 1.27336070e-01f, 5.61297312e-02f, 5.60109094e-02f, 1.29224584e-01f, -5.62588386e-02f, 7.52717350e-03f, 4.11554426e-02f, -5.52998260e-02f,
  5.20626791e-02f, 3.33410092e-02f, 2.70489790e-02f, 2.14582905e-02f, 1.08722760e-03f, 4.50286604e-02f, -8.77358913e-02f, 5.71187213e-02f, 5.93677014e-02f, -2.53881514e-02f,
  -9.54170898e-02f, 6.88122585e-02f, -8.30418617e-02f, 3.15734331e-04f, 8.97518098e-02f, -9.38571021e-02f, -3.58115323e-02f, -1.06029093e-01f, 3.31285186e-02f, 7.17442036e-02f,
  1.03800654e-01f, -1.58533175e-02f, 9.54602733e-02f, 4.01553847e-02f, 8.77343193e-02f, -2.32279841e-02f, 1.73160434e-02f, -9.35807601e-02f, -9.86705273e-02f, -3.55369039e-02f,
  4.80570160e-02f, 7.54712373e-02f, -2.04135589e-02f, -1.64829306e-02f, -1.94776356e-02f, -5.03800586e-02f, 8.56856555e-02f, 4.32061628e-02f, -2.27031242e-02f, -9.25250426e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.73437136e-01f, 1.41999394e-01f, 1.85397461e-01f, 1.10498331e-01f, 4.36630219e-01f, 2.39610761e-01f, 2.08062038e-01f, 2.28808656e-01f, 1.13385953e-01f, 3.49370539e-01f,
  4.35587093e-02f, 1.38891697e-01f, 6.05058312e-01f, 4.41654265e-01f, 2.18951195e-01f, 1.49462059e-01f, 1.07195526e-01f, -1.99664868e-02f, 6.19348623e-02f, 5.96976355e-02f,
  5.67849815e-01f, 1.58133641e-01f, -4.49947268e-02f, 1.71953022e-01f, 2.61161059e-01f, 2.37507783e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.15142027e-01f, -8.10143277e-02f, -3.84391725e-01f, 3.18216592e-01f, 4.22796249e-01f, -4.01743948e-01f, 1.94122896e-01f, -2.22837776e-02f, 2.36347720e-01f, -6.87171593e-02f,
  -3.90691668e-01f, 3.28180671e-01f, -1.80296049e-01f, 1.05733968e-01f, 1.64865971e-01f, 2.18958989e-01f, -2.11588338e-01f, 1.37353629e-01f, -3.44788522e-01f, 3.24176341e-01f,
  2.46076912e-01f, 2.54855007e-02f, 2.60492355e-01f, -2.22052693e-01f, 3.47119749e-01f, 2.94351339e-01f, 6.09119274e-02f, -4.41834368e-02f, 7.21121356e-02f, -1.90690234e-01f,
  -2.60826081e-01f, -1.82921140e-04f, -3.17186773e-01f, -1.39541626e-01f, -1.88459784e-01f, 2.12647855e-01f, -2.89493471e-01f, -3.04622442e-01f, 3.05189818e-01f, 6.30095676e-02f,
  2.18604609e-01f, -8.76743495e-02f, -1.04202576e-01f, -1.36626109e-01f, -1.65009245e-01f, 2.14700103e-01f, -1.96137682e-01f, -2.80555040e-01f, -3.13431740e-01f, -2.45805502e-01f,
  1.94844157e-01f, -2.65831202e-01f, -1.91032514e-01f, 3.30188312e-02f, 2.00530648e-01f, 1.80631921e-01f, -1.65883973e-01f, 1.96996778e-01f, -1.53119862e-01f, -2.69946277e-01f,
  -1.27296567e-01f, 5.84666654e-02f, 1.55017108e-01f, -1.07965827e-01f, -2.95370430e-01f, -3.47319186e-01f, 4.52191895e-03f, 1.73717111e-01f, -3.84957343e-01f, 1.87847748e-01f,
  9.26204398e-02f, 1.64650574e-01f, -2.44317889e-01f, -8.34055170e-02f, -9.50486064e-02f, 1.65439680e-01f, -8.51954985e-03f, 9.67577696e-02f, -6.21614046e-02f, -3.85212421e-01f,
  2.40673006e-01f, -1.49434239e-01f, 2.62066871e-01f, 2.24337101e-01f, 1.52292967e-01f, -9.84241590e-02f, -1.35147199e-01f, -9.21153724e-02f, 7.27366582e-02f, -1.91019643e-02f,
  2.31061786e-01f, -2.10590690e-01f, 1.36926502e-01f, 5.16962446e-02f, -1.39081106e-01f, -1.15499645e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.68135315e-01f, 4.34536815e-01f, 3.75069916e-01f, -5.98762929e-02f, -4.03878242e-01f, -2.37485040e-02f, 4.53745365e-01f, -1.79832369e-01f, 3.80342603e-01f, -1.56522870e-01f,
  -3.93546760e-01f, -3.00450265e-01f, 4.40020233e-01f, -9.43209007e-02f, 6.51410893e-02f, 8.15907657e-01f, -2.70184577e-01f, -3.35262418e-01f, 8.01158011e-01f, 9.25140083e-02f,
  4.41315072e-03f, -1.68775678e-01f, -1.41946211e-01f, 4.31831218e-02f, 1.85621560e-01f, 1.94804132e-01f, 1.98340304e-02f, 3.73050719e-01f, -2.37708073e-02f, 8.14214423e-02f,
  2.43987381e-01f, -1.04838505e-01f, 4.00623381e-01f, 1.62913695e-01f, 2.15109140e-01f, -1.04629762e-01f, 2.87252545e-01f, 9.36338380e-02f, -2.47034822e-02f, 4.17852141e-02f,
  2.76498199e-01f, -5.93362749e-02f, 3.45457196e-01f, 4.67290469e-02f, -1.55688539e-01f, -1.96147069e-01f, -1.48193344e-01f, -2.41327152e-01f, 2.29900703e-01f, 6.52716607e-02f,
  -5.12426607e-02f, 2.14789748e-01f, 2.34085694e-01f, -1.11234009e-01f, -4.23592553e-02f, -8.10302645e-02f, -1.70436054e-01f, 2.02352405e-01f, 4.95773882e-01f, 5.23447730e-02f,
  9.17996690e-02f, 4.59954999e-02f, 4.12481725e-02f, -1.36391312e-01f, 3.81038003e-02f, 1.67728275e-01f, 1.06631137e-01f, -6.70850992e-01f, -6.62795842e-01f, 1.56840663e-02f,
  4.17615801e-01f, -6.74997643e-02f, -2.74579912e-01f, 2.97498912e-01f, 5.92739642e-01f, 1.15050375e-02f, 5.46966754e-02f, 1.06752992e-01f, -5.71014062e-02f, -2.51412280e-02f,
  4.11724001e-01f, 1.33560285e-01f, 2.06692442e-01f, 2.96629965e-01f, -1.01372987e-01f, -9.72294956e-02f, -1.26711369e-01f, 2.55236566e-01f, 7.12636113e-03f, -3.10718477e-01f,
  -3.92989367e-01f, 4.41493578e-02f, -1.84446514e-01f, -1.77421600e-01f, 5.10906518e-01f, -4.73380424e-02f, 3.37587684e-01f, 5.54448247e-01f, 2.30071247e-01f, 7.12212920e-01f,
  -3.26664060e-01f, 5.49938202e-01f, 3.42691392e-01f, 3.09558630e-01f, 2.47731492e-01f, -3.13750327e-01f, -3.92882898e-02f, -6.25284538e-02f, 8.12506676e-02f, 2.34686896e-01f,
  -2.49271870e-01f, -1.90302223e-01f, 1.24365240e-01f, -3.74704003e-01f, 7.53346622e-01f, 4.11824673e-01f, 1.35827675e-01f, 1.16875969e-01f, -5.62446862e-02f, -3.81315380e-01f,
  -1.48963451e-01f, -2.77577098e-02f, 5.73280275e-01f, -7.63500258e-02f, -1.56841710e-01f, 7.97238588e-01f, -6.83104619e-02f, 4.36248809e-01f, 2.46709153e-01f, 2.87177503e-01f,
  3.40521634e-01f, -8.75631645e-02f, 3.40805799e-01f, 6.97861835e-02f, 2.92886972e-01f, -2.66889036e-01f, 3.59784454e-01f, 1.61184013e-01f, -1.03864148e-01f, -4.88751046e-02f,
  1.06034771e-01f, 5.82261719e-02f, -2.53891945e-02f, -5.55773266e-02f, 1.73095584e-01f, -8.03263411e-02f, 6.91130981e-02f, 9.83890519e-02f, -6.15677051e-02f, -7.13193268e-02f,
  3.88333052e-02f, 1.79287210e-01f, -9.57971497e-05f, 9.13808644e-02f, 4.25000727e-01f, 9.05797854e-02f, 1.58439845e-01f, -2.62184829e-01f, 1.35459661e-01f, -8.46156850e-02f,
  -9.90230888e-02f, 5.78286834e-02f, -2.36699030e-01f, 2.52859890e-01f, 1.59218073e-01f, 9.46242586e-02f, 8.89009610e-02f, -1.92074463e-01f, -5.92300035e-02f, -1.31043652e-02f,
  2.04070702e-01f, 1.41860977e-01f, 2.01864764e-01f, 1.03700180e-02f, 5.53251617e-02f, -1.66236132e-01f, 2.10886046e-01f, 1.61408812e-01f, 2.08938867e-01f, 3.96198869e-01f,
  1.45820528e-01f, 8.24232921e-02f, -2.43078023e-02f, -2.32735306e-01f, 1.13748714e-01f, 4.27833619e-03f, -9.24936496e-03f, 1.55825019e-01f, 1.15774520e-01f, -3.58261131e-02f,
  -1.88707933e-01f, -1.28571346e-01f, 2.41234094e-01f, 2.33708873e-01f, 3.04862559e-01f, -4.97223556e-01f, 1.15917083e-02f, 3.22357357e-01f, -7.55090546e-03f, -3.93980630e-02f,
  -1.73932742e-02f, 5.58823168e-01f, 4.47964042e-01f, 1.25609115e-01f, 6.85843304e-02f, -2.26846263e-01f, 1.49711445e-02f, 4.96193945e-01f, 6.45985156e-02f, 8.97922441e-02f,
  -1.65677756e-01f, 1.18738726e-01f, 1.36197582e-01f, -3.54496568e-01f, -2.76191324e-01f, 2.49682106e-02f, 1.50844350e-01f, -4.00923081e-02f, -3.77992809e-01f, -1.05525397e-01f,
  1.34823531e-01f, -4.52537835e-02f, -1.32128030e-01f, 4.97822315e-02f, 5.66827692e-02f, 1.05304904e-01f, 2.29017690e-01f, 1.48546681e-01f, 3.55634876e-02f, 2.18826652e-01f,
  5.42270690e-02f, 1.92962363e-01f, 1.20662443e-01f, -1.27613172e-01f, 1.90882772e-01f, 3.11376005e-01f, 5.77373104e-03f, 2.40391806e-01f, 8.81095380e-02f, -2.73648709e-01f,
  3.54341827e-02f, 1.01822680e-02f, 1.31575197e-01f, 2.61588931e-01f, 4.09773551e-02f, -1.66155472e-01f, 5.22752032e-02f, -1.78800002e-01f, -1.67095780e-01f, -1.36944264e-01f,
  3.31833661e-01f, -2.08399296e-01f, -7.78625682e-02f, 2.15232581e-01f, -4.04054206e-03f, 7.10931048e-02f, -5.01607843e-02f, 2.09534585e-01f, 3.93855035e-01f, -5.89852370e-02f,
  6.00603335e-02f, -1.50859803e-01f, -1.85243875e-01f, 1.66802436e-01f, -1.66773856e-01f, 3.65412056e-01f, -9.18364003e-02f, 3.75612944e-01f, 3.49512279e-01f, 5.33204749e-02f,
  3.70133281e-01f, 2.39589244e-01f, -3.14306647e-01f, 2.38804370e-01f, 5.71551323e-01f, 3.75652403e-01f, 2.77969003e-01f, 1.36209682e-01f, -2.30931729e-01f, 2.47744415e-02f,
  2.12403923e-01f, 1.89643931e-02f, -2.84774005e-01f, -8.17726105e-02f, -1.81019574e-01f, 5.36377989e-02f, 1.73042089e-01f, 5.68070263e-03f, 2.29129881e-01f, 2.68568873e-01f,
  -4.42861132e-02f, 3.75037640e-01f, -2.40957662e-01f, 9.85783190e-02f, 4.30490136e-01f, -1.58113688e-02f, 4.02504086e-01f, -1.14565887e-01f, -2.99103469e-01f, 1.00854680e-01f,
  -1.05796486e-01f, -1.04839705e-01f, -1.98127016e-01f, 3.88819948e-02f, 1.28486425e-01f, -9.34968293e-02f, 2.45368391e-01f, 2.14610711e-01f, 1.94196537e-01f, -7.63513744e-02f,
  -9.17577371e-02f, 9.24267620e-02f, 7.76476115e-02f, 4.96810824e-02f, 2.32724547e-01f, 1.10672645e-01f, 1.96534902e-01f, -7.97251388e-02f, -8.73332694e-02f, -6.79677203e-02f,
  -4.18968089e-02f, 1.07641719e-01f, 1.13872029e-01f, 3.37236553e-01f, -1.77500315e-03f, -9.31815282e-02f, 9.64154601e-02f, -4.53018881e-02f, 1.18296847e-01f, -1.04549557e-01f,
  -2.66221583e-01f, -1.57014593e-01f, 3.03150475e-01f, -5.93532994e-02f, -1.43542230e-01f, 1.28565475e-01f, 1.10433795e-01f, -1.71551317e-01f, 5.81409454e-01f, 1.50356099e-01f,
  8.87244269e-02f, 7.38687515e-02f, -2.12030664e-01f, -2.54754983e-02f, 1.19464993e-01f, -6.35246783e-02f, 9.78222936e-02f, 2.39576608e-01f, 9.28690806e-02f, -1.24210410e-01f,
  -7.06736445e-02f, -6.72575235e-02f, 4.61453795e-01f, 3.32656860e-01f, -1.83203220e-02f, 2.10641753e-02f, 1.75499842e-01f, -5.71981668e-01f, 8.23583186e-01f, -9.49187130e-02f,
  5.74372292e-01f, -1.08417474e-01f, -1.26307443e-01f, 2.03763202e-01f, -2.72870779e-01f, 3.29759538e-01f, 1.74401015e-01f, 1.59853786e-01f, -1.52161554e-01f, 1.11278020e-01f,
  -9.67907440e-03f, 2.36403704e-01f, 9.42637250e-02f, 7.97716856e-01f, 3.68078619e-01f, -4.42921892e-02f, -6.99109063e-02f, 1.14552081e-01f, 9.30251256e-02f, 1.45393070e-02f,
  4.89236116e-02f, 4.21768017e-02f, 3.44803542e-01f, -1.82145640e-01f, 2.49331966e-01f, -8.42705928e-03f, 1.88910529e-01f, 1.02382176e-01f, 3.93551260e-01f, -1.79855630e-01f,
  7.36557543e-02f, 2.67088890e-01f, -6.62130862e-02f, 3.23472857e-01f, -1.44300267e-01f, 4.87283558e-01f, 1.24581113e-01f, 1.46860272e-01f, 3.51579189e-01f, 1.10809259e-01f,
  -2.96777755e-01f, 2.42062688e-01f, 9.77880359e-02f, 3.54857892e-01f, 2.56169021e-01f, 1.21738590e-01f, -2.07466796e-01f, -1.72333747e-01f, 2.50248779e-02f, 1.98010243e-02f,
  -2.00759441e-01f, 7.86453858e-03f, -1.80590093e-01f, 4.43292521e-02f, -2.02572182e-01f, 2.20071316e-01f, 1.82776988e-01f, 5.02480686e-01f, 7.81989932e-01f, -5.61644733e-01f,
  -1.11181520e-01f, -3.19600970e-01f, -1.63653065e-02f, 2.97081888e-01f, -1.79581806e-01f, -6.49656728e-02f, 6.16529047e-01f, -1.05422638e-01f, 1.27237782e-01f, 1.27812222e-01f,
  3.19965519e-02f, -4.87489253e-02f, -1.70634314e-01f, 4.05795336e-01f, -2.31141940e-01f, -3.83910835e-01f, -9.32358131e-02f, 2.74683625e-01f, 4.03826296e-01f, -2.07704782e-01f,
  1.33420482e-01f, -1.19367711e-01f, 1.23828568e-01f, -1.62056476e-01f, -1.88294858e-01f, -2.49978721e-01f, 6.52024984e-01f, -1.62197188e-01f, -2.75241762e-01f, 2.06876650e-01f,
  1.50521010e-01f, 3.04040968e-01f, 2.51144439e-01f, 5.05813677e-03f, 5.97020052e-02f, -2.36788213e-01f, 5.99308498e-02f, 3.30872275e-02f, -3.10595959e-01f, 3.90876159e-02f,
  -1.18075497e-02f, -1.65065944e-01f, -1.26740053e-01f, 1.23739235e-01f, 4.34185751e-02f, -1.21504173e-01f, 3.20850015e-01f, 3.87544781e-01f, 6.29240200e-02f, -1.35649845e-01f,
  -1.18934494e-02f, 8.85214359e-02f, -3.66012603e-02f, 2.18804508e-01f, 2.45795280e-01f, 2.48930961e-01f, 3.03991318e-01f, -1.76820666e-01f, -1.49127290e-01f, 1.29363224e-01f,
  1.85873970e-01f, -1.11653030e-01f, -1.84395224e-01f, 1.81259051e-01f, 1.22071050e-01f, 6.72143921e-02f, -1.06028445e-01f, -1.07032090e-01f, -1.27421394e-01f, 1.82020441e-02f,
  2.40893885e-01f, 2.01579884e-01f, -1.43929854e-01f, 3.76372598e-02f, 1.63739603e-02f, -2.30338834e-02f, -9.74061340e-02f, -1.27010066e-02f, 2.32491747e-01f, 2.28424799e-02f,
  -5.62787317e-02f, 2.37345129e-01f, 1.48477346e-01f, 5.84442206e-02f, -5.36539555e-02f, -8.66803899e-02f, -3.68115418e-02f, -6.90356654e-04f, 1.25690717e-02f, 2.04600379e-01f,
  -4.86937203e-02f, 1.01613440e-01f, 7.77405724e-02f, -1.03869937e-01f, -1.73777953e-01f, -2.12476388e-01f, -3.04453045e-01f, 1.90912753e-01f, 5.97340427e-02f, 7.67204612e-02f,
  -1.55699685e-01f, -2.14007776e-02f, 5.00121832e-01f, -2.29386121e-01f, -2.14655280e-01f, -1.09857641e-01f, -1.32264197e-01f, -1.44457921e-01f, 1.44826174e-01f, -1.05877489e-01f,
  -1.45089865e-01f, 1.44755617e-01f, -9.51975584e-02f, -8.33827034e-02f, -1.24202818e-01f, 9.43663567e-02f, -1.44798145e-01f, -9.05039012e-02f, -1.47160077e-02f, 1.27296329e-01f,
  -7.38655552e-02f, -1.58334091e-01f, -1.27470851e-01f, 6.51965663e-02f, 1.41026884e-01f, 9.10832807e-02f, 2.44766265e-01f, -1.76107869e-01f, -6.34143054e-02f, -1.27362475e-01f,
  1.24516539e-01f, 2.55920440e-01f, -3.61515768e-02f, 4.07835424e-01f, -1.45576606e-02f, 5.42421520e-01f, -1.19879458e-03f, -9.35078040e-03f, 3.31480354e-01f, -1.91570912e-02f,
  -1.32897556e-01f, 2.69257486e-01f, -1.36678398e-01f, 1.05322637e-01f, 2.94738173e-01f, 2.18583092e-01f, -2.86321551e-01f, 1.24788553e-01f, 9.05478597e-02f, -2.31865376e-01f,
  -3.01609635e-01f, 8.41358528e-02f, -2.48784542e-01f, 1.18723176e-01f, -2.89479159e-02f, 9.43651143e-03f, 4.49925333e-01f, -3.56842466e-02f, -2.42536157e-01f, -6.92045093e-02f,
  -2.09349822e-02f, 2.42908031e-01f, 1.64219558e-01f, -1.37255743e-01f, 1.66186780e-01f, -1.86311025e-02f, 3.08908850e-01f, 2.35603929e-01f, 6.05599172e-02f, 1.88991308e-01f,
  -5.05265668e-02f, -2.12242126e-01f, 1.48984149e-01f, -6.36032820e-02f, -1.10217266e-01f, 3.78921777e-01f, 6.33152574e-02f, -1.09333068e-01f, -3.01509239e-02f, 1.38478816e-01f,
  2.94395834e-02f, 1.10630825e-01f, 4.78872746e-01f, 1.29425060e-02f, 7.61048049e-02f, 1.67661145e-01f, -1.76662859e-03f, 9.96209607e-02f, 2.32901692e-01f, 1.93232983e-01f,
  -2.84529366e-02f, 1.87717125e-01f, 5.71834028e-01f, -2.31800899e-01f, 2.89806455e-01f, 9.22065414e-03f, 3.40431660e-01f, 1.92487407e-02f, -1.32445425e-01f, -1.93204984e-01f,
  3.63743119e-02f, -6.37063161e-02f, -2.32203469e-01f, 5.50941765e-01f, 1.03587642e-01f, 5.29197231e-02f, -2.16547176e-01f, -1.31589979e-01f, 1.74221508e-02f, 6.74765408e-02f,
  4.95623946e-02f, 1.26157803e-02f, 1.89425349e-01f, 3.31313252e-01f, 2.84813702e-01f, 1.53441830e-02f, 6.73137307e-02f, -2.19714060e-01f, -1.48897380e-01f, 7.93107674e-02f,
  9.37969089e-02f, 9.17609558e-02f, -2.33472809e-01f, 6.40402511e-02f, 4.10058722e-02f, -4.34235334e-02f, -7.93722924e-03f, 2.00531602e-01f, -1.19828433e-01f, 2.75631063e-02f,
  -2.58168668e-01f, 2.95676649e-01f, 6.77331910e-02f, -4.70249355e-02f, 2.25923300e-01f, -2.96452343e-02f, -1.73777193e-01f, -1.30039394e-01f, 3.67496103e-01f, -5.69432899e-02f,
  1.07593112e-01f, 4.12526101e-01f, 7.12601840e-02f, 6.22539110e-02f, 4.64151166e-02f, 1.23694725e-01f, 1.45483196e-01f, 8.44074190e-02f, -1.89638630e-01f, 1.95702001e-01f,
  2.38123517e-02f, 1.01642877e-01f, -1.48346677e-01f, 9.33697000e-02f, 2.78027445e-01f, -3.08676302e-01f, -1.94114879e-01f, 1.99684873e-01f, 1.44588917e-01f, -1.18066527e-01f,
  4.69449162e-02f, 3.93487751e-01f, 1.16289519e-01f, 1.13265283e-01f, -9.86629874e-02f, -2.06222728e-01f, 4.43909243e-02f, -2.38309763e-02f, 3.19994628e-01f, -1.39886647e-01f,
  2.02672437e-01f, 5.20795286e-02f, 2.17527255e-01f, -3.92588191e-02f, -1.40861705e-01f, 1.92533150e-01f, 8.27371478e-02f, 9.85545069e-02f, -6.88465312e-02f, 2.51435563e-02f,
  -1.50214985e-01f, 1.01593606e-01f, -1.31461890e-02f, 1.25613347e-01f, -5.18190563e-02f, -3.62849198e-02f, -2.26849988e-02f, -1.85709149e-01f, 1.17083654e-01f, -1.44782871e-01f,
  -6.17985427e-03f, -1.25313047e-02f, -4.56771292e-02f, 2.36389652e-01f, 4.19609174e-02f, 9.41750780e-02f, 1.63169727e-01f, -1.11024186e-01f, 6.78501502e-02f, 1.41303852e-01f,
  1.15239128e-01f, 1.53431863e-01f, 1.15541173e-02f, 2.41203874e-01f, 1.08228855e-01f, -1.14448369e-01f, -1.42395735e-01f, 1.08791359e-01f, 1.71329185e-01f, -6.49318248e-02f,
  -4.61306535e-02f, -1.77132357e-02f, 4.07913104e-02f, -1.00243606e-01f, 2.33682454e-01f, 1.39577866e-01f, 2.50192732e-01f, 4.26573813e-01f, 6.09042406e-01f, -2.23858967e-01f,
  1.78408220e-01f, 1.00111149e-01f, 1.87673107e-01f, -1.54676244e-01f, 5.29665686e-02f, 8.07996690e-02f, 1.74483344e-01f, 1.10882491e-01f, 3.58485095e-02f, -1.41369760e-01f,
  1.68636367e-01f, 1.18189558e-01f, -1.50882648e-02f, 6.17778115e-02f, 3.42188478e-01f, -1.69480309e-01f, -6.85172528e-02f, -9.62912217e-02f, -3.08774441e-01f, 9.42645147e-02f,
  1.99394092e-01f, -1.99029431e-01f, -1.98717341e-02f, 2.47123182e-01f, -1.84062123e-01f, -2.17174292e-01f, 1.74686670e-01f, -6.13026172e-02f, -2.00533763e-01f, 1.42034739e-01f,
  -8.27452838e-02f, 5.02299070e-02f, 1.92894286e-03f, 4.73805107e-02f, -1.88097358e-01f, -5.75183816e-02f, 7.12745413e-02f, -1.72060221e-01f, -4.67787012e-02f, -2.07551476e-02f,
  2.13093445e-01f, -8.11626296e-03f, -1.81921661e-01f, 2.36748636e-01f, -3.48186605e-02f, 6.86494112e-02f, 3.94220203e-01f, 3.74755040e-02f, -8.62707496e-02f, -2.08559349e-01f,
  1.28092110e-01f, 9.87693816e-02f, 1.41655877e-01f, 2.21687362e-01f, -1.44667104e-01f, 2.38442328e-02f, 5.53397164e-02f, 2.33229309e-01f, 1.26559928e-01f, 1.38131678e-01f,
  1.70355901e-01f, 2.82940984e-01f, 3.72831374e-01f, 5.21767326e-02f, 5.68674982e-01f, 8.72368962e-02f, 2.07933649e-01f, 1.59080386e-01f, 1.38964402e-02f, 2.54777461e-01f,
  1.50587633e-01f, 5.14496230e-02f, -1.36003554e-01f, -2.07587451e-01f, 3.25957462e-02f, -1.58868417e-01f, -8.82398114e-02f, 1.75850734e-01f, 1.42542496e-01f, 5.99020496e-02f,
  2.50902921e-01f, 2.91387796e-01f, 1.09452650e-01f, -1.90755371e-02f, 4.43317704e-02f, 1.02961667e-01f, 2.81878173e-01f, 8.76685753e-02f, 1.27525002e-01f, -2.42797866e-01f,
  -2.87646353e-01f, -1.17345534e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.42806315e-01f, 4.07525413e-02f, 3.17395061e-01f, 2.76466578e-01f, 1.92345068e-01f, 4.52687442e-02f, 2.84665078e-01f, 1.11225881e-01f, 1.61667347e-01f, 1.02664001e-01f,
  -1.70813724e-02f, 1.56020641e-01f, -6.74708840e-03f, 5.04712105e-01f, -4.96479534e-02f, -3.29464152e-02f, 2.56879687e-01f, 2.54914403e-01f, 1.78026199e-01f, 1.53350160e-01f,
  1.03158839e-01f, 1.13112591e-01f, 2.12568138e-02f, 1.42889261e-01f, 9.73819643e-02f, 1.03920326e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -5.95977426e-01f, -3.28585267e-01f, -4.07221586e-01f, 3.50199677e-02f, 5.54571390e-01f, -1.29530549e-01f, 8.14648494e-02f, 1.20644709e-02f, -3.14279795e-01f, -1.99207351e-01f,
  5.11140525e-02f, -2.34551355e-02f, -2.02716336e-01f, -3.66500467e-01f, -3.80139500e-01f, 4.05515134e-02f, -1.36774868e-01f, 1.10970819e+00f, -8.13261420e-02f, -1.56530380e-01f,
  -1.14544071e-01f, 1.79907590e-01f, 1.33003712e-01f, -2.73936838e-01f, 1.01011768e-01f, 3.29198658e-01f, 3.13562453e-01f, -2.46414214e-01f, -2.45417982e-01f, -4.26464945e-01f,
  -1.23970639e-02f, 2.50174794e-02f, -9.63616446e-02f, -4.42050934e-01f, 8.14090967e-02f, 5.78438103e-01f, 3.22779924e-01f, 3.67296040e-02f, 1.66134104e-01f, 4.00125057e-01f,
  -5.84495425e-01f, 4.34086442e-01f, 4.94836748e-01f, 2.56550312e-01f, -1.65582359e-01f, -2.92066038e-02f, -4.94056612e-01f, 6.46986783e-01f, 3.02057683e-01f, 3.33010703e-01f,
  -3.07213273e-02f, -5.36791146e-01f, 6.29360616e-01f, -2.41607547e-01f, 2.38485578e-02f, -3.61854613e-01f, 1.90193176e-01f, 5.43930233e-01f, -1.18992947e-01f, -6.53894395e-02f,
  -7.49146417e-02f, -1.40793463e-02f, -1.51476532e-01f, 3.72299552e-01f, 5.40609062e-01f, 3.08303535e-01f, 5.33183217e-01f, -4.36258018e-01f, -4.57138330e-01f, -4.71939296e-01f,
  -5.24899006e-01f, 6.20809972e-01f, -3.14395577e-01f, 7.09704822e-03f, 5.05856454e-01f, -1.93558142e-01f, -8.78720656e-02f, 2.99624890e-01f, -1.59397349e-01f, -1.58233881e-01f,
  -1.78268984e-01f, 6.92495257e-02f, -2.72888660e-01f, 7.89783299e-01f, 2.88741626e-02f, 8.83842446e-03f, -6.00083470e-02f, -2.80940026e-01f, 2.77308613e-01f, 1.45197943e-01f,
  -1.47484884e-01f, -2.40518689e-01f, -1.82577193e-01f, 3.14460129e-01f, 3.05831209e-02f, 5.07104814e-01f, -4.45798904e-01f, 4.35807496e-01f, -5.42649515e-02f, 6.77150726e-01f,
  -1.11205183e-01f, -4.73010540e-01f, -5.11692524e-01f, -1.32351205e-01f, -2.35906169e-01f, -6.28790140e-01f, -6.39673173e-02f, 1.78672131e-02f, -1.99065268e-01f, -1.81227863e-01f,
  3.49240810e-01f, -2.99764097e-01f, -1.11318551e-01f, 4.52312976e-01f, 5.80983341e-01f, 2.98688531e-01f, -2.19634622e-01f, 6.26902655e-02f, -6.07456416e-02f, 5.35796583e-01f,
  -1.78446814e-01f, 1.10256970e-01f, 3.52908581e-01f, -2.47082174e-01f, -6.16114400e-03f, 1.27838418e-01f, -1.71508282e-01f, 3.17605853e-01f, 5.61051965e-01f, 2.90746421e-01f,
  -6.75413907e-02f, 4.29354161e-01f, 5.60610950e-01f, -5.59121892e-02f, 9.31186974e-02f, -3.46066535e-01f, 6.76952600e-01f, -4.88767296e-01f, -4.67185788e-02f, -2.41412506e-01f,
  -4.08368289e-01f, 4.48361412e-03f, 1.61718249e-01f, -2.19507709e-01f, -2.19598949e-01f, 3.79217505e-01f, -1.73326179e-01f, 1.12110162e+00f, -1.80676728e-02f, -1.91457391e-01f,
  1.69976074e-02f, -9.34077352e-02f, -2.05418393e-01f, -1.93822816e-01f, -2.17782274e-01f, -2.49040991e-01f, 1.24597423e-01f, -1.81881934e-01f, 1.15010746e-01f, -4.54508245e-01f,
  4.27176237e-01f, 3.05614844e-02f, 3.65486383e-01f, -1.96878433e-01f, 3.41469407e-01f, -8.02222937e-02f, 8.07526648e-01f, 1.59515664e-02f, 2.79114306e-01f, 3.40539724e-01f,
  1.81739107e-01f, -1.96696341e-01f, -2.63864905e-01f, -5.59644587e-02f, 2.21869245e-01f, 3.33307087e-01f, 2.22388387e-01f, 1.04603238e-01f, 7.78725743e-02f, -3.27817909e-02f,
  -2.26921663e-01f, -1.31136909e-01f, -1.84940919e-01f, 1.07598618e-01f, 3.34796086e-02f, -5.07179916e-01f, 1.75434113e-01f, 1.46459058e-01f, -5.97937629e-02f, 4.69831914e-01f,
  -2.11418211e-01f, -1.85354218e-01f, 1.20829511e-02f, -3.50221366e-01f, 8.25619791e-03f, -5.79194069e-01f, -4.65429902e-01f, 7.23367929e-01f, -4.43925142e-01f, 3.16989720e-01f,
  6.47991419e-01f, 6.03458583e-02f, -1.81957513e-01f, 2.43153676e-01f, 1.54438257e-01f, 1.71796858e-01f, -6.02358162e-01f, -6.07223287e-02f, -2.69912064e-01f, -4.40180272e-01f,
  -5.05448699e-01f, -2.71438032e-01f, -2.58164257e-01f, 1.11431435e-01f, 5.10453403e-01f, -2.47873649e-01f, 5.72388351e-01f, -2.79455632e-01f, -1.49806961e-01f, 1.45752296e-01f,
  -5.48081361e-02f, -4.43817228e-01f, -1.17381653e-02f, -3.76333386e-01f, -3.18176806e-01f, -5.85184216e-01f, 3.75950821e-02f, 3.51165265e-01f, 1.87765679e-03f, 5.67673333e-02f,
  -3.11678380e-01f, 9.31307822e-02f, 8.50409344e-02f, -7.01411903e-01f, -8.78418460e-02f, 1.90745801e-01f, 3.94738734e-01f, 1.55145183e-01f, 5.78962922e-01f, -7.94361532e-02f,
  -1.35119885e-01f, 8.08516890e-03f, 5.96629500e-01f, -4.04160976e-01f, 2.15268001e-01f, 1.01073779e-01f, -2.08719939e-01f, 4.16593403e-01f, 1.21903725e-01f, -2.79585551e-02f,
  6.53698761e-03f, 6.27262816e-02f, 2.22800076e-01f, -2.19134375e-01f, -1.13300383e-01f, 1.05733924e-01f, -3.19241616e-03f, 1.22282781e-01f, -5.16730584e-02f, -5.45223773e-01f,
  2.55753666e-01f, 2.76964605e-01f, 5.32241344e-01f, -1.54111639e-01f, -3.01891744e-01f, 6.69206560e-01f, -1.44524962e-01f, 2.48195350e-01f, -3.74327511e-01f, 1.00756787e-01f,
  4.82044518e-01f, 7.37956166e-02f, 5.60726643e-01f, -8.36815238e-01f, 9.87660363e-02f, -4.37225640e-01f, 4.80783910e-01f, 1.79776713e-01f, -1.96061924e-01f, -3.54019374e-01f,
  -2.38583073e-01f, -1.95686892e-01f, 2.68345237e-01f, 5.01586609e-02f, -4.66016680e-02f, -5.62122539e-02f, 5.07823229e-01f, 4.24605384e-02f, -4.10848446e-02f, 8.99480283e-02f,
  4.70103592e-01f, -7.15932488e-01f, -6.31164610e-02f, -1.60536885e-01f, -3.04919422e-01f, 3.59655507e-02f, 6.98021889e-01f, -4.91832256e-01f, -4.46638837e-02f, -2.58401155e-01f,
  8.09676230e-01f, -2.69618571e-01f, 3.52255180e-02f, -2.19740868e-01f, -1.00318611e-01f, -3.93651545e-01f, -1.59640655e-01f, 4.47654933e-01f, -8.05930421e-02f, -7.76896700e-02f,
  2.66559243e-01f, 3.49890232e-01f, -2.86687195e-01f, -2.24098489e-01f, -5.62896654e-02f, 4.46952701e-01f, 5.13122603e-02f, 1.41256943e-01f, -4.97739315e-02f, 2.63546735e-01f,
  -1.19812936e-01f, -3.19462746e-01f, -5.66679537e-01f, 1.52587548e-01f, -3.68141145e-01f, -2.71739274e-01f, 8.78473759e-01f, -1.68493301e-01f, -2.88596451e-01f, -4.72590327e-01f,
  4.22070101e-02f, -2.91178823e-01f, 4.43762243e-01f, -2.29023471e-01f, 2.14052409e-01f, -1.31208152e-01f, 1.64308310e-01f, -1.59468204e-01f, 1.48392692e-01f, -9.71012041e-02f,
  1.06555186e-01f, -5.72137199e-02f, -1.17648296e-01f, -8.54275897e-02f, -2.48481378e-01f, 5.85503578e-01f, -1.66483089e-01f, -6.99471235e-02f, 3.00524272e-02f, 2.89458692e-01f,
  3.10114205e-01f, -8.30307528e-02f, 2.33447775e-01f, 2.01344386e-01f, -1.64288450e-02f, -9.63016674e-02f, -3.42439353e-01f, 3.47185314e-01f, -5.15770555e-01f, 1.20954856e-01f,
  -4.24917907e-01f, 1.19175065e+00f, -4.55484152e-01f, -4.66876999e-02f, -7.61874467e-02f, 5.13917625e-01f, -5.42220920e-02f, 1.26830637e-01f, -1.86863944e-01f, -1.85069427e-01f,
  2.30867863e-01f, -2.80368686e-01f, -2.18215585e-01f, 2.01849729e-01f, -9.87743810e-02f, 1.31149471e-01f, 2.81339109e-01f, -6.79708570e-02f, 1.66566446e-01f, -1.28370851e-01f,
  -2.84959286e-01f, -3.14098239e-01f, -4.97381948e-02f, -2.08137035e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.29831168e-03f, -1.50001764e-01f, 1.74802005e-01f, 1.84782416e-01f, 2.08978597e-02f, 7.01822788e-02f, 1.40663385e-01f, -2.14789018e-01f, -2.20403224e-01f, 2.73740679e-01f,
  -1.68190628e-01f, 4.46708687e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    