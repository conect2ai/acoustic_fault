/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.56972271e-01f, -7.33932480e-02f, -1.25365421e-01f, 4.27881092e-01f, -2.49480940e-02f, 2.38640737e-02f, -2.26217642e-01f, 1.72542781e-01f, 1.58890709e-02f, 2.48115249e-02f,
  2.44862676e-01f, -2.40899950e-01f, -3.73265833e-01f, 3.66913527e-01f, -4.29793485e-02f, -2.58534789e-01f, 3.90051126e-01f, 1.15482472e-01f, -3.29628848e-02f, 2.19522089e-01f,
  1.04195423e-01f, 2.67822921e-01f, 1.29634008e-01f, 1.08682347e-04f, 2.40626901e-01f, -9.38764215e-03f, 1.83073103e-01f, -3.10863405e-01f, 2.22989723e-01f, -3.26249339e-02f,
  1.32287011e-01f, 7.33705685e-02f, -5.50108925e-02f, -3.85615863e-02f, 1.17235489e-01f, 1.77674796e-02f, -4.24290672e-02f, -1.43872663e-01f, -1.07508302e-01f, -9.73354466e-03f,
  -8.31625238e-02f, -2.20616721e-02f, 1.09177366e-01f, -1.07610457e-01f, 6.74826801e-02f, -3.63809266e-03f, 1.56831726e-01f, 1.48862764e-01f, -4.92719151e-02f, 8.48781969e-03f,
  3.66935097e-02f, 7.09196925e-02f, 1.59986809e-01f, 3.71174999e-02f, -7.84828980e-03f, 1.83919705e-02f, 1.38814403e-02f, -5.78444451e-02f, 6.28078729e-02f, 5.71350418e-02f,
  1.13214804e-02f, -5.49979582e-02f, 5.43097965e-02f, -3.60627249e-02f, -2.95229144e-02f, 4.12512012e-02f, -2.65266537e-03f, 3.04592811e-02f, -1.98984016e-02f, 6.32705316e-02f,
  6.01115152e-02f, 9.22554061e-02f, 4.46328409e-02f, 3.23423222e-02f, 1.03134476e-01f, 2.22204719e-03f, -2.20673401e-02f, 4.97752465e-02f, 1.24369979e-01f, 5.97433597e-02f,
  -1.33611605e-01f, -6.13612905e-02f, -2.32121237e-02f, 1.80122852e-02f, 4.76079024e-02f, -1.70929674e-02f, 4.69808877e-02f, 8.83079022e-02f, 1.92805361e-02f, -3.72025780e-02f,
  -6.95052817e-02f, -5.75352050e-02f, -6.99357390e-02f, -5.93347335e-03f, -8.36081281e-02f, -9.13437270e-03f, -6.39314950e-02f, 1.25397250e-01f, -1.49699494e-01f, -2.43190359e-02f,
  1.60238072e-01f, -3.75321892e-04f, 1.00835115e-01f, 6.65206760e-02f, -3.69070880e-02f, -2.24875156e-02f, -4.29964997e-02f, -7.93210045e-02f, 2.33297218e-02f, 3.41639034e-02f,
  -8.74744356e-03f, -6.33779392e-02f, -5.57398237e-02f, 9.42868218e-02f, 1.25494257e-01f, -1.30314631e-02f, -1.54205337e-02f, 5.93370162e-02f, 6.21689968e-02f, -5.11289835e-02f,
  3.23129058e-01f, -1.48172215e-01f, -3.15779597e-01f, 1.49679020e-01f, 2.56652921e-01f, 4.04382765e-01f, 1.90484166e-01f, -7.58087188e-02f, 2.46823296e-01f, 3.54101993e-02f,
  -1.69239566e-01f, 6.19536676e-02f, -2.91504383e-01f, 7.31341168e-03f, -4.27423790e-02f, -4.45511609e-01f, 2.98638105e-01f, 1.03308715e-01f, -4.64315303e-02f, 1.16319329e-01f,
  1.38372192e-02f, 3.23833913e-01f, -2.20809817e-01f, 7.88260996e-02f, 2.25095138e-01f, 1.37873255e-02f, -1.49507850e-01f, -5.82491979e-02f, 5.45855276e-02f, -1.49442069e-02f,
  -3.81149240e-02f, -2.31422950e-02f, -5.06928340e-02f, 7.22587854e-02f, -1.68305635e-02f, 9.75507498e-02f, -1.50642479e-02f, -6.00026511e-02f, 4.56602871e-02f, 1.86979230e-02f,
  1.09047228e-02f, 6.20798171e-02f, 1.44629210e-01f, -2.18597967e-02f, 6.56826571e-02f, -2.05546953e-02f, 7.64431991e-03f, -9.82247964e-02f, 1.57764796e-02f, -6.16118424e-02f,
  4.41947989e-02f, -7.97974318e-02f, 3.73019949e-02f, -3.27431858e-02f, 2.60343379e-03f, 1.67736430e-02f, 6.73331618e-02f, 9.41416901e-03f, 5.24827577e-02f, 5.13450578e-02f,
  1.20771565e-01f, -1.16300760e-02f, -1.47769749e-01f, 9.33211949e-03f, 5.02941422e-02f, -2.98157204e-02f, -8.16128850e-02f, -2.94790436e-02f, -2.52363216e-02f, -5.24961166e-02f,
  5.07308207e-02f, -5.31146936e-02f, 1.10384911e-01f, 8.63307193e-02f, -2.53928173e-02f, 7.98151642e-02f, -6.98421299e-02f, -4.24988568e-02f, 5.24167344e-02f, -8.32515657e-02f,
  -5.07755727e-02f, 1.16907366e-01f, -1.22051641e-01f, -1.47488788e-02f, 1.35142785e-02f, -1.13512978e-01f, -2.11267378e-02f, -1.31164387e-01f, 5.18387067e-04f, 5.11652194e-02f,
  1.62234455e-01f, 1.52798295e-01f, -7.68325999e-02f, 6.20344765e-02f, -3.31039950e-02f, 1.11765310e-01f, -1.89017430e-02f, -1.45541299e-02f, -2.18107458e-03f, 1.45027721e-02f,
  1.57818094e-01f, 1.44262183e-02f, -4.34607826e-02f, 3.92223746e-02f, 4.44337092e-02f, -1.06254593e-01f, 1.18735604e-01f, 3.90795581e-02f, 1.72650635e-01f, -4.03279103e-02f,
  5.90615422e-02f, 1.04104690e-01f, 4.74630594e-02f, 4.92973775e-02f, 9.66460034e-02f, 3.22759300e-02f, 1.26313090e-01f, -5.32945171e-02f, 2.39313785e-02f, 2.17113737e-02f,
  3.92262153e-02f, -2.15045288e-02f, 1.49191126e-01f, -4.00959626e-02f, -2.86200702e-01f, 2.89961606e-01f, 2.58739918e-01f, -9.92681608e-02f, -4.02636260e-01f, 1.15794443e-01f,
  3.46585140e-02f, 1.20046914e-01f, -7.13326409e-02f, 3.21076840e-01f, 3.18659216e-01f, 5.16039059e-02f, 1.82802632e-01f, 1.30242303e-01f, -2.08424881e-01f, -7.07153603e-02f,
  -1.45062402e-01f, 1.71102181e-01f, 2.68295914e-01f, -6.72392026e-02f, 1.84351970e-02f, -1.37641534e-01f, -2.52958145e-02f, -1.56476825e-01f, 3.68390381e-01f, 9.89762470e-02f,
  2.18835160e-01f, -6.21220507e-02f, 6.72212169e-02f, 1.17199115e-01f, -7.51476660e-02f, 2.62417495e-02f, 1.42959937e-01f, 5.77546023e-02f, -6.51568919e-02f, 7.95523301e-02f,
  -3.02012172e-02f, 1.07766777e-01f, 3.02008837e-02f, -8.94291997e-02f, -3.41433175e-02f, -1.99744683e-02f, -3.57606933e-02f, 4.14136872e-02f, -3.62208160e-03f, 1.22859590e-02f,
  3.11578698e-02f, 1.08404029e-02f, -3.68858092e-02f, 1.90505851e-02f, 1.62781589e-02f, -8.55525956e-03f, 6.53769523e-02f, -7.64251314e-03f, 5.39032891e-02f, -8.26231241e-02f,
  -5.36490530e-02f, -1.11437179e-01f, 3.78427245e-02f, 7.50009790e-02f, -3.03330105e-02f, 3.24404947e-02f, 4.18725051e-03f, 5.56719676e-02f, -3.97323593e-02f, 3.10760597e-03f,
  -2.40798872e-02f, 1.76009852e-02f, -2.54358482e-02f, -2.12673023e-02f, -4.54049148e-02f, 6.07950725e-02f, 3.92593853e-02f, -4.76843631e-03f, 2.31623501e-02f, -2.77177449e-02f,
  -6.85165003e-02f, 2.81903427e-02f, 3.33955213e-02f, 5.72290681e-02f, 1.12393856e-01f, -6.03410862e-02f, -6.81653013e-03f, 8.55635628e-02f, -1.82244405e-02f, -6.48399889e-02f,
  -1.00474969e-01f, -4.40798610e-01f, -8.58661681e-02f, 1.00282058e-01f, -8.07511155e-03f, 2.51794104e-02f, 9.65833291e-03f, -3.64141949e-02f, -1.31585836e-01f, 9.71772522e-02f,
  2.81725638e-02f, -9.45292972e-03f, 1.08414451e-02f, 9.95647758e-02f, 5.05263135e-02f, 7.21379444e-02f, 3.71128996e-03f, -4.83442284e-02f, -9.92968902e-02f, -8.48816633e-02f,
  2.97133438e-02f, -1.34644024e-02f, -3.19761597e-02f, -4.83754203e-02f, 5.46415560e-02f, -7.27102235e-02f, -7.26038963e-02f, -2.03939676e-02f, -2.53019556e-02f, 8.56698025e-03f,
  2.05381781e-01f, -1.13702975e-01f, 2.34437853e-01f, 4.48311299e-01f, -1.63983598e-01f, -3.04374158e-01f, -2.69372016e-01f, -3.06016114e-02f, 2.11769655e-01f, -9.68446583e-02f,
  -3.16895783e-01f, 1.05397165e-01f, -5.09305239e-01f, -1.15521796e-01f, 2.03363821e-01f, -2.73645908e-01f, 2.20367163e-01f, -4.49460298e-02f, -2.77415141e-02f, -6.10550605e-02f,
  8.56088921e-02f, -1.42804459e-01f, 1.03288796e-02f, 8.82860348e-02f, -2.62836628e-02f, 4.18091923e-01f, 2.28191808e-01f, -8.46764967e-02f, 2.00861931e-01f, -1.61167607e-01f,
  -2.33367011e-01f, -3.84092629e-02f, 1.19172512e-02f, 7.21796751e-02f, 4.15422861e-03f, -6.86774729e-03f, 4.16244939e-02f, -8.10455009e-02f, 1.06750898e-01f, -4.20628227e-02f,
  -1.40767977e-01f, 8.98923054e-02f, 8.34965333e-02f, -1.82455312e-02f, 1.36114731e-01f, 6.31705001e-02f, -2.54910570e-02f, -1.57374337e-01f, 8.40674713e-02f, -6.81343302e-02f,
  -1.32901156e-02f, -3.68742272e-02f, 1.48011088e-01f, 1.04895435e-01f, 1.90902591e-01f, 1.23431645e-01f, -2.69097127e-02f, 4.00414644e-03f, 1.23525955e-01f, 1.58252627e-01f,
  -3.70652340e-02f, -7.19479397e-02f, -9.53211635e-02f, -3.88714522e-02f, -8.46412615e-04f, -8.50696564e-02f, 1.43367918e-02f, -1.73816159e-01f, 1.42064422e-01f, -6.14947788e-02f,
  5.86996712e-02f, 3.55351605e-02f, -5.79992980e-02f, -9.74063110e-03f, -1.05110779e-01f, 3.77222709e-02f, 3.18617770e-03f, 2.65536252e-02f, 3.64780985e-02f, -2.34457310e-02f,
  2.42345985e-02f, 3.22269090e-02f, -6.27799928e-02f, -1.30213216e-01f, 5.10193408e-02f, 4.27670171e-03f, -3.12786028e-02f, 4.19174554e-03f, -7.05005005e-02f, -6.65647760e-02f,
  2.46879607e-02f, 3.20292085e-01f, 1.96103156e-02f, 7.15787634e-02f, 5.62378429e-02f, -8.49183202e-02f, 1.88280421e-03f, 7.76278898e-02f, 1.62672251e-01f, -1.77399125e-02f,
  5.36628664e-02f, 1.22072175e-02f, 3.11164092e-02f, 4.75867204e-02f, 3.17223892e-02f, -4.51971404e-02f, -5.56180701e-02f, 1.81059703e-01f, 1.52293667e-01f, -3.49845961e-02f,
  3.02987695e-02f, -1.06368050e-01f, -2.70742327e-02f, 5.05618155e-02f, 3.00595090e-02f, -7.18740560e-03f, 4.39641885e-02f, 1.14178196e-01f, -3.10185086e-02f, 7.92392343e-02f,
  3.26277107e-01f, -3.72991204e-01f, 1.02090918e-01f, 3.08343470e-01f, -1.58846721e-01f, -5.22660851e-01f, 1.65116221e-01f, -2.45346650e-01f, 6.28181919e-02f, -2.52652675e-01f,
  -2.50241272e-02f, 2.09842727e-01f, 1.33610204e-01f, -4.68830913e-01f, -1.02201119e-01f, 1.78162362e-02f, -3.20839345e-01f, -1.18022777e-01f, 1.36254489e-01f, -7.18286261e-02f,
  5.90879917e-02f, -2.17349872e-01f, 8.90422389e-02f, -3.29761446e-01f, 1.95297264e-02f, 1.25904992e-01f, 1.10515423e-01f, 2.36569643e-01f, -2.41870627e-01f, 2.00172048e-02f,
  -5.73261529e-02f, 1.22715890e-01f, 7.17249513e-03f, -3.03499065e-02f, -1.07458070e-01f, 4.75447550e-02f, 5.02816252e-02f, 1.83041424e-01f, 9.48674902e-02f, -1.92643162e-02f,
  9.58206654e-02f, 7.16887787e-02f, -3.26745585e-02f, -2.98644193e-02f, -3.46011929e-02f, 3.71126980e-02f, -3.74222808e-02f, -1.52375158e-02f, -2.20575035e-02f, 9.87756625e-03f,
  1.57997049e-02f, -3.31550166e-02f, -4.31026779e-02f, -2.55994443e-02f, 3.99702154e-02f, -5.14666736e-03f, -6.83331341e-02f, 5.91996387e-02f, -5.09821475e-02f, -1.50901347e-01f,
  2.39441656e-02f, -4.29394953e-02f, -1.55125419e-02f, 3.45262629e-03f, -2.03528740e-02f, 8.47712681e-02f, 4.67129312e-02f, 6.42782822e-02f, 1.05360396e-01f, -4.76962626e-02f,
  -5.38097844e-02f, 4.53361645e-02f, -5.19092306e-02f, 8.38467758e-03f, 1.57928951e-02f, 1.30963419e-02f, 1.16354018e-01f, -7.01763993e-03f, 9.26837847e-02f, -5.23488820e-02f,
  5.34878410e-02f, -4.51815948e-02f, 3.35409418e-02f, 3.33099328e-02f, -4.58761491e-02f, 7.72181004e-02f, -3.80574390e-02f, 5.04940152e-02f, -2.94877973e-04f, -7.37019302e-03f,
  -2.20210403e-01f, -2.94199914e-01f, 1.67616028e-02f, 2.48996988e-02f, 2.88802814e-02f, -7.73057491e-02f, 4.69830818e-02f, -1.49266914e-01f, 3.78378816e-02f, -1.06288448e-01f,
  -6.98590055e-02f, 1.29973413e-02f, -2.02775691e-02f, 4.91929911e-02f, 6.36425391e-02f, -1.36753783e-01f, 8.41771737e-02f, 6.51740134e-02f, 5.83396104e-05f, -3.24861147e-02f,
  1.27921365e-02f, 1.17784394e-02f, -1.98666006e-02f, -6.20401651e-02f, -8.03935528e-02f, 1.72710642e-02f, -8.20728659e-04f, -1.61834266e-02f, 4.43801060e-02f, 4.03730990e-03f,
  5.72027624e-01f, -5.30705571e-01f, -3.38858157e-01f, -1.36276484e-01f, 2.29975775e-01f, 3.71530205e-01f, 4.65469211e-02f, -7.02121928e-02f, 1.67991459e-01f, -3.09673548e-01f,
  -1.00754261e-01f, -1.65517047e-01f, -2.43670300e-01f, -2.14279845e-01f, 4.84733224e-01f, -9.40695032e-02f, 7.46771023e-02f, -1.38472393e-02f, 8.78354162e-03f, -5.88333867e-02f,
  6.68222457e-02f, 4.88356836e-02f, -1.66427702e-01f, -7.20755383e-02f, -9.82108191e-02f, -1.05122782e-01f, -1.61945205e-02f, -1.00286536e-01f, -1.59006938e-01f, 4.28346992e-02f,
  -3.84417474e-02f, -1.42065689e-01f, -1.33078963e-01f, 4.29096911e-03f, 3.79447192e-02f, 7.42038339e-02f, 3.12346295e-02f, -4.81745191e-02f, 7.60632276e-04f, -2.41277982e-02f,
  -1.17845014e-02f, 4.88385968e-02f, -3.48476321e-02f, -1.51715772e-02f, 5.37187345e-02f, 5.09064365e-03f, 2.91291382e-02f, 5.12152426e-02f, -1.03027605e-01f, 5.02259890e-03f,
  2.55815429e-03f, -8.79795328e-02f, 4.02760990e-02f, -1.21766012e-02f, -4.91868481e-02f, 1.92086101e-02f, -9.93997138e-03f, -5.51757636e-04f, 3.92050892e-02f, 8.67555812e-02f,
  5.66423871e-02f, 7.17248709e-04f, -3.65728475e-02f, -2.52144523e-02f, -3.71123804e-03f, -1.09165860e-02f, -8.35608877e-03f, -3.23472619e-02f, 1.90861635e-02f, -1.16717732e-02f,
  6.41911700e-02f, 4.52261185e-03f, -1.01903798e-02f, 1.46167669e-02f, 6.60962909e-02f, -1.24459518e-02f, -2.84866802e-02f, -8.40536579e-02f, -8.96015391e-03f, 2.46279929e-02f,
  -5.24804443e-02f, 6.99922442e-02f, -1.11787975e-01f, -4.15162044e-03f, -1.21848509e-02f, 2.68660095e-02f, -2.78997272e-02f, -9.00221709e-03f, -7.48400390e-02f, 3.86619270e-02f,
  3.31610106e-02f, -6.73133060e-02f, -5.62232127e-03f, -2.07749195e-02f, -1.08396508e-01f, -5.96684963e-02f, 1.07385851e-02f, 7.93718770e-02f, -9.07931849e-03f, 5.68240844e-02f,
  -5.02090144e-04f, -5.93935922e-02f, 1.44681921e-02f, 1.66180488e-02f, 1.32334023e-03f, -5.63568957e-02f, -4.22351733e-02f, -4.63071875e-02f, 5.93631044e-02f, -3.95095423e-02f,
  -1.29118804e-02f, 1.09183036e-01f, -4.93770801e-02f, 2.40906216e-02f, 4.92254198e-02f, -1.06493710e-02f, 8.04124027e-02f, -5.05425297e-02f, -3.67199071e-02f, -4.01851647e-02f,
  -1.74646363e-01f, 2.33986288e-01f, 1.53976306e-01f, -2.89670169e-01f, -4.87041436e-02f, -8.25776234e-02f, -3.32161516e-01f, 1.19207554e-01f, 5.09072244e-02f, 5.18141463e-02f,
  -2.99397230e-01f, 5.59152924e-02f, -1.45977112e-02f, -4.49492276e-01f, -3.28918874e-01f, 3.95732038e-02f, -4.20113385e-01f, -2.25901812e-01f, 1.12177655e-01f, -1.56027779e-01f,
  -4.06724110e-04f, -3.55664402e-01f, -1.80559754e-01f, 2.66609818e-01f, -7.71204829e-02f, 2.83103406e-01f, -1.01129621e-01f, 2.51959056e-01f, -1.35891825e-01f, 3.27875875e-02f,
  -4.71903682e-02f, -8.86008590e-02f, 2.04511210e-02f, 1.28166482e-01f, -1.32881239e-01f, -3.12934369e-02f, -3.82461697e-02f, 2.85223946e-02f, 6.84574060e-03f, 7.86308721e-02f,
  6.00715838e-02f, 4.41436656e-03f, -1.64377186e-02f, 8.83077011e-02f, 8.01537484e-02f, 8.34547281e-02f, 2.31192764e-02f, 5.16824797e-02f, 1.38756456e-02f, -3.44021358e-02f,
  -1.48020713e-02f, -3.28664258e-02f, -1.09573528e-01f, -2.18373463e-02f, 2.59019006e-02f, -6.73727766e-02f, -3.75942327e-02f, -6.98207924e-03f, 4.24966663e-02f, 1.03900461e-02f,
  -7.36270770e-02f, -2.06996780e-02f, -6.59348965e-02f, 7.15412498e-02f, -1.48843778e-02f, 1.21306935e-02f, -3.86545056e-04f, -3.22267003e-02f, 1.12665527e-01f, -9.67972726e-02f,
  -7.65944785e-03f, -1.15500707e-02f, -1.24243125e-02f, 2.33137440e-02f, -1.11210652e-01f, 6.10145787e-03f, -2.54415888e-02f, 1.89346932e-02f, -2.26762611e-02f, -4.49683005e-03f,
  -2.65429672e-02f, -3.84003557e-02f, 7.35251978e-02f, 4.72004898e-03f, 3.07183471e-02f, 6.13079369e-02f, -4.69243862e-02f, 6.70070155e-03f, 2.89153103e-02f, -6.01396114e-02f,
  -6.67858943e-02f, -1.30745396e-01f, 6.28737807e-02f, -9.86060593e-04f, 1.01456337e-01f, 2.34909207e-02f, -1.91401858e-02f, 1.57383960e-02f, 1.01626582e-01f, -3.56104970e-02f,
  -8.74399841e-02f, -6.50538281e-02f, 5.90893067e-03f, 1.09917596e-02f, -2.90068295e-02f, -2.95987166e-02f, -9.47186276e-02f, -2.52330787e-02f, -1.09979928e-01f, 3.93176638e-02f,
  -6.21911511e-02f, -3.45639065e-02f, 1.85783561e-02f, 5.66300154e-02f, -7.09371874e-03f, -3.55931632e-02f, 7.57145323e-03f, 9.62065160e-02f, -1.09846674e-01f, -1.04385633e-02f,
  1.69862032e-01f, 3.24085742e-01f, -2.27762386e-01f, -1.45498306e-01f, 2.41148070e-01f, 1.57349676e-01f, -8.64531025e-02f, 2.56134152e-01f, -9.19294134e-02f, 3.05198759e-01f,
  3.72342616e-02f, 6.51094764e-02f, -1.57174036e-01f, 1.95510656e-01f, -3.45670998e-01f, -2.93849885e-01f, 1.41813576e-01f, 6.92245662e-02f, -8.22849721e-02f, 1.91592991e-01f,
  -1.61994040e-01f, 2.05321267e-01f, -2.17683926e-01f, 2.63683528e-01f, 1.69023186e-01f, -5.92946168e-03f, 7.22355917e-02f, -8.79852474e-02f, 1.88462645e-01f, -4.40085568e-02f,
  1.10841528e-01f, 2.54376009e-02f, -6.01129606e-02f, -5.07126302e-02f, 1.04055412e-01f, 8.14107433e-02f, -2.65334491e-02f, -8.98385644e-02f, -9.34447646e-02f, 1.31230392e-02f,
  1.90771278e-02f, -2.83675380e-02f, 2.28846315e-02f, -6.24867789e-02f, 1.73488870e-01f, -3.56614180e-02f, -3.99076343e-02f, -1.00382334e-02f, 1.82216112e-02f, -9.89707708e-02f,
  -2.55505461e-02f, -5.08333482e-02f, -4.76097949e-02f, -4.19955887e-02f, -1.50858864e-01f, -8.30983967e-02f, -1.07446909e-01f, -3.60677391e-02f, 5.63690439e-02f, 1.47689864e-01f,
  -6.86894581e-02f, 2.84015834e-02f, -4.20620367e-02f, -7.60908332e-03f, -4.54186089e-02f, -3.46943848e-02f, -1.77470073e-02f, -1.44899720e-02f, 3.13732438e-02f, 6.31341264e-02f,
  4.88899574e-02f, 2.79593859e-02f, -2.00610813e-02f, 1.97032448e-02f, -2.34198663e-02f, 5.61126648e-03f, -3.82554345e-02f, -2.95950187e-04f, 6.84264749e-02f, -2.08945647e-02f,
  -5.50921932e-02f, 7.03603104e-02f, 1.07428521e-01f, 2.44853385e-02f, -6.57694638e-02f, -6.51184693e-02f, 1.45802321e-02f, -3.86270857e-03f, -6.27036393e-02f, 1.27354106e-02f,
  3.01243752e-01f, 1.90090448e-01f, 1.99986473e-02f, 8.15138742e-02f, 2.50522345e-02f, 3.53932641e-02f, -6.07045963e-02f, 9.09059774e-03f, 6.38505816e-02f, -3.87938097e-02f,
  -7.47513073e-03f, 8.47585648e-02f, -3.60040031e-02f, 7.12682158e-02f, -1.22686587e-02f, 3.54323257e-03f, 4.22221273e-02f, 2.12089326e-02f, 9.14028361e-02f, 1.65365472e-01f,
  4.95040901e-02f, -3.47950831e-02f, -1.64303686e-02f, 3.45855430e-02f, 5.98729141e-02f, -5.83533570e-03f, 1.06893942e-01f, -9.63534191e-02f, 2.53696479e-02f, 3.76997702e-02f,
  2.28723750e-01f, -8.48712176e-02f, 1.66445255e-01f, 2.81169802e-01f, 1.19140968e-01f, -3.56758595e-01f, 6.14566468e-02f, 1.79980043e-02f, 1.77230805e-01f, -2.64223993e-01f,
  -2.02972978e-01f, 2.76244789e-01f, -3.20925266e-01f, -2.37198904e-01f, -5.66460341e-02f, -4.08277512e-01f, -1.24789752e-01f, -1.34657979e-01f, 4.74610664e-02f, 1.42091870e-01f,
  1.62359834e-01f, -1.51516318e-01f, 2.03110147e-02f, 1.39374714e-02f, 1.39963090e-01f, 3.29545438e-01f, 8.54365900e-02f, 1.37641072e-01f, 5.63754812e-02f, -3.15502919e-02f,
  -1.64813429e-01f, 5.46981059e-02f, 2.16451231e-02f, -6.97797686e-02f, 1.85337085e-02f, 8.55958369e-03f, -1.94777101e-02f, 1.22851292e-02f, 6.48500919e-02f, 3.80187519e-02f,
  -1.45155415e-02f, 2.80950032e-02f, 7.97530860e-02f, -7.87624344e-02f, 3.67137417e-02f, 3.14147137e-02f, -3.45181897e-02f, -1.85943656e-02f, 4.89278361e-02f, 1.47241242e-02f,
  9.75827593e-03f, -5.41324653e-02f, 9.43212882e-02f, -1.64975990e-02f, 1.37526497e-01f, 9.45231020e-02f, 1.06610961e-01f, 1.75701082e-02f, -7.38344043e-02f, 2.20192462e-01f,
  -1.14096120e-01f, 3.60428579e-02f, 3.18148471e-02f, -2.37131976e-02f, -1.18135987e-02f, 7.20028058e-02f, 4.21546698e-02f, 3.65882665e-02f, 2.65329313e-02f, -5.99402562e-02f,
  8.50975141e-02f, 2.35129781e-02f, -6.71365783e-02f, 9.23316255e-02f, 8.26825425e-02f, 2.28678063e-02f, 2.50091795e-02f, 1.86102334e-02f, 3.29992250e-02f, -3.65363844e-02f,
  -1.10264029e-02f, -4.93947454e-02f, 4.44325013e-03f, -1.24799497e-02f, -1.04846261e-01f, 4.87383455e-02f, -5.49050756e-02f, 4.00264226e-02f, -7.29805902e-02f, -4.58969995e-02f,
  -2.02765092e-01f, 1.19905271e-01f, 3.27652059e-02f, 7.32400566e-02f, 3.62260081e-02f, -8.40045884e-02f, 3.24448831e-02f, -2.64103673e-02f, -3.52851003e-02f, -7.23434612e-02f,
  8.69566866e-04f, 3.66821103e-02f, -3.39174233e-02f, -3.85899954e-02f, -5.35726584e-02f, -2.81535890e-02f, 6.07948564e-02f, 1.15564756e-01f, 1.51940240e-02f, -2.17675082e-02f,
  -1.66173950e-02f, -4.48408052e-02f, 5.02947234e-02f, 1.28620803e-01f, -2.51237601e-02f, -3.54733951e-02f, 6.74190745e-02f, 5.90288676e-02f, 4.08165678e-02f, -3.92589942e-02f,
  -3.75133693e-01f, 4.30304617e-01f, -2.27655143e-01f, -3.74962211e-01f, 3.84862453e-01f, 3.11006099e-01f, -8.85302760e-03f, 3.24919850e-01f, -2.18508750e-01f, 3.34359914e-01f,
  1.44051388e-01f, -3.44293624e-01f, 5.11094816e-02f, 2.78315544e-01f, -3.18938643e-01f, -1.34759441e-01f, -2.39063874e-01f, -2.40132585e-01f, -2.11935744e-01f, 7.95553103e-02f,
  -4.02519181e-02f, 4.51689065e-01f, 8.80250931e-02f, 4.29453164e-01f, 2.39550233e-01f, -1.10799119e-01f, 4.45414782e-02f, 3.04195452e-02f, 1.11812793e-01f, 8.15844089e-02f,
  2.38564685e-02f, 3.09806950e-02f, 2.06867848e-02f, 7.25956680e-03f, 5.74276485e-02f, 1.11250822e-02f, -1.24348357e-01f, 1.20704598e-03f, -5.14462069e-02f, -6.63618222e-02f,
  -8.89921635e-02f, 7.98308253e-02f, 5.53327836e-02f, -1.61700957e-02f, 1.13661617e-01f, -1.20462980e-02f, -1.21794771e-02f, 1.63418055e-02f, 5.54584302e-02f, 1.44721489e-04f,
  8.16911012e-02f, -6.54693991e-02f, -3.75555195e-02f, -4.33352813e-02f, -1.08555183e-01f, -9.03382301e-02f, 5.92516214e-02f, -3.02268118e-02f, -7.31774196e-02f, 7.80643597e-02f,
  4.75950055e-02f, 4.57361862e-02f, -7.84380734e-03f, 8.21193680e-03f, 2.79777721e-02f, -1.16817793e-02f, 7.05519989e-02f, -5.78865260e-02f, -2.09212169e-01f, 1.01444535e-02f,
  2.29360741e-02f, 4.63383039e-03f, 2.65942123e-02f, 1.68935657e-02f, -6.89448928e-03f, 5.85377403e-02f, -5.11557497e-02f, -9.45314020e-03f, -9.89609137e-02f, 7.20247179e-02f,
  4.98580635e-02f, -5.64262867e-02f, 2.82184165e-02f, 6.86984062e-02f, 1.18827999e-01f, -8.81716758e-02f, 7.64223468e-03f, 7.79086677e-03f, -5.23575433e-02f, 3.49747054e-02f,
  4.11305428e-02f, 1.14339605e-01f, 4.36969325e-02f, 2.91818939e-02f, 2.59201284e-02f, 8.58873352e-02f, -1.62005443e-02f, -1.68916062e-02f, -9.72345937e-03f, 1.02530867e-01f,
  -5.32516018e-02f, -3.52822132e-02f, -4.14363295e-02f, -7.12692589e-02f, -3.97358723e-02f, 1.50035039e-01f, -1.22464687e-01f, -2.67059449e-02f, -4.93275858e-02f, 3.22132036e-02f,
  8.83703306e-02f, -2.79620532e-02f, -3.23022163e-04f, 1.50016874e-01f, 4.62343991e-02f, -3.43691669e-02f, -3.48310843e-02f, -4.43484113e-02f, 2.88967416e-02f, -6.03220277e-02f,
  1.33705780e-01f, 9.49901994e-03f, -3.28648597e-01f, 1.86635658e-01f, -1.07087940e-01f, -3.13075751e-01f, 2.63349917e-02f, -1.95053548e-01f, -1.74299553e-02f, 1.40578166e-01f,
  4.91527796e-01f, -1.10749945e-01f, 2.22516045e-01f, 4.36878830e-01f, 1.25536621e-01f, 3.42840523e-01f, 1.26227364e-01f, 2.19507501e-01f, -3.86759713e-02f, -3.85661460e-02f,
  -1.02771819e-01f, 3.00279886e-01f, -2.24158317e-02f, -3.68787497e-01f, -3.03136301e-03f, -3.54314208e-01f, 2.18249038e-01f, -2.29800344e-01f, 3.29161771e-02f, 9.54573974e-02f,
  1.46050230e-01f, 2.59337664e-01f, 8.38343985e-03f, -1.41744748e-01f, -3.07458341e-02f, -3.74896005e-02f, -4.85424250e-02f, 1.79655477e-02f, -8.55492707e-03f, 3.36130559e-02f,
  -2.90050227e-02f, -8.84851292e-02f, -5.98168857e-02f, 4.16156240e-02f, -1.87467318e-02f, -3.06099169e-02f, 4.30585667e-02f, 6.07431456e-02f, -3.00522521e-02f, 4.13761884e-02f,
  7.36977160e-02f, -6.50008768e-02f, 2.53903568e-02f, 2.15482898e-02f, -1.70425683e-01f, -3.05374917e-02f, -6.50713518e-02f, -4.49158810e-02f, 1.07681472e-02f, -6.37314767e-02f,
  5.77011779e-02f, -7.99248368e-02f, 3.26994359e-02f, 1.27699766e-02f, 7.60564068e-03f, -1.50883244e-02f, -4.81832437e-02f, 5.60335303e-03f, -7.12030083e-02f, 3.09902336e-03f,
  -3.18573490e-02f, -8.10178649e-03f, -1.41753098e-02f, -2.08750851e-02f, 3.17937844e-02f, -6.75942423e-03f, -1.02559581e-01f, 3.84478155e-03f, -4.49120291e-02f, 4.92987176e-03f,
  2.16529537e-02f, -4.49177399e-02f, 2.11642664e-02f, -3.98364738e-02f, -4.46248846e-03f, -5.70375379e-03f, 3.99492048e-02f, -3.64767723e-02f, 7.54710892e-03f, -3.64231728e-02f,
  -4.55610678e-02f, -3.66537794e-02f, -6.38655946e-02f, -1.02319522e-02f, 4.69272695e-02f, 8.32103267e-02f, 3.30397040e-02f, -1.29532993e-01f, -7.43327895e-03f, -5.93510531e-02f,
  -9.65198576e-02f, 6.09507076e-02f, -1.46087959e-01f, 6.34746626e-02f, 1.07155694e-02f, 5.19339442e-02f, -2.63093058e-02f, -8.65151286e-02f, -7.08921477e-02f, -2.36054044e-02f,
  -4.15212438e-02f, -4.63428497e-02f, -1.15597360e-01f, -8.53064191e-03f, -7.53292292e-02f, 1.84215140e-02f, -6.45949990e-02f, -4.35483828e-02f, -2.67442074e-02f, -4.91145672e-03f,
  5.52066982e-01f, 9.56802815e-02f, 1.63363755e-01f, 3.55632842e-01f, 1.17236145e-01f, -1.83022469e-01f, -4.57779281e-02f, 2.01288328e-01f, 2.67642420e-02f, -9.32982489e-02f,
  -1.03277564e-01f, 3.02864105e-01f, -3.19878042e-01f, 3.45501363e-01f, 2.16097772e-01f, -3.14253688e-01f, 2.83028692e-01f, 1.30134583e-01f, -1.52690083e-01f, 2.49675065e-01f,
  1.93930045e-01f, 2.46737182e-01f, 1.36551335e-01f, -8.85318890e-02f, 1.42968327e-01f, -2.37950031e-02f, 1.45628572e-01f, -1.79099411e-01f, 1.47764787e-01f, 4.72085774e-02f,
  -1.16072528e-01f, 9.18027759e-02f, 9.30879936e-02f, -3.84404436e-02f, 7.03617036e-02f, -8.82109329e-02f, 2.82379240e-02f, -3.65543994e-03f, -5.52545562e-02f, -3.60234044e-02f,
  -3.72820348e-02f, 3.12523469e-02f, 4.43528816e-02f, -3.21012065e-02f, 1.81158651e-02f, 7.13786036e-02f, 2.76116990e-02f, -2.15661749e-02f, 3.47450748e-02f, 7.87749887e-02f,
  -2.70088241e-02f, -8.32614750e-02f, 1.07565425e-01f, 7.39534497e-02f, 6.84477463e-02f, -5.94949611e-02f, -1.05849719e-02f, 4.11775596e-02f, -5.34748472e-02f, 9.65331718e-02f,
  9.51502249e-02f, -4.92510712e-03f, -2.21787374e-02f, 2.31886562e-02f, -1.05650045e-01f, 3.21032442e-02f, -4.71788608e-02f, 1.19354673e-01f, -6.89169839e-02f, 2.89608967e-02f,
  1.31556243e-02f, 5.41748898e-03f, 4.70642149e-02f, -3.02677844e-02f, 3.35995667e-02f, 7.49053359e-02f, 2.41894294e-02f, -1.63841285e-02f, 3.30583043e-02f, 2.07708171e-03f,
  3.42021212e-02f, -5.11580333e-02f, -1.25078363e-02f, 4.49525788e-02f, -5.33665158e-02f, -1.97545812e-03f, 3.73754762e-02f, 8.56872126e-02f, -3.91098708e-02f, 7.24038780e-02f,
  1.55762155e-02f, 1.40342772e-01f, -3.43415253e-02f, -6.29748255e-02f, -6.00920022e-02f, 6.17414378e-02f, 7.51758441e-02f, 4.50707786e-02f, -9.69546810e-02f, 2.07026247e-02f,
  2.12649219e-02f, -4.74974560e-03f, -1.48325209e-02f, 1.76947620e-02f, -8.05665255e-02f, -1.50127048e-02f, -2.92707644e-02f, -9.33119804e-02f, 9.60419998e-02f, -5.87570015e-03f,
  9.32180416e-03f, -4.02109511e-02f, -3.32327858e-02f, 5.20400815e-02f, -1.04295823e-03f, 2.70595644e-02f, 1.51484460e-01f, -3.67793776e-02f, 9.97289643e-03f, -6.70123026e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.55551696e-01f, -4.78458464e-01f, 1.62844896e-01f, -3.53826761e-01f, 2.13305637e-01f, 7.26538837e-01f, 2.39126142e-02f, 1.12353690e-01f, -5.13448536e-01f, -2.06815928e-01f,
  -5.49353287e-02f, -6.51083231e-01f, -3.07606697e-01f, -4.39044058e-01f, -2.83093095e-01f, -4.58364546e-01f, 3.07838246e-02f, -1.09444626e-01f, -1.58804640e-01f, 5.19698709e-02f,
  -6.56226873e-02f, -2.41070285e-01f, 1.78920459e-02f, 2.29867160e-01f, 1.91964030e-01f, 1.10744592e-02f, 2.99408376e-01f, 2.03411698e-01f, 1.60618752e-01f, -1.85106725e-01f,
  2.30295993e-02f, -3.08683366e-01f, 7.38965943e-02f, 7.78033510e-02f, 4.76589859e-01f, 2.27256000e-01f, 2.61242211e-01f, -1.69181153e-01f, 2.11963374e-02f, -8.03071335e-02f,
  1.14094175e-01f, -5.74819185e-02f, -2.21615329e-01f, -4.69052941e-02f, -1.51915858e-02f, -7.95462728e-02f, 1.13452651e-01f, 2.05206618e-01f, -1.21858595e-02f, -6.78993836e-02f,
  3.81579250e-02f, -6.71723038e-02f, 8.41270164e-02f, -1.00013897e-01f, -1.43865481e-01f, -9.61432904e-02f, -9.54278931e-02f, 1.73152946e-02f, 1.86447427e-02f, -1.56790152e-01f,
  -9.88774598e-02f, 5.11164442e-02f, 2.75644213e-02f, 5.67304567e-02f, -1.48776487e-01f, 7.65516385e-02f, 3.17878947e-02f, -2.43409667e-02f, -2.63085514e-02f, 9.19013694e-02f,
  9.20482129e-02f, 2.78206132e-02f, 3.99034433e-02f, 5.74450493e-02f, -3.56933326e-02f, 2.52104495e-02f, 3.46799823e-03f, -1.13560800e-02f, -8.57222304e-02f, -8.31323266e-02f,
  -4.10951301e-02f, 1.38382226e-01f, -1.09011404e-01f, 5.91141842e-02f, -2.05082893e-02f, -9.29065049e-02f, -6.02904521e-02f, -6.41689897e-02f, 1.63039863e-01f, 4.95850034e-02f,
  2.64233023e-01f, 5.07052355e-02f, 8.61828253e-02f, -8.08134973e-02f, 1.17473863e-01f, 1.21968120e-01f, 3.41380127e-02f, -1.81835860e-01f, 5.51410727e-02f, -6.42780447e-03f,
  1.26098439e-01f, 7.61714485e-03f, 2.00221911e-01f, -1.13078967e-01f, -9.11646988e-03f, 1.79300532e-01f, -5.98589592e-02f, 8.05887878e-02f, 1.71506286e-01f, 3.83739918e-02f,
  2.95084193e-02f, 9.21789855e-02f, -8.36179629e-02f, -6.51014522e-02f, 6.15432709e-02f, -4.13384400e-02f, -8.47097766e-03f, -1.09007265e-02f, 2.20069513e-02f, -1.02313757e-01f,
  -3.12473178e-01f, 3.23839307e-01f, -4.05428298e-02f, -2.98299730e-01f, 3.19080800e-01f, -2.55829245e-01f, -3.06871593e-01f, 3.80402237e-01f, 4.07061398e-01f, -1.25818253e-01f,
  -1.18608043e-01f, -1.90959260e-01f, 2.21856028e-01f, -2.41791621e-01f, -3.34599257e-01f, 5.96710555e-02f, -3.53365719e-01f, -3.87283742e-01f, 2.62226373e-01f, -2.80540526e-01f,
  4.64004725e-02f, -1.43847033e-01f, -3.25038135e-01f, 2.62600690e-01f, -9.96634737e-02f, 6.08120896e-02f, -3.86711597e-01f, 2.64161140e-01f, -2.98678428e-01f, 5.81158027e-02f,
  -2.69735813e-01f, -7.59065747e-02f, -2.57430136e-01f, -1.57777190e-01f, -1.77353889e-01f, 3.61087359e-02f, -1.41905814e-01f, -3.58611532e-02f, -1.07674427e-01f, 2.66181733e-02f,
  -9.91714597e-02f, -2.66554803e-02f, 1.20011866e-01f, 1.88500807e-01f, 6.02953061e-02f, -1.63953006e-02f, -6.80821016e-02f, -2.15962231e-01f, 4.57618311e-02f, -9.47592780e-02f,
  5.76165551e-03f, 5.06352261e-02f, -2.52079908e-02f, -5.55116795e-02f, -1.53896585e-01f, -6.39356673e-02f, 6.89414970e-04f, -1.97344258e-01f, -4.63595651e-02f, -4.29477170e-02f,
  3.56296450e-02f, -1.03684254e-01f, -7.71198422e-02f, 1.11638188e-01f, 3.68356816e-02f, 8.22227001e-02f, 7.34210461e-02f, -5.09616248e-02f, 8.09349865e-02f, -4.44407985e-02f,
  2.86517646e-02f, -9.35815349e-02f, 1.14879556e-01f, -9.59035084e-02f, -8.16553161e-02f, -2.27353373e-03f, -2.52373755e-01f, 2.46938355e-02f, 2.40367532e-01f, -7.40508661e-02f,
  7.47048482e-03f, -7.13134035e-02f, 1.11161217e-01f, 1.31231159e-01f, -4.50947098e-02f, 1.47801355e-01f, 4.95865792e-02f, 8.49840865e-02f, 7.58826584e-02f, 5.54970950e-02f,
  -4.83062476e-01f, -4.36520815e-01f, -2.54633933e-01f, -5.06117418e-02f, -1.00270934e-01f, -1.31558895e-01f, -1.86150372e-01f, 1.87735725e-02f, -2.80753344e-01f, 7.16569945e-02f,
  6.44901320e-02f, -9.68620181e-02f, -4.23270203e-02f, 2.80202571e-02f, -1.56393766e-01f, -4.61899899e-02f, -2.75910616e-01f, -1.11114584e-01f, -2.41273642e-01f, -2.61796620e-02f,
  -6.37973100e-02f, 1.04776315e-01f, -5.33589050e-02f, 1.05924629e-01f, -1.43950418e-01f, -1.10751040e-01f, 2.46584360e-02f, -1.14407420e-01f, -8.24815854e-02f, 5.10131828e-02f,
  6.02509081e-01f, -1.41038239e-01f, -1.35199070e-01f, 3.65031213e-01f, 2.88248926e-01f, -7.30152428e-02f, -4.76677001e-01f, 1.89420909e-01f, -9.26294327e-02f, -4.36071873e-01f,
  5.52089559e-03f, -5.35238981e-01f, -3.33281368e-01f, 3.84194732e-01f, 2.71464139e-01f, 1.08570848e-02f, 3.69585991e-01f, -5.16209984e-03f, 2.95836508e-01f, 3.63147885e-01f,
  3.62457961e-01f, 4.70198214e-01f, 2.28909478e-01f, 3.09482604e-01f, 4.60719973e-01f, 2.94751935e-02f, 1.28078014e-02f, -2.25030154e-01f, 8.17542598e-02f, -4.52804938e-02f,
  1.69126466e-01f, 2.04053685e-01f, 1.08954653e-01f, -3.90098132e-02f, 2.38683105e-01f, 8.63652211e-03f, -9.03129503e-02f, -2.20062688e-01f, -9.81478915e-02f, -9.30672437e-02f,
  -6.81744590e-02f, 4.48686294e-02f, -2.32635345e-02f, -8.81517977e-02f, 9.87118408e-02f, 1.04465917e-01f, 7.17101544e-02f, 9.41663459e-02f, -8.69090483e-02f, 3.61207314e-02f,
  -1.42218880e-02f, -2.22672336e-02f, 3.77854519e-02f, -8.37170109e-02f, -1.54420659e-01f, -9.74901542e-02f, -1.44853160e-01f, -2.00436980e-01f, -7.28720203e-02f, -5.19616455e-02f,
  3.07471249e-02f, -4.04999442e-02f, 5.18741086e-04f, 6.00150265e-02f, -1.10339662e-02f, 1.28456205e-03f, -8.05422142e-02f, 3.83459963e-02f, -3.92547995e-02f, 4.59335558e-02f,
  -2.07820740e-02f, 2.66746581e-02f, 2.42460929e-02f, -7.95376822e-02f, 8.22102129e-02f, 4.89034355e-02f, -1.75810438e-02f, -4.36082967e-02f, -4.40474711e-02f, -7.57125067e-03f,
  5.43816248e-04f, 7.94394873e-03f, 4.20000125e-03f, -4.62086312e-02f, 5.44510968e-02f, -1.62317425e-01f, -1.03563126e-02f, -1.96607951e-02f, 2.50023529e-02f, 2.63845511e-02f,
  -4.38341200e-02f, -1.14779644e-01f, -5.07261679e-02f, -1.03290409e-01f, 4.11521792e-02f, 2.34573498e-01f, 8.16802233e-02f, 8.30329675e-03f, -3.44439074e-02f, -3.51413861e-02f,
  -7.04420209e-02f, -9.54518560e-03f, -1.48078173e-01f, 4.04234901e-02f, 1.18873708e-01f, -9.92824361e-02f, -1.28207266e-01f, -7.52702579e-02f, -9.04008746e-02f, 2.07556561e-02f,
  -5.99603057e-02f, -9.43123698e-02f, 4.54596840e-02f, 7.38556013e-02f, -7.93904886e-02f, -8.82180035e-02f, -8.78560692e-02f, -2.32351776e-02f, 7.13290498e-02f, -1.21314794e-01f,
  7.75852680e-01f, 1.03874490e-01f, 1.35758966e-01f, 5.32389522e-01f, 2.73984760e-01f, 2.39892125e-01f, 4.23653394e-01f, 3.00892651e-01f, 6.76773787e-01f, -1.36792317e-01f,
  -1.69943701e-02f, -1.86865944e-02f, -2.01030329e-01f, 2.35925421e-01f, 6.95834905e-02f, -7.03460053e-02f, 3.52680713e-01f, 2.15484992e-01f, 1.46575168e-01f, 3.16505760e-01f,
  3.28104228e-01f, 1.23892650e-01f, -5.56352511e-02f, -2.83397108e-01f, 1.57663286e-01f, -6.87011927e-02f, -4.09768552e-01f, -3.72234255e-01f, -3.17299992e-01f, -1.61512673e-01f,
  -1.52749068e-03f, 2.02760056e-01f, -6.41136393e-02f, -1.55232191e-01f, 1.43653661e-01f, -4.93511744e-02f, -1.02429032e-01f, -1.11319922e-01f, -3.01374588e-02f, -4.07434776e-02f,
  -1.78034529e-02f, 2.41615381e-02f, 3.93424556e-02f, -4.97220382e-02f, 1.40182182e-01f, 7.57358968e-02f, 9.38181803e-02f, 1.07845120e-01f, -5.59754260e-02f, 2.56259367e-02f,
  1.35369733e-01f, 9.23994929e-02f, 2.36854032e-02f, -4.27300110e-02f, -7.91551769e-02f, 5.59674986e-02f, -6.28503487e-02f, -4.01002876e-02f, -4.07838486e-02f, 9.21588913e-02f,
  -1.73994265e-02f, 3.51800397e-02f, 1.90295931e-02f, 2.35533901e-03f, 1.06112167e-01f, 7.09208623e-02f, 1.14317648e-01f, 5.02723409e-03f, 7.05804974e-02f, 3.81090939e-02f,
  2.77555641e-02f, 9.55605060e-02f, -2.50184387e-02f, 7.16803074e-02f, 3.83225530e-02f, 1.67683721e-01f, -1.06282622e-01f, -3.48686241e-02f, 7.56405294e-02f, 5.99127449e-02f,
  -5.24096303e-02f, 5.50726354e-02f, -1.68568000e-01f, -8.59210193e-02f, 3.07301222e-03f, 7.37281004e-03f, -9.06612128e-02f, -1.78320259e-02f, 1.53261013e-02f, -3.93151455e-02f,
  4.61336225e-02f, 1.52283162e-01f, -1.81682140e-01f, -1.23644173e-01f, 1.04939993e-02f, 7.97799882e-03f, 1.14732251e-01f, -4.21490110e-02f, -9.88603756e-03f, 1.51565857e-02f,
  2.28273887e-02f, 2.93814167e-02f, 3.93356681e-02f, -1.45970378e-02f, -1.84921741e-01f, 4.89223190e-02f, 3.81801166e-02f, 6.54323474e-02f, -2.06800967e-01f, -7.87669271e-02f,
  -2.78599467e-02f, 1.19544692e-01f, -3.68856601e-02f, 5.62632196e-02f, -2.90914010e-02f, -1.21492259e-01f, 8.84874836e-02f, 3.13304178e-02f, -9.99971852e-02f, -2.81317811e-02f,
  2.07959786e-01f, 5.93815386e-01f, 7.22924247e-02f, -1.48754567e-01f, 9.36021283e-03f, -4.13470268e-01f, -3.76130760e-01f, -1.61154628e-01f, -6.85329596e-03f, 2.50458747e-01f,
  -2.99085170e-01f, 4.72849190e-01f, -3.43072740e-03f, -3.19716424e-01f, -6.59428775e-01f, -2.44102925e-01f, -3.87643218e-01f, -1.42036110e-01f, 8.28567371e-02f, -2.49009848e-01f,
  -2.74288893e-01f, -4.59422857e-01f, -3.74901086e-01f, -1.74763411e-01f, -5.63478395e-02f, 3.25949818e-01f, -6.19408339e-02f, 6.80695698e-02f, -3.80018651e-02f, -1.07207999e-01f,
  -2.02560693e-01f, 1.37718141e-01f, 1.19781651e-01f, -4.06536534e-02f, -1.72839209e-01f, 4.62665670e-02f, 5.47853969e-02f, -6.65284544e-02f, -7.12985098e-02f, -1.41661659e-01f,
  1.50566339e-01f, -3.43116149e-02f, -7.00167120e-02f, -2.26187333e-02f, 1.02897629e-01f, 1.25943467e-01f, 4.78390083e-02f, -2.52014119e-02f, 2.27227993e-02f, -7.58309430e-03f,
  1.93371009e-02f, 6.48084357e-02f, -1.22388918e-02f, -2.15844642e-02f, -2.75375713e-02f, -6.78845774e-03f, -2.21160445e-02f, 9.42950323e-02f, 1.50622390e-02f, -5.80531284e-02f,
  8.27355832e-02f, -4.42996323e-02f, 4.00999794e-04f, 7.51861930e-02f, -1.60915002e-01f, 2.42577605e-02f, -1.40085509e-02f, 9.00052637e-02f, 9.36470181e-02f, -2.23675184e-02f,
  -4.35316153e-02f, 1.34808168e-01f, -4.49725054e-02f, -6.47424683e-02f, 7.77353486e-03f, 2.13207714e-02f, -1.29559170e-02f, 6.50008842e-02f, -6.67185783e-02f, -4.84613962e-02f,
  7.19956160e-02f, -6.96376935e-02f, 3.51188122e-03f, 3.84364165e-02f, -5.69954775e-02f, -1.30103594e-02f, 2.79887617e-02f, 6.70897737e-02f, -9.35863703e-03f, -1.21778712e-01f,
  -4.29546058e-01f, -2.32736185e-01f, -4.90226448e-02f, -1.53589225e-03f, -9.02096033e-02f, -5.54010505e-03f, -4.83718216e-02f, 1.06391154e-01f, -7.85891339e-02f, -2.02052698e-01f,
  5.20504341e-02f, -2.82186531e-02f, -3.01342774e-02f, -4.59313393e-02f, -3.19836475e-02f, -1.51588753e-01f, -2.53394116e-02f, 4.77057099e-02f, -8.49718973e-02f, 9.20669660e-02f,
  3.66526097e-02f, 9.92787108e-02f, 1.05540697e-02f, -3.71393003e-02f, 8.32946524e-02f, 1.63493101e-02f, -3.05981841e-03f, 1.84922874e-01f, -2.75958851e-02f, 8.44579339e-02f,
  -1.15162939e-01f, -2.40887552e-02f, 3.02224215e-02f, 9.53448042e-02f, -1.28066093e-01f, -1.71008974e-01f, -2.83521593e-01f, -6.95438012e-02f, -3.10642719e-01f, 8.94533768e-02f,
  -9.78819430e-02f, 7.18439221e-02f, -1.09643631e-01f, -4.52563435e-01f, 2.70897478e-01f, -1.84395686e-01f, 3.21582854e-02f, -5.08086868e-02f, -6.02875128e-02f, 3.84160101e-01f,
  1.34495258e-01f, -1.40701607e-01f, 1.16259038e-01f, 1.61451712e-01f, 5.58498390e-02f, 3.91161114e-01f, 5.36600828e-01f, 1.29727721e-01f, 2.74137527e-01f, -2.62047738e-01f,
  -2.36896724e-01f, -4.63301502e-02f, -1.35689229e-01f, -2.38062263e-01f, 2.67844409e-01f, 5.72688282e-02f, 2.16479048e-01f, -1.17655471e-01f, -8.39651525e-02f, -1.02621056e-02f,
  2.33162031e-01f, 5.71363838e-03f, -2.63095759e-02f, -7.86204562e-02f, -1.33880973e-01f, -8.10362026e-03f, -1.09141260e-01f, -5.18189706e-02f, -2.33888805e-01f, -9.77531672e-02f,
  -5.65880090e-02f, 4.68891710e-02f, 1.83022290e-01f, 6.54202402e-02f, 2.15946212e-02f, -1.99248958e-02f, 1.20664924e-01f, 3.00140828e-01f, -1.84146598e-01f, 1.81547180e-01f,
  1.07125893e-01f, -1.97798908e-02f, -1.90411787e-02f, -1.23518445e-01f, -2.63907760e-02f, -1.56765208e-02f, 6.39880374e-02f, -1.47464899e-02f, -4.65386882e-02f, -5.25521189e-02f,
  4.83137034e-02f, 1.49326056e-01f, -2.08266020e-01f, 5.91974035e-02f, 1.19761236e-01f, -1.66088000e-01f, -7.56493285e-02f, 6.51147664e-02f, 2.32340768e-01f, 1.31259501e-01f,
  -1.54856622e-01f, 8.69943723e-02f, 6.47998378e-02f, 6.87567666e-02f, -2.75759518e-01f, 1.86355978e-01f, 1.32383958e-01f, 5.38864285e-02f, 8.23029727e-02f, -5.55701070e-02f,
  2.13481113e-01f, 4.58304793e-01f, 1.01427168e-01f, -2.62531370e-01f, 4.01712283e-02f, -1.04755498e-02f, -1.46668211e-01f, -8.66660327e-02f, 3.58008116e-01f, 3.58310230e-02f,
  5.89042865e-02f, 1.47083104e-01f, 2.49941781e-01f, -2.20665231e-01f, -8.55672825e-03f, 3.11893046e-01f, 8.33084360e-02f, 2.13659897e-01f, 7.25416318e-02f, 2.73951352e-01f,
  1.29166692e-01f, 8.34214389e-02f, 5.67867160e-02f, -8.11190605e-02f, 6.15121871e-02f, 1.54618293e-01f, 4.08620946e-02f, -1.11929439e-02f, 1.38482107e-02f, -1.04913283e-02f,
  -1.12160407e-02f, -3.47872108e-01f, 4.05558288e-01f, -3.43918651e-01f, -3.61905880e-02f, -1.24716491e-01f, 8.34814906e-02f, -1.23980291e-01f, -3.85280758e-01f, -4.84690636e-01f,
  -1.61003590e-01f, -7.70904869e-03f, 5.54448724e-01f, -3.95271242e-01f, 7.59149015e-01f, 3.54218662e-01f, -3.51442903e-01f, -2.87695646e-01f, 6.56144395e-02f, -4.58704941e-02f,
  6.81891516e-02f, -3.13201040e-01f, 5.33042371e-01f, -2.36047581e-01f, -9.62143242e-02f, -9.69557017e-02f, 1.55768767e-01f, 3.23395252e-01f, -4.06859547e-01f, 7.67808408e-02f,
  -3.32707092e-02f, -3.09688188e-02f, 3.53148766e-02f, 1.94214601e-02f, 8.24841186e-02f, 6.41908124e-02f, 7.23733976e-02f, 2.50060648e-01f, 2.34026182e-02f, 3.45096877e-03f,
  -1.43490825e-02f, -3.11652366e-02f, -2.12717563e-01f, 1.11067787e-01f, -1.80693269e-01f, -5.54319099e-02f, 1.40317972e-03f, -3.97526920e-02f, 5.85473180e-02f, 1.62642315e-01f,
  1.75726101e-01f, -1.60525769e-01f, -5.36259310e-03f, -2.32426971e-02f, 1.91157252e-01f, -1.85947582e-01f, -6.56057447e-02f, 1.16742132e-02f, -1.94353580e-01f, -9.70883742e-02f,
  4.07948345e-03f, -1.27071545e-01f, -1.02196418e-01f, -8.99156779e-02f, 1.32078156e-01f, -9.21956673e-02f, 7.40023926e-02f, 4.11080010e-02f, -2.02595480e-02f, -9.51690003e-02f,
  -5.97041287e-02f, -1.39174625e-01f, -1.13027245e-02f, 6.94571435e-03f, -1.44537464e-01f, -6.23403825e-02f, -3.46917026e-02f, 8.90848935e-02f, -8.56499970e-02f, -4.04547043e-02f,
  2.09818035e-02f, -2.21137907e-02f, -1.16000853e-01f, 1.44019434e-02f, -8.22046325e-02f, 2.10894436e-01f, -1.73001155e-01f, -1.43541306e-01f, -5.19378446e-02f, 2.28866383e-01f,
  2.68388987e-02f, 5.03337942e-02f, -4.08696104e-03f, -1.45661443e-01f, 6.54085204e-02f, -7.37594441e-02f, -7.51549080e-02f, -1.22607939e-01f, -3.90224531e-02f, 2.84628421e-02f,
  -1.57816857e-01f, -6.47595301e-02f, -1.67096153e-01f, 2.52464935e-02f, -7.60987848e-02f, -1.71305686e-01f, 3.27986553e-02f, -1.01971850e-01f, 5.40321320e-02f, -1.64980050e-02f,
  1.93165634e-02f, -2.26078015e-02f, 1.47015467e-01f, -9.28507522e-02f, -4.02149037e-02f, -3.13398317e-02f, 2.11537555e-02f, -7.73961768e-02f, 3.55824195e-02f, -5.31672090e-02f,
  3.77588868e-01f, -3.62950861e-01f, 2.80862987e-01f, 1.66469872e-01f, 9.20186564e-02f, 1.73633382e-01f, 4.23670053e-01f, -3.10571283e-01f, -4.95703399e-01f, -3.04062754e-01f,
  -1.82583317e-01f, 4.58524048e-01f, -5.34080109e-03f, -3.18996459e-02f, 3.98958743e-01f, -2.27447242e-01f, -1.81342196e-02f, 1.27173856e-01f, -1.96163937e-01f, 2.37419754e-02f,
  -9.55551937e-02f, -1.82441264e-01f, 2.50608474e-01f, -3.74022007e-01f, 1.63680270e-01f, -7.06998748e-04f, -2.15252236e-01f, 1.60001397e-01f, 6.58391342e-02f, 2.67856896e-01f,
  -5.42995930e-02f, -2.76877433e-01f, 1.17547803e-01f, 4.44266573e-03f, -1.88275147e-02f, 1.54394507e-01f, 1.54491052e-01f, 1.66693121e-01f, 5.51182441e-02f, 6.75620809e-02f,
  9.50687230e-02f, 1.21626884e-01f, -5.82532212e-02f, 8.17035437e-02f, 4.42799591e-02f, -1.18231764e-02f, 5.93807362e-02f, -1.91892348e-02f, 8.80627632e-02f, 9.73857567e-02f,
  1.74305350e-01f, 8.94064158e-02f, -1.18852988e-01f, -7.25998655e-02f, -5.17112426e-02f, 6.23666868e-03f, 2.16674823e-02f, 2.24077031e-01f, 3.57034281e-02f, -5.14552109e-02f,
  -2.38737911e-01f, -1.37878016e-01f, -2.41374113e-02f, 8.92740041e-02f, 1.25881359e-01f, -7.72782490e-02f, 3.13683785e-02f, -6.02854881e-03f, 8.61759186e-02f, 4.56178896e-02f,
  8.68869796e-02f, 7.94268698e-02f, -9.01769623e-02f, -4.92626987e-02f, 4.44022566e-03f, -1.37216598e-01f, 1.23069614e-01f, 4.93798987e-04f, -8.50164294e-02f, -1.34780370e-02f,
  -4.30174805e-02f, -8.56422726e-03f, -9.15502943e-03f, 5.32341041e-02f, -9.47827846e-02f, -1.50581682e-02f, -4.18667048e-02f, 8.28027427e-02f, -1.58761173e-01f, 8.05149004e-02f,
  -3.19651127e-01f, -4.85479355e-01f, -9.15766954e-02f, -4.49276008e-02f, 2.74282061e-02f, 2.20266022e-02f, -8.86970311e-02f, -8.51389244e-02f, -2.91326959e-02f, -7.97939524e-02f,
  -9.92262363e-02f, 7.36680850e-02f, -1.04148269e-01f, 4.13155481e-02f, -4.44648378e-02f, -1.31238833e-01f, 5.16097732e-02f, -9.19081420e-02f, 1.24661922e-01f, -3.70086320e-02f,
  -2.86155380e-03f, 4.70798500e-02f, -3.11541161e-03f, -1.49843236e-02f, -1.54776037e-01f, 1.15406983e-01f, -7.85635561e-02f, 7.24312384e-03f, 5.77538870e-02f, -5.25592417e-02f,
  3.74551326e-01f, -6.55422509e-01f, 9.72063541e-02f, 4.03995991e-01f, 2.91479677e-01f, 1.07511200e-01f, 4.01807874e-01f, -2.65274346e-01f, -1.50384367e-01f, -5.30151844e-01f,
  1.44491419e-01f, -8.19448978e-02f, -1.26555592e-01f, -1.77270621e-02f, 5.00995278e-01f, -2.09353313e-01f, 1.25801206e-01f, 7.03705773e-02f, -6.73412830e-02f, -1.75327912e-01f,
  1.19778723e-01f, 8.11013132e-02f, 2.57918358e-01f, -2.52723813e-01f, 4.95188162e-02f, -9.56010148e-02f, 7.64848739e-02f, 7.73029327e-02f, 9.38289892e-03f, 1.69666767e-01f,
  -7.26120993e-02f, -1.02971688e-01f, 1.23424478e-01f, -1.06691897e-01f, -1.01112984e-01f, 3.60093601e-02f, 4.47077071e-03f, 1.86927482e-01f, 2.26927131e-01f, 1.19420616e-02f,
  -4.77714725e-02f, -2.93591470e-02f, 3.58224511e-02f, 5.34195155e-02f, -6.78830221e-03f, -1.70428399e-02f, -4.05659415e-02f, -6.80633634e-02f, -3.01708896e-02f, -3.16803195e-02f,
  -3.22346315e-02f, -6.59173056e-02f, 7.71303400e-02f, -2.89275944e-02f, 1.20629869e-01f, 4.19598781e-02f, 1.30692750e-01f, 2.05653496e-02f, -1.80598989e-01f, -1.45813068e-02f,
  -1.00416787e-01f, -3.20877433e-02f, -8.36522058e-02f, -3.19483988e-02f, -4.38415483e-02f, 3.83635983e-02f, 7.76618300e-03f, 1.52453715e-02f, -7.30942935e-02f, -7.46729970e-02f,
  8.17661658e-02f, -2.27916781e-02f, -1.82422716e-02f, -1.84197314e-02f, 2.04479881e-02f, 7.63128102e-02f, 5.58767207e-02f, -2.14357805e-02f, 1.18593954e-01f, 5.26166148e-02f,
  -3.35595608e-02f, -1.44992797e-02f, -8.82439837e-02f, 1.82776786e-02f, -3.33769955e-02f, -5.54702021e-02f, -5.68722114e-02f, -8.97966176e-02f, -4.19315733e-02f, 1.14785351e-01f,
  -5.30222595e-01f, -6.64482236e-01f, -6.42467365e-02f, -6.79827780e-02f, -4.03375067e-02f, -1.28184304e-01f, -8.15794840e-02f, -1.05947264e-01f, -1.50739908e-01f, -9.71153751e-03f,
  -5.56913465e-02f, 6.50516376e-02f, -6.43210113e-02f, 4.36484367e-02f, 1.78551730e-02f, -1.08181767e-01f, -2.45496519e-02f, 2.21290588e-02f, 4.96778898e-02f, -1.23278521e-01f,
  -3.29868905e-02f, -1.27825169e-02f, 1.42671749e-01f, 2.41433289e-02f, -5.26029095e-02f, 5.23519553e-02f, -2.20440309e-02f, -8.50936100e-02f, 4.59105596e-02f, -7.05645978e-02f,
  4.19005156e-01f, 1.35550067e-01f, -4.15271968e-01f, -3.92155379e-01f, 1.43634364e-01f, 6.23690724e-01f, -2.32866988e-01f, 2.87055224e-02f, -4.62385148e-01f, -1.29564956e-01f,
  -2.43927743e-02f, 1.06569223e-01f, -5.21664500e-01f, 4.13486630e-01f, 2.92661190e-01f, -9.90927443e-02f, 3.44028920e-01f, 2.80509830e-01f, 1.57314628e-01f, 2.30901003e-01f,
  8.99283513e-02f, 5.45919657e-01f, -2.26470351e-01f, 4.60103393e-01f, 2.28351548e-01f, -8.39805454e-02f, -2.45579466e-01f, -2.23371372e-01f, 3.52212191e-01f, 2.41338879e-01f,
  6.50619641e-02f, -1.37862056e-01f, -4.48979437e-02f, 1.46164492e-01f, -8.13668370e-02f, 1.07869215e-01f, 8.41565654e-02f, 1.45803675e-01f, -1.01269454e-01f, -1.19572863e-01f,
  -9.11189243e-02f, 1.17759824e-01f, 1.08056486e-01f, 3.83532420e-02f, 9.87197608e-02f, 2.95248814e-02f, 8.42065588e-02f, -1.98723022e-02f, 3.34273092e-02f, -8.75135011e-04f,
  -1.99071899e-01f, 1.51645141e-02f, -1.17359318e-01f, -1.01846091e-01f, -7.83065632e-02f, 3.89922708e-02f, -4.93058898e-02f, -9.63369161e-02f, 1.34763584e-01f, 3.61058339e-02f,
  1.41138703e-01f, -3.11171059e-02f, 9.62952748e-02f, 2.49175150e-02f, 4.39715460e-02f, -2.17815842e-02f, -5.16277626e-02f, 3.22141759e-02f, 4.57130000e-03f, 5.16687706e-02f,
  -1.67200387e-01f, -1.57497991e-02f, -2.28252597e-02f, 3.86749511e-03f, 2.99401451e-02f, 5.21730445e-02f, -3.77511419e-02f, -1.72027647e-02f, -3.71143362e-03f, -7.36316666e-02f,
  -4.90850881e-02f, 1.68784827e-01f, 2.73830164e-02f, -9.19469893e-02f, 7.77871236e-02f, -1.56839103e-01f, -8.25631712e-03f, 3.92223969e-02f, -1.01347446e-01f, -1.17551543e-01f,
  9.73457284e-03f, -3.41728404e-02f, -7.76627809e-02f, 7.96568617e-02f, -1.17448457e-02f, 1.53299034e-01f, 7.71248639e-02f, 1.22559056e-01f, -3.17151509e-02f, 1.75100282e-01f,
  -1.63212139e-02f, -1.11360520e-01f, -2.32547824e-03f, 5.71845472e-02f, -1.37862274e-02f, 1.00281067e-01f, -1.08050518e-01f, -1.74445733e-01f, -9.86085236e-02f, 7.14987963e-02f,
  5.10944277e-02f, -4.93628122e-02f, -6.38915375e-02f, 8.17458611e-03f, -7.14404043e-03f, -1.31246909e-01f, 1.31618470e-01f, 4.35525551e-02f, 3.23189087e-02f, -7.51921013e-02f,
  2.90936857e-01f, 4.44875300e-01f, 3.41767758e-01f, 1.67153284e-01f, -2.15811864e-01f, -3.82681102e-01f, -3.09142292e-01f, -3.18832099e-01f, -2.83530325e-01f, 1.11728184e-01f,
  -4.47674721e-01f, 3.96562725e-01f, -4.28652972e-01f, -1.41783863e-01f, -3.51877600e-01f, -3.43487591e-01f, 1.83864161e-01f, 4.07921821e-02f, 4.22026291e-02f, 2.39488810e-01f,
  -8.83354619e-02f, -3.92586976e-01f, -1.60843536e-01f, -3.35619360e-01f, 4.22674835e-01f, 2.72387922e-01f, 2.87382960e-01f, 7.66266929e-03f, 3.65244329e-01f, -7.21513554e-02f,
  -1.43350765e-01f, -6.48410246e-02f, 5.38004041e-02f, 1.18449561e-01f, 8.43903348e-02f, 1.38282180e-01f, 1.43816784e-01f, -9.31794047e-02f, -1.07743964e-01f, 5.01681082e-02f,
  5.72591498e-02f, -8.61962587e-02f, 6.55803010e-02f, -1.31538540e-01f, 1.88009515e-02f, 1.09597020e-01f, 1.11964330e-01f, 1.96049362e-01f, 4.84341122e-02f, 8.58040303e-02f,
  4.76082638e-02f, 1.17694147e-01f, 1.24797985e-01f, 1.86892331e-01f, 2.18196828e-02f, -3.64852585e-02f, 1.92951486e-01f, 1.88957140e-01f, 2.40449876e-01f, 6.36518300e-02f,
  7.25344494e-02f, 1.35821342e-01f, -4.72369455e-02f, -5.39088957e-02f, -1.16137095e-01f, -1.29832208e-01f, 8.15656111e-02f, -1.46064356e-01f, -9.26075317e-03f, 3.79226841e-02f,
  -1.48228742e-02f, -6.47837967e-02f, -2.83072535e-02f, 6.31997138e-02f, -2.94320639e-02f, 4.63837944e-02f, -8.20679367e-02f, 5.44952303e-02f, 1.35513544e-01f, -2.15228014e-02f,
  -3.03240959e-02f, -3.01306844e-02f, -1.32970521e-02f, -4.16010953e-02f, -1.76519185e-01f, -4.00671810e-02f, 4.12172377e-02f, -4.95355390e-02f, 1.23435799e-02f, -6.34452328e-02f,
  1.12801582e-01f, 3.21637928e-01f, -4.61251400e-02f, -7.62444809e-02f, 8.87303203e-02f, 1.29501939e-01f, -8.54778960e-02f, -2.20220312e-02f, 1.26821458e-01f, -8.08083341e-02f,
  1.20731354e-01f, 4.24104221e-02f, 2.06807673e-01f, 1.72896292e-02f, -1.41919568e-01f, -5.81851527e-02f, 1.85926398e-03f, 4.48606722e-02f, 1.24754936e-01f, -2.52791122e-02f,
  2.19393432e-01f, 1.45844175e-02f, 1.55594700e-03f, 2.18022000e-02f, 8.33042637e-02f, 2.09682658e-01f, 4.83434834e-02f, -5.58544844e-02f, 2.55875945e-01f, 7.96990693e-02f,
  -1.12702571e-01f, 2.65673280e-01f, -4.71324712e-01f, 6.08720118e-04f, -3.30712527e-01f, 1.30915567e-01f, 3.64867330e-01f, -4.01627161e-02f, -2.43359178e-01f, 5.40324628e-01f,
  2.95805335e-01f, -3.16337407e-01f, 3.84918749e-01f, 5.11787832e-01f, -4.22204673e-01f, 2.55111963e-01f, 3.10304046e-01f, 2.92080015e-01f, -2.94822276e-01f, 4.47759360e-01f,
  -1.60218149e-01f, 5.29503107e-01f, -7.24929897e-03f, -9.24737658e-03f, 1.34878844e-01f, -1.16008207e-01f, 3.14638376e-01f, -3.55113536e-01f, 1.73686400e-01f, -3.52011859e-01f,
  -5.84306866e-02f, -1.46375056e-02f, 9.25254426e-04f, -6.13988340e-02f, 1.48988754e-01f, 1.24915384e-01f, 2.16396581e-02f, -1.35409623e-01f, -2.22743005e-01f, 5.33911660e-02f,
  8.00755098e-02f, -8.83811936e-02f, -4.13377509e-02f, -1.69168621e-01f, -1.02569997e-01f, -1.26195759e-01f, -1.33725971e-01f, -5.08775339e-02f, -9.01707858e-02f, -4.32621874e-02f,
  -9.80584398e-02f, 2.73435493e-03f, 8.03075954e-02f, 1.04293965e-01f, -1.17916644e-01f, 8.23194087e-02f, 3.84973886e-04f, -5.05606234e-02f, -1.20512918e-02f, -8.63829926e-02f,
  4.09525521e-02f, 2.18238644e-02f, 1.10813715e-01f, 3.33566517e-02f, -1.21484518e-01f, 6.13728911e-02f, -1.77578572e-02f, 3.51252258e-02f, -6.86653778e-02f, 1.59444988e-01f,
  -9.77698620e-03f, -5.22042103e-02f, -7.13520078e-03f, 6.80460557e-02f, 1.29350632e-01f, 6.97328225e-02f, -6.75529838e-02f, -6.71248734e-02f, 1.02029137e-01f, -7.64833689e-02f,
  -3.23748179e-02f, -7.54751191e-02f, -4.35169637e-02f, 1.06764875e-01f, 6.06832467e-02f, 2.63630655e-02f, 4.06849422e-02f, -1.87462084e-02f, -3.69589254e-02f, -6.21740567e-03f,
  1.45920634e-01f, 3.37592751e-01f, -9.88949463e-03f, 2.47568451e-02f, 6.50459900e-02f, 7.86710754e-02f, -2.10912507e-02f, 3.18086408e-02f, -1.18777484e-01f, 1.32406622e-01f,
  1.76755369e-01f, 6.00125082e-02f, 1.87711015e-01f, -1.21484987e-01f, -1.05502032e-01f, 2.40598351e-01f, 1.74903691e-01f, -1.14626221e-01f, -6.10251026e-03f, -8.48432630e-02f,
  1.43142834e-01f, 9.52017158e-02f, 6.87660947e-02f, 2.96480604e-03f, 1.27009004e-01f, 1.75305530e-01f, -1.40260682e-01f, -7.38762766e-02f, -4.31354949e-03f, -9.56410728e-03f,
  6.67950511e-01f, -6.58556595e-02f, 3.46017361e-01f, 5.16208231e-01f, -1.51371703e-01f, -1.82536282e-02f, 5.40060878e-01f, -2.53612697e-01f, 5.77387989e-01f, -3.17145377e-01f,
  -4.69828993e-01f, 5.78233659e-01f, -3.65521938e-01f, -1.18796743e-01f, -3.65217845e-03f, -1.86324701e-01f, 3.06662302e-02f, 3.73240590e-01f, 6.95126131e-02f, 1.88421816e-01f,
  7.28261545e-02f, -4.16970640e-01f, -2.11234882e-01f, -3.51839691e-01f, 4.37443666e-02f, 1.86144412e-01f, -4.49150890e-01f, -1.61927506e-01f, -1.17282398e-01f, -5.11544496e-02f,
  -3.10554713e-01f, 3.93154211e-02f, 6.49584690e-03f, 5.20243272e-02f, -8.22817311e-02f, 5.42731546e-02f, 1.57947727e-02f, -3.93369645e-02f, -4.17661816e-02f, 1.06161475e-01f,
  1.73560068e-01f, -8.75778645e-02f, -8.12795162e-02f, 5.84114268e-02f, 2.48913392e-02f, -3.83246853e-03f, -1.30584920e-02f, 3.85361258e-03f, 1.12806723e-01f, 3.59494351e-02f,
  1.61359161e-01f, 1.29994156e-03f, -6.41548634e-02f, -2.42029559e-02f, 7.85782337e-02f, -1.46204317e-02f, 1.99199587e-01f, -3.85740288e-02f, 1.17030293e-02f, 1.03621349e-01f,
  1.02713563e-01f, 5.72366267e-02f, -4.36271764e-02f, -4.03159633e-02f, -5.57412803e-02f, -3.41141969e-02f, 5.83666936e-02f, -1.29124910e-01f, 1.24790683e-01f, -5.20943291e-03f,
  -7.48867616e-02f, 5.36708049e-02f, 2.36123540e-02f, -3.92458169e-03f, 6.73607066e-02f, 1.67743176e-01f, 1.80745148e-03f, -3.83655317e-02f, 2.35397276e-02f, 5.93981482e-02f,
  6.94406126e-03f, 9.62829590e-02f, -1.38930768e-01f, 6.73926845e-02f, 6.84903655e-03f, -8.16779137e-02f, -1.85378149e-01f, 9.33698639e-02f, 1.12661302e-01f, -9.92680788e-02f,
  -3.73686194e-01f, -1.40385389e-01f, 8.15932527e-02f, 5.01217246e-02f, 9.64405537e-02f, -1.00443929e-01f, 9.86256972e-02f, 6.19987473e-02f, 1.78674329e-02f, 1.00498185e-01f,
  -1.55517116e-01f, 5.70420586e-02f, -2.18905676e-02f, -2.24155411e-02f, 2.44370978e-02f, -4.45478372e-02f, 1.31031889e-02f, -4.46425788e-02f, -1.40935987e-01f, -6.92282841e-02f,
  -8.57116133e-02f, 4.77555357e-02f, 1.04390919e-01f, 5.65059632e-02f, 6.75587431e-02f, -1.41380087e-01f, 4.44866568e-02f, 3.51812430e-02f, -7.76962712e-02f, -7.70691112e-02f,
  3.63207787e-01f, -3.37404490e-01f, -6.28314987e-02f, 2.75062591e-01f, 2.13853836e-01f, -1.06740437e-01f, -1.28819063e-01f, 3.04513901e-01f, 1.30164310e-01f, -2.14476794e-01f,
  2.01661438e-01f, -2.05367729e-01f, -2.25012124e-01f, 3.54872674e-01f, 5.62707543e-01f, -1.34370342e-01f, 3.80065650e-01f, 9.60585568e-03f, 7.24686086e-02f, 2.51094639e-01f,
  2.71376103e-01f, 4.70375508e-01f, 2.92400956e-01f, 2.62670666e-01f, 2.93083847e-01f, 1.69861186e-02f, 2.24476874e-01f, -8.06725919e-02f, 2.32596144e-01f, 1.56298757e-01f,
  4.46912944e-02f, 1.45016357e-01f, 1.15414254e-01f, 5.58999777e-02f, -8.47885385e-02f, -1.77442893e-01f, -1.94008768e-01f, 1.11260498e-02f, -3.89561132e-02f, -4.86234240e-02f,
  -4.91275452e-02f, -5.98910563e-02f, 1.69260800e-01f, 6.86526000e-02f, -1.58772785e-02f, -8.79565403e-02f, -7.19703808e-02f, -1.84635390e-02f, -1.08621113e-01f, -6.27339557e-02f,
  -1.17596827e-01f, 9.62827727e-03f, 9.73720998e-02f, 9.19329524e-02f, 1.31173685e-01f, -1.46558378e-02f, -1.82767779e-01f, -5.85528538e-02f, -3.63928005e-02f, 5.78202233e-02f,
  1.00251354e-01f, -8.98112282e-02f, -1.33061484e-01f, 1.12212405e-01f, 1.52182654e-02f, 1.24009050e-01f, 6.95508942e-02f, -4.99499850e-02f, -2.38793138e-02f, -7.74248391e-02f,
  3.58326733e-02f, 1.33850425e-01f, -2.48241834e-02f, -5.89315929e-02f, 6.83046803e-02f, -4.08806689e-02f, -5.32123558e-02f, 7.74855912e-02f, 3.44026648e-03f, 3.63716222e-02f,
  3.54442932e-02f, 1.73859075e-02f, -6.35737404e-02f, -7.78664500e-02f, 4.21257094e-02f, 5.60807697e-02f, 7.46179298e-02f, 2.14325879e-02f, 2.11450495e-02f, -2.45755091e-02f,
  7.88560659e-02f, 1.68415412e-01f, 1.22698702e-01f, 8.88845138e-03f, -3.50693725e-02f, 1.51885703e-01f, 2.17807237e-02f, 1.48233697e-01f, 1.66809067e-01f, 1.96655035e-01f,
  3.87597084e-02f, -2.84426641e-02f, 7.66720809e-03f, 1.20096924e-02f, -9.84722376e-02f, 1.23137616e-01f, 2.49520764e-02f, -3.12451366e-02f, 6.75019575e-03f, 1.01706892e-01f,
  1.90114677e-01f, -2.93285120e-02f, 2.33087037e-02f, 6.27817307e-03f, 3.42993550e-02f, -7.90977553e-02f, -1.64250322e-02f, -5.04847951e-02f, 2.44169906e-02f, 2.38471441e-02f,
  5.69244683e-01f, -5.72654784e-01f, -3.61175299e-01f, 2.60539055e-01f, 2.34037906e-01f, -2.80599713e-01f, -2.93121666e-01f, -5.51102459e-02f, 4.86252397e-01f, -3.44738096e-01f,
  1.46570638e-01f, -2.63679683e-01f, -2.31182918e-01f, -1.61072776e-01f, 3.43694746e-01f, 4.61193398e-02f, -1.30684599e-01f, -1.41302302e-01f, 1.11997411e-01f, -5.81013411e-02f,
  2.61780262e-01f, -2.02022027e-02f, -3.00596118e-01f, -3.22664678e-01f, -2.95180947e-01f, -2.30168551e-01f, -5.68728074e-02f, -3.48528743e-01f, -3.50871474e-01f, -1.40625045e-01f,
  -3.54776904e-02f, 1.31990328e-01f, -4.27775048e-02f, -8.62155184e-02f, 7.66608566e-02f, 5.61965443e-02f, -1.66481897e-01f, -1.28024548e-01f, 7.94175267e-02f, 2.55535711e-02f,
  -1.33552447e-01f, 1.27365952e-02f, -2.11266410e-02f, -5.76337613e-02f, -6.72790632e-02f, 7.06316531e-02f, 1.29397735e-01f, 8.59206319e-02f, -1.17579378e-01f, -3.34711038e-02f,
  -6.79348633e-02f, -7.69947097e-03f, 1.11236691e-01f, -1.08617403e-01f, 1.74503818e-01f, 9.85273346e-02f, -9.46580693e-02f, -4.02630679e-02f, -3.10552157e-02f, 1.68959275e-02f,
  -9.96466279e-02f, -6.96020201e-04f, 6.27049208e-02f, 1.86432470e-02f, 7.30061380e-04f, 7.91224390e-02f, 4.90167066e-02f, -2.26185713e-02f, 1.38053641e-01f, 4.03294340e-02f,
  6.25932962e-02f, -4.95367125e-02f, 1.18712209e-01f, -3.32850777e-02f, 9.42459702e-02f, -1.70724299e-02f, -2.76571661e-02f, -7.41381245e-03f, 2.39029065e-01f, 5.19359037e-02f,
  -1.25496238e-01f, 5.93021102e-02f, -5.33064678e-02f, -8.24608058e-02f, -1.20499969e-01f, -5.83954155e-03f, 5.55734448e-02f, -1.44743491e-02f, -1.25113474e-02f, -1.94065925e-03f,
  -8.16949904e-02f, -4.57342416e-01f, -4.51901276e-03f, -1.01629682e-01f, -1.41644120e-01f, 1.64715305e-01f, -7.28465244e-02f, 5.12762107e-02f, -2.14712381e-01f, -4.98533919e-02f,
  -7.18151033e-02f, -2.62082424e-02f, 1.01625487e-01f, 9.74901393e-02f, -1.20881729e-01f, 2.70182989e-03f, 1.53316441e-03f, 8.12199861e-02f, 2.85221636e-02f, -1.75494224e-01f,
  -1.24599710e-01f, -4.39935923e-02f, 5.43620661e-02f, 6.14744648e-02f, -1.38548287e-02f, -2.20997054e-02f, -1.73307043e-02f, 2.25979351e-02f, 9.53700542e-02f, 5.92618734e-02f,
  -1.42254427e-01f, -3.61153305e-01f, 4.19021994e-01f, 1.03396595e-01f, 5.37334621e-01f, 3.99789244e-01f, -8.25990215e-02f, 2.64259338e-01f, 3.04709077e-02f, -5.12615383e-01f,
  -3.20983142e-01f, -3.49135727e-01f, -3.63745362e-01f, -4.44478309e-03f, 2.42746055e-01f, -1.65073395e-01f, -5.80431614e-03f, -3.26934308e-01f, 2.08277047e-01f, 2.94967741e-03f,
  4.03143354e-02f, -3.57980058e-02f, 1.93817407e-01f, 7.19253421e-02f, 2.40111485e-01f, -7.05656335e-02f, -3.61625701e-01f, -2.47687567e-02f, 7.87392110e-02f, 1.27714589e-01f,
  2.48694383e-02f, -7.15897977e-02f, -1.60868853e-01f, -2.98252217e-02f, 7.07639158e-02f, -1.54385036e-02f, -7.96875879e-02f, -1.62866749e-02f, 8.42404515e-02f, 2.82116476e-02f,
  -1.54396996e-01f, 1.93718731e-01f, 7.12118447e-02f, 5.70084201e-03f, 1.00177981e-01f, 1.39425635e-01f, 1.36932701e-01f, 1.56077772e-01f, -6.88945949e-02f, 1.23033918e-01f,
  1.54597849e-01f, 6.91792816e-02f, 9.43233296e-02f, -1.66677833e-01f, 6.02709651e-02f, 1.43977821e-01f, 1.21730953e-01f, 6.30092025e-02f, 1.74222857e-01f, 1.83063924e-01f,
  -7.36432821e-02f, -2.31525581e-02f, 3.66004370e-03f, -8.38321522e-02f, -7.64952525e-02f, 1.17436334e-01f, 6.87293932e-02f, 2.32880935e-02f, 6.62188753e-02f, -1.04121715e-01f,
  7.22690523e-02f, 2.00012559e-03f, 1.45113498e-01f, 1.02602737e-02f, -5.74796833e-02f, 1.24332318e-02f, -2.84651443e-02f, -7.82214031e-02f, 2.92309467e-03f, 4.97880317e-02f,
  -1.99675109e-04f, -2.44032014e-02f, -4.41688392e-03f, 7.59513453e-02f, -1.72294881e-02f, -9.71624628e-03f, -7.69586256e-03f, 8.45127851e-02f, 3.35618332e-02f, -7.23630562e-02f,
  -4.02889669e-01f, -5.49824476e-01f, -1.92052230e-01f, 6.08502924e-02f, -1.65006474e-01f, -1.82404108e-02f, 6.17823983e-03f, -5.65889739e-02f, -1.78771272e-01f, -9.56758708e-02f,
  3.23321149e-02f, 1.59845687e-02f, -8.13560262e-02f, -2.61457562e-02f, -5.41450232e-02f, -7.74784535e-02f, -8.81683081e-02f, -2.43030414e-01f, -1.92784816e-01f, -6.57778885e-03f,
  -1.03846148e-01f, -2.73921881e-02f, 1.09241717e-01f, -1.65293608e-02f, 1.83328316e-02f, -9.73087102e-02f, -5.25040887e-02f, -1.16309501e-01f, -8.64933506e-02f, 3.21827009e-02f,
  9.45416316e-02f, 5.06342173e-01f, 5.02435029e-01f, -3.75326961e-01f, -4.17764813e-01f, -1.35960996e-01f, -2.73555666e-01f, 3.86041403e-01f, 3.30438286e-01f, 3.84705573e-01f,
  -2.27504551e-01f, 5.30897200e-01f, 1.38717756e-01f, -1.93749756e-01f, -3.97221148e-01f, -1.93222716e-01f, -4.69134897e-01f, -1.80666909e-01f, -6.56973347e-02f, -2.63076872e-01f,
  -4.09939229e-01f, -5.97200811e-01f, -2.85403252e-01f, -4.01211292e-01f, -2.96399802e-01f, 4.89186794e-02f, -4.32624459e-01f, -2.65705585e-01f, -3.15790996e-02f, -3.74058858e-02f,
  6.80994149e-03f, 2.18220443e-01f, 3.06864053e-01f, 2.50958741e-01f, -6.34016842e-03f, 2.86593824e-03f, -1.15482658e-01f, 7.04255551e-02f, -9.67882108e-03f, 1.16520740e-01f,
  9.54624340e-02f, 1.24569729e-01f, 5.95082156e-02f, 1.62762627e-02f, -8.60660598e-02f, 1.07615598e-01f, 7.06054494e-02f, 1.46864966e-01f, 1.30122125e-01f, 1.59120262e-02f,
  6.94226101e-02f, 1.08385585e-01f, 6.24016374e-02f, 4.59764190e-02f, 4.39890251e-02f, 5.95590547e-02f, -9.47368331e-03f, 1.06279239e-01f, 4.80056666e-02f, 5.52009745e-03f,
  8.16459302e-03f, -2.00033009e-01f, -7.94557948e-03f, -3.59535143e-02f, -9.46785659e-02f, -6.79710433e-02f, -5.96908517e-02f, 9.51851904e-02f, 9.19760317e-02f, 1.62493959e-02f,
  4.16225381e-02f, 7.99531713e-02f, -2.42883235e-01f, -4.88553233e-02f, -1.91662952e-01f, 2.92713761e-01f, 7.05992058e-02f, 3.33654992e-02f, -1.54433176e-01f, 4.38127592e-02f,
  -7.79564455e-02f, -1.16960630e-01f, -9.55163613e-02f, -2.49494895e-01f, 2.59763971e-02f, 3.66619267e-02f, 7.64580518e-02f, 1.16333775e-01f, -8.28585774e-02f, -9.75371003e-02f,
  8.86362419e-03f, -7.77310804e-02f, 5.86891845e-02f, 2.78712124e-01f, 3.14319991e-02f, 8.45348090e-02f, -9.50031281e-02f, -3.98840345e-02f, 2.27927193e-02f, -2.29703970e-02f,
  -7.52273127e-02f, 1.03003956e-01f, 1.07208537e-02f, 9.17698741e-02f, -5.55100553e-02f, -3.63531485e-02f, -2.57118434e-01f, -1.33537697e-02f, -1.28376976e-01f, -4.64520566e-02f,
  -6.80743754e-02f, -1.13052003e-01f, 1.69047996e-01f, -2.55891114e-01f, -7.48574510e-02f, 4.12598252e-03f, 7.55067393e-02f, 1.15045093e-01f, -5.07116653e-02f, -2.81237215e-02f,
  3.65832865e-01f, -6.12785965e-02f, -3.45759720e-01f, -6.88382313e-02f, 3.21977399e-02f, -1.60141140e-01f, -3.08323234e-01f, 2.37349451e-01f, -2.32876599e-01f, 3.08114618e-01f,
  2.68075377e-01f, 2.35539705e-01f, -1.62828341e-01f, 3.51934165e-01f, 4.69138026e-01f, -1.65662274e-01f, 3.92599463e-01f, 1.19731046e-01f, -4.09362912e-02f, 3.64543229e-01f,
  2.66380250e-01f, 4.24876302e-01f, 2.21413627e-01f, 3.31464469e-01f, 3.41082782e-01f, 1.98460706e-02f, 4.30924356e-01f, -1.13688022e-01f, 2.73784399e-01f, 2.37132341e-01f,
  -2.76168566e-02f, 6.83206320e-02f, -6.81749359e-02f, -8.40692744e-02f, 6.92848638e-02f, -9.16230679e-02f, -9.17073041e-02f, -1.21785149e-01f, -9.54381600e-02f, 6.62358850e-02f,
  -8.95677693e-03f, 6.75537959e-02f, 1.60687044e-02f, 3.11558880e-02f, -2.47710980e-02f, -7.39736557e-02f, 1.17398622e-02f, -7.65636005e-03f, -1.41707316e-01f, 1.27900869e-01f,
  -3.00332624e-02f, -6.44961298e-02f, 2.88113970e-02f, -1.28937453e-01f, -8.34069327e-02f, -3.11409007e-03f, 1.65258721e-02f, -5.41647384e-03f, -6.29105121e-02f, 5.69654368e-02f,
  8.33754167e-02f, 7.25081051e-03f, 3.06618661e-02f, -1.43936902e-01f, -8.53895023e-02f, -2.95687485e-02f, -1.17466360e-01f, -1.08939573e-01f, 3.00130453e-02f, 9.21519548e-02f,
  -4.87856865e-02f, -5.81164025e-02f, 5.38843758e-02f, -5.44178635e-02f, 7.66553655e-02f, -4.52848338e-02f, -9.55318287e-02f, 9.20399800e-02f, 1.57066956e-02f, -1.06895097e-01f,
  -8.84823594e-03f, 1.54218171e-02f, 5.28734885e-02f, -9.27709416e-02f, -7.10465088e-02f, 1.54579327e-01f, 4.32085544e-02f, 1.48319870e-01f, 2.92443205e-02f, 5.93369044e-02f,
  8.85077342e-02f, 2.14726493e-01f, -6.05618954e-02f, -8.24488774e-02f, -1.45406112e-01f, 4.76083420e-02f, -1.42884851e-02f, 4.39556167e-02f, 1.03442363e-01f, 3.60134877e-02f,
  1.28674626e-01f, -5.92123605e-02f, 3.58221680e-02f, -3.51450294e-02f, -1.35510101e-03f, 1.91846833e-01f, 5.24597056e-02f, -4.47638966e-02f, 1.99488178e-02f, 9.64449346e-02f,
  -8.56332947e-03f, -2.91560385e-02f, -2.77426839e-02f, -2.97250330e-01f, -6.57641962e-02f, 9.95870084e-02f, 8.52748081e-02f, 1.01286463e-01f, 1.98742989e-02f, -1.31988721e-02f,
  -4.34966296e-01f, -4.89030004e-01f, -2.79215991e-01f, -2.02985391e-01f, 1.51699737e-01f, -6.04193471e-03f, -7.49089643e-02f, -3.22737694e-01f, -2.84103423e-01f, -1.97476491e-01f,
  5.39116450e-02f, -7.93999061e-02f, -3.41200620e-01f, -7.82924443e-02f, -2.76576012e-01f, -4.75292355e-01f, -4.00614232e-01f, -2.03671567e-02f, -1.94798455e-01f, -9.00940150e-02f,
  -1.59580573e-01f, 1.07961223e-01f, -4.28341269e-01f, 2.78920799e-01f, -1.87057272e-01f, 2.55418271e-01f, 3.37121874e-01f, 2.42547557e-01f, 3.23981076e-01f, 3.63820106e-01f,
  -2.11695880e-01f, -2.05964699e-01f, 5.54227307e-02f, -1.76329724e-02f, -1.06836319e-01f, 4.73674200e-02f, 1.56904876e-01f, 1.91079333e-01f, -1.02632381e-02f, -8.45631510e-02f,
  -2.93595629e-04f, 1.86247498e-01f, 4.18274999e-02f, 1.12644129e-01f, -6.54175729e-02f, 5.39114624e-02f, 4.01067063e-02f, -1.82076588e-01f, -8.28763656e-03f, -5.09295166e-02f,
  -1.42996892e-01f, -2.25841656e-01f, 1.03226036e-01f, 5.10696545e-02f, 1.35897160e-01f, 1.37034893e-01f, -5.25482781e-02f, 1.43422158e-02f, -9.48759168e-03f, -3.47153912e-03f,
  1.88201182e-02f, 1.12000681e-01f, -1.04223698e-01f, -1.82464793e-01f, 6.77473843e-02f, 9.97158960e-02f, -9.95712951e-02f, -6.91291038e-03f, 5.90881296e-02f, -3.45502794e-02f,
  3.96936871e-02f, -6.26940131e-02f, -1.54805370e-02f, 4.56367657e-02f, -3.87422927e-02f, -1.03930973e-01f, -1.19133130e-01f, -2.13022567e-02f, -1.30829439e-01f, -3.13082933e-02f,
  -3.45267467e-02f, 6.65068775e-02f, -4.78039682e-02f, 5.20879403e-02f, -1.79588541e-01f, -1.00277020e-02f, 5.11929467e-02f, -1.34411231e-01f, -1.63930561e-02f, 6.69645071e-02f,
  -1.19470738e-01f, 3.38296145e-02f, -2.48076357e-02f, 1.35476530e-01f, 5.47450073e-02f, 6.64692968e-02f, -5.28395036e-03f, -2.77104378e-02f, -1.07081980e-01f, -2.29297150e-02f,
  -1.83311224e-01f, 1.89334467e-01f, 9.18803513e-02f, 4.76110121e-03f, 6.78452253e-02f, -2.15005681e-01f, 8.41598585e-02f, 4.69246358e-02f, -6.68269023e-02f, 6.73416182e-02f,
  3.33369635e-02f, 1.60212293e-01f, 4.14474793e-02f, -1.76439732e-02f, -6.53277943e-03f, 1.19454868e-01f, -1.10930100e-01f, -1.49069158e-02f, 1.37006789e-01f, 9.47993994e-02f,
  -3.90463412e-01f, 6.03641927e-01f, 3.05738360e-01f, -9.28323157e-03f, 8.18134248e-02f, 5.48441827e-01f, 3.92213374e-01f, 4.60524410e-01f, 6.20986521e-01f, 4.45262715e-02f,
  -2.65325785e-01f, -7.08042607e-02f, 7.36081600e-02f, 3.10080089e-02f, 2.70523783e-03f, 2.81808585e-01f, 3.03320467e-01f, 1.09989032e-01f, 3.86719227e-01f, -9.08456370e-02f,
  -9.66457501e-02f, -1.53772205e-01f, -3.59214544e-01f, -6.40555248e-02f, -2.65968949e-01f, -1.14437774e-01f, -5.47362924e-01f, 6.70378357e-02f, -3.06195855e-01f, 2.34791249e-01f,
  -8.36629272e-02f, 1.93416134e-01f, -1.73029467e-01f, 1.98525656e-02f, 8.58605206e-02f, -4.00859937e-02f, 6.22205772e-02f, 1.64298974e-02f, 6.34802273e-03f, 8.52935463e-02f,
  -8.74159336e-02f, 7.37052737e-03f, 1.74561255e-02f, -1.28509812e-02f, 6.16638474e-02f, -5.38968034e-02f, 7.16122910e-02f, -2.14197114e-02f, 1.02946319e-01f, 3.90339009e-02f,
  -8.80436525e-02f, -5.62460460e-02f, -1.24421641e-01f, 2.53425315e-02f, -1.18505165e-01f, -1.14973180e-03f, 5.05254455e-02f, -6.23199642e-02f, 1.00643560e-02f, 1.04573190e-01f,
  -1.02963224e-01f, 1.65163711e-01f, -1.01300031e-02f, 9.03179124e-03f, 1.13301771e-02f, 8.57521668e-02f, -1.40131950e-01f, -6.14597574e-02f, 1.20468074e-02f, -1.49772629e-01f,
  -8.98146778e-02f, 1.02914218e-02f, 1.68256104e-01f, -4.60797586e-02f, 8.00987147e-03f, -1.63310338e-02f, -1.36090904e-01f, 1.40944913e-01f, 7.77240098e-02f, -1.08530924e-01f,
  -2.42520906e-02f, -6.44800216e-02f, -1.20789856e-01f, -3.34438891e-03f, -6.74600750e-02f, -1.87404752e-02f, 1.77084701e-04f, -1.06229344e-02f, -9.61284265e-02f, -1.50144771e-01f,
  2.35044047e-01f, 4.61251706e-01f, 5.90366907e-02f, 3.38424891e-02f, -2.25193705e-02f, -1.40575124e-02f, 1.22388348e-01f, 1.09634183e-01f, 2.32346982e-01f, 7.33046383e-02f,
  1.17335226e-02f, 4.91416454e-02f, -1.61017165e-01f, -6.29542097e-02f, -2.87477556e-03f, 5.29440343e-02f, 2.52446178e-02f, 9.47504491e-02f, 1.44363567e-01f, -3.84494402e-02f,
  -2.18770325e-01f, 3.65742594e-02f, 3.81723903e-02f, -8.76439437e-02f, -8.58067572e-02f, -1.66815624e-01f, 4.37829383e-02f, -2.90951207e-02f, -2.05181055e-02f, 8.81144032e-02f,
  -4.63711858e-01f, -4.11537468e-01f, -3.18980455e-01f, 1.16692424e-01f, -2.61686981e-01f, -3.29956949e-01f, -3.72273177e-01f, -3.42483461e-01f, -7.39394827e-03f, 1.97703019e-01f,
  1.05383368e-02f, 3.47095989e-02f, -1.65129215e-01f, 4.07120377e-01f, 5.94936088e-02f, 1.86353818e-01f, 2.98013333e-02f, 1.60002321e-01f, -9.71698947e-03f, -3.20434004e-01f,
  9.16071907e-02f, 2.97169387e-01f, -9.58582293e-03f, 1.35205269e-01f, -3.63339096e-01f, 2.95043737e-02f, 2.12649211e-01f, -3.00063461e-01f, 2.19034791e-01f, 2.66202986e-02f,
  -2.81709760e-01f, -3.73516679e-01f, -1.09977193e-01f, 3.90550978e-02f, -6.60805032e-02f, -8.05580094e-02f, -3.90593410e-02f, -1.09362297e-01f, 4.97106835e-02f, -2.34572813e-02f,
  -1.91961639e-02f, 1.01212904e-01f, 1.48181885e-01f, 1.98967665e-01f, -6.91599473e-02f, 2.76021622e-02f, -5.07839546e-02f, -4.10805605e-02f, -8.24541897e-02f, -1.62835628e-01f,
  -2.10663691e-01f, -1.79220606e-02f, -1.64839208e-01f, 7.24375844e-02f, -1.47527531e-01f, -8.37750956e-02f, 7.89460316e-02f, -1.28380433e-01f, -1.02585681e-01f, 1.89008415e-02f,
  3.02582029e-02f, -6.36272654e-02f, -1.04038045e-01f, 4.36739773e-02f, 5.00749163e-02f, 1.36278614e-01f, 3.82880718e-02f, 7.57733211e-02f, 9.96985137e-02f, -6.96426481e-02f,
  1.50987968e-01f, -7.59924278e-02f, 6.71027321e-03f, 1.20232426e-01f, 1.05244927e-02f, -5.94588136e-03f, -6.49332181e-02f, 1.78218354e-02f, -9.25484579e-03f, -3.69311473e-03f,
  4.76317331e-02f, -2.92907935e-02f, -9.37671065e-02f, -5.35444617e-02f, -5.59924655e-02f, -6.73027560e-02f, -1.00731641e-01f, 3.42381075e-02f, -7.04108626e-02f, -1.65110379e-01f,
  -4.67808455e-01f, -5.29938102e-01f, -9.19209197e-02f, -2.58965250e-02f, 9.76019427e-02f, -8.13726634e-02f, 1.85762141e-02f, -3.52939293e-02f, -1.50076479e-01f, -5.44062145e-02f,
  5.79271130e-02f, 2.28335783e-02f, -6.94176331e-02f, 2.64977515e-02f, 1.01347119e-01f, -1.32440642e-01f, -3.09013715e-03f, 4.72316034e-02f, -6.83187842e-02f, -5.22035696e-02f,
  -2.00916529e-02f, -6.03120998e-02f, 4.53221016e-02f, -1.71770066e-01f, 1.37425855e-01f, -1.44371940e-02f, -5.01422863e-03f, 8.85467231e-03f, -4.96701673e-02f, 1.04063518e-01f,
  2.19755203e-01f, 5.25614798e-01f, 2.67087102e-01f, 4.70092177e-01f, 1.12677060e-01f, -7.42238522e-01f, -9.72861573e-02f, 1.22814409e-01f, 4.29613113e-01f, -3.52147967e-02f,
  5.81644811e-02f, 3.71459812e-01f, 1.67768985e-01f, 2.04355896e-01f, -5.36284029e-01f, -2.35045329e-01f, -2.84395456e-01f, -1.27535358e-01f, 1.32914022e-01f, 1.64364383e-01f,
  -1.00752637e-02f, 4.44257408e-02f, 2.28192031e-01f, 2.10561484e-01f, 1.52787060e-01f, 2.60182291e-01f, -1.37311533e-01f, 1.76135555e-01f, -9.81945559e-05f, -2.17309639e-01f,
  -1.22475833e-01f, 3.88678253e-01f, 1.82901993e-01f, 4.24930779e-03f, -1.28041998e-01f, -1.08632252e-01f, -6.12611547e-02f, -6.96024001e-02f, 1.14036992e-01f, 1.82763264e-02f,
  -6.09661378e-02f, -6.11851364e-02f, -7.05509633e-03f, 1.02043010e-01f, 5.33031896e-02f, 9.93260667e-02f, 1.28837347e-01f, -5.67770079e-02f, 2.19490364e-01f, 6.31591538e-03f,
  2.03604788e-01f, -8.24410468e-02f, -4.21855859e-02f, -1.30111963e-01f, -5.88991083e-02f, 7.61272684e-02f, -1.88492388e-01f, -1.07094742e-01f, -6.54275864e-02f, 7.03720935e-03f,
  5.17924279e-02f, -6.05651438e-02f, 8.75722244e-02f, 1.42989978e-01f, 1.13092974e-01f, 4.25734632e-02f, 1.66609185e-03f, -9.95302498e-02f, -7.38856122e-02f, -1.42941382e-02f,
  -1.08016029e-01f, 1.77080929e-01f, 2.52573844e-02f, -2.45563276e-02f, 5.08849882e-02f, 1.01765908e-01f, -1.27301648e-01f, -1.28482252e-01f, -1.50881127e-01f, 4.04180363e-02f,
  1.84707195e-01f, -1.55821174e-01f, 4.73045185e-02f, -1.51477858e-01f, -7.83796832e-02f, 5.61807193e-02f, 3.06877084e-02f, 1.22113051e-02f, 3.38968704e-03f, -4.11164314e-02f,
  -5.38171232e-01f, 9.10012573e-02f, -2.21324489e-02f, -9.36488956e-02f, 6.57624677e-02f, -1.44048467e-01f, 3.83105204e-02f, -1.01736031e-01f, 3.69947143e-02f, -3.28009017e-02f,
  -2.84263846e-02f, -1.50970250e-01f, -2.13828743e-01f, -1.15729123e-01f, 1.88820774e-03f, -4.35447991e-02f, 6.69148043e-02f, -3.96443456e-02f, 1.41373742e-02f, -1.28430977e-01f,
  3.37641574e-02f, 9.00770724e-02f, -5.29499725e-02f, -1.16048418e-02f, -1.30775139e-01f, -8.69446958e-04f, 5.28502315e-02f, 1.32503454e-02f, -2.09097564e-02f, -1.14960656e-01f,
  -5.88407703e-02f, 2.26884350e-01f, -4.50434387e-01f, -1.76940903e-01f, 4.83258843e-01f, 8.66687655e-01f, 1.89714581e-01f, 1.07239999e-01f, -1.55300692e-01f, 3.53703201e-01f,
  3.46691161e-01f, -1.96717203e-01f, -3.39701742e-01f, 3.00377250e-01f, 1.12133846e-01f, -8.00825134e-02f, 3.83873522e-01f, 2.98427284e-01f, -2.94075131e-01f, -1.11471012e-01f,
  -1.90528929e-01f, 4.09911692e-01f, -3.69196653e-01f, 1.16140932e-01f, 2.05990016e-01f, -3.21988225e-01f, -1.35514066e-01f, -4.02443022e-01f, 1.95192277e-01f, 2.74515748e-01f,
  1.14564588e-02f, -2.64933705e-01f, -1.78153530e-01f, -1.18451014e-01f, -1.62471901e-03f, -5.14232852e-02f, -6.54480234e-02f, -2.82488465e-02f, -1.94016472e-01f, -1.33345887e-01f,
  -5.06802946e-02f, -7.82888755e-02f, -1.39028709e-02f, -1.51584700e-01f, 2.24769916e-02f, -1.20245237e-02f, -5.28319702e-02f, -1.21614458e-02f, -6.26752451e-02f, -2.29608431e-01f,
  -1.88356727e-01f, -1.95820443e-02f, 2.94123702e-02f, 1.20322257e-01f, 5.10901399e-02f, 2.27099359e-02f, 8.05342272e-02f, -5.19089811e-02f, 1.47724032e-01f, 1.44322217e-01f,
  5.62400706e-02f, 3.93613987e-02f, 1.10183060e-02f, -4.99253422e-02f, 1.59623414e-01f, -3.20923664e-02f, 7.86094144e-02f, -2.32631639e-02f, -6.91388175e-02f, 7.75977448e-02f,
  7.23501593e-02f, 3.81127149e-02f, -1.41875565e-01f, -3.31052542e-02f, 1.39216319e-01f, 2.49325465e-02f, -1.16210207e-01f, 3.61837028e-03f, -7.15053976e-02f, 7.31491670e-02f,
  -1.65947899e-01f, 6.81717694e-02f, 1.16951158e-02f, -3.31454054e-02f, 1.08107567e-01f, -4.14832309e-02f, 2.64666583e-02f, -8.74364190e-03f, -9.18728188e-02f, 5.94805814e-02f,
  3.07298839e-01f, 3.09837282e-01f, -3.93867865e-02f, 2.10177843e-02f, -1.67830423e-01f, -4.85198246e-03f, -7.77770206e-02f, -4.59532104e-02f, 9.70735550e-02f, 7.71147013e-02f,
  -3.30051258e-02f, -1.35832369e-01f, 2.01357514e-01f, 9.12618916e-03f, 2.16085538e-02f, -5.06279506e-02f, 7.69857615e-02f, -4.14820795e-04f, 3.14796269e-01f, 7.66843781e-02f,
  9.76609960e-02f, 5.26207350e-02f, 6.24454319e-02f, 2.12084681e-01f, 1.67057469e-01f, 5.30962758e-02f, 2.06253707e-01f, -2.06783295e-01f, 1.05762146e-01f, -5.48999906e-02f,
  4.43983018e-01f, -2.58513361e-01f, 4.50522423e-01f, 2.05062851e-01f, 3.41872603e-01f, 4.35313433e-01f, 4.54635441e-01f, 2.33624116e-01f, 4.58970577e-01f, -3.35634440e-01f,
  -3.44710618e-01f, -1.94875389e-01f, 1.26122504e-01f, -3.12354743e-01f, 4.64525551e-01f, 1.12182826e-01f, -9.92189646e-02f, -2.03458458e-01f, 2.18896225e-01f, -5.00107259e-02f,
  1.38589576e-01f, -3.48434359e-01f, 8.63859802e-02f, -3.86894405e-01f, 1.11600542e-02f, -1.57988355e-01f, -4.01775450e-01f, 1.14973277e-01f, -6.38892770e-01f, 3.63427028e-02f,
  -1.42788827e-01f, -1.20249707e-02f, 6.30376488e-02f, -5.83816431e-02f, 8.18713605e-02f, 2.05752328e-02f, -1.23702727e-01f, 7.25500882e-02f, 1.78562075e-01f, -4.97968793e-02f,
  -2.04026867e-02f, -1.16124555e-01f, -7.18157813e-02f, -4.86119688e-02f, 1.59984738e-01f, -1.20159671e-01f, 1.91834010e-02f, 1.42116323e-01f, 9.50113311e-02f, 1.17918201e-01f,
  1.34622499e-01f, 4.68363725e-02f, 1.46307647e-01f, -1.82965934e-01f, 7.39459395e-02f, 1.13678031e-01f, -3.10014710e-02f, 4.90250662e-02f, -3.19258310e-03f, 1.50079921e-01f,
  1.68021202e-01f, 8.53709057e-02f, -6.14371672e-02f, -8.52248669e-02f, -5.32338172e-02f, -5.30002676e-02f, -2.22296774e-01f, -2.03815505e-01f, -4.45133336e-02f, -5.54148369e-02f,
  -4.60504293e-02f, -8.26116800e-02f, -4.63683084e-02f, -9.49247275e-03f, 5.28052710e-02f, -7.79161751e-02f, -8.29680189e-02f, -2.65304297e-01f, 5.98390996e-02f, 2.40441069e-01f,
  -1.00021251e-01f, 2.48230528e-02f, 5.36222011e-02f, -4.79719602e-02f, 1.45604640e-01f, -5.17454185e-02f, -1.12708770e-01f, 9.26421061e-02f, 1.44008160e-01f, 9.49283913e-02f,
  -4.66731220e-01f, -3.54924679e-01f, -1.71684604e-02f, -1.98317736e-01f, -2.31879890e-01f, -1.52328685e-01f, -1.08858898e-01f, -8.52269307e-02f, -1.27112968e-02f, 1.94713518e-01f,
  9.00452361e-02f, -1.75503477e-01f, -1.00618219e-02f, -7.55464584e-02f, 4.13134918e-02f, 1.25532690e-02f, -7.00316206e-02f, -9.19777527e-02f, -3.68718803e-02f, -2.28112340e-01f,
  -2.75255647e-02f, -6.76592961e-02f, -3.12920064e-02f, -9.14769247e-03f, -1.30054936e-01f, 4.31682356e-03f, -3.02249100e-02f, -9.90062673e-03f, 1.28935231e-02f, 4.22531441e-02f,
  -4.52590615e-01f, -3.72669637e-01f, 5.50233424e-02f, 1.53888941e-01f, 4.13041450e-02f, -3.79660577e-01f, -4.82438207e-01f, -1.55442059e-01f, -3.60463619e-01f, -4.70023692e-01f,
  -1.90641135e-01f, 7.91881830e-02f, -1.74971238e-01f, 4.32483479e-02f, 5.65240800e-01f, 3.72519642e-02f, 7.19385594e-02f, 1.15115911e-01f, 3.39798808e-01f, 9.54678953e-02f,
  4.14070100e-01f, 2.13524401e-01f, 5.57965934e-01f, 3.24736297e-01f, 1.88099518e-01f, 2.52894819e-01f, 2.99952239e-01f, 3.31123948e-01f, 3.47809076e-01f, 2.55670011e-01f,
  -1.93802372e-01f, -1.04024932e-01f, -1.59848154e-01f, -6.59834668e-02f, -3.96268209e-03f, -1.50279731e-01f, -3.27076167e-02f, 1.28214061e-01f, -4.32165600e-02f, 8.64077508e-02f,
  -8.68898109e-02f, 1.28657475e-01f, 1.46908477e-01f, 1.11092471e-01f, -1.74583301e-01f, 4.28121313e-02f, 1.30903706e-01f, -1.00278966e-01f, 8.97005014e-03f, 6.27421886e-02f,
  -6.04189970e-02f, 1.93358231e-02f, -1.46377727e-01f, 1.65623836e-02f, 5.72462454e-02f, -1.47650674e-01f, 2.73905359e-02f, 8.35752115e-02f, 5.35297347e-03f, 6.24803361e-04f,
  -7.41456598e-02f, 2.08090339e-02f, 6.49601966e-02f, 9.06930268e-02f, -6.84210211e-02f, -1.57341540e-01f, -3.06298789e-02f, -7.09831417e-02f, 6.19969293e-02f, -7.92238265e-02f,
  6.55558798e-03f, -4.06208448e-02f, -5.17370552e-02f, -1.88146144e-01f, -2.60361340e-02f, -5.40133417e-02f, 1.03982046e-01f, -3.40715819e-03f, -1.42610250e-02f, 6.61853403e-02f,
  -7.79212546e-03f, -6.17347062e-02f, -8.49007070e-02f, 1.39315248e-01f, -8.46599191e-02f, -1.30435079e-01f, -9.15220007e-03f, -1.53951257e-01f, 5.92294075e-02f, 2.20123842e-01f,
  -2.62043923e-01f, 1.06317639e-01f, 8.76865536e-02f, -1.16077043e-01f, -9.91092063e-03f, 6.20351592e-03f, 1.42694846e-01f, 1.22279733e-01f, -1.16717771e-01f, -3.98404114e-02f,
  5.44722602e-02f, -6.13742601e-03f, -1.09872535e-01f, -1.09747335e-01f, 1.32241175e-01f, -1.57428801e-01f, -4.36840542e-02f, -4.96018715e-02f, 5.48594594e-02f, 4.52082306e-02f,
  1.46214562e-02f, -4.01015095e-02f, 9.39522684e-02f, 1.86842069e-01f, -1.34159923e-02f, -1.45673349e-01f, 9.65011399e-03f, 1.00951575e-01f, 1.07797965e-01f, -2.93055624e-02f,
  4.55439657e-01f, -4.28601205e-01f, -5.03443778e-01f, 1.16485931e-01f, 4.18221265e-01f, 4.63666618e-01f, 3.96454185e-01f, 3.47374082e-02f, -3.43611419e-01f, -1.65502682e-01f,
  3.49646300e-01f, 7.35042393e-02f, -1.24219619e-01f, 3.24196637e-01f, 5.49697518e-01f, -2.97827035e-01f, 9.23113525e-02f, 1.44343331e-01f, -3.58747005e-01f, 1.45115972e-01f,
  1.24290988e-01f, 4.66372728e-01f, -2.09132712e-02f, 8.53889808e-02f, 3.68126154e-01f, -1.27969906e-01f, 3.48685294e-01f, -6.79349229e-02f, 1.95239484e-01f, 1.52025878e-01f,
  -1.27169034e-02f, -1.35543332e-01f, -1.26732178e-02f, -1.16246805e-01f, 1.29673004e-01f, 8.47652107e-02f, 3.21778879e-02f, 1.99893296e-01f, 5.12355082e-02f, 3.91107574e-02f,
  6.79352656e-02f, 3.69141251e-02f, 1.31289154e-01f, -9.98674631e-02f, 1.01819985e-01f, -5.04187588e-03f, -1.33683071e-01f, -1.13502391e-01f, 1.51536362e-02f, 2.57533249e-02f,
  -1.84088796e-01f, -1.60222709e-01f, -9.41233337e-02f, -1.52090043e-01f, -1.96404103e-02f, -7.59442002e-02f, -7.33920410e-02f, 5.15910722e-02f, -1.25655029e-02f, -1.67886596e-02f,
  1.07877292e-01f, -9.51530635e-02f, 6.28274307e-02f, -6.70230612e-02f, 5.29055633e-02f, 9.55675319e-02f, 8.46217424e-02f, 3.35361511e-02f, -1.32245645e-01f, 1.57881483e-01f,
  -1.67449866e-03f, 8.44605863e-02f, -5.50674200e-02f, 8.00424442e-02f, 5.87919503e-02f, -1.47610113e-01f, 6.67300522e-02f, 4.87693027e-02f, -6.11291490e-02f, 2.69769728e-02f,
  -1.18330019e-02f, 4.69473265e-02f, 1.05016083e-01f, -5.26744081e-03f, -5.15776612e-02f, 1.51963964e-01f, -5.32596335e-02f, 4.40935194e-02f, -2.02895775e-01f, 2.77780145e-02f,
  -5.86100807e-03f, -3.99284400e-02f, -9.75060537e-02f, -3.25154997e-02f, -1.21220298e-01f, 2.16140281e-02f, -8.54625255e-02f, 5.20273522e-02f, 3.05072106e-02f, 3.64980963e-03f,
  1.26666337e-01f, 1.98113509e-02f, -1.98279954e-02f, -1.91766918e-02f, 8.52416605e-02f, 9.40256268e-02f, 4.77912910e-02f, -1.26260325e-01f, 1.55469954e-01f, 1.68222502e-01f,
  -1.12889320e-01f, 1.29459593e-02f, 9.17716473e-02f, -1.18821062e-01f, -1.75497693e-03f, 1.83703024e-02f, -2.15655733e-02f, -3.95033918e-02f, -1.19333155e-02f, -3.82349491e-02f,
  2.79438943e-01f, -3.36085737e-01f, -4.84603673e-01f, -1.15490399e-01f, 2.53613323e-01f, 4.35280055e-01f, 1.67508870e-01f, -1.23380780e-01f, -4.95485634e-01f, 2.19537482e-01f,
  1.87114701e-01f, -1.76714305e-02f, -2.11442530e-01f, 5.16279712e-02f, -1.78205311e-01f, -3.90137017e-01f, 8.20801631e-02f, 1.52093947e-01f, -2.79217690e-01f, 2.66540181e-02f,
  -2.28824362e-01f, 1.47044927e-01f, -3.17496598e-01f, 1.18371181e-01f, 4.48075503e-01f, 3.62305827e-02f, 2.32929796e-01f, 2.09919080e-01f, 3.70958298e-01f, 2.07123443e-01f,
  -9.40612517e-03f, -1.17098853e-01f, -8.70849937e-02f, -5.54279387e-02f, 3.36142667e-02f, 1.03174590e-01f, 2.92645037e-01f, 9.39808339e-02f, 4.18757014e-02f, -1.19275600e-01f,
  1.92555398e-01f, 3.50135528e-02f, -1.45150321e-02f, -5.76363094e-02f, 7.52136018e-03f, -3.18776071e-02f, -1.65422380e-01f, -7.89539982e-03f, -1.77967235e-01f, -6.73194556e-03f,
  -1.33141965e-01f, 1.20625637e-01f, 1.21494271e-01f, 2.60378495e-02f, -2.04809368e-01f, -9.12878141e-02f, -6.34928271e-02f, -6.42156322e-03f, 8.65547955e-02f, 2.34644320e-02f,
  3.41118500e-02f, 5.48069403e-02f, -7.56926313e-02f, 4.52731363e-02f, -1.73397854e-01f, 1.09718807e-01f, 1.05952531e-01f, -2.11942736e-02f, -4.08469774e-02f, -1.33583710e-01f,
  7.87503198e-02f, 7.37669244e-02f, 1.30759016e-01f, 4.65388298e-02f, -1.16846539e-01f, 7.87834376e-02f, 1.08284682e-01f, 1.29414797e-01f, -1.19640581e-01f, -6.97612017e-02f,
  8.20071772e-02f, 1.90636981e-02f, 4.22559828e-02f, 1.98660269e-01f, -9.59853455e-03f, -1.74353257e-01f, 4.53013852e-02f, -9.98649746e-02f, 6.73164427e-02f, 1.56801805e-01f,
  -7.57415816e-02f, -2.42920414e-01f, -9.60190073e-02f, 1.33381188e-01f, -1.62914898e-02f, 1.94558293e-01f, -1.15221970e-01f, -1.51978537e-01f, -4.60176583e-04f, -8.45312700e-02f,
  2.13311791e-01f, 6.76804036e-02f, 7.93149322e-02f, 5.81386536e-02f, 8.63501802e-02f, -4.08790782e-02f, 5.39359264e-02f, 1.40145659e-01f, -4.29555364e-02f, 6.93582967e-02f,
  -5.51959500e-02f, 7.67669827e-02f, 8.22392404e-02f, -4.35039997e-02f, 1.09082043e-01f, -3.08047924e-02f, 2.85396259e-02f, 5.32501340e-02f, 1.17403762e-02f, 4.75423858e-02f,
  -6.32304370e-01f, 4.24398839e-01f, 7.26590976e-02f, -4.81061906e-01f, 2.40660980e-01f, -7.50311390e-02f, -1.24927223e-01f, 2.44672403e-01f, -1.89976305e-01f, 2.95680285e-01f,
  1.71899945e-01f, -1.91757940e-02f, 3.32648367e-01f, -1.45550370e-01f, -6.19057894e-01f, -3.19094956e-01f, -4.91294980e-01f, -2.09875941e-01f, -1.30817920e-01f, 5.76623194e-02f,
  -1.90954253e-01f, -2.03789890e-01f, -1.02358542e-01f, 3.54126841e-01f, 2.02986225e-01f, 1.60790876e-01f, -1.86002612e-01f, 3.25797468e-01f, -9.52339321e-02f, 1.01877481e-01f,
  1.77553654e-01f, 1.28703378e-02f, 1.42272383e-01f, 1.06920406e-01f, 7.80402794e-02f, -5.21422327e-02f, 9.35380310e-02f, -2.34496756e-03f, -1.08221889e-01f, -5.66000007e-02f,
  -6.51808232e-02f, -9.05914139e-03f, -1.01688072e-01f, -8.02096203e-02f, -5.88699840e-02f, 2.05018237e-01f, 1.23956323e-01f, 3.77752334e-02f, 8.61305594e-02f, -9.28149372e-02f,
  -2.29651444e-02f, -2.24255342e-02f, -2.33522311e-01f, -1.80432215e-01f, -4.47650105e-02f, 4.66103293e-02f, -1.79717302e-01f, -1.18815033e-02f, -1.35378033e-01f, -1.70251459e-01f,
  -3.12068183e-02f, -9.12255421e-02f, -9.22639668e-02f, 1.85353056e-01f, -1.78497005e-02f, 1.80595115e-01f, -8.26984420e-02f, -6.37810081e-02f, -7.37751722e-02f, -2.96912491e-02f,
  -5.75469155e-03f, -5.89622036e-02f, -2.76641175e-02f, -1.73073009e-01f, -1.29366055e-01f, -1.08621798e-01f, 1.22728772e-01f, 8.15696176e-03f, 3.15748863e-02f, -1.04103778e-02f,
  7.09564388e-02f, -5.77503145e-02f, 5.95604219e-02f, 5.19957244e-02f, 5.17701060e-02f, -6.40374124e-02f, -4.12531421e-02f, 7.16447532e-02f, 9.14547220e-02f, -1.84610948e-01f,
  4.40952964e-02f, -2.02544592e-02f, 1.65527806e-01f, 1.10736795e-01f, -9.25787259e-03f, -1.10203728e-01f, -1.82022061e-02f, -2.15526652e-02f, -5.83554842e-02f, -6.66025430e-02f,
  1.00266986e-01f, 3.28431418e-03f, 5.13966493e-02f, 8.13014805e-02f, -1.38255283e-01f, -7.45418575e-03f, -3.58953103e-02f, 6.60314085e-03f, -9.65998322e-02f, -2.65267137e-02f,
  -1.49517423e-02f, -6.70131147e-02f, -1.61711305e-01f, 4.44504358e-02f, -6.80215582e-02f, 3.67795154e-02f, 1.08757541e-01f, 1.18077815e-01f, -7.49601871e-02f, 3.42993625e-02f,
  2.40279824e-01f, -3.94843549e-01f, -2.35143043e-02f, -4.87938195e-01f, 2.51524858e-02f, 1.25979241e-02f, -2.94359270e-02f, -4.15312856e-01f, -6.10319257e-01f, -4.43098366e-01f,
  -3.47098678e-01f, 6.65187240e-02f, 3.64241719e-01f, -5.39542913e-01f, 5.33420324e-01f, 3.39382827e-01f, -3.92313808e-01f, -9.84945670e-02f, -1.94567025e-01f, -1.90775871e-01f,
  -4.22419496e-02f, -2.25380167e-01f, 9.86290723e-02f, -3.67491037e-01f, -2.35336870e-01f, -2.54706502e-01f, 1.32800266e-01f, 1.42190814e-01f, -3.03388476e-01f, 2.65027229e-02f,
  -2.72558536e-02f, -2.38371924e-01f, -2.44164281e-02f, 1.15858866e-02f, 9.33824405e-02f, 1.60661578e-01f, 2.65891761e-01f, 1.97383553e-01f, 5.17449481e-03f, -6.72425032e-02f,
  1.47532523e-01f, 9.35779326e-03f, -2.04192191e-01f, 2.61872768e-01f, -1.24908097e-01f, -1.62364021e-01f, -1.08451016e-01f, -4.84541953e-02f, -1.58086762e-01f, 9.69391596e-03f,
  -1.14712454e-01f, 7.86501635e-03f, -1.32457420e-01f, -3.52714919e-02f, -1.55923009e-01f, -1.54387236e-01f, 1.19668037e-01f, 2.23473608e-01f, -5.73007427e-02f, -1.17449984e-01f,
  -2.08115298e-02f, 1.53534085e-01f, 1.24885738e-01f, -1.38578480e-02f, 5.99792413e-02f, -8.80834684e-02f, -6.35287017e-02f, 3.27018425e-02f, -7.13483095e-02f, 4.13847528e-02f,
  -1.56079769e-01f, 5.80426082e-02f, -1.99722070e-02f, -1.19935222e-01f, 2.23305784e-02f, 2.48507578e-02f, 1.55217126e-01f, -1.40105216e-02f, -1.53429106e-01f, -2.86487043e-02f,
  -7.49744326e-02f, -5.50059900e-02f, 7.83133730e-02f, -6.32816777e-02f, -5.65374568e-02f, 7.96667561e-02f, 1.04728332e-02f, -2.41580606e-02f, -4.83577251e-02f, 1.03907071e-01f,
  -1.18661247e-01f, -2.00958684e-01f, -1.17020614e-01f, 4.02383581e-02f, -2.92085391e-03f, 5.63625395e-02f, 3.98712493e-02f, -2.84699351e-01f, -1.65818095e-01f, 6.95316344e-02f,
  -2.13541277e-02f, 2.51592845e-02f, -6.99561760e-02f, 4.06696014e-02f, -5.47157191e-02f, -1.01790600e-01f, 1.49582416e-01f, 5.08605577e-02f, -5.17270826e-02f, -2.03830332e-01f,
  -1.05774947e-01f, -6.54335469e-02f, 4.47947159e-02f, -1.26704246e-01f, -1.28076166e-01f, 1.24985091e-02f, 5.04291281e-02f, 6.44460693e-02f, 1.66497886e-01f, -1.23033132e-02f,
  -2.11281687e-01f, -1.82805598e-01f, 2.70344824e-01f, 4.24657613e-01f, 4.07812335e-02f, -3.13399076e-01f, -3.20976585e-01f, 3.00485373e-01f, 1.27575681e-01f, -3.69546294e-01f,
  -2.93181986e-01f, -1.98355943e-01f, -3.66063714e-01f, -3.83173339e-02f, 1.84522923e-02f, -5.37962496e-01f, 2.86695510e-01f, -4.14257795e-02f, -9.18168202e-02f, 2.18541414e-01f,
  2.69650340e-01f, 1.06318586e-01f, 3.48589569e-01f, 3.65475178e-01f, 1.16622448e-01f, 4.91840094e-01f, 3.99114460e-01f, 2.86926925e-01f, 5.98465979e-01f, -9.54435021e-02f,
  5.86305633e-02f, -1.97531968e-01f, 1.26977906e-01f, 1.66233703e-01f, 1.48822531e-01f, 7.70386681e-02f, 1.10703632e-01f, -1.09656639e-01f, 2.37075254e-01f, 5.35547622e-02f,
  -8.10228214e-02f, 1.78123340e-01f, -3.29318852e-03f, 3.30273397e-02f, 1.18303485e-01f, 1.36171222e-01f, 5.54764755e-02f, -1.32526606e-02f, 5.64815626e-02f, -2.30757862e-01f,
  1.89039335e-02f, -5.82836792e-02f, -5.45444861e-02f, -3.04573048e-02f, -6.68664351e-02f, 3.06699146e-03f, -1.78614985e-02f, -5.11788279e-02f, 1.08921006e-01f, -2.11698643e-04f,
  -2.18940794e-01f, -2.73194965e-02f, -3.99189442e-02f, 1.42279997e-01f, 1.40371457e-01f, 1.22814393e-02f, 1.54238790e-02f, -2.04165094e-02f, 1.96368992e-02f, -4.30123042e-03f,
  2.32381865e-01f, 5.24865799e-02f, 9.49487537e-02f, 4.50894237e-02f, -1.36198848e-01f, -5.47168776e-02f, 5.73447086e-02f, -5.76146320e-02f, 1.14502482e-01f, -6.01575933e-02f,
  -1.02525167e-01f, 3.59215029e-02f, 3.34857553e-02f, 4.65506837e-02f, 6.38349429e-02f, 7.84195513e-02f, -3.15164849e-02f, -1.18345460e-02f, 1.57713741e-02f, 5.16149774e-02f,
  2.82288175e-02f, -1.98084507e-02f, 1.14143670e-01f, 1.11902192e-01f, -7.42603689e-02f, -1.23909712e-01f, -1.42701596e-01f, -5.18546328e-02f, 8.05774406e-02f, -9.31871980e-02f,
  7.47143552e-02f, 1.26609460e-01f, -1.11347936e-01f, 2.69229617e-02f, 1.39472291e-01f, -4.41084281e-02f, 1.29401729e-01f, 9.50957835e-03f, 3.08662474e-01f, 1.37524351e-01f,
  5.40607143e-03f, -1.00814611e-01f, 5.24380468e-02f, 8.37672502e-02f, 2.38583740e-02f, -2.18973495e-04f, -2.83244289e-02f, 7.01848119e-02f, 4.70960606e-03f, 2.12609340e-02f,
  -8.98947239e-01f, 3.56045842e-01f, 1.82942256e-01f, -5.98469019e-01f, -1.15769535e-01f, 8.72399732e-02f, -1.29659042e-01f, -3.50015424e-02f, -3.38939190e-01f, -4.64997590e-02f,
  -2.99582243e-01f, -1.61218852e-01f, 3.60991448e-01f, -1.73440814e-01f, 2.35551536e-01f, 4.93182570e-01f, -1.58610612e-01f, -1.48210138e-01f, 3.46330144e-02f, -1.69717595e-01f,
  1.39766365e-01f, -3.44895244e-01f, 3.09927404e-01f, -4.26718071e-02f, -3.34116250e-01f, -2.89696544e-01f, -1.38861343e-01f, 1.92749295e-02f, -3.23099524e-01f, -5.35927303e-02f,
  -2.96808243e-01f, -6.07993841e-01f, -1.68886557e-01f, -5.93072101e-02f, -1.36592552e-01f, -9.42803025e-02f, -1.75446495e-01f, -1.32630803e-02f, -1.52137935e-01f, -5.34086339e-02f,
  -5.22750281e-02f, 1.27662480e-01f, -1.66114137e-01f, 1.55761931e-02f, -1.23944007e-01f, -1.72045872e-01f, 1.21041693e-01f, 2.09913254e-02f, 2.55128331e-02f, 1.79104984e-01f,
  1.74180984e-01f, 8.71801600e-02f, -5.01232371e-02f, 4.91825268e-02f, 1.12200573e-01f, -2.40763053e-02f, 6.50314763e-02f, 2.92829052e-02f, -6.78301379e-02f, -1.13543883e-01f,
  2.50694901e-02f, -1.32586248e-02f, -6.98775500e-02f, 1.89142860e-02f, 8.94984230e-03f, -7.62184411e-02f, -1.05151810e-01f, -3.43839526e-02f, 2.00510863e-02f, 1.65706217e-01f,
  -6.55804276e-02f, -3.90742384e-02f, -9.96530503e-02f, -7.06414953e-02f, 1.64438803e-02f, -1.12468310e-01f, -3.54272197e-03f, -1.20939933e-01f, 5.38640805e-02f, 6.45469278e-02f,
  -7.63328373e-02f, 6.74006790e-02f, -1.20353170e-01f, 5.18446341e-02f, -3.51992529e-03f, 1.62322611e-01f, -6.56968579e-02f, 7.75347948e-02f, -1.16615191e-01f, 6.22389093e-02f,
  -3.87615144e-01f, -7.26985991e-01f, -9.95079651e-02f, -1.52092040e-01f, -4.17156145e-02f, 7.77987391e-02f, 8.84256065e-02f, 2.04140134e-02f, -1.19260795e-01f, -1.01367734e-01f,
  -1.09830283e-01f, -6.79442734e-02f, -7.21444190e-02f, -2.61026714e-02f, 9.97800454e-02f, 3.82781290e-02f, 1.88087334e-03f, -7.30933100e-02f, -7.63295293e-02f, 1.17728086e-02f,
  1.18527999e-02f, -1.47422299e-01f, 1.17705114e-01f, -1.04801636e-03f, -2.69063227e-02f, -1.16698764e-01f, -1.89263493e-01f, 1.08248927e-01f, 4.91226651e-02f, 4.78906855e-02f,
  -3.24853599e-01f, 7.11887376e-03f, -4.40748155e-01f, -3.80574286e-01f, 2.55461652e-02f, -6.61556125e-01f, -5.45586526e-01f, 1.07687503e-01f, -2.75212467e-01f, 1.38344929e-01f,
  1.48707852e-01f, -3.82186413e-01f, 4.02656287e-01f, -5.72957575e-01f, -5.30948520e-01f, -3.18089753e-01f, -4.94340926e-01f, -4.61076975e-01f, -7.76452050e-02f, 3.53272855e-02f,
  -1.01961412e-01f, 5.27012311e-02f, -2.45221600e-01f, 4.17432606e-01f, -1.75600901e-01f, 3.03683907e-01f, 4.34007138e-01f, 2.86698610e-01f, -9.57065448e-02f, -6.20529763e-02f,
  -2.26398885e-01f, 1.54726610e-01f, -8.89210701e-02f, -1.39286146e-01f, -3.66079323e-02f, 3.80061455e-02f, -1.06887117e-01f, -8.03050324e-02f, 1.27304895e-02f, -4.00633402e-02f,
  8.48286226e-02f, 5.83228879e-02f, -8.37669894e-03f, 7.50129148e-02f, 4.64219116e-02f, -5.79204485e-02f, -3.85182351e-02f, -1.07667819e-01f, 2.07109028e-03f, -1.53154179e-01f,
  -1.16260543e-01f, -3.19466814e-02f, -7.04570208e-03f, 2.72946078e-02f, 5.14264740e-02f, -3.51417959e-02f, -9.09543484e-02f, 1.95534597e-03f, 1.30060930e-02f, -9.41394493e-02f,
  1.16056629e-01f, -8.82032327e-03f, 9.16631892e-03f, -1.55686557e-01f, -4.69371565e-02f, 6.52606785e-03f, -3.40662785e-02f, 2.81801801e-02f, 4.48240824e-02f, -7.20820650e-02f,
  1.63460132e-02f, 8.06764141e-02f, -3.32926773e-02f, -9.44483355e-02f, 1.13741271e-01f, 7.29424283e-02f, -5.06560989e-02f, 8.80197436e-02f, -1.57709613e-01f, -8.30908027e-03f,
  9.28797945e-02f, 7.50974566e-02f, -3.58201899e-02f, 1.48661718e-01f, -6.18864186e-02f, -4.98763174e-02f, 2.04192713e-01f, 2.61581745e-02f, 3.35827991e-02f, 2.68002134e-02f,
  6.33061528e-02f, 4.21162516e-01f, -5.82496338e-02f, 9.86373052e-02f, -9.38780457e-02f, -1.13713257e-01f, -4.88045402e-02f, -2.84768455e-02f, -1.96836330e-03f, 9.41454023e-02f,
  1.62340119e-01f, 8.78615584e-03f, 4.10800055e-02f, 9.60950367e-03f, 3.91377211e-02f, -9.19942707e-02f, 1.64730996e-01f, 1.21182930e-02f, 1.81787476e-01f, 9.33791101e-02f,
  2.50379682e-01f, 1.52512074e-01f, 8.34171772e-02f, -1.41425254e-02f, 1.14455886e-01f, 5.29808961e-02f, 7.25155324e-02f, 3.08882557e-02f, 1.79195672e-01f, -4.65353131e-02f,
  3.69508862e-01f, 9.65138152e-02f, -2.99840868e-01f, -1.72761977e-02f, -4.94078994e-01f, -1.82799265e-01f, -2.53674775e-01f, -1.56521112e-01f, 4.66797441e-01f, 2.14915797e-01f,
  -3.30305010e-01f, 4.68657643e-01f, 2.59742707e-01f, -3.00819486e-01f, 2.40715876e-01f, 5.31554222e-01f, 5.03543355e-02f, 1.41751632e-01f, 1.46464929e-01f, 5.18608466e-02f,
  7.96456262e-02f, -3.42890114e-01f, -3.50449473e-01f, -2.95018464e-01f, -5.51938236e-01f, -1.50069982e-01f, -3.14609319e-01f, -3.40959877e-01f, -4.08922195e-01f, -2.56302923e-01f,
  -7.09007755e-02f, -2.75758822e-02f, -1.60581037e-01f, 1.35872558e-01f, -7.98350852e-03f, -1.23181619e-01f, -1.33558154e-01f, -1.16766788e-01f, 2.31916774e-02f, 3.89519893e-02f,
  2.29108199e-01f, 6.79097250e-02f, 1.36335298e-01f, -2.27020662e-02f, 2.15631276e-02f, -8.05335045e-02f, -1.12605365e-02f, -6.67531490e-02f, -6.93983436e-02f, -6.64036572e-02f,
  -7.21830279e-02f, -7.69173354e-02f, -9.91154015e-02f, 2.52561420e-01f, -2.06314176e-02f, 4.69130501e-02f, -6.01646230e-02f, -7.69487396e-02f, 4.93030064e-02f, 3.49406861e-02f,
  -1.17979527e-01f, 9.75695401e-02f, 1.63532223e-03f, -6.95756316e-05f, -8.16690996e-02f, -6.11864626e-02f, -6.92586526e-02f, -8.29708278e-02f, 1.42215922e-01f, -6.47144765e-02f,
  4.25310247e-02f, -9.78493020e-02f, 5.65962344e-02f, -1.76185220e-02f, -5.15350047e-03f, 1.80634052e-01f, 1.07399561e-01f, 1.88301057e-02f, -2.04299893e-02f, 2.41059922e-02f,
  -1.17154859e-01f, 9.60522071e-02f, -2.21514497e-02f, -7.37132458e-03f, 5.21980077e-02f, -1.67299658e-01f, 1.61261968e-02f, 5.20734526e-02f, 1.32384310e-02f, 1.18431645e-02f,
  -7.24412203e-02f, 2.85414606e-01f, 5.71327209e-02f, 1.35844707e-01f, 3.86102940e-03f, -6.62008747e-02f, 8.84276256e-02f, 1.23810679e-01f, -8.92589912e-02f, 8.12548175e-02f,
  -5.35019767e-03f, 1.20947108e-01f, 1.96072627e-02f, -4.07508388e-03f, 2.91752238e-02f, -3.74369211e-02f, 9.33948606e-02f, 1.63955122e-01f, -2.32393071e-02f, -3.78032103e-02f,
  -3.10637802e-02f, 9.06483382e-02f, 1.08694673e-01f, 1.01572953e-01f, 3.03834323e-02f, 3.04569136e-02f, 1.60854205e-01f, 9.71334204e-02f, -7.49399886e-02f, -5.56428032e-03f,
  -8.08388591e-02f, -2.18022987e-01f, 3.61632526e-01f, 4.07588989e-01f, 2.51187086e-01f, 4.88535315e-01f, 6.46702886e-01f, 1.73008695e-01f, 6.67496443e-01f, -3.83774415e-02f,
  4.73449826e-02f, -2.57032722e-01f, 2.14153558e-01f, 7.22402707e-02f, 2.20518857e-01f, 2.72940010e-01f, 3.75760853e-01f, 1.71162367e-01f, 1.02571353e-01f, -1.47446886e-01f,
  1.31016225e-01f, -4.99884523e-02f, -7.21406937e-02f, -5.48682809e-01f, -1.12366468e-01f, -3.40097785e-01f, -3.46105903e-01f, 5.45511767e-02f, -4.23832744e-01f, 1.02094404e-01f,
  1.15590245e-02f, -1.23133726e-01f, -1.21499710e-01f, 1.88225694e-02f, -1.35703683e-01f, -4.87285256e-02f, 1.12202607e-01f, 1.17190098e-02f, -5.10846823e-02f, -1.11992501e-01f,
  -1.39394850e-02f, -2.69813016e-02f, -1.30356267e-01f, -8.33509490e-03f, 6.52026311e-02f, -1.32132024e-01f, -2.34672185e-02f, 2.45753713e-02f, -6.52099401e-02f, 3.92763913e-02f,
  7.48808384e-02f, -2.58858986e-02f, -9.74058826e-03f, -1.03230039e-02f, 4.18229364e-02f, -9.29642245e-02f, 1.29674062e-01f, 3.15173417e-02f, -1.62990242e-02f, -5.85338064e-02f,
  -2.25040689e-02f, 7.69838393e-02f, 1.69331860e-02f, -5.04157320e-02f, 4.52043749e-02f, -9.14706141e-02f, 5.10250870e-03f, -6.24537729e-02f, 4.89814058e-02f, 3.94625925e-02f,
  2.54966523e-02f, -3.76046821e-03f, 1.11423517e-02f, 2.79629678e-02f, -3.03881969e-02f, 1.60952777e-01f, -2.23383843e-03f, 2.62057465e-02f, -3.60721052e-02f, -7.76388273e-02f,
  4.89249229e-02f, 7.20134899e-02f, -1.53774479e-02f, 5.74259199e-02f, 3.42851914e-02f, 4.84893471e-02f, -6.49152175e-02f, 3.57622132e-02f, 1.20094284e-01f, 1.17814519e-01f,
  1.19564690e-01f, -1.47692665e-01f, -5.68576083e-02f, -1.15382457e-02f, -4.05275449e-03f, -1.52419090e-01f, 1.14613054e-02f, -9.11024306e-03f, 1.11416571e-01f, 2.97966525e-02f,
  -1.00085177e-01f, -5.92264123e-02f, -9.58605930e-02f, 4.98303492e-03f, -2.17702147e-02f, 3.09863687e-02f, -4.67444025e-03f, -1.10601135e-01f, 4.43234518e-02f, -1.67887971e-01f,
  -1.84975505e-01f, -7.09421784e-02f, -5.02201430e-02f, -1.33002803e-01f, -9.77538303e-02f, -2.23926082e-02f, -1.50730669e-01f, 2.40157917e-02f, -3.85184251e-02f, -5.69747761e-02f,
  7.00083196e-01f, 2.37409011e-01f, 4.75584447e-01f, 5.76561630e-01f, 1.63749382e-02f, -2.28330523e-01f, -2.21754778e-02f, 2.48473778e-01f, 3.68612170e-01f, -2.52756894e-01f,
  -8.13605785e-02f, 1.68652311e-01f, -2.05527887e-01f, 2.13030502e-01f, -4.00305390e-01f, -3.20294410e-01f, -1.15147837e-01f, -9.78166759e-02f, 5.32218739e-02f, 8.83418098e-02f,
  2.34378755e-01f, -4.64108825e-01f, 1.86166272e-01f, -2.68686295e-01f, 4.78676260e-01f, 3.27711076e-01f, -2.55847603e-01f, -1.30415529e-01f, -9.32623073e-02f, -2.91790366e-01f,
  1.27250820e-01f, 3.13371360e-01f, 3.38224292e-01f, 2.36845408e-02f, 5.31203002e-02f, 8.29807818e-02f, -1.90819297e-02f, -1.12298772e-01f, 1.55357808e-01f, 2.95568034e-02f,
  1.57501139e-02f, 7.89870396e-02f, -2.97062416e-02f, -1.23985492e-01f, 1.44553050e-01f, 1.29844084e-01f, 3.01621288e-01f, 2.60517240e-01f, 1.45744801e-01f, 2.83605963e-01f,
  1.80276781e-01f, 8.66780356e-02f, 7.91631863e-02f, -7.97309428e-02f, 1.62150785e-01f, 3.19736190e-02f, -8.52222145e-02f, 8.14855099e-02f, 1.71522275e-02f, 8.54265392e-02f,
  -1.22678541e-01f, -1.03810929e-01f, -1.24053158e-01f, 5.59701733e-02f, -9.73610058e-02f, 6.85902461e-02f, -1.29917160e-01f, 2.62011513e-02f, -2.00742926e-03f, -8.67970213e-02f,
  7.48467296e-02f, 1.46651223e-01f, 4.01542149e-02f, -2.86329202e-02f, 8.84576421e-03f, 3.34437378e-02f, -8.59839767e-02f, -3.56634334e-02f, -3.22360569e-03f, 1.15893319e-01f,
  -8.42502192e-02f, -7.53042027e-02f, 1.83031149e-02f, 6.07161783e-02f, -1.20946959e-01f, -1.57778133e-02f, 1.07732400e-01f, 1.27363011e-01f, -9.58444830e-03f, -1.30149722e-01f,
  -4.27708149e-01f, -4.71971333e-01f, -5.38482033e-02f, -1.45333990e-01f, -1.11639492e-01f, 1.39482617e-02f, 2.33143307e-02f, 8.53809789e-02f, -1.77528694e-01f, -2.31217146e-02f,
  1.13371693e-01f, 4.42126617e-02f, -8.10526982e-02f, 1.57591216e-02f, -1.05651639e-01f, -7.16461055e-03f, -7.00694770e-02f, -1.70947939e-01f, -7.19555542e-02f, 4.13557189e-03f,
  5.36359623e-02f, -3.13595310e-02f, -1.98287535e-02f, 5.31427376e-02f, 4.97209169e-02f, -5.67763224e-02f, -6.96725994e-02f, -7.84764439e-02f, -1.59311295e-01f, 1.69004854e-02f,
  -7.30256736e-01f, 4.43527624e-02f, -4.07059371e-01f, 1.71407573e-02f, -2.49521017e-01f, -3.52188796e-01f, 1.83395341e-01f, -2.90772110e-01f, -9.73624885e-02f, 5.46997666e-01f,
  3.46731395e-01f, -3.73073310e-01f, 1.13665491e-01f, 2.11681232e-01f, -8.44828427e-01f, 4.00224254e-02f, 6.68410361e-02f, 1.81323111e-01f, -1.29307419e-01f, -2.38301888e-01f,
  -2.78564990e-01f, 5.83960079e-02f, 1.86957847e-02f, 4.05355878e-02f, 6.77519143e-02f, -6.28613681e-02f, 3.40247512e-01f, 3.46660018e-02f, 8.12769085e-02f, -2.53264278e-01f,
  -1.21255413e-01f, -9.08578411e-02f, 8.88240039e-02f, -3.46712060e-02f, -1.50096223e-01f, 2.06553861e-01f, 1.66900884e-02f, 2.71057952e-02f, -2.70988569e-02f, -1.20205209e-01f,
  -2.39643212e-02f, -4.88771275e-02f, -6.90095350e-02f, -6.30257949e-02f, -2.36363038e-02f, -1.23551272e-01f, -1.25974864e-01f, 1.04184836e-01f, -5.87113611e-02f, -7.51030445e-02f,
  -7.44288340e-02f, -7.68118650e-02f, 2.79198997e-02f, 7.26345778e-02f, -1.10895768e-01f, -1.44408971e-01f, 5.32528609e-02f, -1.22219278e-02f, -1.30029749e-02f, -8.39209184e-02f,
  -5.12477271e-02f, -1.15943691e-02f, 5.95923252e-02f, -5.24461381e-02f, -5.06134816e-02f, 7.45990798e-02f, 7.23412707e-02f, 2.13014092e-02f, -8.68256092e-02f, -4.35471497e-02f,
  -5.27065806e-02f, 2.62616538e-02f, 3.83952558e-02f, 8.28633457e-02f, 1.80365276e-02f, -1.33169768e-02f, 9.54827480e-03f, -7.99215063e-02f, -1.42922655e-01f, 1.27966389e-01f,
  9.33274999e-02f, -1.32993296e-01f, -6.10952219e-03f, 1.54508680e-01f, 1.37628792e-02f, 2.60567181e-02f, 7.02291727e-02f, -1.43984407e-02f, 8.64902735e-02f, -1.22913875e-01f,
  -3.61251205e-01f, -2.74132401e-01f, 1.64141636e-02f, -1.22230342e-02f, 7.92977810e-02f, -2.55014095e-02f, 7.15814084e-02f, -4.09218371e-02f, -7.59542286e-02f, -1.13515958e-01f,
  -5.05371317e-02f, 1.44993514e-01f, -4.61918525e-02f, 4.05830704e-02f, -6.33442402e-02f, -2.20073275e-02f, -5.08186892e-02f, -2.99429381e-03f, 4.30988669e-02f, -1.04597092e-01f,
  2.76205447e-02f, -3.33284177e-02f, 3.01885679e-02f, 7.95953199e-02f, 1.95574299e-01f, -5.98415406e-03f, -1.14917345e-01f, 1.21829165e-02f, -1.66587550e-02f, 9.36434697e-03f,
  3.35472636e-02f, -1.76010638e-01f, -5.21709442e-01f, -1.94756910e-01f, 2.91646183e-01f, -3.91131967e-01f, -5.83039261e-02f, 2.08211333e-01f, 2.82713234e-01f, 7.79052451e-02f,
  1.70847952e-01f, -2.97082543e-01f, 1.76542312e-01f, -5.20451128e-01f, -4.62206334e-01f, -1.65154099e-01f, -6.69941187e-01f, -3.00472766e-01f, 1.35937765e-01f, -2.81988204e-01f,
  -1.18986107e-01f, 1.59671515e-01f, -4.28980798e-01f, 3.83494318e-01f, 3.48602794e-02f, 5.97502552e-02f, 2.86254227e-01f, 2.08242998e-01f, -2.96516567e-01f, 2.04312913e-02f,
  -1.06604926e-01f, 1.85061559e-01f, 7.55700767e-02f, -3.46197076e-02f, -4.86548580e-02f, 1.36976078e-01f, -9.28512886e-02f, -1.53035792e-02f, 2.27333070e-03f, 7.63123408e-02f,
  -2.49439161e-02f, 8.33787397e-02f, 3.78627032e-02f, 1.97483510e-01f, 2.37379164e-01f, 3.63361463e-02f, -1.09236166e-01f, -8.31656978e-02f, 1.31726647e-02f, -1.47100359e-01f,
  -2.34340787e-01f, -1.93944976e-01f, -1.93881094e-01f, -4.77753133e-02f, -1.32082775e-01f, 5.39912982e-03f, -1.89414814e-01f, -2.05164209e-01f, -4.29124162e-02f, -3.63418907e-02f,
  6.76304325e-02f, -4.79732901e-02f, -5.91395088e-02f, 1.61476210e-01f, -5.38338087e-02f, 3.08242664e-02f, -2.60884762e-02f, -1.15921587e-01f, 1.35165617e-01f, 5.89902587e-02f,
  -2.45133638e-02f, 5.61776944e-02f, 2.31915742e-01f, -9.87065062e-02f, -6.69512674e-02f, -3.09958924e-02f, -8.17045346e-02f, 2.25789975e-02f, 2.15025749e-02f, -1.20621398e-01f,
  8.24950188e-02f, -9.58528146e-02f, 2.22379103e-01f, 6.34438694e-02f, -1.41972795e-01f, 1.33879691e-01f, 9.71352756e-02f, -1.09433010e-01f, -1.22374944e-01f, 6.06658161e-02f,
  -1.99573413e-01f, 7.27042407e-02f, 1.11956589e-01f, -8.41667503e-03f, -5.92900924e-02f, 6.17312118e-02f, -8.10448825e-02f, -1.59258589e-01f, -1.12375371e-01f, 2.10132465e-01f,
  2.02438198e-02f, 4.38474752e-02f, -6.63304105e-02f, 7.59397745e-02f, -1.12096645e-01f, 1.74405426e-01f, -9.19213239e-03f, 1.45488186e-02f, -5.44894068e-03f, -7.09775388e-02f,
  1.66818697e-03f, -2.71431562e-02f, -4.92398851e-02f, 8.83231312e-02f, 1.02654204e-01f, -6.46693632e-03f, 9.24400240e-02f, 6.01456650e-02f, -4.18531857e-02f, -7.82753080e-02f,
  -8.82675231e-01f, 3.23030591e-01f, 4.38454032e-01f, -3.37644309e-01f, -3.54636431e-01f, 5.70910037e-01f, 5.68615496e-01f, -1.44689977e-01f, -1.10635586e-01f, 3.32934409e-01f,
  -3.41306590e-02f, -1.38367504e-01f, 5.21903515e-01f, 1.79872900e-01f, 3.83427769e-01f, 5.02036273e-01f, 2.02312931e-01f, 2.61690915e-01f, -1.20538533e-01f, -3.44947040e-01f,
  -2.71682531e-01f, -2.30967671e-01f, 4.05836880e-01f, -2.04288557e-01f, -2.19165981e-01f, -2.05334246e-01f, -8.85126740e-02f, 1.11120038e-01f, -9.10415947e-02f, -7.79752731e-02f,
  -6.04967773e-01f, -5.30837119e-01f, -3.07840407e-01f, -7.41328225e-02f, -1.06580332e-01f, 6.33947402e-02f, 9.48722064e-02f, 1.01162255e-01f, -6.04972765e-02f, -1.85414910e-01f,
  -4.46672849e-02f, -2.75691207e-02f, -1.68505698e-01f, -8.95907544e-03f, -9.43497494e-02f, -5.51154017e-02f, 7.20430985e-02f, -1.11977302e-01f, -5.27988113e-02f, 1.14026681e-01f,
  1.67422175e-01f, -4.47634384e-02f, 1.11978939e-02f, 5.75052053e-02f, 3.50733846e-02f, -9.13476199e-02f, 2.50151567e-02f, 1.01388380e-01f, -8.40863287e-02f, -3.11296806e-02f,
  1.90082192e-01f, 7.97373205e-02f, 6.76021725e-02f, -5.24109975e-03f, -4.13251072e-02f, -1.31929755e-01f, 8.73872116e-02f, 2.46146023e-02f, 4.38210778e-02f, 5.65749817e-02f,
  -1.02859549e-01f, -4.74220291e-02f, -8.39682296e-02f, 4.74352241e-02f, -3.01438710e-03f, -8.91911983e-02f, 9.85252336e-02f, -2.19232053e-01f, 1.15452893e-01f, 4.74281478e-05f,
  5.60926571e-02f, 6.17248490e-02f, 8.88227448e-02f, 3.86573970e-02f, 5.63617125e-02f, 1.12864360e-01f, -7.08156303e-02f, 6.07994609e-02f, 2.22926959e-02f, -2.35769842e-02f,
  -4.46806222e-01f, -2.65365541e-01f, -1.80560738e-01f, -2.64546931e-01f, -4.92047472e-03f, -1.09893717e-01f, 5.54717258e-02f, -1.51754975e-01f, -6.68302178e-02f, -1.29313126e-01f,
  -1.05129421e-01f, -3.19589749e-02f, -7.19412491e-02f, 4.39832397e-02f, 1.47034243e-01f, 2.48311684e-02f, 7.34183192e-02f, -7.96370208e-02f, -4.88961227e-02f, -7.08885565e-02f,
  -1.13647103e-01f, -3.31894159e-02f, 6.87657967e-02f, -1.51658177e-01f, -6.48910776e-02f, -1.06582142e-01f, -2.54884511e-01f, -3.43419090e-02f, -7.99915195e-02f, 1.19087964e-01f,
  -4.60708499e-01f, 5.58194518e-01f, -1.64856911e-01f, 3.73790503e-01f, -5.71197629e-01f, 4.78498757e-01f, 6.43719435e-01f, -1.23498552e-01f, 3.14989746e-01f, 5.44070125e-01f,
  -2.20315099e-01f, 3.55848253e-01f, 1.57202050e-01f, 4.11164552e-01f, -6.33235350e-02f, 5.66955984e-01f, 5.21719337e-01f, 3.65467280e-01f, 3.72167304e-02f, 1.13581188e-01f,
  -5.61833829e-02f, 2.36652181e-01f, -1.58802286e-01f, -8.77744332e-02f, -2.72166818e-01f, -1.09110944e-01f, -2.67538071e-01f, -1.71384200e-01f, -3.81227657e-02f, -7.57687390e-02f,
  9.64056328e-02f, 9.10256952e-02f, -1.17961928e-01f, 2.04800472e-01f, 3.32357958e-02f, 2.69068144e-02f, -1.17718689e-02f, -1.50879264e-01f, -6.76296577e-02f, 1.11085854e-01f,
  6.86575249e-02f, -6.21741861e-02f, 1.61700085e-01f, -7.57743865e-02f, 8.04815348e-03f, -7.34647438e-02f, -7.47933090e-02f, -1.55594170e-01f, 1.18761100e-01f, -1.15670502e-01f,
  -1.06560513e-02f, -1.62359029e-02f, -5.92246205e-02f, 1.41806737e-01f, -9.53521356e-02f, 2.37226523e-02f, 1.08629428e-01f, -1.38080895e-01f, 3.57023142e-02f, 1.79143950e-01f,
  -9.66967717e-02f, 5.46586737e-02f, 3.79184484e-02f, -2.25608237e-02f, -3.30744870e-02f, 3.12507525e-02f, 3.75164580e-03f, -4.18074019e-02f, 5.29770693e-03f, 4.62397337e-02f,
  6.36365488e-02f, -4.20510583e-02f, 5.91980778e-02f, 5.44148637e-03f, 6.92951307e-02f, 4.56950702e-02f, -1.68954745e-01f, -5.61453328e-02f, 5.22835087e-03f, -1.12167105e-01f,
  4.93897833e-02f, 1.14949934e-01f, 8.00829679e-02f, 3.59041728e-02f, 1.08928539e-01f, -1.51064157e-01f, 9.37803388e-02f, -5.06607071e-02f, -8.72091874e-02f, -3.82090062e-02f,
  2.53162831e-01f, 4.60101843e-01f, 1.48105040e-01f, 9.76702124e-02f, 1.59032762e-01f, -1.17794961e-01f, 6.33690506e-02f, 1.39547847e-02f, 1.68352425e-01f, 1.14068270e-01f,
  -1.05190158e-01f, 5.65878674e-02f, -9.69193578e-02f, -1.31550536e-01f, -8.82548932e-03f, 1.35332987e-01f, 2.32990742e-01f, 8.74830503e-03f, 3.01251337e-02f, -6.52725473e-02f,
  -7.63273314e-02f, 1.40721157e-01f, 4.54391874e-02f, -1.07193878e-02f, -3.64986062e-03f, -2.49161273e-02f, -3.06866802e-02f, -2.51704920e-02f, -1.20040938e-01f, 1.05494291e-01f,
  -8.60584974e-01f, 6.45111322e-01f, 1.32599637e-01f, -2.68964499e-01f, 8.98520276e-02f, -4.93339188e-02f, -9.68357362e-03f, 1.24744929e-01f, -3.49215001e-01f, 2.96269119e-01f,
  2.29627639e-02f, -2.14562062e-02f, 1.12634316e-01f, 1.61163643e-01f, -5.05646229e-01f, 4.98752482e-02f, -4.95169051e-02f, -1.28923193e-01f, -1.02437034e-01f, -9.06613320e-02f,
  -1.68688893e-01f, -8.09222683e-02f, 6.60852864e-02f, 4.02912706e-01f, 6.93622306e-02f, -2.37145051e-02f, -2.45271027e-02f, 2.07237214e-01f, 2.64358401e-01f, 6.38753325e-02f,
  -5.14010489e-01f, -3.93098563e-01f, -1.68875739e-01f, -1.69700474e-01f, -1.64852560e-01f, -6.42816275e-02f, -6.64747879e-02f, -9.72912610e-02f, -1.56006992e-01f, 5.01769073e-02f,
  -3.82837863e-03f, -1.10396490e-01f, 2.03363299e-02f, 1.66046452e-02f, -6.56192899e-02f, -1.42834159e-02f, 1.88492626e-01f, 8.35767537e-02f, 9.32446718e-02f, 9.56843272e-02f,
  1.19395554e-01f, 6.27047643e-02f, 4.24771793e-02f, 8.70650038e-02f, 3.69625203e-02f, 7.83616751e-02f, 3.36626880e-02f, 1.47174187e-02f, -5.54211512e-02f, 1.08657992e-02f,
  8.26970860e-02f, -1.94612652e-01f, 3.83347757e-02f, -7.46434331e-02f, -4.14028764e-02f, 6.25331234e-03f, 2.37822570e-02f, -7.70574212e-02f, 5.06272726e-03f, 1.64232240e-03f,
  7.13916495e-03f, -1.73559543e-02f, -4.77267541e-02f, -4.95941490e-02f, 1.98374558e-02f, -1.43136129e-01f, 2.66209804e-02f, 1.01967202e-02f, 6.41991869e-02f, -9.91506353e-02f,
  -1.57025978e-01f, 1.71468463e-02f, -5.48743783e-03f, -6.27313927e-02f, -3.03174965e-02f, -7.90096968e-02f, -2.19080988e-02f, 5.76141924e-02f, -5.75422402e-03f, -8.44073594e-02f,
  -7.29939878e-01f, -3.67683917e-01f, -2.04985306e-01f, -6.55599460e-02f, -6.34901151e-02f, -7.71948323e-02f, -6.24688305e-02f, 3.61489505e-02f, -1.89599525e-02f, -3.62031981e-02f,
  -7.01707825e-02f, 7.71615375e-03f, -6.59814030e-02f, -1.39759585e-01f, -2.43927035e-02f, -6.03255741e-02f, -6.19842075e-02f, -4.12863418e-02f, -1.85855493e-01f, -4.60038669e-02f,
  -1.52727487e-02f, -8.82175379e-03f, 1.42998993e-01f, 8.42752401e-03f, -7.96824619e-02f, -6.51452690e-02f, -1.50748774e-01f, 8.96890685e-02f, 3.73692699e-02f, 3.42659056e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.57634509e-01f, 3.50135386e-01f, 4.02495682e-01f, 4.89581138e-01f, 4.66934621e-01f, 5.88470757e-01f, 4.36091036e-01f, 4.31118816e-01f, 2.88408399e-01f, 3.61660898e-01f,
  5.22803843e-01f, 5.05514741e-01f, 6.85771763e-01f, 3.60250860e-01f, 2.86516905e-01f, 3.55474651e-01f, 4.20901477e-01f, 2.88588613e-01f, 4.74801332e-01f, 4.81506735e-01f,
  2.75362223e-01f, 3.98239166e-01f, 4.97017950e-01f, 5.88175714e-01f, 3.36480737e-01f, 4.84137774e-01f, 4.98460531e-01f, 4.58294630e-01f, 3.18903774e-01f, 3.19674432e-01f,
  3.82552296e-01f, 4.05334502e-01f, 2.77740568e-01f, 4.79313672e-01f, 3.83723110e-01f, 2.19143972e-01f, 4.93018895e-01f, 3.81301761e-01f, 3.98316115e-01f, 5.08650124e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.09552392e-01f, 8.62381980e-02f, -3.11210513e-01f, -1.99960440e-01f, -2.49936525e-02f, -6.27788752e-02f, -1.58252850e-01f, 6.36708736e-02f, -4.93799210e-01f, -2.14755498e-02f,
  -5.99818647e-01f, 1.40738815e-01f, 3.82431567e-01f, -4.52004224e-01f, 3.89127761e-01f, -3.02519709e-01f, -1.22435324e-01f, -4.76567179e-01f, -4.47007626e-01f, -2.53052384e-01f,
  -2.32978284e-01f, 2.96204016e-02f, 3.78220618e-01f, -4.39502120e-01f, 6.43309280e-02f, -4.69991446e-01f, -1.82663232e-01f, -3.63311201e-01f, -3.28711033e-01f, -2.99721450e-01f,
  -3.93383324e-01f, -4.19157028e-01f, -6.20569326e-02f, -4.25233364e-01f, -3.31099749e-01f, 5.95741630e-01f, -3.18236589e-01f, -1.44471511e-01f, -3.93640339e-01f, -5.74106872e-01f,
  -5.40628195e-01f, -2.34169990e-01f, -2.48949319e-01f, -5.27477674e-02f, 5.95184863e-01f, -1.15133278e-01f, 3.53722237e-02f, -7.33889043e-01f, -5.16702592e-01f, -4.21753287e-01f,
  -9.27124992e-02f, 8.56673568e-02f, -4.32160914e-01f, 1.07028238e-01f, 1.87099501e-01f, -3.05830777e-01f, -1.78322032e-01f, 2.20247656e-01f, -2.62578040e-01f, 7.58641303e-01f,
  -3.64565432e-01f, 5.17443120e-01f, 5.34994960e-01f, 3.89928341e-01f, -2.76901573e-01f, 2.75301207e-02f, 1.23451009e-01f, 4.47367907e-01f, -4.85064238e-01f, 1.96701810e-01f,
  -2.18966767e-01f, -3.60319436e-01f, -7.02903122e-02f, -8.08044150e-03f, -2.64575750e-01f, 2.33799189e-01f, 4.92496759e-01f, 4.19781893e-01f, 5.35356879e-01f, -5.49009860e-01f,
  -2.36244991e-01f, 3.88195813e-01f, -2.69911349e-01f, 6.30826950e-01f, -6.94149911e-01f, 6.47262216e-01f, 3.65864605e-01f, 5.86979091e-01f, -1.71379462e-01f, -4.75637883e-01f,
  2.46022165e-01f, 1.96606085e-01f, -2.31743991e-01f, -2.14254186e-01f, -1.25313401e-01f, -1.07888088e-01f, -3.75444472e-01f, 5.69238603e-01f, -9.13566798e-02f, 3.38650972e-01f,
  -8.49766135e-01f, 2.74433076e-01f, 6.35355338e-02f, -4.57690269e-01f, -6.02634728e-01f, 4.37350571e-01f, -4.88072991e-01f, -5.69785573e-02f, -3.26548070e-01f, -3.07314277e-01f,
  6.63731039e-01f, -6.27811968e-01f, -5.09934485e-01f, 5.48503220e-01f, 4.52863574e-01f, -5.09607315e-01f, 2.15814069e-01f, -7.34735787e-01f, -2.95111179e-01f, -4.94029149e-02f,
  -2.75544912e-01f, 4.45481576e-03f, -2.99580574e-01f, -4.87327009e-01f, 1.06922068e-01f, -3.86526942e-01f, 3.74756306e-02f, -3.66256386e-01f, -2.17916101e-01f, -1.78501934e-01f,
  -3.46890569e-01f, -1.71135828e-01f, 9.66386348e-02f, -1.31932378e-01f, -6.37890100e-02f, 9.33185685e-03f, -4.82906736e-02f, -2.26056039e-01f, -2.84800623e-02f, -8.04424807e-02f,
  2.50605106e-01f, 2.85335928e-01f, 2.50292003e-01f, 4.20972228e-01f, -2.17957273e-01f, 3.01517397e-01f, -3.03540956e-02f, -1.61334708e-01f, 3.19787532e-01f, -4.88223694e-02f,
  -2.49252379e-01f, 2.00095251e-01f, -3.48012485e-02f, -4.04951066e-01f, 2.74934202e-01f, -3.01419705e-01f, -2.35346943e-01f, -3.11140388e-01f, -5.95918059e-01f, 1.59726888e-01f,
  4.44374353e-01f, 3.66622299e-01f, -2.47335121e-01f, -7.31176853e-01f, -2.22150117e-01f, 3.30033809e-01f, -6.54180115e-03f, 3.43497425e-01f, -2.53123403e-01f, -1.20565016e-02f,
  6.12477720e-01f, -6.20711029e-01f, 5.05694866e-01f, -5.21101534e-01f, 9.13534611e-02f, -4.82243001e-01f, 4.07669425e-01f, 3.23814541e-01f, 3.85712415e-01f, -2.48522088e-01f,
  -2.73274779e-01f, 4.54262555e-01f, -4.10122961e-01f, -4.37052369e-01f, -3.27611029e-01f, -4.34933156e-01f, -4.68963772e-01f, -6.32333606e-02f, -3.07126313e-01f, -5.11027217e-01f,
  -4.00911987e-01f, -1.54054791e-01f, -3.59944314e-01f, 8.84296596e-02f, -2.96088785e-01f, -3.46626580e-01f, 1.30025163e-01f, -2.15349153e-01f, -3.09851617e-01f, 1.71563663e-02f,
  1.05904341e-01f, -1.63143903e-01f, 9.75217149e-02f, -2.86305159e-01f, -1.61149606e-01f, -3.35309118e-01f, -2.86509573e-01f, -3.09040159e-01f, 3.29280466e-01f, -4.71967489e-01f,
  1.40673086e-01f, 2.22453803e-01f, 1.36818826e-01f, 2.43416667e-01f, 2.23717451e-01f, -1.70560151e-01f, -5.58929324e-01f, 4.96726453e-01f, -2.36842200e-01f, -4.29105967e-01f,
  3.53684723e-01f, -6.98859274e-01f, -2.05203444e-01f, -3.72065634e-01f, -1.00182995e-01f, -2.75354028e-01f, -5.54891825e-01f, -9.45636705e-02f, -2.09563822e-01f, 2.19964907e-02f,
  -2.87259132e-01f, -2.36928001e-01f, 2.32803106e-01f, -3.89849812e-01f, 2.12517813e-01f, -3.47369500e-02f, 8.60482231e-02f, 6.50606513e-01f, -7.49312878e-01f, -5.28211594e-01f,
  -2.76504070e-01f, -5.19285738e-01f, -1.51114598e-01f, 4.84546989e-01f, -3.08507115e-01f, -6.39424503e-01f, 5.38552143e-02f, 4.32179809e-01f, -2.64984697e-01f, -6.99026525e-01f,
  -3.49125624e-01f, 4.04545903e-01f, 4.84334320e-01f, -3.50866228e-01f, -1.37837857e-01f, 4.60829586e-01f, -3.32356654e-02f, 1.66707858e-02f, 3.26864332e-01f, 4.74972241e-02f,
  2.47588962e-01f, 2.79765666e-01f, 4.14028279e-02f, 2.45677710e-01f, 4.23176885e-02f, 2.85483122e-01f, 1.91936076e-01f, -1.26296580e-01f, -3.87201786e-01f, -5.56696653e-01f,
  1.15706533e-01f, -3.90058368e-01f, -5.24465501e-01f, -1.72650918e-01f, 5.44794023e-01f, -4.58344787e-01f, -4.32662666e-01f, 5.42602837e-01f, -4.39702898e-01f, -4.23519820e-01f,
  3.41342032e-01f, 2.16633454e-01f, 2.66169399e-01f, -6.48043752e-01f, -2.10804641e-01f, -7.39227980e-02f, 3.51757705e-01f, -1.11966111e-01f, -3.99032831e-01f, 2.84380585e-01f,
  -4.61325258e-01f, -5.40844738e-01f, -4.95667011e-01f, -3.12995426e-02f, -5.20648897e-01f, 5.02889931e-01f, 4.13664460e-01f, -1.45960003e-01f, -2.73637712e-01f, 2.32910633e-01f,
  -3.63216639e-01f, -4.90738243e-01f, -1.10822730e-01f, 1.64692685e-01f, 4.66298819e-01f, -5.80730617e-01f, -5.34034610e-01f, 2.55307645e-01f, 1.17085613e-01f, -2.78619397e-02f,
  5.54013431e-01f, -5.46133876e-01f, -4.21891451e-01f, -7.53785372e-02f, 5.79688735e-02f, -4.89775002e-01f, -4.07626718e-01f, 3.97793144e-01f, -3.04119229e-01f, 4.85997260e-01f,
  1.90628260e-01f, 2.15975150e-01f, 3.79991047e-02f, 3.46532799e-02f, 2.04682559e-01f, 2.20164090e-01f, 5.30164242e-01f, 4.82858986e-01f, 1.28323823e-01f, 2.97675788e-01f,
  5.82088232e-01f, 3.02080274e-01f, -4.83085811e-01f, 5.55346191e-01f, -3.91689479e-01f, 5.57701468e-01f, -4.96049225e-01f, 2.93737262e-01f, -3.72883201e-01f, 8.55749846e-02f,
  5.81957288e-02f, -6.00538611e-01f, 9.94586200e-02f, -1.30768090e-01f, -3.80135745e-01f, 2.07189266e-02f, -4.14991498e-01f, 3.25740963e-01f, -5.81468761e-01f, 2.25631461e-01f,
  -3.52338314e-01f, -1.64583206e-01f, -5.43411613e-01f, -4.36325632e-02f, 2.13478714e-01f, -1.72936022e-02f, 4.04601693e-01f, -1.10693291e-01f, -4.19071227e-01f, -2.77382910e-01f,
  1.31959543e-01f, -2.98349530e-01f, 1.54735371e-01f, 6.42061293e-01f, 2.21925303e-02f, -2.53075302e-01f, 3.25374492e-02f, 9.86714438e-02f, -4.18627828e-01f, -2.63448298e-01f,
  -5.89347184e-01f, -6.39098406e-01f, -2.44787827e-01f, -5.07703237e-02f, -1.92708522e-01f, -3.05348039e-01f, 5.10982931e-01f, 3.65587950e-01f, -5.52772939e-01f, -8.49926770e-01f,
  -3.34812999e-01f, 1.83617741e-01f, 6.67265296e-01f, -7.49023139e-01f, -9.85701755e-02f, 2.91822962e-02f, 2.39315808e-01f, 1.20348528e-01f, 1.96173728e-01f, -2.16299206e-01f,
  -4.65001874e-02f, -5.28484881e-02f, -2.31853276e-01f, -1.74213976e-01f, -1.67080194e-01f, -8.33510682e-02f, 5.83894253e-01f, 2.22541049e-01f, -3.03394377e-01f, 2.08280429e-01f,
  1.84224039e-01f, 4.03578222e-01f, 1.73677742e-01f, -2.52178431e-01f, 1.58424795e-01f, 1.86532855e-01f, 3.68524455e-02f, 1.91471457e-01f, 2.55351253e-02f, 2.76789755e-01f,
  4.07063723e-01f, 5.57667673e-01f, -6.15303814e-01f, -3.66153687e-01f, -2.74062812e-01f, -4.99526113e-02f, 3.20901215e-01f, -5.24131775e-01f, -8.01994145e-01f, -3.13690662e-01f,
  4.17228371e-01f, 1.67317674e-01f, 6.23219073e-01f, 4.55391288e-01f, -5.14122784e-01f, -2.80440450e-01f, -4.48279411e-01f, -1.47257313e-01f, -4.26681250e-01f, 2.09668249e-01f,
  -4.45457071e-01f, 4.52142537e-01f, -3.50543082e-01f, -1.51175039e-03f, -3.29624683e-01f, -3.89981598e-01f, -6.18694782e-01f, 2.50431329e-01f, -8.20217252e-01f, -2.62075484e-01f,
  5.25000244e-02f, 2.52013892e-01f, 6.33469462e-01f, -1.94376782e-01f, 3.38080078e-01f, -6.14965022e-01f, -4.59635675e-01f, -4.67558712e-01f, -1.35505974e-01f, -3.34600836e-01f,
  -2.67297536e-01f, 3.30780051e-03f, -1.31493732e-01f, -1.46046598e-02f, -2.69749284e-01f, -3.99383783e-01f, -8.59473646e-02f, -1.93022415e-01f, 4.51788455e-02f, -2.23938420e-01f,
  3.64317968e-02f, -6.68735579e-02f, -2.84471542e-01f, 1.49238154e-01f, 3.72639149e-01f, 3.63819569e-01f, 9.12879407e-02f, -3.29768300e-01f, -1.56948447e-01f, -3.28370988e-01f,
  2.42993131e-01f, -1.16921641e-01f, -3.38624835e-01f, 2.80335844e-01f, -1.67099044e-01f, -3.00067484e-01f, 3.71371448e-01f, 4.92535792e-02f, 3.30969632e-01f, -4.75920856e-01f,
  -3.06974530e-01f, -2.49197900e-01f, 1.67088121e-01f, -4.92827594e-01f, 2.41831169e-02f, -2.12691203e-01f, 3.66225272e-01f, -3.15893322e-01f, 2.68003911e-01f, 3.43454666e-02f,
  -1.20062754e-01f, -1.92577526e-01f, 3.92401695e-01f, -4.57881659e-01f, -2.88651615e-01f, -9.05129388e-02f, 2.71556497e-01f, -3.71924728e-01f, -5.44783652e-01f, -4.09286082e-01f,
  4.46300894e-01f, -3.85253936e-01f, 3.20553243e-01f, 2.34164357e-01f, 4.74238813e-01f, -3.97748232e-01f, -3.41410667e-01f, -2.88259983e-01f, 1.70777142e-01f, -1.45245612e-01f,
  -3.60419989e-01f, -5.51817179e-01f, -2.29202121e-01f, 2.07280163e-02f, 8.06947891e-03f, -2.88025320e-01f, -1.37766078e-01f, -1.73284158e-01f, -2.31514826e-01f, 9.19125378e-02f,
  1.31690562e-01f, 6.94353804e-02f, 1.35055155e-01f, -4.42689836e-01f, 2.47640148e-01f, -4.23561931e-01f, -2.41945028e-01f, 2.86413223e-01f, 2.15741634e-01f, -4.92343575e-01f,
  -2.47617751e-01f, 1.41169444e-01f, 4.06860948e-01f, -1.30704381e-02f, 1.45917058e-01f, 2.57563353e-01f, -4.01166320e-01f, -3.49723190e-01f, 2.46090531e-01f, 1.71582624e-01f,
  -2.25227490e-01f, 4.67744619e-01f, 3.03709209e-01f, -4.45542306e-01f, -4.63122427e-01f, -3.81001383e-01f, 3.48394632e-01f, 1.40465990e-01f, -5.04358172e-01f, 4.24562097e-01f,
  -2.81666934e-01f, -3.18951905e-01f, -2.21134171e-01f, 3.88433486e-01f, -3.90603244e-01f, -2.43427470e-01f, -3.62362117e-01f, 5.26263118e-01f, -4.12292659e-01f, -3.42929214e-01f,
  5.33876836e-01f, 7.94640258e-02f, -4.90757793e-01f, -4.01022315e-01f, -3.95013541e-01f, 4.86672014e-01f, -7.02173561e-02f, 2.78697193e-01f, -3.14370215e-01f, -3.73719573e-01f,
  1.75639704e-01f, -3.97203684e-01f, -4.54179466e-01f, -3.87782812e-01f, -2.31107354e-01f, -8.14940259e-02f, 2.28129804e-01f, 2.18240872e-01f, -5.79790995e-02f, 7.04975277e-02f,
  -2.51121432e-01f, -4.71333712e-02f, 2.08812714e-01f, -3.33392441e-01f, 2.20167086e-01f, -2.42335543e-01f, 1.74544394e-01f, 5.83448894e-02f, -5.53352892e-01f, -2.27809340e-01f,
  2.75778055e-01f, -3.93505931e-01f, 6.07261002e-01f, 2.33372942e-01f, -4.04728860e-01f, -3.66131693e-01f, 2.49333642e-02f, -5.00814438e-01f, -5.78512484e-03f, -2.14733750e-01f,
  -7.95720071e-02f, -6.71302438e-01f, -4.18119997e-01f, -2.43746102e-01f, -3.20071518e-01f, -7.09672645e-02f, 6.03418648e-01f, 6.00854218e-01f, 5.42377651e-01f, -5.17541349e-01f,
  -1.26338080e-01f, -3.67795378e-01f, 1.59750581e-01f, -1.07585475e-01f, -1.52578935e-01f, -1.26382876e-02f, -2.94361532e-01f, -2.86481589e-01f, 1.90173134e-01f, -3.89382809e-01f,
  -2.86832899e-01f, -3.84897947e-01f, -3.82447779e-01f, 3.07135284e-01f, 9.34843495e-02f, 3.25217247e-01f, 3.78416806e-01f, -5.11743188e-01f, 6.86253428e-01f, -6.14931762e-01f,
  5.42633906e-02f, -4.04430270e-01f, -2.84898758e-01f, 2.89019167e-01f, -3.51139545e-01f, -2.20972896e-01f, -5.84982574e-01f, 3.11583072e-01f, -6.13079607e-01f, -6.16108179e-01f,
  4.12362784e-01f, 1.91009939e-02f, -1.72895268e-02f, 1.91383719e-01f, 6.55194931e-03f, 3.64716023e-01f, 2.96742588e-01f, -1.73761576e-01f, 1.32620811e-01f, 1.23764994e-02f,
  -4.96425480e-02f, 1.60466954e-01f, 4.30963002e-02f, 4.56823558e-01f, -5.09020627e-01f, 7.69694746e-02f, -2.33592033e-01f, 1.39271379e-01f, 3.94084662e-01f, 3.98017555e-01f,
  1.32816911e-01f, 1.93845496e-01f, -5.19906521e-01f, -4.12259489e-01f, 5.47542393e-01f, -1.15613200e-01f, -7.36540854e-01f, -4.18820411e-01f, 3.40453573e-02f, 5.17398834e-01f,
  -3.42195928e-01f, -3.08639258e-01f, -2.46480167e-01f, -3.38510215e-01f, 3.41311216e-01f, 2.88289845e-01f, -5.52770555e-01f, -5.88059008e-01f, -1.38431162e-01f, -3.87343735e-01f,
  -3.80242079e-01f, -5.98686151e-02f, 4.70987350e-01f, -2.85413891e-01f, -4.04791415e-01f, -7.21570611e-01f, 3.40331703e-01f, -2.54279345e-01f, -3.19724292e-01f, 1.30706817e-01f,
  4.82560188e-01f, 2.42516041e-01f, -6.72931001e-02f, 2.46574312e-01f, -6.52980804e-01f, 4.63884413e-01f, -3.06343973e-01f, -3.01797807e-01f, -4.96957093e-01f, 2.01307178e-01f,
  1.68772891e-01f, -5.13768196e-01f, -4.25997674e-01f, 3.43966149e-02f, 2.11254433e-01f, 9.31250229e-02f, 9.91876349e-02f, 1.89798381e-02f, 1.44008577e-01f, -1.53172210e-01f,
  1.07001059e-01f, -5.25038280e-02f, -1.43081352e-01f, 1.28842354e-01f, 5.19416891e-02f, 2.26060729e-02f, 1.89289182e-01f, -4.70851436e-02f, 2.15794727e-01f, 2.55115241e-01f,
  3.02029431e-01f, -2.96091795e-01f, 3.15417469e-01f, 2.81966448e-01f, 4.56780225e-01f, -2.84558535e-01f, -3.66854936e-01f, 3.26467961e-01f, -2.48622745e-01f, -3.62974517e-02f,
  -2.74212748e-01f, 1.11770712e-01f, 5.69845557e-01f, -1.54768229e-01f, -5.43018937e-01f, 3.47181767e-01f, -2.91080087e-01f, 1.88966356e-02f, 5.39142847e-01f, -1.95594370e-01f,
  5.57291627e-01f, -6.81749523e-01f, -4.44936156e-01f, 2.55113258e-03f, 5.12422442e-01f, -1.69854090e-01f, -2.59326845e-01f, -2.13383377e-01f, -3.21326703e-01f, 4.94384825e-01f,
  -3.45441163e-01f, -8.18613768e-02f, -4.85464156e-01f, -1.90436929e-01f, 1.16043679e-01f, 7.74182826e-02f, -1.89306647e-01f, 1.75683081e-01f, -2.87829101e-01f, -5.64207196e-01f,
  -5.41487224e-02f, -4.83183712e-01f, 5.85527956e-01f, 8.37524235e-02f, -7.11913705e-01f, -3.93797815e-01f, -1.96607843e-01f, 1.72774062e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.63181704e-02f, -8.44031721e-02f, -1.86385900e-01f, 4.21226397e-02f, 1.53322414e-01f, 1.86391190e-01f, 2.27960851e-02f, -2.98225917e-02f, -1.37765855e-01f, 1.09533541e-01f,
  -6.06975257e-02f, -1.20111823e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    