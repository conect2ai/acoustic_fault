/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.39735734e-01f, -1.41751647e-01f, -1.25263050e-01f, -2.43706778e-01f, -1.91894367e-01f, -8.34937543e-02f, -1.49616599e-01f, -1.33126557e-01f, 1.91810019e-02f, 1.79688074e-02f,
  -4.67518270e-02f, -2.59932280e-01f, 1.32156596e-01f, -2.33639583e-01f, -3.39053929e-01f, 1.63942426e-01f, -3.59471887e-01f, -1.12369254e-01f, 1.15639111e-02f, -2.70144761e-01f,
  -9.92375538e-02f, -2.30432495e-01f, -1.55972928e-01f, -9.41871405e-02f, -1.08206324e-01f, 1.48549810e-01f, -4.27797213e-02f, 6.83768839e-02f, -1.06332496e-01f, -3.25191580e-02f,
  3.83686810e-03f, 4.15331312e-02f, -7.71416947e-02f, 8.22048411e-02f, -6.65644258e-02f, -6.19694218e-02f, 3.85159603e-03f, -4.50017629e-03f, 1.96009558e-02f, -1.83889661e-02f,
  7.79707581e-02f, -1.69821143e-01f, -6.80014491e-02f, 3.62730213e-02f, 2.15879586e-02f, -4.35543731e-02f, 3.82613018e-02f, -2.06021201e-02f, 4.98736501e-02f, -1.06376991e-01f,
  2.72437371e-02f, 7.97083415e-03f, -8.24385136e-03f, 1.77207682e-02f, -6.78367987e-02f, -2.95491721e-02f, -2.11421605e-02f, 6.57653157e-03f, 4.58997935e-02f, 9.84269008e-03f,
  -6.14208169e-02f, -2.53071450e-02f, -3.48107070e-02f, 5.73935099e-02f, -5.28082736e-02f, 3.30889970e-02f, 2.65058670e-02f, 1.32419607e-02f, -3.44520696e-02f, 1.22479014e-02f,
  -5.60206622e-02f, -1.38756447e-02f, 3.34624690e-03f, 1.03559950e-02f, -7.76653588e-02f, 1.95127307e-03f, -3.64067331e-02f, 2.00497080e-02f, -8.59630387e-03f, -7.86724985e-02f,
  4.12099175e-02f, 6.35968428e-03f, 3.67734469e-02f, 6.79295361e-02f, -2.78867465e-02f, -6.58673979e-03f, 1.45916231e-02f, -5.76092582e-03f, 5.04278056e-02f, -9.94596630e-03f,
  4.36743200e-02f, -1.57662451e-01f, 3.55293304e-02f, 2.77031809e-02f, 2.51679011e-02f, -3.53239737e-02f, -1.02249764e-01f, -3.08500603e-02f, 8.66240077e-03f, -2.03556344e-02f,
  -1.16251502e-02f, 9.25133657e-03f, 9.65555161e-02f, 3.50336507e-02f, 4.13915589e-02f, -3.80948093e-03f, -6.33241534e-02f, 1.18433475e-03f, -1.06715843e-01f, -3.60665657e-02f,
  -5.48103489e-02f, -2.07735281e-02f, 2.55217496e-02f, -5.52624799e-02f, -5.89430667e-02f, -1.99784921e-03f, 9.35576018e-03f, -1.08448202e-02f, -7.46071115e-02f, -2.09061820e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.28725266e-01f, 6.37420833e-01f, 3.81170735e-02f, 2.99125016e-01f, -2.00892881e-01f, 8.89579356e-01f, 8.55760515e-01f, 2.36070767e-01f, 3.31501216e-01f, 4.95971739e-01f,
  -3.47046033e-02f, 3.03319599e-02f, 1.04086146e-01f, 5.51862538e-01f, 2.51657695e-01f, 5.64699233e-01f, 4.11343783e-01f, 3.97526830e-01f, -1.30787432e-01f, 2.14580465e-02f,
  -1.18669413e-01f, 1.33593410e-01f, 2.45260051e-03f, -3.07279080e-01f, -1.81299776e-01f, -4.66699034e-01f, -2.96715468e-01f, -2.31264994e-01f, -1.00525700e-01f, 8.31499025e-02f,
  1.05483927e-01f, -1.93137228e-01f, -2.53124833e-01f, 1.04876474e-01f, -1.98354442e-02f, -7.45856017e-02f, 4.37169448e-02f, -6.05132431e-02f, -2.21798033e-01f, 4.82605509e-02f,
  -2.78365389e-02f, -3.34454775e-02f, 1.46679476e-01f, -4.29740101e-02f, 1.13014303e-05f, -7.84755945e-02f, -5.09431995e-02f, 1.04424488e-02f, 4.87727672e-02f, -2.37101577e-02f,
  -4.50331084e-02f, -3.63738323e-03f, 4.66273585e-03f, 1.39992282e-01f, -2.06601724e-01f, 1.53820543e-03f, 1.55350834e-01f, 1.85560100e-02f, 1.67409505e-03f, 6.09721281e-02f,
  -5.82825840e-02f, -2.60921456e-02f, 5.71566867e-04f, -4.15809080e-02f, -5.37442230e-03f, -1.51967347e-01f, -4.02126834e-02f, -1.61820222e-02f, -8.50455761e-02f, -1.95740126e-02f,
  6.97053000e-02f, -1.64518412e-02f, 6.26908615e-02f, 4.81971093e-02f, -1.79218948e-02f, 3.90872099e-02f, -1.35841727e-01f, -1.15476986e-02f, 9.89360511e-02f, 2.54179165e-03f,
  4.05330174e-02f, 5.03673814e-02f, -1.14841357e-01f, -1.36899859e-01f, 2.51623634e-02f, -1.63512751e-01f, 4.06747758e-02f, -6.47297595e-03f, -3.73340538e-03f, 1.78165175e-02f,
  2.96364844e-01f, 2.22955361e-01f, 1.10908737e-02f, -2.40435004e-02f, -5.71358353e-02f, -4.10709120e-02f, 7.72240907e-02f, 5.29437847e-02f, 1.12820283e-01f, -5.27598932e-02f,
  2.35490203e-02f, -8.95354077e-02f, 6.93799332e-02f, -5.81884868e-02f, -3.79726407e-03f, 1.69266790e-01f, -2.81592589e-02f, -1.43073266e-02f, 7.12043121e-02f, -1.01505958e-01f,
  -1.82178065e-01f, 2.73990706e-02f, -1.44268153e-02f, -1.48561999e-01f, -3.13801095e-02f, 3.68402861e-02f, -3.73937786e-02f, -1.62620947e-01f, -2.77462462e-03f, 5.66117465e-02f,
  -3.96766514e-01f, -1.86993182e-01f, -4.70839471e-01f, -4.96460013e-02f, -1.25892296e-01f, 3.02177608e-01f, 1.55400664e-01f, 1.00917391e-01f, -2.06696689e-01f, 7.62103438e-01f,
  6.12519383e-01f, -2.68116534e-01f, 4.97688055e-01f, 1.79415911e-01f, -4.84393865e-01f, 8.64073485e-02f, 2.45512933e-01f, 3.21744941e-02f, -1.99623585e-01f, -9.02337432e-02f,
  -2.27271408e-01f, 2.37493038e-01f, -1.27950802e-01f, 1.08780488e-01f, 1.25101626e-01f, -9.36950818e-02f, 2.65181154e-01f, 1.71638787e-01f, 2.00151861e-01f, -1.54554635e-01f,
  3.61948609e-02f, -1.99029408e-03f, -1.52790457e-01f, -3.99709195e-02f, 4.76226807e-02f, 1.91107467e-01f, 7.42114931e-02f, -3.99083979e-02f, -7.84264952e-02f, -5.06317578e-02f,
  3.07174912e-03f, -6.10758886e-02f, -7.00990483e-02f, -1.81062117e-01f, -6.05204329e-02f, -8.14777687e-02f, -3.96559089e-02f, -5.23216138e-03f, -3.96528170e-02f, 1.99319664e-02f,
  -1.86535530e-02f, -3.87333743e-02f, 1.92453131e-01f, -3.98586355e-02f, -4.17426005e-02f, 3.11088208e-02f, 6.33991510e-02f, -1.06489025e-01f, -8.37357622e-03f, -3.02967690e-02f,
  8.63016769e-03f, 5.32229729e-02f, 3.43666673e-02f, -5.28529137e-02f, -5.00465333e-02f, 6.16982579e-02f, 1.28485426e-01f, 1.55049365e-03f, -1.47373276e-02f, 1.60403714e-01f,
  -5.04885651e-02f, -1.88213103e-02f, 1.56573400e-01f, -1.17480308e-02f, -9.59576014e-03f, 2.66483221e-02f, 3.80156636e-02f, 5.17760292e-02f, -2.48109177e-02f, -1.77008361e-02f,
  1.78818718e-01f, -5.60852513e-02f, -5.95517531e-02f, 1.51375040e-01f, -4.54939157e-02f, 6.41009305e-03f, 4.40120958e-02f, -4.81102690e-02f, -3.15565951e-02f, -2.83941478e-02f,
  1.32330388e-01f, 3.32670361e-01f, -1.58595433e-03f, 2.62843259e-02f, 9.83075984e-03f, 3.93838957e-02f, -2.52629607e-03f, -4.77578305e-02f, 1.50948567e-02f, -5.65590002e-02f,
  2.32638838e-03f, -4.29832637e-02f, 3.03697854e-01f, 9.05232131e-03f, -1.04581244e-01f, 7.05541819e-02f, 1.73798636e-01f, -2.90292520e-02f, 1.07730858e-01f, 1.65605634e-01f,
  1.41123340e-01f, 1.35177821e-01f, -4.44951132e-02f, 7.11228978e-03f, 7.84984827e-02f, 2.74098068e-01f, -1.48554504e-01f, -9.49859396e-02f, -1.06691914e-02f, 2.94415411e-02f,
  -2.15977266e-01f, -6.39504194e-01f, 5.91605544e-01f, -1.16675571e-01f, 5.80888271e-01f, 5.73955357e-01f, 3.97060812e-01f, 2.31283277e-01f, -8.34001601e-02f, -5.63945711e-01f,
  -1.95884526e-01f, -1.63809285e-01f, -1.47772312e-01f, -9.00460780e-02f, 6.36640668e-01f, 1.20318227e-01f, 9.36462134e-02f, -1.02212705e-01f, 8.43641907e-02f, -1.10929303e-01f,
  1.61152616e-01f, -1.62383705e-01f, 3.13710064e-01f, -1.72017843e-01f, -3.26651260e-02f, -2.23840669e-01f, -1.69225782e-01f, 2.23441511e-01f, -1.27275527e-01f, 3.00961137e-01f,
  -1.23806387e-01f, -1.61519364e-01f, -9.53719914e-02f, 8.75315350e-03f, 1.98263768e-02f, -1.13297954e-01f, 5.62575012e-02f, 1.70557201e-01f, -5.01807369e-02f, -1.92385539e-03f,
  -1.52007744e-01f, 7.95778781e-02f, -2.31217649e-02f, 4.72340081e-03f, 2.88494583e-02f, 6.78632827e-03f, 1.77409992e-01f, -7.22856149e-02f, 5.72567619e-02f, 1.84504181e-01f,
  9.11802649e-02f, 2.68593933e-02f, 1.38557442e-02f, -5.41640334e-02f, 1.21333346e-01f, -1.51796183e-02f, 1.47806540e-01f, 5.84910326e-02f, 3.30444588e-03f, 1.21078631e-02f,
  1.64315760e-01f, 8.73835906e-02f, 7.18750199e-03f, -8.64130631e-02f, -4.41674236e-03f, -2.61321906e-02f, 5.46920262e-02f, 4.05390486e-02f, -1.02898255e-01f, -1.33086313e-02f,
  -4.22822833e-02f, -6.67584017e-02f, 1.06370531e-01f, -6.87298700e-02f, -5.60893863e-02f, -1.06542856e-01f, -6.28278479e-02f, -8.61447379e-02f, 9.40364972e-02f, 6.55839592e-02f,
  -4.08263765e-02f, 1.21405199e-01f, -1.99307054e-02f, -4.54333099e-03f, -1.11333594e-01f, 1.19275711e-02f, -1.49708822e-01f, -6.96799606e-02f, -3.31597812e-02f, 8.97447318e-02f,
  -7.35741675e-01f, -5.43499291e-01f, -1.20662883e-01f, -1.93004593e-01f, -2.71138381e-02f, -1.06240444e-01f, 5.49028814e-02f, -7.09260255e-02f, -1.02967009e-01f, -2.88828108e-02f,
  -9.35770050e-02f, -5.24678677e-02f, -7.00767413e-02f, 3.16882832e-03f, 1.59972273e-02f, 3.91083136e-02f, 2.58307885e-02f, -1.02140509e-01f, -3.12199108e-02f, -1.12361521e-01f,
  -2.18835607e-01f, -8.59066769e-02f, 8.13360959e-02f, -1.12795889e-01f, -4.53063324e-02f, 2.23225504e-02f, 5.70714846e-02f, 6.05813134e-03f, 8.55016634e-02f, -1.63399354e-02f,
  -1.41710695e-02f, -2.47533172e-01f, -2.84057915e-01f, 5.19166328e-02f, 1.57354966e-01f, -4.05208498e-01f, -6.02585018e-01f, 3.73407416e-02f, -4.34322029e-01f, -2.63155308e-02f,
  1.26536548e-01f, -1.38227165e-01f, -3.01583439e-01f, 2.09955797e-01f, 1.26639456e-01f, -8.76997560e-02f, 8.99982676e-02f, -6.51487559e-02f, 3.04794572e-02f, 2.32375085e-01f,
  -4.54751365e-02f, 6.38722479e-01f, 1.66895315e-01f, 4.29385215e-01f, 7.99777657e-02f, 1.50148094e-01f, 3.41817111e-01f, 1.13892175e-01f, 2.38301545e-01f, 2.54140139e-01f,
  3.27509791e-02f, 2.31373027e-01f, -1.03856668e-01f, -1.08089773e-02f, 5.71246818e-02f, 3.32757905e-02f, -1.02007106e-01f, 1.59408882e-01f, 5.34229204e-02f, -1.34275660e-01f,
  -8.41410179e-03f, 1.02464125e-01f, -3.37735899e-02f, 2.32676473e-02f, -1.31031722e-01f, -5.83097525e-02f, -7.59212375e-02f, -9.93557349e-02f, -1.72322437e-01f, 8.97359382e-03f,
  -1.91707969e-01f, 7.04554617e-02f, 7.51420856e-02f, -5.59772849e-02f, -1.06025010e-01f, 6.73869923e-02f, -9.00147930e-02f, -3.35068628e-03f, -7.95583148e-03f, -4.10317406e-02f,
  2.08649039e-01f, -5.39755002e-02f, -1.80997103e-02f, -9.79313105e-02f, 4.16148975e-02f, -5.35451472e-02f, 7.79577717e-03f, -4.11149040e-02f, -4.19260748e-02f, -3.94801758e-02f,
  -7.86322262e-03f, -9.64347497e-02f, 1.31473124e-01f, -1.59523934e-02f, -3.44633199e-02f, 1.53522328e-01f, -8.26249793e-02f, 6.62297681e-02f, -2.05724403e-01f, -1.13555945e-01f,
  9.01728868e-02f, 1.50049090e-01f, -1.48279473e-01f, -8.30845386e-02f, 2.50999257e-02f, -2.52266834e-03f, 5.87297417e-02f, 4.04449366e-02f, 2.00852510e-02f, 8.93430188e-02f,
  6.57072067e-02f, 3.01399857e-01f, -4.48210277e-02f, 1.99697930e-02f, -6.86231535e-03f, -7.27633527e-03f, -2.62174048e-02f, 5.10806590e-02f, 1.12210445e-01f, 3.85450339e-03f,
  7.86337107e-02f, -8.68471190e-02f, -3.23669128e-02f, 4.18553501e-02f, 1.28038507e-02f, 6.78930432e-02f, 8.97307098e-02f, -7.43192136e-02f, -8.18054155e-02f, 7.44696185e-02f,
  3.32495645e-02f, -1.07966624e-01f, -8.45168158e-02f, -1.69081107e-01f, 1.53495173e-03f, -4.06365357e-02f, 2.75572166e-02f, 3.89960455e-03f, 2.02290609e-01f, 5.87473176e-02f,
  2.53373589e-02f, 4.78676468e-01f, 4.07858431e-01f, 4.16937888e-01f, -1.77419171e-01f, -6.46609783e-01f, -4.82913613e-01f, 3.68526131e-01f, -8.12367871e-02f, 8.26760158e-02f,
  -2.39049628e-01f, 3.24405462e-01f, -3.18244547e-01f, 2.40255892e-01f, -5.98409295e-01f, -5.34950852e-01f, 5.50024770e-02f, 1.39898956e-01f, 1.86446644e-02f, 1.70164064e-01f,
  2.75159013e-02f, -3.41364950e-01f, 1.64016455e-01f, 1.78073958e-01f, 2.98844099e-01f, 5.32661080e-01f, 2.61298388e-01f, -5.48877716e-02f, 5.80286741e-01f, -3.99396941e-02f,
  -1.03084937e-01f, 3.55485901e-02f, 1.61574408e-01f, -3.61231938e-02f, 5.72774000e-02f, -7.71380961e-02f, 1.58574566e-01f, -1.41147286e-01f, -1.00148253e-01f, 3.83270532e-02f,
  -3.13557452e-03f, -8.35585296e-02f, 1.79088518e-01f, -3.53413112e-02f, 2.66006007e-03f, 1.15006506e-01f, 1.07632503e-01f, 8.75740573e-02f, 8.67096260e-02f, 2.16239482e-01f,
  1.06093891e-01f, 1.21982507e-01f, 9.11589712e-02f, 3.05944383e-02f, -2.39006095e-02f, -4.29276191e-02f, -4.59230207e-02f, 1.45077378e-01f, 7.62464851e-02f, 4.38839719e-02f,
  -1.57412086e-02f, -1.71675161e-01f, -8.84593055e-02f, 4.88380678e-02f, -1.46923542e-01f, -3.16020101e-02f, 1.68077126e-02f, 3.11940312e-02f, -3.18975449e-02f, -9.97583643e-02f,
  -7.21960589e-02f, 1.22061126e-01f, -5.16773798e-02f, -9.90623981e-03f, -9.05480683e-02f, 2.70427708e-02f, -7.77738914e-02f, 1.42926928e-02f, 1.36855454e-03f, 2.18146577e-01f,
  -4.60549556e-02f, -2.20294416e-01f, -7.53019229e-02f, 1.43648431e-01f, -2.58324623e-01f, -1.51217982e-01f, 8.56412500e-02f, -6.89072907e-02f, 3.29278111e-02f, 2.06017774e-02f,
  3.66306007e-02f, 8.55958536e-02f, 1.79584939e-02f, 8.22992697e-02f, 7.15871202e-03f, -6.28607199e-02f, -1.27636017e-02f, 1.54530093e-01f, -1.16376355e-02f, -8.36030766e-02f,
  -2.11038347e-02f, -2.70723514e-02f, 1.01355717e-01f, -1.17891327e-01f, 2.58154906e-02f, -4.33886088e-02f, -4.71427515e-02f, -8.74459967e-02f, 2.23796964e-01f, 7.32326806e-02f,
  9.28056166e-02f, -1.34187728e-01f, 6.61811009e-02f, 2.73671616e-02f, 1.65870544e-02f, 6.58782050e-02f, -1.92328505e-02f, 2.77692601e-02f, 5.33430241e-02f, -1.61638632e-02f,
  7.23109484e-01f, -5.24547637e-01f, -6.66407466e-01f, 1.27882853e-01f, 5.77365577e-01f, 5.09230971e-01f, 2.31653806e-02f, 1.25995815e-01f, -5.25593497e-02f, -3.88925552e-01f,
  2.62240231e-01f, -1.88357666e-01f, -5.57281137e-01f, 5.97388983e-01f, 5.26427805e-01f, -3.99599880e-01f, 3.93356740e-01f, 1.33711159e-01f, -1.45043790e-01f, 7.41306543e-02f,
  2.90565878e-01f, 7.27287292e-01f, -1.06662981e-01f, 3.06746244e-01f, 4.36176181e-01f, -3.00462663e-01f, -4.98354919e-02f, -3.28448206e-01f, 2.88357109e-01f, 2.64045537e-01f,
  1.84069380e-01f, -5.07280901e-02f, -1.08655477e-02f, -7.35959709e-02f, 2.43906509e-02f, -4.71501891e-03f, -1.16959833e-01f, -6.84098303e-02f, 4.49616648e-02f, -8.48254114e-02f,
  -9.65294465e-02f, 4.88406718e-02f, 1.46778688e-01f, 2.03312710e-02f, 1.71034515e-01f, 6.72967434e-02f, 2.79301777e-02f, 3.70397642e-02f, -2.02991664e-01f, 4.18849625e-02f,
  -8.43361467e-02f, 1.16637256e-02f, 5.24325259e-02f, -1.28089115e-01f, -1.05892874e-01f, -5.05763898e-03f, -5.62305339e-02f, -6.25122786e-02f, -3.78770456e-02f, 5.14878593e-02f,
  4.11975682e-02f, -5.29423133e-02f, 1.08665787e-02f, 9.44494605e-02f, 6.85588568e-02f, 2.35833917e-02f, 3.52831110e-02f, -3.09948176e-02f, -1.00228831e-01f, 5.09315319e-02f,
  2.46655717e-02f, 6.16617948e-02f, -1.87561996e-02f, 6.56426093e-03f, 6.19272962e-02f, 4.84100543e-02f, 9.40987084e-05f, -9.00767278e-03f, 3.84544395e-02f, 2.20872369e-02f,
  -6.75227940e-02f, 9.75239463e-03f, -3.26335207e-02f, -2.91861016e-02f, 7.57252797e-02f, -1.01151451e-01f, 3.42167653e-02f, 6.22705631e-02f, -1.10571854e-01f, -4.97828312e-02f,
  -8.01066384e-02f, -4.26214755e-01f, -1.14544876e-01f, -1.37031591e-02f, -1.35124564e-01f, 9.67522785e-02f, -2.94707641e-02f, 8.10225680e-02f, -1.49545833e-01f, 7.67843127e-02f,
  2.78631579e-02f, -7.23833367e-02f, -3.86614017e-02f, 1.27372608e-01f, -7.74048688e-03f, 7.06496416e-03f, -1.62786961e-01f, -1.15066446e-01f, 8.92970711e-03f, 1.03002079e-02f,
  1.09507553e-02f, -7.48695061e-03f, -1.26001297e-03f, 9.11131278e-02f, 4.28441949e-02f, -2.32190061e-02f, 6.22782335e-02f, -8.14571902e-02f, -1.27315912e-02f, -5.40459566e-02f,
  -2.40748510e-01f, -1.17897160e-01f, -5.62756285e-02f, -3.11312169e-01f, -1.81770161e-01f, 5.61146855e-01f, 5.36876798e-01f, -2.47094080e-01f, -7.11213648e-01f, 2.52589281e-03f,
  3.40199888e-01f, -1.52936548e-01f, 3.36205155e-01f, 3.44146639e-01f, 5.82196653e-01f, 4.22337234e-01f, 1.62291169e-01f, 1.99550033e-01f, 1.15141477e-02f, -6.47655949e-02f,
  1.12463683e-02f, 3.95607620e-01f, 5.28445542e-01f, 1.12372249e-01f, 7.27473199e-02f, -2.23910898e-01f, -1.61126435e-01f, -4.21693921e-02f, 7.43966997e-02f, 2.94798970e-01f,
  2.60483712e-01f, -1.83627546e-01f, 7.64790326e-02f, -4.13576281e-03f, 1.36511981e-01f, 5.13049811e-02f, 7.75587335e-02f, 8.01999569e-02f, -8.70172903e-02f, -1.67385191e-02f,
  -1.15111724e-01f, -2.16286242e-01f, -1.62327535e-06f, -1.64885819e-02f, -2.55580276e-01f, -1.98282331e-01f, -2.90216804e-01f, 3.42345424e-02f, -9.50450301e-02f, -2.01993305e-02f,
  -1.37979120e-01f, -9.76855010e-02f, -7.82290623e-02f, 8.07906908e-04f, -1.64422855e-01f, -1.48535416e-01f, -8.87405034e-03f, 2.27009244e-02f, -8.79672021e-02f, -4.17467542e-02f,
  -1.73564687e-01f, -8.10145121e-03f, -7.19053373e-02f, 2.13964283e-01f, -1.18754487e-02f, 9.43203643e-02f, 2.84555573e-02f, 1.45446867e-01f, -3.67181073e-03f, -3.61873545e-02f,
  -9.21213329e-02f, -7.06746578e-02f, -4.55327472e-03f, -2.55842842e-02f, 2.37158239e-02f, -4.26618755e-02f, 2.28687301e-01f, 5.99435270e-02f, -1.38711751e-01f, 7.92159364e-02f,
  -3.17579918e-02f, -1.60499752e-01f, -5.27526066e-02f, 2.36798283e-02f, 1.28076822e-01f, 3.09784301e-02f, 7.54416436e-02f, -2.28228550e-02f, 3.84249687e-02f, 1.17422119e-01f,
  8.79158229e-02f, -3.84032220e-01f, 1.16359787e-02f, 5.74854352e-02f, 1.33331567e-01f, 8.26203749e-02f, 2.07212478e-01f, -7.53662735e-02f, -8.06056485e-02f, -4.10447344e-02f,
  8.40855390e-02f, 5.78222312e-02f, -8.73896405e-02f, 9.32894647e-02f, -3.99414003e-02f, -2.20717047e-03f, -8.82865787e-02f, -8.04198161e-02f, -7.75651857e-02f, 2.89447960e-02f,
  -2.70921197e-02f, -1.28680632e-01f, 4.45898212e-02f, 6.56103939e-02f, -1.61593944e-01f, 9.75675210e-02f, -1.56636119e-01f, -7.17359483e-02f, -6.55516908e-02f, 1.06829545e-02f,
  -1.21437359e+00f, 5.88984668e-01f, -7.93181807e-02f, -3.42159241e-01f, 1.92882016e-01f, -3.81984040e-02f, -4.48243096e-02f, 1.30072862e-01f, -2.84458876e-01f, 2.23183483e-01f,
  -2.24040337e-02f, -3.10137153e-01f, 3.09324563e-01f, 1.19138196e-01f, -5.36757946e-01f, 1.08576797e-01f, -2.95116484e-01f, -2.67449170e-01f, -7.73250237e-02f, -5.25062047e-02f,
  -7.65914619e-02f, 1.87333941e-01f, -2.41127592e-02f, 4.82566804e-01f, -6.53708726e-02f, -1.71156600e-02f, -4.74866778e-02f, 2.70943284e-01f, -4.00183676e-03f, 5.74424118e-02f,
  -2.71862537e-01f, -3.06784153e-01f, -1.39442936e-01f, -2.37127796e-01f, -1.76286578e-01f, -8.06226954e-02f, -9.38043594e-02f, -1.04003046e-02f, -5.78147843e-02f, -4.21053357e-02f,
  -9.15460736e-02f, 1.41867008e-02f, -5.10387830e-02f, 7.10901618e-02f, -4.58595641e-02f, -2.51905620e-02f, 1.20644905e-01f, 2.22704764e-02f, 3.94797549e-02f, 3.47373262e-02f,
  9.73838717e-02f, -5.39604984e-02f, -5.20968176e-02f, 5.76754734e-02f, 8.69157538e-02f, 2.70752143e-02f, 2.92823277e-02f, 8.29762518e-02f, -1.02996282e-01f, -4.39084917e-02f,
  7.89098383e-04f, 7.89230913e-02f, 8.99469331e-02f, -9.48198438e-02f, -1.81871392e-02f, -5.45475520e-02f, -8.99871904e-03f, -8.35890472e-02f, 1.97773576e-02f, -4.12522368e-02f,
  -2.68036462e-02f, -1.82698481e-02f, -1.60661787e-02f, -5.34812622e-02f, 1.13410287e-01f, -4.94494922e-02f, -5.81077784e-02f, -1.18358724e-01f, -1.95924495e-03f, -2.73137074e-02f,
  1.31463977e-02f, 4.54850048e-02f, 3.07460874e-02f, -1.09333925e-01f, -5.22291511e-02f, -7.44399577e-02f, -5.55257080e-03f, 1.00642167e-01f, -8.33044127e-02f, 4.45809513e-02f,
  -5.39187253e-01f, -3.75632137e-01f, 9.79679227e-02f, -9.79822949e-02f, -1.71587646e-01f, -1.28121544e-02f, 3.42489183e-02f, 5.14455847e-02f, -8.94180089e-02f, -5.69879040e-02f,
  -6.16160221e-02f, 5.60216419e-03f, -1.37781978e-01f, -1.17646895e-01f, -7.64325308e-03f, 6.68570846e-02f, -5.11091687e-02f, -6.23670891e-02f, -1.03186570e-01f, -2.69379504e-02f,
  -4.09341529e-02f, 7.47373104e-02f, 8.60153288e-02f, 3.86996903e-02f, -6.89421445e-02f, -1.46282062e-01f, 5.26141701e-03f, -3.62206670e-03f, 1.47282174e-02f, 7.89715573e-02f,
  -1.08238548e-01f, 6.25266850e-01f, 2.66378731e-01f, -3.98751020e-01f, -1.07141629e-01f, -1.29268900e-01f, -2.65801698e-01f, 3.24973106e-01f, 3.34303260e-01f, 3.89612257e-01f,
  1.06179677e-02f, 5.33683956e-01f, 4.49545324e-01f, -3.81854326e-01f, -2.10374162e-01f, 8.98910984e-02f, -3.30485165e-01f, -9.06735733e-02f, 2.52269417e-01f, -2.49290079e-01f,
  -1.73291564e-01f, -5.14829755e-01f, -5.49292624e-01f, -1.18366972e-01f, -2.20235437e-01f, -5.00734411e-02f, -5.42347848e-01f, -9.02669057e-02f, -4.62484807e-01f, 6.99599311e-02f,
  -4.83125262e-02f, 2.39770576e-01f, -5.43659739e-02f, 2.25153148e-01f, -9.09659788e-02f, -9.65334568e-03f, -6.53388128e-02f, 1.21515263e-02f, 1.88565981e-02f, 1.46612033e-01f,
  4.02756967e-02f, 1.50705397e-01f, -1.18534490e-02f, 7.40470812e-02f, 7.16125518e-02f, 9.56198573e-02f, 1.05768652e-03f, -1.20213427e-01f, 1.08907223e-01f, 1.15061902e-01f,
  6.00756183e-02f, 1.14299446e-01f, -3.02520320e-02f, -1.02670237e-01f, -3.25586274e-02f, -4.57185768e-02f, -1.04243375e-01f, -9.18421820e-02f, 6.99610412e-02f, 5.61603680e-02f,
  -3.19630344e-04f, 1.30688283e-03f, -5.17430194e-02f, 1.14803948e-01f, 2.28051003e-02f, 1.97478961e-02f, 1.85099058e-02f, -1.79182410e-01f, -6.50323182e-02f, -1.00519724e-01f,
  -1.75949767e-01f, 6.47542477e-02f, -1.58656925e-01f, -3.91066894e-02f, -6.99955598e-02f, 3.77980582e-02f, -4.61483784e-02f, 9.86199751e-02f, -4.34500836e-02f, -1.24151528e-01f,
  3.63424644e-02f, -1.70731634e-01f, 1.63878173e-01f, -1.60348177e-01f, 1.62272006e-01f, 9.34596583e-02f, 1.36005789e-01f, 1.05717346e-01f, -7.98069015e-02f, -2.27008477e-01f,
  -2.71430880e-01f, -2.20455527e-02f, 1.41778472e-03f, 1.19704239e-01f, 6.72980100e-02f, 5.14616370e-02f, 2.18313816e-03f, 5.76406484e-03f, 1.01852203e-02f, -3.64235416e-02f,
  1.21650696e-01f, -9.01044011e-02f, -3.13074365e-02f, -7.07741380e-02f, -7.44313747e-02f, -3.79018951e-03f, -1.60038978e-01f, 6.91240206e-02f, -9.53320265e-02f, 8.01467299e-02f,
  5.08843549e-02f, 3.19294892e-02f, 1.17302092e-03f, -1.69104353e-01f, -7.25271180e-02f, 5.52783534e-02f, 3.59307528e-02f, 1.29490212e-01f, -3.31858024e-02f, 1.15355857e-01f,
  4.27496672e-01f, 1.89785529e-02f, 3.76120210e-01f, 3.95099908e-01f, -3.67968976e-02f, 1.95287675e-01f, 4.01636779e-01f, -3.65797430e-01f, 7.08494559e-02f, -2.09894970e-01f,
  -9.31332931e-02f, 5.77119529e-01f, 1.57881483e-01f, -2.90588345e-02f, 1.62128538e-01f, -1.78957254e-01f, -1.02571651e-01f, 1.36892155e-01f, -5.15591241e-02f, 8.10117051e-02f,
  -2.76813004e-02f, -4.83796924e-01f, 1.18357174e-01f, -5.51446319e-01f, 1.60301551e-01f, -4.70344834e-02f, -2.83361733e-01f, 1.34999767e-01f, -7.46814460e-02f, 5.47972731e-02f,
  7.81522915e-02f, -1.66435122e-01f, 3.22035514e-02f, -7.18545988e-02f, -7.13755861e-02f, 9.54776406e-02f, 9.09152105e-02f, 6.88025057e-02f, 2.00436398e-01f, -3.96841355e-02f,
  1.83133572e-01f, 1.47770206e-02f, -7.71104991e-02f, 1.66448541e-02f, -1.32894069e-01f, -7.65381083e-02f, 6.26255246e-03f, -1.83478501e-02f, 3.36322151e-02f, 8.33865851e-02f,
  2.39869490e-01f, 1.61169007e-01f, -5.72773516e-02f, 4.19814847e-02f, 3.56698558e-02f, 2.06476022e-02f, 7.86191300e-02f, 3.27518702e-01f, 2.42729448e-02f, 7.95848593e-02f,
  3.17936973e-03f, -1.09672539e-01f, -7.38921911e-02f, -2.43666768e-02f, -7.99783468e-02f, -8.15668725e-04f, -8.83215014e-03f, -8.75512287e-02f, 9.76778567e-02f, 6.87453663e-03f,
  -6.41557574e-02f, 3.59704979e-02f, -1.72136799e-01f, 7.01265112e-02f, 5.70675433e-02f, 1.60616655e-05f, 1.61628321e-01f, 3.22844237e-02f, -2.37120967e-02f, -8.66159890e-03f,
  3.89305316e-02f, -1.46726798e-02f, 9.29532051e-02f, 1.15209498e-01f, 4.76911478e-02f, 3.19563299e-02f, -1.17060363e-01f, 1.96619466e-01f, -2.40859874e-02f, 3.47042456e-02f,
  -2.24950224e-01f, -4.65973049e-01f, -3.94024812e-02f, 3.14723812e-02f, -1.86550338e-03f, 1.60317402e-02f, -1.16638049e-01f, -1.62592288e-02f, 4.85159829e-02f, -2.72896476e-02f,
  -9.30709243e-02f, -8.90822802e-03f, 1.65036879e-02f, 6.30643172e-03f, 3.31132533e-03f, -1.02852369e-02f, -2.51401067e-02f, -5.76927587e-02f, -1.12505676e-02f, -1.74485683e-01f,
  1.45790055e-01f, -8.01563188e-02f, 6.23834506e-02f, 1.57583989e-02f, -7.53828138e-02f, -4.15554922e-03f, 6.88390732e-02f, -6.86380491e-02f, -3.52148712e-03f, 1.15676522e-02f,
  -7.35337436e-01f, 6.57984674e-01f, -1.10488482e-01f, 4.02412355e-01f, -3.85927171e-01f, 2.16171905e-01f, 1.96546942e-01f, -1.38578326e-01f, 1.00436106e-01f, 3.37134540e-01f,
  6.15628175e-02f, 1.94237300e-03f, 1.42399430e-01f, 5.77023923e-01f, 2.34441161e-01f, 5.39751828e-01f, 5.00359476e-01f, 2.75809139e-01f, 2.01993689e-01f, 1.12191506e-01f,
  3.29573661e-01f, 3.58473957e-01f, 4.72663760e-01f, 9.89785120e-02f, 5.77522628e-02f, -8.49218071e-02f, 1.40242547e-01f, -1.31760776e-01f, 1.93459108e-01f, 6.57532886e-02f,
  -6.13086037e-02f, -2.89549798e-01f, -1.72072887e-01f, -1.65769026e-01f, -1.36115283e-01f, -1.85107112e-01f, -2.06536815e-01f, -2.02823222e-01f, -1.00261472e-01f, 6.77545890e-02f,
  -5.68315946e-02f, -8.51094276e-02f, 4.39622216e-02f, 9.93709192e-02f, -5.98142296e-03f, 3.42725851e-02f, 1.34277076e-01f, -6.41861111e-02f, -4.86230664e-02f, -5.71445934e-03f,
  1.05019629e-01f, 7.82278925e-02f, 4.33089882e-02f, 2.50869125e-01f, 9.48121697e-02f, 5.21395868e-03f, 1.05698436e-01f, 1.31002776e-02f, 8.73389021e-02f, 8.25536326e-02f,
  7.87684694e-02f, 3.70877683e-02f, -3.10080871e-02f, -5.49111608e-03f, 5.92070110e-02f, -1.80209354e-02f, 1.42405048e-01f, -1.31220073e-01f, 4.89268191e-02f, 4.43294719e-02f,
  -9.17474627e-02f, 7.16597959e-02f, -1.33692414e-01f, 9.05112829e-03f, 1.26171902e-01f, -1.15137182e-01f, -1.85531542e-01f, -3.59316617e-02f, 9.03984085e-02f, -1.35446452e-02f,
  -5.41126542e-02f, -5.00279889e-02f, 1.43397212e-01f, 7.95512348e-02f, 6.49970472e-02f, -5.22709228e-02f, 3.27154100e-02f, 1.17769167e-01f, -5.75516000e-02f, -5.30518778e-02f,
  3.67180586e-01f, 4.74276870e-01f, -4.96550975e-03f, -1.07564643e-01f, 1.31134823e-01f, -5.20407222e-03f, -4.22596596e-02f, -9.57428478e-04f, 2.42938250e-01f, 1.07388742e-01f,
  -2.00913683e-01f, 1.23530000e-01f, -2.03154311e-02f, -9.71591994e-02f, 1.94108635e-01f, 2.05413997e-01f, 2.97783166e-02f, 3.04072984e-02f, 5.17340079e-02f, -5.12213670e-02f,
  1.01455361e-01f, -8.15898776e-02f, -1.98198017e-02f, 3.33454739e-03f, 1.68319698e-02f, -8.91458318e-02f, 1.92448776e-02f, -1.07135959e-01f, -1.49233360e-02f, 1.40857816e-01f,
  1.66569471e-01f, -1.32055029e-01f, -3.76911491e-01f, -2.33538508e-01f, 4.56812352e-01f, 3.72440606e-01f, 1.52519554e-01f, -2.18838975e-02f, -5.68425536e-01f, 1.00705996e-01f,
  7.88129196e-02f, -3.27516824e-01f, -2.13339448e-01f, -3.78718048e-01f, -2.34543055e-01f, -3.70736092e-01f, -1.21574830e-02f, 1.45714641e-01f, -1.87512368e-01f, 1.35817602e-01f,
  -4.08483073e-02f, 1.38916537e-01f, -4.01842356e-01f, 7.91293383e-02f, 2.77078480e-01f, 7.14104623e-02f, 3.53830338e-01f, 5.12142256e-02f, 2.06425339e-01f, -1.29617050e-01f,
  -1.37329385e-01f, -1.20367400e-01f, -9.20911133e-02f, -1.69150203e-01f, 1.86324283e-01f, 1.31062448e-01f, 1.83614522e-01f, 7.63371438e-02f, -9.73007083e-02f, -1.49706248e-02f,
  1.05481029e-01f, 1.42418994e-02f, -6.17182702e-02f, -4.08482179e-02f, 1.86121687e-01f, 6.73478702e-03f, -9.79835540e-02f, -2.55465750e-02f, -1.01540186e-01f, 3.80045623e-02f,
  -1.12821698e-01f, 2.11335830e-02f, 5.71379066e-02f, -4.47059311e-02f, -2.18425896e-02f, -9.00975913e-02f, -7.64372339e-03f, 1.67323023e-01f, 4.88986336e-02f, 3.53888310e-02f,
  1.23479158e-01f, 1.08237281e-01f, 8.77150893e-02f, -8.61363932e-02f, 4.06449521e-03f, -4.85869981e-02f, 6.70420304e-02f, -7.97911063e-02f, -1.26865506e-01f, 2.15162858e-02f,
  3.53166088e-03f, 5.88191971e-02f, -1.43270448e-01f, 6.32792935e-02f, 1.19842485e-01f, -3.76941301e-02f, -3.77756134e-02f, 7.97721595e-02f, 1.28873631e-01f, -9.37430263e-02f,
  -1.75478682e-01f, 1.08982176e-01f, 1.27269819e-01f, 7.29624033e-02f, -8.73588100e-02f, 5.93856536e-02f, -7.52914418e-03f, -7.39763677e-02f, -4.64742407e-02f, 3.30863222e-02f,
  1.00670747e-01f, 1.96675062e-01f, -1.36350170e-01f, -9.70871001e-02f, -1.38425425e-01f, 7.74685852e-03f, -1.86143279e-01f, -2.07605548e-02f, 8.63009095e-02f, 8.19558650e-03f,
  2.42826894e-01f, 4.76519428e-02f, 1.58785760e-01f, -1.38471246e-01f, 5.42568490e-02f, 1.25149190e-01f, 2.16140881e-01f, 1.06022462e-01f, 4.43668962e-02f, 1.21790729e-01f,
  1.00222059e-01f, 2.09763750e-01f, -6.51378483e-02f, 6.29299320e-03f, 8.37116614e-02f, -2.43930668e-02f, 1.24653742e-01f, 8.62469897e-02f, 1.18008837e-01f, 2.53861118e-02f,
  4.93080944e-01f, -1.98245347e-01f, -4.70477700e-01f, -4.70621020e-01f, -2.91602820e-01f, -3.07227194e-01f, -2.24060446e-01f, -4.29627359e-01f, -1.15299739e-01f, -1.46548167e-01f,
  -1.00598700e-01f, 2.51651436e-01f, 5.00788510e-01f, -3.17912728e-01f, 5.70969403e-01f, 5.18190563e-01f, -3.09876561e-01f, -4.89266664e-02f, -9.61694047e-02f, -1.05031788e-01f,
  -6.76722750e-02f, -1.49342373e-01f, -9.19880345e-02f, -2.82086313e-01f, -3.12709659e-01f, -3.34325880e-01f, -2.55385004e-02f, 3.84749398e-02f, -4.88836348e-01f, -2.83253640e-02f,
  -1.08529024e-01f, -5.93417138e-02f, -1.01236381e-01f, 6.20220453e-02f, -1.43018559e-01f, 5.50555857e-03f, 2.41792686e-02f, 1.04414932e-01f, 7.60218054e-02f, 7.91724995e-02f,
  1.97265089e-01f, 2.59386033e-01f, -1.68301105e-01f, 1.20544851e-01f, -4.39957120e-02f, -1.49401620e-01f, 9.78802796e-03f, -1.94554374e-01f, -1.53720453e-01f, -7.41427988e-02f,
  6.01548143e-02f, -2.06289828e-01f, -6.36800081e-02f, -4.62161042e-02f, 2.64221989e-02f, -1.60962164e-01f, 1.28500447e-01f, -9.53935906e-02f, -3.94229777e-02f, 3.45933065e-02f,
  6.23930544e-02f, 2.32481718e-01f, 8.20837170e-02f, -7.24469349e-02f, 2.06036922e-02f, -1.36603460e-01f, -2.25783922e-02f, 5.58606088e-02f, 1.12290293e-01f, 3.01656406e-02f,
  -1.77691486e-02f, 9.08556953e-03f, 9.46441814e-02f, -1.20651238e-02f, 6.64554685e-02f, 3.61626372e-02f, 1.24814413e-01f, 4.67340089e-02f, -4.82605584e-02f, -1.62358418e-01f,
  2.32846364e-02f, 1.29254282e-01f, -3.82834226e-02f, -1.16423286e-01f, -1.01473309e-01f, 8.59176069e-02f, 5.60883014e-03f, 7.21027032e-02f, -1.35078818e-01f, 6.17742129e-02f,
  -1.21113554e-01f, -1.81553289e-01f, -2.29008738e-02f, 4.59788702e-02f, -1.35045275e-01f, -1.51463626e-02f, -4.03019972e-02f, -5.36843203e-02f, -1.72422633e-01f, -1.58125497e-02f,
  -1.60497963e-01f, -9.75774415e-03f, -7.68927783e-02f, -4.75429408e-02f, 5.92286093e-03f, -4.84178066e-02f, 1.75872758e-01f, 5.66060692e-02f, -3.80286984e-02f, -5.60044870e-02f,
  -3.54087949e-02f, 2.45634377e-01f, 2.29694188e-01f, 5.67369610e-02f, -5.74504882e-02f, -9.82761085e-02f, -1.33644193e-02f, -9.93772876e-03f, -2.52443384e-02f, 5.85092381e-02f,
  5.54508328e-01f, -2.06931338e-01f, 2.89754719e-02f, 7.74587512e-01f, 4.04104382e-01f, 1.26269519e-01f, 1.85609803e-01f, 3.41561019e-01f, 8.78617048e-01f, -4.01915491e-01f,
  1.60927065e-02f, -2.37934798e-01f, -4.85524088e-01f, 8.08872283e-02f, 3.19236182e-02f, -2.68755883e-01f, 4.22930092e-01f, 7.67089501e-02f, 4.16445643e-01f, 7.90793225e-02f,
  4.23310667e-01f, 4.77232561e-02f, -1.74261793e-01f, -7.90747330e-02f, 2.46486425e-01f, 1.94973826e-01f, -2.30597585e-01f, -1.97377473e-01f, -2.45430231e-01f, -9.29678455e-02f,
  1.20555229e-01f, 2.58459419e-01f, 6.70160577e-02f, -1.24231642e-02f, 2.16723904e-01f, 1.86492875e-03f, -1.19972177e-01f, -1.84841603e-01f, 1.33284554e-01f, -3.79182249e-02f,
  -2.24433899e-01f, 1.37950648e-02f, 6.69919476e-02f, -1.34807378e-01f, 1.57811657e-01f, 2.80228816e-02f, 4.22446392e-02f, 3.63920517e-02f, -9.91169885e-02f, -8.88909176e-02f,
  -6.51590824e-02f, 6.19398169e-02f, 1.73744529e-01f, -5.59987575e-02f, 1.19050266e-02f, 1.60942584e-01f, -4.17893846e-03f, -1.78717956e-01f, -3.53034399e-02f, 1.74554065e-01f,
  -9.78082791e-02f, 3.58243659e-02f, -1.69017926e-01f, 9.57515761e-02f, -7.22994730e-02f, 1.61872134e-01f, -5.67457490e-02f, -3.82836647e-02f, 2.27430407e-02f, -6.51016235e-02f,
  -2.77145784e-02f, 8.36319402e-02f, 7.58180916e-02f, 8.53724256e-02f, 8.96640569e-02f, -7.45179132e-03f, -6.60287961e-02f, -4.67635430e-02f, 1.97745845e-01f, 2.47061364e-02f,
  6.97638839e-03f, -5.63725084e-03f, -9.69211534e-02f, 5.79856597e-02f, -2.90028080e-02f, -7.40215033e-02f, 9.12978724e-02f, -1.95025541e-02f, 5.50934076e-02f, -1.01714812e-01f,
  1.06943347e-01f, -3.22339498e-02f, -4.19915169e-02f, 4.49227216e-03f, -9.17584263e-03f, -1.19932026e-01f, 3.92852202e-02f, 7.95719177e-02f, 8.24788362e-02f, 5.85963205e-02f,
  1.75502636e-02f, -8.34175274e-02f, 9.57102515e-03f, -3.43869999e-02f, -9.11043771e-03f, -4.42596562e-02f, -1.33715987e-01f, 6.80362880e-02f, 5.99132925e-02f, -2.77740852e-04f,
  -1.30386934e-01f, -2.40631420e-02f, -4.08474877e-02f, 1.71757728e-01f, -1.86233148e-02f, -7.59776914e-03f, 2.65279114e-02f, -3.42417806e-02f, -1.34116620e-01f, 7.83066675e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.46375167e-01f, 6.02994442e-01f, 8.19260001e-01f, 5.40560544e-01f, 5.90440929e-01f, 3.48755956e-01f, 4.99198973e-01f, 3.10708255e-01f, 5.79222262e-01f, 5.75348616e-01f,
  6.55613363e-01f, 3.69603485e-01f, 6.44331396e-01f, 3.41288865e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.87154993e-01f, -2.47756794e-01f, 8.17484707e-02f, -3.00935563e-02f, -3.06074619e-01f, 1.62921473e-01f, 2.80978620e-01f, 3.98388058e-01f, -7.92834535e-02f, -2.85943776e-01f,
  -2.09934637e-02f, -8.99881274e-02f, -5.91340102e-02f, 2.90702611e-01f, -2.05890596e-01f, -1.05189040e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.72398973e-01f, -5.94271958e-01f, -1.72106400e-01f, -3.89682986e-02f, 7.78904974e-01f, -1.76037550e-01f, 2.27302033e-02f, 1.20357561e+00f, 3.74081999e-01f, -6.62806630e-01f,
  -3.53630483e-01f, 5.95997095e-01f, -3.96822780e-01f, 4.11786288e-01f, 1.89411774e-01f, 4.95103508e-01f, -7.38286495e-01f, -8.11839759e-01f, 7.33549893e-02f, -1.39059365e-01f,
  -2.96674132e-01f, 7.44627833e-01f, 1.93364590e-01f, 1.07717121e+00f, 1.44920563e-02f, -4.14066613e-01f, -3.85283194e-02f, -5.29147446e-01f, 2.45423675e-01f, 3.23863357e-01f,
  5.51626265e-01f, -2.18410026e-02f, -2.11760238e-01f, 3.77389103e-01f, -2.97640949e-01f, -2.09301636e-02f, 3.97700548e-01f, 5.33394098e-01f, 3.69228005e-01f, 5.93293071e-01f,
  8.93796921e-01f, 9.41907108e-01f, 6.87290013e-01f, -1.02370776e-01f, 5.02279043e-01f, -6.12202942e-01f, -4.85393941e-01f, -5.91305614e-01f, 6.18301749e-01f, -1.26055956e-01f,
  8.56295705e-01f, 8.35195482e-01f, 5.03714919e-01f, -1.76227719e-01f, -5.65086722e-01f, -3.35147619e-01f, 6.63761616e-01f, -4.13123667e-02f, -4.27960575e-01f, 4.67699468e-01f,
  4.41691160e-01f, 7.31758714e-01f, 5.30482411e-01f, -5.29745340e-01f, 3.15659940e-01f, -9.82621908e-01f, 1.03921092e+00f, 4.18150187e-01f, -6.94356024e-01f, 3.51991028e-01f,
  -2.12604664e-02f, 1.56390876e-01f, 1.70731232e-01f, -3.60677898e-01f, -6.39428422e-02f, -3.01448464e-01f, 1.27939212e+00f, 7.17311725e-02f, 1.89195380e-01f, 2.90356725e-01f,
  -5.05224288e-01f, 3.60974461e-01f, -6.40511513e-01f, 5.32238662e-01f, -3.06109011e-01f, 5.93167722e-01f, 3.40809464e-01f, -5.08903265e-02f, -4.43112254e-01f, 5.94610929e-01f,
  3.38859290e-01f, -2.62116969e-01f, 1.23837134e-02f, 1.89546466e-01f, 4.26092863e-01f, -6.50749505e-02f, 4.81269747e-01f, -4.65615541e-01f, 7.28612781e-01f, 7.53321946e-02f,
  4.77447301e-01f, -2.22720191e-01f, -7.43462682e-01f, 5.69028795e-01f, 4.44255203e-01f, -1.20516799e-01f, 9.28630903e-02f, -4.72188517e-02f, 3.68393749e-01f, -1.09809645e-01f,
  8.31863523e-01f, 7.83420801e-01f, 4.66584980e-01f, -3.33789825e-01f, -2.29677543e-01f, -8.73110473e-01f, 9.27161694e-01f, 1.29078880e-01f, 1.08870924e+00f, 2.44486496e-01f,
  -1.82574823e-01f, 1.64714858e-01f, 6.90674007e-01f, 8.18434715e-01f, 2.16931269e-01f, -4.71336037e-01f, 1.92250699e-01f, 1.09228230e+00f, -1.05460569e-01f, 2.34849140e-01f,
  2.62126535e-01f, 8.26207876e-01f, -7.87947059e-01f, 3.94883603e-01f, 5.38366199e-01f, -3.24945122e-01f, 5.27445197e-01f, 3.59740257e-01f, -6.57538116e-01f, -3.52983385e-01f,
  7.01786220e-01f, 5.21416426e-01f, -5.40541649e-01f, -3.22102636e-01f, 2.35171646e-01f, 2.93369144e-01f, -2.50204206e-01f, 4.41399038e-01f, 4.89961028e-01f, 6.63285196e-01f,
  4.65370685e-01f, 2.54362643e-01f, 9.46392477e-01f, 7.36723125e-01f, 8.88665840e-02f, 1.94962755e-01f, 3.12226593e-01f, 5.07856071e-01f, -2.39024743e-01f, -7.98054695e-01f,
  3.30167055e-01f, 6.22189641e-01f, 3.88880342e-01f, 2.98277378e-01f, 3.02672267e-01f, 3.37153107e-01f, -2.70635068e-01f, -8.08177948e-01f, 2.13632733e-01f, 9.73812461e-01f,
  8.27204943e-01f, -6.66061997e-01f, 2.52852380e-01f, -1.71887070e-01f, 4.57591861e-01f, -1.48055004e-02f, 6.85053825e-01f, -5.60312212e-01f, 2.15755180e-01f, 3.21160257e-02f,
  1.30137578e-01f, -2.56366953e-02f, 4.62970257e-01f, -3.49875003e-01f, 2.85041571e-01f, -7.21323907e-01f, 5.64112306e-01f, 7.72450626e-01f, -3.10727656e-01f, 1.99535549e-01f,
  8.74444306e-01f, -5.44000626e-01f, -7.33989775e-01f, -3.01808603e-02f, -6.59256876e-01f, -2.44633369e-02f, -3.14658314e-01f, 6.27468526e-01f, 2.37868711e-01f, -1.62211344e-01f,
  -2.64729410e-01f, 5.31434178e-01f, 5.79992235e-01f, -3.75137806e-01f, 2.38851905e-01f, -6.98402047e-01f, 6.04332566e-01f, -1.74758255e-01f, 9.10850242e-02f, 4.28754926e-01f,
  -7.11509943e-01f, 4.23389524e-01f, -7.19006002e-01f, 3.17440301e-01f, 7.76291549e-01f, -2.69686192e-01f, -4.58168060e-01f, 2.24122658e-01f, 4.26247448e-01f, 2.86807626e-01f,
  -8.71811584e-02f, 6.46986961e-01f, 3.98500443e-01f, 5.31464107e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.15984210e-01f, -8.81129429e-02f, 2.21796185e-01f, 4.56901401e-01f, 4.28920835e-02f, 1.18680529e-01f, 4.13437158e-01f, 5.72226226e-01f, 2.57102877e-01f, 4.59167361e-01f,
  4.11462277e-01f, 1.27188355e-01f, 2.82596126e-02f, 2.52393305e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -2.79112995e-01f, -4.42422807e-01f, -7.60672092e-01f, -9.22169566e-01f, 9.91497338e-02f, 4.66632098e-01f, 2.91746914e-01f, -5.52486479e-01f, 2.63414592e-01f, -1.40258455e+00f,
  4.50607896e-01f, 2.05195040e-01f, 3.30463871e-02f, -7.12012529e-01f, -3.65673035e-01f, -3.67669582e-01f, -4.35325384e-01f, 7.20745921e-01f, 1.58998504e-01f, 7.67438412e-01f,
  -2.34282464e-01f, 1.50131628e-01f, 6.10760093e-01f, -1.26453564e-01f, 3.05786848e-01f, -1.11843288e+00f, 3.53836417e-02f, -7.90869743e-02f, -7.58896053e-01f, -1.65400133e-01f,
  -2.62512676e-02f, -1.20531060e-01f, -7.32109919e-02f, 1.71458840e-01f, 2.97838748e-01f, 6.37999296e-01f, 5.66128194e-01f, -9.18900192e-01f, -3.95300984e-02f, -2.30742335e-01f,
  -1.45792335e-01f, 2.21673235e-01f, -9.08944786e-01f, 3.86046976e-01f, -6.66704357e-01f, -8.43790650e-01f, -7.79631257e-01f, -5.00698924e-01f, -7.80121759e-02f, -2.95762688e-01f,
  -1.35761023e-01f, -5.43610394e-01f, 6.18594825e-01f, -9.50087011e-01f, -6.70854628e-01f, 5.57936728e-01f, -6.88518107e-01f, -7.13854909e-01f, -2.54354864e-01f, 2.44697228e-01f,
  4.12730992e-01f, -6.05570316e-01f, 9.20685410e-01f, 3.67940724e-01f, 2.56180260e-02f, -6.28766894e-01f, -5.83004177e-01f, -3.28029096e-01f, 8.34514737e-01f, -3.51127260e-03f,
  -8.45093250e-01f, -4.85167086e-01f, -4.82074469e-02f, 2.41616815e-01f, -2.17338130e-01f, 5.56792200e-01f, 4.69188899e-01f, -1.37568280e-01f, -2.74979115e-01f, -9.05941308e-01f,
  6.00580812e-01f, -3.36599469e-01f, -4.41906095e-01f, -4.16437030e-01f, -1.08790135e+00f, 2.78827310e-01f, 8.41907084e-01f, -4.74555671e-01f, 4.70075876e-01f, 1.98066220e-01f,
  -7.37818182e-01f, -9.02679503e-01f, 2.84039140e-01f, 3.34037542e-01f, -6.16887510e-01f, -3.97574723e-01f, 4.30786520e-01f, -2.47319862e-01f, 6.32084846e-01f, -1.14468917e-01f,
  -9.54252601e-01f, -4.55580115e-01f, -8.71038079e-01f, -3.65386337e-01f, 5.88791251e-01f, 7.18458593e-01f, -3.49436402e-01f, -1.12919736e+00f, -5.53267419e-01f, -5.95070541e-01f,
  -6.32117018e-02f, -4.91869956e-01f, -2.17749268e-01f, -1.76211536e-01f, -5.81006110e-01f, 2.32846558e-01f, -6.11996174e-01f, -4.13016170e-01f, -3.02147686e-01f, 2.98668534e-01f,
  1.71600029e-01f, 2.76185311e-02f, -5.15063822e-01f, -7.38554716e-01f, 1.90009296e-01f, 3.39858502e-01f, 6.56872153e-01f, 3.79161268e-01f, -2.79219270e-01f, 2.64275849e-01f,
  -5.86944282e-01f, 2.77692527e-01f, 6.74101189e-02f, -7.91590452e-01f, 4.45422918e-01f, 1.47894427e-01f, -6.67942584e-01f, 3.48497331e-01f, 4.47482258e-01f, 1.18861385e-01f,
  -6.25299811e-01f, -5.28681278e-01f, 5.78801572e-01f, -5.06722443e-02f, -2.10293218e-01f, -4.27266538e-01f, 5.49870372e-01f, -4.79988962e-01f, -4.03618991e-01f, 7.75417209e-01f,
  -1.10318100e+00f, -3.89929056e-01f, -1.30865292e-03f, -1.32031038e-01f, -6.02283418e-01f, 3.89671534e-01f, -7.76890337e-01f, 7.68404961e-01f, -2.56045282e-01f, -5.57636976e-01f,
  2.12265939e-01f, 4.80056494e-01f, -2.95107484e-01f, -4.22367483e-01f, -7.09639370e-01f, 4.20470536e-01f, -3.64290833e-01f, 3.59920710e-01f, -6.62490308e-01f, -8.34207714e-01f,
  7.60389507e-01f, 4.46379751e-01f, -1.22455209e-01f, -1.49773881e-01f, -9.10828054e-01f, 8.30185235e-01f, 3.03721637e-01f, 3.87908667e-01f, 1.05437621e-01f, -7.47599483e-01f,
  1.05849013e-01f, -5.05872607e-01f, -5.13559222e-01f, -2.82273650e-01f, -9.53732967e-01f, 7.19438195e-01f, -3.48656565e-01f, 1.21056005e-01f, -6.27021849e-01f, 6.20013714e-01f,
  -2.23927632e-01f, 5.39613485e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.70010799e-01f, -1.35444671e-01f, -1.45510331e-01f, -1.35532632e-01f, 6.17013201e-02f, 2.97671050e-01f, 5.22566438e-02f, -3.23431641e-02f, -7.32352631e-03f, -3.06405187e-01f,
  3.57453048e-01f, 3.13636065e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    