/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.31761204e-02f, -4.54707235e-01f, -1.99150369e-01f, -1.80823043e-01f, -2.55883187e-01f, -1.64768636e-01f, 2.40103677e-01f, -2.33120441e-01f, -3.40440303e-01f, 2.36963183e-01f,
  1.17435209e-01f, -5.74082769e-02f, 1.10098775e-02f, -1.15439177e-01f, 3.27628762e-01f, -5.52483164e-02f, 7.93341361e-03f, -4.43813168e-02f, -2.28588536e-01f, -3.59105021e-02f,
  -8.41258839e-02f, 7.32136443e-02f, 1.47335932e-01f, -1.66683733e-01f, -2.01896220e-01f, -1.59919679e-01f, 2.97064930e-01f, 6.85176998e-02f, 1.15584180e-01f, 1.80845894e-02f,
  1.30285665e-01f, -2.88883299e-01f, -4.22345214e-02f, -1.17965706e-01f, -4.29506078e-02f, -2.03506579e-03f, 6.95739593e-03f, 1.25165552e-01f, -7.94185139e-03f, -4.24768925e-02f,
  -2.09368262e-02f, -3.50489654e-02f, 5.70795173e-03f, 1.50064081e-02f, -1.32506728e-01f, -1.36853799e-01f, -8.26747045e-02f, -1.43242404e-01f, -9.53179374e-02f, -6.72613904e-02f,
  -1.75084006e-02f, -1.17452323e-01f, -7.80429132e-03f, -1.71955787e-02f, -8.37459788e-02f, -1.77390128e-01f, 2.17930656e-02f, -7.85930976e-02f, -1.44810146e-02f, -1.13214746e-01f,
  -3.60370837e-02f, -1.44661203e-01f, -1.54345389e-03f, -5.51307714e-03f, 1.19331926e-02f, 2.02352181e-02f, 5.97751290e-02f, 1.52128935e-01f, 5.47426380e-03f, 3.34785059e-02f,
  4.67064828e-02f, -1.89818174e-03f, -3.61900926e-02f, -9.44005921e-02f, 2.88373157e-02f, 4.81893122e-03f, 1.08223490e-01f, -6.25899434e-02f, -1.26976157e-02f, 7.73624405e-02f,
  5.57234772e-02f, 6.36522695e-02f, 2.19558477e-02f, 4.98081818e-02f, -3.46617810e-02f, -4.63899262e-02f, -6.78442568e-02f, 9.68868099e-03f, 1.58793051e-02f, 1.27775818e-01f,
  -9.09821391e-02f, -3.54451574e-02f, 4.46283184e-02f, 6.42362162e-02f, 9.50686187e-02f, 8.87422450e-03f, 2.39797719e-02f, -6.95384815e-02f, -5.62011376e-02f, -1.99953783e-02f,
  -4.07479294e-02f, 8.42207596e-02f, -1.32940575e-01f, 2.24815658e-03f, 1.53831214e-01f, 2.03164332e-02f, 8.85705352e-02f, 3.80652323e-02f, 6.71756193e-02f, 8.81551579e-02f,
  -5.56411780e-02f, -3.34362648e-02f, 6.53544962e-02f, -6.76432624e-02f, 4.54737693e-02f, 6.00501932e-02f, -9.96467695e-02f, 2.51119789e-02f, 4.19166163e-02f, 6.22821376e-02f,
  3.15698713e-01f, -1.90742329e-01f, -5.71570098e-02f, 7.84042552e-02f, 2.13729307e-01f, 2.96605885e-01f, -1.25262052e-01f, 1.87129393e-01f, 1.09847248e-01f, -1.91172823e-01f,
  1.66506693e-01f, -1.20029472e-01f, -3.09249796e-02f, 8.53940025e-02f, 2.24146783e-01f, -1.21532053e-01f, 1.04213722e-01f, -1.01657175e-01f, 2.19508465e-02f, 6.46304414e-02f,
  1.10842973e-01f, 2.59709358e-01f, 1.50996462e-01f, 2.91044898e-02f, 4.08345722e-02f, -1.06952146e-04f, 1.08087976e-02f, 4.37440164e-02f, -4.30427417e-02f, 3.80633287e-02f,
  8.10042322e-02f, 6.26034439e-02f, -1.98241454e-02f, -1.61662742e-01f, 5.47981113e-02f, -1.04437798e-01f, -6.62615523e-02f, -1.07802548e-01f, 1.42100006e-02f, -4.08900753e-02f,
  -1.17270648e-01f, 5.77114783e-02f, -2.38143969e-02f, -7.77435750e-02f, 1.10151209e-01f, 1.04498163e-01f, 1.19427688e-01f, 4.38744165e-02f, 1.65649280e-02f, 5.67893796e-02f,
  5.64247146e-02f, -2.64399182e-02f, 8.41887742e-02f, -1.88359261e-01f, 5.69920763e-02f, 3.51003483e-02f, -7.35976100e-02f, -1.61740944e-01f, 3.22246738e-02f, 2.10030768e-02f,
  -7.85805006e-03f, -1.22920752e-01f, 2.22883727e-02f, 1.14753991e-02f, 3.36708017e-02f, 6.42685220e-02f, 2.31315829e-02f, 5.30205341e-03f, -4.09713127e-02f, -1.50326313e-02f,
  8.68145674e-02f, 2.17114668e-02f, -4.07423042e-02f, 3.17864008e-02f, 3.58841456e-02f, 4.02721912e-02f, -4.27547246e-02f, -3.36555541e-02f, 5.79297207e-02f, 9.12821665e-02f,
  -3.20436135e-02f, 2.52503552e-03f, -3.16512436e-02f, -6.09760843e-02f, 1.61591638e-02f, -4.89535071e-02f, 8.30751285e-03f, -5.61729394e-05f, -7.84653611e-03f, 6.51751086e-02f,
  -2.79984362e-02f, -3.14357907e-01f, -4.94964756e-02f, -4.31904718e-02f, -9.57938209e-02f, 4.00039777e-02f, -7.75999427e-02f, 1.27175013e-02f, 5.79925394e-03f, 1.68053702e-01f,
  -3.97607610e-02f, -6.21691197e-02f, -1.25990696e-02f, 3.06844898e-02f, -9.99959633e-02f, -2.54653171e-02f, -1.33540571e-01f, -9.17678103e-02f, -1.05760917e-01f, -4.10018116e-03f,
  -4.85936664e-02f, 1.86113548e-02f, -2.05953862e-03f, 1.62150130e-01f, -3.10650002e-02f, -3.32251526e-02f, 1.11107968e-01f, -2.42301580e-02f, -1.64555367e-02f, -6.54370934e-02f,
  -2.58426927e-02f, -3.57736647e-02f, 3.20800632e-01f, -3.37399170e-02f, -2.40999117e-01f, 3.59601557e-01f, 2.42333189e-01f, 5.88275632e-03f, 5.40929213e-02f, -1.12312630e-01f,
  -1.04314558e-01f, -7.92245865e-02f, -2.28030667e-01f, 6.60154074e-02f, 1.36697397e-01f, 5.39380051e-02f, 2.77243257e-01f, 3.86909172e-02f, -3.04810447e-03f, -1.13820106e-01f,
  2.13164330e-01f, -8.06928724e-02f, 2.31792137e-01f, 3.54669504e-02f, 1.01210400e-01f, 1.19140148e-01f, -2.60062009e-01f, -1.04450537e-02f, 1.34111792e-02f, -9.18046981e-02f,
  1.60138905e-01f, -8.06968361e-02f, -6.02128077e-03f, 1.05957270e-01f, 1.55455992e-02f, -2.10452434e-02f, -2.42210086e-02f, -6.09918237e-02f, 3.35512236e-02f, -1.01919342e-02f,
  1.09062169e-03f, -2.22668666e-02f, -1.19883809e-02f, -8.50953721e-03f, 2.97213979e-02f, -6.89068884e-02f, 3.96613665e-02f, 1.50764018e-01f, 7.64172226e-02f, 3.88026796e-02f,
  4.89916578e-02f, 1.28680572e-01f, 5.27404733e-02f, 4.34682891e-02f, 4.60814461e-02f, 4.97950427e-02f, 5.91470860e-02f, 5.86794801e-02f, -8.65791645e-03f, 1.43100535e-02f,
  -1.58442557e-01f, 4.58252616e-02f, 9.40520242e-02f, -2.43320633e-02f, 1.59175287e-03f, -2.78511792e-02f, 6.27810881e-02f, -4.88925166e-02f, -4.56745358e-04f, -7.36458376e-02f,
  -2.62064189e-02f, 1.67541876e-02f, -8.63482729e-02f, 1.55372694e-02f, -1.96512844e-02f, -2.57906653e-02f, 2.47808956e-02f, -1.29403502e-01f, 7.63675794e-02f, 5.12359291e-02f,
  -4.19598594e-02f, 2.06283256e-02f, 1.81998983e-02f, 1.53417308e-02f, -3.86656262e-02f, 7.03331595e-03f, 3.26410681e-02f, 5.89054190e-02f, -5.48311472e-02f, -5.59475310e-02f,
  -1.46635234e-01f, -2.01834321e-01f, 6.40189126e-02f, -3.11919041e-02f, -1.66025329e-02f, -9.96891991e-04f, 8.55993256e-02f, 4.54930700e-02f, -3.79771665e-02f, -2.07839552e-02f,
  -2.61105374e-02f, 4.13650870e-02f, 1.24945492e-02f, -5.54568172e-02f, 8.76963586e-02f, 7.13369176e-02f, -8.44601765e-02f, -7.62148350e-02f, 3.37529257e-02f, -3.69834378e-02f,
  -8.53017494e-02f, -7.95631409e-02f, 3.47607024e-02f, -1.67514812e-02f, -4.43433486e-02f, 4.62359451e-02f, -3.36242430e-02f, 2.67639663e-02f, 5.89159466e-02f, 9.53399613e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.67850673e-02f, 2.33137757e-01f, 2.01321289e-01f, 3.15270424e-01f, 1.63114533e-01f, -4.07057732e-01f, 6.10264279e-02f, 5.06715596e-01f, 5.97777724e-01f, 1.41795063e-02f,
  7.06149638e-02f, -2.03252733e-01f, 3.55134964e-01f, -2.75747180e-01f, -2.48810202e-01f, -1.06362663e-01f, -3.92672151e-01f, -2.46034682e-01f, 7.05940798e-02f, 3.43795747e-01f,
  8.25581476e-02f, 8.51228163e-02f, -2.43841559e-01f, 3.23330730e-01f, 9.50152501e-02f, 1.65435955e-01f, -4.12166975e-02f, 2.25549132e-01f, -5.53982139e-01f, -2.00451449e-01f,
  -2.71686584e-01f, 2.84347832e-01f, -5.90329394e-02f, 2.56541055e-02f, 5.36659621e-02f, -1.11419603e-01f, -1.53929517e-01f, 5.74115179e-02f, -4.98990305e-02f, -5.14528481e-03f,
  1.58415064e-02f, -8.75960365e-02f, -2.28924770e-02f, -1.07218608e-01f, 1.78763807e-01f, -1.29049132e-02f, 1.09163178e-02f, -6.22474216e-02f, -2.95424666e-02f, -1.03060231e-01f,
  -6.03246205e-02f, 2.63983831e-02f, 1.28901511e-01f, -1.67366773e-01f, 4.72081418e-04f, 7.09710196e-02f, -1.19443811e-01f, -1.89878672e-01f, -1.23758145e-01f, -5.86727150e-02f,
  9.11749527e-02f, 8.20326339e-03f, -1.53503686e-01f, 1.44530550e-01f, -2.16428101e-01f, -3.27563006e-03f, 2.04514638e-02f, -2.04523951e-02f, 1.14743195e-01f, -9.16429162e-02f,
  2.16655377e-02f, -3.49609219e-02f, 4.11211252e-02f, -5.19488752e-02f, 1.39248997e-01f, 4.99748364e-02f, -9.00540352e-02f, -1.20704167e-01f, 5.40500209e-02f, 2.96307579e-02f,
  4.75336015e-02f, -9.22756493e-02f, 9.16914865e-02f, -4.17375416e-02f, -1.89177953e-02f, 1.11961607e-02f, 7.41705298e-02f, -4.06014957e-02f, 9.74029824e-02f, 4.39353958e-02f,
  1.45887867e-01f, 5.40151775e-01f, 1.67672396e-01f, -8.81720707e-02f, 7.30136037e-02f, -3.57361175e-02f, 6.80928379e-02f, -8.08918625e-02f, 2.25354403e-01f, -3.19942497e-02f,
  5.19337952e-02f, -1.36308819e-02f, -1.09991781e-01f, -1.40805706e-01f, 6.18704222e-02f, 6.82423860e-02f, 3.03672138e-03f, 1.32152975e-01f, 1.83179945e-01f, -1.26294149e-02f,
  -9.81020704e-02f, 9.96130854e-02f, 1.48642018e-01f, 1.05218507e-01f, -1.02403365e-01f, -9.97170527e-03f, -1.38985217e-02f, 6.55210167e-02f, 1.98250581e-02f, -4.24678624e-02f,
  8.55341554e-02f, 6.28336489e-01f, -4.99850869e-01f, -3.91825177e-02f, -4.60394561e-01f, 8.55266631e-01f, 8.28845203e-01f, 5.87797947e-02f, 8.23531374e-02f, 9.14259732e-01f,
  2.51146793e-01f, 3.36686149e-02f, 1.77019060e-01f, 8.56302619e-01f, -1.66483261e-02f, 6.17202044e-01f, 6.07117474e-01f, 5.08161068e-01f, 2.37510689e-02f, 9.34766978e-02f,
  -8.62680674e-02f, 5.41752636e-01f, -7.09873661e-02f, -1.27328724e-01f, 1.16827480e-01f, -2.90267557e-01f, -2.79579014e-01f, -2.49350324e-01f, 1.05366640e-01f, -4.90670800e-02f,
  1.21273354e-01f, -1.11787349e-01f, -1.65241033e-01f, 1.23085789e-02f, -1.36721656e-01f, -1.29739821e-01f, -2.41383836e-02f, -1.24015629e-01f, -2.38909900e-01f, -1.56401619e-02f,
  2.63126437e-02f, -1.13612130e-01f, 1.36842936e-01f, -1.67315736e-01f, -7.92705044e-02f, -8.36806074e-02f, -1.43982157e-01f, -1.82083081e-02f, 1.61803197e-02f, -1.18624046e-02f,
  -1.39965162e-01f, 6.10646009e-02f, -3.18134613e-02f, 1.98919609e-01f, -8.45233127e-02f, 1.89341456e-02f, 1.22143552e-01f, -1.12103917e-01f, 1.86574701e-02f, -2.84540448e-02f,
  6.66902438e-02f, 2.31240522e-02f, 2.24079825e-02f, 5.27781714e-03f, -8.04701447e-02f, 2.77132448e-02f, -1.43496331e-03f, 4.56150882e-02f, -6.36164248e-02f, 7.93096945e-02f,
  -8.17650482e-02f, -2.58159395e-02f, -1.68266613e-02f, 6.51333183e-02f, 1.33323789e-01f, 1.09578617e-01f, -1.06248073e-01f, 2.38506775e-02f, 1.08005628e-01f, 8.87466893e-02f,
  4.73921793e-03f, -4.65104617e-02f, 2.82111578e-02f, -2.73158941e-02f, -2.98156254e-02f, -4.22986411e-02f, 1.39429316e-01f, 7.39124492e-02f, -1.41845584e-01f, -5.69673292e-02f,
  2.35851064e-01f, 4.89427179e-01f, 5.47238924e-02f, -5.39554246e-02f, 1.77285317e-02f, -7.86267668e-02f, 6.96334615e-02f, 1.62049428e-01f, 1.74057767e-01f, 1.41079381e-01f,
  6.65917546e-02f, 4.38728370e-03f, -6.34433255e-02f, -1.36372179e-01f, -9.58271399e-02f, 1.74994171e-01f, 1.34408861e-01f, 2.30930261e-02f, 2.84806117e-02f, -2.46533528e-02f,
  -4.81626317e-02f, 5.70008084e-02f, 6.66358098e-02f, -4.20630910e-02f, -3.75367142e-02f, 1.58441827e-01f, -1.17537044e-01f, 1.65669760e-03f, -9.22269076e-02f, 7.79292881e-02f,
  6.30694687e-01f, 4.13117617e-01f, -1.31433174e-01f, 2.45452151e-01f, -3.76970887e-01f, -3.90599906e-01f, -3.45907092e-01f, 6.85151592e-02f, -2.00826656e-02f, -1.12671955e-02f,
  -4.99332808e-02f, -4.99964692e-02f, 2.27532327e-01f, -3.20007831e-01f, 5.54046988e-01f, 2.22016886e-01f, -2.67610531e-02f, -3.23158205e-01f, 4.05774005e-02f, 2.37628102e-01f,
  9.97107103e-02f, 3.72342207e-02f, -1.29031977e-02f, 1.03571847e-01f, -2.59525776e-01f, 6.40944019e-02f, 2.03491062e-01f, -1.13675714e-01f, -9.40762386e-02f, -2.98232496e-01f,
  -1.24312595e-01f, 1.16500393e-01f, -1.19622074e-01f, -1.38536254e-02f, 1.77132487e-02f, -8.61726627e-02f, -1.68048352e-01f, -2.26316050e-01f, -8.38447362e-03f, -7.24589080e-02f,
  5.45579270e-02f, 1.02933899e-01f, -1.87089995e-01f, -6.60612211e-02f, -2.25817889e-01f, -5.75711466e-02f, -7.78530762e-02f, -1.96369104e-02f, -2.50579845e-02f, 1.02958299e-01f,
  1.56170249e-01f, -1.45368695e-01f, -1.04733169e-01f, -1.16375342e-01f, 8.50824639e-02f, -4.11339402e-02f, -8.92058108e-03f, -2.28754520e-01f, -5.60474209e-03f, 3.52955125e-02f,
  -1.15964696e-01f, 6.78300261e-02f, 4.72716354e-02f, 5.84779754e-02f, 3.71314257e-01f, -2.07867511e-02f, 9.74607542e-02f, -1.53829545e-01f, 3.97477187e-02f, -6.03729673e-02f,
  -3.65735702e-02f, 5.24401339e-03f, -9.01862830e-02f, -1.09770492e-01f, 3.86389531e-02f, 6.87783882e-02f, -1.62297711e-01f, -2.59053744e-02f, -3.79158333e-02f, 9.29365456e-02f,
  -1.29623026e-01f, 1.47439182e-01f, 4.56646271e-02f, -1.25443473e-01f, -4.92388234e-02f, 4.90963571e-02f, -5.94568439e-02f, 1.64057747e-01f, -1.65091619e-01f, 1.02031477e-01f,
  2.37124801e-01f, 4.87025976e-01f, -4.22777086e-02f, -1.17055431e-01f, -3.17249186e-02f, -2.11522542e-03f, 1.86570082e-02f, -1.17769189e-01f, 1.18342735e-01f, 1.08833499e-01f,
  -2.03209117e-01f, -1.39594331e-01f, 1.75197572e-02f, 5.95761277e-02f, -1.33317085e-02f, 1.87185422e-01f, -3.91177693e-03f, 1.74876109e-01f, -5.52766994e-02f, 3.86311561e-02f,
  1.22160077e-01f, -9.79857445e-02f, -9.17475149e-02f, -5.99373020e-02f, -2.15566494e-02f, -3.02859601e-02f, 2.20920816e-01f, 1.55119309e-02f, -2.80723470e-04f, -1.90378744e-02f,
  -1.47759867e+00f, 6.77476645e-01f, 2.42331848e-01f, -6.34285271e-01f, 2.94773728e-01f, 1.05944037e-01f, -7.22171366e-02f, 1.45757258e-01f, -9.81493294e-03f, 3.72616768e-01f,
  -1.47487177e-02f, 1.07637964e-01f, 3.21149826e-01f, -6.35677483e-03f, -4.34596449e-01f, 1.54601768e-01f, -9.75855514e-02f, -1.14683434e-01f, 2.92729527e-01f, -2.95770820e-02f,
  -1.54642999e-01f, -1.38691589e-02f, -7.76375458e-02f, 5.21364331e-01f, -2.12339133e-01f, -4.94706519e-02f, -2.49851316e-01f, 4.23894495e-01f, -1.50203556e-01f, 2.53292054e-01f,
  -3.76277804e-01f, -6.52655140e-02f, -3.05746555e-01f, -1.64406255e-01f, -2.24419609e-01f, -1.00992076e-01f, -1.66056097e-01f, 3.06650158e-02f, 3.50499079e-02f, 8.49371329e-02f,
  -4.09775414e-02f, 7.98442513e-02f, 9.77883190e-02f, 1.44581005e-01f, -1.34486347e-01f, -3.10483593e-02f, 3.28005143e-02f, -5.80016188e-02f, 1.78762019e-01f, 5.88543899e-02f,
  1.25750527e-01f, -1.72723103e-02f, -1.59030840e-01f, -2.77141295e-02f, 7.25728795e-02f, -2.16905847e-02f, 5.57410298e-03f, -1.44421041e-01f, 9.68419202e-03f, -1.57798856e-01f,
  8.62706359e-03f, -3.93275283e-02f, 2.35201092e-03f, -6.42243996e-02f, 2.12952480e-01f, -1.19470999e-01f, 7.93677121e-02f, -4.02012877e-02f, -5.71984099e-03f, 5.10094278e-02f,
  1.00609139e-02f, -1.20395767e-02f, -8.50524008e-02f, -2.53682107e-01f, 2.39495486e-02f, -1.75905317e-01f, -9.56387259e-03f, -1.21804878e-01f, -5.86173013e-02f, 1.65778697e-02f,
  4.17375453e-02f, 5.78811690e-02f, 1.31963834e-01f, -2.65173558e-02f, 4.60844450e-02f, 2.98018362e-02f, -3.06089111e-02f, 4.38008904e-02f, -6.87950701e-02f, 4.92102653e-02f,
  -4.81756508e-01f, -4.34132278e-01f, 5.65788522e-02f, -5.36534972e-02f, -5.23300581e-02f, -7.29522929e-02f, -5.38754389e-02f, -7.30573907e-02f, -2.40841024e-02f, -1.52541399e-01f,
  -1.32981673e-01f, -1.07781507e-01f, -1.33313790e-01f, 1.85101256e-02f, 3.91908130e-03f, -5.33035994e-02f, -1.55808359e-01f, -4.36271764e-02f, -1.55858457e-01f, -2.69950796e-02f,
  -1.64205238e-01f, -4.22350727e-02f, 1.44921038e-02f, 1.13362912e-02f, -1.43379331e-01f, -1.49591133e-01f, -1.11920081e-01f, 8.55548605e-02f, -3.29985581e-02f, 7.13106319e-02f,
  -1.96517661e-01f, -2.87484199e-01f, 2.90551662e-01f, -5.26629329e-01f, 2.31799662e-01f, -2.67785966e-01f, -5.29578812e-02f, -3.81409496e-01f, -4.05636102e-01f, -7.11163700e-01f,
  -3.21254045e-01f, 2.00164795e-01f, 5.03669977e-01f, -8.01262677e-01f, 8.70772839e-01f, 3.81206125e-01f, -6.57223880e-01f, -3.01795036e-01f, 1.00942396e-01f, -5.32210946e-01f,
  -1.57010347e-01f, -6.64773166e-01f, 3.00329387e-01f, -4.96595204e-01f, -3.14509779e-01f, -2.53192782e-01f, 1.23968929e-01f, 3.22571188e-01f, -5.63382387e-01f, 2.50994027e-01f,
  1.63231287e-02f, -4.71153140e-01f, -5.79398498e-02f, -1.16246536e-01f, -8.76194611e-02f, 4.87147532e-02f, 1.24454446e-01f, 2.65650362e-01f, 1.81325525e-02f, -7.06227822e-03f,
  8.99119675e-02f, -1.90345645e-02f, -2.89979964e-01f, 8.35381225e-02f, -8.30089748e-02f, -1.16471410e-01f, 5.97277842e-02f, -3.55220027e-02f, -7.06698298e-02f, 1.20200574e-01f,
  1.02821745e-01f, 1.66533545e-01f, -7.70672560e-02f, -1.45864813e-02f, 1.15287207e-01f, -1.01729654e-01f, 4.37451992e-03f, 1.75744921e-01f, 3.57109518e-03f, -2.80459344e-01f,
  -3.17131132e-02f, 7.63966218e-02f, -3.89364474e-02f, 5.68669960e-02f, -1.42489746e-01f, -1.82412267e-02f, -1.07697994e-01f, 4.35906425e-02f, 3.52774374e-03f, -5.49695492e-02f,
  -1.30577847e-01f, -9.44041610e-02f, -9.33712944e-02f, -8.69680271e-02f, -4.32359129e-02f, -2.80044675e-02f, 3.36370021e-02f, -8.86125490e-02f, -1.86136719e-02f, -2.67948397e-02f,
  -1.38404608e-01f, -2.17682570e-02f, 2.93745776e-04f, -7.99407214e-02f, -6.13122210e-02f, 1.06907956e-01f, -9.46666524e-02f, 7.39642745e-03f, 9.68112051e-02f, 1.25986949e-01f,
  -3.13227385e-01f, -6.74204111e-01f, -2.51313988e-02f, -1.49553284e-01f, -5.94772138e-02f, -7.93314502e-02f, 1.46347200e-02f, -9.10169408e-02f, -5.25697274e-03f, -1.43147692e-01f,
  3.74977812e-02f, -4.14409786e-02f, 2.04979721e-02f, -5.03440239e-02f, -7.91753381e-02f, 5.21230139e-02f, -1.12524904e-01f, 3.09511330e-02f, -5.02871685e-02f, -1.58807755e-01f,
  -1.65057048e-01f, 6.85303137e-02f, 8.72273296e-02f, -1.42635122e-01f, -1.55500233e-01f, 1.22741923e-01f, -9.23847929e-02f, 1.04607575e-01f, 2.36189142e-02f, -7.05788955e-02f,
  7.53518343e-01f, 3.40716749e-01f, 5.04690111e-01f, 5.35676241e-01f, 2.05496084e-02f, -2.98816830e-01f, -2.55525827e-01f, 3.37277681e-01f, 3.25223655e-01f, -5.79599664e-02f,
  -1.70779169e-01f, 4.21686918e-01f, -4.90443438e-01f, 3.40835720e-01f, -6.20895326e-01f, -5.84827125e-01f, -1.52407389e-03f, 1.17202573e-01f, 1.01571523e-01f, 1.66524947e-01f,
  1.16429314e-01f, -3.98625493e-01f, -1.75282925e-01f, -3.19371134e-01f, 4.09985453e-01f, 3.94545227e-01f, -4.93548363e-01f, -2.05813497e-01f, 6.36244640e-02f, -1.26155794e-01f,
  7.93498605e-02f, 3.07643592e-01f, 1.32228494e-01f, -9.37509462e-02f, -4.56133373e-02f, -1.46259680e-01f, -1.21250134e-02f, -7.69831911e-02f, 2.80793458e-02f, 1.80561543e-02f,
  2.59677470e-02f, -1.93613376e-02f, 1.78289011e-01f, -3.41698490e-02f, -8.17636698e-02f, 8.56160000e-02f, 2.26001263e-01f, 1.20682307e-01f, 6.82919845e-02f, 2.01994747e-01f,
  8.54088366e-02f, 1.87892929e-01f, 6.47858530e-03f, -1.66923389e-01f, 7.04588965e-02f, 1.56626821e-01f, 6.22050278e-02f, 1.44116461e-01f, 5.28857931e-02f, 8.29988047e-02f,
  5.40732443e-02f, -1.61708459e-01f, -1.32288679e-01f, 5.57682477e-02f, -4.92959879e-02f, 4.15344425e-02f, -8.27786848e-02f, 2.14282535e-02f, -2.66289786e-02f, 1.24579944e-01f,
  -3.38437818e-02f, 7.89694339e-02f, 8.19533840e-02f, -7.49525335e-03f, -7.29914531e-02f, 4.34110425e-02f, 1.15202945e-02f, -2.87578385e-02f, 1.91434007e-02f, -3.30107659e-03f,
  -1.40004838e-02f, -6.22272976e-02f, -1.10398263e-01f, 7.09882304e-02f, -1.20840706e-01f, 5.40565215e-02f, 1.71687696e-02f, 9.04431492e-02f, 1.37811080e-01f, -1.21326111e-01f,
  -8.05752516e-01f, -6.33314788e-01f, -1.22206450e-01f, 1.69385429e-02f, -8.58735517e-02f, 1.05038524e-01f, 8.04797933e-02f, 9.08699483e-02f, -1.66398540e-01f, -1.03588536e-01f,
  2.36680154e-02f, 1.11817953e-03f, -7.83320293e-02f, 3.30906175e-02f, -5.53509668e-02f, -1.16862185e-01f, -1.46154955e-01f, -1.35291994e-01f, -1.17929183e-01f, -1.96251627e-02f,
  3.31321619e-02f, -1.27926052e-01f, 6.59697801e-02f, 9.17074531e-02f, 8.63565132e-02f, -3.87339480e-02f, 9.26953740e-03f, 3.82213891e-02f, -1.00670643e-01f, -6.47782534e-02f,
  5.60651779e-01f, -4.49659526e-01f, 2.36584973e-02f, 6.10664606e-01f, 7.16021240e-01f, 7.25098729e-01f, 7.86027491e-01f, 2.30971947e-01f, 6.56733871e-01f, -7.16501534e-01f,
  -3.55565101e-01f, -5.85520640e-02f, -2.26124153e-01f, 1.31779730e-01f, 8.68834138e-01f, -5.88291995e-02f, 5.87879717e-01f, 2.49524385e-01f, 9.79023650e-02f, 1.35336712e-01f,
  9.13325176e-02f, 1.46525472e-01f, -4.08652276e-01f, -5.83576858e-01f, 6.07561544e-02f, -1.60833567e-01f, -3.49858195e-01f, 8.34685192e-02f, -3.81453782e-01f, 2.58004963e-01f,
  1.28820524e-01f, -4.06435318e-02f, -1.33410990e-01f, -9.73401889e-02f, -8.42899680e-02f, -1.09234571e-01f, 1.38998494e-01f, 1.69313967e-01f, 7.82653913e-02f, -5.40206060e-02f,
  2.49355659e-03f, -1.45481415e-02f, 1.38538349e-02f, 1.77622020e-01f, 2.29811445e-01f, -1.33598432e-01f, -2.12410539e-02f, -1.89154804e-01f, -5.52653186e-02f, -4.21299897e-02f,
  -1.12168647e-01f, -1.68472320e-01f, -1.97278187e-02f, -4.14924733e-02f, -6.82381541e-02f, -7.42315352e-02f, 2.45722812e-02f, -3.53544275e-03f, -1.86628606e-02f, 1.39443859e-01f,
  -7.79853389e-02f, 2.13319600e-01f, -1.20471314e-01f, -7.79673681e-02f, -9.17782485e-02f, -4.50884327e-02f, -7.46166930e-02f, -2.85308380e-02f, 1.64882578e-02f, 4.77909558e-02f,
  9.93561372e-02f, -3.71404625e-02f, 1.20782778e-01f, -7.64293447e-02f, 5.22475280e-02f, -8.13718811e-02f, -2.28734724e-02f, -7.59842023e-02f, -1.87447052e-02f, -3.61622088e-02f,
  3.49116065e-02f, 2.13692591e-01f, -5.55738658e-02f, -8.44232142e-02f, -1.20453313e-02f, 1.54708913e-02f, -1.61905870e-01f, -3.18787657e-02f, -1.31871730e-01f, 4.05216962e-02f,
  2.25905687e-01f, 5.39226159e-02f, -2.13596094e-02f, 4.03247625e-02f, -1.81761950e-01f, -1.86733052e-01f, 8.55538622e-02f, 1.35031417e-01f, 2.12485958e-02f, 1.25296209e-02f,
  -1.47629371e-05f, 2.05799453e-02f, 3.85776162e-02f, -6.24736995e-02f, 3.71407159e-02f, -9.63514969e-02f, -5.71159497e-02f, 7.64756873e-02f, 1.35019556e-01f, -1.84332013e-01f,
  -2.84664124e-01f, 2.18207791e-01f, 1.41951159e-01f, -3.33162732e-02f, -5.09350076e-02f, 2.79019563e-03f, -4.12183069e-03f, 6.95724338e-02f, -5.06146252e-02f, 2.89455280e-02f,
  1.77069783e-01f, 2.82609969e-01f, 3.84773910e-01f, 5.55978656e-01f, -4.10953313e-01f, -6.63440645e-01f, -4.85567868e-01f, 2.09601060e-01f, -1.84152663e-01f, -3.38999406e-02f,
  -1.74210504e-01f, 5.57156622e-01f, -1.86311945e-01f, 1.08010821e-01f, 1.83805197e-01f, -3.84382576e-01f, 3.50176007e-01f, 2.98706032e-02f, -7.07840100e-02f, 3.24185759e-01f,
  2.60534048e-01f, 6.46780655e-02f, 3.75862956e-01f, 1.74200207e-01f, -1.08007237e-01f, 3.78956050e-01f, 3.96966696e-01f, -1.12081200e-01f, 6.92189217e-01f, -5.86501360e-02f,
  -1.23037651e-01f, -6.12122193e-02f, 1.64154813e-01f, -2.52215937e-02f, -9.90036130e-02f, -9.00692269e-02f, -3.20077389e-02f, -1.63602993e-01f, -3.85484248e-02f, -1.13573307e-02f,
  -2.77173258e-02f, 5.85794970e-02f, 8.24644640e-02f, -1.34441242e-01f, -9.77480039e-02f, 9.41452533e-02f, -3.17452662e-02f, -1.99485328e-02f, 7.54331872e-02f, -1.34242564e-01f,
  1.61549687e-01f, 4.17838693e-02f, 2.61768550e-02f, 2.02394411e-01f, 1.27495423e-01f, 2.54178643e-02f, -5.41971512e-02f, 1.68654501e-01f, -3.49885784e-02f, 3.39175090e-02f,
  -6.15140647e-02f, -1.01671651e-01f, 3.77865322e-02f, -1.21506490e-01f, -7.17138723e-02f, 7.24555785e-03f, -5.83012961e-02f, -5.99157438e-02f, -1.09415784e-01f, -4.33856212e-02f,
  -1.09074108e-01f, 2.51450483e-02f, -1.44047245e-01f, 5.95023856e-04f, -5.87258190e-02f, 8.70884024e-03f, 8.10618177e-02f, -6.04914352e-02f, -7.64606595e-02f, 3.85110341e-02f,
  -7.13136569e-02f, 6.79234322e-03f, 4.14021611e-02f, -8.74637589e-02f, -6.34905994e-02f, -4.33719791e-02f, 5.50511107e-02f, 9.43562984e-02f, -3.90382633e-02f, 1.39435166e-02f,
  1.05433546e-01f, 3.12366158e-01f, 1.98671650e-02f, -1.09789660e-02f, -7.05860136e-03f, -5.68861701e-02f, -1.46437258e-01f, 2.01910853e-01f, 2.00427994e-01f, -1.84454963e-01f,
  2.57303357e-01f, 5.03463559e-02f, -1.10399894e-01f, 6.63897917e-02f, 4.43986654e-02f, 5.40952161e-02f, 1.92714617e-01f, 1.01570651e-01f, 1.89080566e-01f, 1.24124460e-01f,
  -1.33896060e-02f, -1.93258390e-01f, 4.32805456e-02f, 2.01680698e-02f, 6.86988980e-02f, 6.21439330e-02f, -1.65116973e-02f, 1.47672191e-01f, -2.07113270e-02f, -1.46568520e-02f,
  -3.60219896e-01f, -4.74386290e-02f, -4.33952719e-01f, -2.88593441e-01f, 3.50092679e-01f, -1.70708835e-01f, -1.52291626e-01f, 1.50939912e-01f, -2.79684991e-01f, 2.96735406e-01f,
  1.48189321e-01f, -3.36724788e-01f, -4.29580174e-02f, -5.94997346e-01f, -7.39651799e-01f, -6.13561451e-01f, -1.61604613e-01f, -1.45773783e-01f, -1.49249315e-01f, 2.13851154e-01f,
  -1.37190893e-01f, -4.92294393e-02f, -4.88997906e-01f, 3.01724821e-01f, 2.76452661e-01f, 1.09417208e-01f, 3.75519603e-01f, 2.45780811e-01f, 1.47808880e-01f, -1.37660801e-01f,
  -1.01861116e-02f, -1.02254234e-01f, -1.80331111e-01f, -2.14553863e-01f, 1.34097427e-01f, 2.02540070e-01f, 8.10071230e-02f, -1.42602071e-01f, -8.82781893e-02f, 8.85230824e-02f,
  3.35753821e-02f, -1.65195465e-02f, -1.66979134e-01f, -8.14536065e-02f, -3.68718542e-02f, -4.90414388e-02f, -1.14528589e-01f, 7.43191093e-02f, 5.16384542e-02f, -9.92432609e-02f,
  -1.15786284e-01f, -4.27431054e-02f, 1.39473602e-01f, -5.54643152e-03f, -6.71737939e-02f, -6.83436096e-02f, -2.18901597e-02f, 5.15580885e-02f, 1.10842548e-01f, -1.47733122e-01f,
  -4.81250696e-02f, 9.55790728e-02f, -8.50183070e-02f, -4.12778975e-03f, -2.85303295e-02f, -8.13026971e-04f, 8.95931385e-03f, -4.93788458e-02f, -3.64796594e-02f, 8.44720975e-02f,
  1.98088825e-01f, 2.81413365e-03f, 3.10410131e-02f, 2.95465495e-02f, 1.17058434e-01f, -7.42943659e-02f, -1.64662139e-03f, -2.94226576e-02f, 1.14668883e-01f, -1.09231822e-01f,
  -2.33403537e-02f, 6.61635622e-02f, 2.33387221e-02f, 1.81240007e-01f, 4.01358455e-02f, 1.41411275e-01f, 7.08330050e-02f, -4.09226939e-02f, 7.41678895e-03f, 1.36564001e-01f,
  3.93899769e-01f, 2.67605543e-01f, -6.73482940e-02f, -9.62678194e-02f, -1.51359951e-02f, -1.06945500e-01f, -1.38903737e-01f, -1.13409847e-01f, 7.18532205e-02f, -5.80857880e-02f,
  1.68515265e-01f, 1.04028061e-01f, 4.46352541e-01f, 3.14217024e-02f, 7.28243813e-02f, 1.16046164e-02f, 1.53501481e-01f, 9.37579647e-02f, 1.95953339e-01f, 9.01859701e-02f,
  2.13855177e-01f, 2.22480252e-01f, -1.24980472e-01f, 1.19894020e-01f, 5.79024367e-02f, 2.26347923e-01f, 1.71545848e-01f, -3.20867524e-02f, 1.49655104e-01f, 5.82169034e-02f,
  5.51502287e-01f, -3.18299979e-01f, -6.12090051e-01f, 2.37270102e-01f, 5.07289052e-01f, -6.53782189e-02f, -3.85861129e-01f, 2.60544389e-01f, -4.08841312e-01f, -2.46029750e-01f,
  2.19345316e-01f, -1.13412281e-02f, -4.79973823e-01f, 5.81080019e-01f, 5.85651696e-01f, -4.74839628e-01f, 4.88088876e-01f, 1.55589104e-01f, -1.09049536e-01f, 1.77319735e-01f,
  2.61019796e-01f, 9.41974521e-01f, -7.64544234e-02f, 4.93325055e-01f, 5.53758025e-01f, -1.81933418e-01f, 4.50030893e-01f, -2.45025724e-01f, 5.80313683e-01f, 3.57175678e-01f,
  -3.42123397e-02f, 1.47425309e-01f, -1.90658905e-02f, -1.05039999e-01f, 1.20705590e-01f, 4.56631072e-02f, -8.75099748e-02f, 1.98216662e-02f, -5.56949563e-02f, -2.24066898e-02f,
  -3.21294777e-02f, 1.36357978e-01f, 7.91732743e-02f, 1.14146203e-01f, 1.24960996e-01f, 2.28268560e-02f, 1.45048583e-02f, -9.41299200e-02f, -9.86946523e-02f, 2.60325824e-03f,
  -2.91203171e-01f, 5.31996377e-02f, 4.12553884e-02f, -7.49436840e-02f, -6.44102544e-02f, 8.81896820e-03f, -6.80844113e-02f, -1.37388065e-01f, 1.83351636e-02f, 6.68535829e-02f,
  1.47422165e-01f, 1.74741261e-02f, 1.55044449e-02f, 8.18413198e-02f, 1.67789813e-02f, -6.11823378e-03f, 6.57053590e-02f, 2.00790595e-02f, -3.06936745e-02f, 3.62841524e-02f,
  -2.58145239e-02f, 2.27311756e-02f, 2.75337324e-02f, -1.69156507e-01f, 9.90742221e-02f, -9.04313996e-02f, -4.10787053e-02f, -1.47644086e-02f, -7.67613500e-02f, 3.89574729e-02f,
  -3.86044122e-02f, -2.00249366e-02f, 1.52718443e-02f, -3.98307480e-02f, 1.06782280e-02f, -3.16282995e-02f, 2.13212714e-01f, -3.28110009e-02f, -1.37317106e-01f, -4.20490205e-02f,
  4.62890416e-02f, -1.09969191e-02f, -1.06599912e-01f, 2.41336618e-02f, -1.51087001e-01f, 1.39737859e-01f, 1.62597152e-03f, 9.22352523e-02f, 4.93469350e-02f, -2.94335224e-02f,
  1.15907647e-01f, -1.16353817e-01f, 3.58056389e-02f, 2.27378495e-03f, 6.22324720e-02f, -4.77260444e-03f, -1.05994493e-01f, 8.26437101e-02f, 2.33503550e-01f, 1.02996729e-01f,
  5.19542675e-03f, -2.55858824e-02f, -2.78889257e-02f, -4.10049688e-03f, 1.05273351e-01f, 8.56899247e-02f, -3.05845141e-02f, 1.85786821e-02f, 7.79917911e-02f, -9.16847438e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  9.61196363e-01f, 5.43545842e-01f, 3.72565389e-01f, 4.08814669e-01f, 7.13238776e-01f, 5.11655569e-01f, 1.15847349e+00f, 2.85033494e-01f, -1.03027925e-01f, 2.97117263e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -9.05810967e-02f, 4.19929922e-01f, -1.33459121e-01f, -3.34984124e-01f, -4.52723116e-01f, -5.02686679e-01f, 2.80209463e-02f, 4.11669791e-01f, -1.49890959e-01f, 1.39568850e-01f,
  -8.90249908e-02f, -3.45163107e-01f, -1.78218618e-01f, -4.31814760e-01f, 2.55338222e-01f, 7.60841221e-02f, 9.97348502e-02f, -4.12012815e-01f, 1.34527847e-01f, 3.97211283e-01f,
  4.85861033e-01f, -2.01794833e-01f, -3.10329944e-02f, -5.57285994e-02f, 4.64912772e-01f, -4.26809877e-01f, 1.16996688e-03f, -1.03824861e-01f, 3.22982907e-01f, 1.33615270e-01f,
  2.88818032e-01f, 1.66364744e-01f, -1.48795575e-01f, 1.10079490e-01f, 1.78716719e-01f, -4.12722290e-01f, -4.18994099e-01f, -5.52902460e-01f, 4.44011725e-02f, 2.20849574e-01f,
  3.73062044e-01f, -9.13780481e-02f, -3.52589101e-01f, -4.13584635e-02f, 1.47602245e-01f, 1.67736337e-01f, 4.10242677e-01f, -6.64529204e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.27658713e-01f, 8.32130909e-01f, 5.51958203e-01f, 4.92028952e-01f, 3.17746967e-01f, 1.33887303e+00f, -6.04684234e-01f, 5.09067833e-01f, -8.92306268e-01f, 3.87904257e-01f,
  7.99482465e-01f, 5.57074249e-01f, -3.82550865e-01f, -2.03554153e-01f, -5.58563530e-01f, 4.94493037e-01f, 4.58617896e-01f, 5.97413540e-01f, 2.96146244e-01f, 7.83343434e-01f,
  5.45600235e-01f, -8.11661541e-01f, -6.39287233e-01f, 6.10866070e-01f, 1.92280352e-01f, -4.31102902e-01f, 1.07527554e+00f, -3.05451334e-01f, 6.39530182e-01f, -8.88425589e-01f,
  -7.31765339e-03f, 8.93450201e-01f, 4.92589921e-01f, 8.06814060e-02f, 1.93463057e-01f, 1.12613416e+00f, -7.66926780e-02f, -9.91580635e-03f, 5.80096364e-01f, -8.55546236e-01f,
  -3.42064947e-02f, -8.82896304e-01f, 6.49879694e-01f, 7.98947513e-01f, 4.93581921e-01f, 7.85537302e-01f, 9.99760389e-01f, 1.56364083e-01f, 2.20070004e-01f, -2.32144862e-01f,
  5.71021557e-01f, -8.51836026e-01f, 2.99052417e-01f, 1.20980823e+00f, 1.55540854e-01f, -2.44746208e-01f, 3.78926933e-01f, 1.42905071e-01f, 1.84406057e-01f, 1.19939101e+00f,
  5.75362265e-01f, 1.09660588e-01f, -1.63220465e-01f, -6.96246743e-01f, 2.17323467e-01f, 9.20763075e-01f, 4.59128588e-01f, 5.37704527e-01f, -1.08733654e+00f, 2.16606632e-01f,
  5.86865306e-01f, 4.36907977e-01f, -2.68659234e-01f, 6.23275638e-01f, -2.61610951e-02f, -5.25455594e-01f, 5.00067234e-01f, 4.55071211e-01f, 7.15114892e-01f, -1.06279480e+00f,
  2.73570627e-01f, 6.24880135e-01f, 5.41400552e-01f, -1.37346804e+00f, 1.26577020e-01f, 5.65800488e-01f, 6.77312195e-01f, 1.10165048e+00f, 7.35617280e-01f, 5.51822007e-01f,
  -1.31291464e-01f, -4.41742569e-01f, 5.26923597e-01f, 3.44503410e-02f, -5.18278182e-01f, -2.67562896e-01f, -1.72376394e-01f, -7.67243430e-02f, -5.47275960e-01f, -2.95221120e-01f,
  -1.09529686e+00f, -7.21259117e-01f, 6.66262090e-01f, -4.37931657e-01f, 3.12729418e-01f, 1.10266411e+00f, 6.34581149e-01f, 1.04852235e+00f, -8.20900738e-01f, 6.55208111e-01f,
  -5.72597086e-01f, -6.12726621e-02f, 4.30699617e-01f, 9.86619443e-02f, -5.64102590e-01f, 1.11749828e-01f, -5.25103211e-01f, -1.10203969e+00f, 9.00395632e-01f, -4.09415632e-01f,
  4.07548666e-01f, 5.71185410e-01f, 5.56431890e-01f, -3.06994021e-01f, -5.26566505e-01f, 5.71489990e-01f, 4.24881577e-01f, 4.35054839e-01f, 4.28909749e-01f, -4.20537889e-01f,
  6.62427306e-01f, -4.14344907e-01f, 8.31059933e-01f, 3.59776229e-01f, 4.61255461e-01f, 1.12899087e-01f, 1.04931347e-01f, -4.45426315e-01f, -6.50101840e-01f, 6.36037767e-01f,
  1.06264937e+00f, 9.02789295e-01f, -4.86077368e-01f, 9.49154973e-01f, 8.77340317e-01f, 4.13508028e-01f, 8.78026932e-02f, -7.78247654e-01f, 5.80894470e-01f, 7.89862633e-01f,
  9.60262895e-01f, -6.48205757e-01f, -2.50874162e-01f, 6.14175379e-01f, 7.65857995e-01f, -1.35431409e-01f, 7.98581481e-01f, -6.37537360e-01f, -1.59215465e-01f, -5.33666372e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  5.16949475e-01f, 3.51139098e-01f, 2.48380765e-01f, 5.53771079e-01f, 7.67828286e-01f, 4.42758977e-01f, 2.69520909e-01f, -7.21831843e-02f, 2.45128602e-01f, 5.26870012e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -6.18260026e-01f, 2.82244891e-01f, 5.66829860e-01f, 5.80221355e-01f, -1.11366284e+00f, 6.64870739e-02f, 9.69252646e-01f, 1.50680885e-01f, -1.26939863e-01f, -1.03964078e+00f,
  9.35371816e-01f, 3.88120770e-01f, -5.76777101e-01f, -5.71173787e-01f, -8.84198427e-01f, -1.38339543e+00f, 2.44424075e-01f, -2.11638182e-01f, -8.13355505e-01f, 1.09911001e+00f,
  8.19083273e-01f, 7.76128173e-01f, 2.31948599e-01f, 1.07900190e+00f, -1.14688122e+00f, -9.20050502e-01f, -8.21304262e-01f, 2.61125237e-01f, -1.54295459e-01f, 2.15904593e-01f,
  1.40207902e-01f, -9.86719310e-01f, -8.13254640e-02f, -2.93280870e-01f, 3.54962587e-01f, -6.80309951e-01f, 1.00146703e-01f, -1.99107558e-01f, 4.73205000e-01f, 2.87485331e-01f,
  2.98371673e-01f, -3.87005687e-01f, -6.16670191e-01f, -1.19066358e+00f, -4.90315080e-01f, -6.28071785e-01f, 8.44572365e-01f, -1.11431992e+00f, -2.11697534e-01f, -1.04321055e-01f,
  3.81757058e-02f, 5.53816974e-01f, -4.52311397e-01f, 5.18316865e-01f, -8.72386754e-01f, -1.29657638e+00f, -4.93963599e-01f, -5.51186800e-01f, 2.15571910e-01f, -2.85050392e-01f,
  9.64193106e-01f, 6.45179629e-01f, -8.94169390e-01f, 5.17016113e-01f, 8.19104254e-01f, 3.37598510e-02f, 4.73676592e-01f, 1.02149375e-01f, -1.02322757e+00f, -1.08523750e+00f,
  8.37729692e-01f, -6.33103371e-01f, -6.89562321e-01f, 4.15104330e-01f, -1.94019467e-01f, 4.32193011e-01f, -1.75841805e-02f, -1.03651166e-01f, -1.15892184e+00f, 8.34501624e-01f,
  9.63760078e-01f, 4.19547617e-01f, -6.87557399e-01f, 2.48604983e-01f, 1.88174143e-01f, 6.93570435e-01f, -7.17818439e-01f, -5.18464327e-01f, -1.12288773e+00f, 1.95985302e-01f,
  8.29873443e-01f, 7.52796292e-01f, -9.52821434e-01f, -5.93014359e-01f, 1.54547796e-01f, 1.99843898e-01f, -5.25762439e-01f, -1.46529198e-01f, 4.53309566e-01f, -6.63976133e-01f,
  3.87390137e-01f, -1.57872409e-01f, -5.03283262e-01f, -5.24510384e-01f, 1.03783727e-01f, 7.32587457e-01f, -5.30272067e-01f, 4.67177965e-02f, -8.88289332e-01f, -2.43550986e-02f,
  3.66911858e-01f, 4.53407824e-01f, 9.55244079e-02f, 2.27066115e-01f, 3.15961301e-01f, -1.05136879e-01f, 1.84771657e-01f, -5.03578544e-01f, -4.22549695e-02f, 4.54958200e-01f,
  4.67652023e-01f, -4.50530648e-01f, -7.51782358e-01f, -5.44806957e-01f, 7.57798672e-01f, 5.95414817e-01f, -9.88390148e-01f, -1.74787596e-01f, -4.53907102e-01f, -5.50188959e-01f,
  -4.19430763e-01f, -1.70572564e-01f, -9.04604718e-02f, 9.02170986e-02f, -7.10223675e-01f, -9.23172593e-01f, 2.50423133e-01f, -5.26869893e-01f, -5.71301222e-01f, -1.54826984e-01f,
  3.96208882e-01f, 6.09910429e-01f, 6.05316520e-01f, -6.58865392e-01f, 1.15173563e-01f, -1.01802899e-02f, -2.42773682e-01f, -6.30329609e-01f, 3.79117221e-01f, -8.27011645e-01f,
  5.31062961e-01f, 8.31757843e-01f, 4.95192826e-01f, -4.91117053e-02f, 4.11194265e-01f, -7.20369339e-01f, -1.02478027e+00f, -1.17700565e+00f, -7.79134452e-01f, 3.25912505e-01f,
  2.68330220e-02f, 1.99832186e-01f, -5.80185890e-01f, 6.77794755e-01f, 6.90940797e-01f, 2.62258887e-01f, -6.10307992e-01f, -2.16857001e-01f, 1.04377973e+00f, -5.31869113e-01f,
  9.95145619e-01f, -9.28417444e-01f, -9.87066031e-01f, 3.60487521e-01f, -5.64712644e-01f, -2.71609306e-01f, -6.24293461e-02f, 5.13081610e-01f, 9.29157510e-02f, -3.95332903e-01f,
  -7.03248203e-01f, 3.06487143e-01f, 5.67493975e-01f, -1.09318507e+00f, 4.86999601e-01f, 8.65636528e-01f, -2.38150343e-01f, -7.04149783e-01f, 7.14512408e-01f, -6.27214432e-01f,
  -2.15830043e-01f, -5.54761708e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.31021518e-01f, 8.35100636e-02f, -2.14760378e-01f, 5.37592508e-02f, 5.32353938e-01f, 1.92418501e-01f, -1.42117009e-01f, -3.31362814e-01f, -1.73989683e-01f, -9.79569554e-02f,
  2.16037467e-01f, 2.36497745e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    