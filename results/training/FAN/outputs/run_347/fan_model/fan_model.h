/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.65110871e-02f, -3.62869427e-02f, -4.27552909e-01f, -1.30800055e-02f, 6.30257465e-03f, -5.18807285e-02f, -1.01039946e-01f, -7.98470229e-02f, 4.53649508e-03f, 2.83913583e-01f,
  1.39227018e-01f, -1.21496901e-01f, -1.11476757e-01f, 4.27934714e-03f, -3.03957313e-01f, 1.89690315e-03f, 9.66074243e-02f, 5.88009469e-02f, -4.43556346e-02f, -4.29533087e-02f,
  -1.79664120e-02f, 1.23671852e-01f, -2.89786905e-01f, 9.27705988e-02f, -7.76234567e-02f, -5.88908158e-02f, 1.48116544e-01f, -1.05478905e-01f, 1.01433635e-01f, -2.77286232e-03f,
  -9.89475846e-02f, -2.96284035e-02f, -3.53891812e-02f, -6.57119378e-02f, 4.72431220e-02f, 6.70508668e-02f, -6.80863112e-02f, -3.50450650e-02f, 1.46873258e-02f, -6.46604896e-02f,
  -1.56394280e-02f, -1.87877174e-02f, 7.56755769e-02f, 4.84321788e-02f, 1.01775087e-01f, -5.13496995e-02f, 1.93480961e-02f, -4.86164466e-02f, -6.51036650e-02f, -1.38805434e-01f,
  -1.26037836e-01f, -5.39327376e-02f, -1.68295652e-02f, 1.00942336e-01f, -4.69622687e-02f, -4.46269326e-02f, 4.81489114e-02f, -7.08102062e-02f, 5.12385555e-02f, 4.59819436e-02f,
  -9.12103709e-03f, 6.49901927e-02f, -4.72348072e-02f, -4.90025394e-02f, -1.17728123e-02f, -1.52868486e-03f, -3.51763777e-02f, 6.67473823e-02f, -6.85181320e-02f, -4.22420651e-02f,
  -3.64642777e-03f, -2.69258544e-02f, -3.72748040e-02f, 1.05623221e-02f, -5.87275298e-03f, -3.19308564e-02f, -4.28545065e-02f, -1.51407123e-02f, -6.68166354e-02f, -4.99091744e-02f,
  6.88841520e-03f, 1.37954103e-02f, -1.43184820e-02f, -2.21664701e-02f, -5.97310476e-02f, -7.18388781e-02f, 4.24767695e-02f, -4.99443244e-03f, 4.19068858e-02f, -9.80704278e-03f,
  -4.34572175e-02f, -1.91121711e-03f, -6.01069592e-02f, 4.02263366e-02f, 7.71136256e-03f, 1.14679262e-02f, 4.66499887e-02f, 3.00295111e-02f, -3.44468318e-02f, 6.65032398e-03f,
  9.07926783e-02f, 8.04769024e-02f, 1.17240548e-02f, 1.94008294e-02f, -5.74484169e-02f, 2.79785469e-02f, -1.87105872e-02f, 2.65556425e-02f, 6.04455620e-02f, 9.43969935e-03f,
  1.73119921e-02f, 8.90048370e-02f, 2.43939999e-02f, 3.67530924e-03f, 7.70775527e-02f, 2.34741345e-02f, -5.74443676e-02f, 1.16776610e-02f, 2.27403007e-02f, 3.03726345e-02f,
  -1.36864588e-01f, 1.43024281e-01f, 9.38366652e-02f, 8.85097608e-02f, 1.13984812e-02f, -7.61683434e-02f, -5.71072921e-02f, 1.68618992e-01f, 4.28104727e-03f, -6.03226721e-02f,
  8.90556350e-02f, -1.59605443e-02f, -1.17633097e-01f, 1.21639989e-01f, -9.18850079e-02f, -1.04987592e-01f, -7.80990571e-02f, -6.73576519e-02f, 5.25913350e-02f, 1.98208001e-02f,
  4.03969027e-02f, 1.70814857e-01f, 3.87883261e-02f, 1.06935710e-01f, 6.38289526e-02f, -1.10904733e-02f, -6.85309842e-02f, 3.87469158e-02f, 2.74082497e-02f, -5.67247905e-02f,
  4.40227687e-02f, 3.13306227e-02f, 4.97522727e-02f, 7.88431093e-02f, 7.41854906e-02f, -4.46892865e-02f, -6.93249926e-02f, -7.28987902e-02f, -2.05274262e-02f, 5.73789328e-02f,
  4.41928916e-02f, -3.00812125e-02f, 7.51872212e-02f, 1.38518596e-02f, -2.26530191e-02f, -4.63571260e-03f, 5.98966628e-02f, -1.01148330e-01f, 8.68168753e-03f, 3.57217640e-02f,
  -5.93383312e-02f, 7.80304670e-02f, 3.40669230e-02f, -1.87924337e-02f, -2.86423694e-02f, 3.40578631e-02f, -8.37643743e-02f, -2.46232357e-02f, -4.60888185e-02f, 2.09153611e-02f,
  -1.05084823e-02f, -7.87097290e-02f, 8.35632011e-02f, 5.49716540e-02f, 7.79318288e-02f, -5.95920421e-02f, -1.85972266e-02f, -2.81601101e-02f, 3.42838243e-02f, 8.28623921e-02f,
  -9.31473076e-03f, -3.25700603e-02f, 7.65350014e-02f, -5.93870841e-02f, -5.60149103e-02f, -8.34914763e-03f, -6.65245056e-02f, -6.93132654e-02f, -1.64418146e-02f, 4.92516905e-03f,
  -2.77825780e-02f, -2.11248063e-02f, -4.57131416e-02f, 7.01259216e-03f, -3.13190669e-02f, 2.02579983e-02f, -4.27368991e-02f, 7.46965557e-02f, 4.68212354e-04f, -5.93088381e-02f,
  9.48202536e-02f, 6.81203827e-02f, 7.93367177e-02f, 5.03661335e-02f, 2.37619523e-02f, -3.98946777e-02f, 6.00678399e-02f, -4.35827337e-02f, 1.12197483e-02f, 5.92376431e-03f,
  -9.13420320e-02f, -8.17929767e-03f, -4.82684299e-02f, -3.95006426e-02f, 7.30630532e-02f, 4.42777155e-03f, -6.76839650e-02f, 5.35762869e-02f, 6.38532117e-02f, 6.93154931e-02f,
  3.62358987e-02f, -5.48898466e-02f, 2.86826435e-02f, -2.43491251e-02f, -2.36143135e-02f, 4.81111696e-03f, -6.69354945e-02f, 5.08026145e-02f, 3.98541056e-02f, 5.25836125e-02f,
  -1.32642671e-01f, 3.73060107e-02f, 3.21791172e-01f, -1.35406598e-01f, 1.57801278e-05f, 1.30969211e-02f, 7.62705803e-02f, 1.57679487e-02f, 1.00906454e-01f, -1.19491450e-01f,
  -8.10139999e-02f, -2.65698172e-02f, 1.71485722e-01f, -2.04918191e-01f, -2.77449101e-01f, 5.00206091e-02f, -2.65028626e-01f, -4.79573421e-02f, 9.56167206e-02f, -1.34726344e-02f,
  -6.01168955e-03f, -2.40588233e-01f, -9.58571807e-02f, -2.91835843e-03f, -2.90418528e-02f, 2.14265157e-02f, -3.08644950e-01f, 2.18266830e-01f, -2.05768958e-01f, -1.33078441e-01f,
  7.41643757e-02f, -1.39727890e-01f, -9.57660284e-03f, -3.72317284e-02f, -3.91236097e-02f, 3.71902026e-02f, 5.84141947e-02f, 2.70953681e-02f, -9.47565679e-03f, -8.00212286e-03f,
  6.94379909e-03f, -1.56603550e-04f, -2.86049098e-02f, 2.49033272e-02f, 3.52881737e-02f, 2.73778345e-02f, 5.22530116e-02f, 7.07206056e-02f, -1.54472170e-02f, 3.35172787e-02f,
  3.76902856e-02f, 9.53958929e-02f, -5.48953004e-02f, 2.75262743e-02f, 4.76537868e-02f, 6.59436658e-02f, -7.42258620e-04f, -3.90823334e-02f, 3.07752173e-02f, 8.03818554e-03f,
  -7.59071782e-02f, 5.05818650e-02f, -1.11743631e-02f, -5.06893406e-03f, 1.28013575e-02f, -3.31501290e-02f, 6.70628250e-02f, -5.99933900e-02f, 5.11982255e-02f, 5.12031876e-02f,
  -4.54920754e-02f, 2.40533403e-03f, -4.69057336e-02f, 3.89017798e-02f, -1.49623696e-02f, 1.42255491e-02f, 4.39891368e-02f, -4.30627391e-02f, 6.32464513e-02f, -1.32658926e-03f,
  -4.74578980e-03f, 4.13650833e-02f, 1.97116695e-02f, 3.92188039e-03f, 1.55599024e-02f, 6.19777404e-02f, 2.76470240e-02f, 6.89486042e-02f, 7.28043988e-02f, 3.03407554e-02f,
  -1.21212304e-01f, -2.52591550e-01f, 8.79215077e-02f, 5.86013868e-02f, 4.26780246e-02f, -5.88685125e-02f, -6.15669712e-02f, 2.23135538e-02f, 5.12524042e-04f, 3.88804749e-02f,
  -3.72181609e-02f, -2.84062116e-03f, -6.79490119e-02f, -3.04173827e-02f, 1.00672450e-02f, -1.10325287e-03f, -4.82237451e-02f, -9.05957147e-02f, -3.71213518e-02f, -4.27688062e-02f,
  4.67288261e-03f, 1.10647138e-02f, 7.04493225e-02f, -1.60170346e-02f, -6.84646368e-02f, -2.82550845e-02f, -7.21833557e-02f, 7.14590400e-02f, 1.32614328e-02f, 4.92638946e-02f,
  1.62146926e-01f, -8.90406072e-02f, 1.65628567e-01f, 1.58412214e-02f, 1.16897583e-01f, -2.03082979e-01f, -1.05857715e-01f, 3.91251640e-03f, 1.22063227e-01f, -8.72504935e-02f,
  -1.47627681e-01f, 3.13336551e-02f, -4.07860726e-02f, -2.00012058e-01f, -1.72510237e-01f, -9.70702171e-02f, -2.09212914e-01f, -1.34995177e-01f, -5.11554405e-02f, -9.59499646e-03f,
  -8.13903008e-03f, -3.19834441e-01f, -5.51045761e-02f, -1.63261548e-01f, -1.16969701e-02f, 1.29504129e-01f, 8.69580060e-02f, 5.85572906e-02f, -1.72035754e-01f, -5.96131347e-02f,
  -7.77977109e-02f, 7.70567134e-02f, 1.53512388e-01f, 1.26216095e-02f, 2.21935436e-02f, 6.40028417e-02f, 8.99689943e-02f, 1.55533617e-02f, 7.16783106e-02f, 3.40903848e-02f,
  -7.82465190e-03f, 4.40073796e-02f, -5.35322679e-03f, -7.34987333e-02f, 6.35716990e-02f, 7.17214402e-03f, 7.98332095e-02f, 6.46138489e-02f, -4.88827378e-02f, 6.24122880e-02f,
  9.19940695e-02f, 5.04524373e-02f, 6.05617762e-02f, -1.21328970e-02f, 2.50410624e-02f, -3.38640772e-02f, 6.00478239e-02f, 4.27516140e-02f, -2.72728479e-03f, -4.11461629e-02f,
  -1.76498317e-03f, 2.41050683e-02f, 9.24896449e-03f, 6.79924935e-02f, -3.13484557e-02f, -3.48397829e-02f, -5.48472032e-02f, -5.99489138e-02f, 4.77271117e-02f, -2.51545236e-02f,
  2.66020978e-03f, 5.91452420e-02f, 4.28248420e-02f, 4.43629250e-02f, 4.86497544e-02f, -5.80866728e-03f, 8.30930024e-02f, -3.90626304e-02f, 7.09356666e-02f, 4.53874804e-02f,
  6.47181273e-02f, -7.86189456e-03f, -2.56264210e-02f, -1.28500462e-02f, -2.72598844e-02f, -9.93908849e-03f, -5.93101643e-02f, -1.51230972e-02f, 3.85205299e-02f, 3.82088460e-02f,
  -9.98569205e-02f, -1.28600836e-01f, -2.46117860e-02f, 4.13228422e-02f, -8.75518993e-02f, -5.63653782e-02f, -9.60462391e-02f, -5.44502586e-02f, -2.88433190e-02f, 3.99189703e-02f,
  8.32657143e-02f, 5.95632195e-02f, -1.66994296e-02f, 3.84924449e-02f, -5.12885749e-02f, 4.00504172e-02f, 2.58977860e-02f, -5.39912581e-02f, 1.61172748e-02f, -1.50585994e-02f,
  -1.71905048e-02f, 5.86691201e-02f, -1.95531081e-02f, 6.70229178e-03f, -3.27594317e-02f, -3.59005731e-04f, -3.57235745e-02f, 6.45509437e-02f, -4.82672680e-04f, -3.48117948e-02f,
  6.14858903e-02f, -2.89140549e-02f, 1.38129815e-01f, 1.27959624e-01f, 2.16043800e-01f, 3.37630212e-01f, 1.44116372e-01f, 1.81012347e-01f, 1.79005235e-01f, -2.32780874e-01f,
  -5.55425361e-02f, 7.14392066e-02f, -2.30185747e-01f, 9.01708007e-02f, 1.18951991e-01f, -6.65195510e-02f, 1.67271435e-01f, -2.12258380e-02f, 3.53994453e-03f, 3.90432179e-02f,
  1.18995503e-01f, -1.53350709e-02f, -4.02984880e-02f, 3.84422950e-03f, 7.63538852e-02f, -1.04468819e-02f, -9.96673629e-02f, -1.14933997e-01f, -3.31368409e-02f, 3.20653133e-02f,
  -6.24761079e-03f, -3.25157158e-02f, -1.69274714e-02f, 2.02904940e-02f, 1.28821200e-02f, 2.61789933e-02f, -5.47816455e-02f, -6.57712966e-02f, -2.47438513e-02f, 6.58846740e-03f,
  -1.26489829e-02f, -2.31866203e-02f, 9.32922214e-02f, 7.05119921e-03f, 8.63539055e-02f, 8.87942035e-03f, 9.49811339e-02f, 1.03224330e-01f, -3.58971953e-02f, 8.21955204e-02f,
  8.52563456e-02f, 1.55984722e-02f, 5.66357002e-02f, -4.94023692e-03f, 9.26618557e-03f, -2.03054934e-03f, -3.45642231e-02f, -6.43436518e-03f, 1.06177345e-01f, 1.63787100e-02f,
  -3.68809253e-02f, -7.14448541e-02f, -9.21145733e-03f, -6.62060280e-04f, -1.71409007e-02f, 9.25018266e-03f, -5.08873612e-02f, -2.12478600e-02f, -4.54022437e-02f, 2.88304482e-02f,
  1.12467529e-02f, -6.72422275e-02f, 1.69616344e-03f, 1.71905402e-02f, -5.99051379e-02f, 4.63131405e-02f, -2.98286020e-03f, 3.27381156e-02f, -1.76826902e-02f, -1.14138871e-02f,
  -3.59420329e-02f, -2.65234951e-02f, -5.23865083e-03f, -4.62666638e-02f, -3.99359828e-03f, -2.87113935e-02f, 2.16169972e-02f, 6.80083334e-02f, 5.28011099e-02f, -5.00060320e-02f,
  -4.55863141e-02f, -1.84470683e-01f, -8.09622258e-02f, 7.82215036e-03f, -2.19516419e-02f, -5.28583825e-02f, -1.32656675e-02f, 7.16894791e-02f, -8.62111971e-02f, 2.05827411e-02f,
  3.21357846e-02f, 4.52402160e-02f, 6.40685484e-02f, 6.70902338e-03f, -7.64961913e-02f, 9.92289931e-02f, -1.94313414e-02f, 1.38524938e-02f, 1.89451519e-02f, 3.16529088e-02f,
  -2.99954154e-02f, 4.43557911e-02f, 6.04538107e-03f, 4.20573959e-03f, 7.76390433e-02f, 1.31248860e-02f, -2.86848340e-02f, -3.79539728e-02f, -4.47160937e-02f, -3.48225906e-02f,
  -1.37956962e-01f, 1.47835240e-01f, 5.36060594e-02f, -1.90535769e-01f, 9.07337759e-03f, -6.39727339e-02f, -6.80625588e-02f, 4.87334980e-03f, 1.48604244e-01f, 1.41156942e-01f,
  -3.49121392e-02f, -1.40083537e-01f, 1.97813168e-01f, -1.60123870e-01f, -1.86898127e-01f, 1.82181150e-01f, 1.00850489e-03f, -1.02678560e-01f, 1.06372185e-01f, -2.26307251e-02f,
  -4.23132442e-02f, -1.14846453e-01f, 6.46740273e-02f, -4.07806709e-02f, -1.39425889e-01f, -4.61652353e-02f, -1.96855500e-01f, -6.69808090e-02f, -9.60280374e-02f, -4.52095307e-02f,
  1.00025438e-01f, -4.00647782e-02f, 4.51335981e-02f, 6.33059815e-02f, 8.31241831e-02f, 3.91342938e-02f, -1.14415638e-01f, -2.63527259e-02f, -7.14733452e-02f, 4.46384735e-02f,
  -6.03806339e-02f, -2.71221567e-02f, -4.61602025e-02f, -3.28827687e-02f, -9.08186734e-02f, -6.74290732e-02f, -2.86735371e-02f, 3.63094285e-02f, 5.04824966e-02f, -1.18605532e-02f,
  1.07562475e-01f, -1.11202514e-02f, 5.17009273e-02f, 6.15578145e-03f, 1.63260791e-02f, 4.07609008e-02f, -1.48403896e-02f, -8.26381519e-03f, -1.25573697e-02f, -4.06425931e-02f,
  -1.81587115e-02f, 4.09444235e-02f, 1.18207035e-03f, 4.71058786e-02f, 6.79108649e-02f, -3.42190340e-02f, -4.69204783e-02f, 5.70091754e-02f, -6.46184385e-02f, -4.93914075e-02f,
  2.86270827e-02f, -1.41136646e-02f, -4.77011083e-03f, -1.44788232e-02f, -2.03271881e-02f, -4.15268354e-02f, -5.95574901e-02f, 1.70856286e-02f, 2.58115716e-02f, 3.88333052e-02f,
  -1.48272235e-02f, -9.08601210e-02f, 1.91130992e-02f, 2.74121948e-03f, -5.16215973e-02f, 9.12957173e-03f, 1.91797353e-02f, 3.26279253e-02f, 6.15366846e-02f, -1.52550722e-02f,
  -8.25322792e-02f, -1.54584557e-01f, 5.25746830e-02f, -2.81510241e-02f, -5.80790415e-02f, -3.79320607e-02f, -5.36581874e-03f, -1.06777847e-01f, 2.47648917e-02f, -4.37615737e-02f,
  -3.96170951e-02f, 9.84958559e-03f, -7.61912912e-02f, -2.61136936e-03f, 9.61193442e-03f, 1.04798852e-02f, -1.07921287e-01f, -5.58169447e-02f, -4.24818769e-02f, 2.01164428e-02f,
  -5.91916703e-02f, -1.54156825e-02f, -8.38174447e-02f, -4.98617478e-02f, -4.81517576e-02f, -5.84935136e-02f, -4.57597859e-02f, -4.28687036e-02f, -5.63566126e-02f, 8.69837850e-02f,
  -9.51448083e-02f, 1.36263058e-01f, -2.13000491e-01f, -2.60608077e-01f, 1.28499717e-01f, 2.42614493e-01f, -8.04202855e-02f, 1.47658795e-01f, 5.90864792e-02f, 1.83742762e-01f,
  -9.01838169e-02f, -5.91744483e-03f, 2.58310474e-02f, -3.34093608e-02f, -1.60583705e-01f, -1.75771475e-01f, -3.19106579e-02f, 5.45447022e-02f, 1.02881998e-01f, -5.82915135e-02f,
  -1.23175621e-01f, 3.94433513e-02f, -2.68127173e-01f, 9.87565890e-02f, -4.72984500e-02f, 6.57773465e-02f, -4.27623242e-02f, 1.42859131e-01f, 6.75269514e-02f, 1.02721304e-01f,
  1.66097209e-01f, -5.71849085e-02f, -1.74158793e-02f, 6.51299506e-02f, -2.79730856e-02f, -2.89906692e-02f, 7.16267154e-02f, -4.73420322e-02f, -6.60285279e-02f, 8.13953131e-02f,
  5.98525368e-02f, 1.15200412e-02f, 5.33232167e-02f, -8.04773420e-02f, -2.17452124e-02f, -5.97651303e-02f, 8.40194803e-03f, -1.56017970e-02f, -2.43490580e-02f, 1.90536026e-02f,
  -6.26246184e-02f, 6.20592646e-02f, -6.38667494e-02f, -4.07257862e-02f, -4.46817987e-02f, -3.27232368e-02f, -6.79657012e-02f, 9.22998972e-03f, 6.85745897e-03f, 6.61976496e-03f,
  1.02316409e-01f, 2.25649495e-03f, -4.52167019e-02f, 7.95105752e-03f, -1.58679187e-02f, 6.17913669e-03f, -3.11848335e-02f, 2.43219808e-02f, 3.87008153e-02f, -1.21508185e-02f,
  5.14979623e-02f, -7.24483803e-02f, -1.49865169e-02f, -3.89752202e-02f, 7.60381809e-03f, 3.07748821e-02f, 2.42902394e-02f, 5.21760024e-02f, 4.33528088e-02f, -9.04767513e-02f,
  -1.51978629e-02f, 8.01617578e-02f, 2.01028585e-02f, 3.09646036e-02f, 6.46172687e-02f, -6.45419508e-02f, 1.03149796e-02f, 7.01864529e-03f, -3.77709530e-02f, 1.10520190e-02f,
  1.72481954e-01f, 1.38097823e-01f, 3.99152413e-02f, 6.71296939e-02f, 3.18106748e-02f, 6.51076958e-02f, 5.60266115e-02f, 3.21270674e-02f, 6.79598674e-02f, 7.42571354e-02f,
  3.63467187e-02f, 7.46530853e-03f, 1.37759671e-02f, -7.34554380e-02f, 7.21745566e-02f, 4.53316793e-02f, 5.90496650e-03f, 5.76600172e-02f, 2.27838494e-02f, 6.80124313e-02f,
  3.80922183e-02f, 2.73700468e-02f, -3.22289206e-02f, 5.41901700e-02f, 1.94617938e-02f, 3.17266374e-03f, 4.06736359e-02f, -2.99910223e-03f, 8.49684849e-02f, 3.12134475e-02f,
  1.37453675e-02f, 1.38746008e-01f, -3.32561471e-02f, -2.73918629e-01f, 2.45487243e-02f, 3.14339459e-01f, 2.39074111e-01f, 1.08229309e-01f, 2.56872419e-02f, 1.27383461e-02f,
  6.65116832e-02f, -1.90337393e-02f, 2.80978322e-01f, -1.42327566e-02f, -8.11819956e-02f, 1.44718230e-01f, 2.41947430e-03f, 1.00136556e-01f, 6.48422763e-02f, -1.56138120e-02f,
  -5.66953793e-02f, -1.21509135e-01f, -1.07266076e-01f, -4.42303568e-02f, -8.72936398e-02f, -1.75930023e-01f, -2.75958717e-01f, 3.48543264e-02f, -2.44978264e-01f, -6.97611719e-02f,
  8.34528506e-02f, 1.77989826e-02f, 1.51926710e-03f, 7.33370781e-02f, 2.20085564e-03f, -1.51507827e-02f, -2.35781018e-02f, -3.32436012e-03f, -1.52640399e-02f, 1.13892835e-02f,
  2.61628926e-02f, -9.43336040e-02f, -8.27905163e-02f, -2.42235418e-02f, 2.70605348e-02f, -1.24371827e-01f, -1.33783603e-02f, 1.02680288e-02f, -6.77150190e-02f, 5.84822558e-02f,
  -3.51612680e-02f, 1.41307979e-03f, -5.09758852e-02f, -3.85411531e-02f, -1.20756021e-02f, -7.51465783e-02f, 8.41875561e-03f, 5.03340140e-02f, 1.48240095e-02f, -5.04511446e-02f,
  6.76444173e-02f, 8.10864102e-03f, 5.76476660e-03f, -2.07972117e-02f, -2.44238265e-02f, 1.00428879e-03f, -8.31212550e-02f, -1.54199209e-02f, 2.78215595e-02f, 6.04663342e-02f,
  -2.17039827e-02f, 2.89850738e-02f, -1.40771810e-02f, -9.25063528e-03f, -2.22023460e-03f, 2.00047474e-02f, 4.95710177e-03f, -1.46519607e-02f, -6.14467338e-02f, -1.28469214e-01f,
  3.89444195e-02f, -2.86920909e-02f, -3.44685838e-02f, -3.78732421e-02f, -3.25337425e-02f, -3.77949746e-03f, -6.46906197e-02f, 6.14756048e-02f, 1.93450619e-02f, -2.09552888e-02f,
  8.87411162e-02f, -9.22907665e-02f, 2.48935204e-02f, 3.00427862e-02f, -4.73405235e-02f, -2.01084875e-02f, -1.43475493e-03f, 7.17479959e-02f, -9.13244560e-02f, 7.23881274e-02f,
  -2.13004760e-02f, 4.50963043e-02f, 1.65880583e-02f, -6.07877709e-02f, 5.57541065e-02f, -3.03561762e-02f, -9.18121785e-02f, -1.66117363e-02f, -1.77972317e-02f, 1.95480566e-02f,
  1.34762432e-02f, 7.65700713e-02f, 4.29338552e-02f, -4.23353240e-02f, -4.26763371e-02f, 5.29971980e-02f, 4.12392989e-02f, -1.92054529e-02f, -1.87323000e-02f, -1.32137658e-02f,
  -5.26061296e-01f, 6.76670521e-02f, -1.60611406e-01f, -2.07693696e-01f, 4.84112613e-02f, 2.41168037e-01f, 1.11244500e-01f, 9.73560214e-02f, -2.49336824e-01f, 1.97118804e-01f,
  1.62504688e-01f, -1.72360614e-01f, 4.55978364e-02f, 1.24439873e-01f, -1.77675318e-02f, 8.56434703e-02f, 7.89987389e-03f, -1.70051344e-02f, -7.56616667e-02f, -3.56428213e-02f,
  -1.48312777e-01f, 1.24235027e-01f, -4.18664403e-02f, 2.02112183e-01f, -1.63710583e-02f, -1.19748518e-01f, 7.72946700e-02f, 1.29907951e-01f, 7.01214820e-02f, 1.19551368e-01f,
  1.12041622e-01f, 2.03177333e-02f, -7.21691772e-02f, 5.62223904e-02f, 3.08040604e-02f, 1.69227645e-02f, 1.24014188e-02f, -8.94106552e-03f, -9.12474915e-02f, -1.85810793e-02f,
  -3.59424017e-02f, 4.45001684e-02f, 8.33866000e-03f, -3.34047340e-02f, -2.73822974e-02f, 1.09415120e-02f, -3.02871838e-02f, -3.04510389e-02f, -4.75773728e-03f, 2.56210770e-02f,
  -5.02176723e-03f, 3.66395041e-02f, -3.82497460e-02f, 8.23447034e-02f, -1.69452820e-02f, 2.85411580e-03f, 3.75018902e-02f, -1.57526564e-02f, 8.46428145e-03f, 4.27371869e-03f,
  -1.56176910e-02f, -5.07406257e-02f, 4.65892218e-02f, -4.82976288e-02f, -3.40090282e-02f, -1.00123771e-02f, 7.25335674e-03f, 4.53013219e-02f, -5.05480915e-02f, -1.31266806e-02f,
  -4.28251885e-02f, -4.84373719e-02f, 2.10872125e-02f, 2.05612220e-02f, -3.10851112e-02f, -2.63009556e-02f, 6.67091459e-02f, 3.53149846e-02f, -7.90327415e-02f, -1.58207826e-02f,
  3.31289396e-02f, -5.25093824e-02f, -1.57330148e-02f, -3.96420211e-02f, -1.70038268e-03f, -5.34530431e-02f, -1.84142813e-02f, -5.23175448e-02f, 1.81444772e-02f, 2.39841435e-02f,
  5.81149533e-02f, 9.30099785e-02f, -1.25047741e-02f, -1.12319561e-02f, 3.58062088e-02f, 3.60470340e-02f, 4.52548377e-02f, -6.22528046e-02f, 4.68877368e-02f, 1.51787391e-02f,
  1.25314659e-02f, -1.25834337e-02f, 4.73047234e-02f, 2.74492912e-02f, 2.71045826e-02f, -9.52823553e-03f, 5.43720461e-02f, 1.43639036e-02f, -1.85703896e-02f, 4.12547402e-02f,
  6.02663420e-02f, -1.13616353e-02f, 4.30153199e-02f, -3.86848003e-02f, -4.81593935e-03f, -6.62384368e-03f, 1.58534106e-02f, 2.60867141e-02f, 2.24581417e-02f, -1.51696317e-02f,
  -1.90000907e-01f, 1.51075155e-01f, 1.63296118e-01f, -1.60874892e-02f, -3.70860934e-01f, -7.77480602e-02f, 1.92789838e-01f, -2.55540967e-01f, 7.88554624e-02f, 5.86760119e-02f,
  -4.62970957e-02f, 2.03451887e-01f, 2.32716396e-01f, -1.45259416e-02f, 1.39319360e-01f, 3.44697505e-01f, -4.92527969e-02f, 1.08848415e-01f, 9.34726931e-03f, -1.33696437e-01f,
  -9.81768295e-02f, -1.91418484e-01f, 8.00943449e-02f, -2.48643786e-01f, -1.79687724e-01f, -1.98568687e-01f, -1.36279896e-01f, 8.37521404e-02f, -1.84674323e-01f, 8.31075013e-02f,
  -8.97316560e-02f, -1.52721060e-02f, 3.23643088e-02f, 6.04984947e-02f, -6.82340860e-02f, -9.67386365e-03f, -5.84699865e-03f, 6.82350472e-02f, 1.15381239e-03f, 4.32864390e-02f,
  4.16729925e-03f, -8.70332196e-02f, -8.18609595e-02f, 3.26660238e-02f, -8.49511549e-02f, -2.21300814e-02f, -2.30423268e-02f, 3.31919938e-02f, 1.20471604e-02f, 1.41147822e-02f,
  7.35895894e-03f, -1.35067971e-02f, -1.13022011e-02f, 2.65800208e-02f, -2.87375655e-02f, -1.74396280e-02f, 2.26110630e-02f, 1.29854232e-02f, -5.90140335e-02f, -2.98892744e-02f,
  4.17605191e-02f, -6.69581117e-03f, 6.73935041e-02f, -3.73535343e-02f, 4.16361168e-03f, -1.69983935e-02f, 1.32460734e-02f, 5.10752499e-02f, 2.26092665e-03f, -2.90011335e-02f,
  -2.06087977e-02f, -2.30639167e-02f, 3.52844223e-02f, 6.28678361e-03f, -2.36218758e-02f, -9.61896218e-03f, 7.98605457e-02f, 1.40845673e-02f, -6.90252855e-02f, -5.93921207e-02f,
  5.00518642e-02f, 4.61533782e-04f, -5.33807352e-02f, 1.37250023e-02f, -6.51862752e-03f, 1.30827806e-03f, -5.92493005e-02f, 5.34508564e-02f, -1.30862882e-02f, -2.41305344e-02f,
  -1.93576813e-01f, -3.42372269e-03f, -2.68078260e-02f, 3.81883839e-03f, 2.46127136e-02f, -5.33934347e-02f, 9.74905863e-02f, -1.00650638e-02f, 1.27356639e-02f, 2.78598489e-03f,
  -3.47377472e-02f, -3.43133733e-02f, 4.58540395e-02f, -1.05477348e-02f, 7.31009692e-02f, 8.31439439e-03f, 3.82832326e-02f, -4.01884876e-02f, -5.41290455e-02f, -6.29171133e-02f,
  -1.60858762e-02f, -3.87323019e-03f, 3.09404433e-02f, -7.02860728e-02f, 1.86367314e-02f, -3.91358361e-02f, -8.16299114e-03f, 5.23984171e-02f, 5.61894514e-02f, 5.32278568e-02f,
  5.80852181e-02f, -2.52004415e-01f, 9.44729149e-03f, 9.68481153e-02f, 2.79144406e-01f, 1.38387397e-01f, -9.96551104e-03f, -2.53028162e-02f, -1.84006438e-01f, -1.93506911e-01f,
  2.02720407e-02f, -1.51537424e-02f, -1.81823730e-01f, -3.85027416e-02f, -7.38936812e-02f, -3.73346090e-01f, -1.41965553e-01f, -8.36625993e-02f, -3.11496425e-02f, 8.30739513e-02f,
  -1.48879215e-02f, -6.24920353e-02f, 3.07485647e-02f, 7.59346932e-02f, 8.83327574e-02f, 3.94752808e-02f, 4.37667631e-02f, 8.35751295e-02f, 1.24918550e-01f, 7.74244219e-02f,
  1.09498210e-01f, -3.93749326e-02f, 4.23890091e-02f, -6.73052762e-03f, 7.00869635e-02f, 9.26581696e-02f, 2.22250819e-02f, 3.73342112e-02f, 3.68035287e-02f, -3.20255905e-02f,
  5.04453741e-02f, -1.36520518e-02f, -1.76563091e-03f, 1.37901660e-02f, 1.06345326e-01f, 1.02556655e-02f, -2.34554838e-02f, 3.81971970e-02f, 3.88235748e-02f, 6.43410310e-02f,
  -6.12228997e-02f, 3.81781682e-02f, -1.33940326e-02f, -7.35158101e-02f, -5.33964857e-02f, -3.76072973e-02f, -5.67240156e-02f, 3.62791941e-02f, 6.06466457e-02f, -6.40535876e-02f,
  5.67972176e-02f, -5.22504561e-02f, 1.72363892e-02f, -2.23613083e-02f, 2.74364538e-02f, 6.25938475e-02f, 4.37846361e-03f, 3.72161716e-02f, 2.93126758e-02f, 3.95468697e-02f,
  8.89445096e-02f, 3.60815111e-03f, 8.36494789e-02f, -2.56749634e-02f, 6.86195344e-02f, -7.28470311e-02f, 6.67540058e-02f, -3.24935615e-02f, -3.12128086e-02f, -3.80941890e-02f,
  -4.01820317e-02f, 8.07903428e-03f, -1.94043070e-02f, -2.13753991e-02f, -3.90520915e-02f, -3.79144736e-02f, 4.33340445e-02f, 4.45800722e-02f, -4.33058776e-02f, 2.56293081e-02f,
  -6.79741278e-02f, -2.21326411e-01f, -5.39552644e-02f, 7.52085373e-02f, -7.48228133e-02f, -5.27733192e-02f, -6.08593598e-02f, -2.85219066e-02f, -6.91521317e-02f, -2.86590140e-02f,
  3.27747092e-02f, -3.29711684e-03f, -5.92922978e-02f, 6.41833991e-02f, 1.56160397e-03f, 2.66667996e-02f, -1.23890573e-02f, 6.91198220e-04f, 4.42131199e-02f, 2.09498238e-02f,
  -1.66327860e-02f, -2.27780454e-02f, 6.39093434e-03f, 1.35353915e-02f, 3.61763649e-02f, -2.22814009e-02f, 2.31287275e-02f, 5.24982996e-03f, -2.16373969e-02f, -1.44286659e-02f,
  3.06414545e-01f, -3.87142271e-01f, -1.15662105e-01f, 1.94822237e-01f, -1.09837567e-02f, 9.80667546e-02f, 3.01768661e-01f, -4.95687202e-02f, 1.18673705e-01f, -2.64459074e-01f,
  1.12000406e-01f, -3.51103097e-02f, -5.11662215e-02f, 5.18718325e-02f, 5.35821676e-01f, 6.44621477e-02f, 1.93794191e-01f, 9.65325460e-02f, -1.56565607e-02f, -5.06494530e-02f,
  1.39100075e-01f, 1.68110639e-01f, 7.69693591e-03f, -1.66445449e-01f, -6.91023916e-02f, -1.52301967e-01f, 5.23971505e-02f, -1.19535133e-01f, -1.02847926e-01f, 4.33575958e-02f,
  2.45523304e-02f, -2.36758497e-02f, -7.69207580e-03f, -9.61080119e-02f, 1.18700033e-02f, -4.43189926e-02f, 2.62602773e-02f, 1.70565471e-02f, 8.69765356e-02f, -8.93598702e-03f,
  -1.15473773e-02f, 2.46689525e-02f, 3.85961048e-02f, -7.02917157e-03f, 2.17492022e-02f, -7.35543892e-02f, -7.08594620e-02f, -3.53790186e-02f, -7.06206784e-02f, -2.95294467e-02f,
  -8.53611454e-02f, 1.13815526e-02f, -4.87568192e-02f, -2.69160029e-02f, 5.28297871e-02f, -8.41176976e-03f, 4.57448773e-02f, -6.95881248e-03f, 3.02720983e-02f, -7.15142163e-03f,
  -3.06799300e-02f, 4.98732589e-02f, 3.78933847e-02f, -1.66327190e-02f, 3.91847081e-02f, -2.13677883e-02f, 1.92438718e-02f, -5.22955740e-03f, -2.55906954e-02f, 1.17617417e-02f,
  1.25495046e-02f, -5.70533704e-03f, 1.92217827e-02f, 2.99472418e-02f, 1.65395979e-02f, 1.01613728e-02f, 1.69195849e-02f, -2.33307630e-02f, -2.21961048e-02f, -2.84928828e-02f,
  1.39597543e-02f, 3.72503772e-02f, -6.63566515e-02f, 2.25326475e-02f, 3.21118310e-02f, -1.00495834e-02f, -3.84660400e-02f, -5.03787026e-02f, 2.49540936e-02f, 8.55664983e-02f,
  -4.90105115e-02f, -7.19818324e-02f, -3.01645398e-02f, -1.02138547e-02f, 1.34754032e-02f, 3.85193974e-02f, -1.17755467e-02f, 2.63605565e-02f, -4.30638045e-02f, 2.26318929e-02f,
  -1.88248493e-02f, 7.17304589e-04f, 1.02073541e-02f, 2.10740976e-02f, 7.15482561e-03f, 3.96073051e-02f, 2.66032591e-02f, 4.72611487e-02f, 4.86604385e-02f, 7.69727025e-03f,
  3.67267709e-03f, -3.12372092e-02f, 1.00000672e-01f, 1.77078322e-02f, -4.17086482e-02f, 1.55191272e-02f, 4.87927953e-03f, 3.34200040e-02f, -4.79344949e-02f, -1.29589450e-03f,
  -1.33071840e-01f, -3.33688259e-01f, 4.38858569e-02f, -6.36076331e-02f, 6.83308840e-02f, -3.24274711e-02f, -6.77729473e-02f, -6.88779429e-02f, -8.51289183e-02f, -1.86159343e-01f,
  1.70781743e-02f, -1.59388557e-01f, -8.04058164e-02f, -2.46447906e-01f, 7.42050707e-02f, 2.75016646e-03f, -1.97393566e-01f, -1.62539870e-01f, 6.82378113e-02f, -2.52336204e-01f,
  4.20209542e-02f, -2.15748519e-01f, 1.45327851e-01f, 8.70292932e-02f, -1.07184723e-01f, 9.23825800e-02f, -1.91323347e-02f, 5.11195883e-02f, 9.98112746e-03f, 9.79833156e-02f,
  -1.83525607e-01f, -1.71593279e-01f, 4.40627225e-02f, 4.79807444e-02f, -1.65991914e-02f, -2.95932572e-02f, 4.65384275e-02f, 8.83080587e-02f, 5.07255234e-02f, 1.75938457e-02f,
  -3.65442857e-02f, 2.18178649e-02f, -1.09650344e-02f, 8.82508233e-02f, 1.47292865e-02f, 7.24250823e-02f, 1.72698963e-02f, -3.29289511e-02f, 1.58797149e-02f, 8.62297323e-03f,
  2.66906787e-02f, -1.28910207e-04f, 4.68286388e-02f, 4.31725606e-02f, 2.00051777e-02f, 5.62532991e-03f, -2.99867392e-02f, 2.96594538e-02f, -4.36318107e-02f, 2.68218443e-02f,
  1.11983813e-01f, 2.18333211e-02f, -5.09000681e-02f, 1.41255474e-02f, 6.36557397e-03f, 5.30179702e-02f, -1.44518446e-02f, -1.57518545e-03f, -4.75636944e-02f, 2.09656004e-02f,
  -5.97599670e-02f, -3.05973142e-02f, -6.78997301e-03f, 4.63147461e-03f, -7.02476874e-02f, 3.05121578e-02f, 1.49557265e-02f, -3.55305746e-02f, 4.19638641e-02f, -1.44620426e-02f,
  -1.53017668e-02f, -7.92663544e-02f, -7.55455717e-02f, 3.82274464e-02f, 2.02897340e-02f, 4.03970527e-03f, -3.63476351e-02f, -1.80188520e-03f, 1.21553773e-02f, -3.43134860e-03f,
  -1.88247770e-01f, -3.11658561e-01f, -1.11231208e-02f, -1.82141084e-02f, -3.28894675e-04f, 3.24936658e-02f, -7.07532316e-02f, -1.32223284e-02f, -1.00667872e-01f, -5.02587818e-02f,
  -2.90019196e-02f, -2.47837947e-04f, 4.80524451e-02f, -8.97532478e-02f, 2.49519106e-02f, -9.47633684e-02f, -9.12888199e-02f, 1.11513138e-02f, -3.60647701e-02f, -2.67155073e-03f,
  2.97123864e-02f, 5.37153184e-02f, 7.10250586e-02f, -6.51203468e-03f, 6.81857020e-02f, -1.99526567e-02f, 4.56341878e-02f, 8.55979696e-02f, 6.46967292e-02f, -8.95180628e-02f,
  -4.77766581e-02f, 3.89652178e-02f, 1.69181392e-01f, 3.69182713e-02f, 4.79535423e-02f, 3.06423884e-02f, 1.02362588e-01f, 2.08295025e-02f, -3.14361975e-02f, -3.38031841e-03f,
  -1.32358387e-01f, -1.73155501e-01f, 4.77314591e-02f, -5.89553192e-02f, 9.66441929e-02f, 2.67326459e-02f, 4.00044508e-02f, 4.03132848e-02f, 7.45631158e-02f, 7.82292709e-02f,
  1.10254914e-01f, -4.05915417e-02f, 8.72972757e-02f, -7.09005073e-02f, -7.83174559e-02f, 3.01799420e-02f, 3.95504870e-02f, -3.47987451e-02f, 5.26687317e-02f, -9.86551866e-03f,
  -1.94151774e-02f, 1.65587775e-02f, -1.30014457e-02f, 3.08186077e-02f, 1.37676686e-01f, -2.63191592e-02f, -6.99579045e-02f, 9.90693364e-03f, 7.35393614e-02f, -6.90586790e-02f,
  -1.62402708e-02f, -6.79008290e-02f, 2.74886005e-02f, -5.44795096e-02f, -5.59681803e-02f, -9.84615013e-02f, -4.11388166e-02f, -5.05948327e-02f, 6.17622733e-02f, -6.64767399e-02f,
  1.49536738e-02f, -5.90827735e-03f, 1.14069775e-01f, 2.36027129e-02f, 2.89362296e-02f, -5.31137809e-02f, 4.18538265e-02f, 4.95986864e-02f, 1.46444363e-03f, 6.20689057e-02f,
  -1.66832341e-03f, 1.05935253e-01f, -5.56821609e-03f, -8.37358832e-02f, 3.84751856e-02f, 3.05224434e-02f, 5.54512255e-02f, 8.57342705e-02f, -2.41156239e-02f, 1.26802288e-02f,
  -1.44855576e-02f, 4.71143164e-02f, 1.94683392e-02f, 3.36938091e-02f, -6.31362200e-02f, 5.34268506e-02f, -4.76410873e-02f, -6.52925745e-02f, 3.17717493e-02f, 1.28655983e-02f,
  4.08639796e-02f, 5.06483316e-02f, -6.03914075e-02f, -2.59672217e-02f, -4.28648889e-02f, -8.77615064e-03f, 4.77862507e-02f, 5.36159761e-02f, 5.38534075e-02f, 8.04074854e-02f,
  -7.00501585e-03f, 1.27228349e-01f, 5.55131882e-02f, -7.98555836e-02f, 6.89312741e-02f, 1.00575201e-02f, 8.41171816e-02f, 2.99548190e-02f, 2.97709387e-02f, 8.26916564e-03f,
  8.86386633e-02f, 4.55498844e-02f, -3.91576625e-02f, -1.00371102e-02f, -2.89848335e-02f, 4.28041741e-02f, 5.51581848e-03f, 6.16144240e-02f, -4.36157361e-02f, -6.95072487e-02f,
  1.43509556e-03f, -2.17249803e-02f, 6.90037981e-02f, 6.16199821e-02f, 1.30072059e-02f, 9.30079892e-02f, 1.13745751e-02f, -5.92829380e-03f, -2.37621218e-02f, 6.13243878e-02f,
  -5.15288174e-01f, 1.31755024e-01f, -8.75454843e-02f, -2.39049673e-01f, 2.26901155e-02f, 2.52087384e-01f, -8.06667209e-02f, 3.32752988e-02f, -6.35718182e-02f, 1.36707708e-01f,
  8.10411796e-02f, -1.65692076e-01f, 2.18799207e-02f, 1.05831198e-01f, -3.00891679e-02f, 5.84827736e-02f, 6.87098727e-02f, 6.28624558e-02f, -6.56456873e-02f, -9.13473964e-02f,
  -8.16687644e-02f, 1.75800100e-01f, 1.79580282e-02f, 2.07526490e-01f, -4.20760885e-02f, -4.15637679e-02f, 2.10748818e-02f, 5.07983714e-02f, 1.18793614e-01f, 7.99117684e-02f,
  -1.28643081e-01f, -2.15936720e-01f, -8.71965736e-02f, 1.42529095e-02f, 1.12041114e-02f, -7.40242600e-02f, -2.13381033e-02f, -6.79010712e-03f, -4.94474284e-02f, -3.19449529e-02f,
  -6.51397035e-02f, -3.91752422e-02f, 4.35967706e-02f, -4.09316979e-02f, -1.94481965e-02f, -9.95498616e-03f, 9.88061354e-03f, 4.89804149e-02f, -2.02460214e-02f, -6.33890834e-03f,
  -5.31878509e-02f, 4.26984355e-02f, -4.51802686e-02f, 3.97923961e-02f, -9.63579107e-04f, 5.53704910e-02f, 2.21742280e-02f, -3.11770793e-02f, 5.58294877e-02f, 3.03387512e-02f,
  -2.28177253e-02f, 6.15760824e-03f, -1.76616497e-02f, 3.91933974e-03f, -5.73182851e-03f, -3.63271274e-02f, 2.57266667e-02f, 2.53936718e-03f, -5.02584875e-02f, 3.85155380e-02f,
  1.54989678e-02f, -6.09397218e-02f, 9.01872572e-03f, 3.24904658e-02f, -5.71149401e-04f, -2.33728159e-02f, -2.47089975e-02f, 9.74033959e-03f, -1.49400309e-02f, 3.13112214e-02f,
  2.82409228e-02f, 2.18955870e-03f, 5.53697348e-02f, -4.51255254e-02f, 7.24881366e-02f, 3.03503741e-02f, -1.47987166e-02f, -3.11377831e-02f, -6.72454666e-03f, -7.30159208e-02f,
  2.19966285e-02f, -1.24422222e-01f, 4.37468151e-03f, 5.01796138e-04f, -2.31290665e-02f, 6.78362278e-03f, 2.54065748e-02f, -8.46135896e-03f, 2.91600544e-02f, 4.68201935e-03f,
  2.93027610e-02f, -1.61878038e-02f, 1.94920134e-02f, 3.54337203e-03f, 5.49536161e-02f, 4.57963347e-02f, -1.35122556e-02f, -6.85523599e-02f, 4.24186140e-02f, 5.83845899e-02f,
  2.66809240e-02f, 5.65166119e-03f, -4.78835739e-02f, -6.96576759e-02f, 7.39333220e-03f, -2.13762969e-02f, -5.70918843e-02f, 2.37320513e-02f, 6.03047907e-02f, 7.11445808e-02f,
  -1.81790158e-01f, 2.72110254e-01f, -1.31890610e-01f, -2.28677526e-01f, -7.90162385e-02f, 1.55782461e-01f, 6.85398234e-03f, 1.50410738e-02f, -1.04414478e-01f, 2.35954627e-01f,
  -5.44270724e-02f, -4.51524742e-02f, 1.16854310e-01f, -5.87896816e-02f, -1.05580106e-01f, 1.82056576e-01f, 5.96343465e-02f, 7.67252594e-02f, 3.08349021e-02f, -1.40123209e-02f,
  -1.15703419e-01f, -1.29784614e-01f, -9.95636061e-02f, -1.40826683e-03f, -1.12989545e-01f, -3.77667621e-02f, -1.16118088e-01f, 6.58751093e-03f, 3.12872380e-02f, 3.05299573e-02f,
  -1.65043138e-02f, -9.02357772e-02f, -3.28986570e-02f, 8.35898593e-02f, 4.14748414e-04f, -5.77220470e-02f, 1.59871913e-02f, 1.24004316e-02f, -2.54888926e-02f, -4.81557287e-02f,
  8.42479393e-02f, 1.32173358e-04f, 1.50753232e-02f, 5.60888909e-02f, 6.87384084e-02f, -2.22225906e-03f, -3.12493462e-02f, 1.82856508e-02f, 4.36879955e-02f, 2.44196951e-02f,
  -8.03985540e-03f, 4.68096137e-02f, 1.14708403e-02f, 3.06596346e-02f, -4.62579168e-02f, -7.93077275e-02f, 4.18779813e-02f, 1.83745604e-02f, -1.23807043e-02f, -6.04488477e-02f,
  -7.01447949e-02f, -6.55577481e-02f, 4.68004383e-02f, 2.75242049e-02f, -8.45957994e-02f, -3.32246572e-02f, 6.97297677e-02f, 2.49532834e-02f, -6.51511503e-03f, 7.67375380e-02f,
  3.55280712e-02f, -6.13770820e-02f, 2.05780528e-02f, 7.27434382e-02f, -1.31101348e-02f, -2.20703147e-02f, 5.52051254e-02f, 2.63041873e-02f, 5.42209707e-02f, -5.82723990e-02f,
  -1.46816233e-02f, 1.55347225e-03f, -2.93492991e-02f, 6.82204440e-02f, 5.33312634e-02f, -3.85552756e-02f, 3.02483398e-03f, -1.47482259e-02f, 2.28736214e-02f, -2.57700160e-02f,
  2.56919056e-01f, 1.27963126e-01f, -6.27549216e-02f, 6.69461861e-02f, 8.06211457e-02f, 4.83344868e-02f, -1.31097883e-02f, -2.16158573e-02f, 6.11011535e-02f, 1.61573496e-02f,
  -1.13040665e-02f, -8.33624508e-03f, 1.13074675e-01f, -7.27611482e-02f, -3.55226286e-02f, -1.08889425e-02f, -6.78877234e-02f, -1.22918766e-02f, 2.46809777e-02f, -4.12721522e-02f,
  -5.05954549e-02f, 1.16968295e-02f, 1.59012042e-02f, -2.27766205e-02f, -9.89490002e-03f, 1.90917682e-02f, 7.30782049e-03f, 5.13388924e-02f, -3.42710689e-02f, -3.53596769e-02f,
  -6.20180275e-03f, -1.38828084e-01f, 2.50022230e-03f, -2.77081847e-01f, -2.21483759e-03f, -1.42468452e-01f, -1.19393073e-01f, 1.93214100e-02f, -8.24618712e-02f, -1.40499204e-01f,
  -1.79921780e-02f, -2.24517241e-01f, 1.54883370e-01f, -2.85068631e-01f, 2.72896551e-02f, 1.49363920e-01f, -2.10821405e-01f, -2.58100450e-01f, 1.02714188e-01f, -8.09302926e-02f,
  6.00654213e-03f, -1.55992016e-01f, 4.54210304e-02f, 8.48931074e-02f, -1.00680083e-01f, 9.68004577e-03f, 7.86839277e-02f, 2.17586368e-01f, -1.86276406e-01f, 5.91790944e-04f,
  -1.29460335e-01f, 5.80352731e-03f, 1.87559407e-02f, -1.67519581e-02f, -1.76370479e-02f, -7.10681528e-02f, -5.60904332e-02f, 2.14371141e-02f, -4.59013544e-02f, 1.93210337e-02f,
  -4.93271351e-02f, 1.05919025e-03f, -8.15177113e-02f, 7.70077333e-02f, -6.06012717e-02f, 2.01002564e-02f, 5.26012741e-02f, -5.01822494e-03f, -4.41133138e-03f, 8.08113664e-02f,
  2.24912539e-02f, -4.69091833e-02f, 1.67028653e-03f, -7.43109062e-02f, 3.48024815e-02f, -2.65975948e-02f, -5.66222668e-02f, -4.02921624e-02f, -7.73468539e-02f, 2.69165449e-02f,
  -6.34659156e-02f, -1.80164017e-02f, -4.07004394e-02f, -1.39943380e-02f, -7.99293369e-02f, 8.38263929e-02f, -6.41231984e-02f, -6.23834729e-02f, 4.75037023e-02f, -3.04278564e-02f,
  -3.64211500e-02f, -4.56094332e-02f, -7.81025179e-03f, -3.23937573e-02f, -6.07858114e-02f, -7.03390017e-02f, -2.36290805e-02f, -9.32622235e-03f, -1.67877376e-02f, 3.83484922e-02f,
  -8.32849462e-03f, -5.95136918e-02f, -8.03666748e-03f, -2.65708379e-02f, -8.02913494e-03f, 6.22867942e-02f, 4.44696099e-03f, -3.47058102e-02f, 3.13874967e-02f, -5.95905893e-02f,
  -6.25173897e-02f, 7.28220418e-02f, -5.23818210e-02f, -4.21616584e-02f, 2.32603122e-02f, 1.46437017e-03f, 1.27411634e-02f, 8.79050605e-03f, -5.77367377e-03f, 1.95836667e-02f,
  4.93171662e-02f, -6.80039823e-02f, -3.32080461e-02f, -6.57522902e-02f, -6.19018897e-02f, -3.43815275e-02f, 1.87686346e-02f, -9.69783403e-03f, -9.34766140e-03f, -2.45767590e-02f,
  -5.05803451e-02f, 9.27710757e-02f, -1.83642861e-02f, -1.33357821e-02f, -5.82134761e-02f, 7.96795706e-04f, 1.95652079e-02f, 4.98528741e-02f, 1.83966178e-02f, -5.26214316e-02f,
  3.41519207e-01f, -1.57390416e-01f, -1.29936546e-01f, 1.34976938e-01f, 4.01302502e-02f, 2.74556071e-01f, 3.41304272e-01f, -7.29598552e-02f, -4.67574522e-02f, 2.64976025e-02f,
  2.00676605e-01f, -5.43200001e-02f, -9.65012759e-02f, 3.22278827e-01f, 3.23679566e-01f, 1.03502803e-01f, 3.12828422e-01f, 2.44457304e-01f, -3.44657823e-02f, 2.68603563e-02f,
  4.67187464e-02f, 1.89508334e-01f, 4.32102308e-02f, -2.00477302e-01f, 6.72226474e-02f, -1.72326729e-01f, 4.77370881e-02f, -2.34974593e-01f, -5.05046593e-03f, -7.30988756e-03f,
  7.45158195e-02f, 6.09971844e-02f, -2.33341344e-02f, -7.95906186e-02f, 5.50439060e-02f, 1.57729276e-02f, -1.32201379e-02f, -4.15639021e-02f, -9.60678421e-03f, -1.29775619e-02f,
  -1.86409466e-02f, -1.60715058e-02f, -1.25646228e-02f, 1.66418180e-02f, -4.79729511e-02f, -4.73291166e-02f, 1.16630187e-02f, 3.23357061e-02f, -1.25938095e-02f, -1.81059558e-02f,
  5.23350611e-02f, 4.05685604e-02f, 4.30910513e-02f, -4.91202669e-03f, -2.73482557e-02f, -1.64784938e-02f, -3.36635895e-02f, -2.99943537e-02f, -5.79717755e-02f, 6.80728108e-02f,
  2.80493274e-02f, 4.95208055e-02f, 1.81652457e-02f, 3.09901033e-02f, 1.00723356e-02f, 2.29984112e-02f, 2.61776932e-02f, -7.40128616e-03f, 3.78928822e-03f, 4.87396456e-02f,
  7.08730565e-03f, 4.04547751e-02f, 1.51500860e-02f, -5.28611755e-03f, 2.14780550e-02f, 2.90415511e-02f, 1.24992523e-02f, -2.62470655e-02f, 4.09199744e-02f, 2.72067953e-02f,
  -3.92363891e-02f, 6.32108524e-02f, -5.52508608e-02f, -1.11386040e-03f, 2.10679416e-02f, -4.19411473e-02f, 2.26871632e-02f, -6.27159141e-03f, -2.06957497e-02f, 2.23139562e-02f,
  1.56383663e-02f, -1.28957778e-01f, -7.44984224e-02f, -3.64239365e-02f, -2.10922677e-02f, 1.15167955e-02f, 6.40258193e-02f, 6.23747474e-03f, -2.91059799e-02f, 6.19524717e-02f,
  5.97567018e-03f, 3.22453305e-03f, -5.09713730e-03f, -4.92213592e-02f, 2.79557449e-03f, 3.76544632e-02f, 5.05146161e-02f, -1.53034907e-02f, 1.71860866e-02f, -4.18788753e-02f,
  -4.94073555e-02f, 2.68369745e-02f, 1.82799660e-02f, -2.89924145e-02f, -6.08033035e-03f, 5.41435033e-02f, 1.42671801e-02f, -5.05568571e-02f, 2.42119320e-02f, -6.37781918e-02f,
  -1.85792357e-01f, 1.58297598e-01f, 9.27213654e-02f, -2.27353096e-01f, -2.00207666e-01f, 5.42771369e-02f, -3.47132646e-02f, -3.04541197e-02f, -2.59672135e-01f, 6.24759197e-02f,
  -1.57114789e-02f, 3.49657238e-02f, 2.29856238e-01f, 1.09154187e-01f, 2.96504349e-02f, 1.56449571e-01f, 2.40215305e-02f, -6.80783391e-02f, -8.62885416e-02f, -1.02038041e-01f,
  -2.20038556e-02f, 4.01228927e-02f, 2.65471071e-01f, -3.04795597e-02f, -8.13504532e-02f, -2.42593810e-02f, -9.32002254e-03f, -4.06978391e-02f, -3.36205517e-03f, 5.39235882e-02f,
  -7.37992115e-03f, -7.50831664e-02f, 3.04815825e-02f, -2.40530390e-02f, -1.71217024e-02f, 4.24692817e-02f, -3.03739328e-02f, 5.03957737e-03f, -9.41444710e-02f, 3.71872308e-03f,
  -1.68203861e-02f, 3.00259255e-02f, -3.15330736e-02f, -1.71705112e-02f, -1.92952715e-02f, -1.43448468e-02f, 2.86629330e-03f, -2.62797158e-02f, 2.99759898e-02f, 8.46033022e-02f,
  3.61840473e-03f, 7.23174661e-02f, -9.06796604e-02f, 1.67240929e-02f, -5.56991659e-02f, -4.58320230e-02f, -8.62998608e-03f, 8.59798864e-02f, -3.30728889e-02f, -4.06867340e-02f,
  5.01214014e-03f, 4.72609960e-02f, 2.86797192e-02f, 1.27283204e-02f, 5.06531559e-02f, -1.44198248e-02f, 6.01209551e-02f, 7.31316060e-02f, -3.65372598e-02f, -8.60970467e-03f,
  -5.43920174e-02f, -6.51234835e-02f, 2.13697902e-03f, 9.82557144e-03f, -1.40250209e-04f, -3.37175392e-02f, 6.52105883e-02f, 2.22950466e-02f, -6.00111373e-02f, -1.59425884e-02f,
  3.43615562e-02f, 9.84926708e-04f, 8.91293734e-02f, 5.84207177e-02f, 3.46621461e-02f, 3.03258058e-02f, 4.48463950e-03f, 3.10133975e-02f, -6.82985485e-02f, -4.93735336e-02f,
  3.89510742e-03f, 3.87066579e-03f, 6.53917342e-02f, 1.00538535e-02f, 8.86872858e-02f, 1.68199204e-02f, -4.43215184e-02f, -1.52324233e-02f, 1.08830947e-02f, -8.00888240e-02f,
  2.92656757e-02f, -1.06760107e-01f, -1.63888540e-02f, 4.90956008e-02f, -2.63151880e-02f, -9.34474822e-03f, 3.07264626e-02f, -2.70563047e-02f, -1.08789206e-01f, -1.25054689e-02f,
  1.52454013e-02f, -7.57225677e-02f, 3.97935845e-02f, -1.38409272e-01f, 7.78871169e-03f, -4.55457829e-02f, -9.96040031e-02f, 4.57629189e-02f, 8.01165104e-02f, 1.44034075e-02f,
  -5.61247058e-02f, -1.51439786e-01f, 1.03424512e-01f, -2.97176326e-03f, 1.51748117e-02f, 1.09206565e-01f, 2.96072699e-02f, -5.64236678e-02f, -2.53116697e-01f, 1.54644884e-02f,
  -8.35976526e-02f, -1.48537472e-01f, -1.28720673e-02f, 7.53224120e-02f, 2.62675256e-01f, -3.89525257e-02f, 2.36368105e-01f, 5.34888953e-02f, -1.05828248e-01f, 3.96349095e-02f,
  1.12915486e-01f, 2.54073478e-02f, 2.19366506e-01f, 7.57076442e-02f, -5.35141304e-03f, -2.17197016e-02f, 1.22540228e-01f, -9.41309482e-02f, 2.25770488e-01f, -3.81708853e-02f,
  1.12203108e-02f, -1.42962694e-01f, -5.49444109e-02f, -4.87460122e-02f, 1.15194835e-01f, 7.14657605e-02f, 8.14241916e-02f, -5.83238006e-02f, -4.08079363e-02f, 1.39068011e-02f,
  5.90243563e-03f, 7.12583028e-03f, -6.08694218e-02f, -5.84994145e-02f, 3.91986333e-02f, 3.72504368e-02f, 6.54339045e-02f, 5.44509962e-02f, -1.73301641e-02f, 3.86841558e-02f,
  -3.58711407e-02f, 2.53889281e-02f, 6.83591217e-02f, -2.14002691e-02f, 4.05545272e-02f, 6.19023889e-02f, 7.89085552e-02f, 5.17771840e-02f, -1.48838144e-02f, 3.93433794e-02f,
  -1.10625885e-02f, -4.60516624e-02f, 2.91779172e-02f, -1.65741593e-02f, -6.21811189e-02f, 3.68402414e-02f, -3.11875809e-02f, 5.13454080e-02f, -1.00856170e-01f, 6.10558316e-02f,
  -3.01073603e-02f, -1.06057720e-02f, -6.96449429e-02f, -1.83994789e-02f, 7.62131810e-02f, -9.65587571e-02f, -1.13457534e-02f, 3.36633176e-02f, 4.01689373e-02f, 6.56902418e-02f,
  -9.02099013e-02f, 2.81073339e-02f, 3.16018537e-02f, -1.32662803e-02f, 4.65947837e-02f, 2.28079651e-02f, 3.19779478e-02f, -1.26534309e-02f, -1.44982561e-02f, 7.41029391e-03f,
  1.67306960e-01f, -7.06003904e-02f, 4.91470508e-02f, -9.02208674e-04f, 5.04320189e-02f, -6.32912107e-03f, -6.76624700e-02f, -3.12002636e-02f, 4.00303006e-02f, 4.02838066e-02f,
  9.58244056e-02f, 3.21692117e-02f, 3.08579300e-02f, -1.78691186e-02f, -1.57850236e-02f, 1.04310416e-01f, 1.54336244e-02f, 4.72453125e-02f, -4.50943522e-02f, 7.57298991e-02f,
  7.86253437e-02f, -5.24815023e-02f, 1.25769954e-02f, 8.99968147e-02f, -4.29228954e-02f, -2.08767019e-02f, 3.76661494e-02f, 2.94113494e-02f, 8.09480622e-03f, 1.41709168e-02f,
  5.85260652e-02f, -1.96956798e-01f, -5.49519993e-02f, 4.24907729e-03f, 1.45070449e-01f, 1.85175732e-01f, 7.77918622e-02f, 2.07444038e-02f, 3.57161872e-02f, -2.27422073e-01f,
  -6.86757192e-02f, -5.50483055e-02f, 1.37965167e-02f, -1.03544220e-01f, 3.24178874e-01f, 1.43283397e-01f, -8.45391452e-02f, -1.45579372e-02f, 6.78536147e-02f, -4.35442105e-02f,
  4.46597822e-02f, -9.35078338e-02f, -1.05812587e-01f, -7.91186616e-02f, -2.04833850e-01f, -2.15225846e-01f, -8.18771124e-02f, 4.04206067e-02f, -1.41900703e-01f, 9.71582308e-02f,
  9.25012492e-03f, -1.80436447e-02f, -3.68072353e-02f, 6.67545721e-02f, -7.83436745e-02f, 4.06551026e-02f, -5.87625541e-02f, 2.47916542e-02f, -2.46619544e-04f, 6.79006577e-02f,
  9.19488538e-03f, 4.25926633e-02f, -4.90936376e-02f, 8.25486779e-02f, 6.99667959e-03f, 3.48569751e-02f, -9.58213508e-02f, -1.11754872e-01f, -1.75341386e-02f, -1.51224965e-02f,
  -4.89438847e-02f, -5.87895662e-02f, -6.39732704e-02f, -5.67944124e-02f, -3.79766189e-02f, 2.56768987e-02f, 9.31955501e-03f, 9.02824700e-02f, -6.11976907e-02f, 5.20072617e-02f,
  1.01846149e-02f, 7.39859650e-04f, -1.48705142e-02f, 4.03161421e-02f, -2.56955158e-02f, 2.85248384e-02f, -2.21302267e-02f, -3.63232307e-02f, -5.39980121e-02f, -8.34051799e-03f,
  -4.17772196e-02f, -6.95432499e-02f, -3.82327754e-03f, 3.78863141e-02f, -1.95818618e-02f, -2.82569323e-03f, 1.16663771e-02f, -5.26436344e-02f, 3.13571729e-02f, -6.56843707e-02f,
  4.32209633e-02f, 1.05971806e-01f, -2.80179568e-02f, -5.66626973e-02f, -2.12844387e-02f, -7.21763493e-03f, -7.20591694e-02f, -4.02836390e-02f, -1.17065990e-02f, 2.29501091e-02f,
  -6.68732300e-02f, 3.02052218e-02f, -3.28241754e-03f, -1.74192116e-02f, 2.75573768e-02f, 5.54786623e-02f, 6.47375733e-02f, -2.72936141e-03f, 7.91228563e-02f, 3.12738470e-03f,
  1.78228654e-02f, -7.10919350e-02f, 2.41409168e-02f, 1.03063313e-02f, 8.54597241e-02f, -3.52033228e-02f, 3.04794349e-02f, 4.92863543e-02f, -4.58201505e-02f, -1.12247365e-02f,
  -3.68593745e-02f, -1.29794162e-02f, 2.51358245e-02f, -2.47108005e-02f, -5.70940748e-02f, -1.00761451e-01f, -2.13706773e-02f, -7.30560422e-02f, 6.44062757e-02f, 6.64310902e-02f,
  2.10884720e-01f, -2.28929743e-01f, -1.42664269e-01f, -4.42095958e-02f, 1.32331729e-01f, -6.80603087e-02f, -1.07442640e-01f, -3.04233097e-03f, -4.24414016e-02f, -1.17918715e-01f,
  1.41648799e-01f, -2.35004090e-02f, -2.08031192e-01f, -4.79323827e-02f, -8.92183930e-02f, -2.91120589e-01f, -7.15558678e-02f, -6.56403601e-02f, -1.50966123e-02f, 2.53287293e-02f,
  7.26761892e-02f, 9.86804292e-02f, -8.52771997e-02f, 1.28187105e-01f, 7.15101436e-02f, 1.50447071e-01f, 1.01498939e-01f, 3.64958122e-02f, 8.99024308e-03f, 6.08628690e-02f,
  -1.03519097e-01f, 5.19966781e-02f, 4.19926196e-02f, -1.14246592e-01f, 6.28188103e-02f, 7.77710378e-02f, -1.04573794e-01f, 2.24822015e-02f, -1.75961629e-02f, 5.44346832e-02f,
  -7.61332437e-02f, 1.58385932e-02f, -3.46643887e-02f, -3.39847617e-02f, -3.87773998e-02f, 6.99627548e-02f, -4.33450937e-02f, 7.07658380e-03f, 4.39353362e-02f, -2.45268606e-02f,
  1.87118433e-03f, 1.30688604e-02f, -2.61007212e-02f, -2.16719471e-02f, -3.40398923e-02f, 5.92187718e-02f, 4.07658592e-02f, 2.65332740e-02f, -2.47584898e-02f, 2.34664399e-02f,
  2.89239846e-02f, -1.97081473e-02f, 2.67389752e-02f, -4.37746756e-02f, 4.70729619e-02f, -1.85740571e-02f, 1.90280043e-02f, 5.38954996e-02f, -5.45261130e-02f, -2.54710708e-02f,
  1.20828971e-02f, 7.07172379e-02f, 1.70999207e-03f, 4.13672738e-02f, -5.48366178e-03f, 6.55305907e-02f, -8.66721384e-03f, 4.82559577e-02f, 1.29004298e-02f, -4.35274065e-04f,
  -7.94074088e-02f, -3.36876400e-02f, -2.29724906e-02f, 8.17751214e-02f, 1.17233479e-02f, 5.09298444e-02f, 1.79119278e-02f, -5.88693321e-02f, 2.93329582e-02f, 2.20634118e-02f,
  -5.04393019e-02f, -1.16509289e-01f, -6.98881373e-02f, 5.40858805e-02f, 1.89256482e-02f, 3.22662331e-02f, -6.03841506e-02f, -4.89507131e-02f, -8.84297043e-02f, -6.01069331e-02f,
  6.07930534e-02f, -2.31291138e-04f, 5.91112189e-02f, -1.89348543e-03f, 1.12614855e-02f, -3.93996648e-02f, 7.41573274e-02f, -4.11989279e-02f, -4.57379445e-02f, 8.57714936e-02f,
  -1.03361877e-02f, 2.74441112e-02f, 4.24807109e-02f, -5.75946681e-02f, -2.33988445e-02f, 4.85355109e-02f, 3.32650878e-02f, 3.24020647e-02f, -3.91186476e-02f, -8.08233246e-02f,
  2.10594907e-01f, -1.04603730e-01f, -1.32974312e-01f, 8.39754120e-02f, 2.40772620e-01f, 1.09902591e-01f, 8.95422623e-02f, 1.13151126e-01f, -4.30833846e-02f, -7.47331306e-02f,
  7.95691088e-02f, -5.43477992e-03f, -1.71002015e-01f, 3.05486331e-03f, 7.13540167e-02f, -2.51922071e-01f, 1.42769694e-01f, 5.28260358e-02f, -1.08235136e-01f, 2.65523940e-01f,
  -6.36972636e-02f, 2.32318193e-01f, -1.42680615e-01f, 1.47950336e-01f, 1.84213459e-01f, 2.30597612e-02f, 5.74023388e-02f, -3.95353027e-02f, 1.09733760e-01f, 7.89203420e-02f,
  1.16124853e-01f, -5.37400208e-02f, 4.49512266e-02f, 1.46984784e-02f, 1.46814510e-01f, 5.74968122e-02f, -2.17160918e-02f, -6.43645003e-02f, 1.71563979e-02f, -3.59286331e-02f,
  -7.93784559e-02f, -6.31829631e-03f, -4.52040695e-02f, -3.47739533e-02f, 8.07726532e-02f, 4.33164835e-03f, -4.24008556e-02f, 4.22798768e-02f, -3.97666842e-02f, -8.74762759e-02f,
  -1.08231688e-02f, -9.40964464e-03f, 5.18551059e-02f, 3.07395011e-02f, -8.10680464e-02f, 6.62659034e-02f, 1.25337346e-02f, 5.46916761e-02f, 3.44103971e-03f, 7.62097016e-02f,
  -2.51147579e-02f, 6.30836189e-02f, -2.08969340e-02f, -8.84905551e-03f, 4.88144020e-03f, 2.11187638e-02f, -5.63181192e-02f, 1.35222087e-02f, -2.76558306e-02f, 8.01734105e-02f,
  3.94490808e-02f, -1.78392511e-02f, -5.57001457e-02f, 2.07023621e-02f, -1.36818904e-02f, -1.35522280e-02f, -1.01203537e-02f, 1.94225533e-04f, 4.01658937e-02f, -2.66015772e-02f,
  -1.26707386e-02f, 3.60288024e-02f, 4.45667543e-02f, 1.84393134e-02f, -3.36871371e-02f, -7.51974643e-04f, -4.37130220e-02f, 8.08503106e-03f, 2.08853520e-02f, -5.58345404e-04f,
  2.72136927e-01f, 1.19051322e-01f, -4.40160977e-03f, 1.69633869e-02f, -4.18851599e-02f, -3.10346968e-02f, -8.11797157e-02f, 4.09465060e-02f, -1.22878365e-02f, 9.74530075e-03f,
  1.00486256e-01f, -2.33705658e-02f, 1.13086209e-01f, -1.45390946e-02f, -1.96873397e-02f, 6.82990849e-02f, -4.70901653e-03f, 7.43442625e-02f, 4.86062802e-02f, 3.73520516e-02f,
  -1.70192253e-02f, 5.14359400e-02f, -9.94483680e-02f, 3.77387144e-02f, 6.04660772e-02f, -1.31735541e-02f, 5.45084812e-02f, -5.23703992e-02f, 4.10372624e-03f, -2.06708126e-02f,
  2.49719083e-01f, 1.48378342e-01f, 9.90430787e-02f, 7.49487057e-03f, -1.34714961e-01f, 1.52726591e-01f, -5.71500361e-02f, 7.36893415e-02f, 6.65104240e-02f, -9.50738695e-03f,
  -1.15109026e-01f, 2.29026377e-01f, -6.55050874e-02f, 1.14856616e-01f, 2.62901366e-01f, -2.53934469e-02f, 2.08869144e-01f, 9.48865041e-02f, 7.70090148e-03f, 1.92042023e-01f,
  1.47619080e-02f, 6.92492723e-03f, 3.80776934e-02f, -8.34147260e-02f, 1.53946718e-02f, -6.44955188e-02f, -1.68763369e-01f, -1.32186741e-01f, 1.92502346e-02f, 9.27227661e-02f,
  9.43668652e-03f, -2.38593221e-02f, 4.50419523e-02f, -6.29009958e-03f, 6.48686811e-02f, 2.10316442e-02f, 4.33864165e-03f, -2.10056752e-02f, -6.81018159e-02f, 1.45471357e-02f,
  -4.47382964e-02f, 7.58699980e-03f, 1.45993317e-02f, 1.77030861e-02f, -2.33995840e-02f, -3.09760068e-02f, 2.12017708e-02f, -7.69903883e-02f, -2.15653200e-02f, 1.16642058e-01f,
  3.25801745e-02f, 6.05938444e-03f, -6.05358295e-02f, 2.67486218e-02f, -1.29132485e-02f, -3.01551743e-04f, -1.55962864e-02f, 2.42419280e-02f, 2.22911965e-02f, 9.94106531e-02f,
  1.21956281e-01f, 5.92446364e-02f, -1.97194554e-02f, -7.42742345e-02f, 4.77580465e-02f, -7.15330765e-02f, -7.59208873e-02f, 3.36372666e-02f, -6.38780519e-02f, 5.36745153e-02f,
  -6.37980271e-03f, 2.10488718e-02f, -3.39571163e-02f, -3.29061188e-02f, 4.34588045e-02f, 3.97707336e-03f, 4.76022474e-02f, -2.22882982e-02f, 6.86657382e-03f, -2.79610604e-02f,
  -8.50479305e-02f, 2.30562873e-02f, -6.53603673e-02f, -1.23113830e-04f, -1.42445264e-03f, -5.94200455e-02f, 2.51537451e-04f, -1.89350452e-02f, -4.63948660e-02f, -6.33988976e-02f,
  1.47333384e-01f, 2.21732676e-01f, -4.02429998e-02f, 3.40642147e-02f, -6.86341226e-02f, 7.20330998e-02f, 2.70659942e-03f, 5.09555899e-02f, 9.64185596e-02f, 2.85883471e-02f,
  6.93379119e-02f, -2.88751740e-02f, 1.29038632e-01f, 6.87518110e-03f, -4.15986367e-02f, 8.18959597e-05f, -2.15679985e-02f, -2.49266475e-02f, 5.83518744e-02f, -3.22066527e-03f,
  -1.45291900e-02f, 4.45740521e-02f, 5.26468605e-02f, 8.46780092e-03f, -3.04455832e-02f, -2.33465526e-02f, 7.34453052e-02f, 2.54663136e-02f, 8.27495530e-02f, -6.30011037e-03f,
  6.52125403e-02f, 6.82383254e-02f, 8.29737857e-02f, -3.88536882e-03f, 1.41901700e-02f, 1.08038940e-01f, 1.46823600e-01f, -1.68969229e-01f, -5.41737936e-02f, -2.32460033e-02f,
  -6.61153495e-02f, 1.39280915e-01f, -1.09453142e-01f, -2.72023320e-01f, -1.90662846e-01f, -1.99925810e-01f, -2.71423291e-02f, -6.15398064e-02f, -1.73913732e-01f, -5.50885387e-02f,
  -8.25243071e-02f, -2.37195626e-01f, -1.40419155e-01f, -1.63504466e-01f, -5.30652553e-02f, 6.03997782e-02f, 1.81322719e-03f, -3.63721065e-02f, 6.50573056e-03f, -2.00336203e-02f,
  8.61659572e-02f, -1.05729103e-01f, -3.47056165e-02f, 4.40762332e-03f, -2.53118039e-03f, 9.90860686e-02f, 1.17604226e-01f, -4.66613695e-02f, 2.63343509e-02f, -4.93448526e-02f,
  4.91602439e-03f, -6.83154315e-02f, -8.11497197e-02f, 3.08365170e-02f, -1.45585164e-02f, -1.01484641e-01f, -5.96064217e-02f, 5.64268194e-02f, 1.20828636e-02f, -5.25760418e-03f,
  -7.27628693e-02f, 5.45892268e-02f, -6.86542094e-02f, 4.08869982e-02f, -1.09386295e-02f, 4.86445427e-02f, 4.21020873e-02f, 3.42085548e-02f, 2.64878385e-02f, -4.07498069e-02f,
  -8.20071772e-02f, 4.25175726e-02f, -3.67744896e-03f, -3.32189985e-02f, 3.47400568e-02f, 3.60288471e-02f, 2.57549342e-02f, 3.70288156e-02f, 6.29423633e-02f, -5.52974790e-02f,
  -1.83598213e-02f, -3.27783227e-02f, -1.30138295e-02f, 3.25707756e-02f, -3.02569102e-02f, 7.38335177e-02f, -1.22856814e-02f, 2.03868616e-02f, -1.51279243e-02f, 9.74512380e-03f,
  -6.32915571e-02f, -4.23608162e-03f, -2.83261687e-02f, -3.75515930e-02f, 4.35273051e-02f, -1.55342035e-02f, -5.51049113e-02f, 1.58641376e-02f, 7.53914639e-02f, 1.11762263e-01f,
  7.09987655e-02f, 6.76440680e-03f, -6.25528991e-02f, 1.07455522e-01f, 3.33443619e-02f, 4.30252310e-03f, 1.63895860e-02f, -1.41696911e-02f, 1.46197742e-02f, 1.57310590e-02f,
  1.06909290e-01f, 4.59779687e-02f, 1.08359873e-01f, 2.27289107e-02f, 4.54726480e-02f, -1.99457388e-02f, 1.05222456e-01f, 7.80083165e-02f, -1.78899076e-02f, -5.77365793e-02f,
  1.72914155e-02f, 3.24620642e-02f, 1.42787732e-02f, -4.38228399e-02f, 1.35695487e-02f, -2.98200734e-02f, 8.45244247e-03f, 5.89502603e-02f, -3.27923708e-02f, 3.69367674e-02f,
  2.76648432e-01f, -3.10695171e-01f, 2.56378472e-01f, 2.12952510e-01f, 2.00637549e-01f, 1.74913749e-01f, 1.62705407e-01f, 4.81423847e-02f, 6.84591681e-02f, -2.88533926e-01f,
  -1.02139011e-01f, 1.55185565e-01f, -2.15572551e-01f, -8.26948136e-02f, 5.15774675e-02f, -2.13338941e-01f, 1.55813829e-03f, -4.28856313e-02f, 5.65507673e-02f, 8.71883258e-02f,
  6.32012859e-02f, -9.90413725e-02f, 9.98201296e-02f, -1.27314880e-01f, 7.93044046e-02f, 5.14596067e-02f, -1.89145312e-01f, 9.75799263e-02f, -4.52336855e-02f, 2.78331563e-02f,
  -5.07586673e-02f, -6.64469004e-02f, 2.11271252e-02f, 1.18408583e-01f, 3.63793969e-02f, -2.40565222e-02f, -3.81021947e-02f, 8.31286656e-04f, 7.18894452e-02f, 4.63395119e-02f,
  -6.10219222e-03f, 8.25799927e-02f, 3.91399935e-02f, 4.21969481e-02f, 2.26752050e-02f, 9.50918645e-02f, 9.43237245e-02f, 5.40813692e-02f, 6.43831119e-02f, 8.88098329e-02f,
  8.48054439e-02f, -8.69133323e-03f, 4.99747507e-02f, -4.50076722e-03f, 6.63534328e-02f, -7.39306817e-03f, 5.87876216e-02f, -5.67670539e-03f, 2.91604735e-02f, 5.30499555e-02f,
  -9.93810371e-02f, -2.97997203e-02f, -3.59762497e-02f, 1.32938419e-02f, -1.75089967e-02f, 2.60713287e-02f, -1.66213978e-02f, -3.95397730e-02f, 1.38902785e-02f, -4.99459915e-02f,
  5.10242209e-02f, -3.14390287e-02f, -1.58728454e-02f, 1.33433128e-02f, -1.41429538e-02f, -2.93418448e-02f, 4.94354917e-03f, -1.65413432e-02f, 3.52171585e-02f, 1.48834847e-02f,
  2.91776713e-02f, 6.03115559e-02f, -4.83540520e-02f, 7.89170191e-02f, 3.31037268e-02f, 3.14675607e-02f, 8.80475808e-03f, 7.10907727e-02f, -4.98810783e-03f, 3.82040292e-02f,
  -1.50232419e-01f, -1.68173566e-01f, -6.74171373e-02f, 4.57896851e-02f, -7.39544109e-02f, -5.60565367e-02f, 2.74640359e-02f, -2.61961436e-03f, -9.50828716e-02f, 4.65028323e-02f,
  5.21231368e-02f, 4.37576957e-02f, 3.14374687e-03f, -1.95821766e-02f, -4.51373532e-02f, -7.34334812e-02f, -3.40193398e-02f, -5.09581938e-02f, -3.39055434e-03f, -9.15265605e-02f,
  -2.27645990e-02f, 2.01681536e-02f, 3.97198126e-02f, -4.61833924e-03f, -5.61964363e-02f, 3.68057191e-02f, -4.10361551e-02f, -1.47339730e-02f, -6.28363490e-02f, -4.35822085e-02f,
  -1.91398844e-01f, 3.38673413e-01f, 5.24028726e-02f, 2.11710408e-02f, 5.01736142e-02f, -6.37818202e-02f, 2.24601831e-02f, 1.84511676e-01f, 8.27552006e-02f, 7.37553760e-02f,
  1.91865906e-01f, -1.88800737e-01f, 1.60608426e-01f, 2.18919247e-01f, -7.45214298e-02f, 7.64779076e-02f, 3.94666567e-02f, -3.70637588e-02f, 1.25842750e-01f, 1.64828360e-01f,
  4.73956093e-02f, 2.53585696e-01f, 9.63894948e-02f, 2.12030128e-01f, 8.52036551e-02f, -2.23539080e-02f, 8.26992188e-03f, -7.83753674e-03f, -4.28922363e-02f, -3.74872759e-02f,
  6.00656383e-02f, 1.45037815e-01f, 3.34766954e-02f, -5.88376857e-02f, -1.74867082e-03f, -8.98103565e-02f, -6.49571866e-02f, -7.74316723e-03f, 5.94607182e-03f, 7.63699040e-02f,
  -1.25731021e-01f, -2.92110331e-02f, -4.77208756e-02f, 4.23124321e-02f, 2.89476775e-02f, -2.36807968e-02f, 2.05675848e-02f, -7.07430020e-02f, -1.88931497e-03f, 2.41646208e-02f,
  -3.61367874e-02f, -5.47276624e-02f, -3.49058807e-02f, -5.22213103e-03f, 7.08594825e-03f, -2.67711915e-02f, -5.34108728e-02f, -6.76436275e-02f, -4.62764949e-02f, 6.61316328e-03f,
  -9.71048698e-02f, -3.57674137e-02f, 1.74460765e-02f, 2.44828947e-02f, 5.25752432e-04f, 5.04070595e-02f, -4.28899974e-02f, 6.80751204e-02f, -6.44331798e-02f, 4.27637920e-02f,
  2.61970535e-02f, 3.59284654e-02f, 6.23725913e-03f, -3.81595492e-02f, -1.39481016e-03f, -3.81492227e-02f, 5.47811273e-04f, 2.99566500e-02f, -1.51093965e-02f, 3.33199129e-02f,
  5.49669303e-02f, -1.27903242e-02f, 2.49116067e-02f, -5.97817190e-02f, -9.86924674e-03f, -2.82040406e-02f, 3.30175310e-02f, -6.44969568e-03f, -9.26484354e-03f, 1.02714533e-02f,
  -2.33865175e-02f, 9.85597000e-02f, -2.82080136e-02f, -7.48173073e-02f, -4.62119691e-02f, 1.03140799e-02f, -5.00686765e-02f, 5.63965850e-02f, -5.59109412e-02f, 1.79820731e-02f,
  -3.97025794e-02f, 2.16660071e-02f, 6.64732978e-03f, 1.86355636e-02f, -8.05223435e-02f, 4.55006957e-03f, 3.55766565e-02f, 2.44322773e-02f, -8.05794001e-02f, -4.10670191e-02f,
  6.23922646e-02f, 5.26824631e-02f, 1.17024379e-02f, -2.98916758e-03f, -3.89368273e-02f, 2.94214357e-02f, -6.82604909e-02f, 1.87681392e-02f, -6.46722037e-04f, -7.66661093e-02f,
  2.45761856e-01f, 9.80539247e-02f, 2.27064669e-01f, 3.04382384e-01f, -4.70135920e-02f, -2.13312402e-01f, -1.06505655e-01f, 1.65467724e-01f, 4.60236639e-01f, -1.64976701e-01f,
  -2.10487455e-01f, 2.66339406e-02f, -8.77031162e-02f, 7.27856299e-03f, 1.21070057e-01f, 1.36953164e-02f, -3.47540826e-02f, -4.23269644e-02f, 1.46307260e-01f, 5.27237803e-02f,
  1.39350429e-01f, -2.61986911e-01f, -5.35022765e-02f, -9.90165398e-02f, -5.70790283e-02f, 1.45421103e-01f, -1.44460291e-01f, -5.67835756e-02f, -1.70466840e-01f, -9.63823274e-02f,
  3.79349664e-03f, 1.67295486e-01f, 9.29968655e-02f, -1.01042408e-02f, -4.99435328e-02f, -9.35232788e-02f, -5.89199848e-02f, -9.47845951e-02f, 4.85314578e-02f, 3.16349715e-02f,
  5.47714811e-03f, 1.78216826e-02f, 4.97623272e-02f, -2.66888235e-02f, 1.17089823e-01f, 9.34762061e-02f, 3.91642004e-02f, -4.40202624e-04f, 9.93934926e-03f, 1.84204131e-02f,
  7.14218169e-02f, -4.41766307e-02f, 6.32047653e-02f, 4.20983061e-02f, 8.61600786e-02f, 5.87262698e-02f, -5.38753755e-02f, -3.88266752e-03f, -4.15318795e-02f, 2.88709123e-02f,
  -2.60362332e-03f, 3.14039737e-02f, -2.25273632e-02f, 3.90615314e-02f, -2.06012148e-02f, 1.64751038e-02f, 2.31299046e-02f, -5.88350790e-03f, -4.45719855e-03f, -1.36246122e-02f,
  5.23569882e-02f, -1.19383996e-02f, 5.82464263e-02f, 1.45964762e-02f, 2.08448973e-02f, -3.40731144e-02f, -6.48958934e-03f, -2.00412367e-02f, 5.81362620e-02f, -5.69231026e-02f,
  2.85334084e-02f, -2.36187484e-02f, -3.07601783e-02f, -6.28647953e-02f, 1.38360560e-02f, 1.16918664e-02f, 7.67297484e-03f, 1.65718775e-02f, 1.21541740e-02f, -9.16582793e-02f,
  2.41414774e-02f, 4.70323535e-03f, 1.80442315e-02f, 9.69148614e-03f, -1.60482358e-02f, -4.50673280e-03f, 2.20259223e-02f, 4.92452993e-04f, -1.84382200e-02f, 1.62326507e-02f,
  -6.50414219e-03f, -3.82023640e-02f, -1.57582406e-02f, -5.22466674e-02f, 3.67480293e-02f, -6.29326180e-02f, -7.14930240e-03f, 3.44553776e-02f, -4.94756326e-02f, 8.70942604e-03f,
  -5.73317744e-02f, -8.67440365e-04f, 2.56584790e-02f, -2.15852503e-02f, -5.37581258e-02f, -6.90112263e-02f, 6.75710887e-02f, 1.97186377e-02f, 8.31210054e-03f, 8.72517191e-03f,
  -4.82471101e-02f, 1.35341018e-01f, -1.06061220e-01f, -9.47277248e-02f, -2.50618249e-01f, -3.05790275e-01f, -3.13574433e-01f, -1.25278100e-01f, -2.18332171e-01f, 2.79332221e-01f,
  -1.61853526e-02f, 9.05049741e-02f, 2.02955127e-01f, -1.40300348e-01f, -3.59685451e-01f, -4.77928743e-02f, -2.63637543e-01f, -7.84011930e-02f, -1.17032170e-01f, 5.10992520e-02f,
  -7.41662532e-02f, -6.37743548e-02f, 5.93521632e-03f, 1.16386242e-01f, -3.01056243e-02f, 1.18322179e-01f, 1.16789944e-01f, -4.46402356e-02f, 2.15608589e-02f, -6.23953268e-02f,
  -6.22583441e-02f, 9.08398479e-02f, 3.47823626e-03f, -1.86910648e-02f, -3.37883048e-02f, 6.32529184e-02f, 1.03506744e-02f, -6.57447353e-02f, -5.17601613e-03f, 3.20272297e-02f,
  4.41934019e-02f, 2.80807838e-02f, 6.44884706e-02f, -6.90772524e-03f, -5.69490045e-02f, 5.28044328e-02f, 2.31180564e-02f, -1.13289636e-02f, -2.77457479e-03f, -4.26716395e-02f,
  2.20171325e-02f, -2.58997101e-02f, 3.08271404e-02f, 3.78477722e-02f, -6.31247312e-02f, -1.92411356e-02f, -2.39423965e-03f, -6.66743377e-03f, 3.01335263e-03f, -6.60394207e-02f,
  -1.32504269e-03f, -9.76362377e-02f, 3.83628942e-02f, -1.23528354e-02f, -4.73709889e-02f, 6.51513785e-02f, 5.28014591e-03f, 2.04212926e-02f, 2.95442389e-03f, 1.30301816e-02f,
  -1.68456901e-02f, 2.75790808e-03f, -1.53308753e-02f, 5.97873656e-03f, 5.29285856e-02f, 2.63606403e-02f, -1.50684798e-02f, -2.98864134e-02f, 2.99463328e-02f, -7.37155154e-02f,
  4.95813787e-02f, -7.03308955e-02f, -4.09597345e-03f, 5.77915013e-02f, -2.62647159e-02f, -3.81722599e-02f, 8.23655799e-02f, 2.70963516e-02f, 2.27049217e-02f, -6.90697432e-02f,
  -1.10461526e-01f, -3.59610431e-02f, 6.52495818e-03f, 2.71012485e-02f, -4.61609885e-02f, -6.15144148e-02f, -5.30665591e-02f, -2.32941471e-02f, -7.59165585e-02f, 1.91201910e-03f,
  2.30323547e-03f, -5.20587005e-02f, -7.92158581e-03f, -4.26243208e-02f, 2.36805007e-02f, 3.04472586e-03f, 1.15183359e-02f, 1.01873577e-02f, 2.40784865e-02f, 5.28504141e-02f,
  2.86472514e-02f, 6.45737723e-02f, 2.23526713e-02f, 1.15543259e-02f, 5.92112318e-02f, 3.75892483e-02f, 2.31787208e-02f, -7.55705358e-03f, -9.63905826e-03f, 1.11626294e-02f,
  9.97350067e-02f, 5.30929193e-02f, 1.55085146e-01f, 1.08541315e-02f, 1.00238249e-01f, -2.15372257e-02f, -1.31946176e-01f, 5.67627959e-02f, 1.41523793e-01f, -2.24015042e-01f,
  -2.07533374e-01f, 7.08038285e-02f, 8.13965648e-02f, -1.82841614e-01f, 1.27246473e-02f, 1.68436915e-01f, -1.40443876e-01f, -1.73906773e-01f, 8.24018493e-02f, -1.41248062e-01f,
  7.88639784e-02f, -2.63020456e-01f, -1.60812922e-02f, -7.84486234e-02f, -5.90836480e-02f, 3.26000527e-02f, -1.31595626e-01f, 9.33809057e-02f, -1.55836731e-01f, -6.53574616e-02f,
  8.19202419e-03f, 6.85063824e-02f, -5.59647605e-02f, -3.25910933e-02f, -7.32288212e-02f, 8.26936308e-03f, 2.87620239e-02f, 4.22194228e-02f, 1.05711378e-01f, -2.78283078e-02f,
  -1.82202796e-03f, 8.13916177e-02f, 1.10968472e-02f, 9.86840352e-02f, 8.02762806e-02f, -2.17766315e-02f, -3.23922783e-02f, 3.93240452e-02f, 4.52296808e-02f, 1.94478277e-02f,
  2.75109205e-02f, -7.12684542e-02f, -2.31187977e-02f, -6.80740625e-02f, 6.04461320e-02f, -1.14858802e-02f, 2.30471231e-02f, -3.87734622e-02f, 1.40789934e-02f, 7.90294334e-02f,
  -5.02894595e-02f, -3.26000713e-03f, 4.22289297e-02f, -2.50184592e-02f, -3.62513997e-02f, -3.31109427e-02f, -1.98918954e-02f, -4.81700189e-02f, 2.07152274e-02f, -2.63479501e-02f,
  -2.10318458e-03f, -5.66686541e-02f, -7.44068548e-02f, 6.32323623e-02f, -4.34103049e-02f, -4.17305417e-02f, -7.55558684e-02f, -4.31220308e-02f, -6.28472194e-02f, 3.10660154e-02f,
  -8.52071568e-02f, 4.51488420e-02f, 6.68445975e-02f, -5.04937693e-02f, -5.14202453e-02f, -3.55088823e-02f, 1.86086614e-02f, 6.72289655e-02f, -2.90571991e-03f, -2.75947824e-02f,
  -6.62606955e-02f, -9.18333512e-03f, 8.90344605e-02f, 5.44337071e-02f, -6.05565161e-02f, -6.24390990e-02f, 3.03921103e-02f, 6.27741665e-02f, -1.25547750e-02f, -4.31176350e-02f,
  -7.34473467e-02f, 1.70345753e-02f, -5.63993230e-02f, -4.09225449e-02f, -2.18654163e-02f, 6.94201216e-02f, 1.15306890e-02f, 4.70155776e-02f, -1.26447603e-02f, -4.35124673e-02f,
  1.01821320e-02f, -2.80323010e-02f, -2.74628177e-02f, -5.96803706e-03f, -4.27351147e-02f, 1.44046387e-02f, 5.73232211e-02f, 5.73790707e-02f, -2.73251981e-02f, 5.20280525e-02f,
  2.38619611e-01f, 3.10137402e-02f, 2.57290810e-01f, 8.32416341e-02f, -1.33132100e-01f, 1.31656304e-01f, 1.70101061e-01f, -8.31005573e-02f, 2.51574367e-01f, -6.10193200e-02f,
  -7.04788864e-02f, 1.96507424e-01f, -8.28691721e-02f, 7.59530440e-02f, -7.72314966e-02f, 8.13523382e-02f, -2.24575214e-02f, 1.25797421e-01f, 5.17432801e-02f, 1.19928261e-02f,
  -2.96629388e-02f, -1.32896006e-01f, -5.21929525e-02f, -2.13807002e-01f, 4.92078774e-02f, -7.01406896e-02f, -3.32705259e-01f, -9.94906761e-03f, -3.94275226e-02f, -1.75482426e-02f,
  4.67412621e-02f, 8.54064897e-02f, 1.40858710e-01f, 2.93363165e-02f, 4.66087535e-02f, 1.39527312e-02f, -2.04360094e-02f, 1.67223923e-02f, 3.76078882e-03f, 7.59451911e-02f,
  -5.82805253e-04f, 3.27104256e-02f, 8.83864909e-02f, -6.32657409e-02f, 5.87657094e-04f, 4.69145365e-02f, 9.91409197e-02f, 4.20900770e-02f, 6.91820979e-02f, 5.29240519e-02f,
  1.69919170e-02f, 4.44159051e-03f, -2.16599437e-03f, 6.91374689e-02f, 9.59484577e-02f, 2.28244234e-02f, -2.96761468e-03f, 2.51524691e-02f, 1.41599085e-02f, -7.44463503e-03f,
  -5.12748435e-02f, -5.22496328e-02f, -4.40689921e-02f, 3.03832870e-02f, -5.31552918e-02f, 3.51345763e-02f, -3.55818681e-02f, 3.67232561e-02f, -1.13713359e-02f, -7.00208470e-02f,
  4.81181145e-02f, -3.33894719e-03f, 5.81568182e-02f, -5.60198054e-02f, -3.31925862e-02f, -1.49774598e-02f, -3.55228446e-02f, 5.79408146e-02f, -1.29846740e-03f, -6.69476762e-02f,
  -4.61018533e-02f, -7.75078386e-02f, -8.74233607e-04f, -1.51819484e-02f, -5.13961315e-02f, -8.47388804e-03f, -4.02570218e-02f, 7.45798275e-03f, -1.46210194e-03f, -8.62466618e-02f,
  -8.86887126e-03f, -1.23637818e-01f, 5.40419901e-03f, -2.59078648e-02f, -4.49289121e-02f, 2.95955800e-02f, -3.56324166e-02f, -1.21151563e-02f, 6.08593618e-05f, -2.52146609e-02f,
  -8.79263654e-02f, -5.37481643e-02f, 1.98750515e-02f, 4.24619429e-02f, -2.64732279e-02f, -4.76481654e-02f, -8.42699185e-02f, -3.12486049e-02f, -7.40707889e-02f, -3.77322845e-02f,
  -3.82752754e-02f, -1.69779267e-02f, -7.99227282e-02f, -1.13426810e-02f, -7.19727948e-02f, -3.66517417e-02f, -6.01615990e-03f, 6.65547028e-02f, -6.47068620e-02f, -2.32414082e-02f,
  2.38415480e-01f, 1.14909805e-01f, -9.12622288e-02f, 1.86929002e-01f, 1.08351566e-01f, -8.66102651e-02f, -5.69298938e-02f, 1.27999082e-01f, 1.81160808e-01f, -2.40715612e-02f,
  8.67021754e-02f, -5.15089929e-03f, -1.37441590e-01f, 2.34063819e-01f, -8.41660798e-02f, -9.76032242e-02f, 1.14167079e-01f, 3.93002667e-02f, 8.26911628e-02f, -4.91011068e-02f,
  3.00551932e-02f, 1.56817853e-01f, 1.23439077e-02f, 1.08091623e-01f, 5.97153604e-02f, 3.89802977e-02f, -1.75039083e-01f, -1.92106918e-01f, 1.03032865e-01f, 2.30700634e-02f,
  1.31437123e-01f, 1.85465291e-02f, 7.70761073e-02f, 9.21278149e-02f, -3.95681262e-02f, 1.90205276e-02f, -9.53970104e-02f, 1.03501333e-02f, 6.07904308e-02f, -7.11698756e-02f,
  -6.48105219e-02f, -2.11376771e-02f, 8.95883739e-02f, 1.56587884e-02f, 3.52329798e-02f, 8.56715068e-02f, -1.60774887e-02f, 6.40592352e-02f, 3.94087797e-03f, 3.51687633e-02f,
  5.86630367e-02f, -4.97715883e-02f, 7.81395845e-03f, -8.16964358e-02f, -7.34234750e-02f, -3.74144241e-02f, 2.16724724e-03f, -1.77534912e-02f, -3.12523134e-02f, -4.38470282e-02f,
  -4.16112468e-02f, -6.20211214e-02f, 1.78522477e-03f, 8.69405419e-02f, 5.56924790e-02f, -1.25239994e-02f, 6.06834441e-02f, -4.43690680e-02f, -4.20228839e-02f, -7.53632560e-02f,
  -1.49856536e-02f, -2.89028455e-02f, 7.54965991e-02f, -1.78796146e-02f, -1.45243471e-02f, -2.02387981e-02f, 3.23510952e-02f, -2.32849885e-02f, -1.81425754e-02f, 5.65915629e-02f,
  4.67321426e-02f, -2.97010634e-02f, -8.30626488e-03f, 3.13658081e-02f, 2.78420001e-02f, -4.57875319e-02f, -3.32528651e-02f, 7.09095132e-03f, 5.27015775e-02f, -3.35188881e-02f,
  -1.38168097e-01f, -1.72040582e-01f, 1.39559209e-02f, 8.17614943e-02f, -6.02050349e-02f, 1.73696596e-02f, -2.57663596e-02f, 1.85213145e-02f, -3.73301804e-02f, 6.00683736e-03f,
  4.11139950e-02f, 3.78773026e-02f, -9.86996293e-02f, 4.61432291e-03f, -6.11464307e-03f, -2.45031100e-02f, -3.78044471e-02f, -5.03851622e-02f, -8.14644769e-02f, -2.83914879e-02f,
  -8.06989372e-02f, -2.77116746e-02f, -4.76387367e-02f, 3.81128341e-02f, -4.52934541e-02f, -6.84694992e-03f, 1.71626341e-02f, -6.87829554e-02f, -5.39565124e-02f, -1.11954268e-02f,
  -1.79868579e-01f, -2.88061202e-01f, -3.00550729e-01f, -3.63391370e-01f, 2.22275317e-01f, -4.86171655e-02f, -1.66064978e-01f, 2.13687168e-03f, -2.09435999e-01f, -1.06893927e-01f,
  1.44832104e-01f, -2.69107968e-01f, 9.36936180e-04f, -1.58092946e-01f, 7.75018036e-02f, 2.12304574e-02f, -1.51087403e-01f, -1.03824876e-01f, -5.39488457e-02f, -1.73778445e-01f,
  3.71084083e-03f, 1.08662069e-01f, -1.79799628e-02f, 9.41920057e-02f, -1.06635742e-01f, -1.39479429e-01f, 1.46439120e-01f, 5.54995760e-02f, 5.65091185e-02f, 1.42864928e-01f,
  2.16908325e-02f, -3.91392969e-02f, -9.88435745e-02f, 3.41691002e-02f, -3.23417969e-02f, -6.55765459e-02f, 8.77312757e-03f, 1.49949919e-02f, 3.71315666e-02f, 1.78159196e-02f,
  -6.42378926e-02f, 8.66566449e-02f, -3.17006335e-02f, 1.28542231e-02f, -5.45854606e-02f, -5.11936396e-02f, 6.21876083e-02f, 4.08484787e-02f, -8.86402205e-02f, -1.96377095e-02f,
  -8.08149800e-02f, -3.25748101e-02f, -2.97253858e-02f, -1.66774318e-02f, -3.44252624e-02f, 7.79129798e-03f, -6.61793426e-02f, 2.56360061e-02f, 3.63868065e-02f, -4.02856013e-03f,
  -7.50831235e-03f, 1.37153612e-02f, 2.65245754e-02f, 2.31769513e-02f, 2.70484146e-02f, 3.50152515e-02f, -4.65788357e-02f, 3.52526270e-02f, -4.40579951e-02f, 3.29800807e-02f,
  -4.33132797e-02f, -1.39499875e-03f, 7.14770332e-02f, -1.03617303e-01f, -5.60866706e-02f, -4.45635356e-02f, -1.03522167e-02f, -2.55700834e-02f, -1.32458156e-03f, -6.59691496e-03f,
  -4.25430238e-02f, 6.41914383e-02f, 2.47765915e-03f, -1.44264335e-02f, 7.70863891e-03f, 6.29924312e-02f, 1.79036614e-02f, -2.95900516e-02f, 2.87808967e-03f, -1.01982253e-02f,
  -3.62318233e-02f, -1.51362315e-01f, -4.10409681e-02f, 2.04817671e-02f, -5.18602654e-02f, 9.82645825e-02f, 1.70957614e-02f, -1.15116760e-02f, -2.03505177e-02f, -1.71104185e-02f,
  7.16047594e-03f, -1.10068083e-01f, 5.40849715e-02f, 1.73117202e-02f, 4.31900993e-02f, 7.30908141e-02f, -5.66984266e-02f, -6.73484877e-02f, -5.51333325e-03f, -4.02331818e-03f,
  -9.50955134e-03f, 3.89645086e-03f, 1.69527736e-02f, 4.55304570e-02f, 3.97869945e-02f, 5.32654524e-02f, -1.60257239e-02f, -5.97063787e-02f, 1.21971695e-02f, -1.01556465e-01f,
  6.44470006e-02f, -9.58399177e-02f, -1.49940290e-02f, 1.70186773e-01f, -1.83783293e-01f, 7.43753761e-02f, 2.60275215e-01f, -1.75900996e-01f, -2.18108058e-01f, 9.74358469e-02f,
  8.36644694e-02f, 8.18595737e-02f, -2.94553954e-02f, 1.92578509e-01f, 1.98996305e-01f, 3.41533236e-02f, 9.72992256e-02f, 1.11892775e-01f, -1.58411860e-01f, 1.20186776e-01f,
  -2.42893919e-02f, 1.30297601e-01f, 2.82461606e-02f, -9.08638164e-02f, 6.50210902e-02f, 3.08938771e-02f, 1.84671074e-01f, 2.95587629e-02f, 1.80210873e-01f, -1.69437062e-02f,
  -2.77873091e-02f, -5.52810468e-02f, 7.89263844e-02f, -7.54553378e-02f, -2.27585938e-02f, 2.82971971e-02f, 1.07918993e-01f, 6.66284189e-02f, -4.02014097e-03f, 4.61299019e-03f,
  8.86518508e-02f, -1.55160890e-03f, -5.36691248e-02f, -1.79365911e-02f, -6.78865984e-02f, -1.88658722e-02f, -4.63735834e-02f, 8.24207719e-03f, -5.33530954e-03f, -9.80040282e-02f,
  1.99941103e-03f, -3.68101858e-02f, 5.44002056e-02f, 6.19388856e-02f, -5.76219670e-02f, -3.73432189e-02f, 3.03776618e-02f, 1.14964485e-01f, -3.80226336e-02f, -8.51606354e-02f,
  -1.35227554e-02f, 5.82799204e-02f, 2.51717605e-02f, 6.40972424e-03f, 2.40162387e-02f, 1.87066011e-02f, 3.74737643e-02f, -3.33241932e-03f, -7.30447024e-02f, 7.67557174e-02f,
  4.89580166e-03f, 8.38351995e-03f, 4.06502932e-03f, 4.73746061e-02f, 5.60875498e-02f, -1.04954548e-03f, 6.90075532e-02f, -2.17631683e-02f, 8.46572816e-02f, 1.02415252e-02f,
  2.20410023e-02f, -3.83211114e-02f, 5.86178415e-02f, -2.64263898e-02f, -4.04478200e-02f, 1.21020544e-02f, 2.71435287e-02f, -7.05305301e-03f, 6.05301969e-02f, 1.43587198e-02f,
  -3.11971772e-02f, 5.53447530e-02f, -6.14506751e-02f, -2.53891503e-03f, 4.16790950e-04f, -9.44293290e-03f, 2.58152466e-02f, -7.17666969e-02f, 5.50854765e-02f, -5.67453019e-02f,
  5.18539287e-02f, 7.94911608e-02f, 1.73070841e-02f, -4.98010851e-02f, 1.09868236e-01f, 1.01283547e-02f, 4.71760035e-02f, 5.03645502e-02f, 3.56765129e-02f, 1.04572261e-02f,
  7.22374618e-02f, 2.81400792e-02f, 2.64805388e-02f, -6.71304464e-02f, 5.16264997e-02f, 9.49615389e-02f, 1.82798924e-03f, -2.61233039e-02f, 4.50288020e-02f, 3.23788412e-02f,
  2.12023214e-01f, -2.95618057e-01f, -7.30167255e-02f, -1.98163897e-01f, 1.38196126e-01f, 1.00016594e-01f, -6.24630749e-02f, -1.04483388e-01f, -1.43563703e-01f, -2.36066818e-01f,
  -3.18896696e-02f, -1.77084982e-01f, -6.71203956e-02f, -9.10574496e-02f, 2.32743248e-01f, -1.76837575e-02f, -3.21654230e-02f, -1.03234826e-02f, -7.59311765e-02f, -4.21816297e-02f,
  8.15509483e-02f, 2.24095536e-03f, 8.68015587e-02f, 5.06446585e-02f, 6.10465296e-02f, -1.48303360e-01f, 8.48547593e-02f, 5.44201881e-02f, -1.01619042e-01f, 3.01329587e-02f,
  1.06217928e-01f, -5.43687791e-02f, -8.62641446e-03f, -5.11658378e-03f, 6.95980191e-02f, 8.00417960e-02f, 6.17058612e-02f, 1.00199006e-01f, 3.46264243e-02f, -8.38635489e-02f,
  -4.84202430e-02f, 2.04389039e-02f, -9.67055783e-02f, 3.57539766e-02f, -1.29721612e-02f, -2.90827285e-02f, 4.16631885e-02f, 1.45109219e-03f, -8.46668780e-02f, 8.36035162e-02f,
  -3.48104257e-03f, -1.47517985e-02f, 3.32916640e-02f, 3.66141349e-02f, 5.39032519e-02f, 4.12892923e-02f, -6.88781664e-02f, 7.18232337e-03f, -1.04661569e-01f, -4.70709465e-02f,
  -1.60746407e-02f, 3.80146652e-02f, -5.99108972e-02f, 4.04283591e-02f, 8.33952241e-03f, -2.17276141e-02f, 5.25248051e-02f, -4.57944945e-02f, -6.92561828e-03f, 4.28406596e-02f,
  -4.10063863e-02f, -4.97430936e-02f, 4.40895446e-02f, -3.07269543e-02f, 6.58727437e-02f, -2.00306065e-03f, 3.94464396e-02f, 1.63386925e-03f, 3.56945805e-02f, 6.91384135e-04f,
  2.52031032e-02f, -1.84185840e-02f, -9.74547416e-02f, 2.73527820e-02f, -3.97622399e-02f, -4.04426940e-02f, -5.37046939e-02f, 7.39767076e-03f, -3.60645801e-02f, 3.71947587e-02f,
  -1.46190405e-01f, -1.76716298e-01f, -3.60556468e-02f, -7.87013173e-02f, -9.17151868e-02f, 1.41529506e-02f, -2.25616852e-03f, -9.07073170e-03f, -7.60150179e-02f, -2.75050439e-02f,
  8.94895103e-03f, 3.86100188e-02f, 5.69740720e-02f, -4.19271700e-02f, 1.72726030e-03f, -6.77904114e-02f, -7.68560171e-02f, -5.88015318e-02f, 5.57779111e-02f, 1.33136231e-02f,
  -6.83163181e-02f, -7.50265568e-02f, -2.59557813e-02f, -5.01862615e-02f, -6.89530447e-02f, -4.14764881e-02f, 1.80368274e-02f, -5.91260232e-02f, 8.96412581e-02f, 1.77751891e-02f,
  -3.46289314e-02f, 4.15307656e-02f, 1.83086306e-01f, -2.28089973e-01f, -5.79511300e-02f, -7.06768706e-02f, -4.68164347e-02f, -7.82251731e-02f, -1.37328699e-01f, -1.20498501e-01f,
  -7.45052025e-02f, 1.37316182e-01f, 1.61267146e-01f, -1.64571121e-01f, 2.98339296e-02f, 8.32916722e-02f, -2.85426497e-01f, -1.19318083e-01f, 9.45931599e-02f, -9.70969498e-02f,
  -1.34920120e-01f, -1.57610252e-01f, 3.97487776e-04f, -5.06271347e-02f, -1.05751216e-01f, 3.59774381e-03f, 1.57173872e-02f, 6.01124614e-02f, -6.45600855e-02f, 5.94683364e-02f,
  1.18663278e-03f, -4.43156138e-02f, -6.21613935e-02f, 4.46535423e-02f, 2.09700856e-02f, -4.39720266e-02f, -7.53729269e-02f, 3.81724462e-02f, 5.50669283e-02f, -2.79920152e-03f,
  -4.26203199e-02f, -6.21023402e-03f, -9.47109163e-02f, -4.01950106e-02f, -3.32644619e-02f, -1.79349948e-02f, 7.55784437e-02f, 4.01185872e-03f, -3.17726284e-02f, 5.23643233e-02f,
  -8.23704712e-03f, 4.92062941e-02f, 2.18124837e-02f, 5.63431010e-02f, 4.27973308e-02f, 6.33511180e-03f, 2.30338890e-02f, 8.53018016e-02f, 3.04122586e-02f, -2.24463176e-02f,
  1.00729708e-02f, -5.82337454e-02f, -3.60592529e-02f, 4.13378626e-02f, 1.55010177e-02f, -1.43397488e-02f, 4.71350364e-02f, 5.01765087e-02f, 7.80180283e-03f, 3.62289771e-02f,
  -1.98591128e-02f, 1.32828113e-02f, -7.98595175e-02f, 6.24794886e-03f, -7.66541958e-02f, 3.65491658e-02f, 1.66797899e-02f, -3.12740845e-03f, -1.13839488e-02f, 4.09580171e-02f,
  4.05489132e-02f, 3.32707018e-02f, 6.42387476e-03f, -6.30903915e-02f, 6.15912266e-02f, -8.56586359e-03f, -3.24216820e-02f, 1.58713181e-02f, -2.09991243e-02f, 1.15857692e-02f,
  -4.10372540e-02f, -8.20154026e-02f, 4.09532413e-02f, 2.38239318e-02f, 4.42883074e-02f, 1.13673573e-02f, -4.02566530e-02f, 3.91447879e-02f, -7.62046129e-02f, -6.54546719e-04f,
  4.81790826e-02f, -2.95056514e-02f, -4.12742794e-02f, 3.93017121e-02f, 1.57443271e-03f, -8.48375410e-02f, -3.88327725e-02f, -5.33096232e-02f, -8.17091856e-03f, -1.15711195e-02f,
  -5.64374253e-02f, -2.15929449e-02f, 4.25448939e-02f, -3.79977934e-02f, -5.73773906e-02f, -4.76917513e-02f, 5.50286695e-02f, 5.37317470e-02f, -1.37288366e-02f, 3.46070789e-02f,
  -3.20639104e-01f, 3.33392136e-02f, 2.65779406e-01f, -1.54242322e-01f, -9.74881575e-02f, -6.08161129e-02f, 1.20074138e-01f, -1.27721027e-01f, -2.49199972e-01f, -3.04435268e-02f,
  3.71760614e-02f, 5.51468916e-02f, 2.32391357e-01f, 1.47380307e-01f, 1.45838317e-02f, 4.94884662e-02f, -7.51526747e-03f, 3.48004699e-02f, -1.79626215e-02f, -9.63741317e-02f,
  -6.93685114e-02f, 6.01340737e-03f, 1.61335990e-01f, -4.72809467e-03f, 6.26324862e-02f, 7.77385151e-03f, -8.33184719e-02f, 1.75997049e-01f, 5.66339046e-02f, 1.15134001e-01f,
  -4.17406820e-02f, -1.25452936e-01f, 5.17095029e-02f, 3.88316028e-02f, 8.81788088e-04f, -2.31992826e-02f, 4.81427461e-02f, 5.64707220e-02f, 3.40789780e-02f, -4.17033955e-02f,
  4.65619899e-02f, -6.39700815e-02f, -3.21408026e-02f, 3.59416530e-02f, -9.87379476e-02f, 7.13495491e-03f, -3.69383059e-02f, -2.06660312e-02f, 1.77145470e-02f, -1.06353555e-02f,
  4.73645851e-02f, 1.41095277e-02f, 1.43809104e-02f, 6.90851137e-02f, -2.40970068e-02f, -6.71106130e-02f, 3.38371359e-02f, 7.50323478e-03f, -9.38665941e-02f, -2.41438225e-02f,
  -8.95077083e-03f, -1.74862985e-02f, -6.99725514e-03f, 3.89084481e-02f, -2.34147049e-02f, 5.77139519e-02f, -2.99559142e-02f, 4.29141484e-02f, 1.47659509e-02f, -4.56271805e-02f,
  1.04821296e-02f, -3.96827385e-02f, -1.22185526e-02f, -2.13279799e-02f, -4.66213189e-02f, -6.47326112e-02f, 2.84459647e-02f, -2.23282576e-02f, -6.50665117e-03f, -2.93101761e-02f,
  2.51118373e-02f, -1.14282845e-02f, 2.32296269e-02f, -5.83292320e-02f, -1.32212397e-02f, 6.95895627e-02f, 5.59286699e-02f, -1.65668596e-02f, 5.40856868e-02f, 7.20573077e-03f,
  -3.45468193e-01f, -2.89146066e-01f, -2.94650663e-02f, -2.33835150e-02f, -2.10939683e-02f, -8.45830590e-02f, 1.17222173e-02f, 4.00305522e-04f, -5.56455553e-02f, -4.94469404e-02f,
  -4.52220477e-02f, 4.39796112e-02f, -8.71787667e-02f, 8.20455793e-03f, 7.11417273e-02f, -4.93298620e-02f, 4.66711186e-02f, -4.64552902e-02f, -6.89354390e-02f, 3.26034352e-02f,
  -5.42852469e-02f, 1.27680961e-03f, 1.31053422e-02f, -6.74696639e-02f, 1.35917990e-02f, 2.95898635e-02f, -5.11276573e-02f, -2.73673777e-02f, 2.74936333e-02f, 2.22758520e-02f,
  -1.58353731e-01f, 2.74962604e-01f, 1.07602097e-01f, -1.47939712e-01f, 6.37587858e-03f, 1.27023369e-01f, 1.98078439e-01f, 1.34354874e-01f, 1.76929459e-01f, 3.27969253e-01f,
  1.98179483e-01f, 1.05278768e-01f, 2.52642035e-01f, 1.38244733e-01f, -1.28690004e-01f, 1.39742389e-01f, -8.64136219e-02f, 4.89935130e-02f, -1.01327732e-01f, -1.43081114e-01f,
  -1.83376223e-01f, -6.58652280e-03f, -9.42844674e-02f, -1.63446561e-01f, 4.09343503e-02f, -1.32517442e-01f, -2.31002688e-01f, 1.96828637e-02f, -9.17046368e-02f, 1.00539634e-02f,
  8.06877464e-02f, -2.48220135e-02f, -9.18433443e-03f, -4.33780765e-03f, -2.60412078e-02f, 5.35038533e-03f, -5.94331846e-02f, -3.24068628e-02f, -4.04771939e-02f, -3.84622030e-02f,
  -3.28571089e-02f, -2.19421741e-03f, -1.85799226e-03f, 9.50070545e-02f, -4.45878832e-03f, 6.51359558e-02f, 1.53374486e-02f, 5.42229936e-02f, 1.03031427e-01f, 1.47448241e-04f,
  -2.61122230e-02f, 6.63219243e-02f, -2.93206959e-03f, 3.76242809e-02f, 4.94969357e-03f, 1.01510510e-01f, -1.63098779e-02f, 8.73062946e-03f, 3.77447829e-02f, 4.07184660e-02f,
  -4.78269234e-02f, -1.31443869e-02f, 8.31827223e-02f, 4.79586422e-02f, 1.21818380e-02f, 5.62180839e-02f, -1.90359838e-02f, 5.62185654e-03f, -7.44272918e-02f, -2.37716753e-02f,
  -5.99431992e-02f, 1.41092082e-02f, -7.35521363e-03f, -2.70601399e-02f, -3.53567712e-02f, 3.10055185e-02f, -9.77958441e-02f, -3.11418250e-02f, -7.74175301e-02f, 1.75859630e-02f,
  -4.30811308e-02f, -3.09640318e-02f, -1.39856935e-02f, -1.08711971e-02f, 6.90219626e-02f, 1.50804771e-02f, 2.44442616e-02f, 3.38654108e-02f, 7.63445022e-03f, -2.06674803e-02f,
  -1.56754926e-02f, 1.26082567e-03f, -3.50542776e-02f, 4.44602743e-02f, -1.29466020e-02f, 5.60502849e-05f, -7.10119605e-02f, 4.40021791e-02f, 2.51105018e-02f, 2.30012648e-03f,
  -2.19230521e-02f, -5.00015169e-02f, -7.98471123e-02f, 1.68546457e-02f, -7.71695003e-02f, -1.77660901e-02f, -4.83173393e-02f, -7.40424246e-02f, -6.60038143e-02f, -6.74725026e-02f,
  5.10332324e-02f, -9.78251323e-02f, 3.79804969e-02f, -2.77261548e-02f, -7.70076830e-03f, -3.56632024e-02f, 3.94091718e-02f, -3.50621939e-02f, -5.52782081e-02f, -3.85018587e-02f,
  4.23983391e-03f, 2.46559754e-01f, 2.86075056e-01f, 5.46536781e-02f, 7.10875820e-03f, -2.31421173e-01f, -1.49618790e-01f, 1.70788288e-01f, 6.86360300e-02f, -1.24885514e-01f,
  -1.13813922e-01f, 1.70864940e-01f, -1.00599393e-01f, -6.32137284e-02f, -1.70900941e-01f, -2.54537374e-01f, -2.13772982e-01f, -7.67668784e-02f, 2.37215459e-02f, 8.06794092e-02f,
  -3.68269421e-02f, -9.66492742e-02f, 7.07841292e-02f, 1.53029621e-01f, 1.96028706e-02f, 2.24707052e-01f, -5.80549166e-02f, 2.03943297e-01f, 1.33207858e-01f, -2.70082708e-02f,
  -9.30038765e-02f, 3.70338298e-02f, 4.05159071e-02f, 7.51639903e-02f, -1.55474036e-03f, -6.41411394e-02f, 1.00043854e-02f, 2.73302533e-02f, 6.48937151e-02f, 1.33879879e-03f,
  -2.32984102e-03f, 4.94717946e-03f, 4.53109778e-02f, -6.15370413e-03f, 4.53148521e-02f, 9.82173979e-02f, 9.04489756e-02f, 1.94348991e-02f, 5.51936664e-02f, -1.57132167e-02f,
  2.63023027e-03f, 3.36557738e-02f, -3.29898968e-02f, -6.53898120e-02f, 3.50492448e-03f, -4.48212512e-02f, -6.68706894e-02f, 5.76643310e-02f, -2.48006862e-02f, -4.34409156e-02f,
  -5.75345568e-02f, 7.01494813e-02f, 4.69893217e-02f, 5.06681353e-02f, 1.56183075e-03f, -1.75876562e-02f, 8.78115650e-03f, -6.24633580e-02f, 5.17338440e-02f, -1.54592982e-02f,
  3.05218622e-02f, 6.90274918e-03f, 3.81135829e-02f, -6.45233467e-02f, -1.35013089e-02f, -1.74788330e-02f, 3.12748514e-02f, 2.34439094e-02f, -4.50357683e-02f, -2.35839025e-03f,
  -2.59412616e-03f, 8.54825508e-03f, -3.52117047e-02f, -3.52673456e-02f, 2.01660730e-02f, -1.93925481e-03f, -1.14650028e-02f, 7.16923364e-03f, 3.83191998e-03f, -4.53514904e-02f,
  -8.26194733e-02f, 1.12799063e-01f, 1.04247602e-02f, -1.72507707e-02f, 2.37442888e-02f, -1.46272294e-02f, -1.24214392e-03f, 1.66776832e-02f, -3.33813056e-02f, 1.44477440e-02f,
  8.80045816e-03f, -4.11252454e-02f, -1.81199983e-02f, -1.42896106e-03f, -8.28189030e-03f, -5.13129458e-02f, -5.19024245e-02f, 9.75471735e-03f, 2.51478143e-02f, 4.31234464e-02f,
  4.41854708e-02f, -4.65369299e-02f, -1.23740705e-02f, 5.46674244e-02f, -3.50378035e-03f, -2.34732348e-02f, 1.97887626e-02f, -9.35653690e-03f, 2.71053258e-02f, 4.46423925e-02f,
  1.33111598e-02f, -4.92065027e-02f, 4.19945121e-02f, -1.33007690e-01f, -1.06154457e-01f, 2.27015555e-01f, 2.28384808e-01f, 2.50127334e-02f, 1.10851504e-01f, 1.22136578e-01f,
  7.23867444e-04f, -8.73036534e-02f, 1.43562183e-01f, -1.47524267e-01f, 5.49372584e-02f, 3.02406983e-03f, -4.78272252e-02f, 1.00501075e-01f, -1.08283952e-01f, -3.39902565e-02f,
  -7.91684464e-02f, -1.57527760e-01f, -1.59944937e-01f, -2.39524126e-01f, -1.57267693e-02f, -9.10080373e-02f, -5.09096608e-02f, -1.50467262e-01f, -1.42061487e-01f, -1.40993863e-01f,
  1.05769597e-01f, 1.22404052e-02f, 2.61256620e-02f, -1.36210332e-02f, 1.06198989e-01f, 9.02012736e-02f, 3.28693800e-02f, -2.26984620e-02f, -1.41641060e-02f, 4.54748310e-02f,
  -5.34799416e-03f, -7.36659840e-02f, -3.49058323e-02f, -9.01962072e-02f, 4.48163711e-02f, 1.28212636e-02f, 3.08280382e-02f, -6.98346319e-03f, 1.33424504e-02f, 2.94436160e-02f,
  -5.52866571e-02f, 1.95949301e-02f, 2.59661339e-02f, 2.22577211e-02f, -3.55915166e-02f, -3.56739364e-03f, -5.48067540e-02f, -2.73798443e-02f, 5.59551381e-02f, -4.20847386e-02f,
  1.15343377e-01f, 2.53158864e-02f, 1.24264220e-02f, -3.71597931e-02f, -4.32276465e-02f, -6.03185445e-02f, -1.88239943e-02f, -6.56471401e-02f, 2.28146911e-02f, 5.96742481e-02f,
  -3.14297006e-02f, 1.20829530e-02f, -2.35572457e-02f, 7.22578540e-02f, -1.89325213e-02f, -1.72942467e-02f, -2.79024560e-02f, -1.77376196e-02f, -3.10644023e-02f, 1.53314415e-02f,
  6.88355193e-02f, 5.76201417e-02f, 3.53914946e-02f, -4.45913002e-02f, 9.35341883e-03f, 2.52395030e-02f, -2.62603946e-02f, -1.54160652e-02f, 2.35556252e-02f, -1.32849067e-02f,
  1.80594623e-01f, -9.15347114e-02f, -1.34018306e-02f, -6.90184459e-02f, 4.47522588e-02f, -1.99784897e-02f, 5.46739437e-02f, 4.27617645e-03f, 6.71655983e-02f, -2.43536998e-02f,
  1.20391240e-02f, -2.48527690e-03f, -2.62984335e-02f, 2.70282552e-02f, -2.17848532e-02f, 2.88830679e-02f, 2.25696955e-02f, -1.52564673e-02f, 4.43166271e-02f, -6.13812618e-02f,
  1.57296956e-02f, 3.30770798e-02f, 2.58490834e-02f, -4.61479574e-02f, 1.61809921e-02f, -1.88096967e-02f, 6.34426251e-02f, -1.28732072e-02f, -1.21509787e-02f, -3.96418832e-02f,
  -9.04661343e-02f, -2.78653614e-02f, -2.03661118e-02f, -8.50074068e-02f, -1.07941814e-01f, 1.79384172e-01f, 2.35620067e-01f, -7.19479844e-02f, -6.82320446e-02f, -7.08403857e-03f,
  1.87414721e-01f, -1.50410444e-01f, 1.65611833e-01f, 1.18709520e-01f, 1.42449707e-01f, 2.09723830e-01f, 1.28346071e-01f, 1.38002649e-01f, -1.87271659e-03f, 6.65690526e-02f,
  -4.52558137e-02f, 1.07114062e-01f, 7.39286169e-02f, -2.35902984e-02f, -4.89779450e-02f, -2.06837967e-01f, -4.87735718e-02f, -2.88901981e-02f, -7.22644664e-03f, 2.81708930e-02f,
  7.22154528e-02f, -6.46360219e-02f, -9.29573085e-03f, 3.94177698e-02f, 1.07147954e-02f, -4.35449779e-02f, 4.91881091e-03f, 1.30305961e-02f, 1.37992138e-02f, -5.95367439e-02f,
  -2.78725754e-02f, 4.96341698e-02f, -9.44774672e-02f, 2.23733392e-02f, -3.88343539e-03f, 6.29713433e-03f, -2.00642068e-02f, -2.85538454e-02f, -1.00664467e-01f, -4.34352234e-02f,
  5.79232499e-02f, -3.38104763e-03f, -4.75510582e-02f, 4.95231412e-02f, -5.49282245e-02f, -5.62753715e-02f, 1.13214203e-03f, -6.07021302e-02f, -6.19257353e-02f, -1.14505760e-01f,
  3.98828238e-02f, -6.10161433e-03f, 6.81252033e-02f, 1.46057568e-02f, 5.33096530e-02f, -6.24657515e-03f, 4.72390503e-02f, -6.23942502e-02f, -2.48664320e-02f, 4.36387993e-02f,
  -2.72789355e-02f, -2.93176565e-02f, 1.15744211e-02f, -4.83788848e-02f, 2.05068868e-02f, 3.95931117e-02f, -9.58914030e-03f, -2.21308600e-03f, 3.74876410e-02f, -1.03945518e-02f,
  -1.06412815e-02f, 5.40898480e-02f, -7.32400343e-02f, 4.12328728e-02f, -1.40257869e-02f, 4.91990000e-02f, -1.66991055e-02f, 2.90680602e-02f, -5.37210628e-02f, 2.51724152e-03f,
  1.61870033e-01f, -2.76283417e-02f, -1.13992812e-02f, 4.16147821e-02f, -4.66362908e-02f, 7.30941594e-02f, -1.55636054e-02f, 4.00245190e-02f, 1.02731749e-01f, 1.87174547e-02f,
  2.23845076e-02f, -4.41828519e-02f, 4.20875996e-02f, 5.34354039e-02f, 8.72030854e-02f, 6.62413687e-02f, -2.19072029e-02f, -3.70527105e-03f, 7.47456700e-02f, 2.34772339e-02f,
  -7.86098912e-02f, 4.48886044e-02f, -3.03698909e-02f, -6.25394285e-03f, -6.27419073e-03f, -2.13249233e-02f, 1.50375897e-02f, -3.62134613e-02f, -5.73995821e-02f, 6.97662830e-02f,
  -2.61538681e-02f, 4.19991128e-02f, 2.33069877e-03f, 9.73053575e-02f, -1.69414058e-02f, 2.38308199e-02f, 8.55232403e-02f, 1.91470459e-02f, 2.25454718e-02f, -5.41979596e-02f,
  7.84391090e-02f, 4.73319218e-02f, -7.52463117e-02f, 2.92863846e-01f, 2.01903209e-01f, 8.62171352e-02f, 2.33316168e-01f, 6.93901330e-02f, -3.70916165e-02f, 2.78695393e-02f,
  6.88461438e-02f, -8.45762715e-03f, 1.68881088e-01f, -5.37665002e-02f, 1.01572305e-01f, -1.57093990e-03f, -4.72894683e-02f, -1.36509925e-01f, 1.60549030e-01f, -7.30028376e-04f,
  1.53640300e-01f, -2.25704536e-02f, -4.51809615e-02f, -4.23067808e-02f, -7.39732310e-02f, 5.94812594e-02f, -4.61111963e-02f, 1.61043578e-03f, -3.26960869e-02f, 7.66468421e-02f,
  -7.68859461e-02f, -2.24126261e-02f, 8.42356980e-02f, -7.72755817e-02f, -2.75537129e-02f, -2.72150226e-02f, -8.84771626e-03f, 7.59574398e-02f, -2.55836025e-02f, 8.01508576e-02f,
  5.89103363e-02f, 4.04789038e-02f, -1.09805949e-02f, 8.89724344e-02f, 7.04408213e-02f, 3.14644799e-02f, -1.60012599e-02f, 4.34356444e-02f, 7.92114735e-02f, 6.33044764e-02f,
  2.08367966e-02f, -4.95749526e-02f, 1.15354685e-02f, -6.50114715e-02f, 2.19961926e-02f, -3.68958749e-02f, -3.89890037e-02f, 4.48236940e-03f, 2.42948700e-02f, 2.94476449e-02f,
  6.51403964e-02f, -5.42198047e-02f, -8.54813829e-02f, 7.91764930e-02f, -4.80864272e-02f, -4.20557745e-02f, -2.67985277e-02f, -6.05736189e-02f, 4.80735824e-02f, 8.36471990e-02f,
  -4.32639122e-02f, 4.39905226e-02f, -6.12916909e-02f, 2.05697622e-02f, 6.20059781e-02f, 2.07647383e-02f, 2.85619237e-02f, 5.57274744e-02f, 4.75708954e-02f, 7.02911168e-02f,
  7.38252699e-02f, -7.37197101e-02f, 3.84791754e-02f, -5.11700399e-02f, -4.14561890e-02f, 4.06032661e-03f, -4.70466260e-03f, 1.18761219e-01f, -4.18125167e-02f, -1.84301287e-02f,
  -5.08485101e-02f, -6.61357641e-02f, 3.87127548e-02f, 8.11555237e-03f, -3.61832939e-02f, -1.89983156e-02f, 3.90994735e-03f, -3.56602781e-02f, 5.56980185e-02f, 4.96163145e-02f,
  2.25018859e-02f, -1.16394982e-02f, -3.43235210e-02f, 1.67471785e-02f, -4.45290096e-03f, -3.79192410e-03f, 6.03496805e-02f, 2.44110706e-03f, 3.76968198e-02f, 4.28887680e-02f,
  -3.05765092e-01f, 3.16836447e-01f, 2.42218599e-02f, -1.22087650e-01f, -4.05321307e-02f, 4.18295413e-02f, -1.07021235e-01f, 7.06116855e-02f, -8.04743394e-02f, 7.40400925e-02f,
  -1.03022484e-02f, 1.08457260e-01f, -2.23124586e-02f, 9.90063697e-02f, -1.11586601e-02f, -7.95841776e-03f, 1.47173390e-01f, -2.76723281e-02f, -1.45369181e-02f, 1.25459105e-01f,
  5.58667481e-02f, 3.12326774e-02f, 1.00656062e-01f, 2.35547587e-01f, -3.76845524e-02f, -4.48930776e-03f, 1.72063801e-02f, -6.20941035e-02f, 1.90246373e-01f, 4.28356379e-02f,
  2.52422541e-02f, -5.50340153e-02f, 1.89368874e-02f, -5.87242991e-02f, 4.89649326e-02f, -3.56941931e-02f, -9.28192735e-02f, 3.72285247e-02f, -5.75270085e-03f, 5.38786575e-02f,
  -6.47122785e-02f, 3.01551004e-03f, 9.83977020e-02f, -2.13148748e-03f, 1.96385290e-02f, 9.69368219e-02f, -4.92052734e-03f, 1.15870973e-02f, 3.04455012e-02f, -3.48292701e-02f,
  -2.80845035e-02f, -2.52320059e-02f, -6.84047565e-02f, 7.10602403e-02f, 2.70816330e-02f, -3.62298973e-02f, 4.29147817e-02f, -3.16467427e-04f, 8.70982111e-02f, 6.65503740e-02f,
  5.03154099e-02f, -5.28508537e-02f, -5.14712259e-02f, 5.89109259e-03f, 2.32082959e-02f, 3.08121685e-02f, 7.29438104e-03f, -5.29829673e-02f, -1.91460103e-02f, 3.59484442e-02f,
  -1.85432266e-02f, 5.94651289e-02f, -5.17093809e-03f, 6.34202436e-02f, -3.68209258e-02f, -6.97683096e-02f, -6.58186525e-02f, 7.08319172e-02f, 2.71634590e-02f, -6.57007918e-02f,
  3.01311314e-02f, 4.15864773e-02f, -1.36297019e-02f, -1.31023824e-02f, 6.02608733e-02f, -5.08753359e-02f, -2.21852809e-02f, 6.95353746e-02f, -4.08486910e-02f, -3.28331366e-02f,
  1.51649565e-01f, 1.62192911e-01f, 2.69320775e-02f, -2.94045359e-02f, -6.97965082e-03f, -1.56268179e-02f, 7.97502026e-02f, 3.49241756e-02f, -6.10995572e-03f, -3.40155587e-02f,
  -3.93099561e-02f, 8.04269439e-05f, -5.33338599e-02f, 5.47948331e-02f, -4.87396435e-04f, -2.22947598e-02f, 7.08357524e-03f, -4.88511147e-03f, 5.27622970e-03f, 2.83427816e-02f,
  -4.21714745e-02f, -2.93173622e-02f, -3.60073559e-02f, -3.10194734e-02f, -4.18879986e-02f, 4.05598059e-03f, 3.91065069e-02f, 2.66378075e-02f, 2.13240869e-02f, 1.84329394e-02f,
  -1.29644334e-01f, 7.40898773e-02f, -2.36325845e-01f, -2.45490581e-01f, -7.57702515e-02f, -1.26945838e-01f, -2.13912413e-01f, -5.03537580e-02f, 1.07274160e-01f, 1.59397587e-01f,
  -6.43184111e-02f, 6.62949905e-02f, 2.31992193e-02f, -1.12982020e-01f, -1.49161309e-01f, 1.06813028e-01f, -5.71271852e-02f, -4.20319028e-02f, 7.62348101e-02f, -9.71109644e-02f,
  -1.30468026e-01f, -5.39033450e-02f, -1.91853285e-01f, 1.00314111e-01f, -2.18229190e-01f, -3.38642448e-02f, -6.35688454e-02f, -5.68202138e-02f, -1.57075450e-01f, 1.53351703e-03f,
  -1.34925708e-01f, 3.43536921e-02f, 2.51108482e-02f, 2.82801129e-02f, -6.88287467e-02f, -1.11067139e-01f, 2.21830923e-02f, 1.02745881e-02f, -1.52858682e-02f, 5.10483142e-03f,
  7.21177086e-03f, 1.47097576e-02f, 8.31042379e-02f, -2.72156764e-02f, 2.28607915e-02f, 4.28893184e-03f, 1.67859662e-02f, -9.15833935e-02f, -9.09745600e-03f, -7.35602006e-02f,
  -9.15662870e-02f, -6.45674318e-02f, -1.44187501e-02f, 7.58483857e-02f, -5.67601062e-02f, 1.99728422e-02f, -1.49277560e-02f, -3.27783404e-03f, -2.36984417e-02f, 2.05210387e-03f,
  5.97775951e-02f, 9.18222070e-02f, -5.74261025e-02f, 5.22194766e-02f, 2.57090591e-02f, 4.75839479e-03f, 7.21963868e-02f, -3.46958600e-02f, -3.12990882e-02f, -2.35336553e-02f,
  -2.07213030e-04f, 2.07831878e-02f, -3.91136855e-02f, -7.19830021e-03f, -3.98082323e-02f, -3.08797639e-02f, 4.01100516e-02f, 2.14934703e-02f, -1.31761245e-02f, -1.81692764e-02f,
  4.47227322e-02f, -3.28537039e-02f, 4.96262684e-03f, -4.26834300e-02f, 5.85331284e-02f, 6.17407374e-02f, 4.47239801e-02f, -4.24790271e-02f, -5.93642108e-02f, -3.15818824e-02f,
  -1.28408335e-02f, 1.41251564e-01f, 1.41416898e-03f, -1.09901391e-02f, 4.77844775e-02f, 8.79985653e-03f, -6.67872578e-02f, 2.57135518e-02f, 4.61741649e-02f, 5.62858507e-02f,
  -6.66459128e-02f, 5.73496222e-02f, -4.61707786e-02f, 1.28916111e-02f, 5.82307801e-02f, 4.16279025e-02f, -9.53123346e-03f, -1.37851248e-02f, -7.12814257e-02f, 8.13874137e-03f,
  -7.14026531e-03f, -6.82024797e-03f, -5.32569662e-02f, -2.59996839e-02f, -2.16270909e-02f, -8.70548305e-04f, -3.82770486e-02f, 1.74844339e-02f, 2.67064814e-02f, 1.52823422e-02f,
  6.64052665e-02f, -6.29508570e-02f, 6.25522584e-02f, -2.28033327e-02f, 5.64176776e-02f, 1.18490970e-02f, -1.40679881e-01f, 4.35431153e-02f, -2.73587942e-01f, -4.69675958e-02f,
  -1.01319170e-02f, -8.08024406e-02f, -1.07009701e-01f, -2.16674898e-02f, 7.38902241e-02f, -1.69351012e-01f, 1.42571190e-02f, -8.29406269e-03f, -7.49131739e-02f, 1.49330005e-01f,
  5.22699580e-02f, 1.75084427e-01f, 1.29379094e-01f, 1.49543211e-01f, 1.22323506e-01f, 1.12699963e-01f, 1.51048690e-01f, 1.14858761e-01f, 4.34926562e-02f, 8.16371851e-03f,
  7.48572350e-02f, 8.94906297e-02f, 8.76255929e-02f, 3.67255174e-02f, 1.43492326e-01f, 8.32884200e-03f, 6.53681755e-02f, 4.34963405e-02f, 7.66951125e-03f, -6.76213624e-03f,
  -5.08347899e-03f, 3.09635121e-02f, -2.12830734e-02f, -6.74688816e-02f, 3.40343919e-03f, 1.89087950e-02f, 6.02514520e-02f, -3.58061641e-02f, -7.50830323e-02f, 3.67763378e-02f,
  -6.07675835e-02f, -4.61147092e-02f, -7.50535820e-03f, 1.29646230e-02f, -4.55088122e-03f, -3.08394767e-02f, -3.42343524e-02f, 1.67524200e-02f, 3.28199193e-02f, -3.46562034e-03f,
  9.13845003e-02f, 4.30829339e-02f, -2.99337208e-02f, 5.53604402e-02f, 1.98186543e-02f, 6.43149540e-02f, 1.00675160e-02f, 3.00514027e-02f, -1.56152993e-02f, -4.36351448e-02f,
  -1.78955793e-02f, -7.57195009e-03f, -6.07450344e-02f, 1.48838870e-02f, -1.98420715e-02f, -5.28026037e-02f, 1.40870353e-02f, 3.37619409e-02f, -4.49854396e-02f, -5.44971451e-02f,
  2.67365444e-02f, -5.38575016e-02f, -1.92376114e-02f, 3.19515243e-02f, -2.41791587e-02f, 4.39084992e-02f, 7.81623274e-03f, -5.04779033e-02f, -1.70735978e-02f, 8.12889561e-02f,
  1.55820549e-01f, 1.71735689e-01f, 2.55336817e-02f, -9.86628328e-03f, 3.88179086e-02f, 5.83495535e-02f, -2.93555185e-02f, 4.06812765e-02f, -1.95485447e-02f, 8.77961889e-02f,
  3.36771570e-02f, 2.88184378e-02f, -7.53305014e-03f, -5.32355942e-02f, -2.15836521e-03f, 3.53131108e-02f, -2.25616116e-02f, 6.57679164e-04f, 9.92995277e-02f, 4.90789786e-02f,
  1.18757375e-01f, 6.39047995e-02f, -1.60399973e-02f, -4.23666388e-02f, 8.23286399e-02f, 3.44834179e-02f, 8.15831199e-02f, -6.63705319e-02f, -4.10714280e-03f, -2.92554963e-02f,
  -1.72915235e-02f, -1.47744641e-01f, 7.27855191e-02f, 2.09911153e-01f, 1.86383113e-01f, 3.13183069e-01f, 7.70190358e-02f, 1.07725829e-01f, 1.23094060e-01f, -1.16721600e-01f,
  -1.07948638e-01f, -9.86678526e-02f, -2.29655907e-01f, 1.86701730e-01f, 1.60702571e-01f, -1.04458131e-01f, 1.84887514e-01f, 6.11362904e-02f, 3.60975787e-02f, 6.90371990e-02f,
  1.42647415e-01f, 4.67414446e-02f, 9.18109417e-02f, -2.83246990e-02f, 5.89396022e-02f, 1.41302338e-02f, -4.73447405e-02f, -9.67954546e-02f, 1.33407518e-01f, 8.38738866e-03f,
  -4.90915440e-02f, -2.08680034e-02f, 9.81090590e-02f, 9.56121180e-03f, 7.31080994e-02f, 2.47184243e-02f, 1.98475402e-02f, 3.05501632e-02f, 5.90839535e-02f, 3.24314856e-03f,
  -3.63620669e-02f, -9.06803366e-03f, 3.63347642e-02f, -8.50709006e-02f, -5.98002002e-02f, 2.78975721e-02f, 1.05802892e-02f, 5.81995770e-02f, 7.71770850e-02f, 1.19573362e-02f,
  5.80446534e-02f, 7.21424669e-02f, 7.60834888e-02f, 9.70618352e-02f, 6.47541359e-02f, -4.91434485e-02f, 2.96900366e-02f, 4.50453609e-02f, -3.73152606e-02f, 1.33592069e-01f,
  -5.97107708e-02f, -9.60191190e-02f, -6.52871430e-02f, 5.73257636e-03f, -2.07550302e-02f, -4.31785434e-02f, -3.74209508e-02f, -1.87944509e-02f, -5.19899651e-02f, -6.38836995e-02f,
  7.22854733e-02f, -3.31807621e-02f, 7.89139792e-03f, -3.79712065e-03f, -7.96631444e-03f, 2.50652386e-03f, -3.76465805e-02f, -1.88020337e-02f, 1.80349275e-02f, 5.63313067e-02f,
  -9.40633938e-02f, -9.45566408e-03f, -5.43019958e-02f, -3.39085087e-02f, -3.87849696e-02f, 2.89708637e-02f, -2.50772648e-02f, 4.22037430e-02f, -8.02784264e-02f, -2.79052462e-02f,
  2.78506353e-02f, -1.39668971e-01f, -5.58942631e-02f, -2.62208153e-02f, -7.32264295e-02f, 5.87117746e-02f, 4.02328558e-03f, 5.50948130e-03f, 1.71405647e-03f, 7.17040524e-02f,
  1.04659619e-02f, -4.02633511e-02f, -3.23155262e-02f, 1.41844833e-02f, 8.08474720e-02f, 1.74851064e-02f, -2.60841791e-02f, -5.94980158e-02f, 1.10074701e-02f, 3.76947261e-02f,
  -1.59641001e-02f, -8.09892789e-02f, 6.30784035e-02f, -1.51802553e-02f, -3.22466418e-02f, 3.85293141e-02f, 4.21152450e-02f, -1.06967296e-02f, 5.45731671e-02f, -3.55622955e-02f,
  -8.63974541e-03f, 1.04233772e-01f, 1.03450017e-02f, -1.97172593e-02f, -5.95745631e-03f, -2.72317939e-02f, 1.00896068e-01f, -1.22447386e-01f, -1.29866764e-01f, -2.36055395e-03f,
  5.44714890e-02f, 1.20479293e-01f, 3.23122330e-02f, 1.25901103e-01f, -9.03794989e-02f, -3.06366384e-03f, 1.22430488e-01f, 1.54453114e-01f, -1.52766351e-02f, -2.09210068e-01f,
  -5.52621204e-04f, -6.39722198e-02f, -1.55041888e-02f, -3.66486460e-02f, -7.45149627e-02f, -1.08776242e-01f, -5.79382479e-02f, -1.37899801e-01f, 2.34348327e-02f, 6.28404766e-02f,
  -2.76262276e-02f, -1.06229760e-01f, -2.23091966e-03f, -2.53286120e-02f, -1.09292373e-01f, -1.61958933e-02f, -5.82129546e-02f, 4.88391779e-02f, -8.69872340e-04f, -2.75300387e-02f,
  5.71207739e-02f, -4.33230866e-03f, 8.32699984e-02f, -6.01079874e-02f, -5.06673791e-02f, 1.80675182e-02f, 1.23876475e-01f, -9.72792227e-03f, -3.22544239e-02f, 1.02817900e-02f,
  1.11310393e-01f, 3.81718352e-02f, 5.47450297e-02f, 8.43682364e-02f, 3.71839516e-02f, 2.71552075e-02f, 4.05112840e-02f, 3.41201611e-02f, -4.16266061e-02f, 6.59399629e-02f,
  3.35442461e-02f, -5.15143164e-02f, 3.26702259e-02f, 2.65437271e-02f, -4.56212694e-03f, 4.23351265e-02f, 2.37011649e-02f, 8.25098976e-02f, -9.10573546e-03f, -1.09427366e-02f,
  -6.10581823e-02f, 1.38545427e-02f, -5.12056798e-02f, 5.46505488e-02f, 1.52899865e-02f, 2.70929914e-02f, 3.79457474e-02f, 2.89849434e-02f, -1.00151254e-02f, -9.25335754e-03f,
  -2.54912977e-03f, -5.25836311e-02f, -3.77622955e-02f, 4.26549315e-02f, -3.82350720e-02f, 4.24202867e-02f, -7.50181898e-02f, -2.89147794e-02f, 2.51577445e-03f, 4.33437899e-02f,
  -1.02282204e-01f, -3.83581966e-01f, -3.37257907e-02f, 4.96745780e-02f, 7.34705105e-02f, -4.91480827e-02f, 2.20253058e-02f, 4.35833260e-02f, -1.23058110e-01f, 5.10784332e-03f,
  5.88593725e-03f, -4.51232865e-03f, -6.48464561e-02f, 7.66842160e-03f, 2.97923479e-02f, 3.18432003e-02f, -1.21359408e-01f, 5.42876609e-02f, -5.06005697e-02f, 4.20313291e-02f,
  -1.08825237e-01f, -5.07114530e-02f, -1.39107350e-02f, -2.23559178e-02f, -9.54970717e-03f, -1.45801185e-02f, 7.44395796e-03f, 3.13464589e-02f, 4.47609723e-02f, -3.92108932e-02f,
  -2.94939131e-02f, 2.50066668e-01f, -6.81753606e-02f, -2.45019533e-02f, -1.32066131e-01f, -8.69101062e-02f, -5.41885570e-02f, -2.48438455e-02f, 1.40824050e-01f, 2.72833318e-01f,
  1.28997965e-02f, 3.41237746e-02f, 3.50304171e-02f, -7.61617348e-02f, -3.30061167e-01f, 2.50431858e-02f, 2.64465623e-02f, 3.69249992e-02f, 6.91256970e-02f, 6.87690228e-02f,
  -7.82356933e-02f, -2.70968247e-02f, -1.70551389e-01f, 1.02561459e-01f, -1.01391464e-01f, 6.60041869e-02f, -3.42919417e-02f, -1.00508377e-01f, -8.65755454e-02f, -4.45566997e-02f,
  -1.16338760e-01f, 1.19041443e-01f, -5.56489192e-02f, 5.86233176e-02f, -6.95414469e-03f, -7.66619444e-02f, -6.12998269e-02f, -1.15356587e-01f, -8.92049745e-02f, -4.02736738e-02f,
  7.11801499e-02f, -2.76626740e-02f, -2.74187922e-02f, -1.77804437e-02f, -5.65265007e-02f, 3.46298032e-02f, -1.18759098e-02f, 2.89594475e-02f, 1.88440029e-02f, -4.58957516e-02f,
  4.55496386e-02f, -3.48648662e-03f, 3.49313952e-02f, 2.40772162e-02f, -5.45702912e-02f, 3.89618091e-02f, 3.24955918e-02f, -2.61404533e-02f, 4.43535559e-02f, 3.34285013e-02f,
  4.21073586e-02f, 2.73773018e-02f, 3.00233103e-02f, -1.76786445e-03f, -2.72370372e-02f, 1.00695193e-02f, 7.04684062e-03f, -1.57221202e-02f, -2.44007390e-02f, 6.94341287e-02f,
  2.08076891e-02f, -1.09563116e-02f, 6.03407733e-02f, -3.26566473e-02f, 5.31603955e-03f, 5.65056168e-02f, 8.40764376e-04f, -9.11918841e-03f, 2.53601745e-02f, -4.05465104e-02f,
  5.37962727e-02f, -1.25430776e-02f, -6.33732509e-03f, -5.71877472e-02f, 2.46707927e-02f, -1.57843647e-03f, 1.03097059e-01f, 3.94807309e-02f, -5.20623885e-02f, -6.65590027e-03f,
  2.93583795e-02f, 2.91151345e-01f, 5.57369106e-02f, 1.62822809e-02f, 5.69632240e-02f, 5.17119765e-02f, 3.60450596e-02f, 2.39728931e-02f, 1.01496447e-02f, 6.87010735e-02f,
  7.52682686e-02f, -4.19946983e-02f, 5.19596562e-02f, -2.84736026e-02f, 3.76113541e-02f, 5.86675294e-02f, 5.83733842e-02f, 7.06516355e-02f, -4.63586748e-02f, 5.13197929e-02f,
  3.40778530e-02f, 4.55075391e-02f, 8.79595429e-03f, -3.86581160e-02f, -1.60896257e-02f, 4.45154905e-02f, 7.15366453e-02f, -3.69581813e-03f, 3.81844770e-03f, 4.70800512e-02f,
  1.90671846e-01f, -1.52945742e-01f, -9.50600058e-02f, -5.93834072e-02f, -1.90237314e-01f, -2.25888282e-01f, -1.24217205e-01f, -1.50814101e-01f, -2.26444695e-02f, -9.19945166e-02f,
  -1.32484928e-01f, 6.35377541e-02f, 1.37317821e-01f, -1.94410890e-01f, 2.35608211e-04f, 7.32622594e-02f, -1.97648197e-01f, -4.46001207e-03f, 2.34276373e-02f, 4.37285518e-04f,
  6.75775334e-02f, 5.93900913e-03f, -5.14111035e-02f, -9.06492695e-02f, -1.67751491e-01f, 8.32008664e-03f, 1.31629864e-02f, 4.38946635e-02f, -4.81572226e-02f, -4.56287600e-02f,
  5.58424890e-02f, 8.34929794e-02f, -3.39549780e-02f, 2.53800564e-02f, -6.73511177e-02f, 3.24944742e-02f, 5.29766791e-02f, 2.14159507e-02f, 4.45425212e-02f, -8.55363011e-02f,
  -2.40118355e-02f, 2.77952682e-02f, -1.42649524e-02f, 1.18921854e-01f, -8.52922127e-02f, -5.38119338e-02f, -9.33163911e-02f, -1.47352824e-02f, -3.80325094e-02f, -8.14324245e-03f,
  -8.61908570e-02f, -6.32502064e-02f, -1.90322157e-02f, 1.63359921e-02f, -8.83014500e-02f, -5.80670722e-02f, 4.93266024e-02f, -3.66191790e-02f, -1.00232154e-01f, 5.06440587e-02f,
  8.05889219e-02f, 3.29519026e-02f, -2.86475774e-02f, 3.95494774e-02f, 5.30907959e-02f, -8.06102231e-02f, -4.90582623e-02f, 3.60081829e-02f, 2.12553721e-02f, -1.34513238e-02f,
  6.04386767e-03f, -1.18635772e-02f, 4.88740159e-03f, -2.24933457e-02f, 4.27643722e-03f, -5.33919968e-02f, -3.50915603e-02f, -6.06805906e-02f, -3.91077437e-02f, -9.44026113e-02f,
  9.20685306e-02f, -5.48178703e-02f, -1.04452344e-02f, 2.07263026e-02f, 4.15089875e-02f, 1.09616462e-02f, -5.17625399e-02f, 7.83770252e-03f, -1.27768386e-02f, 7.39847822e-03f,
  5.18619344e-02f, 4.32353280e-03f, 2.90412158e-02f, -5.37311286e-02f, -3.59836444e-02f, -3.60154696e-02f, 5.59016466e-02f, -3.41693424e-02f, 7.80572817e-02f, 7.22565576e-02f,
  -2.01798161e-03f, -1.42102744e-02f, -3.65300998e-02f, -5.06037427e-03f, 5.44828735e-02f, -2.35826243e-02f, -1.90091878e-02f, -2.32134629e-02f, -3.39275748e-02f, -1.69163533e-02f,
  4.28102799e-02f, -7.16403872e-03f, -7.50445947e-03f, -1.71401948e-02f, 2.08731331e-02f, 1.64606832e-02f, 3.69133353e-02f, 2.76930463e-02f, 3.69777083e-02f, -5.09706587e-02f,
  2.93488920e-01f, 2.68187616e-02f, 3.69314663e-02f, 2.14249775e-01f, -7.93848038e-02f, -6.92188889e-02f, -9.00552645e-02f, 2.53025237e-02f, 1.50738969e-01f, -9.19795409e-02f,
  -2.20018074e-01f, 2.61021733e-01f, -1.71802208e-01f, 7.22303763e-02f, 1.85023591e-01f, -8.33320841e-02f, 8.31357613e-02f, 5.16198687e-02f, 1.17214806e-01f, 8.40642750e-02f,
  1.87017217e-01f, 9.58654191e-03f, 8.64748806e-02f, 4.35359888e-02f, 1.56783953e-01f, 1.61962092e-01f, 1.02811471e-01f, -1.58058524e-01f, 8.61687139e-02f, 7.94644281e-02f,
  -9.36920866e-02f, 5.90268597e-02f, -8.74681845e-02f, 4.92778830e-02f, 7.78160542e-02f, -4.73799482e-02f, 5.24991080e-02f, -8.57110173e-02f, 3.66437919e-02f, -6.70167431e-02f,
  -9.08908062e-03f, 2.99061742e-02f, 7.44582117e-02f, -1.70304403e-02f, 7.40645975e-02f, 1.00900163e-03f, -6.32200716e-03f, -6.22374862e-02f, 4.54197228e-02f, 7.19330981e-02f,
  8.23496003e-03f, 5.10563664e-02f, 2.30530370e-02f, 2.05739010e-02f, 6.41346946e-02f, -1.30794558e-03f, -1.22408913e-02f, -7.13418126e-02f, 3.43751833e-02f, 2.61354595e-02f,
  2.99737062e-02f, -2.00346671e-02f, -1.69330444e-02f, -7.98042640e-02f, 4.95942086e-02f, 1.63248111e-03f, -2.46531963e-02f, 6.29469194e-03f, 5.51195964e-02f, -5.47737367e-02f,
  -2.83300765e-02f, 2.95575112e-02f, -1.53788431e-02f, -3.62750888e-02f, 3.77385691e-02f, 7.33040720e-02f, 4.35486762e-03f, -5.33743687e-02f, -3.12648974e-02f, 2.42559332e-02f,
  -2.93743294e-02f, 4.28304859e-02f, -7.33492896e-02f, -6.98812380e-02f, 1.59781296e-02f, -3.14921141e-02f, 8.00542310e-02f, 4.34315205e-02f, 3.20902414e-04f, 4.32138182e-02f,
  -1.51407337e-04f, 2.14467898e-01f, 3.34352031e-02f, -8.39132536e-03f, -4.13416699e-02f, 4.66290526e-02f, 1.34582110e-02f, 6.40462786e-02f, 1.81524232e-02f, 8.60959962e-02f,
  -2.80112717e-02f, -4.23909873e-02f, -1.20749157e-02f, -2.51396536e-03f, -4.57947515e-02f, 8.31206888e-02f, 1.58714745e-02f, 4.52459082e-02f, 1.51850330e-03f, 1.07591366e-02f,
  2.05592439e-02f, -2.26802044e-02f, 8.73439014e-02f, 1.41339120e-03f, 1.08161382e-02f, 2.98229624e-02f, 1.04690179e-01f, 4.09147851e-02f, 2.97968332e-02f, 4.35534492e-02f,
  -1.75151005e-01f, 5.64106693e-03f, -3.59410904e-02f, 6.67499676e-02f, -1.19430274e-01f, -1.50906801e-01f, 1.05615538e-02f, 1.19790561e-01f, 3.13397497e-01f, 7.08843172e-02f,
  -6.33039325e-02f, -1.66546240e-01f, 6.69347048e-02f, 8.81454125e-02f, 5.58873825e-02f, 1.25364229e-01f, 1.15959458e-01f, -3.84476855e-02f, 9.61171091e-02f, -5.05270585e-02f,
  9.67937782e-02f, -1.42197469e-02f, 6.07637241e-02f, 1.01117408e-02f, -1.89786389e-01f, -3.35669778e-02f, -1.67025328e-01f, -9.53235105e-02f, -2.26245522e-01f, -9.60777551e-02f,
  8.13900605e-02f, 1.56274810e-02f, -6.54823780e-02f, 4.79712114e-02f, 2.42415466e-03f, -9.95153487e-02f, -5.96754365e-02f, -1.02970220e-01f, 1.56105710e-02f, 1.45819942e-02f,
  -6.99217767e-02f, 9.81075503e-03f, 3.42004113e-02f, 3.68321240e-02f, 2.69271117e-02f, 1.22558847e-02f, 9.13514942e-03f, -1.25664577e-03f, 3.72853912e-02f, -1.09196700e-01f,
  1.16835982e-02f, -3.78142623e-03f, -2.00958941e-02f, 6.94240555e-02f, 6.54997751e-02f, -3.95863280e-02f, -3.69925797e-02f, -1.25570580e-01f, -3.62874866e-02f, 5.87720610e-02f,
  -7.59681314e-02f, 4.42322232e-02f, 1.72157548e-02f, -8.03976357e-02f, -2.60738246e-02f, 4.48303623e-03f, -2.95191128e-02f, -7.32085109e-02f, 3.84112000e-02f, -1.95891466e-02f,
  -3.27111781e-02f, -6.39986768e-02f, 7.97623917e-02f, -1.10460371e-02f, -8.05885866e-02f, 5.69979921e-02f, -5.95670454e-02f, -4.11253981e-03f, 9.00045261e-02f, 7.87665248e-02f,
  9.13008153e-02f, 5.85698150e-02f, -2.78179403e-02f, -5.97767383e-02f, 6.13449961e-02f, 6.91043139e-02f, 3.54243927e-02f, -4.20400463e-02f, 6.57773912e-02f, -4.45007859e-03f,
  -8.08329508e-02f, 2.31564511e-02f, -2.96471044e-02f, 4.79918085e-02f, 9.66280475e-02f, -5.35044186e-02f, 5.24326302e-02f, 3.28329927e-03f, -7.26317838e-02f, -9.93813481e-03f,
  -1.02360830e-01f, 7.24889152e-03f, -1.76608935e-02f, 8.62650946e-03f, 9.02049690e-02f, 1.04013225e-02f, 3.77218202e-02f, 6.30890056e-02f, -2.77516956e-05f, 2.62091719e-02f,
  -3.38516757e-02f, 7.44067226e-03f, 4.08091675e-03f, 3.66895683e-02f, 1.71048974e-03f, -5.05437935e-03f, 3.79548222e-03f, 4.73435083e-03f, -4.50033136e-02f, -1.36973727e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.71412891e-02f, 1.65674865e-01f, 1.30157292e-01f, 1.30862281e-01f, -1.57984614e-01f, -1.25064015e-01f, -1.53404579e-01f, -2.89324895e-02f, 9.06453356e-02f, -4.91662212e-02f,
  -7.77817294e-02f, 3.09264094e-01f, -1.38704330e-01f, 9.39116068e-03f, -1.13388352e-01f, -9.39149484e-02f, -1.18197106e-01f, -1.64646748e-02f, -2.71849670e-02f, -1.92342363e-02f,
  -8.07310417e-02f, -1.99108690e-01f, -1.57758091e-02f, -2.39041098e-03f, 8.26694146e-02f, -7.01814564e-03f, -1.77257121e-01f, 2.80887890e-03f, 6.23341203e-02f, -1.65608637e-02f,
  8.33373591e-02f, -7.51758053e-04f, 1.28776774e-01f, 5.94993457e-02f, -4.31505106e-02f, -4.56867851e-02f, 1.14201516e-01f, -2.12206580e-02f, -4.29190975e-03f, 2.38775965e-02f,
  1.07210338e-01f, 5.87595887e-02f, -5.36075328e-03f, 4.15144004e-02f, -9.41746403e-03f, 4.24942784e-02f, 7.86176175e-02f, -6.39314298e-03f, 3.96911316e-02f, 8.57981220e-02f,
  1.47583008e-01f, 8.80203918e-02f, -1.57223921e-02f, 3.97179127e-02f, -4.39715050e-02f, 1.19229164e-02f, 5.28512262e-02f, 7.93477073e-02f, -4.48443741e-03f, -6.59911335e-03f,
  5.21675050e-02f, -2.63642427e-03f, -5.32259559e-03f, -5.16810827e-02f, -1.98137760e-02f, 5.92652820e-02f, -1.27958553e-02f, -7.12452084e-02f, -4.54498492e-02f, 3.52392830e-02f,
  -9.57173929e-02f, -3.31414975e-02f, -5.17197289e-02f, -7.77770579e-02f, -8.33524987e-02f, 7.32999071e-02f, 6.37408271e-02f, 9.10464376e-02f, 1.56043582e-02f, -1.31869381e-02f,
  4.55120094e-02f, -2.41663996e-02f, 3.76345553e-02f, -4.46524695e-02f, -1.15259849e-02f, -6.60083890e-02f, -1.68294529e-03f, 5.50854136e-04f, -3.04111410e-02f, -2.08257772e-02f,
  -1.41419604e-01f, -1.33031026e-01f, -3.25187556e-02f, 8.60028565e-02f, 4.47495878e-02f, -7.28547573e-02f, 6.26105070e-02f, -1.79690719e-02f, -4.88647074e-02f, 3.80429532e-03f,
  1.94821935e-02f, -1.60197895e-02f, 1.18495068e-02f, 6.25328273e-02f, 2.29837559e-02f, -2.57805176e-02f, 5.03113568e-02f, 9.21065807e-02f, -5.06806746e-02f, -1.75611523e-03f,
  -4.30518501e-02f, -2.64313328e-03f, -1.73945073e-02f, -3.02344691e-02f, -4.50863838e-02f, -2.47882996e-02f, 3.27420118e-03f, -2.14567184e-02f, -6.46722913e-02f, -8.61527249e-02f,
  -3.69535796e-02f, 1.04557886e-03f, 1.30487382e-02f, -8.56591314e-02f, -5.15142195e-02f, -4.66285385e-02f, -8.02674890e-02f, -6.62139952e-02f, -7.92178214e-02f, 8.58121738e-02f,
  2.49599339e-03f, -2.77919415e-02f, -8.94390494e-02f, -1.46577701e-01f, -2.40699798e-01f, -6.71717674e-02f, -6.37563914e-02f, -6.83223307e-02f, -5.33481985e-02f, -1.67616345e-02f,
  -5.80047369e-02f, -2.36010570e-02f, -1.80937983e-02f, -2.33847648e-02f, 2.80950721e-02f, 1.15452096e-01f, 1.32844001e-01f, -5.97383454e-02f, 1.04170345e-01f, -1.35635093e-01f,
  -5.76774403e-02f, -8.24279189e-02f, 8.98517743e-02f, -4.43433635e-02f, -3.67700532e-02f, 6.72039539e-02f, 7.25452006e-02f, -3.36219110e-02f, -8.96890536e-02f, -6.76453114e-02f,
  1.10898279e-01f, -5.89086786e-02f, 2.33795363e-02f, 6.23069145e-03f, 2.10224316e-02f, -7.27917328e-02f, 2.89002825e-02f, 1.02894329e-01f, 4.99621071e-02f, 7.61672035e-02f,
  6.18219487e-02f, -4.32498084e-04f, -3.61841824e-03f, 3.11215632e-02f, -2.41045021e-02f, 2.18829643e-02f, 8.19869265e-02f, 4.40028310e-03f, 9.94453281e-02f, 3.79221663e-02f,
  3.01954802e-03f, 6.13824949e-02f, -8.41529742e-02f, 6.05562367e-02f, 4.52506244e-02f, 3.54520380e-02f, 3.12286597e-02f, -6.35044351e-02f, 7.37040043e-02f, 6.21845499e-02f,
  -1.01883190e-04f, 2.01693624e-02f, 6.17242344e-02f, 8.37969482e-02f, -8.15369934e-02f, 2.70404853e-02f, -7.45915174e-02f, 6.39307499e-02f, -2.80553531e-02f, 6.76629990e-02f,
  -5.87818213e-02f, -2.81163747e-03f, -1.03016412e-02f, -1.85709056e-02f, -3.02004982e-02f, 8.48352537e-02f, -6.29759133e-02f, -4.71145380e-03f, -6.14851378e-02f, 1.70553718e-02f,
  8.23912583e-03f, 9.37962979e-02f, -5.33663444e-02f, 4.80142459e-02f, 7.52980039e-02f, -1.09904725e-02f, -1.56244440e-02f, 4.79413532e-02f, 3.07380669e-02f, -2.67984048e-02f,
  8.13199505e-02f, 1.09470859e-01f, 3.40887010e-02f, 4.67479229e-02f, 6.04512356e-03f, 5.01386896e-02f, 5.61437830e-02f, 9.27436501e-02f, -1.70310363e-02f, 9.92312580e-02f,
  1.26387909e-01f, 3.52438986e-02f, 3.16192843e-02f, 5.35829961e-02f, 1.40576418e-02f, 6.64483663e-03f, -3.63353044e-02f, 8.26233923e-02f, 1.03827767e-01f, 7.09385127e-02f,
  -8.13202932e-02f, 1.75501913e-01f, 2.73104645e-02f, -1.33179069e-01f, -1.19276002e-01f, -2.04285547e-01f, -1.89045832e-01f, 3.68492422e-03f, 3.22329253e-02f, 9.13589448e-02f,
  -3.83089371e-02f, 8.10560584e-02f, 1.11110516e-01f, 4.36603203e-02f, 2.22168155e-02f, 1.11002922e-01f, -1.07277967e-01f, 2.45343931e-02f, 6.93383142e-02f, 2.87327375e-02f,
  9.14856195e-02f, -7.79893100e-02f, 4.63721156e-02f, 1.39127702e-01f, -3.65702398e-02f, 2.69173235e-02f, 9.34560746e-02f, 8.73085111e-02f, 2.00084709e-02f, -3.75336856e-02f,
  -4.64682765e-02f, 3.22961397e-02f, 7.61145055e-02f, -4.55218852e-02f, 1.40888495e-02f, 5.02697676e-02f, -3.13752593e-04f, -4.18870598e-02f, 1.70045383e-02f, -1.94463681e-03f,
  -1.00625858e-01f, -5.07035293e-02f, 1.86880454e-02f, 3.43997702e-02f, -8.37363023e-03f, -2.54129283e-02f, 9.99355037e-03f, -4.83249836e-02f, -3.02019808e-03f, 4.95420536e-04f,
  4.98637371e-02f, -3.85003388e-02f, -9.16466936e-02f, 7.27980435e-02f, -4.02918644e-02f, -1.76146273e-02f, 1.70883834e-02f, 8.01956430e-02f, -7.68974330e-03f, 2.68461630e-02f,
  5.21870703e-02f, -8.95411298e-02f, -1.04916459e-02f, -2.00955570e-02f, -1.80997793e-02f, 4.41952460e-02f, -1.95441507e-02f, 1.01495937e-01f, -4.03618626e-02f, 5.43784760e-02f,
  1.89849338e-03f, -8.11153650e-02f, 5.50073981e-02f, -6.00478239e-03f, -1.44869136e-03f, 5.15592732e-02f, -1.45450393e-02f, -6.21048585e-02f, 1.72047298e-02f, 8.68302360e-02f,
  -2.35968567e-02f, -5.91219030e-02f, 1.04870573e-01f, -6.87935799e-02f, 4.93488722e-02f, -1.82769764e-02f, 4.53546308e-02f, 9.75242481e-02f, 4.27618483e-03f, -8.05211067e-02f,
  1.83432046e-02f, -9.84298158e-03f, -4.23602201e-02f, 3.95314954e-02f, 3.73980105e-02f, 3.79556976e-02f, -6.61711581e-03f, -6.17862009e-02f, -6.99438453e-02f, 3.91246453e-02f,
  -2.30723899e-02f, 1.12003135e-02f, -9.31627303e-02f, 2.44816132e-02f, 6.80409446e-02f, 7.46386126e-02f, 6.59044459e-02f, 9.41716060e-02f, -6.73310980e-02f, 4.64301221e-02f,
  -2.84716710e-02f, 2.85164416e-02f, -7.73254856e-02f, 7.94887468e-02f, -9.19160023e-02f, -9.24204290e-02f, -8.60766172e-02f, 4.98071089e-02f, 4.33946699e-02f, 6.90026060e-02f,
  1.11820243e-01f, 1.65528916e-02f, 5.46890981e-02f, 2.13632956e-01f, -8.92189518e-02f, -1.00411110e-01f, 5.72453253e-02f, 1.53426498e-01f, -3.95740494e-02f, -1.66492373e-01f,
  -5.54746687e-02f, -4.76083830e-02f, -4.27719913e-02f, -3.10908016e-02f, 1.69151630e-02f, -7.20856637e-02f, 1.46838296e-02f, -2.41910480e-02f, -1.84572432e-02f, 3.81443687e-02f,
  1.18885323e-01f, 1.05397381e-01f, 1.22200988e-01f, 9.20525491e-02f, 1.58854827e-01f, 2.02744842e-01f, 9.60589647e-02f, 6.62724227e-02f, 1.64843410e-01f, -7.17519894e-02f,
  2.53629610e-02f, 4.97061908e-02f, -3.53042521e-02f, 5.10051362e-02f, -2.41906550e-02f, 2.42415462e-02f, 1.92051884e-02f, 2.43517142e-02f, -1.32039664e-02f, 5.78597300e-02f,
  3.73189673e-02f, 6.22446872e-02f, -1.18875187e-02f, 7.65350685e-02f, -5.65584712e-02f, -1.90896690e-02f, 4.24467549e-02f, 3.53143066e-02f, -8.46109465e-02f, -2.36694403e-02f,
  -3.53356190e-02f, -6.96770176e-02f, -4.80486825e-02f, -4.66370443e-03f, 6.18812777e-02f, 4.45614792e-02f, -9.80697870e-02f, -1.82331558e-02f, -1.76055431e-02f, 2.80952919e-03f,
  -2.74792872e-02f, 4.71444204e-02f, -1.07753441e-01f, -2.35006586e-02f, 7.61834846e-04f, 5.80432154e-02f, 4.48281690e-02f, 1.28291799e-02f, 6.48256838e-02f, 5.90245463e-02f,
  -4.47377302e-02f, 2.77265105e-02f, 7.13184699e-02f, -7.48749077e-02f, 1.20783374e-02f, 4.69426773e-02f, -4.31795269e-02f, 5.16506806e-02f, 7.53905252e-02f, 4.09268178e-02f,
  4.52496633e-02f, 4.27728668e-02f, -2.34861020e-02f, 7.55631104e-02f, 3.58567946e-02f, 6.38133660e-02f, -1.39054768e-02f, 3.83639373e-02f, 4.56208773e-02f, -3.60941887e-02f,
  1.30602038e-02f, 5.42820431e-02f, 5.59317879e-02f, -1.25356391e-02f, -5.82186840e-02f, -4.44985181e-02f, 2.44909078e-02f, 3.19191813e-02f, 2.71725915e-02f, 2.99369302e-02f,
  -5.49523272e-02f, 3.86518314e-02f, -1.83911733e-02f, -4.88614962e-02f, 4.01740372e-02f, 4.55430336e-02f, 2.39372980e-02f, -2.04530079e-02f, -6.65886179e-02f, -5.27658612e-02f,
  3.09668928e-02f, 3.43888290e-02f, -7.50683621e-03f, 2.63178977e-03f, 1.13512820e-03f, -1.81711297e-02f, -3.72739546e-02f, 4.58545685e-02f, -1.80080384e-02f, -1.11938240e-02f,
  1.58334628e-01f, 5.99535443e-02f, -3.13610733e-02f, -1.48229644e-01f, 1.50893573e-02f, -8.94767568e-02f, -3.84658650e-02f, -3.87793146e-02f, 3.92728336e-02f, 1.17351614e-01f,
  7.63349533e-02f, 2.59865038e-02f, -7.94444699e-03f, -1.70907989e-01f, -1.34255849e-02f, -2.87389811e-02f, -1.28268264e-02f, 3.27930525e-02f, -3.13611776e-02f, -6.58857962e-03f,
  -2.02342179e-02f, -1.23796508e-01f, -1.15255810e-01f, -1.23438157e-01f, -1.08077012e-01f, 7.22212791e-02f, 5.22252396e-02f, -9.85116512e-02f, 5.27546927e-02f, -1.00817390e-01f,
  7.17140585e-02f, 9.73703936e-02f, 6.02901541e-02f, 9.62250959e-03f, 5.49550094e-02f, -4.02776226e-02f, -6.44157873e-03f, -9.34307203e-02f, -1.04496386e-02f, 1.38466796e-02f,
  4.87721749e-02f, -8.67911279e-02f, -1.91555489e-02f, -2.22136006e-02f, 7.38141760e-02f, -5.53268604e-02f, -9.61266756e-02f, 8.23410079e-02f, 3.36136743e-02f, -9.38002393e-02f,
  -3.67054455e-02f, -6.95092082e-02f, -2.41060499e-02f, -2.62813587e-02f, -1.70009322e-02f, -2.63392553e-02f, 3.86861823e-02f, 4.54488881e-02f, 8.65090266e-02f, 1.89989794e-03f,
  -2.96296794e-02f, 2.60370993e-03f, 7.00820461e-02f, -1.46198124e-02f, 7.88183659e-02f, 9.13593359e-03f, -9.00437981e-02f, 5.86027130e-02f, 3.22280116e-02f, -5.55848703e-02f,
  3.80498394e-02f, 6.66953847e-02f, -5.94755970e-02f, 5.60078956e-02f, -4.22684178e-02f, 5.14345802e-02f, 2.54226681e-02f, 3.76094878e-02f, 6.29204363e-02f, 7.02528134e-02f,
  -1.47696696e-02f, 3.05425376e-02f, -2.50968225e-02f, 1.83397848e-02f, 6.88973665e-02f, 3.73334885e-02f, 2.64305826e-02f, -9.26229171e-03f, 7.72025064e-02f, 6.74991384e-02f,
  -2.28447001e-02f, 4.50852967e-04f, 5.69341220e-02f, -5.26726693e-02f, 7.65609741e-02f, -6.45410791e-02f, 5.47837913e-02f, -9.02634561e-02f, -7.63439313e-02f, -7.46980980e-02f,
  -3.42162587e-02f, 1.46141499e-02f, -5.20947799e-02f, -6.39473200e-02f, -9.78410318e-02f, -6.94647580e-02f, -4.41443138e-02f, 1.54131744e-02f, -3.92937586e-02f, 8.31075981e-02f,
  6.71072900e-02f, -2.24797484e-02f, 8.02520737e-02f, -2.43580453e-02f, 1.65456198e-02f, 4.16961638e-03f, 9.45194885e-02f, -3.26160677e-02f, 6.90258667e-02f, 1.48577197e-03f,
  -4.30606157e-02f, 8.08960851e-03f, 2.22229436e-02f, 4.26713116e-02f, -7.02348817e-03f, -7.74012282e-02f, -1.26289383e-01f, 6.36708215e-02f, -1.98731646e-02f, 1.82545587e-01f,
  -4.49119620e-02f, -2.70941597e-03f, 5.54315411e-02f, -4.19168323e-02f, -2.74046659e-01f, -9.91460606e-02f, -1.00798503e-01f, 7.48316571e-03f, 2.62375195e-02f, -3.46132480e-02f,
  -6.50805011e-02f, -7.35043883e-02f, -1.55369227e-03f, -6.68141097e-02f, 3.04930545e-02f, 6.91246465e-02f, 4.57694344e-02f, -2.89346781e-02f, -3.59965977e-03f, -5.94823547e-02f,
  -8.47111270e-02f, 9.66439173e-02f, 8.21269304e-02f, -6.81182891e-02f, -2.96475012e-02f, 6.40336722e-02f, 5.07232770e-02f, -1.05197847e-01f, 5.62125957e-03f, 1.80393606e-02f,
  1.15924561e-02f, -1.82721838e-02f, 3.65099795e-02f, -2.36607669e-03f, 1.57574471e-02f, 6.42155930e-02f, -3.19314152e-02f, 7.66419470e-02f, 1.16213541e-02f, 5.53437546e-02f,
  3.37397382e-02f, 7.83844963e-02f, 2.41888090e-04f, -9.05466150e-04f, 5.94593436e-02f, -5.96023165e-02f, 2.01450884e-02f, 2.92755682e-02f, 4.79833446e-02f, 4.44472954e-03f,
  -7.41367415e-02f, -8.25139694e-03f, 2.52504405e-02f, -6.44106185e-03f, -2.52857637e-02f, -2.14325413e-02f, -1.72454435e-02f, 4.46237959e-02f, -2.51606256e-02f, 3.18779536e-02f,
  -4.11737189e-02f, 2.72746738e-02f, 4.23793943e-04f, -7.01671317e-02f, -3.68184894e-02f, 6.61725774e-02f, 3.19320336e-02f, 6.06347620e-03f, -1.58584956e-02f, 2.09773928e-02f,
  1.09331673e-02f, -1.40552567e-02f, -2.37268861e-02f, -9.54099558e-03f, -1.30723640e-02f, 2.66380166e-03f, -6.27641901e-02f, -6.38945326e-02f, -4.91489843e-02f, -9.18689370e-02f,
  3.89750190e-02f, 7.14853853e-02f, 7.16562271e-02f, 7.93772750e-03f, 4.96955663e-02f, -4.56049815e-02f, -2.65679602e-02f, -4.94803749e-02f, -1.42054893e-02f, -9.76107419e-02f,
  -7.85950348e-02f, 2.92187510e-03f, -1.20619056e-03f, 2.66495347e-02f, -4.60561700e-02f, -3.87501270e-02f, 9.25044119e-02f, -3.79571430e-02f, -2.81587034e-03f, 8.62442032e-02f,
  4.40668762e-02f, 6.43155649e-02f, 6.72519431e-02f, -1.35779316e-02f, 5.34912087e-02f, 8.13979581e-02f, 1.63397305e-02f, -3.81703787e-02f, -6.09562732e-03f, 7.31170997e-02f,
  5.92179410e-02f, 7.72457197e-02f, -1.02726996e-01f, 5.49926199e-02f, -1.28176317e-01f, -4.87571359e-02f, -5.26739545e-02f, -9.66760814e-02f, -8.41898173e-02f, 9.53406468e-03f,
  -2.89830770e-02f, -9.02379863e-03f, 2.32760943e-02f, 8.94577801e-02f, 1.26136824e-01f, 1.58349693e-01f, -1.36930468e-02f, 7.46466070e-02f, -8.61721635e-02f, 2.66971122e-02f,
  -1.20393196e-02f, 5.50668314e-02f, 1.58071686e-02f, -2.31581666e-02f, -6.30466416e-02f, -1.25355810e-01f, -6.10151850e-02f, -1.16186626e-01f, -3.05361971e-02f, 1.09050833e-02f,
  7.16255754e-02f, 2.60522962e-02f, -3.10668424e-02f, 7.48672709e-02f, 3.77289893e-04f, -5.92407174e-02f, -4.45941165e-02f, 2.13934183e-02f, -7.72143230e-02f, -7.19866082e-02f,
  -2.53451932e-02f, 4.38738056e-02f, -7.15073273e-02f, 2.43057888e-02f, -2.89266910e-02f, 1.93490349e-02f, -2.32502520e-02f, -6.15672767e-02f, 5.96120209e-03f, 7.71252215e-02f,
  -1.04122467e-01f, -1.69093404e-02f, -6.05571717e-02f, 3.92458998e-02f, -7.60884956e-02f, -9.49222818e-02f, -6.41984642e-02f, 9.84601527e-02f, -2.54500248e-02f, 1.78889651e-02f,
  7.35842064e-02f, 1.11650683e-01f, -2.20718514e-02f, 1.00139799e-02f, -3.94719839e-02f, -6.01473823e-03f, 3.08303963e-02f, 2.95653660e-02f, 6.43030033e-02f, -6.90568984e-02f,
  -5.65808043e-02f, -9.13172886e-02f, -4.39956784e-02f, 8.78426582e-02f, -5.56453643e-03f, 1.10121779e-02f, -5.14828898e-02f, 4.73648915e-03f, -6.38870448e-02f, -1.49312662e-03f,
  1.02408744e-01f, -5.37645556e-02f, 8.19877908e-02f, -2.85689365e-02f, 4.01184596e-02f, 2.03969143e-03f, -7.91971982e-02f, 4.93981168e-02f, -3.55257764e-02f, -5.60150445e-02f,
  5.19139320e-02f, 1.65833384e-02f, 7.18100071e-02f, 7.06545562e-02f, 5.81681452e-05f, 6.74201399e-02f, -6.07592203e-02f, -5.49802072e-02f, -8.59942213e-02f, 6.24569729e-02f,
  7.63818771e-02f, -5.37276864e-02f, -6.52399734e-02f, 3.86785902e-02f, 7.24854097e-02f, -5.58340214e-02f, 1.03681609e-01f, -6.07523695e-02f, 8.71890113e-02f, -1.85526151e-03f,
  8.19178894e-02f, -7.94191509e-02f, -5.04878610e-02f, 7.78486058e-02f, 7.68333226e-02f, 3.81303206e-02f, -5.99917658e-02f, -2.63437554e-02f, -3.31622474e-02f, 1.48935728e-02f,
  1.47030324e-01f, -1.46728009e-01f, -2.01639995e-01f, -1.42829031e-01f, 5.69945164e-02f, -2.00310964e-02f, -3.53061110e-02f, -4.46008593e-02f, -1.10346116e-01f, 5.43903708e-02f,
  -8.16214532e-02f, -1.25147104e-01f, -9.54464450e-02f, 1.69290360e-02f, 5.29690050e-02f, 3.48129570e-02f, -9.88642797e-02f, -8.39798301e-02f, 5.91162853e-02f, 6.12540208e-02f,
  6.31889403e-02f, 1.45049319e-01f, -1.39007285e-01f, 8.62934515e-02f, -7.51189142e-02f, 6.73140213e-02f, 1.65115938e-01f, 2.16654707e-02f, 9.48179364e-02f, 1.20595872e-01f,
  3.90912928e-02f, -7.66925514e-02f, -1.65668186e-02f, 3.22010294e-02f, 2.29586754e-02f, 2.89493874e-02f, -2.10323557e-02f, -4.59469296e-02f, 6.09953329e-02f, 6.07042462e-02f,
  8.22433233e-02f, 4.86600623e-02f, -4.62225899e-02f, 9.59734153e-03f, -2.46030148e-02f, 3.33204307e-02f, -8.54072496e-02f, -4.60787788e-02f, -6.58150762e-02f, -3.47413197e-02f,
  -1.23544559e-01f, 2.98120137e-02f, 1.89691093e-02f, 4.75070626e-02f, 3.50524895e-02f, -6.52416497e-02f, 1.40992058e-02f, -3.53095159e-02f, -8.57992694e-02f, -3.01417839e-02f,
  9.33332145e-02f, 9.53465104e-02f, 1.21480655e-02f, -5.36447428e-02f, -2.66586393e-02f, -2.64193695e-02f, 8.62097740e-02f, 9.64187011e-02f, -7.11699657e-04f, 1.84465107e-02f,
  5.46941124e-02f, -8.77762958e-02f, 1.06187746e-01f, -3.03096208e-03f, 7.63744190e-02f, 6.39745295e-02f, 7.68304914e-02f, 1.40619939e-02f, -1.95136238e-02f, -7.33514428e-02f,
  8.23104233e-02f, -2.86932215e-02f, 1.19398218e-02f, -5.61833866e-02f, 2.29706592e-03f, -5.73088527e-02f, 8.64898413e-02f, 6.95579499e-02f, 4.89729233e-02f, -2.41737701e-02f,
  5.92186674e-02f, -1.13845114e-02f, -3.75918448e-02f, -2.48608720e-02f, 5.40617742e-02f, 2.70569343e-02f, -3.06485668e-02f, -2.36811750e-02f, -8.88039824e-03f, 7.03519136e-02f,
  -3.51284035e-02f, 5.56323975e-02f, -5.79633489e-02f, -1.04958452e-02f, 1.58989094e-02f, -1.93036366e-02f, -2.82776006e-03f, 4.55114841e-02f, 7.01440051e-02f, 3.61342430e-02f,
  -1.00413077e-02f, 2.63981186e-02f, 6.34166179e-03f, -1.71437841e-02f, 9.07315314e-02f, -4.54420075e-02f, 9.18163732e-02f, 3.41607817e-02f, 7.86418617e-02f, -7.40857273e-02f,
  -7.52724533e-04f, 8.46995693e-03f, -4.88199480e-02f, 9.73745659e-02f, -8.44355822e-02f, -3.09204340e-01f, -1.81543827e-01f, 3.73158115e-03f, -5.01691699e-02f, -7.67718926e-02f,
  8.07247907e-02f, 1.39702871e-01f, 7.31323957e-02f, 6.40743673e-02f, 4.83457595e-02f, 1.00856975e-01f, 5.34870140e-02f, -3.67382099e-03f, 2.39105355e-02f, 1.38690129e-01f,
  6.58977553e-02f, 3.87007073e-02f, 8.78974721e-02f, 5.18120825e-02f, 5.06958039e-03f, 2.69357599e-02f, 1.69474348e-01f, -9.95877013e-02f, 7.08159208e-02f, 2.68480871e-02f,
  -1.91370472e-02f, 1.69165999e-01f, 5.26855513e-02f, 2.68212054e-02f, 6.00233488e-02f, -6.25194376e-03f, -4.81184479e-03f, -1.00648776e-01f, 2.99326866e-03f, -4.63223271e-02f,
  -8.31153244e-03f, -1.30688800e-02f, 5.18016666e-02f, 4.67458107e-02f, -5.74248992e-02f, 9.46989581e-02f, -5.11835143e-02f, 3.81188355e-02f, 1.18906051e-03f, 4.65841256e-02f,
  -6.26984164e-02f, 9.87751856e-02f, 4.35437113e-02f, -1.06524603e-04f, 3.20983008e-02f, -1.09040275e-01f, 5.68400975e-03f, 1.02217838e-01f, 5.73771298e-02f, 6.23522252e-02f,
  8.85781944e-02f, 2.65921187e-02f, -1.46543011e-02f, 3.17863859e-02f, -7.39321783e-02f, -2.17748377e-02f, -4.45534624e-02f, 1.21130897e-02f, -1.06722815e-02f, -4.69009206e-02f,
  -2.63276137e-03f, 7.13940384e-03f, -5.54015413e-02f, -8.62434506e-02f, -5.61230630e-02f, 4.55981754e-02f, -2.80587329e-03f, 3.11561245e-02f, -5.09942845e-02f, 3.99219394e-02f,
  -7.08393604e-02f, 1.73114520e-02f, 8.55512917e-03f, 1.53207891e-02f, -7.53009468e-02f, 4.81652189e-03f, 2.73133423e-02f, 5.08944541e-02f, 6.96516931e-02f, 6.53984919e-02f,
  5.60048968e-02f, 1.77193224e-01f, -3.84247452e-02f, -2.83406023e-02f, -3.50327343e-02f, -2.16789450e-02f, -3.98565717e-02f, -7.21212178e-02f, -4.47648810e-04f, 6.93572313e-02f,
  8.89744535e-02f, -2.21501160e-02f, 7.02964813e-02f, -6.31396323e-02f, -2.32055653e-02f, 4.85785753e-02f, 6.52713748e-03f, 3.50845084e-02f, 9.33839604e-02f, 6.46875724e-02f,
  -4.86275777e-02f, -6.75161555e-02f, 6.51853019e-03f, -1.23479217e-02f, 5.44251278e-02f, 3.97809446e-02f, -2.01563556e-02f, 2.84246895e-02f, 1.72248241e-02f, 7.68176243e-02f,
  -1.42701976e-02f, -2.17784807e-01f, -5.76179400e-02f, 1.08055174e-01f, -6.12909384e-02f, 6.17304444e-02f, 9.15820599e-02f, -1.05891734e-01f, -9.53225717e-02f, -1.08463801e-01f,
  -3.35286334e-02f, -2.16616169e-02f, -1.17182866e-01f, 9.63694900e-02f, 2.11937964e-01f, 7.11241886e-02f, 1.56914681e-01f, 1.92195535e-01f, -4.50694934e-02f, -1.36519954e-01f,
  -4.89634871e-02f, 1.70276128e-02f, -1.54994917e-03f, -8.86880308e-02f, 3.76790278e-02f, 3.43781598e-02f, 1.54552698e-01f, -5.93418255e-03f, 1.47104561e-01f, 5.20594120e-02f,
  5.16455732e-02f, -1.04863063e-01f, -9.84503794e-03f, 5.12458161e-02f, -7.75104314e-02f, 1.72793008e-02f, 1.27237022e-01f, 1.62192523e-01f, -3.80619578e-02f, -5.13622388e-02f,
  4.13335068e-03f, 6.23101043e-03f, 8.87447745e-02f, 5.00305369e-02f, -9.07000899e-02f, 1.27833886e-02f, 4.27295007e-02f, -4.12477627e-02f, 6.72909012e-03f, -8.90327767e-02f,
  -1.46289229e-01f, -1.88136962e-03f, 3.41432244e-02f, -3.98682244e-02f, 1.99878998e-02f, -6.76436275e-02f, 9.52852368e-02f, -3.51097016e-03f, 6.63768053e-02f, 1.04675792e-01f,
  -2.98982654e-02f, 2.38179304e-02f, -3.72063508e-03f, 7.14017078e-02f, -1.09199602e-02f, -7.17004687e-02f, -1.31332362e-02f, 1.00179255e-01f, 8.59793946e-02f, 9.63260327e-03f,
  -3.68296504e-02f, -9.29535180e-02f, -7.10513517e-02f, 6.08206578e-02f, 3.96585949e-02f, -5.62931485e-02f, 3.09441495e-03f, -2.68492308e-02f, 1.57891661e-02f, -1.48807392e-02f,
  -6.10337108e-02f, -1.09763043e-02f, 3.12561616e-02f, -3.26120667e-02f, 1.40179573e-02f, -1.06057280e-03f, -1.32189747e-02f, 4.22499068e-02f, -1.01407342e-01f, -6.48474470e-02f,
  -7.69956633e-02f, -3.55653763e-02f, -7.57214502e-02f, 3.19574177e-02f, -6.30690623e-03f, 3.52559239e-02f, 7.52046555e-02f, 7.11903535e-03f, -8.83716568e-02f, -4.73862737e-02f,
  -4.80234176e-02f, -3.28319445e-02f, -2.77513247e-02f, 8.73218849e-02f, -2.78195404e-02f, -4.99787405e-02f, 8.37689545e-03f, -3.30278575e-02f, 3.97545248e-02f, -3.89402546e-02f,
  -1.07975960e-01f, 1.61241423e-02f, 1.09388195e-01f, -6.09296337e-02f, -5.52669109e-04f, 2.04994176e-02f, 8.13805982e-02f, 8.64934847e-02f, 7.70533532e-02f, 3.43148336e-02f,
  -2.97252145e-02f, 1.54386893e-01f, 1.78960823e-02f, 8.91766027e-02f, -1.01564862e-01f, 4.48806509e-02f, 5.33769513e-03f, 3.91680412e-02f, -8.07454363e-02f, 1.75898522e-01f,
  -1.30164474e-01f, 1.67551324e-01f, -1.55144259e-01f, 2.84531992e-02f, -1.69305369e-01f, -1.63644850e-01f, 1.41775101e-01f, 2.58165449e-02f, -2.10671797e-02f, 2.04608291e-02f,
  -7.14318380e-02f, -2.33616475e-02f, -1.30406365e-01f, -2.86085177e-02f, -1.09657152e-02f, 8.84023011e-02f, 5.72486073e-02f, 2.39310637e-02f, 1.56266347e-01f, -1.18457898e-01f,
  5.95337078e-02f, 2.82194912e-02f, -3.14479284e-02f, 1.18903063e-01f, 6.11508153e-02f, 3.80286798e-02f, 1.19646959e-01f, 2.30922140e-02f, 6.18694685e-02f, 5.86685017e-02f,
  6.30647987e-02f, 5.35480268e-02f, -4.36034501e-02f, 1.38409734e-02f, 8.54643583e-02f, -6.68460578e-02f, -5.75431585e-02f, -1.95285548e-02f, 2.53433604e-02f, -3.20546031e-02f,
  -1.42370036e-03f, -1.56214209e-02f, 1.15699492e-01f, 4.18422446e-02f, 2.41316501e-02f, 7.14674070e-02f, 1.68787017e-02f, 2.15389952e-02f, 5.04963584e-02f, 7.85710216e-02f,
  4.98690456e-02f, -3.87498438e-02f, 3.38693708e-02f, 2.39576884e-02f, -9.13663134e-02f, -3.16010267e-02f, 3.67832258e-02f, -5.62829636e-02f, -6.27786815e-02f, -7.19157606e-02f,
  1.43569731e-03f, -6.94296658e-02f, -3.29903215e-02f, -1.04659200e-02f, 3.17826681e-02f, 7.40912557e-02f, -2.54926905e-02f, -2.13355292e-02f, 3.91348526e-02f, 4.94041145e-02f,
  3.83481905e-02f, 8.37712586e-02f, 1.73557235e-03f, -2.61699408e-02f, 1.58631708e-02f, 1.47016870e-03f, 2.01462414e-02f, 6.36691749e-02f, -4.46220599e-02f, -3.09902392e-02f,
  -1.27913430e-02f, 4.38840427e-02f, -6.46565557e-02f, -9.78605077e-03f, 1.13100253e-01f, 5.60535081e-02f, 3.86038683e-02f, 1.13229290e-01f, -1.12572722e-02f, -3.35649550e-02f,
  1.10345140e-01f, 2.33850777e-02f, 8.08379948e-02f, 5.96570782e-03f, 2.17917301e-02f, -7.77652636e-02f, 6.96487576e-02f, 4.55182940e-02f, 1.39849447e-02f, -2.51467247e-03f,
  -1.54534327e-02f, 6.83488026e-02f, 7.69170672e-02f, 4.35015000e-03f, -6.11112416e-02f, 2.09475569e-02f, 8.33624303e-02f, -4.47501056e-02f, 1.39431888e-02f, -2.85651572e-02f,
  4.41577472e-02f, -5.43372147e-02f, -2.59164006e-01f, 6.33084625e-02f, -4.02889540e-03f, 9.86544415e-02f, 3.25121246e-02f, 8.15285444e-02f, -9.66239255e-03f, 9.61822122e-02f,
  5.48382439e-02f, -9.92451459e-02f, -2.63025649e-02f, 1.88779399e-01f, -9.19691175e-02f, -5.12937382e-02f, 1.31683692e-01f, 8.62240568e-02f, -9.00097713e-02f, -2.13704146e-02f,
  3.17814276e-02f, 1.24039054e-01f, -1.22535922e-01f, 1.64595366e-01f, 6.11306839e-02f, 3.61071061e-03f, -2.63465266e-03f, -1.02223508e-01f, 1.57988012e-01f, 5.55536486e-02f,
  5.60839921e-02f, 6.81953132e-02f, 1.35481087e-02f, -2.31767669e-02f, -6.10293895e-02f, 3.59009840e-02f, -4.98437360e-02f, 5.20896129e-02f, -7.85320774e-02f, -8.83596465e-02f,
  7.69466441e-03f, 6.72032237e-02f, 6.15912937e-02f, 8.06639940e-02f, -3.45430486e-02f, -5.34894653e-02f, -9.61433947e-02f, -9.47867185e-02f, -8.23197439e-02f, -4.85027917e-02f,
  -2.31710896e-02f, 1.57047641e-02f, 1.19176963e-02f, 1.03682633e-02f, -5.18044718e-02f, 4.30357680e-02f, 4.97399569e-02f, -3.35758664e-02f, 2.04692502e-02f, 5.23173716e-03f,
  5.65462820e-02f, 7.69822598e-02f, 6.76329732e-02f, 6.38364702e-02f, -2.21644640e-02f, 8.02254006e-02f, 2.07549743e-02f, -2.52839550e-02f, -5.75690083e-02f, 8.03377479e-02f,
  -1.00866176e-01f, -8.16704333e-03f, 5.42212985e-02f, -5.59758022e-03f, 1.04268948e-02f, -4.95734923e-02f, -4.33039516e-02f, -1.63493231e-02f, 2.43846886e-02f, 3.04835420e-02f,
  7.76279569e-02f, -4.71421778e-02f, 1.25918817e-02f, -3.46378721e-02f, 9.62572731e-03f, -2.82612145e-02f, 1.19751804e-02f, -6.68258220e-02f, -9.37497169e-02f, -6.40646815e-02f,
  5.13539203e-02f, -7.17204213e-02f, 5.96342348e-02f, 4.59764712e-02f, -2.71894671e-02f, 5.75399697e-02f, -4.19751368e-03f, -2.38220505e-02f, -5.24085648e-02f, 8.82001668e-02f,
  -3.81566361e-02f, -3.35437469e-02f, 4.89084199e-02f, 1.94962546e-02f, 5.91526292e-02f, -5.02327532e-02f, 5.48597872e-02f, -8.71367604e-02f, 7.04636797e-02f, -4.34265360e-02f,
  3.76194902e-02f, -6.33601891e-03f, 2.12902967e-02f, -6.23881221e-02f, 3.21621262e-02f, -3.91479731e-02f, -2.96088997e-02f, -1.07896864e-01f, 5.19080684e-02f, 6.03983365e-02f,
  -1.28176615e-01f, 3.39916386e-02f, 1.88536689e-01f, -9.91104320e-02f, 2.20579073e-01f, 1.80050656e-01f, -3.45427692e-02f, 4.10285182e-02f, -1.36343494e-01f, -1.67808115e-01f,
  -5.46102151e-02f, -8.83038342e-02f, -6.78544939e-02f, 2.39325222e-02f, -5.62584214e-02f, -1.30795687e-01f, -6.59024995e-03f, -7.73723982e-03f, 5.01333922e-02f, 1.82999726e-02f,
  1.14830192e-02f, -8.59720334e-02f, 6.08316809e-02f, 3.55379879e-02f, 1.17629766e-01f, 4.34465474e-03f, -1.32247895e-01f, 1.48410544e-01f, -4.43876199e-02f, -4.72842306e-02f,
  1.97399911e-02f, -9.76823196e-02f, 7.41534866e-03f, -6.54902086e-02f, 4.77138646e-02f, -2.63271462e-02f, -6.49873912e-02f, 6.04937300e-02f, 9.43164825e-02f, -2.48527415e-02f,
  -6.93361163e-02f, 6.15621954e-02f, -4.85925265e-02f, 5.99423237e-02f, 7.17605576e-02f, 2.99398601e-02f, -3.78293097e-02f, 9.84359458e-02f, 6.87259138e-02f, 1.18186593e-01f,
  2.43239924e-02f, -3.25541794e-02f, -6.47067577e-02f, -5.80002926e-02f, -3.37284915e-02f, -7.47025246e-03f, 2.44542398e-02f, -8.26260224e-02f, -4.99545448e-02f, 5.23690805e-02f,
  -5.15987054e-02f, 6.45962134e-02f, -2.56305058e-02f, 5.96198887e-02f, -3.26464064e-02f, -5.25941327e-02f, 5.67658246e-02f, 6.62272498e-02f, 2.95381472e-02f, -2.45113689e-02f,
  6.11779615e-02f, 2.40038447e-02f, 2.64780726e-02f, -7.15726614e-02f, -7.25870281e-02f, 4.45970781e-02f, 2.91643497e-02f, -6.70197010e-02f, -4.00298275e-02f, 7.75636211e-02f,
  4.36322279e-02f, -2.12937710e-03f, 2.72300914e-02f, -5.81163205e-02f, -5.66540509e-02f, -2.01739073e-02f, -5.67844100e-02f, -6.20659161e-03f, -5.08565120e-02f, -2.79364493e-02f,
  -2.98418291e-02f, -1.42312780e-01f, -4.51221205e-02f, 4.91557010e-02f, 4.34352048e-02f, -2.09056195e-02f, -5.16843684e-02f, -8.25309381e-02f, -2.10020952e-02f, -5.22732884e-02f,
  5.02794236e-02f, -2.58020684e-02f, -8.63012299e-02f, 4.29133996e-02f, 3.83430645e-02f, -5.27791940e-02f, -1.17632352e-01f, 4.31782492e-02f, -9.59091112e-02f, -6.63891733e-02f,
  3.22837606e-02f, 3.04629356e-02f, -6.93333596e-02f, -6.03056028e-02f, -8.81570652e-02f, -6.72641024e-02f, -1.69333462e-02f, 6.77961856e-02f, 7.19293486e-03f, 4.17238940e-03f,
  6.68506920e-02f, -7.31952786e-02f, 5.15368767e-02f, 1.13250101e-02f, 3.77060734e-02f, 6.43359823e-03f, 1.14636235e-01f, -1.23917505e-01f, -2.25551389e-02f, 4.41275835e-02f,
  -5.22206239e-02f, 7.29127079e-02f, 4.79920544e-02f, -8.29043984e-02f, -1.19423956e-01f, 1.48862635e-03f, 2.59206612e-02f, 6.19626977e-02f, -4.38772105e-02f, -5.76051734e-02f,
  4.98022214e-02f, 1.46816215e-02f, -8.81441403e-03f, -1.24950752e-01f, -6.77826330e-02f, 8.07790533e-02f, -1.43649308e-02f, 8.43741521e-02f, -8.17336068e-02f, 6.07358702e-02f,
  -3.52996960e-02f, -8.88800845e-02f, 8.38497058e-02f, 1.80902444e-02f, -6.54625818e-02f, -2.36150399e-02f, 1.11118741e-02f, -2.08076593e-02f, -5.35983816e-02f, -2.52756081e-03f,
  8.06414932e-02f, 8.36414173e-02f, -6.40382022e-02f, 7.46111348e-02f, -2.18894705e-02f, 1.47300744e-02f, -6.06837459e-02f, 3.30964290e-02f, 6.29625171e-02f, 4.44997586e-02f,
  9.29263234e-02f, 8.00259635e-02f, -3.03624347e-02f, 4.77927662e-02f, -2.55148020e-02f, -3.11354585e-02f, -2.34752428e-02f, 5.09289280e-02f, -7.11654127e-02f, 1.26251709e-02f,
  4.60708886e-02f, 3.85103486e-02f, -6.98127002e-02f, 7.62205124e-02f, 4.39380221e-02f, 5.71907833e-02f, -8.51692334e-02f, 4.94255461e-02f, -4.80486900e-02f, -1.81359164e-02f,
  -8.35398287e-02f, 7.55154435e-03f, -4.66978289e-02f, -5.91682941e-02f, 6.98150927e-03f, -6.24885149e-02f, 1.25448918e-02f, -7.03431806e-03f, 8.74157175e-02f, 1.28558686e-03f,
  -4.52007689e-02f, 9.63382572e-02f, 9.13196430e-02f, 4.11375351e-02f, -3.72064784e-02f, 2.51613632e-02f, 1.43137071e-02f, -2.55464483e-02f, -3.09426896e-02f, 8.95240679e-02f,
  4.21071500e-02f, 3.74857970e-02f, 2.36939229e-02f, 1.87521446e-02f, 2.06676740e-02f, -2.06095949e-02f, 2.29979190e-03f, 5.74024431e-02f, -1.71068590e-02f, -3.29110632e-03f,
  -3.77041325e-02f, -6.73412904e-02f, -6.38289899e-02f, -7.48501271e-02f, -6.07926175e-02f, 6.82134554e-02f, 7.26635335e-03f, -1.22296717e-02f, 4.15007062e-02f, -2.81537827e-02f,
  -1.40356747e-02f, 9.43237245e-02f, 6.60772026e-02f, 5.49719296e-02f, 8.35732296e-02f, -3.02624283e-03f, 6.78010955e-02f, 2.64329445e-02f, 4.15553153e-02f, -2.18277518e-02f,
  2.17281803e-01f, -2.41239765e-03f, 5.80577254e-02f, 3.35061066e-02f, 4.10102196e-02f, 1.18853673e-01f, -1.97140034e-02f, 2.10406736e-01f, 2.76348770e-01f, 1.87280104e-02f,
  7.01959245e-03f, -8.43403190e-02f, 3.56919318e-02f, 9.55140404e-03f, 2.07053185e-01f, 4.05631587e-02f, 2.12168366e-01f, -6.18064255e-02f, 6.65827990e-02f, 6.43329248e-02f,
  1.65959269e-01f, 7.09944740e-02f, -1.22261554e-01f, -7.48529136e-02f, -1.21522555e-03f, -9.42879990e-02f, -1.24290615e-01f, -1.13069713e-01f, -5.35805970e-02f, -4.38773856e-02f,
  -7.25055188e-02f, 1.52666211e-01f, -7.40864128e-02f, 6.52803928e-02f, 2.86449604e-02f, -4.58495133e-02f, -1.04097091e-01f, -5.07401079e-02f, -2.38682572e-02f, -1.59179233e-03f,
  -4.42270003e-02f, 5.92804514e-02f, 9.62346941e-02f, 3.60698178e-02f, 3.01514640e-02f, 5.49427606e-02f, -5.63214533e-02f, -4.91905436e-02f, 2.38100644e-02f, 2.00022329e-02f,
  2.29902267e-02f, 4.66484278e-02f, 1.70792697e-03f, -8.66941456e-03f, -9.84946266e-03f, 3.93226072e-02f, -3.36136930e-02f, -2.26316862e-02f, 1.08270207e-02f, 1.23516008e-01f,
  -6.47006789e-04f, 1.65216662e-02f, -3.73278297e-02f, -1.71889365e-02f, 8.73753428e-02f, -4.45371494e-02f, 3.77359204e-02f, 3.55572701e-02f, 7.06138611e-02f, -5.46693467e-02f,
  -8.41617882e-02f, -1.27413189e-02f, 1.73614416e-02f, 6.33595735e-02f, 7.39050433e-02f, -5.96552528e-02f, -6.83522075e-02f, 4.21709642e-02f, 8.44111219e-02f, -5.07502770e-03f,
  3.83771360e-02f, 3.71820410e-03f, 7.44204521e-02f, -3.10045071e-02f, 4.58531417e-02f, 6.03041500e-02f, 5.60470745e-02f, -7.03020394e-02f, -6.17781375e-03f, 4.04192172e-02f,
  8.35887864e-02f, 2.14036196e-01f, -2.37944480e-02f, 5.56000732e-02f, 1.26455287e-02f, -4.48011160e-02f, 9.04550850e-02f, 1.01964667e-01f, -5.74654061e-03f, 1.07020989e-01f,
  4.39694487e-02f, 1.53135434e-02f, -5.12478165e-02f, -7.65200779e-02f, -7.88410679e-02f, 7.23985508e-02f, 3.69193256e-02f, -5.92231452e-02f, 5.91590516e-02f, -7.82549158e-02f,
  -1.09565243e-01f, 3.95727530e-02f, -6.83174729e-02f, 2.34005917e-02f, 7.46040419e-02f, -8.77633020e-02f, 8.37464929e-02f, -2.65858397e-02f, -4.49568927e-02f, -3.13860439e-02f,
  1.07025534e-01f, -9.98603404e-02f, -1.76257223e-01f, 8.58053938e-03f, 3.64550874e-02f, -8.17377344e-02f, -9.78666767e-02f, -7.63869137e-02f, -1.64265528e-01f, 1.07218750e-01f,
  7.36827999e-02f, 9.56201274e-03f, 2.99628191e-02f, 4.86945175e-02f, -1.63326934e-01f, -1.71345890e-01f, -3.92090641e-02f, 1.90265030e-02f, -1.17068104e-01f, 4.92804721e-02f,
  3.55335847e-02f, 4.81123626e-02f, -3.14077325e-02f, -1.08263241e-02f, 9.45076644e-02f, -5.89858517e-02f, 9.67341941e-03f, 1.03757501e-01f, 5.66409752e-02f, 7.84661323e-02f,
  -1.83764677e-02f, 5.42073995e-02f, -3.36811319e-02f, 6.95402920e-02f, -6.65711612e-02f, 1.34226978e-01f, -6.18172635e-04f, -6.00650646e-02f, 4.46439683e-02f, 1.79646406e-02f,
  6.60786033e-02f, -5.45045137e-02f, 1.78541504e-02f, 6.09846413e-02f, 7.64816552e-02f, 6.47386461e-02f, 6.37403205e-02f, -7.39938468e-02f, 3.52715179e-02f, 3.01901232e-02f,
  -1.66730247e-02f, -1.93260368e-02f, -7.14450851e-02f, 5.61403558e-02f, -7.48969615e-02f, 4.38829064e-02f, -2.62459740e-02f, 1.32323150e-02f, 5.17795086e-02f, -5.88551350e-03f,
  5.16729690e-02f, -3.21739353e-02f, 1.51484879e-02f, 7.59670958e-02f, 6.35392684e-03f, 2.23852545e-02f, -1.26301236e-02f, 4.68731970e-02f, -2.34543905e-02f, 2.97761168e-02f,
  1.06228435e-04f, -2.09593456e-02f, 9.24547091e-02f, -6.08094968e-03f, 4.07938361e-02f, 5.42973541e-02f, 2.52822228e-02f, 7.63893649e-02f, 2.41262373e-02f, -5.30941971e-02f,
  7.57079050e-02f, 2.52568983e-02f, -8.52963626e-02f, -8.99323821e-03f, -5.64850345e-02f, -3.97576578e-03f, 1.07762896e-01f, 7.25674033e-02f, -9.92162153e-03f, 6.08745217e-02f,
  -4.60761376e-02f, 1.15572631e-01f, 1.29821515e-02f, -3.65401357e-02f, -4.05730233e-02f, 9.63000655e-02f, -1.69171821e-02f, -5.91451041e-02f, -2.83307470e-02f, -5.48142679e-02f,
  5.05990572e-02f, 3.19299325e-02f, 1.09694779e-01f, -3.91334929e-02f, 4.02606241e-02f, 3.52284200e-02f, 6.65817633e-02f, 3.58393416e-02f, -4.15804982e-02f, 5.44467419e-02f,
  5.72152399e-02f, 1.08341925e-01f, -5.44136278e-02f, 1.70595553e-02f, 4.00953703e-02f, -8.33932236e-02f, -6.81068562e-03f, -9.32956673e-03f, 4.04595174e-02f, 5.67509830e-02f,
  1.07058711e-01f, -8.24295953e-02f, -7.49558806e-02f, 1.57988265e-01f, 9.71457288e-02f, -6.56841472e-02f, -2.20469199e-02f, 1.15980729e-01f, -4.01919521e-02f, -7.19683319e-02f,
  6.89644516e-02f, 9.10000317e-03f, -1.72271386e-01f, 1.10810481e-01f, -1.22208007e-01f, -2.15556920e-01f, 2.64139548e-02f, -4.44815755e-02f, -9.92114022e-02f, -1.68231130e-02f,
  -6.47506490e-02f, 1.61778390e-01f, -6.64359331e-02f, 1.47521928e-01f, 1.17036045e-01f, 1.22747116e-01f, 2.62352955e-02f, -8.42650756e-02f, 1.22689351e-01f, -2.96455398e-02f,
  -1.74617637e-02f, -7.67896250e-02f, 2.45183725e-02f, 8.10528919e-03f, -8.12031999e-02f, 7.23463148e-02f, 3.18273604e-02f, -3.49291973e-02f, 5.34711070e-02f, -9.58972052e-02f,
  -9.04985145e-02f, 5.77316321e-02f, -5.59913144e-02f, -6.42126724e-02f, 1.34606674e-01f, -1.69649869e-02f, -1.42025826e-02f, -8.01776499e-02f, 3.25916782e-02f, -1.03723086e-01f,
  2.70143300e-02f, -1.02525959e-02f, 7.51436595e-03f, -3.84909511e-02f, -3.79656851e-02f, -2.01461148e-02f, 3.84352356e-02f, 5.02498001e-02f, 6.51780050e-03f, 1.62546691e-02f,
  -6.59309735e-04f, 2.73438692e-02f, 1.03174745e-04f, -2.24221516e-02f, -8.66653696e-02f, 2.37913560e-02f, 7.58612454e-02f, -9.19204727e-02f, 3.11199687e-02f, -4.11480963e-02f,
  -5.56840003e-02f, 6.34077638e-02f, -3.35068069e-02f, 6.25431091e-02f, -4.65501212e-02f, -2.47774273e-02f, 6.34049252e-02f, 7.63553753e-02f, -7.98517838e-02f, -2.93281823e-02f,
  6.48010448e-02f, 4.31383774e-02f, -7.70408511e-02f, -4.24507633e-03f, -7.81821739e-03f, 3.80400047e-02f, -5.25943562e-02f, 2.95346621e-02f, 7.67838731e-02f, 5.64267673e-03f,
  3.89451236e-02f, 3.09892800e-02f, 6.12670258e-02f, 8.20658803e-02f, -2.83769201e-02f, 1.85607299e-02f, 7.21459910e-02f, 1.38746500e-02f, 2.91417576e-02f, -2.63969246e-02f,
  -2.81330608e-02f, 1.12768009e-01f, 5.11309057e-02f, 3.94758396e-02f, 3.64570171e-02f, -5.80327101e-02f, -4.90321107e-02f, 1.00766405e-01f, 4.16200943e-02f, 8.48866925e-02f,
  -5.63879311e-02f, 3.70497406e-02f, 1.38371205e-02f, 5.28495908e-02f, 3.51677798e-02f, -5.00814430e-02f, 8.10201019e-02f, -9.47378427e-02f, 5.87098524e-02f, 4.32072729e-02f,
  8.61875936e-02f, 2.31175646e-02f, 5.31581566e-02f, 2.36524433e-01f, -6.58918694e-02f, -9.47121307e-02f, -1.84868455e-01f, 1.05326228e-01f, -9.83683467e-02f, -3.68004218e-02f,
  3.49696130e-02f, 2.05632038e-02f, -7.74765238e-02f, 1.20887190e-01f, 5.70672154e-02f, -8.54137838e-02f, 7.50569776e-02f, -6.11899979e-02f, 4.79272865e-02f, 1.84449315e-01f,
  1.24132812e-01f, 9.88442898e-02f, 7.25612715e-02f, 1.08332813e-01f, 1.63277164e-01f, 1.10558718e-01f, 2.61580348e-01f, 1.54237831e-02f, 2.13900462e-01f, 1.08625188e-01f,
  2.39083301e-02f, 4.87686805e-02f, -6.34806603e-02f, -3.78556624e-02f, -5.18555902e-02f, 5.47517762e-02f, -3.79680283e-02f, -8.41179118e-02f, 5.24519794e-02f, -3.77612039e-02f,
  4.64872308e-02f, -5.27617075e-02f, 8.98388922e-02f, -5.82568981e-02f, 7.32218847e-02f, -3.32736261e-02f, 4.57070060e-02f, 5.40582202e-02f, -6.58364221e-02f, 2.98083038e-03f,
  -1.84038617e-02f, -2.37185117e-02f, 9.96499509e-02f, 2.25449484e-02f, 6.23705275e-02f, -4.86883946e-04f, 5.01544699e-02f, -5.77984527e-02f, -4.15208675e-02f, 5.35741933e-02f,
  4.97088693e-02f, -8.16512182e-02f, 1.81857683e-02f, -6.24689879e-03f, -3.46734002e-02f, 3.87248434e-02f, 3.60909253e-02f, 4.41988558e-02f, -7.74819925e-02f, -5.56278192e-02f,
  -6.75763041e-02f, -7.09114224e-02f, 1.61816180e-02f, -1.27375983e-02f, -3.89011987e-02f, -6.95761591e-02f, 5.32591194e-02f, 2.07775012e-02f, -3.74897718e-02f, 3.75396274e-02f,
  -5.79281636e-02f, -4.68405858e-02f, -8.94280747e-02f, -2.41854554e-03f, -8.88453200e-02f, -3.08197886e-02f, 6.71179742e-02f, -2.95002870e-02f, -7.20197707e-02f, -3.01577412e-02f,
  2.64148004e-02f, 2.21850559e-01f, -2.27091014e-02f, 3.95551100e-02f, 2.93801259e-02f, -7.14888517e-03f, -2.10846756e-02f, 1.82710141e-02f, 1.32561758e-01f, -5.86417839e-02f,
  -5.13192937e-02f, -6.66507483e-02f, -6.04235865e-02f, 9.42124501e-02f, 7.64489546e-02f, 1.06092114e-02f, -2.69928742e-02f, 3.04850787e-02f, 8.34978446e-02f, 8.09233934e-02f,
  1.09647727e-02f, 2.53928453e-02f, -1.20111946e-02f, -2.01571491e-02f, 8.41022953e-02f, 5.78636266e-02f, 5.17214984e-02f, -3.56456265e-02f, 4.98343110e-02f, 6.73053786e-02f,
  1.63540035e-01f, 1.39925539e-01f, -1.72238231e-01f, 1.51271503e-02f, 4.67959344e-02f, -1.62152797e-02f, 7.49658123e-02f, 3.48000005e-02f, -2.26769391e-02f, 9.40643549e-02f,
  1.22177325e-01f, 1.75791373e-03f, 2.61182785e-02f, 1.79259196e-01f, 8.77286121e-02f, 1.13845259e-01f, 1.04433849e-01f, 1.62605375e-01f, 4.88824062e-02f, 4.18458320e-02f,
  -1.04638515e-03f, 1.84119508e-01f, -1.10304803e-01f, 9.88017619e-02f, -1.64703857e-02f, -1.01544760e-01f, 2.98190191e-02f, -1.53115854e-01f, 7.60083273e-02f, -6.01433255e-02f,
  1.21019155e-01f, -2.60224333e-03f, 2.99258367e-03f, -5.17126247e-02f, -6.36787042e-02f, 8.69951546e-02f, -9.46523249e-02f, -6.80815652e-02f, -4.21682857e-02f, -1.46652982e-02f,
  5.71570732e-03f, 1.18357716e-02f, 5.93492873e-02f, 4.06458527e-02f, 3.04683112e-02f, 5.57483137e-02f, 6.01695180e-02f, 2.62128264e-02f, -1.92185827e-02f, 6.69249669e-02f,
  -1.08324990e-01f, 6.95321858e-02f, 2.08189921e-03f, 5.37098236e-02f, -5.22759482e-02f, -7.59363025e-02f, -4.37751487e-02f, 5.14834188e-02f, -4.73617278e-02f, 1.73058342e-02f,
  6.47889497e-03f, 8.94497484e-02f, -6.33323342e-02f, 3.81033421e-02f, 9.10870507e-02f, -3.45995873e-02f, 3.83316725e-02f, -6.85534477e-02f, 6.52717650e-02f, 9.83317010e-03f,
  5.36345653e-02f, 2.66436562e-02f, -2.54145414e-02f, 7.80656114e-02f, -7.25794882e-02f, -6.93442747e-02f, -7.72015974e-02f, -7.79542029e-02f, -7.29663372e-02f, -8.08943436e-02f,
  -6.75033182e-02f, 1.72856671e-03f, 2.06677220e-03f, -9.57898721e-02f, -6.13706699e-03f, 9.07611102e-03f, -5.38891926e-02f, 5.58793657e-02f, -3.87965962e-02f, 5.60803376e-02f,
  7.55505562e-02f, 1.15117304e-01f, -4.99395207e-02f, -7.25527294e-04f, -2.96766013e-02f, -2.55589690e-02f, 3.53374742e-02f, 6.83236644e-02f, -2.93032965e-03f, 3.07234321e-02f,
  8.05573305e-04f, -5.79103716e-02f, 6.85795322e-02f, -6.08067401e-02f, 6.53902814e-02f, 1.76987294e-02f, -1.35932146e-02f, -6.84796050e-02f, 2.09417138e-02f, 6.39486685e-02f,
  -6.27113208e-02f, 5.39277568e-02f, 7.10702613e-02f, -1.36553785e-02f, -2.49841157e-02f, -8.34043771e-02f, -2.93730162e-02f, 1.14728799e-02f, -5.75876720e-02f, 5.62789515e-02f,
  -4.63385321e-02f, 1.78537920e-01f, 1.61102831e-01f, -1.30902529e-01f, -4.92131524e-02f, 4.01047319e-02f, -1.81788504e-02f, 9.96864587e-02f, -1.62541270e-01f, -6.30173683e-02f,
  6.67817444e-02f, -5.50545491e-02f, -7.29100183e-02f, 8.29710737e-02f, -4.66890913e-03f, 6.17170148e-02f, 5.98776788e-02f, -4.21262234e-02f, 1.95656177e-02f, -4.48357798e-02f,
  5.71380854e-02f, -6.68163374e-02f, 4.85932343e-02f, 1.36069342e-01f, 1.11691974e-01f, 3.43854241e-02f, -1.20221637e-01f, -3.41490321e-02f, 3.77301569e-03f, -6.62571788e-02f,
  2.37834696e-02f, -4.31180075e-02f, 7.79192448e-02f, -5.62469438e-02f, 8.96638725e-03f, 6.49523064e-02f, 8.40979889e-02f, 4.46808338e-02f, 4.82807904e-02f, -7.91345537e-02f,
  3.60613279e-02f, 6.45863786e-02f, -3.78591679e-02f, 1.10866185e-02f, 1.62630416e-02f, 8.69574919e-02f, 2.70691104e-02f, -3.70760672e-02f, -2.05459725e-02f, 3.91277075e-02f,
  3.16689685e-02f, 1.68145988e-02f, 6.46706745e-02f, -7.45098963e-02f, 6.05698191e-02f, -5.20691462e-02f, 6.97442666e-02f, 4.00263257e-02f, 8.24894756e-03f, -6.74104244e-02f,
  -7.20411018e-02f, 4.27794233e-02f, 4.41813953e-02f, 4.88719307e-02f, 5.27539998e-02f, 2.23373203e-03f, -6.85742998e-05f, -2.94961445e-02f, -7.65312687e-02f, 6.38503805e-02f,
  6.68233633e-03f, -1.53857879e-02f, -3.34924273e-02f, 5.10120057e-02f, 6.83634803e-02f, -2.54296511e-02f, 4.07132879e-02f, -8.21449608e-02f, 4.16575558e-02f, 1.00106679e-01f,
  -2.75873374e-02f, 6.33026883e-02f, -1.02284458e-02f, -6.70769438e-02f, 2.64107697e-02f, -1.71684497e-03f, 1.31397536e-02f, 7.59642199e-02f, 7.95865878e-02f, -1.01183718e-02f,
  7.30549768e-02f, -5.17052482e-04f, 1.80400927e-02f, 8.08584541e-02f, 9.16967019e-02f, 9.07190740e-02f, 4.02074829e-02f, 6.23756237e-02f, -4.78179604e-02f, -4.26856801e-02f,
  -7.04144463e-02f, -3.04939337e-02f, 8.38075504e-02f, -5.99656738e-02f, -3.49686481e-02f, 1.61706880e-02f, -9.13678557e-02f, -4.37170118e-02f, -1.03605002e-01f, 5.17492890e-02f,
  -3.56402174e-02f, -3.74866612e-02f, 5.92505224e-02f, -5.24127446e-02f, -1.05969742e-01f, -1.06740825e-01f, 1.25725390e-02f, 2.98306458e-02f, -6.17184229e-02f, -2.21328288e-02f,
  5.97026385e-02f, -9.64208394e-02f, 8.03289264e-02f, 1.40727222e-01f, 1.00605883e-01f, 5.19037545e-02f, 7.52085224e-02f, -3.67026627e-02f, 7.94954523e-02f, -9.36431885e-02f,
  -3.19076702e-02f, -3.69429402e-02f, -1.33418486e-01f, -8.08169693e-02f, 6.20327285e-03f, -2.61166673e-02f, 9.32125226e-02f, -8.31938908e-02f, 1.55681327e-01f, -1.80193372e-02f,
  8.92849118e-02f, 2.15141103e-02f, 2.31472254e-02f, -5.79101481e-02f, 2.69500539e-03f, -5.49808107e-02f, 6.49484545e-02f, 4.73799855e-02f, 1.86090823e-02f, 5.66780269e-02f,
  8.71234611e-02f, 8.60636309e-02f, -8.54090676e-02f, 5.34754395e-02f, 9.99317765e-02f, -7.75247365e-02f, -9.70555469e-02f, -1.40656810e-02f, 4.29840535e-02f, -7.05233067e-02f,
  -6.36285311e-03f, -6.42507523e-02f, -2.35434230e-02f, 1.32268313e-02f, 1.01270229e-01f, 1.90364216e-02f, 5.56682609e-02f, -5.76554164e-02f, -7.27103278e-02f, -8.56444463e-02f,
  -8.41192901e-03f, 6.77707419e-02f, 9.32343975e-02f, 7.58190677e-02f, 3.44590954e-02f, 2.54178438e-02f, 4.90138382e-02f, 7.78899714e-02f, 4.43102829e-02f, -4.26366851e-02f,
  -3.39613631e-02f, 4.49760305e-03f, 3.58461030e-02f, 6.23327643e-02f, 1.88548397e-02f, -1.44647723e-02f, 2.82029249e-02f, 5.46519868e-02f, 1.00651979e-01f, 2.39206012e-02f,
  3.69389132e-02f, -1.63859539e-02f, 5.68501465e-02f, 3.81425805e-02f, 6.48768619e-02f, -5.19675724e-02f, 7.71371052e-02f, 7.07583502e-02f, -4.95395681e-04f, -8.64387080e-02f,
  -7.25624934e-02f, -6.34193271e-02f, 5.45678064e-02f, -9.71075818e-02f, 1.77101772e-02f, -7.75041729e-02f, 4.48718928e-02f, -5.61983325e-02f, -6.53981417e-02f, -6.02455139e-02f,
  4.52705063e-02f, 1.33736685e-01f, -6.55978546e-02f, 1.00912992e-02f, -2.12936886e-02f, 2.59433035e-03f, -7.54745379e-02f, -7.61683518e-03f, 8.42961445e-02f, -6.81319833e-02f,
  4.66771573e-02f, -1.00589311e-02f, -5.34016080e-02f, 4.87510934e-02f, 7.93389082e-02f, -4.14101146e-02f, -1.62531610e-03f, -6.79599643e-02f, 5.59525890e-03f, -3.63582559e-02f,
  -2.23547649e-02f, 4.54144925e-02f, 7.85421729e-02f, 8.36765170e-02f, 2.39439812e-02f, 4.88047078e-02f, -1.63639206e-02f, 7.58667709e-04f, 6.63394853e-02f, 5.11811487e-02f,
  2.13406652e-01f, -1.06891729e-01f, -7.02197701e-02f, 1.15370333e-01f, 9.12797078e-02f, 8.91483277e-02f, 9.30299163e-02f, 9.23104584e-03f, 3.35200019e-02f, -1.26025870e-01f,
  -1.22657334e-02f, 8.84493068e-02f, 9.51185897e-02f, 5.29799052e-03f, 1.93823457e-01f, -3.77307869e-02f, 2.69294884e-02f, 1.15493999e-03f, -6.31458089e-02f, 1.61495712e-02f,
  1.18271727e-02f, -3.26280110e-02f, -8.33339468e-02f, -1.70886010e-01f, 7.61737376e-02f, -1.34213984e-01f, -6.51730075e-02f, 7.97595307e-02f, -9.39259753e-02f, 1.34332702e-02f,
  8.60451311e-02f, 1.03177093e-02f, -1.43643944e-02f, -6.05184883e-02f, -5.44063859e-02f, -7.50732422e-02f, -2.23794002e-02f, 8.45253021e-02f, 4.01510932e-02f, 1.01820894e-01f,
  2.90891295e-03f, -3.31624560e-02f, 5.18998764e-02f, -2.80439388e-02f, 5.43330051e-02f, -1.16862953e-01f, -1.55775603e-02f, -1.13578282e-01f, 2.49173138e-02f, -1.03741966e-01f,
  -1.25217400e-02f, 2.08623204e-02f, 6.95337430e-02f, -6.72555491e-02f, -1.93046369e-02f, -1.24551053e-03f, 6.44533038e-02f, -7.98855424e-02f, -4.78774235e-02f, 6.19632304e-02f,
  7.52206743e-02f, -1.48400217e-02f, -4.41117473e-02f, 1.76392961e-02f, 8.67517889e-02f, 3.06333639e-02f, 1.29375309e-02f, 2.81995665e-02f, -3.76901738e-02f, 8.89593214e-02f,
  3.22509669e-02f, -2.37120464e-02f, 6.65485412e-02f, -7.11483508e-02f, -6.32842705e-02f, 7.03009516e-02f, 1.40712950e-02f, 2.36605946e-02f, -3.50073986e-02f, 5.80411442e-02f,
  6.54923962e-03f, 1.37422383e-02f, 8.60805344e-03f, -4.33492288e-02f, -8.90789703e-02f, -1.41751803e-02f, -3.71148288e-02f, -6.23786524e-02f, -7.87038580e-02f, -5.14277406e-02f,
  -3.43218260e-02f, 2.83637345e-02f, 6.76615397e-03f, 2.80399509e-02f, -6.86896965e-02f, -4.19890285e-02f, -8.09423923e-02f, 8.31511095e-02f, 2.75105573e-02f, -6.53126929e-03f,
  -7.30675980e-02f, -9.94055625e-03f, -8.38026851e-02f, -1.31556606e-02f, -1.11196293e-02f, 4.72429059e-02f, -1.08014224e-02f, 4.64083850e-02f, 2.50453223e-03f, 2.75863688e-02f,
  2.51966296e-03f, -4.84631490e-03f, 4.43279818e-02f, 7.48605281e-02f, -9.28132311e-02f, -2.71765813e-02f, 7.42245317e-02f, -2.51508504e-02f, 5.70469350e-02f, 1.64666194e-02f,
  -6.12457022e-02f, -2.87806988e-01f, 1.74762413e-01f, -2.80426759e-02f, -8.24740995e-03f, 1.58363059e-01f, 1.04886293e-01f, -2.05347881e-01f, -2.83272952e-01f, -2.40140885e-01f,
  -8.76933150e-03f, 1.44961979e-02f, 1.10041380e-01f, 4.26989160e-02f, 3.24619800e-01f, 7.64728338e-02f, 3.15658599e-02f, 1.38944909e-01f, 6.61206171e-02f, 1.03803137e-02f,
  -2.43754722e-02f, 8.88214409e-02f, 1.92592710e-01f, -5.23000285e-02f, 1.70447789e-02f, -6.51442185e-02f, -7.42526427e-02f, 1.90864339e-01f, 6.64710253e-02f, 1.96548462e-01f,
  -6.95495531e-02f, -9.05007198e-02f, -1.88855529e-02f, 7.28451163e-02f, 1.80829335e-02f, -1.99405979e-02f, 1.73890609e-02f, 1.33203059e-01f, 8.87133926e-02f, 2.88771670e-02f,
  5.55289909e-02f, 1.70697290e-02f, 2.65005889e-04f, -4.20105718e-02f, 6.95606787e-03f, -3.31499167e-02f, -8.27213749e-02f, -7.54635502e-03f, 6.63099959e-02f, 4.77089081e-03f,
  1.59636177e-02f, -1.87519565e-02f, 4.09375057e-02f, 3.20872329e-02f, 3.36393304e-02f, -2.83462647e-02f, 2.16068886e-02f, 7.18533769e-02f, -5.16752191e-02f, -5.10653816e-02f,
  -6.41605332e-02f, 1.20145408e-03f, 1.45856179e-02f, -1.47206258e-04f, 6.74084648e-02f, -5.36974594e-02f, -4.49616536e-02f, 2.57471204e-02f, 5.91475330e-02f, 5.73990159e-02f,
  2.26510614e-02f, -1.17119662e-02f, 4.08913679e-02f, -6.64178208e-02f, 1.50885638e-02f, -3.84755880e-02f, 2.63803545e-02f, -7.35420082e-03f, -1.94177907e-02f, 5.99237122e-02f,
  -2.45512975e-03f, 1.13017708e-02f, 1.78374592e-02f, 3.28719467e-02f, 5.55134192e-02f, -5.29286154e-02f, -1.88476604e-03f, 2.96990816e-02f, 5.45669720e-02f, 3.68702896e-02f,
  -1.91321686e-01f, -1.90599889e-01f, -4.90582362e-02f, -1.22583061e-02f, -6.21785522e-02f, -4.65386994e-02f, 4.64773215e-02f, -5.30799180e-02f, -2.61182096e-02f, -5.10828532e-02f,
  -1.12637348e-01f, 7.84433559e-02f, 3.26921418e-02f, -1.64095052e-02f, -1.15211857e-02f, -1.26080215e-01f, -5.35154343e-03f, 2.57718116e-02f, 1.99205242e-02f, -2.73421109e-02f,
  5.73192686e-02f, -4.63369712e-02f, -7.75415124e-03f, 3.85498554e-02f, 1.07431011e-02f, 5.66826984e-02f, -2.78531667e-02f, -9.64542553e-02f, 1.55728403e-02f, 4.65059429e-02f,
  1.04063079e-01f, -4.12101448e-02f, -9.43491459e-02f, -1.61003515e-01f, -1.20922938e-01f, -2.10656151e-01f, -2.71906644e-01f, -1.43606067e-01f, -1.54904857e-01f, -1.92483842e-01f,
  -1.18001118e-01f, 7.21360296e-02f, -9.82642919e-02f, -6.96621612e-02f, 3.11082453e-01f, 2.24107504e-01f, -3.80170532e-02f, -7.20119476e-02f, 8.15734342e-02f, -1.06065139e-01f,
  1.12294078e-01f, 2.12197825e-02f, 9.03231427e-02f, 2.46626083e-02f, -1.87226996e-01f, -2.00734120e-02f, -8.77393689e-03f, 2.07759123e-02f, 3.39164734e-02f, 7.58659979e-03f,
  6.68957010e-02f, 9.18065198e-03f, -8.96587893e-02f, 4.82886061e-02f, -5.35157584e-02f, -7.60917366e-02f, 2.18356177e-02f, 7.77222663e-02f, -5.76400831e-02f, -6.75684633e-03f,
  -4.38655317e-02f, -1.15102632e-02f, -3.46696787e-02f, 8.87323767e-02f, -1.04767963e-01f, 6.55463040e-02f, 2.47881655e-02f, 8.68112408e-03f, 1.61554420e-03f, 2.71384194e-02f,
  -2.46659532e-04f, 4.81278598e-02f, -1.04266554e-01f, 8.58215094e-02f, -5.13760932e-02f, -5.26727475e-02f, 4.39746380e-02f, -2.19768751e-02f, 9.95300040e-02f, 7.27792270e-04f,
  1.49378320e-02f, -4.45943438e-02f, 6.79451823e-02f, -2.82836277e-02f, 4.04957682e-02f, -3.98194715e-02f, -1.33761046e-02f, -4.16618679e-03f, 6.08941317e-02f, -5.96911274e-02f,
  -3.85651588e-02f, 7.17388019e-02f, -3.67254689e-02f, 3.94024923e-02f, 7.25213215e-02f, -3.19566391e-02f, 4.10032552e-03f, 1.10177323e-02f, 4.76508662e-02f, 1.51923513e-02f,
  -1.52491787e-02f, 8.94983336e-02f, -3.27918567e-02f, -3.95601913e-02f, -6.50679618e-02f, -4.94186021e-02f, -1.98077057e-02f, -8.54585469e-02f, 3.31807323e-02f, 4.62681316e-02f,
  4.92119305e-02f, 9.20804869e-03f, -4.69360128e-02f, -3.15725878e-02f, -3.74169499e-02f, 2.63740532e-02f, 7.25681484e-02f, 9.36207697e-02f, 7.07987323e-02f, 6.42583370e-02f,
  -1.21563207e-02f, 6.69727549e-02f, -8.94202888e-02f, -9.73725226e-03f, -2.61826683e-02f, -4.31602299e-02f, -4.03565690e-02f, -9.86487325e-03f, -5.62812621e-03f, 1.00706719e-01f,
  4.20489274e-02f, -2.43398026e-02f, 1.44172916e-02f, -6.87975883e-02f, -4.99643236e-02f, -9.24969092e-02f, -4.15622443e-02f, 4.00039703e-02f, 5.04367650e-02f, 7.21504241e-02f,
  1.04065724e-01f, -3.44194621e-02f, -5.18071726e-02f, -2.60947924e-03f, 1.07311696e-01f, -5.06830513e-02f, 3.45696621e-02f, 3.25809978e-02f, 1.48507416e-01f, -7.72622973e-02f,
  -3.76305543e-02f, 1.07868709e-01f, -1.12462431e-01f, 7.43232220e-02f, -4.20563556e-02f, -1.81311928e-02f, 1.03501014e-01f, -4.33302335e-02f, 9.37796906e-02f, 3.36052552e-02f,
  9.87973362e-02f, -7.39605799e-02f, -4.70237434e-02f, -1.11292087e-01f, -5.93286864e-02f, 3.67553607e-02f, -8.62997249e-02f, -4.42964360e-02f, -9.14884806e-02f, -5.94277531e-02f,
  -7.64491260e-02f, -6.43307790e-02f, 2.08187103e-02f, -7.92345032e-02f, -7.55206719e-02f, 1.05182029e-01f, 7.54970014e-02f, -4.63215746e-02f, -6.84127808e-02f, -6.13867566e-02f,
  1.96440723e-02f, -5.37586622e-02f, 2.26596054e-02f, -5.85823506e-02f, 4.99096997e-02f, -5.59983104e-02f, -7.79993609e-02f, 1.01380788e-01f, -3.04178596e-02f, -8.53297710e-02f,
  2.52714884e-02f, -1.16691190e-05f, 4.91380645e-03f, 9.85877030e-03f, -9.66594927e-03f, 9.17838216e-02f, 4.91480976e-02f, -5.21068797e-02f, 1.71784498e-02f, 6.10213578e-02f,
  1.57569274e-02f, -1.03825191e-02f, 2.44279997e-03f, 4.59915176e-02f, -1.12163266e-02f, -8.61309990e-02f, 7.20825139e-03f, -4.92938124e-02f, -4.60100807e-02f, 8.51619542e-02f,
  -6.55990541e-02f, 3.05223726e-02f, 4.15747892e-03f, -4.41842303e-02f, 4.77883779e-03f, 7.40045309e-02f, -8.90426561e-02f, 6.60733134e-02f, 7.32999668e-02f, 5.89606166e-02f,
  -6.02453807e-03f, -7.06970468e-02f, -6.59570545e-02f, 6.45098090e-02f, -8.05080235e-02f, -1.43558262e-02f, 3.33712287e-02f, -2.80950218e-02f, 5.78576699e-02f, -7.44210184e-02f,
  5.15185297e-02f, 1.13509782e-02f, 1.62300039e-02f, 3.76681164e-02f, -1.35209532e-02f, -3.70843773e-04f, 5.68163730e-02f, -7.06323609e-02f, 3.23871598e-02f, 4.69614379e-02f,
  9.45781544e-02f, 9.06825513e-02f, 8.16581994e-02f, -5.09708598e-02f, -4.15619351e-02f, 2.23601125e-02f, -2.98094749e-02f, 6.65326938e-02f, 2.48409552e-03f, -4.09325548e-02f,
  1.06938854e-02f, 2.06760298e-02f, 3.54302153e-02f, 4.37838808e-02f, 6.28722413e-03f, -6.81235790e-02f, 7.31848925e-02f, -5.15905693e-02f, -3.44828516e-02f, 3.44510190e-02f,
  -2.16294244e-01f, 7.14495108e-02f, -4.47599478e-02f, -8.55407193e-02f, -1.55561427e-02f, -1.12021357e-01f, 2.58213212e-03f, 5.96230850e-02f, -9.99578983e-02f, 1.55280173e-01f,
  8.62147361e-02f, -6.87404275e-02f, 7.33129447e-04f, -1.72810331e-02f, -1.67872235e-01f, 4.14537862e-02f, 8.78275465e-03f, -4.48860116e-02f, -1.19572505e-01f, -9.62656438e-02f,
  -1.60467196e-02f, 1.29037589e-01f, 6.56728894e-02f, 1.44328594e-01f, -5.97873032e-02f, 3.21633965e-02f, 1.10511087e-01f, 1.11729793e-01f, 9.82532501e-02f, 6.82840869e-02f,
  -2.73768418e-03f, -5.73579706e-02f, -4.60356027e-02f, -9.24831927e-02f, -4.17398363e-02f, 1.50983101e-02f, -1.41130043e-02f, -8.94664600e-02f, -8.44618529e-02f, -6.60718679e-02f,
  -3.44097167e-02f, -2.91552637e-02f, 7.23881871e-02f, 7.06276670e-02f, -7.11940154e-02f, -8.09660628e-02f, 8.37323591e-02f, 7.02432767e-02f, -9.52269584e-02f, 1.33262556e-02f,
  -9.38167572e-02f, -6.83473498e-02f, -4.52430248e-02f, -6.67683333e-02f, -8.29202160e-02f, -6.33922964e-03f, -4.34378125e-02f, 4.91672307e-02f, -3.95800211e-02f, -7.38697574e-02f,
  -6.15993701e-02f, -4.87166084e-02f, -8.86064246e-02f, -5.88298999e-02f, 3.72154340e-02f, 5.48723154e-02f, 1.14974976e-02f, 1.30716333e-04f, 1.56345088e-02f, -4.90652956e-03f,
  5.28044142e-02f, -7.79962987e-02f, 5.03383279e-02f, 3.71073373e-02f, 4.98655587e-02f, -6.17354549e-03f, -4.48383465e-02f, -1.72125753e-02f, 5.42047024e-02f, -8.35418934e-04f,
  -6.07269593e-02f, 6.95319548e-02f, -5.53724691e-02f, -3.66957225e-02f, 6.25484213e-02f, 3.46009396e-02f, -2.58758664e-02f, 2.63680646e-04f, 1.05179444e-01f, -3.62555906e-02f,
  4.07434255e-02f, -1.51632100e-01f, 4.23488803e-02f, 1.25126273e-03f, 5.69381565e-02f, -5.88265881e-02f, -4.94863503e-02f, 3.13872541e-03f, 3.66868488e-02f, 1.93527602e-02f,
  -5.36943823e-02f, 3.02651804e-02f, 2.23781485e-02f, 9.52503365e-03f, -4.91666123e-02f, -8.52123722e-02f, -2.61645694e-03f, 8.78567398e-02f, -2.08051987e-02f, 4.25768346e-02f,
  4.87648174e-02f, -7.50103742e-02f, 8.70175436e-02f, 7.04872906e-02f, -4.23563980e-02f, -7.86934271e-02f, -6.01586252e-02f, -5.77451363e-02f, -9.86497849e-02f, 3.38148698e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.14130145e-02f, 1.09602019e-01f, 3.57212350e-02f, 3.81231718e-02f, 6.00738311e-03f, 1.20566130e-01f, 1.87192280e-02f, 5.88322571e-03f, -5.83800208e-03f, 1.59360126e-01f,
  1.11644678e-01f, 9.37135890e-02f, 1.71170175e-01f, -3.75737622e-02f, 1.98880568e-01f, 2.24714987e-02f, 1.40634164e-01f, 4.72314321e-02f, 1.96208116e-02f, 2.61389837e-03f,
  -1.01884305e-02f, 4.86676209e-02f, 1.09167941e-01f, 1.84223041e-01f, -3.67781594e-02f, 2.15579942e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.41762048e-01f, -5.66689186e-02f, 2.26287439e-01f, -1.50360271e-01f, 3.87316989e-03f, 8.62821192e-02f, 4.92356643e-02f, 9.30201635e-02f, -1.68924138e-01f, -1.81934297e-01f,
  -2.00317338e-01f, 1.07332714e-01f, 1.03918940e-01f, 3.84030230e-02f, -2.13858932e-01f, -2.15420369e-02f, 4.57060449e-02f, -1.16266884e-01f, -5.44388033e-02f, 5.37838377e-02f,
  8.03342387e-02f, -1.08177215e-01f, 1.12284198e-01f, 5.36513366e-02f, -8.25370178e-02f, -1.86224788e-01f, -1.43291980e-01f, -4.91379835e-02f, 1.83269456e-01f, -1.22250959e-01f,
  -5.59276668e-03f, -4.42547910e-02f, 8.36533085e-02f, 5.36597408e-02f, 7.63182342e-02f, 9.20846090e-02f, -1.58242166e-01f, -1.84750631e-01f, -2.78837621e-01f, 1.03396423e-01f,
  -1.94555178e-01f, 4.64100502e-02f, 5.65597527e-02f, 7.32591078e-02f, -4.57259305e-02f, 8.93967599e-02f, -1.82112187e-01f, 9.63640660e-02f, -8.91327932e-02f, -2.45307386e-02f,
  -8.26264620e-02f, 2.80979186e-01f, -6.70581236e-02f, -1.83312833e-01f, -2.09529102e-01f, -1.96282625e-01f, 2.63829559e-01f, -1.83350995e-01f, 2.57100970e-01f, 3.10857683e-01f,
  4.10819352e-01f, -2.26307541e-01f, -5.31954020e-02f, -1.62703097e-01f, 2.16760226e-02f, 3.03818464e-01f, 2.08161727e-01f, -3.04965138e-01f, 4.36917901e-01f, 3.14971477e-01f,
  1.69472992e-01f, -2.31951445e-01f, -3.62568349e-01f, -3.75119686e-01f, -1.80599570e-01f, -1.53918162e-01f, -4.04848218e-01f, 2.15529218e-01f, -3.33906412e-01f, 9.27478522e-02f,
  -3.56426805e-01f, -2.53381580e-02f, 3.89381759e-02f, -7.74330720e-02f, 3.63213509e-01f, -2.07953110e-01f, -2.01357171e-01f, 3.62547964e-01f, 3.53593320e-01f, -2.98247755e-01f,
  2.16462523e-01f, 2.91194767e-01f, 2.01206952e-01f, 3.94437686e-02f, -4.36485838e-03f, -3.56381863e-01f, -8.48434940e-02f, 3.22284520e-01f, 1.17302977e-01f, -1.23429053e-01f,
  -3.62246245e-01f, 2.65952975e-01f, -1.18711077e-01f, -1.57225356e-02f, 8.74258280e-02f, -1.22752599e-01f, -1.68693736e-02f, 7.05094784e-02f, 1.21183753e-01f, -1.37474477e-01f,
  -2.49464158e-02f, 9.69832316e-02f, 1.56981871e-02f, 1.41366139e-01f, -1.40373975e-01f, -1.09660877e-02f, -1.34983778e-01f, -1.00222006e-01f, -8.25913027e-02f, -1.23821639e-01f,
  1.01158343e-01f, 2.57287212e-02f, -1.60178646e-01f, -1.43692523e-01f, 7.77337328e-02f, -1.09817475e-01f, -3.86705734e-02f, 2.04492509e-01f, 1.22896217e-01f, 5.51995337e-02f,
  -2.66491055e-01f, -2.30487004e-01f, -1.47662356e-01f, 8.46496299e-02f, 6.12202138e-02f, 2.98736155e-01f, -7.28908330e-02f, 1.70844764e-01f, 1.49971500e-01f, 6.88957721e-02f,
  -2.08024681e-01f, 8.25724974e-02f, -5.92214353e-02f, 1.58165053e-01f, -1.82688043e-01f, -3.87189716e-01f, 2.22194362e-02f, 5.79319187e-02f, 3.66813242e-02f, 1.00667691e-02f,
  -1.92328796e-01f, -1.27195954e-01f, 9.17048603e-02f, 2.14343239e-02f, 9.79505014e-04f, 6.44650906e-02f, -9.28377286e-02f, -1.21183492e-01f, 7.81747699e-02f, 4.81968075e-02f,
  2.12972406e-02f, 4.92347404e-03f, -1.66837797e-01f, -5.49309403e-02f, -4.02860753e-02f, 9.20109674e-02f, -7.21961558e-02f, 1.76989630e-01f, -3.63801233e-02f, -1.19499035e-01f,
  3.70895602e-02f, 8.65414590e-02f, 8.53436999e-03f, -8.16216990e-02f, -1.25122080e-02f, 1.79130763e-01f, -2.31193930e-01f, 2.41124183e-01f, -1.42275663e-02f, 2.61791110e-01f,
  6.26137704e-02f, -4.35437858e-01f, -2.74302900e-01f, 1.21709816e-01f, -2.81097263e-01f, 2.90742457e-01f, 1.97822288e-01f, 2.26939321e-01f, -4.86590475e-01f, -3.89803573e-02f,
  3.07543665e-01f, -4.68420208e-01f, -1.66215047e-01f, 1.96497619e-01f, 1.80961639e-01f, -1.12398423e-01f, 3.69312406e-01f, 9.36150700e-02f, 1.17109172e-01f, 3.79845127e-02f,
  1.08006939e-01f, 4.96518970e-01f, 3.68768036e-01f, -2.22169086e-01f, -3.02885413e-01f, 2.45759457e-01f, -4.26327646e-01f, -9.32898223e-02f, -2.94744849e-01f, -1.34586006e-01f,
  2.06613049e-01f, 1.47656411e-01f, 1.06173180e-01f, 1.00459591e-01f, -2.19372913e-01f, -2.80640692e-01f, 2.39072919e-01f, -3.86193663e-01f, 1.84525654e-01f, 2.97047108e-01f,
  1.46662578e-01f, 1.35646686e-01f, -1.13657489e-01f, 6.86271265e-02f, -4.50328402e-02f, -1.95096694e-02f, 2.55379938e-02f, -1.94714323e-01f, 1.97582558e-01f, -2.97517657e-01f,
  -1.38192490e-01f, -8.91248584e-02f, -7.41402730e-02f, -6.29926920e-02f, 4.22330201e-02f, -1.41018704e-01f, 1.23308390e-01f, 2.06101149e-01f, 1.48448916e-02f, -4.30127122e-02f,
  5.99967374e-04f, 2.83673644e-01f, -8.51431414e-02f, -1.22510627e-01f, 1.94368586e-01f, 2.00166240e-01f, 6.63875788e-02f, 8.71989429e-02f, 3.52002650e-01f, 1.00145191e-01f,
  -6.96120337e-02f, 1.28978178e-01f, -1.75856516e-01f, 7.25599900e-02f, 2.18946096e-02f, -9.79382470e-02f, 4.85912822e-02f, 1.27100609e-02f, -1.56222552e-01f, -5.05399257e-02f,
  -1.40328426e-02f, -2.03485116e-01f, -7.82146398e-03f, -2.61529177e-01f, 9.83348191e-02f, -2.45920509e-01f, -2.46614560e-01f, -1.10513158e-01f, 3.19170654e-02f, 6.32458031e-02f,
  -6.49602935e-02f, -7.16626346e-02f, -1.14984810e-01f, -4.67509553e-02f, 7.44737759e-02f, -6.65711015e-02f, -2.94643231e-02f, -1.65314510e-01f, -6.95455149e-02f, -2.56140269e-02f,
  -5.64368181e-02f, 4.99981418e-02f, 2.67529394e-02f, -4.58004437e-02f, -1.02607816e-01f, -6.05769940e-02f, 3.31870392e-02f, -6.80045784e-02f, 1.55370375e-02f, -3.69447395e-02f,
  -7.69674480e-02f, -4.86208498e-02f, 7.81938136e-02f, -2.84164727e-01f, 7.27834478e-02f, -1.94366649e-01f, -1.24338372e-02f, -5.02208211e-02f, 7.74282441e-02f, -3.45039405e-02f,
  6.65882556e-03f, -2.29653850e-01f, 5.71481399e-02f, -1.79335415e-01f, -3.93747129e-02f, 4.83567710e-04f, 7.80379251e-02f, 2.13968173e-01f, 8.77269283e-02f, -3.65296364e-01f,
  -1.73081785e-01f, 1.75901130e-01f, -2.70163625e-01f, -8.00194442e-02f, -3.83069277e-01f, 9.99524072e-02f, -1.85695082e-01f, 3.08906764e-01f, 1.33483782e-01f, 3.50879043e-01f,
  -8.52660760e-02f, 1.34996712e-01f, -3.00020397e-01f, -2.71344006e-01f, 1.73097700e-01f, -1.91974238e-01f, 2.69989282e-01f, 6.16014786e-02f, 2.22673178e-01f, 2.43536100e-01f,
  -2.99724843e-02f, -9.28031206e-02f, 2.73857504e-01f, -1.22949734e-01f, -1.75273716e-01f, -3.07640761e-01f, -2.18436748e-01f, -1.74535260e-01f, 2.71323532e-01f, 3.30104113e-01f,
  1.92648202e-01f, 3.01046371e-01f, -1.94454312e-01f, 9.37439948e-02f, -3.56910497e-01f, -1.06276274e-01f, -3.27926368e-01f, -6.44217432e-02f, 1.60644799e-01f, 1.50759220e-01f,
  -7.39802718e-02f, 2.45764688e-01f, 2.62702286e-01f, 1.57426119e-01f, -4.04819340e-01f, -6.25924692e-02f, 1.59264877e-01f, -1.19607195e-01f, -2.03716308e-02f, -7.85771832e-02f,
  -1.23290636e-01f, 9.84667167e-02f, -2.05570579e-01f, -8.93170238e-02f, -1.32444100e-02f, 1.85801700e-01f, -9.61928070e-02f, 3.68944049e-01f, 4.57444005e-02f, 1.92205071e-01f,
  8.55180249e-02f, -1.11861847e-01f, -1.11286201e-01f, 2.42220312e-02f, 3.15265715e-01f, 2.24715605e-01f, 1.87419914e-02f, -2.10454059e-03f, 4.77758609e-02f, 7.12858094e-03f,
  2.66147524e-01f, 1.87941939e-01f, -1.14858039e-02f, 1.15579270e-01f, -1.69980479e-03f, -4.30277968e-03f, -1.67851314e-01f, 1.35800451e-01f, -9.71417427e-02f, -9.64570418e-02f,
  -2.06190705e-01f, 8.20740405e-03f, -5.22789955e-02f, 3.02743018e-01f, 1.77636310e-01f, -3.54135752e-01f, 6.62524477e-02f, -1.17359489e-01f, -2.95933988e-02f, -7.57895922e-03f,
  3.80301327e-02f, -4.25040096e-01f, -5.00741415e-02f, -2.89891362e-01f, 1.24269024e-01f, 3.01559884e-02f, 1.12202086e-01f, -2.31801614e-01f, 1.41321763e-01f, -1.98279265e-02f,
  1.34909339e-03f, 1.27215117e-01f, -1.99250251e-01f, 5.19625321e-02f, 1.19574107e-01f, 3.20333987e-02f, 9.44081098e-02f, -1.07843421e-01f, -1.11859664e-01f, 3.72372679e-02f,
  -8.00998881e-03f, -9.83442217e-02f, -2.08176300e-02f, 1.61635764e-02f, 3.62249650e-02f, -1.99306026e-01f, 7.32136667e-02f, -1.31004676e-01f, 9.09373313e-02f, -2.72894174e-01f,
  4.39570984e-03f, -5.68528622e-02f, 1.47978827e-01f, -1.05150409e-01f, 1.64539367e-01f, 2.54597545e-01f, 1.84872985e-01f, 2.37884715e-01f, 2.00662732e-01f, -2.91782588e-01f,
  1.33180946e-01f, 8.28802362e-02f, 2.47659367e-02f, 2.27730483e-01f, 6.75340965e-02f, 6.77150721e-03f, -2.73749202e-01f, 4.03891355e-02f, -1.72791496e-01f, 2.30859578e-01f,
  -2.53871195e-02f, 3.06547344e-01f, -3.31918657e-01f, 2.12403163e-02f, -4.60211158e-01f, -1.59915283e-01f, 7.47866705e-02f, -3.32037956e-01f, -3.33290190e-01f, -1.64298877e-01f,
  -2.09458008e-01f, 3.40099096e-01f, -1.28963411e-01f, 3.27517867e-01f, 1.10846415e-01f, -1.72402203e-01f, 1.01831354e-01f, 2.65959412e-01f, -3.33632767e-01f, -1.66793510e-01f,
  1.11539491e-01f, 2.09352255e-01f, 3.96399707e-01f, 4.57098871e-01f, -1.97312459e-01f, -1.77622557e-01f, -3.03662449e-01f, 7.35463053e-02f, 4.16836500e-01f, -1.23899639e-01f,
  -3.27377707e-01f, 1.58457998e-02f, 2.67543882e-01f, 1.47214398e-01f, -3.11421841e-01f, 8.94927979e-02f, -1.25406813e-02f, -1.66426469e-02f, 1.71308294e-01f, -1.09347209e-01f,
  -2.64153816e-02f, 1.92241639e-01f, -8.54401588e-02f, -2.35311817e-02f, -8.66635293e-02f, -2.76784033e-01f, -6.54773042e-02f, 4.83204052e-02f, 1.10194780e-01f, -1.47052947e-02f,
  -1.46917194e-01f, 1.12633608e-01f, 4.20018844e-02f, -1.10325992e-01f, -1.01913951e-01f, -7.47312158e-02f, -3.09338141e-02f, -7.34922290e-03f, -1.73077017e-01f, -1.94922298e-01f,
  -6.18364215e-02f, 2.49854967e-01f, -7.27928197e-03f, -2.66154646e-03f, -9.71900150e-02f, -1.23426132e-02f, 1.02792017e-01f, -9.67818275e-02f, 1.00330032e-01f, -5.25591373e-02f,
  9.65808034e-02f, 1.46047726e-01f, 2.13688716e-01f, 2.62272507e-01f, 3.55519541e-02f, 6.05278760e-02f, -1.24606818e-01f, 7.77074173e-02f, 4.02201898e-03f, 3.31606686e-01f,
  3.92083265e-02f, 1.31935820e-01f, 8.30646679e-02f, 3.96108553e-02f, -6.26311302e-02f, 1.21513762e-01f, -1.15787666e-02f, 1.85093760e-01f, 1.28242150e-02f, 1.23670943e-01f,
  3.55248779e-01f, 7.95755014e-02f, 1.20910127e-02f, 6.49027480e-03f, 1.14212938e-01f, -2.79698540e-02f, -3.02166287e-02f, 8.40141028e-02f, -1.14314266e-01f, -2.33936146e-01f,
  1.75966784e-01f, -1.13262035e-01f, 9.36529711e-02f, 7.07842261e-02f, 6.47749901e-02f, 1.84392735e-01f, -9.32847485e-02f, 2.19854549e-01f, -3.97508740e-02f, 1.71024084e-01f,
  3.01659685e-02f, -4.74741086e-02f, 7.52043501e-02f, -3.84296596e-01f, 1.11081354e-01f, 4.43064630e-01f, -3.70543785e-02f, 2.29403406e-01f, 3.36866051e-01f, 1.38494566e-01f,
  2.99764782e-01f, 3.99106383e-01f, 1.77162096e-01f, 1.23669172e-03f, -4.61964369e-01f, 3.60807419e-01f, 1.17322266e-01f, 4.64247674e-01f, 2.28888735e-01f, 3.52845699e-01f,
  -4.47858304e-01f, 3.70118350e-01f, 1.98688313e-01f, 1.98167637e-01f, -2.86093801e-01f, -3.01390439e-01f, -4.48683888e-04f, -1.43135071e-01f, 1.62736297e-01f, 9.94009599e-02f,
  -3.00266128e-02f, -2.02166080e-01f, 2.53708631e-01f, -5.24873100e-03f, -9.09197628e-02f, 2.37265319e-01f, -4.03040498e-01f, 1.84400231e-01f, 2.90171802e-01f, 2.45661348e-01f,
  4.96238749e-03f, 1.76261500e-01f, 2.29708198e-02f, 1.37399599e-01f, 3.07886563e-02f, 2.36729667e-01f, 9.66142770e-03f, -6.59325644e-02f, 1.30340382e-01f, 1.08264200e-01f,
  -1.85491756e-01f, -2.61235267e-01f, -2.00145289e-01f, 4.31784987e-02f, -4.11153287e-02f, -1.21600859e-01f, 1.01742163e-01f, -6.46537617e-02f, -6.48062602e-02f, -6.48480728e-02f,
  -1.13119610e-01f, -8.81689116e-02f, -1.48722216e-01f, -2.26936623e-01f, -1.87749922e-01f, -1.57518893e-01f, 3.54980081e-01f, -1.09808818e-01f, -2.71300264e-02f, -2.25504324e-01f,
  -2.01153845e-01f, -1.72629043e-01f, -1.30205989e-01f, 3.02198023e-01f, -5.14473803e-02f, -1.81954086e-01f, 1.76109239e-01f, 1.51629746e-01f, -5.54407015e-02f, 7.65640568e-03f,
  1.68126374e-01f, 3.48955803e-02f, 2.28709623e-01f, 1.70221597e-01f, -4.61963098e-03f, 2.05946481e-03f, 1.41552016e-02f, -2.68262833e-01f, 1.83002636e-01f, 5.26347198e-02f,
  -5.53552359e-02f, 2.29164258e-01f, -5.69136534e-03f, -1.08938947e-01f, 2.27943584e-01f, 1.27240538e-03f, 1.09352976e-01f, 2.80402631e-01f, 7.09046721e-02f, -4.71980944e-02f,
  2.56882738e-02f, -1.49467155e-01f, 4.24042828e-02f, -8.24839845e-02f, 1.58241019e-01f, 3.07148904e-01f, 4.07674536e-02f, 7.03287795e-02f, -1.75473511e-01f, 6.91996962e-02f,
  1.19017866e-02f, 1.59059197e-01f, -1.29101396e-01f, 2.88324580e-02f, 7.16800662e-03f, 1.32880673e-01f, 5.48861437e-02f, 6.59651607e-02f, 1.78131700e-01f, -9.02824029e-02f,
  1.43502336e-02f, 6.98858723e-02f, 1.53449401e-01f, 1.09301060e-02f, 8.54694694e-02f, 1.04963958e-01f, 9.00279582e-02f, -5.94414398e-02f, 4.96528111e-02f, 6.71390817e-02f,
  -1.69269308e-01f, -1.07524330e-02f, -3.04673985e-02f, -5.94029985e-02f, -2.68347502e-01f, 8.43605325e-02f, -3.75391617e-02f, 2.70718843e-01f, 7.16660842e-02f, -6.88269883e-02f,
  3.28766704e-01f, -4.11817640e-01f, 2.69143850e-01f, -4.05608505e-01f, 1.18885383e-01f, 8.61223694e-03f, 2.46472836e-01f, -3.28165978e-01f, 2.29946867e-01f, -1.50317863e-01f,
  -1.71457797e-01f, 2.95682013e-01f, -3.66110057e-01f, 1.20265618e-01f, 4.74051982e-01f, 1.40825942e-01f, 3.94375920e-02f, -6.65683821e-02f, 4.06899989e-01f, -3.21553081e-01f,
  1.39665186e-01f, 3.27662408e-01f, -1.07282609e-01f, -5.29884636e-01f, -1.19520612e-02f, -3.38687360e-01f, -1.29740372e-01f, -2.89164484e-01f, 1.73720941e-01f, -1.11810327e-01f,
  1.68872312e-01f, 1.68193519e-01f, 7.75664346e-03f, 1.51324868e-01f, 2.14514419e-01f, -2.50936389e-01f, 8.26074108e-02f, -1.33091986e-01f, 3.06108594e-01f, 2.84975115e-02f,
  2.13987231e-01f, 1.62338212e-01f, -1.06441557e-01f, -7.81192034e-02f, -7.79767334e-02f, -1.07513711e-01f, -5.08792289e-02f, -8.91372934e-02f, 7.75360614e-02f, -1.05041504e-01f,
  -1.17122479e-01f, 5.00474572e-02f, 1.43909365e-01f, -8.05276334e-02f, -1.24378450e-01f, 5.10054082e-02f, 3.19642216e-01f, -2.02121109e-01f, -4.03091908e-02f, -1.47160077e-02f,
  6.54840842e-02f, -1.32708043e-01f, 1.71682239e-01f, 1.32144406e-01f, -1.73293814e-01f, -9.68390983e-03f, 1.56967938e-01f, -2.13673338e-01f, 1.26842484e-01f, 5.19398823e-02f,
  2.26967573e-01f, 9.48089436e-02f, -3.36330384e-01f, 1.15573652e-01f, -3.00622359e-03f, 8.97368193e-02f, -1.20717064e-01f, -1.84344538e-02f, 3.65112387e-02f, -7.78281763e-02f,
  3.08390018e-02f, 4.38409019e-03f, -7.53875375e-02f, -1.07637592e-01f, 1.71444323e-02f, -9.95852128e-02f, -1.15057692e-01f, 1.39298424e-01f, 3.70979719e-02f, 9.09281373e-02f,
  1.77973751e-02f, -4.01555188e-02f, 8.75590593e-02f, -3.93226534e-01f, 5.93288206e-02f, -3.03933978e-01f, -2.09654078e-01f, 7.62055591e-02f, -1.70199141e-01f, -8.88611078e-02f,
  1.53154299e-01f, 1.23442844e-01f, 1.46882534e-01f, 3.86071727e-02f, 1.19338378e-01f, 1.79476738e-01f, 1.07521556e-01f, 1.81741677e-02f, -3.22776623e-02f, 9.27613825e-02f,
  -1.01872208e-02f, -1.20351575e-01f, 2.07527578e-02f, -1.95670024e-01f, -2.26522423e-02f, 6.08963147e-02f, 1.51517689e-02f, 7.22304806e-02f, 1.71243921e-01f, -1.66586444e-01f,
  1.64655317e-02f, 1.98333666e-01f, 2.94302315e-01f, 1.93577588e-01f, 9.12964195e-02f, -2.67770499e-01f, 4.54993732e-03f, -4.00545865e-01f, -3.95823896e-01f, 2.11231291e-01f,
  3.93048614e-01f, 9.68950838e-02f, 6.71660006e-02f, -3.70686680e-01f, -3.91160905e-01f, 1.97100192e-02f, 1.83409765e-01f, -4.39555258e-01f, -6.00831956e-02f, 2.16750219e-01f,
  1.54007599e-01f, 1.78328693e-01f, -1.07528321e-01f, -1.33275002e-01f, 3.20768356e-01f, 5.46624847e-02f, 4.93564427e-01f, -3.78433108e-01f, 2.12421969e-01f, 1.16404034e-01f,
  3.72356415e-01f, -1.76904783e-01f, -2.53752500e-01f, 2.78459847e-01f, -2.19877288e-01f, -3.23016793e-01f, -1.33806974e-01f, -2.01239046e-02f, 9.29015502e-02f, -5.84137700e-02f,
  3.07015446e-03f, -3.80402714e-01f, -1.77629039e-01f, -1.34627074e-01f, 2.57100612e-01f, -8.59391391e-02f, -2.44212359e-01f, -1.02544099e-01f, 7.52886459e-02f, 2.34495878e-01f,
  -1.03004485e-01f, -1.89377904e-01f, -1.83552325e-01f, 1.41701922e-01f, -1.06068905e-02f, -3.30964960e-02f, -1.69445887e-01f, -6.52915835e-02f, -5.73154725e-02f, -9.94854197e-02f,
  -1.97969928e-01f, -3.16382237e-02f, 1.43057600e-01f, -5.83775155e-02f, 2.93335021e-01f, -9.75875258e-02f, 1.00552700e-01f, -4.84678671e-02f, -8.68247375e-02f, -4.79329303e-02f,
  2.10720763e-01f, 2.11093843e-01f, -1.70169711e-01f, -2.15176597e-01f, 2.21645594e-01f, -1.85568213e-01f, 8.13855976e-03f, 3.44267897e-02f, -6.78023770e-02f, -1.85375791e-02f,
  1.37371542e-02f, -1.20668672e-01f, 1.27354994e-01f, -6.77773207e-02f, -3.04792728e-02f, -7.02599064e-02f, -7.26616457e-02f, 1.88030168e-01f, -1.55754700e-01f, 6.27283901e-02f,
  7.93702528e-02f, 5.71319200e-02f, -2.48067111e-01f, -6.34241775e-02f, 4.10930291e-02f, -1.02659039e-01f, -1.23938344e-01f, -6.80772215e-02f, -2.90207684e-01f, 7.43898675e-02f,
  2.38420293e-02f, -1.47295743e-01f, -7.45034143e-02f, -6.61702976e-02f, -9.96803567e-02f, -1.76751927e-01f, 1.32332779e-02f, 4.95743454e-02f, -1.23662882e-01f, -2.60991361e-02f,
  6.98526502e-02f, -9.41133201e-02f, 3.22663039e-02f, -5.94812967e-02f, 1.07029080e-01f, -1.07960857e-01f, 7.90662244e-02f, 4.12880480e-02f, -2.83037163e-02f, -2.54430264e-01f,
  -1.13281772e-01f, -2.26527840e-01f, 1.29130334e-01f, 3.49669755e-02f, -3.70654047e-01f, -1.41322419e-01f, 6.49920776e-02f, 1.91165030e-01f, -2.47666508e-01f, -1.27752602e-01f,
  2.54530162e-01f, -2.49069750e-01f, 1.83289841e-01f, -1.45193025e-01f, -1.02488279e-01f, -2.84857452e-01f, 3.10631126e-01f, -2.86600530e-01f, 1.09390670e-03f, 2.20988125e-01f,
  -6.82403669e-02f, -2.31189281e-01f, 1.35443330e-01f, 2.10894927e-01f, -1.21289492e-01f, 1.35550484e-01f, -1.17257066e-01f, 1.13647833e-01f, -4.95812967e-02f, -3.06855351e-01f,
  -1.07397191e-01f, -2.31346153e-02f, -2.98634946e-01f, -3.52817476e-01f, 1.86987743e-01f, 3.08642358e-01f, 2.45195106e-01f, -1.52914986e-01f, -1.54028237e-01f, 2.40047380e-01f,
  -2.45503813e-01f, 2.26695850e-01f, 2.17545390e-01f, -1.73983365e-01f, -1.15258045e-01f, -1.08393088e-01f, 3.66999246e-02f, -1.66668132e-01f, -1.40625089e-01f, -1.83794096e-01f,
  3.26861411e-01f, -1.82072297e-01f, -2.27049232e-01f, 1.13207899e-01f, 1.60017461e-01f, 3.36814493e-01f, 8.77870992e-02f, 2.07021594e-01f, 7.66061619e-02f, 5.42325638e-02f,
  1.98057950e-01f, -1.60117641e-01f, 1.99701682e-01f, 4.61439453e-02f, 1.12350143e-01f, 1.53154045e-01f, 1.84441209e-01f, 2.18238775e-02f, -1.64837271e-01f, -1.64704040e-01f,
  -2.22648352e-01f, -5.04056998e-02f, 3.70030403e-02f, 1.53135290e-04f, -1.82676181e-01f, -2.26493552e-02f, -3.93748544e-02f, -1.20393895e-01f, -1.76193821e-03f, 7.77454451e-02f,
  -8.29768032e-02f, 4.35914755e-01f, 7.81488121e-02f, -5.23000099e-02f, -2.06619482e-02f, 9.06874333e-03f, -1.63414180e-01f, 8.72657597e-02f, 4.45491821e-02f, -7.04686204e-03f,
  -7.58584216e-02f, -3.32097203e-01f, 8.23784694e-02f, 3.41780335e-02f, -9.59420484e-03f, 8.76904000e-03f, -9.71100330e-02f, -7.24874884e-02f, 7.44920969e-02f, -3.77123915e-02f,
  6.66173315e-03f, 6.10843152e-02f, 5.60503155e-02f, -6.44826740e-02f, -3.11766546e-02f, -1.58533324e-02f, -2.59203110e-02f, -1.65531673e-02f, -7.85597190e-02f, -1.65383127e-02f,
  -1.74682319e-01f, 1.35225449e-02f, 7.52877370e-02f, -6.82509616e-02f, -8.97506773e-02f, 9.93926972e-02f, -4.84770350e-02f, -1.69441458e-02f, -2.03332826e-02f, 4.69678380e-02f,
  7.86771178e-02f, -1.59064099e-01f, -1.19214371e-01f, -2.36286044e-01f, 1.27992108e-01f, -2.54665855e-02f, -6.66897744e-02f, -4.79439832e-02f, -1.03177533e-01f, 1.56345755e-01f,
  -1.11113988e-01f, 5.42140193e-02f, 5.64763248e-02f, -1.89748928e-01f, -4.74040769e-02f, -1.70968816e-01f, 2.39364386e-01f, -3.05970520e-01f, -2.73800679e-02f, -2.19773039e-01f,
  -1.98363751e-01f, -3.37797016e-01f, -3.85701329e-01f, -1.25044361e-01f, -1.13134965e-01f, -1.15108177e-01f, -8.84987786e-02f, -1.79637685e-01f, 1.78868860e-01f, -2.55175561e-01f,
  -1.35248840e-01f, 7.70817101e-02f, -1.10171460e-01f, 7.77062550e-02f, 1.59064963e-01f, -2.20517337e-01f, -2.47897059e-02f, 7.76417553e-02f, 2.08352789e-01f, -2.69521743e-01f,
  -1.43016919e-01f, 3.54316831e-01f, 2.72103101e-01f, 5.54898418e-02f, -8.17185491e-02f, -2.33450443e-01f, -7.77645037e-02f, -2.20090076e-01f, 2.66326994e-01f, -1.80917010e-01f,
  -1.19838484e-01f, -5.95981851e-02f, -2.40394816e-01f, 3.40888560e-01f, -3.39398116e-01f, -6.57679513e-02f, 9.10849348e-02f, 2.49691591e-01f, -1.72949463e-01f, 3.32928270e-01f,
  1.29388494e-03f, -3.04785758e-01f, 7.41655678e-02f, 3.49737443e-02f, 3.25370252e-01f, 3.17920707e-02f, -3.53745930e-02f, 1.72568038e-02f, 2.16069207e-01f, 3.08904141e-01f,
  -1.00408442e-01f, 5.87326884e-02f, 2.50741038e-02f, -7.04246238e-02f, 4.05577898e-01f, -1.28292769e-01f, -1.49248354e-02f, -1.10973023e-01f, -1.40870750e-01f, -7.37625659e-02f,
  1.67702049e-01f, 3.96993896e-03f, 7.19228312e-02f, 4.99259800e-01f, 6.63446561e-02f, 7.55276158e-02f, 4.53355499e-02f, -4.80962992e-02f, -7.72171188e-03f, 1.85397014e-01f,
  -7.72541165e-02f, 2.49851551e-02f, -1.75134599e-01f, -8.12492222e-02f, 7.56749585e-02f, 1.58268437e-01f, 1.61161020e-01f, 2.73414869e-02f, -1.20108955e-01f, 6.10267883e-03f,
  -1.58468559e-02f, -1.15323812e-01f, -9.70555004e-03f, -1.72304481e-01f, 6.90726936e-02f, -7.05743507e-02f, 1.21894376e-02f, 9.47537944e-02f, 1.54254004e-01f, 7.00469464e-02f,
  1.75125703e-01f, 1.13436252e-01f, -1.71306446e-01f, -1.35914295e-03f, 1.45060629e-01f, 1.14518829e-01f, 2.16518659e-02f, -1.03607878e-01f, -1.04789659e-01f, 1.89355552e-01f,
  -1.78661905e-02f, 1.00303724e-01f, 1.47787333e-01f, -8.84503946e-02f, 1.09232709e-01f, -5.66488765e-02f, -1.55939609e-01f, 6.48289248e-02f, -1.68334112e-01f, 1.45666644e-01f,
  3.95745859e-02f, 8.29261728e-03f, -1.19351344e-02f, 8.03595930e-02f, -1.51455570e-02f, -4.44142818e-02f, 1.07906416e-01f, 1.52033076e-01f, 4.86329123e-02f, -2.22222298e-01f,
  -5.65334186e-02f, -1.47140725e-03f, -1.68722291e-02f, -3.54763389e-01f, -2.18351662e-01f, 1.49936721e-01f, 1.49954766e-01f, 3.57627273e-02f, -1.34692594e-01f, -2.52052158e-01f,
  1.48471758e-01f, -1.68874227e-02f, 4.21116680e-01f, 1.91961810e-01f, 4.51316088e-01f, 2.68846303e-01f, 3.42665352e-02f, -2.82351285e-01f, -2.45230645e-01f, 1.54025897e-01f,
  2.57738054e-01f, 1.14422046e-01f, 1.01139374e-01f, 2.10836947e-01f, -4.91635948e-02f, -6.93082958e-02f, -5.30532226e-02f, 1.43287525e-01f, 4.19466466e-01f, -2.86962777e-01f,
  -2.26597443e-01f, -2.30362847e-01f, 8.61303359e-02f, 2.02720627e-01f, -3.18648398e-01f, 3.29066664e-02f, 3.25887829e-01f, 3.15677524e-01f, 2.71847457e-01f, 3.53900105e-01f,
  -5.30327596e-02f, -1.39194444e-01f, 1.81757823e-01f, 1.90720826e-01f, -5.24533130e-02f, -3.60809922e-01f, -2.81155735e-01f, 2.07951735e-03f, -3.00385021e-02f, 1.14486493e-01f,
  -3.31522495e-01f, 1.93005770e-01f, -1.79618672e-01f, -3.10261250e-01f, 5.78678958e-03f, -8.27609226e-02f, -1.16681568e-01f, -5.92323206e-02f, -7.02645630e-02f, -7.84936994e-02f,
  2.17925441e-02f, -1.03971668e-01f, -1.14958316e-01f, 1.62906572e-01f, -1.44031405e-01f, -2.28526309e-01f, 7.51173124e-02f, 1.19540282e-01f, -2.41319120e-01f, 1.73090585e-02f,
  -1.66496217e-01f, -1.87337458e-01f, -2.08133787e-01f, -1.23407573e-01f, -2.58330405e-02f, 2.65886694e-01f, 5.33159912e-01f, 3.16790417e-02f, -1.24814481e-01f, -1.17352203e-01f,
  -1.22472376e-01f, 5.42941652e-02f, 1.03615671e-01f, 4.23892885e-02f, 4.95087914e-02f, 1.44042820e-01f, -8.67317989e-02f, 1.00911662e-01f, -2.70725247e-02f, -1.17200464e-01f,
  -4.69982587e-02f, -8.96736793e-03f, 1.24123991e-01f, 7.29889274e-02f, 1.75185248e-01f, -1.91551819e-02f, 9.23724398e-02f, -3.35539720e-04f, -5.80256172e-02f, 8.56607854e-02f,
  -4.33178060e-02f, -6.15183413e-02f, -4.17521484e-02f, -5.84093574e-03f, -1.05833620e-01f, 1.83392897e-01f, 2.76390500e-02f, -1.35656267e-01f, 4.28094231e-02f, 4.25367914e-02f,
  -1.52574226e-01f, -4.94901463e-02f, 5.78142591e-02f, 1.16581298e-01f, 2.85720248e-02f, -2.84450338e-03f, 7.26338103e-02f, 1.22844949e-01f, 6.49259165e-02f, 7.94248357e-02f,
  -6.65934710e-03f, -1.81290954e-02f, 1.88824944e-02f, 1.70567095e-01f, 3.77192162e-02f, 1.00965761e-01f, 6.01563603e-03f, -5.96203795e-03f, 5.80947436e-02f, 1.10125512e-01f,
  -6.44548088e-02f, 3.52908015e-01f, -5.13955504e-02f, 1.37695670e-02f, 1.95970416e-01f, -2.05830157e-01f, -9.19543430e-02f, 3.57357234e-01f, -1.15703441e-01f, 3.05552602e-01f,
  -4.19988722e-01f, 3.17305177e-01f, -3.52045745e-01f, 1.13356911e-01f, 1.15541533e-01f, 1.11838363e-01f, 1.33700877e-01f, 1.84241310e-01f, -2.90604383e-01f, -1.69358641e-01f,
  1.45028338e-01f, -1.42872512e-01f, 2.80265272e-01f, 3.70176911e-01f, -1.70419425e-01f, 2.96194583e-01f, -2.10305527e-01f, -1.93498150e-01f, -2.39319295e-01f, 3.68597806e-01f,
  -2.08382607e-01f, -3.20924133e-01f, -3.66771877e-01f, 2.16832966e-01f, 6.03125803e-02f, 6.02927841e-02f, -6.67145997e-02f, -3.04070652e-01f, -2.60008126e-01f, 1.29096016e-01f,
  1.25881150e-01f, -9.19484571e-02f, -2.89645642e-01f, -9.92283691e-03f, 1.14729390e-01f, 3.73616338e-01f, -1.85174853e-01f, -2.57429570e-01f, 1.91142172e-01f, -2.70578172e-02f,
  -2.35305786e-01f, -2.66134083e-01f, -2.19511434e-01f, 3.24109435e-01f, -7.54106566e-02f, -2.35427190e-02f, 7.41255283e-02f, 1.77613243e-01f, -1.69148043e-01f, 1.10364430e-01f,
  -9.66131315e-02f, -9.67188552e-02f, 1.71195105e-01f, 5.64601086e-02f, 1.59566868e-02f, 4.01999578e-02f, -1.39637783e-01f, 1.62234128e-01f, 1.52074680e-01f, 2.21328232e-02f,
  -1.47724643e-01f, -7.90071040e-02f, -4.64326032e-02f, -6.70611411e-02f, -2.41005719e-01f, -2.87155747e-01f, 4.06876653e-02f, 1.07257962e-01f, 1.08574979e-01f, -4.65462953e-02f,
  4.50333320e-02f, -1.07302926e-01f, -5.19459136e-03f, 2.53970474e-02f, 4.40221727e-02f, 2.00309202e-01f, -3.43252979e-02f, 1.69496790e-01f, -4.85644769e-03f, -2.00491846e-01f,
  8.89600739e-02f, -4.75001335e-02f, -3.40556018e-02f, 1.02513932e-01f, -7.59064034e-02f, 8.82524252e-02f, -2.17448436e-02f, 8.31465051e-03f, -1.17902428e-01f, 2.45411433e-02f,
  1.11436643e-01f, -2.61578728e-02f, 2.18189824e-02f, 3.17876749e-02f, -5.98874837e-02f, -3.59674394e-02f, 1.65186733e-01f, 2.12492961e-02f, -1.56156301e-01f, 5.37760220e-02f,
  -3.64454269e-01f, 1.36711076e-01f, -5.80728576e-02f, 9.06762481e-02f, 8.40229616e-02f, 1.16292410e-01f, -1.87088475e-01f, 9.96114090e-02f, -1.22056521e-01f, 8.56421292e-02f,
  4.00486328e-02f, 1.31452054e-01f, 2.12118983e-01f, 6.11428842e-02f, 3.08932643e-02f, 1.02283649e-01f, -7.74545968e-03f, 1.40686959e-01f, 4.95772325e-02f, -1.26485780e-01f,
  2.88492404e-02f, 2.87128657e-01f, 2.34432846e-01f, 9.12286863e-02f, 4.16899584e-02f, -3.87004539e-02f, -4.73565906e-02f, -4.10320044e-01f, 1.44185945e-02f, 1.71656966e-01f,
  -4.70274180e-01f, -1.28960818e-01f, -1.07574388e-01f, -2.70881534e-01f, 1.05939833e-02f, -3.69484395e-01f, -2.84723490e-01f, 2.90086381e-02f, -1.48619190e-01f, -3.79187256e-01f,
  -3.08489893e-02f, -7.51065090e-02f, 1.98585942e-01f, 3.04376185e-01f, 2.21239731e-01f, -2.02291608e-01f, 2.27984831e-01f, 3.37469041e-01f, 5.60260750e-02f, 4.36468154e-01f,
  2.20637709e-01f, -4.75199968e-01f, -3.56527902e-02f, -2.46520042e-01f, 8.47751647e-02f, 8.64176527e-02f, 1.15700401e-01f, 4.68072772e-01f, 1.80874411e-02f, -3.20334882e-01f,
  8.95894617e-02f, 5.85050881e-02f, -1.07949726e-01f, -6.54244497e-02f, 6.98283315e-03f, 2.66820252e-01f, 2.27314293e-01f, -8.85864049e-02f, 2.38036007e-01f, -2.56502777e-01f,
  4.76230562e-01f, 1.87306851e-01f, 4.05843630e-02f, -1.09691564e-02f, 9.70062613e-02f, 2.14018211e-01f, -5.56286983e-02f, -2.23712876e-01f, -3.36465538e-02f, -9.40512493e-02f,
  3.26986074e-01f, -9.60044712e-02f, 7.86724091e-02f, 6.75389022e-02f, -1.76572978e-01f, 5.56138121e-02f, 7.25212842e-02f, -2.15717182e-02f, -4.67072390e-02f, 1.16295643e-01f,
  -1.41851962e-01f, -4.61568683e-02f, -9.65102464e-02f, -6.47307187e-02f, 1.32322997e-01f, -1.68595672e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.16995278e-03f, -2.36508120e-02f, 3.41329277e-02f, 7.10962415e-02f, 5.04870666e-03f, -6.71594292e-02f, 5.97476326e-02f, 7.52120838e-02f, -5.66495322e-02f, 4.44677472e-02f,
  -1.36982044e-02f, -1.95867103e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    