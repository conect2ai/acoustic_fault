/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.59861162e-01f, 3.07073325e-01f, 6.08583577e-02f, -3.39973271e-02f, -1.46708399e-01f, -3.92723531e-01f, -3.76645774e-01f, 9.75756273e-02f, 5.13609536e-02f, 2.01197922e-01f,
  -1.32361621e-01f, -3.07072839e-03f, 1.12757050e-01f, -2.77297616e-01f, -5.07998466e-01f, -7.04444721e-02f, -3.07124734e-01f, -2.03550830e-01f, -9.00688842e-02f, -8.80256295e-02f,
  -1.08899243e-01f, -2.73079485e-01f, -1.94290757e-01f, -8.73176455e-02f, 4.05542403e-02f, 1.90640584e-01f, -9.41170845e-03f, 3.64661068e-02f, -6.01841239e-05f, -6.09581135e-02f,
  -1.51421174e-01f, 1.37926489e-01f, 1.35670871e-01f, -2.88077481e-02f, 1.06329191e-02f, 3.26190144e-02f, -8.71399790e-02f, -8.54631886e-02f, -1.25258893e-01f, 9.49487463e-03f,
  3.44128255e-03f, -3.89101617e-02f, -4.67422307e-02f, 1.04725949e-01f, -7.46492967e-02f, -6.98231682e-02f, 6.71616290e-04f, -2.88922768e-02f, 2.71253083e-02f, 4.50612009e-02f,
  -3.09376214e-02f, -1.81266274e-02f, 3.12387303e-04f, 2.89906245e-02f, 1.59261022e-02f, 3.27751413e-02f, 2.90402919e-02f, 8.90621543e-02f, -2.47703101e-02f, 1.40963629e-01f,
  2.71089692e-02f, 1.21879801e-02f, 6.10992834e-02f, -6.08831458e-02f, -3.60592604e-02f, 2.09066514e-02f, -8.46012533e-02f, 4.27065417e-03f, 3.05490792e-02f, 6.47995947e-03f,
  4.53861393e-02f, 1.16777785e-01f, -8.72413963e-02f, -6.25147745e-02f, 1.16205849e-01f, 5.93611635e-02f, -7.65649602e-02f, 1.25791892e-01f, -9.30901319e-02f, -4.81338575e-02f,
  -4.81359325e-02f, 8.99880286e-03f, 5.96781708e-02f, -3.44322510e-02f, -2.47558281e-02f, -5.68079911e-02f, 2.69305762e-02f, 9.64463651e-02f, 8.00747201e-02f, -2.72421986e-02f,
  -2.32273131e-03f, 2.77225196e-01f, 1.56464763e-02f, 2.52551120e-02f, 5.30139310e-03f, 5.09942845e-02f, -1.40745759e-01f, 3.53860930e-02f, 6.79217353e-02f, 2.78094579e-02f,
  2.67448323e-03f, -7.08554164e-02f, 7.81360734e-03f, -4.36175913e-02f, 9.61135402e-02f, -1.41108939e-02f, -6.51533827e-02f, 1.95825775e-03f, 2.73279883e-02f, 2.88840346e-02f,
  3.19617763e-02f, -7.05308989e-02f, 6.40681237e-02f, -7.58643895e-02f, -6.99672028e-02f, 8.93147364e-02f, -5.27221002e-02f, -6.14548847e-03f, -1.14117712e-02f, -4.47027162e-02f,
  2.84998298e-01f, -2.67503168e-02f, 2.14149982e-01f, -4.40092720e-02f, -2.45888289e-02f, 1.39071152e-01f, 1.41344234e-01f, -7.79941157e-02f, 2.39189491e-01f, -2.17060059e-01f,
  -2.91661829e-01f, 4.93410170e-01f, -4.16258574e-02f, -2.27468699e-01f, 1.52941331e-01f, -1.33608347e-02f, -1.36695206e-01f, 1.43039590e-02f, 1.03757292e-01f, -1.30154759e-01f,
  -1.42574683e-01f, -3.45963150e-01f, -1.11179508e-01f, -4.83345464e-02f, -7.75659010e-02f, -1.14493603e-02f, -2.65569806e-01f, 1.30319120e-02f, -1.22909792e-01f, -5.74361719e-02f,
  6.50671571e-02f, -1.53235748e-01f, -1.08204931e-01f, -3.25949565e-02f, -4.39690202e-02f, -4.19530571e-02f, -4.23705541e-02f, -8.65607634e-02f, 4.42444943e-02f, -1.43861966e-02f,
  -3.88736241e-02f, -1.99676175e-02f, 2.24335361e-02f, 5.53713006e-04f, 1.01630436e-02f, -4.23221439e-02f, -6.07253797e-02f, -4.50533032e-02f, -6.53492212e-02f, -2.86121923e-03f,
  -1.68542638e-02f, -1.89729556e-02f, -4.35320139e-02f, 4.59252670e-02f, -3.06475093e-04f, 2.72491202e-02f, 2.52288058e-02f, 1.58199649e-02f, -1.73410457e-02f, 4.55779955e-02f,
  -2.09731571e-02f, 3.44640166e-02f, 5.83014674e-02f, -2.22507641e-02f, 2.33713798e-02f, 6.00748602e-03f, 6.63359091e-02f, -7.76979774e-02f, 3.84605154e-02f, -1.06325246e-01f,
  -6.64162114e-02f, -1.17864639e-01f, 1.28308656e-02f, -2.60079596e-02f, -6.08822852e-02f, -6.36299998e-02f, -2.03759223e-02f, -1.90975927e-02f, -3.74908047e-03f, -4.25631292e-02f,
  3.30074355e-02f, 8.41593444e-02f, -5.18051051e-02f, -3.15567805e-03f, 2.57232599e-03f, -1.94258261e-02f, -4.56143282e-02f, 7.43839070e-02f, -1.93953235e-02f, 1.13612898e-02f,
  -9.40208212e-02f, -1.67368248e-01f, -1.10894352e-01f, -5.15689403e-02f, 1.07016467e-01f, -8.71227533e-02f, 7.84913450e-02f, -3.20146345e-02f, -4.38950071e-03f, -4.05759066e-02f,
  -6.44249022e-02f, -1.48277864e-01f, 8.90128464e-02f, -1.13351950e-02f, 2.79891882e-02f, -7.28773624e-02f, -9.61419102e-03f, 4.90789115e-03f, -1.48807123e-01f, -9.15854797e-02f,
  -1.34207442e-01f, 4.17988189e-03f, -7.31587633e-02f, -4.41474188e-03f, -1.35972112e-01f, 2.64069680e-02f, 1.60287619e-01f, -8.00009817e-02f, -8.38404223e-02f, 6.64803088e-02f,
  -2.77298272e-01f, 1.63585275e-01f, -6.16095476e-02f, -2.24421211e-02f, -1.72054514e-01f, -2.63660699e-01f, -3.54061186e-01f, 6.11580685e-02f, -9.08844769e-02f, 1.07945703e-01f,
  -1.47820026e-01f, -5.34605794e-02f, 6.24630339e-02f, 2.54381523e-02f, -2.89765596e-01f, 1.00148283e-01f, -8.43411498e-03f, 6.59584701e-02f, -6.97820410e-02f, 4.25596312e-02f,
  -7.48912618e-03f, -3.66479270e-02f, -1.39206409e-01f, 1.33239493e-01f, -1.14997663e-01f, -5.75518142e-03f, 1.90287068e-01f, -1.08284667e-01f, 1.24033526e-01f, -2.89289709e-02f,
  -1.00460038e-01f, 2.81442404e-02f, -2.38657594e-02f, 1.10910228e-02f, 3.19326073e-02f, -5.71640991e-02f, -2.41651237e-02f, -1.98828429e-03f, -1.01973265e-01f, -2.34532561e-02f,
  9.25616547e-02f, -7.19675273e-02f, -2.60303058e-02f, 4.98789772e-02f, -3.72021459e-03f, -4.57972940e-03f, -5.27521893e-02f, 8.49591568e-02f, 2.63826270e-03f, -7.01923296e-02f,
  -8.86928216e-02f, 4.97753695e-02f, 6.25713244e-02f, 1.01515718e-01f, 3.29564661e-02f, -1.54392626e-02f, 3.94636355e-02f, 1.23934513e-02f, 3.62079144e-02f, 6.90024793e-02f,
  5.97735383e-02f, 6.67994767e-02f, 6.99301884e-02f, 7.44188018e-03f, -4.20495421e-02f, 2.25391816e-02f, -1.38568403e-02f, -4.38928269e-02f, -5.42708002e-02f, -6.99420646e-02f,
  -6.33002743e-02f, 2.23939363e-02f, 2.41755061e-02f, -7.70566473e-03f, -3.45943235e-02f, 1.16898399e-02f, -4.08383310e-02f, 9.34817269e-02f, -3.62922512e-02f, 2.77202167e-02f,
  -1.87577177e-02f, -1.84749085e-02f, 4.03156970e-03f, 1.14150546e-01f, 5.65551482e-02f, -1.12826601e-01f, -2.37797089e-02f, 7.98186138e-02f, 8.18686113e-02f, -5.19746058e-02f,
  1.36196062e-01f, 2.83867210e-01f, -3.46880294e-02f, -8.68162215e-02f, 6.24105148e-02f, 4.09395918e-02f, 5.20900823e-02f, 8.99127647e-02f, 3.59361619e-02f, 4.92364578e-02f,
  6.20026514e-02f, 1.16828263e-01f, -6.67281041e-04f, -5.46275713e-02f, -6.74093887e-02f, -8.19598045e-03f, 7.25594014e-02f, 5.39449193e-02f, 8.34969804e-02f, 1.30670384e-01f,
  6.25408217e-02f, 7.59802908e-02f, 8.37544166e-03f, 2.65697259e-02f, -2.96115819e-02f, 2.25458458e-01f, 6.71425760e-02f, -2.70281862e-02f, 9.61105749e-02f, -1.85390394e-02f,
  -4.99100059e-01f, 1.29492521e-01f, 2.90806983e-02f, -5.40053882e-02f, -3.87758732e-01f, -3.01312566e-01f, -1.79570496e-01f, -1.41976371e-01f, -2.20148295e-01f, 1.06378704e-01f,
  -1.40029460e-01f, 1.60135910e-01f, 6.40097558e-02f, 1.13972269e-01f, -5.75253665e-02f, 1.37537554e-01f, -1.88155115e-01f, 2.22659502e-02f, -1.25505654e-02f, -1.78311449e-02f,
  -1.20814204e-01f, -9.40748900e-02f, 3.60818654e-02f, 1.77189503e-02f, -9.25376862e-02f, 1.88709097e-03f, 8.35684910e-02f, 1.37122616e-01f, -1.18447162e-01f, 8.76290426e-02f,
  -1.04797848e-01f, -9.54801217e-02f, -3.13343704e-02f, 5.89352883e-02f, -6.14671111e-02f, -5.93311116e-02f, 8.27556252e-02f, 1.64981306e-01f, -1.78985093e-02f, -2.62656081e-02f,
  1.55567273e-01f, 1.72183421e-02f, -1.29161514e-02f, -2.09652372e-02f, -1.56791769e-02f, -9.00541097e-02f, 6.81843758e-02f, -7.57417157e-02f, 1.64504170e-01f, 6.93967044e-02f,
  5.91330305e-02f, 1.22400463e-01f, -3.45697626e-02f, 5.79862334e-02f, -5.85576380e-03f, 9.01815202e-03f, 8.93765837e-02f, 1.35069057e-01f, 8.13282933e-03f, 3.66515629e-02f,
  -1.00040277e-02f, -2.25795619e-02f, -1.09622456e-01f, -3.51648480e-02f, -6.54705763e-02f, -4.36301380e-02f, -2.86391843e-02f, -4.68973964e-02f, 9.56862271e-02f, -7.18060043e-03f,
  -6.27449304e-02f, -1.56126115e-02f, 3.95456664e-02f, 3.46964747e-02f, 7.56409094e-02f, -4.17603739e-02f, 1.06266379e-01f, 4.00779769e-02f, 6.20486215e-02f, -2.99942158e-02f,
  -4.73140329e-02f, 1.06962226e-01f, -1.32519439e-01f, 5.46423793e-02f, 1.28354235e-02f, 3.69495936e-02f, -4.45589349e-02f, 6.26827478e-02f, -6.30035028e-02f, 3.72743681e-02f,
  4.70752679e-02f, -3.66467126e-02f, 3.36836763e-02f, 3.16749699e-02f, 6.64621294e-02f, 5.17048351e-02f, -4.32453714e-02f, -8.61310363e-02f, -4.30166647e-02f, -1.93072140e-01f,
  2.09340639e-02f, 9.11429226e-02f, 4.09995019e-02f, 5.15122265e-02f, 4.53277268e-02f, 9.32651758e-02f, 1.31913349e-02f, -3.89472544e-02f, -2.46309470e-02f, 2.20065806e-02f,
  -9.41860452e-02f, -5.98299429e-02f, 8.92835557e-02f, -4.56315763e-02f, -7.75155872e-02f, -5.68001866e-02f, -4.87371795e-02f, 7.06464276e-02f, -3.04862335e-02f, 7.09166825e-02f,
  5.72644651e-01f, -3.59014459e-02f, -4.23942395e-02f, 6.64191172e-02f, 2.42350683e-01f, -1.09788589e-02f, 1.07300408e-01f, -5.05592115e-02f, -3.75393569e-03f, -1.13461271e-01f,
  8.13099742e-02f, 1.83811814e-01f, -5.40511012e-02f, -8.94894674e-02f, 2.76385874e-01f, -8.22701454e-02f, 1.52950883e-01f, 8.17814395e-02f, 7.27823228e-02f, 1.82799205e-01f,
  1.11134589e-01f, -4.12799567e-02f, 4.00900841e-02f, -4.83631268e-02f, -7.96631351e-02f, -1.73489924e-03f, -1.04656868e-01f, -5.73577844e-02f, -1.40665874e-01f, -8.41111597e-03f,
  1.46079697e-02f, -2.31985771e-03f, 2.16023880e-03f, -1.16046950e-01f, 4.81729805e-02f, 2.63107158e-02f, 4.98690307e-02f, 5.99317141e-02f, 4.19239886e-02f, -1.02035955e-01f,
  7.02248812e-02f, -2.62212418e-02f, -3.02146981e-03f, -6.10342957e-02f, -4.10888717e-02f, -5.85200600e-02f, -6.19769730e-02f, 4.76034172e-03f, 2.72713955e-02f, -6.72168657e-02f,
  4.28512953e-02f, -8.32417682e-02f, 8.21095519e-03f, -8.97725672e-02f, -6.56752512e-02f, 3.09998095e-02f, 2.29209978e-02f, 2.51041576e-02f, -7.01421574e-02f, -1.55857578e-02f,
  1.15825068e-02f, 4.44117049e-03f, 7.36510977e-02f, 9.81288590e-03f, 4.23571914e-02f, 2.11546198e-02f, -2.57297512e-02f, 6.49001077e-02f, -4.57327552e-02f, 3.93192060e-02f,
  -1.58592220e-03f, 2.59172413e-02f, 9.99296177e-03f, -1.69335306e-02f, 3.59080136e-02f, -6.98646344e-03f, -6.60434831e-03f, -4.03620452e-02f, -7.28284642e-02f, 2.81658154e-02f,
  3.40225175e-02f, -1.04012536e-02f, -8.05482827e-03f, -6.52660355e-02f, 7.21258968e-02f, -9.44494978e-02f, -2.08591502e-02f, -4.82320786e-02f, 1.07801914e-01f, 7.38241673e-02f,
  -1.25474744e-02f, -2.60448959e-02f, -1.06452284e-02f, 5.48353903e-02f, -3.12686265e-02f, -5.75167835e-02f, 1.91532709e-02f, -9.00660381e-02f, -2.01259870e-02f, -3.81426662e-02f,
  -3.47512728e-03f, 4.90338318e-02f, 2.61443295e-02f, -9.70787555e-02f, -1.02821197e-02f, -5.17925201e-03f, 7.40952278e-03f, 4.42036614e-03f, 5.46735637e-02f, 2.74648070e-02f,
  4.24919277e-03f, 6.99821338e-02f, 5.04133403e-02f, -5.84091917e-02f, 2.06562970e-02f, 1.40109196e-01f, 1.74228381e-02f, -4.75021377e-02f, -6.95531443e-02f, 4.13001835e-04f,
  6.75871670e-01f, -3.71344923e-03f, 3.10029030e-01f, 3.11648250e-01f, 1.58775393e-02f, 8.92130136e-02f, -4.88690510e-02f, -4.12553130e-03f, 3.47838402e-01f, -5.99178448e-02f,
  -1.51444897e-01f, 3.20970565e-01f, -1.68753877e-01f, 1.68382272e-01f, 3.83799434e-01f, 2.39440892e-02f, 2.17946500e-01f, 1.04909979e-01f, 9.13291425e-02f, 1.46334469e-01f,
  1.40155271e-01f, -3.23669687e-02f, 2.00025234e-02f, -1.68498904e-01f, 9.44228098e-02f, 1.01768583e-01f, -1.02268597e-02f, 1.48510644e-02f, 1.64548233e-02f, -3.08027249e-02f,
  -1.59626633e-01f, -7.70844445e-02f, 6.09483235e-02f, -1.32568199e-02f, 5.49734794e-02f, 3.80622558e-02f, 9.03227031e-02f, -3.10394987e-02f, -3.04987039e-02f, 3.36641222e-02f,
  5.49731255e-02f, 3.95456068e-02f, 1.03380635e-01f, -3.61200310e-02f, 5.70971258e-02f, 4.16319221e-02f, -9.82953422e-03f, -7.89769217e-02f, -3.12249698e-02f, -7.99489301e-03f,
  -5.24731129e-02f, 4.20356989e-02f, 1.73001528e-01f, 8.08943361e-02f, 3.59826051e-02f, -1.95036258e-03f, 1.81085598e-02f, 2.15802714e-02f, 5.75161912e-02f, 6.44962937e-02f,
  6.47334084e-02f, -4.43560304e-03f, 5.18305302e-02f, -2.21376307e-02f, -2.35173292e-02f, -3.86268161e-02f, -5.05171297e-03f, -9.32679251e-02f, 9.36676636e-02f, -3.58638987e-02f,
  -2.57403143e-02f, 5.80667146e-02f, 4.30599526e-02f, -2.97711473e-02f, -1.62886679e-02f, -9.54392925e-03f, 1.91569906e-02f, 2.98968330e-02f, 8.18628520e-02f, -4.67263535e-02f,
  -5.50774820e-02f, 5.48711186e-03f, 1.98224224e-02f, -2.88854819e-02f, -5.81509881e-02f, -1.65530568e-04f, 2.46969219e-02f, 5.05452640e-02f, -5.28540090e-02f, 3.53092961e-02f,
  9.11522005e-03f, 2.59496778e-01f, -2.07104851e-02f, 4.12406251e-02f, -4.89780027e-03f, 5.52863628e-02f, -2.47824378e-02f, 3.57888527e-02f, 6.58176607e-03f, 6.64865673e-02f,
  4.22338396e-02f, -5.53633720e-02f, 4.73562703e-02f, -8.53195228e-03f, -4.04259749e-02f, 7.83903152e-02f, 3.79906781e-02f, -1.09560370e-01f, 9.02138129e-02f, 1.28984079e-01f,
  -9.88788307e-02f, -2.64638085e-02f, -5.20989709e-02f, -8.31143484e-02f, -5.69063537e-02f, -6.85049407e-03f, 1.58454075e-01f, 5.74092567e-02f, 6.91528711e-03f, 3.37131321e-02f,
  1.04859084e-01f, -1.59539402e-01f, -1.18512936e-01f, 1.99982762e-01f, 2.14280665e-01f, 6.00924455e-02f, 3.33205871e-02f, 8.03872421e-02f, 6.01671524e-02f, -3.92187029e-01f,
  -6.79007620e-02f, -2.93563694e-01f, -2.45444641e-01f, -7.07050264e-02f, 1.86305419e-01f, 7.80586600e-02f, 1.87236369e-01f, 1.22990087e-02f, 1.61588669e-01f, 6.37147203e-02f,
  1.84756830e-01f, 1.19122125e-01f, 7.08110705e-02f, 7.34946225e-03f, 1.45443231e-02f, -1.02031872e-01f, -1.92259699e-02f, -5.66399843e-02f, -3.06175910e-02f, 3.15565690e-02f,
  4.29150686e-02f, -4.25717980e-02f, -7.09240064e-02f, -1.12192839e-01f, -2.80743130e-02f, -1.04888342e-01f, 8.22281837e-03f, -7.41005912e-02f, 4.66000959e-02f, -5.50772436e-02f,
  3.56011689e-02f, 4.76027392e-02f, 7.73077980e-02f, -8.39464366e-02f, 5.65475691e-03f, -9.49343666e-02f, 8.85875837e-04f, 8.30759779e-02f, -3.59247997e-02f, 4.20612730e-02f,
  -5.83338328e-02f, 6.09760219e-03f, 2.80424301e-02f, 2.04381533e-02f, 6.27952488e-03f, 1.09696485e-01f, -1.28529564e-01f, -6.08789660e-02f, 5.00469767e-02f, 2.59616524e-02f,
  6.97678775e-02f, 1.79915633e-02f, -8.03897902e-02f, 4.66676243e-03f, -8.36581513e-02f, 5.09457588e-02f, 4.51849625e-02f, 7.53724948e-02f, 4.97659557e-02f, 6.14548549e-02f,
  5.84933758e-02f, 4.54219393e-02f, 1.73197463e-01f, 6.33690357e-02f, -6.41929433e-02f, 4.60726023e-02f, -2.90240534e-02f, 1.26232758e-01f, 6.05304390e-02f, 3.55799571e-02f,
  2.86690798e-02f, -9.72924232e-02f, -5.50766289e-02f, 3.60986143e-02f, -9.50550102e-03f, 3.87252904e-02f, -7.95656219e-02f, 6.73639402e-02f, 1.16438106e-01f, -6.00773729e-02f,
  -4.47479077e-02f, -2.44574144e-01f, -3.33706918e-03f, 7.23263323e-02f, -1.09957330e-01f, -8.65133554e-02f, -6.28600195e-02f, 9.50918123e-02f, -3.71981673e-02f, -4.54090871e-02f,
  -3.09733450e-02f, -3.09394524e-02f, -4.42353114e-02f, 6.94815814e-02f, -6.81779757e-02f, -6.98183030e-02f, -1.94250736e-02f, -9.22833662e-03f, -8.11438337e-02f, 1.18100777e-01f,
  -1.46217003e-01f, 5.53920539e-03f, 6.20133094e-02f, -7.15788603e-02f, 1.40336705e-02f, -5.44539932e-03f, -6.94440231e-02f, -5.82952192e-03f, 5.28754815e-02f, -1.64112195e-01f,
  -8.48086923e-02f, 6.85894638e-02f, 1.62015378e-01f, 2.18283355e-01f, -1.48046404e-01f, -3.85233283e-01f, -3.61896932e-01f, 1.22139618e-01f, -1.80260595e-02f, -2.83462256e-02f,
  -8.03314745e-02f, 1.39770821e-01f, -2.47085705e-01f, 7.09036514e-02f, -4.25327212e-01f, -2.67936319e-01f, 5.25882728e-02f, 4.79878820e-02f, 8.06150585e-02f, 5.47512323e-02f,
  6.79063844e-03f, -4.36603874e-02f, -2.90520694e-02f, -1.19524691e-02f, 1.19794883e-01f, 2.80745119e-01f, 9.85899717e-02f, -6.15745559e-02f, 2.77161062e-01f, -1.08801946e-01f,
  -1.49912134e-01f, -1.19589247e-01f, 2.87115034e-02f, 1.53755890e-02f, 1.73827894e-02f, -3.33643407e-02f, 2.50347406e-02f, -4.56313305e-02f, 2.67144688e-03f, 2.75252648e-02f,
  -4.32153344e-02f, -2.82471702e-02f, 6.87239766e-02f, -8.22708160e-02f, -1.22974232e-01f, 2.66839080e-02f, 6.81668520e-02f, 7.27451146e-02f, 4.42968719e-02f, -5.01605216e-04f,
  6.36291057e-02f, -4.93812235e-03f, 3.23610157e-02f, -1.04136601e-01f, 9.04912874e-02f, -1.38114253e-02f, -7.51453340e-02f, -1.40207121e-02f, 4.06498788e-03f, 6.44286200e-02f,
  -3.60860787e-02f, 5.96133200e-03f, 5.87654114e-02f, 9.26207229e-02f, -7.29861036e-02f, 1.93309970e-02f, -2.14719195e-02f, -3.26015390e-02f, 4.36117053e-02f, -5.39668417e-03f,
  4.09334674e-02f, 1.63623150e-02f, 2.85129678e-02f, -1.84489302e-02f, 4.42208834e-02f, -1.48447640e-02f, -1.79574341e-02f, 1.03285545e-02f, 5.11011994e-03f, 8.13351721e-02f,
  3.22571807e-02f, -6.82295263e-02f, 8.20303857e-02f, 8.15157965e-02f, -6.32064650e-03f, -8.33808109e-02f, 6.34736046e-02f, 4.39843163e-02f, 1.14244940e-02f, -4.05312069e-02f,
  -6.87857196e-02f, 4.96094674e-02f, -3.06686689e-03f, -1.07806608e-01f, 4.83444557e-02f, -3.27119306e-02f, -1.00470185e-01f, 2.64612567e-02f, 5.72550483e-02f, -9.26626287e-03f,
  -2.26561933e-05f, 1.98387299e-02f, -3.07996161e-02f, -2.60616299e-02f, -3.84565592e-02f, -6.16835840e-02f, 1.00327596e-01f, 1.03744164e-01f, 8.21745768e-02f, 3.98437493e-02f,
  5.05146161e-02f, -4.69463021e-02f, -3.10444627e-02f, 5.41794933e-02f, -1.35643780e-02f, 6.47162274e-02f, 5.11084050e-02f, -5.56139722e-02f, -4.06991020e-02f, 3.16950283e-03f,
  -2.68097930e-02f, -1.47876337e-01f, 3.88090126e-02f, -1.45073041e-01f, 2.92563111e-01f, -3.41865957e-01f, -1.39588341e-01f, 1.76828019e-02f, 2.43205294e-01f, -1.66517049e-01f,
  -9.30691585e-02f, 1.00735659e-02f, -1.17268272e-01f, -1.57616004e-01f, -2.87356406e-01f, -2.12988496e-01f, -2.03147262e-01f, -1.89023972e-01f, 2.59150982e-01f, -2.18098983e-02f,
  -8.75324756e-03f, -1.37673616e-01f, -2.78260052e-01f, 3.99128571e-02f, -9.97162238e-02f, 1.59929365e-01f, -2.06027076e-01f, 1.95062727e-01f, -1.55580372e-01f, 8.08070973e-02f,
  -8.14412311e-02f, 3.56652564e-03f, 1.55934738e-02f, -3.23554166e-02f, -1.10454038e-01f, -1.60785373e-02f, 2.49893144e-02f, 8.84497315e-02f, 4.66449037e-02f, 8.23225155e-02f,
  -1.77097991e-02f, 2.44344417e-02f, 6.11112341e-02f, 5.85170910e-02f, -2.39455495e-02f, 3.81176509e-02f, 2.38430756e-03f, -6.14977591e-02f, 5.57104545e-03f, -8.40878696e-04f,
  4.52683270e-02f, -9.47859287e-02f, -1.51285365e-01f, -4.47314493e-02f, -8.57216306e-03f, -2.62181088e-02f, -3.56379412e-02f, 4.25218865e-02f, -8.84697363e-02f, -1.27882119e-02f,
  9.21905562e-02f, 3.38804885e-03f, -1.45679703e-02f, -3.88795435e-02f, -3.58056165e-02f, 4.44347821e-02f, -2.27458607e-02f, 2.72018518e-02f, 3.49669158e-02f, -9.30906534e-02f,
  -1.00402851e-02f, -7.54549280e-02f, 2.69242916e-02f, -6.09929413e-02f, 4.53562941e-03f, -2.39284318e-02f, -3.87420282e-02f, -2.67319009e-02f, 3.81334834e-02f, 3.30458395e-02f,
  7.74407806e-03f, 2.03170031e-02f, 5.90798957e-03f, -1.11851923e-03f, -5.18741719e-02f, 8.33912045e-02f, -5.53193793e-04f, 5.12864552e-02f, -7.39794374e-02f, -6.36885390e-02f,
  -3.48260224e-01f, -2.09015220e-01f, -5.49163222e-02f, -7.87321255e-02f, -1.92503873e-02f, 2.55398988e-03f, 8.35937262e-02f, 3.63791883e-02f, -1.08965904e-01f, -3.87512930e-02f,
  -3.05875279e-02f, -6.23555249e-03f, -2.28461064e-02f, -5.07334294e-03f, -1.60021186e-01f, -1.27010467e-02f, -5.05682193e-02f, -5.93718402e-02f, -1.21781893e-01f, 2.76114214e-02f,
  -1.09676547e-01f, 9.36859753e-03f, 1.78311002e-02f, -1.02150232e-01f, -1.49960935e-01f, -1.45297823e-02f, -2.85503566e-02f, 7.84894973e-02f, 5.03686257e-02f, -4.06142250e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.87943184e-02f, -1.89291820e-01f, 1.11105435e-01f, -4.77602631e-02f, -8.00025240e-02f, -2.96772361e-01f, -1.83243621e-02f, -1.90486789e-01f, -2.20291048e-01f, -1.84355214e-01f,
  1.08202286e-01f, 1.39980808e-01f, 2.25269735e-01f, -1.94733769e-01f, 5.09393871e-01f, 1.70094863e-01f, -2.49247715e-01f, -1.23701328e-02f, 8.09499994e-02f, -1.21749312e-01f,
  8.46789628e-02f, -9.69267711e-02f, 3.87104541e-01f, -1.60909534e-01f, -2.25138739e-01f, -4.91180867e-02f, 2.80448705e-01f, 1.18106700e-01f, -1.12428062e-01f, 1.13249257e-01f,
  -1.10637844e-01f, -7.91139752e-02f, -5.69466762e-02f, -3.23204733e-02f, -4.58619483e-02f, -1.46235460e-02f, 1.31898969e-01f, 1.55295134e-01f, 1.64002106e-01f, 7.93624744e-02f,
  -1.42809963e-02f, -1.66564565e-02f, -1.54531509e-01f, -1.98279675e-02f, -9.96406972e-02f, -4.54919487e-02f, -1.01342704e-02f, -2.32293848e-02f, 1.30233273e-01f, 1.46632819e-02f,
  9.43915918e-03f, -3.88364792e-02f, 1.61670242e-02f, 5.29202521e-02f, -1.28153814e-02f, -1.14184208e-01f, -4.79848720e-02f, -7.57897645e-02f, -4.49658707e-02f, -3.19596045e-02f,
  -6.50528073e-02f, 1.28852995e-02f, 6.54553296e-03f, -5.98041117e-02f, -4.75630276e-02f, 5.66824935e-02f, 5.07886196e-03f, 3.47060673e-02f, 4.06477638e-02f, 9.27915946e-02f,
  -7.79457241e-02f, -7.40527734e-02f, -6.57285079e-02f, 2.62273513e-02f, 6.98785782e-02f, 2.98367534e-02f, 2.10384652e-01f, 5.98629899e-02f, 3.84891853e-02f, 1.57516878e-02f,
  4.32639234e-02f, -7.82533512e-02f, -1.60856992e-02f, -4.32625301e-02f, 4.69757104e-03f, 4.63054813e-02f, 1.64506398e-02f, 8.15809071e-02f, 7.38684312e-02f, 1.11537412e-01f,
  6.01576865e-02f, 3.47207598e-02f, -4.16678488e-02f, 4.41095419e-02f, 1.00740343e-01f, -8.19322467e-02f, -3.62950303e-02f, -1.41600370e-02f, 7.94778988e-02f, -5.33911921e-02f,
  -5.04289404e-04f, 4.65092026e-02f, 5.55266030e-02f, -5.03025725e-02f, 3.41386124e-02f, 3.67506668e-02f, 1.24475956e-01f, 1.16351113e-01f, 4.32123728e-02f, -1.79747924e-01f,
  -1.25147263e-02f, 4.00561318e-02f, 9.64922532e-02f, -1.40291065e-01f, -2.67156046e-02f, 1.34133935e-01f, -1.36989087e-01f, 1.97389983e-02f, -9.93076246e-03f, 3.21274363e-02f,
  -5.04296087e-02f, 2.16483444e-01f, 1.29320323e-01f, 1.74441084e-01f, 2.74686009e-01f, 1.22854799e-01f, 1.59572765e-01f, 3.48115236e-01f, 4.85025585e-01f, -3.01693175e-02f,
  -8.15869197e-02f, 1.12102870e-02f, -4.20772620e-02f, -3.13323848e-02f, -7.26657733e-02f, -4.67752628e-02f, 2.65412748e-01f, -2.02772375e-02f, 1.81624949e-01f, -9.51796249e-02f,
  8.05227682e-02f, -1.44015864e-01f, -1.08791232e-01f, -1.54074684e-01f, -1.82603925e-01f, 4.79005054e-02f, -1.50963396e-01f, -1.58491789e-03f, -2.46114239e-01f, 1.46384835e-01f,
  6.98744133e-02f, 2.90202588e-01f, -1.31589428e-01f, 8.29552710e-02f, -1.56616852e-01f, -5.32173254e-02f, -4.76001687e-02f, -3.65910418e-02f, 6.70969933e-02f, 4.79461364e-02f,
  -4.36928459e-02f, -1.30114332e-01f, -1.22836269e-02f, -5.51289693e-02f, 8.17586258e-02f, 1.41806128e-02f, -1.08410582e-01f, 8.28189179e-02f, -2.31790170e-02f, 3.49743441e-02f,
  4.78901248e-03f, -4.91154529e-02f, 6.66994601e-02f, 1.79674085e-02f, -8.35419539e-03f, 1.27179176e-01f, 1.00732632e-01f, 3.52118835e-02f, -1.63712110e-02f, 1.54583395e-01f,
  -1.15643606e-01f, 5.33033796e-02f, 4.15252382e-03f, -7.53663853e-02f, -3.84733677e-02f, -8.24776217e-02f, -3.74617130e-02f, -2.26793643e-02f, 3.96777578e-02f, -7.07517415e-02f,
  5.54270968e-02f, 4.55666371e-02f, 2.45476849e-02f, -1.14138283e-01f, 5.93288578e-02f, 1.27548203e-01f, -5.82111925e-02f, -1.39788806e-01f, 1.01970777e-01f, 3.00979838e-02f,
  2.30486039e-02f, 4.41648923e-02f, -5.65899760e-02f, 1.59952939e-02f, -6.32582307e-02f, 3.51117663e-02f, -1.47447377e-01f, 3.09901237e-02f, 8.45021103e-04f, 3.07563841e-02f,
  1.20051436e-01f, 1.69454142e-01f, -9.73534584e-03f, -2.75637619e-02f, -6.98212683e-02f, -1.97311655e-01f, 3.51330079e-02f, -1.39088511e-01f, 1.50814757e-01f, -1.59496404e-02f,
  4.73890342e-02f, -2.26689279e-02f, 6.55836612e-02f, -2.18810011e-02f, 3.52471732e-02f, -7.19137341e-02f, -1.11688636e-02f, 2.45565251e-02f, 8.63158479e-02f, -4.98837139e-03f,
  -1.13234289e-01f, 6.81819245e-02f, -2.98642628e-02f, 8.74298140e-02f, -1.00529730e-01f, 7.87296146e-02f, 1.09381609e-01f, 1.24886967e-01f, -1.02270447e-01f, -9.36906859e-02f,
  -9.52654362e-01f, 5.46455681e-01f, -3.20843190e-01f, 1.10589303e-01f, -5.00833429e-02f, 2.40804598e-01f, 2.64071912e-01f, 5.77232763e-02f, 3.13993506e-02f, 3.96046698e-01f,
  1.35833323e-01f, -7.30329677e-02f, 1.83221340e-01f, 2.34853342e-01f, -1.71325147e-01f, 3.14260274e-01f, 2.04627559e-01f, 5.09450585e-02f, 1.37703687e-01f, -1.13731273e-01f,
  -7.75962248e-02f, 1.80503190e-01f, -8.54116753e-02f, 1.03180073e-01f, -2.08059192e-01f, -1.51493222e-01f, -1.71491224e-02f, -6.76335171e-02f, 1.19241633e-01f, 7.35820457e-02f,
  -2.17614844e-01f, -4.17859495e-01f, -1.83244050e-01f, -2.40819469e-01f, -1.58322498e-01f, -5.36704324e-02f, -1.40096381e-01f, -5.95535189e-02f, -1.78154573e-01f, 4.58734483e-02f,
  -1.18024446e-01f, -4.83872509e-03f, 5.23917302e-02f, 9.17926133e-02f, 6.48497492e-02f, 6.81939162e-03f, 2.30391063e-02f, -4.60409820e-02f, -4.85171266e-02f, 1.08227804e-02f,
  -2.63178945e-02f, 1.85148567e-02f, -1.85518358e-02f, 1.24560550e-01f, -1.23496853e-01f, 2.47480646e-02f, 6.43748119e-02f, 1.65461916e-02f, -2.61193439e-02f, 2.72672391e-04f,
  -5.95755093e-02f, -1.31010506e-02f, 2.48023421e-02f, -4.17371355e-02f, 8.04864541e-02f, -7.59922108e-03f, 8.52833241e-02f, -1.58566274e-02f, 5.34390099e-02f, -6.22206228e-03f,
  5.96636795e-02f, -3.07915695e-02f, -7.97998458e-02f, -3.70731875e-02f, -1.27827689e-01f, -6.99886531e-02f, -1.01973139e-01f, -1.13050677e-02f, 1.92684960e-02f, -2.66119391e-02f,
  1.78687144e-02f, -1.28623322e-02f, 1.35110199e-01f, 2.35855822e-02f, -1.36731425e-02f, -1.67114253e-03f, 6.32166043e-02f, -7.61296675e-02f, 7.59113999e-03f, -7.20221177e-02f,
  -1.50859104e-02f, -1.48523211e-01f, -2.08513234e-02f, 1.03820413e-02f, -2.84740347e-02f, 6.68786913e-02f, 3.71760279e-02f, 4.60088328e-02f, 7.24498704e-02f, 1.63087361e-02f,
  -1.09431274e-01f, -3.37606594e-02f, -8.60668644e-02f, 7.96559229e-02f, -2.48016641e-02f, 3.43716964e-02f, 1.30706013e-03f, -3.36710885e-02f, 9.08288658e-02f, 6.89795334e-03f,
  -7.39677176e-02f, -2.73316763e-02f, 3.39891799e-02f, -9.03970748e-03f, -9.81319230e-03f, -4.00630087e-02f, -9.49676260e-02f, 3.02628241e-02f, 5.03315553e-02f, 7.36197233e-02f,
  -2.03511164e-01f, 1.84999436e-01f, 2.01030910e-01f, 2.79213101e-01f, -1.47640690e-01f, -4.61782277e-01f, -2.14095697e-01f, 1.14144742e-01f, -8.30984637e-02f, 7.14575201e-02f,
  -1.43031273e-02f, 1.96071282e-01f, -3.99803557e-02f, 3.07829548e-02f, -1.51866272e-01f, -2.17302486e-01f, -3.17507125e-02f, -5.98815307e-02f, -9.48087350e-02f, 1.94756970e-01f,
  1.45282522e-01f, -1.63614586e-01f, 1.15538493e-01f, -1.90286816e-03f, 1.42605618e-01f, 2.86467403e-01f, 1.38593525e-01f, 9.48394388e-02f, 3.25154990e-01f, -5.01143560e-02f,
  -1.08031712e-01f, 1.31748915e-01f, 4.50653397e-02f, -4.31889631e-02f, 2.45613120e-02f, -3.91975278e-04f, -3.32617876e-03f, -3.60441953e-02f, 9.45138186e-02f, -3.76152210e-02f,
  8.66680965e-02f, 4.53438051e-03f, 4.44284342e-02f, -1.18644563e-02f, -3.90366209e-03f, 6.06382601e-02f, 9.84666497e-02f, 5.32185752e-03f, 6.18107878e-02f, 3.51906084e-02f,
  1.62291005e-01f, 1.59860536e-01f, 3.14063532e-03f, 1.39598876e-01f, 5.13804257e-02f, -4.31007333e-02f, 1.18825048e-01f, 1.32549390e-01f, -1.54667562e-02f, 4.83746938e-02f,
  -2.25534532e-02f, 3.72271061e-05f, 5.32856919e-02f, -1.05374761e-01f, 5.41645885e-02f, -4.24423702e-02f, -2.64217965e-02f, 6.12682023e-04f, 5.73838167e-02f, -1.43968482e-02f,
  -2.81242151e-02f, 4.66458909e-02f, -6.48418963e-02f, -3.03048864e-02f, 1.07332498e-01f, 3.28973792e-02f, 6.86386377e-02f, 4.95127216e-02f, 7.97588825e-02f, 1.26200197e-02f,
  3.30233760e-02f, 2.07827482e-02f, 1.29539100e-02f, 3.25026247e-03f, -9.50506255e-02f, 5.91197237e-02f, -7.88335875e-02f, 6.59844130e-02f, 8.76981691e-02f, 2.09968220e-02f,
  1.17474943e-01f, 2.91557461e-01f, -3.61551121e-02f, -4.44166623e-02f, -6.91384897e-02f, 6.14279844e-02f, -6.15121163e-02f, -5.22395745e-02f, 2.38026172e-01f, -2.75249835e-02f,
  9.32192653e-02f, -3.70502919e-02f, 4.91223708e-02f, 5.50197288e-02f, -3.23775336e-02f, 1.28600165e-01f, 1.56915784e-01f, 5.66524155e-02f, 7.89417922e-02f, 7.27239400e-02f,
  8.01808462e-02f, -6.04756922e-02f, -2.51250379e-02f, -4.40973975e-02f, -2.88696624e-02f, 1.80152562e-02f, 4.96830232e-02f, 1.36860430e-01f, 6.42629117e-02f, 1.00229941e-02f,
  -5.33859074e-01f, -1.44809201e-01f, -2.52514750e-01f, -2.94445634e-01f, 9.96088907e-02f, -7.79832900e-02f, -1.26810402e-01f, -2.43261282e-04f, -5.65225631e-02f, 1.20674916e-01f,
  1.57699101e-02f, -2.23609045e-01f, 4.09170017e-02f, -3.07204038e-01f, -4.11978960e-01f, -2.06563696e-01f, -3.36421847e-01f, -1.98459655e-01f, -1.32304594e-01f, -6.48754537e-02f,
  -1.46618187e-01f, -1.40349671e-01f, -3.56792748e-01f, 1.78596273e-01f, -4.08636406e-02f, 1.51826560e-01f, 2.69980431e-01f, 1.63477719e-01f, 5.71222790e-02f, 1.35198720e-02f,
  -9.17001590e-02f, 5.55306524e-02f, -1.60255823e-02f, -1.25220388e-01f, 3.87957990e-02f, 3.70352790e-02f, 6.68089315e-02f, -8.18604007e-02f, -5.02536707e-02f, -1.06081285e-01f,
  3.00685875e-02f, -1.20900638e-01f, -8.68089497e-02f, -6.69758469e-02f, -1.21164247e-02f, -1.62261069e-01f, 2.90076938e-02f, 2.86060246e-03f, -1.64867625e-01f, -8.33776817e-02f,
  -5.87405562e-02f, -3.95060889e-02f, 1.18398294e-01f, 1.13397809e-02f, 1.20295286e-01f, 1.09420670e-02f, -1.04616787e-02f, -5.26607893e-02f, 9.71519351e-02f, 9.98495966e-02f,
  5.64025976e-02f, 2.76066437e-02f, -1.11208800e-02f, -8.82817507e-02f, -2.87900642e-02f, -8.55431855e-02f, -2.76615452e-02f, -2.04812381e-02f, 4.45481949e-02f, -6.82231933e-02f,
  5.26368320e-02f, -1.85334347e-02f, -1.17769048e-01f, 4.84001823e-02f, 1.00752257e-01f, -1.65175516e-02f, -7.52849802e-02f, 4.74663042e-02f, -6.67601973e-02f, -8.01277831e-02f,
  9.93377566e-02f, 3.85480449e-02f, 3.10846735e-02f, -1.48261562e-01f, -1.48588762e-01f, -5.89836016e-02f, 9.28065255e-02f, 1.60465650e-02f, -5.43294102e-02f, -2.19729785e-02f,
  1.12370960e-03f, 1.55718371e-01f, 2.14911029e-02f, -2.59020738e-02f, 9.86310914e-02f, 9.47224870e-02f, -8.47831517e-02f, -1.51418094e-02f, 5.32442192e-03f, 4.79436778e-02f,
  1.13321535e-01f, 7.93640390e-02f, -4.23043333e-02f, 1.35650514e-02f, 3.73033062e-02f, -3.70552344e-03f, 5.01215868e-02f, 7.65736252e-02f, 8.18332210e-02f, -4.42635827e-03f,
  1.66205671e-02f, 1.08177990e-01f, -3.15208696e-02f, 9.57532600e-03f, 1.40400864e-02f, 1.61974192e-01f, 1.32187590e-01f, -1.13516115e-01f, 3.74186151e-02f, 9.46349427e-02f,
  2.87321985e-01f, -1.13530584e-01f, -2.12372571e-01f, -3.30458939e-01f, -1.09125629e-01f, -4.55716312e-01f, -4.06360447e-01f, -2.62458235e-01f, -1.63419127e-01f, -2.00652614e-01f,
  -2.11659059e-01f, -1.77273706e-01f, 1.35058552e-01f, -2.88456947e-01f, 1.99885204e-01f, 2.48724431e-01f, -2.77985275e-01f, -1.14237145e-01f, 7.27937743e-02f, 4.64280844e-02f,
  1.36184558e-01f, -1.41342476e-01f, 1.46755800e-01f, 6.97508231e-02f, -1.68153808e-01f, -5.59236184e-02f, 1.95878863e-01f, -2.93597206e-02f, -3.18607390e-01f, -1.02321312e-01f,
  -6.49573952e-02f, 4.39338796e-02f, -1.11544587e-01f, 6.46032095e-02f, 2.52748709e-02f, 3.07816360e-02f, -5.81758134e-02f, 3.65055315e-02f, -5.57543859e-02f, 2.40648314e-02f,
  3.17069851e-02f, -4.26169001e-02f, -2.46335324e-02f, 7.65264556e-02f, 5.71513474e-02f, -9.48041379e-02f, -8.50403979e-02f, -4.09343243e-02f, -1.32790729e-01f, 9.90540981e-02f,
  -8.92320573e-02f, 8.69061649e-02f, -9.34337527e-02f, 5.44589721e-02f, 1.16745681e-02f, -8.36778607e-04f, 9.14277136e-02f, 1.11193575e-01f, -6.82815015e-02f, -5.94705064e-03f,
  4.20477539e-02f, 5.26074879e-02f, 3.65480632e-02f, -3.50078680e-02f, 2.59176884e-02f, -3.10205817e-02f, -1.05903395e-01f, 3.23647484e-02f, -8.07334017e-03f, -4.28580679e-02f,
  -8.62367004e-02f, -9.96067747e-02f, 2.17703544e-02f, 8.64973590e-02f, 1.89399868e-02f, 1.85714334e-01f, 3.38706747e-02f, -1.53768137e-02f, -1.15550324e-01f, -2.00198889e-01f,
  -6.63525052e-03f, 3.75982150e-02f, -2.95833200e-02f, 5.95264249e-02f, -6.73353523e-02f, -6.69868896e-03f, -5.63062802e-02f, 3.00432015e-02f, -1.65824965e-01f, 4.67164582e-03f,
  -1.13741651e-01f, 3.81888300e-02f, -1.49734467e-01f, -1.24805652e-01f, -2.06584148e-02f, -4.89685126e-02f, 2.51421556e-02f, -1.17513068e-01f, -3.93619388e-02f, 9.98514704e-03f,
  2.88461670e-02f, -6.80612177e-02f, 1.01304427e-01f, -9.86680947e-03f, -3.74351032e-02f, -8.69961083e-02f, 9.22867134e-02f, -1.05793931e-01f, -1.10554226e-01f, -1.82297919e-02f,
  5.63881767e-04f, 6.01904839e-02f, 5.16517125e-02f, -8.79867151e-02f, -4.58281152e-02f, -4.10782453e-03f, 3.73966619e-02f, 1.69277564e-01f, 1.13284118e-01f, -7.74959847e-02f,
  1.17243931e-01f, 4.33315396e-01f, 2.02101886e-01f, 1.06795855e-01f, -7.11889789e-02f, 1.68849692e-01f, 9.74607319e-02f, 2.45335158e-02f, 2.89528608e-01f, 2.83437163e-01f,
  -2.13241383e-01f, 3.78745049e-01f, -2.60515623e-02f, 5.26702143e-02f, 4.39483952e-03f, -6.93791956e-02f, 1.21341802e-01f, 1.24777198e-01f, 6.92088306e-02f, 1.33365452e-01f,
  1.30950902e-02f, -1.12621440e-02f, -2.69620419e-01f, -5.38713783e-02f, -1.61684513e-01f, -1.39883831e-02f, -3.36165965e-01f, -1.75078824e-01f, -1.31746158e-01f, -3.04568540e-02f,
  -7.00826198e-02f, -1.83599386e-02f, -4.51210362e-04f, 8.62076730e-02f, -1.20369652e-02f, 4.10360768e-02f, 4.08017002e-02f, -1.16007313e-01f, -4.64053303e-02f, 3.14104855e-02f,
  1.08933054e-01f, 5.52781783e-02f, 1.52017176e-01f, -1.23502230e-02f, 4.86747734e-02f, 1.58576085e-03f, 7.59980977e-02f, -1.18464477e-01f, 3.88323851e-02f, 3.52626550e-03f,
  3.97692099e-02f, -2.18347162e-02f, -2.73098722e-02f, 6.46162480e-02f, 5.39681129e-02f, 5.38165495e-02f, 2.50203311e-01f, 1.10956738e-02f, 3.55524756e-02f, 1.13649584e-01f,
  4.89474013e-02f, 2.24045347e-02f, -6.01339266e-02f, -1.69404507e-01f, 1.48205981e-02f, -1.51954457e-01f, -7.11745247e-02f, -4.14816998e-02f, 1.02412917e-01f, 8.64116400e-02f,
  4.02753279e-02f, 1.68575794e-02f, 2.11753920e-02f, 2.62010917e-02f, 9.51595977e-02f, 2.04124451e-02f, 3.21844444e-02f, 1.22676693e-01f, 6.33540526e-02f, -1.36244595e-01f,
  -6.93516284e-02f, 7.73036033e-02f, 1.66932959e-02f, -8.30263048e-02f, -5.71469031e-02f, 4.49070595e-02f, 6.62130630e-03f, 1.23444371e-01f, -1.15259722e-01f, 3.24820913e-02f,
  1.49188623e-01f, 4.46825057e-01f, 8.96389410e-02f, 4.75951657e-02f, 2.51714550e-02f, -3.02600916e-02f, 5.15964478e-02f, 1.17423244e-01f, 9.70393196e-02f, 2.78582443e-02f,
  5.23681194e-02f, 2.47223694e-02f, -3.40661500e-03f, -4.11933623e-02f, 9.65489224e-02f, -2.10640044e-03f, 4.50570509e-02f, 1.04925103e-01f, 5.10175973e-02f, 2.65265931e-03f,
  -1.16953403e-01f, 1.27741098e-02f, 4.81623858e-02f, 1.60775501e-02f, 1.23203345e-01f, -1.18497051e-01f, 3.58503424e-02f, 6.63543418e-02f, 5.23661897e-02f, 3.44890952e-02f,
  -8.86619464e-02f, -2.76447594e-01f, 1.25862315e-01f, -1.87452793e-01f, 2.75424451e-01f, 2.15342090e-01f, 2.03856960e-01f, -3.16156685e-01f, -3.98149312e-01f, -1.31733730e-01f,
  -6.36621416e-02f, 1.75951291e-02f, 2.38884598e-01f, -3.48697513e-01f, 3.26440811e-01f, 3.57835442e-02f, -1.52614757e-01f, -4.49194498e-02f, -1.20194487e-01f, -9.82569978e-02f,
  -1.03612944e-01f, -2.00282797e-01f, 1.95498064e-01f, -1.53801799e-01f, -1.68349788e-01f, -1.27391741e-01f, 2.04743832e-01f, 3.15662682e-01f, -1.45694524e-01f, 1.22847527e-01f,
  -1.16299950e-01f, -3.15429479e-01f, -1.66826591e-01f, 5.21854013e-02f, 8.34134892e-02f, 1.02232352e-01f, 1.78489275e-02f, 1.68375611e-01f, 2.70532258e-03f, 5.68275061e-03f,
  -1.99955776e-02f, 7.14843348e-02f, -1.39034688e-01f, 8.72326419e-02f, -1.64778098e-01f, -7.15534166e-02f, -2.92635672e-02f, -6.57500625e-02f, -4.40957732e-02f, -2.16135457e-02f,
  3.71492989e-02f, -1.31742433e-02f, -6.78682402e-02f, 7.58586526e-02f, 5.36112487e-02f, 2.44875234e-02f, 4.27014530e-02f, 2.60517627e-01f, -1.06478008e-02f, 4.41555530e-02f,
  6.59154281e-02f, -1.26200896e-02f, 1.18263386e-01f, 3.28855403e-02f, -3.84424999e-02f, -8.25948566e-02f, -1.04082122e-01f, -1.14151083e-01f, -4.10453491e-02f, -5.04831858e-02f,
  2.91512702e-02f, -3.93515900e-02f, -5.18936329e-02f, 1.48059223e-02f, -4.10110727e-02f, -1.63002498e-02f, 5.37992790e-02f, 7.28560910e-02f, -4.86931242e-02f, -1.82042256e-01f,
  -1.48717508e-01f, -2.94424184e-02f, 1.00048736e-01f, 1.17563687e-01f, 1.63052417e-02f, 1.18597776e-01f, -6.60166070e-02f, 1.48644410e-02f, -9.36959013e-02f, 1.55223131e-01f,
  1.71893407e-02f, -8.26071650e-02f, -1.46085933e-01f, -4.92085218e-02f, -1.47893210e-03f, -7.55276829e-02f, -1.25383392e-01f, -4.38322499e-02f, -1.00143388e-01f, -1.20080002e-01f,
  9.47298408e-02f, 4.53090388e-03f, -4.10819203e-02f, 1.59839522e-02f, 8.72904658e-02f, -3.11189592e-02f, 7.50726089e-02f, -5.79496101e-02f, -2.07973886e-02f, -8.30205306e-02f,
  4.97077033e-03f, 1.36123478e-01f, 1.44775659e-01f, 4.94584702e-02f, -3.13824043e-02f, 1.77552685e-01f, 2.84015052e-02f, 8.03594738e-02f, -1.08586280e-02f, -3.20731476e-02f,
  1.42687008e-01f, -3.70332509e-01f, -5.86513400e-01f, -9.51643102e-03f, 4.24807757e-01f, 3.46199065e-01f, -1.27588093e-01f, 6.77881762e-02f, -2.88724065e-01f, 7.50959441e-02f,
  1.53412476e-01f, -2.70602643e-01f, -4.03623790e-01f, 2.04610378e-01f, 2.55346000e-01f, -5.46717942e-01f, 2.01239571e-01f, 4.88065034e-02f, -1.34407774e-01f, 1.39775246e-01f,
  8.53190497e-02f, 5.65895379e-01f, -2.35973939e-01f, 3.36155266e-01f, 2.02779889e-01f, 1.61109064e-02f, 3.62617671e-01f, -9.61687267e-02f, 4.14830744e-01f, 1.14117198e-01f,
  -2.08318681e-02f, -1.50020748e-01f, 3.38434465e-02f, -6.88948482e-02f, 4.65258472e-02f, 1.52460933e-01f, 7.23515404e-03f, -9.51638520e-02f, -2.73537170e-02f, -1.28599226e-01f,
  -6.67572841e-02f, 3.59674171e-02f, 3.50871719e-02f, 8.70914385e-03f, 1.52649105e-01f, 6.29081065e-03f, -1.02043800e-01f, -2.91629396e-02f, -4.23603207e-02f, -2.53004152e-02f,
  -6.53596148e-02f, 2.64368881e-03f, -1.28076360e-01f, -2.33600009e-02f, -1.22690499e-01f, -1.29842401e-01f, -4.33892570e-02f, -1.61440708e-02f, -1.39298094e-02f, 8.92914757e-02f,
  1.31066084e-01f, -9.22449902e-02f, -9.17630121e-02f, -4.23233919e-02f, -4.89246063e-02f, -1.36817908e-02f, -3.32288146e-02f, 9.41208471e-03f, -7.90869668e-02f, -7.46326055e-03f,
  3.00379824e-02f, -2.20038537e-02f, -9.92162619e-03f, 4.57535386e-02f, -4.97527793e-02f, 4.20895219e-02f, -4.93252352e-02f, 9.05305296e-02f, 1.95153654e-02f, 2.56728921e-02f,
  -9.33922529e-02f, 2.97727599e-03f, 2.55709570e-02f, 1.39179891e-02f, 4.24069632e-03f, -1.58127286e-02f, -4.48837094e-02f, -2.99065467e-02f, -7.42737129e-02f, -1.71976332e-02f,
  2.77506299e-02f, -1.57807972e-02f, -7.41222054e-02f, 9.70735773e-02f, -8.20463672e-02f, 1.06043309e-01f, -4.47386727e-02f, -4.18414846e-02f, -1.10585846e-01f, -1.40320649e-02f,
  1.78867579e-01f, 6.02957606e-03f, -3.68844979e-02f, 4.08510901e-02f, -7.54140504e-03f, -2.98411548e-02f, -6.19449541e-02f, 3.53515707e-02f, 1.12662300e-01f, 3.88179198e-02f,
  1.02781676e-01f, 3.99988666e-02f, -3.57106589e-02f, 1.89049151e-02f, 5.95931299e-02f, 5.43361008e-02f, 1.35902271e-01f, -2.45724041e-02f, 6.77144453e-02f, -1.04801491e-01f,
  -4.33025986e-01f, -2.38050129e-02f, -3.22241038e-02f, -2.91537851e-01f, 7.27119669e-02f, -4.08780783e-01f, -3.61845106e-01f, 1.58871576e-01f, 3.35747525e-02f, -4.22481298e-02f,
  2.38887053e-02f, 2.12916657e-02f, 2.28115976e-01f, -2.79323608e-01f, -1.80534258e-01f, 8.33633617e-02f, -5.54361701e-01f, -2.00269669e-01f, 1.89761426e-02f, -3.00739240e-02f,
  -5.74267581e-02f, -4.48707342e-02f, 2.79286858e-02f, 2.24244684e-01f, -6.62483871e-02f, -1.09439977e-01f, 2.29830772e-01f, 8.64401832e-02f, -1.74197666e-02f, -5.44539792e-03f,
  -5.06315865e-02f, 1.88594282e-01f, -1.54737430e-03f, 6.27190173e-02f, 6.30968660e-02f, -1.02732770e-01f, -1.08849756e-01f, 1.21609764e-02f, -4.86498065e-02f, -2.68186405e-02f,
  4.16681059e-02f, -4.50581238e-02f, -6.85628178e-03f, 8.52505192e-02f, -4.72110137e-02f, -2.24056300e-02f, 9.58761349e-02f, -1.52355552e-01f, -8.60388670e-03f, -3.10659092e-02f,
  1.52968466e-02f, 4.12237346e-02f, -1.88269675e-01f, 2.17590332e-02f, -6.96956962e-02f, -2.14965809e-02f, -1.61768168e-01f, 2.07651537e-02f, 3.84627678e-03f, -9.35429558e-02f,
  -3.28259505e-02f, -1.16522357e-01f, -8.59985799e-02f, 5.51950149e-02f, -1.43063843e-01f, 1.33448755e-02f, 6.13741111e-04f, 3.52753624e-02f, -7.81575665e-02f, 5.34134544e-02f,
  4.24676947e-02f, 3.83304283e-02f, 4.24990952e-02f, -2.01062873e-01f, -1.43180370e-01f, 7.16253072e-02f, 5.22942329e-03f, 1.17437065e-01f, -1.30087763e-01f, -9.39661264e-03f,
  1.20548889e-01f, -4.16615009e-02f, -5.47354333e-02f, -2.19056942e-02f, 1.05209440e-01f, -7.97115862e-02f, 8.64882395e-02f, -1.41900972e-01f, 6.65976852e-02f, -1.34224281e-01f,
  8.20557773e-02f, 8.59653354e-02f, 1.82595924e-02f, 5.54774962e-02f, -1.89133734e-02f, -4.48263437e-02f, -8.43011960e-02f, -9.57415402e-02f, -4.47718166e-02f, -7.76738599e-02f,
  -1.62446015e-02f, -6.80055395e-02f, 3.93280536e-02f, 3.43122333e-02f, -1.70108695e-02f, -1.29525792e-02f, 9.72130969e-02f, 3.76586132e-02f, -7.83455838e-03f, 1.09953068e-01f,
  2.60402057e-02f, 4.14478183e-02f, -1.25598639e-01f, -2.78488342e-02f, -9.83232707e-02f, 1.90202203e-02f, -1.22869732e-02f, 2.10718848e-02f, -1.03312954e-01f, 1.79577991e-03f,
  1.72904581e-01f, -7.37241656e-02f, -9.20222253e-02f, 1.78468019e-01f, 1.37739301e-01f, -1.37959287e-01f, -9.33339670e-02f, -4.17909883e-02f, -1.55730888e-01f, 4.35972027e-03f,
  1.63593203e-01f, 1.26496956e-01f, -2.52547801e-01f, 4.30514187e-01f, 5.98331034e-01f, -7.44337216e-02f, 3.13847095e-01f, 9.00480598e-02f, -4.77436259e-02f, 1.53120548e-01f,
  1.06926121e-01f, 3.89438242e-01f, 1.55166924e-01f, 3.69691402e-01f, 3.54250371e-01f, -1.20152961e-02f, 3.48733664e-01f, 9.59074870e-02f, 4.02981699e-01f, 3.92514378e-01f,
  -6.43337071e-02f, 7.28581799e-03f, -9.07800645e-02f, -3.79486419e-02f, -2.87754787e-03f, -1.54851824e-01f, -1.28241464e-01f, 9.50914398e-02f, 1.53376833e-02f, -2.02319808e-02f,
  -3.19566503e-02f, 2.80044544e-02f, 1.75837222e-02f, -5.59242591e-02f, -5.40046720e-04f, 4.86861467e-02f, -1.23411343e-01f, -9.84379500e-02f, -8.27167407e-02f, 1.12282328e-01f,
  -1.79173708e-01f, -1.34400681e-01f, -1.01103280e-02f, 2.35909503e-02f, -1.30353840e-02f, -2.12074723e-02f, -3.76007780e-02f, -4.16497551e-02f, -3.50054763e-02f, 1.27589656e-02f,
  8.18051919e-02f, -1.49817392e-02f, 4.05203849e-02f, 3.52514498e-02f, 5.11078946e-02f, -1.08919879e-02f, 7.74254203e-02f, -3.55934389e-02f, 1.99946798e-02f, 5.09155802e-02f,
  -1.72692500e-02f, 2.17093737e-03f, -2.69712880e-02f, -6.22038804e-02f, -1.69541482e-02f, -8.38154480e-02f, -5.04197627e-02f, 7.46727958e-02f, -1.70965686e-01f, -6.37642965e-02f,
  -6.94307908e-02f, 7.32433796e-02f, -6.10048585e-02f, -1.01007037e-01f, -9.42054018e-02f, 1.18098512e-01f, 1.49525583e-01f, -2.84977555e-02f, 1.00953370e-01f, -5.77004720e-03f,
  1.29182875e-01f, 2.87447661e-01f, -8.38391036e-02f, -2.00560670e-02f, 6.53721765e-03f, 5.23314625e-02f, -1.24282697e-02f, 9.23053026e-02f, 1.64472282e-01f, 1.17729921e-02f,
  3.44594084e-02f, -1.91650838e-02f, -4.87360917e-03f, 5.65229170e-02f, 4.16659601e-02f, 1.20517239e-01f, 9.45838019e-02f, -1.96175799e-02f, -3.33784781e-02f, 1.00929074e-01f,
  -8.09791833e-02f, -2.35242248e-02f, -1.33536980e-02f, -3.43624614e-02f, 1.77340731e-02f, -1.60468414e-01f, 1.38615984e-02f, -2.71648113e-02f, 1.60421446e-01f, -2.97521185e-02f,
  -7.90106237e-01f, -5.02023101e-02f, -2.66379155e-02f, -5.62588573e-01f, 1.75321519e-01f, 1.77135423e-01f, -1.80259764e-01f, 5.29456772e-02f, -3.03354681e-01f, 6.20508976e-02f,
  -1.90615132e-01f, -2.21333817e-01f, 4.69791004e-03f, -2.60812819e-01f, -5.23786321e-02f, -1.24679886e-01f, 6.35940731e-02f, -1.37326434e-01f, 3.71107236e-02f, -2.47488674e-02f,
  -5.09241447e-02f, -4.29608067e-03f, 1.20517544e-01f, 4.71465111e-01f, -4.27824520e-02f, 1.13637842e-01f, 8.43613744e-02f, 1.80708468e-01f, 9.79821831e-02f, 1.67579219e-01f,
  -8.46632570e-03f, -3.21708083e-01f, -6.39144555e-02f, 6.84525864e-03f, 1.37234405e-01f, -2.79635042e-02f, -2.50820373e-03f, 6.05073851e-03f, -7.99969956e-02f, 5.93372658e-02f,
  -5.68098910e-02f, 2.16990430e-02f, -4.73321974e-02f, 8.93969554e-03f, 1.81737430e-02f, 5.44883348e-02f, 1.39274290e-02f, 2.92431284e-02f, 1.08328043e-02f, 3.15980799e-02f,
  -3.51841711e-02f, 3.99347208e-02f, -4.26118486e-02f, -4.82550897e-02f, 1.91518087e-02f, -2.22003572e-02f, 6.16153404e-02f, 7.60517418e-02f, 7.24327788e-02f, -5.32327613e-05f,
  -6.19205693e-03f, 1.44327357e-01f, -6.35469854e-02f, 4.57443893e-02f, -6.25056252e-02f, 2.91925296e-02f, 9.93159506e-03f, 5.83772585e-02f, 2.74676476e-02f, -1.08597405e-01f,
  -8.51807222e-02f, -1.07849941e-01f, -8.53066146e-02f, 3.46013382e-02f, -5.90113811e-02f, -1.13445148e-01f, -4.42070514e-02f, -8.53272621e-03f, -8.78726989e-02f, -3.16522969e-03f,
  -3.04408232e-03f, -4.50597033e-02f, -3.79994735e-02f, 1.47709623e-02f, -1.92406047e-02f, 7.33867362e-02f, 9.44685414e-02f, 1.59759056e-02f, -1.14157889e-02f, -1.60884634e-02f,
  -6.03865497e-02f, -8.14163536e-02f, -5.76319695e-02f, 2.46063024e-02f, -2.16872171e-02f, 4.17145930e-04f, -2.96279825e-02f, 8.78132731e-02f, -6.10711575e-02f, 5.26479855e-02f,
  1.13703609e-01f, 1.34066850e-01f, 1.07181512e-01f, -3.33218370e-03f, 6.48886412e-02f, -2.04605181e-02f, -7.26635158e-02f, -3.06608807e-02f, 1.36518613e-01f, 8.46216157e-02f,
  5.43846525e-02f, 4.44661081e-03f, 5.21993116e-02f, -4.35087979e-02f, 6.74363524e-02f, 1.74226370e-02f, -4.17472906e-02f, 1.09827101e-01f, 3.31713036e-02f, 5.81988692e-02f,
  1.00059509e-02f, -2.33527526e-01f, 8.57341439e-02f, -1.71865046e-01f, 1.17062993e-01f, 6.28653467e-02f, 8.77892599e-02f, -1.32382751e-01f, -8.73169526e-02f, -1.29719436e-01f,
  -8.56447816e-02f, 8.04841816e-02f, 1.91626951e-01f, -2.64337301e-01f, 4.57741350e-01f, 1.97416723e-01f, -2.66563356e-01f, -5.16493283e-02f, -1.27589749e-02f, -3.05432945e-01f,
  -4.61980281e-03f, -4.52364057e-01f, 1.20346300e-01f, -2.58166075e-01f, -2.74518311e-01f, -1.33849174e-01f, 1.39729857e-01f, 1.42141581e-01f, -2.48132840e-01f, 1.32823110e-01f,
  -2.64093727e-01f, -4.00716126e-01f, -1.47451565e-01f, 3.75531688e-02f, -1.11446518e-03f, 8.71065408e-02f, 9.14186835e-02f, 1.18193850e-01f, -4.19927202e-03f, 3.68644595e-02f,
  1.04470728e-02f, -1.18919909e-01f, -6.00194186e-02f, 4.39197905e-02f, 2.02139299e-02f, -3.15545127e-02f, -6.15097769e-02f, -5.13734706e-02f, 1.59271974e-02f, 8.64133388e-02f,
  3.99979241e-02f, -2.72673145e-02f, -1.48452967e-01f, -5.05272821e-02f, 2.28804648e-02f, -9.62389261e-02f, 3.60617787e-02f, 2.23820731e-02f, -4.05156985e-02f, -3.29289474e-02f,
  1.18391946e-01f, 3.55005115e-02f, 5.22045456e-02f, 6.20793588e-02f, 4.56689129e-04f, -1.74355507e-02f, 6.26344457e-02f, 9.04169008e-02f, 7.55933449e-02f, -2.09328495e-02f,
  -9.84006152e-02f, 7.59877916e-03f, -5.26317880e-02f, -2.15263944e-02f, -3.82814631e-02f, -1.06962882e-01f, 4.23591547e-02f, -5.70310317e-02f, -4.66503687e-02f, -3.65494825e-02f,
  -1.77490246e-02f, -3.52942199e-02f, -5.15335202e-02f, -4.38372418e-02f, -3.52372006e-02f, -2.52503064e-02f, -5.19267321e-02f, -1.01738498e-01f, -6.09499551e-02f, 1.80548102e-01f,
  -1.38820410e-01f, -2.42559597e-01f, -4.48264088e-03f, -8.04754347e-02f, 3.10184192e-02f, -5.29722646e-02f, -5.83799649e-03f, -6.11275323e-02f, -6.54586107e-02f, -5.40975928e-02f,
  1.09020295e-03f, -8.15812796e-02f, -9.23718140e-03f, -6.81279078e-02f, 3.02013848e-02f, -9.90715921e-02f, -1.34481601e-02f, 1.60395708e-02f, -6.68170601e-02f, -2.32177004e-02f,
  -5.97203188e-02f, 1.46520939e-02f, -3.87246907e-02f, -9.47229117e-02f, 4.58935797e-02f, -3.19823474e-02f, -2.41257604e-02f, -6.98271394e-03f, 1.96782853e-02f, 2.10014060e-02f,
  -1.41051382e-01f, 3.35632890e-01f, -2.77688891e-01f, 1.37725040e-01f, -1.88934654e-01f, 3.98415416e-01f, 4.43875313e-01f, -8.11427534e-02f, -3.65294367e-02f, 4.60762739e-01f,
  2.85362393e-01f, -7.32880011e-02f, 2.03962609e-01f, 4.04900700e-01f, 6.84928324e-04f, 2.32452795e-01f, 2.75548160e-01f, 2.49939427e-01f, -1.21223181e-01f, 9.45358500e-02f,
  -1.08548522e-01f, 3.92426729e-01f, -1.56757273e-02f, -1.48900161e-02f, 1.98259100e-01f, -2.07273200e-01f, 1.24104125e-02f, -1.08481675e-01f, 9.41322669e-02f, 5.52948611e-03f,
  1.73381433e-01f, 1.82291627e-01f, -1.07312970e-01f, -1.42061235e-02f, 7.90240802e-03f, -2.78092045e-02f, 5.13541624e-02f, -4.75489162e-02f, -5.75004593e-02f, 1.83159281e-02f,
  5.96834198e-02f, -4.57942784e-02f, 5.87170310e-02f, -6.72611967e-02f, -1.22990556e-01f, -1.16928235e-01f, 3.69463558e-03f, -5.14158159e-02f, -2.35024467e-02f, 8.48641992e-02f,
  -6.17619939e-02f, 1.89302471e-02f, -4.52228673e-02f, 6.23842143e-02f, -1.04051307e-01f, 1.61649403e-03f, 7.20250160e-02f, -3.05373464e-02f, 6.96790358e-03f, 1.19364355e-03f,
  6.86686933e-02f, -1.46681918e-02f, 7.64570311e-02f, 6.89457431e-02f, -3.90003473e-02f, -1.49408495e-02f, 8.03949758e-02f, -3.20085417e-03f, -9.68590751e-02f, 3.40553783e-02f,
  -4.84632291e-02f, -6.19837604e-02f, 1.01323843e-01f, 1.01850301e-01f, 5.74851632e-02f, 1.11560233e-01f, 9.95755270e-02f, 3.18327919e-02f, -4.12618602e-03f, -6.02174774e-02f,
  3.14105600e-02f, -9.41339433e-02f, -6.09384738e-02f, -1.84943865e-03f, 5.28189912e-03f, -4.28139605e-02f, 2.15292256e-03f, -6.51933923e-02f, -4.71631661e-02f, 2.97048260e-02f,
  3.09593733e-02f, 1.79267421e-01f, -2.05258280e-02f, -1.82889798e-03f, 2.22609169e-03f, -2.98966169e-02f, 6.08255193e-02f, -1.72995105e-02f, 3.44734490e-02f, 1.27453795e-02f,
  8.32047611e-02f, 2.32078917e-02f, -3.71575840e-02f, -4.52367328e-02f, -1.61746264e-01f, 7.37775788e-02f, 4.62885983e-02f, -2.86506582e-02f, -2.49354951e-02f, -6.13096580e-02f,
  1.65298451e-02f, 8.14218745e-02f, -1.38677191e-02f, -3.81113552e-02f, -3.48293595e-02f, 1.33887276e-01f, -4.42676358e-02f, 7.94043019e-02f, -2.83324830e-02f, -1.55680645e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.72746082e-02f, 6.67533278e-02f, 3.16083372e-01f, -2.01833788e-02f, 1.42850563e-01f, 1.80409271e-02f, 8.54733065e-02f, 2.72786319e-01f, 3.43903571e-01f, 2.62413293e-01f,
  2.77307123e-01f, 3.09363127e-01f, 9.84064043e-02f, -1.30371675e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.19228959e-01f, 1.43298268e-01f, 1.67747974e-01f, 4.32207733e-02f, 1.22650109e-01f, 2.28032172e-01f, 2.02545710e-02f, 1.76581517e-01f, 3.91796092e-03f, -2.21658275e-01f,
  -3.73313054e-02f, -5.56059591e-02f, -8.57436508e-02f, 4.52415757e-02f, 1.06804542e-01f, -9.94730368e-02f, -1.89194202e-01f, -3.27021569e-01f, -1.62923068e-01f, 1.49151811e-03f,
  2.20966831e-01f, -9.37592611e-02f, -3.16301197e-01f, -7.79251987e-03f, 1.44978255e-01f, 3.05641349e-02f, 2.93558568e-01f, -3.13344449e-01f, -5.81993237e-02f, -7.02987388e-02f,
  -1.10324457e-01f, 4.06816810e-01f, -6.78500999e-03f, -5.07756509e-02f, -2.09732756e-01f, 5.15180863e-02f, 8.02152082e-02f, 2.29424000e-01f, -2.98368167e-02f, -8.12433660e-02f,
  4.45454895e-01f, 2.30465606e-01f, 2.28596777e-01f, -1.72314584e-01f, -2.06574842e-01f, 2.58906871e-01f, -2.24680215e-01f, 2.75535971e-01f, 5.82058504e-02f, 8.66915733e-02f,
  3.17994207e-01f, -1.84961334e-01f, -3.37257415e-01f, 1.09600589e-01f, 1.61199138e-01f, -1.64628029e-01f, -1.12934038e-01f, 3.97157490e-01f, 1.05597163e-02f, -1.42065078e-01f,
  -1.11348173e-02f, 1.85504258e-01f, 2.13284612e-01f, -3.27050507e-01f, -2.85980433e-01f, -8.01032260e-02f, -2.18979977e-02f, 1.20921098e-02f, -1.94947436e-01f, -2.06140399e-01f,
  -1.91538140e-01f, 1.42789125e-01f, -1.70734897e-01f, 5.69471717e-02f, -3.51782113e-01f, 4.95791212e-02f, 1.19012766e-01f, -2.16385797e-01f, -1.55566990e-01f, 1.12722376e-02f,
  -1.53988739e-02f, -1.15372509e-01f, -1.44244105e-01f, -9.95584726e-02f, 1.17483325e-01f, -3.02999746e-02f, 2.16963455e-01f, -2.11039051e-01f, -2.62074739e-01f, -2.00105131e-01f,
  3.22711557e-01f, 4.35286537e-02f, -1.82379643e-03f, 3.29539686e-01f, -3.63871336e-01f, 1.46865621e-02f, -2.41453007e-01f, -1.76316366e-01f, -8.98735523e-02f, 2.55064219e-01f,
  9.49699059e-03f, -1.09560326e-01f, 5.95660694e-03f, -8.93584415e-02f, 1.40053764e-01f, 3.10788602e-01f, 5.08917496e-02f, 1.51208118e-01f, 9.30344835e-02f, 5.45807034e-02f,
  -1.31225377e-01f, 4.38391007e-02f, 3.96247208e-02f, 2.57675767e-01f, 8.48290995e-02f, -4.77508269e-02f, -2.24882901e-01f, 1.72975317e-01f, 3.71984124e-01f, -7.26973042e-02f,
  -1.45462289e-01f, 1.18647620e-01f, -1.63416311e-01f, 2.65261799e-01f, 3.21197622e-02f, 3.14452872e-02f, 6.11501262e-02f, -3.60122800e-01f, 2.81321816e-03f, 1.34328142e-01f,
  1.03467777e-01f, -2.93864131e-01f, 8.47683698e-02f, -9.92629305e-02f, -1.56389877e-01f, 1.82432055e-01f, -4.38520104e-01f, -2.72930145e-01f, -1.06039725e-01f, 8.66677426e-03f,
  1.22627541e-01f, -1.31178722e-01f, -3.94314341e-02f, -5.60498498e-02f, -1.70754880e-01f, 3.72788869e-02f, -1.19523764e-01f, 1.54160246e-01f, 3.26704174e-01f, -2.59849578e-01f,
  -4.24622484e-02f, 4.12708551e-01f, -1.19371116e-01f, -2.39327177e-01f, -3.28985676e-02f, 2.96039373e-01f, -9.34389457e-02f, -8.82093534e-02f, 1.67205080e-01f, 2.69232422e-01f,
  8.30169115e-03f, 1.39906943e-01f, 7.61327446e-02f, -1.62680626e-01f, -4.96509820e-02f, -1.16389088e-01f, -3.29044312e-01f, -1.30983414e-02f, 6.55504912e-02f, 1.07938126e-01f,
  1.15468726e-01f, -2.48008788e-01f, -9.88866985e-02f, 3.25118974e-02f, 6.24935590e-02f, 1.27594888e-01f, 2.08303452e-01f, 3.12795013e-01f, -2.01403201e-01f, 2.13472962e-01f,
  -1.94665641e-01f, -1.70835510e-01f, -1.76394463e-01f, -1.85184851e-01f, 1.82079330e-01f, -3.56601030e-01f, 7.41024911e-02f, -2.36186981e-02f, -1.03940926e-01f, 8.00531730e-02f,
  -1.76607087e-01f, -3.02200556e-01f, -2.03536823e-01f, -1.06931515e-01f, -7.03072920e-02f, 2.03889818e-03f, -2.45608315e-01f, 2.15766922e-01f, 3.19003791e-01f, -3.41113299e-01f,
  -1.20361961e-01f, 3.16210054e-02f, -4.35197838e-02f, -2.99875643e-02f, -8.54436308e-02f, 7.94494748e-02f, 1.60181060e-01f, -3.69577557e-02f, -1.54952690e-01f, -2.35437810e-01f,
  3.29874128e-01f, -2.40615398e-01f, -1.03940815e-01f, -5.65038249e-02f, -3.70722860e-01f, 4.42524821e-01f, -1.31900962e-02f, 1.48198962e-01f, 1.64998218e-01f, -1.95198223e-01f,
  4.69346434e-01f, -4.54549104e-01f, 1.33065566e-01f, -7.63922289e-04f, -2.72359639e-01f, -2.94019338e-02f, -6.33541867e-02f, 3.94555569e-01f, 7.35002607e-02f, -5.66836856e-02f,
  1.28664151e-01f, -5.86181022e-02f, 2.08464801e-01f, 2.24283233e-01f, 1.24986090e-01f, 1.24503754e-01f, 3.56806442e-02f, 4.17217761e-02f, -6.97953179e-02f, -9.19326097e-02f,
  1.90989584e-01f, -2.14998890e-02f, 1.40524089e-01f, -3.92701745e-01f, -2.59514749e-01f, 1.63048699e-01f, 3.09470922e-01f, -2.72739500e-01f, -6.19963557e-02f, 2.31639221e-01f,
  5.10413833e-02f, -1.43773416e-02f, 1.37643561e-01f, -2.00277288e-02f, -5.39474748e-03f, -3.35689127e-01f, 2.90081173e-01f, -7.54726380e-02f, -6.17400929e-02f, 1.27689332e-01f,
  2.22390797e-02f, 3.70305061e-01f, 2.53607005e-01f, -3.53214473e-01f, 1.42447963e-01f, 2.72746477e-02f, 2.93316633e-01f, 7.35466555e-02f, -1.72851041e-01f, 1.56389788e-01f,
  3.59337568e-01f, -4.34779227e-02f, 7.86179751e-02f, -6.07872643e-02f, 1.86848715e-01f, 4.85798120e-02f, -1.66869804e-01f, 1.18975982e-01f, -2.56708056e-01f, 3.45605046e-01f,
  4.09371495e-01f, 1.33256182e-01f, 1.02354914e-01f, -2.33719677e-01f, 2.35360429e-01f, -2.42445096e-01f, 2.55956519e-02f, -1.99083641e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.27324730e-01f, 2.97959536e-01f, 9.32550281e-02f, 1.16620407e-01f, 7.42384940e-02f, 2.63238847e-01f, -1.05828010e-01f, 3.26194912e-01f, 2.10004151e-01f, 1.82064012e-01f,
  -1.05493359e-01f, -1.93006516e-01f, -1.71432465e-01f, -1.82935327e-01f, -3.36504489e-01f, 3.23835403e-01f, 8.40006396e-03f, 1.74645677e-01f, -1.27139032e-01f, -7.18530864e-02f,
  -6.12515165e-03f, -2.00092450e-01f, 3.90831709e-01f, -1.51923299e-01f, -2.01774463e-01f, 1.26499921e-01f, 6.41275287e-01f, -5.38736917e-02f, 1.84116036e-01f, 6.11169398e-01f,
  -7.44379833e-02f, -3.65704805e-01f, 4.49428335e-02f, -1.78624526e-01f, -9.26544070e-02f, 3.93190652e-01f, 2.42473826e-01f, 2.53570806e-02f, 4.08911586e-01f, -1.83312297e-01f,
  2.78408736e-01f, 2.52122879e-01f, 6.08801544e-02f, 2.78273672e-01f, 3.66261937e-02f, 1.06667299e-02f, 8.69113952e-02f, -1.23793475e-01f, 3.00218433e-01f, -3.45900282e-02f,
  3.42755020e-01f, -2.62385815e-01f, -3.91133457e-01f, 3.58163178e-01f, 1.67060122e-01f, 1.25287533e-01f, 6.58848956e-02f, 2.59240329e-01f, -2.07700804e-02f, 8.37923810e-02f,
  3.76561582e-01f, -2.14191034e-01f, 8.92919600e-02f, 4.30718902e-03f, 4.53629762e-01f, 4.04789120e-01f, 4.02447015e-01f, 1.85280278e-01f, 3.68247807e-01f, 3.20905596e-01f,
  1.11750573e-01f, 2.14333802e-01f, 4.04968023e-01f, -3.80928755e-01f, 4.35374886e-01f, -2.89028972e-01f, -5.48382625e-02f, -8.51223543e-02f, 1.33346722e-01f, 3.40031743e-01f,
  -1.98838100e-01f, 2.66289413e-02f, -6.46072403e-02f, 5.55694282e-01f, 4.55166519e-01f, 2.75433846e-02f, -3.24151427e-01f, -3.06805938e-01f, 5.56455195e-01f, 2.61856049e-01f,
  -2.69187957e-01f, -2.52424449e-01f, -1.48206562e-01f, 1.82089955e-01f, 1.54114380e-01f, 3.22737217e-01f, 3.78219895e-02f, 1.01409972e-01f, 2.15006620e-01f, 3.84516716e-01f,
  2.22482637e-01f, -2.59335898e-02f, 5.56146428e-02f, 1.39274001e-01f, 1.58031717e-01f, 3.00161272e-01f, 3.38005386e-02f, 1.76671028e-01f, 3.40979576e-01f, -3.70823234e-01f,
  -4.89210576e-01f, -2.52822101e-01f, 1.14254378e-01f, 2.51681894e-01f, -1.89487800e-01f, -4.55231071e-02f, 2.89703697e-01f, 2.84784377e-01f, 5.28711021e-01f, -1.66565463e-01f,
  -9.09159631e-02f, 2.78439045e-01f, -5.10101318e-02f, 3.54106635e-01f, -3.05884123e-01f, 4.39300746e-01f, 2.19594110e-02f, -1.19667724e-01f, 1.53336331e-01f, -1.27893299e-01f,
  8.83744061e-02f, 4.10364568e-01f, 2.09494412e-01f, 2.34370500e-01f, 5.02606511e-01f, -4.29377645e-01f, 3.92096996e-01f, 3.94926488e-01f, 1.60522640e-01f, 1.87659547e-01f,
  2.21855089e-01f, 3.19102183e-02f, 8.03424865e-02f, -9.02314633e-02f, 1.99410498e-01f, -1.25738055e-01f, 2.92331427e-01f, -1.53433293e-01f, -2.57022262e-01f, 4.16327089e-01f,
  1.71783715e-01f, 1.33276448e-01f, 2.89950043e-01f, 4.27499771e-01f, 3.22190151e-02f, 1.46443993e-01f, 3.39598387e-01f, -1.48005977e-01f, 2.40998298e-01f, -2.14114413e-01f,
  -2.76147395e-01f, 9.66108814e-02f, -2.05411687e-01f, -1.48523808e-01f, 1.23742305e-01f, 2.96770275e-01f, 1.38862416e-01f, -1.83749869e-02f, 1.05716534e-01f, -6.88465685e-02f,
  -1.92701116e-01f, -2.23045647e-01f, -2.50122368e-01f, 2.79703319e-01f, 8.74752179e-02f, 2.92241216e-01f, -3.12741250e-02f, -1.26519024e-01f, 2.29704559e-01f, -1.62396312e-01f,
  -2.06332758e-01f, -9.20889080e-02f, 2.94815093e-01f, 2.86957264e-01f, -1.98887438e-01f, 2.62774974e-01f, 7.47175634e-01f, -1.23481750e-01f, 3.98971289e-01f, 2.28285819e-01f,
  1.62370533e-01f, -9.44208652e-02f, -7.75796473e-02f, -1.26205251e-01f, -2.34749969e-02f, 9.38640907e-02f, 1.43631697e-01f, -1.79330423e-01f, 2.30489492e-01f, 2.88064390e-01f,
  -2.76288629e-01f, -1.31761163e-01f, -5.09751618e-01f, 1.63099766e-01f, 1.69683278e-01f, -1.23982176e-01f, 2.65463199e-02f, -1.62344217e-01f, -5.09231985e-02f, -2.69589126e-01f,
  1.99303925e-01f, 3.41168754e-02f, 5.00777960e-01f, 1.98005468e-01f, 1.23009942e-01f, 4.55184698e-01f, -1.57970741e-01f, -3.21804762e-01f, 3.48638892e-01f, 1.92947835e-01f,
  4.70826298e-01f, -8.89630150e-03f, 6.43954007e-03f, 5.09989798e-01f, 1.16850073e-02f, 9.81733128e-02f, 2.58588731e-01f, 3.00160646e-01f, 3.30987573e-01f, 9.08560827e-02f,
  3.30077678e-01f, 8.25017691e-02f, 2.01202452e-01f, 2.73517877e-01f, 1.06235385e-01f, 1.67040646e-01f, 3.34461510e-01f, -1.04921199e-01f, -4.73172933e-01f, 1.32533088e-02f,
  -2.50086904e-01f, 1.85402617e-01f, 3.45892489e-01f, -1.34148508e-01f, 4.84690905e-01f, 1.52641132e-01f, 3.99423450e-01f, 4.00502741e-01f, -3.38373661e-01f, 4.14937675e-01f,
  -3.62389565e-01f, 6.78576112e-01f, -1.50890991e-01f, 4.43704754e-01f, 6.54521167e-01f, -4.22834791e-02f, -9.62865576e-02f, 2.11484656e-01f, 4.40150760e-02f, 2.28397906e-01f,
  3.13848317e-01f, 2.86872387e-01f, 2.08842233e-01f, -8.82991999e-02f, 3.03388387e-01f, 1.27760973e-02f, -2.03493610e-02f, -1.92517340e-01f, -2.19131827e-01f, 1.52530551e-01f,
  3.67965013e-01f, 1.51578441e-01f, 2.93303490e-01f, -3.87753546e-02f, 1.40113071e-01f, 1.31278649e-01f, -1.87024936e-01f, 1.87886089e-01f, -1.13462005e-02f, -1.68994039e-01f,
  2.82714128e-01f, 2.07778528e-01f, 5.66921234e-01f, -1.81985155e-01f, 5.18243134e-01f, 2.21451342e-01f, -1.68531433e-01f, -1.28295869e-01f, 1.36181608e-01f, 1.94031939e-01f,
  1.31845688e-02f, -3.29022855e-02f, 1.90081760e-01f, 3.09177488e-01f, 1.65810674e-01f, 1.83534667e-01f, 1.20667055e-01f, -3.69144022e-01f, 2.52043549e-02f, -2.24915430e-01f,
  -1.58390775e-01f, 1.47389159e-01f, -6.94805235e-02f, 2.54635900e-01f, -4.28202212e-01f, -1.44733891e-01f, 1.58321545e-01f, 1.40255675e-01f, 1.91661432e-01f, -3.36736768e-01f,
  -1.80587500e-01f, 3.64359945e-01f, 5.59824705e-02f, 4.19909328e-01f, -5.31846099e-02f, -4.78301682e-02f, 6.17321469e-02f, -1.23201013e-02f, 5.30946136e-01f, 5.44940196e-02f,
  1.09366879e-01f, 1.43995032e-01f, 1.34280920e-01f, 8.19807276e-02f, 3.38852704e-02f, 1.72540575e-01f, 2.90744990e-01f, 1.85350806e-01f, -2.24275127e-01f, -3.23069751e-01f,
  -2.84711510e-01f, 1.71688840e-01f, 1.67487815e-01f, -1.77686751e-01f, 5.97394444e-02f, -1.30805671e-01f, -2.64122456e-01f, -4.71496254e-01f, 1.79984510e-01f, 5.77421747e-02f,
  4.41104442e-01f, 1.06988832e-01f, -2.81090349e-01f, 2.99306691e-01f, 1.69036686e-01f, 1.31357640e-01f, 1.69071019e-01f, 4.38189978e-04f, 2.57153779e-01f, -2.61295080e-01f,
  5.99029437e-02f, 4.56304491e-01f, -1.67578831e-01f, 1.46267891e-01f, 3.46336335e-01f, 4.56141979e-01f, 3.05837125e-01f, -6.15555644e-02f, 4.66211587e-02f, -8.57426375e-02f,
  2.69142240e-01f, 3.34205955e-01f, 4.53114718e-01f, 1.70115530e-01f, 3.67638439e-01f, -1.38741702e-01f, 2.64904261e-01f, -2.77711689e-01f, 4.33319151e-01f, 3.46368462e-01f,
  1.50555437e-02f, 1.90667257e-01f, 1.27433203e-02f, 3.83346796e-01f, 6.91223219e-02f, -3.00078690e-01f, 3.92741770e-01f, -3.01044118e-02f, 1.27044134e-02f, 1.61582276e-01f,
  2.59933054e-01f, 8.84015411e-02f, -2.10539207e-01f, -2.65251458e-01f, -6.62348047e-02f, 2.34179303e-01f, 1.20803840e-01f, -9.67178345e-02f, 2.84952879e-01f, 3.11146289e-01f,
  2.05473721e-01f, -2.10874504e-03f, 1.17952479e-02f, -3.18153858e-01f, 1.63675040e-01f, -2.48469725e-01f, -3.15353990e-01f, 2.79738963e-01f, 2.64626592e-01f, 2.43291929e-01f,
  -7.65240416e-02f, 4.67239022e-02f, 2.57876515e-01f, 1.83624193e-01f, -1.14225894e-01f, -2.53546089e-01f, -5.28179184e-02f, 3.40962321e-01f, -9.91991255e-03f, 3.99661958e-01f,
  1.98300362e-01f, -2.18843237e-01f, 1.78450152e-01f, -3.36728171e-02f, 4.14401501e-01f, -1.26310159e-02f, 1.96437493e-01f, 7.83035904e-02f, 3.29353601e-01f, 3.71557951e-01f,
  2.40037426e-01f, -9.28410888e-02f, 1.33604378e-01f, 1.34674743e-01f, 5.37895225e-02f, -1.26737043e-01f, -2.19345078e-01f, 2.79947042e-01f, 2.41592318e-01f, -3.17532510e-01f,
  -1.34732336e-01f, -2.67075866e-01f, 3.86069976e-02f, -1.90403581e-01f, -4.30334313e-03f, -1.61315128e-02f, 6.44759417e-01f, 1.95255145e-01f, 2.58474439e-01f, 2.59852052e-01f,
  8.61496404e-02f, -7.75418431e-02f, 2.12420315e-01f, 2.66219139e-01f, 3.53129804e-01f, 2.29332149e-01f, -2.33822897e-01f, 3.34511995e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.86725485e-02f, 1.71183556e-01f, 4.39679414e-01f, 1.53015196e-01f, 1.18902735e-01f, 1.64998442e-01f, -1.80792492e-02f, 2.84786671e-01f, 3.44360977e-01f, 2.12645426e-01f,
  3.28225456e-02f, 1.09536283e-01f, 1.50575504e-01f, 1.22955747e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -3.73763859e-01f, -8.99422020e-02f, -1.27841160e-01f, -1.68427899e-01f, -4.50755320e-02f, 1.77704826e-01f, -5.92015199e-02f, -2.23099422e-02f, -1.48558006e-01f, 5.01182117e-02f,
  -3.23396951e-01f, 2.18041122e-01f, -1.90014020e-01f, 1.32731274e-01f, 2.50813644e-02f, -2.43604416e-03f, -7.34842420e-02f, 3.40737440e-02f, 1.16387852e-01f, -2.39469483e-01f,
  1.12323046e-01f, -4.87539135e-02f, -2.25228593e-01f, 1.62327513e-02f, -3.45794205e-03f, -1.65359229e-01f, -5.22122160e-02f, 1.03139430e-02f, 1.71519816e-01f, 1.27012923e-01f,
  5.27328402e-02f, 2.92001486e-01f, -1.36730120e-01f, 1.88673198e-01f, 2.90659308e-01f, -1.09049268e-01f, -5.16698100e-02f, 1.56686977e-01f, 5.45804948e-02f, 1.32390589e-01f,
  -2.31396593e-02f, -3.98229361e-02f, -2.64803499e-01f, 1.32985204e-01f, -1.97107092e-01f, 2.06496522e-01f, 1.59636050e-01f, -3.74767959e-01f, -2.88082480e-01f, -1.86708227e-01f,
  1.99611068e-01f, -3.08808148e-01f, 2.36628488e-01f, 9.47050471e-03f, -3.53200108e-01f, -1.41093895e-01f, -4.30552214e-02f, -1.59982562e-01f, 9.49120820e-02f, 1.97152328e-02f,
  1.56053111e-01f, 1.66130632e-01f, -4.82696593e-02f, 1.56325325e-01f, -1.78823709e-01f, -4.16834317e-02f, 9.09968186e-03f, -8.33955500e-03f, -7.18273371e-02f, -8.93929154e-02f,
  1.50222450e-01f, -5.58084734e-02f, -7.48473406e-02f, 1.51739404e-01f, -2.35586941e-01f, -1.02362921e-02f, -3.18879515e-01f, -2.79851016e-02f, 1.21345706e-02f, -1.28012896e-01f,
  -1.87206700e-01f, 3.95853445e-02f, -2.33648151e-01f, 7.63086453e-02f, 2.02870771e-01f, -2.34938458e-01f, 1.62749246e-01f, -3.34696293e-01f, 1.85634255e-01f, -8.18350837e-02f,
  -5.55987209e-02f, -8.36600214e-02f, 6.60465583e-02f, 2.64720339e-02f, -1.17592588e-01f, 6.52453378e-02f, 7.19130645e-03f, 2.13715751e-02f, -4.39566933e-02f, 2.98598588e-01f,
  5.10459244e-02f, 7.75843579e-03f, -1.31207360e-02f, 1.10020250e-01f, -3.45256599e-03f, 1.89360291e-01f, 1.96027160e-01f, 5.64461760e-02f, 5.12551852e-02f, 7.53289685e-02f,
  -1.83498375e-02f, -2.52543420e-01f, 5.92047572e-02f, -1.25851735e-01f, -8.29974562e-02f, -1.85431510e-01f, 2.47360200e-01f, 2.78731942e-01f, -1.56894058e-01f, -5.96527457e-02f,
  -2.19136432e-01f, 1.87881485e-01f, -1.13592438e-01f, 3.39780897e-02f, -7.49314995e-03f, 5.28291203e-02f, -2.31961366e-02f, -1.10949717e-01f, 2.73709804e-01f, 1.77190289e-01f,
  8.69197100e-02f, 6.49721315e-03f, -1.18732102e-01f, -3.72065119e-02f, 2.06083227e-02f, 2.66532041e-02f, 9.24598873e-02f, -3.05837214e-01f, 1.64354160e-01f, 1.70511782e-01f,
  9.48373675e-02f, 5.88981397e-02f, 2.60207742e-01f, -1.68633893e-01f, -1.69822112e-01f, -9.53800082e-02f, 2.57761359e-01f, -9.18706413e-03f, -1.27959937e-01f, 1.37571663e-01f,
  5.30609861e-03f, -3.12325805e-02f, 2.94051588e-01f, -1.07884392e-01f, 2.57270932e-02f, -9.35784057e-02f, -5.55826045e-06f, -1.68663874e-01f, -1.48515671e-01f, 2.31871709e-01f,
  1.83618933e-01f, 6.58040717e-02f, -1.32247731e-02f, 1.07800327e-01f, 5.70201278e-02f, 1.38185561e-01f, 1.46127850e-01f, 1.11102983e-02f, 3.88276614e-02f, -3.14645246e-02f,
  1.98321659e-02f, -1.51649386e-01f, -1.10981427e-01f, -1.97667152e-01f, 1.22748308e-01f, 1.95280060e-01f, -6.54822066e-02f, 2.97207564e-01f, -1.23361148e-01f, 2.00679705e-01f,
  -3.63100953e-02f, -1.66779578e-01f, 5.13939373e-02f, 8.12644288e-02f, -1.57491732e-02f, -9.22266915e-02f, 2.39899203e-01f, -2.70974785e-02f, 3.98746580e-02f, 1.58683389e-01f,
  1.88679129e-01f, -1.38892546e-01f, 3.15456361e-01f, 2.28205264e-01f, 1.67587548e-01f, 1.99903667e-01f, -6.39429837e-02f, -2.97245868e-02f, -1.96106732e-03f, -9.99919698e-02f,
  2.67406225e-01f, -1.92803696e-01f, 4.05137390e-01f, 6.90321624e-02f, 1.62085027e-01f, -1.81066558e-01f, 1.29848614e-01f, -9.14926529e-02f, -7.21839368e-02f, -1.92678601e-01f,
  2.32294977e-01f, 7.62629835e-03f, -4.58026640e-02f, 1.49446264e-01f, -2.23506871e-03f, 1.62018076e-01f, -1.12428761e-03f, -1.20858978e-02f, 8.68061483e-02f, -2.08008096e-01f,
  -2.04208866e-01f, -1.89017147e-01f, -2.59687781e-01f, -2.61149332e-02f, 1.27853006e-01f, -8.22186768e-02f, -7.11180568e-02f, 2.06068978e-02f, -2.31040508e-01f, -1.19150333e-01f,
  -1.18334852e-01f, -4.43339683e-02f, -1.62530094e-02f, 1.86663810e-02f, 2.10936099e-01f, 4.88423742e-02f, 2.12085500e-01f, -2.01977924e-01f, -1.02237187e-01f, 6.25915155e-02f,
  2.28684485e-01f, -9.79085192e-02f, 6.16884045e-02f, 2.36458927e-01f, -3.07287067e-01f, 2.12408215e-01f, 2.40215018e-01f, 2.53102612e-02f, 7.88417980e-02f, 8.64014030e-02f,
  -3.71996351e-02f, -8.25850293e-02f, -1.72556758e-01f, 5.99082485e-02f, -1.11804016e-01f, -3.99490558e-02f, 1.34270191e-01f, -7.53876865e-02f, -1.13169625e-01f, -1.03733584e-01f,
  1.35599419e-01f, -1.21022537e-01f, -9.77564901e-02f, -1.08559541e-01f, 1.26649648e-01f, -4.16416535e-03f, 2.66613454e-01f, -9.72246453e-02f, -3.95065956e-02f, -7.02411160e-02f,
  -1.43955797e-01f, 2.29244322e-01f, -8.08889978e-03f, 1.48111200e-02f, -3.14629846e-03f, 1.32618740e-01f, -2.11829275e-01f, -2.10398838e-01f, 1.23990498e-01f, 1.56689301e-01f,
  3.14000472e-02f, 8.03533122e-02f, 1.87191516e-01f, 1.33353904e-01f, -1.03296518e-01f, -1.32617265e-01f, -1.90822687e-02f, -1.82609722e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.15381905e-01f, -1.73203096e-01f, -7.81271532e-02f, -2.62089938e-01f, -1.56950474e-01f, -2.41960540e-01f, -1.56550482e-01f, -1.35861402e-02f, -9.35757905e-02f, -6.71746209e-02f,
  -1.13117313e-02f, 1.52979242e-02f, -5.48088439e-02f, 1.03473626e-01f, -1.96981698e-01f, 4.30853367e-01f, -2.39777379e-02f, 2.48024419e-01f, -1.94368944e-01f, 2.04130024e-01f,
  -1.31632432e-01f, -5.03830135e-01f, 3.23122263e-01f, 5.06353617e-01f, 4.17582184e-01f, 2.77471747e-02f, 1.83745623e-01f, 3.55058670e-01f, 4.91774380e-01f, -1.96111843e-01f,
  4.34043080e-01f, 2.01368690e-01f, -3.06577772e-01f, -7.06332177e-02f, -4.43740711e-02f, -6.30532056e-02f, -8.82195532e-02f, 7.14637786e-02f, 5.60010448e-02f, 1.19961239e-01f,
  -3.97367835e-01f, -3.81395295e-02f, -6.74454212e-01f, -3.68249118e-01f, -1.17766820e-01f, 1.33827612e-01f, -3.45813125e-01f, 4.30806100e-01f, 1.51266217e-01f, 4.64275956e-01f,
  -7.20048785e-01f, 4.99889404e-01f, 3.26806992e-01f, -1.42282307e-01f, 3.70153099e-01f, -3.97551835e-01f, 2.48631790e-01f, 1.47259846e-01f, 9.38228741e-02f, 1.37304068e-01f,
  6.15476012e-01f, 2.84992486e-01f, 4.17906977e-02f, 3.21695149e-01f, 5.72784059e-03f, -3.18440720e-02f, -3.58617641e-02f, -4.82555991e-03f, -7.27185160e-02f, -3.11177149e-02f,
  -6.09652810e-02f, -1.17959715e-02f, -2.74853464e-02f, 1.97508037e-02f, -6.03657104e-02f, 1.64440032e-02f, -2.73678312e-03f, 2.43508611e-02f, 2.72803716e-02f, -1.78337321e-02f,
  -3.38205546e-02f, -1.67272221e-02f, -5.65983206e-02f, -3.53668854e-02f, -2.90922243e-02f, -2.73030363e-02f, -2.31928006e-02f, -3.15836444e-02f, -2.16677785e-02f, -2.92239841e-02f,
  -5.59923425e-02f, -1.90735981e-02f, -1.79498531e-02f, -4.24092039e-02f, -2.59287171e-02f, -3.12706418e-02f, 2.55038619e-01f, 1.92478076e-01f, 8.94481167e-02f, 2.58751273e-01f,
  1.06723070e-01f, 2.95960922e-02f, -3.29361558e-02f, 1.93725601e-02f, -1.01931304e-01f, 2.11333916e-01f, -9.07855406e-02f, 2.04658881e-02f, 6.15592338e-02f, -2.23612040e-02f,
  -2.50133187e-01f, -4.34684843e-01f, 1.72468275e-01f, -5.11529326e-01f, -1.17233403e-01f, 1.60916448e-01f, 2.93509871e-01f, 5.40352941e-01f, 2.48961180e-01f, -5.42465568e-01f,
  1.76119387e-01f, 8.06178153e-01f, -2.60982096e-01f, -1.25691622e-01f, 1.40185356e-01f, 4.87444818e-01f, -4.11989301e-01f, 4.52165991e-01f, -3.62721086e-01f, -9.15748551e-02f,
  3.09549458e-02f, -2.67547280e-01f, -1.49418294e-01f, 4.79523139e-03f, 8.45511630e-02f, 1.86923355e-01f, -1.85494781e-01f, -9.63766798e-02f, -5.38576722e-01f, -4.71275523e-02f,
  -1.28655657e-01f, 6.23523355e-01f, -3.14416587e-01f, -1.11389738e-02f, -3.17647368e-01f, -2.52070367e-01f, -3.29925984e-01f, -1.41678244e-01f, 4.21817482e-01f, 1.43687502e-01f,
  -2.38611072e-01f, -1.73592582e-01f, 4.89885181e-01f, 4.79584515e-01f, -2.34165117e-01f, 4.08799469e-01f, 6.61405623e-01f, -2.21167982e-01f, 2.02618286e-01f, 4.14193124e-01f,
  1.70099407e-01f, 3.42600256e-01f, 9.08173025e-02f, 6.45434260e-02f, 1.15737677e-01f, 3.60821635e-01f, 5.71599193e-02f, 8.54200199e-02f, 2.18522921e-02f, 5.76204695e-02f,
  -1.68406144e-01f, 7.87075981e-03f, 2.34884024e-01f, -4.15817082e-01f, 1.77511964e-02f, -1.46376595e-01f, 4.46346104e-01f, 2.33604878e-01f, 1.96256757e-01f, 3.95079583e-01f,
  1.73589718e-02f, 3.32885504e-01f, 4.58795875e-01f, -1.95733264e-01f, -2.39545852e-02f, -2.72715509e-01f, 5.25026739e-01f, -5.29110909e-01f, -1.55186668e-01f, 7.87680447e-01f,
  -3.64023447e-01f, 4.41716433e-01f, 2.64305234e-01f, 5.60188778e-02f, 1.05378129e-01f, 2.19118461e-01f, -4.03935350e-02f, -3.78957354e-02f, -6.77507967e-02f, 2.94843912e-01f,
  2.55022217e-02f, -1.63208872e-01f, 6.12448528e-03f, 1.39487550e-01f, 1.96502686e-01f, 2.80657589e-01f, 1.88617557e-02f, -2.24871084e-01f, 1.28209844e-01f, -5.41512072e-01f,
  1.56408727e-01f, -1.28664210e-01f, 5.46461716e-03f, 5.71584821e-01f, -1.45319298e-01f, -3.14736605e-01f, 1.94941387e-01f, 8.32148015e-01f, -6.07140422e-01f, 6.88330084e-02f,
  -1.12969331e-01f, 1.53569281e-01f, -3.24563831e-01f, 4.21363562e-01f, 3.72270823e-01f, 3.99211466e-01f, 2.34105483e-01f, 3.89347792e-01f, 3.79486948e-01f, 3.55867624e-01f,
  3.57537895e-01f, 2.62963176e-01f, 3.36029917e-01f, 2.80722708e-01f, 2.61459827e-01f, -3.09809208e-01f, -2.39096284e-01f, -1.36032790e-01f, 5.02758443e-01f, -2.68475652e-01f,
  -1.77749678e-01f, 4.33058947e-01f, 5.28740466e-01f, -2.86251754e-01f, 3.98048788e-01f, -6.71678130e-03f, -1.83192179e-01f, 4.04890686e-01f, -2.89301872e-01f, -1.88242108e-01f,
  5.62201619e-01f, 2.46617064e-01f, -9.91263539e-02f, 3.63510996e-01f, 4.08333480e-01f, -1.62648275e-01f, 3.45109850e-01f, 1.64507538e-01f, 3.58692594e-02f, 3.57575655e-01f,
  2.74214536e-01f, 1.25602305e-01f, 2.09765092e-01f, 3.74055773e-01f, 1.93423077e-01f, 3.24135751e-01f, 2.53161609e-01f, -3.53529572e-01f, -2.42968842e-01f, -1.46996751e-01f,
  2.87978947e-01f, -2.03807682e-01f, 7.94153214e-02f, 1.83371603e-01f, 2.07546130e-01f, -2.77547538e-01f, 6.17671430e-01f, 6.98670149e-02f, 1.10684214e-02f, 7.72845596e-02f,
  -4.65366662e-01f, 3.42157111e-02f, 3.48466635e-01f, 4.66925383e-01f, -8.77208412e-02f, 1.70148596e-01f, 2.51761258e-01f, -2.62059838e-01f, -1.60679862e-01f, 7.86832571e-02f,
  1.35886788e-01f, 2.43658945e-02f, 1.71309233e-01f, -9.78391245e-03f, 2.32367098e-01f, 7.36052170e-02f, 4.69866663e-01f, 2.27721453e-01f, 5.63396327e-02f, -1.44069880e-01f,
  -4.20814574e-01f, 3.19292456e-01f, -2.32078418e-01f, -2.69204557e-01f, -5.21464288e-01f, -2.20533654e-01f, 4.60599184e-01f, -1.99592441e-01f, 5.28858900e-01f, -1.85764298e-01f,
  -1.87968105e-01f, 4.01936769e-01f, 4.25600857e-01f, -4.09002509e-03f, 2.15507388e-01f, 4.47367877e-01f, 5.32859266e-01f, -5.16162634e-01f, 3.35754246e-01f, 3.71732146e-01f,
  3.02810878e-01f, 6.37087375e-02f, -1.96176227e-02f, 1.31613463e-01f, -5.38013689e-02f, -2.36782432e-02f, -3.17345619e-01f, 7.43128955e-02f, 8.02974775e-02f, -4.04442310e-01f,
  4.37871993e-01f, 2.77304441e-01f, 5.62624872e-01f, -5.00057824e-02f, -2.92587310e-01f, 1.73466310e-01f, 4.09777761e-01f, -1.94788694e-01f, 6.62982166e-01f, 1.96379408e-01f,
  -3.76955688e-01f, 4.31260258e-01f, 3.90416443e-01f, 5.57149053e-01f, 2.35841691e-01f, 6.57944620e-01f, 1.26130566e-01f, 1.30341038e-01f, -4.73154671e-02f, 6.44999417e-03f,
  1.17091395e-01f, 1.56175748e-01f, 7.02643394e-02f, -3.11300427e-01f, -3.48941803e-01f, -1.42342776e-01f, -1.62208304e-01f, -8.37570429e-02f, -2.40673721e-01f, -1.40158027e-01f,
  -3.17586623e-02f, -2.58952826e-01f, 2.92088866e-01f, 1.33436382e-01f, 3.66937578e-01f, -4.38672751e-01f, -4.58938658e-01f, 5.02035975e-01f, 5.45434535e-01f, 2.05946207e-01f,
  -2.68386398e-02f, 6.25945747e-01f, -3.22925001e-01f, 2.13101730e-01f, 6.09497845e-01f, 3.80507201e-01f, 1.39368638e-01f, 3.54029417e-01f, 2.33186617e-01f, 7.06320396e-03f,
  8.21980089e-02f, 1.82614967e-01f, 1.91590533e-01f, 1.30952522e-01f, 1.16872698e-01f, 1.82706192e-01f, -3.02098662e-01f, 2.21863031e-01f, 3.19023997e-01f, 1.23909920e-01f,
  1.58186376e-01f, -2.01753020e-01f, 3.58713955e-01f, 4.69624013e-01f, 3.62683922e-01f, -1.76660389e-01f, -1.04683883e-01f, -5.38887262e-01f, 7.08265081e-02f, -2.72549063e-01f,
  3.31420779e-01f, 2.36296669e-01f, 2.89292574e-01f, 1.64333835e-01f, 4.18045789e-01f, 2.51837939e-01f, 2.78888375e-01f, 4.87995222e-02f, -5.18644333e-01f, -7.51933679e-02f,
  3.42233539e-01f, 8.04368407e-02f, -1.02483235e-01f, 2.50516325e-01f, 2.08729506e-01f, -6.83245361e-02f, 3.94733757e-01f, 3.75300318e-01f, -8.36329833e-02f, 4.90275890e-01f,
  2.72963315e-01f, 2.41508320e-01f, 2.20096320e-01f, 3.11929554e-01f, 3.60898733e-01f, 2.26983666e-01f, 8.63586962e-02f, -6.24822974e-01f, -1.59611702e-01f, 1.44385234e-01f,
  3.35388221e-02f, -2.77516484e-01f, -3.73394012e-01f, 3.88345599e-01f, -1.13263428e-01f, 2.75455806e-02f, 6.03068233e-01f, -7.39698708e-02f, 4.10949826e-01f, -1.74430534e-01f,
  -6.19040668e-01f, 4.58707720e-01f, -6.98723421e-02f, 3.83412272e-01f, -1.91856191e-01f, 1.63193792e-01f, 4.29426700e-01f, -2.76093185e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.22454748e-01f, 1.83831342e-02f, -4.28607278e-02f, 1.55473113e-01f, 6.15847148e-02f, -3.37175792e-03f, 1.08719021e-01f, 2.69020855e-01f, 1.54251814e-01f, 5.47107421e-02f,
  6.55454770e-02f, -1.01879518e-02f, 1.29133537e-01f, 3.00601065e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -7.59432986e-02f, -2.01817885e-01f, -5.12712263e-02f, 1.14317954e-01f, -1.21119417e-01f, -1.12358220e-01f, 1.75732121e-01f, 8.62242877e-02f, -1.49955347e-01f, 1.81715518e-01f,
  8.99021924e-02f, 3.42758745e-01f, 3.42861503e-01f, 1.52253732e-01f, -4.41799194e-01f, -2.51882881e-01f, -2.93083221e-01f, -2.49142691e-01f, -6.82194382e-02f, 1.32743180e-01f,
  -9.19428933e-03f, 2.59521961e-01f, 3.94799739e-01f, -5.75868011e-01f, 2.69061655e-01f, -7.14545071e-01f, -3.01879823e-01f, 3.35427374e-01f, -4.72042888e-01f, -4.16622818e-01f,
  -5.92924297e-01f, -4.72332060e-01f, -8.66890773e-02f, 7.18874298e-03f, 1.10243201e-01f, -6.02749400e-02f, 9.19348001e-02f, 1.21615224e-01f, 9.26027820e-02f, 1.82534512e-02f,
  2.11111456e-01f, 2.20144004e-01f, 1.70791626e-01f, -1.05533339e-01f, -4.01032239e-01f, 3.42355996e-01f, 2.61855960e-01f, -1.32274210e-01f, -4.63155434e-02f, 5.32115772e-02f,
  2.21607462e-01f, 2.48780191e-01f, -2.67312359e-02f, -6.89267933e-01f, 3.18224400e-01f, -1.69167981e-01f, -5.27475238e-01f, -4.27943356e-02f, -1.13805704e-01f, 3.92945826e-01f,
  -1.28344730e-01f, -4.47698031e-03f, -6.75709605e-01f, -4.62541312e-01f, -1.56275660e-01f, 2.44294420e-01f, -1.82066053e-01f, -2.62361228e-01f, -6.46545663e-02f, -1.22313835e-01f,
  -1.62298799e-01f, -2.44842574e-01f, -1.00055849e-02f, 3.87719065e-01f, 1.99953839e-01f, -1.08611174e-01f, -2.43125141e-01f, 2.11172178e-02f, -8.72558057e-02f, 2.95289069e-01f,
  2.18924776e-01f, 4.77463380e-02f, 5.57864942e-02f, -3.69916439e-01f, 6.55040424e-03f, -6.78700209e-01f, -6.89903915e-01f, 1.91755712e-01f, -3.56220007e-01f, 2.83725172e-01f,
  6.83645532e-02f, -1.09660402e-02f, 1.51095703e-01f, 1.05540201e-01f, 2.81585336e-01f, -7.80173361e-01f, 2.30052490e-02f, -7.83417150e-02f, -2.15500683e-01f, -1.64670736e-01f,
  -2.81505436e-01f, -6.38761818e-02f, 3.11561972e-01f, -1.05254300e-01f, -2.26004273e-01f, 2.83743650e-01f, 3.66197348e-01f, -1.10287637e-01f, 3.19178164e-01f, 7.41924569e-02f,
  -2.63712317e-01f, 2.51100600e-01f, 2.33545288e-01f, -3.93646926e-01f, -4.89886224e-01f, -2.90759243e-02f, -5.28332070e-02f, 4.07910347e-01f, 2.58916080e-01f, 1.78274825e-01f,
  4.10481930e-01f, -6.84364498e-01f, -6.17497563e-01f, -7.01086044e-01f, 1.18901469e-01f, -8.18219557e-02f, -6.44612134e-01f, -5.41271389e-01f, 2.06249371e-01f, -6.54578805e-02f,
  7.53720552e-02f, -1.89178228e-01f, 1.24578990e-01f, 1.77538157e-01f, 3.88043560e-03f, 3.55974883e-01f, -1.79276988e-02f, -1.39435530e-01f, -3.87678482e-02f, -3.30662280e-01f,
  -7.36449612e-03f, 2.61523098e-01f, -3.97695243e-01f, 2.02107951e-01f, 8.86740908e-02f, -8.59887451e-02f, -4.71622676e-01f, -3.57022703e-01f, 3.12866531e-02f, 2.74167180e-01f,
  -1.51011469e-02f, -1.03823557e-01f, 3.37450236e-01f, 3.86285074e-02f, 2.24805951e-01f, 2.84810334e-01f, 1.13653846e-01f, -4.12992477e-01f, -1.25350863e-01f, 3.35166097e-01f,
  -1.40065134e-01f, -1.63224742e-01f, -1.01682525e-02f, 1.63731515e-01f, 1.37778983e-01f, 2.46730655e-01f, -2.90797830e-01f, -1.26880199e-01f, 1.82971731e-02f, 5.17708540e-01f,
  1.53484643e-01f, 6.72915041e-01f, 6.96742311e-02f, -5.89034200e-01f, 3.07339896e-02f, -5.08895278e-01f, -1.24470562e-01f, -1.51546359e-01f, -1.83451012e-01f, 4.11467999e-01f,
  -1.15912640e-02f, 6.70439526e-02f, 1.52569503e-01f, 9.69772562e-02f, -4.22178626e-01f, -3.22184898e-02f, 1.08370416e-01f, 1.66450366e-01f, -1.02944994e+00f, -4.85527664e-01f,
  2.21475333e-01f, 3.30262065e-01f, 2.63222098e-01f, 9.35395956e-02f, 2.01364651e-01f, 1.82852015e-01f, 2.97473371e-01f, -2.95707971e-01f, 1.96735591e-01f, 1.12752795e-01f,
  2.22098038e-01f, -1.45922676e-01f, 4.76389855e-01f, -3.71701121e-01f, 1.09640293e-01f, -1.07614867e-01f, 2.80362278e-01f, 1.83502316e-01f, -4.25771147e-01f, 4.01404679e-01f,
  -3.69092256e-01f, -5.17628014e-01f, -1.69625841e-02f, -7.29965627e-01f, -3.98707360e-01f, -3.45016479e-01f, -3.68546724e-01f, 5.62104940e-01f, 4.50638860e-01f, 2.04157770e-01f,
  -5.66758931e-01f, -9.07266498e-01f, 2.35357136e-01f, 4.45994407e-01f, -2.44996622e-01f, -3.31676185e-01f, 1.47772236e-02f, 1.00619145e-01f, 2.65937358e-01f, 1.39364675e-01f,
  5.53998025e-03f, -3.18535268e-01f, -1.99105263e-01f, -1.64906636e-01f, -2.26063341e-01f, 1.20913662e-01f, -9.76072848e-02f, -1.18870810e-01f, -1.42386481e-02f, -6.14618100e-02f,
  2.71609537e-02f, 8.97564888e-02f, 2.01845407e-01f, 9.45697650e-02f, -1.43634658e-02f, -6.52926341e-02f, -2.97231060e-02f, -5.38309872e-01f, 2.10885748e-01f, -7.35751212e-01f,
  -5.06282210e-01f, -2.64007360e-01f, 3.17082852e-01f, 3.11983138e-01f, -6.19273663e-01f, 1.55559584e-01f, -4.30422574e-02f, -1.90330997e-01f, 2.37168878e-01f, -4.11839932e-01f,
  -1.22714058e-01f, -2.72398323e-01f, -6.07099244e-03f, -1.94230080e-01f, -1.11660995e-01f, -7.59259090e-02f, -4.21132177e-01f, -7.41922855e-02f, -2.70499766e-01f, 1.99160397e-01f,
  -4.14569229e-02f, 2.51300871e-01f, -1.52669728e-01f, 2.80622452e-01f, 1.20780163e-01f, 4.42866415e-01f, 3.82243507e-02f, 1.19493745e-01f, -4.51948047e-01f, 4.17382926e-01f,
  -3.06414068e-01f, -4.18712050e-01f, -4.54358876e-01f, -2.72073925e-01f, 7.21283928e-02f, 2.94636220e-01f, -2.15204448e-01f, -4.98179376e-01f, 9.84466448e-02f, 3.64112705e-02f,
  -1.17644466e-01f, 1.45903364e-01f, -4.23783243e-01f, -1.99176908e-01f, -3.48113216e-02f, 1.73561975e-01f, -5.17080963e-01f, -4.24207121e-01f, -6.32461190e-01f, -7.30388314e-02f,
  1.27753451e-01f, -3.77575308e-01f, 9.54187587e-02f, -2.65411645e-01f, 2.45157778e-01f, 1.77449092e-01f, 8.61739144e-02f, 1.02000937e-01f, 1.18742203e-02f, -5.23269594e-01f,
  -1.34420887e-01f, -6.75461054e-01f, -4.64814723e-01f, -7.74270445e-02f, 3.15569192e-01f, -3.75339277e-02f, -9.94935781e-02f, 2.57160366e-01f, 2.83400565e-01f, 1.68069988e-01f,
  1.87095493e-01f, 2.04327360e-01f, -5.83975762e-02f, 4.06196535e-01f, -1.16736718e-01f, 4.05652165e-01f, -5.21731555e-01f, -2.92726338e-01f, 1.97170645e-01f, -1.66069746e-01f,
  2.04423498e-02f, 2.03399479e-01f, 1.57782048e-01f, -1.15285285e-01f, -2.43561208e-01f, 5.94538115e-02f, -2.69310057e-01f, -3.19399824e-03f, -4.63905185e-01f, -8.87550414e-01f,
  -1.33408466e-02f, 2.97044963e-01f, -6.05912209e-01f, 3.48482460e-01f, 5.25339618e-02f, -2.77938932e-01f, -4.63588864e-01f, -1.15809746e-01f, 3.30587804e-01f, 3.61886203e-01f,
  4.97889638e-01f, -4.30089086e-01f, -6.65331110e-02f, 1.51109053e-02f, 3.77259672e-01f, 3.37835103e-01f, 2.69136786e-01f, -2.87510395e-01f, 2.46859148e-01f, -5.99029250e-02f,
  -5.90626374e-02f, -2.39582703e-01f, 1.10840194e-01f, 1.92435943e-02f, 8.58387947e-02f, 8.16910062e-03f, 3.80544543e-01f, 1.76822335e-01f, 1.84791103e-01f, -2.73327351e-01f,
  -6.20485008e-01f, 2.22200543e-01f, -2.20373515e-02f, 1.52145669e-01f, -7.11990654e-01f, 4.44728911e-01f, -9.37460437e-02f, 1.53168947e-01f, 1.88025877e-01f, -8.26965630e-01f,
  -2.53326356e-01f, 3.56360972e-02f, 3.70909214e-01f, 3.22263539e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.93589253e-02f, 2.93033421e-02f, 9.27228555e-02f, 1.48046300e-01f, 1.25622349e-02f, 4.71564904e-02f, 1.44401938e-01f, -4.91761155e-02f, 7.72384834e-03f, -1.75027758e-01f,
  3.46553065e-02f, 1.23367861e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    