/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.22407317e-01f, -7.84860700e-02f, 2.93067068e-01f, -2.38273501e-01f, -8.64844546e-02f, -2.83044446e-02f, 2.59535033e-02f, -2.67337561e-01f, -2.32494444e-01f, 3.65450978e-02f,
  -1.58277720e-01f, -2.22038582e-01f, -1.17501713e-01f, -8.78465697e-02f, -5.80696538e-02f, 1.56195119e-01f, 2.04189405e-01f, 2.46402666e-01f, -6.37385473e-02f, -1.64962769e-01f,
  -1.48536578e-01f, -7.39739218e-04f, -3.41597870e-02f, -2.88326610e-02f, -4.33543324e-02f, -1.01987615e-01f, 2.33325630e-01f, 1.72307268e-01f, 1.40759364e-01f, 4.18188691e-01f,
  9.38008800e-02f, -3.98662798e-02f, 5.07079735e-02f, 1.18503489e-01f, -6.72387481e-02f, 3.22124641e-03f, -7.38537461e-02f, 5.44948354e-02f, -2.72519849e-02f, 6.31644279e-02f,
  9.72730592e-02f, 6.92726523e-02f, -9.02282912e-03f, 1.17897265e-01f, 3.92439477e-02f, 5.37591986e-02f, 1.55735463e-01f, 6.38414249e-02f, 8.81660506e-02f, 1.74463820e-02f,
  3.20356637e-02f, 1.58113405e-01f, 1.33161291e-01f, 7.48463124e-02f, 1.60077140e-02f, 8.90555233e-02f, 9.68471244e-02f, 6.16640300e-02f, 2.34789625e-01f, 2.05735192e-01f,
  8.56034011e-02f, -1.73077285e-02f, -3.34749394e-03f, 4.40210961e-02f, 3.97232361e-02f, 1.70636475e-01f, 7.91648403e-02f, -9.83636174e-03f, -2.48351339e-02f, -4.06707358e-03f,
  4.68843766e-02f, 3.60832773e-02f, -3.04314382e-02f, -8.04552659e-02f, 1.88500322e-02f, -3.76179889e-02f, -1.44853860e-01f, 8.15990865e-02f, 5.27137183e-02f, 4.72731963e-02f,
  -6.17875271e-02f, 1.02157913e-01f, 3.37882414e-02f, -5.08012064e-02f, -2.54368479e-03f, -3.33349332e-02f, -5.22164889e-02f, -8.86750296e-02f, 2.41875350e-02f, -7.32749030e-02f,
  -2.24449933e-01f, 2.72982605e-02f, -1.48408627e-02f, 4.63015120e-03f, 1.76664554e-02f, 1.16284713e-01f, -1.06060840e-01f, 3.75580974e-02f, -5.82219288e-02f, 1.91490597e-03f,
  -4.48189154e-02f, -6.45673275e-02f, 4.37025167e-02f, 3.44415531e-02f, -1.84200648e-02f, -3.28505691e-03f, 1.13740429e-01f, -3.73652671e-03f, -3.76770720e-02f, -2.85934545e-02f,
  -1.18148578e-02f, 8.23422447e-02f, 1.94803849e-02f, 1.64156049e-01f, -3.29149626e-02f, -4.64290939e-02f, 2.38567013e-02f, -3.03894803e-02f, -2.10470371e-02f, 5.89886867e-02f,
  -1.12119272e-01f, -2.51825482e-01f, -1.33820653e-01f, 2.72903860e-01f, 7.75042623e-02f, 2.23320141e-01f, 1.27191737e-01f, 1.46306470e-01f, 2.13706613e-01f, -2.86181998e-02f,
  4.15454656e-02f, 5.44296904e-03f, 1.72279682e-02f, 5.83044766e-03f, 6.68113381e-02f, 2.28533477e-01f, 5.70284016e-02f, -9.58851427e-02f, 1.60255566e-01f, 1.24550469e-01f,
  -3.22981142e-02f, -2.26812810e-01f, -1.16816327e-01f, 2.38392707e-02f, -1.59299269e-01f, 4.12665866e-02f, -9.34137702e-02f, -3.35126132e-01f, -1.47283629e-01f, -3.29546481e-01f,
  -2.21879706e-01f, -4.33957875e-01f, 1.20667391e-01f, -6.06816225e-02f, 2.57308036e-02f, 4.04389091e-02f, -7.03954650e-03f, 7.90512636e-02f, 8.82960409e-02f, -2.37160027e-02f,
  3.60677652e-02f, -5.68523817e-02f, -1.17012430e-02f, -5.77473976e-02f, -4.80704866e-02f, -9.33066085e-02f, -8.80624205e-02f, -5.48462570e-02f, -2.33904291e-02f, -2.21678242e-02f,
  -1.12154484e-01f, -1.42218262e-01f, -8.72424841e-02f, -9.71609578e-02f, -1.18449263e-01f, -2.26424653e-02f, -1.26777828e-01f, -1.76382899e-01f, -8.95119533e-02f, -1.83327809e-01f,
  7.27900397e-03f, 6.27996447e-03f, -2.29642279e-02f, 1.55100478e-02f, 1.11506693e-02f, 4.12447713e-02f, 6.94884825e-03f, -9.72316507e-03f, 3.28880660e-02f, -8.52029920e-02f,
  3.67326871e-03f, 1.66115575e-02f, 7.92712793e-02f, 3.00592519e-02f, 1.27769858e-02f, -7.54764006e-02f, 1.08482637e-01f, -3.23060788e-02f, 8.10341984e-02f, -4.31948118e-02f,
  6.58890754e-02f, -3.33810933e-02f, -4.76865619e-02f, 4.88449410e-02f, -9.89526361e-02f, 7.07772374e-02f, 2.87748650e-02f, -7.24536628e-02f, -1.47152813e-02f, 2.84443740e-02f,
  1.45185664e-01f, 6.53429106e-02f, 1.34602830e-01f, 3.94363627e-02f, 6.31960556e-02f, 6.09311946e-02f, -5.63879982e-02f, -3.74924950e-02f, -3.94943133e-02f, 5.41412272e-02f,
  5.85885160e-03f, 8.64883587e-02f, -5.88559210e-02f, 2.36937683e-03f, -8.73992033e-03f, 1.45096648e-02f, 4.96563762e-02f, -8.20432615e-04f, 1.43050253e-01f, 3.77333127e-02f,
  5.00466265e-02f, 5.48857711e-02f, 1.28793359e-01f, 7.14036170e-04f, -7.70503432e-02f, 1.69719830e-01f, 8.40720534e-02f, 3.53374779e-02f, 2.13062420e-01f, 3.85475069e-01f,
  -5.69659114e-01f, 1.23351268e-01f, 4.11588848e-01f, -2.03224588e-02f, 2.84863979e-01f, 2.40748808e-01f, 4.26674724e-01f, 1.05883092e-01f, -1.94209769e-01f, 1.33749545e-01f,
  3.74812819e-02f, -2.37342834e-01f, -5.91091439e-02f, -3.83958369e-02f, 3.83609906e-02f, 3.23638767e-01f, 3.09171349e-01f, 9.82128009e-02f, -9.77127329e-02f, -7.84496367e-02f,
  5.31161651e-02f, -9.03596580e-02f, -2.31849432e-01f, -1.71571195e-01f, -1.13904022e-01f, -7.11096823e-02f, 9.27807018e-02f, -5.68795279e-02f, 8.40374753e-02f, 2.75190294e-01f,
  -5.16918488e-02f, 1.52147397e-01f, 8.70823935e-02f, -2.21346542e-01f, -4.30874433e-03f, -8.07369575e-02f, -6.53573573e-02f, -1.15140751e-01f, -7.33257756e-02f, 5.36550693e-02f,
  -2.46818308e-02f, -7.82203600e-02f, -1.56698465e-01f, -3.63739319e-02f, 4.72703343e-03f, -3.67384851e-02f, -1.13241397e-01f, -3.46729755e-02f, 1.02604292e-01f, 9.37176049e-02f,
  1.65778156e-02f, -4.77193110e-02f, -1.00798206e-03f, 5.57485111e-02f, 9.02923644e-02f, 1.21004283e-01f, 1.23444192e-01f, -5.74574396e-02f, 8.77039284e-02f, -1.65285151e-02f,
  4.38025706e-02f, 6.81186169e-02f, 3.96280102e-02f, -3.08240056e-02f, 4.05588467e-03f, -1.65748093e-02f, 3.47481412e-03f, 3.95082170e-03f, -4.72146496e-02f, -4.17463258e-02f,
  3.66821736e-02f, 4.14888896e-02f, -2.84525417e-02f, 2.20262147e-02f, 1.51926593e-03f, 4.51469757e-02f, -2.35139523e-02f, 6.93697631e-02f, -7.10203722e-02f, -2.83478424e-02f,
  -6.81969672e-02f, -1.01003861e-02f, -2.68726051e-02f, 3.12086437e-02f, 6.74347281e-02f, 5.15982844e-02f, 3.60973179e-02f, -3.61047126e-02f, 1.47270132e-03f, -5.47404662e-02f,
  -3.35858732e-01f, 2.33431399e-01f, 2.02821102e-02f, -4.77757007e-02f, -1.47325536e-02f, -2.77147405e-02f, 3.25106364e-03f, 4.90473630e-03f, -2.47251075e-02f, 5.80145195e-02f,
  1.18893526e-01f, 1.62658840e-02f, 8.31165612e-02f, 4.13569696e-02f, 5.58663569e-02f, -4.08918299e-02f, -1.26037532e-02f, -2.43968125e-02f, 4.15459163e-02f, 1.29232556e-01f,
  4.23260033e-02f, -6.38616597e-03f, -1.91693604e-01f, -6.18072413e-03f, -2.65078135e-02f, -4.53560539e-02f, 3.69280279e-02f, 1.28564714e-02f, -7.21828490e-02f, -6.21995926e-02f,
  3.03079575e-01f, -1.18797675e-01f, 2.09891155e-01f, -1.72040597e-01f, -2.06445903e-01f, 8.62210095e-02f, 6.44761473e-02f, -3.62334698e-02f, -2.00887799e-01f, -1.05047598e-01f,
  -9.21395347e-02f, -2.85671055e-01f, -2.01619372e-01f, -1.05715813e-02f, 1.88826293e-01f, 1.70242563e-02f, 2.57843956e-02f, 2.91507959e-01f, 3.63029391e-02f, -7.69883990e-02f,
  -9.00695100e-02f, -4.28743027e-02f, 1.88394591e-01f, -5.54271787e-02f, -1.89387333e-02f, -1.31913304e-01f, 5.17001264e-02f, 8.17197263e-02f, 6.54480457e-02f, -2.66530123e-02f,
  -2.08730623e-03f, 1.32777348e-01f, 1.05130393e-02f, -8.77318606e-02f, -1.21335126e-01f, 5.23672476e-02f, -9.69848260e-02f, -8.53154957e-02f, -3.74142379e-02f, -4.00282331e-02f,
  -1.14113383e-01f, -5.14906645e-02f, -4.41187136e-02f, -1.05222598e-01f, -4.30710800e-02f, -7.67476782e-02f, -1.56639978e-01f, 8.84222314e-02f, -3.91404144e-02f, -4.54106405e-02f,
  -1.76921979e-01f, 3.52385119e-02f, 4.44397070e-02f, 1.20181389e-01f, 2.11611204e-02f, -4.95641381e-02f, 8.04486126e-02f, 7.16574714e-02f, 5.67706153e-02f, 4.46893126e-02f,
  -1.28189728e-01f, 4.35577929e-02f, 1.14199435e-02f, -1.47756571e-02f, -8.97644460e-02f, -8.10211466e-04f, 4.63563502e-02f, 8.14655125e-02f, 1.38365895e-01f, 8.03442076e-02f,
  1.20822899e-01f, 1.13110125e-01f, 1.24680884e-01f, 1.85600426e-02f, 2.65316870e-02f, 8.72088596e-02f, 4.93588671e-02f, -1.62451472e-02f, 1.21024571e-01f, 1.47874802e-01f,
  1.04323953e-01f, 1.35322720e-01f, 3.16295438e-02f, 8.01813602e-02f, 9.47780088e-02f, 1.45044371e-01f, 4.79935780e-02f, 5.34054935e-02f, 1.13567607e-02f, 1.11031577e-01f,
  -3.72238398e-01f, 4.98574562e-02f, -1.43036112e-01f, -1.25486925e-01f, -1.01129338e-01f, -1.50109425e-01f, -3.03834826e-02f, -6.13356605e-02f, -7.80315325e-02f, -5.78317381e-02f,
  -7.44435489e-02f, -2.69989017e-02f, -8.52209926e-02f, 3.66463838e-03f, -7.53874555e-02f, -8.45501497e-02f, -9.33565125e-02f, 4.64478545e-02f, 1.25437966e-02f, -2.10537374e-01f,
  -2.55227592e-02f, 1.45400101e-02f, -4.90644537e-02f, -6.09767772e-02f, -3.38745192e-02f, -4.51572537e-02f, -1.30239978e-01f, -1.61274690e-02f, 3.94029580e-02f, -7.80214742e-02f,
  -3.57534260e-01f, -1.32754996e-01f, -2.72990137e-01f, -2.06510112e-01f, -1.13125809e-01f, 4.31619883e-02f, -1.43553630e-01f, 2.62753200e-02f, 6.20846190e-02f, -1.77862972e-01f,
  1.86315119e-01f, 3.68378699e-01f, 2.11180061e-01f, 1.76982373e-01f, 1.49508461e-01f, -2.67818958e-01f, -1.70718342e-01f, -1.06830791e-01f, 9.97660682e-02f, 5.15132770e-02f,
  -1.60213672e-02f, -2.38396600e-01f, -1.23206563e-01f, 3.75277270e-03f, -1.72714442e-01f, 8.33831877e-02f, -4.16452289e-02f, 4.49364297e-02f, 1.70342207e-01f, -3.99383098e-01f,
  -4.13221121e-02f, -9.63372290e-02f, -1.04934862e-02f, 5.37677966e-02f, -8.67254287e-02f, -4.17720191e-02f, -1.22914158e-01f, -8.56295526e-02f, 5.71248792e-02f, -9.46340486e-02f,
  1.28675578e-02f, 7.04239085e-02f, 8.87035765e-03f, -3.54459509e-02f, -6.62052631e-02f, -5.61770983e-02f, -3.47387008e-02f, -5.67937680e-02f, -5.05956672e-02f, -4.36128955e-03f,
  -3.06477845e-02f, 4.39025648e-03f, -3.97207066e-02f, 1.24668926e-01f, -3.21399234e-02f, 8.99642482e-02f, 1.90440137e-02f, 2.76630744e-02f, 7.54588917e-02f, -7.51766637e-02f,
  1.57603957e-02f, -7.79489726e-02f, 1.65996645e-02f, -5.50815545e-04f, 1.10528655e-02f, -2.73171980e-02f, 4.68286350e-02f, 8.48001391e-02f, 3.56818587e-02f, -4.37155403e-02f,
  4.44209538e-02f, -3.84863131e-02f, 6.07449096e-04f, -2.94260439e-02f, 5.70839196e-02f, -7.10950196e-02f, -5.99027611e-02f, 3.65557931e-02f, 2.88415551e-02f, -5.80512872e-03f,
  6.23770170e-02f, 4.09759916e-02f, -6.02008030e-03f, -6.57311175e-03f, 5.05086295e-02f, -1.30757913e-02f, 1.26106694e-01f, 8.17135870e-02f, 4.82421741e-02f, -1.87827405e-02f,
  -1.62571780e-02f, 2.25180164e-01f, -1.47948056e-01f, 1.33824693e-02f, -3.76125686e-02f, 7.17855291e-03f, -2.01718267e-02f, -4.47674915e-02f, -8.28808472e-02f, -5.41207893e-03f,
  1.10640883e-01f, -6.74766526e-02f, 1.25941932e-02f, -6.57383129e-02f, -5.29266484e-02f, -4.20060288e-03f, 1.03457563e-01f, 2.63789538e-02f, 9.40956250e-02f, -1.85179450e-02f,
  -2.74782516e-02f, -1.66511815e-02f, 4.03928980e-02f, -3.41306217e-02f, -1.20475953e-02f, 3.41211371e-02f, -1.00505501e-01f, -9.97559130e-02f, 5.55285485e-03f, -1.93577990e-01f,
  4.44455981e-01f, -1.07196867e-01f, 2.42992312e-01f, 1.76250950e-01f, 4.63571578e-01f, 2.46909738e-01f, 9.80956405e-02f, 6.75158277e-02f, 1.07997775e-01f, 1.14551440e-01f,
  -7.78272822e-02f, 1.03203692e-01f, 1.39076352e-01f, 6.24494068e-02f, 9.85195860e-02f, 3.56544219e-02f, 8.79203901e-02f, 8.14421102e-02f, 1.34536803e-01f, 2.15501964e-01f,
  1.57653049e-01f, 1.69746816e-01f, 2.31869090e-02f, -7.10682794e-02f, -4.38503036e-03f, -1.17754802e-01f, 8.46399218e-02f, 1.28745720e-01f, -3.99327390e-02f, 2.07570121e-01f,
  1.69005439e-01f, 1.88068345e-01f, 1.48111014e-02f, 1.24596536e-01f, 4.25784700e-02f, -8.92319009e-02f, 3.18249948e-02f, -1.02050111e-01f, -6.85361028e-02f, -1.43881124e-02f,
  2.64476445e-02f, -9.64499563e-02f, 7.73308054e-02f, 1.22914895e-01f, 3.47608589e-02f, 1.21158145e-01f, -6.23301826e-02f, 1.09440321e-02f, -7.64782131e-02f, -5.92118129e-02f,
  8.99597928e-02f, 4.26556692e-02f, 4.53537852e-02f, -8.07519257e-02f, 1.15716299e-02f, 7.96381906e-02f, 1.86888746e-03f, 9.05166939e-03f, 2.41278503e-02f, -2.69749537e-02f,
  4.08024378e-02f, 4.15231623e-02f, -2.46059033e-03f, -1.12485826e-01f, 1.47104710e-02f, -5.83196059e-02f, -2.05374174e-02f, 4.80226167e-02f, -6.14048541e-03f, -6.27674982e-02f,
  -1.18878074e-02f, -4.46645878e-02f, -5.92403766e-03f, -3.96276824e-02f, -5.22445552e-02f, 5.80233261e-02f, 5.54981874e-03f, -1.22763969e-01f, -7.53503758e-03f, -6.19810373e-02f,
  1.15289455e-02f, -1.10719316e-01f, -4.74045333e-03f, -1.08051218e-01f, -1.83015224e-02f, -5.73893031e-03f, 9.59559307e-02f, -2.79252511e-02f, 7.04475343e-02f, -2.34383624e-03f,
  1.08795566e-02f, 5.48994541e-02f, -8.02770555e-02f, -7.90509805e-02f, -4.68423910e-04f, -8.70248303e-02f, -3.87179703e-02f, -5.23599610e-02f, 5.54834902e-02f, 8.16189218e-03f,
  3.56771536e-02f, -6.25085086e-02f, 4.20701765e-02f, -9.73674059e-02f, 6.49248138e-02f, 7.01652793e-03f, 6.84977770e-02f, 1.01189725e-01f, -3.87212075e-02f, 4.30919006e-02f,
  1.22303357e-02f, -7.37592354e-02f, -4.95882705e-02f, 9.20510013e-03f, -1.31254300e-01f, 1.04360841e-01f, -4.44016755e-02f, -6.03241287e-02f, -7.98581690e-02f, -1.93246275e-01f,
  3.17548424e-01f, 5.26954651e-01f, -8.64203200e-02f, 9.52341408e-02f, -9.40876678e-02f, -2.76419699e-01f, -9.69529822e-02f, 4.45687883e-02f, -2.01664176e-02f, 2.12876365e-01f,
  1.41791701e-02f, 1.73362754e-02f, 4.48621325e-02f, -3.89760621e-02f, -8.77747834e-02f, 8.81846845e-02f, 6.43783584e-02f, -7.40255788e-02f, -3.07547629e-01f, -2.49158576e-01f,
  -1.11129358e-01f, -2.94639096e-02f, -3.37955393e-02f, 7.68431574e-02f, 2.54986435e-01f, -2.30908856e-01f, -2.82243006e-02f, 1.94929950e-02f, -1.05504580e-01f, 4.49907243e-01f,
  -1.03570804e-01f, 2.04990119e-01f, -2.14631453e-01f, 1.18082359e-01f, -5.83892390e-02f, -2.06132140e-02f, 4.35326733e-02f, 1.42839924e-01f, 4.88048308e-02f, 4.38969173e-02f,
  8.56469125e-02f, -8.21199864e-02f, 3.99378687e-02f, 7.09811151e-02f, 9.16722715e-02f, 4.04385477e-02f, 9.10015479e-02f, 1.12643272e-01f, 1.90875053e-01f, 3.44764218e-02f,
  -2.48996820e-02f, 9.84519813e-03f, 1.07059859e-01f, -5.55002689e-03f, -1.06499428e-02f, 7.84130394e-02f, 5.42866513e-02f, 5.57138324e-02f, -7.94596896e-02f, 2.62053628e-02f,
  2.12367307e-02f, -8.58644545e-02f, -3.00732125e-02f, -3.32891606e-02f, 4.95091639e-02f, 1.86307840e-02f, 6.31022155e-02f, -8.42629895e-02f, 6.24458157e-02f, 6.65218905e-02f,
  -5.56122288e-02f, -1.55259343e-02f, 2.64011472e-02f, 5.42150475e-02f, -1.66187773e-03f, 3.06500867e-02f, 1.49320988e-02f, 4.28161919e-02f, 7.28993639e-02f, 7.49249533e-02f,
  -4.21635108e-03f, -5.50850667e-03f, 1.80221051e-02f, -1.63371805e-02f, 7.96206519e-02f, -3.09784748e-02f, -5.35828583e-02f, 1.78253762e-02f, -6.62880465e-02f, -2.21490879e-02f,
  -1.51728496e-01f, 4.93888417e-03f, -2.67671831e-02f, -8.10132176e-02f, -1.33793224e-02f, 6.02442622e-02f, -8.43807459e-02f, 5.89441061e-02f, 3.79240774e-02f, -4.49913293e-02f,
  -1.16247095e-01f, -7.07933959e-03f, 5.18951006e-02f, -5.95921241e-02f, -7.58724809e-02f, -1.13864020e-01f, 7.21032992e-02f, 2.64795739e-02f, 4.61326689e-02f, 1.15498137e-02f,
  5.99681064e-02f, -2.19022289e-01f, -6.92719072e-02f, -8.62914324e-02f, -1.48200735e-01f, -2.04927638e-01f, -2.30938792e-01f, -1.28259987e-01f, -1.80581480e-01f, -1.36451751e-01f,
  6.15420818e-01f, -3.09626132e-01f, 2.34136403e-01f, 4.00520176e-01f, 2.28253305e-01f, 2.46726312e-02f, -2.01186359e-01f, -3.62176672e-02f, 3.36666591e-02f, -1.90073237e-01f,
  -9.93917212e-02f, -2.62435153e-02f, 3.79497721e-03f, -3.78435813e-02f, -1.24340139e-01f, -1.43183753e-01f, 1.67382956e-01f, 2.59444952e-01f, 3.53241205e-01f, 8.77554491e-02f,
  7.15316683e-02f, 3.29024225e-01f, 3.57988566e-01f, 1.32223099e-01f, -3.66449207e-02f, 1.46907657e-01f, 2.54889708e-02f, 9.90137085e-02f, -1.12217382e-01f, 1.93769321e-01f,
  -2.04392344e-01f, 1.29360840e-01f, 7.39511847e-02f, 1.18698776e-01f, 2.64737429e-03f, -3.71034741e-02f, 2.56098025e-02f, 8.18413049e-02f, -8.38655010e-02f, 3.77483815e-02f,
  4.85205799e-02f, -3.58650684e-02f, 1.32426322e-01f, 6.64537922e-02f, 1.07376710e-01f, -4.22435068e-02f, 3.76826711e-02f, -5.30696027e-02f, 3.30391191e-02f, -1.08086243e-02f,
  -3.22435312e-02f, 6.70976341e-02f, 1.09100072e-02f, -8.21486413e-02f, -1.87709890e-02f, 1.17270380e-01f, -7.30451271e-02f, -5.19697070e-02f, 4.31591906e-02f, -5.71733974e-02f,
  3.58961662e-03f, -2.82112695e-02f, 2.31196042e-02f, 3.87133360e-02f, -8.46351404e-03f, -5.71575426e-02f, -6.12915785e-04f, -6.24510311e-02f, 5.66767342e-02f, -3.46675925e-02f,
  -4.81796935e-02f, 2.35992316e-02f, -9.00572911e-02f, 3.26760001e-02f, 4.79524657e-02f, -1.59456879e-02f, -6.71708137e-02f, 5.56661338e-02f, 6.51057623e-03f, 1.66657791e-02f,
  7.63647025e-03f, 3.84216458e-02f, -1.47947725e-02f, -3.03793047e-02f, 3.65295261e-02f, -7.70860957e-03f, 6.16785586e-02f, -3.74074690e-02f, 2.72960458e-02f, 1.35792226e-01f,
  5.88656254e-02f, 6.88176006e-02f, 1.28821107e-02f, -6.48884401e-02f, 7.55351856e-02f, -1.17023572e-01f, 7.71664781e-04f, -5.75605482e-02f, -1.94612506e-03f, 6.04010969e-02f,
  -2.10951827e-02f, -3.93594354e-02f, -3.99834849e-02f, -8.34928080e-02f, -3.59693239e-03f, 3.15467566e-02f, -8.06009993e-02f, 3.05358581e-02f, -1.62014109e-03f, -8.72159526e-02f,
  -1.46656543e-01f, -5.56677505e-02f, -1.26534933e-02f, -5.99615797e-02f, -3.65458801e-02f, 7.84120411e-02f, -3.07258219e-02f, -7.25392774e-02f, -5.03886268e-02f, -2.38951832e-01f,
  2.96218306e-01f, 2.45008264e-02f, 3.02475512e-01f, -1.41283393e-01f, 9.84492823e-02f, 2.84284472e-01f, 4.29574400e-01f, -2.58508828e-02f, -2.38348588e-01f, 1.82822645e-01f,
  1.08869448e-02f, -1.55488312e-01f, -1.17352165e-01f, -1.46033010e-02f, 1.18178658e-01f, 3.42209965e-01f, 3.20657551e-01f, 3.02911848e-01f, 4.25569378e-02f, 1.01020634e-01f,
  -8.06571916e-02f, 2.01122239e-02f, 2.08218992e-02f, -1.06202267e-01f, -3.27909924e-02f, -1.03357315e-01f, -1.16587263e-02f, -7.35898614e-02f, -6.86864601e-03f, 1.89558089e-01f,
  2.01922119e-01f, -8.82574543e-03f, 1.45079002e-01f, 6.21447191e-02f, 1.53580055e-01f, 1.49639294e-01f, 6.88476488e-02f, 1.02929004e-01f, 2.59114858e-02f, 7.02563077e-02f,
  3.21089802e-03f, 6.50975779e-02f, 8.78536031e-02f, -1.68076325e-02f, 3.82943153e-02f, 6.83077127e-02f, 1.23582538e-02f, 4.88684624e-02f, 5.96434474e-02f, 4.98321801e-02f,
  1.33990556e-01f, 1.57237947e-02f, 1.23185568e-01f, 1.49004254e-02f, 6.43170550e-02f, 9.18943584e-02f, 1.02695283e-02f, -1.69961900e-02f, 1.36702180e-01f, 9.74606797e-02f,
  8.17934703e-03f, -7.42049282e-03f, -6.09050393e-02f, -8.48822445e-02f, -1.36738300e-01f, -7.18357340e-02f, -1.45573579e-02f, 2.50645634e-03f, -7.94691816e-02f, -7.61283189e-02f,
  -5.21136820e-02f, 5.31563759e-02f, -7.61097297e-02f, 1.20101320e-02f, -8.13509151e-03f, -6.26994222e-02f, 4.66919877e-02f, 4.41447385e-02f, -1.09179476e-02f, -1.59933250e-02f,
  -3.50593999e-02f, -3.59049030e-02f, -5.35087734e-02f, -3.39044817e-02f, 1.67174060e-02f, -3.72861922e-02f, -7.00476393e-02f, -9.81282368e-02f, -5.02636954e-02f, 4.64427583e-02f,
  -2.36082301e-01f, 2.34126508e-01f, 1.29255941e-02f, -3.38080572e-04f, 5.63629083e-02f, -1.21306265e-02f, 7.87583143e-02f, 4.91202017e-03f, 1.37286887e-01f, 3.83897796e-02f,
  -5.52253239e-02f, 4.82450835e-02f, 8.48393738e-02f, 2.36926824e-02f, 1.19339362e-01f, 4.34035547e-02f, -5.44610210e-02f, 1.18671414e-02f, 1.35127660e-02f, -4.27303575e-02f,
  -1.57217514e-02f, -1.45370485e-02f, 2.47792969e-03f, 4.33994234e-02f, -7.13200541e-03f, 1.41959324e-01f, 7.00554624e-02f, -1.61377396e-02f, 1.19992025e-01f, 1.01362161e-01f,
  -2.24739492e-01f, 1.56047419e-01f, -2.21889745e-02f, -4.80527058e-02f, 9.38420519e-02f, -9.50290337e-02f, 1.58078000e-01f, -2.19419599e-02f, -1.18704066e-01f, 3.66749346e-01f,
  1.61137193e-01f, 1.52244374e-01f, 8.74763578e-02f, 1.37783766e-01f, 7.95984939e-02f, 2.98269421e-01f, 1.26901016e-01f, 2.17596889e-02f, -5.10540791e-02f, 6.60282522e-02f,
  1.30161643e-01f, 4.18769419e-02f, -9.77130905e-02f, 8.95596389e-03f, 2.30826616e-01f, 1.72079071e-01f, 1.42507525e-02f, 6.62951916e-02f, 1.56758711e-01f, 5.47312915e-01f,
  2.27899134e-01f, -1.33423477e-01f, 1.16943598e-01f, 3.71572040e-02f, -1.72132552e-02f, -3.68294567e-02f, 2.34538633e-02f, -4.13091183e-02f, -5.64837903e-02f, 8.08553249e-02f,
  8.68990347e-02f, 7.11524766e-03f, -1.04013294e-01f, 7.26882294e-02f, -3.03755440e-02f, 3.17479335e-02f, -5.52194044e-02f, 2.31976304e-02f, -3.90052944e-02f, 4.06624004e-02f,
  2.05381867e-02f, 6.01560175e-02f, 2.41360199e-02f, 1.73311289e-02f, -6.73657730e-02f, -6.78064972e-02f, 7.43631050e-02f, 1.08570486e-01f, -7.49276653e-02f, 2.91270584e-01f,
  -7.59061705e-03f, -2.50811949e-02f, -1.73397318e-01f, 5.03932592e-03f, -7.60429129e-02f, 1.15362387e-02f, -1.06078103e-01f, 8.26333091e-02f, 2.09982526e-02f, 4.21021953e-02f,
  -3.45225334e-02f, -1.86843015e-02f, -7.61161521e-02f, 2.95285806e-02f, 1.00909382e-01f, -5.49487434e-02f, 8.15067068e-03f, 7.65210688e-02f, 4.22119461e-02f, 5.34106903e-02f,
  5.67407720e-02f, -1.63810570e-02f, -2.42481679e-02f, -1.06856428e-01f, 5.07425866e-04f, -2.88142469e-02f, -4.13513184e-02f, -5.28678782e-02f, -5.92734553e-02f, -4.22014557e-02f,
  -6.87143207e-02f, -9.46577638e-03f, 1.89546704e-01f, 7.75258690e-02f, -1.36704501e-02f, -4.63916734e-03f, 9.90889315e-03f, -3.24292034e-02f, -1.18186750e-01f, 2.47689728e-02f,
  4.58218306e-02f, -3.45768407e-02f, -3.82517539e-02f, -2.54848953e-02f, -1.67069510e-02f, 3.03242244e-02f, 7.27432519e-02f, 1.37931168e-01f, 9.13613215e-02f, -4.30491380e-02f,
  -1.59364585e-02f, 2.08977997e-01f, 1.31692365e-01f, 1.03353560e-01f, 4.31517921e-02f, 1.06643680e-02f, 8.44201148e-02f, 1.48747697e-01f, -9.95532982e-03f, 1.69992298e-01f,
  -7.25675523e-02f, -1.08468402e-02f, -3.44401449e-02f, -2.12526284e-02f, 1.28893450e-01f, 3.82823497e-02f, -4.82895114e-02f, 3.54886129e-02f, 1.73760746e-02f, -1.69018656e-01f,
  -5.57425879e-02f, 1.08695202e-01f, 2.62185894e-02f, -3.06284986e-02f, 4.95210588e-02f, -1.32264286e-01f, -1.70079470e-02f, 6.32641017e-02f, -3.57702933e-02f, 1.22051746e-01f,
  -4.11366113e-02f, -1.12988494e-01f, -3.08410581e-02f, 1.16193220e-02f, 6.73259497e-02f, 3.17673050e-02f, -1.64419234e-01f, 5.04157096e-02f, 1.65770069e-01f, 1.07111245e-01f,
  -9.41232368e-02f, 2.24862635e-01f, 7.97746852e-02f, 1.43146604e-01f, 6.30872548e-02f, 1.13113500e-01f, 6.35014549e-02f, 1.01141073e-01f, 8.85471329e-02f, 6.60142526e-02f,
  7.76019022e-02f, 8.08684081e-02f, 1.88957259e-01f, 9.25854817e-02f, 7.54212141e-02f, 9.89124030e-02f, 1.00919195e-01f, 4.93477657e-02f, 4.03299369e-02f, -2.69170683e-02f,
  1.09996814e-02f, 1.72561303e-01f, 1.28745943e-01f, 4.08621654e-02f, 1.44600913e-01f, 1.62464127e-01f, 2.71141026e-02f, 2.00039044e-01f, 1.62964851e-01f, -1.79826021e-02f,
  2.83175668e-05f, -1.08572640e-01f, -7.59539232e-02f, -1.20762408e-01f, -1.91243347e-02f, -1.03699021e-01f, -1.11639109e-02f, -1.62307113e-01f, -1.23482041e-01f, -9.65279415e-02f,
  3.91070358e-02f, -1.06162600e-01f, -1.02716558e-01f, -3.02291308e-02f, -8.57364982e-02f, 2.31758412e-03f, 5.74919842e-02f, -6.40189275e-02f, -2.44290736e-02f, 6.32439777e-02f,
  4.63107079e-02f, 2.93667279e-02f, -1.22997180e-01f, 4.41662297e-02f, -2.41426788e-02f, 7.67576247e-02f, 6.99625462e-02f, 2.25519855e-02f, -2.81117298e-03f, 3.18278670e-02f,
  -3.33869725e-01f, 2.09941626e-01f, 2.33961884e-02f, 8.87764469e-02f, 2.83855069e-02f, 3.99895310e-02f, -6.31290907e-03f, -1.08394660e-02f, 4.62944545e-02f, 4.82368190e-03f,
  1.35081649e-01f, -6.08205348e-02f, 3.06990631e-02f, 6.12333529e-02f, -5.30194119e-03f, 3.86999398e-02f, 5.21603134e-03f, -5.20855486e-02f, 9.36410204e-02f, -3.84832285e-02f,
  -6.33650199e-02f, -1.23220637e-01f, -1.43440619e-01f, -1.32752627e-01f, 4.69689295e-02f, -6.75633550e-02f, -5.14000319e-02f, -6.51495457e-02f, -2.28361506e-02f, -3.34766537e-01f,
  1.30616784e-01f, 5.41253164e-02f, -1.72812061e-03f, 9.43319276e-02f, 3.38966548e-02f, -1.14571080e-01f, -1.05965868e-01f, -1.12888239e-01f, -6.35514483e-02f, 6.72078803e-02f,
  1.56902492e-01f, 5.28070778e-02f, 8.78973305e-02f, 3.66978087e-02f, -4.05247808e-02f, -2.15354115e-02f, 4.43651974e-02f, 9.10958499e-02f, -1.69681385e-01f, -2.09582344e-01f,
  -1.99207254e-02f, 1.57560725e-02f, -4.02119532e-02f, -8.81804377e-02f, 1.78142086e-01f, -7.88278580e-02f, 2.90819611e-02f, 1.46029800e-01f, 3.52783240e-02f, 2.98771560e-01f,
  2.34925494e-01f, 2.70698398e-01f, -2.54240148e-02f, 1.06502073e-02f, 2.88035236e-02f, -5.42022474e-02f, 9.34571102e-02f, 2.96099409e-02f, 4.90184911e-02f, -1.29446003e-03f,
  1.61035791e-01f, 6.21771030e-02f, 7.87952095e-02f, -1.67952273e-02f, -1.70447268e-02f, -1.35155827e-01f, -7.07391500e-02f, -2.89556254e-02f, -4.19491939e-02f, -1.50904758e-02f,
  6.71445765e-03f, 1.39225051e-01f, 7.04390407e-02f, -1.37370452e-01f, -1.13983952e-01f, 7.41867274e-02f, -6.73545301e-02f, 2.44927090e-02f, -1.69699535e-01f, -6.37127683e-02f,
  -7.32842758e-02f, -6.14818968e-02f, -4.43112515e-02f, -3.03335879e-02f, 4.54927236e-02f, 3.83500196e-02f, 4.10966836e-02f, 1.13468198e-02f, -9.49725807e-02f, -4.78866659e-02f,
  -5.00567183e-02f, -5.55023402e-02f, 2.41428167e-02f, 2.45089363e-03f, 1.91705127e-03f, -1.87276653e-03f, -2.32049562e-02f, 6.85079768e-02f, -1.78367905e-02f, 2.71435659e-02f,
  -4.85688597e-02f, -9.51100234e-03f, 5.70315728e-03f, -6.25176728e-02f, 2.10932991e-03f, -4.42371443e-02f, -3.23641934e-02f, -3.58094387e-02f, -1.54788550e-02f, -5.11617884e-02f,
  -9.59455818e-02f, -9.51720625e-02f, 1.47263974e-01f, 6.38921559e-02f, 5.11302762e-02f, -3.91650125e-02f, 6.95119053e-02f, 2.32065823e-02f, -1.18866293e-02f, -2.13919859e-03f,
  2.72429478e-03f, 7.70018175e-02f, 1.21678732e-01f, -1.51683062e-01f, -1.57297775e-01f, -1.22511089e-01f, -5.32795787e-02f, -9.37556326e-02f, -1.33749798e-01f, -5.57476841e-02f,
  -1.25646770e-01f, -1.20713413e-01f, -1.49815679e-01f, -3.17262895e-02f, 2.41492763e-02f, 7.45656788e-02f, -1.30265057e-01f, -5.37936315e-02f, -8.92010406e-02f, -2.99283981e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.50863588e-01f, -2.79317379e-01f, 1.95688024e-01f, -4.02038723e-01f, 1.50930032e-01f, 1.53909311e-01f, -3.98020118e-01f, -3.11060786e-01f, -7.04280138e-02f, -2.69946009e-01f,
  1.20067142e-01f, 2.39167243e-01f, -1.70955230e-02f, 1.31125852e-01f, -2.68830270e-01f, -2.57013440e-01f, -4.29460593e-02f, 8.04813579e-02f, 1.06620498e-01f, 1.97166353e-01f,
  -4.44031917e-02f, -9.85987186e-02f, 5.01897372e-02f, 5.80826476e-02f, -2.69332588e-01f, -1.97953954e-02f, 6.47649765e-02f, -9.51609481e-03f, 1.97371706e-01f, -1.20566040e-01f,
  1.76959366e-01f, -2.19457865e-01f, 1.88692182e-01f, 1.49897262e-01f, 2.30217755e-01f, -1.60485044e-01f, -3.16663384e-02f, 5.96620329e-02f, 1.24036200e-01f, 3.50533500e-02f,
  1.12130068e-01f, 1.55622736e-01f, -1.14059895e-01f, 9.55964066e-03f, 4.28732224e-02f, -7.44844899e-02f, 2.06368551e-01f, -6.94475323e-02f, -3.57918628e-02f, 2.72266157e-02f,
  1.96398661e-01f, 1.41313761e-01f, -1.06641173e-01f, -1.46373017e-02f, -1.66387156e-01f, 2.65510697e-02f, -1.44681975e-01f, 3.65018798e-03f, -2.38196086e-02f, -5.14110148e-01f,
  2.10759435e-02f, 7.16604888e-02f, 5.39555103e-02f, -1.09837115e-01f, -6.48722276e-02f, -5.45901917e-02f, 8.44345093e-02f, 7.21859708e-02f, -2.75585782e-02f, -1.33020073e-01f,
  6.35450035e-02f, -1.69880595e-02f, 1.17604941e-01f, -1.13083169e-01f, 1.34821132e-01f, 1.07367150e-02f, 1.53399827e-02f, 3.49203013e-02f, 6.06720196e-03f, 3.36857736e-02f,
  -3.55569683e-02f, 7.81049281e-02f, -5.43610901e-02f, 3.00133117e-02f, 6.40766099e-02f, 2.61077043e-02f, -9.79570299e-02f, -1.06319934e-01f, -1.29137248e-01f, -9.58550572e-02f,
  -3.66250068e-01f, 3.69058251e-01f, -1.83136865e-01f, -8.14989954e-02f, 6.36664778e-02f, 5.54886870e-02f, -1.42225958e-02f, 1.09838985e-01f, 5.74809276e-02f, -1.35065481e-01f,
  1.40287252e-02f, -7.41589665e-02f, -1.63795933e-01f, -4.20730598e-02f, -1.15943499e-01f, -4.44356836e-02f, -5.27444221e-02f, -9.64689478e-02f, 2.71308143e-02f, 3.16542126e-02f,
  -7.10002482e-02f, -1.73706606e-01f, -3.59838396e-01f, -2.77934968e-01f, -3.17864269e-02f, -1.33700699e-01f, -2.35340074e-01f, -1.34736642e-01f, -3.63793939e-01f, -6.93090379e-01f,
  -4.42273855e-01f, 2.25615334e-02f, 1.29514530e-01f, 1.82114273e-01f, 1.19172111e-01f, -3.05097967e-01f, -5.16247511e-01f, -3.86172146e-01f, -1.08879507e-01f, 1.18066572e-01f,
  1.62354335e-01f, 1.65410697e-01f, 1.62670895e-01f, -3.93681340e-02f, -4.35918450e-01f, -2.30329558e-01f, -1.66007370e-01f, -2.54257917e-01f, -3.52588177e-01f, -2.16601163e-01f,
  1.87281184e-02f, -5.69392405e-02f, -2.39741981e-01f, -1.71677306e-01f, 4.94822174e-01f, 3.00398886e-01f, 2.82808185e-01f, 1.67822182e-01f, 9.09457803e-02f, 4.27311361e-01f,
  4.86401469e-01f, -6.60619289e-02f, -4.44776900e-02f, -4.66450006e-02f, 2.36715645e-01f, -4.35442775e-02f, -4.60988469e-03f, 3.96422632e-02f, 8.63776878e-02f, 5.02238758e-02f,
  1.73230335e-01f, 7.05682812e-03f, 3.60001512e-02f, 1.20815195e-01f, 2.66155694e-02f, -1.09949872e-01f, -1.15270698e-02f, -1.85482264e-01f, -5.74443676e-02f, 2.24074766e-01f,
  1.82673573e-01f, 4.50116582e-02f, 5.99352270e-02f, -1.43670157e-01f, -1.68243363e-01f, 7.59392753e-02f, -1.32368095e-02f, -6.70338720e-02f, -1.22975618e-01f, 1.43942207e-01f,
  -7.17528537e-02f, 3.52634788e-02f, 7.73380846e-02f, -1.19553711e-02f, -6.83690757e-02f, 2.25636992e-03f, 2.36335602e-02f, -7.60693045e-04f, -4.82300110e-02f, -8.06243792e-02f,
  1.22606233e-01f, -9.83470306e-03f, 1.86705533e-02f, -1.85270701e-02f, 5.26173487e-02f, 5.18364795e-02f, -3.62705928e-03f, -5.33591304e-03f, 1.34073095e-02f, -2.51355413e-02f,
  -1.49965743e-02f, -4.25313525e-02f, 6.95083439e-02f, -5.89954630e-02f, -3.22754197e-02f, -5.93241975e-02f, -9.75859817e-03f, -4.93326038e-02f, -3.41985226e-02f, -1.82150980e-03f,
  2.28852063e-01f, -1.35264128e-01f, 1.96752444e-01f, 3.16267088e-02f, -5.17580565e-03f, 7.51502290e-02f, 2.07005963e-01f, -3.25578302e-02f, 1.66716203e-01f, 6.86482787e-02f,
  -3.45592201e-02f, 3.39913890e-02f, 4.67075594e-02f, 1.39562622e-01f, -3.39365155e-02f, 4.92481589e-02f, -5.17329462e-02f, 9.14517194e-02f, -2.23666448e-02f, 1.26318842e-01f,
  -8.72469097e-02f, -4.16766144e-02f, -1.33810610e-01f, -7.73040205e-02f, 1.00637451e-01f, 7.69932568e-03f, 1.72127441e-01f, 5.30352667e-02f, -6.09587617e-02f, -6.32915348e-02f,
  7.91102469e-01f, 4.64718997e-01f, 5.02095759e-01f, 1.68328777e-01f, -4.09897119e-02f, 1.29831076e-01f, 1.83588378e-02f, -5.10256402e-02f, -1.02061793e-01f, 7.26186931e-02f,
  3.21571112e-01f, 1.49912387e-01f, 7.04161003e-02f, 8.37561339e-02f, 1.77345648e-01f, -1.52864650e-01f, -2.08151087e-01f, 1.11292429e-01f, 1.65953055e-01f, 8.47714022e-02f,
  -2.13028014e-01f, -4.73662391e-02f, 2.43350089e-01f, -7.70758465e-02f, -2.46793464e-01f, -8.35142881e-02f, 9.44285169e-02f, 6.62959218e-02f, 1.56324103e-01f, -2.89849102e-01f,
  7.64642954e-02f, 3.83088708e-01f, -1.36606932e-01f, -8.66801813e-02f, 1.98118705e-02f, -1.55933518e-02f, -6.94672614e-02f, -4.76502860e-03f, -2.78760847e-02f, -5.05172238e-02f,
  2.66891345e-02f, -4.25930470e-02f, -3.65404971e-02f, -1.67549914e-03f, 7.57430270e-02f, 4.62464569e-03f, 5.21434061e-02f, 7.97419176e-02f, 4.82029766e-02f, 2.58261058e-02f,
  5.08726723e-02f, 1.07625075e-01f, 7.88794383e-02f, 4.31463383e-02f, 2.05275297e-01f, 9.10100713e-02f, 1.79887697e-01f, 3.25415358e-02f, 1.92909300e-01f, 6.58681616e-02f,
  2.12299265e-02f, -4.60755918e-03f, 3.32964659e-02f, -6.35529263e-03f, 5.07658795e-02f, -1.07126132e-01f, 7.59674683e-02f, 2.77606528e-02f, -3.29124518e-02f, 2.57687699e-02f,
  7.77635276e-02f, 1.41595557e-01f, 9.45663005e-02f, 2.86921673e-02f, 1.30927518e-01f, 1.16131753e-01f, -1.65365160e-01f, 9.80115160e-02f, 1.40783697e-01f, -5.88578247e-02f,
  9.97973010e-02f, -2.03176774e-02f, 7.22525269e-02f, -1.77705530e-02f, 4.00579311e-02f, 6.17703833e-02f, 8.93972740e-02f, 3.40443058e-03f, 5.59263602e-02f, -1.26589268e-01f,
  -3.04223180e-01f, 4.04360533e-01f, -1.23533905e-01f, -1.32748736e-02f, -1.38426013e-03f, -2.45319884e-02f, 2.03902632e-01f, -3.72299366e-02f, 7.00803623e-02f, -5.71434200e-02f,
  1.18559236e-02f, 1.25780359e-01f, 1.29109681e-01f, 2.17905026e-02f, -3.15589234e-02f, 5.64286001e-02f, 2.25864984e-02f, -5.58316633e-02f, 3.42766009e-02f, -6.77056089e-02f,
  2.41507962e-02f, -6.98726624e-02f, -9.00046080e-02f, -6.05621412e-02f, -8.31293073e-05f, -3.66089381e-02f, -1.02829118e-03f, -7.48076364e-02f, -8.27809330e-03f, -1.20876074e-01f,
  -1.04273848e-01f, -6.45105243e-02f, 9.55945775e-02f, -2.51002293e-02f, -1.05471864e-01f, -4.05304909e-01f, -4.03627932e-01f, -2.53857583e-01f, -7.46483281e-02f, 1.29494369e-02f,
  -2.09025621e-01f, -4.28504758e-02f, 1.50229499e-01f, 1.60899147e-01f, 4.37034480e-02f, 9.09184366e-02f, 3.76275301e-01f, 4.84836906e-01f, 1.78843830e-02f, 4.61103320e-02f,
  1.35080799e-01f, 1.14596993e-01f, 6.29717633e-02f, -1.34707959e-02f, 8.24149027e-02f, -6.06825389e-02f, -6.83742613e-02f, 8.72141942e-02f, 6.74749911e-02f, 5.94687462e-01f,
  2.31301904e-01f, 2.46197693e-02f, -7.08771423e-02f, -8.41286853e-02f, 8.89806151e-02f, 2.45068856e-02f, 1.21484022e-03f, 1.52615637e-01f, 3.79443057e-02f, 1.06497303e-01f,
  -5.50371967e-02f, 5.00735305e-02f, -7.21097738e-02f, -5.40962927e-02f, -1.68169498e-01f, -6.05529994e-02f, 7.38280788e-02f, 1.44196197e-01f, 6.72431514e-02f, 1.33746147e-01f,
  1.15588039e-01f, -1.86147094e-01f, -2.14154735e-01f, -1.14786439e-01f, 7.99386390e-03f, 1.19675599e-01f, -2.62028813e-01f, 5.51648438e-02f, -6.64278194e-02f, 1.13554493e-01f,
  -2.24248618e-02f, 4.09806632e-02f, 4.46438827e-02f, 1.69893473e-01f, -2.10751705e-02f, -1.03430867e-01f, 1.64125219e-01f, -5.70486039e-02f, -4.92313504e-02f, 1.31644299e-02f,
  -2.30476633e-02f, 4.25729118e-02f, 3.91237549e-02f, -1.19856698e-02f, 4.07408103e-02f, 4.84006219e-02f, 2.34128591e-02f, 5.40864021e-02f, -2.17950623e-03f, 5.95017150e-02f,
  -4.90629561e-02f, 3.94238867e-02f, -1.90868601e-02f, 1.71505094e-01f, 4.50201929e-02f, 1.01524375e-01f, 9.73206684e-02f, 7.39365593e-02f, -8.58373418e-02f, -2.08437014e-02f,
  -2.13618785e-01f, -2.74413880e-02f, 3.51113118e-02f, -6.63634017e-02f, 1.20916165e-01f, -1.31484857e-02f, 6.12455495e-02f, 3.88204679e-02f, -2.37196106e-02f, -6.94052801e-02f,
  4.61684028e-03f, -6.78021610e-02f, 1.95840616e-02f, -1.64437875e-01f, 2.32122298e-02f, 3.91358398e-02f, -6.09381311e-02f, -1.46348417e-01f, -4.72073331e-02f, -2.35169847e-02f,
  -3.06048431e-02f, -1.79701462e-01f, -3.55584294e-01f, -1.37494832e-01f, -1.66249409e-01f, -2.06234530e-01f, -1.25801906e-01f, -1.62609622e-01f, -2.38019332e-01f, -3.42504352e-01f,
  -3.94193977e-01f, -2.04911426e-01f, -6.73675835e-01f, 1.29232138e-01f, 7.81781077e-02f, 8.45216364e-02f, 7.84109384e-02f, 4.96084616e-02f, 1.20166495e-01f, 8.79535377e-02f,
  9.76209491e-02f, 2.12577134e-01f, 1.69984937e-01f, 1.44532666e-01f, -9.56814457e-03f, 5.53144701e-02f, 2.30261400e-01f, -4.32419069e-02f, -3.49689350e-02f, 1.83552399e-01f,
  3.28444242e-01f, 3.27345096e-02f, -2.70876318e-01f, -7.48031912e-03f, 3.35582763e-01f, 1.56998202e-01f, -5.22162691e-02f, -3.80645655e-02f, -1.29072636e-01f, 1.71250999e-01f,
  -1.80252999e-01f, -8.91430750e-02f, -9.76784378e-02f, 4.81415391e-02f, -7.14950934e-02f, -1.82940066e-01f, -1.37430921e-01f, -2.53750175e-01f, -4.31165509e-02f, -7.22090388e-03f,
  -2.63800342e-02f, -5.41512296e-03f, 1.82729959e-01f, 4.80761938e-02f, -1.34412780e-01f, -9.33446735e-02f, 1.99797433e-02f, -1.07747577e-01f, -2.98068323e-03f, -1.28233256e-02f,
  3.74017239e-01f, 7.62551427e-02f, -1.37658507e-01f, 6.54639900e-02f, 4.74649109e-02f, 5.26269712e-03f, 4.05183509e-02f, 1.32484347e-01f, -2.48234227e-01f, 6.11581765e-02f,
  2.46317908e-01f, -2.27074735e-02f, -8.07431340e-03f, -7.40169287e-02f, 1.89721406e-01f, 2.07997754e-01f, 2.03062091e-02f, 9.21898335e-02f, -1.51556190e-02f, -4.52991948e-02f,
  6.40572831e-02f, -4.26063426e-02f, 1.12226292e-01f, 1.16477478e-02f, 5.07433303e-02f, -1.31549686e-01f, 5.43443561e-02f, -1.33308560e-01f, 4.19606979e-04f, -1.00125661e-02f,
  -1.06965601e-01f, -9.41544399e-02f, -1.49750695e-01f, 2.36803398e-01f, -2.30444949e-02f, 5.67687228e-02f, -3.56319710e-03f, 1.04148529e-01f, 4.89891088e-03f, -6.80665672e-02f,
  -1.76732913e-01f, -1.94779009e-01f, 1.12708099e-01f, -3.82132828e-02f, -7.85964429e-02f, -7.39800408e-02f, -1.08875996e-02f, 1.34846689e-02f, -9.84107777e-02f, -1.29936397e-01f,
  -1.40196338e-01f, -4.84761000e-02f, -1.60540670e-01f, -5.72279543e-02f, 3.06455065e-02f, -9.85186398e-02f, 5.78639209e-02f, 1.92699775e-01f, -7.73786381e-02f, -9.16456580e-02f,
  -5.25758900e-02f, -1.49124429e-01f, -1.43396124e-01f, -7.23675266e-02f, -1.84332117e-01f, 5.73436022e-02f, 6.93672821e-02f, -1.34210110e-01f, -3.17515045e-01f, -1.55664757e-01f,
  -2.89305776e-01f, 2.54644841e-01f, 2.71573424e-01f, 3.30389827e-01f, 2.30955556e-01f, 1.85533836e-01f, 3.66805226e-01f, 2.39011914e-01f, 8.24183077e-02f, 6.70011565e-02f,
  -6.51090220e-02f, 4.99465317e-02f, -3.94114293e-02f, 2.08954379e-01f, 1.78939894e-01f, 3.81687045e-01f, 3.29764992e-01f, 1.46390840e-01f, 3.31285745e-02f, 7.69539252e-02f,
  1.92728229e-02f, -2.18028706e-02f, -7.11678863e-02f, 1.09821558e-01f, 2.94799805e-01f, -1.81000289e-02f, 1.07330538e-01f, 1.68246120e-01f, 9.81972665e-02f, 3.85815978e-01f,
  2.26459444e-01f, 1.30595893e-01f, -5.10491803e-02f, -5.71727417e-02f, 3.21467295e-02f, -3.84469815e-02f, -9.89954993e-02f, -5.42722158e-02f, -1.61252677e-01f, -7.45621622e-02f,
  -9.46481992e-03f, -1.79550990e-01f, 5.43096364e-02f, -1.34131312e-01f, -3.02750766e-02f, -5.19526489e-02f, -3.10147572e-02f, 6.86480897e-03f, 2.00386733e-01f, 5.73595017e-02f,
  -3.15197483e-02f, -1.91040754e-01f, -2.16048025e-02f, 2.50621792e-03f, 5.02997302e-02f, -1.57534868e-01f, -7.87600577e-02f, -1.04423068e-01f, 2.32104980e-03f, -9.18525904e-02f,
  -4.49054018e-02f, 8.72575566e-02f, 4.26382609e-02f, -7.52873868e-02f, -1.14729933e-01f, -1.12740315e-01f, 8.60282630e-02f, 7.51879960e-02f, -3.37567404e-02f, -1.35687888e-01f,
  -1.65850714e-01f, -1.42661231e-02f, 1.08729482e-01f, -9.60821062e-02f, 3.43320295e-02f, -5.71793765e-02f, 1.13073505e-01f, 2.21465416e-02f, -8.54019970e-02f, -5.30266911e-02f,
  2.23765406e-03f, 2.07493275e-01f, -2.41638627e-02f, 9.53203291e-02f, -6.73965961e-02f, 4.45923880e-02f, 1.13265431e-02f, -9.08138454e-02f, -5.51772602e-02f, -1.09188482e-01f,
  3.28902096e-01f, 5.83484694e-02f, 2.91528106e-02f, 1.09749578e-01f, 2.61717103e-02f, -8.68595764e-02f, 8.97244141e-02f, -5.07606789e-02f, 4.85777035e-02f, 1.64071649e-01f,
  8.48609135e-02f, 1.50812715e-01f, 4.12958264e-02f, -7.77839571e-02f, -1.77913383e-01f, -6.68803230e-02f, -1.89558379e-02f, 2.10417747e-01f, 8.54382515e-02f, 3.96768562e-02f,
  3.34485471e-02f, -5.23310117e-02f, -8.63078982e-02f, -3.31632085e-02f, 6.62767962e-02f, -3.54446955e-02f, -1.45570219e-01f, -4.87256870e-02f, 1.19302586e-01f, -1.44934237e-01f,
  1.04399645e+00f, -3.87008160e-01f, -3.34199846e-01f, 2.38286823e-01f, -2.11780071e-01f, -3.80069427e-02f, -3.17394137e-01f, -3.64534147e-02f, 8.54567215e-02f, -2.96909273e-01f,
  6.58970773e-02f, 2.98602045e-01f, 1.95253670e-01f, 1.70346856e-01f, 2.09522426e-01f, -3.58662933e-01f, -3.34390342e-01f, 9.77983773e-02f, 3.77850562e-01f, 1.15247212e-01f,
  -7.90674314e-02f, -1.18444338e-01f, 1.27423674e-01f, 1.74977422e-01f, -2.56239891e-01f, 3.14460248e-02f, -4.41009641e-01f, -1.83830574e-01f, -1.27511486e-01f, -4.30543423e-01f,
  1.09181352e-01f, 2.09059101e-02f, 2.11681873e-01f, 1.15504906e-01f, -5.79255149e-02f, 1.03438824e-01f, 4.74728234e-02f, -4.76889126e-02f, 5.11687696e-02f, 6.42575324e-02f,
  7.81419277e-02f, -1.06445521e-01f, -9.86411497e-02f, -6.44454286e-02f, -2.84400862e-02f, 2.39705276e-02f, -5.36586009e-02f, 8.26328546e-02f, 6.87997937e-02f, -2.45666895e-02f,
  -1.16956234e-01f, 1.96456369e-02f, 3.14651355e-02f, 4.90800552e-02f, 1.07200630e-01f, 1.03501193e-01f, -1.52625456e-01f, 1.67020652e-02f, 1.06836081e-01f, -1.77398697e-01f,
  1.09049855e-02f, 1.73667837e-02f, 5.77835776e-02f, 3.68480720e-02f, 2.77348813e-02f, -3.15774195e-02f, 2.72255205e-02f, 5.62165603e-02f, 1.59686282e-02f, -5.39409332e-02f,
  -1.24056175e-01f, 4.62108403e-02f, 6.80901110e-02f, -4.04949039e-02f, -8.83816555e-02f, -2.94148363e-02f, 7.80487657e-02f, 1.66130345e-02f, 3.07717249e-02f, -2.36927271e-02f,
  5.75735383e-02f, 7.82640651e-03f, -8.41231197e-02f, -4.81088832e-02f, -6.73791915e-02f, -5.91545552e-02f, 6.21925630e-02f, -2.93340720e-02f, -9.74756107e-02f, -9.50409174e-02f,
  1.06116578e-01f, 9.24150348e-02f, -6.83768168e-02f, -1.47357387e-02f, -6.85305744e-02f, -4.21694368e-02f, -1.94716863e-02f, 3.85808460e-02f, 4.37755585e-02f, -1.62612330e-02f,
  8.88569281e-02f, 1.08273260e-01f, -7.56819546e-02f, -3.86422947e-02f, 1.18016362e-01f, 7.72920996e-02f, -4.96249907e-02f, 1.04438581e-01f, 1.52649879e-01f, 8.85384530e-02f,
  -1.28749713e-01f, 2.73237247e-02f, 2.51334250e-01f, 7.26443157e-02f, -1.68905705e-02f, 2.50854254e-01f, 8.63329973e-03f, -1.05291763e-02f, 1.72756359e-01f, -1.83546484e-01f,
  -1.94653422e-01f, -4.26559985e-01f, 5.38609803e-01f, -2.40249008e-01f, -5.45566045e-02f, -1.29824787e-01f, -2.15580568e-01f, -2.74819285e-01f, -2.77005970e-01f, -2.13186055e-01f,
  -2.49676600e-01f, -2.92576198e-02f, 1.12034805e-01f, 1.14652686e-01f, -2.65386906e-02f, 7.84731284e-02f, 1.43402413e-01f, 4.90544975e-01f, 5.53041756e-01f, 5.65339290e-02f,
  7.15785548e-02f, 2.14188263e-01f, 2.18482018e-01f, 6.67788833e-02f, -9.79650468e-02f, 1.50346622e-01f, 1.35646567e-01f, -8.38039145e-02f, -4.52217571e-02f, -1.09418027e-01f,
  3.29514474e-01f, -4.72127557e-01f, 2.07015295e-02f, -1.97309941e-01f, 7.85143971e-02f, -6.77116215e-02f, 5.33012487e-02f, -1.28626123e-01f, -1.73318788e-01f, -2.04314440e-02f,
  -1.47652805e-01f, -7.35013485e-02f, 6.68525556e-03f, 4.44735400e-02f, 4.00364362e-02f, -8.60972330e-02f, -9.82469227e-03f, -2.91833691e-02f, 5.72171472e-02f, -3.98397781e-02f,
  -1.29396021e-01f, -5.68571091e-02f, 2.94477330e-03f, 4.92336862e-02f, -2.03459561e-01f, 8.72090906e-02f, -5.12766428e-02f, -1.61133796e-01f, -3.09416428e-02f, -2.31932506e-01f,
  2.76356619e-02f, 1.95254479e-02f, -3.99768874e-02f, 5.57901710e-02f, 3.36062126e-02f, -6.52763918e-02f, 1.22585125e-01f, -1.43076498e-02f, -7.67263472e-02f, 6.16340302e-02f,
  -2.50236988e-02f, -5.59165888e-03f, 3.70805971e-02f, -1.20278485e-02f, -1.77375972e-02f, -3.76466140e-02f, -2.13288027e-03f, -9.32971295e-03f, 3.03532882e-03f, 4.31630649e-02f,
  -4.98625040e-02f, -1.90423504e-02f, -1.26986287e-03f, -1.55076711e-03f, -8.65120664e-02f, 4.80616419e-03f, 2.73643602e-02f, 1.80271675e-03f, 5.87796457e-02f, -5.10583669e-02f,
  2.20569715e-01f, 5.01924828e-02f, -3.65937594e-03f, -7.68436641e-02f, 2.06329636e-02f, -1.47437394e-01f, -9.25429817e-03f, -6.73004426e-03f, -1.63531750e-02f, -2.69728135e-02f,
  -6.46148324e-02f, -1.53576452e-02f, 1.94882199e-01f, -5.83149642e-02f, 1.23142675e-01f, -7.37504289e-02f, -5.63655123e-02f, 7.01044276e-02f, 6.02659397e-02f, -5.25347292e-02f,
  -9.39666778e-02f, -1.18965402e-01f, 1.52226835e-01f, 1.32665142e-01f, 2.86366534e-03f, 1.37268052e-01f, 1.60369530e-01f, 9.10124555e-02f, 1.39896989e-01f, -1.17824059e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.06919819e-01f, 1.89667046e-01f, 1.16309792e-01f, 1.10650994e-01f, 1.08499704e-02f, -1.40268788e-01f, 1.85802490e-01f, 3.64512533e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.76446599e-03f, -1.11300685e-01f, 2.10905984e-01f, -1.79880988e-02f, 7.60827586e-02f, 1.05127327e-01f, -2.07322165e-01f, -4.01472822e-02f, 1.07627533e-01f, 2.79606804e-02f,
  -3.48586515e-02f, 1.03292547e-01f, -1.39904767e-01f, 2.61077404e-01f, -3.08294654e-01f, -2.29251340e-01f, -1.05521522e-01f, 1.80862814e-01f, -5.92755228e-02f, 1.22608200e-01f,
  1.31051093e-01f, 8.07594359e-02f, -3.89867544e-01f, 1.54765591e-01f, -5.59413552e-01f, -6.42359629e-02f, 1.06310338e-01f, -1.76656917e-02f, 3.45821977e-02f, 1.50027990e-01f,
  -5.37975281e-02f, 4.30953614e-02f, -3.53721641e-02f, 1.04724087e-01f, -1.51910931e-01f, 5.04985489e-02f, -6.70097619e-02f, 5.90957738e-02f, 3.57951969e-02f, 1.55196846e-01f,
  -2.69235093e-02f, -2.72737741e-01f, 9.71444547e-02f, 1.01483002e-01f, 4.41513993e-02f, -1.63789955e-03f, -1.14710599e-01f, -1.15287177e-01f, 3.22290748e-01f, 4.24839482e-02f,
  -3.43468487e-01f, 8.35136324e-02f, -1.32004559e-01f, -1.74492449e-01f, 1.46942347e-01f, -1.52085915e-01f, 1.08093187e-01f, -2.54344672e-01f, 2.71122843e-01f, -1.55162320e-01f,
  1.39117409e-02f, -1.22067943e-01f, 3.47387195e-01f, 3.03434759e-01f, 1.21147454e-01f, 3.50583643e-02f, 1.24209762e-01f, 9.63430405e-02f, -8.52788612e-02f, -3.00805317e-03f,
  1.10739335e-01f, -1.16264969e-01f, 3.11231524e-01f, 1.67822510e-01f, 5.69022335e-02f, 1.23723783e-01f, 2.27867775e-02f, 2.20954791e-01f, 4.59974885e-01f, 1.54184788e-01f,
  7.37870410e-02f, 7.54532171e-03f, -2.33253062e-01f, 3.13086063e-01f, 9.25131440e-02f, -2.38480434e-01f, -4.88658473e-02f, -8.00703093e-02f, 6.17918968e-02f, -4.92977947e-01f,
  1.85996160e-01f, -6.65836111e-02f, -1.46526396e-01f, 1.05992839e-01f, 1.81401268e-01f, 5.57579696e-02f, 5.30064516e-02f, 1.62013814e-01f, -2.43671253e-01f, 8.02945793e-02f,
  2.30319649e-01f, -5.34992181e-02f, 1.78829923e-01f, 4.78489660e-02f, 1.17889695e-01f, -2.09205039e-03f, -9.76918787e-02f, 1.88256487e-01f, -6.72364086e-02f, 1.43889040e-01f,
  -2.46276557e-02f, -1.77377298e-01f, 1.29818723e-01f, 7.25407228e-02f, -3.02615017e-01f, -9.46642384e-02f, -8.98742974e-02f, 1.77674681e-01f, -9.61408243e-02f, 4.86215465e-02f,
  1.57041594e-01f, -1.22067243e-01f, 1.87314954e-02f, -1.40195921e-01f, 4.96959120e-01f, -2.82973200e-02f, -1.57148212e-01f, 2.80742701e-02f, -1.37620181e-01f, 1.03210248e-01f,
  1.51717022e-01f, 6.43226318e-03f, 1.19357422e-01f, -5.69979995e-02f, 8.11472684e-02f, -1.56082436e-01f, -6.00278340e-02f, 2.88267117e-02f, 2.38637105e-02f, -4.88969013e-02f,
  1.27020385e-02f, -1.85763016e-01f, 3.10942009e-02f, 4.19531986e-02f, 9.17499438e-02f, -1.10242881e-01f, 2.41807669e-01f, -3.86330783e-02f, 5.49405962e-02f, -4.28073816e-02f,
  1.68850645e-01f, -8.29885527e-02f, 3.97794008e-01f, -1.30229801e-01f, -3.91648076e-02f, -3.69395941e-01f, -2.03899771e-01f, 1.31056290e-02f, -3.26531082e-01f, -2.41927102e-01f,
  7.10973665e-02f, 1.16377212e-01f, -5.39598048e-01f, 3.89537890e-03f, 2.24162415e-01f, -1.10226788e-01f, 1.19359605e-02f, 9.21316072e-02f, -5.51093072e-02f, 1.75152987e-01f,
  -8.78142938e-02f, -1.18248671e-01f, -4.04817387e-02f, 2.99076855e-01f, -1.33068571e-02f, -6.50904402e-02f, -1.25989094e-01f, -6.23608008e-02f, 4.41758940e-03f, -1.57015741e-01f,
  2.46256381e-01f, 8.20663571e-02f, -1.21702656e-01f, -1.26478642e-01f, -4.56592500e-01f, -2.54709870e-01f, 1.00120134e-03f, -2.92954206e-01f, -5.19344471e-02f, 1.56338751e-01f,
  2.30817422e-02f, -5.69150783e-02f, -1.40550330e-01f, 3.89778949e-02f, -1.54218197e-01f, -2.08154172e-02f, 5.46498522e-02f, -1.29481465e-01f, 6.79260343e-02f, 1.02309436e-01f,
  -9.20759048e-03f, -2.03810483e-01f, -8.29256922e-02f, 1.43232523e-02f, -7.23534748e-02f, 1.08208716e-01f, -7.98689276e-02f, -2.01516181e-01f, 1.32973060e-01f, 5.30347088e-03f,
  5.27871959e-02f, -7.19979852e-02f, -1.25086099e-01f, 4.21163701e-02f, 1.43669583e-02f, 7.81267211e-02f, 1.40848801e-01f, 2.64542580e-01f, -6.85386583e-02f, -1.99826643e-01f,
  4.84081417e-01f, 1.75180271e-01f, 2.05431990e-02f, -3.69766563e-01f, 1.94623306e-01f, -1.01323120e-01f, 2.03330338e-01f, 1.73927750e-02f, -1.78439945e-01f, 1.99820638e-01f,
  -2.47702748e-01f, 5.98073043e-02f, -6.28793761e-02f, -4.05451283e-02f, 7.69253746e-02f, -9.13096964e-02f, 1.57861739e-01f, -2.65033513e-01f, 1.10846378e-01f, 1.09936722e-01f,
  -1.53207242e-01f, 1.53369516e-01f, -5.98696247e-02f, 1.32467076e-01f, 1.30441800e-01f, 2.15439349e-01f, 1.45414218e-01f, 4.37813066e-02f, 1.33557647e-01f, 9.83112231e-02f,
  -1.28977612e-01f, 1.37509525e-01f, -1.30493149e-01f, 3.80885266e-02f, 1.61833227e-01f, 2.22054154e-01f, 1.87618241e-01f, -1.15601324e-01f, 1.02785364e-01f, 1.52681082e-01f,
  6.06799982e-02f, 7.75633603e-02f, -4.19960320e-02f, -1.89202577e-01f, 1.00329280e-01f, 8.62084925e-02f, 3.19955163e-02f, 3.95664833e-02f, 3.08814365e-02f, 6.39002472e-02f,
  -4.16252166e-02f, -1.43681869e-01f, -2.29898676e-01f, 2.31397375e-01f, -1.29790097e-01f, 2.50793844e-01f, 3.87782492e-02f, 1.70893505e-01f, -1.84969068e-01f, -8.54781866e-02f,
  -1.89266175e-01f, 2.47423127e-01f, -2.52069503e-01f, 2.99738407e-01f, 1.93502530e-01f, 2.10605949e-01f, -1.44464478e-01f, 2.85997003e-01f, 5.25564030e-02f, -1.13759130e-01f,
  -1.12068281e-01f, 2.98693124e-02f, -6.08050972e-02f, 8.42641853e-03f, 4.93463725e-02f, 1.00304104e-01f, -5.57531696e-03f, 8.74050893e-03f, 6.81339428e-02f, -1.17517091e-01f,
  1.29041880e-01f, -1.63361475e-01f, 3.83581638e-01f, 1.19235165e-01f, -4.50699106e-02f, 1.60033226e-01f, -7.04084635e-02f, 2.48488992e-01f, 1.36604253e-02f, -1.51032776e-01f,
  1.36691973e-01f, -1.26080541e-02f, 6.88691884e-02f, -6.86580390e-02f, 6.84898272e-02f, 2.63013363e-01f, 5.35368919e-03f, 1.82496101e-01f, 8.59786496e-02f, -1.21804878e-01f,
  -2.84574609e-02f, 9.91428867e-02f, -8.22055712e-03f, 7.50791430e-02f, -7.12490007e-02f, -7.38060623e-02f, -1.94073655e-03f, -1.59364104e-01f, -7.52875879e-02f, -8.62498730e-02f,
  1.49108991e-02f, 5.70316762e-02f, -7.12447464e-02f, 6.86738566e-02f, -2.72199392e-01f, 3.60567793e-02f, 2.02411070e-01f, -3.15671772e-01f, -1.56023934e-01f, -4.04279411e-01f,
  -1.26411244e-01f, -4.01416309e-02f, 7.06251860e-02f, -2.77185291e-01f, 6.26953468e-02f, -2.00530794e-02f, -7.60138482e-02f, -7.41456598e-02f, 4.29266132e-02f, 7.25689679e-02f,
  3.54271352e-01f, 1.06428333e-01f, -4.93935728e-03f, -9.25540030e-02f, -5.19767962e-02f, -1.71906073e-02f, -1.62212163e-01f, 1.98997378e-01f, -9.50721428e-02f, 1.48939148e-01f,
  -1.14939995e-01f, -4.69516106e-02f, -1.72244757e-02f, -4.38647121e-02f, 3.12384721e-02f, -5.01731038e-01f, -9.36413258e-02f, 8.46017003e-02f, -8.64824578e-02f, 1.95406377e-01f,
  2.70777792e-01f, -6.02943748e-02f, -9.21594501e-02f, -4.57863212e-02f, 1.13194197e-01f, 2.79939651e-01f, 2.29689069e-02f, -1.83988418e-02f, 1.78827927e-01f, 8.83347839e-02f,
  1.50819197e-01f, 2.89406121e-01f, -6.65018857e-02f, -3.67920578e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.20829633e-02f, -2.09992796e-01f, -3.37913394e-01f, 8.86575878e-02f, 3.70696187e-02f, -4.90453467e-03f, -2.31988877e-01f, 3.19805205e-01f, 9.32131708e-02f, 2.10421413e-01f,
  5.12077697e-02f, 7.95363486e-02f, -1.85157210e-01f, -1.52387872e-01f, -4.40994576e-02f, -1.70109808e-01f, -6.13086931e-02f, 3.22151780e-01f, 3.46439838e-01f, 2.07681134e-01f,
  1.06699593e-01f, 1.65956169e-01f, 1.43047884e-01f, 2.00215697e-01f, 1.23983119e-02f, -9.66450498e-02f, -8.37975144e-02f, 4.65728760e-01f, 3.32213372e-01f, 2.34094739e-01f,
  -2.44512454e-01f, -2.21957892e-01f, 3.79534140e-02f, 1.18851833e-01f, -1.87456563e-01f, 1.60742514e-02f, -1.82257276e-02f, -1.28733218e-01f, 1.83730409e-01f, 4.08841789e-01f,
  -6.21582195e-03f, 1.42022476e-01f, 5.51302396e-02f, 2.15380207e-01f, -1.21630356e-02f, 1.74724881e-03f, 3.25978518e-01f, 4.35437374e-02f, 5.63722670e-01f, -1.09367803e-01f,
  -3.89111370e-01f, 2.19300255e-01f, 8.29068646e-02f, -1.38253570e-01f, 3.13197494e-01f, 1.23629518e-01f, 4.16629612e-01f, -4.13582534e-01f, 1.55080244e-01f, -2.03831613e-01f,
  3.19823086e-01f, 3.95866692e-01f, 2.15513721e-01f, 2.43231609e-01f, 2.06190541e-01f, 9.73060168e-03f, 4.54982758e-01f, 2.34007791e-01f, 2.27135301e-01f, 1.74606562e-01f,
  -1.10179313e-01f, -4.82367836e-02f, 1.63614571e-01f, -2.23055501e-02f, -1.78361312e-01f, -8.17679018e-02f, -9.61734951e-02f, -9.80163068e-02f, 1.15991153e-01f, -1.29352108e-01f,
  3.61695349e-01f, -1.80714250e-01f, 1.31208256e-01f, -3.85420024e-01f, -9.90761667e-02f, 6.31190017e-02f, -1.71331301e-01f, 8.85947570e-02f, 1.17874242e-01f, 4.34441388e-01f,
  1.95615858e-01f, -1.34686589e-01f, -1.47818297e-01f, -9.81615037e-02f, -4.18894500e-01f, 3.95773679e-01f, 2.86479622e-01f, 7.10886866e-02f, 1.80689156e-01f, 2.85952449e-01f,
  3.60352211e-02f, -1.28221437e-01f, 2.04685524e-01f, -1.51175678e-01f, 4.37218025e-02f, 1.73609465e-01f, -1.30779482e-03f, 1.91233709e-01f, 1.97166145e-01f, -4.62408006e-01f,
  9.21633482e-01f, 9.50591043e-02f, 1.62050352e-02f, 5.57908230e-02f, 2.27296054e-01f, 6.03422701e-01f, -8.87809601e-03f, -2.31108367e-01f, 1.46732688e-01f, -1.98012561e-01f,
  5.06368816e-01f, 1.01403892e-01f, 1.36890367e-01f, 3.62387806e-01f, -2.40327165e-01f, -1.31031647e-01f, -6.45044267e-01f, 1.61275253e-01f, -7.70851225e-02f, 1.47403419e-01f,
  5.81198605e-03f, 1.44934356e-01f, -3.89900766e-02f, -1.99480101e-01f, 3.72894913e-01f, -1.48592070e-02f, 2.10715532e-01f, -1.76970810e-01f, 1.14787452e-01f, 1.35464996e-01f,
  -1.86211273e-01f, -3.48882824e-02f, 1.38515253e-02f, 7.85978734e-02f, 1.52210444e-01f, -2.40699157e-01f, -2.47978151e-01f, -2.43781090e-01f, -4.06926796e-02f, -9.03057307e-02f,
  5.62481880e-02f, -4.99654785e-02f, 2.09824905e-01f, 8.06528106e-02f, 1.65246092e-02f, -1.97285905e-01f, 2.39269391e-01f, -3.02047461e-01f, 2.37033367e-01f, -4.24523473e-01f,
  -1.93300191e-02f, 1.68680951e-01f, 5.05604744e-01f, -8.25786777e-03f, 3.28524351e-01f, -2.55535156e-01f, -1.98966891e-01f, -1.37737051e-01f, -1.56278998e-01f, -4.82825845e-01f,
  9.52547267e-02f, 7.70499259e-02f, -2.02238947e-01f, -1.03131264e-01f, -2.25434318e-01f, -5.60359545e-02f, 3.11703682e-01f, -7.64727071e-02f, -9.63246599e-02f, -4.64200079e-01f,
  -1.36378109e-01f, 2.45231926e-01f, 1.19670853e-01f, 1.29573405e-01f, 1.45949349e-01f, 2.50115752e-01f, -2.33404085e-01f, 4.31311829e-03f, 6.59270287e-02f, -3.11616898e-01f,
  -3.34406763e-01f, -6.04555011e-03f, 1.03918448e-01f, 1.28342733e-01f, -1.45865530e-01f, 7.38722607e-02f, 2.26840422e-01f, -9.48836133e-02f, 2.57063180e-01f, 1.72587186e-01f,
  6.84450986e-03f, 3.49355727e-01f, 9.05687809e-02f, 1.49814337e-01f, -8.16727653e-02f, 6.10461123e-02f, 3.01234610e-02f, 5.84486723e-02f, -1.06426150e-01f, -1.41566247e-01f,
  1.55929163e-01f, -1.72998160e-02f, 1.70582384e-01f, -2.07122475e-01f, -1.22131884e-01f, 2.41323821e-02f, -5.02911627e-01f, -1.69315487e-01f, 2.74380863e-01f, -5.74605048e-01f,
  -1.25855103e-01f, 4.59475480e-02f, 2.45881975e-01f, -1.33607253e-01f, 1.35090649e-01f, 1.17273428e-01f, 3.19675863e-01f, 4.29866239e-02f, 3.26592118e-01f, 1.30913872e-02f,
  3.30444127e-01f, -1.72733262e-01f, 2.49613196e-01f, 4.82989728e-01f, 7.76640102e-02f, -1.61551178e-01f, 5.98679855e-02f, -1.89613864e-01f, 3.86699498e-01f, -1.22262262e-01f,
  3.03420108e-02f, -1.41192243e-01f, 2.94485927e-01f, 1.03257202e-01f, 5.13748974e-02f, -2.95431137e-01f, -3.30081172e-02f, 4.60080728e-02f, 3.45672071e-01f, 3.68076324e-01f,
  2.61105504e-02f, 2.93697387e-01f, -2.67819107e-01f, -2.10348979e-01f, -3.54547292e-01f, 1.78356215e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.22028984e-01f, 3.25669982e-02f, 3.38891685e-01f, 2.29635864e-01f, 8.03847089e-02f, 2.95600981e-01f, 2.20038578e-01f, 2.08740339e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.99793303e-01f, -1.65896177e-01f, -1.00661799e-01f, 1.16730658e-02f, 3.15489667e-03f, 6.89948499e-02f, 4.48138751e-02f, 2.61512637e-01f, 1.98670700e-01f, 1.47813275e-01f,
  -1.50277819e-02f, 1.19358469e-02f, -1.75909474e-01f, -5.82175478e-02f, -1.01434872e-01f, 2.13527247e-01f, 9.53088462e-01f, -2.84501642e-01f, 2.31652036e-01f, -1.92106023e-01f,
  -4.16281849e-01f, -1.23048380e-01f, -2.89633796e-02f, 4.86181341e-02f, -6.03849925e-02f, 3.31865437e-02f, 2.41655976e-01f, 1.23147286e-01f, 3.00101459e-01f, 3.19451720e-01f,
  2.83361554e-01f, 1.45355821e-01f, -6.45697862e-03f, -6.61951005e-02f, 1.79408878e-01f, -4.55241650e-02f, -4.46269922e-02f, -1.84235930e-01f, -2.84644246e-01f, 6.83606192e-02f,
  2.84717102e-02f, -7.27936998e-02f, -8.44018906e-02f, -6.44502342e-02f, -1.96230620e-01f, 1.61865111e-02f, 1.67266905e-01f, -1.15715779e-01f, -2.72190124e-01f, 2.06574231e-01f,
  -3.20356160e-01f, 2.46067941e-01f, 2.96051562e-01f, 1.34342387e-01f, -3.63529734e-02f, -3.74068730e-02f, 2.04454839e-01f, 2.62463450e-01f, 1.30934030e-01f, 2.64434516e-01f,
  -4.35947329e-01f, -3.69436368e-02f, -1.79457366e-01f, -1.22632213e-01f, 1.06367551e-01f, -9.45906714e-02f, -6.64152354e-02f, 3.34256515e-02f, 4.48048800e-01f, 2.33488515e-01f,
  -1.28534481e-01f, -3.65529880e-02f, -9.84450243e-03f, -1.25376388e-01f, -6.56020194e-02f, -9.60069671e-02f, 2.29011893e-01f, 3.88742308e-03f, 7.25572631e-02f, 1.01092309e-02f,
  9.97958705e-02f, 1.96623817e-01f, 2.31049687e-01f, -2.66397417e-01f, -2.40475088e-01f, 1.83863305e-02f, -3.75555128e-01f, 2.54846066e-01f, 9.25640017e-02f, 1.46553934e-01f,
  -1.03972621e-01f, -3.48450214e-01f, 1.34270400e-01f, -1.23630896e-01f, 2.62923390e-01f, -1.54243708e-01f, 3.58652994e-02f, -1.83250271e-02f, -5.22111431e-02f, 5.88218756e-02f,
  5.16862929e-01f, -9.53104571e-02f, 1.61068812e-01f, -2.72603095e-01f, -1.75896674e-01f, -5.92630357e-02f, 2.71789283e-01f, -3.47693145e-01f, 2.79597044e-01f, -1.52442381e-01f,
  5.60508609e-01f, 1.86176568e-01f, 2.57786792e-02f, -5.30512072e-02f, -5.70941627e-01f, -1.32941622e-02f, 1.78344339e-01f, -1.58923149e-01f, -2.59629250e-01f, 1.77040622e-02f,
  -1.94406331e-01f, -2.79477984e-01f, 1.39472932e-01f, 8.90944302e-02f, -1.71546593e-01f, -1.47209302e-01f, 2.52183732e-02f, 3.24832737e-01f, 2.78260976e-01f, -1.62555218e-01f,
  8.99989828e-02f, 2.05200419e-01f, -8.25261325e-02f, -2.84361899e-01f, 2.07994461e-01f, -4.27575186e-02f, -3.02620698e-02f, -6.80033341e-02f, 5.10236733e-02f, 8.14160481e-02f,
  6.50763288e-02f, -1.89739585e-01f, 2.33729675e-01f, -1.32795393e-01f, -1.07072234e-01f, 2.49551758e-01f, 2.64513433e-01f, -7.52153248e-02f, -2.14551479e-01f, 3.96514058e-01f,
  -1.87469587e-01f, 6.15418628e-02f, 1.84702784e-01f, -7.47829676e-02f, -3.66580844e-01f, 1.98641375e-01f, -8.56090859e-02f, -4.66220051e-01f, -1.87373683e-01f, 1.69739082e-01f,
  -5.33992499e-02f, 4.07414734e-02f, 2.14504689e-01f, 4.33292314e-02f, -2.01546997e-02f, -1.56707484e-02f, 3.03249538e-01f, 1.31261617e-01f, -1.61904201e-01f, 1.34670317e-01f,
  1.10840738e-01f, 2.23972276e-01f, -2.37420619e-01f, -1.33804902e-01f, -5.28955460e-01f, 1.69042960e-01f, 3.19456577e-01f, -6.29893839e-02f, 2.68902004e-01f, -4.18172002e-01f,
  3.47842351e-02f, -4.13908124e-01f, 1.23646788e-01f, -1.40507042e-01f, 1.47777349e-01f, -5.31442873e-02f, 7.42969662e-02f, -1.40938863e-01f, -8.66531432e-02f, 5.32976449e-01f,
  -1.73304409e-01f, 1.88394129e-01f, -6.34727105e-02f, 2.30285563e-02f, 1.89922288e-01f, -2.97992617e-01f, -7.32667670e-02f, 7.71359950e-02f, -5.58733165e-01f, -8.37943107e-02f,
  -3.27531248e-01f, -2.76875407e-01f, -2.79963225e-01f, -1.43750802e-01f, 2.96905518e-01f, 3.33662927e-01f, 1.26592100e-01f, -1.18091544e-02f, -1.09609477e-01f, -3.24963629e-01f,
  -8.22785720e-02f, 1.01548195e-01f, -3.41744572e-02f, 2.12383971e-01f, 4.27333191e-02f, -1.24623934e-02f, 1.11477837e-01f, 1.15766764e-01f, -2.05055073e-01f, -6.67189434e-02f,
  2.13753536e-01f, -1.93312496e-01f, 4.77202833e-02f, -3.98082078e-01f, 5.94165269e-03f, -4.13417928e-02f, -1.67102441e-01f, 7.67166391e-02f, -2.21797466e-01f, 3.71620841e-02f,
  3.29407632e-01f, 2.54406273e-01f, 4.52171415e-02f, -2.52397358e-01f, -1.71349779e-01f, 6.93350509e-02f, -1.89402178e-01f, 3.10532842e-02f, -5.82405865e-01f, -4.69067879e-02f,
  -1.40578344e-01f, -9.81453657e-02f, 5.05861461e-01f, -1.08291119e-01f, -2.88933143e-02f, -1.92114606e-01f, 3.75498682e-01f, 2.23677710e-01f, 4.18708026e-02f, -6.70899302e-02f,
  2.35410616e-01f, -2.83181846e-01f, -3.01215611e-02f, 4.51703191e-01f, -3.89986098e-01f, 1.06662400e-01f, -3.10301185e-01f, 4.03131656e-02f, -2.02073082e-01f, 8.09645727e-02f,
  -3.92971560e-02f, 2.39791155e-01f, -2.68802971e-01f, 2.25824922e-01f, 3.13772321e-01f, -2.00954542e-01f, -1.50239378e-01f, 2.02622131e-01f, -2.25490928e-01f, 4.06867355e-01f,
  2.14390978e-01f, 9.39275697e-02f, 4.06775206e-01f, -1.11529142e-01f, 2.50223856e-02f, -1.26310457e-02f, -2.10110068e-01f, -3.11168283e-01f, 2.79166340e-03f, -2.01571107e-01f,
  -2.29948848e-01f, 2.34643683e-01f, -1.31198958e-01f, 1.62171945e-01f, 2.31730789e-01f, 2.87035167e-01f, 2.01903526e-02f, -8.37276429e-02f, 1.48663893e-01f, -1.01863846e-01f,
  3.21061790e-01f, 3.03529855e-02f, 1.59155607e-01f, -1.98700190e-01f, -3.41974527e-01f, 8.89285803e-02f, -4.39162523e-01f, -2.79410034e-01f, 1.98170748e-02f, -2.22455263e-01f,
  2.23705113e-01f, -3.49243402e-01f, -3.61236632e-01f, -1.80618614e-02f, -2.68976897e-01f, -3.02091390e-01f, 4.13739145e-01f, 8.09616819e-02f, 1.66823417e-01f, 2.74174690e-01f,
  -1.03185020e-01f, 4.80032623e-01f, 3.85336757e-01f, -2.11475402e-01f, -1.10167161e-01f, -1.04674146e-01f, -4.59436998e-02f, 1.65864583e-02f, -3.48352849e-01f, 8.02492127e-02f,
  1.28554761e-01f, 3.01380694e-01f, 1.46396859e-02f, 8.84369463e-02f, 1.53563572e-02f, -2.43633941e-01f, 2.23651845e-02f, 2.81454086e-01f, -2.04263598e-01f, -1.96958371e-02f,
  1.53093204e-01f, 4.85359997e-01f, -3.55775177e-01f, 3.03587299e-02f, -3.21963400e-01f, 2.97958434e-01f, 1.29673667e-02f, -4.00620222e-01f, 3.59095573e-01f, 7.32349604e-02f,
  1.26245841e-01f, -1.26297876e-01f, 4.42760050e-01f, 3.70144509e-02f, -1.68313622e-01f, -2.21215844e-01f, 1.16301633e-01f, 6.90755099e-02f, 5.47021218e-02f, 1.50528461e-01f,
  -3.67281854e-01f, 1.77805796e-01f, 2.50115544e-01f, 4.12293896e-02f, 2.11570293e-01f, 6.49676248e-02f, 2.66144961e-01f, -1.94694847e-01f, -3.42483997e-01f, -1.20713063e-01f,
  -2.56208777e-02f, -2.52114385e-01f, 2.25991219e-01f, -3.20218831e-01f, 2.51590818e-01f, -6.72484115e-02f, -6.18212819e-02f, -2.34469965e-01f, -1.34981915e-01f, -2.27475032e-01f,
  -1.57184407e-01f, 3.06887507e-01f, 1.69554681e-01f, 2.61300921e-01f, 9.31407809e-02f, 1.81781128e-01f, 9.01470333e-02f, -6.44673333e-02f, 2.70545870e-01f, 1.35416463e-02f,
  -1.19315073e-01f, 4.96119969e-02f, -2.43910417e-01f, 1.68549657e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -4.86061901e-01f, -3.72473806e-01f, -1.22417569e-01f, -9.64997634e-02f, 1.24665014e-01f, 2.48629883e-01f, -6.58675209e-02f, 2.72227734e-01f, -2.43908212e-01f, 1.84054613e-01f,
  -1.80906445e-01f, 3.85492027e-01f, -1.96446721e-02f, 2.39708841e-01f, 1.40336871e-01f, 5.66628039e-01f, -3.27813715e-01f, 5.36798984e-02f, 4.59539779e-02f, -1.93892151e-01f,
  -4.24251258e-02f, -1.83396608e-01f, -4.70215306e-02f, -3.27508330e-01f, 4.36346650e-01f, 4.08251315e-01f, -7.00612783e-01f, -2.65323102e-01f, 3.11321825e-01f, 3.12332101e-02f,
  -1.20347463e-01f, -4.47960943e-01f, 4.77498025e-01f, 6.19981706e-01f, 2.90540487e-01f, 1.26444384e-01f, 3.49896848e-01f, 1.18733764e-01f, 2.41178468e-01f, 2.98379380e-02f,
  -8.30765516e-02f, -1.93180963e-01f, 3.71909976e-01f, 4.75011617e-02f, 1.61752537e-01f, 1.66584179e-01f, -3.86818759e-02f, 4.08987850e-01f, -3.55913609e-01f, 3.67410094e-01f,
  -3.70583266e-01f, 3.64561044e-02f, 5.71064115e-01f, -5.74699521e-01f, 1.93657964e-01f, -3.97375584e-01f, -4.91059780e-01f, -6.24531925e-01f, 4.64199454e-01f, -2.10794240e-01f,
  -2.68372267e-01f, 3.00508350e-01f, -6.42567202e-02f, -9.91173461e-03f, 2.66374290e-01f, 1.14316881e-01f, 2.11139917e-01f, 3.28197479e-01f, -1.02046557e-01f, 4.03412059e-02f,
  -4.22454238e-01f, 2.56288320e-01f, 2.26109505e-01f, 1.25781491e-01f, 8.63870457e-02f, -1.05390280e-01f, 2.56435335e-01f, -7.81889334e-02f, 4.35719371e-01f, -3.84683460e-01f,
  -8.12542215e-02f, -3.37151527e-01f, -7.26705417e-02f, 3.63691926e-01f, 3.71485502e-01f, 6.18507385e-01f, -2.56089419e-01f, 5.32626092e-01f, 4.20395762e-01f, 2.47081161e-01f,
  1.98452562e-01f, 6.59228325e-01f, -3.65604907e-01f, -4.23864484e-01f, -1.33304372e-01f, 4.22229409e-01f, -7.87715539e-02f, -2.22254060e-02f, 8.90823752e-02f, 2.11947024e-01f,
  6.67611510e-02f, 3.35871994e-01f, 1.98334709e-01f, 2.30468750e-01f, -7.06535280e-02f, 3.94327007e-02f, 1.18467249e-02f, -1.21066518e-01f, 6.27251267e-02f, -1.18815213e-01f,
  2.62271315e-01f, -9.96040776e-02f, -5.90818942e-01f, 1.20916978e-01f, -3.08823735e-01f, 6.28547519e-02f, -1.71308760e-02f, 1.16235763e-01f, -2.73575991e-01f, 2.90606171e-01f,
  5.26403129e-01f, 2.11851239e-01f, -3.57171208e-01f, -2.20342595e-02f, 2.08768368e-01f, -4.70480323e-01f, 8.42869282e-03f, -1.67627618e-01f, 2.93146055e-02f, 6.74040169e-02f,
  -2.52153814e-01f, 4.88872826e-01f, 1.21533044e-01f, 3.59416217e-01f, 5.88342309e-01f, 3.38970304e-01f, 5.34875281e-02f, 2.09748715e-01f, 5.57986379e-01f, -1.54667825e-01f,
  -2.73270346e-02f, -1.59196332e-02f, 2.01215431e-01f, 3.81421894e-01f, 2.59007692e-01f, -1.64330795e-01f, -1.68325439e-01f, -4.40282822e-01f, -2.19543844e-01f, 2.56265253e-01f,
  3.20564061e-01f, -3.36238235e-01f, -1.89744070e-01f, 7.36882687e-02f, 8.32906961e-02f, 1.78828672e-01f, 3.61394882e-01f, -8.76589566e-02f, 2.86303848e-01f, 3.99842322e-01f,
  5.23792267e-01f, 2.84944057e-01f, 3.05727571e-01f, 2.14930102e-01f, 3.09763044e-01f, 1.20399058e-01f, 1.11976370e-01f, -1.69496834e-01f, 1.48262143e-01f, 3.78848791e-01f,
  1.22159839e-01f, 5.39844453e-01f, 7.53165931e-02f, -3.48572508e-02f, 1.89060599e-01f, -2.39301428e-01f, -4.90948051e-01f, 1.59593802e-02f, -1.39367804e-01f, 2.74751514e-01f,
  5.68866193e-01f, -6.20356649e-02f, 2.74095297e-01f, -7.32871771e-01f, -2.09386796e-02f, -4.08776492e-01f, -6.08518839e-01f, -6.95778877e-02f, 1.59123018e-01f, -3.56869817e-01f,
  8.10629800e-02f, -1.95459023e-01f, -2.11023301e-01f, 3.81221808e-02f, 1.27106383e-01f, 3.11214626e-01f, -5.68583086e-02f, -2.43986771e-01f, 3.86811286e-01f, 1.17257334e-01f,
  1.42598420e-01f, 2.43768975e-01f, 4.67887312e-01f, 3.55527371e-01f, -4.73639995e-01f, 8.30536615e-03f, 2.48409197e-01f, 8.17968488e-01f, -1.47130176e-01f, -6.53576776e-02f,
  1.25560269e-01f, -5.09087861e-01f, -2.08374396e-01f, -9.08932164e-02f, 1.90526158e-01f, -4.79807884e-01f, -2.15141661e-02f, 2.18984827e-01f, -1.78860754e-01f, 2.74583757e-01f,
  7.06512257e-02f, -9.42014381e-02f, -1.97289407e-01f, 2.98429996e-01f, 2.45424509e-01f, 4.30765688e-01f, 2.65284002e-01f, 1.65840477e-01f, -1.01585798e-01f, -2.21513852e-01f,
  2.74918173e-02f, 1.25980139e-01f, 2.58818328e-01f, 1.82960421e-01f, 5.27458251e-01f, 2.02753171e-01f, -5.34310579e-01f, -2.71167811e-02f, 2.95219481e-01f, -7.02976063e-02f,
  2.45815128e-01f, -5.89479685e-01f, -2.19312951e-01f, 9.20760557e-02f, -3.38315815e-02f, 2.73268700e-01f, 1.26010567e-01f, -4.69890803e-01f, -1.23117924e-01f, 8.37406963e-02f,
  2.86302179e-01f, 6.49433553e-01f, 2.41863802e-01f, 4.79368985e-01f, -3.17892462e-01f, 4.20894980e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.06862360e-01f, 2.91789949e-01f, 3.23396623e-01f, 2.64867634e-01f, 8.06895420e-02f, 3.55912149e-01f, -1.18963122e-01f, 1.50043905e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  2.85137707e-04f, -6.69198111e-02f, -2.07595587e-01f, -1.54922917e-01f, -1.55959994e-01f, 3.16704124e-01f, -4.25440282e-01f, -4.20923233e-01f, 8.41990188e-02f, 8.51352364e-02f,
  3.23107503e-02f, 7.40233585e-02f, 2.84665823e-01f, 8.55473727e-02f, 4.27587442e-02f, 6.02799803e-02f, 2.21651018e-01f, -5.09839296e-01f, 1.59353167e-01f, -5.29487729e-01f,
  -3.35121155e-02f, 6.93039596e-02f, -4.22703773e-01f, 1.25108197e-01f, -2.12087482e-01f, -3.25453758e-01f, 2.15480760e-01f, 6.63759932e-02f, -4.11231350e-03f, 1.93186235e-02f,
  -2.80185074e-01f, 1.24288231e-01f, 5.56096472e-02f, 8.72580931e-05f, 1.60668164e-01f, -8.89212340e-02f, -1.38303876e-01f, -3.17836851e-01f, 9.79509018e-03f, 4.52001870e-01f,
  -1.64930433e-01f, -4.60160166e-01f, -4.04930636e-02f, -1.74286246e-01f, -1.40938833e-01f, 3.21439356e-02f, -2.00117782e-01f, -2.32428536e-01f, -1.55580267e-01f, 3.33723187e-01f,
  -2.49221865e-02f, 3.06813359e-01f, 5.75580932e-02f, 1.73893526e-01f, 3.90512049e-01f, -3.35993111e-01f, 4.76781756e-01f, 2.73477472e-03f, -2.80553848e-01f, -1.69293180e-01f,
  -3.39498743e-02f, 2.09485248e-01f, 4.02289331e-01f, 7.49475807e-02f, 5.07215038e-02f, -2.21655905e-01f, 7.70793706e-02f, -3.12071562e-01f, 1.14172690e-01f, 1.32255945e-02f,
  4.26439077e-01f, -2.73970783e-01f, 2.73237228e-01f, -3.17147970e-01f, 1.67891726e-01f, -5.30251205e-01f, 1.05480708e-01f, 1.97414488e-01f, 5.97485840e-01f, 3.82367730e-01f,
  2.51633614e-01f, -1.76254392e-01f, -1.67639941e-01f, -3.30219656e-01f, -2.73871303e-01f, 1.99014977e-01f, -2.06599846e-01f, 7.34983459e-02f, -4.54833210e-02f, 1.20699234e-01f,
  8.80205929e-02f, 1.37239456e-01f, -2.06769362e-01f, -4.08674568e-01f, -1.12803401e-02f, -3.05815637e-01f, 2.83416510e-01f, -1.86069142e-02f, 1.40727594e-01f, -2.10751563e-01f,
  -6.69445023e-02f, 5.48055768e-02f, 1.80434734e-01f, -1.94329470e-02f, -9.49745104e-02f, -1.33114159e-01f, 3.59722227e-02f, 8.04107985e-04f, 2.61526108e-01f, 1.47713959e-01f,
  2.64751632e-02f, 1.05329655e-01f, 3.75573449e-02f, 6.15171269e-02f, 6.43458217e-02f, 3.80672336e-01f, -4.79629368e-01f, 2.53529876e-01f, 2.91058332e-01f, 1.98880255e-01f,
  3.16324532e-01f, -8.72404948e-02f, 2.42545128e-01f, 8.57815146e-02f, -3.76581758e-01f, -1.81385711e-01f, -3.66103679e-01f, -7.52685964e-02f, 2.14350015e-01f, 1.84696525e-01f,
  -6.10660501e-02f, 3.70184839e-01f, -1.03528783e-01f, 9.92163047e-02f, -3.88329327e-01f, -6.66142032e-02f, -5.78009076e-02f, 2.00739220e-01f, 6.24852628e-02f, 2.52037047e-04f,
  1.39218837e-01f, -7.61870071e-02f, -4.90322262e-01f, 1.53526068e-01f, 4.87303687e-03f, -4.45886068e-02f, -8.31665546e-02f, 3.77144665e-01f, 5.93832880e-02f, -9.29075778e-02f,
  1.48287803e-01f, 3.25193107e-01f, -3.99974972e-01f, -2.02286080e-03f, -1.28746405e-01f, 2.59887949e-02f, 7.66917318e-02f, -4.07107741e-01f, 1.95759803e-01f, 2.82055020e-01f,
  -1.58355311e-01f, -1.71045624e-02f, 2.63676643e-01f, -7.37378746e-02f, -5.90162516e-01f, -4.01013978e-02f, 1.37171239e-01f, -1.09544545e-01f, -2.81343013e-01f, -5.33780903e-02f,
  -7.54180539e-04f, 9.45385769e-02f, -5.34098923e-01f, 4.29422222e-02f, -3.73453647e-01f, -1.09880589e-01f, 9.34457928e-02f, 3.28557454e-02f, 1.75670594e-01f, 4.68673408e-01f,
  -9.79037210e-02f, 3.14508110e-01f, 6.19234592e-02f, 8.88753682e-02f, 1.10070400e-01f, 1.95563480e-01f, -1.21833287e-01f, -2.77129076e-02f, -2.06440076e-01f, 2.70132422e-01f,
  -3.38849932e-01f, 1.78841367e-01f, -1.71375006e-01f, -5.27856909e-02f, 7.40952343e-02f, -5.28168269e-02f, 9.65789109e-02f, 1.10215083e-01f, 1.01972707e-01f, -7.61044621e-02f,
  -2.98732787e-01f, -4.27365690e-01f, -2.37565283e-02f, -3.00401878e-02f, -2.62329131e-01f, 2.54762977e-01f, 3.06392610e-01f, -3.05870652e-01f, -2.96708584e-01f, -3.27834755e-01f,
  3.46998245e-01f, -1.09466441e-01f, -1.58673018e-01f, 4.29175168e-01f, -7.81950355e-02f, -2.60861605e-01f, 3.68058920e-01f, -2.95434684e-01f, 1.93393767e-01f, -1.29677821e-02f,
  -2.72762537e-01f, -5.81426267e-03f, 6.94144070e-02f, -2.07013682e-01f, 8.94237533e-02f, 2.38088176e-01f, 4.24668938e-01f, 1.70105174e-01f, 1.15222871e-01f, -1.89201504e-01f,
  -7.10438266e-02f, 1.24401867e-01f, -1.60497323e-01f, -1.93931833e-01f, -7.81812593e-02f, -6.94189314e-03f, -1.73120573e-01f, -4.55596834e-01f, 2.27793917e-01f, -1.07595555e-01f,
  1.51800111e-01f, 2.20030144e-01f, -1.18964441e-01f, 9.05635953e-03f, -3.46084297e-01f, 4.00090933e-01f, -3.42022218e-02f, 1.71263635e-01f, 2.69892126e-01f, -4.76452917e-01f,
  3.64274196e-02f, -5.04964180e-02f, -2.08011702e-01f, -2.74091929e-01f, 1.95996389e-01f, 1.32975131e-01f, 4.48017195e-02f, -3.69385660e-01f, 3.40471603e-02f, -2.84047604e-01f,
  3.25257808e-01f, -1.07454378e-02f, -1.82998832e-02f, -3.59822154e-01f, 1.16620407e-01f, 3.89423102e-01f, -2.05358446e-01f, 2.74333879e-02f, 1.91860586e-01f, 7.52462819e-02f,
  6.04786992e-01f, -8.64544287e-02f, -5.82370125e-02f, -1.60419703e-01f, -1.09480493e-01f, -2.20314145e-01f, 1.96217611e-01f, 1.38362542e-01f, -4.32254434e-01f, 2.61553198e-01f,
  1.89383581e-01f, 9.25773308e-02f, -2.33216323e-02f, 1.65345088e-01f, 7.33437762e-02f, -1.21293277e-01f, -1.29218042e-01f, -1.28339529e-01f, 1.12878792e-04f, -1.93773180e-01f,
  -4.85885143e-02f, -8.55576843e-02f, -1.03120461e-01f, -1.72294140e-01f, -1.18908703e-01f, 2.95082211e-01f, -8.64358153e-03f, -2.71439880e-01f, 4.96015400e-02f, -1.21092990e-01f,
  -2.54833162e-01f, 5.42313099e-01f, -2.94848919e-01f, 3.49381179e-01f, 5.75236559e-01f, 2.63968259e-01f, -1.28639042e-01f, -1.20295875e-01f, -2.21228942e-01f, 2.35305563e-01f,
  9.13578644e-02f, 1.20402820e-01f, -2.32769758e-01f, -1.38090491e-01f, 1.77227810e-01f, -4.55471277e-02f, -1.90219074e-01f, 1.54605761e-01f, 1.13678068e-01f, 2.48310864e-01f,
  -3.32589261e-02f, -1.17290989e-01f, -2.04030588e-01f, -1.30374596e-01f, 3.36109698e-01f, 7.37630799e-02f, -9.58286822e-02f, 4.81985867e-01f, -1.88098937e-01f, -1.13794118e-01f,
  9.20369178e-02f, -2.24385694e-01f, -2.02268198e-01f, 2.90537596e-01f, -2.09459394e-01f, 2.09198102e-01f, 4.03180003e-01f, 7.49401972e-02f, -1.57319456e-01f, -4.12585407e-01f,
  -2.97729492e-01f, 4.02655035e-01f, 1.42990142e-01f, 2.79464245e-01f, -3.91928911e-01f, -3.88222039e-01f, 9.52854455e-02f, 4.63492833e-02f, -2.10681781e-02f, 2.87217617e-01f,
  1.36583209e-01f, 2.50308394e-01f, -5.75605512e-01f, 2.13432517e-02f, 4.31614637e-01f, -1.82881862e-01f, -2.20491663e-01f, -1.59285888e-01f, -5.16324900e-02f, -1.39819086e-01f,
  -2.83045620e-01f, -5.52180521e-02f, 4.50630719e-03f, 2.80908227e-01f, -2.08227068e-01f, -1.31935805e-01f, 3.04065287e-01f, -5.76473773e-01f, -1.43081665e-01f, -3.35585624e-01f,
  3.90208036e-01f, 4.30754237e-02f, -2.05410153e-01f, 1.83192268e-01f, -1.61432356e-01f, -2.56211668e-01f, 2.32128322e-01f, -2.72006184e-01f, -5.85312909e-03f, 1.10744163e-01f,
  -3.00481170e-01f, 2.87869394e-01f, -4.49034959e-01f, 1.63787469e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -3.48491132e-01f, -7.17615411e-02f, 4.11588132e-01f, -5.39103039e-02f, -1.00324281e-01f, 1.23661328e-02f, 2.24672839e-01f, -5.71888983e-01f, -9.16653648e-02f, 7.41912186e-01f,
  -5.35706460e-01f, 4.53109205e-01f, 3.09060156e-01f, -4.38326448e-01f, 7.15981573e-02f, -6.39766976e-02f, 4.79567125e-02f, -3.00261438e-01f, -3.73672247e-01f, -4.14015688e-02f,
  1.73877016e-01f, -8.80528033e-01f, -3.01049113e-01f, 7.68240690e-02f, -1.80319510e-02f, -4.98046875e-01f, 6.66955262e-02f, -1.11929961e-01f, 4.75581199e-01f, -7.88589180e-01f,
  2.32054442e-01f, 3.96889478e-01f, 4.68574435e-01f, 8.86122763e-01f, 1.46619499e-01f, 4.03798908e-01f, 1.37251928e-01f, -2.87401885e-01f, -2.74423867e-01f, 9.80377257e-01f,
  2.13062707e-02f, -4.84868944e-01f, 2.72383451e-01f, -1.70429185e-01f, 4.48467791e-01f, -2.83639822e-02f, -4.18955922e-01f, 4.44785297e-01f, 2.39586592e-01f, 5.49406886e-01f,
  -3.87142450e-01f, 3.96152318e-01f, -5.79596221e-01f, 4.10772681e-01f, 3.69141579e-01f, 5.04175246e-01f, -5.19224823e-01f, -4.73882645e-01f, 6.04693711e-01f, 1.26781255e-01f,
  1.59476653e-01f, -6.10403121e-01f, 1.17713310e-01f, 3.02603751e-01f, 2.25062355e-01f, -6.21379726e-02f, 1.18152119e-01f, -6.97722659e-02f, 3.29706043e-01f, 2.70401180e-01f,
  3.53875279e-01f, 3.81700486e-01f, 4.12071407e-01f, -3.20977390e-01f, -5.10978773e-02f, -1.36235088e-01f, 4.83437218e-02f, 4.37483758e-01f, 7.39608645e-01f, -2.64411896e-01f,
  1.97417155e-01f, -4.72314566e-01f, 3.27440798e-01f, -6.29946768e-01f, 1.86002508e-01f, 2.07548052e-01f, -4.92952228e-01f, 1.86794147e-01f, 4.25008714e-01f, -3.82600009e-01f,
  5.56437254e-01f, 6.44745052e-01f, 2.23345752e-03f, -5.01965463e-01f, -6.40896261e-02f, 3.06621455e-02f, -2.43183792e-01f, 1.42454103e-01f, 2.95397788e-01f, 3.98561239e-01f,
  6.68743551e-01f, -1.19082510e-01f, 4.05461282e-01f, 7.08695829e-01f, 3.52584291e-03f, -5.41035235e-01f, 3.36404949e-01f, 1.73880175e-01f, 4.28761363e-01f, -6.48345232e-01f,
  2.28017733e-01f, -6.48262277e-02f, -3.88369262e-01f, 3.16734821e-01f, -2.97682047e-01f, -2.71411557e-02f, 4.64053690e-01f, -1.76213488e-01f, -8.98350403e-03f, -9.27252531e-01f,
  6.89189911e-01f, -1.14470661e-01f, -1.76309958e-01f, 3.69472325e-01f, 3.93099576e-01f, 6.38181746e-01f, 4.30285394e-01f, -7.37930369e-03f, -3.34916681e-01f, 1.32485956e-01f,
  2.26858854e-02f, 2.44367659e-01f, 2.03361675e-01f, -2.28835106e-01f, -2.26194561e-01f, 2.63804495e-01f, -2.19863951e-01f, 3.93338233e-01f, -7.00086832e-01f, 1.56498671e-01f,
  -2.18666226e-01f, -5.41794300e-01f, -2.59826511e-01f, -5.36423028e-01f, -1.39094248e-01f, 3.62551212e-01f, 7.43477419e-02f, -6.71286508e-02f, 1.08871639e-01f, -2.11051539e-01f,
  3.53943199e-01f, 3.70054781e-01f, 5.12074351e-01f, -7.11165905e-01f, 8.76304880e-02f, -2.03936268e-02f, 1.80423394e-01f, -2.31414631e-01f, 7.09201515e-01f, 5.46281219e-01f,
  2.22553030e-01f, 8.09299992e-04f, 4.30157669e-02f, 3.61161619e-01f, -2.70738661e-01f, -3.06084722e-01f, -1.31096676e-01f, 8.56345221e-02f, 1.80717468e-01f, 4.29955095e-01f,
  -1.42549694e-01f, 5.99305451e-01f, 1.38131157e-01f, -6.99885190e-01f, -5.66102684e-01f, -1.33971527e-01f, -2.56875098e-01f, 5.38033128e-01f, -4.71502274e-01f, 7.05674589e-01f,
  1.14576817e-01f, -3.67819011e-01f, 3.68287802e-01f, -2.02167276e-02f, -2.62390465e-01f, 7.52230406e-01f, -6.61348820e-01f, -3.37837875e-01f, 3.25993299e-01f, -1.76803201e-01f,
  2.60639220e-01f, 1.88498750e-01f, 4.15707290e-01f, 3.55197787e-01f, 1.40467376e-01f, -4.39634323e-01f, 1.56871706e-01f, 5.12107491e-01f, 3.69574100e-01f, -4.43680942e-01f,
  3.56564820e-01f, 5.73057532e-01f, 3.49980175e-01f, 1.15997151e-01f, 1.88744701e-02f, 2.09481865e-01f, -3.02370429e-01f, 6.66757464e-01f, 6.01620749e-02f, -3.19054216e-01f,
  -6.34921491e-01f, -3.60619038e-01f, -1.19662426e-01f, -4.13572788e-01f, 7.95179904e-02f, 4.18979436e-01f, -7.74878502e-01f, 9.72239792e-01f, 5.30082226e-01f, -2.25040987e-01f,
  1.41803265e-01f, 7.41108060e-01f, -1.27532363e-01f, 4.73463684e-01f, 2.08964378e-01f, -1.21825650e-01f, 4.97511998e-02f, 3.10926467e-01f, 2.71435738e-01f, 4.07713383e-01f,
  -4.79668736e-01f, 7.71076798e-01f, 3.43045831e-01f, 1.58895463e-01f, 1.78376928e-01f, 1.08694799e-01f, 6.37722135e-01f, -2.34345630e-01f, -1.17187491e-02f, 2.55006164e-01f,
  -1.71960548e-01f, 3.65081757e-01f, 2.95748711e-02f, -1.89987257e-01f, 3.12141299e-01f, -3.74045551e-01f, 4.97071177e-01f, 2.38461316e-01f, -6.37032747e-01f, -1.06032394e-01f,
  1.40417174e-01f, -5.88362575e-01f, 2.31064186e-01f, -2.18361676e-01f, 4.79126602e-01f, 4.36516374e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -9.34679061e-03f, 2.63560712e-01f, 2.36566201e-01f, 1.40539750e-01f, 1.97502375e-01f, 2.76407778e-01f, 3.15905660e-01f, -9.33042914e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -5.96162736e-01f, -3.69352460e-01f, -4.04990077e-01f, 1.91958219e-01f, 5.22649646e-01f, 1.26311734e-01f, 5.11072874e-01f, 1.71572156e-02f, 3.26012187e-02f, 1.77209079e-02f,
  -1.55499831e-01f, 4.71804172e-01f, 1.18651457e-01f, -5.19424438e-01f, 9.80483219e-02f, -5.96564889e-01f, 3.00080210e-01f, 3.30620348e-01f, -3.36174190e-01f, 6.04804575e-01f,
  -1.67376608e-01f, -3.15057218e-01f, -2.62212694e-01f, 3.68737459e-01f, 4.18676466e-01f, -4.02054340e-01f, -6.85102582e-01f, 2.04952136e-01f, 5.60611904e-01f, 8.15185830e-02f,
  -8.40802252e-01f, -5.62910318e-01f, 2.31378585e-01f, -2.92237490e-01f, 1.52012318e-01f, -3.58587533e-01f, 1.01631217e-01f, -6.98672593e-01f, 4.62318510e-01f, 2.60489404e-01f,
  -1.91753507e-01f, -8.56790692e-02f, 4.81396437e-01f, 3.16887349e-01f, -3.94049704e-01f, 1.59410939e-01f, -5.36861233e-02f, -4.09246117e-01f, -2.37931862e-01f, -4.23059970e-01f,
  3.65105152e-01f, -2.48398855e-01f, 3.55334371e-01f, -3.27722073e-01f, -4.13766772e-01f, -4.95752007e-01f, -4.38434958e-01f, -3.86033386e-01f, 1.44288227e-01f, 4.88517255e-01f,
  1.27609909e-01f, -9.19484079e-01f, -5.08319497e-01f, -5.56729376e-01f, 1.50164992e-01f, 4.85817969e-01f, -3.78019392e-01f, -3.02675307e-01f, -2.58631796e-01f, -4.56401348e-01f,
  -3.54287885e-02f, 2.65677094e-01f, 6.13145269e-02f, -3.52244139e-01f, -1.09888777e-01f, 9.77585325e-04f, 3.91620219e-01f, -2.46774599e-01f, -3.27025980e-01f, -7.11241126e-01f,
  -1.11744255e-02f, -1.75081808e-02f, 1.18244819e-01f, -3.47315401e-01f, -2.44784772e-01f, 8.80331919e-02f, -7.03005433e-01f, 9.24358606e-01f, 1.39980271e-01f, -2.80593991e-01f,
  -1.93845913e-01f, -2.97483236e-01f, 3.55592847e-01f, -9.47504759e-01f, 6.58646077e-02f, 4.33709174e-01f, -3.51934999e-01f, -5.84211349e-01f, 5.10346830e-01f, -2.56700099e-01f,
  -5.74606597e-01f, -1.10836491e-01f, 6.23851307e-02f, -3.37004453e-01f, -6.98235035e-01f, 4.40627694e-01f, -1.27569154e-01f, -5.20990193e-01f, -4.73343939e-01f, 1.33154839e-01f,
  -3.22903842e-02f, 5.54757059e-01f, 3.02817989e-02f, -3.47231567e-01f, 7.14459717e-02f, 4.84117493e-02f, -1.31241515e-01f, 7.96973109e-01f, 9.41427171e-01f, 4.65851188e-01f,
  -5.37131466e-02f, 2.50001311e-01f, -5.37801921e-01f, 2.83234566e-01f, 2.62532502e-01f, 7.01342225e-02f, -4.67946649e-01f, 2.98194438e-01f, 4.09415394e-01f, 5.36091745e-01f,
  -1.11013371e-02f, 1.41740084e-01f, -4.27720904e-01f, 4.05518889e-01f, -6.33541882e-01f, 3.69386464e-01f, 2.16687962e-01f, 3.80547494e-01f, 5.63391268e-01f, 5.00798583e-01f,
  -1.56283513e-01f, 5.75014055e-01f, 7.16220617e-01f, 4.19691116e-01f, -3.66669409e-02f, 5.04150212e-01f, -2.47900233e-01f, -2.09632516e-01f, -7.95814842e-02f, -3.03919137e-01f,
  -7.70223793e-04f, -1.71613589e-01f, 4.34611678e-01f, -7.87303925e-01f, -1.52320862e-01f, -4.31278795e-01f, 2.57898688e-01f, 2.90183365e-01f, -1.70945361e-01f, 1.33809984e-01f,
  -1.17699362e-01f, -1.12758495e-01f, -1.57114774e-01f, -2.46911850e-02f, 7.14748263e-01f, 5.73319308e-02f, -4.23676103e-01f, -6.25032559e-02f, 3.27489913e-01f, 1.34421989e-01f,
  -2.13211663e-02f, -6.66209638e-01f, 1.78282380e-01f, 5.00657916e-01f, -5.07493496e-01f, 3.97633225e-01f, 2.68733893e-02f, -3.84846628e-01f, -6.06352210e-01f, -3.12044054e-01f,
  -1.35239825e-01f, -6.40335441e-01f, -2.73028970e-01f, -1.10565774e-01f, -4.85393971e-01f, -7.06734300e-01f, -3.53696495e-01f, 3.85343581e-01f, -4.50652242e-01f, 2.02090874e-01f,
  -6.21220358e-02f, 2.81449705e-01f, -3.35202634e-01f, -2.70684034e-01f, 2.13431567e-01f, -3.23504731e-02f, 4.87545103e-01f, 2.84327090e-01f, 1.76204160e-01f, 3.08959901e-01f,
  5.09228408e-01f, -2.45925531e-01f, -4.99864161e-01f, 4.18490410e-01f, -1.94535092e-01f, -4.39744532e-01f, 1.05568163e-01f, 4.33468729e-01f, -3.98930430e-01f, 4.43103999e-01f,
  6.91117346e-01f, 4.89123672e-01f, -4.91741657e-01f, -4.76719111e-01f, -4.30906802e-01f, 5.94700515e-01f, -6.06587172e-01f, 2.39551157e-01f, 1.65904462e-01f, -2.58162141e-01f,
  -7.07150519e-01f, -2.34637842e-01f, 2.78923810e-01f, -7.15379536e-01f, 2.20663607e-01f, 9.00851339e-02f, 4.13056500e-02f, -2.27907509e-01f, -7.72753894e-01f, 6.02429926e-01f,
  -6.43390298e-01f, -3.41496952e-02f, -4.50464070e-01f, -6.88299723e-03f, 3.35865617e-01f, -2.17588574e-01f, 2.70195007e-01f, -6.72437996e-02f, 6.24899864e-01f, 5.55341601e-01f,
  -2.30806291e-01f, -2.75798857e-01f, 7.31970975e-03f, 3.41062456e-01f, 2.37206623e-01f, 5.44522047e-01f, 2.45671242e-01f, 5.76765835e-01f, -7.17218876e-01f, -1.26228765e-01f,
  5.19076884e-01f, -2.54425257e-01f, -1.24196960e-02f, 1.34385243e-01f, -7.83139408e-01f, -6.22917533e-01f, 1.55830055e-01f, 2.02076778e-01f, 3.66571277e-01f, 1.78633451e-01f,
  2.80792773e-01f, 4.77012008e-01f, 2.50210166e-01f, -3.18077207e-01f, 4.25861299e-01f, 4.31757122e-01f, 6.27917275e-02f, 6.22967362e-01f, 6.92291737e-01f, -5.80067277e-01f,
  -4.02215451e-01f, -7.28946507e-01f, -4.84285653e-01f, 1.17249727e-01f, -4.40595657e-01f, -3.82205367e-01f, 1.89280257e-01f, 7.45464444e-01f, 5.88408530e-01f, -7.24034607e-02f,
  -7.67928004e-01f, -6.37811363e-01f, -2.52655029e-01f, -2.32213527e-01f, -2.61180371e-01f, -6.68109655e-01f, 6.40435398e-01f, -3.43816519e-01f, 4.30521250e-01f, 3.96528691e-01f,
  2.31904164e-01f, 2.93989748e-01f, -2.50687271e-01f, 5.43415785e-01f, 4.91485357e-01f, -1.93471625e-01f, -2.10744902e-01f, -4.57473509e-02f, -5.37408181e-02f, -3.76570106e-01f,
  4.33247983e-01f, -2.47259840e-01f, -4.53699708e-01f, 5.98103106e-01f, 5.78108251e-01f, -4.34171349e-01f, -7.73517564e-02f, 5.00423372e-01f, -2.81973064e-01f, 6.14298284e-02f,
  1.16799520e-02f, -5.82516789e-01f, -9.13009584e-01f, 6.38820589e-01f, -1.91516697e-01f, -7.85572052e-01f, 1.79354623e-01f, -2.50030875e-01f, -1.09067604e-01f, 1.80854991e-01f,
  -1.46002561e-01f, 3.79913747e-01f, 1.71334129e-02f, 1.36613682e-01f, -4.81492162e-01f, 6.73635826e-02f, 4.87559661e-02f, -6.75694406e-01f, 2.31613293e-02f, 2.37213016e-01f,
  4.90442328e-02f, -7.46314645e-01f, -3.62298876e-01f, 3.10817480e-01f, -1.60276994e-01f, -5.69338799e-01f, 2.25493133e-01f, 5.56113124e-01f, 2.92434841e-01f, -2.36993819e-01f,
  -3.94560635e-01f, -1.14190876e-01f, -3.90343785e-01f, 2.55746216e-01f, -4.49401855e-01f, -3.29189271e-01f, -6.55357897e-01f, -1.17623889e+00f, -7.95905828e-01f, 5.74882448e-01f,
  3.59843045e-01f, -1.12217650e-01f, -3.92145157e-01f, -7.61801422e-01f, 3.55079994e-02f, 3.89592052e-01f, 1.67431310e-01f, -8.77102911e-01f, 1.39213607e-01f, -5.68830781e-02f,
  -1.90253392e-01f, 1.96907237e-01f, -7.99606219e-02f, -2.48910978e-01f, 3.34181860e-02f, 3.58374894e-01f, 6.42966390e-01f, 2.39012823e-01f, 1.03742912e-01f, -1.08272903e-01f,
  -5.62664986e-01f, -1.24570373e-02f, 7.49434531e-01f, 6.21356010e-01f, 4.57590848e-01f, -8.03505003e-01f, 7.31152892e-01f, 1.41731158e-01f, 5.98709621e-02f, -3.64011794e-01f,
  -5.28945386e-01f, -3.19320023e-01f, 1.67338207e-01f, -1.32923692e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.06651716e-01f, 1.82162270e-01f, -2.39064202e-01f, -2.85822988e-01f, 1.42259941e-01f, 3.39933842e-01f, -6.66552112e-02f, -1.32052489e-02f, 9.40184891e-02f, 5.91637045e-02f,
  -1.74126744e-01f, -3.01230520e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    