/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.09561163e-01f, -3.69592220e-01f, -2.95646697e-01f, 7.98547566e-02f, 1.78531781e-01f, -5.16208708e-01f, -2.21526533e-01f, -1.22379027e-02f, 1.60718560e-01f, -9.62098613e-02f,
  6.89534172e-02f, -2.26946399e-01f, -8.81632194e-02f, -1.47226891e-02f, -2.70340592e-01f, 3.36235575e-02f, -2.11699739e-01f, -1.00088701e-01f, 1.97016090e-01f, -1.81410268e-01f,
  -3.39137092e-02f, 4.53527598e-03f, -1.34857625e-01f, 6.33378699e-02f, -1.37795612e-01f, 5.10713346e-02f, 1.42305642e-01f, -4.26799096e-02f, -8.23721513e-02f, -6.27453066e-03f,
  -1.83304369e-01f, 6.14921823e-02f, 9.26748216e-02f, 1.42936781e-02f, -2.40126941e-02f, -2.46465113e-02f, -1.20432980e-01f, 2.91607119e-02f, 5.57392202e-02f, 4.32014950e-02f,
  -1.30286720e-02f, 9.13443640e-02f, 1.00702710e-01f, 4.21366617e-02f, 8.40961337e-02f, 2.15772763e-02f, 1.95545182e-02f, -8.48756135e-02f, 1.36613501e-02f, -3.09337005e-02f,
  -2.66633555e-02f, -1.46610197e-02f, -8.44366383e-03f, 4.53431755e-02f, -3.56824435e-02f, 5.38050905e-02f, -3.33072469e-02f, -7.55626708e-02f, -1.50716320e-01f, 4.33134884e-02f,
  6.80392236e-02f, -3.77824232e-02f, -5.58055900e-02f, 2.72352230e-02f, -8.35836604e-02f, 8.47318023e-02f, -6.52137697e-02f, 5.00211567e-02f, -1.70150306e-02f, -5.37853427e-02f,
  3.17805670e-02f, -4.53971419e-03f, 1.09701090e-01f, -1.65845584e-02f, 5.57880104e-02f, 4.57202755e-02f, -7.77822211e-02f, -1.80265475e-02f, -6.50142599e-03f, 2.15890631e-02f,
  4.59258780e-02f, -6.90635741e-02f, -5.49474247e-02f, 3.56259868e-02f, 1.94088761e-02f, -6.68464452e-02f, -9.52482298e-02f, -7.00447485e-02f, 4.58169635e-03f, -4.96713296e-02f,
  -3.38458687e-01f, -3.88922662e-01f, 5.33837788e-02f, 3.91616151e-02f, 1.88656654e-02f, -1.48183983e-02f, 7.54360780e-02f, 6.65084869e-02f, -9.45562348e-02f, -3.01320814e-02f,
  -1.05173057e-02f, 1.70914456e-02f, -8.00609291e-02f, 2.43905429e-02f, -1.27284512e-01f, -5.86615466e-02f, -4.74584773e-02f, 2.08594594e-02f, -1.05298586e-01f, -4.02513631e-02f,
  -6.87581301e-02f, 1.49510950e-02f, 7.81364888e-02f, 2.38299295e-02f, 8.07337984e-02f, 1.32339587e-02f, -3.96840498e-02f, 6.26335144e-02f, -5.34194009e-03f, -6.61765039e-02f,
  3.56551141e-01f, -7.23904371e-02f, 1.84316978e-01f, 8.42629299e-02f, 3.35687041e-01f, -1.16860375e-01f, -3.57358724e-01f, 2.73745507e-01f, -6.38425127e-02f, -4.17107701e-01f,
  1.28675908e-01f, 9.40076709e-02f, -1.99025199e-01f, 2.83117563e-01f, 4.80930626e-01f, -2.66370654e-01f, -6.95215315e-02f, -2.48553529e-01f, 3.96809429e-02f, 5.45399971e-02f,
  1.97167680e-01f, 5.26048951e-02f, 1.49923459e-01f, 1.14993200e-01f, 2.08404914e-01f, -2.50532962e-02f, -1.26013055e-01f, -7.98271038e-04f, 8.38193223e-02f, 1.19999550e-01f,
  1.07286073e-01f, 2.19202247e-02f, 6.19757874e-03f, -3.82965319e-02f, 6.71534091e-02f, -1.05281770e-01f, -1.31238103e-01f, 3.83104309e-02f, 1.26598328e-01f, -5.67012578e-02f,
  -1.32207230e-01f, 8.53396282e-02f, 4.51902784e-02f, -8.55459273e-02f, 1.09205276e-01f, 1.00039929e-01f, 9.30764154e-02f, 1.16971113e-01f, 4.14633229e-02f, 7.49861449e-02f,
  3.37088183e-02f, 8.23801085e-02f, 1.24398395e-01f, -1.37272850e-01f, 8.35885853e-03f, -1.80709027e-02f, -1.12544447e-01f, -2.78499536e-02f, 1.69138256e-02f, -4.79377918e-02f,
  -5.14068604e-02f, -1.05605736e-01f, 1.68709740e-01f, 8.98204222e-02f, 4.42061834e-02f, -1.23932706e-02f, 4.30396684e-02f, 5.06960489e-02f, 4.68581319e-02f, 4.40401770e-03f,
  3.04406993e-02f, 8.52295235e-02f, -7.94223547e-02f, -1.32832602e-02f, -3.49276960e-02f, -1.66749526e-02f, -8.03829357e-02f, 1.51200872e-02f, -7.93989226e-02f, 1.10531643e-01f,
  -6.80312589e-02f, -3.37860174e-02f, -1.41404033e-01f, -7.08687454e-02f, -4.81092520e-02f, 1.78175960e-02f, 6.63971603e-02f, 5.84896654e-02f, 2.22359672e-02f, 1.02928896e-02f,
  -1.41716272e-01f, -2.29653150e-01f, -3.12852859e-02f, 9.10196174e-03f, -1.48085132e-01f, 1.05981782e-01f, -2.32450832e-02f, 3.10608409e-02f, -6.01628050e-02f, 5.28358705e-02f,
  -6.24761581e-02f, -1.11479573e-01f, -9.01401788e-02f, 9.13170949e-02f, -1.53474556e-02f, -6.86391816e-02f, -1.58551708e-01f, -5.65159693e-02f, -9.21092108e-02f, 4.26478684e-02f,
  2.53761280e-02f, -1.23810530e-01f, -7.98353255e-02f, -1.32064447e-02f, -7.55482316e-02f, -9.93162394e-02f, 5.13059795e-02f, -6.40539601e-02f, -2.39491444e-02f, -1.23286545e-01f,
  -1.71042725e-01f, 5.10671377e-01f, 8.52691233e-02f, -4.34857637e-01f, -2.99950451e-01f, 4.84092772e-01f, 2.07844913e-01f, 2.08986196e-04f, -5.45955542e-03f, 3.19337249e-01f,
  -1.01146661e-01f, 1.51961237e-01f, 2.18156800e-01f, -7.13243335e-02f, -3.70306134e-01f, 2.45007686e-02f, 4.44296077e-02f, 2.35446289e-01f, 1.67698842e-02f, -3.99838528e-03f,
  -2.95550555e-01f, -2.11507350e-01f, -1.66703746e-01f, 2.26228475e-03f, -7.79201239e-02f, 4.30463776e-02f, -1.96915373e-01f, 2.09971499e-02f, -1.24538532e-02f, -2.64277514e-02f,
  1.88113838e-01f, -1.59825042e-01f, -8.91847610e-02f, 1.35217234e-01f, -6.24395907e-02f, 3.30131091e-02f, 7.92858750e-02f, -5.34579046e-02f, -8.22798088e-02f, -2.57303435e-02f,
  7.63339922e-02f, -8.47672299e-02f, -3.54526006e-02f, -5.56170866e-02f, 6.31246567e-02f, 8.47391188e-02f, -7.86932483e-02f, 4.42477278e-02f, 1.23497518e-02f, -7.37729818e-02f,
  1.05227180e-01f, 1.38441082e-02f, -2.85573434e-02f, 5.52926734e-02f, -6.02539964e-02f, -6.48294203e-03f, -2.96070259e-02f, -5.55045418e-02f, 2.71498356e-02f, -8.56894031e-02f,
  -1.84305813e-02f, -2.15172678e-01f, -1.91518702e-02f, 1.78115573e-02f, -4.79429252e-02f, -4.46549542e-02f, 3.06515768e-02f, -7.13403150e-02f, -4.13510948e-02f, 4.05084230e-02f,
  -3.64708491e-02f, -9.29115154e-03f, -3.06123607e-02f, 3.02293780e-03f, -2.28726044e-02f, -2.74304356e-02f, -3.61940078e-02f, 8.12401921e-02f, 2.18468588e-02f, -1.40007287e-01f,
  6.31893426e-02f, 2.37951074e-02f, 6.49409890e-02f, -8.89336411e-03f, 1.58223927e-01f, -6.88093677e-02f, 5.65843694e-02f, 9.83661711e-02f, -8.67525414e-02f, -4.93514091e-02f,
  2.06218675e-01f, -7.09699243e-02f, 1.18471878e-02f, 1.80156454e-02f, 5.05045988e-02f, -5.06263832e-03f, -7.87042081e-02f, 9.80385318e-02f, 3.71572860e-02f, 6.77255867e-03f,
  2.56919544e-02f, 5.30010946e-02f, 5.84270470e-02f, 1.11701181e-02f, 2.70477924e-02f, -2.89073400e-02f, 3.49435620e-02f, 6.30692542e-02f, -8.71700346e-02f, -1.30277257e-02f,
  2.36937795e-02f, 7.98825081e-03f, -6.94261980e-05f, -7.04148859e-02f, 5.61081432e-03f, 1.96446311e-02f, -1.48140751e-02f, -7.36811897e-03f, -1.50911510e-01f, 3.11496016e-02f,
  -2.37878457e-01f, 3.96872729e-01f, -2.23168552e-01f, -3.18652362e-01f, -8.38580579e-02f, -2.93429732e-01f, -3.00903738e-01f, -4.96172719e-02f, -3.07669997e-01f, 2.00487584e-01f,
  1.40212670e-01f, 1.00413367e-01f, 1.37211159e-01f, -5.75640723e-02f, -3.16294223e-01f, -1.14598989e-01f, -2.04929903e-01f, -1.97789595e-02f, 6.97850995e-03f, 3.27292718e-02f,
  -6.63599446e-02f, 3.16491686e-02f, -9.37441960e-02f, 7.55953938e-02f, 4.63585034e-02f, 1.34082124e-01f, 1.18144341e-01f, 4.12572734e-02f, 1.55524716e-01f, -6.35657832e-02f,
  3.03719789e-02f, -7.13250935e-02f, 1.65407792e-01f, -1.42864771e-02f, 6.04907423e-02f, 1.08654406e-02f, 4.67952304e-02f, -7.34288841e-02f, -4.31546802e-03f, 3.09655424e-02f,
  1.64352711e-02f, -6.82690442e-02f, 6.87761903e-02f, -5.83546348e-02f, 3.92393358e-02f, 4.86958176e-02f, -6.01660386e-02f, 3.18392292e-02f, 2.15575541e-03f, -6.87099323e-02f,
  4.53781001e-02f, 1.40388049e-02f, 5.01723625e-02f, -2.38172412e-02f, -3.41668501e-02f, -4.92335856e-02f, -1.40595242e-01f, 4.50756922e-02f, 8.51737484e-02f, -9.41966753e-03f,
  2.05906369e-02f, -4.93212789e-03f, 1.67356096e-02f, -4.43551801e-02f, -3.67305311e-03f, -1.43421311e-02f, 2.14623474e-02f, 3.18891034e-02f, -6.21393789e-03f, 8.93566906e-02f,
  -5.48981465e-02f, 8.19320511e-03f, 5.38298897e-02f, 4.18438874e-02f, -8.86461139e-03f, -2.74294727e-02f, 3.06222327e-02f, 5.36434539e-02f, 1.18171768e-02f, -4.82233614e-02f,
  -6.14166036e-02f, -1.01444805e-02f, 8.67523775e-02f, -1.40964184e-02f, 2.82816384e-02f, 4.10346836e-02f, 1.00288890e-01f, -1.21568097e-02f, -2.16579698e-02f, -4.45784293e-02f,
  2.96294242e-01f, 2.76755542e-01f, 1.24667697e-01f, 1.10361569e-01f, -1.57009065e-02f, 2.07280950e-03f, -6.90348521e-02f, -7.63373747e-02f, 5.83526790e-02f, -7.37661496e-02f,
  9.39490050e-02f, -7.86690600e-03f, 7.29678646e-02f, -9.05607864e-02f, 2.77866945e-02f, 2.90912651e-02f, 6.12819791e-02f, 2.97212489e-02f, 1.42625600e-01f, 8.52258056e-02f,
  8.93142968e-02f, 8.37574061e-03f, -8.83660838e-02f, -9.45177898e-02f, 1.41902342e-01f, 5.26092686e-02f, 8.89084190e-02f, -7.95499980e-02f, -2.16015410e-02f, 6.50947839e-02f,
  4.61142391e-01f, -4.65931803e-01f, -4.73831236e-01f, -9.64796767e-02f, 3.83982092e-01f, -3.50508153e-01f, -2.31085360e-01f, -2.73480918e-02f, 7.55795091e-02f, -1.56400293e-01f,
  8.85292217e-02f, -1.13634028e-01f, -1.28487140e-01f, -2.70914018e-01f, -1.47064373e-01f, -3.16007197e-01f, -1.91710517e-01f, -7.20128715e-02f, 5.51435277e-02f, 1.52988704e-02f,
  3.14110355e-03f, -1.02300517e-01f, -3.89490753e-01f, 6.45350218e-02f, 7.15512559e-02f, 8.85555819e-02f, 1.74402252e-01f, 8.55284464e-03f, -7.49667808e-02f, -1.65999830e-02f,
  -4.62020859e-02f, 2.63236146e-02f, -4.08868939e-02f, -7.90826604e-02f, -1.03427414e-02f, 5.19535020e-02f, 3.63483615e-02f, 1.49202095e-02f, 7.38780200e-02f, -3.81367765e-02f,
  1.23549975e-01f, 8.93759057e-02f, -5.18758148e-02f, -5.20294392e-03f, 1.16828181e-01f, 1.93447005e-02f, 2.26754658e-02f, -6.60936683e-02f, 1.99248660e-02f, -2.72013396e-02f,
  -3.27887051e-02f, 6.53192252e-02f, 1.32942542e-01f, -8.45565498e-02f, 5.58219962e-02f, 5.73869757e-02f, -2.34085284e-02f, 3.19475047e-02f, 1.77189242e-02f, -3.44225727e-02f,
  1.27091140e-01f, 2.74187326e-02f, -4.22957130e-02f, 1.42201120e-02f, -8.46973732e-02f, 2.31020655e-02f, 8.08674656e-03f, 4.39485051e-02f, 4.55766777e-03f, 2.25874800e-02f,
  5.04173674e-02f, -2.24658418e-02f, 8.37450325e-02f, -1.29885375e-01f, -1.29618626e-02f, 3.46680619e-02f, 1.11364629e-02f, -2.43895501e-02f, 3.45253609e-02f, -1.01962844e-02f,
  -9.83485859e-03f, -2.12019999e-02f, -8.01088214e-02f, 1.59950212e-01f, -5.49169555e-02f, -2.59700473e-02f, -3.04213688e-02f, -2.30760295e-02f, -6.04000650e-02f, -5.15291095e-03f,
  -1.46764860e-01f, -2.80612886e-01f, -6.54531270e-02f, 5.42106889e-02f, -7.61448070e-02f, -7.82235805e-03f, -7.99706727e-02f, 1.05003528e-02f, -3.56749222e-02f, -1.99066866e-02f,
  -6.43120706e-03f, 3.14273778e-03f, -1.20145837e-02f, -3.47213028e-03f, -3.94908041e-02f, -2.47841924e-02f, -2.20757145e-02f, 2.29990128e-02f, 4.74689752e-02f, -1.89866452e-03f,
  3.36059183e-02f, -1.44047393e-02f, 2.22714357e-02f, -1.49714286e-02f, 7.74330925e-03f, 8.49744212e-03f, 6.15629591e-02f, 2.06345879e-02f, 2.76225284e-02f, 6.98603923e-03f,
  1.34006202e-01f, 1.27151921e-01f, -3.98983419e-01f, 6.78202659e-02f, 9.10103619e-02f, -1.92787468e-01f, 4.76093739e-02f, 8.18445608e-02f, -3.43311839e-02f, 7.28742629e-02f,
  2.75655031e-01f, -1.28974408e-01f, 1.27325743e-01f, 1.33300975e-01f, 3.29744577e-01f, 2.73665842e-02f, 2.48188809e-01f, 5.63588366e-02f, -1.31055862e-01f, 1.52065605e-01f,
  2.18024328e-02f, 3.94695997e-01f, -1.40874505e-01f, 4.10834812e-02f, -7.20404312e-02f, -2.20968112e-01f, 3.92849207e-01f, -1.09875992e-01f, 6.62698746e-02f, 9.20068994e-02f,
  -4.32979502e-03f, 1.03210844e-01f, -9.36290026e-02f, -6.97316974e-02f, 4.26715426e-02f, 5.64416833e-02f, -1.04601551e-02f, -3.35303918e-02f, -6.43281192e-02f, -1.13401204e-01f,
  -6.37852252e-02f, -5.29135764e-02f, 6.33593798e-02f, -7.36268908e-02f, -3.17050330e-02f, -8.94604027e-02f, -1.40316799e-01f, -1.53141528e-01f, 1.47134885e-02f, -8.26022997e-02f,
  -8.05248842e-02f, -1.21839583e-01f, 6.46789093e-03f, 1.44356536e-02f, -3.07314079e-02f, -8.50972906e-02f, -1.58564657e-01f, -6.31543323e-02f, 3.03189214e-02f, -4.10234816e-02f,
  2.59918850e-02f, 1.46068081e-01f, 7.13679520e-03f, 2.18208823e-02f, 1.74759682e-02f, -3.47248577e-02f, -3.98076065e-02f, 7.11177289e-02f, -5.87677844e-02f, -1.27040939e-02f,
  6.93166554e-02f, 5.84099442e-02f, 1.27060767e-02f, -3.30981091e-02f, 6.70512579e-03f, -2.29167566e-02f, -7.72496359e-03f, -4.94552664e-02f, 1.29169375e-02f, -3.87706123e-02f,
  3.27076726e-02f, 7.63935875e-03f, 7.00555742e-02f, 1.12349363e-02f, -2.89515220e-02f, -5.55458060e-03f, -2.41944827e-02f, -1.97656900e-01f, 4.65654209e-02f, 2.60292906e-02f,
  2.76440263e-01f, 3.05429131e-01f, 4.63622473e-02f, -7.09584802e-02f, -5.57193011e-02f, 7.02996776e-02f, 4.11115363e-02f, -1.59137428e-01f, 9.01748314e-02f, 2.32735537e-02f,
  -3.93942967e-02f, 1.98565032e-02f, 2.99654417e-02f, -1.12881307e-02f, 9.76660475e-02f, 4.31364104e-02f, 1.34128287e-01f, 6.46439195e-02f, 1.59597918e-01f, 7.37561956e-02f,
  9.08080209e-03f, 2.33358499e-02f, -5.03761210e-02f, 1.88174378e-02f, -4.31705900e-02f, 4.26128767e-02f, 2.17711143e-02f, -4.95831408e-02f, -6.27721176e-02f, 4.22152169e-02f,
  -5.14235795e-01f, 2.76869416e-01f, 4.79690433e-01f, -2.15436697e-01f, -3.45201641e-01f, -2.93627918e-01f, 1.93539895e-02f, -3.68331261e-02f, -2.64771670e-01f, 1.46102324e-01f,
  1.45238061e-02f, 2.01876342e-01f, 2.23863855e-01f, -4.08262946e-02f, -2.87474424e-01f, 6.46954402e-02f, -1.90556034e-01f, -6.30291253e-02f, -1.76304858e-02f, -6.08735606e-02f,
  -4.33563106e-02f, -2.05866337e-01f, 2.28153065e-01f, 1.02020748e-01f, -2.59157903e-02f, 5.22984415e-02f, 3.30076255e-02f, 3.26519638e-01f, -1.39588743e-01f, 3.72122005e-02f,
  1.44330288e-05f, 9.35596600e-02f, 2.26058904e-02f, 8.19471106e-02f, -8.56167376e-02f, -2.39579864e-02f, 8.66663158e-02f, 1.01201467e-01f, 2.51394883e-02f, -2.77219582e-02f,
  7.33502954e-02f, -8.88989344e-02f, 3.83895327e-04f, 3.01614627e-02f, -1.23998247e-01f, 6.18552268e-02f, 2.05209292e-02f, -5.45848981e-02f, 2.99810581e-02f, -5.27345669e-03f,
  1.45816868e-02f, 3.83282676e-02f, 2.23450661e-02f, 7.54581951e-03f, 3.54856215e-02f, 2.53351163e-02f, 2.73943637e-02f, 4.43223454e-02f, -3.83283794e-02f, -1.02893151e-01f,
  1.39594004e-01f, -3.24438214e-02f, 4.26777154e-02f, 1.18121020e-02f, -9.05326009e-02f, 4.68282886e-02f, -9.06646674e-05f, 3.66759710e-02f, 5.89620322e-02f, 6.87476154e-03f,
  -9.58875343e-02f, -8.47287253e-02f, 1.95938852e-02f, -2.34352844e-03f, -7.00093359e-02f, -3.45499464e-03f, -6.05410943e-03f, 6.10420480e-04f, -1.09137908e-01f, -8.60408545e-02f,
  1.12230003e-01f, -6.37978613e-02f, -1.46734214e-03f, -1.46592101e-02f, 9.17317579e-04f, 1.50469933e-02f, 7.31926486e-02f, 2.88548023e-02f, 9.74578261e-02f, -2.01720204e-02f,
  -3.65068525e-01f, 3.73369493e-02f, -1.04813268e-02f, -5.14917485e-02f, -9.16798972e-03f, -5.36764115e-02f, 1.08310422e-02f, -6.44345954e-02f, 1.31887376e-01f, -2.01471653e-02f,
  1.48250712e-02f, -8.54507834e-02f, -1.05510086e-01f, -8.16344842e-02f, 5.65581918e-02f, -6.02884218e-02f, 6.06800504e-02f, -4.14609946e-02f, -1.23540014e-01f, -4.71291840e-02f,
  3.90911624e-02f, -6.97993720e-03f, 5.86175248e-02f, -6.09885231e-02f, 2.31647510e-02f, 9.21979826e-03f, -8.28875229e-02f, 6.50297254e-02f, 3.04632448e-03f, 2.38666665e-02f,
  2.28352159e-01f, 1.53735802e-01f, -9.73286256e-02f, -3.97567987e-01f, -5.90120926e-02f, 4.93537784e-01f, 3.11184555e-01f, -1.21613994e-01f, -2.88576335e-01f, 1.56668946e-01f,
  3.09957862e-02f, 2.18734682e-01f, 2.39672050e-01f, -1.92616284e-01f, 1.24385089e-01f, 7.12140724e-02f, -3.04492172e-02f, 2.22667024e-01f, -1.82115778e-01f, -1.23572052e-01f,
  -1.37035280e-01f, 2.05494324e-03f, -1.73876286e-01f, -1.18372612e-01f, -6.89027384e-02f, -1.83012143e-01f, -1.05085045e-01f, -6.28839061e-02f, -4.74217050e-02f, 1.54593199e-01f,
  -2.27992819e-03f, -1.82960525e-01f, -6.46501333e-02f, -4.19990979e-02f, -4.64950316e-02f, 1.06582567e-01f, 9.35078338e-02f, 7.20951632e-02f, -1.29554525e-01f, -4.50616367e-02f,
  2.00149387e-01f, -1.15077915e-02f, -1.29612477e-03f, 9.53166932e-03f, -5.01110889e-02f, -1.02482848e-01f, -8.89821351e-03f, 1.05572268e-01f, -5.82322776e-02f, 1.13523111e-01f,
  -6.60334772e-05f, -3.86538878e-02f, -5.30446600e-03f, 2.63771210e-02f, 4.82076034e-02f, -4.38937992e-02f, 5.33914603e-02f, 1.10023066e-01f, 1.59082651e-01f, -1.76420882e-02f,
  9.90798473e-02f, -3.37599702e-02f, 7.26789683e-02f, -6.61475882e-02f, -4.81816381e-02f, -7.64105991e-02f, 2.01231111e-02f, 9.77325141e-02f, -9.28094536e-02f, 6.83936551e-02f,
  -7.83688426e-02f, 2.38398761e-02f, -3.87386754e-02f, -1.71448886e-02f, 7.32576028e-02f, -1.12078181e-02f, 4.45848890e-02f, 3.30687165e-02f, 2.78716478e-02f, -2.70288996e-02f,
  -1.11896098e-01f, -5.07060811e-03f, -1.85030848e-02f, 1.56520028e-02f, -2.50050053e-02f, 6.12670928e-02f, -4.59062755e-02f, -5.58193354e-03f, -8.13102499e-02f, 1.39939338e-01f,
  4.78550158e-02f, 8.67084339e-02f, -2.86593176e-02f, 8.44786968e-03f, 3.51394750e-02f, 1.92916822e-02f, -2.31723650e-03f, 2.48450637e-02f, 5.14599495e-02f, 1.68062851e-03f,
  1.71618480e-02f, 2.40899646e-03f, -3.68591840e-03f, 8.10583010e-02f, -1.31389676e-02f, 4.35143337e-02f, -3.87952337e-03f, 2.80001690e-03f, -3.74804949e-04f, 1.00562451e-02f,
  -1.39946425e-02f, 1.03696823e-01f, -1.10068722e-02f, 4.54972424e-02f, 8.97454321e-02f, -1.72683112e-02f, 2.43423674e-02f, 2.70412136e-02f, 7.56906047e-02f, -4.22301814e-02f,
  -1.99430496e-01f, -5.84414825e-02f, 1.87005386e-01f, -1.36762679e-01f, 2.91067541e-01f, 1.75195619e-01f, -1.89878896e-01f, 3.39768767e-01f, -2.82632768e-01f, -9.36123431e-02f,
  -1.05483122e-01f, -2.97818005e-01f, -2.51655787e-01f, -2.33402103e-01f, -2.37295955e-01f, -4.36951876e-01f, -1.95104331e-01f, -2.33343914e-01f, -2.16109619e-01f, 8.31071958e-02f,
  7.87935853e-02f, 4.29297565e-03f, 2.22644851e-01f, 3.36759478e-01f, 3.10341448e-01f, 3.31540614e-01f, 2.11344585e-01f, 1.39955893e-01f, 1.78576678e-01f, -5.79792298e-02f,
  5.57825156e-03f, -1.49278179e-01f, 2.21304987e-02f, -6.28908351e-02f, 6.70396239e-02f, 2.89461482e-02f, -9.98595580e-02f, -5.53443991e-02f, 4.01494093e-02f, 6.20745728e-03f,
  -1.09195769e-01f, 5.32886153e-03f, -1.08848698e-01f, -5.32448255e-02f, -7.70823732e-02f, -6.85888007e-02f, -1.55700706e-02f, 1.09235816e-01f, -2.92113554e-02f, 2.23462610e-03f,
  1.08671477e-02f, -3.88225960e-03f, -8.83873180e-02f, -5.56353629e-02f, 2.14637350e-02f, -8.13736171e-02f, 3.38440649e-02f, 6.58832341e-02f, 7.66538456e-03f, 2.67046988e-02f,
  2.34131012e-02f, -1.13977054e-02f, -7.10910885e-03f, -1.06138103e-01f, -1.26618445e-02f, -3.80170979e-02f, -1.54797181e-01f, 4.61790226e-02f, 3.40080261e-02f, -2.95360498e-02f,
  5.84621727e-02f, 2.42641401e-02f, -5.07023893e-02f, 8.95770639e-02f, 6.32184185e-03f, -7.52907898e-03f, 1.09804953e-02f, -1.24901710e-02f, 1.06140412e-01f, 1.17009766e-01f,
  -8.09644833e-02f, 3.50299068e-02f, 9.10616815e-02f, 5.64878620e-03f, -1.37701914e-01f, 1.47616297e-01f, -6.30560797e-03f, 1.07198181e-02f, 2.89395768e-02f, 1.38947386e-02f,
  9.95852351e-02f, 4.63386215e-02f, 4.67187762e-02f, 2.24745926e-02f, -1.12875953e-01f, -4.23985049e-02f, -1.15097269e-01f, 5.42159602e-02f, 1.43753430e-02f, -8.87087286e-02f,
  1.90460101e-01f, 7.35678524e-02f, 3.26061435e-02f, 4.34997082e-02f, 5.55321649e-02f, 1.67382341e-02f, -7.92837590e-02f, -1.72607005e-02f, 3.87633368e-02f, 8.65768418e-02f,
  1.43907860e-01f, 3.94026190e-02f, -3.40642668e-02f, 1.02690548e-01f, 3.05159856e-02f, 2.61042118e-02f, -2.29868479e-02f, 5.58837652e-02f, 5.50786918e-03f, -1.79875642e-01f,
  -5.89632168e-02f, -2.91165914e-02f, 4.04529482e-01f, 1.14030764e-01f, -1.48304731e-01f, 1.34841785e-01f, 3.22830319e-01f, -1.24091841e-01f, 1.48675010e-01f, -1.49011180e-01f,
  -1.77049190e-02f, 7.03884959e-02f, 1.51752517e-01f, -6.44018725e-02f, -1.64965689e-01f, 1.22317962e-01f, -2.87170168e-02f, -6.15071058e-02f, 1.21649794e-01f, -4.59758230e-02f,
  1.28799543e-01f, -3.31000954e-01f, 2.32533678e-01f, -7.23014325e-02f, 7.16841146e-02f, 7.76500031e-02f, -3.11600059e-01f, 1.45126313e-01f, -2.99716145e-01f, -7.56606087e-02f,
  6.92993328e-02f, 1.80565387e-01f, 1.79394141e-01f, 7.77375624e-02f, 8.45262595e-03f, -9.10279527e-02f, 1.52823245e-02f, 1.93552598e-01f, 1.36277499e-02f, -3.41906883e-02f,
  -2.23650392e-02f, -5.81320152e-02f, -4.06217575e-02f, 5.10822684e-02f, -3.04360427e-02f, 7.11177513e-02f, 2.66376138e-02f, 9.46646109e-02f, 6.01973049e-02f, 7.84606040e-02f,
  7.59550855e-02f, 4.51714881e-02f, 1.68282121e-01f, -6.35290798e-03f, 5.42027429e-02f, 1.36142790e-01f, 1.29053280e-01f, -8.53168666e-02f, -9.52117965e-02f, -6.04336672e-02f,
  5.58578782e-02f, 5.49001992e-03f, 4.07564901e-02f, -4.86022830e-02f, -4.10992578e-02f, -2.89354306e-02f, -4.30498831e-02f, -4.95032072e-02f, -5.65485321e-02f, 1.35158701e-03f,
  -7.75660872e-02f, -5.98476045e-02f, -1.98897347e-02f, 6.52172342e-02f, 3.14813037e-03f, 1.33483782e-02f, 8.00634399e-02f, -9.03979316e-02f, 3.34176682e-02f, -2.07626121e-03f,
  -9.11031291e-02f, 2.73658931e-02f, 2.30118502e-02f, 2.04923023e-02f, 5.12633249e-02f, -5.49953207e-02f, -3.09098922e-02f, 5.63291907e-02f, 6.99076504e-02f, -2.04838067e-02f,
  -3.65040183e-01f, -4.64210033e-01f, -1.17000928e-02f, -7.94137046e-02f, -5.99708706e-02f, -4.37392257e-02f, 1.11492418e-01f, -6.54760674e-02f, -4.32743505e-02f, 1.30987260e-02f,
  6.01351857e-02f, -7.94051364e-02f, -8.58561769e-02f, 1.99912731e-02f, 3.22333649e-02f, -3.10358722e-02f, -9.14276019e-02f, -6.27212226e-02f, -8.90017226e-02f, -1.48072302e-01f,
  -1.16771460e-01f, -2.73244809e-02f, 3.65833426e-03f, 2.02926970e-03f, -4.85736318e-03f, -8.70880485e-02f, -1.28216475e-01f, 9.94802341e-02f, -8.04625601e-02f, -8.80634412e-02f,
  3.50446999e-01f, -2.98245341e-01f, 2.02140272e-01f, 3.15884084e-01f, 2.46457949e-01f, 1.94056833e-03f, 2.25727499e-01f, 7.84509033e-02f, 2.76501268e-01f, -2.44994119e-01f,
  2.55021989e-01f, -2.63807416e-01f, -1.56532645e-01f, 5.71850538e-02f, 1.56480625e-01f, -2.83584863e-01f, 2.57319629e-01f, -2.31571142e-02f, -4.17115241e-02f, 1.20506361e-01f,
  1.85666397e-01f, 1.20458871e-01f, 1.73292294e-01f, -1.44956470e-01f, 4.03146267e-01f, 8.45270976e-02f, 1.37965485e-01f, -1.37509862e-02f, 2.00795934e-01f, -6.85773883e-03f,
  2.38878839e-02f, 8.64208415e-02f, 9.07927006e-02f, 5.58859482e-02f, 1.91280216e-01f, 7.49840587e-02f, 6.72752932e-02f, 2.90688518e-02f, 8.87704939e-02f, 2.36003883e-02f,
  -5.39449006e-02f, 3.51171270e-02f, 3.56605984e-02f, -1.29663974e-01f, 1.55900002e-01f, 4.10446897e-02f, 5.22354171e-02f, 9.54853818e-02f, 1.73207745e-02f, -5.36177133e-04f,
  5.01895472e-02f, 7.66106322e-02f, 1.21965908e-01f, 4.77633923e-02f, 1.10998549e-01f, 9.61330011e-02f, -5.80029236e-03f, 6.25811592e-02f, 2.95016523e-02f, 1.46608889e-01f,
  4.45580035e-02f, 1.40070803e-02f, -9.19221435e-03f, 5.36454357e-02f, -2.01606235e-04f, 2.89687030e-02f, 3.44011486e-02f, -2.52826195e-02f, -9.51280410e-04f, 7.75919259e-02f,
  6.93753883e-02f, -4.70581725e-02f, 3.93684916e-02f, 9.31840837e-02f, 3.10751908e-02f, 4.83447611e-02f, -4.82356809e-02f, -1.14401326e-01f, 6.65780678e-02f, -7.16981571e-03f,
  2.11208556e-02f, 3.98044474e-03f, 2.87806150e-02f, -6.48173094e-02f, 6.69500232e-03f, 1.13962358e-02f, -4.54389816e-03f, 4.99344338e-03f, -2.33981686e-04f, 3.86862159e-02f,
  7.03574121e-02f, 1.11341044e-01f, 5.80102205e-03f, 6.02259301e-02f, -3.13295536e-02f, -7.56146908e-02f, -6.85859546e-02f, -1.36999249e-01f, -5.72979404e-03f, 1.12538284e-03f,
  6.29733354e-02f, -8.47994408e-04f, 6.73567727e-02f, -3.77748497e-02f, -8.90505314e-02f, 6.06943406e-02f, 1.22693041e-02f, -7.79177547e-02f, 9.83383656e-02f, -3.78350243e-02f,
  -1.13242701e-01f, 7.76508590e-03f, -5.48862852e-02f, 1.06619015e-01f, -1.66567899e-02f, 3.54512408e-02f, -3.20215430e-03f, 1.94782317e-02f, 1.44672208e-02f, -4.32971157e-02f,
  1.78591162e-01f, 1.88360333e-01f, 3.27134520e-01f, 3.16949517e-01f, -2.52184451e-01f, -2.55408227e-01f, 2.54222482e-01f, -8.07285607e-02f, 3.79016697e-01f, 2.27450952e-02f,
  -2.21044317e-01f, 2.06214190e-01f, 1.53413132e-01f, -8.78825560e-02f, 1.15981802e-01f, 4.38499451e-01f, -2.02073203e-03f, 5.83445616e-02f, 1.67967319e-01f, -1.14077039e-01f,
  1.55919030e-01f, -3.44085962e-01f, 1.30482420e-01f, -2.90118277e-01f, -8.59187022e-02f, 1.38804421e-01f, -1.42382920e-01f, -7.07820728e-02f, -3.00838858e-01f, -1.51799664e-01f,
  3.13816443e-02f, 4.10957821e-02f, 4.36531752e-02f, 4.76058945e-02f, -2.85413992e-02f, -1.11241817e-01f, 4.03551422e-02f, -3.93110290e-02f, 5.58445379e-02f, 9.42088813e-02f,
  2.98463255e-02f, -6.86514229e-02f, 5.95714897e-02f, 3.20150459e-04f, -6.21431991e-02f, 4.17840071e-02f, -6.05232194e-02f, -3.16639505e-02f, -2.19214819e-02f, 3.42917629e-02f,
  1.14109062e-01f, -1.56167103e-02f, -6.26918003e-02f, -3.32096666e-02f, 1.04061887e-02f, 1.14768930e-02f, 2.84748748e-02f, 1.62906405e-02f, 1.80221372e-03f, 2.15487592e-02f,
  -1.36070117e-01f, 2.37742383e-02f, -4.77686971e-02f, 1.14670388e-01f, -7.88411945e-02f, 1.69110335e-02f, -5.52878156e-02f, -8.24133083e-02f, -2.11031549e-02f, -3.89595442e-02f,
  2.95975730e-02f, 5.71529148e-03f, -8.03255886e-02f, 4.89120604e-03f, -6.67061582e-02f, 1.11698300e-01f, -1.44514190e-02f, -3.80263031e-02f, 8.46763775e-02f, -2.62681637e-02f,
  1.60944108e-02f, 1.77921299e-02f, 1.48375249e-02f, -7.09276572e-02f, -3.66180837e-02f, 7.96028972e-02f, -4.67154570e-02f, 6.85827211e-02f, 5.72593324e-02f, -7.24879429e-02f,
  -7.58635327e-02f, -5.74667156e-02f, -1.01851329e-04f, 8.07531737e-03f, 6.40399233e-02f, -4.85178083e-02f, 1.54018204e-03f, -4.70545553e-02f, -3.42330802e-03f, -7.95585662e-02f,
  -7.28000477e-02f, 5.34513891e-02f, -1.49650248e-02f, -7.54244849e-02f, 3.96127999e-02f, -3.11091449e-02f, 6.80487752e-02f, 8.37812573e-02f, -8.13919827e-02f, -6.48091733e-02f,
  -9.97379646e-02f, 8.47949460e-02f, -5.92543883e-03f, -7.63983466e-03f, -3.99993919e-02f, -5.38773946e-02f, -7.87839070e-02f, 8.13023224e-02f, -7.98727497e-02f, 4.45717424e-02f,
  -5.69849372e-01f, 3.67160022e-01f, 4.28147279e-02f, -1.26778618e-01f, 6.42373487e-02f, -4.10653604e-03f, -8.88856128e-03f, 1.59334660e-01f, 5.65388314e-02f, 2.22589895e-01f,
  1.03714883e-01f, -6.61917031e-02f, 1.35300994e-01f, -1.09974127e-02f, -3.36193562e-01f, 3.71887460e-02f, -5.24641089e-02f, -8.42810497e-02f, 1.03751875e-01f, 6.42473325e-02f,
  -2.07960904e-02f, -2.30019279e-02f, -2.42548674e-01f, 2.66590208e-01f, 1.05345026e-02f, 7.30576292e-02f, 4.68844287e-02f, 1.89230740e-01f, -9.25039575e-02f, -3.37611139e-02f,
  -8.09635147e-02f, 3.82080637e-02f, -4.86132652e-02f, -3.78869735e-02f, 8.71952623e-02f, -8.21459386e-03f, -6.54126182e-02f, -7.34458342e-02f, -2.89763585e-02f, 1.67637912e-03f,
  9.02413949e-03f, -1.01187818e-01f, 1.72600970e-02f, 2.25120913e-02f, -3.81747782e-02f, -4.37514745e-02f, -5.00057079e-03f, -1.07151061e-01f, 5.83442822e-02f, -6.41892403e-02f,
  -3.35413031e-02f, -6.30199909e-02f, 3.86280566e-02f, 2.16335431e-02f, 4.80116494e-02f, 1.21936211e-02f, -4.71051037e-02f, 1.40461698e-02f, -1.02138132e-01f, 1.85276456e-02f,
  -1.49603821e-02f, 3.91275883e-02f, -2.54043639e-02f, -8.82337317e-02f, 1.90221295e-02f, -1.42890410e-02f, -6.52149096e-02f, -6.58349544e-02f, 4.02755588e-02f, 2.08925251e-02f,
  -2.42300145e-02f, -4.84271049e-02f, 6.03445917e-02f, -1.50215834e-01f, -3.39529961e-02f, -3.15093882e-02f, -4.73378785e-02f, 8.04793015e-02f, 5.24102040e-02f, -9.26804245e-02f,
  4.38690260e-02f, 1.64441729e-03f, 5.30339405e-02f, 4.37268689e-02f, 6.67839823e-03f, -5.36353774e-02f, 1.09884739e-01f, 1.60229057e-02f, 7.12363124e-02f, -6.45670518e-02f,
  1.89699143e-01f, 5.10381699e-01f, 9.03932005e-02f, 1.95812471e-02f, 2.07018796e-02f, 4.25828621e-02f, 6.01636544e-02f, 8.32564011e-03f, -1.30603872e-02f, 1.29036814e-01f,
  4.42098454e-02f, 1.77564323e-02f, 2.35280767e-02f, -9.25004929e-02f, -3.21108885e-02f, 1.12599529e-01f, -1.42732612e-03f, 7.79246688e-02f, 3.60575095e-02f, 2.70023439e-02f,
  -4.87467162e-02f, 1.98816396e-02f, -1.49059802e-01f, 6.78013340e-02f, 7.23682866e-02f, 4.84798439e-02f, 1.22504778e-01f, -8.71022716e-02f, 5.20545170e-02f, -8.17836449e-03f,
  5.39801240e-01f, -4.11150962e-01f, -1.51894212e-01f, 1.13626689e-01f, 3.99341315e-01f, 1.21941045e-02f, 2.85783678e-01f, 5.42339087e-02f, -1.83729902e-01f, -2.00034276e-01f,
  2.53403395e-01f, -6.30757958e-02f, 3.50037999e-02f, -1.77440614e-01f, 2.08736584e-01f, -4.42074299e-01f, -4.04338017e-02f, -4.86290231e-02f, -1.29362762e-01f, 3.38857144e-01f,
  2.16043610e-02f, 3.02020103e-01f, -7.46021643e-02f, -1.10027995e-02f, 1.89734802e-01f, 6.32515848e-02f, 3.18961203e-01f, 2.82944944e-02f, -1.96976028e-02f, 3.59640643e-02f,
  5.37635051e-02f, -9.14963186e-02f, -2.29041558e-02f, -1.23953409e-01f, 1.88340172e-01f, 8.87467265e-02f, 2.46394593e-02f, 2.50586066e-02f, 3.25030163e-02f, -1.55807370e-02f,
  -3.53102311e-02f, 9.21713281e-03f, -5.37825897e-02f, -6.01276793e-02f, 2.11446993e-02f, -4.76323217e-02f, -1.69203505e-01f, -1.33006379e-01f, -6.06455505e-02f, -6.28060326e-02f,
  -7.71775544e-02f, -7.10056722e-02f, -8.31870884e-02f, -6.05977476e-02f, 9.04344097e-02f, -2.21114252e-02f, -1.82151794e-02f, 9.37215164e-02f, -1.19777992e-01f, 4.11710329e-02f,
  -3.88582796e-02f, 7.57478178e-02f, -2.64568813e-02f, -4.20809090e-02f, -2.63077039e-02f, 6.16459213e-02f, -1.30357072e-01f, -2.04318780e-02f, 5.80553412e-02f, 5.38798608e-02f,
  1.29046276e-01f, 6.61301985e-02f, -1.62362959e-02f, 5.67925535e-02f, 1.28148049e-01f, 3.21939518e-03f, -2.14065565e-03f, 1.08600780e-02f, 1.21341191e-01f, -2.86200028e-02f,
  -7.42315408e-03f, 7.78873684e-03f, 3.90383527e-02f, 5.16429991e-02f, -7.93254673e-02f, 9.44550335e-02f, -6.72543049e-02f, -5.82097434e-02f, 2.35848520e-02f, 1.02077916e-01f,
  1.03880398e-01f, 1.14087373e-01f, -8.51429254e-03f, 3.81329954e-02f, -1.32152677e-01f, -9.04997215e-02f, -7.93345571e-02f, -9.04558152e-02f, -3.07294950e-02f, -3.76459733e-02f,
  4.23883907e-02f, 3.99431810e-02f, 2.33822502e-02f, 7.30273277e-02f, -2.83218622e-02f, 1.05158888e-01f, 8.15915018e-02f, 8.83884653e-02f, 8.66802335e-02f, 8.34505111e-02f,
  1.37618840e-01f, 1.16620734e-01f, -6.31358176e-02f, 6.40797615e-02f, 7.08764121e-02f, 5.77025749e-02f, 4.01105694e-02f, -4.02066708e-02f, -3.76374610e-02f, -1.19166531e-01f,
  -4.01145607e-01f, -6.57483488e-02f, -1.79647461e-01f, -5.31071067e-01f, 1.62404060e-01f, 1.19072780e-01f, -4.66352284e-01f, 2.04871580e-01f, -1.80880055e-01f, -7.45380372e-02f,
  -9.49827656e-02f, -3.60441923e-01f, -1.29113406e-01f, -3.59615177e-01f, -2.34447226e-01f, -1.42712206e-01f, -4.46852237e-01f, -2.91279346e-01f, 4.43894453e-02f, -1.35828570e-01f,
  -1.43574163e-01f, -1.96653217e-01f, -1.10513583e-01f, 3.85724038e-01f, -4.01324593e-03f, 1.62891462e-01f, 1.03889309e-01f, 2.15796217e-01f, 1.23387061e-01f, 4.44859490e-02f,
  -4.59927917e-02f, -1.69724196e-01f, 3.00525092e-02f, 1.18087593e-03f, -6.35966584e-02f, 4.74531054e-02f, -8.83857310e-02f, 4.59000729e-02f, -3.28708589e-02f, 1.96292810e-03f,
  -7.08050728e-02f, -1.93529706e-02f, -6.48250207e-02f, -2.20187511e-02f, -2.21314952e-02f, 1.02776714e-01f, -4.30161394e-02f, -3.79088824e-03f, 2.32632142e-02f, -6.45010620e-02f,
  -8.20890442e-03f, 2.43043597e-03f, -1.01312816e-01f, -8.31024647e-02f, -1.53514966e-02f, -1.15186639e-01f, -1.38803059e-02f, -1.01894205e-02f, 8.12010840e-02f, 3.05794943e-02f,
  -6.24115095e-02f, -8.81249364e-03f, -1.76047701e-02f, 7.48367831e-02f, 2.54187677e-02f, 8.21192786e-02f, -7.46863037e-02f, 4.66017462e-02f, 3.23211104e-02f, 1.84719600e-02f,
  9.00197104e-02f, -1.02232561e-01f, 6.13089502e-02f, 1.67851560e-02f, -5.06977364e-02f, 3.03926878e-02f, -4.22096252e-03f, 3.40275206e-02f, 3.18647921e-02f, 8.17639977e-02f,
  -2.72180177e-02f, -5.66238500e-02f, -3.48966978e-02f, 4.07703333e-02f, -7.03858361e-02f, -7.25688189e-02f, -1.52219972e-02f, -2.21654642e-02f, 6.96944213e-03f, 2.57615894e-02f,
  -7.29117692e-02f, -8.91471878e-02f, -1.89267070e-04f, 3.73582495e-03f, 2.21188739e-02f, 7.81658068e-02f, -9.12244990e-02f, 2.80339066e-02f, 4.44937944e-02f, 1.89939793e-03f,
  -6.06328882e-02f, 6.41297325e-02f, 5.47341816e-02f, 2.88524628e-02f, -1.91983990e-02f, -8.80841464e-02f, -1.50457725e-01f, -3.89761627e-02f, -3.36844660e-02f, 4.42695133e-02f,
  3.11848689e-02f, -2.65393928e-02f, 3.29999514e-02f, 1.13639690e-01f, 7.39135370e-02f, -1.04018310e-02f, 4.54705914e-05f, 5.44892140e-02f, 4.92334291e-02f, -4.73019630e-02f,
  -2.85092384e-01f, -3.48741710e-01f, 1.01990141e-01f, -2.57190555e-01f, -1.57849148e-01f, -3.73048842e-01f, -1.17608145e-01f, -1.08130731e-01f, -1.34462893e-01f, -1.60482258e-01f,
  7.02067558e-03f, -1.05146691e-01f, 2.99755335e-01f, -3.53948861e-01f, -2.38182172e-01f, 3.06124270e-01f, -3.99077237e-01f, -2.84177601e-01f, 1.14330173e-01f, -2.22671390e-01f,
  -1.28416885e-02f, -1.71231285e-01f, 6.01565093e-02f, -9.42030624e-02f, -2.61642218e-01f, -1.93823241e-02f, 1.31476745e-01f, 2.78562129e-01f, -1.01140827e-01f, 2.98068337e-02f,
  -1.19697787e-01f, 7.14402786e-03f, 1.31298434e-02f, 9.77447703e-02f, -8.19382966e-02f, -3.80399227e-02f, 4.65636374e-03f, 7.78803974e-02f, -1.89085049e-03f, -5.61978435e-03f,
  6.26758635e-02f, 1.47195188e-02f, -1.76774580e-02f, -8.62058159e-03f, -8.91066343e-02f, -2.33896542e-02f, -2.86824424e-02f, -5.07556759e-02f, -1.16777164e-03f, -5.86053133e-02f,
  -4.33688425e-02f, -1.00511508e-02f, -1.23710297e-01f, -4.31428291e-02f, 9.18408670e-03f, -3.52614410e-02f, -8.95790458e-02f, 1.45926857e-02f, -1.50295440e-02f, -1.27668843e-01f,
  -3.17413695e-02f, -6.40125945e-02f, 3.36839259e-02f, 5.09510152e-02f, -3.89704481e-02f, 1.18434697e-01f, -2.65155341e-02f, 4.84848954e-02f, 2.22778134e-02f, -4.75138836e-02f,
  1.34438754e-03f, 2.62454934e-02f, -2.13417020e-02f, -3.68300341e-02f, -4.52461541e-02f, -5.61259463e-02f, 6.51423866e-03f, 1.08722687e-01f, 3.23903374e-02f, 6.81382790e-03f,
  4.61576693e-02f, -5.59902564e-02f, 6.77042082e-02f, 3.02550476e-02f, -9.62347910e-02f, 9.61298421e-02f, -1.68583859e-02f, 3.10235228e-02f, -1.79274976e-02f, -1.38920275e-02f,
  -4.05758917e-02f, -2.42705584e-01f, 6.45268932e-02f, -1.70098022e-02f, 9.78945047e-02f, -2.47484557e-02f, -1.27350737e-03f, -4.71583270e-02f, 8.52436107e-03f, 1.57837756e-02f,
  -5.80872633e-02f, -7.18925893e-02f, 1.21707499e-01f, -2.15010229e-03f, 5.56291686e-03f, -6.71155974e-02f, 7.88319707e-02f, 5.32422289e-02f, -8.75368714e-02f, -2.82495581e-02f,
  2.24710684e-02f, 3.54345255e-02f, 3.46525684e-02f, -5.29203601e-02f, -5.64890839e-02f, 4.30005342e-02f, -1.97153434e-01f, 3.58851776e-02f, 7.43375123e-02f, 5.35782613e-02f,
  7.31980875e-02f, 3.62231851e-01f, 2.91635960e-01f, 1.20574132e-01f, 4.76832017e-02f, -1.32954726e-02f, -9.04564261e-02f, 2.92858243e-01f, 1.55417532e-01f, -8.06457363e-03f,
  -2.01878786e-01f, 2.51784116e-01f, -1.05635613e-01f, -1.74190298e-01f, -2.06811413e-01f, -2.21844092e-01f, -1.01259738e-01f, -1.55734763e-01f, 4.62194867e-02f, 2.69155443e-01f,
  8.02173316e-02f, -1.36584237e-01f, 1.25764534e-01f, 2.49790519e-01f, 2.22180188e-01f, 3.53042513e-01f, -9.17530656e-02f, 1.61311015e-01f, -3.64803746e-02f, -1.91640675e-01f,
  -1.71472758e-01f, 3.18656899e-02f, 1.71090543e-01f, -1.19873034e-02f, 9.02685076e-02f, 7.77473254e-03f, -1.51139811e-01f, -1.72357203e-03f, -8.22249521e-03f, 1.93584152e-02f,
  -4.65210751e-02f, -3.79433744e-02f, -4.22874205e-02f, -1.99282244e-02f, -2.62251012e-02f, 4.38532606e-02f, -4.88511026e-02f, -6.40172586e-02f, 2.32269522e-02f, 4.79767695e-02f,
  3.01898886e-02f, -7.76343867e-02f, 1.25685530e-02f, -2.47502342e-01f, -6.46152720e-03f, 3.79514277e-05f, -9.90786701e-02f, -2.02591904e-02f, -7.11598024e-02f, 4.53520827e-02f,
  -7.15434700e-02f, 4.67284843e-02f, 1.69772133e-02f, -1.46723846e-02f, -3.85247171e-02f, -2.87953038e-02f, -1.48285180e-02f, -5.15667014e-02f, 2.18241569e-02f, 3.45327370e-02f,
  -9.62684862e-03f, -4.34182435e-02f, -1.32615805e-01f, -2.30034422e-02f, -7.08592087e-02f, -8.50251410e-03f, 1.61891486e-02f, -8.30321014e-02f, -3.94738466e-02f, 2.17790008e-02f,
  9.61321685e-03f, -8.48399475e-02f, 1.08926632e-01f, -3.83744761e-02f, -7.58297965e-02f, 7.02569559e-02f, -4.71889079e-02f, 4.39523458e-02f, 8.68087411e-02f, 9.27281678e-02f,
  -5.87270558e-02f, 2.60608941e-01f, 1.04274705e-01f, -1.05617933e-01f, -1.53454300e-02f, 2.84647942e-02f, -5.47516122e-02f, 4.91551869e-02f, 2.07162760e-02f, -1.09693697e-02f,
  1.44683998e-02f, 9.63645130e-02f, -3.61167677e-02f, -7.87358135e-02f, 1.24871021e-03f, 6.67597577e-02f, -2.10763626e-02f, -2.07531974e-02f, 4.99093644e-02f, 9.21205580e-02f,
  -1.14722829e-02f, -4.47358191e-02f, 6.72812089e-02f, 8.65314305e-02f, -1.02153793e-01f, -6.24861270e-02f, 8.96352157e-02f, 4.04902771e-02f, -9.81372036e-03f, -3.36274728e-02f,
  -1.54073909e-01f, 1.31174520e-01f, -3.66459936e-01f, -1.67112693e-01f, 3.02881822e-02f, -1.08594373e-01f, 3.10522802e-02f, 7.41380453e-03f, 1.37102976e-01f, 3.07691276e-01f,
  3.79908741e-01f, -1.06606431e-01f, 3.18919331e-01f, 1.86119403e-04f, -5.76103628e-01f, 1.71889499e-01f, -2.61038423e-01f, -3.83022130e-02f, 1.85924303e-02f, -9.38127041e-02f,
  -7.83616379e-02f, -1.47608975e-02f, -1.29342258e-01f, -1.41901329e-01f, -3.66340205e-02f, -1.24045931e-01f, -5.13315946e-03f, -1.25800237e-01f, -1.98829979e-01f, -9.25245285e-02f,
  -4.82629165e-02f, 1.86837852e-01f, -1.69440676e-02f, -2.80948691e-02f, 9.14449058e-03f, 8.79755393e-02f, -5.38976938e-02f, -4.27635126e-02f, 4.46769521e-02f, 5.77800460e-02f,
  6.19939640e-02f, -7.49384165e-02f, -8.01484212e-02f, -6.06603585e-02f, 4.73770723e-02f, -5.34960404e-02f, 1.01530068e-01f, 9.53060761e-02f, -4.45422065e-03f, 4.24973145e-02f,
  7.52731338e-02f, 3.00503196e-03f, -1.00067938e-02f, 1.44299138e-02f, -8.39880928e-02f, 1.60625074e-02f, 8.20714049e-03f, -2.72889342e-02f, 9.81270988e-03f, -3.04831807e-02f,
  -1.94549356e-02f, -1.90067256e-03f, -2.36752592e-02f, 3.79055329e-02f, 9.94935855e-02f, 1.08328342e-01f, -1.38272289e-02f, 5.39132729e-02f, -8.50225389e-02f, 2.17000991e-02f,
  -1.81542244e-03f, -4.22164761e-02f, 5.92969498e-03f, -4.19224706e-03f, -9.02835373e-03f, 5.55334799e-02f, -2.63729654e-02f, 1.02315182e-02f, -5.28276972e-02f, -4.31090742e-02f,
  1.42198121e-02f, -1.17325440e-01f, 2.69522555e-02f, -6.23075338e-03f, 6.50793966e-03f, 9.76458658e-03f, 6.83130405e-04f, -2.47372724e-02f, 4.83520478e-02f, -1.20956860e-01f,
  2.93717571e-02f, 1.88446864e-02f, 3.50158215e-02f, -4.53652106e-02f, -1.66420192e-02f, -2.49925498e-02f, 1.84757391e-05f, -4.47340794e-02f, -3.44529897e-02f, -2.90547702e-02f,
  -6.50290325e-02f, -1.61884632e-02f, -1.81180779e-02f, -5.88762760e-02f, -1.01890758e-01f, 5.69694340e-02f, -2.15068553e-02f, -6.52028322e-02f, -1.25806004e-01f, 6.60504997e-02f,
  -5.32884672e-02f, 1.00237265e-01f, -1.78760532e-02f, -6.11518137e-02f, -2.90132011e-03f, 8.11277237e-03f, -1.03841357e-01f, 8.13539978e-03f, -7.03390315e-02f, 2.69463286e-02f,
  3.76530170e-01f, -1.67416111e-01f, 2.04374641e-01f, -1.21958151e-01f, -6.24437779e-02f, -7.18621686e-02f, 2.58804798e-01f, -1.15865842e-01f, 2.73333162e-01f, -2.83754528e-01f,
  -4.29622263e-01f, 4.10773903e-01f, -3.34377363e-02f, -4.38540488e-01f, 2.91038960e-01f, -2.16754690e-01f, -1.77370116e-01f, -1.97557975e-02f, 1.44824401e-01f, -1.57020107e-01f,
  -2.03804635e-02f, -4.29873496e-01f, -2.57013679e-01f, -2.08003104e-01f, -1.85411707e-01f, 1.75252736e-01f, -1.22165918e-01f, 1.43085942e-01f, -2.30078086e-01f, -2.65797088e-03f,
  -1.46572158e-01f, -1.06185554e-02f, 4.99963835e-02f, 9.83862281e-02f, -4.93802242e-02f, -2.61519160e-02f, -1.70838851e-02f, 1.02660500e-01f, 1.62743151e-01f, 7.70294815e-02f,
  1.25414744e-01f, -5.20795248e-02f, -2.90590953e-02f, 5.19588403e-02f, 2.32836846e-02f, 6.72868360e-03f, -2.06949916e-02f, -7.89157152e-02f, 4.07669656e-02f, -2.98019480e-02f,
  -2.99254153e-02f, -2.85658520e-02f, 2.61999620e-03f, 8.40467773e-03f, 9.99396071e-02f, 2.62693921e-03f, -3.08502391e-02f, 1.74236801e-02f, -2.92030983e-02f, 6.42991439e-02f,
  -1.12880595e-01f, -1.02489651e-03f, -3.46922763e-02f, -1.01842418e-01f, -3.48449871e-02f, -1.32915154e-01f, -4.22773212e-02f, -7.51520395e-02f, 1.52504772e-01f, -9.22935531e-02f,
  2.77090408e-02f, 4.67742421e-02f, -3.16639096e-02f, -4.01845295e-03f, -8.60250369e-02f, -7.97996949e-03f, 4.42586318e-02f, -3.03348154e-02f, -7.91357737e-03f, -1.23736216e-02f,
  1.13328099e-01f, -1.24472827e-02f, -7.01449113e-03f, -2.00730120e-03f, -4.49341573e-02f, 3.77063230e-02f, -3.63218524e-02f, -7.48300105e-02f, 1.04227308e-02f, -7.55742788e-02f,
  -3.21250334e-02f, -1.60918325e-01f, -4.26212139e-03f, -5.02740145e-02f, 3.97035480e-02f, -9.12223458e-02f, 5.88444211e-02f, 5.73388161e-03f, 4.67352793e-02f, -3.20536122e-02f,
  -1.03796728e-01f, -7.34416991e-02f, 6.14082143e-02f, -4.40319590e-02f, -6.59708455e-02f, -8.58309865e-03f, 3.84466983e-02f, 2.58019455e-02f, 2.17817593e-02f, -3.50551382e-02f,
  -3.68520059e-02f, 5.64405404e-04f, 9.66530107e-03f, -4.58243070e-03f, -1.20908082e-01f, 6.32863045e-02f, 8.23231712e-02f, 7.46412948e-02f, -3.56674679e-02f, 5.87520190e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.20829010e-01f, -8.28858972e-01f, 4.10585582e-01f, 7.18531191e-01f, -5.94117828e-02f, 3.24088037e-01f, 7.27329969e-01f, -3.26594591e-01f, 3.38272691e-01f, -5.26127338e-01f,
  -3.02831262e-01f, 3.31633151e-01f, -6.38358742e-02f, -9.08703655e-02f, 5.65515816e-01f, 1.14735641e-01f, 2.43707925e-01f, 3.37817073e-01f, 2.34443396e-02f, 6.47877604e-02f,
  1.98842317e-01f, -3.37345332e-01f, 1.53047144e-01f, -6.48438275e-01f, -2.16706112e-01f, -1.94226488e-01f, -3.70734125e-01f, 2.77647320e-02f, -2.94502795e-01f, 5.49899153e-02f,
  -3.45801622e-01f, 1.78073626e-02f, -2.00653136e-01f, -1.78887576e-01f, -8.16651285e-02f, -8.80649686e-02f, 1.66772932e-01f, 1.77459732e-01f, 1.18727095e-01f, -1.03415616e-01f,
  5.50633408e-02f, -1.38508976e-01f, -4.38433699e-02f, 2.83317380e-02f, 1.43503388e-02f, -1.24787413e-01f, -1.35426387e-01f, -1.24772958e-01f, -2.60914583e-02f, 2.63335695e-03f,
  -5.37199304e-02f, -1.01345800e-01f, 2.38235164e-02f, -5.96837737e-02f, 1.05407543e-01f, -1.13192266e-02f, 1.81300238e-01f, 2.01815322e-01f, 1.50226736e-02f, 8.12774822e-02f,
  1.11479923e-01f, 5.04063815e-02f, -5.75703643e-02f, -6.72238022e-02f, 1.09446891e-01f, -1.63299009e-01f, -4.31894697e-02f, 4.11821995e-03f, 4.66539934e-02f, -3.36726848e-03f,
  6.71793222e-02f, -6.10202178e-02f, 1.68613046e-02f, 1.58219822e-02f, 3.29264291e-02f, 8.41701180e-02f, 1.21167712e-01f, -1.26063377e-02f, -5.99135123e-02f, -7.34136552e-02f,
  3.00784335e-02f, 7.86421672e-02f, -1.75374538e-01f, 8.39078501e-02f, -6.13668114e-02f, -3.37671638e-02f, -2.13748693e-01f, -1.26987156e-02f, 2.20289584e-02f, 8.18583295e-02f,
  -6.77258134e-01f, -3.17899436e-01f, -1.00430667e-01f, -1.53795660e-01f, -4.59486954e-02f, -1.35541856e-01f, 5.34170121e-02f, -5.59627861e-02f, 2.67215148e-02f, 7.23742843e-02f,
  -1.82965785e-01f, 3.25710699e-02f, -5.59662841e-02f, 1.14023276e-01f, 9.60840434e-02f, -9.16264430e-02f, 1.83056742e-01f, -9.91432741e-02f, -1.87040847e-02f, -1.44955531e-01f,
  -2.22195685e-02f, 1.18449479e-01f, -3.39049883e-02f, -5.68331182e-02f, 7.82439709e-02f, 2.11071670e-02f, 8.84566903e-02f, -8.35346952e-02f, -3.76471356e-02f, -4.70538251e-02f,
  4.33810890e-01f, -2.34625846e-01f, 3.85465324e-01f, -4.63123880e-02f, 4.90702093e-01f, 5.52903891e-01f, -9.01138335e-02f, 8.03517848e-02f, -2.70344138e-01f, -1.12820499e-01f,
  -3.11270207e-01f, -1.91609249e-01f, -4.01740074e-01f, -1.55105308e-01f, -4.78582650e-01f, -6.41763508e-01f, 9.87852551e-03f, -3.60028654e-01f, -2.55654961e-01f, -5.16334586e-02f,
  -1.84720512e-02f, -3.31192166e-01f, 2.34162360e-02f, 3.18238959e-02f, 4.49328214e-01f, 3.43823135e-01f, -8.03920701e-02f, -1.87018409e-01f, 1.77379042e-01f, -1.42515361e-01f,
  -1.41556174e-01f, -1.84631333e-01f, 7.42384195e-02f, 1.45221785e-01f, 3.13302398e-01f, 5.27354926e-02f, 6.93475679e-02f, -1.12468712e-01f, 2.69015934e-02f, 3.09218094e-03f,
  1.20955773e-01f, 2.74759084e-02f, -2.28189565e-02f, -1.23833619e-01f, 1.54320732e-01f, 6.02733307e-02f, 2.25027725e-01f, 2.65245140e-01f, 1.66554172e-02f, 1.25595182e-01f,
  1.40021265e-01f, 2.36364275e-01f, 1.35050938e-01f, 3.96257266e-02f, 3.33076902e-02f, 7.04671592e-02f, 6.36811880e-03f, -4.50322181e-02f, 2.02474624e-01f, 1.63738132e-01f,
  -6.28368780e-02f, -3.78047712e-02f, -1.98129714e-02f, 1.41064420e-01f, -1.53088048e-01f, 5.03750592e-02f, -3.21926922e-02f, 4.73934747e-02f, -4.65141311e-02f, -2.55101025e-02f,
  1.90024097e-02f, 1.46608232e-02f, -6.85382634e-02f, 1.05568625e-01f, 2.37927362e-02f, 1.33723781e-01f, 7.33401105e-02f, 4.53580320e-02f, -4.57030945e-02f, 6.39446899e-02f,
  -6.48210794e-02f, -3.04593239e-03f, -1.01028875e-01f, 1.65453970e-01f, 3.18295173e-02f, -1.55799896e-01f, 4.38500717e-02f, 1.12981133e-01f, 1.20626576e-02f, -1.13379903e-01f,
  -7.77177587e-02f, -2.17260569e-01f, -9.97477323e-02f, -6.55347407e-02f, -1.35199785e-01f, 7.68557340e-02f, 6.47618473e-02f, 9.89696309e-02f, -1.29782975e-01f, -2.28695548e-03f,
  2.90310979e-01f, 6.82913661e-02f, 1.10041618e-01f, -1.59601554e-01f, -4.94179130e-02f, 4.75069843e-02f, -4.79186736e-02f, -9.16859508e-02f, 1.07337117e-01f, 1.39377490e-01f,
  2.94342823e-02f, 1.51415154e-01f, 1.00097526e-02f, -8.80704541e-03f, 2.41430327e-02f, 3.47752087e-02f, 1.59453545e-02f, -6.62869960e-02f, -1.00479443e-02f, 1.68767702e-02f,
  4.42280680e-01f, 6.13230705e-01f, 2.23430350e-01f, 6.47958696e-01f, -1.97192639e-01f, 1.14226907e-01f, 1.20994069e-01f, 1.34113029e-01f, 4.96085018e-01f, 1.16427829e-02f,
  -3.05971712e-01f, 5.06812632e-01f, -4.69526738e-01f, 5.26127398e-01f, 3.39936703e-01f, -1.99677080e-01f, 7.07635641e-01f, 2.09753513e-01f, 5.38458563e-02f, 4.66120183e-01f,
  1.83780745e-01f, 2.02143386e-01f, -1.12093918e-01f, 6.22300757e-03f, 1.11552551e-01f, 1.47768840e-01f, -1.90488070e-01f, -3.58450800e-01f, 8.66424888e-02f, -1.31841615e-01f,
  -7.05311298e-02f, 1.43962055e-01f, 9.77586135e-02f, -1.68987922e-03f, 2.04239059e-02f, -6.85939193e-02f, -1.18399970e-01f, -8.75390694e-02f, -9.50696841e-02f, 2.27521583e-02f,
  1.98794156e-02f, 4.94166464e-02f, 1.77214906e-01f, -1.40997041e-02f, 5.78993708e-02f, 1.12460472e-01f, -5.11895046e-02f, -1.17662571e-01f, -5.52945072e-03f, -1.24376984e-02f,
  -8.65705609e-02f, -2.96693761e-02f, 7.41663873e-02f, 3.81742641e-02f, 5.33731394e-02f, 1.31358534e-01f, 5.55204824e-02f, -3.18070278e-02f, -9.13163349e-02f, 2.25951776e-01f,
  5.90920739e-04f, 5.50552979e-02f, -5.64338826e-02f, -1.78374231e-01f, 3.19465362e-02f, -1.12247095e-01f, -8.00783839e-03f, -1.98668212e-01f, 1.03400998e-01f, -3.01398393e-02f,
  5.09130349e-03f, 4.64855023e-02f, -1.09625924e-02f, -3.19361291e-03f, 1.50157601e-01f, 5.69372103e-02f, -3.84582169e-02f, -1.11720383e-01f, 4.74769734e-02f, -9.47393626e-02f,
  -3.05630341e-02f, 5.26327640e-02f, -5.26578724e-02f, -1.50519803e-01f, -5.24053313e-02f, -1.18697241e-01f, -4.63600010e-02f, 4.72807474e-02f, -1.28044784e-01f, -2.16752216e-02f,
  1.28440335e-01f, 4.98320818e-01f, 6.51730224e-02f, -1.48495408e-02f, 1.10405810e-01f, 3.10223736e-02f, 8.06358084e-02f, 1.14040948e-01f, 1.77665770e-01f, 1.37133420e-01f,
  6.59263805e-02f, -4.10983488e-02f, -4.37071845e-02f, -7.97692910e-02f, 1.21266380e-01f, -2.42224941e-03f, 3.93910408e-02f, 8.34782422e-02f, 1.33901894e-01f, 1.74931601e-01f,
  5.17790653e-02f, 6.25705943e-02f, 6.84665591e-02f, 1.10507952e-02f, 7.31392056e-02f, -6.75044348e-03f, 4.75171618e-02f, 1.34443566e-02f, -1.95288491e-02f, 6.67194799e-02f,
  1.31005079e-01f, 2.83915162e-01f, -4.71397042e-01f, -1.18654653e-01f, -2.40268111e-01f, -6.14512444e-01f, -3.53606999e-01f, -2.32028335e-01f, 3.74077141e-01f, 3.47467184e-01f,
  -1.87672332e-01f, 6.90727055e-01f, 2.27227822e-01f, -3.49788427e-01f, -5.64524353e-01f, -1.03836961e-01f, -5.07672310e-01f, -6.22429512e-02f, 1.82753295e-01f, -7.92910308e-02f,
  -1.54208735e-01f, -1.58857256e-01f, -4.79950607e-01f, 1.03560254e-01f, -2.67955691e-01f, -1.86689440e-02f, -3.11037660e-01f, -7.59819746e-02f, -4.80250508e-01f, -1.72055215e-01f,
  -2.41848588e-01f, 3.00404638e-01f, -1.06788110e-02f, 3.03483550e-02f, -2.42007926e-01f, 1.35773979e-02f, -1.14021748e-01f, -9.81433243e-02f, 5.01811169e-02f, 3.37123349e-02f,
  2.29717448e-01f, 1.37420177e-01f, 1.80259675e-01f, 2.66816150e-02f, 9.92655456e-02f, 9.07922164e-02f, -6.00813031e-02f, -1.33106545e-01f, 7.05336705e-02f, -6.55383319e-02f,
  5.58365248e-02f, -7.15931207e-02f, -1.64338276e-01f, 1.16794221e-01f, -1.08053036e-01f, -6.40254468e-02f, -1.05388761e-01f, -1.68865457e-01f, -3.68053280e-02f, -2.84081958e-02f,
  -1.63718276e-02f, -3.36296521e-02f, -1.11225173e-02f, 6.81571141e-02f, 6.85779527e-02f, -1.25488937e-01f, 3.08214277e-02f, 5.92193753e-02f, 4.60751727e-02f, -6.34320527e-02f,
  -6.86722323e-02f, 3.77608351e-02f, -7.07833692e-02f, -3.60912904e-02f, -5.52720353e-02f, 1.17150053e-01f, 7.92966690e-03f, 8.71231556e-02f, -5.79893328e-02f, -9.42046195e-03f,
  6.18255176e-02f, -2.06041858e-02f, 7.15873241e-02f, -4.54371944e-02f, -1.04419269e-01f, 9.38410014e-02f, 7.10101053e-02f, -4.08816040e-02f, 2.22650487e-02f, -4.07683626e-02f,
  -2.08636120e-01f, -4.65343557e-02f, 9.17208642e-02f, 2.20478237e-01f, 2.58547235e-02f, -5.02411611e-02f, -4.58125062e-02f, -7.24428967e-02f, -1.49021029e-01f, 3.11370678e-02f,
  -1.22208513e-01f, 1.60506859e-01f, -1.46961689e-01f, 6.81374082e-03f, 5.13919853e-02f, -2.04289585e-01f, -9.50070471e-03f, 4.32685167e-02f, -6.45022914e-02f, -6.95303828e-02f,
  5.30339479e-02f, 1.33548126e-01f, 1.52992159e-01f, 1.07128628e-01f, 1.14880137e-01f, 9.10119343e-05f, 9.84202549e-02f, 7.14271888e-03f, -4.41423357e-02f, -3.78606841e-02f,
  -7.30036259e-01f, 6.86606884e-01f, -2.88801432e-01f, 1.01188079e-01f, -2.99691319e-01f, 8.69732440e-01f, 5.85970163e-01f, 1.47567660e-01f, 2.51617044e-01f, 4.50886071e-01f,
  2.16101319e-01f, -8.61978531e-02f, 1.38667345e-01f, 4.38628346e-01f, 3.43357384e-01f, 6.42990232e-01f, 4.49667484e-01f, 3.52134615e-01f, -1.26430660e-01f, -4.75971177e-02f,
  -1.31564379e-01f, 3.19119692e-01f, -4.77451906e-02f, -7.22914115e-02f, -1.35267675e-01f, -3.95723373e-01f, -3.17957103e-01f, -3.06976736e-01f, 1.71570987e-01f, 6.17440455e-02f,
  -1.62403360e-01f, -5.27178824e-01f, -1.92659527e-01f, -7.76792020e-02f, -2.18377095e-02f, -1.64955124e-01f, -9.18662474e-02f, -8.53170976e-02f, -7.98056722e-02f, -5.57518527e-02f,
  -1.52958810e-01f, -1.11177094e-01f, -6.70916028e-03f, 4.66012303e-03f, -3.75237055e-02f, 2.19695140e-02f, -1.17883906e-02f, 2.19318438e-02f, 5.67228459e-02f, -1.10715501e-01f,
  8.49246830e-02f, 1.07272811e-01f, 4.44297073e-03f, 1.17061429e-01f, 2.77899895e-02f, 1.76091328e-01f, 1.28714919e-01f, -2.20441595e-02f, 2.00913355e-01f, 1.42571002e-01f,
  -8.04397650e-03f, 3.02807457e-04f, 1.08891219e-01f, -8.36316794e-02f, 4.57333513e-02f, -7.14302510e-02f, 3.53450999e-02f, -2.43086033e-02f, -7.25776106e-02f, 1.34125471e-01f,
  5.13644218e-02f, -2.24788431e-02f, 2.48009749e-02f, 7.99528286e-02f, -1.82480793e-02f, 2.26233844e-02f, -2.12999918e-02f, -6.75322562e-02f, 2.82577649e-02f, 3.45895626e-02f,
  -3.34534571e-02f, 2.97574140e-02f, 9.44012834e-04f, -1.40160143e-01f, 1.10284135e-01f, -7.57454261e-02f, -6.03988059e-02f, 9.04669911e-02f, -4.60034721e-02f, -4.29341123e-02f,
  3.86591196e-01f, 1.71239287e-01f, -1.26991449e-02f, 7.94782490e-02f, -3.01763676e-02f, 9.11637694e-02f, 2.92028077e-02f, 2.88262754e-03f, 1.50152251e-01f, 5.01662046e-02f,
  -8.65117684e-02f, 1.13791227e-02f, 1.17463311e-02f, -2.34953016e-02f, 9.63258296e-02f, 1.09053239e-01f, 2.04789359e-02f, -1.87323727e-02f, 1.32841840e-01f, -4.22165021e-02f,
  -8.70289374e-03f, 2.82531083e-02f, 2.03784313e-02f, -2.63554063e-02f, -4.67294864e-02f, 1.44863380e-02f, -2.54916959e-02f, -4.81381975e-02f, 4.46655322e-03f, -2.84557045e-02f,
  5.82044303e-01f, -6.39777362e-01f, -4.14472371e-01f, 4.16337192e-01f, 3.51284415e-01f, 2.01909423e-01f, -1.37348473e-01f, 2.67245352e-01f, 2.67536104e-01f, -1.22405663e-01f,
  3.97314191e-01f, -4.30656523e-01f, -6.00435674e-01f, 3.30894858e-01f, -2.56791133e-02f, -3.45665872e-01f, 2.37502277e-01f, 8.33771974e-02f, 2.62768827e-02f, 1.77137196e-01f,
  2.50154853e-01f, 3.80923510e-01f, -2.82191008e-01f, 1.19764253e-01f, 2.80505866e-01f, 1.55640900e-01f, -7.42341252e-03f, -3.91180754e-01f, 2.31809869e-01f, -2.57511307e-02f,
  8.29143003e-02f, 8.10301229e-02f, 5.24507463e-02f, -1.00416414e-01f, 2.81675681e-02f, 3.23606208e-02f, -9.58844796e-02f, -1.97361395e-01f, -1.13367170e-01f, 1.26622720e-02f,
  -2.38982365e-01f, -1.47709519e-01f, 1.45327434e-01f, -2.07646698e-01f, 2.19500110e-01f, 1.29312053e-01f, 7.17561319e-02f, 1.25693947e-01f, -1.92030236e-01f, -1.44877201e-02f,
  -1.13970473e-01f, -1.37308082e-02f, 6.18145578e-02f, -1.59361616e-01f, 2.62197293e-02f, 6.11745752e-02f, -1.36957601e-01f, -1.23473145e-01f, -3.96452248e-02f, 7.81718791e-02f,
  -2.40156446e-02f, -6.22454993e-02f, 2.61691548e-02f, -3.28275748e-02f, -8.31649974e-02f, 8.89447406e-02f, -3.32511626e-02f, -5.55950515e-02f, -2.55034585e-02f, -3.11541446e-02f,
  6.37707040e-02f, 4.28753681e-02f, 1.10138290e-01f, -5.86201437e-02f, 6.24612235e-02f, -6.02843538e-02f, -4.24735211e-02f, 5.74326850e-02f, 1.19612478e-01f, -3.60076576e-02f,
  -7.11756051e-02f, -8.21897015e-03f, -1.81144252e-02f, -1.07771814e-01f, -2.43302844e-02f, 1.18871763e-01f, 2.05792874e-01f, 1.25964731e-01f, 7.41712376e-02f, -5.49347401e-02f,
  -9.00475383e-02f, -3.81650567e-01f, 3.90949510e-02f, -1.50065450e-02f, -8.11228380e-02f, 1.39430597e-01f, -9.01764855e-02f, 1.92982871e-02f, -1.75460860e-01f, 2.49791071e-02f,
  1.13535918e-01f, 2.50557810e-02f, 3.56449746e-02f, 1.21695608e-01f, 1.06039308e-02f, 5.53972833e-02f, -5.53343520e-02f, -1.66141372e-02f, -2.28313543e-02f, 4.31025065e-02f,
  -6.63908124e-02f, -1.56588911e-03f, 5.81021495e-02f, 5.15854061e-02f, 9.61463377e-02f, -9.97797176e-02f, -8.87193233e-02f, 1.95306558e-02f, -5.38797714e-02f, -1.04582600e-01f,
  -2.90052474e-01f, -1.81008711e-01f, 5.80338478e-01f, -5.95610201e-01f, 4.33426388e-02f, 2.36267731e-01f, -1.72039434e-01f, -3.22174162e-01f, -5.47048748e-01f, -5.79736412e-01f,
  -2.61272997e-01f, -1.94229826e-01f, 4.01374847e-01f, -5.69007516e-01f, 8.09862733e-01f, 4.33228374e-01f, -4.02307719e-01f, -4.07075167e-01f, 7.57790282e-02f, -2.47960523e-01f,
  -7.57504553e-02f, -4.39901650e-01f, 4.47254419e-01f, -1.62894443e-01f, -3.14000845e-01f, -2.35220358e-01f, -1.10098034e-01f, 3.07945818e-01f, -3.25440228e-01f, 4.88877855e-02f,
  -1.71409249e-02f, -1.68660149e-01f, 1.14086986e-01f, 5.26312590e-02f, 1.36684299e-01f, 4.73753288e-02f, 5.51457405e-02f, 1.86360061e-01f, 2.84010209e-02f, 4.24015932e-02f,
  5.80880465e-03f, 1.10036908e-02f, -2.51904517e-01f, 9.17225331e-02f, -1.48849711e-01f, -6.54081106e-02f, 1.39041975e-01f, 8.56800973e-02f, 4.60964777e-02f, 1.90205649e-01f,
  1.66058376e-01f, 6.47309497e-02f, -6.42256737e-02f, -1.05949290e-01f, 3.71412421e-03f, -1.63492456e-01f, 3.55581450e-03f, 1.35562181e-01f, -1.67963266e-01f, -1.69228800e-02f,
  -3.12926322e-02f, -1.91077683e-02f, 6.02219775e-02f, -8.16216767e-02f, 1.03779919e-02f, -6.31747767e-02f, 3.12422984e-04f, 8.61548856e-02f, -6.87538506e-03f, 4.80735227e-02f,
  -1.09947465e-01f, -5.94048128e-02f, -1.02696948e-01f, -1.65708765e-01f, -2.21167225e-02f, -5.67433089e-02f, 1.51084542e-01f, 6.90137744e-02f, -2.41465378e-03f, 2.14544367e-02f,
  -6.76458403e-02f, -3.98150133e-03f, -1.06609076e-01f, -6.49195090e-02f, -2.19779368e-02f, 8.37277323e-02f, -1.58991709e-01f, 9.75201651e-03f, 1.41257733e-01f, 2.23019198e-01f,
  7.02697830e-03f, -1.67641759e-01f, 2.45408453e-02f, -8.44505280e-02f, -2.00618710e-02f, 2.56260391e-02f, 3.84823792e-02f, -1.36126488e-01f, -6.03668801e-02f, 3.06516290e-02f,
  -2.18988538e-01f, -5.20325340e-02f, -3.51839513e-02f, -1.22924939e-01f, 2.30822358e-02f, 3.08942087e-02f, -8.34925994e-02f, -1.03733838e-01f, 4.42669876e-02f, -5.34714572e-02f,
  -9.34558213e-02f, -1.01387173e-01f, 8.59235525e-02f, -2.06153393e-01f, -2.34131888e-01f, -1.16177574e-01f, -1.56339966e-02f, -7.23498911e-02f, 9.33427215e-02f, -9.79494154e-02f,
  3.99088353e-01f, 2.18028039e-01f, 3.14480394e-01f, 1.68714061e-01f, -2.77853191e-01f, 1.22084513e-01f, -2.02548146e-01f, 5.22992834e-02f, 6.72413409e-01f, -2.07450073e-02f,
  -5.46157062e-01f, 3.32268298e-01f, -3.73074502e-01f, -2.77859848e-02f, -1.95304468e-01f, -8.24728515e-03f, -1.46855635e-03f, 1.63618121e-02f, 3.01730912e-02f, -8.58563781e-02f,
  -8.41496803e-04f, -6.43183947e-01f, -5.62929809e-01f, -6.57889307e-01f, -3.77501130e-01f, 2.77108610e-01f, -4.13375586e-01f, -3.16108018e-01f, -2.19565868e-01f, -8.82921368e-02f,
  2.45170686e-02f, -2.23694760e-02f, 4.17615566e-03f, 2.14638725e-01f, 1.61800727e-01f, -2.38131620e-02f, 5.83486557e-02f, -1.01721562e-01f, 3.96401845e-02f, 1.20726690e-01f,
  2.58547794e-02f, 2.90463902e-02f, 5.42827509e-02f, -1.32643536e-01f, -8.82510139e-05f, -4.08656932e-02f, 8.03828612e-02f, 1.59174323e-01f, 2.95088273e-02f, 1.61015205e-02f,
  1.60551608e-01f, 2.31784835e-01f, 1.68333963e-01f, 2.60659903e-01f, 7.33686760e-02f, -4.49867919e-02f, 1.10721439e-01f, 3.63344513e-02f, 2.12052673e-01f, 8.68757814e-02f,
  -4.31057028e-02f, 4.31914479e-02f, -1.44519418e-01f, -1.15943439e-01f, -1.28375113e-01f, 4.86750603e-02f, -8.35926235e-02f, -4.39530835e-02f, 2.42913261e-01f, -6.98665064e-03f,
  -3.94507647e-02f, -8.30739811e-02f, 3.27721611e-02f, 1.01124212e-01f, -9.43960771e-02f, -7.68208653e-02f, 3.29313874e-02f, 1.27831638e-01f, 6.73457757e-02f, -2.63845380e-02f,
  -2.52045780e-01f, -5.23980847e-03f, -1.64769262e-01f, -8.81487131e-02f, -1.45774186e-01f, -2.08913777e-02f, 2.89381128e-02f, 1.75106704e-01f, -1.23399217e-02f, -1.60905913e-01f,
  1.43060654e-01f, 7.45149553e-02f, 9.38841850e-02f, -1.07951656e-01f, -4.22497801e-02f, 6.46778848e-03f, -1.28645018e-01f, 1.51077956e-01f, 1.19703189e-02f, -9.01374072e-02f,
  5.13906591e-03f, -1.09498268e-02f, 2.38774478e-01f, 6.97703138e-02f, -1.04820810e-01f, -3.75491008e-02f, 5.95848002e-02f, 1.10883631e-01f, -4.59524803e-02f, -6.65798113e-02f,
  3.65031958e-02f, 2.97246594e-02f, -2.81259813e-03f, 1.59075279e-02f, 3.07631213e-02f, -9.33695510e-02f, 1.01253927e-01f, 1.25431702e-01f, -1.23894207e-01f, 8.72663483e-02f,
  -1.63185894e-01f, -6.78410530e-01f, -4.69283879e-01f, -1.95959508e-01f, 2.52674580e-01f, 6.01478040e-01f, 5.67911565e-01f, -4.02351320e-01f, -7.69339263e-01f, 1.14275940e-01f,
  4.25752401e-01f, -2.56629632e-04f, -8.47700611e-02f, 1.87906265e-01f, 3.06217998e-01f, -3.05754721e-01f, 2.25977346e-01f, 2.89748222e-01f, -3.59999537e-01f, -1.87943488e-01f,
  -1.93325937e-01f, 3.36505741e-01f, 2.55242456e-02f, -5.52477874e-02f, 1.67894825e-01f, -1.37496114e-01f, 4.42314476e-01f, 8.49549100e-02f, 4.82222319e-01f, 4.49196398e-01f,
  7.69010782e-02f, -3.13994229e-01f, -1.68880746e-01f, 4.44928892e-02f, 8.88323784e-02f, 1.82769910e-01f, 4.03007090e-01f, 2.80134737e-01f, 4.32429574e-02f, -4.07641418e-02f,
  1.26396731e-01f, -6.17432781e-03f, -1.41436562e-01f, 5.41680865e-02f, -8.68679136e-02f, -1.74977109e-01f, -2.42761627e-01f, -1.12507313e-01f, -1.80220723e-01f, -9.10990685e-02f,
  -3.17643017e-01f, -5.70405535e-02f, -8.15995876e-03f, 1.14287339e-01f, -7.52985030e-02f, -1.33524150e-01f, -4.95857634e-02f, 5.17626368e-02f, -1.35503843e-01f, -1.32685989e-01f,
  -1.26026412e-02f, 1.48940280e-01f, -2.08431751e-01f, -1.55107258e-02f, 6.10164506e-03f, 4.76389006e-02f, 1.60333104e-02f, 4.67286929e-02f, 1.00977533e-01f, -5.23669086e-02f,
  -1.09223381e-01f, -9.03238580e-02f, 5.50701506e-02f, 1.08045094e-01f, -4.24050093e-02f, -9.84866247e-02f, 1.31379843e-01f, 8.46977085e-02f, -2.13037990e-02f, 7.52774030e-02f,
  5.32298647e-02f, 6.38168752e-02f, 1.31231219e-01f, 1.19686931e-01f, -3.03657167e-02f, 1.26073211e-01f, 4.95514646e-02f, -4.18486781e-02f, -3.80553566e-02f, 1.93260834e-01f,
  2.18363889e-02f, -2.59627163e-01f, -1.13077171e-01f, 7.46911541e-02f, 8.16899538e-02f, 1.65305715e-02f, -9.74658760e-04f, -8.04578736e-02f, -6.05191439e-02f, -1.45178422e-01f,
  1.98899791e-01f, -1.28332153e-01f, -8.09797924e-03f, 6.55611008e-02f, 1.26967430e-01f, -7.70710483e-02f, 1.18064322e-01f, 8.21015239e-02f, 1.18831256e-02f, -4.49732170e-02f,
  3.29067186e-02f, 5.69967255e-02f, 4.14469279e-02f, -1.48346975e-01f, -4.90097068e-02f, 1.73968419e-01f, -7.06995800e-02f, 3.77381779e-02f, 1.05654821e-01f, -5.26427804e-03f,
  -8.69385421e-01f, -3.54987569e-02f, -2.73541927e-01f, -9.01274756e-02f, 5.27564138e-02f, 1.72668338e-01f, -8.84439237e-03f, -1.47043869e-01f, -3.35459530e-01f, 2.45354295e-01f,
  3.73720199e-01f, -2.77161926e-01f, -5.22063002e-02f, 5.37797034e-01f, -7.49702901e-02f, 1.91312179e-01f, 2.40029037e-01f, 1.38864979e-01f, 3.18536200e-02f, -3.06490272e-01f,
  -6.38073608e-02f, 4.55281883e-01f, 5.26787974e-02f, 2.17229798e-01f, -5.84321143e-03f, -3.79280411e-02f, 9.01857167e-02f, -1.41811669e-01f, 4.51051772e-01f, 2.58375257e-01f,
  -3.16415191e-01f, -5.75742424e-01f, -2.55207539e-01f, -1.15681909e-01f, -1.70128405e-01f, -7.69764557e-02f, -2.37963617e-01f, 7.91362748e-02f, -1.18926607e-01f, -4.48430888e-02f,
  -6.26579300e-02f, 4.70085628e-02f, 7.07035661e-02f, -9.70828831e-02f, -1.69727340e-01f, 2.83096228e-02f, 1.20170470e-02f, 7.71043003e-02f, -6.59014508e-02f, -8.53196084e-02f,
  1.69264376e-02f, 2.13014558e-01f, -1.27751948e-02f, 1.18887194e-01f, 7.72607997e-02f, 1.70882791e-01f, 1.13770120e-01f, -1.57795817e-01f, -6.62316084e-02f, 2.66139098e-02f,
  1.02689750e-01f, 2.90097464e-02f, -7.09309727e-02f, 4.91065085e-02f, 1.22316768e-02f, 1.69811055e-01f, 3.71302515e-02f, 3.31249125e-02f, -3.12206596e-02f, 6.99816346e-02f,
  1.02787010e-01f, -9.92872864e-02f, -1.15294389e-01f, -3.37238535e-02f, 9.51273665e-02f, -9.51298978e-03f, 1.22299343e-02f, -2.37130094e-02f, -2.69604065e-02f, 1.36088696e-03f,
  -9.14743841e-02f, 4.60417755e-03f, 1.06805535e-02f, -3.47331129e-02f, 4.81566451e-02f, -8.36570263e-02f, 2.64850650e-02f, -7.44149387e-02f, -3.02212741e-02f, 6.68660849e-02f,
  -7.00951993e-01f, -5.94598889e-01f, -6.32562041e-02f, -2.64010485e-02f, 2.67141741e-02f, -9.13376510e-02f, 8.28974098e-02f, 1.49735501e-02f, -1.84436962e-02f, -9.43425149e-02f,
  -7.22616762e-02f, 1.06493004e-01f, -1.44729288e-02f, 5.33820800e-02f, 5.68757951e-02f, 6.29271716e-02f, -2.49176566e-02f, -5.77875152e-02f, -5.52662909e-02f, 1.93089768e-02f,
  -8.16283524e-02f, -3.44152078e-02f, 9.29096192e-02f, -6.13275869e-03f, 6.20958097e-02f, 5.54125905e-02f, -1.29660577e-01f, 2.42643803e-02f, 1.61542326e-01f, 6.24732040e-02f,
  -6.25420749e-01f, 5.74364960e-01f, 5.18247068e-01f, 1.12852067e-01f, -3.97684693e-01f, -1.59839511e-01f, 2.87495732e-01f, -1.49188368e-02f, -2.06088215e-01f, 5.08745670e-01f,
  1.46276593e-01f, 2.48537764e-01f, 2.26998806e-01f, 4.66294289e-01f, -5.56705058e-01f, -3.04600522e-02f, 1.20427489e-01f, 2.96702743e-01f, -3.27627100e-02f, -9.88251269e-02f,
  -2.84079105e-01f, -5.36232948e-01f, 3.34127635e-01f, -4.15737957e-01f, 2.40194842e-01f, 1.56418666e-01f, -1.97633743e-01f, -5.67296194e-03f, 2.36687630e-01f, -9.68209803e-02f,
  -7.50821680e-02f, -1.69139862e-01f, 3.01911235e-01f, -2.49494407e-02f, -2.73106769e-02f, 2.12330699e-01f, 1.21248297e-01f, 1.02590144e-01f, -1.83978319e-01f, -1.04806654e-03f,
  1.43196585e-03f, -6.66470081e-02f, -1.00346543e-01f, -1.36192515e-01f, -2.54037809e-02f, 4.77279685e-02f, 7.30239823e-02f, 2.23583564e-01f, 1.79515108e-02f, 2.16086864e-01f,
  2.69083440e-01f, 2.45251521e-01f, 7.67915398e-02f, 8.98130536e-02f, 1.06203249e-02f, -5.28709032e-02f, 1.39762446e-01f, 1.56814277e-01f, -3.11625120e-03f, -8.82593095e-02f,
  -6.44857958e-02f, 1.73222963e-02f, 7.61872530e-02f, 7.05236057e-03f, -5.39352857e-02f, -2.05129534e-02f, 6.95149302e-02f, 4.16041799e-02f, 1.05703205e-01f, 2.39910129e-02f,
  -1.06719576e-01f, 4.00360264e-02f, -1.44790396e-01f, 5.41114397e-02f, -4.25414629e-02f, -7.83085078e-02f, 8.22737142e-02f, -1.10034324e-01f, 6.97905198e-02f, 6.86292863e-03f,
  -7.03886449e-02f, -1.43395394e-01f, 1.08721279e-01f, 4.36943881e-02f, -1.86238810e-02f, -2.39545014e-02f, -2.60806130e-03f, 1.39473036e-01f, -7.37756789e-02f, -1.21820100e-01f,
  -8.14748406e-01f, -6.27136528e-01f, -6.34551644e-02f, -1.54464498e-01f, 2.90122312e-02f, -2.07085125e-02f, -3.29781994e-02f, 2.37056967e-02f, -2.15686947e-01f, -1.77198634e-01f,
  -1.08757809e-01f, 4.13978249e-02f, 1.90055389e-02f, 2.70428369e-03f, -8.49388167e-02f, -4.17385288e-02f, -5.93311936e-02f, -1.42820269e-01f, -1.59332857e-01f, -2.37103249e-03f,
  -1.93079934e-02f, 7.89632928e-03f, 1.11774281e-01f, -3.90753560e-02f, -9.68673453e-03f, 8.48171115e-02f, -1.81962922e-01f, 1.07130662e-01f, -1.22996189e-01f, 9.20533165e-02f,
  2.06881657e-01f, 3.57933283e-01f, -5.13468504e-01f, -4.80483979e-01f, 4.20347363e-01f, 3.35535556e-02f, -2.26213425e-01f, 1.88127846e-01f, -2.51626194e-01f, 4.28373814e-01f,
  5.36236107e-01f, -2.05085412e-01f, 5.74916713e-02f, 2.98042923e-01f, -2.80398518e-01f, -1.53735444e-01f, 3.10833454e-02f, -1.00000501e-01f, -1.36416838e-01f, 1.45927384e-01f,
  -2.73557484e-01f, 6.08807564e-01f, -2.68492818e-01f, 3.97504926e-01f, 1.60622150e-01f, -1.93105221e-01f, 2.82700330e-01f, 1.34104043e-01f, 2.04581097e-01f, 1.80482611e-01f,
  7.41610378e-02f, 2.27746248e-01f, -1.12771906e-01f, -1.24784209e-01f, 2.74338052e-02f, 2.28143446e-02f, -1.28352940e-01f, 3.28682847e-02f, -1.08322546e-01f, -5.09696342e-02f,
  -5.25920242e-02f, 4.38001044e-02f, -7.28444457e-02f, -5.26572019e-02f, 3.99916880e-02f, 6.07298873e-02f, -5.80963194e-02f, -4.62788418e-02f, -1.50495887e-01f, 1.42483711e-01f,
  -1.59134786e-03f, -8.40743855e-02f, 5.61524509e-03f, -2.11364001e-01f, -9.16909724e-02f, 9.79223922e-02f, -1.44985408e-01f, -6.51284829e-02f, -2.63357367e-02f, -8.23336169e-02f,
  1.03536867e-01f, -6.05787821e-02f, 6.23593479e-02f, -1.19290575e-01f, 8.64900947e-02f, -2.93281619e-02f, -4.84484881e-02f, -4.59044464e-02f, -1.23520091e-01f, 1.71207845e-01f,
  -4.47720625e-02f, -7.11581409e-02f, 1.11767925e-01f, 3.23944502e-02f, 1.00276597e-01f, -2.43727304e-02f, 4.62841019e-02f, 6.13759533e-02f, -2.11132035e-01f, 2.80474499e-02f,
  -5.58828823e-02f, 5.60704209e-02f, -2.59879902e-02f, -2.89303660e-02f, 8.59314948e-02f, -1.77989736e-01f, -9.01836976e-02f, 1.11750908e-01f, -1.38100088e-01f, 1.57055054e-02f,
  3.49518955e-02f, 2.93755084e-01f, -6.45634308e-02f, -9.37243551e-02f, 4.73661907e-02f, 7.72015229e-02f, 3.04525103e-02f, 1.06657229e-01f, -5.44620212e-03f, 1.11552209e-01f,
  6.10962063e-02f, -1.44961804e-01f, 6.22727200e-02f, 9.90332570e-03f, -1.58940554e-01f, 7.74400607e-02f, -3.51711363e-03f, -2.44619265e-01f, -1.77519113e-01f, 1.67452998e-03f,
  9.63774770e-02f, 2.44404033e-01f, -2.68743634e-01f, -3.71551886e-02f, -2.88274642e-02f, 8.86833994e-04f, 1.28376886e-01f, -2.00895499e-02f, 9.16361660e-02f, -8.83550197e-02f,
  -7.91809618e-01f, 6.18219115e-02f, -1.27761617e-01f, 7.16094196e-01f, -2.96186447e-01f, -6.48082912e-01f, 9.80769098e-02f, 6.97131529e-02f, -1.18593350e-01f, 3.65547746e-01f,
  5.44859469e-01f, -6.63215995e-01f, 3.10210198e-01f, 4.04687524e-01f, -4.47121233e-01f, 3.63929361e-01f, -2.08921544e-02f, -5.77448048e-02f, -3.25749636e-01f, -7.32525513e-02f,
  -3.57214622e-02f, 4.09793198e-01f, 3.46174657e-01f, 4.08615135e-02f, -7.12438151e-02f, 3.84448208e-02f, 6.11079931e-01f, 8.17205012e-02f, 1.73515007e-01f, -3.29392523e-01f,
  -2.81987358e-02f, 2.57041246e-01f, 1.14202864e-01f, -1.40586510e-01f, 1.22287888e-02f, 7.28912372e-03f, -1.26751631e-01f, -4.91355620e-02f, 8.08753520e-02f, 2.12224796e-02f,
  -1.64976388e-01f, -1.20398253e-01f, -2.22750902e-01f, -4.51197214e-02f, -7.01412782e-02f, 1.49530163e-02f, -8.58326852e-02f, -6.94785547e-03f, -3.59983444e-02f, -1.75804481e-01f,
  4.11616936e-02f, -8.04285333e-02f, 2.35952958e-02f, 3.50096170e-03f, 1.57289766e-03f, -2.53231116e-02f, 7.30060833e-03f, -2.28087619e-01f, -1.12838306e-01f, -1.49633110e-01f,
  -1.73533574e-01f, 4.69601341e-02f, 1.44866765e-01f, -2.78571062e-03f, -4.04169410e-02f, 6.50338978e-02f, 1.19090877e-01f, -1.03750028e-01f, -9.97343808e-02f, -3.38140549e-03f,
  -7.74200857e-02f, 1.09092414e-01f, -1.35223055e-02f, 1.06584750e-01f, -1.45200752e-02f, 4.46265601e-02f, 7.88728893e-02f, 5.86157814e-02f, -8.49650204e-02f, 1.87692419e-01f,
  5.63350618e-02f, -9.65493694e-02f, -7.87448287e-02f, -2.03928668e-02f, 8.09717365e-03f, 6.91800937e-02f, 9.51854214e-02f, 3.93041521e-02f, 7.74015188e-02f, 2.76632980e-02f,
  -2.18580231e-01f, 2.04862624e-01f, 1.45746037e-01f, -4.55123410e-02f, 4.44556549e-02f, -1.83175832e-01f, 4.07282524e-02f, -2.25542292e-01f, -5.39440662e-03f, 6.81204796e-02f,
  -6.64631352e-02f, 1.51542231e-01f, -3.71099524e-02f, 9.08667594e-02f, 1.11594975e-01f, 4.26718034e-02f, 1.39876366e-01f, 6.35353401e-02f, 1.69631168e-01f, -6.76812371e-03f,
  1.57063052e-01f, -1.11996576e-01f, 9.40366276e-03f, 1.04762152e-01f, 6.38920069e-02f, -8.55204687e-02f, -1.35910481e-01f, -1.65416643e-01f, 6.48846552e-02f, 4.35617380e-03f,
  1.12643862e+00f, -5.95722139e-01f, -3.86961877e-01f, 1.54249251e-01f, 5.98881304e-01f, 4.88584638e-01f, 5.21915674e-01f, 1.19706772e-01f, 1.66567862e-01f, -3.87787372e-01f,
  2.58635700e-01f, -6.80779815e-02f, -2.47573957e-01f, 3.37058634e-01f, 6.82560146e-01f, -1.52194157e-01f, 3.10113043e-01f, 2.24942371e-01f, 1.94361228e-02f, 1.34255528e-01f,
  3.00947577e-01f, 4.27445292e-01f, 9.18060616e-02f, -3.06664079e-01f, 4.74338740e-01f, -4.07836705e-01f, -8.29644948e-02f, -2.35124543e-01f, -1.22372717e-01f, 2.94937670e-01f,
  9.13475379e-02f, -1.22853899e-02f, 1.01130240e-01f, -1.48948118e-01f, 8.54035374e-03f, 1.18365791e-02f, -6.06282502e-02f, 7.06154704e-02f, 1.61893278e-01f, 3.81130204e-02f,
  5.24341613e-02f, 6.94865435e-02f, 1.53166261e-02f, 6.39183298e-02f, 4.83870246e-02f, 3.95961991e-03f, 8.42072219e-02f, -3.29514667e-02f, -1.03394262e-01f, 6.88970760e-02f,
  6.74730167e-02f, -2.25219713e-03f, 1.28770411e-01f, -2.34508254e-02f, -5.50594628e-02f, 1.60762127e-02f, -8.09508041e-02f, -1.54028073e-01f, 5.56601584e-02f, 1.00064658e-01f,
  3.36710960e-02f, -1.21540822e-01f, -4.39185416e-03f, 5.34236878e-02f, 3.82146938e-03f, 7.05483854e-02f, 5.08874767e-02f, -4.78896648e-02f, -6.27025440e-02f, 3.22043411e-02f,
  8.09842348e-02f, 1.10870950e-01f, -3.44423875e-02f, 6.43352047e-02f, -6.44649789e-02f, 2.45470200e-02f, -4.19523055e-03f, -6.25657290e-02f, -4.70844507e-02f, 5.04973195e-02f,
  -2.80013941e-02f, -2.04539783e-02f, 5.72297983e-02f, -4.49552424e-02f, 9.14345309e-03f, 4.14312035e-02f, -1.19618446e-01f, 5.89306988e-02f, -6.67633340e-02f, 1.61445830e-02f,
  -1.41426980e-01f, -4.62859660e-01f, -5.57820462e-02f, -2.62709577e-02f, -2.52414167e-01f, 6.14963323e-02f, -3.66646387e-02f, 6.22772872e-02f, 7.86904618e-03f, -4.41770814e-02f,
  -6.05761297e-02f, 2.69089453e-02f, -6.43131733e-02f, 1.30104721e-02f, -1.05397306e-01f, 7.06006810e-02f, -1.40110508e-01f, -3.67010273e-02f, 4.25500236e-02f, -1.61585152e-01f,
  -1.14356298e-02f, 4.33907025e-02f, 5.82477450e-03f, 1.00729860e-01f, -1.01589270e-01f, -4.90898378e-02f, 2.69982666e-02f, -9.28440541e-02f, -1.62221715e-02f, -1.07633419e-01f,
  5.72144210e-01f, -4.37124759e-01f, 4.03055968e-03f, -2.92806685e-01f, -3.64661473e-03f, -2.84113735e-01f, -5.69288991e-02f, -4.92839128e-01f, -2.07198054e-01f, -5.57653606e-01f,
  -1.72595680e-01f, -2.96291485e-02f, 3.18419099e-01f, -4.65826273e-01f, 5.30059755e-01f, 4.01573449e-01f, -5.03275692e-01f, -3.44750166e-01f, 1.76989809e-02f, -2.82957196e-01f,
  4.44407389e-02f, -3.09078306e-01f, 1.98913842e-01f, -5.84818900e-01f, -2.91102588e-01f, -2.18688503e-01f, 1.32841974e-01f, 1.93114191e-01f, -3.87740165e-01f, -4.88247424e-02f,
  1.10700865e-04f, -3.66528668e-02f, -1.57853454e-01f, -1.35246411e-01f, -3.66051123e-02f, 1.01141982e-01f, -5.78020215e-02f, 2.20220596e-01f, 1.11507997e-01f, -5.75251356e-02f,
  1.50688589e-01f, 3.78211960e-02f, -1.47633851e-01f, 1.08761273e-01f, -1.20165579e-01f, -1.27295837e-01f, -6.45336807e-02f, -7.54749551e-02f, -4.30280864e-02f, 1.67337820e-01f,
  7.39270151e-02f, 1.30304964e-02f, 6.87009841e-02f, -1.26523510e-01f, 1.58545464e-01f, 9.44767222e-02f, 9.28924978e-02f, 1.43401280e-01f, -1.52965680e-01f, -8.24412033e-02f,
  3.79615612e-02f, 5.51238619e-02f, 4.69154045e-02f, -1.32400900e-01f, -3.01691443e-02f, -8.45762808e-03f, -4.44749855e-02f, -4.93631102e-02f, 8.78356397e-02f, -9.85627342e-03f,
  -8.30111802e-02f, 2.26958655e-02f, 5.30710183e-02f, -5.04627032e-03f, 5.25476150e-02f, 1.40214980e-01f, -5.03232470e-03f, 6.59843385e-02f, 2.73991679e-03f, -4.14037555e-02f,
  9.11255702e-02f, 3.22364978e-02f, 4.43874821e-02f, -3.25607583e-02f, 5.33479974e-02f, -1.77848898e-02f, -8.42509642e-02f, 7.07583576e-02f, -1.36128990e-02f, 3.04768048e-03f,
  8.90477560e-03f, -1.83817074e-01f, -2.53987372e-01f, -1.49680391e-01f, -1.17955796e-01f, -6.92376643e-02f, -4.95604128e-02f, -2.80775964e-01f, -6.77051023e-02f, 4.58122045e-02f,
  -1.57430157e-01f, 5.14577562e-03f, -6.94342628e-02f, 3.58679937e-03f, -9.22878906e-02f, -2.21740305e-01f, -1.22356014e-02f, -1.38134450e-01f, -5.60130877e-03f, -7.49303252e-02f,
  -7.94037655e-02f, 4.46215225e-03f, -3.91885899e-02f, -2.03301609e-02f, -8.90236422e-02f, 2.23128155e-01f, 1.40857706e-02f, 4.10880409e-02f, 1.41009092e-01f, 3.55604701e-02f,
  -7.23217249e-01f, 8.85411203e-02f, -4.19455558e-01f, -7.32426405e-01f, 2.35354751e-01f, -1.58037737e-01f, -3.70452702e-01f, 1.85719877e-01f, -1.81542635e-01f, 3.21876854e-01f,
  1.72404006e-01f, -4.31564540e-01f, 2.85049617e-01f, -5.82005799e-01f, -5.41499138e-01f, -3.80999207e-01f, -4.95838434e-01f, -5.14705896e-01f, -2.87174165e-01f, -2.10998356e-01f,
  -3.80035073e-01f, -3.90466243e-01f, -4.35934812e-01f, 3.63425404e-01f, -2.95280695e-01f, 2.03715771e-01f, 2.59925097e-01f, 4.11177158e-01f, -1.34776101e-01f, -7.67205209e-02f,
  -2.54417717e-01f, -7.19282106e-02f, 1.06703058e-01f, -1.11479282e-01f, 9.94528830e-02f, 1.85415685e-01f, -4.73723561e-02f, 1.52681516e-02f, -5.95234819e-02f, -8.94097313e-02f,
  7.41015077e-02f, 4.72466322e-03f, -1.23879671e-01f, 7.37117827e-02f, -3.25451442e-03f, 1.99133367e-03f, -3.75122391e-02f, 8.73693265e-03f, 3.35582830e-02f, -2.27770939e-01f,
  -2.37789452e-01f, -9.16936621e-02f, -6.22101352e-02f, -1.18469940e-02f, -2.58993953e-02f, 1.54799568e-02f, -6.19855598e-02f, 1.13902643e-01f, -8.05452019e-02f, -1.86433531e-02f,
  2.91377772e-02f, 4.99530323e-02f, 1.55640552e-02f, -8.78798515e-02f, 6.70464039e-02f, 8.52531120e-02f, -2.16020942e-02f, -4.21305932e-02f, 4.42567132e-02f, 5.11004888e-02f,
  3.58519927e-02f, -8.95566866e-02f, -2.39008348e-02f, -2.01371670e-01f, -2.05071010e-02f, -1.56875119e-01f, 3.17899063e-02f, -3.02596530e-03f, -1.00864574e-01f, -3.18122320e-02f,
  7.14622587e-02f, -7.44147599e-02f, 6.71722814e-02f, 5.96289150e-02f, 3.84258735e-03f, 7.37020448e-02f, 3.03784963e-02f, 4.43487652e-02f, 2.21296884e-02f, 7.94482455e-02f,
  7.44557381e-02f, 2.81702071e-01f, 6.84783310e-02f, 4.59786728e-02f, -3.44246738e-02f, -2.17225198e-02f, -1.33336872e-01f, -8.54975581e-02f, -5.51756769e-02f, -8.97717997e-02f,
  1.04450816e-02f, 2.12517083e-02f, 1.58431500e-01f, -6.98607713e-02f, -1.43278148e-02f, 7.80835608e-03f, 1.33102229e-02f, 7.95136392e-02f, 8.42271820e-02f, 1.17315628e-01f,
  1.03413559e-01f, 3.14470418e-02f, 7.71510229e-02f, 8.08581188e-02f, -4.60509509e-02f, 1.59232244e-01f, 4.00351360e-02f, 7.18564317e-02f, 6.38897121e-02f, 7.19380304e-02f,
  -7.56691635e-01f, 3.79167825e-01f, -4.16696846e-01f, -3.61466944e-01f, -3.47339123e-01f, -1.42935336e-01f, -2.68895894e-01f, -3.17844674e-02f, -3.51966172e-02f, 2.75613159e-01f,
  1.74479127e-01f, 5.59896268e-02f, 4.50186342e-01f, 2.53204972e-01f, -2.85093963e-01f, 5.67683160e-01f, 1.70423724e-02f, -1.85728669e-02f, 1.32477060e-01f, -2.58312970e-01f,
  -9.72682685e-02f, 1.51453391e-01f, -7.04732463e-02f, 4.89632487e-02f, -4.60174024e-01f, -2.10464343e-01f, -1.16827033e-01f, -2.72293687e-01f, -2.32433945e-01f, -8.98843780e-02f,
  -1.87647581e-01f, -2.65989065e-01f, -2.97967792e-01f, -1.63293451e-01f, -1.70390636e-01f, -2.37414911e-01f, -2.87574381e-01f, 1.62398797e-02f, -1.20645650e-02f, 4.16294187e-02f,
  1.53546482e-02f, 1.07379325e-01f, -1.39416112e-02f, 7.98083618e-02f, -1.37757048e-01f, -9.73126367e-02f, 5.67236654e-02f, 8.52043647e-03f, -1.02676696e-03f, 5.14542162e-02f,
  4.40770537e-02f, 4.17751633e-02f, -1.55931354e-01f, 7.46727735e-02f, -7.05982968e-02f, -6.53712898e-02f, -4.59508188e-02f, -1.35725543e-01f, -1.11207619e-01f, -1.34158283e-01f,
  -5.10563664e-02f, -3.18922922e-02f, -5.77908428e-03f, 5.01823127e-02f, -5.15424088e-03f, -8.83252546e-02f, -3.24509852e-02f, 2.40057781e-02f, 1.98656674e-02f, 4.06686775e-02f,
  3.25668156e-02f, -2.78195478e-02f, -5.57326451e-02f, 5.67984916e-02f, 1.19853113e-02f, -5.12285754e-02f, -4.77263555e-02f, -4.26611416e-02f, -7.51579031e-02f, -7.12011829e-02f,
  -4.82169986e-02f, -1.60409007e-02f, 6.31803125e-02f, -1.78138930e-02f, -1.01037458e-01f, -3.41187865e-02f, -5.55639341e-02f, 4.44677696e-02f, 5.58311082e-02f, -1.02030098e-01f,
  -4.32914317e-01f, -4.30088252e-01f, -3.16486545e-02f, -8.76670033e-02f, -1.47270218e-01f, -2.54515503e-02f, 3.95033648e-03f, -3.97718586e-02f, -2.09054440e-01f, -1.05893739e-01f,
  -2.32128315e-02f, 2.12532524e-02f, -7.99061507e-02f, -1.66866798e-02f, 7.37072453e-02f, 5.29422201e-02f, -1.66107004e-03f, -3.86005752e-02f, -1.72574297e-01f, -5.90120330e-02f,
  -6.59628958e-02f, 2.10163984e-02f, -5.46625406e-02f, 4.95812856e-03f, -4.30506021e-02f, -7.29206875e-02f, -7.62915090e-02f, -7.40171894e-02f, -7.40280673e-02f, 7.80160576e-02f,
  3.50846797e-01f, -1.79750428e-01f, -2.94224381e-01f, 7.86683038e-02f, 1.03637436e-02f, 2.54836798e-01f, -2.12827399e-01f, -2.43852988e-01f, -4.09281194e-01f, -5.98328821e-02f,
  4.65278067e-02f, 6.95669428e-02f, -4.96318460e-01f, 6.52955830e-01f, 5.63501000e-01f, -1.50059670e-01f, 5.32839179e-01f, 2.45249867e-01f, -5.27851358e-02f, 1.14998378e-01f,
  1.26476586e-01f, 5.28949142e-01f, 1.35273203e-01f, 3.96472871e-01f, 2.97542334e-01f, 1.30814552e-01f, 3.96180719e-01f, 3.06266751e-02f, 6.21003032e-01f, 4.52870697e-01f,
  -3.05269938e-02f, -2.45342292e-02f, -7.17626065e-02f, 5.21973930e-02f, -4.49583046e-02f, -8.78906921e-02f, 1.31961092e-01f, 8.80024880e-02f, -1.16892658e-01f, 9.23252180e-02f,
  1.17662333e-01f, 2.19581351e-01f, 8.86322111e-02f, 9.67927203e-02f, -1.00626297e-01f, 3.75010818e-02f, -9.40837488e-02f, -2.90300161e-01f, -7.91593790e-02f, -1.12902693e-01f,
  -1.90233007e-01f, -1.49729729e-01f, -6.20699860e-02f, 9.25566182e-02f, 1.45616429e-02f, -1.28986603e-02f, 7.72122294e-02f, -1.74614385e-01f, 1.28682584e-01f, 1.39514744e-01f,
  1.60519168e-01f, 1.39054477e-01f, -9.90270451e-03f, -5.00462018e-02f, 7.50121027e-02f, -3.92813310e-02f, 7.30488636e-03f, -3.44638824e-02f, -4.28818241e-02f, -1.75313372e-02f,
  -6.83041736e-02f, 7.49226585e-02f, -6.95259720e-02f, -3.33332866e-02f, 6.76260218e-02f, -6.41196668e-02f, -5.91311022e-04f, 1.42238557e-01f, -2.64786720e-01f, -1.49265572e-01f,
  2.12773047e-02f, 5.74461110e-02f, -6.81325644e-02f, -1.12677537e-01f, -6.14709295e-02f, -8.16608667e-02f, 7.05431625e-02f, -1.25736874e-02f, -1.45475656e-01f, -5.23130596e-02f,
  1.58741623e-01f, 4.50652033e-01f, -3.55633274e-02f, -6.10214993e-02f, 1.14396093e-02f, 1.51882097e-01f, 1.71306342e-01f, 1.94899783e-01f, 2.57292807e-01f, 1.27783239e-01f,
  1.35214224e-01f, -1.06577225e-01f, 5.02653532e-02f, 6.88869208e-02f, 7.47769400e-02f, -6.50943369e-02f, 6.55875579e-02f, 2.40481482e-03f, 2.69937161e-02f, 1.31224632e-01f,
  -4.44344915e-02f, -3.33369188e-02f, 8.26285481e-02f, -1.22948386e-01f, 1.21072143e-01f, -8.02923217e-02f, -4.47615758e-02f, -1.20728791e-01f, 6.02736063e-02f, 1.11174844e-01f,
  -7.76074588e-01f, 5.59662879e-01f, 4.14501727e-02f, -1.95749849e-01f, 5.00741124e-01f, 1.11006789e-01f, -9.58786160e-02f, 4.27379608e-01f, 1.13509901e-01f, -2.02867344e-01f,
  -2.02791423e-01f, -2.27758303e-01f, 1.24623040e-02f, -1.25084102e-01f, -3.65926057e-01f, -1.70793593e-01f, -4.07447964e-01f, -3.98056388e-01f, 2.36307055e-01f, -1.71519205e-01f,
  -5.27252583e-03f, 2.77360320e-01f, -4.11266607e-04f, 5.83690763e-01f, 3.19407731e-01f, 1.27335295e-01f, -3.38400811e-01f, 3.05353075e-01f, -6.36604950e-02f, 3.15836757e-01f,
  -2.01264068e-01f, -3.22145313e-01f, -1.06073730e-01f, -8.37977752e-02f, -3.46488863e-01f, -2.09308878e-01f, -2.61533678e-01f, 6.51510581e-02f, -4.58773226e-02f, 1.00539818e-01f,
  -4.62194309e-02f, 8.65293220e-02f, 1.53705478e-01f, 1.93740085e-01f, 1.12211823e-01f, 1.30008146e-01f, 2.03810260e-03f, 2.78432574e-02f, 1.51394680e-01f, 1.33793667e-01f,
  2.74213664e-02f, -4.39780997e-03f, -1.03203334e-01f, -3.93060073e-02f, 3.64851998e-03f, -1.02152683e-01f, -5.25447503e-02f, -1.57520566e-02f, -8.05249587e-02f, -4.66303714e-02f,
  -1.19215421e-01f, -1.82640463e-01f, 3.11482605e-02f, 5.40496409e-02f, 2.87713204e-02f, 9.95129421e-02f, -1.53523041e-02f, 9.68434964e-04f, -4.10454441e-03f, -6.46952614e-02f,
  5.83765022e-02f, -5.06232008e-02f, 9.38333347e-02f, -1.16098210e-01f, -9.77638289e-02f, -1.80544183e-02f, -1.70148447e-01f, -6.17649630e-02f, 1.03544235e-01f, -7.04056919e-02f,
  5.30596413e-02f, -9.99209434e-02f, -2.23257765e-02f, 4.22592312e-02f, -6.62010610e-02f, 7.73459300e-02f, -6.50869906e-02f, 1.39236152e-01f, -3.74338068e-02f, 6.51886016e-02f,
  -6.26868248e-01f, -5.86867452e-01f, -4.22137864e-02f, 1.30862772e-01f, -5.74531071e-02f, 4.28819424e-03f, -3.35495472e-02f, 1.30056605e-01f, -1.26242749e-02f, -4.72970679e-02f,
  -6.05413988e-02f, -1.12895496e-01f, -1.13436192e-01f, -1.04840465e-01f, -2.54895072e-02f, 4.24877107e-02f, -1.16020650e-01f, -1.06498130e-01f, -1.17940284e-01f, -1.28112674e-01f,
  -7.67050162e-02f, -7.92928636e-02f, -8.11611041e-02f, 1.59883112e-01f, 2.21053660e-02f, -4.86278050e-02f, -1.26498818e-01f, 1.70099765e-01f, -6.58758655e-02f, 6.94718510e-02f,
  1.58591375e-01f, 7.21393228e-01f, 2.97914386e-01f, 2.13808760e-01f, -1.39554115e-02f, -6.68455184e-01f, -4.06760424e-01f, 7.16698766e-02f, -1.12923332e-01f, 1.96193874e-01f,
  -2.51949787e-01f, 4.85088140e-01f, -2.27825046e-01f, -1.64323553e-01f, -9.19628739e-01f, -6.77922249e-01f, -2.71050543e-01f, -3.10180690e-02f, -9.99534503e-02f, 2.83563852e-01f,
  -2.52249092e-01f, -2.11080298e-01f, -1.24965243e-01f, 1.64042339e-01f, 4.09746468e-01f, 4.17717487e-01f, 2.89984420e-02f, 1.65602684e-01f, 3.10269535e-01f, -1.01249870e-02f,
  -5.38977161e-02f, 1.37972176e-01f, 1.52037993e-01f, -4.40001935e-02f, -1.37449592e-01f, 1.44981891e-02f, 1.04688667e-01f, -4.07914929e-02f, -1.42676920e-01f, 4.15188745e-02f,
  5.45651140e-03f, -9.60271433e-02f, 1.50226310e-01f, 4.80433106e-02f, 1.08555548e-01f, 1.64511248e-01f, 4.58031753e-03f, 4.60208431e-02f, 8.75207111e-02f, 8.35418552e-02f,
  2.57495940e-02f, 5.47755472e-02f, 7.09759118e-03f, 8.63663182e-02f, -4.60395217e-02f, 6.29485250e-02f, -6.13452531e-02f, 1.31880850e-01f, 5.29409088e-02f, 2.62596235e-02f,
  1.12386256e-01f, -6.69574887e-02f, -3.53999324e-02f, 3.31889689e-02f, -1.17966488e-01f, 4.41938965e-03f, -2.95847002e-02f, 2.87575368e-02f, 6.37116134e-02f, -1.26755489e-02f,
  -3.18778642e-02f, 8.52859765e-02f, 6.11337274e-03f, -4.67639863e-02f, -2.26039123e-02f, 7.18525946e-02f, -3.86382900e-02f, 4.96967658e-02f, 4.45109494e-02f, -7.89327547e-02f,
  1.59871858e-02f, -1.11675091e-01f, 6.80676624e-02f, -2.22535338e-02f, -1.08613700e-01f, 4.01084498e-02f, 2.71767564e-02f, 1.50387431e-03f, 5.44929914e-02f, -5.63814938e-02f,
  -5.03417738e-02f, 1.22845747e-01f, 2.01645661e-02f, 3.91433276e-02f, 1.37247881e-02f, -4.33582552e-02f, -1.04638837e-01f, 9.37811434e-02f, -1.50843207e-02f, -7.99168870e-02f,
  5.75417280e-03f, 4.10920531e-02f, 7.29867257e-03f, 4.81833890e-03f, -5.24033196e-02f, -1.09310314e-01f, -5.56074269e-02f, 3.64556871e-02f, 5.68791553e-02f, 1.41270578e-01f,
  1.17169954e-01f, 8.53470191e-02f, -1.16052032e-01f, -9.11323428e-02f, 2.22611707e-02f, -3.47508378e-02f, 7.75115490e-02f, 1.04447208e-01f, 6.15515141e-03f, 4.04344127e-02f,
  1.48433140e-02f, -2.74866343e-01f, 1.52257666e-01f, 4.29159731e-01f, -2.42256835e-01f, -6.42107546e-01f, -5.22995949e-01f, -1.03364393e-01f, -2.59536833e-01f, -3.14380944e-01f,
  -2.24592388e-01f, 4.52186227e-01f, -5.17301559e-01f, 4.24398333e-01f, 3.50356698e-01f, -1.65640265e-01f, 1.46953374e-01f, 2.91682392e-01f, 1.84201717e-01f, -2.31919169e-01f,
  1.96795091e-01f, 7.38340691e-02f, 3.19519967e-01f, 1.91376135e-01f, 1.30859941e-01f, 4.73277867e-01f, 4.20429528e-01f, 1.31488621e-01f, 4.55228299e-01f, 3.59711021e-01f,
  -4.63095486e-01f, 3.91348787e-02f, 3.77298973e-04f, 9.29111242e-02f, -2.10541990e-02f, -6.05304865e-03f, -2.14736052e-02f, 7.07512870e-02f, 1.69178307e-01f, 7.26202130e-02f,
  -9.89988521e-02f, 9.67661664e-03f, 2.49129906e-01f, 8.35639890e-03f, -8.15811306e-02f, 1.32656947e-01f, 2.87319794e-02f, 1.86346062e-02f, -2.97706127e-02f, 2.03346442e-02f,
  -6.35176525e-02f, 3.17593291e-02f, 5.40195033e-02f, 9.61683020e-02f, -6.41790079e-03f, -1.72258705e-01f, 5.73208258e-02f, 8.97925869e-02f, 1.40794069e-01f, -5.09029888e-02f,
  -8.51335898e-02f, -2.45820601e-02f, 3.53297070e-02f, 2.83872820e-02f, -7.12071583e-02f, 3.70251164e-02f, -4.06866372e-02f, 3.48801911e-02f, 1.15138032e-01f, -1.73582196e-01f,
  -6.76401779e-02f, 8.67489427e-02f, 1.76082328e-02f, -1.68641150e-01f, 4.39848155e-02f, 5.83233945e-02f, 3.26159447e-02f, -8.10893625e-03f, -6.77809939e-02f, 8.29467997e-02f,
  -8.53117481e-02f, -1.24218881e-01f, 2.76863910e-02f, 1.85522549e-02f, -1.04831383e-01f, -4.23479006e-02f, 1.62922442e-01f, -7.76594505e-02f, 1.99645702e-02f, 7.80456141e-02f,
  -6.39217198e-01f, -5.17960005e-02f, -1.06601909e-01f, -1.73792809e-01f, 8.04004073e-02f, 5.39307995e-03f, 1.31132305e-01f, 3.55300941e-02f, -8.92595649e-02f, -1.23396464e-01f,
  -2.08172631e-02f, 1.24451347e-01f, -5.85220717e-02f, 2.81646941e-02f, 4.36283685e-02f, -1.38689920e-01f, 1.20244576e-02f, 9.17705819e-02f, 8.43843445e-02f, 1.13873310e-01f,
  4.70079780e-02f, -1.26302615e-01f, 7.97790214e-02f, -1.04091559e-02f, 6.43752841e-03f, -8.18710849e-02f, 1.07013941e-01f, 4.53830399e-02f, 5.92165999e-02f, 9.88353714e-02f,
  1.57429218e-01f, -3.31974216e-02f, -3.56306434e-01f, 4.05130982e-01f, 2.21181318e-01f, 5.18883049e-01f, 6.86733782e-01f, 2.44872957e-01f, 5.49176455e-01f, 1.99662313e-01f,
  2.23735109e-01f, -4.22962785e-01f, 1.22041374e-01f, -9.25526395e-02f, -1.78382099e-01f, 5.08836657e-02f, 3.67503375e-01f, 1.54282317e-01f, 2.98611343e-01f, 8.16418231e-02f,
  3.18615064e-02f, 1.66188002e-01f, -4.56048995e-01f, -3.63488570e-02f, -6.45201840e-03f, -6.74269497e-02f, -2.74770916e-01f, -4.04597148e-02f, -3.43573987e-01f, -1.65939219e-02f,
  -4.26027104e-02f, 1.58264071e-01f, -9.36843082e-02f, -9.73295569e-02f, 1.02593474e-01f, 1.58805296e-01f, -4.10709716e-03f, -1.49860568e-02f, 1.82071037e-03f, 8.04174840e-02f,
  2.55501904e-02f, -1.05754808e-01f, 8.85001570e-02f, -9.08035934e-02f, 3.75447385e-02f, -2.21073069e-02f, -1.31718472e-01f, -6.40796870e-02f, -4.34232950e-02f, -1.39575183e-01f,
  -5.41392565e-02f, -6.71508834e-02f, 1.06767349e-01f, 7.78097808e-02f, -2.06401080e-01f, 5.63077331e-02f, 3.05173993e-02f, -1.34024560e-01f, 7.53063662e-03f, -5.42246625e-02f,
  -4.59436476e-02f, 1.59212410e-01f, 8.77144709e-02f, -2.05561705e-02f, -2.81632207e-02f, -3.11116297e-02f, 1.01695709e-01f, -4.37531397e-02f, 5.30596599e-02f, -2.62884181e-02f,
  1.04869463e-01f, -3.31405066e-02f, 3.54839712e-02f, -6.21980801e-03f, 1.52466580e-01f, 7.92418048e-02f, -3.23097780e-02f, -6.52806740e-03f, 1.58698395e-01f, -9.46910083e-02f,
  -1.35712894e-02f, 2.08951980e-02f, -4.40732054e-02f, 5.61100841e-02f, -4.52081226e-02f, -9.04770494e-02f, 1.10727683e-01f, -1.42570615e-01f, 4.98674903e-03f, 2.06143722e-01f,
  1.04700819e-01f, 4.89403248e-01f, 4.73566651e-02f, -1.34372011e-01f, -2.47362722e-02f, 2.40159500e-02f, 6.00954965e-02f, 6.77150721e-03f, 1.23209968e-01f, 1.97204083e-01f,
  1.02048032e-01f, 1.19566143e-01f, 2.23910779e-01f, -1.35964751e-01f, -5.63310534e-02f, 1.56439826e-01f, -1.66573599e-02f, 9.32148919e-02f, 1.60398945e-01f, -1.50981918e-01f,
  -4.98601496e-02f, 2.59595990e-01f, 1.57106407e-02f, 1.32414058e-01f, 8.21462348e-02f, 4.04974818e-02f, 1.81133866e-01f, -3.44820730e-02f, -2.48836726e-02f, 5.64153194e-02f,
  -1.43045425e-01f, -1.99262902e-01f, -2.93627739e-01f, -7.40037262e-02f, -2.94187572e-02f, -2.68499196e-01f, -6.62276328e-01f, 9.94932577e-02f, -5.88846028e-01f, -3.06022000e-02f,
  -1.15334950e-01f, -7.77136981e-02f, -4.66055810e-01f, -3.35464835e-01f, 3.67071144e-02f, -3.88945013e-01f, 2.28077531e-01f, 8.52664933e-02f, 4.11377326e-02f, 3.61588210e-01f,
  3.08219880e-01f, 2.27902114e-01f, 3.84500057e-01f, 5.20816982e-01f, 2.04313889e-01f, 3.85823399e-01f, 7.00643241e-01f, 1.86819851e-01f, 5.47800124e-01f, -1.26617253e-02f,
  -1.71901673e-01f, -1.59201339e-01f, -1.24969341e-01f, -1.60155192e-01f, 6.65028542e-02f, 1.55978978e-01f, 2.20062077e-01f, -2.40487382e-02f, -4.77765873e-02f, -1.21209130e-01f,
  4.23585363e-02f, 5.13279401e-02f, -4.98371832e-02f, -1.34653166e-01f, -3.56827155e-02f, 1.25732431e-02f, 3.59957591e-02f, 5.37436223e-03f, -1.63945794e-01f, -8.80463570e-02f,
  -5.72977439e-02f, 5.07168956e-02f, 3.56509760e-02f, 1.05109483e-01f, 3.68571561e-03f, 6.69670105e-02f, 4.70311455e-02f, 5.46974503e-02f, -5.29656634e-02f, -8.34535509e-02f,
  1.38089478e-01f, 1.95087325e-02f, -1.86105203e-02f, -1.51574224e-01f, -1.27518639e-01f, -6.13789037e-02f, -2.02706568e-02f, -3.61369513e-02f, -7.53734261e-02f, 4.31649461e-02f,
  1.07775345e-01f, 6.68598413e-02f, -2.28926197e-01f, -5.80472462e-02f, 4.33412530e-02f, -9.65932533e-02f, 4.62801158e-02f, 9.10638869e-02f, 1.15897298e-01f, -2.95506269e-02f,
  -2.34943777e-01f, 9.90258753e-02f, -2.65925266e-02f, 9.13269371e-02f, -1.36359900e-01f, 6.94455206e-02f, 2.07486935e-02f, -8.87894332e-02f, -9.06552747e-03f, 1.47089854e-01f,
  9.95891914e-02f, 3.27992439e-01f, -7.28181051e-03f, -5.89569993e-02f, -9.34462920e-02f, 6.13695234e-02f, -1.58202857e-01f, 3.63242701e-02f, 1.58173189e-01f, -2.58341525e-02f,
  3.33707809e-01f, 7.90580213e-02f, 1.59620970e-01f, 2.51702927e-02f, 6.56077117e-02f, 1.05623268e-01f, 1.11854628e-01f, 4.91798259e-02f, 1.98536575e-01f, 2.28633851e-01f,
  1.77029759e-01f, 1.37720853e-01f, -1.32236993e-02f, 8.58271718e-02f, 1.37529537e-01f, 1.72512382e-01f, 4.73910421e-02f, 5.49380183e-02f, 1.20447613e-01f, -9.24816877e-02f,
  4.47818860e-02f, 1.27190471e-01f, -4.35418963e-01f, -3.45766723e-01f, -1.02920420e-01f, -8.76589045e-02f, -8.03227350e-02f, -1.59407094e-01f, -3.79191756e-01f, 5.80837250e-01f,
  3.15613270e-01f, -1.73439384e-01f, 1.44151688e-01f, 2.17639819e-01f, -1.81096241e-01f, 1.71364322e-01f, 3.30599189e-01f, 3.06334585e-01f, -1.02527522e-01f, 2.33348623e-01f,
  9.44657922e-02f, 2.73757279e-01f, 1.08331375e-01f, 1.68245703e-01f, 1.59077495e-01f, -1.15668073e-01f, 5.39253116e-01f, -3.53928685e-01f, 1.14910454e-01f, -2.41237711e-02f,
  1.22776050e-02f, 3.76010779e-03f, -2.34659202e-02f, -8.64646286e-02f, 1.75371051e-01f, 2.45627612e-02f, 3.48259173e-02f, -1.59622312e-01f, -2.87643939e-01f, 1.32516865e-02f,
  -5.44914939e-02f, -2.66150981e-02f, -5.60089648e-02f, -1.41500756e-01f, -1.34070143e-01f, -1.84094712e-01f, -8.31165910e-02f, -9.07427818e-03f, -1.93261713e-01f, -4.82013216e-03f,
  -1.57690004e-01f, -3.10828444e-02f, 7.68908933e-02f, 1.08280078e-01f, -9.08189416e-02f, -1.16978712e-01f, 1.55065889e-02f, 1.25316218e-01f, 3.68124582e-02f, 1.68821623e-03f,
  2.03040969e-02f, 5.29649593e-02f, 7.52208605e-02f, -6.02304637e-02f, -8.77430849e-03f, 1.02992142e-02f, -9.34195966e-02f, 1.80530045e-02f, -1.06854081e-01f, 5.31657338e-02f,
  -1.09377593e-01f, -1.94284424e-01f, -2.68475227e-02f, 3.57894488e-02f, 5.77536337e-02f, -3.47107905e-03f, -1.65281162e-01f, -6.99538086e-03f, 1.21434741e-02f, -1.15158245e-01f,
  -2.02106740e-02f, -8.56907517e-02f, 1.00938551e-01f, -7.40063637e-02f, -6.57570437e-02f, 1.80461258e-02f, 1.79367244e-01f, -3.04582976e-02f, 1.26851469e-01f, 2.84182094e-02f,
  1.63784772e-01f, 2.48927727e-01f, 5.27571933e-03f, -9.48728770e-02f, -3.72795202e-02f, 1.22198813e-01f, 2.30901651e-02f, -3.80622484e-02f, 7.96693414e-02f, -7.79859945e-02f,
  8.54475051e-02f, -5.28694950e-02f, 2.68931538e-01f, -1.19119948e-02f, -1.79283872e-01f, 1.93618417e-01f, 1.30928189e-01f, 2.71647628e-02f, 1.83426496e-02f, 8.47778693e-02f,
  2.76275706e-02f, -4.77091521e-02f, 5.72798811e-02f, -7.32378569e-03f, 9.75055769e-02f, 1.18219450e-01f, -1.16728790e-01f, 5.37798973e-03f, -2.19602622e-02f, -6.09787740e-03f,
  -6.76779866e-01f, 2.68081844e-01f, 5.47143340e-01f, -1.68586627e-01f, 4.55165863e-01f, 5.94527841e-01f, 1.19649529e-01f, 5.32729030e-01f, 5.66226006e-01f, -3.51701319e-01f,
  -4.15962785e-01f, -3.79322976e-01f, -1.13177625e-03f, -1.69721544e-01f, 7.52681121e-02f, 2.27102116e-01f, 7.50598758e-02f, -1.13956399e-01f, 4.70658720e-01f, 1.64578184e-02f,
  1.49538174e-01f, -2.98741758e-01f, -1.80597715e-02f, 1.32958397e-01f, -9.84715763e-03f, -3.76450345e-02f, -4.61158216e-01f, 4.20357049e-01f, -3.93776923e-01f, 1.11449227e-01f,
  -2.63492674e-01f, 4.24812585e-02f, -1.18183285e-01f, 9.61953625e-02f, -3.00246440e-02f, -1.57187169e-03f, 4.61797491e-02f, -5.63401654e-02f, -8.19202699e-03f, -1.97745971e-02f,
  -1.98112741e-01f, 1.01210982e-01f, -2.42819972e-02f, 2.62415595e-02f, 1.94687590e-01f, 7.12332800e-02f, 4.49103191e-02f, 8.87662638e-03f, -4.10344265e-02f, 1.55159593e-01f,
  -8.33144225e-03f, 1.00128524e-01f, -5.68083040e-02f, -6.75108135e-02f, 9.53684226e-02f, 1.37174755e-01f, 1.16586104e-01f, -1.58390440e-02f, -1.66894235e-02f, 9.51540321e-02f,
  1.94166094e-01f, 3.28461975e-01f, -2.06701159e-02f, -1.75809767e-02f, 3.24559137e-02f, -1.53891416e-02f, -1.27049908e-01f, -9.40766782e-02f, 8.52025449e-02f, -1.36406720e-01f,
  -6.95798546e-02f, -5.99923097e-02f, 1.62375659e-01f, 7.32137933e-02f, -3.48559134e-02f, -3.96409109e-02f, -1.26497462e-01f, -4.92347330e-02f, 4.02172059e-02f, 5.66840135e-02f,
  1.75495073e-02f, 8.47461149e-02f, -1.03633292e-01f, -1.46217821e-02f, 9.79586691e-02f, 4.34596576e-02f, -7.33026769e-03f, -5.09352461e-02f, 1.19992793e-02f, -8.86991844e-02f,
  -8.21823403e-02f, 1.27848744e-01f, -7.47528374e-02f, -2.41392255e-01f, 1.40191531e-02f, -9.79904681e-02f, 1.98626623e-01f, -5.61974235e-02f, 8.58855993e-02f, 1.45046310e-02f,
  -6.44895881e-02f, -2.13481933e-01f, -4.28952798e-02f, 1.19745983e-02f, -2.96831969e-02f, -4.34445292e-02f, -1.14808455e-01f, -4.40952927e-02f, -1.05665162e-01f, 2.95751859e-02f,
  -1.58262521e-01f, -1.43931508e-02f, -5.88853359e-02f, -6.29251823e-02f, -1.42853230e-01f, -2.39136308e-01f, -8.51527601e-02f, -8.02661553e-02f, 2.61369045e-03f, 9.51381922e-02f,
  4.94750470e-01f, 4.55386490e-01f, 3.49405736e-01f, 6.08213961e-01f, 2.66600341e-01f, -5.02964258e-01f, -1.45708814e-01f, 2.74537772e-01f, 5.78248799e-01f, -9.98703465e-02f,
  1.07651800e-01f, 1.61426604e-01f, -3.81149054e-02f, 3.70618403e-01f, -2.36613303e-01f, -1.19078159e-01f, 8.43682885e-02f, -2.55297460e-02f, 3.14382195e-01f, 2.41959721e-01f,
  2.50682086e-01f, 8.26965123e-02f, 2.13075459e-01f, -5.87508753e-02f, 2.51116037e-01f, 2.85140008e-01f, -1.43573016e-01f, -7.95215294e-02f, -3.89012620e-02f, -1.84106320e-01f,
  -4.93588857e-02f, 4.88054365e-01f, 1.05382748e-01f, -9.47670564e-02f, 8.91419277e-02f, -1.49762288e-01f, -1.07300974e-01f, -6.71097934e-02f, -1.08979806e-01f, 1.02171311e-02f,
  1.32548153e-01f, -1.36578754e-01f, -1.41515449e-01f, -2.06558164e-02f, 1.87601931e-02f, 7.91972727e-02f, 1.49939582e-01f, 6.60845125e-03f, 1.90632895e-01f, 1.61274195e-01f,
  1.73817843e-01f, 8.95441920e-02f, 4.44129258e-02f, 6.26398623e-02f, 1.04788214e-01f, 2.04748735e-01f, -1.77870572e-01f, -5.64272292e-02f, 5.63273840e-02f, 2.86601931e-01f,
  1.69004276e-01f, -1.45390898e-01f, 2.64419783e-02f, -6.73033893e-02f, 8.36728886e-02f, 1.05092131e-01f, 8.13788399e-02f, -1.15485482e-01f, -7.81758875e-02f, 2.24314127e-02f,
  -1.36262506e-01f, 9.86273661e-02f, 1.08852312e-01f, -9.81081929e-03f, 2.21267670e-01f, 1.45428523e-01f, -7.37314373e-02f, -1.99740641e-02f, 4.81471568e-02f, 9.76591110e-02f,
  4.83471937e-02f, -1.26607701e-01f, 6.99003134e-03f, -1.02904946e-01f, -1.65339395e-01f, 1.42931432e-01f, 1.27498478e-01f, 9.15672183e-02f, -3.79060991e-02f, -8.57033581e-03f,
  4.09501977e-03f, 4.57309127e-01f, -6.24927171e-02f, 3.60335931e-02f, 1.79725792e-02f, -1.10195354e-01f, -4.56756167e-02f, 1.00600637e-01f, 9.07742754e-02f, 1.52596040e-02f,
  8.37062746e-02f, -1.13309748e-01f, -2.15460703e-01f, -5.07344045e-02f, -1.85481399e-01f, 5.34088500e-02f, -4.35007224e-03f, -2.58308295e-02f, 1.57102719e-02f, 4.19743098e-02f,
  -5.03048152e-02f, -1.17946871e-01f, -4.25533019e-03f, -4.22277525e-02f, -8.21543708e-02f, 2.26068310e-02f, -1.02376990e-01f, -1.76938083e-02f, 7.21848756e-02f, -1.71532318e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.97041309e-01f, 7.39079177e-01f, 7.01848745e-01f, 4.50275898e-01f, 6.12719893e-01f, 3.57232064e-01f, 5.68715096e-01f, 6.27904952e-01f, 4.31727946e-01f, 2.84187764e-01f,
  6.75401509e-01f, 5.02948463e-01f, 4.31651980e-01f, 4.71491426e-01f, 5.65607011e-01f, 4.89355654e-01f, 4.10168529e-01f, 4.40461725e-01f, 1.69821292e-01f, 3.98598105e-01f,
  3.31069380e-01f, 5.81934690e-01f, 6.69976115e-01f, 4.39661115e-01f, 5.71385920e-01f, 7.30937421e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.97867289e-01f, -4.02823210e-01f, -3.03078175e-01f, 1.94815889e-01f, -3.64592612e-01f, 1.23931043e-01f, 7.00509399e-02f, 2.41872319e-03f, -1.95052817e-01f, 8.62528905e-02f,
  -7.67989829e-02f, 6.13970459e-02f, 2.35245447e-03f, -2.61392117e-01f, 2.76232064e-02f, 2.65887946e-01f, -3.59580338e-01f, -3.63531560e-02f, -4.83514160e-01f, 2.77325243e-01f,
  -4.48311806e-01f, 1.29039273e-01f, -1.45443335e-01f, -3.51244718e-01f, 2.83580292e-02f, 3.39653105e-01f, -2.28273496e-01f, -2.06318930e-01f, 3.22334319e-01f, -1.66396927e-02f,
  1.46910667e-01f, 2.17519209e-01f, -4.37860489e-01f, -4.64725554e-01f, 1.00820400e-01f, -4.51839417e-01f, 5.17324388e-01f, -4.14287150e-01f, -2.16361433e-01f, -2.19489604e-01f,
  -4.44745809e-01f, -4.08322573e-01f, 4.37687874e-01f, -2.60770172e-01f, -6.27702892e-01f, -5.09271085e-01f, 2.68828183e-01f, 5.50942898e-01f, 5.09722233e-01f, -3.13162282e-02f,
  8.15799952e-01f, -7.72031248e-01f, -4.21741247e-01f, -6.51337445e-01f, 4.77223337e-01f, -2.17487499e-01f, -4.84521568e-01f, -3.71804059e-01f, -1.76678430e-02f, 9.88758877e-02f,
  -7.10031867e-01f, 4.56413060e-01f, -6.73296571e-01f, -3.88377488e-01f, -2.11690724e-01f, 3.11000645e-01f, 5.23370981e-01f, 9.37720016e-03f, 4.87146527e-02f, -5.16925514e-01f,
  -5.00270963e-01f, -1.48513494e-02f, 1.64386541e-01f, -1.88593403e-01f, 2.46258870e-01f, -2.08260724e-03f, -6.03858717e-02f, 1.64289549e-01f, 9.71109271e-02f, -5.58536649e-01f,
  4.97431234e-02f, 3.61785620e-01f, -1.98138714e-01f, -4.29888010e-01f, 1.94454581e-01f, 2.17350364e-01f, 2.69552052e-01f, -3.03402115e-02f, 3.79396468e-01f, -4.74023700e-01f,
  6.34809554e-01f, -2.97952831e-01f, -5.82856238e-01f, 2.27583736e-01f, -6.05523944e-01f, -1.33495275e-02f, 3.70069772e-01f, -3.08704108e-01f, -2.56756723e-01f, -4.09711212e-01f,
  3.22133042e-02f, -4.23595339e-01f, -7.39665389e-01f, -4.36670110e-02f, 8.37542415e-02f, -4.16010439e-01f, 3.60169828e-01f, 2.62305647e-01f, -8.17431509e-02f, -6.67680085e-01f,
  1.99232012e-01f, -4.62734252e-02f, -5.86546361e-01f, 6.30453229e-01f, -4.95388448e-01f, 4.41368759e-01f, 2.30976611e-01f, -7.78961599e-01f, -5.31832092e-02f, 2.93790966e-01f,
  -1.78331256e-01f, -3.74920607e-01f, -6.38638973e-01f, 1.94612041e-01f, -7.75660053e-02f, 3.76125544e-01f, -7.95473337e-01f, -2.77074184e-02f, -5.39167672e-02f, -9.72476080e-02f,
  -4.84425485e-01f, -2.27418363e-01f, -1.22326143e-01f, 6.68740571e-02f, -1.49079770e-01f, -1.09692171e-01f, -1.27312467e-01f, -6.11644648e-02f, -1.99677963e-02f, -2.89257228e-01f,
  -3.71519297e-01f, -1.33530796e-01f, -1.00654447e-02f, -1.23324893e-01f, -2.51056343e-01f, -4.95757639e-01f, 7.63450712e-02f, 4.49195057e-01f, 3.30261946e-01f, -9.64146405e-02f,
  -3.59655142e-01f, 3.58020335e-01f, 9.09445956e-02f, -1.97607264e-01f, -3.37550730e-01f, -3.64080928e-02f, -2.11409464e-01f, 3.02671473e-02f, -3.26065093e-01f, -4.37112838e-01f,
  -3.95238260e-03f, 4.00507480e-01f, -3.02463025e-01f, -2.08219498e-01f, -2.01278210e-01f, -2.73550957e-01f, 3.31684127e-02f, 1.88335389e-01f, -1.31900292e-02f, -2.85726756e-01f,
  -2.10186973e-01f, 3.58284444e-01f, -5.59074998e-01f, -2.86248118e-01f, 4.83938843e-01f, 4.04849559e-01f, -6.47412658e-01f, -3.30508769e-01f, -1.67588279e-01f, 2.56717741e-01f,
  -7.52677381e-01f, -3.68033379e-01f, -3.03293109e-01f, 5.24815798e-01f, 1.61454737e-01f, -3.21458131e-02f, 5.46043873e-01f, -7.48481095e-01f, 2.07302421e-01f, -5.86658657e-01f,
  -4.30422604e-01f, -7.95177698e-01f, -3.97237509e-01f, -1.55081078e-01f, -1.36500195e-01f, -1.43796161e-01f, 3.44697610e-02f, 1.09061673e-01f, -4.49411631e-01f, -5.28410487e-02f,
  4.09407079e-01f, 5.12523241e-02f, -2.31690541e-01f, 9.85948220e-02f, -3.67484689e-01f, 2.91008562e-01f, -8.17730054e-02f, -3.71101201e-01f, 6.29089698e-02f, -4.09605801e-01f,
  2.83435248e-02f, 4.47997570e-01f, -1.03851222e-01f, -8.16531703e-02f, 3.42290163e-01f, 4.22308207e-01f, -2.20247820e-01f, 2.96708077e-01f, -2.66332656e-01f, 1.32466964e-02f,
  1.47787362e-01f, -2.54152507e-01f, -4.09800440e-01f, 2.80752867e-01f, -3.54995012e-01f, 1.12461060e-01f, 3.42092961e-01f, 2.86501914e-01f, 1.13965869e-01f, 1.62789434e-01f,
  -3.62461150e-01f, -7.63395369e-01f, -3.77397954e-01f, 6.52368128e-01f, -8.55502784e-01f, -3.18536341e-01f, -4.20713633e-01f, -5.58357000e-01f, -6.14220202e-01f, 2.27722511e-01f,
  2.27440093e-02f, 4.94575739e-01f, 4.40748960e-01f, -3.20937485e-01f, -3.18408757e-01f, 4.90347356e-01f, 2.70199955e-01f, -4.50790942e-01f, 6.42818570e-01f, 3.60502779e-01f,
  -4.63060051e-01f, -7.68392906e-02f, -6.85707569e-01f, -5.47693729e-01f, 4.36806120e-02f, 2.63710946e-01f, 2.40580276e-01f, 3.74627769e-01f, -3.90086472e-02f, 3.98903161e-01f,
  1.62382752e-01f, -7.06038848e-02f, 4.13620174e-02f, 1.28052562e-01f, 4.42907870e-01f, -7.99845830e-02f, 1.01214699e-01f, 1.93097487e-01f, 2.90094614e-01f, -4.49808389e-02f,
  2.18539953e-01f, 2.29039893e-01f, 2.44948670e-01f, 1.46194980e-01f, 1.01123661e-01f, -2.85291940e-01f, 2.20467776e-01f, 3.16409707e-01f, -3.01734120e-01f, -5.95469058e-01f,
  -5.85272789e-01f, 5.05897224e-01f, -6.50307462e-02f, 3.54849011e-01f, 3.61366153e-01f, -4.67177540e-01f, -4.78855781e-02f, 3.90620172e-01f, -4.84580070e-01f, 7.60501742e-01f,
  5.25915504e-01f, 1.95690766e-01f, -9.22060311e-02f, -2.48037912e-02f, -6.50136113e-01f, 2.25897387e-01f, -6.39216781e-01f, -6.52903914e-01f, 2.22774342e-01f, -3.90960097e-01f,
  7.19188869e-01f, 1.35958165e-01f, -3.93820763e-01f, 2.56560832e-01f, 2.01813415e-01f, 5.75973503e-02f, -5.98724306e-01f, -4.35110927e-01f, -8.46216828e-02f, -1.69282989e-03f,
  1.49557322e-01f, -5.07021472e-02f, 4.50938880e-01f, -8.84616911e-01f, -1.75866500e-01f, -5.07114291e-01f, 1.27983674e-01f, -1.02226213e-01f, 6.62727535e-01f, -2.67052263e-01f,
  -1.24396324e-01f, 6.87715113e-02f, 5.53548522e-02f, 1.82309821e-01f, 2.24532373e-02f, 4.75743920e-01f, 3.87071699e-01f, 1.02223098e-01f, -1.47536293e-01f, 4.41884518e-01f,
  1.05497763e-01f, 7.59905130e-02f, 9.33234766e-02f, 2.97442853e-01f, 8.14248342e-03f, 9.60862041e-02f, 3.53789091e-01f, 1.39127180e-01f, 2.54207790e-01f, -4.15309876e-01f,
  -6.46632433e-01f, 5.40573418e-01f, -4.22948241e-01f, -5.83782673e-01f, 2.96403259e-01f, -5.39463162e-01f, 2.05595374e-01f, -3.94108891e-01f, -5.42136980e-03f, -3.34335834e-01f,
  4.62352693e-01f, 3.71519893e-01f, -3.49316120e-01f, -5.05253434e-01f, -4.24349457e-01f, 1.64054662e-01f, -1.83562189e-01f, 4.38554883e-01f, 1.68889582e-01f, -6.31298065e-01f,
  4.85670954e-01f, 2.91665703e-01f, 4.05266762e-01f, -6.42749012e-01f, -4.88507807e-01f, 4.25216496e-01f, -6.05893433e-01f, -7.65973449e-01f, -5.92084944e-01f, -8.54020298e-01f,
  -6.41421795e-01f, -3.19422811e-01f, -5.46621561e-01f, -7.33851314e-01f, 1.12971373e-01f, 1.33681938e-01f, -5.20716727e-01f, -6.21196568e-01f, -3.41673046e-01f, 5.47506213e-01f,
  -2.11786553e-01f, -2.20980033e-01f, 5.48123479e-01f, 1.38464421e-01f, 1.56908914e-01f, -1.48136005e-01f, -1.51987314e-01f, -5.11094093e-01f, 2.17305258e-01f, -4.12406623e-02f,
  -1.96915358e-01f, -2.05687098e-02f, -1.49087701e-02f, -1.32115737e-01f, -4.05572772e-01f, 9.86813903e-02f, 2.41141003e-02f, -5.78081235e-02f, 7.25746015e-03f, 2.27904711e-02f,
  -1.57995094e-02f, 6.52974322e-02f, -8.24121311e-02f, 5.22907138e-01f, 5.77705145e-01f, -5.86112440e-01f, -2.09742934e-01f, 6.28316224e-01f, -2.84981638e-01f, -4.70199943e-01f,
  -5.42034090e-01f, 2.73941875e-01f, 4.60022062e-01f, 3.92805159e-01f, 3.56484056e-01f, -4.73111898e-01f, 3.41050595e-01f, 1.32388607e-01f, -2.21264541e-01f, 1.61229402e-01f,
  9.78334248e-02f, 7.74144903e-02f, 4.36559528e-01f, 4.23719019e-01f, 1.06450476e-01f, -3.53559822e-01f, -6.34424627e-01f, 6.78819835e-01f, -5.74839711e-01f, 2.81820536e-01f,
  -8.90542746e-01f, -6.43831134e-01f, -5.75984478e-01f, -1.91463575e-01f, 1.55025095e-01f, 5.27978718e-01f, -4.46267612e-02f, -2.80873269e-01f, -3.95320117e-01f, -8.05931270e-01f,
  2.65101612e-01f, -6.25812352e-01f, -3.25739563e-01f, 3.92599076e-01f, -1.94711715e-01f, -2.91465849e-01f, 2.25743055e-01f, 3.34969133e-01f, -4.71419662e-01f, -7.35384300e-02f,
  6.18860535e-02f, 1.57046303e-01f, -2.16319293e-01f, 9.02105570e-02f, 1.94564372e-01f, -4.08119000e-02f, -1.56547248e-01f, 9.87276807e-03f, -4.60093915e-01f, -3.13474894e-01f,
  9.71242636e-02f, 5.99400140e-02f, -3.55166420e-02f, -3.38477165e-01f, -2.93900818e-01f, -2.82876402e-01f, -2.24092409e-01f, 1.22881457e-01f, -2.09784344e-01f, -5.07477522e-02f,
  -3.27731930e-02f, 4.26064372e-01f, 7.26544559e-02f, -9.49126557e-02f, 1.23618208e-01f, -2.85334229e-01f, -2.51483083e-01f, -6.19407780e-02f, 1.94694817e-01f, -4.60217953e-01f,
  -3.25030029e-01f, 2.68619098e-02f, 1.77611083e-01f, -2.50946373e-01f, 2.18435243e-01f, 2.59026974e-01f, -2.15291157e-01f, -4.57901865e-01f, -3.98659289e-01f, 5.40271163e-01f,
  -5.15714347e-01f, -3.95722717e-01f, 4.13134992e-01f, 2.99303681e-01f, -4.98151600e-01f, -3.05595100e-01f, -6.79353416e-01f, -4.47400272e-01f, -4.38800126e-01f, -3.69799346e-01f,
  5.35969198e-01f, 2.71418154e-01f, 3.36213917e-01f, -1.99486241e-01f, -4.88379389e-01f, -4.12398130e-01f, 4.60570306e-01f, -1.71456873e-01f, 1.35628268e-01f, 1.39472574e-01f,
  -1.68677300e-01f, -1.31066754e-01f, -1.46744773e-01f, -7.61644840e-02f, -2.21505240e-01f, -6.34355396e-02f, 8.06920510e-03f, -3.03760141e-01f, 1.04806490e-01f, -4.50677663e-01f,
  -7.30143860e-02f, -8.49733651e-02f, 2.24598162e-02f, -7.99401999e-02f, 1.60948351e-01f, -9.75888371e-02f, -1.78815991e-01f, 6.69018477e-02f, -2.96858460e-01f, -3.46098095e-02f,
  -3.94452587e-02f, -2.29577929e-01f, 2.56732851e-01f, -3.55372161e-01f, 2.46907011e-01f, -3.17625612e-01f, 2.80180126e-01f, 2.25734711e-01f, -4.44113076e-01f, 2.69563347e-01f,
  -6.94149062e-02f, 3.18902224e-01f, -4.45856899e-02f, 2.69870251e-01f, 1.66691527e-01f, -2.57603317e-01f, 5.75294532e-02f, 3.56913418e-01f, -3.54052067e-01f, -2.59985179e-01f,
  -3.10877591e-01f, -5.68906665e-01f, 4.45495427e-01f, -5.67606568e-01f, -3.96695673e-01f, -2.39743650e-01f, -7.22528622e-02f, -2.23995611e-01f, -5.21731794e-01f, -4.52228427e-01f,
  -1.29830584e-01f, -9.53235254e-02f, 5.00534236e-01f, -4.51815903e-01f, -5.46755083e-02f, -3.76599550e-01f, -4.29021448e-01f, 2.06764281e-01f, -3.43405277e-01f, 2.53407270e-01f,
  5.47690809e-01f, -4.95903999e-01f, 4.15343732e-01f, 9.78287756e-02f, -4.31629807e-01f, 5.14298797e-01f, 2.00603083e-01f, 6.54572770e-02f, 1.93178374e-02f, 1.64931435e-02f,
  1.66904062e-01f, 2.81568319e-01f, 2.61632860e-01f, -4.28327210e-02f, 2.21289575e-01f, -1.15279354e-01f, 3.36902648e-01f, 1.73924595e-01f, -2.33620256e-01f, 4.98729646e-02f,
  2.18758330e-01f, 1.47314653e-01f, 1.16069324e-01f, -1.30913118e-02f, -1.70137480e-01f, -3.82942677e-01f, -4.23761457e-03f, -2.49267876e-01f, -3.87578517e-01f, -3.89655796e-03f,
  -2.53764212e-01f, 1.85208917e-01f, 4.68607545e-01f, -3.73892605e-01f, 2.25583717e-01f, 3.46059650e-01f, 1.65052593e-01f, -3.53411943e-01f, 5.79848170e-01f, -4.13720191e-01f,
  4.37043458e-01f, -2.74656296e-01f, -3.30359161e-01f, 5.62886059e-01f, 6.45713449e-01f, -1.95754260e-01f, -7.79452860e-01f, -4.59458351e-01f, -4.68076169e-01f, -7.73057401e-01f,
  6.08346999e-01f, -5.28270960e-01f, 6.61594808e-01f, -1.85786545e-01f, 8.13748986e-02f, -6.43910766e-01f, -1.29545510e-01f, 3.89557928e-01f, 6.04094982e-01f, -3.73975962e-01f,
  -5.15395761e-01f, -1.38578221e-01f, -6.10938609e-01f, -1.30523562e-01f, 9.16138589e-02f, -2.35827461e-01f, -6.17347896e-01f, -5.74714899e-01f, -2.50229925e-01f, -8.12201560e-01f,
  3.47723305e-01f, -1.40718028e-01f, 3.32070321e-01f, -8.25924128e-02f, -2.28110120e-01f, 2.12212265e-01f, 1.97415784e-01f, 2.77033210e-01f, -4.96132791e-01f, 3.74515615e-02f,
  1.95792675e-01f, -2.85447419e-01f, -1.48758918e-01f, -9.44354758e-02f, -3.47162455e-01f, 1.15273789e-01f, 2.05380227e-02f, 2.52271026e-01f, 2.73189664e-01f, 9.75718126e-02f,
  -4.38953072e-01f, 2.13391125e-01f, 3.47483218e-01f, 4.45427626e-01f, 1.39749199e-01f, -1.87112257e-01f, 5.41376621e-02f, 3.31942201e-01f, -5.01095116e-01f, 5.84016368e-02f,
  -4.12623316e-01f, 4.75884467e-01f, 6.48807228e-01f, 5.31906426e-01f, 1.35822758e-01f, 1.04745522e-01f, 4.31383789e-01f, -1.18430942e-01f, -3.86817843e-01f, 5.07664561e-01f,
  -6.45502925e-01f, -2.14839503e-01f, -3.78859550e-01f, 1.33836195e-01f, -5.69105685e-01f, 2.92997491e-02f, 3.61998111e-01f, -3.78709257e-01f, -4.59598601e-01f, 2.12636635e-01f,
  4.39285040e-02f, -4.88582999e-01f, -2.37344652e-01f, 6.72692478e-01f, -6.08859301e-01f, -4.07216370e-01f, -4.34504390e-01f, 1.52269542e-01f, -6.25490427e-01f, 2.37729698e-01f,
  6.09890819e-01f, 2.46725947e-01f, -2.99382240e-01f, -5.09296834e-01f, -7.09417984e-02f, 8.91723670e-03f, 5.60675897e-02f, 1.01203941e-01f, 1.01938806e-01f, -2.28258938e-01f,
  9.33395252e-02f, 1.72442615e-01f, 2.02029645e-01f, 5.29439040e-02f, 3.07549685e-01f, -1.05751097e-01f, 1.68125048e-01f, 1.34001732e-01f, 9.68600214e-02f, 1.11070521e-01f,
  -7.91045353e-02f, 2.48238698e-01f, -3.65006030e-02f, -3.67482871e-01f, 8.34555402e-02f, 4.16465372e-01f, 2.68404990e-01f, -3.05852462e-02f, -4.07669425e-01f, 2.25222588e-01f,
  -7.73041546e-02f, 5.40654249e-02f, 4.04030859e-01f, -6.71436787e-02f, 3.42551410e-01f, -2.16348499e-01f, -2.69308001e-01f, -1.39977247e-01f, -3.32812399e-01f, 4.16432500e-01f,
  -4.05308977e-02f, 3.14393342e-01f, -7.55396411e-02f, 5.59699655e-01f, 2.26752087e-01f, 3.67447197e-01f, -6.43017590e-01f, -1.57358035e-01f, -6.94969118e-01f, 4.94448215e-01f,
  -1.70694083e-01f, -3.21503937e-01f, 6.37815595e-01f, -4.83148843e-01f, -6.27651632e-01f, -4.42397565e-01f, -5.14679432e-01f, -4.70716357e-01f, -4.91045117e-01f, -5.75457096e-01f,
  -2.95183390e-01f, 6.96054518e-01f, 9.98519808e-02f, -6.38970554e-01f, -1.98609412e-01f, -2.40182579e-01f, -2.86627352e-01f, 4.14092481e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.49838203e-02f, 5.09521849e-02f, -4.63739596e-02f, -1.24285504e-01f, 1.93538874e-01f, 5.47392666e-02f, -1.90692078e-02f, 3.63531783e-02f, -1.44598633e-01f, -5.13982251e-02f,
  3.40946577e-02f, -3.50359231e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    