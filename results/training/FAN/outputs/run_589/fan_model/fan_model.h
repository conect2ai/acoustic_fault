/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.12856972e-01f, 3.19492638e-01f, -9.83311795e-04f, -2.05727190e-01f, 1.91109121e-01f, 5.55918999e-02f, 1.04389861e-01f, -5.11230752e-02f, -5.98999448e-02f, 1.97832331e-01f,
  3.94269079e-01f, 8.66427869e-02f, 4.23521269e-03f, 6.95895925e-02f, -1.94678202e-01f, -1.95786089e-01f, -2.98460811e-01f, -3.26195180e-01f, -2.99246699e-01f, 4.09785472e-02f,
  2.51856565e-01f, 1.19022630e-01f, -2.79225018e-02f, -6.34961426e-02f, 1.18227594e-01f, -4.80998354e-03f, 1.84778735e-01f, 1.35621488e-01f, 1.84673294e-01f, -3.02239675e-02f,
  1.69169933e-01f, -9.17888805e-02f, 2.08592173e-02f, 5.65475635e-02f, 1.60853013e-01f, -9.77332890e-02f, -8.88075978e-02f, -2.65880618e-02f, -3.82430404e-02f, -3.11893295e-03f,
  4.57490794e-02f, 5.00546880e-02f, -6.82015568e-02f, 1.23282231e-01f, -1.11580305e-02f, 7.22754188e-03f, -7.74410367e-02f, -7.79696330e-02f, -1.15828417e-01f, 1.02358937e-01f,
  1.88137606e-01f, 9.76006240e-02f, 9.02861506e-02f, 4.78375889e-02f, 4.71134372e-02f, -1.69324148e-02f, 1.91732034e-01f, -9.01061483e-03f, 3.72433588e-02f, -7.72646591e-02f,
  -1.59185380e-02f, -9.80900228e-02f, -9.68723521e-02f, -4.79482077e-02f, -1.45127147e-01f, -3.11729331e-02f, -4.51215357e-02f, -7.81997293e-02f, -7.21999928e-02f, -6.88712299e-02f,
  -2.61274278e-02f, -3.95160429e-02f, -8.69436190e-02f, -1.24178983e-01f, 1.33136837e-02f, -2.17724331e-02f, -5.19467592e-02f, -9.03090229e-04f, -1.20607495e-01f, -8.96378085e-02f,
  -5.57458214e-02f, 6.44249618e-02f, 3.85945439e-02f, 1.17676044e-02f, -7.89468884e-02f, -1.34399891e-01f, -1.12973899e-02f, 6.97334036e-02f, -5.86944111e-02f, -4.09468375e-02f,
  6.57728761e-02f, -2.47578789e-02f, -1.03869483e-01f, -6.83653280e-02f, -3.40836756e-02f, -3.14079374e-02f, 4.93885484e-03f, -1.59185603e-02f, 1.76693480e-02f, 3.89118791e-02f,
  1.51519421e-02f, -2.28275601e-02f, -8.12762603e-03f, 1.24497339e-01f, -2.41598878e-02f, 2.74458118e-02f, 4.07114401e-02f, -4.73131938e-03f, 3.64645980e-02f, 1.21764898e-01f,
  8.50154087e-02f, -6.72075823e-02f, -7.94525743e-02f, 2.34490819e-03f, -1.06399313e-01f, -1.74246207e-01f, 1.09225065e-01f, 6.55786647e-03f, -2.04934165e-01f, 2.61620432e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.09397376e-01f, 6.81722999e-01f, -5.91717958e-01f, 3.26805085e-01f, 2.58030713e-01f, -2.83159435e-01f, -3.25457424e-01f, -5.11466503e-01f, -1.04760684e-01f, 2.90991366e-01f,
  2.15177387e-01f, 1.30982414e-01f, 5.00190184e-02f, -1.37700826e-01f, -4.57765490e-01f, -6.34855404e-02f, 1.31045029e-01f, -5.06099403e-01f, -7.84184575e-01f, -4.26078469e-01f,
  4.94782835e-01f, 3.18944514e-01f, -1.85660660e-01f, -2.66743302e-01f, 3.78188640e-01f, 1.00983270e-01f, 3.02545913e-02f, 3.47117841e-01f, 2.69923508e-01f, 7.80380487e-01f,
  1.00615643e-01f, 1.47322744e-01f, -4.32392061e-01f, 1.91514179e-01f, 1.44141138e-01f, 1.67433232e-01f, 4.43358123e-02f, -5.41902632e-02f, 1.78019419e-01f, 9.44952667e-02f,
  2.06297383e-01f, 1.54488266e-01f, 1.15284249e-01f, 6.78556412e-02f, -4.49545421e-02f, -1.31011426e-01f, -9.89471152e-02f, -3.92808616e-01f, -3.07501495e-01f, -1.20579816e-01f,
  3.78585041e-01f, 3.44562411e-01f, -3.75651836e-01f, -3.56409788e-01f, -1.36108294e-01f, 1.59354843e-02f, -9.06009153e-02f, 2.14209892e-02f, -3.42943013e-01f, 4.32645887e-01f,
  -8.50707814e-02f, 3.33276205e-02f, 1.23521179e-01f, 6.10015951e-02f, 1.91295624e-01f, -6.11298531e-02f, 1.30159706e-02f, 4.75688018e-02f, -7.04045445e-02f, -3.19581665e-02f,
  -1.19644813e-01f, 4.19490971e-02f, 5.77817485e-02f, 1.02390878e-01f, 1.36666372e-02f, 1.86456278e-01f, 4.61978093e-02f, 1.09172508e-01f, -7.46213198e-02f, 1.58075333e-01f,
  2.51577795e-02f, -1.50269240e-01f, 3.36439796e-02f, -5.27093038e-02f, 1.67067677e-01f, -5.12227751e-02f, 8.89153779e-02f, -8.35886505e-03f, 1.01704421e-02f, 1.85408950e-01f,
  1.42971635e-01f, -2.59556323e-01f, 1.70492664e-01f, 1.48159079e-02f, 1.06516629e-01f, 8.35245326e-02f, 1.06089734e-01f, 3.23552079e-02f, 2.46057123e-01f, -2.54650377e-02f,
  -1.44021541e-01f, -2.27333993e-01f, 1.06050749e-03f, -4.34572883e-02f, -2.85239786e-01f, -1.43311739e-01f, 1.32876262e-01f, -1.53190330e-01f, -1.60682470e-01f, -1.47169651e-02f,
  6.23185970e-02f, 2.99566407e-02f, -2.95268238e-01f, -1.67599872e-01f, 5.92401177e-02f, -1.08807914e-01f, -9.80788320e-02f, -1.57119721e-01f, -3.30262929e-01f, 1.21926472e-01f,
  7.21901774e-01f, -4.22916561e-01f, -1.10400689e+00f, 1.05972603e-01f, -6.76635742e-01f, -7.49045730e-01f, -7.18396246e-01f, 4.17121857e-01f, 3.71583372e-01f, -5.34361064e-01f,
  -3.05128425e-01f, 3.13950062e-01f, -7.86909251e-04f, 1.70014322e-01f, 2.25606963e-01f, -8.12491953e-01f, -7.73731291e-01f, -3.62497568e-01f, 2.08181962e-01f, 4.14706737e-01f,
  8.85635167e-02f, 3.07032138e-01f, 4.95073289e-01f, 3.62730563e-01f, -2.93635130e-01f, -1.79987237e-01f, -5.73067844e-01f, -3.57336342e-01f, -4.92421836e-01f, -9.61002052e-01f,
  -7.67423093e-01f, -3.58201861e-01f, 2.51758575e-01f, 3.71181548e-01f, -3.51462871e-01f, 4.71372940e-02f, -8.62666517e-02f, -1.81541845e-01f, 3.78401056e-02f, -9.95521396e-02f,
  -2.78392553e-01f, -3.24848667e-03f, -4.95045865e-03f, -7.17997923e-02f, 1.53448191e-02f, 9.48806554e-02f, 3.55273392e-03f, -8.35128874e-03f, -3.12585607e-02f, -2.54648626e-01f,
  -4.96531725e-02f, -4.37058330e-01f, -3.43036711e-01f, -1.15015712e-02f, -3.98155190e-02f, -8.26091021e-02f, -2.79650450e-01f, -2.75958747e-01f, -2.62140095e-01f, -2.51159191e-01f,
  1.98343307e-01f, -2.39393145e-01f, 1.70267504e-02f, 7.66714364e-02f, 1.33751348e-01f, -1.22008398e-01f, -9.24439132e-02f, 1.93702290e-03f, 1.17222570e-01f, 2.64448673e-02f,
  1.06734082e-01f, -1.28279775e-01f, -2.06112303e-03f, -1.80106144e-02f, -5.73467314e-02f, -1.18879870e-01f, -1.18146978e-01f, -9.41499509e-03f, 8.14963132e-02f, 1.42994300e-01f,
  -7.49313608e-02f, 3.74633223e-02f, 8.88758898e-02f, 2.22049743e-01f, -3.00554842e-01f, -1.28223836e-01f, -4.34018159e-03f, 1.42986089e-01f, 1.95065707e-01f, -1.04419000e-01f,
  4.99998391e-01f, 1.47436202e-01f, -1.57508403e-01f, 7.89240524e-02f, -2.11138502e-01f, -5.52420169e-02f, -2.51466691e-01f, 1.86697409e-01f, -1.42754868e-01f, -5.35256043e-02f,
  9.93285421e-03f, 9.32859927e-02f, -1.37778863e-01f, 7.31450245e-02f, -6.98455423e-02f, -1.81386806e-02f, 1.36704430e-01f, -1.38056740e-01f, 1.33303255e-01f, 1.28247976e-01f,
  2.41327152e-01f, 8.25439245e-02f, 3.05842698e-01f, 5.13636507e-02f, 2.31510147e-01f, 1.17984265e-01f, -2.76560009e-01f, -1.56519607e-01f, 1.07224025e-01f, 4.68734920e-01f,
  1.14266062e+00f, 1.10713013e-01f, 4.62081045e-01f, 2.13592574e-01f, -4.32147831e-01f, -6.56458318e-01f, -6.89259291e-01f, -3.66305351e-01f, -1.54919937e-01f, 2.73166690e-04f,
  6.47677407e-02f, 1.75397545e-01f, 3.62378091e-01f, 1.86695427e-01f, 1.78844810e-01f, -2.01163083e-01f, -3.18332501e-02f, 6.91492796e-01f, 4.85929579e-01f, 1.70119643e-01f,
  5.11142537e-02f, 2.50176936e-01f, 6.80171430e-01f, 2.78449208e-01f, 5.02882451e-02f, 1.51073977e-01f, 8.49432126e-02f, 1.95234150e-01f, 7.85481408e-02f, 4.19545442e-01f,
  3.17645848e-01f, 4.20147538e-01f, -1.14384122e-01f, -1.16448943e-02f, -6.05857894e-02f, 7.36032501e-02f, -1.05986744e-01f, 7.71352127e-02f, -8.93745646e-02f, -7.20741078e-02f,
  -1.43984124e-01f, -5.56052737e-02f, -9.36435685e-02f, -1.08892232e-01f, -1.64455712e-01f, -7.50884190e-02f, 8.35994408e-02f, 3.49286526e-01f, 9.61192399e-02f, -4.37181927e-02f,
  -4.83884588e-02f, 2.23968476e-02f, -1.38469249e-01f, -3.05919409e-01f, 2.65655499e-02f, 2.43116282e-02f, -1.62607506e-02f, -4.76523638e-02f, -3.62981968e-02f, 1.03252411e-01f,
  7.66035914e-02f, 2.27596208e-01f, 1.07996881e-01f, 9.02095363e-02f, 1.50923088e-01f, 6.93768710e-02f, 5.18183503e-03f, -8.86654332e-02f, 1.44644186e-01f, -4.76139225e-02f,
  7.32372478e-02f, 1.83562394e-02f, 1.73285957e-02f, 2.73264456e-03f, 1.93672180e-01f, -2.14967821e-02f, -1.80578753e-01f, -3.65317017e-02f, 2.82444004e-02f, -6.71928748e-02f,
  1.29384845e-01f, 4.02143970e-02f, 8.81258994e-02f, 8.01787004e-02f, -2.72270273e-02f, 4.11690027e-02f, 2.10932866e-02f, -1.00657023e-01f, 5.21327928e-02f, 1.05100520e-01f,
  -7.26142049e-01f, 9.19343457e-02f, 2.25760520e-01f, 5.46339676e-02f, 2.51583643e-02f, 2.04202794e-02f, 1.13220684e-01f, 9.59278047e-02f, -1.30479068e-01f, 1.87930446e-02f,
  -1.21131554e-01f, 6.69291094e-02f, 4.32726694e-03f, 6.67498484e-02f, -3.92250568e-02f, -1.29872128e-01f, -5.06933331e-02f, 4.55446243e-02f, 6.15955505e-04f, 3.55331507e-03f,
  -2.38093268e-03f, -3.21713150e-01f, -1.87108770e-01f, -2.13924304e-01f, -2.75186896e-01f, -1.37509122e-01f, -1.88377336e-01f, -2.66976595e-01f, -2.50769317e-01f, -3.58460158e-01f,
  -4.55331663e-03f, -4.45739515e-02f, 5.64038992e-01f, -1.89353675e-01f, 6.99565649e-01f, 2.21680924e-01f, -1.69321761e-01f, -2.35559121e-01f, 4.35966998e-02f, -5.03344275e-02f,
  5.70278585e-01f, 3.86323214e-01f, 2.55920172e-01f, 7.23240376e-02f, -2.58162528e-01f, -3.09367090e-01f, -1.13679871e-01f, -7.52880424e-02f, 1.40270412e-01f, 1.99972138e-01f,
  -1.96984693e-01f, -8.72152001e-02f, -5.41467145e-02f, -1.38521627e-01f, -4.40583795e-01f, -2.52240390e-01f, 7.11879646e-03f, 3.67930811e-03f, -6.50798157e-02f, -7.95583785e-01f,
  7.31025040e-02f, 1.35078087e-01f, 4.01444405e-01f, 1.72989354e-01f, 3.00549865e-01f, -3.17180723e-01f, -2.88892776e-01f, -9.87338796e-02f, -8.62953514e-02f, -1.30319804e-01f,
  5.89091890e-02f, 2.67740944e-03f, -1.43755376e-01f, -1.84712827e-01f, 4.54867296e-02f, -2.71163821e-01f, 1.29053876e-01f, -1.18386321e-01f, -3.36683720e-01f, -4.71095778e-02f,
  -6.64452165e-02f, 3.24543089e-01f, 2.47131675e-01f, -6.05519377e-02f, -1.53013095e-01f, 1.12200873e-02f, -1.67173550e-01f, -5.20800889e-01f, -3.06838512e-01f, -1.13299859e+00f,
  -1.95767626e-01f, 2.01823279e-01f, 2.19365716e-01f, 5.64002711e-03f, -8.99124593e-02f, 1.21033061e-02f, 1.50321186e-01f, 2.77772278e-01f, -8.62899795e-02f, -2.28228979e-02f,
  2.81453699e-01f, 1.65494084e-01f, 1.52842328e-01f, -9.21229795e-02f, 8.59342739e-02f, -9.72644910e-02f, 2.40532272e-02f, -7.77192935e-02f, 8.62209871e-02f, -1.14692427e-01f,
  1.08696304e-01f, -1.48371160e-01f, -1.48812547e-01f, -2.50562578e-01f, 1.00096889e-01f, -3.81108630e-03f, -2.27462366e-01f, 7.68071190e-02f, 1.10723451e-01f, -1.46299094e-01f,
  -3.50148499e-01f, 6.18515551e-01f, -2.03214496e-01f, -1.28659219e-01f, 4.05489840e-02f, 5.02493121e-02f, -1.46993458e-01f, 2.35639974e-01f, 1.87811390e-01f, -1.00238867e-01f,
  9.59128812e-02f, 2.54808106e-02f, -1.21240348e-01f, -1.06185965e-01f, 2.97462121e-02f, -1.16568282e-01f, 4.29350920e-02f, -1.79983109e-01f, -1.76920205e-01f, 1.86940227e-02f,
  -1.69606686e-01f, -3.67621273e-01f, -1.08934768e-01f, -3.27787369e-01f, -2.87961334e-01f, -3.08607399e-01f, -3.73350143e-01f, -4.14448619e-01f, -4.10418242e-01f, -1.14076328e+00f,
  3.94179106e-01f, -1.01389217e+00f, 2.66945451e-01f, 5.98692372e-02f, 5.39470136e-01f, 7.87114918e-01f, 1.64057791e-01f, 1.92020193e-01f, 1.75088942e-01f, -2.76087135e-01f,
  -5.53215802e-01f, -5.37547112e-01f, -5.25765121e-01f, -3.75270396e-01f, -2.48793885e-01f, -6.89641982e-02f, 1.00747295e-01f, 9.58763435e-03f, 5.22642076e-01f, 5.78157604e-01f,
  -1.02095723e-01f, -4.17690635e-01f, -2.96997130e-01f, -1.57644868e-01f, -3.17410856e-01f, -1.40545368e-02f, -3.91444653e-01f, -3.33398432e-01f, -1.20416634e-01f, -7.14520633e-01f,
  -8.38826448e-02f, -7.11138994e-02f, 1.02031142e-01f, -2.36839756e-01f, -3.25585395e-01f, -2.74055060e-02f, -8.48496624e-04f, -2.17828885e-01f, -8.36373195e-02f, -5.52257113e-02f,
  -2.15661719e-01f, -1.00043043e-02f, -8.57859477e-02f, 1.99416969e-02f, 7.96881020e-02f, -1.28491223e-01f, -1.67536318e-01f, -2.29392067e-01f, -1.51245058e-01f, -7.80033916e-02f,
  -2.95797855e-01f, 1.31751657e-01f, 1.80143833e-01f, 1.95511356e-01f, 7.83795416e-02f, 1.34560332e-01f, -6.88754916e-02f, -1.11860828e-02f, 1.32218629e-01f, -2.90712029e-01f,
  -5.44489287e-02f, -1.19392639e-02f, 1.74078848e-02f, 3.71424630e-02f, -5.44253970e-03f, -1.42357370e-03f, 3.86134908e-02f, -7.24699497e-02f, 4.38522100e-02f, -1.36973917e-01f,
  -8.43832344e-02f, -9.58870873e-02f, 3.91807705e-02f, -4.16210368e-02f, -2.19762638e-01f, -7.38481525e-03f, 2.03451095e-03f, -1.37005806e-01f, -9.15020108e-02f, 1.13780494e-03f,
  -1.29121065e-01f, 8.06461573e-02f, 1.31123006e-01f, -5.80480248e-02f, 3.69535908e-02f, -1.44167259e-01f, 3.91579419e-02f, -9.29674786e-03f, -4.60619442e-02f, 1.23402730e-01f,
  -3.16045254e-01f, 1.70039088e-01f, -6.30175397e-02f, -1.27440646e-01f, 2.48137373e-03f, -4.36255001e-02f, -2.44990125e-01f, 1.53900897e-02f, 1.00922426e-02f, 1.20850839e-01f,
  -5.17610051e-02f, -1.53826422e-03f, -7.15807751e-02f, 4.56019305e-02f, 1.23669624e-01f, 1.32431909e-01f, -8.73284563e-02f, -9.49066654e-02f, 2.71218251e-02f, -9.21258703e-03f,
  -1.30917922e-01f, 2.59772331e-01f, 2.00881645e-01f, 2.04561576e-01f, 7.40607753e-02f, 3.26666266e-01f, 3.65710668e-02f, 1.51206687e-01f, 2.68037379e-01f, -1.91881396e-02f,
  -1.18442886e-02f, -3.06880236e-01f, 3.50679427e-01f, 4.91644084e-01f, 7.58882821e-01f, 5.58334768e-01f, 5.65898716e-01f, 3.17294836e-01f, 3.98183852e-01f, 3.15595120e-01f,
  -4.69587483e-02f, -3.40652233e-03f, 4.71261851e-02f, 7.25820661e-02f, 1.56810477e-01f, 4.12056953e-01f, 5.41686773e-01f, 8.88289511e-02f, 2.64185399e-01f, 3.90050381e-01f,
  3.17016482e-01f, 1.50885001e-01f, -1.77207306e-01f, 1.28107727e-01f, 6.75010458e-02f, 1.44513100e-01f, 8.03124830e-02f, 1.58397332e-01f, -1.64719261e-02f, -6.58620819e-02f,
  1.67562127e-01f, -3.54964063e-02f, 5.10153025e-02f, -1.53694183e-01f, -9.32017192e-02f, -2.44224221e-01f, 7.77895451e-02f, -2.55230695e-01f, -8.29417259e-02f, 3.98219824e-02f,
  -3.93056124e-02f, -1.03048295e-01f, -7.23734647e-02f, -2.14165047e-01f, -6.99279830e-02f, -1.38735371e-02f, -1.98819324e-01f, 8.31387490e-02f, 1.19921692e-01f, 3.75742428e-02f,
  -8.13057795e-02f, -9.78704169e-03f, 2.23505974e-01f, 9.47531611e-02f, -4.00843844e-03f, 4.68740091e-02f, -1.74434483e-01f, -1.82611540e-01f, -1.08861960e-02f, -6.69083521e-02f,
  3.71455520e-01f, 2.83303186e-02f, -2.20475681e-02f, 3.21769044e-02f, -3.25606875e-02f, -3.34294029e-02f, 9.73870084e-02f, 1.92711338e-01f, 2.53608197e-01f, 4.53316644e-02f,
  3.22409049e-02f, 2.94251233e-01f, 9.44496766e-02f, 7.50369728e-02f, 2.79132798e-02f, -3.71070355e-02f, -8.68617669e-02f, -1.54205605e-01f, -4.23040055e-03f, 1.34211197e-01f,
  1.16131850e-01f, 2.30614580e-02f, -1.97451577e-01f, 6.96401894e-02f, 2.34482605e-02f, 1.33784059e-02f, 1.13515198e-01f, -1.10920072e-01f, -1.02715485e-01f, -7.94869885e-02f,
  1.71374187e-01f, 7.75135309e-02f, 1.15564354e-01f, 4.67372760e-02f, -4.37431596e-02f, -2.48272777e-01f, 9.14195031e-02f, -1.10627361e-01f, -1.73181310e-01f, -3.77623700e-02f,
  -1.57776460e-01f, -2.14593902e-01f, -1.19652808e-01f, -1.51970565e-01f, -3.09183169e-02f, 2.62859301e-03f, -1.12579226e-01f, 2.30456650e-01f, 7.72247761e-02f, -1.78717580e-02f,
  -1.16303384e-01f, 1.98705897e-01f, 2.99585700e-01f, 1.37599319e-01f, -6.59681410e-02f, 1.16517961e-01f, -6.28437102e-02f, -2.02274665e-01f, 7.39821419e-02f, -6.54872879e-02f,
  -1.98968172e-01f, -2.90719181e-01f, -5.33971369e-01f, -9.33650374e-01f, -3.76353800e-01f, 3.96973908e-01f, 3.71595502e-01f, -4.02304269e-02f, -3.38111281e-01f, -1.91322133e-01f,
  1.77882940e-01f, 2.48689383e-01f, -7.92062804e-02f, 3.39838326e-01f, 5.35652339e-01f, 3.59297954e-02f, -2.53309458e-01f, -1.60114020e-02f, 4.41127926e-01f, 4.93343145e-01f,
  2.30163306e-01f, -4.32407230e-01f, -2.10860565e-01f, -8.18710700e-02f, -5.53623855e-01f, -3.75018418e-02f, -6.44020498e-01f, -5.13513565e-01f, 1.58371076e-01f, -5.75038075e-01f,
  -1.79026589e-01f, -3.24395388e-01f, 2.48798311e-01f, 1.80941150e-01f, -2.20098749e-01f, 7.82803819e-02f, -8.97627696e-03f, -5.42066932e-01f, 1.97765511e-02f, -1.28548786e-01f,
  -2.93595314e-01f, -3.42132822e-02f, -2.80552804e-01f, -1.27336726e-01f, -3.00822437e-01f, 5.61666824e-02f, -1.62588805e-01f, -7.68161938e-02f, -8.35819636e-03f, 1.02909850e-02f,
  8.91508237e-02f, 1.09715842e-01f, -2.01733131e-02f, 1.19557716e-01f, 8.49953964e-02f, 7.00286105e-02f, -1.94865204e-02f, 1.16391264e-01f, 2.08749250e-02f, -3.51569772e-01f,
  -1.07042506e-01f, -4.90922248e-04f, 5.61046340e-02f, 1.37993777e-02f, 1.59452721e-01f, -4.43386137e-02f, -1.26880273e-01f, 7.15832636e-02f, -1.85841750e-02f, -2.36552451e-02f,
  -9.36495140e-03f, 1.88385740e-01f, -4.55399677e-02f, 1.07959947e-02f, 2.32903026e-02f, -6.06109537e-02f, 5.35043925e-02f, 3.73131931e-02f, 6.92278845e-04f, 3.26070711e-02f,
  1.07501596e-01f, -6.01442531e-02f, -2.61812478e-01f, -5.27888595e-04f, 1.01121172e-01f, 8.27911869e-03f, 7.90936034e-03f, -8.32813233e-03f, -1.89427108e-01f, 7.65172541e-02f,
  -2.82575786e-01f, 5.35742342e-01f, -2.66539007e-01f, 9.70376879e-02f, -9.37097967e-02f, -6.29195645e-02f, -1.41321048e-01f, 2.11321805e-02f, -3.01039480e-02f, 2.33122595e-02f,
  6.30630627e-02f, 2.11937986e-02f, -2.13555008e-01f, -9.47081484e-03f, -4.25994433e-02f, -1.54701481e-02f, 9.41024423e-02f, 1.71257749e-01f, 1.41082212e-01f, -1.29800066e-01f,
  -6.34105280e-02f, 2.77709275e-01f, 2.36890852e-01f, 9.52734202e-02f, 1.61263645e-02f, 3.44625652e-01f, 1.50794536e-01f, -6.59148768e-02f, 3.86669278e-01f, 1.31074503e-01f,
  -6.24006391e-01f, -8.14585924e-01f, 2.93399483e-01f, -3.04746598e-01f, -1.35709733e-01f, -4.43599969e-01f, -1.06165457e+00f, -5.40021122e-01f, 1.66556656e-01f, -5.24533093e-01f,
  -3.15660954e-01f, 7.58869201e-02f, 3.19628298e-01f, -8.49897563e-02f, -5.37401319e-01f, -7.64733255e-01f, -3.19400221e-01f, -2.62991879e-02f, -1.51871353e-01f, -6.62965775e-01f,
  -5.90843678e-01f, -1.16034091e-01f, 7.08085001e-02f, 6.89815134e-02f, -2.27550659e-02f, 1.95838198e-01f, 3.46834630e-01f, 2.13485748e-01f, -1.62352636e-01f, -1.02047421e-01f,
  -2.35859826e-01f, -2.40643010e-01f, 1.91847131e-01f, 5.22046015e-02f, 1.30983472e-01f, -4.35295627e-02f, -1.96191609e-01f, 2.04824910e-01f, 9.81901586e-03f, -1.04388528e-01f,
  -8.74934345e-02f, -2.01447159e-01f, 1.06420897e-01f, 4.03767005e-02f, -2.76130468e-01f, -2.92902261e-01f, 2.26587236e-01f, 1.34155914e-01f, 1.80718333e-01f, -3.66346180e-01f,
  -3.42249364e-01f, -7.45645687e-02f, -5.78095615e-02f, 1.32784590e-01f, -1.57602970e-02f, 3.45677197e-01f, 2.30839506e-01f, 2.38302931e-01f, 3.15869212e-01f, -1.52684778e-01f,
  -3.28691937e-02f, 1.11312628e-01f, 1.12198338e-01f, 3.07737873e-03f, -2.80997669e-03f, 1.60132900e-01f, 1.56804830e-01f, -2.03773990e-01f, 4.15923540e-03f, -7.41417110e-02f,
  5.01824841e-02f, -9.61926207e-02f, 4.11548689e-02f, -5.75567894e-02f, 1.12050742e-01f, 1.43281957e-02f, -7.60596767e-02f, 2.19769552e-02f, -1.77557603e-03f, 4.24692556e-02f,
  -9.08756256e-02f, 8.43978673e-02f, 1.64745510e-01f, -8.86796638e-02f, -4.76823337e-02f, -4.46375683e-02f, -7.21767321e-02f, 1.51207708e-02f, 5.34109073e-03f, -4.32466306e-02f,
  -9.40693840e-02f, 4.50571984e-01f, -1.83476463e-01f, 3.12751122e-02f, -2.48737782e-01f, 1.20233841e-01f, 1.31023526e-01f, -7.72404894e-02f, 5.52083962e-02f, -2.37780392e-01f,
  -2.91734666e-01f, -2.06413418e-01f, 5.49397059e-02f, 1.03611685e-01f, -3.11813027e-01f, -1.26361400e-01f, -3.17978203e-01f, -1.13610052e-01f, 3.79704945e-02f, -1.39481261e-01f,
  -7.29596242e-02f, -4.67128187e-01f, -5.04092216e-01f, -1.59473494e-01f, -1.47917598e-01f, -1.21726863e-01f, -6.35632798e-02f, -1.82791539e-02f, -1.27078444e-01f, -6.85961068e-01f,
  -8.13537657e-01f, 1.95887104e-01f, -1.04956353e+00f, 2.39608996e-02f, 2.97818720e-01f, -1.26289412e-01f, 1.67399302e-01f, 4.14778739e-02f, 2.88412988e-01f, 3.01763535e-01f,
  3.09171796e-01f, 2.34171495e-01f, -6.12352602e-02f, -1.12707406e-01f, -6.13221765e-01f, 6.14284873e-02f, -1.65600747e-01f, -7.99744010e-01f, -7.52163410e-01f, 3.16229403e-01f,
  6.30152345e-01f, -1.19149342e-01f, -4.85104948e-01f, -9.60758403e-02f, 3.69173318e-01f, -5.88880032e-02f, -3.32461178e-01f, -2.90376604e-01f, -5.83710410e-02f, 7.08557367e-02f,
  -3.94821167e-01f, -4.61610556e-01f, -3.84415574e-02f, -2.99396161e-02f, -5.33339046e-02f, -2.22531274e-01f, -3.04388907e-02f, -3.29914719e-01f, 1.15158767e-01f, -2.66855687e-01f,
  6.23438284e-02f, 5.18449694e-02f, 1.02516912e-01f, -3.90060209e-02f, 1.45954877e-01f, 7.33255148e-02f, -9.12558381e-03f, -1.78025171e-01f, -2.66668260e-01f, -1.64660245e-01f,
  4.53570753e-01f, -3.48514393e-02f, -4.76696342e-01f, -6.99119568e-02f, 2.26637237e-02f, -1.59718573e-01f, -5.34539984e-04f, 1.57422200e-01f, -5.51506221e-01f, -2.95336038e-01f,
  2.23651215e-01f, 6.16143383e-02f, 7.63851926e-02f, -1.52130527e-02f, 2.31142700e-01f, 1.45969182e-01f, 6.36104718e-02f, -3.02737858e-02f, 1.12949952e-01f, -1.33451983e-01f,
  3.36526558e-02f, 1.47450298e-01f, 3.62719484e-02f, 1.39124513e-01f, 2.59976033e-02f, -6.20332845e-02f, -1.35197580e-01f, -3.70804779e-02f, -7.48129934e-02f, -4.82746176e-02f,
  -1.90242693e-01f, 1.39186773e-02f, 1.04260147e-01f, -1.29357442e-01f, -1.51083350e-01f, -1.06854081e-01f, 1.03742994e-01f, -5.04425317e-02f, -2.87105329e-02f, 1.25437483e-01f,
  -1.39243379e-01f, -1.76104054e-01f, 1.98401120e-02f, 6.36828765e-02f, -1.68701187e-01f, 1.12387255e-01f, 9.12034512e-03f, 9.91419074e-04f, -4.43432294e-02f, -3.13198529e-02f,
  8.21317285e-02f, 4.68297154e-02f, -1.79374352e-01f, 4.25946899e-02f, 9.75555275e-03f, 7.25160167e-02f, 2.95708060e-01f, -2.63811834e-02f, 1.33991078e-01f, 2.86201060e-01f,
  -1.79319888e-01f, -1.10408396e-01f, -1.41161144e-01f, 7.67533248e-03f, 1.77917853e-01f, -1.77122533e-01f, -4.03642386e-01f, -2.72121932e-03f, -5.04560053e-01f, -4.02772486e-01f,
  -6.39787018e-01f, 1.05128273e-01f, 6.32351637e-02f, 1.94943845e-01f, 3.29450458e-01f, 2.88031902e-02f, -1.38941646e-01f, -1.95280045e-01f, -1.58227623e-01f, -2.09333256e-01f,
  -2.91792095e-01f, -1.14813410e-01f, -1.18484034e-03f, 1.31124869e-01f, -5.06333187e-02f, 3.99634361e-01f, 6.28732860e-01f, 3.55717897e-01f, 4.67181616e-02f, 1.15897022e-01f,
  2.16937497e-01f, 5.12365103e-02f, -1.77883014e-01f, 1.02690816e-01f, 3.44488114e-01f, 1.48680270e-01f, 1.19757680e-02f, 2.16286719e-01f, 2.54587889e-01f, 7.59030163e-01f,
  -2.10757196e-01f, -1.74781322e-01f, 4.17592898e-02f, -1.39153466e-01f, 2.28023063e-02f, -9.74225178e-02f, -7.75608495e-02f, 6.83949962e-02f, -1.62128378e-02f, 2.64400337e-02f,
  7.51814023e-02f, -1.92013115e-01f, 6.49297610e-02f, -2.87094153e-02f, -1.88129678e-01f, -1.77556425e-01f, 2.01390177e-01f, 1.04185216e-01f, -1.39302403e-01f, -1.01229191e-01f,
  4.07402188e-01f, 1.44095179e-02f, -2.75390387e-01f, -1.91752270e-01f, -2.19164655e-01f, -1.15125909e-01f, -2.24124238e-01f, -1.72604308e-01f, -6.05749249e-01f, -4.63680886e-02f,
  -2.53498942e-01f, 1.81629341e-02f, -1.08696185e-01f, 1.11590318e-01f, -7.49290064e-02f, 7.27494657e-02f, 2.86306411e-01f, 4.32422012e-03f, -7.27748051e-02f, 1.26089066e-01f,
  5.02885282e-02f, -1.48243919e-01f, -3.89654785e-02f, -6.15625866e-02f, -6.25990555e-02f, 6.01229630e-02f, 4.22254875e-02f, 9.01531056e-02f, -1.13157351e-02f, -1.37462467e-01f,
  -1.59529492e-01f, 1.10466763e-01f, -5.67014106e-02f, 2.11270526e-01f, -4.02828716e-02f, -2.42710300e-02f, -1.43963799e-01f, -6.58033714e-02f, -1.54296994e-01f, -1.09551445e-01f,
  -2.90881366e-01f, -2.20445227e-02f, -8.27316046e-02f, -1.76897973e-01f, -7.70922750e-02f, -1.54848590e-01f, -1.02249598e-02f, -7.52048865e-02f, -1.39275312e-01f, -1.63263127e-01f,
  -2.80736685e-01f, -1.47490412e-01f, -2.86402434e-01f, -1.41969353e-01f, -2.86437031e-02f, -2.23541468e-01f, -8.84624720e-02f, 9.47878882e-03f, 9.54526141e-02f, 3.66900265e-02f,
  1.80331573e-01f, -1.97465137e-01f, -3.22957247e-01f, -2.01484933e-01f, -2.36472324e-01f, -3.56500983e-01f, -1.77364096e-01f, -2.82955825e-01f, -6.27440095e-01f, -4.57756311e-01f,
  -1.18276882e+00f, 4.89630878e-01f, 4.03675616e-01f, -7.04516411e-01f, -3.42158914e-01f, 4.66936976e-02f, 8.28017771e-01f, -3.96264531e-02f, -4.80520844e-01f, 4.10146832e-01f,
  8.53922218e-02f, -3.94495994e-01f, -7.42997369e-03f, 5.55641055e-02f, -5.02776019e-02f, 6.33469939e-01f, 1.37684405e-01f, -1.22927099e-01f, -5.31783462e-01f, -3.60659659e-01f,
  1.20755937e-02f, -2.99140871e-01f, -5.18423319e-01f, -3.62637073e-01f, -2.42794584e-02f, -2.76854336e-01f, 3.70567322e-01f, -1.49299651e-01f, 3.88411582e-02f, 6.48532435e-02f,
  4.34644699e-01f, -4.48029429e-01f, 3.73647436e-02f, -3.55942905e-01f, -6.94356672e-03f, -2.26045445e-01f, -6.44463822e-02f, -6.31188676e-02f, -2.08072528e-01f, -1.61762219e-02f,
  -3.29216659e-01f, -2.10946679e-01f, -2.64316261e-01f, -3.41513418e-02f, -2.09105656e-01f, -1.39830694e-01f, -2.84240358e-02f, -1.60982370e-01f, 2.34471131e-02f, 1.01799414e-01f,
  7.56291896e-02f, -2.12101623e-01f, -5.38866743e-02f, 1.17613755e-01f, -1.38206586e-01f, -1.86412275e-01f, 1.85801938e-01f, -2.88670182e-01f, -1.29639179e-01f, 2.57793695e-01f,
  1.23200670e-01f, -9.10976622e-03f, -5.43354265e-02f, 3.82926241e-02f, -1.25969239e-02f, 1.60343833e-02f, 3.94129157e-02f, 5.42814732e-02f, 2.57619657e-02f, -7.16877729e-02f,
  6.81243092e-02f, 1.78929940e-01f, 5.01352213e-02f, 1.34447766e-02f, 1.41481794e-02f, -1.02259666e-01f, -4.36080340e-03f, 9.65917557e-02f, 1.34759462e-02f, -1.34687245e-01f,
  -8.45128596e-02f, -9.87975225e-02f, -2.81105284e-02f, 4.69143651e-02f, 1.49915833e-02f, 3.84739377e-02f, -1.75221525e-02f, -2.25783903e-02f, -3.43091525e-02f, -2.97482852e-02f,
  3.51737827e-01f, 1.14400405e-02f, 1.65627450e-01f, -1.05356887e-01f, -5.12408018e-02f, 7.45877475e-02f, -5.46584837e-02f, 7.14553669e-02f, -4.32021432e-02f, -4.26117294e-02f,
  -2.40246564e-01f, -4.81152013e-02f, -1.73316244e-02f, 1.12029418e-01f, -1.11258924e-01f, -1.13264389e-01f, 1.47972941e-01f, -1.94561835e-02f, 3.15388944e-03f, 1.06633708e-01f,
  1.46975219e-01f, 1.34134367e-01f, 1.72539443e-01f, 1.63722575e-01f, 6.66171759e-02f, 4.77913693e-02f, 3.24940622e-01f, 6.02036081e-02f, 1.83336332e-01f, 7.83418179e-01f,
  9.23180044e-01f, 9.27673101e-01f, 3.26161534e-02f, -4.62955087e-02f, -3.68473269e-02f, 5.29319681e-02f, 8.80370080e-01f, 6.57798409e-01f, -1.41568676e-01f, 8.29370767e-02f,
  -3.30473304e-01f, -8.06365728e-01f, -5.34689844e-01f, -3.66668135e-01f, 1.94573253e-01f, 1.83821902e-01f, 5.15990369e-02f, -3.58824164e-01f, -5.98730862e-01f, -2.25224569e-01f,
  -2.34309867e-01f, 3.22025746e-01f, 3.26065809e-01f, 2.21774057e-02f, 1.38217986e-01f, -2.30007976e-01f, 4.71212268e-01f, 2.37018317e-01f, -1.74483806e-01f, -1.77583903e-01f,
  -4.19159234e-01f, 7.28687644e-01f, -4.27732766e-01f, -2.20889539e-01f, -1.62263736e-01f, -1.36407331e-01f, -1.24050304e-01f, -3.94755714e-02f, -9.19272378e-02f, 8.64061154e-03f,
  -5.96385598e-02f, -2.05375403e-01f, -3.15921962e-01f, -8.10834616e-02f, 1.10535726e-01f, -1.41833812e-01f, 1.73896268e-01f, 1.32334784e-01f, -1.11602761e-01f, -6.78705126e-02f,
  -2.80025363e-01f, -5.23319617e-02f, 2.41780177e-01f, 1.09396502e-02f, -1.30758017e-01f, -1.06568672e-01f, 1.49909347e-01f, -5.72369881e-02f, 4.35628481e-02f, 1.13799289e-01f,
  -9.72961336e-02f, 1.86691493e-01f, 1.19195096e-01f, 1.69641501e-03f, 1.00405544e-01f, -8.01907945e-03f, -6.27339538e-03f, 4.11351658e-02f, -7.40905255e-02f, 1.11126706e-01f,
  -5.21560758e-02f, -3.84789780e-02f, -3.80115174e-02f, 2.39656810e-02f, 1.13863572e-02f, 7.23135620e-02f, -9.58255604e-02f, 2.31958907e-02f, -3.30186682e-03f, 1.58378363e-01f,
  -8.23052675e-02f, 9.47037265e-02f, -3.18713649e-03f, -1.48002177e-01f, -2.21993364e-02f, -5.16363420e-02f, -1.97993115e-01f, -2.13030294e-01f, 5.72587103e-02f, 1.64430767e-01f,
  -3.88834476e-01f, -3.40892724e-03f, -2.74382383e-02f, -2.43623424e-02f, 8.92119855e-02f, 7.31121078e-02f, -2.02399462e-01f, -1.71947933e-03f, -1.06707484e-01f, -2.56980117e-02f,
  -1.64740473e-01f, -7.78412744e-02f, 2.37816572e-02f, 9.77477655e-02f, -1.77382022e-01f, 5.61651736e-02f, 1.03476748e-01f, -7.36534521e-02f, -4.20833863e-02f, 1.37492865e-01f,
  -2.69705220e-03f, 5.21605834e-02f, 9.87082869e-02f, 9.92105976e-02f, -3.19482312e-02f, -2.69778430e-01f, -2.22006273e-02f, -1.37961190e-02f, -7.78285637e-02f, 4.08664942e-01f,
  1.10031343e+00f, 2.63684303e-01f, 4.52798247e-01f, 1.02631435e-01f, -1.26435205e-01f, 2.87557125e-01f, 2.15864152e-01f, 2.61097223e-01f, 6.56622229e-03f, 1.90023854e-01f,
  1.08364522e-01f, 1.48391230e-02f, -3.81892584e-02f, 2.63448134e-02f, 1.23987496e-01f, -2.78123245e-02f, -1.51792079e-01f, 1.65786028e-01f, 2.50812978e-01f, 1.35489315e-01f,
  -1.64269492e-01f, -1.41300350e-01f, 7.56026283e-02f, -1.41837761e-01f, -3.06319326e-01f, -2.01696023e-01f, -4.18956913e-02f, -1.83508024e-02f, -1.44738838e-01f, -1.59664705e-01f,
  2.46981218e-01f, 5.55140615e-01f, -6.09438270e-02f, -1.54172992e-02f, 5.10318065e-03f, 4.27402593e-02f, -4.01773006e-02f, 9.44990548e-04f, -4.34921682e-02f, -8.23571905e-03f,
  -2.34715447e-01f, -1.41600534e-01f, -1.10180043e-01f, 2.09715366e-02f, -9.53429043e-02f, -1.96560323e-02f, 1.49088934e-01f, 2.66950399e-01f, 1.16057023e-01f, 1.37529068e-03f,
  -8.32479894e-02f, 1.29267767e-01f, 1.87256068e-01f, -2.56686565e-03f, 1.12343468e-01f, 8.94860253e-02f, 3.32976654e-02f, 3.59450392e-02f, 1.49335012e-01f, 2.39635527e-01f,
  -4.56277318e-02f, -8.95646140e-02f, 3.19382176e-02f, 2.06015959e-01f, 3.42556015e-02f, -1.32239107e-02f, -4.05903235e-02f, -1.90551236e-01f, -4.82699722e-02f, -1.28890663e-01f,
  -5.88778220e-02f, 1.36160597e-01f, 1.79050475e-01f, 7.73423687e-02f, -7.13413656e-02f, 3.98132429e-02f, 1.23848775e-04f, 1.62280723e-02f, -1.52729392e-01f, -5.17529659e-02f,
  -1.26070887e-01f, -1.22089835e-03f, -1.27960518e-01f, 4.66009527e-02f, 1.39693618e-01f, 1.37720853e-01f, -2.23508272e-02f, -1.22674726e-01f, -1.43564746e-01f, -5.59558161e-04f,
  -1.27227411e-01f, 7.96531886e-02f, -4.78508733e-02f, -1.01890936e-01f, -2.16923840e-02f, -1.33574173e-01f, -1.26664406e-02f, -2.00358927e-02f, -1.51903927e-01f, 1.43895909e-01f,
  -1.27758528e-03f, -6.40989766e-02f, -6.21342100e-02f, -1.35655791e-01f, -1.37382373e-01f, -7.94159696e-02f, 3.22748683e-02f, 1.24976076e-01f, -3.33047956e-02f, -8.88289586e-02f,
  -2.65638143e-01f, 1.48511261e-01f, 5.73860407e-02f, 9.93063860e-03f, 9.20144655e-03f, -6.52635098e-02f, -2.15924662e-02f, 6.59163967e-02f, 5.93973286e-02f, 4.09469493e-02f,
  7.25285172e-01f, 2.09880009e-01f, -5.81771910e-01f, 1.72803059e-01f, -3.16169500e-01f, -2.65544474e-01f, -1.62777789e-02f, 1.76115841e-01f, 1.89263433e-01f, 2.19290897e-01f,
  1.78284392e-01f, 3.97688508e-01f, 4.38525170e-01f, 1.60762429e-01f, 2.23091573e-01f, -1.71237260e-01f, -3.79886180e-01f, -1.58208549e-01f, 8.11868871e-04f, -1.86247408e-01f,
  2.20050965e-03f, 2.43286416e-01f, 1.52444243e-01f, -1.34602308e-01f, -2.42941663e-01f, 1.78559139e-01f, -1.46579012e-01f, -3.31343442e-01f, -3.97672832e-01f, -3.06793720e-01f,
  2.06227422e-01f, -2.88617522e-01f, 6.29439801e-02f, 2.24907007e-02f, -8.43604431e-02f, 5.67914285e-02f, 1.70679241e-02f, -2.38412425e-01f, -1.11125186e-01f, -1.01139292e-01f,
  -1.13684751e-01f, -5.57847545e-02f, -1.63300559e-01f, -1.13414854e-01f, -1.27192914e-01f, -7.95021430e-02f, -1.29554093e-01f, -8.94408301e-02f, -8.12394172e-02f, -1.67535037e-01f,
  -1.92245811e-01f, -2.00142071e-01f, -9.57194045e-02f, 1.94328406e-03f, -5.65406196e-02f, -6.43878356e-02f, -8.97782966e-02f, -1.81321576e-01f, -1.72094047e-01f, 1.23449087e-01f,
  -3.15823197e-01f, 9.83023271e-02f, 2.81553902e-02f, -1.40120657e-02f, 1.17781647e-01f, 7.42253587e-02f, 1.04517505e-01f, 4.74044606e-02f, -3.53349894e-02f, 5.79699650e-02f,
  1.13884978e-01f, 5.28905541e-02f, -1.07003063e-01f, 1.83899805e-01f, 1.33606598e-01f, -1.10807747e-01f, 9.84479673e-03f, -1.38118304e-02f, -1.46360800e-01f, 6.44987002e-02f,
  6.01302758e-02f, -1.05786473e-01f, -1.38514549e-01f, -1.70740917e-01f, -3.02727610e-01f, -1.82392105e-01f, -1.74358919e-01f, -1.77143857e-01f, 7.39604458e-02f, 5.72703071e-02f,
  7.19675183e-01f, -2.64706641e-01f, 3.91563028e-01f, 1.19141601e-01f, -1.10303707e-01f, -4.98188287e-03f, -3.64969373e-02f, -1.32808223e-01f, -4.77128513e-02f, -9.17765051e-02f,
  -1.61444187e-01f, -1.87366959e-02f, 8.49080831e-03f, 2.99539194e-02f, 3.37530337e-02f, 4.07490321e-02f, 5.46605326e-03f, 6.31828010e-02f, -1.22287728e-01f, -1.39807791e-01f,
  -2.51769852e-02f, 2.63630599e-01f, 3.63912940e-01f, 3.41978788e-01f, 1.54369235e-01f, 2.33499214e-01f, 2.11161122e-01f, 1.32438287e-01f, 1.54515713e-01f, 5.17772973e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.85075688e-01f, 6.93990290e-01f, 8.01017165e-01f, 7.76821256e-01f, 8.21369886e-01f, 5.18861115e-01f, 3.58227789e-01f, 7.36347198e-01f, 8.89423668e-01f, 6.58909976e-01f,
  8.48699629e-01f, 9.44841027e-01f, 1.94469392e-01f, 1.06163681e+00f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.86311483e-01f, -4.65989828e-01f, -2.54609197e-01f, -2.83209980e-01f, 2.01992705e-01f, -4.71400954e-02f, -9.65148211e-02f, 1.16734212e-04f, -2.58975446e-01f, 1.81244746e-01f,
  -3.16920429e-01f, -1.98195189e-01f, 3.77656847e-01f, 1.37826800e-01f, 2.20358223e-01f, 7.49131814e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.66606621e-02f, -1.37928665e-01f, -4.95344758e-01f, 8.87017369e-01f, -6.16378300e-02f, 4.45068777e-02f, 5.58647156e-01f, 2.48341486e-01f, 2.24619992e-02f, 2.90077150e-01f,
  2.73522586e-01f, -1.42765060e-01f, -9.19477999e-01f, -2.95796931e-01f, 2.36631826e-01f, 6.25762820e-01f, -2.27437660e-01f, 1.13356662e+00f, 1.57891169e-01f, -4.64616418e-01f,
  4.41116512e-01f, 1.04398417e+00f, 3.50144878e-02f, -3.92662048e-01f, -1.82588736e-03f, 8.36427033e-01f, 2.91775465e-01f, -9.54584330e-02f, 9.36850786e-01f, -8.49803150e-01f,
  -3.96017015e-01f, -1.62680104e-01f, 2.81100750e-01f, -4.74693030e-01f, 3.13314110e-01f, -7.44197547e-01f, 3.54633868e-01f, -2.17561666e-02f, 8.10655534e-01f, 3.00304830e-01f,
  -4.28724468e-01f, -8.25579405e-01f, 1.85780346e-01f, 7.63893068e-01f, -1.79881945e-01f, 1.24092543e+00f, -4.97690821e-03f, -8.71745348e-02f, 4.02583718e-01f, -7.54185438e-01f,
  5.40787458e-01f, 3.42992693e-01f, 8.67286384e-01f, -1.57894120e-01f, -3.72483045e-01f, -6.99129924e-02f, -4.79100347e-01f, 4.56144780e-01f, 6.45482689e-02f, 4.45324153e-01f,
  -2.40432486e-01f, 1.31491601e-01f, 5.27451158e-01f, 6.60519898e-01f, 4.64713544e-01f, -5.07109575e-02f, 5.57960212e-01f, 6.82714581e-01f, 4.16831821e-01f, -5.58142245e-01f,
  -6.00304127e-01f, -3.32228273e-01f, -9.17206556e-02f, 5.54261915e-03f, 7.16611147e-02f, 5.84648609e-01f, 5.81514716e-01f, 1.64906532e-01f, -7.75674701e-01f, 8.49413693e-01f,
  2.42548570e-01f, 8.26800168e-01f, 1.30570388e+00f, 2.85449237e-01f, -6.08499408e-01f, 4.07826900e-01f, -2.29858942e-02f, 1.50169328e-01f, -3.07607055e-01f, -2.55797267e-01f,
  1.51621580e+00f, -3.09302598e-01f, 5.78607261e-01f, 1.09959686e+00f, 2.51858801e-01f, -1.98581874e-01f, 3.26767892e-01f, 6.61429644e-01f, 7.46488452e-01f, -1.35889500e-01f,
  9.25492406e-01f, 5.05808711e-01f, -3.96988899e-01f, 1.49768949e-01f, -6.17857397e-01f, 4.17822033e-01f, -1.33419469e-01f, -5.20848155e-01f, -2.82453984e-01f, 6.07679188e-01f,
  3.29324021e-03f, 3.77737619e-02f, -2.52917260e-01f, 4.73288536e-01f, -2.48939306e-01f, -3.03639799e-01f, 9.87311453e-02f, 4.61471111e-01f, -6.04441583e-01f, 4.17338073e-01f,
  5.58978468e-02f, -7.16610432e-01f, 6.53019428e-01f, -1.84780821e-01f, -2.34153613e-01f, -1.94956422e-01f, 3.47529173e-01f, 9.03369933e-02f, 3.93160321e-02f, -2.13759959e-01f,
  8.11878562e-01f, -1.97590098e-01f, 2.15619653e-01f, -2.29616508e-01f, 3.87001395e-01f, 6.30792677e-01f, 8.83210540e-01f, -3.30955446e-01f, 4.22299564e-01f, 5.28366268e-01f,
  8.29500020e-01f, -2.96768636e-01f, -1.19609192e-01f, 8.65166426e-01f, -3.42198908e-02f, 1.64506942e-01f, 3.58042836e-01f, -1.06100857e-01f, 6.83153868e-01f, 4.11866963e-01f,
  1.80886522e-01f, -3.05842370e-01f, 1.05144107e+00f, -2.03762308e-01f, 2.76147664e-01f, 8.74359310e-01f, 8.91766772e-02f, -2.53203541e-01f, -2.54984140e-01f, -9.86039340e-01f,
  -1.11188665e-01f, -1.06770873e-01f, -6.37475252e-01f, 8.81776690e-01f, 9.02233243e-01f, 6.25637770e-01f, 7.18489051e-01f, 3.46192792e-02f, 1.18596923e+00f, 6.49896979e-01f,
  -1.36827081e-02f, -2.58261710e-02f, -6.87492967e-01f, -8.50476563e-01f, 2.82274961e-01f, -7.23923370e-02f, -8.55430216e-02f, 2.33360842e-01f, -1.20902091e-01f, -6.95280015e-01f,
  -6.66574776e-01f, 1.92222759e-01f, 8.61278415e-01f, 6.47318900e-01f, -2.49139801e-01f, 6.28473580e-01f, 2.21704811e-01f, 5.39571404e-01f, 9.71971273e-01f, 4.27513093e-01f,
  4.39038835e-02f, -5.23084700e-01f, 8.74679461e-02f, 1.01066124e+00f, 5.77067792e-01f, -4.42929529e-02f, -2.83604532e-01f, 6.07043386e-01f, 1.46497965e-01f, 1.63286746e-01f,
  -3.50795776e-01f, 6.35855258e-01f, 8.16598535e-01f, 6.13170207e-01f, -7.06312433e-02f, -6.20021880e-01f, -9.52413321e-01f, -6.14924371e-01f, 2.60895878e-01f, -5.26956320e-01f,
  8.57465789e-02f, 6.78543448e-01f, -2.14911208e-01f, 6.82568312e-01f, 7.76053011e-01f, 4.25589740e-01f, 4.87947494e-01f, 1.47289574e-01f, -2.39270534e-02f, -3.55874807e-01f,
  -2.17544168e-01f, 6.70765758e-01f, -1.30990729e-01f, -2.45701686e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -2.19802067e-01f, 6.49112463e-01f, 3.84401709e-01f, 7.55478859e-01f, 6.86922133e-01f, 1.35029212e-01f, 5.06026506e-01f, -1.32965744e-01f, 7.20244786e-03f, -1.59766510e-01f,
  -8.67876131e-03f, 2.61385679e-01f, 4.95189041e-01f, 7.20647454e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -8.45694661e-01f, 4.24414843e-01f, 5.83414257e-01f, 4.06488106e-02f, -6.07916713e-01f, -3.38765204e-01f, -9.33375806e-02f, 3.87084842e-01f, -6.73996866e-01f, 1.43873855e-01f,
  -1.10245764e+00f, -1.08893104e-01f, 5.72753668e-01f, -6.11052990e-01f, 3.92812900e-02f, -1.80531248e-01f, 1.10510491e-01f, 2.59583563e-01f, 2.93653011e-01f, -8.08795571e-01f,
  -2.59956986e-01f, -4.81192907e-03f, -1.00280486e-01f, -9.72181618e-01f, 2.72244811e-01f, 3.81348014e-01f, 1.86176807e-01f, -5.43785274e-01f, 7.81104684e-01f, -6.05811119e-01f,
  -1.37934589e+00f, 2.64237374e-01f, 5.46139121e-01f, 6.17395401e-01f, -2.23999277e-01f, 4.71266627e-01f, -5.73130846e-01f, 4.82745916e-01f, 2.74540186e-01f, -1.08192587e+00f,
  -1.25793695e-01f, 8.76470357e-02f, -1.04182553e+00f, 1.99116185e-01f, 3.36892068e-01f, 1.26274884e-01f, -8.79916251e-02f, -7.93527514e-02f, -1.59019530e-01f, -3.37336212e-01f,
  -1.06134450e+00f, 2.52561122e-01f, -7.12849677e-01f, -1.43164253e+00f, -5.78388333e-01f, 3.71773422e-01f, -8.74424458e-01f, -7.55827308e-01f, 1.51625410e-01f, 7.40815222e-01f,
  1.13656960e-01f, 3.53902161e-01f, 5.31173684e-02f, 1.22338913e-01f, -3.94591205e-02f, -1.50881422e+00f, 9.66481566e-02f, 5.06636143e-01f, -3.40226322e-01f, -9.58803445e-02f,
  -7.46085271e-02f, 2.64527887e-01f, 3.78392249e-01f, 9.93150622e-02f, -5.95710337e-01f, -1.42152762e+00f, -3.54615062e-01f, 5.05244255e-01f, 5.10688007e-01f, -8.97449926e-02f,
  1.58263713e-01f, -4.60433215e-01f, -4.21216749e-02f, -8.63431036e-01f, -1.34448484e-01f, 1.33173719e-01f, 6.72824323e-01f, 4.68141079e-01f, -2.69847214e-01f, 2.23629236e-01f,
  2.20032156e-01f, -6.72012448e-01f, -5.07932842e-01f, -7.61518121e-01f, -3.71001542e-01f, 2.70226598e-01f, -4.77095284e-02f, 9.68213260e-01f, -3.01414043e-01f, -7.46031523e-01f,
  5.28846323e-01f, 5.74392736e-01f, 2.97728419e-01f, -3.97909373e-01f, 2.32719287e-01f, -5.35254896e-01f, -1.47687808e-01f, 4.43333864e-01f, -1.45489648e-01f, -9.74088728e-01f,
  -1.32663262e+00f, -1.06216812e+00f, -7.46723950e-01f, -2.29176164e-01f, 1.20958157e-01f, -9.11642134e-01f, 1.80647895e-01f, -2.50698358e-01f, -9.90832821e-02f, -3.13855195e-03f,
  -6.49502695e-01f, 2.16284961e-01f, 4.13155735e-01f, 2.82808453e-01f, -8.39643180e-01f, 3.78660381e-01f, 6.74450755e-01f, -3.73554230e-01f, 5.10431945e-01f, 2.27868021e-01f,
  1.96221933e-01f, -9.86850381e-01f, 6.45694494e-01f, -7.61391938e-01f, -9.35164332e-01f, -6.00506961e-01f, -4.00918961e-01f, -7.92949438e-01f, 4.07679468e-01f, -4.17841762e-01f,
  -6.35442808e-02f, 5.25668979e-01f, -1.08392611e-01f, 4.65075940e-01f, -4.88084964e-02f, -3.72369766e-01f, -2.22895458e-01f, 2.62632757e-01f, -4.18138623e-01f, 3.91474038e-01f,
  -5.85793592e-02f, -4.72162329e-02f, 2.75617540e-01f, -7.50425085e-02f, 2.56432235e-01f, 5.31384706e-01f, -4.92039293e-01f, -1.08554173e+00f, 4.77892905e-01f, -9.74453092e-01f,
  4.48734462e-02f, 8.76091719e-01f, -8.78517151e-01f, 7.72346795e-01f, -7.40534842e-01f, -7.32893109e-01f, 6.60016298e-01f, -1.47975892e-01f, -1.11490119e+00f, -6.46088541e-01f,
  7.86315620e-01f, -9.92925704e-01f, -6.38660371e-01f, 5.05098142e-02f, -4.73512292e-01f, -5.53047895e-01f, 7.13773489e-01f, -7.82999694e-02f, -8.59622717e-01f, -5.05600035e-01f,
  2.83686012e-01f, -1.63196728e-01f, -1.42728078e+00f, 6.53263748e-01f, 8.29666674e-01f, -5.55240735e-02f, -7.62060821e-01f, -1.86380595e-01f, -6.59000099e-01f, 1.35554522e-01f,
  -1.07193708e+00f, 4.68876183e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.12593919e-01f, -1.02448516e-01f, 3.65069211e-01f, -3.76555383e-01f, 1.77741528e-01f, 3.69415343e-01f, 2.87673354e-01f, -4.32341963e-01f, -1.35164812e-01f, -2.43800864e-01f,
  1.45082653e-01f, 3.60172212e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    