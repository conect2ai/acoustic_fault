/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.28400636e-01f, -3.28836769e-01f, -8.55731443e-02f, 4.08926785e-01f, 5.80716040e-03f, -3.07227314e-01f, -3.23162854e-01f, -1.95543200e-01f, 1.36232510e-01f, -3.71442437e-02f,
  -4.12347429e-02f, 1.17844500e-01f, -1.53370248e-03f, -1.25791237e-01f, -1.05714105e-01f, -2.37115040e-01f, -1.59818113e-01f, 1.86651886e-01f, 4.80830036e-02f, -1.83694601e-01f,
  -2.38522723e-01f, 1.85017630e-01f, 2.54899085e-01f, 8.35291445e-02f, -1.76724806e-01f, -8.56952146e-02f, -1.23508342e-01f, 2.18140017e-02f, -2.27934897e-01f, -3.39651763e-01f,
  5.72977737e-02f, 4.06413786e-02f, -3.79863270e-02f, -2.34109890e-02f, 3.22356187e-02f, 4.96243089e-02f, 4.36528847e-02f, 2.11678389e-02f, 4.78999428e-02f, -3.93907875e-02f,
  6.91692857e-03f, 2.69157626e-02f, 5.58242537e-02f, -1.04744673e-01f, 2.71681547e-02f, -7.26295859e-02f, 3.14251259e-02f, -3.76814455e-02f, -3.96964028e-02f, -5.51568381e-02f,
  -1.18019111e-01f, -5.69849217e-04f, 1.74432918e-01f, -6.52045161e-02f, -1.40839681e-01f, 1.12255014e-01f, -1.11709177e-01f, -7.85644278e-02f, 1.56784356e-02f, -1.19354241e-01f,
  3.76874171e-02f, 4.48715389e-02f, 4.28018495e-02f, 2.64367834e-02f, 2.25478541e-02f, 4.57333848e-02f, 6.84302207e-03f, -3.41701098e-02f, -6.18002042e-02f, 4.53969315e-02f,
  -3.65730487e-02f, 9.28643420e-02f, 1.21450685e-02f, 9.84957367e-02f, -5.26867062e-02f, 2.86256545e-03f, 5.96873499e-02f, 2.33322755e-02f, 4.44905199e-02f, 9.01058689e-02f,
  2.77044959e-02f, -4.40873690e-02f, 3.89583893e-02f, -5.46415858e-02f, -5.53268678e-02f, -4.37786095e-02f, -1.21594872e-02f, -7.50045478e-02f, 7.35037727e-03f, 5.72693273e-02f,
  2.46307433e-01f, 1.64110079e-01f, -4.55728695e-02f, -1.20323800e-01f, -1.30611613e-01f, -7.79455677e-02f, -6.33280799e-02f, -1.15826212e-01f, -5.06392680e-02f, -3.94613557e-02f,
  -6.83159009e-02f, -6.56743646e-02f, -5.49130980e-03f, -1.24249130e-01f, -2.31743939e-02f, -7.86503851e-02f, -5.17661795e-02f, 4.77865376e-02f, -9.09339488e-02f, -7.57595599e-02f,
  -7.35031441e-02f, -1.88906863e-02f, 2.29776818e-02f, -1.14099838e-01f, -9.46984217e-02f, -2.14794539e-02f, -8.73489529e-02f, -8.38378444e-02f, 3.15556824e-02f, -6.09778911e-02f,
  -3.95759434e-01f, -5.57452559e-01f, 6.06531799e-01f, -4.06074345e-01f, -3.62283945e-01f, 3.86549463e-03f, -2.79973119e-01f, 2.01809034e-02f, -1.05724111e-01f, -2.31155008e-01f,
  -2.62262553e-01f, -8.13147724e-02f, 8.70037153e-02f, 1.57986641e-01f, 1.96165159e-01f, 2.30063349e-02f, 7.87066445e-02f, 4.12299871e-01f, 4.32050377e-01f, -4.90410067e-02f,
  -3.18473965e-01f, -2.53146172e-01f, -1.02796793e-01f, 6.06052913e-02f, -1.34694446e-02f, 7.40401680e-03f, 4.66550253e-02f, -6.01502741e-03f, 1.76681429e-02f, -4.08739187e-02f,
  3.50033849e-01f, 5.67611903e-02f, 1.94997694e-02f, -1.09812543e-01f, -3.71841192e-02f, 3.90653871e-02f, -6.29620031e-02f, 4.81290892e-02f, 4.28433567e-02f, 1.99032184e-02f,
  -8.65110233e-02f, -3.92341539e-02f, -1.05906472e-01f, -6.12230785e-02f, -6.40846565e-02f, 1.10231027e-01f, 6.69449642e-02f, 9.80661064e-02f, 3.99329849e-02f, 3.71753238e-02f,
  -1.74792275e-01f, -1.72931671e-01f, -1.98074942e-03f, 1.02487616e-01f, 1.59680963e-01f, -4.32815887e-02f, 1.49138020e-02f, 1.10400312e-01f, 2.13435814e-01f, 2.45854296e-02f,
  -1.21863233e-02f, 5.55603765e-02f, 3.04588582e-02f, -5.39601669e-02f, -6.20078146e-02f, 6.15630001e-02f, 1.86436772e-02f, 1.87227572e-03f, 3.82396393e-02f, -1.68151371e-02f,
  -3.54799591e-02f, -6.87894970e-02f, 5.49380407e-02f, 2.33615376e-02f, 3.49821784e-02f, -3.47129889e-02f, -5.98542355e-02f, -2.78252605e-02f, 1.20343929e-02f, -4.22374159e-03f,
  8.99979100e-03f, 3.94317061e-02f, -1.36420177e-02f, 6.55516014e-02f, 5.56035861e-02f, 1.05648726e-01f, 9.09774564e-03f, 6.00352474e-02f, -3.52134258e-02f, -7.59912133e-02f,
  -2.51812696e-01f, 1.06290523e-02f, -6.41987547e-02f, 6.13932498e-02f, -3.34365219e-02f, 6.32072911e-02f, -4.98277880e-02f, 4.90715764e-02f, -2.65686195e-02f, 5.04203215e-02f,
  6.37820065e-02f, -6.47546425e-02f, -4.46638688e-02f, 8.33883211e-02f, 3.47654745e-02f, 2.27489080e-02f, -1.30863771e-01f, -6.54409826e-02f, 8.38899985e-02f, 1.19569011e-01f,
  -5.25873713e-02f, -5.60012721e-02f, -1.72514856e-01f, -6.74944371e-02f, -5.26002757e-02f, -8.11077282e-02f, 6.52994663e-02f, -1.65058151e-02f, -3.62005993e-03f, -3.16865087e-01f,
  4.74678725e-01f, 3.86621296e-01f, 3.71926606e-01f, 2.12032869e-01f, -3.71782780e-01f, -2.18930077e-02f, 3.81629407e-01f, 2.14957923e-01f, -5.00407368e-02f, 3.09814155e-01f,
  -1.77598625e-01f, -3.23783189e-01f, -1.14133768e-01f, -1.11918449e-01f, 1.63077235e-01f, 3.87347132e-01f, 2.48638183e-01f, 6.07081316e-02f, -1.59955680e-01f, -2.44067207e-01f,
  -3.32798034e-01f, -1.41754314e-01f, -2.01707706e-03f, 1.09591514e-01f, 1.68632716e-01f, -2.06181958e-01f, 2.86589354e-01f, -4.20825593e-02f, -7.93299004e-02f, 5.75697310e-02f,
  8.01270306e-02f, 4.01468158e-01f, -3.96631025e-02f, -1.82640433e-01f, -2.62737405e-02f, 1.40740931e-01f, 1.51038542e-01f, 1.42066434e-01f, 4.45765927e-02f, 9.41756666e-02f,
  5.00895223e-03f, 2.84071248e-02f, -2.84457300e-02f, -5.57149877e-04f, 3.54987048e-02f, 1.01181485e-01f, 2.04088926e-01f, 2.57448554e-01f, 1.15922287e-01f, 7.01186061e-02f,
  -1.76877171e-01f, -1.54607788e-01f, 1.78951100e-01f, 1.58684641e-01f, 1.95754275e-01f, -1.60396516e-01f, 2.22422719e-01f, 2.03615069e-01f, 9.04113725e-02f, 3.76104236e-01f,
  -1.54477999e-01f, -3.28996442e-02f, -2.17952877e-02f, 4.96886559e-02f, -2.15251539e-02f, -5.73672503e-02f, -8.45677126e-03f, -4.80047986e-02f, -7.36763179e-02f, 1.20731713e-02f,
  -7.90528283e-02f, 8.93353485e-03f, -1.12429485e-01f, 5.95422499e-02f, -8.78695771e-02f, 4.50954959e-02f, -4.89348918e-02f, 2.99071129e-02f, -1.21723518e-01f, -6.59975260e-02f,
  -4.30439636e-02f, -5.60685806e-02f, -4.03789245e-02f, -7.14615509e-02f, -4.44382690e-02f, 1.76411737e-02f, 2.43633166e-02f, -4.05401066e-02f, -1.72374751e-02f, 1.38086248e-02f,
  4.30462286e-02f, -1.91110358e-01f, 1.40075356e-01f, 1.61118522e-01f, 7.90539682e-02f, 5.64475358e-02f, -1.44696767e-02f, 2.30241613e-03f, 4.05921936e-02f, 1.65101618e-01f,
  2.97662951e-02f, 1.53266653e-01f, 8.34457278e-02f, 5.74855804e-02f, 5.67737706e-02f, 1.16731204e-01f, 2.85515934e-02f, -4.67983959e-03f, 4.15073372e-02f, 9.67491511e-03f,
  1.35123312e-01f, 6.22211359e-02f, 1.37722835e-01f, 1.38104871e-01f, 5.98395690e-02f, 1.42690204e-02f, 1.94795042e-01f, 9.59342197e-02f, 1.50414079e-01f, 4.04338300e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.34226465e+00f, 5.62065721e-01f, 4.14766401e-01f, 2.21631438e-01f, -4.65022355e-01f, -1.49291558e-02f, 2.46932179e-01f, 2.69198358e-01f, 5.63390404e-02f, 1.48457691e-01f,
  -8.62345919e-02f, 7.89635926e-02f, 6.03676774e-02f, 1.36907384e-01f, 2.47048289e-01f, 2.85925895e-01f, 1.38120934e-01f, 3.27620715e-01f, 1.47043630e-01f, 5.45941517e-02f,
  -1.61910877e-01f, -1.79386988e-01f, 1.67970620e-02f, 1.22989960e-01f, 1.03485562e-01f, -1.06059693e-01f, 1.59588587e-02f, -1.56535616e-03f, -4.00734171e-02f, 3.66165906e-01f,
  1.57092646e-01f, 6.78851128e-01f, -1.50343642e-01f, -2.73478657e-01f, -2.90174067e-01f, 9.91684645e-02f, -3.29279527e-02f, -8.25662762e-02f, -5.42978048e-02f, -7.31885657e-02f,
  -2.41240695e-01f, 2.57225875e-02f, -6.02191649e-02f, -8.60431977e-03f, -6.87572137e-02f, -5.63627295e-02f, 1.62321284e-01f, 2.71612853e-01f, 7.15017319e-02f, 2.85843369e-02f,
  -7.61268958e-02f, -2.60255098e-01f, -2.70698488e-01f, 3.35587710e-02f, 1.67859465e-01f, -7.00244978e-02f, 5.99737428e-02f, 1.94344252e-01f, 6.75046518e-02f, 3.94154668e-01f,
  -2.87534832e-03f, 1.60077050e-01f, 1.27912104e-01f, 1.91489547e-01f, 2.21734703e-01f, 3.64855044e-02f, 1.00888655e-01f, -1.24328889e-01f, -3.53649422e-03f, 5.10567613e-02f,
  4.77432199e-02f, 1.70953751e-01f, -1.27459168e-01f, 6.28122641e-03f, -2.61974731e-03f, -1.02035098e-01f, -4.07696068e-02f, 4.60691750e-02f, -2.62701213e-01f, -1.41148224e-01f,
  4.86070998e-02f, 1.37667045e-01f, 3.10518243e-03f, 2.25042716e-01f, -8.15162249e-03f, 7.12361336e-02f, -5.58846518e-02f, -4.15221900e-02f, -1.10229410e-01f, -9.75065231e-02f,
  -7.68611908e-01f, -2.42414683e-01f, 2.74094284e-01f, 1.66235372e-01f, -1.25347123e-01f, -4.54052053e-02f, 8.80308524e-02f, -1.50774568e-01f, -2.27285385e-01f, 2.00243667e-01f,
  -1.38043597e-01f, 1.09859236e-01f, -4.77437302e-02f, 3.74441072e-02f, -2.89533082e-02f, -2.50194252e-01f, -1.42991692e-01f, -4.80145216e-02f, -1.23280913e-01f, -3.08978856e-02f,
  -1.59008637e-01f, -3.12796712e-01f, -3.96639496e-01f, -1.03581794e-01f, -1.49000674e-01f, -3.43820184e-01f, -1.28682762e-01f, -8.16876143e-02f, -8.74667913e-02f, -4.65553515e-02f,
  1.02747786e+00f, -4.90246892e-01f, -1.03894222e+00f, -5.40831089e-01f, -6.90435410e-01f, -3.32140982e-01f, -3.33754331e-01f, 1.14231236e-01f, -2.03944832e-01f, -3.84511232e-01f,
  3.03534418e-01f, 9.14373577e-01f, 6.96868718e-01f, 5.03849268e-01f, 6.10967517e-01f, -4.99195606e-01f, -6.85260415e-01f, 2.56279707e-01f, 6.33362293e-01f, 1.98404521e-01f,
  4.13739718e-02f, -3.83744761e-02f, 4.69826639e-01f, 1.43813908e-01f, -4.14725393e-01f, 8.79910216e-02f, -4.71295267e-01f, -3.44714046e-01f, -5.49511835e-02f, -8.60312521e-01f,
  -2.21966580e-02f, 9.48450714e-02f, 2.57733822e-01f, 2.66167670e-01f, -1.48628429e-01f, 5.72274104e-02f, 9.48038325e-02f, 7.12018088e-02f, 2.66963895e-02f, -1.00540474e-01f,
  -8.92353132e-02f, 6.66553229e-02f, -6.41387254e-02f, -5.34937019e-03f, -2.04541743e-01f, -8.71754810e-02f, 8.63614725e-04f, 1.61430258e-02f, -1.01352103e-01f, -1.91408247e-01f,
  -4.23061810e-02f, 7.13379011e-02f, -1.41437147e-02f, 2.03406155e-01f, 1.54042244e-01f, 1.16655834e-01f, 7.27900714e-02f, 9.41054374e-02f, 5.18051572e-02f, -2.60287407e-03f,
  2.72585731e-02f, -6.43001720e-02f, 8.67651254e-02f, 6.00219704e-02f, 1.74611390e-01f, -2.70523503e-02f, -5.43523813e-03f, 3.69140953e-02f, 7.20888302e-02f, 7.42057478e-03f,
  -6.97310269e-02f, 1.34470584e-02f, 9.83998030e-02f, -6.91511557e-02f, -9.44310278e-02f, -4.48680855e-02f, -5.82508594e-02f, 1.30013779e-01f, 1.02699965e-01f, -6.49781106e-03f,
  1.52350768e-01f, -5.11293598e-02f, -6.28383756e-02f, -2.28522085e-02f, -7.02904984e-02f, -2.45107021e-02f, 7.15364441e-02f, 1.54677495e-01f, -5.67794181e-02f, -2.39119008e-01f,
  3.93605143e-01f, 3.55065972e-01f, 7.12012649e-02f, 1.06150895e-01f, -2.72312909e-01f, -2.00415894e-01f, 2.98691429e-02f, -8.57210308e-02f, -1.54849514e-01f, -8.16182271e-02f,
  -8.76723453e-02f, 1.76649198e-01f, -4.92959619e-02f, 5.19382171e-02f, -7.25960806e-02f, 1.00227252e-01f, 2.32652426e-01f, 8.60249549e-02f, -1.28439791e-03f, -3.32591265e-01f,
  -1.30740106e-01f, 2.58640163e-02f, 2.18807310e-01f, 1.62443057e-01f, 3.73714161e-03f, 1.09496474e-01f, 8.13562237e-03f, -2.15378553e-02f, 4.06577364e-02f, -9.66876224e-02f,
  1.14068782e+00f, 8.31368804e-01f, 5.86390555e-01f, 9.74303707e-02f, -1.94551662e-01f, -3.10584038e-01f, -1.88985482e-01f, -1.15266278e-01f, -1.43757015e-01f, -1.69182047e-02f,
  -1.46231651e-01f, -3.31994921e-01f, -1.87825799e-01f, -2.73062021e-01f, -1.41062126e-01f, -2.47015096e-02f, 1.25220418e-01f, 9.77261215e-02f, -3.46203268e-01f, -5.56308150e-01f,
  -5.46087563e-01f, 2.72343516e-01f, 4.51281339e-01f, -1.86097827e-02f, 2.58128196e-01f, -2.66480148e-01f, 3.74966443e-01f, 4.81935859e-01f, 1.00500718e-01f, 3.71686012e-01f,
  1.72230184e-01f, 7.78945208e-01f, -9.62923527e-01f, -8.53779241e-02f, 4.00717318e-01f, -1.33659586e-01f, -2.32866362e-01f, 3.26089174e-01f, 9.81385559e-02f, 2.47679427e-02f,
  1.31257698e-01f, -7.31436387e-02f, 3.30346346e-01f, -1.50813594e-01f, 8.68984461e-02f, -1.69580191e-01f, 2.35586599e-01f, 1.19800583e-01f, -1.11966141e-01f, -4.64588404e-02f,
  -3.12765568e-01f, 2.18871176e-01f, 3.95774424e-01f, -1.26956880e-01f, 1.20658286e-01f, -1.62053853e-01f, 2.75234729e-01f, 7.33114257e-02f, -8.22596774e-02f, 9.65879336e-02f,
  -3.69747996e-01f, -3.83935273e-02f, 8.82108416e-03f, 1.51366321e-02f, -1.97366476e-01f, -4.18841168e-02f, 8.14462602e-02f, -1.10310249e-01f, -1.41047448e-01f, 2.44587630e-01f,
  -1.12366201e-02f, -7.21838176e-02f, 1.29788313e-02f, -4.22806405e-02f, -2.97412723e-01f, 1.86150089e-01f, 9.71926842e-03f, -4.11641896e-02f, 2.49908529e-02f, 5.79072610e-02f,
  -6.33804351e-02f, 1.09353125e-01f, 2.32908100e-01f, -3.93230654e-02f, -9.67827886e-02f, -5.81957884e-02f, -1.34947971e-01f, -9.37962905e-02f, 1.88759193e-02f, 1.11903042e-01f,
  -2.02865228e-01f, -4.10920709e-01f, -3.62733155e-01f, 4.51997668e-02f, 2.60909826e-01f, 1.38899997e-01f, -1.28684416e-02f, 2.05110069e-02f, 2.95391709e-01f, 2.95423344e-02f,
  -4.89168279e-02f, -9.20416489e-02f, 3.67596895e-01f, -1.33753523e-01f, -2.25016296e-01f, -1.64431080e-01f, -1.46539912e-01f, -3.23475935e-02f, -1.98092788e-01f, 1.67066678e-01f,
  -4.37561572e-02f, -3.22694123e-01f, -4.72846597e-01f, -2.96284109e-01f, -2.92818129e-01f, -6.43614590e-01f, -2.46521965e-01f, -2.32558265e-01f, -4.18084055e-01f, -4.80061710e-01f,
  -9.74952132e-02f, 2.05398374e-03f, 1.81695551e-01f, 3.03646382e-02f, 7.19950020e-01f, -2.68859327e-01f, -1.13212097e+00f, -9.26110148e-01f, 7.03589246e-02f, 2.88756102e-01f,
  8.25253844e-01f, 5.75827658e-01f, 1.65666163e-01f, -2.76993662e-01f, -1.13309014e+00f, -4.99564290e-01f, -5.14724433e-01f, -9.11939502e-01f, -1.05507934e+00f, -6.04812086e-01f,
  -2.17110127e-01f, -4.61432964e-01f, -7.64104128e-01f, -4.25890058e-01f, 7.80144930e-01f, 2.46892735e-01f, 6.30938113e-01f, 5.79570293e-01f, 6.53120875e-01f, 1.06422484e+00f,
  6.88805223e-01f, 5.35288870e-01f, -3.99803445e-02f, 3.78690898e-01f, 1.92002565e-01f, -1.77521378e-01f, -9.87394601e-02f, -9.91438422e-03f, 7.34124929e-02f, -7.26804659e-02f,
  5.94473362e-01f, 2.97456563e-01f, 4.91751470e-02f, 1.44424960e-01f, -3.06924164e-01f, -2.85873771e-01f, -2.69735336e-01f, -6.80794179e-01f, -4.41060752e-01f, -1.05547592e-01f,
  3.95131648e-01f, 1.45290613e-01f, -6.93352893e-02f, -1.71114877e-01f, -3.49955171e-01f, 1.03335634e-01f, 1.97258979e-01f, 2.05244839e-01f, -2.17668355e-01f, 3.96171689e-01f,
  -6.66501299e-02f, 8.38765278e-02f, 1.17678657e-01f, 1.57901779e-01f, 1.96309667e-02f, 2.04520956e-01f, 4.25689223e-06f, 1.02220632e-01f, -1.00933805e-01f, -9.25760120e-02f,
  -4.15314995e-02f, 7.89251402e-02f, -3.45991515e-02f, -1.23282529e-01f, 1.14441879e-01f, 5.81893101e-02f, 1.24365546e-01f, -3.11179191e-01f, -5.99235371e-02f, 9.53572318e-02f,
  -1.29819736e-01f, 9.22196507e-02f, 2.86373407e-01f, -2.13374898e-01f, 2.46234074e-01f, -3.94066535e-02f, 1.86478153e-01f, 8.60496610e-02f, -6.85875043e-02f, 1.79183736e-01f,
  -1.81988299e-01f, -1.22179516e-01f, 3.32793146e-01f, -9.24779698e-02f, 1.04200549e-01f, 1.36821523e-01f, 3.34264129e-01f, -9.42377076e-02f, 2.13798568e-01f, -1.90851018e-01f,
  -2.99677312e-01f, -9.21286792e-02f, 7.18417170e-04f, 9.32271406e-02f, -3.32123339e-01f, 5.31588532e-02f, 5.94842769e-02f, 7.82320946e-02f, -2.84503847e-01f, 9.09465253e-02f,
  -2.09784895e-01f, -7.27761447e-01f, -6.90347135e-01f, -3.51989895e-01f, -5.88779971e-02f, -2.91299194e-01f, -2.75105715e-01f, -6.00166805e-02f, -5.47743261e-01f, -9.59962904e-01f,
  -1.10434723e+00f, 1.10079885e+00f, 7.50868097e-02f, -2.07964569e-01f, -5.18420935e-01f, -6.22968554e-01f, 8.18426192e-01f, 7.34852627e-02f, -1.52081158e-02f, 9.54730511e-01f,
  2.89436400e-01f, -7.57396698e-01f, 4.76850979e-02f, -1.81817681e-01f, -3.15488458e-01f, 9.20445681e-01f, 4.59661007e-01f, -6.83776140e-01f, -1.28349555e+00f, -6.97835147e-01f,
  7.15386346e-02f, 8.79910886e-02f, -3.96103948e-01f, -1.97596610e-01f, 1.41900942e-01f, -2.21690666e-02f, 6.86762750e-01f, -2.78955132e-01f, -7.88358450e-02f, 3.32722694e-01f,
  2.98502445e-01f, -6.34961665e-01f, -1.94897443e-01f, -3.48843277e-01f, 3.19471769e-02f, -2.40900800e-01f, -9.14467722e-02f, -1.45288274e-01f, -6.91211298e-02f, 1.47902161e-01f,
  -3.37708712e-01f, -2.27190152e-01f, -3.17009568e-01f, -4.48585935e-02f, -4.52393033e-02f, 2.77090054e-02f, 3.86047438e-02f, -4.45949972e-01f, -1.09877624e-01f, 4.69343960e-02f,
  -1.28905326e-01f, -5.91378927e-01f, -3.50968033e-01f, 1.53884888e-01f, -2.48410240e-01f, -5.65958023e-01f, 1.09394498e-01f, -5.70613861e-01f, -4.40740198e-01f, 9.06737149e-01f,
  1.75557122e-01f, 2.31576487e-01f, -8.43445659e-02f, 1.12234645e-01f, 2.38907129e-01f, 2.48125158e-02f, 2.44642824e-01f, 5.75525649e-02f, -6.00378551e-02f, 8.65336657e-02f,
  -5.30906990e-02f, 1.20476931e-01f, 6.94279373e-02f, 1.96371973e-02f, -4.46703732e-02f, -2.27596164e-02f, -1.50055811e-01f, 2.57091433e-01f, -4.48591374e-02f, -7.41030369e-03f,
  1.57833993e-02f, -1.78409576e-01f, 2.62552183e-02f, 1.83481976e-01f, -1.95095107e-01f, -8.37265179e-02f, 2.33648568e-02f, -1.88922480e-01f, -1.09585062e-01f, 3.20075043e-02f,
  7.15957940e-01f, -5.38588703e-01f, 5.42531967e-01f, -6.57800734e-02f, 5.97469993e-02f, -2.06432715e-01f, 8.10962394e-02f, 3.12865824e-02f, -1.51271597e-01f, -6.93213046e-02f,
  -3.02271158e-01f, -2.58616567e-01f, 1.74151883e-01f, 2.02556029e-01f, -1.07160456e-01f, -2.02578992e-01f, 3.00164223e-01f, -3.02289538e-02f, -1.45234317e-01f, -1.25589650e-02f,
  2.96259314e-01f, 3.42767715e-01f, 3.35426331e-01f, 4.80523169e-01f, 6.69185072e-02f, -1.13404818e-01f, 5.01468182e-01f, 1.57231390e-01f, -2.72804171e-01f, 1.18881440e+00f,
  -9.14223567e-02f, -2.01887731e-02f, -2.21247748e-01f, 3.25645536e-01f, -2.99584776e-01f, -8.36240590e-01f, -8.47226799e-01f, -5.13044119e-01f, -7.51990527e-02f, -4.32054400e-01f,
  -9.53500688e-01f, -3.56962144e-01f, -1.84990615e-01f, 2.13895664e-01f, 1.52578622e-01f, 1.26103148e-01f, 9.21981394e-01f, 1.00962710e+00f, 5.33843517e-01f, 1.77249864e-01f,
  6.07685566e-01f, 9.69181061e-01f, 9.00757968e-01f, 5.53736329e-01f, 4.95776564e-01f, 3.17301810e-01f, 6.85769767e-02f, 8.42976496e-02f, -1.61851514e-02f, 9.19289947e-01f,
  -7.47247040e-01f, -5.48760235e-01f, 7.24345669e-02f, 2.79906631e-01f, 7.96042979e-02f, 2.31201109e-02f, -2.08457783e-01f, 2.33131260e-01f, -2.96853513e-01f, 3.16315025e-01f,
  -3.51821512e-01f, -9.01296511e-02f, -1.04346722e-01f, 1.31183907e-01f, -8.33690166e-02f, -4.06307966e-01f, 4.64307368e-01f, 7.52456039e-02f, -1.39478967e-01f, -3.88127029e-01f,
  4.00805563e-01f, 5.67390583e-03f, -7.72896230e-01f, -2.39360377e-01f, -3.15275103e-01f, 3.62843186e-01f, -5.78031242e-01f, -5.65018691e-02f, -4.59176511e-01f, 1.75106719e-01f,
  -3.28944147e-01f, -1.44665288e-02f, -1.86043069e-01f, 1.45428658e-01f, 2.85178632e-01f, -6.73601031e-02f, 6.35184199e-02f, -2.95261890e-02f, 1.38713837e-01f, 8.23610500e-02f,
  -3.36821154e-02f, -1.35332085e-02f, -1.24427594e-01f, -1.76351801e-01f, -6.23807020e-04f, -1.26519695e-01f, 3.85495625e-03f, 2.27874041e-01f, -5.97481169e-02f, 3.25785428e-02f,
  6.70946157e-03f, -8.84393826e-02f, 2.12066039e-01f, 1.00829385e-01f, -2.87122820e-02f, 6.97566122e-02f, 1.61745027e-01f, -4.23991799e-01f, 1.06501527e-01f, -4.42591086e-02f,
  -7.33688697e-02f, 1.75221115e-01f, -3.58338617e-02f, 3.88073213e-02f, 2.31131762e-02f, 6.36924133e-02f, 5.03045693e-02f, 5.39260246e-02f, -3.18212867e-01f, -1.92408841e-02f,
  -2.34878853e-01f, -2.53731087e-02f, -6.22902475e-02f, 2.01234873e-02f, -9.97752845e-02f, -4.65177506e-01f, 1.13992505e-02f, -1.94224581e-01f, -3.68697755e-02f, -1.90012440e-01f,
  4.25639302e-01f, -1.49805874e-01f, -3.55678111e-01f, -5.44223964e-01f, -3.84120911e-01f, -4.11923617e-01f, -3.61717373e-01f, -1.52899086e-01f, -7.60374844e-01f, -3.61807555e-01f,
  2.00308159e-01f, 1.69853225e-01f, -5.34258261e-02f, 7.83664465e-01f, 8.13507080e-01f, 6.95167959e-01f, 5.88763773e-01f, 3.45916927e-01f, 3.78017515e-01f, 2.90581018e-01f,
  2.34192565e-01f, 3.56104016e-01f, 3.13252777e-01f, 1.73378393e-01f, 2.25390002e-01f, 3.97312284e-01f, 5.33342481e-01f, 3.61799151e-02f, 3.80639620e-02f, 4.44105119e-01f,
  4.34898227e-01f, 3.28530610e-01f, -1.23031147e-01f, 1.34795606e-01f, 2.81133145e-01f, 3.77008706e-01f, 3.41130286e-01f, 2.67874986e-01f, 1.77707493e-01f, 4.05842513e-01f,
  -9.55419987e-02f, -2.94888783e-02f, 1.15518849e-02f, 4.64443415e-02f, -1.53636038e-01f, -3.45252961e-01f, -1.61631703e-01f, -3.43471438e-01f, -1.58632353e-01f, 1.15032066e-02f,
  -8.04424807e-02f, -1.57556847e-01f, -4.23472673e-02f, -1.90511987e-01f, -7.90690184e-02f, -1.29524127e-01f, -1.71769574e-01f, -6.66236952e-02f, 6.09186143e-02f, -1.38048187e-01f,
  -8.81482884e-02f, 1.38113769e-02f, -2.42243819e-02f, 9.15315673e-02f, 2.90488335e-03f, -1.89908091e-02f, -1.29561916e-01f, -3.97043228e-02f, -3.25668603e-02f, -4.72452603e-02f,
  -1.97396636e-01f, -5.95474020e-02f, 1.01963282e-01f, -2.14434229e-03f, -6.68838993e-02f, -1.50312195e-02f, 1.17098384e-01f, 9.37080607e-02f, 2.33862206e-01f, -2.65059453e-02f,
  -7.45942444e-03f, 9.85423550e-02f, -1.43221259e-01f, 1.22702993e-01f, -4.29813098e-03f, -3.88881844e-03f, -1.04029059e-01f, -1.18167795e-01f, -9.71595496e-02f, -2.39631593e-01f,
  7.58991987e-02f, 5.05804047e-02f, -1.10032506e-01f, -1.49461314e-01f, -1.78812984e-02f, 8.64763930e-02f, -3.36032696e-02f, -1.22878797e-01f, 2.39413511e-02f, 2.52910201e-02f,
  3.24413925e-01f, -1.96545184e-01f, 4.82774749e-02f, -8.17938969e-02f, 1.25308177e-02f, -3.62034440e-01f, 1.29999341e-02f, -1.38495296e-01f, -2.40588248e-01f, -4.01581153e-02f,
  -5.26763052e-02f, -2.20346838e-01f, -5.05950339e-02f, -8.46293122e-02f, -1.23158105e-01f, -1.21601120e-01f, -7.79816136e-02f, 1.15394918e-02f, 4.90201563e-02f, -1.16744228e-01f,
  -8.56444016e-02f, 6.45815507e-02f, 6.44191504e-02f, -1.18436757e-02f, 3.88418511e-02f, -2.24974239e-04f, -2.18405187e-01f, -8.74844342e-02f, -9.79040414e-02f, 5.91358282e-02f,
  -1.38439071e+00f, 8.72617245e-01f, 4.66094404e-01f, -1.08705091e+00f, 6.15538180e-01f, 9.75759685e-01f, 1.34955847e+00f, 4.22737598e-01f, -5.06099164e-01f, 2.56875485e-01f,
  1.40665323e-01f, -6.86219335e-01f, -4.38595116e-01f, -2.04326972e-01f, 2.78352410e-01f, 7.88227797e-01f, 4.77439642e-01f, -3.40136409e-01f, -3.79541814e-01f, 5.79626001e-02f,
  2.21120641e-01f, -3.29774082e-01f, -8.01871836e-01f, -3.77716780e-01f, -3.03873062e-01f, -4.88884240e-01f, -7.18808100e-02f, -4.46280800e-02f, 5.96644819e-01f, -9.08914134e-02f,
  -3.45695525e-01f, 8.72788951e-02f, 3.93959507e-03f, -3.74914646e-01f, -8.86944160e-02f, -3.08683336e-01f, -1.43352285e-01f, -4.39094901e-01f, -5.87334819e-02f, -1.21295393e-01f,
  -1.90740168e-01f, -2.40720864e-02f, -9.11779106e-02f, 1.14258178e-01f, -7.26647601e-02f, -3.89509723e-02f, -8.16157460e-03f, -8.56221840e-02f, -1.23086676e-01f, 1.85001731e-01f,
  3.49340975e-01f, 3.65630627e-01f, 1.58530638e-01f, 3.18903297e-01f, 3.36048037e-01f, -2.16278628e-01f, 2.53713638e-01f, 1.73390076e-01f, 2.04775482e-01f, -4.51576591e-01f,
  -3.62603776e-02f, -1.29919231e-01f, 1.53792486e-01f, -1.00635588e-01f, 6.34517334e-03f, 3.19868773e-02f, 5.40956408e-02f, 4.46876660e-02f, 6.49515390e-02f, -1.56546146e-01f,
  1.39653549e-01f, 1.23587519e-01f, 3.60317007e-02f, -1.89368442e-01f, -2.37213522e-01f, -1.67902210e-04f, 1.90429449e-01f, -7.14830682e-02f, 8.81311297e-02f, 2.08486151e-02f,
  -1.37815446e-01f, 2.78661221e-01f, -1.72770515e-01f, -4.59479950e-02f, 2.40859568e-01f, -4.95109335e-02f, -4.46208082e-02f, 6.56836852e-03f, -3.04110676e-01f, 8.18464756e-02f,
  -7.92688966e-01f, 7.28661358e-01f, -4.43726718e-01f, 6.98407516e-02f, 1.35981649e-01f, -1.38531169e-02f, -1.35192662e-01f, 6.83395118e-02f, 5.39821871e-02f, -8.89960006e-02f,
  1.57878354e-01f, -1.81929126e-01f, 5.14445342e-02f, 4.63257618e-02f, -1.13136858e-01f, -1.75450802e-01f, 1.59447551e-01f, -1.06658094e-01f, 6.24604635e-02f, -1.17410347e-01f,
  1.41151547e-01f, -3.60565856e-02f, -4.96436983e-01f, -1.26498491e-01f, -7.97534809e-02f, -3.08286458e-01f, -1.00197993e-01f, -1.42343000e-01f, 2.97317386e-01f, -3.10544312e-01f,
  6.74676299e-01f, 3.50630507e-02f, -1.54129267e+00f, 2.98605978e-01f, -4.75698888e-01f, -5.51964045e-01f, -4.19785142e-01f, 8.67756188e-01f, 6.86721146e-01f, -5.57988733e-02f,
  -3.10831875e-01f, -6.57494128e-01f, -1.08452022e+00f, -8.13742399e-01f, -7.47258604e-01f, -6.58302009e-01f, -7.57190883e-01f, -1.11730587e+00f, -9.07921195e-01f, 4.07751083e-01f,
  4.66100931e-01f, 1.84963960e-02f, -9.73525867e-02f, 6.79614767e-02f, -1.29821137e-01f, -5.75312853e-01f, -7.92858720e-01f, -6.68907762e-01f, -8.67586970e-01f, -1.20599759e+00f,
  -1.46646762e+00f, -9.05981138e-02f, -2.67551571e-01f, 1.44606475e-02f, -3.49809021e-01f, -2.05283076e-01f, -2.89100111e-01f, -2.06293866e-01f, 1.97744727e-01f, 1.61247388e-01f,
  -4.43576992e-01f, -1.47601888e-01f, -1.53289348e-01f, -3.70449871e-01f, -1.17564455e-01f, -1.16271118e-03f, 1.18236482e-01f, -2.48223081e-01f, -3.93336654e-01f, 1.26766950e-01f,
  1.26258107e-02f, -6.44318283e-01f, -1.08267665e+00f, 5.40677272e-02f, -5.02301931e-01f, -4.07015949e-01f, -2.46745721e-01f, -2.53393620e-01f, -6.31482601e-01f, -8.22201818e-02f,
  2.20437884e-01f, -1.78081751e-01f, -4.81997542e-02f, 1.28104374e-01f, 2.24412784e-01f, 1.12036504e-01f, -1.73778072e-01f, -7.91576654e-02f, 2.51083046e-01f, 6.24821112e-02f,
  1.00303506e-02f, 3.68097201e-02f, 2.15893403e-01f, -1.28536969e-01f, -3.11404288e-01f, -7.59994686e-02f, -5.34303579e-03f, -1.10291340e-03f, -1.32438406e-01f, 1.05446756e-01f,
  -1.38824463e-01f, -8.89372826e-02f, 1.03685064e-02f, 3.79415154e-01f, -2.24367663e-01f, -1.45562053e-01f, -9.12287906e-02f, 2.30547950e-01f, -6.67075515e-02f, 9.27621052e-02f,
  -1.03077002e-01f, -3.50976229e-01f, -1.70963734e-01f, -1.51813477e-01f, -9.97008458e-02f, 1.39531538e-01f, -3.14922690e-01f, 3.90385091e-01f, -3.16907354e-02f, -5.00059426e-02f,
  -2.14077443e-01f, 1.55088842e-01f, -2.00867966e-01f, 5.23618013e-02f, 1.29890159e-01f, 1.13291830e-01f, 1.53492555e-01f, -3.61850023e-01f, -1.51039064e-01f, 3.03832769e-01f,
  2.94235319e-01f, 3.08923125e-01f, -4.87533817e-03f, -1.59571216e-01f, -2.99573503e-02f, -3.01687241e-01f, -3.68190587e-01f, 4.12508249e-02f, -3.92740160e-01f, 6.17493808e-01f,
  1.20202088e+00f, -1.36301529e+00f, 6.27197027e-01f, 1.63706735e-01f, 2.11822823e-01f, 3.21177214e-01f, -3.97094280e-01f, -2.23173752e-01f, 1.72152162e-01f, -4.18269038e-01f,
  -6.27484858e-01f, -4.31844741e-01f, -1.94322422e-01f, -8.68556052e-02f, 2.28972752e-02f, -8.20186064e-02f, 4.21291679e-01f, 8.59770358e-01f, 8.44571650e-01f, -1.11039102e-01f,
  -4.56728339e-01f, -9.67747346e-02f, 3.42503279e-01f, 2.48360876e-02f, -4.92499232e-01f, 1.28742754e-01f, -1.06432460e-01f, -2.30851993e-01f, -3.93097132e-01f, -5.72062254e-01f,
  -1.45413324e-01f, -5.64153850e-01f, 3.08971614e-01f, -1.61406934e-01f, -1.69766739e-01f, -5.12599498e-02f, -4.14080471e-02f, -4.23038304e-02f, -9.71876085e-02f, -1.41067933e-02f,
  -2.08866358e-01f, -5.45546673e-02f, -1.45477310e-01f, -2.10064337e-01f, -1.53151274e-01f, -5.63160516e-02f, -5.33106141e-02f, -7.00929016e-02f, -6.07313253e-02f, -2.41708934e-01f,
  -3.88188183e-01f, -1.06735401e-01f, 2.13529855e-01f, -2.27462035e-03f, -2.30909780e-01f, 2.24775016e-01f, -2.13241190e-01f, -2.22112522e-01f, 1.79769173e-01f, -2.47826502e-01f,
  -1.32898793e-01f, 4.75186259e-02f, -9.35047790e-02f, 5.37735447e-02f, 1.08739875e-01f, 9.14723948e-02f, 4.52884249e-02f, -1.72190042e-03f, 5.39783388e-02f, 8.21313709e-02f,
  -3.72640975e-02f, 8.75830203e-02f, 4.28427793e-02f, -7.34212622e-02f, -6.19038120e-02f, -1.15565136e-02f, 1.17782652e-01f, -1.97388068e-01f, 1.22997006e-02f, 1.08196311e-01f,
  -5.60941845e-02f, 7.24408999e-02f, 3.28517221e-02f, -1.09503821e-01f, 7.55027980e-02f, 4.65859622e-02f, 6.28118366e-02f, -5.49934246e-02f, 5.31510003e-02f, 9.64573249e-02f,
  -2.70013034e-01f, 4.90478307e-01f, -1.11964764e-02f, -1.80805221e-01f, 2.99858730e-02f, -1.46087080e-01f, -9.05614346e-02f, -1.97753171e-03f, -1.51286731e-02f, -1.04992069e-01f,
  -1.36785656e-01f, -5.25344051e-02f, -2.84745783e-01f, -1.16036944e-01f, 1.60914540e-01f, 1.03141122e-01f, -1.84402376e-01f, 1.36659816e-01f, -4.25680578e-02f, -1.21709369e-01f,
  -1.98690906e-01f, 3.17300588e-01f, 5.10146976e-01f, 2.33522758e-01f, 4.57002176e-03f, 4.67393398e-01f, 1.51439175e-01f, 6.02017194e-02f, 3.89167875e-01f, 1.68741733e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -2.96768278e-01f, 5.59180796e-01f, 1.03227258e+00f, 4.45103347e-01f, 1.56040716e+00f, 1.10058069e+00f, 6.02821827e-01f, 1.13789153e+00f, 1.07787883e+00f, 1.24606931e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  3.81941646e-02f, 1.95802733e-01f, -9.07002687e-01f, -4.33159947e-01f, 2.45396584e-01f, -4.50410038e-01f, -1.82436660e-01f, 6.45350218e-01f, -1.07381833e+00f, -6.62757397e-01f,
  -1.85877001e+00f, 2.08041053e-02f, -9.75875676e-01f, -1.08799088e+00f, 8.59359503e-01f, -1.47983468e+00f, -4.44147438e-02f, 2.23497719e-01f, 2.09349200e-01f, 3.59777808e-01f,
  1.67150274e-01f, -3.04967850e-01f, 9.52255607e-01f, 9.42198992e-01f, -6.60232544e-01f, -1.68966651e+00f, -1.37321270e+00f, -9.72602606e-01f, 2.17753783e-01f, -1.57074058e+00f,
  5.80806751e-03f, 6.12598956e-01f, 2.68013060e-01f, -3.49267423e-01f, -5.74396960e-02f, 2.17013955e-01f, 6.85536623e-01f, -5.38308203e-01f, -1.06222773e+00f, 2.15899587e-01f,
  -9.28044971e-03f, -1.03202164e+00f, -9.74921227e-01f, 1.24821889e+00f, -1.63905060e+00f, -5.11982262e-01f, -1.33162665e+00f, 3.80228877e-01f, -1.21930218e+00f, -4.85351920e-01f,
  9.58287790e-02f, -7.33880162e-01f, 2.79399812e-01f, -1.55558676e-01f, -4.18688893e-01f, -9.91577029e-01f, -1.38876152e+00f, 8.45920071e-02f, -7.90766999e-03f, -6.24781549e-01f,
  -1.33591437e+00f, 1.66185272e+00f, -1.07832111e-01f, -5.02294362e-01f, 2.90144473e-01f, 9.19786049e-04f, 2.21618056e-01f, -6.92189097e-01f, 7.94510901e-01f, 2.40130410e-01f,
  -1.32015357e-02f, -1.14302421e+00f, 4.34795320e-01f, 9.38854754e-01f, -7.30858222e-02f, -1.84161460e+00f, 1.68216750e-01f, -1.28374004e+00f, 2.04570562e-01f, -1.10900569e+00f,
  5.29546142e-01f, -1.05860400e+00f, -8.00952688e-02f, 9.35334027e-01f, -1.56497300e+00f, 4.64641809e-01f, -7.68163621e-01f, -1.63582191e-01f, -6.69846177e-01f, -1.55743659e+00f,
  5.80052972e-01f, 2.45611548e-01f, 1.27597839e-01f, -1.98547161e+00f, 4.59303021e-01f, -6.60425365e-01f, -2.47272149e-01f, 7.11460784e-02f, 4.85667914e-01f, 2.71951914e-01f,
  7.29961693e-01f, 1.34632540e+00f, 9.27791953e-01f, -9.06354129e-01f, 1.05941296e+00f, -3.58530253e-01f, -4.68102306e-01f, 2.79850364e-01f, -5.74765623e-01f, -1.57313013e+00f,
  -1.88278806e+00f, -1.22326648e+00f, -2.94517517e-01f, 9.92058143e-02f, -1.70553967e-01f, -3.92263323e-01f, -4.16795194e-01f, -1.16933860e-01f, -6.52957082e-01f, -1.40001917e+00f,
  -7.35182226e-01f, -6.64913118e-01f, 4.01990920e-01f, 4.72514518e-02f, 3.24578553e-01f, 7.29894519e-01f, -1.31018555e+00f, -1.01438725e+00f, 2.85378367e-01f, 5.76475024e-01f,
  1.47249237e-01f, 5.37348270e-01f, -3.16351503e-01f, 3.60912293e-01f, -6.60605192e-01f, -1.65564239e+00f, -9.18934226e-01f, -2.43742496e-01f, -3.68480086e-01f, -4.61929411e-01f,
  1.87946796e-01f, -6.20549358e-02f, -1.09051895e+00f, 1.64446032e+00f, 1.98839605e-01f, 4.67223823e-01f, -4.64854181e-01f, 3.42228919e-01f, -8.61674309e-01f, -1.10931933e+00f,
  -7.13837862e-01f, -1.26804209e+00f, 1.35314509e-01f, 1.32884240e+00f, -1.41648436e+00f, 4.98867214e-01f, -5.26067764e-02f, -1.29717135e+00f, -7.67673433e-01f, -1.68816459e+00f,
  2.27075769e-03f, -2.61065185e-01f, 2.25084320e-01f, -8.16275179e-01f, 9.55684006e-01f, 2.50065476e-01f, -7.67052352e-01f, 3.04165095e-01f, -1.03799224e+00f, -5.65311551e-01f,
  1.75973928e+00f, -1.19732940e+00f, -8.63194883e-01f, -4.17534679e-01f, -1.61823595e+00f, -8.30827415e-01f, 3.06251585e-01f, -1.53713226e-01f, 2.22737212e-02f, 5.22283375e-01f,
  -7.89999783e-01f, 5.89272618e-01f, 3.11546624e-01f, -1.88791305e-01f, 1.12788260e+00f, 8.89966413e-02f, -1.26262176e+00f, -1.34090126e+00f, -1.86652094e-01f, 1.30132818e+00f,
  -1.28086436e+00f, -1.02104485e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.02741593e-01f, -3.91882688e-01f, 6.72488034e-01f, -9.52403784e-01f, 4.57067043e-01f, 3.03330749e-01f, 2.61917651e-01f, -5.78738093e-01f, -2.00551122e-01f, -7.26120770e-02f,
  -2.36914262e-01f, 7.20624477e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    