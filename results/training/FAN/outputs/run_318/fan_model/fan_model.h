/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.25685734e-01f, 2.41867959e-01f, -6.68911785e-02f, 8.60604942e-02f, -2.72279710e-01f, -1.46451369e-01f, -1.91644207e-01f, -1.10317133e-01f, -2.09454801e-02f, 1.42014697e-02f,
  -1.18274562e-01f, 4.28406335e-02f, 2.11545955e-02f, 9.07026380e-02f, -1.05654903e-01f, 1.68862641e-01f, 7.93801527e-03f, -1.25512823e-01f, 1.47646457e-01f, -6.83979020e-02f,
  4.91918018e-03f, -2.57935133e-02f, 3.96665186e-02f, 4.36048321e-02f, -2.19961643e-01f, 6.26439368e-03f, 1.87671222e-02f, 5.62712774e-02f, -1.04509614e-01f, -3.38941775e-02f,
  -7.63869956e-02f, -3.49576883e-02f, -1.36204168e-01f, -9.39090326e-02f, -1.76969498e-01f, -9.55867544e-02f, -8.64118189e-02f, -2.99033932e-02f, -7.40292668e-02f, -4.65300167e-03f,
  -2.51085740e-02f, -9.13800765e-03f, -4.31108102e-03f, 1.38092889e-02f, 2.77478117e-02f, -2.94707529e-02f, 5.80501631e-02f, -7.80128092e-02f, 1.90501902e-02f, -2.36722436e-02f,
  3.80322002e-02f, -1.91041920e-02f, -2.52891462e-02f, 1.03318896e-02f, -3.90254892e-02f, 1.53042050e-02f, 1.62530877e-02f, -7.29035214e-02f, -2.89988797e-02f, -3.96580920e-02f,
  1.62070375e-02f, -1.87524352e-02f, 2.43507046e-02f, -1.17613776e-02f, 4.60030586e-02f, -7.72273242e-02f, 1.08905220e-02f, -2.01934390e-02f, -6.15265546e-03f, 5.34330606e-02f,
  -1.18895881e-01f, 9.72777605e-03f, -1.34216563e-03f, 1.27126984e-02f, -1.94024872e-02f, -3.67196351e-02f, 2.72725113e-02f, -5.38586155e-02f, -4.83709089e-02f, 2.66132038e-02f,
  2.46125646e-02f, 1.61724202e-02f, -1.67726390e-02f, -1.65926963e-02f, -9.94900707e-03f, 2.77946461e-02f, 9.42816585e-02f, 7.07684606e-02f, -9.97111294e-03f, -7.04941079e-02f,
  -2.70169415e-02f, 7.26177245e-02f, 4.76343557e-02f, 2.09803437e-03f, 6.46862909e-02f, 3.68824527e-02f, 2.21106634e-02f, -4.15608697e-02f, 8.08267742e-02f, -5.54744601e-02f,
  -5.58963828e-02f, -5.77248037e-02f, -7.24769011e-02f, -3.26794498e-02f, -2.59866435e-02f, 4.92447093e-02f, -6.03375919e-02f, 7.32591823e-02f, -7.81081766e-02f, 3.78237963e-02f,
  -2.52368040e-02f, -1.48146842e-02f, 9.47514270e-03f, -5.91658726e-02f, -5.82274385e-02f, -4.43762466e-02f, -8.40372071e-02f, 2.13473532e-02f, -3.65547091e-02f, 1.28557961e-02f,
  3.88233289e-02f, 2.27595344e-01f, -2.09095582e-01f, 9.71193891e-03f, -5.50417714e-02f, 1.58791486e-02f, -2.74033844e-01f, -5.15674055e-02f, -2.14315042e-01f, 1.04873128e-01f,
  -1.00000091e-02f, 1.39460176e-01f, -1.55971378e-01f, 1.12497643e-01f, -1.92951784e-01f, -1.25220135e-01f, 9.94190201e-02f, 4.15935405e-02f, -3.95232998e-02f, 8.48800689e-02f,
  -1.80950239e-02f, 5.63601702e-02f, -4.12874036e-02f, 1.19841881e-01f, 1.45113990e-01f, 1.27507329e-01f, 1.64964184e-01f, -4.48341332e-02f, 2.20797077e-01f, -9.03558172e-03f,
  7.96611458e-02f, -7.43002072e-02f, 9.72710326e-02f, 8.32088962e-02f, 5.45013174e-02f, 6.39527366e-02f, 7.69882696e-03f, -9.40725282e-02f, -5.83994724e-02f, -4.81835306e-02f,
  5.76758198e-02f, -5.96169662e-03f, 3.60278301e-02f, -7.99461007e-02f, 6.19940609e-02f, -5.11256084e-02f, -5.81328273e-02f, 6.09029718e-02f, -5.92395337e-03f, -5.23357727e-02f,
  -7.60483230e-03f, 8.15948918e-02f, 4.20954414e-02f, 3.16156298e-02f, 2.72384323e-02f, 7.78746419e-03f, 7.31641834e-04f, 1.19340802e-02f, 2.89171468e-02f, 4.23527621e-02f,
  -3.42065878e-02f, -2.36656256e-02f, -2.21506655e-02f, 5.74400835e-03f, -2.11658478e-02f, -5.53380400e-02f, 7.12404177e-02f, -2.81053018e-02f, 5.50359534e-03f, 5.58770858e-02f,
  5.44640273e-02f, 3.73062268e-02f, 5.69816343e-02f, -1.27652874e-02f, 1.87408272e-02f, -7.42268190e-03f, 7.29521811e-02f, -9.92090721e-03f, 4.01040688e-02f, -3.85416448e-02f,
  -7.72513598e-02f, -4.55430076e-02f, 2.16858322e-03f, -4.25538979e-02f, 3.40044461e-02f, -3.54129523e-02f, 5.62232509e-02f, -1.50489323e-02f, -3.67439464e-02f, -9.80382971e-03f,
  3.41871321e-01f, 1.61777735e-01f, 2.21982785e-02f, -3.53763811e-03f, 1.49347326e-02f, 3.32169905e-02f, 2.84721982e-03f, 3.14329341e-02f, 3.78779583e-02f, -4.26527020e-03f,
  3.81688438e-02f, 2.25641881e-03f, 4.92609665e-02f, -1.80370675e-03f, 3.06878518e-03f, 5.50775863e-02f, -4.34931309e-04f, 4.80578877e-02f, 1.02685027e-01f, 7.98126012e-02f,
  3.24449465e-02f, 9.05726198e-03f, -2.65266821e-02f, -6.06075898e-02f, 2.73867957e-02f, 1.81877147e-02f, 2.22218558e-02f, 4.63470770e-03f, -4.16534767e-03f, 2.39394978e-02f,
  3.31859380e-01f, -1.53977782e-01f, 1.34412020e-01f, 3.16423252e-02f, 2.83388831e-02f, 2.11307239e-02f, 8.68539885e-03f, -5.58008216e-02f, 3.38733830e-02f, -1.33246690e-01f,
  -5.89410290e-02f, 1.78136855e-01f, 5.53448265e-03f, -6.05784506e-02f, 1.03551224e-01f, -1.02578007e-01f, -5.98421097e-02f, 4.05673757e-02f, -3.81303132e-02f, 5.67324758e-02f,
  -7.90430233e-03f, -3.42545509e-02f, 8.04692432e-02f, -1.03101134e-01f, 3.51495249e-03f, 3.18954103e-02f, -1.72550939e-02f, 3.75392362e-02f, 5.57059497e-02f, 9.77740041e-04f,
  9.75522324e-02f, 9.38068703e-02f, 1.27567321e-01f, 1.55696971e-02f, 1.22052900e-01f, -6.55706450e-02f, -9.84199531e-03f, 8.30756798e-02f, 1.78289488e-02f, 2.04090923e-02f,
  -6.78691268e-02f, 1.39152668e-02f, 1.81533173e-02f, -3.53437811e-02f, -5.78222796e-02f, 5.96897379e-02f, 3.33181955e-02f, -5.66827320e-02f, 1.07646743e-02f, -3.03300889e-03f,
  -3.23472321e-02f, -3.32027152e-02f, -6.00161701e-02f, 1.34378420e-02f, 4.55360301e-03f, -3.61721814e-02f, 5.56377098e-02f, -3.40483675e-04f, -1.19434744e-01f, 6.74954280e-02f,
  -9.87475887e-02f, -1.63888242e-02f, -4.94754203e-02f, 4.00780281e-03f, -5.30185662e-02f, -6.77204356e-02f, -7.36079514e-02f, -3.23001519e-02f, -1.30904894e-02f, -2.23222263e-02f,
  1.57771129e-02f, -3.07739452e-02f, -2.93935388e-02f, -6.13674335e-02f, -3.39546390e-02f, 3.78011987e-02f, 5.87453209e-02f, 2.85539292e-02f, 8.32674652e-03f, 6.24914700e-03f,
  1.95492730e-02f, -1.58304162e-02f, -2.73972359e-02f, 3.70893488e-03f, -5.79403527e-02f, 1.62955448e-02f, 2.84283534e-02f, -9.81350243e-02f, -1.85047165e-02f, -6.89425766e-02f,
  -1.02801077e-01f, -4.34807874e-02f, -1.09932041e-02f, 6.07964098e-02f, 5.06444573e-02f, 1.87241901e-02f, 1.67274289e-02f, -5.81063032e-02f, -5.92977032e-02f, -6.14812113e-02f,
  4.99237282e-03f, 5.83209693e-02f, -2.16914602e-02f, 4.43352051e-02f, -5.97896986e-02f, -6.58795908e-02f, -2.07816809e-02f, -1.37933865e-02f, 4.13921550e-02f, -1.47344852e-02f,
  7.35907182e-02f, 6.00766875e-02f, -1.50507521e-02f, -5.63212596e-02f, -5.77079616e-02f, -2.62021236e-02f, 7.68902525e-02f, -3.60326609e-03f, -4.84597832e-02f, -8.76347348e-02f,
  4.15846467e-01f, 9.41263512e-02f, 1.73159793e-01f, 2.24526182e-01f, -8.24487116e-03f, 2.88912542e-02f, 4.44910787e-02f, 1.35642648e-01f, 2.95245796e-01f, -1.13976307e-01f,
  -2.74026468e-02f, 1.25432462e-01f, -1.71919167e-01f, 7.29305372e-02f, 2.55024135e-01f, -1.27921313e-01f, 2.56012797e-01f, -3.36794667e-02f, 5.41388728e-02f, 9.37251821e-02f,
  8.16453248e-02f, -6.34638546e-03f, 6.46284521e-02f, -3.92700545e-02f, -2.69967504e-03f, 2.45513245e-02f, -6.09686002e-02f, -8.62893611e-02f, -1.03434563e-01f, -2.04647100e-03f,
  2.20649410e-02f, -8.55348539e-03f, -3.85630541e-02f, -4.15368378e-02f, -4.03526351e-02f, -1.06425546e-02f, -8.67844373e-02f, -2.97319493e-03f, -2.17527654e-02f, -5.29722236e-02f,
  1.55038852e-02f, 4.28306758e-02f, 1.06052589e-02f, 1.08018154e-02f, 1.34296278e-02f, -5.72044170e-03f, -4.52987105e-02f, 1.60009135e-02f, 3.97409014e-02f, -7.19406530e-02f,
  -4.66464497e-02f, 1.92979258e-02f, 3.41246128e-02f, -3.53066251e-02f, 1.93512551e-02f, -4.14335285e-04f, 2.54993755e-02f, -5.26576303e-02f, -1.18266675e-03f, 6.43167123e-02f,
  5.88566698e-02f, 2.78884005e-02f, 1.18558146e-02f, -3.15070078e-02f, 7.58515596e-02f, -5.42774424e-02f, -3.65393120e-03f, -1.74454208e-02f, -5.60462708e-03f, -2.42095497e-02f,
  6.57471269e-02f, -3.90706165e-03f, 1.17164748e-02f, -1.22577446e-02f, 2.36617494e-02f, -2.36565284e-02f, -7.82419592e-02f, 3.80882025e-02f, 6.04770295e-02f, 2.56066304e-02f,
  -2.85695512e-02f, 1.16705392e-02f, -2.43384484e-02f, -7.93772340e-02f, 1.17616006e-03f, -1.29594682e-02f, 1.30674299e-02f, 3.82934660e-02f, 1.97178125e-02f, -2.41308082e-02f,
  7.60102971e-03f, 1.48338616e-01f, 7.27796508e-03f, -9.88300890e-03f, 4.92923297e-02f, 2.74805296e-02f, 1.05918139e-01f, 2.02789437e-02f, 9.76499915e-02f, 8.80035684e-02f,
  -9.32724401e-03f, 5.51129458e-03f, -2.61376593e-02f, -4.09972630e-02f, 3.51886451e-02f, 1.31499046e-03f, -5.01870923e-03f, 6.07234128e-02f, 2.01451164e-02f, -1.52759161e-02f,
  -5.22318780e-02f, -1.36893401e-02f, 6.26780316e-02f, -6.54647546e-03f, 4.74864431e-03f, -1.26407715e-02f, 2.72489190e-02f, 3.23418230e-02f, 2.20958069e-02f, 4.20481600e-02f,
  -8.10928568e-02f, -7.38030896e-02f, 1.46729365e-01f, -2.77811766e-01f, -3.97719890e-02f, 3.01122107e-02f, 5.57143241e-02f, -1.84940677e-02f, -4.37070755e-03f, -4.51171324e-02f,
  -1.29580842e-02f, -5.32007068e-02f, 1.46475673e-01f, -7.55144879e-02f, 7.24126101e-02f, 6.13973103e-02f, -1.76523849e-01f, -2.50743236e-02f, 3.18288393e-02f, -5.06739542e-02f,
  -3.88755500e-02f, -3.37187760e-02f, 1.21566474e-01f, 5.27953580e-02f, -2.57933252e-02f, -8.13729689e-02f, 3.27659659e-02f, 1.45250270e-02f, -5.59572577e-02f, 4.48033400e-03f,
  -1.53513986e-03f, -2.58525431e-01f, 8.70878547e-02f, -5.29475063e-02f, -7.46475384e-02f, -1.38534103e-02f, -6.22436255e-02f, 5.35850488e-02f, 4.55906577e-02f, 2.58449763e-02f,
  -7.32508081e-04f, -4.30037454e-02f, -7.84238875e-02f, 9.19293538e-02f, 2.06885710e-02f, -2.00579073e-02f, -8.35403241e-03f, 2.39999499e-02f, 3.47247347e-02f, -3.37325297e-02f,
  8.54460746e-02f, 3.05593642e-03f, 1.19947987e-02f, 2.03052685e-02f, 4.12833132e-02f, 5.99202476e-02f, 4.54010852e-02f, -3.81110981e-03f, -7.86002129e-02f, -6.14173375e-02f,
  7.30114058e-03f, 4.00912464e-02f, 2.25300640e-02f, 2.51843012e-04f, 1.69293527e-02f, -2.14443114e-02f, 1.39990104e-02f, 5.21442667e-02f, -2.79600825e-02f, 2.56695077e-02f,
  2.21757870e-02f, -4.69763242e-02f, -4.87188697e-02f, 1.25220045e-02f, 2.52326149e-02f, -5.26875257e-02f, 7.22749829e-02f, -2.33250521e-02f, 2.60944795e-02f, -5.62555855e-04f,
  -6.40071034e-02f, -7.33443797e-02f, -2.33468581e-02f, 2.46861205e-02f, 2.78770886e-02f, -1.31310575e-04f, -7.74728553e-03f, 1.75644383e-02f, 1.87231936e-02f, 4.42194343e-02f,
  -2.98826456e-01f, -3.45552862e-01f, 7.37333894e-02f, -2.02666726e-02f, 1.66814160e-02f, 4.97498289e-02f, 5.67675494e-02f, 6.66003972e-02f, -3.80993001e-02f, 8.56779609e-03f,
  -2.36664228e-02f, 5.02057513e-03f, -4.00633067e-02f, -3.00833266e-02f, 3.91505547e-02f, 2.73258369e-02f, -6.10458385e-03f, 1.17194876e-02f, -6.64758533e-02f, -1.71908662e-02f,
  -8.46771970e-02f, 1.08925905e-02f, 4.81391549e-02f, 3.25505994e-02f, 4.13518138e-02f, -5.50772510e-02f, -8.37249383e-02f, -3.83176506e-02f, -4.88090329e-02f, -1.16708381e-02f,
  -2.40389988e-01f, 7.94833079e-02f, -1.12748846e-01f, -1.60034224e-01f, -5.96211106e-02f, -1.33388303e-02f, 1.00733817e-01f, 6.63067922e-02f, 7.57587254e-02f, 1.61970347e-01f,
  5.65593727e-02f, 7.78078288e-02f, 6.71724379e-02f, -7.31590688e-02f, -1.31123960e-01f, 9.21586528e-03f, 2.47195773e-02f, 4.14825007e-02f, -2.76252255e-02f, -5.36116324e-02f,
  -8.81037861e-02f, -9.61847696e-03f, -4.86018099e-02f, -7.51288459e-02f, -4.08149138e-02f, -1.09818622e-01f, -5.77519760e-02f, -1.49525758e-02f, -9.34335440e-02f, 1.56306028e-02f,
  -1.24361860e-02f, 1.03187673e-01f, -3.86066809e-02f, 3.58753428e-02f, 6.98163882e-02f, -4.87530418e-02f, -2.04127119e-03f, 1.11775771e-02f, -6.89032674e-02f, -2.39751730e-02f,
  5.62875792e-02f, -5.35084382e-02f, 2.08505131e-02f, -1.55069085e-03f, -1.60957165e-02f, -3.39487405e-03f, -1.86498575e-02f, -6.56767115e-02f, -1.85532365e-02f, 3.12350653e-02f,
  -5.05371578e-03f, 1.39368307e-02f, -2.88475789e-02f, -4.82362621e-02f, -1.04301069e-02f, 3.97992395e-02f, -5.88638410e-02f, -1.02029387e-02f, 6.28836900e-02f, -5.63340588e-03f,
  2.00794055e-03f, 5.32528311e-02f, 8.40128139e-02f, 1.79914683e-02f, 1.40145579e-02f, 3.50274779e-02f, 1.50588844e-02f, -5.06681651e-02f, 5.34207337e-02f, 1.83256902e-02f,
  -5.72388582e-02f, 5.30409142e-02f, -7.32783228e-02f, 3.76279540e-02f, 1.38721969e-02f, 5.88807091e-03f, -3.93544585e-02f, 4.29833010e-02f, -5.97866811e-03f, 1.31130833e-02f,
  -8.31953716e-03f, 1.81504863e-03f, -5.94044328e-02f, 5.90999098e-03f, -3.71956751e-02f, -5.11412360e-02f, -2.68428046e-02f, 4.05557454e-02f, 4.20232750e-02f, 3.00693302e-03f,
  1.61007941e-01f, 2.04876605e-02f, 3.75474580e-02f, -4.34353575e-02f, -3.71038094e-02f, 1.26476921e-02f, -2.02450398e-02f, -1.11852707e-02f, 4.78772633e-02f, 5.86317182e-02f,
  1.35444943e-02f, 2.68860869e-02f, 1.68070123e-02f, -1.30894696e-02f, -6.86292797e-02f, 7.17750415e-02f, 5.31095639e-02f, -1.89744961e-02f, -6.31660968e-02f, 5.71096763e-02f,
  2.27581747e-02f, 2.45060083e-02f, -7.06895217e-02f, -4.27158140e-02f, -3.72682847e-02f, -3.96753773e-02f, 3.92151587e-02f, 3.17321755e-02f, -6.48620259e-03f, 4.67607789e-02f,
  -8.60977620e-02f, -1.26456931e-01f, -1.39243618e-01f, 4.14675884e-02f, 6.12385161e-02f, 1.81809902e-01f, 1.61424816e-01f, 3.17976587e-02f, -1.63166039e-02f, -1.03225904e-02f,
  1.91504866e-01f, 4.96961102e-02f, 1.79533809e-02f, 2.10942835e-01f, 2.51997262e-01f, 7.74151087e-02f, 1.97654307e-01f, -2.75992602e-02f, -1.87581070e-02f, -3.03432234e-02f,
  -5.49318716e-02f, 1.36014059e-01f, 8.89731571e-02f, -6.72892183e-02f, -8.36795866e-02f, -1.56798795e-01f, 5.47786020e-02f, 2.16663871e-02f, -5.29534891e-02f, 3.49904187e-02f,
  1.50041342e-01f, -2.90960595e-02f, -1.02770105e-01f, -3.72614600e-02f, 3.15219685e-02f, -6.49041012e-02f, 9.64392256e-03f, 6.88886195e-02f, -2.15624720e-02f, -3.12795378e-02f,
  -5.07122427e-02f, 4.71988097e-02f, 4.79838923e-02f, 1.55711845e-02f, 3.24868821e-02f, 1.51963830e-02f, 4.11359817e-02f, 1.86021160e-02f, -5.46691455e-02f, -6.61659166e-02f,
  -7.13990554e-02f, -6.29050881e-02f, -1.49935987e-02f, 4.91137654e-02f, 6.38160557e-02f, -1.12436358e-02f, 2.87399385e-02f, 2.64885109e-02f, -9.37500410e-03f, -9.20685530e-02f,
  4.63760607e-02f, -5.29147573e-02f, 2.52143852e-02f, 1.51666384e-02f, 3.25989537e-02f, 1.08667305e-02f, 6.52160048e-02f, 3.77690047e-02f, -3.52827199e-02f, -1.04412688e-02f,
  -4.36051413e-02f, 2.29736809e-02f, 1.97016578e-02f, 4.92328517e-02f, -1.87644188e-03f, -2.07225773e-02f, 5.58695570e-03f, 4.00376767e-02f, -2.41891537e-02f, 5.84873371e-02f,
  5.34240752e-02f, -6.09661452e-02f, -6.12431392e-02f, 6.44952357e-02f, 3.38785537e-02f, 1.04959239e-03f, -2.14993246e-02f, -4.16034758e-02f, -1.60800107e-02f, -1.86741631e-02f,
  -7.92710483e-02f, -8.42874795e-02f, 2.97219809e-02f, 4.96516712e-02f, 3.27255577e-02f, 4.17925604e-02f, 5.80306053e-02f, -1.80845764e-02f, 5.76172322e-02f, -3.61908786e-02f,
  -3.07482872e-02f, -1.90892513e-03f, -6.24521598e-02f, -1.53480666e-02f, 6.28152564e-02f, -3.09398156e-02f, -4.68088016e-02f, -1.09457932e-02f, -2.44017243e-02f, -2.01299656e-02f,
  9.26830620e-03f, 7.93005824e-02f, -5.01125753e-02f, 5.51840737e-02f, -3.16109159e-03f, -3.17184627e-02f, 5.80942119e-03f, -4.03629094e-02f, -4.68518101e-02f, 3.85062285e-02f,
  -1.57965824e-01f, -2.74855476e-02f, -1.96738958e-01f, 1.47132248e-01f, 1.18655235e-01f, 1.49957612e-02f, 3.48657109e-02f, 1.02589376e-01f, 2.69617140e-01f, 1.20815560e-01f,
  1.43270373e-01f, -1.50856882e-01f, -1.32033331e-02f, 6.70526400e-02f, -2.18240201e-01f, -1.84269156e-02f, 6.11470605e-04f, 4.77340966e-02f, 9.39913094e-02f, 4.38721776e-02f,
  -4.19857055e-02f, 2.15583578e-01f, -1.39161840e-01f, 1.20810680e-01f, -3.91323268e-02f, 5.07570840e-02f, -7.36132190e-02f, -3.24938074e-02f, 8.64557177e-02f, -4.12357375e-02f,
  -9.05777588e-02f, 6.16820268e-02f, -1.11081991e-02f, -5.20875454e-02f, 7.44450558e-03f, -8.49377587e-02f, -6.62186667e-02f, -1.14482790e-01f, -7.12338611e-02f, 5.15783802e-02f,
  -9.39972028e-02f, -3.09082624e-02f, -1.34304296e-02f, 6.39791265e-02f, 6.11688457e-02f, -5.05518317e-02f, 5.81971891e-02f, 1.02330379e-01f, 1.04568235e-03f, -1.12729698e-01f,
  3.37782316e-02f, -1.82212815e-02f, -2.23915614e-02f, -1.61965820e-03f, 2.72735301e-03f, 9.41402614e-02f, 5.84562346e-02f, -5.47749065e-02f, 7.27816597e-02f, 7.23226517e-02f,
  1.70529187e-02f, 4.26769108e-02f, 1.24793500e-02f, 3.46790627e-02f, -1.70350634e-02f, 8.98989849e-03f, -3.39364856e-02f, -2.63184849e-02f, -1.22771028e-03f, 8.02692473e-02f,
  4.72427756e-02f, 3.37821916e-02f, 4.83954847e-02f, -3.43335904e-02f, 1.37156490e-02f, 3.45323347e-02f, -5.66562563e-02f, 4.46132980e-02f, -6.81922492e-03f, 2.23907083e-02f,
  3.26573998e-02f, 3.58449146e-02f, 7.05826655e-02f, 3.17597575e-02f, 1.05214808e-02f, -5.56536764e-02f, 6.86641112e-02f, 1.68572608e-02f, 5.27207628e-02f, -9.71070230e-02f,
  -4.03896756e-02f, 7.25080147e-02f, 4.91089225e-02f, -3.81620713e-02f, -6.15519546e-02f, 5.47886454e-03f, -5.36759198e-02f, 4.37197313e-02f, 1.07189745e-03f, -4.03933972e-02f,
  -2.67321127e-03f, 4.83349431e-03f, 1.74144022e-02f, -3.78723890e-02f, -6.29724562e-02f, 4.35470976e-02f, -6.55258521e-02f, -2.45119594e-02f, 8.80002007e-02f, 2.55314466e-02f,
  -4.30933386e-02f, 2.10523568e-02f, -9.98720992e-03f, 9.02943164e-02f, 4.34687920e-02f, -2.42580045e-02f, 2.02058889e-02f, -8.90439600e-02f, -5.52791022e-02f, 2.12502517e-02f,
  3.86746168e-01f, 3.44324410e-02f, 3.35274301e-02f, 1.98298082e-01f, -3.84517014e-03f, 5.95182143e-02f, 1.28128320e-01f, -2.51384377e-02f, 3.14466238e-01f, -6.21184707e-02f,
  -7.53892511e-02f, 1.45769000e-01f, -4.75939885e-02f, 1.44959092e-01f, 2.08077580e-01f, -1.16017519e-03f, 1.41052723e-01f, 9.45629776e-02f, 1.34475380e-01f, 7.12605417e-02f,
  4.79756817e-02f, -1.34272307e-01f, -1.59545481e-01f, -2.54247814e-01f, 3.78861725e-02f, -5.16131520e-02f, -2.44036585e-01f, -1.78076148e-01f, -8.75834972e-02f, -1.29637569e-01f,
  8.61968324e-02f, 1.17845938e-01f, -2.90958956e-03f, 2.34795604e-02f, -2.67444216e-02f, -1.00945551e-02f, 8.23350623e-03f, -9.02818069e-02f, 2.99344156e-02f, 3.06207966e-03f,
  4.54695076e-02f, -2.96493713e-02f, -2.97123566e-02f, 5.63713983e-02f, 2.95142494e-02f, 5.46338083e-03f, 4.63214144e-02f, -1.57643296e-02f, 1.67326368e-02f, 1.42902397e-02f,
  7.25886971e-02f, 4.99128830e-03f, 4.21279706e-02f, -1.93563532e-02f, 1.62371211e-02f, -1.67973079e-02f, 1.58792231e-02f, 4.83495593e-02f, 1.22868235e-03f, 1.19368406e-02f,
  3.62311751e-02f, -3.50214727e-03f, -8.09066743e-02f, 6.24146592e-03f, 1.34296166e-02f, -6.88207671e-02f, 1.97992567e-02f, -5.46080209e-02f, 5.58052696e-02f, 5.23284711e-02f,
  -2.02544499e-02f, 2.78346171e-03f, 5.89793622e-02f, 4.79840711e-02f, 2.76508438e-03f, 4.85264584e-02f, 1.03013525e-02f, -3.94798182e-02f, 2.81437822e-02f, 1.13563258e-02f,
  -7.84890633e-03f, 6.50534872e-03f, -5.61189912e-02f, 3.04087363e-02f, -5.64483032e-02f, -2.10367721e-02f, -1.02166804e-02f, 6.38474151e-02f, -2.06064992e-02f, 3.34330052e-02f,
  -6.04622252e-02f, -3.04045994e-02f, 1.13375625e-02f, 2.91035287e-02f, -2.00061910e-02f, 2.28037704e-02f, -3.11088469e-02f, 7.48014301e-02f, -2.98338868e-02f, 5.14262309e-03f,
  -3.23114172e-03f, -2.26253830e-02f, -5.07900724e-03f, -3.06940638e-02f, -2.96873786e-02f, -1.84149705e-02f, -9.85960593e-04f, -1.81184821e-02f, -5.66742308e-02f, 2.51332521e-02f,
  -6.79564476e-02f, 2.66338233e-02f, -9.28394590e-03f, -5.03784157e-02f, -3.94858941e-02f, 2.25869659e-03f, -3.48477848e-02f, -5.11884503e-02f, -1.58674419e-02f, 7.15580508e-02f,
  3.13017294e-02f, 2.15130262e-02f, 6.62750751e-02f, -2.07991108e-01f, 1.42976090e-01f, -8.03590342e-02f, -1.39646783e-01f, 3.79758514e-02f, 5.10606058e-02f, -2.15747692e-02f,
  -9.03297216e-02f, 5.78735173e-02f, -1.14157930e-01f, -2.05492467e-01f, -2.65404761e-01f, -9.17010382e-02f, -2.64816761e-01f, -2.24814549e-01f, 9.61233452e-02f, 2.12405194e-02f,
  -8.48228484e-02f, -1.16417080e-01f, -2.03745425e-01f, 1.19146109e-01f, 5.22738434e-02f, 1.07540078e-01f, -1.49661705e-01f, 9.99249220e-02f, -7.02880397e-02f, -5.57985380e-02f,
  2.30737533e-02f, -3.47995274e-02f, -4.28481400e-02f, 4.87234592e-02f, -7.01414049e-02f, -5.43219447e-02f, -6.51775897e-02f, -5.96088544e-02f, -2.92669726e-03f, 1.45470584e-02f,
  3.23740728e-02f, 6.90941513e-02f, -2.64800079e-02f, 1.90664977e-02f, 1.02755576e-02f, 6.70229048e-02f, 3.98726799e-02f, 6.65796772e-02f, 2.84450445e-02f, -2.07017567e-02f,
  4.71712574e-02f, -4.96488903e-03f, -2.29519196e-02f, -1.98989436e-02f, 4.30793688e-02f, -7.64540955e-02f, -3.56702320e-02f, -5.19332429e-03f, -5.34708984e-02f, -5.68191223e-02f,
  -8.14784393e-02f, 6.49009869e-02f, 2.58937161e-02f, -4.42742668e-02f, 2.42514946e-02f, -7.64485970e-02f, -1.44177293e-02f, 1.73052400e-02f, -1.47099979e-02f, -4.32558991e-02f,
  -3.73426862e-02f, 1.84278730e-02f, -8.10847897e-03f, -4.34023701e-02f, -2.50729080e-02f, -7.54987374e-02f, -5.33323698e-02f, -1.15291709e-02f, 4.40318920e-02f, -2.40710787e-02f,
  -5.07596508e-02f, 5.12728803e-02f, -1.38804391e-02f, -7.11887032e-02f, -3.61080021e-02f, -3.79674248e-02f, 1.11886514e-02f, 9.62863676e-03f, -2.33629812e-02f, -4.23453636e-02f,
  -2.04966247e-01f, -1.08387128e-01f, -2.26667263e-02f, 4.15866002e-02f, -8.20283145e-02f, 8.99951532e-03f, 7.19731022e-03f, 5.96571565e-02f, 1.52248843e-02f, 6.14975020e-02f,
  -7.79498834e-03f, 1.20562408e-02f, -7.36024417e-03f, 4.63659652e-02f, -7.98448175e-02f, -8.79584849e-02f, -1.23334028e-01f, 5.51078003e-03f, -4.98273969e-02f, 3.18263136e-02f,
  3.89936678e-02f, -9.82092787e-03f, 2.30759121e-02f, -3.22928876e-02f, -3.54582183e-02f, 1.16408709e-02f, 6.19314127e-02f, 2.06305292e-02f, 1.34990718e-02f, 2.51334831e-02f,
  -3.86649162e-01f, 8.53703916e-02f, -2.55543645e-02f, -2.48175696e-01f, 5.15990704e-02f, 5.64139485e-02f, 3.86925787e-02f, 2.00361051e-02f, 7.20714405e-02f, 1.16068341e-01f,
  -1.54927373e-01f, -7.63828866e-03f, 3.35670151e-02f, -1.51679248e-01f, -3.22128028e-01f, 1.17656626e-01f, -1.19224489e-01f, 4.86392565e-02f, 4.72495705e-02f, -8.00440535e-02f,
  -1.36638775e-01f, -1.66863188e-01f, -1.45974562e-01f, -6.27879575e-02f, -1.54236695e-02f, -2.78715324e-02f, -1.68128490e-01f, 4.34534214e-02f, -1.24549277e-01f, -5.91206923e-02f,
  -1.36747107e-01f, -5.21294512e-02f, -3.30429152e-02f, 6.16699383e-02f, -4.80741188e-02f, 2.55701095e-02f, 5.27545847e-02f, -5.85371628e-02f, 5.97847952e-03f, -1.69465318e-02f,
  4.69120443e-02f, -2.90204901e-02f, -3.15037440e-03f, 1.66029781e-02f, 8.26047659e-02f, 9.93267051e-04f, 1.78186484e-02f, 2.56033000e-02f, 7.93205691e-05f, 9.30974819e-03f,
  -1.55204581e-02f, -8.35597441e-02f, 2.54125819e-02f, 3.27724889e-02f, -3.84001583e-02f, 5.05914092e-02f, 4.54779938e-02f, -2.74002533e-02f, 2.67465282e-02f, -7.90474415e-02f,
  2.42200475e-02f, 6.36730168e-04f, -3.75701375e-02f, -3.22430879e-02f, -1.42678335e-01f, -2.33964138e-02f, 3.62053737e-02f, 8.29156395e-03f, 2.34037247e-02f, -2.22183485e-02f,
  -3.41127068e-02f, -5.94420508e-02f, 7.34588923e-03f, 4.48170155e-02f, 7.19820010e-03f, -3.46474648e-02f, 6.90253004e-02f, 1.11204144e-02f, -7.74125569e-04f, -6.13227785e-02f,
  2.50902027e-02f, -4.29099016e-02f, -1.11854948e-01f, 2.45137531e-02f, 1.69983003e-02f, -4.12298553e-02f, -4.14203182e-02f, -5.78857120e-03f, 2.14152467e-02f, -4.56577614e-02f,
  1.11209983e-02f, -6.78927749e-02f, 8.89529567e-03f, -8.71095248e-03f, 4.07220498e-02f, 5.28112948e-02f, 6.75031021e-02f, 1.57018006e-02f, -1.07931532e-02f, 1.17264548e-02f,
  5.82906641e-02f, -9.21480008e-04f, 4.33118120e-02f, -3.39654721e-02f, -3.53220552e-02f, -3.04009542e-02f, -5.75157143e-02f, -2.64466591e-02f, -6.48600049e-03f, -9.27225873e-02f,
  9.29233525e-03f, 8.98486469e-03f, 1.88101120e-02f, 5.92565052e-02f, 3.15011777e-02f, 1.75461490e-02f, 1.83333326e-02f, 1.23487450e-02f, 2.69141211e-03f, 5.76770678e-02f,
  -2.45484203e-01f, -1.23842120e-01f, -3.50194663e-01f, 1.91068202e-02f, -1.11612692e-01f, -1.42145827e-01f, -1.37558177e-01f, -2.43012886e-02f, -2.76430160e-01f, 2.11910233e-01f,
  1.22503258e-01f, -1.67597905e-01f, 1.05441645e-01f, 6.66760653e-02f, -1.59677058e-01f, -2.91592581e-03f, -8.82990286e-02f, 1.39373792e-02f, -1.52575463e-01f, 1.30396392e-02f,
  -6.12959862e-02f, 2.36045569e-01f, -1.01213031e-01f, 1.53918937e-01f, -5.53817078e-02f, -4.22617905e-02f, 2.46635169e-01f, -7.15544522e-02f, 7.56975412e-02f, -3.00448090e-02f,
  -1.09793521e-01f, -4.00341721e-03f, -8.81255791e-03f, -4.94302176e-02f, 2.06177821e-03f, -3.84383835e-02f, -2.01789886e-02f, -1.65444724e-02f, -3.92822810e-02f, -5.25320880e-02f,
  -1.91389676e-02f, -1.14833014e-02f, -2.25956962e-02f, 2.66093351e-02f, -1.15703978e-01f, -4.87135053e-02f, -9.89281163e-02f, -8.44323561e-02f, -4.02764119e-02f, -1.04655713e-01f,
  -9.73201469e-02f, -7.90994465e-02f, 2.80392282e-02f, -1.92531683e-02f, -9.80889425e-02f, -1.00073619e-02f, 3.18963043e-02f, -3.80327813e-02f, -5.86951040e-02f, -8.44009221e-02f,
  2.25141104e-02f, -5.15408292e-02f, 5.17103001e-02f, -1.44799314e-02f, 5.43856546e-02f, 3.36816013e-02f, 1.92985889e-02f, 5.52759990e-02f, -5.72820082e-02f, 6.92633092e-02f,
  1.62976626e-02f, -3.07088392e-03f, -9.52739920e-03f, -4.38224636e-02f, 3.62316370e-02f, 4.81903134e-03f, -2.81663761e-02f, 4.85542230e-02f, -5.35599291e-02f, -3.01804971e-02f,
  3.00955065e-02f, -3.15963253e-02f, 6.83799833e-02f, 7.69372005e-03f, -4.22215946e-02f, 2.26648413e-02f, 3.88761720e-04f, 8.11725855e-04f, 8.73614661e-03f, 1.28911240e-02f,
  1.38644189e-01f, 1.07970357e-01f, 6.42864406e-02f, 1.97654422e-02f, 1.97272580e-02f, 7.26652592e-02f, 9.09252185e-03f, 3.38080302e-02f, -2.99011748e-02f, 2.24000737e-02f,
  3.10147442e-02f, 1.90388579e-02f, -3.44819091e-02f, -3.61433886e-02f, -1.75208133e-02f, 3.91064920e-02f, 3.98839749e-02f, 4.21183445e-02f, -3.23056094e-02f, 4.93539833e-02f,
  2.77978387e-02f, 7.76761845e-02f, -2.50659436e-02f, -1.73082277e-02f, 9.97207388e-02f, -3.49838920e-02f, -4.89003100e-02f, -4.88211177e-02f, 3.44038568e-03f, -9.63204727e-03f,
  3.99807515e-03f, -2.17214182e-01f, -1.20227434e-01f, -1.66358382e-01f, 1.99522868e-01f, 2.21147805e-01f, 8.38884562e-02f, -1.08275443e-01f, -6.28459752e-02f, -2.60224909e-01f,
  4.47457694e-02f, -1.71984330e-01f, -5.42173684e-02f, 2.85344198e-02f, 2.20158994e-01f, 1.39954492e-01f, 1.38266072e-01f, -1.01530761e-01f, 7.79092684e-02f, -1.25761852e-01f,
  9.17945057e-02f, 1.07035771e-01f, 9.51870382e-02f, 5.10824732e-02f, 2.27615070e-02f, -6.85740635e-02f, 1.19393831e-02f, 3.63604538e-02f, -4.30401750e-02f, 1.37551859e-01f,
  4.15245593e-02f, -3.82080153e-02f, -3.80239151e-02f, 2.30134372e-02f, -3.17189731e-02f, 4.58381101e-02f, 2.11490169e-02f, 3.15040536e-02f, -2.51421966e-02f, -4.12454978e-02f,
  -5.19763082e-02f, -4.28471752e-02f, 7.72703253e-03f, 5.67700900e-02f, 6.88249916e-02f, -8.09232965e-02f, 2.19780728e-02f, -3.67403105e-02f, -6.11330792e-02f, 4.49857973e-02f,
  -3.33863357e-03f, -2.72288341e-02f, -3.18678692e-02f, 2.00418234e-02f, 3.08416318e-02f, -1.45972976e-02f, -3.07284892e-02f, -9.01636481e-02f, -4.13908847e-02f, 2.50984300e-02f,
  -1.39870821e-02f, -1.21424524e-02f, 3.93074378e-02f, -3.78464013e-02f, -2.59094294e-02f, 4.36656503e-03f, 4.95501421e-02f, 4.34149653e-02f, -3.97172160e-02f, 3.01459040e-02f,
  -6.24234267e-02f, -5.60033619e-02f, -4.29636054e-02f, -7.86359161e-02f, -6.35473654e-02f, -4.69064750e-02f, -1.32428603e-02f, -8.20906982e-02f, 9.29456204e-03f, -1.05545772e-02f,
  2.47688666e-02f, 3.28669362e-02f, -8.20063949e-02f, 5.81312692e-03f, 1.74943954e-02f, -2.59895548e-02f, -6.29620776e-02f, -8.19497630e-02f, -2.10598647e-03f, 3.06392722e-02f,
  -5.40645933e-03f, -2.35421181e-01f, -8.08809325e-02f, -4.91925441e-02f, -7.31485561e-02f, 2.88005229e-02f, 3.92613299e-02f, -9.29064676e-02f, -6.03894144e-03f, 6.02865852e-02f,
  4.66935672e-02f, -1.27094891e-03f, 7.00683612e-03f, -1.50329270e-03f, -6.71881512e-02f, 8.07058290e-02f, -4.88381796e-02f, 2.25704741e-02f, -1.65728647e-02f, -4.54326570e-02f,
  -1.31871784e-03f, 1.56658646e-02f, -7.27356528e-04f, -4.43739556e-02f, -2.96866279e-02f, -2.96701584e-02f, 4.98701371e-02f, 4.91463691e-02f, -1.60799976e-02f, -6.07450912e-03f,
  -2.24414513e-01f, 6.16979226e-02f, -1.63204372e-02f, -5.21841124e-02f, -9.07640159e-02f, -5.57630733e-02f, -1.26964852e-01f, -5.54690808e-02f, 9.80029330e-02f, -9.10253748e-02f,
  -4.82147513e-03f, 5.02629988e-02f, 6.08518422e-02f, -1.13824412e-01f, -2.00019166e-01f, 7.69037157e-02f, -1.38512909e-01f, -5.98585978e-02f, 1.13826647e-01f, -1.57157212e-01f,
  -7.74469003e-02f, -4.38789241e-02f, 2.99664382e-02f, -1.12506244e-02f, -1.33193180e-01f, 9.01508778e-02f, -2.25785226e-02f, 1.35213345e-01f, -1.03309527e-01f, -2.45715980e-03f,
  4.39019911e-02f, 9.44366679e-03f, -3.89271788e-02f, 4.56996597e-02f, -4.07613739e-02f, -4.60563414e-02f, 1.73538681e-02f, 7.88983926e-02f, -3.34261768e-02f, -9.97799542e-03f,
  -7.54108056e-02f, 5.49585856e-02f, 3.63978446e-02f, 4.15162332e-02f, 5.26136160e-03f, 6.06268495e-02f, 5.89781553e-02f, 5.88266598e-03f, 1.08617991e-02f, -9.74006280e-02f,
  -2.93689184e-02f, 7.57502532e-03f, -4.10660505e-02f, 3.33424658e-02f, 2.80039832e-02f, -3.45392972e-02f, 2.88938824e-02f, 1.74944140e-02f, 3.11687309e-02f, 5.74833751e-02f,
  -3.04772183e-02f, -5.24366982e-02f, 8.64512101e-03f, -2.26468854e-02f, 2.20043398e-02f, 6.72708526e-02f, -2.68349256e-02f, -4.71912734e-02f, -2.57346593e-02f, -1.22712096e-02f,
  6.58630673e-03f, -4.49784175e-02f, 2.01020073e-02f, -7.19003007e-02f, -8.38820711e-02f, 5.23513295e-02f, -3.14080194e-02f, 5.03776558e-02f, 2.56053042e-02f, 1.51505070e-02f,
  9.40128714e-02f, -1.89387575e-02f, 6.45205453e-02f, -4.23497856e-02f, -2.01495178e-02f, -7.45070924e-04f, -5.90091050e-02f, -2.49232780e-02f, -2.21319590e-02f, 6.90695888e-04f,
  -8.48898739e-02f, 9.38156247e-02f, 1.06339790e-01f, -3.27762254e-02f, 9.23707187e-02f, -7.98374936e-02f, 3.69254723e-02f, -7.79839009e-02f, 3.30345370e-02f, -4.45040688e-02f,
  -1.22257203e-01f, -6.35612011e-02f, -8.78801662e-03f, 2.51046456e-02f, 4.12270166e-02f, -7.80262798e-02f, 2.41232645e-02f, 3.89810875e-02f, -6.97364286e-02f, 2.45443173e-02f,
  -6.14975691e-02f, 3.04443240e-02f, -1.28668286e-02f, 4.64397669e-02f, -1.45026119e-02f, -7.28008384e-03f, 4.01374977e-03f, -2.35693641e-02f, -3.04494593e-02f, -1.11120800e-02f,
  1.10279448e-01f, 7.67004117e-02f, -1.66025013e-01f, 1.70124471e-02f, -6.74980730e-02f, 5.63486293e-02f, 8.60529095e-02f, -5.76693639e-02f, -4.26365994e-02f, 2.66065806e-01f,
  5.99201098e-02f, 6.98503703e-02f, 7.58035257e-02f, 2.10956350e-01f, 1.46137148e-01f, 1.49210036e-01f, 1.07272081e-01f, 1.79397672e-01f, -1.05545603e-01f, 1.31377652e-01f,
  -9.82690044e-03f, 1.29320607e-01f, -1.45480469e-01f, -1.35730077e-02f, 2.09411681e-02f, -2.47443229e-01f, 3.38821858e-03f, -2.03286961e-01f, -1.21417537e-01f, -1.26783296e-01f,
  -6.83137476e-02f, 8.72874819e-03f, -4.37938701e-03f, -3.44821177e-02f, -5.28070144e-02f, 2.43608374e-04f, 6.23568408e-02f, 3.40234442e-03f, -2.80766804e-02f, -3.79978679e-02f,
  4.98434193e-02f, 1.13011179e-02f, 5.34594059e-02f, 2.98489537e-03f, -5.65285515e-03f, -6.50247931e-02f, -1.05103709e-01f, -5.69959357e-02f, -5.59100211e-02f, -2.82608811e-02f,
  -6.28044829e-02f, 3.78965251e-02f, -2.47668829e-02f, -1.63542591e-02f, -1.23840407e-03f, 2.52854265e-02f, 1.00275196e-01f, -7.62801692e-02f, -1.06983054e-02f, 8.58823955e-02f,
  5.19545637e-02f, -5.91933429e-02f, 1.61010269e-02f, -3.10576856e-02f, 5.59525448e-04f, 5.21968678e-03f, -4.75856615e-03f, 1.75789725e-02f, -6.87112659e-02f, -1.48318289e-03f,
  7.48569658e-03f, 1.29979951e-02f, -2.13580094e-02f, 2.96174455e-02f, 7.53802285e-02f, -2.14792285e-02f, 7.11634979e-02f, -3.20708789e-02f, -3.92504316e-03f, -2.22111214e-02f,
  2.19366532e-02f, 2.04401668e-02f, -7.20569678e-03f, -4.21661772e-02f, 9.40649584e-03f, 1.73049215e-02f, 2.54114512e-02f, -8.42543598e-03f, -3.29336859e-02f, 7.10074510e-03f,
  2.26636119e-02f, 1.09989703e-01f, -5.71605489e-02f, 6.27970248e-02f, 3.27816643e-02f, 1.09412618e-01f, -6.99027150e-05f, 1.98342502e-02f, -2.28328183e-02f, 6.61252290e-02f,
  -3.11890747e-02f, -5.17055951e-02f, 4.77353632e-02f, -9.73268785e-03f, -2.30340436e-02f, 3.53010260e-02f, 1.05911598e-01f, 9.81426314e-02f, 8.40989314e-03f, -1.35968821e-02f,
  -1.88138541e-02f, -1.09491106e-02f, 2.94189714e-02f, 2.69316416e-02f, 4.49305847e-02f, -9.93228611e-03f, 1.68735031e-02f, -9.94998813e-02f, -3.76015343e-02f, -2.82623433e-02f,
  2.82331586e-01f, -2.49334544e-01f, 1.47442684e-01f, -1.35344267e-01f, 1.23434007e-01f, -6.31683767e-02f, -2.45371908e-01f, 2.19116416e-02f, 1.90827716e-02f, -2.07074031e-01f,
  -9.32566300e-02f, 7.03404192e-04f, -3.84434909e-02f, -2.94691503e-01f, -1.33075997e-01f, -1.86931863e-01f, -1.94653094e-01f, -1.08723929e-02f, -4.73302789e-04f, 6.31885007e-02f,
  8.08064118e-02f, -1.22845158e-01f, -3.28079797e-02f, 3.55212577e-02f, -6.88712671e-02f, 1.43000176e-02f, 1.98516939e-02f, 2.82797553e-02f, -1.55330390e-01f, -1.62176490e-01f,
  3.53541374e-02f, 1.80143178e-01f, 7.73704574e-02f, 2.57228706e-02f, 8.00297037e-03f, 5.18774800e-02f, -4.45583574e-02f, -4.04420979e-02f, 6.65370449e-02f, -3.25654857e-02f,
  3.85015309e-02f, -2.95338198e-03f, -1.41986767e-02f, 3.64464745e-02f, -5.71287563e-03f, 2.65521575e-02f, -8.20773374e-03f, -3.78714576e-02f, -4.84141856e-02f, -3.60184871e-02f,
  3.59052420e-02f, -1.68860201e-02f, 4.22297791e-02f, -1.02950767e-01f, 7.37791136e-02f, 4.76175845e-02f, -4.04642522e-02f, -6.82166144e-02f, -1.58375744e-02f, 4.36644852e-02f,
  7.08817095e-02f, -9.60697699e-03f, -2.56387871e-02f, 5.12732100e-03f, -3.06705888e-02f, 2.22096629e-02f, -1.57134440e-02f, -6.50767889e-03f, -2.53267456e-02f, 3.02563328e-02f,
  -9.61607962e-04f, 1.92738622e-02f, 7.18447044e-02f, 3.33275944e-02f, 1.04372874e-01f, -6.13661446e-02f, 7.58638531e-02f, -3.52141485e-02f, -1.91429816e-02f, 5.03172204e-02f,
  3.39887962e-02f, -4.71762531e-02f, 2.50075683e-02f, 1.77186430e-02f, -7.33847246e-02f, -4.19045165e-02f, 5.24013303e-03f, 4.57617734e-03f, 8.37722514e-03f, 6.05150349e-02f,
  -1.20449543e-01f, 1.37729256e-03f, 2.73341332e-02f, -5.34910820e-02f, -7.29892775e-03f, -5.91609590e-02f, 2.18652259e-03f, 3.06647760e-03f, -8.12191963e-02f, 2.60479879e-02f,
  -3.32171135e-02f, 3.62629779e-02f, -6.21143207e-02f, -4.11378853e-02f, -1.88550968e-02f, 8.92139692e-03f, -1.16532296e-02f, 5.95818907e-02f, 4.34802733e-02f, 4.69207112e-03f,
  -5.71360923e-02f, 4.61067222e-02f, 1.66995153e-02f, 2.25544982e-02f, 2.55412646e-02f, -2.80384142e-02f, 4.43327837e-02f, 4.86458205e-02f, -1.09967794e-02f, -5.95228970e-02f,
  -8.04484915e-03f, -9.32486914e-03f, -6.38195723e-02f, -1.04588456e-02f, 8.88840109e-02f, 6.59110472e-02f, 1.00097977e-01f, 9.06817466e-02f, -5.39415516e-02f, 1.37751987e-02f,
  1.76140055e-01f, -2.48089224e-01f, -2.11365465e-02f, 1.19956292e-01f, 2.52113845e-02f, 5.76990359e-02f, 1.64754480e-01f, -6.42354712e-02f, -8.87067765e-02f, 2.37033907e-02f,
  8.16630721e-02f, 2.21544504e-01f, -2.92615360e-03f, 1.56896546e-01f, 2.41887774e-02f, -7.54888505e-02f, -7.87891913e-03f, 7.47888759e-02f, -7.32609332e-02f, -9.62988213e-02f,
  9.20739993e-02f, 2.78591439e-02f, 1.95593033e-02f, 1.40931038e-02f, 3.15758176e-02f, 4.13660407e-02f, -6.82131425e-02f, -1.53359994e-02f, 3.10761500e-02f, -3.84277627e-02f,
  -6.02063909e-02f, 2.63134036e-02f, -1.52009504e-03f, -4.94759530e-02f, -5.43032214e-03f, 4.19340748e-03f, 1.49201173e-02f, -5.46521693e-03f, 4.66645136e-02f, -2.52944808e-02f,
  4.96004373e-02f, 1.08319893e-02f, 4.84396145e-02f, -8.77755880e-02f, -4.41290922e-02f, -2.55301949e-02f, -5.93908466e-02f, 8.66912771e-04f, -3.79643627e-02f, 1.07707568e-02f,
  5.00709526e-02f, -2.91538704e-03f, 1.61017962e-02f, 6.11626692e-02f, -3.48496363e-02f, -4.72819731e-02f, -2.10330393e-02f, 2.03659963e-02f, -1.78827476e-02f, 4.53185700e-02f,
  -3.45052369e-02f, 4.32297401e-02f, 6.40827194e-02f, 6.24016486e-02f, -3.13461721e-02f, 4.29082923e-02f, 4.37081791e-02f, 2.63928268e-02f, 4.68206741e-02f, -4.95347828e-02f,
  -2.55190907e-03f, -4.22319844e-02f, 1.51598724e-02f, -2.06528883e-02f, -3.13629657e-02f, 5.59557928e-03f, 5.86695410e-02f, -3.61425690e-02f, 5.42536527e-02f, 3.88852321e-02f,
  -9.68413502e-02f, -1.56470880e-01f, 4.41541560e-02f, 6.18304498e-03f, 2.41253860e-02f, -3.96543853e-02f, 5.57735190e-03f, 1.97403040e-02f, -2.98007503e-02f, -2.43675970e-02f,
  2.02931277e-02f, 8.65754089e-04f, 1.24489525e-02f, 5.21508418e-02f, -5.70033006e-02f, -6.17452301e-02f, -3.28710005e-02f, -1.00137722e-02f, -4.04905789e-02f, 2.10064165e-02f,
  2.45349272e-03f, -1.75626483e-02f, 2.81253476e-02f, 5.87029234e-02f, -2.14973614e-02f, 2.68982239e-02f, -6.08491376e-02f, -9.66229737e-02f, 1.24035748e-02f, -6.02756590e-02f,
  -1.37699679e-01f, 6.20255321e-02f, 1.65353611e-01f, -7.95267150e-02f, -1.02324903e-01f, 1.66027188e-01f, 1.62770912e-01f, -1.03519373e-01f, -1.17479622e-01f, -2.46732812e-02f,
  1.30739631e-02f, 1.17022463e-03f, 9.62608233e-02f, 8.36988986e-02f, 2.16872483e-01f, 1.98508203e-01f, -2.09998386e-03f, -5.85978571e-03f, -8.66763666e-02f, -3.68384868e-02f,
  -7.84055591e-02f, -3.08863185e-02f, 2.26336092e-01f, -5.54379299e-02f, 2.68632416e-02f, -1.23493606e-02f, -1.11876532e-01f, -2.52659898e-02f, 1.86323449e-02f, 3.71885076e-02f,
  -2.80783307e-02f, -1.70683354e-01f, 2.75667701e-02f, 3.71057093e-02f, 2.14484055e-02f, 3.04117333e-04f, 4.11354974e-02f, 3.89015116e-02f, 1.77821275e-02f, -9.36517143e-04f,
  -4.46277671e-02f, 7.27114081e-02f, 4.62594815e-02f, -2.48335879e-02f, -6.52003288e-02f, 6.99282438e-02f, -5.02141751e-02f, 1.51406983e-02f, -1.32939573e-02f, -3.91967557e-02f,
  1.21446081e-01f, 9.48531404e-02f, -1.49118304e-02f, -4.46289545e-03f, -4.55216169e-02f, 2.64994930e-02f, 8.05833563e-02f, 5.69790602e-02f, 4.20404598e-02f, -2.64715627e-02f,
  -1.15438725e-03f, 2.13581114e-03f, 5.07717999e-03f, -5.42946570e-02f, -2.07350906e-02f, -2.03009918e-02f, 3.06176897e-02f, 3.89165543e-02f, 2.47388911e-02f, 2.36605816e-02f,
  4.74511385e-02f, -6.13250285e-02f, -9.13973339e-03f, 4.89247218e-02f, -1.20057641e-02f, -7.73944855e-02f, -1.92875899e-02f, -5.45643782e-03f, 1.71153229e-02f, -9.04514641e-03f,
  4.31871675e-02f, 1.08702807e-02f, 8.43887683e-03f, 6.98548034e-02f, 5.64193428e-02f, -5.35838343e-02f, -5.76752760e-02f, -1.45147601e-02f, -1.09078549e-02f, -7.05448736e-04f,
  -8.59844536e-02f, -1.42308071e-01f, 2.23434437e-02f, -4.57473993e-02f, -2.24372372e-02f, 3.64621589e-03f, 1.40157016e-03f, -5.76656871e-03f, -2.04036646e-02f, -1.50330202e-03f,
  2.44085100e-02f, -8.94756150e-03f, 1.98434554e-02f, -6.90218508e-02f, 5.91236092e-02f, -3.10131181e-02f, 4.94373664e-02f, -2.24166848e-02f, 2.05927044e-02f, -3.97180999e-03f,
  2.15209909e-02f, -1.11391013e-02f, 7.34903663e-02f, -5.09502590e-02f, 4.05883007e-02f, -5.36986180e-02f, -4.20073494e-02f, -1.27473474e-02f, 1.84472166e-02f, 6.87559023e-02f,
  3.23073536e-01f, -1.53070971e-01f, -4.39956086e-03f, -6.31305054e-02f, 4.76570241e-02f, 1.27487227e-01f, -1.05901293e-01f, 1.00261522e-02f, -1.54535636e-01f, -4.86703217e-02f,
  3.97915691e-02f, -5.74564449e-02f, -1.29111901e-01f, -2.46731937e-02f, -2.46335268e-02f, -1.04267120e-01f, 6.88585863e-02f, 6.08068146e-02f, 6.53317617e-03f, -8.02915394e-02f,
  5.67304902e-02f, 8.58688075e-03f, -1.17580732e-02f, 4.27866057e-02f, 1.20672382e-01f, 9.08284485e-02f, 2.26234645e-02f, -7.47490451e-02f, 4.49481308e-02f, 5.38839325e-02f,
  1.09751910e-01f, -7.41949081e-02f, 4.93832212e-03f, -5.17752878e-02f, 9.04001817e-02f, 6.96841255e-02f, 1.08677618e-01f, -5.45072220e-02f, -4.39500883e-02f, -4.70864150e-04f,
  -2.41915490e-02f, -7.45840603e-03f, -4.34027314e-02f, 6.87658712e-02f, -2.17476394e-02f, 4.65439521e-02f, 6.10351376e-02f, 4.03057039e-03f, -7.51127899e-02f, 5.21753244e-02f,
  3.90631147e-02f, -4.53300066e-02f, -1.21441772e-02f, -2.88209692e-02f, -4.30901125e-02f, 4.17663902e-02f, 1.67492889e-02f, 4.20545377e-02f, 7.31921494e-02f, 8.80626030e-03f,
  4.54935953e-02f, -8.87616351e-02f, -4.84019704e-02f, 1.15390252e-02f, 3.35183777e-02f, 9.38319042e-02f, -4.36706655e-02f, 1.80366880e-03f, 7.56399781e-02f, -7.03600142e-03f,
  -4.49382421e-03f, 6.56615198e-02f, -3.16030383e-02f, 2.65258830e-02f, -4.70541120e-02f, -9.52686556e-03f, -1.53072262e-02f, 7.27558285e-02f, 5.63982986e-02f, 2.49481667e-02f,
  2.47167200e-02f, 5.48019335e-02f, 4.72890064e-02f, -6.82898622e-04f, 3.46978493e-02f, -7.13572577e-02f, 5.30447438e-03f, -3.66163552e-02f, -1.99392289e-02f, -4.05168124e-02f,
  -2.75672916e-02f, -1.18741021e-01f, -5.44027872e-02f, -5.49518988e-02f, -1.80615205e-02f, 5.70307523e-02f, -6.70645982e-02f, 2.99141668e-02f, -3.52937169e-02f, -2.36204155e-02f,
  4.54230197e-02f, -1.84443016e-02f, 7.29322955e-02f, -2.23088879e-02f, 5.46104784e-05f, 1.57695860e-02f, 4.57591377e-02f, -1.07163368e-02f, -1.22983858e-03f, 4.97848429e-02f,
  -6.06993549e-02f, -3.75432260e-02f, -7.47870877e-02f, 2.52693519e-02f, 7.87399635e-02f, 1.01994518e-02f, -3.37544791e-02f, -2.99966764e-02f, 4.46629301e-02f, -3.81025821e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.57165626e-02f, -3.32728475e-02f, -1.17411554e-01f, -9.14143398e-03f, 7.01616630e-02f, 8.46269205e-02f, 5.06518036e-02f, 1.06117867e-01f, 8.06607679e-02f, -6.75382279e-03f,
  1.11550622e-01f, -1.06699765e-01f, 1.87810771e-02f, 7.81623498e-02f, 6.16110722e-03f, -8.15619379e-02f, 3.51906419e-02f, 1.18650362e-01f, -4.93685380e-02f, -5.66776693e-02f,
  -4.44744006e-02f, 1.85280874e-01f, -1.05518773e-01f, 1.13650404e-01f, 7.98348859e-02f, -1.14578858e-01f, 2.43593194e-02f, -8.46652314e-02f, -2.47928016e-02f, 6.60432652e-02f,
  5.20069189e-02f, -9.59892794e-02f, 3.31386295e-03f, -1.96267292e-02f, -1.20640628e-01f, 2.56275944e-02f, -6.37211204e-02f, -8.03079903e-02f, -5.21724112e-02f, -1.10097826e-01f,
  2.71530319e-02f, -8.29561353e-02f, -1.21338535e-02f, 5.53599931e-02f, -7.48945028e-03f, -6.83180615e-02f, 4.11106497e-02f, -4.33905004e-03f, -9.57031548e-02f, -1.01668984e-01f,
  -6.64031692e-03f, -8.69627744e-02f, -7.67052826e-03f, 3.68619375e-02f, 5.49533963e-02f, -6.44647926e-02f, -4.30717319e-02f, -9.94066820e-02f, 5.40059097e-02f, 2.78357230e-02f,
  -1.96907986e-02f, 2.93405615e-02f, -3.17210630e-02f, 5.84862903e-02f, 9.77052748e-03f, -7.69072399e-03f, 4.40060943e-02f, -5.20925224e-02f, 2.47424804e-02f, 8.06489810e-02f,
  -3.97853218e-02f, -6.03799783e-02f, -4.14400212e-02f, 8.42363108e-03f, 4.11799140e-02f, 8.24576020e-02f, 2.56093889e-02f, 6.92613050e-02f, -3.02198585e-02f, -7.00368583e-02f,
  6.66706488e-02f, 6.57572597e-02f, -5.48627786e-02f, 1.71798456e-03f, -3.13796382e-03f, -6.31724522e-02f, 6.41398728e-02f, 4.79623377e-02f, 5.87720890e-03f, 6.19655773e-02f,
  9.10835788e-02f, -2.85908929e-03f, -2.89165601e-02f, -1.39784925e-02f, -3.96495014e-02f, 5.17391637e-02f, 8.07838514e-03f, 3.66509072e-02f, -9.81643721e-02f, -1.05183996e-01f,
  -2.72269524e-03f, 8.64195526e-02f, 1.51973311e-02f, 6.01294935e-02f, 5.02982549e-03f, 5.16867340e-02f, -9.70411897e-02f, 6.69785440e-02f, 7.27568343e-02f, -6.11208491e-02f,
  6.87742755e-02f, 1.14253135e-02f, 6.15890138e-02f, -6.22276925e-02f, -5.39994426e-02f, 2.76523829e-02f, 4.90962267e-02f, 2.91434713e-02f, 9.22734663e-02f, 3.29751782e-02f,
  2.07226202e-01f, -6.36736155e-02f, 1.79671749e-01f, 5.54435775e-02f, 1.53274117e-02f, -5.39814942e-02f, -4.89044515e-03f, -4.17209417e-02f, -6.50650188e-02f, -3.10490429e-02f,
  -4.55927523e-03f, 1.48128821e-02f, -5.74295521e-02f, 6.63604364e-02f, -1.27560630e-01f, -1.92993164e-01f, 1.30814295e-02f, -1.10547498e-01f, 4.42033447e-03f, -4.73673120e-02f,
  -2.32818276e-02f, -2.36532814e-03f, 5.37767932e-02f, 4.99645211e-02f, 1.55958354e-01f, 1.44987717e-01f, -3.74967270e-02f, 5.16017526e-03f, 2.85017323e-02f, 6.48963824e-02f,
  5.46214022e-02f, -5.12586683e-02f, 2.17728037e-02f, 4.04199399e-02f, 3.94502357e-02f, 1.04747333e-01f, 9.70926136e-02f, -5.42269126e-02f, -5.77259585e-02f, -6.37814179e-02f,
  -3.49715836e-02f, 8.41217712e-02f, 2.09381320e-02f, 5.87468483e-02f, -2.76293866e-02f, 3.36637571e-02f, -2.41060704e-02f, -6.30986597e-03f, -4.09371667e-02f, -7.41216028e-03f,
  -7.04721722e-04f, 7.40215927e-02f, 8.59274492e-02f, 8.90811533e-02f, -3.13750394e-02f, -6.11133128e-02f, 2.64366772e-02f, 1.24924250e-01f, 7.87003264e-02f, 7.93244168e-02f,
  -8.01594704e-02f, -5.38834035e-02f, 5.23240902e-02f, 2.66554598e-02f, -1.22923357e-03f, 6.55081216e-03f, -1.99287403e-02f, -6.26348332e-02f, 7.00471476e-02f, 5.62010258e-02f,
  -6.29242808e-02f, -4.16822592e-03f, -5.81793636e-02f, 1.67894773e-02f, 5.56485876e-02f, -1.51241478e-02f, 7.53162429e-02f, 8.50097684e-04f, -2.39318721e-02f, -3.48410592e-03f,
  9.75846592e-03f, -5.94904833e-02f, -9.71789733e-02f, -4.33045998e-03f, 1.26251159e-03f, -7.55277351e-02f, 3.75287677e-03f, 4.60616127e-02f, -7.99094979e-03f, 2.86442731e-02f,
  -1.23110801e-01f, -5.33464216e-02f, -1.03617221e-01f, 4.47412059e-02f, -1.41594103e-02f, 1.85885583e-03f, 1.59540568e-02f, 3.92325856e-02f, 5.77559918e-02f, -4.54644673e-02f,
  -4.86160852e-02f, -1.90776531e-02f, -3.78359146e-02f, 9.42452997e-03f, -7.46624023e-02f, -4.05014716e-02f, -3.35593373e-02f, 7.05133080e-02f, 7.27306213e-03f, 6.56123459e-02f,
  8.55787620e-02f, -6.35118503e-03f, 7.65016526e-02f, 1.11448541e-01f, 8.85690972e-02f, -2.30305903e-02f, 8.07018504e-02f, 1.01063035e-01f, 5.55618964e-02f, 5.31570949e-02f,
  1.16684094e-01f, 9.67585761e-03f, -6.61373958e-02f, -3.80233936e-02f, 6.01897389e-02f, 7.15157622e-03f, 5.68641461e-02f, 1.36797437e-02f, -3.78571227e-02f, -2.82006916e-02f,
  6.75123557e-02f, -1.31666899e-01f, -1.59203857e-01f, -2.35955223e-01f, -2.09353745e-01f, -1.75334513e-01f, -3.24621312e-02f, -4.12450060e-02f, -5.33399954e-02f, 1.26515806e-01f,
  -7.48971924e-02f, -1.22162461e-01f, -8.49208012e-02f, 3.04553360e-02f, -2.90008914e-02f, 1.91778138e-01f, 1.25346169e-01f, 1.29455850e-01f, 1.17509738e-01f, -9.79287922e-03f,
  -1.89615302e-02f, -3.21887471e-02f, -3.15307938e-02f, -6.71818778e-02f, 1.14086298e-02f, 6.45961836e-02f, 6.06244206e-02f, 2.86178500e-03f, 1.67043712e-02f, 5.41848540e-02f,
  -2.44805822e-03f, -3.58022451e-02f, -9.75702610e-03f, -5.33260740e-02f, 9.29197669e-02f, 3.28361318e-02f, 1.72915719e-02f, 4.00364883e-02f, -3.00090052e-02f, -6.35009483e-02f,
  5.31276055e-02f, -4.15449180e-02f, 1.37004495e-01f, -2.60498971e-02f, -1.84457265e-02f, 2.02227011e-02f, -1.15700411e-02f, 5.94137013e-02f, 5.06967753e-02f, 2.06548395e-03f,
  8.22151676e-02f, 4.34100777e-02f, 3.82047184e-02f, -4.10355963e-02f, 6.44251937e-03f, -3.68050998e-03f, 6.38973415e-02f, 5.31970561e-02f, -3.17738093e-02f, 2.52521709e-02f,
  6.45846874e-03f, -5.74485622e-02f, -7.24942759e-02f, 8.65890756e-02f, -3.99335939e-03f, -5.92965586e-03f, 6.44587353e-02f, 5.09222634e-02f, 4.72862385e-02f, -3.21562551e-02f,
  -7.69068152e-02f, -3.08408663e-02f, 3.15933600e-02f, 8.65892917e-02f, -9.22721401e-02f, -1.50867552e-03f, -2.79945601e-02f, 5.23863211e-02f, 8.60779488e-04f, 3.96922939e-02f,
  8.60645249e-02f, -2.57949010e-02f, -5.12145571e-02f, -8.55296552e-02f, 8.94483402e-02f, 9.66626629e-02f, -6.36755526e-02f, -2.36139465e-02f, -9.27785784e-03f, -3.88899520e-02f,
  1.21697992e-01f, 9.65051949e-02f, 5.19137383e-02f, -5.92061393e-02f, 8.53868574e-02f, -7.41910338e-02f, -5.37445918e-02f, 2.40225671e-03f, -6.24724887e-02f, -4.94294241e-02f,
  1.08274139e-01f, 8.78781378e-02f, -1.85048357e-02f, 4.97804545e-02f, -4.70866412e-02f, 7.96735510e-02f, -2.46189497e-02f, -1.29190320e-03f, -5.71095161e-02f, -5.47867641e-02f,
  1.08251333e-01f, 1.34101287e-01f, 3.05498205e-02f, 5.01604341e-02f, 4.17541713e-02f, -9.27221775e-02f, -7.42599294e-02f, 2.88479235e-02f, 5.46445064e-02f, -2.50888094e-02f,
  2.47198157e-03f, 8.54654387e-02f, -9.26811546e-02f, 7.39475116e-02f, -1.56251177e-01f, 1.35561619e-02f, 4.26672325e-02f, -1.77585464e-02f, 6.02710387e-03f, 4.37062792e-02f,
  -7.62496740e-02f, 2.66065425e-03f, -3.63695808e-02f, -7.80457705e-02f, 2.30722893e-02f, 6.49576634e-02f, 1.14538120e-02f, 5.90941310e-02f, 4.99005802e-02f, -1.38534233e-01f,
  -5.15011773e-02f, 3.95908803e-02f, -3.31220590e-02f, -2.97517851e-02f, 2.53985357e-03f, 1.08250812e-01f, -1.56579427e-02f, 2.35149674e-02f, 5.80920093e-02f, -2.82095019e-02f,
  3.66507797e-03f, 8.29346105e-02f, 9.29336436e-03f, -2.90901493e-03f, 1.00640304e-01f, 7.15940520e-02f, -1.48753787e-03f, 4.39107716e-02f, 5.97583363e-03f, -4.68731523e-02f,
  -2.54737660e-02f, 6.04200102e-02f, 7.00955242e-02f, -6.59470484e-02f, -2.84358822e-02f, -2.82745287e-02f, -5.66731393e-02f, -8.11967105e-02f, 3.21136340e-02f, -5.93822896e-02f,
  7.47162774e-02f, -8.42796545e-03f, -7.93961585e-02f, 4.79267091e-02f, 2.41243187e-02f, 4.36946973e-02f, -7.31770173e-02f, 6.31428435e-02f, 5.50184138e-02f, 1.82964765e-02f,
  -8.48573912e-03f, -8.11505318e-03f, 2.58612745e-02f, 4.97981310e-02f, 2.67413668e-02f, 2.83202641e-02f, -5.61513714e-02f, -3.21434438e-02f, 2.83830035e-02f, 6.59907758e-02f,
  -4.68157604e-02f, -4.77553234e-02f, -7.43866935e-02f, 4.83932160e-02f, -6.89013675e-02f, -1.05280057e-01f, 2.79436000e-02f, 2.24375110e-02f, 7.43252039e-02f, -3.51206609e-03f,
  5.88600561e-02f, -6.15061074e-02f, 7.25124180e-02f, -7.16055110e-02f, 7.17333406e-02f, -5.88453449e-02f, 3.48623581e-02f, 5.94673529e-02f, 6.41798675e-02f, 8.77197366e-03f,
  -2.99249720e-02f, 2.25114580e-02f, -5.84910661e-02f, 9.00417492e-02f, 2.04807688e-02f, -2.14054529e-02f, 4.91133444e-02f, -5.86062064e-03f, -3.17084119e-02f, 2.78277881e-02f,
  1.09005056e-01f, -7.02117905e-02f, -5.94716147e-03f, -4.13703285e-02f, 7.78811891e-03f, 2.38136202e-02f, -4.27351296e-02f, 8.72592442e-03f, 4.27975506e-02f, 3.44606936e-02f,
  -1.76580951e-01f, 5.65831475e-02f, -3.59547586e-04f, 1.01127401e-01f, -7.86965117e-02f, -2.28075478e-02f, -1.60223871e-01f, -2.06778627e-02f, 3.59322093e-02f, 3.86150256e-02f,
  6.34191930e-02f, -9.33509842e-02f, 8.79122913e-02f, 9.30601582e-02f, 5.34823090e-02f, 1.15583122e-01f, 2.24345066e-02f, -2.24478804e-02f, 4.35541980e-02f, -6.19937032e-02f,
  1.84838325e-02f, 6.81795627e-02f, 1.98133871e-01f, -1.58208422e-02f, -5.71180657e-02f, 1.26413926e-01f, 1.21984780e-01f, -6.70546060e-03f, -4.14981321e-02f, 6.56072497e-02f,
  -3.51006053e-02f, -4.41808477e-02f, 6.04197904e-02f, -3.65458764e-02f, -2.72686798e-02f, -2.93600131e-02f, 5.63093759e-02f, -5.09669706e-02f, -2.47075148e-02f, 7.33057261e-02f,
  -7.89316669e-02f, 4.94192354e-02f, -3.78895625e-02f, 4.87775505e-02f, -6.63453788e-02f, 6.03404976e-02f, -6.04063570e-02f, 2.71938890e-02f, -3.17919515e-02f, 3.52316089e-02f,
  -4.30294909e-02f, 8.61957073e-02f, 3.91553976e-02f, 5.35937287e-02f, 9.75544453e-02f, -6.57951534e-02f, -3.78626920e-02f, 3.68181169e-02f, -9.97375697e-03f, -5.34680784e-02f,
  -3.95951010e-02f, 3.77275087e-02f, -7.73163140e-02f, 7.01213405e-02f, 5.53111956e-02f, 4.55428138e-02f, 4.04944383e-02f, -8.59822482e-02f, -1.97356157e-02f, 6.76651194e-04f,
  -7.77534172e-02f, -4.26289663e-02f, 2.00702976e-02f, 5.14951348e-02f, 7.80311599e-03f, 6.15188926e-02f, -2.57820357e-02f, -6.84893131e-02f, -2.09663305e-02f, 8.95862104e-05f,
  4.00329717e-02f, 1.67021528e-03f, -3.47550586e-02f, -5.36079444e-02f, 5.43387122e-02f, 8.06730334e-03f, 3.87762152e-02f, -8.39622878e-03f, -7.74254557e-03f, 6.12883642e-02f,
  -2.27611735e-02f, 1.50627524e-01f, -3.98049243e-02f, -5.97000644e-02f, 9.51309800e-02f, 5.20657562e-02f, 5.14858700e-02f, 1.66483000e-02f, 4.35691252e-02f, 1.58811528e-02f,
  4.10376415e-02f, -2.80480403e-02f, -3.99961509e-02f, 7.50159398e-02f, 3.61171104e-02f, -7.16641992e-02f, 5.83719090e-02f, -1.01697054e-02f, 4.99616750e-03f, -9.71095823e-03f,
  5.06964959e-02f, 9.75853577e-03f, 5.27380332e-02f, -2.59772521e-02f, -7.64421672e-02f, -3.16366553e-02f, -4.77219634e-02f, 5.01551628e-02f, -1.73138250e-02f, -3.69848609e-02f,
  -2.00939357e-01f, 3.67619693e-02f, -1.85992550e-02f, -1.95400849e-01f, -1.21346235e-01f, -1.53752476e-01f, -2.10494772e-02f, -7.52766579e-02f, -4.04552296e-02f, 1.24936812e-01f,
  -1.62004940e-02f, 2.89744996e-02f, 1.66319117e-01f, 1.86992865e-02f, 3.20066884e-02f, 1.99974447e-01f, -1.00836523e-01f, -6.09307736e-02f, -2.96214316e-02f, -1.92987040e-01f,
  -2.30482705e-02f, -5.39314970e-02f, -4.67032976e-02f, 5.89523837e-02f, -9.40047950e-03f, 2.58361399e-02f, -4.67320457e-02f, -9.63524580e-02f, -5.20787984e-02f, 7.54158422e-02f,
  -1.05629459e-01f, -2.39493791e-02f, -8.58045667e-02f, 3.41793075e-02f, -2.91831251e-02f, -6.56858608e-02f, -8.75929222e-02f, 3.77678871e-02f, -4.48452123e-02f, -1.23975858e-01f,
  -2.70558447e-02f, 4.10087258e-02f, 5.40746264e-02f, 3.21335383e-02f, -7.81538337e-02f, -1.10962279e-01f, -4.30047587e-02f, -5.50936209e-03f, 5.86964376e-03f, 7.74921477e-02f,
  3.90852895e-03f, 3.72276665e-03f, -3.55739966e-02f, 4.91362773e-02f, -5.49421795e-02f, -6.65697828e-02f, 6.23494480e-03f, 3.19876298e-02f, -2.24336851e-02f, -6.73560649e-02f,
  5.45932390e-02f, -4.85170968e-02f, 1.60478428e-02f, 5.81654608e-02f, -6.29218575e-03f, -1.75748393e-02f, 1.09732235e-02f, 4.99660056e-03f, 9.78605705e-04f, 1.21920211e-02f,
  5.43689914e-02f, 6.59922287e-02f, -5.21652177e-02f, -4.52259369e-02f, -3.32310535e-02f, 3.71398143e-02f, 1.55082066e-02f, -2.26924429e-03f, 1.03048697e-01f, -5.19904643e-02f,
  -3.67549621e-02f, -5.55841951e-03f, 5.78579940e-02f, -4.79840599e-02f, 3.16879526e-02f, 8.25175568e-02f, 6.64301291e-02f, 4.21998240e-02f, -2.55172998e-02f, -8.73399600e-02f,
  -1.73642129e-01f, -1.50845453e-01f, -1.07856952e-01f, 2.92002852e-03f, 3.76176611e-02f, 4.90331724e-02f, 3.83567251e-02f, -3.57037783e-02f, -9.73457545e-02f, -3.42611372e-02f,
  -7.37172589e-02f, 5.46344146e-02f, 1.34287653e-02f, -2.58590970e-02f, 9.22647417e-02f, 4.03192379e-02f, -9.47383419e-02f, -7.46108145e-02f, -8.75073299e-02f, 5.58528304e-02f,
  -2.23529171e-02f, 8.07538908e-03f, -1.51489722e-02f, -6.47423789e-02f, 1.38037198e-03f, 6.41323552e-02f, 3.88565771e-02f, 4.81853969e-02f, -1.58417206e-02f, 1.76634677e-02f,
  1.19721986e-01f, -2.30861846e-02f, 1.15461916e-01f, -5.99501841e-02f, -1.14247026e-02f, 8.53021592e-02f, 5.22094034e-02f, -7.47942412e-03f, 1.30867109e-01f, 4.54278253e-02f,
  -1.02359749e-01f, 1.08764268e-01f, 1.54795423e-02f, -9.05150920e-03f, 1.21174313e-01f, -3.58016714e-02f, 6.49060383e-02f, 1.74362231e-02f, 4.14672904e-02f, -1.97588168e-02f,
  5.80771901e-02f, -9.79190469e-02f, -9.00927484e-02f, -9.83389616e-02f, -8.53580385e-02f, 1.08581390e-02f, -8.91397297e-02f, 3.16164270e-02f, -1.18802920e-01f, -8.50482956e-02f,
  -3.43186967e-02f, -5.15748449e-02f, -1.92282326e-03f, 9.89380255e-02f, 8.33998248e-02f, -1.19525362e-02f, 2.39928868e-02f, -3.37230340e-02f, -1.19638545e-02f, -1.51637848e-02f,
  -4.17682827e-02f, -7.01705143e-02f, 2.82759871e-02f, 6.20501153e-02f, 9.02481452e-02f, -2.57971250e-02f, 1.32296067e-02f, -5.27437441e-02f, -1.59893576e-02f, -5.71650080e-02f,
  7.11818412e-02f, -4.59101936e-03f, 7.55031258e-02f, -6.14804886e-02f, 7.50551894e-02f, 4.27480526e-02f, -4.67235819e-02f, -8.52839425e-02f, 8.86137262e-02f, -3.79847772e-02f,
  -3.24436687e-02f, 2.48216279e-03f, 6.18304722e-02f, -1.30678825e-02f, -3.17631736e-02f, -8.18020329e-02f, -1.53134083e-02f, 1.90581251e-02f, 6.22009684e-04f, 8.01436901e-02f,
  8.60966593e-02f, 8.58335048e-02f, 4.95015755e-02f, 6.70052413e-03f, 3.64112593e-02f, 5.46100698e-02f, -1.10970670e-02f, 6.99093044e-02f, -3.11053079e-02f, 5.70311211e-03f,
  -3.14981751e-02f, -7.47323874e-03f, 8.75481125e-03f, -8.76365751e-02f, 7.62677714e-02f, 4.46853563e-02f, -5.37208915e-02f, 6.82947561e-02f, 3.38317193e-02f, 7.69616142e-02f,
  9.63734761e-02f, 1.22134974e-02f, 7.75814503e-02f, -8.98732920e-04f, 6.93485513e-03f, 2.72081029e-02f, -1.06202746e-02f, -4.50491384e-02f, 1.48376962e-02f, -1.06752478e-02f,
  -5.76536506e-02f, -1.55918896e-02f, 4.13220525e-02f, -8.35552141e-02f, 2.94821169e-02f, 8.34108740e-02f, -7.45034814e-02f, 5.01459651e-03f, -2.40947073e-03f, 4.08304967e-02f,
  -3.74381430e-02f, -6.60660565e-02f, -1.87295657e-02f, -2.04155827e-03f, -7.70260990e-02f, -1.61712039e-02f, -9.77434590e-03f, 2.80604810e-02f, -7.04542920e-02f, -4.07408476e-02f,
  -1.96377695e-01f, 1.33058727e-01f, -7.93318674e-02f, 3.78823243e-02f, 6.94565997e-02f, 3.39715406e-02f, -6.30745813e-02f, 1.22052163e-01f, 1.13328464e-01f, -7.54549652e-02f,
  2.42876746e-02f, -1.08850405e-01f, 4.41381149e-02f, 2.22818032e-02f, -1.65943563e-01f, 3.48992599e-03f, 2.12627500e-02f, 1.45785613e-02f, 1.15630515e-01f, -6.71627000e-03f,
  4.49001603e-02f, -7.99343884e-02f, 1.63593772e-03f, 4.31811772e-02f, 6.42937571e-02f, -1.15287818e-01f, -1.27807692e-01f, 2.83370968e-02f, -8.67260471e-02f, -8.02747756e-02f,
  1.12411618e-01f, -1.04287406e-02f, -1.66602246e-02f, 5.50122410e-02f, 2.73043495e-02f, 2.41879448e-02f, 3.58901657e-02f, 2.35143509e-02f, 6.90401271e-02f, 9.18577239e-02f,
  5.28113432e-02f, 5.80520630e-02f, -5.77438958e-02f, 4.76338416e-02f, -6.01214878e-02f, 6.54605031e-02f, 4.41856422e-02f, -8.32035467e-02f, 9.82865989e-02f, -2.56185643e-02f,
  2.93266829e-02f, 7.23553002e-02f, 1.65151469e-02f, 1.33635174e-03f, -8.89274552e-02f, -3.72510031e-02f, -8.40535313e-02f, -6.55601779e-03f, -8.48430395e-02f, 3.67916711e-02f,
  -1.71517283e-02f, -7.05729797e-03f, -2.22351346e-02f, 5.67415655e-02f, 5.02448007e-02f, 7.58660436e-02f, -7.91151077e-02f, -2.96555888e-02f, 4.12242711e-02f, -4.93132696e-03f,
  7.81040564e-02f, 3.37489806e-02f, 7.08921328e-02f, 5.93801476e-02f, 2.47410703e-02f, -6.19451106e-02f, -6.58087209e-02f, -4.20184918e-02f, 5.49576664e-03f, 8.20488632e-02f,
  6.42252937e-02f, 9.19632316e-02f, 2.30907183e-02f, -9.01639834e-02f, 9.00869910e-03f, -6.09551966e-02f, -8.99249222e-03f, 5.32030724e-02f, -7.94597492e-02f, 7.96818174e-03f,
  9.96919647e-02f, -7.98961148e-02f, 3.23001780e-02f, 1.56827848e-02f, 6.58476865e-03f, -7.39943758e-02f, -8.92761052e-02f, -1.64834168e-02f, -1.19424969e-01f, -6.54258132e-02f,
  -6.98668584e-02f, 1.20095722e-02f, 1.69313028e-02f, 4.88821194e-02f, -2.98534762e-02f, 1.96517576e-02f, -1.70598703e-03f, 6.31581396e-02f, 4.97036278e-02f, -4.56610247e-02f,
  -6.36683106e-02f, -2.11072457e-03f, -7.57168606e-02f, -1.91478152e-02f, 9.35449917e-03f, 2.00254447e-03f, 5.70274219e-02f, 6.42961562e-02f, -3.33087444e-02f, -2.57588681e-02f,
  2.20502764e-01f, -1.37531459e-01f, 8.70473981e-02f, 8.86618271e-02f, -4.94672805e-02f, -1.38768693e-02f, -4.55778390e-02f, -1.51458150e-02f, 3.13425958e-02f, -1.68120816e-01f,
  -3.62117104e-02f, 4.39557880e-02f, -1.89750895e-01f, 3.84864174e-02f, -9.18972641e-02f, -1.20732874e-01f, -1.07443690e-01f, -4.44428809e-03f, -5.72727807e-02f, -3.23315673e-02f,
  -4.32925895e-02f, -1.10356987e-01f, -6.00751601e-02f, -1.43485457e-01f, 9.43833143e-02f, 2.22583655e-02f, 2.42783614e-02f, -2.04676352e-02f, -2.04735547e-02f, -1.11750580e-01f,
  -2.24630744e-03f, -7.93861598e-02f, -1.10219978e-02f, 7.88941979e-02f, -9.78398696e-02f, 6.14465028e-02f, -3.58450189e-02f, 5.68766072e-02f, 7.86420191e-04f, 5.30062243e-02f,
  -4.09233943e-02f, -2.80017536e-02f, 2.10813861e-02f, 9.42907035e-02f, -3.85653079e-02f, 2.17767954e-02f, 7.76939467e-02f, 2.97514480e-02f, 3.99188176e-02f, 9.90120173e-02f,
  -5.19908518e-02f, 6.31022379e-02f, -1.00206379e-02f, 1.10445982e-02f, 1.22570526e-02f, -3.57563533e-02f, 2.50792992e-03f, -3.31857838e-02f, 1.08190682e-02f, -6.36036173e-02f,
  1.93656818e-03f, 5.85684180e-03f, 1.31366793e-02f, 5.45414984e-02f, 2.04667114e-02f, 8.66911486e-02f, 8.45189840e-02f, -5.49973994e-02f, 1.40110226e-02f, 4.67945114e-02f,
  -7.20298802e-03f, 3.84106897e-02f, 4.35867012e-02f, 3.83683518e-02f, 7.43231177e-02f, -2.13316418e-02f, 4.26173583e-02f, -6.46388507e-04f, -6.53042197e-02f, 1.33328335e-02f,
  9.14070830e-02f, 6.28696084e-02f, 1.66182930e-03f, 4.76914681e-02f, -6.41377568e-02f, 5.90887330e-02f, 6.63636625e-02f, 3.94349135e-02f, -5.42763360e-02f, 2.51423288e-02f,
  1.09688763e-03f, -1.64770886e-01f, 4.43197154e-02f, 2.61641182e-02f, -7.49772787e-02f, -2.58036200e-02f, -3.32513116e-02f, 1.90709177e-02f, -7.01058060e-02f, -5.68172894e-02f,
  -7.54491836e-02f, -9.59846005e-02f, 2.06723846e-02f, 1.35841379e-02f, 3.82279679e-02f, 8.31704438e-02f, -3.80477458e-02f, -6.46551624e-02f, -1.41901486e-02f, 4.37691100e-02f,
  1.43981883e-02f, -3.84962521e-02f, -6.15469404e-02f, 9.72263142e-02f, -2.28472780e-02f, 7.08937123e-02f, -2.96319686e-02f, -8.16215426e-02f, 2.81853024e-02f, -4.14421037e-02f,
  2.38856778e-01f, -3.98568630e-01f, -1.46412790e-01f, 1.38010859e-01f, 1.53245613e-01f, -1.09903678e-01f, -8.15841705e-02f, 6.52261749e-02f, -6.87089637e-02f, -1.20961912e-01f,
  -1.03258751e-01f, -1.70951590e-01f, -3.59192371e-01f, 2.02565007e-02f, 1.53410569e-01f, -2.17377350e-01f, 1.33479893e-01f, -1.70545988e-02f, 2.68218815e-02f, -5.48016727e-02f,
  3.70611250e-02f, 1.34368688e-01f, 1.12478800e-01f, 1.45158753e-01f, 1.37802050e-01f, 1.01637691e-01f, 1.37141362e-01f, 2.24383324e-02f, 2.60867357e-01f, 1.38252795e-01f,
  1.75935216e-02f, -1.12503260e-01f, 4.27903468e-03f, -6.80075632e-03f, -9.17232782e-03f, -9.00205746e-02f, 2.23252806e-03f, 7.19166771e-02f, 5.48787042e-02f, -8.16396698e-02f,
  -3.55878361e-02f, 4.58099991e-02f, 1.18781567e-01f, -5.73650841e-03f, 8.82231370e-02f, 9.68582928e-02f, -2.29888763e-02f, -1.37546696e-02f, 2.81346720e-02f, -1.56175002e-01f,
  -1.18606009e-01f, 5.13925590e-02f, -3.22746933e-02f, 1.39123842e-03f, -2.88876463e-02f, 4.08550128e-02f, -4.99396473e-02f, -5.08850701e-02f, -4.70916741e-02f, -3.26858945e-02f,
  -7.25232810e-02f, 2.39309054e-02f, 1.88708398e-02f, 5.48044667e-02f, -1.33916903e-02f, 7.81490356e-02f, 2.10600719e-02f, 1.39551507e-02f, 5.71863875e-02f, -2.91486178e-02f,
  9.41231996e-02f, -3.38453911e-02f, -3.28002707e-03f, 3.12386509e-02f, 1.10447193e-02f, -3.67653109e-02f, -2.14276742e-02f, 3.29506770e-02f, -4.83952276e-02f, 9.79474094e-03f,
  -6.59525469e-02f, 5.40913306e-02f, -4.75418642e-02f, 9.26671475e-02f, -1.99046321e-02f, 7.84858875e-03f, -1.49185136e-02f, -2.48400867e-03f, 3.73119116e-02f, -3.60104702e-02f,
  -1.27018422e-01f, -2.44350269e-01f, 4.23642397e-02f, 2.21261196e-02f, -4.28577093e-03f, 7.98064098e-03f, -6.40277565e-02f, -5.02863117e-02f, 1.18144602e-02f, 1.52643919e-02f,
  -6.84196129e-02f, 9.21244454e-03f, -1.86384730e-02f, 7.59235322e-02f, 4.57898714e-02f, -1.09286822e-01f, -3.59319262e-02f, 3.20390612e-02f, 1.09371487e-02f, -5.84244132e-02f,
  -5.53877577e-02f, -8.06784034e-02f, 3.48920152e-02f, -4.41755094e-02f, -4.48189341e-02f, -7.56408647e-02f, -4.47096676e-03f, -3.29092816e-02f, -7.58087076e-03f, -1.27271945e-02f,
  -8.74653459e-02f, -1.44414470e-01f, 1.76728830e-01f, 7.03360811e-02f, 1.22909024e-02f, 1.21828809e-01f, 1.60040632e-01f, -3.38038169e-02f, -3.66788357e-02f, -1.33561656e-01f,
  -8.98272097e-02f, 1.28885005e-02f, -4.15885374e-02f, -4.68039215e-02f, 5.27981669e-02f, 2.89358553e-02f, 7.18854815e-02f, -6.91736266e-02f, -3.95365618e-03f, -2.07078960e-02f,
  -2.92536281e-02f, -7.52000213e-02f, 1.33031026e-01f, 4.75618951e-02f, -2.96695940e-02f, -7.60703236e-02f, -2.35899165e-02f, 1.41294017e-01f, 3.01741417e-02f, 7.66339377e-02f,
  -1.41142551e-02f, -1.18591204e-01f, -1.13576084e-01f, -9.17624161e-02f, -3.31042744e-02f, 7.82879349e-03f, 2.46516876e-02f, 1.16693936e-01f, -3.64670493e-02f, -8.59060809e-02f,
  -8.22941363e-02f, 4.96845022e-02f, 2.02276055e-02f, 2.69452520e-02f, -1.66822206e-02f, -4.81400564e-02f, -2.04968527e-02f, 1.11151524e-02f, -7.29427999e-03f, -4.28690873e-02f,
  -5.91963008e-02f, 3.92803326e-02f, -8.47333521e-02f, 4.76409271e-02f, 1.13317758e-01f, 4.74644788e-02f, -3.74511778e-02f, 6.70349076e-02f, 5.10639288e-02f, 7.02645481e-02f,
  -1.27908466e-02f, 1.19843259e-02f, -6.18882813e-02f, 5.67955077e-02f, -8.46737474e-02f, -6.02992065e-03f, -1.62451975e-02f, 3.66908647e-02f, 4.38688546e-02f, 6.30012080e-02f,
  -1.97301172e-02f, 9.11439657e-02f, -6.55476600e-02f, -2.88601294e-02f, -7.43658766e-02f, -6.11203257e-03f, -4.83450368e-02f, -5.37989661e-02f, -3.21837291e-02f, 7.14933872e-02f,
  -8.19515511e-02f, -4.29880619e-02f, 2.29504928e-02f, -2.49055243e-04f, -6.05660044e-02f, -7.20003434e-03f, -1.07524153e-02f, 4.60018329e-02f, 8.38219468e-03f, 6.78900927e-02f,
  -1.38992667e-01f, -1.53399661e-01f, -8.34473670e-02f, -6.79163411e-02f, 1.33692818e-02f, 7.55459815e-03f, 6.85663670e-02f, -9.96382721e-03f, -8.51081163e-02f, -3.90581638e-02f,
  1.84945259e-02f, 2.47489233e-02f, -5.59179783e-02f, 1.73560102e-02f, 5.42607307e-02f, -8.82143062e-03f, 2.99304910e-03f, 1.18924666e-03f, -7.14197531e-02f, 3.49704847e-02f,
  5.85438237e-02f, 2.78950972e-03f, 5.01990318e-02f, -6.17163405e-02f, 5.42730056e-02f, 9.26612169e-02f, -6.50555594e-03f, 5.47447614e-02f, 5.89161515e-02f, 7.98647106e-02f,
  6.60210401e-02f, -1.73227385e-01f, 7.94185475e-02f, 4.43608128e-02f, 2.44746683e-04f, 1.25380736e-02f, 2.03583509e-01f, -1.46335632e-01f, -7.65245557e-02f, -1.22536801e-01f,
  6.78049261e-03f, -3.23145241e-02f, 7.62247369e-02f, 3.60260531e-02f, 7.23324493e-02f, 2.65677404e-02f, -2.75077559e-02f, 1.05393849e-01f, 4.02996987e-02f, 3.66438925e-02f,
  2.07362752e-02f, 3.82266566e-02f, -9.63087529e-02f, -8.04469958e-02f, -7.19915107e-02f, -8.96266773e-02f, 4.87878136e-02f, -6.90517202e-02f, -6.11497685e-02f, 1.06545158e-01f,
  4.32706699e-02f, 8.32904354e-02f, 3.74630019e-02f, -9.41393822e-02f, 4.56588864e-02f, -3.80906127e-02f, -4.27767225e-02f, 2.95093730e-02f, -3.56344730e-02f, -4.43200245e-02f,
  1.67299993e-02f, 6.98928684e-02f, 3.71617340e-02f, 3.59746069e-02f, 6.61406517e-02f, -9.08502862e-02f, -1.01198088e-02f, -4.30853888e-02f, -1.11659601e-01f, -2.01652534e-02f,
  2.32302118e-02f, -1.07928775e-02f, 7.19402432e-02f, -2.57986337e-02f, -6.85704872e-02f, 6.08079657e-02f, 4.83012535e-02f, 1.05453499e-01f, -5.25095277e-02f, -1.65462326e-02f,
  2.05250122e-02f, 7.00772628e-02f, 6.76769987e-02f, -5.79873547e-02f, 4.35740203e-02f, 5.52013442e-02f, 5.44925854e-02f, -4.08060439e-02f, 7.24078417e-02f, -5.10926098e-02f,
  5.96166076e-03f, -7.69516304e-02f, 1.77134611e-02f, -6.11920096e-02f, 7.28653222e-02f, -7.22407177e-02f, 2.53557283e-02f, -1.25799812e-02f, -7.01579079e-02f, -2.53414325e-02f,
  2.78438963e-02f, -6.57437649e-03f, -9.88538489e-02f, -9.32354759e-03f, 5.28791361e-02f, 3.40195410e-02f, 7.23061338e-02f, 3.53227779e-02f, 4.92428392e-02f, -1.32070109e-02f,
  -1.68704167e-02f, -1.27317250e-01f, -5.33913448e-02f, 6.58741593e-02f, 3.94952390e-03f, -4.24812036e-03f, 5.17188618e-03f, 2.51031220e-02f, -1.31297102e-02f, 4.30042036e-02f,
  3.58201414e-02f, -5.94901890e-02f, 4.44627851e-02f, 3.06905266e-02f, -3.06612048e-02f, 2.12833993e-02f, -4.59583923e-02f, 3.34801637e-02f, 2.36902945e-02f, 1.76905114e-02f,
  -4.75437343e-02f, 4.59742211e-02f, 8.92006382e-02f, -2.86315940e-03f, -6.62686452e-02f, 2.03929953e-02f, 1.97951123e-02f, 1.96432378e-02f, -5.97000718e-02f, -9.69667807e-02f,
  1.02351606e-01f, -4.77850176e-02f, -8.96299109e-02f, -1.69541538e-01f, -9.64883342e-02f, -2.18537748e-01f, -2.21521437e-01f, -2.22990289e-01f, -8.10036212e-02f, -7.04716295e-02f,
  -1.85554519e-01f, 5.38780950e-02f, -6.69354647e-02f, -1.50515631e-01f, 5.90061061e-02f, 4.08295281e-02f, -9.14231017e-02f, -1.30105853e-01f, -7.85071403e-02f, -1.55375212e-01f,
  5.07776663e-02f, -2.57423848e-01f, -1.00976542e-01f, -1.73816010e-01f, -2.30311826e-01f, 1.26683339e-02f, -8.66766274e-03f, -1.71949714e-01f, -5.51585481e-02f, -3.70590873e-02f,
  -1.20882064e-01f, 4.45962884e-03f, 3.71100823e-03f, -2.78591570e-02f, -5.41302413e-02f, 1.69967429e-03f, -7.91517347e-02f, -7.00849518e-02f, -1.48631986e-02f, 1.33352447e-02f,
  -3.58327143e-02f, 4.65545170e-02f, -8.18869025e-02f, 6.17790073e-02f, -8.22410733e-02f, -2.61497106e-02f, -4.05749753e-02f, 5.90129606e-02f, 6.67846645e-04f, -6.65629581e-02f,
  -6.51033968e-02f, 1.67268999e-02f, -1.49084246e-02f, -5.14495447e-02f, -1.97878592e-02f, -1.68371461e-02f, 5.88467419e-02f, 1.31963238e-01f, 7.41513297e-02f, 9.63906571e-02f,
  2.92448811e-02f, 4.13141493e-03f, 2.53524892e-02f, 1.32321101e-02f, -2.05871440e-03f, 2.77046324e-03f, -7.29594454e-02f, -4.10945825e-02f, 6.31438866e-02f, 6.38503348e-03f,
  4.65650856e-02f, 6.72596022e-02f, 6.26993626e-02f, 6.91980124e-02f, -8.64724591e-02f, 4.53223325e-02f, -4.34214771e-02f, 4.51217107e-02f, -3.91598558e-03f, -3.06049623e-02f,
  -5.00446334e-02f, -6.27134591e-02f, 8.95954445e-02f, -1.94037016e-02f, -3.04148383e-02f, -4.23924625e-02f, 2.80776676e-02f, 1.03729919e-01f, 3.83895785e-02f, 1.97388213e-02f,
  -3.47258151e-02f, -5.62526137e-02f, -9.52922255e-02f, 1.88858099e-02f, -7.71620078e-03f, 3.98039594e-02f, -7.25281239e-02f, -6.77660182e-02f, 2.32563224e-02f, -7.89024234e-02f,
  -1.82162561e-02f, 5.98678715e-04f, -2.69784816e-02f, 4.20426838e-02f, -7.58143887e-02f, -3.95359918e-02f, -8.32961425e-02f, 1.16484659e-02f, 1.21654663e-02f, 9.47615970e-03f,
  3.18462104e-02f, -1.18362857e-02f, 4.52670716e-02f, -1.97485518e-02f, -5.11494372e-03f, -6.04762286e-02f, -8.90883151e-03f, -4.96446118e-02f, 3.09349466e-02f, 5.52769937e-02f,
  7.24202860e-03f, -5.77347679e-03f, 5.11121675e-02f, 1.58195928e-01f, -1.38895690e-01f, -1.07362278e-01f, -1.85632229e-01f, 1.72215048e-02f, -1.57463476e-01f, -1.59233600e-01f,
  2.04202458e-02f, -2.42802855e-02f, -1.58125088e-02f, 1.74559951e-01f, 1.81271896e-01f, 8.92792866e-02f, 4.08248976e-02f, -2.56294999e-02f, -2.38776132e-02f, 9.57530141e-02f,
  1.33139044e-01f, 5.10247611e-02f, 1.98515549e-01f, 1.46857396e-01f, -4.84573767e-02f, 1.92854807e-01f, 1.78781062e-01f, 3.63975875e-02f, 1.83613390e-01f, 6.21222034e-02f,
  9.26374167e-04f, 2.37179417e-02f, -2.48541478e-02f, -2.40179971e-02f, -1.36758424e-02f, 2.11707409e-02f, -5.03626391e-02f, 5.01539297e-02f, 4.66656424e-02f, 5.29033020e-02f,
  -1.01042967e-02f, 5.00769131e-02f, -5.41451015e-02f, 9.06516016e-02f, 3.19581069e-02f, 1.32876402e-02f, -3.38650658e-03f, -7.67623037e-02f, -6.87983185e-02f, 6.89078718e-02f,
  1.04193240e-02f, -6.26526028e-02f, -5.27000055e-02f, 3.21396589e-02f, -1.77055150e-02f, -5.87311871e-02f, 9.25986841e-03f, -5.98167023e-03f, 3.76042612e-02f, -2.08304245e-02f,
  -3.63273523e-03f, -2.19407864e-02f, 2.55477577e-02f, -4.28108312e-03f, -1.99793149e-02f, -7.21956417e-02f, 5.29980510e-02f, 8.97372365e-02f, -6.12742901e-02f, 7.74548277e-02f,
  -3.38658579e-02f, 2.54635420e-02f, 1.88235566e-02f, -1.95910931e-02f, 7.29419738e-02f, -4.26191241e-02f, 3.98657173e-02f, 3.08932569e-02f, 2.66656280e-02f, 3.53500992e-02f,
  -4.08884063e-02f, -2.78876908e-02f, -2.76250299e-03f, 4.70153652e-02f, 2.00314205e-02f, -4.79679815e-02f, -1.23663461e-02f, -1.01565998e-02f, -6.38431981e-02f, -3.07256635e-03f,
  1.23122133e-01f, 2.22702637e-01f, 2.85445619e-02f, -6.70224652e-02f, -3.70601937e-02f, 3.19448076e-02f, -2.54265387e-02f, -3.52502130e-02f, -2.05127709e-03f, 7.53176510e-02f,
  4.99545448e-02f, -1.68079752e-02f, 6.27055839e-02f, -3.92380282e-02f, -3.63836400e-02f, -2.40308717e-02f, 1.00373976e-01f, 6.52783811e-02f, 1.22696638e-01f, 6.03838675e-02f,
  3.76907475e-02f, -6.24712510e-03f, 1.19787529e-02f, 7.43318768e-03f, 6.80485368e-02f, 8.04800019e-02f, 6.84989393e-02f, 6.73748478e-02f, -1.15551902e-02f, 3.78765352e-02f,
  -1.17399067e-01f, 1.17016964e-01f, 3.86597365e-02f, 3.74472626e-02f, 2.54249498e-02f, -2.03373313e-01f, -1.08741499e-01f, 6.59878999e-02f, -6.12813719e-02f, -7.88820013e-02f,
  -3.43054906e-02f, -4.67040651e-02f, -2.09775697e-02f, -3.97348311e-03f, -1.58854611e-02f, 4.42519076e-02f, 1.42995175e-02f, -1.15769222e-01f, -8.28724727e-02f, 1.16414554e-01f,
  1.01152971e-01f, 8.51311460e-02f, 6.05027303e-02f, 1.27164826e-01f, 3.77306268e-02f, 2.05471236e-02f, 4.32915054e-02f, 1.42870128e-01f, -3.59250568e-02f, -2.47806944e-02f,
  -7.24150315e-02f, 1.21444620e-01f, -3.74094285e-02f, -2.36988277e-03f, 2.98713185e-02f, -3.44780050e-02f, -2.14096922e-02f, -6.09341785e-02f, -9.95621737e-03f, -6.81355670e-02f,
  -3.90005112e-02f, -6.83592930e-02f, -7.88882822e-02f, 3.80640961e-02f, -5.93465343e-02f, 5.99035025e-02f, -6.89322278e-02f, -3.09784338e-03f, 5.47522530e-02f, 1.86349638e-02f,
  7.38951704e-03f, 6.16081320e-02f, -6.90089241e-02f, 7.53116310e-02f, -1.06241563e-02f, -2.68287025e-02f, -8.43416993e-03f, -6.40516914e-03f, 3.93668190e-02f, 9.77109303e-05f,
  3.49758454e-02f, -2.02166452e-03f, -7.65975863e-02f, 4.57909405e-02f, -1.70948021e-02f, 2.55987532e-02f, -5.56593649e-02f, 1.58865191e-02f, 9.25657600e-02f, -7.73744434e-02f,
  1.02019012e-02f, -2.14633457e-02f, 2.07900126e-02f, -2.65413132e-02f, -4.60216403e-02f, -4.09257039e-02f, -4.64613847e-02f, -2.41694041e-03f, 7.11590648e-02f, -1.38759008e-02f,
  7.31488913e-02f, -5.70551790e-02f, -6.04853556e-02f, -4.93728407e-02f, -7.21359551e-02f, -5.70511408e-02f, 8.66905674e-02f, 1.18704690e-02f, -3.15965363e-03f, -4.06887531e-02f,
  -2.02363562e-02f, 1.69248790e-01f, 6.51028752e-02f, 3.67142900e-04f, -2.52280105e-02f, -1.36994831e-02f, 1.43807707e-03f, -8.29099938e-02f, 2.51988731e-02f, -3.71594727e-02f,
  -1.04283337e-02f, 2.66589932e-02f, -3.66688855e-02f, -2.99796797e-02f, 6.72188103e-02f, -1.68492850e-02f, 8.24084580e-02f, -7.45225549e-02f, 2.33834516e-02f, -1.81273241e-02f,
  6.50479123e-02f, 5.93605153e-02f, -4.75471579e-02f, -1.02281854e-01f, -6.07623011e-02f, -2.59572435e-02f, 3.53114009e-02f, -7.07115456e-02f, 6.09659851e-02f, 6.71372190e-02f,
  8.68245959e-02f, 5.70350736e-02f, -6.71930090e-02f, -1.45799881e-02f, -9.43156332e-02f, -9.02127102e-02f, -2.31442899e-02f, 9.06580070e-04f, 6.85882345e-02f, -8.59438479e-02f,
  -4.18692939e-02f, 8.41881633e-02f, -1.22656347e-02f, -6.50349036e-02f, 2.52671726e-03f, 9.34400931e-02f, -1.38467830e-02f, -1.00950107e-01f, 1.92770641e-02f, -4.10028547e-03f,
  4.69733104e-02f, 2.50843063e-04f, -9.18981433e-02f, -4.42518247e-03f, -4.21931520e-02f, -9.28622410e-02f, -9.36021283e-02f, -8.54793862e-02f, -1.04500420e-01f, 2.63473624e-03f,
  4.81703132e-02f, 2.20325924e-02f, -1.41884070e-02f, 4.41598222e-02f, -7.70110488e-02f, 6.48260564e-02f, 1.74091477e-02f, 2.93037705e-02f, -8.62343833e-02f, -7.38159614e-03f,
  3.32116224e-02f, 7.10322633e-02f, 3.88362780e-02f, 2.30089929e-02f, -7.33019784e-02f, 3.48644778e-02f, 7.92901069e-02f, -2.52668560e-02f, 5.72944097e-02f, 1.75898317e-02f,
  -4.31579910e-02f, -6.08506165e-02f, -7.63963535e-02f, -2.26386059e-02f, -5.66341430e-02f, -4.52658348e-02f, 4.80949134e-02f, -7.88582712e-02f, -3.80424373e-02f, -5.49476333e-02f,
  7.97539577e-02f, -6.02676459e-02f, -4.01275121e-02f, -2.35687625e-02f, 3.96617651e-02f, -8.69277045e-02f, 4.01253551e-02f, -2.73650140e-02f, 9.47327986e-02f, -9.50746164e-02f,
  -2.05623731e-02f, -5.46097383e-02f, 2.12436896e-02f, -1.29981600e-02f, 3.11901364e-02f, 3.90429422e-02f, -8.11865851e-02f, 7.30688497e-02f, 9.10729244e-02f, -6.35887384e-02f,
  5.72831444e-02f, 2.49565039e-02f, -6.25324324e-02f, 6.39351783e-03f, 1.20926993e-02f, -3.98017019e-02f, -3.23859788e-02f, -6.84906542e-02f, 3.67102176e-02f, -4.53299135e-02f,
  -4.45019081e-02f, 5.96352145e-02f, 9.96268634e-03f, -3.42903994e-02f, 6.17879517e-02f, 5.41722253e-02f, 5.67126162e-02f, -4.50493768e-02f, -1.52796749e-02f, 1.11958086e-02f,
  -5.01825660e-02f, -6.53097257e-02f, -5.69991022e-02f, -2.44623758e-02f, 6.15752302e-02f, 3.84485386e-02f, 1.17778881e-02f, 3.43716070e-02f, -1.09634893e-02f, 8.31842721e-02f,
  6.85732737e-02f, 7.38254040e-02f, -6.30360022e-02f, 3.87856066e-02f, 5.98264113e-02f, -6.31180033e-02f, 4.17314060e-02f, -6.56816885e-02f, 4.56271246e-02f, -5.46577275e-02f,
  5.90447225e-02f, -3.30844969e-02f, 1.91619053e-01f, -3.12575474e-02f, 8.20179656e-02f, 6.26425371e-02f, 3.99364308e-02f, -1.08235061e-01f, 8.64604041e-02f, -1.17528543e-01f,
  -9.53016207e-02f, 6.45690337e-02f, -5.49244024e-02f, 1.11915702e-02f, 5.47126345e-02f, -3.15541290e-02f, -1.87105685e-02f, -1.55781377e-02f, 5.30588739e-02f, 1.93395056e-02f,
  -5.47151193e-02f, -9.53520611e-02f, 3.78465764e-02f, -9.75961052e-03f, -1.51055353e-02f, 5.07793836e-02f, -6.70432597e-02f, 8.85155275e-02f, -3.86809595e-02f, -7.82964006e-02f,
  1.26512617e-01f, 4.53321598e-02f, 1.45289212e-01f, -6.54164702e-02f, 6.32980093e-02f, 4.79808263e-02f, 4.38555842e-03f, 3.22504900e-02f, -3.40008065e-02f, -4.87460457e-02f,
  4.85040173e-02f, 2.60363910e-02f, -2.11681966e-02f, -9.80254859e-02f, -6.47659367e-03f, -3.66446152e-02f, 9.05102789e-02f, 6.76395223e-02f, -2.67784093e-02f, -2.98345549e-04f,
  2.43049972e-02f, 1.57549605e-02f, 4.17098170e-03f, -1.01738244e-01f, -5.78716733e-02f, -7.06108706e-03f, 7.11586922e-02f, 9.83410981e-03f, 4.07781824e-02f, -2.23123394e-02f,
  -1.13172360e-01f, -8.06343257e-02f, -1.22369435e-02f, -9.32114348e-02f, 2.18902230e-02f, -2.79662386e-02f, -1.84403658e-02f, -5.50240986e-02f, -5.82264513e-02f, -4.51406911e-02f,
  -5.15173636e-02f, 3.66088450e-02f, -5.94275221e-02f, -1.08605407e-01f, 1.12109892e-02f, 3.93288471e-02f, -3.97221968e-02f, -7.39083141e-02f, 9.99659151e-02f, 2.21584905e-02f,
  7.80179650e-02f, 4.00338508e-02f, -7.65480176e-02f, 4.55382727e-02f, -4.55883369e-02f, 4.07106318e-02f, -8.74199867e-02f, 2.41542738e-02f, -6.10308461e-02f, -7.64015391e-02f,
  -9.85002592e-02f, -7.50752315e-02f, 3.02732326e-02f, -6.83129206e-02f, 5.05204722e-02f, 5.77584580e-02f, -6.92960098e-02f, -2.75013465e-02f, 5.89436106e-02f, -6.80017993e-02f,
  -5.54891638e-02f, -2.68628746e-02f, 1.03582829e-01f, -4.50614393e-02f, -1.91251263e-02f, -1.55812362e-03f, 3.37263234e-02f, 3.56619358e-02f, -5.93002699e-02f, -7.89698958e-02f,
  -1.55245615e-02f, -3.04115061e-02f, -7.92232603e-02f, -4.29675616e-02f, -2.28425972e-02f, -9.59976763e-02f, 2.41129822e-03f, -7.88481385e-02f, -3.82139571e-02f, 1.92115586e-02f,
  5.29601499e-02f, -1.01383269e-01f, -1.07585602e-02f, 7.54017532e-02f, 1.69226453e-02f, -5.19928262e-02f, -2.06412360e-01f, 2.03771591e-02f, -1.43603131e-01f, -1.07136868e-01f,
  -5.44207578e-04f, -5.76486019e-03f, -1.35281205e-01f, -8.05374514e-03f, -3.81162837e-02f, -1.54597595e-01f, -1.06304036e-02f, -1.31305948e-01f, -8.89825970e-02f, 7.05657080e-02f,
  7.14313984e-02f, 1.52067289e-01f, 1.05543099e-01f, 2.37731934e-01f, 1.19239561e-01f, 1.19023450e-01f, 1.95027292e-01f, 5.13538718e-02f, 2.17163235e-01f, 2.10161600e-03f,
  4.09359522e-02f, -1.13772936e-02f, -2.37290990e-02f, 3.04829534e-02f, 3.26421484e-02f, 1.90866049e-02f, -2.06602402e-02f, 1.13351122e-01f, 9.30353850e-02f, -4.46909256e-02f,
  -4.35883775e-02f, -4.30505425e-02f, -3.68233211e-02f, 1.95890311e-02f, -7.97129795e-02f, 1.03527140e-02f, 4.10495624e-02f, -2.24126410e-02f, -6.39870167e-02f, 1.70893706e-02f,
  -6.37479797e-02f, -8.29161797e-03f, 1.00139387e-01f, 4.92099747e-02f, 7.99735785e-02f, 4.00432087e-02f, -4.79923598e-02f, 6.72053918e-02f, 5.97025640e-02f, 2.38076970e-02f,
  -2.96010207e-02f, 6.23746775e-02f, 1.02122072e-02f, -5.15309274e-02f, -5.31065427e-02f, 5.25745563e-02f, -2.20259577e-02f, -2.08422113e-02f, -5.92500009e-02f, -9.37804356e-02f,
  8.99965242e-02f, -6.38198555e-02f, -6.61858008e-04f, 4.74683419e-02f, -6.93766912e-03f, 1.84515081e-02f, 2.93210316e-02f, 4.29778505e-04f, 3.88458669e-02f, -8.00072215e-03f,
  7.03743659e-03f, 7.53771141e-02f, -2.63987985e-02f, -4.95945141e-02f, 2.50832718e-02f, 1.07055269e-01f, -2.95062233e-02f, 3.96703091e-03f, 5.87760322e-02f, 3.17715332e-02f,
  -6.29678415e-03f, 6.78756312e-02f, -4.96544205e-02f, 5.07063419e-02f, -2.66231764e-02f, -1.03869801e-02f, 2.91059688e-02f, 9.30755809e-02f, -1.75176803e-02f, -3.05044204e-02f,
  1.06295668e-01f, 1.53829390e-02f, -3.64153124e-02f, -1.22086043e-02f, 6.52633384e-02f, 4.24094573e-02f, 2.37317127e-03f, 8.09194595e-02f, -5.20014018e-02f, 1.13799408e-01f,
  7.60700330e-02f, -6.67041540e-02f, -8.31915736e-02f, 1.19379172e-02f, 4.32641841e-02f, -6.59802631e-02f, 1.97916571e-02f, 1.27375207e-03f, -4.79464270e-02f, -5.93447499e-02f,
  2.13066906e-01f, -1.16413668e-01f, -1.94540322e-01f, -1.79155052e-01f, -7.83601329e-02f, -2.11766720e-01f, -1.70352116e-01f, -1.62360698e-01f, -8.81594047e-02f, -1.22055737e-02f,
  -9.78785753e-02f, -8.96792263e-02f, 3.40433940e-02f, -2.89111435e-01f, -9.76489857e-02f, -1.30594447e-02f, -1.17567539e-01f, -9.27384011e-03f, -1.14526302e-02f, -7.66482055e-02f,
  1.89490784e-02f, -1.38511091e-01f, -7.50402287e-02f, -7.17176646e-02f, -1.68941662e-01f, 6.68314174e-02f, 1.94492072e-01f, -5.13684452e-02f, -6.30440563e-02f, -5.48807979e-02f,
  -1.20444767e-01f, 7.19860243e-03f, -3.13550867e-02f, -5.16848974e-02f, 9.92204994e-02f, 1.13367848e-02f, 8.84364694e-02f, -4.70893495e-02f, 1.07773673e-02f, -2.54998188e-02f,
  -2.35762000e-02f, 2.03236602e-02f, -1.46703585e-03f, 1.23508498e-02f, 2.70174202e-02f, -1.02006055e-01f, 1.69036780e-02f, 3.59383561e-02f, -5.62434494e-02f, -7.04688057e-02f,
  -1.19642140e-02f, 2.33066846e-02f, 9.30702593e-03f, 5.71910255e-02f, 2.88812630e-02f, -6.40917271e-02f, -9.71408635e-02f, 4.15066592e-02f, 5.08129001e-02f, 5.45284450e-02f,
  -3.84884924e-02f, 6.90426007e-02f, -7.94342831e-02f, -1.11575030e-01f, -8.95042866e-02f, -1.52273523e-02f, 3.86577211e-02f, 1.12147562e-01f, -4.78541479e-02f, 1.93883739e-02f,
  -1.88621655e-02f, -2.98073646e-02f, 2.95141842e-02f, 1.00470718e-03f, -1.16054970e-03f, 5.47675006e-02f, -2.98405737e-02f, 8.46273303e-02f, -2.57035885e-02f, 3.91420126e-02f,
  -4.93996888e-02f, 7.16636181e-02f, -1.01955682e-01f, -1.60922576e-02f, 5.81252128e-02f, 6.08072011e-03f, 9.17388499e-03f, -3.19708176e-02f, -7.28894845e-02f, -4.72181141e-02f,
  -7.67323375e-02f, -6.51283115e-02f, -6.05875142e-02f, -4.31726836e-02f, -5.31721450e-02f, 9.36993062e-02f, 3.68194096e-02f, -5.59345521e-02f, 2.34339293e-02f, 1.28858330e-04f,
  8.45494568e-02f, 1.00383740e-02f, 7.26953298e-02f, -2.18949877e-02f, 4.55913134e-02f, -5.28819486e-02f, -7.99774155e-02f, -1.30684637e-02f, -6.76901862e-02f, 5.39910905e-02f,
  -6.71216473e-02f, 3.36651541e-02f, 4.23934795e-02f, -7.09524304e-02f, 5.94567508e-02f, 9.24789011e-02f, 7.11656585e-02f, -3.62642370e-02f, -3.36591229e-02f, -3.58723253e-02f,
  -3.37490812e-02f, -9.43472702e-03f, -6.62161484e-02f, 2.67659742e-02f, 6.88044503e-02f, -2.56749094e-02f, 3.60676907e-02f, -2.04497091e-02f, -1.27505213e-02f, -1.55071029e-02f,
  1.05724037e-01f, 7.14833513e-02f, 7.86875263e-02f, 6.30369931e-02f, 3.57698202e-02f, -6.77215168e-03f, 7.99652860e-02f, -1.18695321e-02f, -2.63507720e-02f, 8.36310387e-02f,
  -1.11410804e-01f, -2.20336895e-02f, -4.16775458e-02f, -2.07893532e-02f, 7.93023556e-02f, -1.13015085e-01f, -8.07817429e-02f, 5.06544933e-02f, 6.75897375e-02f, -4.13287766e-02f,
  -5.54430075e-02f, -8.51012841e-02f, 8.41157287e-02f, 2.47300267e-02f, -4.29117121e-02f, 6.92397207e-02f, 8.97327214e-02f, -6.04030793e-04f, -9.00054723e-02f, -2.31429636e-02f,
  -7.65006542e-02f, 6.54265359e-02f, -1.04253171e-02f, 1.72982737e-02f, -1.56222200e-02f, 6.00369461e-03f, 1.60054546e-02f, 7.60431215e-02f, -9.39076990e-02f, 5.74586280e-02f,
  -9.22470763e-02f, -6.75989091e-02f, 3.20421457e-02f, 2.12640930e-02f, -5.68208564e-03f, 6.21892512e-02f, 3.83091606e-02f, 4.50333990e-02f, -6.06600754e-03f, -2.94970218e-02f,
  4.95909490e-02f, 7.72143900e-02f, -5.49181066e-02f, -2.58634482e-02f, 3.92181538e-02f, 6.10035099e-02f, 1.67470258e-02f, 2.24712379e-02f, -7.74515867e-02f, 8.25368389e-02f,
  -2.04169080e-02f, -7.05903396e-02f, 8.15882757e-02f, 7.67968446e-02f, 1.33450273e-02f, -5.38557805e-02f, -5.86180687e-02f, -9.84517206e-03f, -2.69591734e-02f, 5.50120622e-02f,
  -5.15343621e-02f, 7.63860196e-02f, 7.75694698e-02f, 5.27778603e-02f, 3.31492834e-02f, -6.86371252e-02f, 8.35943222e-02f, 3.87417562e-02f, -9.02282521e-02f, -2.36791354e-02f,
  3.46164964e-02f, 3.80629078e-02f, 3.22021805e-02f, -5.66234291e-02f, -4.99830507e-02f, 4.25898135e-02f, -9.33307484e-02f, 6.81972131e-02f, 1.17574269e-02f, -6.48905486e-02f,
  -6.86986074e-02f, -2.14839019e-02f, 7.58574879e-06f, 4.76079918e-02f, -2.42331382e-02f, 1.00588799e-01f, -8.30873102e-02f, -1.58082861e-02f, 7.79731944e-02f, -3.00604329e-02f,
  6.61377758e-02f, 2.14150697e-02f, -3.03387418e-02f, 8.81893039e-02f, -6.55653924e-02f, 3.25331539e-02f, 3.25553156e-02f, -5.22008799e-02f, -3.29955593e-02f, 3.19539346e-02f,
  9.26539153e-02f, -2.59514358e-02f, -5.22226021e-02f, -4.07140888e-02f, -2.40457226e-02f, -2.21451789e-01f, -2.06447706e-01f, -1.67654026e-02f, 1.36742681e-01f, -1.03859127e-01f,
  -1.71000317e-01f, 1.79005697e-01f, -1.45792842e-01f, -4.23604995e-02f, -2.82042045e-02f, -8.05469602e-02f, -1.66067004e-01f, 3.82241830e-02f, -1.19310862e-03f, -1.39398113e-01f,
  5.34257793e-04f, -1.48228765e-01f, -7.20166555e-03f, -2.43024044e-02f, 9.06495657e-03f, 6.27486631e-02f, -1.28178343e-01f, -7.66892508e-02f, -7.09170923e-02f, 1.48987742e-02f,
  3.10908873e-02f, 1.51851997e-02f, 7.10161999e-02f, 3.18518430e-02f, -1.57827195e-02f, 4.15897593e-02f, -4.74349521e-02f, -6.29441366e-02f, 9.24668182e-03f, -4.68936525e-02f,
  5.04802093e-02f, -3.85363959e-02f, -6.52843416e-02f, -3.60218473e-02f, 5.98398671e-02f, -1.83748063e-02f, 6.65565953e-02f, 6.94916919e-02f, -5.42402938e-02f, 1.28518701e-01f,
  2.81232242e-02f, 1.69609170e-02f, 1.04200048e-02f, 9.51324478e-02f, -7.36212209e-02f, -2.98709720e-02f, -1.01253418e-02f, 5.00835329e-02f, -2.12718677e-02f, -2.21178774e-02f,
  -8.79447721e-03f, -9.76778194e-02f, 3.73141021e-02f, 4.19239737e-02f, -5.19910976e-02f, -2.93419342e-02f, -9.58963931e-02f, 6.65339530e-02f, -5.37876710e-02f, -4.80153337e-02f,
  4.92890365e-02f, 8.90504047e-02f, -1.14249522e-02f, 8.75922814e-02f, -4.97732610e-02f, 5.74066080e-02f, -1.27394563e-02f, 3.66035327e-02f, -7.43034333e-02f, 3.39595042e-02f,
  -2.35818494e-02f, -6.67010620e-02f, -4.86346744e-02f, 4.47283238e-02f, 2.12731585e-02f, -3.92144136e-02f, -3.36643010e-02f, -9.51462018e-04f, 6.66147768e-02f, -8.00995529e-02f,
  -5.37049677e-03f, -5.04542515e-02f, -6.68249726e-02f, 2.24569570e-02f, -7.67810196e-02f, 1.98740307e-02f, -7.86296725e-02f, 5.37403822e-02f, -4.48495708e-02f, -8.05898532e-02f,
  6.64025219e-03f, 1.05404500e-02f, 8.14058036e-02f, -7.67788440e-02f, 2.52879895e-02f, -4.61661592e-02f, -4.14169356e-02f, 7.56175369e-02f, 8.78805202e-03f, -7.12362602e-02f,
  -1.03446953e-02f, -2.92722788e-03f, 6.76359907e-02f, 6.85279965e-02f, -3.69446650e-02f, -6.05910551e-03f, 3.54542397e-02f, 1.72204757e-03f, -1.70162842e-02f, 5.18758595e-02f,
  1.58834741e-01f, -9.20249969e-02f, -4.59513292e-02f, -1.82307646e-01f, -7.93795940e-03f, 4.91014868e-02f, 4.16830629e-02f, -9.25255045e-02f, -1.44815564e-01f, -7.37576559e-02f,
  1.18050702e-01f, -1.50078759e-02f, 1.14182010e-01f, -4.77085821e-02f, 1.68893728e-02f, 3.99173386e-02f, -1.63193606e-02f, 6.22774102e-02f, -3.38480473e-02f, 1.59716904e-02f,
  -6.34024292e-02f, 1.36287913e-01f, -1.53247556e-02f, -1.06968246e-02f, 6.79706708e-02f, -8.08198601e-02f, -1.41750351e-02f, 7.23904371e-02f, 8.10071733e-03f, 7.54745901e-02f,
  1.60805494e-01f, 2.57379506e-02f, 8.06133635e-03f, -3.15005332e-02f, 4.45107669e-02f, 7.40931258e-02f, 6.57457113e-02f, 7.80593529e-02f, 1.12892566e-02f, -7.77002349e-02f,
  8.51282179e-02f, -1.57191344e-02f, -1.37899324e-01f, 2.25208458e-02f, -3.16226762e-03f, -5.27268127e-02f, 7.89226126e-03f, -4.78191450e-02f, -2.69250274e-02f, -6.22683279e-02f,
  -1.08713647e-02f, 7.85178244e-02f, 7.23924860e-03f, 2.28470005e-02f, -7.39493892e-02f, -1.11979782e-03f, -3.36822122e-02f, -7.97266439e-02f, 2.12050173e-02f, -2.31053960e-02f,
  -4.31321934e-03f, 2.77065076e-02f, 5.04824445e-02f, 5.30299768e-02f, -6.49601072e-02f, -4.74718511e-02f, 8.52891654e-02f, 1.55173419e-02f, -6.89553395e-02f, -1.00925751e-02f,
  -7.05899997e-03f, 4.98311967e-02f, 8.67859125e-02f, 3.99963781e-02f, -3.34124849e-03f, 3.69132645e-02f, 3.45874159e-03f, 4.80872579e-02f, -5.30308448e-02f, -5.19867167e-02f,
  -1.51439868e-02f, 5.70187978e-02f, 3.38289589e-02f, -7.46186450e-02f, -7.33674038e-03f, -6.53446391e-02f, -6.41639680e-02f, 1.00842915e-01f, 8.18112716e-02f, -4.94112261e-03f,
  1.22666568e-01f, -1.17597580e-01f, 3.96328187e-03f, 5.46571659e-03f, 7.13278130e-02f, 3.81485671e-02f, 4.93683331e-02f, -2.23306417e-02f, -1.17011135e-02f, -2.73824725e-02f,
  -5.77397309e-02f, -4.28433791e-02f, -6.06320836e-02f, -3.63397375e-02f, -7.19279721e-02f, 1.09110670e-02f, 9.00548324e-02f, -6.94903582e-02f, -6.69244379e-02f, 3.40262130e-02f,
  -1.22514358e-02f, -6.47658780e-02f, -7.29067177e-02f, -8.74266922e-02f, -6.56908751e-02f, 3.60905603e-02f, 2.98685953e-02f, -6.40003895e-03f, 8.48737955e-02f, -7.31976405e-02f,
  8.40341076e-02f, -3.51946279e-02f, 1.12046018e-01f, 1.89029559e-01f, -7.96646532e-03f, -6.87895939e-02f, -8.75875950e-02f, 1.46331891e-01f, 1.67883918e-01f, -6.61689192e-02f,
  -5.68786915e-03f, -7.63877854e-02f, -1.37249738e-01f, 3.98084857e-02f, 9.02673751e-02f, -5.97684551e-03f, 1.25528321e-01f, 7.31396079e-02f, 1.59693256e-01f, 5.83545603e-02f,
  1.23685293e-01f, -6.04666434e-02f, -8.08939338e-02f, 5.72714605e-04f, 1.34828240e-02f, -3.44966911e-02f, -3.64704616e-02f, -8.41440912e-03f, -7.04549477e-02f, 3.99394743e-02f,
  -2.66556516e-02f, 3.60680148e-02f, -6.44701347e-02f, -5.09325899e-02f, 4.42702230e-03f, -5.52323163e-02f, 4.02515456e-02f, -5.71797974e-02f, 4.81356643e-02f, 6.00546859e-02f,
  -4.30982076e-02f, -3.83338635e-03f, 5.51995113e-02f, -1.42154319e-03f, 1.89121608e-02f, 3.67129631e-02f, -1.21748671e-02f, -4.03147601e-02f, -2.82908212e-02f, -5.42226098e-02f,
  -1.12236299e-01f, -2.51087584e-02f, -8.26081783e-02f, 9.04083252e-02f, 5.62027358e-02f, 4.42030951e-02f, -1.84621532e-02f, 3.30795185e-03f, -7.74891302e-02f, 1.70636538e-03f,
  7.22206980e-02f, -7.76680782e-02f, 1.12757757e-02f, -1.01829872e-01f, -9.92570519e-02f, 3.26383822e-02f, 2.56059486e-02f, 2.87564956e-02f, -7.25556836e-02f, 5.83724007e-02f,
  -1.33939479e-02f, 7.20141232e-02f, 2.68485602e-02f, -8.15616772e-02f, -3.93679589e-02f, -7.44964555e-02f, 3.47441286e-02f, 4.72209416e-02f, 4.12234291e-02f, 8.99810493e-02f,
  -8.52431729e-02f, -4.48880345e-02f, -7.11953416e-02f, -2.74787918e-02f, 1.26889842e-02f, -6.71146065e-02f, -5.32645434e-02f, -4.22313251e-02f, -2.72035915e-02f, -2.53616590e-02f,
  8.91596526e-02f, 1.47849768e-01f, 2.58402377e-02f, 4.67212833e-02f, -8.42840523e-02f, -3.06573827e-02f, 6.05459921e-02f, 1.04542159e-01f, 1.05857529e-01f, -1.13804797e-02f,
  -5.07276393e-02f, 2.77550798e-02f, 4.49551307e-02f, -6.26225397e-02f, -3.39327343e-02f, -2.40118913e-02f, 8.05777982e-02f, -7.06519708e-02f, -4.14351970e-02f, 2.95386445e-02f,
  2.56951451e-02f, 1.76484492e-02f, -6.25189692e-02f, -1.50623117e-02f, 8.19049403e-02f, -2.98926514e-02f, -8.58587325e-02f, 8.45798329e-02f, 2.39129644e-02f, -3.18193547e-02f,
  1.01409875e-01f, -1.48559868e-01f, -3.38352174e-02f, 1.09265342e-01f, -1.70723230e-01f, -1.65800542e-01f, -1.76427126e-01f, -2.15641707e-02f, -1.28336772e-01f, 7.11449469e-03f,
  -4.73675728e-02f, 1.36157870e-01f, 5.55187911e-02f, 8.37285444e-03f, 1.89711794e-01f, 1.58474535e-01f, -6.00519925e-02f, 1.35305412e-02f, 9.67158377e-03f, 2.29927618e-02f,
  2.63557378e-02f, -4.18057963e-02f, 1.57071859e-01f, 7.43387267e-02f, -8.23653117e-02f, 7.62392431e-02f, 8.75291526e-02f, 8.78518745e-02f, 5.62133081e-02f, -2.60497984e-02f,
  -7.51504898e-02f, -1.09931931e-03f, -1.02467634e-01f, 4.47771363e-02f, 5.62489517e-02f, 2.87823249e-02f, -6.97491914e-02f, 6.48707077e-02f, 2.19491571e-02f, 3.87974754e-02f,
  -2.90267309e-03f, 2.05215737e-02f, -1.90933049e-02f, 5.59557937e-02f, -2.37506051e-02f, -4.58456650e-02f, 7.28856400e-02f, -9.02492367e-03f, -7.36240149e-02f, -7.25612044e-02f,
  1.47134550e-02f, -7.64543563e-02f, -4.83523458e-02f, -3.64595056e-02f, 7.20068300e-03f, -9.55559164e-02f, -2.58887354e-02f, -4.31712158e-02f, 3.62536907e-02f, -2.07128190e-02f,
  3.35248485e-02f, -8.37291926e-02f, -4.64510247e-02f, -8.69902521e-02f, -6.34186715e-02f, -3.11429482e-02f, -2.29158252e-02f, -5.72911128e-02f, 5.95658980e-02f, 1.06892914e-01f,
  2.89531872e-02f, 8.02938244e-04f, -2.04504151e-02f, 8.87885913e-02f, 8.17688704e-02f, 1.73418298e-02f, -1.73218250e-02f, -5.65680414e-02f, 2.02042088e-02f, 6.75566271e-02f,
  4.96724918e-02f, -4.90717255e-02f, -6.76133856e-03f, 9.33587253e-02f, -7.21666440e-02f, -5.42513281e-02f, 2.92263515e-02f, 1.45688029e-02f, 5.10054231e-02f, 5.67953140e-02f,
  2.14946922e-02f, 4.00003456e-02f, -6.79976940e-02f, 3.17920782e-02f, -2.34795990e-03f, -9.81107354e-02f, -4.99604978e-02f, -2.49813609e-02f, 4.54045832e-02f, 3.03710289e-02f,
  3.11002340e-02f, -3.57240625e-02f, 7.70477131e-02f, 8.77212211e-02f, 7.68424049e-02f, -2.78827939e-02f, -1.95398144e-02f, 8.44970122e-02f, -1.99325141e-02f, 2.05461830e-02f,
  -2.65267286e-02f, 5.46203107e-02f, -1.46557307e-02f, -4.62205373e-02f, -6.78787157e-02f, 2.15369333e-02f, -1.75064593e-03f, 8.42353329e-02f, -6.61614463e-02f, 3.00218295e-02f,
  2.16942400e-01f, -2.43851483e-01f, -5.98895140e-02f, -1.38515919e-01f, 1.58951227e-02f, -1.28439218e-01f, 6.45100921e-02f, -2.72253871e-01f, -3.05919409e-01f, -1.03123248e-01f,
  -1.94546152e-02f, 1.13916911e-01f, 1.67954087e-01f, -1.58459365e-01f, 3.44978631e-01f, 1.02260165e-01f, -1.60905972e-01f, 2.27255467e-02f, -7.67642185e-02f, -1.40790984e-01f,
  4.35992554e-02f, -1.34879827e-01f, 1.49725312e-02f, -1.20647751e-01f, -9.69313160e-02f, -1.44105002e-01f, 4.95798551e-02f, 1.61498770e-01f, -6.96170703e-02f, 1.01732137e-03f,
  5.56064723e-03f, -1.30085200e-01f, -1.87071729e-02f, 2.79029384e-02f, 1.64455045e-02f, 3.03963013e-02f, 5.92949428e-02f, 1.10863551e-01f, 1.50579810e-02f, -5.25081381e-02f,
  9.24709141e-02f, -7.71054327e-02f, -8.16703737e-02f, 2.08035614e-02f, -4.25897315e-02f, -7.84175843e-02f, -4.13283426e-03f, 4.41480577e-02f, -3.90442763e-03f, 3.12068481e-02f,
  -9.84928533e-02f, -7.15098307e-02f, 1.70337707e-02f, -3.14529683e-03f, 2.38667205e-02f, -1.00804754e-01f, 8.55560321e-03f, 4.65202816e-02f, -6.65015653e-02f, -2.61656437e-02f,
  8.19220841e-02f, 9.43017155e-02f, -2.32760757e-02f, 2.91426331e-02f, 4.19927835e-02f, -3.05744726e-03f, -5.42551354e-02f, 5.84110133e-02f, -2.06548590e-02f, 1.08615216e-02f,
  1.00384951e-02f, -5.87086380e-02f, 1.41421305e-02f, -1.06509529e-01f, -4.22271900e-02f, -1.23363947e-02f, 1.47284325e-02f, 1.55544821e-02f, -8.52413997e-02f, 5.35508022e-02f,
  -5.23905717e-02f, 6.18229844e-02f, 6.23273663e-02f, -1.47234024e-02f, -5.27556650e-02f, 3.38872056e-03f, 3.30017842e-02f, -1.44330831e-02f, 1.57068633e-02f, 8.23560655e-02f,
  -1.10597156e-01f, -9.28013176e-02f, 1.57952439e-02f, -5.50142080e-02f, -6.14651144e-02f, -2.80851554e-02f, -4.21837792e-02f, -2.19435635e-04f, 1.16434973e-02f, -3.70886885e-02f,
  8.64070002e-03f, 9.33155864e-02f, 4.25075032e-02f, -3.85793783e-02f, -9.27851647e-02f, -9.57767963e-02f, -4.34283279e-02f, 1.42795928e-02f, 4.58609575e-04f, -4.15329523e-02f,
  -1.01770870e-01f, 7.18464479e-02f, -5.22078648e-02f, -1.99543964e-02f, -1.02768736e-02f, 7.36518344e-03f, 6.72059366e-03f, -2.98950411e-02f, 6.59728050e-02f, 4.31012064e-02f,
  -1.77767873e-01f, -4.45396360e-03f, 1.09371357e-01f, -2.89584808e-02f, -4.43447530e-02f, 7.21757561e-02f, -5.92693649e-02f, 1.29777044e-01f, 4.46161255e-02f, -6.71821758e-02f,
  -4.74884100e-02f, -1.11707523e-01f, 4.34867516e-02f, 4.63345982e-02f, 4.77318428e-02f, -4.37371023e-02f, -8.99371952e-02f, -7.22612217e-02f, 3.05322045e-03f, -9.79513582e-03f,
  -1.05504468e-01f, 6.89608753e-02f, -2.72489637e-02f, -5.05125523e-02f, -2.79228501e-02f, -5.35749607e-02f, -1.82854701e-02f, -5.07169068e-02f, 6.46382512e-04f, 2.29881387e-02f,
  -8.97394642e-02f, -5.31439818e-02f, -1.07772961e-01f, -6.49833307e-02f, 4.46349457e-02f, 2.40081190e-05f, -4.42949459e-02f, -7.48044848e-02f, 4.65511866e-02f, -2.23516067e-03f,
  2.56860768e-03f, 7.83525333e-02f, -4.31881845e-02f, 2.93222480e-02f, 6.82282522e-02f, 6.71584010e-02f, 2.77903713e-02f, 1.04008280e-02f, -2.16557868e-02f, 9.49028134e-02f,
  -5.29965125e-02f, -4.17144336e-02f, 7.18433559e-02f, 6.06180206e-02f, 2.71435571e-03f, -8.87250900e-03f, -2.73390301e-02f, 2.35206764e-02f, -6.89438134e-02f, 6.30267039e-02f,
  9.52708870e-02f, -2.01812591e-02f, -1.14252104e-03f, -2.03520469e-02f, 6.28751889e-02f, 4.48606685e-02f, 8.30963999e-02f, 3.80330011e-02f, -2.91297920e-02f, -3.08434404e-02f,
  -6.80551305e-02f, -4.92034368e-02f, 2.43059266e-02f, -3.32821608e-02f, 8.39468166e-02f, 3.82265775e-03f, 6.46732226e-02f, 6.00597374e-02f, 8.09544474e-02f, 8.71018693e-02f,
  -7.22434670e-02f, -3.63012813e-02f, -2.48181894e-02f, 6.43543005e-02f, 5.64884841e-02f, -1.84653271e-02f, 6.72277622e-03f, -9.39333215e-02f, -1.04274012e-01f, -7.42122307e-02f,
  -9.25158337e-02f, -4.73378636e-02f, -2.59187967e-02f, 3.44687104e-02f, 2.25313362e-02f, 1.61900092e-02f, -3.89497814e-04f, -5.11733070e-02f, 6.91781985e-03f, -2.59997621e-02f,
  -8.42076614e-02f, -7.41102770e-02f, -4.14670743e-02f, -4.25079726e-02f, 4.25631441e-02f, 6.33218214e-02f, 8.67887773e-03f, 9.91916005e-03f, 3.29765975e-02f, -4.66770045e-02f,
  -7.27813989e-02f, 1.96545850e-03f, -6.42905980e-02f, 4.14052047e-02f, 5.44341430e-02f, 4.17370088e-02f, -3.98377068e-02f, 7.17515498e-02f, -6.68071955e-02f, -3.69898230e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.22458719e-01f, 1.76869869e-01f, 1.48096234e-01f, -1.76299624e-02f, 7.53490925e-02f, 1.57707140e-01f, 9.85648781e-02f, 1.11259282e-01f, 7.15095550e-02f, 2.40522325e-02f,
  -5.25269471e-03f, 1.90975089e-02f, 1.29531205e-01f, 6.17221035e-02f, -4.72759195e-02f, -2.83373483e-02f, 1.54671250e-02f, 7.66989123e-03f, 5.96307889e-02f, 7.09896833e-02f,
  1.31691948e-01f, 5.52529655e-02f, 1.38648003e-01f, -1.84279457e-02f, 1.08300656e-01f, 7.73940235e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.73682429e-03f, 1.71202011e-02f, 4.07107957e-02f, -2.73979716e-02f, -6.93133846e-02f, -1.06449381e-01f, 5.05432077e-02f, -1.47071913e-01f, -1.57199189e-01f, 1.42710894e-01f,
  2.12709736e-02f, 2.80307531e-02f, -1.32677913e-01f, -1.89643481e-03f, -1.25225827e-01f, 1.84461586e-02f, 9.20996219e-02f, -9.52332690e-02f, -4.58439514e-02f, -1.51514709e-01f,
  -2.86914378e-01f, 9.74198356e-02f, 2.21109480e-01f, 1.17396817e-01f, -1.49865806e-01f, 2.12968335e-01f, -1.78077016e-02f, 1.29883155e-01f, -6.76784813e-02f, 3.33235189e-02f,
  -2.70130724e-01f, 1.45524263e-01f, -9.23344865e-02f, -2.10812595e-03f, 7.03331977e-02f, 2.97962315e-02f, 9.08513889e-02f, 1.10164389e-01f, 8.94108862e-02f, -8.30868259e-02f,
  -1.34595200e-01f, -8.64286572e-02f, -9.74288806e-02f, 4.52281721e-02f, 1.24741144e-01f, 5.55278324e-02f, -1.58163197e-02f, 7.37024024e-02f, 4.81707305e-02f, 3.44122648e-02f,
  -1.15773380e-01f, -7.67465308e-02f, -5.64987659e-02f, 2.92453598e-02f, 4.78053279e-02f, 4.18508388e-02f, -1.34021625e-01f, -1.15310745e-02f, -3.66939530e-02f, 6.25621676e-02f,
  4.14209738e-02f, -1.68593362e-01f, -7.63784945e-02f, 3.08561586e-02f, 7.52622932e-02f, -1.64677985e-02f, 5.83862537e-04f, 1.70966387e-01f, -8.10862780e-02f, -6.27077296e-02f,
  1.18950173e-01f, -7.82026425e-02f, 1.77442476e-01f, 7.86164626e-02f, 1.53699189e-01f, 8.54754746e-02f, 6.25141114e-02f, 2.00901181e-01f, -3.77155989e-02f, 1.47866318e-02f,
  7.34541491e-02f, -7.77596086e-02f, 1.15082271e-01f, -5.95546179e-02f, -1.40897289e-01f, -1.06683768e-01f, 2.21355468e-01f, 2.13220179e-01f, -9.48140770e-02f, 1.78753570e-01f,
  -1.13982432e-01f, 8.38175565e-02f, -1.52857164e-02f, 1.55730555e-02f, -2.75663286e-01f, 2.22615972e-01f, -1.53427839e-01f, -7.15461373e-02f, -2.13853884e-02f, 1.80814907e-01f,
  1.85763195e-01f, 4.98203076e-02f, -5.93194887e-02f, 9.11271945e-02f, -1.04970448e-01f, -6.73864558e-02f, -8.68329313e-03f, 2.20769621e-03f, 1.86214049e-03f, -4.87538278e-02f,
  -6.63720816e-02f, -3.76280285e-02f, 5.19467182e-02f, 1.24816876e-03f, -2.41074279e-01f, -2.53388309e-03f, 3.00099645e-02f, -1.20831832e-01f, 1.57961830e-01f, -1.46483704e-01f,
  -2.04348847e-01f, -2.28977501e-02f, -2.30030581e-01f, 8.28470439e-02f, 3.00119407e-02f, -6.59191161e-02f, 8.98430683e-03f, -5.05193975e-03f, -6.45596460e-02f, -7.93568045e-02f,
  4.31537442e-02f, 4.95036729e-02f, -1.12295197e-02f, -7.26242661e-02f, -3.28265391e-02f, -1.06244378e-01f, -1.12672430e-02f, 2.55262852e-02f, 9.29847285e-02f, -1.26348749e-01f,
  3.97490487e-02f, -1.24631695e-01f, 2.66470015e-02f, 4.75258306e-02f, -9.66589525e-02f, -2.35939771e-02f, 9.82525200e-03f, -5.90259060e-02f, 4.96042930e-02f, 1.42476976e-01f,
  -3.47177358e-03f, 6.66890964e-02f, 2.45819520e-02f, -1.25792861e-01f, -8.12260881e-02f, -8.10420513e-02f, 2.05922842e-01f, 1.19852886e-01f, -1.54236138e-01f, -1.16601577e-02f,
  1.48121387e-01f, -7.74683356e-02f, 1.77871898e-01f, -1.22862600e-01f, -1.35566249e-01f, -1.74050767e-03f, -2.75478549e-02f, -1.10642552e-01f, 1.29406884e-01f, -9.16467831e-02f,
  -1.07234605e-01f, -5.10786436e-02f, 1.57278795e-02f, -1.52771816e-01f, 9.14304629e-02f, -5.54932728e-02f, -1.26768529e-01f, -2.71435324e-02f, -1.67427876e-04f, -4.90618348e-02f,
  -6.27750829e-02f, -4.08194065e-02f, 3.09378281e-02f, -1.42668739e-01f, 8.48996118e-02f, -1.23956926e-01f, 4.28707227e-02f, -8.43666047e-02f, 3.02469321e-02f, -3.16091441e-02f,
  1.58582196e-01f, -1.18446991e-01f, 9.99915376e-02f, -6.73156306e-02f, -4.71725650e-02f, -1.31818175e-01f, 5.51089719e-02f, 5.61357588e-02f, -1.36260614e-01f, 6.03729300e-02f,
  -2.67674625e-01f, 6.39212504e-02f, -1.67695537e-01f, -4.44604792e-02f, 9.36285779e-02f, 5.27062174e-03f, -3.51511203e-02f, 4.94425222e-02f, -5.59323169e-02f, 1.90153234e-02f,
  3.97456251e-02f, -1.79639563e-01f, 1.78130805e-01f, -2.94424258e-02f, 1.86898232e-01f, -5.67271449e-02f, -6.75850660e-02f, 7.53133446e-02f, 1.48121864e-01f, -4.93176654e-02f,
  -8.49613249e-02f, -2.16959119e-01f, 1.60477147e-01f, -1.97336860e-02f, -5.95294870e-02f, 1.63979977e-01f, 1.44339740e-01f, 6.92477226e-02f, -1.78632855e-01f, 4.90748733e-02f,
  6.24851175e-02f, -3.42222373e-03f, 8.17903429e-02f, 5.67784486e-03f, -1.01514466e-01f, -1.22973911e-01f, -1.07217720e-02f, -5.95991015e-02f, 5.03739491e-02f, 1.50536835e-01f,
  -9.05631781e-02f, 6.35567680e-02f, -7.27257952e-02f, 1.06544688e-01f, 1.37300324e-02f, 4.41434681e-02f, -9.20537934e-02f, 1.67532593e-01f, 1.38548212e-02f, 1.07992264e-02f,
  -1.29900584e-02f, 4.17713728e-03f, 5.40051498e-02f, 2.72883866e-02f, -1.23295873e-01f, -5.89971431e-02f, 6.49337918e-02f, -6.54722229e-02f, 1.55522928e-01f, -3.64053324e-02f,
  1.21257216e-01f, -7.44675323e-02f, -8.40941593e-02f, 1.10299177e-01f, 1.75643247e-02f, -8.51882529e-03f, -7.32969493e-02f, 1.15872927e-01f, -8.94153118e-02f, 3.53438556e-02f,
  5.20350737e-03f, 2.04433188e-01f, -9.99792814e-02f, 1.42719641e-01f, -1.68148931e-02f, -2.06571162e-01f, 2.07626507e-01f, 1.80464923e-01f, 2.69909710e-01f, -2.77472705e-01f,
  3.36943455e-02f, -8.75018910e-02f, -9.45419371e-02f, 2.51191735e-01f, -9.54391584e-02f, -1.84211642e-01f, -2.18849331e-01f, -1.60201043e-01f, -7.88273588e-02f, 1.78372741e-01f,
  1.25914365e-01f, -1.73258141e-01f, -7.07849413e-02f, 4.60798442e-02f, -3.25970016e-02f, 9.43608209e-02f, -3.03090028e-02f, 7.73921758e-02f, -5.05611785e-02f, -1.97751284e-01f,
  -1.32538686e-02f, -1.44512802e-01f, -6.39243796e-02f, 6.83119446e-02f, 3.35769840e-02f, 4.41659652e-02f, -1.23519778e-01f, -2.64904983e-02f, -7.19059855e-02f, 5.07049449e-02f,
  1.12066288e-02f, 9.09211561e-02f, -5.06664813e-02f, 7.75768235e-02f, 9.16985124e-02f, -5.80153707e-03f, 1.18837267e-01f, -7.86085576e-02f, -5.51206283e-02f, -1.14374332e-01f,
  4.13222387e-02f, -3.13613042e-02f, -3.78847346e-02f, 1.23998262e-01f, 1.41902804e-01f, 1.55412853e-01f, 1.23720765e-01f, -1.57841500e-02f, 2.17876527e-02f, 2.42735650e-02f,
  1.33514985e-01f, 6.19698279e-02f, -8.47652107e-02f, 5.93847595e-02f, -1.65648572e-02f, -3.15391012e-02f, -5.03556877e-02f, 1.13055517e-03f, -7.47455880e-02f, -1.04071401e-01f,
  -2.07339630e-01f, 9.24533606e-02f, 1.16198696e-01f, 1.51070401e-01f, -1.33784637e-01f, 4.32799943e-02f, 6.35884702e-02f, 2.60301113e-01f, 6.11095428e-02f, -1.21579424e-01f,
  -2.46971846e-01f, 1.49055213e-01f, -5.91838211e-02f, 7.65134767e-02f, -1.06019258e-01f, -4.51745093e-02f, 4.44179662e-02f, 5.10988235e-02f, 2.73071583e-02f, 9.37348083e-02f,
  -1.32254325e-02f, 6.70635188e-03f, -1.49053976e-01f, 1.74198113e-03f, 1.22245982e-01f, -3.66798937e-02f, 1.33280545e-01f, 3.33150737e-02f, 1.51148498e-01f, 9.81053188e-02f,
  -4.44108294e-03f, -1.27673969e-01f, -1.72560841e-01f, -1.24175465e-02f, 1.63570359e-01f, -3.12847160e-02f, -1.07457250e-01f, -1.00218840e-01f, 7.62917101e-02f, -3.73687185e-02f,
  -6.00285232e-02f, -7.60625750e-02f, -3.45182829e-02f, 6.06908649e-02f, 8.14811513e-02f, -5.53371124e-02f, 1.32944718e-01f, -1.51258826e-01f, 1.29655629e-01f, 6.26044646e-02f,
  7.99883530e-02f, 1.80475041e-01f, -2.21184835e-01f, 8.94888192e-02f, 5.28204546e-04f, -1.78774036e-02f, -5.60675301e-02f, -3.28709595e-02f, 1.26750872e-01f, 2.41319194e-01f,
  1.09285079e-01f, 6.09019026e-02f, 5.45129962e-02f, -1.71416439e-03f, 3.86708193e-02f, 1.59736603e-01f, 1.76791355e-01f, 1.70560763e-03f, -4.58900072e-02f, -1.37004972e-01f,
  1.11847363e-01f, -1.23029705e-02f, 2.93090940e-01f, 1.00648083e-01f, -9.14356858e-03f, -4.27133925e-02f, 1.85760379e-01f, -2.08103597e-01f, 2.53308952e-01f, 2.12796498e-02f,
  -1.17557317e-01f, -1.22324549e-01f, -3.54005545e-02f, 6.98752552e-02f, 3.60433049e-02f, 2.26267539e-02f, -1.55698159e-03f, -3.48920077e-02f, 1.14469573e-01f, 6.75880015e-02f,
  9.28951129e-02f, 1.62614956e-01f, -1.00094154e-01f, 1.07124867e-03f, -1.37053385e-01f, 5.70052825e-02f, 1.04357399e-01f, -8.27321317e-03f, 1.45161286e-01f, 5.89397438e-02f,
  4.13432196e-02f, -9.94467661e-02f, 1.13532200e-01f, -1.60041288e-01f, 1.58168122e-01f, -5.86889200e-02f, -1.83267072e-01f, 5.40986918e-02f, -5.82399033e-02f, -5.81052080e-02f,
  -1.53412506e-01f, 4.67035882e-02f, -1.58760592e-01f, -6.73841510e-04f, 1.00731440e-01f, 7.44711757e-02f, 4.78698239e-02f, 7.61972293e-02f, 1.47855803e-01f, 7.48220757e-02f,
  -1.31511956e-01f, 9.06142145e-02f, 1.70475602e-01f, 9.66864228e-02f, -3.30064744e-02f, -1.12340413e-01f, -3.97501625e-02f, 1.40087344e-02f, -2.53605787e-02f, 2.05374539e-01f,
  -6.74011484e-02f, -4.86787595e-02f, -1.88506559e-01f, -1.63292721e-01f, -2.65884995e-01f, 9.51444954e-02f, 1.49212207e-03f, 5.65274693e-02f, -2.68309385e-01f, 5.09389341e-02f,
  1.21761531e-01f, -1.08559132e-01f, 2.59624869e-01f, -1.29129812e-01f, 1.12868184e-02f, -5.06473854e-02f, -1.30041450e-01f, 1.14685908e-01f, 4.29267213e-02f, -8.97049382e-02f,
  1.12290587e-02f, -4.31834273e-02f, -9.38867554e-02f, -9.94914323e-02f, 1.49129584e-01f, 5.00716604e-02f, 1.27606794e-01f, 1.16062604e-01f, 9.73590761e-02f, 1.14178546e-02f,
  -8.06382522e-02f, 1.39338076e-01f, 3.62370946e-02f, 1.06442921e-01f, 1.31503418e-01f, -1.55702218e-01f, 1.63560316e-01f, -6.21816702e-02f, -1.13612190e-01f, 2.06279997e-02f,
  1.92130461e-01f, -7.68260136e-02f, -4.45159972e-02f, -1.83442160e-01f, 1.28366146e-02f, 1.84019744e-01f, 1.15884513e-01f, -5.48634771e-03f, -1.32055273e-02f, -8.06484818e-02f,
  8.83270726e-02f, 1.47567600e-01f, 1.68896422e-01f, 1.02344252e-01f, 1.52678462e-02f, -1.48161789e-02f, -6.92986250e-02f, 8.41483194e-03f, -4.40917276e-02f, 8.19322616e-02f,
  1.18119493e-01f, -2.92833239e-01f, -9.13263187e-02f, 2.50146836e-01f, 2.91204522e-03f, 1.04388893e-01f, -3.68815474e-02f, -1.07037678e-01f, -2.14874014e-01f, 3.68489176e-02f,
  9.99659970e-02f, -2.46192347e-02f, -2.17906639e-01f, 1.45035729e-01f, -1.39756873e-01f, -1.19052388e-01f, 2.48566687e-01f, 3.70519646e-02f, -7.43591636e-02f, 2.88645685e-01f,
  2.97158919e-02f, 1.50343761e-01f, 1.03273503e-01f, 3.08341999e-02f, -7.24867657e-02f, -1.11559980e-01f, -7.56767541e-02f, -1.89421833e-01f, 2.00977877e-01f, 2.01977432e-01f,
  8.53896588e-02f, 6.26799911e-02f, 4.50572595e-02f, -2.10917771e-01f, -1.38430163e-01f, -7.15047643e-02f, 1.53703704e-01f, 1.30175352e-02f, 2.01917455e-01f, 9.75913927e-02f,
  1.43680006e-01f, 8.85688514e-02f, -1.01144627e-01f, 1.31336797e-03f, 2.73681194e-01f, -4.84149829e-02f, 1.31794497e-01f, 2.30245769e-01f, 1.36425063e-01f, -6.54639527e-02f,
  -9.87862423e-03f, 9.73398909e-02f, 2.90575791e-02f, -5.31562753e-02f, -1.00437142e-01f, -6.56698123e-02f, 6.53346721e-03f, 4.73793149e-02f, -6.55914918e-02f, -2.80036349e-02f,
  -5.29211164e-02f, -6.02797456e-02f, 2.95050815e-03f, 1.98751092e-02f, 8.24163482e-02f, 2.04239503e-01f, 2.09963202e-01f, -9.02995989e-02f, 3.12628560e-02f, -5.03987111e-02f,
  -3.12046264e-03f, -1.86262563e-01f, 8.87874812e-02f, 1.17464691e-01f, 1.92224309e-01f, 1.90198913e-01f, 5.47720604e-02f, -2.65085042e-01f, 8.02289546e-02f, 9.56288278e-02f,
  4.76793945e-02f, -2.15653598e-01f, -1.71087533e-01f, -4.39941436e-02f, -8.30122679e-02f, -3.00335512e-02f, -9.92564261e-02f, 1.18255444e-01f, 3.72967981e-02f, 3.15402597e-02f,
  6.35427460e-02f, 6.05903938e-03f, 2.98465379e-02f, 4.41081403e-03f, 1.08938909e-03f, -3.13337743e-02f, 1.32188290e-01f, -1.10207252e-01f, -6.85699657e-02f, 1.83041006e-01f,
  1.02621540e-01f, -5.89422919e-02f, 1.04609281e-01f, -4.36832309e-02f, 6.31921962e-02f, -1.25351295e-01f, 1.64133072e-01f, 1.15086548e-02f, -1.59003511e-01f, -1.11605987e-01f,
  -4.31418568e-02f, -4.22981102e-03f, -1.18755229e-01f, -5.89241683e-02f, -3.72385532e-02f, -2.68708412e-02f, -2.57831998e-02f, -4.15678471e-02f, 2.98317149e-02f, -1.35900872e-02f,
  2.10840791e-01f, -3.31980847e-02f, 2.19157971e-02f, -1.77782066e-02f, 6.75992146e-02f, 1.81688648e-02f, -4.98797446e-02f, -1.42955706e-02f, -2.55858544e-02f, -9.23143476e-02f,
  -7.32949451e-02f, -9.53185633e-02f, -2.73695171e-01f, 1.98332593e-01f, 6.86607957e-02f, -8.91312957e-02f, 1.09864390e-02f, -2.22927272e-01f, 1.59935251e-01f, 1.49168655e-01f,
  6.73798099e-02f, 4.93539218e-03f, 1.67373642e-01f, -7.14850277e-02f, 2.19274387e-02f, 4.48969752e-03f, -3.25316489e-02f, 1.44554839e-01f, -2.06662249e-02f, -1.14310399e-01f,
  9.77126360e-02f, -1.72050111e-02f, -1.47057742e-01f, 1.24536030e-01f, -1.42695010e-01f, -4.33503278e-02f, -2.15780828e-02f, -9.39175785e-02f, 5.35939597e-02f, -3.32393833e-02f,
  6.17073551e-02f, -2.55564302e-01f, -4.39250953e-02f, -7.18331337e-02f, 5.75385429e-02f, -2.86472635e-03f, 4.33848090e-02f, -2.48637190e-03f, -3.44710834e-02f, 1.25374690e-01f,
  -1.56995267e-01f, -1.62567064e-01f, -6.35665506e-02f, -1.12909578e-01f, 1.36906147e-01f, 6.26709610e-02f, 3.51686813e-02f, -8.64486173e-02f, 5.99314384e-02f, 1.90197363e-01f,
  -6.18160143e-02f, -7.46194571e-02f, -2.69058999e-02f, -9.21645202e-03f, 1.66865721e-01f, -8.83558858e-03f, 2.03472301e-02f, 3.80282663e-02f, 1.65658835e-02f, 8.17735493e-02f,
  -7.58221466e-03f, 7.33666271e-02f, 7.85414204e-02f, 7.23529549e-04f, 2.13537529e-01f, 3.37995589e-02f, -1.98503509e-01f, -1.40322968e-01f, 7.87357017e-02f, -1.13395341e-01f,
  -1.44642442e-01f, 9.15118158e-02f, 1.28261298e-01f, 2.12121904e-01f, 6.91265538e-02f, -2.12720469e-01f, 2.24648342e-02f, -1.80311754e-01f, 1.70490183e-02f, -1.80338308e-01f,
  -1.47027569e-02f, -6.99674860e-02f, -8.07376280e-02f, -2.63830852e-02f, 1.56427339e-01f, -6.65699411e-03f, 9.79474708e-02f, -3.97673994e-02f, -9.80685651e-02f, 1.08456938e-03f,
  7.16144815e-02f, -2.46628106e-01f, -1.87304437e-01f, -8.35850686e-02f, 1.34745464e-01f, -1.23036839e-02f, -4.67142761e-02f, -8.82790983e-02f, 3.81331667e-02f, 6.23049773e-03f,
  1.82123601e-01f, 2.05199253e-02f, 1.11627966e-01f, -1.34922303e-02f, -1.14027604e-01f, -1.01554640e-01f, -9.21589360e-02f, -1.01424165e-01f, 6.16313778e-02f, 1.67936131e-01f,
  -5.73908687e-02f, -9.12302285e-02f, -1.06303215e-01f, 6.86572567e-02f, 5.96773485e-03f, 5.72551787e-03f, -9.01919976e-03f, 2.64865113e-03f, -7.10429475e-02f, 4.03012289e-03f,
  -2.11652815e-01f, -5.05888835e-02f, 1.40519500e-01f, 1.30156368e-01f, -3.89997894e-03f, -6.34214580e-02f, -2.36304775e-02f, 2.65051126e-01f, -3.93477716e-02f, -6.10811636e-02f,
  5.73958680e-02f, 1.36257052e-01f, 8.04267358e-03f, -5.54496795e-02f, -1.26269713e-01f, -1.19956121e-01f, 2.13046730e-01f, 1.43604651e-01f, -1.69711724e-01f, -1.34594627e-02f,
  1.22074723e-01f, -1.36022732e-01f, -6.43933415e-02f, -1.01879217e-01f, 1.15555488e-01f, -1.48436233e-01f, -1.76675230e-01f, -6.89944299e-03f, -1.02434896e-01f, 5.58691211e-02f,
  1.35245845e-01f, 1.66606158e-01f, 2.84330416e-02f, 8.85216519e-02f, -2.45215707e-02f, 1.21087790e-01f, 1.02003127e-01f, -1.81438729e-01f, 1.45934531e-02f, 7.81200007e-02f,
  1.10037535e-01f, -6.82606967e-03f, 1.80360284e-02f, 6.57430440e-02f, -1.17131315e-01f, -2.48381943e-02f, 1.72221974e-01f, -9.10111070e-02f, 9.17822346e-02f, 9.24032554e-02f,
  -2.70664669e-03f, 5.09671569e-02f, -8.54479596e-02f, 8.55245143e-02f, -9.77492556e-02f, 2.01425314e-01f, -3.42990234e-02f, 1.21057585e-01f, -4.47213016e-02f, -1.14239037e-01f,
  1.92197546e-01f, -4.27797176e-02f, 3.34789306e-02f, 6.06895462e-02f, -1.39277101e-01f, -1.10509833e-02f, 1.90506876e-01f, 1.40947506e-01f, 1.28616467e-01f, -1.21858619e-01f,
  -1.15729272e-02f, 4.91259135e-02f, 7.98537061e-02f, 5.11709787e-02f, -8.60142186e-02f, 1.32026345e-01f, -1.30920321e-01f, 3.94750983e-02f, -1.98868304e-01f, -2.17065647e-01f,
  -4.20461351e-04f, 1.29068807e-01f, -1.36405006e-01f, 9.47788209e-02f, -3.04293130e-02f, -1.76849559e-01f, 2.59660296e-02f, -7.80415609e-02f, 1.85234472e-01f, 7.58592933e-02f,
  -6.93814158e-02f, 1.24181919e-01f, -4.21645027e-03f, -1.20188497e-01f, 4.62407134e-02f, 4.28886060e-03f, 4.76077013e-03f, -4.64820713e-02f, -6.00895248e-02f, -1.08077213e-01f,
  1.83135048e-01f, -8.27318728e-02f, 1.12000845e-01f, 3.91975343e-02f, -8.85606930e-02f, 8.80940408e-02f, 4.28115390e-02f, -8.34402815e-03f, -1.12180188e-02f, 1.23137617e-02f,
  2.84938756e-02f, -4.57629003e-02f, -1.58612579e-01f, -1.23373214e-02f, 1.73563272e-01f, 8.28506425e-02f, 9.29346383e-02f, 4.04991955e-03f, 1.62214711e-01f, 3.19025069e-02f,
  1.97825823e-02f, -1.24701783e-01f, 4.26789597e-02f, 1.62565604e-01f, -1.73846841e-01f, 6.05434440e-02f, -2.16738209e-01f, -1.96726173e-02f, 8.97209868e-02f, 1.88878532e-02f,
  1.51982248e-01f, 9.30521414e-02f, 5.02498001e-02f, 5.72406501e-02f, -3.40206511e-02f, 8.72106329e-02f, 1.37131602e-01f, 6.94236998e-03f, -3.11906543e-02f, -6.04607016e-02f,
  -1.51483357e-01f, 8.50049928e-02f, 1.86528534e-01f, -1.64817467e-01f, 6.39477447e-02f, -2.95136124e-02f, 5.52362353e-02f, 3.21397632e-02f, -4.41929772e-02f, -9.07062963e-02f,
  1.60103932e-01f, 2.06645261e-02f, -1.56149790e-01f, 7.35774636e-02f, 1.05507173e-01f, 1.21045515e-01f, 8.07060823e-02f, -1.02711156e-01f, 1.32072330e-01f, -9.37077850e-02f,
  3.65299988e-03f, -3.26016247e-02f, -4.67811190e-02f, 2.25002483e-01f, -9.80162546e-02f, -1.07693397e-01f, -8.57161358e-02f, 6.74576387e-02f, 1.52277038e-01f, -7.32204765e-02f,
  7.51342550e-02f, 1.69065595e-01f, -9.25532356e-02f, 5.77044897e-02f, -9.48294476e-02f, -7.97057599e-02f, 5.58151789e-02f, -5.33814691e-02f, -1.42730042e-01f, 5.55894226e-02f,
  9.91159379e-02f, 1.16949260e-01f, -2.81752292e-02f, -4.33553793e-02f, 1.28815323e-01f, 3.79314423e-02f, -4.20709960e-02f, -1.60494018e-02f, -7.44091719e-02f, -1.44834310e-01f,
  -1.50532439e-01f, 2.16243695e-02f, 4.22660410e-02f, -1.02000624e-01f, 5.70546985e-02f, -1.90467760e-02f, -2.03719195e-02f, -7.60119110e-02f, -1.45460263e-01f, 6.23396561e-02f,
  1.92622006e-01f, -1.40446037e-01f, 9.25445259e-02f, -1.84336513e-01f, 6.91531450e-02f, 9.90024284e-02f, 2.67412871e-01f, -1.55067161e-01f, -2.08038509e-01f, -1.17770351e-01f,
  3.27276200e-01f, -5.98555021e-02f, -1.32025212e-01f, 1.96721420e-01f, -2.43305452e-02f, 1.93064496e-01f, -3.64483893e-02f, -3.63379829e-02f, 1.26196831e-01f, -9.34687629e-02f,
  8.12074989e-02f, 6.50037453e-02f, -5.86017929e-02f, -4.71784100e-02f, -1.24806546e-01f, 3.71274091e-02f, -1.08000144e-01f, 7.40638375e-02f, -2.36539468e-02f, -7.60822892e-02f,
  -9.16532651e-02f, 8.58820677e-02f, 7.30492026e-02f, 2.71136481e-02f, -1.83743060e-01f, 1.81502387e-01f, 6.24319166e-02f, 3.41283418e-02f, -1.22659534e-01f, 9.67002567e-03f,
  5.83663508e-02f, -7.08202720e-02f, -1.35701269e-01f, 1.63638759e-02f, -8.64642933e-02f, -5.27126081e-02f, 6.19522063e-03f, -1.19435348e-01f, 8.73368010e-02f, 1.79425385e-02f,
  4.94566634e-02f, 1.43903613e-01f, -7.75722191e-02f, 3.27416919e-02f, 1.85669169e-01f, 6.60296006e-04f, 8.62861574e-02f, -3.57559435e-02f, -5.39967269e-02f, 5.54061830e-02f,
  -1.86200887e-02f, 1.03074171e-01f, 9.02083442e-02f, -1.11485876e-01f, -2.61393320e-02f, -8.96223187e-02f, -1.72997490e-01f, 8.63667354e-02f, 5.49013875e-02f, -2.26113856e-01f,
  1.39426827e-01f, -1.35546938e-01f, 2.51944542e-01f, 2.52519190e-01f, -4.03310545e-02f, -1.03397951e-01f, 1.57212973e-01f, -1.88341528e-01f, 1.51705340e-01f, -1.13542780e-01f,
  -4.81929705e-02f, -2.01758835e-02f, -1.49791036e-02f, 1.35617509e-01f, 2.00217828e-01f, 6.62612692e-02f, -1.09317169e-01f, -3.09273880e-03f, -1.15423001e-01f, 1.54036313e-01f,
  1.19535387e-01f, -6.93542287e-02f, 8.35949276e-03f, 3.96913774e-02f, 7.67867938e-02f, -2.99856871e-01f, -9.31399316e-02f, 1.64549146e-02f, 6.51013628e-02f, -1.09794550e-01f,
  -4.52733226e-02f, -5.61732687e-02f, 1.40322328e-01f, 4.32653651e-02f, -2.88666878e-02f, -2.05025122e-01f, -1.91212595e-01f, 1.28674656e-01f, -1.29078086e-02f, 6.36430224e-03f,
  9.16374996e-02f, -3.41321938e-02f, -7.20960274e-02f, -1.67691991e-01f, -1.54068455e-01f, 7.96707422e-02f, 3.26108336e-02f, -1.39717788e-01f, -2.54130781e-01f, 1.30221412e-01f,
  8.90316367e-02f, 1.82895437e-02f, 6.75425455e-02f, -1.50969952e-01f, 7.32313171e-02f, 1.00370608e-01f, -1.46659046e-01f, -1.44845113e-01f, 1.58870131e-01f, 1.30982980e-01f,
  6.09968565e-02f, -1.38703942e-01f, -2.03372434e-01f, 1.57353938e-01f, 2.95836795e-02f, -3.91426980e-02f, -1.05065674e-01f, -1.86559528e-01f, 1.78861558e-01f, -2.47109178e-02f,
  -9.88313109e-02f, 6.29435033e-02f, -1.29227579e-01f, -2.16904860e-02f, -1.10130534e-01f, 9.28632021e-02f, 6.23196363e-02f, -7.27348682e-03f, 1.04539894e-01f, 1.26402423e-01f,
  2.86623603e-03f, -9.64150354e-02f, -9.41125676e-02f, -3.73055302e-02f, 2.75540408e-02f, 2.44833067e-01f, -5.19451015e-02f, -2.18027961e-02f, -1.23764060e-01f, 8.84208009e-02f,
  -6.16542296e-03f, 5.16666286e-02f, -6.60532936e-02f, 1.52435288e-01f, -1.30613055e-02f, 2.70662140e-02f, -6.52491599e-02f, -1.59902945e-01f, -1.30494321e-02f, 1.40747413e-01f,
  6.55580014e-02f, -7.88978189e-02f, -2.40599774e-02f, -1.13018543e-01f, -8.06425139e-02f, 1.10774465e-01f, 4.74930070e-02f, 5.19073382e-02f, -1.75073780e-02f, -1.65737141e-02f,
  -7.46953022e-03f, 1.57504737e-01f, 6.44969493e-02f, 8.28926340e-02f, 2.44756807e-02f, 8.79727006e-02f, 2.24338286e-03f, -2.08704248e-02f, -1.27739489e-01f, 5.83638810e-02f,
  -2.96814013e-02f, -4.91294712e-02f, -2.01342404e-01f, 9.66041908e-03f, 1.29319564e-01f, 1.34580657e-01f, 1.26532298e-02f, 1.73962787e-01f, -4.07406595e-04f, 1.08858012e-01f,
  7.85018504e-03f, -8.92737284e-02f, -1.90009728e-01f, 2.23163590e-01f, -4.10313308e-02f, -7.35023096e-02f, 6.96000382e-02f, -2.12079585e-02f, 4.95739095e-02f, -6.38034120e-02f,
  4.48595993e-02f, -1.26475006e-01f, 1.61766037e-02f, -1.34236768e-01f, 8.44472870e-02f, 1.15923412e-01f, -5.45016639e-02f, 5.81987500e-02f, 7.27432668e-02f, 1.20572507e-01f,
  -1.32053811e-02f, 9.62031409e-02f, 8.48218128e-02f, -1.25459045e-01f, -1.71501070e-01f, -7.76999816e-02f, -1.40575990e-02f, -6.76060468e-02f, -2.41220333e-02f, -8.09107423e-02f,
  -5.26245162e-02f, 1.39363289e-01f, -2.17764135e-02f, 2.84879133e-02f, 2.01426297e-01f, -1.06104776e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.13041280e-02f, 1.30509943e-01f, -6.52242778e-03f, 1.02894984e-01f, 1.49582401e-02f, 7.72242807e-03f, 8.08981135e-02f, -6.56207651e-02f, -7.20783276e-03f, 1.70378312e-01f,
  1.51378736e-01f, -4.43123244e-02f, 1.42005414e-01f, 1.64605722e-01f, 1.19044289e-01f, 1.66030034e-01f, 1.39937833e-01f, -5.44468351e-02f, 1.37726739e-01f, 4.91653718e-02f,
  7.34252259e-02f, 5.12746796e-02f, 1.36576295e-01f, 7.33398274e-02f, 1.91534050e-02f, -1.39978632e-01f, -1.59855947e-01f, 1.63935110e-01f, 6.41795918e-02f, 1.72869533e-01f,
  -5.87024614e-02f, 5.51845022e-02f, 1.65028557e-01f, -1.23157956e-01f, 3.49680148e-02f, -3.96938808e-02f, 1.10587804e-02f, 9.31892991e-02f, 1.05821356e-01f, -9.23270136e-02f,
  -5.84738096e-03f, 1.13476418e-01f, 1.10031024e-01f, -5.51136956e-02f, 1.62952185e-01f, -1.95396096e-02f, -8.79314989e-02f, 2.73464210e-02f, -7.13660717e-02f, -1.25199467e-01f,
  7.94797912e-02f, -9.57287997e-02f, 8.16078112e-02f, 1.97249409e-02f, 7.61236176e-02f, 5.61357103e-02f, 5.21742702e-02f, -2.62680873e-02f, -1.89569052e-02f, -1.09884553e-01f,
  3.84498127e-02f, 5.67692630e-02f, 8.60196203e-02f, 1.09667301e-01f, 7.09510818e-02f, 1.75437573e-02f, 1.15895323e-01f, -7.46757686e-02f, -1.03472201e-02f, -5.87358661e-02f,
  4.50673178e-02f, 1.81008875e-01f, 3.50609794e-02f, -2.25127954e-03f, 1.29512295e-01f, 8.38970616e-02f, 1.75799653e-01f, 9.09987316e-02f, -1.67033225e-02f, 8.85017402e-03f,
  1.55184597e-01f, -7.98961334e-03f, 7.96199515e-02f, -7.34428689e-02f, 9.60726663e-02f, 3.13065462e-02f, 1.10005245e-01f, 1.82390213e-02f, -8.24746192e-02f, -6.07719645e-02f,
  -9.16293636e-03f, 3.21925953e-02f, -1.22459203e-01f, -5.88611625e-02f, 1.22385696e-01f, -1.60897240e-01f, -3.11548524e-02f, 6.79567531e-02f, 5.30727021e-02f, 6.88362569e-02f,
  -1.55528821e-02f, 2.15326995e-02f, -7.59808421e-02f, 8.94965008e-02f, 1.75002173e-01f, 3.54382093e-03f, -4.25143577e-02f, -1.65518299e-02f, -7.54640996e-02f, -1.01960078e-01f,
  -1.39055131e-02f, -8.53607059e-03f, -1.27467573e-01f, 9.66229886e-02f, -7.19958842e-02f, 8.86390880e-02f, 1.57743767e-01f, 3.84421647e-02f, -4.72425716e-03f, 1.90865919e-01f,
  5.71662225e-02f, -6.92497641e-02f, 8.99978504e-02f, -1.33404911e-01f, 5.53056821e-02f, 1.25646651e-01f, -1.14059687e-01f, 9.77857932e-02f, 4.06837277e-02f, -9.58199985e-03f,
  1.04114890e-01f, -2.18928456e-02f, 2.69320942e-02f, 6.79151807e-03f, -8.98655097e-04f, -4.68749888e-02f, -5.34124002e-02f, 5.75758703e-02f, 1.42425567e-01f, 2.85070762e-02f,
  1.26493424e-01f, -5.71369529e-02f, 7.12651983e-02f, 4.43663821e-02f, -7.52853230e-02f, -2.96907984e-02f, 3.99903767e-02f, 2.82760076e-02f, -3.68830226e-02f, -5.18547334e-02f,
  -3.29405777e-02f, -1.26425490e-01f, 6.57347590e-02f, -5.83580025e-02f, 1.65142074e-01f, 1.45989461e-02f, -1.48153193e-02f, 2.31128912e-02f, -1.03907704e-01f, 6.83712736e-02f,
  -6.86004758e-02f, 1.03915617e-01f, -1.51112676e-01f, -8.17581788e-02f, -1.00115858e-01f, -1.64402425e-01f, 1.20267898e-01f, -9.74504650e-02f, -4.36461940e-02f, 1.04925536e-01f,
  9.89945829e-02f, 1.28763318e-01f, -5.41362865e-03f, 1.06935702e-01f, -6.41691014e-02f, 7.49101564e-02f, 3.23343091e-02f, 7.29543120e-02f, 5.63231148e-02f, -9.60082859e-02f,
  -1.07179269e-01f, 1.00179136e-01f, 6.53147511e-03f, -6.80463612e-02f, -1.39092758e-01f, 1.36016533e-01f, -5.09198196e-02f, -7.37023577e-02f, 1.21233068e-01f, -6.79440573e-02f,
  -6.91890344e-02f, 9.29781199e-02f, 1.39810085e-01f, -6.04176931e-02f, 8.88696015e-02f, 5.77682741e-02f, -2.16623265e-02f, 1.65948093e-01f, 1.69674214e-02f, 1.72501370e-01f,
  2.73399681e-01f, 1.08359195e-01f, 4.46951091e-02f, 1.49924263e-01f, -5.88895120e-02f, 1.61433652e-01f, 2.43155345e-01f, 1.84382260e-01f, 1.54165313e-01f, 1.64857537e-01f,
  2.22023189e-01f, 1.50217161e-01f, -1.86689094e-01f, -4.80121113e-02f, -1.06313974e-01f, 1.31460875e-01f, 9.21556875e-02f, -1.12266447e-02f, -2.62746364e-01f, 9.24182609e-02f,
  1.56446666e-01f, 1.04057625e-01f, -2.63479203e-01f, 6.12074398e-02f, 7.93608278e-02f, -1.76649287e-01f, 1.94928080e-01f, -2.02831686e-01f, 1.59476459e-01f, 5.98076209e-02f,
  -9.05302539e-02f, 7.19249398e-02f, -1.05900936e-01f, 4.37423633e-03f, -4.81646322e-02f, 1.60352245e-01f, 1.04218274e-01f, -1.28403902e-01f, 7.09905401e-02f, -9.16472524e-02f,
  3.35898027e-02f, -1.79539863e-02f, 2.95781940e-01f, 1.58042759e-02f, -2.59443093e-02f, 6.47581667e-02f, 9.45443064e-02f, -1.83484837e-01f, 1.01818793e-01f, 8.36062580e-02f,
  1.73500881e-01f, 1.09505795e-01f, 3.11000627e-02f, -7.34384954e-02f, 3.03568065e-01f, 4.78963740e-02f, 1.85301825e-01f, -6.22071959e-02f, 6.13555089e-02f, 2.63334155e-01f,
  -2.53719669e-02f, 1.11644745e-01f, -8.40836093e-02f, -7.93538764e-02f, 2.71625161e-01f, 6.82949126e-02f, 1.99582070e-01f, 2.01253697e-01f, 1.09196648e-01f, 2.10530877e-01f,
  -2.40550879e-02f, -1.59192961e-02f, 1.48302481e-01f, 1.20798700e-01f, 1.45728260e-01f, 3.74956392e-02f, -8.73557329e-02f, 4.01373431e-02f, -6.47922680e-02f, 1.96189359e-02f,
  -1.00713678e-01f, 3.80058354e-03f, -1.24300100e-01f, 2.52352320e-02f, -1.72089219e-01f, -1.68676600e-01f, 9.43509024e-03f, 5.53377345e-02f, 2.46176906e-02f, 1.66783616e-01f,
  -2.84733415e-01f, -1.02364041e-01f, 2.05267593e-01f, -4.15445352e-03f, -5.79550825e-02f, 7.65151754e-02f, -1.50461376e-01f, -6.49394393e-02f, 1.25843182e-01f, 1.45079389e-01f,
  1.69234234e-03f, -8.03782046e-02f, -7.80691952e-02f, 1.25803947e-01f, -3.83672863e-02f, 1.20424904e-01f, 8.17397237e-02f, 1.12970799e-01f, 2.43038172e-03f, -7.33166859e-02f,
  -2.89436467e-02f, -1.82073638e-02f, -2.22383700e-02f, -1.99804530e-02f, -1.34634346e-01f, 1.01195805e-01f, -2.03155279e-02f, 1.74827024e-01f, 2.33090654e-01f, -3.40334661e-02f,
  5.22409379e-02f, 5.83859496e-02f, 1.27221063e-01f, -6.96622506e-02f, 1.48337081e-01f, 1.04139343e-01f, 1.87753444e-03f, 2.23414879e-02f, 2.54824217e-02f, 1.10920578e-01f,
  1.11333996e-01f, -1.27037335e-02f, 1.09315686e-01f, -4.73727919e-02f, -7.10905045e-02f, 1.55212849e-01f, 1.81343108e-01f, -5.05715683e-02f, -5.22341989e-02f, -1.61199719e-01f,
  -2.03093350e-01f, 8.30741748e-02f, 7.83841163e-02f, 6.89100251e-02f, 3.37220989e-02f, 1.47862971e-01f, -9.84079465e-02f, -7.87227973e-02f, 1.26839988e-02f, 8.62330049e-02f,
  6.70871884e-02f, 5.31435199e-02f, -9.43848789e-02f, 5.99472336e-02f, 1.47158027e-01f, 4.25366908e-02f, -5.65037578e-02f, 8.54895189e-02f, -1.03931621e-01f, -9.85391289e-02f,
  -2.42912471e-02f, -1.98732037e-02f, -1.02618888e-01f, 4.79663052e-02f, 6.94910213e-02f, -1.02504827e-01f, -6.25090525e-02f, -3.92649658e-02f, 7.36866519e-02f, 1.68212354e-02f,
  -7.23198280e-02f, 2.54763849e-02f, 4.48575169e-02f, 7.14006796e-02f, 1.45039245e-01f, -1.01300880e-01f, -2.95263715e-02f, 8.18717554e-02f, -6.79938421e-02f, -4.49677780e-02f,
  -1.14273638e-01f, 1.35249151e-02f, 2.06731558e-02f, 1.22314841e-02f, 5.15248217e-02f, 4.67318259e-02f, -3.08794286e-02f, -6.37111291e-02f, 6.14272133e-02f, -7.26472586e-02f,
  -6.87260479e-02f, 1.12673350e-01f, -4.79665678e-03f, -3.41181457e-02f, -8.45520124e-02f, 3.84349227e-02f, -4.31072637e-02f, 4.91111726e-02f, 1.53547600e-01f, 1.43283308e-01f,
  7.66442195e-02f, 1.01052277e-01f, -3.26029472e-02f, -1.24061637e-01f, -1.47515327e-01f, 6.84647784e-02f, -3.49135771e-02f, -6.93347529e-02f, -9.54939723e-02f, 1.54991299e-01f,
  -8.17770883e-03f, 1.04042761e-01f, 5.90775348e-02f, -2.15925381e-01f, -1.12369396e-01f, 2.25988835e-01f, -1.73027262e-01f, -1.03860818e-01f, 1.67251393e-01f, 1.07993424e-01f,
  -7.03091472e-02f, 1.11199245e-01f, -7.76269063e-02f, 5.65211922e-02f, -6.19467534e-03f, 4.98244092e-02f, -5.91752343e-02f, -1.08861081e-01f, -5.70791773e-02f, -6.86284453e-02f,
  1.02024488e-01f, 3.67466301e-01f, 6.98970184e-02f, 6.86954558e-02f, 1.00211732e-01f, 5.58299460e-02f, -4.18591313e-02f, -1.31379915e-02f, 5.89995272e-02f, 1.08549548e-02f,
  6.07740507e-02f, 3.67404521e-02f, 3.15607153e-02f, 7.45662153e-02f, 1.07236467e-01f, 3.19236852e-02f, 6.08153492e-02f, -2.44662538e-02f, 9.03250724e-02f, 1.17536141e-02f,
  1.66603640e-01f, -5.60292117e-02f, 1.29725009e-01f, 1.47473797e-01f, 5.92830069e-02f, 3.16200219e-02f, -9.72778425e-02f, 1.13745250e-01f, 5.00486158e-02f, -9.77040902e-02f,
  2.10361704e-02f, 1.40174031e-01f, -4.62846905e-02f, 1.84807301e-01f, -6.05341345e-02f, -3.78013290e-02f, 1.43685922e-01f, 6.36239722e-02f, -5.86448088e-02f, 1.29449904e-01f,
  1.84032694e-01f, 1.20195150e-01f, -2.62429425e-03f, 5.62810414e-02f, 6.45071492e-02f, -9.13725570e-02f, 1.28445640e-01f, -6.31958470e-02f, -1.57381669e-01f, 3.79702970e-02f,
  -4.58171852e-02f, -1.63845718e-01f, -2.74176355e-02f, -3.41894594e-03f, 3.95276099e-02f, -3.02270465e-02f, -8.55080187e-02f, 1.33635387e-01f, -5.33402152e-02f, -1.79926250e-02f,
  7.22496584e-02f, -3.45493555e-02f, 1.06417686e-02f, 8.31318200e-02f, -4.81739491e-02f, 8.81243572e-02f, 9.96926874e-02f, -6.74864277e-04f, -1.24000221e-01f, -1.83529891e-02f,
  4.71847057e-02f, 2.17320789e-02f, 1.17182389e-01f, 2.27652304e-03f, -7.29222670e-02f, 6.97459504e-02f, 9.93733928e-02f, -8.01677164e-03f, 8.21859241e-02f, 5.94736263e-02f,
  -4.09323350e-02f, -6.31044656e-02f, 6.22890480e-02f, 3.31374705e-02f, 1.01932317e-01f, 2.02621043e-01f, 1.49199262e-01f, 1.49191305e-01f, 2.81655267e-02f, 2.00685710e-01f,
  -5.96785545e-02f, 2.02455655e-01f, 8.86520429e-04f, -1.15963295e-02f, 1.46916136e-01f, 2.09117368e-01f, 9.29911882e-02f, 2.53753960e-01f, 1.88366517e-01f, 5.40701486e-02f,
  8.06051400e-03f, -3.90407711e-01f, -1.19462743e-01f, 7.64031187e-02f, 2.35022962e-01f, 3.87241095e-02f, -1.17161572e-01f, 2.91902255e-02f, 1.13454930e-01f, 1.94390774e-01f,
  2.20298208e-03f, -2.65899867e-01f, -9.32124853e-02f, 2.79454052e-01f, -2.00081319e-01f, -1.28558353e-01f, 2.84772545e-01f, 6.97319731e-02f, -1.13759423e-02f, 8.17251056e-02f,
  1.01567566e-01f, 1.73046798e-01f, 5.11079989e-02f, -7.53943175e-02f, -2.37959087e-01f, 1.60711841e-03f, 1.78711653e-01f, 2.42894478e-02f, 1.99561507e-01f, 2.58522838e-01f,
  8.01342726e-02f, 1.08331211e-01f, 1.01111501e-01f, -1.76265866e-01f, -1.83467090e-01f, 6.94292411e-02f, -2.13218220e-02f, -9.15521085e-02f, -6.26307502e-02f, -1.06493682e-01f,
  4.61882502e-02f, 2.99492907e-02f, 1.06636032e-01f, -1.47254989e-01f, 8.90422091e-02f, -5.53467683e-02f, 1.38847977e-01f, 5.94696514e-02f, -2.31561940e-02f, 1.55631691e-01f,
  1.25180215e-01f, 1.77971750e-01f, -1.04498034e-02f, 6.84403181e-02f, -8.82524922e-02f, 1.17796563e-01f, 1.46538511e-01f, 7.08764866e-02f, 1.72664046e-01f, 2.61493120e-02f,
  1.78099032e-02f, 7.45983422e-02f, 1.11791775e-01f, 1.02975301e-01f, 1.02483757e-01f, -1.39733642e-01f, 2.84625918e-01f, 1.00397892e-01f, 1.16818883e-01f, -1.51849434e-01f,
  -1.47090942e-01f, -1.67816371e-01f, 7.40540028e-02f, -1.96917951e-02f, -3.71058425e-03f, 3.00145429e-02f, 3.78933400e-02f, -1.63189203e-01f, -2.00810447e-01f, 9.26263779e-02f,
  1.90671474e-01f, 2.08280459e-02f, -3.67634706e-02f, 2.08134562e-01f, 1.32285086e-02f, 1.56259894e-01f, 2.62367219e-01f, 1.48183167e-01f, -1.33881852e-01f, -3.80459577e-02f,
  8.63164887e-02f, 4.81143370e-02f, 8.71550590e-02f, 5.01847044e-02f, -1.37043744e-01f, 4.83225398e-02f, 1.14787228e-01f, -1.10938109e-01f, -5.06865978e-02f, -2.73843724e-02f,
  -3.12244687e-02f, 2.05923811e-01f, 2.03128770e-01f, 2.43151300e-02f, 8.36873055e-02f, -6.45852014e-02f, -3.63999195e-02f, 1.82356834e-02f, 5.11965193e-02f, -1.22085148e-02f,
  1.14103528e-02f, -9.75740477e-02f, -3.76277901e-02f, 5.27698221e-03f, 1.90415736e-02f, 1.57681592e-02f, -6.66398108e-02f, 1.38529703e-01f, 1.39759143e-03f, -2.58323587e-02f,
  3.60772312e-02f, 6.97555542e-02f, 1.01032391e-01f, -1.17615303e-02f, -4.86192107e-02f, 2.14085076e-02f, -6.42129977e-04f, -5.07172085e-02f, 8.18857737e-03f, 1.69718440e-03f,
  8.70347545e-02f, 8.23523328e-02f, -8.35922286e-02f, -7.49096870e-02f, 7.83117041e-02f, -4.40391339e-02f, -1.24959581e-01f, -1.34447709e-01f, -5.58725856e-02f, -3.89291421e-02f,
  1.33001119e-01f, 3.96203175e-02f, -8.99121258e-03f, -1.44870624e-01f, 1.05089970e-01f, -8.03078897e-03f, 2.26746984e-02f, -5.27454540e-02f, -2.47652642e-02f, 9.52041000e-02f,
  -9.45435092e-02f, -8.84843171e-02f, 6.72374219e-02f, -5.46058156e-02f, 2.28253510e-02f, 3.31690051e-02f, -9.53663364e-02f, 5.26648834e-02f, 7.87422359e-02f, 4.32985649e-03f,
  1.23965412e-01f, 1.28994852e-01f, -5.75494282e-02f, -8.54474902e-02f, -1.15520656e-01f, 2.57050451e-02f, 8.33256394e-02f, -1.07114896e-01f, 3.51226367e-02f, -1.93263998e-03f,
  6.30466715e-02f, 3.81620526e-02f, -9.01218355e-02f, -1.78175382e-02f, 2.31089517e-02f, -7.94787407e-02f, 1.74341183e-02f, 2.00900692e-03f, -2.17028726e-02f, 8.97024572e-02f,
  2.04731263e-02f, 3.22132930e-02f, 1.75624743e-01f, 1.34320796e-01f, 1.77088559e-01f, 1.39266893e-01f, 1.07743226e-01f, 8.14080983e-02f, 1.02951536e-02f, 1.68041419e-02f,
  7.98018053e-02f, -8.01375583e-02f, 1.58614114e-01f, -9.85780358e-02f, -1.14891604e-01f, 7.05495030e-02f, -1.67051166e-01f, 1.79588854e-01f, -7.54470602e-02f, 1.31793901e-01f,
  -5.79228587e-02f, 5.10475822e-02f, -1.50549173e-01f, -9.40899625e-02f, 1.73012465e-02f, 1.55277625e-01f, -1.76328607e-02f, 1.13376670e-01f, -1.12759411e-01f, 1.25671759e-01f,
  1.94379151e-01f, -5.91620281e-02f, -6.62407801e-02f, -9.90949497e-02f, -2.30057277e-02f, -8.74832943e-02f, -5.02621196e-02f, 5.06367497e-02f, -5.16392142e-02f, -1.41725436e-01f,
  9.24093798e-02f, 1.22953691e-01f, 1.75693721e-01f, 1.76763147e-01f, -6.63362145e-02f, 1.07526639e-02f, -1.10355258e-01f, -3.40571888e-02f, -3.88367362e-02f, -4.55271453e-02f,
  -3.58656198e-02f, 1.36627490e-02f, 6.33499213e-03f, 1.81832716e-01f, -1.48788691e-01f, 3.79882427e-03f, 6.90762997e-02f, 7.10389167e-02f, 1.45004600e-01f, -1.04807895e-02f,
  1.55643314e-01f, 4.99501973e-02f, 1.60562098e-01f, 1.37953579e-01f, -4.93114553e-02f, 6.09533302e-03f, 7.23548830e-02f, -2.07871273e-02f, 2.26614363e-02f, -3.18790674e-02f,
  -3.43472660e-02f, 1.19559489e-01f, 3.88700701e-02f, 9.05391723e-02f, 1.67341188e-01f, -2.50314865e-02f, 4.39610556e-02f, -1.28160445e-02f, 8.77274722e-02f, 1.63051300e-02f,
  1.11453258e-01f, -6.46490008e-02f, 2.13020835e-02f, 5.26620075e-02f, 5.75832687e-02f, -1.50015980e-01f, 7.50388503e-02f, -1.17052719e-01f, 1.68082193e-01f, -1.80740207e-01f,
  -1.05755277e-01f, -8.20900351e-02f, 7.23206922e-02f, -6.35895655e-02f, -1.03952050e-01f, -4.90443856e-02f, 5.11391312e-02f, 4.16008532e-02f, 1.94992647e-01f, -3.38454992e-02f,
  -7.50051113e-03f, -1.66376576e-01f, -8.06611180e-02f, 2.59428117e-02f, -7.62397945e-02f, 8.31451267e-02f, -1.29364073e-01f, -1.19830541e-01f, -7.21200462e-03f, 9.96929556e-02f,
  1.36402994e-01f, 3.11899744e-02f, -1.06361516e-01f, 1.46608323e-01f, -3.52203473e-03f, -3.70819718e-02f, -1.17266409e-01f, 2.49524545e-02f, 1.43157259e-01f, -1.09374747e-01f,
  -5.70693351e-02f, -1.19254217e-01f, -1.01627126e-01f, -4.54869941e-02f, 8.92044753e-02f, 1.61971606e-03f, -8.59433562e-02f, 9.87024792e-03f, 6.75403029e-02f, 3.70299667e-02f,
  -5.15806079e-02f, -3.75978760e-02f, 4.18767557e-02f, -6.46679488e-04f, 1.42388428e-02f, -1.27729341e-01f, -6.31368235e-02f, 2.02276167e-02f, -6.54942393e-02f, -6.85595647e-02f,
  9.99196246e-02f, 1.04339987e-01f, 1.16046757e-01f, -2.99304072e-02f, 5.01617789e-03f, 7.01957643e-02f, -5.48482537e-02f, -6.93029836e-02f, 2.49658581e-02f, 3.52259949e-02f,
  4.40089256e-02f, 1.23554813e-02f, -7.54466131e-02f, 5.97388372e-02f, 1.40692830e-01f, -6.46753088e-02f, -1.93111468e-02f, -1.24565594e-01f, -7.33509138e-02f, -8.20355713e-02f,
  -6.21412396e-02f, 8.57536867e-02f, 8.87104943e-02f, -1.22562774e-01f, 8.06457549e-02f, 3.84344049e-02f, -6.29594103e-02f, 1.96623430e-02f, 1.03763394e-01f, 9.25698504e-02f,
  -8.89476389e-02f, -1.43541014e-02f, 2.80853629e-01f, 4.06307802e-02f, -7.95804262e-02f, 1.35536417e-01f, 4.77654561e-02f, 8.40292573e-02f, 1.26489341e-01f, -7.30143711e-02f,
  8.22118819e-02f, 3.74128148e-02f, 7.03758001e-02f, 1.63855255e-01f, 1.82813615e-01f, 7.46294782e-02f, 1.31385788e-01f, 3.26772705e-02f, 1.36439204e-01f, -3.49669047e-02f,
  -1.14873581e-01f, 1.09879881e-01f, 1.39972255e-01f, 3.47577743e-02f, 1.08610075e-02f, -8.69206414e-02f, 2.81142332e-02f, 3.05933016e-03f, 1.19404905e-01f, -2.48331879e-03f,
  -1.34788770e-02f, 1.23015583e-01f, 6.05100989e-02f, -9.96420458e-02f, -2.36609369e-03f, -4.08873074e-02f, 3.47540155e-02f, 3.18957753e-02f, -1.50414556e-01f, 3.52457108e-04f,
  9.79130119e-02f, -9.82339457e-02f, -1.22158714e-02f, -1.41820535e-01f, 9.73051935e-02f, 2.20929142e-02f, -2.12683994e-03f, -5.67414574e-02f, 1.43821999e-01f, -1.46366119e-01f,
  7.84066394e-02f, 1.02859125e-01f, 1.17449485e-01f, 7.88877625e-03f, 2.59317681e-02f, 2.14731675e-02f, -9.15598348e-02f, -1.04323089e-01f, -4.57159318e-02f, -1.77780110e-02f,
  -3.67006287e-02f, -5.26817180e-02f, 8.73617604e-02f, -8.79576653e-02f, 4.80423123e-02f, -4.70838696e-02f, -9.66245588e-03f, -9.87703577e-02f, 4.86196131e-02f, 4.16174382e-02f,
  9.24495161e-02f, -9.39411372e-02f, -3.31444107e-02f, 1.10363685e-01f, -1.97133683e-02f, 1.24795005e-01f, 8.01309571e-02f, 4.23680507e-02f, -3.12939622e-02f, 7.68953115e-02f,
  -8.31257403e-02f, 1.77322090e-01f, 1.39620841e-01f, -6.39923895e-03f, 8.09850991e-02f, -2.22664718e-02f, 1.90944135e-01f, 1.34227261e-01f, 1.84578840e-02f, -1.76670719e-02f,
  -9.08927843e-02f, 1.75032079e-01f, 1.28704518e-01f, 1.27428889e-01f, 2.03403831e-01f, 4.26027663e-02f, 3.74477431e-02f, 1.72068357e-01f, 1.93923563e-01f, 2.90680863e-02f,
  -2.18036160e-01f, 6.17461167e-02f, -1.22021496e-01f, 1.22995920e-01f, -1.39496177e-01f, 1.10642269e-01f, 1.26915768e-01f, -3.17014486e-01f, -3.68898362e-02f, 1.10218585e-01f,
  4.70779352e-02f, 2.07071975e-01f, 8.42514411e-02f, -1.88501626e-01f, -6.77345023e-02f, 1.49560258e-01f, 1.50531530e-01f, 8.67997529e-04f, 7.22086653e-02f, 1.07104696e-01f,
  -1.10069588e-01f, -4.31922860e-02f, 1.62564978e-01f, 1.03574932e-01f, -1.43663839e-01f, 1.74539149e-01f, 5.93399778e-02f, 3.13889563e-01f, 7.25142360e-02f, -1.75723527e-02f,
  -1.21832073e-01f, 7.34489337e-02f, -2.87133083e-02f, 3.93422022e-02f, -3.14878374e-02f, 1.56633571e-01f, -1.89465970e-01f, -5.31608015e-02f, 4.27647457e-02f, -6.71579242e-02f,
  4.96528000e-02f, 1.93407144e-02f, -3.62060778e-02f, -2.61271354e-02f, 1.03365786e-01f, -3.65701579e-02f, -1.02825873e-01f, 1.05150476e-01f, 3.63679007e-02f, 7.25201070e-02f,
  -7.90052786e-02f, -3.01298629e-02f, 9.68489945e-02f, -9.85657051e-02f, -6.56490177e-02f, -8.71392637e-02f, -6.47929357e-03f, 6.47386983e-02f, -3.59515548e-02f, 1.02439269e-01f,
  -2.33689304e-02f, 5.47812358e-02f, 3.95418666e-02f, 2.61138417e-02f, 8.59410036e-03f, 1.05532832e-01f, 7.81805590e-02f, 1.35926992e-01f, 1.20947853e-01f, -3.62926605e-03f,
  -1.16830483e-01f, 2.05190480e-02f, 2.07968634e-02f, 9.39824209e-02f, 8.72684196e-02f, 2.32232232e-02f, 1.43851951e-01f, 6.16649762e-02f, -8.75241607e-02f, -4.57110628e-02f,
  5.91732860e-02f, 9.64222476e-02f, 7.36043751e-02f, -1.44678801e-01f, -4.86200154e-02f, -7.50368088e-02f, -2.79583819e-02f, -2.31675822e-02f, 9.60436091e-02f, -3.72171961e-02f,
  -1.10644780e-01f, -1.07002236e-01f, 1.24167599e-01f, -6.92581534e-02f, 2.36625358e-01f, -2.95649040e-02f, 2.37015188e-02f, 8.84817019e-02f, 8.45774710e-02f, -3.47098336e-02f,
  1.60708949e-01f, -2.04993654e-02f, -6.51587173e-02f, -7.07331598e-02f, -2.48040585e-03f, 1.40494734e-01f, -5.45854978e-02f, 2.35960912e-02f, -2.10686158e-02f, -7.23055676e-02f,
  4.79000583e-02f, 3.65154929e-02f, -5.23067787e-02f, -1.13448396e-01f, -4.74415384e-02f, -5.62614836e-02f, 7.20731243e-02f, -8.58263969e-02f, 1.28391357e-02f, 1.40457675e-02f,
  1.27207577e-01f, 2.19733790e-02f, -1.17358312e-01f, -9.86274183e-02f, 8.97033289e-02f, -1.02984376e-01f, -7.23512918e-02f, -1.30219860e-02f, -1.38706239e-02f, 1.11227103e-01f,
  -2.93109864e-02f, 1.33943781e-01f, -7.03641213e-03f, -7.50335632e-03f, 7.33606964e-02f, 3.45054939e-02f, -3.64838652e-02f, -5.56076877e-02f, 1.14113674e-01f, 1.24732107e-01f,
  1.49414726e-02f, 9.39547364e-03f, 9.45489481e-02f, -5.41575663e-02f, -7.26078600e-02f, -7.90406168e-02f, -3.10054813e-02f, 3.73457596e-02f, -3.62158641e-02f, -7.77752772e-02f,
  -7.93426260e-02f, -9.81904715e-02f, -9.72452238e-02f, 1.17938295e-01f, -1.23065293e-01f, -7.84542114e-02f, -2.29265913e-02f, -5.23656011e-02f, 1.24242790e-01f, 8.72267410e-02f,
  6.72045797e-02f, 9.85895246e-02f, 3.19880880e-02f, 1.04532883e-01f, 7.56562203e-02f, 1.14140637e-01f, 2.86158640e-02f, 8.81226808e-02f, 4.53338511e-02f, 6.19669333e-02f,
  -7.03504458e-02f, -9.94172320e-02f, 1.07549027e-01f, -4.46157902e-02f, 3.37787159e-02f, -1.04064979e-02f, -4.06408794e-02f, 4.80541661e-02f, 7.54407570e-02f, -2.55317017e-02f,
  -9.78809521e-02f, -8.04042220e-02f, 8.59554298e-03f, -2.89885662e-02f, 1.21089064e-01f, -1.07773155e-01f, -9.90501568e-02f, -1.55145943e-03f, -4.39553000e-02f, -9.05829947e-03f,
  -1.00519396e-01f, -4.53129970e-02f, 2.33809128e-02f, 2.13125572e-02f, 4.93348166e-02f, -1.46835372e-01f, 8.60298201e-02f, -2.39768624e-02f, 1.36211872e-01f, -7.09990859e-02f,
  -1.28987795e-02f, 9.70665365e-02f, 5.44742309e-03f, -8.74539986e-02f, -9.23478678e-02f, -2.83007529e-02f, 6.68269843e-02f, -4.80354391e-03f, 1.32668791e-02f, -2.94747297e-02f,
  1.23947427e-01f, 3.41370255e-02f, 7.39448965e-02f, 6.41924217e-02f, 8.24692696e-02f, -1.25678122e-01f, 6.53575435e-02f, 6.73419237e-02f, -1.23957582e-02f, 5.30695543e-02f,
  5.00206836e-02f, 4.21353281e-02f, -1.57421716e-02f, -3.76568474e-02f, -1.26715407e-01f, 7.60376900e-02f, 1.07614741e-01f, 8.90704989e-02f, 6.14147484e-02f, 7.45325387e-02f,
  -1.54961357e-02f, 3.89066897e-03f, 7.51932934e-02f, -5.44679537e-02f, 9.84927565e-02f, -1.13240562e-01f, 4.30621617e-02f, 2.60438267e-02f, 1.77486479e-01f, 1.79888532e-01f,
  1.71921760e-01f, -1.92678813e-03f, 2.03471914e-01f, 1.17455848e-01f, 1.39391690e-01f, 2.17642590e-01f, 7.55925924e-02f, 1.11617185e-01f, 2.21418694e-01f, 1.61578000e-01f,
  -7.55061135e-02f, 1.06304362e-01f, 1.42165450e-02f, 9.92963742e-03f, -5.97764701e-02f, 1.38067409e-01f, -1.72104120e-01f, 5.09582460e-02f, 1.54684827e-01f, -7.91683495e-02f,
  9.44999680e-02f, 1.53527364e-01f, -1.35367781e-01f, 2.85022259e-01f, -9.82855931e-02f, 5.67951128e-02f, -1.16203241e-01f, -6.76001981e-02f, 1.50750473e-01f, 1.37220353e-01f,
  -1.57868549e-01f, -1.06052406e-01f, 1.81251183e-01f, -2.08176553e-01f, -1.71576831e-02f, -7.07503557e-02f, -1.64422199e-01f, -8.53694007e-02f, -4.35367301e-02f, 3.17709930e-02f,
  1.35826752e-01f, 9.09138620e-02f, -1.64979905e-01f, -1.90150902e-01f, 1.50190040e-01f, 1.37051329e-01f, 8.07179064e-02f, 3.17122899e-02f, -2.85485503e-03f, 1.04796745e-01f,
  -6.26317039e-02f, -1.84737310e-01f, -9.00022238e-02f, -2.25029010e-02f, -1.66040033e-01f, -1.00165844e-01f, 1.45597368e-01f, 6.92074001e-02f, -3.17624100e-02f, 2.30972748e-02f,
  4.36172672e-02f, -5.65166324e-02f, 1.59012645e-01f, 2.06415251e-01f, 4.67823967e-02f, 2.22891361e-01f, 1.17084153e-01f, 1.23788923e-01f, 2.74106055e-01f, 1.03832148e-01f,
  8.45609158e-02f, 1.00899324e-01f, 2.67251968e-01f, 3.27174843e-04f, 2.15083696e-02f, -1.07026912e-01f, -5.64089455e-02f, 5.29552400e-02f, 1.51662976e-01f, -9.91998613e-02f,
  2.50504553e-01f, -1.89035133e-01f, -2.78353930e-01f, -4.17173356e-02f, 5.15448265e-02f, 1.70243382e-01f, -1.54149368e-01f, -1.47200122e-01f, -2.11738423e-01f, -3.35759185e-02f,
  3.21043313e-01f, 1.40779123e-01f, -1.57573462e-01f, 1.57868370e-01f, -8.54481570e-03f, -1.45611186e-02f, -6.91636056e-02f, 1.34140074e-01f, 1.76601574e-01f, 1.87574029e-02f,
  3.76639329e-02f, 2.89232023e-02f, 5.77079244e-02f, 1.28730282e-01f, -7.87675008e-02f, -7.34598422e-03f, -4.20952663e-02f, -4.31121401e-02f, -1.01198386e-02f, 8.85856673e-02f,
  2.33435974e-01f, 1.56012341e-01f, -4.56494913e-02f, -7.29025528e-02f, -4.96494956e-02f, -2.82997098e-02f, 3.22523624e-01f, 7.77700543e-02f, 1.03213258e-01f, 1.60987556e-01f,
  -3.10723251e-03f, 1.71054110e-01f, 3.09517175e-01f, -1.57149974e-02f, 1.76927432e-01f, -6.26320136e-04f, 8.85740072e-02f, 5.98582253e-02f, 1.70956716e-01f, 1.35471821e-01f,
  1.57823670e-04f, 2.44965851e-01f, -4.89066727e-02f, 1.81004360e-01f, 8.69693011e-02f, 6.71966821e-02f, -2.41070893e-02f, 1.26834467e-01f, 1.00311063e-01f, 1.75747648e-01f,
  3.86786647e-02f, 1.63014218e-01f, 1.67833522e-01f, -1.52583584e-01f, 1.39671877e-01f, 7.27329105e-02f, 8.44051689e-02f, -8.56121108e-02f, -1.92744955e-01f, -9.18691903e-02f,
  -1.07729852e-01f, -6.75521493e-02f, -1.06155407e-02f, -3.52222882e-02f, -1.62732840e-01f, -2.17591166e-01f, 2.21796539e-02f, -7.53403679e-02f, 1.43020988e-01f, -1.80853158e-01f,
  5.96071891e-02f, 1.87934950e-01f, -9.56166685e-02f, 1.54270783e-01f, 1.75223231e-01f, 9.68073234e-02f, -1.26545906e-01f, -5.18104732e-02f, 5.07673761e-03f, -6.22552261e-02f,
  1.42558485e-01f, 2.47399330e-01f, -2.50564944e-02f, -4.99951914e-02f, 1.01406485e-01f, -7.38129392e-03f, -2.55448408e-02f, 3.09851393e-02f, 4.58181053e-02f, 1.71819385e-02f,
  -7.36802593e-02f, -4.26122285e-02f, 1.67516246e-01f, -1.65607616e-01f, 1.15841016e-01f, -4.19861004e-02f, 5.00261672e-02f, -4.58906963e-02f, -1.32436017e-02f, -4.65810448e-02f,
  -4.43944931e-02f, 1.60410881e-01f, 1.56499207e-01f, 2.63525266e-02f, -9.82083008e-03f, 5.70945255e-02f, 9.87912528e-03f, 1.01799905e-01f, 5.30237192e-03f, 1.75548680e-02f,
  1.17446318e-01f, -8.03704634e-02f, -2.02360414e-02f, 1.26195461e-01f, -6.06949851e-02f, 2.04426353e-03f, 2.89029442e-02f, -1.92794338e-01f, 3.70978005e-02f, -5.08226827e-02f,
  7.45738074e-02f, -4.51629460e-02f, 6.54625893e-02f, 9.70736668e-02f, -4.37089195e-03f, 1.08798660e-01f, -1.72323912e-01f, -1.29456133e-01f, 6.22410774e-02f, 4.17628139e-02f,
  -4.83402610e-02f, 6.18481562e-02f, -6.48817271e-02f, -4.97405380e-02f, -4.09560911e-02f, 7.14304373e-02f, -3.72933187e-02f, 1.03305638e-01f, 8.22600424e-02f, -9.39290151e-02f,
  7.67450407e-02f, 7.91752040e-02f, 3.23094614e-02f, -8.47694948e-02f, 6.36994168e-02f, -4.48586792e-02f, 7.60559738e-02f, -6.40774146e-03f, -6.38493001e-02f, 7.68527836e-02f,
  -1.20398380e-01f, 1.19768143e-01f, 6.72395676e-02f, 9.01718438e-02f, -3.29877958e-02f, 3.00874170e-02f, 2.61359997e-02f, -2.87091248e-02f, -2.62944233e-02f, -9.52511188e-03f,
  -7.76913464e-02f, 8.86351690e-02f, 1.05842270e-01f, 1.26964882e-01f, 9.77229774e-02f, 1.91634938e-01f, 8.10584202e-02f, -1.38656422e-02f, -4.08087783e-02f, 3.09976377e-02f,
  2.20906883e-02f, 4.34042104e-02f, -1.86041966e-01f, 1.60622641e-01f, 1.35295004e-01f, 9.40758511e-02f, 6.57738969e-02f, 1.52145490e-01f, 1.54997617e-01f, 5.00363670e-02f,
  -2.16786172e-02f, -2.27120474e-01f, 3.24716091e-01f, -2.48108599e-02f, 8.35107937e-02f, -1.93719715e-01f, -7.17690513e-02f, 7.63391796e-03f, 1.17557123e-01f, -1.25688789e-02f,
  1.40090985e-02f, -1.78599834e-01f, 5.98098934e-02f, 8.53662714e-02f, -2.38697305e-01f, -3.30189355e-02f, -1.30120516e-01f, 2.54243221e-02f, -1.37295201e-01f, 1.05584316e-01f,
  1.92291901e-01f, 1.62192315e-01f, -9.44281556e-03f, -7.27431402e-02f, 5.86747890e-03f, -1.27785668e-01f, 9.46108921e-05f, -1.30341008e-01f, -5.41414730e-02f, 3.31634372e-01f,
  9.24197957e-02f, 1.72094512e-03f, -3.15719284e-02f, 2.24084988e-01f, 9.94425546e-03f, -2.13608909e-02f, -9.10191163e-02f, 1.35134846e-01f, 1.39842898e-01f, -2.27691233e-02f,
  -3.57154831e-02f, 1.01712383e-01f, 1.22108757e-01f, 5.13297431e-02f, -8.49428624e-02f, 8.21532160e-02f, -1.55346710e-02f, 1.88402176e-01f, 1.30236782e-02f, 1.11796081e-01f,
  2.25331876e-02f, 6.96975887e-02f, 1.67195089e-02f, 9.87075046e-02f, 1.63657352e-01f, -1.25406429e-01f, 3.44795808e-02f, 1.37569681e-01f, 1.86689183e-01f, 4.47662286e-02f,
  1.90250486e-01f, -9.93827954e-02f, -2.27165362e-03f, 1.65600330e-02f, 1.83541849e-01f, 2.36313105e-01f, -9.95673388e-02f, -1.54174224e-01f, -3.34067583e-01f, 2.58227855e-01f,
  5.61403111e-02f, -9.61658657e-02f, -3.53272893e-02f, -1.91542059e-01f, -1.01656429e-02f, 2.37556145e-01f, 3.10911655e-01f, -5.51389568e-02f, 1.80500552e-01f, -6.64040521e-02f,
  9.19139236e-02f, 3.44499759e-02f, -4.57891170e-03f, -8.45115036e-02f, 3.50323133e-02f, -1.93283349e-01f, 3.79818084e-04f, -1.38477057e-01f, -2.54342910e-02f, 2.79920876e-01f,
  7.75626069e-03f, 3.74442786e-02f, -6.45202100e-02f, -4.59467284e-02f, -7.00248182e-02f, -5.37748896e-02f, 1.37944847e-01f, -4.74170856e-02f, 1.04808010e-01f, -6.68847561e-02f,
  -3.28064188e-02f, -6.02523498e-02f, 9.26953256e-02f, -9.31942612e-02f, 1.94126323e-01f, 1.30877346e-01f, -9.28573310e-02f, 3.57177854e-03f, 1.05736725e-01f, 1.78237870e-01f,
  -1.09152317e-01f, 4.97610532e-02f, -7.59765133e-02f, 2.05365912e-04f, -1.26371086e-01f, 1.96081474e-02f, 5.26932590e-02f, -7.29299709e-02f, 3.56395990e-02f, -1.00028943e-02f,
  -8.46195593e-02f, -3.26047577e-02f, 9.85508636e-02f, -9.77445468e-02f, 4.12708074e-02f, -4.25412506e-02f, 5.17018251e-02f, 3.27675119e-02f, -1.25252157e-01f, -3.14698406e-02f,
  -1.00337462e-02f, 8.49210396e-02f, -2.47410983e-02f, 9.31585059e-02f, 8.18869695e-02f, -1.44746415e-02f, -7.76311755e-02f, -4.84427102e-02f, 7.87213072e-03f, -5.82461543e-02f,
  4.25272956e-02f, -7.82041773e-02f, -6.26321360e-02f, -8.66382271e-02f, -2.33818535e-02f, 8.19539651e-02f, 4.94678542e-02f, -1.14402704e-01f, 9.78697389e-02f, -9.73023847e-02f,
  1.13123218e-02f, -7.36947879e-02f, -1.03036083e-01f, -1.08437687e-01f, 5.95043041e-02f, -1.08106494e-01f, 3.43512297e-02f, 5.82004413e-02f, -9.97622386e-02f, -1.14133142e-01f,
  6.96045011e-02f, -9.77154002e-02f, -4.88703698e-03f, 6.79217428e-02f, -1.12585627e-01f, 3.60115096e-02f, 2.09351536e-02f, -7.14939982e-02f, 6.02140389e-02f, 6.48695379e-02f,
  -9.16880295e-02f, 1.18068820e-02f, -2.41184304e-03f, 7.35971928e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -6.77886000e-03f, -3.73865291e-02f, -5.47968224e-02f, 1.41185731e-01f, 4.41000126e-02f, -1.28866071e-02f, 6.65631741e-02f, 1.95682086e-02f, 1.57245278e-01f, 7.66833127e-02f,
  -8.19812045e-02f, 2.54338831e-02f, 9.37906932e-03f, -1.35860369e-02f, 9.62388590e-02f, -1.55563364e-02f, -6.60034195e-02f, -3.95577867e-03f, 1.45418961e-02f, 2.92588510e-02f,
  1.39461249e-01f, 1.46654956e-02f, 1.43557101e-01f, 1.53925955e-01f, 2.11732849e-01f, -1.74707379e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.43560236e-02f, -2.44396459e-02f, -1.10737868e-01f, -9.41039026e-02f, 1.17792070e-01f, 1.23480223e-01f, -4.33033258e-02f, -3.33052576e-02f, 1.42633766e-01f, 6.73722923e-02f,
  -1.23131938e-01f, -2.50067394e-02f, 1.02068976e-01f, 1.02296643e-01f, -8.58008265e-02f, -6.98649883e-02f, -2.22237110e-02f, -8.26042816e-02f, 5.23275062e-02f, -1.83633387e-01f,
  -2.60613620e-01f, 7.24375919e-02f, 5.40768802e-02f, 4.28268164e-02f, -2.81722575e-01f, -1.83639959e-01f, -6.11499026e-02f, -2.05499977e-01f, 1.38507918e-01f, -1.04585551e-01f,
  2.06221625e-01f, -4.22516912e-02f, -5.51289394e-02f, -2.90945340e-02f, 1.64726395e-02f, -2.86054797e-02f, 1.17653295e-01f, -1.95277408e-01f, -4.65746112e-02f, 7.43930712e-02f,
  1.26652643e-01f, -7.04910904e-02f, -6.03460036e-02f, -1.54204279e-01f, -8.52428824e-02f, -1.89119235e-01f, -2.43262991e-01f, 1.38777539e-01f, 3.32695358e-02f, -6.89212903e-02f,
  8.20107386e-03f, 1.19285718e-01f, 1.03650190e-01f, -1.48587063e-01f, 7.13232458e-02f, 4.84636761e-02f, -8.76242518e-02f, -1.09855413e-01f, 2.57037044e-01f, 6.43960163e-02f,
  -7.55127370e-02f, 1.18357450e-01f, 1.73854962e-01f, -5.04044350e-03f, 9.14267972e-02f, -2.98768375e-02f, -1.74247414e-01f, -1.12344056e-01f, -8.36216807e-02f, -9.70318168e-02f,
  -1.29644886e-01f, -4.10097912e-02f, 3.43388692e-02f, 1.79534964e-02f, -1.10627711e-01f, 1.15933353e-02f, -1.14990706e-02f, 8.16888511e-02f, -1.92063347e-01f, -8.95578936e-02f,
  1.51463151e-02f, -1.41441733e-01f, -5.90365119e-02f, 7.45871738e-02f, -1.55081585e-01f, -9.23039392e-02f, 3.16533446e-02f, -1.38916522e-01f, -9.90616903e-02f, 3.17541212e-02f,
  -8.26822072e-02f, -1.79903895e-01f, 7.04382211e-02f, -3.70391458e-02f, -1.69058740e-01f, 1.72471046e-01f, 5.26672695e-04f, -2.08557956e-02f, 1.87151983e-01f, -1.00632012e-01f,
  1.82632506e-01f, -1.59971178e-01f, -1.64761394e-01f, -3.27731110e-02f, 4.77148816e-02f, -1.81739658e-01f, -1.63143724e-02f, -9.37415212e-02f, 1.34698048e-01f, 1.62740555e-02f,
  -1.71962351e-01f, -4.95633036e-02f, 7.61845186e-02f, -1.95940379e-02f, -1.90066360e-02f, 9.71009731e-02f, 5.65005504e-02f, 2.24256784e-01f, 7.15846941e-02f, 7.20251352e-02f,
  9.53352526e-02f, -1.14264987e-01f, -9.11927596e-02f, 1.65834371e-02f, -1.19852707e-01f, 1.26220047e-01f, 5.76365441e-02f, 8.20656121e-03f, -6.45757467e-02f, 5.52786291e-02f,
  -2.32453402e-02f, 5.43417409e-02f, 8.54395851e-02f, 5.95096499e-02f, 1.38545269e-02f, 2.34088805e-02f, -1.59541190e-01f, 4.33439994e-03f, -9.68890786e-02f, -3.39617021e-02f,
  6.16295300e-02f, -1.54072763e-02f, 7.43107647e-02f, -5.04121929e-02f, -1.16827808e-01f, 5.58922514e-02f, -8.12126771e-02f, 1.16109863e-01f, 1.90041512e-01f, -2.11932078e-01f,
  8.71866941e-02f, 1.09856717e-01f, 6.55696094e-02f, -1.89966068e-01f, -1.18034355e-01f, -2.36354694e-01f, -9.53904688e-02f, 3.90035063e-02f, -1.98381141e-01f, -1.83374286e-01f,
  -3.47754024e-02f, -2.85436865e-02f, 2.02750638e-01f, -2.08862290e-01f, 2.78479815e-01f, 8.24407116e-03f, -8.65134448e-02f, -6.34313524e-02f, 3.99338603e-02f, -1.16170853e-01f,
  1.74049839e-01f, -6.12863861e-02f, -7.69419968e-03f, 1.24021871e-02f, -5.66972457e-02f, -2.19683610e-02f, -1.25438884e-01f, 1.25955224e-01f, 7.33112395e-02f, -3.55130658e-02f,
  -1.00387648e-01f, -1.59187857e-02f, -1.52830243e-01f, 1.42140416e-02f, 1.50694447e-02f, -1.26891643e-01f, 6.00675195e-02f, -1.12304501e-01f, 1.17927320e-01f, 2.18059629e-01f,
  -6.96003735e-02f, 5.81861027e-02f, -9.45959836e-02f, 1.00887492e-01f, 1.62910726e-02f, 1.63363352e-01f, -2.72965264e-02f, 1.06190756e-01f, 4.81296852e-02f, 1.02630541e-01f,
  1.16693847e-01f, 2.68179495e-02f, -1.23248667e-01f, 6.32003620e-02f, 2.14071393e-01f, 1.93257749e-01f, 1.39384404e-01f, -4.10486571e-03f, 1.60083637e-01f, 1.60895944e-01f,
  1.28376275e-01f, -1.05254002e-01f, -1.82754323e-01f, 2.46005505e-02f, 9.31020826e-02f, -7.01696277e-02f, -1.57563448e-01f, -3.36564258e-02f, 6.94442987e-02f, -3.21806997e-01f,
  1.44312978e-01f, -1.94109976e-01f, 1.36384293e-01f, 8.08858946e-02f, -1.61357552e-01f, -1.06287524e-01f, 1.00847997e-01f, -1.97612852e-01f, 1.08543806e-01f, -2.94646248e-02f,
  -2.16336865e-02f, 1.72859997e-01f, 7.84590989e-02f, -4.79959361e-02f, 2.14142650e-01f, -4.93067317e-02f, -1.84937358e-01f, 2.40818150e-02f, -2.28308648e-01f, 1.45673146e-02f,
  -6.55175969e-02f, -1.65337577e-01f, -2.76972409e-02f, 1.74869254e-01f, -1.32927239e-01f, -1.24418467e-01f, 7.10358322e-02f, 3.95815596e-02f, 1.87838804e-02f, 2.55017519e-01f,
  2.05353573e-01f, -7.10263625e-02f, 5.44499569e-02f, -7.34637007e-02f, 5.16705886e-02f, -6.64748922e-02f, -7.71986023e-02f, 3.99679914e-02f, 8.63165688e-03f, -1.07407290e-02f,
  -2.21509347e-03f, 8.60092044e-02f, -1.59781724e-01f, 7.27388784e-02f, -8.78742188e-02f, -1.24539509e-02f, -1.30141377e-01f, -7.78295994e-02f, -9.24268216e-02f, -9.43062734e-03f,
  1.64768435e-02f, -1.47230968e-01f, -1.65588900e-01f, -2.04487219e-01f, -9.03268009e-02f, 5.15582189e-02f, 1.68403760e-01f, -1.33924395e-01f, 3.64285670e-02f, -7.22175613e-02f,
  -5.65291829e-02f, 9.20856968e-02f, 8.69776830e-02f, 9.69592258e-02f, -2.42692977e-01f, -4.42886315e-02f, -1.91323280e-01f, 8.41621533e-02f, 8.93655270e-02f, 1.48824781e-01f,
  1.91284474e-02f, -5.01927957e-02f, 1.81580186e-01f, 3.34031694e-02f, -1.10090792e-01f, -5.80529217e-03f, -9.69350561e-02f, -8.19224194e-02f, 1.10962830e-01f, -3.95957641e-02f,
  1.87113523e-01f, 9.12285745e-02f, 1.36437505e-01f, 4.49658707e-02f, 1.21490799e-01f, 2.70968699e-03f, -7.83825852e-03f, 5.85191958e-02f, 8.28276277e-02f, 1.91108197e-01f,
  7.96845704e-02f, -8.70852694e-02f, -6.86480489e-04f, -9.59806517e-02f, -1.31655768e-01f, 4.81538512e-02f, -1.18540831e-01f, -1.07100874e-03f, -6.94007128e-02f, 4.76435460e-02f,
  6.19607083e-02f, 9.63975415e-02f, 2.27667876e-02f, -1.36933386e-01f, -1.11565925e-01f, -9.94952582e-03f, 4.75229919e-02f, -7.27336528e-03f, 7.15671256e-02f, -9.71052945e-02f,
  -5.00029046e-03f, 1.69867098e-01f, -7.64753148e-02f, -2.67699081e-02f, -3.62766460e-02f, -4.73170541e-02f, 4.07736078e-02f, -5.79775199e-02f, 9.41180065e-02f, -5.31489849e-02f,
  1.87284827e-01f, 8.47616699e-03f, -1.42720088e-01f, 1.65323652e-02f, 1.07706390e-01f, -3.32789212e-01f, -1.36439696e-01f, -7.28850588e-02f, -6.88717067e-02f, -1.54454101e-04f,
  -1.09864593e-01f, -8.46145302e-02f, 5.43169491e-02f, -2.41235048e-01f, 8.14556703e-02f, -1.85699344e-01f, -4.26182561e-02f, -2.13813633e-02f, -7.27104992e-02f, -7.67110139e-02f,
  6.12026937e-02f, 1.73779488e-01f, 1.51259527e-01f, -2.48215161e-02f, -8.82804915e-02f, -8.15525576e-02f, -1.65406108e-01f, 1.79946562e-03f, -8.09203312e-02f, 1.77211046e-01f,
  -1.13573469e-01f, 1.28111616e-01f, -1.63463354e-02f, 8.43517631e-02f, 9.51676667e-02f, 1.33877575e-01f, -1.11514509e-01f, 3.29601131e-02f, 2.27064475e-01f, -1.02103435e-01f,
  1.33515701e-01f, 9.03257728e-02f, 2.16738619e-02f, 3.44764814e-02f, 4.58334647e-02f, -7.35863373e-02f, 7.08393008e-02f, 9.30062085e-02f, -3.78114209e-02f, 5.45230173e-02f,
  -7.18567148e-02f, 2.96753608e-02f, 6.39757365e-02f, 5.66071533e-02f, 4.46405411e-02f, -3.41883153e-02f, -8.73873234e-02f, 4.68341485e-02f, -1.07159622e-01f, -6.94661364e-02f,
  -4.82198633e-02f, 9.06796381e-02f, 1.42653927e-01f, -2.49731854e-01f, -2.15545699e-01f, 4.34312113e-02f, -1.51656959e-02f, -2.44389340e-01f, -1.79484338e-01f, 9.65270400e-02f,
  -9.21933502e-02f, -1.31865889e-01f, 1.30209103e-01f, 2.51722455e-01f, 2.08386660e-01f, 2.42949203e-02f, 1.38196588e-01f, 1.37778625e-01f, 4.89846133e-02f, 2.34983325e-01f,
  -1.62542596e-01f, -1.09608471e-01f, -1.17709003e-02f, 7.64729977e-02f, -1.01620376e-01f, -8.36159755e-03f, -6.83770701e-02f, 8.11724812e-02f, -1.45854726e-01f, -4.17445861e-02f,
  -2.63874114e-01f, 8.39499235e-02f, 9.28402618e-02f, 1.83878858e-02f, 3.30937579e-02f, -1.99056808e-02f, 1.78056344e-01f, 1.09447151e-01f, -7.23605752e-02f, 1.02979623e-01f,
  7.15556368e-02f, -6.35266528e-02f, 1.55111358e-01f, -1.80013224e-01f, -1.06278598e-01f, -1.40254408e-01f, 2.93913364e-01f, 6.37056828e-02f, -1.80112138e-01f, -6.22753389e-02f,
  -5.21777347e-02f, -3.74974757e-02f, -4.86711673e-02f, -1.33133635e-01f, -2.14155521e-02f, -2.45367736e-01f, -9.28413272e-02f, -2.61641201e-02f, 1.36620402e-01f, -1.41887754e-01f,
  2.42711790e-02f, 1.92887504e-02f, -4.12252136e-02f, -1.80931106e-01f, 6.43344671e-02f, -7.99433663e-02f, -1.50830820e-02f, -1.49404451e-01f, -2.56663859e-01f, 2.03106320e-03f,
  1.00489601e-01f, 6.90191537e-02f, 5.23846000e-02f, 7.17517808e-02f, 1.86040387e-01f, 2.68944889e-01f, 1.80132180e-01f, 8.57623070e-02f, 1.88441470e-01f, 4.51440923e-02f,
  -9.67137888e-02f, -1.22207962e-01f, -7.28433803e-02f, 2.20490828e-01f, 8.12094286e-02f, 7.06208423e-02f, 9.43180323e-02f, -4.12446707e-02f, -8.00266266e-02f, -1.00362539e-01f,
  -1.18620567e-01f, -1.01796500e-01f, -3.26794460e-02f, -1.14427499e-01f, 1.07087962e-01f, 1.80346951e-01f, -1.64882373e-02f, 4.58785556e-02f, -1.05136909e-01f, -1.58383232e-02f,
  -5.88725694e-02f, -2.30767757e-01f, 8.85844305e-02f, 1.58015080e-02f, -2.91869473e-02f, -2.03736320e-01f, 5.69766797e-02f, 1.18884213e-01f, 6.54304475e-02f, -1.25444546e-01f,
  3.49396840e-02f, 5.96817881e-02f, 2.00950786e-01f, 2.10914642e-01f, -6.03751801e-02f, -1.76404342e-02f, 8.06195755e-03f, 7.05122054e-02f, 3.91357467e-02f, 1.23048380e-01f,
  1.35885209e-01f, 4.90297489e-02f, 1.30484164e-01f, 4.60859053e-02f, 8.45469832e-02f, 3.40780318e-02f, 5.45389131e-02f, 2.32118681e-01f, 3.58161852e-02f, -1.05425358e-01f,
  -4.11716737e-02f, -1.60689410e-02f, 1.12818599e-01f, -2.11006403e-01f, 1.19510472e-01f, -4.10910882e-02f, 1.60985533e-02f, -3.74366902e-02f, -2.38107100e-01f, -2.51858205e-01f,
  3.21991481e-02f, -1.63603976e-01f, -1.89303562e-01f, -3.23677831e-03f, -1.72702000e-01f, 4.42005359e-02f, 8.97265505e-03f, 8.80197342e-03f, 4.77432124e-02f, -5.66441305e-02f,
  -9.26770270e-02f, 1.20198764e-01f, -8.59274641e-02f, -1.68059036e-01f, 1.96789637e-01f, -8.46592635e-02f, -1.02158375e-01f, -1.13638736e-01f, 1.45502072e-02f, -1.53037280e-01f,
  -3.52549963e-02f, 3.65871899e-02f, 1.87019221e-02f, -1.35176405e-01f, -9.60739255e-02f, 1.47490487e-01f, 2.45104805e-02f, 9.45196450e-02f, 4.93735746e-02f, 1.25142202e-01f,
  -1.12385713e-01f, -1.00574523e-01f, 7.12272823e-02f, 7.71297738e-02f, -7.51232877e-02f, -1.40438154e-01f, -7.21756443e-02f, 1.66471496e-01f, -5.36720231e-02f, 1.15170836e-01f,
  -6.19519390e-02f, 8.96723662e-03f, 1.02378078e-01f, 1.28816724e-01f, 1.51190192e-01f, 9.60371196e-02f, -1.02114990e-01f, 1.53314784e-01f, 7.90517591e-03f, 1.18382581e-01f,
  -1.21394791e-04f, 1.58360079e-01f, -3.11886109e-02f, -4.44092453e-02f, 4.69989404e-02f, -2.26762697e-01f, -1.92536995e-01f, -6.39054775e-02f, 4.48686071e-02f, -5.76300249e-02f,
  -2.62626946e-01f, -6.79030344e-02f, -1.64255500e-01f, -3.03728849e-01f, 3.55021693e-02f, 1.47835957e-02f, -3.10788471e-02f, -8.10995772e-02f, -8.63446891e-02f, 1.29418910e-01f,
  1.84157476e-01f, -1.14658296e-01f, 1.46004455e-02f, -2.73829550e-02f, -1.38217807e-01f, 8.80243778e-02f, -3.35699357e-02f, -1.97705626e-01f, -3.27792857e-03f, 4.33908589e-02f,
  -1.15561761e-01f, -1.12798654e-01f, -1.85012728e-01f, 2.79888939e-02f, 3.15021798e-02f, -4.66226898e-02f, 1.98081136e-01f, 1.04703858e-01f, -3.15015912e-02f, 1.77813128e-01f,
  -7.43577927e-02f, -6.04434088e-02f, 9.97779425e-03f, -7.19669759e-02f, 2.41663307e-02f, -9.66830105e-02f, 9.56908837e-02f, 1.28084883e-01f, 1.12696201e-01f, -9.71560404e-02f,
  1.10145420e-01f, -2.30111424e-02f, -8.10811371e-02f, -4.64478061e-02f, 6.60229623e-02f, 7.56402388e-02f, -6.94436282e-02f, -5.26890755e-02f, 1.85834825e-01f, 9.60872769e-02f,
  4.37906533e-02f, 1.69947043e-01f, -1.00260198e-01f, -2.67275795e-03f, -9.88021214e-03f, 1.42967090e-01f, -2.88635548e-02f, 6.29626513e-02f, 7.20837042e-02f, -2.05470681e-01f,
  3.27796005e-02f, -2.02091374e-02f, 1.68190777e-01f, -1.38763070e-01f, -2.00415611e-01f, -1.20210670e-01f, -2.79576033e-01f, -1.80597976e-01f, -1.12190973e-02f, -3.68047543e-02f,
  -1.10491246e-01f, -4.33220416e-02f, -8.76510814e-02f, 1.71071321e-01f, 3.18540305e-01f, 3.44844721e-02f, 6.40232787e-02f, -7.12930188e-02f, -1.64352611e-01f, 4.20738719e-02f,
  7.91147072e-03f, -2.87865520e-01f, -5.58062531e-02f, 9.44467932e-02f, -1.14453860e-01f, -1.56991854e-01f, -4.58061174e-02f, -3.00705880e-02f, -4.11015563e-02f, -6.06093481e-02f,
  9.78295505e-02f, -1.48621693e-01f, -5.52899092e-02f, 2.54679415e-02f, -1.10249639e-01f, 4.73042056e-02f, 8.16181079e-02f, -1.34837136e-01f, 1.49544731e-01f, -1.21735647e-01f,
  1.55745834e-01f, -3.52623984e-02f, 1.58785731e-01f, -1.19461671e-01f, -1.23659402e-01f, -3.84314023e-02f, -1.00846432e-01f, 6.90137874e-03f, -7.96801895e-02f, -1.14976630e-01f,
  -1.97973415e-01f, 8.78158212e-02f, 1.03172548e-02f, -7.30952993e-02f, 1.38946846e-01f, -6.31955490e-02f, -1.23854183e-01f, -2.53185648e-02f, 7.35125244e-02f, 2.12443341e-03f,
  -7.77193233e-02f, 1.51766464e-01f, -7.39189163e-02f, -2.00719640e-01f, -8.30600858e-02f, 7.84904808e-02f, 1.42720100e-02f, -2.92780995e-01f, -1.96815655e-01f, 1.62448566e-02f,
  -7.88007975e-02f, 1.03657737e-01f, 3.50542367e-02f, 2.89549977e-01f, 2.65235435e-02f, 1.04376674e-01f, -8.69497005e-03f, 1.00266514e-02f, -7.88218156e-02f, 3.13249648e-01f,
  -1.07742071e-01f, -3.87210660e-02f, 4.93765138e-02f, -7.00426698e-02f, 3.96457054e-02f, 5.63634112e-02f, -1.99859202e-01f, -3.33134942e-02f, -1.33277580e-01f, 8.45746025e-02f,
  -1.83731645e-01f, -1.28726080e-01f, -2.72336621e-02f, -5.87324351e-02f, 2.94952486e-02f, 1.12496816e-01f, 1.34615123e-01f, 1.26060739e-01f, 9.50400233e-02f, -3.24430205e-02f,
  -1.12747289e-01f, -2.33569667e-01f, 1.37342617e-01f, -1.09024920e-01f, -1.89346164e-01f, -1.11517236e-01f, 2.11850971e-01f, -8.33034292e-02f, -1.13527872e-01f, -1.10731810e-01f,
  5.23621961e-02f, 1.07175991e-01f, 5.86814769e-02f, -1.48421004e-01f, -1.36530578e-01f, -8.38340819e-02f, 5.68258055e-02f, 1.20518424e-01f, -8.81349146e-02f, 6.70705587e-02f,
  1.09179005e-01f, 1.54812738e-01f, 3.48491073e-02f, 1.79571807e-01f, 1.93554536e-02f, 1.53673306e-01f, -2.67106257e-02f, 6.42952994e-02f, 6.98278621e-02f, 6.19265139e-02f,
  2.16544449e-01f, -6.85603172e-02f, -1.45345211e-01f, 7.75100961e-02f, -1.88602418e-01f, -1.22932002e-01f, 1.16674617e-01f, -2.06456155e-01f, -1.36930784e-02f, -6.53180629e-02f,
  -2.93350011e-01f, 1.04074478e-01f, 1.18686132e-01f, -1.43027371e-02f, 7.02417046e-02f, 9.34403390e-02f, 2.49716621e-02f, 1.50340414e-02f, 1.44910082e-01f, -1.39345145e-02f,
  -1.18947804e-01f, -6.95400359e-03f, -3.33305448e-02f, 5.03220670e-02f, 9.33002010e-02f, 6.95689349e-03f, 7.06533939e-02f, -8.04118589e-02f, 1.25455841e-01f, 1.33722380e-01f,
  3.04761250e-02f, -1.65065184e-01f, 8.40886235e-02f, -9.46182758e-03f, 4.77634817e-02f, 4.57099900e-02f, -4.88900021e-03f, -1.28765360e-01f, -5.73947579e-02f, 8.01322516e-03f,
  -8.91021788e-02f, -1.00569330e-01f, 1.63155451e-01f, -4.81066331e-02f, -1.10445984e-01f, 3.98276150e-02f, -1.20574340e-01f, 2.92979013e-02f, -1.55362962e-02f, -2.81378906e-02f,
  7.48926625e-02f, 9.74171758e-02f, -2.34455839e-02f, 9.26014259e-02f, 1.09211192e-01f, 6.72415271e-02f, -2.36403123e-02f, 1.15583546e-01f, -7.46109560e-02f, 6.73941374e-02f,
  -8.20079446e-02f, 1.65861562e-01f, 2.96560023e-02f, -6.23617917e-02f, -1.79225370e-01f, -2.00132966e-01f, 1.18780039e-01f, -2.63572466e-02f, -2.07526550e-01f, -2.26658180e-01f,
  -1.03453286e-01f, -6.49149269e-02f, -8.89776498e-02f, 2.09522456e-01f, 4.06618603e-03f, 2.67610736e-02f, -1.09926142e-01f, 1.20494962e-01f, -1.79640520e-02f, 5.15466258e-02f,
  -2.90292781e-02f, -1.25352353e-01f, 1.45948455e-01f, -1.00145303e-01f, -3.79953708e-05f, 1.12070575e-01f, -1.36920378e-01f, -7.89372027e-02f, -1.65548548e-01f, -1.31868660e-01f,
  -3.75406742e-02f, 4.56257612e-02f, 1.02385655e-02f, -8.19647312e-02f, 1.18366763e-01f, 7.83398822e-02f, 3.03427000e-02f, 9.25457403e-02f, -2.09446065e-02f, 1.06064260e-01f,
  -1.61678895e-01f, -2.19792798e-01f, -1.46805719e-01f, -2.08103865e-01f, 1.86847553e-01f, 9.72405970e-02f, -9.60867777e-02f, 2.62816884e-02f, 8.72934014e-02f, 7.52656832e-02f,
  -3.59445140e-02f, -5.51289991e-02f, 3.23339105e-02f, -3.37771699e-02f, 1.42561331e-01f, 1.46839201e-01f, 7.51606449e-02f, 5.89300729e-02f, -5.70126399e-02f, -5.47261648e-02f,
  -1.28955618e-01f, -1.97353661e-02f, 7.57128596e-02f, 3.94150950e-02f, 1.71314001e-01f, -2.13758811e-01f, -1.99468046e-01f, -4.08481248e-03f, 5.24567142e-02f, -4.98602651e-02f,
  -2.60799766e-01f, 1.66974992e-01f, 1.03896864e-01f, -1.53985456e-01f, 1.63103297e-01f, 2.00452097e-02f, 1.40039355e-01f, 1.33969992e-01f, 1.13521911e-01f, 8.18495601e-02f,
  -1.44203566e-02f, 3.59618701e-02f, -1.17895722e-01f, -2.45590776e-01f, 2.15439703e-02f, 1.06705621e-01f, -1.17882721e-01f, 5.00916280e-02f, -1.96736082e-01f, -7.09430650e-02f,
  -1.72995374e-01f, 3.31052989e-02f, -2.43815809e-01f, 1.84602551e-02f, 1.36607632e-01f, -2.07490653e-01f, 1.13395505e-01f, 1.12201691e-01f, 1.44495234e-01f, 8.41846690e-02f,
  6.00812212e-02f, -5.70811890e-02f, 1.25137672e-01f, -1.50186792e-01f, 7.85821490e-03f, 7.04883486e-02f, 5.33375069e-02f, 8.01726207e-02f, 2.27349058e-01f, 4.95354608e-02f,
  -1.35698259e-01f, 1.00652240e-01f, 6.51040114e-03f, 6.15542792e-02f, 1.16599947e-01f, -9.04833153e-02f, -1.00474156e-01f, 5.03542311e-02f, 1.18140817e-01f, 7.02817217e-02f,
  -1.73702911e-01f, 2.10877713e-02f, -3.83791886e-02f, 1.13653215e-02f, -5.14465943e-02f, 2.73752753e-02f, -1.16272662e-02f, 5.27706556e-02f, 3.44452746e-02f, -3.54730301e-02f,
  -6.87701926e-02f, 8.74777287e-02f, 1.77266866e-01f, 3.06962788e-01f, -1.98859405e-02f, 2.50869215e-01f, 8.41166079e-02f, 3.80367786e-02f, -9.84125212e-02f, -1.20703340e-01f,
  -1.22266203e-01f, -1.33203343e-01f, -9.25238281e-02f, 1.28481910e-01f, -6.83118924e-02f, 1.02095269e-01f, 3.98637634e-03f, 5.02146641e-03f, -9.76964906e-02f, 5.74431717e-02f,
  -5.86401932e-02f, -9.98774618e-02f, -1.48753390e-01f, -2.40867175e-02f, 9.05395001e-02f, -2.78301910e-03f, 2.41663679e-01f, 1.27824485e-01f, -6.46274760e-02f, -1.06788717e-01f,
  5.37774675e-02f, 9.16589051e-02f, 8.01679939e-02f, -2.10119650e-01f, 7.71944970e-02f, 1.01704009e-01f, 7.69402757e-02f, 1.54958591e-01f, -2.68193811e-01f, 1.43559292e-01f,
  9.64571908e-02f, -6.26933649e-02f, -1.52013674e-01f, -2.82926019e-02f, 1.23996444e-01f, 8.42158347e-02f, -9.96105745e-02f, 2.76370882e-03f, 9.23749954e-02f, -4.63582128e-02f,
  9.33993757e-02f, -8.57065469e-02f, -6.69413731e-02f, -1.31907510e-02f, -7.31289983e-02f, -2.61591710e-02f, 1.29846454e-01f, 1.00142173e-01f, 7.76803493e-02f, -2.06829850e-02f,
  7.26140290e-02f, 5.91494590e-02f, -3.80525552e-02f, -8.52614045e-02f, 1.49689764e-01f, -2.27664173e-01f, -6.93960786e-02f, -4.96898033e-03f, -9.49449316e-02f, -1.18153177e-01f,
  -1.63144201e-01f, -2.94754088e-01f, -6.52031675e-02f, -9.53239277e-02f, 9.38838646e-02f, -4.66836430e-02f, -6.55562803e-02f, 1.71499159e-02f, 1.47894189e-01f, -1.30873114e-01f,
  -4.75915968e-02f, -3.81160043e-02f, 2.26262398e-02f, 1.44135952e-01f, 1.53143138e-01f, -2.19744682e-01f, 8.35519582e-02f, 6.83602691e-02f, -1.71376362e-01f, 1.00390866e-01f,
  -1.55146882e-01f, -5.07111177e-02f, -5.01200929e-02f, 4.45266254e-02f, 1.41920611e-01f, -3.21562812e-02f, -8.36583674e-02f, -3.79445516e-02f, -6.17466681e-02f, -9.40159187e-02f,
  1.80433411e-02f, 1.75359920e-01f, -1.06052160e-02f, -5.76124601e-02f, 1.67692862e-02f, -7.50523433e-02f, -1.61556810e-01f, -1.10889263e-01f, 7.70407915e-02f, 9.35054272e-02f,
  -3.51076797e-02f, 1.53991967e-01f, 1.60084307e-01f, 6.63043037e-02f, -1.08313881e-01f, 9.29762647e-02f, 6.96157739e-02f, 1.49812385e-01f, 1.67438388e-01f, -7.77199045e-02f,
  1.25870526e-01f, 4.65348139e-02f, -8.01314339e-02f, -2.67887190e-02f, 4.89076599e-02f, 1.89327106e-01f, 1.34364337e-01f, -2.28691742e-01f, -2.39376292e-01f, 5.19335605e-02f,
  4.10246253e-02f, -1.13424145e-01f, -1.77371979e-01f, 9.14442614e-02f, -8.88300836e-02f, -2.02666372e-01f, 2.04569817e-01f, 1.66887492e-01f, 1.57697812e-01f, -9.09712538e-02f,
  -1.65976062e-02f, 1.08240545e-02f, 1.47392333e-01f, 2.07024530e-01f, -8.67259339e-04f, -2.29320183e-01f, 7.16403872e-02f, 7.90683031e-02f, 8.68808627e-02f, -4.58468497e-02f,
  -1.02838159e-01f, -1.08925894e-01f, -1.62381485e-01f, 8.14639330e-02f, -2.11930141e-01f, 2.22099215e-01f, 6.71648309e-02f, -1.32679388e-01f, 1.53763607e-01f, -1.07997835e-01f,
  -1.88511573e-02f, -2.31147073e-02f, -6.06003553e-02f, -1.35735879e-02f, 9.31264311e-02f, -1.77618816e-01f, 2.17955243e-02f, -4.40922715e-02f, 2.54657548e-02f, 2.90045086e-02f,
  6.12765327e-02f, -4.99971062e-02f, 1.37876391e-01f, -1.32919416e-01f, 8.34302530e-02f, -1.02028430e-01f, -9.50129889e-03f, 9.19799805e-02f, 5.11220582e-02f, -1.61952525e-01f,
  5.39640710e-02f, -1.77294642e-04f, 2.31649458e-01f, 1.72301903e-01f, -4.54811519e-03f, -5.51983900e-02f, 2.07298502e-01f, 2.90972777e-02f, 1.07072227e-01f, 1.51641309e-01f,
  7.16419667e-02f, -8.89011696e-02f, 1.11599557e-01f, -4.67475168e-02f, -2.27851093e-01f, -1.13133207e-01f, 1.42422512e-01f, -2.28229985e-01f, -1.41529322e-01f, 5.99050708e-02f,
  -1.50375620e-01f, -4.37756447e-04f, 2.93883327e-02f, -1.26409143e-01f, 1.28877237e-01f, -1.75579488e-01f, -1.94830820e-01f, -8.51093158e-02f, -1.45404473e-01f, 9.50349029e-03f,
  1.83416195e-02f, -7.78547674e-02f, -1.25023156e-01f, 1.43682778e-01f, 1.50111616e-01f, -5.98818883e-02f, -3.27162333e-02f, -5.18100113e-02f, 1.48918763e-01f, 3.88049684e-03f,
  7.45022073e-02f, 1.52962431e-01f, 4.15894017e-02f, -3.32383886e-02f, 9.44215283e-02f, -1.32361889e-01f, 7.56167620e-02f, 4.63938080e-02f, 5.66847250e-02f, 5.47356755e-02f,
  2.23802682e-02f, -1.91589206e-01f, -2.63277534e-02f, -6.05125464e-02f, -5.71069084e-02f, -1.22926548e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.67990670e-01f, 2.87804138e-02f, 1.34027928e-01f, 5.37044890e-02f, 8.21037218e-02f, 2.50575636e-02f, 1.89304397e-01f, 1.65404454e-01f, -2.54793931e-02f, 2.50466391e-02f,
  1.75651744e-01f, 2.57911503e-01f, 1.40035316e-01f, 7.41516650e-02f, 1.61303997e-01f, 3.19354311e-02f, 1.86260432e-01f, 6.86425045e-02f, 1.12044752e-01f, 7.18008494e-03f,
  2.21407726e-01f, -1.74791798e-01f, -3.31356227e-01f, -2.85560250e-01f, 9.61678252e-02f, -8.15027803e-02f, 2.49920581e-02f, -1.74053267e-01f, -6.13285974e-02f, 6.85348585e-02f,
  1.18696868e-01f, 5.31093404e-02f, 2.05878437e-01f, -1.07229076e-01f, -2.32966244e-01f, 3.49234454e-02f, -2.39562482e-01f, 2.50317723e-01f, 8.74152705e-02f, -1.75995842e-01f,
  4.43715928e-03f, 3.56299788e-01f, 3.33315700e-01f, 3.47511321e-02f, -6.13264255e-02f, 2.28787754e-02f, -1.10813074e-01f, -2.68912435e-01f, 9.51204970e-02f, 2.44814664e-01f,
  -1.56144157e-01f, 7.63103440e-02f, -4.92086634e-02f, -3.46534327e-02f, 1.15366220e-01f, 4.02465314e-02f, -1.50303692e-01f, 3.50922734e-01f, 1.00707717e-01f, -1.98108256e-01f,
  -3.52300704e-02f, -1.86426297e-01f, 3.41256201e-01f, 2.00695582e-02f, 1.24956839e-01f, 1.54522017e-01f, -8.62484500e-02f, 1.09385893e-01f, 1.08486667e-01f, -2.29220558e-02f,
  1.82214111e-01f, 9.71970111e-02f, 5.01715131e-02f, 1.40544206e-01f, -1.11181989e-01f, 1.05117284e-01f, 2.05762655e-01f, -2.22428646e-02f, -2.58777943e-02f, 1.32811844e-01f,
  -6.49938136e-02f, -8.06756839e-02f, 1.17391795e-01f, -1.83651507e-01f, -9.54401046e-02f, 1.42499423e-02f, -8.66813362e-02f, 1.72191635e-01f, -9.16026086e-02f, -1.30925924e-01f,
  -7.44577944e-02f, -1.03500940e-01f, 3.20984200e-02f, -6.28412738e-02f, 7.53762573e-02f, 6.98932558e-02f, 9.44995359e-02f, -7.30428323e-02f, 1.67283058e-01f, -9.90270898e-02f,
  1.10637583e-01f, -1.39468834e-01f, 7.75775239e-02f, 1.55788094e-01f, 2.69411225e-02f, 1.46456221e-02f, 1.65302396e-01f, -1.35934040e-01f, -9.69472528e-02f, 6.63127452e-02f,
  1.07293657e-03f, -2.28040740e-02f, 8.81052166e-02f, -1.06470965e-01f, 4.03525420e-02f, -1.79026034e-02f, 1.35510471e-02f, 1.32684158e-02f, -5.77660799e-02f, -4.97056805e-02f,
  -9.47840512e-02f, 6.03622310e-02f, 9.37747732e-02f, 4.44376469e-02f, 5.66923209e-02f, 2.41784453e-01f, -1.48633227e-01f, -8.21705163e-02f, 1.19131878e-01f, 4.51176101e-03f,
  2.70656794e-01f, 9.82823074e-02f, 3.10824229e-03f, 1.83083847e-01f, -4.50013243e-02f, 2.13052332e-01f, 2.87269831e-01f, 1.43587738e-02f, 2.02141419e-01f, 1.73374563e-01f,
  6.06111065e-02f, 1.42473146e-01f, 1.49801821e-01f, 2.87610114e-01f, 1.51159376e-01f, 1.55712947e-01f, 2.48303175e-01f, -1.53800294e-01f, 9.86929908e-02f, -6.84861243e-02f,
  -2.49185562e-01f, -3.32888812e-01f, 8.88224766e-02f, 2.02975020e-01f, -1.45287206e-02f, -2.48894870e-01f, 2.06886142e-01f, -2.03547310e-02f, 1.08353823e-01f, 2.97166020e-01f,
  8.20067823e-02f, 1.28573611e-01f, -4.38893884e-02f, 2.13719025e-01f, -2.91093290e-01f, 7.51852021e-02f, -2.25562509e-02f, -2.53220345e-03f, 3.84440422e-02f, 2.17304632e-01f,
  -1.73028305e-01f, -6.12048386e-03f, -1.07331820e-01f, 1.64462924e-01f, -1.07960612e-01f, -2.77807619e-02f, -7.73346126e-02f, -1.04261845e-01f, -7.81859979e-02f, -1.05471551e-01f,
  8.09423402e-02f, 2.98894346e-01f, -2.89455950e-02f, 1.01915091e-01f, -8.69791284e-02f, 9.52635407e-02f, -1.52479306e-01f, 3.12053785e-02f, -6.03153370e-02f, -1.30684555e-01f,
  2.77976871e-01f, -1.02556586e-01f, -9.68704820e-02f, 7.73972943e-02f, -1.03875853e-01f, -4.89442796e-02f, 2.68678293e-02f, -2.64873402e-03f, 1.03646545e-02f, -1.05889946e-01f,
  7.79126957e-02f, -6.03318736e-02f, 8.49280357e-02f, 5.55592291e-02f, -1.99987292e-02f, 6.07857220e-02f, 8.38393252e-03f, -1.81534961e-02f, -5.02353022e-03f, 8.04970935e-02f,
  -7.04568550e-02f, 1.21458955e-02f, 4.35648933e-02f, 9.98499691e-02f, -9.58454907e-02f, 6.86857626e-02f, -1.23079717e-01f, -1.14306957e-01f, -4.59862873e-02f, -5.53004481e-02f,
  9.04976055e-02f, 7.82193244e-02f, -8.05591643e-02f, 1.72216352e-02f, 3.41239385e-02f, -2.51985248e-02f, 1.10250212e-01f, -8.90796706e-02f, -5.52372858e-02f, 8.99415389e-02f,
  -1.23767674e-01f, -1.10295013e-01f, -6.44242167e-02f, 6.82033002e-02f, -9.83327702e-02f, 7.98988342e-02f, 7.61793852e-02f, 3.48266698e-02f, 1.73149221e-02f, -7.30322152e-02f,
  -2.42736563e-02f, 2.08515790e-03f, -3.88342217e-02f, -3.97126973e-02f, -1.20162189e-01f, 7.06750676e-02f, 2.13222485e-02f, -1.76669713e-02f, 1.15609832e-01f, -8.23912546e-02f,
  3.92594412e-02f, -5.69490530e-02f, 9.71388072e-02f, -5.91919757e-02f, 4.46568504e-02f, 3.23592238e-02f, -7.22678751e-02f, -1.99005544e-01f, 1.22160561e-01f, 2.95736846e-02f,
  7.55987614e-02f, -2.35909205e-02f, 2.07663864e-01f, -5.76987937e-02f, 1.28901452e-01f, 1.81287844e-02f, -2.81989034e-02f, 1.43295407e-01f, 1.30816385e-01f, -8.00776184e-02f,
  -7.65334144e-02f, 8.86202976e-02f, 1.89644933e-01f, 4.75349687e-02f, -2.75068190e-02f, 4.11333423e-03f, -7.32089728e-02f, 3.54728438e-02f, -1.20842747e-01f, -7.56032988e-02f,
  -1.23242669e-01f, -9.13262218e-02f, 8.64373967e-02f, -1.29564106e-01f, -8.72395039e-02f, 1.14134243e-02f, 2.77699661e-02f, 1.91253111e-01f, 1.72399893e-01f, -1.78147867e-01f,
  -7.98245743e-02f, -1.06326334e-01f, -1.74317524e-01f, 1.71809107e-01f, 1.27672553e-01f, 4.10992950e-02f, -2.89801955e-02f, 3.55281174e-01f, 5.48757985e-02f, 1.18387923e-01f,
  5.86704873e-02f, -8.24035853e-02f, 8.64644125e-02f, -1.91892609e-01f, -3.03852912e-02f, -1.57564804e-02f, -1.71779737e-01f, 1.82812065e-01f, -2.94126142e-02f, 1.31001949e-01f,
  1.15195908e-01f, 1.51545275e-02f, -1.05170049e-01f, 1.54819399e-01f, 2.70151258e-01f, -1.01591974e-01f, 4.99755098e-03f, -1.08975172e-01f, 2.63746172e-01f, 1.30777016e-01f,
  1.66251764e-01f, 1.14277199e-01f, 7.35478699e-02f, 1.19159974e-01f, 1.21274054e-01f, 1.88175783e-01f, 4.06140722e-02f, 1.42659977e-01f, 6.11995682e-02f, 1.30690292e-01f,
  3.04107256e-02f, -2.87696701e-02f, 1.66172132e-01f, 9.24141482e-02f, -4.94619943e-02f, 1.99691001e-02f, -7.35377595e-02f, -3.22041810e-02f, 1.29151884e-02f, -1.19301543e-01f,
  2.89999926e-03f, -1.98317826e-01f, 2.05202430e-01f, 2.23751187e-01f, -1.95832685e-01f, 1.22186616e-01f, -1.42408222e-01f, -1.28158242e-01f, -1.04324237e-01f, -2.24487007e-01f,
  8.98556560e-02f, -7.87216574e-02f, 8.28091800e-02f, 4.54930589e-02f, 1.82233885e-01f, -2.25148484e-01f, 2.55134910e-01f, -4.22422029e-02f, 9.38097909e-02f, 2.12713987e-01f,
  -2.02264115e-02f, -4.69869077e-02f, 1.39107734e-01f, -6.76508173e-02f, -6.16143905e-02f, 2.92904563e-02f, -1.20567806e-01f, 1.64676696e-01f, -4.43643518e-02f, -6.53298944e-02f,
  2.07863569e-01f, -9.67546701e-02f, 9.31127593e-02f, -8.06923434e-02f, -4.78672236e-02f, 9.06539708e-03f, -5.43454401e-02f, 1.98213741e-01f, 1.27643496e-01f, -5.40447161e-02f,
  -6.55301586e-02f, 2.21167341e-01f, -1.54386207e-01f, 8.74173716e-02f, -2.09174659e-02f, -3.55813876e-02f, -1.07422955e-02f, -1.10962406e-01f, 1.07651785e-01f, 1.09995022e-01f,
  1.56778798e-01f, 1.45532563e-01f, 2.00255378e-03f, 5.95572870e-03f, -5.70226274e-02f, -2.61210315e-02f, -8.89019445e-02f, -8.12674016e-02f, -5.49235605e-02f, 1.02616660e-01f,
  5.03167026e-02f, -3.84619012e-02f, -6.27600029e-02f, -6.19382896e-02f, 4.84360382e-02f, -1.80320621e-01f, 1.42426133e-01f, -7.70662129e-02f, -2.75482535e-02f, 1.10515215e-01f,
  1.36851996e-01f, -7.95768127e-02f, -8.88230950e-02f, -1.09825559e-01f, -6.19382970e-03f, 9.39805061e-02f, 1.49319008e-01f, 2.91701891e-02f, 1.58253118e-01f, -1.85325965e-01f,
  1.29218087e-01f, 1.18285321e-01f, -9.97859612e-02f, -2.55519599e-02f, -1.27267510e-01f, 8.62803012e-02f, 8.93766433e-02f, 1.00594535e-01f, 1.32568881e-01f, -8.65930766e-02f,
  9.27889661e-04f, -7.59440884e-02f, -5.32958210e-02f, 4.86674346e-02f, 3.44209298e-02f, 1.45779476e-01f, -7.62265921e-02f, 2.03208163e-01f, -1.89594254e-02f, -1.39166387e-02f,
  -1.02463201e-01f, -8.19460675e-02f, 8.55080634e-02f, 7.94249624e-02f, 5.88101894e-02f, 1.40648887e-01f, -8.71545300e-02f, -1.20166406e-01f, 1.71003386e-01f, 1.51251614e-01f,
  -7.79394731e-02f, -5.73456511e-02f, 9.88239609e-03f, -1.03073241e-02f, 8.50782171e-02f, 1.21094674e-01f, 7.58688599e-02f, -6.28134385e-02f, 1.55254900e-02f, 1.24499008e-01f,
  2.14890569e-01f, 3.43288630e-02f, -1.26630664e-01f, 1.40515208e-01f, -3.59264985e-02f, 4.03663628e-02f, 1.79537889e-02f, -6.81805536e-02f, 8.04432333e-02f, -8.89554992e-02f,
  1.81573749e-01f, 1.22181050e-01f, 5.73621765e-02f, 2.36480460e-01f, 6.77021816e-02f, -5.11446856e-02f, -2.14865021e-02f, -2.15176210e-01f, -1.17902480e-01f, 1.29330918e-01f,
  -1.02798335e-01f, 1.51729688e-01f, -7.22324550e-02f, -8.62052198e-03f, 2.81249490e-02f, -7.73313046e-02f, -4.27667871e-02f, 1.23622648e-01f, -9.36782584e-02f, 1.47430375e-01f,
  -1.04303304e-02f, -1.20929144e-01f, 1.76302701e-01f, 1.67985067e-01f, 1.24224700e-01f, 1.28973112e-01f, 7.15287328e-02f, -6.90562427e-02f, 1.36819631e-01f, -4.72762883e-02f,
  -7.91822970e-02f, 1.62930667e-01f, -2.47103069e-02f, -8.40328708e-02f, -6.71370327e-02f, -1.99161991e-02f, -2.01940984e-01f, 1.72592759e-01f, 1.07466005e-01f, 1.50718480e-01f,
  -2.07990438e-01f, 5.84421679e-03f, -1.78182945e-02f, 1.02927210e-02f, 1.47247300e-01f, -6.54793084e-02f, 2.05854680e-02f, 1.04297772e-01f, 4.40166245e-04f, 1.46414697e-01f,
  -9.48750228e-03f, -8.80184174e-02f, 8.85377526e-02f, -2.06851703e-03f, 7.13923015e-03f, -5.86274453e-02f, -9.27794650e-02f, -1.29468283e-02f, 9.16302279e-02f, -6.43376708e-02f,
  -4.34500985e-02f, -1.06217049e-01f, 9.02963504e-02f, 5.17120585e-02f, 3.16869095e-02f, 1.64212629e-01f, 8.62691328e-02f, 1.77124649e-01f, 2.11281702e-01f, -3.08567230e-02f,
  -2.93156654e-02f, -5.54954335e-02f, -2.52374783e-02f, 1.62724659e-01f, 1.87533170e-01f, -1.26057088e-01f, -6.64392486e-02f, 7.22697601e-02f, 6.88817203e-02f, 6.79496527e-02f,
  -3.29964496e-02f, 2.71545071e-02f, 1.67697724e-02f, 1.86206624e-01f, 1.98077530e-01f, 1.11858614e-01f, 2.66387239e-02f, -3.63699067e-03f, -1.32386724e-03f, 1.10135294e-01f,
  5.76755926e-02f, 1.03601478e-01f, -3.75341289e-02f, -5.13658896e-02f, 6.75150380e-02f, -7.06052408e-02f, -1.77105237e-02f, -1.37978107e-01f, -4.24296893e-02f, 9.65081435e-03f,
  1.43868372e-01f, 2.68568933e-01f, 1.08943649e-01f, 1.29462853e-01f, -9.87144336e-02f, 9.72126275e-02f, -2.87799574e-02f, -2.54841223e-02f, 2.68009037e-01f, 7.44605809e-02f,
  9.92265716e-02f, -2.89095044e-02f, 9.86106694e-02f, 9.99055579e-02f, 1.56236649e-01f, -5.57200052e-02f, 1.72266677e-01f, 4.73126210e-02f, 1.55751303e-01f, 9.17288885e-02f,
  1.30074516e-01f, 7.81222656e-02f, -5.81725761e-02f, 1.07863955e-01f, 2.14656174e-01f, -1.32983997e-01f, -1.48156792e-01f, 3.77218425e-02f, -1.52811870e-01f, -4.79851514e-02f,
  -1.20171756e-02f, 1.56046554e-01f, 2.18541175e-02f, 4.23966199e-02f, 1.59668654e-01f, 5.14610782e-02f, 2.06296340e-01f, 2.27224797e-01f, -6.04960136e-02f, 2.53867023e-02f,
  -1.26117924e-02f, 2.38556966e-01f, -1.98476508e-01f, -1.09516576e-01f, 1.28617108e-01f, 1.42576452e-02f, -7.50664738e-04f, 3.14077616e-01f, -5.96337207e-02f, -3.25640887e-02f,
  -8.21835548e-02f, 5.52577414e-02f, 1.22679651e-01f, 5.97314648e-02f, -2.01541279e-02f, -1.31220281e-01f, 1.01404153e-01f, -2.08203271e-02f, 1.21790700e-01f, -5.09855151e-02f,
  -9.92556661e-02f, -9.23078284e-02f, -8.05147067e-02f, -6.67414218e-02f, -3.74026112e-02f, 8.93906355e-02f, 8.91278610e-02f, -1.13670953e-01f, 7.52663240e-02f, -6.57280311e-02f,
  6.53009415e-02f, 1.82652265e-01f, 1.26697674e-01f, 3.02966647e-02f, -3.82320322e-02f, 6.89211562e-02f, 1.95061900e-02f, -1.12819776e-01f, 1.08390905e-01f, 1.35103345e-01f,
  5.92532083e-02f, -1.45401686e-01f, 1.69930473e-01f, -1.06950291e-02f, -4.55142856e-02f, -2.48427130e-02f, -1.14808958e-02f, 1.82196155e-01f, 6.39382228e-02f, -2.42776796e-01f,
  -2.28285804e-01f, 1.34596691e-01f, 5.05953282e-02f, 2.54428148e-01f, -1.26786128e-01f, 1.06603973e-01f, 2.59608984e-01f, 1.53110594e-01f, 1.26720369e-01f, 1.86960120e-03f,
  2.88325846e-01f, -1.67849123e-01f, 2.13826671e-02f, 5.57422563e-02f, -1.55054972e-01f, -2.57325135e-02f, -2.02859007e-02f, -4.98911962e-02f, -1.80433749e-03f, 3.00001800e-02f,
  -1.30942941e-01f, 1.17162935e-01f, 5.62198386e-02f, 3.74861024e-02f, -1.53982610e-01f, -4.18654419e-02f, -6.26785681e-02f, 3.14425528e-01f, 1.37875423e-01f, -4.90758456e-02f,
  1.73680454e-01f, 1.08014554e-01f, -7.17992261e-02f, -2.72948861e-01f, -1.05949014e-01f, -1.34641044e-02f, 3.72039946e-03f, -7.62946457e-02f, 2.22447485e-01f, 2.89911509e-01f,
  -6.15912303e-02f, 1.45401239e-01f, -7.81734586e-02f, -1.33334801e-01f, 1.17565461e-01f, 2.48616248e-01f, -3.34386863e-02f, 1.96587175e-01f, 4.18612473e-02f, 2.73107979e-02f,
  1.55037493e-01f, 1.27328321e-01f, 2.08526745e-01f, 1.79545283e-01f, -5.07947616e-02f, 2.04361722e-01f, 2.20198989e-01f, 4.53009941e-02f, 6.24194220e-02f, 2.18047187e-01f,
  -4.79780100e-02f, -3.12093999e-02f, 1.56234860e-01f, 2.56765354e-02f, -1.12346672e-01f, -1.49114564e-01f, 1.32003874e-01f, -4.10284894e-03f, 2.17082649e-02f, 6.07171170e-02f,
  -2.83182949e-01f, -2.92428672e-01f, 8.70872587e-02f, -1.00695796e-01f, -1.67885676e-01f, -1.68500200e-01f, -1.08640134e-01f, 1.94661736e-01f, 2.56806731e-01f, -1.10323243e-01f,
  1.82139605e-01f, -6.75148815e-02f, -4.34769206e-02f, -8.94556381e-03f, 8.74989629e-02f, -1.82607815e-01f, 4.72188778e-02f, -6.95049539e-02f, 1.17643364e-01f, -1.03684038e-01f,
  8.97328630e-02f, 6.57117814e-02f, 8.67660344e-02f, -6.13014027e-03f, 1.53059615e-02f, -8.98304060e-02f, -1.35487676e-01f, 4.32833750e-03f, -6.46355450e-02f, -5.04327267e-02f,
  -7.08435997e-02f, 1.41155392e-01f, 1.30705029e-01f, -8.84872004e-02f, 1.61444210e-02f, 2.42265612e-01f, 9.43937078e-02f, -8.07461664e-02f, 9.44552869e-02f, 3.44300345e-02f,
  1.52981151e-02f, 1.54499292e-01f, 1.12271756e-01f, -6.95395768e-02f, -4.60997522e-02f, -7.98466876e-02f, -1.18464697e-02f, 4.23570462e-02f, 1.57311007e-01f, -5.21062687e-02f,
  6.65752441e-02f, 1.75083891e-01f, -4.58042398e-02f, 8.53377208e-02f, 1.60190776e-01f, 1.90690234e-01f, 3.25147174e-02f, -5.72617687e-02f, 9.00029484e-03f, 5.81255779e-02f,
  1.25233918e-01f, 1.30571231e-01f, 4.47229343e-03f, -1.77830569e-02f, -1.36216179e-01f, 1.49372453e-02f, -3.21537703e-02f, -2.35138759e-02f, 6.10814430e-02f, -1.30793750e-01f,
  2.41707312e-03f, 6.76751211e-02f, -8.61388892e-02f, 7.61221051e-02f, -6.21362180e-02f, -7.68036693e-02f, 2.00850926e-02f, 9.68836471e-02f, 4.92187263e-03f, -5.61905541e-02f,
  -1.10980436e-01f, 1.19356416e-01f, -3.79945189e-02f, -3.92031446e-02f, 1.47171631e-01f, -3.04000545e-02f, -6.20155036e-02f, 5.22344969e-02f, -6.28549159e-02f, -1.39152482e-01f,
  -1.07201310e-02f, -1.39385760e-02f, 1.62417255e-03f, -1.23212315e-01f, 4.99781817e-02f, 1.76917300e-01f, -1.08984951e-02f, 9.03654173e-02f, 9.72755924e-02f, 1.37712613e-01f,
  4.92946990e-03f, 1.03780568e-01f, 1.06698707e-01f, -5.21330424e-02f, 4.79382277e-02f, 5.71958944e-02f, -4.93560880e-02f, 1.20106963e-02f, 1.04673102e-01f, 1.18045965e-02f,
  1.03017047e-01f, 7.84585699e-02f, 1.72731563e-01f, 4.90505882e-02f, 8.43654051e-02f, 1.56480387e-01f, 1.19913571e-01f, -2.84503773e-02f, 9.55388919e-02f, 8.40969104e-03f,
  7.31927976e-02f, 1.19419239e-01f, 2.84004301e-01f, -1.02485947e-01f, -1.67973816e-01f, -6.61300123e-02f, 8.45437273e-02f, 1.86120924e-02f, -1.61319599e-02f, -3.39496462e-03f,
  -4.38375846e-02f, 5.08529283e-02f, -6.30618855e-02f, 1.40873324e-02f, 2.09817756e-02f, 4.11650958e-03f, -1.76314563e-01f, -5.57322018e-02f, -1.42956764e-01f, 1.72736421e-01f,
  1.48819938e-01f, 2.23005991e-02f, -5.37874252e-02f, 7.78968260e-02f, 1.74720213e-01f, 1.24458231e-01f, -1.09823138e-01f, 1.14634097e-01f, 7.22496584e-03f, -8.85933116e-02f,
  3.85629050e-02f, 7.72720799e-02f, -1.20167956e-01f, -7.43920654e-02f, 6.36098459e-02f, 1.63589641e-01f, 1.57409778e-03f, -4.69098166e-02f, 1.79386735e-02f, 2.03902930e-01f,
  -3.79600041e-02f, 5.46550713e-02f, -1.08244918e-01f, -6.28848970e-02f, -4.18345630e-02f, -8.42347220e-02f, -5.00890501e-02f, 1.59055710e-01f, 1.25641217e-02f, -3.38771902e-02f,
  3.30295153e-02f, -4.20418615e-03f, 2.55100802e-02f, 1.72538951e-01f, 1.84487104e-01f, 4.45318827e-03f, -1.43236175e-01f, 1.34620130e-01f, 1.17073260e-01f, 1.23957835e-01f,
  -4.06967513e-02f, -3.28466035e-02f, 1.20681539e-01f, 7.59860082e-03f, -8.14674273e-02f, -2.81978752e-02f, 6.57021552e-02f, 4.69153225e-02f, 8.13505054e-03f, 1.08368583e-01f,
  4.62109735e-03f, 5.48706613e-02f, 2.80347858e-02f, -1.79808587e-01f, 1.45640627e-01f, 6.61060959e-02f, -2.52666101e-02f, 1.58914283e-01f, 9.11590236e-04f, -7.15160072e-02f,
  -1.25537783e-01f, -5.85467517e-02f, -8.90963897e-02f, -5.91584817e-02f, 1.37156978e-01f, 4.39619571e-02f, 9.55937430e-02f, -7.47065842e-02f, 3.30215842e-02f, -2.16105711e-02f,
  2.17916444e-02f, 5.66755347e-02f, 3.83516811e-02f, 4.17445377e-02f, 2.32497938e-02f, 6.58607036e-02f, -5.65658771e-02f, -4.38157395e-02f, 1.63052697e-03f, 6.62454665e-02f,
  9.25689749e-03f, 9.02472660e-02f, -1.05014361e-01f, -2.98366323e-02f, -4.07091342e-03f, 1.18815370e-01f, -1.22446537e-01f, 1.71873599e-01f, -7.99624175e-02f, -1.01595543e-01f,
  2.49462780e-02f, 2.20778614e-01f, 1.68370739e-01f, 1.21757649e-01f, 1.49159804e-01f, 6.97716996e-02f, 6.99310303e-02f, 9.81560498e-02f, 1.44559801e-01f, 1.99600190e-01f,
  3.33174989e-02f, -1.27209648e-01f, 1.99475884e-01f, 1.79524362e-01f, -3.03062778e-02f, 4.01199004e-03f, 4.27773083e-03f, -5.94503954e-02f, 1.86425358e-01f, 2.38790691e-01f,
  9.43116769e-02f, -1.50945142e-01f, 2.34219462e-01f, 2.20395312e-01f, 1.54964864e-01f, 2.25485489e-01f, 4.37396541e-02f, 4.44885701e-01f, -9.36837271e-02f, -4.23335209e-02f,
  -5.09008728e-02f, -1.93797156e-01f, -3.36724557e-02f, 2.71826535e-01f, -7.45375827e-02f, 2.05490053e-01f, 1.62398323e-01f, 1.84096485e-01f, 1.34874374e-01f, 9.06032547e-02f,
  -5.48650743e-03f, 2.52282955e-02f, -1.08647585e-01f, 1.78951547e-01f, 2.53391355e-01f, 1.79664522e-01f, 5.65715194e-01f, 3.39299321e-01f, -8.37313235e-02f, 3.70215662e-02f,
  6.22676536e-02f, -1.20305926e-01f, -7.19447881e-02f, 1.64550111e-01f, -6.12985864e-02f, -1.32525459e-01f, 6.24824502e-02f, -1.25271738e-01f, -7.73020461e-02f, 3.66525352e-01f,
  8.58642906e-02f, 3.45792174e-01f, -2.78684884e-01f, -4.95100580e-02f, -8.99779275e-02f, 7.73352906e-02f, 1.11191168e-01f, -3.01134214e-02f, -2.84749977e-02f, -5.36772050e-02f,
  -1.43258860e-02f, 2.08224908e-01f, 9.33584670e-05f, 1.81935057e-01f, -4.08700667e-02f, -7.16810748e-02f, 1.93008423e-01f, 1.23476170e-01f, -2.76027601e-02f, 8.86484683e-02f,
  -7.85515085e-02f, 1.28584608e-01f, -8.06092471e-02f, 6.34436905e-02f, 1.89481657e-02f, -2.10749712e-02f, 1.82821929e-01f, 1.79387435e-01f, -1.59774959e-01f, 2.51053959e-01f,
  6.81115547e-03f, -7.52461031e-02f, 8.75640437e-02f, -6.40235748e-03f, 1.42745790e-03f, 9.67081711e-02f, -1.21208556e-01f, 7.27977604e-02f, 1.15577906e-01f, 1.43182844e-01f,
  2.26157885e-02f, -8.75759944e-02f, 4.45050746e-02f, 6.72761947e-02f, -2.15881169e-02f, 7.45432153e-02f, -1.12118535e-01f, 1.01185590e-01f, 1.87299073e-01f, 9.07676071e-02f,
  1.52925149e-01f, 8.06576386e-03f, 8.13914537e-02f, -7.49069825e-02f, 3.06411255e-02f, -1.84582695e-02f, 5.88123798e-02f, 1.79829746e-01f, -1.05027422e-01f, 2.57426817e-02f,
  -5.14071062e-02f, -3.13381776e-02f, -9.34069380e-02f, 7.05856383e-02f, 7.64267743e-02f, 2.05904260e-01f, 4.63782065e-02f, -7.79759884e-02f, -1.14571946e-02f, -7.09333867e-02f,
  1.17780305e-01f, -2.42493283e-02f, 2.33709943e-02f, 2.03615606e-01f, 1.17616959e-01f, 8.12058821e-02f, 1.09118752e-01f, -4.34603132e-02f, 1.93646476e-02f, -2.89493017e-02f,
  1.61841840e-01f, 8.04863498e-02f, 1.10280097e-01f, -7.77117014e-02f, -1.13433572e-02f, 1.45855904e-01f, 7.22739426e-03f, -1.49880290e-01f, -2.27526724e-01f, 2.35139318e-02f,
  -1.85656294e-01f, -4.27449355e-03f, 3.71986479e-02f, 1.90882370e-01f, 1.11564957e-01f, 2.28135377e-01f, 2.89878815e-01f, 1.17647044e-01f, 3.16976368e-01f, 8.97527710e-02f,
  8.53600278e-02f, 4.55706194e-02f, -2.61627346e-01f, 2.77900577e-01f, -1.74865112e-01f, 3.60915959e-02f, 2.20289797e-01f, -2.70796418e-02f, -4.59942147e-02f, 3.81582171e-01f,
  6.53942600e-02f, -1.79114717e-03f, 4.99122404e-02f, -2.78812833e-02f, 8.53197128e-02f, 9.71566439e-02f, -6.88099265e-02f, -1.94042414e-01f, -6.40125126e-02f, 1.70628145e-01f,
  7.86345154e-02f, -2.12652721e-02f, 1.37602553e-01f, -1.22066498e-01f, 6.46936595e-02f, -1.06760316e-01f, 4.74785157e-02f, 8.16519484e-02f, -9.68288109e-02f, -1.01460248e-01f,
  2.09301382e-01f, -6.68637753e-02f, 7.02066794e-02f, -4.52237725e-02f, 1.38094351e-01f, 3.41019854e-02f, 1.48918882e-01f, -4.10602093e-02f, -1.00938892e-02f, -1.60400361e-01f,
  -1.25306845e-01f, 1.20285839e-01f, 1.73608735e-01f, 8.06839466e-02f, 1.03260569e-01f, -8.11759606e-02f, 1.92089900e-01f, -8.02989304e-02f, 1.46652296e-01f, 1.87824249e-01f,
  -7.83979818e-02f, -4.13397253e-02f, 1.38967410e-01f, 1.97153259e-02f, 6.87584281e-02f, -1.76275000e-01f, 3.21638733e-02f, -2.50009209e-01f, -1.77618042e-02f, 9.18502063e-02f,
  -3.02067339e-01f, 5.70390709e-02f, -2.17539176e-01f, -1.78942576e-01f, 3.91680151e-02f, 4.62243222e-02f, -8.57983828e-02f, -1.53681502e-01f, 7.48176947e-02f, 2.42812559e-01f,
  -1.41674966e-01f, 6.44811057e-03f, -5.00472598e-02f, 7.58185983e-02f, 2.18349025e-01f, 1.13590650e-01f, 1.44561201e-01f, -4.85161133e-02f, 2.60716915e-01f, -8.67315233e-02f,
  2.77184229e-02f, 2.87785292e-01f, 2.51164241e-03f, -5.48201129e-02f, 9.61986035e-02f, 9.16719958e-02f, -6.07040599e-02f, -2.50206217e-02f, -2.54884479e-03f, -1.38776585e-01f,
  1.97347119e-01f, -1.26311451e-01f, 7.94545710e-02f, 8.53522718e-02f, -1.61381215e-02f, -8.03527087e-02f, -4.04000320e-02f, 1.65485993e-01f, 2.03115381e-02f, 6.34769499e-02f,
  7.82546923e-02f, 1.49537414e-01f, 1.32496223e-01f, -4.23580334e-02f, 7.52625093e-02f, 1.97186083e-01f, -2.01233998e-02f, -2.80343071e-02f, -7.63077810e-02f, 1.02963679e-01f,
  5.33143245e-02f, 1.71708986e-01f, -1.34365976e-01f, 2.50920597e-02f, 7.85543472e-02f, -1.81022301e-01f, -1.64251223e-01f, -1.30152076e-01f, 2.36344337e-01f, 1.29199103e-02f,
  -2.63328701e-01f, -1.05163962e-01f, -1.52376577e-01f, -1.46989569e-01f, -2.22548053e-01f, 3.62480953e-02f, -1.55191869e-01f, -1.82944924e-01f, 1.46196987e-02f, 2.55223215e-01f,
  3.78092915e-01f, -1.07532404e-01f, 2.91121960e-01f, -1.14525072e-01f, -2.24589221e-02f, -2.53826641e-02f, 6.67160600e-02f, -1.01079419e-01f, 4.46860380e-02f, -1.17840797e-01f,
  1.29276633e-01f, -2.44703200e-02f, 7.94785470e-02f, 1.61807775e-01f, 6.91344589e-02f, 1.61999520e-02f, 1.97370380e-01f, -2.45700497e-02f, 6.71852976e-02f, 1.74450248e-01f,
  -6.26687035e-02f, 2.73549976e-03f, 9.95511413e-02f, -1.77102059e-01f, 4.13160145e-01f, -4.73221168e-02f, 3.74044962e-02f, 2.81942338e-01f, 5.93763031e-02f, 1.00001425e-01f,
  1.34531751e-01f, 1.89118177e-01f, -7.27583170e-02f, 2.32453831e-02f, 4.38202098e-02f, 1.48817375e-01f, -5.90030365e-02f, 1.32037356e-01f, 1.71653956e-01f, 1.49125069e-01f,
  -1.92028377e-02f, 2.44647756e-01f, 2.19707824e-02f, -1.30122760e-02f, 1.58328772e-01f, 2.96553154e-03f, 1.73170015e-01f, 2.35291034e-01f, 2.09598407e-01f, 1.02203988e-01f,
  1.96618646e-01f, -1.90874144e-01f, -1.29840195e-01f, 5.94723709e-02f, 5.79237603e-02f, 1.01915054e-01f, -2.32541487e-01f, 2.34326180e-02f, -2.83275843e-02f, -2.15016715e-02f,
  -1.58789426e-01f, -2.80757695e-02f, -1.29456207e-01f, -1.27594816e-02f, 1.27802581e-01f, 6.33916929e-02f, 1.59630906e-02f, 4.74296883e-02f, 7.35551864e-02f, 2.16744263e-02f,
  1.72090903e-01f, 2.14992985e-02f, -7.02974051e-02f, 5.17402636e-03f, -1.27224773e-01f, -2.95023751e-02f, -3.63834798e-02f, -1.90920606e-02f, -9.49760675e-02f, -5.15389591e-02f,
  1.40497414e-02f, -4.62277196e-02f, 9.17464048e-02f, -7.26236030e-02f, 9.83521044e-02f, -6.89393282e-02f, 1.54655967e-02f, 2.15787515e-01f, 1.09682912e-02f, -1.56277567e-01f,
  6.25309944e-02f, 5.01696020e-02f, -2.16192491e-02f, 4.85979356e-02f, 1.08189151e-01f, -3.49050462e-02f, 4.92480546e-02f, -2.56618746e-02f, 1.58882216e-01f, 1.39297813e-01f,
  -4.49302122e-02f, -1.15483843e-01f, -2.29124445e-04f, 8.12386572e-02f, 9.25352946e-02f, 1.52178675e-01f, -6.13713190e-02f, -6.67445883e-02f, 1.51099503e-01f, -5.89582585e-02f,
  9.46978927e-02f, 1.34598032e-01f, 9.58756804e-02f, 1.65704966e-01f, 1.70659691e-01f, 6.45502135e-02f, 2.60050651e-02f, 6.81836670e-03f, 1.83282167e-01f, -1.25576705e-01f,
  -2.52449419e-02f, 4.67609651e-02f, -1.13480084e-01f, -8.64882767e-02f, 4.85359225e-03f, -1.30597442e-01f, 1.18613079e-01f, -1.21703394e-01f, -1.71168953e-01f, 2.38524675e-02f,
  -6.20373785e-02f, 2.82342564e-02f, 9.61990654e-02f, 2.89087594e-02f, 9.71970484e-02f, 1.46441355e-01f, 8.85936990e-02f, 6.97086081e-02f, -6.99277818e-02f, 8.62236470e-02f,
  1.63094550e-01f, 7.79267773e-02f, 3.77945676e-02f, 6.71924502e-02f, -7.99766108e-02f, 1.23326614e-01f, 8.70147943e-02f, 5.30250780e-02f, 1.12424269e-02f, 3.37940045e-02f,
  4.00424637e-02f, 4.46388358e-03f, 1.85160339e-01f, -6.88759089e-02f, 1.40099809e-01f, -3.21723223e-02f, 7.39208087e-02f, 6.47511408e-02f, -9.37162787e-02f, -6.10906146e-02f,
  -8.87698010e-02f, 1.86388716e-01f, 7.40842223e-02f, 3.65098827e-02f, 7.78069645e-02f, -5.43066934e-02f, 1.33045375e-01f, 1.51999891e-01f, 7.79325664e-02f, 1.23891704e-01f,
  -4.87309210e-02f, 1.00632332e-01f, 1.96693376e-01f, -3.69766802e-02f, 1.02339320e-01f, 4.12193239e-02f, 1.06948003e-01f, -2.35058323e-01f, -8.05258080e-02f, -6.78523555e-02f,
  -5.44733554e-02f, -2.13542461e-01f, -6.30051121e-02f, -9.85987931e-02f, -1.82206720e-01f, -1.20276615e-01f, -1.06876986e-02f, 1.22325547e-01f, 7.56257772e-02f, -7.45676905e-02f,
  -3.42018716e-02f, -3.85666452e-02f, 1.27129734e-01f, 1.15562573e-01f, 2.92055067e-02f, -9.14322585e-02f, -7.91856498e-02f, 1.38202935e-01f, 2.23999973e-02f, 1.39342114e-01f,
  8.52399096e-02f, 1.48017630e-02f, -3.72886658e-02f, -9.53478217e-02f, -1.71924755e-01f, 4.36207540e-02f, 1.10090345e-01f, 1.14867777e-01f, -7.52935708e-02f, 2.31437609e-02f,
  4.77948319e-03f, -2.15704925e-03f, 7.75014684e-02f, -1.18749060e-01f, 1.04992986e-01f, -2.96424180e-02f, 2.56909549e-01f, 9.43170488e-03f, -9.19398153e-05f, 7.79586434e-02f,
  1.17462195e-01f, 2.77380496e-02f, -7.06074461e-02f, 1.00145273e-01f, 2.10556723e-02f, 4.95769316e-03f, 9.31182504e-02f, 1.33744493e-01f, 1.19637825e-01f, -1.09400950e-01f,
  6.62375242e-02f, 1.75536647e-02f, 3.32376338e-03f, 1.03536732e-01f, -5.03939651e-02f, 7.57154729e-03f, 8.47274736e-02f, 4.31568846e-02f, -1.78372059e-02f, 9.24597830e-02f,
  -1.37761338e-02f, -1.05011106e-01f, -1.32811606e-01f, -8.22754297e-03f, 1.07458390e-01f, -7.36490861e-02f, -7.43143866e-03f, -1.37467757e-01f, -3.81217673e-02f, -5.94775751e-02f,
  3.71894762e-02f, -3.45612392e-02f, 1.18876413e-01f, -5.80359623e-02f, -1.09290503e-01f, -8.74464437e-02f, 7.74206594e-02f, -1.71978753e-02f, 4.36586328e-02f, 1.99007057e-02f,
  -5.92259057e-02f, 1.17216520e-01f, -3.96297127e-02f, -6.98433369e-02f, 9.54711586e-02f, 2.84103062e-02f, -8.55686143e-02f, 5.97871020e-02f, -8.38079676e-03f, 4.09444124e-02f,
  7.34616816e-02f, 1.18676513e-01f, 1.27525860e-02f, 1.22921929e-01f, 4.17783074e-02f, -3.97023782e-02f, 1.15585722e-01f, 1.10234305e-01f, 8.08536783e-02f, 4.18124124e-02f,
  2.48403355e-01f, -3.71650234e-02f, -4.76968586e-02f, 7.87341893e-02f, 1.05341166e-01f, 1.10995486e-01f, 9.16768014e-02f, -1.86663121e-02f, -1.44113293e-02f, 4.06381339e-02f,
  1.55849129e-01f, -1.65381338e-02f, -4.57695425e-02f, -5.60992621e-02f, 1.10533819e-01f, 1.47670746e-01f, 6.21464550e-02f, -3.05079632e-02f, -4.99634147e-02f, -5.63197322e-02f,
  1.07252494e-01f, -7.99864233e-02f, 1.13759838e-01f, -3.31369676e-02f, -5.97841553e-02f, -3.04878540e-02f, 6.87871575e-02f, -1.55697063e-01f, 2.39598099e-02f, 6.54743463e-02f,
  -5.42948283e-02f, -1.35679379e-01f, -2.47485358e-02f, -4.19776030e-02f, -7.40453079e-02f, 6.65201247e-02f, -5.48644736e-02f, -1.82839781e-01f, 7.28313923e-02f, -1.14209384e-01f,
  6.83377385e-02f, -4.83369417e-02f, 1.14986502e-01f, -7.70191923e-02f, -1.20324612e-01f, 1.11051328e-01f, 1.04189485e-01f, -1.12910949e-01f, 4.37030979e-02f, -1.04154006e-01f,
  6.59888014e-02f, -8.59898925e-02f, 8.11995044e-02f, 1.71141475e-01f, -7.25897029e-02f, 3.20259891e-02f, -7.66055658e-02f, 5.63923130e-03f, -4.55081202e-02f, -8.69190171e-02f,
  1.09977841e-01f, 9.83425677e-02f, 5.68835139e-02f, -3.08077261e-02f, 2.57686168e-01f, -1.47261083e-01f, -3.43606658e-02f, 1.83347613e-01f, -5.89852557e-02f, 2.75855754e-02f,
  5.33584431e-02f, 1.59104411e-02f, 1.11589819e-01f, -5.36456984e-03f, 5.25791273e-02f, 7.20828697e-02f, 1.44629523e-01f, -3.47486814e-03f, -1.02185860e-01f, 8.18172321e-02f,
  2.06549451e-01f, 2.12416828e-01f, 9.68868099e-03f, -3.25719342e-02f, 2.50159562e-01f, 4.50700969e-02f, 1.43910691e-01f, 2.90592730e-01f, -4.37155999e-02f, 1.43380374e-01f,
  3.42114419e-02f, -9.80609357e-02f, 5.93318045e-02f, -6.60834834e-02f, 1.78696632e-01f, 1.79871749e-02f, -1.20868348e-01f, 3.11962552e-02f, -1.73770100e-01f, -1.81719497e-01f,
  -1.09815888e-01f, -2.29033530e-01f, -1.73490509e-01f, 4.41805907e-02f, -1.39519632e-01f, -1.21086724e-01f, -1.11168837e-02f, 2.31235176e-01f, -5.54945990e-02f, -4.34970222e-02f,
  8.21537003e-02f, 1.29374236e-01f, -2.06402801e-02f, 5.70877604e-02f, 6.45977631e-02f, 2.61274036e-02f, 3.11623633e-01f, 1.23652652e-01f, -1.32679820e-01f, 1.12010967e-02f,
  -5.15123606e-02f, -5.03704287e-02f, 4.27725166e-02f, -5.54726981e-02f, 3.84020656e-02f, 1.54626369e-02f, -1.58910640e-02f, -1.74577385e-02f, 1.00787893e-01f, -1.14516623e-01f,
  7.89672658e-02f, -8.31713527e-02f, -1.35831192e-01f, 2.80297045e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.02171049e-01f, 9.21617597e-02f, 2.07110748e-01f, -2.04239748e-02f, -2.99627855e-02f, 1.84583459e-02f, 6.15625130e-03f, -4.64248098e-02f, -3.47464196e-02f, 1.01658739e-02f,
  1.29070044e-01f, 8.30202028e-02f, -3.44611146e-02f, -5.59553988e-02f, -6.37895837e-02f, 1.34751037e-01f, 1.48914112e-02f, 1.66861206e-01f, 1.25089601e-01f, 3.40842567e-02f,
  1.27789468e-01f, 6.53574094e-02f, 9.63326693e-02f, -3.34514864e-02f, 1.57307491e-01f, 4.48645838e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.08714306e-01f, 2.42955104e-01f, 1.42167270e-01f, -2.78714031e-01f, -9.26764216e-03f, -2.28587717e-01f, 1.39493465e-01f, -4.16136384e-02f, -2.14764863e-01f, -6.04686588e-02f,
  1.75191343e-01f, 3.22141647e-01f, 1.25413612e-01f, -9.15066712e-03f, 9.44946632e-02f, -3.09963703e-01f, -6.19305186e-02f, 1.09457396e-01f, -4.98505533e-02f, 5.48683219e-02f,
  -4.89101373e-03f, 3.08083951e-01f, 7.41324574e-02f, -1.93687066e-01f, 1.65825665e-01f, 2.58189708e-01f, -8.57420638e-02f, 3.52408171e-01f, 3.27301085e-01f, 3.96882951e-01f,
  -4.10425961e-02f, 1.06844697e-02f, 2.33740732e-01f, -5.27162477e-02f, -3.57695758e-01f, 3.11928660e-01f, 2.86844164e-01f, 2.06441507e-01f, 4.74039704e-01f, 9.19989422e-02f,
  2.45347023e-01f, 1.12102307e-01f, 1.07370719e-01f, -2.82314029e-02f, -1.24522075e-01f, -2.55695909e-01f, -2.09711879e-01f, -2.24496797e-01f, -2.40615696e-01f, 2.56661057e-01f,
  7.18550906e-02f, 1.73704579e-01f, -5.46367615e-02f, -6.40931904e-01f, -2.46473253e-01f, -3.53128791e-01f, 2.37679094e-01f, 8.55964497e-02f, 1.94961354e-01f, -1.83777697e-02f,
  3.04548234e-01f, 1.55483887e-01f, 7.69149885e-02f, 6.07182868e-02f, 1.63039252e-01f, 7.15249628e-02f, -2.66995281e-01f, 7.84014910e-02f, 7.65485689e-02f, -1.76689252e-01f,
  1.01502545e-01f, 1.47526599e-02f, -8.74518380e-02f, -1.44799510e-02f, -2.56008729e-02f, -2.58863360e-01f, 7.93770775e-02f, 3.33786905e-02f, 2.48251989e-01f, 1.43216819e-01f,
  -9.83329043e-02f, 3.35645556e-01f, 5.62698673e-03f, 1.63964361e-01f, -9.74259600e-02f, 3.21846277e-01f, 3.11952233e-01f, -1.19008139e-01f, 3.01273972e-01f, -2.45698228e-01f,
  -1.48702096e-02f, -6.30581677e-02f, 2.22029775e-01f, 3.96518350e-01f, -2.21834749e-01f, 2.08746970e-01f, -1.82669386e-01f, -2.09681064e-01f, -8.98039266e-02f, 7.53140077e-02f,
  -5.66319972e-02f, 2.83280283e-01f, -3.48629117e-01f, 1.41350120e-01f, -4.88773286e-01f, 1.00818637e-03f, -2.23292530e-01f, 2.39322647e-01f, 1.68413129e-02f, -2.31211558e-01f,
  -1.72566995e-01f, -1.91147417e-01f, 5.76865152e-02f, 2.51942068e-01f, 4.12030853e-02f, -1.25179604e-01f, -1.96267039e-01f, -3.90669145e-03f, -2.60324210e-01f, -2.86894083e-01f,
  3.60595465e-01f, 5.28016388e-01f, 3.08038890e-01f, 1.68732136e-01f, 1.02738865e-01f, 1.45640224e-01f, 3.90652150e-01f, 3.09168279e-01f, 9.94793251e-02f, 2.14992970e-01f,
  -1.94004178e-01f, 2.11119756e-01f, -3.39490175e-01f, -8.04860592e-02f, -1.47772267e-01f, -1.74177811e-01f, -1.98701918e-01f, 4.95342575e-02f, 1.63753897e-01f, -2.12589040e-01f,
  4.50556166e-02f, -9.79902968e-02f, -1.10923901e-01f, -1.33951724e-01f, 4.30578366e-02f, 4.37945724e-02f, 7.11832792e-02f, -3.49292904e-01f, 3.01179022e-01f, 9.26565900e-02f,
  -2.59525776e-01f, 1.63019031e-01f, -5.05588166e-02f, -2.22984448e-01f, 4.67330962e-02f, 1.74240246e-01f, 6.03225082e-02f, -6.31939173e-02f, 1.45043641e-01f, -1.60098150e-01f,
  -1.97473336e-02f, -1.27584383e-01f, 1.10134268e-02f, -2.13585407e-01f, -2.64682651e-01f, -2.86108643e-01f, -3.92177105e-01f, 8.47400259e-03f, -3.68173271e-01f, -7.22310394e-02f,
  -1.62895069e-01f, 1.34410828e-01f, 2.99877197e-01f, 3.04482639e-01f, 1.29146829e-01f, -3.00767511e-01f, -2.56864011e-01f, 2.69226521e-01f, 2.10030954e-02f, -3.81184071e-02f,
  1.16578326e-01f, 5.40268421e-01f, 1.42937064e-01f, -2.81878442e-01f, 7.06697032e-02f, 3.10300410e-01f, -1.36960387e-01f, -1.91768587e-01f, -3.11357051e-01f, -2.05072984e-02f,
  7.95103610e-02f, -1.92204684e-01f, -9.90811363e-03f, 2.15306491e-01f, 4.89350669e-02f, 4.16989885e-02f, -1.08492032e-01f, 9.59600881e-02f, -4.50103879e-01f, 1.85774818e-01f,
  2.50756353e-01f, -3.95955816e-02f, 2.12780908e-01f, -4.14348505e-02f, 1.70165464e-01f, 2.33016402e-01f, -4.14004952e-01f, -6.59359992e-02f, -4.15499089e-03f, -3.10548723e-01f,
  2.18576327e-01f, 2.15419322e-01f, 1.03439212e-01f, -1.80765837e-01f, 1.50258183e-01f, -1.96340397e-01f, -1.87055349e-01f, 1.52724057e-01f, -1.07569173e-01f, 2.66760867e-03f,
  3.00229669e-01f, 1.59014598e-01f, 4.74817038e-01f, 8.85513648e-02f, 2.45835364e-01f, 3.39596868e-01f, -1.62707095e-03f, -7.74743110e-02f, 4.07231629e-01f, -6.61804751e-02f,
  8.02369565e-02f, -4.41018939e-02f, 6.22301102e-01f, -2.78918166e-02f, 1.04954362e-01f, -1.77306369e-01f, -1.16223283e-01f, -2.24667400e-01f, -2.16037318e-01f, 4.93331075e-01f,
  -1.69168562e-01f, -2.25405190e-02f, -3.33713815e-02f, -1.74805015e-01f, 9.44681540e-02f, -5.77032924e-01f, 1.20425612e-01f, 2.98279524e-01f, -1.46202028e-01f, -1.11579128e-01f,
  -1.16275912e-02f, -2.14684665e-01f, 1.32330358e-01f, -5.32603152e-02f, -7.25996271e-02f, -1.55480772e-01f, -7.95078054e-02f, -1.73870698e-02f, -3.54948975e-02f, 2.44498923e-01f,
  1.64816409e-01f, 7.32104331e-02f, 2.33106837e-01f, -1.10905454e-01f, 1.05637625e-01f, 1.40416145e-01f, 1.72361806e-01f, 4.57779795e-01f, -1.02287263e-01f, 1.70579806e-01f,
  3.21973443e-01f, -6.37600347e-02f, 9.39053223e-02f, 2.37589449e-01f, -1.50493413e-01f, -2.79025704e-01f, 4.16711457e-02f, -2.47883812e-01f, -2.07439974e-01f, 1.10925414e-01f,
  2.09262595e-01f, 3.07841808e-01f, -2.33503759e-01f, -4.10252586e-02f, -1.85073927e-01f, -2.88208276e-01f, 1.74416468e-01f, -2.16145113e-01f, 2.62824744e-01f, 1.91969454e-01f,
  -3.28972965e-01f, -1.03283964e-01f, -1.68244690e-01f, 1.67318806e-01f, 4.70892191e-01f, -7.81219155e-02f, 5.24683952e-01f, -9.77635086e-02f, 2.40611702e-01f, -1.89116180e-01f,
  1.14740252e-01f, -9.15271789e-02f, 1.39078079e-03f, 1.30385995e-01f, -3.03260356e-01f, -3.30587596e-01f, -1.86303332e-01f, 3.54838014e-01f, 1.07606754e-01f, -1.93242565e-01f,
  -1.17016278e-01f, 1.63134545e-01f, 4.90683205e-02f, -1.87083811e-01f, 1.51728615e-01f, 1.63399160e-01f, -9.76877883e-02f, -2.13025376e-01f, -1.37721017e-01f, -4.36277948e-02f,
  8.54995400e-02f, -1.64663121e-01f, 3.19227040e-01f, -2.00563774e-01f, -9.58956629e-02f, 1.82497904e-01f, 2.32476443e-01f, -1.51804164e-01f, -8.93587992e-02f, 3.60042334e-01f,
  2.90712029e-01f, -3.11251134e-01f, 4.29990664e-02f, 1.86650559e-01f, 2.64416099e-01f, 3.17859083e-01f, 1.80598661e-01f, 3.21343213e-01f, 6.13181330e-02f, -2.61759579e-01f,
  -5.58830388e-02f, -5.02072610e-02f, 2.85751820e-01f, -2.96244830e-01f, 1.28312081e-01f, -4.46385115e-01f, -2.13865861e-01f, 3.76583487e-01f, -1.53986305e-01f, -2.35016987e-01f,
  -3.26182306e-01f, 3.11537087e-01f, 1.42232299e-01f, -2.47057498e-01f, 2.20954344e-01f, 3.61665845e-01f, -1.11232556e-01f, -1.68734472e-02f, 2.82449514e-01f, 7.81691521e-02f,
  1.69443727e-01f, 5.05388081e-02f, 9.36342701e-02f, 2.54344970e-01f, -1.38704687e-01f, 1.44820690e-01f, -1.17556080e-02f, 7.96752274e-02f, -9.11535919e-02f, 2.08531052e-01f,
  1.76412433e-01f, 2.69892454e-01f, 2.09998965e-01f, 3.40933166e-02f, 4.65464257e-02f, -6.78382963e-02f, -3.12055916e-01f, -3.02442253e-01f, 4.10230100e-01f, -4.94582653e-02f,
  -1.62432089e-01f, -2.78563180e-04f, -1.11750640e-01f, 1.21084988e-01f, -4.90732044e-01f, -1.90528244e-01f, 1.70073062e-01f, 1.92190602e-01f, 2.43485849e-02f, -5.25195338e-02f,
  -2.04258487e-01f, 2.26328209e-01f, 1.99120045e-01f, 3.38191055e-02f, 2.71509774e-02f, 4.84835058e-02f, 2.95765530e-02f, -6.05551302e-02f, -4.71790768e-02f, -1.95093706e-01f,
  -1.64293293e-02f, 7.61709213e-02f, 2.07881108e-01f, -2.35341683e-01f, -2.03613520e-01f, -8.87812376e-02f, -3.38832170e-01f, 2.41424739e-01f, -3.46320510e-01f, -2.82845497e-01f,
  -5.04436120e-02f, -4.15794458e-03f, -3.25298548e-01f, -2.04363570e-01f, -1.28569856e-01f, 3.35083038e-01f, -4.59466204e-02f, -4.24176067e-01f, 3.57013911e-01f, -9.22796056e-02f,
  -3.45113516e-01f, 6.31544814e-02f, -3.15952688e-01f, -3.62266392e-01f, 2.83677354e-02f, -8.38907063e-02f, -1.70585155e-01f, -2.66627043e-01f, -1.72559500e-01f, 1.19124904e-01f,
  -1.26664951e-01f, -2.19919048e-02f, -1.49793714e-01f, -1.10066712e-01f, 1.72296315e-01f, 5.34869060e-02f, -7.63974860e-02f, 6.01274490e-01f, 2.59502620e-01f, -1.84887305e-01f,
  2.43416578e-01f, -1.83960363e-01f, 1.13185823e-01f, 9.32676941e-02f, -2.02042893e-01f, -4.35138866e-02f, -5.21377735e-02f, 4.33353841e-01f, -4.88775857e-02f, -1.80692345e-01f,
  -2.99028814e-01f, -2.30092660e-01f, -1.15683891e-01f, -1.66479841e-01f, -8.02723095e-02f, -3.52425352e-02f, -2.33154684e-01f, 6.53495267e-02f, -2.23463610e-01f, 6.63711950e-02f,
  4.32108752e-02f, -1.65807605e-01f, -1.14932477e-01f, -1.95646986e-01f, -3.03861260e-01f, 9.21331288e-04f, -4.54878174e-02f, 3.82204801e-01f, 1.17323153e-01f, -2.53309846e-01f,
  6.97705597e-02f, -1.95890769e-01f, 5.03119938e-02f, 1.82014376e-01f, 4.59528893e-01f, -2.42809668e-01f, -2.70675927e-01f, -2.39622757e-01f, 2.19983459e-01f, -6.35445714e-02f,
  -1.73049256e-01f, 1.75516173e-01f, -1.01204120e-01f, -1.97215050e-01f, 2.30491813e-02f, 3.66860963e-02f, 2.81959713e-01f, -1.77734062e-01f, -3.18881720e-02f, -4.13274094e-02f,
  5.30671895e-01f, -2.65643418e-01f, 2.91969888e-02f, -2.53264874e-01f, 1.25531018e-01f, 1.45540252e-01f, 2.54369795e-01f, -3.45817626e-01f, -1.52909756e-01f, -4.41250913e-02f,
  3.34506817e-02f, -4.26593065e-01f, -1.96741015e-01f, 4.73027557e-01f, 8.01329408e-03f, -2.18040571e-01f, -2.50469834e-01f, 1.45581543e-01f, 1.30858108e-01f, 1.23794757e-01f,
  6.09042980e-02f, -2.91308556e-02f, 3.37865129e-02f, 1.08059525e-01f, 8.44697952e-02f, -3.69274229e-01f, 2.94891279e-02f, 3.09444834e-02f, 2.48945236e-01f, -7.76997432e-02f,
  1.16115408e-02f, -3.21847528e-01f, 3.19882557e-02f, -1.14665791e-01f, -2.78291665e-02f, -1.36659309e-01f, -1.58374518e-01f, 1.13465764e-01f, -4.33005765e-02f, -7.68003147e-03f,
  5.24144620e-02f, 3.52037430e-01f, 2.82202661e-01f, 2.42827684e-01f, 2.33803242e-01f, 2.02513754e-01f, -1.35371964e-02f, -1.07706554e-01f, -2.21062943e-01f, 9.69687104e-02f,
  1.61609590e-01f, 8.35923404e-02f, -3.19478631e-01f, 1.33227795e-01f, -1.16618030e-01f, 3.90925139e-01f, 1.65280253e-01f, 2.08916888e-01f, 2.96771318e-01f, -4.03404117e-01f,
  -3.88536453e-01f, 4.17072356e-01f, -1.95613131e-01f, -1.01076111e-01f, 4.10605855e-02f, 5.51407754e-01f, 2.27135375e-01f, 3.14436793e-01f, 1.50603428e-01f, -1.19134396e-01f,
  2.07372695e-01f, 2.03986466e-01f, -1.66018695e-01f, -1.13327660e-01f, 1.67179465e-01f, -1.64490238e-01f, 2.41537824e-01f, -2.47022793e-01f, -2.56473452e-01f, 3.38903725e-01f,
  -1.35110840e-01f, -3.06596756e-01f, -4.47870530e-02f, 8.06511939e-02f, -5.57344817e-02f, -3.83132130e-01f, -3.20652694e-01f, -3.88951838e-01f, 1.15894124e-01f, 7.88673237e-02f,
  1.47811035e-04f, -1.36896357e-01f, -2.36318618e-01f, 5.69149628e-02f, 1.19381025e-01f, -2.62792408e-01f, -2.59402424e-01f, -2.23534077e-01f, 6.55164421e-02f, -6.13748170e-02f,
  -2.90480226e-01f, 1.54636875e-01f, 8.82333070e-02f, -3.76761556e-01f, -3.04367065e-01f, -1.51326150e-01f, -9.87420827e-02f, 1.10975616e-01f, -1.13949478e-01f, 3.15242000e-02f,
  1.91258281e-01f, -3.01691979e-01f, -1.61953390e-01f, -1.31947756e-01f, -2.54963696e-01f, -8.71208236e-02f, -9.76877511e-02f, -2.23143771e-01f, -3.10762208e-02f, -3.20746958e-01f,
  -5.48322760e-02f, -4.32718247e-02f, -3.19612354e-01f, 2.96326689e-02f, 4.29585636e-01f, -2.17852015e-02f, -3.72601181e-01f, -6.03973605e-02f, 3.09106320e-01f, -3.12690437e-02f,
  9.44339857e-02f, -1.93758026e-01f, 2.31260717e-01f, -6.02512769e-02f, -7.35221952e-02f, -4.20331419e-01f, -1.57104097e-02f, 2.54280984e-01f, -1.39278024e-01f, -8.83236295e-04f,
  -2.23100021e-01f, -1.04049705e-01f, 5.19679666e-01f, -2.83903211e-01f, -2.36329541e-01f, 2.15720400e-01f, -1.28225014e-01f, -9.32724252e-02f, -6.22084178e-02f, 2.56688923e-01f,
  -2.13020369e-02f, -1.20924592e-01f, 8.32518116e-02f, 9.98765677e-02f, -1.11138910e-01f, 3.79712768e-02f, -2.87734598e-01f, 1.82159841e-01f, 7.55308867e-02f, 1.13801211e-01f,
  2.27098361e-01f, 2.01998070e-01f, 9.37876776e-02f, -2.43907169e-01f, -2.91896433e-01f, 1.12537898e-01f, 4.57776412e-02f, -4.73229945e-01f, -4.78935754e-03f, 3.72768909e-01f,
  -5.01508303e-02f, -2.28539899e-01f, 1.76416621e-01f, -1.85956895e-01f, -2.87965417e-01f, 4.66126472e-01f, 2.69461304e-01f, -1.43070087e-01f, 2.80379951e-01f, 2.22309753e-01f,
  1.84012413e-01f, 7.58794919e-02f, -2.92368263e-01f, 2.90852368e-01f, 1.85831577e-01f, -6.78474829e-02f, 1.35329872e-01f, -5.91800511e-02f, -3.84464741e-01f, -3.00099663e-02f,
  -9.08404067e-02f, -5.98817319e-02f, -1.55415401e-01f, 1.16681367e-01f, -1.72339082e-01f, -1.75775856e-01f, 2.09509861e-02f, 1.32150337e-01f, 4.78192180e-01f, -1.46640176e-02f,
  1.92700580e-01f, -2.00106129e-01f, -7.70564005e-02f, 3.07388574e-01f, 1.24062903e-01f, 1.51966959e-01f, -5.98855875e-02f, 3.81186485e-01f, -1.24107622e-01f, -1.15996607e-01f,
  1.69976130e-01f, 1.00477889e-01f, 5.11768609e-02f, -1.21183597e-01f, 2.57153094e-01f, -2.31020465e-01f, -4.37534228e-02f, 2.20360950e-01f, -2.06078105e-02f, 5.04184663e-02f,
  3.71918380e-01f, 1.15939900e-01f, 2.09423136e-02f, 7.99501687e-02f, -2.48600245e-01f, 1.82063580e-01f, 1.15488939e-01f, -1.15065791e-01f, 1.15862966e-01f, 4.51932335e-03f,
  1.36108603e-02f, 1.46862701e-01f, 1.94940686e-01f, -1.24633506e-01f, -3.68765518e-02f, -1.54397637e-01f, -4.92556132e-02f, -6.01368509e-02f, -1.68442890e-01f, -2.93108597e-02f,
  3.45717251e-01f, -1.81459412e-01f, -3.22379082e-01f, -2.70937443e-01f, -1.39736518e-01f, -3.29902172e-01f, -2.71030068e-01f, 9.56739113e-02f, 1.89424768e-01f, -1.52476206e-01f,
  3.95473748e-01f, 1.69300690e-01f, -1.77623227e-01f, 1.04212046e-01f, 1.02481633e-01f, -1.28613830e-01f, -3.30912858e-01f, -1.27879277e-01f, -1.62320316e-01f, 1.02647319e-01f,
  2.52153099e-01f, 3.16777766e-01f, 4.80423242e-01f, -3.57158989e-01f, 2.81379763e-02f, -2.04278696e-02f, 4.45444323e-02f, 2.45654598e-01f, -5.78251481e-02f, 3.87711912e-01f,
  -2.85251439e-01f, -4.15248275e-01f, -4.98834737e-02f, -1.09066684e-02f, -1.74386352e-01f, -1.67107776e-01f, -1.16004698e-01f, -5.38700111e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.00365495e-02f, 1.56714633e-01f, -8.80180597e-02f, 4.87667136e-02f, -1.25087947e-01f, 5.74903376e-02f, -9.37608108e-02f, -1.10245414e-01f, 4.94424254e-02f, 8.50727558e-02f,
  -5.98782077e-02f, 1.63640022e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    