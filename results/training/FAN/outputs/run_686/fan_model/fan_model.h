/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.23031892e-01f, 2.97216654e-01f, 2.93314129e-01f, 6.93650469e-02f, 2.63175040e-01f, 1.94568008e-01f, 3.95615518e-01f, 9.47759226e-02f, -1.79954860e-02f, 1.92537904e-01f,
  1.58840537e-01f, -1.37269199e-01f, -1.34953678e-01f, -1.01076096e-01f, 9.89308581e-02f, 2.09217608e-01f, 2.36206070e-01f, 1.16480943e-02f, -1.08735196e-01f, 3.78489979e-02f,
  1.05793834e-01f, 2.79805809e-02f, 4.25695553e-02f, -9.84285120e-03f, 1.15350343e-01f, -1.00081176e-01f, 1.54030681e-01f, 9.30911303e-02f, 1.44627988e-01f, 1.14329666e-01f,
  4.25244719e-02f, 1.32358849e-01f, -1.21186495e-01f, 5.28711565e-02f, 7.60039538e-02f, 2.55782064e-02f, 8.01022351e-02f, -1.48139251e-02f, 7.97647908e-02f, 4.75747734e-02f,
  6.37739003e-02f, 7.81112388e-02f, 8.92993659e-02f, 1.52693242e-02f, 1.25679880e-01f, 1.17232807e-01f, 1.87383220e-01f, 5.02949618e-02f, 2.88032629e-02f, 1.23508416e-01f,
  9.31344330e-02f, 8.26498643e-02f, 1.53650388e-01f, 7.31235594e-02f, 1.72617286e-01f, 1.06728949e-01f, 1.77691683e-01f, 3.32528241e-02f, 1.49909139e-01f, 1.70676261e-02f,
  -7.80137107e-02f, -5.56064211e-02f, 2.10586917e-02f, 3.38357016e-02f, -4.46397178e-02f, 2.58652307e-02f, -8.07249621e-02f, -2.85584759e-02f, 7.67545914e-03f, -1.59263499e-02f,
  -6.88418280e-04f, 4.93782498e-02f, -7.34411404e-02f, 5.09061478e-03f, 1.91507104e-03f, 4.25250782e-03f, 7.65237734e-02f, 5.89718856e-03f, 5.13509363e-02f, -3.55110988e-02f,
  -3.20541076e-02f, 2.05771606e-02f, -2.30039060e-02f, -5.59280254e-02f, -2.27744430e-02f, -3.55064273e-02f, -3.45203318e-02f, 3.01471353e-02f, -8.17599669e-02f, 6.93681538e-02f,
  -1.98973119e-01f, 1.76842377e-01f, -1.38790816e-01f, -5.47767542e-02f, 1.61902122e-02f, -3.71936820e-02f, -4.38403562e-02f, 2.88632009e-02f, 4.71003987e-02f, -3.95943038e-02f,
  5.98805062e-02f, -1.42662134e-02f, -1.66016426e-02f, 1.10791035e-01f, 6.39790222e-02f, -2.87813712e-02f, 2.30122656e-02f, 7.56465048e-02f, -8.51055328e-03f, 7.82391503e-02f,
  6.91714734e-02f, 5.21617346e-02f, -6.58472180e-02f, -4.88051912e-03f, 2.87905037e-02f, -1.10206716e-01f, 3.83311622e-02f, -3.14647779e-02f, -2.37188488e-02f, -8.55686050e-03f,
  -9.26827954e-04f, 1.73544705e-01f, -2.13578679e-02f, -2.21775830e-01f, -4.66650166e-02f, 4.64606248e-02f, 7.13053718e-02f, 1.94331557e-02f, -3.17017697e-02f, -5.62081151e-02f,
  -2.05940455e-01f, -3.95425647e-01f, -2.16492847e-01f, -2.84776986e-01f, -9.15298015e-02f, 6.16528653e-02f, 8.54615197e-02f, -1.21082753e-01f, -1.86337769e-01f, -2.08267331e-01f,
  -2.05685467e-01f, 1.30079323e-02f, -1.35925356e-02f, -2.04928249e-01f, -1.73630580e-01f, -2.49030411e-01f, -8.60563740e-02f, -4.46659178e-02f, -1.23326093e-01f, -1.71286121e-01f,
  -2.82863081e-01f, 5.32363988e-02f, -1.66359380e-01f, -9.63272750e-02f, -8.60910118e-03f, -1.24744937e-01f, -1.44747302e-01f, -4.73250151e-02f, -1.27366439e-01f, -3.56478617e-02f,
  -1.51082978e-01f, -1.16066508e-01f, -1.44791640e-02f, -6.49272427e-02f, -1.25603005e-01f, -6.87764585e-02f, -3.60869914e-02f, -5.77913709e-02f, -9.96260121e-02f, -1.02981217e-01f,
  -9.97333671e-04f, -1.22297369e-02f, -5.10191172e-02f, -1.73661783e-02f, -1.26316726e-01f, -1.11639239e-01f, -8.06498230e-02f, -1.48007959e-01f, -1.48341388e-01f, -1.93548709e-01f,
  -5.18338457e-02f, 2.79937545e-03f, 1.94942560e-02f, -7.57517293e-03f, 3.81588526e-02f, 3.01918425e-02f, -3.92675810e-02f, -4.69509661e-02f, 3.48558743e-03f, 9.89275277e-02f,
  1.36949439e-02f, 2.90625952e-02f, 5.77509701e-02f, 2.34987363e-02f, -8.93419329e-03f, 9.08146054e-02f, -2.37054303e-02f, -1.38720581e-02f, -7.29130581e-03f, 1.49377808e-01f,
  -7.94840679e-02f, 1.95008125e-02f, 9.73679572e-02f, 3.37914787e-02f, 6.63510337e-02f, -5.03173359e-02f, 3.46353240e-02f, 1.90719087e-02f, 1.37357684e-02f, 8.85671005e-02f,
  -1.60043895e-01f, 2.50228010e-02f, -7.98443258e-02f, -1.04402281e-01f, -7.43537545e-02f, 1.05435001e-02f, -1.82250738e-02f, -8.82122368e-02f, -4.77026291e-02f, -1.11012205e-01f,
  -4.90234867e-02f, -8.81215036e-02f, -7.92873427e-02f, -8.05873945e-02f, -2.29965858e-02f, -1.19293660e-01f, -3.09581831e-02f, -1.62524000e-01f, 1.67665314e-02f, -8.89343917e-02f,
  4.01406065e-02f, -1.13941431e-01f, -1.92171231e-01f, -1.54611200e-01f, -5.90555891e-02f, -2.23122045e-01f, -1.22466117e-01f, -2.05463529e-01f, -1.18592650e-01f, -5.77542335e-02f,
  4.13666487e-01f, -1.50582641e-01f, -1.41321570e-01f, 3.79441418e-02f, -2.64743686e-01f, -7.11080730e-02f, -1.44308880e-01f, 1.49022127e-02f, -1.07810525e-02f, -1.18326329e-01f,
  4.67050867e-03f, -4.76718210e-02f, -4.37762775e-03f, -2.33968329e-02f, 2.19403543e-02f, -1.38380811e-01f, -1.77111432e-01f, -4.75166366e-02f, 8.22344720e-02f, -2.74721365e-02f,
  -2.32089028e-01f, 6.99567795e-03f, 4.64083068e-02f, 5.96843064e-02f, -2.49825433e-01f, -1.63203359e-01f, -1.84296489e-01f, -1.46039471e-01f, -1.16937436e-01f, -3.85761052e-01f,
  -1.52920589e-01f, -2.15087309e-02f, -5.82804158e-02f, -8.59514549e-02f, -1.34875849e-01f, -1.62605699e-02f, -5.79814101e-03f, -8.73760320e-03f, -7.22701196e-03f, -1.33029774e-01f,
  -1.35368228e-01f, -1.06560864e-01f, -1.47356158e-02f, -4.98395674e-02f, -1.04146332e-01f, -1.02061220e-01f, 1.76310912e-02f, -3.63995284e-02f, -9.17077959e-02f, -6.40854612e-02f,
  -2.05234587e-01f, -1.19261801e-01f, -7.27320537e-02f, -1.07116066e-01f, 1.29033672e-02f, -1.73704311e-01f, -5.36182337e-02f, -8.23759735e-02f, -3.76649275e-02f, -1.46617427e-01f,
  -5.60765434e-03f, 3.64215043e-03f, 4.39117588e-02f, -2.01853383e-02f, 5.22001013e-02f, 1.70809161e-02f, -4.94405068e-03f, -2.07011178e-02f, 3.53434570e-02f, 3.60602438e-02f,
  6.69042096e-02f, -6.19371273e-02f, -6.42131418e-02f, -7.03941379e-03f, -2.31362171e-02f, -2.25803833e-02f, -2.36837249e-02f, -2.67937668e-02f, -1.12717319e-03f, 4.05962989e-02f,
  -4.88745794e-03f, -3.30999726e-03f, -1.82609558e-02f, 2.73209997e-02f, -1.14147819e-03f, 7.39460532e-03f, 6.55880049e-02f, 2.33974587e-02f, 9.29262489e-02f, -6.55413931e-03f,
  1.18576244e-01f, -4.40464914e-02f, -7.85827488e-02f, -2.37237271e-02f, -1.59425974e-01f, -8.45461935e-02f, -8.45802128e-02f, -2.08759159e-02f, -1.39332965e-01f, -3.77078317e-02f,
  1.00157699e-02f, -5.22857681e-02f, -3.17007974e-02f, -1.14548303e-01f, -5.84667437e-02f, -7.52324564e-03f, -9.62551162e-02f, -2.01209724e-01f, -9.67787206e-02f, -1.27839506e-01f,
  -8.21515638e-03f, -6.25736937e-02f, -5.23615591e-02f, -1.02726556e-01f, -2.21528374e-02f, -5.19730411e-02f, -1.75112441e-01f, -1.46649316e-01f, -4.57791239e-02f, -6.61411732e-02f,
  2.13062033e-01f, -1.68682739e-01f, -5.77525869e-02f, 3.12192328e-02f, -2.30007261e-01f, -7.36222044e-02f, -1.67328492e-01f, -1.15915779e-02f, -1.83025431e-02f, -1.28791362e-01f,
  -3.23893934e-01f, -3.65833700e-01f, -1.97484374e-01f, -2.17418849e-01f, -1.43479154e-01f, -5.78614511e-02f, 5.04343584e-02f, 2.55092960e-02f, -1.06504329e-01f, -1.19672298e-01f,
  -1.08840968e-02f, 9.79073197e-02f, 1.79646850e-01f, 1.00257479e-01f, -4.11943160e-02f, -1.14699535e-01f, 1.85044538e-02f, 1.08968914e-02f, -1.70938358e-01f, 6.94294972e-03f,
  -2.41887480e-01f, -1.47237610e-02f, -1.20049819e-01f, -1.91383004e-01f, -9.65986699e-02f, -7.62535110e-02f, -8.95083398e-02f, -4.99298684e-02f, -8.77929293e-03f, -1.08590409e-01f,
  -2.01124400e-01f, -1.71212479e-01f, -1.91214412e-01f, -5.95478006e-02f, -1.39651299e-01f, -1.95780158e-01f, 2.20668484e-02f, 3.93454097e-02f, -1.49206579e-01f, -2.33481005e-01f,
  -2.05582947e-01f, -2.32052714e-01f, -1.80598497e-01f, -4.70336229e-02f, -1.63080633e-01f, -8.99656862e-02f, -1.28148660e-01f, -1.60152659e-01f, -1.64443582e-01f, -3.30463075e-03f,
  2.49771867e-02f, 1.32848779e-02f, -2.54716948e-02f, 1.03792131e-01f, -2.20027217e-03f, -3.40759568e-02f, 2.26190276e-02f, -5.55515923e-02f, 6.77133799e-02f, 6.19654022e-02f,
  -6.94326684e-02f, -6.88321516e-02f, -1.25862900e-02f, -2.46290118e-02f, -8.83529261e-02f, 8.92443862e-03f, -6.81110844e-02f, -1.14983961e-03f, 4.43832651e-02f, 6.01979680e-02f,
  -7.05358863e-04f, -7.54456669e-02f, 5.90171702e-02f, 3.83974016e-02f, -7.66596869e-02f, 3.59277315e-02f, 5.49849011e-02f, -9.26471800e-02f, -3.28164212e-02f, 4.72298265e-02f,
  -7.31794462e-02f, -2.23097593e-01f, -7.00459853e-02f, -7.24665076e-02f, -5.39538935e-02f, -1.69286236e-01f, -1.18969411e-01f, -9.44329947e-02f, -1.57426342e-01f, -4.67371009e-02f,
  -1.75436154e-01f, -1.25064701e-01f, -1.74130097e-01f, -1.40538052e-01f, -1.54096588e-01f, -3.23966406e-02f, -1.27989590e-01f, -1.26155525e-01f, -1.25906840e-01f, -7.77092651e-02f,
  -5.47631532e-02f, -1.56950895e-02f, -1.68286741e-01f, -1.50349796e-01f, -6.53846413e-02f, -2.10067987e-01f, -1.97069213e-01f, -2.05466393e-02f, -1.44042894e-01f, -8.91380478e-03f,
  3.31146121e-01f, -1.39474928e-01f, -1.88706458e-01f, 1.18333645e-01f, -7.35167935e-02f, -1.36381313e-01f, -9.39672738e-02f, -1.76810042e-03f, 1.12113789e-01f, 4.98450696e-02f,
  2.10502580e-01f, 1.32176414e-01f, 1.96009606e-01f, 1.79972559e-01f, 1.03694396e-02f, -1.04781277e-01f, -2.64322698e-01f, -6.05965815e-02f, -2.12897193e-02f, 5.12908772e-03f,
  -8.47619027e-02f, -1.58717409e-02f, 1.34715602e-01f, 1.01260111e-01f, -1.25874504e-01f, 2.02358440e-02f, -1.55991837e-01f, -3.31794396e-02f, -1.27055898e-01f, -2.04131886e-01f,
  -6.69609979e-02f, 1.38536870e-01f, -8.95512998e-02f, 6.17075637e-02f, -1.20768268e-02f, 1.65025808e-03f, 3.17376666e-02f, -8.52025859e-03f, 8.73783007e-02f, 4.27252008e-03f,
  -4.90084402e-02f, 2.25367825e-02f, -9.24631953e-02f, 5.15240105e-03f, 9.12162475e-03f, 2.92318258e-02f, -1.11907609e-02f, 2.27991268e-02f, 7.07569644e-02f, -2.41060765e-03f,
  -5.48760556e-02f, -1.09614864e-01f, -1.19242782e-03f, -9.65482667e-02f, 1.60799548e-02f, 7.46347755e-02f, 5.23741059e-02f, 3.85139734e-02f, 2.23801169e-03f, 1.23763755e-02f,
  -5.27146347e-02f, 8.95606130e-02f, -2.53002420e-02f, 1.25719197e-02f, -1.59382150e-02f, 5.90403527e-02f, -8.20035674e-03f, 4.68321927e-02f, 2.78718155e-02f, -8.80969018e-02f,
  7.47736841e-02f, 2.13460736e-02f, 5.20502264e-03f, 3.06641380e-03f, 8.70937482e-03f, 3.80254649e-02f, -3.57659720e-02f, 4.45748307e-02f, 9.10694376e-02f, 8.17411467e-02f,
  5.67119345e-02f, -2.44083186e-03f, 3.14698480e-02f, 2.58363057e-02f, 2.07909718e-02f, 3.19552608e-02f, -5.25947471e-05f, -3.76946613e-04f, -1.15900515e-02f, -2.18915138e-02f,
  -3.24726328e-02f, 6.81022853e-02f, -6.20415732e-02f, 1.64505038e-02f, -2.22695898e-02f, 7.08560944e-02f, -3.88875753e-02f, -4.13662829e-02f, -5.31508811e-02f, 8.83795135e-03f,
  2.52453350e-02f, 4.56202924e-02f, -3.11730951e-02f, -6.42179549e-02f, -7.36185238e-02f, 2.14476101e-02f, -7.04987198e-02f, -5.23582809e-02f, 7.76118264e-02f, -4.29555215e-02f,
  2.14438867e-02f, 2.72085536e-02f, 1.33073041e-02f, 1.93070564e-02f, 2.48071435e-03f, -7.53441080e-02f, -9.91972610e-02f, -8.34836364e-02f, -7.52957016e-02f, -4.67907377e-02f,
  -3.23357999e-01f, -1.03766128e-01f, -1.86956096e-02f, -3.84144709e-02f, 5.66703677e-02f, -2.14407146e-02f, 1.62518937e-02f, -1.06973693e-01f, 2.62330472e-02f, -3.05433068e-02f,
  -1.00794137e-01f, -8.83480012e-02f, -7.29957744e-02f, 2.34342255e-02f, 1.16153220e-02f, 1.61657080e-01f, 1.55013427e-01f, 1.82750896e-02f, 5.49481846e-02f, 1.60088629e-01f,
  1.13615081e-01f, 1.07489035e-01f, 8.26976225e-02f, 1.89066380e-01f, 1.75449759e-01f, 1.17949948e-01f, 2.45959431e-01f, 1.37121528e-01f, 1.52438179e-01f, 3.18863511e-01f,
  2.46871039e-02f, -7.90431499e-02f, 4.83052097e-02f, 8.32471177e-02f, 4.21784483e-02f, 4.59732451e-02f, 7.10317213e-03f, 1.05408825e-01f, 3.94003130e-02f, 8.02246854e-02f,
  5.67686297e-02f, 1.42352343e-01f, 2.07242463e-02f, 2.02395797e-01f, 1.28097206e-01f, 1.52978957e-01f, 1.05623245e-01f, 7.50803798e-02f, 1.28626138e-01f, 5.63762933e-02f,
  2.43848950e-01f, 2.02934742e-01f, 4.44333777e-02f, 1.72490001e-01f, 9.77937803e-02f, 5.86058050e-02f, 1.82705894e-01f, 2.20149159e-01f, 1.40210688e-01f, 1.75897598e-01f,
  -2.49833381e-03f, -9.90446433e-02f, 1.77866071e-02f, -4.68642376e-02f, -7.46379495e-02f, -3.07962466e-02f, 1.74580868e-02f, 4.61999476e-02f, -1.48468781e-02f, -1.39576010e-02f,
  -1.41025207e-03f, 1.23655898e-02f, -7.83385038e-02f, -1.68708041e-02f, -9.05512348e-02f, 6.74211755e-02f, -5.01000322e-03f, -6.18595257e-02f, 2.90639829e-02f, 2.31762864e-02f,
  -7.02587664e-02f, -4.29964028e-02f, -8.66795182e-02f, 5.02321124e-02f, -4.37934976e-03f, 1.93367340e-02f, 2.93365531e-02f, -1.09874815e-01f, -2.35853978e-02f, -4.50064391e-02f,
  -9.99432355e-02f, -4.58497107e-02f, 1.08205706e-01f, 4.04480137e-02f, 1.54501289e-01f, 4.98656109e-02f, 3.35318819e-02f, 8.78598168e-02f, -5.58564290e-02f, 4.28995788e-02f,
  2.79962365e-03f, 2.90516447e-02f, 9.00520906e-02f, 1.04747660e-01f, 2.02510618e-02f, 1.51239097e-01f, 5.73256165e-02f, 9.90760848e-02f, 1.18931197e-01f, 1.00139119e-01f,
  9.07428414e-02f, 1.02642402e-01f, -3.57911848e-02f, 6.40065819e-02f, 1.65996656e-01f, 9.61090066e-03f, 1.08846603e-02f, 7.20651373e-02f, 2.50938796e-02f, 1.46287665e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.73675638e-01f, 3.62793595e-01f, 4.57508005e-02f, -4.59989786e-01f, 8.90038833e-02f, 3.95063668e-01f, 4.99717146e-01f, 1.19935781e-01f, -8.42654854e-02f, 8.29707310e-02f,
  1.50626406e-01f, -1.88192233e-01f, -1.28004491e-01f, 4.39673513e-02f, 1.66221216e-01f, 3.21649194e-01f, 1.10883832e-01f, -1.13464251e-01f, -8.83460045e-02f, 5.02444245e-02f,
  4.34862971e-02f, -9.34780464e-02f, -1.71302646e-01f, -1.03644907e-01f, -1.81003377e-01f, -2.38370180e-01f, -1.21324480e-01f, -1.09708592e-01f, 1.64350480e-01f, -1.93901330e-01f,
  -2.21207932e-01f, -7.36815408e-02f, -1.53583540e-02f, -1.61216691e-01f, -2.86607817e-02f, -1.89607944e-02f, 1.67764388e-02f, -1.27259925e-01f, 6.76625296e-02f, 1.05167344e-01f,
  -8.94247293e-02f, 3.28219160e-02f, -1.61236599e-02f, 1.06320627e-01f, 1.03709921e-02f, 2.83012055e-02f, -4.38574292e-02f, -8.12091455e-02f, 1.00147072e-02f, 1.11200459e-01f,
  1.65866598e-01f, -2.54194271e-02f, -1.22238636e-01f, 6.00178763e-02f, 6.22903183e-02f, -1.89230606e-01f, 5.90159521e-02f, -9.79150180e-03f, -4.20574509e-02f, -2.67694533e-01f,
  -2.16955636e-02f, 4.42766547e-02f, 1.16537265e-01f, -6.90041110e-02f, -3.01521719e-02f, -1.04513228e-01f, -1.20672122e-01f, 6.29278347e-02f, 1.98483653e-02f, 1.38229306e-03f,
  1.92236081e-02f, 6.39415532e-02f, -9.24877450e-03f, 3.11844032e-02f, -6.46607503e-02f, 9.21958219e-03f, 5.34033515e-02f, -9.17305984e-03f, -4.71599847e-02f, 7.04871789e-02f,
  2.15870235e-02f, -1.27555979e-02f, -7.02640042e-02f, -5.27002737e-02f, 4.26290147e-02f, -5.49010597e-02f, -2.40436010e-02f, 8.05417821e-02f, -1.38919652e-01f, 3.97185870e-02f,
  -3.23004514e-01f, 2.27548093e-01f, -1.89703435e-01f, -1.34706557e-01f, -6.49115592e-02f, 1.73773225e-02f, 7.93824643e-02f, 1.37956217e-01f, 1.58885121e-02f, 7.80947134e-03f,
  1.35931522e-01f, -2.04136614e-02f, -9.39190760e-02f, 1.08233124e-01f, 1.65506359e-02f, -8.99863318e-02f, 2.41450574e-02f, -1.46529555e-01f, 1.12637974e-01f, -3.02954414e-03f,
  8.99173692e-02f, -2.35323049e-02f, -2.22882882e-01f, -1.15062900e-01f, 1.58688072e-02f, -3.24108571e-01f, -1.18374959e-01f, -1.02331847e-01f, -1.09336749e-01f, -1.71236888e-01f,
  5.52919656e-02f, 7.57374316e-02f, -6.72313794e-02f, 1.97531447e-01f, 2.61315793e-01f, 1.10789873e-01f, -4.66379412e-02f, -9.33267623e-02f, 1.30387547e-03f, 7.39193186e-02f,
  2.36646667e-01f, 2.47757882e-01f, 6.65807724e-02f, 6.31013736e-02f, -1.45249829e-01f, -8.42141658e-02f, -1.85998306e-02f, -9.78821442e-02f, -7.77556561e-03f, 1.42393366e-01f,
  2.31366977e-01f, 1.27785668e-01f, -1.27291502e-02f, 8.72752815e-02f, 1.20092906e-01f, 1.74784705e-01f, -5.90277128e-02f, 2.08750859e-01f, 1.32848710e-01f, 2.09412992e-01f,
  2.61784531e-02f, -2.83368230e-02f, -1.28086463e-01f, 1.76136330e-01f, 4.01628576e-02f, -1.64766252e-01f, -7.32373223e-02f, -1.72488749e-01f, 4.49701436e-02f, -1.43805429e-01f,
  -1.75413843e-02f, -6.92261308e-02f, 5.61576374e-02f, -2.87001114e-02f, -1.36590824e-02f, -1.40575375e-02f, -1.37512922e-01f, -1.63434893e-01f, -1.47467792e-01f, -2.27863453e-02f,
  2.03327253e-01f, 1.82760537e-01f, -1.48174763e-02f, 4.13272716e-03f, 7.23020136e-02f, 1.20102949e-01f, -6.44771382e-03f, 4.70443480e-02f, -7.23946095e-02f, -7.12531954e-02f,
  6.62845001e-02f, 1.03909843e-01f, 2.50895768e-01f, 3.42543982e-02f, 1.15885541e-01f, 5.31980172e-02f, 5.54271080e-02f, 1.55578837e-01f, 8.84680171e-03f, -7.54614845e-02f,
  -5.40630706e-02f, 9.51532423e-02f, -1.07119925e-01f, -6.19675405e-03f, 2.04701304e-01f, -1.96481757e-02f, 1.84443220e-02f, 2.89336545e-03f, 4.10848670e-02f, 2.49195285e-02f,
  4.32086177e-02f, -1.20589770e-02f, 5.14253043e-02f, -1.36631444e-01f, -5.99397533e-02f, -8.54332149e-02f, 4.73034643e-02f, 4.42992598e-02f, 1.43651545e-01f, 7.11916154e-03f,
  -2.54157454e-01f, -9.26413909e-02f, 1.26188146e-02f, -7.50769004e-02f, -2.40374897e-02f, -6.69297129e-02f, 1.61889866e-02f, -5.77335209e-02f, 1.75991748e-02f, -1.21692219e-03f,
  -3.84636410e-02f, 8.86950083e-03f, -1.35732204e-01f, -5.35451248e-02f, -3.69232334e-02f, -2.12403852e-02f, -2.21428573e-02f, -8.84167776e-02f, -7.47226328e-02f, -1.25458479e-01f,
  -8.19096044e-02f, -1.92362651e-01f, -1.72967955e-01f, -1.00006938e-01f, -2.91339736e-02f, -2.49894299e-02f, -9.72259790e-02f, -1.41352430e-01f, -1.46059006e-01f, -1.71615496e-01f,
  -1.14767231e-01f, -2.21310064e-01f, 1.74388185e-03f, 2.58079946e-01f, 1.33547887e-01f, 1.02800310e-01f, 9.31637585e-02f, 7.90751819e-03f, 2.32475489e-01f, -8.03061668e-03f,
  2.49550696e-02f, 1.38262287e-01f, 7.43283406e-02f, 2.23070364e-02f, 3.35065015e-02f, 1.98977128e-01f, 2.03909650e-01f, 9.37996153e-03f, 1.79498211e-01f, 1.49212182e-01f,
  2.11070299e-01f, 1.59133226e-01f, -5.58312163e-02f, 1.22539006e-01f, 1.02056116e-01f, 1.73278019e-01f, 1.08278595e-01f, -4.90534566e-02f, 8.81006047e-02f, 1.67092949e-01f,
  -7.63906091e-02f, -1.17240503e-01f, 1.00708216e-01f, -1.03570096e-01f, -9.79423374e-02f, -1.00167476e-01f, 7.42116496e-02f, -1.45380959e-01f, -9.38051715e-02f, -4.20319811e-02f,
  -3.38094458e-02f, -3.08836754e-02f, -9.62822586e-02f, -1.41827539e-01f, -4.95449640e-02f, -5.92000000e-02f, -1.52285784e-01f, 9.56483856e-02f, 1.09757833e-01f, -8.52005482e-02f,
  -3.79597135e-02f, -7.73051381e-02f, 1.56113710e-02f, 8.11702609e-02f, 7.12853894e-02f, 8.89420658e-02f, 7.90601305e-04f, -9.16781723e-02f, -4.67437245e-02f, 2.44305898e-02f,
  1.02268010e-01f, 8.92851725e-02f, 8.93182214e-03f, 5.76015897e-02f, 5.99297397e-02f, 2.91494303e-03f, 5.56083471e-02f, 8.77675116e-02f, 2.36619502e-01f, -2.84978524e-02f,
  -3.25457603e-02f, 1.01416096e-01f, 9.33620408e-02f, 1.60193086e-01f, -2.77908184e-02f, 2.66521201e-02f, -3.13488990e-02f, 6.35023415e-02f, -1.16585903e-01f, 4.17078510e-02f,
  1.19535066e-01f, -1.14056999e-02f, -1.48477390e-01f, 2.46190112e-02f, -5.55569753e-02f, 1.87721979e-02f, -1.80604458e-02f, 6.67345896e-02f, -2.61870530e-02f, 2.25355141e-02f,
  2.57731080e-01f, 1.32966653e-01f, 1.36136720e-02f, -4.75472882e-02f, -7.61485919e-02f, -1.56351820e-01f, 9.18049812e-02f, 3.11369561e-02f, -1.28517449e-01f, 2.43368074e-02f,
  -2.77760495e-02f, -7.06526563e-02f, -1.00842444e-02f, -1.18006170e-02f, 8.00588056e-02f, 7.20632970e-02f, -7.33255967e-02f, 2.66513582e-02f, 1.30193666e-01f, 5.66414744e-02f,
  3.02771386e-02f, 1.06884502e-01f, 1.68493778e-01f, 1.21179707e-01f, 3.73961963e-02f, 2.32917234e-01f, 4.71671782e-02f, 1.46831060e-02f, -1.01252683e-02f, 1.68157697e-01f,
  -1.95855737e-01f, -6.35287585e-03f, -4.27290164e-02f, 3.21945176e-02f, -4.70272452e-02f, -1.02519855e-01f, -1.56904608e-01f, 4.63781646e-03f, 2.03873396e-01f, 1.36084065e-01f,
  3.75193693e-02f, -4.29092832e-02f, -3.08066104e-02f, -1.51752844e-01f, -2.50984669e-01f, -1.44133449e-01f, -1.21994913e-01f, -3.34390849e-01f, -4.11541343e-01f, -3.01778466e-01f,
  -2.19920218e-01f, -1.79497316e-01f, -2.31373399e-01f, -1.99987486e-01f, 1.15151525e-01f, -1.24995932e-01f, 6.20794035e-02f, -1.02264389e-01f, -1.15102917e-01f, 6.14731796e-02f,
  -2.54929904e-02f, 8.23786017e-03f, -7.14303479e-02f, -1.31298408e-01f, 9.29806009e-02f, 2.07560528e-02f, -5.19460142e-02f, 1.48865748e-02f, -2.81561799e-02f, -4.38884161e-02f,
  -8.02941993e-02f, -7.22954571e-02f, -3.27258483e-02f, -5.50600663e-02f, -9.25808549e-02f, -1.17760889e-01f, -6.55781701e-02f, -1.09472908e-01f, 1.98607985e-02f, -6.58545792e-02f,
  -1.37982860e-01f, -5.87567985e-02f, -1.48532167e-01f, -2.07939595e-02f, 4.67463695e-02f, -2.94738989e-02f, 1.98479625e-03f, 3.01929731e-02f, -4.35374044e-02f, 1.10955559e-01f,
  8.55762586e-02f, 1.07270151e-01f, -5.30042425e-02f, -9.49368775e-02f, -3.04244198e-02f, 9.66944546e-02f, 6.65795803e-02f, 1.27758896e-02f, -7.35020032e-03f, 1.21745698e-01f,
  9.42932293e-02f, 5.06871119e-02f, -4.98199323e-03f, -4.07157615e-02f, -1.17139183e-01f, -4.89881150e-02f, -4.62245047e-02f, -1.13063045e-01f, -1.13807477e-01f, 7.26099983e-02f,
  -2.25496665e-02f, 6.69267103e-02f, 5.60501516e-02f, -7.44909421e-02f, 1.04986448e-02f, 7.83787817e-02f, 5.68318442e-02f, 3.11812423e-02f, -6.26541534e-03f, -1.85596868e-02f,
  2.31460971e-03f, -3.70922349e-02f, -4.44848426e-02f, -1.67871594e-01f, -1.42917493e-02f, 1.56807452e-01f, 9.60377753e-02f, -5.65368533e-02f, 9.82436240e-02f, -5.54292314e-02f,
  -1.76587552e-01f, 2.87470724e-02f, 3.21158059e-02f, -8.05094242e-02f, -1.10033698e-01f, -1.85943171e-02f, -1.40949249e-01f, -9.20687765e-02f, -4.73969057e-02f, 2.70503610e-02f,
  -4.31669913e-02f, -2.14145601e-01f, -1.52256578e-01f, -5.69329560e-02f, 7.19088223e-03f, -1.56628668e-01f, -7.21813738e-02f, -6.07317314e-02f, -1.46909907e-01f, 1.67363677e-02f,
  4.64983523e-01f, 1.80905521e-01f, 1.67329773e-01f, 1.37559939e-02f, 4.44372706e-02f, -2.16661066e-01f, -1.47179037e-01f, -1.18312828e-01f, -3.80966887e-02f, 1.51031062e-01f,
  1.05086625e-01f, -1.45533174e-01f, -7.55004361e-02f, -2.13856936e-01f, -2.69960016e-01f, -1.55173093e-01f, -1.43687189e-01f, -1.29438192e-01f, -3.59775901e-01f, -2.50716835e-01f,
  -1.91029876e-01f, 4.28720452e-02f, 8.78526792e-02f, -4.77897152e-02f, 2.02655852e-01f, 5.73442727e-02f, 2.64926225e-01f, 2.69894242e-01f, 1.56155512e-01f, 3.54795039e-01f,
  2.46282771e-01f, 4.20861781e-01f, -2.37645864e-01f, -3.92427258e-02f, -2.12383904e-02f, -1.03798322e-02f, -1.14891455e-01f, 6.40213266e-02f, -4.78329360e-02f, 3.39158252e-02f,
  -3.66834179e-02f, 3.62463929e-02f, -2.54794639e-02f, -1.47063822e-01f, 2.23892443e-02f, -2.02504516e-01f, -1.26131743e-01f, -3.31005901e-02f, -8.48485008e-02f, 1.56873614e-02f,
  -2.15629637e-01f, 7.02522025e-02f, 1.63089946e-01f, 4.35370672e-03f, 6.96859322e-03f, -6.74393326e-02f, 1.07446440e-01f, 4.97733727e-02f, 1.43329665e-01f, 3.49785864e-01f,
  -6.41272366e-02f, 2.17878073e-02f, 3.99216078e-02f, -1.09839318e-02f, -6.29837066e-02f, -8.42261985e-02f, -9.12356097e-03f, 2.89851963e-03f, -4.01162058e-02f, -4.87499610e-02f,
  -3.69598158e-02f, 2.20298171e-02f, 2.60516237e-02f, 5.76435402e-02f, -9.25527140e-02f, 8.15164596e-02f, -6.45937249e-02f, -1.11459695e-01f, -2.53173839e-02f, 6.66510463e-02f,
  -6.26409426e-02f, 3.20337042e-02f, 8.53352621e-03f, -2.67468300e-03f, 5.55619523e-02f, -4.62728776e-02f, -2.36782730e-02f, -2.04260577e-03f, 8.00137222e-02f, 5.54381274e-02f,
  -1.35805398e-01f, -2.27878079e-01f, -9.49886739e-02f, -8.14675838e-02f, -4.28411961e-02f, -6.44082390e-03f, 7.94845298e-02f, -1.66522205e-01f, -5.20351678e-02f, -1.02466820e-02f,
  -3.67183611e-02f, -7.54423067e-02f, 6.83439076e-02f, -1.20632529e-01f, -1.39881566e-01f, -1.02367595e-01f, -1.90975592e-01f, -1.01764373e-01f, -1.61018386e-01f, 8.88550952e-02f,
  -1.51080504e-01f, -1.24494955e-01f, -1.89147532e-01f, -6.08652234e-02f, -1.62883997e-02f, -1.97024018e-01f, -8.88412446e-02f, -1.22697845e-01f, -1.64099127e-01f, -1.76169947e-01f,
  8.74144677e-03f, -3.89772326e-01f, 2.28138030e-01f, -2.40664646e-01f, 1.43923879e-01f, 3.60546798e-01f, 3.23551208e-01f, 2.20988374e-02f, -1.28231764e-01f, -1.26524448e-01f,
  -9.90530998e-02f, -2.78105110e-01f, -3.41092736e-01f, -2.64190584e-01f, -7.50780702e-02f, 1.05983406e-01f, 6.72684759e-02f, 2.00396612e-01f, 3.44632894e-01f, 2.67528594e-01f,
  -3.34334448e-02f, -3.06044035e-02f, 2.78297178e-02f, 1.39364731e-02f, -3.23826045e-01f, -2.06229642e-01f, -8.00877362e-02f, -1.03946105e-01f, 1.01886958e-01f, -3.19440782e-01f,
  -9.23960470e-03f, 3.31600420e-02f, 5.89438416e-02f, -1.15689635e-01f, -9.96657014e-02f, -1.37162402e-01f, 4.74055819e-02f, -9.35403630e-02f, -9.29468349e-02f, -4.75195870e-02f,
  -6.08065575e-02f, -9.80333462e-02f, -9.95061472e-02f, -1.33252487e-01f, 1.32295201e-02f, 7.30609372e-02f, -1.38875514e-01f, -1.65877312e-01f, -4.16016132e-02f, 7.82556552e-03f,
  -1.20687999e-01f, 7.07983002e-02f, 9.78920683e-02f, 8.37570615e-03f, 5.89358732e-02f, 3.87828797e-02f, -3.50914826e-03f, 6.42763153e-02f, 1.14043675e-01f, -2.82641500e-03f,
  8.19708705e-02f, 1.05917910e-02f, 3.59607078e-02f, -5.93107268e-02f, -1.23952702e-02f, 6.79562092e-02f, -4.93691536e-03f, -6.30364148e-03f, -4.60858569e-02f, -4.19956744e-02f,
  -7.55764171e-03f, -4.88789864e-02f, 5.06411009e-02f, -7.48574585e-02f, -1.29991919e-01f, 2.03323364e-02f, 3.15968022e-02f, -1.29130602e-01f, 2.76370738e-02f, -1.76413823e-02f,
  4.23948430e-02f, -4.22754660e-02f, -1.81163177e-02f, 7.89818838e-02f, 6.57469481e-02f, 3.66912410e-03f, 4.37658504e-02f, -7.73560703e-02f, -5.57056852e-02f, -4.90934104e-02f,
  -3.72838259e-01f, 2.39481792e-01f, -5.99228516e-02f, -1.43691957e-01f, -1.92185666e-03f, -4.79217991e-02f, -6.67367876e-02f, -3.50829326e-02f, -6.36543483e-02f, 4.66342457e-02f,
  -1.37710460e-02f, 2.12158896e-02f, -6.54060394e-02f, -1.86627418e-01f, 1.17185645e-01f, 7.98770338e-02f, -5.09247072e-02f, -8.77551064e-02f, -9.51228812e-02f, 1.02643007e-02f,
  -7.00008795e-02f, 9.06023383e-02f, 4.99624945e-02f, 2.52442583e-02f, -5.66890538e-02f, 6.52343035e-02f, 1.29434481e-01f, 1.03210919e-01f, 2.50266939e-01f, 1.40282989e-01f,
  -1.59508526e-01f, -1.62459742e-02f, 6.32309318e-02f, 9.79634449e-02f, -2.55188299e-03f, -4.40844059e-01f, -5.13843775e-01f, -3.85894835e-01f, 2.16706954e-02f, 5.08392751e-02f,
  6.92256540e-02f, 1.24348633e-01f, 1.49535939e-01f, -2.10439898e-02f, -2.11203337e-01f, -7.14248866e-02f, -2.90843956e-02f, -7.05817482e-03f, -2.10097417e-01f, -3.59808393e-02f,
  1.58849508e-01f, 6.37699366e-02f, 7.01242611e-02f, 6.14525825e-02f, 4.26664859e-01f, 2.09320202e-01f, 9.14055631e-02f, 9.10187662e-02f, 1.82344303e-01f, 3.59416515e-01f,
  4.47993100e-01f, -3.12234228e-03f, -3.80201042e-02f, 4.34562154e-02f, 1.99949622e-01f, -5.99038452e-02f, -6.85983151e-02f, 1.41335905e-01f, -9.53058600e-02f, 1.07757933e-01f,
  1.42770201e-01f, 1.18354924e-01f, -2.08463036e-02f, 3.33437175e-02f, 4.68893461e-02f, 5.92283672e-03f, -4.35592085e-02f, -1.19872250e-01f, -1.19267412e-01f, 1.33891597e-01f,
  1.21209189e-01f, 3.49539705e-02f, -1.49651021e-01f, -2.15573698e-01f, -2.55578727e-01f, -1.62622288e-01f, -7.66824931e-02f, -4.01800033e-03f, -1.26987323e-01f, 3.49837057e-02f,
  -1.49428576e-01f, -1.96817685e-02f, 7.54041821e-02f, -2.44755056e-02f, -1.05450191e-01f, -6.70804679e-02f, -4.12067436e-02f, -5.92394024e-02f, -1.77469075e-01f, -1.37134194e-01f,
  8.05116892e-02f, 5.52313663e-02f, -7.87426382e-02f, 1.10139430e-01f, 9.73621160e-02f, 1.02256067e-01f, -7.15121103e-04f, 1.12025447e-01f, 5.56879491e-02f, 3.09144817e-02f,
  -6.32842705e-02f, -1.60196256e-02f, 1.76303864e-01f, 6.54160008e-02f, 3.01862303e-02f, 3.24820988e-02f, 2.48895064e-02f, 3.15396823e-02f, -3.76066193e-02f, 4.71665487e-02f,
  2.53891796e-01f, -2.68473685e-01f, 2.09343076e-01f, -3.43508250e-03f, 9.59721953e-02f, 8.93120170e-02f, 1.92354426e-01f, 1.23417251e-01f, 2.28916690e-01f, 1.11412607e-01f,
  3.61418501e-02f, 3.76507342e-02f, 9.57596451e-02f, -6.07576184e-02f, -8.60268623e-02f, 1.01943538e-02f, 1.10620618e-01f, 1.23601137e-02f, 6.35885894e-02f, 1.88096464e-01f,
  7.01761171e-02f, -1.10384122e-01f, -1.81612760e-01f, -9.85630676e-02f, -7.11021423e-02f, 1.37692858e-02f, 8.63574743e-02f, 6.60145283e-02f, -6.89851567e-02f, -5.83751872e-02f,
  3.38697076e-01f, -4.41960134e-02f, -3.78080577e-01f, 1.97003335e-01f, 1.73348244e-02f, -1.86882541e-01f, -1.90388918e-01f, 1.32569270e-02f, 1.75039530e-01f, -9.01322961e-02f,
  -5.04385941e-02f, 6.62446469e-02f, -9.45038497e-02f, -1.79630697e-01f, -3.13911885e-01f, -3.82276386e-01f, -3.26877356e-01f, -2.85209119e-01f, -2.36407280e-01f, -4.46472615e-02f,
  -6.99121132e-02f, 7.39029422e-02f, -2.19909362e-02f, -1.06069654e-01f, 1.33779228e-01f, 7.49831367e-03f, -9.68798697e-02f, -1.25442803e-01f, -3.08235407e-01f, -1.12867266e-01f,
  -2.96982139e-01f, 6.40414432e-02f, -1.40250877e-01f, -4.56227176e-02f, -1.27977535e-01f, 1.45056071e-02f, -1.08198486e-01f, -6.08731695e-02f, 2.04848852e-02f, -1.18571080e-01f,
  1.73985325e-02f, 2.01932099e-02f, 5.11286408e-02f, -5.59827387e-02f, -7.19992502e-04f, -1.00092078e-02f, 4.03336575e-03f, -1.20476887e-01f, -9.17895809e-02f, 4.94925976e-02f,
  2.94792000e-02f, 3.27178724e-02f, -7.11895078e-02f, -5.45737818e-02f, 7.97624607e-03f, -2.74038538e-02f, -1.99730173e-02f, 8.65525082e-02f, -1.18563741e-01f, 1.79345941e-03f,
  -3.43732089e-02f, -1.13457895e-03f, -4.05010805e-02f, 5.84580079e-02f, 7.49994591e-02f, 1.79297477e-02f, 4.87473235e-02f, -9.62150916e-02f, -3.12629864e-02f, 2.56222356e-02f,
  3.22756879e-02f, -1.14577733e-01f, 3.58849838e-02f, -2.29088143e-02f, -8.68219510e-02f, 8.23385999e-05f, -8.55049565e-02f, -1.39876574e-01f, -8.53935778e-02f, -2.90109236e-02f,
  2.03188439e-03f, 3.36260945e-02f, 1.72458608e-02f, -5.69516160e-02f, -1.93102017e-01f, -1.05929069e-01f, -4.45905440e-02f, -4.20619100e-02f, 1.57849938e-02f, -1.60301584e-04f,
  1.12233870e-01f, -2.09085643e-01f, -8.46242979e-02f, -2.51966298e-01f, -2.49886692e-01f, -3.69766392e-02f, 3.51802595e-02f, -8.01974237e-02f, 2.03370508e-02f, -3.26211960e-03f,
  -1.02573670e-01f, 7.08136633e-02f, 8.47790614e-02f, -7.99771622e-02f, 7.78208300e-03f, 6.91464022e-02f, -1.68733969e-01f, -1.19189471e-01f, -6.49871156e-02f, 1.04152240e-01f,
  -2.79045999e-02f, -1.50367483e-01f, -2.05152538e-02f, -1.24280952e-01f, 4.67875116e-02f, -8.92714411e-02f, -1.06057972e-01f, -1.04573809e-01f, -2.37234697e-01f, -3.15779001e-02f,
  7.05397949e-02f, -3.51271152e-01f, -1.64629132e-01f, -3.01935256e-01f, -1.76851273e-01f, -1.55986384e-01f, -3.47661227e-01f, -1.42111853e-01f, -1.39014781e-01f, -3.10687393e-01f,
  -3.10524926e-02f, 2.96005040e-01f, 1.09029256e-01f, 2.62284398e-01f, 2.75115579e-01f, -4.18388575e-01f, -2.88222969e-01f, 1.20952748e-01f, 3.24906498e-01f, 6.69874400e-02f,
  -6.12437017e-02f, -8.54234397e-02f, 1.97047666e-01f, 9.37981158e-02f, -4.64675397e-01f, -7.76855648e-02f, -2.68185735e-01f, -1.82747096e-01f, -1.57823056e-01f, -3.62729162e-01f,
  -2.48809904e-01f, -1.47662535e-01f, 8.67650211e-02f, 2.19858974e-01f, -1.41735792e-01f, -1.75873563e-02f, 1.23697864e-02f, -7.26139545e-02f, -1.80283226e-02f, -1.07226647e-01f,
  2.19570920e-02f, 8.29404220e-02f, 1.14790462e-01f, -9.62324720e-03f, -1.03614464e-01f, -3.63578796e-02f, -1.19335353e-01f, 1.11213818e-01f, -7.85233378e-02f, -1.38630405e-01f,
  -1.34100765e-02f, -1.23769874e-02f, 1.00687385e-01f, -7.56610632e-02f, -6.47333041e-02f, 7.10351542e-02f, -9.80609506e-02f, -7.59982914e-02f, 2.10480392e-01f, -4.02240753e-01f,
  -1.10928817e-02f, -2.41034199e-02f, -3.26436386e-02f, -2.42410926e-03f, -5.45531623e-02f, 1.89812388e-02f, 2.50764657e-02f, -3.43052624e-03f, 4.50151153e-02f, 3.31555493e-02f,
  1.15298122e-01f, -1.45720392e-01f, -7.75442924e-04f, -1.25144701e-02f, -5.11928797e-02f, 1.40165230e-02f, -1.76045224e-02f, -1.08548284e-01f, 2.31942330e-02f, 1.11845257e-02f,
  1.14039861e-01f, -6.59376243e-03f, -4.32779863e-02f, -4.92836088e-02f, -6.55791834e-02f, 1.07386392e-02f, -9.88237858e-02f, 4.69511747e-02f, 7.65172485e-03f, -1.05571970e-02f,
  5.94315166e-03f, 1.63725123e-01f, -2.09863469e-01f, 4.96523567e-02f, -8.88762623e-03f, 2.35300069e-03f, -1.24158643e-01f, -6.07881695e-02f, -7.65179610e-03f, -1.28513977e-01f,
  -4.04005237e-02f, -2.89666699e-03f, 4.93603647e-02f, -6.58246577e-02f, 4.90024947e-02f, -4.41076048e-03f, -8.84212554e-03f, 6.63914680e-02f, 9.12298486e-02f, -2.21139565e-02f,
  -1.29113302e-01f, 1.13870427e-02f, 8.02401826e-02f, 1.39080165e-02f, -3.03429421e-02f, 1.45107165e-01f, -2.85714734e-02f, -5.60280494e-03f, 2.82235295e-01f, -3.20619613e-01f,
  -2.95777589e-01f, -9.11902785e-02f, -1.40156507e-01f, -1.98166475e-01f, 4.38407697e-02f, 6.86721802e-02f, -5.61230034e-02f, -4.78267893e-02f, -4.25589867e-02f, -1.29539192e-01f,
  -3.70109119e-02f, -3.45632620e-02f, -1.12739511e-01f, -1.16020799e-01f, -2.76820838e-01f, -2.68737078e-01f, -1.96786657e-01f, -2.09668115e-01f, -8.94842371e-02f, 8.30787644e-02f,
  8.84742290e-02f, -7.23015666e-02f, -1.27631173e-01f, 2.32671853e-02f, -9.18071903e-03f, -7.14315623e-02f, -2.04830337e-02f, -6.92739934e-02f, -4.30466756e-02f, -1.22450531e-01f,
  -1.36376515e-01f, 1.15255630e-02f, 1.26241356e-01f, -1.22978836e-02f, 2.62062903e-02f, 1.23120666e-01f, -4.54734005e-02f, -6.15919270e-02f, 5.10139950e-02f, -5.29985428e-02f,
  -5.66229969e-02f, 6.57382682e-02f, 6.29440546e-02f, 2.62541100e-02f, -6.75794529e-03f, 4.11425438e-03f, -8.37872699e-02f, -3.06132939e-02f, 2.27097422e-02f, 1.37829632e-01f,
  1.03944330e-04f, -3.15274708e-02f, -9.40313339e-02f, 6.28704131e-02f, 3.01117674e-02f, -5.76654822e-02f, 6.17043227e-02f, 8.54653046e-02f, 1.19433962e-02f, -1.15545861e-01f,
  2.16949359e-02f, 2.98664179e-02f, -1.02998987e-02f, -1.47704110e-02f, -4.75897193e-02f, 5.00374958e-02f, -7.19472542e-02f, -7.86763057e-02f, 1.28544241e-01f, -1.02463961e-01f,
  4.87590581e-02f, 5.83659373e-02f, 4.87188287e-02f, -2.42982656e-02f, 2.02384032e-02f, -8.64936784e-02f, 5.42546436e-03f, -5.08701466e-02f, 3.01574022e-02f, 6.49631862e-03f,
  -4.01275232e-03f, 1.23623284e-02f, 2.51237266e-02f, -3.89741696e-02f, 5.85093610e-02f, -1.64250597e-01f, 2.72913184e-02f, 3.48945744e-02f, 1.28521370e-02f, 7.52001361e-05f,
  -2.01664329e-01f, 1.10652275e-01f, -1.27660871e-01f, -1.67446449e-01f, -1.27920240e-01f, 4.39714901e-02f, -9.90761891e-02f, -3.11570782e-02f, 8.96022469e-03f, 3.02195475e-02f,
  6.14442974e-02f, -4.74060886e-02f, -7.67966732e-02f, 2.27053929e-02f, 5.00530936e-02f, -1.06897820e-02f, -1.20169245e-01f, -8.80145356e-02f, 8.85391384e-02f, 4.52801511e-02f,
  -2.77117863e-02f, -1.27503902e-01f, -1.90007463e-01f, -1.99577987e-01f, 2.74415240e-02f, -1.11733228e-01f, -4.97257188e-02f, 1.40722226e-02f, -1.39647588e-01f, -2.49614984e-01f,
  3.49076718e-01f, 1.81059599e-01f, 2.81436861e-01f, 2.35316381e-01f, 1.09878816e-01f, 1.86963961e-01f, 3.02969724e-01f, 2.33427748e-01f, 9.69212875e-02f, 6.65682182e-02f,
  1.94032602e-02f, -4.86957058e-02f, 5.34591936e-02f, -9.00337752e-03f, 6.87740147e-02f, 1.19552456e-01f, 1.39540136e-01f, 1.48957700e-01f, 1.28365502e-01f, 9.63517502e-02f,
  -2.02642325e-02f, 1.19473904e-01f, 8.97685140e-02f, 1.23278916e-01f, 5.85342906e-02f, -8.46767289e-05f, 1.05106682e-01f, 1.95640892e-01f, 1.47672728e-01f, 3.07305492e-02f,
  1.10436440e-01f, 3.35526019e-01f, -8.92431382e-03f, -1.02557719e-01f, 2.66462117e-02f, -2.00867116e-01f, 1.73468853e-03f, -1.36587560e-01f, -1.00526832e-01f, -6.42276704e-02f,
  -3.17416824e-02f, -1.03680864e-01f, -2.61142161e-02f, -4.23389636e-02f, -1.58035301e-03f, -1.28793091e-01f, -1.04823969e-02f, -6.28901226e-03f, 6.89431950e-02f, 8.53358507e-02f,
  -1.50161767e-02f, 1.82126146e-02f, 1.45170569e-01f, -3.87710258e-02f, -2.95799840e-02f, -1.84394032e-01f, -1.92457158e-02f, 5.92753701e-02f, 3.28177065e-02f, -1.10948235e-01f,
  -6.04598410e-02f, -2.26824339e-02f, -2.45633652e-03f, -6.03120588e-02f, 3.26713361e-02f, -1.23157181e-01f, -1.32755348e-02f, 2.23874785e-02f, -2.02973466e-02f, 2.29516570e-02f,
  -7.31745735e-02f, 1.01157315e-01f, 1.07742414e-01f, -1.14341371e-01f, -9.24199820e-02f, 1.02630071e-01f, 5.92660643e-02f, -1.24853939e-01f, -4.53159539e-03f, 6.76307604e-02f,
  2.33651549e-02f, -5.83811589e-02f, -1.51610389e-01f, 2.28171702e-02f, -6.70707598e-02f, -1.04557231e-01f, -1.10830583e-01f, -3.43155786e-02f, -1.65276766e-01f, -1.75972402e-01f,
  -8.05409327e-02f, 2.53249884e-01f, 3.06266602e-02f, 9.39662941e-03f, -5.40171051e-03f, -1.14463918e-01f, 1.27264142e-01f, 1.13943405e-01f, 5.82534261e-02f, -8.82165283e-02f,
  8.26929659e-02f, -4.31058492e-04f, 8.67173746e-02f, -5.15620112e-02f, -2.63187923e-02f, -1.41178653e-01f, -1.14817053e-01f, 6.59954771e-02f, -6.78437725e-02f, -6.42764196e-02f,
  -7.08394721e-02f, 2.01340113e-02f, 3.28413956e-02f, 6.02549361e-03f, -1.16949789e-01f, -7.86395222e-02f, -1.81478620e-01f, -4.99635451e-02f, -1.10034376e-01f, -1.02198750e-01f,
  4.03071493e-01f, -5.22550523e-01f, 1.68111980e-01f, 8.43157023e-02f, 2.11401016e-01f, 2.16435432e-01f, 8.67412984e-02f, 1.45118371e-01f, 2.29586214e-02f, -5.74006401e-02f,
  -1.93006530e-01f, -9.49044675e-02f, -1.14376955e-01f, 3.29270773e-02f, 8.45860019e-02f, -7.34308213e-02f, -4.27213423e-02f, 2.02395335e-01f, 2.06699520e-01f, 1.67784423e-01f,
  -6.16379976e-02f, -2.93428395e-02f, -5.06666340e-02f, -3.24822627e-02f, -1.50811076e-01f, -5.38772680e-02f, -9.84041691e-02f, -1.82191849e-01f, -1.61435246e-01f, -2.64189065e-01f,
  1.75980538e-01f, -1.80950791e-01f, 1.07838260e-02f, -4.33823466e-02f, -1.61894798e-01f, -1.15652261e-02f, 1.08186036e-01f, -2.68280618e-02f, 1.09542804e-02f, -7.73969069e-02f,
  -5.59291691e-02f, 1.34360474e-02f, -2.65592877e-02f, -9.55788642e-02f, 3.13207507e-03f, -6.16392493e-02f, -1.52829796e-01f, -2.53984090e-02f, -1.01866670e-01f, -1.09852403e-01f,
  -1.54586136e-01f, -1.23635732e-01f, -7.34473020e-02f, -1.41594606e-03f, -1.42754942e-01f, 4.18366678e-03f, -9.23546627e-02f, -3.75795029e-02f, -7.22849146e-02f, 2.24298070e-04f,
  3.77193354e-02f, -3.06127686e-02f, -1.14085943e-01f, 9.27221589e-03f, -6.97923228e-02f, 1.81957230e-03f, 1.68930404e-02f, -6.55922219e-02f, -2.07956973e-02f, -2.78604869e-02f,
  -9.95125771e-02f, -3.45649058e-03f, -5.70823699e-02f, -1.03801414e-01f, -7.93161020e-02f, 1.52124120e-02f, -5.43770902e-02f, -5.68610206e-02f, 1.98912621e-03f, -4.40101400e-02f,
  -4.61399294e-02f, 2.93090511e-02f, -6.47378620e-04f, -4.12723646e-02f, -1.55270202e-02f, 4.02111001e-02f, -2.40755547e-02f, -1.21394403e-01f, 9.72213298e-02f, -7.71871060e-02f,
  3.03934664e-02f, 5.04737832e-02f, 1.20656073e-01f, -6.59339577e-02f, 1.79917254e-02f, -1.42273251e-02f, -3.06458846e-02f, -4.66683647e-03f, 9.35881659e-02f, 1.23588115e-01f,
  2.22130660e-02f, 1.35164201e-01f, -4.94013354e-02f, -9.44165587e-02f, 1.57690659e-01f, 3.45648564e-02f, 2.73827952e-03f, 5.41839115e-02f, -4.17815670e-02f, -8.01110938e-02f,
  -5.37086725e-02f, 9.10976529e-02f, 1.51394829e-01f, 1.93658676e-02f, 4.65590581e-02f, 2.19228104e-01f, 4.97203730e-02f, 2.87987869e-02f, 9.64273289e-02f, 1.32311538e-01f,
  5.38403451e-01f, 4.65944886e-01f, 2.18499884e-01f, 1.25823423e-01f, -1.99001785e-02f, 2.37297043e-02f, 3.11718851e-01f, 2.39953533e-01f, -4.83459234e-03f, 1.64848447e-01f,
  -4.19349223e-02f, -1.72555059e-01f, -1.94550261e-01f, -2.12773345e-02f, -3.65418121e-02f, 1.18009925e-01f, -5.88153452e-02f, 1.06244057e-01f, 5.77489957e-02f, 1.17909066e-01f,
  -7.97374994e-02f, 3.90739515e-02f, 1.37054101e-01f, 9.34446529e-02f, 3.02689765e-02f, -9.58418921e-02f, -2.53591817e-02f, 1.51498646e-01f, 4.30210307e-02f, 1.80988312e-01f,
  -6.86032623e-02f, 6.32156804e-02f, -8.76475424e-02f, -1.10569209e-01f, -1.05440170e-01f, 6.03230745e-02f, -2.78727934e-02f, -6.54565990e-02f, -5.75181730e-02f, 2.17487942e-02f,
  -4.41531511e-03f, -7.41329491e-02f, -3.47452536e-02f, -3.69877256e-02f, 4.73517105e-02f, -3.43757719e-02f, -6.62473589e-02f, -4.22608405e-02f, -1.12654259e-02f, -5.25784194e-02f,
  -3.66005115e-02f, -3.02019734e-02f, -4.26522382e-02f, -8.78313482e-02f, -4.68108840e-02f, -9.22556445e-02f, 3.43570858e-02f, -3.79202589e-02f, -4.75013629e-03f, 1.79826412e-02f,
  -1.16637364e-01f, 9.76814106e-02f, -1.75747991e-01f, -1.87568501e-01f, -1.80390492e-01f, -1.07394286e-01f, 4.15224060e-02f, 5.63142598e-02f, -5.73644638e-02f, 5.93673438e-02f,
  -5.66238202e-02f, -1.97675928e-01f, -1.67228222e-01f, -1.57846525e-01f, -2.03744411e-01f, 1.16996631e-01f, 6.17073961e-02f, -2.81906128e-02f, -1.80187151e-01f, -1.50472730e-01f,
  -1.00804970e-01f, 1.64755970e-01f, 1.29226625e-01f, -1.21024884e-02f, 1.67833269e-02f, 7.02665700e-03f, -1.03775531e-01f, -1.35796115e-01f, 3.65886895e-04f, 1.53127775e-01f,
  -3.76131535e-01f, -5.37016273e-01f, -7.76832849e-02f, 7.58864880e-02f, 8.87346119e-02f, 8.06773901e-02f, -2.25844935e-01f, 3.50327604e-02f, 5.91272861e-02f, -2.57315673e-02f,
  5.31712212e-02f, 1.05921544e-01f, 1.00943677e-01f, 5.83957694e-02f, -7.26131126e-02f, 4.24833779e-05f, -3.40504721e-02f, 1.95851866e-02f, 7.60235041e-02f, 1.41087234e-01f,
  1.61879539e-01f, 6.10169247e-02f, -4.18433659e-02f, -5.88953309e-02f, -1.43039763e-01f, -1.30763501e-01f, -1.26362424e-02f, -2.68281391e-03f, 4.92931232e-02f, -3.96724418e-03f,
  -2.37255394e-02f, -3.49401444e-01f, 6.99824467e-03f, -3.15970334e-04f, 1.22224979e-01f, 3.48432720e-01f, 1.61901966e-01f, 1.35626882e-01f, 1.51396737e-01f, -9.19850450e-03f,
  -1.99292228e-01f, -1.13052562e-01f, -2.05814436e-01f, -1.34120136e-01f, 2.22118292e-02f, 1.28684580e-01f, 1.71163067e-01f, 1.67960078e-01f, 3.29178065e-01f, 2.42269412e-01f,
  1.32458108e-02f, -2.75756530e-02f, -1.43236786e-01f, -5.13112731e-02f, -2.72852778e-01f, 1.42574841e-02f, -1.62243694e-01f, -1.42785087e-01f, -1.61186859e-01f, -1.61519006e-01f,
  -2.26982921e-01f, -1.94149390e-01f, 1.54585272e-01f, -1.71344221e-01f, -1.83663279e-01f, 2.25866791e-02f, 2.15043798e-02f, -1.46388113e-01f, -8.00757483e-02f, -4.78820913e-02f,
  -1.01444520e-01f, -4.35178690e-02f, -4.89154495e-02f, -5.47742955e-02f, -5.21429293e-02f, -1.62914898e-02f, -1.20569617e-01f, -9.04799849e-02f, -2.07934394e-01f, -1.69591382e-01f,
  -2.04253674e-01f, 4.71500717e-02f, 5.19179255e-02f, 1.18876003e-01f, 9.06108990e-02f, 4.81955037e-02f, 3.54114920e-02f, 1.26422681e-02f, 1.19722992e-01f, -2.37062331e-02f,
  2.01122183e-03f, 4.53705899e-03f, 4.05946597e-02f, -7.75420070e-02f, 8.03199932e-02f, 2.48467717e-02f, 6.14763461e-02f, 5.43120056e-02f, 1.10350043e-01f, 5.19826859e-02f,
  -5.52034453e-02f, 4.23193201e-02f, -1.02582894e-01f, 1.73075609e-02f, -1.01663969e-01f, -1.63781092e-01f, 8.75534043e-02f, -5.57465851e-02f, -6.13310970e-02f, -1.29448667e-01f,
  -1.67900138e-02f, 1.63519196e-02f, -7.30553120e-02f, -1.38833210e-01f, -1.51769206e-01f, 1.70398951e-02f, -5.54719847e-03f, -1.53809234e-01f, -1.52911907e-02f, 3.73658258e-03f,
  -1.75876945e-01f, 7.17049465e-02f, 1.70150157e-02f, -9.87898707e-02f, 3.56066115e-02f, -6.00980036e-02f, -2.82055102e-02f, -7.98071548e-02f, -2.45593190e-02f, 1.26425521e-02f,
  1.09671243e-01f, -4.86846827e-02f, -1.14862852e-01f, 5.57167158e-02f, 2.27742672e-01f, 1.54400557e-01f, -5.31131811e-02f, -5.94087467e-02f, 2.08471017e-03f, -1.36204083e-02f,
  -9.64450985e-02f, 1.94677666e-01f, 5.18676564e-02f, 2.07194030e-01f, 1.19279541e-01f, 2.04552576e-01f, 1.88031495e-01f, 8.49542022e-02f, 1.51536763e-01f, 3.33020955e-01f,
  -2.74914235e-01f, -1.94423914e-01f, -4.68654372e-03f, -2.13229671e-01f, 1.13026924e-01f, -4.52035777e-02f, -1.72897369e-01f, -2.56976753e-01f, -6.36647716e-02f, -1.04868934e-02f,
  2.29251638e-01f, 1.13893040e-01f, -2.83215176e-02f, -1.74835369e-01f, -3.82882029e-01f, -3.08806896e-01f, -2.68107682e-01f, -2.20613167e-01f, -1.49533331e-01f, -1.86677556e-02f,
  8.01994503e-02f, -2.45558061e-02f, -1.53233200e-01f, -1.18531257e-01f, 3.37090492e-02f, -3.82894985e-02f, 4.87150885e-02f, 1.29225636e-02f, 7.97650665e-02f, -2.29097623e-02f,
  -6.42908588e-02f, -5.90614714e-02f, 2.41951123e-02f, -1.28155854e-02f, 1.61858112e-01f, -7.15960413e-02f, -9.54370052e-02f, 3.81191932e-02f, 1.19519114e-01f, -1.04063205e-01f,
  1.60326883e-01f, -1.45711401e-03f, 2.68499311e-02f, -1.67996529e-02f, -6.69138730e-02f, -6.33201674e-02f, -1.36435241e-01f, -1.65072724e-01f, -1.42355829e-01f, 2.80584134e-02f,
  4.87915426e-02f, 7.09313825e-02f, -1.60153285e-01f, -7.98299536e-02f, -1.09870695e-01f, 2.02283002e-02f, 6.92571048e-03f, 1.01137057e-01f, -8.55433196e-02f, -1.15998067e-01f,
  1.11020625e-01f, 2.90384125e-02f, -5.30595817e-02f, -8.78717005e-02f, 6.47957772e-02f, 1.04051763e-02f, -4.16378304e-02f, -3.72743532e-02f, 6.02561496e-02f, -3.92688811e-02f,
  -8.93958146e-04f, 1.04311644e-03f, -6.96012692e-04f, 2.78757419e-02f, 2.16182731e-02f, -4.82640266e-02f, -2.32004691e-02f, -5.28772250e-02f, -5.09297736e-02f, 1.25415232e-02f,
  -2.33726390e-02f, -2.28728075e-02f, -1.26208533e-02f, -5.26185371e-02f, 3.17045674e-02f, -6.77957460e-02f, 1.00270912e-01f, 2.43843044e-03f, -4.96089160e-02f, 1.52139261e-01f,
  -2.08098456e-01f, 1.98157653e-01f, -1.10349163e-01f, -1.07444666e-01f, -9.69204754e-02f, 7.25906203e-03f, 5.16144224e-02f, -7.08745420e-03f, 3.06701176e-02f, -4.56373245e-02f,
  -3.07905059e-02f, -7.20312297e-02f, -6.67454898e-02f, -1.55997183e-03f, -4.58357967e-02f, 8.28408543e-03f, -2.57522762e-01f, -3.66367474e-02f, -8.86402428e-02f, 6.78797290e-02f,
  -2.14898378e-01f, -2.90562212e-01f, -3.31830084e-01f, -2.21688464e-01f, -1.20527819e-01f, -1.62217006e-01f, -8.19498673e-02f, 1.00935600e-03f, -1.62682772e-01f, -3.34284514e-01f,
  5.51857591e-01f, -2.67568022e-01f, -4.08886187e-02f, 1.57309145e-01f, 7.12234201e-03f, -1.35533959e-01f, -1.54620662e-01f, -7.91565478e-02f, 1.73871696e-01f, 5.24273291e-02f,
  1.89880148e-01f, 3.18244725e-01f, 2.16722876e-01f, 1.71554476e-01f, 1.53954327e-02f, 3.03920247e-02f, 4.15185243e-02f, 1.52895838e-01f, 2.37796232e-01f, 1.33584782e-01f,
  1.37276411e-01f, 2.08795562e-01f, 2.51269728e-01f, 1.61650762e-01f, 1.57977834e-01f, 1.03952602e-01f, 1.24091044e-01f, 1.01333939e-01f, 7.45733529e-02f, 1.17301188e-01f,
  1.46893635e-01f, 7.17619658e-02f, 7.09661916e-02f, 7.04771578e-02f, -4.05149348e-02f, 2.67852508e-02f, 1.38710719e-03f, -1.17800713e-01f, 5.19229509e-02f, -7.47939944e-02f,
  -7.78652430e-02f, 5.63225895e-02f, -3.44946161e-02f, -3.39104570e-02f, -8.18210021e-02f, -7.16239586e-02f, -3.15397680e-02f, 3.60571332e-02f, -2.91231945e-02f, 4.69319448e-02f,
  3.09665613e-02f, -1.13257729e-01f, -2.19709545e-01f, -3.41179445e-02f, 1.91425215e-02f, 6.87468126e-02f, 2.71383841e-02f, -4.96158563e-02f, 5.66530861e-02f, 1.60036813e-02f,
  2.09126733e-02f, -2.59663165e-02f, 6.73824251e-02f, 1.32620662e-01f, 2.85750359e-01f, 2.48520467e-02f, 3.44871311e-03f, -5.31709902e-02f, 6.17515855e-02f, -9.19886753e-02f,
  1.55996820e-02f, 6.16311766e-02f, -1.13840193e-01f, 2.08614171e-02f, 2.82878391e-02f, -1.45818785e-01f, -1.45118579e-01f, -9.11655053e-02f, 3.91221531e-02f, -1.55398939e-02f,
  1.31442426e-02f, -8.56494680e-02f, 3.83720621e-02f, 4.58117723e-02f, -4.09342572e-02f, -1.24668935e-02f, 1.24034677e-02f, 3.70278396e-02f, 2.52985046e-03f, 9.21582952e-02f,
  -1.83255062e-01f, -8.10799375e-02f, 2.14388743e-01f, 7.72100128e-03f, -1.31615803e-01f, 5.04468605e-02f, 9.87577587e-02f, -6.39534742e-02f, -8.03676620e-02f, -1.91033948e-02f,
  -8.35236162e-02f, -1.87769625e-02f, -5.31909652e-02f, 1.52307525e-02f, -8.44306499e-03f, -6.42497418e-03f, -9.27867815e-02f, -1.52862385e-01f, -2.05907933e-02f, -7.40455762e-02f,
  -3.43959555e-02f, -2.10245222e-01f, -1.63385183e-01f, -1.99136406e-01f, -1.24680564e-01f, 2.18096655e-02f, -5.80867715e-02f, -1.12297103e-01f, -1.48764223e-01f, -8.26783851e-02f,
  2.91305512e-01f, 3.59827101e-01f, -1.54349941e-03f, 2.94269286e-02f, -2.53079265e-01f, -3.82737905e-01f, -2.65831470e-01f, -1.48060352e-01f, 2.33247541e-02f, -4.66407090e-02f,
  -1.12295263e-01f, -9.66353565e-02f, -1.43029764e-01f, 6.63208738e-02f, 9.42989513e-02f, 2.11339667e-01f, 1.43049300e-01f, 1.53803036e-01f, 7.59735480e-02f, 1.31011799e-01f,
  9.16136876e-02f, 1.54022843e-01f, 1.92657754e-01f, 9.26087052e-02f, 2.46701255e-01f, 1.35475425e-02f, 5.27062230e-02f, 3.92527282e-02f, 1.80924288e-03f, 3.45234543e-01f,
  4.84336875e-02f, 6.22078329e-02f, -2.04285666e-01f, -3.81905964e-04f, -1.45299867e-01f, 1.37926742e-01f, -3.29751498e-03f, 5.14291823e-02f, -3.18678059e-02f, 1.20313443e-01f,
  2.71612294e-02f, -2.58734003e-02f, -2.82695014e-02f, -7.91816786e-03f, 7.04472363e-02f, -8.48073661e-02f, 1.21439442e-01f, 3.21957022e-02f, 8.00203979e-02f, 5.30015863e-02f,
  1.56195620e-02f, -8.53061005e-02f, -2.18238980e-01f, -3.03669125e-01f, 2.98321303e-02f, -2.65527666e-01f, -1.96589112e-01f, -8.69581290e-03f, -1.72020972e-01f, 3.16427261e-01f,
  6.49552792e-02f, 1.06737977e-02f, 3.87463644e-02f, 1.85068518e-01f, 1.23174749e-01f, 2.80583259e-02f, 1.32333785e-01f, 5.44533841e-02f, 7.14464486e-02f, 1.58038080e-01f,
  -1.09854760e-02f, 2.83418912e-02f, 1.08650528e-01f, -5.27865067e-02f, -1.29240960e-01f, 1.05280109e-01f, 1.40183583e-01f, 5.23906834e-02f, -1.28513843e-01f, 2.25882158e-02f,
  8.79825372e-03f, 3.57958861e-03f, -7.96543732e-02f, 1.29705012e-01f, 1.59080308e-02f, 1.89683549e-02f, 1.86988950e-01f, -5.91761544e-02f, -1.05725817e-01f, 5.38772717e-03f,
  1.22276265e-02f, -4.33412135e-01f, -5.69139309e-02f, 2.35247612e-01f, -2.54287999e-02f, -8.97066295e-02f, 1.29541039e-01f, -1.01378858e-01f, -1.94104642e-01f, 8.09695572e-02f,
  -3.13900858e-02f, 8.09473917e-02f, -5.52760698e-02f, -1.80174392e-02f, -1.31154191e-02f, -1.38369784e-01f, -2.87482124e-02f, -1.54502839e-01f, -1.21856565e-02f, -1.84392035e-02f,
  -3.24415006e-02f, -2.14479536e-01f, -2.60699838e-01f, -2.05689386e-01f, -2.23964429e-03f, -3.70662749e-01f, -2.89029032e-01f, -1.40065834e-01f, -2.93368578e-01f, -9.32748392e-02f,
  -1.36802435e-01f, -1.56461090e-01f, -2.45492503e-01f, -4.04912502e-01f, -1.75728798e-01f, 1.46199152e-01f, 1.13947988e-01f, 1.17201522e-01f, -1.56792477e-01f, -5.20711131e-02f,
  2.05292571e-02f, 1.11966141e-01f, -9.88209397e-02f, 8.83634463e-02f, 1.14915960e-01f, -5.52714989e-02f, -1.94617271e-01f, -6.64718002e-02f, 1.86470300e-01f, 2.54557014e-01f,
  5.87811954e-02f, -7.11881220e-02f, -1.17910236e-01f, -4.50259298e-02f, -2.93293387e-01f, -7.14794919e-02f, -3.24401289e-01f, -2.26237074e-01f, -7.88958743e-02f, -2.50438213e-01f,
  7.34739229e-02f, -1.68950498e-01f, -2.39769910e-02f, -1.53151024e-02f, -8.02015886e-02f, -5.54007962e-02f, -1.75633710e-02f, -2.48055607e-01f, -5.01719117e-02f, -1.65701836e-01f,
  -1.18249230e-01f, 4.67946148e-03f, -5.38114123e-02f, -1.04567587e-01f, -1.44711405e-01f, -3.65275703e-02f, -2.90283471e-01f, -1.84143841e-01f, -1.52008235e-01f, 1.36274785e-01f,
  -6.28492460e-02f, -6.63470179e-02f, -7.93285295e-02f, 2.58803945e-02f, 5.34997880e-02f, 1.21345026e-02f, -2.14671250e-02f, 2.85503129e-03f, 1.40859820e-02f, -1.33408546e-01f,
  5.43250591e-02f, 2.87901815e-02f, -1.67095661e-02f, -1.73702333e-02f, 2.77813757e-04f, 2.73327474e-02f, -1.00009292e-01f, 2.39367271e-03f, 1.17406324e-01f, 6.22760281e-02f,
  -4.74322923e-02f, 5.34561984e-02f, 9.59817246e-02f, 3.37006040e-02f, -3.51602882e-02f, 2.97178403e-02f, 4.96851355e-02f, 2.43887566e-02f, 9.20533240e-02f, 5.38527966e-02f,
  1.76386051e-02f, 9.07145068e-02f, -1.51319439e-02f, 1.03412017e-01f, 4.76422831e-02f, -2.54340507e-02f, 1.08784407e-01f, 1.91869661e-01f, 8.12007785e-02f, 3.47044878e-02f,
  5.80828637e-03f, 3.32927220e-02f, -6.46982156e-03f, 7.08920881e-02f, -4.93423417e-02f, 6.40214561e-03f, -1.11838080e-01f, -1.16376348e-01f, -2.33121350e-01f, 5.76825179e-02f,
  7.89987370e-02f, 3.99089344e-02f, -2.37535890e-02f, 6.01424649e-02f, 2.84822322e-02f, 4.58149724e-02f, -5.67835160e-02f, 1.86321586e-02f, 6.94128349e-02f, 1.09915450e-01f,
  -1.59225706e-02f, 1.81342989e-01f, 1.56756982e-01f, 5.00310846e-02f, 1.27243370e-01f, 1.73016787e-01f, 1.76925778e-01f, 2.48117939e-01f, 2.26593763e-01f, 1.83088928e-01f,
  2.82955140e-01f, 1.41878054e-01f, 2.80217737e-01f, 1.37993753e-01f, -1.19929120e-01f, 7.14995991e-03f, 1.01257905e-01f, 8.12221318e-02f, -1.12214662e-01f, 4.39364463e-03f,
  -2.24059194e-01f, -2.66303599e-01f, -1.71264052e-01f, -1.65161461e-01f, 1.17480613e-01f, 8.05777758e-02f, 1.42567262e-01f, 2.22963929e-01f, 1.80188775e-01f, 4.90224063e-02f,
  -9.04192552e-02f, 1.04837827e-01f, 3.08915138e-01f, 1.65636480e-01f, 6.02843501e-02f, -1.34929597e-01f, 1.15334868e-01f, 6.52156696e-02f, -5.20549119e-02f, 8.35403055e-02f,
  -1.61299836e-02f, 2.98699260e-01f, -2.60596842e-01f, -2.12898225e-01f, -2.12556884e-01f, 2.00605541e-02f, -5.38457111e-02f, 4.14259695e-02f, -1.00629732e-01f, -4.98182736e-02f,
  -1.94444343e-01f, -1.42048091e-01f, -1.12734072e-01f, -1.59922987e-01f, 4.63620201e-02f, -1.26497582e-01f, -5.15046120e-02f, 1.93774879e-01f, -5.12583815e-02f, -9.19244960e-02f,
  -1.66419610e-01f, -3.73272188e-02f, 1.14636868e-01f, -2.59586833e-02f, 3.56347002e-02f, -8.63908380e-02f, -6.79678097e-02f, -4.81937937e-02f, -2.53090039e-02f, 1.71198308e-01f,
  -7.46606141e-02f, 5.53972907e-02f, 5.10486178e-02f, 2.12558955e-01f, 4.90690582e-02f, -9.27596241e-02f, -3.95681895e-02f, -5.12945503e-02f, 8.88651460e-02f, 9.17964727e-02f,
  -4.01059212e-03f, -4.42725942e-02f, 1.54634833e-01f, 5.47438227e-02f, -7.63278902e-02f, -2.88730580e-02f, -4.62957136e-02f, 2.65644770e-02f, 1.04249045e-01f, 5.73281832e-02f,
  -6.82158023e-02f, -5.76623827e-02f, 1.52744455e-02f, -3.90003622e-02f, -4.19434570e-02f, 5.05355597e-02f, -1.99419521e-02f, -3.21522616e-02f, 1.04253441e-01f, 3.48041132e-02f,
  4.26258706e-02f, -6.36250153e-02f, -5.70086576e-02f, -3.03661712e-02f, 9.86744538e-02f, -1.15624424e-02f, 4.99506854e-02f, 5.66954762e-02f, -1.10174753e-01f, 2.97754239e-02f,
  -1.38401285e-01f, -1.73098058e-01f, -1.08705230e-01f, -9.89978667e-03f, -7.63635188e-02f, -4.39444296e-02f, -1.99630022e-01f, 2.02005878e-02f, -1.10620640e-01f, -4.70711291e-02f,
  -9.34491083e-02f, 4.60217968e-02f, 3.83494087e-02f, -1.06109016e-01f, -1.45620676e-02f, -1.27299175e-01f, 3.32258753e-02f, -1.17545910e-02f, -1.43876359e-01f, 6.88967183e-02f,
  7.69549668e-01f, 2.41435859e-02f, 3.19624633e-01f, 1.97182894e-01f, -1.82025936e-02f, 4.53492217e-02f, -2.32239370e-03f, -5.94847016e-02f, -8.07007551e-02f, 8.09395537e-02f,
  1.16275623e-01f, 1.77688345e-01f, 1.94964349e-01f, 9.83299688e-02f, 1.68013960e-01f, -1.05794579e-01f, 1.17459211e-04f, 2.17803568e-01f, 1.37043893e-01f, 6.53793365e-02f,
  -1.49211794e-01f, -3.65608260e-02f, 2.00446770e-01f, 7.53623433e-03f, -3.34233604e-02f, 9.91106033e-03f, 2.69431621e-02f, -6.05109334e-03f, 1.20222308e-01f, -7.60383755e-02f,
  -7.12846667e-02f, 2.35091507e-01f, -6.96744397e-02f, -1.87405162e-02f, 5.18280827e-02f, -7.53237084e-02f, 5.99324219e-02f, -1.32541195e-01f, -5.42217158e-02f, -9.23707485e-02f,
  -2.86337249e-02f, 3.15562636e-02f, 1.30259423e-02f, -9.13454965e-02f, -5.02172559e-02f, -5.84954210e-02f, 1.53135825e-02f, -1.91440973e-02f, 7.47589953e-03f, -1.31431175e-02f,
  -4.33199368e-02f, 4.38358895e-02f, 3.83065604e-02f, -3.61584909e-02f, 7.41045550e-02f, 5.69356047e-02f, 6.76250085e-02f, 1.13302961e-01f, -1.22467531e-02f, 3.96173932e-02f,
  1.17500894e-01f, 1.83314070e-01f, 2.22938731e-01f, 3.92339639e-02f, 8.36536139e-02f, 9.17778164e-02f, -4.89468314e-02f, -7.45130256e-02f, 9.85027403e-02f, 2.40899604e-02f,
  -3.31007913e-02f, 9.81996730e-02f, 7.03564438e-04f, 3.16300131e-02f, 2.39543170e-02f, -8.92344341e-02f, -2.12347824e-02f, -4.56401557e-02f, 3.02092498e-03f, -2.54806373e-02f,
  9.74352751e-03f, -9.40500349e-02f, -9.46283564e-02f, -5.11155650e-02f, -7.80199021e-02f, 1.04445517e-01f, 5.00828996e-02f, -4.17305455e-02f, 6.53371662e-02f, -1.78333297e-02f,
  -5.62964559e-01f, 1.90651700e-01f, 8.71748999e-02f, -9.93553102e-02f, -2.81116441e-02f, 6.26294129e-03f, 6.51822388e-02f, 2.92983912e-02f, -1.44699216e-01f, -1.03986159e-01f,
  3.30669768e-02f, -1.44405700e-02f, 1.08340718e-02f, 1.50599619e-02f, -4.69133072e-02f, -1.22604102e-01f, -1.22242905e-02f, -2.65842397e-02f, 8.05780757e-03f, -1.59836426e-01f,
  -2.37906501e-02f, -9.08398479e-02f, -3.78968641e-02f, -1.13675579e-01f, -6.72829300e-02f, 5.77600673e-02f, 4.56968546e-02f, -1.17724307e-01f, -1.17363576e-02f, -7.70657882e-02f,
  -6.86027288e-01f, 3.84705216e-02f, 1.52825192e-01f, -5.05827725e-01f, -2.30379447e-01f, -1.95775349e-02f, 1.00053139e-01f, -1.89808682e-01f, -4.10513818e-01f, 4.52189669e-02f,
  9.96266454e-02f, -9.82078239e-02f, -1.00789592e-01f, -2.60359719e-02f, -1.02793671e-01f, 1.36650810e-02f, -9.84492823e-02f, -2.71941602e-01f, -3.65461409e-01f, -2.04627067e-01f,
  -1.44980580e-01f, -3.38347018e-01f, -4.54810798e-01f, -3.28903407e-01f, -3.84622440e-02f, -1.04816310e-01f, -4.25098538e-02f, -2.73516893e-01f, -1.96353905e-03f, -5.87757230e-02f,
  4.15990472e-01f, -5.43241352e-02f, 1.14805123e-03f, -1.10667378e-01f, 3.47587578e-02f, -5.00899665e-02f, -4.56540547e-02f, 2.50075310e-02f, -4.54086214e-02f, 8.82731564e-03f,
  -1.37315720e-01f, 9.77444276e-03f, -1.30848572e-01f, 5.78853078e-02f, -9.59031433e-02f, -5.94869852e-02f, 1.33930445e-01f, 6.02657609e-02f, 9.29535925e-02f, 2.47678787e-01f,
  1.19702443e-01f, 8.11320543e-02f, 9.08892006e-02f, 1.63148195e-01f, 1.09697677e-01f, 5.15382774e-02f, 1.51617259e-01f, 1.72766745e-01f, 1.02337815e-01f, 9.87550542e-02f,
  4.18245457e-02f, -1.37799149e-02f, -1.20946541e-02f, -5.26126809e-02f, -3.57916616e-02f, 6.53155446e-02f, -1.82660744e-02f, -7.46092275e-02f, -1.92072421e-01f, -5.43112978e-02f,
  1.07371822e-01f, 1.93352386e-01f, 2.09400300e-02f, -2.70449352e-02f, 1.88556239e-02f, -9.64171737e-02f, -3.38850692e-02f, 1.14666291e-01f, 5.53416461e-02f, -2.61947066e-02f,
  2.18650047e-02f, -8.62740446e-03f, -1.47764022e-02f, 4.47572544e-02f, 1.22040264e-01f, -1.58540457e-02f, 4.00908552e-02f, -4.52342890e-02f, -1.51716575e-01f, -6.89326525e-02f,
  4.92161773e-02f, 1.41896412e-01f, -3.59024405e-02f, -7.70383105e-02f, -1.19635195e-01f, -4.54887450e-02f, -2.13485025e-03f, -2.76013482e-02f, -6.91410154e-02f, 7.80676957e-03f,
  4.00696807e-02f, -7.05730841e-02f, 6.99929819e-02f, -8.45594704e-03f, -2.12753415e-01f, -1.83869675e-02f, 4.79774736e-02f, 9.19193476e-02f, 8.79660994e-02f, 1.71534106e-01f,
  8.35026056e-02f, -1.18552521e-02f, -3.75311486e-02f, 1.43003687e-01f, 2.17781216e-02f, -1.75706297e-02f, 1.61974102e-01f, 1.22812085e-01f, 1.60107687e-02f, -2.93590967e-02f,
  2.48212561e-01f, 4.64579850e-01f, 1.03493571e-01f, 7.56782666e-03f, 1.20521195e-01f, 1.58769861e-01f, 2.74022371e-01f, -1.60688907e-02f, -1.61435217e-01f, 1.23683974e-01f,
  1.45948634e-01f, -1.35321781e-01f, -1.96540654e-01f, -7.55737051e-02f, -1.18377887e-01f, 1.08040065e-01f, 7.49634579e-02f, -3.51528153e-02f, -1.67392105e-01f, -1.11019323e-02f,
  -4.49153148e-02f, -1.35253044e-03f, -5.70445210e-02f, -1.22089177e-01f, -7.47107575e-03f, -2.62246341e-01f, 6.51655868e-02f, 2.41982087e-01f, 2.12888718e-01f, 9.91970375e-02f,
  9.68336612e-02f, 3.80266041e-01f, -3.68502527e-01f, 4.75088181e-03f, 6.21243715e-02f, -5.39471805e-02f, -9.00734141e-02f, -2.96959537e-03f, 2.58580968e-02f, 2.06881594e-02f,
  1.63637027e-01f, 1.09156683e-01f, 7.56867081e-02f, 4.20877971e-02f, 1.10937543e-02f, -1.59182977e-02f, -8.77630264e-02f, -1.00617874e-02f, -4.30598073e-02f, -7.35188127e-02f,
  -3.80073115e-02f, 1.49158075e-01f, 1.25217080e-01f, -1.78169772e-01f, -4.28887643e-02f, -9.19546187e-02f, 8.15019161e-02f, 8.88842717e-03f, -1.76122025e-01f, -1.19419992e-01f,
  -2.01971471e-01f, 1.23788312e-01f, 1.28289506e-01f, 5.03384210e-02f, -1.70349963e-02f, 1.37663065e-02f, 5.84776849e-02f, -1.72124561e-02f, -2.33436935e-02f, 1.00237943e-01f,
  -1.39550522e-01f, -1.64818674e-01f, 4.81885336e-02f, -1.40280157e-01f, -1.53325334e-01f, -8.99228361e-03f, -4.35643867e-02f, -4.91116643e-02f, 5.63834049e-02f, -3.19199823e-02f,
  -6.13087229e-03f, -7.85036534e-02f, -7.39681954e-03f, -4.76139560e-02f, -6.58228993e-02f, -7.64672011e-02f, -1.78682953e-01f, -1.43447891e-01f, -1.65290996e-01f, -3.93014252e-02f,
  -1.83959574e-01f, -3.20858993e-02f, -3.26063544e-01f, 1.03460692e-01f, 1.60826549e-01f, -4.50577624e-02f, -4.85971943e-03f, -5.98364789e-03f, 1.21845700e-01f, -6.77280352e-02f,
  9.80166346e-02f, -1.89214181e-02f, -7.14265183e-02f, -3.15288901e-02f, -1.33218557e-01f, 4.15252335e-02f, 7.23590106e-02f, -6.76652640e-02f, -1.84057161e-01f, 9.05116796e-02f,
  4.98790517e-02f, -1.33663833e-01f, -2.78305829e-01f, -3.37418795e-01f, -2.21510544e-01f, -4.94685382e-01f, -2.49490395e-01f, -1.96279377e-01f, -3.10934901e-01f, -2.47305930e-01f,
  3.19648564e-01f, 4.94194962e-02f, -7.24301577e-01f, 7.89005402e-03f, -2.92856663e-01f, -2.04391643e-01f, 6.64609447e-02f, 9.55359861e-02f, 5.07373363e-02f, 4.09730524e-02f,
  -1.80115402e-01f, -1.97223768e-01f, -1.95092916e-01f, -1.37850761e-01f, 1.35923084e-02f, -4.37305458e-02f, -9.02321190e-02f, -2.94778556e-01f, -1.95193142e-01f, -6.65979227e-03f,
  6.31816164e-02f, 8.12581554e-02f, 8.14232305e-02f, -5.18339947e-02f, -2.09103733e-01f, -2.84514070e-01f, -3.98097724e-01f, -2.38728255e-01f, -1.56665444e-01f, -3.16973686e-01f,
  -4.09823745e-01f, -2.73656875e-01f, -1.84254959e-01f, 2.39203330e-02f, -1.23387441e-01f, -3.03405896e-02f, -3.76059189e-02f, -1.65196255e-01f, 4.70357537e-02f, -1.62153784e-02f,
  -1.41901448e-01f, 9.56774782e-03f, -1.75270528e-01f, -2.13808671e-01f, -1.67177007e-01f, -4.84736823e-02f, 5.87854721e-02f, -5.16627096e-02f, -8.79195109e-02f, -6.45533763e-03f,
  1.06126398e-01f, -1.27513498e-01f, -1.92894727e-01f, 6.78672418e-02f, -1.39951229e-01f, -1.25331894e-01f, -1.46662191e-01f, -5.84767535e-02f, -1.93297625e-01f, 1.28924593e-01f,
  2.00691774e-01f, -1.68639403e-02f, -2.07662638e-02f, 1.02891503e-02f, 1.24743551e-01f, -9.24351513e-02f, -1.08982697e-01f, 9.09637883e-02f, -6.57635601e-03f, 2.79789045e-02f,
  4.02099043e-02f, 4.01658453e-02f, 9.71965306e-03f, -2.82591535e-03f, -1.32465847e-02f, -8.80624205e-02f, 9.19385999e-03f, 1.08637512e-01f, 5.39847650e-03f, 1.31025231e-02f,
  -1.86792128e-02f, -6.38385192e-02f, -1.76834837e-01f, 7.21585527e-02f, 2.44741589e-02f, 1.68073699e-02f, -5.91808232e-03f, 8.07928666e-02f, 1.03049360e-01f, 1.09458086e-03f,
  9.71057937e-02f, -2.88603976e-02f, -5.44325262e-03f, 9.11568627e-02f, -4.09118086e-03f, -1.50414243e-01f, -7.68348202e-02f, 8.17611143e-02f, -1.00080788e-01f, -1.11416150e-02f,
  -2.52292044e-02f, 1.94506142e-02f, -4.89670523e-02f, -1.05400328e-02f, -4.95011173e-02f, -1.53188586e-01f, 2.23274916e-01f, -5.44624068e-02f, 6.30874336e-02f, 1.58389345e-01f,
  2.98854649e-01f, 2.81975389e-01f, 2.37270355e-01f, 1.74325615e-01f, 3.42218876e-02f, 6.92306906e-02f, -9.81027931e-02f, -2.53294352e-02f, 5.24179824e-02f, 3.81689578e-01f,
  3.40971321e-01f, -2.02682111e-02f, 1.83566123e-01f, 2.08823336e-03f, -1.96980342e-01f, -2.16910213e-01f, -1.90674752e-01f, -6.85859993e-02f, 4.39456291e-02f, 1.12758890e-01f,
  1.14088997e-01f, 1.37540817e-01f, 1.10289842e-01f, 1.44728646e-01f, 1.94990367e-01f, -3.74575816e-02f, -4.85277316e-03f, 2.30141789e-01f, 8.65928829e-02f, 8.90610218e-02f,
  -1.00955449e-01f, 8.56750980e-02f, 1.09480537e-01f, 1.90025032e-01f, 9.03903134e-03f, 1.41707197e-01f, 7.88270459e-02f, -3.53860110e-02f, 2.33547129e-02f, 1.95771024e-01f,
  3.33312273e-01f, 7.91121200e-02f, 6.03435375e-02f, 2.13447902e-02f, -3.81916538e-02f, 5.42410538e-02f, -3.19566317e-02f, 1.34974523e-02f, -1.06038965e-01f, -1.32136181e-01f,
  -3.63279246e-02f, 4.59633954e-02f, 6.03619330e-02f, -1.70109440e-02f, -1.70744196e-01f, 2.46636532e-02f, -1.03798450e-03f, 1.76984537e-02f, 3.12025920e-02f, 8.76571983e-02f,
  -8.34655762e-03f, -6.13405816e-02f, -1.26335695e-01f, -1.14353403e-01f, 1.59613392e-03f, 5.68531454e-02f, 3.44753191e-02f, 7.08497316e-02f, 5.49694747e-02f, -9.06843096e-02f,
  2.34136179e-01f, 3.93508840e-03f, -4.13994677e-03f, 5.78327924e-02f, -9.83640999e-02f, -3.82924974e-02f, -1.74695536e-01f, -1.72627196e-02f, 3.52460518e-03f, -4.37578373e-02f,
  -7.99095184e-02f, 8.30164403e-02f, -8.45376179e-02f, -8.20675641e-02f, 1.36914849e-01f, 2.75280550e-02f, -1.60516739e-01f, 6.46575764e-02f, 2.23987997e-02f, 1.65806469e-02f,
  7.68713430e-02f, -3.12324893e-02f, -3.01499497e-02f, -5.14322799e-03f, -8.75838026e-02f, -3.60690281e-02f, -1.25196069e-01f, -5.15834540e-02f, 7.11786449e-02f, -1.10413492e-01f,
  -8.79589394e-02f, 1.81473374e-01f, 1.15651965e-01f, 1.52503550e-01f, -8.98763016e-02f, 8.97767097e-02f, 4.69974466e-02f, 5.75676858e-02f, -1.27989529e-02f, -1.00802340e-01f,
  -9.00368392e-02f, -2.41450150e-03f, 2.36470089e-03f, 1.24243638e-02f, -9.81682539e-02f, 3.49731483e-02f, -5.99209145e-02f, -8.19681119e-03f, -1.05726674e-01f, -8.33451226e-02f,
  -7.70551488e-02f, -1.58305869e-01f, -4.14388925e-02f, -3.90682369e-02f, -4.22249995e-02f, -6.14841236e-03f, 1.06027732e-02f, -1.00269601e-01f, 4.97794747e-02f, -3.61256190e-02f,
  2.91476637e-01f, -4.55629438e-01f, 2.19652191e-01f, 2.97070354e-01f, 2.25265920e-01f, 1.58638418e-01f, 1.63028687e-01f, 9.59490091e-02f, 1.52815387e-01f, 8.52642022e-03f,
  -3.70176464e-01f, -4.60346699e-01f, -2.63118327e-01f, -2.55067587e-01f, -2.09190577e-01f, 2.27749690e-01f, 2.08857939e-01f, 1.56789377e-01f, 3.61121371e-02f, 4.03183438e-02f,
  4.43719281e-03f, 2.63201863e-01f, 1.06290311e-01f, -6.27657995e-02f, 3.29954848e-02f, -5.17713167e-02f, 6.59218132e-02f, -2.04532128e-02f, -9.54522118e-02f, -3.59250989e-04f,
  -1.06493913e-01f, -8.18668380e-02f, 4.80336621e-02f, -1.52276635e-01f, -6.79470450e-02f, -2.26279311e-02f, -6.33720262e-03f, -2.74565034e-02f, -2.26557944e-02f, 2.49806494e-02f,
  -1.49026811e-01f, -1.23368546e-01f, -1.16834998e-01f, -3.21079269e-02f, -5.82217192e-03f, 3.82610306e-04f, -5.99173866e-02f, 1.10218162e-02f, -7.48555921e-03f, -1.13325186e-01f,
  -2.70546436e-01f, 1.94076225e-02f, 3.55933764e-04f, 7.71938190e-02f, -1.41989082e-01f, -2.25181952e-02f, 1.45078376e-02f, -9.62368101e-02f, -5.31415232e-02f, 1.11879021e-01f,
  1.26571208e-01f, 1.29318818e-01f, 3.58525552e-02f, 7.54003376e-02f, 2.15303674e-02f, -9.53816548e-02f, 1.61163323e-02f, 1.25402408e-02f, -3.12940963e-02f, 4.93886881e-02f,
  -3.31652886e-03f, 4.81537357e-02f, 8.57281536e-02f, 7.62612522e-02f, -1.97558217e-02f, -5.14459237e-03f, 4.50895727e-02f, -4.52271709e-03f, -4.28864732e-02f, 1.90673277e-01f,
  1.50769344e-02f, -9.96632967e-03f, -9.50999707e-02f, -4.79247756e-02f, -4.78228480e-02f, -7.88745284e-03f, 2.60353871e-02f, -8.39564949e-02f, 4.20797542e-02f, 4.68005240e-02f,
  1.30811885e-01f, -1.55270636e-01f, -1.83464792e-02f, -2.36462727e-02f, 1.92315562e-03f, -8.28226581e-02f, -5.55697531e-02f, -4.95755188e-02f, -7.18668550e-02f, -4.23519537e-02f,
  -1.57037437e-01f, -6.11114241e-02f, -1.20950803e-01f, -7.01671317e-02f, 1.11526936e-01f, 6.55261278e-02f, -1.15916699e-01f, -2.20503695e-02f, 1.39869899e-02f, -4.50894237e-02f,
  1.39379567e-02f, 7.90982321e-02f, 1.94759384e-01f, 1.08210452e-01f, 2.15806998e-02f, -1.51485228e-03f, 8.68808329e-02f, 1.28129229e-01f, 1.00310154e-01f, 2.00977325e-01f,
  2.58174334e-02f, -4.56477096e-03f, -3.38165581e-01f, 1.46072805e-01f, 1.55283645e-01f, -5.74799813e-03f, -1.11890867e-01f, -1.27364531e-01f, 9.01466310e-02f, 2.46749744e-01f,
  6.78319111e-02f, 1.25485241e-01f, 1.51009858e-01f, 2.08447147e-02f, -2.44815852e-02f, 3.89368683e-02f, 2.62744147e-02f, -1.51340723e-01f, -1.40849426e-02f, -2.00094525e-02f,
  2.62192786e-01f, 2.25875124e-01f, 4.58336174e-02f, -1.24802405e-03f, -1.49045447e-02f, 1.39862925e-01f, 6.28531873e-02f, 1.04159839e-01f, -1.98452882e-02f, -1.57391757e-03f,
  9.75613594e-02f, -2.47110978e-01f, -1.55271158e-01f, -8.28188956e-02f, -1.47132471e-01f, -6.17415085e-03f, -1.35262519e-01f, -2.75748640e-01f, -1.63264185e-01f, -1.08167119e-01f,
  -4.27804254e-02f, -2.99646091e-02f, -1.83307286e-02f, 4.35727239e-02f, -6.27024425e-03f, -1.37458578e-01f, -1.02501862e-01f, -2.97857016e-01f, -1.42033324e-01f, -1.88001767e-01f,
  -5.09471335e-02f, -9.13148522e-02f, -2.23419607e-01f, -2.18620986e-01f, -2.60258228e-01f, -1.32525768e-02f, -2.52777040e-01f, -1.92739964e-01f, -1.87383965e-01f, 3.04741357e-02f,
  4.19082902e-02f, -1.71188544e-02f, -2.19213050e-02f, -1.01320088e-01f, 2.34770868e-02f, -4.28448133e-02f, -1.02270633e-01f, 9.82158929e-02f, 4.26768474e-02f, 8.14706236e-02f,
  -1.10480145e-01f, 6.87460043e-03f, -2.29659434e-02f, 7.18651637e-02f, 9.76560563e-02f, -2.04102099e-02f, -6.01663999e-02f, 1.03985339e-01f, -1.14668854e-01f, 1.11863412e-01f,
  3.25781293e-02f, 9.14191082e-02f, 6.72675818e-02f, -1.52190313e-01f, 2.43123844e-02f, -1.21031374e-01f, 8.91719535e-02f, 8.57258737e-02f, -1.72739457e-02f, -5.37967607e-02f,
  4.11026239e-01f, -3.74554582e-02f, -2.10275520e-02f, -1.29178584e-01f, 6.78681582e-02f, 1.12785837e-02f, -7.22132996e-02f, -1.74287278e-02f, -3.02374214e-02f, -6.34042174e-02f,
  -3.00090164e-02f, -8.25670809e-02f, 1.09230429e-01f, 8.64050612e-02f, 7.08614290e-02f, 1.46295249e-01f, 1.95603669e-01f, 6.33976283e-03f, 7.04606995e-02f, -1.00366190e-01f,
  1.45540386e-01f, 7.75141716e-02f, 1.74013808e-01f, -3.58045734e-02f, 1.00138430e-02f, 1.60306886e-01f, 1.55728653e-01f, 7.75200576e-02f, -6.14392273e-02f, 3.50265980e-01f,
  -3.49847913e-01f, 2.32795134e-01f, -1.16254173e-01f, -5.49599230e-02f, 2.21833244e-01f, 2.47652203e-01f, 2.52508819e-01f, 8.32813382e-02f, 3.09181530e-02f, 6.71586767e-02f,
  -9.73715354e-03f, -4.08590883e-02f, -4.76491600e-02f, -5.35881193e-03f, 6.46868423e-02f, 1.69420049e-01f, 2.36328214e-01f, 1.35071774e-03f, -1.53899014e-01f, -9.31612700e-02f,
  1.83100417e-01f, 1.62146688e-02f, -1.44832551e-01f, -2.23880839e-02f, -3.16494443e-02f, 5.25432862e-02f, 1.36437595e-01f, 3.71904001e-02f, 1.77927867e-01f, 5.54469489e-02f,
  -3.72753024e-01f, -9.52201560e-02f, -3.13622430e-02f, -3.65042537e-02f, -1.49362698e-01f, -8.15041885e-02f, 6.29344434e-02f, -2.42097173e-02f, 3.23939584e-02f, -9.06533301e-02f,
  5.45913354e-02f, -1.23420164e-01f, 1.84630960e-01f, 9.57593247e-02f, 1.83711760e-02f, -2.40750331e-02f, 1.03018664e-01f, -1.30495667e-01f, -9.33058336e-02f, -1.44775197e-01f,
  1.93264827e-01f, 8.57708156e-02f, -9.38211307e-02f, 5.41645288e-02f, 2.12960057e-02f, -1.33746192e-01f, -6.09571673e-02f, -1.24733016e-01f, -1.87028274e-01f, -2.52001494e-01f,
  8.81571472e-02f, -5.02884714e-03f, 2.94222143e-02f, -3.99616621e-02f, -9.80619248e-03f, 5.84568549e-03f, -7.35622346e-02f, -9.76563394e-02f, -7.59775657e-03f, 4.01555635e-02f,
  -7.12697282e-02f, -2.06788898e-01f, -1.44144937e-01f, -1.36525244e-01f, -9.11002159e-02f, 3.74649838e-03f, 3.56981158e-02f, -5.46523146e-02f, -7.94242024e-02f, -5.06864488e-02f,
  -4.66180667e-02f, -2.05433458e-01f, -2.92213205e-02f, -1.03986159e-01f, -2.62600258e-02f, -6.39446154e-02f, -6.52474388e-02f, -1.81488469e-01f, -3.84498686e-02f, 3.05021331e-02f,
  -1.10852867e-01f, 1.39717653e-01f, -2.62586921e-01f, 4.76604886e-02f, -7.85278082e-02f, -3.98343848e-03f, 1.73901636e-02f, -6.61995113e-02f, -1.06254891e-01f, -1.38734370e-01f,
  -1.77563339e-01f, -2.69137055e-01f, 2.23154873e-02f, 7.26920888e-02f, -8.01190436e-02f, -3.41562368e-02f, 9.97207239e-02f, 3.07054706e-02f, -6.93890825e-02f, -1.80044785e-01f,
  4.24449295e-02f, -9.81764272e-02f, -1.22172065e-01f, 1.62138212e-02f, -6.43877611e-02f, -1.27338022e-01f, -1.94617510e-01f, -9.11144540e-02f, -1.02034405e-01f, -7.45129287e-02f,
  -4.13367420e-01f, 2.83816308e-01f, 2.61657909e-02f, -2.15324000e-01f, 2.00494066e-01f, 2.45382339e-01f, 3.34461391e-01f, 8.99141952e-02f, -5.39831035e-02f, 4.55372632e-02f,
  6.91150427e-02f, -9.85208228e-02f, -5.80646396e-02f, -6.18587434e-03f, 1.03243724e-01f, 2.12733015e-01f, 1.59107760e-01f, -6.20655008e-02f, -6.27617687e-02f, 1.43120900e-01f,
  1.81376323e-01f, -3.65751609e-02f, -1.48045391e-01f, -2.23916341e-02f, -4.73957136e-02f, -1.19101770e-01f, 2.36222837e-02f, -5.13514765e-02f, 1.17503889e-01f, -4.98743840e-02f,
  -2.80855238e-01f, -6.59177899e-02f, 1.46825882e-02f, -4.82393056e-02f, -3.83249037e-02f, -1.28614545e-01f, 3.98152129e-04f, -1.67663485e-01f, 1.13802619e-01f, -6.15513287e-02f,
  -1.21895422e-03f, -4.51448634e-02f, 1.17507624e-02f, -5.12890778e-02f, -1.04131944e-01f, -4.53091599e-02f, -5.37206093e-03f, -2.64200866e-02f, -1.40013725e-01f, -6.57497644e-02f,
  1.11477338e-01f, 3.56686264e-02f, -6.97383061e-02f, 3.76450680e-02f, 4.41965312e-02f, -2.19296709e-01f, 4.05228473e-02f, 3.12394667e-02f, -1.48899585e-01f, -2.15698108e-01f,
  -4.58487310e-02f, -6.17313012e-03f, -4.60463949e-03f, 8.77074897e-02f, 1.44191995e-01f, 3.64187062e-02f, 3.50622050e-02f, 9.42765474e-02f, -5.50490245e-03f, 1.04244888e-01f,
  2.45571285e-02f, -7.88781941e-02f, 3.48204467e-03f, -3.28421872e-03f, 1.93013996e-02f, 2.71402001e-02f, 1.39799267e-01f, 6.78410009e-02f, -2.66563427e-03f, 1.50218844e-01f,
  -8.40440392e-02f, -8.44447222e-03f, 2.88343858e-02f, -7.02107623e-02f, -7.32999071e-02f, 9.43469480e-02f, -2.53846329e-02f, -1.00912273e-01f, -7.61268660e-02f, -4.58143372e-03f,
  -2.19007179e-01f, 1.06819786e-01f, -2.29943842e-01f, 1.69075374e-02f, -4.34792340e-02f, -7.14897662e-02f, -5.68449385e-02f, 6.57138973e-02f, 4.43763211e-02f, -4.48239036e-03f,
  6.70543015e-02f, 2.38297489e-02f, -9.68650430e-02f, -5.54158576e-02f, -6.05230592e-02f, -1.58447623e-01f, -1.05857968e-01f, -1.23616748e-01f, 1.60039887e-02f, 6.62255362e-02f,
  2.70860083e-02f, -1.84022278e-01f, -2.52661407e-01f, -1.06924966e-01f, -9.52172279e-02f, -2.75239319e-01f, -1.50681853e-01f, -7.99544975e-02f, -1.84037268e-01f, -1.44048348e-01f,
  -3.22847158e-01f, -3.78611207e-01f, 3.42855565e-02f, -3.29496592e-01f, -1.97032854e-01f, -1.34980351e-01f, -4.35490549e-01f, -1.16552785e-01f, -1.48925141e-01f, -4.20915812e-01f,
  -2.17522681e-01f, 1.23489320e-01f, 8.56244341e-02f, 2.36113697e-01f, 1.93564817e-01f, -3.81550014e-01f, -1.12105057e-01f, 2.65629709e-01f, 4.73066986e-01f, 8.01382288e-02f,
  -1.28144532e-01f, -3.93770486e-02f, 2.85615891e-01f, 1.37643352e-01f, -3.72885615e-01f, -7.67215490e-02f, -1.56107381e-01f, -3.70384268e-02f, -1.61873460e-01f, -4.02850568e-01f,
  -1.07239023e-01f, -1.96446493e-01f, 1.91238061e-01f, 1.08441561e-01f, 3.85623835e-02f, -1.59105044e-02f, -8.32391977e-02f, 3.34030343e-03f, 4.57737073e-02f, -1.17391966e-01f,
  -3.07691675e-02f, 7.70835730e-04f, 4.52105552e-02f, 1.15547180e-01f, -6.04149066e-02f, -6.14025928e-02f, 7.56955966e-02f, 1.68001309e-01f, 2.53559947e-02f, -1.96769685e-01f,
  -1.01036124e-01f, -5.86386733e-02f, 4.25514802e-02f, 1.44107407e-02f, 4.94185090e-02f, 1.53334633e-01f, -6.31462038e-02f, 1.66232269e-02f, 1.33212045e-01f, -4.05330926e-01f,
  -4.77814069e-03f, 6.25013411e-02f, -8.57657462e-04f, 5.23829125e-02f, -3.30487788e-02f, -8.88637230e-02f, 3.02617736e-02f, -1.87233761e-02f, 3.90792489e-02f, -1.69081725e-02f,
  6.51088655e-02f, 2.57912911e-02f, -6.29356802e-02f, -1.70535684e-01f, -6.86287414e-03f, -6.30732253e-02f, 1.33690396e-02f, -1.32136177e-02f, 1.70048662e-02f, -7.26830438e-02f,
  9.06634629e-02f, -1.17702661e-02f, 8.05629045e-02f, 1.52485510e-02f, 2.00407673e-02f, 5.03300615e-02f, -3.83950509e-02f, 1.42126024e-01f, -2.18625879e-03f, 2.66696587e-02f,
  1.11838300e-02f, 2.77660310e-01f, -3.61387432e-01f, 5.07368855e-02f, -8.91908910e-03f, 1.02502182e-01f, -8.34445953e-02f, 8.01517367e-02f, -1.15699936e-02f, -1.27815129e-02f,
  3.83305773e-02f, -3.61397229e-02f, -3.07022892e-02f, 1.24176413e-01f, -5.71629666e-02f, -2.17010360e-02f, 4.82285470e-02f, -1.09232049e-02f, 1.01690345e-01f, -1.21500097e-01f,
  -5.84008247e-02f, -7.23039135e-02f, -2.67158188e-02f, -8.22475329e-02f, -1.20450251e-01f, 1.34182855e-01f, -4.54236753e-02f, -2.53731608e-02f, 6.53355196e-02f, -2.77404279e-01f,
  -3.91031951e-01f, -8.66053067e-03f, -2.65616357e-01f, -3.07703048e-01f, -3.16558301e-01f, -3.29246253e-01f, -2.86066443e-01f, -1.67295948e-01f, -2.19892099e-01f, -9.84101519e-02f,
  6.32689595e-02f, 1.55823827e-01f, 9.85080376e-02f, 6.06424361e-02f, -6.93593174e-02f, -1.11958593e-01f, -3.07297051e-01f, -3.45786333e-01f, -2.40039945e-01f, -2.88369179e-01f,
  -1.81657091e-01f, -3.18747520e-01f, -2.15639889e-01f, -2.20564857e-01f, -4.12812494e-02f, -3.67813930e-02f, -8.89905319e-02f, -2.74071783e-01f, -2.53450543e-01f, -2.85204858e-01f,
  1.95061073e-01f, -4.04867083e-01f, 3.82385775e-02f, -2.03821585e-01f, 3.02434172e-02f, -1.23287570e-02f, -7.54806846e-02f, 2.33158413e-02f, -3.30126286e-02f, -6.22855462e-02f,
  -7.70625845e-02f, -8.21190774e-02f, -6.95685372e-02f, 7.44377226e-02f, -9.24988687e-02f, 2.05211528e-02f, 7.02417642e-02f, 1.54039003e-02f, 2.76758950e-02f, 1.29394472e-01f,
  6.18478209e-02f, -4.20402735e-02f, 1.60773247e-01f, 1.39459938e-01f, 7.11168814e-03f, -7.85956234e-02f, 2.81874370e-02f, -1.41969426e-02f, -8.36613495e-03f, 5.27945198e-02f,
  -4.60024327e-02f, 9.58482549e-02f, -3.37446854e-02f, -1.44641604e-02f, -8.40382129e-02f, 2.27478296e-02f, 1.82297162e-03f, 1.30064666e-01f, -5.39580882e-02f, 1.31710738e-01f,
  7.57812173e-04f, 1.62426718e-02f, 3.46131437e-02f, 2.86929905e-02f, 7.25492788e-03f, -2.54814103e-02f, -6.40884787e-02f, 3.35427076e-02f, 5.55832088e-02f, -6.08830750e-02f,
  -4.81402278e-02f, -8.26266110e-02f, -2.49601696e-02f, -5.34295551e-02f, -1.26921386e-01f, -1.24704711e-01f, -2.90015973e-02f, 5.44004608e-03f, -7.32505992e-02f, -4.56809103e-02f,
  1.77272186e-01f, -1.77482724e-01f, 1.02116745e-02f, 1.04258589e-01f, -2.57266536e-02f, 1.08155407e-01f, -7.72090331e-02f, -1.10625051e-01f, -7.74426013e-02f, -2.01128259e-01f,
  -1.38690233e-01f, 3.90335433e-02f, 4.68268320e-02f, 1.81789711e-01f, 3.89080308e-02f, -8.62939507e-02f, 3.72290537e-02f, 2.44705044e-02f, 3.24731283e-02f, 1.77696630e-01f,
  1.79133371e-01f, -5.04277013e-02f, 2.02505916e-01f, 1.51656136e-01f, 1.11155687e-02f, 2.30377633e-02f, 1.61847040e-01f, 9.01524909e-03f, 5.37855476e-02f, 1.84894994e-01f,
  -2.57651210e-01f, -1.73092723e-01f, 1.27662346e-01f, 1.96503893e-01f, -1.47939501e-02f, -7.38722384e-02f, -1.16174199e-01f, -6.03878014e-02f, 2.85781529e-02f, -8.62669200e-02f,
  -2.02010199e-01f, 3.28959487e-02f, 1.70554265e-01f, 2.08917707e-01f, 1.02605298e-01f, 6.02146126e-02f, 2.63389170e-01f, 3.08089584e-01f, 2.14163944e-01f, -1.08226098e-01f,
  2.99934316e-02f, 3.47867459e-02f, 6.73045963e-02f, 7.27183074e-02f, -1.02856927e-01f, 1.10439152e-01f, -1.08916163e-02f, -2.66487617e-02f, -6.14515133e-02f, 1.23416362e-02f,
  -3.16548020e-01f, -2.67657816e-01f, 1.33501261e-01f, -5.25036678e-02f, 6.29701419e-03f, -8.71847421e-02f, -7.64669105e-02f, -2.99783479e-02f, -2.90011726e-02f, -4.30926271e-02f,
  -1.27159044e-01f, -8.81695896e-02f, 1.59137289e-03f, 6.95004500e-03f, -9.85117406e-02f, -1.34048268e-01f, 3.87432948e-02f, 1.16207756e-01f, 4.48095836e-02f, -6.78815842e-02f,
  8.13842844e-03f, -1.85928196e-01f, -2.24585041e-01f, 5.03812395e-02f, 1.39670167e-02f, 8.51763040e-02f, -1.01591662e-01f, -5.05549684e-02f, -9.31364298e-02f, -2.49805376e-01f,
  -1.20904803e-01f, 5.72826713e-02f, 2.22924855e-02f, -2.49846466e-02f, 4.55745086e-02f, 1.59828831e-02f, 1.18616812e-01f, -1.84900053e-02f, -4.74467175e-03f, -1.22552536e-01f,
  1.99132543e-02f, -3.76137123e-02f, -2.28445176e-02f, -1.87243745e-02f, -1.72400363e-02f, -7.92010203e-02f, -5.37547879e-02f, 7.91566167e-03f, -8.08427632e-02f, -5.41299246e-02f,
  4.22008187e-02f, 9.98973921e-02f, -5.46359341e-04f, 8.42366964e-02f, 6.47323206e-02f, 4.00239974e-02f, -3.77256386e-02f, -1.30775064e-01f, -2.04914939e-02f, -1.64227217e-01f,
  -6.98597403e-03f, 1.79818511e-01f, -2.19491482e-01f, -6.00343049e-02f, -1.29724294e-01f, 4.20026062e-03f, 1.86731014e-02f, 3.47690396e-02f, -7.86955561e-03f, -3.57614160e-02f,
  -1.91157877e-01f, -4.88190614e-02f, -2.88537592e-02f, 9.88353863e-02f, -4.33423817e-02f, -4.90715019e-02f, -7.84586966e-02f, 1.66513659e-02f, 1.33964687e-03f, -1.51398659e-01f,
  5.51924258e-02f, -1.56314179e-01f, -1.53842762e-01f, -6.53050020e-02f, -9.71018225e-02f, 6.10771589e-02f, -4.84547988e-02f, -1.52848691e-01f, -7.52483159e-02f, -2.42725983e-01f,
  -3.56029416e-03f, -2.42871702e-01f, -9.37180519e-02f, -2.07632110e-01f, -1.58704951e-01f, -2.13209286e-01f, -2.90537328e-01f, -9.26840976e-02f, -1.36956647e-01f, -3.15360934e-01f,
  4.48972285e-02f, 3.01307082e-01f, 1.49079144e-01f, 1.65281773e-01f, 1.41525894e-01f, -2.87770897e-01f, -3.09231281e-01f, 7.84867704e-02f, 3.06872874e-01f, 7.39175752e-02f,
  -1.36128650e-03f, -1.28457308e-01f, 5.28237298e-02f, -2.80273370e-02f, -2.47733966e-01f, -3.23865861e-02f, -3.02675098e-01f, -1.87715009e-01f, -1.12732790e-01f, -3.32455784e-01f,
  1.05419442e-01f, -8.59478116e-02f, 5.74053191e-02f, 2.77052373e-02f, -9.46725085e-02f, 8.96989480e-02f, 1.28553078e-01f, -5.98011278e-02f, -1.88192888e-03f, -7.48182163e-02f,
  -5.58006391e-02f, 9.06272605e-02f, 5.24155013e-02f, -3.00132446e-02f, -1.12498768e-01f, 1.53935207e-02f, -2.46841967e-01f, -7.05210268e-02f, -5.46189360e-02f, -8.93126335e-03f,
  -4.15338911e-02f, -1.11517562e-02f, 1.01109520e-02f, -1.05904177e-01f, 1.46829516e-01f, 1.18709035e-01f, -6.44934699e-02f, -3.21210548e-02f, 1.86646655e-02f, -1.84695601e-01f,
  -3.40039097e-02f, 1.84496008e-02f, -2.41184738e-02f, 5.16005680e-02f, -2.22284719e-02f, 1.92729793e-02f, 8.28882977e-02f, 3.69235799e-02f, 5.61257778e-03f, -5.46836890e-02f,
  2.95571610e-02f, -5.76700456e-02f, 9.36950073e-02f, -3.46718309e-03f, 8.04853439e-03f, -1.24949096e-02f, -6.27043769e-02f, 4.44955043e-02f, -4.07813936e-02f, -1.63484942e-02f,
  -1.33480504e-02f, -4.50567603e-02f, 5.40616782e-03f, 1.57221481e-01f, -3.94149907e-02f, 2.74998453e-02f, -6.66420460e-02f, 8.81878212e-02f, -3.63604352e-02f, -6.99101463e-02f,
  3.47745806e-01f, -1.73645224e-02f, 4.22807820e-02f, 1.60674676e-01f, -2.83164922e-02f, -9.34543684e-02f, -1.06935631e-02f, 3.15889083e-02f, 1.03030885e-02f, 1.72946951e-03f,
  3.49734956e-03f, -2.72674840e-02f, -6.16584681e-02f, -6.06057532e-02f, 3.45986076e-02f, 3.89532223e-02f, -1.13457702e-01f, 1.03672452e-01f, -6.82769716e-02f, -1.23736784e-01f,
  -1.72708750e-01f, 3.54796872e-02f, 1.67245984e-01f, 7.17732236e-02f, -1.70334857e-02f, 2.21346095e-01f, 1.06625579e-01f, 9.01420787e-02f, 1.95817292e-01f, -5.04584005e-03f,
  -1.10088468e-01f, 2.47741550e-01f, -6.64720908e-02f, -7.45889470e-02f, -2.47390896e-01f, -2.00127259e-01f, -3.01450752e-02f, -1.06972337e-01f, -2.02247445e-02f, 2.39212096e-01f,
  1.22696623e-01f, -6.03129715e-02f, 1.25753641e-01f, -1.21111795e-01f, -1.79300636e-01f, 8.92346129e-02f, -6.13201410e-02f, -3.09928834e-01f, -4.96398151e-01f, -3.49350035e-01f,
  -1.94955736e-01f, -1.90215170e-01f, -2.40566134e-01f, -1.26806855e-01f, 3.85769233e-02f, -2.69485395e-02f, 1.31745413e-01f, -6.60814717e-02f, -1.23111263e-01f, 6.16638921e-02f,
  1.10974550e-01f, -9.08886790e-02f, -7.84680024e-02f, -8.80431235e-02f, -2.66211219e-02f, -4.79678921e-02f, -6.70472684e-04f, 7.90654030e-03f, 1.53577905e-02f, -6.75738603e-02f,
  -1.08850934e-01f, -1.24737427e-01f, -1.13882497e-01f, -7.14363083e-02f, -1.14551440e-01f, -8.29631537e-02f, 1.47416918e-02f, -1.82641804e-01f, -1.18772514e-01f, -1.52601739e-02f,
  -1.88638732e-01f, -2.45953277e-01f, 3.43604572e-02f, 2.74743866e-02f, -2.47296020e-02f, -7.50475228e-02f, -2.01857090e-02f, -7.90965185e-02f, -6.94679171e-02f, 2.13396311e-01f,
  5.45627698e-02f, 6.46159649e-02f, 6.40563145e-02f, 9.18483883e-02f, 1.00554943e-01f, 5.87590300e-02f, 7.05114603e-02f, 9.10784081e-02f, 1.21877883e-02f, 1.10184491e-01f,
  4.10634242e-02f, 4.11875993e-02f, 5.73236160e-02f, -2.22570705e-03f, 7.74817467e-02f, -2.56547816e-02f, 6.38100654e-02f, 1.30021393e-01f, 3.20548862e-02f, 9.11046490e-02f,
  -2.82711480e-02f, 8.08652788e-02f, 1.06180944e-01f, 1.13332085e-01f, 2.92586326e-03f, 1.34278247e-02f, -9.93675962e-02f, -8.23108330e-02f, 3.90675887e-02f, -3.45134772e-02f,
  1.98530436e-01f, -1.56341031e-01f, 9.97445360e-02f, -4.00440656e-02f, -9.99623537e-02f, -1.25235289e-01f, 1.90848202e-01f, 4.25094925e-03f, 9.19820219e-02f, 6.36252537e-02f,
  -4.54263389e-02f, 7.62541667e-02f, 3.84466611e-02f, -3.18000019e-02f, -1.33488208e-01f, -1.33085400e-01f, -9.58214626e-02f, -6.63489774e-02f, -1.32817671e-01f, 3.25805321e-02f,
  -1.58758964e-02f, -4.82650734e-02f, 1.93434149e-01f, 2.51150846e-01f, -3.32234688e-02f, 8.48312154e-02f, 1.82200670e-01f, 8.24035034e-02f, 8.47874116e-03f, 3.18329871e-01f,
  8.21953177e-01f, 2.64713287e-01f, -9.21145156e-02f, 2.11936548e-01f, -3.33574682e-01f, -2.36508340e-01f, -1.14683911e-01f, 2.14921221e-01f, 1.73835963e-01f, -5.86922504e-02f,
  -2.95456462e-02f, 6.48988634e-02f, 8.16361010e-02f, 1.49915576e-01f, 3.53360921e-01f, 3.77845839e-02f, -8.52710288e-03f, 2.36809358e-01f, 5.97017296e-02f, -1.75702557e-01f,
  -1.94698140e-01f, 5.96902855e-02f, 3.05219740e-01f, 1.40009269e-01f, -2.53174096e-01f, -9.97434631e-02f, -9.52284038e-02f, -1.25564873e-01f, -1.37063026e-01f, -8.90347138e-02f,
  -4.12006795e-01f, -2.69685667e-02f, 3.86998034e-03f, 8.19022655e-02f, -9.02311429e-02f, 1.99761197e-01f, 1.14683192e-02f, 9.60802361e-02f, -3.33832726e-02f, -9.23331454e-02f,
  -3.14062648e-02f, -7.86752924e-02f, -1.51479527e-01f, -2.68474314e-02f, -1.48346961e-01f, -2.79795751e-02f, -1.06543750e-01f, 7.17983693e-02f, 5.75672202e-02f, -9.88978669e-02f,
  -2.33173594e-01f, -6.98757097e-02f, -1.22870812e-02f, 2.81811208e-02f, 2.91483402e-02f, -8.30611959e-02f, -2.47444008e-02f, -1.64268054e-02f, 9.58725139e-02f, 1.39894843e-01f,
  -8.06515887e-02f, -7.74946436e-02f, -2.00527579e-01f, -4.79620025e-02f, 5.61607592e-02f, -2.34352108e-02f, -1.78788394e-01f, -4.14853580e-02f, -8.90414566e-02f, 1.09263733e-02f,
  -7.36897811e-02f, -1.51865885e-01f, -1.02108270e-01f, -6.11665770e-02f, -2.76759919e-02f, -1.04770586e-01f, -5.83829097e-02f, -1.10669538e-01f, -3.91578823e-02f, -3.11590470e-02f,
  -2.30040848e-02f, -8.76266658e-02f, -1.22193180e-01f, -1.76288158e-01f, -9.28304121e-02f, -1.02463372e-01f, -1.01958863e-01f, -9.84996259e-02f, 3.11615225e-02f, 1.07074954e-01f,
  -2.49050066e-01f, -2.18212213e-02f, -6.69151098e-02f, 1.08231664e-01f, -3.46619226e-02f, 4.11829837e-02f, -8.19690824e-02f, -3.37849706e-02f, 3.68101411e-02f, -3.38285007e-02f,
  -1.15127694e-02f, -4.60411645e-02f, -2.71793175e-02f, -1.33474633e-01f, -6.84992224e-02f, -1.10468805e-01f, 4.65053283e-02f, 1.40927248e-02f, -3.92488129e-02f, -1.61149159e-01f,
  -1.37989288e-02f, 7.39356829e-03f, 1.89279348e-01f, 6.28789216e-02f, -7.78364064e-03f, 1.51368886e-01f, -7.34411702e-02f, 1.15441289e-02f, -3.12669761e-03f, 2.20803812e-01f,
  -4.35408115e-01f, 1.04382902e-01f, -9.11837071e-02f, -5.48424982e-02f, 5.54783754e-02f, 1.42022654e-01f, 3.99252683e-01f, 5.89328557e-02f, -1.07509919e-01f, 1.11968383e-01f,
  -2.12344855e-01f, -4.90247719e-02f, -1.08103044e-01f, -3.37329060e-02f, 7.52408011e-03f, 2.74201006e-01f, 1.14873677e-01f, -1.50332525e-01f, 2.87750568e-02f, 2.01567188e-02f,
  1.28397390e-01f, -2.04759948e-02f, -2.76781023e-01f, -7.74689317e-02f, -2.72687133e-02f, 1.94002632e-02f, 7.50882998e-02f, -1.75395697e-01f, -1.06390730e-01f, -5.17993188e-03f,
  1.30347669e-01f, -3.79711926e-01f, -7.20991055e-03f, -1.99831724e-01f, -8.53514820e-02f, -1.85401306e-01f, -1.30844906e-01f, -1.45315528e-01f, -4.35721874e-02f, 4.60967273e-02f,
  -2.86521800e-02f, -9.66810808e-02f, -8.56249779e-02f, 4.50249687e-02f, 1.05193920e-01f, -2.40600873e-02f, -5.17227016e-02f, -1.04157954e-01f, -1.25683457e-01f, -1.12617142e-01f,
  3.46864276e-02f, -2.01835454e-01f, -7.24945813e-02f, -4.71746139e-02f, -4.94847558e-02f, -1.14277072e-01f, -3.64283472e-02f, -3.71238105e-02f, -3.23822722e-02f, 5.20348251e-02f,
  -4.46482003e-02f, 1.40152544e-01f, -7.39145204e-02f, 1.18060941e-02f, -4.84901741e-02f, 6.28221110e-02f, 1.33311659e-01f, 4.45891246e-02f, 5.70306694e-03f, -1.72104128e-02f,
  4.84790467e-02f, -1.11018039e-01f, 2.70259250e-02f, -8.20918381e-02f, -8.64015892e-02f, -1.27807498e-01f, -9.40697491e-02f, -9.77593586e-02f, -4.60758694e-02f, -2.62504369e-02f,
  -3.94534394e-02f, -3.56801413e-02f, -2.24677231e-02f, 1.66709833e-02f, -1.00745991e-01f, -1.65890619e-01f, -7.80881718e-02f, -1.46965444e-01f, 4.36975546e-02f, 2.62221433e-02f,
  3.19413006e-01f, -3.15911502e-01f, 1.61354885e-01f, 6.71484545e-02f, -1.35477990e-01f, -1.43953636e-01f, -1.95882544e-01f, -1.00663379e-01f, -1.19458310e-01f, -9.89860371e-02f,
  -1.93102300e-01f, -1.82638001e-02f, 5.01954891e-02f, 4.03792821e-02f, 1.23910747e-01f, -5.11625744e-02f, 3.20929512e-02f, 8.30714256e-02f, -7.58271571e-03f, 1.28542304e-01f,
  -1.83535498e-02f, 1.04091682e-01f, 2.00042188e-01f, 2.05091581e-01f, 1.09445132e-01f, 1.23390086e-01f, 1.80539563e-01f, 6.54470846e-02f, 1.40053496e-01f, 2.92283863e-01f,
  7.64823034e-02f, -1.13700159e-01f, 2.17123721e-02f, 9.29828584e-02f, 2.52835895e-03f, 9.81821716e-02f, 4.94517908e-02f, -3.27424146e-02f, -1.15397200e-02f, 1.46384135e-01f,
  1.75813392e-01f, 1.76124886e-01f, 1.17986321e-01f, 1.41029418e-01f, -9.27074347e-03f, -4.16821092e-02f, 1.01889789e-01f, 4.91719246e-02f, 1.78618029e-01f, 1.47474512e-01f,
  -8.54399893e-03f, -6.07932322e-02f, -7.39165246e-02f, 9.09546018e-02f, -2.56997030e-02f, 5.54140024e-02f, -7.07947537e-02f, 7.59495348e-02f, -4.21632938e-02f, -3.38325761e-02f,
  3.38692635e-01f, 4.69094813e-02f, 7.90817589e-02f, -5.52974753e-02f, 2.35141758e-02f, -1.03054650e-01f, 2.88765933e-02f, -3.77836898e-02f, -5.18632345e-02f, -3.00166290e-03f,
  -5.13148792e-02f, 1.68401580e-02f, -9.22133103e-02f, -4.44232151e-02f, -4.65924805e-03f, 6.46006986e-02f, 2.08797026e-02f, 6.18918389e-02f, 1.05933040e-01f, 1.08759053e-01f,
  5.76390624e-02f, 1.30619943e-01f, 2.13743553e-01f, 9.49338749e-02f, 1.03240125e-01f, 1.14166841e-01f, 9.00653005e-02f, 7.63010606e-02f, 4.82798405e-02f, 1.66502967e-01f,
  3.07135969e-01f, 9.69588831e-02f, -3.65463905e-02f, -5.23293670e-03f, -1.10237420e-01f, -2.25909352e-02f, -5.10883750e-03f, 1.59796737e-02f, 5.81011847e-02f, -1.57596529e-01f,
  5.68930060e-03f, 8.29083174e-02f, -2.46428642e-02f, -8.63634143e-03f, -2.02638004e-02f, 3.53784375e-02f, -1.20627182e-02f, 3.03735975e-02f, -6.20316598e-04f, -5.49295209e-02f,
  -6.58525387e-04f, -5.68001606e-02f, -7.52011240e-02f, -1.25456333e-01f, -5.69948889e-02f, 9.06469449e-02f, 5.04398867e-02f, -1.13785021e-01f, -1.19843252e-01f, -8.64412636e-02f,
  1.44628674e-01f, -6.65871706e-03f, 8.07563588e-03f, -7.47137796e-03f, 3.56772467e-02f, -1.78554296e-01f, -3.64569686e-02f, -1.73147529e-01f, -7.86453411e-02f, -5.30924350e-02f,
  -2.02386640e-02f, -1.37110323e-01f, -4.44679186e-02f, 3.41168270e-02f, -1.74633006e-03f, 8.24386403e-02f, -3.23431455e-02f, 8.82817432e-02f, -3.01062241e-02f, -2.65854206e-02f,
  -9.44342166e-02f, 1.50845036e-01f, 1.35825709e-01f, 5.89248948e-02f, 3.23126130e-02f, 1.57682538e-01f, 8.43886733e-02f, 9.37387869e-02f, 7.86744431e-02f, -2.45748851e-02f,
  -2.90599734e-01f, -1.24646723e-01f, 6.72048852e-02f, 2.87241429e-01f, 1.85165912e-01f, 2.64201075e-01f, 1.88411608e-01f, 2.60473996e-01f, 2.39390418e-01f, 1.29623100e-01f,
  1.08631384e-02f, 6.54186010e-02f, 7.88652599e-02f, 6.39599636e-02f, 1.67871058e-01f, 1.47613108e-01f, 2.67757475e-01f, 1.43406302e-01f, 1.18340336e-01f, 1.18758641e-01f,
  1.14265785e-01f, 2.00278126e-02f, -1.19014151e-01f, 5.34608327e-02f, 1.95456013e-01f, 1.34212360e-01f, 8.46646875e-02f, 1.37549028e-01f, 2.94102244e-02f, 1.29880011e-01f,
  -1.70499936e-01f, -1.34646535e-01f, 1.40549049e-01f, -8.39018170e-03f, -1.98072881e-01f, -1.74185455e-01f, 1.50985196e-02f, -3.23848538e-02f, -7.28257298e-02f, 2.77179088e-02f,
  -1.20101459e-01f, -7.93145970e-02f, 9.15274210e-03f, -8.69481266e-02f, -5.90933189e-02f, -3.09221931e-02f, -1.20535120e-01f, 3.90937962e-02f, 8.07716027e-02f, -1.27516255e-01f,
  3.86912785e-02f, -9.26470757e-02f, 1.18987150e-01f, 1.23437271e-02f, -7.60043934e-02f, -2.37644371e-02f, -1.66750187e-03f, -1.05687976e-02f, 8.97571743e-02f, 5.08122891e-02f,
  1.61991939e-01f, 4.38142829e-02f, -4.24127020e-02f, -1.76619496e-02f, -2.28765272e-02f, 4.78426591e-02f, 1.22229412e-01f, 1.33668007e-02f, 1.72700018e-01f, -6.71809390e-02f,
  1.01559065e-01f, -3.31909209e-02f, -5.37276678e-02f, 8.09168220e-02f, 2.99488176e-02f, -7.81825706e-02f, 3.62900235e-02f, -1.40123323e-01f, -1.90986350e-01f, -5.89613132e-02f,
  -4.93555889e-02f, 9.40512568e-02f, -7.66504556e-02f, 1.53042730e-02f, -1.16808616e-01f, 9.41121718e-04f, -1.42164538e-02f, -1.84061974e-02f, -9.49130487e-03f, 6.87181577e-02f,
  2.65147477e-01f, -1.13118969e-01f, 9.98491719e-02f, 4.48686518e-02f, -1.73777759e-01f, -1.43217847e-01f, -1.40351444e-01f, -1.02002420e-01f, -2.23467443e-02f, 8.96988884e-02f,
  -2.93035135e-02f, -1.24171432e-02f, -5.29190451e-02f, 6.37482405e-02f, 1.10570416e-01f, -1.13823555e-01f, -2.27975801e-01f, 5.30024171e-02f, -1.49053009e-03f, 2.01316318e-04f,
  -7.87220057e-03f, 1.30757704e-01f, 1.76841989e-01f, 1.67560786e-01f, 9.48945880e-02f, 1.98098779e-01f, 4.71975133e-02f, -3.68508361e-02f, -1.47942537e-02f, 4.06996123e-02f,
  4.40657914e-01f, -3.17014873e-01f, -2.41746590e-01f, -2.53478378e-01f, -3.19207728e-01f, -1.58028513e-01f, -2.47851446e-01f, -9.93205756e-02f, 2.04858650e-02f, -3.07791144e-01f,
  -6.67725429e-02f, 2.32223198e-02f, 2.09715683e-02f, 9.28478837e-02f, 3.83480340e-02f, -2.17893973e-01f, -1.86956555e-01f, 2.29645148e-01f, 2.64955789e-01f, -8.18171725e-02f,
  -2.44081452e-01f, -1.91296246e-02f, 1.38879329e-01f, 8.59370381e-02f, -3.43241990e-01f, -1.04206331e-01f, -2.67840832e-01f, -1.42264247e-01f, -2.35871449e-01f, -3.23184401e-01f,
  -2.15528369e-01f, 2.03872129e-01f, 1.47408903e-01f, 1.56760409e-01f, 1.02126524e-01f, 1.34282947e-01f, -6.21555839e-03f, -3.13345045e-02f, 9.91030782e-02f, -9.90993306e-02f,
  3.11942864e-02f, 9.31416005e-02f, 3.30863371e-02f, 3.95286269e-02f, 4.50775735e-02f, 1.33143306e-01f, 7.32628331e-02f, 6.98571354e-02f, 2.00198200e-02f, -8.09549466e-02f,
  -7.59411082e-02f, 7.54703060e-02f, 2.47615343e-03f, 1.28381878e-01f, 1.02039084e-01f, 2.16421410e-01f, 2.77169552e-02f, 1.40650079e-01f, 1.07225567e-01f, -2.45622359e-02f,
  -2.98221055e-02f, 6.56918883e-02f, 4.99748327e-02f, 2.15709116e-02f, 8.60837176e-02f, 5.63245192e-02f, 6.33176463e-03f, -6.62062084e-04f, 4.72810417e-02f, 3.01404204e-02f,
  -3.19101885e-02f, -4.53807488e-02f, 1.14111595e-01f, -5.40324263e-02f, 1.01512037e-01f, 1.87977217e-02f, 3.03107407e-02f, 2.64819693e-02f, 6.26484975e-02f, 7.42868893e-03f,
  1.93761557e-01f, -2.90523823e-02f, -1.31455824e-01f, 7.73893262e-04f, 2.15671472e-02f, -8.61928388e-02f, 1.83601200e-03f, 4.15430628e-02f, 1.13376686e-02f, -9.93042067e-03f,
  -1.53296307e-01f, 2.81883419e-01f, -3.58179770e-02f, 4.93688919e-02f, -2.38318322e-03f, -2.94534024e-02f, 2.00714879e-02f, -4.41280752e-02f, -1.29000330e-02f, -3.65506224e-02f,
  1.49729224e-02f, 6.48041442e-02f, 8.16169307e-02f, -7.34971240e-02f, 2.51619555e-02f, 2.98212301e-02f, 1.04805611e-01f, -2.51576509e-02f, -1.36643443e-02f, -5.87692931e-02f,
  3.48952115e-02f, 2.81858835e-02f, 1.70119867e-01f, 7.83772767e-02f, 1.45790085e-01f, 1.99211583e-01f, 8.16284865e-02f, -4.05056700e-02f, 1.13898151e-01f, -2.04053838e-02f,
  2.58904576e-01f, -1.60933286e-01f, -4.42876369e-01f, -2.14062586e-01f, -2.13993192e-01f, -3.58183384e-02f, 4.88847457e-02f, 9.77460220e-02f, -6.11306541e-02f, -4.39231955e-02f,
  4.31127995e-02f, 2.90845752e-01f, 1.20363325e-01f, 1.79701433e-01f, 2.28290930e-01f, -5.90339266e-02f, -2.83070028e-01f, -9.74203423e-02f, 2.55642384e-01f, 1.60863534e-01f,
  6.11625165e-02f, 6.88394308e-02f, 7.75949657e-02f, 1.00482488e-02f, -2.59890169e-01f, -1.89450923e-02f, -3.17426831e-01f, -2.71183670e-01f, -1.34739563e-01f, -3.82027656e-01f,
  1.81733556e-02f, -2.28719234e-01f, -6.45863563e-02f, 5.22323251e-02f, -1.91719368e-01f, 8.40901956e-02f, 5.44793904e-02f, -1.66650161e-01f, -5.06347194e-02f, -9.08859372e-02f,
  -2.24883091e-02f, 1.53565146e-02f, -7.13314675e-03f, 2.48980448e-02f, -1.01100929e-01f, 1.00636315e-02f, -1.04686730e-01f, -3.98668684e-02f, -4.43268344e-02f, -1.97169203e-02f,
  1.66832022e-02f, -7.84157664e-02f, -1.81678057e-01f, -2.04022810e-01f, -1.66017890e-01f, -9.97421071e-02f, -1.73976138e-01f, -1.37633294e-01f, -9.69113931e-02f, -2.01662913e-01f,
  7.90048763e-03f, -1.26138180e-01f, -6.14677183e-02f, 1.12520255e-01f, 3.69819291e-02f, 2.17483584e-02f, -3.86887267e-02f, 5.76670542e-02f, 7.19158277e-02f, -1.25367846e-02f,
  2.95898337e-02f, -3.04618757e-02f, -6.17845766e-02f, 8.42872635e-03f, -7.92257860e-02f, -7.41627887e-02f, 1.28258303e-01f, 1.84571836e-02f, -3.93641256e-02f, -4.31276262e-02f,
  2.70805974e-02f, -1.07845038e-01f, -5.29749170e-02f, 4.48476784e-02f, -7.39243999e-02f, -4.86531742e-02f, -4.81615737e-02f, 8.84062946e-02f, 7.78472573e-02f, 9.20021813e-03f,
  3.04671824e-01f, -1.46722775e-02f, -1.12148216e-02f, 9.51380581e-02f, -8.38567019e-02f, -3.84344510e-03f, -2.15232186e-02f, 6.06273226e-02f, 3.74273956e-02f, 5.92685342e-02f,
  7.25964606e-02f, 1.44466594e-01f, -3.68388258e-02f, -4.83458564e-02f, 1.01642027e-01f, 2.69901063e-02f, 1.05104007e-01f, 5.95851317e-02f, -2.80903727e-02f, -6.72813803e-02f,
  -1.22029394e-01f, 1.40865892e-01f, 1.14827663e-01f, -2.00812221e-02f, 1.68579295e-02f, 1.65417343e-01f, 6.12891167e-02f, 4.37960289e-02f, 2.30005369e-01f, 2.05327198e-01f,
  -5.82277536e-01f, -2.88472269e-02f, 3.60823013e-02f, -5.30945361e-01f, -2.48409286e-01f, -6.75856322e-02f, 9.53783914e-02f, -2.11802330e-02f, -1.08733095e-01f, 5.05850725e-02f,
  2.47458085e-01f, 5.87536879e-02f, 2.14519631e-02f, 2.31246911e-02f, -1.33265611e-02f, 3.01747750e-02f, -1.54084101e-01f, -1.11666501e-01f, -6.25508279e-02f, 4.04359177e-02f,
  -9.10036489e-02f, -2.63552099e-01f, -3.25454026e-01f, -9.23329443e-02f, -1.43089116e-01f, -7.08749741e-02f, -5.07353432e-02f, -2.06279427e-01f, -2.12231148e-02f, -1.91322789e-01f,
  2.79225677e-01f, -3.34780991e-01f, -8.03893507e-02f, -1.97860479e-01f, -1.08461022e-01f, 2.31530722e-02f, -6.31384738e-03f, -1.59645468e-01f, 4.01613936e-02f, 7.08209956e-03f,
  -7.35424682e-02f, 5.17123491e-02f, -7.11418465e-02f, 4.69193906e-02f, -5.66959567e-02f, 1.22595485e-02f, -3.21586505e-02f, -2.97337417e-02f, -1.30580347e-02f, 3.08467716e-01f,
  9.16006193e-02f, -2.08586100e-02f, -5.47249988e-03f, 9.26261991e-02f, 3.46499383e-02f, -1.12254068e-01f, 1.34181827e-01f, -6.21751361e-02f, 1.09850531e-02f, -2.56926399e-02f,
  3.12470645e-02f, 6.50883988e-02f, 2.55825873e-02f, -8.60694200e-02f, -6.09859033e-03f, 8.22195932e-02f, -5.58973514e-02f, 2.07458772e-02f, 5.13079539e-02f, -1.24566127e-02f,
  3.03230137e-02f, 1.03518173e-01f, -7.49679804e-02f, -8.25306550e-02f, -2.22374331e-02f, -6.58709705e-02f, 1.95309278e-02f, 8.88271108e-02f, -4.99339886e-02f, -4.23786528e-02f,
  -5.73341548e-02f, -2.92940550e-02f, -1.46286890e-01f, 6.01575561e-02f, -8.02050829e-02f, -4.44037206e-02f, 9.19720232e-02f, 1.23791974e-02f, 7.29617104e-02f, 9.43601280e-02f,
  2.48597818e-04f, -1.29282683e-01f, -1.72103010e-02f, -6.20835274e-02f, -3.80177908e-02f, 1.86023965e-01f, -1.95870418e-02f, -1.98489819e-02f, -1.41370699e-01f, -1.83471367e-02f,
  -4.24179627e-04f, -7.95597881e-02f, -4.71444316e-02f, 4.01862338e-02f, -4.72769961e-02f, 7.81755224e-02f, 7.90777653e-02f, -1.24796011e-01f, 9.33142304e-02f, 1.12797365e-01f,
  1.15063652e-01f, -5.19062951e-02f, 1.60362385e-02f, 1.18464530e-01f, 8.70752186e-02f, -1.84837785e-02f, 1.05558038e-01f, 1.35983676e-01f, 4.59589884e-02f, 9.98645052e-02f,
  -3.37618291e-01f, -1.93105116e-01f, -1.91205636e-01f, -2.77508050e-01f, -1.59763433e-02f, 7.04168901e-02f, 1.59700250e-03f, 4.15949486e-02f, -5.83694577e-02f, -2.14989781e-01f,
  -5.71900085e-02f, 6.32028580e-02f, -1.43434465e-01f, -4.01995284e-03f, -6.45515844e-02f, -3.16246152e-01f, -2.79226989e-01f, -1.50418833e-01f, 1.01177089e-01f, 2.57897198e-01f,
  6.84867501e-02f, -9.63270739e-02f, -8.06305464e-03f, 9.94833484e-02f, -1.08016049e-02f, -5.80379069e-02f, -1.08137920e-01f, -9.45310220e-02f, -2.15451624e-02f, -3.05663317e-01f,
  -1.73867077e-01f, -2.89924294e-02f, 1.62810773e-01f, 4.76809032e-02f, -2.58813631e-02f, -1.43248113e-02f, -1.12852853e-04f, -2.64905412e-02f, 8.30857083e-02f, -9.47355926e-02f,
  4.27899882e-02f, 1.18218653e-01f, -6.42895624e-02f, 1.60683959e-03f, 4.56403196e-02f, 5.60181998e-02f, 4.30696225e-03f, -1.71181168e-02f, -4.28918973e-02f, 8.96964818e-02f,
  6.35103276e-03f, -6.33111224e-02f, -1.37979329e-01f, 3.47646661e-02f, 2.95978338e-02f, -1.27029559e-02f, 1.79888122e-02f, 2.19177976e-01f, 7.27061778e-02f, -1.26536727e-01f,
  -1.03956293e-02f, -7.95356855e-02f, 9.03065279e-02f, 1.66380946e-02f, 5.52556254e-02f, -1.88240167e-02f, -3.08141503e-02f, -2.09189896e-02f, 1.17654495e-01f, -5.15012294e-02f,
  1.51408296e-02f, 5.11878692e-02f, 5.45139890e-03f, -4.84284274e-02f, -7.37610087e-02f, -8.15454274e-02f, -4.07969318e-02f, -8.90039727e-02f, -5.68600073e-02f, 4.79683653e-02f,
  9.01266583e-04f, 1.16713271e-02f, -5.80091625e-02f, 1.39149940e-02f, -6.11913390e-02f, -8.37601423e-02f, -4.39334614e-03f, 4.68226038e-02f, 6.59139082e-02f, -3.09566073e-02f,
  -1.65813148e-01f, -6.36108145e-02f, -1.71928391e-01f, 1.06907442e-01f, -8.75310600e-02f, 5.05827703e-02f, -4.16466631e-02f, 2.87574269e-02f, -1.39983401e-01f, 2.68003866e-02f,
  1.73017874e-01f, -1.06282815e-01f, -1.92048624e-01f, 7.84106255e-02f, 1.58252820e-01f, -8.48769769e-03f, -6.65972903e-02f, -5.07806726e-02f, 2.16482505e-02f, 3.14895734e-02f,
  -3.96508491e-03f, -1.57785267e-01f, -1.41894475e-01f, -1.30254254e-01f, 1.07173538e-02f, -2.10267641e-02f, -8.28924850e-02f, -2.88099907e-02f, -1.23530060e-01f, -2.83076972e-01f,
  -4.44116682e-01f, 3.15121233e-01f, 1.46779388e-01f, -1.33901760e-01f, 2.30313331e-01f, 6.65029436e-02f, -8.00890550e-02f, -1.97090909e-01f, -1.85131937e-01f, 1.16404966e-01f,
  1.22929879e-01f, 5.38865011e-03f, 3.55190784e-02f, -4.67803814e-02f, -8.51404890e-02f, 2.00366005e-01f, 1.65910751e-01f, -2.59048939e-02f, -2.55412906e-01f, -2.08806142e-01f,
  1.03305407e-01f, 2.01161802e-02f, -1.52968198e-01f, -5.43399788e-02f, 5.40516414e-02f, -4.50341702e-02f, 1.61618125e-02f, 1.15576901e-01f, 9.22979042e-02f, 2.97762364e-01f,
  -5.25061488e-02f, -1.94468424e-01f, -8.00641179e-02f, 1.59912109e-01f, 8.40075314e-02f, -1.53714955e-01f, -5.64983562e-02f, -6.14488795e-02f, -3.66068222e-02f, -9.59624723e-02f,
  1.73806056e-01f, -1.12559162e-02f, 8.45051482e-02f, -6.91423640e-02f, -1.62147865e-01f, -2.89904773e-01f, -6.95900247e-02f, -1.93358615e-01f, -2.24891469e-01f, -1.21177375e-01f,
  1.93864554e-01f, 1.18631408e-01f, -5.41346669e-02f, -1.15681343e-01f, -1.64024413e-01f, -1.08235843e-01f, -1.82338163e-01f, -1.15836322e-01f, -2.22013906e-01f, -1.53725088e-01f,
  -8.65775067e-03f, 7.14894757e-02f, -2.10229196e-02f, 3.80968936e-02f, -4.72831242e-02f, 4.58585322e-02f, 1.41219452e-01f, 9.21325013e-02f, 5.82034625e-02f, -3.31011526e-02f,
  9.60964859e-02f, -6.38414472e-02f, -2.70482209e-02f, 1.20558040e-02f, 2.23173257e-02f, -1.24083878e-02f, 9.19964686e-02f, 1.16450340e-01f, 2.21304726e-02f, -1.05787478e-02f,
  -2.46927198e-02f, 1.01150997e-01f, 4.66098525e-02f, 7.31658982e-03f, 1.06611550e-01f, 1.44032845e-02f, 1.48726450e-02f, -1.13725811e-01f, -1.73337162e-02f, 4.74825501e-02f,
  -2.43724078e-01f, 9.86997113e-02f, -1.56189725e-01f, -2.86017749e-02f, 7.58966953e-02f, -5.32543473e-02f, 6.40019774e-02f, -1.16801988e-02f, 5.25683388e-02f, -1.48323491e-01f,
  -9.57643017e-02f, 2.05784608e-02f, -3.31964158e-02f, -4.81283069e-02f, -1.57901064e-01f, -7.64247850e-02f, 9.08007249e-02f, -3.11209019e-02f, 3.03578842e-02f, -2.20128242e-02f,
  6.87417015e-02f, -2.67506182e-01f, -2.43803576e-01f, -1.37138292e-01f, -6.11566342e-02f, -1.39394835e-01f, -1.50617167e-01f, -1.87346324e-01f, -2.15611324e-01f, -3.31428498e-01f,
  1.31457895e-01f, 2.82268389e-03f, -4.37036872e-01f, 8.86247680e-02f, -1.72315091e-01f, -2.66627610e-01f, -1.95537567e-01f, 7.71872178e-02f, 2.50107139e-01f, -2.15947889e-02f,
  -8.98060948e-02f, -5.59597462e-02f, -3.03908456e-02f, -1.51622474e-01f, -2.30061427e-01f, -2.07688242e-01f, -2.57660598e-01f, -3.89389843e-01f, -3.95213664e-01f, -2.50785291e-01f,
  -2.34671310e-01f, -3.36041637e-02f, -6.38937131e-02f, 1.55811571e-03f, 8.52470696e-02f, -5.22293709e-03f, 1.22912806e-02f, -6.85116798e-02f, -1.89848572e-01f, -7.89523274e-02f,
  -2.51611352e-01f, 4.54056375e-02f, -1.21171705e-01f, -3.22498893e-03f, -4.86469222e-03f, -2.22836565e-02f, -1.12319939e-01f, 4.25669514e-02f, 6.71873391e-02f, -1.34094600e-02f,
  -1.22063451e-01f, -1.09187484e-01f, -5.59267551e-02f, -4.86512929e-02f, -1.01607472e-01f, -1.25390157e-01f, -5.01579084e-02f, -1.22447416e-01f, -7.52212331e-02f, -1.19245470e-01f,
  -2.41474584e-01f, -1.94643348e-01f, -8.34068954e-02f, -4.59734127e-02f, -2.31677629e-02f, -1.61104798e-01f, 1.65624395e-02f, 8.59759599e-02f, 7.40343258e-02f, 2.42323801e-01f,
  7.12306648e-02f, 1.00692146e-01f, 7.12288246e-02f, 1.48271546e-01f, 6.89668730e-02f, 4.50091735e-02f, 7.04205856e-02f, -8.75906833e-03f, -2.74900198e-02f, 1.47808835e-01f,
  6.98341727e-02f, -5.60787506e-02f, 3.34432907e-02f, 1.58266518e-02f, -1.07756309e-01f, -2.64992025e-02f, -7.79085904e-02f, -2.21109968e-02f, 1.42042274e-02f, 4.04041074e-02f,
  -7.93079883e-02f, -6.05896190e-02f, -3.33964415e-02f, 1.93507597e-02f, -9.25170332e-02f, -1.86698567e-02f, 6.66445075e-03f, -5.36094466e-03f, -1.37647670e-02f, -1.18097648e-01f,
  1.30850792e-01f, -9.71945450e-02f, 3.80674042e-02f, 7.53597263e-03f, -1.54388193e-02f, 9.86279920e-03f, 4.01315242e-02f, 5.74106947e-02f, 3.23551334e-02f, -5.56244552e-02f,
  -1.91827878e-01f, 4.37268838e-02f, -5.02821710e-03f, 1.14845857e-02f, -1.32701904e-01f, -1.50561512e-01f, -9.42075104e-02f, -2.36779824e-02f, -8.42871293e-02f, -2.96922047e-02f,
  -1.70761166e-04f, -1.02479346e-01f, 5.77599406e-02f, 3.71147543e-02f, 7.88249075e-02f, 5.43457270e-03f, 8.56354949e-04f, 6.30102605e-02f, 3.92829776e-02f, 2.79045433e-01f,
  4.10541534e-01f, 1.54941857e-01f, 3.67964625e-01f, 1.16431966e-01f, -1.69376452e-02f, 8.26909319e-02f, 1.18238248e-01f, -3.42572778e-02f, -1.67326316e-01f, -5.06504141e-02f,
  -4.94568981e-02f, -1.72605798e-01f, -8.13808814e-02f, -9.28152427e-02f, 6.14577420e-02f, -2.18865406e-02f, 2.47365627e-02f, 1.54622212e-01f, 1.11496933e-01f, -4.17895336e-03f,
  -1.85650155e-01f, 5.85492030e-02f, 1.78690448e-01f, 2.32404862e-02f, -1.95346177e-02f, -3.19585055e-02f, 3.27080004e-02f, 1.38868898e-01f, -2.32524015e-02f, -2.46247239e-02f,
  1.88519970e-01f, 2.17370674e-01f, -2.41638169e-01f, -1.99375227e-01f, 4.17540036e-02f, -6.54776245e-02f, -2.66035907e-02f, -3.04686390e-02f, -1.20221779e-01f, -6.18832447e-02f,
  9.66219045e-03f, 4.85071279e-02f, 2.27996688e-02f, 1.22603863e-01f, 2.87546497e-02f, 1.11875691e-01f, 1.80347592e-01f, 1.39324710e-01f, -8.35050363e-03f, 6.06592335e-02f,
  2.38747969e-02f, 5.71538322e-02f, 9.80165154e-02f, 5.75864539e-02f, 9.27173793e-02f, 7.03341365e-02f, 1.56407133e-01f, 1.66564599e-01f, 1.61837265e-01f, 1.08494125e-01f,
  -7.74364844e-02f, -3.52986455e-02f, -1.07081281e-02f, 1.49654811e-02f, -5.81776127e-02f, 7.13809952e-02f, 1.10888720e-01f, 4.90303859e-02f, 9.47535336e-02f, 1.64697021e-01f,
  1.20564722e-01f, 1.05090179e-01f, 1.81123167e-01f, 1.04961596e-01f, 1.20483920e-01f, 2.18444601e-01f, 1.42735168e-01f, -1.32749742e-02f, 9.24325287e-02f, -5.51124895e-03f,
  1.88564155e-02f, 1.81044027e-01f, 1.94092259e-01f, 4.42144983e-02f, 6.37081787e-02f, 7.64032379e-02f, 1.48743868e-01f, 1.59334391e-01f, 1.66202396e-01f, 2.50481576e-01f,
  -1.70852631e-01f, 1.58274204e-01f, 6.19215928e-02f, -9.19835865e-02f, -4.56371531e-02f, 8.52778926e-02f, -4.94352207e-02f, -1.97318748e-01f, -1.05518132e-01f, -7.33857602e-02f,
  1.20317847e-01f, -1.62157658e-02f, 1.60559073e-01f, 1.45195946e-01f, 4.20259759e-02f, 1.99685413e-02f, -1.03974335e-01f, -8.08508098e-02f, -1.20123878e-01f, -3.43896970e-02f,
  -4.80378121e-02f, -9.37005356e-02f, -1.60215065e-01f, -2.03625392e-03f, 2.49769893e-02f, -3.42143048e-03f, -9.75207984e-02f, -6.27997220e-02f, 1.26911262e-02f, -8.67747143e-02f,
  5.31531692e-01f, 7.49784261e-02f, 2.25438416e-01f, 1.08315460e-01f, 6.16901666e-02f, 2.46310458e-01f, 1.57482281e-01f, 9.30302665e-02f, 6.96242005e-02f, 1.45829767e-01f,
  1.09991640e-01f, -2.39468906e-02f, 1.42715693e-01f, -3.04855476e-03f, 1.78898618e-01f, -4.74798232e-02f, -5.42652719e-02f, 7.41534159e-02f, 5.41148633e-02f, -7.01678023e-02f,
  -1.04034767e-01f, -1.62922814e-02f, 9.75260511e-02f, -4.40044142e-02f, -2.03030452e-01f, -3.25742885e-02f, -4.75062989e-02f, 5.64768016e-02f, 8.65462329e-03f, -1.60849825e-01f,
  1.83571681e-01f, 2.46177986e-01f, -5.44449128e-02f, -2.03074351e-01f, -4.21332952e-04f, -1.28446236e-01f, -5.81225418e-02f, -1.26335174e-01f, -9.02388766e-02f, -3.97863872e-02f,
  -1.65531933e-01f, 2.86174612e-03f, 3.90646197e-02f, -7.24360719e-02f, -5.46086431e-02f, 3.94589594e-03f, -5.72489798e-02f, 1.10643826e-01f, 2.95632426e-02f, -8.44631717e-03f,
  -1.78718165e-01f, -8.33272189e-02f, -1.01657109e-02f, 6.60767034e-02f, 1.43567696e-02f, -1.86050590e-02f, -3.15167755e-02f, 5.68291172e-02f, 3.56548242e-02f, 4.65366803e-02f,
  5.98303564e-02f, 7.21541196e-02f, 1.25720510e-02f, -8.15343671e-03f, -4.71956022e-02f, -6.96489215e-02f, -6.38582706e-02f, 1.03133731e-01f, 6.37582019e-02f, -9.97206420e-02f,
  1.11916009e-02f, 5.89470379e-02f, 8.98468122e-02f, 8.37817490e-02f, -6.90459535e-02f, 1.14890253e-02f, 7.57259578e-02f, 3.88810858e-02f, -2.47429274e-02f, 6.21833466e-03f,
  3.91194969e-02f, -7.56480545e-02f, -1.25156388e-01f, -1.37015045e-01f, 3.70730599e-03f, 9.36861038e-02f, -2.65466329e-02f, -7.04579502e-02f, -5.34274317e-02f, -1.20020226e-01f,
  -1.50735393e-01f, 2.03469440e-01f, -5.23313545e-02f, -3.52796428e-02f, -7.59171918e-02f, -5.53533919e-02f, 5.29634058e-02f, -9.07413438e-02f, -1.97628483e-01f, -7.80799091e-02f,
  2.05139276e-02f, -4.12891619e-02f, 6.80558756e-02f, -4.52594683e-02f, -5.43201575e-03f, -1.20592520e-01f, -9.92385596e-02f, 1.19799554e-01f, -1.00229634e-02f, -1.37254849e-01f,
  -1.88198835e-01f, 7.03318492e-02f, 1.05034329e-01f, 6.57924414e-02f, 1.64685603e-02f, -5.42136170e-02f, 3.47849801e-02f, -1.11546613e-01f, 6.77459985e-02f, -1.25511393e-01f,
  -2.83501118e-01f, 4.73979972e-02f, 1.97973296e-01f, -4.50262278e-02f, 6.73335940e-02f, -2.49179319e-01f, -3.02976459e-01f, -4.19468790e-01f, -1.61212862e-01f, 8.20646659e-02f,
  6.42337650e-02f, 6.56851754e-02f, 7.90369883e-03f, 5.32134715e-03f, -1.82548717e-01f, 8.15935507e-02f, 2.36863732e-01f, 1.47954309e-02f, -2.41940275e-01f, -2.93760508e-01f,
  -9.16650966e-02f, -6.47699311e-02f, -9.75488778e-03f, -9.25587043e-02f, 9.88637954e-02f, -1.55210169e-02f, 1.80595741e-01f, 1.06067300e-01f, 1.54990524e-01f, 2.72842109e-01f,
  2.44775638e-01f, -9.88145769e-02f, -1.56798899e-01f, 1.61500610e-02f, 1.60844818e-01f, -1.17733702e-01f, -4.11482267e-02f, -4.57870178e-02f, -3.07595599e-02f, -6.53235093e-02f,
  1.61944255e-01f, -6.69240132e-02f, 9.57537293e-02f, -6.38730973e-02f, -8.75849370e-03f, -3.28300864e-01f, -5.22530563e-02f, -1.05731346e-01f, -1.48459598e-01f, 1.99363511e-02f,
  9.84459743e-02f, 1.24429062e-03f, -1.01324096e-01f, -7.68500790e-02f, -1.01145200e-01f, 5.45150600e-02f, -1.46558851e-01f, -3.87667269e-02f, -1.66780412e-01f, -1.79735422e-01f,
  -5.46543784e-02f, 4.11952808e-02f, -5.99741340e-02f, -7.66596664e-03f, -5.94731756e-02f, 1.34792663e-02f, 1.30958751e-01f, -1.69054437e-02f, 5.69822602e-02f, -2.45951675e-02f,
  -1.95188485e-02f, -6.68987408e-02f, -4.69547398e-02f, -5.46693616e-02f, 3.53829488e-02f, 4.15888540e-02f, -5.34452125e-02f, -5.98261692e-02f, -1.85232945e-02f, -6.28420115e-02f,
  2.48473380e-02f, -2.85606608e-02f, 6.60051778e-02f, -1.15082338e-01f, 9.11206566e-03f, 3.95683898e-03f, 5.42902835e-02f, -5.83892167e-02f, 2.75167124e-03f, 2.32329983e-02f,
  -8.68543833e-02f, 1.66900814e-01f, -3.44074517e-02f, -3.74654345e-02f, 3.75019796e-02f, 8.02373588e-02f, -1.57084465e-02f, -1.63591001e-02f, -6.85733110e-02f, -3.12215127e-02f,
  -8.45466033e-02f, -8.00366476e-02f, -1.29813049e-03f, -2.44850833e-02f, -1.41845375e-01f, -8.02515354e-03f, -2.97170617e-02f, 4.00113501e-03f, -8.57270285e-02f, 5.81333414e-03f,
  3.86701599e-02f, -2.20753640e-01f, -2.41418332e-01f, -2.25148842e-01f, -9.01055783e-02f, -6.14637025e-02f, -1.79295748e-01f, -2.47467428e-01f, -2.78628618e-01f, -3.70994300e-01f,
  3.62635612e-01f, 7.26983771e-02f, 2.37890929e-01f, 1.91567808e-01f, 1.95946828e-01f, 1.82218596e-01f, 1.61152154e-01f, -3.97697426e-02f, 9.47892889e-02f, 1.22554839e-01f,
  8.79498869e-02f, 3.54430452e-02f, 4.48154137e-02f, 9.57417265e-02f, 3.08869276e-02f, 6.60598204e-02f, 1.79641157e-01f, 1.41156718e-01f, 1.36906356e-01f, 8.97343457e-02f,
  7.00617060e-02f, 8.27898681e-02f, 2.06991062e-01f, 1.07888080e-01f, 6.72644079e-02f, 8.88947248e-02f, 1.20678730e-01f, 5.80581278e-02f, 1.76609263e-01f, 1.97326690e-01f,
  -1.40115425e-01f, 3.39262001e-03f, 1.00773854e-04f, -1.24236360e-01f, 3.56639251e-02f, -1.05983138e-01f, -8.09357688e-02f, -9.45415944e-02f, -9.97005627e-02f, -9.94572118e-02f,
  -5.06868437e-02f, 4.09560762e-02f, 8.86037201e-02f, -2.80470960e-02f, 7.06679821e-02f, 2.04055551e-02f, -3.14095244e-02f, -6.08655922e-02f, -5.23851700e-02f, 1.10644638e-03f,
  -4.88986224e-02f, 2.64729699e-03f, -1.45486630e-02f, 1.83243435e-02f, -3.06324922e-02f, -4.71476652e-02f, -1.09314702e-01f, 7.35046566e-02f, -1.46790966e-02f, -3.13871801e-02f,
  -9.84958559e-02f, 2.48897076e-01f, 2.70526499e-01f, 1.17489584e-01f, 2.61877090e-01f, 2.46640965e-02f, 9.79588553e-02f, -2.97690537e-02f, 1.32057130e-01f, -4.51525263e-02f,
  -1.56265870e-02f, 8.68371222e-03f, -5.46112023e-02f, -7.55643100e-02f, 1.40400724e-02f, 9.02662650e-02f, -4.31158580e-02f, 3.21501233e-02f, 2.76977774e-02f, 3.72590274e-02f,
  6.21767994e-03f, 5.65289408e-02f, -4.05914150e-02f, -3.75592299e-02f, -1.19473577e-01f, 2.47689821e-02f, 3.65376994e-02f, -5.24032563e-02f, 7.72196129e-02f, 4.29197960e-02f,
  -3.38953644e-01f, -6.10665418e-02f, 1.48041518e-02f, -1.36623513e-02f, 2.46656630e-02f, -3.22125107e-02f, 4.45282422e-02f, -1.56359091e-01f, -3.74591388e-02f, 5.38932299e-03f,
  8.82720482e-03f, -7.02708811e-02f, -8.45918655e-02f, -3.48960608e-02f, 6.77333970e-04f, -1.42677963e-01f, -2.11507604e-02f, -2.86974832e-02f, -1.84562355e-01f, -1.61880210e-01f,
  -8.23315457e-02f, -1.72493845e-01f, -1.30035132e-01f, -1.37080103e-01f, -1.41053185e-01f, -1.27118617e-01f, -1.24530956e-01f, -9.20421880e-05f, -1.84369698e-01f, -1.31166711e-01f,
  -2.18009949e-01f, -3.56933147e-01f, 1.93190619e-01f, -1.95322677e-01f, 4.81286366e-03f, 2.10540101e-01f, 1.11498989e-01f, 2.37859897e-02f, -1.32503822e-01f, -1.21274211e-01f,
  4.14705686e-02f, 2.04368129e-01f, 1.12980299e-01f, 1.91531822e-01f, 1.61288410e-01f, 7.71261007e-02f, 3.60619240e-02f, 1.52598098e-01f, 1.96892172e-01f, 8.02207515e-02f,
  -1.11108974e-01f, -1.20520242e-01f, -8.72139931e-02f, -1.15028121e-01f, -2.26492777e-01f, 4.18183841e-02f, 4.62806746e-02f, 7.74933258e-03f, 6.73991963e-02f, -1.83085501e-01f,
  4.46598887e-01f, -7.27334023e-02f, 9.02837291e-02f, -4.03122008e-02f, -1.88876372e-02f, -9.73520577e-02f, -5.62503785e-02f, -4.68131043e-02f, -3.61937918e-02f, -1.79146398e-02f,
  -5.34167401e-02f, -1.43918931e-01f, 3.61505151e-02f, -3.24186571e-02f, -1.20599821e-01f, -1.28102466e-01f, -1.34716824e-01f, -4.74172235e-02f, 1.59685791e-01f, -5.12232957e-03f,
  -9.35807228e-02f, -7.32125044e-02f, 2.34197065e-01f, 9.46092233e-02f, 4.07308601e-02f, 1.17552862e-01f, 1.74934007e-02f, -1.02047592e-01f, -1.36189722e-02f, -1.20158680e-01f,
  -1.48114832e-02f, 3.81885432e-02f, -1.72505807e-02f, 1.00755878e-01f, 6.05216846e-02f, 8.32807645e-03f, 7.77796060e-02f, 1.56980857e-01f, 1.18172787e-01f, -1.29283637e-01f,
  1.78232063e-02f, 7.48801008e-02f, 2.36166045e-02f, 7.10739866e-02f, -3.77165191e-02f, 8.93303379e-02f, 5.95526882e-02f, -1.28604501e-01f, 8.86646844e-03f, 6.98738769e-02f,
  -2.35250555e-02f, 1.34530151e-02f, -1.46602243e-01f, -5.99710234e-02f, -8.56464058e-02f, -2.50530280e-02f, -6.63948432e-02f, 1.91821754e-02f, -6.87725917e-02f, -2.16164365e-02f,
  2.32770458e-01f, 2.70168364e-01f, 1.12241842e-01f, -3.34640928e-02f, -4.79297014e-03f, -1.71772256e-01f, 2.46851780e-02f, 4.54884320e-02f, 6.90858811e-02f, 1.47819906e-01f,
  -6.83753267e-02f, 1.83242687e-03f, -6.33378327e-02f, -1.41568825e-01f, -8.63910764e-02f, -2.10459959e-02f, -1.17167056e-01f, 8.50689504e-03f, 1.06417499e-01f, -8.23405161e-02f,
  -1.75365716e-01f, 5.87427355e-02f, 2.90601820e-01f, 1.85977131e-01f, 7.24722892e-02f, 7.36802071e-02f, 7.52631351e-02f, 4.51744646e-02f, 6.20717183e-02f, 1.77548286e-02f,
  -2.52434127e-02f, -2.81995654e-01f, -1.57991320e-01f, 3.29657823e-01f, 2.17020035e-01f, -1.57134861e-01f, -4.56078261e-01f, -2.37102494e-01f, 2.03406110e-01f, -8.98939371e-02f,
  1.06625922e-01f, 2.16141090e-01f, 1.52933165e-01f, -5.26284240e-02f, -3.44044149e-01f, -3.76323551e-01f, -1.67553470e-01f, -9.80177596e-02f, -7.38676935e-02f, -1.17581151e-03f,
  7.04937279e-02f, 1.29924253e-01f, 5.33847557e-03f, -3.38922851e-02f, 1.48973778e-01f, 1.14799604e-01f, -8.54556710e-02f, 8.73137042e-02f, -4.34260331e-02f, -1.70012005e-02f,
  4.68644872e-02f, -4.25749086e-02f, -3.09606120e-02f, 1.98870674e-01f, 1.03210397e-01f, 9.05780587e-03f, -8.75801593e-02f, -9.48011354e-02f, -7.15815648e-03f, -7.47557962e-03f,
  2.17988029e-01f, 7.44566321e-02f, 7.26894587e-02f, 8.88602361e-02f, -8.29079896e-02f, -1.61561728e-01f, -1.37914494e-01f, -1.70860916e-01f, -1.40459910e-01f, -1.05937958e-01f,
  1.08026072e-01f, 1.62845880e-01f, -1.49884462e-01f, -1.38856649e-01f, -1.49344280e-01f, 5.95618375e-02f, -7.87643865e-02f, -3.30814905e-02f, -2.15312526e-01f, -2.37749293e-01f,
  9.73236039e-02f, 1.22878067e-01f, -3.33794206e-02f, -2.68611684e-02f, -3.85153778e-02f, 1.08168319e-01f, 5.01207002e-02f, 7.97102228e-02f, 3.63245308e-02f, -1.15618175e-02f,
  -3.03890929e-02f, -9.90739539e-02f, 1.66065036e-03f, -1.79621980e-01f, -1.12398230e-01f, 4.09045443e-03f, 3.64390314e-02f, -3.56949423e-03f, -8.49936604e-02f, -9.68501419e-02f,
  1.25676021e-01f, -1.56647321e-02f, 9.96777322e-03f, 3.58243883e-02f, 7.61566088e-02f, -1.44280136e-01f, 7.01161623e-02f, -8.25131312e-02f, -1.36408014e-02f, 1.79363380e-03f,
  1.48199663e-01f, -4.62611988e-02f, -8.28812569e-02f, -6.10304177e-02f, 1.19354136e-01f, 8.28062668e-02f, 1.13754056e-01f, -1.90614760e-02f, 4.51342110e-03f, -7.36598298e-02f,
  -1.70575485e-01f, -1.19014055e-01f, 5.01677059e-02f, 2.42441464e-02f, -7.70921409e-02f, -7.24692345e-02f, -1.47057220e-01f, 1.40096741e-02f, -8.80105123e-02f, 7.33853728e-02f,
  8.78288317e-03f, -9.14492607e-02f, -1.01662919e-01f, -1.93398863e-01f, -1.12384051e-01f, -8.14286917e-02f, -1.33543432e-01f, -1.15339749e-01f, -2.79283732e-01f, -2.80432403e-01f,
  -1.76358029e-01f, 1.50449067e-01f, -6.55555278e-02f, 2.20351517e-01f, 1.12323843e-01f, 1.44313827e-01f, 1.12584151e-01f, 3.06221005e-02f, 8.98872316e-02f, 3.48343439e-02f,
  8.11718106e-02f, 9.04181227e-02f, 1.76560104e-01f, 6.14591725e-02f, 4.81095649e-02f, 1.43574178e-01f, 7.90011212e-02f, 1.98174603e-02f, 4.92618866e-02f, 6.44310489e-02f,
  2.30749622e-01f, 8.32035840e-02f, 6.78544268e-02f, -1.54870888e-02f, 1.98264629e-01f, 2.20544487e-01f, 1.21589437e-01f, 1.18944794e-03f, 1.34087443e-01f, 1.52005345e-01f,
  -3.18014026e-01f, -1.20942213e-01f, 1.00227050e-01f, 4.22136709e-02f, -1.40286088e-01f, -2.41410173e-02f, 8.96401927e-02f, 2.35152021e-02f, -5.55695109e-02f, 5.82943205e-03f,
  -8.58896971e-03f, 1.56804919e-02f, 5.99866733e-02f, 8.00933167e-02f, 1.46281663e-02f, 2.72282446e-03f, -7.03455135e-02f, 4.19393778e-02f, 9.64981690e-03f, -9.64107141e-02f,
  1.15742318e-01f, -6.75681159e-02f, -1.73725590e-01f, 5.24508320e-02f, -1.73585713e-02f, -2.67840326e-02f, -5.83506487e-02f, -3.93781215e-02f, -1.48330510e-01f, -2.47930884e-02f,
  1.11567967e-01f, -1.93947479e-01f, -8.49303156e-02f, 7.16453493e-02f, 1.03796786e-02f, -8.24387893e-02f, -1.11899227e-01f, -5.08397669e-02f, -3.14111896e-02f, -2.11640634e-03f,
  3.87110785e-02f, -9.22804773e-02f, -1.39851496e-01f, 9.78657305e-02f, 4.56533805e-02f, 7.14374632e-02f, -7.84718469e-02f, 3.25614996e-02f, -7.58328065e-02f, -4.89695668e-02f,
  -6.40209019e-02f, 4.43129689e-02f, 2.76028458e-02f, 2.86654737e-02f, -1.25175761e-03f, -1.16706900e-01f, 1.50463164e-01f, 1.17235288e-01f, 1.11558884e-01f, 1.62205875e-01f,
  1.71383813e-01f, -8.00004005e-02f, 3.82841639e-02f, -4.27735485e-02f, -1.83969855e-01f, 6.08702144e-03f, -3.39915715e-02f, -2.16570318e-01f, -8.36746544e-02f, -1.65996421e-02f,
  -1.34552985e-01f, -9.82407928e-02f, -2.15119943e-02f, -7.21974373e-02f, 1.50276329e-02f, -4.19959277e-02f, -6.19188510e-02f, -5.33761941e-02f, -1.23485208e-01f, -1.84712783e-01f,
  2.75918450e-02f, -5.13666533e-02f, -1.79623321e-01f, -8.17799196e-02f, -2.25906298e-02f, 7.07179401e-03f, 1.28158610e-02f, 4.05331552e-02f, -9.09629315e-02f, 4.57395613e-02f,
  1.04653277e-01f, -3.07154894e-01f, -5.10984123e-01f, 1.53700992e-01f, 1.74163997e-01f, -1.69139281e-01f, -3.43127519e-01f, -1.43923521e-01f, 2.39177763e-01f, -9.08007324e-02f,
  5.27699850e-02f, 2.89880276e-01f, 9.05258954e-03f, -1.15440793e-01f, -2.94355422e-01f, -3.53827953e-01f, -2.60727435e-01f, -1.26260236e-01f, 3.26211862e-02f, 3.28861028e-01f,
  2.20618054e-01f, 1.66759461e-01f, 1.43598095e-01f, 1.02397628e-01f, 8.43875110e-02f, -8.98783933e-03f, -2.07322299e-01f, 1.13920562e-01f, 6.43075025e-03f, -8.48928764e-02f,
  -1.23987675e-01f, -1.31815905e-02f, 7.53248855e-03f, 2.22296014e-01f, 7.74127990e-02f, -3.57255340e-02f, -2.77805552e-02f, 2.09647566e-02f, 3.62727307e-02f, -9.04559642e-02f,
  9.01457369e-02f, 1.13683075e-01f, 1.37641668e-01f, 1.08771861e-01f, 1.31290957e-01f, -1.10725582e-01f, -5.33822626e-02f, -1.03211567e-01f, -1.96987808e-01f, -1.39438421e-01f,
  -3.16460175e-03f, 2.61890050e-02f, -1.43760189e-01f, -2.17008382e-01f, -1.84250370e-01f, -8.59944746e-02f, -9.90727469e-02f, 4.88160960e-02f, -2.63301522e-01f, -7.61451572e-02f,
  3.49467732e-02f, 7.80926198e-02f, 1.40272649e-02f, 4.07439610e-03f, -3.10011897e-02f, -1.12935983e-01f, 6.30062968e-02f, -1.02197169e-03f, 1.18329145e-01f, -1.11274831e-01f,
  -1.05018709e-02f, -6.97828680e-02f, -7.02183247e-02f, -1.78708926e-01f, -1.54563575e-03f, -6.94619492e-02f, -4.28862162e-02f, -1.15934871e-01f, -9.26612094e-02f, -3.27093229e-02f,
  -5.25219589e-02f, -1.93937328e-02f, 2.74895262e-02f, -5.56018576e-02f, -9.59306732e-02f, -1.18322276e-01f, 1.56297500e-03f, 3.57395643e-03f, 4.58487906e-02f, -1.53842336e-02f,
  1.54205695e-01f, -1.95305556e-01f, -1.17803335e-01f, 5.55674098e-02f, -5.52651919e-02f, -2.98741702e-02f, -1.04483985e-03f, -3.06626447e-02f, 7.04748183e-02f, -1.85571276e-02f,
  -7.60748088e-02f, -1.47644088e-01f, -3.67338583e-02f, -1.98378805e-02f, 4.80321161e-02f, 5.93909435e-03f, -8.21808726e-02f, -5.77571578e-02f, -1.71525061e-01f, 9.91310179e-02f,
  -8.45991671e-02f, -2.84347609e-02f, -7.00583830e-02f, -1.65924400e-01f, 8.91844854e-02f, -1.05887383e-01f, -1.09983973e-01f, -7.19591156e-02f, -2.76960433e-01f, -2.14396074e-01f,
  1.57893464e-01f, -4.44971025e-01f, 2.06883520e-01f, 9.30369496e-02f, -2.97048271e-01f, -3.37958753e-01f, -4.05422121e-01f, -1.70697823e-01f, 4.77228761e-02f, -3.20355594e-01f,
  -2.71392167e-01f, -1.98648889e-02f, 8.63267779e-02f, 9.68353078e-02f, 2.08971411e-01f, -8.36155489e-02f, 9.22140181e-02f, 4.66019869e-01f, 4.52979445e-01f, 2.23748878e-01f,
  3.52966934e-02f, 2.34873965e-01f, 3.26343775e-01f, 2.79797614e-01f, 1.47794619e-01f, 6.90933168e-02f, 6.29982054e-02f, 1.82868838e-01f, -6.61010221e-02f, 1.12209462e-01f,
  1.31852359e-01f, -1.34299442e-01f, 1.40001431e-01f, 2.57982649e-02f, 3.94709781e-02f, 1.23553909e-01f, 7.48162270e-02f, 1.37040287e-01f, 1.93141308e-02f, 4.38451692e-02f,
  5.32645267e-03f, 3.35374884e-02f, -7.57407397e-02f, 7.24772108e-04f, -3.48655856e-03f, -1.32095382e-01f, 1.45994648e-01f, 2.78423846e-01f, 1.57349706e-01f, 7.30059370e-02f,
  -1.75891340e-01f, -8.50490779e-02f, -2.52898633e-01f, -2.31794938e-01f, 9.10379644e-03f, 1.52275592e-01f, -1.02826227e-02f, 4.30375747e-02f, -3.15958597e-02f, -3.67629528e-02f,
  -2.73126774e-02f, 2.15104986e-02f, 1.37274677e-03f, -1.60004735e-01f, -3.12925652e-02f, 4.28861938e-02f, 4.80792001e-02f, -6.29913881e-02f, 9.50263292e-02f, 4.38214131e-02f,
  2.84287278e-02f, 5.09639531e-02f, 3.44789177e-02f, -6.03740523e-03f, 7.30538070e-02f, -5.55898622e-02f, 4.40051109e-02f, 9.92774516e-02f, 1.00777619e-01f, -5.20285778e-03f,
  -7.35701397e-02f, 1.22774299e-02f, -2.30469648e-03f, 1.78843662e-01f, 1.03726834e-01f, 1.08575433e-01f, 7.22674280e-02f, 1.59674406e-03f, -6.71334788e-02f, -1.74718782e-01f,
  -2.06869930e-01f, 3.41164619e-02f, -2.51328684e-02f, -4.05860730e-02f, -4.62923311e-02f, -1.35085195e-01f, -8.75478610e-02f, 5.03245071e-02f, -8.51277933e-02f, -6.56943694e-02f,
  -1.52647704e-01f, -4.72504534e-02f, -4.26694453e-02f, 8.32163319e-02f, 6.85604736e-02f, -1.46167949e-01f, -1.61831185e-01f, -1.81879386e-01f, 5.89275099e-02f, 3.28119658e-02f,
  -6.20796010e-02f, -1.57436445e-01f, -2.71112084e-01f, -3.34918469e-01f, -2.23743498e-01f, -1.92997381e-01f, -1.32188022e-01f, -9.93145332e-02f, -2.57130325e-01f, -3.46132189e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.52819479e-01f, 2.67569155e-01f, 1.66366845e-01f, 1.50703937e-01f, 3.03444147e-01f, 5.75688064e-01f, 4.05666113e-01f, 1.67455286e-01f, 9.50878635e-02f, 1.50995255e-01f,
  3.12123597e-01f, 3.78456116e-01f, 1.50848180e-01f, 2.73021311e-01f, 3.01514328e-01f, 3.29951704e-01f, 1.80652410e-01f, 2.42973387e-01f, 3.66831273e-01f, 5.05173922e-01f,
  3.41205567e-01f, 3.76120120e-01f, 3.95481020e-01f, 2.15525866e-01f, 3.88697565e-01f, 2.96430826e-01f, 1.32952422e-01f, 2.24050432e-01f, 4.35719997e-01f, 4.58483279e-01f,
  4.06626463e-01f, 3.05282950e-01f, 4.30867374e-01f, 4.00039524e-01f, 3.86644840e-01f, -2.89605290e-01f, 1.36091560e-01f, -6.49965182e-02f, 3.76703501e-01f, 3.79246294e-01f,
  5.57095148e-02f, 2.30711132e-01f, 3.30163479e-01f, 3.50105047e-01f, 2.11654663e-01f, 2.30948746e-01f, 4.48645204e-01f, 2.95421094e-01f, 2.35620201e-01f, 2.20328927e-01f,
  1.40026897e-01f, 3.17400277e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.54642746e-01f, -3.63930874e-02f, 1.07237950e-01f, 4.71512005e-02f, -8.73355791e-02f, 8.49127248e-02f, 5.39710559e-03f, -4.47976813e-02f, -1.21499948e-01f, -1.17080733e-01f,
  1.00230180e-01f, -9.63688921e-03f, -1.15273654e-01f, 2.12677289e-02f, 1.37308901e-02f, 3.68116610e-02f, 2.66318589e-01f, 1.28047138e-01f, 9.66539308e-02f, 4.04918939e-02f,
  -1.29461184e-01f, -4.62377369e-02f, 4.87058386e-02f, 2.20744938e-01f, 1.56355783e-01f, -1.27235293e-01f, 6.68299571e-02f, 1.03879943e-01f, 1.46329463e-01f, -1.89264324e-02f,
  -4.19276133e-02f, 1.55991375e-01f, 1.46515980e-01f, -3.07569653e-02f, -1.74559221e-01f, 6.41438514e-02f, -2.64781229e-02f, -8.69161934e-02f, -2.19846740e-01f, -1.50926039e-01f,
  -2.32547656e-01f, -8.02689418e-02f, -1.53362647e-01f, -1.66457996e-01f, 1.44955784e-01f, -9.71982405e-02f, 1.25873368e-02f, 8.09759945e-02f, -9.62820798e-02f, -3.16770256e-01f,
  -1.15492679e-01f, -2.18258537e-02f, -4.16960604e-02f, -6.24275692e-02f, 1.90718416e-02f, 1.00492574e-01f, 1.32960856e-01f, 1.08571097e-01f, 2.20383741e-02f, 7.92978853e-02f,
  -4.10872772e-02f, -5.22832125e-02f, -5.87893687e-02f, 1.09168090e-01f, -3.72153446e-02f, 4.99914661e-02f, 5.20807281e-02f, -3.88978645e-02f, -4.63465080e-02f, -1.02647655e-01f,
  6.13474138e-02f, 5.69027625e-02f, 9.49727520e-02f, 1.09857090e-01f, -8.32066089e-02f, 8.51156563e-02f, 4.65799076e-03f, -1.17418744e-01f, 5.35913780e-02f, 1.03102643e-02f,
  1.95995927e-01f, 8.44087973e-02f, -1.00791216e-01f, -1.46643996e-01f, -1.55551285e-01f, -1.65208712e-01f, 2.01409101e-01f, 1.03991821e-01f, 1.97051972e-01f, 1.56842873e-01f,
  -1.32582232e-01f, -2.15599239e-01f, 1.82895303e-01f, 6.74803182e-02f, 1.67695254e-01f, -1.38244584e-01f, -9.41981897e-02f, 7.48940334e-02f, 3.08774672e-02f, -2.91864630e-02f,
  1.53668955e-01f, -9.30803940e-02f, 4.25625741e-02f, 1.05413683e-01f, -1.73106790e-01f, -6.20804988e-02f, -1.17719986e-01f, -5.90976961e-02f, 9.65439975e-02f, 2.36843061e-02f,
  1.86158895e-01f, -6.94244877e-02f, 1.23175330e-01f, -1.11757092e-01f, -2.61847228e-02f, 5.17099835e-02f, -1.88000679e-01f, -6.57088384e-02f, 7.04182638e-03f, -5.18884100e-02f,
  6.69511780e-02f, -1.59438476e-01f, 3.93058406e-03f, 9.98422503e-02f, -2.11514309e-01f, 1.29513079e-02f, -2.16589853e-01f, -1.28665671e-01f, 9.02244076e-02f, -1.01084389e-01f,
  -2.20395923e-02f, 9.74563062e-02f, 7.05423430e-02f, -5.07853068e-02f, -3.58579829e-02f, -1.21789686e-01f, -9.92215052e-02f, 1.16808034e-01f, -7.98561573e-02f, 1.05183095e-01f,
  -5.71375042e-02f, 1.30445778e-01f, 1.16877437e-01f, 3.47883217e-02f, 2.18951687e-01f, -1.81820020e-01f, 7.86080360e-02f, -1.13607384e-01f, -1.04739539e-01f, -4.15354297e-02f,
  -1.02462014e-03f, 1.08724818e-01f, 8.34584832e-02f, 7.83517510e-02f, -3.93962115e-02f, 1.06415085e-01f, 1.38031036e-01f, -1.18887136e-02f, -3.00711952e-02f, -1.23498902e-01f,
  -8.39423314e-02f, -1.72353894e-01f, -1.44840747e-01f, 1.38205737e-01f, 8.07308182e-02f, 2.22624794e-01f, -1.71664320e-02f, -5.08324802e-02f, -1.27245933e-01f, -1.37704775e-01f,
  -9.19438154e-02f, -8.98067933e-03f, 1.14704380e-02f, 3.61805037e-02f, 1.31568342e-01f, 9.77547467e-02f, 1.04773887e-01f, -2.06519008e-01f, -1.62140042e-01f, -1.48209527e-01f,
  -5.09854294e-02f, 6.76163882e-02f, 9.95387440e-04f, -2.38930006e-02f, -1.48590440e-02f, 4.11018059e-02f, 1.25230029e-01f, 4.00112234e-02f, 6.64107129e-02f, 3.36243622e-02f,
  4.33621705e-02f, 1.88192278e-01f, -1.34864390e-01f, -5.91475889e-02f, 2.18405370e-02f, -4.24747132e-02f, -1.45381922e-02f, 1.00073144e-01f, 8.50851163e-02f, 1.35717154e-01f,
  -7.37342313e-02f, 6.59333840e-02f, -6.73900917e-02f, -9.91556142e-03f, 1.10197447e-01f, 4.60162982e-02f, 1.09888837e-01f, 1.16395049e-01f, 5.01300022e-02f, -4.54723835e-02f,
  -4.56201546e-02f, -1.27956167e-01f, -1.85272262e-01f, 1.54862970e-01f, 5.06203584e-02f, -7.54113197e-02f, 1.16350390e-01f, 9.06456113e-02f, 2.12321490e-01f, 1.58033464e-02f,
  -1.87074631e-01f, 5.17339725e-03f, -1.16860949e-01f, 2.82255020e-02f, 7.37198442e-02f, -3.59040350e-02f, -9.33276713e-02f, 9.30684283e-02f, 5.35066314e-02f, 1.34456549e-02f,
  3.34368162e-02f, 8.11092779e-02f, 1.25305295e-01f, -1.35404304e-01f, -1.59896482e-02f, -2.44368345e-01f, 5.18388487e-02f, -2.86546461e-02f, 8.42055306e-02f, 1.80520713e-01f,
  9.34868008e-02f, -1.69440001e-01f, -1.45864844e-01f, -2.26462148e-02f, -1.03472382e-01f, 1.23382375e-01f, -9.78450999e-02f, 8.49629864e-02f, 6.12164140e-02f, 2.59357452e-01f,
  -7.92631730e-02f, -2.16977987e-02f, -1.50536736e-02f, 6.52944073e-02f, -1.92291930e-01f, -2.92155333e-02f, -3.85570228e-02f, 4.48370762e-02f, 2.07743794e-02f, 3.38759236e-02f,
  -3.55814323e-02f, 2.34220992e-03f, -1.92326948e-01f, -1.98922008e-01f, 3.84620242e-02f, -2.16119975e-01f, 1.81116298e-01f, -3.14636566e-02f, -1.02509536e-01f, 6.09595254e-02f,
  -3.99894826e-03f, -2.05588490e-02f, 1.28531560e-01f, -1.39879167e-01f, 1.99348465e-01f, 1.81804672e-01f, 1.20551148e-02f, 6.97269589e-02f, -1.10728536e-02f, -4.83748093e-02f,
  -6.55498803e-02f, -2.10645169e-01f, 1.32427379e-01f, 9.88562107e-02f, -1.06209271e-01f, 1.34700477e-01f, -1.36199012e-01f, -1.02892682e-01f, 2.38625072e-02f, 6.46803156e-02f,
  -7.63686448e-02f, 4.53400649e-02f, -1.98498994e-01f, 4.38428149e-02f, -1.12404391e-01f, 1.55736636e-02f, -1.22175775e-01f, 2.99631786e-02f, -1.46900266e-01f, 1.03369363e-01f,
  9.65421647e-03f, -1.56614691e-01f, -1.05328709e-01f, 1.42729253e-01f, -2.88829505e-02f, -4.23456728e-02f, 4.23788466e-02f, 6.65895492e-02f, 1.41127229e-01f, -1.69361569e-02f,
  -4.80928011e-02f, -8.76940265e-02f, -5.96915279e-03f, -4.62836735e-02f, -6.64241761e-02f, -1.42667526e-02f, 1.22252665e-01f, -1.65894888e-02f, 2.37761348e-01f, -9.98167843e-02f,
  -1.64808765e-01f, -1.63448721e-01f, -1.17617972e-01f, -4.33161296e-02f, -3.94573174e-02f, -2.46197373e-01f, 2.47256532e-02f, 1.28872901e-01f, -4.76313569e-02f, 9.11483988e-02f,
  5.84964314e-03f, 6.67909347e-03f, 3.51007730e-02f, 9.37003344e-02f, -1.27128556e-01f, 6.54246807e-02f, 1.46536395e-01f, -3.62894014e-02f, -1.27758354e-01f, 1.83364302e-01f,
  3.61727774e-02f, 4.78956625e-02f, -8.69607404e-02f, -1.49498597e-01f, 2.41384923e-01f, -7.85703585e-02f, -3.77230272e-02f, 1.01542912e-01f, 1.62454233e-01f, -6.22924380e-02f,
  1.13469385e-01f, 9.13778469e-02f, -2.28501424e-01f, 1.05313204e-01f, 6.87436312e-02f, 2.32391264e-02f, -9.75685343e-02f, -1.06286921e-01f, 3.22195888e-02f, 3.50037627e-02f,
  -4.26058061e-02f, -5.55545054e-02f, -1.40181389e-02f, 3.85739096e-02f, -6.53086379e-02f, 7.03785270e-02f, -5.92772812e-02f, -1.14166193e-01f, 6.83297217e-02f, 1.21568982e-02f,
  -6.75470978e-02f, -1.61178961e-01f, -2.71388963e-02f, -6.40131086e-02f, 1.14878856e-01f, 2.05155551e-01f, -1.37586042e-03f, -1.80180937e-01f, 6.64488003e-02f, -2.56724328e-01f,
  -4.49788570e-02f, 6.64412454e-02f, 8.10456425e-02f, -6.06837235e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.70697480e-01f, 1.21624179e-01f, 2.08774745e-01f, 3.08227129e-02f, 2.48285621e-01f, 7.17685148e-02f, 7.81445578e-02f, 9.78043526e-02f, 1.78628534e-01f, 3.28216292e-02f,
  3.01107913e-01f, -1.74823448e-01f, -2.22587213e-01f, -2.33913928e-01f, -5.68038411e-02f, 1.21801592e-01f, 4.20258284e-01f, -1.59126848e-01f, 4.36225021e-03f, 2.96294689e-01f,
  -2.72648126e-01f, -8.29041973e-02f, 2.14965254e-01f, -1.10402718e-01f, 3.21373671e-01f, -2.47207254e-01f, 5.55697195e-02f, -2.15497583e-01f, 1.52230412e-01f, -2.43500561e-01f,
  2.32923150e-01f, 3.64057883e-03f, 1.90977275e-01f, 2.33601883e-01f, 2.35083938e-01f, 7.62612969e-02f, 9.29330662e-02f, 9.34217218e-03f, 3.96964885e-02f, -5.40471748e-02f,
  -3.08746010e-01f, 1.27977133e-01f, -1.25574917e-01f, -2.07790703e-01f, 2.15440914e-01f, 2.17922598e-01f, -1.48442551e-01f, 8.70578364e-02f, 7.95043409e-02f, 1.31391376e-01f,
  -1.26402691e-01f, -7.85560533e-02f, -1.15954213e-01f, -1.52828902e-01f, 3.42247605e-01f, 1.10379927e-01f, 1.08366452e-01f, -3.37352045e-02f, -1.04910843e-01f, 1.75881106e-02f,
  -2.33682506e-02f, 1.67829394e-02f, 4.30395938e-02f, -1.18909083e-01f, 1.02367468e-01f, 1.15678355e-01f, 4.90524387e-03f, 1.05011165e-01f, 1.91197425e-01f, 1.10180385e-01f,
  3.14994119e-02f, 6.64276071e-03f, 1.84464216e-01f, 4.22851928e-02f, 1.50791734e-01f, -5.40579930e-02f, -5.58452196e-02f, -5.52709959e-02f, -1.30279228e-01f, 1.18681312e-01f,
  2.82225549e-01f, 5.78825176e-02f, 1.48432612e-01f, 2.64500320e-01f, 2.55732387e-01f, 1.87720969e-01f, 2.40716472e-01f, -5.16609661e-02f, 1.41420618e-01f, -2.15027615e-01f,
  8.39428380e-02f, 1.96711663e-02f, 2.45267794e-01f, 3.15490831e-03f, 1.13915995e-01f, 2.30646208e-01f, 2.18287762e-02f, 4.69215475e-02f, -1.42324045e-01f, 1.75394535e-01f,
  -8.09137225e-02f, -3.25811982e-01f, -1.52633250e-01f, 1.49665922e-02f, 2.36056179e-01f, 1.16220852e-02f, 1.83895886e-01f, 1.47050694e-01f, -1.57745659e-01f, 4.93720807e-02f,
  -3.01098317e-01f, 1.29997641e-01f, -4.32498157e-02f, 1.10724136e-01f, -4.39671539e-02f, 9.11306776e-03f, 3.04366440e-01f, -1.02845922e-01f, 7.10503459e-02f, 1.41417697e-01f,
  1.03254832e-01f, 2.73995362e-02f, 1.38945013e-01f, -3.71993817e-02f, 1.41537756e-01f, -1.62278309e-01f, 1.89701602e-01f, 3.35929692e-01f, 3.36061329e-01f, 8.69715735e-02f,
  9.62531641e-02f, -1.32649066e-02f, 5.57714365e-02f, 1.85307890e-01f, -1.13581717e-01f, -5.75178787e-02f, 9.59714279e-02f, 2.37416089e-01f, -6.89096227e-02f, 3.49431485e-02f,
  -1.50359675e-01f, -8.62659588e-02f, 8.00117627e-02f, 1.39417470e-01f, -3.74612659e-02f, 1.70823908e-03f, 2.34316692e-01f, -1.99270193e-02f, -2.00491711e-01f, -1.10345013e-01f,
  -1.14744067e-01f, 4.95539159e-02f, 2.15689212e-01f, 2.55895197e-01f, -2.16498971e-01f, 1.81004778e-01f, 2.68646687e-01f, -1.61617883e-02f, 1.02304712e-01f, 4.67292927e-02f,
  -3.24101001e-01f, -2.95962065e-01f, 2.67407566e-01f, 1.01424284e-01f, 2.78907597e-01f, 1.75770327e-01f, -1.10900335e-01f, -1.89776927e-01f, -1.65111776e-02f, 2.54351765e-01f,
  2.49269873e-01f, 3.86756100e-02f, 2.57069677e-01f, 2.26714417e-01f, 2.59370774e-01f, 6.84824660e-02f, 1.42033547e-01f, -7.19196796e-02f, 3.47622372e-02f, 9.87090692e-02f,
  -1.73937112e-01f, -8.24152455e-02f, 1.56147778e-01f, 8.27962905e-02f, 2.09366474e-02f, 2.29978159e-01f, 1.32653311e-01f, -2.21938431e-01f, 1.97290815e-03f, 2.33259022e-01f,
  -1.39654323e-01f, 2.56373405e-01f, 1.40749991e-01f, 1.23137966e-01f, 1.48511648e-01f, 2.35535681e-01f, 1.49724334e-01f, 8.02406594e-02f, 1.04878768e-01f, 1.27164915e-01f,
  -1.80863008e-01f, -1.08800068e-01f, -1.30604178e-01f, 1.64915264e-01f, 2.92375982e-01f, 2.61880755e-01f, -1.58464402e-01f, 1.73853040e-01f, -4.65730540e-02f, 1.31856456e-01f,
  8.26263335e-03f, 7.74713308e-02f, 7.32279150e-03f, 3.25882345e-01f, -1.26765415e-01f, -1.88716531e-01f, -1.18524499e-01f, 1.78629637e-01f, 3.79825175e-01f, 4.41816710e-02f,
  6.94363937e-02f, 7.01987594e-02f, -3.01789399e-02f, 1.19494766e-01f, 2.79711455e-01f, 2.43466035e-01f, 5.87217137e-03f, -1.39342159e-01f, -1.26906261e-01f, 3.77274752e-02f,
  2.55580992e-01f, 3.16589445e-01f, 1.15765296e-01f, -2.90375128e-02f, 1.53892040e-01f, -7.77385682e-02f, -1.84828892e-01f, -3.62529308e-01f, -1.50263444e-01f, 4.61049788e-02f,
  -5.57175726e-02f, -1.31436083e-02f, -4.57941182e-02f, 1.48038119e-01f, 3.08988810e-01f, 3.97957474e-01f, 2.09058840e-02f, -7.35638663e-02f, -2.69078523e-01f, 3.11856329e-01f,
  3.95417437e-02f, -2.18290329e-01f, 1.33641154e-01f, 1.00174197e-03f, 9.76480618e-02f, 7.45594427e-02f, -5.20761982e-02f, 9.59193632e-02f, -5.21517955e-02f, 5.16445264e-02f,
  1.13028102e-01f, 3.42979245e-02f, -1.74611602e-02f, 7.73190185e-02f, 5.60160493e-03f, -3.70669663e-02f, 8.54799971e-02f, 1.06355824e-01f, 2.33472630e-01f, -7.45592862e-02f,
  4.06821147e-02f, 1.85918152e-01f, 3.30823511e-02f, 1.36967301e-01f, -1.03072505e-02f, 6.12298511e-02f, 3.09705287e-01f, 2.15334326e-01f, -3.64571452e-01f, -2.59061962e-01f,
  -2.76479930e-01f, 5.86899333e-02f, 1.74008712e-01f, -9.14875884e-03f, -9.78568345e-02f, 2.54911423e-01f, 3.48493159e-02f, -1.25370085e-01f, 4.39368725e-01f, -2.95203608e-02f,
  -2.02333890e-02f, -1.38794288e-01f, -8.62497091e-02f, -1.29404008e-01f, -1.88526642e-02f, 1.10493168e-01f, 3.52794439e-01f, 2.03477368e-01f, 5.21525666e-02f, 2.90960491e-01f,
  4.17068712e-02f, -7.26674423e-02f, -1.67062476e-01f, 1.08116120e-01f, -1.50191739e-01f, 3.50529253e-01f, 2.43426859e-01f, 3.60661983e-01f, 2.50241399e-01f, 6.16906174e-02f,
  2.22339362e-01f, -8.13042223e-02f, -7.62935281e-02f, 8.81939232e-02f, -1.31341487e-01f, -4.86804098e-02f, 5.71874902e-02f, -7.59610608e-02f, -2.04304978e-03f, 2.16522396e-01f,
  1.50837362e-01f, 1.75863549e-01f, 1.11382149e-01f, 1.17887035e-01f, 5.95327280e-02f, 1.80226117e-01f, -1.70802355e-01f, -1.76351033e-02f, 1.93589274e-02f, -8.95182788e-02f,
  1.37067679e-02f, -1.92197170e-02f, -3.53003711e-01f, 8.78517926e-02f, 5.24621680e-02f, -3.40858772e-02f, -1.90011382e-01f, 6.90754652e-02f, -2.96319854e-02f, -3.81604731e-02f,
  -2.24418994e-02f, -1.77752972e-01f, 1.75770804e-01f, 1.74007609e-01f, -1.44208103e-01f, 1.99567765e-01f, -2.22937897e-01f, 2.34799102e-01f, 5.29778264e-02f, 2.96275407e-01f,
  -2.24258304e-02f, 1.38888389e-01f, -7.47022033e-02f, -2.07791552e-01f, 3.50286782e-01f, -1.03555895e-01f, 1.90561891e-01f, 4.81706917e-01f, 2.98244003e-02f, -2.23957926e-01f,
  -1.51904225e-01f, 1.92469552e-01f, -1.09289728e-01f, 1.76297575e-01f, 2.07699329e-01f, 2.01762468e-01f, 2.92884111e-01f, -1.39955312e-01f, -4.76762019e-02f, -3.71018909e-02f,
  3.82946104e-01f, -1.07149151e-03f, -2.42836863e-01f, -2.68095165e-01f, 1.20682031e-01f, 1.23906814e-01f, 6.01936840e-02f, -9.21117961e-02f, 4.45176661e-02f, -3.81567292e-02f,
  -2.72677857e-02f, 7.72067308e-02f, 1.52085587e-01f, -7.70946592e-02f, 2.57079885e-03f, 2.35510364e-01f, 1.38726443e-01f, 9.23480745e-03f, 6.92646997e-03f, 4.61778324e-03f,
  -2.04428717e-01f, -1.62078196e-03f, -1.21929757e-01f, 1.43610947e-02f, 1.11083247e-01f, 1.57182127e-01f, -1.45620808e-01f, 1.36647835e-01f, 9.80912447e-02f, -1.85433716e-01f,
  -8.54487270e-02f, 1.15929313e-01f, 1.13486625e-01f, 1.66703165e-01f, 1.23138808e-01f, 1.98192638e-03f, -1.64242059e-01f, 1.11596718e-01f, 1.30837308e-02f, 2.67718405e-01f,
  -2.38593873e-02f, 4.91683893e-02f, 1.77350491e-01f, 8.90845209e-02f, -4.99768518e-02f, -9.40028206e-02f, -1.60047412e-01f, -1.67367175e-01f, 3.79493713e-01f, -1.81015879e-01f,
  2.00373441e-01f, 1.53958961e-01f, 9.18562561e-02f, -4.68330085e-02f, 9.28267464e-02f, -8.88829976e-02f, 4.89100553e-02f, 1.78621277e-01f, -6.84257373e-02f, 1.12017311e-01f,
  1.62499920e-01f, -6.21422380e-02f, 7.72753432e-02f, 2.50162333e-01f, 3.34746122e-01f, -1.72385573e-01f, 1.50868177e-01f, -2.23139629e-01f, 1.29239261e-01f, -2.51344979e-01f,
  -1.55541062e-01f, -2.12357149e-01f, 1.48694277e-01f, 5.16160801e-02f, 9.18002725e-02f, 1.39301971e-01f, 3.28449368e-01f, 2.04553455e-01f, 1.93481073e-01f, -9.59912017e-02f,
  1.10236466e-01f, 6.20902963e-02f, 2.53293484e-01f, 1.68635190e-01f, -1.28036320e-01f, -4.07803357e-02f, 1.84593652e-03f, -1.13869995e-01f, 2.37735510e-02f, -7.84076229e-02f,
  -2.95060784e-01f, 2.29162872e-01f, 1.04322083e-01f, 6.92831278e-02f, 5.73614575e-02f, 8.66264924e-02f, 1.00729123e-01f, 9.07104164e-02f, -1.48072332e-01f, -1.11126676e-01f,
  7.41294473e-02f, 1.42643556e-01f, 1.02405824e-01f, 2.32937392e-02f, -2.78282985e-02f, -7.08216727e-02f, -3.20118099e-01f, 2.22213250e-02f, 4.53347676e-02f, 1.72649533e-01f,
  9.78296921e-02f, 7.40393400e-02f, -1.19711928e-01f, -3.14102918e-02f, 2.42809132e-01f, 4.47563231e-01f, -5.84808886e-02f, -5.46830855e-02f, -1.93019122e-01f, 2.62547046e-01f,
  -1.44981667e-01f, 1.23162970e-01f, 3.07783663e-01f, -8.82259235e-02f, 1.34951100e-01f, -1.88549563e-01f, 5.45418710e-02f, 1.68979187e-02f, -2.97533395e-03f, 7.07327574e-02f,
  -9.47583094e-02f, 6.67023566e-03f, 1.78712815e-01f, 3.03494006e-01f, 1.39177382e-01f, 1.04589043e-02f, 7.92528465e-02f, -6.71142265e-02f, 1.62865072e-01f, 1.56320274e-01f,
  1.78040907e-01f, -2.54121035e-01f, 1.58650041e-01f, 1.48777932e-01f, 1.00618355e-01f, 1.53001457e-01f, 2.21825927e-01f, 2.31032103e-01f, 1.05498463e-01f, 1.39713123e-01f,
  -1.25058845e-01f, 2.52469122e-01f, -5.16373873e-01f, 2.55749524e-01f, 1.82257593e-01f, -3.69494446e-02f, -1.14783086e-01f, -2.53787544e-02f, -1.16792880e-02f, 3.74350578e-01f,
  -5.16856601e-03f, -2.63752073e-01f, 4.21745889e-02f, -4.03638631e-02f, -5.71669564e-02f, 3.38072479e-01f, -3.67083661e-02f, 3.95831764e-01f, 4.45875786e-02f, -2.53030751e-02f,
  1.15505040e-01f, 1.26433611e-01f, 1.92381248e-01f, -1.33130968e-01f, 6.65899292e-02f, -3.75498645e-02f, -2.28325069e-01f, -5.65504804e-02f, 4.88467515e-01f, -1.12689631e-02f,
  1.80909231e-01f, 1.32084310e-01f, 4.44876492e-01f, 1.74705088e-02f, 2.92024255e-01f, 1.32731246e-02f, 1.08803980e-01f, -7.45758880e-03f, 4.15277749e-01f, -1.35549754e-01f,
  -6.23164624e-02f, -9.29325521e-02f, -1.47894219e-01f, 1.69603199e-01f, 7.16756657e-02f, 1.80384025e-01f, -1.86283290e-01f, 1.39821112e-01f, -2.51670539e-01f, 1.78391427e-01f,
  1.68805137e-01f, 1.55532390e-01f, -2.77438402e-01f, 6.67058155e-02f, -2.62027949e-01f, 3.95848215e-01f, -2.59287953e-02f, 2.64611337e-02f, -3.67752686e-02f, 9.22551528e-02f,
  -3.03174648e-02f, -2.14336924e-02f, -1.29784480e-01f, -1.66208580e-01f, -6.20044805e-02f, -9.16688442e-02f, 1.48488089e-01f, -1.58791348e-01f, -2.39230648e-01f, 6.57889396e-02f,
  7.56502226e-02f, -1.27635270e-01f, -1.61714792e-01f, -9.28532854e-02f, -1.64639167e-02f, 8.30786601e-02f, 3.57820690e-01f, 6.93681389e-02f, 8.06335136e-02f, 6.24841228e-02f,
  -1.19034134e-01f, -6.32640943e-02f, -6.16858713e-02f, 1.61450878e-01f, 5.79645336e-02f, 2.60671586e-01f, -2.28914335e-01f, 1.53159320e-01f, 6.64385408e-02f, -2.12204769e-01f,
  7.51990974e-02f, 9.03969109e-02f, -2.47843906e-01f, 9.10267830e-02f, -1.98907703e-01f, -1.83389038e-01f, 1.86435848e-01f, -1.09306918e-02f, 8.90723020e-02f, 3.39576662e-01f,
  1.07048946e-02f, 5.15973289e-03f, -2.72064172e-02f, 1.12099960e-01f, 1.57610700e-01f, 7.54342154e-02f, 3.58046860e-01f, 8.43865201e-02f, 3.76565494e-02f, -2.32410491e-01f,
  4.00392190e-02f, -2.34195873e-01f, 1.39570013e-01f, -1.69340506e-01f, 5.24462126e-02f, 1.76853001e-01f, -1.64582557e-03f, 1.25510976e-01f, 1.31057352e-01f, 1.08150929e-01f,
  4.26994031e-03f, -1.45156067e-02f, 2.28239581e-01f, 5.72468527e-02f, 1.08063132e-01f, 1.86766963e-03f, 1.01240009e-01f, -1.13321710e-02f, -1.15337685e-01f, 2.97693405e-02f,
  -1.74323156e-01f, 1.19078696e-01f, -3.89250852e-02f, -1.68386586e-02f, 1.62327319e-01f, -6.32917508e-02f, 1.26843259e-01f, 3.22782874e-01f, 6.70572966e-02f, 7.09838867e-02f,
  -1.12304717e-01f, -5.09321913e-02f, -5.45105413e-02f, 1.34005740e-01f, -3.18118744e-02f, 2.51280695e-01f, 3.62468995e-02f, -1.39171809e-01f, -4.90109809e-02f, -3.49158347e-02f,
  1.26980215e-01f, -1.44864783e-01f, -1.33079767e-01f, 2.72550583e-01f, -6.46778420e-02f, -1.84646681e-01f, 4.01902020e-01f, 1.38733417e-01f, 1.03866667e-01f, 1.55538842e-01f,
  -9.93074402e-02f, -1.83067709e-01f, -5.10436557e-02f, -4.47162054e-02f, -5.33015728e-02f, -1.13353096e-01f, 1.29270583e-01f, -1.76403850e-01f, 8.67903233e-02f, 3.06556579e-02f,
  -1.22078702e-01f, -8.72905105e-02f, -5.81938289e-02f, 1.16043255e-01f, -1.47051483e-01f, 1.68308422e-01f, -1.67148225e-02f, 6.73312396e-02f, 1.29780784e-01f, 1.90118760e-01f,
  4.22620252e-02f, -1.16845362e-01f, 4.08432120e-03f, -2.08584890e-01f, 1.07703075e-01f, 1.25968695e-01f, 1.12837136e-01f, 3.90057042e-02f, 1.02949761e-01f, -1.30879227e-02f,
  -3.33204232e-02f, -1.40355676e-01f, -5.27489856e-02f, 1.15507022e-01f, 8.10901914e-03f, 1.09834899e-03f, -3.06718588e-01f, 7.00311735e-02f, -2.27376893e-01f, 1.61902755e-01f,
  4.14969683e-01f, -3.42563301e-01f, 4.13109392e-01f, 3.46264243e-01f, -1.47972450e-01f, 4.82987575e-02f, 8.30769241e-02f, -2.64202714e-01f, 2.11581320e-01f, -3.26834768e-01f,
  2.57630467e-01f, 1.05835699e-01f, 3.69646609e-01f, -2.36265987e-01f, 1.68928027e-01f, 7.13991746e-02f, 1.58200964e-01f, 2.82534242e-01f, -1.86034590e-01f, 1.16137480e-02f,
  -6.14457242e-02f, -2.08429858e-01f, -2.53559589e-01f, -9.67669562e-02f, -2.15013567e-02f, 1.51915178e-01f, -4.24482450e-02f, -4.01924253e-02f, 8.40563327e-02f, 1.75503254e-01f,
  -3.48961353e-01f, -1.29334524e-01f, -2.96235502e-01f, -1.92394033e-01f, -3.18164647e-01f, 2.21644677e-02f, -1.16009302e-01f, 4.93328907e-02f, 2.25251868e-01f, 2.95438707e-01f,
  -2.27270991e-01f, 2.09055498e-01f, 5.17185591e-02f, -1.77031174e-01f, 1.51924297e-01f, -3.36432341e-03f, 4.24588546e-02f, 3.60096157e-01f, -2.85554491e-02f, 1.14637790e-02f,
  -2.07083207e-02f, 6.13672435e-02f, 3.49190757e-02f, 6.42775446e-02f, -1.08612515e-01f, -1.44287273e-01f, -7.95356706e-02f, -9.79652032e-02f, -5.82495742e-02f, 9.39929932e-02f,
  9.93105322e-02f, 1.06650054e-01f, -4.82339226e-03f, 5.48254959e-02f, 2.07359456e-02f, 8.89840946e-02f, -1.63770154e-01f, 1.53423296e-02f, 8.38479176e-02f, 1.98952302e-01f,
  5.47652356e-02f, -1.04921430e-01f, -1.28581196e-01f, 2.58390959e-02f, 1.33560613e-01f, 1.29995123e-01f, -3.65097485e-02f, 1.34795621e-01f, -1.69843554e-01f, 2.33710974e-01f,
  3.78052652e-01f, -5.69669530e-02f, -7.87608251e-02f, -1.55358957e-02f, -1.11170582e-01f, -6.11408018e-02f, -1.60562228e-02f, 9.96314213e-02f, 1.41421229e-01f, 1.86868161e-02f,
  -6.86195940e-02f, 2.12542444e-01f, 7.92023316e-02f, -5.44147864e-02f, -4.66905199e-02f, 7.98310563e-02f, 7.46992230e-02f, 1.05502643e-01f, 1.53328419e-01f, 2.33209267e-01f,
  2.48157322e-01f, -4.80340831e-02f, 1.92140102e-01f, -8.78838375e-02f, -1.80973280e-02f, -8.59732851e-02f, -7.42005184e-02f, 1.07856803e-02f, 7.13677034e-02f, -5.41302897e-02f,
  1.08518638e-01f, -5.74653633e-02f, 3.87803018e-02f, 9.19409916e-02f, 1.73507705e-01f, 1.85703263e-01f, 2.03454167e-01f, 1.31090386e-02f, 1.39726892e-01f, 2.87230372e-01f,
  -3.19084711e-02f, 1.78724959e-01f, -4.93344180e-02f, -1.01803720e-01f, 4.25832458e-02f, 5.92206493e-02f, -4.97320928e-02f, -2.79653650e-02f, -4.12394181e-02f, 2.48323262e-01f,
  -1.70791239e-01f, 6.89081475e-02f, 1.23985242e-02f, -5.54380454e-02f, -2.28856541e-02f, 9.52113569e-02f, 4.11559045e-02f, 3.74146163e-01f, -4.74852771e-02f, -1.56496495e-01f,
  -2.49868378e-01f, 3.19136195e-02f, 1.85391128e-01f, -1.09706461e-01f, -1.47732317e-01f, 1.50772899e-01f, 3.39673847e-01f, -1.77024305e-01f, 1.99742943e-01f, 3.83430049e-02f,
  2.73200363e-01f, 1.61654010e-01f, -7.17945248e-02f, 2.19803248e-02f, 7.69597068e-02f, -8.71617049e-02f, 3.49162780e-02f, 1.53985932e-01f, 3.95014919e-02f, 8.09167325e-02f,
  -3.57469022e-02f, 1.87840275e-02f, 7.61629343e-02f, -5.06998301e-02f, -1.54922351e-01f, -5.20285778e-02f, 1.17280073e-01f, 2.51876682e-01f, 1.46017358e-01f, -4.79611084e-02f,
  2.37438142e-01f, 1.13346584e-01f, -5.13672940e-02f, 1.74672186e-01f, -2.94638909e-02f, -3.38128775e-01f, 1.16579063e-01f, 8.56226832e-02f, 1.33711129e-01f, 5.91774434e-02f,
  1.79336324e-01f, -1.21504040e-02f, -2.41950601e-01f, -1.59484729e-01f, 4.91796955e-02f, -1.44828722e-01f, 1.96584091e-01f, -1.65887624e-01f, -2.61788577e-01f, 2.03013480e-01f,
  -1.49371892e-01f, 1.53749660e-01f, 7.98770934e-02f, -8.34894627e-02f, 9.31957737e-02f, 1.56317055e-01f, 2.27126464e-01f, 1.23283863e-01f, 1.15742661e-01f, 1.30046785e-01f,
  -3.37306783e-02f, -6.76692203e-02f, 2.07583964e-01f, 2.03317195e-01f, -1.81234851e-01f, 9.21744034e-02f, -1.01601325e-01f, 2.29472905e-01f, 1.61675900e-01f, -4.76082824e-02f,
  -1.75475553e-01f, 1.19808070e-01f, -9.25092548e-02f, 2.71059006e-01f, -1.76835641e-01f, -1.91900849e-01f, 1.75069422e-01f, 1.79149255e-01f, 1.49974748e-01f, 2.48107418e-01f,
  5.52373715e-02f, 6.20586909e-02f, -1.49264261e-01f, -1.21311828e-01f, 1.47263650e-02f, -1.43152438e-02f, 5.20077087e-02f, 2.20240921e-01f, 4.71573696e-02f, 1.43220782e-01f,
  1.48052737e-01f, 5.74088581e-02f, -1.56851672e-02f, 2.06442609e-01f, 1.42848715e-01f, 4.08112295e-02f, 3.08004141e-01f, -4.09380570e-02f, 2.40532622e-01f, 1.53036371e-01f,
  1.21243343e-01f, 7.91759118e-02f, 1.92607284e-01f, 5.03233820e-02f, 9.91674215e-02f, 8.05013776e-02f, 1.13908529e-01f, -1.85838360e-02f, 1.25616431e-01f, 7.97814801e-02f,
  9.68527123e-02f, 1.29610747e-01f, -1.95251644e-01f, 2.29176641e-01f, -1.41470924e-01f, -5.08759953e-02f, 2.58179486e-01f, 2.12292783e-02f, 3.98615003e-01f, 3.30850661e-01f,
  1.45105362e-01f, 9.14302543e-02f, 3.55033986e-02f, -1.26250327e-01f, 1.58555210e-02f, -1.78330585e-01f, 1.37200847e-01f, 1.99562371e-01f, 2.98407644e-01f, -8.95520821e-02f,
  1.94296941e-01f, 1.42213494e-01f, -1.44608974e-01f, 2.90367484e-01f, 9.16426703e-02f, 1.47129158e-02f, -1.01421429e-02f, -8.95095840e-02f, -6.95985407e-02f, -3.66986543e-02f,
  2.30804354e-01f, -1.10480912e-01f, 1.06185906e-01f, 2.34942287e-02f, -5.39929159e-02f, -5.76879010e-02f, -1.21522352e-01f, -9.46282409e-03f, -3.78610462e-01f, 7.95296133e-02f,
  -1.01367183e-01f, -1.93468690e-01f, 1.40281022e-01f, 8.00381601e-02f, -1.45556748e-01f, 2.12440193e-01f, 1.30712250e-02f, 1.39548793e-01f, 2.05503464e-01f, -3.55760567e-02f,
  1.20112576e-01f, -1.36134341e-01f, 1.82769313e-01f, 2.89717644e-01f, 1.79584026e-01f, 2.31152788e-01f, 8.56979042e-02f, 1.14238635e-01f, 1.30531400e-01f, 5.16395196e-02f,
  -2.20510602e-01f, 3.68609605e-03f, 2.15917632e-01f, 1.91883028e-01f, 3.27347249e-01f, -2.22021088e-01f, -2.36857474e-01f, 7.39563331e-02f, 4.32116203e-02f, 1.33599862e-01f,
  1.35628030e-01f, -8.01968575e-02f, 3.32957000e-01f, 2.87119269e-01f, 6.20629676e-02f, -1.05214536e-01f, 1.20766386e-01f, 1.05684146e-01f, 1.83340162e-01f, -1.16786890e-01f,
  -1.66145205e-01f, 2.45325174e-03f, 1.77893266e-01f, -9.27836299e-02f, 1.67299926e-01f, 1.07683778e-01f, -2.55773962e-01f, -7.82795064e-03f, 4.14108306e-01f, 1.73785821e-01f,
  7.48652667e-02f, 2.64275879e-01f, -8.89063701e-02f, -2.81458020e-01f, -1.20758891e-01f, 2.36532748e-01f, 1.82289053e-02f, 4.64141257e-02f, 3.16124618e-01f, 3.16288352e-01f,
  3.62745039e-02f, -1.39989510e-01f, -5.08768298e-02f, 1.35867566e-01f, 1.50924489e-01f, -1.59032404e-01f, -3.09190631e-01f, -1.79831326e-01f, 2.24612579e-01f, -9.78316367e-02f,
  -8.89439210e-02f, 5.14608845e-02f, 6.25224411e-02f, -1.53862804e-01f, 1.80956960e-01f, 1.45124391e-01f, 6.90345913e-02f, 1.35332689e-01f, 1.57413542e-01f, 7.45629817e-02f,
  9.38005894e-02f, 1.48788810e-01f, 1.95282295e-01f, 1.46934107e-01f, -2.08644103e-02f, 9.40828100e-02f, -2.27230281e-01f, -2.62780078e-02f, -3.32464814e-01f, 1.42357126e-01f,
  2.80209064e-01f, 1.57527909e-01f, 1.78190079e-02f, 5.44803031e-02f, -8.34003687e-02f, 2.05903277e-01f, 3.64813060e-01f, -1.16194248e-01f, -3.01162720e-01f, -6.41487399e-03f,
  -1.14657655e-02f, -1.31439567e-01f, -1.96502537e-01f, 1.34546697e-01f, 1.79633230e-01f, -6.56471848e-02f, 1.02584384e-01f, 2.21786454e-01f, -1.53265661e-02f, -1.91806883e-01f,
  3.74047607e-01f, 2.20529228e-01f, 2.77248323e-01f, -2.39853933e-02f, 1.14400228e-02f, 3.55359048e-01f, 3.54915947e-01f, 2.16681153e-01f, -1.62698761e-01f, 1.54876798e-01f,
  -7.45653640e-03f, -2.98424028e-02f, 3.39285821e-01f, 2.36645807e-03f, 4.81001794e-01f, -4.75427732e-02f, 7.81205595e-02f, -3.12285185e-01f, 6.34593293e-02f, 1.59652606e-01f,
  -1.13984741e-01f, 4.33517486e-01f, -8.17151144e-02f, -1.09970942e-01f, -2.29380965e-01f, 2.69917876e-01f, 1.12453990e-01f, 1.77912146e-01f, 2.60981768e-02f, 2.56689280e-01f,
  -4.81439643e-02f, -2.84804374e-01f, 2.87289303e-02f, 1.45268798e-01f, 5.25050499e-02f, 4.44161408e-02f, 6.48962008e-03f, -1.94023326e-02f, 1.79758519e-02f, 1.68927584e-03f,
  -8.31352323e-02f, -9.36899409e-02f, -1.78481653e-01f, 8.63193795e-02f, 3.87915760e-01f, 1.91385210e-01f, 1.72281086e-01f, 6.30817264e-02f, -1.32413045e-01f, -5.20924032e-02f,
  -7.95960650e-02f, -2.38554701e-02f, -9.57295671e-02f, 1.69213623e-01f, 1.13884725e-01f, -2.41946131e-01f, -9.88048464e-02f, 2.34555423e-01f, 1.99200734e-01f, -1.00880757e-01f,
  1.96345448e-01f, 2.22078547e-01f, -2.31732093e-02f, -3.20579678e-01f, 4.05897200e-01f, 5.43306116e-03f, 1.94983184e-01f, -1.54581860e-01f, -2.62293309e-01f, 2.91718356e-02f,
  1.93809837e-01f, 3.49350899e-01f, -2.80571021e-02f, 5.76482713e-02f, 1.22311182e-01f, 4.12548669e-02f, 1.57496780e-01f, -2.47284979e-01f, 3.96621257e-01f, -5.12211621e-02f,
  2.85270691e-01f, -3.38392705e-01f, 1.16878092e-01f, 1.59572765e-01f, 2.66815156e-01f, 1.84845015e-01f, 3.25508490e-02f, -2.28508160e-01f, -3.29872638e-01f, 3.50028872e-02f,
  1.77026764e-01f, -4.96272044e-03f, -4.14429158e-02f, 1.59648001e-01f, 1.27899319e-01f, -1.09556541e-01f, 1.07773840e-01f, 1.80925444e-01f, 2.23235577e-01f, 1.79968089e-01f,
  2.16635466e-01f, 1.75215036e-01f, 1.48648202e-01f, 1.14104800e-01f, 5.19247837e-02f, 1.35752603e-01f, -1.72242802e-02f, -8.20658281e-02f, 2.61406779e-01f, 1.34058192e-03f,
  1.48862684e-02f, 1.34455487e-02f, -2.84600351e-02f, 4.43765670e-01f, -3.04147899e-01f, -1.00756921e-01f, 4.77491803e-02f, 1.43234611e-01f, 1.68105140e-01f, -7.47791231e-02f,
  -5.07440753e-02f, 8.34007487e-02f, 2.28214577e-01f, -1.24020264e-01f, -3.29874218e-01f, 1.37751654e-01f, 7.83865303e-02f, 2.17789188e-01f, 1.28119662e-01f, 1.19611003e-01f,
  3.16069305e-01f, -1.49206340e-01f, 1.69471297e-02f, -6.62260130e-02f, -4.47764322e-02f, 9.72121060e-02f, 2.00175136e-01f, -3.44907194e-02f, 1.07461818e-01f, -1.27922833e-01f,
  -6.91441521e-02f, 5.74406460e-02f, -9.26382840e-02f, -2.68321723e-01f, -2.95781344e-01f, 5.80912121e-02f, 7.95947239e-02f, 2.11900681e-01f, 1.40859604e-01f, 1.04795769e-01f,
  1.28580555e-02f, 3.43379676e-01f, 1.42356694e-01f, 7.50339404e-02f, 3.94882411e-02f, -1.49202153e-01f, 7.29278177e-02f, -2.92562664e-01f, -4.52618254e-03f, 7.14945197e-02f,
  -3.97341959e-02f, 1.29094958e-01f, 2.70277299e-02f, 2.70078871e-02f, 1.76073599e-03f, 3.40969227e-02f, 3.44736539e-02f, 1.51624724e-01f, 4.92169857e-02f, -1.16919883e-01f,
  7.75863454e-02f, 1.34848282e-01f, 3.01482826e-01f, -6.72999322e-02f, -7.38353580e-02f, 1.76056802e-01f, -7.34039247e-02f, 3.43280554e-01f, -1.60284266e-01f, 1.56950980e-01f,
  3.88487279e-02f, 2.87743062e-01f, -1.26053944e-01f, -1.09292842e-01f, -9.43495259e-02f, 7.09489882e-02f, 1.89825773e-01f, -2.71105999e-03f, -9.41950083e-02f, 1.71368062e-01f,
  -1.57934874e-02f, -1.09512210e-01f, 3.76389474e-01f, 9.55393352e-03f, 1.26168132e-01f, -2.72551954e-01f, -3.91408764e-02f, -1.09055027e-01f, -6.70936331e-02f, 1.07603922e-01f,
  9.92171317e-02f, 5.70073053e-02f, 1.27033954e-02f, -7.15344772e-02f, -1.87434569e-01f, -2.99666405e-01f, -2.47575924e-01f, 6.31368831e-02f, -1.57729328e-01f, 2.13369086e-01f,
  2.58177463e-02f, 2.78995067e-01f, 2.79926926e-01f, 2.28139386e-02f, 1.18047260e-01f, -1.66417271e-01f, 1.09995983e-03f, 6.88902335e-03f, -8.07086080e-02f, -6.99044466e-02f,
  9.21432227e-02f, -9.48176309e-02f, 1.39084548e-01f, 7.96459690e-02f, -1.63117666e-02f, 7.12089464e-02f, 2.80257642e-01f, 1.06729403e-01f, 2.57737517e-01f, 2.28408962e-01f,
  1.90337896e-01f, 1.71165273e-01f, 7.63969943e-02f, 1.70881316e-01f, -2.46525243e-01f, 2.50634365e-02f, 3.14605504e-01f, -2.13440359e-01f, -3.09712380e-01f, 7.39771202e-02f,
  2.57453680e-01f, 4.40494210e-01f, -4.23320867e-02f, -1.81714281e-01f, 1.24605615e-02f, 4.80908453e-02f, 3.84512730e-03f, 3.16795260e-01f, 1.94034785e-01f, 3.71693820e-01f,
  7.15836734e-02f, -1.32299498e-01f, 1.46043450e-01f, 1.81104347e-01f, 4.57291961e-01f, 6.96066245e-02f, 3.80634852e-02f, 3.08800668e-01f, 5.53721935e-03f, 4.25964780e-03f,
  4.69833255e-01f, -9.56616923e-02f, -4.48592417e-02f, 1.36892125e-01f, 1.58056185e-01f, -5.21865934e-02f, -1.42376810e-01f, -6.12066202e-02f, -4.03053872e-02f, 1.16969727e-01f,
  1.69124871e-01f, -1.18406557e-01f, -1.28437251e-01f, -4.30346392e-02f, -6.71495125e-02f, 1.30085453e-01f, -6.99343160e-02f, 3.18014459e-03f, -6.64553046e-02f, 1.86191753e-01f,
  -4.57158647e-02f, 2.68326271e-02f, 1.85193270e-01f, 8.56291503e-02f, -3.93040448e-01f, -6.56320676e-02f, -3.58290493e-01f, 2.03043729e-01f, 2.28114828e-01f, 2.45674208e-01f,
  -1.01900645e-01f, 2.45666638e-01f, 1.62064195e-01f, 1.96142316e-01f, -1.30608194e-02f, 6.52033091e-02f, -3.95264365e-02f, 9.80067551e-02f, 1.16264578e-02f, 1.49604127e-01f,
  -5.39948232e-02f, 2.15654194e-01f, 1.26583666e-01f, 1.48105714e-02f, -2.00608343e-01f, -1.25490233e-01f, 4.24631149e-01f, 3.41089845e-01f, -1.83048129e-01f, 5.59499152e-02f,
  -1.64541323e-02f, -1.49942368e-01f, -2.45744139e-01f, 1.42490435e-02f, 7.64643699e-02f, -2.24539954e-02f, -2.97742821e-02f, 5.11735678e-02f, -3.88232097e-02f, -2.23307639e-01f,
  -2.80830473e-01f, 3.64224846e-03f, 4.40808147e-01f, -2.14919612e-01f, 3.19359899e-02f, 2.76877999e-01f, 2.77159959e-01f, 2.94701964e-01f, -1.12471938e-01f, -8.52335617e-02f,
  2.70151943e-01f, -4.12361883e-02f, -1.71162300e-02f, 2.34268438e-02f, 1.98002934e-01f, -2.07587808e-01f, -6.77992636e-03f, 8.35753679e-02f, 1.93106204e-01f, -9.29783434e-02f,
  1.96945190e-01f, 1.20337516e-01f, 1.35860547e-01f, -1.83867276e-01f, -2.85845965e-01f, -1.08034238e-01f, 2.48869359e-02f, -6.28636956e-01f, 2.82905042e-01f, 3.27059031e-01f,
  3.51428837e-01f, 9.95065793e-02f, 8.69816989e-02f, 5.42773940e-02f, 9.51002538e-02f, 4.56552878e-02f, 1.07733816e-01f, 6.37649745e-02f, -1.08781464e-01f, -6.11251444e-02f,
  1.34314343e-01f, 1.63143557e-02f, 1.26630068e-01f, -5.31336628e-02f, -1.88741237e-01f, -6.23247251e-02f, -2.72756931e-03f, 1.46578075e-02f, -1.56010091e-01f, 4.69936840e-02f,
  1.41216770e-01f, 5.56950942e-02f, 8.49422254e-03f, -6.98088557e-02f, -1.48504615e-01f, 1.01152226e-01f, 4.23727594e-02f, 1.23103797e-01f, -9.30709839e-02f, 8.51397216e-02f,
  6.04130588e-02f, 5.69335371e-02f, 9.81601030e-02f, -1.18095152e-01f, -7.67833814e-02f, -2.54559666e-01f, 2.03961030e-01f, -2.01750726e-01f, 1.70400172e-01f, 4.83855665e-01f,
  -5.31356223e-02f, -7.85335749e-02f, 7.51602054e-02f, 1.42671287e-01f, 8.31507146e-02f, 1.51499495e-01f, 1.70278206e-01f, -1.33493051e-01f, 2.37169236e-01f, 6.47120178e-02f,
  -6.61462322e-02f, 2.03728199e-01f, 2.84127384e-01f, -4.63792384e-02f, 5.29552773e-02f, -2.96182275e-01f, 2.10882053e-01f, -2.67122418e-01f, 7.32083395e-02f, -2.54659146e-01f,
  1.22607201e-01f, 6.38707802e-02f, 2.92938240e-02f, 1.28260836e-01f, 9.33082774e-02f, 4.87456620e-02f, -1.33358076e-01f, 1.75493568e-01f, 1.27601847e-01f, -3.78604350e-03f,
  -1.74289588e-02f, 1.21568881e-01f, 3.89342159e-02f, 6.63473159e-02f, -2.66324612e-03f, 4.57204878e-02f, -2.42572296e-02f, -1.30948544e-01f, -1.68656468e-01f, 4.79156636e-02f,
  2.59045422e-01f, -1.88610151e-01f, -2.07904905e-01f, 1.64154440e-01f, -3.26241672e-01f, -1.73950315e-01f, 3.03132653e-01f, -1.45136952e-01f, 1.95843771e-01f, 1.05999969e-01f,
  -1.33620784e-01f, 1.84376091e-01f, -1.14801377e-01f, 4.03197557e-02f, -1.71065778e-01f, 1.15850851e-01f, 9.83385220e-02f, 1.57398626e-01f, -1.04466781e-01f, -4.85932827e-02f,
  4.09461111e-02f, -8.17457810e-02f, 1.52586713e-01f, -1.17054872e-01f, -5.72136529e-02f, -2.00181063e-02f, 3.53390783e-01f, -6.70958683e-02f, 6.33309111e-02f, 3.12775791e-01f,
  -1.33826256e-01f, 1.53749347e-01f, -5.60966134e-02f, -2.82137562e-02f, 1.27585813e-01f, 7.49278814e-02f, 1.60954148e-01f, -1.26238436e-01f, -1.10736541e-01f, 2.23759040e-02f,
  -2.86302008e-02f, 3.11002523e-01f, 1.97731942e-01f, -9.24141034e-02f, 7.84330517e-02f, 2.52266407e-01f, -3.13315392e-02f, 5.55168763e-02f, -7.73507282e-02f, -1.13951676e-01f,
  1.40237555e-01f, 1.08292341e-01f, 1.13104388e-01f, 1.11926101e-01f, 4.65682894e-02f, 9.91752744e-02f, 6.01000339e-02f, 9.61811766e-02f, 8.29056650e-02f, 2.50527173e-01f,
  -1.12045810e-01f, 6.80891192e-03f, -2.14623613e-03f, -1.52738184e-01f, 4.28534336e-02f, -1.50293708e-01f, 1.78458199e-01f, 2.02519864e-01f, -1.27405738e-02f, -1.44170508e-01f,
  -2.17100829e-01f, -2.27322027e-01f, 1.05566695e-01f, 1.57993674e-01f, 1.91660762e-01f, 2.09389240e-01f, -2.31449619e-01f, 3.49537246e-02f, 1.65807292e-01f, 1.05029542e-03f,
  3.43991786e-01f, -1.25811458e-01f, -1.37824059e-01f, 2.25127608e-01f, 1.92774460e-01f, -1.32319778e-01f, 4.08317477e-01f, -1.10004559e-01f, -3.38837458e-03f, 7.81648457e-02f,
  -2.43819326e-01f, -1.22851901e-01f, -6.71780184e-02f, -7.24533647e-02f, 2.26634238e-02f, 4.22235616e-02f, 1.69666722e-01f, -1.32139474e-01f, 1.11528501e-01f, -3.79363447e-02f,
  1.17639629e-02f, -3.02198641e-02f, -2.18723789e-01f, -1.27935454e-01f, 4.52088602e-02f, 2.17550978e-01f, -4.46611606e-02f, -1.36232167e-01f, 1.91380847e-02f, -5.82580008e-02f,
  -4.14494365e-01f, 1.25872597e-01f, -1.59595549e-01f, 9.24118534e-02f, 2.27784723e-01f, 9.13873240e-02f, 1.15761615e-01f, 1.49765059e-01f, 2.61124402e-01f, 4.91639860e-02f,
  -1.14672810e-01f, 1.45203872e-02f, 5.23013361e-02f, -2.45734341e-02f, -5.26360683e-02f, 3.05269787e-04f, -1.54398769e-01f, -7.92129263e-02f, -2.79102195e-02f, 2.13686720e-01f,
  2.84408689e-01f, -9.10392702e-02f, 2.68931575e-02f, 9.20143425e-02f, -3.72171611e-01f, -1.23788811e-01f, -7.13011846e-02f, -1.01596929e-01f, 2.62214184e-01f, 2.48644631e-02f,
  -1.44684926e-01f, 6.55933768e-02f, 3.25736433e-01f, -8.72509181e-03f, 1.69076562e-01f, -2.38081411e-01f, 1.42381107e-02f, -1.19208798e-01f, 1.00616008e-01f, 1.46399871e-01f,
  1.00197934e-01f, 2.94585198e-01f, 2.14806329e-02f, -1.83516771e-01f, -3.38688284e-01f, 3.89290601e-01f, -7.28402808e-02f, -4.79465798e-02f, 3.19036633e-01f, 1.48627222e-01f,
  2.05146253e-01f, 5.62041327e-02f, 7.68089965e-02f, -1.64290637e-01f, -3.57856341e-02f, 2.88524985e-01f, -2.76496470e-01f, -2.56159306e-02f, 2.83774793e-01f, -4.71563190e-02f,
  -6.99400902e-02f, 1.54290469e-02f, -1.53296292e-01f, -1.82373360e-01f, 2.14598700e-02f, 1.40208110e-01f, -1.40775576e-01f, -1.13856249e-01f, -7.63291717e-02f, 2.10097656e-01f,
  1.26702622e-01f, 8.56604502e-02f, 1.32630050e-01f, 2.19755201e-03f, -9.95838456e-03f, 2.96595663e-01f, 2.39665303e-02f, 8.60479325e-02f, 1.68154761e-01f, -1.85269147e-01f,
  2.38834739e-01f, 1.44765839e-01f, 1.72841057e-01f, 1.65031310e-02f, -1.37864277e-01f, 1.54212937e-01f, -3.73093426e-01f, -6.65492639e-02f, 9.19251144e-02f, -9.85974446e-02f,
  2.47976147e-02f, -8.61095358e-03f, 8.56074020e-02f, 2.40462109e-01f, -7.05440491e-02f, 8.17292780e-02f, -2.56461024e-01f, 2.48459592e-01f, -5.42798974e-02f, 1.17258646e-01f,
  1.82161331e-02f, 2.26368889e-01f, 4.52167273e-01f, -7.75419921e-02f, -2.68939827e-02f, 2.35518187e-01f, 2.86273688e-01f, 2.70727217e-01f, -7.47757673e-04f, 1.96918622e-01f,
  6.04521967e-02f, 5.23915701e-02f, 1.42510414e-01f, 1.41598687e-01f, 1.15560062e-01f, -7.50098517e-03f, 2.05252409e-01f, 1.70664384e-03f, 2.84902245e-01f, 3.31481285e-02f,
  -1.43491194e-01f, 1.72295928e-01f, 6.48031607e-02f, -7.01115280e-02f, 4.75889742e-02f, -2.03164205e-01f, 1.42034397e-01f, -3.49867791e-02f, -4.59297188e-02f, 2.24324524e-01f,
  -1.02476768e-01f, -5.62083066e-01f, 1.58077121e-01f, 6.50627911e-02f, 1.92947745e-01f, -2.01045279e-03f, 4.54883091e-02f, 4.70985845e-02f, -1.33213922e-01f, -1.46557748e-01f,
  -1.45392582e-01f, 7.14973062e-02f, -1.28301203e-01f, 9.84762460e-02f, -2.60224462e-01f, 2.16161668e-01f, -6.37598336e-02f, -1.42669961e-01f, 1.25398308e-01f, -2.42857754e-01f,
  4.03051764e-01f, 1.35256261e-01f, 2.65431907e-02f, 1.17248902e-02f, -9.65283588e-02f, 2.04544086e-02f, -2.94752046e-02f, -7.78796747e-02f, -2.68172799e-03f, 4.41547006e-01f,
  4.20970201e-01f, -9.49348509e-02f, 6.97499588e-02f, 2.01145142e-01f, -1.68511316e-01f, 5.99682368e-02f, -1.56774614e-02f, 2.66828775e-01f, -7.19973221e-02f, 1.31825909e-01f,
  -9.31093544e-02f, 2.87348479e-02f, 7.60779008e-02f, -1.60048544e-01f, 3.07640493e-01f, -1.11378103e-01f, -2.75469154e-01f, 1.36962637e-01f, -2.73599084e-02f, -4.77296785e-02f,
  -1.77296698e-01f, 1.18310928e-01f, -7.77133480e-02f, -2.69855648e-01f, -1.41568994e-02f, 1.55980870e-01f, -3.68608981e-01f, 3.18521224e-02f, -1.38881698e-01f, 2.74690747e-01f,
  1.72113687e-01f, -1.10491507e-01f, 2.78922558e-01f, 4.97436561e-02f, 2.54105657e-01f, 5.92393100e-01f, 1.30644534e-02f, 1.20847961e-02f, 8.84531066e-02f, -2.37268172e-02f,
  -2.45698653e-02f, 1.30385503e-01f, 1.26161367e-01f, -3.03778201e-02f, -1.52769431e-01f, -9.85878855e-02f, -1.44725904e-01f, 1.63318038e-01f, -1.64399326e-01f, 1.89762637e-01f,
  1.57006353e-01f, -8.11848566e-02f, 1.70606151e-02f, -1.16674777e-03f, 3.50676686e-01f, 8.56595561e-02f, 3.14245299e-02f, 9.52479546e-04f, 3.98118757e-02f, 2.34476745e-01f,
  5.38283726e-04f, 5.62313236e-02f, 9.36165452e-02f, 1.87912092e-01f, 1.80231154e-01f, -5.76051176e-02f, 6.66738302e-02f, 2.55891114e-01f, -6.26353472e-02f, 6.17157035e-02f,
  -8.23449716e-02f, 1.18305951e-01f, 1.40225917e-01f, 8.62664208e-02f, 1.88168753e-02f, -1.40422059e-03f, -1.45437997e-02f, -2.40833357e-01f, 2.23437563e-01f, -3.78905013e-02f,
  -1.40678987e-01f, 6.23971336e-02f, -3.84402312e-02f, 6.39183670e-02f, -1.01033442e-01f, 3.78996767e-02f, -4.66599315e-02f, -2.48846024e-01f, -5.55155799e-02f, 2.03003302e-01f,
  -2.65310824e-01f, 2.27070644e-01f, -2.66923383e-02f, 2.27444321e-01f, 2.92735130e-01f, 1.01433217e-03f, 2.27463588e-01f, 9.12504047e-02f, 1.32547259e-01f, 3.28183800e-01f,
  9.87516195e-02f, 4.79000546e-02f, -2.40306221e-02f, 4.07685488e-02f, 7.17653185e-02f, 8.12686682e-02f, -2.03073964e-01f, -1.62545457e-01f, 2.19935387e-01f, -3.26769277e-02f,
  3.46314639e-01f, -1.36934653e-01f, -7.14812875e-02f, 5.19900024e-02f, -1.98319443e-02f, -1.52875185e-01f, -3.00885767e-01f, 6.61261706e-03f, 3.63851083e-03f, 7.94634670e-02f,
  1.06298372e-01f, 2.08750870e-02f, -1.02967443e-02f, 2.65029728e-01f, -2.08449498e-01f, 5.63770346e-02f, -9.43661854e-02f, 2.79685289e-01f, -1.64089147e-02f, 2.36848518e-01f,
  -1.13657817e-01f, 6.39079288e-02f, -2.48668119e-01f, -3.22833240e-01f, 4.59615439e-01f, -8.29172805e-02f, 5.52084222e-02f, 4.43646699e-01f, -4.13004644e-02f, -2.90792454e-02f,
  -3.46755534e-02f, 8.97313580e-02f, -1.06349051e-01f, 2.01803625e-01f, -7.41648301e-02f, 1.61012352e-01f, -3.82356010e-02f, -1.60828128e-01f, 3.12249502e-03f, 7.48725533e-02f,
  3.80560815e-01f, -9.33739617e-02f, 4.88655902e-02f, -3.06880593e-01f, 2.40392312e-01f, -2.18074799e-01f, -2.56679766e-02f, -2.83626318e-01f, -8.75401720e-02f, -7.80062377e-02f,
  7.88662136e-02f, 1.89847991e-01f, 2.85568327e-01f, 2.83826254e-02f, -3.18429694e-02f, -2.72842753e-03f, 4.64597791e-02f, 4.58984338e-02f, -7.70996734e-02f, 7.89557844e-02f,
  -5.15899435e-02f, -1.25025913e-01f, -1.56676874e-01f, -2.15328597e-02f, -2.07095593e-01f, 5.85165760e-03f, 1.19224161e-01f, 5.59763350e-02f, 2.13508204e-01f, -3.99739482e-02f,
  -1.82403252e-01f, -1.42159974e-02f, 1.36199966e-01f, -1.11423962e-01f, -2.65328772e-02f, -4.51242402e-02f, 5.44672720e-02f, 2.99326275e-02f, -2.56538540e-01f, -2.69725826e-02f,
  3.50807756e-02f, -8.44669715e-02f, 5.70038594e-02f, -1.13754328e-02f, -4.96659763e-02f, -2.55684584e-01f, 2.05839545e-01f, -2.47057667e-03f, -2.23368138e-01f, 1.29195884e-01f,
  -3.63506079e-02f, 3.25611420e-02f, 1.49380624e-01f, 1.38445407e-01f, -8.57638381e-03f, 1.71939746e-01f, 2.25734159e-01f, 1.09537311e-01f, 8.70815963e-02f, -2.83014178e-01f,
  2.82717407e-01f, 2.77740248e-02f, 2.36714810e-01f, -3.18173468e-01f, -8.61085206e-03f, 1.09251291e-01f, -1.68559011e-02f, 2.99077362e-01f, -6.70079291e-02f, -2.61004508e-01f,
  -7.12545812e-02f, 1.33825734e-01f, -9.24814492e-02f, 3.33560765e-01f, -1.20648015e-02f, 1.65098742e-01f, -2.06635073e-02f, 4.22321185e-02f, -8.13282579e-02f, 5.86351678e-02f,
  1.15846708e-01f, -1.28531875e-03f, 2.36760348e-01f, 1.47587806e-01f, 1.07853740e-01f, 7.36156181e-02f, -3.00624017e-02f, 1.04752004e-01f, 1.29399061e-01f, -9.34505761e-02f,
  4.62686829e-02f, 1.48456976e-01f, -2.03089520e-01f, -8.45211893e-02f, 2.75062293e-01f, -1.44313565e-02f, -1.30660444e-01f, 3.87514643e-02f, -1.51462913e-01f, -9.04199108e-02f,
  1.56354040e-01f, -1.07074872e-01f, 2.70577490e-01f, -3.41410786e-01f, -2.25678291e-02f, 1.72600895e-01f, 1.32835656e-01f, -2.20206194e-02f, 1.82384968e-01f, 3.35194796e-01f,
  1.57336399e-01f, 3.42907339e-01f, -3.23665403e-02f, -5.41840792e-02f, -1.68619886e-01f, -7.42143691e-02f, -4.04253788e-02f, -4.50315475e-02f, -1.91125423e-01f, -2.41482139e-01f,
  -1.50876194e-01f, -6.57735690e-02f, -2.31096502e-02f, 1.27058014e-01f, -5.40863052e-02f, 7.11445287e-02f, -2.21474096e-01f, 7.33466074e-02f, 2.34676525e-02f, -1.47918090e-01f,
  -1.61448166e-01f, -7.52835497e-02f, -1.72511294e-01f, 1.26442179e-01f, 2.16364205e-01f, 2.06209021e-03f, 2.54301250e-01f, -3.19552422e-02f, -1.22314304e-01f, -1.59913272e-01f,
  -2.45111436e-02f, -1.32471368e-01f, 2.32891470e-01f, 4.06027921e-02f, 1.00205049e-01f, -5.86044276e-03f, 2.76440948e-01f, 1.55365646e-01f, -8.59858319e-02f, 1.27643824e-01f,
  1.23932892e-02f, 9.40591097e-02f, 1.59599274e-01f, 6.73185149e-03f, -8.77935365e-02f, -1.09428331e-01f, 1.01087384e-01f, 2.27777019e-01f, 3.00692115e-02f, -2.40142718e-02f,
  1.42616361e-01f, 2.85796136e-01f, -6.96445927e-02f, 1.20147176e-01f, -9.38455686e-02f, 1.26676440e-01f, 1.53922543e-01f, 9.65797603e-02f, 1.11394994e-01f, 1.28188908e-01f,
  -9.72039253e-02f, -1.30999714e-01f, 2.69191921e-01f, -1.29099444e-01f, 6.36071190e-02f, -1.61635831e-01f, 1.05045952e-01f, -7.04771653e-02f, 1.79048836e-01f, 1.01574399e-01f,
  7.07988366e-02f, -1.18279032e-01f, 1.42446876e-01f, 9.41477790e-02f, 1.89162299e-01f, -1.31652951e-01f, -2.91369930e-02f, 3.74118623e-04f, -2.35962253e-02f, 1.72645465e-01f,
  8.45052749e-02f, 8.46883059e-02f, -1.06676750e-01f, 1.01927601e-01f, 4.27685417e-02f, -1.21445648e-01f, 2.44215444e-01f, -5.52704260e-02f, -1.63377058e-02f, -3.19533944e-02f,
  -9.81762782e-02f, -2.13557020e-01f, 2.20696673e-01f, 4.92383093e-02f, 1.72515750e-01f, 2.71495461e-01f, 2.83380635e-02f, 3.75112817e-02f, 9.23214257e-02f, 2.73052938e-02f,
  6.83486611e-02f, 1.00446809e-02f, -2.04682052e-01f, -1.63956538e-01f, 8.92675892e-02f, -7.38563091e-02f, 1.30102739e-01f, -5.96250556e-02f, 5.79197258e-02f, -1.36960670e-01f,
  -7.93470144e-02f, 1.79101881e-02f, -3.27121645e-01f, 1.74976408e-01f, -4.48428169e-02f, 4.19948855e-03f, 4.87475991e-01f, 1.60454243e-01f, 2.25496609e-02f, 1.76853642e-01f,
  -2.55923033e-01f, 2.14745253e-01f, 1.16813757e-01f, 2.12273732e-01f, -3.55638117e-01f, 1.08289756e-01f, -1.24158196e-01f, 5.19551158e-01f, -1.12352110e-01f, -2.28582829e-01f,
  -1.38881847e-01f, 1.31985188e-01f, -2.43042216e-01f, -1.39262244e-01f, -1.49991572e-01f, 3.07314973e-02f, 6.07191384e-01f, 1.26218321e-02f, 4.18884605e-01f, 3.81858110e-01f,
  -2.65097111e-01f, 1.66081890e-01f, -3.71604800e-01f, 2.07687952e-02f, -8.32059756e-02f, 2.02049360e-01f, 1.45986676e-01f, -4.04996425e-03f, 2.09766269e-01f, -1.37676105e-01f,
  -6.59002364e-02f, 5.68401031e-02f, 1.33307263e-01f, 3.42976325e-03f, 2.18293406e-02f, 1.40112445e-01f, 1.57592803e-01f, -9.98441726e-02f, 6.11515380e-02f, 3.44806284e-01f,
  2.50869602e-01f, 5.35076745e-02f, 1.99388459e-01f, 6.64697587e-02f, 2.45298445e-01f, 1.19319856e-01f, 8.20187032e-02f, -7.66356811e-02f, -4.57971953e-02f, 5.81721999e-02f,
  -7.01894611e-02f, -5.20498818e-03f, -7.61662284e-03f, 1.36875913e-01f, -1.32619396e-01f, 2.85799265e-01f, 2.21381322e-01f, -2.34291553e-01f, 4.34512407e-01f, 1.30000994e-01f,
  -2.27460861e-01f, 9.53501686e-02f, -8.24776143e-02f, -1.87724933e-01f, -8.15012082e-02f, 5.16701303e-02f, 2.04616353e-01f, 8.61572102e-03f, 5.09644337e-02f, -7.50773177e-02f,
  -5.94110675e-02f, -7.96872228e-02f, 4.33236897e-01f, 2.26935837e-02f, 4.24149819e-03f, 1.17072664e-01f, -5.74124120e-02f, 2.21630707e-01f, 2.37589270e-01f, -1.51610270e-01f,
  -2.07668796e-01f, 2.58899391e-01f, -5.77497780e-02f, -9.77509022e-02f, 3.95742267e-01f, -3.71785089e-02f, 2.62562424e-01f, 5.27647547e-02f, -9.64701846e-02f, -2.36426264e-01f,
  -2.07969900e-02f, 1.59063756e-01f, -7.13348612e-02f, 2.24421084e-01f, 2.27926910e-01f, -7.44493529e-02f, -8.83868784e-02f, 2.21913055e-01f, 7.10468143e-02f, -1.62670672e-01f,
  3.52224372e-02f, 2.19045058e-01f, 3.22536901e-02f, -1.71675727e-01f, 7.78011829e-02f, 1.27856359e-01f, 4.27545607e-02f, 3.01706791e-02f, 4.03845124e-02f, 3.93850990e-02f,
  -1.56036302e-01f, 3.77373286e-02f, -1.10447612e-02f, 1.69524461e-01f, 1.31763160e-01f, -4.74988995e-03f, -1.52606055e-01f, -9.01929438e-02f, 3.55705798e-01f, -1.22809015e-01f,
  1.28504455e-01f, 1.68190435e-01f, -2.05544457e-01f, -1.43145055e-01f, 2.21716002e-01f, -1.69280246e-01f, 3.84799466e-02f, 2.29555413e-01f, 1.48494303e-01f, 2.61304468e-01f,
  -2.88858652e-01f, 1.69611737e-01f, 2.40463689e-01f, 1.07202649e-01f, 1.30744994e-01f, 1.93580806e-01f, -2.98095614e-01f, -1.04252860e-01f, 2.08403572e-01f, 1.62391230e-01f,
  1.49060979e-01f, 2.82438821e-03f, -1.47946000e-01f, 5.19332215e-02f, 8.87984782e-02f, -4.66362049e-04f, 8.18527788e-02f, 1.65306300e-01f, -8.06715935e-02f, 2.38984391e-01f,
  1.85127724e-02f, 1.13186091e-02f, 2.99636930e-01f, 8.40996206e-02f, 1.82097137e-01f, -1.05544880e-01f, -2.61648685e-01f, -5.58679663e-02f, 8.40285569e-02f, 1.36268988e-01f,
  1.69919640e-01f, -2.03090340e-01f, 1.81526706e-01f, -4.38554585e-02f, -1.78222448e-01f, 3.95040177e-02f, -1.89429060e-01f, 2.22085081e-02f, 1.25236452e-01f, 1.47444963e-01f,
  8.97170901e-02f, 1.21129751e-01f, 2.71799952e-01f, 1.75662473e-01f, -7.71413371e-02f, 1.28108412e-01f, 2.35792235e-01f, -9.12170261e-02f, 4.03517246e-01f, -3.42707098e-01f,
  -2.30099186e-01f, 8.51792172e-02f, -5.16281202e-02f, 2.42270872e-01f, 3.40566367e-01f, -2.07048029e-01f, 2.00025383e-02f, 4.29230966e-02f, 1.50297442e-02f, -1.14799485e-01f,
  2.12234899e-01f, -5.75266853e-02f, -2.99331900e-02f, -2.80475199e-01f, 3.37989219e-02f, 8.97173584e-02f, -1.46955341e-01f, -2.14749187e-01f, 7.66272172e-02f, 3.73925239e-01f,
  -8.63599591e-03f, 1.58567399e-01f, 2.68010736e-01f, 1.60780817e-01f, 4.96594273e-02f, 1.62508503e-01f, 1.44435735e-02f, -3.35666388e-01f, -6.09001219e-02f, 7.35014454e-02f,
  6.94555938e-02f, 1.49312848e-02f, 3.03846002e-01f, 3.77329350e-01f, -1.15874112e-01f, -9.13559869e-02f, 1.72316022e-02f, 1.27905428e-01f, 4.42787111e-02f, -2.26873588e-02f,
  -2.50657648e-01f, -7.90890902e-02f, 1.07436806e-01f, 1.06251627e-01f, 2.55958550e-02f, 2.20284000e-01f, 2.06797104e-02f, -1.56419367e-01f, 1.00040704e-01f, 3.95760946e-02f,
  3.88187580e-02f, -9.30156261e-02f, 4.42952812e-02f, 5.09664863e-02f, 1.80687204e-01f, 7.20334351e-02f, 1.56107545e-01f, 1.86503381e-01f, 1.28712520e-01f, 9.55561176e-03f,
  -1.12291098e-01f, -1.71418354e-01f, -3.10017020e-02f, -1.72228560e-01f, 2.77058512e-01f, 1.94796994e-01f, 5.92980385e-02f, 1.34769812e-01f, 1.75077036e-01f, 1.96103156e-02f,
  9.84187201e-02f, -1.25583723e-01f, -2.16202810e-01f, 9.63008329e-02f, 3.18125635e-01f, -1.28083482e-01f, 9.84668210e-02f, -1.78255618e-01f, 7.92030916e-02f, -2.54574895e-01f,
  -2.62862146e-01f, -4.06239405e-02f, -8.67088586e-02f, 8.94472152e-02f, 4.83407468e-01f, 3.73090565e-01f, -2.70031899e-01f, -1.72939077e-02f, -1.86103821e-01f, 4.41854224e-02f,
  4.10650790e-01f, 2.75154591e-01f, -1.92871466e-01f, 2.79708534e-01f, 2.29560081e-02f, -7.65408650e-02f, 2.95587987e-01f, -3.53215992e-01f, 2.06438020e-01f, 2.55639274e-02f,
  1.02831349e-01f, -2.65873909e-01f, -5.81353642e-02f, 3.29179049e-01f, -2.85752751e-02f, 3.70139927e-01f, 7.96294957e-02f, 1.62033048e-02f, 2.10286394e-01f, 1.85319245e-01f,
  -2.69598085e-02f, 2.24618077e-01f, -1.18406480e-02f, -2.37904154e-02f, -1.80704638e-01f, -5.26788831e-01f, 8.72757379e-03f, 1.12723321e-01f, 9.37030688e-02f, 1.90247163e-01f,
  7.83012528e-03f, 1.51555091e-01f, -2.10383488e-03f, -1.57165498e-01f, 2.12304778e-02f, -2.35213488e-02f, -7.54916668e-02f, 7.77106266e-03f, -7.33118579e-02f, -1.31857231e-01f,
  2.42214829e-01f, 1.40150651e-01f, 5.49762137e-02f, -8.08223784e-02f, 1.07894111e-02f, -7.28980899e-02f, 1.40852407e-01f, -2.10056175e-03f, 1.49106547e-01f, -4.46970426e-02f,
  -1.63054004e-01f, -2.62331843e-01f, 7.21613243e-02f, -1.90085918e-01f, -1.08581997e-01f, -2.19036072e-01f, -5.36750704e-02f, -1.57412156e-01f, 2.70219445e-02f, -2.72796135e-02f,
  -3.28033596e-01f, 5.19155338e-02f, -1.21335704e-02f, 2.05276906e-02f, 1.54529795e-01f, 1.67254284e-01f, 3.71005952e-01f, 1.53012201e-01f, 3.71251017e-01f, 3.86724137e-02f,
  2.40545258e-01f, -9.78739187e-02f, 1.62396878e-01f, 3.89252752e-02f, 1.66574910e-01f, -8.22801143e-02f, -1.99222893e-01f, 1.65815502e-01f, -6.16762377e-02f, 3.25992644e-01f,
  6.50547519e-02f, -1.20785087e-01f, -1.98989622e-02f, 2.95349896e-01f, -8.51327926e-03f, 2.09832132e-01f, 1.80029452e-01f, 3.94245796e-02f, -1.56035751e-01f, 2.20025763e-01f,
  1.49349779e-01f, -1.40675539e-02f, 1.66015178e-01f, 1.02156430e-01f, 1.39820620e-01f, 1.29194036e-01f, -1.32084191e-01f, -9.57368314e-03f, -1.14823125e-01f, 1.89116236e-03f,
  5.14167063e-02f, -1.52229786e-01f, -2.09240049e-01f, 2.64030606e-01f, 3.48212391e-01f, 1.89382732e-01f, 1.39161274e-01f, -2.93256849e-01f, 1.22652136e-01f, 1.10077336e-01f,
  -8.00728127e-02f, -1.19545512e-01f, -8.31005815e-03f, 2.37074140e-02f, -1.47978172e-01f, 3.36827105e-03f, 5.58422729e-02f, 6.79837540e-02f, 4.26202314e-03f, -8.87885541e-02f,
  -1.44218817e-01f, 1.04653955e-01f, 3.76903526e-02f, -1.66642189e-01f, -1.34960532e-01f, -9.91031807e-03f, -8.37537739e-03f, 4.02493685e-01f, 1.62799388e-01f, -1.52649447e-01f,
  -6.93516657e-02f, 2.68535942e-01f, 4.45966050e-02f, 1.39930084e-01f, 3.67350757e-01f, 5.40183904e-03f, 1.95600778e-01f, 5.36632240e-02f, 3.18064213e-01f, -1.99771479e-01f,
  -2.15075351e-02f, 1.75632030e-01f, -1.18738599e-01f, 2.09572494e-01f, 1.89994097e-01f, -9.53607857e-02f, 5.25175631e-02f, 1.65519416e-01f, -5.72511740e-02f, 1.08757980e-01f,
  1.90160304e-01f, 2.30289117e-01f, -4.37211338e-03f, -3.23362678e-01f, -1.10539444e-01f, -4.90654707e-02f, 6.91080987e-02f, 1.02085836e-01f, 1.25214523e-02f, 9.43660885e-02f,
  1.07544415e-01f, 1.55853823e-01f, 1.46206766e-01f, 8.47854540e-02f, 2.51588851e-01f, -1.39996350e-01f, 1.42035395e-01f, -5.00297435e-02f, -4.75645475e-02f, -8.71733353e-02f,
  1.95867136e-01f, 9.19805244e-02f, -2.81724155e-01f, -3.44509631e-02f, -5.17532490e-02f, -1.60591587e-01f, 2.67241448e-01f, -1.14278099e-03f, 1.02184571e-01f, -1.43481776e-01f,
  -1.50163561e-01f, -3.00946645e-02f, -1.96906347e-02f, -3.57809179e-02f, 1.32649243e-01f, 3.01271439e-01f, 1.68377444e-01f, 1.69283181e-01f, -2.37093549e-02f, -3.68491709e-02f,
  -1.36146426e-01f, 7.59938955e-02f, 2.18418330e-01f, 1.27992868e-01f, -1.66833788e-01f, -6.16208613e-02f, 6.43555969e-02f, -4.05925810e-02f, 3.02255582e-02f, 1.97950557e-01f,
  -9.83940624e-03f, -4.09573987e-02f, -1.73234254e-01f, 1.26462594e-01f, 5.99561632e-02f, 2.66841557e-02f, -1.47444487e-01f, -2.50244942e-02f, 2.91003287e-02f, 1.71449929e-01f,
  1.54331923e-01f, -1.94465563e-01f, 8.15504938e-02f, -4.49345112e-02f, -1.52111694e-01f, 8.85825828e-02f, -1.25028521e-01f, -3.59314173e-01f, 2.45187789e-01f, 3.11373144e-01f,
  4.34132703e-02f, 1.39540389e-01f, 2.66413778e-01f, 2.33328775e-01f, -5.89500368e-02f, 2.35411972e-02f, 3.72880474e-02f, 2.96751142e-01f, -1.84213314e-02f, 1.71022370e-01f,
  1.89159269e-04f, -1.27411529e-01f, -8.11232254e-02f, -5.81273846e-02f, -5.27142137e-02f, -1.42135710e-01f, 3.21590513e-01f, -1.00802831e-01f, -1.73011690e-01f, -9.80495512e-02f,
  -9.33249965e-02f, -1.68781281e-01f, -8.89388993e-02f, -1.26950517e-01f, -1.82127178e-01f, 1.71003252e-01f, 3.88962716e-01f, -9.62719917e-02f, 2.12364897e-01f, -1.39154091e-01f,
  -2.08428726e-01f, -9.60818157e-02f, 3.47095728e-01f, -3.74303386e-02f, 1.43344223e-01f, 3.38973068e-02f, 2.21421272e-01f, 9.04404521e-02f, 1.11638956e-01f, -8.27212557e-02f,
  2.64077634e-01f, -1.88425153e-01f, 1.51370227e-01f, 3.22878599e-01f, 1.82830185e-01f, -3.60049218e-01f, 3.72788683e-02f, 5.58029227e-02f, -5.80102243e-02f, -1.48322254e-01f,
  -1.84936270e-01f, 6.57037050e-02f, 1.09195463e-01f, 2.02926528e-02f, -6.63764030e-02f, 1.95163161e-01f, 8.44594091e-02f, -3.69543910e-01f, -2.15489902e-02f, 2.09498405e-01f,
  -1.51892910e-02f, 3.11550468e-01f, 6.67790174e-02f, 1.19944036e-01f, 2.03730628e-01f, 1.32502511e-01f, 6.72019348e-02f, 1.00396171e-01f, -6.39633536e-02f, 2.87895855e-02f,
  3.72015908e-02f, -1.42037332e-01f, -5.95443919e-02f, -2.25504823e-02f, 3.36888433e-01f, 1.07809052e-01f, 5.24418056e-02f, -1.93641543e-01f, -1.31834462e-01f, 1.81851164e-01f,
  -5.34828603e-01f, -3.15312952e-01f, 4.11155224e-01f, 4.27247807e-02f, 5.67345470e-02f, 1.89323425e-01f, -8.39109197e-02f, 9.09432918e-02f, 8.08278173e-02f, 2.26112064e-02f,
  -1.62354946e-01f, 3.31578285e-01f, 7.57490471e-02f, 1.94842264e-01f, 1.92669034e-01f, 2.33049870e-01f, -7.18891853e-03f, 8.06738734e-02f, -2.44145021e-01f, -1.96659684e-01f,
  1.98162511e-01f, 2.48767972e-01f, 4.47957993e-01f, 1.50503933e-01f, 1.81751966e-01f, 2.67911047e-01f, -7.01648593e-02f, -5.41758202e-02f, 7.91050270e-02f, -2.03551307e-01f,
  1.11226756e-02f, 2.33925488e-02f, 1.86543569e-01f, 1.43683344e-01f, 8.47921968e-02f, 7.75334015e-02f, -8.48448426e-02f, 7.33098760e-02f, 3.95231806e-02f, -9.50595960e-02f,
  2.09505036e-01f, 1.86679810e-01f, -2.04023808e-01f, -5.33290207e-02f, -2.52761245e-01f, -1.45661399e-01f, 2.91422337e-01f, 8.63258690e-02f, 1.24839164e-01f, 2.31237054e-01f,
  2.86697328e-01f, 1.12691931e-01f, 1.22491261e-02f, -5.45964651e-02f, 1.32219970e-01f, 5.07889576e-02f, 1.42848656e-01f, 6.39780983e-02f, 1.32935852e-01f, 9.40170437e-02f,
  1.72349751e-01f, 3.07233781e-01f, -7.73099661e-02f, -1.64131537e-01f, 5.01138091e-01f, 2.93303162e-01f, -2.08791882e-01f, 1.97159111e-01f, -5.35181686e-02f, -9.19980034e-02f,
  -2.00141564e-01f, -1.53145939e-01f, 3.46417874e-01f, 1.28086403e-01f, -1.31931171e-01f, -1.18451431e-01f, -2.00714216e-01f, -1.63416445e-01f, 3.85520011e-02f, -7.29100928e-02f,
  3.50579023e-01f, -2.03471050e-01f, 8.21696594e-02f, 3.17572802e-01f, 2.52483279e-01f, 1.81170508e-01f, -3.84849943e-02f, 6.96886331e-02f, 1.92362174e-01f, -1.67783141e-01f,
  1.89547811e-03f, -2.23367512e-01f, -8.17713737e-02f, -1.56923726e-01f, 8.33157599e-02f, 6.43044189e-02f, -6.17912114e-02f, 4.34168428e-03f, 9.65671539e-02f, 2.75405407e-01f,
  2.60280252e-01f, 9.62630212e-02f, -1.62843958e-01f, 2.24773958e-01f, 8.24734420e-02f, -4.48223710e-01f, 2.96132058e-01f, 2.72040740e-02f, 4.23193634e-01f, 5.03357239e-02f,
  1.49101883e-01f, 5.41849062e-03f, 5.88211156e-02f, 8.34322944e-02f, -9.55357682e-03f, 1.72766402e-01f, 4.16920194e-03f, -1.53319061e-01f, -1.58468261e-01f, -8.00414290e-03f,
  -1.82100654e-01f, 6.86273277e-02f, -1.23616897e-01f, 2.23437160e-01f, 9.18059517e-03f, 4.82449159e-02f, -6.07442260e-02f, 6.98010102e-02f, 1.88439831e-01f, 1.80252939e-01f,
  3.23729101e-03f, 3.26529630e-02f, -6.13385700e-02f, 2.42943138e-01f, -2.20886767e-01f, 6.34669140e-02f, 1.10942766e-01f, 8.53886008e-02f, -1.18554890e-01f, -1.57990381e-02f,
  -7.49895200e-02f, -1.23807423e-01f, 3.20093930e-02f, -8.10602903e-02f, -1.91309333e-01f, -7.49723688e-02f, 2.59175330e-01f, 2.52159774e-01f, -5.32235280e-02f, -5.54159917e-02f,
  1.00244403e-01f, 1.01630040e-01f, 1.05680436e-01f, 4.06076089e-02f, -1.55938715e-02f, -6.07312955e-02f, 1.04212426e-01f, 9.56736878e-02f, 4.35837992e-02f, -3.06734932e-03f,
  -1.76010672e-02f, -7.66020408e-03f, 1.21432625e-01f, 6.52522519e-02f, 6.29111975e-02f, 2.78294921e-01f, 5.87237142e-02f, 7.93661997e-02f, 9.86022428e-02f, 2.88281888e-02f,
  3.11900288e-01f, 4.69421328e-04f, 3.09211731e-01f, 2.30262533e-01f, 2.28721723e-02f, 9.87328216e-02f, 1.56227842e-01f, 6.97449818e-02f, 6.28537163e-02f, 2.08109275e-01f,
  -4.19774987e-02f, 1.16741247e-01f, 1.72700435e-01f, 8.66558328e-02f, 1.79182682e-02f, 2.62001976e-02f, 2.59235442e-01f, -1.32789657e-01f, -1.13892965e-01f, -4.27465513e-02f,
  -2.80079365e-01f, 4.77022558e-01f, -1.30452827e-01f, -9.89963785e-02f, 2.62143970e-01f, 2.79584527e-02f, -3.76515527e-04f, 2.33985558e-01f, -3.76581848e-02f, 4.01099950e-01f,
  8.11115056e-02f, 1.80054009e-01f, -1.43415406e-01f, 2.91476816e-01f, 1.11776143e-01f, 2.04540163e-01f, 1.34642897e-02f, -2.56723881e-01f, 3.14360052e-01f, -7.07441568e-03f,
  6.61743954e-02f, 8.33281949e-02f, -8.43343511e-03f, 6.04752675e-02f, 2.96566427e-01f, -2.04403549e-02f, 3.11817020e-01f, 1.74174204e-01f, -8.82653072e-02f, -1.30858058e-02f,
  4.00401056e-02f, 2.47745980e-02f, -3.91208306e-02f, 3.84377629e-01f, 2.48701707e-01f, 1.28092021e-01f, 4.91723232e-02f, -1.80129468e-01f, -3.59497629e-02f, 1.65295750e-01f,
  1.47866867e-02f, -6.56702816e-02f, 1.02222912e-01f, 1.76848508e-02f, -7.84903318e-02f, -8.74433443e-02f, 1.36553183e-01f, 2.65310645e-01f, -5.85305579e-02f, -8.88390988e-02f,
  2.01723441e-01f, -5.56927770e-02f, 3.11504230e-02f, 8.87433365e-02f, -5.30760773e-02f, -2.19125360e-01f, 2.00476917e-03f, -1.01813339e-01f, -1.41340300e-01f, -1.17362767e-01f,
  -1.14910886e-01f, 1.91265434e-01f, -5.78926802e-02f, -2.32679024e-01f, 1.35240301e-01f, 1.83668375e-01f, -8.91490057e-02f, -2.16584995e-01f, 3.11112076e-01f, -2.22495303e-01f,
  1.82989448e-01f, 2.80206949e-01f, 6.00567460e-02f, 3.87212038e-02f, -1.30125105e-01f, 3.36366221e-02f, -1.16096735e-01f, 2.50122428e-01f, -8.48299786e-02f, 4.41939354e-01f,
  8.31242576e-02f, 6.62332475e-02f, -4.24550891e-01f, 8.50283429e-02f, -1.39395058e-01f, -5.52655049e-02f, -9.50977802e-02f, -6.12323880e-02f, 1.81196496e-01f, 2.00199351e-01f,
  -8.82336199e-02f, 4.52381849e-01f, 1.45688936e-01f, 9.99618173e-02f, 1.02175184e-01f, -1.87163144e-01f, -1.38133038e-02f, -1.76574618e-01f, 2.53126353e-01f, 2.22521573e-01f,
  -3.17765959e-02f, -1.67673528e-01f, -1.03257291e-01f, 4.91002560e-01f, 5.62721230e-02f, -1.28621235e-01f, 1.02719218e-01f, 2.06156850e-01f, -1.16395757e-01f, 9.23878700e-03f,
  -1.92682609e-01f, -1.94009408e-01f, -6.50842339e-02f, 2.11868420e-01f, 2.45177839e-02f, 1.02662787e-01f, 4.35042568e-02f, 3.46920416e-02f, -1.51159018e-01f, 5.45007735e-02f,
  1.10327207e-01f, -7.68955722e-02f, 2.40734190e-01f, -1.39648616e-01f, 6.79290518e-02f, 2.05223918e-01f, 6.44587427e-02f, -6.56542182e-03f, -2.44899988e-01f, -1.11152582e-01f,
  -2.81504810e-01f, 5.14021516e-02f, 2.80517250e-01f, -4.01475541e-02f, -6.22877851e-02f, 3.45512405e-02f, -1.18741512e-01f, 1.99100718e-01f, 2.34468654e-02f, 1.41285628e-01f,
  -1.25584424e-01f, 2.13637635e-01f, -9.30326730e-02f, 2.74123967e-01f, 1.08288109e-01f, -1.13328673e-01f, 2.76494890e-01f, 9.24397781e-02f, -2.27052495e-01f, 2.45767504e-01f,
  1.40186638e-01f, 1.57817349e-01f, 1.25229433e-01f, 2.53376979e-02f, 1.50211275e-01f, 2.23325327e-01f, 3.66292484e-02f, 1.81626484e-01f, 6.33062199e-02f, 8.40634853e-02f,
  -4.82407063e-02f, 9.01168212e-02f, 3.31174999e-01f, -7.26255998e-02f, 1.08084232e-01f, -2.56752092e-02f, 1.13667093e-01f, -7.16457292e-02f, -5.36366329e-02f, -1.28644690e-01f,
  2.01246828e-01f, 4.43570912e-02f, 9.07538924e-03f, 9.37628746e-02f, 5.00846505e-02f, -7.28545934e-02f, 9.74911824e-02f, 2.15936393e-01f, 8.17923769e-02f, 6.70680255e-02f,
  1.69913396e-01f, 2.48305574e-02f, 1.78207174e-01f, 2.11880043e-01f, -2.34304368e-02f, 6.18451610e-02f, -8.24078396e-02f, 3.74035016e-02f, 3.96387011e-01f, 8.17675516e-02f,
  -1.76565126e-01f, 1.61243930e-01f, 1.84368730e-01f, 2.44411454e-01f, -2.27679461e-01f, -2.96416897e-02f, -1.11724377e-01f, 1.59786806e-01f, 1.54590979e-01f, -1.98267400e-01f,
  2.55502671e-01f, 8.29966087e-03f, 1.09704129e-01f, -1.35410756e-01f, 1.11943163e-01f, -9.99678597e-02f, 1.07092910e-01f, 5.08399568e-02f, 4.42105949e-01f, 4.56244320e-01f,
  -3.63666341e-02f, -1.31034777e-01f, -6.86417520e-02f, -1.72868013e-01f, 9.50586125e-02f, 2.39083782e-01f, -9.74027719e-03f, -2.97887661e-02f, 3.86632010e-02f, -1.06435791e-01f,
  7.76068643e-02f, -2.08370332e-02f, -6.98018074e-02f, -1.95335820e-01f, -2.44071573e-01f, 1.32212546e-02f, -1.87625885e-01f, 1.77169412e-01f, -4.81578447e-02f, 2.88697928e-01f,
  -6.32672235e-02f, 3.01044226e-01f, -6.84980527e-02f, 2.50359505e-01f, 2.14082003e-01f, -1.72239497e-01f, -1.89278632e-01f, 5.65916561e-02f, -2.12939620e-01f, -8.89128670e-02f,
  9.38557684e-02f, -2.56584305e-02f, 1.19806878e-01f, 7.13986680e-02f, 1.36619493e-01f, -5.66456802e-02f, 1.72614213e-02f, -1.65401295e-01f, -7.15318620e-02f, -1.31284386e-01f,
  6.75308183e-02f, -3.73018980e-02f, 1.03264702e-02f, 1.60308301e-01f, -8.61024559e-02f, 2.58435398e-01f, 3.14926833e-01f, -9.29252058e-02f, 3.24139744e-01f, 2.30745018e-01f,
  -2.43373349e-01f, 1.47464141e-01f, -9.48409066e-02f, -9.40234810e-02f, -5.55909462e-02f, 9.04533360e-03f, 1.28419712e-01f, 1.22848138e-01f, 1.69542789e-01f, -4.32853065e-02f,
  -3.93062122e-02f, 1.20872967e-02f, 2.57274419e-01f, 8.75012577e-02f, -6.50968626e-02f, -3.75504456e-02f, -3.49725336e-02f, 5.74947409e-02f, -5.15891425e-03f, -1.51472181e-01f,
  -2.05603629e-01f, 2.72662461e-01f, -1.45836055e-01f, 2.55504828e-02f, 2.99677253e-01f, -4.34502494e-03f, 1.07172273e-01f, -1.16922878e-01f, -1.62640825e-01f, -2.04528615e-01f,
  -1.22371865e-02f, 3.62249613e-01f, 1.17088214e-01f, -3.42839472e-02f, 2.57878631e-01f, 1.00655742e-01f, -3.11100148e-02f, 8.08398202e-02f, -2.94155814e-03f, -2.23702602e-02f,
  1.68543547e-01f, 1.22477204e-01f, 2.14082271e-01f, -1.19189166e-01f, -1.45306960e-01f, 1.64079279e-01f, 4.43751663e-02f, 5.57325594e-02f, 6.25387803e-02f, 8.70376155e-02f,
  2.40915552e-01f, 9.75684077e-03f, -7.91350082e-02f, -1.98322963e-02f, 5.08095659e-02f, 8.85209218e-02f, 6.74951822e-02f, 2.11614996e-01f, -6.67093694e-02f, -6.03252873e-02f,
  1.04786798e-01f, -1.02208577e-01f, -2.08858494e-02f, -2.01257821e-02f, -9.46885124e-02f, -6.66575059e-02f, 2.91164637e-01f, 3.74424532e-02f, 1.24161988e-01f, -5.96628860e-02f,
  -7.11231157e-02f, 1.94928616e-01f, 1.97236538e-01f, -8.55466947e-02f, 1.39960855e-01f, 3.06816399e-01f, -9.85183343e-02f, 2.43334159e-01f, -6.64351806e-02f, 9.22418311e-02f,
  -9.71254334e-02f, -1.59320831e-01f, 3.99314426e-02f, 1.66681856e-01f, -1.80459559e-01f, -1.03123300e-01f, 3.12072970e-02f, -4.57655974e-02f, -2.85584331e-02f, -1.40605718e-02f,
  1.88800186e-01f, -7.38801733e-02f, 1.88308463e-01f, -1.29461244e-01f, -4.67352346e-02f, -1.10939175e-01f, -3.59999947e-02f, 7.70632327e-02f, -6.39529675e-02f, 8.70430470e-02f,
  8.59612823e-02f, -9.75403264e-02f, 2.28273183e-01f, 4.07663137e-02f, -9.29584131e-02f, 2.12484058e-02f, -9.50099081e-02f, -2.11609051e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.93091029e-01f, 4.82824966e-02f, 2.56729484e-01f, 8.09015483e-02f, 8.50048289e-02f, 1.97729230e-01f, 1.51341304e-01f, 1.65587634e-01f, 2.01836616e-01f, 1.79446302e-02f,
  2.05263197e-01f, 2.14962527e-01f, 2.23035794e-02f, 1.44665614e-01f, 1.18693210e-01f, 1.85774505e-01f, 3.02214861e-01f, 1.35138497e-01f, 1.61546692e-01f, 2.66062766e-01f,
  -5.26768574e-03f, 1.29870877e-01f, 2.12260649e-01f, 7.34443441e-02f, 1.17606044e-01f, 1.60864756e-01f, 2.02448636e-01f, 2.35748962e-01f, 1.26922742e-01f, 1.53578416e-01f,
  1.38787091e-01f, 1.40239835e-01f, 2.02568606e-01f, 2.77025700e-02f, 1.41348854e-01f, 1.61110342e-01f, 1.27911970e-01f, 4.24611121e-01f, 3.46492290e-01f, 7.36756101e-02f,
  1.65871844e-01f, 3.49684209e-01f, 2.80411243e-01f, 1.02273233e-01f, 1.91911697e-01f, 2.22358070e-02f, 7.97475129e-02f, 2.14339927e-01f, 1.35285512e-01f, 2.52147943e-01f,
  2.34844416e-01f, 8.52917954e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.50884175e-01f, -6.83294013e-02f, 7.12666884e-02f, -2.61182070e-01f, -2.60248482e-01f, 1.30847692e-01f, -5.80867231e-02f, 1.29128903e-01f, -8.31269845e-02f, -1.32390931e-01f,
  -8.98291022e-02f, 2.84643263e-01f, -5.71296411e-03f, 2.20585510e-01f, -2.66802996e-01f, 7.12431669e-02f, 2.21320793e-01f, -1.82996184e-01f, 2.92654335e-01f, -1.99422777e-01f,
  -5.77545948e-02f, 1.62887201e-01f, 5.83250541e-03f, -1.63034856e-01f, 2.39417061e-01f, -1.49365187e-01f, -3.92998345e-02f, -1.32015180e-02f, -4.20577765e-01f, -3.20400596e-01f,
  1.48507729e-01f, 7.94403553e-02f, 3.01605791e-01f, -5.47573492e-02f, 2.91851997e-01f, 1.52215928e-01f, -2.70777255e-01f, 3.51767652e-02f, -3.32864344e-01f, -1.01039678e-01f,
  -5.83175570e-02f, -1.47773907e-01f, 3.20152283e-01f, -1.34482577e-01f, 2.40574762e-01f, 1.93423972e-01f, 2.33438835e-01f, -1.34735033e-01f, -3.30379695e-01f, -4.28743541e-01f,
  -2.79153138e-01f, -3.26259553e-01f, -2.67627656e-01f, 9.92359370e-02f, -8.57370049e-02f, -1.02659397e-01f, 1.07443675e-01f, 7.71673247e-02f, 2.47952580e-01f, -6.77806884e-02f,
  1.59247205e-01f, -3.95901203e-01f, 6.69070035e-02f, -5.82908168e-02f, -1.99957967e-01f, 1.57060504e-01f, -6.79893717e-02f, -2.92118013e-01f, 2.70121545e-01f, 2.58590579e-01f,
  5.34730926e-02f, -1.79405868e-01f, 4.68201898e-02f, -1.01774059e-01f, -5.08769490e-02f, -1.65133700e-01f, -1.48500025e-01f, -3.51925045e-02f, 6.24352507e-02f, -5.53434610e-01f,
  1.94872081e-01f, 2.05223024e-01f, 1.77007467e-01f, 7.02369865e-03f, -5.98247528e-01f, 2.19014302e-01f, -1.84920251e-01f, -3.18897069e-01f, 3.31398807e-02f, 1.26610622e-02f,
  1.59351215e-01f, -2.42087916e-01f, 1.04809634e-01f, -6.09723449e-01f, -4.90319520e-01f, -6.45826682e-02f, -1.84624996e-02f, -4.02052999e-01f, -4.91924942e-01f, 6.87763318e-02f,
  2.55364656e-01f, -7.12724328e-02f, -2.28374004e-01f, 1.78953201e-01f, 9.09261405e-02f, 1.18537322e-01f, 2.90859520e-01f, -7.56374598e-02f, 8.83205235e-02f, -1.21003717e-01f,
  3.54113162e-01f, -5.95501482e-01f, 1.72704890e-01f, 2.34672293e-01f, -1.33026540e-01f, -9.72320884e-02f, 7.53708333e-02f, 1.57666147e-01f, -4.10328805e-01f, 2.97943115e-01f,
  -5.30843258e-01f, -8.08632150e-02f, 2.13874966e-01f, 2.17265129e-01f, 2.91547567e-01f, -3.26727271e-01f, -2.61581063e-01f, 1.66891396e-01f, 2.26111442e-01f, -9.63221416e-02f,
  2.24468470e-01f, 1.34801343e-01f, -5.74136600e-02f, -1.58755586e-01f, -5.12839593e-02f, -2.91860104e-01f, 1.46850720e-01f, 3.18648010e-01f, -2.67475307e-01f, -1.39300093e-01f,
  -7.34389648e-02f, 1.63379997e-01f, 1.58524081e-01f, -1.25608835e-02f, 3.68035473e-02f, -3.06694746e-01f, -1.77454147e-02f, -4.59433705e-01f, 4.55345273e-01f, -1.27163634e-01f,
  -3.19545925e-01f, -1.00481883e-01f, -2.22601235e-01f, -4.85206442e-03f, 7.71221444e-02f, 2.40930587e-01f, 5.70942415e-03f, -2.92210877e-01f, -1.95246443e-01f, 2.72740066e-01f,
  -1.59109220e-01f, 9.47747231e-02f, -1.82834834e-01f, 6.57719523e-02f, 4.65878956e-02f, -3.43868077e-01f, -2.39403710e-01f, -3.75338644e-01f, 2.14811057e-01f, 1.70083269e-01f,
  -2.70568520e-01f, -1.20327711e-01f, -3.81638020e-01f, 1.96236312e-01f, 4.21703309e-01f, -1.14040799e-01f, -1.36248723e-01f, -3.18386257e-02f, -4.66369033e-01f, 3.39987516e-01f,
  -3.42794865e-01f, -3.28182906e-01f, 2.05846742e-01f, 2.98372328e-01f, 7.39619741e-03f, 9.06165689e-02f, 2.89918780e-01f, -1.80009261e-01f, -2.32979972e-02f, 7.86958044e-05f,
  -4.98441458e-01f, -4.21595007e-01f, 5.55538051e-02f, -1.34096667e-01f, -5.40289432e-02f, -2.83163786e-02f, 1.44259930e-01f, -1.31561056e-01f, -2.21323788e-01f, -1.42770648e-01f,
  -1.43452287e-01f, 1.33591652e-01f, -1.61534809e-02f, -1.51653200e-01f, -4.86484438e-01f, -1.79149762e-01f, -2.30353236e-01f, 2.65109539e-01f, 1.53808370e-01f, -1.71261236e-01f,
  -4.53348100e-01f, -3.10241997e-01f, 4.65683527e-02f, -3.46864015e-01f, -1.94235846e-01f, -4.17576104e-01f, 1.27962381e-01f, -1.40334129e-01f, -1.00422718e-01f, -3.81835222e-01f,
  -6.57386243e-01f, 3.48278582e-01f, 3.13933313e-01f, 3.03719848e-01f, 2.52730727e-01f, 2.60486633e-01f, -2.69915909e-01f, -3.82127315e-01f, -1.18916675e-01f, -9.09121111e-02f,
  -1.08379483e-01f, 1.80798605e-01f, -1.36614054e-01f, -3.24504584e-01f, -2.90484518e-01f, 3.62277217e-02f, -7.61329383e-02f, -1.88323081e-01f, 1.06540639e-02f, 3.56870554e-02f,
  -6.17233142e-02f, -3.00283790e-01f, 2.78486311e-01f, -1.30949929e-01f, -2.57388681e-01f, -1.55068889e-01f, -1.17040515e-01f, 3.88027132e-01f, -4.13188338e-02f, -2.81143904e-01f,
  2.23736048e-01f, -2.34706551e-01f, 8.68462846e-02f, 4.06558841e-01f, -3.13718431e-02f, -2.17713535e-01f, 7.45181963e-02f, -1.86815232e-01f, -4.83866073e-02f, 5.37727177e-01f,
  -8.37747455e-02f, -6.20603710e-02f, -1.08702734e-01f, 7.17258006e-02f, -5.77990353e-01f, -2.30927691e-01f, 2.06592992e-01f, 9.48842466e-02f, 2.58964330e-01f, 1.67177498e-01f,
  6.16521202e-02f, 3.45166773e-02f, 5.26103154e-02f, -4.42392886e-01f, -4.51924980e-01f, 8.33917260e-02f, -1.77458584e-01f, -1.13301270e-01f, -3.06744814e-01f, 4.47709560e-01f,
  3.66913378e-02f, -1.41666412e-01f, 1.15783021e-01f, -1.54400438e-01f, -3.90781388e-02f, -1.79664314e-01f, -7.18033835e-02f, -7.92939886e-02f, 1.02113970e-01f, -1.83247074e-01f,
  -1.41526356e-01f, -2.12295517e-01f, 6.00281432e-02f, -9.72300246e-02f, 2.00061083e-01f, -1.29466370e-01f, -6.19301081e-01f, -1.84398323e-01f, -2.90979803e-01f, -5.61658144e-02f,
  -1.93245903e-01f, 1.83612004e-01f, 4.77032624e-02f, 2.29066387e-01f, 1.27473801e-01f, 3.08600485e-01f, 1.99851915e-01f, 1.38859898e-01f, 2.42248997e-01f, -1.20857907e-02f,
  -1.55179396e-01f, -4.76986527e-01f, 1.30730465e-01f, 8.48271605e-03f, -2.58923382e-01f, -1.25015646e-01f, -8.67539048e-02f, 7.11823776e-02f, 3.09165061e-01f, 2.46531181e-02f,
  6.67707920e-02f, 3.07281286e-01f, 1.98730424e-01f, -5.89618348e-02f, 1.49563223e-01f, 2.67209709e-01f, -3.14153790e-01f, 8.83715525e-02f, -3.18582952e-01f, -4.30708557e-01f,
  -1.00116640e-01f, -2.72142172e-01f, 2.42830828e-01f, -2.67235458e-01f, 2.99804002e-01f, -4.23550129e-01f, -1.33976877e-01f, 2.73312092e-01f, 1.53183550e-01f, 9.96562093e-02f,
  -3.19696724e-01f, -1.09641835e-01f, -1.82960704e-01f, -4.19294477e-01f, -1.82829827e-01f, 1.23464026e-01f, -1.99111581e-01f, -1.21146619e-01f, 3.12583536e-01f, 4.80185784e-02f,
  -5.89094721e-02f, 6.10976666e-02f, -3.96937989e-02f, -2.17397928e-01f, 4.46777105e-01f, 2.26944789e-01f, -1.75947160e-01f, 1.67398661e-01f, 3.77805889e-01f, 2.38016412e-01f,
  -1.17027454e-01f, -1.90492466e-01f, 2.91314960e-01f, -2.99487978e-01f, -9.28186625e-02f, 1.94424197e-01f, -4.33752030e-01f, 2.20852401e-02f, 5.66350631e-02f, 2.11994708e-01f,
  -1.59092203e-01f, -3.21175575e-01f, 9.95785892e-02f, 9.26785991e-02f, 4.33811694e-01f, -3.79787266e-01f, 2.21440554e-01f, -1.49531558e-01f, 5.78451566e-02f, -5.27407587e-01f,
  1.15095548e-01f, -2.91652888e-01f, -2.63677817e-02f, -9.14743170e-02f, -1.31205156e-01f, 2.43977025e-01f, -2.01983258e-01f, 3.30734700e-02f, -3.78655009e-02f, 2.07776614e-02f,
  1.22813165e-01f, 1.91589251e-01f, 7.36309439e-02f, -3.30888778e-02f, -1.43754318e-01f, 2.21303582e-01f, 2.23754972e-01f, 1.97769582e-01f, 2.27410242e-01f, -3.14103901e-01f,
  -3.74725342e-01f, -6.16113767e-02f, 3.75143141e-02f, -4.38951164e-01f, 4.59632324e-03f, -2.67568212e-02f, -1.37240693e-01f, 3.70421737e-01f, -1.39172167e-01f, -3.07257026e-01f,
  -2.21127674e-01f, 2.44166613e-01f, 3.09269577e-01f, -4.49783742e-01f, -2.95709431e-01f, -4.52114582e-01f, -7.55665153e-02f, 2.66038150e-01f, -4.62832958e-01f, -9.15964618e-02f,
  -2.26250961e-01f, 2.36427963e-01f, 1.93556666e-01f, -4.93458778e-01f, 2.61817962e-01f, 9.90989730e-02f, -1.48399472e-01f, -3.31678599e-01f, 1.92276508e-01f, -2.02242807e-01f,
  -2.96227783e-01f, -1.87723041e-01f, 1.66893095e-01f, 1.08771630e-01f, -4.90882546e-01f, -2.44302422e-01f, -3.79596561e-01f, -3.35585028e-02f, 2.67865747e-01f, -1.64952397e-01f,
  -5.57500899e-01f, -3.93296629e-01f, -2.28801548e-01f, -1.44861847e-01f, -3.00593942e-01f, 1.31066427e-01f, -4.58367057e-02f, 1.84385076e-01f, 3.10223177e-02f, -1.71283036e-01f,
  -3.06211114e-01f, -4.02902067e-01f, -1.73229367e-01f, -6.33182004e-02f, -2.17834517e-01f, 2.02878311e-01f, 2.96106994e-01f, 1.81362554e-01f, -5.15765101e-02f, 2.43675679e-01f,
  -3.04449983e-02f, -7.04959035e-02f, -2.66789254e-02f, 1.54127583e-01f, -4.97725129e-01f, -3.78601253e-01f, 4.43208292e-02f, -2.69724935e-01f, 1.67302638e-01f, 9.48257148e-02f,
  8.26954562e-03f, -2.81033546e-01f, -1.67437214e-02f, -3.78426723e-02f, -4.23310250e-01f, -1.29331842e-01f, -1.63063481e-01f, 2.80281246e-01f, 5.18620133e-01f, -2.56837875e-01f,
  -2.70959437e-01f, -2.96569616e-01f, 3.22397679e-01f, -7.69897103e-02f, 1.11964785e-01f, -7.37747923e-02f, -1.27069622e-01f, 1.36787385e-01f, -4.39664908e-02f, -2.13406403e-02f,
  -1.29075080e-01f, 3.79215419e-01f, -2.90371478e-01f, -1.04596600e-01f, -5.63882776e-02f, -6.32220805e-02f, 3.94111983e-02f, -3.31571996e-01f, 2.23208547e-01f, 3.15536529e-01f,
  1.82140887e-01f, 8.77265912e-03f, 1.60660625e-01f, 1.29580572e-01f, 2.64285542e-02f, -4.67896685e-02f, -2.89795965e-01f, -2.66944796e-01f, 2.37922762e-02f, 1.96694717e-01f,
  -3.70526165e-01f, 1.14673041e-01f, 2.07358241e-01f, -2.51957566e-01f, -1.31540090e-01f, 9.48530212e-02f, -1.55651912e-01f, 6.22833334e-02f, 5.52958436e-02f, 2.04012126e-01f,
  2.97976494e-01f, 1.85963273e-01f, -2.39209682e-01f, -1.07955113e-01f, -1.97636545e-01f, -2.40949020e-01f, 1.53641298e-01f, -5.38938865e-02f, -3.77181083e-01f, 2.13147417e-01f,
  1.73055351e-01f, 1.99850455e-01f, 5.75489998e-01f, -2.13780537e-01f, 4.39083308e-01f, -9.84491482e-02f, -2.19014451e-01f, 1.46746203e-01f, -3.42344582e-01f, -2.20814914e-01f,
  -2.42779180e-02f, 3.03618163e-02f, -2.32282802e-01f, -1.25867262e-01f, -3.61071862e-02f, 4.52726185e-01f, -1.32442892e-01f, 1.30825654e-01f, 2.56956130e-01f, 3.17666084e-01f,
  -6.41455874e-02f, -8.25481564e-02f, -1.26160175e-01f, 1.12191401e-01f, -2.94752624e-02f, -4.32258584e-02f, -4.01342243e-01f, -1.35294393e-01f, -1.59068972e-01f, -3.23470682e-01f,
  1.84712142e-01f, -4.25119847e-01f, -2.07992762e-01f, -1.17191851e-01f, -2.75138691e-02f, -1.21751413e-01f, -7.49175027e-02f, -4.64317501e-02f, -9.45317149e-02f, 1.65183246e-01f,
  1.45796865e-01f, 8.59726965e-02f, -2.84597546e-01f, -1.45946950e-01f, -2.64395893e-01f, -3.48023660e-02f, -7.02357814e-02f, -1.01839170e-01f, 1.04486756e-03f, -1.87088940e-02f,
  -8.58795121e-02f, 2.55241357e-02f, 4.07399982e-01f, -3.81156385e-01f, 1.89422324e-01f, 1.05493613e-01f, 4.19002950e-01f, 1.95673183e-02f, -4.70389845e-03f, 6.72936141e-02f,
  -1.66435875e-02f, 1.89007014e-01f, -5.77389061e-01f, -1.02629758e-01f, 5.04614674e-02f, 9.20680258e-03f, -4.73509759e-01f, 7.02237152e-03f, 5.83421104e-02f, 2.77172267e-01f,
  -2.73061603e-01f, -1.59955531e-01f, 1.81867614e-01f, 2.87936240e-01f, 1.11547820e-01f, 2.49423847e-01f, -2.38615513e-01f, -8.66595209e-02f, -3.62102211e-01f, -5.19878149e-01f,
  1.80489376e-01f, -2.69393951e-01f, -1.91862077e-01f, -4.62870955e-01f, -1.40669301e-01f, -3.39334965e-01f, 2.93950289e-01f, 2.69445062e-01f, -2.97453821e-01f, 3.84986475e-02f,
  -1.72582958e-02f, -4.53049205e-02f, -3.17444324e-01f, 3.02913487e-01f, -3.93890351e-01f, 1.56196669e-01f, -3.49005982e-02f, -8.78173262e-02f, 8.75650123e-02f, -3.08616787e-01f,
  -1.45571297e-02f, -2.67900795e-01f, 2.25858465e-01f, 1.63340971e-01f, -4.65866476e-01f, -2.60130882e-01f, -7.32384920e-02f, -6.09114170e-02f, 8.95624906e-02f, -3.24830748e-02f,
  1.05182134e-01f, -3.80411595e-02f, 1.94084391e-01f, 1.24346778e-01f, -3.55793685e-02f, -1.86571062e-01f, 3.73354480e-02f, 7.93493167e-02f, 4.29617763e-02f, -1.06258579e-01f,
  1.12722762e-01f, 1.45178437e-01f, -5.00611424e-01f, -2.93956310e-01f, 3.95762101e-02f, -3.38207692e-01f, -2.51805447e-02f, 2.51244903e-01f, -1.35707587e-01f, 2.12534562e-01f,
  3.43017519e-01f, 1.20088838e-01f, -2.31059626e-01f, -2.99730629e-01f, 9.01631489e-02f, -3.36660057e-01f, 3.36672133e-03f, -8.84923935e-02f, -9.75243449e-02f, 4.20115590e-01f,
  1.50579005e-01f, -3.65912735e-01f, -3.54764849e-01f, -1.05313092e-01f, -1.98973551e-01f, 1.80812567e-01f, -1.52144507e-01f, -2.00975507e-01f, 2.37991333e-01f, -1.25088587e-01f,
  -5.50741404e-02f, -3.22137684e-01f, -4.68253121e-02f, 3.27599823e-01f, -5.34645915e-02f, -4.07296270e-01f, -1.19841129e-01f, 2.48406172e-01f, -3.64493668e-01f, -3.17887962e-01f,
  2.99966723e-01f, 1.19591661e-01f, 2.83123076e-01f, -7.55566955e-02f, -9.67450440e-02f, 6.86768591e-02f, -4.69271213e-01f, 2.88433284e-02f, -1.17577180e-01f, 4.47600335e-01f,
  -1.82734504e-02f, -3.01808715e-01f, 2.22669274e-01f, -1.88213333e-01f, 3.98750938e-02f, -9.36805904e-02f, 2.08907723e-01f, -8.60747416e-03f, 1.46634296e-01f, -5.39193824e-02f,
  1.83859691e-01f, 2.90274620e-01f, -2.49742363e-02f, 1.38295263e-01f, -2.82611668e-01f, 2.70281166e-01f, 3.01111877e-01f, 4.61005755e-02f, -4.88075554e-01f, -6.80765510e-02f,
  -8.87972638e-02f, -2.14994237e-01f, -4.02571708e-01f, 1.14459068e-01f, -1.36127979e-01f, -3.72676313e-01f, 2.40098953e-01f, 1.36635685e-02f, -1.43206492e-01f, 1.67241216e-01f,
  -1.71559647e-01f, 1.55921876e-01f, -2.57550310e-02f, -8.34684521e-02f, -2.11818814e-01f, 3.40739995e-01f, -1.37694851e-01f, 3.69652420e-01f, -2.29837015e-01f, -2.16473609e-01f,
  9.48816091e-02f, 1.13264397e-01f, -2.17296422e-01f, 1.15703382e-01f, -2.66207188e-01f, -5.55953048e-02f, -1.68462321e-01f, -2.13145390e-01f, 3.70079815e-01f, -4.06720489e-01f,
  -2.45458841e-01f, -2.83444345e-01f, -1.54715240e-01f, 1.51112869e-01f, 3.59869838e-01f, -1.33338749e-01f, -3.63618344e-01f, 3.48452836e-01f, -4.02987570e-01f, 2.55097032e-01f,
  -2.62496531e-01f, -2.34510586e-01f, -1.18916236e-01f, 2.13348091e-01f, -1.53958157e-01f, 3.58395368e-01f, -7.21783862e-02f, 1.62742943e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.68900967e-01f, 9.03360322e-02f, -3.45835760e-02f, 1.34166433e-02f, 1.01233937e-01f, 4.81696241e-02f, -8.50470811e-02f, 4.42034639e-02f, -2.51219291e-02f, -7.82286450e-02f,
  -3.32727954e-02f, 6.54369919e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    