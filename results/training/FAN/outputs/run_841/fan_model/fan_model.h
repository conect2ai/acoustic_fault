/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13330704e-01f, -2.34634712e-01f, -7.06792176e-02f, -1.48220301e-01f, -1.51128322e-01f, -1.75230145e-01f, -3.65399063e-01f, -2.49257032e-02f, 1.06584251e-01f, -1.88513890e-01f,
  1.40298367e-01f, 3.41661811e-01f, 3.15793097e-01f, 2.43883356e-01f, 1.93801403e-01f, -1.53584421e-01f, -1.83538392e-01f, 1.41507387e-01f, 3.17746639e-01f, 3.77297997e-02f,
  4.16327342e-02f, 3.05840783e-02f, 9.45711136e-02f, 2.14937091e-01f, -1.48749560e-01f, 2.76526481e-01f, 2.59278808e-04f, -1.48297727e-01f, 2.05952991e-02f, -4.37220275e-01f,
  9.89464223e-02f, -3.54986638e-01f, 1.20282464e-01f, 8.31500143e-02f, -4.43583690e-02f, -5.94662018e-02f, 4.80472157e-03f, -7.26228729e-02f, 6.48701265e-02f, 7.61710852e-02f,
  -1.45309577e-02f, 2.68866634e-03f, -1.38535732e-02f, 1.49454791e-02f, -1.31862089e-01f, -7.36586377e-02f, -7.16568157e-02f, 5.10154925e-02f, -5.08848997e-03f, -8.87354016e-02f,
  -2.37433091e-02f, -1.23272456e-01f, -4.38363850e-02f, 4.80074808e-03f, 3.16669084e-02f, 1.09842516e-01f, -4.63006832e-02f, -1.04069121e-01f, -3.07699144e-02f, -2.24909231e-01f,
  3.71863097e-02f, 2.74923500e-02f, -6.00703619e-02f, -4.21746541e-03f, 4.15940322e-02f, -1.41222533e-02f, -6.41862229e-02f, 7.30136558e-02f, -2.43086950e-03f, -4.30425536e-03f,
  5.15032709e-02f, -3.01437825e-02f, -6.35130564e-03f, -4.49696742e-02f, 6.38371259e-02f, -5.79841360e-02f, -6.88711926e-02f, -1.71348676e-02f, 5.37000299e-02f, -8.31600949e-02f,
  4.38142344e-02f, 1.35891978e-02f, -2.28311829e-02f, 3.22825159e-04f, -7.02049211e-02f, 5.93057536e-02f, -4.16903794e-02f, 6.76486045e-02f, 8.07249472e-02f, 3.66340787e-03f,
  1.14534557e-01f, 1.06575318e-01f, 4.76667099e-02f, 1.86068974e-02f, -9.61549208e-03f, 5.43232448e-02f, 1.25827165e-02f, 2.34084390e-02f, 8.49996880e-02f, -7.96098076e-03f,
  8.73174332e-03f, 4.99006659e-02f, 5.00894263e-02f, -9.23247484e-04f, -2.27030832e-02f, 4.83976826e-02f, -8.56770668e-03f, 2.07293089e-02f, -8.99176393e-03f, -2.96077468e-02f,
  1.43545642e-02f, -1.65570248e-02f, 2.41654497e-02f, 1.83776841e-02f, -7.38008991e-02f, 1.15986075e-02f, 7.78156444e-02f, -2.69530062e-02f, 2.46627070e-02f, -3.98389101e-02f,
  -2.51368910e-01f, 4.22583669e-01f, 8.95506963e-02f, -1.45849124e-01f, -4.52882163e-02f, -1.55308381e-01f, 7.81476051e-02f, -1.35811388e-01f, -2.03566790e-01f, 5.46355844e-02f,
  1.72989517e-02f, -9.76786986e-02f, -2.32007653e-02f, -4.98692505e-02f, -1.15614543e-02f, 2.30799317e-01f, 2.60337144e-01f, 5.17869294e-02f, -3.71044397e-01f, -2.32417107e-01f,
  -1.42202049e-01f, 4.45375293e-02f, -1.40801027e-01f, -1.54834136e-01f, 1.15100913e-01f, -2.32658342e-01f, 1.35113940e-01f, 5.33462279e-02f, 1.51795939e-01f, 5.45358658e-01f,
  9.05656666e-02f, 2.74025738e-01f, -1.37725830e-01f, 1.37369633e-02f, 1.22880191e-01f, -5.44656515e-02f, 3.56165394e-02f, -8.37429950e-04f, 1.00515686e-01f, 3.73430029e-02f,
  1.17318027e-01f, -3.40552106e-02f, -6.30292967e-02f, -2.50626318e-02f, -5.29020503e-02f, -3.41039896e-02f, 1.55096442e-01f, 4.53451239e-02f, -2.24323254e-02f, 5.02421148e-02f,
  4.84334975e-02f, 1.25834450e-01f, 1.23749793e-01f, -1.93021502e-02f, -5.32671846e-02f, -4.65562008e-02f, 6.24844879e-02f, 8.82054418e-02f, 2.43978272e-03f, 1.38318062e-01f,
  -4.72228508e-03f, 3.87848844e-03f, -3.24198455e-02f, 2.01065815e-03f, 9.12988186e-03f, 1.43127879e-02f, 3.52835655e-03f, 9.05635674e-03f, -5.69409765e-02f, 5.06276079e-02f,
  -1.24906248e-03f, -3.74884941e-02f, 1.53180573e-03f, -3.85891733e-04f, -6.22612238e-02f, 4.67480756e-02f, -1.02955878e-01f, -2.75034010e-02f, 1.35140374e-01f, -2.15033144e-02f,
  -7.82231838e-02f, 5.59373163e-02f, 6.18661642e-02f, -6.20946139e-02f, 4.97948639e-02f, -2.41114665e-02f, -7.98281431e-02f, 5.68299703e-02f, 5.35385571e-02f, -6.23568445e-02f,
  -3.50677580e-01f, -2.65867934e-02f, -7.77424918e-03f, 2.16680095e-02f, -4.15360369e-02f, 8.09084103e-02f, -4.31200024e-03f, -5.97591652e-03f, -1.77380703e-02f, -6.57392293e-02f,
  2.09620465e-02f, 2.60303319e-02f, 4.65293787e-02f, 7.59388655e-02f, -1.54205739e-01f, -8.66401754e-03f, 7.62093663e-02f, -1.08882517e-01f, -1.35449916e-02f, -1.03731900e-02f,
  -3.60281020e-02f, -1.33191407e-01f, -1.89947739e-01f, -5.42038046e-02f, -5.44667570e-03f, -1.45036474e-01f, -1.47353366e-01f, -1.73259303e-01f, -1.98658824e-01f, -3.79623294e-01f,
  -8.52972925e-01f, 4.23248678e-01f, 1.20245486e-01f, -8.91423821e-02f, 2.25423098e-01f, 7.74720535e-02f, 3.38156670e-01f, 5.31303287e-02f, -1.68254763e-01f, 1.79645747e-01f,
  1.33471206e-01f, -1.77758783e-01f, -1.42706007e-01f, -2.50524073e-03f, -1.05462188e-03f, 2.66581357e-01f, 2.03344107e-01f, -2.21479073e-01f, -3.82238925e-01f, -7.20488504e-02f,
  8.25391486e-02f, 4.34065834e-02f, -3.12460959e-01f, -1.23843208e-01f, 9.41216052e-02f, -8.79971534e-02f, 7.19371885e-02f, -2.23982204e-02f, 1.33561209e-01f, 2.15327993e-01f,
  3.88185084e-02f, -2.67258584e-02f, -3.48504190e-03f, -7.66150430e-02f, 7.11486787e-02f, -1.13952152e-01f, -7.30842054e-02f, 1.20317517e-02f, -3.84003334e-02f, -2.50707543e-03f,
  -5.75799670e-04f, 3.24083678e-02f, 1.54693075e-03f, 2.21813866e-03f, 3.49495560e-02f, 1.12259602e-02f, -7.20592663e-02f, -9.54337642e-02f, -7.51287565e-02f, 5.69375679e-02f,
  1.28759682e-01f, 1.33931115e-01f, 6.69537336e-02f, -8.37714411e-03f, 1.53305912e-02f, -1.33764297e-01f, 3.05181257e-02f, -6.07808307e-02f, -6.35203272e-02f, 9.95735526e-02f,
  1.37456134e-02f, -3.33665721e-02f, -2.26029437e-02f, 2.42171343e-02f, -3.30189541e-02f, -4.27788682e-03f, -2.25717295e-02f, 1.17872857e-01f, 7.98250083e-03f, 2.01716460e-02f,
  -1.18358666e-02f, 5.84219731e-02f, -4.42830436e-02f, 1.49870571e-02f, 9.68485475e-02f, 4.01308499e-02f, -4.90305424e-02f, 4.04527299e-02f, 1.00013763e-02f, -2.54713073e-02f,
  2.74640992e-02f, -8.36223885e-02f, -2.03607921e-02f, 9.46675055e-03f, -1.54877920e-02f, 6.18091449e-02f, -5.19024655e-02f, 5.17006814e-02f, -2.14035846e-02f, -3.38092111e-02f,
  -2.29775812e-02f, -1.31461238e-02f, -3.08877346e-03f, -8.05559084e-02f, 3.11041642e-02f, -1.31767122e-02f, 4.79410328e-02f, 2.57704351e-02f, -1.64046902e-02f, 1.59104615e-02f,
  -3.20844539e-02f, -9.11208391e-02f, 6.82065934e-02f, 5.89674115e-02f, -2.83699692e-03f, -2.93001588e-02f, 8.32024291e-02f, -9.04857926e-03f, -5.79029992e-02f, -9.41351801e-03f,
  5.27495481e-02f, -1.14833061e-02f, -4.57902886e-02f, 5.41737378e-02f, -8.88870284e-02f, -4.57158312e-02f, 1.22416995e-01f, 3.38813029e-02f, -5.36760725e-02f, 1.44286498e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.19515562e-01f, 1.18744060e-01f, 6.09106570e-02f, 2.16137152e-02f, 8.45386162e-02f, 7.81627074e-02f, 1.31660447e-01f, 1.25345111e-01f, 8.29571411e-02f, -8.40367749e-03f,
  1.30226508e-01f, 1.51051849e-01f, 1.86951503e-01f, 1.07100666e-01f, 5.39889634e-02f, 4.65661697e-02f, -2.87036244e-02f, 1.63051262e-02f, -3.36873122e-02f, 4.41900976e-02f,
  9.79082808e-02f, -4.49575298e-02f, 7.33592287e-02f, 8.70865285e-02f, -3.79265547e-02f, 1.06463440e-01f, -8.52061138e-02f, -5.38753532e-02f, 6.04979061e-02f, -1.49728000e-01f,
  3.06713823e-02f, 1.53621599e-01f, -1.40606919e-02f, 4.76251654e-02f, 4.43212725e-02f, 2.46309843e-02f, -1.30464335e-03f, -6.51961640e-02f, -4.41464595e-02f, -1.14566565e-01f,
  -4.02995721e-02f, -9.56017897e-02f, 6.04711585e-02f, -8.69348571e-02f, 1.31079517e-02f, -2.59907153e-02f, -1.50673408e-02f, 4.48104590e-02f, 6.98947683e-02f, 5.16638272e-02f,
  -4.62624654e-02f, -1.68229308e-04f, 3.78019512e-02f, -1.55687677e-02f, 9.39042494e-02f, -1.15515594e-03f, 5.45520373e-02f, 5.57223684e-04f, -5.09325974e-02f, -1.63032627e-03f,
  4.42247875e-02f, 2.40647420e-02f, 4.74586263e-02f, 4.89143766e-02f, 3.68507132e-02f, 4.43105027e-02f, -7.18135014e-02f, -1.10135913e-01f, -4.93599661e-02f, 7.41886795e-02f,
  2.27585938e-02f, 4.22179587e-02f, -9.62885749e-03f, -2.80147395e-03f, 5.24932593e-02f, 6.32578209e-02f, 1.82552505e-02f, -4.30212065e-04f, 4.78555076e-02f, -6.37063431e-03f,
  2.05688085e-02f, -6.75631464e-02f, -2.42051966e-02f, -1.18685104e-02f, -4.62596975e-02f, 9.52224508e-02f, 8.16024169e-02f, -2.26906259e-02f, 6.10646755e-02f, -5.73877059e-02f,
  9.27159376e-03f, 2.84354221e-02f, -4.30330634e-02f, -3.13802138e-02f, -7.39365304e-03f, -4.83060405e-02f, 9.64721143e-02f, 2.86802202e-02f, -1.73783258e-01f, -1.02233082e-01f,
  6.94362633e-03f, -1.29315695e-02f, 7.90791884e-02f, -1.57653820e-02f, -1.02608740e-01f, -9.01989192e-02f, -5.33470623e-02f, 3.94070074e-02f, 5.61461188e-02f, 7.03164749e-03f,
  -4.55328450e-02f, -7.36069158e-02f, -5.07659353e-02f, 2.90769096e-02f, -9.76507366e-03f, -9.38849803e-03f, -6.25623316e-02f, -8.91062245e-02f, -1.18603101e-02f, -2.45690439e-03f,
  1.24277316e-01f, -1.97988123e-01f, -3.73231828e-01f, -2.12153822e-01f, -2.20227301e-01f, -1.06777877e-01f, -1.50076941e-01f, -8.16972628e-02f, 8.97558406e-04f, -1.93598032e-01f,
  -1.14795044e-01f, -5.75354509e-02f, -1.29352912e-01f, -1.22037329e-01f, -2.69174688e-02f, -2.69897580e-01f, -2.39785582e-01f, -2.60657281e-01f, -1.30276546e-01f, 3.58865336e-02f,
  -1.94061413e-01f, -1.66933239e-01f, -1.19584583e-01f, -1.61400557e-01f, -1.11855209e-01f, -2.02472836e-01f, -3.46008003e-01f, -2.19431311e-01f, -1.89986542e-01f, -2.80863315e-01f,
  -3.54511172e-01f, 1.06455401e-01f, 6.20472021e-02f, -9.80475266e-03f, 5.94389811e-03f, 9.54496711e-02f, 7.64519768e-03f, 1.06118076e-01f, 1.19468823e-01f, -2.60294005e-02f,
  1.05689228e-01f, 6.76096007e-02f, 8.16289708e-02f, 8.83906484e-02f, -9.53035709e-03f, -1.45830237e-03f, -1.10043637e-01f, 4.48769592e-02f, 3.22647206e-02f, 1.28955260e-01f,
  6.44283146e-02f, 7.17705861e-02f, 4.91912030e-02f, -5.05024791e-02f, -3.14954631e-02f, -1.90284774e-02f, -2.42841411e-02f, 2.79932213e-03f, -1.37289241e-01f, -1.81147128e-01f,
  -8.26296024e-03f, 2.64703482e-02f, 5.05626500e-02f, 4.20119725e-02f, 1.82869304e-02f, -2.87483521e-02f, -2.45144200e-02f, -2.79859528e-02f, 1.16183320e-02f, -2.09352616e-02f,
  -7.49926120e-02f, -4.55749184e-02f, -6.51566461e-02f, 1.66998245e-02f, -1.29630705e-02f, -2.89526097e-02f, -1.75947081e-02f, -5.94422966e-03f, 1.03224717e-01f, -5.32795116e-02f,
  9.03369859e-03f, 1.15527865e-03f, -6.04486875e-02f, 1.55875042e-01f, 4.84876931e-02f, -2.94076875e-02f, -5.04551604e-02f, 5.57905883e-02f, 5.62251285e-02f, 6.55204132e-02f,
  -1.67590693e-01f, 3.17037329e-02f, 7.17627779e-02f, 1.38490781e-01f, 7.09930062e-02f, 8.57878253e-02f, 4.25386541e-02f, 8.60832483e-02f, 9.72658470e-02f, 1.66312791e-02f,
  2.56294161e-02f, -3.20159532e-02f, 1.16116870e-02f, 5.00988029e-02f, -5.89721017e-02f, 7.16801966e-03f, -6.46659508e-02f, -2.18837559e-02f, 2.95429192e-02f, -4.20620069e-02f,
  -3.64190303e-02f, -5.00165671e-02f, -9.92850736e-02f, -9.39475093e-03f, -1.46998875e-02f, 4.03703190e-02f, -1.28237724e-01f, -3.30629312e-02f, -3.51556949e-02f, -1.65969461e-01f,
  -4.50219750e-01f, -2.20571741e-01f, 1.19736701e-01f, -8.47312957e-02f, 3.02701127e-02f, -6.89464584e-02f, -2.44798720e-01f, -2.19519794e-01f, -1.22442625e-01f, -8.97477716e-02f,
  2.00816263e-02f, 4.93063033e-02f, -5.20802625e-02f, -6.04889952e-02f, -2.61886925e-01f, -2.53156602e-01f, -9.90953594e-02f, -1.26312047e-01f, -5.32302149e-02f, -7.28873163e-02f,
  -7.13700652e-02f, -1.49550214e-02f, -1.41446054e-01f, -4.20845114e-02f, 7.83720091e-02f, 1.70302570e-01f, 1.41952068e-01f, 1.33068368e-01f, 9.97741669e-02f, -8.26349109e-02f,
  -6.32351497e-03f, -3.38201635e-02f, 6.04160801e-02f, -2.02700286e-03f, 4.90253642e-02f, -2.34547835e-02f, -8.27379599e-02f, 6.86623380e-02f, 1.10906601e-01f, -6.63375184e-02f,
  5.31524085e-02f, 6.43851608e-02f, -6.39252961e-02f, 7.88166374e-02f, -5.32366447e-02f, -1.99501086e-02f, -4.26010462e-03f, -8.49732533e-02f, -9.14045572e-02f, -3.91805954e-02f,
  3.77377085e-02f, 2.47820243e-02f, -1.54547021e-01f, -9.85444784e-02f, 2.82341316e-02f, -6.46191910e-02f, 1.10463023e-01f, 1.51227470e-02f, 5.36222011e-02f, -3.76076028e-02f,
  1.62457302e-02f, 4.51715291e-02f, 1.74405798e-02f, 1.64871309e-02f, -1.74105652e-02f, 9.28983912e-02f, 9.03096609e-03f, -6.90001249e-03f, -6.16961904e-02f, -4.50698957e-02f,
  4.05187160e-02f, 4.94522601e-02f, -1.31565556e-02f, -4.96294582e-03f, 2.43525729e-02f, -8.05187505e-03f, -3.26325037e-02f, -7.11967349e-02f, 3.80703323e-02f, -3.11198626e-02f,
  -2.73487084e-02f, 2.47847214e-02f, 5.39789535e-02f, 3.03553697e-02f, -1.02449968e-01f, -5.08325584e-02f, -3.92345190e-02f, 5.18850423e-02f, 5.14620095e-02f, -5.65924905e-02f,
  -7.53208622e-02f, 1.35828778e-01f, -5.52732944e-02f, 1.47113092e-02f, 4.18520384e-02f, 4.09896709e-02f, 7.60308653e-02f, -6.52893782e-02f, 3.03415265e-02f, 3.15773324e-03f,
  -3.42782028e-02f, -6.11169776e-03f, 1.87637750e-02f, 1.25251319e-02f, -1.02257818e-01f, -1.25133991e-01f, -1.06627114e-01f, -4.01495919e-02f, 1.22518055e-02f, 9.10497550e-03f,
  -1.21052355e-01f, -2.27270097e-01f, -2.42804304e-01f, -1.15998372e-01f, -5.92753887e-02f, -1.98533386e-01f, -5.36928549e-02f, -8.71686563e-02f, -1.81778625e-01f, -2.63909847e-01f,
  -1.53569624e-01f, -1.42359249e-02f, -7.77753210e-03f, 1.17597282e-01f, 1.51391655e-01f, -6.35236427e-02f, -2.39037678e-01f, -1.39949575e-01f, 6.45381808e-02f, -7.71418735e-02f,
  -4.17209454e-02f, 1.50364712e-01f, 2.57699601e-02f, 9.73208770e-02f, -9.43911672e-02f, -3.31535079e-02f, 5.63307405e-02f, 1.73675299e-01f, 9.97651219e-02f, 2.81611849e-02f,
  3.41015235e-02f, 1.70167863e-01f, 4.21866924e-02f, -2.41397917e-02f, 1.87907610e-02f, 1.97734699e-01f, 4.12836149e-02f, 2.21654147e-01f, 5.16827703e-02f, 2.78063387e-01f,
  -4.42184359e-02f, -1.02268435e-01f, 2.78843995e-02f, 9.03351512e-03f, 4.59937453e-02f, -1.01048328e-01f, -3.95659693e-02f, 6.50606304e-02f, -8.76362100e-02f, -6.17011301e-02f,
  1.98783935e-03f, 9.95445922e-02f, -1.21737733e-01f, 3.31485830e-02f, -9.13020130e-03f, 2.23959964e-02f, -8.64903331e-02f, -4.83969599e-02f, -1.06178358e-01f, -8.16845372e-02f,
  7.79041555e-03f, 6.58217221e-02f, -5.38729131e-02f, -1.61302269e-01f, 1.51545424e-02f, 9.01177898e-02f, 3.63917686e-02f, -4.33955081e-02f, -3.12492047e-02f, -5.16267195e-02f,
  -1.73729211e-02f, 6.48385361e-02f, 2.39323974e-02f, 3.96045111e-02f, -4.45980504e-02f, -4.29113731e-02f, 1.11973241e-01f, 3.88494693e-02f, 7.86288455e-02f, 2.19778214e-02f,
  1.62895722e-03f, -4.90846932e-02f, 3.05278134e-03f, -4.23550718e-02f, 7.62401149e-02f, 1.46780759e-02f, 1.55769475e-02f, -1.97184235e-02f, -7.45345354e-02f, 6.32200465e-02f,
  5.39837852e-02f, -6.75888211e-02f, 5.07632717e-02f, -2.64856908e-02f, 1.05322115e-01f, 8.38098750e-02f, 1.61632765e-02f, -1.38177751e-02f, 3.66397686e-02f, -2.17894688e-02f,
  -1.33520951e-02f, 1.11411616e-01f, -6.64287657e-02f, 2.36465596e-03f, 5.12685142e-02f, -7.17539899e-03f, -6.49308190e-02f, -2.00717729e-02f, 8.33205730e-02f, -9.38140228e-02f,
  8.46824124e-02f, -9.42560583e-02f, 4.60978262e-02f, 1.64288469e-02f, -1.32164229e-02f, -3.93701456e-02f, 5.53301610e-02f, -4.72024520e-04f, -7.35605462e-03f, -9.77512002e-02f,
  -2.69572847e-02f, -1.87454801e-02f, -4.00097705e-02f, -1.52089462e-01f, -1.00432541e-02f, -8.04928504e-03f, -6.22157529e-02f, 3.09974737e-02f, 3.83248478e-02f, -7.43996724e-02f,
  -7.36097805e-03f, 1.15650408e-01f, 6.86850026e-03f, 1.57360584e-02f, 8.04478079e-02f, -3.93470898e-02f, -1.13353975e-01f, 2.67326133e-03f, 4.89367768e-02f, -2.83172075e-02f,
  -4.43568192e-02f, 5.92113398e-02f, -2.47007404e-02f, -2.91939303e-02f, 4.55444753e-02f, 6.06165305e-02f, 1.07646950e-01f, 4.79217917e-02f, -1.59261152e-02f, -5.70315942e-02f,
  6.43615797e-02f, 4.22387756e-02f, 7.81565011e-02f, 3.61702330e-02f, 1.67856187e-01f, 9.03885365e-02f, -9.04786512e-02f, 5.79525009e-02f, 1.44805104e-01f, 2.55359501e-01f,
  1.80497989e-02f, 3.28723267e-02f, 5.77510946e-06f, 4.92721498e-02f, -5.99719957e-03f, -5.02196811e-02f, -9.11805872e-03f, 5.97198419e-02f, -1.43912481e-03f, 3.23045328e-02f,
  2.71349475e-02f, 4.89933044e-02f, 2.98771784e-02f, 2.73808781e-02f, -7.95756355e-02f, -6.68001771e-02f, 1.48838025e-03f, -3.83467861e-02f, -1.16763167e-01f, -8.21890980e-02f,
  2.84101944e-02f, 3.94601375e-02f, -4.88142557e-02f, -8.25592130e-02f, -7.84628093e-02f, 2.76051313e-02f, 4.50374186e-02f, -2.59352867e-02f, -8.73027071e-02f, 9.61435065e-02f,
  -4.52368669e-02f, 3.43505777e-02f, 9.93136093e-02f, -2.01290697e-02f, -1.58237051e-02f, 2.71836892e-02f, 2.67704781e-02f, -1.39539586e-02f, 1.61335748e-02f, 8.13656002e-02f,
  2.47715823e-02f, -5.22226579e-02f, -7.95745403e-02f, 1.27006182e-02f, 3.65921631e-02f, 1.40464008e-02f, 5.15555106e-02f, -4.77265678e-02f, -3.65435407e-02f, 2.46768706e-02f,
  -3.51597118e-04f, -3.64743784e-04f, 5.70010021e-02f, -3.43635641e-02f, -3.84720392e-03f, -8.49984214e-02f, -1.40085872e-02f, -1.08942837e-01f, -2.17600483e-02f, 2.50793882e-02f,
  -1.04120545e-01f, -1.64002210e-01f, -4.40165140e-02f, -4.96750809e-02f, 9.03585106e-02f, 4.79978025e-02f, 4.26502563e-02f, -3.29532810e-02f, 5.44110872e-02f, -6.85081184e-02f,
  -2.01090612e-02f, 6.10528849e-02f, -1.77442003e-02f, -5.62083200e-02f, -6.55226111e-02f, 3.13605629e-02f, -8.90205875e-02f, -8.32546949e-02f, -9.16800648e-03f, -1.45547897e-01f,
  4.71414216e-02f, -1.14575356e-01f, -1.14170820e-01f, -1.79759730e-02f, -1.18633769e-01f, -1.09406494e-01f, -2.86590438e-02f, -5.63133284e-02f, -4.70203310e-02f, -2.28556335e-01f,
  -1.51977450e-01f, -3.79258730e-02f, -1.04345724e-01f, -1.55962452e-01f, -1.86675727e-01f, -1.48718864e-01f, -1.75486341e-01f, -1.20196074e-01f, -1.30117878e-01f, -1.66830540e-01f,
  -7.75154382e-02f, -2.32467297e-02f, -1.69156358e-01f, -2.01053731e-02f, -1.32071674e-01f, -2.45331556e-01f, -2.83084750e-01f, -2.29459941e-01f, -9.78388339e-02f, -6.03219010e-02f,
  -6.52905554e-03f, -1.72572538e-01f, -1.14056557e-01f, -1.10996105e-01f, -2.03702107e-01f, -1.48433253e-01f, -2.10068136e-01f, -2.46664688e-01f, -1.84361026e-01f, -3.08050305e-01f,
  -3.32959563e-01f, -6.34095818e-02f, -2.50646789e-02f, 8.37604702e-02f, -6.46990538e-02f, -4.46147583e-02f, -6.13256618e-02f, -5.93723170e-02f, 2.16882862e-02f, -4.73172255e-02f,
  4.71322564e-03f, 2.46612094e-02f, -7.71452487e-02f, 1.57844108e-02f, 1.49065116e-02f, -7.81456232e-02f, -6.63297251e-02f, -1.06854022e-01f, -4.65375744e-02f, 3.41053642e-02f,
  4.91076559e-02f, -9.61312652e-03f, -6.75345212e-02f, -1.95304919e-02f, -1.09478131e-01f, -1.53961629e-01f, -7.22908080e-02f, -1.81370407e-01f, -1.26129106e-01f, -7.72680566e-02f,
  5.27513921e-02f, -4.54486255e-03f, -8.61238223e-03f, -1.42789073e-02f, 1.16876736e-02f, 1.65669024e-02f, -3.54112722e-02f, 6.37441222e-03f, 8.15384183e-03f, 2.76830792e-02f,
  1.24130882e-02f, 5.38778752e-02f, 5.78849986e-02f, 3.74923944e-02f, -5.09809591e-02f, 8.35500211e-02f, -6.55423105e-02f, -5.69921099e-02f, 4.01430055e-02f, 4.99750152e-02f,
  -5.00498191e-02f, 1.05674691e-01f, 7.20930770e-02f, 1.49459289e-02f, -4.71578836e-02f, -9.78821367e-02f, 1.08604744e-01f, 1.64964404e-02f, 6.93918765e-02f, -1.76040381e-02f,
  -1.56404153e-01f, -5.09685017e-02f, -1.23181649e-01f, 1.39518231e-01f, -2.38499511e-02f, 5.64444177e-02f, -5.25858812e-02f, -6.84144273e-02f, 3.23063955e-02f, -1.69335343e-02f,
  -1.62957720e-02f, -3.07041220e-02f, -5.37889190e-02f, -4.88864183e-02f, -1.96761824e-02f, 1.10015266e-01f, 1.09225921e-01f, 6.68628961e-02f, 7.26847425e-02f, 1.07766032e-01f,
  9.61052999e-02f, -1.33706704e-01f, -1.23549357e-01f, -1.21080495e-01f, -1.04094088e-01f, -1.16500705e-01f, -9.60837007e-02f, -4.37593237e-02f, -8.42071027e-02f, 5.04141189e-02f,
  -4.70260412e-01f, 1.03701890e-01f, -3.04918438e-01f, -7.22566396e-02f, 1.15729466e-01f, 1.40087634e-01f, 2.68546015e-01f, 9.10504535e-03f, -7.22073317e-02f, 1.10288590e-01f,
  -3.51429544e-02f, -2.71838587e-02f, -7.21061975e-02f, 3.70168098e-04f, 1.89164318e-02f, 1.59024060e-01f, 1.89924136e-01f, -1.20388538e-01f, -1.02707453e-01f, 5.27566187e-02f,
  8.64403173e-02f, -9.41823982e-03f, -2.93157995e-01f, -1.09383143e-01f, 1.31067738e-01f, -6.33750763e-03f, -1.25807524e-01f, -1.25785097e-01f, 1.78035542e-01f, 3.64763469e-01f,
  -7.86279067e-02f, -1.76704586e-01f, -1.46697219e-02f, 7.43394941e-02f, -2.53251828e-02f, -7.61969462e-02f, -7.28481859e-02f, -6.69707730e-02f, 3.64356562e-02f, -1.30948022e-01f,
  -3.80439796e-02f, 5.89060644e-03f, 2.70637218e-02f, 5.07991575e-03f, -1.51171595e-01f, -7.05305412e-02f, -8.14790651e-02f, -1.42152339e-01f, -5.67616187e-02f, -4.90225181e-02f,
  9.05484259e-02f, 3.56753245e-02f, -1.77976012e-01f, -7.14314356e-02f, -9.11999214e-03f, -1.03487797e-01f, -1.11959331e-01f, -5.26951300e-03f, -1.34736747e-01f, 1.79817365e-03f,
  1.01232156e-01f, -1.05074206e-02f, -3.83844562e-02f, 1.02003865e-01f, 2.89604273e-02f, 1.19904771e-01f, 3.32230255e-02f, 1.12242401e-01f, -8.87201075e-03f, -1.30863279e-01f,
  -6.96234778e-02f, -3.75445373e-02f, -7.49733821e-02f, -1.68309954e-03f, 3.84190157e-02f, 2.72014420e-02f, -2.31945924e-02f, 3.92066501e-02f, -2.10001357e-02f, -6.56622946e-02f,
  -4.82196435e-02f, 9.45759565e-03f, -5.14369905e-02f, -3.34631628e-03f, 9.09645334e-02f, -7.70177366e-03f, 4.68242764e-02f, -9.72893462e-02f, -4.45112064e-02f, 1.91998314e-02f,
  -1.19472288e-01f, 1.95530970e-02f, 1.08459413e-01f, 5.38761877e-02f, -2.48655602e-02f, -3.17991599e-02f, -2.21931431e-02f, -1.13858476e-01f, -1.21443747e-02f, -1.10595804e-02f,
  -9.16087106e-02f, 1.50844799e-02f, -5.36638312e-02f, -3.58895324e-02f, -5.96428625e-02f, -7.77120516e-02f, 5.75971156e-02f, -7.53514469e-02f, 1.11209322e-02f, -4.94100973e-02f,
  5.50731905e-02f, -5.53026088e-02f, -1.96197376e-01f, -6.72765523e-02f, 1.23780675e-03f, 3.79350223e-02f, -1.62859946e-01f, -5.55135794e-02f, -1.81359380e-01f, -1.06884435e-01f,
  1.72322795e-01f, 2.13291466e-01f, -1.64531648e-01f, 8.18827823e-02f, -4.91136014e-02f, -1.61513507e-01f, -2.30470404e-01f, -1.85499325e-01f, 6.72923848e-02f, 2.09639013e-01f,
  -1.98852737e-02f, 1.24549102e-02f, 3.68788317e-02f, -7.07939491e-02f, -1.19464472e-01f, 5.04859202e-02f, 4.87188436e-02f, -1.25779986e-01f, -1.91868395e-01f, -1.00496687e-01f,
  1.32704163e-02f, 1.71672851e-02f, -8.10090899e-02f, -1.55757926e-02f, 1.31520346e-01f, 4.37971279e-02f, 4.04215464e-03f, 8.80167708e-02f, 2.60121506e-02f, 3.26483369e-01f,
  1.02045946e-01f, -1.85623214e-01f, -8.72911736e-02f, 6.96248189e-02f, 2.19543464e-02f, 5.16299112e-03f, 8.11250880e-02f, 1.25625851e-02f, 1.73430238e-02f, 9.81020406e-02f,
  1.10683270e-01f, 5.86340390e-02f, 5.49835712e-02f, -9.27081704e-02f, -1.10696685e-02f, -1.02780603e-01f, 3.85093391e-02f, -3.07311099e-02f, -2.75157820e-02f, 5.71343042e-02f,
  -2.33458430e-02f, -1.95790897e-03f, -5.50547391e-02f, -1.38482839e-01f, -1.55012161e-01f, -9.05336440e-03f, -1.14640653e-01f, 2.66501047e-02f, -1.09036595e-01f, 1.16743550e-01f,
  3.25739570e-02f, 6.71737641e-02f, 3.42663191e-02f, -7.55299032e-02f, 1.06250748e-01f, -1.75692588e-02f, -1.00957021e-01f, -6.99235033e-03f, -3.47200632e-02f, 1.08598778e-02f,
  9.51252505e-03f, -5.87846525e-02f, 3.95624749e-02f, -7.20907971e-02f, 1.24364905e-02f, -3.29147205e-02f, 3.16501921e-03f, 8.81742463e-02f, -1.41657770e-01f, 5.22319041e-02f,
  -7.57556260e-02f, -1.07455179e-02f, 6.19626381e-02f, -1.71353817e-02f, 3.90483923e-02f, -8.06639940e-02f, 4.80718911e-02f, -4.97911200e-02f, 3.13805044e-02f, 2.88043786e-02f,
  -2.90870946e-02f, -2.57533729e-01f, 1.88805252e-01f, 1.40046731e-01f, 1.05612110e-02f, 1.17125891e-01f, 4.38252799e-02f, -3.53222936e-02f, 6.31934851e-02f, 3.54579948e-02f,
  -1.66203585e-02f, -1.66880116e-02f, 1.16583742e-01f, 1.00347959e-02f, -1.07787617e-01f, 2.08649971e-02f, 1.03795640e-01f, 6.51945770e-02f, 4.87399027e-02f, 2.65865363e-02f,
  1.12205885e-01f, -5.75200766e-02f, -9.16257426e-02f, -6.59038872e-02f, -4.33395244e-02f, -1.01712823e-01f, -1.15768164e-02f, -1.06512316e-01f, -1.16050750e-01f, 9.63753611e-02f,
  -6.42093241e-01f, 9.42593589e-02f, 9.13387835e-02f, -4.23564017e-01f, -1.58767700e-01f, 1.53859956e-02f, 6.24483626e-04f, 4.30156700e-02f, -7.37927407e-02f, 6.18421007e-04f,
  -2.50503998e-02f, -1.22314483e-01f, -4.34287488e-02f, -6.04758449e-02f, -1.36579350e-01f, -5.88277280e-02f, -2.07183093e-01f, -2.00848565e-01f, -1.40261739e-01f, -3.02692074e-02f,
  -1.31452292e-01f, -1.79959074e-01f, -3.06857646e-01f, -6.82741180e-02f, 7.12787407e-03f, 4.32200953e-02f, 2.47848108e-02f, -1.41096339e-02f, 1.00164339e-01f, -1.16624795e-01f,
  2.67438978e-01f, -1.23014450e-01f, -2.62738415e-03f, -1.23233654e-01f, 4.56637740e-02f, 4.38960977e-02f, -2.73454357e-02f, 3.94665748e-02f, -5.02036326e-02f, 3.90865020e-02f,
  -1.28701448e-01f, 3.32270376e-02f, -6.10987209e-02f, 1.40206944e-02f, 1.21871021e-03f, -4.01245654e-02f, 1.84137877e-02f, 1.82489511e-02f, 4.21667323e-02f, 1.48262620e-01f,
  -3.20529304e-02f, -1.24250893e-02f, -3.04241404e-02f, 7.82605112e-02f, 2.49152794e-01f, 1.46639068e-02f, 1.80561289e-01f, 1.48251429e-01f, 1.60360381e-01f, 6.72494322e-02f,
  -8.04820061e-02f, 1.29516758e-02f, 3.41845565e-02f, -7.75749162e-02f, 2.89469548e-02f, 8.94952714e-02f, 2.99992459e-03f, -1.70308119e-03f, 5.00348024e-02f, 2.58619916e-02f,
  -1.06569529e-02f, -3.12197488e-02f, 2.48994790e-02f, -7.21743330e-02f, -1.18698841e-02f, 7.38122361e-03f, -4.36878353e-02f, 4.99107726e-02f, -5.46512119e-02f, -3.51654142e-02f,
  -2.27341312e-03f, 9.55338925e-02f, -5.34953363e-02f, -1.21130459e-02f, 6.15861230e-02f, 4.36305068e-03f, -1.19559374e-02f, 5.50975464e-03f, -8.92368108e-02f, 4.35095318e-02f,
  -7.17895280e-04f, -9.70245376e-02f, -6.36345744e-02f, -3.72654684e-02f, -5.27969189e-02f, -4.77545261e-02f, -1.64973550e-02f, 4.69403304e-02f, -5.51438145e-02f, 1.77041558e-03f,
  4.77119498e-02f, -7.67969489e-02f, -2.67300885e-02f, 2.96228547e-02f, 4.22598906e-02f, 2.74192868e-03f, -5.99037707e-02f, -1.26224801e-01f, 3.04997694e-02f, 6.13140352e-02f,
  -1.49853863e-02f, 1.96364243e-02f, -5.69719709e-02f, 6.76375926e-02f, 6.16534017e-02f, -1.57519743e-01f, 1.35247171e-01f, 2.07041539e-02f, 7.41929421e-03f, -3.60466875e-02f,
  2.99170315e-01f, -5.18385284e-02f, 1.08678013e-01f, 2.26106361e-01f, 2.14655995e-01f, 2.34421819e-01f, 1.96891561e-01f, 1.92742631e-01f, 1.51677623e-01f, 1.54635131e-01f,
  -8.82775933e-02f, 1.19573198e-01f, 8.31844285e-02f, 7.86030516e-02f, 1.09925114e-01f, 1.90118417e-01f, 1.04209937e-01f, 1.00734353e-01f, 1.85569912e-01f, 1.08741947e-01f,
  7.17024207e-02f, 2.19388101e-02f, -7.57313371e-02f, -7.35974759e-02f, -7.37038404e-02f, 7.54912645e-02f, 3.90413515e-02f, -5.59094809e-02f, -6.71299268e-03f, 2.24466827e-02f,
  -3.86120081e-02f, -5.34093240e-03f, -1.81482155e-02f, 4.50852327e-02f, -8.42353851e-02f, -8.55344310e-02f, -6.38698339e-02f, -1.97421074e-01f, -4.65035252e-02f, -9.13561434e-02f,
  -1.85175911e-01f, -6.89285919e-02f, -4.16201763e-02f, -7.44579500e-03f, -2.04903055e-02f, 7.06082359e-02f, -1.28134251e-01f, -3.74011546e-02f, -2.91303080e-02f, -8.54107440e-02f,
  1.71734001e-02f, -8.52950364e-02f, -1.64974883e-01f, 2.50382498e-02f, 6.06681295e-02f, -2.84623224e-02f, -8.09539855e-02f, 3.33864987e-02f, -3.04471813e-02f, -8.51598457e-02f,
  -1.36306006e-02f, -3.05189099e-02f, 1.45459995e-02f, 9.18771978e-03f, 7.53116757e-02f, -8.67116749e-02f, 1.26678534e-02f, -1.56675875e-02f, 1.24718519e-02f, 1.50323566e-03f,
  8.79443660e-02f, 6.52559474e-02f, 1.38995154e-02f, 5.16716503e-02f, 1.11288585e-01f, -2.88887899e-02f, 2.98182294e-02f, -3.85388397e-02f, -7.21551999e-02f, -2.32254826e-02f,
  7.33799189e-02f, -1.03493389e-02f, -1.00634452e-02f, 5.32542095e-02f, 2.79661268e-02f, 8.56683925e-02f, 1.37239276e-02f, 4.10596281e-02f, 2.43413989e-02f, -6.58723488e-02f,
  -7.21882954e-02f, -9.33148339e-03f, 1.21179864e-01f, -8.71553048e-02f, -1.26773432e-01f, -2.32266150e-02f, 6.33662716e-02f, -8.96727145e-02f, -4.92022857e-02f, 7.44342729e-02f,
  -5.87465055e-02f, -6.56959563e-02f, -3.96732576e-02f, -2.69553494e-02f, 6.65422902e-02f, -9.11291391e-02f, 3.19186151e-02f, -1.32366689e-02f, -9.99489799e-02f, 6.54540211e-03f,
  5.63557856e-02f, 1.82381421e-02f, 1.93098243e-02f, -6.11212011e-03f, -3.66576873e-02f, 1.20579928e-01f, -1.26547739e-02f, -4.01223684e-03f, 8.46480280e-02f, 5.32662533e-02f,
  1.88266069e-01f, 1.13613568e-01f, -1.56151094e-02f, 9.93303806e-02f, 9.86814722e-02f, 1.02782801e-01f, 7.89262280e-02f, 1.33669365e-03f, 1.09891355e-01f, 1.62723973e-01f,
  9.97045934e-02f, -3.24390195e-02f, 5.17232995e-03f, 9.86701809e-03f, 8.38084891e-02f, -2.39826608e-02f, 9.31180790e-02f, -3.48588750e-02f, -9.40201804e-02f, -3.53764333e-02f,
  5.91208115e-02f, 9.93567035e-02f, 9.79962945e-03f, 9.45841819e-02f, 1.54063106e-01f, 1.11568309e-01f, 8.31206888e-02f, 2.00918049e-01f, 1.23750314e-01f, 1.07741252e-01f,
  9.67426505e-03f, 1.10426530e-01f, -7.93443620e-02f, 6.19732067e-02f, -1.31331366e-02f, -4.62464616e-02f, 5.26736258e-03f, -6.09201603e-02f, 9.38951597e-02f, 5.92454448e-02f,
  8.40118602e-02f, 5.02512977e-02f, 7.59864822e-02f, -7.37500414e-02f, -6.40185997e-02f, -2.69318800e-02f, -8.01855139e-03f, -7.09240958e-02f, 1.61475781e-02f, 5.46190701e-02f,
  2.45803017e-02f, 9.12678689e-02f, -3.70641686e-02f, -4.01185192e-02f, -1.10928364e-01f, -6.66121617e-02f, -4.54190001e-02f, 2.35912930e-02f, -4.87858197e-03f, -7.64213726e-02f,
  -7.77846761e-03f, 1.97685212e-02f, -9.13215131e-02f, 9.41053405e-02f, -8.63884110e-03f, -7.54547715e-02f, -6.26623258e-02f, -6.72705024e-02f, 1.29636622e-03f, 5.73355332e-02f,
  3.55691947e-02f, 1.33312419e-02f, -4.00005840e-02f, -5.81106022e-02f, -6.97482228e-02f, -3.95363308e-02f, -7.47433528e-02f, -4.41717841e-02f, -6.53780922e-02f, 1.99213419e-02f,
  6.68973625e-02f, 5.83667122e-02f, 1.13779996e-02f, -5.57180494e-02f, 6.52997345e-02f, -1.11673489e-01f, 1.27462829e-02f, -1.87294614e-02f, 5.11606969e-02f, -3.70702595e-02f,
  5.98314963e-02f, -6.43315911e-02f, -9.34847742e-02f, -6.39588851e-03f, -2.07676291e-02f, 2.09639017e-02f, 4.84086834e-02f, 4.00180593e-02f, 9.78960544e-02f, -1.92098797e-03f,
  4.64239568e-02f, -8.71543735e-02f, 1.70185603e-02f, 2.16092765e-02f, -3.83946113e-02f, 6.75133243e-02f, -3.05930376e-02f, 3.69853107e-03f, -2.53199562e-02f, 3.28506120e-02f,
  1.72749895e-03f, -5.08788042e-02f, -3.75336707e-02f, -9.61349383e-02f, -2.58271974e-02f, -1.26203790e-01f, -7.93478116e-02f, -6.86487649e-03f, -7.52398968e-02f, -1.60747692e-01f,
  5.94341010e-02f, -2.81076953e-02f, 2.23142896e-02f, 6.16267398e-02f, -2.52031442e-02f, -1.53162971e-01f, -1.09020680e-01f, -1.86845532e-03f, -5.38076125e-02f, -4.23969999e-02f,
  -1.02605991e-01f, -7.43509755e-02f, -3.20173129e-02f, -9.42298099e-02f, -6.80482434e-03f, 2.32561883e-02f, 3.92356068e-02f, -3.72218713e-02f, -1.13439545e-01f, -5.76120242e-02f,
  -6.25161976e-02f, 2.15695966e-02f, 7.81625062e-02f, 9.28599574e-03f, 1.49873152e-01f, 4.56731068e-04f, 7.55850747e-02f, 9.02572572e-02f, -1.15147873e-03f, 1.07881762e-01f,
  1.41710356e-01f, -5.87073863e-02f, -3.28650363e-02f, 6.98345453e-02f, -5.83324842e-02f, 9.38244015e-02f, 7.77768269e-02f, 6.24286123e-02f, 3.40590887e-02f, 6.16793334e-02f,
  -1.77565310e-02f, 2.40746532e-02f, 5.22953738e-03f, -6.14276975e-02f, -6.54765368e-02f, 2.09183358e-02f, 3.95750999e-02f, 6.17073551e-02f, 6.28603324e-02f, -6.05152100e-02f,
  -7.38579631e-02f, 4.41535190e-02f, -4.63595092e-02f, 3.23171653e-02f, 7.97444209e-02f, -5.32288384e-03f, -3.72215658e-02f, 5.20940349e-02f, -1.02899289e-02f, -1.15325057e-03f,
  4.33224775e-02f, 8.68870988e-02f, 5.92803806e-02f, -1.17396349e-02f, 1.27441704e-01f, -8.73875804e-03f, 9.86655876e-02f, 1.11331828e-02f, -4.69770357e-02f, 1.28661215e-01f,
  5.92966601e-02f, -1.63390972e-02f, 1.02204062e-01f, 9.36319456e-02f, -3.85531783e-02f, 6.49431273e-02f, 3.22799720e-02f, -7.38288090e-03f, -3.71318161e-02f, 9.61944014e-02f,
  7.26873800e-02f, 7.07567185e-02f, -7.58743659e-02f, 8.24324489e-02f, 1.01010911e-01f, -5.65884262e-03f, 6.63961247e-02f, -1.39368447e-02f, 9.59086642e-02f, 5.06525040e-02f,
  5.20739332e-03f, -1.44818708e-01f, 6.25700280e-02f, -1.95364802e-04f, 7.58517161e-02f, 5.27040660e-02f, -4.36786469e-03f, 5.88005707e-02f, 1.05299667e-01f, 8.51393938e-02f,
  6.86153099e-02f, -2.37857830e-02f, -1.47963557e-02f, 3.03800721e-02f, 4.27120626e-02f, -7.84346834e-03f, 6.36536926e-02f, -7.11145848e-02f, -8.88785440e-03f, -7.32872412e-02f,
  3.06838211e-02f, -2.18274649e-02f, -1.06126532e-01f, 4.07244600e-02f, -6.41163439e-02f, -7.06049725e-02f, 1.65503137e-02f, -8.33918601e-02f, -5.63898422e-02f, 1.02047436e-01f,
  5.39601445e-01f, 1.74106658e-02f, -3.26395869e-01f, 2.48447284e-02f, -1.87673435e-01f, -2.02143028e-01f, -1.65938869e-01f, -2.21794583e-02f, 1.24025807e-01f, -1.10431045e-01f,
  -5.89318685e-02f, 4.45030630e-03f, 1.86331831e-02f, 1.89542808e-02f, 2.17990242e-02f, -3.59928161e-02f, -1.68671504e-01f, -1.04063995e-01f, -1.02502272e-01f, -1.48695529e-01f,
  -1.37019083e-01f, 4.98190261e-02f, 1.40151009e-01f, -3.01799774e-02f, -1.40325755e-01f, 5.30912057e-02f, -1.31935552e-01f, -4.54195887e-02f, -1.50331423e-01f, -6.26692027e-02f,
  -3.28349411e-01f, -5.26805073e-02f, -1.11095913e-01f, 4.17760834e-02f, -1.14799917e-01f, 2.55979300e-02f, -1.00204870e-01f, 3.90041992e-02f, 6.34230971e-02f, -4.13071588e-02f,
  -5.36256507e-02f, -2.05939841e-02f, -4.76082088e-03f, -1.49762228e-01f, -7.78137520e-02f, -3.32380347e-02f, 8.12754780e-02f, -3.36139649e-02f, -7.42153078e-02f, -9.40093491e-03f,
  -3.51692773e-02f, -4.75108065e-02f, 4.01185127e-04f, 1.48595348e-02f, -1.07266054e-01f, 2.26835869e-02f, -1.63943693e-01f, -7.29827285e-02f, -1.35409057e-01f, 7.97927827e-02f,
  -1.55907527e-01f, -1.17772721e-01f, -1.30243571e-02f, -5.10627478e-02f, 3.47292796e-02f, 8.55277702e-02f, 1.22333886e-02f, 7.42441639e-02f, -5.50607219e-02f, 2.64915526e-02f,
  -3.06176320e-02f, 4.76575643e-03f, 1.96405333e-02f, 7.02204481e-02f, -8.91542509e-02f, 3.82004268e-02f, -3.73658426e-02f, 4.86057214e-02f, 1.19965402e-02f, -2.38313619e-03f,
  2.35250946e-02f, -5.80116846e-02f, -3.08033964e-03f, -8.08153376e-02f, -5.50664216e-02f, 2.61528324e-02f, 1.70925446e-02f, -2.57116444e-02f, 5.99065907e-02f, -6.44061640e-02f,
  1.39031947e-01f, -1.72805116e-02f, 2.86787897e-02f, 7.34196603e-02f, -4.24785540e-02f, -1.59163103e-02f, -4.66196379e-03f, -2.67269611e-02f, -2.72072218e-02f, -7.26318806e-02f,
  -6.75187679e-03f, 3.21412124e-02f, -5.13434373e-02f, -1.59913618e-02f, -3.31291184e-02f, -1.39957266e-02f, 1.55256227e-01f, -5.32639548e-02f, -7.64728524e-03f, -1.71538889e-02f,
  -2.04961058e-02f, 1.17389470e-01f, 1.82345435e-01f, 5.23856394e-02f, 3.02234571e-02f, 4.69246954e-02f, 8.00130591e-02f, 9.48491506e-03f, 1.56756356e-01f, 1.97892651e-01f,
  8.21505934e-02f, -1.59623414e-01f, 2.00433493e-01f, 1.70732588e-01f, 7.45665878e-02f, 2.98654348e-01f, 2.19263718e-01f, 1.17471665e-01f, 1.75070375e-01f, -1.15734152e-01f,
  -2.31592685e-01f, -1.88013241e-01f, -1.89001888e-01f, -1.91041172e-01f, 1.25660552e-02f, 1.69442222e-01f, 2.84720063e-01f, 1.91834778e-01f, 1.90994054e-01f, 1.47985235e-01f,
  3.85565385e-02f, 3.63161676e-02f, -4.57623675e-02f, -4.09591533e-02f, 7.47672915e-02f, 1.03078306e-01f, 1.22572444e-02f, -1.25583217e-01f, -7.62189552e-02f, 2.28400990e-01f,
  -1.11715563e-01f, -8.93527567e-02f, 5.34168296e-02f, -2.27715120e-01f, -1.19486198e-01f, -3.28208804e-02f, 7.16540441e-02f, -2.61219870e-02f, -6.39757887e-02f, 7.17302971e-03f,
  6.86888443e-03f, -4.87610586e-02f, -2.78292075e-02f, -1.11412533e-01f, 2.04623397e-02f, -7.07981735e-02f, -1.13957442e-01f, -1.66362468e-02f, -3.20055075e-02f, -2.83242930e-02f,
  -1.29918590e-01f, -1.07607052e-01f, -2.65982710e-02f, 8.09495598e-02f, 1.65123627e-01f, -1.34137301e-02f, -3.85251716e-02f, 5.76429106e-02f, -7.64358370e-03f, 8.99008512e-02f,
  4.24152724e-02f, 1.03374213e-01f, -9.67115816e-03f, -8.30205083e-02f, -4.08153124e-02f, 3.67319919e-02f, 2.05569901e-02f, 4.33698809e-03f, -5.32679679e-03f, 1.49643142e-02f,
  2.29852051e-02f, 4.76300623e-03f, -1.63355432e-02f, 5.72363213e-02f, -2.20591817e-02f, 9.35086887e-03f, 4.98095602e-02f, -6.58716932e-02f, -4.45025712e-02f, -1.93115491e-02f,
  2.88132927e-03f, 4.18330953e-02f, -3.32973041e-02f, -3.47429998e-02f, -6.30916879e-02f, 2.80883685e-02f, 4.50217817e-03f, 2.66223419e-02f, -1.23565709e-02f, 3.86522338e-02f,
  -1.33604616e-01f, -8.89946297e-02f, 1.60493895e-01f, 5.03828339e-02f, 1.15696259e-01f, -1.14572700e-02f, -1.76091250e-02f, -1.76815689e-02f, -1.58213168e-01f, -2.01772284e-02f,
  -8.12901091e-03f, -2.06182636e-02f, 6.68666586e-02f, 2.80498285e-02f, 2.70552319e-02f, 1.61364377e-02f, -1.30273297e-01f, 1.40175223e-01f, 6.67086169e-02f, -2.44493876e-02f,
  5.37093133e-02f, 1.42421156e-01f, 3.43444347e-02f, 7.85925910e-02f, 3.76702696e-02f, 6.00556694e-02f, -7.77581334e-02f, 1.32072031e-01f, 6.78466409e-02f, 1.19842077e-02f,
  -1.40140541e-02f, -1.44793898e-01f, -6.32878542e-02f, 1.27505641e-02f, 4.58935462e-03f, -5.90526536e-02f, -1.18405357e-01f, -1.18267633e-01f, 3.85567024e-02f, -9.60548520e-02f,
  -3.97431254e-02f, 6.13253228e-02f, -3.81832495e-02f, 1.03739418e-01f, -6.38734251e-02f, -7.63584077e-02f, 1.61171556e-02f, 8.10822919e-02f, 5.49738854e-02f, 3.04293411e-04f,
  -2.38776747e-02f, 4.43492047e-02f, 7.41343051e-02f, 9.29614231e-02f, 5.90159371e-02f, 6.59361854e-02f, 6.16522655e-02f, 1.05954997e-01f, -2.98131406e-02f, -8.81877914e-02f,
  -3.11863087e-02f, -7.80081376e-02f, -2.63536791e-03f, 4.64960597e-02f, 3.34602664e-03f, 4.62010466e-02f, -8.52849036e-02f, -3.31994109e-02f, -2.62328610e-02f, -3.03713977e-02f,
  -3.04334480e-02f, -5.11834212e-02f, 8.64532739e-02f, 6.23714998e-02f, -6.70725480e-03f, -3.36759835e-02f, 4.08563428e-02f, -6.97743380e-03f, 8.59838948e-02f, -3.63672785e-02f,
  8.36795792e-02f, -3.64484191e-02f, -1.40151698e-02f, -5.05640768e-02f, 4.72318269e-02f, -4.86415178e-02f, -4.86167111e-02f, -1.06118277e-01f, -2.08783075e-02f, -7.81728625e-02f,
  6.19526692e-02f, -5.39242961e-02f, -3.39948088e-02f, 4.61083241e-02f, -7.45609701e-02f, 2.78396457e-02f, 1.97660755e-02f, 7.12430701e-02f, 9.93745029e-03f, -3.39643136e-02f,
  -3.27791145e-06f, -2.98945196e-02f, 2.07513534e-02f, -6.06431961e-02f, -3.40375863e-02f, -7.67808482e-02f, 7.19747320e-02f, -6.40131086e-02f, 7.75922090e-02f, 4.39403541e-02f,
  2.52512153e-02f, -7.01231286e-02f, -2.70609539e-02f, 1.56055912e-02f, -7.96041638e-02f, 4.74755354e-02f, 2.83429772e-02f, 6.24238513e-02f, -5.13078757e-02f, 1.83073729e-02f,
  -8.16402957e-03f, 2.53265928e-02f, -2.72998102e-02f, 5.60398884e-02f, -8.29439424e-03f, 4.47834730e-02f, 3.83618772e-02f, 4.44289558e-02f, -7.63180330e-02f, -7.19129294e-02f,
  2.61653587e-02f, -9.00664926e-02f, -5.17015420e-02f, -1.18764760e-02f, -5.63259721e-02f, -3.33197117e-02f, -3.33463661e-02f, 3.93337279e-04f, -2.03874018e-02f, -4.29336913e-02f,
  -5.60456216e-02f, -2.56492030e-02f, -6.43586367e-02f, -5.34140579e-02f, -1.95788201e-02f, -4.00411710e-02f, 1.76276866e-04f, 6.93053566e-03f, -8.34024921e-02f, -1.77075695e-02f,
  2.81493336e-01f, 3.10430825e-01f, 1.71692491e-01f, -6.41876087e-02f, 2.20744852e-02f, 1.36153549e-01f, 2.28152186e-01f, 6.63475022e-02f, -4.31397073e-02f, 8.24431330e-02f,
  4.34753597e-02f, -1.17291905e-01f, -7.07104281e-02f, -1.36602193e-01f, -1.16096489e-01f, -4.14724499e-02f, -1.25314206e-01f, -1.72257736e-01f, -7.61986077e-02f, -7.66665637e-02f,
  -5.04053012e-02f, 7.40150437e-02f, 1.09316818e-01f, 1.42865507e-02f, 3.22153307e-02f, -1.39324861e-02f, 3.25481258e-02f, 1.11677326e-01f, 6.61916658e-02f, 3.07607558e-02f,
  -7.04225451e-02f, 3.45056176e-01f, -2.51976848e-01f, -1.22657225e-01f, 7.02475309e-02f, -4.56482694e-02f, 2.16862280e-02f, 2.61943601e-02f, 6.75769597e-02f, -5.31313792e-02f,
  -4.58676070e-02f, -4.97598350e-02f, 5.84294535e-02f, -2.66911834e-03f, -5.90734417e-03f, 1.84871983e-02f, -4.37565781e-02f, -8.12763795e-02f, 2.59361584e-02f, 2.28693653e-02f,
  -1.39938861e-01f, 9.16940495e-02f, 6.05253838e-02f, -6.49417639e-02f, 5.86967282e-02f, 1.68879088e-02f, -1.36202376e-03f, -1.54717462e-02f, 8.53527114e-02f, 9.04187374e-03f,
  -1.05589196e-01f, 5.44780530e-02f, 2.46224254e-02f, 3.90239581e-02f, 8.59586801e-03f, -4.76553105e-02f, -5.22081926e-02f, 3.90043966e-02f, 3.82475293e-04f, 9.51652750e-02f,
  -4.09664214e-02f, -9.08466801e-02f, -6.82189390e-02f, -2.09746696e-02f, -7.45272860e-02f, -2.51369923e-02f, 2.46646907e-02f, 8.08772594e-02f, -4.27026115e-02f, 1.87388305e-02f,
  4.61797900e-02f, -3.14797871e-02f, -1.54383602e-02f, -1.59955807e-02f, 4.65708300e-02f, 7.80749545e-02f, -5.39320707e-02f, 5.72243743e-02f, 5.82131883e-03f, 6.60417825e-02f,
  -2.90246680e-02f, 3.13204005e-02f, -2.18886226e-01f, -1.11618802e-01f, 5.55610396e-02f, 9.40132141e-03f, 3.61056924e-02f, -2.38294248e-02f, -1.27708809e-02f, 6.11227378e-02f,
  -2.99944226e-02f, -4.63730432e-02f, 7.45835006e-02f, -1.30322069e-01f, -6.34690300e-02f, 1.54745867e-02f, 4.51426357e-02f, -5.10856770e-02f, -4.98108976e-02f, -1.84503831e-02f,
  1.62357185e-02f, 7.71408807e-03f, -4.82188202e-02f, -8.02505910e-02f, 1.37483589e-02f, -1.43485591e-01f, -6.27380386e-02f, -5.85560016e-02f, -1.04291692e-01f, -9.14768800e-02f,
  -1.89738926e-02f, -7.54396021e-02f, -8.38136300e-02f, 1.78557217e-01f, -6.21334985e-02f, -1.69837490e-01f, -3.00867170e-01f, -1.59749091e-01f, 9.53854620e-02f, -4.72385995e-02f,
  5.28413914e-02f, 2.69167311e-02f, 4.79698814e-02f, 1.81393847e-02f, -2.10957095e-01f, -1.26252368e-01f, -7.00569823e-02f, -8.40962455e-02f, -5.28499670e-02f, -1.14906132e-01f,
  -4.97791432e-02f, 1.54030353e-01f, 1.58012018e-01f, 1.32011191e-03f, 8.41350928e-02f, 1.72050074e-02f, 1.30968675e-01f, -7.93579035e-03f, -4.83640051e-03f, 5.24481200e-02f,
  -1.26234770e-01f, -1.76072001e-01f, 1.00763766e-02f, 7.59154186e-02f, 1.24458432e-01f, -4.87994365e-02f, -2.31919605e-02f, -3.38971172e-03f, -5.77374659e-02f, -3.71345766e-02f,
  -6.17791824e-02f, -7.84394443e-02f, -1.91796012e-02f, 5.06296009e-02f, -1.07257038e-01f, -1.99857093e-02f, -3.99462581e-02f, 6.01452924e-02f, -1.03845997e-02f, -4.96684052e-02f,
  -3.46366316e-02f, -3.07340808e-02f, -4.54551764e-02f, -6.02498055e-02f, -1.17168844e-01f, -8.98926854e-02f, -3.66853401e-02f, -3.66884060e-02f, -5.38695194e-02f, -7.49806613e-02f,
  -1.60141271e-02f, 2.09286585e-02f, -7.59578720e-02f, 5.75672537e-02f, -6.37342921e-03f, 2.43101120e-02f, -3.13688740e-02f, 5.44918934e-03f, 6.75595626e-02f, -3.73607613e-02f,
  4.16223565e-03f, -4.15717252e-04f, -4.99440320e-02f, 1.35191157e-02f, 5.53375706e-02f, -6.51713014e-02f, -6.41801655e-02f, -3.55485342e-02f, -3.31145786e-02f, 2.80638516e-04f,
  2.10688114e-02f, -1.32153600e-01f, -1.40929995e-02f, -1.61319878e-02f, 1.00784330e-02f, 1.20006660e-02f, -1.07706361e-03f, -1.69934146e-02f, 5.60061336e-02f, 3.52021083e-02f,
  1.17428400e-01f, -3.47713567e-02f, -1.00798756e-01f, -1.35561749e-01f, 5.12110218e-02f, 7.16476366e-02f, 6.77174609e-03f, 5.15820235e-02f, -8.77866000e-02f, -1.14275776e-01f,
  -1.07506610e-01f, -1.26313688e-02f, -1.37165505e-02f, -3.64633054e-02f, -3.52779441e-02f, -6.23112060e-02f, -3.10614258e-02f, -8.96867812e-02f, -7.21193552e-02f, 8.88381824e-02f,
  9.89733711e-02f, -3.21349092e-02f, -3.28350216e-02f, 4.72292975e-02f, -5.18274903e-02f, 2.22924328e-03f, -9.74172950e-02f, -7.55695924e-02f, -5.83839118e-02f, -6.30673254e-03f,
  -3.42362791e-01f, -1.02173634e-01f, -2.20812872e-01f, 5.00670560e-02f, 8.80639181e-02f, -9.00728330e-02f, -2.08808295e-02f, -1.33646578e-01f, 7.66354874e-02f, 1.28766939e-01f,
  1.45909768e-02f, 1.10754453e-01f, -6.44183978e-02f, 5.57356291e-02f, -1.26946762e-01f, 7.49678984e-02f, -4.13271189e-02f, -6.87962174e-02f, -1.03224710e-01f, 3.44861336e-02f,
  4.52573746e-02f, 7.63982907e-02f, -4.94339652e-02f, -9.80900694e-03f, 1.34479418e-01f, 3.62573378e-02f, -4.80466671e-02f, -9.50865224e-02f, 1.48027400e-02f, 1.01634189e-01f,
  -9.32207182e-02f, -1.39672384e-01f, -4.95354384e-02f, 3.86474617e-02f, 7.90628195e-02f, 6.39134459e-03f, 3.58444862e-02f, -7.38426447e-02f, -5.02294712e-02f, -9.06319916e-02f,
  -2.64493152e-02f, 9.21991542e-02f, -1.57639179e-02f, 1.96535867e-02f, -3.10250781e-02f, -1.00881010e-01f, -1.29986227e-01f, -1.41454071e-01f, -1.22728907e-01f, 1.28508108e-02f,
  4.18570414e-02f, -4.92881909e-02f, -7.08340108e-02f, -3.39071974e-02f, -5.71787311e-03f, -7.84993321e-02f, -4.99760322e-02f, -1.46874804e-02f, -7.50522390e-02f, -1.68013692e-01f,
  1.18044727e-01f, -2.01215269e-03f, -1.61841456e-02f, 3.03868670e-02f, -2.76251826e-02f, -4.54852730e-02f, 4.05245759e-02f, 9.73999035e-03f, -6.81007132e-02f, 2.71339715e-02f,
  6.39940798e-02f, -5.63850114e-03f, 6.78894222e-02f, 7.27813318e-03f, -2.18677241e-02f, -2.02882057e-03f, -8.90837051e-03f, -1.67660993e-02f, -4.06891443e-02f, 2.10791174e-02f,
  4.33735624e-02f, 4.13852222e-02f, 4.69635762e-02f, 5.92902955e-03f, -3.58890221e-02f, -3.70627865e-02f, 3.16757918e-03f, 3.07310726e-02f, -7.06267878e-02f, 3.66923735e-02f,
  -5.50231971e-02f, 5.41625842e-02f, -1.74370371e-02f, 6.36321157e-02f, -4.98560444e-03f, -4.10561264e-02f, 2.43975818e-02f, 3.10873576e-02f, 7.21878931e-02f, -3.41040678e-02f,
  -6.81312978e-02f, 5.28520253e-03f, 2.20016707e-02f, -9.64966416e-02f, -7.49427676e-02f, 8.60373024e-03f, 6.76527992e-03f, 3.32826264e-02f, -7.09747970e-02f, -5.53068221e-02f,
  4.02748324e-02f, -1.92721691e-02f, -1.90883756e-01f, -1.35498792e-01f, -3.80922966e-02f, -6.68331757e-02f, -1.89694837e-01f, -1.32937342e-01f, -1.17834620e-01f, -2.02005550e-01f,
  -2.03049649e-03f, -1.57280356e-01f, -3.72803397e-03f, -1.07151471e-01f, -1.76657006e-01f, -9.55840871e-02f, -1.94018811e-01f, -2.66828202e-02f, 8.44271202e-03f, -1.76296934e-01f,
  7.23873451e-02f, 1.70802828e-02f, 1.92192325e-03f, 9.79219973e-02f, 1.01207346e-01f, -1.06787607e-01f, -1.27860278e-01f, 6.46890476e-02f, 8.30741506e-03f, 4.30901349e-02f,
  1.94915235e-02f, -1.01818301e-01f, 5.05813025e-02f, 9.74894613e-02f, 5.23391040e-03f, 2.86560003e-02f, -7.72009138e-03f, -1.00136481e-01f, -5.34856208e-02f, -3.16310264e-02f,
  8.26155171e-02f, -5.91452122e-02f, 1.39365703e-01f, -1.90859269e-02f, -4.52856487e-03f, 3.11234836e-02f, 1.23196565e-01f, 4.46026884e-02f, 5.32175489e-02f, 5.16884588e-02f,
  3.63062248e-02f, 5.89095093e-02f, 5.55546135e-02f, 2.99557485e-02f, -8.67634118e-02f, 2.92444490e-02f, -7.61994720e-02f, -3.20721678e-02f, 1.01940878e-01f, -3.81053090e-02f,
  -4.89029959e-02f, -6.02593236e-02f, -5.52261919e-02f, 7.02868551e-02f, 1.27284512e-01f, 3.74338962e-02f, -1.92595422e-02f, 1.18332021e-01f, 1.78055063e-01f, 1.12973355e-01f,
  -6.59804419e-02f, 5.14309704e-02f, -3.32714207e-02f, -5.44917770e-02f, 2.42030155e-02f, -3.87481041e-02f, 7.60139301e-02f, -8.08458682e-03f, 3.71945999e-03f, -4.96216211e-03f,
  -8.60740468e-02f, -6.32898435e-02f, -5.10954438e-03f, -4.32545729e-02f, 6.37426926e-03f, -5.29583767e-02f, -1.03386313e-01f, -2.13246811e-02f, -1.49789741e-02f, 4.93169166e-02f,
  -1.24194272e-01f, -6.61666170e-02f, -9.69960988e-02f, -6.80917278e-02f, -7.70556228e-03f, 3.74686308e-02f, -7.85977915e-02f, 4.32879291e-02f, -6.54966980e-02f, 2.81288773e-02f,
  -6.48093447e-02f, 1.01462245e-01f, 6.62899092e-02f, -7.28513449e-02f, -2.59143319e-02f, 8.01126286e-03f, -6.72371686e-02f, -2.64907535e-02f, -1.37677431e-01f, -3.65566835e-02f,
  1.53632800e-03f, -9.60273147e-02f, -6.47002012e-02f, -3.64265628e-02f, 1.78184845e-02f, -3.33076455e-02f, 2.42351089e-02f, 8.47111791e-02f, 4.99412082e-02f, 1.43210255e-02f,
  -4.28399444e-02f, 4.58902260e-03f, 5.59436046e-02f, 6.60639554e-02f, -4.55192849e-03f, 1.47729784e-01f, 1.60849184e-01f, 1.19701259e-01f, 1.58370975e-02f, 1.30057842e-01f,
  2.09843684e-02f, 2.19085459e-02f, -3.99665795e-02f, 1.03425227e-01f, 1.87833514e-02f, -1.06417142e-01f, -6.00425974e-02f, -6.46719113e-02f, -5.69671653e-02f, -7.06650391e-02f,
  -1.06396534e-01f, -7.11908713e-02f, 5.53052574e-02f, -3.95218022e-02f, -7.77972629e-04f, -8.57640505e-02f, -1.88415200e-02f, -6.79408833e-02f, -8.49973336e-02f, -8.85321796e-02f,
  6.05394393e-02f, -5.46781868e-02f, 2.47058831e-02f, 5.50110973e-02f, -1.07692234e-01f, -2.79203448e-02f, -1.11993834e-01f, 2.35471111e-02f, -1.04095347e-01f, -2.29552016e-02f,
  -1.07892945e-01f, -6.83335438e-02f, -1.10251255e-01f, 2.15532966e-02f, -3.62070799e-02f, 4.16310178e-03f, -3.60815860e-02f, 1.02340110e-01f, -1.65955592e-02f, -1.36246383e-02f,
  8.18923563e-02f, -4.41665687e-02f, 4.50719818e-02f, -4.69685458e-02f, -1.39327552e-02f, -2.14750953e-02f, 1.46557102e-02f, 5.69417290e-02f, -6.22801334e-02f, 8.88087507e-03f,
  1.07041486e-02f, -1.11235149e-01f, 3.43559943e-02f, -7.23011345e-02f, 1.30760893e-02f, -5.52423634e-02f, -6.28844872e-02f, 2.80383192e-02f, -8.01812708e-02f, 8.25636238e-02f,
  8.09251610e-03f, -4.25482616e-02f, -9.55402404e-02f, 2.64648702e-02f, -4.85111549e-02f, 4.37568948e-02f, -1.41983582e-02f, 3.33820321e-02f, 5.63036948e-02f, -1.40802702e-02f,
  2.57434901e-02f, -1.19572707e-01f, -4.12980430e-02f, 9.09760520e-02f, -4.52268571e-02f, 2.26482265e-02f, -6.60637543e-02f, -2.15399135e-02f, -1.20580830e-02f, -2.52554677e-02f,
  -4.70746048e-02f, 2.15689242e-02f, 6.22720793e-02f, 9.47934538e-02f, -5.24337552e-02f, 9.81386453e-02f, -7.17864707e-02f, 6.18440174e-02f, 7.09709674e-02f, 8.18170011e-02f,
  2.15955615e-01f, -3.88543904e-02f, -9.75529477e-02f, 1.15097184e-02f, -4.72747646e-02f, 2.55601164e-02f, -5.58657050e-02f, 3.37090977e-02f, -3.18046622e-02f, -6.76699653e-02f,
  -5.64454161e-02f, 1.26294255e-01f, -1.97356027e-02f, 7.96330422e-02f, -2.75305044e-02f, -1.02663487e-02f, 1.77431647e-02f, 4.81305756e-02f, -1.12590641e-01f, 5.59676960e-02f,
  -2.89223995e-02f, 6.72576576e-02f, 2.90666223e-02f, 8.49560052e-02f, -5.25471102e-03f, 3.78398187e-02f, 5.08145466e-02f, 1.09663695e-01f, 4.74894978e-03f, 8.81589483e-03f,
  2.60255840e-02f, 9.00158212e-02f, 9.61298402e-03f, 6.42061085e-02f, 8.93859640e-02f, -5.75468736e-03f, 1.60174936e-01f, 7.50818998e-02f, 6.22048089e-03f, 6.01773858e-02f,
  -1.23125732e-01f, -4.36088629e-02f, 3.15479264e-02f, -4.63657230e-02f, 4.18718681e-02f, 1.96706742e-01f, 2.26589471e-01f, -1.70281902e-02f, -3.94584704e-03f, 1.02384299e-01f,
  6.09906157e-04f, 8.89767485e-04f, 3.95722426e-02f, 2.80957185e-02f, 1.09130993e-01f, -8.45468044e-02f, 2.13467088e-02f, -8.72962773e-02f, 9.97490883e-02f, 2.86335558e-01f,
  3.38374823e-02f, 5.49571030e-02f, -3.59638110e-02f, -7.41447881e-02f, -9.32980031e-02f, -1.94841977e-02f, -7.31839165e-02f, 3.95334698e-02f, 5.11049666e-02f, -3.05032171e-02f,
  1.08607556e-03f, 8.14663172e-02f, -1.23226577e-02f, 5.38684726e-02f, -6.26187772e-02f, 3.58958282e-02f, 1.01625226e-01f, 3.15482393e-02f, 4.62985411e-02f, -4.96595865e-03f,
  -3.23430113e-02f, 3.22640203e-02f, 3.81651632e-02f, 3.20753530e-02f, 1.06902100e-01f, 4.08138731e-04f, -7.61395320e-03f, -2.32490408e-03f, -1.22134918e-02f, 4.49219160e-02f,
  -8.93796682e-02f, -1.88272409e-02f, -2.53507402e-02f, -2.38586850e-02f, 6.42817542e-02f, 3.58034596e-02f, 4.44673635e-02f, -2.81842351e-02f, 8.18196237e-02f, -4.16202024e-02f,
  -5.97032383e-02f, -7.30796829e-02f, -4.60906420e-03f, 2.01752242e-02f, -4.89271991e-02f, -1.02844397e-02f, -9.75679886e-03f, -3.63400094e-02f, -3.53810750e-02f, 1.66711342e-02f,
  1.12166487e-01f, -9.47610959e-02f, -5.27808256e-02f, 8.92673358e-02f, 2.30141990e-02f, -2.31041722e-02f, 4.68340255e-02f, -5.53251542e-02f, 5.30658551e-02f, 1.37538761e-02f,
  -3.20927240e-02f, -2.55734831e-01f, -6.31296588e-03f, -2.17195731e-02f, 4.95078377e-02f, -4.04584408e-02f, -9.61814895e-02f, -7.47779310e-02f, -6.67092949e-02f, 6.56877505e-03f,
  -9.11078528e-02f, -7.14921905e-03f, -4.26899865e-02f, 9.35020447e-02f, -1.96991581e-03f, 4.58616652e-02f, -1.09696895e-01f, 1.28917433e-02f, -9.86854061e-02f, 1.90401059e-02f,
  -6.65948913e-02f, -6.30487576e-02f, 2.16433071e-02f, 1.84906255e-02f, 4.84475167e-03f, -1.90086663e-01f, -5.71294799e-02f, -4.05413471e-02f, -1.75672337e-01f, -1.20801769e-01f,
  8.19156691e-02f, 1.50111705e-01f, 6.42882809e-02f, 1.53278261e-02f, -4.86190291e-03f, 3.56650688e-02f, 5.76694235e-02f, 7.57304505e-02f, 1.24751009e-01f, 4.44721356e-02f,
  1.21398037e-02f, 1.68179959e-01f, 1.68703511e-01f, 1.29124075e-01f, 3.95110808e-02f, 6.80959597e-02f, 8.70125070e-02f, 3.57446335e-02f, 7.67382681e-02f, 2.32430566e-02f,
  2.47377716e-03f, -4.39131372e-02f, -8.90440121e-02f, -1.47654945e-02f, 1.61987282e-02f, -1.61855668e-02f, -1.59051325e-02f, 5.00170887e-02f, -9.81943011e-02f, 3.76539975e-02f,
  4.68121432e-02f, 1.47038281e-01f, 1.00532196e-01f, 7.08677396e-02f, 8.55147615e-02f, 5.64009883e-03f, 1.93274375e-02f, -4.83024009e-02f, 4.60935794e-02f, -5.68280136e-03f,
  4.23990041e-02f, -8.45426694e-02f, 7.70079568e-02f, -2.28707418e-02f, -1.47457570e-02f, 2.03502961e-02f, 4.77592573e-02f, 4.61510196e-02f, -2.31030155e-02f, 1.02352232e-01f,
  1.06026612e-01f, 8.22847113e-02f, -1.51861915e-02f, 2.41607111e-02f, 5.47383390e-02f, 6.16526343e-02f, -1.11786965e-02f, 9.67079923e-02f, -3.07262149e-02f, -3.60752866e-02f,
  4.02809717e-02f, 1.02882095e-01f, 7.85565004e-02f, 6.15631416e-02f, -8.88528861e-03f, -4.11344357e-02f, 4.27335799e-02f, 4.50617038e-02f, -2.86842696e-02f, -7.34723359e-02f,
  -1.86675619e-02f, -9.72348731e-03f, 5.63048832e-02f, -6.70338050e-02f, 5.85898533e-02f, 6.25315532e-02f, 1.99150629e-02f, 3.29749510e-02f, 7.90923387e-02f, 4.80337366e-02f,
  3.08510102e-02f, -2.53331829e-02f, -6.66786134e-02f, 8.05555284e-02f, -3.19661424e-02f, 7.20791295e-02f, -6.80577615e-03f, 3.61896530e-02f, 4.45661247e-02f, 5.63744493e-02f,
  -7.71688595e-02f, -1.26396092e-02f, -3.42181623e-02f, 2.26836950e-02f, 1.07089318e-02f, -3.49290445e-02f, 7.59427473e-02f, -9.24727023e-02f, -3.22933495e-02f, -8.72630626e-02f,
  -8.00438672e-02f, 1.34958765e-02f, 7.53864050e-02f, -1.97081622e-02f, 1.78346653e-02f, -1.91915240e-02f, 6.24751560e-02f, 7.86097869e-02f, -6.07740879e-03f, 4.84198257e-02f,
  1.63644031e-02f, -2.41256785e-02f, 7.95425624e-02f, 3.93926501e-02f, 2.96457410e-02f, -2.34399270e-02f, 2.86104716e-02f, 5.90277053e-02f, -4.72659133e-02f, 4.78381924e-02f,
  -3.64760578e-01f, 4.67822850e-02f, -1.29936695e-01f, -1.02589220e-01f, -5.45149930e-02f, 8.62710550e-02f, 1.89210430e-01f, 7.24053308e-02f, -1.02487631e-01f, -3.67747806e-02f,
  -2.04942059e-02f, -1.84957981e-02f, -4.97253202e-02f, 1.49636678e-02f, 9.24545061e-03f, 3.20828110e-02f, 1.40731275e-01f, -4.82123382e-02f, 1.40922489e-02f, -2.20957007e-02f,
  6.71843663e-02f, 5.50858602e-02f, -5.93315400e-02f, -4.74512316e-02f, 5.57588004e-02f, 7.34512657e-02f, -1.91758610e-02f, -3.12233474e-02f, 1.87353250e-02f, 5.31706363e-02f,
  -8.56335610e-02f, -1.40668169e-01f, -4.15932765e-04f, -7.95228928e-02f, 2.34866571e-02f, -3.16053480e-02f, -3.44128460e-02f, -1.86283235e-02f, 3.32070105e-02f, 2.81175654e-02f,
  -4.63909358e-02f, -7.82209784e-02f, -1.30695580e-02f, 1.16628846e-02f, -1.21093526e-01f, -2.56713992e-03f, -3.35310362e-02f, -7.05065131e-02f, 6.49667159e-02f, 3.92842703e-02f,
  1.37335852e-01f, 3.15048546e-02f, -9.90212411e-02f, 7.73956180e-02f, 2.50400277e-03f, 3.07332482e-02f, 1.50647806e-02f, 1.88656375e-02f, -4.68439274e-02f, -7.70844296e-02f,
  4.16630879e-02f, 3.76702398e-02f, -6.79080263e-02f, 2.25118939e-02f, 4.88152243e-02f, 1.21017508e-02f, -6.05899002e-03f, -4.99783345e-02f, 2.46247742e-02f, 1.62366088e-02f,
  -3.06203216e-02f, 1.81649420e-02f, 1.10216998e-02f, -8.49362463e-02f, -9.47139859e-02f, -4.49377485e-02f, 5.71577251e-02f, -6.26386628e-02f, -6.26346543e-02f, 5.20770811e-02f,
  5.87832779e-02f, 3.74734551e-02f, 1.98526550e-02f, 1.80065259e-02f, 4.43363078e-02f, 1.81456227e-04f, 3.50162312e-02f, -4.31082509e-02f, -4.21256945e-02f, 6.90435171e-02f,
  -1.30905479e-01f, -4.13137302e-02f, 3.43753258e-03f, 4.76697534e-02f, 4.34317552e-02f, -7.45820999e-02f, -3.06871757e-02f, 2.74443608e-02f, -1.00458078e-01f, -5.45162596e-02f,
  2.55088639e-02f, -1.15089834e-01f, -5.60174463e-03f, -6.65327534e-02f, 5.23873279e-03f, -5.18457405e-02f, 6.06935471e-02f, -1.73330642e-02f, 8.51268321e-02f, 1.54664451e-02f,
  3.74141820e-02f, -1.32148676e-02f, 1.34380069e-02f, 2.56326962e-02f, -3.69224474e-02f, -4.28002735e-04f, -4.39387979e-03f, 3.75372991e-02f, -7.91641921e-02f, 4.13805321e-02f,
  2.65562713e-01f, -2.69713737e-02f, 8.56527165e-02f, 1.73768997e-01f, -2.89210796e-01f, -4.79044825e-01f, -5.36065519e-01f, -2.82950789e-01f, 7.13173226e-02f, 1.18925348e-01f,
  -7.15074390e-02f, 1.39163230e-02f, 1.72568336e-02f, -8.23445544e-02f, -1.80733323e-01f, 3.51287313e-02f, 1.63292736e-01f, 1.73120350e-01f, -1.20884903e-01f, -3.27756882e-01f,
  -4.20652926e-02f, 1.57927483e-01f, 2.70052850e-01f, -6.90771863e-02f, 1.17512964e-01f, -5.62021919e-02f, 6.40468253e-03f, 1.22457579e-01f, -5.91736985e-03f, 3.13811362e-01f,
  1.59565836e-01f, -6.42718822e-02f, -4.95384857e-02f, 2.76222322e-02f, 7.78725222e-02f, 8.84076804e-02f, -1.33472711e-01f, 9.91786271e-02f, -1.32790161e-02f, 5.91450334e-02f,
  -4.24248241e-02f, -5.00285923e-02f, 1.14885001e-02f, 4.29454818e-03f, 3.62269990e-02f, -4.68591861e-02f, -9.08980984e-03f, 1.56097487e-01f, 2.24046167e-02f, 1.01395836e-02f,
  -3.82908881e-02f, -9.47744623e-02f, -1.09174468e-01f, -1.75586700e-01f, 4.53052260e-02f, -1.06701031e-02f, -6.82942718e-02f, 1.14135249e-02f, -9.47646424e-02f, 7.00811669e-02f,
  7.32995644e-02f, -2.57620420e-02f, -9.40663815e-02f, 3.62147428e-02f, 1.10523514e-02f, 2.78196093e-02f, -2.13588718e-02f, 1.39365504e-02f, -7.33786076e-02f, 2.41424590e-02f,
  -8.97200182e-02f, 1.10049471e-02f, -4.35557887e-02f, 1.74841117e-02f, 1.16762340e-01f, -1.95202753e-02f, -7.55163953e-02f, 2.09554192e-02f, 3.31189595e-02f, 1.77914165e-02f,
  4.96909395e-02f, -2.65186988e-02f, 6.96485937e-02f, 3.50484392e-03f, -7.83203449e-03f, 9.05455202e-02f, 2.44100466e-02f, -6.71671405e-02f, 4.59497562e-03f, 4.64508161e-02f,
  -2.69687790e-02f, -9.11755562e-02f, 9.54000652e-02f, -6.36578649e-02f, 2.16683676e-03f, -5.67439198e-02f, 6.52449727e-02f, 3.88543075e-03f, 1.12907905e-02f, 5.66887930e-02f,
  -1.72840819e-01f, 3.89060751e-02f, -2.73175426e-02f, -2.03527268e-02f, -2.48250272e-02f, -6.72963262e-02f, -2.81730797e-02f, -5.29307425e-02f, -5.10490723e-02f, 1.05610698e-01f,
  -4.15854938e-02f, -1.55152321e-01f, -1.06259435e-01f, -1.74371183e-01f, -6.56520277e-02f, -1.57875881e-01f, -1.97958469e-01f, -1.71144102e-02f, -2.74627954e-01f, -8.63441899e-02f,
  -1.31838545e-01f, -1.16308250e-01f, -1.15232438e-01f, -7.43651837e-02f, 2.61760615e-02f, 7.57126417e-03f, -4.82574962e-02f, -1.00667819e-01f, -1.07359774e-01f, -5.47080562e-02f,
  -2.15877667e-02f, -3.40508559e-05f, -9.81771871e-02f, -2.68124696e-02f, -5.13722748e-02f, -6.24138163e-03f, 1.44935295e-01f, 6.49236292e-02f, -3.48419994e-02f, -2.09990311e-02f,
  -8.43815356e-02f, 2.43288558e-02f, 4.27059606e-02f, -6.03461862e-02f, -7.25192875e-02f, 1.83359496e-02f, 3.90560664e-02f, -3.30413803e-02f, 3.90443429e-02f, -8.27447996e-02f,
  6.47897646e-02f, -1.67239904e-02f, 5.69218360e-02f, 3.11836544e-02f, -2.72650458e-02f, 4.62706164e-02f, -8.29491913e-02f, 2.19922252e-02f, 1.51709216e-02f, 3.48948054e-02f,
  2.79767439e-02f, -1.00241706e-01f, -5.96721210e-02f, -1.04788043e-01f, 7.05006421e-02f, -7.88474753e-02f, -6.52824640e-02f, 1.31125450e-01f, 1.35089858e-02f, -2.81373486e-02f,
  -1.01409338e-01f, -3.57599296e-02f, 6.17470182e-02f, 1.50787076e-02f, 5.26442006e-02f, 1.66478455e-01f, -3.21011916e-02f, 3.24623436e-02f, 1.18782051e-01f, -6.86856285e-02f,
  -4.72838841e-02f, 3.13163805e-03f, 1.88294111e-03f, -6.19221516e-02f, -5.06554544e-02f, -6.73130006e-02f, -9.12266150e-02f, -7.31781647e-02f, -5.42512946e-02f, -8.59405380e-03f,
  -7.58315218e-05f, 3.34547013e-02f, -3.72277088e-02f, 1.24335475e-02f, 3.74517739e-02f, 5.44099137e-02f, -6.18476570e-02f, -1.46306015e-03f, -4.99418005e-02f, -5.37865162e-02f,
  1.54813183e-02f, -2.37497091e-02f, 6.72304770e-03f, -1.01295917e-03f, 4.91781496e-02f, -6.98599443e-02f, 2.77356450e-02f, 2.70602293e-02f, -2.87736040e-02f, 4.19338867e-02f,
  6.34672493e-02f, 1.64440319e-01f, 9.41950455e-02f, 6.94359764e-02f, 1.72807947e-02f, 7.35147744e-02f, -1.07220441e-01f, -6.23382591e-02f, -8.94713588e-03f, 1.81628186e-02f,
  1.50150694e-02f, -2.72697564e-02f, 7.02004973e-03f, -7.08488747e-04f, 1.61445141e-02f, 1.04904093e-01f, 7.45217577e-02f, 1.48138240e-01f, 1.40751600e-01f, 1.19226523e-01f,
  3.38107832e-02f, 3.63634564e-02f, 1.78925574e-01f, 3.27594355e-02f, 6.47035614e-02f, 1.50157958e-01f, 1.38243129e-02f, 1.28524723e-02f, 1.44357815e-01f, -8.19501877e-02f,
  -1.01364478e-01f, 1.47718787e-01f, 2.90878513e-03f, 8.25575888e-02f, 1.11695903e-04f, 7.63937682e-02f, -3.08370162e-02f, 6.08768091e-02f, 1.05481774e-01f, 3.99517305e-02f,
  9.24829915e-02f, 1.78090311e-04f, 8.06448609e-02f, 4.53718305e-02f, -1.14580601e-01f, 5.37338629e-02f, -4.03965153e-02f, -1.26355559e-01f, -1.22480132e-01f, 1.52365146e-02f,
  8.04543048e-02f, -5.37621789e-02f, -9.87414643e-02f, -1.47506669e-01f, -1.67867765e-02f, -8.29333737e-02f, -1.66195873e-02f, -1.27972871e-01f, 5.75289305e-04f, -6.29013926e-02f,
  -1.28541470e-01f, -8.29624385e-02f, 1.23057570e-02f, -1.95818096e-02f, 1.42165441e-02f, 7.87948966e-02f, 3.75808068e-02f, 3.94677408e-02f, 3.82469669e-02f, 3.77881713e-03f,
  3.15358303e-02f, -7.35486522e-02f, -4.93350551e-02f, -1.08138464e-01f, 4.94052470e-02f, 2.15342231e-02f, -3.62222753e-02f, -8.13034251e-02f, -1.20431647e-01f, 8.78972784e-02f,
  9.17562563e-03f, -8.45631864e-03f, 6.75263070e-03f, 3.01558450e-02f, -6.64571449e-02f, -7.15557560e-02f, -7.76135921e-02f, -8.92670229e-02f, -3.06760482e-02f, -9.97616798e-02f,
  -1.06876776e-01f, -8.07314515e-02f, -6.25278652e-02f, -5.81523515e-02f, 6.88634291e-02f, -8.06204677e-02f, 2.89802160e-03f, -6.15518056e-02f, -2.03401763e-02f, -1.24352403e-01f,
  -3.23314518e-02f, 7.69422576e-02f, -2.93411184e-02f, 3.86447157e-03f, -5.77546097e-02f, -8.84581655e-02f, -2.08280962e-02f, -3.69706452e-02f, -6.16042838e-02f, 2.01148465e-02f,
  1.95997115e-02f, -9.53208283e-02f, 8.52344238e-05f, -4.23154868e-02f, -1.40666422e-02f, 3.27917151e-02f, -2.32107397e-02f, -1.20081296e-02f, 3.98601741e-02f, -2.09772810e-02f,
  -1.77011508e-02f, -2.30615679e-02f, -1.18807472e-01f, -6.15565479e-02f, -2.87474599e-02f, -5.26026301e-02f, -5.61669096e-02f, 1.66467112e-02f, -5.10740057e-02f, -8.69986936e-02f,
  1.30256802e-01f, -3.36051583e-02f, 4.51418795e-02f, -1.21924924e-04f, -5.90930916e-02f, -5.12799285e-02f, 1.80989150e-02f, -2.70155910e-02f, -1.10019699e-01f, 5.42181842e-02f,
  2.55266298e-03f, -3.78817394e-02f, -1.32933587e-01f, -7.81908631e-02f, -1.15757436e-01f, 4.50536609e-03f, -8.87439400e-02f, -5.07654510e-02f, -1.49804140e-02f, -1.08824328e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.29305283e-02f, 7.00390413e-02f, 2.57455915e-01f, 2.27702293e-03f, 2.56670807e-02f, 4.01789427e-01f, 1.14332274e-01f, 1.84947744e-01f, 2.57314622e-01f, 1.88545808e-01f,
  2.04469964e-01f, 2.31672898e-02f, 2.57467091e-01f, 1.80619404e-01f, 8.44146311e-02f, 1.71322897e-01f, 1.69210508e-01f, 1.82087630e-01f, 1.39638603e-01f, 2.31119990e-03f,
  9.03471783e-02f, 7.54201040e-02f, 4.98192646e-02f, 2.18581095e-01f, 4.42707948e-02f, 2.31252387e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.27501205e-01f, 2.36448608e-02f, 1.16298422e-02f, 3.99676412e-01f, -2.83022642e-01f, 2.78108567e-03f, 8.69752318e-02f, -1.61609739e-01f, -6.90638870e-02f, 1.75007239e-01f,
  -1.31060019e-01f, -2.50655897e-02f, 1.69274032e-01f, 8.54634047e-02f, 1.21142350e-01f, 5.04716337e-02f, -1.49087086e-01f, 1.28681108e-01f, -5.96911237e-02f, -1.11772224e-01f,
  -5.25788106e-02f, -1.38578355e-01f, -3.81509550e-02f, -1.82759181e-01f, 2.52235115e-01f, 1.67308450e-01f, -1.23581998e-01f, 1.75136894e-01f, 6.80355653e-02f, -4.91613336e-03f,
  2.58753270e-01f, 1.35080069e-02f, -1.52981073e-01f, 1.49477437e-01f, -3.49270135e-01f, 7.51262963e-01f, -3.31878483e-01f, -3.08930457e-01f, -1.02239214e-01f, 2.07161278e-01f,
  -1.93428062e-02f, 1.53604224e-01f, -2.69000717e-02f, 6.67978898e-02f, -1.85825765e-01f, -3.18426311e-01f, 1.36824315e-02f, -8.20059180e-02f, 1.37994766e-01f, -5.28749153e-02f,
  1.01312824e-01f, -3.52865517e-01f, 2.28825524e-01f, -6.01911824e-03f, -4.63829003e-02f, -1.42316699e-01f, 2.22677037e-01f, -5.52875474e-02f, -1.89702779e-01f, -1.54914692e-01f,
  9.64000076e-02f, -1.62847117e-01f, -2.73954254e-02f, 4.48999964e-02f, -2.96787564e-02f, -2.85461813e-01f, 7.93450251e-02f, -5.04914582e-01f, 5.59965789e-01f, 3.97413880e-01f,
  -2.45847762e-01f, 7.61846974e-02f, -8.65298286e-02f, 1.65812403e-01f, 1.70544788e-01f, -5.74799143e-02f, 2.46036857e-01f, 2.04206422e-01f, 1.19614694e-02f, -2.70762593e-01f,
  1.15922578e-01f, 6.50825277e-02f, -1.04268730e-01f, -3.34098749e-02f, -2.64357209e-01f, 3.11306864e-01f, -1.64742410e-01f, 2.44567655e-02f, -2.31121317e-01f, -2.12232172e-01f,
  1.36509955e-01f, -7.24886954e-02f, 1.82992905e-01f, -1.75817207e-01f, 5.69916405e-02f, 6.47636428e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.55048358e-01f, -1.41757891e-01f, -2.03380033e-01f, 2.89904326e-02f, -3.67955081e-02f, 1.87819883e-01f, -1.58892035e-01f, 1.84606880e-01f, -6.75214082e-02f, 2.11326312e-02f,
  2.12814406e-01f, 1.15488589e-01f, 6.43221676e-01f, -1.07312098e-03f, -8.72942433e-02f, 2.76862323e-01f, -1.46501467e-01f, 9.59819648e-03f, 1.03480928e-01f, 4.63956952e-01f,
  1.26865417e-01f, -2.92734951e-01f, -2.37857178e-01f, 3.34727794e-01f, 2.48004254e-02f, 6.97601289e-02f, 3.29741746e-01f, -8.56439397e-02f, 3.78076822e-01f, -3.16837460e-01f,
  1.08933628e-01f, 6.08406849e-02f, -1.52517527e-01f, -5.79392016e-02f, 2.79421955e-01f, -3.49033415e-01f, 5.34188412e-02f, -1.51140794e-01f, -1.21212028e-01f, -1.41206384e-01f,
  -1.01348318e-01f, -1.11746199e-01f, 6.38810471e-02f, -1.73447415e-01f, 2.67685819e-02f, -1.07903115e-01f, 1.91257522e-01f, 1.62546813e-01f, 2.38431662e-01f, -1.02583855e-01f,
  3.98960970e-02f, 1.22687988e-01f, -1.77438334e-01f, 3.92321408e-01f, -1.58929050e-01f, -1.29129946e-01f, -7.62927234e-02f, 6.78233281e-02f, 7.05243126e-02f, -9.40693542e-02f,
  -1.22709394e-01f, 2.05825847e-02f, -3.68306376e-02f, 1.34699434e-01f, -4.24143299e-02f, 1.99053988e-01f, 1.47871918e-03f, 1.41148895e-01f, -2.57410079e-01f, -3.07053953e-01f,
  1.10144727e-01f, 1.52763203e-01f, -1.38192311e-01f, -1.53019607e-01f, -1.35322794e-01f, 2.36267850e-01f, -1.46229401e-01f, 3.50643098e-02f, -2.21006736e-01f, -1.11143403e-01f,
  -5.48541695e-02f, 1.84092104e-01f, 3.39216053e-01f, 4.29985560e-02f, -7.91596696e-02f, 1.31936088e-01f, 2.08788589e-01f, 1.18759573e-02f, 7.61219487e-02f, 2.05709666e-01f,
  -1.58092856e-01f, 8.34773406e-02f, 5.86697645e-02f, 2.91830838e-01f, -1.70446903e-01f, 1.88183501e-01f, -1.49645135e-01f, 1.35715597e-03f, -9.81407613e-02f, -1.41470909e-01f,
  -4.10206523e-03f, 8.38949829e-02f, -1.08096920e-01f, -1.17424957e-01f, -2.13567764e-02f, 9.56488699e-02f, -1.32547885e-01f, -2.52666399e-02f, 5.96675910e-02f, -6.53973296e-02f,
  -6.77382341e-03f, 5.59319556e-02f, 6.50336295e-02f, -8.81712362e-02f, 9.38820317e-02f, -9.96181592e-02f, -9.19264108e-02f, 7.66563863e-02f, -1.27051011e-01f, -1.57121047e-01f,
  8.76102000e-02f, -1.65120408e-01f, -1.19136088e-01f, -2.00631879e-02f, 6.09420752e-03f, 5.37115633e-02f, -3.15614231e-02f, -1.28220722e-01f, 1.00892320e-01f, 3.56116802e-01f,
  4.13797051e-01f, 2.16453984e-01f, 2.15387195e-01f, 4.20809329e-01f, 6.87367171e-02f, 2.15348929e-01f, 5.41940033e-01f, 2.34115273e-01f, 5.35940975e-02f, 5.17714858e-01f,
  9.21752453e-02f, 1.80770844e-01f, 5.14033020e-01f, -8.98562893e-02f, 1.81276217e-01f, -6.06796965e-02f, 1.25791207e-01f, -2.02865854e-01f, -8.94628838e-02f, 2.83671588e-01f,
  1.49879023e-01f, 3.93109947e-01f, -6.57811090e-02f, 3.37501578e-02f, -1.82616726e-01f, 7.14767128e-02f, 8.57224390e-02f, -1.73982099e-01f, -1.15595877e-01f, 1.49016351e-01f,
  4.64582562e-01f, 2.84862012e-01f, 3.92330110e-01f, -3.33691239e-01f, 3.94905418e-01f, -2.71049589e-01f, -1.29087374e-01f, 1.15122743e-01f, -2.13410449e-03f, 4.07005310e-01f,
  3.89421642e-01f, -7.06325099e-02f, 2.20103599e-02f, 5.82496285e-01f, -2.37146392e-01f, -2.07330156e-02f, 2.87123144e-01f, 3.16027492e-01f, 3.56033027e-01f, 1.56264186e-01f,
  1.43185332e-01f, 1.51884034e-01f, 3.73202354e-01f, 1.83873072e-01f, 1.27782315e-01f, 7.44841024e-02f, 2.01488703e-01f, 5.48042683e-03f, -6.35285676e-02f, 9.13835287e-01f,
  1.93850055e-01f, -1.05320595e-01f, 7.95595050e-02f, 5.75984791e-02f, 9.49869826e-02f, -3.36425602e-02f, 7.80246183e-02f, 2.41302955e-03f, -7.90939927e-02f, 6.13240413e-02f,
  2.89098006e-02f, 4.70809229e-02f, -5.22326082e-02f, 2.45148525e-01f, -1.73689369e-02f, -1.97767541e-02f, 5.13745137e-02f, 1.76603511e-01f, 2.17677876e-02f, -4.38229814e-02f,
  9.03475359e-02f, -1.02440767e-01f, 4.12059240e-02f, -6.73024952e-02f, 1.56717777e-01f, 1.23350509e-02f, -7.00566396e-02f, -9.87707227e-02f, 4.17980887e-02f, -1.59234866e-01f,
  -1.10145204e-01f, -7.78801963e-02f, 1.16845384e-01f, 2.21586809e-01f, 9.55325142e-02f, -7.49240741e-02f, 3.29584852e-02f, -2.18910500e-01f, -1.49214655e-01f, -1.87914029e-01f,
  -1.61829293e-01f, -1.61966130e-01f, 7.53366202e-02f, -3.02258432e-02f, -1.90304108e-02f, -2.25724831e-01f, 7.79486075e-02f, -2.09532212e-02f, -1.65553354e-02f, 1.71481624e-01f,
  -2.08362937e-01f, 1.37609407e-01f, -5.04147634e-02f, 2.20708981e-01f, -2.71199048e-02f, 4.26778235e-02f, -6.86390325e-02f, 5.48358075e-02f, 9.79343206e-02f, -1.14708148e-01f,
  1.32426083e-01f, 5.94498664e-02f, 9.80408639e-02f, -6.60527125e-02f, -5.49942926e-02f, 1.21594921e-01f, 5.64960539e-02f, 2.06289098e-01f, 2.16986462e-01f, 3.62352788e-01f,
  3.41220200e-02f, -7.03832656e-02f, -9.45747122e-02f, -2.06504077e-01f, 4.18831944e-01f, 3.18416923e-01f, 5.90063110e-02f, 2.83112228e-01f, -1.20081753e-02f, 2.01844767e-01f,
  3.65090353e-04f, -2.95974687e-02f, 3.77072617e-02f, 1.86829358e-01f, 6.97421581e-02f, -1.22930244e-01f, -1.37210144e-02f, -2.61779875e-01f, 3.21855068e-01f, 1.25416249e-01f,
  9.03245993e-03f, 1.06946267e-01f, -1.46340221e-01f, -1.46256521e-01f, 4.21906263e-02f, 2.59126902e-01f, -1.37981758e-01f, 1.93822339e-01f, -1.56709075e-01f, -9.60230827e-03f,
  -3.06906164e-01f, 1.08820595e-01f, -2.49464646e-01f, 2.35209465e-02f, 8.70462283e-02f, 1.78229883e-01f, -1.03511125e-01f, 9.01319608e-02f, 1.07930362e-01f, 2.03463048e-01f,
  1.80414408e-01f, -1.49286553e-01f, 1.06101364e-01f, -6.87547028e-03f, 6.96064979e-02f, -3.82747594e-03f, 6.48213625e-02f, 3.62944864e-02f, 1.83758751e-01f, -1.85905725e-01f,
  8.49460587e-02f, 4.97761555e-02f, 1.26902327e-01f, -9.53388661e-02f, 2.45747253e-01f, -1.15506262e-01f, 1.90633774e-01f, 5.27452258e-03f, 1.14560112e-01f, -4.53603342e-02f,
  -1.92966923e-01f, 2.73432732e-01f, 4.86561395e-02f, 2.12306947e-01f, 7.91251287e-02f, 2.52735227e-01f, 2.47617573e-01f, 3.66070032e-01f, 4.36042547e-01f, -1.46264628e-01f,
  -2.32880563e-02f, 4.03623402e-01f, 2.46868283e-01f, -2.22341865e-01f, 2.44190425e-01f, 3.19330454e-01f, 1.25876039e-01f, -1.38216734e-01f, -6.87423795e-02f, -1.97329283e-01f,
  -1.22460695e-02f, 1.62500411e-01f, -1.79770082e-01f, 2.80060302e-02f, -1.44158555e-02f, -2.57064197e-02f, 9.86720100e-02f, 3.07829440e-01f, -1.80924423e-02f, -2.23044112e-01f,
  8.69175643e-02f, 3.30706626e-01f, -4.97471653e-02f, -1.35019459e-02f, -3.60323995e-01f, 2.20593289e-01f, -6.09311104e-01f, -4.12172049e-01f, 1.82627186e-01f, 5.12163758e-01f,
  -1.56153515e-01f, -1.75173730e-01f, 5.16263954e-03f, 3.52575451e-01f, 4.18109775e-01f, 1.47945909e-02f, -1.38280347e-01f, 4.15874481e-01f, -5.08321486e-02f, -2.38317270e-02f,
  3.61061335e-01f, 2.15411976e-01f, -3.15314941e-02f, -9.91544649e-02f, -8.51060450e-02f, 2.49866590e-01f, 1.26991421e-01f, 1.79753616e-01f, 7.72368163e-02f, -4.70951162e-02f,
  1.81742445e-01f, -4.29663867e-01f, -2.50729680e-01f, 1.00168906e-01f, -1.54003529e-02f, 6.49173930e-02f, 3.20218116e-01f, 3.23162436e-01f, 1.94745943e-01f, -5.90923652e-02f,
  -1.33937076e-01f, 2.69395620e-01f, 3.32691431e-01f, 3.18588376e-01f, 2.39022449e-02f, 3.44146699e-01f, -4.21842411e-02f, -1.22666210e-01f, 2.92674690e-01f, 9.02316123e-02f,
  1.53819621e-01f, -9.27894190e-02f, -7.66409412e-02f, -1.09245434e-01f, 1.10113829e-01f, -2.44820282e-01f, 2.34911934e-01f, 2.47853324e-01f, 2.38431111e-01f, -3.93869467e-02f,
  -1.91184565e-01f, 2.23111033e-01f, -5.55285737e-02f, 5.77958785e-02f, 1.41381221e-02f, 1.31998464e-01f, -2.62593329e-02f, 9.01013687e-02f, -1.51468039e-01f, 7.72077739e-02f,
  1.67583123e-01f, 2.20731333e-01f, 1.07364126e-01f, -6.21260842e-03f, -1.97091196e-02f, 2.02181842e-02f, 1.98355228e-01f, -1.95447952e-02f, 2.82335967e-01f, -1.02544896e-01f,
  4.11899626e-01f, -6.66757056e-04f, 1.27692431e-01f, -3.65948528e-02f, -2.25124598e-01f, -1.52790695e-02f, -8.43531042e-02f, 1.53744206e-01f, -2.23947838e-01f, 1.82395041e-01f,
  1.94806784e-01f, -9.05847922e-02f, 8.66787508e-03f, -1.37646599e-02f, 2.16403902e-01f, -2.92048961e-01f, 1.44741550e-01f, -1.04790680e-01f, 8.09205472e-02f, 4.04308774e-02f,
  2.95295835e-01f, -4.06727105e-01f, 4.55690682e-01f, 8.65455046e-02f, 1.34115010e-01f, 1.67598471e-01f, -4.65127500e-03f, 5.79685234e-02f, 2.55616933e-01f, 2.30160296e-01f,
  2.26186156e-01f, 2.23044083e-01f, 6.69062734e-02f, -6.83599636e-02f, 2.00585037e-01f, 1.65153846e-01f, 7.56804273e-02f, -1.74386069e-01f, 9.32772160e-02f, 2.30632529e-01f,
  -4.02711481e-02f, 1.46505103e-01f, -7.95398206e-02f, -4.08456810e-02f, 1.51153341e-01f, -3.13479193e-02f, -4.29159887e-02f, 2.13477746e-01f, -6.15239143e-02f, 1.78920537e-01f,
  3.19389015e-01f, 1.32337213e-01f, 2.44589150e-02f, -2.21450508e-01f, 7.78273642e-02f, 6.94522485e-02f, 1.33552641e-01f, 1.71515718e-01f, -2.23300666e-01f, -6.27084821e-02f,
  2.04498380e-01f, 4.83725294e-02f, 2.70572394e-01f, 4.21947829e-04f, -1.10971415e-02f, 2.00282298e-02f, 3.14691842e-01f, 1.99592903e-01f, 1.27643153e-01f, 2.25976571e-01f,
  -1.80810660e-01f, 4.98491190e-02f, -1.25170514e-01f, -9.91294757e-02f, 9.15695429e-02f, 9.05054659e-02f, 2.18015000e-01f, 8.70533735e-02f, -5.21557927e-02f, 2.65852332e-01f,
  -1.37085781e-01f, 8.80990848e-02f, 1.68153688e-01f, 1.54535055e-01f, 1.17693484e-01f, 2.75206357e-01f, -2.50864238e-01f, 1.32757053e-01f, 5.86881451e-02f, 2.97710389e-01f,
  2.19920859e-01f, -1.36241376e-01f, 1.25174195e-01f, 2.24240914e-01f, 1.44775342e-02f, 1.22316502e-01f, 4.79781151e-01f, 3.50582637e-02f, -1.57354355e-01f, 1.74075380e-01f,
  2.36393839e-01f, -7.76610747e-02f, -2.70726457e-02f, 6.90371171e-02f, 6.47186786e-02f, 1.92147806e-01f, 1.35946656e-02f, 1.86719894e-01f, -1.45537749e-01f, -2.00751588e-01f,
  -1.28717259e-01f, -1.09462358e-01f, -1.93177909e-01f, 1.35671511e-01f, 2.21988663e-01f, -2.07677826e-01f, -1.30572230e-01f, -8.82264674e-02f, -3.70623559e-01f, -6.09576702e-01f,
  2.99064349e-02f, 4.53409046e-01f, -1.54662967e-01f, 6.01670556e-02f, -2.90067066e-02f, 1.18356384e-01f, -6.17682040e-02f, 2.04388767e-01f, -3.20766300e-01f, 4.30900693e-01f,
  1.18853606e-01f, -5.39278425e-02f, 5.84936678e-01f, 2.74805605e-01f, -1.22074574e-01f, -5.74032292e-02f, 1.48424163e-01f, -5.33292741e-02f, 2.58296877e-01f, -1.50744570e-03f,
  2.27224886e-01f, 2.49440409e-02f, -1.53166160e-01f, 1.98508874e-01f, 8.21190625e-02f, -1.63005918e-01f, 3.11587900e-01f, 4.46734093e-02f, 4.34594341e-02f, -2.76426166e-01f,
  3.37630570e-01f, 3.82318020e-01f, 9.06822681e-02f, 2.57266402e-01f, -1.58298731e-01f, 8.79458562e-02f, 1.37668535e-01f, 9.69400480e-02f, 4.84806120e-01f, 1.84196621e-01f,
  1.02376767e-01f, -1.10322073e-01f, 2.06788242e-01f, 5.35184070e-02f, -2.25789356e-03f, -7.05749542e-02f, -7.74335489e-02f, -1.90224409e-01f, -1.07610293e-01f, 2.23328218e-01f,
  -1.22897759e-01f, -5.07005081e-02f, 8.81389230e-02f, 6.26699999e-02f, 1.35529965e-01f, -1.00902215e-01f, 3.83450910e-02f, 1.35456368e-01f, 1.68720484e-01f, 9.32741910e-02f,
  5.23447171e-02f, -8.74456838e-02f, 3.49535346e-02f, -2.77074776e-03f, -1.56538576e-01f, -1.11006029e-01f, -1.30469352e-01f, -5.44798970e-02f, -1.39135003e-01f, -1.78165928e-01f,
  -3.56515832e-02f, -1.74503908e-01f, 1.18192405e-01f, 1.72090337e-01f, -8.56352001e-02f, 2.40830760e-02f, -1.59807894e-02f, 3.25041443e-01f, -5.75671978e-02f, -1.40533760e-01f,
  1.30903021e-01f, -2.16975883e-02f, 2.14384079e-01f, 1.06707439e-01f, -1.54909864e-01f, -1.07166074e-01f, -9.86253321e-02f, 1.42402261e-01f, 2.21561909e-01f, -7.11652562e-02f,
  4.84307706e-01f, -8.35754573e-02f, 3.18548828e-01f, -1.14501052e-01f, -5.60079888e-02f, -6.22991957e-02f, -1.70722157e-01f, -1.74639076e-02f, -1.34669006e-01f, -1.11873597e-01f,
  1.14591923e-02f, 2.57418245e-01f, 3.15277815e-01f, 2.38534272e-01f, 3.78319249e-02f, 1.56762637e-02f, 1.15538046e-01f, -5.84021509e-02f, 4.22206730e-01f, 1.72313303e-01f,
  -8.07016119e-02f, -3.50231212e-03f, 1.40891314e-01f, -1.03180245e-01f, -1.97348788e-01f, 1.91086344e-02f, 8.55960697e-02f, -1.77088797e-01f, 6.73067942e-02f, 1.81659415e-01f,
  4.95926999e-02f, 1.16060562e-01f, 1.13624841e-01f, -7.06793442e-02f, 7.12882355e-02f, -5.89075498e-03f, -2.68790841e-01f, -1.20456137e-01f, 3.04564953e-01f, 4.99472082e-01f,
  1.38145715e-01f, -2.70799041e-01f, -1.63414180e-01f, 4.45130825e-01f, -1.40919223e-01f, -7.48310760e-02f, 3.28230917e-01f, 3.37363154e-01f, 1.76548794e-01f, 5.78702427e-02f,
  1.60593048e-01f, 7.42877796e-02f, 6.24409840e-02f, 3.47743422e-01f, 9.39568430e-02f, -1.32270029e-03f, -1.15876138e-01f, 2.50421047e-01f, 9.21200737e-02f, 9.15864483e-02f,
  -1.64519712e-01f, -1.89809412e-01f, -2.51806557e-01f, 2.01705635e-01f, -5.04243560e-02f, 2.64329091e-02f, 4.42175679e-02f, -1.12898536e-01f, -2.42843091e-01f, 8.79416615e-02f,
  -1.36035547e-01f, -1.24633005e-02f, 8.43655691e-02f, 1.49983943e-01f, -1.13823051e-02f, -4.33139950e-02f, 5.50285317e-02f, 1.27249658e-01f, 7.04303756e-02f, 4.01509143e-02f,
  1.18222438e-01f, -1.01002036e-02f, 2.29607671e-01f, -1.48473129e-01f, -4.37139571e-02f, -5.19085564e-02f, -3.96010727e-02f, 1.47027802e-03f, 1.39417484e-01f, 4.77215648e-02f,
  -1.62466511e-01f, -1.48465201e-01f, -7.06026256e-02f, 9.33545232e-02f, -1.94161192e-01f, 1.72364309e-01f, -7.35371113e-02f, 2.46616662e-01f, 1.19474061e-01f, 3.82040858e-01f,
  4.42627110e-02f, 2.44835928e-01f, -1.41833305e-01f, 6.12848885e-02f, 4.21924978e-01f, 7.53555223e-02f, -1.06245480e-01f, 2.13513032e-01f, 8.73742849e-02f, 1.34074003e-01f,
  4.49402481e-01f, -4.79743592e-02f, -1.25401139e-01f, 1.07332982e-01f, 1.52390659e-01f, -1.22537442e-01f, 8.51517767e-02f, -3.58074568e-02f, 1.98137417e-01f, 1.84398696e-01f,
  3.08264077e-01f, 8.72776806e-02f, -7.88219459e-03f, 1.02416530e-01f, 7.37983733e-02f, -1.01799376e-01f, 4.37664613e-02f, 1.40109155e-02f, -5.54945283e-02f, -9.83569846e-02f,
  -2.15147361e-01f, -7.39626773e-03f, 1.40592456e-01f, -2.12152854e-01f, -1.47512943e-01f, 3.09081703e-01f, 1.45906046e-01f, 5.49849905e-02f, 2.80325133e-02f, 1.69631481e-01f,
  3.27241011e-02f, -1.97444677e-01f, 4.74258289e-02f, -1.80348396e-01f, 1.26292884e-01f, -1.81401357e-01f, 3.57798822e-02f, -2.17141017e-01f, 7.09230602e-02f, -4.87876730e-03f,
  1.13638699e-01f, 2.37566337e-01f, 4.49399538e-02f, -1.18285730e-01f, -1.58114269e-01f, -1.50380418e-01f, -1.39998078e-01f, -7.54725635e-02f, 2.23613605e-01f, 1.54683456e-01f,
  9.31712091e-02f, -1.75740033e-01f, 1.02588404e-02f, -5.23991324e-02f, -1.84201866e-01f, 1.29908323e-01f, -1.60441890e-01f, -1.03054941e-01f, -4.27597724e-02f, 5.43221682e-02f,
  1.06218075e-02f, 7.66151547e-02f, 1.82268262e-01f, -5.87243922e-02f, 1.49814472e-01f, -5.56635819e-02f, 1.16249599e-01f, 3.34938131e-02f, 5.63381650e-02f, 1.84496582e-01f,
  7.12348372e-02f, 7.57718384e-02f, 8.53679255e-02f, 1.54065326e-01f, -8.95442069e-02f, -3.29007581e-02f, 5.86317033e-02f, -6.80609718e-02f, 1.89542115e-01f, -1.44560307e-01f,
  1.83878452e-01f, -1.19085787e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.85385510e-01f, 8.85596350e-02f, -2.28500757e-02f, -1.43714935e-01f, 3.26138109e-01f, 2.56935149e-01f, -7.26325884e-02f, 1.08490758e-01f, 2.52480596e-01f, -1.39096558e-01f,
  3.36525589e-01f, 2.26731881e-01f, 5.06206974e-02f, 2.31357113e-01f, 1.52352542e-01f, 2.18855754e-01f, 3.22166264e-01f, 3.43725860e-01f, 1.54286399e-01f, 1.65035576e-01f,
  2.60333747e-01f, 2.84547895e-01f, 1.05661601e-01f, 3.70701492e-01f, -1.14524491e-01f, 3.17879803e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -5.37749678e-02f, 1.49469629e-01f, -2.11054251e-01f, -1.63767591e-01f, 1.51776522e-01f, 9.29967239e-02f, 7.42539689e-02f, 2.46021524e-01f, -1.99081272e-01f, 5.10626808e-02f,
  2.20638782e-01f, -3.39573175e-01f, 4.94151041e-02f, 1.34486049e-01f, -4.17557210e-02f, -1.15321286e-01f, 1.27685443e-01f, 2.09240198e-01f, 4.81196418e-02f, -1.43220633e-01f,
  -1.48205206e-01f, -1.13024265e-01f, 2.03140557e-01f, -1.38991207e-01f, -1.74326509e-01f, 2.14169919e-01f, -3.42703849e-01f, 3.06383193e-01f, -1.07775845e-01f, 8.77596810e-02f,
  1.45098940e-01f, -1.93365682e-02f, 3.81079353e-02f, 6.89359307e-02f, -4.92171086e-02f, -1.18086338e-01f, -2.43576437e-01f, 3.17616016e-01f, -5.53082116e-02f, 1.43350204e-02f,
  -1.43373147e-01f, 1.73804015e-01f, -9.79799405e-02f, 3.62636954e-01f, -2.23175183e-01f, -3.29961330e-02f, 3.28218527e-02f, 2.19280776e-02f, -3.14905554e-01f, -5.79418093e-02f,
  5.41995801e-02f, 1.94377989e-01f, 1.47964001e-01f, -1.00849301e-01f, -1.48518264e-01f, 1.54943112e-02f, 1.82424963e-01f, 2.76346505e-01f, -1.20313086e-01f, -3.68807822e-01f,
  4.05282453e-02f, 4.89473902e-02f, -8.73467177e-02f, 2.26229519e-01f, -2.75056243e-01f, -2.80560583e-01f, 1.24433696e-01f, -1.18116468e-01f, -3.79678011e-01f, 4.03913140e-01f,
  1.71568349e-01f, -1.02791809e-01f, -2.80087739e-01f, -9.75780636e-02f, 1.34121999e-01f, 3.07446837e-01f, -8.38646814e-02f, 1.79756097e-02f, 1.31256193e-01f, -5.40194139e-02f,
  -9.83065590e-02f, -2.51408070e-01f, 1.07254133e-01f, 2.94658959e-01f, 2.22566172e-01f, 2.00741924e-02f, -1.35728464e-01f, -2.05873758e-01f, 2.57920712e-01f, -3.23737934e-02f,
  -1.17683366e-01f, -4.36999738e-01f, -1.42359480e-01f, 7.35769272e-02f, 1.11005399e-02f, -1.00742877e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.18128011e-01f, 1.49222180e-01f, -1.09038375e-01f, -2.30759814e-01f, -2.17541426e-01f, -2.45296545e-02f, -2.94924378e-01f, 3.33100826e-01f, 6.37024939e-02f, 1.53805122e-01f,
  2.69730061e-01f, -1.64408684e-01f, -1.13314122e-01f, 1.68366134e-01f, -2.32929677e-01f, -4.76961881e-02f, 3.78448874e-01f, 1.80158049e-01f, 1.57406732e-01f, 1.26487598e-01f,
  1.66377097e-01f, -3.32833119e-02f, 2.76241899e-01f, 3.38322744e-02f, -2.21682414e-01f, 1.06294282e-01f, -1.90428242e-01f, 5.58546126e-01f, -8.99851173e-02f, 2.14012310e-01f,
  7.26345554e-02f, -1.92037523e-01f, 2.87063599e-01f, 1.06368989e-01f, 1.46733060e-01f, 5.01101054e-02f, -2.62499116e-02f, -3.03248346e-01f, 1.08395135e-02f, -1.54366866e-01f,
  1.27227232e-01f, -1.75306737e-01f, -1.01534694e-01f, 7.25968719e-01f, 2.73676426e-03f, 1.99802637e-01f, 2.70755678e-01f, -1.32187098e-01f, -3.85795861e-01f, -9.97510776e-02f,
  2.57241279e-01f, -4.02633667e-01f, 1.33802265e-01f, -6.53566569e-02f, 1.36739135e-01f, 1.33199587e-01f, -1.05659775e-01f, 2.98881948e-01f, 2.24727139e-01f, 1.50111727e-02f,
  6.04258617e-03f, 4.89962660e-02f, 6.84874654e-02f, -1.51590481e-01f, -9.40256640e-02f, -2.26773977e-01f, 1.15506865e-01f, -7.78324753e-02f, -2.18312759e-02f, 1.78558275e-01f,
  2.89417803e-01f, -2.12336332e-01f, -5.42812087e-02f, -1.30838072e-02f, -3.07874475e-02f, 3.27970654e-01f, -1.75203271e-02f, -1.45980448e-01f, 1.67238474e-01f, 2.24929273e-01f,
  -8.03912058e-02f, -7.99959991e-03f, 2.33200744e-01f, -7.68880695e-02f, -3.77139077e-02f, -6.62157536e-02f, 1.70883741e-02f, 1.10322475e-01f, 1.73065364e-01f, -4.15155180e-02f,
  -1.35672325e-02f, -1.65603906e-01f, 1.60118267e-01f, -9.62089561e-03f, -3.61280218e-02f, -5.00285588e-02f, 1.23474367e-01f, -1.43287003e-01f, 1.78770646e-01f, -3.47591907e-01f,
  -3.61587912e-01f, 6.55967295e-01f, 2.89702535e-01f, 1.79938197e-01f, 5.36886684e-04f, 3.61539982e-02f, 4.59001571e-01f, -7.80601576e-02f, 1.76419448e-02f, -1.45751953e-01f,
  -2.52864897e-01f, 1.30045161e-01f, 4.07454163e-01f, 4.11233194e-02f, -1.29584730e-01f, 3.14110279e-01f, 5.30494452e-01f, 3.02201331e-01f, -1.35368049e-01f, -2.48320580e-01f,
  4.30712849e-01f, 6.02207966e-02f, 6.17630258e-02f, 2.26866856e-01f, -8.26716237e-03f, -7.75562227e-02f, 1.67758688e-01f, 5.49275391e-02f, 4.85175885e-02f, -1.62595898e-01f,
  -2.64739960e-01f, 1.41496211e-01f, 4.37960587e-02f, -1.00512713e-01f, 4.15870041e-01f, -1.75479397e-01f, 2.77568966e-01f, 3.22022587e-02f, -1.65883139e-01f, 3.30223292e-01f,
  -9.78294611e-02f, 1.04884014e-01f, 6.35980964e-02f, 1.75764039e-01f, -5.08455075e-02f, 6.07083023e-01f, 3.33751366e-02f, -7.21634775e-02f, 5.59251606e-02f, 3.11584830e-01f,
  -4.53932025e-02f, 6.93697572e-01f, 1.03212051e-01f, -1.78101823e-01f, 1.36338636e-01f, 1.95564926e-01f, 1.05979688e-01f, -7.29422271e-02f, 1.05135046e-01f, -1.10979863e-01f,
  1.46578714e-01f, -3.52200121e-02f, -2.27221951e-01f, 4.28391814e-01f, 4.22852874e-01f, -3.89814496e-01f, 2.82959663e-03f, -5.92502132e-02f, -7.31606642e-03f, 4.40997556e-02f,
  2.79377818e-01f, -4.30117249e-01f, -1.08875461e-01f, 6.37231767e-03f, 1.32487655e-01f, 2.12865517e-01f, 2.99714744e-01f, 5.58823466e-01f, 2.16766834e-01f, 2.73305207e-01f,
  -3.15200299e-01f, -7.98802748e-02f, 4.67149764e-01f, 2.62747824e-01f, -5.89547621e-04f, 1.23659089e-01f, 1.19046248e-01f, 5.27502537e-01f, 8.54063928e-02f, 4.92192328e-01f,
  2.69215535e-02f, -8.00843015e-02f, -1.05128124e-01f, -1.54091954e-01f, -1.84631184e-01f, 5.22389971e-02f, -2.38169245e-02f, 1.37283914e-02f, 2.41885707e-01f, -3.06571946e-02f,
  -1.78665951e-01f, -1.04109906e-01f, -1.40850069e-02f, -1.99228272e-01f, 1.76292434e-01f, 1.16689421e-01f, -1.55961156e-01f, 2.33935177e-01f, 3.40026498e-01f, 2.11774424e-01f,
  2.33342603e-01f, 2.47797281e-01f, 1.92240048e-02f, 1.15833700e-01f, 4.19770628e-02f, -1.07622698e-01f, 2.42800444e-01f, 2.62036752e-02f, 1.87567398e-02f, 6.46024346e-02f,
  -1.33184984e-01f, 2.10467234e-01f, 2.68412411e-01f, -5.27892634e-03f, 1.41132787e-01f, 2.48438403e-01f, 9.24304724e-02f, 8.27151686e-02f, 1.81601524e-01f, 1.38924226e-01f,
  2.48624831e-01f, -1.39440104e-01f, -9.77264643e-02f, -1.71776727e-01f, 6.34386659e-01f, 7.04273721e-03f, 1.76630929e-01f, -2.03993589e-01f, 1.30943343e-01f, -8.46352354e-02f,
  4.67100143e-01f, -1.53514817e-01f, 4.24373150e-01f, 1.18177421e-01f, 2.78020352e-01f, 6.70571402e-02f, 2.47750372e-01f, -3.61198902e-01f, 3.10570836e-01f, -9.35444422e-03f,
  2.21566021e-01f, 2.92454287e-02f, 6.28591469e-03f, 3.92932832e-01f, -1.09261580e-01f, 1.32242009e-01f, 2.95273274e-01f, 2.00506940e-01f, 2.49886289e-01f, -2.25373968e-01f,
  -1.33843884e-01f, -1.93312377e-01f, -3.84823292e-01f, -1.07739240e-01f, 1.13578282e-01f, 1.15538783e-01f, 5.15590072e-01f, 6.62450790e-01f, 1.37890438e-02f, -2.46160686e-01f,
  4.19973671e-01f, -2.15389714e-01f, -6.62643015e-02f, -4.05575871e-01f, 2.86275744e-01f, -8.64143744e-02f, 2.08100021e-01f, -1.14095798e-02f, -1.04989678e-01f, 8.75323545e-03f,
  4.39821146e-02f, -2.11036444e-01f, 1.56412518e-03f, -1.27309337e-01f, -1.19968690e-01f, 6.69352198e-03f, -1.26436621e-01f, 2.70571522e-02f, 3.44415367e-01f, -4.60147113e-02f,
  2.74160594e-01f, -1.35528862e-01f, -3.64026427e-01f, -6.26193210e-02f, 3.84343356e-01f, -5.37977926e-02f, 4.47328277e-02f, -1.46995634e-01f, -4.97957282e-02f, 2.51099139e-01f,
  9.47380066e-02f, 1.50368914e-01f, -2.30281413e-01f, -8.60970989e-02f, -2.65270114e-01f, 3.78295392e-01f, -2.22286940e-01f, -1.64261520e-01f, 1.54871091e-01f, 3.06905627e-01f,
  -7.85383582e-02f, 6.02706730e-01f, 3.13432783e-01f, 9.92034972e-02f, 5.33608019e-01f, -4.51973528e-02f, -1.38950244e-01f, -8.92077088e-02f, -6.91972375e-02f, 1.62490666e-01f,
  -1.25697196e-01f, -1.64456397e-01f, 1.06017187e-01f, 2.30072234e-02f, -1.95981190e-02f, 2.17726156e-01f, -1.02237023e-01f, -2.67050657e-02f, -2.21277520e-01f, 1.18788682e-01f,
  2.48843849e-01f, -2.72851363e-02f, 4.94768433e-02f, -8.25480372e-02f, 1.02200016e-01f, -1.40848562e-01f, 2.19687492e-01f, -1.41228661e-01f, 2.48652369e-01f, -7.88330063e-02f,
  4.35650721e-02f, -6.24292418e-02f, 2.76108265e-01f, -1.65292099e-01f, 2.73281574e-01f, 1.09308384e-01f, -1.78215191e-01f, 1.87335968e-01f, 1.12123348e-01f, 1.93522796e-01f,
  4.95153107e-02f, -2.09535118e-02f, 1.02840587e-01f, -3.12092334e-01f, -6.74629807e-02f, -4.98123206e-02f, 2.04135329e-01f, -1.18759118e-01f, -9.01570544e-03f, 1.68111399e-01f,
  1.72404334e-01f, -4.87647168e-02f, -8.17853808e-02f, -2.09508389e-02f, -1.06410772e-01f, 6.98919892e-02f, 5.22419550e-02f, 2.75454551e-01f, 1.65999636e-01f, 3.25072616e-01f,
  1.92984417e-01f, -1.93137616e-01f, -2.11580575e-01f, 1.98645201e-02f, -6.14377446e-02f, 4.00466472e-01f, -1.61400691e-01f, 1.55910313e-01f, -2.04020381e-01f, 6.41583279e-02f,
  -1.42646641e-01f, -1.70986041e-01f, 3.21121871e-01f, -1.21787935e-01f, 2.50475079e-01f, 1.21685371e-01f, 3.55119795e-01f, -1.38305917e-01f, -3.53100657e-01f, 2.01005727e-01f,
  2.12047160e-01f, 2.26551339e-01f, -1.24349833e-01f, 1.04749329e-01f, -8.97313505e-02f, 5.69615304e-01f, -1.72498778e-01f, 6.28916966e-03f, -1.90195337e-01f, -3.04704104e-02f,
  -1.19655095e-01f, 5.38306534e-02f, -1.97168231e-01f, -5.02000935e-03f, 3.17795366e-01f, 3.06961060e-01f, -1.48236066e-01f, 1.34640455e-01f, 9.13925916e-02f, 7.88567215e-02f,
  2.11339071e-01f, 3.35499048e-02f, 2.81688198e-03f, -1.81191638e-01f, -6.65331185e-02f, 7.17926472e-02f, 1.56043068e-01f, 3.84307474e-01f, -5.74909747e-02f, -1.43109888e-01f,
  7.32671246e-02f, -1.51830360e-01f, -5.83920442e-02f, -2.03458533e-01f, 2.35300943e-01f, -4.00848426e-02f, 4.74728167e-01f, 1.60295710e-01f, 2.35744864e-02f, -1.71865329e-01f,
  3.34984422e-01f, -1.07667796e-01f, -7.06465170e-02f, -4.73937541e-02f, 3.74309778e-01f, -1.30444869e-01f, 3.58556695e-02f, -1.70967922e-01f, 1.58044249e-01f, -9.88609120e-02f,
  -1.50808752e-01f, 1.19744278e-01f, 2.77718544e-01f, 1.26645118e-01f, 1.86917126e-01f, 2.72822380e-02f, -1.33693069e-01f, 1.02402635e-01f, 7.10812956e-02f, 5.15428245e-01f,
  -2.34057978e-02f, 1.53820485e-01f, 4.80320007e-01f, -4.54348117e-01f, -1.02594212e-01f, 1.96601450e-02f, 9.75850448e-02f, 4.74376008e-02f, 6.18302584e-01f, -1.29160300e-01f,
  1.24677300e-01f, -7.75556043e-02f, 4.23397899e-01f, 9.68349054e-02f, 4.51203704e-01f, 1.92284748e-01f, 2.96181321e-01f, 1.82553723e-01f, 4.62736040e-02f, -5.01539670e-02f,
  3.89835775e-01f, -8.83016735e-02f, -1.00784950e-01f, -1.11264572e-01f, 5.18653765e-02f, 2.34141976e-01f, 8.91896337e-02f, 5.88671207e-01f, -4.64340076e-02f, -7.20858648e-02f,
  2.76688244e-02f, 9.79012102e-02f, 2.82507926e-01f, -9.11011696e-02f, -3.50457162e-01f, 2.95903057e-01f, 1.23734614e-02f, -9.09427553e-02f, -2.92169273e-01f, 4.53208340e-03f,
  3.34137172e-01f, 3.86661470e-01f, 6.55703545e-02f, -1.75330356e-01f, 2.03307629e-01f, 3.22287939e-02f, -5.26026357e-03f, -3.91846836e-01f, 1.11103788e-01f, -6.45903684e-03f,
  3.35351080e-01f, 2.89255112e-01f, -2.10483178e-01f, -3.16127062e-01f, 2.31608912e-01f, -9.85675007e-02f, 1.64725900e-01f, -2.45074052e-02f, -1.54147416e-01f, -3.96119282e-02f,
  1.63579449e-01f, -1.96572572e-01f, 6.74821138e-02f, 2.68556356e-01f, 3.62714343e-02f, 8.12497810e-02f, 6.81162998e-02f, -2.21814558e-01f, 1.27266690e-01f, -2.17069406e-02f,
  -6.58146963e-02f, -1.25032678e-01f, 9.41672102e-02f, -1.21631317e-01f, -1.10954180e-01f, 6.59841150e-02f, -1.41168699e-01f, -1.97402835e-01f, 8.85649547e-02f, -2.31204242e-01f,
  1.84548661e-01f, 3.54765542e-02f, -8.50495622e-02f, 1.39984414e-01f, 1.63755938e-01f, -1.86205190e-02f, -9.38172638e-02f, 2.46162787e-01f, 1.15119942e-01f, -5.70064858e-02f,
  -1.09327972e-01f, 2.17635855e-01f, -2.47550398e-01f, -6.44035498e-03f, -9.61107165e-02f, 4.08972166e-02f, 9.59229618e-02f, -1.68912467e-02f, 1.51110426e-01f, -1.85225889e-01f,
  -1.22577079e-01f, -1.72888353e-01f, 5.56090102e-02f, 1.24770574e-01f, -1.82105422e-01f, 8.09072480e-02f, -1.30517498e-01f, -2.09558848e-02f, 1.62750751e-01f, -6.85326234e-02f,
  -8.22420977e-03f, -5.07239513e-02f, -4.86069024e-02f, -1.38163403e-01f, -2.10551471e-02f, -1.28807575e-01f, -1.14857428e-01f, 1.82495922e-01f, 9.91027281e-02f, 1.60387531e-01f,
  -1.29564866e-01f, 1.39493540e-01f, -8.46099630e-02f, 5.15371487e-02f, -1.63272753e-01f, 7.98667073e-02f, -1.14901930e-01f, 1.48806889e-02f, 5.06814159e-02f, 4.11887243e-02f,
  -2.20820680e-02f, 8.93652216e-02f, 1.29696682e-01f, 6.15556240e-02f, -4.03254107e-02f, 8.24145302e-02f, 1.19907267e-01f, -1.34172335e-01f, 1.04919389e-01f, -1.23588853e-01f,
  -8.60741436e-02f, -1.71260312e-01f, -1.27966374e-01f, -1.32847399e-01f, -1.70095250e-01f, 2.79362276e-02f, 8.06348771e-02f, -1.32603735e-01f, -1.60845309e-01f, -5.39121479e-02f,
  -1.65748417e-01f, -3.08821127e-02f, 6.59135506e-02f, -1.33447759e-02f, -7.22143576e-02f, -5.70519865e-02f, 8.19495097e-02f, -7.05124959e-02f, -9.14842859e-02f, -1.02381811e-01f,
  6.51543513e-02f, 6.61328882e-02f, 1.79359838e-02f, 1.55878559e-01f, 1.95149511e-01f, 4.63477038e-02f, 4.16904502e-02f, 1.47964060e-01f, 1.49182379e-01f, 1.53933302e-01f,
  1.33800013e-02f, 1.02907224e-02f, -4.12980467e-02f, 8.60395283e-02f, 1.19210653e-01f, -1.12863049e-01f, 5.98193593e-02f, 3.90017629e-02f, -8.20558369e-02f, -8.51503238e-02f,
  -1.08458921e-01f, -1.01068430e-01f, 1.96896583e-01f, 1.00578062e-01f, -7.90966675e-02f, -8.19338411e-02f, 1.30213454e-01f, 1.51274158e-02f, 1.00976631e-01f, 3.27967815e-02f,
  1.63170382e-01f, -4.63232361e-02f, -1.72587678e-01f, 3.85718346e-02f, -2.98749655e-02f, -6.47149235e-02f, 1.01221330e-01f, 3.82302813e-02f, 6.40260950e-02f, 5.28118983e-02f,
  -1.20952621e-01f, -1.08042277e-01f, -3.94011177e-02f, -6.47271648e-02f, -6.75460026e-02f, 1.35853931e-01f, -1.32458672e-01f, -1.13889977e-01f, -7.61685446e-02f, -7.43030012e-02f,
  1.29189834e-01f, 1.26766367e-02f, -1.35913000e-01f, 2.90431827e-03f, -1.65292397e-01f, 9.65561066e-03f, -1.14132464e-01f, 4.27639484e-02f, -1.13519572e-01f, 9.22308862e-02f,
  1.39270037e-01f, -7.49864057e-02f, 3.60132068e-01f, 4.96119857e-02f, 2.38153428e-01f, -2.21638858e-01f, -3.47563148e-01f, 2.77928505e-02f, -5.41961849e-01f, 1.42194703e-01f,
  3.04854214e-01f, -1.44906595e-01f, 2.35718396e-02f, 7.83115327e-01f, 9.18289050e-02f, -2.25641981e-01f, -1.41178444e-02f, -1.44155636e-01f, -1.73835546e-01f, -3.51596504e-01f,
  4.65395674e-02f, -3.22629154e-01f, 2.79641986e-01f, 3.59406322e-01f, 9.56680030e-02f, 2.27633774e-01f, -6.93610385e-02f, -1.67531485e-03f, 2.02815399e-01f, 2.58033693e-01f,
  1.70026168e-01f, -8.26928690e-02f, -1.52762949e-01f, -1.53192401e-01f, 2.22809955e-01f, 5.89199781e-01f, 4.08928365e-01f, 2.37671852e-01f, -1.70880079e-01f, -1.43003911e-01f,
  3.09950978e-01f, -9.31575298e-02f, -7.87895620e-02f, -7.38773420e-02f, 3.42481554e-01f, -3.11653521e-02f, -1.21015094e-01f, -3.15226875e-02f, 2.34360978e-01f, 1.13850860e-02f,
  -1.99711263e-01f, -1.86981946e-01f, 5.14771342e-02f, 9.88628566e-02f, -2.17696384e-01f, 8.49304050e-02f, 2.67884463e-01f, -2.98854470e-01f, 1.56109318e-01f, 2.13247880e-01f,
  1.93379223e-01f, 6.05816841e-02f, 2.06520796e-01f, 1.33617669e-01f, -2.17037156e-01f, 2.25545932e-02f, 2.13060722e-01f, -2.06741959e-01f, 1.67928934e-01f, 2.89032180e-02f,
  -2.10364833e-01f, 2.33997256e-01f, 4.64206606e-01f, 2.39425331e-01f, 2.31012672e-01f, 1.30786017e-01f, -9.27933380e-02f, 8.43635127e-02f, 1.24995038e-01f, 2.42252350e-01f,
  -2.24750012e-01f, -1.21847279e-02f, -4.03697230e-02f, 5.75000405e-01f, -1.91164255e-01f, 6.24297224e-02f, 9.58853364e-02f, 2.04961494e-01f, -6.72467658e-03f, 4.45436507e-01f,
  3.84427339e-01f, -4.88257371e-02f, 3.64128947e-01f, 3.01923007e-01f, -2.15674862e-02f, -1.88290402e-01f, -1.03906333e-01f, 2.66070008e-01f, 1.49524277e-02f, -3.98365259e-02f,
  1.42994151e-02f, -8.82154778e-02f, -9.38509405e-02f, -1.15955018e-01f, -1.03540160e-01f, -1.50631815e-01f, 1.70142487e-01f, 2.40070585e-04f, 1.66557789e-01f, -1.16706930e-01f,
  -1.55423498e-02f, 3.49289551e-02f, 1.13904849e-01f, 1.43009767e-01f, -1.69973597e-01f, -1.77337497e-01f, 4.15071473e-02f, -1.13704383e-01f, -5.39890490e-02f, -8.11176971e-02f,
  -1.73317030e-01f, 8.12289771e-03f, -9.33357924e-02f, -2.14475729e-02f, 5.86100742e-02f, 8.89630541e-02f, -1.55944899e-01f, 6.95298314e-02f, -1.15595087e-01f, 1.56048194e-01f,
  1.71108991e-02f, -1.50469318e-01f, -1.71257347e-01f, 1.60395443e-01f, 9.59369540e-02f, -1.75563648e-01f, -1.02161311e-01f, -4.99416254e-02f, -1.36108980e-01f, -7.29466826e-02f,
  -6.84910342e-02f, 2.03243382e-02f, 1.66184187e-01f, -1.40036121e-01f, 6.04402162e-02f, -8.74416679e-02f, -9.99206007e-02f, 5.58560081e-02f, -1.00419968e-01f, 3.12399101e-02f,
  -4.36450057e-02f, 1.31349787e-01f, -1.37168810e-01f, -5.91933392e-02f, -9.90488157e-02f, -1.74674883e-01f, -1.03127256e-01f, 9.16285664e-02f, 8.80841017e-02f, -5.97431548e-02f,
  -2.81627122e-02f, 1.76401153e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.24204287e-01f, 3.70961875e-02f, 1.11389048e-01f, 2.92041283e-02f, 2.81577520e-02f, 9.57462117e-02f, -1.03765011e-01f, -1.00647166e-01f, 3.48554909e-01f, 1.76252589e-01f,
  -3.03221326e-02f, 2.05743805e-01f, 4.30295356e-02f, 3.81216444e-02f, 3.49978119e-01f, -4.51444425e-02f, 1.81212410e-01f, -7.03532472e-02f, 6.78240955e-02f, -1.73725262e-01f,
  4.26401198e-02f, 3.42778981e-01f, 2.51145810e-01f, 1.25652671e-01f, -1.73765063e-01f, -7.73440301e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -4.53488469e-01f, -6.02290174e-03f, -2.36612216e-01f, 1.06813326e-01f, 3.25075418e-01f, 1.73808187e-01f, 3.55168641e-01f, -6.90066889e-02f, 1.93770185e-01f, 1.34558920e-02f,
  -2.25375537e-02f, 6.02613509e-01f, 2.23744869e-01f, -5.01238257e-02f, -3.53930831e-01f, -4.39635038e-01f, 1.33990958e-01f, 4.58430946e-01f, -1.90670073e-01f, 2.02304065e-01f,
  3.52052867e-01f, -4.87494349e-01f, -3.05869788e-01f, -6.58727735e-02f, 1.13063149e-01f, 1.14108762e-02f, -1.43239141e-01f, -3.80987853e-01f, -2.35480428e-01f, -1.13108428e-02f,
  8.34432431e-03f, 4.11381535e-02f, 2.02711418e-01f, -4.25856888e-01f, -2.76668698e-01f, 3.56292009e-01f, -4.02000904e-01f, -4.53983545e-02f, 2.23697692e-01f, -1.46562561e-01f,
  -6.14357553e-02f, -1.84920907e-01f, 7.76454628e-01f, 7.28072464e-01f, 2.43199468e-01f, -5.13612509e-01f, -5.11133313e-01f, 1.65495351e-01f, -2.40681961e-01f, 5.53094208e-01f,
  -3.98764729e-01f, -4.41132545e-01f, 4.09154482e-02f, -1.40549839e-01f, -2.48552799e-01f, 3.97818722e-02f, 1.37276530e-01f, -1.12718925e-01f, 1.32126883e-01f, -1.15961418e-01f,
  -6.05191171e-01f, 2.67553508e-01f, -2.44430620e-02f, 1.03031404e-01f, 2.96275944e-01f, 4.18392360e-01f, 7.10905731e-01f, -2.88252711e-01f, 5.95640168e-02f, 9.51702148e-02f,
  -7.64481574e-02f, 5.51093638e-01f, 8.95094350e-02f, -7.51451313e-01f, -6.84103221e-02f, -1.46359667e-01f, -3.10657084e-01f, 2.25101292e-01f, 5.99293530e-01f, -2.01167986e-01f,
  -1.63221046e-01f, 1.61406845e-01f, -2.63518393e-01f, 3.90302777e-01f, 4.12220985e-01f, 1.06683098e-01f, 1.84636354e-01f, 6.39638975e-02f, 1.70862287e-01f, 1.08979978e-01f,
  -1.18682727e-01f, 1.89994156e-01f, 2.04791933e-01f, -6.01814389e-01f, 7.74433613e-02f, 7.92530850e-02f, -6.94140792e-02f, -2.77532488e-01f, 1.62331015e-01f, -1.26973853e-01f,
  -1.13159850e-01f, 3.00726533e-01f, -2.88936365e-02f, -5.72396457e-01f, 7.01835088e-04f, 5.37186086e-01f, -5.13299823e-01f, 1.98467568e-01f, 4.28897977e-01f, 6.04048431e-01f,
  -1.80773780e-01f, -3.01526159e-01f, 2.80357063e-01f, -2.15754479e-01f, -3.48886102e-01f, -1.26462370e-01f, 1.03649221e-01f, 2.76127100e-01f, 4.74966727e-02f, 1.55216962e-01f,
  -4.77638133e-02f, -5.08227060e-03f, 7.48480856e-02f, -5.89188516e-01f, 2.30833843e-01f, -2.25396063e-02f, -1.08680595e-02f, -1.48647532e-01f, -2.40749985e-01f, -4.22962517e-01f,
  3.89920771e-02f, 4.18916672e-01f, 3.06899101e-01f, -1.27594560e-01f, 4.74150687e-01f, 1.08089805e-01f, 1.28088310e-01f, 1.15712835e-02f, -3.08225363e-01f, 2.67858505e-02f,
  -2.63378229e-02f, 3.85365427e-01f, 2.95840085e-01f, -2.32286066e-01f, 3.60279918e-01f, -2.05101416e-01f, -1.30774274e-01f, 1.67679086e-01f, 1.28886908e-01f, 2.37671420e-01f,
  1.59889787e-01f, 3.25683318e-02f, 1.65778697e-01f, 1.61279634e-01f, 1.09156616e-01f, 3.25190574e-01f, 4.91448604e-02f, -3.58141184e-01f, -1.34731323e-01f, 1.83774177e-02f,
  3.00553709e-01f, -1.16850875e-01f, -3.70358199e-01f, 4.09773625e-02f, -5.25960326e-01f, -3.63464206e-01f, -7.48964027e-02f, 9.35812071e-02f, -1.43450588e-01f, -3.03966224e-01f,
  1.97019160e-01f, 1.89999178e-01f, -2.52589166e-01f, 4.43346575e-02f, 2.25096252e-02f, 3.53988469e-01f, -2.63468236e-01f, -2.52006769e-01f, 2.89489795e-02f, 3.91695917e-01f,
  2.03018293e-01f, -3.29858452e-01f, -4.35661562e-02f, 9.35313478e-02f, -7.02525750e-02f, -8.55801478e-02f, 1.66417018e-01f, 4.22281057e-01f, 2.81454444e-01f, 3.75576615e-01f,
  9.66975018e-02f, 9.85330120e-02f, -4.39937979e-01f, -1.97288737e-01f, -2.16978222e-01f, -3.15320045e-01f, 3.31182748e-01f, 4.41062599e-01f, -3.88197452e-01f, 2.79121697e-01f,
  1.33686692e-01f, 8.01748484e-02f, 2.46567652e-02f, -2.96985984e-01f, -1.30374685e-01f, -4.68509406e-01f, 2.89676458e-01f, 3.61972451e-01f, -3.19343597e-01f, -2.27753986e-02f,
  5.69575489e-01f, -4.47537214e-01f, -9.82441843e-01f, 4.05599326e-01f, 8.86707380e-02f, 8.74236226e-02f, 1.05746398e-02f, -2.16175556e-01f, 1.41865879e-01f, 8.03678155e-01f,
  -4.16753650e-01f, 1.59292281e-01f, -1.50078103e-01f, -1.46384880e-01f, -1.82988226e-01f, -5.22353537e-02f, -4.50376898e-01f, -1.63321659e-01f, 3.13702971e-01f, 2.70270824e-01f,
  -5.21217823e-01f, -3.46234262e-01f, 3.21730763e-01f, 5.31509221e-01f, 4.02407467e-01f, -1.69174120e-01f, 1.90041527e-01f, 3.45403612e-01f, -3.34315181e-01f, 3.85993958e-01f,
  -7.25006461e-02f, 9.67814103e-02f, 2.32384160e-01f, -2.11323962e-01f, -4.19127166e-01f, 1.00851931e-01f, 9.51694697e-02f, 4.41768616e-02f, 1.73050780e-02f, 1.09113470e-01f,
  -1.87648088e-02f, -5.61737359e-01f, -1.40593713e-02f, 5.23583353e-01f, -9.67150629e-02f, 4.75884564e-02f, 4.85458881e-01f, 6.73852801e-01f, 4.53938186e-01f, -6.30530044e-02f,
  -1.53450016e-03f, -6.45746291e-01f, -6.43790588e-02f, 3.65318865e-01f, 7.88513385e-03f, -2.27744982e-01f, 1.20689400e-01f, -2.70199597e-01f, -1.76365256e-01f, -6.50768042e-01f,
  -3.16538841e-01f, 7.93016136e-01f, -1.96324944e-01f, 2.21854642e-01f, 4.65300679e-01f, -1.54796213e-01f, -5.62667787e-01f, -1.67267188e-01f, 1.89126462e-01f, 6.61216155e-02f,
  -8.90691653e-02f, 5.51520288e-02f, -3.40486579e-02f, 1.87403094e-02f, 3.49758774e-01f, 6.05789244e-01f, 1.71367779e-01f, 1.62083045e-01f, -4.69592273e-01f, 1.67497655e-03f,
  -1.13094643e-01f, -2.41083294e-01f, 3.49981874e-01f, 1.42317221e-01f, -4.18929368e-01f, 2.35449567e-01f, 2.60622203e-01f, 7.71012157e-02f, 5.03182746e-02f, -5.66683292e-01f,
  -1.06147192e-01f, 2.31786534e-01f, 6.21060669e-01f, 6.26059622e-02f, -2.36982275e-02f, 9.71437618e-02f, 1.57866076e-01f, 2.13596910e-01f, -2.91042980e-02f, 5.16763687e-01f,
  -2.78490424e-01f, -9.04897526e-02f, 1.04569733e-01f, 1.42722219e-01f, 1.00312032e-01f, 2.42824048e-01f, 2.27750629e-01f, -1.67301357e-01f, 1.68932050e-01f, -5.97108416e-02f,
  5.10139585e-01f, 6.75999075e-02f, 1.88393787e-01f, 5.71511984e-01f, -8.79372060e-01f, -4.71561939e-01f, -9.01374407e-03f, -3.19781542e-01f, -7.99537599e-02f, -2.11024821e-01f,
  -5.84993064e-01f, 6.42269850e-01f, -6.89858124e-02f, 1.66805953e-01f, -1.50805354e-01f, -5.09481788e-01f, -4.37918631e-03f, -2.48466074e-01f, -2.26293147e-01f, -9.83196571e-02f,
  6.81178510e-01f, -3.84779513e-01f, 4.05094802e-01f, -1.25192970e-01f, 1.29332200e-01f, -9.95635241e-02f, 4.93867248e-02f, -3.74864310e-01f, 5.92632830e-01f, -5.44196606e-01f,
  1.27276555e-02f, 1.72798131e-02f, 6.20437801e-01f, 2.88761079e-01f, 3.26648146e-01f, -3.16028535e-01f, 3.53229165e-01f, 5.38081706e-01f, 4.87429708e-01f, -4.41939116e-01f,
  -3.45787466e-01f, 8.56251955e-01f, -3.37300777e-01f, -5.37511766e-01f, -1.23994984e-01f, 7.11918175e-02f, 3.01572382e-01f, 1.77899599e-02f, -8.43801070e-04f, -4.55709267e-03f,
  3.23359191e-01f, -1.28542379e-01f, -2.42200673e-01f, 2.65699595e-01f, -1.08509749e-01f, 4.90467586e-02f, -7.60537386e-02f, -4.56036516e-02f, 1.72254816e-01f, 4.23649997e-01f,
  -6.71041980e-02f, 5.64129874e-02f, -1.24976054e-01f, 1.06799617e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.19671056e-01f, 8.21834579e-02f, 1.46332964e-01f, -1.82698995e-01f, -2.59541839e-01f, -2.94828452e-02f, -5.73552400e-02f, -2.26085037e-02f, 3.58768791e-01f, -2.51944512e-01f,
  2.94079512e-01f, 3.03209394e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    