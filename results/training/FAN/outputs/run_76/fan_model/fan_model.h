/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.45171744e-01f, -2.17571184e-01f, -2.50687897e-01f, -2.20858693e-01f, 8.63689035e-02f, 2.25333050e-01f, 2.27170140e-01f, -1.04146995e-01f, -1.39732435e-01f, 1.12966202e-01f,
  1.37024507e-01f, -1.06124155e-01f, 1.99796647e-01f, 2.31379494e-02f, -7.24575892e-02f, 1.60499141e-02f, -7.65838325e-02f, 3.03803496e-02f, -8.20874050e-02f, -9.80872065e-02f,
  -1.31409958e-01f, 3.21186334e-02f, -1.57711700e-01f, 3.20229717e-02f, -4.86804545e-02f, -9.66644287e-02f, 9.47371358e-04f, 1.12624183e-01f, 3.77196446e-02f, 3.26995216e-02f,
  8.02639201e-02f, 1.85308605e-02f, -2.82183103e-02f, -2.78716674e-03f, 1.62580423e-02f, 1.91795379e-02f, -1.10977581e-02f, 6.47793640e-04f, -2.44619213e-02f, 1.20010590e-02f,
  5.22579886e-02f, -4.04893830e-02f, -1.14553701e-03f, 3.44362743e-02f, -7.23068789e-02f, 3.94443981e-02f, -5.45713753e-02f, -6.51477948e-02f, -4.29756083e-02f, -9.39662848e-03f,
  7.34786456e-03f, -2.98784282e-02f, -9.14544985e-02f, -9.65157300e-02f, -4.34676372e-02f, -7.68334419e-02f, 3.11300401e-02f, 5.16010746e-02f, 5.41201681e-02f, -6.78597987e-02f,
  -4.95825475e-03f, -1.02945687e-02f, -1.65457819e-02f, 4.09400351e-02f, -3.01243197e-02f, 4.66435961e-02f, 2.13043950e-02f, -7.00413540e-04f, -7.76004940e-02f, -2.56638378e-02f,
  6.60758317e-02f, -7.03580156e-02f, 9.24099237e-02f, -6.54555634e-02f, -4.71528433e-03f, 8.62819403e-02f, 8.05045385e-03f, 3.26984078e-02f, -7.33726919e-02f, 5.98061876e-03f,
  9.06513408e-02f, 2.03412697e-02f, -5.64162470e-02f, 3.02172191e-02f, 1.02859139e-01f, 9.60202608e-03f, -5.41379340e-02f, -4.14664410e-02f, 8.14111680e-02f, 7.08143935e-02f,
  -4.24923711e-02f, -5.48659824e-02f, 3.34681151e-03f, -3.87645327e-02f, 9.77587625e-02f, 2.61642914e-02f, -6.30059931e-03f, -6.02934882e-02f, -4.63146344e-02f, -3.00925095e-02f,
  -3.11357118e-02f, -1.37009472e-03f, 1.07392510e-02f, -2.67274063e-02f, 5.57543188e-02f, 2.21100263e-02f, 3.84083837e-02f, -6.70392513e-02f, 3.75859626e-02f, -8.29009265e-02f,
  2.39506345e-02f, -1.81725081e-02f, 6.27188850e-03f, 3.75073613e-03f, -1.26490435e-02f, -2.83652060e-02f, 6.35392591e-02f, -3.50130051e-02f, 2.96658296e-02f, 4.53399792e-02f,
  4.24732044e-02f, -9.26241204e-02f, -3.33019346e-01f, -4.50949073e-02f, 1.47454798e-01f, -5.29390015e-02f, -1.66284561e-01f, 2.17223972e-01f, -2.51334757e-01f, -1.12003729e-01f,
  2.53005236e-01f, -1.48856118e-01f, -6.42814673e-03f, 1.42813064e-02f, 2.21306160e-01f, -1.86129227e-01f, 4.21873815e-02f, -4.21607196e-02f, -2.04537466e-01f, 1.09119557e-01f,
  4.01969515e-02f, 2.08014876e-01f, 7.30735809e-02f, 2.10245952e-01f, 6.89220726e-02f, 1.02553919e-01f, 1.60664380e-01f, 1.00540090e-03f, 2.18299359e-01f, 1.96418688e-02f,
  1.17588505e-01f, -1.42064737e-02f, -2.72322502e-02f, -2.48751473e-02f, 1.85931712e-01f, 2.35582087e-02f, 3.77183803e-03f, -9.03446227e-02f, -7.05620870e-02f, -1.53433988e-02f,
  -1.44572988e-01f, -7.86148384e-03f, -7.14568701e-03f, -1.06954366e-01f, -1.32483706e-01f, 4.38232012e-02f, -9.36252773e-02f, 7.44780665e-03f, -5.67397997e-02f, -8.90610293e-02f,
  4.19760235e-02f, -9.55981109e-03f, -4.75556925e-02f, -8.14250857e-02f, 4.66542179e-03f, 3.31214853e-02f, 2.20690854e-02f, 1.03281904e-02f, 2.04444099e-02f, -2.06711516e-02f,
  -2.73585748e-02f, -5.01472838e-02f, -3.34182158e-02f, 5.46178408e-03f, 5.66124804e-02f, -2.35532224e-03f, -6.91022202e-02f, 4.76677269e-02f, -5.29750623e-03f, -1.83770992e-02f,
  1.68337211e-01f, 5.25265597e-02f, 1.42447939e-02f, -7.09652305e-02f, -3.93202938e-02f, 8.75356793e-03f, 6.74211839e-03f, 3.04953288e-02f, 9.11125820e-03f, 1.76811833e-02f,
  -5.66904247e-02f, 1.09772027e-01f, 5.57967238e-02f, 2.46101944e-03f, 3.32751349e-02f, 2.85067186e-02f, -9.14224461e-02f, -6.81727678e-02f, -6.33119047e-02f, -3.67435650e-03f,
  9.28632692e-02f, 2.44460255e-01f, 9.49085355e-02f, 1.07858568e-01f, 1.03484221e-01f, 1.20443881e-01f, -7.50512779e-02f, -3.84652838e-02f, 1.10129593e-02f, 1.86789315e-02f,
  1.72479764e-01f, 1.10253729e-01f, 5.49207367e-02f, 3.34035754e-02f, 2.79683955e-02f, 4.53787446e-02f, -4.67913635e-02f, 1.18586630e-01f, 1.76749185e-01f, 4.39640991e-02f,
  2.05908924e-01f, 1.60060853e-01f, 6.55888990e-02f, 8.29808712e-02f, 2.98231542e-02f, 1.14536295e-02f, 9.25097987e-02f, 4.50007133e-02f, -4.06204304e-03f, 8.38651508e-02f,
  -6.40190303e-01f, 1.85954750e-01f, -2.61943281e-01f, 8.25286750e-03f, 5.20882048e-02f, -1.50582924e-01f, -2.35665575e-01f, 6.46325350e-02f, -3.55971515e-01f, 1.09745309e-01f,
  4.45631631e-02f, -2.40210239e-02f, 2.45447811e-02f, 1.98321760e-01f, -3.94912921e-02f, -8.05449337e-02f, 9.40705985e-02f, -6.46701902e-02f, -1.09750696e-01f, 2.86977738e-01f,
  -9.36809257e-02f, 2.97142953e-01f, 1.08464949e-01f, 1.48367494e-01f, 4.13973592e-02f, -7.64923319e-02f, 1.85964912e-01f, 8.83359741e-03f, 2.74984628e-01f, 1.29407197e-01f,
  2.36218348e-02f, 3.14463787e-02f, -1.23485483e-01f, -1.36183470e-01f, -4.63928394e-02f, 4.68593314e-02f, -5.47800809e-02f, -4.71063852e-02f, -7.61690512e-02f, 3.80958728e-02f,
  -8.20083022e-02f, -1.03142057e-02f, 1.84379355e-03f, 2.44368277e-02f, -3.92089263e-02f, -9.23266709e-02f, 8.91399011e-03f, -7.45784119e-02f, -8.70392323e-02f, 6.23054197e-03f,
  -7.36389607e-02f, 5.61851710e-02f, -6.25888482e-02f, -4.57684174e-02f, -1.42693287e-02f, -6.21373393e-02f, -1.26488982e-02f, -2.74425726e-02f, -1.91084053e-02f, -5.11836894e-02f,
  -1.41726853e-02f, -1.54551053e-02f, -8.17493349e-03f, -3.38848792e-02f, 2.84554642e-02f, 8.87648109e-03f, 6.25107363e-02f, 1.22962967e-01f, -1.11645557e-01f, -7.01690000e-03f,
  3.32987234e-02f, 3.80607769e-02f, -3.38109909e-03f, -2.33759377e-02f, 9.47692469e-02f, 3.90090384e-02f, -6.87140003e-02f, 4.72454764e-02f, -6.05530590e-02f, -1.75570883e-02f,
  6.11052066e-02f, 9.92043391e-02f, -3.22777890e-02f, -6.99827448e-02f, -6.16086461e-03f, 5.07645719e-02f, 2.04012580e-02f, 3.83050442e-02f, 3.83249409e-02f, 2.95915101e-02f,
  9.68575254e-02f, 9.39929932e-02f, 1.73328500e-02f, 3.48421857e-02f, 2.46051643e-02f, 1.89340133e-02f, 3.18628587e-02f, -8.37418251e-03f, -2.57419106e-02f, -3.49654034e-02f,
  -3.14640477e-02f, 5.20901047e-02f, 5.89498468e-02f, 2.96858344e-02f, 3.68266217e-02f, -6.85310885e-02f, 8.57465416e-02f, -8.11266750e-02f, 2.11527962e-02f, -1.13130929e-02f,
  1.11564472e-01f, -2.51772795e-02f, -6.21705912e-02f, -1.33095058e-02f, 4.55385223e-02f, -4.32805642e-02f, 1.59252249e-02f, -1.23185001e-01f, 3.38582434e-02f, 3.95942181e-02f,
  1.93848200e-02f, -6.73313960e-02f, 1.64893880e-01f, -1.62631035e-01f, 4.53949608e-02f, -6.41490296e-02f, -7.53375189e-03f, 8.81170295e-03f, 3.24729569e-02f, -2.18873531e-01f,
  -1.27457172e-01f, 2.18869954e-01f, 7.79134780e-03f, -7.21990615e-02f, 1.34416983e-01f, -2.06916798e-02f, -2.17014745e-01f, -6.87851086e-02f, -2.99915858e-02f, 6.23790883e-02f,
  4.09541130e-02f, -1.89577788e-01f, 1.13707967e-01f, -9.81368572e-02f, 5.34714349e-02f, -2.08178237e-02f, 6.68065175e-02f, 5.75411841e-02f, -9.40718502e-02f, 3.18717211e-02f,
  -5.42052090e-03f, -1.65873960e-01f, 7.26666078e-02f, 1.42144233e-01f, 3.44752148e-02f, 6.30971342e-02f, 1.65148348e-01f, 1.27889708e-01f, 4.07947898e-02f, -6.69396156e-03f,
  6.30595833e-02f, 5.48603162e-02f, 2.09870022e-02f, -6.46426603e-02f, -6.34876639e-02f, -3.33187617e-02f, 6.91654980e-02f, -5.09636179e-02f, 6.37311935e-02f, 1.91858225e-02f,
  -3.97005677e-02f, 6.40376844e-03f, -4.75769490e-03f, -1.17135629e-01f, 7.61141852e-02f, -1.43360272e-01f, -7.47341290e-02f, 1.07916683e-01f, -4.60704416e-02f, -1.49308830e-01f,
  7.48519748e-02f, -3.94073986e-02f, -1.61123816e-02f, -5.09845912e-02f, -1.49271175e-01f, -7.36690760e-02f, 2.60686334e-02f, 2.38174247e-03f, -1.07775748e-01f, -1.28960997e-01f,
  -8.64906013e-02f, 1.67805906e-02f, -5.23396172e-02f, -3.33208442e-02f, -2.65240427e-02f, 1.20169427e-02f, -1.56800449e-02f, -1.71627179e-01f, -2.26512328e-02f, -1.44145219e-02f,
  -3.91315110e-02f, 2.94523872e-03f, -5.32938458e-04f, -1.67547241e-02f, -5.79750678e-03f, 3.49873267e-02f, 1.22358929e-02f, -1.05031185e-01f, 9.68258902e-02f, 3.16181779e-02f,
  -1.94241270e-01f, -2.65166610e-01f, 1.63492691e-02f, -4.08072658e-02f, -7.15197399e-02f, 4.50165384e-03f, -2.04577707e-02f, 2.80411206e-02f, -5.38365431e-02f, 8.22347626e-02f,
  8.83602053e-02f, 2.13585887e-02f, 5.72179854e-02f, -6.15287051e-02f, -3.53006199e-02f, -8.73772353e-02f, 4.71150652e-02f, 1.38385138e-02f, -7.56184384e-02f, 4.62029129e-03f,
  -4.98187356e-02f, 3.07164676e-02f, 1.08732865e-03f, -2.84788981e-02f, 5.68339489e-02f, -2.43113786e-02f, -2.82281195e-03f, -4.73047458e-02f, 5.19894436e-02f, 4.60416414e-02f,
  1.74220324e-01f, 3.58172320e-02f, 6.58148602e-02f, 2.68603235e-01f, -5.21056615e-02f, 2.40029767e-01f, 3.21457654e-01f, 6.22532032e-02f, 2.05131266e-02f, -6.53545484e-02f,
  1.16875634e-01f, -1.13475412e-01f, 7.57202655e-02f, 1.31416783e-01f, 1.26727238e-01f, 3.67449448e-02f, 2.51232415e-01f, 2.39327122e-02f, -8.92062560e-02f, 1.02123797e-01f,
  6.05847090e-02f, 1.43337786e-01f, 1.93705603e-01f, 3.62734944e-02f, 5.41724637e-02f, -1.60430893e-01f, 1.47010293e-02f, 1.13043217e-02f, 1.54701620e-01f, 8.55036080e-03f,
  1.64133944e-02f, -6.85437694e-02f, -5.58940955e-02f, 1.06333932e-02f, 7.73202479e-02f, 8.72329623e-03f, 4.16664071e-02f, -9.47608426e-02f, -6.72952756e-02f, 9.86676589e-02f,
  -6.78485781e-02f, 1.78395945e-03f, 2.95944163e-03f, 5.64491451e-02f, 5.29881306e-02f, -8.83570779e-03f, -7.04471096e-02f, -3.47604826e-02f, -3.55304256e-02f, -2.09091511e-02f,
  7.64635801e-02f, 5.65957502e-02f, 5.43553103e-03f, -1.68190468e-02f, -1.10150117e-03f, -3.46080847e-02f, -2.38923207e-02f, 4.14515566e-03f, -1.89663880e-02f, -2.62029134e-02f,
  -4.80177440e-02f, -4.06526886e-02f, -1.08461753e-02f, -1.63239297e-02f, -3.83772291e-02f, -7.53244385e-03f, 4.66125458e-03f, -7.45259747e-02f, -1.32596627e-01f, -2.03944687e-02f,
  3.61151434e-02f, -4.24166676e-03f, -1.04340157e-02f, 2.30200030e-02f, -8.91965777e-02f, -5.92233241e-02f, 5.37760034e-02f, -8.70481655e-02f, 1.91503037e-02f, -5.97673915e-02f,
  -2.96249893e-02f, 4.48578689e-03f, -7.25430325e-02f, 1.84658263e-02f, 4.19549737e-03f, -5.75946011e-02f, 7.85004199e-02f, -4.91234474e-02f, 9.22766849e-02f, 8.43789279e-02f,
  6.05678186e-02f, 1.78416632e-02f, -7.68843442e-02f, 3.92583403e-04f, -3.67270559e-02f, -6.39642924e-02f, -8.45398346e-04f, -1.24951778e-02f, 7.84332901e-02f, 1.28438458e-01f,
  2.37184390e-02f, -1.46774705e-02f, 5.50735705e-02f, -4.02881913e-02f, 1.38332294e-02f, -1.32198923e-03f, 1.08857647e-01f, -2.63600741e-02f, 1.00125514e-01f, -2.21858714e-02f,
  1.66615844e-02f, -3.35467048e-02f, -6.40502796e-02f, 2.48576440e-02f, -7.01317787e-02f, -3.41195203e-02f, 1.71986315e-02f, 4.30123545e-02f, 4.46242318e-02f, 1.12554180e-02f,
  1.69078931e-01f, -3.59651782e-02f, 6.92620650e-02f, -9.15087685e-02f, 2.63259888e-01f, 2.08638236e-01f, 2.73624379e-02f, 1.03191018e-01f, -9.22840014e-02f, -2.22581312e-01f,
  -2.91470140e-02f, 1.44222006e-01f, 9.65909138e-02f, -1.77035704e-01f, -1.96689144e-01f, -2.61565953e-01f, -8.53239447e-02f, 8.49059373e-02f, 4.69599515e-02f, 7.83116445e-02f,
  -1.69251055e-01f, -2.63403326e-01f, -9.43053365e-02f, 7.91017562e-02f, 9.09279361e-02f, 3.52566913e-02f, -1.23246342e-01f, 7.60293528e-02f, 2.29393728e-02f, 6.08724803e-02f,
  -1.05097024e-02f, -9.04277489e-02f, -1.75708473e-01f, -4.46372703e-02f, -8.32576901e-02f, 3.17382067e-02f, -1.52971298e-01f, 2.27720663e-02f, -4.66068387e-02f, 5.01244031e-02f,
  -5.29630817e-02f, -5.11959754e-02f, -3.27570699e-02f, 2.56037023e-02f, 3.73003189e-03f, -1.38765192e-02f, 1.01566881e-01f, 5.36959991e-02f, 3.57715525e-02f, 9.33125466e-02f,
  8.22166726e-02f, 4.25794013e-02f, 4.79119457e-02f, 5.11875004e-03f, 3.59895714e-02f, -3.18276201e-04f, -8.69634449e-02f, 1.03813738e-01f, 5.23220114e-02f, 3.92859094e-02f,
  2.49722097e-02f, -6.58126175e-03f, 5.90853915e-02f, -1.15800481e-02f, 4.00698893e-02f, 4.03291099e-02f, 2.56252866e-02f, 5.93194552e-02f, -4.41302434e-02f, -5.35380952e-02f,
  -2.51078568e-02f, -2.84202248e-02f, -1.02879209e-02f, -2.34618802e-02f, 1.24341985e-02f, -1.09815076e-01f, 2.17252001e-02f, 1.21399490e-02f, -3.84928025e-02f, -3.07606603e-03f,
  -4.12080288e-02f, 3.55718136e-02f, 3.31729539e-02f, 9.68075469e-02f, 1.11495197e-01f, -3.76373418e-02f, -1.59887653e-02f, 6.33762553e-02f, -2.02094764e-02f, 5.99227324e-02f,
  -1.04173899e-01f, -2.78678745e-01f, -1.06277749e-01f, -2.10756008e-02f, -7.10300952e-02f, -3.77276205e-02f, -5.83218262e-02f, -7.36716539e-02f, -1.39319614e-01f, -4.43505123e-02f,
  -7.82218650e-02f, -6.16172841e-03f, 9.55027342e-02f, 2.46170722e-02f, -7.77358264e-02f, -8.96995738e-02f, -2.54843608e-02f, -1.63357943e-01f, -1.19266205e-01f, -4.41960916e-02f,
  3.28461034e-03f, -1.36332102e-02f, 2.22492521e-03f, -1.20356251e-02f, -9.66574516e-05f, 5.49565516e-02f, 9.51053128e-02f, -3.50931399e-02f, 4.88743559e-02f, 1.04877362e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.11387289e-02f, -2.17574969e-01f, -3.19982708e-01f, -1.94336370e-01f, -2.08172556e-02f, -2.66099602e-01f, -1.52261943e-01f, -1.23667091e-01f, 1.03636228e-01f, 2.48745009e-01f,
  4.62949648e-02f, 7.84965828e-02f, 1.60929158e-01f, -4.54116352e-02f, -2.49927297e-01f, 1.17599487e-01f, -3.30703855e-01f, -1.12190112e-01f, 4.82216515e-02f, -2.53309518e-01f,
  -1.71176434e-01f, -5.73573681e-03f, -1.92755789e-01f, 1.45027295e-01f, -2.67007262e-01f, 6.58775419e-02f, 1.02945857e-01f, 3.69962491e-02f, -1.22666165e-01f, -2.10727733e-02f,
  3.72384526e-02f, 1.53900206e-01f, -3.76639627e-02f, -7.90064596e-03f, -8.05992559e-02f, -2.76998580e-02f, -6.11927398e-02f, -2.41239276e-02f, 5.76837547e-02f, -4.52832039e-03f,
  -9.31870341e-02f, 5.03960736e-02f, 1.86011381e-02f, 2.59787980e-02f, -2.98267361e-02f, -6.26692176e-02f, -4.38521020e-02f, -8.14139470e-02f, 6.32937923e-02f, -4.36954619e-03f,
  -7.11749196e-02f, -1.28066912e-01f, -1.43791378e-01f, -1.43239368e-02f, -4.75502759e-03f, -7.63064027e-02f, -7.40361772e-03f, -2.58287955e-02f, -1.65339634e-02f, 2.72534005e-02f,
  -7.51482770e-02f, -3.34584131e-03f, 5.15164547e-02f, -6.12416677e-02f, 2.56363302e-02f, 4.70650829e-02f, -6.61850572e-02f, 1.28503576e-01f, -4.51763235e-02f, 4.44937386e-02f,
  7.84278512e-02f, -1.01980194e-01f, 1.59356952e-01f, -5.09683602e-02f, -1.44187137e-01f, 3.77491466e-03f, -1.09933866e-02f, -4.03577872e-02f, -8.88138711e-02f, -5.51864840e-02f,
  1.31864220e-01f, -5.17591601e-03f, 3.66646759e-02f, 6.16862029e-02f, -6.87531307e-02f, 1.41405324e-02f, 3.34119871e-02f, 4.02503125e-02f, 1.13489062e-01f, -5.34776300e-02f,
  -1.19379200e-01f, 8.13748837e-02f, 1.38461426e-01f, 2.52145622e-03f, 3.60873267e-02f, -5.98648190e-02f, -4.59020138e-02f, -9.71347764e-02f, -6.04421310e-02f, -3.90536599e-02f,
  -1.33927435e-01f, -4.18027341e-02f, 1.49849546e-03f, 5.00016809e-02f, -1.40497327e-01f, -6.22326322e-02f, 1.20647594e-01f, 3.16343382e-02f, -8.71749595e-02f, 1.73150711e-02f,
  -1.13706002e-02f, 2.66451724e-02f, 1.47996042e-02f, 2.98845973e-02f, -4.60565556e-03f, -8.94121267e-03f, -1.71246920e-02f, 3.54457796e-02f, -4.41908352e-02f, -3.98296155e-02f,
  -2.17510283e-01f, -2.86822528e-01f, -2.94573039e-01f, -2.08985060e-01f, 1.87206730e-01f, 2.98824925e-02f, -3.21625441e-01f, 1.57639701e-02f, -1.36284500e-01f, 5.59271984e-02f,
  -2.00169221e-01f, -5.86431623e-02f, -2.98429817e-01f, -4.07372415e-01f, -9.09804478e-02f, -2.07075655e-01f, -1.05724148e-01f, -1.37617260e-01f, -7.41160735e-02f, -2.14226499e-01f,
  -6.79807141e-02f, -4.11595069e-02f, -2.16747150e-01f, 1.85621440e-01f, -1.29168943e-01f, 1.51624694e-01f, 3.21329594e-01f, 5.49674854e-02f, 6.09231032e-02f, 9.40148160e-02f,
  -5.32345511e-02f, -1.54017776e-01f, -1.67612717e-01f, -1.08447438e-02f, -2.33534519e-02f, 5.26622273e-02f, 1.15401201e-01f, -4.23008054e-02f, 6.66558444e-02f, -9.71447974e-02f,
  2.94581652e-02f, 8.96871164e-02f, -2.66302768e-02f, 1.43826485e-01f, -4.36127260e-02f, 2.03798749e-02f, 4.55031544e-02f, -4.22422402e-02f, -1.00348942e-01f, -6.10373951e-02f,
  -1.88848957e-01f, 4.46414724e-02f, -1.71243735e-02f, 3.98813672e-02f, -4.58261296e-02f, -2.38533150e-02f, 5.89047931e-02f, 5.88912629e-02f, 1.15801014e-01f, -2.44973693e-02f,
  5.25342524e-02f, 7.19816685e-02f, -1.00868575e-01f, 2.17542201e-02f, 2.35333629e-02f, 3.28356773e-02f, -7.92442635e-02f, -8.03492311e-03f, -4.41535935e-02f, -4.44640368e-02f,
  5.73676340e-02f, -7.15860873e-02f, 1.49302352e-02f, -2.63966452e-02f, -3.14155556e-02f, 7.16618672e-02f, 1.50183141e-02f, -2.64340267e-02f, 9.99951661e-02f, -1.00109980e-01f,
  8.17663968e-02f, 6.50113598e-02f, -4.80102859e-02f, 9.66204423e-03f, -4.48891446e-02f, -3.41829024e-02f, 5.76214790e-02f, 7.59936078e-03f, 3.52628045e-02f, -4.59465571e-03f,
  3.64718772e-02f, -1.50783330e-01f, -9.17030945e-02f, 1.18551359e-01f, -5.94958737e-02f, -6.19873106e-02f, -3.68331186e-02f, 6.05678698e-03f, 5.02806343e-03f, -9.47557855e-03f,
  6.13492690e-02f, 5.08937314e-02f, 1.62608579e-01f, 6.71451315e-02f, -4.49510738e-02f, 2.69223843e-02f, 4.34783027e-02f, 9.93926376e-02f, 6.85528740e-02f, 7.17323199e-02f,
  7.51231387e-02f, -6.42179474e-02f, -7.81361312e-02f, -2.98629235e-02f, 6.03350513e-02f, 2.04158686e-02f, 1.09489977e-01f, 1.46115394e-02f, -7.95114711e-02f, 5.64938188e-02f,
  3.68175447e-01f, -2.06092268e-01f, 3.58571053e-01f, 2.56388903e-01f, 2.77299136e-01f, 2.45106027e-01f, 3.04372907e-01f, 7.97693897e-03f, 3.89624476e-01f, -2.54560620e-01f,
  -1.58449739e-01f, -8.51867069e-03f, 7.83136263e-02f, -2.31040403e-01f, 1.76282078e-01f, 5.05420342e-02f, -1.13002853e-02f, 4.32716906e-02f, 6.75094351e-02f, -1.30933926e-01f,
  1.33994818e-02f, -2.15820789e-01f, -1.42105564e-01f, -3.56565803e-01f, -9.48795080e-02f, -1.09556995e-01f, -1.43395171e-01f, 2.08725169e-01f, -3.34994763e-01f, 4.44224365e-02f,
  4.67733406e-02f, 5.22262082e-02f, -6.79347441e-02f, -1.52464420e-01f, -9.03573334e-02f, -1.01594515e-02f, -4.46033590e-02f, 1.14540353e-01f, 1.33777574e-01f, 2.89528370e-02f,
  3.38130333e-02f, -4.22107205e-02f, 8.79933778e-03f, 9.98741481e-03f, 5.00777364e-02f, 1.52776381e-02f, 1.02304248e-02f, -5.06571904e-02f, 6.95833266e-02f, 8.06775764e-02f,
  -2.84309760e-02f, 6.75490424e-02f, 1.00957945e-01f, -2.96974983e-02f, 1.82924308e-02f, 8.26763064e-02f, 2.77560055e-02f, 7.16186017e-02f, -4.14984077e-02f, 1.95602663e-02f,
  -1.15637988e-01f, -1.80936530e-02f, 3.36579420e-02f, -9.34332162e-02f, -3.18076974e-03f, 4.63319495e-02f, -2.20630839e-02f, -5.39586414e-03f, 9.82962921e-02f, 1.00871913e-01f,
  -4.28479537e-02f, -3.23655047e-02f, 9.27783735e-03f, 1.09618559e-01f, -4.49004397e-02f, -1.10467881e-01f, 3.27512622e-02f, 4.85302089e-03f, -3.41813117e-02f, 2.89054331e-03f,
  -2.98271943e-02f, -6.57649264e-02f, 4.19085473e-02f, 5.22517152e-02f, -2.71739904e-02f, -3.90209220e-02f, -1.53284386e-01f, 5.46706468e-02f, 2.44579967e-02f, 4.02814746e-02f,
  -1.06873795e-01f, -8.42950195e-02f, -1.67523772e-02f, -1.11618854e-01f, -9.13800076e-02f, -1.56278878e-01f, 5.52680828e-02f, -5.96764833e-02f, 7.98735544e-02f, -1.21709391e-01f,
  -4.77465764e-02f, -8.89702663e-02f, 5.47592379e-02f, -5.94509654e-02f, -1.80413112e-01f, -3.47421169e-02f, 6.74482435e-02f, -3.92923504e-03f, -2.39838436e-02f, 2.82599870e-03f,
  5.22091165e-02f, -4.28506136e-02f, -2.10464112e-02f, -8.93503800e-03f, -3.98814641e-02f, 2.79197246e-02f, 1.91548727e-02f, 4.82652299e-02f, 6.35208189e-03f, -1.28009869e-02f,
  3.03190015e-03f, 3.25063378e-01f, -1.78983063e-02f, -5.62514886e-02f, -1.11106999e-01f, -3.62227589e-01f, -3.32406729e-01f, -4.92000207e-02f, 1.64523438e-01f, 3.79246939e-03f,
  -1.80521846e-01f, 3.11258018e-01f, -1.24580219e-01f, -3.10780220e-02f, -3.22628230e-01f, -8.31263736e-02f, -3.25534999e-01f, -2.41998583e-01f, 1.03770584e-01f, -1.11921020e-01f,
  -7.84761086e-02f, -2.83078253e-01f, -2.19189867e-01f, -1.06778562e-01f, -1.78076908e-01f, -8.59934371e-05f, -2.08488509e-01f, -1.45555109e-01f, -1.46861956e-01f, -4.15564030e-02f,
  5.67752831e-02f, 7.61727467e-02f, 9.31585431e-02f, 4.05473933e-02f, -9.50213224e-02f, -9.99475941e-02f, -5.09106815e-02f, -1.92143973e-02f, -4.62770611e-02f, -7.32532665e-02f,
  2.39716582e-02f, -2.96264552e-02f, 5.67911938e-02f, 1.65771134e-02f, 9.69118904e-03f, 5.83771206e-02f, 1.08591625e-02f, 2.46189628e-02f, 4.22130786e-02f, -2.29805149e-02f,
  4.69417963e-03f, 1.76229421e-03f, -6.82952348e-03f, -3.71903833e-03f, 3.75919379e-02f, -7.56963418e-05f, 2.90990546e-02f, 1.70647055e-02f, -3.43417600e-02f, -1.61062982e-02f,
  -9.58536565e-02f, -1.26314774e-01f, 5.12124859e-02f, 5.96483685e-02f, -4.01581675e-02f, 8.25461373e-02f, 2.69698706e-02f, 5.58114611e-02f, -5.11788800e-02f, -1.15829162e-01f,
  -1.44029967e-02f, 8.29816386e-02f, 5.36180995e-02f, -3.18761319e-02f, 6.74928650e-02f, 1.10891595e-01f, -7.39990827e-03f, -1.83270127e-02f, -1.00852937e-01f, 4.17611040e-02f,
  1.09782461e-02f, -6.70329016e-03f, 1.04204521e-01f, -3.04785483e-02f, -3.26984823e-02f, -1.58182327e-02f, -1.00468949e-03f, 6.40618652e-02f, -8.65453705e-02f, -8.43429789e-02f,
  -1.81466967e-01f, -1.95984572e-01f, -3.54432911e-02f, 7.13074803e-02f, -2.76043694e-02f, -8.78626555e-02f, -6.91446587e-02f, 7.02062994e-02f, -2.01011747e-01f, -7.40355775e-02f,
  -9.58530158e-02f, -2.05925163e-02f, -1.66924465e-02f, -3.90255861e-02f, 6.59893006e-02f, -3.20172757e-02f, -2.18808302e-03f, 1.21123958e-02f, -1.25942886e-01f, -4.80784616e-03f,
  -5.27165048e-02f, 5.46978861e-02f, 8.01446959e-02f, -5.60247488e-02f, -2.95888260e-02f, -5.22850268e-02f, 1.99587084e-02f, -5.22036850e-03f, -8.06185976e-02f, -4.76056561e-02f,
  -4.05451119e-01f, 2.60078341e-01f, 2.47514211e-02f, -3.04581165e-01f, 1.41695172e-01f, 2.86304718e-03f, -1.67108297e-01f, 1.54416651e-01f, -4.15547751e-02f, 1.79391250e-01f,
  -6.33550957e-02f, -7.71081746e-02f, 3.30983251e-02f, -2.26466849e-01f, -5.76804399e-01f, -2.59529978e-01f, -3.81309628e-01f, -1.33096129e-01f, -6.85929060e-02f, 2.57064030e-02f,
  -1.45730525e-01f, -1.89381391e-01f, -3.29088598e-01f, 1.02413230e-01f, 8.89141262e-02f, 1.22444011e-01f, -1.24814384e-01f, 2.48971656e-01f, 1.09745495e-01f, -7.45856091e-02f,
  -5.04208058e-02f, 1.03056312e-01f, 1.26109734e-01f, 4.06069793e-02f, -4.19017524e-02f, 5.34534007e-02f, -2.38101482e-02f, -6.54108450e-02f, 1.12031467e-01f, 2.80447174e-02f,
  3.30066495e-02f, 3.80634359e-04f, 2.59907059e-02f, -1.15439892e-02f, 1.39209062e-01f, 4.95152436e-02f, 1.12806372e-02f, 3.61430347e-02f, 6.14243113e-02f, 3.35946982e-03f,
  8.22332315e-03f, 1.11519605e-01f, 5.25307804e-02f, -1.43985637e-02f, -4.39163186e-02f, 4.33204696e-02f, -9.80683416e-02f, -3.16038541e-02f, 3.93082388e-04f, 7.67913833e-03f,
  -2.14277534e-03f, 3.41725573e-02f, -6.63027242e-02f, -3.46493050e-02f, -2.08155848e-02f, 2.25303546e-02f, -5.59353866e-02f, -2.71360725e-02f, 4.84923124e-02f, 2.89387107e-02f,
  2.92120990e-03f, 1.13610178e-02f, 8.79534893e-03f, 7.72604020e-03f, -1.39505779e-02f, -5.86751252e-02f, 5.26541099e-02f, 4.79645394e-02f, -3.24820727e-02f, -3.16962749e-02f,
  7.68290716e-04f, 1.56368874e-02f, -1.13789756e-02f, -3.70042585e-02f, -3.81927676e-02f, 9.73651111e-02f, 5.92471473e-03f, -6.63587358e-04f, 5.61075620e-02f, -7.54789039e-02f,
  4.35974635e-03f, 3.73824649e-02f, 2.53418125e-02f, 2.74731386e-02f, 4.41061035e-02f, 3.56312878e-02f, -5.46805933e-03f, 9.09521244e-03f, 1.14707248e-02f, -4.97341082e-02f,
  1.51355371e-01f, 3.50609086e-02f, 5.94985187e-02f, -1.45702511e-02f, -4.47252467e-02f, 5.69543019e-02f, -1.16577605e-02f, 3.59847061e-02f, 3.63878459e-02f, -5.50278127e-02f,
  4.33906913e-03f, 7.26420954e-02f, -5.96128125e-03f, 5.15734665e-02f, -3.21008917e-03f, 2.42438279e-02f, 3.01917009e-02f, -1.93577744e-02f, 5.70293441e-02f, -4.48485389e-02f,
  1.19966343e-01f, -2.16204360e-01f, -3.46710652e-01f, -2.37438992e-01f, -4.02029634e-01f, -1.58315465e-01f, -1.13534741e-01f, -3.24061692e-01f, -3.57448049e-02f, 1.82612583e-01f,
  4.20180708e-03f, 1.15964979e-01f, 3.59540761e-01f, -8.07719827e-02f, 2.78520048e-01f, 4.25550848e-01f, 6.91737654e-03f, 6.94192275e-02f, 4.92836945e-02f, -1.13969259e-01f,
  -1.30995184e-01f, -1.29964277e-01f, 1.24524713e-01f, -2.10613593e-01f, -2.32666209e-01f, -2.56257832e-01f, -6.17819764e-02f, -1.36870295e-01f, -2.39803344e-01f, -8.51801485e-02f,
  -5.47549911e-02f, 1.86248831e-02f, -1.17267519e-01f, 4.51292768e-02f, -6.91375136e-02f, -4.12682332e-02f, -3.22489962e-02f, 6.69413581e-02f, 6.91071972e-02f, -8.32873490e-03f,
  1.76251441e-01f, 6.42913431e-02f, -1.06504850e-01f, -2.68168505e-02f, -2.47033476e-03f, -1.78002656e-01f, -2.56477632e-02f, 7.55691081e-02f, -3.71426754e-02f, -2.47296896e-02f,
  1.13118649e-01f, -4.62811030e-02f, -4.48328480e-02f, 5.19595034e-02f, 4.76254597e-02f, 3.97002697e-02f, 9.96097699e-02f, 2.96144541e-02f, -2.93516158e-03f, -5.57101108e-02f,
  -4.26568985e-02f, 2.17072573e-02f, 2.12927777e-02f, 4.87595377e-03f, -7.37959146e-02f, -6.17302880e-02f, 2.28327122e-02f, -2.70495713e-02f, 1.24768548e-01f, -9.33412388e-02f,
  -6.72211405e-03f, 9.25731566e-03f, -2.15484272e-03f, 2.65030796e-03f, 5.43742888e-02f, 3.20943445e-02f, -6.96211727e-03f, 1.36618484e-02f, -3.53483064e-03f, -4.31646733e-03f,
  2.93465424e-03f, 1.95105169e-02f, 3.06455307e-02f, -6.90458566e-02f, -5.14365099e-02f, 7.40627423e-02f, 3.67957912e-02f, -6.99678883e-02f, -8.72377455e-02f, 9.66805518e-02f,
  -1.07364826e-01f, -2.02560380e-01f, 2.70305388e-02f, 2.33149491e-02f, -1.26149971e-02f, 1.71305090e-02f, 1.19001726e-02f, -1.51197584e-02f, 2.52076853e-02f, 6.73018470e-02f,
  -1.58494953e-02f, 3.44632305e-02f, -7.93231279e-02f, 9.74512938e-03f, 3.96841243e-02f, -1.62094280e-01f, 1.38413236e-01f, 6.56545833e-02f, -7.35956198e-03f, -9.20595154e-02f,
  4.87671047e-02f, 8.98319930e-02f, 8.12555328e-02f, 1.51069798e-02f, -6.08672164e-02f, 7.60039836e-02f, -2.49482524e-02f, -9.62362811e-03f, 2.54893377e-02f, -6.72044083e-02f,
  2.03880981e-01f, -3.66224766e-01f, -3.65536183e-01f, 1.57057330e-01f, 3.30717146e-01f, 2.04541668e-01f, 5.88156432e-02f, 2.34859303e-01f, 1.01928316e-01f, -1.18944645e-01f,
  6.02966063e-02f, -1.61059976e-01f, -2.58408219e-01f, 1.75314844e-01f, 2.77811378e-01f, -2.61309713e-01f, 1.71405241e-01f, -2.13869866e-02f, -6.15991540e-02f, -4.14912915e-03f,
  8.74565691e-02f, 2.99403042e-01f, -1.22473367e-01f, 1.04790069e-01f, 8.54975954e-02f, 2.60981936e-02f, -2.66723707e-02f, -1.66642874e-01f, 1.14456289e-01f, 1.15229331e-01f,
  3.57260518e-02f, -1.32186292e-02f, -2.06653029e-02f, 4.43635844e-02f, -1.96996499e-02f, 2.19169203e-02f, -3.19211446e-02f, 2.18745926e-03f, 2.14305781e-02f, 4.34761122e-03f,
  -4.04538624e-02f, 1.11626973e-02f, -9.66491699e-02f, 1.93227250e-02f, 1.66828945e-01f, 7.09557384e-02f, 1.51852900e-02f, -2.83041000e-02f, 2.22585816e-02f, -5.25386557e-02f,
  -9.77744684e-02f, -8.97180475e-03f, -6.95405528e-02f, -3.34925801e-02f, -7.31084198e-02f, -5.52036725e-02f, -5.96495494e-02f, -1.02703609e-01f, -1.16264485e-01f, 9.13429186e-02f,
  -3.93647552e-02f, 5.06218895e-03f, -5.37651703e-02f, -3.01361717e-02f, 6.60236925e-02f, 4.07340303e-02f, 4.63531651e-02f, -4.16995585e-02f, -1.18019894e-01f, -1.50294174e-02f,
  7.43021592e-02f, 7.71965533e-02f, 3.52750458e-02f, 4.64268066e-02f, 9.20721292e-02f, 4.90501709e-02f, 1.86897684e-02f, 4.79311906e-02f, 3.88133116e-02f, 4.07177918e-02f,
  -1.07829319e-02f, 1.05025195e-01f, 1.02714589e-02f, -1.54909743e-02f, 8.55698213e-02f, 2.13533565e-01f, 2.37301514e-02f, -1.68096367e-02f, -9.02546942e-02f, -1.81342900e-01f,
  -1.28459348e-03f, -2.37548977e-01f, -5.81061393e-02f, 3.19191627e-02f, -5.64549863e-02f, 5.11155650e-02f, -3.66005339e-02f, 1.11797489e-01f, 2.23826300e-02f, 1.07111791e-02f,
  -2.21285261e-02f, 1.92713756e-02f, -5.41614555e-03f, -9.05523542e-03f, 1.02146417e-01f, -6.06537685e-02f, -1.80282965e-01f, -5.47399111e-02f, 7.19511062e-02f, -5.97841591e-02f,
  3.59630361e-02f, -1.39120951e-01f, -4.00326215e-02f, 6.67843148e-02f, -2.73742992e-02f, 1.27906520e-02f, -3.20328102e-02f, -6.47802353e-02f, -1.59726948e-01f, 7.04393312e-02f,
  -3.91655296e-01f, -7.49302730e-02f, -5.58047779e-02f, -2.58039504e-01f, -1.51733369e-01f, -3.12165469e-02f, -5.45387901e-02f, -2.54936606e-01f, -1.82300091e-01f, -9.47812870e-02f,
  -1.45126060e-01f, -3.06809600e-02f, 2.16342971e-01f, -4.93944399e-02f, 3.03391278e-01f, 3.18319499e-01f, -1.98173732e-01f, -7.19778016e-02f, -2.72506010e-02f, -2.07914725e-01f,
  -3.89829054e-02f, -1.23838998e-01f, 1.26235932e-01f, -2.49995887e-01f, -2.09756106e-01f, -2.47862130e-01f, 1.49219707e-02f, -4.43068184e-02f, -1.29360557e-01f, -2.15435140e-02f,
  -2.26272479e-01f, -3.31241041e-01f, -1.55253828e-01f, -1.12308830e-01f, -1.24167092e-01f, -5.40744402e-02f, 1.23534541e-04f, 8.66938159e-02f, -1.95597112e-02f, -5.24082407e-02f,
  -4.76980731e-02f, 1.09660840e-02f, -1.43142223e-01f, 4.97417375e-02f, -1.03824876e-01f, -6.28991798e-02f, 9.51177813e-03f, -5.74165247e-02f, 1.40283247e-02f, 2.66201328e-02f,
  -1.59813240e-02f, -6.69065565e-02f, -5.51759005e-02f, 4.30950820e-02f, 7.04272538e-02f, -1.04362294e-01f, 5.25368117e-02f, 6.39753714e-02f, -5.40092774e-02f, -4.68943566e-02f,
  3.05361990e-02f, 1.76123068e-01f, 2.60457546e-02f, -3.05988640e-02f, 1.19432360e-01f, -3.36600281e-02f, -3.59189473e-02f, 1.23684630e-01f, 8.23634341e-02f, 2.37794314e-02f,
  -1.81511194e-02f, -2.41957605e-02f, -7.19212666e-02f, 3.31367925e-02f, -2.28402615e-02f, 1.43140387e-02f, -1.00281192e-02f, -8.06246772e-02f, 7.90710598e-02f, -9.76145938e-02f,
  4.11547646e-02f, 1.88349634e-02f, 4.44368087e-02f, 3.19707654e-02f, 1.76905058e-02f, 6.08382672e-02f, 2.85306778e-02f, -2.16440279e-02f, 3.03172935e-02f, 4.68107080e-03f,
  -2.61165738e-01f, -3.24079782e-01f, -2.66070161e-02f, -1.86889797e-01f, 2.03810576e-02f, -2.95572300e-02f, 6.58140853e-02f, -2.29932857e-03f, -5.91376983e-02f, -1.07907109e-01f,
  -1.38340443e-01f, 8.21485445e-02f, -4.77285637e-03f, -5.15717342e-02f, 4.60218750e-02f, -5.98981120e-02f, -1.13892734e-01f, -1.07725248e-01f, 3.59290689e-02f, 2.60877423e-03f,
  -3.12253404e-02f, -1.39696943e-02f, 1.34261951e-01f, 1.71197543e-03f, 9.42242984e-03f, -6.26704246e-02f, -2.43400782e-02f, -3.27385962e-02f, -1.42762689e-02f, 4.91071083e-02f,
  2.89390653e-01f, -8.31583664e-02f, -9.52115357e-02f, 1.17951833e-01f, 1.29709959e-01f, 2.60776877e-01f, 1.83676228e-01f, 1.48532271e-01f, 3.13092083e-01f, 1.55531466e-01f,
  9.43056643e-02f, -1.39811680e-01f, 7.00747445e-02f, 2.83160418e-01f, 1.33483201e-01f, 6.69767782e-02f, 3.07790905e-01f, 8.84017646e-02f, 7.28012845e-02f, 1.92635193e-01f,
  3.09854429e-02f, 1.02757081e-01f, -1.60931125e-01f, -1.94054857e-01f, -5.63072972e-02f, -1.41577795e-01f, -1.31147608e-01f, -2.28846490e-01f, -2.42454819e-02f, -5.49063347e-02f,
  4.69375513e-02f, -2.08726823e-02f, -7.39634484e-02f, -3.60112861e-02f, -1.44008577e-01f, -7.81349912e-02f, -1.02092564e-01f, -1.41439319e-01f, -1.25829861e-01f, -4.81925681e-02f,
  -7.41598904e-02f, 8.31406340e-02f, 8.64318479e-03f, 7.44489655e-02f, 3.24503938e-03f, 2.11913101e-02f, -5.03742043e-03f, 6.18390590e-02f, 2.40531797e-03f, -9.32848379e-02f,
  -6.12396672e-02f, 4.11424823e-02f, 1.00674987e-01f, -1.68909848e-01f, -3.91330384e-03f, 5.00273257e-02f, 1.19941551e-02f, -1.16259903e-01f, 1.90474112e-02f, 2.05873773e-02f,
  -4.24452908e-02f, 2.71669612e-03f, -8.38845447e-02f, 1.26209602e-01f, 9.42801218e-03f, -7.63164088e-02f, 1.04552746e-01f, 7.83362016e-02f, 3.35644893e-02f, 1.21340185e-01f,
  -1.58302821e-02f, -2.42639538e-02f, 7.33131394e-02f, 1.46346297e-02f, 4.89151366e-02f, -1.77141633e-02f, -6.29301295e-02f, 4.86559048e-02f, -4.24957648e-02f, -3.15069631e-02f,
  2.76012626e-02f, 6.15504570e-02f, -9.96905640e-02f, 2.04809848e-02f, -1.58240832e-02f, -7.17174336e-02f, -5.19016013e-03f, 7.94343874e-02f, 1.25271127e-01f, -2.95373071e-02f,
  1.63598076e-01f, -1.12014070e-01f, -1.70322414e-02f, 7.81960040e-02f, -4.72406521e-02f, -5.54084815e-02f, -2.84582376e-03f, -9.61698294e-02f, -1.54523268e-01f, -6.04114048e-02f,
  6.00096397e-02f, 1.24723308e-01f, -2.63512488e-02f, 2.63567455e-02f, 1.42518682e-02f, -4.12450545e-03f, -9.91285220e-03f, -5.85789047e-02f, 9.35267434e-02f, -3.00496817e-02f,
  6.61167921e-03f, -1.44809252e-02f, 4.64936458e-02f, -6.48146719e-02f, 1.23587042e-01f, -9.35846716e-02f, -4.87123393e-02f, -4.86009121e-02f, -3.69476341e-02f, 6.93528578e-02f,
  -3.80679309e-01f, 1.56841889e-01f, -1.50354505e-01f, -8.63216147e-02f, 1.67266524e-03f, -2.34729216e-01f, -1.38747841e-01f, -1.48311341e-02f, 9.24155563e-02f, 9.95441601e-02f,
  1.13383807e-01f, -2.05518454e-02f, 1.59552783e-01f, 1.36426864e-02f, -1.61898986e-01f, 1.96513414e-01f, -1.03352904e-01f, -9.03641284e-02f, -4.33732830e-02f, -1.00895599e-01f,
  -5.07015139e-02f, 5.51694632e-03f, -1.05983064e-01f, 7.49719068e-02f, -1.37900636e-01f, -5.79982884e-02f, 3.38076875e-02f, -3.25272456e-02f, -2.10906044e-01f, -1.06524937e-01f,
  -1.57538354e-01f, -1.56524733e-01f, -1.01588927e-01f, -5.47563508e-02f, -6.82209358e-02f, -4.29956689e-02f, -4.95488793e-02f, -4.30066362e-02f, -1.29449844e-01f, -5.38568534e-02f,
  -4.82220389e-02f, 4.21494246e-02f, 1.74857117e-02f, -4.18321155e-02f, -3.05489055e-03f, -8.04105997e-02f, -2.49156747e-02f, -9.02309418e-02f, -9.22895689e-03f, -4.22887243e-02f,
  -5.20792678e-02f, -6.85665756e-03f, 1.57542843e-02f, -1.32901706e-02f, -1.63181759e-02f, 1.79944262e-02f, 4.51091770e-03f, 6.28871173e-02f, -1.48957774e-01f, -4.37668562e-02f,
  2.49990318e-02f, 5.20170387e-03f, -1.63896326e-02f, 3.46531570e-02f, -7.35921264e-02f, 5.33497222e-02f, -2.90216282e-02f, -1.09422840e-02f, 4.10571955e-02f, 2.21875552e-02f,
  2.46985117e-03f, -4.72815707e-02f, 9.31740776e-02f, -8.51336052e-04f, -5.65506285e-03f, 1.64145213e-02f, 4.54778830e-03f, 5.01770638e-02f, 3.47568579e-02f, 2.47203261e-02f,
  -5.86794168e-02f, 5.01914658e-02f, 7.34768659e-02f, -2.48113703e-02f, -2.56060474e-02f, -3.73886153e-02f, -1.21351499e-02f, -5.37675768e-02f, -3.60754170e-02f, -3.34772542e-02f,
  -3.14571887e-01f, -2.53955960e-01f, -1.28343597e-01f, -2.43943091e-02f, 8.53351224e-03f, -1.38781324e-01f, 1.10946107e-03f, -9.76379663e-02f, -9.52265784e-02f, 1.31626902e-02f,
  2.69391257e-02f, -8.67206417e-03f, -1.31195423e-03f, -4.01854850e-02f, 2.13363543e-02f, -1.19713964e-02f, -6.80651665e-02f, 1.70188677e-02f, -9.26083624e-02f, -3.35152820e-02f,
  1.30244605e-02f, -1.03368629e-02f, 3.70053165e-02f, -5.65757155e-02f, 8.63102973e-02f, -1.38866259e-02f, -6.27810359e-02f, 1.30482763e-03f, -9.11348034e-03f, 3.02317534e-02f,
  -6.93597436e-01f, 4.15441066e-01f, -1.57830134e-01f, -1.09004088e-01f, -7.67766833e-02f, 1.10281736e-01f, 1.09012797e-01f, 1.72762617e-01f, -7.41266757e-02f, 1.42626375e-01f,
  2.77958810e-02f, -2.47118026e-01f, 1.54724568e-01f, 1.01567164e-01f, -1.43489316e-01f, 2.15326890e-01f, 1.00241825e-01f, 4.13095169e-02f, -3.48128844e-03f, 1.46153957e-01f,
  1.12585008e-01f, 1.75748274e-01f, 1.92995980e-01f, 2.45171934e-01f, 2.65091266e-02f, -1.50619522e-01f, -7.53269270e-02f, -6.01744689e-02f, -8.92127529e-02f, -8.62695277e-02f,
  -2.05716684e-01f, -3.88906866e-01f, -2.29371354e-01f, -7.38454014e-02f, -1.74205661e-01f, -2.50187665e-02f, -5.21001965e-02f, -1.10057211e-02f, -9.01212245e-02f, -5.72605059e-03f,
  -8.01133513e-02f, 9.07816645e-03f, -8.29877555e-02f, 1.24194100e-02f, -6.01987317e-02f, 6.61424082e-03f, 1.27170920e-01f, 7.51067325e-03f, 2.17833444e-02f, 3.98011841e-02f,
  7.14513734e-02f, -5.15510440e-02f, 1.19397961e-01f, 1.45131359e-02f, 8.54313001e-02f, 6.01899736e-02f, -3.37089272e-03f, -1.37476651e-02f, -5.23353331e-02f, -5.73852435e-02f,
  -6.27753288e-02f, -1.66662745e-02f, -1.41087295e-02f, 3.97008061e-02f, 9.56728309e-03f, 6.84119295e-04f, 2.28089560e-02f, -4.80416454e-02f, -1.15229539e-03f, 7.42477998e-02f,
  1.05920536e-02f, -1.78000499e-02f, -8.11350122e-02f, -2.78446227e-02f, 2.82182656e-02f, -6.09842725e-02f, -4.60605584e-02f, 5.34152463e-02f, -3.12777655e-03f, -2.75330450e-02f,
  1.11638354e-02f, 3.08713038e-02f, -4.67827916e-02f, 8.10293667e-03f, 3.30447555e-02f, 7.62355924e-02f, 2.15959344e-02f, -1.09798443e-02f, 7.11124614e-02f, -1.06140196e-01f,
  -9.32198241e-02f, -3.41871291e-01f, -7.15742484e-02f, -6.44843653e-02f, -1.27298534e-01f, 2.63763182e-02f, 3.85051686e-03f, 1.33562863e-01f, -4.18450423e-02f, -2.55969465e-02f,
  -3.45616676e-02f, 2.83100363e-02f, -8.33932683e-02f, -1.09959757e-02f, -6.72684908e-02f, -6.57711625e-02f, 3.02976537e-02f, -1.75920606e-01f, -3.01604681e-02f, -3.73032168e-02f,
  1.58640556e-02f, -9.44361687e-02f, 2.19990849e-04f, -7.08459993e-04f, -4.63140309e-02f, -5.30581996e-02f, -3.39234211e-02f, -3.29013318e-02f, 1.22413517e-03f, 1.11030743e-01f,
  2.69206494e-01f, -1.31135985e-01f, -3.87495995e-01f, 6.62053749e-03f, 1.08224768e-02f, 2.40229785e-01f, 1.46863293e-02f, -5.38169332e-02f, -1.70835182e-01f, 1.62229776e-01f,
  9.59336758e-02f, -2.43788794e-01f, -1.08573958e-01f, 4.18592155e-01f, 2.05696031e-01f, -3.67636085e-02f, 2.49044269e-01f, 2.68349409e-01f, -1.06273539e-01f, 1.66997284e-01f,
  -1.01078495e-01f, 4.57303017e-01f, -1.82236448e-01f, 1.64821833e-01f, 2.66682565e-01f, -1.93194076e-01f, 4.06069905e-02f, -2.77243555e-01f, 1.86800271e-01f, 1.43373981e-01f,
  1.34196922e-01f, 2.83372942e-02f, -5.74537106e-02f, -8.63997638e-02f, 3.41336504e-02f, 1.68012083e-01f, -6.61440939e-03f, -4.95556509e-03f, -1.47056356e-01f, -1.35586951e-02f,
  -7.42344325e-03f, 8.30828920e-02f, 3.90835851e-02f, -1.52592966e-02f, 5.19319670e-03f, -1.32009247e-03f, -5.58893234e-02f, -6.99491724e-02f, -3.39712389e-02f, -1.72666349e-02f,
  -1.26909599e-01f, -3.72698642e-02f, -5.42718954e-02f, -6.85427785e-02f, -1.53360069e-01f, -6.29113838e-02f, -1.01799704e-01f, -1.75561905e-02f, 7.16262609e-02f, 3.11450642e-02f,
  1.68114960e-01f, 6.93578944e-02f, 5.37538901e-02f, 7.64891654e-02f, -6.00999175e-03f, -7.30032399e-02f, 8.83696042e-03f, -5.49692512e-02f, -1.15669727e-01f, 2.38599684e-02f,
  5.85688241e-02f, -6.73459470e-02f, 6.26426116e-02f, 1.78610981e-02f, 1.21680014e-01f, 9.84191597e-02f, 6.62760867e-05f, 7.74362907e-02f, -1.45344108e-01f, -4.14803326e-02f,
  -3.64258550e-02f, 1.14484228e-01f, -5.47299311e-02f, 1.72741581e-02f, 1.43118113e-01f, 1.11784795e-02f, 1.32733032e-01f, -1.49502407e-03f, -8.95846859e-02f, 4.09350283e-02f,
  1.04822563e-02f, -1.71603650e-01f, -8.87779966e-02f, -6.60300180e-02f, -1.45793278e-02f, 1.96361080e-01f, 5.08836433e-02f, -3.08508370e-02f, -5.88666610e-02f, 5.97589202e-02f,
  2.90566776e-02f, -5.29438294e-02f, 6.89702109e-02f, -8.94620046e-02f, 1.34710344e-02f, 4.84300628e-02f, 5.69392228e-04f, -8.22493732e-02f, -5.31251095e-02f, -5.35529712e-03f,
  -6.39327094e-02f, 1.17375098e-01f, -1.70990229e-02f, -7.69482329e-02f, -2.93253511e-02f, -5.46940081e-02f, -2.93302555e-02f, -4.04344425e-02f, 4.21802402e-02f, -1.35448262e-01f,
  -6.15045786e-01f, 3.14606279e-01f, -1.05460688e-01f, 3.17433253e-02f, -1.37844861e-01f, 3.46617669e-01f, 3.50338906e-01f, 1.00894026e-01f, 2.42059454e-01f, 3.88751924e-01f,
  1.54449120e-01f, 5.18478341e-02f, 2.13464066e-01f, 3.11428279e-01f, -5.73399998e-02f, 1.78927734e-01f, 1.97539911e-01f, 2.05289975e-01f, -1.13196023e-01f, -1.39919296e-01f,
  -2.94248939e-01f, 1.17847323e-01f, -9.66403559e-02f, -1.37238652e-01f, -1.24241523e-01f, -1.84184387e-01f, -3.76917981e-02f, -1.52787536e-01f, 5.08804806e-02f, 4.46902448e-03f,
  -1.78879010e-03f, -2.22728699e-02f, -5.29491752e-02f, 9.12905261e-02f, -3.62968743e-02f, -7.80689418e-02f, -6.51670573e-03f, -5.76411411e-02f, -9.93687585e-02f, 1.02277309e-01f,
  -1.29755121e-03f, -9.77007896e-02f, -8.94233026e-03f, -1.37951300e-02f, 1.46855144e-02f, -1.38432551e-02f, -9.72782597e-02f, 1.28017887e-01f, 2.96421461e-02f, -6.40913025e-02f,
  1.44382787e-03f, 1.05831161e-01f, 7.11486302e-03f, 1.98380426e-02f, -6.63946867e-02f, -3.07454308e-03f, 5.46538085e-02f, -4.67897207e-02f, 7.99450558e-03f, 4.40423116e-02f,
  -3.45174149e-02f, -3.80242034e-03f, 4.00005393e-02f, 2.45282426e-02f, 4.91472287e-03f, -8.60898942e-02f, -1.20515525e-02f, 2.82008480e-02f, -2.47201510e-02f, -2.45503001e-02f,
  6.10528253e-02f, 4.48769592e-02f, -3.44178663e-03f, -4.63693552e-02f, -1.62829179e-03f, -5.24342898e-03f, -1.01098299e-01f, 1.48842344e-02f, 5.01011498e-02f, -6.87884167e-03f,
  2.74795666e-02f, -2.87141260e-02f, 1.06428221e-01f, 1.74412519e-01f, 6.47815829e-03f, 2.63480637e-02f, -3.12114079e-02f, -1.23443473e-02f, -2.81277411e-02f, -4.97160815e-02f,
  2.74968743e-01f, 1.07707143e-01f, -4.21952754e-02f, 4.74373065e-02f, -1.16698979e-03f, -9.83464047e-02f, -2.82417443e-02f, -5.94481677e-02f, 1.85228102e-02f, -6.22538365e-02f,
  -1.26718427e-03f, 1.89319439e-02f, -5.79162501e-02f, -1.17379818e-02f, 3.62477265e-02f, 1.40708074e-01f, -5.71079031e-02f, -8.32364038e-02f, 4.96650673e-02f, -5.57835028e-02f,
  -6.58739218e-03f, 5.12684346e-04f, -5.97135723e-02f, 1.89393554e-02f, 1.81414727e-02f, -3.40950079e-02f, 6.32605283e-04f, -9.25264955e-02f, -8.63111317e-02f, 1.23550415e-01f,
  2.87061006e-01f, -4.32149738e-01f, 1.20661743e-01f, 2.46191159e-01f, 4.20135617e-01f, 2.31234990e-02f, 2.44918644e-01f, 2.77536623e-02f, 1.97658837e-02f, -4.55630898e-01f,
  -6.53127208e-03f, -2.87638418e-02f, -2.05211177e-01f, 9.48217437e-02f, 3.72288495e-01f, -1.12091944e-01f, 2.23549530e-02f, 2.76329685e-02f, 3.51971537e-02f, -1.78358760e-02f,
  1.12460293e-01f, 1.66657344e-01f, 1.84263155e-01f, -7.80337304e-02f, 6.80210516e-02f, -3.93282063e-02f, -3.74555103e-02f, 1.31639279e-02f, 1.47948293e-02f, 1.68400720e-01f,
  -1.08205125e-01f, -7.31019303e-02f, -4.92712669e-02f, -1.07990824e-01f, -1.27164423e-01f, -6.55395463e-02f, -4.95478958e-02f, 1.99816581e-02f, 5.84168211e-02f, 1.72280520e-02f,
  -1.06670409e-01f, 5.74496342e-03f, 2.42782533e-02f, 9.83936265e-02f, 1.87798105e-02f, 9.56901461e-02f, 1.00582235e-01f, 2.20117755e-02f, -3.62133346e-02f, 7.24405348e-02f,
  8.08614120e-02f, -4.69773076e-02f, -1.56364255e-02f, -2.58620887e-04f, 2.23218855e-02f, 1.21332491e-02f, 1.20171785e-01f, 1.24397734e-02f, 5.40624410e-02f, 3.39327604e-02f,
  6.27088323e-02f, 2.69199796e-02f, -6.09545223e-02f, -6.53503230e-03f, 1.41311735e-02f, 1.26844332e-01f, 1.11999214e-02f, 1.96350217e-02f, -4.84004468e-02f, -8.85626748e-02f,
  1.80637352e-02f, 2.40224395e-02f, -3.46330635e-04f, -5.89771681e-02f, -4.52985279e-02f, 1.79094207e-02f, 3.03812884e-02f, 4.88805696e-02f, -3.80514637e-02f, 2.84872204e-02f,
  2.29104701e-02f, 3.64193730e-02f, -7.15619773e-02f, -4.61850017e-02f, 8.69200658e-03f, 9.09551978e-03f, -4.41422537e-02f, -4.49894331e-02f, 2.56960299e-02f, 1.93257686e-02f,
  -5.37849009e-01f, -4.21539754e-01f, -7.91445002e-02f, -1.16632609e-02f, -2.33263075e-02f, -8.21447521e-02f, 7.62109226e-03f, 3.67583893e-02f, -2.03683659e-01f, -1.99730173e-02f,
  -6.54178634e-02f, 5.31338677e-02f, -2.06257582e-01f, 1.04016833e-01f, 2.54697949e-02f, -1.40866358e-02f, -1.45120665e-01f, -2.08742961e-01f, -7.31551126e-02f, -2.12440193e-02f,
  -1.36625528e-01f, 3.96440849e-02f, 1.22698337e-01f, 4.81683128e-02f, 2.99829524e-02f, -1.57592222e-02f, 5.98971769e-02f, 1.32282553e-02f, -4.11932133e-02f, 1.01649258e-02f,
  -3.77508372e-01f, 4.68553185e-01f, 2.44404390e-01f, -5.29821776e-02f, -8.74985754e-02f, 1.89167261e-01f, 1.92580856e-02f, 4.13906053e-02f, 2.71488838e-02f, 3.84140685e-02f,
  -2.07812712e-01f, 1.72059193e-01f, -1.32083103e-01f, 9.24964249e-02f, -1.76598415e-01f, -6.45978525e-02f, -7.65177608e-02f, 2.42019240e-02f, 1.01682544e-01f, 5.46282902e-02f,
  1.55833047e-02f, -1.72542915e-01f, -4.30140644e-02f, 5.94730079e-02f, -9.40476209e-02f, 1.02016486e-01f, -3.28639060e-01f, 7.68666342e-02f, -3.62936892e-02f, 7.72528499e-02f,
  -3.00675362e-01f, -1.55778512e-01f, -1.19348645e-01f, -3.01340315e-02f, -9.22854319e-02f, -1.21407814e-01f, 3.90027091e-03f, -1.54687446e-02f, -4.10129726e-02f, 5.46407402e-02f,
  -1.64017528e-02f, 2.91999560e-02f, 1.91366428e-03f, 1.55100405e-01f, -3.98814753e-02f, 5.98499775e-02f, 2.15702448e-02f, -2.19676103e-02f, -6.21049106e-03f, 4.32538241e-02f,
  8.79205614e-02f, 2.24282965e-02f, -5.40383682e-02f, 6.27771318e-02f, -1.50369406e-02f, -3.54176648e-02f, 1.29415706e-01f, 3.73905003e-02f, 7.93879852e-02f, -5.06921485e-02f,
  9.36018154e-02f, -4.53632772e-02f, 1.05381556e-01f, 7.25127161e-02f, 1.38228461e-01f, 4.12399061e-02f, 2.09896974e-02f, -7.38294423e-02f, 5.30923121e-02f, -6.82346597e-02f,
  -1.83392819e-02f, -7.57515058e-02f, -3.19190137e-02f, 3.13605741e-02f, 5.08295884e-03f, 1.17010318e-01f, 3.59521317e-03f, -3.13207656e-02f, 5.73263429e-02f, -8.20717439e-02f,
  -6.78626299e-02f, -1.63635854e-02f, 1.63384266e-02f, -1.08946927e-01f, -6.29834319e-03f, -2.98617873e-02f, -1.59733947e-02f, 4.43897396e-02f, -7.36803859e-02f, 1.46547249e-02f,
  -3.39271188e-01f, -1.03325270e-01f, -1.77330926e-01f, -1.16383053e-01f, -1.04241870e-01f, -7.32153878e-02f, 1.31896921e-02f, -4.96038012e-02f, 4.49819025e-03f, 2.22598631e-02f,
  -3.62389684e-02f, -6.71563372e-02f, -4.43901634e-03f, 2.56880596e-02f, -4.57075499e-02f, -1.94178969e-01f, -1.30456984e-01f, 4.59509529e-02f, -1.22965686e-01f, 2.59172870e-03f,
  -3.16396579e-02f, -4.66242880e-02f, 3.44910845e-02f, -1.07582189e-01f, 5.93847148e-02f, -1.15636416e-01f, 8.62606615e-02f, -4.99560982e-02f, -6.92864284e-02f, -8.71375278e-02f,
  4.16588962e-01f, 4.20322537e-01f, -6.35433709e-03f, 1.60257921e-01f, -1.72800776e-02f, 2.09225163e-01f, 1.91861883e-01f, 5.48299998e-02f, 3.87862176e-01f, 1.91894338e-01f,
  -1.05210111e-01f, 2.15945721e-01f, -5.97166754e-02f, 1.65246651e-01f, -6.38824841e-03f, 1.02990098e-01f, 2.46328205e-01f, 9.49735567e-02f, 1.34042665e-01f, 2.25015387e-01f,
  1.99953586e-01f, 1.72088265e-01f, -8.24401751e-02f, -4.29172292e-02f, 1.50192920e-02f, -8.86541158e-02f, -2.96495974e-01f, -1.19011998e-01f, -1.13807321e-01f, -7.63348415e-02f,
  -4.40769903e-02f, 1.18504971e-01f, 3.89943784e-03f, 3.30067128e-02f, 7.56737590e-02f, -1.91626009e-02f, -5.20685241e-02f, -1.93630010e-04f, 9.74373519e-02f, 3.32907066e-02f,
  7.45206475e-02f, 2.22677551e-02f, 1.40487224e-01f, 2.35871356e-02f, 1.09111983e-02f, -5.23634776e-02f, 4.03686799e-02f, -2.43717269e-03f, 8.92660115e-03f, 1.00762740e-01f,
  7.18749836e-02f, -6.04361109e-02f, 2.36542914e-02f, 6.18643016e-02f, 9.39246565e-02f, 1.14620425e-01f, 1.20941371e-01f, -7.19904378e-02f, -3.90080065e-02f, 1.25450671e-01f,
  7.06936494e-02f, 8.96500573e-02f, 2.53303945e-02f, -1.00263804e-01f, 2.11593322e-02f, -7.96986371e-03f, 3.98791395e-02f, -4.81466725e-02f, -3.08791734e-02f, 8.88975039e-02f,
  -9.93044768e-03f, -3.46825048e-02f, -4.68715280e-02f, 1.96259804e-02f, 2.95968503e-02f, 3.31222080e-02f, -1.94647107e-02f, -3.76544558e-02f, 8.02707151e-02f, -6.61554234e-03f,
  5.22539776e-04f, 2.92583145e-02f, -9.22167748e-02f, -3.89091447e-02f, -3.30386981e-02f, -2.78071612e-02f, -7.48234452e-04f, -3.72287608e-03f, -6.93465844e-02f, -2.06310600e-02f,
  8.34204033e-02f, 3.12600106e-01f, 6.12990325e-03f, 1.02989219e-01f, -3.30673275e-03f, -6.91471994e-02f, 1.21846355e-01f, 1.05134539e-01f, 1.01869293e-01f, 9.89390314e-02f,
  3.75216268e-02f, -1.77725181e-02f, 1.61249395e-02f, -8.02135542e-02f, -9.44923982e-03f, 3.67744416e-02f, 6.56057149e-02f, 7.13816285e-02f, 4.00605910e-02f, -5.42396158e-02f,
  -2.05634013e-02f, 1.08093798e-01f, 1.02937981e-01f, 1.01384856e-01f, 4.38982472e-02f, 2.07141098e-02f, -3.92207503e-02f, -8.71094968e-03f, -9.58164409e-02f, 9.04419944e-02f,
  2.40067720e-01f, 2.38832727e-01f, 2.96476722e-01f, 2.89902925e-01f, -2.57386804e-01f, -3.95027190e-01f, -2.28682145e-01f, 1.73425585e-01f, -8.00230727e-03f, 6.41044974e-02f,
  -7.01077506e-02f, 1.91364512e-01f, -1.86229840e-01f, 7.77585655e-02f, -9.25452188e-02f, -1.79570019e-01f, 1.07675821e-01f, -9.25679691e-03f, 7.26389978e-03f, 1.52521178e-01f,
  1.62322208e-01f, -7.04016611e-02f, 2.07038566e-01f, 7.88438320e-02f, 2.79703140e-01f, 2.02178001e-01f, 2.23978907e-01f, -7.68968016e-02f, 2.16132805e-01f, -1.01089120e-01f,
  3.32565568e-02f, 1.25902012e-01f, 1.76643386e-01f, 2.96771433e-02f, 1.36676831e-02f, -8.93715322e-02f, 4.30044867e-02f, 2.10862234e-02f, -6.36902303e-02f, 8.81004054e-03f,
  1.57227162e-02f, -9.91106629e-02f, 4.48348420e-03f, -3.80367413e-02f, -2.54009999e-02f, 9.17528272e-02f, 2.72135120e-02f, 4.35702726e-02f, 1.02607660e-01f, 8.02885816e-02f,
  8.08177814e-02f, 3.09866406e-02f, -8.64311936e-04f, 6.99723214e-02f, 5.97119480e-02f, 2.02564243e-02f, -5.10321222e-02f, 6.00694939e-02f, 5.05162217e-02f, -1.40841249e-02f,
  3.65066826e-02f, -1.06935047e-01f, -9.42957923e-02f, -1.52797904e-02f, -1.85862277e-02f, -4.16012891e-02f, -2.61489712e-02f, 9.24079865e-02f, -5.01706675e-02f, 4.80597280e-03f,
  4.24603745e-02f, 4.20266949e-02f, -1.26333833e-01f, 1.85811277e-02f, 2.46772859e-02f, 2.33640578e-02f, -1.90307032e-02f, -3.70053835e-02f, -3.77111658e-02f, 1.24096036e-01f,
  -6.94580674e-02f, -1.55838162e-01f, -2.56702546e-02f, 4.32988219e-02f, -1.19809970e-01f, -4.30948362e-02f, 7.40613565e-02f, -4.70255092e-02f, 5.63977174e-02f, 8.39184523e-02f,
  -3.10831666e-02f, 2.69995034e-01f, 7.52170086e-02f, 3.59349400e-02f, -1.57225400e-01f, -2.39802040e-02f, -2.75881998e-02f, 1.36299327e-01f, 7.96081647e-02f, -3.52371372e-02f,
  3.14210020e-02f, -1.26085861e-03f, -1.85953677e-01f, 3.52931861e-03f, -1.53747061e-02f, 6.02043234e-02f, 9.03438032e-03f, -3.72122228e-02f, 2.79105026e-02f, 6.72987103e-02f,
  7.29842782e-02f, -9.91322398e-02f, 5.16366698e-02f, 2.17604861e-02f, 9.63588059e-02f, -1.07096219e-02f, -9.11872759e-02f, 5.72123453e-02f, 5.48382141e-02f, -1.19936712e-01f,
  2.71407932e-01f, 1.07405335e-01f, 3.15818548e-01f, 3.77223819e-01f, 3.97556834e-03f, -3.68291497e-01f, -1.73016563e-01f, 1.66313007e-01f, 1.17646545e-01f, -7.53764361e-02f,
  -5.91164008e-02f, -2.20927149e-02f, -1.26043871e-01f, 5.55537008e-02f, -2.43499111e-02f, -1.01132348e-01f, 8.50324556e-02f, -4.35940214e-02f, 8.24046582e-02f, 2.55282193e-01f,
  2.26352841e-01f, -4.56324667e-02f, 3.14586043e-01f, 7.44827762e-02f, 1.35410622e-01f, 2.92341053e-01f, 1.72160998e-01f, -6.42943904e-02f, 1.93868428e-01f, -1.82434127e-01f,
  -7.10635483e-02f, 1.38455993e-02f, 1.03789210e-01f, -7.98895881e-02f, 9.33696553e-02f, -6.76599517e-02f, -9.76095945e-02f, -5.70260212e-02f, -1.62268393e-02f, -5.35898358e-02f,
  3.97979766e-02f, -2.41375454e-02f, 1.02942577e-02f, -4.81984615e-02f, -2.00176276e-02f, 3.13211158e-02f, -8.13491177e-03f, 5.07799685e-02f, 8.75001550e-02f, -3.72365192e-02f,
  6.43802285e-02f, 2.28788089e-02f, 8.95189529e-04f, -5.04793748e-02f, 1.12977609e-01f, 6.48545176e-02f, -3.20917107e-02f, 7.27390870e-03f, -1.86913610e-02f, 2.37697307e-02f,
  -1.20842077e-01f, 3.92147303e-02f, 1.25986025e-01f, 1.47597075e-01f, 3.10001406e-03f, 2.94948984e-02f, -1.49991987e-02f, -4.41283882e-02f, -1.56803057e-02f, -1.93351079e-02f,
  -4.42964248e-02f, 9.94658917e-02f, 7.04232901e-02f, -1.21384062e-01f, 5.63280471e-02f, 5.49877249e-02f, -3.62263732e-02f, -1.16501644e-01f, 3.44041809e-02f, 5.09537831e-02f,
  -1.07709363e-01f, -1.08291224e-01f, 5.15522324e-02f, 1.95186585e-02f, -6.39458969e-02f, -4.52640746e-03f, 1.09167136e-02f, 4.26227897e-02f, -7.03013455e-03f, 3.85071486e-02f,
  -7.77109191e-02f, 8.08112398e-02f, 5.94050661e-02f, -9.28047970e-02f, 1.85108408e-02f, -1.12761911e-02f, -5.26318960e-02f, -3.71590219e-02f, -2.97755115e-02f, 2.44186097e-03f,
  1.63986236e-02f, 5.50245084e-02f, -1.30570948e-01f, 1.06890965e-02f, -6.57596588e-02f, -2.59761885e-02f, 2.95793749e-02f, 1.71546713e-02f, -9.94566176e-03f, 4.79777204e-03f,
  1.04876906e-01f, -5.26487455e-03f, 8.84213373e-02f, -1.15992613e-02f, -3.40253636e-02f, -4.56592329e-02f, -2.44731493e-02f, 8.90193600e-03f, 6.87232763e-02f, -5.63632473e-02f,
  2.90579945e-01f, 3.57204139e-01f, 2.21183807e-01f, 2.61477292e-01f, 7.78588057e-02f, 2.78483659e-01f, 2.27736279e-01f, 6.03784434e-02f, 3.40602666e-01f, 6.80934265e-02f,
  -9.99051407e-02f, 1.23191357e-01f, -1.80417210e-01f, 1.38142496e-01f, -1.20031640e-01f, -8.11622664e-02f, 1.38942719e-01f, 6.00023493e-02f, 1.35627657e-01f, 8.17609355e-02f,
  7.98068270e-02f, -5.21490909e-02f, -2.01526687e-01f, -1.46970123e-01f, 2.00127643e-02f, 1.32767931e-02f, -3.16346079e-01f, -2.59413093e-01f, -9.55709442e-02f, -7.11001363e-03f,
  -5.08652627e-03f, 1.64489727e-02f, 3.11987903e-02f, 1.96255706e-02f, 1.10247806e-02f, 1.98354870e-02f, -3.41085196e-02f, -1.28384009e-01f, -4.57042716e-02f, 5.37281558e-02f,
  1.35553122e-01f, -4.75175455e-02f, 6.58987612e-02f, -5.54606318e-02f, 4.03641574e-02f, 3.67754176e-02f, 9.54056010e-02f, 4.76475321e-02f, 9.55841318e-02f, 4.31052744e-02f,
  3.90289538e-02f, 5.72814606e-02f, 7.90181197e-03f, 7.70455301e-02f, 6.34466782e-02f, 4.99138944e-02f, 5.58345914e-02f, -1.57174580e-02f, 1.15294717e-01f, 7.49715022e-04f,
  -1.07362564e-03f, 5.35776466e-02f, 2.79273232e-03f, -2.25271378e-02f, 7.05358833e-02f, 3.40747796e-02f, -7.23216534e-02f, -5.76304384e-02f, 1.51013672e-01f, -1.74812153e-02f,
  -5.54755852e-02f, 4.89144810e-02f, 6.46424815e-02f, 1.55611644e-02f, 1.12476178e-01f, 2.72459220e-02f, 6.62431568e-02f, -5.37179317e-03f, 4.58245277e-02f, -2.95734499e-02f,
  -2.12496333e-02f, 3.11000505e-04f, 5.59517881e-03f, -4.17287461e-03f, -5.07209934e-02f, -5.44305816e-02f, 7.82743171e-02f, 1.31567076e-01f, -1.30275875e-01f, 1.84834152e-02f,
  7.98749253e-02f, 1.64768115e-01f, 3.98029275e-02f, 9.73907951e-03f, 8.99564102e-03f, -1.27128646e-01f, -4.12272941e-03f, 1.54894859e-01f, -3.25388135e-03f, 2.58285888e-02f,
  4.21794020e-02f, 2.41336580e-02f, 7.02584209e-03f, -3.98348980e-02f, -2.82645710e-02f, -4.05787397e-03f, 1.20682307e-01f, 2.52927653e-02f, -1.29842222e-01f, 1.36164837e-02f,
  -6.31104037e-02f, 3.76155339e-02f, 5.16854860e-02f, -1.58112776e-02f, 1.06479168e-01f, -2.32969839e-02f, -2.18366068e-02f, 2.27345098e-02f, 5.19472659e-02f, -7.91888833e-02f,
  -3.37815434e-01f, 1.19888455e-01f, 3.80949497e-01f, -5.13372719e-01f, 5.43919317e-02f, 4.31135416e-01f, 1.94475517e-01f, 4.26501408e-02f, -3.61717254e-01f, -1.91739678e-01f,
  -1.52884886e-01f, -2.44975433e-01f, 1.70123503e-01f, -9.67367291e-02f, 3.03897113e-01f, 1.56514093e-01f, -3.32298465e-02f, -6.66705444e-02f, 1.99645191e-01f, -5.05902953e-02f,
  -8.87589604e-02f, -1.45954609e-01f, 3.56848329e-01f, 5.73693216e-03f, -1.19612195e-01f, -8.77242088e-02f, -1.57701135e-01f, 1.26193658e-01f, -1.15654327e-01f, 4.70721163e-02f,
  1.00738600e-01f, -3.04909685e-04f, 5.63601218e-02f, 6.41841441e-02f, -2.35769562e-02f, -1.34641714e-02f, 1.55227128e-02f, 1.18354738e-01f, -1.29200712e-01f, -2.29832926e-03f,
  -4.30811159e-02f, 6.71154037e-02f, -2.56313272e-02f, -1.14563279e-01f, -1.87659293e-01f, -5.77949993e-02f, -2.39019021e-02f, -5.72271422e-02f, -5.33571132e-02f, 1.35354921e-01f,
  2.56242324e-02f, 2.96117589e-02f, -2.07272843e-02f, -1.04235195e-01f, -2.26526894e-02f, 7.80712515e-02f, 3.87909301e-02f, 6.13521747e-02f, -4.03394476e-02f, -9.61072668e-02f,
  -9.85721424e-02f, 6.80295750e-02f, 6.15414344e-02f, 1.23572741e-02f, -5.96143231e-02f, -4.47410382e-02f, -7.97205232e-03f, -3.98491435e-02f, -8.42121616e-02f, 4.55821119e-02f,
  -9.25182328e-02f, 4.99554835e-02f, 3.42980884e-02f, -8.41663107e-02f, -1.06726490e-01f, -1.13945842e-01f, 4.36478704e-02f, 3.07809263e-02f, -2.75579616e-02f, 8.63851234e-02f,
  -7.86122680e-02f, -1.10769477e-02f, 1.19383015e-01f, -1.25774339e-01f, 1.19236052e-01f, -1.21115513e-01f, -6.55772388e-02f, -4.21413146e-02f, 1.44822463e-01f, 5.99778034e-02f,
  8.98223370e-02f, 2.29403600e-02f, 1.06505550e-01f, 5.18069118e-02f, 8.86106864e-02f, -2.62147952e-02f, 7.08089247e-02f, -3.21477875e-02f, -5.48867472e-02f, 2.47283503e-02f,
  -1.62425637e-01f, -1.52094930e-03f, 3.30370963e-02f, 4.13470939e-02f, -5.23459353e-03f, 5.28677832e-03f, -1.07175387e-01f, -5.57250381e-02f, -4.67121638e-02f, 7.91514143e-02f,
  -1.62810050e-02f, -5.71759790e-02f, -7.05931932e-02f, -6.50171936e-02f, -8.66172314e-02f, -2.41852459e-02f, -5.92893697e-02f, 1.34093966e-02f, 5.26510691e-03f, 8.30159262e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  9.15027857e-02f, 3.19121480e-01f, 2.53255278e-01f, 2.32586831e-01f, 3.89962554e-01f, 2.67178208e-01f, 1.36183470e-01f, 3.16448450e-01f, 2.49986604e-01f, 9.82406363e-02f,
  2.41714060e-01f, 2.11353973e-01f, 2.37544164e-01f, 2.87153602e-01f, 2.58314908e-01f, 3.82971793e-01f, 2.46548831e-01f, 2.31838539e-01f, 2.68548787e-01f, 2.10745662e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.01183124e-01f, -8.78473818e-02f, -8.68213773e-02f, 6.50888607e-02f, -3.88765931e-02f, 1.71890303e-01f, -8.40934552e-03f, 1.44961417e-01f, -1.47786289e-01f, 4.51411977e-02f,
  1.41514450e-01f, 3.25776171e-03f, -6.54051602e-02f, 1.27766192e-01f, 1.79350629e-01f, -1.47817194e-01f, -2.57115096e-01f, 3.45458269e-01f, 2.19948083e-01f, 1.42931789e-01f,
  2.15781763e-01f, 4.31990586e-02f, -5.21952547e-02f, 1.23747796e-01f, 1.50822714e-01f, -4.59921267e-03f, -2.12804034e-01f, 8.99841487e-02f, -3.30329090e-01f, -2.14486927e-01f,
  1.83161393e-01f, -8.20512250e-02f, -1.95034727e-01f, -2.91262627e-01f, -1.18142806e-01f, 1.88930988e-01f, -5.64674214e-02f, -2.06641238e-02f, -9.99728739e-02f, 1.39289722e-01f,
  1.97630450e-01f, -1.90668374e-01f, 2.34144375e-01f, -1.34156317e-01f, -2.63184547e-01f, -1.24697499e-01f, -9.00184512e-02f, -3.48875314e-01f, -3.23237628e-01f, -7.22089857e-02f,
  8.41236115e-02f, -1.13439538e-01f, 1.83954865e-01f, -1.86984554e-01f, 9.08134282e-02f, 2.93290794e-01f, 3.17502916e-01f, -6.80160075e-02f, -3.87405269e-02f, 7.31761158e-02f,
  5.74318357e-02f, 4.70973253e-02f, 3.82610410e-02f, 4.74676788e-02f, 9.89180207e-02f, 1.63371757e-01f, 1.64955422e-01f, -1.45582825e-01f, -2.29457356e-02f, -1.66156758e-02f,
  7.71955401e-02f, -1.24908380e-01f, -9.60133150e-02f, 1.09809577e-01f, -2.53581703e-02f, -9.37013999e-02f, 2.14492660e-02f, 3.51262987e-02f, 8.69853944e-02f, 8.50947201e-02f,
  1.15454592e-01f, 1.27662137e-01f, -1.38878673e-01f, 3.32369179e-01f, -4.01393771e-02f, 5.97545831e-03f, 4.11126129e-02f, -2.42931053e-01f, -1.07709728e-01f, 1.01773262e-01f,
  -4.77812029e-02f, -1.95186391e-01f, -1.16558215e-02f, -1.74611107e-01f, -2.50136346e-01f, 2.47001529e-01f, 1.46742150e-01f, -6.73781931e-02f, 6.95130154e-02f, 2.03398123e-01f,
  1.41075104e-01f, 6.91106766e-02f, -2.21681580e-01f, 7.53502473e-02f, -1.72177702e-01f, -3.61885950e-02f, -4.36536828e-03f, 2.89868861e-01f, -4.96738032e-03f, 2.33387351e-01f,
  3.53695974e-02f, 1.58683881e-01f, -4.90866266e-02f, 1.32541910e-01f, 1.55752912e-01f, -2.07976565e-01f, 1.05964355e-01f, -1.54683083e-01f, -1.96413308e-01f, 1.64719060e-01f,
  -1.90366328e-01f, 5.46173789e-02f, -5.23974113e-02f, 1.99344158e-01f, 6.71155332e-03f, 6.25554323e-02f, 1.39979556e-01f, -1.98737353e-01f, -1.46291211e-01f, 6.21224707e-03f,
  -1.37853632e-02f, 1.90170884e-01f, -6.33675158e-02f, 2.11584084e-02f, 1.75357863e-01f, 3.17429215e-01f, 1.69042543e-01f, -1.30673021e-01f, 7.15914816e-02f, 9.67908278e-02f,
  -7.66763836e-02f, 1.56061664e-01f, -2.36078322e-01f, -6.93037286e-02f, 2.02748612e-01f, -3.37380916e-01f, 2.08445758e-01f, -2.38947093e-01f, 1.59104437e-01f, -5.58933280e-02f,
  -1.06855594e-01f, 1.38687998e-01f, -1.70330442e-02f, 1.19905785e-01f, -2.71893233e-01f, -1.60416052e-01f, -9.98510048e-03f, 2.62356829e-02f, -1.32449985e-01f, -2.12712318e-01f,
  -2.24756926e-01f, -2.11355478e-01f, -1.02227315e-01f, -8.31039324e-02f, -1.33415237e-01f, 7.47240335e-02f, -6.16770498e-02f, 1.41037196e-01f, 2.34691724e-01f, -1.05956569e-01f,
  1.05092637e-01f, -1.73266381e-01f, -1.02105387e-01f, -6.45880625e-02f, -3.10081929e-01f, -2.96933889e-01f, -3.29514146e-01f, 5.11635579e-02f, 1.02483854e-01f, 9.34267491e-02f,
  1.64245769e-01f, 1.91612579e-02f, 1.35832220e-01f, 1.88553616e-01f, 1.51763067e-01f, -1.71387076e-01f, -2.22205475e-01f, -4.20363210e-02f, 1.06741801e-01f, 5.18245972e-04f,
  -4.26563099e-02f, -1.16817988e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -5.33033796e-02f, -1.33161917e-01f, -1.06862441e-01f, 2.82551140e-01f, 9.02146995e-02f, -8.91055837e-02f, -4.99853283e-01f, 8.34892541e-02f, 1.27027214e-01f, -1.76055565e-01f,
  1.31514743e-01f, -3.69021669e-02f, -1.56796023e-01f, -4.95157726e-02f, 7.23399073e-02f, 1.78828970e-01f, 3.83475386e-02f, -1.16556538e-02f, 6.89936848e-03f, -3.05881113e-01f,
  3.00758332e-01f, -1.77307934e-01f, -3.27490360e-01f, 3.58898453e-02f, 4.00123093e-03f, 8.46142322e-02f, 4.43126075e-02f, 4.78838295e-01f, 6.32902920e-01f, 5.61142325e-01f,
  2.95841038e-01f, -2.62271732e-01f, 3.32386523e-01f, 2.67616444e-04f, 2.06097960e-01f, 3.55300039e-01f, 2.34315917e-01f, 2.57532269e-01f, -4.57523949e-02f, 3.37004662e-01f,
  -2.79928565e-01f, -1.46324951e-02f, 9.61750597e-02f, 3.97688746e-01f, -2.78687440e-02f, 3.38348389e-01f, 2.85648137e-01f, -1.25601947e-01f, 7.05219954e-02f, 1.02668688e-01f,
  4.35289949e-01f, -1.43761024e-01f, 3.43803376e-01f, -2.08524540e-01f, -3.75228733e-01f, 3.58941823e-01f, -1.83629975e-01f, 3.66249532e-01f, -2.91330367e-01f, 1.92527533e-01f,
  -4.21039015e-02f, -1.71565581e-02f, 1.94231048e-01f, -2.01900825e-01f, 5.20958565e-02f, 1.32295221e-01f, 1.06770322e-01f, -1.94600392e-02f, 1.96788102e-01f, 1.33948624e-01f,
  2.85088301e-01f, 4.40980047e-02f, 2.26164311e-01f, -1.70775816e-01f, 2.03363493e-01f, -2.95353353e-01f, 1.78407773e-01f, -1.89751476e-01f, -1.26384526e-01f, -1.94677651e-01f,
  -6.95046782e-02f, 1.36753127e-01f, -1.07970551e-01f, 2.32139573e-01f, 1.56453371e-01f, 1.15966134e-01f, 5.00536740e-01f, 3.24558854e-01f, 3.93888116e-01f, -3.45795065e-01f,
  9.43912491e-02f, 2.19333589e-01f, -2.09420100e-01f, -2.53770292e-01f, 1.28128111e-01f, 3.40216070e-01f, 1.99446082e-01f, 9.94468331e-02f, -2.72067841e-02f, 1.01491548e-01f,
  -2.37828046e-01f, 5.03670461e-02f, -1.55098975e-01f, 1.24112088e-02f, -2.45532990e-01f, 3.14375281e-01f, -6.82905763e-02f, 1.44394994e-01f, 1.42222121e-01f, 4.05670136e-01f,
  4.28725600e-01f, 1.88414514e-01f, -2.37831712e-01f, 3.91259640e-01f, 3.72022420e-01f, 4.45490092e-01f, 2.62011707e-01f, 2.36744285e-02f, -4.63203937e-01f, -7.85878599e-02f,
  -4.32598501e-01f, 5.96087098e-01f, -3.22126120e-01f, -6.65530488e-02f, -2.46584751e-02f, -3.38867828e-02f, -1.20329514e-01f, -9.32611525e-02f, 2.75080472e-01f, 3.01204115e-01f,
  1.84885219e-01f, 1.59692213e-01f, 3.80357146e-01f, 7.01348633e-02f, -2.52416641e-01f, -3.12790334e-01f, -5.18243670e-01f, 1.82834506e-01f, 7.88353682e-02f, 3.20721716e-01f,
  -3.54242563e-01f, -2.81230599e-01f, 5.38007677e-01f, 1.58498317e-01f, 7.94358253e-02f, -8.71644821e-03f, -1.39830917e-01f, 5.59390895e-03f, 2.69979052e-02f, -2.06414565e-01f,
  1.60809439e-02f, -2.72119045e-01f, -1.72868058e-01f, 2.94376284e-01f, 3.84470344e-01f, 3.46832484e-01f, 3.84022325e-01f, 1.56234026e-01f, 3.96035612e-01f, 4.16634977e-01f,
  1.88984111e-01f, 2.27752924e-01f, 3.98212641e-01f, -5.86357005e-02f, 1.12790681e-01f, 6.29143417e-02f, 2.01442227e-01f, -1.99707523e-01f, -1.30431771e-01f, 2.53175378e-01f,
  -3.62283856e-01f, 1.64049432e-01f, 2.90249765e-01f, 3.63102496e-01f, 2.23024741e-01f, 5.07539511e-01f, 6.00028574e-01f, 6.31834492e-02f, -3.87529135e-02f, 3.01826805e-01f,
  -1.52940571e-01f, 2.65759438e-01f, 2.47053038e-02f, -9.41896588e-02f, -1.40512362e-01f, 1.81256264e-01f, 3.13219637e-01f, -6.53015748e-02f, 1.13813460e-01f, 1.01859225e-02f,
  1.33009672e-01f, 3.95559609e-01f, 3.10682416e-01f, 1.76441386e-01f, 1.46609306e-01f, 3.79508249e-02f, 1.27326667e-01f, 1.90338239e-01f, 8.38923380e-02f, -1.41518712e-01f,
  -2.42590174e-01f, -7.02708587e-02f, 3.54018152e-01f, -3.39958757e-01f, -3.20519954e-02f, -7.46347159e-02f, 3.44538838e-01f, -3.59757334e-01f, -3.52064967e-01f, 4.25825357e-01f,
  9.86163691e-02f, 3.74321073e-01f, 3.24958980e-01f, -1.70541741e-03f, 2.23442554e-01f, 1.23419710e-01f, 4.73714978e-01f, -1.85013637e-02f, 1.22218847e-01f, 2.34567150e-01f,
  -1.51584998e-01f, -2.00498328e-01f, 2.01246068e-01f, 3.17748368e-01f, 9.83722955e-02f, -2.80700535e-01f, 1.57688726e-02f, 1.54654711e-01f, 1.50450036e-01f, 1.95569992e-01f,
  -1.70479655e-01f, 5.48817277e-01f, 3.94534290e-01f, -2.96748489e-01f, 1.03835113e-01f, 1.53021052e-01f, -1.47511691e-01f, 5.28445065e-01f, -1.33437768e-01f, -2.55394429e-01f,
  1.08072497e-01f, -9.86075625e-02f, 5.24719298e-01f, -2.84190744e-01f, 3.11521620e-01f, -2.79935062e-01f, -2.59502441e-01f, 4.38428849e-01f, -1.34604752e-01f, 3.97241294e-01f,
  -5.06576121e-01f, 6.14978187e-02f, 1.90004379e-01f, 3.11041266e-01f, -1.12625383e-01f, -1.76346451e-01f, 3.70776691e-02f, -1.75757408e-02f, 7.81726986e-02f, 4.60111611e-02f,
  3.01436454e-01f, 2.27439910e-01f, 2.93587208e-01f, 7.11636022e-02f, 4.58647549e-01f, -1.62196755e-01f, -2.44235650e-01f, -1.26256719e-01f, 3.11518282e-01f, 2.02965364e-01f,
  -2.19351783e-01f, 2.46048108e-01f, 6.00533009e-01f, -6.82402626e-02f, 2.11251504e-03f, 2.05503479e-01f, -5.51362708e-02f, 1.73185512e-01f, 4.11473036e-01f, 3.26694757e-01f,
  3.85588706e-01f, -1.51363268e-01f, 2.04920694e-01f, 1.78529453e-02f, 2.18974724e-01f, 1.42072737e-01f, 1.27333835e-01f, 2.35705286e-01f, 4.85611819e-02f, -3.65949944e-02f,
  1.53744861e-01f, 8.69883448e-02f, 1.31003603e-01f, 3.32991928e-01f, 3.29765439e-01f, 3.67809802e-01f, 4.75864530e-01f, -2.11850628e-01f, -2.20181152e-01f, 1.33591413e-01f,
  1.98615730e-01f, 3.68940920e-01f, -4.09151644e-01f, -6.43409928e-03f, 5.56436956e-01f, -2.38167092e-01f, 3.22534710e-01f, 7.01112747e-02f, 1.01990305e-01f, 9.67955440e-02f,
  4.28043783e-01f, 5.35428584e-01f, 3.06000739e-01f, -9.84394103e-02f, -5.71377296e-03f, -1.99423179e-01f, -1.38050973e-01f, -1.61581695e-01f, -5.30646928e-02f, 1.36971176e-01f,
  2.18970459e-02f, -6.80761710e-02f, 4.76811789e-02f, -1.19849972e-01f, -8.76081586e-02f, 1.57973737e-01f, 1.90188959e-01f, 2.86144931e-02f, 3.63678008e-01f, 3.34707685e-02f,
  -1.14243612e-01f, -7.11488426e-02f, 3.00025254e-01f, 3.30286980e-01f, -3.41120735e-02f, 3.06527197e-01f, 1.28927395e-01f, 2.45724425e-01f, 2.11893693e-01f, 3.47778916e-01f,
  6.73045143e-02f, 3.38139057e-01f, 2.87548631e-01f, 3.20682466e-01f, 1.93369374e-01f, 1.80979207e-01f, -5.27219996e-02f, -1.76771730e-01f, -8.45484063e-02f, -1.57130912e-01f,
  -2.48129323e-01f, 1.91101119e-01f, 1.84791774e-01f, 1.10681973e-01f, 4.39957902e-03f, 1.59764186e-01f, 2.91522473e-01f, 1.04533039e-01f, -3.63661110e-01f, -1.89124465e-01f,
  -2.72449374e-01f, -1.23768516e-01f, 1.53917193e-01f, 5.80066741e-02f, 1.09638728e-01f, -1.71484753e-01f, 1.74793452e-01f, 1.27590775e-01f, 8.58719721e-02f, 3.46902721e-02f,
  -5.78158125e-02f, -6.47017034e-03f, 4.62460741e-02f, -4.04224508e-02f, 1.43111870e-01f, 2.08933115e-01f, 1.31026447e-01f, -2.93506414e-01f, 2.79889613e-01f, 4.83414620e-01f,
  3.98876309e-01f, 2.79879928e-01f, 4.67513442e-01f, 1.72782719e-01f, 1.83236733e-01f, 1.00673981e-01f, 5.67125678e-02f, -4.94344123e-02f, -2.18286738e-02f, 2.45560274e-01f,
  1.39007553e-01f, -2.19914347e-01f, 7.66004771e-02f, -2.35656917e-01f, -1.01918086e-01f, -3.52649957e-01f, 4.56035942e-01f, -5.87230660e-02f, -5.52615114e-02f, 1.53745770e-01f,
  4.23094407e-02f, 3.78437757e-01f, -1.18785292e-01f, 1.41250983e-01f, 1.59102231e-02f, 3.40331823e-01f, 3.51586014e-01f, 2.80026048e-01f, 5.44262946e-01f, -4.84715998e-01f,
  1.96198985e-01f, 4.19706881e-01f, -3.92523259e-02f, -1.51099071e-01f, 2.34708533e-01f, 1.50918486e-02f, 2.83683181e-01f, 1.75778911e-01f, 1.39870122e-01f, -1.40249580e-01f,
  6.67878464e-02f, -2.13098936e-02f, -1.09750584e-01f, -2.95585841e-01f, -3.95779282e-01f, 2.53246993e-01f, 4.46986966e-02f, 1.05779894e-01f, 2.28978574e-01f, -1.08567052e-01f,
  3.47127438e-01f, 4.14175212e-01f, 1.16536185e-01f, 1.40097022e-01f, -7.86658376e-02f, 3.39304358e-01f, -1.18975148e-01f, 1.49095744e-01f, 9.33816507e-02f, -4.28217277e-02f,
  -1.59269571e-01f, 1.94015309e-01f, 3.14617395e-01f, -3.36640514e-02f, 3.53625059e-01f, 1.67541206e-01f, 4.60020900e-02f, 5.01602709e-01f, 2.02417463e-01f, 7.57699460e-02f,
  -3.75489518e-02f, 3.53352338e-01f, 2.70548493e-01f, 1.79728076e-01f, -2.52193004e-01f, 1.77811489e-01f, -2.41067141e-01f, -1.32415056e-01f, 1.53750584e-01f, 2.16233552e-01f,
  -3.43512595e-01f, 2.10310265e-01f, 3.62679332e-01f, -4.60933708e-02f, -1.10167796e-02f, -2.87370011e-02f, 2.47300252e-01f, 2.79487725e-02f, 1.75471365e-01f, -2.40856901e-01f,
  2.55409144e-02f, 7.35032745e-03f, -1.25817195e-01f, 3.89484137e-01f, 2.04581823e-02f, 1.70635462e-01f, 3.69608641e-01f, 4.60113585e-01f, 1.86364055e-01f, 1.21930718e-01f,
  8.75210017e-02f, 1.02721371e-01f, 1.28129855e-01f, -1.58351138e-01f, 9.80475247e-02f, 3.48831937e-02f, 3.79228354e-01f, -1.75315514e-01f, 1.37864321e-01f, 7.64784887e-02f,
  -6.56770393e-02f, -3.75594981e-02f, 3.75928193e-01f, 7.35555440e-02f, 6.27734736e-02f, 2.53847927e-01f, 2.68192530e-01f, 2.23814845e-01f, -4.14446406e-02f, 4.30736780e-01f,
  -1.31858885e-01f, 3.60741764e-01f, 4.65463549e-01f, 1.51978552e-01f, 1.67153195e-01f, 8.77264068e-02f, 2.95663774e-01f, -2.52235085e-01f, -8.18937644e-02f, -1.31399304e-01f,
  -3.08658153e-01f, 4.57947820e-01f, 2.81516135e-01f, 2.13432685e-01f, 2.21170574e-01f, 2.52942741e-02f, 1.58369049e-01f, 1.81054786e-01f, 5.30430041e-02f, -1.59426108e-01f,
  -9.06277448e-02f, 6.63542449e-02f, 1.79929256e-01f, -2.39657104e-01f, 9.97740552e-02f, -4.03724760e-02f, 1.79649964e-01f, -5.76413907e-02f, -3.32805961e-01f, 3.45681965e-01f,
  8.75105634e-02f, 3.82653236e-01f, 9.93157104e-02f, 7.23238587e-02f, 1.78185716e-01f, 2.72958189e-01f, 3.43927979e-01f, 1.02801904e-01f, 1.74019292e-01f, 1.55710727e-01f,
  -9.58463699e-02f, -2.11182654e-01f, 2.47201204e-01f, 4.15056705e-01f, 2.84170955e-01f, -3.95205431e-02f, 1.47560626e-01f, 2.49287352e-01f, 1.53643176e-01f, 2.29286134e-01f,
  2.03894362e-01f, 2.72945195e-01f, -3.65889333e-02f, -1.90150049e-02f, 1.06768891e-01f, 1.99745774e-01f, -1.15686223e-01f, 2.12256268e-01f, 3.24592113e-01f, -2.94436544e-01f,
  -4.04667035e-02f, 1.31911650e-01f, 3.74412924e-01f, 1.25561148e-01f, 2.99019247e-01f, -1.60360560e-01f, 1.14219822e-02f, 2.43882120e-01f, -3.09645273e-02f, 4.97173637e-01f,
  -1.19639404e-01f, -2.96753161e-02f, -4.77331653e-02f, -1.79614767e-01f, -2.22821925e-02f, 4.32322741e-01f, 2.09667273e-02f, -1.17384903e-01f, 3.29719409e-02f, 1.41470000e-01f,
  1.07266409e-02f, 1.97863281e-01f, 3.55689861e-02f, 9.32704657e-02f, 7.43181482e-02f, -1.05093479e-01f, -2.69145165e-02f, -8.74454901e-02f, 2.69036651e-01f, 2.06814826e-01f,
  -2.80202110e-03f, 9.59484577e-02f, -5.47467731e-02f, 5.16760767e-01f, 8.74772668e-02f, 1.48508221e-01f, 8.20685849e-02f, 1.41462028e-01f, -8.79800394e-02f, 2.98218340e-01f,
  1.62854522e-01f, -3.57445538e-01f, -1.68992966e-01f, 3.36572886e-01f, -1.21890403e-01f, -1.57509401e-01f, 1.91926137e-01f, -9.64051634e-02f, 2.30808109e-01f, 4.93904129e-02f,
  -2.36411896e-02f, 2.15245083e-01f, -3.77301164e-02f, 1.57536194e-01f, -1.83669105e-01f, -3.04986816e-02f, -2.65616566e-01f, -1.33459475e-02f, 2.96455592e-01f, -8.05401132e-02f,
  8.08347389e-02f, 3.46780755e-02f, 3.33062619e-01f, -6.16567247e-02f, -2.39711151e-01f, 4.46296453e-01f, 2.96662033e-01f, 2.95244576e-03f, 3.74553233e-01f, 1.73085015e-02f,
  -2.99700629e-02f, 2.11736023e-01f, 1.05893783e-01f, 1.48215488e-01f, -6.14176206e-02f, 3.65334779e-01f, -6.10318175e-03f, 7.48541057e-02f, 3.23068947e-01f, -5.60605042e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.24418998e-01f, 1.19348243e-01f, 1.22897185e-01f, 9.99714360e-02f, 9.16589275e-02f, 3.33594441e-01f, 1.70268804e-01f, 1.56962767e-01f, 3.44063640e-01f, 1.06589772e-01f,
  1.32149860e-01f, 1.36266500e-01f, 1.62660465e-01f, 2.26042584e-01f, 1.73889816e-01f, 1.22979343e-01f, 1.50955662e-01f, 3.21913153e-01f, 1.02826327e-01f, 5.49084358e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -4.38927077e-02f, -7.30469543e-03f, 7.17114732e-02f, -1.13233872e-01f, 4.05751392e-02f, -7.52225220e-02f, -7.15141520e-02f, -1.87555104e-01f, -1.05507687e-01f, 2.29415938e-01f,
  2.05179766e-01f, -5.71149550e-02f, 1.26338946e-02f, 3.05516958e-01f, -1.63657948e-01f, -8.45524520e-02f, 7.76957199e-02f, 6.41728565e-03f, -1.61646321e-01f, 4.75914478e-02f,
  -4.50799428e-02f, 2.88028479e-01f, 7.39705563e-02f, -8.79077911e-02f, -3.55027355e-02f, -6.35059699e-02f, -7.12015554e-02f, -1.27482757e-01f, -6.33095279e-02f, 1.17178753e-01f,
  -2.16517560e-02f, -2.82897651e-02f, 1.43412545e-01f, 1.14021286e-01f, 2.49186680e-01f, -1.59799486e-01f, -6.99478835e-02f, 7.75967613e-02f, 4.12043296e-02f, 3.33732762e-03f,
  -2.23188549e-01f, 1.89088657e-01f, 1.80024430e-01f, -1.33026630e-01f, 1.99842849e-04f, 2.66912013e-01f, -5.58973737e-02f, -2.78509613e-02f, 1.01211611e-02f, 3.21773440e-02f,
  4.08057198e-02f, 8.33436623e-02f, -1.26244202e-01f, 8.31024423e-02f, -2.21996143e-01f, 1.28982244e-02f, 1.45778507e-01f, -2.33634725e-01f, 1.09089449e-01f, -2.37893000e-01f,
  1.37130141e-01f, 8.50285310e-03f, 8.57174695e-02f, 1.51036188e-01f, 2.27292068e-02f, 5.06901601e-03f, 6.48480877e-02f, 1.78257618e-02f, 1.52125852e-02f, 6.19439334e-02f,
  -1.44722551e-01f, -1.02961697e-01f, 7.17475191e-02f, -9.60119069e-02f, -2.63627589e-01f, -6.67014122e-02f, 8.63695815e-02f, -2.14845970e-01f, -7.75028467e-02f, 1.63882896e-01f,
  1.92616165e-01f, 2.43637055e-01f, 2.35652402e-02f, -1.81433097e-01f, -1.61294684e-01f, -1.69686273e-01f, -6.80103824e-02f, 1.54720992e-01f, 9.27657261e-02f, 1.81795597e-01f,
  -5.20412810e-02f, 7.86431879e-02f, 9.50133279e-02f, -6.03365600e-02f, -1.45324737e-01f, 3.10461819e-02f, 5.47802784e-02f, 1.28052592e-01f, -1.62962768e-02f, 3.24897356e-02f,
  -9.38235745e-02f, -9.22169387e-02f, -7.03494027e-02f, 2.70338934e-02f, 1.62627399e-02f, 1.25652850e-01f, 1.16497055e-01f, -1.41707277e-02f, 1.35862902e-01f, 7.50314444e-02f,
  -7.76385516e-02f, -1.83783531e-01f, 6.41809702e-02f, -6.53396100e-02f, -9.92200598e-02f, 1.68384761e-01f, 1.87054053e-01f, 9.28184018e-02f, -1.05316930e-01f, 1.48905525e-02f,
  -3.33706737e-02f, -9.32851657e-02f, 1.23812228e-01f, 1.52080450e-02f, -9.93759707e-02f, 4.31848550e-03f, -3.06304707e-03f, -6.99168220e-02f, -1.46961302e-01f, -2.81131774e-01f,
  -1.15905128e-01f, -1.45160332e-01f, -3.62432152e-02f, -8.82611945e-02f, 3.37969791e-03f, 1.66377783e-01f, -2.56232359e-03f, -1.19470812e-01f, 2.06056893e-01f, 2.58994401e-01f,
  -1.41823953e-02f, -1.39520735e-01f, -7.62394518e-02f, 1.97033688e-01f, -3.12072366e-01f, -3.74544784e-02f, -1.54839307e-01f, 2.25848943e-01f, -1.08462404e-02f, 6.66028261e-03f,
  1.93416163e-01f, -1.28885701e-01f, 2.47911401e-02f, -2.80278791e-02f, 1.02197394e-01f, 3.72548811e-02f, 5.56116225e-03f, -1.07715957e-01f, -9.61243659e-02f, 1.15498848e-01f,
  1.13989078e-01f, 1.35080442e-01f, -2.36649212e-04f, -1.29241415e-03f, -7.24402815e-02f, 8.15461725e-02f, 1.42388165e-01f, -5.68412915e-02f, 1.15712799e-01f, -1.32852614e-01f,
  -1.78480089e-01f, -5.87660484e-02f, -1.11360438e-01f, -3.61472368e-04f, 6.52067140e-02f, 1.93891823e-01f, 6.26105294e-02f, -6.05947711e-02f, 2.12469131e-01f, -2.46142223e-01f,
  -1.01343423e-01f, -2.77254850e-01f, -5.41942678e-02f, -1.03916697e-01f, 1.41146302e-01f, 7.80059695e-02f, 5.66023178e-02f, 8.96507055e-02f, 1.80229515e-01f, 1.52740017e-01f,
  -4.33327295e-02f, 6.50844797e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.56518929e-02f, 1.36732012e-01f, -9.38808080e-03f, 1.84271425e-01f, 1.80628702e-01f, -4.84727398e-02f, 2.23591805e-01f, -8.86885375e-02f, 1.79318056e-01f, 2.65839230e-02f,
  -5.69959208e-02f, -7.64295682e-02f, -3.16999018e-01f, 1.02668539e-01f, 4.68768775e-01f, -3.90548371e-02f, -4.78254221e-02f, -9.09550190e-02f, 5.30289829e-01f, -1.23075962e-01f,
  -6.00920431e-03f, 8.68119299e-02f, 4.44316566e-02f, 4.14272118e-03f, 3.20512086e-01f, 4.00455445e-02f, -4.95064817e-03f, 1.32631972e-01f, 3.37430060e-01f, 1.89972073e-01f,
  2.17558667e-01f, 2.26285353e-01f, -1.14028633e-01f, -1.95453420e-01f, 7.59699792e-02f, 6.49371520e-02f, 1.25002772e-01f, -4.02276143e-02f, 1.05091622e-02f, 1.99372947e-01f,
  9.08050537e-02f, -3.32682192e-01f, -1.88765615e-01f, 1.38669163e-01f, -1.84822246e-01f, -6.24697804e-01f, 2.41033360e-01f, -4.27809693e-02f, -1.37093112e-01f, 1.94744855e-01f,
  6.30327538e-02f, -5.88505089e-01f, 2.32584909e-01f, 5.63407913e-02f, 2.72399127e-01f, 5.06188162e-02f, 3.60465527e-01f, 2.17954934e-01f, -3.50213856e-01f, 3.56872886e-01f,
  1.10530436e-01f, -3.36122781e-01f, -7.96503201e-03f, -2.61539258e-02f, 8.04446936e-02f, 1.08478047e-01f, 2.26968750e-01f, -1.13994926e-02f, -1.78860426e-01f, 7.61673972e-02f,
  2.11364642e-01f, 3.32143642e-02f, -1.24384552e-01f, 1.68501332e-01f, 3.35499287e-01f, -3.44344899e-02f, 2.69220978e-01f, 3.86068165e-01f, -2.28907838e-01f, 5.16005516e-01f,
  5.22217564e-02f, 9.56151113e-02f, 4.17564251e-02f, 4.77857590e-01f, -9.58804861e-02f, 1.23592719e-01f, 2.23861873e-01f, -9.46531668e-02f, -1.15787536e-01f, -5.14998548e-02f,
  3.48196119e-01f, -2.34719917e-01f, -1.27939209e-01f, 2.97524720e-01f, 1.24478497e-01f, 2.18110681e-01f, 2.17553988e-01f, 2.69714415e-01f, 2.78819382e-01f, 1.83153212e-01f,
  1.24588788e-01f, 5.41645214e-02f, -2.29325324e-01f, -9.15843770e-02f, 7.80384615e-02f, 8.78339857e-02f, -8.94792825e-02f, -1.82916313e-01f, -2.73334552e-02f, -1.03957087e-01f,
  2.59073615e-01f, -4.62341905e-01f, 2.24643737e-01f, 4.67386812e-01f, 6.67004883e-02f, -2.89117843e-01f, 4.71560210e-01f, 4.60893393e-01f, 7.03884885e-02f, 3.73473406e-01f,
  4.46002841e-01f, -3.81023251e-02f, -1.64126307e-01f, 3.75597090e-01f, 8.84598345e-02f, -6.97508827e-02f, 1.52618170e-01f, -1.29190013e-01f, -2.07182497e-01f, -3.32568616e-01f,
  -2.48663668e-02f, 1.13080190e-02f, 1.28619298e-01f, -2.74199136e-02f, -1.59555137e-01f, 3.65875848e-02f, -1.88214220e-02f, 1.89765692e-01f, 9.98953134e-02f, 1.88741907e-02f,
  4.74802554e-01f, -8.87257829e-02f, -1.86937332e-01f, 2.73277164e-01f, -2.44139478e-01f, 3.63347501e-01f, -4.59404409e-01f, 6.85372129e-02f, 2.83194691e-01f, 1.10975802e-01f,
  2.69118160e-01f, -2.00767349e-02f, 2.49806330e-01f, 2.33682036e-01f, -8.05102214e-02f, 6.26442358e-02f, -2.58291215e-01f, -4.71847415e-01f, 2.00566635e-01f, -3.25011685e-02f,
  8.96672010e-02f, 1.48262903e-01f, 1.14340439e-01f, 1.66650862e-01f, -1.43980021e-02f, 1.05740406e-01f, 1.53538018e-01f, 1.85306281e-01f, 1.41961202e-01f, -2.71436751e-01f,
  -3.18399996e-01f, 6.18176274e-02f, -2.06341580e-01f, -2.53852367e-01f, 3.30602080e-01f, -2.63285547e-01f, 6.61439523e-02f, -5.05567864e-02f, 4.64176774e-01f, -4.01360363e-01f,
  5.61130494e-02f, -3.43455225e-02f, 1.62155837e-01f, 7.24314377e-02f, 2.80860186e-01f, 3.78890820e-02f, -1.34615619e-02f, 2.86255956e-01f, 3.44822556e-01f, 1.14288181e-01f,
  -2.76787411e-02f, 1.00664727e-01f, 7.73335844e-02f, 1.61022976e-01f, 1.61228180e-01f, -8.20992142e-03f, 5.67713333e-03f, 2.23476127e-01f, 1.74939498e-01f, 1.38600215e-01f,
  -2.43748635e-01f, 1.18901156e-01f, 2.86811236e-02f, 9.47118849e-02f, 2.03604832e-01f, 2.20125809e-01f, 4.33704078e-01f, -2.30764300e-01f, 2.43348733e-01f, -2.09897131e-01f,
  4.58266854e-01f, 2.60056615e-01f, 1.90733761e-01f, 1.08622678e-01f, -2.10831285e-01f, 2.93763161e-01f, 2.04589188e-01f, -3.01478595e-01f, 3.05060893e-01f, -1.56028733e-01f,
  3.06028903e-01f, 3.58716637e-01f, 1.27437472e-01f, 3.87459338e-01f, 4.22583856e-02f, -1.74366198e-02f, 1.03272073e-01f, 7.41472691e-02f, 3.49225581e-01f, -1.02273919e-01f,
  -4.51214105e-01f, 2.38508899e-02f, -1.84243470e-01f, 1.97037354e-01f, 1.39577016e-01f, 1.05885074e-01f, 6.47951066e-01f, -2.91032437e-02f, 1.21186236e-02f, -4.74595904e-01f,
  3.88311297e-01f, 8.49187896e-02f, -2.91201293e-01f, 1.65771350e-01f, 4.44773763e-01f, 2.08841592e-01f, -1.38621584e-01f, 6.08187973e-01f, 6.29639998e-02f, 3.87758553e-01f,
  4.56846505e-01f, -5.50343655e-02f, -2.55742311e-01f, -1.50732100e-01f, -8.46095830e-02f, -1.79584101e-01f, -1.72745675e-01f, -2.78714120e-01f, -1.57831103e-01f, -1.84763119e-01f,
  -9.21459273e-02f, 5.95891438e-02f, 4.94650751e-01f, 1.69387117e-01f, -1.31474853e-01f, 2.37866402e-01f, 2.23420724e-01f, 1.57562479e-01f, -2.85401698e-02f, 2.97113031e-01f,
  1.21667786e-02f, 5.98787189e-01f, -1.98233947e-01f, -9.40134898e-02f, 2.70507038e-01f, 4.19206798e-01f, -1.26840040e-01f, -1.06553519e-02f, 2.99565107e-01f, 1.06030693e-02f,
  1.93098754e-01f, -7.54192919e-02f, 9.90740061e-02f, -6.19247928e-02f, 2.50776857e-01f, 1.63889065e-01f, 5.35808504e-01f, 2.98718691e-01f, -7.71906553e-03f, 1.23006471e-01f,
  1.28882691e-01f, -1.08675323e-01f, 2.19571497e-02f, -4.45041098e-02f, 1.37236252e-01f, -2.24098206e-01f, 6.06655702e-02f, 2.80243792e-02f, 1.38183892e-01f, -1.83009848e-01f,
  6.50423840e-02f, 3.95740747e-01f, -3.65438521e-01f, 6.32336378e-01f, 2.58327723e-01f, 5.76260611e-02f, 8.14324338e-03f, 2.02217966e-01f, -4.16493058e-01f, -2.46769831e-01f,
  -1.34307027e-01f, -9.75471586e-02f, -4.86340225e-01f, 1.84413254e-01f, 3.36930990e-01f, -2.30839640e-01f, 5.73744997e-02f, 3.51442903e-01f, -2.94953257e-01f, 2.23427519e-01f,
  2.31965154e-01f, 4.42148179e-01f, 2.14756891e-01f, -2.66651083e-02f, 6.38866946e-02f, -4.95551759e-03f, -1.77877873e-01f, -4.07114685e-01f, 2.39981815e-01f, 2.22516835e-01f,
  -4.06007558e-01f, -5.74576735e-01f, 6.35384768e-02f, 2.38641515e-01f, -3.01313162e-01f, 2.14523807e-01f, 7.66311824e-01f, 3.88553530e-01f, 1.52423263e-01f, -3.41623634e-01f,
  -2.21595258e-01f, -4.08315152e-01f, -4.87121530e-02f, 4.23839390e-01f, -4.99684736e-02f, 6.22311711e-01f, 5.71108997e-01f, -3.99475582e-02f, 1.35018080e-01f, 6.74596205e-02f,
  -2.06248894e-01f, 2.26732641e-01f, 1.78219285e-02f, -1.59851566e-01f, -1.87415645e-01f, 2.38369256e-01f, 1.69962347e-01f, -7.37244189e-02f, 1.89736649e-01f, -7.01312497e-02f,
  4.00469422e-01f, -2.82557070e-01f, -2.30713233e-01f, 1.56231940e-01f, -4.14268821e-01f, -1.00840040e-01f, 4.14118081e-01f, 2.84147216e-03f, -1.27835140e-01f, 2.14994922e-02f,
  4.87729073e-01f, -2.72592574e-01f, 1.74911782e-01f, 1.25330403e-01f, 3.45111191e-01f, -4.87189516e-02f, 3.02885234e-01f, 3.74591559e-01f, -8.34290907e-02f, 4.15027440e-01f,
  3.65700543e-01f, 2.29487360e-01f, 1.44949690e-01f, 2.38889027e-02f, -1.30709082e-01f, -4.40922119e-02f, -1.02968670e-01f, -1.92781672e-01f, -3.21065560e-02f, 6.19650856e-02f,
  1.95711359e-01f, 1.32740974e-01f, -1.24964401e-01f, 1.06869191e-01f, 1.50836155e-01f, 2.11789116e-01f, 1.27031982e-01f, 3.67509186e-01f, 1.11999273e-01f, 1.48505643e-01f,
  -1.18780002e-01f, -2.88647026e-01f, 1.26908511e-01f, 4.74599391e-01f, -1.23181246e-01f, 3.14854831e-01f, 8.63303170e-02f, 5.84516898e-02f, -7.26928487e-02f, -1.40178367e-01f,
  2.37687662e-01f, -1.58928260e-01f, 4.33470868e-02f, 2.34491214e-01f, 1.67371318e-01f, 3.24345827e-01f, 1.61372617e-01f, -5.69683239e-02f, -1.48469537e-01f, 1.25951141e-01f,
  3.70925963e-02f, 1.32219587e-02f, -5.19985799e-03f, -5.38006648e-02f, 2.07302541e-01f, -2.03862377e-02f, -2.97723621e-01f, -3.23928036e-02f, -3.42100978e-01f, -2.15972751e-01f,
  2.87586540e-01f, -2.33630985e-02f, 9.29905921e-02f, 2.89571315e-01f, 1.48233637e-01f, -1.74369693e-01f, 3.83027673e-01f, 1.80873767e-01f, 2.77017951e-01f, 2.77550429e-01f,
  4.64722127e-01f, 3.66987675e-01f, -6.40600100e-02f, 4.49972332e-01f, 2.74060965e-01f, -4.39491533e-02f, 2.55701840e-01f, -1.10077597e-01f, 3.28094572e-01f, 8.18054453e-02f,
  6.86709732e-02f, 2.04215556e-01f, -1.13599539e-01f, 6.00007270e-03f, -2.84018278e-01f, -4.04359341e-01f, 3.36412489e-01f, 7.85498098e-02f, -8.66748206e-03f, -3.73066723e-01f,
  -2.78617203e-01f, -5.58916666e-02f, -4.03146967e-02f, 2.55512327e-01f, 1.73196822e-01f, 5.96118152e-01f, -2.53398985e-01f, -1.22719601e-01f, 3.74071330e-01f, 3.43400002e-01f,
  3.07815284e-01f, -1.64390385e-01f, -2.37690851e-01f, 4.54686016e-01f, 8.33964646e-02f, 3.45144391e-01f, 1.71532720e-01f, 1.78917184e-01f, -1.52456790e-01f, -3.55626702e-01f,
  2.60557253e-02f, -2.13436961e-01f, -5.20471372e-02f, -3.09179183e-02f, 1.70680091e-01f, -8.50032046e-02f, 8.42626542e-02f, -4.07209322e-02f, 1.85898971e-02f, 1.02663547e-01f,
  3.90323162e-01f, 1.64022416e-01f, -2.64028281e-01f, 2.39868835e-01f, 2.47514397e-01f, 5.05185015e-02f, -5.50456643e-01f, 2.09419146e-01f, -1.35504961e-01f, 3.88045162e-01f,
  5.72790802e-01f, 7.89465189e-01f, 5.29417574e-01f, -1.57028615e-01f, 2.77372688e-01f, -2.22693771e-01f, -2.05802649e-01f, 4.28356737e-01f, 1.95590839e-01f, 1.29949659e-01f,
  1.66548535e-01f, -7.06603155e-02f, -7.54167186e-03f, 1.79273680e-01f, 1.37402453e-02f, -1.40622795e-01f, 4.70425449e-02f, 5.45905605e-02f, 2.70665139e-01f, 1.22301169e-01f,
  -2.77368784e-01f, 2.79933184e-01f, -3.18752527e-01f, -1.03346713e-01f, 4.24209774e-01f, 3.42201471e-01f, 1.35601848e-01f, 1.45541996e-01f, 2.87691772e-01f, -1.64836552e-02f,
  4.63464081e-01f, -8.78224447e-02f, -1.17240459e-01f, -3.68016481e-01f, -5.34672886e-02f, 5.93333840e-01f, 4.23745453e-01f, 9.80707258e-02f, 3.22666705e-01f, -1.98845550e-01f,
  4.55951661e-01f, -2.38287132e-02f, 3.74142230e-01f, 4.78602737e-01f, 3.19706380e-01f, 2.78784573e-01f, 1.03389628e-01f, 2.38421738e-01f, -1.15941659e-01f, 2.12013289e-01f,
  2.45272722e-02f, -2.61708409e-01f, 1.84540480e-01f, 7.80386627e-02f, 2.82871306e-01f, -1.09929331e-01f, -2.74762392e-01f, 1.51783094e-01f, 7.28014633e-02f, 8.75180736e-02f,
  3.01329102e-02f, 1.48044422e-01f, 1.60768196e-01f, 4.64916497e-01f, 5.92793860e-02f, 3.06063861e-01f, 2.27421492e-01f, -3.04874897e-01f, -2.73689300e-01f, -1.05468124e-01f,
  2.98026204e-01f, 5.98589890e-02f, 4.53517362e-02f, 4.53677684e-01f, -1.67847916e-01f, -1.65253624e-01f, 4.26823124e-02f, 3.23761739e-02f, 5.67678176e-03f, 2.02872917e-01f,
  9.45968181e-02f, 1.28197610e-01f, 1.97368458e-01f, -3.84957820e-01f, 1.81556910e-01f, 3.87348413e-01f, 1.04013376e-03f, -3.88401181e-01f, -1.28383473e-01f, 3.47540706e-01f,
  -1.70392767e-01f, 4.47090060e-01f, 2.67271698e-01f, 4.71180648e-01f, -1.04793020e-01f, -1.43200293e-01f, 7.32618794e-02f, -1.37189731e-01f, -1.41683361e-02f, 2.74846461e-02f,
  -1.22323543e-01f, 3.78890783e-01f, 9.44561064e-02f, 2.05534011e-01f, -3.74954194e-02f, 2.73773760e-01f, 1.80057421e-01f, 9.19380561e-02f, 1.08581102e-02f, -1.40041724e-01f,
  2.28044782e-02f, 3.81518491e-02f, 1.25223473e-01f, 8.87049958e-02f, -1.47360951e-01f, 4.01769310e-01f, -2.93621421e-01f, -1.58066247e-02f, 3.42193216e-01f, 4.33723360e-01f,
  5.38720965e-01f, 1.26547411e-01f, 1.04482532e-01f, -2.18748689e-01f, -7.13496134e-02f, -2.74292201e-01f, 2.81963050e-02f, 4.69240278e-01f, 4.12933022e-01f, 4.42072481e-01f,
  1.52159482e-01f, 2.71750182e-01f, 5.56039810e-02f, -1.97672889e-01f, 3.69977534e-01f, -1.90013349e-01f, -1.72865555e-01f, 1.73201382e-01f, 1.12018593e-01f, 1.24571867e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  3.56760398e-02f, -7.81667419e-03f, 6.45937622e-02f, 2.70463750e-02f, 8.13692883e-02f, 4.15031649e-02f, 7.39158764e-02f, 2.45306075e-01f, 2.55219378e-02f, 3.50651890e-02f,
  1.04151286e-01f, 5.52085713e-02f, -6.53545782e-02f, -1.40021220e-02f, 2.01155648e-01f, 1.88258156e-01f, 5.74412718e-02f, 2.12970406e-01f, 1.70005754e-01f, 1.04231685e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.08345637e-01f, 1.76827863e-01f, 1.03438810e-01f, -2.00548798e-01f, 1.74427420e-01f, -2.43007809e-01f, -1.81158930e-01f, 1.07324189e-02f, -7.07001984e-02f, -2.80043691e-01f,
  4.19209525e-02f, 2.75356532e-03f, 1.58103123e-01f, 5.12700617e-01f, -4.28888053e-01f, 1.32094294e-01f, -3.00567269e-01f, 3.38154316e-01f, 5.38845696e-02f, -5.35778940e-01f,
  -1.15340911e-01f, -8.64468291e-02f, -8.47535849e-01f, 1.81909099e-01f, -1.99641466e-01f, 1.28349990e-01f, -2.22171143e-01f, 1.79878995e-01f, -1.33947343e-01f, -3.80938649e-02f,
  -5.41525364e-01f, -8.17716271e-02f, 6.64011016e-02f, -2.31897295e-01f, -2.91690856e-01f, 3.46202739e-02f, 1.17617831e-01f, 2.97439575e-01f, 2.07408458e-01f, 1.62455365e-01f,
  -2.90753007e-01f, 6.52679009e-03f, 2.99650967e-01f, 2.85790693e-02f, 2.02839091e-01f, -6.85839236e-01f, -9.32497978e-02f, -1.69567570e-01f, -1.08190022e-01f, -2.33276814e-01f,
  1.72927439e-01f, -3.99885066e-02f, 2.70002693e-01f, -7.20197022e-01f, -7.31176794e-01f, 7.01627582e-02f, 3.64125103e-01f, 2.03821585e-02f, -5.10253489e-01f, 3.62396687e-01f,
  7.71761984e-02f, -9.61639732e-02f, -1.92004293e-01f, 1.65963352e-01f, -2.49402851e-01f, -1.61418542e-01f, -2.66869307e-01f, 6.36638179e-02f, -2.56184667e-01f, 2.00679198e-01f,
  1.73002779e-01f, -6.67024255e-02f, -6.58321008e-02f, 2.75564939e-01f, 1.52330220e-01f, -8.28562155e-02f, -4.31249470e-01f, -2.90314872e-02f, 4.68396515e-01f, -5.92533529e-01f,
  -1.74413875e-01f, -3.37201208e-01f, 3.65115032e-02f, -4.65008646e-01f, 2.40121350e-01f, 1.97955668e-01f, -3.96228284e-01f, -4.06098723e-01f, 3.33224863e-01f, -5.84470987e-01f,
  -1.28202941e-02f, 2.07224295e-01f, -1.79793090e-01f, 3.16371083e-01f, -7.77972415e-02f, 1.77059308e-01f, 2.44061306e-01f, -2.77325436e-02f, 1.12127006e-01f, 1.28818646e-01f,
  2.66121142e-02f, 2.17336833e-01f, 1.80077031e-01f, -3.68589073e-01f, 1.92926973e-01f, -1.63440570e-01f, 1.82550713e-01f, -3.19799006e-01f, -1.34559438e-01f, 6.26186550e-01f,
  -6.60842657e-01f, 2.70063877e-01f, 3.99965942e-01f, -1.07831992e-01f, -6.51974857e-01f, 1.75296456e-01f, -6.08160615e-01f, -1.54882167e-02f, -4.00892466e-01f, 4.31144126e-02f,
  -2.12373257e-01f, 9.91685316e-02f, 9.69017223e-02f, 3.25078100e-01f, -6.95427656e-01f, -4.71248388e-01f, -2.89239194e-02f, -1.38912395e-01f, 3.79915722e-02f, 2.60535777e-01f,
  -6.40556738e-02f, 3.91031317e-02f, -1.46697298e-01f, -1.41389668e-01f, -2.93900698e-01f, -4.15329814e-01f, 2.85575539e-01f, -1.20384976e-01f, -3.72009695e-01f, 3.41352433e-01f,
  8.16791505e-02f, -6.04094639e-02f, -4.70338106e-01f, 1.91831425e-01f, -6.68767512e-01f, 1.42774671e-01f, -7.82194436e-02f, 2.45218761e-02f, -6.49770081e-01f, -4.53363389e-01f,
  3.20895761e-01f, 1.35898992e-01f, -3.02185684e-01f, 2.48724505e-01f, 3.66859823e-01f, -6.82307109e-02f, -3.00016582e-01f, 2.18114942e-01f, 1.27160950e-02f, -3.63850594e-01f,
  -4.50661555e-02f, -3.19454461e-01f, 2.55309582e-01f, 1.26585901e-01f, -2.57792085e-01f, -2.82494932e-01f, -3.58486444e-01f, 7.56798778e-03f, 4.34879690e-01f, -1.68066218e-01f,
  -2.79593915e-01f, 2.80133709e-02f, 1.47939086e-01f, -2.05557525e-01f, -1.35719836e-01f, 1.48373157e-01f, -2.43592247e-01f, 2.73148060e-01f, 2.72458494e-01f, -2.09757239e-01f,
  -4.24985476e-02f, -5.24800956e-01f, 9.85236987e-02f, -4.06822413e-02f, -1.09692171e-01f, 2.38512754e-02f, -4.21695322e-01f, -4.30173934e-01f, 3.70664150e-01f, -4.03236330e-01f,
  -2.21535154e-02f, -1.92918897e-01f, -1.82514898e-02f, -1.77604124e-01f, 1.70295537e-01f, -3.84472758e-02f, 1.40494257e-01f, -2.29777589e-01f, 9.15886760e-02f, -1.43496573e-01f,
  1.89396949e-03f, -7.93735012e-02f, -4.13152725e-02f, 4.72822636e-02f, 2.88503449e-02f, -8.76566686e-04f, 3.05821419e-01f, -5.40278971e-01f, -2.78417289e-01f, -4.71798360e-01f,
  4.00590599e-02f, -1.48242965e-01f, 3.17813866e-02f, 4.23192680e-01f, 3.09951574e-01f, -4.83333945e-01f, 1.71713665e-01f, -6.27455354e-01f, -4.51182097e-01f, -6.58505917e-01f,
  1.16177425e-01f, -9.86922532e-02f, 1.20200835e-01f, -1.41376749e-01f, -1.33580372e-01f, 2.82903109e-02f, -1.15177438e-01f, -1.77225053e-01f, -8.00291821e-02f, -1.02481149e-01f,
  -1.19973868e-01f, -1.48003325e-01f, 1.73761055e-01f, -9.28458795e-02f, 3.59042585e-01f, 1.14436470e-01f, -1.10169537e-01f, 1.24787822e-01f, 2.37792227e-02f, -9.64815393e-02f,
  3.40314209e-01f, -2.12763891e-01f, -4.95042622e-01f, -4.92506117e-01f, 3.75336230e-01f, -2.32836604e-01f, -2.73609627e-02f, 9.58646238e-02f, -2.20810130e-01f, 2.70522594e-01f,
  2.05250099e-01f, 1.04257695e-01f, -6.50120676e-02f, -3.37816745e-01f, 2.82443970e-01f, -5.31842113e-01f, 1.34689584e-01f, 2.61518240e-01f, 2.49430940e-01f, -1.41028360e-01f,
  2.18471542e-01f, -1.26646772e-01f, -1.17774010e-01f, 7.18133226e-02f, -7.21026631e-03f, 2.00584203e-01f, 3.16071332e-01f, -3.51671487e-01f, -3.06422263e-01f, -1.69976428e-02f,
  1.56494647e-01f, -3.58531952e-01f, 2.71745265e-01f, -2.60954946e-01f, 1.16391726e-01f, 6.03611648e-01f, -1.94161028e-01f, -1.90298095e-01f, -2.68773258e-01f, -4.06346709e-01f,
  2.38252478e-03f, -4.23323065e-01f, -4.41310406e-01f, -5.27827740e-01f, -7.23608583e-02f, -3.54880132e-02f, -4.16295648e-01f, 5.02767503e-01f, 1.21424258e-01f, 1.32971346e-01f,
  -8.01593661e-02f, -2.28224650e-01f, -8.86782482e-02f, -1.61989272e-01f, -4.43758965e-02f, 3.94226909e-01f, 1.05790026e-01f, -2.93852270e-01f, -2.41426393e-01f, 8.97150710e-02f,
  2.35116109e-01f, -5.95899940e-01f, -5.50602823e-02f, -3.27607453e-01f, -3.69844586e-01f, 1.22793904e-02f, -1.22836746e-01f, -8.17841947e-01f, -3.80678624e-02f, 2.41840780e-01f,
  2.94525832e-01f, 2.12400600e-01f, -1.94761977e-01f, -9.00121927e-02f, 1.66341215e-01f, -3.72590482e-01f, -9.14576128e-02f, 3.14835817e-01f, 4.18658167e-01f, -6.79187179e-01f,
  -1.86037242e-01f, 1.13149337e-01f, -1.06158897e-01f, -5.06215617e-02f, 4.31309976e-02f, -2.47805621e-02f, 1.92804277e-01f, 3.49265277e-01f, -2.90935338e-01f, 2.00873718e-01f,
  -1.63318068e-01f, -2.07083523e-01f, 6.13308337e-04f, -6.00397348e-01f, 1.33119270e-01f, 2.77094185e-01f, 1.28648272e-02f, -4.98299599e-01f, -4.95983660e-02f, 5.18701263e-02f,
  -2.40196779e-01f, -4.12435472e-01f, -4.26007360e-01f, -3.13602448e-01f, -1.93124026e-01f, -8.38156939e-02f, 2.82115430e-01f, 3.27868611e-01f, -6.53683662e-01f, 5.08322954e-01f,
  1.89659581e-01f, 2.63930559e-02f, 1.49561703e-01f, 9.21802521e-02f, 1.17579382e-02f, -1.89047251e-02f, -1.31381720e-01f, 2.56688893e-01f, 1.99159622e-01f, 2.54422665e-01f,
  2.83068478e-01f, 2.02816799e-01f, -2.53114283e-01f, -2.67271668e-01f, -5.45433223e-01f, -1.82931751e-01f, -3.23024482e-01f, 2.26442307e-01f, 1.12332359e-01f, -3.94836813e-01f,
  -6.72890246e-02f, 4.11820382e-01f, -4.81023788e-01f, -2.75370348e-02f, 4.44308937e-01f, -5.25605142e-01f, -4.44284439e-01f, 2.29814667e-02f, 1.28620803e-01f, -2.52674013e-01f,
  2.51728773e-01f, -3.49742979e-01f, 6.83700591e-02f, -2.80465901e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.69471696e-02f, -1.31648853e-01f, 6.86288998e-02f, -1.45252377e-01f, 5.00155948e-02f, 1.39804287e-02f, 3.33094187e-02f, -8.22778121e-02f, 1.52986512e-01f, -7.94801116e-02f,
  2.29441784e-02f, -2.71670111e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    