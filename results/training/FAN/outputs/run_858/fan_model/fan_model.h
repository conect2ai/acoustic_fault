/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.85652947e-01f, 1.67047754e-01f, 1.79246627e-02f, -1.62042812e-01f, 2.56400049e-01f, 1.40316755e-01f, 1.83129925e-02f, -3.30207124e-02f, 1.77241005e-02f, 9.61254016e-02f,
  1.93031490e-01f, 1.33402813e-02f, -9.31169763e-02f, 5.71614876e-02f, -2.00858027e-01f, -3.83109711e-02f, -7.78098106e-02f, -9.75188464e-02f, -1.37217477e-01f, 8.11501686e-03f,
  -4.04584082e-03f, -9.10467878e-02f, -1.83426127e-01f, 4.03977148e-02f, 1.08119555e-01f, -8.69035348e-03f, 1.08305506e-01f, 1.58401012e-01f, 1.29353330e-01f, 5.25856204e-02f,
  2.07989216e-01f, -1.61478203e-02f, -9.02771056e-02f, -8.73177871e-02f, 1.11107424e-01f, -1.19671777e-01f, -4.33153324e-02f, -3.20342705e-02f, -4.43101451e-02f, 3.13537158e-02f,
  -5.22879660e-02f, -5.64511456e-02f, -1.46395370e-01f, 6.94196075e-02f, 8.78828242e-02f, -1.00156823e-02f, 3.16162109e-02f, 2.52502915e-02f, 3.98456678e-02f, 1.40310125e-02f,
  1.06119640e-01f, 6.86089769e-02f, -6.35436252e-02f, 4.41646799e-02f, -2.70613283e-03f, -6.12204261e-02f, 1.31626844e-01f, -2.70085298e-02f, 1.73951611e-02f, 1.32259369e-01f,
  -7.97391776e-03f, -2.84922920e-04f, 3.43339443e-02f, -4.25019823e-02f, 1.98976360e-02f, 1.07043581e-02f, -1.30176265e-02f, 5.03588095e-02f, -2.53871437e-02f, 1.61939524e-02f,
  -4.10224348e-02f, 4.15022857e-02f, -2.80140378e-02f, -2.62228567e-02f, 4.73643243e-02f, 4.71574673e-03f, 3.70159931e-02f, 4.55969274e-02f, 8.03597420e-02f, -4.83026020e-02f,
  -1.22874305e-02f, 1.98719278e-02f, -1.88791491e-02f, 2.25682575e-02f, -4.99410704e-02f, -2.51775584e-03f, 3.51651572e-02f, 2.02174042e-03f, 2.45208349e-02f, -1.02231286e-01f,
  -3.98902483e-02f, -7.46148080e-02f, -7.63642341e-02f, -3.81214209e-02f, 3.16041484e-02f, -7.94567633e-03f, 2.42441129e-02f, 8.12390894e-02f, -1.70508008e-02f, 4.55649719e-02f,
  -2.40340945e-03f, -2.66287848e-02f, 7.59442598e-02f, 2.82696951e-02f, -3.41812596e-02f, -5.19237444e-02f, 2.08858401e-02f, -7.75654521e-03f, -6.15793280e-03f, 6.84345961e-02f,
  1.07469503e-04f, -7.93838724e-02f, -1.09841131e-01f, 5.56225479e-02f, -4.59303521e-03f, -1.01266511e-01f, 3.70807238e-02f, 1.21030577e-01f, -1.67983204e-01f, -6.29814863e-02f,
  3.21292371e-01f, 1.06358975e-01f, 9.00197178e-02f, 2.81877458e-01f, -2.53762394e-01f, -2.52393708e-02f, 1.40620098e-01f, 2.12564200e-01f, 1.20314240e-01f, 1.16191879e-01f,
  -3.26463193e-01f, -2.45956019e-01f, -1.57696575e-01f, -9.80424508e-02f, 1.13204658e-01f, 2.69599706e-01f, 3.37452829e-01f, 1.66905448e-01f, 9.42013636e-02f, -2.15766951e-01f,
  -1.17683701e-01f, 1.04849599e-01f, 1.51061520e-01f, 3.74892801e-02f, 9.04091541e-03f, -1.15844510e-01f, 3.17107923e-02f, -1.04821205e-01f, -2.53270775e-01f, 3.43760289e-02f,
  -1.86298117e-01f, 1.03469707e-01f, -2.43425593e-02f, -8.78126994e-02f, 3.02936584e-02f, 1.28733978e-01f, 3.91767211e-02f, 5.42287193e-02f, 2.70599872e-02f, 8.73876810e-02f,
  -1.48497760e-01f, -1.66273758e-01f, 4.52456437e-02f, -4.09954637e-02f, -8.68476555e-03f, 8.42118487e-02f, 1.42638728e-01f, 1.28286377e-01f, 1.49647772e-01f, 2.35221628e-02f,
  -1.89990610e-01f, -1.45567924e-01f, -1.40745506e-01f, 8.34675357e-02f, 2.32554488e-02f, -5.29439896e-02f, -8.31007808e-02f, 3.25973183e-02f, 2.30139270e-02f, 5.68207018e-02f,
  4.38819528e-02f, -8.15781951e-03f, 4.71137092e-03f, 3.64741869e-02f, 1.97553411e-02f, -2.76654605e-02f, 1.06568597e-02f, -8.22185352e-02f, 3.61858495e-02f, 4.53280546e-02f,
  -2.27187923e-03f, 4.34667841e-02f, -4.90244403e-02f, 1.88497268e-02f, -5.13148829e-02f, 3.41668352e-02f, -9.64877894e-04f, 6.09816350e-02f, -4.10959087e-02f, -3.91720906e-02f,
  5.79532934e-03f, -8.76323041e-03f, -1.35941803e-02f, 5.58296181e-02f, 5.14071062e-02f, -6.28938060e-03f, -2.78490013e-03f, 1.34910801e-02f, -4.66818660e-02f, -8.24117009e-03f,
  3.82094979e-02f, 8.56484100e-03f, -4.68023978e-02f, -8.09440538e-02f, -7.06708729e-02f, -2.21814699e-02f, -4.43662517e-02f, -2.70905290e-02f, -3.86319123e-02f, -1.31717362e-02f,
  1.18397884e-02f, 7.93833435e-02f, -8.58023986e-02f, 6.36415556e-03f, 3.45332101e-02f, 2.65863966e-02f, -9.31814164e-02f, -5.42048365e-02f, -5.18562552e-03f, 4.73908521e-02f,
  6.00836575e-02f, -7.46302586e-03f, 3.32239568e-02f, 2.51967795e-02f, -7.08984062e-02f, 5.64605668e-02f, 7.04952478e-02f, 1.52740702e-02f, 1.07149526e-01f, 2.13865966e-01f,
  -2.24389195e-01f, -3.62294801e-02f, 3.64067674e-01f, -2.12068051e-01f, 4.68204282e-02f, -1.30143613e-01f, -6.01383075e-02f, -1.29582465e-01f, -1.29906058e-01f, 4.52298746e-02f,
  3.70558128e-02f, -2.31084034e-01f, -5.00064902e-02f, 3.69898230e-02f, -2.83455271e-02f, 7.17679933e-02f, 1.82718366e-01f, 2.26272583e-01f, -2.55444907e-02f, -1.23983636e-01f,
  -5.07909916e-02f, -3.40924338e-02f, 6.50622100e-02f, -4.32590246e-02f, 9.50352028e-02f, -2.26902962e-01f, 2.00768456e-01f, 2.46348575e-01f, 7.52928779e-02f, 4.02543575e-01f,
  2.54088193e-01f, 1.05763264e-01f, -1.58234462e-02f, -1.05236769e-01f, 9.15640667e-02f, 3.87547947e-02f, -9.73691195e-02f, 1.86508633e-02f, 5.73437773e-02f, 1.11622466e-02f,
  4.31972044e-03f, -1.34757617e-02f, 2.36853119e-02f, 2.28769314e-02f, 3.80943939e-02f, 1.67188048e-02f, 8.96111354e-02f, 1.41659439e-01f, 6.12742752e-02f, 1.42124251e-01f,
  6.10834174e-02f, 1.10870577e-01f, 1.19486317e-01f, 3.21818814e-02f, 1.31361127e-01f, 5.10940142e-02f, 9.92894396e-02f, 8.22035745e-02f, 2.13563025e-01f, 1.27341717e-01f,
  1.70850977e-02f, 9.65174753e-03f, -9.77462716e-03f, -1.64111126e-02f, -1.47404391e-02f, -6.87748715e-02f, 3.89154740e-02f, -2.15029828e-02f, -2.10417211e-02f, -6.20046854e-02f,
  1.26965463e-01f, -4.76207472e-02f, 1.94032211e-02f, -4.18245643e-02f, 1.97318159e-02f, 2.57667620e-02f, -9.57508851e-03f, -5.55455834e-02f, 2.08640788e-02f, -5.64743318e-02f,
  -2.62088366e-02f, 5.81573471e-02f, -5.62251881e-02f, 5.01719987e-05f, 1.80032235e-02f, 4.76696268e-02f, 4.08102060e-03f, -1.33313052e-03f, -1.65934246e-02f, 9.52780917e-02f,
  -2.70662338e-01f, 3.09705697e-02f, -7.35414550e-02f, 2.92805266e-02f, -6.21084422e-02f, -4.68892343e-02f, 1.64539292e-02f, 5.40752411e-02f, 1.22967456e-02f, 3.08742048e-04f,
  -1.81530099e-02f, -5.61054461e-02f, 2.30774470e-03f, 7.12187663e-02f, -8.79173279e-02f, 3.04845683e-02f, -9.42111667e-03f, -5.85093759e-02f, 1.75443739e-02f, -9.40173194e-02f,
  -5.73462099e-02f, -1.89164683e-01f, -2.15461850e-01f, -6.72542378e-02f, -3.07953991e-02f, -2.34253228e-01f, -5.83897606e-02f, -7.75861889e-02f, -1.08395942e-01f, -3.18084776e-01f,
  -2.89817631e-01f, 1.95372894e-01f, 1.48406804e-01f, -1.93587273e-01f, 1.12762399e-01f, 2.01630861e-01f, 5.27331531e-01f, 4.00859043e-02f, -1.85902372e-01f, 1.81753889e-01f,
  1.25086412e-01f, -1.64908752e-01f, -3.11824381e-02f, -1.18909270e-01f, 9.03658941e-02f, 2.03854572e-02f, 1.45292044e-01f, -1.05135955e-01f, 7.47731477e-02f, 4.78508100e-02f,
  1.94573905e-02f, 4.47106734e-02f, -1.09193213e-01f, -1.04073837e-01f, -2.55666338e-02f, -2.71088868e-01f, -2.24499088e-02f, 2.37081740e-02f, -3.92014012e-02f, -8.02418813e-02f,
  -4.31622518e-03f, 8.53855535e-02f, -2.21631601e-02f, -4.11503240e-02f, 3.54040787e-02f, 3.54874693e-02f, 8.33570734e-02f, -1.28857717e-02f, 1.91153046e-02f, -1.21563710e-02f,
  5.52256815e-02f, 5.97222801e-03f, 5.26240431e-02f, 5.63108316e-03f, 1.38293311e-01f, 5.11024753e-03f, -1.10470675e-01f, -8.31582304e-03f, -5.98340631e-02f, -9.76373150e-04f,
  -7.64803635e-03f, 6.01627640e-02f, 1.16600968e-01f, 2.28593424e-02f, 8.28647316e-02f, 1.13774709e-01f, 1.41930841e-02f, 1.13173053e-01f, 6.86445385e-02f, -1.44997761e-01f,
  7.35145360e-02f, 6.96385186e-03f, 1.11528039e-02f, 3.07814050e-02f, -3.84594277e-02f, -1.64936744e-02f, 7.00515360e-02f, -8.78783166e-02f, 2.14160867e-02f, -3.85833271e-02f,
  1.44628488e-04f, 6.89883763e-03f, -2.47205496e-02f, 2.00570654e-02f, -2.37757768e-02f, 2.91975569e-02f, -1.49356453e-02f, -8.18586648e-02f, 3.90128642e-02f, 4.23444668e-03f,
  -4.96891811e-02f, -3.09365280e-02f, -3.17627043e-02f, -8.77988350e-04f, 3.83957895e-03f, 1.67002473e-02f, -4.75949496e-02f, 6.45545274e-02f, 8.81592184e-03f, 5.71223609e-02f,
  -2.54713386e-01f, 1.75638959e-01f, -9.07998160e-02f, -1.48735810e-02f, -1.67663384e-03f, -1.12621263e-02f, -6.33560941e-02f, 1.85826365e-02f, -1.86113026e-02f, 1.14332670e-02f,
  -1.24848429e-02f, 2.89587807e-02f, -4.86461520e-02f, -3.78625989e-02f, -8.19107518e-03f, -1.36844339e-02f, 6.62166849e-02f, -5.80682494e-02f, 1.53038964e-01f, -4.32510339e-02f,
  -8.51739570e-02f, 3.64406928e-02f, -1.04561856e-03f, 1.07579362e-02f, -8.36956024e-04f, -1.16804941e-02f, 5.94593845e-02f, 9.25305486e-03f, 1.66270971e-01f, -1.36675656e-01f,
  1.98002577e-01f, 4.04607840e-02f, 3.18850093e-02f, 4.15243618e-02f, 1.93851572e-02f, 2.16531560e-01f, 1.29612222e-01f, 1.97253570e-01f, 1.29711106e-01f, -2.86850296e-02f,
  -6.29422143e-02f, 3.80250700e-02f, 4.59013842e-02f, 1.03228670e-02f, 2.17400774e-01f, 1.44916043e-01f, 7.73842260e-02f, 1.38661072e-01f, 1.25155658e-01f, -3.51798683e-02f,
  -5.02898283e-02f, 2.23437417e-02f, 5.72078899e-02f, 1.01176359e-01f, -1.70530695e-02f, 3.25982645e-02f, 3.17951441e-02f, -1.18085340e-01f, -1.23986937e-01f, 8.26728120e-02f,
  -7.10033625e-02f, 4.93515544e-02f, 1.83516461e-02f, -3.96108627e-02f, 1.26233166e-02f, 5.41568957e-02f, 2.06728186e-02f, 3.87771539e-02f, -7.38264099e-02f, 4.89573320e-03f,
  -4.17325199e-02f, -6.16190862e-03f, -2.99551431e-02f, 2.32539624e-02f, 4.08132300e-02f, 2.14743260e-02f, -5.73443361e-02f, 3.59734520e-02f, 3.45230438e-02f, -8.34103301e-02f,
  -1.49636967e-02f, -8.15576464e-02f, -1.01611011e-01f, -6.03443384e-02f, 5.22245765e-02f, 1.44525971e-02f, 1.49876960e-02f, 1.33415638e-02f, -3.52028087e-02f, 1.75971407e-02f,
  1.02100307e-02f, 1.27411515e-01f, 3.48699950e-02f, -4.42050286e-02f, -3.21475156e-02f, 1.79688470e-03f, -6.20352440e-02f, -2.03338149e-03f, 4.80942503e-02f, -8.11646634e-04f,
  -5.66885993e-02f, -4.95709963e-02f, 2.57278197e-02f, -4.95196283e-02f, -8.75478759e-02f, -9.52379033e-02f, 1.56666618e-02f, 1.82889327e-02f, 2.06528734e-02f, -2.30644047e-02f,
  -5.88948838e-02f, -6.65104464e-02f, 6.48233853e-03f, -5.57871126e-02f, -8.71372670e-02f, 2.29293853e-02f, -4.70491461e-02f, 2.24001110e-02f, 6.98934123e-02f, -7.32125267e-02f,
  7.94114321e-02f, 1.08628348e-01f, 1.43861309e-01f, -8.61258991e-03f, 7.25289807e-02f, 9.88014191e-02f, -4.12652232e-02f, 3.25498879e-02f, -4.82528098e-02f, -5.36004119e-02f,
  1.08923018e-01f, 1.22532388e-02f, 7.79888332e-02f, -2.10830700e-02f, 1.02295235e-01f, -1.09321855e-01f, 1.25848185e-02f, -9.83955488e-02f, -1.77715756e-02f, -8.69742855e-02f,
  -3.13078649e-02f, 7.58616626e-02f, 5.47535568e-02f, 6.87008500e-02f, 1.04503796e-01f, 9.25299004e-02f, -1.54868644e-02f, 3.98885459e-02f, 3.58932987e-02f, -5.37607237e-04f,
  -2.61362195e-01f, 5.18151633e-02f, 1.28822193e-01f, -1.63878188e-01f, 2.23635674e-01f, 9.82968062e-02f, 1.58138245e-01f, 7.34950751e-02f, 5.23028895e-02f, 7.69077614e-02f,
  5.60416207e-02f, 4.72680926e-02f, -3.19684483e-02f, 8.46600309e-02f, 7.72993267e-02f, 6.11446574e-02f, 6.59266412e-02f, -2.94636600e-02f, 1.54163071e-03f, 1.16758347e-01f,
  -3.86707969e-02f, -5.50971963e-02f, -1.03132926e-01f, -9.30297971e-02f, 6.84876740e-02f, -8.15772861e-02f, 4.20825742e-02f, -5.46539649e-02f, 6.12401851e-02f, 8.93166810e-02f,
  1.54766768e-01f, 7.32379854e-02f, -5.77445421e-03f, -5.78480177e-02f, 3.83416936e-02f, 4.60177846e-02f, 1.08656153e-01f, 6.44639740e-03f, 3.33280303e-02f, -3.18799615e-02f,
  1.03840701e-01f, -1.82502270e-02f, -1.20547204e-03f, -4.48399931e-02f, -9.79193151e-02f, -2.36612596e-02f, -6.14513867e-02f, -1.24312028e-01f, -1.96574908e-02f, 4.98351315e-03f,
  7.88111761e-02f, -3.29026431e-02f, 7.44621158e-02f, 5.12339175e-02f, 5.73263131e-02f, -3.93077284e-02f, 2.36283019e-02f, 1.66693274e-02f, 2.20223796e-02f, 1.05992882e-02f,
  -3.90265509e-02f, 6.21651784e-02f, 6.11800514e-02f, -6.66015968e-02f, -5.00099361e-02f, 1.15563220e-03f, -5.74574806e-02f, -1.39768366e-02f, -2.75633228e-03f, -2.75671743e-02f,
  1.24150040e-02f, 9.42057837e-03f, 2.61433925e-02f, 5.22425361e-02f, -6.44199774e-02f, -8.69900174e-03f, -7.61920065e-02f, 1.14147710e-02f, 6.16654605e-02f, -6.42217696e-02f,
  9.48867667e-03f, -5.62752225e-03f, 4.71140072e-02f, -4.72148471e-02f, 2.58230250e-02f, -1.24604665e-02f, -5.68963289e-02f, 3.96295488e-02f, 7.78530836e-02f, -8.13761540e-03f,
  -1.13011412e-01f, 1.30430996e-01f, 1.44210204e-01f, -2.07228884e-02f, -9.44437459e-03f, 3.65860425e-02f, 6.67821057e-03f, -4.86389920e-02f, -2.23927889e-02f, 1.37597537e-02f,
  4.68750075e-02f, -3.82704437e-02f, 3.18236463e-02f, -3.64640797e-03f, 4.96560931e-02f, 3.43265496e-02f, -1.34631926e-02f, -6.65678307e-02f, 2.24157311e-02f, 6.70599192e-02f,
  7.89332092e-02f, -1.47553394e-03f, -4.78734970e-02f, -3.63970548e-02f, 6.43459633e-02f, -1.26721282e-02f, 3.79729420e-02f, -6.52538314e-02f, -6.93838298e-02f, -1.07594607e-02f,
  4.44754034e-01f, 1.18315518e-01f, -9.04255062e-02f, 6.58167824e-02f, 2.02275097e-01f, -2.03687593e-01f, 6.40325770e-02f, -8.83815587e-02f, -9.14684460e-02f, 9.48255360e-02f,
  9.49682295e-02f, -3.50871822e-03f, -1.02006122e-01f, -8.23945701e-02f, -4.49979939e-02f, 2.24123336e-02f, 1.38691021e-02f, -3.07523217e-02f, -2.70828515e-01f, -5.79528548e-02f,
  8.90639573e-02f, 3.36187452e-01f, 1.43848211e-01f, -8.62208903e-02f, 9.51117575e-02f, -2.04633713e-01f, 1.04759596e-01f, 1.70624852e-01f, 6.44778758e-02f, 4.38249111e-01f,
  1.30608112e-01f, 1.74182072e-01f, -7.22722039e-02f, 6.15884624e-02f, 8.30769688e-02f, -2.48489622e-02f, -4.13994677e-02f, -1.54351145e-02f, -6.05008714e-02f, -3.10046729e-02f,
  8.28509703e-02f, 6.65940493e-02f, 7.90042654e-02f, 2.41676532e-02f, 2.44002584e-02f, -3.41403391e-03f, -1.57665983e-02f, -5.64543530e-03f, -8.47553089e-02f, -1.18056074e-01f,
  -1.33818500e-02f, 1.64103299e-01f, 1.30959172e-02f, -8.04175586e-02f, -2.72581100e-01f, -2.92836726e-02f, 2.48359218e-02f, -1.30646843e-02f, 4.03711125e-02f, 2.33259678e-01f,
  -6.82855099e-02f, 2.73501482e-02f, 4.30142060e-02f, 1.92940666e-03f, -3.03601827e-02f, -2.47686580e-02f, -6.88406033e-03f, 2.47024409e-02f, -6.17372692e-02f, 3.60999778e-02f,
  -2.60376912e-02f, -6.50436804e-02f, 1.03643332e-02f, -5.41464128e-02f, -2.77318321e-02f, 6.93885684e-02f, -3.08994600e-03f, -2.02378388e-02f, -1.21468324e-02f, 3.77084278e-02f,
  -4.45689335e-02f, -2.75131073e-02f, 3.70620601e-02f, -3.52002531e-02f, 6.00027032e-02f, 1.29053397e-02f, -2.12589614e-02f, 5.50788343e-02f, -3.67837921e-02f, 2.33398434e-02f,
  -7.96326473e-02f, -1.88705936e-01f, 7.95102194e-02f, 3.31335701e-02f, -6.34839833e-02f, 4.22493480e-02f, 2.38470398e-02f, 3.63598689e-02f, 4.38663214e-02f, 5.13103530e-02f,
  -3.50532867e-02f, -3.11256927e-02f, 1.63574573e-02f, 8.53803940e-03f, -3.21383961e-02f, -3.55342403e-02f, 5.09654656e-02f, -5.38437022e-03f, -7.92064145e-02f, 5.53391092e-02f,
  -9.66356248e-02f, -6.31451011e-02f, -6.86868280e-02f, -1.06208934e-03f, -1.55555205e-02f, -3.27123813e-02f, -5.72068803e-02f, 4.76773269e-02f, -1.40595615e-01f, -1.45717233e-01f,
  1.55141756e-01f, -1.53673768e-01f, -6.38385713e-02f, -2.54855901e-01f, -5.73425693e-03f, 3.67777199e-02f, -2.22386643e-02f, 9.87070892e-03f, -4.32156585e-02f, -6.90032775e-03f,
  -1.24033513e-02f, 1.37914702e-01f, 4.18303814e-03f, -1.75367408e-02f, 3.92474234e-03f, -7.01458454e-02f, -2.14995876e-01f, 5.31891845e-02f, 1.60238147e-01f, 1.67853966e-01f,
  -7.57061392e-02f, -1.39319235e-02f, -1.38208911e-01f, -1.03494331e-01f, -8.55578408e-02f, 1.52133763e-01f, -1.42698169e-01f, 3.46506797e-02f, 6.03716373e-02f, -1.06767043e-01f,
  3.65803450e-01f, -6.40259609e-02f, -8.43191985e-03f, -6.50702640e-02f, 1.41209941e-02f, 2.06933776e-03f, 6.89821243e-02f, 4.05281745e-02f, 8.22532699e-02f, -6.32409006e-02f,
  2.10605897e-02f, -1.09835733e-02f, -5.91487326e-02f, 5.79097541e-03f, -3.27817723e-02f, 3.15738805e-02f, 4.01147231e-02f, -4.64190729e-02f, 4.59643565e-02f, -7.14530982e-03f,
  3.57495062e-02f, -1.37730420e-01f, 8.01569223e-02f, 4.23470186e-03f, 7.64703974e-02f, 4.48623188e-02f, 2.57299934e-02f, -1.02493092e-01f, 8.20539370e-02f, 1.46161616e-01f,
  1.49052963e-01f, -1.01902299e-02f, 1.62517838e-02f, -9.65549611e-03f, 4.48106490e-02f, 4.86434018e-03f, 1.73113067e-02f, 4.86052930e-02f, -2.22290158e-02f, 5.36221126e-03f,
  3.18592116e-02f, 1.15345800e-02f, -2.51786169e-02f, -3.99203561e-02f, -4.44721989e-02f, -1.23394094e-02f, 5.68450149e-03f, -2.40280759e-02f, -4.04909700e-02f, -6.49609715e-02f,
  1.46701664e-01f, -1.10234814e-02f, 1.17971981e-02f, 3.65180038e-02f, -8.05375427e-02f, -3.37737389e-02f, -6.35063797e-02f, -5.32935448e-02f, 4.62888889e-02f, 2.60465275e-02f,
  6.76889867e-02f, -4.16070446e-02f, 3.07129994e-02f, -6.01852080e-03f, 4.39811498e-02f, 4.59480397e-02f, -2.65350100e-02f, 4.18345723e-03f, -5.10728714e-05f, 4.80822474e-02f,
  4.50325944e-03f, -2.02881526e-02f, -6.86106905e-02f, -4.54333164e-02f, -1.55177678e-03f, -2.78535346e-03f, -1.16079919e-01f, 7.63799921e-02f, -5.66991270e-02f, -1.01805523e-01f,
  -3.85367684e-02f, 8.84380341e-02f, 2.16395110e-01f, 1.67937860e-01f, 1.26060471e-01f, 1.55736342e-01f, 2.33328015e-01f, 1.33832423e-02f, 2.02401519e-01f, 1.20340914e-01f,
  -2.04042673e-01f, -1.20743796e-01f, -1.34860262e-01f, 1.23155877e-01f, 1.47430032e-01f, 2.21672039e-02f, -9.60411057e-02f, 5.81005141e-02f, 2.18494818e-01f, -1.65113881e-01f,
  1.20171845e-01f, 1.65490282e-03f, -1.48721695e-01f, -8.89022946e-02f, -9.07226503e-02f, -9.83556435e-02f, 5.36078624e-02f, -7.25477859e-02f, -2.89627835e-02f, 2.08495542e-01f,
  1.18510418e-01f, 5.70585020e-03f, 1.09576963e-01f, 1.00058928e-01f, -6.87994584e-02f, -2.12976292e-01f, -5.63804533e-05f, 1.42539471e-01f, -5.55518791e-02f, -2.32459933e-01f,
  -1.68467745e-01f, 9.12972838e-02f, -5.90084642e-02f, -1.96633656e-02f, 4.96296547e-02f, 3.34835574e-02f, -2.99220178e-02f, -3.08006611e-02f, 6.25292510e-02f, 1.00228610e-02f,
  6.46247938e-02f, 5.14238700e-02f, 2.43376102e-03f, 9.15558711e-02f, 6.59970269e-02f, 1.30685829e-02f, 1.13186210e-01f, -1.01950979e-02f, 3.72450729e-03f, 1.38690090e-02f,
  5.52980835e-03f, 2.32545182e-01f, -4.04591262e-02f, 1.59827024e-02f, 3.52950133e-02f, 1.47811756e-01f, 2.27606688e-02f, 4.61850241e-02f, -3.73984762e-02f, -1.28794834e-01f,
  6.42608777e-02f, -1.98991373e-02f, 1.09027876e-02f, -1.77223480e-03f, 4.10854630e-02f, -6.04717061e-02f, 1.18679565e-03f, -8.63894522e-02f, 3.28222930e-04f, -4.63811271e-02f,
  2.74395868e-02f, -6.43273175e-04f, 4.15566824e-02f, -6.67390898e-02f, -1.34875383e-02f, 1.19460383e-02f, 8.29146523e-03f, -4.26177110e-04f, -1.28638055e-02f, -2.47435309e-02f,
  -8.90866946e-03f, -4.04685289e-02f, 5.23958309e-03f, -1.11459466e-02f, 6.32941127e-02f, 3.03137619e-02f, 4.36569974e-02f, -1.59057472e-02f, -8.62861499e-02f, 9.63140279e-02f,
  -1.63896158e-01f, 1.16614982e-01f, -8.60925764e-02f, -5.14430851e-02f, -8.44225138e-02f, 1.52702266e-02f, -3.29234824e-02f, 1.20533165e-03f, 4.01201844e-02f, -3.97895724e-02f,
  -1.75671596e-02f, -2.01153979e-02f, -1.00482620e-01f, -1.50049580e-02f, -5.52708954e-02f, -2.56050769e-02f, -8.73441622e-02f, -1.25536546e-01f, 4.82715704e-02f, 9.26634297e-02f,
  -1.19176000e-01f, -1.89277187e-01f, -2.04393268e-01f, -1.70803562e-01f, 9.57360119e-02f, -8.04671869e-02f, -2.30464622e-01f, -1.21565253e-01f, -2.12626308e-01f, -4.71573710e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.72100618e-01f, 1.05512480e-03f, 3.16493679e-03f, -8.67565870e-02f, 5.81367835e-02f, 2.24849768e-02f, -5.98882064e-02f, 8.09215903e-02f, -1.16874047e-01f, 5.07029053e-03f,
  1.02480613e-01f, -6.70098420e-03f, 1.72999408e-02f, 4.12737653e-02f, -1.11876149e-02f, -9.64380428e-02f, -4.08133268e-02f, -4.60128859e-02f, 4.68353694e-03f, 4.98814695e-02f,
  7.82819837e-02f, -1.00599535e-01f, -4.63741226e-03f, -2.91896127e-02f, 8.61129463e-02f, 7.18825832e-02f, -1.12916634e-03f, -6.05739728e-02f, -5.28287962e-02f, 4.29965630e-02f,
  1.83386222e-01f, -6.72605932e-02f, 1.42559763e-02f, -1.02677889e-01f, -4.27326513e-03f, 3.17976736e-02f, 9.23930109e-02f, 2.03145873e-02f, 6.02814667e-02f, -5.39283901e-02f,
  -6.18757829e-02f, -2.55178567e-02f, -1.03116907e-01f, 7.86461085e-02f, 1.35174124e-02f, 5.17368969e-03f, -3.77448089e-02f, 4.48226258e-02f, -4.62455861e-02f, -5.09125218e-02f,
  6.98704971e-03f, -1.76736452e-02f, 2.90173907e-02f, 6.23808801e-02f, -7.77741969e-02f, 5.01477085e-02f, 5.88818789e-02f, 7.73655847e-02f, -2.99182031e-02f, -8.10585842e-02f,
  -9.58597753e-03f, -3.33431624e-02f, 5.21475300e-02f, -2.39474626e-04f, -5.89557067e-02f, -9.12295654e-02f, 5.48260845e-02f, -4.62622456e-02f, -6.76934272e-02f, -8.11366457e-03f,
  5.62073179e-02f, 3.04156709e-02f, 6.46074042e-02f, -8.08234140e-02f, -4.68013473e-02f, -2.82019302e-02f, -5.33305742e-02f, -1.98474014e-03f, -1.34166311e-02f, -1.11042023e-01f,
  -4.02187780e-02f, 2.59520207e-03f, -7.48528019e-02f, -1.91556830e-02f, -2.71046273e-02f, 5.53877279e-02f, -9.26797166e-02f, -3.82986963e-02f, 2.22560130e-02f, 6.65307045e-02f,
  6.46993369e-02f, 2.45632157e-02f, -7.68048614e-02f, 4.91918717e-03f, -9.56912618e-03f, 4.98719402e-02f, 7.83568770e-02f, 8.42460059e-03f, 3.78533714e-02f, 9.04566422e-02f,
  5.71034998e-02f, -7.23840445e-02f, 6.51391372e-02f, -8.36443231e-02f, 2.60598436e-02f, 2.60396227e-02f, -2.25544050e-02f, 4.32593971e-02f, -2.01281253e-02f, -4.65028360e-03f,
  -1.52590126e-02f, -5.72991595e-02f, 8.38769376e-02f, 6.79809377e-02f, -6.05679397e-03f, 5.84674105e-02f, 2.22167466e-02f, 4.67104726e-02f, 4.56423052e-02f, -7.90791586e-02f,
  -4.38135117e-01f, 3.07038635e-01f, -7.51552656e-02f, -2.84542772e-03f, 1.80172250e-01f, 2.54279822e-01f, 5.28334796e-01f, 1.99177966e-01f, 1.70870014e-02f, 4.20739986e-02f,
  8.55468363e-02f, -1.03613816e-01f, -5.48116565e-02f, -4.21026498e-02f, 1.75225705e-01f, 1.24594875e-01f, 2.34564424e-01f, -1.39135689e-01f, -1.87393785e-01f, -5.99628426e-02f,
  8.11309367e-02f, 3.22451890e-02f, -1.75617412e-01f, -3.78277451e-02f, 3.10400371e-02f, -1.38294458e-01f, 7.70935267e-02f, 4.48226854e-02f, -7.07859844e-02f, 2.96072401e-02f,
  -1.20998651e-01f, 6.96382970e-02f, -9.63184386e-02f, -1.11748330e-01f, -5.29047400e-02f, -1.16976537e-01f, -9.17448550e-02f, -7.12754251e-03f, -4.56047431e-02f, 4.55977097e-02f,
  1.03289910e-01f, -1.34536549e-01f, 1.94752753e-01f, 4.27702023e-03f, 1.75809991e-02f, 2.44774912e-02f, 1.24087790e-02f, -7.64706433e-02f, 8.55144986e-04f, -5.50923012e-02f,
  1.68394342e-01f, 3.99992205e-02f, 1.44540802e-01f, 9.37542021e-02f, 3.59057970e-02f, -1.28124118e-01f, 1.23805784e-01f, 4.15743552e-02f, 3.77237909e-02f, -1.06092319e-01f,
  -1.06089331e-01f, -5.39393947e-02f, 9.97230411e-02f, -4.48721647e-02f, -7.22042890e-03f, 4.12044078e-02f, -9.21442360e-02f, 3.64622734e-02f, -8.31087527e-04f, -2.74072383e-02f,
  1.72964241e-02f, 4.15787250e-02f, 4.97817621e-02f, -6.23411462e-02f, -2.04992536e-02f, 3.93861160e-02f, 6.85356259e-02f, 8.78105909e-02f, -3.08837444e-02f, 1.72216613e-02f,
  -1.75889116e-02f, 3.25212814e-02f, -6.71331072e-03f, 1.04118690e-01f, -4.03983369e-02f, -1.38642296e-01f, 5.90203293e-02f, -4.44099046e-02f, -4.38949391e-02f, -3.36650461e-02f,
  1.53747767e-01f, 1.22770453e-02f, -1.05190292e-01f, -2.23724055e-03f, -6.25861883e-02f, -1.25456259e-01f, 3.99537571e-02f, 2.18500365e-02f, 1.55420238e-02f, 4.06907611e-02f,
  2.49454286e-02f, -1.80539619e-02f, 8.06393549e-02f, -4.04756814e-02f, -5.27689792e-02f, -6.78766444e-02f, 1.47901941e-02f, 6.33160472e-02f, 1.43338023e-02f, 2.10181680e-02f,
  4.19882499e-02f, -2.11664699e-02f, -1.59851685e-01f, 5.11092879e-02f, 3.85271013e-02f, -1.40377106e-02f, -7.80462623e-02f, -6.37203604e-02f, -8.63646716e-03f, -3.88747454e-02f,
  -9.14481208e-02f, -4.88126874e-02f, 2.73891632e-02f, 1.48592398e-01f, 1.01270594e-01f, 6.41668811e-02f, 3.97228114e-02f, 1.17228523e-01f, 1.17979031e-02f, 1.23612560e-01f,
  1.00679696e-01f, 1.08138667e-02f, 1.80644408e-01f, 9.30951163e-02f, 1.83099017e-01f, 1.03674829e-01f, 1.34139031e-01f, -2.92205401e-02f, 1.29481763e-01f, 8.92056599e-02f,
  1.21005058e-01f, 5.44845313e-02f, -7.86923617e-02f, -1.27715785e-02f, 2.64848154e-02f, 3.21339117e-03f, -5.01672551e-02f, -2.16178577e-02f, -7.59746432e-02f, -3.13590392e-02f,
  1.24720342e-01f, -4.19004969e-02f, 8.78162682e-02f, 5.07208556e-02f, 3.72171365e-02f, 1.72640737e-02f, 1.13134407e-01f, -6.25831038e-02f, -2.81025004e-02f, 1.28877386e-02f,
  -5.68373352e-02f, 5.51329665e-02f, -3.86799895e-03f, -1.09216034e-01f, 4.52783257e-02f, 8.52155536e-02f, -9.61126387e-02f, -3.64062563e-02f, 9.82808247e-02f, 1.20579109e-01f,
  -3.15605290e-02f, 3.56996730e-02f, -4.04635072e-02f, 1.10451408e-01f, -3.48373242e-02f, 4.90021631e-02f, -1.81835722e-02f, 8.28711502e-03f, -3.75616960e-02f, -1.55920321e-02f,
  6.59691170e-02f, 3.75091173e-02f, 2.99193207e-02f, 8.70946199e-02f, -4.10596021e-02f, 1.39284700e-01f, 7.89550599e-03f, -6.99394494e-02f, 1.65048335e-02f, -4.73570563e-02f,
  -6.07876182e-02f, 1.23137265e-01f, 8.71553048e-02f, 2.29691826e-02f, -4.87636626e-02f, -4.07898687e-02f, -3.95835238e-03f, -6.49431255e-03f, -1.01015344e-02f, -4.87349406e-02f,
  4.55052368e-02f, -3.93101163e-02f, 6.76837564e-02f, -9.02628005e-02f, 4.78039794e-02f, 6.54264987e-02f, -3.86358500e-02f, -1.84486359e-02f, 1.06266439e-02f, 3.81558985e-02f,
  -6.40122741e-02f, -1.11238007e-02f, 1.49216145e-01f, -6.65233061e-02f, -6.22676983e-02f, 2.05389149e-02f, 3.10018193e-02f, 3.23948674e-02f, -6.31279051e-02f, 8.10954943e-02f,
  5.12454845e-02f, -2.42363065e-02f, -7.72618800e-02f, -2.58165691e-02f, 6.36391416e-02f, 3.84962820e-02f, 6.90299049e-02f, 1.16810232e-01f, 7.61115700e-02f, 9.77592096e-02f,
  -7.32930526e-02f, 3.90994959e-02f, 7.32723475e-02f, 1.26966378e-02f, -3.85522358e-02f, 7.18886107e-02f, 7.19262064e-02f, -8.19401965e-02f, 1.74251478e-02f, 1.18980728e-01f,
  -5.20325661e-01f, 1.16586328e-01f, 1.89705065e-03f, -2.25685671e-01f, -7.44744167e-02f, 1.01386309e-01f, 1.44383714e-01f, 8.88436008e-03f, -2.08151147e-01f, -1.16549030e-01f,
  -4.91098464e-02f, -9.09026787e-02f, -8.56575593e-02f, 5.83918877e-02f, -1.18103214e-01f, 4.82625701e-02f, -1.53034598e-01f, -8.22452977e-02f, 6.48302585e-02f, -6.50715679e-02f,
  -3.44845541e-02f, -2.02576607e-01f, -1.22261025e-01f, -5.26602305e-02f, -3.16951647e-02f, 3.00928541e-02f, -7.45748729e-02f, -1.72097608e-01f, 1.53463989e-01f, -1.79217253e-02f,
  1.02020241e-01f, 2.23126374e-02f, -1.55238248e-02f, -2.01140717e-02f, -1.04009397e-02f, 3.82218175e-02f, 7.37256631e-02f, -6.31933287e-02f, 2.40547899e-02f, 2.56729443e-02f,
  -1.54605538e-01f, 3.95217501e-02f, -3.41224782e-02f, 6.37679696e-02f, -1.76449940e-02f, -3.80024649e-02f, 2.00397577e-02f, -2.25433689e-02f, 8.99391025e-02f, 1.12859301e-01f,
  8.16359743e-02f, -5.35387956e-02f, -9.02025867e-03f, 9.81454700e-02f, 7.51720667e-02f, -7.05224499e-02f, 1.56627610e-01f, 5.99536411e-02f, 1.08279780e-01f, 4.14965078e-02f,
  -5.36829308e-02f, 5.96838146e-02f, 1.09781101e-02f, 8.62976462e-02f, -5.38447537e-02f, 1.87863931e-02f, 3.46513093e-02f, -1.25475405e-02f, 1.10206222e-02f, -1.02367559e-02f,
  -2.88117770e-02f, -4.86556739e-02f, 1.01021543e-01f, 6.10413263e-04f, -5.75698726e-02f, -1.05723403e-02f, -3.36208865e-02f, 5.58249606e-03f, 2.57544983e-02f, -4.26568426e-02f,
  -5.20355962e-02f, -2.12317682e-03f, -3.55106182e-02f, 1.07677206e-01f, 5.82750849e-02f, -8.04550797e-02f, 3.21156904e-02f, -4.20452841e-03f, 9.40875523e-03f, 6.59161573e-03f,
  -1.08180396e-01f, -8.24253559e-02f, -1.18247151e-01f, -7.75659978e-02f, -1.13843225e-01f, 2.67731845e-02f, -5.46974242e-02f, -4.03454714e-02f, -8.10711682e-02f, -4.63078618e-02f,
  1.27462357e-01f, 2.97840293e-02f, 1.23689681e-01f, 7.74752349e-02f, 1.51984487e-02f, 4.45338190e-02f, -3.90428603e-02f, -5.98410368e-02f, 9.04973447e-02f, -1.84884935e-03f,
  -1.21066824e-03f, -1.58712007e-02f, -4.60655317e-02f, 4.21410277e-02f, -9.94662642e-02f, -4.70808931e-02f, 1.21152990e-01f, 1.40472755e-01f, 4.72816937e-02f, -1.07311765e-02f,
  5.29497601e-02f, -1.01977317e-02f, -4.37399074e-02f, -9.74380039e-03f, 1.02771953e-01f, -1.90211311e-02f, 3.72049734e-02f, 5.03175370e-02f, 9.25573483e-02f, 1.01759791e-01f,
  7.65241981e-02f, 1.09438322e-01f, 1.21093191e-01f, 6.18076511e-02f, 6.10579737e-02f, 6.22625835e-02f, 9.95926335e-02f, 1.24224253e-01f, 1.19109519e-01f, -5.22881486e-02f,
  -5.54116629e-02f, 7.55638480e-02f, -7.10267052e-02f, -1.28817884e-02f, 3.93139198e-02f, 6.64909557e-02f, 5.31242751e-02f, -2.89802570e-02f, -9.35268253e-02f, -5.31595312e-02f,
  -2.27830596e-02f, 3.11026536e-02f, -2.06710789e-02f, -3.37180458e-02f, 9.93577912e-02f, -8.18570033e-02f, 3.89310755e-02f, -3.66790295e-02f, -7.24839270e-02f, 3.09472680e-02f,
  4.31876294e-02f, -1.00120500e-01f, -2.05550641e-02f, -2.80355569e-02f, -9.95183289e-02f, 4.29414287e-02f, 5.48366755e-02f, -1.00683309e-02f, -3.48243117e-02f, -1.68380328e-02f,
  8.14772025e-02f, 7.91062787e-02f, -1.82514098e-02f, -3.40229198e-02f, -6.07760549e-02f, -6.41256338e-04f, 1.60864238e-02f, -2.96158949e-03f, -4.36316691e-02f, -6.34186566e-02f,
  -4.76192869e-02f, 1.01280594e-02f, 3.90121751e-02f, -2.57663354e-02f, -3.19759771e-02f, -6.17264956e-02f, -3.90591770e-02f, 3.10544111e-02f, 2.97658518e-02f, -4.29346152e-02f,
  -3.29392380e-03f, -3.93595733e-02f, 4.11579236e-02f, -2.54799780e-02f, 5.92579320e-02f, -1.09700836e-01f, 2.88768820e-02f, -2.52228379e-02f, -5.83361164e-02f, 2.18026377e-02f,
  8.49438086e-03f, -2.32113618e-02f, -7.19626248e-02f, 5.50196134e-02f, 4.53093201e-02f, 4.41309400e-02f, 3.65648158e-02f, -6.90147504e-02f, -1.69230765e-03f, -9.12999362e-02f,
  -1.23592667e-01f, 5.25995716e-02f, 1.00236759e-01f, -6.67958781e-02f, 6.39095157e-02f, 1.14901178e-01f, -3.18910403e-04f, 9.97740999e-02f, 7.04059983e-03f, -5.07235602e-02f,
  -2.69218180e-02f, -1.23229481e-01f, -6.09498732e-02f, 5.52576631e-02f, 3.34086902e-02f, 3.47515382e-02f, 1.12952478e-01f, -3.45230587e-02f, -4.06410545e-02f, 5.97469099e-02f,
  -5.71558401e-02f, 6.26673847e-02f, 6.34185374e-02f, 6.91597089e-02f, 3.76151763e-02f, -8.99139885e-03f, 6.23313300e-02f, 8.31209794e-02f, 6.68956637e-02f, 2.13243533e-02f,
  6.52671680e-02f, 1.04544885e-01f, -8.26289356e-02f, 5.58415912e-02f, 2.93875374e-02f, 3.27916979e-03f, 8.32221508e-02f, -1.81940501e-03f, 7.16106966e-02f, -2.66854614e-02f,
  -7.35336766e-02f, -8.33956674e-02f, 1.58923082e-02f, -9.38327089e-02f, -1.29306585e-01f, -1.86041109e-02f, 3.75361145e-02f, -1.17256284e-01f, -1.05964422e-01f, 1.29141342e-02f,
  -4.59912559e-03f, 6.43996745e-02f, -5.60097117e-03f, -8.31732526e-04f, 7.79910013e-02f, -2.91234646e-02f, -4.54542525e-02f, 2.56371126e-02f, -5.22702783e-02f, -4.61276621e-02f,
  -4.02744301e-03f, -1.78836524e-01f, 9.00587649e-04f, 2.00630222e-02f, -2.76948456e-02f, -8.89968723e-02f, -2.74844412e-02f, -3.61178555e-02f, -9.76887420e-02f, 6.61874237e-03f,
  -4.18637432e-02f, 5.93443923e-02f, -9.52197760e-02f, 3.88572253e-02f, -3.10108811e-02f, -4.42658626e-02f, -3.69421877e-02f, -1.92972012e-02f, -1.08497247e-01f, -8.25168714e-02f,
  9.14711431e-02f, -9.83554870e-02f, 1.94380451e-02f, 2.45151278e-02f, 1.68126449e-02f, -1.91632062e-02f, -6.92441612e-02f, -1.19083636e-02f, -3.86028141e-02f, 6.26827255e-02f,
  4.76066433e-02f, -4.33267877e-02f, 1.22371875e-02f, 2.40920912e-02f, 2.73867568e-04f, -5.24710119e-02f, 3.14406976e-02f, -3.19158286e-02f, -7.78676420e-02f, -4.46557775e-02f,
  -2.01430712e-02f, 1.67262647e-02f, 1.53950853e-02f, 3.55692245e-02f, 3.19551192e-02f, 1.81977567e-03f, -3.52323870e-04f, -1.17078871e-02f, 1.32096279e-02f, 1.76396817e-02f,
  1.17383569e-01f, -4.30272445e-02f, 7.59043247e-02f, -5.36283143e-02f, -3.14897038e-02f, 1.13980189e-01f, 4.70795520e-02f, -1.71160493e-02f, 9.18382034e-02f, 1.42792672e-01f,
  -6.10884428e-02f, -9.87795442e-02f, -8.62125754e-02f, 4.23467457e-02f, -1.78097505e-02f, 4.89331782e-03f, -1.29587585e-02f, 4.05770959e-03f, -7.86777288e-02f, -8.67420156e-03f,
  -3.73570547e-02f, -3.85821350e-02f, -9.16677353e-04f, -3.21523193e-03f, 1.21859256e-02f, 3.50835733e-02f, 4.18432243e-02f, 6.38015047e-02f, -5.29591255e-02f, -2.51582172e-03f,
  7.73163885e-02f, 1.85388085e-02f, 7.03583732e-02f, -2.28815246e-02f, 9.47416723e-02f, 7.83208087e-02f, 3.20320129e-02f, 4.63727824e-02f, 8.31362084e-02f, 1.00685954e-01f,
  -2.47905880e-01f, 5.40160835e-02f, 4.87536788e-02f, -2.55127430e-01f, 1.05632022e-01f, 2.73757130e-01f, 1.18016891e-01f, 3.24672833e-02f, 3.79728191e-02f, 3.04905064e-02f,
  3.70751582e-02f, -1.26454413e-01f, 8.23261123e-03f, -1.62067953e-02f, 1.17836259e-02f, 9.19438303e-02f, -1.47838086e-01f, -8.70962143e-02f, -5.39620547e-03f, 1.10115269e-02f,
  -2.98515428e-02f, -2.89799929e-01f, -2.42749572e-01f, -2.22272836e-02f, -1.71635583e-01f, -1.49300918e-02f, -1.36778057e-01f, -1.71691433e-01f, 1.11042850e-01f, -2.05531612e-01f,
  -7.49525204e-02f, 4.91733244e-03f, 7.06341723e-03f, -1.19703770e-01f, -3.90328765e-02f, 3.67149450e-02f, -2.88718268e-02f, 1.02404235e-02f, -3.60965282e-02f, 3.72445979e-03f,
  -4.31551710e-02f, -5.54552525e-02f, 4.90357205e-02f, -8.05848688e-02f, -1.54246300e-01f, 2.14363281e-02f, -1.36672473e-02f, 1.92662906e-02f, -7.00497180e-02f, 7.14721456e-02f,
  -9.69787464e-02f, 4.93789315e-02f, -8.27700049e-02f, -5.17844632e-02f, -8.09874758e-02f, 5.04957065e-02f, -6.85729831e-02f, 1.55961262e-02f, 1.12039819e-01f, 2.20781052e-03f,
  1.51071977e-02f, -2.70158593e-02f, -8.92859511e-03f, 3.63866463e-02f, -5.87569959e-02f, -1.94790792e-02f, -1.81229878e-02f, -1.54632419e-01f, 1.26644522e-01f, 1.40819242e-02f,
  2.18020584e-02f, -4.69176751e-03f, -3.96350138e-02f, -1.15253448e-01f, -1.84242497e-03f, -8.73775221e-03f, 4.85721640e-02f, -8.26917514e-02f, -1.01960331e-01f, 4.00488712e-02f,
  5.42691164e-02f, 6.63148053e-03f, 1.71486884e-02f, -4.54368144e-02f, 4.27976102e-02f, -1.78527292e-02f, -5.12378402e-02f, 1.04394257e-01f, -8.21837932e-02f, 2.73560900e-02f,
  -1.47068471e-01f, 1.11066490e-01f, 2.51103807e-02f, 1.93044054e-03f, -5.41841611e-02f, 2.90843844e-02f, -3.71322967e-02f, -9.39706247e-03f, 9.07310173e-02f, 1.53135741e-02f,
  -9.09680035e-03f, -4.41889018e-02f, -1.11019947e-01f, -5.58015145e-02f, 2.89210323e-02f, -3.31835262e-02f, -1.50205866e-01f, -6.56937733e-02f, 8.50478560e-03f, -2.95952242e-02f,
  -1.09318316e-01f, -3.23162675e-02f, -9.64931324e-02f, -3.49344537e-02f, 2.67825369e-02f, -5.30633610e-03f, -3.44361030e-02f, 1.19580561e-02f, 1.65387720e-01f, -1.04468606e-01f,
  1.88121364e-01f, 8.35190490e-02f, 1.78393841e-01f, 1.19548567e-01f, 5.29772155e-02f, 5.07785678e-02f, 7.20592290e-02f, 8.96592960e-02f, 5.42143919e-02f, 8.55585560e-02f,
  1.11645676e-01f, 4.46080901e-02f, 1.39431298e-01f, 1.11594893e-01f, 1.03989676e-01f, 2.96510365e-02f, 6.29418790e-02f, 3.67596634e-02f, 4.76513728e-02f, 1.20258525e-01f,
  6.78036660e-02f, 7.83399493e-03f, -2.96938717e-02f, 7.73066282e-02f, 6.29436076e-02f, 5.33273667e-02f, 5.09197675e-02f, 4.68710139e-02f, 5.24785630e-02f, -5.21843731e-02f,
  -5.44129461e-02f, 1.53145313e-01f, -5.72141707e-02f, -1.06051944e-01f, 1.31101757e-02f, 6.70246407e-03f, 6.44499585e-02f, -7.73287565e-02f, -9.44715515e-02f, 2.13844869e-02f,
  -5.22454605e-02f, 2.92326231e-02f, 8.43747258e-02f, 2.43429709e-02f, 7.70564526e-02f, 6.31852299e-02f, 5.28736366e-03f, 7.68148452e-02f, -8.80178884e-02f, 3.58850062e-02f,
  -6.39868379e-02f, 3.39208692e-02f, 5.18342331e-02f, 9.60683543e-03f, 4.35908325e-03f, 1.05422877e-01f, -1.16175264e-02f, 8.82297382e-03f, 1.61409955e-02f, 4.52438667e-02f,
  -3.44039500e-02f, 5.62611371e-02f, 5.90246804e-02f, 7.83211663e-02f, 2.97042131e-02f, 8.52852240e-02f, -6.58730790e-02f, -4.54559401e-02f, 8.29842500e-03f, -8.23667794e-02f,
  -5.76495230e-02f, -2.30425410e-02f, 7.96165094e-02f, -1.42651172e-02f, 1.68832317e-02f, -6.87146261e-02f, 7.81012699e-02f, -8.87125283e-02f, 6.24667108e-02f, 2.15562177e-03f,
  -6.50923606e-03f, -5.48730902e-02f, 1.12483382e-01f, -4.96490449e-02f, 1.05116285e-01f, -6.87908158e-02f, 6.40396774e-02f, -6.42814040e-02f, 8.60696658e-03f, 2.09084842e-02f,
  -1.33716345e-01f, -1.92603003e-03f, 1.17755514e-02f, 3.36122476e-02f, 2.92225387e-02f, -9.96660441e-02f, 6.22217581e-02f, -2.52467971e-02f, -5.87512031e-02f, -7.67572075e-02f,
  -1.16298549e-01f, 1.04713375e-02f, -1.02984153e-01f, -3.80905084e-02f, -6.53437972e-02f, -1.42613202e-01f, -3.67587544e-02f, 1.67108495e-02f, -3.94629650e-02f, -1.40864998e-01f,
  -6.72471374e-02f, -6.46622553e-02f, -1.12261418e-02f, -1.09149948e-01f, 4.16838564e-02f, -3.26000564e-02f, -6.02397956e-02f, -2.09823418e-02f, 4.71630283e-02f, 1.70493070e-02f,
  -2.76896209e-01f, -3.12801868e-01f, 1.64677650e-01f, 2.41043553e-01f, 2.27617770e-01f, 3.09773922e-01f, 2.54019946e-01f, 1.90114602e-01f, 1.81776628e-01f, 6.23258650e-02f,
  -2.52475321e-01f, -2.11088970e-01f, -1.62408561e-01f, -1.76793903e-01f, -1.92157388e-01f, 1.95928112e-01f, 4.14777935e-01f, 1.31137773e-01f, 6.32076189e-02f, 1.08897097e-01f,
  4.89048660e-02f, 9.61963162e-02f, -1.65520266e-01f, -4.24845666e-02f, 1.19168296e-01f, 1.36131078e-01f, 3.93556468e-02f, -7.06596226e-02f, -1.81249112e-01f, 1.76676586e-01f,
  -2.21157506e-01f, -1.50953576e-01f, 7.77224377e-02f, -1.00420557e-01f, -1.84454136e-02f, -3.43142301e-02f, -4.17617187e-02f, -6.00086227e-02f, 2.55652368e-02f, 1.59293730e-02f,
  -6.54529408e-02f, -1.07471198e-01f, 6.04109801e-02f, -7.80763403e-02f, -2.73172166e-02f, -2.03298293e-02f, -3.22477520e-02f, -4.93499748e-02f, -4.26919013e-03f, -5.98760955e-02f,
  -1.34242669e-01f, -9.66994241e-02f, -1.30469035e-02f, 2.83478312e-02f, -4.75148857e-02f, -7.69585297e-02f, -2.52452772e-02f, -5.81772439e-03f, -3.41924578e-02f, 1.90124549e-02f,
  -6.06473498e-02f, 7.57253841e-02f, 2.78736390e-02f, -3.59550044e-02f, -6.98653311e-02f, 1.82279330e-02f, 8.75546187e-02f, 4.10669073e-02f, 7.82264993e-02f, -1.81832779e-02f,
  -6.17986694e-02f, -5.06301373e-02f, 4.27074730e-02f, -6.01312984e-03f, -3.52338925e-02f, -4.20519523e-02f, 8.57025385e-03f, -9.25946012e-02f, -6.48468658e-02f, 3.58303729e-03f,
  3.88218351e-02f, 5.07334098e-02f, 2.76464820e-02f, -7.85649270e-02f, -6.08083531e-02f, -3.50047229e-03f, -6.47878647e-02f, 1.20793153e-02f, -3.28232646e-02f, 9.78149772e-02f,
  -2.63315793e-02f, -1.08216241e-01f, 8.79026055e-02f, 4.34948727e-02f, 1.00657798e-01f, -3.34741995e-02f, 5.18158227e-02f, -1.46831544e-02f, 7.61482446e-03f, -1.38756121e-02f,
  2.67695673e-02f, -1.17050678e-01f, 2.35622916e-02f, 5.37423305e-02f, 5.17418757e-02f, 7.99011737e-02f, -2.11900435e-02f, 8.02076515e-03f, 2.37519331e-02f, -6.52177855e-02f,
  6.17080554e-03f, 9.11473259e-02f, 6.25306219e-02f, 8.40817243e-02f, 6.02217205e-02f, 1.83046773e-01f, 8.44666660e-02f, 8.14547688e-02f, 4.07081470e-02f, 5.63571043e-02f,
  1.43636420e-01f, 1.42902121e-01f, -6.32720143e-02f, 8.71327613e-03f, -6.89986274e-02f, -1.15135415e-02f, 1.30289877e-02f, -6.10198593e-03f, 3.10795512e-02f, 1.50952891e-01f,
  2.54678540e-02f, -6.31459802e-02f, -1.32771239e-01f, -1.33645073e-01f, -1.52060241e-01f, 1.53670833e-01f, 9.02418122e-02f, -1.98735550e-01f, -1.81091517e-01f, -8.01237449e-02f,
  -6.26141727e-02f, 1.31895514e-02f, -1.05920650e-01f, -5.47053106e-02f, 1.04005393e-02f, -1.23568259e-01f, -3.18776183e-02f, -1.24832928e-01f, -1.68300942e-01f, 4.25618365e-02f,
  -5.32269515e-02f, -3.57884467e-02f, -1.78679302e-02f, 2.84246653e-02f, -8.05936977e-02f, 7.37611726e-02f, 5.53526767e-02f, -1.15393540e-02f, -5.62288910e-02f, -1.94781665e-02f,
  -6.55686855e-02f, 7.84959048e-02f, 1.88611168e-02f, -6.96083754e-02f, 3.91178168e-02f, 2.64336616e-02f, 4.93031815e-02f, -1.22112006e-01f, -7.48266131e-02f, 5.28012868e-03f,
  3.07316631e-02f, 1.33382548e-02f, -6.80607036e-02f, -1.05813416e-02f, -4.44043241e-02f, -1.43245324e-01f, -8.15056637e-02f, -6.80182828e-03f, -3.41649428e-02f, 4.61502261e-02f,
  5.73494956e-02f, 1.46248101e-04f, -2.81610768e-02f, 8.11873353e-04f, 5.46030104e-02f, 7.52205998e-02f, -6.63823038e-02f, 3.60359177e-02f, 2.19283067e-02f, 2.71770898e-02f,
  1.15193389e-02f, -1.08044585e-02f, 1.07105728e-02f, 9.28001031e-02f, -2.72026826e-02f, -5.03796488e-02f, 7.53172534e-03f, -6.32118760e-03f, -6.08015843e-02f, 5.64715639e-02f,
  -9.92842764e-02f, -7.59052187e-02f, 1.57416041e-03f, -2.07369179e-02f, 1.01548582e-02f, -1.25304341e-01f, 1.64432079e-02f, 5.42790489e-03f, -1.09918565e-02f, -8.21571201e-02f,
  1.52410313e-01f, -8.76908004e-02f, 9.17553082e-02f, -5.37804037e-04f, 5.46393506e-02f, -7.30508938e-03f, -3.22533064e-02f, -4.38689999e-02f, 3.49131636e-02f, 8.98605362e-02f,
  3.27369794e-02f, 5.64695708e-02f, 1.00700006e-01f, 9.84044163e-04f, 1.05290096e-02f, -3.71419564e-02f, 1.25787944e-01f, 1.41951060e-02f, 4.84086983e-02f, 1.28615396e-02f,
  1.03404909e-01f, 1.15501501e-01f, 9.11831409e-02f, 8.28153566e-02f, -4.03585620e-02f, -6.35913759e-02f, 2.09590793e-02f, 1.00695468e-01f, 5.40187918e-02f, 1.82243720e-01f,
  -2.77681440e-01f, -2.48403668e-01f, 1.81156456e-01f, 9.02483687e-02f, 2.10601464e-01f, 2.22221404e-01f, 2.25444898e-01f, -1.79265793e-02f, -4.97467890e-02f, 1.16385549e-01f,
  -6.08575866e-02f, 1.17874227e-01f, 2.70569026e-02f, 1.01417176e-01f, 3.45412157e-02f, 2.27028653e-01f, 2.56041419e-02f, 4.76389425e-03f, 2.21108094e-01f, 7.52585381e-02f,
  1.01375781e-01f, -4.13547736e-03f, -1.22716583e-01f, 6.51573315e-02f, -3.49516794e-02f, 9.98181105e-02f, 6.50612190e-02f, -1.47588030e-01f, -6.73860237e-02f, 2.72159316e-02f,
  3.98708999e-01f, -2.00947568e-01f, 8.37087035e-02f, -1.12084508e-01f, -8.23508501e-02f, 3.50889638e-02f, 3.15409526e-02f, -1.47822136e-02f, -2.70778574e-02f, -6.85539022e-02f,
  2.02927161e-02f, 3.59024629e-02f, 1.14816315e-01f, 3.63728665e-02f, 2.60121971e-02f, 3.16228755e-02f, -3.80342901e-02f, -6.65774420e-02f, -3.62073928e-02f, 5.52005693e-02f,
  1.69719141e-02f, -8.48439485e-02f, -1.11424603e-01f, 2.29171645e-02f, -1.33606419e-01f, 6.88010380e-02f, -7.82134458e-02f, -8.50744098e-02f, -3.28367390e-02f, -1.41609550e-01f,
  5.04297279e-02f, 1.77475326e-02f, 1.04258852e-02f, -1.56442430e-02f, 2.28633955e-02f, 5.28788231e-02f, -1.23283997e-01f, 1.30114201e-02f, -7.14814290e-02f, -6.21900801e-03f,
  3.82578894e-02f, 3.05451197e-03f, 9.69188847e-03f, 1.02380812e-01f, 1.92176513e-02f, 1.86367575e-02f, 2.35183947e-02f, -3.73474397e-02f, 3.68573959e-03f, -8.02081898e-02f,
  -6.45805821e-02f, -5.64115532e-02f, -4.19550575e-02f, 4.42091674e-02f, 5.57818301e-02f, -8.55507609e-03f, 7.99214616e-02f, 3.73505913e-02f, 1.00795574e-01f, -8.04419741e-02f,
  1.13074131e-01f, -6.58585802e-02f, 6.40669912e-02f, -6.37501553e-02f, -4.12352942e-02f, -1.45377770e-01f, -6.76731765e-02f, 6.95258453e-02f, -4.57621217e-02f, 3.97115350e-02f,
  -1.32039532e-01f, -8.16135760e-03f, 5.16273342e-02f, -1.01127625e-01f, 2.53615552e-03f, 5.19307777e-02f, -8.26222450e-02f, 1.54454246e-01f, -3.06014698e-02f, 4.19118889e-02f,
  -2.41242275e-02f, 3.08824070e-02f, 1.54466867e-01f, 1.21539555e-01f, 2.89222281e-02f, 1.26785310e-02f, 1.59214064e-01f, 8.80163237e-02f, 1.40716285e-01f, 1.36600822e-01f,
  -2.58163512e-01f, 5.88589646e-02f, -7.40273148e-02f, -3.13213840e-02f, 9.53298807e-02f, -2.69239116e-02f, -1.84680074e-02f, -5.49737215e-02f, -4.03371863e-02f, -1.30114034e-02f,
  -1.40500143e-01f, 4.69432101e-02f, 8.23530182e-02f, -1.82163790e-02f, 4.50798757e-02f, 2.76079327e-02f, 1.96584165e-01f, 2.38283630e-03f, -1.38818786e-01f, 5.00831939e-02f,
  2.70573609e-02f, -4.83685955e-02f, -9.48512852e-02f, -7.96363056e-02f, 1.04995437e-01f, 5.21609150e-02f, 2.84426678e-02f, 4.99501750e-02f, -3.85748446e-02f, 1.42430857e-01f,
  -1.44682854e-01f, -1.81103170e-01f, 1.50198415e-01f, 2.40291785e-02f, -6.28454536e-02f, -8.06723535e-02f, -5.20622991e-02f, -3.01404372e-02f, 7.05157891e-02f, -8.83919150e-02f,
  -5.10366634e-03f, -3.77776399e-02f, 3.96214239e-02f, -4.42435667e-02f, -8.26370865e-02f, 4.03366759e-02f, -7.45068341e-02f, 3.48296389e-02f, 3.63560244e-02f, 2.41263863e-02f,
  2.22208854e-02f, -1.34859115e-01f, -1.14829645e-01f, -1.05696701e-01f, -7.80595541e-02f, 5.11438400e-02f, -1.05964884e-01f, -1.43102795e-01f, -5.67601509e-02f, -1.28978804e-01f,
  1.39648229e-01f, 1.48762250e-02f, -3.60850058e-02f, 4.23140079e-02f, -4.36056592e-03f, -2.67635076e-03f, 1.28090680e-01f, -5.54743186e-02f, 9.92310792e-02f, 3.59107764e-03f,
  -1.49437636e-01f, 7.66666159e-02f, 2.84712180e-03f, 3.81441563e-02f, 2.33038999e-02f, 4.94686924e-02f, 2.55438685e-02f, 3.06136329e-02f, -8.04732665e-02f, 5.52098416e-02f,
  -3.14758085e-02f, 4.90047177e-03f, 1.93975400e-02f, 7.24883974e-02f, -2.82415319e-02f, 9.83882993e-02f, -1.01219621e-02f, -8.11523348e-02f, -7.14831129e-02f, -2.19399743e-02f,
  6.53873831e-02f, 8.70712027e-02f, 4.43366766e-02f, -6.55835792e-02f, -5.04518440e-03f, 7.41235167e-02f, 9.32205934e-03f, -9.06592831e-02f, -4.17010672e-02f, -8.37645233e-02f,
  -7.53159523e-02f, 2.31701620e-02f, -9.31158140e-02f, -5.72525151e-02f, -5.25053106e-02f, -7.23512545e-02f, -4.57953066e-02f, -9.84947830e-02f, -3.58786769e-02f, -5.85778207e-02f,
  -6.35196641e-02f, -5.29875979e-04f, -2.58792494e-03f, -1.71647742e-02f, 1.42420791e-02f, -4.25506644e-02f, -4.62612733e-02f, -1.24038711e-01f, -7.98566788e-02f, -6.04816973e-02f,
  1.05559401e-01f, -1.03175141e-01f, -1.76483124e-01f, 6.78957626e-02f, -1.71502512e-02f, 7.74772689e-02f, 2.28838846e-02f, 8.11097920e-02f, 9.00153667e-02f, 4.23595868e-02f,
  -2.34398805e-02f, -6.94188178e-02f, -1.05517276e-01f, -4.03755829e-02f, -3.63503806e-02f, -3.23720626e-03f, -1.41243204e-01f, -7.40208775e-02f, 5.71656972e-02f, 4.44186218e-02f,
  4.26659659e-02f, 5.58955558e-02f, 2.54135542e-02f, -4.38892506e-02f, -3.37405829e-03f, 2.75570005e-02f, 6.45759329e-03f, 2.46726405e-02f, -1.13998234e-01f, -2.25049984e-02f,
  1.82162821e-02f, -3.75866219e-02f, 9.83186737e-02f, -6.15993179e-02f, -1.25292232e-02f, 1.43120694e-03f, 5.47139766e-03f, -7.57741109e-02f, 5.47348894e-02f, 9.63000283e-02f,
  -8.24605823e-02f, -3.48972455e-02f, 4.07695547e-02f, -3.98275033e-02f, -6.05058372e-02f, -7.08621815e-02f, -9.23621804e-02f, -8.53301808e-02f, -8.91999528e-02f, -5.06731682e-02f,
  -2.84394268e-02f, -6.32337630e-02f, -9.16661695e-02f, 6.05515391e-03f, -1.32312983e-01f, -8.41845945e-02f, -7.59027079e-02f, 2.99598388e-02f, -1.08771600e-01f, -5.61347455e-02f,
  -1.08245529e-01f, -2.99178567e-02f, 2.22946722e-02f, -2.75069326e-02f, -2.46390495e-02f, -4.40721662e-04f, -6.02751561e-02f, 5.02311476e-02f, 3.98987457e-02f, 2.09029689e-02f,
  -2.20651608e-02f, 4.22201045e-02f, -1.57002322e-02f, -4.99828346e-02f, 3.52408998e-02f, 1.23577490e-01f, 5.26104234e-02f, -5.11150546e-02f, 5.68828918e-02f, -3.53643700e-04f,
  4.57832776e-02f, -1.49670057e-02f, 6.84092939e-02f, 4.12475094e-02f, -1.11749150e-01f, 1.49370832e-02f, 2.62203887e-02f, 6.89715445e-02f, -6.45724013e-02f, 2.11429261e-02f,
  -3.89484279e-02f, -5.12664579e-03f, 9.80697945e-02f, 7.50257298e-02f, -3.14917639e-02f, 3.77475247e-02f, 3.44579555e-02f, 1.40399840e-02f, -1.69579231e-03f, 9.60603133e-02f,
  -3.09213605e-02f, -1.12931550e-01f, 1.81329455e-02f, 1.07135577e-02f, -6.45879284e-02f, -4.57772277e-02f, 6.20336905e-02f, -9.07063577e-03f, 3.73237133e-02f, -5.31386696e-02f,
  -3.79184298e-02f, 1.02291685e-02f, -7.12454394e-02f, 2.66670696e-02f, -2.53751571e-03f, 1.46713050e-03f, 1.04970327e-02f, -5.94170904e-03f, -7.87697881e-02f, 6.12805448e-02f,
  -5.33533432e-02f, -1.94027182e-02f, 2.07327493e-02f, 9.06634051e-03f, -6.32724911e-02f, 7.66832605e-02f, -3.34870629e-02f, -2.62245107e-02f, 1.07993796e-01f, -1.70482304e-02f,
  8.07737112e-02f, -2.27589440e-02f, 7.44803771e-02f, 4.73459363e-02f, -4.42479439e-02f, -4.33665887e-02f, 5.22813872e-02f, -7.91848004e-02f, 5.26023991e-02f, -5.74424351e-03f,
  2.03518011e-02f, -5.48807532e-03f, 1.25533137e-02f, -1.07802592e-01f, 7.02710375e-02f, 3.18460166e-02f, 1.04929321e-02f, 6.45252988e-02f, -1.31841730e-02f, -1.02404132e-01f,
  1.31831737e-02f, -4.17101979e-02f, 8.28361586e-02f, 3.46262008e-02f, -6.08841255e-02f, -2.80329096e-03f, 3.54877301e-02f, -3.79762985e-02f, 4.30077873e-02f, -7.31172860e-02f,
  -5.38793467e-02f, -2.70856936e-02f, -3.08485422e-02f, -4.24500518e-02f, 4.49891612e-02f, 6.86914325e-02f, 2.46076062e-02f, 2.91681774e-02f, -1.92202777e-02f, -2.93437745e-02f,
  -1.01215139e-01f, -7.39435926e-02f, 5.32119051e-02f, -5.80152357e-03f, -6.63189292e-02f, 7.26521686e-02f, 1.05137564e-03f, 5.74561395e-02f, -4.17254902e-02f, -9.72543582e-02f,
  -1.18384454e-02f, 2.10099407e-02f, 7.02463835e-02f, 5.18247038e-02f, 8.45566541e-02f, 1.05561472e-01f, -5.08883074e-02f, 4.76090014e-02f, 6.24274798e-02f, -4.26282585e-02f,
  5.58527820e-02f, 1.16036600e-02f, -6.30148053e-02f, -3.88809480e-02f, 8.86699110e-02f, -6.70546740e-02f, 6.53813183e-02f, 1.18152937e-02f, 2.64421050e-02f, 3.39883827e-02f,
  7.45915249e-02f, 5.58363982e-02f, -1.22803962e-02f, -1.56927074e-03f, 5.46663441e-02f, 9.84311178e-02f, 7.68056884e-02f, 5.89481443e-02f, 6.45358190e-02f, -5.40289702e-03f,
  -7.84985423e-02f, 1.11293860e-01f, 1.95323806e-02f, -2.70164255e-02f, 7.21815825e-02f, -6.94307759e-02f, -3.56958667e-03f, -2.48788353e-02f, -2.71796379e-02f, 3.64999212e-02f,
  9.54402462e-02f, -1.87104922e-02f, 6.01411797e-02f, 6.37218654e-02f, 4.26213630e-02f, 6.13667779e-02f, 8.56548622e-02f, -2.33444832e-02f, -1.31751820e-02f, -6.74599931e-02f,
  -3.25110392e-03f, -3.85858640e-02f, -5.11115082e-02f, 3.91462334e-02f, 6.73614666e-02f, 4.69782725e-02f, 2.84375120e-02f, -2.02759560e-02f, -1.28841456e-02f, -1.02826737e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.79888162e-02f, -1.85253397e-01f, -1.83343198e-02f, -6.17521517e-02f, -2.20119338e-02f, 1.09340198e-01f, -7.58994892e-02f, 1.18037067e-01f, -1.29886240e-01f, -1.80312172e-02f,
  -1.67352203e-02f, 6.35558041e-03f, 1.50897373e-02f, -6.37063310e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.88799375e-01f, 3.72312814e-02f, 1.23563215e-01f, 1.93526015e-01f, -2.15924785e-01f, -1.29385129e-01f, -4.48491797e-02f, 1.30995810e-01f, -1.06895519e-02f, 2.10175395e-01f,
  -2.01312214e-01f, -1.32158086e-01f, -2.38909051e-01f, -7.99670890e-02f, 2.21585348e-01f, -3.31305623e-01f, 3.48229110e-02f, 7.76414648e-02f, 2.18973104e-02f, -4.37855870e-01f,
  5.00358567e-02f, 3.56482238e-01f, 1.59038574e-01f, -1.25045583e-01f, 2.41433695e-01f, 1.68477863e-01f, -3.16284686e-01f, -1.69538110e-01f, 1.01067677e-01f, 6.62558079e-02f,
  1.02480724e-01f, 2.05737114e-01f, 9.48383585e-02f, 9.13777351e-02f, 4.26769443e-02f, -2.13828743e-01f, -8.97231102e-02f, 1.72388241e-01f, -3.14244002e-01f, 3.74936104e-01f,
  1.37913615e-01f, 1.66956246e-01f, -1.36503905e-01f, 2.57908911e-01f, 1.01082951e-01f, 4.45801504e-02f, 5.64024895e-02f, 2.08885193e-01f, -2.29185056e-02f, 8.25322494e-02f,
  -2.25172322e-02f, 1.22887008e-01f, -2.20908061e-01f, 7.20124170e-02f, -8.05765912e-02f, 8.90609473e-02f, 2.35771820e-01f, 1.26469374e-01f, -1.49549827e-01f, 8.10828656e-02f,
  -3.29217315e-01f, -2.00921372e-02f, -1.38497323e-01f, 1.63543046e-01f, 2.80730605e-01f, -1.84668139e-01f, -5.68933859e-02f, 1.78222552e-01f, -8.68799835e-02f, 2.46772110e-01f,
  2.49014229e-01f, -1.18714586e-01f, -1.01105183e-01f, -2.60965556e-01f, 2.48281226e-01f, -1.60898104e-01f, -4.13019031e-01f, 1.22925751e-01f, -3.68105501e-01f, -4.32566345e-01f,
  -1.62069388e-02f, -2.56981105e-01f, -1.61878407e-01f, -1.50109798e-01f, -6.13501891e-02f, -1.07726000e-01f, -3.10673448e-03f, -4.30650227e-02f, -1.61765277e-01f, -2.56238393e-02f,
  2.22653180e-01f, 4.35764976e-02f, 1.01846389e-01f, -1.97535902e-02f, 2.20408440e-01f, -2.10994892e-02f, -1.40839607e-01f, 4.45055440e-02f, -3.19244415e-02f, 2.06434160e-01f,
  -2.02827841e-01f, -8.79013315e-02f, 1.01906769e-01f, -1.99003145e-01f, -2.34503776e-01f, -1.44898891e-01f, -4.64047641e-02f, -1.72350347e-01f, -1.66136250e-01f, 1.85864955e-01f,
  8.01456720e-02f, -1.05282046e-01f, 8.38782489e-02f, 3.28705795e-02f, 1.45791480e-02f, -5.56738973e-02f, 1.70366839e-01f, 1.77936092e-01f, -1.61310062e-01f, 5.66439405e-02f,
  8.07795450e-02f, -8.34438130e-02f, 1.74702406e-02f, -7.03034997e-02f, 1.22938566e-01f, -1.66050643e-01f, 8.94642025e-02f, 2.84898058e-02f, 1.61650985e-01f, 7.96619337e-03f,
  1.78368822e-01f, -1.81626558e-01f, -1.06890596e-01f, 1.70872528e-02f, -1.09661713e-01f, -1.48100823e-01f, 2.10091010e-01f, -1.30442351e-01f, 1.49977103e-01f, 1.08338200e-01f,
  2.23115399e-01f, -1.59220889e-01f, 1.06917553e-01f, 1.15685530e-01f, 1.64331779e-01f, 1.11874960e-01f, 1.24130338e-01f, 3.35485011e-01f, -3.11313272e-01f, 5.93142696e-02f,
  1.38871772e-02f, 1.27917066e-01f, -1.84181198e-01f, -1.52678177e-01f, 2.94810962e-02f, 2.09099084e-01f, -1.78483203e-01f, 2.17311397e-01f, -6.74511716e-02f, -6.02875575e-02f,
  2.82310814e-01f, -3.58765982e-02f, -2.29523401e-03f, 1.87515225e-02f, 5.80520183e-02f, 1.78347632e-01f, -4.49533425e-02f, 7.59399608e-02f, 1.42987326e-01f, 2.19662338e-01f,
  1.45863900e-02f, 3.27219397e-01f, 1.27548143e-01f, -1.93106085e-01f, -3.65941375e-02f, 2.51137823e-01f, -1.60795167e-01f, 1.18477270e-01f, -7.58176371e-02f, 2.37888366e-01f,
  1.90403551e-01f, -7.72263929e-02f, 1.60758764e-01f, 2.77789176e-01f, 1.43326566e-01f, -2.04647571e-01f, -9.24195275e-02f, 2.55840182e-01f, -2.30836853e-01f, 2.83507913e-01f,
  -8.49508643e-02f, 3.28141265e-03f, -1.40336482e-02f, 6.45384118e-02f, -1.77888930e-01f, 1.67350605e-01f, -1.28973961e-01f, -1.76810980e-01f, 1.21493272e-01f, 2.11710453e-01f,
  -1.13816604e-01f, 1.20295985e-02f, -2.33974323e-01f, -9.01016698e-04f, -3.64414334e-01f, -1.52941763e-01f, -2.42426638e-02f, -1.40246078e-02f, 1.17930226e-01f, 2.00880431e-02f,
  2.65961397e-04f, -3.17333221e-01f, 1.07695624e-01f, 2.26874962e-01f, -4.45996933e-02f, 1.71961397e-01f, 1.50392443e-01f, -7.15223998e-02f, -3.12777311e-01f, 1.66149706e-01f,
  -1.02694355e-01f, -7.66852871e-02f, 2.42563993e-01f, -1.07861839e-01f, 2.70684451e-01f, 1.94911212e-01f, -1.61214814e-01f, 4.89899099e-01f, 1.18971564e-01f, 3.14876586e-01f,
  4.23783600e-01f, -2.24607736e-01f, -9.54505503e-02f, -1.75351232e-01f, 4.09970254e-01f, -2.67855972e-01f, -3.75211656e-01f, -6.94588497e-02f, -2.32810304e-01f, -3.56830955e-01f,
  1.06966585e-01f, -1.48287922e-01f, 9.70941484e-02f, -2.36354560e-01f, 1.19167350e-01f, -4.37267609e-02f, 9.78049338e-02f, 1.11666977e-01f, -3.31320584e-01f, -2.53700197e-01f,
  3.18653464e-01f, -3.55959199e-02f, 3.34367931e-01f, -1.85653586e-02f, 1.12921409e-01f, -8.41599479e-02f, -2.87029237e-01f, -1.12507030e-01f, 1.37879863e-01f, 2.03371458e-02f,
  8.41898546e-02f, -1.08677380e-01f, -1.21718213e-01f, -5.61225340e-02f, -9.73010808e-02f, 1.05920933e-01f, -3.72550994e-01f, -2.54688025e-01f, 2.54973210e-02f, 3.88680212e-02f,
  -1.45513013e-01f, -2.27370024e-01f, -1.02847762e-01f, 1.54202972e-02f, -4.39739582e-04f, -1.02846093e-01f, -7.17671216e-02f, 1.99516729e-01f, -5.38567230e-02f, -1.69237807e-01f,
  1.56500906e-01f, -2.10001379e-01f, -4.39521044e-01f, -7.31825903e-02f, 7.91502446e-02f, -6.33627474e-02f, -1.28957704e-01f, 1.06055282e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.86443835e-01f, -1.13917375e-02f, -9.02287290e-02f, 5.00646904e-02f, 5.82231581e-03f, 5.20354845e-02f, 2.11336780e-02f, -4.95979525e-02f, -8.58937055e-02f, 1.11762650e-01f,
  -1.59392476e-01f, 1.00061931e-02f, -3.69182751e-02f, -5.20339236e-02f, -1.37787417e-01f, -5.91929145e-02f, -5.09903282e-02f, -1.38812885e-01f, 9.23902839e-02f, 1.34288684e-01f,
  -8.48493725e-02f, 8.36974084e-02f, 1.95846107e-04f, -1.70187369e-01f, -1.05347477e-01f, -2.86440924e-02f, -1.35087892e-01f, -2.47546080e-02f, -1.25280470e-01f, -1.75549597e-01f,
  1.92524772e-02f, 1.27691537e-01f, 1.23264631e-02f, 1.38703641e-02f, -4.18153517e-02f, 1.74500003e-01f, -1.13840681e-02f, -1.09764069e-01f, 1.53567240e-01f, 1.12758367e-03f,
  -1.37566581e-01f, -1.96250658e-02f, -7.36703500e-02f, -6.90244511e-02f, 2.10064817e-02f, -8.85646567e-02f, 1.19139992e-01f, -5.72229922e-02f, 4.93825786e-02f, -1.18129328e-01f,
  -4.30982970e-02f, 5.55402301e-02f, 5.10081649e-02f, -1.53112799e-01f, -1.52192473e-01f, 1.33779034e-01f, 1.58193514e-01f, -3.63697894e-02f, -1.20608501e-01f, 1.03664123e-01f,
  -1.56412590e-02f, 1.19494312e-01f, 5.22217564e-02f, 1.69853136e-01f, -1.02155901e-01f, -1.47684207e-02f, -1.40188619e-01f, -1.65444538e-02f, 4.87106107e-02f, 1.30110785e-01f,
  6.17898889e-02f, -5.97970784e-02f, -4.81923111e-02f, 1.58721253e-01f, -1.83144689e-01f, -6.09228723e-02f, -5.76275401e-03f, 1.28297389e-01f, 1.92749128e-01f, 1.34416446e-01f,
  1.22137196e-01f, -1.39911264e-01f, 1.09123416e-01f, -9.27887391e-03f, 7.51090273e-02f, 1.78789988e-01f, 3.10436334e-03f, 1.28836423e-01f, 1.43030941e-01f, -9.41739082e-02f,
  -4.95688953e-02f, -2.58236949e-04f, 5.04067913e-02f, 1.58138767e-01f, -1.39960036e-01f, -4.80820164e-02f, 2.82667965e-01f, 1.05418593e-01f, 1.40984148e-01f, 1.12148784e-01f,
  -1.08065791e-01f, 1.37884021e-01f, -1.37612030e-01f, 2.52795398e-01f, -8.25299397e-02f, -1.91702843e-01f, 9.44334865e-02f, 1.32678986e-01f, 9.15718824e-03f, 6.10125512e-02f,
  -1.09678589e-01f, 2.53184825e-01f, 5.77502884e-03f, 1.11504346e-01f, 2.18771747e-03f, -1.43439889e-01f, 2.13778898e-01f, 8.80564153e-02f, 2.55703151e-01f, 9.12313759e-02f,
  1.85962781e-01f, 3.23966891e-01f, -4.05722577e-03f, 1.40488446e-01f, -2.35555191e-02f, -1.76372752e-01f, -7.36083090e-02f, 8.57478827e-02f, 2.69651711e-01f, 1.40810996e-01f,
  3.21456432e-01f, -2.10959256e-01f, 1.01206914e-01f, 2.72948831e-01f, 4.05823290e-02f, 2.29945228e-01f, 3.56381357e-01f, 1.08412430e-01f, 7.90332779e-02f, 4.58256781e-01f,
  -2.80833524e-02f, -2.12125316e-01f, 1.67448610e-01f, 2.77303010e-01f, 3.60880122e-02f, 3.02405745e-01f, 1.17089972e-01f, 2.06693798e-01f, -9.65885669e-02f, 5.40140159e-02f,
  -5.17593138e-02f, -1.03992119e-01f, 1.62435055e-01f, 5.62107973e-02f, 3.79884802e-02f, 2.73645204e-03f, -1.15986140e-02f, 6.13986105e-02f, -2.30211109e-01f, -2.16739140e-02f,
  6.64847419e-02f, 1.47698745e-01f, 3.86663586e-01f, -1.36759067e-02f, 7.45938718e-02f, 1.73549503e-01f, 5.69783226e-02f, 3.31334949e-01f, -6.85999915e-02f, 1.59851581e-01f,
  -3.65721583e-01f, -1.89430431e-01f, -1.09683916e-01f, -2.65444040e-01f, -1.19461872e-01f, 7.88901225e-02f, -2.45484322e-01f, 2.45303750e-01f, 8.05756077e-02f, -2.94451594e-01f,
  -5.04450388e-02f, 2.29136795e-01f, -1.18395142e-01f, 1.13831684e-01f, 2.06865996e-01f, -1.59159511e-01f, -1.82542771e-01f, -1.10554971e-01f, -1.98440060e-01f, 3.19708198e-01f,
  1.40443221e-01f, 1.12072118e-02f, 2.12590143e-01f, 2.03971654e-01f, 3.48791480e-01f, 6.62741512e-02f, 4.04140018e-02f, -9.23911668e-03f, -1.52619004e-01f, 2.77247787e-01f,
  2.95142025e-01f, 1.34430677e-01f, -1.27184123e-01f, 7.19691589e-02f, 3.46333861e-01f, 3.87594327e-02f, 3.02351207e-01f, 3.01183581e-01f, 2.24752352e-02f, 1.71841145e-01f,
  1.14714116e-01f, 1.82923108e-01f, 2.10125417e-01f, -9.79664326e-02f, 1.34342134e-01f, 8.86704102e-02f, 6.56977147e-02f, -8.17976668e-02f, 3.31175961e-02f, -2.18397632e-01f,
  1.23544328e-01f, 1.82784781e-01f, -5.24939597e-02f, 1.66432202e-01f, -4.54381183e-02f, 1.88830733e-01f, -2.81653497e-02f, 3.29993904e-01f, 1.25150457e-02f, 9.71669257e-02f,
  1.23812832e-01f, -1.47262454e-01f, 1.80249140e-01f, -2.20723972e-01f, -1.26439426e-02f, -9.47035253e-02f, -6.22312054e-02f, 1.38230726e-01f, -4.00396623e-02f, -2.62221158e-01f,
  2.27447793e-01f, -2.09376633e-01f, 1.49115458e-01f, 2.33872011e-01f, 6.76583499e-02f, -1.38183936e-01f, 2.87783723e-02f, -2.16771867e-02f, 4.93959077e-02f, 1.55248895e-01f,
  3.27807218e-01f, -2.17619255e-01f, 2.84262687e-01f, 7.57301748e-02f, -9.07962173e-02f, -8.30071270e-02f, 1.70578584e-01f, -9.44571793e-02f, -9.59592834e-02f, -4.86060791e-02f,
  -7.83976167e-02f, 4.08892930e-02f, -1.08593442e-01f, -9.57132727e-02f, 1.82447538e-01f, -1.49015158e-01f, -1.66857481e-01f, -2.17641387e-02f, 3.35377865e-02f, 1.76280439e-01f,
  1.59207378e-02f, 1.26468495e-01f, -5.69095388e-02f, -1.07461512e-01f, 1.10147364e-01f, -3.22502479e-02f, 2.55271226e-01f, 2.24678159e-01f, 1.57824561e-01f, 1.63614918e-02f,
  4.05000784e-02f, 4.77323011e-02f, 1.04279362e-01f, -1.24837354e-01f, 2.69916654e-01f, 1.55583858e-01f, -1.32587075e-01f, -7.70415440e-02f, -1.06617056e-01f, 1.82419926e-01f,
  7.11328089e-02f, 1.99790858e-02f, 1.74077883e-01f, -1.10651173e-01f, 2.15517521e-01f, 3.19731906e-02f, 1.38676748e-01f, -1.03783337e-02f, 2.30404809e-01f, -1.01069644e-01f,
  2.54788667e-01f, 1.73563957e-01f, -6.24800324e-02f, -6.60372525e-02f, -1.53235830e-02f, -2.67601460e-01f, -5.80246784e-02f, 3.87319595e-01f, 7.96951801e-02f, -2.00904727e-01f,
  -6.69279471e-02f, 1.28745437e-01f, -2.88114324e-03f, 1.50974467e-01f, 2.22371310e-01f, -2.47780383e-02f, 1.34967551e-01f, 2.45195314e-01f, 3.17100286e-02f, 1.18562356e-01f,
  7.37686157e-02f, -5.85401468e-02f, 1.40134960e-01f, 1.35438994e-01f, 1.67024210e-02f, 2.30996817e-01f, -1.62220463e-01f, -1.12769000e-01f, -3.06570977e-01f, 2.06183314e-01f,
  -4.82023627e-01f, -1.57731831e-01f, -2.91508324e-02f, -1.31436318e-01f, 1.11337684e-01f, -3.28557760e-01f, 1.06046788e-01f, 1.81960508e-01f, 2.01189563e-01f, 2.91112848e-02f,
  1.30737171e-01f, 4.16220099e-01f, 1.92804039e-01f, -1.34384543e-01f, 5.28160095e-01f, 1.08696409e-02f, -2.60666251e-01f, -2.73628920e-01f, 2.40829214e-01f, -1.01926893e-01f,
  1.38505057e-01f, 4.61731292e-02f, 1.34798959e-01f, 1.25596374e-01f, 6.57932982e-02f, -9.90176946e-02f, -1.90344807e-02f, -6.21422119e-02f, 1.49984226e-01f, -6.35844544e-02f,
  -6.41434640e-02f, -1.22914642e-01f, 9.00980309e-02f, 2.07678508e-02f, -1.83836892e-01f, 9.58744213e-02f, -2.23308560e-02f, -2.03872830e-01f, 1.23338141e-01f, -1.68670744e-01f,
  -4.14953940e-02f, -7.39618838e-02f, -1.48872182e-01f, -5.25857694e-02f, -1.13799773e-01f, -1.14390068e-01f, 9.37369093e-02f, 1.32899284e-01f, -1.34532273e-01f, -4.99457754e-02f,
  -6.89696819e-02f, 8.66076630e-03f, 1.91695970e-02f, 1.08180694e-01f, 1.98207483e-01f, -5.13931327e-02f, -1.15257427e-01f, 1.77773666e-02f, 2.84104683e-02f, 1.67157814e-01f,
  2.01605126e-01f, -2.68163029e-02f, 5.68780564e-02f, -4.84101325e-02f, 1.20954201e-01f, 1.15316607e-01f, -1.13283709e-01f, -5.79438917e-02f, -3.67613696e-02f, 2.21543889e-02f,
  -1.07920812e-02f, 7.00659398e-03f, 1.49339691e-01f, 1.98783919e-01f, 3.78742926e-02f, -1.60126820e-01f, 2.30733808e-02f, -1.03575118e-01f, -9.81503874e-02f, -1.90929383e-01f,
  2.27670729e-01f, -5.71820885e-02f, 2.26443559e-01f, 1.28939822e-01f, 4.89846384e-03f, 5.11236638e-02f, -1.61834098e-02f, -8.53345096e-02f, -9.15140496e-04f, 1.66453980e-02f,
  6.06882051e-02f, 5.15688621e-02f, -9.45478305e-02f, -2.51093134e-02f, 3.85940932e-02f, -4.59698727e-03f, 5.22941053e-02f, 2.65836921e-02f, 1.58646628e-02f, 1.68230683e-01f,
  1.13548681e-01f, -1.11004084e-01f, -4.36719134e-02f, 1.09526582e-01f, 9.39649418e-02f, 6.57826513e-02f, 7.98669532e-02f, -1.76113650e-01f, 6.83744028e-02f, 1.05149142e-01f,
  8.82293135e-02f, 1.56084508e-01f, 2.72721220e-02f, -1.29686520e-01f, 1.45958632e-01f, 1.09338805e-01f, 1.41803533e-01f, 3.73576209e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -7.06767365e-02f, -1.49724677e-01f, 1.47714883e-01f, 2.55920500e-01f, 3.46689187e-02f, 1.80585697e-01f, 2.58365571e-01f, -5.15393429e-02f, 1.94041394e-02f, 9.41004977e-02f,
  1.84101194e-01f, -5.28613850e-02f, -1.08960070e-01f, -1.79954410e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.78391838e-01f, 9.78886634e-02f, 1.72956944e-01f, 2.58704633e-01f, -4.60571386e-02f, -3.93849425e-03f, 3.29822987e-01f, 1.92860886e-01f, 2.53570884e-01f, 3.31075102e-01f,
  1.30067110e-01f, 7.45057315e-02f, 4.65555163e-03f, -3.31664473e-01f, 1.33544773e-01f, 1.94548264e-01f, 2.07840577e-01f, 2.84138452e-02f, 2.78254524e-02f, -3.91463414e-02f,
  -3.84148434e-02f, 2.31639490e-01f, -1.50164440e-01f, 2.77739853e-01f, 1.80733912e-02f, -1.94912761e-01f, 1.52002096e-01f, -1.94917127e-01f, -3.85607406e-02f, 5.76364100e-02f,
  1.35774195e-01f, -9.77287143e-02f, -1.98437832e-04f, 5.29801548e-02f, 1.07937947e-01f, -4.36715260e-02f, -6.62084967e-02f, -2.35639766e-01f, 2.48047143e-01f, 1.57277226e-01f,
  1.46401271e-01f, 3.45352292e-01f, -4.80325408e-02f, -2.08906934e-01f, 2.58499712e-01f, -2.31122151e-02f, -2.49413833e-01f, 3.68297905e-01f, 4.19973098e-02f, 3.92092049e-01f,
  1.29542276e-01f, 1.92352504e-01f, 2.52019882e-01f, -3.67161810e-01f, -4.05574255e-02f, 1.62396178e-01f, -5.84041998e-02f, -9.90808979e-02f, -1.57110207e-02f, -2.17728391e-01f,
  5.34548998e-01f, -3.92913558e-02f, 2.09553353e-02f, -8.79851505e-02f, 9.42674726e-02f, 5.84349921e-03f, -2.75685400e-01f, 1.19657770e-01f, 1.58459365e-01f, -1.68124989e-01f,
  1.03755623e-01f, 5.78607582e-02f, 1.92365833e-02f, 2.70039625e-02f, 4.18370694e-01f, -1.44168377e-01f, -2.20062494e-01f, 1.05143942e-01f, 3.47235262e-01f, 1.69857994e-01f,
  -4.12237912e-01f, 9.08958092e-02f, -1.26795694e-01f, -2.94702668e-02f, -1.46543846e-01f, 1.40258282e-01f, 2.10275903e-01f, 1.54271334e-01f, 9.66328830e-02f, -2.28150070e-01f,
  -1.04278296e-01f, -1.58481255e-01f, -1.63551614e-01f, -1.81317870e-02f, -2.32216805e-01f, -9.72638726e-02f, 2.10831389e-02f, -2.93193534e-02f, 1.84522092e-01f, 2.33416725e-02f,
  -1.36172459e-01f, -1.98417023e-01f, -2.03408152e-01f, -2.69442827e-01f, -1.87469527e-01f, 1.76780373e-01f, -4.41545695e-01f, 2.42923453e-01f, 1.70545965e-01f, -1.41792938e-01f,
  -3.80718470e-01f, -1.34409845e-01f, 4.31472570e-01f, 3.92419882e-02f, 1.36412412e-01f, -8.30678940e-02f, 1.85233597e-02f, -5.54416925e-02f, -3.14790875e-01f, -3.57969731e-01f,
  1.13288239e-01f, 2.03026518e-01f, 1.09500878e-01f, 2.29134291e-01f, 1.59708768e-01f, 1.01734735e-02f, 1.38099447e-01f, 8.14278871e-02f, -8.22445154e-02f, -2.65144762e-02f,
  -1.08908840e-01f, -1.61793068e-01f, 6.43667355e-02f, 4.21195775e-02f, -2.89305560e-02f, -2.89477289e-01f, -9.43117291e-02f, -1.27298892e-01f, -1.52055502e-01f, 2.99183458e-01f,
  -2.84754485e-02f, 2.43321303e-02f, -2.36269593e-01f, 1.75327182e-01f, 3.27973187e-01f, -5.49309999e-02f, 1.24652624e-01f, -1.90931812e-01f, -8.42738524e-02f, 2.73801051e-02f,
  -7.39656612e-02f, -3.07593197e-01f, -1.82558715e-01f, 4.16294672e-02f, 3.43592875e-02f, 1.47006333e-01f, -1.79127410e-01f, 1.58603847e-01f, 2.20257759e-01f, -4.89701703e-03f,
  2.50503719e-01f, 2.88390696e-01f, 2.49639899e-01f, 3.53237577e-02f, 2.16127932e-01f, 1.17718196e-02f, 1.50948688e-01f, 7.71120861e-02f, 1.18369207e-01f, 2.25598991e-01f,
  -1.36525035e-01f, 2.06391156e-01f, -3.89345251e-02f, -2.31685027e-01f, -2.07933545e-01f, 3.18910122e-01f, 4.75703567e-01f, -9.23230574e-02f, -1.63876653e-01f, 9.06720832e-02f,
  1.02685042e-01f, -8.74505341e-02f, 4.87049557e-02f, 9.39321816e-02f, -1.50474072e-01f, 4.86369617e-02f, -1.24824651e-01f, -2.90140361e-01f, -8.03385824e-02f, 1.12502709e-01f,
  3.54471081e-03f, -1.56108066e-01f, -8.18435103e-02f, 1.10547788e-01f, 9.88094285e-02f, -3.07391938e-02f, -1.29421815e-01f, -9.38789174e-02f, -1.25558883e-01f, 1.65679887e-01f,
  1.58548564e-01f, 8.54327083e-02f, 2.28555754e-01f, -2.10664243e-01f, -6.99099377e-02f, -3.76979150e-02f, 2.60035872e-01f, 1.35064572e-01f, -3.02248299e-01f, 1.71596378e-01f,
  -1.50680184e-01f, -1.36889340e-02f, 2.11390093e-01f, 2.50831634e-01f, -1.34129539e-01f, 8.53487775e-02f, 9.53027010e-02f, -3.00346941e-01f, 9.95734707e-02f, -1.43119141e-01f,
  1.76274702e-01f, -1.02243967e-01f, -1.36194617e-01f, -8.45481083e-02f, 1.46216556e-01f, -5.03337830e-02f, 1.74293295e-01f, -2.40329504e-02f, -2.01727152e-01f, -1.62538737e-01f,
  3.65114003e-01f, 1.50851216e-02f, 4.77013364e-02f, 5.41267991e-01f, 5.70804020e-03f, -2.49391556e-01f, 2.82177567e-01f, -3.33420008e-01f, -7.45165348e-02f, 3.41907814e-02f,
  8.15529674e-02f, 3.40848505e-01f, 1.67181656e-01f, 3.37125175e-02f, 1.08272083e-01f, 1.24698892e-01f, -6.67426437e-02f, 5.90702668e-02f, 9.71866474e-02f, -2.44168863e-02f,
  2.36092627e-01f, -1.75762326e-01f, 4.09133136e-01f, -8.41318369e-02f, -2.30681300e-01f, 1.65075630e-01f, 8.62227306e-02f, -3.01487446e-01f, -1.65366605e-01f, -1.77639008e-01f,
  -8.62822309e-02f, 8.68712645e-03f, 3.71056572e-02f, 1.81040391e-01f, 2.58993842e-02f, 2.01771721e-01f, 5.67652322e-02f, -2.30433464e-01f, -4.80483891e-03f, 3.03735565e-02f,
  9.94685218e-02f, -1.75363407e-01f, -3.75634074e-01f, -7.05384165e-02f, 1.16756789e-01f, 4.42836024e-02f, -1.01614922e-01f, -2.85813399e-03f, 2.49072790e-01f, 1.10069595e-01f,
  3.13005090e-01f, -6.60604015e-02f, 1.01586580e-01f, -1.74146742e-01f, 2.30645016e-01f, 7.49650374e-02f, -8.65768343e-02f, 1.58040792e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -9.31085423e-02f, -1.03078783e-02f, 8.83919969e-02f, -6.34544492e-02f, 4.64592874e-02f, 1.12126142e-01f, -2.36972570e-02f, -1.62968487e-02f, -1.41967356e-01f, -9.44098905e-02f,
  1.19047590e-01f, 9.80813801e-02f, 1.48920387e-01f, -1.19788967e-01f, -6.19811676e-02f, 1.71837822e-01f, -7.10005239e-02f, 8.58683586e-02f, 1.12952739e-01f, -1.23033822e-01f,
  5.63468970e-02f, -1.36105850e-01f, -2.22479701e-02f, -2.68139001e-02f, 6.38580089e-03f, -1.15278676e-01f, 5.84299527e-02f, -3.34070995e-02f, -1.75843120e-01f, -6.93503842e-02f,
  1.31100848e-01f, 1.43898157e-02f, 2.13314012e-01f, 1.19759761e-01f, 2.47573495e-01f, 2.36709535e-01f, -8.75390768e-02f, 2.90034954e-02f, 8.24707560e-03f, -1.33247375e-01f,
  1.39682412e-01f, -1.87835089e-04f, -1.90185323e-01f, 2.00812649e-02f, -4.63730879e-02f, -1.18559882e-01f, 3.25426795e-02f, -4.21642140e-03f, 9.69642028e-02f, -7.54579455e-02f,
  6.74177036e-02f, 1.58018127e-01f, 4.09750268e-02f, 1.53932855e-01f, 2.04296336e-01f, 7.84838200e-02f, -1.39213711e-01f, -4.63748835e-02f, -8.76848921e-02f, 1.95459411e-01f,
  -2.42511749e-01f, 1.86201617e-01f, -1.21634588e-01f, 1.63278893e-01f, -5.38737047e-03f, 6.75877631e-02f, 1.21117845e-01f, -1.01734661e-02f, -6.04844317e-02f, 1.80518791e-01f,
  -4.32294086e-02f, 7.56333619e-02f, 1.90605640e-01f, 5.99021167e-02f, -7.54502416e-02f, 4.19640094e-02f, -1.07410923e-01f, 6.96434528e-02f, -1.35658368e-01f, 1.46739706e-01f,
  1.81881949e-01f, 5.12344111e-03f, 9.76184309e-02f, 1.44895643e-01f, 1.20248601e-01f, -2.50317771e-02f, -1.41999833e-02f, 1.39259221e-03f, 1.14620730e-01f, -4.90501933e-02f,
  -2.28429176e-02f, -1.76889986e-01f, 8.53021592e-02f, 1.69826090e-01f, -1.75502673e-01f, 1.28615841e-01f, -5.31767830e-02f, 1.90880650e-03f, -2.92497799e-02f, 8.95349532e-02f,
  1.69271380e-01f, 9.14219171e-02f, 2.90053282e-02f, -1.36030167e-01f, -1.44419581e-01f, -1.44206449e-01f, 7.12743327e-02f, 1.36516288e-01f, 8.06169286e-02f, -1.83171816e-02f,
  1.33251339e-01f, 3.06223705e-02f, 1.72425017e-01f, 1.60993159e-01f, 7.94668198e-02f, -4.52053063e-02f, -1.50168926e-01f, -1.48449942e-01f, 8.91286656e-02f, -5.37714884e-02f,
  -1.73530877e-01f, 9.83939022e-02f, -3.39311697e-02f, 5.83696142e-02f, 4.80322614e-02f, 7.13722557e-02f, -1.37616858e-01f, 1.26553342e-01f, -6.53213114e-02f, 8.12750217e-03f,
  -9.24389716e-03f, 1.38405785e-01f, 2.13742003e-01f, 2.52574533e-01f, 3.88373993e-02f, 1.24399215e-01f, 2.52097815e-01f, 1.00559331e-01f, 1.65117681e-01f, 2.32906699e-01f,
  8.82957429e-02f, -6.62751049e-02f, 1.13176659e-01f, 2.24328503e-01f, 1.59285977e-01f, -1.29645213e-01f, -1.18179165e-01f, 9.58459228e-02f, 9.33464617e-02f, -1.63798809e-01f,
  -1.95178837e-01f, 1.60227697e-02f, -9.49594975e-02f, 3.14406082e-02f, -1.76696524e-01f, 1.04782172e-01f, -1.32565737e-01f, 1.59385115e-01f, -4.82158503e-03f, -7.64747113e-02f,
  8.00999030e-02f, 1.16735302e-01f, 1.59237161e-01f, -5.11492677e-02f, 1.41805872e-01f, 9.52364970e-03f, -1.14562333e-01f, -2.68456154e-02f, 1.24476086e-02f, -2.32103512e-01f,
  1.20157618e-02f, -2.78856978e-02f, 1.27559587e-01f, -7.15829805e-02f, 1.80435717e-01f, 1.55900210e-01f, 1.43673822e-01f, -2.71316111e-01f, 4.54776585e-02f, -6.61179274e-02f,
  1.22834310e-01f, 1.11007586e-01f, 1.14525529e-02f, 4.30502705e-02f, 1.66366011e-01f, 7.67969638e-02f, -1.41491285e-02f, -1.18699977e-02f, -1.40454665e-01f, -1.67619798e-03f,
  8.69732648e-02f, 1.63865402e-01f, 3.91742326e-02f, 1.11741778e-02f, 1.50250152e-01f, 1.82930559e-01f, 3.08641523e-01f, 1.26096944e-03f, 5.03026918e-02f, 1.46212846e-01f,
  2.03906372e-01f, -7.97283947e-02f, 3.91127855e-01f, -3.86366785e-01f, -3.99896562e-01f, 2.54450768e-01f, 4.11239028e-01f, -2.06220999e-01f, -3.31048667e-01f, -2.31121853e-02f,
  1.34023249e-01f, 8.34173858e-02f, 4.58653830e-02f, 1.21756017e-01f, 3.34497362e-01f, 1.86990157e-01f, 3.86349827e-01f, -3.24040145e-01f, -3.11311819e-02f, 2.00840920e-01f,
  -3.05634767e-01f, -6.90949112e-02f, -1.70083329e-01f, -8.77029523e-02f, 1.82983577e-01f, 7.07538351e-02f, -4.62326854e-02f, 1.20016359e-01f, 2.42510229e-01f, 3.94117385e-02f,
  2.07976103e-01f, 2.78688818e-01f, 1.79660395e-01f, -1.87771395e-02f, 3.63863289e-01f, -2.33725488e-01f, -2.14930683e-01f, -1.18928045e-01f, 2.15548649e-01f, 1.54699907e-01f,
  -2.10103497e-01f, -5.63398600e-02f, -1.41059741e-01f, -1.15801163e-01f, -1.89895615e-01f, 3.52528006e-01f, 3.22226584e-01f, 4.81386274e-01f, 3.28060314e-02f, -2.11181864e-01f,
  -1.27692565e-01f, -3.50294530e-01f, 1.86824620e-01f, -1.62388105e-02f, 1.28557578e-01f, -3.50908823e-02f, 8.05994943e-02f, -4.59076948e-02f, -1.08097091e-01f, 2.25041449e-01f,
  1.44824654e-01f, 2.66366694e-02f, 1.44058943e-01f, 2.59279204e-03f, 2.44063795e-01f, 3.39280456e-01f, 2.65725821e-01f, -3.58586282e-01f, -1.07705526e-01f, -1.56683430e-01f,
  1.77739650e-01f, 6.32196888e-02f, -3.93274277e-01f, 1.37240991e-01f, -9.10631195e-02f, -3.07331532e-02f, 3.80272232e-02f, -1.69910789e-02f, 5.75573035e-02f, 5.34781396e-01f,
  1.80111930e-01f, -2.75634885e-01f, 9.44699943e-02f, -2.29959279e-01f, 3.63155812e-01f, 9.20385644e-02f, -1.63916703e-02f, -6.39654920e-02f, 3.83220501e-02f, 1.80231452e-01f,
  1.27362564e-01f, 1.15585290e-01f, 2.71996379e-01f, -9.12978724e-02f, -1.42803878e-01f, 2.37033278e-01f, 5.56192622e-02f, -1.25850886e-02f, 3.06867599e-01f, -2.21033216e-01f,
  -3.35078478e-01f, 9.84226912e-02f, 3.59584570e-01f, -2.44422883e-01f, -2.36313686e-01f, -3.16978067e-01f, 2.58037988e-02f, -7.65458941e-02f, -9.80344638e-02f, 1.08397573e-01f,
  4.66856509e-01f, -5.46657704e-02f, 4.90180075e-01f, 1.50259227e-01f, 1.26697019e-01f, 1.40732333e-01f, -1.77798539e-01f, -7.36695677e-02f, 2.31053829e-01f, 8.03195611e-02f,
  3.11851911e-02f, 5.56833623e-03f, 1.53786033e-01f, 1.80030912e-01f, -7.79174641e-02f, -4.21169810e-02f, -1.61316589e-01f, 1.99239507e-01f, 1.27109587e-02f, 9.04009789e-02f,
  1.31615296e-01f, -3.03798884e-01f, -2.38929495e-01f, 2.17621490e-01f, -2.73725595e-02f, -2.13776827e-02f, -1.14184819e-01f, -1.58922717e-01f, -1.20812282e-01f, 3.75388861e-02f,
  9.40668657e-02f, 2.95590926e-02f, 2.15313494e-01f, 2.51532998e-02f, 2.49864101e-01f, 1.65206894e-01f, 3.37708928e-02f, 2.26066247e-01f, 6.47407863e-03f, 1.17361441e-01f,
  1.46659315e-01f, 4.37081940e-02f, 3.09235215e-01f, 4.96397406e-01f, 5.43888450e-01f, 5.58173835e-01f, 4.53165382e-01f, 3.26957285e-01f, 4.58775103e-01f, -1.22274049e-01f,
  1.83443293e-01f, 6.11182094e-01f, -3.18069488e-01f, 2.94144541e-01f, 1.82260871e-01f, -4.61259007e-01f, -4.09411997e-01f, 1.49775773e-01f, 5.77454329e-01f, 3.27974886e-01f,
  5.05156582e-03f, -1.58505619e-01f, -6.73547834e-02f, 2.42858723e-01f, -1.52916566e-01f, 3.08156013e-01f, -8.41821730e-03f, 2.60605484e-01f, 7.26506263e-02f, 5.98298386e-02f,
  6.11431181e-01f, 2.00837880e-01f, -1.86937764e-01f, -5.45003526e-02f, -1.52239785e-01f, -3.08788810e-02f, 1.65926684e-02f, 1.41750917e-01f, -9.30219814e-02f, 6.90777302e-02f,
  -1.20194413e-01f, 6.65583163e-02f, 1.46449327e-01f, -1.12710990e-01f, -7.08190501e-02f, -1.54323410e-02f, -1.60004795e-01f, -7.48834759e-02f, -1.12971365e-01f, 6.08884776e-03f,
  -4.91232201e-02f, 1.56597003e-01f, -1.32371902e-01f, 1.23554155e-01f, 5.76361679e-02f, -4.84409593e-02f, -9.11878236e-03f, 1.18767783e-01f, 4.22429629e-02f, -8.72931182e-02f,
  2.49194130e-02f, 3.14017870e-02f, 1.63652435e-01f, 1.43638756e-02f, 3.56923379e-02f, 1.29145458e-02f, 2.53517091e-01f, 2.26715192e-01f, -2.89807990e-02f, 2.05093265e-01f,
  3.00508291e-01f, 5.66195957e-02f, -4.09911051e-02f, 3.76608633e-02f, 1.70463230e-02f, -3.18730563e-01f, 4.22336124e-02f, 8.40248540e-02f, -8.65317509e-03f, 2.10579455e-01f,
  -7.36347288e-02f, -1.67759299e-01f, 1.89513519e-01f, -2.20880538e-01f, 8.58496055e-02f, 1.27458647e-01f, -1.66825294e-01f, 5.03703132e-02f, -1.67150870e-02f, -1.54812820e-02f,
  1.11209899e-02f, 2.13967726e-01f, -2.15509340e-01f, 6.68761432e-02f, -2.53283143e-01f, -6.98675662e-02f, 5.21852076e-03f, -1.33681059e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.53598428e-01f, 1.89035982e-01f, -1.21397905e-01f, 1.98979571e-01f, 3.81140336e-02f, 6.36208206e-02f, 2.91282237e-01f, 2.32244387e-01f, 2.38883585e-01f, 2.51835406e-01f,
  1.41812459e-01f, 3.55414540e-01f, -3.73199433e-02f, -5.69912940e-02f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -4.01398800e-02f, -1.10999152e-01f, 1.29547626e-01f, 1.38336852e-01f, 1.29355237e-01f, -8.55992064e-02f, 8.01751688e-02f, -5.79347722e-02f, 1.62595838e-01f, -8.32388643e-03f,
  3.60648900e-01f, -2.74217129e-01f, 1.56824365e-01f, 6.38080239e-02f, 3.63288343e-01f, -2.58029222e-01f, 5.62762022e-02f, -2.83086151e-01f, 1.69506162e-01f, 4.02774327e-02f,
  -1.06911875e-01f, -7.72589520e-02f, 2.22129315e-01f, -1.11878037e-01f, -2.30893016e-01f, 1.26469687e-01f, 7.88306966e-02f, -4.92841840e-01f, -2.38348663e-01f, 4.17225778e-01f,
  -9.91745070e-02f, -1.16369389e-02f, -1.57946199e-02f, -1.92129016e-01f, 1.42250091e-01f, -1.37634993e-01f, 2.59382278e-01f, -1.80671975e-01f, -1.07793473e-02f, 1.01447232e-01f,
  1.61268175e-01f, 4.21766602e-02f, -2.06484403e-02f, -3.37716699e-01f, 2.64470220e-01f, 2.14820594e-01f, 1.82043493e-01f, -8.77148435e-02f, 2.36702725e-01f, -1.55748710e-01f,
  1.10561855e-01f, 1.28934458e-01f, 1.02819726e-01f, 7.65079558e-02f, -2.13141263e-01f, 1.11554235e-01f, -3.88409376e-01f, -1.48699820e-01f, -2.93301404e-01f, -2.60087848e-01f,
  1.16030008e-01f, 3.01943690e-01f, -1.00220099e-01f, -5.20353317e-02f, 2.36713886e-02f, -8.30475315e-02f, 1.67293191e-01f, 1.47028670e-01f, -2.32204958e-03f, -3.84867340e-02f,
  -3.02444380e-02f, 2.85274744e-01f, 1.55419394e-01f, -1.02415740e-01f, -4.83610660e-01f, -1.80172369e-01f, 1.99411392e-01f, 1.27283916e-01f, 7.19058439e-02f, -1.75707445e-01f,
  -1.73030838e-01f, -2.61207610e-01f, 2.98588648e-02f, 1.63827911e-01f, -1.44748166e-01f, 8.42677876e-02f, 3.80722689e-03f, 2.26349816e-01f, -3.03205192e-01f, -2.74644136e-01f,
  -4.02266443e-01f, 1.79147542e-01f, 1.09999105e-02f, 9.93733481e-03f, 8.34251344e-02f, 2.20016763e-01f, -3.12972486e-01f, -2.34412014e-01f, 4.45045605e-02f, 2.30029911e-01f,
  -1.74413323e-01f, -2.47687370e-01f, 2.23838970e-01f, -1.60469890e-01f, 8.62009972e-02f, 1.88332126e-01f, 3.19259971e-01f, 7.82785341e-02f, -1.22825719e-01f, -1.26897231e-01f,
  9.15935859e-02f, 1.58028454e-01f, 3.31289977e-01f, 1.19880810e-01f, 1.43285051e-01f, 1.86587185e-01f, 1.34514675e-01f, 1.16282433e-01f, 4.27802699e-03f, -6.57127574e-02f,
  -1.09982356e-01f, 8.91625136e-02f, 5.76647073e-02f, -2.67992765e-01f, -1.74916610e-01f, 2.94520378e-01f, -9.92908701e-02f, -2.92169660e-01f, -1.55670092e-01f, 7.72251710e-02f,
  -1.87524170e-01f, 7.94586260e-03f, 1.04950359e-02f, -1.49657100e-01f, 2.95398198e-03f, -2.58890688e-01f, -2.13010132e-01f, -4.25516535e-03f, 1.28045678e-01f, -8.85011107e-02f,
  3.55826885e-01f, -2.18410641e-02f, 7.68350065e-02f, -5.17035350e-02f, 5.81319965e-02f, 8.62600356e-02f, -5.20496257e-02f, -1.90506116e-01f, 1.44018129e-01f, -1.99253423e-04f,
  1.05559863e-01f, -6.26932383e-02f, -3.12824368e-01f, -9.41711813e-02f, 1.30329266e-01f, -2.19629243e-01f, -2.40283478e-02f, 3.10465932e-01f, -1.36998475e-01f, -2.21548855e-01f,
  8.65122229e-02f, -3.86489332e-01f, -2.02691406e-01f, -2.94511139e-01f, -1.17607512e-01f, 3.20675522e-01f, -2.30804645e-02f, -1.74981594e-01f, 7.32653439e-02f, -5.83245493e-02f,
  -2.46907488e-01f, 1.42995447e-01f, -2.31414407e-01f, 6.48691878e-02f, -2.69894481e-01f, 2.94010997e-01f, -8.73977505e-03f, 2.19731435e-01f, 1.08352385e-01f, -1.47069290e-01f,
  -1.69289693e-01f, -1.65286645e-01f, -1.98908836e-01f, 8.88511166e-02f, 7.34398067e-02f, 1.51473582e-01f, -5.79117760e-02f, 8.63890350e-02f, 1.44727752e-01f, -5.24078071e-01f,
  -5.38170971e-02f, -1.94844857e-01f, 1.18346296e-01f, -1.57686695e-01f, 9.10670087e-02f, 9.04300958e-02f, 4.41276357e-02f, 2.63944957e-02f, 1.38928145e-01f, 7.95368254e-02f,
  7.32190982e-02f, -1.92768753e-01f, -2.21133888e-01f, 1.93720013e-02f, -2.72390544e-01f, 8.67696106e-02f, -3.82186174e-01f, -1.65268123e-01f, -3.60421628e-01f, 3.20655182e-02f,
  3.89925167e-02f, -7.84812346e-02f, -1.24019936e-01f, -6.56343326e-02f, -9.40551534e-02f, 1.72640741e-01f, 2.67325014e-01f, 1.62976429e-01f, -8.56645927e-02f, 3.23873103e-01f,
  1.12681963e-01f, -7.12333143e-01f, 6.65271133e-02f, 1.83890089e-01f, -1.30947798e-01f, -1.71738118e-02f, -1.67516433e-02f, 1.01687670e-01f, -2.11776823e-01f, -2.35097438e-01f,
  -7.01399222e-02f, -3.33677709e-01f, -1.83258116e-01f, -1.35061473e-01f, 4.91970539e-01f, -3.87474775e-01f, 4.24742103e-01f, -1.11975610e-01f, 2.39677858e-02f, 5.40921800e-02f,
  2.59109527e-01f, -5.16770221e-02f, 2.71494943e-03f, -1.86556652e-02f, -5.43189831e-02f, 7.00845988e-03f, -6.01509474e-02f, 3.95372743e-04f, -2.72956967e-01f, -2.95620501e-01f,
  1.86582759e-01f, -2.12245688e-01f, 6.09803833e-02f, 3.60712796e-01f, -5.48363626e-02f, -1.43992618e-01f, -2.21647426e-01f, -1.26569301e-01f, -2.92849112e-02f, -2.10947871e-01f,
  -2.07412139e-01f, 6.57953769e-02f, -7.82603770e-02f, -9.57413986e-02f, 1.34358570e-01f, 2.03642279e-01f, 4.91779745e-01f, -1.19514897e-01f, 2.54851222e-01f, 1.80567876e-02f,
  1.86325237e-01f, 7.77618811e-02f, 4.79366630e-01f, 2.57991105e-01f, 3.75247039e-02f, -2.02656224e-01f, 1.55946299e-01f, -1.75793871e-01f, -2.09306851e-01f, -2.14350641e-01f,
  1.96342897e-02f, 2.87945241e-01f, 2.55389750e-01f, -9.97825339e-02f, -3.83991003e-03f, 3.16676110e-01f, 2.82919197e-03f, -2.69264549e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  7.27632083e-03f, -7.56806461e-03f, 7.61849508e-02f, -1.15345374e-01f, -1.09725624e-01f, -5.15971296e-02f, -7.71241412e-02f, 1.09579219e-02f, 2.37218017e-04f, -1.90354943e-01f,
  -6.85207993e-02f, 1.01138957e-01f, 1.32851109e-01f, 3.61302192e-03f, -3.30573544e-02f, 1.26419470e-01f, 7.97138438e-02f, -9.07214880e-02f, -7.25606084e-02f, -1.89597696e-01f,
  -1.42339319e-01f, 1.17337964e-02f, 4.72333506e-02f, -1.43711166e-02f, -4.90737967e-02f, -5.71338870e-02f, 3.14707682e-02f, -1.15453511e-01f, -2.62169000e-02f, 1.17379287e-03f,
  5.61141595e-03f, 4.21774872e-02f, 3.32180083e-01f, -2.20778733e-01f, 2.45990664e-01f, 2.04384714e-01f, 1.78210601e-01f, 2.32361391e-01f, 1.09092221e-01f, 1.01867490e-01f,
  2.24333361e-01f, -3.46354932e-01f, -1.06007479e-01f, -1.12897046e-01f, -2.34235600e-01f, -2.36877248e-01f, -4.14282620e-01f, 1.29804596e-01f, -1.64887175e-01f, 7.73149654e-02f,
  5.35917841e-03f, 6.89178556e-02f, -1.27543256e-01f, -1.26954559e-02f, 1.13370433e-01f, -1.02689631e-01f, 3.27498555e-01f, -2.82991886e-01f, -3.24508399e-01f, 4.97799665e-01f,
  4.30499107e-01f, -3.29664707e-01f, 8.81505236e-02f, -8.36519003e-02f, 4.03833725e-02f, -8.35591480e-02f, -3.99175361e-02f, -6.50544465e-02f, -2.77298838e-01f, -2.50470191e-02f,
  -2.46638492e-01f, -2.63966858e-01f, -1.74102232e-01f, 2.69866623e-02f, -2.10199542e-02f, 1.17284931e-01f, -1.25280887e-01f, 1.02774315e-01f, -3.88289094e-02f, 1.86746642e-01f,
  4.69178110e-02f, -3.41496132e-02f, 1.08938918e-01f, -1.86272219e-01f, -7.03309700e-02f, 3.94134261e-02f, -2.27874238e-02f, -1.40570879e-01f, 1.49556443e-01f, 1.04261167e-01f,
  4.01879139e-02f, 1.58937678e-01f, 6.26136214e-02f, 2.20557675e-02f, -1.33027270e-01f, -4.73568253e-02f, 5.92578948e-02f, -2.20579162e-01f, -2.24058256e-01f, 3.56547087e-02f,
  2.38482747e-02f, 2.98758261e-02f, 1.14961356e-01f, -1.13103926e-01f, 2.51177490e-01f, -2.08667517e-01f, 5.61737232e-02f, -3.48731726e-01f, 3.07132125e-01f, 2.98711043e-02f,
  -4.07068096e-02f, -7.93620050e-02f, 3.35187048e-01f, 5.69374859e-02f, -8.72158334e-02f, -7.06485286e-02f, -9.19500664e-02f, 4.04527932e-02f, -1.50991306e-01f, -5.99018559e-02f,
  -9.65062231e-02f, -2.17095450e-01f, -1.27655610e-01f, 2.03154683e-01f, 6.37136996e-02f, 4.08139616e-01f, 4.04830165e-02f, 9.74443704e-02f, -2.79077012e-02f, 1.83560297e-01f,
  -1.54052884e-03f, -2.25263804e-01f, -6.73507825e-02f, 2.05724508e-01f, 2.28609115e-01f, 4.29812551e-01f, -2.15506200e-02f, 8.44586119e-02f, -2.28596136e-01f, 3.71054947e-01f,
  -4.12932694e-01f, -3.44182491e-01f, -7.58462101e-02f, 2.34694228e-01f, -1.17142208e-01f, 1.20948568e-01f, 9.36771184e-02f, 9.49349105e-02f, -1.49561062e-01f, -8.16853940e-02f,
  -1.04215257e-01f, 2.11909339e-02f, 7.48680174e-01f, 5.67285657e-01f, 1.59343883e-01f, 4.67964470e-01f, 2.27517620e-01f, -4.74035740e-01f, -1.29196914e-02f, 1.59151465e-01f,
  -1.33622035e-01f, -1.59287855e-01f, -2.21113898e-02f, 1.13696866e-01f, -3.70371193e-02f, -1.17304482e-01f, -1.29047439e-01f, 1.90954015e-01f, 1.30859822e-01f, 7.81366751e-02f,
  -1.02429762e-01f, 1.06713913e-01f, 1.14531539e-01f, -1.16613796e-02f, 1.82977602e-01f, 1.31574526e-01f, 1.81884363e-01f, -1.48817912e-01f, -1.46343019e-02f, 3.87662388e-02f,
  6.19668886e-02f, -6.58037290e-02f, 1.31513163e-01f, -1.65824264e-01f, -2.11763196e-02f, -6.57436773e-02f, -5.96783906e-02f, -1.40411882e-02f, -9.77864787e-02f, -1.31582811e-01f,
  3.09448049e-04f, -1.78232864e-01f, 9.68648642e-02f, -4.66258861e-02f, -1.39527857e-01f, -1.01172924e-01f, -3.42696130e-01f, 2.68102616e-01f, -1.00429930e-01f, -2.45154183e-02f,
  -2.91773558e-01f, 1.62801906e-01f, 7.86872208e-02f, 8.73765722e-02f, 9.92076620e-02f, 1.45320803e-01f, -1.85173199e-01f, -4.93169203e-02f, 2.22044587e-01f, 1.72786757e-01f,
  -4.20238860e-02f, -3.10556628e-02f, 2.19512470e-02f, -2.04958946e-01f, -1.13087915e-01f, -1.66595861e-01f, 3.22390199e-01f, 1.70897156e-01f, 3.83107752e-01f, 2.85477024e-02f,
  2.48627633e-01f, -7.20479488e-02f, 1.94650516e-01f, -1.74573109e-01f, 1.38380155e-01f, -1.08383454e-01f, -1.22397728e-01f, -2.77607627e-02f, 4.19566780e-02f, -4.65398282e-02f,
  -2.76269056e-02f, -8.23031962e-02f, 6.84568658e-02f, 3.69150043e-02f, 2.00864878e-02f, -1.30172476e-01f, -3.24844904e-02f, -1.08662613e-01f, 3.16362642e-02f, 1.08889177e-01f,
  1.85600758e-01f, -1.22977018e-01f, -1.00993607e-02f, -1.25914708e-01f, 4.16691676e-02f, 8.82255808e-02f, -1.19717615e-02f, -1.62017807e-01f, -7.49302804e-02f, 1.51312575e-01f,
  4.26565111e-02f, -2.65870363e-01f, 3.24612521e-02f, 4.12746012e-01f, 2.07948402e-01f, -2.89227366e-02f, 3.60530731e-03f, 1.16647929e-01f, 9.25430842e-03f, -1.08798891e-01f,
  -3.01005300e-02f, -3.99445510e-03f, 4.07736972e-02f, -1.05324470e-01f, -6.77978769e-02f, -1.13198169e-01f, 8.61762986e-02f, -1.03381701e-01f, -2.45442092e-02f, 1.42978802e-01f,
  1.09432027e-01f, 1.37996897e-01f, -1.33362770e-01f, 1.01174377e-01f, -2.13499367e-02f, 1.19050801e-01f, -1.63539231e-01f, 6.24942109e-02f, 1.04642235e-01f, 1.05671827e-02f,
  -5.65446801e-02f, -7.17592239e-02f, -1.16931684e-01f, -1.69029146e-01f, 8.65666047e-02f, -1.44882366e-01f, 1.68088898e-01f, -2.83048023e-02f, 1.57620057e-01f, 1.97727442e-01f,
  -1.44850299e-01f, -1.02350138e-01f, -1.81878611e-01f, 2.08625704e-01f, 2.10835427e-01f, 1.11737415e-01f, 1.90670520e-01f, 6.51862323e-02f, 1.13135185e-02f, 3.54641795e-01f,
  -3.07589918e-01f, -2.98478603e-02f, -1.98761791e-01f, 3.11582774e-01f, 1.86369345e-01f, 2.68282950e-01f, -1.11993477e-01f, 1.32406533e-01f, -7.39162266e-02f, -1.15045823e-01f,
  -1.92056790e-01f, 6.57867938e-02f, 3.55635583e-01f, 1.84951767e-01f, 2.30928957e-01f, 2.55788058e-01f, 7.69751221e-02f, -2.67836422e-01f, 3.34680006e-02f, -1.83029324e-01f,
  -1.20030634e-01f, 1.44210964e-01f, -1.39796555e-01f, -2.43824229e-01f, -1.88506216e-01f, 1.29603446e-01f, -3.13160606e-02f, 5.04329391e-02f, -1.48141965e-01f, 5.73828910e-03f,
  -3.80308949e-03f, -1.06036603e-01f, -4.97526005e-02f, -1.00866422e-01f, -8.75164941e-02f, 1.75140947e-01f, 2.17370242e-01f, 2.04545483e-02f, 1.20035842e-01f, -1.96519926e-01f,
  1.48233652e-01f, -7.46943280e-02f, 4.50088084e-02f, 8.59193578e-02f, 2.56005883e-01f, 1.72174558e-01f, 3.58833283e-01f, 2.18121484e-02f, -5.57388924e-02f, -1.32556960e-01f,
  9.22396109e-02f, -2.28552341e-01f, -3.90495449e-01f, 2.56843835e-01f, 3.66959602e-01f, 1.33716995e-02f, 1.17293410e-01f, -1.97880030e-01f, 2.30839133e-01f, 1.68207675e-01f,
  1.38384506e-01f, 4.06916052e-01f, 4.24364060e-01f, 9.72442180e-02f, -3.46410125e-01f, -4.23785388e-01f, 5.24495244e-01f, 7.15292916e-02f, 4.61146623e-01f, -2.49583982e-02f,
  -1.75507486e-01f, -2.49908138e-02f, -6.27843663e-02f, 5.00696376e-02f, 1.88352555e-01f, -1.68823272e-01f, -7.33022466e-02f, 5.72822809e-01f, 5.29591084e-01f, 4.84379567e-02f,
  -1.27073497e-01f, 8.89306068e-01f, 1.53100982e-01f, -2.49273911e-01f, 3.33199531e-01f, -1.55383170e-01f, 2.38913432e-01f, 1.49467066e-01f, 2.04868376e-01f, -9.32660997e-02f,
  -4.56409305e-02f, 5.00994958e-02f, 5.97272143e-02f, -8.89787450e-02f, -7.42876455e-02f, -4.71191168e-01f, 3.45360845e-01f, 3.07100326e-01f, 4.56635021e-02f, -5.25919795e-01f,
  -2.07503870e-01f, -1.39320269e-01f, -1.67836964e-01f, 1.08085327e-01f, -6.23256564e-02f, 1.81873813e-02f, -1.15309425e-01f, 4.54584789e-03f, -1.31370753e-01f, -1.86451331e-01f,
  -1.89148560e-01f, 3.02577436e-01f, 7.01103127e-05f, 6.25319123e-01f, -9.58744884e-02f, 1.42941162e-01f, 7.46618062e-02f, 3.65202099e-01f, 2.11052492e-01f, 3.54640812e-01f,
  2.40546882e-01f, -3.83747220e-01f, 3.56507421e-01f, 1.42178595e-01f, -1.77380536e-02f, 4.52972293e-01f, -1.60754710e-01f, -2.38591850e-01f, 2.76714653e-01f, 1.63594127e-01f,
  1.76938206e-01f, -1.64517716e-01f, 2.19767615e-01f, -2.34025553e-01f, 8.88805836e-02f, 2.55659908e-01f, 8.64000022e-02f, 7.54968822e-02f, 1.21298499e-01f, 1.51974618e-01f,
  2.81258672e-02f, -2.47427583e-01f, -3.19132984e-01f, -2.49422640e-01f, -1.94240361e-02f, 4.19908583e-01f, 4.23024148e-02f, -9.28872004e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -3.04825269e-02f, -4.77522649e-02f, -1.97372124e-01f, -1.88262630e-02f, 1.31165937e-01f, -6.70814440e-02f, -1.48965642e-01f, -1.17920332e-01f, 2.05990393e-03f, -8.36254185e-05f,
  1.30715832e-01f, 3.80541682e-02f, 1.74318105e-01f, -7.48249516e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -4.85710114e-01f, 8.28107893e-01f, -5.13185918e-01f, -1.89446464e-01f, 2.71871407e-02f, -1.55501023e-01f, 2.79554240e-02f, 6.05973639e-02f, -1.57368436e-01f, 3.99785601e-02f,
  -7.55784959e-02f, -4.56107974e-01f, -5.99012822e-02f, 5.06815970e-01f, 6.49536178e-02f, -4.86525893e-02f, 2.80963898e-01f, 8.67665261e-02f, 9.65878144e-02f, -7.43444413e-02f,
  9.58293304e-02f, -8.20120275e-02f, -8.03245127e-01f, 1.83642715e-01f, -5.55538200e-02f, 3.55688125e-01f, 1.84135861e-03f, -5.56605518e-01f, 3.35627720e-02f, 7.32094228e-01f,
  -2.81341434e-01f, -3.55628252e-01f, -1.16158634e-01f, -1.94995657e-01f, 4.63819712e-01f, 4.83176768e-01f, 7.22462088e-02f, 4.20512915e-01f, -3.67453992e-01f, 9.49057937e-02f,
  3.10903579e-01f, -1.86117977e-01f, 4.91682559e-01f, 6.16803169e-01f, 3.98418397e-01f, 2.73460239e-01f, 5.43783233e-02f, 9.32443067e-02f, 7.54404247e-01f, 9.03223515e-01f,
  6.00370839e-02f, -5.58583625e-02f, 1.14969619e-01f, 2.90720075e-01f, -4.69241589e-01f, 1.77138418e-01f, -1.56672120e-01f, 1.98762611e-01f, 4.16231379e-02f, -1.14702977e-01f,
  -9.84122008e-02f, 9.53635648e-02f, 3.05105865e-01f, 5.24793506e-01f, 8.47314239e-01f, 2.95661062e-01f, 2.69741535e-01f, 2.83377558e-01f, 2.05410898e-01f, -3.58666539e-01f,
  7.92117417e-01f, -3.08067262e-01f, 3.54739487e-01f, -3.03842481e-02f, -5.62495351e-01f, -2.92907059e-01f, 4.30163831e-01f, -5.26860595e-01f, -1.95065930e-01f, -2.12590203e-01f,
  -6.64512098e-01f, 3.74689192e-01f, 6.69866428e-02f, -3.72112691e-01f, -2.16086760e-01f, -3.37935209e-01f, 3.33927274e-01f, 1.40545949e-01f, -1.19258270e-01f, 7.52845407e-02f,
  7.23536834e-02f, -1.62091866e-01f, -2.07642198e-01f, 4.80292469e-01f, -9.01974738e-02f, 7.24972561e-02f, 6.96091712e-01f, -4.71108168e-01f, -2.08485320e-01f, 7.58474171e-02f,
  3.23770463e-01f, 3.97198528e-01f, 1.81837872e-01f, 5.43079793e-01f, -1.80591062e-01f, -9.41499099e-02f, -2.16590151e-01f, 2.49890968e-01f, 5.10355473e-01f, -1.24371000e-01f,
  9.03710946e-02f, -4.52304184e-01f, -4.66364741e-01f, -2.29334623e-01f, -1.59920305e-01f, -2.52507050e-02f, 3.74133438e-01f, -1.21254392e-01f, 1.90456435e-01f, 8.16458166e-02f,
  7.30393231e-01f, 7.73812905e-02f, -1.08215354e-01f, 3.35690200e-01f, 2.69329727e-01f, 1.27401188e-01f, -3.48273039e-01f, -7.49234557e-02f, 1.26600489e-01f, 3.93264532e-01f,
  -6.28339469e-01f, -3.81158620e-01f, 3.10503691e-01f, 9.42446217e-02f, -3.25153470e-01f, 7.50771761e-01f, -3.69530976e-01f, 7.10354507e-01f, -4.81720895e-01f, -1.23435445e-01f,
  2.01982349e-01f, -3.31991129e-02f, -2.31663570e-01f, -3.66115659e-01f, -1.06404632e-01f, 6.40093014e-02f, -5.12982905e-02f, -8.33915621e-02f, -1.48892745e-01f, -2.02387571e-01f,
  1.09627798e-01f, -1.23285074e-02f, -5.69946915e-02f, 1.32881850e-01f, 9.05828178e-02f, 1.04034871e-01f, 7.16959313e-02f, 6.65278792e-01f, -5.17348647e-01f, -5.19791901e-01f,
  -3.80095780e-01f, 2.85679609e-01f, 4.18916941e-01f, 2.64804721e-01f, 4.04994935e-01f, -6.68566346e-01f, -1.56450704e-01f, 7.77449608e-01f, 3.23913574e-01f, 4.01801556e-01f,
  6.77861929e-01f, 1.65278107e-01f, 1.75916776e-01f, 8.94947425e-02f, -2.35608332e-02f, -8.23895156e-01f, 1.14271559e-01f, -1.49388224e-01f, -1.73932016e-01f, -3.09394300e-01f,
  -9.33737159e-02f, -5.23657382e-01f, -3.12678874e-01f, -1.46299586e-01f, 4.43611480e-03f, 1.57859661e-02f, 8.86667892e-02f, -1.91213176e-01f, -1.51692167e-01f, 2.43622854e-01f,
  1.22440673e-01f, 7.07170248e-01f, 5.86969703e-02f, 6.63222969e-02f, 6.50176883e-01f, 2.60071635e-01f, -3.40225488e-01f, 3.45702261e-01f, -6.45424724e-02f, -6.09977245e-01f,
  5.68504393e-01f, -7.12695003e-01f, -6.79103017e-01f, -1.57830209e-01f, -3.73464197e-01f, -2.23812327e-01f, 1.61963418e-01f, 1.07559121e+00f, 1.97792292e-01f, -3.22879136e-01f,
  -1.92630403e-02f, 1.14643380e-01f, -1.46416441e-01f, -3.91583592e-02f, 5.95301867e-01f, 2.55769081e-02f, -2.07627326e-01f, -1.20910920e-01f, -5.81041500e-02f, 2.23315284e-01f,
  -2.65493184e-01f, 3.78061482e-03f, -2.59845525e-01f, -3.19902241e-01f, -3.01472872e-01f, -3.53033617e-02f, -2.58688070e-02f, -4.75813627e-01f, -3.01126838e-01f, 1.46158218e-01f,
  -3.97028953e-01f, -2.15585485e-01f, -3.49031538e-01f, -4.80659664e-01f, -3.99098366e-01f, 5.86635470e-01f, -2.93614388e-01f, 5.34712858e-02f, 2.14369565e-01f, 1.87338680e-01f,
  -3.22070688e-01f, -5.11907279e-01f, -3.98536287e-02f, 9.48994219e-01f, -8.52407292e-02f, 2.48477817e-01f, 1.10078998e-01f, -6.64405990e-03f, 4.24322300e-02f, -1.18777283e-01f,
  -4.44861352e-02f, 8.18190910e-03f, -2.39237353e-01f, -5.91287851e-01f, 2.36498132e-01f, -2.12862298e-01f, 2.17223503e-02f, 8.89608040e-02f, -2.70178974e-01f, 1.53409272e-01f,
  3.28114092e-01f, -5.12735359e-02f, 4.40611780e-01f, 5.23859739e-01f, 4.42732066e-01f, 3.27325076e-01f, 4.51011926e-01f, 4.83647943e-01f, -7.45160401e-01f, 1.03849165e-01f,
  -5.75491309e-01f, -2.98494816e-01f, 5.76224886e-02f, -3.93129945e-01f, -9.68834683e-02f, -1.56421170e-01f, 5.98247834e-02f, 1.94827989e-01f, -3.50548238e-01f, -3.72463465e-03f,
  -9.84599963e-02f, 9.24545899e-02f, -3.98476794e-03f, -2.14115277e-01f, 9.21868235e-02f, -9.44871664e-01f, 7.56683946e-01f, -1.04719870e-01f, -9.27995145e-02f, -3.47527117e-01f,
  -4.87777442e-01f, 2.23673478e-01f, -6.02807589e-02f, 2.02165172e-01f, 5.72405040e-01f, -6.04410768e-01f, -3.48863393e-01f, -7.00898767e-01f, -1.16578877e-01f, -3.27093750e-01f,
  8.44367780e-03f, -4.29722607e-01f, 3.48864831e-02f, 5.24400353e-01f, -4.97479290e-01f, 3.05817872e-01f, 1.81870952e-01f, -3.64777744e-01f, 3.16997916e-02f, 6.59069195e-02f,
  5.24390101e-01f, -1.18275002e-01f, 2.92360723e-01f, -1.51173249e-01f, 1.08479774e-02f, 2.95305222e-01f, 3.64596307e-01f, 1.34154499e-01f, -2.40182191e-01f, -8.10269713e-02f,
  -3.23927015e-01f, -3.05865645e-01f, 5.06016731e-01f, -3.92631918e-01f, -5.42150259e-01f, -6.14256710e-02f, 8.53837356e-02f, -8.28814030e-01f, -6.90623343e-01f, -3.87004256e-01f,
  3.51070672e-01f, -3.51719856e-01f, 7.52455816e-02f, 3.16292226e-01f, 1.34430960e-01f, 2.36833598e-02f, 2.62455307e-02f, 1.18568040e-01f, 3.20707485e-02f, -2.41876185e-01f,
  1.43323794e-01f, 3.33243877e-01f, -3.66153121e-01f, 7.47538405e-03f, -5.23541123e-02f, 3.65847617e-01f, -4.81178649e-02f, -3.24654847e-01f, -2.52145948e-03f, 2.09512144e-01f,
  2.20981583e-01f, 2.33126327e-01f, -1.00334600e-01f, -1.63177475e-01f, -1.79410964e-01f, -1.58651575e-01f, -2.89261281e-01f, -6.62107021e-02f, -3.55652541e-01f, -1.46445334e-01f,
  1.30595518e-02f, 1.16995528e-01f, 3.88040423e-01f, -3.09564501e-01f, -1.78842515e-01f, 8.34122300e-02f, 5.02858460e-01f, 1.34717271e-01f, 1.36176109e-01f, -3.61122519e-01f,
  1.23391099e-01f, 3.55367541e-01f, 3.67866568e-02f, -3.83748114e-02f, 5.89198649e-01f, -1.09526344e-01f, 2.54649341e-01f, 1.50017023e-01f, 3.12348753e-02f, 3.85898501e-01f,
  1.36099011e-01f, -6.03264272e-01f, -3.60535443e-01f, 1.58187628e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  9.10824165e-03f, 7.37271979e-02f, 9.32125896e-02f, -1.30362421e-01f, 8.47323984e-02f, 3.16128641e-01f, -6.07348979e-02f, -1.61914170e-01f, 2.89308608e-01f, -2.61264592e-01f,
  -2.85159111e-01f, 1.65495966e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    