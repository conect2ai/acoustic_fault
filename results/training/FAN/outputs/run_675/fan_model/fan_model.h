/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.62095535e-01f, 7.09443763e-02f, 2.94103622e-01f, -1.98133186e-01f, -1.07765079e-01f, 2.67909933e-02f, 2.12129176e-01f, -1.38032153e-01f, -2.52306402e-01f, 1.08253291e-04f,
  -7.78833330e-02f, -2.08453223e-01f, -8.92496780e-02f, -6.24972172e-02f, -3.57283019e-02f, 1.84997171e-01f, 1.98551804e-01f, 2.07496986e-01f, 6.82949051e-02f, -4.26426232e-02f,
  -4.21380661e-02f, -8.36302042e-02f, -6.67539164e-02f, 8.98624659e-02f, 2.68416032e-02f, 8.31281021e-02f, 1.48529828e-01f, 3.57858725e-02f, 1.06107749e-01f, 2.19954431e-01f,
  7.44896084e-02f, -2.68973801e-02f, -1.15777433e-01f, -1.61094174e-01f, -1.86584312e-02f, -9.32296515e-02f, 4.01124009e-04f, -5.39379045e-02f, -7.23208934e-02f, -5.19644208e-02f,
  -9.46184173e-02f, -5.56967109e-02f, -5.07616252e-02f, -4.08502966e-02f, -3.79362628e-02f, 9.23624355e-03f, -6.32219985e-02f, -5.85005805e-02f, -3.60021032e-02f, 1.87285356e-02f,
  -1.44760087e-01f, -5.91678545e-02f, 2.00834963e-02f, -9.21923071e-02f, 4.87643220e-02f, -6.20508492e-02f, 6.81670457e-02f, 8.77823457e-02f, 1.08450487e-01f, 5.38570900e-03f,
  6.54420033e-02f, 3.54498625e-02f, 3.10680773e-02f, 9.15189907e-02f, 2.79439297e-02f, 1.12527646e-01f, 2.97150202e-02f, 1.17123447e-01f, 3.35633233e-02f, 9.75142196e-02f,
  7.32154548e-02f, 1.37249054e-02f, 1.00601465e-01f, 6.41987398e-02f, 4.08867151e-02f, 4.82448057e-04f, 4.20770533e-02f, 6.75629750e-02f, 7.33287707e-02f, 1.75980683e-02f,
  1.00984357e-01f, 3.05369161e-02f, 4.33470607e-02f, 4.17598672e-02f, 8.39407295e-02f, 5.87466247e-02f, -5.62092056e-03f, -4.28383984e-02f, -4.05292027e-03f, -6.20053522e-02f,
  -1.16812244e-01f, -2.54216231e-02f, -6.87399879e-02f, -1.03841938e-01f, -7.88741838e-03f, -4.18265909e-02f, -1.17931649e-01f, -7.77465701e-02f, -1.88906938e-01f, -7.39489198e-02f,
  -7.72053823e-02f, -5.45634963e-02f, 2.31740139e-02f, -7.53861889e-02f, -4.75967191e-02f, -2.80806497e-02f, -1.36055395e-01f, 1.66656468e-02f, -9.52184424e-02f, -1.38785407e-01f,
  -7.52237141e-02f, 4.56850119e-02f, -6.45452142e-02f, 4.20316197e-02f, -1.04035707e-02f, -6.06983304e-02f, 1.08135790e-01f, 1.38062583e-02f, 3.00378669e-02f, -2.68217456e-02f,
  -8.63499939e-02f, 2.69409448e-01f, 1.44921213e-01f, -1.28145933e-01f, 2.26494297e-01f, 2.89076924e-01f, 3.86504084e-01f, 2.42482096e-01f, 7.15587214e-02f, 1.94910228e-01f,
  -9.97272087e-04f, -1.87254116e-01f, -1.52562663e-01f, -1.20435476e-01f, 3.62466276e-02f, 3.42062175e-01f, 1.76290378e-01f, -1.32987186e-01f, -2.86790859e-02f, 7.60501176e-02f,
  7.40522444e-02f, -5.00613183e-04f, -4.35784720e-02f, -6.53353035e-02f, -2.88123805e-02f, -2.22635753e-02f, 3.84965502e-02f, -3.09879966e-02f, 9.34655741e-02f, -8.52553770e-02f,
  1.89139023e-01f, 1.90944150e-02f, 1.32193401e-01f, 2.28134394e-02f, 1.96493089e-01f, 7.68788978e-02f, 2.36011162e-01f, 8.74491632e-02f, 1.05809540e-01f, 2.10642621e-01f,
  1.88433044e-02f, 9.64293182e-02f, 1.20447919e-01f, 1.13533311e-01f, 1.47888139e-01f, 1.72650665e-01f, 1.26121342e-01f, 1.08547151e-01f, 8.87408853e-02f, 1.25691652e-01f,
  1.49273932e-01f, 1.82377607e-01f, 2.27666900e-01f, 2.73825049e-01f, 7.67436475e-02f, 1.21306837e-01f, 1.76318452e-01f, 1.21290609e-01f, 1.05844423e-01f, 2.63419122e-01f,
  1.01006500e-01f, -6.50594309e-02f, -1.13487311e-01f, -1.20333448e-01f, -6.11668415e-02f, -1.29515201e-01f, -8.36790204e-02f, -8.51656422e-02f, -6.19318224e-02f, 5.74418381e-02f,
  -8.97441432e-02f, 4.91648950e-02f, -1.10592069e-02f, -3.44410837e-02f, -1.82814691e-02f, 7.75250643e-02f, -4.03064154e-02f, 1.68724116e-02f, -9.40422248e-03f, -4.00206000e-02f,
  -2.69404240e-02f, -9.33053270e-02f, 1.13469444e-03f, -8.45356062e-02f, -5.21253049e-02f, -6.75224885e-02f, -4.57686111e-02f, -5.02580255e-02f, -7.18369111e-02f, -4.56048176e-02f,
  2.21273348e-01f, 1.13290384e-01f, 1.74757361e-01f, 4.61394414e-02f, 1.66686788e-01f, 1.21299848e-01f, 5.29604554e-02f, 1.18530780e-01f, 3.24564539e-02f, 7.31824338e-02f,
  1.64230868e-01f, 2.54436508e-02f, 1.84696972e-01f, 1.34065643e-01f, 1.24195874e-01f, 1.92900732e-01f, 2.14469433e-01f, 6.84329197e-02f, 8.92277211e-02f, 1.92647964e-01f,
  1.38296634e-01f, 2.49313846e-01f, 2.17761680e-01f, 1.35834441e-01f, 1.67808563e-01f, 1.30484954e-01f, 1.95992336e-01f, 1.34498566e-01f, 1.45595029e-01f, 3.47486824e-01f,
  -3.83650176e-02f, -5.45018852e-01f, 2.66124934e-01f, -4.23623472e-02f, 2.65572686e-02f, 1.76256388e-01f, -4.77191433e-02f, -2.78463773e-02f, -1.39857769e-01f, -1.78804964e-01f,
  -3.36566657e-01f, -1.17703319e-01f, -1.10438608e-01f, -1.14753880e-01f, 3.53277363e-02f, -1.26048535e-01f, -2.45413948e-02f, 2.54063189e-01f, 1.75195605e-01f, -3.61659825e-02f,
  -1.94897085e-01f, -1.43492997e-01f, 3.85397784e-02f, -1.35670006e-01f, -3.92972380e-01f, -1.98172987e-01f, -1.44402608e-01f, -1.09412752e-01f, -1.76396653e-01f, -2.36596882e-01f,
  -7.50532672e-02f, -2.05146194e-01f, 1.87768098e-02f, -2.39767313e-01f, -1.23146951e-01f, -1.40670970e-01f, -5.65344505e-02f, -7.16249496e-02f, -1.25816405e-01f, -5.82869202e-02f,
  -1.24942109e-01f, -1.47828788e-01f, -1.73640281e-01f, -1.50429562e-01f, -4.46143299e-02f, -1.65689200e-01f, -1.22071825e-01f, -8.68554935e-02f, -6.53830394e-02f, -9.18502435e-02f,
  -2.82128096e-01f, -1.50376886e-01f, -5.33978939e-02f, -5.07377386e-02f, -6.19817823e-02f, -6.18878752e-03f, -1.09010555e-01f, -1.49790347e-01f, 9.43183154e-03f, -1.50163591e-01f,
  6.17249459e-02f, 1.40963152e-01f, -1.46513535e-02f, 1.27524018e-01f, 9.36039388e-02f, 1.05999708e-01f, 6.26479238e-02f, 1.16059691e-01f, 1.10572018e-01f, 5.30724078e-02f,
  9.69435424e-02f, 1.08994335e-01f, 1.07167482e-01f, -3.09854802e-02f, 5.28232269e-02f, 4.89422567e-02f, 3.30963917e-02f, 8.65589455e-03f, 1.18778244e-01f, 2.59158276e-02f,
  9.82254371e-02f, 4.57410961e-02f, 1.10177383e-01f, 7.79855773e-02f, -1.95361767e-02f, 1.65571421e-01f, 2.87995823e-02f, 2.99089942e-02f, 1.02040038e-01f, 1.10272072e-01f,
  -2.34132648e-01f, 1.20215632e-01f, -1.25876948e-01f, -1.47567391e-01f, -1.28428429e-01f, -2.23980155e-02f, -7.93169588e-02f, -1.68976620e-01f, -4.18899357e-02f, -9.69263613e-02f,
  -1.16547957e-01f, -7.16826767e-02f, -1.29519209e-01f, -2.58594472e-02f, -5.71295694e-02f, -8.27233791e-02f, -1.84870586e-01f, -1.17930248e-01f, -1.54760666e-02f, -9.99527723e-02f,
  -7.35766292e-02f, -4.58931290e-02f, 5.85399568e-02f, -1.25452489e-01f, -1.38507351e-01f, 4.26253080e-02f, -6.34144545e-02f, -9.52308401e-02f, -4.53247875e-02f, -7.93685094e-02f,
  1.10639617e-01f, 3.76191914e-01f, -1.38167888e-01f, 6.37314394e-02f, -1.84420258e-01f, -1.67257831e-01f, -1.41016647e-01f, -6.34549698e-03f, 1.34930804e-01f, 8.78895000e-02f,
  3.48628834e-02f, -6.16409443e-02f, 5.72906388e-03f, -5.57118095e-02f, -2.79808119e-02f, 2.29046438e-02f, 8.71395320e-02f, -1.19599536e-01f, -3.68569344e-01f, -2.17213929e-01f,
  4.96767927e-03f, 1.56840667e-01f, 1.19088203e-01f, 1.85100764e-01f, 2.05368713e-01f, -9.64987034e-04f, 2.08535671e-01f, 1.02776699e-01f, -6.53992668e-02f, 1.83267221e-01f,
  -2.67300695e-01f, 5.64987548e-02f, -1.28948823e-01f, -2.99809929e-02f, -9.40796286e-02f, -2.27549654e-02f, -9.83514823e-03f, 9.02968422e-02f, -8.99405126e-03f, -2.30763033e-02f,
  -2.89308354e-02f, -6.20124452e-02f, 6.68907166e-02f, -1.37206232e-02f, -6.44832337e-03f, -4.38741520e-02f, 4.00230736e-02f, 3.24409306e-02f, -7.39835873e-02f, 6.71591461e-02f,
  -2.85696760e-02f, -1.02106906e-01f, -1.37824178e-01f, 3.73905115e-02f, -4.35178615e-02f, -2.25544855e-01f, -4.40859608e-02f, -7.31860921e-02f, -1.47396279e-02f, 3.05050388e-02f,
  -1.72259826e-02f, -1.62983930e-03f, -1.04394704e-02f, 5.50502203e-02f, 7.46802241e-02f, 2.76708212e-02f, -5.23575880e-02f, -4.01556529e-02f, 3.59114669e-02f, -5.09103574e-02f,
  -9.91414115e-03f, -6.86118659e-03f, 3.68929617e-02f, 6.30461797e-03f, 1.08249765e-02f, -7.64565393e-02f, -2.22292244e-02f, 1.36758592e-02f, 2.22773082e-03f, 1.18423132e-02f,
  -5.77062033e-02f, -5.32278717e-02f, 8.50977190e-03f, 3.72891361e-03f, -8.05060640e-02f, 3.46082039e-02f, -3.20009068e-02f, 4.92318571e-02f, 3.49683277e-02f, -2.56472714e-02f,
  8.36127847e-02f, -1.75976247e-01f, -7.46539459e-02f, -9.95641798e-02f, -2.83916481e-02f, -4.53269333e-02f, 3.78586389e-02f, 2.22937409e-02f, -3.28431018e-02f, -5.40835522e-02f,
  -1.08257301e-01f, -4.45536450e-02f, 4.13743183e-02f, 3.71773690e-02f, -1.22734256e-01f, -1.10555023e-01f, 1.10371619e-01f, -1.48618177e-01f, -9.76282135e-02f, 1.07498905e-02f,
  9.15346071e-02f, -1.28306001e-01f, -2.36922845e-01f, -1.55125812e-01f, 7.40813150e-04f, -2.09435761e-01f, -6.81030825e-02f, -1.79945886e-01f, -1.36835441e-01f, 1.16179667e-01f,
  3.79496843e-01f, -8.47001299e-02f, -2.83372849e-01f, -6.98763058e-02f, -2.03581288e-01f, -1.17069833e-01f, -2.06536829e-01f, -4.40152027e-02f, 7.35744238e-02f, -6.21632300e-03f,
  -9.70803797e-02f, -3.17770690e-02f, -9.58969370e-02f, -1.30035818e-01f, -3.66495177e-02f, -7.01183379e-02f, -2.03455523e-01f, -1.26008958e-01f, 7.90098608e-02f, -3.84548791e-02f,
  7.30856061e-02f, -3.61523032e-02f, 6.91351295e-02f, -8.13007634e-03f, -1.66944172e-02f, -1.46016315e-01f, -2.25166976e-01f, -1.36115313e-01f, -5.69917588e-03f, -1.88279282e-02f,
  -2.50195354e-01f, 8.19811374e-02f, 7.94885978e-02f, 1.73768237e-01f, -5.17687127e-02f, 1.15791902e-01f, -4.88918014e-02f, 1.66938007e-02f, 8.70986059e-02f, -1.42080123e-02f,
  -4.04936709e-02f, 8.54807347e-02f, -7.56388064e-03f, 4.58889604e-02f, -5.30010499e-02f, 9.22134891e-02f, -6.04201760e-03f, 1.62555456e-01f, -2.54995320e-02f, -2.59849522e-03f,
  -1.00640813e-03f, 2.38527022e-02f, 8.83036032e-02f, 2.00528484e-02f, -1.56682041e-02f, 6.58673495e-02f, -1.57064442e-02f, 2.82730330e-02f, 1.15218043e-01f, 1.07507534e-01f,
  1.54714976e-02f, -4.29970138e-02f, -7.97536783e-03f, -1.09102521e-02f, -3.97075005e-02f, 1.70067456e-02f, -2.38303822e-02f, -3.59295644e-02f, 7.32470769e-03f, -1.41688827e-02f,
  -7.11472705e-02f, -5.31394146e-02f, -4.07959661e-03f, -2.79768347e-03f, -4.86764545e-03f, -1.74492374e-02f, 5.19373007e-02f, -4.66153920e-02f, -6.61931857e-02f, 4.56499495e-02f,
  1.85027893e-03f, 8.04994348e-03f, -1.13759987e-01f, 2.42952164e-02f, -7.69862905e-02f, -6.75883144e-02f, -1.62995290e-02f, -7.13667795e-02f, -7.75909275e-02f, -7.48457238e-02f,
  -1.16148189e-01f, 8.56305286e-02f, 9.74863768e-02f, 1.23412438e-01f, 3.67498547e-02f, 7.38631412e-02f, 2.64847688e-02f, 8.55908468e-02f, 1.06850453e-01f, 3.88480239e-02f,
  4.65751588e-02f, 8.45036805e-02f, 1.02814240e-02f, 1.76130212e-03f, 2.23987307e-02f, 1.15937442e-01f, 1.68072522e-01f, -1.81213152e-02f, 1.71001796e-02f, 7.93302357e-02f,
  3.24652195e-02f, 1.07023761e-01f, 1.77142739e-01f, -3.66534921e-03f, 6.39128909e-02f, 1.18229255e-01f, 5.16046695e-02f, 1.21146515e-01f, 1.11671962e-01f, 2.38277130e-02f,
  -2.41520062e-01f, -2.31353983e-01f, -2.43909266e-02f, 8.96562338e-02f, 1.50013104e-01f, 8.35981593e-02f, 2.99282186e-02f, 1.49929240e-01f, 1.21739879e-01f, 1.25787640e-02f,
  1.15206972e-01f, 2.05235437e-01f, 1.33571029e-01f, -1.51661923e-03f, 5.87250218e-02f, -6.80912510e-02f, -1.53835202e-02f, -8.19819719e-02f, 2.76870979e-03f, -4.44072001e-02f,
  4.91118170e-02f, -4.93068360e-02f, -2.15538278e-01f, -3.73296924e-02f, -2.23069057e-01f, -5.52699342e-02f, -1.96769089e-01f, -1.73348740e-01f, -2.29853287e-01f, -3.39058101e-01f,
  -1.47366643e-01f, -1.34321004e-01f, 1.69240430e-01f, 7.79216662e-02f, -2.72831470e-02f, 1.55396061e-02f, 2.45306883e-02f, -3.51725258e-02f, 1.01728011e-02f, -4.65079062e-02f,
  3.25929150e-02f, -3.13894898e-02f, -5.12282476e-02f, 2.15183850e-02f, -4.87742797e-02f, 4.69794199e-02f, 8.23386572e-03f, -1.74413919e-02f, 1.01357676e-01f, -6.81622624e-02f,
  2.19508763e-02f, 2.86259633e-02f, -9.03227553e-02f, 6.75823614e-02f, 7.33457729e-02f, 5.78023903e-02f, -1.69810668e-01f, -1.94782645e-01f, -7.44021311e-02f, -2.24011213e-01f,
  -1.02259964e-01f, -5.36350459e-02f, -2.02007927e-02f, -1.11230053e-02f, -8.62234607e-02f, 9.13857482e-03f, -5.66848554e-02f, -1.07545927e-01f, -4.95525040e-02f, -3.15934122e-02f,
  -3.74799557e-02f, 5.82885109e-02f, -7.00373501e-02f, -2.01106835e-02f, -1.17435783e-01f, -1.38583677e-02f, -2.18369681e-02f, -3.22746187e-02f, -2.66774148e-02f, -8.06652848e-03f,
  2.14849673e-02f, -7.16584027e-02f, 1.42320003e-02f, -1.40760183e-01f, 4.95316349e-02f, -1.09204846e-02f, 2.45640799e-02f, -2.29512132e-03f, -5.68749942e-02f, 4.52988371e-02f,
  -1.17430873e-01f, 2.21152991e-01f, -9.43408012e-02f, -7.75393331e-03f, 8.57561305e-02f, 2.72827689e-02f, 7.26191327e-03f, 3.94528545e-02f, 9.11029577e-02f, -1.79246478e-02f,
  5.43936118e-02f, 3.90378684e-02f, -4.13775444e-02f, -1.46034472e-02f, 1.57350749e-02f, 6.00507408e-02f, 1.44310994e-02f, 6.26960024e-02f, 1.19719736e-01f, 8.94275829e-02f,
  6.42814636e-02f, 7.41889551e-02f, -3.88768837e-02f, 4.39693779e-02f, -8.58482253e-03f, 1.50285959e-01f, -7.49603361e-02f, 1.84219517e-03f, 1.75658297e-02f, -1.31445453e-01f,
  2.47224584e-01f, 5.75202927e-02f, 1.83403343e-01f, 1.70395568e-01f, -1.98962897e-01f, -4.31167334e-02f, 6.47186786e-02f, 1.24244705e-01f, 1.20331429e-01f, -2.03168411e-02f,
  -2.25197256e-01f, -3.52186471e-01f, -3.09196770e-01f, -2.39179015e-01f, -1.62113719e-02f, 1.57690346e-01f, 1.60083964e-01f, 9.67620611e-02f, 1.56887919e-02f, -2.78940424e-02f,
  -5.24748899e-02f, 4.45490293e-02f, 2.25741327e-01f, 1.73771933e-01f, -6.60909922e-04f, -9.40681174e-02f, 2.20707685e-01f, 9.75295752e-02f, -3.57797146e-02f, 1.09545402e-01f,
  -1.11997984e-01f, 2.31420144e-01f, -3.11797429e-02f, -2.14994866e-02f, 6.50645569e-02f, 2.18536675e-01f, 1.17090359e-01f, 1.00893527e-01f, 9.12349448e-02f, 1.92432255e-01f,
  -9.45199877e-02f, 1.04998492e-01f, -3.47916558e-02f, 1.08510718e-01f, 1.77354574e-01f, 8.24688971e-02f, 2.45442957e-01f, 2.85088390e-01f, 2.01103106e-01f, 9.11462978e-02f,
  -3.62738855e-02f, 2.68330872e-02f, -2.22184360e-02f, 1.01111151e-01f, 1.04645535e-01f, 8.12327415e-02f, 1.43812805e-01f, 2.01769054e-01f, 2.29990527e-01f, 3.71615976e-01f,
  3.36605012e-02f, -6.40403703e-02f, -8.12191218e-02f, 1.01213623e-03f, -5.10044545e-02f, -8.73683989e-02f, -2.12450065e-02f, -8.25334489e-02f, -3.28222252e-02f, 2.81218924e-02f,
  -7.51445964e-02f, -1.15860246e-01f, -3.65340384e-03f, -3.09147727e-04f, -1.32676229e-01f, 6.25431072e-03f, -1.45231441e-01f, -2.09697466e-02f, -3.68498005e-02f, -2.75515970e-02f,
  -7.65224472e-02f, -1.23296127e-01f, -6.95014596e-02f, -8.78103971e-02f, -1.23190461e-02f, -2.19725464e-02f, 2.30158176e-02f, -1.12574935e-01f, -1.97276808e-02f, -1.83057226e-03f,
  8.61211643e-02f, -1.63937211e-02f, 4.68089394e-02f, 1.27978474e-01f, 7.33309686e-02f, 7.12899119e-02f, 6.11944087e-02f, 1.69739857e-01f, 2.71807071e-02f, 9.33230370e-02f,
  5.28486259e-02f, 5.28765507e-02f, 1.56199122e-02f, 1.18402801e-01f, 8.92538428e-02f, 9.66223702e-02f, 7.40255788e-02f, 1.81367770e-02f, 1.58773642e-02f, 7.17766434e-02f,
  6.52649775e-02f, 8.16681013e-02f, -7.59127783e-03f, 9.89670828e-02f, 1.21913679e-01f, -1.07205532e-01f, 4.72231470e-02f, 6.91685677e-02f, -1.82605616e-03f, 1.54295996e-01f,
  -3.17410648e-01f, -1.10849775e-01f, -7.81802926e-03f, -3.86247367e-01f, -2.43201435e-01f, -1.79055080e-01f, -1.50154755e-01f, -2.30561286e-01f, -2.72873282e-01f, -1.79328829e-01f,
  -1.44678978e-02f, -7.33393282e-02f, -1.30063891e-01f, -1.67592838e-02f, 1.09498417e-02f, -1.60834581e-01f, -2.58853406e-01f, -1.13207482e-01f, -9.02161673e-02f, -2.12929785e-01f,
  -3.38108242e-01f, -1.92222685e-01f, -1.44367293e-01f, -2.10895911e-01f, -1.68605015e-01f, -2.28509977e-02f, 1.27988886e-02f, -1.83278531e-01f, 3.23863439e-02f, -2.84202307e-01f,
  -9.80109163e-03f, 3.16626094e-02f, -2.05718558e-02f, -1.42939657e-01f, -7.86894783e-02f, -9.54301581e-02f, -7.55928010e-02f, 1.12268515e-02f, -4.46965024e-02f, -5.06335087e-02f,
  -8.76767337e-02f, -4.44407463e-02f, -2.50279102e-02f, -1.54808173e-02f, -1.11098155e-01f, -7.18651563e-02f, -8.83509219e-02f, -4.94631156e-02f, 2.62505617e-02f, -1.58181876e-01f,
  -8.07328522e-02f, -1.05573796e-01f, 2.39293948e-02f, 3.29772308e-02f, 4.95942496e-03f, -7.14242905e-02f, 3.02207321e-02f, 1.00291269e-02f, 5.94383255e-02f, -1.02148496e-01f,
  3.36844511e-02f, 7.05284774e-02f, 1.10557511e-01f, 9.25081447e-02f, 3.83758098e-02f, 5.33037372e-02f, 4.18014936e-02f, -3.49778077e-03f, 6.54495433e-02f, 9.66755971e-02f,
  1.13613337e-01f, 7.94751719e-02f, -4.96129505e-04f, 3.10561731e-02f, 7.22190365e-02f, 1.09408364e-01f, 7.62316138e-02f, 5.08722700e-02f, 4.53234948e-02f, 1.68155003e-02f,
  1.10800810e-01f, -5.70124714e-03f, 1.96167994e-02f, 1.51598468e-01f, 1.08207256e-01f, 8.12267736e-02f, -4.38530091e-03f, 1.90939724e-01f, 1.24613225e-01f, 7.10933581e-02f,
  3.13731357e-02f, 1.75685853e-01f, -2.25095242e-01f, -1.20882289e-02f, -1.35856569e-01f, -1.18565233e-02f, -1.35525735e-02f, -1.37884483e-01f, -1.35444567e-01f, -7.29343444e-02f,
  -7.76584595e-02f, -1.06897235e-01f, -1.18737593e-01f, -4.81095314e-02f, -9.18796882e-02f, -1.37405068e-01f, -1.38811171e-01f, -1.33102596e-01f, -9.75933746e-02f, -1.01262279e-01f,
  -7.58613423e-02f, -1.59197062e-01f, -1.01360410e-01f, -3.62934060e-02f, -9.90419239e-02f, -1.43549621e-01f, 2.93024275e-02f, -1.25040427e-01f, -1.20778561e-01f, -1.94572955e-01f,
  -4.30438489e-01f, 3.63968551e-01f, 3.18869203e-01f, -8.43652114e-02f, 1.37285277e-01f, 3.01516950e-01f, 3.21430087e-01f, 5.21028461e-03f, -1.64529055e-01f, 5.16147912e-02f,
  -1.60336345e-02f, -3.36159676e-01f, -2.30388150e-01f, -1.72919899e-01f, -8.12893659e-02f, 3.50286603e-01f, 2.99752086e-01f, 2.89471075e-02f, -8.91292393e-02f, -4.84278202e-02f,
  9.01480019e-02f, -1.50715813e-01f, -3.07661325e-01f, -1.56561255e-01f, 5.45119606e-02f, -7.50730187e-02f, 1.31476372e-01f, 2.00749114e-02f, 1.94698334e-01f, 3.21559697e-01f,
  1.93758875e-01f, 1.14497781e-01f, -1.23891244e-02f, -1.45250693e-01f, -2.86095310e-02f, -8.16659629e-02f, 5.77873066e-02f, -3.46873105e-02f, -9.63725820e-02f, 7.65153542e-02f,
  -2.85122730e-02f, -7.13469908e-02f, -4.85715736e-03f, 8.67399853e-03f, 9.30160843e-03f, -2.99721342e-02f, -9.60479453e-02f, -3.88211645e-02f, 1.54758536e-03f, 9.90649685e-02f,
  8.73206407e-02f, 1.64788231e-01f, 8.66711810e-02f, 7.47681782e-03f, -6.92027658e-02f, -9.42696854e-02f, -5.09788916e-02f, -2.53510270e-02f, -2.80461330e-02f, -9.67559498e-03f,
  -2.87539177e-02f, 5.42384312e-02f, 3.84272188e-02f, -6.66073784e-02f, 2.07233150e-02f, -7.03963041e-02f, 3.45437564e-02f, 4.08474430e-02f, -6.47855103e-02f, 2.98877209e-02f,
  -4.38780598e-02f, 1.24594308e-02f, -5.88774085e-02f, 6.46314994e-02f, -6.69476539e-02f, 3.48740965e-02f, 5.56869507e-02f, -4.05592024e-02f, -2.48701200e-02f, 9.56378132e-03f,
  -8.52124840e-02f, 1.66245364e-02f, -4.02278416e-02f, -1.28256753e-02f, -2.68267710e-02f, -1.96825098e-02f, 5.53203411e-02f, -2.69438159e-02f, -2.82723363e-02f, -5.64092479e-04f,
  -2.83365011e-01f, -2.14032903e-01f, -3.15470025e-02f, -5.73784523e-02f, 5.16338795e-02f, -1.47204306e-02f, 4.90331016e-02f, -3.52500565e-02f, 3.63229960e-02f, 7.51187429e-02f,
  3.56471762e-02f, -2.68873665e-02f, -2.87590213e-02f, -1.57840680e-02f, -1.17001217e-03f, 3.77078280e-02f, -8.04161504e-02f, 3.32332291e-02f, -4.96170446e-02f, 4.46209637e-03f,
  5.61660416e-02f, -4.20059152e-02f, -1.03063457e-01f, 5.11583053e-02f, -1.22989779e-02f, 2.19908194e-03f, 2.93205846e-02f, 1.17224425e-01f, -1.88419819e-02f, 6.89788610e-02f,
  1.82494164e-01f, 1.05884954e-01f, 8.60784054e-02f, 3.95999365e-02f, 1.13476507e-01f, 1.78516880e-01f, 2.10508570e-01f, 1.64375469e-01f, 1.38565421e-01f, 2.03179970e-01f,
  8.82403702e-02f, 9.87328663e-02f, 1.07610010e-01f, 3.93577442e-02f, 1.21378332e-01f, 1.56644791e-01f, 7.26163313e-02f, -1.87385194e-02f, -1.55594260e-01f, -5.01637626e-03f,
  -8.89845341e-02f, -1.80747360e-01f, -1.21843636e-01f, 1.56636573e-02f, -1.42882735e-01f, -5.46510443e-02f, -9.66890976e-02f, -1.48670182e-01f, 4.34663100e-03f, -1.81745857e-01f,
  -1.31667048e-01f, 1.14834122e-02f, 5.51931821e-02f, 8.79907534e-02f, -7.49366581e-02f, 7.15029314e-02f, 1.33897319e-01f, -4.30192612e-02f, -2.50769034e-03f, 6.44873902e-02f,
  9.32496935e-02f, 8.64555091e-02f, -1.58827547e-02f, -3.16973850e-02f, -1.93701200e-02f, 5.58428504e-02f, 4.95750792e-02f, 4.18704152e-02f, 1.19071774e-01f, 1.46081731e-01f,
  8.62356275e-02f, -5.50021976e-02f, 7.47941211e-02f, 8.77024606e-02f, 1.32136652e-02f, 6.38338551e-02f, 7.92551879e-03f, 7.28733838e-02f, -1.56358834e-02f, -3.03844195e-02f,
  -1.08641470e-02f, 1.85588710e-02f, 2.82859355e-02f, -6.06803671e-02f, -5.20701222e-02f, -2.11548004e-02f, -7.36852586e-02f, -6.26715198e-02f, -4.36343811e-02f, 3.74022536e-02f,
  -8.51199701e-02f, 2.90079489e-02f, -1.12897307e-02f, -4.61907163e-02f, -5.85994758e-02f, -8.07400867e-02f, 1.92530826e-02f, -1.52498148e-02f, 2.72079725e-02f, -5.21637313e-02f,
  -3.71536277e-02f, 1.31627033e-03f, -1.19953625e-01f, -1.41867206e-01f, -9.13676769e-02f, -6.90486701e-03f, 2.29311008e-02f, -4.09761956e-03f, -1.60329472e-02f, 5.64777963e-02f,
  -4.52477299e-02f, 9.23838243e-02f, 5.46352267e-02f, 9.80565473e-02f, 9.33952630e-02f, 7.40503892e-02f, -3.66490819e-02f, 9.61525664e-02f, 8.06320608e-02f, 1.05421674e-02f,
  4.14907262e-02f, 5.14190085e-02f, 7.69099668e-02f, 4.97269183e-02f, 6.72595501e-02f, 1.27253443e-01f, 3.77037488e-02f, 1.11757331e-01f, 7.34755620e-02f, 7.60576129e-02f,
  2.18640551e-01f, 1.68377519e-01f, 2.18037248e-01f, 2.47225463e-01f, 1.81604460e-01f, 1.46686539e-01f, 1.82002023e-01f, 1.33207798e-01f, 2.29247659e-01f, 2.45341226e-01f,
  1.84028000e-01f, -1.70723021e-01f, -2.55122155e-01f, -1.51465729e-01f, -2.71229744e-01f, -2.36118123e-01f, -1.80397734e-01f, -1.18409714e-03f, 6.85643852e-02f, -1.76387638e-01f,
  1.96861816e-04f, 2.33388655e-02f, 6.49668500e-02f, 1.68153569e-01f, 7.01802447e-02f, -2.04367995e-01f, -1.64238513e-01f, 4.59496900e-02f, 1.35152385e-01f, 8.17528274e-03f,
  1.25309713e-02f, 1.02442086e-01f, 2.92516261e-01f, 2.29118600e-01f, -9.14805532e-02f, -5.00239097e-02f, -1.25006214e-01f, -2.31716391e-02f, 4.02629236e-03f, -5.68355769e-02f,
  -1.28033340e-01f, 2.22710535e-01f, 1.16550207e-01f, 1.67357594e-01f, -1.94875170e-02f, 1.03911616e-01f, 1.10979471e-02f, 7.50106052e-02f, 5.20038232e-02f, 4.38014753e-02f,
  -2.69106892e-03f, 4.68608700e-02f, 7.20539242e-02f, 1.21498279e-01f, 7.51796365e-02f, 8.48017931e-02f, 1.41453609e-01f, 2.34880075e-01f, 1.00873157e-01f, 8.96979496e-02f,
  6.68863505e-02f, 4.83961031e-02f, 1.16141140e-01f, 7.33908042e-02f, 2.11461633e-01f, 6.86247870e-02f, 1.94189511e-02f, 1.03342779e-01f, 8.34005028e-02f, -1.18853133e-02f,
  -1.77684352e-01f, -1.19685173e-01f, -5.49496226e-02f, -5.49267717e-02f, -8.11787248e-02f, -7.86573589e-02f, -3.27098370e-02f, -1.46038681e-02f, -4.97109257e-02f, 5.28490134e-02f,
  -2.21133921e-02f, -2.19552182e-02f, -3.39704044e-02f, 5.82178086e-02f, -2.59743612e-02f, 1.12026911e-02f, -2.28104722e-02f, -2.86717601e-02f, 2.01257262e-02f, -3.33391204e-02f,
  6.19796291e-02f, -5.37311542e-04f, -3.56608853e-02f, 3.44588757e-02f, 2.58818027e-02f, -1.68298259e-02f, 3.38740274e-02f, -1.88813470e-02f, 3.45225632e-02f, 2.85483841e-02f,
  -1.01790249e-01f, 9.23126191e-02f, -7.41813332e-02f, 1.55254588e-01f, -6.98391488e-03f, 1.80996478e-01f, -4.52215783e-02f, 1.07616596e-01f, 1.17105402e-01f, 9.38066188e-03f,
  1.62373528e-01f, 1.15171418e-01f, 3.52344029e-02f, 9.27099362e-02f, 8.91135335e-02f, 1.90374758e-02f, -5.86206205e-02f, 2.27308720e-02f, 4.07243073e-02f, 5.61207943e-02f,
  -6.76586572e-03f, -7.23695979e-02f, -8.09561312e-02f, -5.59569038e-02f, -2.82253418e-02f, 2.02055220e-02f, -1.26264974e-01f, -8.36259499e-02f, 7.44311046e-03f, -2.25980237e-01f,
  -3.85634214e-01f, 1.00889653e-01f, -7.19632804e-02f, 2.59719882e-02f, 4.15460281e-02f, 1.13652848e-01f, 8.66739526e-02f, 1.75894588e-01f, 3.58184688e-02f, 8.42233449e-02f,
  1.32116005e-01f, 6.29011095e-02f, -5.32295108e-02f, 7.28669018e-02f, 3.15633081e-02f, 1.96060836e-02f, -8.14590380e-02f, -1.71424568e-01f, -1.19485565e-01f, -6.71800971e-02f,
  2.02007741e-02f, -3.82491313e-02f, -2.29748651e-01f, -1.03383459e-01f, 5.90378530e-02f, -1.52177274e-01f, -1.55598089e-01f, -1.27993077e-01f, -9.85394046e-02f, -1.97055995e-01f,
  -8.79578814e-02f, 1.30525678e-01f, -4.13686559e-02f, 1.08945072e-02f, -1.31760407e-02f, 1.01633631e-01f, 8.63145813e-02f, 6.81404173e-02f, 8.98353457e-02f, 1.10136874e-01f,
  5.35118170e-02f, 1.61924571e-01f, 7.44813085e-02f, 3.73563394e-02f, 2.27753483e-02f, 1.43759131e-01f, 1.40443638e-01f, 6.56749606e-02f, 2.02512480e-02f, 8.92654434e-02f,
  1.76862851e-01f, -4.78605442e-02f, 4.46336716e-02f, -6.02418417e-03f, 1.31865188e-01f, -4.50266078e-02f, -3.43111828e-02f, 3.98119278e-02f, -8.43992308e-02f, -1.45122170e-01f,
  8.08135793e-03f, -4.80712466e-02f, 5.22305109e-02f, -7.60768652e-02f, -3.17693986e-02f, -9.65942368e-02f, -5.21863885e-02f, -8.03956911e-02f, -9.68452841e-02f, -4.09278311e-02f,
  -1.01283081e-01f, -1.96295500e-01f, -5.26732355e-02f, -1.25313297e-01f, -3.73894535e-02f, -3.25973481e-02f, -9.75024104e-02f, -1.10282041e-01f, -1.34958755e-02f, -2.90690120e-02f,
  -1.26744553e-01f, -1.48338601e-01f, -3.52177732e-02f, 1.24646062e-02f, -7.59640932e-02f, -4.33486886e-02f, -1.51344121e-01f, -7.35802501e-02f, -2.21374794e-03f, -1.33101732e-01f,
  4.41736840e-02f, 2.07391791e-02f, 2.51605753e-02f, 1.38463989e-01f, 7.82723501e-02f, -6.85801730e-04f, -9.75255203e-03f, 5.33302389e-02f, 8.41295570e-02f, 4.70276438e-02f,
  1.23764344e-01f, 2.66710762e-02f, 1.17759295e-01f, 9.67990234e-02f, 1.56294629e-02f, -9.62137058e-03f, 6.38433322e-02f, 5.62792271e-02f, -4.18369360e-02f, 7.26256892e-02f,
  -5.71459020e-03f, -1.10623300e-01f, -1.04099400e-01f, -1.29988790e-01f, 2.47972235e-02f, -4.01878655e-02f, -1.54534474e-01f, -1.23484313e-01f, -4.52555306e-02f, -1.42539874e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.61317766e-01f, 4.94561970e-01f, -7.74324656e-01f, 4.73799318e-01f, -2.11175699e-02f, -2.49453008e-01f, 1.28640667e-01f, 3.24865550e-01f, 2.90791422e-01f, 2.27380186e-01f,
  -1.77069213e-02f, -1.97598025e-01f, -1.29021376e-01f, -2.42097855e-01f, -2.81670004e-01f, -7.47893304e-02f, -2.19936937e-01f, -5.53369582e-01f, -4.79979426e-01f, -7.17321560e-02f,
  2.00954631e-01f, 4.60869849e-01f, 3.48966599e-01f, 3.72296348e-02f, 9.79566202e-02f, -1.69069648e-01f, -6.84278691e-03f, 1.70618331e-03f, -2.85362750e-01f, -2.90063679e-01f,
  -4.97095942e-01f, 3.42846178e-02f, -4.12182540e-01f, -4.86667342e-02f, -1.64998367e-01f, -9.38614234e-02f, 1.11715170e-02f, -4.74101342e-02f, 1.10207669e-01f, 3.16449143e-02f,
  -3.25499028e-02f, -7.77468756e-02f, 4.21063118e-02f, -9.88912955e-02f, 1.03944533e-01f, 1.36432284e-02f, 6.18040897e-02f, -1.88368127e-01f, -1.00259885e-01f, -7.53866360e-02f,
  -8.19660574e-02f, -2.88601458e-01f, -2.21879885e-01f, -1.44203708e-01f, -1.81654170e-01f, -1.95611149e-01f, -1.20346874e-01f, -2.69330949e-01f, -2.46430025e-01f, 8.76633301e-02f,
  2.58642063e-02f, -3.19987559e-03f, -4.18312289e-03f, 4.98635881e-02f, 6.03379086e-02f, -8.67606476e-02f, 2.23619621e-02f, 3.09706852e-03f, 4.76126857e-02f, 7.74873979e-03f,
  -9.66055542e-02f, 8.57403502e-02f, 1.62188541e-02f, 1.82675496e-01f, 4.81862947e-02f, 1.19626932e-02f, -6.91750795e-02f, 9.47626308e-02f, -2.27391887e-02f, 5.65299653e-02f,
  -8.98622498e-02f, -4.96042147e-02f, 2.21031830e-02f, -2.44922452e-02f, -1.75385401e-01f, -1.66992933e-01f, 2.35334989e-02f, 5.98544069e-03f, 1.07303739e-01f, 6.01376444e-02f,
  3.60982358e-01f, -2.53703296e-01f, -3.13327387e-02f, -1.33936226e-01f, -9.43503305e-02f, -1.44933686e-01f, 6.40390888e-02f, -5.07228076e-03f, 5.85706942e-02f, 4.25554030e-02f,
  -1.17328562e-01f, 8.07304084e-02f, 1.24438316e-01f, 7.20901415e-02f, -1.20893523e-01f, 1.91461705e-02f, 1.25946060e-01f, -2.15624779e-01f, -3.55112739e-02f, 5.34529760e-02f,
  2.72889942e-01f, -5.67747541e-02f, 1.21203832e-01f, 6.44667074e-02f, 6.08320236e-02f, 1.34702977e-02f, -4.14849557e-02f, -4.44670543e-02f, -1.58523366e-01f, 4.77017194e-01f,
  -2.59093851e-01f, 1.03343718e-01f, 1.18679829e-01f, -2.33164236e-01f, -8.97811726e-02f, 9.27871242e-02f, 2.41510049e-02f, 1.31164283e-01f, 1.77563101e-01f, 1.34278864e-01f,
  1.46541178e-01f, -1.31737515e-02f, 5.57849668e-02f, -7.31860325e-02f, -1.04648553e-01f, 9.90579203e-02f, -2.42490284e-02f, -1.74412638e-01f, -2.03168765e-01f, -2.25813761e-01f,
  -1.97346166e-01f, -2.46018842e-01f, -2.98469514e-01f, -2.04318866e-01f, -6.51371256e-02f, -1.72604352e-01f, 1.85375959e-02f, -1.70288935e-01f, -1.62303805e-01f, -2.30541304e-01f,
  1.93466768e-01f, 3.85510437e-02f, -4.58689816e-02f, -1.86215162e-01f, 9.02538747e-03f, 1.36538700e-03f, 4.34291586e-02f, 1.79963000e-02f, -4.68257107e-02f, 4.16678488e-02f,
  -1.18586153e-01f, -2.48921998e-02f, -1.13827489e-01f, -5.89855500e-02f, 1.62772797e-02f, -4.05367836e-02f, -9.86180976e-02f, -8.77577662e-02f, -9.58788395e-02f, 1.26560982e-02f,
  -1.68334544e-01f, -2.45885462e-01f, -1.11976802e-01f, -9.50901210e-02f, 5.89411445e-02f, -1.35729104e-01f, -1.61105786e-02f, -8.66130516e-02f, -8.67241398e-02f, -3.30587029e-02f,
  2.33748145e-02f, -2.13969555e-02f, -1.37026710e-02f, 1.38384566e-01f, 4.22829874e-02f, 6.80310428e-02f, -3.53638753e-02f, -1.04500584e-01f, 2.72153951e-02f, -2.36216150e-02f,
  3.80610526e-02f, 1.38338581e-01f, 9.76665393e-02f, -1.93720590e-02f, -9.52039100e-03f, -4.06490266e-02f, -5.22380210e-02f, -7.89668187e-02f, 1.09227290e-02f, 6.07324112e-03f,
  2.41985489e-02f, -3.61644477e-02f, 6.16771681e-03f, 9.16943979e-03f, 1.80484646e-03f, 2.18752399e-02f, 9.18837041e-02f, 3.41928564e-02f, 7.18871579e-02f, 1.70321688e-01f,
  1.26793623e-01f, -2.29978040e-02f, 7.76656121e-02f, -7.08003268e-02f, 1.42318681e-02f, 8.69130045e-02f, -3.05778403e-02f, 2.74386210e-03f, 4.39407565e-02f, -6.53948039e-02f,
  -5.71777523e-02f, -2.65307762e-02f, -3.64691718e-03f, -1.48901772e-02f, -3.09917666e-02f, -6.79857880e-02f, -2.15445697e-01f, -2.27041736e-01f, -9.26627517e-02f, 1.77137237e-02f,
  -1.23588167e-01f, -2.16320619e-01f, -3.05590212e-01f, -1.37460038e-01f, -3.29128355e-02f, -2.22258896e-01f, -3.79309133e-02f, -2.31789928e-02f, -1.02066979e-01f, -2.50260588e-02f,
  1.61769077e-01f, 3.61920595e-01f, -1.04919031e-01f, 2.12406561e-01f, -3.44781242e-02f, 1.36933625e-01f, 1.36948064e-01f, 2.32594505e-01f, 2.58196473e-01f, 2.07372740e-01f,
  1.94562495e-01f, 1.87510893e-01f, 2.70653486e-01f, 1.66191444e-01f, 2.81585664e-01f, 3.09182882e-01f, 2.80157983e-01f, 7.56716654e-02f, 3.95548120e-02f, 1.59427494e-01f,
  1.90900385e-01f, 5.69867082e-02f, 8.98972154e-02f, 1.92691803e-01f, 1.21552996e-01f, 2.42395386e-01f, 7.29768574e-02f, 1.30560249e-01f, 1.38839513e-01f, 3.43548536e-01f,
  -1.73098907e-01f, 1.51884696e-02f, 8.58572572e-02f, -1.18058354e-01f, -7.09325224e-02f, 2.31076386e-02f, -8.15854073e-02f, -1.84353255e-03f, -1.32499672e-02f, 2.98835319e-02f,
  -9.06957835e-02f, -1.60578400e-01f, -1.92533389e-01f, -8.01261961e-02f, -1.40779585e-01f, -1.65092707e-01f, -4.30014879e-02f, 4.96450551e-02f, 1.83075994e-01f, 8.18063691e-02f,
  5.35806604e-02f, -7.04909563e-02f, -1.91229880e-02f, -7.00289980e-02f, 8.27846825e-02f, -8.23836997e-02f, 1.51078252e-03f, -4.47720364e-02f, -4.74112034e-02f, 1.55159414e-01f,
  1.65042222e-01f, 1.74655735e-01f, -7.60545135e-02f, -4.32360023e-02f, -1.41651332e-02f, -9.33977962e-02f, -1.52870556e-02f, 6.25240291e-03f, 4.94703725e-02f, -1.54868484e-01f,
  -5.74155003e-02f, -4.06627310e-03f, -2.43449882e-02f, -1.45991817e-01f, -6.28615841e-02f, -2.50688717e-02f, -3.35633419e-02f, -4.61725108e-02f, -1.79318890e-01f, -8.07649642e-03f,
  2.20736396e-02f, -2.22868677e-02f, -2.51177669e-01f, -1.08642466e-01f, -8.28783438e-02f, -1.58957675e-01f, -7.40350410e-02f, -3.62597629e-02f, -6.10960498e-02f, 2.72524338e-02f,
  1.03013720e-02f, -1.29624233e-01f, 1.91893935e-01f, 2.03558728e-01f, -7.67165497e-02f, -8.43595266e-02f, 3.34654078e-02f, -1.16576128e-01f, -6.79142773e-02f, -8.18185583e-02f,
  -7.39827901e-02f, -1.43471569e-01f, -9.35987942e-03f, -6.19549975e-02f, -2.02236772e-01f, -1.09902419e-01f, -2.40544435e-02f, 1.35984734e-01f, 6.00118414e-02f, -2.75584124e-02f,
  2.19304878e-02f, 1.48879699e-02f, -2.89392360e-02f, 3.77237834e-02f, 6.36901930e-02f, -7.95474052e-02f, -1.80637062e-01f, 1.79591682e-03f, -2.42150545e-01f, -2.84477621e-02f,
  -4.94523764e-01f, 1.02269463e-02f, 5.56311756e-02f, 5.15272468e-02f, 1.27972633e-01f, 9.12182555e-02f, 1.12182446e-01f, -2.00209226e-02f, -8.23961794e-02f, 2.90135350e-02f,
  -3.72389257e-02f, -7.35221505e-02f, 9.47309099e-03f, -5.36716962e-03f, -5.79541586e-02f, 2.23766580e-01f, 1.91850975e-01f, 3.40495557e-02f, 1.35628298e-01f, 1.64037589e-02f,
  9.08130482e-02f, 6.23146221e-02f, 1.35594299e-02f, -2.91687883e-02f, 9.41782445e-02f, 8.23864117e-02f, 7.31920674e-02f, -8.96171108e-03f, 4.65690754e-02f, 1.45772457e-01f,
  1.92947432e-01f, -3.47581804e-01f, -7.20968023e-02f, -1.86180234e-01f, -3.56454775e-02f, -1.60860181e-01f, -7.27669373e-02f, -2.66432539e-02f, -2.75379512e-03f, -7.06046149e-02f,
  -1.18903946e-02f, -7.13901222e-02f, -1.09247364e-01f, 3.69145796e-02f, 1.08968586e-01f, 3.62102352e-02f, -2.21069008e-02f, -1.47343129e-01f, -1.61403775e-01f, -2.02896312e-01f,
  1.18293613e-02f, -1.37750402e-01f, -1.38052925e-01f, -6.74707219e-02f, -1.44025460e-01f, -8.41794088e-02f, -9.53011811e-02f, -1.78902283e-01f, -8.34113955e-02f, -7.34851370e-03f,
  -1.08175218e-01f, 2.88765263e-02f, -6.00232966e-02f, -3.56421843e-02f, 1.20356664e-01f, -1.55744411e-03f, 1.42970458e-01f, 1.80154413e-01f, 1.25227690e-01f, 1.31989717e-01f,
  5.40675782e-02f, 1.07885294e-01f, 6.18633367e-02f, 1.45147294e-01f, 3.71234119e-02f, -1.62044708e-02f, 5.77928163e-02f, 4.33081482e-03f, -6.69729784e-02f, -1.93182677e-01f,
  -8.22699293e-02f, -1.88183803e-02f, 2.15367433e-02f, 4.58413698e-02f, -4.04059403e-02f, -2.30971463e-02f, 7.72060081e-02f, -8.47757310e-02f, 3.38244960e-02f, -9.86336321e-02f,
  4.38440263e-01f, -3.39382589e-01f, 2.56689116e-02f, -1.43956661e-01f, 2.10547596e-02f, -4.13512029e-02f, -2.21430250e-02f, -5.57290167e-02f, 9.49222818e-02f, 1.87500305e-02f,
  2.28222795e-02f, 7.92766660e-02f, 3.25576290e-02f, 5.78589328e-02f, 2.66318321e-01f, 2.08471213e-02f, 3.46285179e-02f, 8.99398550e-02f, -8.93736333e-02f, 2.52963249e-02f,
  -4.34004441e-02f, 3.44147198e-02f, 1.87440604e-01f, 1.67566925e-01f, -1.98883377e-02f, 1.60264239e-01f, 2.56872535e-01f, 8.89995098e-02f, 1.28930762e-01f, 3.50312799e-01f,
  -5.13845086e-01f, -8.71140242e-01f, 3.86705011e-01f, -1.32695735e-01f, 6.64339602e-01f, 4.19762254e-01f, 5.83008789e-02f, -1.63516000e-01f, 2.55002268e-03f, -2.41987795e-01f,
  -4.11112100e-01f, -3.74229819e-01f, -4.45932955e-01f, -1.96323171e-01f, -2.29442701e-01f, 1.65898278e-01f, 5.82735479e-01f, 3.68457019e-01f, 4.74851012e-01f, 4.24744219e-01f,
  1.93787470e-01f, 6.21495117e-03f, -1.79601774e-01f, 6.93655461e-02f, -7.46167973e-02f, -1.80130638e-02f, 6.25375137e-02f, 3.86446118e-02f, 9.14323926e-02f, 1.66528784e-02f,
  -3.15827757e-01f, -6.13165677e-01f, 2.16917053e-01f, 1.45145897e-02f, 8.22995678e-02f, -2.50660509e-01f, -2.21268386e-02f, -7.06305876e-02f, -1.11538962e-01f, -8.41864124e-02f,
  -2.84993462e-02f, -1.28760427e-01f, -6.21465519e-02f, -7.59818330e-02f, -1.34556428e-01f, -2.67722964e-01f, -6.80825487e-02f, -2.14055657e-01f, -7.00472146e-02f, 1.16891237e-02f,
  9.58078876e-02f, 2.33974770e-01f, -5.31951152e-02f, 6.91918880e-02f, 1.41212419e-02f, 3.03953767e-01f, 2.79688910e-02f, 1.07420653e-01f, 8.11109468e-02f, -2.19561160e-01f,
  1.92429587e-01f, -1.34115089e-02f, -1.78754572e-02f, -9.03678685e-02f, -1.44186511e-03f, -5.05019818e-03f, -4.19141678e-03f, -5.86164109e-02f, 5.56692220e-02f, -1.09485686e-01f,
  -1.48847967e-01f, -4.85741012e-02f, 2.23164465e-02f, -1.38192147e-01f, -4.72678021e-02f, 3.47550325e-02f, 5.24709001e-02f, -1.55040234e-01f, 1.09447330e-01f, -9.91664976e-02f,
  -5.61510073e-03f, -4.53916471e-03f, 9.95256677e-02f, -1.29577503e-01f, 6.73904419e-02f, 1.40174076e-01f, 1.29740462e-01f, -9.80605856e-02f, -1.03317320e-01f, 4.08247150e-02f,
  -5.21072686e-01f, 8.27046763e-03f, -2.16825321e-01f, -9.13037434e-02f, -1.16616957e-01f, 8.94833729e-02f, -4.80794795e-02f, -3.90044339e-02f, -6.56618848e-02f, -1.62726045e-01f,
  -1.17408037e-01f, -8.64634737e-02f, -9.21365470e-02f, 4.84057590e-02f, 1.90284625e-01f, -3.79667208e-02f, 1.07383775e-02f, -5.57022952e-02f, 5.24493828e-02f, 9.48206261e-02f,
  3.34182307e-02f, 8.02430511e-02f, -1.04239531e-01f, -9.55312774e-02f, -3.76809277e-02f, 8.91917869e-02f, 6.23198878e-03f, 4.25592698e-02f, 1.02906950e-01f, -1.41527385e-01f,
  -6.29457116e-01f, 4.15983051e-01f, 1.92466334e-01f, -4.68336910e-01f, 5.91821112e-02f, 2.63692081e-01f, 5.15579581e-01f, 5.32085225e-02f, -2.35935584e-01f, 1.96547881e-01f,
  9.68323573e-02f, -1.80601865e-01f, -2.21406128e-02f, 7.79080987e-02f, 1.03506237e-01f, 3.79626960e-01f, 2.31600091e-01f, -6.22271895e-02f, -1.72585234e-01f, 3.99165750e-02f,
  1.55440569e-01f, -1.59412444e-01f, -3.04876298e-01f, -1.64587468e-01f, -1.00522965e-01f, -2.04119280e-01f, -3.31795849e-02f, -1.78936757e-02f, 2.73309946e-01f, 1.87955081e-01f,
  -4.59124967e-02f, -6.20153993e-02f, -6.57314733e-02f, -2.15036348e-01f, -4.23611440e-02f, -1.59695428e-02f, 1.36645988e-01f, -6.52617589e-02f, 1.31032273e-01f, 6.18638992e-02f,
  -1.05677657e-02f, 6.57778382e-02f, -4.74387314e-03f, 3.41905467e-02f, -1.46431714e-01f, -5.01305349e-02f, -1.47031814e-01f, -1.87186319e-02f, -7.74499550e-02f, 5.75925037e-02f,
  2.25126326e-01f, -6.90767765e-02f, -1.69509009e-01f, 2.99350601e-02f, 8.57144222e-03f, -1.69193879e-01f, 3.58601511e-02f, 2.54445728e-02f, 1.71319209e-02f, -7.39387125e-02f,
  -5.07777072e-02f, -1.82261057e-02f, 4.54773828e-02f, -1.82414986e-03f, 1.64562389e-02f, 9.65537205e-02f, 3.27290073e-02f, 1.37443423e-01f, 4.46601212e-03f, 5.26682183e-04f,
  2.30492000e-02f, -1.01136468e-01f, -5.40583059e-02f, -1.20854080e-02f, 3.07023730e-02f, 2.65903268e-02f, 1.66566614e-02f, 1.37573376e-01f, 8.13008547e-02f, 6.60977215e-02f,
  -6.53138682e-02f, 4.28859852e-02f, -1.08861305e-01f, -4.08862485e-03f, 4.15834002e-02f, -2.42856499e-02f, -5.62484041e-02f, -8.27178545e-03f, -7.29525536e-02f, 1.25060499e-01f,
  -4.24362659e-01f, 2.28485674e-01f, -1.53397262e-01f, -5.58363982e-02f, 3.61127295e-02f, 8.74406751e-03f, 3.84814665e-02f, 4.98025715e-02f, -4.10647653e-02f, -8.25729892e-02f,
  9.10215452e-02f, 6.95664883e-02f, 3.87125998e-03f, 3.87021787e-02f, -8.75957981e-02f, -1.00895047e-01f, 8.20983723e-02f, -5.36635108e-02f, -2.99826246e-02f, -8.95228609e-02f,
  -1.02346629e-01f, -4.07912098e-02f, -3.42538506e-01f, -1.06657378e-01f, -1.77759469e-01f, -2.63316274e-01f, -8.70598704e-02f, -1.11365065e-01f, -1.54227521e-02f, -9.22516212e-02f,
  7.23742425e-01f, 5.04897714e-01f, 3.39469969e-01f, 5.98030239e-02f, 1.94078013e-01f, 3.95743906e-01f, 4.76754755e-01f, 2.99660891e-01f, 3.82625051e-02f, 1.67453185e-01f,
  8.17877576e-02f, -1.62101030e-01f, -2.12007374e-01f, -1.15050688e-01f, 9.24213901e-02f, -1.33563057e-02f, -1.23525888e-01f, 6.85089901e-02f, 5.66732101e-02f, 1.29339829e-01f,
  -2.25389287e-01f, 6.34754896e-02f, 1.14646405e-01f, -5.73059656e-02f, -1.27962843e-01f, -1.03244424e-01f, 5.34584038e-02f, 1.41839311e-01f, 1.08462021e-01f, -1.20221041e-01f,
  -1.97009712e-01f, 3.41283828e-01f, -2.72281498e-01f, -1.87388480e-01f, 9.86664742e-02f, -8.71977955e-02f, 3.64612155e-02f, -1.06313601e-01f, -1.57668918e-01f, -1.49344549e-01f,
  -1.38187781e-01f, -6.62033260e-03f, 1.27444372e-01f, 1.47073548e-02f, 7.60158747e-02f, 4.10671867e-02f, 1.25606641e-01f, 8.33994672e-02f, -4.14625220e-02f, -3.56564261e-02f,
  -1.77564174e-01f, 1.43657833e-01f, 1.70379937e-01f, -1.15451291e-02f, 1.20689109e-01f, -5.94173819e-02f, 1.87210605e-01f, 1.03652366e-01f, 2.39087623e-02f, 1.68003440e-01f,
  -3.41596812e-01f, -3.93343717e-02f, 9.59602147e-02f, -5.56612248e-03f, -4.75334972e-02f, 5.87070026e-02f, 4.95039821e-02f, 6.64419383e-02f, 1.91576406e-02f, 1.18178248e-01f,
  -4.77401689e-02f, 5.19497495e-04f, 7.58809224e-02f, 1.18554629e-01f, -1.74168214e-01f, 1.33448377e-01f, 4.49060202e-02f, 1.82388667e-02f, 6.50372878e-02f, -2.68975701e-02f,
  5.01029119e-02f, 9.23746452e-02f, 1.39364183e-01f, 1.70072496e-01f, 5.46764992e-02f, 4.96803597e-02f, 4.43736278e-03f, -1.71132572e-02f, 7.99693763e-02f, -3.15016992e-02f,
  -1.41558751e-01f, 1.65064279e-02f, -1.86249271e-01f, -1.27018288e-01f, 1.06995385e-02f, -5.32031022e-02f, -8.23476836e-02f, -8.55063349e-02f, -1.63386419e-01f, -1.59469545e-01f,
  3.07317749e-02f, -9.94962640e-03f, 1.37291197e-02f, -5.01821712e-02f, 5.51537313e-02f, -7.31100067e-02f, -5.90979494e-03f, 9.11737755e-02f, -1.06364034e-01f, -1.09919719e-01f,
  -3.86376679e-02f, 2.68296525e-03f, 3.51997875e-02f, -1.18524693e-02f, -1.74991369e-01f, -7.29061812e-02f, 9.53209307e-03f, -1.70935038e-02f, 7.55502982e-03f, 5.58033437e-02f,
  1.05881758e-01f, -7.19366550e-01f, 1.56653062e-01f, 4.96926308e-02f, -2.58002400e-01f, -1.38353735e-01f, -5.65913737e-01f, -1.87239990e-01f, -2.67253481e-02f, -5.89223921e-01f,
  -1.89762145e-01f, 5.89473844e-01f, 5.84848225e-01f, 4.27784026e-01f, 3.94391239e-01f, -5.86792469e-01f, -4.22678232e-01f, 4.74153280e-01f, 7.54334688e-01f, -2.32364107e-02f,
  -3.40191394e-01f, -3.74647528e-02f, 3.26067001e-01f, 2.01671988e-01f, -4.54350561e-01f, 1.14978127e-01f, -3.09829116e-01f, -2.61494279e-01f, -2.21214056e-01f, -6.64411068e-01f,
  3.19561325e-02f, -2.41989270e-01f, 2.77466744e-01f, 1.08024813e-01f, -4.40013818e-02f, 6.49468787e-03f, -4.61256132e-02f, -3.00646164e-02f, -1.36806190e-01f, -1.34105757e-01f,
  -3.26212049e-02f, 4.15217616e-02f, 2.27513462e-02f, -5.78463748e-02f, -7.93304369e-02f, -3.62687707e-02f, 7.22768903e-03f, 1.38426021e-01f, 2.94793900e-02f, -1.52623326e-01f,
  -2.31060758e-01f, -1.88657820e-01f, 3.97760756e-02f, -9.24994722e-02f, 6.19733334e-02f, 2.40200236e-01f, -1.19238101e-01f, -1.30892575e-01f, 4.75566946e-02f, -6.03943586e-01f,
  -2.93211248e-02f, -2.12742779e-02f, 4.80949767e-02f, -6.88832859e-03f, -3.68605740e-02f, -5.15217967e-02f, -6.13912335e-03f, -1.32563468e-02f, 7.46958656e-03f, 2.02729851e-02f,
  6.66998327e-02f, -4.63609248e-02f, -1.06127746e-02f, -1.02009900e-01f, -5.77741396e-03f, -1.88227221e-02f, 5.36355861e-02f, 1.84275992e-02f, 7.85990153e-03f, -6.74672276e-02f,
  7.16054207e-03f, -2.54046619e-02f, 4.40749004e-02f, 4.23502102e-02f, -1.07700385e-01f, 1.31398007e-01f, 8.89497995e-03f, 6.06686622e-02f, 1.11713581e-01f, -1.52012914e-01f,
  3.15977573e-01f, 4.10407186e-01f, -1.10600740e-01f, 1.24169484e-01f, -1.12483084e-01f, -1.96830388e-02f, -8.90628397e-02f, -1.73160098e-02f, -4.48821904e-03f, 7.57005587e-02f,
  2.49188486e-02f, 1.01368487e-01f, -2.86364127e-02f, -5.04167341e-02f, -7.46765435e-02f, -9.35136080e-02f, -2.06293598e-01f, 6.71169311e-02f, -3.53765450e-02f, -1.87681243e-01f,
  -2.13958606e-01f, -4.41656560e-02f, 1.26763746e-01f, 4.72779758e-02f, -1.11153252e-01f, 2.43017763e-01f, 8.49335641e-03f, -1.31562203e-02f, 2.42629334e-01f, -4.31469411e-01f,
  4.64304060e-01f, 5.57034433e-01f, 2.38787636e-01f, -6.05525542e-03f, -1.62472010e-01f, 6.04147837e-02f, 2.08261713e-01f, 1.30778655e-01f, -1.64032519e-01f, -5.24784364e-02f,
  -1.98900878e-01f, -2.66694695e-01f, -2.49291629e-01f, -7.55924508e-02f, 4.31929007e-02f, 1.74026564e-01f, 8.96035731e-02f, 1.68969795e-01f, -7.93885887e-02f, -5.08001409e-02f,
  -1.00188456e-01f, 1.84075430e-01f, 1.74322724e-01f, 7.34262615e-02f, 1.95534155e-01f, -1.63630053e-01f, 1.12469830e-01f, 1.81393728e-01f, 6.97411224e-02f, 2.13526368e-01f,
  1.09452255e-01f, 3.92748266e-01f, -4.85199064e-01f, -1.01999402e-01f, -1.33741414e-02f, -4.75840494e-02f, -1.50773346e-01f, 3.37303653e-02f, -2.93353815e-02f, 1.10726990e-02f,
  1.35068651e-02f, -1.68811306e-02f, 2.67147925e-02f, 2.31063496e-02f, 1.19250022e-01f, -2.60489546e-02f, 1.07764617e-01f, 2.35311687e-01f, -3.84112224e-02f, 9.95036140e-02f,
  -3.73092927e-02f, 7.30104893e-02f, -2.25779265e-02f, -1.12939827e-01f, -1.27567379e-02f, -3.31670105e-01f, 8.70455876e-02f, -3.01505160e-02f, -1.32317528e-01f, 4.70046476e-02f,
  -3.75092238e-01f, 1.62481121e-03f, 1.30020991e-01f, 3.35416347e-02f, -4.78674620e-02f, -1.07726187e-01f, -1.44148497e-02f, 2.00543962e-02f, 5.04342979e-03f, 4.64618988e-02f,
  -9.57573652e-02f, -1.84241891e-01f, -1.29235014e-01f, -1.26392901e-01f, -2.13966385e-01f, 8.77285525e-02f, -1.55666098e-02f, -1.28489673e-01f, -9.80821624e-02f, -3.57856452e-02f,
  1.60260883e-03f, 8.38140696e-02f, -4.12237570e-02f, 4.42517139e-02f, -2.95686554e-02f, -1.29628614e-01f, -1.46694854e-01f, -1.32119760e-01f, -1.46258429e-01f, 2.42153332e-02f,
  -2.29281649e-01f, -3.32302928e-01f, -2.98567563e-01f, 1.41793936e-01f, 2.22229853e-01f, 6.23089895e-02f, 6.99005052e-02f, -6.31564334e-02f, 6.57108054e-02f, 5.75337522e-02f,
  1.54405206e-01f, 4.18642238e-02f, 1.32410869e-01f, 1.83888867e-01f, -1.04286551e-01f, -1.28108099e-01f, 5.75502329e-02f, -3.06976736e-02f, 6.15331084e-02f, 1.72688559e-01f,
  -5.11309579e-02f, -2.30469763e-01f, -2.43655905e-01f, -2.72350997e-01f, -1.95238501e-01f, -4.72719193e-01f, -2.35147223e-01f, -1.50173843e-01f, -1.58100873e-01f, -2.47292861e-01f,
  -1.58928856e-01f, -2.30011106e-01f, -1.90717503e-01f, -3.82799923e-01f, 3.45772170e-02f, -1.94060039e-02f, -4.20503765e-01f, -2.91863948e-01f, -1.28705248e-01f, -4.60721999e-01f,
  7.41979480e-02f, 3.10218662e-01f, -1.85806066e-01f, -1.55276647e-02f, -4.20514315e-01f, -7.50991464e-01f, -6.15380704e-01f, -2.55501717e-01f, 1.72711775e-01f, 2.94816256e-01f,
  1.37591705e-01f, -2.66036224e-02f, -5.21345995e-02f, -1.50722088e-02f, -2.06614092e-01f, 9.51600540e-03f, -2.26799011e-01f, -8.69566947e-02f, -1.75533697e-01f, -2.42926195e-01f,
  -4.00346845e-01f, -4.43960503e-02f, 7.97525123e-02f, 2.40709141e-01f, 5.81996106e-02f, 1.07405953e-01f, 7.86976982e-03f, 9.43367332e-02f, 2.53810495e-01f, -1.07593924e-01f,
  6.48877844e-02f, 1.57999307e-01f, 8.92587379e-02f, 1.42258212e-01f, -6.39999956e-02f, -2.94338390e-02f, -5.97341023e-02f, 6.50075637e-03f, -1.38632640e-01f, -4.86366376e-02f,
  1.64545015e-01f, 1.13584593e-01f, -1.56037241e-01f, -1.33009866e-01f, -2.73330450e-01f, 1.66628603e-02f, 1.76188932e-03f, 1.13409296e-01f, -1.47778466e-01f, -2.52791137e-01f,
  -8.63837637e-03f, -3.44024599e-02f, -6.46102568e-03f, 2.19108574e-02f, -2.57379021e-02f, 3.11956350e-02f, -1.21956699e-01f, -1.26359344e-01f, 8.27956125e-02f, -2.00380404e-02f,
  6.93490505e-02f, -2.66851392e-02f, 2.67768521e-02f, -9.82167572e-02f, 9.59518626e-02f, -2.53067967e-02f, -6.39010295e-02f, -1.03392810e-01f, -1.10500641e-02f, -2.94595193e-02f,
  1.68200657e-01f, -4.05300595e-02f, -5.93253858e-02f, 1.51344854e-02f, 5.06045558e-02f, -1.77972138e-01f, 3.09669990e-02f, 9.52407420e-02f, 3.78265753e-02f, 7.80878291e-02f,
  -2.63870299e-01f, 7.64080584e-02f, -3.39354813e-01f, -1.04048930e-01f, -9.07858908e-02f, -8.02527647e-03f, -7.12107718e-02f, 2.82944199e-02f, 1.13701895e-01f, -6.32830756e-03f,
  -2.10155770e-02f, -1.92929462e-01f, -2.16110125e-01f, 7.44296089e-02f, 8.88854936e-02f, 4.30136770e-02f, -1.13716684e-01f, 5.23456000e-02f, -1.09906937e-03f, 8.87902379e-02f,
  -1.39991358e-01f, -2.59161174e-01f, -3.23443800e-01f, -2.61442214e-01f, -1.22816660e-01f, -3.56094092e-02f, -1.54197529e-01f, -1.46415725e-01f, -3.12501848e-01f, -4.95846987e-01f,
  -5.42529285e-01f, 4.93384711e-02f, -3.71230155e-01f, 1.80881679e-01f, 1.57080933e-01f, 1.95717454e-01f, 6.66002333e-01f, 3.51572961e-01f, 1.70738310e-01f, 1.89206049e-01f,
  -2.23596349e-01f, -4.59040433e-01f, -5.35211563e-01f, -2.41930217e-01f, -9.87090394e-02f, 5.52189410e-01f, 3.19823384e-01f, -2.84459263e-01f, -2.99383044e-01f, 1.08597577e-01f,
  3.19642752e-01f, 2.10189357e-01f, -1.81000084e-01f, -2.99067982e-02f, 1.15065105e-01f, -6.84391037e-02f, 2.06200797e-02f, -1.04095936e-01f, -1.20820981e-02f, 1.01249637e-02f,
  -4.67440426e-01f, -4.61379707e-01f, 2.70797387e-02f, -1.65779397e-01f, -9.05932635e-02f, -1.02730066e-01f, -1.02959843e-02f, -1.39317825e-01f, -2.72543430e-01f, -2.60824095e-02f,
  -2.51661241e-02f, -1.51489019e-01f, -3.52098197e-01f, -1.12813003e-02f, -2.42120698e-02f, 4.19766791e-02f, -2.43623108e-02f, -2.05961064e-01f, -3.58697295e-01f, -3.43657762e-01f,
  8.20021853e-02f, -2.11506993e-01f, -2.90663362e-01f, 4.79333252e-02f, -2.13387921e-01f, -2.74206400e-01f, -1.24648921e-01f, -3.43942076e-01f, -3.87889475e-01f, 5.28835133e-02f,
  1.41240269e-01f, -6.34630844e-02f, 7.70496279e-02f, 2.40888655e-01f, 1.32340148e-01f, 4.93790135e-02f, 7.21000694e-03f, -1.05112851e-01f, -5.88442758e-02f, 3.07273673e-04f,
  -6.78576827e-02f, -1.13575123e-01f, -1.16679147e-01f, 2.70580202e-02f, 2.56763957e-03f, -8.78047571e-02f, 7.03931451e-02f, -1.74600463e-02f, -5.54781370e-02f, 1.75393000e-02f,
  -4.93641682e-02f, 3.67896780e-02f, -9.02405605e-02f, -1.57510750e-02f, 6.65570199e-02f, -1.18618473e-01f, 4.62541096e-02f, -6.75424188e-02f, -4.67941836e-02f, 4.89528030e-02f,
  2.91352838e-01f, -5.35342321e-02f, 1.28817663e-01f, 1.56543389e-01f, 6.39628023e-02f, -5.59339300e-02f, -1.57147199e-01f, 1.28336074e-02f, -1.27626076e-01f, -6.17621727e-02f,
  -1.48147509e-01f, -1.42719388e-01f, -2.28725567e-01f, 7.11339861e-02f, 8.53193030e-02f, -3.44464555e-02f, 9.39650163e-02f, 1.62986279e-01f, 5.37283532e-02f, 1.02707259e-01f,
  1.97602525e-01f, 3.53186518e-01f, 2.75780410e-01f, 1.92107975e-01f, 1.03822723e-01f, 8.36025923e-02f, 1.20835543e-01f, 1.58342645e-01f, 3.19151245e-02f, 8.20299149e-01f,
  -9.14259791e-01f, 7.61955082e-02f, 2.51790166e-01f, -3.20911765e-01f, -1.04219079e-01f, 9.99991968e-02f, 1.51951879e-01f, -1.80088505e-02f, -1.95951626e-01f, -2.82949256e-03f,
  6.95917383e-02f, 2.08947584e-01f, 9.10212249e-02f, 2.28153586e-01f, 1.94668308e-01f, 3.78023982e-01f, 2.16747090e-01f, 2.53357477e-02f, 5.20981774e-02f, 1.67083547e-01f,
  1.54008225e-01f, -1.27637684e-01f, -2.12024286e-01f, -1.12990625e-01f, 1.34228289e-01f, 1.89210817e-01f, 1.93808377e-01f, 1.09487481e-01f, 2.22634301e-01f, 1.89122766e-01f,
  5.89023829e-01f, -1.77277058e-01f, 1.05779208e-01f, -3.33758444e-02f, 5.25930524e-02f, -1.52685791e-01f, 7.46908486e-02f, 2.39545386e-02f, -1.69914663e-01f, 3.12856063e-02f,
  3.23912576e-02f, -3.41493003e-02f, -5.82960527e-03f, 9.48015228e-02f, 2.51592249e-02f, -1.42535148e-02f, -7.16817155e-02f, -1.01656631e-01f, 1.04068615e-01f, 1.24162108e-01f,
  1.54413655e-01f, 5.15320152e-03f, 2.25931816e-02f, 9.53835472e-02f, -5.80577776e-02f, 1.52631178e-02f, 2.19872296e-01f, 1.87072414e-03f, -3.80227044e-02f, 3.74964178e-02f,
  1.93698313e-02f, -1.60088450e-01f, -9.85759124e-02f, -2.90356148e-02f, -2.13732999e-02f, -7.52881542e-02f, 5.56682311e-02f, -8.66462961e-02f, -5.60724847e-02f, -1.02210179e-01f,
  1.17549479e-01f, 1.96442623e-02f, -4.09381539e-02f, 6.45378232e-02f, 4.84318547e-02f, -4.83171940e-02f, -8.92039761e-02f, 1.30820274e-01f, 1.18919007e-01f, -4.39937674e-02f,
  -1.46206439e-01f, 6.79578818e-03f, 9.62200984e-02f, 1.05847172e-01f, 1.07331187e-01f, 4.07006070e-02f, 6.99988157e-02f, 4.10659276e-02f, -8.51622000e-02f, -6.80823848e-02f,
  4.55555022e-01f, -9.37093273e-02f, 5.70600405e-02f, -7.82242641e-02f, -1.32634833e-01f, -7.88325071e-02f, -2.62548123e-02f, 4.31563705e-02f, 8.96576196e-02f, 1.06968418e-01f,
  2.75514387e-02f, -3.06484867e-02f, 1.97943579e-02f, -3.06326076e-02f, -9.21228621e-03f, 7.31514245e-02f, -1.86354965e-01f, -8.55823606e-02f, 1.46520972e-01f, 1.60702676e-01f,
  1.12080470e-01f, -4.44381274e-02f, 1.89585015e-01f, 1.79217026e-01f, -1.28701665e-02f, 8.14881697e-02f, 1.93463370e-01f, 1.18205085e-01f, 1.45619825e-01f, 1.43703103e-01f,
  7.32310951e-01f, -2.09643885e-01f, -9.56943929e-01f, -4.09548655e-02f, -2.57277757e-01f, -1.72308087e-01f, 8.74281749e-02f, 1.01413935e-01f, -3.08019947e-02f, 6.91683264e-03f,
  1.27701193e-01f, 3.20808113e-01f, -5.50771207e-02f, 9.52918231e-02f, 2.24453688e-01f, -3.02137256e-01f, -3.92935842e-01f, -6.18844181e-02f, 1.97888345e-01f, 4.62460965e-01f,
  4.19896990e-01f, 2.51932710e-01f, 3.56552154e-01f, 7.86898807e-02f, -1.95421368e-01f, -5.42820469e-02f, -5.16532302e-01f, -2.34797865e-01f, -1.21217586e-01f, -3.90100867e-01f,
  -2.54409730e-01f, -3.83983076e-01f, 1.38620315e-02f, 8.46031830e-02f, -1.05448052e-01f, 1.80357043e-02f, 9.79030579e-02f, -2.05726281e-01f, 5.32715134e-02f, -1.35889053e-01f,
  -4.49340530e-02f, 1.06777698e-01f, -2.19501927e-02f, -1.25613704e-01f, 5.49999252e-03f, -7.44472519e-02f, -7.54146725e-02f, -1.62229672e-01f, -1.52323335e-01f, -1.38481140e-01f,
  7.57586444e-03f, -1.20153978e-01f, -2.16598973e-01f, -2.13038430e-01f, -1.57785460e-01f, -1.17854714e-01f, -2.28066489e-01f, -1.76459655e-01f, -2.15875745e-01f, -9.65434611e-02f,
  3.17480490e-02f, -5.92439137e-02f, -1.02453969e-01f, -6.27468973e-02f, 1.68979928e-01f, -6.96596503e-02f, -5.81645183e-02f, 1.57724962e-01f, 2.36208700e-02f, 6.47990927e-02f,
  -4.08165976e-02f, 2.53219623e-02f, 1.09818662e-02f, -1.16019495e-01f, 1.41800251e-02f, -9.37485620e-02f, -8.49403162e-03f, 1.70105807e-02f, 4.27631587e-02f, 9.52481627e-02f,
  2.37894114e-02f, -3.53663564e-02f, -6.00968041e-02f, 2.00181082e-01f, -6.21956140e-02f, -5.75618856e-02f, -1.22030210e-02f, 1.05020791e-01f, 3.61982966e-03f, 9.79143754e-03f,
  3.01621795e-01f, -4.34825867e-02f, -6.75478503e-02f, 7.74929151e-02f, -1.09195702e-01f, -3.54636647e-03f, -3.26338597e-02f, 1.54109737e-02f, -5.44813760e-02f, 1.07138701e-01f,
  -1.23349987e-02f, 2.65379297e-03f, -1.41682610e-01f, -1.51361600e-02f, 6.33519590e-02f, 1.98824089e-02f, 1.90859139e-01f, 1.39062423e-02f, 5.14798537e-02f, -1.00992493e-01f,
  -2.68766601e-02f, 2.17525154e-01f, 2.83853233e-01f, 9.80364159e-02f, -7.47712478e-02f, 1.00310512e-01f, -1.01951128e-02f, -8.09686165e-03f, 4.73794937e-02f, 1.88034564e-01f,
  -6.88811302e-01f, 3.96860451e-01f, 4.79927629e-01f, -4.59325790e-01f, -1.23815581e-01f, 1.25635475e-01f, 2.06408963e-01f, -1.55914634e-01f, -2.51512945e-01f, 3.51636469e-01f,
  2.25887537e-01f, -4.18439895e-01f, -8.08469355e-02f, -3.29405099e-01f, -2.55252868e-01f, 1.91841513e-01f, 2.38289926e-02f, -4.68731940e-01f, -6.56233430e-01f, -4.04499739e-01f,
  -3.40457112e-01f, -5.31299412e-01f, -5.09115100e-01f, -3.52916420e-01f, 4.12628651e-02f, -3.64570439e-01f, 1.05906732e-01f, -8.66878480e-02f, -2.35939547e-02f, 2.49795746e-02f,
  2.95965135e-01f, 1.00061506e-01f, -2.45701954e-01f, -2.18267769e-01f, 5.02245016e-02f, -1.21120006e-01f, -1.16404936e-01f, -8.35204646e-02f, 4.45755869e-02f, 2.16272265e-01f,
  -8.71758349e-03f, -6.51123747e-02f, -1.06306680e-01f, -7.00822473e-02f, 6.41217828e-03f, -3.27053666e-02f, 7.59088770e-02f, -1.40430614e-01f, 2.55470369e-02f, 2.96729475e-01f,
  8.71735066e-02f, 1.10127471e-01f, 1.15293913e-01f, 1.30476967e-01f, 4.80996594e-02f, -9.48026553e-02f, 3.03779840e-01f, 8.18894655e-02f, 6.55328929e-02f, 2.39180755e-02f,
  -1.41132576e-02f, -2.08902806e-02f, -1.49726063e-01f, -4.34989855e-02f, 7.86209702e-02f, 7.46561363e-02f, -5.72965480e-02f, 8.03749859e-02f, -9.70723853e-02f, -1.70884356e-02f,
  2.63917930e-02f, 8.38038325e-02f, -1.30069787e-02f, -5.44199944e-02f, -1.30020948e-02f, -2.90698893e-02f, -5.20084314e-02f, 1.06791511e-01f, 1.20716296e-01f, 8.93226266e-03f,
  -8.06084424e-02f, 4.07929420e-02f, 2.05746498e-02f, 2.52698213e-02f, 1.21036485e-01f, 5.22989444e-02f, 8.65348428e-02f, 2.68250946e-02f, -1.50475457e-01f, 4.56344616e-03f,
  -8.05565715e-02f, -1.74722165e-01f, 2.67361831e-02f, -1.70220241e-01f, 5.99040724e-02f, 1.49571747e-01f, 1.16470531e-01f, -9.58327055e-02f, 5.13169803e-02f, 2.80386787e-02f,
  9.77978259e-02f, -3.66149507e-02f, 2.04872802e-01f, 8.79364237e-02f, -1.00708917e-01f, -2.15152204e-02f, 1.34982437e-01f, -9.69814658e-02f, 5.63193522e-02f, 2.17709109e-01f,
  1.82756811e-01f, -1.58431847e-02f, -4.11692411e-02f, 7.08273053e-02f, -6.88285381e-03f, -2.80885577e-01f, 1.03898659e-01f, 8.27924311e-02f, 1.08785108e-02f, 5.30955158e-02f,
  -4.39841092e-01f, 5.43087423e-01f, -1.85338631e-01f, -1.03364773e-01f, -5.23798466e-02f, -1.17551863e-01f, 1.85516223e-01f, 1.29357159e-01f, 2.33643457e-01f, 3.83366138e-01f,
  1.60197347e-01f, -3.55525464e-01f, -3.34968984e-01f, -3.28231335e-01f, -5.06581068e-01f, 2.42468655e-01f, 5.84739558e-02f, -5.91236413e-01f, -6.79771841e-01f, -3.05276841e-01f,
  -1.56884462e-01f, -3.74597549e-01f, -3.96402359e-01f, -2.28269845e-01f, 2.65285671e-01f, -2.80164242e-01f, 8.09879303e-02f, -2.20150784e-01f, -3.14457893e-01f, 6.33289889e-02f,
  1.16195939e-01f, -2.97340393e-01f, -9.16750580e-02f, -1.17638975e-01f, 1.60860762e-01f, 1.49786413e-01f, 1.41339591e-02f, 5.41236475e-02f, 6.49898350e-02f, 2.09865898e-01f,
  -7.04950690e-02f, -2.39677578e-02f, -1.67636856e-01f, 3.43572646e-02f, -8.43464211e-03f, -6.82894588e-02f, 7.93099329e-02f, -8.17671940e-02f, -1.09535465e-02f, 1.80220425e-01f,
  1.42447501e-01f, -1.18836708e-01f, -1.50682786e-02f, 8.31700116e-02f, -3.73162441e-02f, -3.06995213e-01f, 1.05469950e-01f, -3.02641783e-02f, -2.80090451e-01f, 3.30571026e-01f,
  6.16385229e-02f, 1.91266075e-01f, -4.85997461e-02f, 4.21730764e-02f, 8.58097523e-02f, 7.84370583e-03f, 7.07087591e-02f, 1.57992959e-01f, -1.79179106e-02f, 1.04561329e-01f,
  2.60176599e-01f, 3.62612531e-02f, -5.18360687e-03f, 1.76326390e-02f, -2.37284526e-02f, -1.01294033e-02f, -1.46683557e-02f, 9.14694816e-02f, 4.87999059e-02f, 6.95631206e-02f,
  -2.77544674e-03f, 2.78706476e-02f, -8.52460116e-02f, 6.44252524e-02f, -8.22598860e-03f, 2.98638418e-02f, -9.01406482e-02f, -6.63737301e-03f, -3.04576121e-02f, -8.01663175e-02f,
  8.32480416e-02f, -4.02508616e-01f, 1.69513166e-01f, -3.56965326e-02f, 3.97789031e-02f, 1.79922208e-01f, 3.75819695e-03f, 1.08737200e-01f, 5.48233837e-02f, 1.84804887e-01f,
  -1.34438217e-01f, 5.73504120e-02f, 2.02235822e-02f, 1.67404845e-01f, -6.77033067e-02f, 1.35595705e-02f, 2.13509396e-01f, -7.50613213e-03f, -6.50842488e-02f, 1.99401438e-01f,
  2.86566287e-01f, -9.44414362e-03f, 3.85238347e-03f, 8.54856446e-02f, 1.04320245e-02f, -1.66527331e-01f, -2.29674634e-02f, 7.81879053e-02f, -1.51476964e-01f, 4.89508361e-01f,
  -8.62114951e-02f, -1.63972974e-01f, 5.32421350e-01f, -2.79073179e-01f, -2.82555550e-01f, -4.11127180e-01f, -6.67020023e-01f, -2.80173212e-01f, -1.08367652e-01f, -3.13334726e-02f,
  -1.11360185e-01f, -1.87514484e-01f, 7.78555498e-02f, 5.42624258e-02f, -4.97553963e-03f, 5.46263382e-02f, 2.36294761e-01f, 3.22782218e-01f, -2.01488677e-02f, -3.66554081e-01f,
  -3.37269723e-01f, -5.67868389e-02f, 2.55661428e-01f, 1.70412093e-01f, 7.54386336e-02f, 9.49409977e-02f, 4.15798187e-01f, 1.37390167e-01f, 2.53807098e-01f, 4.27739531e-01f,
  3.69290084e-01f, 7.67065957e-02f, -8.46642926e-02f, -9.90288183e-02f, -1.23168547e-02f, 7.23046586e-02f, -8.90563577e-02f, 7.68457204e-02f, -5.50429225e-02f, 1.13239832e-01f,
  -1.36019617e-01f, -3.42852250e-02f, -2.02584922e-01f, 7.35115409e-02f, -4.85108607e-02f, -1.33224338e-01f, 1.75542787e-01f, 2.17811361e-01f, 1.26788512e-01f, -2.02246346e-02f,
  -3.43844801e-01f, -2.29214922e-01f, -2.76495758e-02f, 1.61825650e-04f, 6.89114854e-02f, -1.05274413e-02f, 1.02688223e-01f, 1.49460196e-01f, 1.91066951e-01f, 2.40923285e-01f,
  -3.51535119e-02f, 5.67648094e-03f, 6.67145699e-02f, 7.99787343e-02f, -6.59207776e-02f, -6.51599700e-03f, 1.08422183e-01f, -7.50804916e-02f, 4.24206294e-02f, -7.19389021e-02f,
  -9.97966677e-02f, 1.86769310e-02f, -3.13190073e-02f, 6.30198279e-03f, 2.80624218e-02f, -6.87119141e-02f, -8.66197497e-02f, 5.10779507e-02f, 1.10763863e-01f, 1.19414084e-01f,
  -9.82652530e-02f, -9.92067605e-02f, 3.91340069e-02f, -2.40710750e-02f, 1.00117169e-01f, 1.74278468e-01f, -9.21674911e-03f, 4.85950708e-02f, -2.45084111e-02f, 5.13747847e-03f,
  -2.79524326e-01f, 1.22460857e-01f, -1.19280674e-01f, -4.34800759e-02f, -5.58250733e-02f, 1.45070672e-01f, -6.06645411e-03f, 1.41801685e-02f, -1.35658577e-01f, -7.70244449e-02f,
  -4.53754961e-02f, -8.04472715e-02f, -1.08385228e-01f, -5.19341044e-02f, -1.66884631e-01f, -5.41480556e-02f, -2.23143861e-01f, -2.14717388e-01f, -1.31727025e-01f, -1.68688163e-01f,
  -1.41801313e-01f, -3.62727374e-01f, -4.28525627e-01f, -3.71510595e-01f, -2.56803781e-01f, -3.67654771e-01f, -9.24601331e-02f, -1.20348319e-01f, -1.25713482e-01f, -3.71482551e-01f,
  3.75639915e-01f, 4.71518666e-01f, -6.16773844e-01f, 3.26968461e-01f, -6.29065782e-02f, -2.44152710e-01f, 4.59561795e-02f, -6.81309626e-02f, 7.91679099e-02f, 1.51546851e-01f,
  1.76511090e-02f, 5.57034388e-02f, 1.26902565e-01f, 5.15987910e-02f, -6.99380459e-03f, 1.44368082e-01f, 2.30639696e-01f, -4.61950041e-02f, -1.99672118e-01f, -2.05474123e-02f,
  3.08159947e-01f, 2.90890455e-01f, 2.21644074e-01f, 4.89917882e-02f, 1.99310660e-01f, 1.73299089e-02f, 5.51675782e-02f, 1.51562721e-01f, -1.30384052e-02f, 3.47517073e-01f,
  -8.41641352e-02f, -1.47602320e-01f, -3.40785682e-01f, 3.06874961e-02f, -2.46934280e-01f, 4.37099561e-02f, -1.39748245e-01f, -1.74404353e-01f, -7.02183321e-02f, 1.23913638e-01f,
  -2.68188957e-02f, 3.80405001e-02f, 1.89967081e-01f, 1.41535595e-01f, 6.78772666e-03f, -2.88679868e-01f, 4.74361032e-02f, -5.12648039e-02f, -2.40758136e-02f, -1.56593889e-01f,
  2.47472599e-01f, -9.25666653e-03f, -3.87392610e-01f, -2.57077456e-01f, -2.83423424e-01f, -1.54454187e-01f, -2.03934744e-01f, -1.40803158e-01f, -3.32388908e-01f, 1.50984481e-01f,
  4.93269134e-03f, -5.78039475e-02f, -1.09672965e-02f, 4.74951267e-02f, 2.80367970e-01f, 8.57588351e-02f, 2.13740900e-01f, 1.38323218e-01f, 2.13540807e-01f, -3.54794180e-03f,
  -7.75827840e-02f, -1.63558841e-01f, -1.01787396e-01f, -1.76025346e-01f, -7.05307126e-02f, 3.27256732e-02f, 1.14831105e-01f, 2.27011681e-01f, -8.44715908e-02f, -1.03605390e-01f,
  7.34271407e-02f, -3.68490536e-03f, -7.54296035e-02f, 6.32440224e-02f, -1.65906087e-01f, -2.21084520e-01f, 3.51671339e-03f, -6.92063197e-02f, 4.73119691e-02f, 6.55298084e-02f,
  2.01315194e-01f, -2.35536009e-01f, -3.47284377e-02f, 9.73214582e-02f, -2.61221663e-04f, -2.18876055e-03f, 8.60487148e-02f, -1.85293108e-01f, 5.91076091e-02f, 9.09292996e-02f,
  -3.56837455e-03f, -8.08887407e-02f, 1.90003023e-01f, 7.95348510e-02f, -8.31704214e-02f, -1.42774135e-01f, 1.57716066e-01f, 8.53319392e-02f, 1.43994689e-01f, -1.60289079e-01f,
  2.24870130e-01f, 4.29214686e-02f, -5.40499091e-02f, -1.46916419e-01f, 8.37185234e-03f, 6.06480092e-02f, -7.69525617e-02f, -9.87066254e-02f, -3.64951551e-01f, 1.13601878e-01f,
  2.09709555e-01f, -5.72676957e-02f, -7.06019998e-01f, 2.13086739e-01f, 3.18984330e-01f, -3.11770022e-01f, -5.37323296e-01f, -3.07659745e-01f, 2.63246089e-01f, -2.03587804e-02f,
  4.27653342e-01f, 4.09375250e-01f, -6.50172383e-02f, -2.75424838e-01f, -5.62493026e-01f, -6.51229739e-01f, -6.41327918e-01f, -6.43998146e-01f, -4.31837201e-01f, 1.92630470e-01f,
  3.94900203e-01f, 2.55273670e-01f, -3.44576426e-02f, -1.02959193e-01f, 4.82937217e-01f, 2.98116833e-01f, 2.44942168e-03f, 2.79428363e-01f, -2.33583935e-02f, 1.02654852e-01f,
  8.35513324e-02f, 2.18111984e-02f, -1.58065513e-01f, 1.95255399e-01f, 1.78881824e-01f, -6.29519895e-02f, -2.09399126e-02f, -1.24233350e-01f, -4.41272371e-02f, -3.19746658e-02f,
  3.19628417e-01f, 2.42705226e-01f, 1.24430150e-01f, 1.19973555e-01f, 2.70008594e-02f, -9.43484828e-02f, -1.90458238e-01f, -3.65394205e-01f, -2.91409582e-01f, -7.79056847e-02f,
  2.22102657e-01f, 1.98071450e-01f, -3.99318188e-01f, -3.23161066e-01f, -2.46047080e-01f, -1.00390352e-02f, -6.91946223e-02f, 8.86030793e-02f, -3.62753391e-01f, 4.89645228e-02f,
  8.68301243e-02f, -6.79030567e-02f, 1.28259752e-02f, 3.56059782e-02f, 1.36978537e-01f, 7.23425895e-02f, 4.02885117e-03f, 5.82964048e-02f, -5.47275618e-02f, -3.17202657e-02f,
  -1.21022739e-01f, -3.73865142e-02f, -1.08167566e-01f, -6.99452087e-02f, -9.04013366e-02f, 5.80664650e-02f, -1.20697273e-02f, -2.86126267e-02f, -1.94343239e-01f, 1.03552518e-02f,
  -4.33245786e-02f, 2.97850315e-02f, 1.24098010e-01f, -3.16810645e-02f, 9.68948528e-02f, -1.82936534e-01f, 2.02169433e-01f, 1.27227485e-01f, -5.67276254e-02f, 1.16457261e-01f,
  4.41723794e-01f, -1.86708912e-01f, 1.09178886e-01f, -7.17523843e-02f, 4.00749743e-02f, 7.04195723e-02f, 1.47379696e-01f, -1.37705788e-01f, 4.69773971e-02f, -1.35495394e-01f,
  -4.81904745e-02f, -1.38184428e-01f, 1.64444875e-02f, -3.17855887e-02f, 5.49792964e-03f, -3.54164019e-02f, -1.33211613e-01f, -1.10069923e-01f, -1.87369004e-01f, 1.94150522e-01f,
  -2.25084629e-02f, -1.32193506e-01f, -9.53974649e-02f, -3.39220941e-01f, 3.50106470e-02f, -1.24008857e-01f, -1.52440324e-01f, 3.52227353e-02f, -4.68086004e-01f, -2.77011454e-01f,
  7.01403711e-03f, 2.10886776e-01f, 1.71107560e-01f, 1.97999254e-01f, -1.82811141e-01f, -9.59664211e-02f, 7.23526776e-02f, 1.96055397e-01f, -6.85649067e-02f, -1.01341642e-01f,
  -3.06407869e-01f, -6.58392683e-02f, 5.10045364e-02f, 1.09608278e-01f, 2.43720114e-02f, 8.33813921e-02f, 2.56134361e-01f, 2.34917253e-01f, 1.13108553e-01f, 8.59836582e-03f,
  4.42797877e-02f, 4.94521968e-02f, 9.12997574e-02f, 1.70727208e-01f, 2.59074390e-01f, 3.21970806e-02f, 2.14179605e-03f, -3.95088345e-02f, -5.63184209e-02f, 4.79373574e-01f,
  -2.10834175e-01f, 5.83296269e-02f, -2.20971957e-01f, -2.10752338e-01f, -1.18746543e-02f, 1.14207312e-01f, 3.27892345e-03f, 7.35881850e-02f, 8.90281051e-02f, 1.13893561e-01f,
  -5.91698438e-02f, 2.67000478e-02f, 1.00139961e-01f, 9.26590785e-02f, 8.57407600e-03f, -2.89168153e-02f, 2.04484716e-01f, 2.38399893e-01f, 9.83046815e-02f, 2.80789770e-02f,
  4.50365879e-02f, -1.36518851e-01f, -9.72234234e-02f, -8.64624903e-02f, 1.21095687e-01f, -1.51597545e-01f, -8.18671286e-02f, 6.35442585e-02f, -1.92641795e-01f, 1.51137650e-01f,
  4.66471538e-02f, -1.76050141e-01f, -6.83247149e-02f, 2.35000402e-01f, 4.30062003e-02f, 4.20871861e-02f, 1.22631013e-01f, 4.98137856e-03f, 4.15957347e-03f, 1.66197971e-01f,
  1.33994028e-01f, -4.63368706e-02f, 2.12949902e-01f, 4.75676358e-02f, -7.59349763e-02f, 3.27648297e-02f, 8.27918015e-03f, -1.14331327e-01f, -2.08675981e-01f, 8.19024444e-02f,
  1.00805730e-01f, 1.07558906e-01f, 1.04474626e-01f, 4.11655307e-01f, -4.38144431e-02f, -1.10894116e-02f, -1.07900389e-02f, -9.91839319e-02f, -4.10876460e-02f, -1.05956383e-01f,
  -3.51643741e-01f, -4.95399803e-01f, -1.40320539e-01f, 9.89045575e-02f, -5.29601872e-02f, -1.38799578e-01f, -1.32000819e-01f, -1.87792167e-01f, -1.10860601e-01f, 1.26948161e-02f,
  -2.09246412e-01f, 5.56308515e-02f, -8.63195434e-02f, 6.58391491e-02f, -8.71315077e-02f, -1.31436676e-01f, -9.09195542e-02f, 4.80926894e-02f, -3.09045333e-02f, -1.31011102e-02f,
  1.22679509e-01f, -2.34604880e-01f, -2.50991613e-01f, -8.72799605e-02f, -9.89051685e-02f, -3.17599535e-01f, -2.22372666e-01f, -1.37784660e-01f, -3.76939923e-01f, -2.60455132e-01f,
  -2.72919565e-01f, -1.02355778e-01f, -3.18732500e-01f, -4.13896680e-01f, -4.64594334e-01f, -4.15595025e-01f, -3.27032000e-01f, -2.57771939e-01f, -1.91843256e-01f, -1.57697752e-01f,
  -9.78690106e-03f, 1.43811509e-01f, 2.23091155e-01f, 3.85232903e-02f, 7.95932114e-02f, -1.30399987e-01f, -2.42510945e-01f, -2.14593545e-01f, -4.24019694e-01f, -4.57017541e-01f,
  -3.61799926e-01f, -4.62611228e-01f, -4.13661212e-01f, -2.91809857e-01f, -2.01086342e-01f, -1.69744059e-01f, -2.08424866e-01f, -2.83134580e-01f, -1.98166296e-01f, -2.25441933e-01f,
  8.23474750e-02f, -2.78238416e-01f, -3.62098366e-02f, -7.98851922e-02f, -6.19220287e-02f, 3.05625238e-02f, 1.91767309e-02f, -1.18474364e-01f, 7.48358853e-03f, -6.34700060e-03f,
  -8.00179318e-02f, -8.90886635e-02f, 3.43034826e-02f, -7.92030171e-02f, -2.01363906e-01f, -5.28325476e-02f, -9.94354784e-02f, -1.04473464e-01f, -1.08439170e-01f, 5.52050099e-02f,
  -3.64124812e-02f, -4.40872163e-02f, 1.51649594e-01f, 9.73170325e-02f, -1.68842368e-03f, -4.57926802e-02f, -3.45023908e-02f, -1.15549371e-01f, -1.06975399e-02f, -2.23822519e-02f,
  -4.04402055e-02f, 1.45335212e-01f, -8.28747228e-02f, -9.91463196e-03f, 2.89983600e-02f, -1.82461459e-02f, 4.66214716e-02f, -1.59291271e-02f, 4.96174283e-02f, -1.22857150e-02f,
  -6.13761358e-02f, -4.54787910e-03f, -3.59002389e-02f, 9.99917556e-03f, 2.03398522e-02f, -3.85755002e-02f, 7.20444974e-03f, 7.31848925e-02f, -5.32829873e-02f, -5.80925085e-02f,
  -7.24534690e-02f, -3.30867842e-02f, -2.86549970e-04f, -1.03024580e-01f, -5.00074141e-02f, -3.76605131e-02f, -2.63430048e-02f, 7.18605518e-02f, -2.43332889e-02f, -2.37035118e-02f,
  2.53244311e-01f, -3.37701365e-02f, 1.72988668e-01f, 2.09010951e-02f, -6.36458024e-02f, -1.95930470e-02f, 4.48292717e-02f, -6.65052533e-02f, 1.13530755e-01f, -7.96451867e-02f,
  -2.58372091e-02f, 5.51987551e-02f, 1.01800196e-01f, -2.63339630e-03f, -6.39597997e-02f, -4.34677899e-02f, -3.46002169e-02f, 9.25273150e-02f, 5.52602522e-02f, -1.00298166e-01f,
  -1.83916222e-02f, 1.85417488e-01f, 3.07463139e-01f, 2.32274234e-01f, -4.40502912e-02f, 2.29446128e-01f, 1.99620113e-01f, 8.02898034e-03f, 2.01732934e-01f, 2.61308402e-01f,
  -5.03239751e-01f, -5.32184616e-02f, 3.90819132e-01f, 1.65476277e-02f, 1.41369760e-01f, -2.89117873e-01f, -4.84331608e-01f, -3.16766411e-01f, 9.78707820e-02f, -5.36003895e-02f,
  -7.57188499e-02f, 9.62585062e-02f, 2.18423590e-01f, 1.12159744e-01f, -1.42231509e-01f, 1.23789996e-01f, 4.11153644e-01f, 1.12563863e-01f, -2.66149074e-01f, -4.18366909e-01f,
  -1.86227122e-03f, -6.86671808e-02f, -6.70953766e-02f, -2.40038745e-02f, 2.64109999e-01f, 1.18210651e-01f, 2.98272192e-01f, 2.29623750e-01f, 3.61706279e-02f, 4.20801103e-01f,
  -1.24190850e-02f, -2.00175554e-01f, -3.19332369e-02f, 1.09140456e-01f, 2.60158271e-01f, -2.09651470e-01f, -1.52630180e-01f, 1.42927274e-01f, 2.61370279e-02f, -4.75870725e-03f,
  1.49989992e-01f, 1.08083948e-01f, 1.81163192e-01f, -1.87738799e-02f, -5.40679246e-02f, -2.48599395e-01f, 5.75701557e-02f, -1.42092869e-01f, -4.11485508e-02f, -1.97521225e-01f,
  9.56946239e-02f, -1.40819758e-01f, -4.26091813e-02f, -1.99007824e-01f, -1.03473723e-01f, -8.20205081e-03f, -1.55330449e-01f, -2.67230093e-01f, -2.72126257e-01f, -2.01039091e-01f,
  9.94049013e-03f, 1.13459781e-01f, 1.12645231e-01f, 5.50919771e-02f, -1.11083068e-01f, 5.36248460e-02f, 1.75475106e-01f, -1.96939800e-02f, 2.10652687e-02f, 4.56604473e-02f,
  6.42933846e-02f, -3.47984917e-02f, -6.60349652e-02f, 1.68815292e-02f, 1.03464946e-02f, -9.99071542e-03f, -4.21564579e-02f, -4.83470298e-02f, 4.74335700e-02f, 5.79605587e-02f,
  1.98102538e-02f, 6.38221204e-02f, 2.22959608e-01f, -8.58421251e-02f, 3.63467149e-02f, 7.82228783e-02f, -7.29755461e-02f, -1.73661754e-01f, -5.13251591e-03f, -1.02639288e-01f,
  -7.29044229e-02f, 1.00214101e-01f, -6.10598139e-02f, -2.43222732e-02f, 7.86855593e-02f, 8.10581967e-02f, 1.68631375e-02f, -1.05402574e-01f, -2.69987360e-02f, -2.14400709e-01f,
  -1.40955478e-01f, 1.27626993e-02f, 1.09698035e-01f, -4.91535105e-02f, -1.48315087e-01f, -3.50716598e-02f, 2.05986369e-02f, 5.87030407e-03f, -7.94782639e-02f, -1.41247381e-02f,
  9.15061384e-02f, -3.50271642e-01f, -2.95194209e-01f, -2.47215450e-01f, -1.04129300e-01f, -2.16868907e-01f, -1.90274209e-01f, -2.89112180e-01f, -3.54793072e-01f, -4.64966267e-01f,
  4.78343695e-01f, -3.11429739e-01f, 2.32347742e-01f, 8.70436355e-02f, 2.55220473e-01f, 3.08135062e-01f, 2.23339811e-01f, 8.90223980e-02f, 5.15153185e-02f, 6.95923939e-02f,
  1.40828982e-01f, 8.06215256e-02f, -1.43827051e-02f, 4.58727702e-02f, 9.44549590e-02f, 1.08611314e-02f, 6.40820526e-03f, 1.89946026e-01f, 1.92967042e-01f, 1.29423007e-01f,
  2.01491788e-02f, -1.59668326e-02f, -3.02277822e-02f, -2.75860410e-02f, -1.77254938e-02f, -3.45617570e-02f, -5.81860095e-02f, -4.99231927e-02f, -5.91444131e-03f, -2.74285406e-01f,
  1.51141152e-01f, -1.06279068e-01f, 1.11975670e-01f, -2.28086300e-02f, -1.43159705e-03f, -1.73665792e-01f, -3.57873663e-02f, -8.69693160e-02f, -9.85055268e-02f, -1.29387692e-01f,
  -2.24345718e-02f, 8.29010010e-02f, 1.04189016e-01f, -5.61711155e-02f, 1.00692689e-01f, 7.58442581e-02f, -2.08726916e-02f, -8.46815482e-02f, -6.87840208e-02f, -4.67109829e-02f,
  3.30875032e-02f, 1.78376213e-01f, 1.89685598e-01f, 9.62078348e-02f, -3.54084633e-02f, 1.19841471e-02f, -3.36148553e-02f, -1.88129209e-02f, 1.02704212e-01f, -9.89248082e-02f,
  8.85284320e-02f, 2.42792338e-01f, 1.23778068e-01f, 1.55087024e-01f, 8.32917243e-02f, -5.32095134e-02f, 1.51863706e-03f, 9.26747732e-03f, 1.55931935e-01f, 1.94204628e-01f,
  1.83473974e-01f, 3.45675126e-02f, -5.39154485e-02f, 2.13917986e-01f, 2.98836619e-01f, 1.20488852e-01f, 1.53491706e-01f, 1.59492381e-02f, 1.77534133e-01f, 8.70938599e-02f,
  1.65131927e-01f, 9.92257670e-02f, -5.88106131e-03f, -6.55386746e-02f, 8.85082036e-02f, 1.95981398e-01f, 1.96611196e-01f, 1.58701330e-01f, 1.26637578e-01f, 1.04554541e-01f,
  -6.40319437e-02f, 1.16923481e-01f, -3.47717889e-02f, -6.32883012e-02f, -8.64564478e-02f, -1.13311626e-01f, -2.99276635e-02f, -1.32691339e-01f, -1.38107657e-01f, -1.96339443e-01f,
  -1.01537295e-01f, 5.02875336e-02f, 6.08367771e-02f, -3.04066547e-04f, 1.44688413e-01f, 9.35586318e-02f, -4.58669141e-02f, 1.96065959e-02f, -2.35230863e-01f, -3.53494361e-02f,
  -5.04103191e-02f, 6.53026626e-02f, 1.94236726e-01f, 1.40948102e-01f, 4.28926423e-02f, 2.01768219e-01f, -2.29448657e-02f, -4.38677855e-02f, 1.76494107e-01f, 3.49160507e-02f,
  8.27309489e-03f, -2.28319749e-01f, -3.45413744e-01f, 1.75079722e-02f, -2.28349015e-01f, -2.52283841e-01f, -3.11276108e-01f, 4.15948555e-02f, 1.63547993e-01f, -2.93924183e-01f,
  -3.09368104e-01f, -1.03736632e-01f, -1.81667656e-02f, -1.96002886e-01f, -2.98138708e-01f, -2.77588964e-01f, -2.58540928e-01f, -2.37744674e-01f, -3.31225961e-01f, -4.20115441e-01f,
  -2.81669766e-01f, -2.08101869e-01f, -1.10009022e-01f, -2.43555307e-02f, 1.60065085e-01f, 4.83690389e-02f, 1.09617643e-01f, -7.11762905e-02f, -1.99828431e-01f, -1.08835958e-01f,
  -1.98294073e-01f, 1.56510770e-01f, 1.65238492e-02f, -8.83311480e-02f, -2.08831113e-02f, -7.92395845e-02f, -3.31131592e-02f, 1.15589917e-01f, -6.69300929e-02f, -4.29414585e-02f,
  -8.36986750e-02f, -1.89151734e-01f, 6.32547727e-03f, -6.47754818e-02f, -2.94142291e-02f, -1.13962397e-01f, -1.34367123e-01f, -5.12394272e-02f, -2.70580426e-02f, -1.16891071e-01f,
  -2.53071904e-01f, -1.86829686e-01f, 5.56684881e-02f, 8.47347826e-02f, 4.59179468e-02f, -1.53877258e-01f, 8.61121267e-02f, 6.56192228e-02f, 1.14357203e-01f, 1.60727888e-01f,
  4.70227152e-02f, 4.91032936e-02f, 1.21556252e-01f, 1.84730664e-01f, 9.78329033e-02f, 1.61258355e-01f, 8.98792744e-02f, 4.68575321e-02f, -3.37856449e-02f, -2.92511657e-02f,
  -8.10553208e-02f, -3.35176438e-02f, 5.95030710e-02f, 1.02891289e-01f, 3.50774787e-02f, 6.30489811e-02f, -2.89044045e-02f, -6.81494772e-02f, -2.16556732e-02f, 1.82576198e-02f,
  -7.26195574e-02f, 3.90671603e-02f, 6.55015483e-02f, -1.55343814e-03f, -5.31615429e-02f, -2.00939681e-02f, -1.06499955e-01f, -7.80447349e-02f, -1.30328491e-01f, -7.90160373e-02f,
  2.40491033e-01f, -1.70590177e-01f, 2.50919424e-02f, 6.65318966e-02f, 4.95166555e-02f, -2.14734534e-03f, -3.11520174e-02f, 1.11753531e-02f, 8.81307647e-02f, -1.80730686e-01f,
  -1.40163705e-01f, -5.62579371e-02f, 5.79482652e-02f, -8.08382779e-03f, -6.64323568e-02f, -5.81803918e-02f, -2.86727786e-01f, -7.86911994e-02f, -5.11047617e-02f, -5.68084531e-02f,
  -1.01840377e-01f, -1.59348667e-01f, -4.23027724e-02f, 1.23573542e-01f, 9.48775038e-02f, -4.20328416e-02f, 4.48790081e-02f, 9.68538821e-02f, 7.55773485e-02f, 9.46513340e-02f,
  6.05456948e-01f, -4.39261973e-01f, 2.37507164e-01f, 2.48121500e-01f, 2.13775933e-01f, 3.62377226e-01f, 1.96926221e-01f, 2.14240640e-01f, 1.16117276e-01f, 8.46356302e-02f,
  -1.16800509e-01f, 2.83591989e-02f, 7.61424601e-02f, -8.23979601e-02f, 6.03118390e-02f, 9.15672481e-02f, 2.13260338e-01f, 2.33025521e-01f, 3.42717409e-01f, 6.22898042e-02f,
  -3.89566123e-02f, 6.19741483e-03f, -3.26898210e-02f, -5.22069223e-02f, -1.75975457e-01f, 6.15722574e-02f, -6.95467740e-02f, -5.48074394e-02f, -2.02159286e-01f, -3.27748626e-01f,
  -3.10912341e-01f, -3.26018855e-02f, 5.62063679e-02f, -2.21213654e-01f, -2.25529477e-01f, -1.61211863e-01f, -4.36334908e-02f, -1.27015039e-01f, -8.86838883e-02f, -1.31078258e-01f,
  -1.24702826e-02f, -8.70831758e-02f, 9.04963911e-03f, -8.38796720e-02f, 1.74472271e-03f, -9.90671292e-02f, -8.86550546e-02f, 1.67766456e-02f, 6.96153119e-02f, -5.27011305e-02f,
  -1.79769248e-01f, 2.73916628e-02f, 1.72023878e-01f, 1.47734448e-01f, 1.41606880e-02f, 1.22289933e-01f, 1.60911549e-02f, -6.58243746e-02f, 1.74470171e-01f, -5.04939742e-02f,
  2.55100112e-02f, -7.82327130e-02f, 1.02314658e-01f, 2.05921546e-01f, 1.56235158e-01f, 1.30611449e-01f, 9.57282186e-02f, -6.59822545e-05f, 1.76632375e-01f, -1.84374284e-02f,
  -4.37042266e-02f, 1.14851691e-01f, 1.98325351e-01f, 2.99588703e-02f, 4.25364589e-03f, -4.72318716e-02f, -4.71670646e-03f, -2.60062702e-02f, -9.71451122e-03f, 7.77322724e-02f,
  1.11347131e-01f, -9.84065756e-02f, -1.60615116e-01f, -1.07941665e-01f, -1.48371235e-01f, -8.54399949e-02f, -3.30724604e-02f, -1.04001828e-01f, -9.17400513e-03f, -7.55513236e-02f,
  -1.81783065e-01f, 3.54058683e-01f, 1.25908509e-01f, 3.55602242e-02f, -7.67347664e-02f, -1.14952058e-01f, 1.20199203e-01f, -1.29114464e-01f, -8.73113647e-02f, 2.17882544e-02f,
  -1.09752193e-02f, -7.66995326e-02f, 6.81373570e-03f, 3.44289583e-03f, 3.80347110e-02f, -2.67049065e-03f, -1.54990628e-01f, 3.91793810e-02f, -4.48730327e-02f, -7.91567639e-02f,
  -1.42444327e-01f, 1.16985977e-01f, 2.38841742e-01f, 1.80461586e-01f, 1.89699188e-01f, 3.28977674e-01f, 6.48669600e-02f, 3.87380496e-02f, 2.12224528e-01f, -9.23854206e-03f,
  -4.41021353e-01f, -6.04909062e-02f, -4.49759245e-01f, -3.58987212e-01f, -9.17228460e-02f, 1.36674821e-01f, 2.40546569e-01f, 1.98389992e-01f, -5.07129878e-02f, -1.20162778e-01f,
  -5.03130257e-02f, -2.62965918e-01f, -4.39554989e-01f, -1.68727309e-01f, -2.05702886e-01f, -2.33430907e-01f, -4.57683504e-01f, -4.46045816e-01f, -2.29349695e-02f, 3.65214258e-01f,
  8.35076347e-02f, -2.41544738e-01f, -2.78671116e-01f, -6.58927113e-02f, -2.16567919e-01f, -2.37727746e-01f, -3.17175776e-01f, -3.14841777e-01f, -1.08020797e-01f, -4.18087393e-01f,
  -1.47388041e-01f, 1.01417266e-01f, 8.34067538e-02f, -1.74709648e-01f, -5.40651120e-02f, 1.07087001e-01f, 9.53587219e-02f, -5.25652319e-02f, 2.85787485e-03f, -1.19424481e-02f,
  -9.47724655e-02f, 2.12892085e-01f, 8.62336308e-02f, 5.45672998e-02f, 1.93553977e-02f, 1.66664600e-01f, -1.32719561e-01f, -7.88076445e-02f, -1.04161561e-01f, 2.56441027e-01f,
  1.18778482e-01f, -1.33428529e-01f, -3.41185868e-01f, 6.75907359e-02f, 1.77633300e-01f, -1.97072253e-01f, 1.11937910e-01f, 2.42149189e-01f, -4.79211323e-02f, -1.63815826e-01f,
  1.59329444e-01f, 5.55834249e-02f, 1.21972740e-01f, -1.10446876e-02f, 4.93167639e-02f, -7.49350116e-02f, -3.12481783e-02f, 5.50782979e-02f, 4.09489125e-02f, -4.64145392e-02f,
  8.95934924e-02f, 6.20036237e-02f, 9.87713113e-02f, 9.59459916e-02f, -6.07417822e-02f, -1.90033749e-01f, 1.77719761e-02f, 7.13811964e-02f, -3.10248248e-02f, -1.12310965e-02f,
  -1.04603089e-01f, -1.49976797e-02f, -5.79264723e-02f, 1.01160280e-01f, -2.61385571e-02f, -5.70556372e-02f, 1.13604464e-01f, 9.72046778e-02f, 4.49488647e-02f, 1.02013551e-01f,
  -4.19361919e-01f, 7.37107992e-02f, -2.64070272e-01f, -1.31518468e-02f, -3.12853344e-02f, 9.19846445e-02f, -1.52137667e-01f, 1.08467683e-01f, -1.21437483e-01f, 1.33690193e-01f,
  1.83950752e-01f, 1.81111097e-02f, 1.52020939e-02f, 6.49998710e-02f, 5.61023951e-02f, 2.90030353e-02f, 2.34004371e-02f, -2.90987611e-01f, -2.34258752e-02f, 9.27342251e-02f,
  -1.10957839e-01f, -2.09679961e-01f, -4.25833315e-01f, -2.61907697e-01f, 2.20191404e-02f, -3.23939085e-01f, -2.75551558e-01f, -3.92693505e-02f, -2.26590589e-01f, -3.09660822e-01f,
  8.32331121e-01f, -3.11419666e-02f, 1.11598603e-01f, 3.40905897e-02f, -5.00316083e-01f, -4.73529637e-01f, -3.55203331e-01f, -3.04000010e-03f, 1.94797739e-02f, -1.14046872e-01f,
  -1.84900016e-01f, -1.93799250e-02f, 2.45016173e-01f, 1.95268139e-01f, 2.73407906e-01f, 6.04734905e-02f, 1.22744344e-01f, 3.63805473e-01f, 3.35734516e-01f, -3.06903757e-02f,
  -1.41496450e-01f, 1.78394958e-01f, 4.03684646e-01f, 2.54194289e-01f, -5.13006113e-02f, -2.93670017e-02f, 7.42214620e-02f, -1.35586247e-01f, -1.93824783e-01f, 3.93276103e-02f,
  -1.93924367e-01f, 4.53549288e-02f, 2.20418438e-01f, 1.07182622e-01f, -5.14803752e-02f, 2.44128332e-01f, 4.95016761e-02f, 1.53829053e-01f, 2.48015635e-02f, 3.76904868e-02f,
  -5.30364588e-02f, 2.08014864e-02f, -6.94977120e-02f, -1.44621462e-01f, -9.04762298e-02f, -8.22462663e-02f, 1.08275764e-01f, -3.26157501e-03f, -9.03400220e-03f, -3.73514518e-02f,
  -5.87181710e-02f, -2.92383254e-01f, -3.35880607e-01f, -2.88191922e-02f, -1.60097703e-02f, 1.41316727e-02f, -1.39076427e-01f, -3.10053620e-02f, -1.18129011e-02f, 6.77242056e-02f,
  1.19652726e-01f, 1.13523632e-01f, -1.24046113e-02f, -8.46908316e-02f, -4.09228131e-02f, -9.86194834e-02f, -2.03732759e-01f, -3.47009227e-02f, -3.14652771e-02f, 6.03147782e-02f,
  -1.37775198e-01f, -9.32817906e-02f, 5.26398085e-02f, -1.84758678e-02f, 2.69861549e-01f, -1.06741749e-02f, -1.46592766e-01f, -7.22996444e-02f, -8.37237462e-02f, 1.00584747e-02f,
  1.95083246e-02f, -1.70934182e-02f, 3.79107073e-02f, -4.64469567e-02f, -1.31955510e-02f, -4.17875871e-02f, 7.54904300e-02f, 6.12065978e-02f, 9.08181816e-03f, -6.93124086e-02f,
  -2.98984408e-01f, 1.30437419e-01f, 1.43228948e-01f, 1.35727495e-01f, -3.20534073e-02f, 9.21677798e-02f, 1.46424502e-01f, 7.69156218e-02f, -1.25330582e-01f, -9.63760391e-02f,
  -5.52987605e-02f, 2.88702250e-01f, 2.75461078e-02f, 1.42600372e-01f, -3.60943154e-02f, -3.70033123e-02f, 8.09803754e-02f, -9.20099486e-03f, 6.58009499e-02f, 9.31729302e-02f,
  3.14975381e-02f, -2.13557458e-03f, 2.00329311e-02f, -3.90568152e-02f, 5.10323681e-02f, 9.50809792e-02f, -2.77271261e-03f, -4.88920789e-03f, 4.01370823e-02f, 1.27348512e-01f,
  -4.38045442e-01f, 4.91921186e-01f, 3.89199108e-01f, -1.22534558e-01f, 3.91076386e-01f, 1.75284073e-01f, 2.40466014e-01f, -1.89770073e-01f, -1.60805210e-01f, 3.23250413e-01f,
  5.20791233e-01f, 1.71113666e-02f, 7.69291148e-02f, -6.66801110e-02f, -1.76369131e-01f, 2.40066797e-01f, 1.37991473e-01f, -3.13931048e-01f, -5.26043177e-01f, -3.33642632e-01f,
  2.74180621e-02f, -1.82523489e-01f, -4.82222289e-01f, -3.15397531e-01f, 1.52657315e-01f, -1.50186568e-01f, 2.96282172e-01f, 1.58335090e-01f, 2.03274697e-01f, 2.78706163e-01f,
  2.94940263e-01f, 3.13712597e-01f, -2.05345094e-01f, 4.90926467e-02f, 2.96735823e-01f, -2.15600088e-01f, -1.03885181e-01f, -6.85116872e-02f, -2.94015300e-03f, -4.84651886e-02f,
  1.69707045e-01f, 6.32347912e-02f, 1.99169487e-01f, -7.72234574e-02f, -8.28883275e-02f, -1.51136488e-01f, -2.06988588e-01f, -3.98212135e-01f, -2.36748666e-01f, -3.55455875e-02f,
  1.91115871e-01f, 7.75049254e-02f, 1.88906834e-01f, -1.26438662e-01f, -1.68485820e-01f, -2.17733502e-01f, -7.95346797e-02f, -3.42514634e-01f, -3.20894182e-01f, -2.83856511e-01f,
  -4.86285351e-02f, 1.10148050e-01f, 1.17466666e-01f, -1.75232980e-02f, -8.93142894e-02f, -1.78058017e-02f, 1.62783880e-02f, 5.49076758e-02f, -7.41940737e-02f, -1.90387622e-01f,
  8.77640545e-02f, -2.69855876e-02f, -3.60875465e-02f, 7.23777786e-02f, -7.29712471e-02f, -2.62974054e-02f, -2.43649306e-03f, -7.88392350e-02f, 5.46710938e-02f, -1.39932528e-01f,
  -1.41186133e-01f, 2.45068781e-02f, -5.16793132e-02f, -1.99580982e-01f, 7.53488243e-02f, 2.40471400e-02f, -1.44501580e-02f, -1.06164604e-01f, -1.66298915e-02f, 1.12329632e-01f,
  -3.40379775e-01f, 1.31797463e-01f, -4.75689881e-02f, -2.97648134e-03f, 2.05032513e-01f, 3.84099036e-02f, 1.74309120e-01f, 9.33116972e-02f, 1.60847113e-01f, -1.38334990e-01f,
  -6.56709424e-04f, 6.71366975e-02f, 1.90791741e-01f, -1.00411974e-01f, -2.61539429e-01f, 2.36360971e-02f, 1.06701717e-01f, 5.29097989e-02f, -2.03551561e-01f, -2.37963088e-02f,
  -8.59396681e-02f, -3.11379373e-01f, -2.31564745e-01f, -1.23317793e-01f, -1.06875971e-01f, -2.48939261e-01f, -2.34028935e-01f, -2.64919013e-01f, -3.27251852e-01f, -4.49893057e-01f,
  7.43369639e-01f, 2.81519890e-01f, 5.41840494e-01f, 3.18176568e-01f, 2.82899082e-01f, 1.69558585e-01f, 2.16365486e-01f, -9.19031911e-03f, 5.51435389e-02f, 1.83636487e-01f,
  1.11443736e-01f, -9.38182101e-02f, -6.01933934e-02f, 4.03108783e-02f, -8.03104602e-03f, -1.65555552e-02f, 4.23279852e-02f, 2.65194774e-01f, 1.59876227e-01f, 1.99538231e-01f,
  5.26762344e-02f, 9.14181322e-02f, 1.81299806e-01f, 4.23734821e-02f, 3.10855992e-02f, 8.57467800e-02f, 1.23481981e-01f, 2.19018444e-01f, 5.62860742e-02f, 1.49577325e-02f,
  1.77952230e-01f, 2.66518980e-01f, -1.63370505e-01f, -2.29055122e-01f, 1.11104008e-02f, -9.00221989e-02f, -6.23438656e-02f, -1.18673772e-01f, -3.82902250e-02f, -6.94739893e-02f,
  -1.26515776e-01f, -3.11507750e-02f, -3.94807234e-02f, 1.61533654e-02f, -1.71711799e-02f, -2.32334696e-02f, -1.19216628e-01f, 1.50999287e-02f, -3.71912532e-02f, -7.20282197e-02f,
  -1.73850462e-01f, 2.71262582e-02f, 7.86145255e-02f, -6.86209947e-02f, 4.38764170e-02f, -4.78426106e-02f, 9.41387787e-02f, 1.74090508e-02f, 6.94832653e-02f, 8.42294991e-02f,
  -4.85187247e-02f, 2.04491124e-01f, 2.88356781e-01f, 2.91527286e-02f, -1.01746321e-02f, 2.80902181e-02f, -5.84707186e-02f, 7.62013048e-02f, 1.36784717e-01f, -5.59838526e-02f,
  -1.85766518e-01f, 1.47054434e-01f, 1.01271190e-01f, 1.43019650e-02f, 2.24493463e-02f, 1.36265112e-02f, -4.07320298e-02f, -8.69187713e-02f, 2.70083477e-03f, -1.58070512e-02f,
  3.38263996e-02f, -7.13799521e-02f, -1.75619587e-01f, -1.84262067e-01f, -1.37736931e-01f, -1.17369276e-02f, -9.22528747e-03f, -6.03176169e-02f, -1.25088036e-01f, -4.34586592e-02f,
  -4.38510805e-01f, 1.32488199e-02f, 1.61452033e-02f, -1.52397126e-01f, 7.11728558e-02f, -1.26340613e-01f, 1.01833656e-01f, -7.16039985e-02f, -1.28875017e-01f, -7.97332823e-02f,
  -1.48015469e-02f, -6.69583231e-02f, -7.68603608e-02f, -1.05524041e-01f, -5.71538694e-03f, -1.40258625e-01f, -4.65397052e-02f, -8.75314623e-02f, -1.17515586e-01f, -5.55787273e-02f,
  -4.96520549e-02f, -9.13466737e-02f, 3.78022017e-03f, -4.04401384e-02f, -1.07380025e-01f, -8.68231058e-02f, 1.88715523e-03f, -7.49584660e-02f, -7.20566288e-02f, -1.26268059e-01f,
  7.89536536e-01f, -1.09401956e-01f, 2.46469483e-01f, 1.96041375e-01f, 1.76709563e-01f, 3.09720784e-01f, 3.20427179e-01f, 1.48143560e-01f, 1.54727593e-01f, -7.39075290e-03f,
  -3.08243245e-01f, -5.02158821e-01f, -3.08546096e-01f, -3.37139398e-01f, -5.92202768e-02f, 1.04131088e-01f, 2.79154718e-01f, 1.90649346e-01f, 3.02907258e-01f, 1.96555316e-01f,
  -1.09317340e-01f, 2.03485996e-01f, 2.78553426e-01f, 8.88564363e-02f, -1.65584683e-01f, -8.29679817e-02f, 2.73851901e-02f, 1.44948915e-01f, -8.69170949e-02f, -1.29817158e-01f,
  -1.62287772e-01f, -3.04409210e-02f, -1.97249558e-02f, -1.56293675e-01f, -8.63630250e-02f, 1.11956060e-01f, -5.44242142e-03f, 7.65099302e-02f, -5.21963648e-03f, 1.44490272e-01f,
  -2.39540497e-03f, -3.23843509e-02f, -7.56476298e-02f, -6.28015101e-02f, 9.69947278e-02f, -1.94497276e-02f, -1.18350692e-01f, -1.40755966e-01f, -1.08407237e-01f, -6.17205352e-02f,
  -3.36154461e-01f, 2.77482793e-02f, -1.60210766e-02f, -4.44771536e-02f, -1.45305574e-01f, -1.41267747e-01f, -2.83187125e-02f, -2.18421426e-02f, 5.01351058e-02f, -4.97795753e-02f,
  6.34096116e-02f, 7.32037127e-02f, -1.96741909e-01f, -1.51634425e-01f, -9.91122946e-02f, -2.77701654e-02f, -1.16138950e-01f, -1.37105659e-01f, -1.32783636e-01f, -1.64055564e-02f,
  -6.79419711e-02f, -2.54403889e-01f, -1.09684750e-01f, 5.58898086e-03f, -1.92681223e-01f, -4.92495485e-02f, 4.41675968e-02f, -1.07148528e-01f, -1.82425708e-01f, -1.31626666e-01f,
  -1.14860415e-01f, 1.91325590e-03f, -1.83736328e-02f, -9.84386429e-02f, -1.96664244e-01f, -5.78708500e-02f, -5.57887554e-02f, -1.97127402e-01f, 1.20312795e-01f, 1.81549594e-01f,
  -3.41783255e-01f, -4.56046641e-01f, 1.18641127e-02f, -2.38415953e-02f, 1.28919706e-01f, -1.52830267e-02f, -3.18820357e-01f, -5.10493927e-02f, 3.31981778e-02f, 3.41733359e-02f,
  1.75016781e-03f, 9.63410214e-02f, -7.68537074e-02f, -3.26423161e-02f, 8.98264498e-02f, 1.36673167e-01f, -6.69031516e-02f, -8.26193541e-02f, -1.10096917e-01f, -8.03543031e-02f,
  -5.04897609e-02f, 1.25239342e-01f, 1.44151896e-01f, 4.53217626e-02f, 3.67896482e-02f, 9.40304175e-02f, 3.88458408e-02f, 5.33707812e-02f, 2.06382170e-01f, 2.45412454e-01f,
  -5.27962863e-01f, 3.07948291e-01f, 3.25289965e-01f, -4.96497661e-01f, 2.13164732e-01f, 4.87002015e-01f, 7.90835083e-01f, 2.11350396e-01f, -3.90876859e-01f, 1.73291579e-01f,
  2.40423694e-01f, -3.93605441e-01f, -3.59235853e-01f, -2.46875674e-01f, 1.86931401e-01f, 4.52924103e-01f, 2.99903989e-01f, -8.75550658e-02f, -1.76517934e-01f, 7.94321895e-02f,
  2.38263197e-02f, -5.24486266e-02f, -2.65060604e-01f, -1.89059034e-01f, -3.88219029e-01f, -2.96587110e-01f, 1.21423140e-01f, 1.33605570e-01f, 3.50554615e-01f, -1.38723373e-01f,
  -4.34806105e-03f, 3.02583903e-01f, 3.39514464e-02f, -1.58790529e-01f, 4.02454250e-02f, -1.33783251e-01f, -5.51245920e-03f, -1.79500937e-01f, -8.33850354e-02f, -1.07067108e-01f,
  -8.81254300e-02f, -1.43595889e-01f, -8.43493044e-02f, -4.00208123e-02f, 3.04018371e-02f, 4.01553623e-02f, -4.11245488e-02f, -1.05690565e-02f, -5.80879487e-02f, 3.63435708e-02f,
  8.33372474e-02f, 2.40950197e-01f, 2.16922432e-01f, 1.74002841e-01f, 6.07347451e-02f, -9.46149230e-02f, 9.25783738e-02f, -6.39831945e-02f, 2.50467002e-01f, -3.53128284e-01f,
  -3.69029790e-02f, -1.54883852e-02f, 3.44343558e-02f, -6.42801374e-02f, 6.08756067e-03f, -4.09083329e-02f, -9.77672115e-02f, 8.51928890e-02f, 6.56223157e-03f, -5.61166629e-02f,
  -2.31666467e-03f, 1.14332020e-01f, 2.10985579e-02f, -3.66539769e-02f, -1.31656885e-01f, 6.62933961e-02f, 1.43546343e-01f, -4.89328541e-02f, 1.74412632e-03f, 1.06883887e-02f,
  2.68891500e-03f, 1.21397570e-01f, -5.31483330e-02f, -5.74721657e-02f, 1.54936165e-01f, -7.96611086e-02f, -7.87195340e-02f, -1.99758392e-02f, -9.86218601e-02f, 1.49953231e-01f,
  -3.01155418e-01f, 6.08624935e-01f, -1.98608935e-01f, -9.57239270e-02f, -3.72173600e-02f, -5.11847213e-02f, -2.25517489e-02f, 2.39986293e-02f, 4.44318317e-02f, 5.05926386e-02f,
  2.52882868e-01f, -1.20450653e-01f, 3.17035951e-02f, 5.93509600e-02f, -1.05339669e-01f, -8.47762004e-02f, 1.07049458e-01f, -1.36921287e-01f, 1.87388100e-02f, 4.84150983e-02f,
  9.19158980e-02f, 7.44855925e-02f, -1.60176560e-01f, -7.61765912e-02f, -1.56515883e-03f, -1.92158699e-01f, -7.69874528e-02f, -5.58099113e-02f, 1.79913163e-01f, -1.69792488e-01f,
  -2.74403214e-01f, -2.25788251e-01f, -1.56824276e-01f, 4.46432263e-01f, 5.69420815e-01f, 3.65610898e-01f, 3.54395397e-02f, 1.26057133e-01f, 3.54849517e-01f, 3.42761189e-01f,
  2.93580621e-01f, 4.57282811e-01f, 2.99621284e-01f, 1.39057964e-01f, -5.45632541e-02f, 6.97734281e-02f, 2.43024021e-01f, 4.98395180e-03f, 4.12043743e-03f, 3.80577087e-01f,
  4.98263776e-01f, 2.36104399e-01f, -7.51164109e-02f, -2.65422165e-02f, 2.28232652e-01f, 3.74369264e-01f, 2.05809325e-01f, 2.68375486e-01f, 9.65146646e-02f, 2.12394610e-01f,
  -1.90703750e-01f, -3.04772466e-01f, 9.27836820e-02f, 6.66651651e-02f, -1.00865953e-01f, -2.06425756e-01f, -8.30265880e-02f, -4.22950350e-02f, -7.49687990e-03f, 5.24054803e-02f,
  -4.77699861e-02f, -7.80951753e-02f, -4.01349319e-03f, -4.59898673e-02f, -1.11269288e-01f, -1.36067584e-01f, -1.75754264e-01f, -1.42902583e-01f, -1.09372683e-01f, -4.51200157e-02f,
  1.30625209e-02f, 2.02759400e-01f, -4.80337925e-02f, -6.94271848e-02f, -1.11807555e-01f, 3.10855825e-03f, -1.49418369e-01f, -1.48291841e-01f, -1.00197576e-01f, 4.08139303e-02f,
  -9.38187838e-02f, -1.63312256e-01f, -1.32346367e-02f, -9.70810838e-03f, 6.73224404e-02f, -1.17480569e-02f, 1.09614231e-01f, 7.21713677e-02f, -6.41680695e-03f, 1.94032509e-02f,
  2.46832203e-02f, 1.05130151e-01f, -1.03963487e-01f, 9.94355083e-02f, 1.00171894e-01f, -7.62251168e-02f, -1.19064756e-01f, -1.60955772e-01f, -1.41232893e-01f, -2.15457857e-01f,
  2.37854663e-02f, -1.19949020e-01f, -1.15178764e-01f, -1.36462152e-01f, 4.19343896e-02f, 4.13156413e-02f, 8.90216827e-02f, 4.67464216e-02f, 5.24837673e-02f, -1.08573049e-01f,
  2.99407125e-01f, 1.17589021e-03f, 5.04844710e-02f, -2.29851931e-01f, -3.19651738e-02f, -1.44110233e-01f, 3.82712595e-02f, -6.49792627e-02f, -1.52696192e-01f, -8.02259594e-02f,
  -7.76391104e-02f, -1.94268450e-01f, -7.01402724e-02f, 1.64961070e-02f, 3.29458527e-02f, 9.63003188e-02f, 5.64937480e-02f, 1.41672641e-01f, -6.88370913e-02f, -7.13479146e-02f,
  -4.39209538e-03f, 2.32968524e-01f, -1.78364646e-02f, 6.80094808e-02f, 1.52805761e-01f, 1.14527501e-01f, -1.13984540e-01f, 5.45016043e-02f, -2.15106755e-02f, 1.86996460e-01f,
  2.04886012e-02f, -5.16307652e-01f, -2.60305077e-01f, -3.72106105e-01f, -5.07541746e-02f, 3.01835388e-01f, 2.65054941e-01f, 1.22994177e-01f, -7.27367401e-02f, -1.14080742e-01f,
  9.53619927e-02f, 2.81631202e-01f, -2.40774993e-02f, 1.15265690e-01f, 2.86432445e-01f, -2.34846130e-01f, -2.72338808e-01f, 1.95561692e-01f, 5.86564720e-01f, 5.71160316e-01f,
  9.22166407e-02f, -1.65569291e-01f, -4.46036272e-03f, -1.47731915e-01f, -3.66593689e-01f, 2.18402576e-02f, -4.36352700e-01f, -3.33406031e-01f, -9.77996290e-02f, -6.04339302e-01f,
  2.95842409e-01f, -3.95102084e-01f, 9.27220508e-02f, -1.08484209e-01f, -1.90289304e-01f, -1.11560628e-01f, 7.07115829e-02f, -1.65482268e-01f, -7.24525303e-02f, -1.42256573e-01f,
  -1.84789434e-01f, 3.38805281e-02f, 1.81514565e-02f, 1.40952449e-02f, 2.99848840e-02f, 4.94433418e-02f, -1.83940411e-01f, -4.63333726e-02f, -4.52973619e-02f, 2.87613384e-02f,
  -1.15535349e-01f, -1.08528495e-01f, -4.51467149e-02f, -7.12880911e-03f, -7.36000091e-02f, 1.54154534e-02f, -5.43194227e-02f, -3.03421225e-02f, -2.23813895e-02f, -1.36779934e-01f,
  2.23945193e-02f, 5.92158586e-02f, 1.94474645e-02f, 1.55349746e-02f, 6.05976619e-02f, -9.13240537e-02f, 2.56186239e-02f, 6.06508553e-02f, 4.04122844e-03f, -2.89121307e-02f,
  6.54904172e-02f, 1.93062481e-02f, 4.54999022e-02f, -1.69664308e-01f, -8.62641111e-02f, -2.32660417e-02f, -3.80852930e-02f, -6.46984428e-02f, 1.33464318e-02f, -3.39495763e-02f,
  9.79590714e-02f, -3.55342291e-02f, -1.20744213e-01f, 7.37746358e-02f, -1.23040885e-01f, -5.00959679e-02f, -5.57146370e-02f, 8.48050341e-02f, 2.73599625e-02f, -1.00906804e-01f,
  1.28076613e-01f, 7.81673715e-02f, 2.19359601e-04f, 2.69794092e-02f, -2.37279423e-02f, -7.02821240e-02f, -5.07337227e-02f, 3.42339613e-02f, -1.17533527e-01f, 1.39937058e-01f,
  6.35783672e-02f, 1.36570230e-01f, -2.29937267e-02f, -7.06143975e-02f, 1.30772516e-01f, -4.23676632e-02f, -7.93745220e-02f, 5.63208535e-02f, -1.14722207e-01f, 1.60579663e-02f,
  -1.80433035e-01f, 8.97074193e-02f, 1.99870408e-01f, 6.52150884e-02f, 5.16818501e-02f, 2.60515571e-01f, 1.22108720e-01f, 1.75986990e-01f, 2.34193295e-01f, 6.06605969e-02f,
  7.98359036e-01f, 1.05370320e-01f, 9.64676365e-02f, 1.14085637e-01f, -1.88631371e-01f, -1.43177807e-01f, -3.32547605e-01f, -1.88356400e-01f, 1.31717026e-01f, 2.11153716e-01f,
  1.80612758e-01f, 2.48156741e-01f, 1.91616267e-01f, 1.16864100e-01f, 5.88965565e-02f, -1.49479099e-02f, 7.42779896e-02f, 1.89845160e-01f, 1.59142703e-01f, 1.32579178e-01f,
  1.82917714e-01f, 4.11474220e-02f, 1.80688947e-01f, 1.86640173e-01f, 2.10638389e-01f, 1.34045392e-01f, 2.28740464e-04f, 1.43641487e-01f, 1.30275533e-01f, 3.06318700e-01f,
  6.93114817e-01f, 3.46387416e-01f, -9.32490602e-02f, 5.54527193e-02f, 1.14735663e-01f, 6.08655363e-02f, -1.88592114e-02f, 7.19144717e-02f, -6.79492578e-02f, 1.54104317e-02f,
  8.99994280e-03f, -3.61420587e-02f, -3.47365849e-02f, -4.19381000e-02f, -3.86744179e-03f, 5.27255284e-03f, 1.36666801e-02f, -3.36324759e-02f, -9.12815407e-02f, 1.50543928e-01f,
  7.74335908e-03f, -9.12018493e-02f, -9.65680629e-02f, -2.21840024e-01f, -4.92744297e-02f, -4.77640368e-02f, -6.75613508e-02f, 7.87761509e-02f, -2.17418522e-02f, 9.89083946e-02f,
  1.84916109e-01f, 1.27481297e-01f, 1.10626161e-01f, 1.03564881e-01f, 1.90204218e-01f, 8.17538947e-02f, 4.49416265e-02f, -2.08687708e-02f, -4.31504957e-02f, 5.91852963e-02f,
  -1.32310949e-02f, 6.59659952e-02f, -5.40828146e-02f, 4.97469567e-02f, 5.32291271e-02f, 6.59534037e-02f, 3.07124387e-02f, -1.55608065e-03f, 2.76954062e-02f, 1.20886024e-02f,
  1.29350657e-02f, -1.97545905e-02f, 1.03583574e-01f, 8.42503831e-02f, -1.39871035e-02f, 2.09313314e-02f, -1.95724145e-02f, -6.09966740e-02f, 3.72085311e-02f, -3.01643126e-02f,
  -3.97930682e-01f, -2.85377741e-01f, 2.03793779e-01f, 2.59527378e-02f, -7.75539577e-02f, 2.28244998e-02f, -2.52689943e-02f, -1.51172252e-02f, 1.71999559e-02f, 4.68492992e-02f,
  -1.63492739e-01f, -7.80586107e-03f, -7.35250115e-02f, -1.10765100e-01f, -1.01249963e-01f, -3.25928628e-02f, 9.64119136e-02f, -1.80334039e-02f, -8.71421769e-02f, 5.72870113e-02f,
  -1.01544611e-01f, -1.72647089e-01f, -2.01889724e-01f, -2.32853174e-01f, -6.19229935e-02f, -3.04228570e-02f, -1.32840440e-01f, -5.13131842e-02f, -9.50512514e-02f, -2.29847237e-01f,
  1.07759321e+00f, -1.35993496e-01f, -1.53917134e-01f, 5.06673157e-01f, -5.01657724e-01f, -3.39013040e-01f, -2.43669793e-01f, 1.73232779e-01f, 1.45189911e-01f, 9.77902263e-02f,
  -4.73765850e-01f, -3.74147505e-01f, 2.01423001e-02f, -1.34212434e-01f, 5.02892919e-02f, 2.94188350e-01f, 3.39933395e-01f, 1.47151649e-01f, -2.41592079e-01f, -4.36357796e-01f,
  -2.57115901e-01f, 1.13191664e-01f, 2.90810913e-01f, 4.15114835e-02f, 2.37797177e-03f, -7.72374198e-02f, 8.26429427e-02f, -5.65168969e-02f, -1.88910857e-01f, 1.45477712e-01f,
  2.32339073e-02f, -6.40929267e-02f, -7.21960813e-02f, -1.71035349e-01f, -1.17294401e-01f, 2.28801727e-01f, 1.09183483e-01f, 2.59410348e-02f, -1.07016541e-01f, 1.60988018e-01f,
  -2.95227230e-01f, -1.83467194e-01f, -8.98143500e-02f, -1.16320722e-01f, -9.30314139e-02f, -3.11530381e-03f, 9.20844078e-02f, 7.77502805e-02f, 1.70624554e-01f, -1.86826885e-01f,
  -3.22544903e-01f, -3.29691023e-01f, -1.07399896e-01f, -6.04265966e-02f, -4.82706055e-02f, -5.93279414e-02f, -2.38668859e-01f, -1.88308969e-01f, 2.75598038e-02f, 3.24542522e-01f,
  8.38494897e-02f, 1.60166044e-02f, 3.23873200e-02f, 3.71381710e-03f, 1.99268619e-03f, -1.04896188e-01f, -1.56099461e-02f, -7.59528801e-02f, -4.82631996e-02f, 2.59449240e-02f,
  -4.29410227e-02f, 1.24133281e-01f, -2.45806556e-02f, 4.93888780e-02f, -1.47019336e-02f, 5.81300892e-02f, -9.48570445e-02f, 8.27753544e-03f, 1.82711855e-02f, 1.17008947e-01f,
  -7.84716159e-02f, -2.74397060e-02f, -2.13186089e-02f, 6.60221502e-02f, 5.66565022e-02f, 7.87566230e-02f, 1.56937823e-01f, -7.69230127e-02f, 2.53868327e-02f, -4.90751024e-03f,
  2.79459149e-01f, -1.44240171e-01f, 3.87811869e-01f, -5.65924868e-02f, -2.92412322e-02f, -2.33347088e-01f, 4.79953550e-02f, -4.86258827e-02f, -9.50601622e-02f, -1.65921152e-02f,
  -2.05235586e-01f, -7.11591020e-02f, 3.00358925e-02f, -9.01815519e-02f, -5.67902252e-02f, -7.34704360e-02f, -8.61453116e-02f, -1.22170717e-01f, -7.46272579e-02f, 3.58849321e-03f,
  1.48645505e-01f, 2.13113353e-02f, 2.12116867e-01f, 6.16068244e-02f, -7.34050199e-02f, 2.36399118e-02f, 8.13716725e-02f, -7.76615962e-02f, 1.34950221e-01f, 4.20255154e-01f,
  -6.74346626e-01f, -3.22959155e-01f, -1.60802230e-01f, -1.38626784e-01f, 1.47345975e-01f, 1.65590495e-01f, 3.10953315e-02f, 8.19555521e-02f, 1.44002825e-01f, -2.57474273e-01f,
  -1.14644982e-01f, 1.73575073e-01f, 6.11629300e-02f, 2.28086293e-01f, 1.55136198e-01f, 5.75876907e-02f, 1.70996591e-01f, 7.47141838e-02f, 1.83719680e-01f, 7.92945623e-02f,
  2.72220314e-01f, 3.34323011e-02f, -1.66829288e-01f, 1.38404876e-01f, -2.11663708e-01f, 1.15971379e-01f, -5.57446890e-02f, -2.47568786e-01f, -9.13777500e-02f, -2.21576393e-01f,
  -5.78070283e-01f, -3.69100749e-01f, 2.45171323e-01f, 4.35188562e-02f, -6.89577535e-02f, -1.63315669e-01f, -1.82875365e-01f, -7.64987245e-02f, 2.89560133e-03f, -1.54336050e-01f,
  -7.15888888e-02f, -1.25990942e-01f, -3.03961933e-02f, -1.37318643e-02f, -9.58590880e-02f, -1.97884031e-02f, 5.11833504e-02f, -2.13572122e-02f, -3.27347312e-03f, -1.13031596e-01f,
  1.43818602e-01f, -1.97506413e-01f, -4.04575795e-01f, 6.24826029e-02f, -4.91579529e-03f, 7.30060264e-02f, -2.08060026e-01f, -1.67589247e-01f, -2.29707524e-01f, -5.94909430e-01f,
  1.32854477e-01f, 6.96853846e-02f, 7.42528290e-02f, -7.28572085e-02f, 1.57859445e-01f, -1.16116432e-02f, 4.00203653e-02f, 9.67131257e-02f, 8.98261443e-02f, -1.23470522e-01f,
  1.47162393e-01f, -1.89246424e-02f, -6.36079684e-02f, -1.61362469e-01f, 8.37584287e-02f, -6.84354231e-02f, 8.05580709e-03f, 2.53339503e-02f, -1.88009441e-02f, -2.15271600e-02f,
  3.10200769e-02f, 2.58257389e-02f, -1.68945417e-02f, 8.42159390e-02f, -9.03784782e-02f, -2.06037126e-02f, -8.75425339e-02f, 3.19940187e-02f, -3.94444428e-02f, -1.42144009e-01f,
  -7.30987117e-02f, 2.95747280e-01f, -3.01296383e-01f, 1.20374754e-01f, 4.91018826e-03f, 1.68478101e-01f, -3.47759128e-02f, 4.14708517e-02f, -1.02914713e-01f, 3.79970185e-02f,
  -1.55796513e-01f, -1.20674551e-01f, -6.01833612e-02f, 1.00795090e-01f, 1.67657174e-02f, -6.81503043e-02f, -1.12692956e-02f, -7.07852766e-02f, 1.04250260e-01f, -6.17874414e-02f,
  1.30324483e-01f, -1.75551847e-01f, -4.99831140e-01f, -1.04172863e-01f, -1.43485025e-01f, -1.41219929e-01f, -2.95103371e-01f, -2.20590353e-01f, -2.00076133e-01f, -6.22973263e-01f,
  8.08126688e-01f, 5.44278800e-01f, 2.46317267e-01f, -4.05398309e-02f, 8.69513825e-02f, 3.26952130e-01f, 4.22050714e-01f, 2.31458753e-01f, 3.57318781e-02f, 1.90869510e-01f,
  2.18844861e-01f, 1.19697273e-01f, 7.27421865e-02f, 5.06192185e-02f, 7.75831714e-02f, -1.55965030e-01f, -2.45028049e-01f, -1.17158100e-01f, -2.54619326e-02f, 5.71809523e-02f,
  -1.77140996e-01f, -6.29416853e-02f, -2.97798123e-03f, -5.19828387e-02f, -1.41925886e-01f, -2.01975539e-01f, -1.47796810e-01f, -8.68267864e-02f, 3.87657457e-03f, -4.18491453e-01f,
  -4.30726334e-02f, 2.85063118e-01f, -1.52888298e-01f, 1.05119310e-02f, 1.99880213e-01f, 1.35300159e-01f, 1.32112041e-01f, 6.98818862e-02f, 1.06098659e-01f, -1.62457321e-02f,
  -4.97420281e-02f, -1.64459813e-02f, 1.35282993e-01f, 1.64145902e-01f, 1.89959973e-01f, 3.30959074e-02f, 1.37764826e-01f, 8.64652172e-02f, -1.15805427e-02f, 1.28739059e-01f,
  -4.77322899e-02f, 7.96527565e-02f, 1.05204649e-01f, 3.37050147e-02f, 1.33688942e-01f, 7.30676576e-02f, 8.40879381e-02f, 5.73737808e-02f, 1.89248279e-01f, 5.46207689e-02f,
  1.20035283e-01f, 1.02612615e-01f, 7.99087957e-02f, 7.71610141e-02f, 1.40284896e-01f, -5.54322638e-02f, -5.42938188e-02f, -8.07592571e-02f, 1.08102240e-01f, 5.29496101e-05f,
  -1.75084114e-01f, -4.99279052e-02f, 7.04759210e-02f, -1.44885048e-01f, -1.72818422e-01f, -4.24108878e-02f, 3.11994441e-02f, 1.14798909e-02f, -6.65443614e-02f, -7.86737576e-02f,
  -8.43849964e-03f, -4.41505201e-02f, -1.19873427e-01f, 9.78284329e-03f, 2.87413877e-03f, 5.38665801e-02f, 2.12836340e-02f, 1.28810540e-01f, 5.82002290e-02f, -3.58876064e-02f,
  -6.88558221e-02f, 2.15700597e-01f, -3.26576233e-01f, -1.60624728e-01f, -1.30345702e-01f, -9.92036238e-03f, -5.92331402e-02f, -1.24068819e-01f, -1.68816417e-01f, -1.20078303e-01f,
  -4.38334327e-03f, 3.66317742e-02f, 7.77777359e-02f, -2.21514478e-02f, -1.34441495e-01f, -1.15301676e-01f, 1.43224858e-02f, 4.34524789e-02f, -1.07233986e-01f, -5.21393828e-02f,
  -1.90738384e-02f, 3.05714775e-02f, 2.33041923e-02f, -7.67876431e-02f, 1.84503775e-02f, -1.07422732e-01f, -1.91389211e-02f, -2.25661993e-02f, 1.55116941e-04f, -1.27975002e-01f,
  7.23570362e-02f, -3.73157144e-01f, 5.42816371e-02f, 2.64201730e-01f, 4.68303800e-01f, -8.15627351e-02f, -6.50676787e-01f, -5.18388987e-01f, 1.85033962e-01f, -4.89654653e-02f,
  -8.38329121e-02f, 2.15415016e-01f, 1.24775954e-01f, -1.39458507e-01f, -8.06084692e-01f, -6.72962248e-01f, -3.87070239e-01f, -2.84381866e-01f, -2.22125828e-01f, -2.34175771e-01f,
  1.32144734e-01f, 1.70861304e-01f, -1.91116259e-01f, -1.66359559e-01f, 3.68132293e-01f, 2.62064397e-01f, 2.50491112e-01f, 2.62720734e-01f, -6.15950339e-02f, 3.72261465e-01f,
  4.25583482e-01f, -2.30762601e-01f, -1.10859834e-01f, -6.51696771e-02f, 1.87646344e-01f, -1.21845119e-01f, -1.15803845e-01f, 3.97607610e-02f, -1.65806472e-01f, -7.11032674e-02f,
  2.17418000e-01f, -2.23573506e-01f, 9.16769803e-02f, -1.36836348e-02f, -1.67860866e-01f, -2.18809426e-01f, -1.09541044e-01f, -3.91832918e-01f, -1.38270229e-01f, 4.18505222e-02f,
  2.62460914e-02f, 5.07319085e-02f, -5.99685162e-02f, -1.85530961e-01f, -1.49267867e-01f, 2.92609572e-01f, -1.14801694e-02f, -5.86409830e-02f, -2.61566013e-01f, 3.46905850e-02f,
  -4.02417146e-02f, 7.26126358e-02f, 4.34290711e-03f, -3.45492712e-03f, 3.29422727e-02f, 6.62330445e-03f, 6.01095296e-02f, -2.64091287e-02f, 3.67522729e-03f, 6.34536594e-02f,
  -1.30006224e-01f, -9.96338129e-02f, 1.07994787e-01f, -8.05941150e-02f, -5.85697517e-02f, 5.45385443e-02f, 4.71314117e-02f, -1.70901984e-01f, -8.17942806e-03f, -5.84847070e-02f,
  -1.01470295e-03f, 1.27755120e-01f, 2.21202418e-01f, -9.35902819e-02f, -2.36815050e-01f, -1.09780967e-01f, 5.96594512e-02f, -1.00069633e-03f, 5.14377765e-02f, 2.19876505e-02f,
  4.14590806e-01f, -3.07178378e-01f, 2.87964076e-01f, -2.63832152e-01f, 9.12501737e-02f, 6.10341541e-02f, 1.71701118e-01f, -1.22031279e-01f, 1.71307266e-01f, 6.58775195e-02f,
  -1.48973808e-01f, -1.30526185e-01f, 5.60787469e-02f, 1.19719043e-01f, -2.99340412e-02f, -4.86427620e-02f, -1.25436097e-01f, 2.55643338e-01f, -1.36207148e-01f, 2.26966232e-01f,
  -1.88766152e-01f, -2.96804041e-01f, 8.37185681e-02f, 7.91161209e-02f, 7.88565800e-02f, 2.21194878e-01f, 2.90813953e-01f, 1.55917272e-01f, -2.26896644e-01f, -5.69485202e-02f,
  6.34767115e-01f, -5.96621394e-01f, -6.26067221e-01f, -3.56385261e-01f, -2.42955178e-01f, 1.49005339e-01f, 1.23876259e-01f, 3.67668383e-02f, 1.03131849e-02f, -2.16846064e-01f,
  -1.39718160e-01f, 4.63808291e-02f, -1.29903719e-01f, 5.98317236e-02f, 6.25446662e-02f, -2.53574193e-01f, -2.98199087e-01f, -2.60184123e-03f, 3.84272516e-01f, 2.36929327e-01f,
  4.22063470e-02f, -7.46177658e-02f, 9.49045941e-02f, -2.04518065e-01f, -3.73616546e-01f, -2.38701522e-01f, -4.87233043e-01f, -2.31473282e-01f, -3.03383708e-01f, -5.25782883e-01f,
  -4.30824757e-01f, -5.77977635e-02f, 2.00135633e-01f, 1.47006407e-01f, -5.17692156e-02f, 8.99025574e-02f, 2.71507725e-02f, -9.46340561e-02f, 4.80132662e-02f, -4.74913828e-02f,
  -3.64645012e-02f, -9.02690664e-02f, -9.07607377e-02f, -7.78233260e-02f, 5.53142466e-02f, 8.09451714e-02f, 6.39217123e-02f, 8.55425000e-02f, -3.29116322e-02f, -1.17223382e-01f,
  -1.24200024e-01f, 1.47831753e-01f, 6.82554096e-02f, 1.17150486e-01f, 1.03981361e-01f, 1.52756482e-01f, 9.50262770e-02f, 9.80227515e-02f, 1.15850873e-01f, 6.26753345e-02f,
  5.23123853e-02f, 2.72699222e-02f, 1.17411964e-01f, 1.49435893e-01f, 2.02415392e-01f, 1.05586983e-01f, 8.53723567e-03f, 1.36041164e-01f, 1.99437618e-01f, -1.47141693e-02f,
  8.88542365e-03f, -2.11494807e-02f, 1.05500504e-01f, -3.24483216e-02f, -1.22732334e-01f, -1.25182673e-01f, -3.16396840e-02f, 1.26299197e-02f, -8.07570368e-02f, -3.21550854e-02f,
  1.25846714e-01f, -1.82055756e-02f, -1.07750773e-01f, -1.06687896e-01f, -9.93818324e-03f, 1.01561677e-02f, -1.25163153e-01f, 1.35115245e-02f, -8.69938284e-02f, -5.24166860e-02f,
  -1.71359330e-01f, 1.80959687e-01f, 5.64321652e-02f, -4.40319162e-03f, -6.02768846e-02f, -1.38065934e-01f, -2.43063997e-02f, -6.65519834e-02f, -4.99883965e-02f, -6.46075457e-02f,
  1.08835762e-02f, 1.51691008e-02f, -7.86099061e-02f, 2.92271022e-02f, 1.24849036e-01f, 1.21984631e-01f, 2.38293067e-01f, 7.95807093e-02f, 2.00525858e-02f, -1.35856360e-01f,
  -1.08177356e-01f, 2.52083361e-01f, 2.28502482e-01f, 1.12730198e-01f, 1.30547673e-01f, 2.48749137e-01f, 9.08511132e-02f, 1.29074037e-01f, 1.83087558e-01f, 2.18347639e-01f,
  -7.89801359e-01f, -4.69104871e-02f, -1.80788815e-01f, -6.16660535e-01f, -3.28469902e-01f, -1.47414103e-01f, 6.95237517e-02f, -1.01593383e-01f, -3.96421224e-01f, -2.26702869e-01f,
  -5.94326258e-02f, 8.97301808e-02f, -1.32494256e-01f, 1.83601439e-01f, 3.19652796e-01f, -1.22358449e-01f, -2.64164716e-01f, 4.10779789e-02f, 4.16882873e-01f, 3.59414309e-01f,
  1.93821266e-01f, 6.84551373e-02f, 1.87575091e-02f, 1.96494013e-02f, -2.66562700e-01f, 1.57535896e-02f, -2.22662792e-01f, -1.92331955e-01f, 2.16849595e-02f, -3.34717989e-01f,
  2.83673823e-01f, -3.19849133e-01f, 7.78257847e-02f, 2.77445652e-02f, 5.39486930e-02f, -7.95357004e-02f, 1.26004880e-02f, -1.20843098e-01f, -6.61325175e-03f, -8.43254030e-02f,
  -1.42293692e-01f, 6.16906304e-03f, -4.04630639e-02f, 1.71892066e-02f, -2.31058151e-03f, 5.30041829e-02f, -3.63233350e-02f, -3.84913534e-02f, -2.51244903e-02f, 3.75465155e-02f,
  3.01810186e-02f, -1.36398911e-01f, -1.61720753e-01f, 8.50999430e-02f, 9.55536589e-02f, 7.80772194e-02f, 1.08653523e-01f, 7.54068419e-02f, -2.27032192e-02f, -7.46698603e-02f,
  2.57322472e-02f, 1.07471216e-02f, 1.14946105e-02f, 7.88009986e-02f, 1.19815037e-01f, -7.87381753e-02f, -7.60722160e-02f, 1.49685051e-02f, 2.97704097e-02f, 1.24796070e-01f,
  -5.93967550e-02f, 6.76221102e-02f, 1.31637573e-01f, 1.30012324e-02f, -6.46506622e-02f, -9.95284319e-02f, -2.79207416e-02f, 6.02298565e-02f, -1.46421352e-02f, -9.24263820e-02f,
  -7.04219565e-02f, -7.17218146e-02f, -1.06978573e-01f, 6.51249290e-02f, -1.06056772e-01f, 7.49946199e-03f, -6.47025034e-02f, 5.86712770e-02f, 9.98589396e-03f, -1.26558602e-01f,
  1.65667936e-01f, 1.64837530e-03f, -1.83084086e-01f, -5.80380969e-02f, -1.28639683e-01f, -5.85714867e-03f, -7.63377473e-02f, 3.32975457e-03f, -2.03635424e-01f, 4.38455157e-02f,
  -1.33320298e-02f, 4.60981205e-02f, 1.95971411e-02f, 1.63118448e-02f, 1.54513353e-02f, 5.45425946e-03f, 6.10061362e-02f, -8.64054188e-02f, -2.46574152e-02f, -3.44731100e-02f,
  2.33749803e-02f, -4.23733108e-02f, 5.49405180e-02f, 3.12274676e-02f, 5.88614633e-03f, -3.18855681e-02f, 2.31706902e-01f, 9.16674733e-02f, -1.03566507e-02f, 8.14072713e-02f,
  -7.70126522e-01f, 2.69644707e-01f, -1.73176706e-01f, -3.17715019e-01f, -5.28206378e-02f, 1.88638255e-01f, 4.33434904e-01f, 1.12668872e-01f, -2.04088867e-01f, 1.15635820e-01f,
  -1.94043983e-02f, 5.46027496e-02f, 1.03096187e-01f, 6.78399801e-02f, 2.46853128e-01f, 3.28042030e-01f, 1.57173753e-01f, -3.11313639e-03f, -8.00672770e-02f, 4.51810062e-02f,
  2.45260194e-01f, -1.84778407e-01f, -2.78536946e-01f, -6.12767786e-02f, 5.86489290e-02f, 8.14014450e-02f, 2.56015663e-03f, -1.40367538e-01f, 4.85303663e-02f, 1.21404253e-01f,
  2.98996180e-01f, -4.15746897e-01f, 3.59061472e-02f, -1.48485348e-01f, -1.08561888e-01f, -2.06851251e-02f, -1.01787888e-01f, -4.62052748e-02f, 4.45737131e-02f, 9.41448659e-02f,
  -2.96971458e-03f, -1.42203301e-01f, 4.26586829e-02f, 6.54687583e-02f, -1.20155230e-01f, -7.65338838e-02f, -1.14795424e-01f, -2.11228989e-03f, 1.00459075e-02f, 1.35992512e-01f,
  7.70607069e-02f, -1.40188616e-02f, -5.72724752e-02f, 5.14558963e-02f, 2.04863288e-02f, 6.13627173e-02f, 4.14385982e-02f, -6.03684187e-02f, -1.63288449e-03f, -4.13515568e-02f,
  6.64584041e-02f, -3.21545918e-03f, -7.32797310e-02f, -1.23702645e-01f, 3.93580161e-02f, -2.73775347e-02f, 5.13340831e-02f, -8.88048485e-03f, -5.54021560e-02f, 4.89549190e-02f,
  -3.31677385e-02f, -8.49651918e-02f, -1.32170673e-02f, 3.68014500e-02f, -9.49381217e-02f, -7.33072087e-02f, 3.99103053e-02f, 2.79393494e-02f, -9.46641937e-02f, -7.58053688e-03f,
  -5.31255268e-02f, 3.25662605e-02f, -1.98203713e-01f, 1.25072658e-01f, -5.50014153e-02f, -3.15300822e-02f, -9.77949873e-02f, 5.56647889e-02f, -6.63403198e-02f, 4.28114180e-03f,
  2.57581383e-01f, -5.57627715e-02f, 3.90066206e-02f, -5.30416444e-02f, -1.56746864e-01f, -2.24368036e-01f, -1.59851834e-01f, -1.63470536e-01f, -2.27983259e-02f, -1.01455331e-01f,
  -9.48392302e-02f, -1.14330374e-01f, 4.61759456e-02f, 6.95771948e-02f, -7.13053974e-04f, -1.39269575e-01f, -1.11299008e-01f, -3.87817025e-02f, 3.88221703e-02f, 8.92802849e-02f,
  7.11637959e-02f, 3.40357888e-03f, 9.07589030e-03f, -6.47561764e-03f, 6.93010390e-02f, 2.24986356e-02f, 1.00281134e-01f, 4.13935818e-02f, 4.39546965e-02f, 1.12686254e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.97353971e-01f, 1.36127442e-01f, 1.35314651e-02f, 5.63079655e-01f, 9.26651239e-01f, 6.99500665e-02f, 4.25306797e-01f, 5.84065437e-01f, 3.77181530e-01f, 3.48313123e-01f,
  7.19842076e-01f, 1.64864510e-01f, 4.35904920e-01f, 6.22840047e-01f, 6.10033631e-01f, 5.87028861e-01f, 6.45799994e-01f, 1.22005954e-01f, 2.54932284e-01f, 3.87670159e-01f,
  3.53833020e-01f, 4.01728123e-01f, 4.99300398e-02f, 5.63422680e-01f, -1.73733961e-02f, 6.57701612e-01f, 3.97469431e-01f, 4.88640636e-01f, 5.76581240e-01f, 4.65771049e-01f,
  2.85865694e-01f, 7.01807916e-01f, 4.21521902e-01f, 8.39666665e-01f, 5.09667099e-01f, 2.25844592e-01f, 5.00896811e-01f, 2.91847974e-01f, 3.93313557e-01f, 5.32558441e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.80487561e-01f, 9.89944953e-03f, 9.10765305e-02f, 9.86161008e-02f, -2.26447120e-01f, -2.88878977e-01f, -1.04828641e-01f, 4.03365605e-02f, -3.31674546e-01f, -1.68899924e-01f,
  -2.92765498e-01f, -3.13413650e-01f, -1.27195776e-01f, -4.84768813e-03f, -8.23312253e-02f, 3.91860073e-03f, 2.92544644e-02f, -1.18761167e-01f, 3.42837721e-02f, -4.05011214e-02f,
  -2.46438906e-01f, -1.89024672e-01f, 1.54648691e-01f, 2.13127404e-01f, 1.19483946e-02f, 2.77125705e-02f, -6.36638701e-02f, -4.14711237e-01f, 2.21101105e-01f, -3.73580068e-01f,
  -1.29419208e-01f, 2.85975039e-01f, -3.01005095e-01f, 5.58286607e-01f, -1.04490206e-01f, -6.38124868e-02f, 4.98359561e-01f, -3.09919029e-01f, -3.00581694e-01f, -3.81321937e-01f,
  -5.40305912e-01f, 3.46904486e-01f, 1.95017289e-02f, -1.79939583e-01f, -5.40009201e-01f, -3.61928999e-01f, 8.51060376e-02f, -4.06680942e-01f, 5.42502820e-01f, -9.04049352e-02f,
  -9.32023883e-01f, 3.79490331e-02f, -6.82333529e-01f, -2.71142393e-01f, -5.97676337e-01f, 4.24199253e-01f, -2.16082945e-01f, -8.64562213e-01f, 4.39238280e-01f, 2.70822406e-01f,
  -1.89166516e-01f, 5.28715372e-01f, 3.63864988e-01f, -4.50068861e-01f, -1.00829504e-01f, 4.25645374e-02f, 9.61944386e-02f, -6.50300784e-03f, -3.23069274e-01f, 1.15135141e-01f,
  5.58366301e-03f, -1.38501838e-01f, -3.36644113e-01f, -4.80346940e-02f, -9.63747725e-02f, 3.37161481e-01f, -2.43589133e-01f, -1.05858527e-01f, 1.12679504e-01f, -4.55643594e-01f,
  2.43808273e-02f, 2.61814862e-01f, -1.86165929e-01f, -4.22927644e-03f, -4.49341893e-01f, 4.44272131e-01f, 1.04969829e-01f, -1.17222384e-01f, -3.42419505e-01f, -3.98219824e-01f,
  8.58149603e-02f, -3.26803446e-01f, -9.91633356e-01f, -3.44628036e-01f, 1.51552930e-01f, 9.35426056e-01f, -3.71510923e-01f, 2.05950886e-01f, -1.18998981e+00f, -4.19482291e-01f,
  5.66696525e-01f, -6.45472407e-01f, -9.87873673e-01f, -6.62799537e-01f, -1.95491359e-01f, -8.49193931e-01f, -1.88434154e-01f, 5.26130676e-01f, -7.26937294e-01f, 1.86011285e-01f,
  2.73869544e-01f, 3.83232683e-01f, -7.56146252e-01f, 2.12526292e-01f, -4.06875908e-02f, 3.97824258e-01f, -1.73856542e-01f, -3.82592738e-01f, 1.35601074e-01f, 3.94360065e-01f,
  3.79904658e-01f, 2.56022155e-01f, -7.92524517e-02f, 1.19738236e-01f, -2.21390903e-01f, 5.73468208e-01f, -2.87753772e-02f, -2.78751165e-01f, 1.88151672e-01f, -5.35174448e-04f,
  -1.58095062e-01f, 1.32934809e-01f, 1.26743615e-01f, 6.33587316e-02f, 3.82347822e-01f, 5.47850877e-02f, -5.63882105e-03f, 1.64887477e-02f, -1.42103434e-01f, 1.46520481e-01f,
  1.54393129e-02f, -2.97712147e-01f, 4.39846843e-01f, 8.39462131e-02f, -4.29731794e-02f, 3.62278163e-01f, 3.03059798e-02f, 3.23506534e-01f, -4.56955820e-01f, -2.64899164e-01f,
  1.63880587e-01f, -3.16217154e-01f, -4.62466657e-01f, -2.18375027e-01f, -4.17333931e-01f, -6.63172603e-02f, 7.50497520e-01f, -1.04185700e-01f, -3.45870346e-01f, 9.22597766e-01f,
  -2.37633049e-01f, 1.93964928e-01f, -4.43767518e-01f, -6.94788620e-03f, -4.48722035e-01f, -4.90428239e-01f, -4.48870957e-01f, 6.78158939e-01f, -3.50638062e-01f, -6.62183285e-01f,
  3.22251357e-02f, -5.39943993e-01f, 5.53870976e-01f, -1.32646933e-01f, -3.66183341e-01f, 1.79826356e-02f, -5.27494669e-01f, 3.19518715e-01f, -3.97160321e-01f, -2.92070061e-01f,
  -7.28738829e-02f, -6.66504726e-02f, -5.05259514e-01f, -4.19444852e-02f, -2.84249276e-01f, -5.05629852e-02f, 6.52454376e-01f, 6.44396022e-02f, -4.57038954e-02f, -4.76463512e-02f,
  1.66855797e-01f, -1.97257668e-01f, -1.32572921e-02f, -9.09057725e-03f, -5.42020015e-02f, 4.11390848e-02f, 6.48986995e-02f, -2.32587934e-01f, -8.82148892e-02f, -3.08652334e-02f,
  -3.21939550e-02f, -1.27347708e-01f, 4.65603098e-02f, -8.07990581e-02f, 1.56544566e-01f, 9.60645154e-02f, -1.10296905e-01f, -4.83483002e-02f, -1.46098867e-01f, 1.24605866e-02f,
  -6.61225021e-02f, 1.85757533e-01f, 5.78878880e-01f, 1.85657352e-01f, 7.04676434e-02f, -8.62402841e-02f, -8.82168591e-01f, 2.25130424e-01f, -4.29994702e-01f, -3.48840922e-01f,
  5.76355219e-01f, 7.64887273e-01f, -4.14645970e-01f, -6.24242902e-01f, -4.35429722e-01f, 9.61759984e-02f, 2.45958596e-01f, -1.54167101e-01f, -3.20870519e-01f, 4.52394992e-01f,
  1.60343587e-01f, 1.96991101e-01f, -5.52135110e-01f, -6.92827225e-01f, -6.31342292e-01f, 1.06159508e-01f, -1.10609099e-01f, -2.32587710e-01f, -2.68149227e-01f, -5.66443205e-02f,
  4.10582215e-01f, -3.83808583e-01f, 3.71800154e-01f, -2.45446086e-01f, -3.88312817e-01f, 1.00750542e+00f, -5.74437559e-01f, 8.15345570e-02f, -1.10394657e-01f, -6.86901212e-01f,
  2.82874107e-01f, -5.06148517e-01f, -1.12935531e+00f, -5.62952459e-02f, 3.24817240e-01f, 4.79433447e-01f, -1.49643466e-01f, -9.79185998e-02f, 2.53312849e-02f, -2.83569753e-01f,
  2.24128887e-01f, -1.53561264e-01f, -1.25949040e-01f, -2.37186342e-01f, 1.14985123e-01f, 1.06395550e-01f, 1.60421446e-01f, -7.35605657e-02f, 6.67263288e-03f, -1.72225133e-01f,
  -7.97177106e-02f, 4.75685269e-01f, 1.38361976e-01f, 2.57289857e-01f, 1.68914586e-01f, 2.61152327e-01f, -2.28236578e-02f, -8.97692442e-02f, 9.15565267e-02f, 4.54172492e-01f,
  -1.91589966e-02f, 3.69729459e-01f, 1.52217612e-01f, -1.34201512e-01f, -3.93301457e-01f, -4.33110982e-01f, 1.32650644e-01f, -1.46843418e-01f, -1.03935618e-02f, -4.08186391e-02f,
  -6.34560347e-01f, 3.41770835e-02f, -8.81108165e-01f, 6.29673243e-01f, 5.28658330e-01f, 3.58654737e-01f, -6.05221331e-01f, 1.71328858e-01f, -2.17417523e-01f, 1.76574305e-01f,
  4.26941454e-01f, -8.06418285e-02f, 4.47519869e-01f, 1.36228194e-02f, -9.10177231e-02f, -1.63370326e-01f, 2.84841985e-01f, -4.77459043e-01f, -3.21530491e-01f, -6.63834751e-01f,
  1.34294823e-01f, -8.23300540e-01f, -3.21504354e-01f, -1.41441198e-02f, -1.59620624e-02f, 1.16922587e-01f, 5.10413766e-01f, -6.48377895e-01f, -5.60915411e-01f, -3.79658699e-01f,
  2.93087453e-01f, 3.16330850e-01f, 9.53788310e-02f, 2.56313115e-01f, -2.55748387e-02f, 1.07295029e-02f, 2.81413555e-01f, 2.38060385e-01f, 7.24407565e-03f, 1.12062402e-01f,
  1.24434605e-01f, 1.51290074e-01f, -2.60610223e-01f, 1.27390549e-01f, -2.48625696e-01f, 4.17892605e-01f, 3.66002291e-01f, -1.65168680e-02f, -9.43274982e-03f, 1.18328482e-01f,
  -3.80578548e-01f, -3.40549164e-02f, 1.78613681e-02f, 6.15776069e-02f, 9.84347999e-01f, -3.15746069e-02f, 8.33998322e-02f, 1.65545121e-01f, -9.78983045e-01f, -5.56546986e-01f,
  -2.08630636e-01f, -6.33125067e-01f, -4.86236274e-01f, -7.86724567e-01f, 8.84259701e-01f, -2.59022027e-01f, 5.45852542e-01f, -3.33058953e-01f, 5.86116433e-01f, -4.87922162e-01f,
  6.67019725e-01f, 2.42165834e-01f, -6.08029962e-01f, 7.19364807e-02f, -4.67742532e-01f, -3.02074999e-01f, 1.29932344e-01f, -3.56914669e-01f, -1.72552451e-01f, 3.46920490e-02f,
  -8.01150620e-01f, -3.30489516e-01f, 2.11813018e-01f, -2.64050603e-01f, 2.43261501e-01f, -3.45190406e-01f, -3.10265601e-01f, 6.81491435e-01f, -2.11279899e-01f, 4.52723205e-02f,
  -1.98616058e-01f, 8.83632824e-02f, -1.37690991e-01f, 8.14252943e-02f, -7.11140782e-02f, 6.09135851e-02f, 1.08882710e-01f, -3.47765610e-02f, 2.28128165e-01f, -2.49310121e-01f,
  -1.40398741e-01f, 1.20900109e-01f, 8.67493600e-02f, -1.62903279e-01f, 1.29230350e-01f, -4.07154784e-02f, 1.92644507e-01f, -2.14753702e-01f, -1.69732437e-01f, 3.43776047e-01f,
  -1.69772089e-01f, -3.26162726e-01f, 5.16125798e-01f, -3.42400372e-01f, 9.21014026e-02f, -2.48333499e-01f, 2.97264159e-01f, -2.09568545e-01f, -2.10557640e-01f, -1.40722051e-01f,
  2.37957239e-01f, -3.17021430e-01f, -8.27038586e-01f, 2.12167595e-02f, -3.92167233e-02f, -4.81239855e-01f, 4.18370038e-01f, -6.97553337e-01f, -1.51941553e-01f, -2.57398397e-01f,
  -4.73412722e-01f, -4.51997280e-01f, -3.54232401e-01f, 5.46686530e-01f, 2.50495493e-01f, -6.43128395e-01f, 7.05862820e-01f, -1.38840467e-01f, -9.25466642e-02f, -4.18005794e-01f,
  -2.36831278e-01f, -5.28646648e-01f, -2.64104038e-01f, 4.96376038e-01f, -4.05112118e-01f, 8.35135877e-02f, 6.58034906e-02f, -7.58545280e-01f, -3.76314014e-01f, -2.71431625e-01f,
  4.43012267e-01f, 7.99100697e-01f, -9.71015811e-01f, -1.13317996e-01f, -7.62269020e-01f, -3.71737301e-01f, -2.00354591e-01f, -2.71264225e-01f, -2.40524322e-01f, 5.83355315e-02f,
  -2.76101291e-01f, -2.83091906e-02f, -2.30391547e-01f, -9.76497978e-02f, -6.92162141e-02f, -1.36070877e-01f, -3.40608925e-01f, -1.22297369e-01f, -2.81312108e-01f, -9.98604968e-02f,
  8.13351125e-02f, 5.87581433e-02f, -1.11549124e-02f, -1.84539631e-01f, 5.98531915e-03f, 2.32574642e-01f, -1.79481357e-01f, -1.60596985e-03f, 1.33582994e-01f, 1.11518353e-01f,
  -4.51355800e-03f, 1.83566764e-01f, 1.59933746e-01f, -3.03932995e-01f, 2.29374543e-01f, 1.90857843e-01f, 3.30297709e-01f, 4.73204672e-01f, -2.98914194e-01f, -3.02397460e-01f,
  -2.45684180e-02f, -2.24276453e-01f, 7.51574278e-01f, 1.74061105e-01f, -4.13041592e-01f, -3.75310838e-01f, -1.69690907e-01f, -7.16798365e-01f, 2.08703473e-01f, -3.89543027e-01f,
  3.71149778e-01f, -3.45300138e-01f, 3.42768013e-01f, -2.40531638e-01f, -2.19455495e-01f, 9.89415646e-02f, -3.39825898e-01f, -2.80700266e-01f, 2.89174944e-01f, -2.76287764e-01f,
  -7.23317862e-01f, 1.26466945e-01f, 2.45238885e-01f, -3.98393929e-01f, -5.65714300e-01f, -1.97655395e-01f, 5.79079866e-01f, -2.39198595e-01f, -3.00417513e-01f, -6.05608046e-01f,
  -1.85681462e-01f, 4.31747496e-01f, 1.07636623e-01f, -2.40792498e-01f, -1.41106904e-01f, -2.94895887e-01f, 9.54778343e-02f, 1.70619920e-01f, 4.78147380e-02f, -2.43305475e-01f,
  3.74430120e-02f, -2.64558569e-02f, -9.75824445e-02f, -9.38188732e-02f, 1.14185929e-01f, 1.89093366e-01f, 2.37945780e-01f, -3.64042461e-01f, 1.04702368e-01f, 2.10733782e-03f,
  3.20145786e-01f, -2.11084872e-01f, 5.12549341e-01f, 9.71588865e-02f, -2.85680920e-01f, -2.52097279e-01f, -2.68918544e-01f, -2.42947429e-01f, -3.89723152e-01f, 3.34393203e-01f,
  9.41013992e-01f, -2.66103119e-01f, 1.00682519e-01f, -3.50866497e-01f, -3.35483402e-01f, -1.65999189e-01f, 7.06408441e-01f, -2.29802012e-01f, -2.16271192e-01f, -7.39026308e-01f,
  -4.73353356e-01f, -3.06338817e-01f, -4.52987462e-01f, -2.87196487e-01f, -9.50771198e-02f, -4.92549539e-01f, -1.48149386e-01f, 2.75771767e-01f, -2.37543657e-01f, 4.04128879e-01f,
  -5.88093549e-02f, -2.78305441e-01f, -2.91711509e-01f, 1.71018858e-02f, 7.10409760e-01f, -4.40173373e-02f, 1.32704630e-01f, 4.98514295e-01f, -3.70360523e-01f, 2.96179682e-01f,
  -3.80564541e-01f, -4.25228089e-01f, 3.88491064e-01f, 1.25838548e-01f, -4.17424381e-01f, -2.40011051e-01f, 8.59188363e-02f, -2.10775852e-01f, 1.01305231e-01f, -7.11992383e-02f,
  -2.97776461e-02f, 1.90209806e-01f, 2.64331158e-02f, 1.23027153e-01f, 2.76739568e-01f, -4.38685119e-02f, 2.30658278e-01f, 9.72611979e-02f, -3.68970573e-01f, -2.56791323e-01f,
  -3.56295437e-01f, -1.55141145e-01f, 1.41748235e-01f, -3.83657247e-01f, -5.78637838e-01f, -2.13357925e-01f, -1.17010325e-01f, -2.90944785e-01f, -2.13398337e-02f, -6.81883469e-02f,
  -3.13750416e-01f, -5.67975044e-01f, -9.50312018e-02f, -9.70873386e-02f, 1.48879066e-01f, -1.44078061e-01f, -5.61954379e-01f, -8.23762000e-01f, -1.13317274e-01f, 5.92905700e-01f,
  -8.92097592e-01f, 2.15392992e-01f, 1.75509341e-02f, -4.34514284e-01f, -3.42142917e-02f, 6.97588921e-02f, 2.47270450e-01f, 9.34691548e-01f, -1.39142722e-01f, -5.54524362e-01f,
  4.93174464e-01f, 1.78842813e-01f, -6.10067248e-01f, -7.68168032e-01f, -3.34230661e-01f, 9.88881737e-02f, 5.20003676e-01f, -1.11442871e-01f, -3.74706775e-01f, -5.53218246e-01f,
  2.82615215e-01f, -6.16665483e-01f, 5.42580843e-01f, -5.49064159e-01f, -3.27601105e-01f, -6.92965984e-01f, 1.04996014e+00f, -1.97726801e-01f, -5.68241894e-01f, -3.72198254e-01f,
  1.69173405e-01f, -1.09477259e-01f, 4.66865450e-02f, -4.99991924e-02f, 1.56608939e-01f, 1.51123345e-01f, 4.03815433e-02f, -1.65319666e-02f, 2.05701664e-01f, 1.08068444e-01f,
  -6.43022638e-03f, 9.67886448e-02f, 3.27526897e-01f, 3.31406265e-01f, -1.50193051e-02f, -3.40284348e-01f, -2.49025509e-01f, -1.63307667e-01f, -2.83882558e-01f, 2.23411053e-01f,
  3.04179043e-01f, 2.92174608e-01f, -3.54418963e-01f, -1.70411468e-01f, -4.78781760e-01f, 1.22969612e-01f, -2.37309560e-01f, 5.53206801e-01f, -5.23812830e-01f, -1.35733068e-01f,
  -2.53252059e-01f, 2.60885358e-01f, -1.19440384e-01f, -6.03114903e-01f, 3.77927482e-01f, 3.37761730e-01f, -3.54462899e-02f, 9.77134109e-02f, -5.89358509e-02f, -4.44855571e-01f,
  -4.99008708e-02f, -4.16418642e-01f, 3.96819273e-03f, 3.25440645e-01f, -4.08028156e-01f, -1.68708578e-01f, -9.16775912e-02f, -4.89819288e-01f, -6.13384128e-01f, -4.74326640e-01f,
  -4.14058208e-01f, -1.72944635e-01f, -2.28707150e-01f, -4.57380980e-01f, -4.06556517e-01f, 5.64566076e-01f, -4.95119542e-02f, -3.74963194e-01f, -4.21554416e-01f, -3.38236123e-01f,
  2.85592794e-01f, -5.26480854e-01f, 7.53671169e-01f, 8.37271273e-01f, 7.41047114e-02f, 7.14861751e-02f, 1.55511931e-01f, 2.00067684e-01f, 4.55721654e-02f, 1.37256518e-01f,
  -1.15513420e-02f, 1.33238984e-02f, -4.65228893e-02f, 5.64654097e-02f, 1.71064198e-01f, 1.52640864e-01f, 1.33669734e-01f, 1.24319725e-01f, -4.96993475e-02f, -6.82282001e-02f,
  3.69112566e-02f, -4.67875898e-02f, -3.90615799e-02f, -3.77377346e-02f, 2.57196009e-01f, -1.93222798e-03f, -1.20515063e-01f, 1.27596222e-02f, 2.59697348e-01f, -2.22984537e-01f,
  -2.29988918e-01f, -4.93972898e-01f, -3.45468104e-01f, 2.08022401e-01f, 6.95040286e-01f, -2.17028722e-01f, 6.52128041e-01f, -2.58748353e-01f, -5.93546569e-01f, -3.70682746e-01f,
  -2.26139307e-01f, 4.30247813e-01f, -2.79051960e-01f, -3.22984904e-01f, -1.98755473e-01f, -3.46208721e-01f, -1.68246612e-01f, -2.80238837e-01f, -2.82451868e-01f, 2.74351746e-01f,
  -1.83076084e-01f, -9.51800421e-02f, -2.41048679e-01f, -7.61014819e-01f, 5.69605291e-01f, 3.60690325e-01f, 1.57218188e-01f, 9.89791393e-01f, -3.16957921e-01f, -1.00786664e-01f,
  -2.25117549e-01f, -3.97819221e-01f, -6.11739993e-01f, 4.58158493e-01f, -2.16681361e-01f, -3.09930444e-01f, -3.54044922e-02f, 9.35528800e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.92030483e-01f, 2.23682135e-01f, 2.88015425e-01f, -1.89723134e-01f, 8.21177587e-02f, 8.69318843e-02f, 1.02017224e-01f, -6.15216307e-02f, -1.19624943e-01f, 1.99746341e-01f,
  -9.58207026e-02f, 6.38410747e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    