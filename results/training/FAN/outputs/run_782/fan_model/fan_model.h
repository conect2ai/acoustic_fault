/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.89958715e-01f, 1.16963133e-01f, 4.53031659e-02f, 9.95276496e-02f, -1.59998998e-01f, -3.97394877e-03f, 1.27868414e-01f, 1.00259125e-01f, 1.23111373e-02f, 2.32103541e-01f,
  -1.49912253e-01f, -2.43585899e-01f, -1.87730774e-01f, -3.22051942e-01f, -1.39374927e-01f, 1.65674776e-01f, 1.87033210e-02f, -6.96803331e-02f, -1.99159175e-01f, -1.14013545e-01f,
  -2.90593326e-01f, -1.42279696e-02f, 9.52689499e-02f, -6.94388375e-02f, 3.54200363e-01f, 7.11321607e-02f, 1.65169120e-01f, 5.42318113e-02f, -5.49338525e-03f, 2.17204019e-01f,
  -1.06894327e-02f, 1.16199695e-01f, -1.63125485e-01f, -1.01566203e-01f, 1.38464468e-02f, 9.38339233e-02f, 1.48655083e-02f, 1.28897101e-01f, -3.50923017e-02f, 3.71764810e-03f,
  -3.27744111e-02f, 1.56753100e-02f, 1.08898757e-03f, -6.50575310e-02f, 8.71406123e-02f, -6.72215968e-02f, 1.29288360e-01f, 1.88017208e-02f, 2.05539465e-02f, 4.97144125e-02f,
  -2.22027466e-01f, -7.87356049e-02f, -2.08922606e-02f, -1.71834826e-01f, -1.46579400e-01f, -2.30294511e-01f, -5.18297590e-02f, 3.32376249e-02f, -1.66011080e-01f, 4.71374094e-01f,
  3.72206792e-02f, 3.05164605e-02f, -3.58412564e-02f, 1.02597885e-02f, -3.04187369e-02f, 2.64076539e-03f, 9.52074863e-03f, 1.04851191e-04f, -1.38543146e-02f, 6.47061169e-02f,
  -5.69051271e-03f, 1.00850649e-02f, -7.61256041e-03f, 5.95860332e-02f, -4.77105305e-02f, 1.07583236e-02f, 4.19580285e-03f, -1.11218705e-03f, -4.86756749e-02f, 1.53899444e-02f,
  -2.61987578e-02f, -2.27941740e-02f, 6.29518554e-02f, -4.53902669e-02f, -4.20767404e-02f, -1.08297169e-02f, -2.23675799e-02f, -4.52296101e-02f, 1.06761418e-01f, 5.16396612e-02f,
  -1.97709855e-02f, -3.61344278e-01f, 1.84295237e-01f, -1.46391569e-04f, 6.07112423e-02f, 3.41533795e-02f, -1.88423824e-02f, -5.92061803e-02f, -3.87587249e-02f, -7.00260103e-02f,
  -5.38158556e-03f, 1.57050058e-01f, 2.87284628e-02f, 1.58303808e-02f, -1.18193282e-02f, 7.79366121e-03f, -7.31465593e-02f, -6.53910935e-02f, -6.06757551e-02f, 7.77092902e-03f,
  2.80418321e-02f, 3.35397385e-02f, 1.14242531e-01f, 2.93841213e-02f, -1.28363237e-01f, -6.54697716e-02f, 9.09675751e-03f, 1.21662125e-01f, 5.63121662e-02f, 4.52735543e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.93195341e-02f, -1.19104005e-01f, 5.38304210e-01f, -4.25944477e-02f, -2.00702846e-01f, -1.93439484e-01f, -3.22437018e-01f, -6.23965673e-02f, -1.95749775e-01f, -2.68847674e-01f,
  -2.66178668e-01f, -3.04241836e-01f, -9.39823315e-02f, 4.21147831e-02f, 7.05517381e-02f, 3.65701281e-02f, 2.66954094e-01f, 4.31688100e-01f, 3.98745328e-01f, -3.39879207e-02f,
  1.93924643e-02f, 2.38956898e-01f, 4.42886174e-01f, 2.00351879e-01f, 1.97238848e-02f, -1.04696779e-02f, 2.10946098e-01f, 3.84206735e-02f, 7.78194591e-02f, -2.79505812e-02f,
  -1.63056135e-01f, -1.08191915e-01f, -1.74273141e-02f, -1.74233377e-01f, 6.44589141e-02f, 1.18666608e-02f, -4.52144668e-02f, 2.00087264e-01f, -8.38193893e-02f, 4.23111254e-03f,
  -1.53642386e-01f, -8.55144635e-02f, -1.75082669e-01f, 6.58839047e-02f, 9.85972770e-03f, -1.03020154e-01f, 2.00342625e-01f, 2.82074839e-01f, 2.06488550e-01f, -4.27036621e-02f,
  -1.73199520e-01f, -1.67630151e-01f, -4.15154286e-02f, 1.72165334e-02f, 1.67073756e-02f, -8.05172510e-03f, -1.32252732e-02f, 3.02195968e-03f, 8.87104496e-02f, -9.91620198e-02f,
  -1.63703021e-02f, 9.83738690e-04f, -4.98535596e-02f, -1.84635222e-02f, 4.34525358e-03f, -5.89073822e-02f, 4.36530225e-02f, -9.91057977e-02f, 6.68989643e-02f, 8.53750408e-02f,
  -8.49031191e-03f, 1.06667206e-02f, 1.29879564e-01f, -1.43381823e-02f, -3.32850628e-02f, 1.44709731e-02f, 7.75433518e-03f, 4.21659537e-02f, 2.76724063e-02f, 8.07258394e-03f,
  -1.82344448e-02f, 6.43979833e-02f, 8.26330632e-02f, 6.22049421e-02f, 5.19401021e-02f, 3.64775807e-02f, 2.79468168e-02f, -7.75874406e-02f, 3.19319963e-02f, -3.42216268e-02f,
  -2.31941551e-01f, 2.48523533e-01f, -1.79141119e-01f, -1.55279646e-02f, -5.22067808e-02f, 1.25120571e-02f, -7.99743682e-02f, 5.54944621e-03f, -3.36006917e-02f, -3.31550650e-02f,
  -1.54592827e-01f, -4.71450686e-02f, 4.79627028e-03f, -5.05097583e-02f, -6.57211319e-02f, -6.27121925e-02f, 4.32873145e-03f, 9.44138877e-03f, 1.83644390e-03f, -3.70607302e-02f,
  -3.60436626e-02f, -1.30877465e-01f, -1.26416758e-01f, -1.13888361e-01f, -7.92387202e-02f, -1.15970269e-01f, -8.46884996e-02f, -1.35534212e-01f, 4.79049981e-02f, -3.57842408e-02f,
  -5.55025041e-01f, -1.87564239e-01f, 7.47127905e-02f, -3.35353874e-02f, 1.04081638e-01f, -1.39784902e-01f, -3.64328384e-01f, -2.03921810e-01f, -1.00014277e-01f, -2.35177930e-02f,
  6.53592870e-04f, 9.51170921e-02f, -4.34699431e-02f, -7.21580982e-02f, -3.86526674e-01f, -2.62583047e-01f, -1.55996516e-01f, -1.99247569e-01f, -2.12852597e-01f, -3.34772207e-02f,
  1.65931597e-05f, -1.02743387e-01f, -9.82761830e-02f, -1.39706045e-01f, -1.68686435e-02f, -6.31497353e-02f, 5.51597327e-02f, 2.95406170e-02f, -1.10666715e-01f, -1.35076955e-01f,
  6.40293881e-02f, -5.75865507e-02f, 1.03815719e-01f, -2.43936609e-02f, 1.77782908e-01f, -4.28882726e-02f, 4.42843847e-02f, -4.81436867e-03f, 5.26536629e-02f, -5.04721627e-02f,
  9.90012065e-02f, 8.61459691e-03f, -7.27947056e-02f, 6.02094084e-02f, 4.39263927e-03f, -1.03256516e-01f, -3.52245197e-02f, -1.71136811e-01f, -6.81121945e-02f, -9.01071131e-02f,
  -6.43821880e-02f, -6.75756484e-03f, -2.56903291e-01f, -1.12650350e-01f, -4.97626588e-02f, 1.37471571e-03f, 3.38632474e-03f, -6.13691621e-02f, -1.57331795e-01f, -2.61562377e-01f,
  -1.45070357e-02f, 2.89650895e-02f, 6.99599683e-02f, -1.34441152e-01f, 1.45790754e-02f, 5.48051186e-02f, 2.21020896e-02f, -1.22887142e-01f, -2.57165506e-02f, 2.81897765e-02f,
  -2.23368499e-02f, 1.32095680e-01f, -5.58723183e-03f, -1.26658052e-01f, -3.54800522e-02f, 6.32183850e-02f, -9.16953832e-02f, -8.62492770e-02f, -1.21768326e-01f, -1.35928812e-02f,
  -2.35224757e-02f, 7.48581113e-03f, 1.15607567e-01f, -2.30005179e-02f, 4.54262719e-02f, -1.05226517e-01f, 6.00588918e-02f, 6.38085082e-02f, 4.38299850e-02f, 1.06475785e-01f,
  -1.31545290e-01f, 1.77176863e-01f, -1.49562940e-01f, -1.03632577e-01f, 5.33583798e-02f, 1.22867348e-02f, 3.51401605e-02f, 1.05503596e-01f, 5.13888001e-02f, -9.04703289e-02f,
  -1.69684980e-02f, -2.76113823e-02f, -3.06708440e-02f, 5.66492863e-02f, -3.55143026e-02f, 1.12707987e-02f, -2.09512755e-01f, -5.07418811e-02f, -2.04739198e-01f, 2.68876515e-02f,
  -1.23106629e-01f, -2.80937970e-01f, -2.28146404e-01f, -2.29231238e-01f, -1.27846107e-01f, -2.22665071e-01f, -2.32720122e-01f, -2.14694396e-01f, -3.92406315e-01f, -3.76756221e-01f,
  -5.21765411e-01f, 1.46631911e-01f, 9.27320868e-02f, -1.17781460e-01f, -2.26539746e-01f, -2.08763689e-01f, -1.25485480e-01f, -1.05598770e-01f, -3.43133020e-03f, 1.03919603e-01f,
  2.24503260e-02f, -1.86420453e-04f, 1.36162430e-01f, -6.61488697e-02f, -2.13721111e-01f, -1.92654461e-01f, -2.99942851e-01f, -3.42726082e-01f, -2.12704033e-01f, -1.48509011e-01f,
  -2.45549664e-01f, -9.55035686e-02f, -2.97888517e-01f, -2.13480070e-01f, 1.05228946e-01f, 1.22600459e-01f, 9.26876068e-02f, -9.48522389e-02f, -1.50669247e-01f, 4.09539975e-02f,
  4.18889403e-01f, -2.07092136e-01f, -1.29214272e-01f, -2.21737608e-01f, 8.34512115e-02f, -1.27850950e-01f, -1.29628805e-02f, 5.07524647e-02f, -6.41216040e-02f, 7.10009038e-02f,
  -5.74358776e-02f, -9.03617665e-02f, -5.33998385e-02f, 1.01266585e-01f, -2.40323283e-02f, -6.94984049e-02f, -3.10498253e-02f, -1.25371635e-01f, 1.28914425e-02f, 1.39624864e-01f,
  -3.50998744e-04f, -1.93564028e-01f, -4.06990871e-02f, -4.38176729e-02f, -6.51108176e-02f, -1.25573784e-01f, 1.59451321e-01f, 1.13408724e-02f, -1.33110791e-01f, 2.55127698e-01f,
  9.51487795e-02f, -6.06499612e-03f, -6.28817230e-02f, -1.20892283e-02f, 3.70531864e-02f, 1.09881528e-01f, 1.13204364e-02f, 8.85276645e-02f, 6.62397146e-02f, 3.62585708e-02f,
  2.81212144e-02f, -4.42868248e-02f, 7.28548542e-02f, 1.09181190e-02f, 5.59096932e-02f, -1.77064687e-02f, -6.66151345e-02f, 2.33395416e-02f, -5.37668690e-02f, -7.15733171e-02f,
  4.38252762e-02f, -3.13904397e-02f, 8.92191101e-03f, 2.47072801e-02f, -5.46680279e-02f, -2.57249456e-02f, -2.45336499e-02f, -1.29220665e-01f, 1.75422914e-02f, -1.42158836e-01f,
  4.31606919e-01f, -4.61477488e-01f, 1.46391317e-01f, -9.25364345e-02f, -6.02142029e-02f, -4.97319810e-02f, 1.01144813e-01f, -8.98897201e-02f, 4.32924330e-02f, 3.25350720e-03f,
  -1.13684557e-01f, 2.25619245e-02f, 9.70414560e-03f, 1.05503820e-01f, -4.16266397e-02f, -8.63069668e-02f, -4.47141826e-02f, 7.13794231e-02f, -4.51439619e-02f, 1.24977306e-01f,
  1.18928608e-02f, -4.31677252e-02f, 1.53328374e-01f, 1.85141519e-01f, 1.28388807e-01f, 1.20156016e-02f, 2.36667052e-01f, 1.28962845e-01f, 4.86491136e-02f, 4.36117619e-01f,
  -3.91490251e-01f, 4.69574600e-01f, 3.40082586e-01f, -2.21087202e-01f, 2.37066463e-01f, 6.04566216e-01f, 1.00951779e+00f, 2.22638026e-01f, -1.48403123e-01f, 1.69569582e-01f,
  1.20297536e-01f, -4.26032931e-01f, -2.33804926e-01f, -1.27628148e-01f, 1.61245376e-01f, 3.96873504e-01f, 2.37544641e-01f, -1.59757614e-01f, -2.79421419e-01f, -1.60549860e-02f,
  2.79999413e-02f, -1.95906758e-01f, -2.24478334e-01f, -1.47953436e-01f, -2.09708378e-01f, -3.37281585e-01f, -4.74459585e-03f, -3.01813949e-02f, 2.36707553e-01f, -5.81278652e-02f,
  -7.91902617e-02f, 1.54382169e-01f, -1.63895026e-01f, -2.51353502e-01f, -5.74880093e-02f, -1.59788564e-01f, -1.56667712e-03f, -1.42624855e-01f, -3.95709425e-02f, -2.90405191e-03f,
  -9.25924629e-03f, -5.43513447e-02f, -3.96032381e-04f, -3.52723710e-02f, -2.45774654e-03f, 1.40226111e-02f, 6.51237220e-02f, -4.58478890e-02f, -8.23429078e-02f, 2.65657399e-02f,
  1.51194662e-01f, 1.76394403e-01f, 1.73275873e-01f, 1.43090084e-01f, 1.02617122e-01f, -1.10089555e-01f, 1.54243857e-01f, -3.65581959e-02f, 1.25235334e-01f, -1.69042870e-01f,
  -1.26653034e-02f, -2.51013543e-02f, 6.23923391e-02f, 1.27401121e-03f, 1.23669254e-02f, -3.49741876e-02f, 3.80140692e-02f, -9.80332401e-03f, 1.01424627e-01f, -1.20877363e-01f,
  6.16476797e-02f, 1.39648104e-02f, 5.13353664e-03f, -4.41429056e-02f, -1.28523782e-01f, 4.54090014e-02f, 1.14360623e-01f, 2.87854150e-02f, 1.67972688e-02f, -1.57252289e-02f,
  4.84168576e-03f, 7.61001036e-02f, -5.74654527e-02f, -3.23390812e-02f, 1.25363022e-01f, -8.14497396e-02f, -6.74983487e-02f, -6.40307143e-02f, -3.50905880e-02f, -4.85032313e-02f,
  -4.21222627e-01f, 2.62749285e-01f, -2.20369115e-01f, -6.64586648e-02f, 5.13358004e-02f, -7.83936530e-02f, -4.80504707e-02f, -7.83759952e-02f, -5.95249720e-02f, 5.76185174e-02f,
  -8.16279463e-03f, -9.41201225e-02f, 8.33621919e-02f, 8.82786363e-02f, -4.94408906e-02f, 1.15557574e-02f, 3.68574671e-02f, -1.76999681e-02f, -1.54962838e-02f, -3.18398960e-02f,
  2.54738517e-02f, 7.63397152e-03f, -1.20266907e-01f, -2.55460516e-02f, -3.33364643e-02f, -1.86389327e-01f, -3.21940631e-02f, -6.51523545e-02f, 1.21174477e-01f, -1.01997323e-01f,
  4.42493975e-01f, -5.05075336e-01f, -8.28517795e-01f, 1.88363940e-02f, -3.57741803e-01f, -3.26442450e-01f, -4.80225861e-01f, 1.76084861e-01f, 1.72507986e-01f, -3.91475499e-01f,
  -4.45778966e-02f, 1.52520776e-01f, 8.78780782e-02f, 5.40411025e-02f, 1.22332662e-01f, -4.91513550e-01f, -4.07013625e-01f, -5.19093163e-02f, 1.69342369e-01f, 1.46541581e-01f,
  -5.61123602e-02f, -1.30094424e-01f, 2.37242088e-01f, 1.51753277e-01f, -3.24622542e-01f, -1.82810515e-01f, -4.28420961e-01f, -3.06522012e-01f, -2.77996242e-01f, -6.56298518e-01f,
  -5.33931494e-01f, -1.68731034e-01f, 9.27759707e-02f, 1.21229358e-01f, -2.02092305e-01f, 3.03998291e-02f, -3.42259444e-02f, 1.34553928e-02f, 1.23862401e-01f, 2.06620768e-02f,
  -7.53449202e-02f, 6.47417009e-02f, -2.12978907e-02f, -8.84109214e-02f, 1.01792114e-02f, -5.98507263e-02f, -3.00456188e-03f, 4.29487042e-03f, -2.22197454e-02f, -3.02673709e-02f,
  -1.32847309e-01f, -1.50898889e-01f, -1.17952555e-01f, -6.53536469e-02f, 2.50259750e-02f, -1.21792294e-02f, -9.18911174e-02f, -7.40302429e-02f, -3.46068144e-02f, -2.34136492e-01f,
  -2.18603816e-02f, -9.91542265e-02f, -3.44491228e-02f, 7.54285976e-02f, 3.22035402e-02f, 6.13813885e-02f, -8.07345007e-03f, 6.28677160e-02f, 3.35141644e-02f, 3.55581311e-03f,
  1.68592446e-02f, -6.81501552e-02f, 3.40009294e-02f, 5.88712618e-02f, -8.26961026e-02f, -2.03031041e-02f, 4.76367772e-02f, -7.81723112e-02f, 2.71597803e-02f, -3.72236930e-02f,
  -8.18186812e-03f, 1.02547891e-02f, -7.12440014e-02f, 4.31270301e-02f, -6.33465499e-02f, -9.09620970e-02f, 8.88162386e-03f, 1.02855802e-01f, 1.44965008e-01f, -2.46854071e-02f,
  3.01986992e-01f, -8.08789879e-02f, -7.01096132e-02f, 8.42930898e-02f, -7.41997659e-02f, -2.47579757e-02f, 4.17312682e-02f, 6.71752989e-02f, 5.90833500e-02f, -9.12141502e-02f,
  -5.10165915e-02f, 1.13251388e-01f, -9.59287304e-03f, -1.96522269e-02f, -1.55104585e-02f, -1.90665834e-02f, 1.10837445e-02f, -2.04485115e-02f, -3.79999168e-03f, -1.24455556e-01f,
  4.65509035e-02f, -7.05543300e-03f, 1.02045111e-01f, 4.29991707e-02f, -1.48914352e-01f, 3.08528747e-02f, -1.29492059e-01f, -1.15320861e-01f, 4.63503227e-02f, -5.76394610e-02f,
  -4.18553799e-01f, -2.01496556e-02f, -7.26903230e-02f, -2.25640729e-01f, -3.20284963e-02f, 6.20167181e-02f, 1.44167930e-01f, 1.17942385e-01f, -1.22391708e-01f, -4.80623543e-02f,
  8.54876079e-03f, -9.96625274e-02f, -6.00013845e-02f, -1.46074109e-02f, -2.47239769e-02f, -1.20426640e-01f, -5.72559349e-02f, -2.26619214e-01f, -9.79763418e-02f, 8.95177647e-02f,
  6.93747997e-02f, -1.81322485e-01f, -2.11400941e-01f, 7.29388092e-04f, 7.80514553e-02f, -5.74123561e-02f, -8.07462931e-02f, -5.52615188e-02f, 8.51439536e-02f, 5.06057031e-02f,
  -4.96497564e-02f, -8.77244696e-02f, 2.09750626e-02f, 5.72068132e-02f, -9.24897864e-02f, -3.72471847e-02f, 3.41689251e-02f, 1.18776597e-02f, -6.67522401e-02f, 3.07384934e-02f,
  -3.45301931e-03f, 3.75216827e-02f, 5.16032800e-02f, 5.43499775e-02f, 7.42060468e-02f, 1.65472610e-03f, -2.18014438e-02f, -5.86790545e-03f, 2.98473928e-02f, 2.58186758e-02f,
  3.12545337e-02f, 3.82369570e-02f, -7.86240101e-02f, 1.27453431e-01f, 1.08291447e-01f, 5.72763532e-02f, 4.72930260e-02f, 1.12358145e-01f, 1.85365781e-01f, 9.79892388e-02f,
  9.57256481e-02f, 5.07991351e-02f, -4.35395762e-02f, 1.10849012e-02f, 1.80575997e-02f, -4.88261171e-02f, 1.25827389e-02f, 4.73433062e-02f, 4.71360385e-02f, -4.43811119e-02f,
  1.55225843e-02f, -4.13494334e-02f, -2.24896725e-02f, -7.96506256e-02f, -4.38442361e-03f, -2.17624083e-02f, -1.80642456e-02f, 9.05538648e-02f, 6.56038150e-02f, 4.83058058e-02f,
  2.78823655e-02f, -3.31378765e-02f, -6.13720417e-02f, 2.49373596e-02f, -2.19948147e-03f, 1.29100922e-02f, -7.01939464e-02f, 1.22269146e-01f, 4.94096875e-02f, -8.45678300e-02f,
  -1.05389409e-01f, -4.59475294e-02f, -1.28446847e-01f, -9.32444166e-03f, -5.04650176e-02f, 3.34803201e-02f, -6.57961378e-03f, -6.15002885e-02f, -8.89113694e-02f, -4.03662026e-02f,
  7.63837248e-02f, -6.74116164e-02f, -4.21505645e-02f, 3.97660919e-02f, -4.20240536e-02f, 1.00728296e-01f, -6.89591840e-02f, -6.50759563e-02f, 2.27637645e-02f, 5.39674908e-02f,
  5.22025600e-02f, 4.05133963e-02f, -1.22218154e-01f, 2.05708239e-02f, 4.00480144e-02f, -4.03947011e-02f, 7.26796910e-02f, 6.27476349e-02f, -9.55143571e-02f, -1.42127305e-01f,
  1.31853506e-01f, 5.71261309e-02f, -1.30653843e-01f, 1.79320052e-01f, 1.87080830e-01f, 9.57007632e-02f, 5.21368943e-02f, 1.82473853e-01f, 3.12400877e-01f, 1.77090839e-01f,
  2.59678632e-01f, 3.14616501e-01f, 2.91474879e-01f, 3.08146715e-01f, 2.65167594e-01f, 1.75470337e-01f, 1.14294395e-01f, -2.09050514e-02f, 1.37559056e-01f, 1.09712146e-01f,
  1.85165122e-01f, 5.90706430e-02f, 3.59904543e-02f, 1.04357064e-01f, 2.12915335e-02f, 4.22482230e-02f, -8.53035152e-02f, -3.86620127e-03f, -7.31682230e-04f, 2.39134319e-02f,
  -6.26594052e-02f, -6.14952743e-02f, 1.09908588e-01f, -1.71182938e-02f, -3.52950022e-02f, -1.02430977e-01f, 5.84474280e-02f, -9.14671272e-02f, -3.57894339e-02f, -1.23827621e-01f,
  -5.96372709e-02f, 2.73059792e-04f, -4.33633886e-02f, -1.54568493e-01f, -4.93751392e-02f, -4.61768396e-02f, 4.40599892e-04f, 9.81109496e-03f, 1.61899310e-02f, 5.50493337e-02f,
  6.08457364e-02f, -5.37943207e-02f, -1.20086648e-01f, -2.85155475e-02f, 2.74148900e-02f, 9.46680903e-02f, -4.50963750e-02f, -1.10116117e-01f, -2.43932121e-02f, 4.73265685e-02f,
  1.10070609e-01f, -1.88744608e-02f, 7.15364739e-02f, -1.30991917e-02f, 3.44884284e-02f, 8.34960490e-02f, -1.78051442e-02f, -6.81430176e-02f, -1.64978020e-02f, -8.48722309e-02f,
  3.21584083e-02f, 9.74253118e-02f, 5.70307672e-02f, 1.31827548e-01f, 5.27627468e-02f, -1.16947830e-01f, 1.56079028e-02f, -5.77625632e-02f, -2.69000768e-03f, -7.83471316e-02f,
  -7.10621998e-02f, 1.15981931e-02f, -6.38377964e-02f, -1.24809565e-02f, -4.33701463e-02f, 7.22215846e-02f, 6.10058336e-03f, 1.26605220e-02f, -1.46858413e-02f, -9.94045883e-02f,
  -2.31663547e-02f, -1.19067531e-03f, 1.08838104e-01f, 8.65912437e-02f, -1.00727156e-01f, -1.58315778e-01f, -4.41141077e-04f, -1.11002460e-01f, -1.07013516e-01f, -9.61051658e-02f,
  -6.11130781e-02f, -1.58427916e-02f, -1.50771113e-02f, -2.80219596e-02f, -7.24955797e-02f, -4.19768952e-02f, 1.51560269e-02f, 9.07832980e-02f, 5.63574098e-02f, 4.98425309e-03f,
  -8.47886130e-02f, 8.77766032e-03f, -2.27094200e-02f, 6.03744052e-02f, 2.67549995e-02f, 5.58016449e-02f, -1.73195694e-02f, -5.07492833e-02f, -9.57785267e-03f, -3.49929519e-02f,
  3.78522724e-01f, -3.06766093e-01f, 3.09086263e-01f, -4.06907946e-02f, -6.32087365e-02f, 5.51813655e-03f, -1.41265973e-01f, -2.39023883e-02f, 3.40090580e-02f, 2.00013118e-03f,
  -1.51669532e-01f, 2.70711929e-02f, -1.03877857e-01f, -5.33298440e-02f, 3.20607126e-02f, 1.01134300e-01f, 1.62375957e-01f, 3.41885388e-01f, 3.50447416e-01f, 8.84120315e-02f,
  1.95128489e-02f, 1.07701086e-01f, 5.63599505e-02f, 9.44169015e-02f, -2.18290393e-03f, -1.02754505e-02f, -1.91505477e-02f, 3.25611047e-02f, -7.38651305e-02f, 2.36631438e-01f,
  3.62007022e-01f, -8.16761702e-02f, 1.37787119e-01f, -1.40414596e-01f, -5.04965782e-02f, -2.49371342e-02f, 1.02559358e-01f, -3.99894901e-02f, -4.79472615e-02f, -1.16414860e-01f,
  6.01302050e-02f, 5.78629635e-02f, -1.04231656e-01f, -2.61084158e-02f, -8.61083809e-03f, 3.74447182e-02f, -2.71777213e-02f, 1.29906625e-01f, 2.30153892e-02f, 9.72422659e-02f,
  -7.39320815e-02f, 7.98633974e-03f, 1.36514027e-02f, -2.94985957e-02f, 2.25188881e-02f, 8.28592107e-03f, -4.99319881e-02f, -1.25937967e-03f, -2.01554932e-02f, 1.36064574e-01f,
  1.46508329e-02f, 7.84459710e-02f, -1.61037240e-02f, -1.87687501e-02f, 1.63085386e-02f, 4.31619063e-02f, 9.59371999e-02f, 1.10791074e-02f, -3.21732424e-02f, -4.75878119e-02f,
  -4.24898267e-02f, -8.37460533e-03f, 3.42417881e-02f, 4.35192287e-02f, 4.06762511e-02f, 1.25248975e-03f, 1.08426623e-01f, -2.74164733e-02f, -1.24250710e-01f, -5.98832704e-02f,
  2.24892981e-02f, 9.78964120e-02f, -8.56940523e-02f, -3.94608676e-02f, -1.20982416e-02f, -8.75755958e-03f, 6.56476319e-02f, -7.22566694e-02f, -7.63543025e-02f, 6.00807741e-02f,
  -2.31760181e-02f, -1.03000693e-01f, 2.16098323e-01f, 4.24530283e-02f, 1.02465414e-01f, -8.92845690e-02f, 2.54370598e-03f, -3.40929925e-02f, -3.61252092e-02f, 7.08881617e-02f,
  -5.52375354e-02f, 1.20372437e-01f, -7.03961253e-02f, -2.89439093e-02f, 1.36077125e-02f, 1.18854865e-02f, -9.85038951e-02f, 1.76199660e-01f, -5.83181009e-02f, -7.78823392e-03f,
  -1.47719011e-01f, 3.92036960e-02f, 4.14597057e-02f, 9.68259294e-03f, 9.38900709e-02f, 1.13078170e-01f, -1.35484328e-02f, 8.02126601e-02f, 1.03167415e-01f, -2.59853955e-02f,
  8.15652788e-01f, -5.66306591e-01f, 1.68192297e-01f, 2.30182663e-01f, 2.95882881e-01f, 2.62194484e-01f, 2.30487466e-01f, 1.02497868e-01f, 9.25626233e-02f, -3.30802910e-02f,
  -1.71825364e-01f, -7.39814062e-03f, -1.40070021e-02f, -1.96280167e-01f, 6.17899857e-02f, -7.62841552e-02f, 9.38596353e-02f, 1.50409162e-01f, 3.41855288e-01f, 1.32705316e-01f,
  -9.98959914e-02f, -2.75072437e-02f, 9.75258555e-03f, -1.55475233e-02f, -1.72320798e-01f, -3.99941206e-02f, -1.16418518e-01f, -1.13398381e-01f, -2.67987072e-01f, -3.30927223e-01f,
  -8.85461792e-02f, -5.99974953e-02f, 2.05079898e-01f, -9.28288475e-02f, -6.41480684e-02f, -6.97022304e-03f, 4.15204689e-02f, -9.85821784e-02f, -9.75647569e-02f, -6.99764490e-02f,
  -3.31310555e-02f, -5.88306226e-02f, -6.38327748e-02f, -7.44664520e-02f, -1.00173116e-01f, 3.55115458e-02f, -3.87850478e-02f, -1.12161413e-01f, -2.01643147e-02f, -2.30754167e-01f,
  -3.74860108e-01f, -1.42520824e-02f, 1.33328184e-01f, -4.53752540e-02f, -3.08649465e-02f, 1.77923709e-01f, -1.55672297e-01f, -8.62148777e-02f, 1.04567222e-02f, -1.41289845e-01f,
  -1.22209387e-02f, 6.62172437e-02f, 1.00769639e-01f, -1.43997166e-02f, 8.42500106e-02f, 7.35694245e-02f, 8.06748401e-03f, -1.23637151e-02f, 5.99148534e-02f, -9.30016022e-03f,
  -6.03565909e-02f, 1.21759094e-01f, 2.07734685e-02f, 8.52573812e-02f, 1.01091983e-02f, 4.00049575e-02f, -7.56192803e-02f, -9.08427387e-02f, 7.71609321e-02f, 7.61297941e-02f,
  3.24754976e-02f, 1.25294197e-02f, -8.47408697e-02f, -7.08201304e-02f, -6.66894391e-02f, -4.35454994e-02f, 1.98624074e-03f, -4.30366546e-02f, 9.52274166e-03f, -4.41768626e-03f,
  -1.23449013e-01f, 3.01711589e-01f, 1.27862304e-01f, -3.89853828e-02f, 1.26023637e-03f, -1.22023448e-01f, -4.48508598e-02f, -8.01943466e-02f, -6.43890351e-02f, -3.15904655e-02f,
  -7.14814439e-02f, -7.63169117e-03f, -1.30607029e-02f, -5.46302982e-02f, 1.80607170e-01f, 1.31773382e-01f, -1.62778556e-01f, 8.50359276e-02f, -1.70884207e-02f, -1.82052687e-01f,
  -1.11250669e-01f, 1.72872886e-01f, 4.24222797e-01f, 1.91766486e-01f, 3.35568823e-02f, 3.86777043e-01f, 1.12896822e-01f, -1.07910074e-02f, 2.49935269e-01f, 2.45618626e-01f,
  2.38522708e-01f, 1.78531960e-01f, 1.59591511e-01f, 3.20974916e-01f, 4.70561199e-02f, -2.43498832e-01f, -2.42891595e-01f, -2.33056530e-01f, -1.83385119e-01f, 4.87029515e-02f,
  -3.14812101e-02f, 8.80426243e-02f, 2.05426197e-02f, 4.00976092e-02f, 1.97401866e-02f, 9.29721221e-02f, 2.33734161e-01f, 2.73928940e-01f, 1.03792749e-01f, -4.93047349e-02f,
  1.10081926e-01f, 3.00475836e-01f, 1.33809596e-01f, 1.63099781e-01f, 2.29919642e-01f, 1.55059859e-01f, 4.46118638e-02f, 2.62316227e-01f, 1.38450116e-01f, 4.82179374e-01f,
  1.03800707e-01f, 2.02114463e-01f, -2.20983043e-01f, -3.69937122e-02f, 1.20209754e-01f, -7.75136575e-02f, 8.13990645e-03f, -5.19452728e-02f, 1.41637279e-02f, 4.99038864e-03f,
  1.11423902e-01f, -2.30692253e-02f, 1.09556496e-01f, -6.57685623e-02f, -1.14206113e-01f, -1.68742746e-01f, 1.35918492e-02f, 9.00084674e-02f, -5.94072938e-02f, -4.49245162e-02f,
  2.32655883e-01f, 7.08884224e-02f, -1.16670236e-01f, -2.52080888e-01f, -9.99330916e-03f, 9.26966965e-03f, -2.84329373e-02f, 2.03277096e-02f, -2.51310498e-01f, -2.70041581e-02f,
  -8.70514512e-02f, 1.97076183e-02f, -3.92563231e-02f, 8.44350755e-02f, -3.88778790e-05f, 1.52661130e-02f, 4.78225807e-03f, -8.23610462e-03f, 8.95743892e-02f, 4.57136855e-02f,
  -2.03690510e-02f, -1.46378577e-02f, -3.98287885e-02f, -2.98367254e-02f, -1.57579547e-03f, -4.54684570e-02f, -4.35477793e-02f, 3.98426279e-02f, -4.18775342e-03f, -2.71770898e-02f,
  9.63920914e-03f, -6.73401775e-03f, -8.86548758e-02f, 8.76724720e-02f, 5.61679266e-02f, 1.82223003e-02f, 3.81923988e-02f, -4.67957184e-03f, -7.79134110e-02f, -1.23165622e-02f,
  -4.08028483e-01f, -1.34823024e-01f, -1.23828813e-01f, -1.97134018e-02f, -1.53951971e-02f, 2.83314381e-02f, 6.22663423e-02f, 2.83195935e-02f, 3.21369506e-02f, -6.93153664e-02f,
  -2.31013317e-02f, 6.53705448e-02f, 1.63744166e-02f, -8.91034231e-02f, -5.26334047e-02f, -1.23224810e-01f, -1.61791041e-01f, 4.93492968e-02f, -8.54113773e-02f, -9.79965031e-02f,
  -5.25032394e-02f, -2.97839165e-01f, -3.04249525e-01f, -2.81790555e-01f, -1.83827683e-01f, -1.58423603e-01f, -3.23158950e-01f, -2.40777344e-01f, -3.79873157e-01f, -4.00807887e-01f,
  -7.02964842e-01f, -5.24735488e-02f, -1.10432990e-01f, -8.02977309e-02f, 2.17414528e-01f, 6.88008890e-02f, 6.49808198e-02f, -7.26559907e-02f, -1.08641826e-01f, -9.04463406e-04f,
  -6.51050657e-02f, -3.48006412e-02f, 4.73990925e-02f, 5.46320751e-02f, 1.61275238e-01f, 1.86947405e-01f, 2.92147040e-01f, 2.50428207e-02f, -3.98437306e-02f, -1.61578171e-02f,
  1.41790479e-01f, -1.20672353e-01f, -2.47265503e-01f, 7.71010965e-02f, 4.82622273e-02f, 1.13283796e-02f, 8.73695016e-02f, -4.70368229e-02f, 7.97439218e-02f, 2.48754635e-01f,
  -9.08037052e-02f, -1.94058776e-01f, 8.46807063e-02f, 4.34270576e-02f, -9.67636053e-03f, -9.41324309e-02f, -1.12220295e-01f, 1.21882756e-03f, -1.02734573e-01f, -4.58395965e-02f,
  -2.34282445e-02f, 2.12681703e-02f, -2.06942912e-02f, 2.35811975e-02f, -1.10126518e-01f, 5.29157743e-03f, -4.01337035e-02f, 3.21391411e-03f, 8.42311233e-03f, 4.57986519e-02f,
  1.01188943e-01f, -4.45656776e-02f, -1.89433157e-01f, -3.30577902e-02f, -1.04913034e-01f, -2.74874456e-03f, 2.46192645e-02f, -4.74736840e-02f, -4.97496948e-02f, -1.77023649e-01f,
  1.98523298e-01f, 9.10185054e-02f, 7.07935542e-02f, -1.32816285e-02f, -2.02716831e-02f, 5.24534881e-02f, 1.44498020e-01f, 9.91685688e-02f, 1.02922581e-02f, -7.84633160e-02f,
  1.10262763e-02f, -7.86106847e-03f, 7.05540255e-02f, -5.13349436e-02f, 1.21922605e-01f, -2.24167444e-02f, 7.73123577e-02f, -2.50441153e-02f, 4.59259786e-02f, 7.12315785e-03f,
  -8.18198621e-02f, 7.20818192e-02f, 5.35623962e-03f, -1.27231842e-02f, -5.35513312e-02f, 3.76095474e-02f, -7.03209862e-02f, -6.55244961e-02f, -6.69004023e-02f, -3.56736146e-02f,
  -2.32651100e-01f, 1.65508896e-01f, 2.00135577e-02f, 1.45570273e-02f, -3.81320864e-02f, -1.43832006e-02f, -1.08019069e-01f, 4.62168232e-02f, -5.73976338e-02f, -1.16576582e-01f,
  -8.06895271e-02f, -7.99802244e-02f, -5.71838282e-02f, 5.55370823e-02f, -7.07204118e-02f, -4.88689393e-02f, 7.12283179e-02f, 3.18874158e-02f, 4.94579487e-02f, -5.55608608e-02f,
  -6.18668133e-03f, -1.72237933e-01f, -2.19943166e-01f, -1.23018309e-01f, -9.67149734e-02f, -1.68420747e-01f, -1.28766194e-01f, -2.36538708e-01f, -3.19527268e-01f, -2.98239887e-01f,
  -3.50146830e-01f, 2.11390778e-01f, -1.68363631e-01f, 7.00761005e-02f, 1.12538926e-01f, -2.11358145e-01f, -1.20500326e-01f, -1.21981531e-01f, 9.44058225e-03f, 3.06491330e-02f,
  1.09538674e-01f, 5.53479567e-02f, -7.16580302e-02f, -3.87215726e-02f, -2.98778057e-01f, -8.87887832e-03f, 7.96388388e-02f, -3.20528448e-01f, -4.64346141e-01f, -3.07992309e-01f,
  -4.71273996e-02f, -1.16501145e-01f, -3.38284820e-01f, -1.77940309e-01f, 2.20158070e-01f, 1.23197451e-01f, 1.17753804e-01f, 9.62172374e-02f, -1.62464399e-02f, 4.77119744e-01f,
  -1.63884640e-01f, -5.55559173e-02f, -1.07745625e-01f, 9.97992307e-02f, 9.38001275e-02f, -1.12591192e-01f, -3.11624408e-02f, 5.31292595e-02f, -1.67017635e-02f, -9.11601633e-02f,
  1.54856518e-01f, -8.01837593e-02f, 7.75424913e-02f, -1.07217737e-01f, -4.96257208e-02f, -1.04996890e-01f, 2.56590042e-02f, -1.63605586e-01f, -1.26557738e-01f, -1.55146912e-01f,
  2.56285459e-01f, 1.51580563e-02f, -1.63500324e-01f, -1.21200390e-01f, -1.24656297e-01f, -9.08508152e-02f, -6.45263493e-02f, -1.57649085e-01f, -1.18979700e-01f, -2.46783607e-02f,
  -3.03458236e-02f, 2.07413174e-02f, -2.14436874e-02f, 1.29637830e-02f, 3.58004011e-02f, 7.88122974e-03f, 4.67821509e-02f, 3.29288915e-02f, -7.22915903e-02f, 3.15629900e-03f,
  -7.71279335e-02f, 5.82155585e-02f, -4.19418607e-03f, 5.77602908e-02f, -1.44263199e-02f, 8.15941989e-02f, -2.21197158e-02f, 4.19608131e-03f, -3.01073249e-02f, 4.59102914e-02f,
  3.06602626e-04f, 6.79894015e-02f, 4.21267673e-02f, 2.27529369e-02f, -1.92123894e-02f, -2.63002981e-02f, 1.69224925e-02f, -2.27151345e-02f, 8.00205544e-02f, 1.31711522e-02f,
  -1.57474190e-01f, -1.64594367e-01f, 8.89848992e-02f, -3.67424786e-02f, 1.68859903e-02f, 8.28489512e-02f, 1.91928089e-01f, -5.90333939e-02f, 9.45426896e-02f, -5.69857955e-02f,
  -3.56992357e-03f, -1.29164219e-01f, 8.91962871e-02f, -1.60399720e-01f, -5.40784784e-02f, -8.33532587e-02f, 2.78729890e-02f, -6.49527833e-02f, -1.58178657e-01f, -1.79570895e-02f,
  2.08775532e-02f, -1.06921487e-01f, -2.02972963e-01f, -7.29479119e-02f, -6.86408803e-02f, -9.26972181e-02f, -1.43999144e-01f, -1.26338452e-01f, -2.35261694e-01f, -1.43122360e-01f,
  3.59992236e-02f, -1.98020995e-01f, -1.93363309e-01f, -2.58345783e-01f, -2.23804981e-01f, -1.65364414e-01f, -3.01602662e-01f, -2.33447701e-02f, -3.64575721e-02f, -2.37326071e-01f,
  -6.17867000e-02f, 1.20889675e-03f, 7.35850912e-03f, 8.69524851e-02f, -5.22133745e-02f, -2.64323473e-01f, -1.82462811e-01f, -5.42285992e-03f, 9.15166065e-02f, -6.97984621e-02f,
  -1.04514062e-01f, -1.33095920e-01f, -4.62749228e-02f, 4.71654013e-02f, -1.02852646e-03f, 1.01799853e-01f, -8.26084148e-03f, -4.69039157e-02f, 1.06275817e-02f, -1.82603493e-01f,
  -7.47166649e-02f, 1.56184047e-01f, 1.22983076e-01f, 1.00022301e-01f, 4.19909470e-02f, 1.12944981e-02f, 4.31058034e-02f, -5.26926108e-02f, 1.57895330e-02f, -1.17707044e-01f,
  4.88572232e-02f, -1.73696280e-02f, -1.55537184e-02f, -8.49543661e-02f, 5.61072375e-04f, -1.32158518e-01f, 3.22219357e-02f, 1.13486104e-01f, 9.56835076e-02f, -5.85614815e-02f,
  -3.72228096e-03f, -4.66864407e-02f, 3.58931534e-02f, 2.72599608e-02f, 1.61500484e-01f, 1.32639885e-01f, 5.95966466e-02f, 3.04666966e-01f, 2.98448861e-01f, 9.57875475e-02f,
  3.38830315e-02f, 4.41516899e-02f, 7.91971572e-03f, -4.01557237e-02f, 5.27958237e-02f, 3.27793844e-02f, -3.50856297e-02f, -5.98845743e-02f, -6.91852048e-02f, 6.94566444e-02f,
  -2.78450400e-02f, -8.78458470e-02f, 2.09670700e-02f, -1.07407480e-01f, 3.34978476e-02f, 3.10333055e-02f, -5.82286902e-02f, -4.11774358e-03f, -3.19037400e-02f, 2.66013797e-02f,
  1.46067664e-01f, 1.35889584e-02f, -9.53761861e-02f, 5.19171134e-02f, -3.04985084e-02f, -4.06531245e-02f, -4.33367863e-03f, -8.88319628e-05f, 7.98414461e-03f, 9.92947631e-03f,
  -2.93893665e-01f, 1.53803334e-01f, 2.71637347e-02f, 5.98017639e-03f, -2.24249810e-03f, 2.61716601e-02f, 1.65129583e-02f, 2.84861457e-02f, -3.45895067e-02f, -8.88184011e-02f,
  9.66082662e-02f, -4.29806821e-02f, -5.45612574e-02f, 9.38866436e-02f, -5.45525039e-03f, 2.64659151e-02f, -1.71851993e-01f, -3.63902301e-02f, 9.32542980e-02f, 6.52213348e-03f,
  -6.96344748e-02f, -9.37323719e-02f, -3.93903814e-02f, 3.33325043e-02f, 1.63072541e-01f, 7.38338530e-02f, 5.48483431e-02f, 1.21027425e-01f, 1.68984622e-01f, -1.35039121e-01f,
  -3.57586026e-01f, 2.22102739e-03f, 1.14840297e-02f, -1.06542744e-01f, 5.29734492e-02f, 5.16754994e-03f, 1.76931247e-01f, 5.95725738e-02f, 3.92459854e-02f, 9.30165574e-02f,
  5.33309467e-02f, 1.18145242e-01f, 1.41510755e-01f, 7.32660964e-02f, 2.61235498e-02f, 7.38389641e-02f, 9.76513103e-02f, -1.09652109e-01f, 7.81228989e-02f, -3.17482166e-02f,
  2.24614218e-02f, 2.37181201e-03f, -8.24166313e-02f, 5.98994642e-02f, -4.18158956e-02f, 7.56837726e-02f, -3.10929231e-02f, 6.14411980e-02f, 1.27280354e-01f, -3.93322445e-02f,
  2.67048299e-01f, -1.49118051e-01f, 9.05071571e-02f, 3.12127043e-02f, 4.03523929e-02f, -1.77197754e-02f, -7.94945359e-02f, -1.21230714e-01f, 6.53675050e-02f, 1.16493285e-01f,
  3.26032229e-02f, -1.14970632e-01f, -8.60340074e-02f, 1.77582167e-02f, 1.81184523e-03f, -7.84874856e-02f, -9.54542905e-02f, -2.78870147e-02f, -6.83270842e-02f, -8.27767700e-03f,
  6.01458028e-02f, 1.48242982e-02f, -5.44483140e-02f, -2.26494987e-02f, 5.54012544e-02f, -6.76427186e-02f, 2.53926497e-02f, 5.25140502e-02f, 2.98043229e-02f, 5.81037439e-02f,
  2.11577788e-02f, 1.95569266e-02f, -2.69227894e-03f, 4.22131494e-02f, 1.11429840e-02f, -6.86133057e-02f, 1.06236292e-02f, -1.26652941e-02f, -4.29924987e-02f, 1.01746432e-02f,
  2.47933045e-02f, -4.23517264e-02f, 2.41683349e-02f, -3.00751030e-02f, -4.10595238e-02f, 5.47040515e-02f, -1.25111416e-02f, 1.84693858e-02f, -1.77832656e-02f, -1.00024357e-01f,
  3.69324498e-02f, 5.66430874e-02f, 5.38314022e-02f, -4.29900885e-02f, -3.32802609e-02f, 6.10057898e-02f, -2.72161271e-02f, -6.22855080e-03f, -3.51904929e-02f, 2.77793575e-02f,
  2.70201653e-01f, -5.96989319e-02f, 1.75633486e-02f, 2.80815978e-02f, -7.98362792e-02f, -1.22359455e-01f, -4.89619598e-02f, -1.26698628e-01f, 3.34413573e-02f, 7.21323341e-02f,
  4.40231487e-02f, 3.73022892e-02f, 1.29869640e-01f, 7.65320286e-02f, -5.36012575e-02f, 1.38313649e-02f, -4.14042883e-02f, 4.63906229e-02f, 3.77237312e-02f, 3.76066156e-02f,
  1.69716641e-01f, -1.16897970e-02f, 1.23823807e-01f, 1.01488449e-01f, 1.13965154e-01f, -2.08524819e-02f, 1.79725662e-01f, 1.16287336e-01f, 4.60364893e-02f, 1.26361758e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.68600124e-01f, 3.02313566e-01f, 4.82286572e-01f, 6.53873444e-01f, 5.32144666e-01f, -6.49185553e-02f, 7.86439627e-02f, 1.71026468e-01f, 6.22020960e-01f, 7.21508980e-01f,
  1.99640930e-01f, 5.40787578e-01f, 7.08527816e-03f, 2.62558088e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  7.81106064e-03f, 5.84968507e-01f, 4.98163290e-02f, -9.49416086e-02f, 1.56384304e-01f, 1.03913054e-01f, -4.75229204e-01f, -2.43013889e-01f, -1.25274405e-01f, 4.31296259e-01f,
  7.45796561e-02f, 4.46491130e-02f, 7.26392046e-02f, 3.88010412e-01f, -4.71914113e-01f, 2.17769518e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.00786084e-01f, 3.07518095e-01f, 1.18719913e-01f, 1.46628678e-01f, -2.17861071e-01f, 1.10536776e-02f, -8.68789405e-02f, -8.07011798e-02f, -1.66946277e-02f, 1.25278354e-01f,
  -3.58630806e-01f, 1.74087107e-01f, 2.49044120e-01f, 7.58161470e-02f, -6.19304068e-02f, 9.23049152e-02f, 1.70042202e-01f, -2.71078169e-01f, -2.56715804e-01f, 9.73580182e-02f,
  2.32726634e-01f, -2.79443026e-01f, -2.07189739e-01f, -5.44722565e-02f, 6.14658237e-01f, 8.71026330e-03f, 2.56966978e-01f, 3.78609359e-01f, 3.73257011e-01f, 6.01482749e-01f,
  1.16711140e-01f, 5.47349826e-02f, 6.91490918e-02f, 9.00785387e-01f, 5.60315430e-01f, -3.66284698e-01f, -1.47414729e-01f, 6.10487461e-01f, 4.38279718e-01f, -3.51944119e-01f,
  -1.59605518e-01f, -8.26736391e-02f, 9.20711040e-01f, 2.56963372e-01f, -3.99560183e-01f, -2.88714349e-01f, -1.68842942e-01f, -5.01221955e-01f, -2.83284009e-01f, -2.39184678e-01f,
  -3.80250216e-01f, -4.81452674e-01f, -3.06623459e-01f, 5.85640132e-01f, 1.29783845e+00f, -1.52239963e-01f, 5.16725123e-01f, 1.83752194e-01f, 8.12102437e-01f, 3.23844343e-01f,
  7.91543946e-02f, -4.68853563e-01f, 3.67187232e-01f, -1.43339396e-01f, 3.96078855e-01f, 6.94379270e-01f, -4.72125441e-01f, 5.01839459e-01f, 1.15395749e+00f, -4.28949386e-01f,
  9.61021960e-01f, -2.24255919e-01f, 1.99525267e-01f, -4.01168764e-01f, 1.79263294e-01f, -8.85474011e-02f, -2.32875809e-01f, 6.45243883e-01f, -2.53601193e-01f, 1.04441650e-01f,
  1.90988362e-01f, -1.02793801e+00f, 3.53582263e-01f, 7.49111950e-01f, -1.37202993e-01f, 9.26048517e-01f, 1.11352406e-01f, 1.43811122e-01f, -2.83834904e-01f, -5.27271211e-01f,
  -2.04379916e-01f, 4.21968102e-01f, 7.33078539e-01f, 4.91055489e-01f, 2.44572207e-01f, -8.97937939e-02f, 6.41541004e-01f, -1.38934702e-01f, 3.77997369e-01f, 4.33474600e-01f,
  -2.81215906e-01f, -8.48460317e-01f, 5.19200444e-01f, -2.92468876e-01f, -7.18899071e-03f, 4.94922578e-01f, 5.39217770e-01f, 5.10889292e-01f, 2.63088830e-02f, -1.32366776e-01f,
  3.84970695e-01f, -4.61945832e-01f, -1.63166136e-01f, 6.55270815e-02f, 4.91200164e-02f, -1.03908539e-01f, 8.64366353e-01f, -9.05648619e-02f, -5.64779222e-01f, 3.03617995e-02f,
  -2.71508485e-01f, 3.87608081e-01f, 8.32431853e-01f, -3.83440435e-01f, -2.15832382e-01f, -1.96669176e-01f, -4.20925289e-01f, 1.35368854e-01f, 4.63160835e-02f, -1.49190888e-01f,
  4.56513941e-01f, 1.59977421e-01f, 1.06046915e-01f, -6.61600232e-01f, 1.62886918e-01f, -8.64168555e-02f, 1.11234840e-02f, 1.39265105e-01f, -2.32720643e-01f, 5.83578825e-01f,
  1.55129265e-02f, 4.93144430e-02f, -1.00263923e-01f, 2.46232562e-03f, -7.67547637e-02f, 1.28593832e-01f, 7.47714877e-01f, 1.85352247e-02f, 9.92969424e-02f, -4.98511106e-01f,
  -7.45612057e-03f, 2.42202589e-03f, 1.45972744e-02f, 3.98275942e-01f, -2.44293407e-01f, 4.76086766e-01f, 9.11039039e-02f, 2.62590766e-01f, 1.22244395e-01f, 1.79669246e-01f,
  -9.51769948e-02f, -3.75987589e-01f, 2.66820759e-01f, 1.03835009e-01f, 1.21875420e-01f, 6.57839835e-01f, -1.34892330e-01f, 2.19819352e-01f, -9.71526932e-03f, -2.39447728e-01f,
  1.32145375e-01f, -5.80209978e-02f, 2.92241216e-01f, 3.34617019e-01f, 1.04288134e-04f, -1.85391426e-01f, -1.98949590e-01f, 3.96768957e-01f, 3.02001208e-01f, -4.93503749e-01f,
  -9.66098979e-02f, 3.79437566e-01f, -4.73412663e-01f, 4.04393114e-02f, 1.55659914e-01f, 2.12690160e-01f, -2.07742497e-01f, 4.85141158e-01f, 2.50855625e-01f, -8.93345848e-03f,
  1.15278490e-01f, -1.66301042e-01f, 1.58834472e-01f, 5.12157619e-01f, -4.09538597e-01f, -1.17735311e-01f, -3.11716050e-01f, 2.42306992e-01f, -4.98055607e-01f, 4.13379371e-02f,
  -2.10930020e-01f, 1.65217832e-01f, -2.90473729e-01f, 1.05496752e+00f, 1.91582754e-01f, 5.62879741e-01f, -1.00825265e-01f, -8.47963989e-02f, -3.31109375e-01f, -8.88295174e-01f,
  9.44016352e-02f, 6.51935041e-01f, -1.24988951e-01f, 3.05718035e-01f, 5.96796930e-01f, 5.18396616e-01f, 2.38948062e-01f, -1.69603318e-01f, -3.50094289e-01f, 8.03067684e-02f,
  6.18604064e-01f, 2.14706421e-01f, 3.94704223e-01f, 8.19387659e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.63505644e-01f, -4.80795763e-02f, 8.95745695e-01f, 3.13388795e-01f, 6.30585730e-01f, 4.01422292e-01f, 2.22981572e-01f, 1.54657513e-01f, 3.58256608e-01f, 2.88527310e-01f,
  1.27724871e-01f, 5.60746044e-02f, 2.25276321e-01f, -9.92559418e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -8.85831118e-01f, 4.39131051e-01f, -3.90024111e-03f, -3.76020849e-01f, -3.00670266e-01f, 4.88631338e-01f, 2.69935250e-01f, -1.78704441e-01f, 1.48504034e-01f, 4.21403022e-03f,
  1.27037019e-01f, 1.06532305e-01f, -2.18436271e-01f, -2.70057201e-01f, -5.96251450e-02f, 9.17413712e-01f, -5.51908672e-01f, -4.65988308e-01f, -2.26347759e-01f, 3.33708793e-01f,
  1.26033321e-01f, 1.22405028e+00f, 1.82639226e-01f, -7.42679596e-01f, 6.63280308e-01f, -3.81288528e-01f, -2.97261655e-01f, -4.46246803e-01f, -4.72177535e-01f, -4.84211594e-02f,
  -7.92537108e-02f, -3.34587306e-01f, 4.10402507e-01f, -2.39368081e-01f, -1.33176982e-01f, -1.67365178e-01f, 9.18761715e-02f, -2.86726087e-01f, -7.37175524e-01f, 7.33214796e-01f,
  6.32251143e-01f, -2.29448006e-01f, 4.86509532e-01f, 3.94527346e-01f, 7.94794969e-03f, -3.81808877e-01f, -7.51085341e-01f, 1.85995013e-01f, -3.69369179e-01f, -9.42707360e-01f,
  -1.33273393e-01f, -2.20885485e-01f, -1.93763822e-01f, -3.88824902e-02f, -2.47088417e-01f, 8.75972986e-01f, -8.07283819e-01f, 1.04430318e-01f, -3.84463191e-01f, -3.60850185e-01f,
  4.59023923e-01f, -5.16584873e-01f, -3.80484462e-01f, 7.90048420e-01f, 1.85539778e-02f, -1.07926810e+00f, -8.85664523e-02f, 3.76065999e-01f, -5.01843750e-01f, -5.21190107e-01f,
  6.59927487e-01f, 2.47935876e-01f, -5.64845130e-02f, 1.08342037e-01f, -1.12703674e-01f, 4.50531870e-01f, -4.72628437e-02f, 5.98343052e-02f, -1.92589104e-01f, 1.91799998e-01f,
  1.09096193e+00f, -5.81617296e-01f, -2.34989762e-01f, 1.04389647e-02f, 7.38827944e-01f, 5.43998897e-01f, 8.05979908e-01f, -5.00245869e-01f, -4.02784705e-01f, -4.09493536e-01f,
  3.17268968e-02f, 2.18130633e-01f, -2.13743493e-01f, -3.10938776e-01f, -3.03070873e-01f, -3.21741343e-01f, -6.92552179e-02f, 2.80275732e-01f, 2.93053836e-01f, -3.92387629e-01f,
  2.85949498e-01f, -4.12919372e-01f, -7.25979865e-01f, -6.24644816e-01f, 2.18735382e-01f, -2.37744108e-01f, 2.94978887e-01f, 5.37109315e-01f, -6.87914044e-02f, 7.20487654e-01f,
  6.23469055e-01f, -7.23061740e-01f, -2.19994470e-01f, 3.76101136e-01f, 1.12902224e-01f, 5.30727327e-01f, -6.47956669e-01f, 3.69277209e-01f, -6.13093197e-01f, 5.35126805e-01f,
  -6.29385293e-01f, 3.19707841e-01f, -1.10530876e-01f, -2.32814252e-01f, 3.43387604e-01f, 2.11199880e-01f, 4.29235399e-01f, 3.75253260e-01f, -3.44973564e-01f, 7.88596213e-01f,
  -2.68619806e-01f, -2.10400224e-01f, 1.00330651e+00f, 1.73458025e-01f, -3.99609566e-01f, -8.11740458e-01f, 9.46201235e-02f, 9.36822116e-01f, -1.42559841e-01f, -1.16570719e-01f,
  8.94943774e-02f, 2.64147613e-02f, -8.54264721e-02f, -1.04653403e-01f, 4.29014862e-01f, 3.05207491e-01f, 7.44444504e-02f, 5.54720402e-01f, -6.53778374e-01f, -5.74646711e-01f,
  1.27818167e-01f, 9.24967080e-02f, 6.29200757e-01f, 4.38563004e-02f, 4.22194272e-01f, 5.00642732e-02f, -3.36641043e-01f, -3.80767286e-01f, 8.06407332e-01f, -1.86914623e-01f,
  5.68590462e-01f, 5.09903610e-01f, 9.52493995e-02f, 1.20954983e-01f, -4.93428558e-01f, -7.94277608e-01f, 1.03945565e+00f, -5.98084867e-01f, -4.73497301e-01f, 7.99376607e-01f,
  1.89185426e-01f, 1.76393967e-02f, -1.43658012e-01f, -2.09173396e-01f, -4.65052307e-01f, -5.26038170e-01f, 3.08716923e-01f, 7.60881901e-01f, -1.50152758e-01f, -4.31831867e-01f,
  7.98653781e-01f, 3.69687706e-01f, -5.96722960e-01f, 3.48212838e-01f, -4.17984575e-01f, -4.49958831e-01f, -5.61143041e-01f, -4.88542348e-01f, 1.69919893e-01f, 1.67282149e-01f,
  4.91884112e-01f, -3.02592784e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.48498392e-01f, -2.04500169e-01f, 1.47246987e-01f, -1.21332236e-01f, -7.91339725e-02f, 6.55993700e-01f, 1.38825197e-02f, -5.40548980e-01f, 1.69221405e-02f, 2.04854440e-02f,
  3.09298813e-01f, 2.55019873e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    