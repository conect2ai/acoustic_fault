/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.56117964e-01f, -8.76017436e-02f, 6.29739314e-02f, 3.08181912e-01f, 4.16372046e-02f, -3.20698433e-02f, -5.85398823e-02f, -4.34867963e-02f, 2.72074286e-02f, 9.46552604e-02f,
  -3.23793232e-01f, -4.76212986e-02f, 1.25247538e-01f, 5.28789163e-02f, -3.14287134e-02f, 1.34081855e-01f, 1.09151848e-01f, 4.22642827e-02f, 6.15661405e-03f, -2.57713616e-01f,
  -1.35252118e-01f, -3.47533748e-02f, -1.16118774e-01f, -9.28593650e-02f, 1.67561695e-01f, 2.10963339e-01f, 2.21308827e-01f, -1.05276695e-02f, -3.05748507e-02f, 1.92186624e-01f,
  1.21277303e-01f, -6.23949058e-02f, 6.01000413e-02f, 2.88498104e-02f, -1.51871145e-02f, 4.30320716e-03f, 3.68754119e-02f, -3.11018521e-04f, 3.15722339e-02f, -1.06072938e-02f,
  -5.67676686e-02f, -6.88866675e-02f, 9.01121646e-02f, 2.25702450e-02f, 7.24267494e-03f, -3.64559069e-02f, -2.69108880e-02f, 2.95998305e-02f, -4.90358137e-02f, -1.37820989e-01f,
  -8.04584026e-02f, -8.12986717e-02f, -3.56437080e-02f, -2.86940318e-02f, 9.86248329e-02f, 1.66289926e-01f, 2.30004899e-02f, 5.14564961e-02f, 9.28354636e-02f, 1.25256389e-01f,
  1.44907627e-02f, -8.24654847e-02f, -3.46372575e-02f, 1.50375711e-02f, 4.55693044e-02f, 2.37376951e-02f, -4.16774536e-04f, -2.77285706e-02f, -2.77126115e-02f, 1.06782485e-02f,
  4.14082296e-02f, -5.92262344e-03f, 2.61172000e-02f, 7.78855607e-02f, -5.14754793e-03f, -3.75694595e-02f, -3.26178372e-02f, 3.43291797e-02f, 3.52512044e-03f, 2.90942714e-02f,
  6.56972378e-02f, 2.93092225e-02f, -2.43228264e-02f, 2.59576775e-02f, 2.97802091e-02f, 1.27262354e-01f, -4.78881784e-03f, -7.02062547e-02f, -4.26316299e-02f, -1.30631953e-01f,
  2.30790243e-01f, 9.70495418e-02f, 1.15054607e-01f, 1.56437233e-02f, 6.34264424e-02f, 7.72866532e-02f, 9.78499427e-02f, 1.49483308e-01f, 9.96369943e-02f, 1.09624326e-01f,
  -6.11087270e-02f, 1.07700914e-01f, 8.05363730e-02f, -2.62676459e-02f, 6.80628642e-02f, 3.29703130e-02f, 1.92855261e-02f, 6.34003878e-02f, -2.71553919e-02f, -5.34765571e-02f,
  -3.85433696e-02f, 2.08649524e-02f, 6.81501254e-02f, 9.18591917e-02f, -8.50576442e-03f, 1.44267648e-01f, 4.12647389e-02f, 4.83393297e-02f, 1.56252667e-01f, 1.67192459e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.85431501e-02f, -2.17303514e-01f, -9.51026857e-01f, -4.52425390e-01f, -6.70538962e-01f, -9.33320727e-03f, 4.04051729e-02f, 1.90765113e-01f, 1.25350818e-01f, -3.12306017e-01f,
  -4.29858565e-02f, 1.08125068e-01f, -1.77900687e-01f, -4.84471321e-02f, 6.74460158e-02f, -3.57886076e-01f, -5.90497494e-01f, -5.70636630e-01f, -2.32838199e-01f, 1.94257155e-01f,
  1.20203070e-01f, -3.20095569e-01f, -2.64400244e-01f, -1.40611812e-01f, -4.03294027e-01f, -2.73605496e-01f, -7.43097901e-01f, -5.75044632e-01f, -3.48049074e-01f, -9.55291688e-01f,
  -5.93857110e-01f, -2.96994179e-01f, -1.07678480e-01f, 8.48987550e-02f, -2.62807220e-01f, 1.26268700e-01f, -6.68690205e-02f, -6.81707487e-02f, 5.67457229e-02f, 4.56479304e-02f,
  -1.59211293e-01f, 2.54313927e-02f, -7.49134496e-02f, -1.95245609e-01f, -1.88601822e-01f, 6.37772158e-02f, 3.48507129e-02f, -2.25390762e-01f, -1.90084018e-02f, 1.64523628e-02f,
  -1.89573842e-03f, 1.59814116e-02f, 9.31353644e-02f, 1.80764660e-01f, -7.45649785e-02f, -1.04093000e-01f, -7.08277896e-02f, -5.35484105e-02f, -1.59105942e-01f, 5.64538948e-02f,
  -7.76661858e-02f, -2.18756832e-02f, 7.16292392e-03f, 7.39363655e-02f, 2.33635470e-01f, 9.43117868e-03f, -1.01321757e-01f, 5.94514795e-02f, -1.97519567e-02f, 5.99762052e-02f,
  1.49294278e-02f, 4.30415943e-02f, 9.94605571e-02f, -3.40997018e-02f, -8.08468927e-03f, -3.56616750e-02f, -5.07990783e-03f, 2.16318816e-02f, 1.43852606e-01f, 7.68966973e-02f,
  9.23230425e-02f, -4.80130352e-02f, -2.02722922e-02f, 9.68878448e-04f, 7.17764953e-03f, -2.05069575e-02f, 4.86361943e-02f, 1.61990285e-01f, 2.35943273e-01f, 4.29005772e-02f,
  -4.78231497e-02f, -9.66112018e-02f, -4.52395231e-02f, 1.78667307e-01f, -2.22856492e-01f, -2.26684418e-02f, -5.42378537e-02f, 1.43685862e-01f, 2.55667623e-02f, 3.00903153e-02f,
  3.03323884e-02f, 6.71444312e-02f, -1.68225318e-01f, 9.97075289e-02f, 8.05666845e-04f, 3.30894999e-02f, 1.59287930e-01f, -5.37450537e-02f, 1.24261029e-01f, 1.23321116e-01f,
  8.38238448e-02f, 3.88323843e-01f, 3.10785532e-01f, 1.61767006e-01f, 9.24720312e-04f, -1.54344097e-01f, -6.33603632e-02f, 4.15588096e-02f, 1.79272294e-01f, 3.98767442e-01f,
  -1.10843349e+00f, -6.79589286e-02f, 3.87539029e-01f, -3.35592955e-01f, 2.77410179e-01f, 3.55913639e-01f, 4.48704660e-01f, -2.50604525e-02f, -2.67234147e-01f, -7.80451223e-02f,
  -5.90195097e-02f, -1.93279207e-01f, -1.23622283e-01f, -3.26954736e-03f, -2.87441928e-02f, 4.27171439e-01f, 4.86972451e-01f, 5.51005006e-02f, 2.22073138e-01f, 1.42200783e-01f,
  9.85321775e-02f, -2.78454006e-01f, -5.41778505e-01f, -1.45072877e-01f, -8.45938921e-02f, 4.93259467e-02f, -1.83032677e-02f, -2.21315503e-01f, 8.69989693e-02f, 1.81756333e-01f,
  1.08314618e-01f, -4.65819418e-01f, 1.27607137e-01f, -1.15101494e-01f, -9.32350680e-02f, -2.12814853e-01f, 2.75026448e-02f, -2.58037686e-01f, -1.28836408e-01f, -6.20013475e-02f,
  -1.98638678e-01f, -1.64351091e-01f, 3.73037416e-03f, -5.57354745e-03f, -1.66212901e-01f, -9.89181846e-02f, -5.99154718e-02f, -1.59980655e-01f, -9.14423540e-02f, 1.20112188e-02f,
  8.41663107e-02f, -8.58701766e-02f, -8.83517265e-02f, 1.16175301e-01f, -5.30343801e-02f, -5.88435680e-02f, -2.53270324e-02f, -7.58522600e-02f, -9.11710337e-02f, -1.74224332e-01f,
  -1.82991810e-02f, -5.54515831e-02f, -4.76359986e-02f, 8.23855007e-05f, 8.75289366e-02f, -6.86994474e-03f, 1.13122709e-01f, 3.15034837e-02f, 3.47054452e-02f, -4.65483591e-03f,
  3.59890647e-02f, -1.64549705e-02f, 1.17636099e-01f, -7.64301270e-02f, -2.39082016e-02f, -4.78537865e-02f, -1.93445571e-02f, -2.52721179e-02f, -3.73317190e-02f, -4.91971262e-02f,
  -6.01769350e-02f, 6.43496215e-02f, -9.71401259e-02f, 5.72751574e-02f, 2.50224918e-02f, 5.25238439e-02f, 2.50948500e-02f, -3.42048379e-03f, 1.10838711e-01f, -9.00955275e-02f,
  9.17194933e-02f, -1.09833166e-01f, 1.35372981e-01f, -2.71407962e-02f, -2.23243628e-02f, -1.35257035e-01f, -2.20675170e-02f, 1.54020995e-01f, 1.28986418e-01f, 1.43362120e-01f,
  -2.79951580e-02f, -2.96270158e-02f, -2.50485092e-02f, 6.35714158e-02f, 1.72569007e-01f, -5.70002422e-02f, 6.35731593e-03f, 8.21973607e-02f, 1.06525309e-01f, -2.06533866e-03f,
  -3.07706418e-04f, 1.12133808e-01f, 6.93925470e-02f, 1.51015341e-01f, 5.02269678e-02f, 1.09105289e-01f, 5.57338707e-02f, 2.27596182e-02f, 9.39627662e-02f, 1.05394550e-01f,
  1.41807258e+00f, 8.13645124e-02f, -1.10472262e-01f, 2.43030041e-01f, -2.15540349e-01f, -1.36379018e-01f, -4.46363091e-02f, 1.76386431e-01f, 2.51612872e-01f, 1.61348075e-01f,
  1.43440574e-01f, 3.49652976e-01f, 1.81627497e-01f, 2.49001414e-01f, 2.21966654e-01f, -1.28591970e-01f, -1.49298146e-01f, 6.41646311e-02f, 1.43255845e-01f, 2.23861217e-01f,
  8.54693726e-02f, -5.93610778e-02f, 5.62974960e-02f, -1.64809432e-02f, -7.08735287e-02f, 1.95568755e-01f, -1.81407601e-01f, -2.72043437e-01f, -1.72572255e-01f, -2.79044397e-02f,
  -4.38946270e-04f, 6.68627843e-02f, 2.02770725e-01f, -5.41155785e-02f, -1.95363373e-01f, -4.94898148e-02f, 2.63317954e-02f, -1.43187955e-01f, -7.87414461e-02f, -1.08776651e-01f,
  -2.17484772e-01f, 1.76868606e-02f, 5.88394031e-02f, -1.81094676e-01f, -6.76378310e-02f, -7.27865100e-02f, 5.58843613e-02f, 1.26232848e-01f, 9.68508795e-02f, -1.07569940e-01f,
  -8.48231278e-03f, -1.34444192e-01f, -9.71413627e-02f, -5.45498319e-02f, 7.76124969e-02f, -3.87775525e-02f, -8.02221745e-02f, 3.13071683e-02f, 1.27289623e-01f, 1.63533226e-01f,
  2.60325015e-01f, 6.49734288e-02f, 9.26326811e-02f, 1.25459749e-02f, 1.16000608e-01f, 1.10838071e-01f, 5.21676764e-02f, 3.17207091e-02f, 1.84628382e-01f, -1.51249766e-02f,
  9.11194179e-03f, 3.77934352e-02f, -9.18992385e-02f, 2.02971622e-01f, 2.69567460e-01f, 2.47936323e-02f, -1.21929005e-01f, -6.03328757e-02f, 1.03359148e-01f, -1.53963923e-01f,
  -3.49572813e-03f, -6.96002916e-02f, -1.69020027e-01f, -9.14861113e-02f, -1.03289485e-01f, -1.08219991e-02f, 1.79789234e-02f, 5.99162914e-02f, -5.63849546e-02f, 5.35896569e-02f,
  -5.23301065e-02f, 2.24679112e-01f, 2.02434003e-01f, -8.44788402e-02f, -1.17880404e-01f, -1.23604387e-01f, 1.94479793e-01f, -8.43297169e-02f, -3.36916983e-01f, -1.15327910e-01f,
  -2.17756718e-01f, 5.04008420e-02f, 1.79830175e-02f, -6.71503395e-02f, -2.54144687e-02f, -5.28579541e-02f, -6.49103895e-02f, 1.05961591e-01f, -5.51880747e-02f, -2.01381087e-01f,
  -1.63579416e-02f, 3.90812149e-03f, 2.31285006e-01f, 2.03698322e-01f, 3.67219071e-03f, 1.54643983e-01f, -6.31104410e-02f, 2.05754284e-02f, 1.23185560e-01f, 1.23635158e-01f,
  2.78057069e-01f, -6.20446622e-01f, 2.06256449e-01f, 2.61583179e-01f, 4.58955437e-01f, 4.85120267e-01f, 1.08391084e-01f, 8.65276679e-02f, 3.10355395e-01f, 1.39238819e-01f,
  -1.90456748e-01f, 1.02522492e-01f, 7.57328495e-02f, -5.40228374e-02f, -2.19441261e-02f, 2.08304852e-01f, 3.29769611e-01f, 7.20891729e-02f, 3.37366313e-01f, 2.01362342e-01f,
  1.89633980e-01f, -1.63796589e-01f, -2.24114701e-01f, 2.58190222e-02f, 8.70527420e-03f, 3.63199204e-01f, 3.89367305e-02f, -9.97134820e-02f, -7.16616586e-02f, 7.26664960e-02f,
  4.10307609e-02f, -2.37126172e-01f, 2.59072632e-01f, -5.42579629e-02f, -1.68967143e-01f, -2.09007561e-01f, -7.91687444e-02f, -2.34811634e-01f, -1.43339589e-01f, -1.65924442e-03f,
  -4.96900044e-02f, -1.46863624e-01f, -3.06960568e-02f, -7.32241422e-02f, 2.83603743e-02f, 1.87756792e-02f, -1.98353201e-01f, -2.92735957e-02f, 1.41265944e-01f, -1.03654079e-01f,
  -1.40726447e-01f, 5.75492345e-02f, 2.77489007e-01f, 1.87713131e-01f, 5.73342703e-02f, 1.01300113e-01f, -1.30391032e-01f, 7.56863458e-03f, 1.20873451e-01f, -2.88132299e-02f,
  1.24054700e-01f, 2.19866261e-03f, 7.55502507e-02f, 1.74196288e-01f, 1.01135865e-01f, -1.43589292e-04f, 3.11551932e-02f, 9.20262039e-02f, 8.23456049e-02f, -1.20317817e-01f,
  4.68027703e-02f, 1.89126894e-01f, 2.73864362e-02f, 2.77187563e-02f, -2.03335825e-02f, -3.12475581e-02f, -4.28223843e-03f, -4.51152362e-02f, -9.97547805e-03f, 1.39731720e-01f,
  5.42960353e-02f, 4.04762626e-02f, -9.72870588e-02f, -9.78480186e-03f, 4.61982228e-02f, 7.19595999e-02f, 7.39729553e-02f, -3.26372087e-02f, 5.37825339e-02f, -7.22115487e-02f,
  -1.34476826e-01f, 2.35379383e-01f, -6.65553939e-03f, 1.00688618e-02f, -4.83156480e-02f, -2.14922875e-01f, 8.02515075e-02f, -8.74765217e-02f, -7.79422298e-02f, 3.94050293e-02f,
  -9.17678997e-02f, -2.17321515e-02f, -2.14664921e-01f, -1.57492265e-01f, -1.75403971e-02f, -5.85254729e-02f, -2.60552883e-01f, 3.65600325e-02f, -1.14067830e-01f, -1.48592710e-01f,
  -1.78605884e-01f, 2.40174055e-01f, 3.63481611e-01f, 8.83266777e-02f, 2.91428231e-02f, 2.79690653e-01f, 2.57964414e-02f, -1.47267813e-02f, 1.30133182e-01f, -1.15215266e-02f,
  8.16859126e-01f, 3.69031101e-01f, -3.67385559e-02f, 2.37399846e-01f, -1.41306564e-01f, -2.56230384e-01f, -1.04776137e-01f, -1.22601323e-01f, 2.28877410e-01f, 2.51772523e-01f,
  1.54753685e-01f, 2.56724775e-01f, 1.92696929e-01f, 8.77994820e-02f, 5.26493602e-02f, -5.45328856e-02f, -9.09396354e-03f, -8.26923326e-02f, -3.02600991e-02f, 1.30305111e-01f,
  2.11589977e-01f, 7.15371687e-03f, -2.81530414e-02f, -1.88092455e-01f, 9.89494696e-02f, 7.91753754e-02f, -9.66923088e-02f, -6.02912903e-02f, 1.03793353e-01f, 3.73475313e-01f,
  1.68951079e-01f, -3.08039039e-02f, 1.47153605e-02f, -3.53226587e-02f, -1.72861829e-01f, -4.36445847e-02f, -2.50386950e-02f, 1.88275501e-02f, -1.23531511e-02f, 4.94213551e-02f,
  -1.24238126e-01f, -1.47516444e-01f, -2.26780251e-01f, 6.07716898e-03f, -1.08219005e-01f, -7.94134885e-02f, 6.96436465e-02f, 2.65372783e-01f, 1.04794234e-01f, -5.95830902e-02f,
  1.10926181e-01f, -1.90838408e-02f, -2.37761326e-02f, -1.30972415e-02f, -4.18927185e-02f, -8.28848686e-03f, 4.05413099e-02f, -1.20514836e-02f, -1.67959873e-02f, 2.67603666e-01f,
  -3.41482572e-02f, 1.03372350e-01f, -2.46938970e-03f, 4.41334955e-02f, 7.78714940e-02f, -9.21202153e-02f, -4.22151051e-02f, 2.27658916e-02f, 2.80734096e-02f, -1.32072806e-01f,
  8.57784227e-02f, 1.23862050e-01f, 3.73224802e-02f, -4.23780978e-02f, -7.76522309e-02f, -5.48836924e-02f, 5.82299381e-02f, -2.00036690e-02f, -1.82902157e-01f, 8.44734088e-02f,
  -1.18788639e-02f, -6.24037571e-02f, -3.28920960e-01f, -1.91524535e-01f, 2.63611022e-02f, -2.15338487e-02f, 9.77147836e-03f, 1.95806399e-02f, -1.64767265e-01f, 9.25245807e-02f,
  2.31777623e-01f, -2.64810652e-01f, 1.96428448e-01f, 1.43285856e-01f, 3.90751958e-02f, -1.25137985e-01f, 9.68258902e-02f, -2.60855956e-03f, -2.08628140e-02f, 1.06474638e-01f,
  -1.16452217e-01f, -1.13400035e-01f, -1.59606144e-01f, -7.52216056e-02f, -2.26168722e-01f, -1.55563056e-01f, 2.22493082e-01f, 2.19071373e-01f, 1.26149058e-01f, -5.57452887e-02f,
  3.91106587e-03f, 1.73021909e-02f, 1.85808614e-01f, 1.05388314e-02f, 3.91416475e-02f, -6.45607188e-02f, -6.35784641e-02f, -5.80463442e-04f, -2.68429250e-01f, -1.53416339e-02f,
  5.10145009e-01f, 6.25765383e-01f, 1.49822131e-01f, 2.05151424e-01f, -1.87697411e-01f, -2.80411243e-01f, -3.25520247e-01f, -1.89105272e-01f, 2.64182221e-02f, 1.55292958e-01f,
  1.24268904e-01f, 8.15251991e-02f, 8.14580079e-03f, 9.31848511e-02f, -5.91400675e-02f, 2.13687513e-02f, 1.99254155e-01f, 1.26417652e-01f, -2.37817675e-01f, -3.87239754e-02f,
  2.78432131e-01f, 1.32734925e-01f, 2.65727311e-01f, -2.01045498e-02f, 3.61513495e-01f, 1.59939319e-01f, 2.14051574e-01f, 4.15300012e-01f, 3.74631733e-01f, 6.80712759e-01f,
  4.31170642e-01f, 3.02099824e-01f, -4.09300178e-01f, -1.05138861e-01f, 8.20037276e-02f, -1.06558584e-01f, -9.38717797e-02f, -1.24277808e-01f, -1.32273242e-01f, -8.35116208e-03f,
  2.18172614e-02f, 2.02791225e-02f, 3.09895538e-02f, 5.36804162e-02f, -8.29312578e-02f, -3.48501764e-02f, -1.31058529e-01f, -1.32400721e-01f, -2.12166518e-01f, -4.43393029e-02f,
  2.07753964e-02f, 1.39328197e-01f, -1.03008404e-01f, -2.50930160e-01f, -5.27294315e-02f, -1.70555431e-02f, 6.91550151e-02f, 1.85743541e-01f, 4.76320535e-02f, 3.57871890e-01f,
  1.58460155e-01f, 3.77991125e-02f, 1.52568445e-01f, 2.19863430e-01f, 2.00019956e-01f, -2.46254820e-02f, 1.55243695e-01f, -1.45053184e-02f, 1.37048289e-02f, 2.07282283e-04f,
  8.64558518e-02f, -2.82514431e-02f, -3.51468027e-02f, 3.24207917e-02f, 1.55732026e-02f, 3.96069922e-02f, -2.69919224e-02f, 8.32008868e-02f, 5.08246236e-02f, 2.63420064e-02f,
  7.30137751e-02f, -1.84233829e-01f, 5.35165854e-02f, -2.40431149e-02f, -2.70639658e-02f, -2.01529195e-03f, 6.32451326e-02f, -1.89440288e-02f, 1.20670438e-01f, 1.31617844e-01f,
  -4.18058366e-01f, -5.13842702e-01f, 9.87615734e-02f, -2.30886377e-02f, 1.73677281e-01f, 3.98328416e-02f, 1.60830896e-02f, -2.11365446e-02f, 6.46278709e-02f, 1.39282703e-01f,
  -4.64699119e-02f, -1.15511693e-01f, 1.37308776e-01f, -5.23071401e-02f, -1.88699141e-01f, -2.22519144e-01f, 2.06342507e-02f, -9.31475535e-02f, -8.42546225e-02f, -4.65354919e-02f,
  -1.30861968e-01f, -1.58092886e-01f, -3.69579017e-01f, -2.17553064e-01f, -4.71386313e-02f, -1.73259363e-01f, -1.78189918e-01f, -1.68242753e-01f, -2.08129153e-01f, -2.39939883e-01f,
  -1.50511906e-01f, 6.39954135e-02f, -2.80783474e-02f, 5.79447299e-02f, -4.31721866e-01f, -8.05302322e-01f, -7.19031453e-01f, -5.75082362e-01f, -1.10422693e-01f, -5.25814481e-02f,
  -1.38853742e-02f, 3.16885233e-01f, 5.63580632e-01f, 3.78020070e-02f, -1.34336710e-01f, -4.04011719e-02f, 1.14194162e-01f, 1.66259408e-01f, -4.32348043e-01f, -7.12069929e-01f,
  -1.64891168e-01f, 4.00357217e-01f, 5.28231442e-01f, -8.54600966e-02f, -1.30092546e-01f, 1.27556911e-02f, 4.29113716e-01f, 1.21916607e-01f, -8.61162171e-02f, 7.71633089e-02f,
  1.70347571e-01f, -7.15092301e-01f, -1.33680105e-01f, 1.15252346e-01f, 1.49164930e-01f, -1.38640210e-01f, -2.87303001e-01f, -2.62464676e-02f, -2.47032061e-01f, 1.42947435e-01f,
  -1.14495635e-01f, -6.18089549e-02f, -5.82603589e-02f, 1.25938803e-01f, -5.52197918e-02f, -2.35175952e-01f, 8.52103755e-02f, -1.98674276e-01f, -3.32882777e-02f, -1.56150222e-01f,
  5.82904443e-02f, -2.58784980e-01f, -1.91752806e-01f, -1.64001137e-01f, -3.72962147e-01f, 7.52574876e-02f, -2.31794760e-01f, -5.24702728e-01f, -3.09762418e-01f, 3.87616679e-02f,
  -4.93924432e-02f, 3.27735059e-02f, -3.33580822e-02f, 1.67632461e-01f, 8.18475112e-02f, 1.04661666e-01f, 1.11198865e-01f, 8.24196041e-02f, -1.68212818e-03f, 9.41068530e-02f,
  -4.92867641e-02f, -1.62536595e-02f, 9.24678221e-02f, -1.06138952e-01f, -1.10581592e-01f, -5.17571829e-02f, -1.11369461e-01f, 6.52323291e-02f, -2.39281222e-01f, 1.17805243e-01f,
  1.17121533e-01f, -6.84641525e-02f, -8.30417499e-03f, -2.09350372e-03f, -4.77951132e-02f, -4.01500650e-02f, 1.08915128e-01f, 4.07246836e-02f, 1.08176179e-01f, 5.02962917e-02f,
  6.82579219e-01f, -9.05551910e-02f, 3.20407867e-01f, -4.60492857e-02f, -2.99823768e-02f, -8.19241907e-03f, 1.91715136e-01f, 1.57539267e-02f, 2.07207263e-01f, -1.68023273e-01f,
  -2.54009962e-01f, -2.67023325e-01f, 1.31125271e-01f, 9.80014205e-02f, -1.49093822e-01f, -1.16301417e-01f, 1.06020914e-02f, 3.63084227e-02f, 8.67374986e-02f, -8.37978050e-02f,
  3.50816280e-01f, 9.42641795e-02f, 9.42576528e-02f, 2.69997060e-01f, -6.35645017e-02f, 5.02579920e-02f, 1.37955934e-01f, 1.03001580e-01f, 8.08407366e-03f, 4.82368499e-01f,
  -7.05996990e-01f, 2.91373670e-01f, 8.86790305e-02f, -2.29947135e-01f, 5.32259166e-01f, 1.71072304e-01f, 1.21080749e-01f, -1.11455299e-01f, -6.98112249e-02f, 1.68101758e-01f,
  6.81476712e-01f, 3.69454436e-02f, 9.89237353e-02f, -3.79087701e-02f, -3.11104417e-01f, 1.40031874e-01f, 8.80610347e-02f, -5.00620484e-01f, -3.45302105e-01f, 4.96830307e-02f,
  4.02858928e-02f, -2.47051507e-01f, -6.12593949e-01f, -1.32786497e-01f, 1.49235293e-01f, -1.33407220e-01f, 7.87372142e-02f, -1.01342499e-01f, 8.38980302e-02f, -1.23499252e-01f,
  1.65691838e-01f, 2.18802705e-01f, -2.47802474e-02f, 8.77467692e-02f, 2.08037883e-01f, -1.73869848e-01f, -1.48610368e-01f, 6.28638640e-02f, 1.02219403e-01f, -5.72971143e-02f,
  1.53411791e-01f, -1.91744193e-02f, 6.14392944e-02f, -8.80693346e-02f, -1.35227785e-01f, -2.95930952e-01f, -1.00500390e-01f, -4.68243927e-01f, -3.69854063e-01f, -2.20333785e-01f,
  1.42484263e-01f, 3.26618850e-01f, 2.90741790e-02f, -1.24675162e-01f, -1.02292500e-01f, -7.56011531e-02f, 2.29060929e-03f, -1.67211354e-01f, -3.53319108e-01f, -4.41615641e-01f,
  -1.62354082e-01f, 1.61995605e-01f, 1.46427944e-01f, 6.01659827e-02f, 1.64130442e-02f, 2.20714390e-01f, 3.02390158e-02f, 2.36124825e-02f, 1.11396097e-01f, -1.29694939e-01f,
  9.80849117e-02f, 1.51315033e-01f, -3.99139822e-02f, -1.15849692e-02f, 1.23346649e-01f, 1.36151013e-03f, 5.72063364e-02f, -1.14194952e-01f, -2.86213458e-02f, -1.32680222e-01f,
  -1.21962264e-01f, -1.49205029e-01f, 5.88331223e-02f, -1.81348830e-01f, 3.81047241e-02f, 5.66247553e-02f, 5.35113700e-02f, 1.78812087e-01f, 1.16932474e-01f, -1.29633527e-02f,
  -3.04753035e-01f, 8.67351517e-02f, -7.24111274e-02f, 1.63827781e-02f, -4.16533239e-02f, -1.19061507e-01f, 5.77150248e-02f, 1.37849346e-01f, 8.57678577e-02f, -1.51180446e-01f,
  -1.12303950e-01f, -1.45048380e-01f, -9.80680529e-03f, 3.19436826e-02f, -2.24231094e-01f, -6.77553145e-03f, 3.77360731e-02f, -3.92225347e-02f, -7.44905025e-02f, -2.18705952e-01f,
  -1.19102113e-01f, -3.92939508e-01f, -3.61052454e-01f, -4.54316348e-01f, -2.37191498e-01f, -2.59686738e-01f, -1.98786408e-01f, -3.72068703e-01f, -4.45874661e-01f, -7.50082254e-01f,
  2.48855084e-01f, 3.36991161e-01f, 2.48730198e-01f, 2.12293476e-01f, 4.07903612e-01f, 5.20618021e-01f, 6.91911399e-01f, 2.79022455e-01f, 8.47265944e-02f, 1.61565334e-01f,
  -6.59854785e-02f, -3.99663329e-01f, -3.12394798e-01f, -2.76970625e-01f, -1.11232221e-01f, 2.25438491e-01f, 2.17977643e-01f, -1.83003489e-02f, -1.43245663e-02f, -8.86709057e-03f,
  3.80076878e-02f, 2.40402028e-01f, -2.58251671e-02f, 2.84498297e-02f, -1.38957761e-02f, -2.10543871e-01f, 1.01530299e-01f, 4.92635891e-02f, 2.08562426e-02f, 3.80001105e-02f,
  -4.94265795e-01f, 2.49612153e-01f, -3.87389123e-01f, -3.93849641e-01f, -1.60053432e-01f, -2.77573392e-02f, -1.69272106e-02f, -1.23742320e-01f, -6.82417750e-02f, 1.85215119e-02f,
  -3.90988328e-02f, -5.24350442e-02f, 1.96055785e-01f, 3.28260660e-02f, 1.54496849e-01f, -2.83845831e-02f, -1.60094351e-02f, -6.16469644e-02f, -1.67781129e-01f, -1.17963448e-01f,
  -1.71891861e-02f, 1.97073430e-01f, 2.83940762e-01f, 3.25557515e-02f, -1.97688304e-02f, -1.65616367e-02f, -5.45868278e-02f, -1.09638376e-02f, -1.94833968e-02f, -8.98871347e-02f,
  -3.02824408e-01f, -1.03390642e-01f, 1.03646725e-01f, 1.02729782e-01f, 2.53863215e-01f, -3.16975228e-02f, -3.76073793e-02f, 9.98508558e-02f, 1.32307798e-01f, 1.88962966e-01f,
  -9.44786053e-03f, -2.20163707e-02f, 1.40429273e-01f, -4.10295837e-03f, -4.60982956e-02f, 5.82149513e-02f, 8.55840966e-02f, 1.69716310e-02f, -6.28711581e-02f, 6.79168776e-02f,
  1.46207139e-01f, 2.06380635e-01f, 1.43780345e-02f, 1.96193278e-01f, -7.72609860e-02f, -1.22602340e-02f, 1.14187568e-01f, -2.03181859e-02f, 6.45755082e-02f, 1.01640329e-01f,
  5.14921807e-02f, -1.52064413e-01f, -2.51820534e-01f, -1.04567833e-01f, 5.64413667e-02f, -1.06574304e-01f, -3.46036144e-02f, -1.29259020e-01f, -1.15922503e-01f, -3.78732979e-02f,
  -1.72547102e-01f, -3.37770544e-02f, 9.58506465e-02f, 1.69816568e-01f, 1.23434342e-01f, 2.06718482e-02f, -3.45702954e-02f, -4.51506786e-02f, -3.67053822e-02f, -2.32558340e-01f,
  -4.37817313e-02f, 1.82772562e-01f, 7.44365826e-02f, 6.57614991e-02f, 2.44467929e-02f, -2.43239589e-02f, -6.28296612e-03f, 5.35761900e-02f, 4.02925983e-02f, 7.53147751e-02f,
  -5.34979582e-01f, -5.14515936e-01f, -2.98121348e-02f, -1.20484459e+00f, -6.71068609e-01f, -2.46601537e-01f, -6.50393546e-01f, -3.69301379e-01f, -6.45306587e-01f, -8.16347182e-01f,
  -8.17242078e-03f, 6.38521016e-01f, 3.78541976e-01f, 4.46104199e-01f, 3.18679929e-01f, -7.88408220e-01f, -1.02440464e+00f, -1.38216272e-01f, 4.02232409e-01f, -1.12212017e-01f,
  -5.35084009e-01f, -6.99757695e-01f, -2.52812564e-01f, -1.66831762e-01f, -3.40538085e-01f, 4.09798056e-01f, -2.86732197e-01f, -1.62312776e-01f, 3.07323068e-01f, -4.17382628e-01f,
  4.06568915e-01f, 1.33464232e-01f, 7.80675709e-02f, 9.04269740e-02f, -2.23353989e-02f, 1.23306118e-01f, 9.73059386e-02f, -9.75136086e-02f, 1.44730657e-01f, -1.33480325e-01f,
  -1.08508751e-01f, -1.49824060e-02f, -7.96629116e-02f, -1.53440414e-02f, -4.03721005e-01f, -1.87849760e-01f, -1.26533940e-01f, 3.92680280e-02f, -2.00616017e-01f, 2.82216445e-03f,
  -3.61497790e-01f, -3.25447395e-02f, 3.17159683e-01f, 1.07033916e-01f, 2.76011914e-01f, 1.02116823e-01f, 8.85295644e-02f, 1.63059756e-01f, 3.10783267e-01f, -1.98198378e-01f,
  -7.91520849e-02f, -9.78268031e-03f, 1.53332338e-01f, 3.24117057e-02f, 5.82057722e-02f, -2.45447401e-02f, 1.80425897e-01f, 5.00781015e-02f, -9.86104012e-02f, 1.30273834e-01f,
  -7.78360739e-02f, -3.19323912e-02f, 1.77502990e-01f, 1.45731606e-02f, -1.04509085e-01f, -2.13282973e-01f, -1.18639164e-01f, 1.19427145e-02f, 1.53095657e-02f, -1.13602764e-05f,
  -8.73400196e-02f, 1.66433528e-01f, -2.60023754e-02f, 1.48531869e-01f, -1.21533513e-01f, -2.23986983e-01f, -4.93113883e-02f, 3.70592177e-02f, 5.70220537e-02f, 1.12220626e-02f,
  7.22454041e-02f, 1.71225965e-01f, -2.24726781e-01f, 2.17799872e-01f, 3.53634991e-02f, 3.62388529e-02f, -6.55648671e-03f, -7.78181851e-03f, 2.08819881e-02f, -6.44382760e-02f,
  1.03592306e-01f, -8.89350399e-02f, 3.82083207e-02f, 1.54741555e-01f, -4.14901413e-02f, -1.14767805e-01f, -3.05193931e-01f, -2.19638292e-02f, 1.86895862e-01f, -2.08939284e-01f,
  -2.03985527e-01f, -3.80918682e-02f, 2.63306070e-02f, 1.27010375e-01f, -4.12464738e-02f, 1.95763275e-01f, 9.96390507e-02f, 3.37820463e-02f, 2.22905427e-01f, -3.33645314e-01f,
  -6.39932334e-01f, 5.45250893e-01f, 4.17733900e-02f, -2.12058067e-01f, 3.50801289e-01f, 2.79266208e-01f, 6.40940607e-01f, 2.34712586e-01f, -9.63387415e-02f, 7.86374733e-02f,
  5.33707291e-02f, -2.41250023e-01f, -1.04221866e-01f, -5.57696372e-02f, -1.01757674e-02f, 4.48752254e-01f, 3.37576002e-01f, -2.60666192e-01f, -3.94185364e-01f, -2.57153898e-01f,
  8.77485126e-02f, -1.46751449e-01f, -5.27841985e-01f, -2.74005413e-01f, 6.48248792e-02f, -6.22301288e-02f, 1.75452769e-01f, 5.66091686e-02f, 2.19595477e-01f, 1.38701856e-01f,
  -4.83577549e-01f, -3.54118273e-02f, 5.43374941e-02f, -4.95079681e-02f, 1.39651378e-03f, -1.78964764e-01f, -1.18670203e-01f, -2.36388624e-01f, -1.23212695e-01f, -1.04836613e-01f,
  1.46437004e-01f, -8.38037638e-04f, 1.49345130e-01f, 1.52927428e-01f, -7.32146576e-02f, -9.17957127e-02f, -6.31761039e-03f, -2.02132672e-01f, 1.15823425e-01f, 3.78215872e-02f,
  3.59952033e-01f, -5.83452098e-02f, -1.40807936e-02f, 1.91122815e-01f, 1.28481045e-01f, -1.68376938e-01f, 1.09417960e-01f, -9.23539102e-02f, 6.35680631e-02f, -2.24668235e-01f,
  2.67807469e-02f, -1.14723571e-01f, 9.55660269e-02f, -4.07306179e-02f, -4.95662056e-02f, 6.07528277e-02f, 4.34512198e-02f, 6.49240054e-03f, 3.97957452e-02f, -9.43282694e-02f,
  -3.94544285e-03f, -1.98691655e-02f, -1.70722216e-01f, 1.43545456e-02f, -4.32759747e-02f, 1.09341010e-01f, -2.57191993e-02f, 8.64733458e-02f, -7.00714663e-02f, 1.55795598e-02f,
  -3.40182148e-02f, -5.82050756e-02f, 2.41271183e-02f, -1.01620756e-01f, 1.22375190e-01f, -9.98746008e-02f, -6.42746985e-02f, -9.92405638e-02f, -1.00550234e-01f, -2.96520088e-02f,
  -7.25185275e-02f, 2.40262479e-01f, -1.92496434e-01f, 7.09406734e-02f, 1.92141347e-02f, -2.15900131e-02f, -3.90465781e-02f, -1.39649302e-01f, -9.16558802e-02f, -1.87525794e-01f,
  -3.50526683e-02f, -2.05936320e-02f, 4.61537912e-02f, -8.69715810e-02f, -2.19381049e-01f, 1.80705562e-02f, 1.26342103e-01f, 4.26680781e-02f, 6.05501123e-02f, 1.82845015e-02f,
  2.64589012e-01f, -8.98218825e-02f, -2.51985013e-01f, -5.08334525e-02f, -8.31135921e-03f, -3.63961697e-01f, -1.49269864e-01f, -6.48298115e-03f, -8.03618580e-02f, -6.14911988e-02f,
  1.56052917e-01f, 1.13062806e-01f, 5.87274313e-01f, -2.55432516e-01f, -1.25203631e-03f, -1.38322696e-01f, 3.01207870e-01f, 1.02532774e-01f, -2.69848377e-01f, 2.51086473e-01f,
  -1.43512473e-01f, -6.79375827e-01f, -2.55272418e-01f, -3.36108178e-01f, -1.26398489e-01f, 1.53822601e-01f, 2.80207932e-01f, 2.51217693e-01f, 2.68955119e-02f, -3.53100687e-01f,
  -3.49181026e-01f, 1.37487695e-01f, 3.10002029e-01f, 1.35615021e-01f, -1.29292414e-01f, -2.24938318e-01f, 4.74012941e-01f, 1.67998392e-02f, -1.41606823e-01f, -1.34547651e-01f,
  3.03290170e-02f, 2.84999698e-01f, -1.74227618e-02f, -1.60684809e-01f, -5.83177730e-02f, 5.36257401e-02f, 6.79502338e-02f, 6.93518147e-02f, -6.14599958e-02f, 3.52992080e-02f,
  -1.10683851e-01f, -6.62798584e-02f, -1.72282234e-01f, -1.29647717e-01f, 6.04058392e-02f, -2.08420336e-01f, 1.60837665e-01f, 1.08072087e-01f, 1.06942423e-01f, -9.64093804e-02f,
  -2.79917091e-01f, -3.47419605e-02f, 2.14376211e-01f, -1.10906092e-02f, -2.38942951e-02f, -1.78600252e-02f, 9.58253294e-02f, -5.88359237e-02f, 1.41905382e-01f, 1.00433985e-02f,
  -1.94439255e-02f, 6.44816756e-02f, 1.58994161e-02f, 1.38654292e-01f, -1.54579012e-02f, 3.70540842e-02f, 2.27297358e-02f, 5.42450100e-02f, -6.20389134e-02f, 1.27750367e-01f,
  6.65987432e-02f, 1.70063879e-02f, 2.15635765e-02f, 6.79465532e-02f, -3.85146290e-02f, 6.05075322e-02f, -9.41710845e-02f, 3.60443853e-02f, 5.43135032e-02f, 6.81871325e-02f,
  -8.76586065e-02f, -4.89605181e-02f, 1.79752912e-02f, -1.23185873e-01f, -8.12877268e-02f, -1.89982485e-02f, -1.35452524e-01f, -7.28695691e-02f, 2.34072860e-02f, 1.38952732e-01f,
  -1.59806773e-01f, 2.93061323e-02f, -5.24105132e-02f, -4.20778990e-02f, 7.27697462e-02f, -2.68945359e-02f, 1.46947112e-02f, -4.08451781e-02f, 8.84663016e-02f, -8.73548090e-02f,
  3.72511824e-03f, 5.95566332e-02f, 7.04735145e-02f, 1.52682895e-02f, -1.32154778e-01f, -5.89232706e-02f, -5.76160774e-02f, -2.72968411e-02f, -1.26205474e-01f, 3.61088216e-02f,
  -1.28386334e-01f, 1.19241076e-02f, -4.08664271e-02f, -7.83077702e-02f, -9.11257565e-02f, -1.34340897e-01f, 1.46786213e-01f, -3.15808281e-02f, -1.61703736e-01f, 1.09065145e-01f,
  -1.09942400e+00f, 3.95623744e-01f, -3.92502807e-02f, -5.60963213e-01f, -3.21212798e-01f, -2.40660429e-01f, 1.20077057e-04f, 1.76225871e-01f, -1.32944733e-02f, 4.96903807e-01f,
  2.37014115e-01f, -1.21951379e-01f, -6.93252236e-02f, -1.40092522e-01f, -4.59172547e-01f, 6.59731552e-02f, -2.69217998e-01f, -8.02570105e-01f, -7.06949055e-01f, -1.67194813e-01f,
  -2.45294020e-01f, -6.75277412e-01f, -7.42143989e-01f, -1.76541254e-01f, 3.12607616e-01f, -1.86887980e-02f, 2.71256030e-01f, -2.03934550e-01f, -5.37549742e-02f, 4.35065255e-02f,
  2.57905155e-01f, -3.03198010e-01f, -1.39455676e-01f, -2.57894814e-01f, -1.90481115e-02f, -1.15981698e-01f, 5.81771955e-02f, 1.22202802e-02f, -3.84907238e-02f, 2.18826815e-01f,
  -7.45079368e-02f, 4.06665727e-02f, -1.55749038e-01f, 8.50147847e-03f, 1.12489713e-02f, -2.65835840e-02f, 4.45330329e-02f, -1.77208185e-01f, 5.27199171e-02f, 3.78637135e-01f,
  2.07575709e-01f, -1.56139871e-02f, -3.45274881e-02f, 1.06450200e-01f, 4.45885025e-02f, -1.29471451e-01f, 1.43147618e-01f, 1.43222973e-01f, 1.01792514e-01f, 2.34541088e-01f,
  7.90980384e-02f, 7.01317787e-02f, 4.23119776e-03f, -1.15089461e-01f, 1.15140609e-01f, -3.31462137e-02f, 3.90325412e-02f, 3.33830789e-02f, -5.14773354e-02f, 2.26385780e-02f,
  -5.22067130e-04f, 1.11877069e-01f, 2.04157084e-03f, 4.83461060e-02f, 1.19489625e-01f, -1.15016215e-01f, -9.96722206e-02f, 1.24351859e-01f, 3.06164660e-02f, -6.56769946e-02f,
  -2.08599910e-01f, 2.92221066e-02f, 4.79191467e-02f, 1.19425237e-01f, 2.36532986e-02f, 5.53313876e-03f, 3.61949578e-02f, 1.23211846e-01f, 3.15031037e-02f, -9.67302397e-02f,
  1.11783385e-01f, -5.59329271e-01f, 1.23615548e-01f, -4.17726636e-02f, -6.72368705e-02f, 7.85890371e-02f, 2.26438977e-02f, -4.38943021e-02f, -1.20607898e-01f, 1.06952772e-01f,
  -1.49441138e-02f, 4.07631248e-02f, 5.09458743e-02f, 6.08443134e-02f, -5.63446507e-02f, -5.64168096e-02f, 3.69359776e-02f, -8.24357942e-02f, -3.56632657e-02f, 2.50432551e-01f,
  1.36105925e-01f, 2.68295687e-02f, -1.08145766e-01f, 4.95097451e-02f, 5.60222231e-02f, -2.36427829e-01f, 8.10495615e-02f, 1.57582268e-01f, -5.27880602e-02f, 3.03230464e-01f,
  4.01370704e-01f, -2.01886877e-01f, -7.79005527e-01f, 4.64912593e-01f, 7.04928935e-02f, -1.25301436e-01f, -3.23531717e-01f, -1.55728087e-01f, 3.63369375e-01f, -1.15416579e-01f,
  1.20447047e-01f, 8.83630514e-02f, -3.08668137e-01f, -3.14769536e-01f, -4.99821454e-01f, -6.88424408e-01f, -5.68359435e-01f, -7.04690814e-01f, -4.01153982e-01f, 2.95528173e-01f,
  4.06727791e-01f, 3.93859297e-02f, 6.92371577e-02f, -1.88687904e-04f, 2.34268323e-01f, 3.43476161e-02f, -3.64808768e-01f, 1.29855573e-02f, -2.72937626e-01f, -1.49835289e-01f,
  -3.19497824e-01f, -3.90717387e-02f, -8.16830173e-02f, 1.52201682e-01f, -3.53238173e-02f, -1.41064525e-01f, 8.49736407e-02f, -1.30909771e-01f, 1.59707088e-02f, 1.08673550e-01f,
  -9.81958807e-02f, -1.46843363e-02f, 9.00258496e-02f, -2.84571256e-02f, 7.77003169e-02f, -4.11596261e-02f, -2.03279197e-01f, -2.58946121e-01f, -3.55475664e-01f, -1.68471888e-01f,
  2.60592967e-01f, -5.38983792e-02f, -3.36444616e-01f, -3.67056653e-02f, -1.56747088e-01f, -2.72309333e-01f, -6.51510805e-02f, 7.78055340e-02f, -2.98186988e-01f, 4.22132015e-02f,
  -8.57655704e-03f, -8.55823010e-02f, -8.81002098e-02f, 7.68487006e-02f, 2.67339516e-02f, 2.04450488e-01f, 7.84002766e-02f, -2.72933710e-02f, 7.49289840e-02f, -1.59377158e-02f,
  -4.18022741e-03f, 3.72524969e-02f, -5.99565101e-04f, 2.92529091e-02f, -3.62471445e-03f, 7.11443797e-02f, -5.32614887e-02f, -6.57465681e-02f, -1.33534551e-01f, -1.27443578e-02f,
  -3.42889279e-02f, 7.10121617e-02f, 1.59334783e-02f, -2.25393195e-02f, -1.34350106e-01f, -1.27517268e-01f, -1.15610667e-01f, -9.26871225e-02f, -6.16372339e-02f, -4.57831211e-02f,
  3.22976351e-01f, -2.97150254e-01f, 1.27695546e-01f, -1.25205815e-01f, 6.28431365e-02f, -1.37783978e-02f, -1.26097584e-02f, -9.24995020e-02f, 1.67095259e-01f, 2.92160641e-02f,
  1.25359539e-02f, 1.24213211e-01f, 7.41506666e-02f, -9.89528745e-02f, 4.74799164e-02f, 1.45890433e-02f, -4.33152430e-02f, -1.65225510e-02f, 4.15160670e-04f, 1.96600154e-01f,
  -2.71298885e-02f, -1.62475690e-01f, -3.07987686e-02f, -5.40360659e-02f, 7.32157901e-02f, -1.40392929e-01f, -5.29454984e-02f, 1.12087503e-02f, -3.69109064e-01f, 1.13989515e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.20843399e-01f, 3.38014007e-01f, 6.22571647e-01f, 1.84391871e-01f, 2.90454589e-02f, 5.28254032e-01f, 9.39278424e-01f, 4.92320299e-01f, 6.93054557e-01f, 6.89459682e-01f,
  2.86323845e-01f, 1.05500543e+00f, 7.64089763e-01f, 2.58924395e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.33445451e-01f, 1.88608527e-01f, -9.68161598e-02f, -4.81786072e-01f, 2.89481640e-01f, -2.64130503e-01f, -1.41979367e-01f, 3.16953808e-01f, -4.12508324e-02f, 4.27192897e-02f,
  -1.40253291e-01f, 1.01470314e-01f, -3.93790543e-01f, 1.43203929e-01f, 1.53176844e-01f, 2.87254572e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.59253412e-01f, 4.76662740e-02f, -6.33720532e-02f, 1.04922855e+00f, -4.02102411e-01f, 8.59604031e-02f, -3.22412342e-01f, 5.55927567e-02f, 2.29679823e-01f, 5.55005431e-01f,
  1.12172127e-01f, 3.77740741e-01f, 6.68679714e-01f, 6.69787049e-01f, 3.37185591e-01f, -5.45117497e-01f, 2.49804646e-01f, 3.40916365e-01f, 6.05672061e-01f, -4.40573841e-01f,
  6.88545167e-01f, 2.05931321e-01f, 5.34784734e-01f, 4.20772105e-01f, 3.43064010e-01f, -4.74506140e-01f, 4.82946247e-01f, 3.09761643e-01f, -5.03300965e-01f, -2.96190411e-01f,
  -7.86409914e-01f, 3.10169756e-01f, -5.69035411e-02f, 3.10000658e-01f, 3.89866501e-01f, 8.15547585e-01f, 6.11056983e-01f, 7.40302384e-01f, 1.72900856e-01f, -1.79270040e-02f,
  -1.88721031e-01f, 4.18494791e-02f, -2.60257833e-02f, 4.47871625e-01f, 1.39991388e-01f, -3.29595476e-01f, -3.89427751e-01f, -3.79695117e-01f, -2.46668696e-01f, -1.85308848e-02f,
  6.64026439e-01f, -3.78681868e-01f, 2.12149143e-01f, 1.95009649e-01f, -1.81079626e-01f, 3.84605676e-01f, -1.19126989e-02f, 3.62599224e-01f, 2.28491332e-02f, 6.55283511e-01f,
  2.86633857e-02f, -1.25548637e+00f, -3.50447953e-01f, 6.11032546e-01f, 2.10153475e-01f, -2.51941741e-01f, 6.85044944e-01f, -4.47878361e-01f, 3.01042140e-01f, 1.39798775e-01f,
  -2.00525299e-01f, 1.18463971e-01f, 1.11812270e+00f, 5.92132211e-01f, 7.51758814e-02f, 5.19071579e-01f, -1.42260492e-01f, -3.48068982e-01f, 3.93550038e-01f, 8.57735157e-01f,
  2.91983753e-01f, 3.92130375e-01f, 3.86425734e-01f, -2.28992000e-01f, 4.10275191e-01f, -4.64670330e-01f, 2.03416601e-01f, 3.57090890e-01f, 8.79473865e-01f, -1.54279694e-01f,
  1.43470749e-01f, -2.48727217e-01f, 8.20883811e-02f, 1.64676115e-01f, 8.82956743e-01f, 7.41754532e-01f, 9.48712677e-02f, 1.54711008e-01f, -2.93855697e-01f, 1.01532519e+00f,
  -1.81316584e-01f, 2.50803828e-01f, -3.33238333e-01f, -2.13536829e-01f, 6.05305657e-02f, 3.90556872e-01f, 3.65916342e-01f, 3.08163911e-01f, 2.94889420e-01f, 3.68038803e-01f,
  5.49320877e-01f, -4.35889155e-01f, 5.75235605e-01f, 1.87238678e-01f, 8.31157640e-02f, 4.50717866e-01f, 4.34903055e-01f, 2.02393681e-01f, -3.33941251e-01f, -4.36826020e-01f,
  1.00704467e+00f, -2.69282162e-01f, -2.92855322e-01f, 5.49821496e-01f, -1.38688773e-01f, 7.66704619e-01f, -2.08085135e-01f, -5.18862724e-01f, 1.36335477e-01f, 1.75271839e-01f,
  2.77645916e-01f, 3.47308740e-02f, 4.10964906e-01f, 8.89850035e-02f, -2.68142760e-01f, -1.04152970e-01f, 1.18859828e-01f, 2.61572421e-01f, 9.48201001e-01f, -5.24210811e-01f,
  1.10360408e+00f, 1.17159474e+00f, 4.96897548e-01f, -8.06071311e-02f, 3.25069100e-01f, -1.89720005e-01f, -2.33971570e-02f, -4.87898409e-01f, -1.83381975e-01f, -4.68135506e-01f,
  8.41289908e-02f, 6.70368195e-01f, 7.03048944e-01f, -1.36277534e-03f, 8.78510699e-02f, -1.98387101e-01f, -4.43311840e-01f, 3.27406079e-01f, 3.44373137e-01f, 3.62668455e-01f,
  -1.23345986e-01f, -3.80290970e-02f, 6.85892224e-01f, 1.12733796e-01f, -3.17323297e-01f, -2.13131055e-01f, 1.71454504e-01f, 1.55655369e-01f, 1.79647431e-01f, 6.97076380e-01f,
  -1.78983808e-01f, 3.20437580e-01f, 2.08200455e-01f, -4.50753003e-01f, 8.72505188e-01f, 8.07214320e-01f, 1.11032136e-01f, 1.36064097e-01f, 3.94552052e-02f, 1.55827343e-01f,
  -2.28037998e-01f, 1.73501611e-01f, -2.11273581e-01f, -4.69170839e-01f, 5.55553794e-01f, 4.45774496e-02f, 1.67915568e-01f, 4.36928004e-01f, -2.07067445e-01f, 8.54459465e-01f,
  5.52243412e-01f, -2.51156420e-01f, -1.59141257e-01f, 2.24256456e-01f, 3.88609827e-01f, 5.74705422e-01f, 2.69646227e-01f, 4.44863662e-02f, -7.58183077e-02f, 3.56723130e-01f,
  -4.61015195e-01f, 8.93937111e-01f, 1.24502644e-01f, 6.58154011e-01f, 7.42267013e-01f, -9.86419320e-01f, 4.89871688e-02f, 4.63412374e-01f, 3.50375295e-01f, -5.21217734e-02f,
  -2.42306396e-01f, -2.90141433e-01f, -3.27177376e-01f, -2.40604192e-01f, 1.67648122e-01f, 8.75398457e-01f, 2.72186428e-01f, 6.33100092e-01f, 3.23351592e-01f, -5.18585220e-02f,
  9.08948660e-01f, 5.72411299e-01f, -3.94844055e-01f, 2.11516470e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.27042621e-01f, 4.18516338e-01f, -1.47836879e-01f, 7.75160491e-02f, 4.83801723e-01f, 2.27919355e-01f, -2.44223280e-03f, 4.92108464e-01f, 8.31844151e-01f, 6.02815390e-01f,
  -7.82119483e-02f, 5.30927062e-01f, -3.53124022e-01f, 5.74778140e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.52978987e-01f, 6.71919584e-02f, 9.80564356e-02f, -4.81702954e-01f, 1.48973241e-02f, 1.41831160e-01f, -4.48087752e-02f, 9.14648473e-02f, 1.41079813e-01f, 4.67294529e-02f,
  2.91365713e-01f, 4.44770940e-02f, -1.14645451e-01f, -9.59627628e-02f, 2.58011013e-01f, -3.03257644e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.81444800e-01f, -3.44417930e-01f, 1.09072462e-01f, -1.16045438e-01f, 4.71311808e-02f, -3.19922686e-01f, 4.02928174e-01f, 1.83521673e-01f, 4.47734326e-01f, 1.14870560e+00f,
  1.13691056e+00f, -2.53727645e-01f, -1.49929181e-01f, 8.62934172e-01f, -4.32239503e-01f, -4.80335414e-01f, -2.04172805e-01f, 1.23983204e-01f, 5.27801692e-01f, -1.89272568e-01f,
  4.98820186e-01f, 1.31859347e-01f, 8.41330811e-02f, 2.49846131e-01f, 3.52624267e-01f, 8.13056603e-02f, -2.74052173e-01f, -3.74542773e-01f, 3.74289602e-01f, -2.89776898e-03f,
  5.17730892e-01f, -3.18005353e-01f, 1.77172024e-03f, 1.29793569e-01f, -6.90909564e-01f, 5.39716244e-01f, -3.40969473e-01f, 3.13642502e-01f, 5.14935553e-01f, 5.62642872e-01f,
  -5.07827580e-01f, -6.69311285e-01f, 5.02409041e-01f, 4.45049465e-01f, 5.43754637e-01f, -2.54843801e-01f, 2.76645809e-01f, 5.47591075e-02f, -3.17409188e-01f, 4.33471769e-01f,
  3.83343130e-01f, 7.00720906e-01f, 4.25358653e-01f, -9.37860727e-01f, -8.34876120e-01f, 2.73659319e-01f, 1.66108698e-01f, 6.37622699e-02f, 4.38085914e-01f, -5.26292175e-02f,
  -6.15899146e-01f, -6.94715202e-01f, 1.29346266e-01f, 2.40924239e-01f, 1.22999726e-02f, -3.90161783e-03f, -5.00353235e-40f, -3.70766744e-02f, -8.84241331e-03f, -2.47137025e-02f,
  -8.85512971e-04f, -2.33519380e-03f, -7.25541171e-03f, -1.14761377e-02f, -1.76952928e-02f, -7.56964000e-05f, -4.68675122e-02f, -1.71084311e-02f, -1.76550597e-02f, -4.18203436e-02f,
  7.16110170e-01f, 3.32592368e-01f, 2.07116812e-01f, 9.88495201e-02f, -1.06485508e-01f, 8.02726805e-01f, 7.99410701e-01f, 7.64496028e-01f, -2.16254950e-01f, 7.86301255e-01f,
  -5.23033977e-01f, 5.28214395e-01f, 5.76047838e-01f, 1.87913135e-01f, 4.72106278e-01f, -2.84726620e-01f, 3.20567787e-01f, 8.71018648e-01f, 1.88864842e-02f, -8.39733779e-02f,
  -7.05946267e-01f, -2.89510846e-01f, 1.72950402e-01f, 3.03864002e-01f, -4.70067650e-01f, 9.07540098e-02f, 3.83904815e-01f, 7.20320106e-01f, -9.57196206e-02f, -1.12572998e-01f,
  -1.68101758e-01f, 7.58837163e-01f, 5.89498758e-01f, 7.40393102e-01f, -5.85835695e-01f, 2.72953302e-01f, -3.13146532e-01f, 1.31277516e-01f, 3.65745753e-01f, 3.12217921e-01f,
  -7.75458634e-01f, 5.45752406e-01f, 7.58647025e-01f, 3.42828184e-01f, -2.04189047e-01f, -4.34923291e-01f, -1.48272902e-01f, 6.04113579e-01f, -1.30331386e-02f, 9.89486754e-01f,
  4.40825373e-01f, -2.43943438e-01f, -7.27866232e-01f, -3.88738096e-01f, 2.02039316e-01f, 1.54674023e-01f, 3.26286465e-01f, 4.28042293e-01f, -3.16028446e-01f, 6.44163370e-01f,
  -2.66629178e-02f, 2.04086676e-01f, -2.34396368e-01f, 5.17370105e-01f, 1.00263581e-01f, 8.14581364e-02f, 1.87663570e-01f, -6.96153224e-01f, -4.23943251e-01f, -6.79112896e-02f,
  2.18472853e-01f, 3.21668804e-01f, 1.40163168e-01f, -6.53189600e-01f, 7.97623694e-01f, 2.85565061e-03f, 5.82304776e-01f, -7.87812192e-03f, 6.12782657e-01f, 1.10042810e-01f,
  6.57060921e-01f, -4.07436639e-01f, 4.63324189e-01f, -2.05935910e-01f, 1.51766494e-01f, -2.10466921e-01f, -7.48081654e-02f, -1.19396202e-01f, 2.11518571e-01f, 2.07200035e-01f,
  6.02608860e-01f, -4.18627053e-01f, -3.42675477e-01f, 5.55041656e-02f, 3.14739794e-01f, 3.15811604e-01f, 3.89838219e-01f, -7.94544876e-01f, 7.64678478e-01f, -4.17872250e-01f,
  -1.83787450e-01f, -3.15502077e-01f, -1.27840981e-01f, -2.76575685e-01f, 8.20626915e-01f, 3.69237751e-01f, 6.70128226e-01f, -5.01317203e-01f, 1.55017182e-01f, 3.49504322e-01f,
  2.47176930e-01f, 3.72657537e-01f, -4.88593698e-01f, 3.49881887e-01f, 5.66113651e-01f, -4.69736308e-01f, -2.29097784e-01f, -2.50120133e-01f, 1.49777502e-01f, 1.78199723e-01f,
  5.17626584e-01f, -5.06852150e-01f, 4.14714307e-01f, 6.49343789e-01f, -1.63704798e-01f, -1.62749037e-01f, 1.03114743e-03f, 6.95742309e-01f, 4.07697678e-01f, -7.28398487e-02f,
  1.75995484e-01f, 3.65708023e-01f, 4.68809694e-01f, 8.95076990e-01f, 4.02311474e-01f, -3.35575402e-01f, 3.92187089e-01f, 3.76898982e-02f, -2.12987185e-01f, -3.63715589e-01f,
  1.69507980e-01f, -1.24397360e-01f, 8.74029160e-01f, 1.00244507e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.52293229e-01f, -3.31262201e-01f, 3.41771059e-02f, 1.69508979e-02f, -5.49590550e-02f, 2.39532858e-01f, 5.08226812e-01f, 4.08565730e-01f, 3.59856606e-01f, -7.87343681e-02f,
  -1.17972590e-01f, 2.65113860e-01f, -1.95119947e-01f, 5.35976440e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.34181261e-01f, -4.13938433e-01f, -6.47794604e-01f, 1.28983080e-01f, 4.14836705e-01f, -2.21567661e-01f, -4.41640113e-05f, 2.05854565e-01f, 8.81779194e-03f, -3.54099005e-01f,
  -2.91387081e-01f, 6.90567344e-02f, -3.95710915e-01f, -5.55066049e-01f, -1.14516079e+00f, 9.74327102e-02f, 3.66137624e-01f, -5.33731282e-01f, 9.44911838e-02f, -4.94970530e-02f,
  1.35070741e-01f, 7.99915045e-02f, -9.82521661e-03f, 2.74048626e-01f, -7.08282650e-01f, 3.22095007e-02f, -1.90055862e-01f, -1.60918844e+00f, -9.68794301e-02f, -8.10399652e-01f,
  -6.35949373e-01f, 5.25038004e-01f, 5.95312059e-01f, -5.45908332e-01f, 3.98717135e-01f, -5.33131123e-01f, -7.65543342e-01f, -9.79331613e-01f, -4.64316682e-13f, -2.27162763e-02f,
  4.28732067e-01f, 1.06871985e-01f, 6.27479792e-01f, -8.62340331e-01f, 1.52585626e-01f, 1.72691911e-01f, -3.33303392e-01f, -9.90458727e-02f, -1.97705671e-01f, -2.07371190e-01f,
  -5.60219772e-02f, 7.93232247e-02f, -1.47812903e-01f, -9.74225163e-01f, -3.56535992e-08f, -8.38483050e-02f, -7.45663583e-01f, -1.12146163e+00f, -5.31240523e-01f, 4.48772013e-01f,
  9.74447206e-02f, 4.35654402e-01f, -2.29407534e-01f, 9.41249132e-02f, -7.36695886e-01f, 9.30908918e-01f, -2.18573716e-02f, 1.48565441e-01f, 1.94421217e-01f, 3.35000157e-01f,
  1.73753109e-02f, -2.24887431e-02f, 6.58589602e-02f, -7.11829066e-01f, 4.15557086e-01f, 5.15298620e-02f, -8.81319821e-01f, -1.80367827e-01f, 2.16573223e-01f, 6.33025542e-02f,
  -1.32242173e-01f, 2.78290719e-01f, 3.35858613e-01f, -2.83740938e-01f, 5.13679147e-01f, -2.35227987e-01f, -1.03510059e-02f, 1.05733044e-01f, 1.74424827e-01f, 2.01112136e-01f,
  -2.44792923e-01f, -1.39545640e-02f, -2.05904022e-01f, -6.83391988e-01f, -9.87514257e-01f, -4.20757025e-01f, -4.06401843e-01f, -3.61644983e-01f, -5.90346217e-01f, -7.33662546e-01f,
  1.01796120e-01f, 5.69590211e-01f, 1.26770372e-12f, -3.73361021e-01f, 4.47218478e-01f, 3.05582643e-01f, 3.93268406e-01f, -8.40721190e-01f, -4.51480448e-01f, -7.13765264e-01f,
  3.02051902e-01f, -9.40605700e-01f, -2.00396761e-01f, -1.76785633e-01f, -5.39735138e-01f, 4.87569541e-01f, -2.80946821e-01f, 3.96384925e-01f, -1.27017340e-02f, -5.83492756e-01f,
  -2.99858212e-01f, -5.29949844e-01f, -4.67452586e-01f, -4.13271878e-03f, 1.38811320e-01f, 1.89532667e-01f, 2.93561757e-01f, 4.11314279e-01f, 4.24327493e-01f, 3.64431411e-01f,
  8.50603282e-01f, -6.95296288e-01f, -5.80037117e-01f, -2.48856127e-01f, 3.20015103e-02f, -5.57235956e-01f, -7.92493165e-01f, -4.64842975e-01f, -9.69511509e-01f, -8.51562619e-01f,
  2.81823754e-01f, 5.61554253e-01f, -6.95259348e-02f, 1.67636901e-01f, 1.18321225e-01f, -2.02779710e-01f, -1.34025991e+00f, -8.13715279e-01f, 3.73660982e-01f, -9.66971397e-01f,
  4.01963240e-10f, 1.37748152e-01f, 2.13309065e-01f, 1.63759947e-01f, 3.64233911e-01f, -1.58870846e-01f, -5.63303649e-01f, -3.87775242e-01f, 1.44483760e-01f, 7.18843415e-02f,
  -6.27297401e-01f, 4.29333836e-01f, 4.18987304e-01f, 2.67513871e-01f, -7.82380462e-01f, -7.98125863e-01f, 3.91286598e-30f, 3.29584271e-01f, -8.13308835e-01f, -9.98338699e-01f,
  4.66884315e-01f, -1.48578465e-01f, -1.36540577e-01f, 1.85256332e-01f, -3.29696536e-01f, -6.49469435e-01f, 2.76717782e-01f, 1.39785921e-02f, 1.60341322e-01f, -1.00019813e+00f,
  -1.05938539e-01f, -1.50330707e-01f, -7.28825224e-04f, -1.02342749e+00f, 7.94060007e-02f, 5.12219071e-02f, -2.57612057e-02f, 2.97804177e-01f, 2.74467528e-01f, 1.70668378e-01f,
  1.97625920e-01f, -5.32274187e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.67868781e-01f, -1.90408021e-01f, 4.59522933e-01f, -4.60544765e-01f, 1.26913950e-01f, -1.49554789e-01f, 4.37444597e-02f, -1.71711653e-01f, 1.73455685e-01f, -2.80126750e-01f,
  -3.97104383e-01f, 1.03979714e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    