/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.61236519e-01f, -2.16091424e-01f, -9.84064564e-02f, -4.23249379e-02f, -5.63998893e-02f, 1.52366459e-01f, 7.66189471e-02f, 5.71072847e-02f, -5.71771115e-02f, -1.21433418e-02f,
  3.95305716e-02f, 3.17673385e-02f, -6.95316643e-02f, -9.58586112e-02f, 1.31265551e-01f, -4.32059951e-02f, -3.01146120e-01f, -1.78104535e-01f, 3.57527733e-02f, 1.92757651e-01f,
  -4.95029427e-03f, -5.24217188e-02f, -1.01780102e-01f, 8.28432143e-02f, -3.23415287e-02f, 1.37344375e-01f, -9.71062407e-02f, 7.47395027e-03f, 3.72797064e-02f, -3.85242790e-01f,
  1.03357360e-01f, 1.51846796e-01f, 4.56157103e-02f, 1.97943784e-02f, 1.49717070e-02f, 6.39577955e-02f, 7.47244880e-02f, -7.76902214e-03f, 3.20150889e-02f, -4.32146974e-02f,
  -1.44865997e-02f, -2.88112368e-02f, -1.28509458e-02f, -1.38482489e-02f, 3.06666526e-03f, -3.32274772e-02f, 2.59590056e-02f, -5.60316443e-02f, -3.01121399e-02f, 4.51636091e-02f,
  -6.06884547e-02f, -8.15552448e-06f, 5.09580746e-02f, -4.76000719e-02f, 8.49525928e-02f, 1.99404843e-02f, 5.43931797e-02f, 5.88146672e-02f, 1.15203924e-01f, 3.24682407e-02f,
  4.58761491e-02f, -3.28248329e-02f, 4.77474146e-02f, -2.56693922e-04f, -1.28977913e-02f, -1.16167695e-03f, -2.80065164e-02f, 5.16214930e-02f, -6.53342232e-02f, -2.42361426e-02f,
  3.58518423e-03f, 5.45741022e-02f, 3.13184923e-03f, 5.59222661e-02f, -1.83718242e-02f, -2.11207233e-02f, 4.96885665e-02f, -8.16676989e-02f, 3.27690728e-02f, -3.78418863e-02f,
  7.36679062e-02f, 2.99761118e-03f, -2.06203740e-02f, -5.26703661e-03f, -2.49658525e-03f, -5.67130605e-03f, 2.57889796e-02f, -1.10459020e-02f, 2.20774412e-02f, -1.55064464e-02f,
  1.51701152e-01f, -3.61071862e-02f, -8.66481215e-02f, -1.24667790e-02f, 6.52588084e-02f, 1.82688162e-02f, -2.81738658e-02f, -3.94113809e-02f, -5.76108322e-02f, -4.75241020e-02f,
  -8.01401772e-03f, 6.24094978e-02f, -4.13568653e-02f, -3.03166490e-02f, -1.57293435e-02f, -1.44715104e-02f, 7.42717534e-02f, 9.19008628e-02f, -4.73165233e-03f, -9.41354632e-02f,
  -7.85529390e-02f, 9.84903201e-02f, 1.76640391e-01f, -3.94173972e-02f, 1.27158007e-02f, 9.70558748e-02f, 1.02995917e-01f, 3.59307453e-02f, 1.94422960e-01f, 3.70084308e-02f,
  2.42796149e-02f, -1.89746216e-01f, -1.41751364e-01f, 3.05982605e-02f, -2.97152027e-02f, 2.61008032e-02f, -3.01074952e-01f, -8.16506669e-02f, 1.50093406e-01f, -7.56666213e-02f,
  6.31264225e-02f, 1.03071555e-01f, 2.25352213e-01f, 1.71554368e-02f, 6.06803223e-02f, -2.65530050e-01f, -1.26122624e-01f, -3.58854681e-02f, 1.02828823e-01f, -2.42932364e-02f,
  -4.12571952e-02f, -2.61441376e-02f, 1.02615871e-01f, 6.71709180e-02f, -1.27528729e-02f, 1.80306032e-01f, -3.14501189e-02f, -2.58233808e-02f, 6.57709390e-02f, -1.84568420e-01f,
  5.09232236e-03f, -1.40012786e-01f, -1.13745257e-02f, 7.34045357e-02f, -4.47827354e-02f, 6.11827802e-03f, 2.53673941e-02f, -7.46926814e-02f, -2.11507659e-02f, -7.67867789e-02f,
  5.92623614e-02f, 8.67753103e-03f, 4.03742157e-02f, -1.76731329e-02f, -1.11374073e-01f, -3.98822352e-02f, -8.22999328e-02f, -6.27243295e-02f, 8.41816217e-02f, -1.41490176e-01f,
  -6.21741526e-02f, -8.63101855e-02f, -4.27247547e-02f, 8.47651288e-02f, 3.80450711e-02f, 9.77580473e-02f, 4.88352105e-02f, 8.75729918e-02f, 7.60286972e-02f, -7.05420747e-02f,
  4.38639112e-02f, -9.28632170e-03f, 1.01354063e-01f, 2.59006862e-02f, -6.48268312e-02f, 3.17173032e-03f, -7.88780227e-02f, -3.17433178e-02f, 4.21320461e-02f, 1.15945132e-03f,
  3.03590074e-02f, -5.68005890e-02f, 4.17607985e-02f, -1.28229512e-02f, 2.57509872e-02f, 5.51039577e-02f, 8.51858465e-04f, -6.37536272e-02f, 7.15960860e-02f, 5.66384867e-02f,
  2.91087404e-02f, 7.91599303e-02f, 1.31069701e-02f, 9.53753851e-03f, -5.53844422e-02f, -7.06278831e-02f, 2.74193529e-02f, 8.02419614e-03f, 1.83749653e-03f, -1.59854386e-02f,
  5.20281121e-03f, 1.00593694e-01f, 2.91323271e-02f, 4.55504656e-02f, -4.63525653e-02f, 9.77905467e-03f, 7.11052641e-02f, 5.46676852e-02f, 3.08062490e-02f, -3.51775140e-02f,
  -1.68121979e-02f, -9.94764827e-03f, 3.08417045e-02f, 5.49971201e-02f, 2.38068756e-02f, 5.45926616e-02f, -4.63482700e-02f, -7.34950975e-02f, 4.80869003e-02f, -3.56966741e-02f,
  -6.68804497e-02f, -6.71034083e-02f, -3.84326116e-03f, 3.80950198e-02f, -4.40051546e-03f, 5.56185953e-02f, -2.73468695e-03f, -8.70390981e-03f, 1.50307223e-01f, -5.49852289e-02f,
  1.97052523e-01f, -2.05203518e-02f, -4.57920209e-02f, 1.34341806e-01f, -8.05552453e-02f, -1.49130061e-01f, -2.52060086e-01f, 1.38760926e-02f, 1.41021058e-01f, 4.84721065e-02f,
  1.54553093e-02f, 3.31663378e-02f, 1.56829447e-01f, 3.66178341e-02f, -6.52528852e-02f, -1.64663136e-01f, -2.84730364e-02f, -8.24585930e-02f, -2.38436442e-02f, -4.40172181e-02f,
  -2.00252812e-02f, -7.68170059e-02f, 4.00329344e-02f, 9.47853625e-02f, -2.11168919e-02f, 8.97044763e-02f, -3.83859500e-03f, 6.44861162e-02f, -4.65896359e-04f, -1.03635773e-01f,
  -1.78088769e-01f, 1.88406017e-02f, 2.52967197e-02f, 1.23764664e-01f, -7.53921270e-02f, -4.67282794e-02f, -2.50033531e-02f, -3.67031596e-03f, 7.33852237e-02f, -1.44699933e-02f,
  -4.23770808e-02f, 9.09563377e-02f, 1.26613706e-01f, -2.55717617e-02f, -3.60848792e-02f, 3.67983915e-02f, -2.21196041e-02f, -4.39013317e-02f, 1.35419397e-02f, -8.88390541e-02f,
  5.32082766e-02f, -8.35100710e-02f, -1.61535554e-02f, -7.86507577e-02f, 8.49379897e-02f, -2.31424277e-03f, 8.25476181e-03f, 7.79308900e-02f, -1.31360339e-02f, 8.83114263e-02f,
  6.33200184e-02f, 3.70125868e-03f, 1.58799216e-02f, 3.40058394e-02f, 9.11858752e-02f, 5.42434454e-02f, 4.34811078e-02f, -3.97408474e-03f, -8.83756652e-02f, 3.45712788e-02f,
  5.28004505e-02f, -1.29143717e-02f, 1.02727965e-01f, 5.41605242e-03f, -8.98881909e-03f, -8.18805769e-02f, -4.21617813e-02f, -1.42083531e-02f, 3.60804647e-02f, 5.11083752e-02f,
  8.63998383e-02f, -8.13917164e-03f, -2.23837607e-02f, -7.75587037e-02f, -1.75081808e-02f, -3.79016176e-02f, 5.59083149e-02f, 3.07614524e-02f, 3.09658274e-02f, -7.72371590e-02f,
  -1.01691417e-01f, 6.00137282e-03f, -1.72196352e-03f, -1.85435265e-02f, 2.70199403e-02f, 3.31028625e-02f, -3.98636376e-03f, 6.00661486e-02f, 4.01523225e-02f, 1.78445168e-02f,
  2.44168825e-02f, 9.59064066e-02f, -2.84898877e-02f, -1.34311514e-02f, -3.43358777e-02f, 6.31394014e-02f, 4.68016826e-02f, 2.74630841e-02f, -5.06178327e-02f, 1.61193255e-02f,
  -8.72267187e-02f, 2.52214950e-02f, -1.58659324e-01f, 3.07185506e-03f, -1.55541906e-02f, -1.23861320e-01f, -8.39062780e-02f, -1.10658191e-01f, -3.72802988e-02f, -4.10963148e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.15394095e-01f, 2.07360595e-01f, 5.83987571e-02f, 1.76551864e-01f, 1.35184973e-01f, 1.14165694e-02f, 1.64603174e-01f, 6.10038973e-02f, 6.20892718e-02f, 1.72965273e-01f,
  1.66413978e-01f, 1.05049916e-01f, 9.19615850e-02f, 1.82693042e-02f, 1.36355758e-01f, 1.73559375e-02f, -6.17957115e-03f, -8.32803622e-02f, -9.98725370e-02f, -3.21884565e-02f,
  5.03325053e-02f, 4.43255827e-02f, -8.32637399e-02f, 2.04424579e-02f, 6.46575689e-02f, -7.16050938e-02f, 4.32339087e-02f, 1.31395385e-01f, 9.63137224e-02f, 1.22996196e-01f,
  -2.09589712e-02f, 1.03720658e-01f, 8.57396610e-03f, 3.45490277e-02f, -5.47968270e-03f, -7.41264597e-02f, 2.89996658e-02f, -1.25363126e-01f, 9.58663523e-02f, -1.03616349e-01f,
  5.87466126e-03f, -5.60350493e-02f, 6.31495938e-02f, -9.48941782e-02f, 3.00088562e-02f, -4.60272245e-02f, -4.60976437e-02f, -8.05851296e-02f, -2.51706913e-02f, -3.80679183e-02f,
  1.51803911e-01f, 4.47780788e-02f, 8.44159573e-02f, 5.53902164e-02f, 1.03207594e-02f, -5.54408506e-02f, 8.69482532e-02f, 2.67693382e-02f, 3.12958248e-02f, 6.79169893e-02f,
  -8.03245325e-03f, 2.85469051e-02f, 6.19113371e-02f, 8.13906565e-02f, 2.92726532e-02f, 4.84316461e-02f, 8.36717412e-02f, -9.71239712e-03f, 1.07777216e-01f, -5.17087467e-02f,
  8.94138310e-03f, 2.98991837e-02f, -6.03009649e-02f, 5.55149838e-02f, -2.83329487e-02f, 4.08763252e-02f, 1.86806209e-02f, -2.55757980e-02f, -6.48998991e-02f, -5.04599810e-02f,
  6.39465526e-02f, 1.19014569e-02f, -6.51448220e-02f, -6.42317161e-02f, -1.95350777e-02f, -2.71697175e-02f, 6.17893860e-02f, 1.82467774e-02f, 2.81219408e-02f, -7.94394687e-02f,
  -1.74682319e-01f, 2.20486540e-02f, 5.73548488e-02f, -4.43869978e-02f, 3.20765488e-02f, 2.36113276e-02f, -2.65386812e-02f, 3.49240676e-02f, -3.14865224e-02f, -1.33523703e-01f,
  1.16665602e-01f, 9.43299010e-02f, -5.06112576e-02f, -6.17026538e-03f, -6.06404170e-02f, -6.73499852e-02f, -6.36042953e-02f, -1.59887761e-01f, -6.21283688e-02f, -7.30407238e-02f,
  -1.75272822e-02f, -1.19353272e-01f, -1.25049546e-01f, -7.46053234e-02f, 2.93560028e-02f, -7.69556267e-03f, -1.54484093e-01f, -1.26067191e-01f, -1.60320327e-01f, -2.29069322e-01f,
  -3.14828008e-02f, 3.08521912e-02f, -5.00688627e-02f, -7.10425079e-02f, -4.49523591e-02f, -7.62537271e-02f, 5.12261018e-02f, 5.81158437e-02f, -8.64780769e-02f, 1.12692416e-01f,
  1.52471289e-02f, -1.27450168e-01f, -1.10435188e-01f, 2.40816213e-02f, -7.47508034e-02f, 7.44524077e-02f, -1.47953525e-01f, -1.23176008e-01f, -1.37449190e-01f, -1.77561328e-01f,
  -7.51491338e-02f, -9.13657714e-03f, -4.00859676e-02f, -6.17545694e-02f, -1.57859921e-02f, 4.31309082e-02f, -1.35551570e-02f, -1.16735816e-01f, -5.57370819e-02f, 1.67054813e-02f,
  1.99876249e-01f, -2.08944842e-01f, 1.03346668e-02f, -3.47131491e-02f, 6.19464479e-02f, 9.71592218e-03f, -2.67949998e-02f, -8.20128322e-02f, -4.07742411e-02f, -7.83035159e-02f,
  -6.16550446e-02f, 2.79955398e-02f, -4.08381894e-02f, -2.06301808e-02f, 8.22028220e-02f, -1.72657706e-02f, -4.39854302e-02f, 3.92672196e-02f, 1.03284232e-02f, -2.44771279e-02f,
  -7.07552880e-02f, -3.73700708e-02f, -1.03747072e-02f, 3.18520665e-02f, 2.89792381e-02f, -9.25441012e-02f, 8.16040114e-02f, -6.92380667e-02f, -3.04481909e-02f, 6.80080578e-02f,
  9.17804390e-02f, -3.10918372e-02f, 2.11911071e-02f, -1.88901019e-03f, 7.37145022e-02f, 7.42309466e-02f, -9.03987885e-03f, 6.98621124e-02f, -7.00656977e-03f, 2.30150931e-02f,
  -9.24798846e-03f, 7.82119036e-02f, 3.77610177e-02f, -5.07939514e-03f, 1.16527900e-02f, 8.38834420e-02f, 3.90098765e-02f, 3.02740317e-02f, -1.32329427e-02f, -3.26066092e-02f,
  1.16764503e-02f, 5.78779988e-02f, 3.92700247e-02f, 3.65512166e-03f, 6.34215176e-02f, 4.01476361e-02f, -7.04541877e-02f, -7.61519894e-02f, -4.17299196e-02f, -1.27333641e-01f,
  1.89641416e-01f, -2.30412096e-01f, 4.04090472e-02f, -5.39498068e-02f, 1.82565022e-02f, 8.46234709e-02f, -8.22922308e-03f, -7.08975419e-02f, -6.72456846e-02f, -6.59450665e-02f,
  -1.70122199e-02f, -1.85330268e-02f, -4.62148525e-02f, 4.21531089e-02f, -9.69532579e-02f, -1.64255708e-01f, 5.82854785e-02f, -8.87997597e-02f, -7.94008896e-02f, -1.28180766e-02f,
  3.56887840e-02f, -9.87073756e-04f, 3.25747393e-02f, -3.60228345e-02f, 5.17233275e-02f, -2.54293531e-03f, 1.05703920e-01f, 5.90011887e-02f, -9.48358625e-02f, 1.90193772e-01f,
  6.88935295e-02f, -1.68602616e-01f, 3.39286029e-02f, 2.18763173e-01f, 8.06116387e-02f, 1.75698429e-01f, -9.02833641e-02f, 1.80270776e-01f, 9.59447548e-02f, 7.90687501e-02f,
  2.13601500e-01f, 2.49372646e-01f, 1.63599238e-01f, 3.72424684e-02f, 6.95043728e-02f, -5.44948578e-02f, -1.52866781e-01f, 5.42027652e-02f, 2.13352501e-01f, 1.89753100e-01f,
  1.64024785e-01f, -2.05343813e-02f, 1.18446797e-01f, -2.95171019e-04f, -1.12135850e-01f, 4.52575423e-02f, -8.77354369e-02f, -1.03599258e-01f, -1.59672976e-01f, -4.10648555e-01f,
  -1.83088202e-02f, -1.24368697e-01f, 8.22828431e-03f, -2.50578281e-02f, -2.46927398e-03f, -3.35927755e-02f, 3.16768251e-02f, -5.62866963e-02f, -5.89799546e-02f, 1.92611534e-02f,
  -4.82399203e-02f, 7.83785358e-02f, 2.64734961e-02f, -6.61814585e-02f, 2.34978143e-02f, -8.65162525e-04f, -9.36964154e-02f, -9.47948992e-02f, -2.71307565e-02f, 1.14823366e-02f,
  -7.62817338e-02f, -6.16414100e-02f, -1.15699016e-01f, -2.03685500e-02f, -1.56625509e-02f, -5.75735718e-02f, -2.02893510e-01f, -1.55344173e-01f, -1.69553325e-01f, -2.46257916e-01f,
  -1.42957810e-02f, -2.38099322e-02f, 1.62921716e-02f, 7.42456689e-03f, 3.05334516e-02f, -3.13804261e-02f, -4.86981310e-02f, 2.10823081e-02f, 6.56013116e-02f, -9.35362577e-02f,
  1.06737643e-01f, 8.63297880e-02f, 3.66750248e-02f, 2.50844005e-02f, 2.28078086e-02f, 2.40131952e-02f, -6.59171492e-02f, -5.02999593e-03f, -2.42126044e-02f, -3.85288596e-02f,
  3.40818502e-02f, 9.40364972e-03f, -8.62729400e-02f, 9.79117397e-03f, -4.06887196e-02f, -1.07776616e-02f, -2.87475362e-02f, 1.00597858e-01f, -1.07048647e-02f, -7.25791790e-03f,
  3.40287387e-02f, 3.09581142e-02f, -2.40625963e-02f, 1.01942178e-02f, 2.24474780e-02f, -6.91070184e-02f, 1.05948307e-01f, 2.42051017e-03f, -3.49280722e-02f, 3.45800072e-03f,
  -2.28595827e-02f, 1.31341070e-02f, -4.34734253e-03f, -3.70753109e-02f, 1.95383448e-02f, 4.69277799e-02f, -4.91085872e-02f, 6.40198514e-02f, -8.61633345e-02f, 3.89609523e-02f,
  5.20001501e-02f, -9.69181943e-04f, -6.42898455e-02f, -1.07563734e-01f, -5.56473993e-02f, -6.85712174e-02f, -8.49855319e-02f, -2.14222103e-01f, -1.12433992e-01f, -1.35552585e-01f,
  -3.91272604e-02f, -2.06649918e-02f, -1.53987378e-01f, 6.49469998e-03f, -5.04124127e-02f, -5.52680008e-02f, -1.55678615e-01f, 1.09255467e-04f, -2.29704697e-02f, -1.45576373e-01f,
  1.87442042e-02f, -5.12318127e-03f, -2.34219432e-02f, -7.42945597e-02f, -4.56274413e-02f, -1.78099424e-01f, -6.69487640e-02f, -3.30936946e-02f, -4.76645082e-02f, 6.71386272e-02f,
  -1.14917412e-01f, -6.89932033e-02f, 5.27747199e-02f, 5.58017306e-02f, 6.18917271e-02f, 5.78943491e-02f, -6.53627962e-02f, -5.78978881e-02f, -4.99718450e-02f, -1.95755020e-01f,
  -3.61676626e-02f, -1.55971497e-01f, 4.61956412e-02f, -1.31034374e-01f, -2.35465802e-02f, 4.82870005e-02f, -8.35659727e-02f, -3.16407271e-02f, 1.47027383e-02f, 4.35701013e-02f,
  -2.83046477e-02f, 2.38609239e-02f, 6.73584938e-02f, 4.05449905e-02f, 1.89872719e-02f, -1.10039497e-02f, -4.69567217e-02f, -3.78385447e-02f, -2.43891906e-02f, -8.62986296e-02f,
  -8.76012892e-02f, -1.47120610e-01f, -6.76499903e-02f, 3.61573957e-02f, 3.28777381e-03f, -1.33715600e-01f, 5.28142415e-02f, 1.01711728e-01f, 1.11872628e-01f, -1.29643492e-02f,
  1.36923185e-02f, -1.12863043e-02f, 4.25092056e-02f, 3.29516940e-02f, 5.77371866e-02f, -5.18146083e-02f, 1.97625328e-02f, 5.19945361e-02f, 9.91058871e-02f, 3.83646786e-03f,
  8.55671894e-03f, 5.21636775e-06f, -3.30874808e-02f, 3.17090936e-02f, -2.54570972e-02f, 5.49643375e-02f, 3.84974442e-02f, -4.33026664e-02f, 1.43684763e-02f, -1.24268867e-01f,
  -6.26259446e-02f, 3.21699008e-02f, -9.72649753e-02f, -7.92016312e-02f, -1.67479977e-01f, 5.41567383e-03f, 2.99566276e-02f, 5.34822941e-02f, 4.57851179e-02f, 1.00302421e-01f,
  2.21884906e-01f, -1.58545837e-01f, -7.10288659e-02f, -2.32017599e-02f, -3.00455727e-02f, 4.56833513e-03f, -3.45787518e-02f, 2.52370499e-02f, 3.39771248e-02f, -3.04864105e-02f,
  -9.13583860e-03f, 3.17535847e-02f, 1.21124620e-02f, 1.02200154e-02f, -8.00516605e-02f, 4.67159152e-02f, -9.16522592e-02f, 3.73637192e-02f, 2.01218687e-02f, 5.00309877e-02f,
  3.49207707e-02f, -2.56842766e-02f, -2.90517285e-02f, 2.64016408e-02f, 4.68136594e-02f, -9.03773531e-02f, 6.90790010e-04f, 1.54874325e-01f, -7.95787275e-02f, 1.60839453e-01f,
  -2.35367659e-02f, -5.12488373e-02f, 1.21124469e-01f, -6.67284206e-02f, 3.54366936e-02f, -2.32490897e-01f, -3.15821707e-01f, -9.01774392e-02f, 4.20125164e-02f, -1.00038081e-01f,
  4.46099415e-02f, -1.85554214e-02f, 1.26578197e-01f, 7.63777569e-02f, -1.46863773e-01f, -1.51757404e-01f, -2.83272266e-02f, 6.80113807e-02f, -1.03977798e-02f, 6.92476612e-03f,
  1.18560582e-01f, 5.37621677e-02f, 1.21958829e-01f, -3.25277932e-02f, 1.40001133e-01f, 6.21199887e-03f, 6.58292770e-02f, 2.75176354e-02f, -3.69932503e-02f, 2.75344461e-01f,
  1.84581727e-01f, -1.33723393e-01f, -3.35217081e-02f, 8.70362297e-03f, 1.07117243e-01f, -1.04710888e-02f, 7.23696053e-02f, 7.02940822e-02f, -6.43897131e-02f, -2.11734530e-02f,
  9.77128819e-02f, 1.55833960e-02f, 6.02741502e-02f, -1.85414106e-02f, -8.16013739e-02f, -1.19825423e-01f, 3.94510552e-02f, -1.71799436e-02f, -1.00215152e-01f, -6.29118308e-02f,
  1.83066155e-03f, 2.70977784e-02f, 4.58342731e-02f, -5.88990934e-02f, -1.07592845e-03f, 6.82434514e-02f, 4.84620482e-02f, -3.44618373e-02f, -1.04944453e-01f, 1.17417499e-01f,
  -2.73134056e-02f, -1.23791294e-02f, 7.36991316e-02f, -3.69438268e-02f, 1.99087691e-02f, -5.69944791e-02f, -1.94141064e-02f, 3.25571410e-02f, 3.10993344e-02f, -7.16010630e-02f,
  -2.50379853e-02f, 1.67690385e-02f, 1.76992789e-02f, 9.52400267e-02f, -2.58769933e-02f, -2.11174111e-03f, -5.25896139e-02f, 3.65252495e-02f, -1.82619411e-02f, 1.01251170e-01f,
  7.03686103e-02f, -4.20954525e-02f, 3.26489769e-02f, 5.09111909e-04f, -1.97486561e-02f, 1.37898773e-02f, 6.53793886e-02f, -1.53783318e-02f, -6.88606575e-02f, -1.70408320e-02f,
  9.85091552e-02f, -9.65581238e-02f, 5.30482829e-02f, -3.54751311e-02f, 2.95860432e-02f, -3.97211723e-02f, -8.08696449e-02f, -1.20436795e-01f, -8.95641651e-03f, 1.10885212e-02f,
  3.34705785e-02f, -8.13110638e-03f, -7.02239061e-03f, 1.54517684e-02f, -1.99574456e-02f, -2.23420411e-02f, 3.47907878e-02f, -7.60947317e-02f, -1.83536240e-03f, -5.25554679e-02f,
  -3.69305424e-02f, -3.27487215e-02f, -1.37953490e-01f, -6.79906309e-02f, -1.21537089e-01f, 5.94937662e-03f, 5.37826121e-02f, 9.16149914e-02f, 2.33064424e-02f, -1.02990486e-01f,
  1.30629251e-02f, 5.98427653e-02f, 2.91234907e-02f, -2.21569147e-02f, -7.40125254e-02f, 6.02249429e-02f, 6.57796562e-02f, -5.04535586e-02f, -6.12014234e-02f, -6.30301535e-02f,
  -3.62585410e-02f, -5.61301149e-02f, -5.47737814e-03f, -3.67739424e-02f, -2.19853539e-02f, 5.83043210e-02f, -9.04120058e-02f, -6.25833049e-02f, -7.13741733e-03f, -1.26782199e-03f,
  5.60041610e-03f, -1.06015243e-01f, -5.74996248e-02f, -7.55318850e-02f, -1.10045388e-01f, -5.33603840e-02f, -1.25815365e-02f, -1.41865397e-02f, 2.97521744e-02f, -2.64260154e-02f,
  4.95127477e-02f, -8.07750225e-02f, -8.26605111e-02f, -3.83857191e-02f, 4.81209494e-02f, -7.78344795e-02f, -7.01956600e-02f, 5.71389012e-02f, 5.23575246e-02f, 3.59845720e-02f,
  -3.16498801e-02f, -7.17825443e-02f, 8.49914998e-02f, -3.58497277e-02f, 3.97266783e-02f, -2.43726559e-02f, 4.73382585e-02f, -7.22486377e-02f, -2.75265165e-02f, 3.54488865e-02f,
  4.35125604e-02f, -6.21844083e-02f, -5.22254407e-02f, 9.03016552e-02f, 8.98450837e-02f, 7.61004612e-02f, 6.26133308e-02f, 4.06580865e-02f, -3.00466325e-02f, 1.35417935e-02f,
  -5.45394011e-02f, -3.03351153e-02f, -2.38191281e-02f, -3.96325924e-02f, 7.05683455e-02f, 4.43763584e-02f, 3.92760150e-02f, -9.78649184e-02f, 4.93801385e-02f, -1.09303696e-02f,
  2.46870685e-02f, -1.96115012e-04f, -8.50528330e-02f, 6.14412166e-02f, 6.21596933e-04f, -7.43779093e-02f, 5.86909661e-03f, -2.12042723e-02f, -8.75611678e-02f, -3.65850851e-02f,
  -5.89271262e-02f, -2.00418998e-02f, -8.37574899e-02f, -2.22333912e-02f, -3.59687991e-02f, 2.08752286e-02f, -1.43495575e-03f, 5.86408824e-02f, 5.24528697e-02f, -4.12891526e-03f,
  -9.04362202e-02f, 4.32699658e-02f, 6.26171231e-02f, -2.71108188e-03f, 7.64329731e-02f, -5.48277721e-02f, 6.40333304e-03f, 2.49067298e-03f, -4.59675863e-02f, -8.71112272e-02f,
  -8.95963833e-02f, 5.14317490e-02f, 2.13834830e-02f, -8.84674266e-02f, -1.95340114e-03f, 6.36555403e-02f, -3.31435353e-02f, -8.50213692e-03f, 7.44157508e-02f, -6.31461293e-02f,
  -3.50931510e-02f, 4.69501577e-02f, 9.75748897e-03f, -3.05977203e-02f, -4.00610752e-02f, 1.10848382e-01f, 1.49301579e-02f, -1.87351070e-02f, -4.59345654e-02f, -2.26884857e-02f,
  -5.79158217e-02f, -2.79040068e-01f, 3.97614650e-02f, 4.31108847e-02f, 1.85548320e-01f, 8.82665291e-02f, 1.49710670e-01f, 3.24936099e-02f, 1.40746295e-01f, 6.33662194e-02f,
  -5.64134568e-02f, 3.66207212e-02f, -7.51123577e-02f, 8.31479803e-02f, 4.44726720e-02f, 5.16474284e-02f, 7.21281841e-02f, 7.54600167e-02f, 1.48453444e-01f, 1.31441772e-01f,
  9.35464352e-02f, 2.83498736e-03f, 1.14319585e-02f, 8.16362351e-02f, 1.41988518e-02f, 1.44729033e-01f, -6.48487955e-02f, -1.19071357e-01f, 1.32548232e-02f, 8.83439183e-02f,
  8.69080052e-03f, -1.05575047e-01f, 4.72347736e-02f, -4.62541357e-02f, -4.71923836e-02f, -9.27088503e-03f, -5.69084212e-02f, -3.35430391e-02f, -1.01480655e-01f, -6.72621047e-03f,
  -1.02572395e-02f, 6.61306549e-03f, 6.67973608e-02f, -6.85008466e-02f, 3.18522751e-02f, -4.67954054e-02f, -1.57446727e-01f, 2.05725487e-02f, 7.52512366e-02f, 1.39964968e-02f,
  -2.73969732e-02f, -7.40780905e-02f, 8.65243301e-02f, 4.99280728e-02f, 6.90618381e-02f, 9.03167874e-02f, -9.37378183e-02f, -6.62019551e-02f, -8.11870676e-03f, -4.53328043e-02f,
  1.36793509e-01f, 5.83001859e-02f, 3.17393690e-02f, 2.58036307e-03f, 5.22437394e-02f, 4.12137210e-02f, 5.75261600e-02f, -4.31919843e-02f, -3.92545797e-02f, 4.36340570e-02f,
  2.34009810e-02f, 5.88244833e-02f, 8.06520954e-02f, -2.13547628e-02f, 5.34020029e-02f, -5.99240512e-02f, 8.94558579e-02f, -3.91082279e-02f, -8.81760567e-02f, 6.19818568e-02f,
  -5.30748256e-02f, -6.63805455e-02f, 3.01960520e-02f, -6.85617179e-02f, -4.94471565e-02f, 3.12518552e-02f, 2.45972276e-02f, -6.14802875e-02f, -5.30169383e-02f, 1.83385201e-02f,
  3.40554602e-02f, 2.20545493e-02f, 8.18381235e-02f, 3.99286710e-02f, -5.11845276e-02f, 3.25453328e-03f, 4.31307368e-02f, -5.14026321e-02f, -3.43823363e-03f, 6.28566276e-03f,
  -8.47967416e-02f, -2.67335214e-02f, -1.11466229e-01f, 3.61663178e-02f, -3.54680382e-02f, 6.86369091e-02f, -2.80263722e-02f, 9.19762067e-03f, -9.28735454e-03f, 3.79735678e-02f,
  4.92618047e-02f, 5.38634993e-02f, 9.76182297e-02f, 7.66142979e-02f, 3.77062000e-02f, 4.10157144e-02f, 6.40535057e-02f, 6.72193542e-02f, -2.01813504e-02f, 1.27060013e-02f,
  -3.19338948e-01f, -1.69585511e-01f, 1.84705094e-01f, -8.17143247e-02f, 7.88725540e-02f, 1.65267602e-01f, 2.83427477e-01f, 2.61131395e-02f, -1.19728379e-01f, 1.28011167e-01f,
  -1.04337774e-01f, -7.93403909e-02f, -1.54640540e-01f, -6.69508874e-02f, 2.96159182e-03f, 8.83161724e-02f, 1.24789327e-01f, 5.47625357e-04f, -1.47300148e-02f, 2.50285235e-03f,
  6.10069893e-02f, -1.83673855e-02f, -1.68801740e-01f, -1.27873272e-01f, 2.55746432e-02f, -3.08999717e-02f, 6.99053705e-02f, -7.19621927e-02f, -7.74940699e-02f, -9.26003829e-02f,
  2.56325692e-01f, -5.56170084e-02f, -3.82491536e-02f, -1.91776484e-01f, 6.56942721e-04f, -6.22838177e-02f, 8.78132656e-02f, -4.89494801e-02f, -1.94710866e-02f, 6.03793859e-02f,
  3.33269648e-02f, 5.91574199e-02f, 4.07992154e-02f, -1.15043111e-02f, 1.05661653e-01f, -2.09981035e-02f, -7.96537027e-02f, -4.23082560e-02f, -1.04720198e-01f, 1.01069044e-02f,
  -1.32744640e-01f, -4.69768085e-02f, -6.34421632e-02f, -4.63130921e-02f, 4.07491885e-02f, -6.12188280e-02f, -4.57160100e-02f, 1.57102402e-02f, -2.59514023e-02f, 8.38926956e-02f,
  3.64516489e-02f, 3.07806730e-02f, 2.15318948e-02f, -6.86130999e-03f, 6.00984972e-03f, 2.63023768e-02f, 2.65762992e-02f, 7.21933246e-02f, 7.97202885e-02f, -5.13288863e-02f,
  8.72490834e-03f, 1.23849735e-01f, 8.64091218e-02f, -4.62664962e-02f, -2.96426136e-02f, 6.44911230e-02f, 3.29043269e-02f, 3.09446286e-02f, -6.72126636e-02f, 1.33150099e-02f,
  4.38528601e-03f, 5.73456287e-02f, 1.37561047e-02f, -4.04920708e-03f, -5.91576286e-02f, -5.30172177e-02f, 1.26451049e-02f, -3.65022607e-02f, -5.45034111e-02f, -5.42693436e-02f,
  2.29434833e-01f, -1.12859175e-01f, 8.53561759e-02f, -7.86756128e-02f, 8.52434784e-02f, -7.81617835e-02f, -3.74198370e-02f, -2.54735649e-02f, 3.67216095e-02f, -2.49167848e-02f,
  7.95855885e-04f, 1.51502723e-02f, 6.88132346e-02f, 6.90815300e-02f, -3.76629196e-02f, 3.30604054e-02f, 2.19212752e-02f, -1.23607954e-02f, -3.88845019e-02f, 8.20991322e-02f,
  5.90734147e-02f, 2.57160608e-02f, 7.28890672e-02f, 6.25266731e-02f, 3.10608912e-02f, -3.49452980e-02f, 8.65406841e-02f, 1.21453315e-01f, 4.55187187e-02f, 2.41797209e-01f,
  1.80203676e-01f, 1.38836429e-01f, 2.60167718e-01f, 2.42387563e-01f, 2.30050445e-01f, 2.24258676e-01f, 2.91382402e-01f, 1.55806690e-01f, -6.67421296e-02f, 1.30502626e-01f,
  -1.19198188e-01f, -2.35038832e-01f, -1.64485097e-01f, -1.31939605e-01f, 5.57164215e-02f, 2.76712358e-01f, 1.06175974e-01f, 1.07094422e-01f, 8.28991532e-02f, 6.10013753e-02f,
  -1.30107068e-02f, -1.29467519e-02f, -5.92981130e-02f, -6.63972422e-02f, 7.78641030e-02f, -4.92309183e-02f, 7.86767229e-02f, 3.55558060e-02f, -4.29472625e-02f, -1.32377353e-03f,
  -7.44508505e-02f, 2.80912429e-01f, -8.49182159e-02f, -1.35059595e-01f, -1.28228694e-01f, -1.44639716e-01f, -2.74744332e-02f, -6.81628361e-02f, -1.54982256e-02f, -1.26037365e-02f,
  -1.22417472e-02f, -7.40585625e-02f, 1.14562176e-02f, -1.33410409e-01f, 3.54807638e-02f, 7.34938309e-02f, -4.88685966e-02f, 6.76467791e-02f, 7.55432025e-02f, -9.57028661e-03f,
  1.04736751e-02f, 5.79306111e-03f, 3.11705582e-02f, 8.01029131e-02f, 1.35413170e-01f, -4.21835296e-02f, 1.12713285e-01f, 8.53940248e-02f, 1.08008251e-01f, 1.02660423e-02f,
  -9.13588516e-03f, 2.94928234e-02f, -2.47064810e-02f, 1.06617458e-01f, -2.16513202e-02f, -9.53941345e-02f, 4.25663218e-02f, -5.89817315e-02f, 1.43545538e-01f, 8.17643330e-02f,
  -4.83836159e-02f, 5.05123436e-02f, 1.60941072e-02f, 5.48624955e-02f, -1.64086856e-02f, 3.04744821e-02f, 3.33636776e-02f, -4.73565562e-03f, 2.87044328e-02f, -6.88503683e-02f,
  6.35950221e-03f, 4.82501946e-02f, -4.56628427e-02f, 3.28591838e-03f, -1.08247446e-02f, -1.21911233e-02f, -4.60043512e-02f, 7.63534149e-03f, -5.18792421e-02f, 3.14275473e-02f,
  -1.97743014e-01f, 3.54527906e-02f, -6.03377521e-02f, -4.82718460e-02f, 1.26661658e-01f, -9.51884016e-02f, -1.99194439e-02f, 3.29085477e-02f, -7.95196071e-02f, -4.48212847e-02f,
  -1.44269792e-02f, -2.59633958e-02f, 6.50408417e-02f, 8.02613199e-02f, 1.02119148e-01f, 2.75316387e-02f, -3.18220891e-02f, 3.24317254e-02f, -4.00842726e-02f, -3.94989317e-03f,
  -1.07115336e-01f, -2.58479510e-02f, 5.76718561e-02f, -5.60354702e-02f, -3.14371213e-02f, 4.09201421e-02f, -4.53397483e-02f, -4.97610606e-02f, -1.52446947e-03f, -1.62452944e-02f,
  3.84514242e-01f, -8.94463286e-02f, -4.98468876e-01f, 2.56328493e-01f, -2.53368288e-01f, -1.96121410e-01f, -8.54822993e-02f, 8.72842297e-02f, 2.11573899e-01f, -1.32403374e-01f,
  -6.17537908e-02f, 7.05169141e-02f, -1.81815289e-02f, 1.62513889e-02f, 7.44654313e-02f, -1.95761010e-01f, -2.29359180e-01f, -2.25888774e-01f, -4.01630141e-02f, 1.27112810e-02f,
  8.31003860e-02f, 1.03848018e-01f, 2.13964671e-01f, 9.98282358e-02f, -6.35544509e-02f, -3.47359143e-02f, -1.32419720e-01f, -1.83104888e-01f, -2.21594781e-01f, -3.07007939e-01f,
  -4.37402189e-01f, -1.55897485e-02f, -2.47560767e-03f, 1.51653087e-03f, -1.11558482e-01f, 3.49541381e-02f, -4.19480950e-02f, -1.01774514e-01f, 6.53261617e-02f, -8.09008703e-02f,
  1.67559572e-02f, 6.12847991e-02f, -8.59961286e-02f, -6.25650957e-02f, 3.20204273e-02f, -5.95252924e-02f, 4.98337522e-02f, -5.11668473e-02f, -2.70942189e-02f, -1.10305041e-01f,
  4.21399027e-02f, -1.08583368e-01f, -9.69103426e-02f, -5.17485552e-02f, -1.01661950e-01f, -8.39451477e-02f, -1.38364568e-01f, -1.47751952e-02f, -4.44771945e-02f, -9.89148915e-02f,
  -3.45851071e-02f, -1.44809540e-02f, -1.90201607e-02f, 7.13083241e-03f, 1.29104489e-02f, 6.45611435e-02f, -4.47982848e-02f, 6.63627684e-02f, 3.46614197e-02f, -1.02993429e-01f,
  -4.15982231e-02f, -5.06593734e-02f, 6.29711226e-02f, 4.89870124e-02f, 9.53093637e-03f, 8.68206471e-03f, 6.21358603e-02f, 6.73647746e-02f, -5.41960970e-02f, 6.82368279e-02f,
  -6.53789788e-02f, 1.97657794e-02f, 1.09142559e-02f, 6.19440787e-02f, -6.85090050e-02f, -1.30944308e-02f, -4.94503463e-03f, -9.11967084e-02f, 5.69176152e-02f, -6.88018417e-03f,
  2.08050787e-01f, -8.20192546e-02f, 8.93849134e-02f, 8.85225460e-02f, -3.64321955e-02f, -1.43865878e-02f, -2.53549125e-02f, -2.78133843e-02f, 7.65933767e-02f, 3.61790545e-02f,
  -7.42206955e-03f, 5.93856201e-02f, -1.95361059e-02f, 3.66948266e-03f, -4.92110513e-02f, -1.88165139e-02f, 4.38340902e-02f, -6.19442686e-02f, 2.33869255e-02f, 2.65974160e-02f,
  5.34518845e-02f, 1.58617541e-01f, 2.85251401e-02f, 3.39753665e-02f, 4.31644320e-02f, 5.77033497e-02f, -6.73132464e-02f, -3.62958610e-02f, 6.37943372e-02f, 2.25979164e-01f,
  1.94164068e-02f, -1.87250778e-01f, -1.22761548e-01f, -3.04070190e-02f, -9.07549709e-02f, -1.28358513e-01f, -1.72731265e-01f, 5.64721338e-02f, 1.21158324e-01f, -9.21208933e-02f,
  4.62228507e-02f, 1.58382788e-01f, 8.08300748e-02f, 6.64807558e-02f, -1.31536834e-02f, -4.11006846e-02f, -4.60406020e-02f, -7.60080293e-02f, 6.90340996e-02f, 1.12039685e-01f,
  -4.80837524e-02f, -1.26530288e-03f, 2.52296869e-02f, 4.12352756e-03f, -1.28427863e-01f, -2.13936195e-02f, -2.16448784e-01f, -4.64796461e-02f, -1.25873700e-01f, -2.16540590e-01f,
  -4.22015004e-02f, -3.82164717e-02f, 6.73622712e-02f, -1.11573692e-02f, -4.89334650e-02f, -6.02502935e-02f, -1.22894756e-02f, 6.66770563e-02f, 1.00968383e-01f, -7.17332736e-02f,
  7.61119127e-02f, 6.72830790e-02f, 3.45600061e-02f, 1.22111961e-01f, 9.64929014e-02f, -1.01962751e-02f, 5.78288510e-02f, 2.80504264e-02f, -1.30517498e-01f, -7.16521293e-02f,
  5.68791404e-02f, 7.56950676e-02f, 1.05941415e-01f, 7.97806978e-02f, 1.01535231e-01f, 6.85222447e-02f, -2.69839205e-02f, 8.79978109e-03f, -2.51228623e-02f, -9.05101523e-02f,
  -1.17165089e-01f, -4.73180488e-02f, -3.75927761e-02f, 4.04061563e-02f, 6.50307685e-02f, 8.79493803e-02f, -6.52631968e-02f, -1.09942205e-01f, 3.72153036e-02f, 7.49418861e-04f,
  2.07024184e-03f, 3.60707194e-02f, -4.20473702e-02f, -1.18545815e-02f, -9.92719084e-02f, -5.19791283e-02f, 4.81828116e-02f, -1.08775180e-02f, 9.18619148e-03f, -2.59388480e-02f,
  8.35824385e-02f, -2.51768120e-02f, 6.29298296e-03f, 4.36259359e-02f, 1.20244876e-01f, -3.25464383e-02f, 2.46637333e-02f, -1.80852860e-02f, 2.75672618e-02f, 7.71360379e-03f,
  -8.17249119e-02f, -1.04831252e-03f, -5.51217906e-02f, 4.76650409e-02f, 2.03903578e-02f, -4.39692736e-02f, -1.44315735e-01f, -4.35874686e-02f, -3.99547331e-02f, 4.94705811e-02f,
  8.95897970e-02f, 1.98891498e-02f, -8.75749290e-02f, -2.62365099e-02f, 3.37494239e-02f, 5.36110364e-02f, 7.69517422e-02f, -4.94287960e-05f, -1.35773672e-02f, 5.63697005e-03f,
  -1.47487614e-02f, 5.78879341e-02f, 8.82559568e-02f, 4.66838246e-03f, 2.60403734e-02f, 1.18850276e-01f, -1.49311274e-02f, -2.59530470e-02f, 5.89581616e-02f, -4.81788553e-02f,
  1.11289963e-01f, 6.90197349e-02f, -8.19637477e-02f, 9.48373377e-02f, 1.25074476e-01f, 1.80520453e-02f, 1.26882687e-01f, -5.52919731e-02f, 4.31944095e-02f, 6.88752010e-02f,
  5.22199906e-02f, -6.94414377e-02f, -2.23509669e-02f, 5.27752303e-02f, 4.02133055e-02f, 5.48395291e-02f, 1.01596229e-02f, -2.95409467e-02f, -4.46492955e-02f, 8.23056623e-02f,
  2.21271031e-02f, 3.51990610e-02f, 4.45616432e-03f, -2.64420640e-02f, 1.34081557e-01f, -7.53701255e-02f, 5.41927060e-03f, 9.03830156e-02f, 8.87118131e-02f, 1.00737512e-01f,
  -2.64764167e-02f, 6.98486045e-02f, -9.95008349e-02f, 8.54964405e-02f, -6.66826367e-02f, -2.16146167e-02f, -1.02506643e-02f, -1.94215290e-02f, -2.48126723e-02f, -6.99896365e-02f,
  -4.77814153e-02f, 1.29812453e-02f, 6.86912239e-02f, -8.09319317e-02f, 1.62294228e-02f, -1.87038686e-02f, 1.46127073e-02f, 4.97394067e-04f, -1.10702544e-01f, 2.81959735e-02f,
  -7.38321687e-04f, -4.53009456e-02f, -7.27281794e-02f, -3.76056060e-02f, -6.78830734e-03f, 4.03281115e-03f, -2.41103992e-02f, -3.52933281e-03f, -6.37402060e-04f, -4.54051569e-02f,
  -3.60423028e-02f, -9.37500075e-02f, -1.95253063e-02f, 6.16311189e-03f, 5.02507575e-02f, 1.70531925e-02f, 1.74660012e-02f, 6.00872338e-02f, -5.93111739e-02f, -4.22251783e-02f,
  4.11399314e-03f, -7.93132186e-02f, -5.64359576e-02f, -8.47297683e-02f, 3.40692885e-02f, 7.90581778e-02f, 3.50428559e-02f, 5.27052209e-02f, -7.63826072e-02f, -2.80268844e-02f,
  6.33269101e-02f, 5.03061749e-02f, -5.35832196e-02f, -2.34070960e-02f, 5.64737245e-02f, -3.22630145e-02f, -9.84909851e-03f, -4.67489511e-02f, 4.65056188e-02f, -1.90493446e-02f,
  -1.14864916e-01f, -1.56230614e-01f, 1.02072991e-01f, -5.00392318e-02f, -3.87867279e-02f, -7.74524584e-02f, 1.29539203e-02f, -7.06747472e-02f, -4.31856588e-02f, -1.81035195e-02f,
  4.77565639e-02f, -1.04149552e-02f, -5.56223877e-02f, -2.63553821e-02f, 8.77381396e-03f, 4.84066494e-02f, 1.57804172e-02f, 7.35594425e-03f, 3.18031609e-02f, -6.13747239e-02f,
  3.08544822e-02f, -1.45016015e-01f, -8.95672441e-02f, -1.00332327e-01f, -9.32903662e-02f, -1.33961082e-01f, 3.60645796e-03f, -1.20030418e-02f, -5.07462397e-02f, -1.08267404e-01f,
  9.63606089e-02f, -1.74107909e-01f, 2.46183928e-02f, 1.50388449e-01f, -1.63994934e-02f, -1.71116367e-01f, -4.41468865e-01f, -2.71001846e-01f, -9.63671505e-02f, -4.14810367e-02f,
  -1.76031236e-03f, 8.65514055e-02f, 9.15810615e-02f, 1.85248721e-02f, -7.81876445e-02f, -1.22023821e-01f, 1.10038549e-01f, 2.38788486e-01f, -1.32781528e-02f, 4.26670536e-02f,
  1.29096597e-01f, 2.26489276e-01f, 1.48736700e-01f, 3.31652649e-02f, 2.03338843e-02f, 9.70927253e-02f, -1.82882175e-02f, 7.95966163e-02f, -6.54730871e-02f, 3.48720610e-01f,
  3.58457118e-02f, -1.15766227e-01f, 2.01141071e-02f, 3.10627464e-02f, 1.22857705e-01f, -7.68399313e-02f, -6.17986135e-02f, 5.29271457e-03f, -4.66283923e-03f, -2.98974887e-02f,
  2.91531701e-02f, 5.52654155e-02f, -8.04928169e-02f, -2.04646401e-02f, 5.49974255e-02f, -2.72229873e-02f, -4.09218222e-02f, 1.03448320e-03f, 6.11715987e-02f, -2.12009940e-02f,
  1.64918695e-02f, 3.82874794e-02f, -7.26105794e-02f, -1.47990838e-01f, -1.72129348e-01f, 1.30244866e-01f, -3.28119472e-02f, -1.68618821e-02f, -9.72835720e-02f, -1.52489971e-02f,
  4.43137139e-02f, -4.98358384e-02f, 4.69371350e-03f, -9.37020406e-03f, 5.07442690e-02f, 1.85500197e-02f, 6.21724725e-02f, 3.58801894e-02f, 2.41568629e-02f, -4.44911420e-02f,
  2.89058629e-02f, 4.58253250e-02f, 3.28607881e-03f, -3.38343382e-02f, 2.58265827e-02f, -9.43442341e-03f, 8.30749273e-02f, 2.09791791e-02f, 1.37669528e-02f, 3.31578813e-02f,
  -2.93068606e-02f, 9.46190357e-02f, -1.45555269e-02f, 1.21899387e-02f, -2.09395345e-02f, -1.44887781e-02f, -1.92608275e-02f, -5.11865839e-02f, 2.75679734e-02f, 6.04063570e-02f,
  -3.94076034e-02f, 4.03196588e-02f, 6.10147119e-02f, 2.25778501e-02f, 1.98709611e-02f, 1.03245564e-01f, -4.64612991e-02f, 2.03333981e-02f, 5.27749732e-02f, -9.68635082e-02f,
  -1.27965719e-01f, 2.31060218e-02f, -2.99757253e-03f, 2.10752655e-02f, -9.14146099e-03f, 3.43614966e-02f, 4.19828370e-02f, -2.47654878e-02f, 6.82462566e-03f, 5.20357676e-02f,
  3.78439873e-02f, -1.40051201e-01f, -1.74010411e-01f, -1.59857959e-01f, -1.43114835e-01f, -8.44398290e-02f, 1.90893300e-02f, -4.91251387e-02f, -1.50284916e-01f, -6.49359375e-02f,
  -5.48201144e-01f, 8.13630596e-03f, -1.74425915e-01f, -1.84934050e-01f, 1.62438124e-01f, 1.99515611e-01f, 3.18054855e-01f, 3.80947813e-02f, -1.81253571e-02f, 5.55581786e-02f,
  -1.23867422e-01f, -4.30916622e-02f, -3.30981053e-02f, 2.49946751e-02f, -2.83915866e-02f, 2.07562312e-01f, 2.01628357e-01f, -9.99471322e-02f, -1.59972738e-02f, 8.17545205e-02f,
  1.49547502e-01f, -1.26726478e-01f, -2.71953672e-01f, -1.08981334e-01f, -5.60663640e-02f, -1.94068979e-02f, -1.08453885e-01f, -1.23131670e-01f, 7.11960942e-02f, 1.33231014e-01f,
  -1.48356885e-01f, -2.16000021e-01f, 9.89450589e-02f, 3.38277631e-02f, -5.47872894e-02f, -1.70186851e-02f, -3.57426004e-03f, -2.69056633e-02f, -8.79293829e-02f, 5.85331731e-02f,
  -7.92323425e-03f, -4.21660050e-04f, 3.85610424e-02f, -2.74654222e-03f, -1.68917961e-02f, 2.44806875e-02f, -8.16910118e-02f, -6.52587935e-02f, -5.27404714e-03f, 3.69850956e-02f,
  6.43538907e-02f, -4.13150666e-03f, -7.33442083e-02f, -1.59699225e-03f, 1.20000346e-02f, -7.85955265e-02f, -1.43119916e-01f, -1.09562069e-01f, 5.06458394e-02f, -5.86034730e-02f,
  8.72023627e-02f, 3.38738086e-04f, 2.91703623e-02f, -1.37081249e-02f, 4.62635122e-02f, -4.00764635e-03f, -7.29248971e-02f, 2.53202743e-03f, 4.19358201e-02f, -8.87884349e-02f,
  -1.22624384e-02f, 1.96860936e-02f, -5.41152246e-03f, -3.42368744e-02f, -3.65666300e-02f, 8.05507079e-02f, 6.95680967e-03f, 5.25488667e-02f, 2.70359907e-02f, 3.07735372e-02f,
  -2.38322411e-02f, 1.71776414e-02f, -8.64432231e-02f, -1.21543277e-02f, 4.08820771e-02f, 1.03419935e-02f, -2.13185661e-02f, -1.43048465e-02f, -5.99098206e-02f, -1.03274668e-02f,
  -7.76428580e-02f, 1.00066200e-01f, -1.17418095e-01f, 1.34516675e-02f, 3.63583229e-02f, -7.73167163e-02f, -5.46198674e-02f, -6.98160008e-02f, -5.83293028e-02f, -7.27099776e-02f,
  4.86082695e-02f, -4.84159738e-02f, -1.69633646e-02f, -1.12399943e-02f, -6.68223808e-03f, 6.15268461e-02f, 4.99132741e-03f, 2.37319842e-02f, 4.23294604e-02f, -1.12125585e-02f,
  8.66367891e-02f, 9.58493203e-02f, -1.58186391e-01f, 3.07457205e-02f, 3.49594280e-02f, -6.98892027e-02f, -3.66806686e-02f, -3.16348970e-02f, -5.99271804e-02f, 3.96424532e-02f,
  2.51918107e-01f, 1.77688539e-01f, -7.63021410e-02f, 5.50684072e-02f, -2.99156252e-02f, 6.01890869e-02f, 8.54340270e-02f, -1.95387322e-02f, -2.21341942e-02f, 7.49785453e-02f,
  4.07077670e-02f, -2.74929944e-02f, 4.14826013e-02f, -2.94947959e-02f, -2.79061161e-02f, 1.99650489e-02f, 8.06579515e-02f, -3.04098371e-02f, -1.30108371e-01f, -1.02286346e-01f,
  -4.20207605e-02f, 1.05725780e-01f, 1.93474442e-02f, 4.18488570e-02f, 1.11770749e-01f, -1.65724382e-01f, 1.54214706e-02f, -1.48850735e-02f, -1.07085761e-02f, 1.52934864e-01f,
  -1.51483133e-01f, 1.40108794e-01f, -2.41393685e-01f, 8.28542560e-02f, -6.46918416e-02f, 1.87963713e-02f, 4.00252678e-02f, 3.18139642e-02f, 3.00620385e-02f, 7.83626959e-02f,
  8.02230835e-02f, 1.16902674e-02f, -2.04656459e-02f, -2.53131371e-02f, -3.20027880e-02f, -1.55095011e-02f, 1.39563857e-02f, -3.25223058e-02f, 1.18833678e-02f, -8.74463618e-02f,
  9.16789169e-04f, -1.75637640e-02f, -1.53623894e-02f, 2.82921493e-02f, 5.66464709e-03f, -9.70649570e-02f, -2.23780647e-02f, 6.50162622e-03f, -4.10423912e-02f, -2.15838496e-02f,
  -8.28118995e-02f, -2.10962892e-02f, 1.65465772e-02f, -8.84339884e-02f, 5.87896723e-03f, -6.59487024e-02f, -1.14633612e-01f, -6.24555200e-02f, -6.33751079e-02f, 5.27491122e-02f,
  2.04806700e-02f, 1.25985714e-02f, 2.15505734e-02f, -8.91918540e-02f, -1.70559797e-03f, 4.02179472e-02f, -9.26929638e-02f, 1.88377779e-02f, -8.54222924e-02f, 5.29200509e-02f,
  7.69361155e-03f, -9.73922946e-03f, -5.29237464e-02f, 3.11291069e-02f, -4.59380215e-03f, 1.47633897e-02f, -5.79837151e-02f, 7.58212432e-02f, 5.48503846e-02f, -1.01045584e-02f,
  -1.63064882e-01f, -2.10129827e-01f, -1.58288315e-01f, 3.72760370e-02f, -4.68092896e-02f, 6.56423196e-02f, 6.65031374e-02f, 3.11675519e-02f, 1.16180338e-01f, -3.80757749e-02f,
  -3.31164114e-02f, 7.75422435e-03f, 6.61829039e-02f, -5.59891649e-02f, -7.88313746e-02f, 6.45875931e-02f, 3.53903733e-02f, -6.00010715e-02f, -5.22956476e-02f, 1.35891689e-02f,
  -3.56591493e-02f, 8.28002840e-02f, -1.15310885e-01f, 6.58273324e-02f, -4.07630540e-02f, -1.08170576e-01f, -8.77626427e-03f, -1.10709086e-01f, -1.15819126e-01f, -5.07926233e-02f,
  -4.39417064e-01f, -4.14137729e-02f, -2.13959247e-01f, -1.33551002e-01f, 2.42520079e-01f, 1.60261795e-01f, 1.24690294e-01f, 1.82014890e-02f, -1.00586720e-01f, 4.49498259e-02f,
  2.79436056e-02f, 1.47287607e-01f, 2.57895868e-02f, 1.20834187e-01f, 2.82668266e-02f, 1.38686478e-01f, 1.42262667e-01f, 7.77053833e-02f, -1.71027094e-01f, 4.56944704e-02f,
  2.03535661e-01f, -1.42051831e-01f, -2.22540066e-01f, -4.09244671e-02f, 2.56372076e-02f, 2.00276915e-02f, -8.43421556e-03f, -8.96715745e-02f, -3.55103426e-02f, 2.21114025e-01f,
  -4.38157693e-02f, -1.53541490e-01f, 1.88786238e-02f, 5.07264175e-02f, 1.53671000e-02f, -1.58797845e-01f, -8.24390575e-02f, -8.51117373e-02f, -2.55930591e-02f, -1.60112642e-02f,
  -5.11297658e-02f, 9.23661515e-02f, 7.02156350e-02f, 4.38754447e-02f, -6.18754067e-02f, -3.51095153e-03f, 2.19738271e-04f, -7.52679110e-02f, -1.31779522e-01f, -5.86146340e-02f,
  9.07601565e-02f, -2.27380870e-03f, -6.46268651e-02f, -5.24753779e-02f, -4.75952066e-02f, -1.49202468e-02f, -1.19098514e-01f, -8.77087340e-02f, -9.39885750e-02f, -5.05245812e-02f,
  2.00252682e-02f, 1.40231559e-02f, 4.38623242e-02f, 4.53844666e-02f, 4.78613712e-02f, -1.94190256e-03f, 8.80900696e-02f, 3.46689373e-02f, 4.08490896e-02f, -1.02941573e-01f,
  3.96316312e-02f, 3.67307328e-02f, 4.00276631e-02f, 4.45543565e-02f, -1.83150284e-02f, -1.84295774e-02f, 9.14199054e-02f, -7.70817976e-03f, 6.63421899e-02f, -7.94283152e-02f,
  3.80354039e-02f, -4.73251715e-02f, 1.48735614e-02f, 2.26385761e-02f, 5.50165474e-02f, -4.34889011e-02f, -7.18414970e-03f, 6.38931117e-04f, -6.52832165e-02f, -1.95215158e-02f,
  -2.84961581e-01f, 6.87804893e-02f, 2.91847289e-02f, -2.36861594e-02f, -3.01713101e-03f, 2.26525161e-02f, 5.39569482e-02f, -3.00515443e-02f, -2.48408820e-02f, -8.91889259e-03f,
  -1.85624845e-02f, -5.94069101e-02f, -1.23002734e-02f, 1.28700966e-02f, -1.14311464e-01f, -6.84533864e-02f, 6.60771579e-02f, 3.40873525e-02f, -4.98961434e-02f, -1.20645761e-01f,
  -6.33402094e-02f, -1.12464853e-01f, -1.51509136e-01f, -1.41991032e-02f, -6.19290993e-02f, 2.00231448e-02f, -1.26398519e-01f, -1.18120536e-01f, -1.59170508e-01f, -1.55738398e-01f,
  5.18549860e-01f, 1.79880559e-01f, 1.02652684e-01f, 1.37909278e-01f, -3.37675586e-02f, 6.47367463e-02f, 8.71009305e-02f, -3.69560905e-02f, -2.93981358e-02f, 1.54368386e-01f,
  6.41004965e-02f, -2.66512278e-02f, -4.47675325e-02f, -2.33352073e-02f, -5.30621558e-02f, -4.88218218e-02f, 4.53684106e-02f, 7.51414429e-03f, -1.24392793e-01f, 3.11538037e-02f,
  2.87482496e-02f, 1.31256312e-01f, 1.31628096e-01f, -4.95443167e-03f, 9.20742750e-02f, -1.02108359e-01f, 6.46805530e-03f, 9.28178057e-02f, 3.82773764e-02f, 2.01659039e-01f,
  1.36260372e-02f, 3.17055672e-01f, -2.27807045e-01f, 8.24550390e-02f, 3.85464691e-02f, 3.71391885e-02f, 1.13655105e-01f, -1.15587944e-02f, 2.38833390e-02f, -4.53277770e-03f,
  -3.18239257e-02f, 1.57796517e-01f, 1.11807212e-01f, 5.42077003e-03f, 6.97169825e-02f, 5.74985100e-03f, 4.75520752e-02f, 1.61739990e-01f, -4.54967320e-02f, 4.51582409e-02f,
  6.78511113e-02f, -1.47836152e-02f, 7.33123645e-02f, -5.11634815e-03f, 6.42659292e-02f, -9.34299156e-02f, -7.85620734e-02f, 9.62305441e-02f, -1.10057227e-01f, 1.24182388e-01f,
  2.38755089e-03f, 1.53814644e-01f, 5.93471006e-02f, -6.66794134e-03f, 2.57536024e-02f, 7.62972236e-03f, -5.93129992e-02f, 6.75351219e-03f, -3.06161325e-02f, -2.67731939e-02f,
  -4.44162190e-02f, -3.51614505e-02f, 7.65478164e-02f, -4.86178603e-03f, -5.23050316e-02f, 8.76296535e-02f, -3.04424725e-02f, 1.21242944e-02f, 1.19791850e-01f, 2.24071182e-03f,
  6.84142262e-02f, 5.94022311e-02f, -1.06359990e-02f, -5.32862693e-02f, 2.41003986e-02f, 6.79156859e-04f, 1.26926629e-02f, 4.11654599e-02f, 7.98651874e-02f, 1.17820069e-01f,
  -2.24476203e-01f, -1.35380879e-01f, -1.03519782e-01f, 2.03766599e-02f, -2.34709196e-02f, -1.59000084e-02f, 9.80543643e-02f, -6.80987686e-02f, -8.34724121e-03f, -5.58017427e-03f,
  1.02434997e-02f, -2.63980553e-02f, -6.51009679e-02f, 4.99645285e-02f, -9.65398550e-03f, -1.30486386e-02f, -1.09214783e-01f, -5.65453582e-02f, -2.16447152e-02f, -1.00304544e-01f,
  -7.51966685e-02f, -8.72984305e-02f, -1.33359045e-01f, -1.75547615e-01f, -5.79304062e-02f, -1.70128122e-01f, -8.72047022e-02f, -7.22237453e-02f, -1.72453314e-01f, -1.90125465e-01f,
  -3.11723113e-01f, -2.46285409e-01f, 7.67444000e-02f, -5.34915589e-02f, 1.03145480e-01f, 3.06098635e-04f, -1.22601055e-01f, -1.96885750e-01f, -2.59970576e-02f, -8.87129158e-02f,
  -7.19265565e-02f, 5.87263331e-02f, -7.57379085e-02f, 5.10294139e-02f, -2.76518226e-01f, -2.09302098e-01f, -1.12960994e-01f, -7.36307353e-02f, 8.02897736e-02f, 5.44955172e-02f,
  -3.96728888e-03f, -5.31704798e-02f, -8.38631317e-02f, 4.23833802e-02f, -6.47287518e-02f, 5.86345829e-02f, 2.23791040e-02f, -9.67990011e-02f, 2.34829150e-02f, 3.04805171e-02f,
  -5.45351766e-02f, -6.28078058e-02f, 4.84499298e-02f, 7.51081705e-02f, 3.56332213e-02f, -7.93078244e-02f, -2.59374026e-02f, 1.45469839e-02f, 1.54784508e-02f, -7.24785030e-02f,
  -4.96569648e-02f, 2.93896329e-02f, -2.55926754e-02f, 6.81427419e-02f, -1.16284281e-01f, -1.11665890e-01f, 1.43854050e-02f, -2.52634007e-02f, 4.65414301e-03f, -1.38973057e-01f,
  -2.42248829e-03f, 8.22489187e-02f, -3.10279820e-02f, -1.09045312e-01f, -2.81131035e-03f, 6.17370754e-02f, -4.17738520e-02f, -1.08513795e-01f, -8.69760662e-02f, -1.19845279e-01f,
  8.08723718e-02f, 5.22775128e-02f, -3.93804498e-02f, -1.06834128e-01f, 1.71803050e-02f, -2.28831768e-02f, 5.27385063e-02f, 3.37179154e-02f, 2.45872904e-02f, -1.09732309e-02f,
  3.52849327e-02f, -3.75858508e-02f, 5.44773377e-02f, -5.82066327e-02f, 1.00778192e-01f, 4.08244580e-02f, 6.90619200e-02f, -3.41952406e-02f, -2.32546274e-02f, 4.73543350e-03f,
  -4.56517823e-02f, 2.14577019e-02f, 4.43305783e-02f, 1.98838580e-02f, 7.31252786e-03f, 3.00936308e-02f, 1.13207782e-02f, -6.27061501e-02f, -4.31734398e-02f, 1.31999955e-01f,
  -2.90661044e-02f, 1.11208335e-01f, -7.81204477e-02f, -1.08751595e-01f, 3.06343082e-02f, 1.48216840e-02f, 1.29306633e-02f, -3.59486118e-02f, -2.81433878e-03f, -3.81098874e-02f,
  -8.27070400e-02f, -4.42319773e-02f, 1.55429430e-02f, 9.07491371e-02f, 3.64514329e-02f, -9.67895985e-02f, 1.83301121e-02f, -7.82480687e-02f, -5.40114827e-02f, -2.24975939e-03f,
  -1.62805524e-02f, -1.80336386e-01f, -2.08805412e-01f, -9.06125307e-02f, -5.88167571e-02f, -1.00552112e-01f, -1.31162271e-01f, -8.36197883e-02f, -1.74897298e-01f, -3.16267580e-01f,
  1.92669518e-02f, -1.86687902e-01f, 1.39224425e-01f, 2.40415812e-01f, 3.42142433e-01f, 2.36312687e-01f, 2.16576785e-01f, 8.35594460e-02f, 1.98380835e-02f, 1.32740691e-01f,
  -2.70119887e-02f, -1.41652167e-01f, -1.16115898e-01f, -1.90208271e-01f, -1.22999057e-01f, 1.32752240e-01f, 2.72341430e-01f, 4.31816094e-02f, 3.41585837e-02f, -3.19909491e-02f,
  2.94254590e-02f, -7.96463862e-02f, -2.09115654e-01f, -1.27182782e-01f, -1.57705676e-02f, 3.89674306e-02f, 7.09683895e-02f, -1.68689519e-01f, -1.06479526e-01f, -1.13052174e-01f,
  -1.79790869e-01f, 1.70657504e-02f, 3.71269695e-02f, 2.80581117e-02f, -5.18460386e-03f, -4.30422500e-02f, -1.07915152e-03f, -1.40388712e-01f, 1.46135222e-02f, -5.74148335e-02f,
  7.45457113e-02f, 3.50469202e-02f, -1.28702857e-02f, -8.28027874e-02f, -5.24470657e-02f, 1.26221394e-02f, -1.04269668e-01f, -8.10678527e-02f, -6.00076560e-03f, -3.53276283e-02f,
  -2.02649888e-02f, -8.25642888e-03f, 7.87328556e-02f, 1.01077333e-01f, 3.04068550e-02f, 2.29530241e-02f, -5.77434078e-02f, -4.05722186e-02f, -1.10829152e-01f, -9.94834229e-02f,
  1.24075729e-02f, -4.98945601e-02f, 8.01372454e-02f, -6.97070211e-02f, -5.78690693e-02f, 4.36402895e-02f, 4.47917730e-02f, -3.04561872e-02f, 1.86154954e-04f, -4.53792848e-02f,
  -5.39731868e-02f, 8.29385892e-02f, -5.28710671e-02f, 2.54850872e-02f, -3.12376618e-02f, 3.13715264e-02f, -2.87276097e-02f, -4.21814024e-02f, -8.61431882e-02f, 7.23659024e-02f,
  -4.88868691e-02f, 7.45951682e-02f, 1.52118485e-02f, 4.77084443e-02f, -3.81011353e-03f, -2.10267846e-02f, -5.66491683e-04f, -3.68028879e-02f, -4.25158143e-02f, 5.90420589e-02f,
  -1.35406017e-01f, 1.50334716e-01f, -2.31053066e-02f, -7.91954994e-02f, 6.48464635e-03f, -1.08336613e-01f, 6.43049274e-03f, -3.58658060e-02f, 9.73030254e-02f, 3.69383506e-02f,
  -6.56130239e-02f, 5.11613153e-02f, -2.59604361e-02f, -1.33490248e-03f, 1.03339970e-01f, -1.07108895e-02f, -3.37745622e-02f, 4.33820225e-02f, -2.03826521e-02f, -7.53981769e-02f,
  -3.20610590e-02f, 1.26677528e-01f, 2.02646311e-02f, 1.93994734e-02f, -3.44090015e-02f, 5.08090295e-02f, 1.10403858e-02f, 2.14569997e-02f, 8.06646198e-02f, 3.54586020e-02f,
  8.15916434e-02f, -7.93138519e-02f, -3.09047718e-02f, -9.96364132e-02f, -2.13104952e-02f, -8.35505351e-02f, -1.72181189e-01f, 1.12761091e-02f, 2.37986669e-02f, -8.31850022e-02f,
  -1.63082462e-02f, 1.75542817e-01f, 1.79509863e-01f, 1.08264171e-01f, 1.00928321e-01f, -1.26525939e-01f, -1.18770252e-03f, 8.10460076e-02f, 1.38209373e-01f, -9.23046190e-03f,
  -3.40342298e-02f, -6.15128018e-02f, -1.10875471e-02f, 3.62026617e-02f, -5.39887510e-02f, 5.32570183e-02f, 1.62116848e-02f, -8.31351504e-02f, 3.88102718e-02f, -7.82870576e-02f,
  -5.86439334e-02f, 7.28016421e-02f, 1.47934914e-01f, -1.42382830e-02f, 1.90958381e-02f, -8.76202807e-03f, -4.38588783e-02f, 2.45250366e-03f, -2.55592875e-02f, -1.18034273e-01f,
  1.42991180e-02f, -1.16203511e-02f, 6.34553879e-02f, -3.47106270e-02f, 3.39777656e-02f, 9.00586229e-03f, 4.74968478e-02f, 1.21559083e-01f, 4.28770296e-02f, -1.33368120e-01f,
  6.21822514e-02f, 5.31647801e-02f, 1.03570655e-01f, 8.12828317e-02f, 1.42097980e-01f, 1.16852313e-01f, 8.95135552e-02f, 1.13423713e-01f, 1.08045787e-01f, 9.68461856e-03f,
  -6.62608445e-02f, 8.14163499e-03f, -2.63972990e-02f, -2.86253821e-02f, 6.92172423e-02f, 9.49667394e-02f, -1.02566011e-01f, 4.53638993e-02f, 4.11782637e-02f, 2.59827953e-02f,
  -1.57900266e-02f, -4.45460379e-02f, -2.80528255e-02f, -2.03344803e-02f, 5.14588468e-02f, 3.75219900e-03f, 2.55775135e-02f, 3.87767144e-02f, 4.82893586e-02f, -2.48357896e-02f,
  4.51483130e-02f, 6.75932318e-02f, -1.10489437e-02f, -7.05725402e-02f, -5.11269458e-02f, -2.53618974e-02f, 8.14914121e-04f, -8.64810217e-03f, 8.78452957e-02f, 9.57451202e-03f,
  1.67651419e-02f, 1.74260661e-01f, 1.29144164e-02f, 2.91557591e-02f, 2.88792010e-02f, 6.85721710e-02f, -2.87744757e-02f, 7.56301684e-03f, 4.01910767e-03f, 1.85470786e-02f,
  4.90632318e-02f, -8.03587362e-02f, 2.83284672e-02f, 9.20203142e-03f, -1.93977952e-02f, -1.36161139e-02f, 3.47142182e-02f, 9.26742107e-02f, 3.01234759e-02f, 1.03392400e-01f,
  -1.08727543e-02f, 3.87747921e-02f, 7.90971071e-02f, 7.00270161e-02f, 2.75156200e-02f, 4.56845760e-02f, 1.34081125e-01f, 8.79511517e-03f, 8.70033130e-02f, -1.07179694e-01f,
  -8.37328508e-02f, -2.51128897e-02f, 8.96817595e-02f, 1.73846614e-02f, 2.87382565e-02f, 7.07971379e-02f, -4.59237359e-02f, 2.93950760e-03f, -3.69132906e-02f, -1.40380904e-01f,
  -9.63562578e-02f, 2.27185730e-02f, 3.54691073e-02f, 7.40764737e-02f, -4.61123884e-02f, -6.88223541e-02f, -1.62959233e-01f, 9.47389975e-02f, -3.31598148e-02f, -2.57643051e-02f,
  -8.52856487e-02f, 3.01098116e-02f, -8.43542591e-02f, 4.46741842e-02f, -1.98128372e-01f, -3.30559239e-02f, -2.74516642e-02f, -1.31999552e-01f, -1.09107502e-01f, -1.59636974e-01f,
  -7.28549883e-02f, -9.50688310e-03f, -2.96533182e-02f, 3.30282934e-02f, 3.76377739e-02f, 1.01921573e-01f, -3.77775319e-02f, 4.11964618e-02f, 8.37057531e-02f, 3.33770998e-02f,
  6.36051446e-02f, 6.42765313e-03f, -7.88565576e-02f, 8.14466625e-02f, -2.50730123e-02f, 5.46901226e-02f, -2.32887845e-02f, -3.76226269e-02f, 2.49846447e-02f, 3.10356300e-02f,
  -2.37561688e-02f, -8.48799273e-02f, -5.29175885e-02f, -6.43183589e-02f, 2.63605472e-02f, 2.92447917e-02f, 1.19806863e-02f, -4.34511267e-02f, -6.59055784e-02f, -9.71703827e-02f,
  -2.06329133e-02f, 1.60294045e-02f, -5.96791096e-02f, -3.95634510e-02f, 6.69693425e-02f, -6.28575236e-02f, 9.45413560e-02f, 1.14057986e-02f, -2.84249634e-02f, -5.28064556e-02f,
  7.56567111e-04f, -2.35653911e-02f, -9.86799132e-03f, -5.92001230e-02f, -8.40242393e-03f, -9.15347785e-02f, -5.27520180e-02f, -1.01364695e-03f, -3.98231745e-02f, -5.05630746e-02f,
  -5.36125265e-02f, 4.89388034e-02f, 2.63680331e-02f, -1.49935959e-02f, 4.62310687e-02f, 2.41061822e-02f, 1.29180215e-02f, -2.53585428e-02f, -8.38197023e-02f, -3.13922502e-02f,
  -7.02698603e-02f, 6.37199059e-02f, 6.70172498e-02f, -1.35341780e-02f, -4.21344638e-02f, -6.04037717e-02f, 1.32464673e-02f, 7.04417899e-02f, 6.02567643e-02f, 4.81473207e-02f,
  1.11234402e-02f, -9.96659771e-02f, 4.11907062e-02f, -7.75489584e-02f, 2.26335204e-03f, -7.09928796e-02f, -9.37701091e-02f, 4.80269566e-02f, -2.92590130e-02f, -1.02638453e-01f,
  2.08628848e-02f, -9.27858874e-02f, 3.30214947e-02f, 9.63781681e-03f, -4.38440703e-02f, -3.47947143e-02f, -6.42533079e-02f, -3.72506375e-03f, 6.69481680e-02f, -1.18416280e-01f,
  -2.03955527e-02f, 1.29059628e-01f, 4.27735634e-02f, -8.19267705e-02f, 8.28325599e-02f, -2.41061226e-02f, 1.19822174e-01f, 4.36203778e-02f, -6.89754933e-02f, 1.18062437e-01f,
  1.01372721e-02f, 4.80209105e-02f, -9.52203870e-02f, -1.12894662e-01f, 8.02310277e-03f, 6.11057915e-02f, 1.94507390e-02f, -1.51628042e-02f, -1.94666013e-01f, -1.13797888e-01f,
  -1.28036654e-02f, -5.26091084e-02f, -5.19826263e-02f, -1.36518598e-01f, 6.29322231e-02f, -4.23411131e-02f, -7.21592605e-02f, 3.89176384e-02f, -7.97690153e-02f, 7.59608373e-02f,
  5.72318248e-02f, 1.26106828e-01f, -1.01320431e-01f, -1.03627473e-01f, -4.28824797e-02f, -2.11517140e-02f, -7.26295784e-02f, 2.59007867e-02f, -1.10001162e-01f, 2.09591184e-02f,
  1.56927370e-02f, 3.83467898e-02f, 2.47058012e-02f, 4.75107394e-02f, -7.57505745e-02f, -1.01379432e-01f, -9.11712721e-02f, -8.69102851e-02f, -1.33023709e-01f, 5.40985651e-02f,
  9.23278704e-02f, 9.08573121e-02f, 6.36257604e-02f, -1.24204874e-01f, -1.24035198e-02f, -1.73131675e-02f, -3.40459161e-02f, -4.34134007e-02f, -5.47342114e-02f, 3.39718908e-02f,
  1.61105506e-02f, -3.35259251e-02f, 3.13483998e-02f, 3.59795615e-02f, 1.47089353e-02f, -3.03323977e-02f, -7.34888613e-02f, -8.48874599e-02f, -3.40701193e-02f, 3.95434014e-02f,
  -4.47127521e-02f, 7.80643076e-02f, -9.37684905e-03f, 7.94774890e-02f, 7.33405277e-02f, 4.26797047e-02f, -6.14121892e-02f, -6.00303002e-02f, 5.43652335e-04f, 1.30259758e-02f,
  -1.19301222e-01f, -1.82604939e-02f, 9.38252488e-04f, 9.11844987e-03f, -6.63227737e-02f, -5.75591885e-02f, 7.87595883e-02f, 5.25255362e-03f, -3.97976302e-03f, 2.57528834e-02f,
  -2.18688976e-02f, -6.58365339e-02f, 2.34728958e-02f, -4.81731221e-02f, 4.04551905e-03f, 5.33331046e-03f, 1.97141171e-02f, -8.09272975e-02f, -4.09711935e-02f, -3.68400700e-02f,
  2.60716435e-02f, -4.16322462e-02f, 4.41678278e-02f, -2.15941537e-02f, -3.57790627e-02f, -6.21305779e-02f, -9.30312648e-03f, 2.68689040e-02f, -2.22391821e-02f, 5.04624210e-02f,
  -4.08688560e-02f, -5.95743693e-02f, 1.61719099e-02f, -7.30167031e-02f, 2.06707176e-02f, -1.13271236e-01f, 4.63527348e-03f, -1.38037592e-01f, -2.87464224e-02f, -5.93516193e-02f,
  1.47298006e-02f, -6.16581999e-02f, -4.67892084e-03f, 5.59507161e-02f, -6.11616252e-03f, -6.56713471e-02f, 1.27363175e-01f, -1.86085720e-02f, 9.20474231e-02f, 1.10386506e-01f,
  -8.20650086e-02f, -1.42904386e-01f, -1.96004026e-02f, -2.95629278e-02f, -8.68715644e-02f, -4.99833636e-02f, 4.29624207e-02f, -1.66583776e-01f, -1.14423715e-01f, 4.31883298e-02f,
  -3.58438864e-02f, 1.29612153e-02f, -1.15800858e-01f, 2.44399738e-02f, -2.53544975e-04f, -4.99929711e-02f, 8.05150568e-02f, -7.85450563e-02f, -1.28772752e-02f, -6.99997246e-02f,
  1.03253238e-01f, -1.78437591e-01f, 3.38432752e-02f, 1.41105428e-02f, -1.62087288e-02f, 5.92628345e-02f, 5.68861607e-03f, -4.46173437e-02f, 3.64790596e-02f, 3.42227495e-03f,
  -7.15254992e-02f, -5.77614643e-02f, 2.54247021e-02f, -1.19011760e-01f, -7.95450658e-02f, -2.49249078e-02f, 3.16370837e-03f, -1.53048486e-01f, -5.73322661e-02f, -5.69570325e-02f,
  -7.58988932e-02f, -1.41699076e-01f, -1.28592834e-01f, -6.87598716e-03f, -1.28749594e-01f, -1.88757449e-01f, -7.96635821e-02f, -7.73362592e-02f, -1.64848074e-01f, -1.69329476e-02f,
  2.09415313e-02f, 1.93036199e-02f, -8.63996744e-02f, 4.32874039e-02f, 2.39480138e-02f, -4.63560820e-02f, 7.46876607e-03f, -9.84976590e-02f, -2.14256514e-02f, 5.45574054e-02f,
  -8.15502256e-02f, 5.63425012e-02f, -3.29979695e-02f, 4.02412144e-03f, 4.04093489e-02f, 4.89714779e-02f, 3.78152095e-02f, 5.79308793e-02f, 1.79775879e-02f, -5.57481486e-04f,
  3.93622778e-02f, -1.41238598e-02f, 7.09046200e-02f, 2.17919005e-03f, -1.89212617e-02f, 1.31793541e-03f, 3.22507359e-02f, -2.13514622e-02f, -2.56063957e-02f, 5.76472729e-02f,
  1.76900372e-01f, -1.90413192e-01f, 1.53590903e-01f, 6.69181943e-02f, 1.03841461e-02f, 4.52267155e-02f, -1.91461053e-02f, 5.31178564e-02f, -6.42252341e-02f, 9.55891237e-02f,
  -8.56977552e-02f, 2.79213209e-03f, -9.29881781e-02f, 5.51295280e-02f, -3.44396867e-02f, 4.57070731e-02f, 9.67426002e-02f, 1.56960124e-03f, 6.09198809e-02f, 1.17923617e-02f,
  1.57034203e-01f, 3.04293819e-02f, -6.19440386e-03f, 5.92423864e-02f, -2.98016481e-02f, -8.08920786e-02f, -5.26183285e-02f, 1.04361907e-01f, -1.78920256e-03f, 2.53876925e-01f,
  -6.16700470e-01f, -1.30307347e-01f, 3.83008681e-02f, -2.05807924e-01f, 4.08078581e-02f, 1.33807927e-01f, 1.14207543e-01f, 1.65924802e-02f, -2.68348176e-02f, -6.42148778e-02f,
  -8.64484310e-02f, -1.73822701e-01f, -1.57299832e-01f, -1.22344054e-01f, -4.91522960e-02f, -1.12024643e-01f, -1.07785679e-01f, -1.49573326e-01f, -1.19769640e-01f, 5.36384759e-03f,
  -8.29956755e-02f, -1.09597877e-01f, -2.71944165e-01f, -1.96022410e-02f, 3.37112620e-02f, -1.27915666e-01f, -9.02725160e-02f, -6.85431287e-02f, 1.64653108e-01f, -6.47089332e-02f,
  -1.14145920e-01f, 5.79603612e-02f, -1.14406347e-02f, 1.76800229e-02f, -4.60941866e-02f, -3.25977132e-02f, 2.59234086e-02f, -6.09196797e-02f, 6.82805479e-02f, 7.17156008e-03f,
  -6.29642457e-02f, 4.68723178e-02f, -7.48283416e-02f, -6.56163087e-03f, 3.81818861e-02f, -9.13132913e-03f, -4.43049595e-02f, -7.02612195e-03f, 9.36298445e-02f, 1.67666450e-01f,
  7.67501891e-02f, 6.08630106e-02f, -1.13097891e-01f, 1.31917372e-01f, 7.38253370e-02f, -3.86931896e-02f, 1.65292755e-01f, 2.18560219e-01f, 1.43718377e-01f, -5.43366782e-02f,
  8.04311708e-02f, -4.86888438e-02f, 2.63031106e-02f, -4.85292003e-02f, -3.92571278e-02f, -1.20198475e-02f, -3.97744663e-02f, -1.72967222e-02f, -5.54007366e-02f, -4.96247523e-02f,
  3.93189769e-03f, 2.82331295e-02f, -1.66709125e-02f, -1.25369251e-01f, 2.87597403e-02f, 1.81473680e-02f, 1.14688508e-01f, 5.67972101e-02f, 5.49982302e-02f, 4.75318693e-02f,
  2.88583152e-03f, 9.08206329e-02f, -1.25160664e-01f, -3.24781872e-02f, 1.04710691e-01f, -1.33649670e-02f, 6.25732318e-02f, 6.16831668e-02f, -3.60789187e-02f, -6.10850193e-02f,
  -3.40605289e-01f, 5.68456128e-02f, -1.92181811e-01f, -6.22040853e-02f, 1.41478889e-03f, 8.87191296e-02f, -6.20182743e-03f, -3.50440592e-02f, -5.01901330e-03f, 1.06755802e-02f,
  1.32753447e-01f, -8.72477964e-02f, -4.49894629e-02f, 1.20482467e-01f, 1.14245843e-02f, 9.25671309e-02f, -3.05903796e-02f, -6.31984398e-02f, 8.50423425e-02f, 2.66918186e-02f,
  3.46577838e-02f, 1.84317920e-02f, -3.05792749e-01f, -9.08516049e-02f, 2.40770783e-02f, -2.31347218e-01f, -1.11232959e-02f, 6.04567043e-02f, -9.81300250e-02f, -2.80716449e-01f,
  -1.11582302e-01f, -1.10900979e-02f, 2.70648096e-02f, -4.03431393e-02f, -2.36221999e-02f, 1.03574172e-01f, -7.16971382e-02f, -8.30652658e-03f, 1.59361333e-01f, -2.68946253e-02f,
  -5.15134446e-03f, -7.19499812e-02f, -2.12188642e-02f, -1.30747214e-01f, -1.13653868e-01f, -3.77234407e-02f, -1.57163814e-01f, -9.94313806e-02f, 3.80996354e-02f, 1.00810699e-01f,
  -9.53891799e-02f, -8.23291242e-02f, -8.33766982e-02f, -4.63880338e-02f, -4.52590138e-02f, -1.57647148e-01f, -3.85186449e-02f, -1.45948917e-01f, -3.96037363e-02f, -2.39942253e-01f,
  -1.20373473e-01f, 6.85346201e-02f, 3.62048298e-02f, -1.25395969e-01f, 5.31690866e-02f, 1.45850539e-01f, 7.85704032e-02f, 7.55686462e-02f, -2.80916076e-02f, 5.33841439e-02f,
  -7.38840103e-02f, 5.35552874e-02f, -6.68958500e-02f, 7.18654245e-02f, 1.93603616e-02f, -1.75668076e-02f, 8.19772258e-02f, 8.49697180e-03f, -4.09763828e-02f, 4.47420329e-02f,
  -8.81008804e-03f, -8.99915770e-02f, -4.90716286e-02f, -2.32535936e-02f, 1.80964358e-02f, -7.17959180e-02f, -5.43442443e-02f, 2.57448256e-02f, -9.07450169e-02f, -2.62452289e-02f,
  -6.18786085e-03f, -2.99849641e-02f, -4.11062986e-02f, -4.88212518e-02f, -1.21000409e-02f, 6.40682951e-02f, 1.11535043e-02f, -1.16765514e-01f, -2.43179146e-02f, 1.45914219e-02f,
  -2.67196223e-02f, -3.36420313e-02f, 5.92667162e-02f, -6.38124123e-02f, -1.87680591e-02f, 2.99670584e-02f, -1.39812976e-01f, 3.61804821e-04f, 7.47396611e-03f, -2.19967067e-02f,
  -4.01069522e-02f, -1.18115738e-01f, -7.25066960e-02f, 4.67758067e-02f, 1.94546469e-02f, 3.55842933e-02f, -4.18771338e-03f, 3.87925766e-02f, 4.02803067e-03f, -4.26277034e-02f,
  3.21999826e-02f, -9.76909995e-02f, 3.59277539e-02f, 1.38221774e-02f, -3.99305485e-02f, 4.50847205e-04f, -2.72102524e-02f, -4.15615225e-03f, 3.12666548e-03f, -1.19785349e-04f,
  3.87101807e-02f, -6.64346516e-02f, -6.03568032e-02f, 5.27319424e-02f, 4.84504141e-02f, -6.15170179e-03f, -8.97278562e-02f, -1.29619047e-01f, -7.51614757e-03f, 1.00565329e-01f,
  -4.65446152e-02f, 2.02306062e-02f, -1.02356791e-01f, -8.27814415e-02f, 6.94289878e-02f, -7.44356066e-02f, -9.48278606e-02f, -5.89014664e-02f, -1.88329384e-01f, -1.15112819e-01f,
  2.06026003e-01f, -1.45778120e-01f, -1.93231910e-01f, 1.63965628e-01f, 1.07640229e-01f, 1.21350504e-01f, 1.42453894e-01f, 1.52392268e-01f, 1.13744132e-01f, 7.85033405e-03f,
  -1.46519929e-01f, -5.40684760e-02f, -1.34344935e-01f, -1.36362702e-01f, -6.75616190e-02f, 1.14963107e-01f, 9.58209708e-02f, -4.17159647e-02f, 4.39350866e-02f, 1.88992426e-01f,
  6.92366138e-02f, 3.82632539e-02f, -3.43343406e-03f, 1.04228780e-01f, 5.33778854e-02f, 8.81197080e-02f, -5.85798509e-02f, -7.37350583e-02f, -1.56285420e-01f, -1.54704735e-01f,
  -2.99525470e-01f, -2.09319457e-01f, -4.00398904e-03f, 6.35504574e-02f, -4.61311415e-02f, -6.77513480e-02f, 2.85902666e-03f, -6.19037077e-02f, -7.63088614e-02f, 6.23075478e-03f,
  -8.49815235e-02f, -3.62084396e-02f, -7.59169310e-02f, -2.00711396e-02f, -4.26782900e-03f, -3.74188311e-02f, 3.17551289e-03f, -1.20914757e-01f, -3.02202627e-02f, -1.20221339e-01f,
  -3.80616225e-02f, -3.09374314e-02f, -9.74021256e-02f, -6.20074645e-02f, -1.26089528e-01f, -4.65332121e-02f, -3.28723229e-02f, -1.01036102e-01f, -1.75316408e-01f, -1.14303753e-01f,
  5.78651465e-02f, -4.38556224e-02f, 4.74722823e-03f, 1.97435021e-02f, 1.16047477e-02f, -1.85526768e-03f, -5.73936803e-03f, -2.22361982e-02f, 3.70941982e-02f, 7.37192822e-05f,
  2.09030733e-02f, -1.75744500e-02f, -3.68260965e-02f, -5.86777413e-03f, 3.69394459e-02f, -3.12145874e-02f, -4.40113433e-03f, 5.94585128e-02f, 4.34520617e-02f, 3.34816761e-02f,
  1.21655939e-02f, -5.73788621e-02f, -1.33608393e-02f, 9.99060227e-04f, 4.85149696e-02f, -7.99126625e-02f, 5.27099967e-02f, 8.02076422e-03f, -4.77330154e-03f, 4.38767411e-02f,
  1.25987709e-01f, -1.91382512e-01f, 2.17631552e-02f, -5.00496775e-02f, 4.45677142e-04f, 4.56797294e-02f, -3.15506458e-02f, -3.05926725e-02f, 1.08000804e-02f, -8.25609826e-03f,
  -1.57864615e-02f, 2.63274387e-02f, -6.86895847e-02f, 9.06997100e-02f, 1.43898994e-01f, 4.30622958e-02f, 1.06067441e-01f, 5.63288806e-03f, -9.21976846e-03f, -1.15633057e-02f,
  5.51768616e-02f, 1.32383347e-01f, 4.56061028e-02f, 6.83277547e-02f, -2.49262359e-02f, 6.90040039e-03f, 5.12918830e-02f, 1.40401572e-01f, 7.38171220e-05f, 2.71975279e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.62372440e-01f, 1.22549243e-01f, 1.49048656e-01f, 8.10048506e-02f, 9.79428887e-02f, 7.23991916e-02f, -9.30489451e-02f, 1.23491094e-01f, 2.09811002e-01f, 5.59146702e-02f,
  -1.20333157e-01f, 7.58415982e-02f, -4.51921858e-02f, -1.25156179e-01f, 1.16347767e-01f, 1.50042728e-01f, 1.48846924e-01f, 1.55859649e-01f, 1.30384132e-01f, -1.39874930e-04f,
  5.20971790e-02f, 1.49446741e-01f, 1.73605070e-01f, 3.14535201e-02f, -5.52186221e-02f, 9.94393080e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.18559569e-01f, 4.59815376e-02f, -7.46294931e-02f, 2.46546697e-02f, 2.27708682e-01f, 1.81156680e-01f, -1.77180506e-02f, -1.09068401e-01f, -8.46654996e-02f, -1.53180063e-01f,
  -1.84627086e-01f, -7.33260214e-02f, 1.66155566e-02f, -1.03192978e-01f, 3.89564410e-02f, 1.53119683e-01f, 6.62636533e-02f, -2.38040052e-02f, -1.70181692e-01f, -4.71738689e-02f,
  -9.32946354e-02f, -5.50932251e-03f, 1.23945929e-01f, -1.85814112e-01f, 3.66027579e-02f, 1.52011335e-01f, -4.63414006e-02f, -1.29027460e-02f, -2.18394384e-01f, -9.64709967e-02f,
  7.02740718e-03f, 8.26992095e-02f, 6.10046349e-02f, -4.91785556e-02f, -1.30588278e-01f, -3.05520862e-01f, -1.38104618e-01f, -2.46698841e-01f, 2.12652802e-01f, 1.16513841e-01f,
  -3.02608907e-01f, -1.59350425e-01f, -1.41280636e-01f, -9.95457843e-02f, -9.52206403e-02f, 1.12649269e-01f, 2.27574743e-02f, -4.16792542e-01f, 5.90683427e-03f, -4.11248161e-03f,
  3.60475923e-03f, -2.74037961e-02f, 2.03295887e-01f, 1.26786664e-01f, 1.80192694e-01f, 7.05550238e-02f, -1.26890793e-01f, 1.58184797e-01f, 1.62387237e-01f, 3.43953699e-01f,
  1.90965198e-02f, 1.38413131e-01f, -7.34860823e-02f, -2.63974309e-01f, -7.07188025e-02f, 4.92687412e-02f, 1.98973060e-01f, -2.35793412e-01f, -8.48986283e-02f, 1.38786614e-01f,
  1.99900970e-01f, -2.12290734e-01f, -1.03723884e-01f, -1.02105178e-01f, 6.14704341e-02f, -5.87273575e-02f, -1.40159637e-01f, -3.10665756e-01f, -8.66503045e-02f, 1.45841360e-01f,
  -8.69813338e-02f, 2.36243345e-02f, 7.43512213e-02f, 1.78396150e-01f, 1.16320334e-01f, 1.40540287e-01f, 1.87007308e-01f, 3.79397869e-02f, -1.69723436e-01f, -1.78614333e-01f,
  -3.55179161e-02f, 2.11691577e-02f, -2.43764162e-01f, -5.52845411e-02f, 1.58709032e-03f, -1.85036913e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.66410381e-01f, 8.63592550e-02f, 5.20804584e-01f, 2.12108344e-01f, 3.65595043e-01f, 2.74860561e-01f, 1.42254040e-01f, -8.04811642e-02f, 6.33621514e-01f, 1.78799510e-01f,
  2.93953624e-03f, -1.46531954e-01f, 8.96146148e-02f, -2.44291931e-01f, -6.18273541e-02f, 3.92219484e-01f, 3.85609269e-01f, -1.27040267e-01f, -9.02479142e-02f, -1.67254865e-01f,
  -1.10688485e-01f, 9.08132046e-02f, -1.90194830e-01f, 4.92787480e-01f, -1.24647215e-01f, 8.19556601e-03f, 2.62055784e-01f, -1.93758942e-02f, -7.14054927e-02f, 6.28845930e-01f,
  3.76143008e-01f, -5.12165483e-03f, 3.62132877e-01f, 2.41501957e-01f, 3.31105530e-01f, 3.84138942e-01f, -1.00521266e-01f, -9.70510691e-02f, 2.02761069e-01f, 5.86137585e-02f,
  -1.71260759e-01f, -9.71872583e-02f, -2.38527730e-01f, 1.32078037e-01f, -1.35503954e-03f, 2.55380899e-01f, 4.10516888e-01f, 4.52118397e-01f, -2.39678957e-02f, 1.67275324e-01f,
  -3.14324170e-01f, 2.09310114e-01f, 1.01833947e-01f, -5.82107902e-02f, 4.11806345e-01f, -2.55152762e-01f, 3.71919960e-01f, -1.12150908e-01f, -3.39120664e-02f, 1.72325894e-01f,
  3.61289382e-01f, -1.01671536e-02f, -1.17601670e-01f, 3.82426709e-01f, 1.72220528e-01f, 2.62864560e-01f, 1.51817545e-01f, 1.71569865e-02f, 3.40712033e-02f, 1.28199816e-01f,
  2.35823095e-01f, 2.69660890e-01f, -5.83150350e-02f, -3.26268561e-02f, 8.56029168e-02f, -6.98245019e-02f, 9.03483555e-02f, 2.27041140e-01f, 1.65868267e-01f, 2.97212899e-01f,
  -8.73280689e-02f, 1.13156132e-01f, -7.27448761e-02f, 1.97296873e-01f, 9.35143754e-02f, 2.34876964e-02f, 1.45673873e-02f, -1.15719646e-01f, 2.82093614e-01f, -2.40100533e-01f,
  -1.91014305e-01f, 2.11946219e-01f, 1.78204492e-01f, -2.36062318e-01f, 5.85554205e-02f, 2.29133666e-01f, -1.96503893e-01f, 6.30526841e-02f, 6.25544190e-02f, 7.66447708e-02f,
  -2.26282373e-01f, -1.17673196e-01f, 3.53430867e-01f, -1.69909790e-01f, -3.94748300e-02f, -2.33714372e-01f, -9.32472199e-03f, 4.47321311e-02f, 1.26526594e-01f, 4.84909713e-02f,
  3.16739589e-01f, -2.65544683e-01f, -8.14206600e-02f, 2.25754559e-01f, 1.97106190e-02f, 4.86947596e-01f, -4.17560386e-03f, 3.55297416e-01f, 2.51059413e-01f, -9.64764133e-02f,
  3.34036440e-01f, -1.10654384e-01f, -1.66967988e-01f, 3.66190933e-02f, 6.89486787e-02f, 2.98727125e-01f, 1.09535418e-02f, 1.46756262e-01f, 8.12052265e-02f, 3.99232894e-01f,
  7.12854639e-02f, -1.76223502e-01f, 6.63088337e-02f, 9.60087031e-02f, 1.90451771e-01f, 4.84152734e-02f, 1.85442716e-01f, -1.38169914e-01f, 3.37718695e-01f, 1.70382887e-01f,
  -1.43811270e-03f, 1.68854922e-01f, -1.69754326e-01f, -2.46644378e-01f, -1.24147579e-01f, -7.47768506e-02f, 2.89416015e-01f, 8.71429443e-02f, -6.08262196e-02f, 3.06485325e-01f,
  -8.26932117e-02f, 2.91477233e-01f, -1.07227653e-01f, 4.10180315e-02f, -5.37437312e-02f, 2.58106962e-02f, -6.15671352e-02f, 3.33893716e-01f, 2.41204739e-01f, -1.79670736e-01f,
  2.93221086e-01f, 1.50663972e-01f, 6.43350417e-04f, 3.14964563e-01f, 2.50375899e-03f, -3.29164043e-03f, -2.06167437e-02f, 1.39570236e-01f, 2.57424265e-01f, 1.97384268e-01f,
  -1.12070709e-01f, -7.48821050e-02f, 1.21309228e-01f, 7.79153407e-02f, -2.15152558e-02f, 1.97417498e-01f, 1.16506265e-02f, 6.49400800e-02f, -2.97338605e-01f, 2.83773225e-02f,
  -4.21077348e-02f, -3.81235778e-02f, -3.53947729e-02f, -7.41093010e-02f, 2.30501473e-01f, -3.00036073e-01f, -1.12585267e-02f, -2.50017997e-02f, 1.88817367e-01f, 2.36021861e-01f,
  1.25567302e-01f, 3.19028348e-01f, -2.96433605e-02f, 8.18191394e-02f, -6.88165426e-02f, 1.93754345e-01f, 1.46273836e-01f, 7.18348920e-02f, 2.15603963e-01f, -6.38342723e-02f,
  -1.32829696e-01f, -3.11746076e-02f, -1.22690357e-01f, -8.95002973e-04f, -1.43779814e-01f, -2.01861076e-02f, 1.46123156e-01f, 2.90865064e-01f, -6.24149032e-02f, 5.58883548e-02f,
  1.48986936e-01f, -4.03900072e-02f, 1.39852971e-01f, -1.40084952e-01f, 2.56713957e-01f, -1.92292091e-02f, 1.27320930e-01f, 9.70365405e-02f, 8.31029639e-02f, 1.57004163e-01f,
  -8.57895538e-02f, -2.18390271e-01f, -1.83750972e-01f, -1.35165751e-01f, 8.23808834e-02f, -2.02036530e-01f, -1.03074446e-01f, 1.56963229e-01f, 1.15583740e-01f, 2.26432607e-01f,
  -1.11160032e-01f, -8.41224641e-02f, 5.35976589e-02f, 2.03575030e-01f, 2.34988742e-02f, -7.87752643e-02f, -1.09001100e-01f, -1.29842654e-01f, 1.19109638e-01f, 3.31359059e-01f,
  -2.90902350e-02f, -3.90213057e-02f, -1.69560820e-01f, -9.84732136e-02f, 1.40491471e-01f, -7.03602005e-03f, -2.08312958e-01f, 1.22545891e-01f, 4.29678187e-02f, 2.22460240e-01f,
  -9.67658684e-02f, 1.15915544e-01f, 5.64376675e-02f, -3.97304334e-02f, 8.42911378e-02f, 1.65245324e-01f, 2.20130071e-01f, 6.29951134e-02f, 1.95039243e-01f, 9.90808979e-02f,
  -2.02768948e-02f, 2.17382401e-01f, 2.34445944e-01f, 2.00373068e-01f, 2.55056441e-01f, -6.50193393e-02f, 1.70938253e-01f, 8.47534314e-02f, -1.61775187e-01f, 8.85038227e-02f,
  -9.13644582e-02f, 1.96866706e-01f, -1.34643540e-01f, -7.94368982e-02f, 1.24461405e-01f, -1.95038736e-01f, 1.59510568e-01f, -3.34425680e-02f, 3.00532579e-01f, 1.62438467e-01f,
  -1.90132827e-01f, 1.23725630e-01f, 5.73683903e-02f, 1.98282018e-01f, 5.11452444e-02f, 1.56480387e-01f, 2.32785970e-01f, -1.47138149e-01f, -1.11950897e-01f, -8.42703804e-02f,
  -3.62791009e-02f, 9.28902701e-02f, -5.98216802e-03f, 1.47416666e-01f, 5.68005331e-02f, -1.08792283e-01f, 5.04815280e-02f, 8.60782266e-02f, 9.23624039e-02f, 1.46282047e-01f,
  -1.40394375e-01f, -4.86310460e-02f, 2.67496735e-01f, 1.41689153e-02f, -1.19429305e-02f, -1.10183833e-02f, 1.38891796e-02f, -1.78834945e-01f, -6.37267977e-02f, -5.22510372e-02f,
  3.28755945e-01f, 1.41785905e-01f, 4.68834490e-02f, 2.24420100e-01f, -2.17701262e-03f, -9.96274054e-02f, 6.90347850e-02f, -6.63565323e-02f, 1.38830587e-01f, -5.42079881e-02f,
  3.03545862e-01f, 2.51885474e-01f, 6.65329024e-02f, -1.61359653e-01f, -2.43866235e-01f, 5.00457622e-02f, -9.02037323e-03f, 1.38800055e-01f, -7.48698786e-02f, 3.99401896e-02f,
  1.55130953e-01f, -5.14879264e-02f, 1.11725651e-01f, 3.60854059e-01f, -2.92685106e-02f, 1.20863914e-01f, -1.59551948e-01f, -2.34599616e-02f, -3.50673757e-02f, -2.59830236e-01f,
  2.20648438e-01f, -3.23196501e-01f, 1.94965109e-01f, 5.57670146e-02f, -9.47760139e-03f, -3.29601437e-01f, -1.76633403e-01f, -2.78280932e-03f, 3.90426219e-01f, -1.05238549e-01f,
  1.31363019e-01f, 3.05246264e-01f, 1.80979237e-01f, -1.42544568e-01f, 6.30664825e-02f, 5.80400079e-02f, 1.65816218e-01f, -1.26235887e-01f, 1.45501539e-01f, 2.26749852e-01f,
  2.61772182e-02f, 1.93392769e-01f, 1.44080045e-02f, 1.55243158e-01f, 6.70200097e-04f, 7.34998360e-02f, 2.60705054e-01f, 1.97067812e-01f, 5.56976236e-02f, -5.74233048e-02f,
  -4.97888736e-02f, -1.46654263e-01f, -1.42499283e-01f, -1.62473664e-01f, 1.15012191e-01f, 9.12516788e-02f, 1.28719196e-01f, -5.82269616e-02f, 1.50306940e-01f, -1.81900024e-01f,
  5.44144493e-03f, -1.39686659e-01f, 3.85102034e-02f, 3.13677281e-01f, -4.33669612e-02f, 2.14979704e-02f, -1.26209564e-03f, 1.63171106e-04f, -4.76537086e-02f, -5.29099405e-02f,
  3.27431202e-01f, -1.80416331e-02f, 4.50215116e-03f, -1.19800240e-01f, 1.76806942e-01f, 1.37840897e-01f, 1.70388088e-01f, -9.31581631e-02f, 2.03159794e-01f, 8.01809654e-02f,
  -1.20966099e-01f, -2.41855457e-02f, 2.00874999e-01f, -1.21237613e-01f, -4.58572693e-02f, 4.53683967e-03f, 3.85332108e-01f, 5.10741174e-02f, -5.22296503e-02f, 1.40027493e-01f,
  4.18034419e-02f, -8.41701478e-02f, -1.77914396e-01f, -1.10712327e-01f, -4.04506698e-02f, 7.80474320e-02f, 9.31121483e-02f, -1.27143949e-01f, 1.96913347e-01f, 1.78370655e-01f,
  -1.85038731e-01f, 1.12587042e-01f, 3.35125625e-01f, -1.58118755e-01f, -8.03618208e-02f, -1.45824626e-01f, 1.04152255e-01f, -1.50557056e-01f, 8.76143947e-02f, 5.04598133e-02f,
  3.24859649e-01f, 7.42872991e-03f, -2.72427239e-02f, 6.32131323e-02f, 5.66856842e-03f, 1.36950240e-01f, 3.06058168e-01f, -1.31602153e-01f, 2.03998268e-01f, 8.98826122e-02f,
  1.14341192e-01f, -1.25892550e-01f, 1.15350246e-01f, 2.45463133e-01f, 6.73761144e-02f, -1.87231734e-01f, -1.20284647e-01f, -6.04403652e-02f, -1.18988037e-01f, -1.34791164e-02f,
  2.16134060e-02f, -7.60908797e-02f, 5.18794954e-02f, 6.58846796e-02f, 1.83895901e-01f, -3.63032147e-02f, -1.66324958e-01f, -1.10000547e-05f, 1.19992644e-01f, -1.05793670e-01f,
  2.04106257e-03f, 1.77990153e-01f, 1.50262251e-01f, 1.16101563e-01f, 1.22594103e-01f, 1.71134099e-01f, -5.62753491e-02f, -1.36475310e-01f, 6.59745485e-02f, -1.58894598e-01f,
  1.07229367e-01f, -1.69309646e-01f, 2.02837922e-02f, 1.70178518e-01f, 1.52227119e-01f, -1.20785296e-01f, -3.72270234e-02f, 1.08532920e-01f, 1.45102754e-01f, -5.53676002e-02f,
  7.85267539e-03f, 2.04422474e-01f, 3.70696545e-01f, 9.95433331e-02f, 3.08936596e-01f, -6.53884262e-02f, -1.52201176e-01f, -2.21039087e-01f, 1.21849567e-01f, 2.01129586e-01f,
  -8.66713151e-02f, 4.74281088e-02f, -1.25715986e-01f, -2.35361934e-01f, -9.13771912e-02f, -9.68823358e-02f, 1.47673741e-01f, -1.10022865e-01f, 1.98474348e-01f, 1.97279096e-01f,
  -1.83496699e-01f, 3.14328313e-01f, -5.97676309e-03f, 3.52014780e-01f, -1.46457657e-01f, 6.56018853e-02f, 1.95656583e-01f, 7.73556903e-02f, -8.31478164e-02f, 5.28751433e-01f,
  -5.40379547e-02f, -2.28397012e-01f, -1.51761770e-01f, -1.37345240e-01f, 1.32831946e-01f, 6.88018128e-02f, 1.91658631e-01f, 3.43257897e-02f, 5.98511100e-02f, 3.00839376e-02f,
  1.17432073e-01f, -8.48734826e-02f, 8.95616263e-02f, -1.43927485e-02f, 2.57145941e-01f, -4.11625095e-02f, 1.77114576e-01f, 7.16159269e-02f, 2.07077384e-01f, 1.38192967e-01f,
  -1.03783160e-01f, 1.31398126e-01f, -1.72240824e-01f, 1.29044145e-01f, -1.77758858e-01f, 7.93398172e-02f, 2.37698838e-01f, 2.44070813e-01f, -2.07059961e-02f, -1.09700099e-01f,
  1.07561439e-01f, -1.19305834e-01f, -2.01361522e-01f, 5.08962758e-02f, 2.64165878e-01f, 3.54261309e-01f, 1.20142348e-01f, -4.48921829e-01f, 6.06767349e-02f, -9.57355276e-03f,
  -7.85788056e-03f, 3.28339040e-01f, -1.67949304e-01f, 1.84340686e-01f, 3.59292597e-01f, 8.70728642e-02f, -2.51714271e-02f, 3.83312792e-01f, 7.33563080e-02f, -3.14450294e-01f,
  -2.41587646e-02f, 2.61904538e-01f, 4.71255839e-01f, -6.85452521e-02f, 3.70191962e-01f, 1.62911221e-01f, 3.15709591e-01f, 3.16218823e-01f, -1.61666587e-01f, -1.59465834e-01f,
  4.69412357e-02f, 2.76874304e-01f, 1.49995789e-01f, 2.04325333e-01f, 1.14441305e-01f, -1.76161274e-01f, -1.32848635e-01f, -1.27583221e-01f, 1.92250624e-01f, 2.15897992e-01f,
  -1.15028441e-01f, -6.62304014e-02f, 2.13072672e-01f, -1.73897654e-01f, -1.34565815e-01f, -6.39430359e-02f, -2.03149423e-01f, 7.37972930e-02f, 3.05979282e-01f, 2.10864007e-01f,
  2.96953708e-01f, -1.74621314e-01f, -1.58718958e-01f, 1.27083585e-01f, -1.58968344e-01f, 4.52853471e-01f, 2.09561475e-02f, 3.81193727e-01f, -3.40579463e-05f, 1.46158531e-01f,
  3.61223489e-01f, -5.23173064e-02f, 1.20569319e-02f, 6.62018433e-02f, -1.53602436e-01f, 9.34660062e-02f, -2.36106329e-02f, 1.51544124e-01f, 1.93401307e-01f, 7.01313168e-02f,
  1.37554467e-01f, -1.09256878e-02f, -2.05266282e-01f, -5.46262302e-02f, 1.26739204e-01f, 5.59337772e-02f, -4.36705984e-02f, 1.46123320e-01f, -5.75152300e-02f, 1.71590641e-01f,
  -1.66010316e-02f, 1.72489852e-01f, 2.90722966e-01f, 2.24013984e-01f, 4.96653318e-02f, -1.17382677e-02f, -9.17519480e-02f, -1.24151528e-01f, 1.80669129e-01f, -2.61732399e-01f,
  1.06996723e-01f, -1.30987510e-01f, 3.04229390e-02f, -9.50677320e-02f, 1.15107633e-01f, -6.25317590e-03f, -7.59101212e-02f, -3.34986374e-02f, -1.11246206e-01f, -1.44706890e-01f,
  -3.26540525e-04f, 2.52788365e-01f, -1.86339281e-02f, -1.02863759e-01f, 1.13331713e-01f, -7.91955814e-02f, -4.13664058e-02f, -1.17791362e-01f, 1.88801780e-01f, -1.44861519e-01f,
  2.24622533e-01f, 5.10861538e-02f, -3.46801914e-02f, -1.92492872e-01f, -1.02464139e-01f, 3.35491635e-02f, 4.89196554e-02f, 1.12156220e-01f, 2.58803904e-01f, -3.44080129e-03f,
  4.87811379e-02f, 2.84166068e-01f, -9.47050154e-02f, 2.73559511e-01f, 1.67742863e-01f, -1.85891353e-02f, 1.22311629e-01f, -9.94050205e-02f, -2.04391167e-01f, 1.08513245e-02f,
  1.37555286e-01f, -6.47817850e-02f, 1.18576318e-01f, -2.45358441e-02f, -9.04521123e-02f, -1.03746451e-01f, -2.12654173e-01f, 9.31388810e-02f, -3.18902824e-03f, 6.88830540e-02f,
  7.83963278e-02f, 1.04046687e-01f, 2.53324788e-02f, 8.54751840e-02f, -1.49799094e-01f, 9.45782512e-02f, 1.80631965e-01f, -6.39970303e-02f, -8.55837762e-02f, 1.10841423e-01f,
  1.20880399e-02f, 1.46771774e-01f, 2.20206887e-01f, 1.73517317e-01f, 1.79994091e-01f, 3.33864018e-02f, 3.85445692e-02f, 3.25677469e-02f, -1.54336780e-01f, -2.56259535e-02f,
  -1.07765056e-01f, -1.73726100e-02f, -1.60933733e-01f, -7.65069798e-02f, 2.48422027e-01f, 1.38902729e-02f, 1.96588174e-01f, 2.82634348e-01f, 3.44572902e-01f, 2.98939019e-01f,
  -6.40555518e-03f, 1.70111626e-01f, 5.02530456e-01f, 3.56392205e-01f, 4.90506440e-02f, 2.05438882e-01f, 1.23664625e-01f, 2.36635841e-03f, 9.41186547e-02f, 4.62011963e-01f,
  3.29962760e-01f, -8.19442570e-02f, -3.10990483e-01f, -5.18579297e-02f, -1.78220775e-02f, -9.03355405e-02f, -6.32336214e-02f, 4.70396653e-02f, 1.11622848e-01f, 1.11623118e-02f,
  1.82947114e-01f, -1.83679581e-01f, 1.99895829e-01f, 3.09422463e-01f, 3.14809620e-01f, 2.61903971e-01f, -2.98849810e-02f, -1.29476666e-01f, -4.15909067e-02f, -9.55446512e-02f,
  5.79315312e-02f, -4.52692732e-02f, 7.06175864e-02f, 5.38485423e-02f, -3.28407846e-02f, 8.27540234e-02f, -1.20690659e-01f, -6.95206672e-02f, -2.30757501e-02f, 3.14835422e-02f,
  -6.93975240e-02f, -1.79070979e-02f, -5.99154793e-02f, -1.63702980e-01f, 1.03784345e-01f, -1.52127266e-01f, -1.18173644e-01f, -1.70843974e-01f, -9.39998329e-02f, 1.46623090e-01f,
  1.64438590e-01f, -4.33472618e-02f, -1.06586233e-01f, 1.62189096e-01f, 2.85299346e-02f, -1.55844152e-01f, 8.48272964e-02f, 8.76245787e-04f, -9.38212592e-03f, -1.13398194e-01f,
  6.31331205e-02f, 6.36936799e-02f, 9.30732563e-02f, 3.72413136e-02f, 1.95121039e-02f, 1.32059557e-02f, -3.02019846e-02f, 1.02635279e-01f, 9.29793641e-02f, -1.74181640e-01f,
  8.08937252e-02f, 2.30754688e-01f, -8.10652003e-02f, 3.33565427e-03f, -4.68940139e-02f, -7.77547434e-02f, -1.38854375e-02f, -5.42071387e-02f, 1.50012448e-01f, -1.58606559e-01f,
  -4.23902422e-02f, -6.94371238e-02f, 4.93463054e-02f, -8.51952061e-02f, -1.52697682e-01f, -2.23017503e-02f, -1.36723503e-01f, -1.53892726e-01f, -9.02880430e-02f, -8.37505013e-02f,
  2.55985484e-02f, 6.84457347e-02f, 1.86046630e-01f, 9.68040973e-02f, -7.45503083e-02f, -1.93450078e-02f, 1.10745139e-01f, -6.71261474e-02f, -3.42848711e-02f, -2.12246358e-01f,
  -2.82568216e-01f, 1.60450339e-01f, 2.69063413e-01f, 5.58894016e-02f, 1.95081487e-01f, -2.08692610e-01f, -1.41866609e-01f, -3.63274384e-03f, -2.41009995e-01f, 4.47087795e-01f,
  -2.46232674e-02f, 3.42577010e-01f, -2.22260639e-01f, -7.19603375e-02f, 2.56753802e-01f, -1.27760530e-01f, -9.72072482e-02f, -4.15912941e-02f, -2.95484271e-02f, 4.12585914e-01f,
  -1.66882783e-01f, 7.91964028e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.04190224e-01f, 1.68514222e-01f, 2.30903581e-01f, 1.49040982e-01f, 9.18922722e-02f, 1.96210489e-01f, 2.30071932e-01f, 4.15159985e-02f, 3.11904848e-01f, 2.34630689e-01f,
  1.91844568e-01f, 1.58785895e-01f, 1.14114329e-01f, 1.27461120e-01f, -1.71165526e-01f, 7.81972483e-02f, -4.70824316e-02f, 2.77373970e-01f, -7.79228210e-02f, -3.63771729e-02f,
  9.62270349e-02f, -6.49165409e-03f, 1.59688592e-01f, -1.69932574e-01f, 3.04380804e-02f, 2.73484234e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.47968147e-03f, 1.08997159e-01f, 1.34732932e-01f, -2.19036609e-01f, 1.08291604e-01f, 3.20530348e-02f, -1.68050677e-01f, -1.93170428e-01f, 2.22835898e-01f, -2.82741547e-01f,
  9.55038369e-02f, -1.09442353e-01f, -2.13351920e-01f, -1.12223007e-01f, 1.88485309e-01f, -1.58969183e-02f, 3.00902307e-01f, -3.59925218e-02f, 2.01848708e-02f, -1.72290757e-01f,
  -1.36421368e-01f, -1.38611659e-01f, -3.06781679e-01f, 4.10273194e-01f, -3.73030216e-01f, 1.80499822e-01f, 9.42456424e-02f, 4.51843115e-03f, -3.15607816e-01f, -3.79378125e-02f,
  -1.30306659e-02f, -2.99605280e-01f, 2.58917838e-01f, 8.39709863e-02f, 1.31780118e-01f, 5.02773859e-02f, 9.75084826e-02f, 1.13291249e-01f, -3.04771930e-01f, 3.71583849e-01f,
  3.08236003e-01f, -3.48653905e-02f, -2.13579819e-01f, 1.71342611e-01f, -8.14273059e-02f, 8.61565024e-02f, -1.35596350e-01f, -2.52501011e-01f, 3.59053254e-01f, 5.01819961e-02f,
  -1.36582643e-01f, -1.84757113e-01f, 1.69535261e-02f, -2.37973288e-01f, -1.75388217e-01f, 1.52939886e-01f, 6.54247850e-02f, -1.08385012e-01f, -1.39226153e-01f, -3.77164818e-02f,
  -2.80064166e-01f, 7.28590554e-03f, 1.44444257e-01f, 1.86565995e-01f, 9.35198814e-02f, 2.04823241e-01f, -3.99936177e-02f, 1.98746189e-01f, -4.19753306e-02f, 1.87143795e-02f,
  -2.66249388e-01f, 2.48086333e-01f, 3.86646092e-02f, 2.19739199e-01f, -2.48533547e-01f, 9.11197662e-02f, 2.19638692e-03f, 5.57393907e-03f, -1.64444163e-01f, -3.04213469e-03f,
  -1.08963996e-02f, 1.05708092e-01f, 6.49207179e-03f, -8.30317736e-02f, -3.90785858e-02f, -3.25869054e-01f, 1.14163481e-01f, -2.46512413e-01f, 2.26002082e-01f, 1.37795970e-01f,
  7.57187158e-02f, 1.34187073e-01f, 1.27846569e-01f, -1.35900781e-01f, 1.31937072e-01f, 6.30828589e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.73398718e-01f, 3.28431576e-02f, -1.43153192e-02f, -3.94146517e-02f, -1.74423620e-01f, -9.92405042e-02f, 1.21898554e-01f, 5.44816256e-02f, 3.42476964e-02f, -2.25423053e-01f,
  1.83850154e-01f, -2.12637216e-01f, 4.67855334e-02f, -1.57705739e-01f, 1.29238576e-01f, 1.29775017e-01f, -2.84973066e-02f, 8.08689296e-02f, 8.70882943e-02f, -2.03749724e-02f,
  -5.65528348e-02f, 7.63885230e-02f, -1.42371669e-01f, 2.20149696e-01f, 7.30469674e-02f, -8.67142808e-03f, -1.33458301e-02f, 1.39761761e-01f, -1.26024678e-01f, 6.33796975e-02f,
  1.27944186e-01f, -1.97495922e-01f, -1.48368180e-01f, 9.32985023e-02f, 1.83713391e-01f, 2.60083769e-02f, -1.42624557e-01f, 1.12965196e-01f, 3.47411245e-01f, 2.02505559e-01f,
  -6.44434243e-02f, -1.51377216e-01f, -1.51764750e-01f, 1.37838438e-01f, 7.95695111e-02f, 2.75188565e-01f, 1.19111359e-01f, -2.85872612e-02f, 2.10682884e-01f, 9.64339152e-02f,
  -1.51438072e-01f, 1.42860692e-02f, 1.48372918e-01f, -1.48068788e-02f, -3.07189189e-02f, -1.34991765e-01f, 1.49867415e-01f, -2.33724471e-02f, -1.81674100e-02f, -6.53563067e-02f,
  4.17296261e-01f, -3.49963754e-02f, 6.43552542e-02f, -1.03544310e-01f, 2.13371828e-01f, 8.16711597e-03f, 3.85772549e-02f, 1.57892600e-01f, 4.49445732e-02f, 1.02547102e-01f,
  1.47401646e-01f, 1.61340594e-01f, -9.74495051e-05f, -1.22866258e-01f, 7.66157135e-02f, 7.43041486e-02f, 1.66679218e-01f, 9.41839069e-03f, -9.53780487e-02f, 8.50138366e-02f,
  2.32884139e-01f, -1.15981936e-01f, -1.22782618e-01f, 1.07914560e-01f, -4.34555523e-02f, -1.77847110e-02f, -1.51897565e-01f, 1.08361334e-01f, -2.08304182e-01f, 1.76355943e-01f,
  1.35130763e-01f, 7.26066977e-02f, 2.48149559e-01f, -1.20007887e-01f, -9.96791348e-02f, 1.16943739e-01f, -7.91284516e-02f, -2.60007083e-02f, -4.86862436e-02f, -1.10757306e-01f,
  -1.77203622e-02f, 1.81796312e-01f, 2.59523273e-01f, -1.71279386e-01f, 9.58692208e-02f, -4.74242158e-02f, 1.37247652e-01f, 6.18721060e-02f, 6.19538426e-02f, -1.57766968e-01f,
  1.05223313e-01f, -9.97205153e-02f, -3.00176884e-03f, -1.13292009e-01f, 1.23279624e-01f, 5.61868176e-02f, -1.86913177e-01f, -2.51300610e-03f, -1.51368231e-01f, 2.41983190e-01f,
  -5.20651229e-02f, -1.84799701e-01f, 6.82972074e-02f, 1.14191184e-03f, 6.52358234e-02f, -1.01801969e-01f, 1.10839810e-02f, 2.55141631e-02f, -1.90939054e-01f, -4.61679623e-02f,
  1.02264546e-01f, 1.85781777e-01f, -4.31407914e-02f, 4.49206419e-02f, -3.04164458e-02f, 1.05483420e-01f, -2.04625875e-01f, 1.39272392e-01f, -8.63510743e-02f, 5.39584532e-02f,
  4.45517227e-02f, 1.12129031e-02f, 1.42028928e-01f, 4.24214788e-02f, 4.94677499e-02f, -9.34830830e-02f, 2.12013945e-01f, 1.64547369e-01f, 7.14054182e-02f, -6.41145036e-02f,
  1.26545057e-01f, -4.58485074e-02f, 6.64660111e-02f, 3.58454958e-02f, -1.68813065e-01f, -2.58011669e-02f, -1.32557020e-01f, -3.65301035e-02f, 9.91548076e-02f, -8.10252652e-02f,
  3.24434131e-01f, 3.41113299e-01f, 1.18640192e-01f, -7.59076327e-02f, 9.65661705e-02f, 7.39211403e-03f, -1.25041887e-01f, 3.96736190e-02f, 1.18146040e-01f, -2.33615264e-01f,
  -1.54134920e-02f, -2.01145798e-01f, 1.84598342e-01f, 1.28696099e-01f, 3.65392655e-01f, 2.39145473e-01f, 4.40438598e-01f, -6.44142255e-02f, 3.25768232e-01f, 2.42738530e-01f,
  -6.72337413e-02f, -2.02697098e-01f, -2.43235290e-01f, 4.60779250e-01f, -3.14443141e-01f, 3.30316126e-02f, -9.53709409e-02f, -6.70883283e-02f, -1.47308543e-01f, -4.05294187e-02f,
  3.97005528e-02f, -4.13545400e-01f, -3.05837300e-02f, -1.22352876e-01f, 1.34337202e-01f, -9.43212658e-02f, 1.04483953e-02f, -5.35563054e-03f, 1.44938305e-01f, 3.42981786e-01f,
  1.09856807e-01f, -7.54815787e-02f, 3.83436568e-02f, 2.50439495e-01f, 1.59972206e-01f, 6.09511994e-02f, 5.55036701e-02f, 1.32399108e-02f, 4.09342069e-03f, 2.43903860e-01f,
  5.59195988e-02f, 1.09051317e-01f, 1.37552097e-01f, -1.32514372e-01f, -2.05501422e-01f, 5.33823445e-02f, -6.49167225e-02f, 1.04169674e-01f, -2.26924539e-01f, 4.23326269e-02f,
  2.08954319e-01f, -1.65760517e-01f, 1.51396289e-01f, 1.83569893e-01f, 1.92300349e-01f, 2.60074914e-01f, 6.68448359e-02f, -2.34787874e-02f, -1.05769269e-01f, -1.86774269e-01f,
  1.05889559e-01f, 5.68055212e-01f, 2.07979903e-01f, -2.15209216e-01f, -3.37526917e-01f, 1.44828305e-01f, 1.47118241e-01f, -6.17509671e-02f, 2.07295001e-01f, 2.03677956e-02f,
  4.29176360e-01f, 3.30488116e-01f, 1.52481109e-01f, 1.35914958e-03f, 6.96947426e-02f, -2.35681921e-01f, -1.18608929e-01f, 1.44563671e-02f, -7.61010498e-02f, 2.99720287e-01f,
  -6.20422401e-02f, -4.81606536e-02f, 3.66844952e-01f, -2.97202840e-02f, -1.27820849e-01f, -2.09799170e-01f, 1.67879760e-01f, 3.41644250e-02f, 2.87155598e-01f, 7.07198605e-02f,
  1.31874438e-02f, -4.07546572e-02f, 4.99384522e-01f, 8.49643201e-02f, -4.47992161e-02f, -1.52361318e-01f, 1.07681885e-01f, 2.75055207e-02f, -9.12049860e-02f, -6.65898174e-02f,
  1.54950529e-01f, 1.85056910e-01f, -2.51339793e-01f, 1.11143351e-01f, 4.77699284e-03f, -1.13116898e-01f, -1.14875257e-01f, 3.18980187e-01f, 5.04811816e-02f, -1.47485033e-01f,
  -1.39220789e-01f, 1.50081813e-01f, -1.89488160e-03f, -2.46096193e-03f, 1.80158377e-01f, 1.47276267e-01f, -1.42589640e-02f, 6.44822605e-03f, 1.89470947e-01f, 2.83035282e-02f,
  1.47264794e-01f, 1.75549150e-01f, -2.37391874e-01f, -3.06155682e-01f, 1.71969131e-01f, 6.44804120e-01f, 3.36137533e-01f, 4.31310415e-01f, -2.90656984e-01f, 2.86162853e-01f,
  3.12849045e-01f, -1.42949834e-01f, -6.04983009e-02f, 5.43572986e-03f, -8.91537145e-02f, 1.88050389e-01f, 1.49145439e-01f, 2.56412774e-01f, -9.64476168e-03f, -1.31517053e-01f,
  -5.92053384e-02f, -3.06803852e-01f, 4.33478266e-01f, 8.80128294e-02f, 4.10399511e-02f, -7.54472837e-02f, 2.62757331e-01f, -3.72635946e-02f, -5.19392267e-02f, 1.66611448e-01f,
  -7.50434995e-02f, -6.81216717e-02f, -7.65379369e-02f, 4.93217781e-02f, 8.04436430e-02f, -8.72070938e-02f, 1.47234350e-01f, -1.55613482e-01f, 6.53427169e-02f, 1.02427490e-01f,
  1.95981026e-01f, -7.09154680e-02f, 1.93747386e-01f, -1.46080211e-01f, -2.15290766e-02f, 3.09129115e-02f, -9.54212025e-02f, 1.50086880e-01f, 9.52042863e-02f, 1.00121282e-01f,
  -1.19996332e-01f, 1.42757908e-01f, -1.61499888e-01f, -9.47648659e-02f, -1.23644039e-01f, -3.21772881e-02f, 8.39218944e-02f, 6.36490285e-02f, -7.74916261e-02f, -3.72222029e-02f,
  -1.33166626e-01f, -7.91586265e-02f, 7.68459961e-02f, -7.11492226e-02f, -4.43374664e-02f, -1.37053102e-01f, 2.05810636e-01f, 1.61930770e-01f, -1.25446081e-01f, 8.44219476e-02f,
  4.40491438e-02f, -1.04858980e-01f, -1.09006286e-01f, 1.25531882e-01f, -1.29139498e-01f, 2.82535069e-02f, -4.03996296e-02f, 1.78227797e-01f, 1.54707581e-01f, 1.25730127e-01f,
  3.13326195e-02f, 1.57561809e-01f, 1.85859412e-01f, 3.27085406e-02f, -6.57210499e-02f, 7.90569093e-03f, 8.19351450e-02f, 2.02898875e-01f, -3.26641537e-02f, -3.52898426e-02f,
  -2.28778459e-02f, -2.75783818e-02f, -1.54981658e-01f, -1.23446874e-01f, -1.45504355e-01f, -9.46355090e-02f, -1.66541055e-01f, -6.57548904e-02f, 5.37331887e-02f, 1.72032882e-02f,
  3.67167778e-02f, -2.78765634e-02f, -1.64518535e-01f, -1.77996591e-01f, -2.31663398e-02f, 1.54024893e-02f, 6.95191994e-02f, -6.40943348e-02f, -2.38409098e-02f, -6.31870180e-02f,
  1.91216655e-02f, 1.32697016e-01f, 1.18106529e-01f, 1.52009428e-01f, 4.55997586e-02f, 8.85771438e-02f, 2.05997750e-01f, -1.15873374e-01f, -4.40928228e-02f, 1.13297544e-01f,
  -1.62507921e-01f, -1.62758663e-01f, 1.14175142e-03f, -6.17818348e-02f, -4.01991792e-02f, -2.95832120e-02f, 1.80422515e-01f, 4.11206692e-01f, -5.70477732e-02f, -5.42577691e-02f,
  1.25722989e-01f, -2.40901813e-01f, -9.81761739e-02f, 3.05973381e-01f, 1.93505004e-01f, 4.36544299e-01f, 3.87177706e-01f, -1.65428922e-01f, 7.72267357e-02f, -3.24666589e-01f,
  5.68556301e-02f, -8.96183681e-03f, 1.30103886e-01f, -8.20345655e-02f, 2.79957950e-01f, 2.19789982e-01f, 2.69197486e-02f, 1.10883892e-01f, 1.66343898e-01f, 3.65564764e-01f,
  3.43762428e-01f, -3.81439328e-02f, 3.09483428e-02f, 9.72655118e-02f, 6.57227784e-02f, 6.31027156e-03f, -4.31026779e-02f, 3.03868920e-01f, 1.87030867e-01f, 1.54664084e-01f,
  2.78478682e-01f, -1.01473533e-01f, 7.13612735e-02f, -1.74506921e-02f, -3.06703360e-03f, 5.32636642e-01f, 3.07523906e-01f, 4.58716035e-01f, -1.91255063e-02f, 8.15760419e-02f,
  1.81965709e-01f, -9.97876469e-03f, 6.43392280e-02f, -2.25676283e-01f, -1.53782994e-01f, -1.24523446e-01f, 5.77439833e-03f, 2.29378238e-01f, -1.77944466e-01f, -3.30026224e-02f,
  9.23449248e-02f, 4.20828946e-02f, 3.59581172e-01f, 7.15654790e-02f, 2.69348137e-02f, 1.49267510e-01f, -1.13578392e-02f, 4.08574007e-04f, -1.05739743e-01f, 3.72680157e-01f,
  2.72358209e-01f, 3.54261547e-01f, 3.43210548e-01f, 3.43134999e-02f, 4.46871877e-01f, 4.68350053e-01f, -4.29671369e-02f, 7.77012035e-02f, 9.55683216e-02f, 3.47482979e-01f,
  2.53709018e-01f, -3.02986532e-01f, 3.28799695e-01f, -1.53024361e-01f, 3.05027187e-01f, 1.65692687e-01f, -1.48014709e-01f, -2.61355311e-01f, 1.45337418e-01f, 3.11535090e-01f,
  1.31477704e-02f, 5.11357300e-02f, -2.41542637e-01f, 6.40078902e-01f, 7.95497075e-02f, 1.49549395e-01f, 2.73382753e-01f, 3.26196343e-01f, -4.31456983e-01f, 2.18774248e-02f,
  3.98190618e-02f, 2.18817919e-01f, 7.35830218e-02f, -1.40285403e-01f, 2.47944668e-01f, -1.05057508e-01f, -2.27227658e-01f, -2.62800932e-01f, 4.02250811e-02f, 4.88387078e-01f,
  4.02985841e-01f, 4.14377674e-02f, -2.33951584e-01f, 5.12640655e-01f, 3.32833342e-02f, 1.70920372e-01f, 2.66047984e-01f, 1.34396046e-01f, 5.00813842e-01f, 3.45577776e-01f,
  -1.82295308e-01f, 1.62226036e-01f, -4.97367270e-02f, -3.41959357e-01f, -2.12933421e-01f, -1.63359597e-01f, -1.18993007e-01f, 2.33731896e-01f, -2.85637349e-01f, 2.32503414e-02f,
  3.63942623e-01f, -6.26465678e-02f, -8.51115212e-03f, -2.53700525e-01f, 1.75835580e-01f, -3.39379068e-04f, 1.96177080e-01f, -1.63024828e-01f, -4.17370396e-03f, 1.20263986e-01f,
  4.14455295e-01f, -5.53720780e-02f, -1.93882570e-01f, -1.48181334e-01f, 3.12654555e-01f, 1.92520946e-01f, 1.88771077e-02f, 1.43965334e-01f, 3.25339526e-01f, -1.31138086e-01f,
  -1.72455296e-01f, 1.33918062e-01f, -1.29088387e-01f, -2.00659379e-01f, 8.69156495e-02f, 3.26185584e-01f, 2.37821396e-02f, 6.66339770e-02f, -7.35698417e-02f, -1.74387783e-01f,
  9.65617690e-03f, -9.59622934e-02f, 2.72562236e-01f, 1.13469437e-01f, -6.19793087e-02f, -7.55737126e-02f, 1.82485983e-01f, -1.17732324e-01f, 2.34637499e-01f, 9.80649665e-02f,
  -3.04445386e-01f, 2.08064750e-01f, 6.13513649e-01f, -1.14888541e-01f, 2.57393010e-02f, 1.28012687e-01f, -1.11540526e-01f, -7.40322396e-02f, 9.12050083e-02f, 2.62036085e-01f,
  1.60934910e-01f, 1.07437775e-01f, -9.73846298e-03f, 1.92213990e-02f, -5.79905100e-02f, 1.10349365e-01f, -3.80015783e-02f, 3.01579297e-01f, -3.23231332e-02f, -3.10449213e-01f,
  -8.39360282e-02f, -7.86889344e-02f, 9.81929004e-02f, 8.82956237e-02f, 3.11699182e-01f, 2.19423044e-02f, -1.12783775e-01f, -6.85331821e-02f, -2.02190861e-01f, 1.73277900e-01f,
  4.59853746e-02f, -1.07534483e-01f, 1.05283566e-01f, -1.46131948e-01f, 2.56125778e-01f, -3.98303717e-02f, -1.65848717e-01f, 2.22077772e-01f, 1.18767977e-01f, 1.84980676e-01f,
  8.20013583e-02f, -1.46115512e-01f, 6.52320459e-02f, -1.61664575e-01f, 1.18650543e-02f, -1.23012841e-01f, 4.22169231e-02f, -9.54476893e-02f, -1.26457170e-01f, 2.33125329e-01f,
  1.41648799e-02f, 1.29919633e-01f, 1.09560698e-01f, -2.78418183e-01f, 2.83400238e-01f, -1.90645859e-01f, -1.01493299e-01f, 1.55828923e-01f, -4.88951765e-02f, 3.38073522e-01f,
  6.02850951e-02f, 2.50187546e-01f, 2.83079386e-01f, -1.66244388e-01f, -2.23149788e-02f, -2.48118371e-01f, 6.75226271e-01f, -1.76078245e-01f, 6.38099536e-02f, -2.91424841e-01f,
  3.13137978e-01f, 2.33357698e-01f, -1.65709540e-01f, -1.42046407e-01f, 1.34725824e-01f, -1.36891901e-01f, 3.26159000e-02f, -7.68163800e-02f, -2.78284341e-01f, -2.01230496e-01f,
  1.66879725e-02f, 4.04032886e-01f, -1.12055890e-01f, 2.66609728e-01f, -3.31921875e-01f, -5.55890985e-02f, 1.90202966e-01f, -8.64398703e-02f, 4.91775751e-01f, 5.01354523e-02f,
  -9.83526483e-02f, -2.02894896e-01f, -1.73323169e-01f, 3.81924920e-02f, -1.25385657e-01f, 1.28035232e-01f, -1.75364450e-01f, 7.97447935e-02f, -1.78422295e-02f, -1.60499420e-02f,
  -5.01709431e-02f, 4.57947366e-02f, -4.93361205e-02f, 8.77994113e-03f, 1.46882962e-02f, 1.42128929e-01f, 1.51506141e-02f, 4.16550562e-02f, 1.35281175e-01f, 1.52266910e-02f,
  2.38706842e-01f, -3.99351902e-02f, 1.88295811e-01f, 1.54416054e-01f, 2.11938322e-01f, -7.68390298e-02f, 9.45272669e-03f, 1.56906709e-01f, -4.45133559e-02f, -7.13639706e-02f,
  -3.43951955e-02f, -8.99189413e-02f, -1.20268323e-01f, -3.15152816e-02f, 2.07183108e-01f, 4.71855283e-01f, 2.71448106e-01f, -2.37332642e-01f, -1.05253115e-01f, 1.17061287e-01f,
  -1.38197586e-01f, -2.03441784e-01f, 8.53504241e-02f, -1.10573821e-01f, 1.89912707e-01f, -1.83331057e-01f, -3.49007249e-02f, -1.68544561e-01f, 1.44603625e-01f, -5.70207499e-02f,
  5.45837618e-02f, 8.65817517e-02f, 7.51408413e-02f, -1.51403129e-01f, -3.68646383e-02f, 7.14624226e-02f, -5.52019030e-02f, 3.93713623e-01f, -2.51553386e-01f, -1.72673151e-01f,
  1.53458267e-01f, 1.53787648e-02f, -9.98307168e-02f, -8.13933164e-02f, 1.14977673e-01f, -2.15378702e-01f, 6.66840896e-02f, -7.59382024e-02f, 1.82329658e-02f, -6.35796860e-02f,
  1.00799212e-02f, 4.59191436e-03f, 8.94314516e-03f, 1.14106461e-02f, 1.84632123e-01f, -1.48424925e-02f, 1.42168954e-01f, -1.12480382e-02f, -1.45808846e-01f, -7.08272457e-02f,
  1.54820636e-01f, -1.72595397e-01f, -1.57628924e-01f, -7.16610178e-02f, -1.72974527e-01f, 1.74812943e-01f, -7.89034590e-02f, 2.07609266e-01f, 9.09958035e-03f, 2.65150871e-02f,
  2.51161158e-01f, -1.46335542e-01f, 4.10307534e-02f, 1.28689274e-01f, -6.63062278e-03f, -1.10932469e-01f, -4.05374616e-02f, -1.90154705e-02f, 2.21092150e-01f, 2.65028793e-02f,
  2.80692667e-01f, 1.15414709e-01f, -2.98382699e-01f, 1.73468292e-01f, 6.87816858e-01f, -3.20496589e-01f, -1.63690552e-01f, -6.91020042e-02f, 4.70748842e-02f, 2.17610039e-03f,
  -2.85171140e-02f, 7.41672218e-02f, 1.94368452e-01f, -3.41336951e-02f, -1.78283542e-01f, 1.58170983e-01f, 2.13367566e-02f, 2.76146699e-02f, -8.98789763e-02f, 3.01720977e-01f,
  -1.75666690e-01f, -6.09667487e-02f, -1.16194554e-01f, -4.54303659e-02f, 1.83573991e-01f, -1.07326973e-02f, 4.36707377e-01f, 1.10739447e-01f, -1.08166695e-01f, -9.96378902e-03f,
  1.61066368e-01f, 2.84964234e-01f, -9.76723209e-02f, -2.43545383e-01f, 3.16241205e-01f, -1.11349918e-01f, -8.74732360e-02f, 5.56810722e-02f, -2.59624664e-02f, -8.09341371e-02f,
  1.93141341e-01f, -9.15200822e-03f, -4.80737202e-02f, 2.01959372e-03f, 1.75251514e-02f, -6.27009049e-02f, 7.83025622e-02f, 1.07236445e-01f, -1.18967809e-01f, 1.66220292e-01f,
  1.45020232e-01f, 2.91370079e-02f, -1.11493655e-01f, 5.17504930e-01f, 1.66524630e-02f, -8.06508027e-03f, 1.39908597e-01f, 2.92730406e-02f, 7.62800500e-02f, -2.55447868e-02f,
  5.55260554e-02f, -1.13311850e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.79295048e-01f, 1.66438669e-01f, -6.08553104e-02f, -1.98839884e-02f, -2.93890741e-02f, 3.51367086e-01f, -3.73504944e-02f, 1.91553950e-01f, 4.36904989e-02f, -8.60830620e-02f,
  -3.92343570e-03f, -7.47639015e-02f, -1.17394172e-01f, -8.56873952e-03f, 3.19403857e-02f, 2.11620510e-01f, 1.34979978e-01f, -3.12149785e-02f, 1.19020015e-01f, -1.44258097e-01f,
  2.65172899e-01f, -1.47442788e-01f, 6.63322657e-02f, 1.88111998e-02f, 2.13568464e-01f, 1.88832760e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.82874039e-01f, -2.88028847e-02f, 2.76853740e-02f, -3.33749503e-02f, -2.57033020e-01f, 3.33730574e-03f, 1.51754573e-01f, 2.08582610e-01f, 1.15482152e-01f, 1.43871009e-02f,
  6.35877997e-02f, 1.14376143e-01f, -8.11841935e-02f, -1.63838238e-01f, 9.17939544e-02f, -3.26013416e-02f, 5.81927970e-02f, 8.41445699e-02f, -1.66685686e-01f, -3.15057904e-01f,
  -1.41500428e-01f, -3.20900798e-01f, 3.79061769e-03f, 1.75912395e-01f, 2.51167685e-01f, -8.17078575e-02f, 7.86235277e-03f, 1.27133161e-01f, -4.76533212e-02f, 8.67618620e-02f,
  1.77980155e-01f, -1.61197394e-01f, -8.06864649e-02f, -1.68854475e-01f, 6.57204315e-02f, 1.50295570e-01f, -1.78066447e-01f, -3.35378736e-01f, 1.73185356e-02f, -1.12338513e-02f,
  -1.40392929e-01f, 7.43282288e-02f, -2.13329159e-02f, -5.97164147e-02f, 1.22393683e-01f, -2.39656672e-01f, -5.06830215e-02f, -1.87267914e-01f, -1.05565093e-01f, -7.07716867e-02f,
  -1.17319435e-01f, -2.21175224e-01f, -9.21146646e-02f, -1.70161292e-01f, -9.15064514e-02f, 2.21745610e-01f, 2.09565967e-01f, -1.26216024e-01f, 2.39346787e-01f, -9.49817374e-02f,
  1.13383874e-01f, 1.77953482e-01f, 2.53990684e-02f, 5.03444299e-02f, 2.69529045e-01f, -5.08139748e-03f, 2.52999991e-01f, 1.44787148e-01f, 2.42387846e-01f, 5.67688644e-02f,
  1.20382912e-01f, 1.28449425e-01f, -4.69880179e-02f, 1.32222056e-01f, 6.58645332e-02f, 3.20833802e-01f, -1.05150722e-01f, 1.21034071e-01f, -1.48109093e-01f, -1.73002690e-01f,
  1.38291582e-01f, -7.63550997e-02f, 5.58727048e-02f, 2.27760896e-03f, 1.64333418e-01f, 1.29789606e-01f, -5.93973473e-02f, -4.39980142e-02f, 6.11192584e-02f, 9.02354866e-02f,
  -2.28792623e-01f, 1.82823792e-01f, 1.80107430e-01f, -1.12631451e-02f, -2.51270413e-01f, 5.27627990e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -2.34558776e-01f, -1.98615238e-01f, -2.38910228e-01f, -2.27371931e-01f, 1.08106069e-01f, 1.78037360e-01f, 7.73043837e-03f, -9.51204449e-02f, -1.37861848e-01f, 1.12002820e-01f,
  -1.20041398e-02f, -1.11891426e-01f, -7.01376349e-02f, -1.31882295e-01f, 8.39562342e-02f, 3.95013131e-02f, 7.04511777e-02f, 1.62219442e-02f, 3.33048403e-02f, 3.40502590e-01f,
  1.97795391e-01f, -8.28563347e-02f, -4.19806987e-02f, 9.96459369e-03f, -1.68744270e-02f, 1.04762271e-01f, -4.34683263e-03f, -2.40167137e-02f, 1.10687673e-01f, 1.11961216e-01f,
  -7.01295631e-03f, 1.32249251e-01f, 1.90138936e-01f, 1.59460783e-01f, -9.02943164e-02f, 1.66364074e-01f, -5.15096009e-01f, -3.60425651e-01f, 5.66574931e-02f, 1.35311291e-01f,
  -4.63343458e-03f, 1.81809813e-01f, 1.23799853e-01f, -1.15650460e-01f, 1.50940850e-01f, 1.23010188e-01f, 1.09708041e-01f, 1.96173764e-03f, 1.99322458e-02f, 3.77804376e-02f,
  -1.51209414e-01f, 1.03076346e-01f, -1.40354797e-01f, 1.19135343e-01f, -1.63906589e-01f, 3.66777629e-01f, 2.99000919e-01f, -3.85258906e-02f, 4.97814476e-01f, 1.37075365e-01f,
  2.53414232e-02f, -1.30794272e-01f, 4.81662959e-01f, 6.92437664e-02f, 1.49227977e-01f, -1.60075292e-01f, -1.40306354e-01f, 1.35622146e-02f, 1.47007093e-01f, 7.95876756e-02f,
  6.34013936e-02f, 1.00776508e-01f, 1.75739363e-01f, 1.57172769e-01f, -1.41040131e-01f, 1.24446452e-01f, -1.02880910e-01f, -8.15235600e-02f, 1.23215690e-01f, -1.24772400e-01f,
  -5.51722478e-03f, -1.68014720e-01f, 7.56409913e-02f, -9.07332152e-02f, 6.96630180e-02f, 3.61889303e-02f, -8.85064751e-02f, -7.88792074e-02f, 1.78013623e-01f, 1.68085650e-01f,
  -7.05203786e-02f, 1.57360002e-01f, 1.52327344e-01f, 1.48687869e-01f, -8.16096738e-02f, -1.23541221e-01f, -6.10539876e-02f, -7.01607019e-02f, -6.62861392e-02f, 8.40580743e-03f,
  3.90165299e-02f, -4.56769429e-02f, -6.61741421e-02f, 1.01372696e-01f, -9.90182087e-02f, -5.42343855e-02f, 1.04513936e-01f, -1.64045066e-01f, 3.57757509e-02f, 8.93062353e-02f,
  -9.68631078e-03f, 1.01683751e-01f, 1.17069960e-01f, 2.34819576e-02f, 6.68053329e-02f, 1.56162873e-01f, 8.46664310e-02f, 3.49505544e-02f, -4.36963178e-02f, -6.58809692e-02f,
  -4.27193157e-02f, 1.61467940e-01f, -1.42108202e-01f, -4.16756701e-03f, -1.63792893e-01f, -5.51569127e-02f, -8.99379477e-02f, -7.92381540e-02f, 1.81225445e-02f, -1.19398022e-03f,
  -1.43491449e-02f, -2.08309125e-02f, -2.71625035e-02f, 8.39930698e-02f, 2.97616925e-02f, -1.70977056e-01f, 8.47352520e-02f, 1.03312992e-02f, -4.90188077e-02f, 9.66789573e-02f,
  -1.69069037e-01f, -1.32462263e-01f, -1.12071328e-01f, -4.40234877e-03f, -3.51949260e-02f, 1.03659190e-01f, 1.11491330e-01f, -1.00191012e-01f, -1.72162261e-02f, -1.60858840e-01f,
  -9.92455333e-02f, 5.93731068e-02f, 1.55758649e-01f, 1.17351502e-01f, 5.16475178e-02f, 5.35071157e-02f, -7.00177848e-02f, -1.21284507e-01f, -1.27625480e-01f, 1.70920223e-01f,
  4.15384263e-01f, 1.90541059e-01f, 3.75522941e-01f, 4.64443326e-01f, 1.82579115e-01f, -2.01139867e-01f, 1.33908898e-01f, -5.70524205e-03f, 1.43235028e-01f, 1.60580769e-01f,
  1.21847942e-01f, 6.18421257e-01f, -1.94696054e-01f, 3.47259164e-01f, -1.56361741e-04f, -4.99688447e-01f, 1.81167871e-01f, 2.11188942e-01f, -1.72598600e-01f, 1.28821135e-01f,
  -7.55682215e-02f, 4.21279460e-01f, 1.21241406e-01f, 5.19314557e-02f, -1.82520673e-01f, -1.17056258e-01f, 2.43805423e-01f, -1.75653800e-01f, 6.03379846e-01f, 7.57844150e-02f,
  2.31455825e-02f, 4.14392292e-01f, -7.31911659e-02f, 1.51510490e-02f, 2.21959874e-02f, -3.95668745e-01f, -2.85203718e-02f, 5.14633842e-02f, -1.60112813e-01f, -9.63560119e-03f,
  -8.82582664e-02f, 9.96609181e-02f, 1.04893975e-01f, -1.57650501e-01f, 1.73062414e-01f, -3.53055284e-03f, 1.27623856e-01f, 2.44086683e-01f, 4.26402614e-02f, 1.18094653e-01f,
  -1.16564572e-01f, 2.55662948e-01f, 4.08029228e-01f, 3.27085823e-01f, -1.56847730e-01f, -5.60381673e-02f, 9.88355801e-02f, -2.56685279e-02f, -2.95393556e-01f, -1.12683922e-01f,
  -2.10730165e-01f, 1.25593133e-02f, 7.56213441e-03f, 1.61946222e-01f, -2.86757857e-01f, -1.66310638e-01f, 7.58898258e-02f, -1.16202213e-01f, -9.72795337e-02f, -4.72165644e-02f,
  -4.43692282e-02f, 3.77625436e-01f, 1.18453309e-01f, 1.66348606e-01f, -6.96267635e-02f, -1.33422494e-01f, -4.24079113e-02f, 1.76112801e-01f, 9.34912413e-02f, 2.88064256e-02f,
  -4.97617051e-02f, -1.28757805e-01f, -1.68170799e-02f, -3.47352952e-01f, -8.38093683e-02f, -4.00083572e-01f, 3.66872132e-01f, 2.25395650e-01f, 5.03201842e-01f, -1.71757326e-01f,
  -4.50086668e-02f, 1.13978475e-01f, -2.40806252e-01f, -1.23214297e-01f, 4.67115253e-01f, -1.73175648e-01f, -2.00410690e-02f, 4.26294237e-01f, 3.96272838e-01f, -2.16933787e-01f,
  2.00370848e-01f, 4.27345693e-01f, -1.87744692e-01f, -6.86841309e-02f, 1.47645980e-01f, -2.72429317e-01f, 4.30922471e-02f, 1.74333468e-01f, 2.13495567e-01f, 4.31301743e-01f,
  5.45413643e-02f, 6.68179512e-01f, -2.18391623e-02f, 1.04469940e-01f, -5.36379106e-02f, -1.06002986e-01f, 4.07703221e-01f, 2.42880762e-01f, 4.25858408e-01f, -1.60193995e-01f,
  1.66006625e-01f, -3.68951291e-01f, -4.33809131e-01f, -7.91729614e-02f, -2.63024777e-01f, -1.85518190e-01f, -9.08190757e-02f, -1.42744735e-01f, 1.01468109e-01f, 1.95381567e-01f,
  2.55561713e-02f, -1.94293499e-01f, -1.20088842e-03f, 2.07011655e-01f, -1.51266590e-01f, -1.40873402e-01f, -9.08745304e-02f, 8.74458253e-02f, 3.90144326e-02f, 1.95698902e-01f,
  5.80517352e-02f, 9.47936922e-02f, -2.39987224e-01f, 5.70775308e-02f, -8.19477290e-02f, -9.87018179e-03f, -8.35264549e-02f, 2.70092785e-01f, 4.26238447e-01f, 4.48811293e-01f,
  -1.64618175e-02f, -1.98868603e-01f, -1.42767936e-01f, -1.30754486e-01f, -3.87695938e-01f, -1.13741986e-01f, -4.12210450e-03f, -5.51492833e-02f, -1.26238510e-01f, 8.18588957e-02f,
  2.95405034e-02f, 9.82446820e-02f, -1.36880368e-01f, 1.06742561e-01f, 3.04947644e-02f, 8.07300806e-02f, 1.15013838e-01f, -1.23029664e-01f, 6.87234700e-02f, -8.33648890e-02f,
  1.48161277e-02f, -5.62869906e-02f, -1.11340165e-01f, -3.39744501e-02f, -1.38988107e-01f, -1.66578859e-01f, -1.26676559e-01f, 4.95440327e-02f, -8.04229602e-02f, 8.63443762e-02f,
  -8.83346796e-02f, -1.51567429e-01f, -1.64847448e-01f, 6.46889284e-02f, -1.07558839e-01f, -8.38652402e-02f, -1.72330260e-01f, -9.19859186e-02f, 1.21316761e-01f, -1.28134504e-01f,
  1.11411013e-01f, 1.18938185e-01f, 2.93072939e-01f, 7.69670755e-02f, 4.44940746e-01f, 1.45840347e-02f, 4.81853604e-01f, 3.19282979e-01f, 3.33914198e-02f, -2.74278492e-01f,
  1.10562347e-01f, -6.51217550e-02f, 5.02842888e-02f, 3.06025118e-01f, 3.73868905e-02f, 1.66632384e-01f, -3.03782701e-01f, -1.41042739e-01f, -3.86877693e-02f, 8.60089809e-02f,
  5.78258261e-02f, 1.96084887e-01f, 1.82321265e-01f, 5.92037976e-01f, 1.20055698e-01f, -9.63095799e-02f, -2.28401706e-01f, -1.52669460e-01f, -2.42188826e-01f, -2.02690035e-01f,
  -3.87228020e-02f, -1.00387797e-01f, -3.77465963e-01f, 1.56156868e-01f, -2.26340815e-02f, -1.37124434e-01f, 6.63140789e-02f, -1.51673079e-01f, -4.71638404e-02f, 5.92026152e-02f,
  -4.73377630e-02f, 1.65331066e-01f, 1.49979889e-01f, 1.70810401e-01f, 4.36384492e-02f, -2.17272356e-01f, -1.24314561e-01f, -1.63332254e-01f, 1.06885731e-02f, 1.55950889e-01f,
  1.16708137e-01f, -5.79240695e-02f, 1.28832549e-01f, 2.41604552e-01f, 1.06137641e-01f, 2.58974880e-01f, -2.66211461e-02f, 1.52894780e-01f, 1.92142114e-01f, 1.25788361e-01f,
  5.78291938e-02f, 4.26410958e-02f, -1.32794961e-01f, 2.70156506e-02f, 2.54505008e-01f, -8.22308660e-02f, -7.10231885e-02f, 6.48457408e-02f, -1.70591861e-01f, -2.07792133e-01f,
  -1.39938161e-01f, -4.24423702e-02f, -1.60315022e-01f, 9.08671841e-02f, 1.71223171e-02f, -2.43897270e-02f, -1.37731552e-01f, -2.17538327e-01f, -7.63681307e-02f, 2.22649183e-02f,
  4.20683593e-01f, -3.42779383e-02f, 9.54437479e-02f, 5.40815070e-02f, -2.08905749e-02f, -3.41963172e-01f, 9.01291743e-02f, -2.58804336e-02f, 1.18291244e-01f, 3.62016112e-01f,
  4.23359722e-01f, 1.90729678e-01f, 2.37948686e-01f, 1.06977396e-01f, -8.45818073e-02f, 1.13066971e-01f, 4.92652565e-01f, -2.76410311e-01f, 2.31026709e-01f, -2.04574227e-01f,
  9.18445438e-02f, -5.40530682e-01f, 5.01201391e-01f, 5.01953602e-01f, -1.12007119e-01f, 3.13784093e-01f, 2.04158127e-01f, 1.40319183e-01f, -2.56258011e-01f, -2.23359019e-01f,
  3.75422060e-01f, 3.71328562e-01f, -2.72297896e-02f, 3.75316709e-01f, -2.79388223e-02f, 8.50122571e-02f, -3.42057720e-02f, 1.08717822e-01f, 3.90047759e-01f, -2.63556391e-01f,
  6.45742238e-01f, 1.84468016e-01f, -5.55302203e-03f, 1.10550448e-02f, 1.57888174e-01f, 5.46884313e-02f, -3.38627964e-01f, 6.33566678e-02f, -8.30892771e-02f, 1.92173272e-01f,
  3.04821953e-02f, 2.14227527e-01f, -4.44362536e-02f, -4.57822084e-02f, -4.34578836e-01f, -3.78975153e-01f, 1.55638576e-01f, -7.65030757e-02f, 6.92636669e-02f, 1.86092809e-01f,
  5.37546128e-02f, 1.15202423e-02f, -1.37350693e-01f, -2.18715250e-01f, 3.09774846e-01f, -1.18861295e-01f, 1.07557438e-01f, 5.84641360e-02f, -1.59512505e-01f, 5.00200808e-01f,
  2.15104178e-01f, 5.62013268e-01f, -3.61984193e-01f, 2.29231566e-01f, 2.12559626e-01f, 3.39302123e-01f, 3.53085667e-01f, 1.40091196e-01f, 1.77390471e-01f, 7.51629621e-02f,
  2.57584244e-01f, 2.46209383e-01f, -2.78878629e-01f, -7.66598880e-02f, 3.18528786e-02f, 1.80871189e-01f, -1.67670384e-01f, -3.18683498e-02f, 6.08936362e-02f, -3.07020498e-04f,
  -1.59741133e-01f, -1.76517531e-01f, 1.24501206e-01f, 5.05349003e-02f, -6.65738359e-02f, 1.10466033e-01f, -1.00078285e-01f, 2.01314747e-01f, 1.59690470e-01f, -1.40787542e-01f,
  -8.93349499e-02f, 1.85974643e-01f, -1.71445668e-01f, -2.22832169e-02f, 2.40126415e-03f, 9.06620398e-02f, -3.10685411e-02f, 1.64039001e-01f, -5.37913442e-02f, 3.87518331e-02f,
  9.30179805e-02f, -1.22009940e-01f, 1.45413280e-01f, -1.26748547e-01f, -4.37938981e-02f, 2.31590167e-01f, 1.80140674e-01f, 1.37947559e-01f, -2.45503381e-01f, -9.89559963e-02f,
  -9.34685171e-02f, 1.12248830e-01f, 1.57699659e-01f, -1.29143983e-01f, -7.85340592e-02f, -1.13231704e-01f, 1.41800329e-01f, 4.54468466e-02f, 2.26920992e-01f, -1.96501851e-01f,
  9.91407484e-02f, 7.70259053e-02f, -1.70516998e-01f, 2.35583503e-02f, -2.15163141e-01f, -1.16400570e-01f, -1.33790458e-02f, 3.70155752e-01f, 1.93187729e-01f, 1.84022769e-01f,
  5.02057850e-01f, -7.05388710e-02f, 2.09033608e-01f, 1.44972220e-01f, 4.51913148e-01f, -2.26262603e-02f, 1.33767769e-01f, 3.61382551e-02f, -9.42294300e-02f, -2.30799139e-01f,
  -4.02864255e-02f, 3.06640834e-01f, 2.26530675e-02f, 1.12934157e-01f, 7.19328821e-02f, 3.22709344e-02f, -3.44791375e-02f, -1.44300431e-01f, 1.27693549e-01f, 5.37989557e-01f,
  9.50870886e-02f, 3.80226135e-01f, -1.25499340e-02f, -1.94832936e-01f, -1.05456561e-01f, 3.07758659e-01f, 8.16132687e-03f, -5.57716966e-01f, 5.58235347e-01f, 8.62769317e-03f,
  -1.55488938e-01f, 4.76744305e-03f, 4.14909393e-01f, 6.66777119e-02f, -2.11733326e-01f, -1.16866268e-01f, -7.81181753e-02f, 1.28788456e-01f, -1.11280851e-01f, -1.33339003e-01f,
  7.83097669e-02f, 8.69598389e-02f, 2.81936023e-02f, -1.23167247e-01f, -1.18316315e-01f, -1.12976238e-01f, -1.80867519e-02f, 1.42477870e-01f, 1.16085015e-01f, 1.19677735e-02f,
  -1.46039173e-01f, -1.73796758e-01f, -1.31196395e-01f, 1.65681124e-01f, 3.53576280e-02f, 1.86018914e-01f, -1.65122166e-01f, 1.84719920e-01f, 6.22722395e-02f, -1.36503935e-01f,
  9.51487944e-02f, 1.47754163e-01f, -1.39539987e-01f, -8.18129480e-02f, -4.70306389e-02f, 1.98679239e-01f, -1.07847154e-01f, -1.45356581e-01f, 1.17526062e-01f, -9.49796587e-02f,
  3.21456820e-01f, -9.06507522e-02f, 1.80072457e-01f, -3.56475972e-02f, 1.86118186e-02f, 1.11948758e-01f, -5.75721404e-03f, 2.40679517e-01f, 1.43915921e-01f, -2.07817957e-01f,
  1.35267302e-01f, 3.61696064e-01f, 2.16800123e-01f, 3.82612228e-01f, 2.73033082e-01f, 1.81408912e-01f, -1.42789230e-01f, 2.41603568e-01f, -1.60881668e-01f, -1.73090130e-01f,
  -2.03944504e-01f, -7.32608885e-02f, 3.55697066e-01f, -9.73155629e-03f, 1.51968971e-01f, -3.04457277e-01f, 2.34244481e-01f, -1.41778618e-01f, 1.29573256e-01f, 5.47509640e-02f,
  7.60959983e-02f, -2.54798830e-02f, -3.52340966e-01f, 9.98773500e-02f, -2.77334511e-01f, -3.53846937e-01f, -3.95799540e-02f, -1.71274343e-03f, 1.45213425e-01f, 1.53923929e-01f,
  -1.03459433e-01f, 8.55790526e-02f, -9.62672308e-02f, -3.32393348e-01f, 1.87547579e-01f, 1.93918124e-01f, 3.07567231e-02f, 5.35318911e-01f, 8.89760777e-02f, -6.67422861e-02f,
  -1.39806077e-01f, 9.82485414e-02f, 3.69549811e-01f, -3.23665403e-02f, 1.77694969e-02f, -4.96734716e-02f, 3.02184671e-01f, 7.27510750e-02f, 9.48430151e-02f, -2.33342294e-02f,
  -2.39195406e-01f, 3.15162763e-02f, 1.16128393e-01f, -3.21491778e-01f, 3.09285909e-01f, 2.62697786e-01f, 1.46045268e-01f, 4.48113739e-01f, -1.38405725e-01f, -2.76914924e-01f,
  5.98883070e-02f, 1.01396225e-01f, 3.47051136e-02f, -9.12754834e-02f, 5.46504296e-02f, 5.71503460e-01f, 2.59035379e-01f, 2.84228623e-01f, 3.36068794e-02f, -2.78081954e-01f,
  -8.76131132e-02f, 3.61472182e-02f, 7.03815594e-02f, 5.78528903e-02f, -1.65339306e-01f, 1.58233464e-01f, 2.72861928e-01f, 1.85373530e-01f, 4.41484228e-02f, -2.14824662e-01f,
  2.95717180e-01f, 1.83040068e-01f, 1.64068550e-01f, -1.82337970e-01f, 1.93697527e-01f, 1.05219692e-01f, 5.27708642e-02f, 8.64188150e-02f, 2.92333156e-01f, 1.47820041e-01f,
  2.77978212e-01f, -9.43852812e-02f, -4.01952714e-02f, 2.19071537e-01f, -1.62167370e-01f, -8.99155363e-02f, 1.58979401e-01f, -1.21515263e-02f, 1.65404439e-01f, 3.22414935e-01f,
  8.42659920e-02f, 1.43722206e-01f, 9.66641456e-02f, 3.46025079e-02f, 8.40890333e-02f, -9.15227160e-02f, 1.17795467e-01f, -3.11919272e-01f, 4.74687040e-01f, 1.07551396e-01f,
  -5.35306968e-02f, 4.05568443e-02f, 3.69372815e-01f, -9.19059105e-03f, -3.48344818e-02f, -2.09512174e-01f, 1.00166745e-01f, -1.40297776e-02f, -1.49283007e-01f, -1.60092458e-01f,
  -4.18212265e-02f, 2.19552025e-01f, -1.14234108e-02f, 1.64493158e-01f, 1.93406507e-01f, -2.40415812e-01f, -2.07010657e-01f, 1.22891545e-01f, 1.71332657e-01f, -4.92753424e-02f,
  3.07863969e-02f, -3.58610973e-02f, -1.13173742e-02f, 1.73135296e-01f, 1.69852413e-02f, -1.54292643e-01f, 1.68259159e-01f, 4.12126720e-01f, 1.94427595e-01f, 3.59807849e-01f,
  -2.81853765e-01f, 3.95763963e-02f, -1.60099879e-01f, 4.79289144e-02f, -1.10508010e-01f, -6.17793314e-02f, -1.65530834e-02f, 1.58700738e-02f, 3.48312110e-02f, -3.96475308e-02f,
  -2.06668243e-01f, 1.54646456e-01f, -4.31371592e-02f, -1.47940993e-01f, -2.66923249e-01f, 3.38965245e-02f, -1.69982940e-01f, -5.37163131e-02f, 4.25366499e-02f, -1.06725454e-01f,
  -9.59512219e-02f, -3.03386331e-01f, 6.52225688e-02f, -2.21719757e-01f, 1.79403797e-01f, 1.89341947e-01f, 2.83180643e-02f, -9.38419327e-02f, -1.81714237e-01f, 9.16540176e-02f,
  2.59677857e-01f, 3.43837947e-01f, -3.05218577e-01f, 2.02084854e-01f, 8.04430768e-02f, 2.52933711e-01f, 2.41182923e-01f, 4.63321693e-02f, 3.76062579e-02f, 6.49156496e-02f,
  3.54936235e-02f, 9.84406173e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -2.81650554e-02f, 2.93305982e-02f, 1.54142054e-02f, -9.95541364e-02f, 5.62370531e-02f, 1.42386153e-01f, 4.70287055e-02f, -7.34568164e-02f, 2.18667254e-01f, 2.28815898e-01f,
  -8.02145451e-02f, 3.21444571e-01f, -1.29169598e-01f, 1.24790715e-02f, -1.74940936e-02f, 2.60606468e-01f, -1.57740951e-01f, 2.18765393e-01f, 5.10610826e-02f, -3.23436372e-02f,
  1.99801400e-01f, -1.98934272e-01f, 2.30599463e-01f, -3.30694169e-02f, -1.59276575e-01f, 5.41404039e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -6.27535105e-01f, -3.77780348e-01f, -3.58324409e-01f, -6.65783603e-03f, 1.37348548e-01f, 3.11464399e-01f, -1.44288868e-01f, 1.62595883e-01f, 1.40759677e-01f, -4.07684632e-02f,
  2.25418359e-02f, -2.53792703e-01f, 6.17680699e-02f, 6.40613675e-01f, -7.04168558e-01f, -2.12069631e-01f, -1.73537150e-01f, -1.99728519e-01f, 6.86635524e-02f, 5.31777382e-01f,
  2.32392829e-02f, -1.34956971e-01f, 3.74215059e-02f, 2.43738577e-01f, 4.68261428e-02f, 1.32533163e-01f, 2.01937720e-01f, 2.33644933e-01f, -2.35925913e-02f, 3.07209015e-01f,
  -1.24348931e-01f, -1.04473718e-02f, -2.85867065e-01f, 3.75014544e-01f, -2.33254820e-01f, 4.43508089e-01f, 3.95299979e-02f, -5.32508314e-01f, 7.31885210e-02f, 1.83376357e-01f,
  -1.65862128e-01f, 2.16385379e-01f, -1.23937272e-01f, -6.62138760e-01f, 1.34786487e-01f, 4.34098661e-01f, 6.39283776e-01f, -6.19267747e-02f, -6.60656691e-02f, -3.52398872e-01f,
  3.01794522e-02f, 4.27188605e-01f, -2.61784047e-01f, -7.81238303e-02f, 3.66180003e-01f, 2.93237001e-01f, 1.43588275e-01f, 2.44551301e-01f, 2.47293681e-01f, 4.74574089e-01f,
  -1.34822473e-01f, 6.48213327e-02f, 4.21562880e-01f, 1.20903365e-01f, 5.92648447e-01f, 2.79102683e-01f, 5.72414875e-01f, 1.24049066e-02f, 3.74764919e-01f, 2.74985731e-01f,
  -1.60740502e-02f, 4.41049308e-01f, 1.64110854e-01f, 8.20689648e-02f, 1.39921576e-01f, 5.57178378e-01f, -4.36658442e-01f, -4.64572459e-01f, -2.90102273e-01f, -5.03274202e-01f,
  -1.70312598e-01f, -5.44297040e-01f, -7.67301992e-02f, 1.49968773e-01f, -7.35189378e-01f, 4.22186226e-01f, 6.08910620e-03f, 4.49686319e-01f, -5.05579710e-01f, 1.51801810e-01f,
  -3.02223815e-03f, -3.86009276e-01f, 2.96497434e-01f, -1.32208228e-01f, -1.65453404e-01f, 6.35295454e-03f, 4.84184101e-02f, 1.19040683e-01f, -9.29891020e-02f, -4.02008519e-02f,
  7.56046772e-02f, -4.16630238e-01f, 1.94528967e-01f, 2.06726521e-01f, -4.50526476e-02f, -1.03592299e-01f, 1.15178689e-01f, -2.42740259e-01f, 7.39804581e-02f, -4.25782412e-01f,
  -3.35075170e-01f, -2.29250744e-01f, -2.37852521e-02f, -1.02977619e-01f, 2.99030066e-01f, 3.34944963e-01f, 8.90716836e-02f, 5.50652087e-01f, 1.04329921e-02f, 2.64813215e-01f,
  4.88346145e-02f, -2.06997544e-01f, -3.60776097e-01f, 1.95618048e-01f, -2.93043166e-01f, 3.37441340e-02f, 4.71606068e-02f, 4.26049322e-01f, -2.62259454e-01f, -1.92548931e-01f,
  -1.56451628e-01f, 4.71788079e-01f, 3.12532812e-01f, -5.93724012e-01f, -2.29175645e-03f, 4.94950175e-01f, 1.63121417e-01f, 3.38385627e-02f, 1.65439174e-01f, 1.53427660e-01f,
  -3.06867242e-01f, -3.35143171e-02f, -4.72481251e-01f, -6.90203980e-02f, 1.34444237e-01f, -2.99890935e-01f, 6.34220093e-02f, 3.33735198e-02f, -2.02556282e-01f, 2.42813483e-01f,
  6.99897557e-02f, 1.96732193e-01f, 3.09294671e-01f, 6.05270192e-02f, 3.63480836e-01f, -1.19351618e-01f, 4.18129206e-01f, -5.39248437e-02f, -3.41287628e-02f, -1.39659449e-01f,
  3.65619391e-01f, -6.02085851e-02f, 1.52503490e-01f, 2.13863477e-01f, 1.07310507e-02f, -1.18200183e-01f, -1.72111616e-02f, -1.32773206e-01f, -1.03669325e-02f, 8.72577131e-02f,
  9.11993608e-02f, -6.83131814e-03f, -2.10573569e-01f, 2.46469364e-01f, 4.89904881e-01f, -3.27853531e-01f, -1.07573316e-01f, -4.31669980e-01f, 5.25403917e-02f, 4.88286763e-02f,
  4.44026381e-01f, -4.71900225e-01f, -1.64174527e-01f, -8.84173438e-02f, 2.11361170e-01f, -2.20958535e-02f, 3.29662651e-01f, -3.05733886e-02f, 2.95535415e-01f, 2.93775529e-01f,
  -6.70667365e-02f, -3.34605753e-01f, 4.10906883e-04f, 1.01728551e-01f, 5.37438616e-02f, -4.11406085e-02f, -2.50385582e-01f, 2.66202897e-01f, -3.00480127e-01f, -3.93802464e-01f,
  -1.26466770e-02f, -1.99576408e-01f, 4.47835699e-02f, 5.78824818e-01f, 4.50548120e-02f, 7.52776116e-02f, 3.00916493e-01f, 4.56688792e-01f, -9.54135042e-03f, 7.92305589e-01f,
  -2.19036326e-01f, -1.26773730e-01f, -5.87174118e-01f, -5.65747917e-02f, -1.09946087e-01f, -3.82028908e-01f, -5.23085475e-01f, 1.26295567e-01f, 2.48544924e-02f, -4.54644650e-01f,
  2.30076358e-01f, -1.90856114e-01f, -1.84598181e-03f, -2.98482209e-01f, -1.99342407e-02f, -2.48694256e-01f, -3.32876921e-01f, 1.16620772e-01f, -3.18084627e-01f, 1.64379001e-01f,
  3.65102828e-01f, -4.02392417e-01f, -4.89060208e-02f, 6.07397072e-02f, -2.41230745e-02f, -5.56521654e-01f, 4.83699977e-01f, -1.54972583e-01f, 1.57545149e-01f, 2.33016148e-01f,
  -2.90467385e-02f, 1.54893592e-01f, 2.79879212e-01f, -8.93588141e-02f, 1.60514668e-01f, 1.18834078e-01f, -7.48951063e-02f, -4.58600670e-02f, -2.41058648e-01f, -3.52456868e-02f,
  -5.38633108e-01f, 1.89238176e-01f, -6.78100228e-01f, -5.71416616e-01f, 4.50088412e-01f, 4.01681751e-01f, 2.10710540e-01f, -2.28718117e-01f, 3.58377457e-01f, -1.24171935e-01f,
  -9.04743895e-02f, -7.29229599e-02f, 9.04800072e-02f, -5.35880566e-01f, -6.59274086e-02f, 2.16392465e-02f, 1.43369943e-01f, -3.81646335e-01f, 9.59115848e-02f, 5.59870452e-02f,
  1.57225370e-01f, 7.57395178e-02f, -1.54391482e-01f, -8.54863971e-02f, -1.98313460e-01f, -1.61345512e-01f, 8.15303147e-01f, -5.66511571e-01f, 4.83815596e-02f, -5.02912879e-01f,
  6.56702638e-01f, -1.20822340e-02f, -1.68627128e-01f, 4.62550640e-01f, -5.89840412e-01f, 4.99297604e-02f, -2.55071849e-01f, -3.47519815e-01f, -1.21729091e-01f, 3.11743468e-01f,
  -1.84779540e-02f, -3.66004378e-01f, -1.84681773e-01f, 3.87350291e-01f, -1.32153451e-01f, 1.67128205e-01f, 1.32313251e-01f, -1.21401370e-01f, -1.35532292e-02f, 6.25269890e-01f,
  5.98634332e-02f, -5.47563396e-02f, -4.76910949e-01f, 7.49264061e-02f, -1.08850487e-01f, 1.86396658e-01f, -7.89131373e-02f, -4.42054272e-01f, -4.11815286e-01f, 6.36492550e-01f,
  4.79095429e-02f, -1.20479703e-01f, -2.77147204e-01f, -1.19043708e-01f, -3.27355921e-01f, 3.02177458e-03f, 1.13668889e-01f, -2.09735349e-01f, 1.64576098e-01f, 1.72192648e-01f,
  7.12332726e-02f, 1.69477299e-01f, 2.82074273e-01f, -4.38523471e-01f, -1.75150812e-01f, 3.28891098e-01f, -1.27907127e-01f, -2.20874891e-01f, -1.66151926e-01f, -6.87084571e-02f,
  3.05929892e-02f, 4.72343951e-01f, -2.55403250e-01f, -4.63580638e-01f, 6.68824613e-02f, -2.69641280e-01f, 8.36083516e-02f, 1.18299484e-01f, -3.31203640e-01f, -4.78228211e-01f,
  2.84028411e-01f, -3.79655272e-01f, 4.64733653e-02f, 2.22192612e-02f, 4.95061994e-01f, 5.11964411e-02f, 3.42786700e-01f, -4.19443429e-01f, 3.32593113e-01f, 4.38875407e-01f,
  -2.08167627e-01f, -1.05765253e-01f, -7.72278607e-02f, -3.92307080e-02f, -2.28653058e-01f, 4.37564440e-02f, -2.06650898e-01f, 3.53087872e-01f, -2.33928889e-01f, -3.13881129e-01f,
  -3.71405818e-02f, 3.02364789e-02f, 4.56836484e-02f, -1.52549207e-01f, 3.59273344e-01f, -2.35490546e-01f, 6.10440016e-01f, 2.81433940e-01f, -1.27628326e-01f, 5.06735146e-01f,
  -8.72756392e-02f, 3.86946686e-02f, 3.54904860e-01f, -3.21529895e-01f, -2.81729192e-01f, -3.87689650e-01f, -2.66466230e-01f, -1.86016470e-01f, 1.95477411e-01f, -1.97979361e-01f,
  -1.34404406e-01f, -9.69112143e-02f, -1.47632033e-01f, -3.90139036e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.45608920e-01f, -1.59790099e-01f, 5.35405008e-03f, -9.08642858e-02f, -1.28020579e-02f, -9.17026401e-02f, 6.24311194e-02f, -6.67850152e-02f, -7.29171140e-03f, 1.25689059e-01f,
  1.66039377e-01f, -2.36799419e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    