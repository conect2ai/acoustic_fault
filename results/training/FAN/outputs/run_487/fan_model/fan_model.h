/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.20843291e-01f, -4.65010136e-01f, -6.05527818e-01f, 9.24198702e-02f, 4.93184716e-01f, -1.34975627e-01f, -1.33933544e-01f, 8.91961902e-02f, 1.15658134e-01f, -3.92322332e-01f,
  -6.18651658e-02f, -1.59736916e-01f, -1.46284565e-01f, -6.88546225e-02f, 3.37273717e-01f, -2.25317478e-01f, 5.25414497e-02f, -1.12172902e-01f, 1.13545719e-03f, 4.17198725e-02f,
  5.26112095e-02f, 2.85765022e-01f, -2.18397230e-01f, 3.07345223e-02f, 8.67525581e-03f, -1.57706931e-01f, 2.29261771e-01f, -2.65671402e-01f, 7.24191666e-02f, 1.80776343e-02f,
  1.23670250e-01f, -1.85468402e-02f, -3.28918099e-02f, -3.89648043e-02f, 1.04970466e-02f, -5.27555458e-02f, -2.82960441e-02f, -7.76795223e-02f, -1.33414296e-02f, 1.41734742e-02f,
  -1.20130824e-02f, 9.42822769e-02f, 3.65657508e-02f, -1.22121908e-01f, 1.51573978e-02f, -7.19596073e-02f, -3.06228492e-02f, -2.97736842e-02f, -5.21688834e-02f, 2.98617706e-02f,
  -1.56678468e-01f, -4.01988439e-02f, -1.56025952e-02f, -1.07982703e-01f, 1.80736817e-02f, 2.23156018e-03f, -7.24261552e-02f, 4.41792682e-02f, -2.13119085e-03f, 3.56546044e-02f,
  5.48336990e-02f, 8.42322931e-02f, -2.26553008e-02f, 2.64385287e-02f, 3.02269720e-02f, 3.47246192e-02f, -5.06510697e-02f, 8.62320811e-02f, -5.07559404e-02f, 5.92816062e-02f,
  1.75231665e-01f, 5.54623455e-02f, 2.34638900e-02f, -4.20701653e-02f, 9.64511707e-02f, -4.88210615e-04f, -2.61509195e-02f, 6.30440074e-04f, 1.79879123e-03f, 1.80916358e-02f,
  -4.16102586e-03f, -6.06926382e-02f, -5.72649762e-03f, 2.74891350e-02f, 3.16178612e-02f, 3.03545836e-02f, -4.59950231e-02f, -2.98127104e-02f, -3.00140213e-02f, -2.28631198e-02f,
  9.20268893e-03f, 1.71712991e-02f, 1.02995383e-02f, 9.63614043e-03f, -2.19480675e-02f, 1.85989942e-02f, 9.22605544e-02f, -4.22366746e-02f, -6.33261055e-02f, 3.81615683e-02f,
  -4.26218919e-02f, -1.53290574e-02f, 3.18547934e-02f, 1.76671743e-02f, -3.30425948e-02f, 2.67871469e-02f, 4.97274809e-02f, -5.10798991e-02f, 5.59224971e-02f, 1.44687726e-03f,
  -3.57413329e-02f, 6.24173433e-02f, -4.55706790e-02f, 7.29799643e-02f, 7.67884180e-02f, 2.16474198e-02f, 6.07536547e-02f, -5.72766513e-02f, 6.61720335e-02f, -6.18415736e-02f,
  -4.28001314e-01f, 6.71551451e-02f, -3.97839010e-01f, -4.40565020e-01f, 1.53996912e-03f, -9.99968871e-02f, -8.82979557e-02f, 2.52219290e-02f, -1.47314712e-01f, 3.38985682e-01f,
  1.16816960e-01f, -4.54018787e-02f, 3.54810029e-01f, -1.44346148e-01f, -4.04860705e-01f, 2.89822340e-01f, -2.64997482e-01f, 3.80263515e-02f, 5.39905392e-02f, -7.28036016e-02f,
  -1.21703453e-01f, 1.63779065e-01f, -8.72501731e-02f, 2.58770287e-02f, -2.66005337e-01f, -2.37315476e-01f, -1.76798642e-01f, -7.20891207e-02f, -2.37315327e-01f, -5.88134080e-02f,
  5.65648638e-02f, 2.13154152e-01f, -7.97266215e-02f, 3.74988876e-02f, -1.94143616e-02f, 2.70991996e-02f, -6.49758950e-02f, -1.53061841e-02f, -6.72088610e-03f, 5.36979735e-02f,
  1.88034009e-02f, 1.11711323e-02f, -1.28095038e-02f, 1.46092596e-02f, -1.03441685e-01f, -1.87140927e-01f, -2.42885593e-02f, 6.13296777e-02f, 3.01384344e-03f, 1.90139504e-03f,
  8.68621573e-04f, -6.25148416e-02f, -1.76116690e-01f, 7.50411153e-02f, -5.17906621e-02f, -3.08656693e-02f, -2.95571294e-02f, 1.88587476e-02f, -4.07521278e-02f, -4.93925586e-02f,
  6.76792786e-02f, 2.26745792e-02f, -2.12097336e-02f, -4.64347526e-02f, 1.88596323e-02f, 5.35648391e-02f, -7.18553830e-03f, 1.08622372e-01f, -6.89752847e-02f, 4.11526114e-02f,
  -7.21016377e-02f, -2.69252844e-02f, 5.69728203e-02f, -3.26505676e-02f, 3.00099794e-02f, -2.69599482e-02f, 9.97509360e-02f, 7.80084804e-02f, -1.37985451e-02f, -7.93717802e-02f,
  7.49044567e-02f, -9.33628157e-02f, 2.83973161e-02f, -3.41473781e-02f, 4.47024032e-02f, -3.70741524e-02f, -6.10605031e-02f, -4.96311300e-02f, -6.40124306e-02f, 1.12151382e-02f,
  -2.25050356e-02f, -2.18410492e-01f, 5.73342182e-02f, 6.32532239e-02f, 3.63632217e-02f, 9.80298780e-03f, 2.15267646e-03f, -4.73132655e-02f, -9.48773250e-02f, 1.96803920e-02f,
  1.51382759e-02f, -1.68097764e-02f, 2.59717628e-02f, -3.05504799e-02f, 1.09401140e-02f, 1.45117417e-02f, 9.28596258e-02f, -4.87887189e-02f, -8.28719139e-02f, 6.49597310e-03f,
  -4.66090441e-02f, 8.22940916e-02f, 4.02354524e-02f, 3.30401920e-02f, 3.55235748e-02f, 1.16381664e-02f, -4.40483131e-02f, 2.17949394e-02f, 2.86180563e-02f, 3.14794928e-02f,
  7.33033299e-01f, 6.86622486e-02f, 1.51046589e-01f, 3.09268147e-01f, 2.14951441e-01f, 1.91258147e-01f, 2.39789993e-01f, 1.76555365e-01f, 3.82535368e-01f, 9.03125927e-02f,
  9.92225558e-02f, 1.23936355e-01f, -1.26179129e-01f, 2.62357164e-02f, -9.16690677e-02f, -1.95261717e-01f, 3.21301252e-01f, 2.14141682e-01f, -7.00423494e-02f, 2.07761213e-01f,
  -1.33058289e-03f, 1.39686046e-02f, -1.11557201e-01f, -1.63267151e-01f, 3.29476178e-01f, 8.91532823e-02f, -1.56088531e-01f, -1.35302588e-01f, -4.00080159e-02f, -5.78149520e-02f,
  1.15987591e-01f, 1.30645618e-01f, 1.14105307e-01f, 1.61914807e-03f, 6.36103228e-02f, 1.74967442e-02f, 1.50416112e-02f, -4.79951091e-02f, -1.04193546e-01f, -6.96407631e-02f,
  1.23930245e-03f, -3.09626907e-02f, -1.04307219e-01f, 4.39852476e-03f, 1.55665532e-01f, 5.65338507e-02f, 2.15777494e-02f, 1.17096238e-01f, -5.75156175e-02f, 1.99660640e-02f,
  -6.66464539e-03f, -3.39422226e-02f, 1.09414786e-01f, -3.26711573e-02f, 1.86973568e-02f, 5.07035619e-03f, 5.31429984e-02f, -1.51495263e-02f, 9.23326090e-02f, 3.10180131e-02f,
  -1.23618491e-01f, -2.43857168e-02f, -2.18626559e-02f, 2.89484076e-02f, -1.04999095e-02f, 3.27084120e-03f, 2.59693712e-02f, -9.11735967e-02f, 2.47336570e-02f, 3.95231843e-02f,
  7.85859972e-02f, 1.44228444e-01f, -1.59389824e-02f, 3.94854993e-02f, 2.98542213e-02f, 8.57660323e-02f, 1.33273075e-03f, 6.40821084e-02f, 1.06426708e-01f, 6.07953481e-02f,
  8.60051252e-03f, -1.21172639e-02f, 5.46832159e-02f, 2.57084351e-02f, -1.15646906e-02f, -5.76578565e-02f, 9.20165703e-02f, 4.84426469e-02f, -2.50468068e-02f, -9.06468835e-03f,
  2.77825385e-01f, 1.93771929e-01f, -8.64821449e-02f, 3.71753909e-02f, -5.64592518e-02f, -3.83703858e-02f, -9.94375050e-02f, 4.23073806e-02f, 1.37268258e-02f, 5.04617207e-02f,
  3.70252654e-02f, 5.82270734e-02f, 1.03709124e-01f, 5.29927090e-02f, -7.30462894e-02f, 1.87974703e-02f, -4.88009416e-02f, 1.09099902e-01f, 4.83155102e-02f, -3.83355543e-02f,
  4.55751717e-02f, 6.10141233e-02f, -1.43684372e-01f, 7.47555345e-02f, 5.12717571e-03f, 3.50222252e-02f, 5.25196493e-02f, 9.95148718e-03f, -7.96894655e-02f, 1.50162994e-03f,
  3.99861336e-01f, -2.34629393e-01f, -5.44874445e-02f, 1.51353881e-01f, 3.19245309e-01f, 2.77463377e-01f, 1.18978925e-01f, 1.17463775e-01f, -4.10295464e-02f, -2.90567636e-01f,
  1.59094334e-01f, -4.70707864e-02f, -8.86935517e-02f, 1.28189042e-01f, 6.98776722e-01f, -6.99727312e-02f, 1.12955578e-01f, -7.00855162e-03f, 5.25087677e-03f, 1.68692455e-01f,
  1.10696673e-01f, 3.05104733e-01f, 9.11855102e-02f, 5.80806620e-02f, 1.14086501e-01f, -1.85035467e-01f, -2.57252008e-02f, -6.59772083e-02f, -1.84507314e-02f, 1.29403800e-01f,
  1.06812060e-01f, 7.79853538e-02f, -1.14209898e-01f, -4.04576100e-02f, 8.21676925e-02f, -6.74073547e-02f, -4.13393825e-02f, 4.18622866e-02f, 6.99420422e-02f, 6.35435060e-02f,
  -1.63113065e-02f, 1.79939926e-01f, 4.93947193e-02f, -2.42841318e-02f, -4.03428227e-02f, 6.88544512e-02f, -4.76449430e-02f, -6.79973140e-02f, -4.64806752e-03f, 2.86184368e-03f,
  1.72921398e-04f, 1.20790731e-02f, -6.42213896e-02f, -6.09379001e-02f, 1.23253232e-02f, -3.51598561e-02f, -1.08564563e-01f, -2.61114780e-02f, 4.68189120e-02f, 9.83240604e-02f,
  7.55973533e-02f, -1.04723424e-01f, -4.95720357e-02f, 8.88793822e-03f, 3.72306481e-02f, -1.93580911e-02f, -1.77593683e-04f, 1.04359519e-02f, -9.07330811e-02f, 6.16724417e-02f,
  2.39215884e-02f, -6.59511834e-02f, 6.42045364e-02f, -4.71556745e-02f, -6.77478835e-02f, -7.73405284e-02f, -2.99655795e-02f, 1.70870870e-02f, 2.45378092e-02f, -3.28620081e-03f,
  2.29765438e-02f, 4.14802246e-02f, -5.64688891e-02f, -4.05624025e-02f, 9.50251371e-02f, -7.62152951e-03f, -9.27809700e-02f, -7.61497393e-02f, 3.75659694e-03f, 1.05537772e-01f,
  2.02678174e-01f, 9.90743488e-02f, 9.89670493e-03f, 6.66557401e-02f, -3.43296230e-02f, 4.98208627e-02f, -3.13379243e-02f, -9.53938216e-02f, 5.88918701e-02f, 4.51672152e-02f,
  -5.87749369e-02f, -9.15737301e-02f, 3.42457816e-02f, 6.09169062e-03f, 7.30079412e-03f, -6.11889139e-02f, -6.16753520e-03f, -1.27382409e-02f, 9.72784087e-02f, 2.41292343e-02f,
  -7.36666471e-03f, 2.43020933e-02f, 3.46058235e-02f, 3.00489757e-02f, -1.75982825e-02f, 7.06065595e-02f, 8.62935260e-02f, -6.71576709e-02f, 5.60873523e-02f, -5.18228710e-02f,
  5.32490373e-01f, 1.94996431e-01f, 1.62703991e-01f, 1.89325616e-01f, 1.37728542e-01f, 1.71992555e-01f, -9.92088020e-02f, 1.07056811e-01f, 1.40038580e-01f, -2.73603827e-01f,
  -3.65553200e-01f, 2.05359295e-01f, -4.05768722e-01f, 1.13295138e-01f, 4.77289855e-01f, -1.54004246e-01f, 3.86128247e-01f, 9.04398113e-02f, 1.11181363e-01f, 2.71044582e-01f,
  1.26969755e-01f, 1.36563614e-01f, 7.76503906e-02f, 3.36959630e-01f, 2.44121440e-02f, 1.66287795e-01f, -3.48806791e-02f, -3.38293687e-02f, 7.72568733e-02f, 7.99481049e-02f,
  -8.77392963e-02f, -1.55637592e-01f, -3.19922045e-02f, 1.50499968e-02f, -1.24510400e-01f, -6.32819906e-02f, -1.63140614e-02f, 1.17110526e-02f, 6.05899049e-03f, -1.49888456e-01f,
  7.30693061e-03f, 1.05229892e-01f, 7.21363425e-02f, -1.94076169e-02f, 2.63434425e-02f, 8.58340859e-02f, -5.54854237e-03f, -8.42571557e-02f, 4.17028889e-02f, -1.51651837e-02f,
  8.88504740e-03f, -1.52699038e-01f, -1.86365601e-02f, -4.75774184e-02f, 5.23528941e-02f, 4.06376645e-03f, -2.72546560e-02f, -6.28890023e-02f, -2.24038512e-02f, 1.07876934e-01f,
  4.44558784e-02f, -3.95970419e-03f, 1.92670058e-02f, -8.36566687e-02f, 3.45363095e-02f, -9.42880660e-02f, 3.92155163e-02f, -1.09195888e-01f, 8.73683542e-02f, 4.01813015e-02f,
  -2.56059486e-02f, 1.95538756e-02f, 4.52290475e-03f, -8.67415294e-02f, -3.47478036e-03f, -1.36744836e-02f, 2.35480238e-02f, -2.52733119e-02f, 5.41280247e-02f, -7.49204382e-02f,
  1.65814888e-02f, 1.27054334e-01f, 1.65344253e-02f, -1.40314000e-02f, -1.90017875e-02f, -1.12171117e-02f, -3.75936404e-02f, 6.65490190e-03f, -1.28149673e-01f, 7.74530992e-02f,
  1.00862660e-01f, 2.58301973e-01f, -2.61534322e-02f, -8.05014670e-02f, 3.71957421e-02f, 7.14656040e-02f, 9.06073079e-02f, 1.39632314e-01f, 7.25454688e-02f, 4.56387959e-02f,
  4.23769392e-02f, -5.13324030e-02f, -4.97066975e-02f, 1.35613279e-02f, 8.09363201e-02f, -7.91416243e-02f, -2.79179197e-02f, 7.05590472e-02f, 1.32752702e-01f, 8.74189567e-03f,
  7.04875216e-02f, -2.61415727e-02f, 5.07896394e-02f, 8.48521739e-02f, 2.83784308e-02f, -6.58813938e-02f, 7.73221403e-02f, 5.73934205e-02f, -3.39415297e-02f, 9.24696773e-03f,
  3.80595893e-01f, 3.53663623e-01f, 1.25815675e-01f, 5.66382647e-01f, -2.23114863e-01f, -2.66209930e-01f, -4.08466756e-02f, 2.47210354e-01f, 5.34040272e-01f, 1.12353051e-02f,
  -1.15802631e-01f, 9.48518291e-02f, 7.03225136e-02f, -1.05415612e-01f, -5.66125438e-02f, -2.86785699e-03f, 6.31799549e-02f, -4.00715321e-02f, 2.00491235e-01f, 1.85726628e-01f,
  1.00017250e-01f, -5.84179051e-02f, -8.42303485e-02f, 2.29510125e-02f, 5.85844107e-02f, 1.06494524e-01f, 7.75729716e-02f, -4.03666571e-02f, -2.03440636e-01f, -1.90574735e-01f,
  -8.58179256e-02f, 3.05024385e-01f, -3.41520682e-02f, -7.80726746e-02f, 6.51474968e-02f, -9.63594615e-02f, -1.45435765e-01f, -1.91486776e-01f, -9.12386328e-02f, 9.31936968e-03f,
  -1.71777159e-02f, -9.51729566e-02f, 2.06408221e-02f, -5.59856975e-03f, 7.59382558e-04f, -2.20871400e-02f, -7.16627315e-02f, -8.09487775e-02f, -1.83375310e-02f, -2.13640817e-02f,
  8.19565728e-02f, -3.15741748e-02f, -3.09080556e-02f, -1.09283114e-02f, -8.37562755e-02f, -4.57107350e-02f, -5.04781231e-02f, -7.41953328e-02f, -7.30218366e-02f, 1.40810147e-01f,
  -2.06780471e-02f, -4.21518460e-03f, 1.00519441e-01f, 5.33693247e-02f, -1.50893442e-02f, -2.94483304e-02f, -3.82188708e-02f, -2.92344224e-02f, -9.66051221e-03f, 2.32208967e-02f,
  -1.00945868e-03f, -4.26799525e-03f, 5.39563671e-02f, -2.23094132e-02f, 5.77498488e-02f, 9.39463899e-02f, -1.06665820e-01f, 3.26092355e-02f, 4.60768901e-02f, 2.92225387e-02f,
  2.97250096e-02f, -1.12400567e-02f, 1.04659749e-02f, -5.67003712e-02f, -2.17767917e-02f, -3.08688264e-03f, 1.26440646e-02f, -2.23563612e-02f, -1.88877294e-03f, -3.75531726e-02f,
  1.50420353e-01f, 3.75263125e-01f, 4.42817761e-03f, -9.20725092e-02f, 3.78353484e-02f, -2.08770894e-02f, 3.41697014e-04f, 4.08223830e-03f, 6.54677451e-02f, 2.87691061e-03f,
  -7.59466514e-02f, 5.39039575e-05f, 2.49207169e-02f, -9.18373764e-02f, -2.43076240e-03f, 8.54206830e-02f, 3.43917459e-02f, -1.24389688e-02f, 5.21268360e-02f, 2.31658341e-03f,
  -8.22426528e-02f, -2.33659297e-02f, 2.95148864e-02f, -1.31890634e-02f, -9.79272053e-02f, 1.72054768e-02f, 2.54600104e-02f, 1.11640673e-02f, -5.21918619e-03f, -3.49068688e-03f,
  -1.26536116e-01f, -2.18692288e-01f, 4.12701219e-01f, -4.12082285e-01f, -8.17275196e-02f, -2.94017524e-01f, -1.55761227e-01f, -2.22643510e-01f, -2.43841335e-01f, -3.43869954e-01f,
  -2.49034777e-01f, 1.59305409e-01f, 3.06489021e-02f, -3.76521587e-01f, -1.29408538e-01f, -3.51405889e-02f, -3.80357206e-01f, -6.15488440e-02f, -4.55461293e-02f, -2.68578172e-01f,
  -6.45333603e-02f, -3.93451244e-01f, 1.53808460e-01f, -2.27255255e-01f, -2.38520429e-01f, 3.05889621e-02f, -5.18554151e-02f, 2.60373116e-01f, -1.35178670e-01f, 1.25931486e-01f,
  2.90934537e-02f, -5.26899770e-02f, -2.86787823e-02f, 1.07824750e-01f, -3.87113579e-02f, 1.36101648e-01f, 5.68706319e-02f, 2.15475902e-01f, 9.46064666e-02f, 5.02183177e-02f,
  1.73475713e-01f, 3.66028063e-02f, 2.51622722e-02f, 5.24037667e-02f, -1.39781728e-01f, 6.94522709e-02f, -4.83751670e-02f, -4.29498740e-02f, -1.13922991e-02f, -2.36770455e-02f,
  3.18396613e-02f, -5.95332496e-03f, -1.73864886e-01f, -4.23855707e-02f, 1.57180764e-02f, -4.58268523e-02f, 2.90694777e-02f, 7.32077286e-02f, -5.37820719e-02f, -3.33066918e-02f,
  2.53946427e-02f, 3.52872126e-02f, -1.59168318e-02f, 5.54297939e-02f, 2.79383436e-02f, 5.26738316e-02f, -8.85978341e-02f, 7.62149245e-02f, 3.78456414e-02f, -7.81783015e-02f,
  -7.66441375e-02f, 3.69866826e-02f, -5.14812060e-02f, -1.85576547e-02f, -9.04766023e-02f, 2.58287098e-02f, 1.09098218e-01f, -2.96448115e-02f, 3.07446532e-02f, -3.66817415e-02f,
  7.06568509e-02f, -5.27485870e-02f, -1.79394940e-03f, 6.98502511e-02f, 1.78446225e-03f, 3.71023901e-02f, -8.56512859e-02f, -7.73233594e-03f, -9.32230707e-03f, 5.59224468e-03f,
  -1.76517934e-01f, -2.51988590e-01f, 5.39376661e-02f, -2.24743946e-03f, 1.09518595e-01f, -4.16123196e-02f, 7.30007365e-02f, -6.13760985e-02f, 6.36204705e-02f, 4.09399867e-02f,
  4.01630485e-03f, -4.94582579e-02f, 2.93569523e-03f, -7.47569576e-02f, -2.23461464e-02f, -7.80366436e-02f, 3.77337635e-02f, 8.86807963e-02f, -1.05332352e-01f, -8.02786127e-02f,
  1.69041883e-02f, 4.52969372e-02f, 1.05395794e-01f, -3.60797010e-02f, -1.84135195e-02f, 2.56405454e-02f, -1.00959077e-01f, 3.54027413e-02f, 4.57646400e-02f, -6.29037991e-03f,
  3.42871636e-01f, 2.74931133e-01f, 1.52197167e-01f, 3.11871413e-02f, -1.61164045e-01f, -3.70716043e-02f, -2.93698087e-02f, 2.83208583e-02f, -3.45742673e-01f, 9.97817069e-02f,
  -1.27372202e-02f, 3.15767944e-01f, 4.16866280e-02f, 1.41601592e-01f, 5.83337918e-02f, -3.04752797e-01f, -1.00712292e-01f, -3.94569188e-02f, -2.06837043e-01f, 3.81675005e-01f,
  -5.21879978e-02f, 3.82627212e-02f, -1.85217950e-02f, 1.03238888e-01f, 1.01414196e-01f, 1.02705628e-01f, 6.22826666e-02f, 2.13788450e-02f, 3.01682264e-01f, -1.08856305e-01f,
  -6.26464188e-03f, -4.04910631e-02f, 7.20710382e-02f, -8.23117793e-02f, -6.73684552e-02f, 2.37200577e-02f, 6.45838007e-02f, 1.28482178e-01f, -6.08095853e-03f, 2.92145181e-02f,
  9.74594876e-02f, 1.48577511e-01f, 3.91330458e-02f, -1.03659108e-01f, 9.74348411e-02f, -2.29388773e-02f, -4.78663333e-02f, -1.06967323e-01f, 7.88873360e-02f, 1.29240349e-01f,
  8.93518254e-02f, -2.64632283e-03f, 2.83523817e-02f, -1.91560704e-02f, 5.51682189e-02f, -7.06249774e-02f, -1.05031967e-01f, 1.25037983e-01f, -2.42369343e-02f, -4.58931737e-02f,
  2.90180650e-02f, -6.35737255e-02f, 4.52446751e-02f, 5.71061485e-02f, 6.93726912e-02f, -1.33549556e-01f, 5.21459319e-02f, 2.32988633e-02f, -4.19186577e-02f, 1.87000670e-02f,
  -5.18530384e-02f, 5.65994233e-02f, -1.32674769e-01f, -4.65914980e-02f, 7.13727474e-02f, -5.49869537e-02f, -8.11855868e-03f, -2.67178402e-03f, -5.32203875e-02f, -1.77056473e-02f,
  -6.11980446e-02f, 1.41916322e-02f, -8.35971981e-02f, -4.78400104e-02f, -1.74151450e-01f, 4.94418964e-02f, 5.96120693e-02f, -2.74440832e-02f, -1.67335197e-02f, 7.70273199e-03f,
  -8.09707716e-02f, 1.48605615e-01f, -9.63620022e-02f, -2.39884853e-02f, -7.51623288e-02f, 1.41119838e-01f, -1.49914056e-01f, 1.32077843e-01f, 7.36536607e-02f, -4.35083136e-02f,
  8.27907845e-02f, -6.69899210e-02f, 1.92726739e-02f, -3.03053949e-02f, 1.25768512e-01f, 1.68493781e-02f, 7.81579688e-02f, -1.71085462e-01f, -1.49012819e-01f, 1.26666695e-01f,
  -4.00609076e-02f, -4.36433405e-03f, 6.17653951e-02f, -1.24473475e-01f, 4.69974317e-02f, -7.11098388e-02f, 8.00147802e-02f, 3.41551602e-02f, -2.86166500e-02f, -1.10724725e-01f,
  -3.55585605e-01f, -4.28555086e-02f, -1.20549733e-02f, -2.67167866e-01f, -1.29175618e-01f, 3.77425909e-01f, 2.34018460e-01f, -5.19335270e-02f, -2.29778260e-01f, 2.02469498e-01f,
  1.24828897e-01f, -1.90321326e-01f, 3.17848176e-01f, 2.54388750e-01f, 4.52668458e-01f, 3.01240951e-01f, 2.53152221e-01f, 5.02582639e-02f, -8.60267207e-02f, -1.83456004e-01f,
  -1.09618574e-01f, 2.03749642e-01f, 1.72302321e-01f, -1.04268104e-01f, -2.13603422e-01f, -2.36040190e-01f, 9.37746614e-02f, -1.08024068e-01f, -4.22246382e-03f, 1.51565090e-01f,
  9.92466435e-02f, -1.65184617e-01f, -1.25411481e-01f, 8.88412446e-02f, 3.99095640e-02f, 3.73901427e-02f, 1.72855251e-03f, 2.59705484e-02f, -2.78754663e-02f, -2.37665186e-03f,
  -2.94361282e-02f, -1.45537313e-02f, -6.41644672e-02f, 5.48645994e-03f, -1.08343139e-01f, -1.55871391e-01f, -9.81883518e-03f, 3.31531838e-02f, -1.26405954e-01f, -7.38305738e-03f,
  3.60381640e-02f, -3.35500040e-03f, -5.96462972e-02f, 8.07375088e-02f, -1.23303419e-03f, -2.90582366e-02f, 3.96254510e-02f, 7.92603046e-02f, 1.06965736e-01f, -1.20102905e-01f,
  -6.78991377e-02f, 1.32125849e-02f, 7.24719614e-02f, -3.17025594e-02f, 8.37994590e-02f, -7.50545934e-02f, 6.23554401e-02f, 4.30526510e-02f, -5.65204956e-03f, 5.98084517e-02f,
  -1.72353256e-02f, -6.78519160e-02f, -7.88076967e-02f, -3.18676122e-02f, -4.32554893e-02f, -3.47029269e-02f, 1.59218803e-03f, -3.41772549e-02f, -9.64126363e-02f, -1.71453599e-02f,
  -8.84730667e-02f, 8.12517032e-02f, -6.12624064e-02f, -3.41074658e-03f, 8.06539282e-02f, 4.78014052e-02f, -4.16996591e-02f, -5.92359640e-02f, 2.84170378e-02f, 2.87468228e-02f,
  2.59712487e-01f, 1.13893092e-01f, 9.41120554e-03f, -1.22943319e-01f, 9.80010349e-03f, 4.24426645e-02f, 3.36384512e-02f, -5.67735583e-02f, 7.87678212e-02f, -3.88854966e-02f,
  4.32257093e-02f, -5.92335612e-02f, -1.52780944e-02f, -1.80819109e-02f, 2.80405786e-02f, 1.42688870e-01f, 5.20170107e-02f, -3.50265950e-02f, 5.45658469e-02f, -1.41207855e-02f,
  -8.56334157e-03f, 5.98909259e-02f, 4.12408188e-02f, -5.58035634e-02f, -2.51007210e-02f, 1.95105709e-02f, -1.26269028e-01f, -4.06167358e-02f, 2.34505162e-02f, 7.40095079e-02f,
  -2.36675799e-01f, 2.35232264e-01f, 6.94735497e-02f, -4.07269299e-01f, -3.32495421e-01f, 2.84823745e-01f, -1.25474511e-02f, -2.03451991e-01f, 2.32911333e-01f, 1.29075825e-01f,
  -3.10106874e-01f, 1.14927009e-01f, 1.57151535e-01f, -4.71735410e-02f, 8.03232566e-02f, 3.16943705e-01f, 7.61895403e-02f, 1.19259551e-01f, 1.16778277e-01f, -4.32239138e-02f,
  -1.22380279e-01f, -2.09989130e-01f, -1.47779346e-01f, 9.85376164e-02f, -2.90364474e-01f, -1.83721349e-01f, -2.26879120e-01f, 6.54462501e-02f, -2.82598883e-01f, -7.55617842e-02f,
  3.85587923e-02f, -6.60353675e-02f, -8.88287351e-02f, 1.73523113e-01f, -1.35334760e-01f, -9.51599404e-02f, 2.98519693e-02f, -6.36301003e-04f, -1.93337426e-02f, 5.17520681e-03f,
  2.53415313e-02f, -8.35847408e-02f, -1.63636217e-03f, 5.68999834e-02f, 3.96630466e-02f, 5.18229268e-02f, -6.73961639e-02f, -6.92339242e-03f, 4.71994989e-02f, -1.46031797e-01f,
  9.26495437e-03f, -9.24043059e-02f, -5.32467216e-02f, 4.42077294e-02f, -4.44766581e-02f, -1.04279239e-02f, 1.08705144e-02f, -1.93584129e-01f, 9.94013697e-02f, 1.51431898e-03f,
  3.52574280e-03f, -1.21838234e-01f, -1.95515472e-02f, 7.39199072e-02f, 3.78792826e-03f, -5.38203903e-02f, 7.31753036e-02f, 2.32042223e-02f, -2.56258845e-02f, 8.58428925e-02f,
  -6.47652969e-02f, -9.60424095e-02f, 7.03164712e-02f, -3.18302214e-02f, -5.61033711e-02f, 2.15448644e-02f, -4.79739681e-02f, 4.65570800e-02f, -3.88658866e-02f, -1.10070936e-01f,
  7.29293600e-02f, 7.16529461e-03f, 4.47842628e-02f, 8.20768774e-02f, 1.04726158e-01f, -7.30872825e-02f, 4.54002917e-02f, 4.92174588e-02f, -6.46738037e-02f, -7.15646893e-02f,
  1.93528101e-01f, 6.60528615e-02f, 2.05132905e-02f, 2.36583315e-02f, 1.30006179e-01f, -3.07854172e-02f, 4.93853949e-02f, 2.24317741e-02f, 8.23781192e-02f, 4.85047661e-02f,
  3.51387938e-03f, 3.40207107e-02f, 9.20030847e-02f, -7.00006858e-02f, 3.90911922e-02f, -1.51130691e-01f, 3.54629457e-02f, 9.39520448e-03f, -9.72174257e-02f, -8.06155130e-02f,
  -8.81519169e-02f, 1.58024114e-02f, 7.11469650e-02f, 3.36664350e-04f, -7.50687812e-03f, 2.34158561e-02f, 3.94207016e-02f, 2.18159668e-02f, -2.54133195e-02f, 5.04397564e-02f,
  6.29168272e-01f, 2.82550484e-01f, -3.09812009e-01f, 2.18229834e-02f, 1.76263079e-01f, 2.86298513e-01f, 3.96270566e-02f, 1.95103630e-01f, 2.37483114e-01f, 2.08347574e-01f,
  2.84738969e-02f, 1.50610164e-01f, -2.74851561e-01f, -6.40828386e-02f, -4.84462112e-01f, -2.87565500e-01f, -6.77235425e-02f, 4.40665111e-02f, 1.29902065e-01f, 8.48553255e-02f,
  -1.47332074e-02f, -1.82191446e-01f, -3.67045313e-01f, 5.90765662e-02f, 1.25789151e-01f, 1.59843326e-01f, -2.71535635e-01f, -1.49355546e-01f, 1.24755539e-02f, 1.26133626e-02f,
  2.21651625e-02f, 2.40100875e-01f, 3.58927138e-02f, -6.24455847e-02f, 9.21288580e-02f, 5.29500330e-03f, -3.34665366e-02f, -9.10499021e-02f, -7.32862651e-02f, -3.32777645e-03f,
  -1.03434175e-02f, -7.28866234e-02f, 2.05515139e-02f, -6.56186715e-02f, 1.96254328e-01f, 9.01074409e-02f, 6.97691813e-02f, 1.54596373e-01f, 1.31103136e-02f, 5.14271446e-02f,
  4.47591469e-02f, 4.04165946e-02f, 4.34859656e-02f, -6.65706769e-02f, -4.29069921e-02f, 1.13989174e-01f, -1.24439701e-01f, 6.48632972e-03f, 3.03448420e-02f, 9.21765342e-02f,
  1.16865054e-01f, -6.06488846e-02f, -3.21342163e-02f, 6.49629310e-02f, 3.47996466e-02f, 5.98258292e-03f, -1.02840208e-01f, -3.28042102e-03f, 1.13204783e-02f, 4.82033119e-02f,
  9.59880278e-03f, 5.29123917e-02f, 8.86084810e-02f, 6.15700074e-02f, -1.27057666e-02f, 9.77204069e-02f, -8.39642510e-02f, 3.31427678e-02f, 1.24232113e-01f, -1.88462459e-03f,
  -5.06117642e-02f, -2.78167296e-02f, -1.77280232e-02f, -4.19258960e-02f, -1.68354679e-02f, -9.31882262e-02f, -2.85680480e-02f, -3.22908424e-02f, -4.87358775e-04f, -1.39567614e-01f,
  -9.44189448e-03f, -2.15549231e-01f, -6.82520568e-02f, 7.66302347e-02f, -7.28828013e-02f, 4.76982333e-02f, -9.09178425e-03f, 6.43911883e-02f, -4.21353355e-02f, 3.09301782e-02f,
  -1.32294213e-02f, -6.61355704e-02f, 4.21565473e-02f, 4.99712974e-02f, -6.75056726e-02f, -5.39513528e-02f, -1.06809191e-01f, -1.21736549e-01f, -1.25180230e-01f, -7.76118645e-03f,
  -7.47827962e-02f, -2.94955261e-02f, -8.46325606e-02f, 9.07528847e-02f, 5.08543253e-02f, 3.02793030e-02f, 1.34301499e-01f, 4.84706834e-02f, -6.37061447e-02f, -5.41325174e-02f,
  -9.41073895e-02f, -1.41629577e-01f, -3.45059365e-01f, -2.43825778e-01f, 3.88503790e-01f, 2.61581630e-01f, -1.48445427e-01f, -3.11674103e-02f, -4.31448966e-01f, -3.56572233e-02f,
  9.89673883e-02f, 1.22268870e-01f, 4.12878506e-02f, -2.12148935e-01f, 2.85091013e-01f, -2.08539665e-01f, -9.98315141e-02f, 1.20657884e-01f, -1.39783442e-01f, 2.33010814e-01f,
  -8.52063149e-02f, 3.23359191e-01f, -7.33314902e-02f, 2.13414609e-01f, 2.38495439e-01f, 3.74306329e-02f, 3.16531241e-01f, 1.08516008e-01f, 2.95383424e-01f, 1.26194000e-01f,
  -3.89574133e-02f, -1.63739160e-01f, -1.01679921e-01f, -5.75987957e-02f, 1.60004377e-01f, -4.29169014e-02f, 4.51676501e-03f, 6.70181066e-02f, -1.86400674e-02f, -1.04325768e-02f,
  -3.78374755e-02f, 9.74523351e-02f, 1.23357344e-02f, 3.74010205e-02f, -1.37224272e-01f, -8.36693123e-02f, 6.17778860e-02f, -9.14685130e-02f, -9.39370319e-02f, -9.77232903e-02f,
  -9.85565856e-02f, -7.51038864e-02f, -8.20074454e-02f, -3.03655826e-02f, 1.02955149e-02f, -3.94459255e-02f, -7.54132941e-02f, 1.92928940e-01f, -8.51546880e-03f, -6.21194020e-02f,
  -4.96614166e-02f, -2.35989261e-02f, 1.16076857e-01f, -8.39529708e-02f, 7.24024922e-02f, -9.22529921e-02f, -6.13695234e-02f, 7.39096627e-02f, 9.56902578e-02f, 4.44149645e-03f,
  5.94348535e-02f, 2.57569849e-02f, -1.12864323e-01f, -6.40981197e-02f, 1.17837831e-01f, -1.13798361e-02f, 9.80897248e-02f, 1.28874421e-01f, -3.45625654e-02f, -6.55411258e-02f,
  -1.20880678e-01f, -6.94269687e-02f, 7.03092441e-02f, 1.45482663e-02f, -1.04083128e-01f, 8.51984769e-02f, -1.46367801e-02f, -6.57252520e-02f, 9.42696929e-02f, 1.58510908e-01f,
  3.96583706e-01f, 2.63770729e-01f, 2.65579876e-02f, 1.86109785e-02f, -8.32257569e-02f, 6.51113316e-02f, -4.78854440e-02f, -2.09039357e-02f, 1.74028084e-01f, 3.27896141e-02f,
  7.97347501e-02f, -9.81445774e-04f, 3.93411852e-02f, -4.32304181e-02f, 4.17948104e-02f, -9.50322393e-03f, 3.61077860e-02f, 1.26903579e-01f, 1.20776355e-01f, 8.56770277e-02f,
  1.41973019e-01f, 1.82815328e-01f, -1.25159463e-02f, 4.73451316e-02f, -2.47037876e-02f, -2.02580858e-02f, 1.16343439e-01f, -7.15436786e-02f, 3.99790555e-02f, 4.15496863e-02f,
  5.31771127e-03f, -3.76069754e-01f, -7.63966367e-02f, -4.15275127e-01f, -1.41519740e-01f, 2.97754884e-01f, 4.02258933e-01f, -1.43156022e-01f, -3.45064968e-01f, 3.11022699e-01f,
  5.74491471e-02f, 3.95805798e-02f, 3.01613122e-01f, -9.97013301e-02f, 2.73674488e-01f, 1.34629011e-01f, 1.41981721e-01f, 1.38559565e-01f, -4.60198790e-01f, 5.18563725e-02f,
  -2.80515522e-01f, 1.46931097e-01f, -4.10764329e-02f, -1.38664618e-01f, 9.12093669e-02f, -2.10465580e-01f, 3.48381191e-01f, -6.96281716e-02f, 1.42852411e-01f, 3.22736651e-02f,
  -1.11788265e-01f, -2.72554904e-01f, -8.76409486e-02f, 7.92746618e-02f, 1.36726916e-01f, 1.44068494e-01f, 1.04759574e-01f, 1.03780314e-01f, -1.15198374e-01f, -4.36515361e-02f,
  1.49968252e-01f, -4.77252454e-02f, -2.46477723e-02f, 6.19443953e-02f, -1.27490954e-02f, -1.20693892e-01f, -1.96108758e-01f, 3.91776022e-03f, -1.00497894e-01f, -4.22233576e-03f,
  -8.82419720e-02f, -8.23115781e-02f, 3.63033228e-02f, 6.84747919e-02f, -1.75980367e-02f, -6.51025549e-02f, 1.36174247e-01f, 1.40432537e-01f, 1.06522935e-02f, -4.83870655e-02f,
  5.63281476e-02f, 7.61194453e-02f, -7.63184996e-03f, -8.53285193e-04f, -3.56717259e-02f, -3.61815579e-02f, 8.22883919e-02f, 1.68250352e-02f, -7.33337849e-02f, 9.47610140e-02f,
  3.04855704e-02f, -6.20591044e-02f, -6.58840835e-02f, -6.19813800e-02f, -2.06667818e-02f, 7.94062465e-02f, 6.19990714e-02f, 4.43062745e-02f, -4.95469831e-02f, 7.70864859e-02f,
  -1.21717297e-01f, -5.79116903e-02f, -5.02735600e-02f, 2.12785155e-02f, 5.60566001e-02f, -1.30830789e-02f, -3.61435153e-02f, -6.85249269e-02f, -1.02691881e-01f, 1.14244699e-01f,
  1.04609832e-01f, 2.36931607e-01f, 7.82259330e-02f, -2.08868627e-02f, -3.69220264e-02f, -6.00212775e-02f, -8.93548802e-02f, 4.76818793e-02f, 2.19600257e-02f, 3.74781620e-03f,
  3.87873016e-02f, 1.18307628e-01f, 1.78989843e-01f, 3.55684645e-02f, -3.68848331e-02f, 2.11451128e-02f, 9.51368660e-02f, 8.12926982e-03f, 1.04282603e-01f, 7.40207499e-03f,
  8.64908546e-02f, 5.77124655e-02f, 2.61997879e-02f, 9.05469209e-02f, 1.01885773e-01f, 2.23240890e-02f, -2.73077656e-02f, -6.43828511e-02f, 9.63869097e-04f, 3.37305628e-02f,
  5.86951196e-01f, -2.38660455e-01f, -1.17324851e-01f, 3.57032567e-01f, 5.01629449e-02f, 4.74862218e-01f, 3.87223989e-01f, -4.10970263e-02f, 1.52712420e-01f, -4.76678908e-02f,
  1.46217510e-01f, -1.67482406e-01f, -2.39283800e-01f, 2.16927528e-01f, 2.49866024e-01f, -9.15715024e-02f, 3.04802597e-01f, 2.12072998e-01f, -5.42479455e-02f, -2.50264052e-02f,
  7.56770149e-02f, 1.82151899e-01f, -1.06115051e-01f, -1.85451910e-01f, 1.79444984e-01f, -9.75954086e-02f, -2.57996976e-01f, -2.61906773e-01f, 9.32548940e-02f, 4.05182093e-02f,
  9.75279957e-02f, -4.63070013e-02f, -1.94925163e-02f, -1.12686632e-02f, 1.35860145e-01f, -7.89118465e-04f, 3.16478163e-02f, -1.46849696e-02f, 2.59561144e-04f, -1.99877061e-02f,
  -7.58430734e-03f, -5.55574335e-02f, 5.16624786e-02f, -4.67327014e-02f, 9.98357460e-02f, -8.10788274e-02f, -1.25994654e-02f, 1.19881786e-01f, -7.19125122e-02f, 4.64762785e-02f,
  -2.61120107e-02f, 5.30545972e-02f, 1.00756228e-01f, -4.60737683e-02f, 1.50012888e-03f, 4.78729941e-02f, -5.44202216e-02f, 4.07554395e-02f, -1.05652092e-02f, 9.88359004e-02f,
  -3.31213837e-03f, -4.17365544e-02f, -1.67423952e-02f, -6.94155172e-02f, 7.32104527e-03f, -3.26494016e-02f, -1.91372782e-02f, -4.54123169e-02f, -3.80772189e-03f, -8.05720314e-03f,
  3.24944556e-02f, 4.44468558e-02f, 4.59194966e-02f, 1.21544413e-02f, 6.24249279e-02f, 4.43886630e-02f, -1.84783377e-02f, -1.48781268e-02f, 8.17672089e-02f, -1.69607997e-02f,
  -7.26507679e-02f, -1.35728428e-02f, -5.22009805e-02f, 4.21323534e-03f, 6.26743585e-03f, 1.48925055e-02f, 4.20502536e-02f, 3.21618989e-02f, 1.83965731e-02f, 8.46348554e-02f,
  1.01973526e-02f, -2.17899039e-01f, -3.23134884e-02f, -5.66368923e-03f, -9.84806344e-02f, -7.03455787e-03f, 1.18453167e-02f, 4.28771228e-02f, -1.32447913e-01f, 3.38221751e-02f,
  7.07022101e-02f, 3.88663560e-02f, -1.00160008e-02f, 3.30075845e-02f, 9.36599076e-03f, -1.49538217e-03f, 5.57313953e-03f, -1.24175306e-02f, 8.43701232e-03f, -8.42891857e-02f,
  3.87729215e-03f, 3.59702036e-02f, -3.18940766e-02f, 5.06944172e-02f, 7.48108849e-02f, -1.60612050e-03f, 1.72237884e-02f, 7.52217472e-02f, 8.44170805e-03f, -2.32733022e-02f,
  -1.75583556e-01f, -3.90948355e-01f, 1.15695365e-01f, -1.05855279e-01f, 1.88760728e-01f, -1.94115713e-01f, 1.18225209e-01f, -9.12380591e-02f, 2.31089607e-01f, -2.95280039e-01f,
  1.19851150e-01f, -3.69248271e-01f, 2.13147283e-01f, -3.69975895e-01f, -4.41479869e-02f, 1.10942898e-02f, -2.97852039e-01f, -2.08923876e-01f, 1.42808944e-01f, -1.18162572e-01f,
  -2.37020310e-02f, -2.91146457e-01f, -6.18770495e-02f, -3.13985497e-02f, -1.65968284e-01f, 9.69599411e-02f, -9.86713693e-02f, 2.00746328e-01f, -3.79563689e-01f, -5.59702923e-04f,
  -1.18898891e-01f, 6.27905652e-02f, 4.07468863e-02f, -7.42754638e-02f, -4.25631851e-02f, 1.01307601e-01f, -7.88845271e-02f, 1.94092691e-01f, 8.99243131e-02f, 2.03012358e-02f,
  -4.73748296e-02f, 7.22111836e-02f, -6.25416785e-02f, 1.00955188e-01f, 1.12044565e-01f, 1.80256926e-02f, 1.46754030e-02f, 1.10663315e-02f, 3.01489164e-03f, 3.57931145e-02f,
  5.45987003e-02f, -1.73608623e-02f, 1.97628941e-02f, -1.68534182e-02f, 5.55628948e-02f, 1.60502773e-02f, 5.53444736e-02f, 2.59056631e-02f, -7.40583986e-02f, 4.87432927e-02f,
  4.39964123e-02f, 7.89208785e-02f, -2.40785312e-02f, 2.34770067e-02f, 8.83998442e-03f, 2.34874934e-02f, 9.02610086e-03f, 5.18607255e-03f, 8.76683835e-03f, -5.08770160e-02f,
  -1.39000891e-02f, -2.43095104e-02f, 3.03484686e-02f, 5.47917187e-02f, -6.10914826e-02f, -5.30471234e-03f, -2.02821046e-02f, 5.51953055e-02f, -2.79262438e-02f, 3.60018760e-02f,
  3.32276686e-03f, 4.38912585e-03f, -1.03299031e-02f, 5.21709807e-02f, 4.22656685e-02f, -5.03651984e-02f, -4.23660427e-02f, 2.89425515e-02f, 1.03097349e-01f, -2.13594660e-02f,
  -3.91173959e-01f, -2.51384199e-01f, 2.36677155e-02f, -2.30655801e-02f, -4.33036536e-02f, -2.75075957e-02f, 2.65900232e-02f, -7.06993490e-02f, -9.28746313e-02f, 4.44863699e-02f,
  -2.62643453e-02f, -2.76808236e-02f, -3.83801125e-02f, 6.11545183e-02f, -6.81440085e-02f, 7.11508887e-03f, -4.90809754e-02f, -9.88612026e-02f, -8.67311135e-02f, -3.28790359e-02f,
  -1.84662957e-02f, 1.88444257e-02f, 8.64521042e-02f, -2.91774445e-03f, -1.49437608e-02f, -6.22691587e-02f, -7.46683180e-02f, 8.28237310e-02f, 5.32476082e-02f, -7.16754198e-02f,
  -4.86647218e-01f, -4.87759002e-02f, 2.01089352e-01f, -2.97506809e-01f, -3.02832961e-01f, 2.94726282e-01f, 1.74422219e-01f, -3.61081302e-01f, -3.54972556e-02f, 3.22204046e-02f,
  -2.14320675e-01f, 7.05340803e-02f, 2.40852430e-01f, -2.27729186e-01f, 1.27574667e-01f, 3.75633508e-01f, -2.02337682e-01f, -4.77212369e-02f, 2.64975755e-03f, -3.63691270e-01f,
  -5.45674004e-02f, -3.33067983e-01f, -2.52980888e-02f, -1.88887984e-01f, -1.85089231e-01f, 1.91918053e-02f, -2.38587230e-01f, 1.31688699e-01f, -1.94138527e-01f, 1.55637385e-02f,
  -6.34707436e-02f, -2.13853404e-01f, 7.67043382e-02f, 9.74580124e-02f, -4.16757725e-02f, 5.01282290e-02f, 9.17878747e-02f, 1.46688521e-01f, 9.52328891e-02f, 1.92668326e-02f,
  7.69518837e-02f, -3.66652645e-02f, -1.25076517e-01f, 1.04649000e-01f, 2.11653989e-02f, 8.64656568e-02f, 6.78685755e-02f, -1.38901798e-02f, -2.09701955e-02f, 1.07210249e-01f,
  3.26782186e-03f, 2.80905385e-02f, 2.72951908e-02f, 4.33713868e-02f, -1.44618284e-02f, 1.92692392e-02f, 4.49480489e-02f, 8.58234689e-02f, -3.70250363e-03f, -1.52494172e-02f,
  2.03913059e-02f, -7.97199202e-04f, 3.30670290e-02f, -2.06467416e-02f, -7.59994518e-03f, -1.11095093e-01f, 5.35778217e-02f, -4.10362035e-02f, 7.12187588e-02f, -4.01555859e-02f,
  -2.06795689e-02f, -6.76981211e-02f, -9.59005728e-02f, 4.14419621e-02f, -4.11003754e-02f, -5.12761287e-02f, 3.71756591e-02f, 9.07876436e-03f, -2.14105975e-02f, -2.81631611e-02f,
  1.84180215e-02f, -3.52368318e-02f, 3.40935728e-03f, 4.22818307e-03f, -6.26126602e-02f, -2.71799341e-02f, 4.46493849e-02f, 3.73778418e-02f, 8.56487732e-03f, -1.49551118e-02f,
  -5.67679815e-02f, -2.53796458e-01f, 1.91699471e-02f, -7.61293173e-02f, -3.48684378e-02f, -2.94542518e-02f, 5.27025200e-02f, 9.08843335e-03f, 2.83109397e-02f, -5.39444573e-02f,
  -1.06402170e-02f, -4.43571918e-02f, -9.42100883e-02f, -9.92630608e-03f, 3.37612927e-02f, -1.91634316e-02f, -8.08947682e-02f, 4.47524665e-03f, -2.41168123e-02f, -7.73841739e-02f,
  -9.54495370e-02f, 1.58529617e-02f, 7.23668486e-02f, -2.05265135e-01f, -1.21259019e-02f, -8.84504430e-03f, -5.82158193e-02f, 6.66344017e-02f, -3.08979061e-02f, 6.83458373e-02f,
  1.20464914e-01f, -2.70880312e-01f, -1.97225705e-01f, 2.10782349e-01f, -1.00872196e-01f, -1.03423029e-01f, 5.31041473e-02f, -1.50159925e-01f, -3.46087217e-01f, 1.26991048e-01f,
  -8.15275908e-02f, 2.49432772e-01f, -2.06020549e-01f, 2.79600978e-01f, 2.76160538e-01f, -3.28629762e-01f, 7.35638589e-02f, 1.48933142e-01f, -2.76684076e-01f, -7.09132850e-02f,
  -4.37296256e-02f, 3.43125910e-01f, -3.23087648e-02f, -6.33738339e-02f, 1.85765803e-01f, -7.97158852e-02f, 4.73332345e-01f, -1.05441444e-01f, 3.83613408e-01f, 6.96271062e-02f,
  -1.26294777e-01f, -6.00224622e-02f, -6.60937652e-02f, 1.70244850e-04f, -4.48545143e-02f, 7.43203014e-02f, 7.69955441e-02f, 6.81769773e-02f, -1.06157273e-01f, -9.86194313e-02f,
  5.94518818e-02f, 1.17338680e-01f, 7.40026981e-02f, 2.62303110e-02f, 6.91648424e-02f, 1.74990911e-02f, -3.37490030e-02f, -4.78722900e-02f, -1.28737800e-02f, -3.60622965e-02f,
  -1.17847376e-01f, -4.22367118e-02f, 7.70994201e-02f, 9.43715125e-02f, -1.52199091e-02f, -2.73707733e-02f, -1.79326013e-02f, 1.99919026e-02f, -6.95261871e-03f, -7.78573155e-02f,
  9.41360146e-02f, -7.86581729e-03f, -7.49704428e-03f, 1.99193647e-03f, -4.22551483e-02f, -1.08904904e-02f, 1.07020378e-01f, 2.19851136e-02f, 7.08263135e-03f, 1.91367362e-02f,
  1.56362392e-02f, 8.57059062e-02f, -2.42364034e-02f, 1.88180190e-02f, 8.99409279e-02f, 1.71065815e-02f, 6.14963435e-02f, 2.88251322e-02f, -4.59832586e-02f, 2.45968532e-02f,
  -2.00384092e-02f, 2.91413385e-02f, -5.62030524e-02f, 1.67851988e-02f, -1.05433673e-01f, -1.96130257e-02f, 5.39499372e-02f, -4.07700837e-02f, -1.80415083e-02f, 9.64363739e-02f,
  1.00629404e-01f, 2.47258037e-01f, -6.68851584e-02f, 5.86261675e-02f, 2.86354106e-02f, 5.20284250e-02f, 1.35606644e-03f, -3.80356722e-02f, 4.37441655e-02f, 2.53044069e-02f,
  8.92163590e-02f, -5.49405906e-03f, 1.27093077e-01f, 3.42191011e-02f, -5.48455399e-04f, -3.13026085e-02f, 6.05139248e-02f, 6.10713921e-02f, 1.41101927e-01f, 9.78718922e-02f,
  1.29854605e-01f, 4.37497646e-02f, 4.28931378e-02f, -4.84639965e-03f, 7.40580559e-02f, 9.24863145e-02f, 3.65013108e-02f, -7.34688342e-02f, 5.00745326e-02f, 3.10839657e-02f,
  -1.17149994e-01f, -2.19067484e-02f, 1.49357721e-01f, 1.88235462e-01f, 4.40688878e-01f, -5.39060235e-02f, -4.20772374e-01f, 3.44698548e-01f, 1.10941060e-01f, -1.68072045e-01f,
  7.23057091e-02f, -7.91596472e-02f, -2.56102920e-01f, 2.83178270e-01f, -1.84209287e-01f, -3.60425174e-01f, 1.20072663e-01f, -2.30973542e-01f, -2.00774111e-02f, 1.29760236e-01f,
  5.69235645e-02f, 2.07423791e-02f, 6.76101819e-02f, 2.77615875e-01f, 1.78099379e-01f, 8.80865455e-02f, -3.85449156e-02f, -1.49285063e-01f, 2.15528443e-01f, -9.43881720e-02f,
  8.56172442e-02f, 1.05806157e-01f, 9.78076011e-02f, -1.44232744e-02f, 5.54677993e-02f, -3.78181785e-02f, -1.18846044e-01f, -2.06364408e-01f, 9.00872145e-03f, -3.19060013e-02f,
  -1.45804852e-01f, 7.37574548e-02f, -2.73588654e-02f, -4.52151150e-02f, 7.77367875e-02f, 1.09564140e-01f, 1.09304175e-01f, 4.25833799e-02f, 1.23859659e-01f, 9.86630283e-03f,
  5.19560389e-02f, 1.16496988e-01f, 1.57485574e-01f, -4.21307385e-02f, 1.16407908e-01f, 6.73456863e-02f, -2.66812984e-02f, -1.01701485e-03f, 3.68799455e-02f, 1.51500970e-01f,
  -2.47948617e-02f, -7.18946382e-03f, 4.16361503e-02f, 3.22811939e-02f, -4.08512577e-02f, 4.93596904e-02f, -3.34319100e-02f, -4.10177857e-02f, 1.61736959e-03f, -7.70295709e-02f,
  1.40944555e-01f, 6.59894571e-02f, 3.42147201e-02f, 5.67803271e-02f, -2.38349773e-02f, -7.16709942e-02f, -7.00971335e-02f, -1.15078494e-01f, 5.58213070e-02f, -2.90167704e-02f,
  3.87311839e-02f, 7.93222785e-02f, -7.18099847e-02f, -1.74402408e-02f, -7.67131476e-03f, 5.07084206e-02f, 1.32221028e-01f, 6.88396692e-02f, 3.06779128e-02f, -9.35445577e-02f,
  -7.78862685e-02f, -1.72402173e-01f, 4.72144745e-02f, -7.62897730e-02f, -1.61923721e-01f, 1.19874008e-01f, 3.68639384e-03f, 1.06550381e-01f, 2.99373316e-03f, 1.90785602e-02f,
  9.88036841e-02f, -9.75424275e-02f, 9.61362645e-02f, 4.27887551e-02f, 3.06682084e-02f, 2.98629757e-02f, -1.37029707e-01f, 3.69971320e-02f, 3.51899602e-02f, 3.82877924e-02f,
  -2.70685013e-02f, -5.96121289e-02f, 5.17590195e-02f, 7.19315633e-02f, 5.24756201e-02f, -1.61413364e-02f, -2.46592890e-02f, -1.02997452e-01f, -4.60346490e-02f, 9.27995816e-02f,
  -6.39865696e-01f, 5.82091391e-01f, 5.07455952e-02f, 2.09595039e-01f, -3.53713870e-01f, -9.58008766e-02f, 5.34747466e-02f, -9.96657088e-03f, -3.89864929e-02f, 4.34812784e-01f,
  6.07594587e-02f, 3.15465070e-02f, 3.17420542e-01f, 2.71453202e-01f, -3.52726936e-01f, 3.70494336e-01f, 1.08863540e-01f, 1.23668507e-01f, 2.73228884e-02f, 7.44173452e-02f,
  -6.37013838e-02f, 5.60532622e-02f, 1.31911710e-01f, 3.68884169e-02f, -5.99637255e-02f, -5.84979840e-02f, 1.22171007e-02f, -1.65825617e-02f, 1.01946935e-01f, -7.60396793e-02f,
  -3.29243317e-02f, 6.17291071e-02f, -5.92361502e-02f, 1.98873077e-02f, -4.65384275e-02f, -5.90298250e-02f, -4.12291773e-02f, -3.52659114e-02f, -1.25466183e-01f, 3.96256559e-02f,
  2.64296234e-02f, -6.64089024e-02f, 2.01685186e-02f, -1.73664857e-02f, -5.67459613e-02f, -1.26179438e-02f, -5.01700304e-02f, -5.40521480e-02f, 9.90370661e-02f, -6.61602989e-02f,
  -2.78239623e-02f, -2.26695761e-02f, -2.42355056e-02f, 9.53715816e-02f, -5.61851300e-02f, -3.23220156e-02f, 3.57858874e-02f, -4.05346043e-02f, 1.85124874e-02f, -2.81322431e-02f,
  -1.94669347e-02f, 6.60517141e-02f, 5.80696911e-02f, 4.41224352e-02f, 4.65829819e-02f, -2.90851090e-02f, 3.94552052e-02f, 2.43370179e-02f, -1.88334808e-02f, 1.00874184e-02f,
  -1.67277940e-02f, -8.43604468e-03f, -1.58461593e-02f, -2.66049076e-02f, -5.58923604e-03f, 1.97413079e-02f, -1.54131157e-02f, 1.60486083e-02f, -2.52521560e-02f, -4.52887788e-02f,
  1.56250987e-02f, -1.03403386e-02f, 6.27870560e-02f, -3.66817527e-02f, 6.96376935e-02f, -4.72667404e-02f, 3.21233720e-02f, -4.09439914e-02f, 2.50200704e-02f, -1.92052163e-02f,
  1.74711660e-01f, 2.67425030e-01f, 6.81295842e-02f, 1.90121923e-02f, 1.41957328e-01f, 3.56692285e-03f, 3.27742510e-02f, -1.65899806e-02f, 9.38518494e-02f, -1.46666635e-02f,
  -7.64795616e-02f, 7.99247846e-02f, 1.38312420e-02f, -3.50789838e-02f, -8.47999938e-03f, 1.10132508e-02f, 7.69326240e-02f, -4.70780535e-03f, -7.48015717e-02f, 1.81341954e-02f,
  1.88334044e-02f, 1.83546692e-02f, -3.56391538e-03f, -4.02669888e-03f, -7.95375463e-03f, -6.54027238e-03f, -6.19140342e-02f, -9.85684991e-03f, -1.61962435e-02f, 4.16573621e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.03089494e-02f, -8.72909784e-01f, 1.01971561e-02f, 4.80371445e-01f, 3.79541844e-01f, 2.42029980e-01f, -3.15697610e-01f, 6.43791482e-02f, -1.25838161e-01f, -6.70137167e-01f,
  -3.69006336e-01f, -4.86412764e-01f, -5.91938317e-01f, 2.12522209e-01f, 3.36748272e-01f, -1.43952355e-01f, 4.28397864e-01f, -6.83098333e-03f, 3.80768478e-01f, 3.83599028e-02f,
  4.91961092e-01f, 3.71324092e-01f, 2.14174524e-01f, 3.53813469e-01f, 1.23191386e-01f, 1.79022804e-01f, -1.41469508e-01f, -1.31789818e-01f, 2.58199662e-01f, 5.69520034e-02f,
  -1.95620522e-01f, -4.89741862e-02f, -1.10656589e-01f, -1.56357378e-01f, -9.20406431e-02f, -2.22431526e-01f, -6.83487654e-02f, 1.59564376e-01f, 1.30016133e-01f, -6.86779385e-03f,
  -1.20179556e-01f, 1.48724869e-01f, 2.29159117e-01f, -2.65857093e-02f, 9.73061398e-02f, 9.36502963e-02f, 1.37478128e-01f, 3.99382599e-02f, 1.11000156e-02f, -1.77933148e-03f,
  -4.25564311e-02f, 6.02821857e-02f, 1.43814355e-01f, 6.33647889e-02f, 1.00256748e-01f, 6.36879634e-03f, 1.07909657e-01f, -1.08025067e-01f, 3.49546783e-04f, 6.80207461e-02f,
  5.07323779e-02f, -5.00258654e-02f, -9.67788249e-02f, -4.09759171e-02f, -7.72460327e-02f, 2.73339194e-03f, 6.27925098e-02f, -4.04368602e-02f, 1.05953673e-02f, -1.30091920e-01f,
  2.02692617e-02f, -1.42584238e-02f, 1.60603374e-01f, -2.06717309e-02f, 2.55445298e-02f, 1.36380896e-01f, 1.13471605e-01f, 8.37985519e-03f, 4.15380374e-02f, 1.15095772e-01f,
  3.61422934e-02f, -6.83965394e-04f, -8.45432952e-02f, 1.61795661e-01f, -1.14675574e-01f, -1.53214157e-01f, -8.38112459e-02f, 1.37160497e-03f, -5.82818948e-02f, 4.74361219e-02f,
  -7.18029320e-01f, -7.06383348e-01f, -9.81758237e-02f, 8.20060745e-02f, -1.30532868e-02f, -1.22288778e-01f, 5.82623072e-02f, 1.54804885e-01f, -1.95093155e-01f, -3.22631523e-02f,
  -3.58622463e-04f, 7.64474124e-02f, -4.53782007e-02f, 1.69052463e-02f, -2.07875408e-02f, -1.50830567e-01f, -1.12742826e-01f, -1.66131049e-01f, -1.05634212e-01f, -1.76636223e-03f,
  -6.12360146e-03f, -5.53173050e-02f, 2.65064631e-02f, 1.33859500e-01f, 6.16641901e-02f, -6.86770454e-02f, -1.82578880e-02f, 8.51007476e-02f, 1.87915657e-02f, 1.18595278e-02f,
  6.05300307e-01f, -5.75863481e-01f, -2.33289525e-01f, -5.01852930e-02f, 1.23925291e-01f, -1.23796038e-01f, 3.02599519e-02f, -4.97170202e-02f, 7.47305512e-01f, -3.83308887e-01f,
  -3.49306077e-01f, -1.54848993e-01f, -5.38200997e-02f, -4.32473838e-01f, 4.61485177e-01f, 1.92800447e-01f, -2.08676010e-01f, -3.46767575e-01f, 2.65184820e-01f, -1.68534249e-01f,
  2.21642509e-01f, -1.83229685e-01f, -2.17398018e-01f, -4.55128521e-01f, -3.70883018e-01f, -2.93162316e-01f, -2.20758960e-01f, -3.57429057e-01f, -6.41285121e-01f, -1.47073701e-01f,
  2.73570828e-02f, 1.30619079e-01f, -1.64175496e-01f, -9.67888907e-02f, -1.24248369e-02f, -2.55335607e-02f, -1.81881174e-01f, -9.52234566e-02f, 3.75245959e-02f, 1.26176566e-01f,
  -6.05901063e-04f, 1.69565842e-01f, -2.88550486e-03f, 2.54268814e-02f, 2.40368377e-02f, -6.33265078e-02f, 7.57087022e-02f, 9.52474773e-03f, -7.53825903e-02f, -4.04683016e-02f,
  1.73068675e-03f, -1.55265350e-02f, 7.84245953e-02f, -1.42066060e-02f, -1.02718346e-01f, -1.21351130e-01f, -2.03472329e-03f, -1.73743203e-01f, 4.66376506e-02f, 1.28551841e-01f,
  -9.44705606e-02f, 2.76405495e-02f, 1.17556781e-01f, 1.87078454e-02f, -3.21753435e-02f, -1.43753914e-02f, -7.92746060e-03f, -6.96847737e-02f, 2.20324919e-01f, -7.29968622e-02f,
  7.07436576e-02f, -1.27030117e-02f, 3.48283090e-02f, -8.68152827e-03f, 4.93020676e-02f, 6.19217679e-02f, -5.88165363e-03f, -6.13178611e-02f, 1.36932880e-01f, 1.02603599e-01f,
  1.21652959e-02f, 1.17821068e-01f, -8.49873200e-02f, -1.31580919e-01f, -2.47276146e-02f, 1.95534248e-02f, -4.07661013e-02f, -7.88537562e-02f, 1.50412349e-02f, -2.50586844e-03f,
  -6.56948090e-02f, -1.23341762e-01f, -1.29478658e-02f, -1.11625493e-01f, -2.28186667e-01f, 1.20478518e-01f, -5.88784032e-02f, -4.28753681e-02f, -1.26427606e-01f, 8.65875185e-02f,
  -8.06511659e-03f, -7.37779588e-02f, 1.32191062e-01f, -4.79771979e-02f, -9.56397504e-02f, -5.62035930e-05f, -1.91036150e-01f, -2.42580231e-02f, -2.57043038e-02f, -5.80273606e-02f,
  -1.73862651e-01f, 1.58501804e-01f, 2.13270728e-02f, 4.42437232e-02f, -1.61764264e-01f, -8.20421651e-02f, 5.47977798e-02f, -4.76195738e-02f, 5.58747463e-02f, -7.00558349e-02f,
  -2.46792078e-01f, 6.67516947e-01f, -2.91152120e-01f, 8.27459693e-02f, -2.09617183e-01f, 8.33531439e-01f, 4.81127650e-01f, 1.13323905e-01f, 2.19628170e-01f, 5.23854971e-01f,
  2.92516917e-01f, 9.23652127e-02f, 3.17104161e-01f, 5.09330392e-01f, 2.40177691e-01f, 4.64997292e-01f, 3.41928661e-01f, 2.20479727e-01f, -2.42371663e-01f, 1.48291960e-01f,
  -4.61408757e-02f, 3.24676454e-01f, -8.79727826e-02f, -8.46551657e-02f, -1.81557700e-01f, -4.68180031e-01f, -2.30310708e-01f, -3.98742795e-01f, -6.05963878e-02f, -1.28768962e-02f,
  1.51947618e-01f, -1.05556145e-01f, -1.12631612e-01f, -6.76313862e-02f, -2.51163468e-02f, -1.32272109e-01f, -1.38235644e-01f, -6.58050850e-02f, -1.98218793e-01f, -4.66424320e-03f,
  -2.01232806e-02f, -7.74469459e-03f, 3.93821336e-02f, -9.69108641e-02f, -1.27880186e-01f, -1.14392057e-01f, -1.00547774e-03f, -6.29351363e-02f, 1.17679559e-01f, 2.15569064e-02f,
  1.25089079e-01f, 7.42329983e-03f, -1.64488330e-02f, 5.16609922e-02f, -1.32224396e-01f, 2.04155128e-02f, 6.38484061e-02f, 1.10447388e-02f, 7.68753737e-02f, 1.46265626e-01f,
  -8.82124677e-02f, 1.18799850e-01f, 1.29486725e-01f, -8.97549987e-02f, 1.90048665e-02f, -1.46953404e-01f, 2.33253352e-02f, -7.33050182e-02f, -3.12451813e-02f, 1.44964740e-01f,
  -1.31054735e-02f, 2.80412496e-03f, 5.27473874e-02f, 5.79505414e-02f, 6.03224188e-02f, 1.73046358e-03f, -8.26831460e-02f, -2.07182374e-02f, 7.28683993e-02f, -3.68390158e-02f,
  -3.99862230e-02f, 1.37323663e-01f, 8.73793438e-02f, -4.06834967e-02f, 3.45972180e-02f, -5.77906482e-02f, -1.77206304e-02f, -8.15763883e-03f, -1.03245163e-02f, -4.00859304e-02f,
  2.95996100e-01f, 3.07574064e-01f, 2.82316692e-02f, 7.56694153e-02f, 2.19436362e-02f, 1.53759122e-02f, 1.39091965e-02f, -2.08892412e-02f, 4.46263142e-02f, 3.80009338e-02f,
  -4.73757498e-02f, -3.29283103e-02f, -4.14283611e-02f, -7.22220838e-02f, 6.19400293e-02f, 2.52270132e-01f, 7.17250705e-02f, -6.05641603e-02f, 8.24173242e-02f, -4.39819992e-02f,
  -1.85552109e-02f, 5.68897417e-03f, -2.04622699e-03f, -8.37504268e-02f, -8.72399472e-03f, 7.26342127e-02f, 2.59678457e-02f, -8.47172514e-02f, -7.34482780e-02f, 1.18853010e-01f,
  9.20860320e-02f, -2.88820237e-01f, 3.67536545e-01f, -4.24315018e-04f, -1.08974008e-02f, -4.61830229e-01f, -1.48615569e-01f, -2.16279551e-01f, -2.36906752e-01f, -3.94208819e-01f,
  3.12255938e-02f, 2.79920757e-01f, 4.94801551e-01f, -2.39683107e-01f, 4.79270726e-01f, 3.70668054e-01f, -3.65880907e-01f, -3.48523080e-01f, -1.71107184e-02f, -2.12283939e-01f,
  8.83143619e-02f, -3.80969614e-01f, 3.97649676e-01f, -4.88703966e-01f, -1.21853046e-01f, -2.67743438e-01f, 1.55886233e-01f, 3.59308720e-01f, -4.20840263e-01f, 6.54618889e-02f,
  -4.02787268e-01f, 3.16886120e-02f, 2.98507195e-02f, -1.69935167e-01f, -1.85555607e-01f, -2.61379723e-02f, 7.70078301e-02f, 1.79407239e-01f, -3.14276032e-02f, -1.11336447e-01f,
  2.03847140e-02f, -1.70882627e-01f, -2.96710581e-01f, 1.95765998e-02f, -1.24376342e-01f, -1.09221965e-01f, -3.20259109e-02f, -4.14922386e-02f, -1.11787863e-01f, 2.41912380e-01f,
  6.28569648e-02f, 3.37196072e-03f, 6.31015897e-02f, 8.80469941e-03f, 2.43258104e-01f, -1.00791253e-01f, 6.80016503e-02f, 1.71224892e-01f, -9.04622748e-02f, -3.07159666e-02f,
  7.71921650e-02f, 6.30236492e-02f, -1.57028101e-02f, -1.97497636e-01f, 4.94158827e-03f, 3.48321535e-02f, -1.62186485e-03f, 8.41102526e-02f, 7.66346883e-03f, 8.24412182e-02f,
  -1.30443931e-01f, 9.43304971e-02f, -1.51456136e-03f, -7.75026008e-02f, -9.86743048e-02f, -8.50610286e-02f, 2.89116073e-02f, -7.37977475e-02f, -3.10094655e-02f, 2.69841682e-02f,
  1.11085609e-01f, -1.18639551e-01f, 6.14948533e-02f, 1.34706959e-01f, -2.18584254e-01f, 2.20224455e-01f, -1.51749142e-02f, -3.86463776e-02f, -1.95772983e-02f, 1.47665396e-01f,
  -3.66297096e-01f, -1.19646348e-01f, -1.42143145e-01f, -1.13093071e-01f, 5.14768763e-03f, -1.35788575e-01f, -8.38109758e-03f, -1.71084315e-01f, -6.76257908e-02f, -4.38585766e-02f,
  -2.58495897e-01f, -5.10523953e-02f, -2.24808045e-02f, -1.40425768e-02f, -5.11712991e-02f, -4.11968604e-02f, 1.52942808e-02f, -5.19295000e-02f, 7.12174475e-02f, -6.83807880e-02f,
  4.72034365e-02f, 1.08944468e-01f, 1.40323773e-01f, -1.38525382e-01f, 1.11796623e-02f, 1.55203519e-02f, 5.72423525e-02f, -3.08803078e-02f, 6.05629608e-02f, -1.40990159e-02f,
  -6.37702107e-01f, 4.56185013e-01f, -4.77686644e-01f, -4.16823119e-01f, 5.05608499e-01f, -5.43682612e-02f, -1.79475248e-01f, 4.23215300e-01f, -1.56067550e-01f, 4.71905708e-01f,
  3.06059241e-01f, -3.20513189e-01f, 2.34009400e-01f, -2.73343295e-01f, -5.86727083e-01f, -3.61824185e-01f, -3.49839270e-01f, -3.32605094e-01f, -2.53300995e-01f, -1.41463820e-02f,
  -3.90306920e-01f, 2.02680543e-01f, -4.96035367e-01f, 4.88119930e-01f, 1.98118370e-02f, -9.06438902e-02f, 4.73682076e-01f, 3.05588573e-01f, 5.49426526e-02f, -3.71928811e-02f,
  -2.62200758e-02f, 8.79842415e-02f, -7.61938244e-02f, -2.45029956e-01f, 3.50199081e-03f, 7.19775036e-02f, 1.41010610e-02f, -5.95101155e-02f, -1.12403251e-01f, -1.56457469e-01f,
  4.92454618e-02f, -6.00040965e-02f, -1.68181024e-02f, -6.24475665e-02f, 7.80508518e-02f, 6.57649264e-02f, -9.22391787e-02f, -6.47127628e-02f, -5.15552238e-02f, -2.45154724e-01f,
  -8.72926340e-02f, -6.95802495e-02f, -5.38134389e-02f, -1.27888724e-01f, -5.24332114e-02f, 1.27185369e-02f, -1.10229284e-01f, 1.39879910e-02f, 1.82584859e-02f, -1.73596386e-02f,
  2.81090513e-02f, 3.30888592e-02f, -2.66609974e-02f, -3.49264815e-02f, 9.23843086e-02f, -2.07639933e-02f, 1.91341564e-02f, -7.29877725e-02f, -2.51069777e-02f, 1.54386118e-01f,
  -5.62902018e-02f, -5.10328114e-02f, 1.49340048e-01f, -4.84669283e-02f, -2.52427384e-02f, -2.27161169e-01f, 2.76909582e-02f, 9.71848145e-02f, -6.87164590e-02f, 6.16631750e-03f,
  2.56053805e-02f, 3.87720857e-03f, 5.07980846e-02f, 7.80592784e-02f, -3.91271077e-02f, 3.30489092e-02f, 5.97681105e-02f, -8.25815052e-02f, 1.88686009e-02f, 1.97774395e-02f,
  1.44054890e-01f, 5.07611513e-01f, -4.25945967e-02f, 6.72642291e-02f, -2.82237120e-02f, 1.29230365e-01f, -4.77486923e-02f, 4.81691658e-02f, -2.07792632e-02f, 1.76756427e-01f,
  1.26036242e-01f, -1.49098067e-02f, 1.06244236e-01f, -3.78501900e-02f, -1.77652851e-01f, 2.85586238e-01f, 2.62377616e-02f, 2.07104068e-02f, 1.08957119e-01f, 1.40664533e-01f,
  9.77309123e-02f, 1.42628029e-01f, -4.19475930e-03f, 1.74249351e-01f, 1.06231868e-01f, 1.29325822e-01f, 1.93450630e-01f, 9.91179422e-03f, 5.64309806e-02f, 4.48485203e-02f,
  4.44187187e-02f, 5.48103154e-01f, 3.47276717e-01f, 8.29416420e-03f, -6.96283579e-02f, 2.58695662e-01f, 8.87885392e-02f, -9.55918059e-02f, 4.30572927e-01f, 1.66813075e-03f,
  -4.70781088e-01f, 2.35511854e-01f, -1.62999019e-01f, -2.00031102e-01f, -2.97043622e-01f, -1.27770066e-01f, 3.60776484e-01f, 7.74860755e-02f, 1.64827015e-02f, 2.55514476e-02f,
  5.72487107e-03f, -2.75202692e-01f, -4.40775305e-01f, -1.24391772e-01f, 5.76605275e-02f, 3.32242221e-01f, -5.23630083e-01f, 7.50109851e-02f, -1.41631842e-01f, -2.26078510e-01f,
  -1.51482031e-01f, -2.03856304e-01f, 3.90225798e-02f, 8.84217918e-02f, 1.21353559e-01f, 1.14447693e-03f, 1.39284566e-01f, -1.81975335e-01f, -4.71087731e-02f, -3.95263769e-02f,
  9.52169225e-02f, -1.97581902e-01f, 8.19672272e-02f, -8.15260038e-02f, 1.84415188e-02f, 4.85194772e-02f, 1.95555855e-02f, -1.81052331e-02f, -9.01410282e-02f, -6.38083601e-03f,
  6.62515238e-02f, 2.25603119e-01f, 1.62603837e-02f, 1.19954504e-01f, 1.44213006e-01f, -1.22544877e-02f, 2.20631599e-01f, 7.26393685e-02f, 1.49406776e-01f, -6.40566871e-02f,
  -1.53801274e-02f, 2.41278931e-01f, -1.38448372e-01f, -2.29458302e-01f, -7.64143392e-02f, -2.01963615e-02f, 2.65572499e-02f, -1.57203451e-01f, 1.81522980e-01f, -2.46099848e-02f,
  9.93084386e-02f, -1.11200102e-01f, 4.18376625e-02f, 1.69598252e-01f, -7.66089112e-02f, 4.16710600e-02f, 1.55211583e-01f, 1.33972958e-01f, 1.03466446e-02f, -2.58531384e-02f,
  -2.22289972e-02f, 2.30148584e-01f, -1.01350069e-01f, -1.32070128e-02f, -9.51346532e-02f, -7.82624409e-02f, 2.59123277e-02f, -6.83096871e-02f, 7.82442018e-02f, 7.08422065e-03f,
  2.73193061e-01f, 4.50535268e-01f, 6.28818125e-02f, -6.20217249e-02f, -5.77727845e-03f, -1.22800265e-02f, 7.60980099e-02f, 9.42443535e-02f, 1.87398404e-01f, -5.78744039e-02f,
  1.06494479e-01f, 8.46288577e-02f, 1.75325081e-01f, -9.89575386e-02f, -2.02892236e-02f, 3.38594876e-02f, 2.78024636e-02f, 1.32732823e-01f, 1.88865602e-01f, -1.59902982e-02f,
  1.35369703e-01f, 1.99258313e-01f, 1.02242880e-01f, 1.39254034e-01f, 1.71299130e-01f, -1.16072945e-01f, 2.33200520e-01f, -1.07772432e-01f, 9.33406278e-02f, 3.52016911e-02f,
  -4.95373070e-01f, 1.05799720e-01f, 7.37430632e-01f, -7.26887286e-02f, 5.53190894e-02f, 5.61595559e-01f, 2.64220089e-01f, 2.91505575e-01f, 3.77390295e-01f, -5.51654994e-01f,
  -3.97520185e-01f, -3.48529756e-01f, 2.57404357e-01f, -2.80400246e-01f, 6.83516264e-01f, 6.09822452e-01f, 9.13100168e-02f, 9.21083242e-02f, 3.24661762e-01f, -2.13183295e-02f,
  1.77591309e-01f, -4.56359804e-01f, 1.61846459e-01f, -3.24698955e-01f, -3.54001641e-01f, -1.07411593e-01f, -4.17261332e-01f, 3.80072773e-01f, -4.21486616e-01f, 1.25032812e-01f,
  -3.22554171e-01f, -1.67906478e-01f, -2.00063020e-01f, 1.28347486e-01f, 7.31190667e-03f, -2.90545039e-02f, 1.21913649e-01f, 3.71232703e-02f, -1.45835197e-02f, -7.61796311e-02f,
  -3.12389177e-03f, -1.17519081e-01f, -1.01776883e-01f, 6.49402812e-02f, 8.37750435e-02f, -6.57248944e-02f, 2.65541039e-02f, -4.29282412e-02f, -1.05132543e-01f, 1.68279335e-01f,
  -2.84397625e-04f, 7.83588141e-02f, -1.78393966e-03f, 2.68783253e-02f, -4.07066979e-02f, -4.13374417e-03f, 1.02662370e-01f, 2.82179844e-02f, -6.49424344e-02f, 2.16421615e-02f,
  1.91502765e-01f, 2.04807758e-01f, -1.42913073e-01f, -1.92174744e-02f, -7.09957331e-02f, -7.37873837e-02f, 4.05529477e-02f, -6.95697442e-02f, 4.03100587e-02f, -1.88982680e-01f,
  -1.43346578e-01f, 2.17449553e-02f, 1.27598077e-01f, 6.44992441e-02f, -4.31185067e-02f, -8.56636837e-02f, 2.43105069e-02f, -1.09468168e-02f, 3.88929769e-02f, 1.17711136e-02f,
  -1.78802088e-02f, 5.49845770e-02f, -1.29593879e-01f, -2.21877266e-02f, 1.00664891e-01f, 8.74847397e-02f, -1.41770139e-01f, 3.70002426e-02f, 3.74160558e-02f, 7.18638897e-02f,
  2.96944141e-01f, 3.75458151e-01f, -1.88361868e-01f, -2.44640410e-01f, 9.72852930e-02f, -1.02125950e-01f, 2.20971435e-01f, -8.66055936e-02f, 1.28666282e-01f, -2.51797568e-02f,
  -6.92985654e-02f, -8.47896561e-02f, -3.64639983e-02f, 1.53041407e-01f, 8.15568268e-02f, -2.48208381e-02f, -1.25831673e-02f, 3.80322784e-02f, -5.69518767e-02f, -5.96204624e-02f,
  -3.06465626e-01f, -9.32613164e-02f, -1.94391664e-02f, -1.52316839e-01f, -2.70365417e-01f, -1.98787630e-01f, -4.71629724e-02f, 8.69389717e-03f, -1.88758373e-02f, 5.70719503e-02f,
  -7.25454986e-01f, 4.70131844e-01f, 3.62210810e-01f, -6.01299524e-01f, 7.57113770e-02f, -1.99405685e-01f, -5.89585423e-01f, 1.66440010e-01f, 1.50145784e-01f, 1.26406163e-01f,
  -3.50550085e-01f, 3.00908595e-01f, 2.65411049e-01f, -3.34840000e-01f, -5.50443947e-01f, -1.09237120e-01f, -6.31739020e-01f, -3.26850176e-01f, -1.49515709e-02f, -2.69471139e-01f,
  -1.51326880e-01f, -6.22427404e-01f, -1.52240917e-01f, 2.31296360e-01f, -1.83996141e-01f, 2.03973591e-01f, -4.32336628e-01f, 3.62783551e-01f, -2.05150232e-01f, -1.31832575e-02f,
  5.52757122e-02f, 9.21377614e-02f, 2.35349521e-01f, 1.60548285e-01f, 1.58827137e-02f, -3.45550850e-02f, 5.69905806e-03f, 3.87183540e-02f, -2.55851578e-02f, 2.78152693e-02f,
  1.74751997e-01f, 9.84239653e-02f, 5.85525110e-02f, 3.03178355e-02f, 9.31444988e-02f, 2.77768988e-02f, 5.65698296e-02f, -5.86788505e-02f, 2.30397373e-01f, 1.54120430e-01f,
  1.55318500e-02f, 1.07350141e-01f, 5.50507195e-02f, -6.18932731e-02f, 6.99912682e-02f, -5.92064932e-02f, -1.79615691e-01f, -2.60747373e-02f, -1.18859440e-01f, 4.32641506e-02f,
  7.34885558e-02f, -1.18268430e-01f, 9.17170849e-03f, 4.12373757e-03f, -7.70319328e-02f, 1.16799831e-01f, -8.67357012e-03f, -1.10454947e-01f, -2.69180350e-02f, -4.19001170e-02f,
  -6.00711741e-02f, 9.25600715e-03f, -1.84476990e-02f, -5.20482399e-02f, -1.04425482e-01f, 6.57632831e-04f, 2.25908943e-02f, 8.18051621e-02f, -1.84784949e-01f, -1.39865605e-02f,
  -1.41019300e-01f, -1.91311583e-01f, -2.12011877e-02f, -2.51154974e-02f, 6.88507333e-02f, 1.05185270e-01f, -4.21179309e-02f, 2.21867949e-01f, 8.09665024e-02f, -4.57301885e-02f,
  -2.50052035e-01f, -1.99722275e-01f, 1.25703484e-01f, 8.69862512e-02f, 7.21555948e-02f, -3.36893983e-02f, -5.84546439e-02f, 3.69433798e-02f, -8.14228281e-02f, -2.82781702e-02f,
  -3.97211127e-02f, -8.60174820e-02f, 4.42043766e-02f, 6.01721462e-03f, -3.99393775e-03f, -3.73339765e-02f, -9.51835439e-02f, -3.52073237e-02f, -9.98956859e-02f, -9.16109830e-02f,
  8.16321373e-02f, 5.59408404e-02f, -3.63766328e-02f, -6.43473864e-02f, -1.02332823e-01f, -6.10164106e-02f, -1.45554289e-01f, 4.79715317e-02f, -2.80575734e-03f, -5.06300963e-02f,
  2.33003929e-01f, 2.58831121e-02f, -5.40145278e-01f, 7.48799220e-02f, -3.93120991e-03f, 5.94534636e-01f, 2.35452101e-01f, -4.88700019e-03f, -2.39365950e-01f, 4.60549265e-01f,
  4.64305162e-01f, 2.80586123e-01f, -4.08574194e-01f, 7.54403770e-01f, 5.22853918e-02f, -3.47057320e-02f, 5.52688181e-01f, 5.13615251e-01f, -2.52350181e-01f, -6.87722489e-02f,
  -1.74044266e-01f, 4.30305123e-01f, 2.95685176e-02f, 9.20600146e-02f, 4.28580254e-01f, -5.25450185e-02f, 4.17698547e-02f, -2.28208557e-01f, 6.80171609e-01f, 3.52718562e-01f,
  3.04735839e-01f, -6.53476343e-02f, 2.56169168e-03f, -8.07141736e-02f, -1.44240811e-01f, 7.54525661e-02f, 7.26343840e-02f, 1.96999162e-01f, -1.04891341e-02f, -6.43194914e-02f,
  5.00689782e-02f, 2.91531701e-02f, 6.65892884e-02f, -9.18450505e-02f, 5.62638836e-03f, 9.99031067e-02f, 2.40081996e-02f, 1.04331657e-01f, -5.21613769e-02f, 2.64830831e-02f,
  -1.27740383e-01f, -2.47228630e-02f, -2.61689052e-02f, 1.06700011e-01f, -2.58581284e-02f, -3.70830670e-02f, 9.56786871e-02f, -3.12002208e-02f, 7.69570470e-02f, 1.17218238e-03f,
  9.29590836e-02f, -1.30403861e-01f, -3.08971126e-02f, 2.34997515e-02f, -3.50972973e-02f, 8.71301144e-02f, 1.36403576e-01f, 6.68078959e-02f, -6.13902211e-02f, 1.88474562e-02f,
  -7.95856267e-02f, 4.17055143e-03f, 9.18828845e-02f, 1.49422020e-01f, 9.76101756e-02f, 8.64449665e-02f, 1.20853921e-02f, 3.03201731e-02f, -3.01610976e-02f, 5.09550385e-02f,
  6.91967504e-03f, -4.25919667e-02f, 8.05705488e-02f, 3.29522677e-02f, 4.85016517e-02f, -6.05349690e-02f, 9.75748971e-02f, 6.81272894e-02f, -1.71245728e-02f, -7.67684355e-02f,
  1.03648290e-01f, -2.66602635e-01f, -9.93461013e-02f, 4.69341092e-02f, -1.28310286e-02f, 2.49532089e-02f, -3.76505703e-02f, 1.56379506e-01f, 6.24915883e-02f, -1.29600644e-01f,
  -1.72084365e-02f, -7.29520842e-02f, -3.34393932e-03f, 1.00147739e-01f, 8.69390927e-03f, -3.08732372e-02f, -1.28613338e-01f, 3.43902372e-02f, 3.59875374e-02f, 2.72420645e-02f,
  -9.08335857e-03f, 1.22289674e-03f, -2.98630483e-02f, -7.16303363e-02f, 1.13194160e-01f, -3.87314595e-02f, 9.92404222e-02f, -1.87925413e-01f, 8.01153928e-02f, 6.83950335e-02f,
  4.29190367e-01f, -2.36743629e-01f, 3.73373479e-01f, 6.45458996e-01f, -2.23818794e-01f, -2.19214022e-01f, 5.67594051e-01f, -4.62327600e-01f, 4.05046523e-01f, -4.55294013e-01f,
  -2.12147519e-01f, 5.86284101e-01f, 2.56617069e-01f, -3.06617528e-01f, 5.90821207e-01f, 2.28643134e-01f, -3.25648226e-02f, 2.00453341e-01f, 7.56945238e-02f, 1.57338530e-02f,
  2.39662051e-01f, -3.07958394e-01f, 2.06839532e-01f, -4.65452433e-01f, -3.09843421e-01f, -7.88496658e-02f, -1.08300894e-01f, 1.76182278e-02f, -3.11821461e-01f, 7.28849173e-02f,
  -2.07117990e-01f, 1.85948491e-01f, 1.93895679e-02f, -7.59332404e-02f, -1.00559816e-01f, -1.16183840e-01f, 1.06454596e-01f, 2.17347369e-01f, 1.40047446e-01f, -6.00708835e-02f,
  1.27985030e-01f, 1.71346329e-02f, -1.34713799e-01f, 4.76468019e-02f, -1.34803886e-02f, -9.88366604e-02f, -6.97347373e-02f, -1.64948702e-01f, -3.63285001e-03f, -1.31665140e-01f,
  5.89113915e-03f, -1.17763303e-01f, 5.31071424e-03f, 4.83556166e-02f, 2.58838713e-01f, 4.36204672e-03f, 2.05723606e-02f, 1.41561434e-01f, -4.44912799e-02f, 3.98070589e-02f,
  6.96342066e-02f, 8.46712366e-02f, -2.90119611e-02f, -1.18824899e-01f, -4.20961305e-02f, -2.02243831e-02f, -5.83419576e-02f, -9.42431390e-02f, -8.99031200e-03f, 3.11506018e-02f,
  -6.80588111e-02f, 4.45940085e-02f, -1.03837080e-01f, -3.81196961e-02f, -2.06842981e-02f, 8.00455511e-02f, 2.85397633e-03f, -5.84134646e-02f, -9.65325311e-02f, -2.76791733e-02f,
  -3.51455882e-02f, -5.15576340e-02f, -3.77052315e-02f, 2.46755760e-02f, -1.49251625e-01f, 1.54048726e-02f, -1.12462737e-01f, 5.43128233e-03f, -1.91857305e-03f, 3.56307179e-02f,
  4.41521220e-02f, 1.65358871e-01f, 1.34273022e-02f, -8.06029141e-03f, -8.62181559e-02f, -1.78447202e-01f, 1.11975417e-01f, -2.27857959e-02f, 1.15983173e-01f, -3.99993807e-02f,
  -7.79351071e-02f, -4.72018942e-02f, -5.91610326e-04f, 1.34238796e-02f, 1.07011721e-01f, -4.96579297e-02f, 2.23671153e-01f, -2.88816914e-02f, 1.07207902e-01f, -4.29927818e-02f,
  8.76696408e-02f, 6.94885701e-02f, -1.12361409e-01f, -1.43732041e-01f, -9.30799916e-02f, 1.08314522e-01f, 8.36161673e-02f, 5.08266091e-02f, 5.82139567e-02f, -1.78404730e-02f,
  -5.52662969e-01f, -3.07717532e-01f, -3.66339087e-01f, -1.67375058e-01f, 1.82651609e-01f, -6.93733767e-02f, 3.16968024e-01f, -1.52337179e-01f, -1.73410994e-03f, 2.50963986e-01f,
  2.43384168e-01f, -4.11019981e-01f, 3.48951310e-01f, -3.86379182e-01f, -4.71192807e-01f, -2.91145444e-01f, -4.63814259e-01f, -3.09122920e-01f, -1.06312111e-01f, -4.90325056e-02f,
  -1.46551237e-01f, 5.31866662e-02f, -3.54188949e-01f, 2.23283261e-01f, 1.00721791e-01f, 9.95482355e-02f, 2.12103233e-01f, 3.92390758e-01f, -1.61395937e-01f, -9.20623615e-02f,
  -9.43143219e-02f, 9.07719657e-02f, 4.60270718e-02f, -2.26245895e-02f, -3.10734957e-02f, 8.64854231e-02f, 3.99216712e-02f, 5.80229014e-02f, 1.20740302e-01f, -1.19481169e-01f,
  7.51980841e-02f, -1.52233820e-02f, -1.66558057e-01f, -1.12681247e-01f, 1.02741525e-01f, -5.72871529e-02f, -9.63368714e-02f, 1.40601872e-02f, 6.19092360e-02f, -1.05361417e-01f,
  -9.72426236e-02f, -5.29901385e-02f, -1.71224698e-02f, -8.29805061e-02f, -5.21732457e-02f, -2.85895570e-04f, -1.46765128e-01f, 2.91837808e-02f, 1.99741405e-02f, -1.62451550e-01f,
  -7.32664168e-02f, 6.05314262e-02f, 1.23013198e-01f, 5.57894260e-02f, -2.79526282e-02f, 5.37908897e-02f, 7.80412853e-02f, 8.80921353e-03f, 1.73328817e-02f, 3.70747447e-02f,
  1.20190568e-02f, -8.41875747e-02f, -5.30283861e-02f, 2.38698460e-02f, 1.00260295e-01f, 7.28054792e-02f, 5.15636289e-03f, -4.86996621e-02f, 1.81077152e-01f, -5.74810877e-02f,
  3.65139768e-02f, -1.67491343e-02f, -1.53040448e-02f, 1.11492679e-01f, 1.03985798e-02f, 7.76574984e-02f, -8.39369223e-02f, -1.60304189e-01f, 1.02986425e-01f, 3.37000974e-02f,
  1.04503408e-01f, 1.29611909e-01f, 2.81401984e-02f, 2.94777956e-02f, 4.02380936e-02f, -5.67781925e-03f, -1.06251635e-01f, -2.32291341e-01f, -5.60613489e-03f, -7.47462139e-02f,
  -8.01079124e-02f, 1.41275540e-01f, 4.55058888e-02f, -1.58661173e-03f, 7.16039911e-02f, -4.27910797e-02f, 1.53262913e-01f, 1.35254055e-01f, 6.14357181e-02f, -5.53768612e-02f,
  1.77233800e-01f, 1.07479662e-01f, 8.79096761e-02f, 1.57194361e-01f, 1.18985422e-01f, 1.09400161e-01f, 1.11334786e-01f, 1.17546869e-02f, 5.12257814e-02f, -4.66768183e-02f,
  -6.55534923e-01f, -2.01874018e-01f, -4.51110154e-01f, -1.66314915e-01f, -1.37347952e-01f, -8.04231465e-02f, -3.32166255e-01f, -8.26684851e-03f, -4.74743068e-01f, 1.43448338e-01f,
  1.67351767e-01f, -3.65210146e-01f, -1.69733822e-01f, 4.55886394e-01f, 4.02020961e-02f, 1.38616696e-01f, 4.78182554e-01f, 2.12116778e-01f, 2.02990055e-01f, 1.39601350e-01f,
  3.90058964e-01f, 5.56980848e-01f, 4.72594082e-01f, 5.24992049e-01f, -3.81643064e-02f, 1.21469937e-01f, 3.75821948e-01f, -8.03884715e-02f, 5.49490035e-01f, 1.68414712e-01f,
  9.16793644e-02f, -4.45941389e-02f, -1.35842189e-01f, -3.01709361e-02f, 1.43084228e-01f, 5.72680729e-03f, 2.45335139e-02f, -6.22756295e-02f, -7.23472312e-02f, -2.46133795e-03f,
  -1.99595660e-01f, 2.15813215e-03f, -7.05637559e-02f, -2.35651247e-02f, -9.72643122e-02f, -6.76554367e-02f, 5.44479713e-02f, -3.30024660e-02f, -6.00742474e-02f, -8.07500631e-02f,
  -1.63229898e-01f, -1.25059008e-03f, -8.35483298e-02f, 7.84709700e-04f, -1.36700913e-01f, -1.23251818e-01f, -1.14684761e-01f, -3.26980688e-02f, 4.50838655e-02f, -4.14367914e-02f,
  2.60421284e-03f, -4.16174270e-02f, 5.43680741e-03f, -1.02974750e-01f, -4.68133427e-02f, -2.13182066e-02f, -1.39600374e-02f, 9.67048183e-02f, -6.03309311e-02f, 5.08180149e-02f,
  8.89537390e-03f, -9.74873826e-02f, -8.78295023e-03f, -8.29888210e-02f, 1.36956334e-01f, 2.43119849e-03f, 2.20891759e-02f, 1.02544472e-01f, -7.86928274e-03f, 9.25069004e-02f,
  -8.27777237e-02f, 5.22716269e-02f, 4.96670976e-03f, 1.70206487e-01f, -6.70746109e-03f, -1.70607101e-02f, -2.73470934e-02f, -5.84498234e-02f, 4.48011756e-02f, 1.60720013e-02f,
  2.41288051e-01f, 1.04034916e-01f, -3.81687586e-03f, 1.20649617e-02f, 2.83546466e-02f, -1.40894018e-02f, 9.28317979e-02f, 3.45610790e-02f, 1.07598333e-02f, -7.23629370e-02f,
  4.22442518e-02f, 1.00486159e-01f, 5.19734621e-03f, -6.44573569e-03f, 1.39794201e-01f, 3.81741934e-02f, -6.00551674e-03f, -5.69599457e-02f, 2.25577056e-02f, 1.40162542e-01f,
  1.96428839e-02f, -2.46140584e-02f, 4.45122905e-02f, -6.81165233e-02f, 1.59017034e-02f, 1.64351740e-03f, 2.64436868e-03f, -4.42235507e-02f, 8.86658207e-02f, -2.52481643e-02f,
  -6.94781721e-01f, 2.09222496e-01f, -1.85169145e-01f, 2.36926049e-01f, -5.76059222e-01f, -5.86202919e-01f, -3.16656530e-02f, -1.95833981e-01f, -2.71619838e-02f, 4.65431869e-01f,
  2.75777876e-01f, -4.11547333e-01f, 3.69609296e-01f, 1.94636822e-01f, -8.17273617e-01f, 2.51749218e-01f, 3.77020180e-01f, 1.91933244e-01f, -1.56653389e-01f, -1.03038192e-01f,
  -2.08627544e-02f, -6.22164160e-02f, 9.62650999e-02f, -4.60677072e-02f, -4.29447144e-01f, 4.37924936e-02f, 3.38391066e-01f, -1.00898974e-01f, 7.41277337e-02f, -4.51226383e-01f,
  -1.70090079e-01f, -5.56030236e-02f, 4.34700847e-02f, -1.31305456e-01f, -9.01599601e-02f, -6.44816598e-03f, 1.75903342e-03f, -2.14336544e-01f, -7.77199790e-02f, -4.25116271e-02f,
  -5.33370813e-03f, -1.39739648e-01f, -5.17402031e-02f, -1.40438098e-02f, -9.30844992e-02f, -8.04542527e-02f, -2.52723366e-01f, -2.00766586e-02f, -4.84556444e-02f, -3.16313684e-01f,
  -1.17821224e-01f, 5.04958630e-02f, -2.78405920e-02f, 1.33742571e-01f, -8.52740034e-02f, -9.16583985e-02f, 5.95443649e-03f, -2.01474745e-02f, -1.62658423e-01f, -1.60996497e-01f,
  1.24544784e-01f, -1.27411395e-01f, -5.78995273e-02f, -2.67739650e-02f, -3.45919421e-03f, 1.04037069e-01f, 1.10668316e-01f, 1.96254370e-03f, 7.03730807e-02f, -4.57086302e-02f,
  -1.43598579e-02f, 7.48434439e-02f, -8.56610984e-02f, 5.70540838e-02f, -9.18035302e-03f, 1.20278589e-01f, 1.17284907e-02f, -6.00746758e-02f, 6.81100488e-02f, -2.93122977e-02f,
  1.79446891e-01f, -1.90817013e-01f, -7.31146634e-02f, 7.53702074e-02f, -4.06473735e-03f, 5.86312450e-03f, 1.29110694e-01f, 2.08977554e-02f, 7.28962198e-02f, -4.45071161e-02f,
  -2.01471802e-02f, 2.92085230e-01f, 5.01524918e-02f, -1.55042693e-01f, 1.66315258e-01f, -4.49916646e-02f, 1.41743898e-01f, -2.78259460e-02f, -5.29034436e-03f, -6.04867786e-02f,
  4.36982475e-02f, -2.07664482e-02f, -7.71314427e-02f, 3.22727039e-02f, 2.71289945e-02f, -1.05664069e-02f, 1.51483342e-01f, 2.24383116e-01f, 1.70586649e-02f, -9.40145701e-02f,
  1.76394150e-01f, 2.18317565e-02f, 3.87014188e-02f, 4.61896062e-02f, -1.20527754e-02f, 9.33529511e-02f, 3.53102759e-02f, -4.02832776e-02f, -5.47548383e-02f, 9.09145400e-02f,
  6.02466285e-01f, 4.56612378e-01f, 6.58340096e-01f, 7.32581854e-01f, -9.50853229e-02f, -2.92803168e-01f, 2.48632524e-02f, 3.07831019e-01f, 7.57160842e-01f, -1.22200854e-01f,
  -3.92027289e-01f, 4.74553943e-01f, -4.39383745e-01f, 3.67579013e-01f, -4.72450733e-01f, -3.60929251e-01f, 3.42800200e-01f, 8.34598988e-02f, 8.72416049e-02f, 5.65954208e-01f,
  3.88653904e-01f, -4.33253020e-01f, -5.64936502e-03f, -3.61087173e-01f, 3.70611191e-01f, 5.26401460e-01f, -4.08580422e-01f, -2.76993603e-01f, 8.07153583e-02f, -4.25246865e-01f,
  -4.82289158e-02f, 2.85917938e-01f, 1.02362536e-01f, 6.08226052e-03f, 6.47941157e-02f, 7.36885741e-02f, 4.03998345e-02f, -2.59362072e-01f, -1.20403310e-02f, 1.12920925e-01f,
  1.46836370e-01f, -1.33280605e-01f, 3.69052254e-02f, -2.82039195e-01f, 1.96883455e-01f, 1.79755405e-01f, 2.08725229e-01f, 2.96099246e-01f, 1.79695442e-01f, 1.31021798e-01f,
  2.03415975e-01f, 1.36893317e-01f, 2.57452548e-01f, -1.56160854e-02f, 1.87404469e-01f, 1.19431309e-01f, 3.29315837e-04f, 1.05114132e-01f, 1.21465690e-01f, 2.41368905e-01f,
  6.33714870e-02f, -5.15951701e-02f, -5.13543002e-02f, -7.12109655e-02f, 5.82102239e-02f, 5.49997501e-02f, 6.37705252e-02f, -4.45164219e-02f, 1.16613016e-01f, 7.12078512e-02f,
  -5.08979261e-02f, 1.16714694e-01f, 1.43026793e-02f, -1.54896736e-01f, 1.25020564e-01f, 1.75423503e-01f, -1.96722090e-01f, -1.87539577e-01f, 1.71621308e-01f, -7.68537298e-02f,
  -1.44145042e-01f, -1.00262776e-01f, -3.90742943e-02f, -1.18744769e-03f, -7.99440071e-02f, 2.82003414e-02f, 4.24014814e-02f, 2.06056416e-01f, 3.99809256e-02f, -8.26281905e-02f,
  1.37059361e-01f, 2.38138571e-01f, 4.23042513e-02f, 1.39833307e-02f, 3.47224139e-02f, -4.87379618e-02f, 1.01635102e-02f, 1.44323334e-01f, 1.44805759e-01f, -1.02868974e-01f,
  1.19611852e-01f, 2.34446190e-02f, -1.35097448e-02f, -1.21710382e-01f, -9.11986083e-02f, 9.34170634e-02f, 6.12554662e-02f, -3.90806757e-02f, -6.83414713e-02f, -6.98808432e-02f,
  1.57803923e-01f, 3.30487564e-02f, 8.57772455e-02f, 1.49689168e-01f, -2.86805313e-02f, 1.55859068e-02f, 9.05062780e-02f, 5.61936833e-02f, -3.74506079e-02f, 3.27826142e-02f,
  1.86437070e-01f, 1.70808107e-01f, -5.59632003e-01f, 1.18636668e-01f, -4.87888724e-01f, 5.80752552e-01f, 5.60321391e-01f, -1.92056760e-01f, 1.41992196e-01f, 5.24674118e-01f,
  2.86240101e-01f, -9.19447932e-03f, 3.25127840e-01f, 6.54260218e-01f, -3.24414261e-02f, 5.55772901e-01f, 5.53918719e-01f, 4.71921951e-01f, -1.50509864e-01f, 1.96459889e-01f,
  -4.12184163e-04f, 5.70059121e-01f, -2.73625731e-01f, -2.08107144e-01f, -2.45825127e-02f, -4.92118418e-01f, -3.02554160e-01f, -4.55948710e-01f, 5.65700755e-02f, -8.88989791e-02f,
  9.17542353e-02f, 1.35860130e-01f, -7.14464560e-02f, -1.35838054e-02f, -3.89368981e-02f, 2.01334693e-02f, 2.96681412e-02f, -1.93077043e-01f, -9.34285671e-02f, 1.08449787e-01f,
  9.55127776e-02f, 6.91267401e-02f, 1.70499429e-01f, -1.12524368e-01f, -1.14431717e-02f, -7.71417916e-02f, -4.56903167e-02f, -1.04621850e-01f, -2.24733520e-02f, -9.70185399e-02f,
  -1.51053742e-01f, 4.13960218e-03f, 6.03002310e-02f, 9.35218856e-02f, -5.77453487e-02f, 2.02026833e-02f, -3.50161530e-02f, -1.88137233e-01f, -4.58409227e-02f, 2.66797543e-02f,
  1.51951350e-02f, 1.57019913e-01f, 2.07192168e-01f, -4.89317887e-02f, -2.00387947e-02f, -1.23884112e-01f, 1.29323632e-01f, -4.32085656e-02f, -3.49054076e-02f, 6.05017096e-02f,
  -2.55083032e-02f, -1.36746302e-01f, 3.13321664e-03f, 2.11326092e-01f, 1.30203277e-01f, 4.62849289e-02f, -1.30996071e-02f, 6.17526704e-03f, 5.26534617e-02f, -9.84047055e-02f,
  3.17037593e-05f, 7.58704692e-02f, 1.80408843e-02f, -2.38299882e-03f, 3.12505849e-02f, -7.76980743e-02f, 8.95073637e-02f, 5.41245006e-02f, -1.72330178e-02f, -1.37390420e-02f,
  2.91026216e-02f, 1.40535772e-01f, -4.91759218e-02f, -9.22484230e-03f, 1.77427884e-02f, 1.14907138e-01f, 7.36135393e-02f, 1.61317792e-02f, 1.19108958e-02f, 1.55255839e-01f,
  8.24582428e-02f, 9.82925445e-02f, 7.57138580e-02f, -1.31080404e-01f, -9.90616307e-02f, 3.12583819e-02f, 2.15892926e-01f, 7.75733590e-03f, -5.04845679e-02f, -1.65236995e-01f,
  -1.36982948e-02f, 1.15870804e-01f, 1.28793508e-01f, 1.91606563e-02f, 1.79008394e-01f, 1.11536779e-01f, -5.32317050e-02f, -1.30159110e-01f, -1.62330568e-01f, 1.95428506e-02f,
  -1.11701727e+00f, 8.52902174e-01f, 3.04546535e-01f, -3.47994506e-01f, 7.50514567e-02f, 2.72229493e-01f, 2.02208474e-01f, 1.28277466e-01f, -3.33442628e-01f, 3.10578883e-01f,
  1.16558343e-01f, -1.47079423e-01f, 4.17738438e-01f, 4.38629389e-01f, -4.59877849e-01f, 3.29988003e-01f, -5.37171401e-02f, -1.79950550e-01f, -8.71900003e-03f, -2.26148129e-01f,
  -8.74248967e-02f, 7.98000544e-02f, 2.50688016e-01f, 2.40583479e-01f, 1.09406143e-01f, -2.95196503e-01f, -1.32726327e-01f, 1.73534587e-01f, 1.54703721e-01f, 1.24042638e-01f,
  -6.48852646e-01f, -5.69727004e-01f, -3.16661894e-01f, -2.07926765e-01f, -2.36628562e-01f, -1.60431325e-01f, -1.43975750e-01f, -7.52143748e-03f, -2.48808384e-01f, -1.22491412e-01f,
  -2.82859541e-02f, 6.77424520e-02f, -1.20800264e-01f, -3.13009731e-02f, -9.03156400e-02f, 3.59040424e-02f, 3.04019183e-01f, 2.04278380e-01f, 1.41783223e-01f, 1.54377192e-01f,
  2.13275284e-01f, 8.67339149e-02f, 4.95171025e-02f, 5.32817803e-02f, 1.38812885e-01f, 5.98169155e-02f, -1.64348092e-02f, 2.63510179e-02f, -4.81491126e-02f, -5.92203178e-02f,
  7.39664678e-03f, -7.20176548e-02f, 8.38922039e-02f, -3.10780443e-02f, 5.81306592e-02f, 7.08433613e-02f, 1.06817849e-01f, -8.92568678e-02f, -8.64701520e-04f, -4.40821890e-03f,
  1.76623429e-03f, 1.06561044e-02f, -1.56066954e-01f, -9.83103663e-02f, -5.18059358e-02f, -7.29106292e-02f, 1.12297041e-02f, -8.12487751e-02f, 9.13075432e-02f, 5.27515523e-02f,
  -8.08749422e-02f, 8.04162920e-02f, 8.72343183e-02f, 2.10462185e-03f, -3.42985764e-02f, -4.74169031e-02f, -7.33581977e-03f, 8.61199573e-02f, -3.52968760e-02f, -1.18164681e-01f,
  -9.17743504e-01f, -6.97581470e-01f, -1.68517783e-01f, -1.50455907e-01f, -1.40785992e-01f, -3.64676490e-02f, -1.14175312e-01f, -7.02726021e-02f, -1.83809757e-01f, -1.00585446e-01f,
  -8.25612694e-02f, 3.76972035e-02f, -1.19066000e-01f, -3.20644788e-02f, -9.53548681e-03f, -2.01498587e-02f, -1.34767637e-01f, -1.22413903e-01f, -2.00017869e-01f, -2.46631838e-02f,
  8.65598116e-03f, -1.00469239e-01f, -4.05482166e-02f, 3.26573402e-02f, -9.02148411e-02f, -6.31057322e-02f, -1.48434773e-01f, 6.87973127e-02f, -1.09777786e-01f, 7.93384537e-02f,
  4.26749527e-01f, 4.89290744e-01f, 1.08281694e-01f, -7.30768815e-02f, -2.39999756e-01f, -4.28486943e-01f, -4.57159698e-01f, 1.34392768e-01f, -2.35657349e-01f, -1.41260490e-01f,
  3.54788080e-02f, -2.39815235e-01f, 2.84039170e-01f, 3.37327659e-01f, 1.89755455e-01f, 3.41887385e-01f, 2.52377898e-01f, 2.29411423e-02f, 2.45979130e-01f, 4.86545622e-01f,
  3.16970408e-01f, 4.86911327e-01f, 5.68623722e-01f, 3.68382812e-01f, 5.13406217e-01f, 2.55182773e-01f, 2.27384180e-01f, 2.72846948e-02f, -2.08542701e-02f, -2.31950536e-01f,
  2.81032338e-03f, 3.62338126e-01f, 1.28042236e-01f, -1.43212438e-01f, 2.59119719e-01f, 3.55471857e-02f, -1.25898033e-01f, -1.53118357e-01f, -4.11857478e-02f, -3.12015545e-02f,
  -8.59630927e-02f, -7.04845693e-03f, 2.94657834e-02f, 6.55923933e-02f, -9.38774645e-02f, -1.02784365e-01f, 1.89266935e-01f, 1.00161001e-01f, -4.38852236e-02f, 3.69262248e-01f,
  1.44465894e-01f, 3.96865495e-02f, -2.76353490e-02f, -1.30109442e-03f, -7.50841945e-02f, -1.07568607e-01f, -1.48256138e-01f, -6.43441305e-02f, -1.54537022e-01f, -8.57612342e-02f,
  1.40661582e-01f, -5.25071137e-02f, 1.36706173e-01f, -5.74301146e-02f, 1.56904623e-01f, -3.43405046e-02f, -1.08614706e-01f, -6.70170859e-02f, -6.93787560e-02f, 8.27603191e-02f,
  -1.61285177e-01f, 5.45765907e-02f, -7.04520121e-02f, 5.43317124e-02f, 1.27977788e-01f, 3.61861400e-02f, -9.83098745e-02f, 5.23552969e-02f, -3.49311009e-02f, -9.48555942e-04f,
  4.27333452e-02f, -1.41408965e-01f, 3.36589180e-02f, -4.81939800e-02f, -9.38730314e-02f, -5.41936755e-02f, 1.41949132e-01f, 8.13235864e-02f, 4.35143001e-02f, 1.69418124e-03f,
  8.84715617e-02f, 4.90471601e-01f, 2.81845797e-02f, -1.78985208e-01f, -9.52132512e-03f, 9.33270454e-02f, 1.59936585e-02f, 9.26851332e-02f, 2.81307027e-02f, 9.79622453e-02f,
  -1.18957229e-01f, -2.59464353e-01f, -7.60927871e-02f, 3.14829014e-02f, -1.45749137e-01f, 1.09403476e-01f, -5.54678850e-02f, -2.38142669e-01f, -9.73588899e-02f, 2.14833796e-01f,
  5.43763712e-02f, 1.33853853e-01f, -1.60096511e-01f, -1.59490034e-01f, -5.04887253e-02f, -2.10235156e-02f, -1.32774770e-01f, 2.63462272e-02f, 1.91892371e-01f, -2.01793611e-01f,
  2.77590483e-01f, 2.73916721e-01f, -4.46427792e-01f, -2.16983542e-01f, -9.97951180e-02f, -7.64622033e-01f, -3.32306117e-01f, 1.17446221e-01f, 1.33544073e-01f, 2.25284517e-01f,
  9.50196013e-02f, 3.55782390e-01f, 3.75979215e-01f, -1.80911452e-01f, -6.83848917e-01f, -1.60876676e-01f, -5.83905816e-01f, -2.35223532e-01f, 2.90109873e-01f, 9.89485160e-02f,
  -1.67193621e-01f, 2.77930021e-01f, -3.79839391e-01f, 3.67514998e-01f, 1.38400421e-01f, 1.47988841e-01f, -2.26417720e-01f, 3.41176122e-01f, -2.52830654e-01f, 1.35068089e-01f,
  -1.42107857e-02f, 3.51868957e-01f, 3.26590389e-02f, 7.58314952e-02f, -2.69679308e-01f, -1.37017637e-01f, -2.76149303e-01f, -1.20098211e-01f, 9.26259756e-02f, 6.39820844e-02f,
  1.04641095e-02f, 1.63610205e-01f, 1.50486799e-02f, 2.69629031e-01f, 1.48270786e-01f, 9.15049165e-02f, -1.39917463e-01f, -2.83501923e-01f, 5.79679199e-02f, -6.40143827e-02f,
  -1.01079620e-01f, -2.08777264e-01f, -1.13791980e-01f, 9.59968194e-03f, -1.40739679e-01f, 3.20429578e-02f, -1.16945617e-01f, -1.30695224e-01f, -1.21972628e-01f, -4.18621153e-02f,
  1.95381597e-01f, -1.02448454e-02f, -2.85463668e-02f, 8.13032761e-02f, -2.10250709e-02f, -5.91394976e-02f, 1.07898787e-01f, -1.06191576e-01f, 8.04376453e-02f, -1.29493058e-01f,
  -9.07649025e-02f, 4.87804040e-02f, 1.49296537e-01f, -1.21908046e-01f, 2.11305078e-02f, 3.15143950e-02f, 1.26530062e-02f, 1.07327640e-01f, -1.61541238e-01f, -2.37377360e-01f,
  2.59565473e-01f, -3.95379625e-02f, 6.72916993e-02f, -1.01044521e-01f, -2.36401777e-03f, -4.01905831e-03f, 8.16529542e-02f, -7.26392791e-02f, -1.80978432e-01f, -8.27155486e-02f,
  -2.09809318e-01f, 2.93779913e-02f, 8.81378651e-02f, -4.77044508e-02f, -3.94518934e-02f, -2.12242797e-01f, -3.40093113e-02f, -1.26116917e-01f, 2.71744262e-02f, 8.62361342e-02f,
  -6.82134926e-02f, -5.68783022e-02f, -2.86650449e-01f, 2.11755503e-02f, -6.69749230e-02f, -2.67541021e-01f, 7.17054754e-02f, 2.01285090e-02f, -5.26064374e-02f, -8.28336701e-02f,
  1.77502390e-02f, 8.78610089e-02f, -3.34215015e-02f, -1.59768909e-01f, -6.89794570e-02f, -1.14844799e-01f, 3.99200954e-02f, 1.05815627e-01f, 6.60446808e-02f, -8.06451887e-02f,
  4.83253449e-01f, -8.48849118e-01f, 2.52733380e-01f, 4.65386882e-02f, 5.92683077e-01f, 2.99389422e-01f, 4.19050545e-01f, -5.09539247e-02f, -1.97398528e-01f, -7.30770767e-01f,
  8.65693688e-02f, -4.01527047e-01f, -7.14237466e-02f, -2.38081682e-02f, 5.13433516e-01f, 1.08991429e-01f, 2.04209805e-01f, -2.11569369e-02f, 1.38264373e-01f, 1.16756067e-01f,
  2.93010414e-01f, 1.94941685e-01f, 4.55763131e-01f, -1.88086227e-01f, 3.57437879e-01f, -1.52528837e-01f, -2.16852829e-01f, 7.65672773e-02f, -3.24316293e-01f, 8.76883492e-02f,
  2.11664855e-01f, 6.91895112e-02f, 3.77852261e-01f, 7.68655315e-02f, 1.34224027e-01f, 3.85493189e-02f, 1.09528350e-02f, 1.53627485e-01f, 6.84175491e-02f, -3.77519093e-02f,
  -1.20563783e-01f, -4.44438159e-02f, -9.50889438e-02f, 1.48602784e-01f, 7.73566291e-02f, 6.04688050e-03f, -7.74623379e-02f, 3.46183926e-02f, -1.22051716e-01f, 7.06730038e-02f,
  1.84719548e-01f, -1.15780488e-01f, 8.38191807e-02f, -1.88810185e-01f, 4.34640311e-02f, -6.16723411e-02f, -7.85171837e-02f, -2.15782821e-02f, -9.29660425e-02f, -1.39959946e-01f,
  -1.22155994e-01f, 3.55525198e-03f, 3.50031853e-02f, 6.60079643e-02f, 9.05478001e-02f, -3.68999806e-03f, -4.46832217e-02f, 3.14304046e-03f, -7.45767429e-02f, -3.57994325e-02f,
  2.64098309e-02f, -2.20158286e-02f, 9.64898393e-02f, -3.88790406e-02f, 5.18530980e-02f, -6.69058114e-02f, 1.00975148e-01f, -3.57441083e-02f, -5.58570772e-02f, 7.06476048e-02f,
  -1.60485044e-01f, 3.73203456e-02f, 5.87310418e-02f, -7.35989911e-03f, -5.06128743e-02f, 9.39386263e-02f, -4.63608168e-02f, -2.57858366e-04f, 7.37696514e-02f, -7.31304884e-02f,
  -2.09836304e-01f, -6.43913329e-01f, 6.03493936e-02f, -4.00097519e-02f, -2.90776305e-02f, 1.40736371e-01f, 4.18891162e-02f, -9.50474292e-02f, -6.63289353e-02f, 1.04579099e-01f,
  -5.56381196e-02f, -5.79123423e-02f, -5.11574931e-02f, 7.29803145e-02f, -1.36227934e-02f, 7.75368512e-02f, -1.02432504e-01f, -9.03807655e-02f, 2.61989832e-02f, -2.50599742e-01f,
  -1.07945703e-01f, -4.55527157e-02f, -5.04883043e-02f, 7.75343403e-02f, -6.22472689e-02f, -1.33776560e-01f, 8.56012255e-02f, -1.28828853e-01f, -9.15454179e-02f, -1.44104511e-01f,
  -9.12675202e-01f, 7.32320011e-01f, -3.59100811e-02f, -1.89701632e-01f, 5.02145231e-01f, 8.62399042e-01f, 1.32433042e-01f, 3.97894718e-02f, -1.06267877e-01f, -3.18482220e-02f,
  1.02245361e-01f, -1.05719678e-01f, -1.38334394e-01f, 1.83296159e-01f, 5.41383386e-01f, 3.26963544e-01f, 1.37002990e-01f, -2.17312686e-02f, 1.10243604e-01f, -2.31806099e-01f,
  -9.06094238e-02f, 2.98053741e-01f, -1.33083969e-01f, 2.50590801e-01f, -2.83005852e-02f, -2.43126571e-01f, -2.58758515e-01f, 4.73225042e-02f, 1.89994901e-01f, 4.96372968e-01f,
  -7.68246502e-02f, -3.99574012e-01f, -3.20189297e-01f, -1.57838747e-01f, 6.13974268e-03f, -1.58890590e-01f, -3.10890209e-02f, 5.07550687e-02f, -1.91359475e-01f, 1.07648700e-01f,
  -5.56683503e-02f, -3.85389365e-02f, 1.16540091e-02f, 2.50837300e-02f, -6.89289067e-03f, 1.03217259e-01f, -5.27740130e-03f, -1.53237171e-02f, -1.05390109e-01f, 1.65413637e-02f,
  -1.16806943e-02f, 3.60992588e-02f, -7.14531466e-02f, 1.14124574e-01f, 1.00368284e-01f, 1.00866005e-01f, 5.78982010e-02f, 5.44739468e-03f, 8.71002153e-02f, 4.99608926e-02f,
  2.87573114e-02f, -1.45111844e-01f, -6.31807297e-02f, -7.26431906e-02f, 1.02374367e-01f, -2.94813346e-02f, -1.69889525e-01f, 1.03693582e-01f, -6.14142139e-03f, 5.45165762e-02f,
  6.82207569e-02f, -6.40037656e-02f, -1.48717850e-01f, 1.42735392e-02f, -7.74177164e-02f, -8.11222792e-02f, -6.61676079e-02f, 1.00448634e-03f, -3.10006496e-02f, 1.66649260e-02f,
  -4.87967804e-02f, -5.29193087e-03f, 2.05823127e-03f, -1.96461827e-02f, -6.49415702e-02f, 3.94872166e-02f, 1.34621978e-01f, 4.55470867e-02f, 5.24804927e-02f, 5.02406061e-02f,
  5.28989434e-01f, 1.50183231e-01f, 8.34966078e-02f, 1.14988297e-01f, -5.32617653e-03f, 2.80477758e-02f, -5.78604899e-02f, 3.75833064e-02f, 1.93201333e-01f, 3.47316712e-02f,
  -5.39724231e-02f, -1.29263639e-01f, -7.71455616e-02f, -6.50194213e-02f, 6.83922991e-02f, 1.18012853e-01f, -1.83079450e-03f, 5.79788908e-02f, -6.80957746e-04f, 1.13257095e-01f,
  4.42539901e-02f, -8.73087570e-02f, 4.71981271e-04f, 1.45314470e-01f, -1.23380885e-01f, 3.68875340e-02f, -1.15115689e-02f, -3.73364240e-03f, 1.04460873e-01f, -7.99461082e-02f,
  -5.74815989e-01f, 5.44347823e-01f, 2.57850468e-01f, 1.57341193e-02f, 5.23234546e-01f, 6.12593055e-01f, 1.88097760e-01f, 3.53262484e-01f, 4.83012646e-01f, 9.98754427e-02f,
  -1.80399194e-01f, 2.30596870e-01f, -1.04824990e-01f, -1.45807430e-01f, -8.55055004e-02f, 3.67157273e-02f, 1.99316919e-01f, 1.24864906e-01f, 4.31523174e-01f, -1.22714005e-01f,
  -5.40097207e-02f, -1.16993874e-01f, -2.17987567e-01f, 3.28797325e-02f, -1.90458402e-01f, -1.86110154e-01f, -4.46596712e-01f, 4.55115885e-02f, -1.57949198e-02f, 2.74203628e-01f,
  8.68380256e-03f, 7.24767521e-02f, -1.36351809e-01f, -2.16697846e-02f, -1.07274428e-01f, -5.33860130e-03f, -8.55911449e-02f, 5.30838966e-03f, -6.61486611e-02f, 8.72802138e-02f,
  -6.42843693e-02f, -1.93510428e-02f, 9.06296894e-02f, -2.20168307e-02f, 4.06459756e-02f, -1.47544630e-02f, 1.06374457e-01f, 1.11052096e-02f, 1.11144520e-01f, 1.20768666e-01f,
  -2.04740658e-01f, 2.13811379e-02f, -1.24701656e-01f, 6.37003407e-02f, -4.57590856e-02f, 2.22572815e-02f, 8.05388018e-02f, 1.07055791e-01f, 3.18946913e-02f, 2.09532887e-01f,
  -2.26111035e-03f, 2.62686908e-01f, 4.71708477e-02f, 9.63494107e-02f, 1.18628787e-02f, -5.54897226e-02f, -2.21032947e-02f, 2.73429579e-03f, 3.04571316e-02f, -5.91510013e-02f,
  -6.46670386e-02f, 8.14907327e-02f, 6.63970634e-02f, 3.53471227e-02f, -2.55993139e-02f, -4.12306264e-02f, 2.75427592e-03f, 1.40082026e-02f, 7.53190815e-02f, -8.16887766e-02f,
  2.77217403e-02f, -4.41101454e-02f, 5.93901016e-02f, -1.46528259e-02f, -4.85513806e-02f, 7.04710782e-02f, 3.58507261e-02f, 2.40177549e-02f, -7.73675814e-02f, 3.39443125e-02f,
  3.48519176e-01f, 5.97398400e-01f, 9.05013148e-05f, -3.48240845e-02f, 6.11301288e-02f, 1.30427536e-02f, 4.43372168e-02f, 1.01426102e-01f, 1.93039462e-01f, 1.11955948e-01f,
  -3.23356912e-02f, 2.81519480e-02f, -1.01663418e-01f, 6.44023493e-02f, 2.13661809e-02f, 1.16591677e-01f, -1.29045948e-01f, 1.30804047e-01f, 2.08596196e-02f, -4.68522012e-02f,
  -1.40244260e-01f, -8.75214394e-03f, -5.11308573e-02f, -2.89023444e-02f, 5.19351056e-03f, -8.12673494e-02f, 3.93711310e-03f, -1.53784137e-02f, -1.36874812e-02f, 6.60309643e-02f,
  4.98751789e-01f, -1.20148109e-02f, 1.81608275e-01f, 1.05890464e-02f, -4.34415042e-02f, -4.83417034e-01f, -2.55312800e-01f, -4.35483873e-01f, 3.49295698e-02f, -3.39220852e-01f,
  -2.21957371e-01f, 4.58275110e-01f, -3.66192870e-02f, -3.63835216e-01f, -1.18045554e-01f, -1.17959410e-01f, -2.98310190e-01f, 2.30658464e-02f, 1.33565694e-01f, -2.42896020e-01f,
  -1.24073155e-01f, -5.73664486e-01f, -9.00870487e-02f, -5.36285222e-01f, -9.10506770e-02f, 1.45568594e-01f, -1.38851315e-01f, -4.31570821e-02f, -1.62349090e-01f, 1.43367156e-01f,
  -4.68453392e-02f, -8.70773569e-02f, 7.29148090e-02f, -2.29468830e-02f, -1.23938344e-01f, -2.10985988e-02f, 1.31846800e-01f, 6.26834258e-02f, -3.43434326e-02f, -4.71403599e-02f,
  1.60011142e-01f, -4.68238816e-02f, -8.11294466e-02f, 7.97451138e-02f, 3.07217184e-02f, -4.63697463e-02f, 1.93134919e-01f, 3.69868428e-02f, -9.74713564e-02f, 1.56491339e-01f,
  3.74361537e-02f, 1.33547813e-01f, 1.13861583e-01f, 9.87520665e-02f, 7.13925734e-02f, -2.48064604e-02f, 9.93746743e-02f, 1.69092566e-01f, 1.12321764e-01f, -1.45182908e-01f,
  -2.13890776e-01f, 1.52983023e-02f, 4.25581560e-02f, 5.68165183e-02f, -6.36021867e-02f, 1.84927806e-02f, -7.88336843e-02f, 9.12083909e-02f, 1.36377797e-01f, -8.75975639e-02f,
  -1.10669814e-01f, 4.84090205e-03f, -2.84010116e-02f, -1.51011720e-01f, 2.06809733e-02f, 5.02446890e-02f, 8.74367207e-02f, -1.01669226e-02f, -5.84561117e-02f, 2.09847037e-02f,
  4.24286686e-02f, -7.79932514e-02f, -2.61127520e-02f, 6.79955408e-02f, -3.85424383e-02f, 4.85834293e-02f, -1.22859523e-01f, 3.11377030e-02f, -7.42021133e-04f, 1.01513723e-02f,
  -2.31844053e-01f, -6.67290688e-01f, -1.21024519e-01f, -1.33582326e-02f, 8.48092418e-03f, 2.74683889e-02f, -7.96386972e-02f, -5.79782985e-02f, -7.24423900e-02f, -1.82363257e-01f,
  -1.22957397e-02f, 6.95554586e-03f, -5.36547862e-02f, -3.47626060e-02f, -9.85828042e-02f, -9.80192795e-02f, -1.52203562e-02f, 1.34428844e-01f, -5.83987832e-02f, 7.45670274e-02f,
  -3.99241075e-02f, 1.94617212e-02f, 1.03788689e-01f, -2.29935274e-02f, -5.62362261e-02f, 9.42437276e-02f, -2.54487190e-02f, 7.02869222e-02f, -2.22739335e-02f, 4.42507379e-02f,
  3.47109735e-02f, 3.68249685e-01f, 2.23360181e-01f, -4.04663056e-01f, -5.33977330e-01f, -2.13822231e-01f, -2.83187628e-01f, 2.86228001e-01f, 2.29180530e-01f, 3.32839847e-01f,
  -2.74934888e-01f, 5.09203196e-01f, 1.63795635e-01f, -2.90610164e-01f, 2.33695686e-01f, 2.65508592e-01f, -4.02774096e-01f, -2.39198402e-01f, -4.43088152e-02f, -2.12787464e-01f,
  -2.09885374e-01f, -4.62041408e-01f, -3.76950651e-01f, -2.17315167e-01f, -3.65694761e-01f, -1.09706134e-01f, -3.23026508e-01f, -3.55377734e-01f, -1.47520378e-01f, -2.21285909e-01f,
  -1.10905077e-02f, 8.46039578e-02f, 2.76907086e-02f, 2.61487752e-01f, 3.67842871e-03f, -3.81198339e-02f, -4.01981436e-02f, -7.08232522e-02f, 6.75554127e-02f, 1.00794785e-01f,
  1.16941974e-01f, 1.75375342e-01f, 2.85016261e-02f, -9.42763239e-02f, -8.30328986e-02f, 5.36267273e-02f, 8.78110826e-02f, 4.54289615e-02f, 7.69140124e-02f, -1.06343761e-01f,
  5.84320985e-02f, 3.45660783e-02f, -1.49635181e-01f, 1.42375365e-01f, 3.95115316e-02f, 3.81348878e-02f, 5.98986000e-02f, -1.31760478e-01f, 2.81526372e-02f, 4.08658609e-02f,
  -1.59066454e-01f, -7.48316869e-02f, -2.65711383e-03f, 4.89618666e-02f, -4.48391624e-02f, -7.86691904e-02f, 1.31360088e-02f, -8.65177363e-02f, 6.49601445e-02f, -9.85868052e-02f,
  9.17047486e-02f, 9.46033522e-02f, -1.46232486e-01f, 7.16469716e-03f, -2.01604411e-01f, 1.90728128e-01f, -1.36882395e-01f, 1.06807649e-01f, 1.36588141e-03f, 1.32208019e-01f,
  -6.41482249e-02f, -6.14530146e-02f, 4.70583960e-02f, -1.19332492e-01f, -4.92641814e-02f, 1.25474790e-02f, 1.06382392e-01f, -1.95811894e-02f, -1.02140613e-01f, -1.73109740e-01f,
  -2.00382881e-02f, 1.25605896e-01f, 1.46157727e-01f, 2.70525217e-01f, 1.63561422e-02f, -1.37504190e-02f, -1.21224046e-01f, 1.46645233e-01f, -3.62934470e-02f, 3.86077315e-02f,
  5.82902990e-02f, 8.45589265e-02f, 3.77759002e-02f, 3.89187001e-02f, 9.30298641e-02f, -9.23234690e-03f, -1.53927609e-01f, 1.86412975e-01f, -7.84809664e-02f, -6.34191511e-03f,
  -6.01942949e-02f, -1.05883226e-01f, 1.89241692e-01f, -2.42525954e-02f, 1.15152046e-01f, -2.73969211e-02f, 8.99263322e-02f, 1.73915863e-01f, -2.03282818e-01f, 3.68203297e-02f,
  3.70296866e-01f, -3.99892628e-01f, -4.19378519e-01f, -5.75111508e-01f, 2.68490136e-01f, 8.02518606e-01f, 8.10038745e-02f, -2.13835299e-01f, -8.32165658e-01f, -7.92681519e-03f,
  2.15998575e-01f, -3.84866267e-01f, -1.42531157e-01f, -4.00989830e-01f, 6.54642880e-02f, -2.50168562e-01f, 8.92852470e-02f, 1.22035705e-01f, -2.76769757e-01f, 1.66204512e-01f,
  3.15582231e-02f, 1.23517789e-01f, -2.26632506e-01f, 1.67084306e-01f, 1.74512684e-01f, -2.04181718e-03f, 2.96665549e-01f, 3.53600532e-02f, 1.49451226e-01f, -8.38357210e-02f,
  -2.73078289e-02f, -2.08261415e-01f, -7.92763978e-02f, -9.22469571e-02f, 2.16058910e-01f, 2.22181022e-01f, 1.84952870e-01f, -1.26875872e-02f, -7.42095038e-02f, 6.36712983e-02f,
  1.41287535e-01f, -7.99530894e-02f, -1.09901287e-01f, -5.35365306e-02f, -2.67530698e-02f, -1.45003304e-01f, -1.32080436e-01f, -1.63443126e-02f, -1.20285325e-01f, -2.05661617e-02f,
  -1.06459416e-01f, 4.67250720e-02f, 7.09802955e-02f, -9.60262418e-02f, -1.19825400e-01f, -2.08032113e-02f, 1.86690576e-02f, 2.06929222e-01f, 2.50263605e-02f, 1.47631869e-01f,
  1.74742192e-01f, 1.31565541e-01f, 1.09934166e-01f, -1.95888698e-01f, -5.90724126e-03f, -1.07458390e-01f, 6.60134181e-02f, -1.20698795e-01f, -9.86786261e-02f, -1.02466773e-02f,
  -1.52698636e-01f, 6.30448461e-02f, -1.05427921e-01f, 4.10838909e-02f, 9.45046023e-02f, -8.02757684e-03f, 1.39156789e-01f, -5.75092249e-02f, -8.21724385e-02f, -1.37300074e-01f,
  -9.02252048e-02f, -3.96516547e-02f, -5.86766303e-02f, 4.58952300e-02f, 1.20348416e-01f, -3.93311828e-02f, -7.77679086e-02f, 3.08768428e-03f, -1.22084178e-01f, 8.86398740e-03f,
  1.63351387e-01f, 1.94568053e-01f, -1.98532656e-01f, -2.93462593e-02f, -8.96704495e-02f, 2.22567305e-01f, -1.27322525e-01f, -9.50158834e-02f, 4.89404239e-02f, 1.87863018e-02f,
  2.57958859e-01f, -6.19097333e-03f, 6.55897632e-02f, -3.70737202e-02f, 1.18870679e-02f, -7.90800608e-04f, -4.04417813e-02f, -7.85492286e-02f, -1.42047033e-02f, 7.03303493e-04f,
  -2.95638051e-02f, 8.60490948e-02f, -1.38578698e-01f, -1.85085773e-01f, -8.83813128e-02f, 7.86907300e-02f, 8.84740204e-02f, 8.39271322e-02f, 7.67220706e-02f, -1.52738139e-01f,
  6.14498481e-02f, 2.81832486e-01f, 7.81603634e-01f, 1.63705811e-01f, -2.03062594e-01f, 2.32299134e-01f, 3.24034601e-01f, -2.15353295e-01f, -3.67812991e-01f, -7.20044412e-03f,
  -2.42498696e-01f, 4.34319735e-01f, 1.04032874e-01f, -9.95189995e-02f, 1.55577749e-01f, -2.86397457e-01f, -2.84181058e-01f, 2.37989239e-02f, -2.51897931e-01f, 6.07390627e-02f,
  -1.29789263e-01f, -5.78934193e-01f, 3.57919425e-01f, -3.79661858e-01f, 2.76659518e-01f, 2.33861119e-01f, -4.66475993e-01f, 2.17764035e-01f, 4.46532667e-02f, -3.42400596e-02f,
  -1.00036852e-01f, -1.59884378e-01f, 1.11332037e-01f, 1.75256535e-01f, -1.34706888e-02f, 6.15822598e-02f, 2.49980032e-01f, -6.96402714e-02f, -1.68583974e-01f, 1.62164062e-01f,
  4.12250273e-02f, 7.17448592e-02f, -2.05661897e-02f, -1.76037505e-01f, -1.62888154e-01f, 4.14904729e-02f, 6.74627349e-02f, 2.28699103e-01f, 1.81671679e-01f, 1.96863994e-01f,
  2.36580282e-01f, 3.01721156e-01f, 1.10774547e-01f, 3.87184471e-02f, 9.80848223e-02f, -4.78489511e-02f, 7.23794475e-02f, 3.64085853e-01f, 1.89601481e-01f, -1.02475574e-02f,
  7.15187937e-02f, -1.97962821e-02f, 2.05310971e-01f, 2.98268069e-02f, -6.36995435e-02f, -1.82436869e-01f, -8.48072767e-02f, -1.11402452e-01f, 1.42428167e-02f, -1.18598128e-02f,
  -5.54479919e-02f, -3.36477645e-02f, -1.28250659e-01f, -6.22930005e-02f, -1.08876862e-01f, -1.03059657e-01f, 4.68289591e-02f, -5.38301505e-02f, 4.46450897e-02f, 7.94746205e-02f,
  -1.84166983e-01f, -2.93334220e-02f, -2.46249847e-02f, -4.99853492e-02f, 1.89549923e-01f, 1.79628376e-02f, -1.15499511e-01f, 2.31536195e-01f, -2.27683276e-01f, 5.03235422e-02f,
  -4.09684747e-01f, -2.74320990e-01f, -8.87832195e-02f, -7.68810138e-02f, -3.06037739e-02f, 3.57610881e-02f, -8.54084827e-03f, -1.05081107e-02f, -7.19760060e-02f, -9.21630189e-02f,
  5.07323742e-02f, 9.32544395e-02f, 7.16833472e-02f, -8.20912197e-02f, -8.44312236e-02f, -8.06049928e-02f, 1.07345788e-03f, -9.46051441e-03f, 4.42655720e-02f, -1.37466311e-01f,
  3.35709639e-02f, -1.62049785e-01f, -3.54092126e-03f, -8.22839141e-02f, -9.34903696e-02f, 2.98006535e-02f, -8.17757174e-02f, -3.61164589e-03f, 8.91479291e-03f, -3.47946249e-02f,
  -2.51887143e-01f, -5.62990904e-01f, -2.88143277e-01f, 1.09903738e-02f, -2.34980858e-03f, -4.62752581e-01f, -6.03582561e-01f, -7.47359991e-02f, -4.82328951e-01f, -1.96168453e-01f,
  -9.78780165e-02f, -8.81938264e-02f, -5.77448249e-01f, -2.76898384e-01f, 1.07278854e-01f, -5.17931163e-01f, 7.59602934e-02f, -5.65442778e-02f, -1.25275239e-01f, 2.27880925e-01f,
  2.95102000e-01f, 1.17705397e-01f, 2.91369259e-01f, 4.25798625e-01f, 6.93570450e-02f, 5.24237275e-01f, 7.89999247e-01f, 1.84348762e-01f, 6.49493635e-01f, 2.69844651e-01f,
  -1.69584244e-01f, -1.25454754e-01f, -9.02874693e-02f, -9.35007185e-02f, 2.46970251e-01f, 1.01099782e-01f, 4.95012589e-02f, -9.24506485e-02f, 1.04879104e-01f, 4.89297025e-02f,
  -1.48341181e-02f, 1.19469568e-01f, 8.72150958e-02f, -7.26107433e-02f, -3.14101428e-02f, 4.97676097e-02f, 3.66595425e-02f, 6.58994019e-02f, 2.76578944e-02f, -6.50153682e-02f,
  -1.61767140e-01f, -1.13088995e-01f, 1.93277150e-01f, 1.90109164e-01f, 3.29830945e-02f, -7.00921491e-02f, 8.89989063e-02f, 1.05193622e-01f, 1.50455311e-02f, 2.03350976e-01f,
  -2.70959316e-03f, 3.32701616e-02f, -1.26844019e-01f, -1.29199758e-01f, 2.06428077e-02f, -1.02527682e-02f, -6.67972416e-02f, 8.91792700e-02f, 3.03019118e-02f, -7.94135630e-02f,
  1.54509097e-01f, -6.58354629e-03f, -2.89393999e-02f, 1.61893759e-02f, 4.80804741e-02f, -6.66624820e-03f, 4.37951013e-02f, 5.68605140e-02f, 6.31197691e-02f, -6.18924797e-02f,
  -2.07089797e-01f, 1.20988339e-02f, 2.75516082e-02f, -1.11655414e-01f, -1.93409652e-01f, 9.46150813e-03f, 6.30471185e-02f, -1.04125161e-02f, 1.81061937e-03f, 6.51849136e-02f,
  1.13189466e-01f, 2.54710257e-01f, 6.78046197e-02f, -1.80742927e-02f, -2.44238824e-02f, -9.09904670e-03f, -1.74398988e-01f, -4.92891148e-02f, 4.05592285e-02f, 2.97320504e-02f,
  1.81863561e-01f, 1.77885979e-01f, 2.51019765e-02f, 9.70499590e-03f, 2.15666518e-01f, 7.01103061e-02f, 1.49619952e-01f, 2.70545602e-01f, 2.17287421e-01f, 1.28372356e-01f,
  2.64563467e-02f, -6.01923540e-02f, 1.17909439e-01f, 1.12181604e-02f, 1.10881301e-02f, 3.84918861e-02f, 3.46784070e-02f, 1.56460181e-01f, 6.64274618e-02f, 6.38100803e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.91784281e-01f, 5.86945415e-01f, 4.62865144e-01f, 5.72705269e-01f, 4.74192202e-01f, 4.68889296e-01f, 5.77577055e-01f, 6.36689842e-01f, 3.76815408e-01f, 7.51392543e-01f,
  5.61476648e-01f, 5.70969343e-01f, 3.72401357e-01f, 6.72302067e-01f, 2.56808013e-01f, 2.93665916e-01f, 2.49010444e-01f, 3.46967041e-01f, 5.90780258e-01f, 4.63850826e-01f,
  3.16858917e-01f, 5.69431901e-01f, 3.84344697e-01f, 6.58034146e-01f, 5.04935324e-01f, 4.16488618e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.63753712e-01f, -2.29783893e-01f, 2.71458160e-02f, -9.39298198e-02f, -1.27184495e-01f, -8.65268856e-02f, -3.44825424e-02f, 3.32704708e-02f, -5.60009718e-01f, -9.19462666e-02f,
  -1.79981321e-01f, 1.61322411e-02f, -2.07093552e-01f, 4.12922427e-02f, 1.68385580e-01f, 1.75245956e-01f, 2.42246568e-01f, -6.14720583e-02f, -6.75517619e-01f, -4.75630790e-01f,
  4.18702841e-01f, -3.58398736e-01f, -6.92727327e-01f, -8.69501054e-01f, -6.83383197e-02f, -2.12450668e-01f, -3.64526391e-01f, 2.43721306e-01f, 2.39858240e-01f, -3.17659467e-01f,
  -5.33670783e-01f, 3.10620219e-01f, 1.36890471e-01f, -3.41568142e-01f, 5.41450202e-01f, 4.66040708e-02f, -3.63122523e-01f, 1.12223417e-01f, -1.86053544e-01f, -6.38638377e-01f,
  4.52311873e-01f, -2.45897010e-01f, -1.76101089e-01f, -4.06589866e-01f, -3.61131877e-01f, -6.85214996e-01f, 2.16754943e-01f, -4.16719615e-01f, 9.27148610e-02f, 2.60761261e-01f,
  7.62035668e-01f, -3.43476266e-01f, 4.57337320e-01f, 4.75319862e-01f, -5.52114323e-02f, -3.49886179e-01f, -1.97775856e-01f, -5.02312034e-02f, -2.92814940e-01f, -2.63388038e-01f,
  -5.12236595e-01f, -2.36956462e-01f, -3.79937202e-01f, -5.28246582e-01f, 8.97678286e-02f, 4.20681506e-01f, -2.10848719e-01f, -4.08802181e-01f, 2.78831750e-01f, 4.18935299e-01f,
  -6.94399059e-01f, -1.10995062e-01f, -1.76205978e-01f, 3.93928200e-01f, 2.25155145e-01f, -1.13860115e-01f, -2.82928765e-01f, -2.35513449e-01f, -4.38325882e-01f, -2.33887479e-01f,
  -1.65116906e-01f, -7.44293109e-02f, 3.57030302e-01f, 5.79698741e-01f, 9.28533003e-02f, 4.08343703e-01f, 6.70409679e-01f, 4.15426612e-01f, -3.98746915e-02f, -5.59968427e-02f,
  4.26363856e-01f, 3.94454598e-01f, -2.14293823e-02f, 4.30715233e-01f, 7.45331764e-01f, 3.24878067e-01f, 3.17720145e-01f, -3.91082793e-01f, -5.60990453e-01f, 5.46407342e-01f,
  -2.13567335e-02f, 2.24992827e-01f, -4.97312486e-01f, 5.51283397e-02f, 4.61720020e-01f, -4.17481363e-01f, 4.80452664e-02f, -3.59454542e-01f, -7.55861759e-01f, -3.98253262e-01f,
  5.70876062e-01f, -7.43705750e-01f, -4.98986512e-01f, 4.36245762e-02f, -6.13327265e-01f, -4.28238362e-01f, 4.17656362e-01f, -3.89537334e-01f, 3.81460339e-01f, 2.87445992e-01f,
  4.57709916e-02f, 4.53390241e-01f, 2.18641326e-01f, 1.98365804e-02f, -8.58196080e-01f, 4.81366545e-01f, -4.45460081e-01f, -4.11168128e-01f, -3.59333396e-01f, -2.53901303e-01f,
  2.90078789e-01f, -3.25664073e-01f, -2.42655516e-01f, -7.01872706e-02f, 2.65317529e-01f, 1.34972736e-01f, 3.19610648e-02f, -2.50951976e-01f, 1.52505115e-01f, -6.78890646e-02f,
  2.77344078e-01f, 1.46574443e-02f, 1.85631305e-01f, -2.46210590e-01f, -5.16922414e-01f, -1.62780181e-01f, -2.23800272e-01f, 2.78253287e-01f, -2.99880028e-01f, -3.76749277e-01f,
  1.49562985e-01f, 2.95515478e-01f, -4.77312237e-01f, -1.69850752e-01f, 9.42937732e-02f, 1.08181257e-02f, 8.94975141e-02f, -3.14275265e-01f, 2.25760728e-01f, -7.17296004e-02f,
  5.01145720e-01f, -2.46924087e-01f, -2.66714662e-01f, 3.17787260e-01f, 1.83317289e-01f, -5.20555437e-01f, 6.61814272e-01f, -4.27441597e-01f, -5.93831420e-01f, -6.80858016e-01f,
  -4.52005446e-01f, -3.04725379e-01f, -2.68304795e-01f, -2.46155143e-01f, 4.72084403e-01f, -3.42987448e-01f, -2.06719860e-01f, 4.16071951e-01f, -5.90338528e-01f, -5.21185517e-01f,
  -2.62605697e-01f, -3.82296622e-01f, -5.76882124e-01f, -3.63375008e-01f, 1.99868053e-01f, 6.02884404e-02f, -7.63070643e-01f, -2.19011873e-01f, -1.56438932e-01f, 4.98948172e-02f,
  -4.38059121e-01f, 4.47399288e-01f, -1.13536872e-01f, -5.02663672e-01f, -1.96983323e-01f, -2.13432610e-01f, -2.20012069e-01f, -1.28626376e-01f, -6.98098391e-02f, 1.76325515e-01f,
  -1.70814157e-01f, -7.54514560e-02f, -2.48510942e-01f, 4.06716406e-01f, -2.00576521e-03f, -4.44767237e-01f, -1.64086208e-01f, 1.76363915e-01f, -1.68884933e-01f, 8.28169361e-02f,
  -7.20803514e-02f, -4.43441272e-01f, 2.87408143e-01f, -5.18311858e-01f, 6.32881932e-03f, -2.54880875e-01f, -5.24702929e-02f, 2.96662897e-01f, -1.18057624e-01f, -4.30781901e-01f,
  4.13603485e-02f, 8.04890618e-02f, -1.45804077e-01f, -5.50819159e-01f, -2.77128488e-01f, 3.64704996e-01f, 8.71711671e-02f, -3.79197925e-01f, 5.48401065e-02f, 4.23691154e-01f,
  -3.88865739e-01f, -5.74943662e-01f, -7.18962550e-01f, -2.70862412e-02f, 5.53841114e-01f, -5.66642821e-01f, -7.42824554e-01f, 5.37789166e-01f, -4.52868789e-01f, -2.95689911e-01f,
  4.46130216e-01f, -3.10810447e-01f, 1.76210433e-01f, -1.95929587e-01f, -4.34666663e-01f, 4.02764261e-01f, -2.58076519e-01f, 8.14508796e-01f, -4.02192563e-01f, -6.96470439e-02f,
  7.17706531e-02f, -1.25453606e-01f, 5.50930724e-02f, -8.26786757e-01f, -7.18795896e-01f, -8.59146178e-01f, -3.16628516e-01f, 4.17538077e-01f, -2.25178510e-01f, 3.52313250e-01f,
  1.22008901e-02f, -5.89334220e-02f, 1.94366664e-01f, 6.07243888e-02f, 1.50620610e-01f, -2.56588887e-02f, 8.16366300e-02f, -1.52525157e-01f, -8.21430683e-02f, 4.46459830e-01f,
  1.86406504e-02f, -4.25739080e-01f, -4.69659537e-01f, 2.95708060e-01f, 2.35069960e-01f, -3.88643742e-01f, 4.64270473e-01f, -6.07458413e-01f, -2.10716516e-01f, -2.87260697e-03f,
  -3.96611959e-01f, 3.58211011e-01f, -1.13332868e-01f, 5.67024767e-01f, 4.40835297e-01f, -1.97011232e-01f, -2.76115667e-02f, -3.51026297e-01f, -6.14836872e-01f, 2.24154845e-01f,
  4.71311241e-01f, -5.29617250e-01f, 2.96960086e-01f, 1.39056250e-01f, 2.76866227e-01f, -2.95221210e-01f, -2.99509298e-02f, 1.07805364e-01f, -2.35695541e-01f, -7.71815479e-02f,
  4.63792682e-01f, 3.45908135e-01f, -5.87473273e-01f, -9.82217550e-01f, -2.85698801e-01f, 2.88822085e-01f, -6.41092062e-01f, -2.32097059e-01f, -8.52324188e-01f, 6.19437516e-01f,
  2.19820544e-01f, -5.80889583e-01f, 2.50880331e-01f, 4.91916716e-01f, 1.97834417e-01f, -3.50265741e-01f, 3.26425791e-01f, 2.20137224e-01f, 2.82393038e-01f, -4.56703693e-01f,
  3.22223574e-01f, -6.57718554e-02f, 4.30666618e-02f, 4.64396119e-01f, 3.34198475e-02f, -1.99304163e-01f, 1.99884519e-01f, -8.85329247e-02f, 2.81775326e-01f, -2.66539067e-01f,
  1.92219406e-01f, 3.03598642e-01f, 2.47973530e-03f, 2.53230184e-01f, 2.32701406e-01f, 1.98822349e-01f, 1.02730028e-01f, -2.53613573e-02f, 3.63051951e-01f, -2.50770390e-01f,
  -7.44144022e-02f, 3.76793593e-01f, 3.04612130e-01f, 5.06475449e-01f, 5.64448118e-01f, -5.82541943e-01f, -1.35891333e-01f, 2.94517905e-01f, 5.38540006e-01f, 6.47161249e-03f,
  -1.37012988e-01f, -1.18783183e-01f, 3.91640991e-01f, -2.75504977e-01f, 3.68626714e-01f, -1.40266657e-01f, -5.20141542e-01f, 5.34521878e-01f, -6.80108964e-01f, 5.65366000e-02f,
  3.56884688e-01f, -5.68614841e-01f, -7.40471303e-01f, 5.92990875e-01f, 6.27169609e-01f, -4.73240107e-01f, -2.66445816e-01f, 2.71387964e-01f, -1.59023553e-01f, -7.72293746e-01f,
  -1.36051491e-01f, 2.24575341e-01f, 3.16476047e-01f, -5.59511185e-01f, -2.78847575e-01f, -7.61376172e-02f, -5.91215849e-01f, 1.54270664e-01f, 5.17344236e-01f, -7.77899921e-01f,
  3.82098377e-01f, -1.66081116e-01f, -3.49050581e-01f, -2.73353636e-01f, -1.33243471e-01f, -1.63902864e-01f, -2.20927447e-01f, 3.99615951e-02f, 1.39147654e-01f, 1.57714516e-01f,
  2.82286316e-01f, 1.84920341e-01f, -9.43758786e-02f, 3.70964445e-02f, 3.02220464e-01f, -2.56012797e-01f, 1.27756093e-02f, -4.54048514e-01f, -4.82339188e-02f, 1.60553217e-01f,
  1.69686779e-01f, -2.32237466e-02f, -3.60275149e-01f, 6.38473213e-01f, -4.75295603e-01f, 5.60742736e-01f, 4.19240624e-01f, 1.98519260e-01f, 6.01262867e-01f, -4.97291684e-01f,
  -5.06884217e-01f, -5.92052460e-01f, -6.63881123e-01f, 7.57534146e-01f, -5.41721463e-01f, -7.52936423e-01f, 2.36256957e-01f, 5.48711717e-01f, -3.93918127e-01f, -4.87669468e-01f,
  4.90853369e-01f, -4.24459666e-01f, 4.13013369e-01f, 5.19540906e-01f, -1.82137504e-01f, -2.02384114e-01f, -3.73721600e-01f, -1.11705832e-01f, 5.67547865e-02f, -4.80424881e-01f,
  -5.46272933e-01f, 2.29042739e-01f, 1.77127615e-01f, -7.03642011e-01f, -5.05031526e-01f, 4.64346319e-01f, -6.79878742e-02f, -4.04311270e-01f, -1.66876391e-01f, -1.41421169e-01f,
  5.28316617e-01f, -6.72370315e-01f, -1.90979525e-01f, -1.22626513e-01f, -4.64783758e-01f, -4.26135719e-01f, -3.52323145e-01f, -3.57708067e-01f, -3.14501263e-02f, -3.29470098e-01f,
  -2.47102782e-01f, -1.66649505e-01f, -4.13933843e-02f, -5.52076846e-02f, -2.02087000e-01f, -4.77885865e-02f, 9.43126008e-02f, -1.55117020e-01f, -2.27963328e-02f, -6.09241016e-02f,
  2.42716074e-02f, -6.97625801e-02f, -2.97835916e-01f, -1.54023901e-01f, -1.89653113e-01f, -2.41528630e-01f, -9.82336774e-02f, 4.14064169e-01f, 2.17405945e-01f, -3.13223332e-01f,
  -2.88672388e-01f, -1.48629665e-01f, 1.96684122e-01f, 2.35596240e-01f, -3.52461964e-01f, 1.40025802e-02f, 2.40629241e-01f, -3.97137590e-02f, -1.43945038e-01f, -1.55520335e-01f,
  -2.71500319e-01f, -3.93960811e-02f, 1.73493207e-01f, 1.05606288e-01f, -3.47949117e-01f, -1.88024417e-01f, -1.95194453e-01f, 5.19874394e-01f, -3.10488611e-01f, 5.09825110e-01f,
  -4.15896654e-01f, -2.98221350e-01f, -7.74686038e-02f, 1.67887717e-01f, -3.36571395e-01f, 2.79781669e-01f, -4.40439023e-02f, 8.28097314e-02f, 4.67201695e-02f, -6.43749356e-01f,
  -3.08965534e-01f, -5.29252529e-01f, -5.07864617e-02f, 7.57476017e-02f, -7.22289264e-01f, -2.92126358e-01f, -4.03715074e-01f, 5.76096416e-01f, 5.13645351e-01f, -1.09148234e-01f,
  -5.21907508e-01f, 2.44970903e-01f, 1.50233790e-01f, -1.79746926e-01f, 9.73814353e-02f, 2.17457950e-01f, -1.89389139e-01f, -4.50584531e-01f, -2.02974349e-01f, -2.01829106e-01f,
  8.20870802e-04f, -2.24785671e-01f, -3.46186876e-01f, -6.38801530e-02f, -3.65202688e-02f, -1.39767006e-01f, -1.84826806e-01f, -4.91809815e-01f, -2.77651966e-01f, 1.25982836e-01f,
  -2.43471060e-02f, 1.73245426e-02f, -3.59029174e-01f, 6.23093136e-02f, 3.15525413e-01f, 3.38894427e-01f, 4.41370636e-01f, -3.58858444e-02f, 3.43097508e-01f, 6.07268214e-02f,
  -3.65700871e-01f, -4.83556449e-01f, 1.73527136e-01f, -1.94994822e-01f, -4.43414122e-01f, -2.31708258e-01f, -1.48777589e-01f, 1.85970947e-01f, 4.12647516e-01f, 4.98620957e-01f,
  -2.38769427e-01f, -5.71219862e-01f, -1.16759434e-01f, 2.74840921e-01f, -1.14669539e-02f, -1.02136821e-01f, -6.81544244e-02f, -4.25425231e-01f, -3.27625632e-01f, 3.17452282e-01f,
  -5.16096473e-01f, 4.13727432e-01f, 4.10254121e-01f, 3.70018274e-01f, -4.84732032e-01f, -4.26000655e-01f, 6.36288464e-01f, -1.68336127e-02f, -3.82444024e-01f, -6.09101534e-01f,
  -3.32201362e-01f, -4.89553690e-01f, -1.80981889e-01f, -4.14998114e-01f, -1.29121318e-01f, 5.19302249e-01f, 1.43881440e-01f, 8.06499794e-02f, 4.31676030e-01f, -9.23534930e-02f,
  2.87623584e-01f, -8.66791755e-02f, -2.90111266e-02f, 6.39944747e-02f, 1.31201476e-01f, 7.07720742e-02f, -8.13959390e-02f, 1.82192385e-01f, -5.87414615e-02f, 2.10359946e-01f,
  6.25912473e-02f, -6.21738844e-02f, 1.51704609e-01f, -6.06412590e-02f, -1.33947164e-01f, -1.69220492e-01f, -8.79549682e-02f, -2.24347681e-01f, 4.19894725e-01f, -1.56858385e-01f,
  -5.62166095e-01f, 6.45950615e-01f, 8.57048929e-02f, 5.85325241e-01f, -5.77326082e-02f, -6.09130681e-01f, 3.08489740e-01f, 6.87169194e-01f, 4.97867763e-01f, 4.94421780e-01f,
  5.17535627e-01f, 2.46674076e-01f, -6.69327796e-01f, -4.60296690e-01f, -1.05922244e-01f, 5.40634133e-02f, -3.35647821e-01f, 7.10166097e-01f, -5.02658129e-01f, -3.46693158e-01f,
  2.75258839e-01f, -6.51873231e-01f, -6.57602325e-02f, 6.25278771e-01f, 1.71587393e-01f, -7.62214661e-01f, -4.36481774e-01f, -9.41764474e-01f, -4.04927492e-01f, -2.04217628e-01f,
  -7.22879767e-01f, -5.01113534e-01f, 4.99734908e-01f, -2.02064201e-01f, -6.79473102e-01f, 3.16929162e-01f, -6.84794009e-01f, 3.29262018e-01f, 4.93695378e-01f, -5.60036242e-01f,
  2.55809605e-01f, 3.25160623e-01f, 2.11000144e-01f, 2.59084821e-01f, 2.44821534e-01f, 1.35040637e-02f, 1.67514011e-01f, -1.37801068e-02f, 2.34411448e-01f, -6.17855527e-02f,
  1.22237623e-01f, -3.22504401e-01f, 1.15789445e-02f, 2.03966662e-01f, 3.48714292e-01f, 3.14108491e-01f, 1.14379160e-01f, 2.20947474e-01f, 1.66289821e-01f, 1.50276989e-01f,
  3.10791463e-01f, 9.58595425e-02f, -5.14302492e-01f, -5.75336218e-01f, -2.56135166e-01f, -4.88177314e-02f, 7.82561116e-03f, -3.14298660e-01f, -2.75341064e-01f, 3.88582945e-01f,
  5.36271751e-01f, 5.34504712e-01f, -4.11539137e-01f, 1.37540162e-01f, -3.79612416e-01f, 3.74268889e-01f, 1.89290389e-01f, -2.71731228e-01f, -4.96141374e-01f, -2.77421027e-01f,
  -5.24952054e-01f, -5.69207668e-01f, 6.24547303e-01f, 4.96271253e-01f, -2.86167830e-01f, 8.28644931e-02f, -4.83219206e-01f, -4.80566710e-01f, 5.42994738e-01f, 2.79544324e-01f,
  2.64063150e-01f, -1.82763278e-01f, -2.11833656e-01f, -7.48270273e-01f, -6.02288485e-01f, -2.92623132e-01f, -6.18685126e-01f, -2.01777756e-01f, -3.10954273e-01f, -2.50586361e-01f,
  -3.25750649e-01f, 6.25390887e-01f, -2.30142996e-01f, 5.00046194e-01f, -7.23373219e-02f, 7.94283077e-02f, -1.25991747e-01f, -1.40300810e-01f, 1.44401744e-01f, 6.94834962e-02f,
  2.52240211e-01f, -1.37417316e-01f, -4.24563080e-01f, 9.55312401e-02f, -3.79440546e-01f, 5.49988560e-02f, -6.59956113e-02f, 2.54318029e-01f, 2.34096780e-01f, 3.42379808e-01f,
  1.98735148e-01f, 3.60658132e-02f, 2.60437012e-01f, -4.52952862e-01f, -2.30638221e-01f, 4.62850839e-01f, -4.73335445e-01f, 7.54897343e-03f, 6.55040368e-02f, 1.87730089e-01f,
  5.36584735e-01f, -4.35249805e-01f, -1.79825678e-01f, 4.58718449e-01f, -3.89649272e-01f, -3.18343252e-01f, -8.65277797e-02f, -3.56188595e-01f, -5.20332716e-02f, -2.66500115e-01f,
  2.38572478e-01f, -1.75099336e-02f, -3.13321888e-01f, -7.11429238e-01f, -5.89887381e-01f, -1.44969180e-01f, -5.71635127e-01f, 4.90074784e-01f, -6.19201541e-01f, 3.16748410e-01f,
  2.92107403e-01f, 2.12811660e-02f, -5.35146296e-01f, -4.72582668e-01f, -1.14821628e-01f, 6.38402820e-01f, -4.16751862e-01f, -1.33007109e-01f, 2.53685135e-02f, 2.92715076e-02f,
  -6.35953367e-01f, -4.96450454e-01f, 6.66841539e-03f, 5.65052211e-01f, 2.64973849e-01f, -1.05141975e-01f, 5.88438511e-01f, -4.09799457e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.82619666e-02f, -1.30332038e-01f, 1.71757385e-01f, 2.75168233e-02f, 6.78633973e-02f, 2.67615337e-02f, 1.34953737e-01f, -2.00598359e-01f, -1.19756768e-03f, 2.25007366e-02f,
  1.20849743e-01f, 6.94008172e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    