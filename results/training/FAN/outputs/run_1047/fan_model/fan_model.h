/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.96130973e-01f, -1.61174759e-01f, -2.32689649e-01f, 6.37961403e-02f, -2.77979970e-01f, -8.66066441e-02f, -2.31799498e-01f, 1.14031816e-02f, 1.02146022e-01f, -8.18846822e-02f,
  6.75580511e-03f, 2.26910457e-01f, 1.06946506e-01f, 4.66117561e-02f, 6.37053028e-02f, -2.14220211e-01f, -2.00860903e-01f, 7.97693804e-02f, 2.39634216e-01f, 1.50784403e-01f,
  6.19794875e-02f, 6.73049316e-02f, 1.88290760e-01f, 1.85109854e-01f, -1.47671700e-01f, -3.17352102e-03f, -6.33233115e-02f, -1.32734880e-01f, -1.08550996e-01f, -3.09840560e-01f,
  -1.09337881e-01f, -1.38707876e-01f, 3.69633026e-02f, 1.21250772e-03f, -1.63340688e-01f, 3.85294817e-02f, -8.21211655e-03f, 7.55861998e-02f, -7.97899738e-02f, 1.52572431e-03f,
  -1.17735095e-01f, -2.99119744e-02f, -4.41132784e-02f, -1.08305208e-01f, -7.50171989e-02f, -4.07338813e-02f, -3.64211462e-02f, -6.95302635e-02f, 1.98165625e-02f, -4.50220555e-02f,
  -9.26855206e-02f, -1.60666034e-01f, -1.90273792e-01f, -3.68455984e-02f, 1.50840206e-03f, 1.30136020e-03f, -1.79962695e-01f, 2.52812207e-02f, 4.16309759e-02f, -8.67086872e-02f,
  2.35353522e-02f, -4.17046547e-02f, -2.61285044e-02f, -5.23717329e-02f, 3.79796587e-02f, 8.93809050e-02f, -5.25118550e-03f, 4.60303612e-02f, 6.65445775e-02f, 4.11780924e-02f,
  5.02283946e-02f, 4.06955406e-02f, 3.55543643e-02f, 8.24415833e-02f, 3.50824930e-02f, -7.64523074e-02f, 1.25287827e-02f, 9.92172286e-02f, 5.08332364e-02f, 4.17280197e-02f,
  7.36627504e-02f, -1.15205739e-02f, -3.84007618e-02f, 9.28078294e-02f, 3.31411101e-02f, 6.61312789e-02f, -2.81811934e-02f, -1.72246806e-02f, 1.36417132e-02f, 1.20765805e-01f,
  1.24723621e-01f, -9.51992944e-02f, -8.22442621e-02f, -4.27457877e-02f, 4.97775665e-03f, 2.57150568e-02f, -2.29293723e-02f, -8.93697366e-02f, -2.89965272e-02f, -9.59498957e-02f,
  5.44246659e-02f, 7.13482872e-02f, -6.76050335e-02f, -5.32000810e-02f, -2.39870232e-02f, -2.80898921e-02f, -9.05735716e-02f, -6.69838302e-03f, -1.17836736e-01f, -5.75099476e-02f,
  -1.09266520e-01f, 7.50702024e-02f, 3.51820514e-02f, -1.97968520e-02f, -4.76422124e-02f, 6.30940916e-03f, 3.87321832e-03f, -8.35614875e-02f, 3.93985324e-02f, 1.17347255e-01f,
  7.69360483e-01f, -1.94212839e-01f, -1.21527575e-02f, 2.57154942e-01f, -1.11066505e-01f, -3.33039425e-02f, -4.52428758e-02f, 1.33457735e-01f, 1.61745977e-02f, -1.05614915e-01f,
  -1.18647516e-01f, -2.54314333e-01f, -1.88202083e-01f, -2.50074416e-01f, -3.73555603e-03f, 1.91369336e-02f, -1.40335441e-01f, 1.59657840e-02f, 1.45188170e-02f, 5.25930189e-02f,
  -5.30722998e-02f, 1.67036474e-01f, 2.53198892e-01f, 2.65829302e-02f, -8.84006768e-02f, -1.42261371e-01f, -1.26246899e-01f, -1.23828001e-01f, -2.30653211e-01f, -2.30100170e-01f,
  -2.04702511e-01f, 3.78623256e-03f, -1.87558550e-02f, 3.58606838e-02f, -1.00359410e-01f, 8.96943640e-03f, 4.80449386e-02f, -5.31254970e-02f, 3.45519707e-02f, -1.89249066e-03f,
  -6.16759360e-02f, -3.22870798e-02f, -1.38558671e-02f, -6.55184314e-02f, -6.45266101e-02f, -2.21929252e-02f, -8.41142051e-03f, -3.06065986e-03f, 1.60919912e-02f, -6.82351738e-02f,
  -1.78400770e-01f, -3.14219529e-03f, -7.29850447e-03f, -1.12054206e-01f, -1.98068377e-02f, -1.26401946e-01f, -1.50688782e-01f, -3.86818796e-02f, -1.20133668e-01f, 9.56609903e-04f,
  5.52717783e-02f, -1.11857541e-01f, 5.75242005e-02f, 1.84914488e-02f, -1.24985436e-02f, 1.83500946e-02f, -1.26460986e-02f, -1.11772403e-01f, -6.51170090e-02f, 5.16166911e-02f,
  -4.89101447e-02f, -9.51703563e-02f, -2.73010265e-02f, 1.19948443e-02f, -1.70796849e-02f, 1.80397485e-03f, 3.54197435e-02f, -7.51008615e-02f, -2.68864557e-02f, 2.24613454e-02f,
  4.68553929e-03f, -4.53930944e-02f, -2.46051252e-02f, 5.05005606e-02f, -1.18388068e-02f, 3.10230558e-03f, -4.90827449e-02f, -2.97665261e-02f, 1.09214173e-03f, 3.51151191e-02f,
  -9.49231349e-03f, -7.35961348e-02f, 4.59064841e-02f, -2.76241172e-02f, 1.07347243e-01f, 2.11927630e-02f, -1.85913965e-02f, 5.75864948e-02f, -3.07749007e-02f, 7.06966445e-02f,
  2.25135218e-02f, -4.44427654e-02f, 1.82884764e-02f, -4.67315782e-03f, 1.61238424e-02f, -2.07845941e-02f, 3.57887968e-02f, -1.46539183e-02f, -2.94455942e-02f, 2.55842526e-02f,
  7.34513998e-03f, 8.06261450e-02f, 4.93808510e-03f, -7.81961754e-02f, -4.96984422e-02f, 2.34354828e-02f, -3.27257626e-02f, -3.37807946e-02f, -2.54868995e-02f, 1.56145632e-01f,
  1.53314710e-01f, -5.65628588e-01f, 9.81973484e-02f, 5.14539294e-02f, -2.07476214e-01f, -2.50920236e-01f, -5.93633592e-01f, -2.32910216e-01f, 2.38165427e-02f, -1.30226746e-01f,
  1.98101085e-02f, 1.30778208e-01f, 1.92745581e-01f, -1.34404069e-02f, -3.01919710e-02f, -2.80219197e-01f, -9.90618095e-02f, 1.85372561e-01f, 9.60594714e-02f, -1.69983022e-02f,
  -9.69007015e-02f, 2.76667122e-02f, 2.95806408e-01f, 1.31290063e-01f, 2.88280938e-02f, 4.97853868e-02f, 3.17862071e-02f, 9.24750417e-02f, -5.83089478e-02f, 2.43295729e-01f,
  3.09255302e-01f, -1.19641595e-01f, 6.58998564e-02f, -5.13025820e-02f, 6.05871305e-02f, 1.02885924e-02f, -2.10653860e-02f, 6.01535290e-02f, -1.38267856e-02f, 4.20157164e-02f,
  1.11028507e-01f, 1.91540606e-02f, 8.41801912e-02f, 4.67197523e-02f, 5.24104983e-02f, 4.54673693e-02f, 2.03206483e-02f, 6.03678450e-02f, 2.07411274e-02f, -7.47852698e-02f,
  -8.31250846e-02f, -3.79823074e-02f, -7.57020433e-03f, -1.03811778e-01f, -1.68838084e-01f, 6.11780100e-02f, -4.58564982e-02f, 9.14064199e-02f, -5.21373078e-02f, -1.44651942e-02f,
  -4.46388051e-02f, -3.01718693e-02f, -1.82459666e-03f, -4.10853289e-02f, -1.12940997e-01f, 7.18276799e-02f, 1.90615747e-02f, 6.07978217e-02f, -4.56526801e-02f, -8.21224898e-02f,
  2.03163251e-02f, -2.98367981e-02f, -4.51430269e-02f, 5.07438555e-03f, 5.08630499e-02f, 2.57938243e-02f, -4.49071974e-02f, 3.85461487e-02f, -3.71954776e-02f, 2.00535487e-02f,
  6.66424856e-02f, 6.21359646e-02f, -5.54496981e-02f, 1.70199573e-02f, -1.03138618e-01f, 9.58603900e-03f, -6.38376698e-02f, -7.05322251e-02f, -1.34641171e-01f, -4.88270773e-03f,
  -5.32549061e-02f, 1.68034099e-02f, 1.39958233e-01f, -2.22054124e-03f, 4.39586081e-02f, -3.67884487e-02f, -4.16490287e-02f, 1.96886137e-02f, 3.02345250e-02f, 3.42819616e-02f,
  -9.28415284e-02f, 1.69266593e-02f, 7.98105747e-02f, 6.80418536e-02f, 1.08593302e-02f, -1.09473160e-02f, 4.66556288e-02f, 3.81508260e-03f, 1.29086245e-02f, -1.58096049e-02f,
  -5.88966087e-02f, -8.95944312e-02f, -4.30892967e-02f, -1.45571724e-01f, -1.38074327e-02f, -3.64262275e-02f, -6.43911138e-02f, -5.59774227e-04f, -1.17494591e-01f, -1.71595320e-01f,
  4.12965089e-01f, -4.27644551e-01f, -1.94493964e-01f, 8.57032239e-02f, -3.75813752e-01f, -1.11529499e-01f, -4.30736840e-01f, -2.94819735e-02f, -6.77820966e-02f, -2.39055812e-01f,
  -2.48123854e-01f, 1.34415984e-01f, 2.44440581e-03f, 1.03419669e-01f, 1.70283437e-01f, -2.53550559e-01f, -9.56784040e-02f, 9.87940878e-02f, 2.12235704e-01f, 8.35785344e-02f,
  -1.07038118e-01f, 5.65579534e-02f, 2.13205174e-01f, 9.52179581e-02f, -2.69163817e-01f, -7.07528135e-03f, -1.36464387e-01f, -1.75836608e-01f, -7.69123286e-02f, -1.90235272e-01f,
  -1.07821031e-02f, -1.31698325e-01f, -1.07441112e-01f, -1.04822591e-01f, -2.60055155e-01f, -1.55383766e-01f, -2.12863535e-01f, -2.50594765e-01f, -1.80630133e-01f, -1.54183716e-01f,
  -1.32820219e-01f, -1.70634240e-01f, -4.82899919e-02f, -1.62817314e-01f, -1.58970281e-01f, -9.92273465e-02f, -9.74367484e-02f, -6.48560328e-03f, -1.19913109e-01f, -1.49922997e-01f,
  -2.21848428e-01f, -2.64623076e-01f, -2.19773471e-01f, -1.58241361e-01f, -7.48382658e-02f, -1.58364475e-01f, -2.27890685e-01f, -1.85419485e-01f, -2.57065054e-03f, -2.06795201e-01f,
  7.63483346e-02f, 9.18068662e-02f, 3.62190343e-02f, 3.35802957e-02f, 5.82503751e-02f, -1.22628724e-02f, 2.07308792e-02f, 5.82895130e-02f, 1.26871333e-01f, 1.00244418e-01f,
  2.17863154e-02f, 9.89588052e-02f, 4.40104119e-02f, 3.16970833e-02f, 5.78375570e-02f, 7.92569015e-03f, 8.70247409e-02f, 9.76298749e-02f, 7.51070753e-02f, 6.55527115e-02f,
  1.78664997e-02f, 8.84448513e-02f, 8.52671638e-02f, 7.24559044e-03f, -1.00408932e-02f, 3.65370996e-02f, 1.49653703e-01f, -1.08925616e-02f, 1.45769536e-01f, 4.37374637e-02f,
  -9.83201433e-03f, -1.84513539e-01f, -1.16723441e-01f, -8.54595229e-02f, -1.17868729e-01f, -1.76274627e-01f, -3.85608114e-02f, -1.55553564e-01f, -1.50540709e-01f, -7.51654133e-02f,
  -1.02161512e-01f, -1.62507426e-02f, -9.64152887e-02f, -7.94352368e-02f, -9.05245915e-02f, -9.98218432e-02f, -2.12909430e-01f, -1.24328911e-01f, -9.01279673e-02f, -1.89930573e-01f,
  -7.99418986e-02f, -1.39653802e-01f, -8.02884549e-02f, -1.16764985e-01f, -7.80589804e-02f, -8.02334100e-02f, -1.20068319e-01f, -6.86251074e-02f, -7.79625177e-02f, -3.31557482e-01f,
  -2.96272308e-01f, 1.12686746e-01f, 1.30002335e-01f, 8.90224874e-02f, 2.91479588e-01f, 1.59192264e-01f, 1.36983350e-01f, 3.76284830e-02f, -4.46476080e-02f, 2.19567999e-01f,
  2.53524166e-02f, -5.24961669e-03f, -5.16136885e-02f, 1.18959667e-02f, -6.63724840e-02f, 1.70635223e-01f, 1.37420073e-01f, -7.94925168e-02f, -7.87304118e-02f, -4.00973260e-02f,
  1.14126571e-01f, 5.34881689e-02f, -3.03677708e-01f, -9.61683840e-02f, 1.02351025e-01f, 9.72057730e-02f, 9.06646848e-02f, -6.29199110e-03f, 2.03639511e-02f, 2.05509886e-02f,
  5.27658388e-02f, -1.71974331e-01f, -7.34869465e-02f, -3.98351438e-02f, -2.87050207e-04f, -1.75237700e-01f, 1.55188264e-02f, -1.35029912e-01f, -1.36901021e-01f, -8.76933932e-02f,
  -4.05840613e-02f, -1.02061816e-01f, -3.52864116e-02f, -1.18424147e-01f, -7.54966661e-02f, 4.19848552e-03f, -1.17976731e-03f, -6.98359683e-02f, -5.56303980e-03f, -9.63680446e-03f,
  3.82192247e-02f, -6.48576617e-02f, -6.83719739e-02f, 4.46809269e-02f, -1.39259711e-01f, -3.68680954e-02f, -8.32861736e-02f, -1.42142149e-02f, -1.57387823e-01f, -4.47949432e-02f,
  3.57351080e-02f, 3.92747819e-02f, 8.49518925e-02f, -1.63793017e-03f, 3.86152007e-02f, 6.94146827e-02f, -3.40848404e-04f, 4.98960018e-02f, 1.44556612e-02f, -6.07730895e-02f,
  -9.23892576e-03f, 2.78020576e-02f, -1.40817165e-02f, -2.52035987e-02f, 8.77881795e-02f, 9.70310420e-02f, -3.71257141e-02f, -1.31588327e-02f, -8.91130120e-02f, -9.91119146e-02f,
  -2.69210692e-02f, -2.56707496e-03f, 1.84139479e-02f, -8.85955244e-03f, 3.25526819e-02f, 6.20068051e-02f, 5.63826859e-02f, 4.86382544e-02f, 2.02508010e-02f, 9.94047034e-04f,
  8.26251134e-02f, 7.63573404e-03f, 3.71884070e-02f, -1.24160647e-01f, -5.82406903e-03f, -8.15747231e-02f, -8.25325921e-02f, -7.91172534e-02f, -6.74216375e-02f, 1.36678414e-02f,
  -9.04571116e-02f, -7.75127634e-02f, 2.86976695e-02f, 2.32306402e-02f, 3.62409092e-02f, -7.46307448e-02f, 8.28074217e-02f, 3.89956422e-02f, -7.80050978e-02f, 1.08449599e-02f,
  5.37269413e-02f, -4.19516787e-02f, 1.34028792e-02f, 4.94332574e-02f, -1.80867966e-02f, 6.62485436e-02f, 2.56829783e-02f, -1.81910098e-02f, 1.33748315e-02f, 1.04121067e-01f,
  -1.75929770e-01f, 7.02225715e-02f, -2.43019730e-01f, -1.27274960e-01f, -2.82068133e-01f, -1.86161578e-01f, -5.08340001e-02f, 3.12124081e-02f, 5.54148704e-02f, -8.85303766e-02f,
  -6.89880103e-02f, 1.51000664e-01f, 1.75942704e-01f, 1.39133930e-01f, 8.93264264e-02f, -1.35791451e-01f, -1.43347099e-01f, 1.82095845e-03f, -1.09326266e-01f, -1.60856247e-01f,
  -8.30204189e-02f, -1.08665563e-01f, -4.37188568e-03f, 4.50704731e-02f, -2.17596948e-01f, -5.43984734e-02f, -1.08200416e-01f, -1.73388407e-01f, -6.04708083e-02f, -2.41718292e-01f,
  -9.16038752e-02f, -1.11229010e-01f, 8.85088556e-03f, -9.75111593e-03f, 9.71241593e-02f, 6.42638281e-02f, 6.99633062e-02f, 3.25465314e-02f, 7.64591945e-03f, 3.45590152e-02f,
  2.90317535e-02f, 8.72019678e-02f, -2.68353280e-02f, 1.07450008e-01f, 2.54597180e-02f, -2.61592008e-02f, 1.91255718e-01f, 1.51955253e-02f, 1.01886384e-01f, 1.59572903e-02f,
  -1.69951111e-01f, 2.04241183e-02f, 4.02988270e-02f, -3.58335152e-02f, 5.37124462e-02f, -5.78258857e-02f, 3.93717065e-02f, 6.44887462e-02f, 5.64438440e-02f, 1.39997870e-01f,
  -1.71559587e-01f, -3.53820324e-02f, 5.21523990e-02f, 4.94922977e-03f, 1.62050024e-01f, 5.16324630e-03f, 2.34619901e-02f, 9.64002162e-02f, -6.67231902e-02f, -2.51174513e-02f,
  2.85298973e-02f, -4.16006595e-02f, -3.80516462e-02f, -8.84029120e-02f, -4.58534062e-02f, -4.74558100e-02f, 3.66866998e-02f, -5.85481385e-03f, 7.68734217e-02f, 5.94439134e-02f,
  -3.83185595e-03f, 4.22339002e-03f, 9.28806234e-03f, 7.61874542e-02f, -3.59089822e-02f, 1.94052011e-02f, -9.38421860e-02f, 4.25674245e-02f, 5.32376692e-02f, 2.58990154e-02f,
  1.19622201e-01f, 2.53893137e-01f, -4.54129055e-02f, 1.27760097e-01f, 3.04255132e-02f, 1.14670075e-01f, 4.51593436e-02f, 1.72719523e-01f, 4.25583832e-02f, 4.69365530e-02f,
  2.26161312e-02f, 1.36749223e-02f, -1.65545400e-02f, 2.85981945e-03f, -8.10118094e-02f, 5.70649430e-02f, 6.97844625e-02f, 2.68154591e-02f, 3.04996828e-03f, 1.93852820e-02f,
  4.72810343e-02f, 9.68931839e-02f, 1.15329830e-03f, 1.25980079e-01f, -4.54361923e-02f, -3.03768516e-02f, -3.55375977e-03f, -1.82847027e-02f, -3.80520821e-02f, 1.64796114e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.76553226e-01f, 1.09389938e-01f, 6.39762640e-01f, 1.05862387e-01f, -3.30111571e-02f, 2.63589412e-01f, 2.58080035e-01f, 1.73314348e-01f, 2.84296479e-02f, 2.12840252e-02f,
  -5.05883321e-02f, -2.93233842e-01f, -3.97570550e-01f, -2.25308523e-01f, 1.01390600e-01f, 1.86913103e-01f, 1.41310573e-01f, 1.74408615e-01f, 2.82698452e-01f, 9.30597186e-02f,
  -2.14873284e-01f, 4.08431962e-02f, 2.07513556e-01f, 5.91822863e-02f, -9.53676999e-02f, -1.50048867e-01f, 1.17847644e-01f, 1.27679575e-02f, -7.07730129e-02f, 1.23681352e-01f,
  7.25547746e-02f, 3.42774570e-01f, -1.58785433e-01f, -2.07218677e-01f, -5.77041954e-02f, -2.64899712e-02f, -9.75142270e-02f, -5.89923672e-02f, -8.86745751e-02f, 7.91896805e-02f,
  2.15764064e-02f, -1.12839371e-01f, -1.10208891e-01f, 8.86530522e-03f, 4.95271347e-02f, -6.02687895e-02f, 1.92517266e-02f, 1.34690076e-01f, 5.51776886e-02f, 1.77868064e-02f,
  -1.81589097e-01f, -5.23541123e-02f, 6.65337667e-02f, 2.53248420e-02f, 3.38854380e-02f, -6.79172724e-02f, 8.90632644e-02f, -3.55740860e-02f, 8.24144706e-02f, 1.14072420e-01f,
  -1.38250962e-01f, -1.33937141e-02f, 6.41509220e-02f, 4.94955555e-02f, 1.46420514e-02f, 1.38187528e-01f, -8.25153738e-02f, 9.40761268e-02f, 8.19278602e-03f, -7.05622062e-02f,
  -6.10620044e-02f, 9.28945392e-02f, 6.55469892e-04f, 1.22241611e-02f, -7.05090538e-02f, 7.80908018e-02f, 1.12557493e-01f, 5.01733944e-02f, -7.89994001e-02f, -1.75987929e-02f,
  -6.90296367e-02f, 7.36546665e-02f, 4.64282222e-02f, 2.18820758e-03f, -4.16487083e-03f, 6.04184680e-02f, 1.91873703e-02f, -1.34864286e-01f, -1.07476287e-01f, 7.90893212e-02f,
  -5.46687603e-01f, -1.07557483e-01f, -8.25022459e-02f, -9.58457515e-02f, 3.44445594e-02f, -7.40157738e-02f, -4.54846658e-02f, -6.29619509e-02f, 5.16238101e-02f, -2.70385984e-02f,
  5.56370802e-02f, -1.91066470e-02f, -3.09988596e-02f, 2.07389686e-02f, 7.47221783e-02f, -4.29368839e-02f, -6.65880367e-02f, 5.46400482e-03f, -6.31310567e-02f, 8.20349827e-02f,
  -1.19140230e-01f, 6.62391959e-03f, -6.60834014e-02f, 6.87163919e-02f, -9.24215317e-02f, -2.05987737e-01f, -6.42487630e-02f, 1.79252774e-03f, 6.66706413e-02f, -1.02425992e-01f,
  -4.53830548e-02f, -3.78434539e-01f, -2.34011948e-01f, -5.06838560e-01f, -2.73198545e-01f, -1.92518666e-01f, 8.14250335e-02f, -2.84846842e-01f, -4.31861043e-01f, -2.12770686e-01f,
  -2.64398307e-02f, 2.93956399e-01f, 2.63977051e-01f, 5.63256294e-02f, 3.29085946e-01f, -1.29765093e-01f, -2.27658689e-01f, 1.88279837e-01f, 3.59310061e-01f, 1.73911273e-01f,
  6.74931705e-03f, -4.21105437e-02f, -7.59850219e-02f, -1.10777959e-01f, -1.67758346e-01f, 1.27388984e-01f, -1.16361424e-01f, -2.79673427e-01f, -4.25917171e-02f, -3.65821362e-01f,
  3.32566947e-01f, -2.29867727e-01f, -1.92033891e-02f, -2.81066950e-02f, 4.41806566e-04f, 4.27184924e-02f, -6.05969504e-02f, -2.30434477e-01f, -6.08408675e-02f, -2.07129300e-01f,
  -1.14262775e-01f, 4.81851920e-02f, 1.86623603e-01f, 1.17032854e-02f, 2.11513788e-03f, 6.04466200e-02f, -7.97457770e-02f, -1.22741461e-01f, -7.73878917e-02f, 1.39964083e-02f,
  3.33350226e-02f, -3.63230915e-03f, -8.77524316e-02f, 1.59091000e-02f, -5.21373302e-02f, 3.73203307e-02f, -7.68295228e-02f, -1.44949466e-01f, -9.39898659e-03f, -2.38244921e-01f,
  -1.18308313e-01f, 6.03595935e-02f, -2.69189738e-02f, 3.95115875e-02f, -6.21463498e-03f, 5.88752143e-02f, 7.16223195e-02f, 4.59897108e-02f, 8.27470049e-02f, 1.62905883e-02f,
  -3.43309827e-02f, -5.06430194e-02f, -2.14407481e-02f, -4.45194021e-02f, 5.53709678e-02f, 5.09092119e-03f, -6.22604936e-02f, -1.29083069e-02f, -1.51675884e-02f, -4.62137498e-02f,
  -5.04080802e-02f, -1.20641835e-01f, -8.39862321e-03f, 6.48862794e-02f, -7.84628689e-02f, -6.57977313e-02f, 3.74473408e-02f, 6.52077347e-02f, 1.67530918e-04f, 5.05215488e-03f,
  2.16504917e-01f, -3.84731106e-02f, -1.13387264e-01f, 6.82466105e-02f, 9.11641568e-02f, -1.39874250e-01f, -4.58801836e-02f, -9.37392190e-02f, -1.58272032e-02f, -8.13124608e-03f,
  -1.00416020e-01f, 1.22982815e-01f, -1.78559758e-02f, -5.04820086e-02f, 5.07764257e-02f, 1.97185390e-02f, -3.90677862e-02f, 1.75392538e-01f, -2.61724573e-02f, -7.03202039e-02f,
  -1.52461365e-01f, 1.15646720e-01f, 2.05589294e-01f, 2.12376714e-01f, -7.13133588e-02f, 3.16109002e-01f, 1.87764034e-01f, -4.93443273e-02f, 2.87810206e-01f, 1.10646151e-01f,
  5.85160330e-02f, -7.28282239e-03f, 5.21300361e-02f, 4.23819184e-01f, 4.12472099e-01f, -1.01066448e-01f, -4.50680792e-01f, -2.41158649e-01f, 1.78189710e-01f, -1.18699512e-02f,
  3.18000972e-01f, 2.41030455e-01f, 3.86241414e-02f, -1.74696505e-01f, -7.39322841e-01f, -3.90980601e-01f, -1.71329618e-01f, -3.53667915e-01f, -4.45772052e-01f, -3.78624648e-01f,
  -1.46346157e-02f, 2.04312857e-02f, -1.38590977e-01f, -6.37029037e-02f, 1.66295663e-01f, 1.13007315e-02f, 1.30121738e-01f, 5.12660630e-02f, 6.57099020e-03f, 2.36309305e-01f,
  2.60644525e-01f, 6.50566220e-02f, -5.18359281e-02f, 8.91046673e-02f, 5.06585836e-02f, 7.19684064e-02f, -1.03685990e-01f, -1.04999430e-01f, 6.35856763e-02f, -2.71302485e-03f,
  2.00237796e-01f, -6.51865229e-02f, 3.40435803e-02f, 1.28896862e-01f, -1.36813134e-01f, -2.01005071e-01f, -6.92777559e-02f, -2.41832420e-01f, -2.91284889e-01f, -9.70295668e-02f,
  -8.40269029e-02f, 1.34631793e-03f, -1.56824157e-01f, -1.75849617e-01f, -2.09178165e-01f, 1.81012869e-01f, -7.40977153e-02f, -1.31153809e-02f, -1.81837514e-01f, -1.24009669e-01f,
  2.01764498e-02f, -5.77479713e-02f, 4.38796356e-02f, -6.29220009e-02f, 1.17191169e-02f, 7.60217458e-02f, 1.33071482e-01f, 5.36637604e-02f, -2.40628067e-02f, 3.71608604e-03f,
  1.15759715e-01f, -4.93585803e-02f, -7.04210028e-02f, 4.09602858e-02f, 5.99554973e-03f, -2.37157606e-02f, 3.95252854e-02f, -9.59058031e-02f, -1.23731554e-01f, 6.82155639e-02f,
  -5.30575067e-02f, 7.01130331e-02f, 1.21382050e-01f, -3.60881910e-02f, -5.09423837e-02f, -1.22859962e-01f, 3.35870534e-02f, -3.63990106e-02f, -9.08876117e-03f, 3.36151533e-02f,
  2.99195439e-01f, -8.36180151e-02f, -5.19716963e-02f, -9.98061821e-02f, -1.14222653e-01f, 1.11170541e-02f, 1.63463533e-01f, -9.76401195e-02f, 8.88426080e-02f, -1.37184663e-02f,
  -6.88671395e-02f, -1.48072794e-01f, 1.77068844e-01f, 1.90510191e-02f, -1.02143295e-01f, 1.60860106e-01f, -1.29204512e-01f, 3.88227366e-02f, -8.66575241e-02f, 2.55517721e-01f,
  -1.16068363e-01f, -2.71394938e-01f, -1.59148946e-01f, -7.54839331e-02f, 8.77181590e-02f, -3.15807387e-02f, -1.37511734e-02f, -4.32539843e-02f, -4.08363789e-01f, -1.89969435e-01f,
  -3.07950974e-01f, -4.29670542e-01f, -2.74035484e-01f, -1.23375021e-01f, -1.89178996e-02f, 2.32816637e-01f, 7.08896518e-02f, 1.57987744e-01f, -5.01014963e-02f, -2.79936969e-01f,
  1.71246622e-02f, 3.38396132e-02f, -2.19496548e-01f, -3.35986950e-02f, 1.43093793e-02f, -2.50824451e-01f, -3.80367607e-01f, -2.12100312e-01f, 2.85099804e-01f, 6.46116912e-01f,
  3.54021102e-01f, -3.51883508e-02f, 1.57306209e-01f, 1.74202740e-01f, -2.15347111e-01f, -7.94848725e-02f, -2.59923995e-01f, -1.26293167e-01f, -4.94252658e-03f, -4.64013577e-01f,
  -3.21153998e-01f, 1.11263625e-01f, 8.87757838e-02f, 2.29383465e-02f, -6.50540069e-02f, 3.26602384e-02f, -9.77030694e-02f, -1.38648421e-01f, 2.19346676e-03f, 2.50295475e-02f,
  8.49416703e-02f, 2.32353330e-01f, -3.77029786e-03f, 1.24561653e-01f, -2.28451490e-02f, 6.53776005e-02f, 1.13299312e-02f, 3.69713381e-02f, -1.17695801e-01f, 6.56457618e-02f,
  5.75409345e-02f, -5.98263852e-02f, 5.51173883e-03f, 1.49542257e-01f, -1.14270700e-02f, -1.26067862e-01f, -5.62778600e-02f, 5.04311435e-02f, -8.05673674e-02f, -3.17166477e-01f,
  -7.09674954e-02f, -1.36634216e-01f, -9.66382995e-02f, 9.54056382e-02f, 2.81117838e-02f, -5.31761721e-02f, -1.10091075e-01f, 5.16201109e-02f, 3.72537374e-02f, -4.79182974e-02f,
  6.83670416e-02f, -3.04630306e-02f, -1.53768333e-02f, -9.24390834e-03f, -3.67845185e-02f, 4.33635674e-02f, -3.87930423e-02f, -9.11336392e-02f, -1.35785770e-02f, 3.87973860e-02f,
  1.66758552e-01f, -6.79411143e-02f, -1.41673954e-02f, 1.67849898e-01f, -1.19732216e-01f, -2.79459972e-02f, 1.05821952e-01f, 1.27736539e-01f, -9.20473505e-03f, 2.17558548e-01f,
  -1.87114462e-01f, -4.48688008e-02f, -3.00579131e-01f, 1.20013513e-01f, 1.20453477e-01f, -6.62975833e-02f, -2.15734601e-01f, 1.08694255e-01f, -3.92987691e-02f, 1.04759507e-01f,
  7.16839582e-02f, -7.88336992e-02f, -1.40835643e-01f, 4.21011671e-02f, 8.26605037e-02f, 1.67944372e-01f, -7.74677098e-02f, 9.00782365e-03f, 1.18293546e-01f, -9.99789089e-02f,
  -2.24221915e-01f, 1.60232726e-02f, -8.88064653e-02f, -1.08406104e-01f, -1.20754182e-01f, -5.69710247e-02f, -7.51526579e-02f, -2.09376048e-02f, -8.50671679e-02f, -2.06383273e-01f,
  -3.25621665e-01f, -4.04810399e-01f, 1.13712223e-02f, -2.66166385e-02f, -2.71552145e-01f, -2.62438476e-01f, -5.70681095e-01f, 3.72898765e-02f, 6.88243136e-02f, -4.81511652e-01f,
  -2.74688751e-01f, -1.37642846e-01f, 1.01483092e-01f, -1.90214999e-02f, -2.47618571e-01f, -4.82832491e-01f, -1.10181384e-01f, 4.37949933e-02f, -1.76232859e-01f, -3.12251747e-01f,
  -2.51416713e-01f, -1.29306242e-01f, 9.55442041e-02f, 1.14780001e-01f, -1.12305224e-01f, -7.21111894e-02f, 1.82775050e-01f, 6.82224482e-02f, -3.29319425e-02f, -8.57430249e-02f,
  -3.63061398e-01f, -3.67894396e-02f, 9.85093266e-02f, -1.38555378e-01f, -1.35526866e-01f, -1.28081858e-01f, -7.63909593e-02f, -5.89630231e-02f, 5.07425070e-02f, -6.87612519e-02f,
  -7.97584578e-02f, -2.34584466e-01f, 1.09426361e-02f, -6.60588965e-02f, -9.62130353e-03f, -9.96218771e-02f, 2.61960417e-01f, -7.13239536e-02f, -3.84339108e-03f, -1.56127229e-01f,
  -1.79530516e-01f, -2.35977054e-01f, -5.95288500e-02f, 1.68550342e-01f, 3.92098585e-03f, 1.72459111e-01f, -4.88316901e-02f, -9.56856310e-02f, 1.62370384e-01f, -2.35535949e-01f,
  1.73311606e-02f, 1.65627729e-02f, -2.02515982e-02f, 1.02076102e-02f, -4.74545620e-02f, 1.34854168e-01f, 1.31048113e-02f, -2.25346419e-03f, -1.80847626e-02f, 2.36047022e-02f,
  1.67708367e-01f, -9.70366448e-02f, -1.89265534e-02f, 1.62447784e-02f, 1.06109254e-01f, 5.38999923e-02f, -3.50302570e-02f, -1.19679168e-01f, 3.04387156e-02f, -1.54822925e-02f,
  -6.69813082e-02f, -3.03221587e-02f, 1.25043401e-02f, -1.76003166e-02f, -6.23091757e-02f, -1.38581917e-01f, -1.08786143e-01f, -1.22902267e-01f, 1.26079451e-02f, -1.41484365e-01f,
  2.84223165e-02f, 2.20879674e-01f, -2.01107323e-01f, -2.57724553e-01f, 8.92131999e-02f, 9.16602239e-02f, -1.50902411e-02f, -6.16797283e-02f, 1.16573773e-01f, -1.70903802e-01f,
  -2.09323570e-01f, -3.41779217e-02f, 5.21865562e-02f, 3.11559178e-02f, 1.56953931e-01f, 1.26323877e-02f, -1.76006749e-01f, -9.59594250e-02f, 1.09926146e-02f, 8.19469690e-02f,
  5.57046309e-02f, -2.71076679e-01f, -1.79130569e-01f, 6.91201985e-02f, 1.27571955e-01f, -6.41526431e-02f, -4.32518385e-02f, 7.44957402e-02f, 3.32149863e-02f, -1.34191662e-01f,
  -9.05561894e-02f, 3.81861664e-02f, 2.61194229e-01f, 2.21587121e-02f, 3.43595803e-01f, 2.98456609e-01f, 4.83614385e-01f, 1.55933231e-01f, -9.54987630e-02f, 5.31581277e-03f,
  -8.73049721e-02f, -3.30935627e-01f, -4.06575412e-01f, -2.72006094e-01f, -7.68474117e-02f, 1.91184804e-01f, 1.52216792e-01f, 2.24219635e-02f, -1.06251992e-01f, -1.11696295e-01f,
  -1.18257500e-01f, 8.45861901e-03f, -1.20928511e-01f, -2.86053747e-01f, -1.32384464e-01f, -2.31186226e-01f, 1.65188223e-01f, 6.34616464e-02f, -5.67018054e-02f, -2.15109751e-01f,
  -1.20806389e-01f, 3.12374771e-01f, -2.50265539e-01f, -2.38737538e-01f, -6.30128533e-02f, -9.12668258e-02f, 6.99749812e-02f, 1.04994006e-01f, 2.72513507e-03f, 5.27104251e-02f,
  5.75804245e-03f, -3.29170488e-02f, 1.04675174e-01f, 9.93226618e-02f, 1.41710207e-01f, 3.00670732e-02f, -1.43261820e-01f, 2.55427454e-02f, -5.59611293e-03f, -5.17577566e-02f,
  -1.28593341e-01f, 8.43660533e-02f, 7.59148970e-02f, 3.93934846e-02f, -4.59477343e-02f, -2.42487211e-02f, 8.59953389e-02f, -3.27176973e-02f, -6.74958378e-02f, -1.24854311e-01f,
  -1.98166892e-01f, 7.23954588e-02f, 8.84136483e-02f, 1.52962934e-02f, 1.27886742e-01f, 1.63476989e-02f, -2.46405210e-02f, 1.55091241e-01f, 7.64304474e-02f, 4.56630178e-02f,
  1.08010165e-01f, -1.58154350e-02f, 2.28340745e-01f, 2.25104064e-01f, -4.72617485e-02f, 2.73289233e-02f, 1.54321706e-02f, 1.24102170e-02f, 1.24537706e-01f, 8.48583803e-02f,
  2.49522422e-02f, 1.64701283e-01f, 3.62717398e-02f, 1.13869078e-01f, 1.04749396e-01f, 3.10753798e-03f, 3.12073925e-03f, -6.23578089e-04f, 1.38637289e-01f, 7.18514100e-02f,
  -2.35966668e-02f, 2.30203241e-01f, -2.02631935e-01f, -2.66181901e-02f, 2.10890427e-01f, -2.72631943e-02f, 3.22429405e-04f, 2.96221692e-02f, 1.19956665e-01f, 4.21095192e-02f,
  6.63534179e-02f, 9.17043630e-03f, 3.99045907e-02f, 6.47269785e-02f, -2.77524348e-02f, 5.60171120e-02f, -1.04198791e-01f, 6.05873801e-02f, -5.40581346e-03f, -4.47996631e-02f,
  -5.17086647e-02f, 6.94103464e-02f, -3.65303969e-03f, 7.41319582e-02f, 6.48052990e-03f, -1.48976976e-02f, 1.54802591e-01f, 1.33727148e-01f, 7.87636563e-02f, 8.34575971e-04f,
  1.79574057e-01f, -5.16430885e-02f, 4.03886348e-01f, 7.82275647e-02f, -3.25314820e-01f, -6.63234353e-01f, -7.89535940e-01f, -5.22890151e-01f, -1.40161574e-01f, 9.00061876e-02f,
  -1.47281766e-01f, -8.09373781e-02f, 1.35844722e-01f, 2.41288892e-03f, -5.82032166e-02f, -3.87931801e-02f, 2.01594308e-01f, 1.80628210e-01f, -6.04618900e-02f, -2.54003465e-01f,
  -9.37561616e-02f, 2.02141181e-01f, 3.23932499e-01f, -2.09591854e-02f, 1.21843055e-01f, -3.35844862e-03f, 1.92156777e-01f, 3.53708118e-01f, 1.69277370e-01f, 5.03049731e-01f,
  3.18058789e-01f, 2.65368849e-01f, -1.95042700e-01f, 1.27749871e-02f, 1.57006472e-01f, -5.05903736e-02f, -9.95278731e-02f, 3.20084512e-01f, -2.60402150e-02f, 1.73983738e-01f,
  -2.86701042e-02f, -6.53156266e-02f, 1.23298950e-01f, -1.07138686e-01f, -1.60785124e-01f, -8.96745026e-02f, 5.53922765e-02f, 1.46063164e-01f, 1.49848685e-01f, -1.22604750e-01f,
  -1.27402902e-01f, -4.69429791e-02f, -1.41338753e-02f, -3.59191656e-01f, 5.54449670e-02f, 6.90681711e-02f, -9.44830924e-02f, 5.67277037e-02f, 2.70876586e-02f, 1.38533294e-01f,
  -6.49467334e-02f, 1.03010453e-01f, 5.84299618e-04f, -7.12578222e-02f, -2.59023681e-02f, -8.40277895e-02f, 6.84234425e-02f, 5.46103381e-02f, -2.83422936e-02f, 7.28723034e-03f,
  -1.43201053e-01f, -9.72316042e-02f, -2.18272395e-02f, 9.03556868e-03f, 1.69443637e-02f, -2.83542294e-02f, -9.29513127e-02f, 6.60838261e-02f, 5.02912030e-02f, -7.56656677e-02f,
  9.28975344e-02f, 2.11822521e-02f, 9.42705423e-02f, 7.54925609e-03f, -9.67760643e-05f, 8.92869309e-02f, -2.51496304e-02f, -1.18203377e-02f, 1.60509869e-01f, 8.19269121e-02f,
  -1.75647870e-01f, -1.43950313e-01f, -7.81132281e-02f, -3.54347862e-02f, 8.62122923e-02f, 4.70369821e-03f, -9.98475328e-02f, -7.08918506e-03f, 1.26075283e-01f, 2.04173736e-02f,
  -1.90096453e-01f, -1.14621453e-01f, -9.48458537e-02f, -7.14194402e-02f, -7.30602890e-02f, -5.14794104e-02f, -8.79358426e-02f, -6.18378259e-02f, -7.25973994e-02f, -6.49362952e-02f,
  -1.12338871e-01f, -3.20259869e-01f, -3.75444263e-01f, -1.75345019e-01f, -2.50073820e-02f, -2.51557320e-01f, -1.56112298e-01f, -1.82875186e-01f, -3.34858239e-01f, -3.66415024e-01f,
  -2.58119881e-01f, -2.51880169e-01f, -3.97729814e-01f, -1.27634108e-01f, -2.18591794e-01f, -1.49273455e-01f, -5.06922364e-01f, 8.98715705e-02f, 1.30885720e-01f, -3.74178290e-01f,
  -2.11954027e-01f, -2.75110658e-02f, -9.26341116e-02f, -6.52948096e-02f, -2.12870523e-01f, -3.79602969e-01f, -4.03782427e-01f, -4.33181226e-01f, -2.80372590e-01f, -7.89422393e-02f,
  -2.77622372e-01f, -2.69187629e-01f, -1.37286047e-02f, -5.19996509e-02f, -1.10856101e-01f, -1.69018134e-02f, -4.02272418e-02f, -8.19173232e-02f, -7.83387199e-02f, -1.54194534e-01f,
  -2.27466151e-01f, 1.26391813e-01f, 1.35043459e-02f, 1.04154786e-02f, -6.68587014e-02f, 8.26748088e-02f, -1.83475688e-01f, -2.23757830e-02f, 1.75614655e-01f, -6.45035086e-03f,
  4.00136672e-02f, -8.73325765e-03f, -5.53682819e-02f, 1.11653535e-02f, 4.44498248e-02f, 6.30624741e-02f, 2.93599982e-02f, 1.78153533e-02f, 4.56549489e-04f, 2.00005285e-02f,
  9.47515443e-02f, 1.09356053e-01f, 2.31533676e-01f, 1.65085152e-01f, 1.69455975e-01f, 4.22676243e-02f, 1.57830402e-01f, 2.24456012e-01f, 2.16990292e-01f, 2.48004898e-01f,
  -6.70793429e-02f, 7.82795697e-02f, -6.93219481e-03f, 3.10017169e-03f, 2.71955319e-02f, -8.08262378e-02f, -1.60589349e-02f, -1.48178339e-02f, -8.39908421e-02f, 4.13010418e-02f,
  2.09292583e-02f, -1.05500363e-01f, 2.41686814e-02f, -1.08882070e-01f, -7.58233294e-02f, 4.31036092e-02f, 4.09228988e-02f, 3.01133990e-02f, 1.83917075e-01f, 9.15803313e-02f,
  9.72773731e-02f, 6.06542565e-02f, -1.11973211e-01f, 1.52195832e-02f, -2.31886152e-02f, 2.06145309e-02f, 1.12782657e-01f, 3.74406390e-02f, 4.29774784e-02f, -6.54468238e-02f,
  -4.56509814e-02f, 3.20712849e-02f, -1.94503605e-01f, 3.17380466e-02f, 1.01181090e-01f, 3.49894837e-02f, 3.27782445e-02f, 7.65141398e-02f, 3.52003961e-03f, 2.20388100e-02f,
  1.23194329e-01f, -1.20898798e-01f, -1.68585196e-01f, 3.48155722e-02f, -4.98634800e-02f, 9.72466618e-02f, 9.09451172e-02f, -8.88029188e-02f, 4.21668496e-03f, 4.95852381e-02f,
  4.14395854e-02f, 1.56412795e-01f, 2.10430413e-01f, 1.09151125e-01f, 1.37476817e-01f, -2.49562711e-02f, -1.17736325e-01f, -1.48588913e-02f, 1.67882219e-02f, -1.02420598e-01f,
  -1.01199162e+00f, -9.21785980e-02f, -2.52783030e-01f, -7.32194722e-01f, -3.42155665e-01f, -5.27768992e-02f, 1.84154227e-01f, 1.09344028e-01f, -3.12946141e-01f, -1.04736060e-01f,
  -8.76747072e-02f, -1.38415575e-01f, -3.29579085e-01f, 1.53285507e-02f, 3.66117284e-02f, -5.87495118e-02f, -4.18295711e-01f, -4.46648419e-01f, 1.08683994e-02f, 3.29365611e-01f,
  8.50758180e-02f, -3.55597287e-01f, -2.79202849e-01f, -1.28472686e-01f, -4.22359351e-03f, -4.23020199e-02f, -1.34566441e-01f, -2.30485246e-01f, 3.76343280e-02f, -4.45403844e-01f,
  2.85246104e-01f, -2.44720541e-02f, 6.39928272e-03f, -1.52218491e-01f, -7.95075949e-03f, -2.68247705e-02f, 2.24172883e-02f, -5.23451380e-02f, -5.20905964e-02f, -6.65816516e-02f,
  -2.85074979e-01f, 6.60093874e-02f, -1.21829130e-01f, 3.24605368e-02f, -6.07581660e-02f, -1.35184556e-01f, -1.06366895e-01f, -1.62116196e-02f, -6.30290285e-02f, 2.47408271e-01f,
  1.47528991e-01f, -1.15788512e-01f, 2.81186681e-02f, 1.61039114e-01f, 1.61065295e-01f, -1.46307454e-01f, 2.67554224e-01f, 2.19723329e-01f, 1.36835143e-01f, 1.88339278e-01f,
  1.04761153e-01f, 1.19319074e-01f, -7.07367202e-04f, -5.09499907e-02f, 4.18523401e-02f, -6.35855868e-02f, -1.89577788e-02f, -5.44059202e-02f, -5.57603454e-03f, -2.43563056e-02f,
  -8.10674354e-02f, 3.59547287e-02f, 8.19789767e-02f, -6.17033504e-02f, -8.69273022e-02f, -1.12234600e-01f, -9.88642499e-02f, -2.87234969e-02f, 3.30684781e-02f, -3.74713503e-02f,
  -6.69978857e-02f, 4.41752188e-02f, -5.51971011e-02f, 1.25060976e-01f, -6.35026395e-02f, -2.23249029e-02f, -5.30078560e-02f, 1.66543629e-02f, 2.03220453e-02f, -8.57815072e-02f,
  -3.09598297e-02f, -1.55692780e-03f, -6.41193762e-02f, 4.62927110e-02f, -2.88885962e-02f, -4.11375873e-02f, -4.56929095e-02f, 8.28081667e-02f, -5.46124689e-02f, -1.04290256e-02f,
  5.00981770e-02f, 8.28919560e-02f, -9.40488055e-02f, 1.74007386e-01f, -1.30844368e-02f, -3.63752693e-02f, -4.34811711e-02f, -1.89962536e-01f, -8.61792080e-03f, 1.62186176e-01f,
  -7.98227172e-03f, -2.89232098e-02f, -1.16314009e-01f, -1.11325702e-03f, 7.21456930e-02f, -2.51478404e-02f, 6.67673498e-02f, 1.38916727e-02f, 8.78850445e-02f, 1.21805809e-01f,
  -2.34722197e-01f, 1.04444578e-01f, -3.00592214e-01f, 1.42052397e-01f, 2.15747371e-01f, 1.47833645e-01f, 2.17725068e-01f, 3.59595008e-02f, 1.13438003e-01f, 1.06691509e-01f,
  4.52778526e-02f, 1.68473557e-01f, 1.53672725e-01f, 1.60169125e-01f, 1.53873742e-01f, 1.60605371e-01f, 2.37112835e-01f, 6.77038729e-02f, -5.06634340e-02f, 9.89195108e-02f,
  3.00548464e-01f, 9.44545865e-02f, -3.56366597e-02f, 1.51442334e-01f, 3.14804167e-01f, 1.41145006e-01f, 5.42353429e-02f, 2.41408184e-01f, 2.68578440e-01f, 3.79576296e-01f,
  -6.50348216e-02f, -6.20674193e-02f, -2.11790483e-02f, -3.01413462e-02f, -1.34425953e-01f, -9.66213122e-02f, -1.10624768e-01f, -1.61164522e-01f, -9.45334509e-02f, -7.99990967e-02f,
  -1.47736222e-01f, -1.25276208e-01f, 1.27281219e-01f, 6.65383637e-02f, -8.80099237e-02f, -7.00872168e-02f, -4.99707684e-02f, 7.05963299e-02f, -6.46815822e-02f, -6.35880530e-02f,
  9.97213945e-02f, 8.58679321e-03f, -1.92584589e-01f, -1.09991515e-02f, 9.21674669e-02f, 5.38044190e-03f, -5.61519377e-02f, -5.14590479e-02f, -1.52162522e-01f, -7.31171519e-02f,
  1.23076074e-01f, -3.92443277e-02f, 1.31704286e-01f, 2.32742261e-02f, 1.64486006e-01f, -2.42814552e-02f, 1.87714204e-01f, 5.78360558e-02f, 1.12806611e-01f, -1.03423327e-01f,
  -1.70981750e-01f, -2.57703569e-02f, -8.01724419e-02f, -4.30741236e-02f, 1.41882971e-02f, -1.23484120e-01f, -5.06993048e-02f, 4.60396931e-02f, -8.97925999e-03f, -3.86852808e-02f,
  -4.33372185e-02f, 4.23063077e-02f, -1.57746628e-01f, 1.58091664e-01f, 6.96424991e-02f, 2.59499811e-02f, -4.41545434e-02f, -1.57530844e-01f, -1.44694775e-01f, -1.17547125e-01f,
  -2.08809167e-01f, -2.31479928e-01f, 1.66331500e-01f, 1.47324264e-01f, -5.78836314e-02f, -3.03084366e-02f, 1.92429442e-02f, -8.98057315e-03f, 1.03677608e-01f, 1.42110407e-01f,
  -2.86698014e-01f, 2.60395426e-02f, -6.24150522e-02f, -1.22938849e-01f, -3.91728953e-02f, 5.90058789e-02f, 1.44662231e-01f, 1.71852857e-01f, 2.31476668e-02f, -9.04280692e-02f,
  -3.95633169e-02f, -1.72137484e-01f, -1.76429406e-01f, 3.71477045e-02f, 8.09666440e-02f, -3.94969434e-03f, -1.42531425e-01f, -1.55275911e-01f, -2.17230305e-01f, -1.42420083e-01f,
  9.29427981e-01f, -1.72763780e-01f, 1.76549390e-01f, 2.31944978e-01f, -2.03385651e-02f, 7.97984153e-02f, -1.27518913e-02f, 1.25377819e-01f, 2.60985307e-02f, 9.12199318e-02f,
  1.69619441e-01f, 2.86869705e-01f, 3.38392943e-01f, 2.02379405e-01f, 2.41182163e-01f, -1.05424039e-01f, -1.81697577e-01f, 3.06703478e-01f, 1.96457878e-01f, 2.82637067e-02f,
  -2.26669442e-02f, -9.96860638e-02f, 1.00881383e-01f, 2.71202680e-02f, -1.86787486e-01f, 1.01784788e-01f, -7.23599866e-02f, -9.98025611e-02f, -1.20101042e-01f, -2.02174678e-01f,
  -9.31045040e-02f, 2.45523915e-01f, 3.74603793e-02f, 2.13216953e-02f, -1.37903228e-01f, -7.93662965e-02f, 6.49533421e-02f, -4.23177108e-02f, -1.25044703e-01f, -2.07475021e-01f,
  -1.52069315e-01f, 1.97013989e-02f, 1.41333276e-02f, 9.60942649e-04f, -1.07841663e-01f, -1.40418708e-01f, -1.26277670e-01f, -2.28456166e-02f, 3.59798260e-02f, 3.30033116e-02f,
  -1.23452656e-02f, -5.13496958e-02f, 4.73172814e-02f, -5.48761226e-02f, -2.02879049e-02f, 1.14916854e-01f, 4.61142473e-02f, 9.42946970e-03f, 1.52860910e-01f, -8.63370076e-02f,
  8.63786638e-02f, 2.08360076e-01f, 1.83353737e-01f, -3.16488221e-02f, -4.74041067e-02f, 5.54994866e-03f, 7.78637603e-02f, -1.07892320e-01f, 2.67461333e-02f, -1.47960410e-01f,
  -3.69890109e-02f, -1.07297394e-02f, 1.32715389e-01f, 4.82702293e-02f, 8.90834257e-02f, -4.69254777e-02f, 5.86592406e-03f, -5.64082600e-02f, 7.88704529e-02f, -8.56181979e-02f,
  6.58649281e-02f, -9.38095599e-02f, 7.47975037e-02f, 1.19244829e-02f, 2.42883749e-02f, -1.61665007e-02f, -1.31197423e-02f, -3.44192721e-02f, -2.74587926e-02f, -7.34535977e-02f,
  -5.28483570e-01f, 2.60785699e-01f, 7.42965117e-02f, -1.21784508e-02f, -1.72561094e-01f, -9.80697200e-03f, 1.03219785e-01f, -8.82446393e-02f, -1.48893416e-01f, -1.01034887e-01f,
  -3.76620032e-02f, 1.02293387e-01f, 5.39377443e-02f, -2.04540621e-02f, -1.16954148e-02f, -1.01045989e-01f, -3.88040603e-03f, 1.45002734e-03f, 1.21239778e-02f, -6.39088228e-02f,
  -9.34516117e-02f, -5.73249273e-02f, 1.03234857e-01f, 2.64806561e-02f, 8.98427609e-03f, 2.08149105e-01f, -6.52598739e-02f, -7.94026405e-02f, 2.49382153e-01f, -1.26790628e-01f,
  -3.97085339e-01f, 3.67592871e-01f, 3.24525870e-02f, -7.58470744e-02f, 4.20532823e-01f, 3.64177153e-02f, 1.26000240e-01f, -1.91689700e-01f, -1.85971424e-01f, 6.68914393e-02f,
  3.30992341e-01f, -1.12787290e-02f, 2.63573118e-02f, 5.13439849e-02f, -2.54588038e-01f, 1.16150536e-01f, 9.03167427e-02f, -2.52706349e-01f, -2.38537207e-01f, -3.45551148e-02f,
  1.49681091e-01f, -1.90243945e-01f, -3.53678793e-01f, -2.65582770e-01f, 1.55460626e-01f, 3.81774828e-02f, 2.79699862e-02f, 6.72876909e-02f, 2.68827349e-01f, 4.14502442e-01f,
  1.87878177e-01f, 7.77657107e-02f, 1.09566730e-02f, 8.00000727e-02f, 1.69634238e-01f, -1.90178990e-01f, 2.56557185e-02f, -8.34667087e-02f, -3.15881856e-02f, -8.80382136e-02f,
  2.03207955e-01f, 1.68349758e-01f, 1.62914708e-01f, -6.47914335e-02f, -1.33779511e-01f, -1.56774119e-01f, -2.92322844e-01f, -2.33374596e-01f, -2.38197818e-01f, -1.39549479e-01f,
  2.39055261e-01f, 1.86030000e-01f, -3.28445286e-02f, 4.20959741e-02f, -6.53408607e-03f, -1.47927985e-01f, -2.64467448e-02f, -4.29280214e-02f, -1.85077757e-01f, -1.91339865e-01f,
  1.61914565e-02f, 2.73331404e-02f, 1.14623576e-01f, 4.49507274e-02f, 1.19665721e-02f, 1.22427016e-01f, 1.16807953e-01f, 7.05304742e-02f, 8.72413591e-02f, -1.23400010e-01f,
  2.12198426e-03f, -2.57182424e-03f, -3.61859016e-02f, 5.68713658e-02f, -1.60263442e-02f, 6.51444495e-02f, -3.19543928e-02f, 4.71985695e-05f, -1.14549972e-01f, -1.93084441e-02f,
  -8.49015824e-03f, -1.10057332e-01f, 4.54426035e-02f, -6.96105510e-02f, 6.67348877e-02f, 4.90135103e-02f, 2.72170063e-02f, 3.07043660e-02f, -3.74020636e-02f, 1.13698699e-01f,
  -3.52123976e-01f, 2.48158038e-01f, -2.07946077e-02f, 9.65847261e-03f, 9.22951475e-03f, -3.02566439e-02f, -9.60611086e-03f, -4.68153991e-02f, -4.92110103e-02f, -6.49869442e-02f,
  3.08963824e-02f, 5.54899685e-02f, -4.95776869e-02f, -1.38340116e-01f, -3.19943167e-02f, -4.94677387e-02f, 1.09097660e-01f, -1.35342002e-01f, -1.07531533e-01f, -2.80147195e-02f,
  -8.42141956e-02f, -1.63079321e-01f, -2.86967069e-01f, -3.70024852e-02f, 5.50890118e-02f, -6.68263957e-02f, -1.23176239e-01f, -1.72214076e-01f, -2.01218709e-01f, -2.70816028e-01f,
  1.02419674e+00f, 1.67945363e-02f, 3.16924714e-02f, 6.70308024e-02f, -1.53044969e-01f, 4.95058261e-02f, 2.37197895e-02f, 2.44410895e-02f, 1.16217537e-02f, 7.49290511e-02f,
  9.81794596e-02f, 1.79305419e-01f, 1.50153637e-01f, 8.14410076e-02f, -2.15263735e-03f, -2.32070357e-01f, -1.24638528e-01f, -8.45035687e-02f, -9.18972120e-02f, 1.84985262e-03f,
  -1.22615859e-01f, 8.40011612e-02f, 8.65787789e-02f, -7.96746239e-02f, -8.02430976e-03f, -1.00554429e-01f, 1.69842076e-02f, 1.02523737e-01f, 5.55864275e-02f, 8.43615606e-02f,
  2.63681293e-01f, 4.91155595e-01f, -2.43549809e-01f, -4.20194352e-03f, 5.82271032e-02f, -4.85183150e-02f, 1.62914712e-02f, -4.89422716e-02f, -3.69183719e-02f, -2.14168116e-01f,
  -3.69596146e-02f, 3.22859623e-02f, 8.41767117e-02f, 1.01430237e-01f, 7.37596527e-02f, 3.15483660e-02f, 8.29518065e-02f, 1.45395041e-01f, 7.75481910e-02f, 9.22941789e-02f,
  -1.47529887e-02f, 3.23291980e-02f, 9.26404595e-02f, -1.79265179e-02f, 8.39554295e-02f, 3.28895748e-02f, -2.48306878e-02f, 7.48759359e-02f, 4.37770672e-02f, -5.11790486e-03f,
  2.80934423e-01f, 1.50071785e-01f, 5.91074340e-02f, 4.53249104e-02f, 4.88177538e-02f, 1.36549696e-01f, 2.79992670e-02f, -7.56836450e-03f, 6.29629344e-02f, 1.14296049e-01f,
  1.52828217e-01f, 9.17259529e-02f, -1.88903827e-02f, 9.68880653e-02f, -4.20627892e-02f, 9.31640193e-02f, 2.09794030e-01f, 9.53791142e-02f, -5.11512645e-02f, -1.70979544e-03f,
  -2.29669902e-02f, -7.89066926e-02f, 3.88561166e-03f, 5.83311019e-04f, 2.33815946e-02f, -4.16879915e-02f, -1.17889391e-02f, 6.90927058e-02f, -8.24238658e-02f, 8.29634815e-02f,
  -3.22254092e-01f, 2.17264250e-01f, 8.99580717e-02f, -7.57589340e-02f, 3.74262258e-02f, -1.22275926e-01f, 1.57099947e-01f, -1.12706028e-01f, -2.10848778e-01f, -2.53901511e-01f,
  -8.33261311e-02f, 1.78559124e-02f, 1.22811340e-01f, -9.19276178e-02f, -1.32870644e-01f, -5.94860427e-02f, -1.16023704e-01f, -3.75469476e-02f, -3.64464931e-02f, 2.17108745e-02f,
  -8.48589838e-02f, -1.64589033e-01f, -1.39026836e-01f, -1.37502387e-01f, -1.23635931e-02f, -1.71427414e-01f, -5.37929721e-02f, 2.20496729e-02f, -4.49285470e-02f, -2.10394740e-01f,
  4.04819220e-01f, -5.02551794e-01f, -6.31563291e-02f, 7.80416727e-02f, 2.49222174e-01f, 2.53322035e-01f, 2.25804359e-01f, 2.80924123e-02f, -2.64780726e-02f, -5.26647130e-03f,
  -2.29888543e-01f, -3.17115307e-01f, -2.93691725e-01f, -3.59842002e-01f, -9.70025137e-02f, 1.22515216e-01f, 6.39005527e-02f, 1.61547065e-01f, 2.13116914e-01f, 1.41305611e-01f,
  -3.61056775e-02f, 1.40890062e-01f, -3.77301946e-02f, -1.49434909e-01f, -5.84819578e-02f, -2.48022261e-03f, -6.33228645e-02f, -5.09636067e-02f, -1.74828365e-01f, -1.57726169e-01f,
  1.20613046e-01f, -3.04057270e-01f, 9.83292460e-02f, -3.50978747e-02f, -1.07280627e-01f, -5.66659383e-02f, 7.67967775e-02f, 1.46826264e-02f, -6.35388196e-02f, 1.83904264e-02f,
  1.25451917e-02f, -1.61438718e-01f, 6.17958978e-03f, -6.10486753e-02f, 9.15906355e-02f, 8.33455771e-02f, -3.71694472e-03f, -2.73440838e-01f, -2.69985706e-01f, -3.45502198e-02f,
  -2.00170785e-01f, -1.22654341e-01f, 1.14453293e-01f, -4.59174886e-02f, -1.10081956e-01f, -6.02969863e-02f, -1.91421166e-01f, -3.25749186e-03f, -1.03173658e-01f, 6.80787023e-03f,
  1.72006362e-03f, 6.69490620e-02f, 4.09945622e-02f, -5.87646151e-03f, 6.52442276e-02f, 7.36236945e-02f, 9.33247060e-02f, -5.54471985e-02f, 7.52156451e-02f, -3.67561653e-02f,
  -3.09791286e-02f, -1.33568034e-01f, -8.40399861e-02f, -2.74795648e-02f, -1.25835195e-01f, -4.61354032e-02f, -5.87713951e-03f, -3.94033641e-02f, -8.02482888e-02f, 8.29271302e-02f,
  -1.27215445e-01f, 5.41278683e-02f, -4.22570072e-02f, -4.44554575e-02f, -1.79010242e-01f, -8.02002996e-02f, -8.96317326e-03f, -2.06495315e-01f, 2.34443955e-02f, -9.69155282e-02f,
  -2.82146316e-02f, -2.34410301e-01f, 2.86708057e-01f, -1.18474104e-01f, 5.90645475e-03f, -1.39046550e-01f, -1.10367328e-01f, 3.25876139e-02f, -6.15591221e-02f, 2.30045766e-02f,
  -9.75685343e-02f, -1.36860143e-02f, -1.38947755e-01f, -5.37437536e-02f, 2.09549382e-01f, 3.61179118e-03f, -8.29105526e-02f, -1.02141872e-01f, -3.62617255e-04f, 4.97038104e-02f,
  -1.07130945e-01f, 1.79031104e-01f, 2.11695224e-01f, 1.78665176e-01f, 1.01436548e-01f, 2.78281957e-01f, 1.33900136e-01f, 9.18231830e-02f, 1.71357438e-01f, 3.67143571e-01f,
  6.98070228e-01f, -3.55572164e-01f, -1.24023981e-01f, 1.77631617e-01f, -6.96159825e-02f, 3.76206934e-02f, -1.64342910e-01f, 3.14765866e-03f, 6.98846206e-02f, -7.14247897e-02f,
  -8.79559759e-03f, 2.15103716e-01f, 1.56651229e-01f, 2.08553284e-01f, 9.33325812e-02f, -1.98221698e-01f, -2.12550253e-01f, 9.97071937e-02f, 3.00235868e-01f, -3.33492868e-02f,
  -1.76980287e-01f, -2.15621457e-01f, 4.53588143e-02f, 6.60713911e-02f, -2.19742686e-01f, 2.35217363e-02f, -2.37394154e-01f, -1.33782879e-01f, -1.48268610e-01f, -3.01200837e-01f,
  1.95065245e-01f, 1.85447440e-01f, 2.89601624e-01f, 1.45666495e-01f, 1.88804269e-02f, 1.36448175e-01f, 1.79235488e-01f, 3.90870608e-02f, -1.29647814e-02f, 3.98766715e-03f,
  6.06755577e-02f, -1.10404626e-01f, -1.57220326e-02f, -6.75778016e-02f, 8.35740846e-03f, -5.34525849e-02f, -6.34326562e-02f, -5.20602567e-03f, -4.70710658e-02f, 2.03145742e-02f,
  -5.24878800e-02f, 5.53255454e-02f, 3.55767496e-02f, 7.48829618e-02f, 1.38348535e-01f, 5.70076667e-02f, -1.16161071e-02f, 5.52810282e-02f, -2.86856554e-02f, -6.89891726e-02f,
  -5.36332419e-03f, 7.01097026e-02f, 9.60867628e-02f, -1.37059629e-01f, -1.99261960e-02f, -1.70415845e-02f, -6.95855403e-03f, 9.19569284e-03f, -2.29679588e-02f, -1.11416429e-01f,
  -1.06071159e-01f, -6.93055475e-03f, 9.59215686e-03f, 5.41412979e-02f, -4.05961685e-02f, -2.02272497e-02f, 6.69574924e-03f, 3.04379649e-02f, 8.27584695e-03f, -5.21488721e-03f,
  3.32158804e-02f, 1.40782120e-02f, -2.62543280e-02f, -6.20170608e-02f, -2.99681760e-02f, 3.66351858e-04f, -2.78257858e-02f, -2.22803634e-02f, 9.67719825e-04f, -1.43356189e-01f,
  6.23588264e-02f, 3.83791983e-01f, 1.76501334e-01f, -9.38978717e-02f, -4.46817726e-02f, -3.09341643e-02f, 6.07173443e-02f, -3.91118713e-02f, 1.43292760e-02f, 5.75386584e-02f,
  9.42990035e-02f, -1.12824785e-02f, -5.91155291e-02f, -8.57468974e-03f, -7.23844022e-02f, 8.74753203e-03f, 7.63370888e-03f, 9.38166007e-02f, 5.41998185e-02f, -6.76978156e-02f,
  -1.86116621e-01f, 1.05074272e-01f, 2.92545646e-01f, 1.60277322e-01f, 1.21249527e-01f, 1.85473442e-01f, -1.73592176e-02f, 4.31780927e-02f, 1.98027194e-01f, -2.31815904e-01f,
  5.74416757e-01f, 2.71448225e-01f, 2.13837013e-01f, -9.48099419e-02f, 1.21482812e-01f, 6.34119613e-03f, 3.81034911e-01f, -4.36224192e-02f, -1.52720794e-01f, 1.44899055e-01f,
  3.15728597e-02f, -2.72159070e-01f, -1.61248773e-01f, -1.81983978e-01f, -1.02633618e-01f, -3.80256772e-02f, 1.54557871e-02f, -6.67197257e-02f, -2.09705770e-01f, -2.83933014e-01f,
  -1.57691196e-01f, 7.12231696e-02f, 1.09102681e-01f, -6.76319003e-02f, 2.34758276e-02f, -3.20624739e-01f, 6.59530237e-02f, 9.02464315e-02f, -3.34794112e-02f, -1.36894630e-02f,
  1.05483264e-01f, 4.34418976e-01f, -5.50789177e-01f, -1.05261356e-01f, 7.39109665e-02f, -5.09597547e-03f, -9.23880562e-02f, 4.74630333e-02f, -8.65065828e-02f, -1.26015827e-01f,
  7.02396184e-02f, -1.08263694e-01f, 7.07540512e-02f, -3.72642875e-02f, -3.21582742e-02f, 3.86807248e-02f, -5.17199636e-02f, -2.48689321e-03f, -3.35993543e-02f, 1.22286089e-01f,
  -1.20949320e-01f, 7.62963444e-02f, 1.91472158e-01f, -1.46440454e-02f, -2.44121030e-02f, -1.01683401e-01f, -4.56522265e-03f, 5.92750907e-02f, 1.45591339e-02f, -6.37122914e-02f,
  -2.10077420e-01f, -1.51520576e-02f, 2.15952434e-02f, -2.10474938e-01f, -8.63658860e-02f, -4.58088927e-02f, -6.88074902e-02f, 8.04698840e-02f, -4.00635451e-02f, -3.36320214e-02f,
  -1.16232589e-01f, -3.50782619e-04f, -9.42130908e-02f, -1.05565451e-01f, -1.21955676e-02f, 2.65613635e-04f, -3.75406593e-02f, 1.04675047e-01f, -9.10826679e-03f, -4.84276302e-02f,
  -1.58572972e-01f, -3.22162211e-02f, -2.80291997e-02f, 1.40420841e-02f, -1.71874657e-01f, -8.98699015e-02f, -6.22691028e-02f, -1.19965561e-01f, -2.34600119e-02f, 8.98680165e-02f,
  -4.03037608e-01f, -2.77794003e-01f, -3.59962612e-01f, -3.42402309e-02f, 5.38999727e-03f, 9.31891501e-02f, 7.11135939e-02f, 1.34465724e-01f, 8.52773115e-02f, 6.89132586e-02f,
  1.37741879e-01f, -3.48122865e-02f, -5.60084395e-02f, 1.62898824e-02f, -1.65345132e-01f, 6.10681698e-02f, -2.83573121e-02f, 1.18663982e-01f, 1.86400302e-03f, 1.25239760e-01f,
  -4.27282490e-02f, -1.51687801e-01f, -1.67255197e-02f, -4.37510349e-02f, -1.97771415e-01f, -2.20950902e-01f, -6.06986508e-03f, -8.06802213e-02f, -5.53154573e-02f, -1.97038114e-01f,
  -4.57621455e-01f, 1.09972499e-01f, -3.85189414e-01f, -1.71216816e-01f, 3.24258715e-01f, 2.72638083e-01f, 3.22615713e-01f, 7.34859928e-02f, -1.57610923e-01f, 7.06426352e-02f,
  1.12291977e-01f, 1.63243636e-02f, -7.29482621e-02f, 3.41683440e-02f, 6.01280928e-02f, 2.45286703e-01f, 1.26788735e-01f, -2.23330911e-02f, 3.93845327e-02f, 2.45648444e-01f,
  1.72767177e-01f, -1.34898514e-01f, -3.43453884e-01f, -8.62838626e-02f, -1.08545855e-01f, -7.60621876e-02f, -8.08389783e-02f, 2.79628765e-02f, 2.15234041e-01f, 1.31569030e-02f,
  -1.17651120e-01f, -1.72662675e-01f, 1.14084736e-01f, -8.17169696e-02f, -1.23889878e-01f, -1.66315734e-01f, 3.19973156e-02f, -7.28269815e-02f, -3.49546596e-02f, -1.21936597e-01f,
  3.80739532e-02f, -7.01159984e-02f, -5.97921200e-02f, 1.37232140e-01f, -1.20417155e-01f, 7.86557570e-02f, -1.37751162e-01f, -1.46570191e-01f, -3.51411074e-01f, -2.04221189e-01f,
  3.92529666e-01f, 1.40981376e-01f, -2.78151065e-01f, -3.94561402e-02f, 8.36479943e-03f, -1.06318705e-01f, -1.36111826e-01f, -2.19713852e-01f, -7.23860934e-02f, -3.81693155e-01f,
  -1.23722591e-01f, 3.54397856e-02f, 1.70922577e-02f, -8.36525410e-02f, -8.51633996e-02f, 5.27304970e-02f, 4.99653928e-02f, 1.92519091e-03f, 5.93921058e-02f, -5.96483797e-02f,
  -9.90047120e-03f, 1.17962733e-01f, -9.92286056e-02f, 4.00437601e-02f, -9.64545365e-03f, 1.35148549e-02f, 7.00634569e-02f, -1.55362055e-01f, 8.91705567e-04f, -4.48445491e-02f,
  3.20903435e-02f, 7.05587715e-02f, 6.87084198e-02f, 8.16268250e-02f, 2.15036198e-02f, 5.65526821e-02f, -5.87228611e-02f, -5.69859520e-02f, 3.78134288e-02f, -1.29603207e-01f,
  -4.17203099e-01f, 1.61574244e-01f, -9.71399993e-02f, 2.88570244e-02f, -3.09640169e-02f, -5.80691434e-02f, 2.79976316e-02f, 4.48010229e-02f, 7.35921189e-02f, -1.08599953e-01f,
  -1.44638875e-02f, 2.70021185e-02f, -4.90782820e-02f, 4.88926470e-03f, 5.56255393e-02f, -6.06955253e-02f, 7.90480301e-02f, 4.60660160e-02f, 7.15202391e-02f, -6.53542653e-02f,
  -1.37927383e-01f, -5.91906160e-02f, -2.48071775e-01f, -1.61221594e-01f, -5.51707782e-02f, -7.30396854e-03f, -1.83277577e-01f, -1.63014099e-01f, -1.73236787e-01f, -3.42975229e-01f,
  1.10567677e+00f, 2.25051582e-01f, 1.48637563e-01f, 1.34147823e-01f, 9.68442932e-02f, -1.73225850e-01f, -1.57280952e-01f, -2.92790920e-01f, -4.87155691e-02f, 9.57433134e-02f,
  2.40552425e-01f, 1.42782733e-01f, 6.39673024e-02f, -1.57269746e-01f, -1.06807232e-01f, -3.49501193e-01f, -2.78719842e-01f, -8.81588832e-02f, -7.64866769e-02f, -6.12728260e-02f,
  4.08225991e-02f, -8.69516209e-02f, 1.04155637e-01f, -1.80575594e-01f, 1.11631311e-01f, -1.36583392e-02f, -2.76211590e-01f, -4.68278937e-02f, 1.43303238e-02f, 9.75769907e-02f,
  2.94667453e-01f, 4.32638973e-01f, -9.71963853e-02f, 1.64808884e-01f, 2.25882143e-01f, 1.76178366e-02f, -2.53715534e-02f, -2.79491097e-02f, -1.10727817e-01f, -6.47267699e-02f,
  1.48998156e-01f, 5.87939247e-02f, 1.40698150e-01f, -4.12387587e-02f, -1.65238492e-02f, 1.35608941e-01f, -2.13632714e-02f, 2.88387816e-02f, -8.92157778e-02f, 1.11460768e-01f,
  2.39447489e-01f, 2.57491201e-01f, 8.48610774e-02f, -3.92743014e-02f, 9.72291008e-02f, 1.19998053e-01f, 1.45802826e-01f, 1.72540769e-01f, 1.30120337e-01f, 8.26411247e-02f,
  -1.87562197e-01f, 1.63214117e-01f, 1.98937878e-02f, 7.14870766e-02f, 4.50235158e-02f, 5.49611859e-02f, -1.29046187e-01f, -7.86833242e-02f, 8.09282437e-03f, -1.32760331e-01f,
  -1.60014808e-01f, 1.38499215e-01f, 3.88250910e-02f, -1.17726035e-01f, -1.91373576e-03f, 1.52532250e-01f, 5.59051596e-02f, -7.10051060e-02f, -4.99998443e-02f, 9.18339565e-02f,
  5.44002280e-02f, -1.71099588e-01f, -2.33325101e-02f, -5.83441816e-02f, 2.00618207e-02f, 6.65124133e-02f, 1.00609496e-01f, -2.45499462e-02f, -3.47208828e-02f, -5.72005846e-02f,
  -2.81422526e-01f, -5.95895424e-02f, -6.13275692e-02f, 7.83757716e-02f, 5.48320934e-02f, 8.42864718e-03f, 1.08795658e-01f, -1.76415652e-01f, -1.22144155e-01f, 5.16206434e-04f,
  1.74521595e-01f, 8.83170143e-02f, -4.09527309e-02f, 9.73919057e-04f, -1.87772378e-01f, -5.63801825e-02f, 8.57371688e-02f, 2.09653676e-02f, -1.34640187e-01f, -1.08546086e-01f,
  -1.19484141e-01f, -4.81182709e-02f, -1.84387445e-01f, -1.55082256e-01f, -7.65397623e-02f, -7.59600848e-02f, -1.46979108e-01f, -3.25105600e-02f, -1.39516264e-01f, -1.18066147e-01f,
  5.93834639e-01f, -1.90998062e-01f, -4.23472136e-01f, 2.14292184e-01f, -2.17133462e-01f, -4.75179665e-02f, -2.98416525e-01f, 1.30473807e-01f, 2.18767777e-01f, -1.20610125e-01f,
  1.56464130e-01f, 2.80444890e-01f, 1.79150924e-01f, 1.84001967e-01f, 1.83200017e-01f, -3.03142190e-01f, -2.54137784e-01f, 1.52055444e-02f, 2.70274580e-01f, 1.01669848e-01f,
  1.56901702e-01f, -5.98325729e-02f, 1.07410558e-01f, 1.95833281e-01f, -2.30823010e-01f, 5.74528873e-02f, -4.25858825e-01f, -2.63723701e-01f, -1.40431106e-01f, -4.77325886e-01f,
  -2.81478345e-01f, 4.03948426e-02f, -5.02342433e-02f, -2.20956635e-02f, -1.33264318e-01f, -3.27987783e-02f, -1.22175001e-01f, -1.88666716e-01f, 2.73772180e-02f, -3.13917100e-02f,
  1.35118559e-01f, -8.30857269e-03f, 8.56832862e-02f, -1.28243744e-01f, -8.07858929e-02f, -1.49330467e-01f, -6.06702827e-02f, 7.31447265e-02f, 5.31824268e-02f, -2.56267991e-02f,
  -3.55655998e-02f, -1.28058434e-01f, -6.52393103e-02f, 1.47222625e-02f, 6.05082735e-02f, 8.42678845e-02f, 1.18953185e-02f, -8.45231190e-02f, -7.06380680e-02f, -3.04211110e-01f,
  -4.89948280e-02f, -2.35683471e-03f, 6.37774095e-02f, 2.94891428e-02f, 4.74584475e-02f, -2.18141600e-02f, -4.97817583e-02f, 3.58897597e-02f, 1.38592586e-01f, -1.25632033e-01f,
  4.09908928e-02f, 3.09507903e-02f, -4.10520062e-02f, 4.21536416e-02f, -1.26735633e-02f, -4.48764786e-02f, -5.81907965e-02f, 5.04015908e-02f, 4.38919552e-02f, 2.32067556e-04f,
  9.61708352e-02f, -8.96488957e-04f, 2.57639121e-02f, -6.95664436e-02f, -6.17114780e-03f, 4.70947707e-03f, 5.91636598e-02f, -1.00186886e-02f, -3.14623639e-02f, -6.69058971e-03f,
  2.16744632e-01f, 8.10998455e-02f, -3.39692719e-02f, -5.50449602e-02f, -9.68508795e-02f, -6.54922947e-02f, 1.07739158e-02f, 1.20310217e-01f, 1.30399495e-01f, 1.45147499e-02f,
  7.36307725e-02f, 3.28901620e-03f, -6.33303821e-02f, -1.22979939e-01f, -3.72486673e-02f, 5.12799211e-02f, 1.05489671e-01f, 1.37565449e-01f, 1.50279745e-01f, -1.62611492e-02f,
  3.84539813e-02f, 1.34194031e-01f, 1.25105441e-01f, -3.06241959e-02f, 1.75669100e-02f, 1.69130579e-01f, 3.79622681e-03f, 1.83057820e-03f, 3.72790135e-02f, -4.35421616e-02f,
  8.67368877e-02f, 1.25305995e-01f, 3.61451000e-01f, 3.12475562e-01f, 4.59563315e-01f, 4.08739150e-01f, 4.41182137e-01f, 2.90095419e-01f, 1.14036821e-01f, 7.24562444e-03f,
  6.09148480e-02f, -1.18241116e-01f, -2.13866785e-01f, -1.12454720e-01f, -6.86018839e-02f, 1.46095276e-01f, 2.57168621e-01f, -2.28947066e-02f, 4.49702106e-02f, 5.32045700e-02f,
  -1.95796248e-02f, -1.49809360e-03f, -1.62475407e-01f, -1.30429966e-02f, -1.08769037e-01f, -5.43535911e-02f, 1.00644723e-01f, 8.10537934e-02f, -8.80592689e-02f, -2.04911873e-01f,
  1.93058908e-01f, 2.97875613e-01f, 4.84379232e-02f, -1.03440642e-01f, -7.90484995e-02f, -1.17671184e-01f, -1.41736325e-02f, -1.46266669e-01f, 4.03836481e-02f, 1.05683826e-01f,
  4.29538824e-02f, -8.60448629e-02f, 1.20050065e-01f, -4.40974273e-02f, -4.83351275e-02f, -1.37922347e-01f, -5.39243072e-02f, 4.70356829e-02f, 1.03603065e-01f, -5.12310341e-02f,
  -2.75765918e-02f, 1.64213583e-01f, 4.44480002e-01f, 2.79143453e-01f, 1.11589983e-01f, 1.06818415e-01f, 9.61738974e-02f, 1.18814744e-02f, 1.21867217e-01f, -1.12419911e-01f,
  1.65142253e-01f, 1.10479154e-01f, 1.42406270e-01f, 1.77869089e-02f, -1.22094221e-01f, -9.51423347e-02f, 4.91080172e-02f, 1.20989531e-01f, -9.81632993e-03f, -1.09022558e-01f,
  -2.04111193e-03f, 4.24456745e-02f, 1.40921906e-01f, 7.90055934e-03f, -7.51615912e-02f, 8.54503065e-02f, 3.27365026e-02f, 6.28412291e-02f, -1.84731595e-02f, 3.02122999e-02f,
  -9.52324495e-02f, 1.19434707e-01f, 3.21141593e-02f, 1.40218846e-02f, 3.04228887e-02f, 7.75244087e-02f, -1.02023557e-01f, 6.38022944e-02f, -1.61341741e-03f, -5.71429804e-02f,
  1.59407318e-01f, 2.94029772e-01f, -1.64380789e-01f, -1.23766586e-01f, 7.16623990e-03f, -3.14352781e-01f, -6.84893057e-02f, -8.52986574e-02f, 3.95366140e-02f, 8.88649300e-02f,
  -6.37784824e-02f, -4.68958169e-02f, 6.82283044e-02f, -1.91123188e-02f, -1.79339841e-01f, -4.77941036e-02f, -1.16505854e-01f, -5.52835688e-03f, 3.86168286e-02f, -7.82821998e-02f,
  1.53467748e-02f, 1.87365860e-01f, 2.77219951e-01f, 6.72691390e-02f, -4.84554954e-02f, -4.58345599e-02f, -7.93974400e-02f, -7.21110776e-02f, 3.41213495e-02f, -8.01159292e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.43500024e-01f, 1.99741259e-01f, -1.03105351e-01f, -5.41015528e-02f, 2.67241955e-01f, 3.86108905e-02f, 1.64822981e-01f, -8.17598999e-02f, 2.24130183e-01f, 1.67505637e-01f,
  3.13730776e-01f, 2.85695672e-01f, 3.71850014e-01f, 1.42453641e-01f, -1.73102185e-01f, 1.72370151e-01f, -2.24493444e-02f, 2.22791404e-01f, 2.92290628e-01f, 2.95352302e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.24681288e-01f, 8.15040618e-02f, 1.74620926e-01f, -7.81026110e-03f, 9.87636372e-02f, -9.46773514e-02f, 1.96582958e-01f, 2.05378130e-01f, 1.99486986e-01f, 2.65573174e-01f,
  -1.19234793e-01f, -5.23348264e-02f, 1.39509261e-01f, -1.97231591e-01f, 3.34594309e-01f, 2.23243367e-02f, 1.13281809e-01f, -3.15709040e-02f, 3.98854733e-01f, 9.25805569e-02f,
  -3.39522660e-01f, -2.66453177e-01f, -1.17464490e-01f, -1.31947532e-01f, 1.27021268e-01f, 3.96644473e-01f, 2.71910012e-01f, 3.59077863e-02f, -2.33835250e-01f, 1.13049418e-01f,
  2.89785564e-01f, 1.36236995e-01f, 3.95668298e-02f, 1.10352248e-01f, 6.04728945e-02f, -5.76388203e-02f, 5.41496612e-02f, 1.16111070e-01f, 4.81276549e-02f, -1.83760017e-01f,
  1.59953311e-01f, 7.19775036e-02f, -1.23438582e-01f, -3.43370475e-02f, 9.84462164e-03f, 2.77573109e-01f, -5.44539746e-03f, 2.67062902e-01f, 1.90937608e-01f, -1.42363325e-01f,
  8.83083344e-02f, 7.17036501e-02f, 4.50737886e-02f, -1.01344995e-02f, 3.34353536e-01f, -1.54849261e-01f, 2.28751376e-01f, -1.41427144e-01f, 4.02762815e-02f, 2.75337398e-01f,
  -1.59209818e-01f, 1.64647490e-01f, 1.74002409e-01f, -2.33613238e-01f, -7.53166303e-02f, 1.51749607e-02f, 2.54705362e-02f, 7.01203058e-03f, 4.79120500e-02f, 7.02423155e-02f,
  -3.58974747e-02f, 4.47463244e-02f, -1.86546341e-01f, -1.75409406e-01f, 1.47672683e-01f, 1.27151534e-01f, -8.20457265e-02f, -3.76619190e-01f, 5.10770380e-01f, 1.97733015e-01f,
  -6.99572712e-02f, 8.37211907e-02f, -2.72397816e-01f, 2.48136610e-01f, 3.43832254e-01f, -2.35239089e-01f, -4.72462252e-02f, 9.88258608e-03f, 1.10497981e-01f, 1.19512081e-01f,
  -2.92870611e-01f, 1.32244542e-01f, 2.85896182e-01f, 1.04587793e-01f, 2.45321449e-03f, -9.87910405e-02f, 1.77514061e-01f, -2.25493982e-02f, 1.51511371e-01f, 2.65256435e-01f,
  1.21360935e-01f, 2.43221000e-01f, -2.78889418e-01f, -1.68557584e-01f, -3.08134586e-01f, -1.02958083e-01f, 2.09272623e-01f, -1.00004010e-01f, 7.63484836e-02f, -1.58088610e-01f,
  1.29884958e-01f, -1.85558900e-01f, -1.77873671e-01f, 2.33065709e-01f, 1.36498988e-01f, 1.93206832e-01f, 9.41053852e-02f, -6.65519908e-02f, -3.27694446e-01f, 4.21982348e-01f,
  -1.82001255e-02f, 7.99802989e-02f, -1.22401915e-01f, 2.20133647e-01f, 6.91732690e-02f, 4.30206507e-02f, -2.70999193e-01f, 1.05704494e-01f, 4.45401073e-02f, 1.03958882e-01f,
  8.16240385e-02f, -4.94615957e-02f, 7.87118375e-02f, 1.41825303e-01f, 2.27844521e-01f, 1.79033786e-01f, 1.39577091e-01f, 1.01333566e-01f, -2.90851802e-01f, 1.19185038e-01f,
  9.58003178e-02f, 1.01141647e-01f, -3.97592723e-01f, 2.36587450e-01f, 1.27900928e-01f, -1.10342383e-01f, 3.13308150e-01f, -1.09442894e-03f, 1.92894310e-01f, 1.71635106e-01f,
  -2.13614091e-01f, -3.48492384e-01f, 1.03478339e-02f, -1.06937133e-01f, -1.15380175e-01f, -2.15770975e-01f, -3.51248145e-01f, -1.64621294e-01f, 2.04786494e-01f, -5.15516028e-02f,
  4.78494279e-02f, 9.10990685e-02f, 3.34768370e-02f, 7.23184422e-02f, 1.31671101e-01f, -1.06824346e-01f, 8.82242173e-02f, 1.41800195e-01f, 1.46762714e-01f, 3.14671062e-02f,
  -1.00632004e-01f, 1.05590589e-01f, 3.38294536e-01f, 1.07219234e-01f, -3.69772702e-01f, -3.16914231e-01f, 3.56495269e-02f, 1.11330852e-01f, 1.99838921e-01f, -9.06827301e-02f,
  -1.21418610e-01f, -2.07643792e-01f, -7.68540800e-02f, -1.56009153e-01f, -1.76990464e-01f, 2.85660475e-01f, 1.38195008e-02f, 1.01330161e-01f, -3.50946188e-01f, 2.51144826e-01f,
  -6.34761080e-02f, 7.23741278e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.92435753e-01f, 9.04564187e-02f, 1.97645307e-01f, 3.17265958e-01f, 3.92857403e-01f, 1.88865542e-01f, -2.75987480e-02f, 1.16228554e-02f, 2.16999054e-01f, 1.18697219e-01f,
  5.94225600e-02f, 1.54230818e-01f, 1.93490803e-01f, -1.13208219e-01f, 3.67259741e-01f, -3.21243495e-01f, 1.85508892e-01f, -2.23472174e-02f, 4.27971095e-01f, 1.34964949e-02f,
  -2.97754347e-01f, 5.55218756e-03f, 2.59930551e-01f, -6.18505925e-02f, 1.69117719e-01f, 4.01922725e-02f, -2.49873221e-01f, 2.39764825e-01f, -2.77712762e-01f, 6.18097819e-02f,
  -1.13221020e-01f, -2.35885885e-02f, 1.45367414e-01f, -1.41911924e-01f, -3.96991186e-02f, 1.99932382e-01f, 2.42365971e-01f, 3.13530117e-02f, -1.93454355e-01f, 2.07633436e-01f,
  2.26350725e-01f, -4.24815118e-02f, -9.02442783e-02f, -2.88987458e-01f, 2.77842134e-02f, 1.60928052e-02f, 8.87528509e-02f, 2.21214518e-01f, 1.07663557e-01f, 3.46609861e-01f,
  2.87751287e-01f, -3.49631637e-01f, -2.86322296e-01f, -6.91876933e-02f, -1.19218722e-01f, 3.36370051e-01f, 1.37853041e-01f, -8.35711509e-02f, -2.32717589e-01f, 4.85554963e-01f,
  -6.69337660e-02f, 2.05763653e-01f, -2.53088236e-01f, 2.23518461e-01f, 2.82885522e-01f, 1.34658471e-01f, 1.16376970e-02f, 7.86156729e-02f, 7.33105615e-02f, 1.71466708e-01f,
  -5.96729591e-02f, -1.24848291e-01f, 2.21253127e-01f, 6.73676981e-03f, -1.33991897e-01f, 8.17095744e-04f, 1.32281512e-01f, 4.65873443e-02f, 2.53403693e-01f, 1.41788423e-01f,
  3.19420338e-01f, -5.04492261e-02f, 4.30795610e-01f, 3.93543959e-01f, 1.21033257e-02f, 1.10055827e-01f, 2.83997983e-01f, -5.24872681e-03f, 3.17470193e-01f, -2.08503544e-01f,
  -6.05931617e-02f, 2.05830261e-01f, -3.01568210e-01f, 1.86906248e-01f, 1.72662571e-01f, -9.75404233e-02f, 3.62597406e-01f, 8.70937631e-02f, 3.68865401e-01f, 1.32994168e-02f,
  1.85492605e-01f, -2.64505134e-03f, 9.74794626e-02f, 1.61984175e-01f, -2.52378546e-02f, 9.39367190e-02f, 2.34925061e-01f, -1.12918042e-01f, 7.26191774e-02f, 2.68881679e-01f,
  5.00275977e-02f, -4.92955506e-01f, -1.16621241e-01f, 3.06469709e-01f, 1.22136079e-01f, -2.52022833e-01f, 2.33951241e-01f, 6.00508675e-02f, 1.88322291e-02f, 1.51853651e-01f,
  1.14631526e-01f, 5.29053435e-02f, -1.07061341e-01f, 3.52372676e-01f, -3.66947412e-01f, 8.06402415e-02f, -2.41515756e-01f, -1.69960618e-01f, -2.14799941e-01f, 1.54198721e-01f,
  1.20314017e-01f, 8.72215480e-02f, -9.21555832e-02f, 1.18893579e-01f, 7.34034926e-02f, -3.36168334e-02f, -1.06790818e-01f, 1.47726893e-01f, 8.63324851e-02f, -1.85497165e-01f,
  -5.96924052e-02f, -1.46871563e-02f, -7.68312067e-02f, 6.05971515e-01f, 2.99838334e-01f, -1.79683298e-01f, -3.50288481e-01f, 2.36742735e-01f, 2.41291672e-01f, 2.92346120e-01f,
  1.49556026e-01f, 6.38777390e-02f, -1.42169625e-01f, -3.15202892e-01f, 1.55054405e-01f, -9.51445401e-02f, 5.70270956e-01f, 1.49556249e-01f, 2.93094248e-01f, 2.52110809e-01f,
  1.29528269e-02f, 3.45660239e-01f, 1.16833031e-01f, 1.95622265e-01f, -1.96506232e-02f, 5.31536490e-02f, -1.07020803e-01f, -1.48500741e-01f, 8.97471085e-02f, -2.04356164e-01f,
  1.43093979e-02f, 2.82940809e-02f, 5.04958183e-02f, 4.16120827e-01f, -3.14416826e-01f, 3.09312791e-01f, -1.42252401e-01f, 2.07529351e-01f, -3.88117880e-01f, -1.93886533e-01f,
  3.34030062e-01f, 2.37328917e-01f, 1.52492657e-01f, 3.30893576e-01f, 3.55684310e-02f, 2.65571296e-01f, -1.12453036e-01f, 4.34890650e-02f, 2.32943699e-01f, 3.68104465e-02f,
  1.17764607e-01f, 2.16249630e-01f, 1.43926516e-01f, 1.15884759e-01f, 7.45858848e-02f, 7.84581602e-02f, 8.03562626e-02f, 2.05610976e-01f, -2.55421877e-01f, 1.02579579e-01f,
  -2.15925559e-01f, 1.58379935e-02f, -5.14263026e-02f, -3.80640745e-01f, 2.25150689e-01f, 7.85985515e-02f, -3.16429555e-01f, -9.35404077e-02f, -7.12857604e-01f, 2.90203542e-01f,
  -4.24989425e-02f, -3.15355599e-01f, -1.75370183e-02f, 2.30488777e-01f, -9.09238011e-02f, 1.24041624e-01f, 6.06523035e-03f, 4.72283423e-01f, -4.14222963e-02f, 3.56888682e-01f,
  -1.95868850e-01f, -1.25112116e-01f, -3.62929136e-01f, 8.12289938e-02f, 2.06939042e-01f, 8.60449821e-02f, 3.14540774e-01f, 3.09824139e-01f, 5.84081411e-02f, 2.55398378e-02f,
  3.13087165e-01f, 4.12669837e-01f, -1.66909710e-01f, 8.56371671e-02f, -4.19633500e-02f, -7.44857788e-02f, 3.00033569e-01f, 2.65670836e-01f, -3.96462291e-01f, -1.48943320e-01f,
  -2.86090598e-02f, -2.43685022e-01f, 1.52598470e-01f, -7.14657605e-02f, 8.70710090e-02f, 1.10580504e-01f, 3.14125687e-01f, -4.53788251e-01f, 1.77752554e-01f, 5.45162857e-01f,
  -1.08775690e-01f, -8.09231028e-02f, -2.22547084e-01f, -1.79900765e-01f, 3.11190814e-01f, 2.07409379e-03f, 7.18244165e-02f, 1.68833137e-01f, 1.91059232e-01f, -1.05895370e-01f,
  6.03821501e-02f, 1.70093030e-01f, 2.14289039e-01f, 2.00786769e-01f, -2.10583717e-01f, 6.27780035e-02f, -2.31054217e-01f, -4.85403053e-02f, 3.95211369e-01f, 8.59744996e-02f,
  -3.61112028e-01f, 2.01163441e-01f, 2.34365299e-01f, 2.21694946e-01f, -8.05343688e-02f, 1.16931818e-01f, -2.18047634e-01f, -6.11651316e-02f, 4.89240557e-01f, -2.29611292e-01f,
  1.35780647e-01f, 1.43388852e-01f, -4.55097109e-02f, 7.76734352e-02f, 1.10923583e-02f, -1.40629649e-01f, 4.00108576e-01f, 1.94301397e-01f, 1.18019290e-01f, -3.36294770e-02f,
  3.64222854e-01f, 6.65015802e-02f, 2.38728449e-01f, 3.89492251e-02f, 1.59733906e-01f, 4.20180380e-01f, -1.61332250e-01f, 5.17183281e-02f, 1.62214816e-01f, -6.05429001e-02f,
  6.69420697e-03f, -1.21322302e-02f, 2.49048591e-01f, -3.28922153e-01f, 1.04466736e-01f, 3.30334663e-01f, 5.63292876e-02f, -6.96228743e-02f, -1.25763535e-01f, -1.66701108e-01f,
  1.59552563e-02f, 9.58327204e-03f, 1.37305439e-01f, 9.72904190e-02f, -2.47506365e-01f, 2.65062749e-01f, -1.25411496e-01f, -2.11909041e-01f, -1.26362309e-01f, 1.12610981e-01f,
  3.58648360e-01f, 1.12161793e-01f, 5.79276979e-01f, 3.91717941e-01f, 1.43825442e-01f, -5.21410331e-02f, 2.27349058e-01f, 1.38245657e-01f, -1.70764223e-01f, 4.92917001e-02f,
  3.72432947e-01f, -5.82583137e-02f, 6.74456172e-03f, 3.57336551e-01f, 3.10630165e-02f, 1.18484229e-01f, -1.93423316e-01f, 1.45938456e-01f, -3.57917219e-01f, -1.22699350e-01f,
  4.40847218e-01f, 1.23158008e-01f, -1.64824322e-01f, -1.68741509e-01f, -2.51911432e-01f, 4.92204875e-01f, -2.68272787e-01f, -1.97391108e-01f, 1.18064053e-01f, -1.41031623e-01f,
  -9.56131667e-02f, 2.05105338e-02f, 2.31637180e-01f, 2.58560896e-01f, -2.17231020e-01f, 9.37858671e-02f, 1.59077957e-01f, 1.72319099e-01f, -2.84305543e-01f, -4.57029462e-01f,
  1.84642136e-01f, 7.53554627e-02f, -7.58229643e-02f, -3.95655334e-02f, -6.33822381e-02f, -4.71392483e-01f, 1.36851221e-01f, 3.78120840e-01f, 2.82247484e-01f, -2.46477306e-01f,
  3.60833585e-01f, 2.55625278e-01f, 2.65041322e-01f, 2.28234991e-01f, 6.53784052e-02f, 3.18618715e-01f, -7.32139423e-02f, -2.19616875e-01f, -1.27828613e-01f, -9.06269401e-02f,
  3.44242871e-01f, -2.35633925e-01f, -1.47972703e-01f, -3.44392985e-01f, 3.72966617e-01f, 7.72878155e-02f, 1.60254568e-01f, 1.65570021e-01f, 5.60863674e-01f, 3.04982483e-01f,
  3.17099035e-01f, 1.47552788e-01f, -2.84006536e-01f, 8.44766870e-02f, 6.47103414e-03f, 4.57543552e-01f, -3.22073251e-01f, -4.59185988e-01f, 4.32377934e-01f, -7.86787122e-02f,
  3.88683438e-01f, -2.29643375e-01f, 1.87600568e-01f, 3.81634124e-02f, 1.61797136e-01f, -1.01597853e-01f, -1.06800765e-01f, 2.17666626e-01f, -1.17902532e-01f, -1.08410884e-02f,
  -5.09628117e-01f, 7.70952478e-02f, -4.18135105e-03f, -3.59819889e-01f, 3.24101806e-01f, -8.19706097e-02f, 3.08392216e-02f, -7.02382401e-02f, 2.25928456e-01f, -5.01928441e-02f,
  3.22376400e-01f, 1.86998069e-01f, -3.32082957e-01f, -1.51487403e-02f, -3.74059938e-02f, -1.19352497e-01f, 2.02177018e-02f, -2.54131764e-01f, 9.97595266e-02f, -9.07957740e-03f,
  2.02788815e-01f, -1.93546638e-01f, -4.73475754e-01f, 1.85792953e-01f, 1.39111638e-01f, -4.20262456e-01f, -6.53548002e-01f, 2.36232132e-01f, -9.62156653e-02f, 5.43917179e-01f,
  2.69226320e-02f, -5.41200265e-02f, -5.99884205e-02f, 2.61302531e-01f, 7.76963234e-02f, -3.15654092e-02f, -1.93489179e-01f, 3.13302457e-01f, -3.71631011e-02f, -2.07228541e-01f,
  1.52062774e-01f, 8.65302458e-02f, -7.39930496e-02f, 8.18547010e-02f, 2.40960553e-01f, 2.68027306e-01f, -1.30354300e-01f, 8.46858621e-02f, -1.54992208e-01f, 1.00891486e-01f,
  -9.64217186e-02f, 1.21355139e-01f, 3.29032362e-01f, 3.73621523e-01f, 8.88620093e-02f, -4.28624988e-01f, -5.55002570e-01f, 2.06307769e-01f, -7.60483230e-03f, 1.46423236e-01f,
  4.23379242e-01f, -2.24470258e-01f, 1.73137020e-02f, -1.84135929e-01f, 7.35211223e-02f, -2.59234101e-01f, -4.12201062e-02f, 1.40317336e-01f, 5.54219484e-01f, 1.58640757e-01f,
  1.39777124e-01f, 1.60928711e-01f, -1.30714327e-01f, 1.14691578e-01f, 2.61567533e-01f, 1.90722570e-02f, -3.11596185e-01f, -4.46772873e-01f, -2.15432215e-02f, -2.56580889e-01f,
  6.97705150e-02f, 7.74706006e-02f, -1.93498909e-01f, 3.98060083e-01f, -3.66696209e-01f, -2.00336322e-01f, 9.26497281e-02f, 6.07139729e-02f, -1.72795773e-01f, -1.20922156e-01f,
  3.48483980e-01f, -1.32876113e-01f, -1.70195252e-01f, 1.08986005e-01f, -2.23302469e-01f, -1.90202102e-01f, -9.33842212e-02f, -1.74403600e-02f, 1.57108843e-01f, -4.13517833e-01f,
  -3.36899817e-01f, 3.03804010e-01f, 2.89956387e-03f, 9.28242430e-02f, -1.87334910e-01f, 1.92144856e-01f, -9.73688141e-02f, 3.91603913e-04f, -1.36361003e-01f, 5.98197468e-02f,
  -2.10179333e-02f, 2.34208647e-02f, -7.67696649e-02f, -2.44001269e-01f, 1.76169872e-01f, -3.45512152e-01f, 4.45057631e-01f, -3.24282438e-01f, -6.61098599e-01f, 1.12620369e-01f,
  2.47541681e-01f, -2.22558692e-01f, -6.45499527e-01f, 3.07473600e-01f, -1.66943088e-01f, 4.29688185e-01f, 2.29750067e-01f, -2.15645343e-01f, -4.81701463e-01f, 4.01163131e-01f,
  2.24437371e-01f, 3.86582196e-01f, -3.26410711e-01f, -2.08744034e-01f, 1.62097648e-01f, 2.65889242e-02f, 1.38588309e-01f, 2.86413848e-01f, 5.20808995e-03f, -5.61322309e-02f,
  9.12739336e-03f, -3.95034291e-02f, -2.30282456e-01f, 1.99962500e-02f, 1.29649714e-01f, 3.08054276e-02f, -4.05742168e-01f, -3.38394850e-01f, 4.93541509e-01f, 1.63611710e-01f,
  2.22169105e-02f, 6.69764206e-02f, -1.09767094e-01f, 2.12049216e-01f, 3.87728959e-01f, 2.34308153e-01f, -1.15560457e-01f, 3.66537750e-01f, 6.43658787e-02f, -1.80732787e-01f,
  -4.40189272e-01f, 8.62903893e-02f, 4.68223035e-01f, 4.61916365e-02f, 8.21120441e-02f, -1.20207503e-01f, 2.81693071e-01f, 1.95874870e-01f, -1.39606878e-01f, 2.37191007e-01f,
  1.00931138e-01f, 1.89682841e-01f, -2.59543955e-01f, -1.47740439e-01f, 3.98168564e-01f, 2.60549355e-02f, 1.84134796e-01f, -2.13156566e-01f, 4.14362410e-03f, -2.09377810e-01f,
  2.14516208e-01f, -9.42128599e-02f, 7.14691430e-02f, 1.94547549e-02f, 4.77863252e-01f, -1.90336481e-01f, -8.48435014e-02f, 2.29484245e-01f, 1.41841590e-01f, 1.94424987e-01f,
  4.82289255e-01f, -3.01830292e-01f, -3.80831398e-02f, 3.16477299e-01f, 1.55942179e-02f, 4.06738967e-01f, -2.70376801e-01f, -2.37083972e-01f, 7.66084017e-03f, -3.41887288e-02f,
  -2.22766846e-01f, 1.49719357e-01f, 1.54596686e-01f, -1.45087410e-02f, -4.27754641e-01f, -2.27121234e-01f, -5.83910286e-01f, -2.35181078e-01f, 6.81840032e-02f, -9.25603732e-02f,
  -1.76821709e-01f, -1.95595220e-01f, 1.21666342e-02f, 5.63991070e-02f, -5.53464051e-03f, -2.36359034e-02f, -1.16670519e-01f, 1.08121157e-01f, 2.51865387e-02f, 7.52424300e-02f,
  -2.39972100e-01f, 3.23971033e-01f, 1.47544295e-01f, -2.87500024e-01f, -3.24587822e-01f, 4.27497298e-01f, 3.91585737e-01f, -1.49423242e-01f, -1.05100945e-01f, 5.71981911e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.19826519e-01f, 2.27861986e-01f, 1.39071167e-01f, 3.66606653e-01f, -1.56514555e-01f, 3.26397747e-01f, -2.58279517e-02f, 2.67735392e-01f, 7.29903132e-02f, 2.98780531e-01f,
  1.83468148e-01f, 1.29738614e-01f, 3.23761642e-01f, 2.76250750e-01f, -3.08703721e-01f, -1.15409099e-01f, 5.60855828e-02f, 2.79054433e-01f, 3.80309671e-01f, -7.87353441e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.33281741e-02f, 1.71797052e-02f, 1.86573729e-01f, 1.28031438e-02f, -2.71243721e-01f, 1.51668321e-02f, -7.73746520e-02f, -2.57566035e-01f, 3.53945315e-01f, -5.73686436e-02f,
  8.83052032e-03f, 7.41875768e-02f, -3.05549446e-02f, 6.72694668e-02f, -1.88652068e-01f, -2.54063219e-01f, 3.02754998e-01f, -1.39882565e-01f, -1.74800545e-01f, -3.53692807e-02f,
  1.55632094e-01f, 4.05757651e-02f, 3.21620665e-02f, -8.20322633e-02f, 1.89651817e-01f, 7.55204409e-02f, 2.26229623e-01f, -2.13799894e-01f, -1.16287194e-01f, 2.36368701e-01f,
  -2.70715415e-01f, -2.10476458e-01f, 2.60634512e-01f, 2.43920371e-01f, -8.10541958e-02f, 8.58910978e-02f, 5.22367299e-01f, 2.60297835e-01f, 1.08149007e-01f, 1.47170484e-01f,
  3.10093433e-01f, 3.87117833e-01f, -4.86706585e-01f, -4.19056922e-01f, 4.03799117e-02f, -1.16784610e-01f, -1.06993355e-02f, -1.67663977e-01f, -1.48896173e-01f, -1.18725710e-01f,
  -2.02796772e-01f, 2.95394026e-02f, -2.11388305e-01f, 1.67345643e-01f, -5.60235567e-02f, -8.97383541e-02f, 2.52943277e-01f, 3.47965509e-02f, -1.18972763e-01f, -8.18133131e-02f,
  1.78142741e-01f, 9.24963281e-02f, -1.07227778e-03f, -1.23679042e-01f, -2.98221558e-01f, 2.91313827e-01f, -1.72758490e-01f, 9.24694613e-02f, -2.14901581e-01f, -9.66969505e-02f,
  -4.53596741e-01f, -4.02466476e-01f, -1.38452100e-02f, 1.33902337e-02f, -2.10622877e-01f, 1.46841615e-01f, -4.07489747e-01f, -1.04731888e-01f, -3.09433699e-01f, -4.80395965e-02f,
  3.42053264e-01f, 1.58982515e-01f, -1.84804857e-01f, -1.00901820e-01f, -1.26614459e-02f, -2.21082658e-01f, 1.36303946e-01f, 1.71016559e-01f, -4.18848656e-02f, 1.94595486e-01f,
  1.42784074e-01f, 2.76643187e-01f, 6.43827692e-02f, 1.63571998e-01f, -1.82318315e-01f, 4.48401496e-02f, 6.41071871e-02f, 1.25494152e-02f, -2.84559458e-01f, -1.45315871e-01f,
  -1.54128745e-01f, -8.76695961e-02f, 6.72020242e-02f, -1.09130621e-01f, -6.51506241e-03f, 2.17585638e-01f, 3.97793902e-03f, -2.13887006e-01f, -7.56816864e-02f, -2.74927884e-01f,
  -8.13328624e-02f, 8.01429674e-02f, -1.76190317e-01f, -1.54346168e-01f, 7.86881968e-02f, -1.70632705e-01f, -1.70700952e-01f, -1.47671416e-01f, -5.23021296e-02f, 3.22830021e-01f,
  5.69889508e-02f, -8.05986896e-02f, -1.73977897e-01f, 2.64360934e-01f, -6.93414137e-02f, 1.35767058e-01f, 1.45206302e-01f, 9.61560383e-02f, 2.16258675e-01f, -1.29887998e-01f,
  -9.78583544e-02f, -5.49056344e-02f, 3.06315243e-01f, 1.21173179e-02f, -1.41033649e-01f, 1.92962527e-01f, 1.44317657e-01f, -2.30343314e-03f, 3.38519365e-03f, -1.29894063e-01f,
  2.09146202e-01f, -1.66761011e-01f, 5.18626086e-02f, -2.18108622e-03f, -1.69590488e-01f, -6.31667152e-02f, -3.22542220e-01f, 5.30758053e-02f, -2.24774703e-01f, -1.98901117e-01f,
  2.01098889e-01f, 4.00780588e-02f, 6.01637661e-02f, -2.85530806e-01f, -6.53037578e-02f, 3.38630587e-01f, 1.10616930e-01f, 3.48467827e-02f, 6.20102212e-02f, -1.11715332e-01f,
  -9.39512923e-02f, -2.79832780e-02f, -2.63202250e-01f, -1.55163348e-01f, 2.38167822e-01f, 3.42414439e-01f, -1.56033546e-01f, 5.39779291e-02f, -3.09112226e-03f, 1.81334868e-01f,
  2.12437749e-01f, -2.84468859e-01f, -9.80935171e-02f, 2.59795915e-02f, 1.58302858e-01f, 1.70700625e-01f, -1.59553722e-01f, 2.06862286e-01f, -2.69749254e-01f, -2.12362513e-01f,
  -2.75132447e-01f, 1.00876473e-01f, -6.12772210e-03f, 2.09994480e-01f, -1.34383634e-01f, -2.23588929e-01f, 9.53463092e-03f, 1.68951139e-01f, -4.36346270e-02f, 5.35809398e-02f,
  -3.97868305e-02f, -1.33951083e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.35350096e-01f, 2.93635607e-01f, -1.36645511e-01f, 7.58130029e-02f, 3.78442019e-01f, 2.64519513e-01f, 5.30299366e-01f, 2.59311825e-01f, -9.38889757e-02f, 4.06310886e-01f,
  -1.40328690e-01f, -6.47955909e-02f, 3.96020710e-01f, 4.04447109e-01f, 3.11294675e-01f, -4.71948925e-03f, -1.48443341e-01f, -1.50851384e-01f, -2.19600439e-01f, -3.86233568e-01f,
  -3.01736087e-01f, -1.15978885e-02f, -4.06305343e-01f, 2.80143708e-01f, 2.46551216e-01f, -1.70308381e-01f, -3.89559239e-01f, 1.96634188e-01f, -1.19285218e-01f, -1.33037567e-01f,
  2.36760408e-01f, 4.82120644e-03f, 2.19617665e-01f, 6.87941611e-02f, -2.55299881e-02f, 4.50069278e-01f, 9.58716217e-03f, 1.57968819e-01f, 5.74313283e-01f, 2.92665660e-01f,
  -1.59627840e-01f, 1.77903563e-01f, 7.41150975e-01f, 2.43357152e-01f, 2.64739037e-01f, -1.15570299e-01f, 1.17714658e-01f, -5.11180870e-02f, -6.90868497e-02f, -4.57089126e-01f,
  -9.68315527e-02f, 3.05225939e-01f, -1.13701977e-01f, -1.36056216e-02f, -1.38181061e-01f, 3.69723260e-01f, 5.78961968e-01f, -1.68505788e-01f, 2.64380783e-01f, -7.96689451e-01f,
  -4.40541059e-02f, 1.93884790e-01f, 6.25360608e-02f, -3.30438912e-01f, -1.91748857e-01f, 1.91170394e-01f, 2.19979793e-01f, 3.18740606e-01f, 1.19489439e-01f, 2.43540764e-01f,
  1.46407411e-01f, 6.67563826e-02f, -1.73939884e-01f, 3.13883007e-01f, 2.97648698e-01f, 5.87387502e-01f, 2.11097881e-01f, 2.46306017e-01f, -3.86379249e-02f, 3.28654528e-01f,
  -4.32204217e-01f, 6.19372129e-02f, 3.35505337e-01f, 3.87798101e-01f, -1.14994399e-01f, 2.89728492e-01f, 5.29755175e-01f, 4.02482115e-02f, 5.40216686e-03f, 1.77851871e-01f,
  -3.47256094e-01f, 8.64558592e-02f, 3.59007299e-01f, -4.08187181e-01f, 1.23140864e-01f, -2.72534430e-01f, 3.45804449e-03f, 1.15954034e-01f, -3.15042228e-01f, 5.49313277e-02f,
  1.53679281e-01f, -3.38342726e-01f, -8.36949795e-02f, 2.52934396e-01f, 3.33471507e-01f, -4.99168634e-02f, 9.30658653e-02f, -5.04844844e-01f, 1.16045378e-01f, -4.89051193e-02f,
  2.62904137e-01f, -4.83643338e-02f, 3.04698497e-01f, 9.87602994e-02f, -3.61638010e-01f, -5.95064521e-01f, -2.54198432e-01f, -1.57497719e-01f, -2.82099426e-01f, 3.62779081e-01f,
  2.37451479e-01f, 1.00912012e-01f, 1.61835492e-01f, -1.34463742e-01f, 1.37590557e-01f, 3.12350303e-01f, 9.01681022e-04f, 1.74358469e-02f, 6.33404106e-02f, 5.52702963e-01f,
  3.67574900e-01f, 4.10379797e-01f, 3.44200492e-01f, 3.91609013e-01f, 3.11723948e-01f, -5.69178797e-02f, -1.45987108e-01f, -2.01237828e-01f, -4.12057221e-01f, 3.61973047e-01f,
  3.80258411e-01f, 2.41310015e-01f, 5.36478721e-02f, 1.70532286e-01f, -7.84625262e-02f, 1.14596728e-02f, -1.79096423e-02f, 2.70227879e-01f, 1.14488155e-01f, 4.17832702e-01f,
  -1.83866769e-01f, -2.03121975e-01f, -1.90959834e-02f, 1.80869594e-01f, 5.99396490e-02f, -7.04183519e-01f, 5.12316704e-01f, 1.29591273e-02f, 2.92151242e-01f, -1.11979045e-01f,
  1.38345256e-01f, 1.22817531e-02f, -2.75815636e-01f, 1.37386829e-01f, 2.18001939e-03f, 8.96880627e-02f, 4.25336599e-01f, 3.50832999e-01f, 2.11156562e-01f, 4.87513319e-02f,
  3.67078274e-01f, -2.64836699e-01f, 1.29781947e-01f, -1.38586760e-01f, 4.32021737e-01f, -3.01872510e-02f, 1.07675567e-01f, 2.16396209e-02f, -2.53245711e-01f, 5.20273810e-03f,
  1.19307488e-01f, -9.49143618e-02f, -3.52300592e-02f, 2.41416931e-01f, 2.57195503e-01f, -1.94451869e-01f, 2.75709897e-01f, -4.69607294e-01f, -2.43498191e-01f, 2.05080807e-01f,
  -1.70339197e-01f, -1.57544807e-01f, 1.98145449e-01f, 4.78280157e-01f, 3.82157743e-01f, 2.28592873e-01f, 3.63577396e-01f, 2.49761343e-01f, 3.89283568e-01f, 5.72121441e-01f,
  2.09247917e-01f, 4.05600727e-01f, -2.38758847e-01f, 2.01240987e-01f, 4.45345968e-01f, 1.40732214e-01f, 1.58895209e-01f, 4.75435376e-01f, -2.12765157e-01f, 4.08878038e-03f,
  -3.22438963e-02f, 1.56123014e-02f, -1.07475825e-01f, 5.24034083e-01f, 1.31050870e-01f, -1.00260325e-01f, 2.02532157e-01f, 8.46311599e-02f, -2.53660202e-01f, -1.60947889e-01f,
  1.02578864e-01f, -3.37752402e-02f, 4.82949466e-01f, -3.00332248e-01f, 9.00512412e-02f, -2.19424386e-02f, 3.32706869e-01f, 2.38774717e-01f, 3.00156325e-01f, 3.43597084e-01f,
  1.70255676e-01f, 3.15924615e-01f, 4.38637614e-01f, 2.88024843e-01f, 1.24844573e-01f, -3.38335872e-01f, 3.68544191e-01f, -7.10938200e-02f, 1.26707613e-01f, 4.49511111e-01f,
  -1.32605553e-01f, -6.42342633e-03f, -3.12700212e-01f, -3.53256352e-02f, -9.28949043e-02f, 9.95690525e-02f, 4.17683721e-01f, 1.42712131e-01f, 1.99957803e-01f, -4.02969062e-01f,
  1.13747388e-01f, -1.03876730e-02f, -3.50671679e-01f, 3.54873449e-01f, -1.23356208e-01f, -1.38798013e-01f, -2.93329626e-01f, -2.42749169e-01f, 3.16652879e-02f, -1.24791026e-01f,
  1.99913643e-02f, 2.03968640e-02f, -6.77183628e-01f, -3.08199584e-01f, 4.23586443e-02f, 1.51944190e-01f, -9.97611601e-03f, -1.93786055e-01f, -3.05394918e-01f, -9.86789614e-02f,
  -1.00166745e-01f, -1.60032019e-01f, 2.01939002e-01f, 1.86712801e-01f, -1.25665441e-01f, -1.07250541e-01f, -3.58299389e-02f, -3.29660058e-01f, 3.56589288e-01f, 3.20005774e-01f,
  3.39196652e-01f, 4.10599001e-02f, -2.80317992e-01f, 7.24571288e-01f, 4.08186242e-02f, 2.54744947e-01f, -1.11165848e-02f, 4.49709773e-01f, -1.43476397e-01f, -5.34035146e-01f,
  1.86650500e-01f, -1.85742810e-01f, 1.24732271e-01f, 3.22184414e-01f, 1.01649888e-01f, -2.05890507e-01f, 7.31187612e-02f, 2.25449577e-01f, -6.60183966e-01f, 1.39042020e-01f,
  2.63737682e-02f, 2.81737536e-01f, 1.95799351e-01f, 1.08548775e-01f, 2.56484628e-01f, 4.26819831e-01f, 2.22107306e-01f, 5.76084033e-02f, 3.16163659e-01f, 2.04464853e-01f,
  -1.63855016e-01f, -5.00966907e-01f, -6.15578175e-01f, 5.53493381e-01f, 3.21475804e-01f, -3.05638045e-01f, 1.40490532e-01f, -9.00578722e-02f, 1.75205410e-01f, 6.16493821e-01f,
  1.99497063e-02f, -4.33675885e-01f, 1.68487895e-02f, -3.00832272e-01f, -4.55875605e-01f, -2.18742400e-01f, 1.59912899e-01f, 2.47571439e-01f, -3.26204568e-01f, -2.54067421e-01f,
  1.60430580e-01f, 3.78101021e-01f, 6.22522682e-02f, 2.22676456e-01f, 6.61477447e-02f, 1.14695951e-01f, 1.91018939e-01f, 2.58965850e-01f, 2.84290105e-01f, 8.55584070e-02f,
  2.26204380e-01f, 2.25607693e-01f, 4.57270257e-02f, -4.85278338e-01f, -6.56894982e-01f, 1.53192818e-01f, 5.88716716e-02f, -4.91001576e-01f, -8.37321281e-02f, -7.99394548e-01f,
  1.53020978e-01f, -3.64044458e-02f, 1.36171088e-01f, 7.27102578e-01f, 1.41024038e-01f, 4.36274856e-01f, 2.94958055e-01f, 5.09891436e-02f, -1.85202718e-01f, 7.75103047e-02f,
  4.10656512e-01f, 4.18918908e-01f, 5.05466580e-01f, 2.99900770e-01f, 1.40355036e-01f, -8.88602510e-02f, -1.20141245e-01f, 3.46826136e-01f, -3.53339553e-01f, 6.81062117e-02f,
  3.07921201e-01f, 3.49367678e-01f, -1.11670040e-01f, 1.94478393e-01f, 4.95625377e-01f, 9.70544219e-02f, 4.11599308e-01f, -3.18234742e-01f, -3.60847414e-01f, 5.70068896e-01f,
  -4.74292964e-01f, 3.00923169e-01f, -5.19944578e-02f, -2.45580271e-01f, -2.33808428e-01f, -1.21019259e-01f, -4.66003716e-02f, 2.19844937e-01f, 2.60359198e-01f, 8.05037022e-02f,
  -3.02584827e-01f, 4.01021652e-02f, 2.80078351e-01f, 1.43571422e-01f, -1.24658905e-01f, -4.63866629e-02f, -3.02770555e-01f, 1.57205723e-02f, -8.31394866e-02f, -8.27000663e-02f,
  2.26691023e-01f, 2.46176988e-01f, 1.34925753e-01f, -2.63623416e-01f, -1.55238196e-01f, -3.58002514e-01f, 3.27047437e-01f, 5.27515411e-01f, 2.73341197e-03f, 3.23237419e-01f,
  -3.23991477e-02f, 2.54073173e-01f, 4.64272112e-01f, 2.73268461e-01f, 2.12382481e-01f, 1.46369189e-01f, 1.11954600e-01f, 5.07982433e-01f, 1.15431696e-01f, 5.87217137e-02f,
  5.09415865e-01f, 4.38794762e-01f, 3.88158679e-01f, 2.84985662e-01f, 3.99896532e-01f, 3.67570639e-01f, -4.59086359e-01f, -1.35154724e-01f, 2.33603671e-01f, 1.18012011e-01f,
  3.40975851e-01f, -1.97365899e-02f, -1.45074623e-02f, 7.48744756e-02f, -2.68490970e-01f, -5.65744460e-01f, -2.35685967e-02f, -1.12401411e-01f, -6.61382616e-01f, 3.86887759e-01f,
  3.20405141e-02f, 8.36614445e-02f, -3.34137619e-01f, 6.82602078e-02f, 3.56076211e-01f, 1.57068804e-01f, 1.25665143e-01f, 3.35607529e-01f, 1.33386850e-01f, 3.34778756e-01f,
  -2.04009131e-01f, 2.57887036e-01f, 9.16373134e-02f, 2.86718249e-01f, 3.19989711e-01f, 3.30700547e-01f, -2.30033204e-01f, 1.71212643e-01f, 3.23627353e-01f, -1.27580374e-01f,
  5.30589700e-01f, 3.38696897e-01f, 3.90967458e-01f, 1.42909318e-01f, -6.05968153e-03f, -1.67502433e-01f, 1.38055650e-03f, -8.43944699e-02f, 1.32270470e-01f, 1.51468024e-01f,
  -4.40948665e-01f, 2.81238228e-01f, 2.59208679e-01f, -2.91657168e-02f, 1.64334416e-01f, -2.47329667e-01f, 7.99067598e-03f, -7.19523802e-02f, 3.60494167e-01f, -1.25460222e-01f,
  1.39461517e-01f, 4.10526395e-01f, 5.29731989e-01f, 7.02958405e-02f, -1.47626609e-01f, 1.06607102e-01f, -1.82700172e-01f, 1.09246425e-01f, 2.29804069e-01f, -1.72921613e-01f,
  3.59370634e-02f, 4.44845945e-01f, 2.29529962e-01f, -1.72655448e-01f, 1.34455916e-02f, 2.90288568e-01f, -2.52984762e-02f, 1.81191519e-01f, 1.29907250e-01f, 2.64671773e-01f,
  2.27159008e-01f, 4.89553720e-01f, 1.84872806e-01f, -2.51385808e-01f, 7.94711709e-03f, -8.82194564e-02f, -1.35472015e-01f, -1.33730158e-01f, -2.39115268e-01f, -2.55916089e-01f,
  -1.52571902e-01f, -3.01842511e-01f, 2.44778037e-01f, 4.07502830e-01f, 4.58297133e-02f, 5.08738577e-01f, 4.01064083e-02f, 7.25506246e-03f, 9.23539996e-02f, -5.14819883e-02f,
  2.71690190e-01f, 3.78402144e-01f, 5.56481659e-01f, -2.44352162e-01f, -1.69753477e-01f, -1.73297003e-01f, 7.60438445e-04f, -8.35873857e-02f, 3.45952302e-01f, 1.03364266e-01f,
  6.35154694e-02f, 2.89481491e-01f, 3.28642517e-01f, 7.58216381e-02f, 1.57426059e-01f, 2.27984145e-01f, 5.28850615e-01f, 1.67593136e-02f, -1.09650614e-02f, -2.90129948e-02f,
  -3.87152523e-01f, 2.46256381e-01f, -1.97587237e-01f, 2.26498675e-02f, -4.97859679e-02f, -5.56269586e-01f, 7.13772252e-02f, 9.15244967e-02f, -2.08914399e-01f, 9.69529152e-02f,
  2.56910980e-01f, 4.53297615e-01f, -1.02408803e+00f, -1.91433981e-01f, 6.37659907e-01f, 1.64409190e-01f, 2.50648886e-01f, -8.57763141e-02f, 3.82962406e-01f, -3.69189493e-02f,
  3.11814677e-02f, 1.78588629e-02f, 1.11807846e-01f, 2.79162794e-01f, -4.23446223e-02f, -3.85516971e-01f, 1.85978543e-02f, 3.04704338e-01f, -2.54012436e-01f, -3.25049423e-02f,
  9.28751975e-02f, -1.43511757e-01f, 2.87427288e-02f, -4.62238282e-01f, 4.60728735e-01f, -6.74664021e-01f, -2.60895997e-01f, 9.57607776e-02f, 1.67406176e-03f, 1.41875818e-01f,
  5.72062612e-01f, 4.19871926e-01f, -9.87251997e-02f, 8.11976492e-02f, -2.50279874e-01f, -3.82924713e-02f, -4.61164653e-01f, 7.73808584e-02f, -1.87349603e-01f, 3.21901068e-02f,
  -1.50378421e-01f, 2.61292040e-01f, 1.87287942e-01f, 8.88308585e-02f, 1.63497597e-01f, -2.80199587e-01f, -1.85388535e-01f, -1.83743685e-01f, -2.38282323e-01f, 2.24563643e-01f,
  4.29463275e-02f, 1.54165849e-01f, -2.34300151e-01f, 2.49852076e-01f, 6.17380679e-01f, 1.42370552e-01f, 2.21336886e-01f, 2.83670455e-01f, 2.95900367e-02f, -3.67541641e-01f,
  -4.63140607e-02f, 3.35438214e-02f, -2.80187488e-01f, 5.47395386e-02f, 1.83899477e-01f, 1.75167471e-01f, 4.59155738e-01f, -2.09326357e-01f, 3.01622421e-01f, -2.60855317e-01f,
  -3.44293505e-01f, -8.83671269e-02f, 1.02815591e-01f, -7.92621896e-02f, 4.05080676e-01f, 2.87576795e-01f, -2.62068696e-02f, 1.50355518e-01f, 2.05782622e-01f, -3.75866741e-01f,
  2.73875147e-01f, 1.83774740e-01f, -3.52010876e-02f, 1.51418850e-01f, 3.14048678e-01f, -3.45242143e-01f, -1.97223037e-01f, -4.31842729e-03f, -1.72661856e-01f, -4.49907839e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  1.48922861e-01f, 6.73493072e-02f, 3.40703636e-01f, 5.03740944e-02f, 2.20570534e-01f, -5.20151295e-02f, 2.31597066e-01f, 2.55467564e-01f, -2.72478200e-02f, 1.46818534e-01f,
  -1.62818387e-01f, 2.98539519e-01f, 1.51211500e-01f, 3.18178803e-01f, 1.72497764e-01f, 3.65104884e-01f, -4.29716473e-03f, -1.41276479e-01f, 1.61549464e-01f, -5.09709381e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  3.08791459e-01f, -1.04693741e-01f, 7.58388489e-02f, 2.54705429e-01f, 1.39541000e-01f, -5.95911555e-02f, -2.12206952e-02f, -2.16564000e-01f, -3.32225077e-02f, -1.21057004e-01f,
  -2.02425987e-01f, 2.60467976e-02f, -3.27064395e-02f, 2.97426097e-02f, 1.35363638e-01f, -8.26022625e-02f, 1.32916728e-02f, -2.61446625e-01f, -1.72833260e-03f, -2.27046907e-01f,
  -2.39061727e-03f, -2.12421432e-01f, -1.99864656e-01f, 3.53216678e-01f, -1.27898306e-01f, 4.76612635e-02f, -5.67664132e-02f, -6.96628913e-02f, 1.45241953e-02f, 2.56999820e-01f,
  1.37683943e-01f, -3.04974914e-01f, 4.17903624e-02f, -2.89477885e-01f, -1.52997166e-01f, 8.81505311e-02f, -1.49552718e-01f, 1.42008007e-01f, -3.79405588e-01f, 1.97681978e-01f,
  -4.74898487e-01f, 4.84509021e-01f, 4.68777478e-01f, 4.01785582e-01f, 1.02606975e-01f, 1.88109830e-01f, 8.46928433e-02f, 3.75642814e-02f, -1.04126289e-01f, -2.51493484e-01f,
  2.70682633e-01f, 6.60353452e-02f, 5.59024252e-02f, -1.79126590e-01f, 2.49002576e-02f, 2.51340300e-01f, -9.35712308e-02f, 2.74610892e-02f, 2.94181675e-01f, -2.50146896e-01f,
  -1.82921097e-01f, 3.40970010e-01f, -8.80813450e-02f, -2.67124325e-01f, 8.64962339e-02f, 5.02996705e-02f, 2.59761393e-01f, 2.36697614e-01f, -1.89164374e-02f, -2.67114490e-01f,
  -2.77143538e-01f, -3.51356059e-01f, 5.00386775e-01f, -2.04655752e-01f, -3.33951503e-01f, -7.15386197e-02f, -1.16898842e-01f, -7.01637566e-02f, 2.12789670e-01f, 3.47869135e-02f,
  -4.09281179e-02f, -2.07754791e-01f, 1.95883214e-01f, -1.83768019e-01f, 3.61746065e-02f, -2.19804645e-01f, 6.46743737e-03f, -4.55406606e-02f, 1.15221083e-01f, -7.73714110e-02f,
  -2.21271664e-01f, 1.99210301e-01f, -7.72111118e-02f, 5.06997220e-02f, 8.16259235e-02f, -1.14185601e-01f, -3.46809775e-01f, 2.11326107e-01f, -3.59944776e-02f, 1.31769642e-01f,
  1.55777648e-01f, 3.84394079e-01f, 9.66269672e-02f, 1.39693573e-01f, 4.50163305e-01f, -4.80126381e-01f, 1.08267471e-01f, -7.38166496e-02f, -1.34771571e-01f, 1.13310196e-01f,
  6.31111264e-02f, 9.84438509e-02f, 3.68998535e-02f, -1.78159580e-01f, 1.40099879e-02f, -1.53461741e-02f, -1.65459976e-01f, -3.98821905e-02f, -4.61472780e-01f, -2.00374722e-02f,
  2.15601787e-01f, 1.01087548e-01f, -1.48157209e-01f, 1.91997021e-01f, 6.82231486e-02f, -2.11426690e-01f, 1.16783872e-01f, 9.65133235e-02f, -3.23331475e-01f, -1.76336825e-01f,
  -5.53124920e-02f, 1.89841241e-01f, 3.92855369e-02f, 7.94706345e-02f, -4.66287166e-01f, 2.77912408e-01f, -4.79288161e-01f, 9.06332135e-02f, 2.63515711e-01f, 1.14639513e-01f,
  2.11318694e-02f, -1.31066784e-01f, -1.14683419e-01f, 1.91562790e-02f, -1.35061756e-01f, 1.69432774e-01f, -9.20797698e-03f, 2.89401740e-01f, -1.76890731e-01f, 1.01286620e-01f,
  -7.76615813e-02f, -8.78985077e-02f, -3.76864150e-02f, -2.14861020e-01f, -1.57706052e-01f, -2.74251830e-02f, 5.85698262e-02f, 1.83505133e-01f, 6.40446171e-02f, 2.63115674e-01f,
  -1.29104242e-01f, -2.95985639e-01f, 1.05059035e-02f, -2.32571494e-02f, 1.11370385e-01f, -9.82894376e-02f, 8.57340246e-02f, -1.52154610e-01f, 3.13384756e-02f, 6.27921373e-02f,
  -6.35609627e-02f, 1.21318713e-01f, -2.37149075e-01f, -1.08410515e-01f, 2.05204561e-02f, 2.78191894e-01f, -2.86744144e-02f, -1.67882696e-01f, 3.05760242e-02f, -1.00165054e-01f,
  1.45628992e-02f, 9.89857037e-03f, 2.04105973e-01f, -1.94271147e-01f, 1.34883776e-01f, -2.26030186e-01f, -2.24567771e-01f, 8.51901099e-02f, 2.13050961e-01f, 3.32916155e-02f,
  -3.30556244e-01f, 2.43073449e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.63145101e-01f, 5.99834733e-02f, -3.68316859e-01f, -3.82588178e-01f, -4.66084480e-02f, -1.30640581e-01f, 6.05457485e-01f, 4.65951532e-01f, -6.16907239e-01f, -2.40252003e-01f,
  -2.52027094e-01f, 2.62481030e-02f, -3.09787601e-01f, 6.88980296e-02f, -9.50050876e-02f, -4.45682675e-01f, 3.33717912e-01f, 1.23872504e-01f, -1.30173117e-02f, 2.16187775e-01f,
  -3.41864198e-01f, 2.83466488e-01f, 7.91913942e-02f, 1.72107518e-01f, -2.82774568e-01f, -2.41034612e-01f, -1.82715818e-01f, 2.22688124e-01f, 1.84706673e-01f, 3.13512273e-02f,
  -1.58430576e-01f, 4.42193896e-02f, -2.29669780e-01f, -2.20744219e-02f, 2.80794889e-01f, 1.44787773e-01f, -1.73724279e-01f, -1.91199750e-01f, -1.72716260e-01f, -2.22974941e-01f,
  1.03899218e-01f, -1.72170490e-01f, -2.07878709e-01f, 5.07099293e-02f, -9.87228453e-02f, -4.43897009e-01f, 3.29405397e-01f, -4.64866348e-02f, 3.16129535e-01f, -3.14778392e-03f,
  4.13258970e-01f, -3.30967963e-01f, -8.93119797e-02f, 3.69211316e-01f, 2.89951801e-01f, 8.80315676e-02f, 2.06301421e-01f, 3.14916134e-01f, -1.23772904e-01f, 7.72784799e-02f,
  -2.29425237e-01f, -3.54241133e-01f, 1.96564376e-01f, 4.16357629e-02f, 1.21774517e-01f, 2.19014958e-01f, -2.03105761e-03f, 9.71831679e-02f, 1.22448750e-01f, 7.66502395e-02f,
  -4.13819477e-02f, -1.32745028e-01f, -4.15682107e-01f, -4.76529777e-01f, -1.98690817e-01f, -3.41358840e-01f, 3.06431800e-01f, 2.26715818e-01f, 5.41353881e-01f, -1.80668190e-01f,
  4.48292494e-01f, 4.39793169e-02f, 6.50921702e-01f, 1.67847812e-01f, -4.75829512e-01f, 8.18607491e-03f, -1.03594013e-01f, 5.76372325e-01f, -1.54826730e-01f, 1.65017277e-01f,
  4.10951197e-01f, 4.56483454e-01f, 1.47894165e-02f, -1.53248794e-02f, -9.37489793e-02f, -2.72372574e-01f, 1.84516534e-01f, -4.69939224e-02f, -1.43560842e-01f, -1.99843660e-01f,
  2.51654446e-01f, -8.56105909e-02f, 3.02651972e-01f, -2.19233632e-01f, -4.57127601e-01f, -3.61730665e-01f, -5.36683142e-01f, -5.04430234e-01f, -4.96415079e-01f, 3.56154382e-01f,
  2.08900884e-01f, -3.20096493e-01f, 1.52664185e-01f, 2.11558789e-01f, -1.25960261e-02f, 1.43774211e-01f, 6.39301389e-02f, 2.93214053e-01f, 2.01125681e-01f, 6.93533719e-02f,
  -1.47279248e-01f, -3.37449163e-01f, -4.11029458e-02f, 3.01679730e-01f, 1.96032882e-01f, 1.27255499e-01f, 1.07998461e-01f, 6.04084916e-02f, 2.32458726e-01f, 5.04638731e-01f,
  -1.81756034e-01f, 1.77067593e-01f, -7.33412877e-02f, 4.20308530e-01f, -3.57857704e-01f, 2.87348300e-01f, 9.86225605e-02f, 2.71123707e-01f, -7.70454705e-02f, 1.88997332e-02f,
  -8.83036703e-02f, -1.55711278e-01f, -2.45291397e-01f, 2.21243218e-01f, 2.61206664e-02f, 3.69306207e-02f, 8.34856108e-02f, -1.81694195e-01f, 2.54857332e-01f, 1.37368172e-01f,
  -6.51668370e-01f, -2.69524068e-01f, 3.35899323e-01f, 1.39366612e-01f, 4.85181808e-02f, -5.08197367e-01f, -1.03372864e-01f, 6.71649948e-02f, 4.79711413e-01f, -3.04632336e-01f,
  1.16075903e-01f, 2.81682044e-01f, 1.03701735e-02f, 3.89074922e-01f, 6.58733666e-01f, 6.77784920e-01f, 3.77052367e-01f, 2.25583404e-01f, -1.98321179e-01f, -6.11311734e-01f,
  1.92270309e-01f, -2.75122672e-01f, 4.19110745e-01f, 4.89863873e-01f, -5.28906398e-02f, -2.29033336e-01f, 6.38076812e-02f, 9.78254750e-02f, 7.04711825e-02f, 2.55196124e-01f,
  -5.73319256e-01f, -3.45153302e-01f, -3.66266757e-01f, -6.86758757e-03f, -2.65001744e-01f, 1.84896037e-01f, 4.14336890e-01f, 1.64010540e-01f, 1.41687915e-01f, 4.26939309e-01f,
  -2.10527912e-01f, 1.37365088e-02f, 2.60397911e-01f, -5.07173352e-02f, 1.81152731e-01f, 1.97140977e-01f, 2.02290207e-01f, -3.34008276e-01f, -3.06193158e-02f, -2.68268883e-01f,
  -3.30337197e-01f, -1.12247057e-01f, -4.70058560e-01f, -1.97072625e-01f, 5.38343228e-02f, -1.86436802e-01f, 5.36295414e-01f, -1.91827983e-01f, 3.24010491e-01f, -4.17232305e-01f,
  3.04383904e-01f, -6.03578448e-01f, 9.87479091e-02f, 2.23384842e-01f, -2.00027879e-02f, -9.84092802e-02f, -5.38691208e-02f, 2.54461868e-03f, 1.33974850e-03f, -7.60215446e-02f,
  -4.92966533e-01f, 3.67326997e-02f, 2.87247181e-01f, -4.97203022e-01f, 3.12483728e-01f, 3.84070814e-01f, 5.45375422e-02f, 2.01038703e-01f, 3.39803219e-01f, -8.25946927e-02f,
  -1.11842975e-01f, 2.04528365e-02f, -9.47457999e-02f, -1.19011858e-02f, 8.02633166e-02f, 2.71437019e-01f, -2.98688203e-01f, -2.71638572e-01f, 3.89422506e-01f, -1.15502149e-01f,
  6.32550940e-02f, -1.76364705e-01f, 2.81433254e-01f, 6.40861750e-01f, 4.27749127e-01f, -9.80035588e-02f, 9.57012177e-02f, 8.30678880e-01f, 1.97691962e-01f, -1.61501735e-01f,
  -3.88432860e-01f, 5.29372454e-01f, 3.93977910e-01f, -5.02331555e-01f, -1.13339029e-01f, 1.48752987e-01f, -4.93535548e-02f, -2.37106353e-01f, -4.20733899e-01f, 2.51801580e-01f,
  1.01895206e-01f, 3.30761403e-01f, -1.93933755e-01f, -2.82253802e-01f, 1.93588942e-01f, 3.86946529e-01f, -3.26354355e-01f, -2.40243554e-01f, 1.90893132e-02f, 2.32036591e-01f,
  1.73587829e-01f, 8.87814462e-02f, -7.79106542e-02f, 3.73062044e-01f, -1.85680002e-01f, 1.59721687e-01f, 1.87818825e-01f, -7.83561822e-03f, -3.15445685e-03f, -4.50671852e-01f,
  2.91686684e-01f, -1.61594391e-01f, 2.09714368e-01f, -2.50489831e-01f, -6.44559925e-03f, 6.41524136e-01f, -1.98747218e-01f, 3.93238485e-01f, -4.17916000e-01f, 1.28366083e-01f,
  -3.10224473e-01f, 2.98368543e-01f, 5.56069374e-01f, 3.02633137e-01f, 2.54409730e-01f, -3.17282438e-01f, -5.16225621e-02f, -6.70571566e-01f, -9.21231136e-02f, -5.33904016e-01f,
  -2.10539196e-02f, 3.66235167e-01f, 2.13244066e-01f, 1.52973607e-01f, 2.42905080e-01f, 2.76907712e-01f, 2.55499423e-01f, -5.61155565e-02f, -2.17170343e-01f, -7.38750547e-02f,
  1.66462496e-01f, -2.59257168e-01f, -2.17531193e-02f, -1.74805671e-01f, 1.28170028e-01f, -1.06273042e-02f, -7.68750980e-02f, 7.39072680e-01f, 9.31197125e-03f, 1.80101186e-01f,
  -2.27937307e-02f, -7.14141354e-02f, 2.41470218e-01f, 2.92657673e-01f, 5.82360327e-02f, 1.12852380e-01f, 6.42835051e-02f, 5.35632014e-01f, -1.76253859e-02f, -1.62873920e-02f,
  5.60861886e-01f, 4.71666962e-01f, 2.98037171e-01f, 3.96770358e-01f, -1.00019388e-01f, 4.52711761e-01f, -2.37410456e-01f, 4.14245784e-01f, 1.59747511e-01f, 6.75608456e-01f,
  1.61993712e-01f, -2.36787662e-01f, -3.03543776e-01f, 7.66226649e-01f, 2.11313024e-01f, 3.23245496e-01f, 2.21598789e-01f, -6.77700415e-02f, 5.65229177e-01f, -3.76666754e-01f,
  -2.08127022e-01f, 1.96402639e-01f, -1.22230448e-01f, 1.77744284e-01f, 3.28171067e-02f, 2.61104435e-01f, -6.36508688e-02f, 2.43917927e-01f, -3.46264124e-01f, -5.97104728e-02f,
  2.00715184e-01f, -1.49289062e-02f, 4.79265787e-02f, 1.56782176e-02f, 7.50859082e-02f, -3.95771623e-01f, 3.44628692e-01f, -2.14593381e-01f, 2.81987041e-01f, -4.05546844e-01f,
  4.22490835e-01f, 1.69550151e-01f, -2.31451560e-02f, 1.45077589e-04f, -1.41916245e-01f, 1.31233772e-02f, 1.62693292e-01f, 2.01664761e-01f, -4.21843231e-02f, 7.28956535e-02f,
  -5.54014325e-01f, 1.23945728e-01f, 2.04424217e-01f, -2.23082691e-01f, -5.91470636e-02f, 5.73803559e-02f, 7.43681043e-02f, 1.44147947e-01f, 5.92532828e-02f, -6.40904233e-02f,
  -3.73328142e-02f, 6.31385565e-01f, -1.14090890e-02f, 5.57138562e-01f, 4.98156995e-01f, 5.77988803e-01f, 2.98741907e-01f, -2.07019579e-02f, -4.80696470e-01f, 4.32420522e-01f,
  -1.21407844e-02f, 2.23219424e-01f, -1.26886040e-01f, 7.54934475e-02f, 4.45215166e-01f, 1.08686931e-01f, -2.50726104e-01f, -1.86938420e-01f, 5.12117207e-01f, 4.41110253e-01f,
  1.77919492e-01f, -5.90776443e-01f, 2.62918025e-01f, -3.12914073e-01f, 4.32018578e-01f, 8.94467384e-02f, 1.08699434e-01f, -9.40923840e-02f, 6.66041598e-02f, 1.08678088e-01f,
  -3.87916178e-01f, 1.47097989e-03f, 1.06245793e-01f, -2.53777802e-01f, 2.40836769e-01f, -1.84575930e-01f, -3.89704317e-01f, 9.50762257e-03f, -4.13348556e-01f, -6.81050360e-01f,
  -6.74178526e-02f, 5.01851290e-02f, 1.36993974e-01f, -9.07610208e-02f, 1.90318213e-03f, -1.42395750e-01f, 7.12822229e-02f, 2.97454417e-01f, 2.30746686e-01f, -5.43383062e-01f,
  3.49250406e-01f, 3.91423970e-01f, -1.26504228e-01f, -2.23842878e-02f, -6.63903728e-02f, -1.31215960e-01f, 2.56186485e-01f, 1.46687374e-01f, 7.49845132e-02f, 4.37879525e-02f,
  3.41664195e-01f, 9.01914090e-02f, 3.47919434e-01f, -3.94763425e-02f, 3.62293422e-01f, 3.66610706e-01f, -7.05643818e-02f, -1.36740133e-01f, 2.31011465e-01f, 7.15123862e-02f,
  4.91633981e-01f, 4.73038673e-01f, -3.18344496e-02f, 4.74173576e-01f, 7.93010145e-02f, 2.70533890e-01f, 8.92400295e-02f, 6.02500439e-02f, -1.02428265e-01f, -3.48605573e-01f,
  -3.34636509e-01f, 4.17322040e-01f, -2.63729617e-02f, 2.50714034e-01f, 4.08854723e-01f, -4.19643760e-01f, 1.34804547e-01f, -1.16584584e-01f, 8.70090872e-02f, 2.70094145e-02f,
  1.76407527e-02f, -5.57061732e-02f, 1.53887913e-01f, -1.67330772e-01f, 3.40617001e-02f, -2.03320198e-02f, -8.87730494e-02f, 5.05570233e-01f, -5.54133296e-01f, 2.25776240e-01f,
  3.39555025e-01f, 1.00784324e-01f, 3.46798927e-01f, 7.19620138e-02f, -1.10698774e-01f, -2.16578785e-02f, 2.37353414e-01f, 2.65956581e-01f, 2.64174432e-01f, 2.47994423e-01f,
  -5.57624221e-01f, 2.71582186e-01f, 1.88838810e-01f, -2.88260162e-01f, -1.77777082e-01f, 3.35050374e-01f, 4.14225817e-01f, -1.01503871e-01f, -9.17349681e-02f, 2.45253608e-01f,
  3.46492864e-02f, 5.50669655e-02f, -2.19365925e-01f, -9.16876569e-02f, 6.06814586e-02f, 2.84275264e-01f, -6.83255345e-02f, 4.59571891e-02f, -2.32645750e-01f, -2.92084694e-01f,
  1.46150097e-01f, -1.39326409e-01f, 1.57782182e-01f, 3.90341226e-03f, -1.40859082e-01f, -3.68243694e-01f, 3.57080311e-01f, 8.44493322e-03f, 3.52968961e-01f, -3.63080174e-01f,
  9.85789970e-02f, 1.07802749e-01f, 4.70297098e-01f, 1.86731815e-01f, -1.12478100e-01f, 1.19656496e-01f, 4.17796433e-01f, 2.92752773e-01f, -1.62782893e-01f, -4.32768948e-02f,
  -3.64117444e-01f, -6.64173886e-02f, 4.86892372e-01f, -9.61000174e-02f, -1.34611890e-01f, 1.33025110e-01f, -2.24112511e-01f, 4.91938829e-01f, 2.13412181e-01f, 2.41987363e-01f,
  -5.08410633e-01f, -2.48778895e-01f, 4.38613027e-01f, 3.48121613e-01f, 2.57899284e-01f, -5.14178723e-02f, 2.59932548e-01f, 1.74805984e-01f, 3.03953826e-01f, -4.56728339e-02f,
  1.06161676e-01f, -2.05881335e-02f, -2.48476714e-02f, -8.75549093e-02f, 2.72652745e-01f, -4.13546264e-01f, -5.10317028e-01f, 1.72469407e-01f, 2.29499429e-01f, 5.27423769e-02f,
  1.88177571e-01f, -3.30660492e-02f, 3.54949087e-02f, 5.18354058e-01f, 1.33279666e-01f, -2.01667339e-01f, 2.99167663e-01f, 1.97280850e-02f, -4.09171522e-01f, -1.70753509e-01f,
  1.93882644e-01f, -1.20623216e-01f, 3.29212815e-01f, -2.80329108e-01f, 3.11292827e-01f, 2.07159013e-01f, -3.10749579e-02f, -1.43126398e-01f, -3.87944579e-02f, -2.80465074e-02f,
  2.11150035e-01f, -1.31104037e-01f, -1.70445785e-01f, 1.52819440e-01f, -2.83977419e-01f, -6.56367615e-02f, 4.73151386e-01f, 8.49927142e-02f, 2.44073436e-01f, 1.69683352e-01f,
  1.70048550e-01f, -1.19514026e-01f, 1.21158481e-01f, 7.73015842e-02f, 1.10965028e-01f, 4.97972965e-01f, 1.67147160e-01f, 1.02234587e-01f, 4.97986197e-01f, -1.73695028e-01f,
  -3.38538468e-01f, -1.59368053e-01f, -1.24066882e-01f, -3.37888122e-01f, -4.23871845e-01f, -1.13580018e-01f, -1.06892139e-01f, 1.51723608e-01f, 5.82902312e-01f, 5.53483725e-01f,
  5.56635261e-01f, -6.06132373e-02f, -2.44167581e-01f, 2.53169596e-01f, 9.73172933e-02f, 7.58009255e-02f, 3.42481315e-01f, 3.78742442e-02f, -1.25402182e-01f, 9.08303782e-02f,
  7.72100165e-02f, -4.43555601e-02f, 4.29911427e-02f, 4.77337539e-01f, 4.10191596e-01f, -1.77871753e-02f, -2.43606821e-01f, -2.92547867e-02f, -4.58273031e-02f, -2.13066950e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  1.00777179e-01f, 3.58502179e-01f, 2.32836202e-01f, 1.09937720e-01f, 2.57204086e-01f, 1.16378650e-01f, 2.34254822e-01f, 1.32950693e-01f, 1.48569703e-01f, 6.54212385e-02f,
  2.09986657e-01f, 1.96508467e-01f, -5.40687554e-02f, 1.37676656e-01f, 2.25011945e-01f, 8.40871409e-02f, -5.17901964e-02f, 1.27589285e-01f, -1.88763365e-02f, -1.70645416e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.79029435e-01f, 1.44900963e-01f, -3.64597678e-01f, -1.88983217e-01f, -4.54441845e-01f, -8.93078297e-02f, 6.27166867e-01f, -2.00387016e-01f, -4.52555297e-03f, 2.24176664e-02f,
  2.65203685e-01f, 2.53080964e-01f, -4.25089002e-01f, -7.96624243e-01f, -7.29986131e-01f, -5.32354647e-03f, -3.66571814e-01f, 2.97229197e-02f, -2.01104775e-01f, -1.90036669e-01f,
  3.01998407e-01f, 4.44157422e-02f, 2.98453987e-01f, -9.56678465e-02f, 1.50501996e-01f, -3.29296112e-01f, 2.12756902e-01f, -7.85791576e-02f, -4.19341862e-01f, 1.34125531e-01f,
  5.81278130e-02f, -3.47217172e-01f, -4.78100985e-01f, 2.66307682e-01f, -1.92927107e-01f, -3.04833084e-01f, -1.08689547e-01f, 5.97408526e-02f, -1.94046512e-01f, -4.71300334e-01f,
  -2.35696197e-01f, -1.98715791e-01f, 4.74418908e-01f, 4.42881614e-01f, 3.32340300e-01f, -1.07351802e-01f, -7.67556950e-02f, 2.79747039e-01f, -6.29898161e-02f, 2.16852292e-01f,
  -1.70908391e-01f, -2.76007921e-01f, 1.55787855e-01f, 2.52919048e-01f, -3.61150444e-01f, -1.28637955e-01f, -2.46700644e-01f, -2.72342432e-02f, -4.38817918e-01f, 2.69712478e-01f,
  -7.32816309e-02f, -6.26160085e-01f, 2.54509568e-01f, 6.26518652e-02f, 4.52159867e-02f, -3.02453101e-01f, 2.45859832e-01f, 2.16317087e-01f, 1.53653651e-01f, -6.02533929e-02f,
  1.25071228e-01f, 2.59258181e-01f, -4.21068281e-01f, -2.92893976e-01f, -5.22859335e-01f, 1.44881785e-01f, -4.83095646e-01f, -3.13365340e-01f, 1.88571483e-01f, -8.20513591e-02f,
  -6.93367541e-01f, 3.40717047e-01f, -6.06664538e-01f, -8.60419691e-01f, 1.94739670e-01f, 2.02479780e-01f, -6.08832501e-02f, -3.23085248e-01f, -3.63874346e-01f, 1.85865954e-01f,
  7.11090192e-02f, -7.89616778e-02f, -7.85903454e-01f, 4.23039615e-01f, 1.43582553e-01f, 2.05990478e-01f, 6.23680092e-02f, 2.63470709e-01f, 2.82863736e-01f, 2.47809738e-01f,
  1.70542687e-01f, -1.53297037e-01f, -2.65267372e-01f, -2.04497248e-01f, -3.05824727e-01f, 2.45658949e-01f, -2.86646873e-01f, -1.28494665e-01f, -1.34508118e-01f, -4.52483326e-01f,
  -7.22860217e-01f, -5.78848600e-01f, 2.62830049e-01f, -1.79868668e-01f, -4.21817482e-01f, 2.02794522e-01f, -9.87434015e-02f, -8.71104419e-01f, 7.90652260e-02f, -4.30153131e-01f,
  3.45219344e-01f, -5.93532860e-01f, 2.51245558e-01f, -3.16618085e-01f, 4.14414927e-02f, 9.25928503e-02f, 3.14651757e-01f, 1.39956191e-01f, -1.58213675e-01f, -3.57400924e-01f,
  -1.66412726e-01f, 6.14831448e-02f, 2.21444722e-02f, 1.49678677e-01f, -3.77381563e-01f, 1.74081370e-01f, -1.32374063e-01f, -5.19960523e-01f, 2.94408053e-01f, -5.07304788e-01f,
  -1.80121232e-02f, -2.45824885e-02f, -1.97001025e-01f, -1.78582862e-01f, -1.09686688e-01f, 4.07806784e-02f, -5.19692600e-01f, -1.67735547e-01f, -4.02211584e-02f, -4.30242270e-01f,
  2.32720569e-01f, -5.08287966e-01f, 2.88372129e-01f, 1.94949538e-01f, 2.72402912e-01f, 3.18284720e-01f, -3.93133491e-01f, -4.88389805e-02f, -1.06882989e-01f, 2.94736177e-01f,
  1.51517481e-01f, 2.62690876e-02f, 1.27413705e-01f, 4.06883806e-01f, 2.06066847e-01f, 3.09607208e-01f, -3.32260102e-01f, -2.78299395e-02f, -2.35297948e-01f, 7.07798064e-01f,
  -6.91397563e-02f, -1.62942275e-01f, 2.89928943e-01f, -8.04742649e-02f, 1.94692925e-01f, 2.00872526e-01f, 9.80302691e-02f, 3.22333932e-01f, -3.08724225e-01f, 2.90854629e-02f,
  -3.93633366e-01f, 3.39611359e-02f, 2.60940164e-01f, -3.67266327e-01f, -2.43691072e-01f, 3.87700528e-01f, 1.50312573e-01f, -8.20359290e-02f, -2.72138059e-01f, -2.21976340e-01f,
  -2.20941044e-02f, -4.23308581e-01f, 8.86787102e-02f, 1.54369637e-01f, 1.74678177e-01f, 4.12526131e-01f, 2.45138779e-01f, -2.81908780e-01f, 2.09264636e-01f, 4.95549500e-01f,
  2.98898369e-01f, -4.88751344e-02f, 1.35769635e-01f, -7.17904195e-02f, -7.04922676e-01f, 8.32018033e-02f, 6.74053356e-02f, 6.15643114e-02f, -3.85774106e-01f, 8.08314979e-02f,
  2.41017491e-01f, -3.75776172e-01f, 1.11226022e-01f, 3.94137353e-01f, -6.56050682e-01f, 1.30783111e-01f, -3.28815967e-01f, -3.07284474e-01f, -4.28041629e-02f, -1.83572294e-03f,
  2.67008729e-02f, -2.65488699e-02f, 1.04236357e-01f, -1.93979695e-01f, 1.17665902e-01f, -2.16918468e-01f, -3.16801131e-01f, -1.16189606e-01f, -2.51907617e-01f, 1.98631942e-01f,
  -1.58496097e-01f, -1.96032792e-01f, 1.57605976e-01f, 1.64788350e-01f, -2.69896686e-01f, -2.61546988e-02f, 3.48561145e-02f, 1.19148187e-01f, -3.66294354e-01f, 7.57866651e-02f,
  4.41634864e-01f, -6.05745792e-01f, 1.78030357e-02f, -2.22395688e-01f, 1.10435069e-01f, -3.53585094e-01f, -3.00696820e-01f, 1.01196900e-01f, 2.15382323e-01f, 3.50937277e-01f,
  -2.88503081e-01f, -3.66345614e-01f, 2.21722320e-01f, 2.50537664e-01f, -3.21712792e-02f, -2.91010439e-01f, 2.01461881e-01f, 1.72080830e-01f, -3.13592762e-01f, -3.08621645e-01f,
  -1.83837429e-01f, 2.26074811e-02f, 5.20635605e-01f, -1.77771583e-01f, 4.10564899e-01f, 4.68615666e-02f, -3.79283845e-01f, 3.31899136e-01f, 2.86956042e-01f, 2.09750995e-01f,
  2.47092098e-01f, 2.87118196e-01f, -1.40344620e-01f, -3.22048873e-01f, 2.65378147e-01f, 3.76544714e-01f, -3.17393661e-01f, -1.97252646e-01f, -6.14724338e-01f, 4.70692292e-02f,
  -1.88601181e-01f, -3.01366299e-01f, -4.57029432e-01f, -4.46636915e-01f, -6.45059645e-02f, -5.80601655e-02f, -1.64668664e-01f, -6.07163012e-01f, 1.67622343e-01f, -6.45124465e-02f,
  1.16598576e-01f, -1.38163641e-01f, 5.37060425e-02f, -7.20356032e-02f, -1.93763062e-01f, -2.31249020e-01f, -1.08396187e-01f, 6.44875169e-01f, -3.43094766e-01f, -3.12478114e-02f,
  -1.08726531e-01f, 1.71018520e-03f, -6.57750741e-02f, -5.41801810e-01f, 4.14246172e-01f, 1.24249287e-01f, -1.27906650e-01f, -5.48139453e-01f, -1.10127702e-01f, 1.99529961e-01f,
  -3.62982035e-01f, 1.91373080e-01f, 1.54740199e-01f, -2.31297314e-01f, 1.65769532e-01f, 1.56790838e-01f, -1.55577110e-02f, 6.82792589e-02f, -3.98845673e-01f, 1.58197790e-01f,
  1.13079101e-01f, 1.01685897e-01f, 1.97069079e-01f, -2.05594972e-01f, -2.52536479e-02f, 9.00929645e-02f, 3.02401930e-01f, 3.70141208e-01f, 4.47369814e-01f, 1.82798490e-01f,
  3.75925511e-01f, 1.64334074e-01f, -4.99567509e-01f, -4.46205623e-02f, 6.14854097e-02f, -2.74899423e-01f, -3.89251739e-01f, 2.01118961e-02f, -6.18735373e-01f, 4.68195081e-01f,
  -5.97894609e-01f, -5.56243479e-01f, 2.76220262e-01f, 2.39025205e-01f, -3.40079457e-01f, -7.86493897e-01f, -2.39549354e-01f, -5.50521553e-01f, 3.47847700e-01f, 7.57196173e-02f,
  3.81052718e-02f, -3.69509816e-01f, -2.29790390e-01f, -1.02761827e-01f, -1.67680547e-01f, -2.59777787e-03f, -3.98573577e-01f, -2.35367436e-02f, -6.36600435e-01f, -2.83392936e-01f,
  7.65954405e-02f, -1.63529873e-01f, 2.05701485e-01f, -2.90569752e-01f, -3.75855982e-01f, 3.10638547e-01f, 2.59239614e-01f, -1.03237018e-01f, -2.13512808e-01f, -6.58449411e-01f,
  1.65516928e-01f, -3.23061883e-01f, -5.72931826e-01f, -8.04153234e-02f, -5.91207445e-01f, 2.25684911e-01f, -3.02366823e-01f, 2.25839227e-01f, -5.99877834e-01f, 6.24891631e-02f,
  1.00690015e-01f, -5.72413921e-01f, -3.33166987e-01f, 1.65542990e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.33096084e-01f, 1.73684992e-02f, 1.42652586e-01f, -1.01861261e-01f, 5.92403114e-02f, 2.69315213e-01f, 1.33005604e-01f, 2.75900867e-02f, -1.88438401e-01f, -1.63114429e-01f,
  1.56853586e-01f, -1.51553988e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    