/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.97146985e-02f, 2.28786707e-01f, 4.22985740e-02f, -1.56375822e-02f, -4.11148429e-01f, 3.93085599e-01f, 1.43657684e-01f, -1.72782108e-01f, -1.70663416e-01f, 4.53630984e-02f,
  2.03987118e-03f, 1.51527524e-01f, 2.16231346e-01f, 2.64978170e-01f, 1.48008913e-01f, 5.53580582e-01f, 3.35571259e-01f, 1.70536458e-01f, -2.01677438e-02f, -7.75595009e-02f,
  -7.26982877e-02f, -1.21720433e-02f, 1.78630129e-01f, -3.53421926e-01f, -3.03052291e-02f, -2.92277992e-01f, -2.66114622e-01f, -1.96330041e-01f, -3.61873843e-02f, 4.23834212e-02f,
  2.00584203e-01f, -6.22816347e-02f, -1.32722065e-01f, 8.41346979e-02f, -2.38954816e-02f, -3.84682342e-02f, 2.73930281e-02f, 2.50176564e-02f, -9.51329395e-02f, 2.93738507e-02f,
  1.49808913e-01f, 1.30253686e-02f, -1.27480747e-02f, -1.11763887e-01f, -3.18595506e-02f, -3.06192283e-02f, 7.55056739e-02f, 1.30413314e-02f, -7.05664903e-02f, 1.75846413e-01f,
  2.36257073e-03f, 1.57429382e-01f, 9.44694411e-03f, 1.25347465e-01f, -6.37244508e-02f, 6.67193905e-02f, 1.43906046e-02f, 8.74822140e-02f, -3.78698930e-02f, -1.23131566e-01f,
  -1.02482755e-02f, -7.81702623e-02f, -7.75246369e-03f, -3.35620418e-02f, -3.48889083e-02f, -7.15238750e-02f, -2.58334819e-02f, 2.63122539e-03f, -1.09485082e-01f, 8.15183576e-03f,
  -4.21407558e-02f, 5.52686714e-02f, 2.67940965e-02f, -3.74162197e-02f, 5.70511185e-02f, -1.79032221e-01f, 9.55759212e-02f, 9.80051979e-02f, 2.45435126e-02f, -1.05387298e-02f,
  -8.83428007e-02f, -1.68903340e-02f, 1.64843388e-02f, -2.32386645e-02f, 2.27685794e-02f, 6.38547586e-03f, 5.78787550e-02f, 1.98865514e-02f, 1.60404984e-02f, -3.34150419e-02f,
  1.17866218e-01f, -8.69822800e-02f, 3.05994693e-02f, -7.52938688e-02f, -1.67523529e-02f, -6.84543625e-02f, 6.23483695e-02f, 8.30966160e-02f, -1.99441910e-02f, -1.93589311e-02f,
  -8.90147388e-02f, -8.13200772e-02f, -3.43577079e-02f, 1.14898875e-01f, 2.61917040e-02f, 9.67999771e-02f, -1.44942226e-02f, -7.09720775e-02f, -9.13247317e-02f, -7.89515600e-02f,
  -8.89121443e-02f, 2.42169853e-02f, -1.55815035e-01f, -1.57841370e-01f, 4.54291925e-02f, -1.98125304e-03f, -1.16024189e-01f, -4.38125692e-02f, -2.38578185e-03f, 9.55764204e-02f,
  2.81088412e-01f, 4.23874974e-01f, -8.05051699e-02f, -5.81871942e-02f, 5.75922430e-02f, -9.54891294e-02f, -4.33103107e-02f, 1.53489202e-01f, 3.22219580e-02f, 1.74750462e-01f,
  -3.46842371e-02f, 1.13650918e-01f, 3.66725326e-02f, -7.83408433e-02f, -1.94329559e-03f, -9.06335413e-02f, 1.26665953e-04f, 1.13995031e-01f, -2.11261697e-02f, 2.62759805e-01f,
  -1.13922313e-01f, 1.00856081e-01f, -2.11232439e-01f, 2.01850772e-01f, -8.44354928e-02f, -5.07565541e-03f, 2.17093825e-01f, 8.53157640e-02f, -5.93764521e-02f, -7.38945305e-02f,
  -1.11900143e-01f, -4.21110652e-02f, -5.90498447e-02f, 3.61182392e-02f, 3.24690342e-03f, -5.30843921e-02f, 7.13622868e-02f, -3.97260822e-02f, -8.28789771e-02f, 6.74400420e-04f,
  5.20947687e-02f, 1.09945619e-02f, 5.55688813e-02f, 4.06922214e-02f, -6.90011494e-03f, 3.00151650e-02f, -9.87506956e-02f, -5.29295355e-02f, 8.99095833e-02f, -1.27186090e-01f,
  -8.24933350e-02f, -1.29238302e-02f, -8.78678560e-02f, 5.32944687e-02f, -4.78714257e-02f, -1.26489764e-02f, -1.12433918e-01f, 1.38084469e-02f, 1.34104248e-02f, 2.73092594e-02f,
  2.24449821e-02f, -1.42375929e-02f, -1.00187562e-01f, 1.68122388e-02f, -3.75172272e-02f, -8.52765292e-02f, 2.72937100e-02f, -3.59013863e-02f, -4.40665409e-02f, 6.50280714e-02f,
  7.94935226e-03f, 1.19644413e-02f, 2.21924540e-02f, -1.88033953e-02f, -4.74114493e-02f, 4.36038971e-02f, 6.29488472e-03f, 4.16094176e-02f, 3.28113674e-03f, -7.76133612e-02f,
  1.60590969e-02f, -5.65491291e-03f, 1.01677133e-02f, -7.19350278e-02f, -2.95986515e-03f, 5.94058968e-02f, 8.03659484e-02f, 3.63545567e-02f, -4.39738594e-02f, -5.29041998e-02f,
  4.27441716e-01f, 6.54194653e-01f, -5.91612607e-02f, -4.13754098e-02f, 5.47122285e-02f, -6.26550466e-02f, 2.13557649e-02f, -3.31880362e-03f, 1.23891383e-01f, 5.92494523e-03f,
  1.79915614e-02f, -7.07788244e-02f, 3.55689153e-02f, 2.31551453e-02f, 6.37854412e-02f, -5.17436340e-02f, -4.54513216e-03f, 5.21900542e-02f, -1.79848503e-02f, 1.12377159e-01f,
  5.33577353e-02f, 7.00862780e-02f, -3.27210836e-02f, -6.06046878e-02f, 5.53670786e-02f, -8.77745822e-03f, 1.40903950e-01f, -1.98219307e-02f, 7.26883560e-02f, -2.02690344e-02f,
  -1.42787471e-01f, -4.99088138e-01f, 1.25833318e-01f, 2.25443497e-01f, 8.11676979e-02f, -1.83189198e-01f, -7.50907436e-02f, -6.36795014e-02f, -1.99886501e-01f, -3.23898852e-01f,
  -1.11676984e-01f, 2.70783693e-01f, -2.18672484e-01f, -2.64926136e-01f, 4.89328116e-01f, -2.99751282e-01f, -1.64342418e-01f, -1.28906056e-01f, -2.31200278e-01f, 1.73575133e-01f,
  7.68039748e-02f, -1.22259155e-01f, -2.24146042e-02f, -6.96633235e-02f, -1.12277709e-01f, 2.31016204e-01f, 3.07558417e-01f, 1.38868153e-01f, 1.74916506e-01f, -9.29761827e-02f,
  -1.03593990e-01f, -2.75684267e-01f, 7.79802278e-02f, -1.21005021e-01f, -2.82035712e-02f, 1.08826039e-02f, 1.76527083e-01f, 9.04819816e-02f, 1.39686629e-01f, -1.27234295e-01f,
  -9.47681665e-02f, 1.11343861e-01f, -9.02782232e-02f, 3.34667824e-02f, -4.99725416e-02f, 2.04405151e-02f, 5.66724092e-02f, -7.80742764e-02f, 3.04267532e-03f, -1.49910673e-02f,
  -4.02495973e-02f, -5.82344718e-02f, 1.13409862e-01f, 6.94403946e-02f, 9.73090678e-02f, -8.05575922e-02f, 6.60841390e-02f, 2.19418164e-02f, -6.16909750e-02f, 8.54020193e-02f,
  -5.86520471e-02f, 4.85706776e-02f, 2.18254961e-02f, -1.25963107e-01f, 7.49058500e-02f, -3.51027548e-02f, 6.58765947e-03f, -7.26912543e-02f, 1.71081826e-01f, -1.50416076e-01f,
  6.90630227e-02f, -2.58650389e-02f, -6.25123307e-02f, 5.86138256e-02f, 1.90513730e-02f, -5.68079390e-02f, 5.38814180e-02f, -8.11233278e-03f, 1.79292392e-02f, -2.21307296e-02f,
  -1.00931069e-02f, 1.04177535e-01f, -1.55538190e-02f, 1.81936994e-02f, -1.20400101e-01f, 8.65304843e-02f, -5.29287346e-02f, 3.69146280e-02f, 3.95312980e-02f, 1.12717915e-02f,
  3.80675904e-02f, 1.48052067e-01f, -1.15172833e-01f, 1.29602060e-01f, 1.62302721e-02f, 2.51240563e-02f, -1.63808525e-01f, -6.66097328e-02f, 8.09261724e-02f, -1.95629578e-02f,
  6.83233291e-02f, 7.28277341e-02f, 4.40580063e-02f, -1.77586041e-02f, 3.95606421e-02f, -8.69304128e-03f, -1.06524546e-02f, 7.46198893e-02f, -2.18675844e-02f, -5.59538184e-03f,
  1.61090180e-01f, 8.92584920e-02f, -1.06866337e-01f, -2.83862595e-02f, 2.21370626e-02f, 7.20555782e-02f, 1.35416076e-01f, 2.01299172e-02f, -2.28451309e-03f, -3.73507254e-02f,
  -2.83088565e-01f, -3.71141315e-01f, -6.35126889e-01f, -1.92371607e-01f, 1.90870598e-01f, 1.34085760e-01f, 4.17942554e-01f, -9.80095640e-02f, -2.96643525e-01f, 1.85715154e-01f,
  4.54628617e-01f, -1.35088533e-01f, 3.69904697e-01f, 1.57938078e-01f, -2.90638208e-01f, 1.60430178e-01f, -7.96185583e-02f, 1.05303548e-01f, -1.58174470e-01f, -2.07934707e-01f,
  -2.25216031e-01f, 3.47491056e-01f, 4.56319898e-02f, 4.08292077e-02f, 1.35133699e-01f, -1.91537723e-01f, 2.04969317e-01f, 1.38849825e-01f, 6.31126389e-02f, 1.70142986e-02f,
  2.19287202e-01f, -2.30189078e-02f, -1.76826775e-01f, -1.29834414e-01f, -4.11857590e-02f, 9.33333263e-02f, 4.33968231e-02f, 1.67942569e-01f, -6.56886175e-02f, 8.78813639e-02f,
  2.25472301e-02f, -2.21169386e-02f, 6.95009949e-03f, -1.72376782e-02f, 3.68833765e-02f, -5.42685129e-02f, -8.05833265e-02f, -4.46827598e-02f, 1.26799285e-01f, -2.06767526e-02f,
  3.43731865e-02f, -5.81909828e-02f, -3.76286209e-02f, -2.89896391e-02f, -5.11488169e-02f, -1.14148594e-02f, -1.20699413e-01f, 5.88190183e-02f, -2.06151512e-02f, -2.14381367e-01f,
  1.26059223e-02f, 5.24556600e-02f, 2.84577012e-02f, 1.09938063e-01f, -4.98528630e-02f, 1.43614128e-01f, 2.67245015e-03f, 5.24022505e-02f, -9.15601030e-02f, -1.95252672e-02f,
  9.23890062e-03f, -8.79639834e-02f, 8.68908986e-02f, 1.60670076e-02f, 1.69672798e-02f, -5.24108186e-02f, -4.76863496e-02f, 5.37319854e-02f, 2.38796137e-02f, -5.32019511e-03f,
  7.00966269e-02f, 1.66369732e-02f, 8.91699493e-02f, 6.75245896e-02f, 1.07651561e-01f, -2.72764508e-02f, 7.94226080e-02f, -7.42757097e-02f, 8.93121772e-03f, 1.24649396e-02f,
  -1.40903369e-01f, -1.53764471e-01f, 4.52953801e-02f, -9.39418655e-03f, 4.91182320e-02f, -2.94322474e-03f, -4.83280495e-02f, -1.18361637e-01f, 2.00954732e-02f, -3.05041932e-02f,
  3.31113078e-02f, 3.96829098e-02f, -5.32712154e-02f, 1.36321029e-02f, -1.33641765e-01f, 7.15289265e-02f, 1.28310770e-01f, 7.84269627e-03f, -5.87698165e-03f, -2.59788521e-02f,
  1.02399357e-01f, 3.38978730e-02f, -2.60523185e-02f, 4.32097390e-02f, 2.22249776e-02f, 6.74376190e-02f, 1.96908880e-02f, -1.38277262e-01f, 3.01432330e-02f, 1.27361938e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.10692883e-01f, -4.72861767e-01f, 6.48009777e-01f, -1.19449592e+00f, 1.13603026e-02f, 6.67304754e-01f, 1.30743533e-01f, -3.66987944e-01f, -7.47795284e-01f, -6.12377107e-01f,
  -4.82833654e-01f, 3.41508150e-01f, 7.27794170e-01f, -6.90101087e-01f, 1.45614409e+00f, 5.89632630e-01f, -5.41317999e-01f, -1.89114958e-01f, -2.06150576e-01f, -2.56815791e-01f,
  -2.93023765e-01f, -7.92394459e-01f, 4.96227294e-01f, -4.06245083e-01f, -5.28080940e-01f, -3.04275841e-01f, -2.61194259e-02f, 4.45794314e-01f, -4.47611690e-01f, 1.85562044e-01f,
  -3.22906464e-01f, -5.66423237e-01f, -6.02601133e-02f, 1.31560385e-01f, -4.56353761e-02f, -5.22223599e-02f, 2.06068233e-01f, 4.88712728e-01f, -1.71624422e-02f, 5.63628301e-02f,
  4.36572023e-02f, 5.15400097e-02f, -3.79041553e-01f, 2.49065027e-01f, -1.76474854e-01f, -5.56941256e-02f, 7.76103288e-02f, -7.84402043e-02f, 4.64188866e-02f, 3.04916978e-01f,
  3.40460651e-02f, 5.59697263e-02f, -1.75311312e-01f, -1.75936427e-02f, 1.51871413e-01f, -1.46190822e-01f, 2.42193602e-02f, 3.39246929e-01f, 1.62813328e-02f, -1.28344178e-01f,
  1.55578956e-01f, 9.99500304e-02f, 4.01341394e-02f, -1.60312861e-01f, -1.59102865e-02f, -2.23130792e-01f, 3.34700458e-02f, -9.06226337e-02f, -6.40241578e-02f, -3.26099200e-03f,
  -1.35416299e-01f, 1.29898090e-03f, -1.23048745e-01f, 1.26353264e-01f, -2.52537638e-01f, -6.02357537e-02f, 1.49783328e-01f, -4.30078022e-02f, -2.19065830e-01f, -1.35998830e-01f,
  -4.09136191e-02f, 1.18371412e-01f, 4.11977544e-02f, -1.12211756e-01f, -7.46269301e-02f, 1.92908838e-01f, -5.51289506e-02f, 5.72362877e-02f, 2.40981970e-02f, 1.70607314e-01f,
  7.17704147e-02f, -2.91472346e-01f, -8.08212832e-02f, -6.23408295e-02f, -4.70618270e-02f, 9.90418419e-02f, 6.38503954e-02f, -5.40268347e-02f, 3.55657637e-02f, 1.94068756e-02f,
  2.61266925e-03f, -3.90259437e-02f, 3.84217240e-02f, -6.20886013e-02f, 7.04532191e-02f, -4.01453897e-02f, -6.05260096e-02f, -1.14062920e-01f, -5.36728010e-04f, 2.68520578e-03f,
  -5.32616638e-02f, 1.18547440e-01f, 2.28008375e-01f, -1.93247750e-01f, -1.75781265e-01f, 7.88965374e-02f, -1.02524951e-01f, -9.82530341e-02f, 1.93558738e-01f, -5.10742813e-02f,
  -6.35619536e-02f, 1.05830359e+00f, -2.04700064e-02f, 5.78819476e-02f, -2.12254629e-01f, 1.25190413e+00f, 3.86006504e-01f, -8.32653865e-02f, 6.89398423e-02f, 1.15016973e+00f,
  -1.18281528e-01f, 5.34836590e-01f, -2.04863831e-01f, 2.78659552e-01f, -6.67334914e-01f, -1.08168796e-02f, 5.16706705e-01f, 5.52986920e-01f, -4.06380028e-01f, 3.80452484e-01f,
  -2.54424006e-01f, -1.89789683e-01f, -5.18135846e-01f, -2.41554305e-01f, 2.09620103e-01f, 1.29368216e-01f, -9.34694856e-02f, -3.88391376e-01f, 3.42374682e-01f, -2.64481932e-01f,
  -1.53334662e-01f, -1.50690228e-01f, 8.94529093e-03f, 8.38733912e-02f, 1.91536084e-01f, 8.99663940e-02f, 2.27182403e-01f, -3.09399307e-01f, -2.52526790e-01f, -5.38402721e-02f,
  1.63391575e-01f, -9.43199098e-02f, -7.96452984e-02f, -7.48978630e-02f, 8.17329958e-02f, -2.40171738e-02f, 2.38577556e-02f, 9.85608026e-02f, 3.06296512e-04f, -3.61132212e-02f,
  -1.35279253e-01f, 6.25565946e-02f, 1.64967835e-01f, 2.49015421e-01f, -9.18088853e-02f, -7.55008683e-02f, 2.41296872e-01f, 8.66210014e-02f, 2.43963659e-01f, 2.65518129e-02f,
  1.01789944e-02f, 2.16107637e-01f, 1.03807345e-01f, -7.95056969e-02f, 2.51411665e-02f, -1.89018875e-01f, -4.00390700e-02f, -2.05783054e-01f, 1.34499213e-02f, -4.40739505e-02f,
  8.39679390e-02f, -4.48338240e-02f, -1.18158750e-01f, 8.63429233e-02f, 3.06559224e-02f, 5.41848950e-02f, 3.21929231e-02f, -4.53086682e-02f, 3.46430615e-02f, -1.01292416e-01f,
  -7.34355375e-02f, 9.70412567e-02f, 8.29465911e-02f, -6.42225668e-02f, -2.03780420e-02f, -9.48463455e-02f, 8.59322399e-02f, 3.99430767e-02f, -3.29177380e-02f, 1.63531001e-03f,
  4.04383093e-01f, 7.66669154e-01f, -2.09261402e-02f, -5.63826747e-02f, 8.84613954e-03f, 2.77968377e-01f, -1.30091712e-01f, 1.61325276e-01f, 1.80897877e-01f, 1.98634371e-01f,
  1.50185063e-01f, 1.48543671e-01f, 2.64493853e-01f, -5.15382960e-02f, -1.47322297e-01f, 2.04267308e-01f, 1.81405872e-01f, -2.79690959e-02f, 1.88893542e-01f, 7.04576001e-02f,
  1.80095285e-01f, 1.62443608e-01f, 9.24655646e-02f, 8.41217265e-02f, 6.53663427e-02f, 1.02944329e-01f, 1.08964741e-01f, -5.31832948e-02f, -8.48289505e-02f, 2.27632076e-02f,
  -8.70937556e-02f, 1.49537551e+00f, 8.83523703e-01f, 5.77347219e-01f, -3.04891348e-01f, -1.42220700e+00f, -3.30550790e-01f, 3.75024796e-01f, -9.67263579e-02f, 6.66081429e-01f,
  -1.27351150e-01f, 1.11254585e+00f, 2.70032048e-01f, 3.52764487e-01f, -1.03359950e+00f, -1.84162945e-01f, -3.21763754e-01f, 1.67190492e-01f, -1.42609283e-01f, 3.88512522e-01f,
  -1.50087580e-01f, -4.63699639e-01f, 2.04164296e-01f, 1.07323229e-01f, 3.29154223e-01f, 6.00889802e-01f, -1.61410775e-02f, 3.39971542e-01f, 4.08198118e-01f, -9.19762403e-02f,
  -1.52714044e-01f, 4.32068080e-01f, 5.81219375e-01f, -8.98320526e-02f, -2.40951598e-01f, 3.39357331e-02f, 4.99860197e-02f, -7.81824812e-02f, -7.42722228e-02f, -1.64055079e-02f,
  1.75397098e-01f, -2.10102215e-01f, -2.53675822e-02f, 6.00847863e-02f, 9.15547162e-02f, 1.73924714e-01f, 7.08805472e-02f, -1.12183549e-01f, 3.10569048e-01f, 2.49172539e-01f,
  3.22943807e-01f, 1.13670342e-01f, -2.98916679e-02f, 9.26541835e-02f, -8.09904747e-03f, -3.74784693e-02f, -1.51759028e-01f, 1.53454006e-01f, -4.13789321e-03f, 1.21511118e-02f,
  -1.42415896e-01f, -2.10160930e-02f, 1.80836052e-01f, 4.40383106e-02f, 1.20327353e-01f, -6.91369846e-02f, -2.79313303e-04f, -1.27390042e-01f, 4.27627563e-02f, -7.11343065e-02f,
  -9.75153893e-02f, 1.98383808e-01f, -1.00386925e-01f, -1.02203615e-01f, 2.03463174e-02f, 9.73511413e-02f, 5.12757413e-02f, -7.21919423e-05f, -1.39980733e-01f, 4.12199125e-02f,
  1.83987200e-01f, -1.83929801e-01f, 1.72254384e-01f, -6.86812475e-02f, -3.48817408e-01f, 1.46119013e-01f, 7.71389157e-02f, -8.26257188e-03f, 3.91750485e-02f, -1.13042243e-01f,
  -4.21619773e-01f, -7.93636963e-03f, 1.85234159e-01f, -4.98272218e-02f, 2.28671417e-01f, 7.23166466e-02f, -6.99061900e-02f, 3.34529541e-02f, -1.61817998e-01f, 9.62436665e-03f,
  1.20114591e-02f, 1.17013611e-01f, -2.39876553e-01f, -2.91387122e-02f, -6.42242059e-02f, -1.09780766e-01f, -4.40558456e-02f, -2.47445218e-02f, -7.01740459e-02f, 7.77303949e-02f,
  2.85176001e-02f, -1.02004275e-01f, 4.23575938e-02f, -1.72136724e-01f, -8.66622776e-02f, 4.49630991e-02f, -5.30808009e-02f, 1.36729285e-01f, 5.13052307e-02f, 1.50950244e-02f,
  -2.19221067e+00f, 7.50498891e-01f, 2.90626079e-01f, -1.37975216e+00f, 4.45847929e-01f, 3.57005775e-01f, -3.15869004e-01f, 5.41235089e-01f, -3.67397666e-01f, 5.36271036e-01f,
  -2.22231776e-01f, -6.10447168e-01f, 5.62135994e-01f, -1.02221465e+00f, -1.06753659e+00f, -3.78955394e-01f, -7.53879964e-01f, -4.84536856e-01f, -6.82041124e-02f, -2.99304668e-02f,
  -2.35065833e-01f, -4.13145274e-01f, -2.75835097e-01f, 8.61357331e-01f, 1.43320084e-01f, 4.20552939e-01f, -6.84621260e-02f, 5.51121473e-01f, -2.69922227e-01f, -8.78886506e-02f,
  -2.57333696e-01f, 2.36943346e-02f, -5.50075108e-03f, 8.85631070e-02f, 1.19899839e-01f, 1.03576712e-01f, -1.80036321e-01f, -1.99954910e-03f, -4.81047034e-02f, 4.55357507e-02f,
  -2.74412893e-03f, 2.19050691e-01f, -3.25461030e-01f, 5.72018884e-02f, 1.96416125e-01f, 1.63576007e-01f, 4.24236022e-02f, 2.74648587e-03f, 2.08820254e-01f, 3.70079800e-02f,
  1.57450840e-01f, -4.15947586e-02f, -1.07857678e-02f, -4.38478552e-02f, 3.01871523e-02f, 1.09588549e-01f, -1.25318542e-01f, 1.15003534e-01f, 1.54287498e-02f, -3.93602215e-02f,
  -9.77333859e-02f, 1.20732248e-01f, 9.29908976e-02f, -6.63067028e-03f, 7.28993639e-02f, 1.20995134e-01f, 8.96727219e-02f, -1.22776106e-01f, 1.15699917e-02f, 3.26366834e-02f,
  -9.00574997e-02f, -9.00045484e-02f, -5.75672649e-02f, 7.40342960e-02f, -7.13840872e-02f, -1.43330246e-01f, -1.10759959e-01f, -3.99798118e-02f, -8.51990879e-02f, -9.77616608e-02f,
  -4.77126352e-02f, -3.85893472e-02f, -3.39298472e-02f, 9.16490108e-02f, 1.73570253e-02f, 6.17655404e-02f, 8.98954123e-02f, 4.34301011e-02f, 2.31924206e-02f, 1.16053279e-02f,
  -1.20008416e-01f, -1.00665033e-01f, -3.03649413e-03f, -8.87633208e-03f, -1.04618683e-01f, 7.51898810e-03f, -1.26826793e-01f, -8.70243553e-03f, 4.71152589e-02f, 1.69304963e-02f,
  1.51362225e-01f, -6.56013265e-02f, 5.76609075e-02f, -1.79924406e-02f, -1.16299450e-01f, -1.67049505e-02f, -1.45606712e-01f, -2.53002107e-01f, -1.56574249e-01f, 2.98949052e-02f,
  1.07489280e-01f, 7.54450411e-02f, -4.27896902e-02f, 1.03496581e-01f, -1.66938975e-02f, -4.06935848e-02f, -8.56100917e-02f, -3.32843065e-02f, 2.54116729e-02f, 1.20775793e-02f,
  -1.05414294e-01f, -5.95578700e-02f, -1.16661370e+00f, -6.56688690e-01f, -5.03535807e-01f, -8.46314073e-01f, -4.88558322e-01f, -3.66501540e-01f, 2.98393279e-01f, 7.07402527e-01f,
  1.17813662e-01f, 3.92693728e-01f, 9.19452190e-01f, -4.55576092e-01f, -3.02595228e-01f, 6.27294004e-01f, -6.47988498e-01f, -1.64808691e-01f, 2.30058938e-01f, -4.14186716e-01f,
  -2.30589613e-01f, -4.79044467e-02f, -6.15627766e-01f, 1.63032711e-01f, -9.66676474e-01f, -5.43836355e-01f, 4.04471755e-02f, -1.51499569e-01f, -5.04731655e-01f, 1.24078942e-02f,
  -2.48096317e-01f, 2.73368716e-01f, -2.79765844e-01f, -1.80554707e-02f, -4.52597141e-01f, -1.24422215e-01f, -2.22525537e-01f, 1.23024315e-01f, 1.12592325e-01f, 1.69595495e-01f,
  4.47717272e-02f, 3.05877328e-01f, -1.00877002e-01f, 2.71174401e-01f, 1.60251394e-01f, -7.24537969e-02f, -1.13712877e-01f, -2.87198037e-01f, 2.54830003e-01f, -1.51064664e-01f,
  -1.15813509e-01f, -1.70130655e-01f, -3.10293525e-01f, 4.35175858e-02f, -1.43752605e-01f, -1.80872381e-01f, -1.15796566e-01f, -1.33925661e-01f, -1.84966862e-01f, -1.96951181e-01f,
  9.32728127e-02f, 5.41049987e-02f, 4.91129532e-02f, -1.00001782e-01f, 1.27823561e-01f, -2.42731720e-01f, 2.24786535e-01f, -2.51792017e-02f, 6.34898990e-02f, -5.75942136e-02f,
  -6.32041916e-02f, 3.43649574e-02f, 1.61545172e-01f, -8.49339291e-02f, -5.10746054e-03f, 6.82157353e-02f, 8.28229710e-02f, -2.87142936e-02f, -1.38569623e-01f, -2.89013565e-01f,
  1.98540032e-01f, 2.54983502e-03f, 2.66441498e-02f, -8.07990730e-02f, -1.33701444e-01f, 1.20870791e-01f, 1.20863326e-01f, -1.45550475e-01f, -9.51296538e-02f, 1.57915230e-04f,
  -2.78680116e-01f, -5.82079440e-02f, 1.73505500e-01f, 1.13766581e-01f, -4.42692004e-02f, -7.27640744e-03f, 8.22329223e-02f, -1.69396892e-01f, -1.10184446e-01f, 5.58651015e-02f,
  -1.41359255e-01f, 3.14433463e-02f, -2.65546978e-01f, -2.85199378e-02f, 1.66695192e-01f, -1.67481259e-01f, 2.37681977e-02f, 1.15730546e-01f, -3.13387454e-01f, -1.36797845e-01f,
  8.52948427e-02f, 2.68471152e-01f, 2.49676675e-01f, 6.58090636e-02f, 1.40424445e-01f, 1.87954471e-01f, 1.22616282e-02f, 4.55144010e-02f, -4.65315171e-02f, -1.35937169e-01f,
  1.60585091e-01f, -6.69461310e-01f, -1.03156412e+00f, -1.32838205e-01f, 4.12276298e-01f, 3.08913767e-01f, -3.39298218e-01f, 1.63320720e-01f, -9.33035374e-01f, 2.87860811e-01f,
  5.70210934e-01f, -6.30712628e-01f, -5.75278342e-01f, 7.28077650e-01f, 3.72415364e-01f, -8.43071520e-01f, 7.85189331e-01f, 1.91266626e-01f, -3.72308671e-01f, 4.61528808e-01f,
  2.51353562e-01f, 1.28311455e+00f, 7.13044927e-02f, 9.80306029e-01f, 6.08018100e-01f, -3.94128747e-02f, 1.06561768e+00f, -2.00152889e-01f, 1.22330546e+00f, 2.40620956e-01f,
  -1.55517682e-01f, -9.11000669e-02f, 4.09279279e-02f, -3.17656487e-01f, 2.29942411e-01f, 3.22501600e-01f, -3.65161188e-02f, -8.98684263e-02f, -1.91029117e-01f, -1.90205306e-01f,
  -1.56899124e-01f, 1.10985696e-01f, 1.52193472e-01f, -2.70685423e-02f, 2.84931421e-01f, -3.64166386e-02f, 1.07397065e-02f, -2.09650010e-01f, -2.83661157e-01f, -1.76838413e-02f,
  -2.83688426e-01f, 5.30198440e-02f, -3.39416936e-02f, -5.63428737e-02f, -1.40290484e-01f, -1.10849664e-01f, -1.58929735e-01f, -7.53238499e-02f, -5.77003732e-02f, 1.89663067e-01f,
  2.51058280e-01f, 9.80178863e-02f, 1.46840557e-01f, -1.17240464e-02f, 4.43271920e-02f, -5.12897596e-02f, 4.47069183e-02f, 3.78350317e-02f, -9.94043574e-02f, 6.86647892e-02f,
  7.17723789e-03f, 1.26063428e-03f, -5.36040440e-02f, 2.01691091e-01f, 1.81582868e-01f, -1.18651010e-01f, -3.57486904e-02f, 5.45658693e-02f, -5.59667647e-02f, 1.38572939e-02f,
  -1.13105170e-01f, 5.57443500e-02f, 2.03716774e-02f, -5.26263118e-02f, -2.18252033e-01f, 4.05290388e-02f, 3.88840288e-01f, 1.20875061e-01f, -1.02849998e-01f, -1.30508924e-02f,
  1.23007903e-02f, 3.52968127e-01f, -1.81073487e-01f, -1.16177045e-01f, -1.43364534e-01f, 3.33914608e-01f, -4.70707119e-02f, -8.80186781e-02f, 4.40802798e-02f, 8.77219588e-02f,
  5.14830112e-01f, 1.58078998e-01f, -1.19879849e-01f, -3.25310975e-02f, 4.05639708e-02f, 2.31328622e-01f, 1.12089142e-01f, -1.13815188e-01f, 2.86540270e-01f, 3.04160416e-01f,
  1.67397931e-01f, 9.96251032e-02f, -7.10916286e-03f, 2.97101513e-02f, 4.17082869e-02f, 2.00256277e-02f, 4.50870804e-02f, -1.23786986e-01f, 1.92324862e-01f, -1.36042595e-01f,
  -2.05265021e+00f, 1.21513939e+00f, 8.31957281e-01f, 7.62217939e-01f, -1.18245733e+00f, -4.98431139e-02f, 7.53167331e-01f, 8.46303478e-02f, 2.85241902e-01f, 5.87713242e-01f,
  -1.01524636e-01f, -1.21880695e-01f, 6.83746636e-01f, 5.56222141e-01f, 1.19049497e-01f, 1.02320313e+00f, 2.09019974e-01f, 2.66626805e-01f, 1.17103055e-01f, -3.06341853e-02f,
  9.97442678e-02f, 1.61285445e-01f, 6.20306849e-01f, -9.31850523e-02f, -1.29971102e-01f, 4.05737273e-02f, 2.79559404e-01f, 3.17337424e-01f, -1.92555115e-01f, -1.51941821e-01f,
  -8.37596357e-01f, -1.36835560e-01f, -2.52571881e-01f, 1.17286509e-02f, -1.89842954e-01f, -1.17159002e-01f, -1.29953235e-01f, 1.44276142e-01f, -1.41620919e-01f, -9.13277715e-02f,
  -1.11121424e-01f, -3.38206440e-02f, -3.84516269e-02f, -1.24780335e-01f, -1.71201795e-01f, -1.02928810e-01f, -1.68319955e-01f, -1.31805480e-01f, -5.20605175e-03f, -8.66857097e-02f,
  1.12021998e-01f, 2.17198785e-02f, 9.41464007e-02f, 1.70971781e-01f, 7.02957362e-02f, -2.83188582e-03f, 1.70089304e-01f, 3.56540307e-02f, -1.90444484e-01f, 1.54926572e-02f,
  -2.27167141e-02f, 1.27688736e-01f, -3.77088897e-02f, -1.00675181e-01f, 1.71834789e-02f, -8.67396966e-03f, -5.05905151e-02f, -7.07453415e-02f, 8.61133263e-02f, -1.05563626e-01f,
  -1.76340461e-01f, -8.09520856e-02f, -2.11400673e-01f, 4.90001813e-02f, -9.40877497e-02f, 6.88070804e-02f, -3.57806049e-02f, -1.85704246e-01f, 1.78062767e-02f, -2.25376412e-01f,
  9.85136181e-02f, 6.21109223e-03f, 3.55125628e-02f, -4.06278782e-02f, 1.08743655e-02f, 1.86332434e-01f, 1.62264869e-01f, 5.55260442e-02f, 5.58229126e-02f, -1.35062054e-01f,
  -1.05247311e-01f, 7.59891272e-01f, 3.08771487e-02f, -2.37203643e-01f, 1.03687741e-01f, -1.95143670e-01f, 5.60748391e-02f, -2.93505430e-01f, 2.58743465e-01f, 1.50143832e-01f,
  -7.14787319e-02f, -5.54879643e-02f, -8.76482353e-02f, -1.18700162e-01f, 1.72164649e-01f, 1.07430048e-01f, 1.36592865e-01f, -6.32834807e-02f, 3.75786871e-02f, -7.87820201e-03f,
  3.62820644e-03f, 1.09146331e-02f, 9.04406011e-02f, -1.15455151e-01f, -7.03323483e-02f, 5.36377579e-02f, -1.79776892e-01f, -7.84159079e-02f, -9.44930390e-02f, 2.68853486e-01f,
  1.61175692e+00f, 5.15206121e-02f, 5.94912469e-01f, 8.75647247e-01f, 2.05954477e-01f, 6.28463805e-01f, 1.29965878e+00f, 2.12813333e-01f, 1.26844013e+00f, -5.10200620e-01f,
  -3.00058246e-01f, 3.17497611e-01f, 2.17775807e-01f, 3.23719881e-03f, 6.34081602e-01f, 1.71159148e-01f, 5.10748029e-01f, 5.51322401e-02f, 1.53196260e-01f, 4.70551848e-01f,
  5.77473044e-01f, -1.15085110e-01f, 2.20305622e-02f, -7.17140615e-01f, 4.03855026e-01f, 8.00006613e-02f, -4.92943704e-01f, -9.93902534e-02f, -8.02093208e-01f, -1.79860517e-01f,
  -1.87034741e-01f, 3.56954694e-01f, 1.06517963e-01f, 4.66511659e-02f, 1.56817883e-01f, -8.41374323e-02f, -9.75434035e-02f, -9.63770673e-02f, 3.14383358e-02f, 5.53095117e-02f,
  1.49650112e-01f, -1.23063199e-01f, 3.53498496e-02f, 9.77353305e-02f, 3.07700545e-01f, 4.19744253e-02f, 9.55535397e-02f, -1.93765774e-01f, -8.47297013e-02f, 4.16982435e-02f,
  2.41279081e-01f, -1.33866951e-01f, 2.88014412e-01f, -9.45426375e-02f, 2.90289462e-01f, 1.78891256e-01f, -7.90977105e-03f, -1.47987679e-02f, -6.31534383e-02f, 1.93760380e-01f,
  7.43515640e-02f, -2.23978478e-02f, 5.03091998e-02f, -2.10880622e-01f, 5.29622361e-02f, -6.86995909e-02f, -5.68275377e-02f, -1.72437489e-01f, 1.24776714e-01f, 6.38509020e-02f,
  -2.28210166e-02f, 5.23848534e-02f, -3.03278770e-02f, 2.00687245e-01f, -1.78426504e-02f, -2.86886096e-02f, 3.87821965e-05f, -1.07847296e-01f, 1.71594724e-01f, -3.01525779e-02f,
  -8.15567374e-02f, -1.89280752e-02f, -2.43212972e-02f, 2.23504677e-02f, -1.75685883e-01f, 1.88352257e-01f, 7.07175881e-02f, 6.05368987e-02f, -1.06675014e-01f, 2.15524342e-02f,
  4.36595976e-02f, 3.61182660e-01f, 7.20848143e-02f, -2.24251330e-01f, -1.28044814e-01f, 1.90277770e-02f, 1.16373494e-01f, 5.21610044e-02f, 1.50739729e-01f, 2.33996525e-01f,
  -4.71996889e-02f, 3.51175778e-02f, -4.07119803e-02f, -9.17283967e-02f, -7.63752237e-02f, 1.11783467e-01f, 1.87421478e-02f, -5.24070822e-02f, 1.49394706e-01f, -6.85781315e-02f,
  -4.72155251e-02f, 1.77324086e-01f, -3.74274701e-02f, 8.28029960e-02f, -1.12858117e-01f, -7.58754164e-02f, 1.49626195e-01f, -1.19085476e-01f, -2.24764809e-01f, 7.64418021e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.05273736e+00f, 1.53767371e+00f, 8.71382058e-01f, 1.56051338e+00f, 5.86007833e-01f, 1.28022063e+00f, 1.06372488e+00f, 1.46609545e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.21859479e+00f, -2.88373262e-01f, -1.28439939e+00f, -1.41324520e+00f, 1.50829047e-01f, -1.16684985e+00f, -7.96694875e-01f, 1.16113889e+00f, -8.04487765e-01f, 5.59939861e-01f,
  -2.71209508e-01f, -6.56390011e-01f, 2.58294046e-02f, -2.85466731e-01f, 1.40432405e+00f, -1.70554614e+00f, 1.12203650e-01f, -1.05497859e-01f, 9.24067974e-01f, -1.16505004e-01f,
  1.37993693e+00f, 1.47238314e+00f, -1.89981031e+00f, 1.57693911e+00f, -1.39328671e+00f, 5.74356973e-01f, -1.61135280e+00f, -1.57406080e+00f, -1.82711750e-01f, 8.97033989e-01f,
  -7.08978951e-01f, -1.79358691e-01f, 2.97494442e-03f, 6.65482223e-01f, -4.40201342e-01f, 9.87760484e-01f, -6.08124614e-01f, -1.60612369e+00f, 1.67875075e+00f, 4.68227088e-01f,
  -7.67721057e-01f, -1.34466970e+00f, -1.31125426e+00f, -1.19579124e+00f, -1.71680522e+00f, 1.27698517e+00f, -1.65453482e+00f, -1.17197180e+00f, -5.07207096e-01f, -4.52601671e-01f,
  -3.98046076e-01f, -1.11381121e-01f, -6.46773100e-01f, 5.76011837e-01f, -1.41603017e+00f, 1.03271902e+00f, -8.59885395e-01f, -1.09962916e+00f, 7.94718504e-01f, 1.00302827e+00f,
  5.60460389e-01f, -1.70443976e+00f, -6.06430471e-01f, -1.11688066e+00f, 7.30958641e-01f, 4.93073076e-01f, 2.74555415e-01f, 5.73186278e-01f, 1.38980186e+00f, -1.37236810e+00f,
  -1.57689917e+00f, -1.13019764e+00f, 7.90353835e-01f, -4.32090640e-01f, -5.37533760e-01f, 8.66968691e-01f, -1.08782327e+00f, -4.89922047e-01f, 3.65936935e-01f, -1.22305644e+00f,
  -1.09561451e-01f, 5.74431360e-01f, -1.58229902e-01f, 8.07616413e-01f, 4.57973063e-01f, 1.67313039e+00f, -4.02675152e-01f, -1.44101679e+00f, -1.62510350e-01f, 8.37653399e-01f,
  -7.68183947e-01f, -1.31533504e+00f, 2.46937171e-01f, -1.47833538e+00f, 3.35566968e-01f, 5.71455240e-01f, -3.21037203e-01f, 3.46799135e-01f, 7.87877738e-01f, 5.07511720e-02f,
  -1.07587898e+00f, -1.21440744e+00f, 1.28422409e-01f, -6.67906046e-01f, -1.15996146e+00f, -1.11832249e+00f, -6.22766495e-01f, -2.66980290e-01f, -1.20458651e+00f, -7.14493990e-01f,
  -1.98683107e+00f, 1.64484084e+00f, 1.39387012e-01f, -2.52425261e-02f, -4.90302145e-02f, -1.40888676e-01f, -3.24831396e-01f, -5.44738054e-01f, 3.18210810e-01f, -1.03682852e+00f,
  6.25101388e-01f, -1.14788818e+00f, -1.06840312e-01f, -4.55268860e-01f, 1.26358676e+00f, -8.57746780e-01f, -1.49161172e+00f, -8.78690600e-01f, 2.29374751e-01f, -1.13588631e+00f,
  -6.50871933e-01f, -7.75465310e-01f, -7.91592717e-01f, 1.13600409e+00f, 7.91915596e-01f, -1.16142547e+00f, -7.19077826e-01f, -1.02221406e+00f, 1.08123064e+00f, -1.14036620e+00f,
  -7.86980331e-01f, 6.05799317e-01f, 7.61694252e-01f, -1.54963419e-01f, 6.10888779e-01f, -2.01489419e-01f, 1.80334374e-01f, 1.87529907e-01f, 9.65070903e-01f, -6.14963710e-01f,
  1.34625316e+00f, 1.14319718e+00f, 1.48579049e+00f, -1.51859033e+00f, -8.21503438e-03f, -1.79388607e+00f, -5.22150517e-01f, -8.06000769e-01f, -9.18859337e-03f, 1.92740768e-01f,
  -8.21277976e-01f, -1.55815095e-01f, 3.17778200e-01f, 2.00096518e-01f, -1.27987206e+00f, 1.41690314e+00f, 1.58141065e+00f, 9.04853404e-01f, -3.36970031e-01f, 6.77448392e-01f,
  -4.01292592e-01f, 8.53622854e-01f, -7.17937171e-01f, 2.73422658e-01f, -1.48950648e+00f, -1.48704469e+00f, 6.83522582e-01f, 2.49581307e-01f, 2.35447347e-01f, -9.07669842e-01f,
  -3.99456769e-01f, 2.52048612e-01f, 3.80518347e-01f, -7.33761728e-01f, -6.93201244e-01f, 5.98316967e-01f, 1.64243221e+00f, -2.58948386e-01f, -9.52774763e-01f, -1.54884398e+00f,
  -1.04258013e+00f, -5.47204576e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.45352000e-01f, -1.48842752e-01f, 4.18957859e-01f, -5.44580102e-01f, 2.16995731e-01f, -9.66036245e-02f, 3.29599082e-01f, -3.42516243e-01f, -5.20503521e-01f, 1.15888137e-02f,
  -9.65901241e-02f, -3.24273467e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    