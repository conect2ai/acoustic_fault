/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.10666859e-01f, 3.48933414e-02f, -1.09284945e-01f, -3.31345320e-01f, 2.46359795e-01f, 3.26284729e-02f, -3.43908668e-01f, 8.59472454e-02f, -7.01890932e-03f, -5.26972190e-02f,
  -1.21551998e-01f, 2.28705537e-02f, -7.96325505e-02f, -1.71430752e-01f, -5.15690148e-01f, -2.28982434e-01f, -3.35646480e-01f, -1.07866026e-01f, 4.91521955e-02f, -3.74493115e-02f,
  -6.16928786e-02f, -1.75438598e-01f, -1.52453989e-01f, 2.67913789e-01f, 1.01533517e-01f, 1.47775993e-01f, -8.23441520e-02f, 1.34064734e-01f, 3.99455465e-02f, 3.54504655e-03f,
  -6.22072145e-02f, 8.04029033e-03f, 1.38668567e-01f, 3.39399241e-02f, -4.06819060e-02f, -1.29336130e-03f, -2.77609937e-02f, 1.64300948e-02f, 3.29581462e-02f, 1.35788871e-02f,
  1.71928778e-02f, 5.10040559e-02f, -3.53911780e-02f, 5.06373458e-02f, 1.09147385e-01f, 4.41752747e-02f, 7.98016787e-02f, 6.88383877e-02f, 3.22351269e-02f, 7.05946162e-02f,
  5.90034835e-02f, 3.12692784e-02f, -5.83313592e-03f, -4.11163829e-02f, 1.51651287e-02f, -2.84645092e-02f, 3.05132708e-03f, 3.96186858e-02f, 1.60271786e-02f, 2.24290825e-02f,
  -2.69815177e-02f, 1.88896954e-02f, 2.94932611e-02f, 3.34281884e-02f, -4.89355214e-02f, 5.17544709e-02f, -1.14386845e-02f, -3.92752327e-02f, 7.01582944e-03f, -1.68229658e-02f,
  -5.12271263e-02f, 1.62134953e-02f, -1.73497060e-03f, 9.80117619e-02f, -2.41102315e-02f, 7.30764307e-03f, -5.23103327e-02f, 4.40416858e-02f, 3.58455516e-02f, -3.71134328e-03f,
  -1.97915919e-02f, -4.66492027e-02f, -6.43274095e-03f, -1.29559655e-02f, -2.78559066e-02f, 1.60242636e-02f, 9.12497640e-02f, 6.93960190e-02f, -2.93931868e-02f, -7.11162314e-02f,
  -2.38304764e-01f, -2.99083233e-01f, 5.42743190e-04f, 7.77195245e-02f, -2.49388497e-02f, 2.78393142e-02f, -6.39793277e-02f, 3.31420414e-02f, -8.39991271e-02f, -3.47619690e-02f,
  1.14204049e-01f, -4.59049046e-02f, -1.23593230e-02f, 1.23292406e-03f, -4.32328247e-02f, -1.14579484e-01f, -1.58895984e-01f, -2.80426443e-02f, -2.03002244e-02f, -2.33755969e-02f,
  1.78462230e-02f, 4.72677610e-04f, 1.41521972e-02f, 4.91863415e-02f, 3.28772478e-02f, -3.28661501e-02f, -6.10286444e-02f, 1.89839713e-02f, -1.04744337e-03f, -2.13097204e-02f,
  -2.98355401e-01f, 2.20194817e-01f, -2.01345950e-01f, -1.55086935e-01f, -1.58362865e-01f, -7.75393322e-02f, -2.12622747e-01f, 8.89088437e-02f, 7.30963945e-02f, 2.04558030e-01f,
  5.11527387e-03f, -1.50577381e-01f, -1.78620312e-02f, 4.04124297e-02f, -2.44985819e-01f, 2.13559955e-01f, 8.86941329e-02f, 6.45182133e-02f, 7.52334390e-03f, -3.94095965e-02f,
  -4.78649028e-02f, 5.64007014e-02f, -2.17000008e-01f, 2.30641682e-02f, -2.21971348e-01f, -4.80475985e-02f, -3.62529755e-02f, -1.62002161e-01f, -4.42334078e-02f, -8.02109018e-02f,
  3.47768725e-03f, 7.20193684e-02f, -8.69658440e-02f, 7.14765564e-02f, -5.39106354e-02f, -3.12245190e-02f, -2.59956252e-02f, -8.54893029e-02f, -6.66277856e-02f, -4.67303023e-02f,
  3.18228155e-02f, -4.79641631e-02f, 2.17208546e-03f, 3.56656499e-02f, -1.05170971e-02f, -1.18310458e-03f, -1.95030775e-02f, 7.81764742e-03f, 1.66160297e-02f, -1.09075129e-01f,
  -4.36050519e-02f, -4.18101177e-02f, -4.21299450e-02f, 1.84482969e-02f, -1.35902718e-01f, -1.02531454e-02f, 1.33104017e-02f, -9.44353268e-02f, 5.43226115e-02f, -5.07018715e-03f,
  3.25213224e-02f, -4.16810401e-02f, -1.21822003e-02f, -5.60143404e-02f, 5.40612862e-02f, -1.37945032e-02f, 8.78187492e-02f, -3.67858354e-03f, -4.39126790e-03f, -1.85128897e-02f,
  -5.67426421e-02f, -2.79729068e-02f, 5.52529767e-02f, -3.08656022e-02f, -5.06436825e-02f, -6.50154566e-03f, -2.45079268e-02f, -1.03574134e-02f, -1.91972405e-02f, -5.13008535e-02f,
  4.97646518e-02f, 1.63390972e-02f, 2.40215659e-02f, -1.99822504e-02f, 5.24449535e-02f, -7.73611516e-02f, -4.51773219e-02f, -7.54316570e-03f, -3.78610268e-02f, -8.72582048e-02f,
  2.19002113e-01f, 1.87805220e-01f, -4.66076545e-02f, -2.27262788e-02f, 1.02234274e-01f, 4.32989858e-02f, 5.39437607e-02f, 4.63813655e-02f, 9.31022167e-02f, 4.89337295e-02f,
  -6.88591599e-02f, -1.05977338e-02f, 6.27305955e-02f, -1.73076261e-02f, 3.27804871e-02f, 2.50070952e-02f, -4.37690318e-02f, 1.20699378e-02f, -5.16487993e-02f, 4.19295132e-02f,
  -9.26666185e-02f, 3.10927490e-03f, 4.80849668e-03f, -4.61565666e-02f, 3.16623040e-02f, -1.42011009e-02f, 6.65696012e-03f, 3.56231779e-02f, 2.80440673e-02f, -2.11968627e-02f,
  3.87228400e-01f, 1.04624473e-01f, 4.55092937e-02f, 9.33643281e-02f, -1.66406427e-02f, 1.34947911e-01f, -5.86933922e-03f, 6.76204488e-02f, 2.43075117e-01f, -1.46225557e-01f,
  -1.89648345e-01f, 2.15637058e-01f, -2.86161125e-01f, 3.90116274e-02f, 1.03570847e-02f, -1.34210452e-01f, 1.25600383e-01f, 4.58984375e-02f, 6.70139492e-02f, 1.43940337e-02f,
  5.88231273e-02f, -1.70486689e-01f, -7.78350886e-03f, -6.63001463e-02f, 1.78463794e-02f, 5.94971105e-02f, -9.67564061e-02f, -4.95398864e-02f, -6.67898729e-02f, -4.31688642e-03f,
  8.87207314e-03f, 1.43456357e-02f, -4.85742353e-02f, 3.11741251e-02f, -8.67787283e-03f, -2.79176608e-02f, -1.38703771e-02f, -4.69071008e-02f, 1.15434686e-03f, -2.08333135e-02f,
  -1.18954445e-03f, 4.72435690e-02f, -1.37501620e-02f, -2.74400339e-02f, 6.89225495e-02f, 3.56198251e-02f, 1.85261890e-02f, 2.12526303e-02f, -3.40283401e-02f, 2.89508551e-02f,
  1.58697553e-02f, -2.05389131e-02f, 6.14636876e-02f, 5.85747771e-02f, 8.43104273e-02f, 5.02466932e-02f, 6.63359389e-02f, -1.00699044e-03f, 5.29869739e-03f, 6.69626743e-02f,
  4.99262773e-02f, -2.11774511e-03f, -5.37561206e-03f, -8.40771720e-02f, -1.23230908e-02f, -1.32547477e-02f, 2.10780073e-02f, -4.53542471e-02f, 2.17715800e-02f, 2.25050114e-02f,
  -2.34669168e-03f, 2.99961902e-02f, -2.13419064e-03f, 4.32924600e-03f, -5.94473928e-02f, 4.06446047e-02f, -5.27859014e-03f, 1.05763711e-02f, 7.46267810e-02f, -3.86881307e-02f,
  2.79528610e-02f, 6.44795671e-02f, -4.55939136e-02f, -6.72377422e-02f, 2.01658439e-02f, -6.23439718e-03f, -3.91381346e-02f, 3.29465158e-02f, -8.40516947e-03f, -2.69139949e-02f,
  1.71171483e-02f, -2.29781829e-02f, -1.96987335e-02f, -2.39011887e-02f, 2.45223846e-02f, 1.61390193e-02f, 4.21085283e-02f, 4.75783683e-02f, 3.47627676e-03f, -4.15564142e-02f,
  4.00054865e-02f, -4.25253063e-02f, 6.73823953e-02f, 3.68041769e-02f, 5.93150556e-02f, -8.06477852e-03f, 4.33668232e-04f, 6.22262470e-02f, 9.07830074e-02f, -3.97267565e-03f,
  -2.76704933e-02f, 5.69636002e-02f, 7.99595565e-03f, 1.97735261e-02f, -1.35337925e-02f, -8.97369720e-03f, 3.69114168e-02f, 3.74643542e-02f, -3.10848039e-02f, 5.51556889e-03f,
  -4.46153969e-01f, -2.64207441e-02f, -1.44580364e-01f, -2.04652742e-01f, 7.76462406e-02f, 3.85718405e-01f, 1.88102171e-01f, 3.23091857e-02f, 4.56549749e-02f, 5.66420704e-02f,
  -1.19947381e-02f, -5.34576625e-02f, -1.52588040e-02f, 5.01195788e-02f, -7.56689608e-02f, 1.20877795e-01f, 9.60010290e-02f, -4.46420396e-03f, 5.16266413e-02f, -5.50437719e-02f,
  -1.04969665e-01f, 1.34182021e-01f, -5.60212182e-03f, 6.32964969e-02f, -7.11411834e-02f, -4.08075117e-02f, -1.11283474e-01f, 2.44860463e-02f, -6.30531311e-02f, 5.34400530e-02f,
  -7.77170733e-02f, -1.79135371e-02f, -6.67774379e-02f, 6.67282864e-02f, 2.76758336e-02f, 1.44857299e-02f, -4.05715443e-02f, 6.35696296e-03f, 1.03836395e-02f, -1.04056075e-02f,
  -3.48056890e-02f, -1.75773297e-02f, 2.75940150e-02f, 9.22660977e-02f, 1.35883829e-02f, 6.83585629e-02f, -3.05785816e-02f, -3.71273607e-02f, -1.21324360e-02f, 9.61754657e-03f,
  -6.63438067e-02f, 2.77667157e-02f, 4.09970954e-02f, 7.23598525e-02f, -2.10898672e-03f, 1.05127424e-01f, 3.98545414e-02f, -2.49377481e-04f, 2.72712596e-02f, 1.99704394e-02f,
  7.64430985e-02f, -3.19246366e-03f, -1.14322109e-02f, -4.65190858e-02f, -3.07408236e-02f, -3.09326481e-02f, 9.56581160e-03f, -6.20442815e-02f, 1.42175863e-02f, -5.06414250e-02f,
  -4.94557545e-02f, -5.61192483e-02f, -5.43553494e-02f, -1.92501198e-03f, -2.48305481e-02f, -1.20038148e-02f, -3.61661911e-02f, 1.05487118e-02f, -3.95625085e-02f, -6.75188676e-02f,
  9.94818192e-03f, -5.52319773e-02f, -1.78435277e-02f, -3.21335644e-02f, 6.44764230e-02f, 6.16316567e-04f, 4.94479109e-03f, 3.65556101e-03f, -2.26065032e-02f, -6.73793480e-02f,
  4.60043438e-02f, -1.42376617e-01f, 3.19491290e-02f, -4.89052124e-02f, 4.37048711e-02f, -1.84097327e-02f, 4.46008006e-03f, -7.44288741e-03f, 3.05979960e-02f, 8.74358714e-02f,
  6.13610893e-02f, 4.35953327e-02f, 2.83255782e-02f, -3.35931554e-02f, 1.21322377e-02f, 2.45120819e-03f, 4.82604466e-03f, 5.80913946e-02f, 1.09278485e-02f, -4.78690714e-02f,
  -7.95431584e-02f, 1.64852440e-02f, -3.59165594e-02f, -9.13141295e-02f, -1.01091461e-02f, -1.67078357e-02f, -3.11935227e-02f, 7.63392150e-02f, -5.65461777e-02f, 8.23972225e-02f,
  3.07186216e-01f, -5.00913382e-01f, 3.44538540e-02f, -1.24020748e-01f, 2.87695855e-01f, 1.35619119e-01f, 7.91430101e-02f, -2.07198393e-02f, -4.70822230e-02f, -2.21707776e-01f,
  1.65397942e-01f, -5.20810448e-02f, -6.78804368e-02f, -1.85335934e-01f, 3.43619376e-01f, -2.55419433e-01f, 3.13024633e-02f, -9.71197151e-03f, -1.08732574e-01f, -7.06917197e-02f,
  -6.78322464e-02f, 5.46886399e-03f, -1.01219490e-01f, -1.44315735e-02f, 9.39766467e-02f, -1.07778072e-01f, 1.85735017e-01f, -1.84356514e-02f, 4.32085805e-03f, 6.66928589e-02f,
  -1.13482147e-01f, -7.61754811e-02f, 8.49535018e-02f, 6.19438998e-02f, 1.46181971e-01f, 9.37042981e-02f, 5.72169246e-03f, -7.59628485e-04f, 7.23726526e-02f, -5.27410619e-02f,
  6.29883399e-03f, 4.32436056e-02f, -6.46983236e-02f, 3.28144655e-02f, 1.35072218e-02f, -1.22875553e-02f, -2.07818598e-02f, 1.41844312e-02f, -1.16430044e-01f, -6.11222312e-02f,
  -5.44659086e-02f, -1.15740560e-02f, -3.16203684e-02f, -3.68107781e-02f, 1.03288386e-02f, 1.54251084e-02f, -1.53028397e-02f, 3.06254439e-02f, -3.75931151e-02f, 4.19879146e-02f,
  1.62718818e-02f, -1.64811648e-02f, -4.48807776e-02f, 3.60635258e-02f, -2.60058936e-04f, 3.07834577e-02f, 4.81447345e-03f, -7.90053047e-03f, 3.95121835e-02f, -2.47211512e-02f,
  5.43421693e-02f, 3.29357386e-03f, 3.83129008e-02f, -1.27300303e-02f, -3.91081162e-02f, 2.44512241e-02f, 8.75453278e-03f, -2.55947188e-02f, -4.27809246e-02f, -5.94696496e-03f,
  -2.79042106e-02f, -1.40943201e-02f, 7.23567419e-03f, 2.95694582e-02f, 3.07538640e-02f, 3.04647926e-02f, -1.58254392e-02f, -5.62828854e-02f, 4.06470560e-02f, 3.86054739e-02f,
  1.95951555e-02f, -1.96393937e-01f, -4.36770767e-02f, -1.63111594e-02f, -1.52395349e-02f, 3.01713143e-02f, -1.76445413e-02f, -3.46044041e-02f, -5.66707589e-02f, 5.39238378e-02f,
  3.71684097e-02f, -1.99706294e-02f, 4.89919931e-02f, 2.05992796e-02f, 4.61151525e-02f, -6.09185286e-02f, -1.42621808e-02f, 1.70122888e-02f, 1.34294152e-01f, -5.91616426e-03f,
  -9.07643139e-03f, 8.81894492e-03f, -2.40910016e-02f, 2.55906563e-02f, 1.50436219e-02f, 1.27088940e-02f, 7.95894861e-02f, -6.52250275e-02f, 1.70210693e-02f, 4.32147086e-03f,
  -4.26535219e-01f, -7.64432270e-03f, -1.99292555e-01f, 1.95097830e-02f, -1.31804600e-01f, -1.76285878e-01f, -4.00333405e-02f, -6.22115470e-02f, -2.21935526e-01f, 5.61006218e-02f,
  2.22447067e-01f, 7.82708526e-02f, 1.53057218e-01f, 1.24542005e-01f, -8.21424946e-02f, 9.36443061e-02f, -1.47894502e-01f, -3.18353288e-02f, 2.69581452e-02f, -1.11121595e-01f,
  -1.35840058e-01f, 1.44739896e-01f, 1.71814919e-01f, 7.90490583e-02f, 2.35975105e-02f, -7.69095570e-02f, 2.37297833e-01f, 4.46926989e-02f, 1.17786340e-01f, -8.29645060e-03f,
  -3.42214890e-02f, 8.56273100e-02f, -8.81203040e-02f, -4.06979658e-02f, -2.78650280e-02f, 2.71396693e-02f, -5.87034002e-02f, 6.35967106e-02f, -1.22006824e-02f, -4.41377684e-02f,
  6.04266562e-02f, 1.09148677e-02f, -2.42024716e-02f, -3.79044451e-02f, -1.25766560e-01f, 1.81233361e-02f, -1.56368855e-02f, -4.36407588e-02f, 5.65131381e-03f, -2.74413228e-02f,
  -6.16328558e-03f, -5.94008341e-02f, -7.07890606e-03f, 3.21536176e-02f, 3.84178609e-02f, -1.23570366e-02f, 2.96458025e-02f, 3.87400575e-02f, -6.40147328e-02f, -7.87937194e-02f,
  -6.21110499e-02f, -4.70007658e-02f, -5.29975817e-02f, 1.90396961e-02f, 3.42025422e-02f, -4.31993008e-02f, 1.68930683e-02f, 5.83358221e-02f, -1.90021936e-02f, 4.11859192e-02f,
  -3.54125127e-02f, 1.08640585e-02f, -1.24030532e-02f, -4.86764610e-02f, -3.90816703e-02f, 7.23399371e-02f, 1.66474245e-02f, 7.11518303e-02f, -3.00384592e-02f, 1.05005261e-02f,
  4.08535488e-02f, -5.20804971e-02f, 6.85494021e-02f, 6.02323003e-02f, 4.26286794e-02f, -2.08225325e-02f, 1.10454792e-02f, -2.77494509e-02f, 3.13719325e-02f, -3.09097357e-02f,
  5.77446856e-02f, 1.82238054e-02f, -6.55297050e-03f, -2.38791872e-02f, 6.01776391e-02f, 4.95172627e-02f, -5.80386594e-02f, -1.75951459e-02f, -1.96470506e-02f, 6.55611828e-02f,
  7.57547654e-03f, -1.97383352e-02f, 6.70451075e-02f, 2.44420208e-02f, -3.55950743e-02f, 3.96880880e-02f, 8.57020393e-02f, 2.92635020e-02f, -6.12505944e-03f, 7.27931559e-02f,
  -1.45338522e-02f, 2.41895895e-02f, -4.85913716e-02f, -4.67428863e-02f, 1.79017950e-02f, 1.69639084e-02f, -9.27466825e-02f, -8.39768946e-02f, 1.58327613e-02f, 3.87575738e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.38321409e-01f, 1.11694969e-01f, -1.99845105e-01f, -1.43662602e-01f, 7.54041076e-02f, -2.07205310e-01f, -9.81393233e-02f, 5.00773713e-02f, -9.44399908e-02f, 1.83639497e-01f,
  -7.71721825e-03f, -3.88150327e-02f, 3.03054433e-02f, -2.67663002e-01f, -7.15480089e-01f, -3.22042525e-01f, -3.76709253e-01f, -1.57366395e-01f, -1.78970501e-01f, 6.83696717e-02f,
  -1.90644011e-01f, -9.75903198e-02f, -2.49547467e-01f, 1.59582078e-01f, 1.03255667e-01f, 1.37176052e-01f, 2.74039030e-01f, 2.57139117e-01f, -1.83515791e-02f, -6.32819682e-02f,
  -1.24685101e-01f, 7.72355273e-02f, -3.57256494e-02f, -3.02341301e-02f, 1.58284847e-02f, 3.37764844e-02f, 2.13321969e-02f, -1.65328700e-02f, -2.26336196e-02f, -8.63894224e-02f,
  7.78632313e-02f, 2.56997272e-02f, -9.20852050e-02f, 4.35923003e-02f, 1.38969850e-02f, 1.15592085e-01f, -9.83108655e-02f, -4.97732013e-02f, -9.13381670e-03f, -6.70343358e-03f,
  6.34614332e-03f, 3.39027531e-02f, 6.64943531e-02f, -2.29810886e-02f, -8.36087614e-02f, 8.98825601e-02f, -6.88167382e-03f, -5.04353608e-04f, -6.28713220e-02f, -4.30191793e-02f,
  7.46041313e-02f, 2.79747415e-02f, 8.15978944e-02f, -9.81789902e-02f, 2.81792935e-02f, 3.03094164e-02f, 1.29716620e-02f, 1.63385905e-02f, 2.47170776e-02f, -1.60670432e-03f,
  2.62243971e-02f, -9.98318847e-03f, 3.62486877e-02f, -2.63626240e-02f, 3.67008187e-02f, 4.71563078e-02f, 1.71654318e-02f, 5.57625070e-02f, -6.62084669e-02f, -3.44764516e-02f,
  5.84599189e-02f, -3.09440866e-02f, -1.95844583e-02f, 8.03012326e-02f, -2.64285877e-02f, 4.17066887e-02f, -1.54843107e-02f, 1.79424807e-02f, -3.29805538e-03f, 4.29467931e-02f,
  4.78823222e-02f, 1.11246474e-01f, 2.08576862e-02f, 1.82704888e-02f, -4.83741686e-02f, 9.22542810e-03f, -6.00829087e-02f, -1.08024344e-01f, -5.34706526e-02f, -1.45729212e-02f,
  7.79172108e-02f, 7.27292299e-02f, 4.92186807e-02f, -1.57882906e-02f, 3.30276527e-02f, -3.82404439e-02f, 1.18570670e-01f, 7.58038238e-02f, 8.05464983e-02f, -2.72127129e-02f,
  1.24944344e-01f, 2.90406100e-03f, -6.04000501e-02f, -1.45869451e-02f, 2.09869780e-02f, 5.54662235e-02f, 6.11062488e-03f, -3.19675207e-02f, 5.45992739e-02f, -8.47480446e-03f,
  3.23915213e-01f, 2.38680281e-02f, 1.76073372e-01f, 3.82544398e-01f, 9.96516719e-02f, -1.16652027e-02f, 9.99144651e-03f, 1.31162643e-01f, 3.30983937e-01f, -6.14551343e-02f,
  -6.78126886e-02f, 1.87894106e-02f, -4.82163578e-02f, 6.63463399e-02f, -1.70575216e-01f, -1.50356308e-01f, -7.11030792e-03f, 4.22213413e-02f, 1.07028119e-01f, 1.08193330e-01f,
  1.53754979e-01f, -1.41112715e-01f, -1.18223824e-01f, -7.67081827e-02f, 1.48758546e-01f, 1.35177419e-01f, -1.39024600e-01f, -9.01139975e-02f, -1.04202472e-01f, -1.62461728e-01f,
  -7.15059787e-03f, 4.10677195e-02f, -6.64755702e-02f, -6.53477805e-03f, 2.20482908e-02f, 8.96313414e-02f, -3.29925492e-02f, -6.79756626e-02f, -2.05807872e-02f, -3.84849831e-02f,
  -1.47831226e-02f, -4.02819961e-02f, 5.92910722e-02f, 2.94284839e-02f, 2.55517941e-02f, 1.26447439e-01f, 1.07870959e-01f, 5.08289747e-02f, 5.39404973e-02f, -1.91411786e-02f,
  1.87143944e-02f, 3.91893610e-02f, 7.90984109e-02f, -6.57662526e-02f, -5.30125573e-02f, 3.22526135e-02f, -4.27721143e-02f, 1.41360462e-02f, -8.60239659e-03f, -7.02459216e-02f,
  -1.43019304e-01f, 4.61532356e-04f, -3.48986834e-02f, -1.73387043e-02f, 2.18369197e-02f, 3.28686535e-02f, -3.45997922e-02f, -2.36808155e-02f, 5.95344678e-02f, 3.37621681e-02f,
  -5.98790217e-03f, -1.06435698e-02f, -1.73428711e-02f, 6.55392036e-02f, 1.68652739e-02f, -2.37536710e-02f, 1.07299807e-02f, 9.33519229e-02f, -3.91516164e-02f, 6.32318184e-02f,
  -7.98257813e-02f, -8.28955546e-02f, -4.24676985e-02f, -7.56907985e-02f, -2.55090010e-04f, -6.94622174e-02f, 5.15338592e-02f, 5.22763804e-02f, -1.62890013e-02f, -1.59576293e-02f,
  -7.56792948e-02f, -5.93561418e-02f, -1.96638703e-03f, -2.65131779e-02f, -4.23073247e-02f, -1.30702211e-02f, -1.80791654e-02f, -8.50864947e-02f, -7.09072053e-02f, 1.09610483e-02f,
  3.73630337e-02f, 8.90545771e-02f, -4.44598757e-02f, 1.41727831e-02f, -7.41855130e-02f, -1.55707914e-02f, -3.50925922e-02f, -3.90067510e-02f, -1.21454962e-01f, -1.75215583e-02f,
  -4.61380221e-02f, 5.42695150e-02f, -4.46749814e-02f, -6.60776570e-02f, -3.05497199e-02f, 1.63938310e-02f, 2.10770294e-02f, 2.21749069e-03f, -3.32356319e-02f, -5.30694649e-02f,
  -3.91304195e-02f, -1.60874456e-01f, 1.66811775e-02f, -3.14637013e-02f, 8.62473994e-02f, 1.04642287e-01f, 2.45449021e-02f, -1.17110917e-02f, -1.60550684e-01f, -1.70071200e-01f,
  -8.15973505e-02f, 1.23548759e-02f, -1.00529693e-01f, 9.08786431e-02f, 7.72012547e-02f, -8.52352977e-02f, -4.78528105e-02f, 7.57273361e-02f, -6.93235844e-02f, 2.36656889e-03f,
  8.71129185e-02f, -6.49511814e-02f, 1.14379987e-01f, 3.23496200e-02f, 3.22212651e-02f, -3.17107365e-02f, -2.26594955e-02f, 7.99460486e-02f, -2.59608198e-02f, 3.24773230e-02f,
  -4.05509863e-03f, 3.41153368e-02f, -4.73171249e-02f, 7.03030266e-03f, 2.81978380e-02f, 8.63011703e-02f, 1.07701523e-02f, 7.64053985e-02f, 2.27592885e-02f, 8.56748894e-02f,
  -2.97634453e-02f, 7.77919143e-02f, -6.18834374e-03f, 5.02303662e-03f, -6.58841431e-02f, -5.38656600e-02f, 9.58278999e-02f, 2.18835678e-02f, 4.35953587e-02f, -1.02560287e-02f,
  6.59938902e-02f, 4.30529146e-03f, 6.83094859e-02f, -7.63523486e-03f, 8.94747823e-02f, 5.56117333e-02f, -6.07193671e-02f, -6.92823604e-02f, -1.89525373e-02f, -4.93830927e-02f,
  1.82527176e-03f, -2.29325658e-03f, -6.58664285e-05f, -1.28982170e-02f, -8.63896683e-02f, -5.39968535e-02f, -1.02782892e-02f, 6.53117672e-02f, 6.87763244e-02f, 4.95249219e-03f,
  -2.53890660e-02f, 8.34345743e-02f, -2.52510719e-02f, 6.73748180e-02f, 5.50719164e-02f, -4.04918417e-02f, 4.82195942e-03f, 7.07936212e-02f, 2.28159782e-02f, 3.02916076e-02f,
  8.86213705e-02f, 1.51381139e-02f, 2.01350730e-02f, -4.45251586e-03f, 3.63065898e-02f, -6.12894632e-02f, 1.41015528e-02f, -7.45828450e-02f, 3.64870057e-02f, -1.33033553e-02f,
  -3.06070019e-02f, -1.67405114e-01f, -3.46842557e-02f, 1.08510442e-02f, -5.19276075e-02f, -1.95611008e-02f, 5.79733178e-02f, -9.23938826e-02f, 2.34971661e-02f, 2.71941070e-02f,
  6.98434785e-02f, 1.20644439e-02f, -5.80892079e-02f, -5.83471954e-02f, 3.76781859e-02f, -5.19518815e-02f, 9.59658157e-03f, 4.49699610e-02f, 8.27255994e-02f, -1.05256878e-01f,
  -7.62381107e-02f, 2.51868069e-02f, -1.47587582e-02f, 7.04370588e-02f, 4.29323576e-02f, -4.97820377e-02f, 2.42359424e-03f, -7.21751153e-02f, -5.09705283e-02f, -6.16997555e-02f,
  3.73795182e-01f, 3.23811024e-02f, -2.07946539e-01f, -1.51432408e-02f, 1.83473244e-01f, 8.89994279e-02f, 4.97989208e-02f, 4.45064195e-02f, 1.20428530e-02f, 7.04494268e-02f,
  2.08151549e-01f, -1.11625850e-01f, -1.96578242e-02f, 1.91344410e-01f, 1.39649406e-01f, -6.26147762e-02f, 2.03331530e-01f, 1.16642416e-01f, -1.60333827e-01f, 2.26539463e-01f,
  6.81715682e-02f, 2.45612487e-01f, -1.27683803e-01f, 1.11863829e-01f, 1.87334076e-01f, -1.27747789e-01f, 1.75412908e-01f, -1.88157678e-01f, 2.85330489e-02f, 7.36644212e-03f,
  -6.28083991e-03f, -4.15805131e-02f, 1.01135615e-02f, -5.88820279e-02f, 4.44561318e-02f, 4.27164733e-02f, -5.24053685e-02f, -7.80959576e-02f, -7.28351995e-02f, 9.07255244e-03f,
  -7.18514100e-02f, -5.94477765e-02f, 9.83292330e-03f, 6.44076914e-02f, 2.05503814e-02f, 6.00501187e-02f, 1.84628703e-02f, -7.66497329e-02f, -6.33603781e-02f, 5.99849746e-02f,
  -2.25733928e-02f, -1.07972464e-02f, 1.44304726e-02f, -3.91358435e-02f, 1.02925841e-02f, -4.68364581e-02f, -3.21682543e-02f, 3.00254226e-02f, 8.92867427e-03f, 8.90841559e-02f,
  1.08294733e-01f, 3.68559845e-02f, -4.17365134e-03f, 4.00943570e-02f, 7.15580732e-02f, -1.54224019e-02f, 2.18315162e-02f, 2.85458639e-02f, 2.32830439e-02f, 3.67538668e-02f,
  6.37127459e-02f, -6.79720044e-02f, 7.42893666e-02f, -6.84574945e-03f, 4.01738025e-02f, -3.45937051e-02f, -3.20857503e-02f, 4.79010912e-03f, 3.85511145e-02f, -7.28823543e-02f,
  -5.35195842e-02f, -2.97307316e-02f, 4.98769917e-02f, -3.43474671e-02f, -2.90481076e-02f, -2.57225707e-02f, 1.32354185e-01f, 5.85739203e-02f, -4.58316579e-02f, 5.19128814e-02f,
  -2.61320453e-03f, 1.45400271e-01f, -3.92168611e-02f, -1.74552556e-02f, -7.77128488e-02f, 1.16460800e-01f, 4.07738239e-02f, 3.68374586e-02f, -2.69500129e-02f, -8.43940377e-02f,
  1.02303445e-01f, 1.42734135e-02f, 8.62115100e-02f, -6.25875294e-02f, -7.79431686e-02f, 1.35763541e-01f, 3.39202695e-02f, 2.51880451e-03f, 4.11555823e-03f, 9.19588879e-02f,
  -7.05996482e-03f, 7.45132938e-02f, -7.96606950e-03f, -2.48929262e-02f, -5.17202616e-02f, 4.45399098e-02f, -5.80840595e-02f, 3.35768126e-02f, 6.26578927e-02f, -9.97704193e-02f,
  -6.22284645e-03f, 1.56574875e-01f, -1.74900845e-01f, -8.27165321e-03f, -5.07328697e-02f, 2.46017963e-01f, 4.52598929e-01f, -1.35245010e-01f, 2.83915782e-03f, 3.09886307e-01f,
  2.37105981e-01f, 7.87594169e-02f, 1.70150757e-01f, 2.46591806e-01f, 1.17499046e-01f, 2.56182522e-01f, 3.43766809e-01f, 2.51510948e-01f, -3.99254151e-02f, 7.04240724e-02f,
  -3.05401720e-02f, 2.32862413e-01f, -1.32213846e-01f, -1.46754012e-01f, 1.32765785e-01f, -2.25531295e-01f, -3.42898071e-02f, -1.69981688e-01f, -2.71821171e-02f, 7.29970261e-02f,
  4.98261638e-02f, 7.82434195e-02f, -8.93670917e-02f, -4.69045714e-02f, 1.43404622e-02f, -1.20401504e-02f, -3.70678911e-03f, -3.13454904e-02f, -3.16869058e-02f, 2.97558960e-02f,
  4.98110689e-02f, -2.01330660e-03f, -2.66454350e-02f, -6.38750196e-02f, -2.51184423e-02f, -5.38974851e-02f, 8.01914022e-04f, -1.80451609e-02f, -4.91300039e-02f, -3.47594842e-02f,
  -9.20012034e-03f, -2.98959743e-02f, 1.85301378e-02f, 1.08103655e-01f, -7.50794113e-02f, 1.30030969e-02f, 1.36367884e-02f, -5.43885166e-03f, -3.94754438e-03f, -4.27310281e-02f,
  -5.58228791e-03f, 9.60312635e-02f, 4.06925678e-02f, 3.99520481e-03f, -5.60233258e-02f, -1.22190528e-02f, 4.20153923e-02f, 4.80994508e-02f, 3.44028473e-02f, 1.06059266e-02f,
  5.33815436e-02f, -8.05134233e-03f, 3.20634432e-02f, 6.94774762e-02f, 6.90104812e-02f, 4.37045470e-02f, -2.13669054e-02f, 9.75818653e-03f, -2.28190515e-02f, 5.26197553e-02f,
  -5.71142770e-02f, 4.61914092e-02f, 1.41616855e-02f, -2.26362869e-02f, 8.73376355e-02f, 2.80299932e-02f, 5.31421565e-02f, 7.79040391e-03f, -4.56021680e-03f, 5.52889109e-02f,
  1.27072692e-01f, 6.41540736e-02f, 4.38025855e-02f, 1.76089313e-02f, -7.07125664e-02f, -1.07386094e-02f, 3.04390967e-04f, -3.44029106e-02f, -2.25539040e-02f, 1.56264883e-02f,
  1.28279850e-02f, 3.12753096e-02f, 5.79076214e-03f, 4.48216982e-02f, 3.16392370e-02f, 6.26001209e-02f, 3.05605363e-02f, -4.41470258e-02f, -2.00061444e-02f, -7.43906498e-02f,
  -1.96932647e-02f, 4.72107045e-02f, 2.52763443e-02f, -5.32255061e-02f, 6.74333349e-02f, 7.04930797e-02f, 4.23533916e-02f, -2.86188275e-02f, -5.76662570e-02f, 5.24768047e-02f,
  -3.46702337e-01f, 3.10402125e-01f, -4.49726023e-02f, 4.51404601e-02f, 1.26900658e-01f, -9.69072878e-02f, -2.09499113e-02f, 1.15342766e-01f, 3.38180542e-01f, 1.00737512e-01f,
  2.02683844e-02f, 6.61465973e-02f, 1.66125551e-01f, -4.37239297e-02f, -2.24213108e-01f, 5.63359447e-02f, -2.32161775e-01f, -4.95227277e-02f, 1.28497034e-01f, -6.35218769e-02f,
  -6.94180578e-02f, -4.49701101e-02f, -2.37018690e-01f, 7.12699890e-02f, -1.70558065e-01f, -6.58453032e-02f, -1.57880947e-01f, 1.92653745e-01f, -2.06618816e-01f, 1.14931799e-01f,
  -5.18442020e-02f, 1.08936995e-01f, -7.12672248e-02f, -2.41722632e-02f, -1.53860047e-01f, -4.58921082e-02f, -3.66720110e-02f, 7.69061223e-02f, 4.64889780e-02f, 2.81279609e-02f,
  -6.67259702e-03f, 4.55042943e-02f, -7.36482348e-03f, 8.44834000e-03f, 8.15905407e-02f, -1.06800213e-01f, -6.90254243e-03f, -1.42105162e-01f, -8.07020720e-03f, -1.62005797e-02f,
  -4.05821167e-02f, -9.43708867e-02f, -7.56566599e-02f, -8.67093205e-02f, -7.97535479e-02f, 8.99669994e-03f, -8.36535543e-03f, -5.62141016e-02f, -4.91487719e-02f, 5.75544685e-02f,
  -1.05460938e-04f, 2.46404968e-02f, 6.46059960e-03f, 9.53672379e-02f, -9.29186586e-03f, 3.87296937e-02f, 6.35014027e-02f, -5.33379503e-02f, 4.16003540e-02f, -8.00910369e-02f,
  -3.17323171e-02f, 5.46388216e-02f, 9.42450836e-02f, -4.45353277e-02f, 1.09699773e-04f, -8.25278088e-03f, -3.12233642e-02f, -5.20712957e-02f, -3.79102640e-02f, -8.64046663e-02f,
  7.38430321e-02f, 8.45266804e-02f, 2.89247185e-02f, -1.09464228e-02f, 3.57950502e-03f, 2.35785525e-02f, 2.92096417e-02f, -4.23771096e-03f, -6.85212202e-04f, -4.64219823e-02f,
  -3.40022556e-02f, 1.94793284e-01f, -1.19996108e-02f, 4.13627326e-02f, 4.22096178e-02f, -1.06683150e-01f, 2.92449109e-02f, -9.86384675e-02f, 3.95394396e-03f, -7.16765458e-03f,
  -1.15939155e-01f, 1.42413592e-02f, -8.17831755e-02f, 2.26012934e-02f, -9.24447179e-03f, 2.86077950e-02f, 4.64813747e-02f, -4.29983623e-02f, 5.61614484e-02f, -8.78617764e-02f,
  -3.94693166e-02f, 1.17881998e-01f, 1.96595639e-02f, -5.89352623e-02f, 2.27863118e-02f, -7.10891932e-02f, 2.91262269e-02f, -4.08134237e-02f, 1.02392025e-03f, 2.25633457e-02f,
  -5.53158410e-02f, 7.11188763e-02f, -6.52413592e-02f, -1.17352255e-01f, -1.21701412e-01f, -2.38470793e-01f, -3.15954924e-01f, 5.91376144e-03f, 1.08642243e-01f, 1.05053723e-01f,
  -1.00146219e-01f, 1.19148910e-01f, -2.79565062e-02f, -3.20681214e-01f, -1.52200669e-01f, 4.97534825e-03f, -3.71539980e-01f, -7.56728277e-02f, -1.03976913e-01f, -1.61104053e-01f,
  -1.21349037e-01f, -2.53082514e-01f, -2.61462033e-01f, -5.22210859e-02f, -1.94569170e-01f, -2.53979247e-02f, 8.04846957e-02f, -4.59837280e-02f, -7.84101039e-02f, -1.23588897e-01f,
  -9.61598083e-02f, 2.31571887e-02f, -3.94376442e-02f, -2.41476651e-02f, -1.70622524e-02f, 6.30553216e-02f, -4.80548516e-02f, 1.79735012e-02f, -6.04105294e-02f, 5.61467446e-02f,
  6.14171773e-02f, 2.69693714e-02f, 4.64368239e-02f, 2.93823350e-02f, -6.86679706e-02f, 2.01993692e-03f, 3.15908459e-03f, 4.48510908e-02f, 7.70017505e-02f, -4.19096611e-02f,
  -5.91788965e-04f, 6.80005699e-02f, -3.10865678e-02f, 4.41551469e-02f, -4.17311341e-02f, -3.86701487e-02f, 1.78561844e-02f, 4.40131538e-02f, 1.37904473e-02f, -6.24990650e-03f,
  -2.36890465e-03f, 4.55127051e-03f, -9.04412344e-02f, 7.58322552e-02f, -3.46726440e-02f, -8.06901976e-02f, -7.69888088e-02f, 7.95067102e-02f, -3.48708518e-02f, 1.91293322e-02f,
  5.96803091e-02f, 2.70733191e-03f, -4.61902795e-03f, -1.31319547e-02f, -1.69014204e-02f, 4.04831134e-02f, -1.58754010e-02f, -1.88378226e-02f, -3.40952873e-02f, -1.48092462e-02f,
  1.26908096e-02f, 4.91345488e-02f, -6.26071617e-02f, 3.57430265e-03f, -7.68851256e-03f, 1.81953311e-02f, 2.56437846e-02f, -2.76562553e-02f, -1.51234344e-04f, 3.12761404e-02f,
  9.56126209e-03f, -1.03260353e-02f, 7.09061176e-02f, -2.95360461e-02f, -5.09921350e-02f, 3.95591259e-02f, -8.66082031e-03f, 4.06144485e-02f, -1.38350995e-02f, -1.13253452e-01f,
  3.06381080e-02f, -7.00506493e-02f, -3.83022800e-02f, 2.03870032e-02f, 3.50663029e-02f, -6.77511469e-02f, -4.31150422e-02f, -4.77781659e-03f, -9.70586911e-02f, 7.85254762e-02f,
  -6.73406720e-02f, 7.85328448e-02f, 2.49121953e-02f, -2.16078591e-02f, 4.34338413e-02f, 5.56697920e-02f, 5.50971813e-02f, -2.16915887e-02f, -9.27758124e-03f, -2.16022562e-02f,
  2.52989650e-01f, -5.53673089e-01f, 8.00723806e-02f, 2.42487520e-01f, 3.19980711e-01f, 2.06785575e-01f, 3.44579965e-01f, 1.61543898e-02f, 9.18869004e-02f, -3.95146072e-01f,
  -5.83767258e-02f, -1.64919093e-01f, -1.90571874e-01f, -3.12538221e-02f, 2.27513880e-01f, -1.41322747e-01f, -8.44496563e-02f, -1.06988616e-01f, -6.74836636e-02f, 1.89910792e-02f,
  1.77078724e-01f, 9.49291810e-02f, 7.60959536e-02f, -1.61596224e-01f, 2.76998840e-02f, 1.39664514e-02f, -4.14702520e-02f, 3.81988399e-02f, -5.88350594e-02f, 2.03332510e-02f,
  -8.05939585e-02f, 9.96090751e-03f, -9.80324298e-02f, -9.12619680e-02f, -1.72274144e-04f, -4.83693331e-02f, -4.16318513e-02f, 9.81897861e-02f, 1.38128418e-02f, 1.21507896e-02f,
  -1.07190087e-02f, 1.47014474e-02f, 8.81203543e-03f, 3.51472273e-02f, -4.43810737e-03f, 6.76906481e-02f, 4.62131388e-02f, -4.79316674e-02f, 3.98798054e-03f, -1.13756126e-02f,
  1.20649152e-02f, -1.13002062e-01f, -3.57513800e-02f, -6.58209100e-02f, -6.18851446e-02f, -8.26214403e-02f, 3.98027450e-02f, 2.42394637e-02f, -8.27426836e-03f, 3.20920758e-02f,
  -5.24690822e-02f, 5.23798307e-03f, -8.30904841e-02f, 7.13182660e-03f, -3.29334252e-02f, 1.08276337e-01f, -4.90120240e-02f, -7.08889775e-03f, -2.38589803e-03f, -7.01341256e-02f,
  -2.41547339e-02f, -2.73536742e-02f, -7.92346597e-02f, 1.12230489e-02f, -1.79286301e-02f, 7.11248815e-02f, -1.58684608e-02f, 9.15569160e-03f, -5.84178269e-02f, 2.91552320e-02f,
  2.25990582e-02f, 4.63262983e-02f, -4.65733930e-02f, 4.98656332e-02f, -4.79386598e-02f, 9.73542221e-03f, -4.98572458e-03f, -2.66798548e-02f, 6.08694181e-02f, -9.72988200e-04f,
  -3.01184863e-01f, -3.15426201e-01f, -7.27445185e-02f, -3.98012064e-03f, -6.45397678e-02f, -3.10457107e-02f, -7.08744675e-02f, -8.52637962e-02f, 1.32618705e-02f, 6.38171053e-03f,
  -6.51974697e-03f, 1.22911811e-01f, -1.06406910e-02f, 1.53277433e-02f, -4.53513116e-02f, -4.63869609e-02f, -1.38674304e-03f, -1.54670760e-01f, -6.80650175e-02f, -7.40190074e-02f,
  -6.48018047e-02f, 2.50656474e-02f, 6.27621934e-02f, -1.12619055e-02f, -3.65160266e-03f, 1.80536695e-02f, -1.38885276e-02f, -4.47074324e-02f, -2.35111676e-02f, -4.63943183e-02f,
  -5.63001513e-01f, -1.35938704e-01f, 2.47327790e-01f, -2.95863926e-01f, -7.65335411e-02f, 2.89101690e-01f, 3.47665310e-01f, -2.23114863e-01f, -3.53169560e-01f, 4.08073189e-03f,
  9.82862413e-02f, -6.84163943e-02f, 2.94867396e-01f, -4.18480076e-02f, 1.81556508e-01f, 2.42482841e-01f, 4.71366197e-02f, 5.19506261e-02f, -6.20972030e-02f, -1.25430658e-01f,
  -5.66674992e-02f, -1.35479778e-01f, 1.14481859e-01f, -1.00918420e-01f, -1.23635568e-01f, -2.43541837e-01f, -7.24432468e-02f, 2.42807657e-01f, -1.41043246e-01f, -7.43370410e-03f,
  -9.34326500e-02f, -3.20350498e-01f, -3.03741824e-03f, -7.12927803e-02f, -4.69271392e-02f, -1.89494360e-02f, 9.34538245e-02f, 1.10556543e-01f, -5.35909198e-02f, -3.70038301e-02f,
  1.41753932e-03f, 5.35583384e-02f, -1.49171919e-01f, 8.04006755e-02f, -6.76774159e-02f, -6.12574741e-02f, -5.20845503e-03f, -1.47419125e-02f, 5.68289123e-02f, 8.22940692e-02f,
  1.09092571e-01f, 6.68443739e-03f, 6.68811426e-02f, -1.30716898e-02f, 2.55053882e-02f, -4.72758114e-02f, 2.98687592e-02f, 9.02893692e-02f, -5.75738698e-02f, -1.69639662e-02f,
  1.37520079e-02f, 2.22423021e-02f, 1.64720919e-02f, -2.62943991e-02f, -6.51959982e-03f, 3.74740502e-03f, 4.52930070e-02f, 3.45782982e-03f, -1.28015997e-02f, 5.60502298e-02f,
  -1.07768834e-01f, -3.87181342e-02f, -2.21640021e-02f, -2.18452066e-02f, -5.32421842e-03f, -3.46976779e-02f, 1.20551782e-02f, -6.21399283e-02f, 8.69254172e-02f, -4.48760390e-02f,
  1.06559480e-02f, 1.89573911e-03f, 2.42929496e-02f, 1.75698963e-03f, 1.55892931e-02f, 3.58281881e-02f, -2.15670522e-02f, -1.81406699e-02f, -4.82868627e-02f, 6.39123321e-02f,
  -1.41278043e-01f, -3.08223575e-01f, -1.42806489e-02f, -5.65551631e-02f, -4.83035967e-02f, -1.07374173e-02f, -5.38611263e-02f, -6.03772923e-02f, -3.27113681e-02f, -5.80193698e-02f,
  -1.56076392e-02f, -7.15276506e-03f, -6.52131736e-02f, -2.12793555e-02f, 6.67241812e-02f, -4.27148826e-02f, 7.96566624e-03f, -5.50348908e-02f, -5.23956567e-02f, -1.86446626e-02f,
  -5.23713194e-02f, -5.22543155e-02f, 6.21082038e-02f, -7.76604041e-02f, -4.28884029e-02f, 4.61245328e-02f, -6.71065971e-02f, -6.67243674e-02f, 2.50755437e-03f, 4.62274719e-03f,
  -1.17311053e-01f, -2.49445498e-01f, -2.62557626e-01f, -5.47141060e-02f, 7.72087872e-02f, 2.45858897e-02f, -2.78216064e-01f, -2.11397991e-01f, -1.12104826e-01f, -1.76769167e-01f,
  -7.63011128e-02f, 2.14347839e-02f, -3.41829658e-01f, -4.01454270e-02f, 2.97571659e-01f, -1.07813329e-01f, 1.04019344e-02f, -2.03705579e-02f, -3.69734056e-02f, -2.11622179e-01f,
  8.08958933e-02f, 5.54028945e-03f, -3.14156670e-04f, 2.30242591e-02f, -1.35028675e-01f, 4.32193130e-02f, 1.46030828e-01f, -3.14496048e-02f, 2.59957731e-01f, 1.90216184e-01f,
  -2.89821383e-02f, -2.27217138e-01f, -1.70453429e-01f, -6.73510954e-02f, -1.05989181e-01f, 4.51835841e-02f, 7.10789040e-02f, 3.68323587e-02f, -3.50292698e-02f, -5.78718409e-02f,
  2.40768306e-03f, 9.34759676e-02f, 7.42873177e-02f, -6.74429210e-03f, -5.56020737e-02f, 3.42718959e-02f, -1.56400818e-02f, -5.28293401e-02f, -6.36492968e-02f, 1.05590187e-02f,
  -4.26804014e-02f, 3.30663808e-02f, 1.91763937e-02f, -1.18476967e-03f, -5.11473753e-02f, -4.23290767e-03f, 8.49063415e-03f, 7.26229278e-03f, -1.41974483e-02f, 6.15031868e-02f,
  6.50423951e-03f, -2.35695462e-03f, -6.17021881e-02f, 3.77704501e-02f, -5.29399067e-02f, 3.46881337e-02f, 2.76310686e-02f, 8.90232176e-02f, 6.12849649e-03f, -3.77442911e-02f,
  -3.66371162e-02f, -3.40938382e-02f, -5.24199419e-02f, -8.32430795e-02f, -2.47214834e-04f, -1.72068011e-02f, 4.01750654e-02f, 2.07906254e-02f, -5.69235533e-02f, 2.53353529e-02f,
  -2.91764718e-02f, -5.31994775e-02f, 1.01670129e-02f, 1.45759815e-02f, -6.05521724e-02f, 6.19346835e-03f, -5.89340506e-03f, -5.66456988e-02f, 2.33703293e-03f, 5.84958978e-02f,
  -2.41914764e-01f, -1.61290988e-01f, 3.76619250e-02f, -5.24753593e-02f, -4.48949225e-02f, -1.53624685e-02f, -1.11471871e-02f, 4.00578715e-02f, -8.16983730e-02f, -6.53387308e-02f,
  1.16942171e-02f, -2.98270378e-02f, 8.16568732e-03f, -2.54391488e-02f, 8.34769458e-02f, -5.83979152e-02f, -2.76359497e-04f, -5.24650402e-02f, 8.44266207e-04f, 1.65470261e-02f,
  -1.19620167e-01f, -2.68134922e-02f, 6.59066513e-02f, 1.07181398e-02f, 9.12067220e-02f, -5.40296407e-03f, 8.25763568e-02f, 3.02146003e-02f, 1.09485187e-01f, -1.30533399e-02f,
  3.75458002e-01f, -1.18053012e-01f, -1.69410661e-01f, 1.34053603e-01f, 2.21269384e-01f, 3.12742412e-01f, 3.55720788e-01f, 1.66396186e-01f, 2.35269278e-01f, 2.03392711e-02f,
  1.01574063e-01f, -5.31098060e-02f, -1.41568273e-01f, 1.67519048e-01f, 2.38611519e-01f, -2.42094975e-02f, 2.13247135e-01f, 1.27319679e-01f, 1.06806375e-01f, -1.19922962e-02f,
  1.04259916e-01f, 1.64146930e-01f, -1.13981605e-01f, -1.09394774e-01f, 1.03563324e-01f, -8.37232694e-02f, -1.13027140e-01f, -7.85111114e-02f, -1.27706034e-02f, -4.90568625e-03f,
  3.17439958e-02f, -1.65354256e-02f, -1.28943011e-01f, -1.61116458e-02f, 5.70333637e-02f, -4.55833040e-02f, -4.03811671e-02f, 5.17673641e-02f, 3.95576730e-02f, 2.41861884e-02f,
  7.34854257e-03f, -8.63731094e-03f, 6.51232675e-02f, -5.65509163e-02f, 4.12070788e-02f, -5.71110807e-02f, -3.44940722e-02f, 2.26423163e-02f, -3.37038301e-02f, -7.26417229e-02f,
  6.32232148e-03f, -1.74205638e-02f, 1.76341645e-02f, -5.06825820e-02f, -6.25733659e-02f, 3.41861509e-02f, -6.15547746e-02f, -4.16969545e-02f, -3.92015204e-02f, 9.33222249e-02f,
  4.65497747e-03f, -4.10736017e-02f, 6.99217394e-02f, -1.22634266e-02f, 1.97094749e-03f, -3.97821441e-02f, 8.43067828e-05f, 2.10902505e-02f, -3.82004641e-02f, 2.59314151e-03f,
  -6.99218363e-02f, 3.48681025e-02f, -7.60591123e-03f, -4.09685336e-02f, 8.26444551e-02f, 6.15557469e-02f, 2.60692257e-02f, -1.81043390e-02f, 5.80582023e-02f, -3.28784226e-03f,
  3.71683538e-02f, -2.75646001e-02f, -7.53368139e-02f, 3.09956521e-02f, -5.17056100e-02f, 2.64141485e-02f, -2.74730679e-02f, 2.03867909e-02f, -6.42792210e-02f, -2.95102615e-02f,
  1.73271671e-02f, 4.38476615e-02f, 2.15735938e-03f, 1.45900734e-02f, -1.15778983e-01f, 1.49059354e-03f, 1.03968203e-01f, 1.06327251e-01f, -1.39265908e-02f, 7.69191608e-02f,
  1.54009899e-02f, -1.61366630e-02f, 1.19721312e-02f, -3.38345617e-02f, -3.05710789e-02f, 5.43620475e-02f, -1.94824915e-02f, 3.46072130e-02f, 5.38350567e-02f, 1.21676764e-02f,
  -7.74563551e-02f, -1.91745684e-02f, 1.47747155e-02f, 1.22977076e-02f, 7.30791390e-02f, -1.14776321e-01f, 4.49823216e-02f, -6.41966090e-02f, -2.15274491e-03f, -5.48636094e-02f,
  4.08003718e-01f, -2.09955484e-01f, -2.72562712e-01f, -2.24447176e-01f, -9.87895504e-02f, 1.40451146e-02f, -1.55732214e-01f, -9.43232998e-02f, 3.39835286e-02f, 3.00643668e-02f,
  2.50669047e-02f, 3.15223336e-02f, 1.35969654e-01f, -1.25968456e-01f, 2.44304359e-01f, 1.77772909e-01f, -6.07671514e-02f, 6.92539476e-03f, 3.72371860e-02f, -4.63970453e-02f,
  2.44737044e-03f, -4.77526598e-02f, -1.24857619e-01f, -1.63321167e-01f, -5.49832769e-02f, -1.61461234e-01f, -2.42770258e-02f, -4.78059426e-02f, -1.35947272e-01f, -3.74797396e-02f,
  -3.84684131e-02f, 8.00348446e-02f, -1.07985571e-01f, -4.90150079e-02f, -8.72263238e-02f, 1.02569342e-01f, 3.47383916e-02f, -6.54971898e-02f, 1.11114057e-02f, -2.51682904e-02f,
  3.62194586e-03f, 2.27268897e-02f, 4.54006679e-02f, 8.21832195e-02f, -3.77422497e-02f, -9.02659446e-02f, -5.00895046e-02f, -6.41006827e-02f, -5.66874184e-02f, -3.97853255e-02f,
  6.83262246e-03f, -6.65601343e-02f, -1.32136112e-02f, -2.00124998e-02f, -1.14201427e-01f, -8.35345536e-02f, -8.70820414e-03f, -8.71286839e-02f, -4.32238206e-02f, -6.56695440e-02f,
  1.55020177e-01f, 4.55604307e-02f, 1.68366563e-02f, -4.15395498e-02f, -5.78275472e-02f, -9.04871970e-02f, -4.89956252e-02f, -5.89273088e-02f, -5.75789288e-02f, 4.84796502e-02f,
  -1.11336239e-01f, -1.95756070e-02f, -3.76708992e-02f, 6.73461631e-02f, 5.30536734e-02f, -8.82426463e-03f, -8.57289657e-02f, -3.10805384e-02f, -4.88325730e-02f, 2.45623402e-02f,
  -1.05249425e-02f, 1.00095771e-01f, -1.27247557e-01f, 5.68663701e-02f, -5.23841456e-02f, 7.22767115e-02f, 7.03886570e-03f, 3.32190022e-02f, 1.34847937e-02f, 7.36808591e-03f,
  8.66455492e-04f, 3.90818119e-02f, -1.03651337e-01f, -5.14716469e-02f, -5.78366220e-02f, -2.47045178e-02f, -1.28408633e-02f, 9.21043232e-02f, -6.12761378e-02f, -2.09304807e-03f,
  -5.45462407e-02f, 8.61809626e-02f, 9.81968548e-03f, 6.45214505e-03f, 3.34942862e-02f, 2.02717613e-02f, 5.17749377e-02f, -6.82463199e-02f, 4.96421158e-02f, -6.21283837e-02f,
  -6.62563136e-03f, -1.98799279e-03f, 3.15850489e-02f, -8.07849169e-02f, -4.20374721e-02f, 5.25334515e-02f, 8.13360140e-02f, -4.59332913e-02f, -1.87023617e-02f, 3.27441208e-02f,
  -1.32689565e-01f, -1.43268332e-01f, -4.99235913e-02f, 2.41491616e-01f, 5.90039454e-02f, -1.77684456e-01f, -4.01877463e-01f, 1.92314431e-01f, -2.38592416e-01f, -1.44812301e-01f,
  6.94645196e-02f, -2.97687985e-02f, -3.65581781e-01f, 2.77381331e-01f, 2.99736500e-01f, -2.64708936e-01f, 2.85151303e-01f, 9.84293222e-02f, 6.17643036e-02f, 9.32449400e-02f,
  2.83517092e-01f, 4.11945164e-01f, 3.51501137e-01f, 3.67068142e-01f, 1.19427525e-01f, 2.43350446e-01f, 3.79657209e-01f, 6.48203939e-02f, 4.74024117e-01f, 1.66614354e-01f,
  2.46257745e-02f, -5.67233711e-02f, -1.48950508e-02f, -4.23083827e-02f, -1.04388937e-01f, -6.82019815e-02f, -6.19762950e-02f, 4.27183993e-02f, 7.06367791e-02f, 4.29632142e-02f,
  -8.33385214e-02f, 5.56920953e-02f, 1.45395517e-01f, 5.00544310e-02f, -6.06856756e-02f, 1.13091998e-01f, -1.42692318e-02f, -4.43944708e-02f, -9.48056877e-02f, -2.94945147e-02f,
  -4.81179319e-02f, -3.81470919e-02f, -7.52715440e-03f, -7.94416014e-03f, -7.40143061e-02f, -2.12772768e-02f, -2.01813783e-02f, -5.80030605e-02f, 2.86914874e-02f, -8.04767851e-03f,
  -9.08606425e-02f, 1.06886039e-02f, -2.72582471e-02f, -5.70112206e-02f, -6.78172186e-02f, -1.78072285e-02f, 5.21311723e-02f, -3.08468025e-02f, -2.99127642e-02f, -2.99810898e-02f,
  6.01450633e-03f, 8.59926865e-02f, 8.92549977e-02f, -3.53116356e-02f, 9.77255180e-02f, -8.21359176e-03f, 2.08380353e-02f, 3.46934609e-02f, -4.31729518e-02f, 4.82091010e-02f,
  2.89020818e-02f, 1.07457742e-01f, -5.98711520e-03f, -2.90821549e-02f, 7.32886419e-03f, -3.45266983e-02f, -4.62092832e-03f, -2.46136896e-02f, -1.87825747e-02f, 3.15809622e-02f,
  2.27637123e-02f, 1.39337599e-01f, -1.59193762e-02f, 5.94741963e-02f, -2.50070021e-02f, 2.88842730e-02f, 1.15216132e-02f, 5.58285154e-02f, 5.32489754e-02f, 4.11428399e-02f,
  6.14474602e-02f, 1.01162963e-01f, -2.97129992e-02f, 6.85647428e-02f, 1.22579418e-01f, 2.97365598e-02f, 2.57685464e-02f, 7.95094222e-02f, 3.50112468e-02f, 7.05257505e-02f,
  3.86935286e-02f, -9.74775013e-03f, 6.64563179e-02f, -1.10918835e-01f, -1.44221308e-02f, -5.51538691e-02f, -2.73238700e-02f, 1.47862639e-02f, 4.89255115e-02f, -3.01144924e-02f,
  -2.07229868e-01f, 1.35354578e-01f, -1.89348869e-02f, 4.60276566e-02f, -2.22736761e-01f, -2.70131111e-01f, -1.36557713e-01f, -1.43280596e-01f, 6.22204617e-02f, 1.09192118e-01f,
  1.53340414e-01f, 9.90375057e-02f, 1.27561614e-01f, 1.61932945e-01f, -2.36650765e-01f, 8.04945156e-02f, -6.43409044e-02f, 7.08631380e-03f, -1.07893668e-01f, 6.46728557e-03f,
  -7.62996525e-02f, 2.73017865e-02f, 1.47799909e-01f, 2.97683533e-02f, 1.03767579e-02f, 1.41238615e-01f, -9.06823203e-02f, 5.21107465e-02f, -6.37131482e-02f, -1.69999637e-02f,
  -1.66964978e-01f, 8.91269594e-02f, 2.37510335e-02f, 1.15724299e-02f, -1.55419707e-01f, -5.61767705e-02f, -6.01515211e-02f, -8.03411156e-02f, -6.23616837e-02f, -5.20655923e-02f,
  -1.95877366e-02f, -1.29394410e-02f, -5.01414500e-02f, 1.00388862e-01f, -3.02625466e-02f, -3.36662419e-02f, 5.07990830e-02f, -8.74864012e-02f, 5.95045043e-03f, 5.08950353e-02f,
  5.14822900e-02f, 2.07331963e-03f, 5.19956723e-02f, 8.26113820e-02f, -2.43845843e-02f, -3.07912938e-02f, -6.84967190e-02f, -2.56709121e-02f, -8.53043273e-02f, 1.57798908e-03f,
  -5.72173707e-02f, -4.34904359e-02f, 5.35851419e-02f, -2.29392033e-02f, -3.18744183e-02f, 6.50141984e-02f, 5.33789396e-02f, -5.84192201e-02f, -1.67502500e-02f, -5.01863956e-02f,
  9.05140396e-03f, 1.74941830e-02f, -6.57744259e-02f, 2.07106546e-02f, -2.52409875e-02f, -2.34582722e-02f, 7.88626745e-02f, -1.40919723e-02f, -2.39680475e-03f, 4.28136811e-02f,
  4.05633040e-02f, -1.68162640e-02f, 3.07404026e-02f, 3.70255075e-02f, -7.10886344e-02f, 5.71733601e-02f, 5.93488403e-02f, 1.90117713e-02f, 6.95945248e-02f, 1.81232754e-03f,
  -1.44844383e-01f, -1.56333402e-01f, 5.59192859e-02f, -8.85287747e-02f, 1.14554726e-02f, -9.54662114e-02f, -1.34664364e-02f, -1.10593699e-01f, -6.69677109e-02f, -9.01628509e-02f,
  -3.13696526e-02f, 3.63190137e-02f, -2.98880413e-02f, -4.69103493e-02f, 5.64660393e-02f, -5.03529347e-02f, -1.51373073e-02f, 5.01807705e-02f, -8.11563991e-03f, -6.42532185e-02f,
  4.47669402e-02f, -3.70893516e-02f, -2.15297993e-02f, -4.34296392e-02f, 6.51406636e-03f, -7.73489699e-02f, 4.10751440e-02f, 4.74969521e-02f, 2.57980227e-02f, 4.54679094e-02f,
  2.57287562e-01f, -8.93428922e-03f, -1.40365988e-01f, 9.12036970e-02f, 1.03311487e-01f, -1.75930619e-01f, -2.24714324e-01f, 1.44395694e-01f, -2.07108840e-01f, 3.88723761e-02f,
  2.46344149e-01f, -2.19999015e-01f, -7.23740086e-02f, -5.69486059e-02f, -6.57707229e-02f, -2.44951919e-01f, 1.40576303e-01f, -9.21779871e-02f, -7.07252994e-02f, 2.35487550e-01f,
  1.03704177e-01f, 1.88647032e-01f, -1.36141013e-02f, 2.26149142e-01f, 6.35893345e-02f, 2.90053070e-01f, 3.69452983e-01f, 1.90389715e-02f, 1.81040168e-01f, -5.32983802e-02f,
  -2.24321738e-01f, -1.74756013e-02f, -2.57668085e-02f, -6.18183129e-02f, 1.52686656e-01f, 1.28373876e-01f, 4.15312983e-02f, -1.30891174e-01f, -5.57412580e-02f, -2.48336903e-04f,
  -1.75935887e-02f, -2.77356654e-02f, -1.12979308e-01f, -8.66196677e-02f, 9.03039647e-04f, -8.92482474e-02f, -2.86139846e-02f, -5.48847280e-02f, -5.48699610e-02f, -1.57713704e-02f,
  -4.54270579e-02f, 4.50199358e-02f, 5.58922440e-02f, -9.22736153e-02f, 5.01807556e-02f, 1.92365870e-02f, -7.02803731e-02f, -1.27034392e-02f, 1.13099523e-01f, -1.49575798e-02f,
  1.82005867e-01f, 3.60640325e-02f, 1.26302312e-03f, -4.76718359e-02f, 9.22085717e-03f, 4.78822999e-02f, 5.63694648e-02f, -2.37470344e-02f, -6.45124470e-04f, 3.24563459e-02f,
  -2.83073615e-02f, 3.47690955e-02f, -5.68876043e-02f, 4.88703661e-02f, -3.44274268e-02f, 7.61259440e-03f, -4.88447584e-02f, 2.68623903e-02f, -2.39054207e-02f, -9.33619589e-03f,
  -3.52216624e-02f, 5.35820890e-03f, -1.11435063e-03f, 7.51317963e-02f, -8.60599428e-03f, -1.14213768e-02f, 1.15516514e-01f, -3.66009772e-02f, -6.48905756e-03f, -3.30595709e-02f,
  1.11314476e-01f, 4.49349374e-01f, -1.09651439e-01f, -9.97380018e-02f, -3.65302935e-02f, 1.44642526e-02f, -4.75468114e-02f, 3.91425341e-02f, 5.43426862e-03f, 2.80881929e-03f,
  9.78555679e-02f, 6.26097387e-03f, 9.33718830e-02f, -6.30080998e-02f, 3.87431271e-02f, -2.69489493e-02f, 1.08427525e-01f, -2.22229250e-02f, 1.21205568e-01f, 8.02991837e-02f,
  1.69640809e-01f, -2.61493158e-02f, 2.02361168e-03f, 5.14000654e-02f, 6.93550929e-02f, 3.59226353e-02f, 7.93606639e-02f, -7.59618776e-03f, 4.64875400e-02f, 5.59798665e-02f,
  -2.91326821e-01f, 1.50561109e-01f, 2.09401667e-01f, -3.24553102e-01f, 2.53490750e-02f, 1.07535616e-01f, -5.09074591e-02f, 9.31678563e-02f, -3.39626148e-03f, 8.71904716e-02f,
  -1.37134848e-04f, -5.95004410e-02f, 1.27548695e-01f, -6.93878904e-02f, 1.03558898e-01f, 2.03875765e-01f, 1.58840101e-02f, -1.42668977e-01f, 7.91853741e-02f, -2.64879968e-02f,
  -1.06507935e-01f, -1.78217709e-01f, 1.16943061e-01f, 7.94695318e-02f, -8.19152445e-02f, -1.13534667e-01f, -2.00615183e-01f, 6.03679977e-02f, -7.91499764e-02f, -1.70798171e-02f,
  -1.00823157e-01f, -1.04149356e-01f, -1.27453059e-01f, 6.21040314e-02f, -6.10268749e-02f, 3.64014064e-03f, -4.41537686e-02f, -9.33474377e-02f, -4.50632833e-02f, 4.60214093e-02f,
  2.02131476e-02f, 6.91661891e-03f, -4.98388112e-02f, -7.32300729e-02f, -8.00760090e-02f, 2.55701263e-02f, 4.38699573e-02f, 1.16718849e-02f, -5.44430874e-02f, 7.07487017e-02f,
  7.79876187e-02f, 1.39547221e-03f, -3.01862173e-02f, -5.78115061e-02f, -3.09409723e-02f, -6.89079836e-02f, -5.44862002e-02f, 2.11480483e-02f, 8.99780076e-03f, 2.66928989e-02f,
  9.47586745e-02f, 3.44890868e-03f, 8.27236250e-02f, -1.03577124e-02f, 7.48288855e-02f, -7.88199753e-02f, -1.88434813e-02f, 2.83049550e-02f, 3.41760628e-02f, 2.40958389e-03f,
  -8.54869082e-04f, -2.27248929e-02f, 2.25659013e-02f, -8.01430736e-03f, -3.32782604e-02f, 2.56472249e-02f, 8.81926995e-03f, 8.12698156e-03f, -2.75515299e-02f, 2.46518422e-02f,
  -4.85753603e-02f, -1.24076409e-02f, 5.68705350e-02f, 2.92218830e-02f, 9.55701619e-03f, 6.23960420e-02f, 4.97354288e-03f, 6.76413476e-02f, -3.94556066e-03f, -1.53365172e-02f,
  -1.49803862e-01f, -2.29303375e-01f, -1.42892808e-01f, -1.50031909e-01f, 3.25831585e-02f, -3.24995928e-02f, -3.44057232e-02f, -2.75038034e-02f, 1.60212368e-02f, -1.44567695e-02f,
  -2.78919097e-02f, -3.98985110e-02f, 9.44989733e-03f, -7.08563253e-02f, 1.62498653e-02f, -1.68440249e-02f, -2.17262674e-02f, -1.01539142e-01f, -2.10679658e-02f, 1.28606185e-02f,
  1.06843247e-04f, -1.56501010e-02f, -7.76794180e-02f, -5.39744124e-02f, -4.82659303e-02f, -3.93497273e-02f, -6.86304690e-03f, 2.63750181e-02f, -1.76953152e-02f, -2.31611114e-02f,
  -7.94724301e-02f, -5.26698790e-02f, 9.81630385e-02f, 7.25398511e-02f, -1.39981568e-01f, -1.60035476e-01f, -1.33612782e-01f, -8.53094161e-02f, -8.03407282e-02f, -9.27973613e-02f,
  -9.32852402e-02f, -8.44987202e-03f, 1.49980024e-01f, -3.55593152e-02f, 8.74174759e-02f, 1.35950660e-02f, -1.12780474e-01f, 4.75768112e-02f, 1.07138954e-01f, 5.04722372e-02f,
  4.71142679e-02f, 1.61863994e-02f, 9.59980562e-02f, 9.49209370e-03f, -9.28862914e-02f, 6.00045435e-02f, 1.05509251e-01f, 1.20588392e-02f, 6.51750490e-02f, 7.44680017e-02f,
  -3.09023838e-02f, -1.63097307e-02f, 8.61811265e-03f, 1.25844497e-02f, 7.04356432e-02f, -8.97144601e-02f, 4.65875491e-02f, 3.20549123e-02f, -2.46274658e-02f, 1.02240376e-01f,
  2.04066858e-02f, 1.15774367e-02f, 3.36488672e-02f, 9.18166190e-02f, 3.60125192e-02f, 4.30002362e-02f, 4.33550328e-02f, 6.12657927e-02f, 6.55305162e-02f, -6.30074739e-02f,
  -3.78796272e-02f, 2.47145444e-02f, 6.04931079e-02f, 4.61532809e-02f, -2.02806909e-02f, -6.12004027e-02f, -6.58795191e-03f, 3.52847576e-02f, 8.23870748e-02f, -5.29725365e-02f,
  1.41084446e-02f, -1.38509786e-02f, -7.63370981e-03f, 5.59039712e-02f, 5.82544021e-02f, 9.36088990e-03f, -7.55579919e-02f, -8.91726762e-02f, 1.72838569e-02f, 5.27338944e-02f,
  -8.63985196e-02f, 6.92371577e-02f, -2.44124457e-02f, -8.66742879e-02f, -3.90745252e-02f, 6.65417239e-02f, -3.45320441e-02f, -4.68293652e-02f, -3.43474820e-02f, -6.75458685e-02f,
  -6.19149283e-02f, 7.69099295e-02f, -3.05613633e-02f, -3.77409123e-02f, 2.96698231e-02f, 1.51241720e-02f, -3.02785281e-02f, 6.97806254e-02f, -6.37954772e-02f, 2.03085952e-02f,
  -8.52684900e-02f, 1.33727968e-01f, -2.09033936e-02f, -5.09823114e-02f, 4.89709154e-02f, 3.95526402e-02f, -1.37922363e-02f, -4.42926679e-03f, 3.40048335e-02f, -2.83350609e-02f,
  9.23777148e-02f, 4.05401587e-02f, -2.99364496e-02f, 7.78538734e-02f, 4.14948277e-02f, -9.46628898e-02f, 9.27496329e-02f, 9.14225131e-02f, 2.27445643e-02f, -3.08518950e-02f,
  8.98383707e-02f, 3.93007174e-02f, -5.82574941e-02f, 1.53026488e-02f, -9.99780819e-02f, -6.41745999e-02f, 4.68591526e-02f, 1.14473999e-02f, -4.23306860e-02f, 5.96723966e-02f,
  1.22686513e-01f, -2.12985709e-01f, -1.69525281e-01f, -6.62125945e-02f, -1.96567411e-03f, -1.77499592e-01f, -2.71437466e-01f, -1.65683389e-01f, 9.10944194e-02f, -8.36937875e-02f,
  -8.80409181e-02f, 1.70166399e-02f, 1.15394704e-01f, -1.88105091e-01f, 2.43367091e-01f, 2.70881146e-01f, -2.34237164e-01f, -1.13809735e-01f, -2.21285429e-02f, -1.62237599e-01f,
  -2.53403354e-02f, -2.15995640e-01f, -8.49645287e-02f, -2.56833136e-01f, -3.65116060e-01f, -1.24234319e-01f, 7.44519830e-02f, -1.79587096e-01f, -1.37684047e-01f, 6.31664321e-02f,
  -1.23770379e-01f, -4.10290137e-02f, -4.98651974e-02f, 2.46165767e-02f, -4.22207778e-03f, -1.24567531e-01f, -5.13826646e-02f, -3.43520939e-02f, 7.87144750e-02f, -2.12894101e-02f,
  1.49576562e-02f, 3.10288016e-02f, -9.74143818e-02f, 8.39049742e-02f, -1.02118924e-01f, 3.91620323e-02f, -4.73399311e-02f, -7.59504810e-02f, -1.81876551e-02f, -2.08586454e-02f,
  -4.59923111e-02f, 3.80988023e-03f, -2.14521843e-03f, 9.76648107e-02f, -3.40577625e-02f, -8.99522305e-02f, 5.87198399e-02f, 1.39349490e-01f, -4.17735539e-02f, -5.09180576e-02f,
  -8.01849440e-02f, -2.96389330e-02f, 1.41667398e-02f, -8.12448263e-02f, 1.47581780e-02f, 2.92858873e-02f, 6.29754812e-02f, -6.87196013e-03f, 4.02554944e-02f, 3.05016991e-02f,
  4.16028723e-02f, -2.67452933e-02f, 5.37887439e-02f, -9.16054845e-03f, -6.45647338e-03f, 1.21820187e-02f, 3.77815403e-02f, 2.89705303e-02f, -9.58607048e-02f, 1.08576994e-02f,
  -4.07911241e-02f, -4.05922160e-02f, -4.80917804e-02f, -8.86803046e-02f, -4.28121723e-02f, -2.79574133e-02f, -1.82927735e-02f, 2.53785308e-02f, 1.30663579e-02f, -2.65312158e-02f,
  2.00619251e-02f, -6.79878891e-02f, -2.26403922e-02f, 4.36952822e-02f, -3.07642277e-02f, -1.13705076e-01f, -4.23052683e-02f, -4.48287791e-03f, -3.30607709e-03f, -1.83183420e-02f,
  -3.01789623e-02f, 5.06948605e-02f, -7.89636448e-02f, 7.79949725e-02f, -2.35174363e-03f, -8.47744942e-02f, 4.10809070e-02f, 2.61882991e-02f, -5.30823544e-02f, -7.87876430e-04f,
  -5.48486970e-03f, 6.21236078e-02f, -1.36090182e-02f, 6.72716424e-02f, 7.30246231e-02f, -2.86817160e-02f, -7.37630203e-03f, -3.48306857e-02f, 7.51060769e-02f, 7.46498406e-02f,
  1.18138753e-01f, -1.04815885e-01f, 1.27606735e-01f, 4.12047654e-02f, 1.25041083e-01f, 1.31670609e-01f, 1.33540601e-01f, 7.21996650e-02f, 3.12404130e-02f, -1.96700230e-01f,
  -4.72645685e-02f, 1.22187935e-01f, 1.10739224e-01f, -1.11850850e-01f, 1.28904119e-01f, 6.31763265e-02f, -2.20577400e-02f, 2.35367734e-02f, 8.55960976e-03f, -1.48206456e-02f,
  -4.34250459e-02f, -1.82589591e-01f, -3.38154584e-02f, -2.35348746e-01f, -6.09082170e-02f, 9.50624514e-03f, -8.68202448e-02f, 1.27637237e-02f, -1.15995660e-01f, 5.82816303e-02f,
  6.02313094e-02f, 4.45428267e-02f, -1.01006225e-01f, 7.50748161e-03f, -6.23260029e-02f, -2.16821842e-02f, -2.25392878e-02f, -7.08725601e-02f, -6.02762727e-03f, -2.36084685e-02f,
  -5.03259860e-02f, -4.15858142e-02f, 5.15702590e-02f, -1.25428513e-02f, -2.64664795e-02f, 6.63436130e-02f, 3.39178517e-02f, -1.71019193e-02f, 5.81853092e-02f, 3.65337655e-02f,
  7.68637657e-02f, -3.59146819e-02f, 2.08307765e-02f, -6.28668591e-02f, -7.14100748e-02f, 2.20473744e-02f, 3.76978517e-02f, -1.64865199e-02f, 4.02777828e-02f, 4.63238992e-02f,
  -1.54168248e-01f, -5.64666279e-02f, 4.34015468e-02f, -5.06845601e-02f, 8.03054869e-02f, 5.70709445e-02f, 5.93035854e-02f, -7.39112198e-02f, 6.26134640e-03f, -2.41516829e-02f,
  5.04246093e-02f, 2.39734333e-02f, -5.89827895e-02f, -5.71697205e-02f, -2.39625629e-02f, -5.21669164e-03f, -6.57510161e-02f, 5.68072719e-04f, -2.97186058e-02f, 5.38045764e-02f,
  2.09169872e-02f, 3.74173857e-02f, -1.31521728e-02f, 4.59525222e-03f, 3.85569707e-02f, -1.88692398e-02f, -5.97667284e-02f, 2.25654691e-02f, 9.13041830e-03f, 5.54214902e-02f,
  -7.51087442e-02f, -1.05923727e-01f, 2.26369724e-02f, 1.05286343e-03f, -8.33011717e-02f, 1.05630541e-02f, 1.55194113e-02f, 7.52617270e-02f, 9.67892259e-03f, -7.12578297e-02f,
  -2.60910485e-04f, 7.20362663e-02f, -2.47962829e-02f, 4.37966995e-02f, -3.60199879e-03f, 4.84798886e-02f, 4.78783250e-02f, 7.55446628e-02f, -1.07496545e-01f, -8.75407550e-03f,
  -4.31055911e-02f, -2.63907369e-02f, 4.58616912e-02f, -5.28311320e-02f, 2.99335942e-02f, -1.93678495e-02f, -3.22667658e-02f, 1.54530408e-03f, -4.41824496e-02f, 3.04813199e-02f,
  4.21823770e-01f, 3.46499413e-01f, 2.14495450e-01f, 3.88956666e-01f, -1.91380307e-01f, -1.27634853e-02f, 7.97277912e-02f, 1.78817268e-02f, 4.34526384e-01f, 7.06331283e-02f,
  -1.68854490e-01f, 5.29742539e-01f, -1.98640078e-01f, 7.68965781e-02f, -1.63395017e-01f, -8.85616541e-02f, 1.03190824e-01f, 1.22605503e-01f, 1.43053263e-01f, 1.77855045e-01f,
  -3.22010219e-02f, -2.49899641e-01f, -5.43583371e-02f, -7.63898492e-02f, 5.03921136e-03f, 1.18452996e-01f, -2.78068155e-01f, -1.29031017e-01f, -5.43532744e-02f, -1.43602148e-01f,
  -5.74925095e-02f, 2.33999386e-01f, 1.71801168e-02f, 3.63620371e-02f, -7.63916373e-02f, -6.43189326e-02f, -7.43998289e-02f, -5.88961057e-02f, -1.33372694e-02f, 7.60717988e-02f,
  1.13045268e-01f, 2.12976858e-02f, 1.27560208e-02f, -9.09488797e-02f, 5.64809218e-02f, 8.24523717e-02f, 4.52591740e-02f, -5.12539037e-03f, 6.71031624e-02f, 5.65598644e-02f,
  1.13476329e-01f, 4.52749617e-02f, 4.28199070e-03f, 6.77737454e-03f, 2.36370810e-03f, 4.64684404e-02f, -4.35773544e-02f, 3.22369151e-02f, 8.63110926e-03f, 4.88386601e-02f,
  -1.04079414e-02f, -5.46903461e-02f, -7.95748681e-02f, 1.00630820e-02f, -9.05053988e-02f, 9.55844857e-03f, 1.31395645e-02f, -3.41520533e-02f, 3.92364673e-02f, -2.28744820e-02f,
  -5.29804565e-02f, 2.37680990e-02f, -3.46858390e-02f, -3.74610424e-02f, 7.71941543e-02f, 6.46727011e-02f, -2.41649281e-02f, 1.36001557e-02f, 6.64610565e-02f, 4.05521691e-02f,
  -1.28907664e-02f, -4.77549955e-02f, 5.76177500e-02f, -2.01639831e-02f, 1.48171149e-02f, -5.81569858e-02f, 3.06651443e-02f, -9.14453529e-03f, -7.86064193e-03f, -4.62460667e-02f,
  -4.49747704e-02f, 1.83866888e-01f, 2.58709546e-02f, 4.24964055e-02f, 7.21687078e-02f, 3.37388627e-02f, 4.02488559e-02f, 3.08862031e-02f, 1.14885680e-01f, 2.23098956e-02f,
  -4.41905111e-02f, 4.98982556e-02f, -3.17886891e-03f, -4.12238315e-02f, -7.62784183e-02f, 1.04081084e-03f, -1.24677317e-02f, -6.82226429e-03f, 2.07834393e-02f, -1.50032928e-02f,
  2.32332349e-02f, -4.96271886e-02f, 5.64262457e-02f, -4.06704023e-02f, 2.37029009e-02f, -3.53697874e-02f, 9.09089223e-02f, 2.95195021e-02f, -6.01879172e-02f, 8.15490782e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.07937145e-01f, 1.78313598e-01f, -1.07621178e-02f, 1.13978200e-01f, 1.64788887e-01f, 1.65506244e-01f, 2.41674319e-01f, 2.28687495e-01f, 3.39533120e-01f, 1.63877785e-01f,
  2.96247900e-01f, 1.41078442e-01f, 2.20371991e-01f, 1.92738175e-01f, 3.20813715e-01f, 1.43066183e-01f, -4.73792255e-02f, 8.60331431e-02f, 2.07139850e-01f, 3.40036094e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.64918089e-01f, 7.67232105e-02f, 9.67986062e-02f, 3.80115211e-02f, -9.49528441e-02f, 8.01361129e-02f, -2.30686963e-01f, -1.95635885e-01f, 2.45181292e-01f, 3.63938540e-01f,
  2.79891253e-01f, -1.95761815e-01f, -3.77879441e-01f, 2.72524431e-02f, -4.50845435e-02f, -7.02632591e-03f, 1.02982335e-01f, 3.79170254e-02f, -2.90275425e-01f, 3.52659732e-01f,
  2.37888202e-01f, -6.19725809e-02f, 2.61855394e-01f, -2.73130531e-03f, -1.03282733e-02f, -2.73161829e-01f, -8.18190575e-02f, -4.72492650e-02f, -2.11857721e-01f, 3.10983788e-02f,
  -4.82138023e-02f, -1.00830361e-01f, -8.23567733e-02f, -2.23936304e-01f, -4.90735937e-03f, -2.56459504e-01f, -3.34199488e-01f, 3.07845529e-02f, -4.68875706e-01f, -2.15964913e-02f,
  -4.35548902e-01f, 7.14329183e-02f, 1.19984813e-01f, 3.17795247e-01f, -1.28511220e-01f, -3.21105719e-01f, 2.42278841e-03f, 1.06295370e-01f, 2.19413489e-02f, -2.47607425e-01f,
  -1.63803250e-01f, -2.24145055e-02f, 3.80811721e-01f, 1.25598133e-01f, -1.39430001e-01f, -1.91109329e-01f, 4.39591169e-01f, 1.45100877e-01f, -3.47581506e-02f, -1.67368785e-01f,
  2.04454973e-01f, -9.39138830e-02f, -1.82114676e-01f, -3.66863996e-01f, 1.36526361e-01f, -1.57566145e-01f, 1.31700888e-01f, 4.79444582e-03f, -9.25481319e-02f, -1.11068353e-01f,
  -4.35613275e-01f, -3.83344889e-01f, 3.85044739e-02f, -2.63872325e-01f, 4.75030214e-01f, -2.92752564e-01f, -1.72518492e-01f, 1.46300718e-01f, -1.59384564e-01f, 2.14100912e-01f,
  5.11641167e-02f, -2.77409852e-01f, -2.54571050e-01f, 1.28243551e-01f, -3.42536643e-02f, -1.55906647e-01f, 1.91093534e-01f, 8.77722874e-02f, 1.14711277e-01f, -1.93496212e-01f,
  1.21102288e-01f, -6.03646189e-02f, -5.41946404e-02f, -8.83992761e-02f, 1.21704392e-01f, -7.78538734e-02f, 1.89516768e-01f, -3.05234015e-01f, 3.74411754e-02f, 4.28290740e-02f,
  -1.11689769e-01f, -7.16579854e-02f, -3.16393748e-02f, -3.85682940e-01f, 6.68663681e-02f, -2.11638033e-01f, 4.07791734e-01f, -2.39887193e-01f, -4.57685590e-02f, 6.96553513e-02f,
  1.93351150e-01f, 6.69749901e-02f, -2.27574468e-01f, -2.02738523e-01f, 7.04798847e-02f, 3.19740415e-01f, 9.81286466e-02f, 1.26816317e-01f, -6.25779182e-02f, -3.92671712e-02f,
  2.72588134e-01f, -4.21481207e-02f, -8.86663049e-02f, 1.83783069e-01f, 1.79403856e-01f, 2.72064775e-01f, 1.20582566e-01f, -8.88292566e-02f, 2.56873518e-01f, -8.74807301e-04f,
  -5.59313484e-02f, 6.09234013e-02f, 3.14309113e-02f, -5.36564253e-02f, 5.12782395e-01f, -2.99990565e-01f, 4.31511581e-01f, 5.49232326e-02f, 1.10200040e-01f, -4.39617395e-01f,
  -2.69474506e-01f, 1.29828840e-01f, 1.48422793e-01f, -2.81838834e-01f, -2.16756448e-01f, -2.47377649e-01f, 1.32660866e-01f, 2.48125136e-01f, -1.23964168e-01f, 2.46028230e-01f,
  -4.67410013e-02f, 2.89693534e-01f, -2.63530053e-02f, -2.01224778e-02f, -2.91269630e-01f, 1.75299302e-01f, 1.58602209e-03f, 2.89830178e-01f, 1.47325974e-02f, 1.28694564e-01f,
  5.05925566e-02f, -1.67301401e-01f, -1.49351619e-02f, -9.61415544e-02f, -1.90684825e-01f, 7.95157775e-02f, -2.98942238e-01f, -1.11367904e-01f, -1.70136318e-01f, -6.65484145e-02f,
  4.30666804e-01f, 1.56300768e-01f, 1.95079502e-02f, -7.19290748e-02f, 2.12300017e-01f, 7.01755211e-02f, 2.17208043e-01f, -3.81023139e-01f, -2.50393391e-01f, 2.46674597e-01f,
  1.88741162e-01f, 2.25439727e-01f, 1.15998305e-01f, 2.00687796e-01f, 1.25767916e-01f, 1.11996299e-02f, 1.37054294e-01f, -1.46583072e-03f, 5.03445640e-02f, -7.86086246e-02f,
  1.31517584e-02f, -3.39466423e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.16633976e-01f, 1.78705439e-01f, 4.64668423e-01f, 6.20372631e-02f, 1.29255518e-01f, 4.36467916e-01f, 6.86479330e-01f, -1.26205400e-01f, 9.61001813e-02f, 7.11432099e-02f,
  5.14852069e-02f, -1.99319087e-02f, -1.60399586e-01f, -2.02890798e-01f, 1.08891949e-01f, -2.13453457e-01f, -3.67750496e-01f, -1.10185213e-01f, 3.01339865e-01f, 3.66162099e-02f,
  4.53137785e-01f, 5.36906183e-01f, -2.75737166e-01f, 2.13638926e-03f, 5.36586404e-01f, -2.95094073e-01f, -1.95853449e-02f, 4.06396985e-01f, 1.87009312e-02f, 2.17999503e-01f,
  2.23528415e-01f, -1.72213599e-01f, -6.06918894e-02f, 2.57547468e-01f, 1.30050420e-03f, -2.64491234e-02f, 2.36340389e-01f, 1.20446920e-01f, 1.77576736e-01f, -5.33233769e-02f,
  1.87400311e-01f, -1.68241084e-01f, 1.77198768e-01f, -1.83144957e-02f, 3.01709682e-01f, 1.78018779e-01f, -2.02225447e-02f, 6.58556223e-02f, -3.27121392e-02f, -2.17595115e-01f,
  1.54677674e-01f, -1.08868562e-01f, -1.95654169e-01f, 2.70957440e-01f, -4.76994726e-04f, 1.90275565e-01f, 4.76312131e-01f, 1.33298054e-01f, 1.12178057e-01f, -2.02761158e-01f,
  1.02132760e-01f, 1.92472115e-01f, 2.79290937e-02f, 1.87006459e-01f, -7.35038891e-02f, 1.41823798e-01f, 2.15874121e-01f, -8.82684514e-02f, -6.45857826e-02f, 1.85255557e-01f,
  8.82562250e-02f, 3.74245077e-01f, -3.18710059e-01f, 2.80094445e-01f, -3.98282528e-01f, 2.76247650e-01f, -4.14037891e-02f, -9.35913101e-02f, 9.84268934e-02f, -2.03419611e-01f,
  1.79811850e-01f, 2.20680401e-01f, -1.23125635e-01f, -1.07205793e-01f, 2.51810312e-01f, 1.05010949e-01f, -1.24287970e-01f, -2.03146264e-01f, 9.22520682e-02f, 1.05385952e-01f,
  -1.08458981e-01f, 2.90075690e-01f, -1.20954134e-01f, -1.66912600e-01f, -6.02859259e-02f, -6.49895966e-02f, 2.41831064e-01f, 2.12282717e-01f, 7.14724436e-02f, 1.59112271e-02f,
  3.08319777e-01f, -5.95715865e-02f, 4.39430535e-01f, -1.96293309e-01f, -9.81697664e-02f, -1.24636538e-01f, -1.27929702e-01f, -3.71613093e-02f, 3.27532440e-01f, 2.40013137e-01f,
  9.23553575e-03f, 1.11498618e-02f, -6.81361929e-02f, -6.03618473e-02f, 1.62556246e-01f, 2.46705160e-01f, -1.45844715e-02f, -2.35945866e-01f, 2.17624120e-02f, -8.72709081e-02f,
  -5.02033457e-02f, -1.88771501e-01f, 3.98395568e-01f, -4.50317077e-02f, 1.32633805e-01f, -2.44275391e-01f, 1.62851796e-01f, -1.30773252e-02f, -4.40215878e-02f, 1.07225969e-01f,
  1.02415793e-01f, 1.01719238e-01f, 2.94172823e-01f, 6.54498488e-02f, -4.75193918e-01f, 3.16625416e-01f, 2.80600619e-02f, 2.45688513e-01f, -2.60719508e-01f, 2.46394932e-01f,
  -1.34603262e-01f, 3.39484178e-02f, 5.88162243e-03f, 1.24154471e-01f, 1.64223284e-01f, 3.02473873e-01f, 3.87894288e-02f, -1.99918732e-01f, 1.42364070e-01f, -5.92536964e-02f,
  1.16660058e-01f, 2.57344246e-01f, 1.71107501e-02f, 6.35884926e-02f, 8.81412551e-02f, 1.78777784e-01f, 5.42869903e-02f, 1.04597464e-01f, 1.06955513e-01f, 2.26367801e-01f,
  7.76443854e-02f, 8.86087045e-02f, 9.72741768e-02f, 1.35297120e-01f, -1.49880514e-01f, 8.67351517e-03f, -2.73491293e-01f, 1.52114600e-01f, -2.24806234e-01f, -8.60754773e-02f,
  2.64441550e-01f, 3.10201049e-01f, 2.89663672e-01f, -5.79948612e-02f, 7.35438317e-02f, 4.77693677e-02f, 1.73374265e-01f, -3.14971525e-03f, 1.04194492e-01f, -2.22487394e-02f,
  2.79381245e-01f, 2.82121360e-01f, 1.54573485e-01f, 1.24017522e-01f, 1.51460707e-01f, 6.57688454e-02f, 1.66184187e-01f, -2.14106351e-01f, 1.98120713e-01f, 3.22463840e-01f,
  -4.87263612e-02f, -2.15527982e-01f, -6.75168857e-02f, 1.38241217e-01f, 2.02450424e-01f, 1.71590775e-01f, 9.77910832e-02f, 1.16824552e-01f, 1.65297732e-01f, 4.48844969e-01f,
  -3.77769470e-01f, 2.40808740e-01f, -2.29829088e-01f, 4.23178583e-01f, 5.29572904e-01f, -9.47926193e-02f, -8.12225603e-03f, -5.75714670e-02f, 9.29275304e-02f, 1.69205666e-01f,
  2.09694356e-01f, 1.24073781e-01f, 5.63334167e-01f, 8.27221051e-02f, -6.64695539e-03f, 3.50245446e-01f, -5.90425357e-02f, 1.57511216e-02f, -8.40405002e-02f, 1.08434282e-01f,
  -5.49507216e-02f, 3.62739980e-01f, 1.03337444e-01f, -4.52274084e-01f, 2.18345940e-01f, -6.10542949e-03f, 2.80268312e-01f, 1.44049346e-01f, 1.88426703e-01f, 5.84245659e-02f,
  -1.76094398e-01f, 3.26914877e-01f, -2.37860791e-02f, 9.69328731e-02f, -9.75442454e-02f, 1.15583397e-01f, -1.30886257e-01f, -2.53448095e-02f, -9.12730172e-02f, 3.19972068e-01f,
  3.20435017e-01f, -1.21737989e-02f, 1.34692639e-01f, -1.72655657e-01f, -8.59101042e-02f, -1.34460535e-02f, 1.27732217e-01f, 3.09033602e-01f, -4.87838201e-02f, -9.42133963e-02f,
  -7.54455328e-02f, -2.33266409e-02f, -8.04765075e-02f, -4.56936099e-02f, -1.66232377e-01f, -1.63491398e-01f, 8.49280581e-02f, 1.64242461e-01f, 2.87867427e-01f, 3.59563798e-01f,
  3.28434139e-01f, 4.09538038e-02f, -6.06679976e-01f, 2.38832116e-01f, 1.60981774e-01f, 1.24300517e-01f, 2.49541029e-02f, -2.08754793e-01f, -1.56011611e-01f, 2.09903285e-01f,
  -1.48929060e-01f, 2.80562729e-01f, 5.64776897e-01f, 1.01488344e-01f, 2.35530823e-01f, 1.16118930e-01f, 5.18736951e-02f, -7.76595771e-02f, 4.51477051e-01f, 2.90238678e-01f,
  -1.54064029e-01f, 8.80434811e-02f, -1.76381469e-01f, -3.14832665e-02f, 1.44067809e-01f, 2.16120809e-01f, 6.96001351e-02f, 2.20448092e-01f, 1.08613521e-01f, 4.34118181e-01f,
  3.64800245e-01f, -5.00905626e-02f, 3.36701065e-01f, 3.31580490e-02f, -2.84030885e-01f, -6.11195862e-02f, 3.81546654e-02f, -5.94677031e-03f, -1.52928650e-01f, -1.51418000e-01f,
  -2.81113058e-01f, -4.71514650e-02f, 4.46456857e-02f, 1.21004447e-01f, -7.11141378e-02f, -4.12267074e-02f, -1.08357243e-01f, -1.64803371e-01f, -3.83292325e-02f, -1.67316973e-01f,
  6.56948909e-02f, 5.01280352e-02f, 5.69772601e-01f, 8.32986832e-02f, 4.15511996e-01f, 1.17986821e-01f, 1.50397092e-01f, -1.33248106e-01f, 9.41277370e-02f, 2.62247503e-01f,
  -8.92116651e-02f, 4.36245888e-01f, 3.13928187e-01f, 2.23105237e-01f, 3.09976280e-01f, 1.52131200e-01f, 6.67552873e-02f, -1.38287559e-01f, -7.99663141e-02f, -3.58274877e-02f,
  2.40599856e-01f, -2.12469455e-02f, 4.50185686e-01f, 1.39373317e-01f, -3.80098522e-02f, 6.39222264e-01f, 3.27362567e-02f, -2.91740209e-01f, 1.71795487e-02f, -1.13912448e-02f,
  -3.57536823e-01f, -9.02104899e-02f, 3.10646445e-01f, 1.22633033e-01f, 6.09824181e-01f, -2.48009250e-01f, 8.26041877e-01f, -2.97393471e-01f, -1.64931089e-01f, -2.49708191e-01f,
  -2.05854639e-01f, -2.11054474e-01f, 4.31808978e-02f, 2.71278620e-01f, 1.87155530e-02f, 4.21675928e-02f, 1.59735948e-01f, 1.45296946e-01f, 3.60512137e-01f, -3.56989652e-01f,
  3.07980716e-01f, -2.26641163e-01f, -2.11992394e-02f, -2.49183908e-01f, 3.52462947e-01f, 4.76302147e-01f, 3.86934243e-02f, 1.28729224e-01f, -2.46970400e-01f, -5.56403697e-02f,
  1.55449629e-01f, 3.29016060e-01f, -3.96150887e-01f, -1.21498346e-01f, -7.00802058e-02f, -1.08654946e-01f, 1.10081144e-01f, 6.35735840e-02f, 7.46594891e-02f, -1.91581249e-01f,
  -1.55683961e-02f, -1.54068843e-01f, 9.61323380e-02f, 5.23251057e-01f, 1.32863596e-01f, -7.07247630e-02f, 2.91135870e-02f, 1.21094421e-01f, 1.04225455e-02f, 1.35686576e-01f,
  2.22836494e-01f, 2.86357123e-02f, 3.04904692e-02f, -1.63501892e-02f, 4.99318428e-02f, -4.42956090e-02f, 1.08827360e-01f, -1.40572786e-01f, 1.32638633e-01f, -1.57702506e-01f,
  -2.48689689e-02f, -1.64035529e-01f, -1.26782253e-01f, 3.68488170e-02f, 5.08633964e-02f, 2.16540024e-01f, 8.76398832e-02f, 4.53365259e-02f, -1.41425524e-02f, -1.97189339e-02f,
  1.30487718e-02f, 6.61810534e-03f, 9.90916491e-02f, 1.37969375e-01f, 1.22638948e-01f, 3.22489366e-02f, -7.53280595e-02f, 3.09608728e-01f, 9.90926251e-02f, 1.37808785e-01f,
  1.97447583e-01f, 2.04539597e-01f, 4.03641671e-01f, 6.66598827e-02f, -2.06360608e-01f, 2.81451195e-01f, -5.59600234e-01f, 1.31238252e-01f, 3.37669462e-01f, 2.75206000e-01f,
  -8.60473886e-02f, -2.37545103e-01f, 8.94080475e-03f, 2.37563983e-01f, 1.28263175e-01f, -3.31209861e-02f, 3.02016705e-01f, -1.69643000e-01f, -6.57901987e-02f, -3.54551226e-01f,
  1.07733734e-01f, 4.26630497e-01f, -2.81671047e-01f, 2.99116701e-01f, 1.69955753e-02f, -2.90808737e-01f, -9.66429412e-02f, 4.13212270e-01f, -4.66464534e-02f, -6.02464899e-02f,
  1.22624584e-01f, -6.27684891e-02f, -9.76465922e-03f, -7.27873147e-02f, -7.06689060e-02f, 8.64124522e-02f, 8.83957148e-02f, -3.89786839e-01f, -1.45029813e-01f, 1.60472110e-01f,
  -6.79218695e-02f, -5.42171560e-02f, 7.55612925e-03f, -1.24704167e-01f, -7.16090053e-02f, 8.27332437e-02f, 4.00036335e-01f, -1.65731817e-01f, -2.22014353e-01f, 3.04811060e-01f,
  -6.47568703e-02f, 1.19883940e-01f, 5.50847173e-01f, 3.19997340e-01f, 1.94606513e-01f, 1.10725366e-01f, 8.73136371e-02f, 3.88475060e-01f, -1.24804169e-01f, 2.94597358e-01f,
  -2.38487665e-02f, 1.21095009e-01f, 2.68953349e-02f, 2.85667062e-01f, 1.18104316e-01f, 7.21414536e-02f, 3.83597076e-01f, 1.92009136e-01f, -1.69628292e-01f, 2.69056678e-01f,
  7.04909787e-02f, -3.81946452e-02f, 5.09294927e-01f, -1.32403463e-01f, -1.77159067e-02f, 4.71394882e-02f, -2.79166073e-01f, 3.57516140e-01f, 2.05291510e-01f, -1.44448108e-03f,
  3.33172530e-02f, 1.54672004e-02f, -1.97866052e-01f, -2.38370195e-01f, 5.21123670e-02f, 5.21629676e-02f, 2.02173248e-01f, 9.07478333e-02f, 1.01803064e-01f, -1.34059548e-01f,
  -1.72240451e-01f, -2.04124078e-01f, 2.10116610e-01f, -3.51852668e-03f, 2.64355272e-01f, 2.00076401e-01f, 4.26363498e-02f, 5.45340739e-02f, -2.67426401e-01f, -2.79669642e-01f,
  2.82974362e-01f, 9.98064354e-02f, 4.15955275e-01f, -4.36729044e-01f, -4.38440330e-02f, 5.13538569e-02f, 6.47272468e-02f, -2.15548873e-02f, 2.20092490e-01f, 2.29208529e-01f,
  5.93653619e-02f, 5.34195900e-01f, -2.00338826e-01f, 2.41612747e-01f, 4.53240633e-01f, 9.30604339e-02f, 2.82295138e-01f, -1.73309594e-01f, -2.64330477e-01f, -9.35675874e-02f,
  -1.95868656e-01f, -2.10134964e-02f, 2.04984844e-01f, 3.58420104e-01f, 7.94402286e-02f, -7.55516216e-02f, 6.74757957e-02f, 2.70427644e-01f, 2.36681812e-02f, -2.18029283e-02f,
  1.08902171e-01f, -3.62615108e-01f, 4.39817421e-02f, -6.72327951e-02f, 1.34207278e-01f, -1.72984779e-01f, -1.55527726e-01f, 9.88220200e-02f, 2.19619259e-01f, -1.60312310e-01f,
  -8.93165395e-02f, -1.10147856e-01f, -1.88033625e-01f, 3.97094667e-01f, 9.93984044e-02f, -5.23227220e-03f, 1.63062051e-01f, 1.49458364e-01f, 2.34433338e-02f, 8.64622369e-02f,
  -1.66927487e-01f, 6.21379726e-02f, 5.18222824e-02f, 9.00007039e-02f, 2.52923638e-01f, 1.01405671e-02f, -1.91114470e-02f, -7.66623914e-02f, 1.39580416e-02f, 2.65491039e-01f,
  -1.59310564e-01f, 1.05588973e-01f, 2.21653119e-01f, -9.15784240e-02f, 2.07654573e-02f, 4.07991782e-02f, 2.70497143e-01f, -1.91222832e-01f, 8.36006775e-02f, -4.20059524e-02f,
  2.57271174e-02f, -1.02786794e-01f, -2.08316758e-01f, 2.40522567e-02f, 1.37833759e-01f, 2.26705045e-01f, -7.66020501e-03f, 3.35830182e-01f, 1.34194970e-01f, -1.13087133e-01f,
  2.90624648e-01f, 1.18546234e-02f, 2.08978355e-01f, -1.21231470e-02f, -1.46360829e-01f, -3.82240443e-03f, -8.16318691e-02f, -7.19553530e-02f, 7.11283535e-02f, -2.66761363e-01f,
  3.23298514e-01f, 2.34924674e-01f, 4.42729183e-02f, -3.11264899e-02f, -4.07298893e-01f, -2.28587389e-01f, -1.41775280e-01f, -9.34604779e-02f, 2.57457763e-01f, 1.62327722e-01f,
  -1.11836120e-01f, -1.80139616e-02f, 1.38804808e-01f, 5.63646443e-02f, 1.43005416e-01f, -1.16484776e-01f, -1.44677490e-01f, 4.62993115e-01f, 5.22398591e-01f, -1.04135297e-01f,
  -8.46894309e-02f, -2.97676139e-02f, -6.15359098e-02f, 5.15366383e-02f, 1.29037211e-02f, 8.73347819e-02f, -9.80272666e-02f, -5.61537109e-02f, 1.91534370e-01f, -2.28766173e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.49598110e-01f, -1.44528858e-02f, 1.41698569e-01f, 1.82223082e-01f, 1.14879787e-01f, 2.31696308e-01f, 5.08236229e-01f, 1.57341182e-01f, 1.23290926e-01f, 3.39889318e-01f,
  2.09283587e-02f, 5.12611233e-02f, -9.30024758e-02f, 3.01405102e-01f, 2.03024313e-01f, 8.33701119e-02f, 2.83597499e-01f, 1.50738329e-01f, -3.00032925e-02f, 3.09106290e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.38408825e-01f, 1.49535477e-01f, 2.46091783e-01f, 1.24188341e-01f, -3.04389656e-01f, 2.49968022e-01f, -3.36089507e-02f, 7.86326468e-01f, -5.03070235e-01f, -5.60104012e-01f,
  -5.99521220e-01f, 4.23885614e-01f, -5.79140902e-01f, -2.66642988e-01f, 6.16798937e-01f, -2.05649629e-01f, 3.78426820e-01f, 2.76074916e-01f, 4.40557122e-01f, 3.53787988e-01f,
  2.21799880e-01f, -9.26069617e-02f, -4.91666049e-01f, -1.18813785e-02f, -7.39579573e-02f, 3.24932426e-01f, -1.06929414e-01f, -2.97611058e-01f, -5.27895987e-01f, 3.61004360e-02f,
  -1.82899296e-01f, 2.25161076e-01f, 5.69550470e-02f, 4.46833134e-01f, 6.02971725e-02f, 1.35536149e-01f, -3.04284245e-01f, -4.80619520e-02f, 1.54931486e-01f, 1.20713837e-01f,
  3.66084903e-01f, -3.13470840e-01f, -5.69396317e-01f, 3.29150617e-01f, -5.48963964e-01f, 3.86401527e-02f, -1.62275180e-01f, -2.52237946e-01f, 2.46981248e-01f, 2.58495510e-01f,
  -2.96558663e-02f, 4.59229320e-01f, 5.19584835e-01f, 3.68734121e-01f, 7.30805874e-01f, -4.50122416e-01f, 4.89671864e-02f, -5.56521177e-01f, -1.11242674e-01f, -1.97124124e-01f,
  3.41018401e-02f, -3.02283496e-01f, -3.70552093e-01f, -5.89985065e-02f, 1.08891293e-01f, -1.05150744e-01f, 4.11613062e-02f, -4.46757019e-01f, -1.71175431e-02f, -3.24168414e-01f,
  3.98124933e-01f, 7.36677289e-01f, 2.09597498e-01f, 2.61685610e-01f, 1.98275372e-01f, 1.66167125e-01f, 4.26896691e-01f, 2.69962460e-01f, -2.94508729e-02f, -3.23970258e-01f,
  -2.43593216e-01f, 2.14639604e-01f, -3.83790851e-01f, -2.12897196e-01f, -3.90649498e-01f, 1.31344408e-01f, 2.92887300e-01f, 4.43577431e-02f, 1.50635034e-01f, -2.23606825e-01f,
  1.73074007e-01f, 7.85661936e-02f, 4.44936395e-01f, 4.66120504e-02f, 4.51664031e-01f, -9.89571139e-02f, -5.93719363e-01f, 1.40048653e-01f, -5.80736697e-01f, -1.35639131e-01f,
  -2.47735009e-01f, -2.60674417e-01f, -2.39061743e-01f, -3.66825432e-01f, -8.57705846e-02f, -4.61858571e-01f, -3.80490750e-01f, -2.85721898e-01f, -4.59185183e-01f, -2.65669197e-01f,
  3.08835059e-01f, -7.59302825e-02f, 8.02633911e-02f, 1.03990391e-01f, 6.44910634e-01f, -2.19421938e-01f, -2.12093487e-01f, -5.15841365e-01f, -2.96575159e-01f, -1.99012272e-02f,
  2.61920094e-02f, 6.00283921e-01f, 1.32508665e-01f, 5.64298451e-01f, -2.27585182e-01f, 7.78624490e-02f, -1.59249663e-01f, -2.71678299e-01f, 4.91515815e-01f, 1.54314086e-01f,
  1.61898881e-01f, 3.01111072e-01f, 5.38428366e-01f, 3.08295246e-02f, 3.28849703e-01f, -2.88444385e-02f, -4.85071689e-01f, 1.02632940e-01f, 4.60829526e-01f, 6.29118755e-02f,
  9.09124076e-01f, -3.81179124e-01f, 4.35141593e-01f, 1.76262215e-01f, -3.03192846e-02f, -3.43426347e-01f, 3.06222498e-01f, -4.33169864e-02f, -3.01078230e-01f, 2.09944934e-01f,
  -3.52142721e-01f, -2.73407578e-01f, 2.00541183e-01f, 5.45137942e-01f, -3.77086073e-01f, 2.06677973e-01f, -1.93911389e-01f, 1.84731439e-01f, -7.94480294e-02f, -1.08359002e-01f,
  1.94641277e-01f, -1.84737414e-01f, 5.22839427e-01f, 2.21868843e-01f, 6.86318696e-01f, 3.96289855e-01f, 5.45813262e-01f, -7.65600324e-01f, -1.43944576e-01f, -4.45273399e-01f,
  -1.12862755e-02f, -5.57783186e-01f, -3.67483079e-01f, -2.62116969e-01f, -2.96481922e-02f, -2.37166271e-01f, 5.52126169e-01f, -2.00747922e-01f, -2.07912743e-01f, 1.18792638e-01f,
  7.92025864e-01f, 2.52431005e-01f, -4.34003294e-01f, -1.18913546e-01f, -5.00580557e-02f, 1.17102824e-02f, -1.06933452e-01f, -2.58743346e-01f, 4.94401276e-01f, -1.14348933e-01f,
  -2.51063854e-01f, -2.90215641e-01f, -1.84685901e-01f, -3.04713488e-01f, -3.44432235e-01f, -3.73892695e-01f, -1.25926867e-01f, 2.55869627e-01f, 5.32182932e-01f, -7.60544479e-01f,
  5.08565962e-01f, 3.77765685e-01f, 5.39978981e-01f, 3.04091007e-01f, -5.47642767e-01f, -1.10789556e-02f, 8.60307589e-02f, 2.68000335e-01f, -2.46033207e-01f, -2.26463094e-01f,
  -4.73730177e-01f, -1.93154857e-01f, 1.93427935e-01f, -9.13699120e-02f, 1.31018937e-01f, 5.17582297e-01f, 5.53224012e-02f, -2.14076921e-01f, -2.76956499e-01f, -1.97330892e-01f,
  6.29459321e-01f, 4.80053812e-01f, 1.83992237e-01f, 1.14620864e-01f, -1.95624337e-01f, -1.59537211e-01f, -1.29833415e-01f, -1.14733681e-01f, -3.81104857e-01f, -8.31593499e-02f,
  -3.96592408e-01f, -1.95036039e-01f, -3.58652472e-01f, 2.65926719e-01f, 5.45993268e-01f, -9.19068530e-02f, 4.14429367e-01f, 2.41103515e-01f, -2.05052137e-01f, -1.07877642e-01f,
  1.69369757e-01f, 3.03328276e-01f, 4.56848621e-01f, 1.60228446e-01f, 2.54385620e-01f, -3.62519592e-01f, -3.40254962e-01f, -2.25427911e-01f, 1.33462563e-01f, -3.72705221e-01f,
  5.47935605e-01f, -1.24423400e-01f, -1.80933148e-01f, -1.05347164e-01f, 5.53663149e-02f, -3.27131182e-01f, 3.00543476e-02f, -4.29147094e-01f, -4.19715345e-02f, -1.50016010e-01f,
  -5.10571122e-01f, 1.28516763e-01f, -4.62546706e-01f, 5.32397985e-01f, 3.24428380e-01f, 1.66685358e-01f, -4.89347070e-01f, -6.51713868e-04f, -1.95524216e-01f, 2.60819286e-01f,
  4.83873934e-02f, 1.69251204e-01f, 7.43732974e-02f, 1.17093943e-01f, -5.32704473e-01f, -3.17911983e-01f, -3.82177442e-01f, 7.16578484e-01f, 5.72329283e-01f, 1.67152345e-01f,
  -1.21517137e-01f, -8.68532807e-02f, 4.82463151e-01f, -9.58028883e-02f, -4.02604967e-01f, -1.11716725e-01f, -2.22970918e-01f, -1.11504279e-01f, -1.56528167e-02f, 5.74934363e-01f,
  -8.21607485e-02f, -3.42600077e-01f, 2.21747816e-01f, -2.72199005e-01f, 4.51616883e-01f, 4.16157097e-01f, 5.03651857e-01f, 5.76079309e-01f, 9.73906592e-02f, 5.44528842e-01f,
  9.51896161e-02f, -3.32461655e-01f, -2.41857663e-01f, -2.05415905e-01f, -1.88426226e-01f, 3.50732118e-01f, 1.45396248e-01f, -1.42776981e-01f, 1.56160504e-01f, -8.48921537e-02f,
  -5.63991129e-01f, -3.22584838e-01f, 1.75739273e-01f, -3.28372955e-01f, -2.46799961e-01f, -1.25842109e-01f, 2.71485895e-01f, 4.65755731e-01f, -5.65144159e-02f, 8.14101577e-01f,
  -8.65184441e-02f, 2.49801427e-01f, -6.30547330e-02f, 6.53960137e-03f, 2.15844899e-01f, 8.92709419e-02f, -4.98098493e-01f, -1.47725925e-01f, -4.92027611e-01f, -9.51109901e-02f,
  -3.56286138e-01f, -3.61101069e-02f, 1.50270447e-01f, 1.03875294e-01f, -6.10812716e-02f, 5.83465815e-01f, -3.46992880e-01f, 1.30078793e-01f, 2.62178898e-01f, 5.67007959e-02f,
  -3.32613796e-01f, -2.69043505e-01f, 7.62634218e-01f, 1.00863144e-01f, 1.66279554e-01f, -6.47230148e-02f, -3.97560298e-01f, 5.17669678e-01f, -3.50706041e-01f, -2.48037830e-01f,
  1.27979726e-01f, -2.67846316e-01f, 1.16545781e-01f, -5.85232019e-01f, 2.64158547e-01f, 2.34389931e-01f, 2.18394428e-01f, -9.48500335e-02f, -3.80835027e-01f, -2.01483577e-01f,
  -2.82936931e-01f, -9.03754458e-02f, 6.28129840e-01f, -6.50915802e-01f, 2.45609656e-02f, 3.10076654e-01f, -1.20765746e-01f, 2.30914712e-01f, -2.54916877e-01f, -3.80341887e-01f,
  -4.78142381e-01f, -2.88987122e-02f, -1.60632581e-01f, 9.75014940e-02f, -1.86563209e-01f, 8.25700045e-01f, 1.43122479e-01f, 5.74497581e-01f, 1.27395138e-01f, -1.32946670e-01f,
  2.22494043e-02f, 1.60393730e-01f, -7.86423087e-02f, -1.39314160e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  6.09394675e-03f, -2.57439222e-02f, -1.65210634e-01f, -1.81113556e-01f, 3.13284039e-01f, 1.80440009e-01f, 9.67317820e-02f, -1.45472184e-01f, -2.31174305e-01f, 1.50871977e-01f,
  -1.80199847e-01f, 1.53353781e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    