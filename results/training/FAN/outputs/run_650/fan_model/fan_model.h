/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.90628266e-01f, 1.22563742e-01f, -2.14398757e-01f, 2.79113710e-01f, -2.15682402e-01f, -8.43415037e-03f, 9.44768190e-02f, 2.53526568e-01f, 1.19171120e-01f, 1.69040501e-01f,
  -8.73126909e-02f, -1.85392439e-01f, -1.42317504e-01f, -2.54081577e-01f, 1.21170925e-02f, 1.05213381e-01f, 5.79799572e-03f, -2.05853388e-01f, -1.73399001e-01f, -1.07960647e-03f,
  -5.45648523e-02f, 2.22675964e-01f, 1.36423290e-01f, 1.08219780e-01f, 7.45157152e-02f, -1.12256497e-01f, -9.21543967e-03f, 9.45643038e-02f, -1.45106524e-01f, -9.47700441e-02f,
  -1.52648970e-01f, 1.87768221e-01f, -2.26091832e-01f, -9.96314138e-02f, -1.33759007e-01f, 5.70737831e-02f, 4.29491289e-02f, -3.38253751e-02f, 4.61669154e-02f, -1.08245397e-02f,
  -5.06513715e-02f, 1.98848695e-02f, 1.49664644e-03f, -6.80777356e-02f, 5.15357405e-02f, -7.44666532e-02f, -3.43194604e-03f, 5.65335415e-02f, 1.93094406e-02f, 5.38521586e-03f,
  -1.77020863e-01f, -5.12908809e-02f, 2.96987444e-02f, -4.00236771e-02f, 2.59658471e-02f, -2.07500011e-01f, -1.75277647e-02f, -3.88251655e-02f, -1.19898215e-01f, 1.29259154e-01f,
  4.59660366e-02f, 1.93135217e-02f, -6.80417791e-02f, 2.16813833e-02f, 2.89863944e-02f, 5.19749261e-02f, -1.98179726e-02f, 7.05414172e-03f, -7.84093142e-03f, -7.96280988e-03f,
  -1.10745519e-01f, 4.43505086e-02f, 2.87156291e-02f, 1.24184273e-01f, -3.95489074e-02f, -2.73448210e-02f, 3.45796980e-02f, -2.01370679e-02f, 2.04296894e-02f, 5.50287142e-02f,
  -4.57496084e-02f, -4.46176603e-02f, -4.75056842e-03f, 1.11141033e-01f, 1.28747597e-02f, -4.34341282e-02f, -8.25963318e-02f, -4.75845672e-02f, 1.02038309e-02f, 3.27915326e-02f,
  1.12778388e-01f, -1.19758487e-01f, 6.78425608e-03f, -7.32675642e-02f, -1.79614930e-04f, -3.63443978e-02f, -1.37969300e-01f, -9.91856754e-02f, -8.51014853e-02f, -2.58944798e-02f,
  -9.35922712e-02f, 4.65310439e-02f, -5.20735863e-04f, -1.22294752e-02f, -4.81714979e-02f, -4.14531678e-02f, -1.05237015e-01f, -3.39258090e-02f, -1.62963048e-02f, 2.20076628e-02f,
  7.73366913e-02f, 6.67556524e-02f, 7.57845957e-03f, 5.04450593e-03f, 5.52635752e-02f, -4.04121028e-03f, -9.52444449e-02f, 3.13051119e-02f, -1.12275891e-01f, 1.47947848e-01f,
  -7.87398443e-02f, 8.40067584e-03f, -2.96608686e-01f, 8.37745443e-02f, -7.29521513e-02f, -1.23862781e-01f, -1.01411939e-01f, 1.78111419e-01f, 3.11912507e-01f, 6.96059223e-03f,
  6.96925893e-02f, 2.29908094e-01f, 1.62147135e-01f, 1.82299241e-01f, 7.67760351e-02f, -2.19301790e-01f, -2.23378092e-01f, -1.76296458e-01f, 9.89362672e-02f, 7.03836009e-02f,
  1.43400937e-01f, 5.62856793e-02f, 3.65830064e-02f, 2.15419248e-01f, -3.08496263e-02f, 2.04788789e-01f, -2.35984828e-02f, -3.50330514e-03f, -5.99017274e-03f, -2.05542624e-01f,
  -1.39367715e-01f, -3.97491567e-02f, 1.07881851e-01f, 7.09763914e-02f, 3.99752147e-02f, 3.99345383e-02f, 8.89486372e-02f, 1.14081375e-01f, 4.15390357e-02f, 3.13909575e-02f,
  -6.87713996e-02f, 5.59199825e-02f, -6.56224973e-03f, -5.25565110e-02f, 8.03025160e-03f, 3.36907618e-02f, 4.83606830e-02f, 1.05053738e-01f, 1.14092021e-03f, -1.07536711e-01f,
  -4.10874635e-02f, -6.78754821e-02f, -1.90085784e-01f, 1.40421554e-01f, 2.80292220e-02f, -5.64772123e-03f, 5.08649908e-02f, 5.35737760e-02f, 3.81340012e-02f, 1.21623956e-01f,
  -4.24368605e-02f, -2.66214479e-02f, -3.51059996e-02f, 1.42035829e-02f, 4.61853482e-02f, -2.97926422e-02f, 4.80076484e-03f, -1.85658447e-02f, -7.11799879e-03f, 1.34636387e-02f,
  4.74969186e-02f, -4.32421789e-02f, 5.30374311e-02f, -4.79331985e-03f, 4.68630195e-02f, -3.98388691e-02f, -2.32061539e-02f, 8.16403190e-05f, -4.19748351e-02f, 5.69036752e-02f,
  9.48495790e-02f, -2.30646450e-02f, 3.61527316e-02f, 5.50161349e-03f, -6.31370172e-02f, -3.38235497e-02f, -3.70095149e-02f, -2.88741849e-02f, -1.11999474e-02f, -8.15731063e-02f,
  2.84300953e-01f, -1.14282474e-01f, 8.40859935e-02f, 4.56248000e-02f, 9.45461914e-02f, 3.44478860e-02f, 5.36644273e-02f, 7.58308172e-02f, 6.07063062e-02f, 1.17840439e-01f,
  3.22381891e-02f, 1.78653188e-02f, 4.00776335e-04f, 2.99725812e-02f, 1.12111373e-02f, 1.66655798e-03f, 1.15146115e-02f, -2.21410785e-02f, -1.07762525e-02f, 2.00627297e-02f,
  2.68553663e-03f, 1.64373592e-02f, -2.02943869e-02f, 5.71403429e-02f, 9.95625034e-02f, 4.36008954e-03f, -2.86241118e-02f, 6.34140745e-02f, -5.56972027e-02f, 2.04382822e-01f,
  -1.09425429e-02f, 4.29604143e-01f, -8.14165920e-02f, 1.09619454e-01f, 2.98439860e-01f, 2.41513878e-01f, 3.75224173e-01f, 1.43136129e-01f, 5.65442182e-02f, 1.48478881e-01f,
  2.01741144e-01f, -3.22978012e-02f, -9.70527083e-02f, -1.08790122e-01f, -5.61628081e-02f, 1.32785037e-01f, 2.56076884e-02f, -1.15275875e-01f, -7.98098519e-02f, 1.37878776e-01f,
  2.69002467e-01f, 1.31019130e-01f, -1.12108603e-01f, 1.87427700e-02f, 5.20311780e-02f, -1.90865295e-03f, -7.97462687e-02f, -6.50916845e-02f, -4.24721576e-02f, -1.35203630e-01f,
  2.62469091e-02f, 5.14196567e-02f, 1.13769367e-01f, 1.11317478e-01f, 1.15035899e-01f, 1.76223025e-01f, 2.33601928e-01f, 4.90690880e-02f, 9.76895094e-02f, 1.23956829e-01f,
  1.46017671e-01f, 4.87376004e-02f, 9.45437998e-02f, 9.22159478e-02f, 9.91747007e-02f, 8.27498883e-02f, 1.02343573e-03f, -5.31483849e-04f, 2.58031338e-02f, 2.22873345e-01f,
  1.64107099e-01f, 1.87429175e-01f, -1.12905791e-02f, 1.27266094e-01f, 3.24960798e-02f, 1.12556316e-01f, 5.06474040e-02f, -4.65418547e-02f, -8.29045773e-02f, 2.08223686e-02f,
  1.03692859e-02f, -8.23213309e-02f, -8.07621107e-02f, -4.92497161e-02f, -8.07472318e-02f, -1.20670117e-01f, -4.72424962e-02f, -4.40885723e-02f, -1.08719267e-01f, -8.60465392e-02f,
  -1.26173094e-01f, -6.51163398e-04f, -1.02444679e-01f, -1.56547744e-02f, -1.06134921e-01f, -7.96591118e-02f, -6.25979081e-02f, -1.60697941e-02f, -2.59313751e-02f, -1.54056236e-01f,
  -6.61357194e-02f, -1.01822667e-01f, -4.64665294e-02f, -8.34688172e-02f, -4.08296660e-02f, -1.21754445e-01f, -9.60680470e-02f, -7.25808647e-03f, -4.74416129e-02f, -6.45289049e-02f,
  2.06485122e-01f, 1.85388736e-02f, 1.00017026e-01f, 7.48776644e-02f, 1.23654291e-01f, 7.56453425e-02f, 1.49815232e-01f, 9.59111676e-02f, 1.07643858e-01f, 1.11397214e-01f,
  2.01717973e-01f, 1.91685155e-01f, 1.27895385e-01f, 1.20087385e-01f, 1.55267492e-01f, 1.55522034e-01f, 1.24614857e-01f, 1.45471603e-01f, 5.10774627e-02f, 1.40271485e-01f,
  7.58664533e-02f, 9.21012610e-02f, 2.01038569e-01f, 1.46970510e-01f, 1.36530697e-01f, 1.39797926e-01f, 1.88281551e-01f, 2.07361743e-01f, 1.84403181e-01f, 3.17269087e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.58750188e-01f, 1.15502737e-01f, 3.51288193e-03f, 3.53867620e-01f, -1.67633608e-01f, -5.06471515e-01f, -5.41499555e-01f, -3.64730209e-01f, 7.95315728e-02f, 1.41310066e-01f,
  -3.12042306e-03f, -1.00291912e-02f, -2.81063132e-02f, -1.13791615e-01f, -4.05200392e-01f, -2.96489447e-02f, -1.48597993e-02f, -7.50503615e-02f, -4.11358029e-01f, -3.75344127e-01f,
  -8.45858175e-03f, 1.17926233e-01f, 8.96922946e-02f, 1.14268437e-01f, 3.82575035e-01f, 2.31548436e-02f, 3.05034611e-02f, 9.16339159e-02f, -6.23589642e-02f, 6.48333311e-01f,
  3.10527444e-01f, 1.30362466e-01f, -8.97336900e-02f, -1.85197536e-02f, -2.83280527e-03f, 1.91245809e-01f, 3.66914570e-02f, 8.42566714e-02f, 5.10049192e-03f, 1.06822923e-01f,
  -2.45034583e-02f, 4.99523990e-02f, -3.64609808e-02f, 8.15329142e-03f, -6.23555817e-02f, 8.59948900e-03f, -4.61613834e-02f, 3.14289294e-02f, 4.78849281e-03f, -2.36538015e-02f,
  7.18366206e-02f, 2.14803014e-02f, -1.10475071e-01f, -2.81010896e-01f, -1.50924146e-01f, 1.20370455e-01f, 2.01888662e-02f, 4.61709201e-02f, -3.84277701e-02f, 3.16601753e-01f,
  1.91314481e-02f, 1.03360293e-02f, 6.08184524e-02f, 5.85667603e-02f, -1.38846980e-02f, -6.00114614e-02f, 1.31318823e-01f, -8.53639096e-02f, 1.05152920e-01f, 2.13930346e-02f,
  -4.74706292e-02f, 1.12282529e-01f, -3.83985043e-02f, 9.54806898e-03f, 1.70927346e-02f, 6.41006231e-02f, 3.63184288e-02f, 9.78573784e-02f, -1.92779265e-02f, -1.49481064e-02f,
  -1.33346930e-01f, 7.75173530e-02f, 7.58960098e-02f, -2.01355685e-02f, -3.87996039e-03f, -5.00761671e-04f, 1.12703271e-01f, 4.91769724e-02f, -1.75152421e-02f, 2.07974529e-03f,
  1.42221361e-01f, -4.21542555e-01f, 3.42161208e-01f, 8.31439421e-02f, 3.23108174e-02f, -4.60908897e-02f, 2.96682537e-01f, 4.90644425e-02f, 4.32924218e-02f, -8.05513710e-02f,
  -1.41205788e-01f, -1.16490915e-01f, -1.69235952e-02f, -3.76005247e-02f, -1.01605892e-01f, 1.04654906e-02f, -6.56515658e-02f, 3.69762332e-04f, -2.11321652e-01f, 3.33452150e-02f,
  2.13404205e-02f, -3.46777231e-01f, -3.11429679e-01f, -1.57266006e-01f, -7.77259329e-03f, -2.13905111e-01f, -2.40057766e-01f, -8.99640843e-02f, -3.19710582e-01f, -7.70112947e-02f,
  -1.44336522e-01f, -5.95934927e-01f, 1.38573781e-01f, 1.01246737e-01f, 6.61962926e-02f, -1.08831093e-01f, -6.74875081e-01f, -1.45709097e-01f, 8.24929401e-02f, -5.38386405e-01f,
  -1.51153162e-01f, 2.77279347e-01f, 5.69123141e-02f, 9.37219486e-02f, -4.46759343e-01f, -6.77309692e-01f, -4.57690597e-01f, 9.24960673e-02f, 2.78118938e-01f, 5.86165057e-04f,
  4.85673137e-02f, 1.78917289e-01f, 2.50235915e-01f, 6.31064102e-02f, -1.29125834e-01f, 3.62147577e-02f, -2.23258347e-03f, -6.26753643e-02f, -1.49521902e-01f, -2.23848879e-01f,
  -2.36910403e-01f, -1.24980904e-01f, 9.50247422e-02f, 6.54299781e-02f, 3.38028520e-02f, 1.65250637e-02f, -1.58617139e-01f, 1.02870591e-01f, 3.11533026e-02f, -7.10911229e-02f,
  1.73687473e-01f, -4.89889793e-02f, 1.99522808e-01f, 1.68689452e-02f, -1.46980330e-01f, -7.56075382e-02f, -6.77369311e-02f, -5.61590046e-02f, -1.66850761e-01f, -2.92141467e-01f,
  -1.39008120e-01f, -8.50303769e-02f, -1.19215950e-01f, -1.67314216e-01f, -1.94480971e-01f, 1.39598608e-01f, -1.08190328e-01f, -1.83155134e-01f, -2.51002103e-01f, -5.90965033e-01f,
  -3.02920844e-02f, 1.96915884e-02f, -2.08682157e-02f, -5.58225214e-02f, -8.33867565e-02f, 5.92546426e-02f, 7.52796009e-02f, -8.80778283e-02f, -7.87586719e-03f, -1.31941037e-02f,
  -4.67756428e-02f, 4.54720343e-03f, -2.42349189e-02f, -1.21502385e-01f, 9.00914613e-03f, -4.19320427e-02f, -8.01633764e-03f, -1.84692353e-01f, -8.75190273e-02f, -4.46360260e-02f,
  -1.35295987e-02f, 9.42188203e-02f, 4.64351997e-02f, 3.12756971e-02f, -8.34146142e-02f, -2.65955273e-02f, 4.53521721e-02f, 3.94481346e-02f, -3.84100936e-02f, 1.04952827e-02f,
  2.86219884e-02f, 2.43992835e-01f, -2.80292660e-01f, 1.11344801e-02f, -3.07421982e-02f, -3.55947986e-02f, 1.13979824e-01f, 1.01972096e-01f, 1.43031552e-01f, -1.40945211e-01f,
  -7.19094500e-02f, 1.17075723e-02f, -4.89301644e-02f, 8.45823288e-02f, 1.82144176e-02f, -1.84931839e-03f, -3.26842517e-01f, 1.36676848e-01f, 4.00274582e-02f, 7.31823891e-02f,
  -8.10144469e-02f, -1.20973296e-01f, -2.02998981e-01f, -2.08448321e-01f, -2.11052060e-01f, -5.10203047e-03f, -3.05500418e-01f, -1.89026967e-01f, -2.29324907e-01f, -6.77602470e-01f,
  4.71611708e-01f, -2.33125478e-01f, -6.37736142e-01f, 1.46668211e-01f, -3.16535413e-01f, -2.44525075e-01f, -1.11286245e-01f, 2.31999815e-01f, 2.28116259e-01f, -1.42847300e-01f,
  -2.45917812e-01f, 1.11684956e-01f, -7.44557679e-02f, -5.25087640e-02f, 1.44832522e-01f, -1.96570113e-01f, -1.96564391e-01f, -2.30649605e-01f, -6.46607354e-02f, 1.02738954e-01f,
  -1.86535306e-02f, 8.31320509e-02f, 1.25008702e-01f, 6.14740476e-02f, -9.06162187e-02f, -6.86782971e-02f, -3.25022727e-01f, -2.71535814e-01f, -2.39988923e-01f, -3.87637377e-01f,
  -4.08853769e-01f, -2.29250908e-01f, -1.14789784e-01f, 3.86411622e-02f, -2.24345431e-01f, 1.06879966e-02f, -1.11624755e-01f, -6.17463067e-02f, -1.39233284e-02f, -1.70147687e-01f,
  -7.04397708e-02f, 5.25154658e-02f, -1.70183837e-01f, -1.38503507e-01f, -6.13544099e-02f, -1.90673620e-02f, -6.45145625e-02f, -7.11420551e-02f, -1.42520443e-01f, -1.32093221e-01f,
  -8.80917460e-02f, -1.00191407e-01f, -1.40321657e-01f, -1.21052757e-01f, -1.98283970e-01f, -2.00963899e-01f, -1.76573783e-01f, -2.30937883e-01f, -2.86862671e-01f, 6.85228854e-02f,
  7.92017858e-03f, -4.71436270e-02f, -3.78945358e-02f, 8.83644372e-02f, 1.74774557e-01f, -2.58974191e-02f, -1.94806661e-02f, 6.69240281e-02f, 1.97618622e-02f, 1.07150175e-01f,
  1.70839075e-02f, 1.30752334e-04f, -1.03294864e-01f, 1.02485633e-02f, -1.77257787e-02f, -1.25997886e-02f, -3.04712635e-02f, 5.89342192e-02f, -7.13684363e-03f, 2.63939369e-02f,
  1.38509262e-04f, -5.53533174e-02f, -6.50786534e-02f, -6.70548715e-03f, -1.33438408e-01f, 4.25086282e-02f, 2.68069953e-02f, 2.13992922e-03f, -1.24518899e-02f, -5.12473918e-02f,
  2.84907609e-01f, -1.91862136e-01f, 1.34051517e-01f, 2.98195779e-01f, -4.00703400e-02f, -2.14647781e-02f, -7.37388656e-02f, 4.34930027e-02f, 6.26099631e-02f, -7.33477399e-02f,
  -1.02664933e-01f, 7.05486238e-02f, -3.41823511e-02f, -1.09304428e-01f, -5.03132679e-02f, 5.49130701e-03f, 1.98962867e-01f, 1.30485460e-01f, 8.42048973e-02f, -4.63155359e-02f,
  1.60333544e-01f, 2.62753189e-01f, 3.24485570e-01f, 8.51532370e-02f, 4.56824340e-02f, 8.10825676e-02f, 6.29058704e-02f, -4.62654792e-02f, 4.60406132e-02f, 3.77528697e-01f,
  -3.69451374e-01f, -2.58756071e-01f, 2.91399509e-01f, -1.92222759e-01f, -8.69564116e-02f, -1.88735705e-02f, -2.13918444e-02f, -1.08981423e-01f, -1.87506720e-01f, -5.64148054e-02f,
  -1.45035647e-02f, 3.13353717e-01f, 2.33796448e-01f, 3.42787147e-01f, 2.85206258e-01f, 1.05522826e-01f, 3.15979458e-02f, 4.15986747e-01f, 4.17565674e-01f, 1.85705513e-01f,
  -2.69453228e-02f, -1.36647746e-01f, -1.32656947e-01f, 2.50170883e-02f, -1.51648432e-01f, 2.94714391e-01f, 2.27821749e-02f, -5.09514809e-02f, -1.65134184e-02f, -6.58388436e-02f,
  5.12950361e-01f, -2.26851001e-01f, 4.28767540e-02f, -1.48392543e-01f, -1.60368994e-01f, -1.17730081e-01f, -9.72261354e-02f, -6.63276240e-02f, -2.10514650e-01f, 1.49958460e-02f,
  -1.14963233e-01f, -5.68723045e-02f, 1.86515674e-02f, -1.66028559e-01f, -5.49028143e-02f, -4.25630109e-03f, -2.00509727e-01f, -3.98696400e-03f, -1.01174578e-01f, 8.87370668e-03f,
  -1.08928658e-01f, -1.86065659e-01f, 6.13670982e-02f, -1.04989260e-02f, -7.18702897e-02f, 1.53245162e-02f, -2.66142748e-02f, -1.14647791e-01f, -3.51354890e-02f, -4.34328541e-02f,
  2.84602810e-02f, -9.63907838e-02f, -4.95044775e-02f, 1.40599702e-02f, 9.25526991e-02f, 4.66926284e-02f, 1.35674074e-01f, 6.10923246e-02f, 1.68791076e-03f, -5.06562553e-02f,
  4.09383178e-02f, 6.38435185e-02f, 5.69598284e-03f, 4.44716550e-02f, 4.30099219e-02f, -8.50755870e-02f, -3.80620658e-02f, 1.08241977e-03f, -1.34951457e-01f, -2.16984283e-02f,
  -4.78288606e-02f, -6.54341578e-02f, -1.31510377e-01f, 4.42710221e-02f, -1.09687634e-01f, -3.53594013e-02f, 1.63898692e-02f, -4.71233809e-03f, -4.10438925e-02f, 2.79716291e-02f,
  4.39728647e-01f, 1.09397464e-01f, 2.30124444e-01f, 5.76169454e-02f, -1.16210565e-01f, -1.36834234e-01f, 6.40790910e-02f, 1.20790213e-01f, 6.05809093e-02f, 7.37096667e-02f,
  4.32015816e-03f, 3.44368652e-03f, 6.02953583e-02f, -7.42683634e-02f, -1.75916906e-02f, -8.03527236e-02f, -1.07371271e-01f, 1.61398962e-01f, -5.43817729e-02f, -2.01893635e-02f,
  -1.09060347e-01f, 7.62711614e-02f, 2.93872058e-01f, 1.70457944e-01f, 1.38553366e-01f, 4.24540818e-01f, 2.90622592e-01f, 8.12331960e-02f, 2.06879303e-01f, 2.89708711e-02f,
  4.23384339e-01f, -2.36524656e-01f, 2.54678875e-01f, 1.68241382e-01f, -2.75074720e-01f, -1.96489125e-01f, -3.41698885e-01f, -6.74557984e-02f, 9.77727100e-02f, 2.11898349e-02f,
  -4.23574820e-02f, 2.15600163e-01f, 1.33361593e-01f, 2.06197590e-01f, 2.37610444e-01f, 1.23098508e-01f, 2.57502794e-01f, 3.82076323e-01f, 2.32871264e-01f, 1.28132150e-01f,
  6.49736375e-02f, -4.49521653e-02f, 2.10247755e-01f, 1.58910349e-01f, 1.36161119e-01f, 4.60722148e-02f, -3.55452187e-02f, -3.30827273e-02f, 7.47049972e-02f, 2.70197600e-01f,
  6.96744071e-03f, 4.65891138e-02f, 4.79154885e-02f, -7.39247575e-02f, -8.13462809e-02f, -6.75371438e-02f, 1.76234879e-02f, -3.50718424e-02f, -8.19100738e-02f, -1.37940617e-02f,
  -9.48146582e-02f, -4.94215153e-02f, -4.96363826e-02f, -1.28508732e-01f, -8.98759067e-03f, -5.29007241e-02f, 1.11472823e-01f, 1.88279614e-01f, 4.13592458e-02f, -1.45902550e-02f,
  1.40462583e-02f, -1.37675973e-02f, -3.38237099e-02f, 8.93578026e-03f, 6.60301670e-02f, 3.31278443e-02f, -4.99407575e-02f, 9.60789472e-02f, 6.14422709e-02f, 9.95871723e-02f,
  1.01653360e-01f, 8.88208523e-02f, 2.65249033e-02f, 1.77311897e-02f, 3.67141291e-02f, 1.19493149e-01f, 1.24391474e-01f, -1.28151968e-01f, 7.05775246e-02f, 7.45261014e-02f,
  2.07367707e-02f, -1.15579600e-02f, 5.33416197e-02f, 1.18766993e-01f, 2.94414088e-02f, -5.36817759e-02f, 1.95200704e-02f, 5.65123670e-02f, 3.08488179e-02f, 1.43578313e-02f,
  -1.78787149e-02f, 9.46951285e-02f, -2.15235855e-02f, 9.61604416e-02f, 8.02231282e-02f, 2.65157446e-02f, -8.03182051e-02f, 8.02752841e-03f, -9.45595559e-03f, -9.73726064e-02f,
  -4.92048293e-01f, 2.14288179e-02f, 2.10617870e-01f, 9.98646319e-02f, 2.35140640e-02f, -8.08194950e-02f, 6.08933531e-03f, 4.62797135e-02f, -7.78155625e-02f, -6.44962192e-02f,
  -8.87391642e-02f, -1.90583281e-02f, -8.08391124e-02f, 7.04215616e-02f, -3.34115811e-02f, -1.23235025e-01f, -2.97405384e-02f, 9.19612404e-03f, 7.66976178e-02f, -3.60677131e-02f,
  -7.91549608e-02f, -1.06178686e-01f, -2.09059924e-01f, -1.25546917e-01f, -4.26004156e-02f, -3.73265520e-02f, -4.47459854e-02f, -1.09082088e-01f, -1.50354877e-02f, -2.36259207e-01f,
  -2.87703961e-01f, 3.49363357e-01f, 1.96525007e-02f, -4.53020334e-02f, -1.35273129e-01f, -1.52359217e-01f, 8.01355205e-03f, -7.52940029e-02f, -6.78050220e-02f, -7.49875903e-02f,
  6.18797448e-03f, -9.75270048e-02f, -5.29106259e-02f, -4.10833582e-02f, 1.36251882e-01f, 6.16436265e-02f, 1.36812687e-01f, 8.72569680e-02f, -6.85774460e-02f, -5.29891960e-02f,
  1.41945541e-01f, 1.62818447e-01f, 1.57344416e-01f, 1.97839439e-02f, -1.20947182e-01f, 5.39104547e-03f, 4.89556007e-02f, -6.33313432e-02f, 4.23648730e-02f, 4.42611799e-02f,
  2.56395668e-01f, -3.11317313e-02f, -3.26938666e-02f, 6.25840649e-02f, 7.31122121e-02f, 4.64059878e-03f, 1.17905863e-01f, 2.19200671e-01f, 1.55223802e-01f, 1.36226311e-01f,
  5.67057021e-02f, -3.13025527e-02f, 8.06385502e-02f, -3.21443900e-02f, 1.72325671e-01f, 2.88443286e-02f, -1.71516705e-02f, 8.95620324e-03f, -4.56526987e-02f, 7.70549476e-02f,
  9.25829560e-02f, -7.26198629e-02f, 4.07900363e-02f, -7.23173190e-03f, -5.72470687e-02f, -1.33402139e-01f, 8.63227621e-02f, -1.51465222e-01f, -8.34655985e-02f, 7.22211599e-02f,
  -2.89628990e-02f, -1.49830595e-01f, -1.03479609e-01f, -2.59992853e-02f, -7.58970007e-02f, 1.61176369e-01f, 4.72526103e-02f, 1.57659054e-02f, -4.17994522e-02f, 8.91132727e-02f,
  1.12047441e-01f, -3.23420577e-02f, 3.57378498e-02f, 8.95342603e-02f, -4.97931466e-02f, -1.31480366e-01f, -8.36177990e-02f, 4.68850695e-03f, 2.56524682e-02f, -1.71358548e-02f,
  -1.08861044e-01f, 1.00611478e-01f, 1.88118103e-03f, 6.66554570e-02f, 3.95790301e-02f, 1.88198164e-02f, 1.33101605e-02f, 2.76602339e-03f, -1.18234605e-01f, -3.84901580e-03f,
  5.57549477e-01f, -1.10335946e-01f, 5.93110025e-02f, -1.69730932e-01f, 1.77748948e-02f, -6.28038198e-02f, -1.43522009e-01f, 5.35890684e-02f, 7.94048980e-02f, 1.64797887e-01f,
  5.72541468e-02f, -4.72570769e-02f, 2.16746274e-02f, 1.17124468e-01f, 8.75074565e-02f, 1.08152106e-01f, -3.35543975e-02f, -1.23997398e-01f, 5.76033667e-02f, 8.63551646e-02f,
  7.66765773e-02f, -7.33564496e-02f, 4.04458679e-02f, 1.75204165e-02f, 2.98404191e-02f, 1.08287930e-01f, 5.39519265e-02f, 9.94102061e-02f, -4.66181012e-03f, 2.13255987e-01f,
  3.70612621e-01f, 3.33304927e-02f, 2.49003634e-01f, 3.10735881e-01f, -6.87730238e-02f, 1.65497199e-01f, 2.72161514e-01f, 2.23713636e-01f, 1.45648554e-01f, 2.05446586e-01f,
  -1.76757067e-01f, -6.80638775e-02f, -7.82054141e-02f, -1.22596003e-01f, 4.77177836e-02f, 2.07326174e-01f, 1.30079955e-01f, 2.10468233e-01f, 1.71681032e-01f, 1.94219008e-01f,
  -3.15343514e-02f, 2.61297319e-02f, 3.46370451e-02f, -9.11408383e-03f, 1.31850004e-01f, 1.77991856e-02f, -1.75731443e-02f, 8.88381619e-03f, 5.45709133e-02f, 2.39924535e-01f,
  1.19495310e-01f, -6.68674484e-02f, -1.36400489e-02f, -1.30717203e-01f, -1.45201832e-01f, 6.05144314e-02f, 7.95666780e-03f, -4.32457849e-02f, -9.38344523e-02f, 6.84010535e-02f,
  -1.38285637e-01f, -1.08071014e-01f, -7.70280957e-02f, -1.50818871e-02f, -3.03622149e-02f, -7.70174861e-02f, -2.11418830e-02f, 7.52145648e-02f, 8.25137869e-02f, -7.44715780e-02f,
  -8.53285119e-02f, -2.76841760e-01f, -2.31471993e-02f, -4.78738640e-03f, 2.31949240e-03f, -1.76074822e-02f, -8.38257372e-02f, 4.09731567e-02f, 4.47061807e-02f, 1.03339730e-02f,
  6.86489195e-02f, -1.03865683e-01f, 6.07708246e-02f, 9.58316848e-02f, 5.12726083e-02f, -2.25421600e-03f, 5.85166700e-02f, -1.63668506e-02f, 5.92320301e-02f, 1.37200747e-02f,
  -3.31448158e-03f, 6.93348050e-02f, 1.06747314e-01f, 1.40095994e-01f, 2.61929389e-02f, -6.61759824e-02f, 1.41223054e-02f, 2.52570994e-02f, -6.41268715e-02f, -7.59676099e-02f,
  7.57118538e-02f, 4.76263687e-02f, -1.47258714e-02f, 1.07632510e-01f, 2.81846039e-02f, 5.07763289e-02f, -1.84408762e-03f, -4.08684947e-02f, 3.48257795e-02f, 1.09779164e-01f,
  -2.19461337e-01f, -5.56809306e-01f, 1.52057648e-01f, -8.67154077e-03f, -1.50606155e-01f, -2.36828566e-01f, -9.97673795e-02f, -2.04908967e-01f, -1.43784791e-01f, -2.14441586e-02f,
  -1.34113301e-02f, -2.75056884e-02f, -1.36253998e-01f, 1.08662374e-01f, 6.40185326e-02f, 5.95174432e-02f, -2.57736474e-01f, -6.97503537e-02f, 7.38234892e-02f, -1.23048544e-01f,
  -8.66327211e-02f, 3.74534838e-02f, -2.44312696e-02f, -2.25648656e-02f, -1.51650514e-02f, 7.02261999e-02f, -1.07144125e-01f, 2.06697490e-02f, -2.84884125e-02f, 7.33272880e-02f,
  -3.27330828e-01f, 1.27777502e-01f, 1.75119475e-01f, 1.20459989e-01f, 2.48501018e-01f, -8.19573030e-02f, -1.26602337e-01f, -2.61597633e-01f, -6.36648992e-03f, 1.49427533e-01f,
  2.07138002e-01f, -7.38985538e-02f, -2.51254998e-03f, -4.44331802e-02f, -2.02107936e-01f, 1.29789844e-01f, 2.14311659e-01f, -8.96207765e-02f, -3.07820737e-01f, -7.42653534e-02f,
  5.16204275e-02f, 4.58296649e-02f, -2.54211992e-01f, -1.50259569e-01f, 1.08574174e-01f, -7.02833831e-02f, 1.67158112e-01f, 8.86506513e-02f, 7.74290115e-02f, 4.14956391e-01f,
  1.06968366e-01f, -7.67453834e-02f, -8.40928257e-02f, -8.35369155e-02f, 6.42090198e-03f, -2.48172998e-01f, -1.89910457e-02f, -7.56965503e-02f, 5.07151447e-02f, -8.02971274e-02f,
  8.47492442e-02f, -2.75847111e-02f, 1.26962349e-01f, -5.52006625e-02f, -1.91202939e-01f, -2.22168729e-01f, -1.90848149e-02f, -4.22865376e-02f, -8.62920955e-02f, -2.01613173e-01f,
  1.92497239e-01f, -3.88169065e-02f, -3.53978127e-02f, -1.37396351e-01f, -1.73959658e-01f, -1.40525892e-01f, -1.16299115e-01f, -1.63036332e-01f, -2.75564253e-01f, -1.35132760e-01f,
  -8.45000520e-02f, -1.61742941e-02f, -6.80561736e-02f, 4.29436900e-02f, -5.99200092e-02f, 7.72216916e-02f, 8.81223977e-02f, -7.88106099e-02f, 6.93104640e-02f, -1.46859325e-02f,
  5.03307097e-02f, 2.58767884e-02f, -8.12643915e-02f, 2.62689348e-02f, -4.86770645e-02f, -8.66740793e-02f, -9.69457030e-02f, -1.25755128e-02f, -1.44782603e-01f, -9.09483954e-02f,
  2.53779832e-02f, 1.45005509e-01f, -7.90148154e-02f, -1.17575321e-02f, 3.61409038e-02f, -9.91006121e-02f, -5.62680997e-02f, -1.90232694e-01f, -4.98110279e-02f, -9.35046119e-05f,
  -8.58490542e-03f, 6.44717887e-02f, -5.71350530e-02f, -6.23240583e-02f, 1.12914518e-01f, -1.15704760e-02f, 8.52326378e-02f, -8.86821300e-02f, -1.35653354e-02f, -1.73961803e-01f,
  -1.25815630e-01f, -2.57628858e-02f, 6.95756525e-02f, 2.17735972e-02f, -8.44102502e-02f, 4.91829142e-02f, -1.64735559e-02f, 9.20649692e-02f, 9.04868692e-02f, -9.61370841e-02f,
  2.96437703e-02f, -1.38958469e-01f, -1.81844607e-01f, 1.82293297e-03f, -6.61137253e-02f, -2.57742912e-01f, -1.24916971e-01f, -2.72281736e-01f, -1.86730072e-01f, -1.97834104e-01f,
  -3.81715447e-01f, -9.69532058e-02f, 2.06232555e-02f, -2.53174812e-01f, 2.44062856e-01f, 2.38059357e-01f, 6.28417373e-01f, 9.27202031e-02f, -1.35073170e-01f, 9.02698934e-02f,
  -1.69941232e-01f, -5.24767339e-01f, -4.54332650e-01f, -1.24626696e-01f, 9.05801076e-03f, 5.14761925e-01f, 3.09126168e-01f, 5.47713749e-02f, 7.29229450e-02f, 1.65194958e-01f,
  2.10981160e-01f, -3.13686617e-02f, -3.97603840e-01f, -1.32144958e-01f, -1.09746180e-01f, -6.37937859e-02f, -8.60828459e-02f, -6.97078854e-02f, 7.83225074e-02f, 6.16368540e-02f,
  1.20625533e-01f, -3.91717732e-01f, 3.67660001e-02f, -3.03913832e-01f, -1.46708325e-01f, -5.73121645e-02f, 6.03610426e-02f, -1.88966125e-01f, -2.50874639e-01f, -1.11307427e-01f,
  -9.67329741e-02f, -5.03761619e-02f, -1.76704586e-01f, 7.09823966e-02f, -4.81135137e-02f, 7.32790381e-02f, -5.54993935e-02f, -4.55034114e-02f, -2.50949174e-01f, 2.21484969e-03f,
  -4.58499752e-02f, -1.92621022e-01f, -1.68341145e-01f, 2.81453691e-02f, -1.20969154e-01f, -1.11318402e-01f, -6.61776960e-02f, -1.56389371e-01f, -2.30251610e-01f, 9.10916715e-04f,
  5.15619852e-02f, 1.59312058e-02f, -3.51144671e-02f, 1.07554905e-01f, -2.45480351e-02f, -4.29073945e-02f, 1.63415521e-02f, -1.23577770e-02f, -4.95875105e-02f, 3.06320144e-03f,
  -1.00206718e-01f, -3.13840322e-02f, 1.06825922e-02f, 1.11677777e-03f, 5.24994992e-02f, -5.88232689e-02f, 2.19133683e-02f, -2.96263453e-02f, -2.77216882e-02f, 5.32560460e-02f,
  -2.98363995e-02f, -5.63148707e-02f, -2.14981586e-02f, 9.99181718e-02f, 1.40894160e-01f, 3.48290205e-02f, -3.30263563e-02f, -9.84870642e-02f, -1.16311692e-01f, -4.21689413e-02f,
  -1.71843469e-02f, -1.06073290e-01f, 1.21902943e-01f, -5.92310093e-02f, -2.94743460e-02f, -1.63679659e-01f, 4.87031266e-02f, 3.87242390e-03f, -1.38061672e-01f, -1.26920734e-02f,
  -4.66486029e-02f, -8.38726982e-02f, -1.45328432e-01f, 1.18228972e-01f, 1.04748964e-01f, 5.52002713e-02f, 1.21991828e-01f, 1.28398016e-01f, 2.34098900e-02f, 5.10744639e-02f,
  1.21536978e-01f, 2.12173596e-01f, 8.98965672e-02f, 1.48680016e-01f, 7.20190927e-02f, 1.99045941e-01f, 1.01248436e-01f, 4.07405160e-02f, 2.21580625e-01f, 4.46614623e-01f,
  4.90437001e-01f, -9.26146731e-02f, 1.82542503e-01f, 3.36000144e-01f, 3.57203543e-01f, 4.22190994e-01f, 4.72640514e-01f, 1.45337060e-01f, 6.50941804e-02f, 1.07507057e-01f,
  -1.92892682e-02f, -2.21148640e-01f, -2.38435134e-01f, -1.97222993e-01f, -7.43948743e-02f, 1.53207153e-01f, -1.42711373e-02f, -5.67900874e-02f, -7.87973311e-03f, 4.84701172e-02f,
  -1.25191689e-01f, 2.00442791e-01f, 1.17689617e-01f, 3.41216326e-02f, -8.44820309e-03f, -8.78181774e-03f, 7.69808218e-02f, 2.86473297e-02f, -1.10990666e-01f, -3.99472535e-01f,
  -1.45511433e-01f, 2.64843643e-01f, -6.40641749e-02f, -1.31419539e-01f, -2.64548399e-02f, -4.73830216e-02f, -5.43411523e-02f, -1.14620656e-01f, -1.96082648e-02f, 2.27512158e-02f,
  -6.73592985e-02f, -4.92804870e-02f, -3.63493264e-02f, 2.07350273e-02f, -2.92818658e-02f, 4.78145666e-03f, -6.16356209e-02f, -1.12888567e-01f, -1.82496849e-02f, -1.13222145e-01f,
  -2.16744617e-01f, -9.25034881e-02f, 5.97142428e-02f, -5.89350238e-02f, -1.20546170e-01f, -9.54157710e-02f, 3.92321497e-02f, -8.72957334e-02f, 9.28796455e-02f, 1.65779628e-02f,
  8.91280919e-03f, 7.92320073e-02f, -9.15127154e-03f, -7.45672733e-02f, 7.94296637e-02f, 4.07058299e-02f, -4.34106290e-02f, -7.46655092e-02f, -4.55024012e-04f, -5.69886677e-02f,
  -1.21582061e-01f, -1.02380246e-01f, -7.84499273e-02f, 2.68310253e-02f, -5.47934324e-02f, -3.92916538e-02f, -1.03255376e-01f, -4.33180369e-02f, -4.27429052e-03f, -8.02418310e-03f,
  -4.54657339e-02f, -4.42572683e-03f, 8.42866115e-03f, -1.18260987e-01f, -2.48614829e-02f, -1.41289145e-01f, -6.37887344e-02f, -1.09229766e-01f, 1.41293067e-03f, 5.71337454e-02f,
  -2.18921855e-01f, 4.41452973e-02f, 2.05267854e-02f, -2.77697653e-01f, 1.19388932e-02f, -2.25581191e-02f, -3.12347263e-02f, -9.39561650e-02f, -1.53435403e-02f, -1.14523083e-01f,
  -6.00188076e-02f, -9.95509252e-02f, -5.37784994e-02f, 8.49390849e-02f, 1.36051774e-01f, -9.47409496e-03f, -1.07446909e-01f, 8.64326488e-03f, -1.29706468e-02f, -6.75482750e-02f,
  -8.51373281e-03f, 9.71597508e-02f, 1.14625901e-01f, 1.92284025e-02f, -5.02083637e-02f, 1.41166687e-01f, -1.00620091e-03f, -4.98637930e-02f, 1.45939410e-01f, 1.63332865e-01f,
  -2.15357110e-01f, 7.93062747e-02f, 1.20874107e-01f, 3.43875140e-01f, 3.91591430e-01f, 1.60513967e-01f, 1.22181527e-01f, -9.49765444e-02f, 1.37412166e-02f, 4.49372530e-02f,
  7.50006735e-03f, 9.50696841e-02f, 7.03781098e-02f, 1.51180178e-01f, 1.19938217e-01f, 1.36649013e-01f, 2.72235662e-01f, 1.90557539e-01f, -5.38139977e-02f, 5.12731448e-02f,
  9.14109871e-02f, 4.17032354e-02f, -1.90270003e-02f, -4.71977592e-02f, 2.26331815e-01f, -1.03741046e-02f, -3.86322848e-02f, 8.82934555e-02f, 1.90291286e-01f, 3.58260125e-01f,
  5.95622994e-02f, 3.89141999e-02f, -3.98230292e-02f, 2.52574328e-02f, -4.80319895e-02f, -1.80638149e-01f, -8.54294598e-02f, -9.67922732e-02f, -6.29186705e-02f, -4.06116694e-02f,
  -1.29519990e-02f, -5.97648248e-02f, 7.65677392e-02f, -1.03495724e-01f, 3.39816958e-02f, -1.82460234e-01f, -1.66339174e-01f, 8.95949602e-02f, 1.34453326e-01f, 2.24671885e-02f,
  1.49665296e-01f, 2.34360203e-01f, 1.36134133e-01f, -1.14445304e-02f, 9.65678506e-03f, -1.54548418e-03f, -5.48388995e-02f, 3.39431092e-02f, -1.92420200e-01f, -9.49265063e-02f,
  -2.50241458e-01f, -7.89705515e-02f, 4.04932313e-02f, -7.51375705e-02f, -4.74132672e-02f, -1.08639009e-01f, 1.19802788e-01f, 7.06083700e-02f, 8.85214433e-02f, -1.49323970e-01f,
  -3.13684866e-02f, 9.76406485e-02f, -6.70505641e-03f, -1.03831239e-01f, -9.97298136e-02f, 8.43769610e-02f, 1.12455912e-01f, 1.21614281e-02f, -6.33374378e-02f, -3.71733308e-02f,
  8.16075951e-02f, 7.78477192e-02f, -1.08350351e-01f, 5.21869361e-02f, 1.27876386e-01f, -3.69573832e-02f, -1.12475879e-01f, -1.37945592e-01f, -7.26297572e-02f, -8.98199826e-02f,
  -8.11250508e-02f, 1.27395436e-01f, 1.90821141e-02f, 1.90170899e-01f, -2.18936559e-02f, -5.51662520e-02f, 1.12043776e-01f, 2.38355204e-01f, 6.82671815e-02f, 1.05397336e-01f,
  5.39943017e-02f, -3.07497568e-02f, -9.57218483e-02f, -1.17904045e-01f, -1.93400785e-01f, -8.21988136e-02f, 5.37968501e-02f, 1.21875331e-01f, 1.45227626e-01f, 1.32866576e-01f,
  5.34125529e-02f, -1.91383418e-02f, -3.37745361e-02f, -6.86887577e-02f, -8.83797631e-02f, -7.59173110e-02f, -3.14833015e-01f, -4.15001810e-02f, -2.79521674e-01f, -4.24714655e-01f,
  -4.63100374e-01f, 3.31388593e-01f, 5.20774871e-02f, -1.96255982e-01f, 2.95270979e-01f, 2.26756096e-01f, 3.28928590e-01f, -4.50976714e-02f, -1.22042507e-01f, 1.01099506e-01f,
  2.11415067e-01f, -6.15440458e-02f, 2.75819115e-02f, -3.34418975e-02f, -1.01216182e-01f, 1.16556548e-01f, 2.07648143e-01f, -2.44901687e-01f, -3.54127645e-01f, -2.20749363e-01f,
  3.77447456e-02f, -2.10996091e-01f, -4.60168302e-01f, -1.20957457e-01f, 3.68135311e-02f, 2.41205581e-02f, 7.69478157e-02f, -3.42113785e-02f, 1.72389865e-01f, 2.82991469e-01f,
  -2.00712770e-01f, -7.27477204e-03f, -2.79857684e-02f, 4.79882471e-02f, -8.49420391e-03f, 1.18390741e-02f, 6.53360784e-02f, 7.64937475e-02f, 2.92702597e-02f, -4.99503762e-02f,
  -1.47465289e-01f, 1.88692063e-02f, 1.15497790e-01f, -2.39765700e-02f, -2.09252477e-01f, -1.24667481e-01f, -7.30569735e-02f, -1.89014956e-01f, -9.22130644e-02f, -1.47407740e-01f,
  3.16997588e-01f, 1.01661362e-01f, -1.81834713e-01f, 1.68436855e-01f, -2.48257834e-02f, -5.47093414e-02f, -5.36491796e-02f, -1.07673720e-01f, -1.00744508e-01f, -1.16861239e-01f,
  1.16448589e-01f, 3.51852290e-02f, 7.47250393e-02f, -1.51017001e-02f, -2.17019133e-02f, 1.03461899e-01f, -2.15154467e-03f, 4.85125445e-02f, 7.23399594e-02f, -4.49493527e-02f,
  1.05058305e-01f, 1.03276692e-01f, -1.13374256e-01f, 9.03281346e-02f, -6.97679371e-02f, -4.95611541e-02f, 4.80692312e-02f, 6.65326715e-02f, 2.13812501e-03f, 1.43745029e-02f,
  -1.04855672e-01f, 1.09807983e-01f, 8.06829780e-02f, -1.50616523e-02f, 4.35818285e-02f, -1.74696110e-02f, 5.58663607e-02f, 1.01935472e-02f, -2.09697589e-01f, -5.53166047e-02f,
  -2.90983170e-01f, 2.04912648e-01f, -5.55651262e-02f, 2.13697366e-02f, 1.26152590e-01f, 1.02815092e-01f, 1.73257850e-02f, 7.46689364e-02f, 1.87299270e-02f, -5.63044548e-02f,
  -1.04076572e-01f, -6.78519532e-02f, 5.16112261e-02f, 5.62183969e-02f, -1.87659070e-01f, -1.18340708e-01f, 8.53093639e-02f, -5.73692136e-02f, -2.48409845e-02f, -2.29611099e-01f,
  -8.86553247e-03f, -2.21204236e-01f, -2.77198613e-01f, 7.82467872e-02f, 1.64483879e-02f, -2.26375312e-01f, -1.18229084e-01f, -6.96906894e-02f, -2.04060674e-01f, -2.61105299e-01f,
  -1.68907166e-01f, 3.29275548e-01f, -7.45461136e-02f, -7.65721947e-02f, 1.15911521e-01f, -4.41866107e-02f, -1.74428485e-02f, -1.95671812e-01f, 1.35458037e-02f, 7.87668303e-02f,
  9.41546485e-02f, 2.12486554e-02f, 1.28537551e-01f, 8.25372264e-02f, -1.32602498e-01f, 1.78297922e-01f, 1.86962977e-01f, -5.11950515e-02f, -3.29825491e-01f, -7.58756176e-02f,
  1.16258539e-01f, -8.73924643e-02f, -1.96585923e-01f, -1.30393460e-01f, 1.91972673e-01f, -2.15873923e-02f, 3.66013832e-02f, 1.13341786e-01f, 1.36105403e-01f, 2.14483589e-01f,
  -1.03863269e-01f, -1.99891329e-01f, -1.31461322e-01f, 1.68835536e-01f, 1.43112481e-01f, -8.42645168e-02f, -2.41284147e-02f, 1.03555553e-01f, 1.18046448e-01f, 6.05428182e-02f,
  2.82225370e-01f, 1.15094617e-01f, 9.02616978e-02f, -1.45664051e-01f, 7.58666396e-02f, 5.96560501e-02f, 7.91174397e-02f, -1.66674126e-02f, -9.50824320e-02f, 1.24917394e-02f,
  3.93810332e-01f, 1.20589718e-01f, -1.08298503e-01f, -1.10559434e-01f, -1.84536785e-01f, -1.15109444e-01f, -1.11389175e-01f, -1.71467155e-01f, -2.95110703e-01f, -1.10134281e-01f,
  2.76803505e-02f, -1.13193512e-01f, -6.22207001e-02f, 2.33991388e-02f, 7.93563500e-02f, 9.49699339e-03f, 5.84856346e-02f, -1.10336401e-01f, -1.26804626e-02f, -3.99297066e-02f,
  -7.34638721e-02f, -1.64780959e-01f, 1.76461246e-02f, -9.47160423e-02f, -7.67180845e-02f, 1.94706749e-02f, -1.57912284e-01f, -1.67258251e-02f, -6.17366061e-02f, -1.48299504e-02f,
  9.02831927e-02f, -1.12822384e-01f, -1.24522038e-02f, -1.04637519e-01f, -8.96186605e-02f, -8.45744088e-02f, -1.08800612e-01f, -1.58445641e-01f, -5.09326160e-03f, -5.56739643e-02f,
  -1.18209675e-01f, 6.71668574e-02f, 3.19078416e-02f, 6.42848061e-03f, -8.29086080e-02f, 1.58860072e-01f, -5.92522845e-02f, -1.03766518e-02f, -6.56795502e-02f, -6.41786074e-03f,
  6.36377633e-02f, -6.05929755e-02f, 7.35985190e-02f, -7.52252787e-02f, 4.32725064e-02f, -3.18720713e-02f, 1.25977755e-01f, -9.30269882e-02f, -1.26746789e-01f, 4.47643772e-02f,
  -1.65271629e-02f, -2.05082193e-01f, -1.49327636e-01f, -3.49178687e-02f, -1.46951869e-01f, -1.42137036e-01f, -2.66046643e-01f, -1.91545978e-01f, -3.01203132e-01f, -2.47841164e-01f,
  -4.05973464e-01f, -1.05898343e-01f, -3.13174009e-01f, 1.04252219e-01f, 1.08483821e-01f, -3.25707868e-02f, 6.70310035e-02f, 1.31799757e-01f, 1.58512309e-01f, -1.09807532e-02f,
  -1.94472641e-01f, -8.74469504e-02f, -6.38096333e-02f, 5.84407374e-02f, 3.32040377e-02f, 1.60952628e-01f, 2.39093930e-01f, -2.80981567e-02f, -8.76001045e-02f, 6.43283278e-02f,
  1.92955881e-01f, 1.30677834e-01f, -1.39222354e-01f, 2.53151119e-01f, 3.88874948e-01f, 4.06609327e-01f, 2.02103242e-01f, 1.75366744e-01f, 2.13964999e-01f, 3.96472514e-01f,
  -6.24244034e-01f, -3.00245196e-01f, 9.75803211e-02f, -7.89477229e-02f, -1.77659184e-01f, -1.56716660e-01f, -1.32035032e-01f, -1.40729398e-01f, -1.69374526e-01f, -1.63175970e-01f,
  -2.29774296e-01f, -1.99979961e-01f, 5.73055819e-03f, -6.25228062e-02f, -1.23331331e-01f, -5.61209433e-02f, 6.78260326e-02f, -1.31426603e-01f, -8.07440430e-02f, -2.73541268e-02f,
  1.13006480e-01f, -1.57638155e-02f, -1.62828118e-01f, 1.56804740e-01f, -5.93035296e-02f, -9.85801592e-02f, 8.14953744e-02f, 6.65016770e-02f, 1.45617068e-01f, 2.09964588e-01f,
  2.76656579e-02f, -1.13608576e-01f, -6.17028847e-02f, -1.95570886e-02f, 6.53160065e-02f, -2.95861587e-02f, 3.58863026e-02f, 6.76306859e-02f, 1.38701908e-02f, 1.18641743e-04f,
  -2.74900328e-02f, 6.05620965e-02f, 1.11809425e-01f, -2.30218675e-02f, 5.87589853e-02f, -1.59458518e-02f, 2.77386210e-03f, 1.84705615e-01f, 9.36510712e-02f, -4.31977212e-02f,
  -2.16340907e-02f, 5.26476279e-02f, 5.42848429e-04f, 1.33061662e-01f, 9.29613784e-02f, 1.65854931e-01f, 3.34735122e-03f, 8.39710468e-04f, -7.92011544e-02f, -5.64389192e-02f,
  -2.15299368e-01f, -7.98412599e-03f, 6.19119629e-02f, 7.49586299e-02f, -1.31527752e-01f, -9.18189362e-02f, -7.60092512e-02f, -1.26475021e-01f, -2.41155565e-01f, -1.32142186e-01f,
  -2.15235412e-01f, -4.61994857e-02f, -5.81054874e-02f, -8.37541372e-02f, -1.79875363e-02f, -3.11547075e-03f, 8.08245838e-02f, 8.27809982e-03f, -8.66145361e-03f, -1.60661399e-01f,
  3.70730981e-02f, 1.62278578e-01f, -1.11828119e-01f, 4.39039096e-02f, 1.33992597e-01f, 7.06282258e-02f, -7.46644661e-02f, -3.41913942e-03f, 2.30353493e-02f, 1.39330924e-01f,
  3.74127775e-01f, 4.14463699e-01f, 2.14949384e-01f, 1.83907792e-01f, 1.26037180e-01f, -6.66028559e-02f, -5.89250354e-03f, -2.19667315e-01f, -2.09930643e-01f, 1.45032369e-02f,
  1.93928212e-01f, -2.28559226e-01f, -1.00194760e-01f, -2.02273980e-01f, -2.25828409e-01f, -4.12802994e-02f, 6.95559457e-02f, -1.14353679e-01f, -4.36962932e-01f, -3.52159709e-01f,
  -1.38016835e-01f, -2.60411352e-02f, -1.06563076e-01f, -1.90425426e-01f, 1.89350277e-01f, -1.33402586e-01f, 2.11029604e-01f, 7.84419775e-02f, 7.94717148e-02f, 2.37291589e-01f,
  1.92408562e-01f, 2.53117085e-01f, -3.50227565e-01f, -1.37746066e-01f, 6.88599199e-02f, -6.99827895e-02f, -1.22608431e-01f, -3.79099846e-02f, 3.00861783e-02f, 1.04272358e-01f,
  9.45243910e-02f, -1.94439590e-02f, 1.67872325e-01f, -1.86204582e-01f, 1.19396653e-02f, -1.09962188e-01f, -6.83908015e-02f, -8.65231827e-02f, -9.27970782e-02f, 6.48974702e-02f,
  4.65403944e-02f, 1.90070555e-01f, 2.64837503e-01f, -1.26761317e-01f, 8.29979219e-03f, -4.65419795e-03f, 1.22906521e-01f, 1.75094616e-03f, -8.27621445e-02f, -5.29605001e-02f,
  -7.10459948e-02f, 2.23180912e-02f, -2.54568923e-02f, 5.81502467e-02f, 3.64571926e-03f, -7.02120224e-03f, -4.32799160e-02f, -5.74148111e-02f, -1.56798631e-01f, -6.19916990e-02f,
  -9.90579836e-03f, 3.36492760e-03f, 8.04027468e-02f, 7.28945956e-02f, -4.56163026e-02f, 1.68949142e-01f, -1.04953915e-01f, -7.00684488e-02f, 7.47709572e-02f, 1.47472369e-02f,
  -1.34942174e-01f, 8.27395245e-02f, -1.87215880e-02f, -1.44110918e-01f, 8.52555260e-02f, 4.94797118e-02f, 3.01664583e-02f, -1.21324122e-01f, -3.33938785e-02f, 6.66980371e-02f,
  -6.89714104e-02f, -4.08353470e-03f, 1.04144387e-01f, -1.64986685e-01f, -9.60927680e-02f, -6.30114824e-02f, 7.40780681e-02f, -9.70276222e-02f, 4.25680839e-02f, 1.16839129e-02f,
  4.74473350e-02f, 5.67958876e-02f, 3.87971010e-03f, -5.84491268e-02f, -1.85362458e-01f, -3.67448851e-02f, -3.21589895e-02f, -1.10744432e-01f, -1.34025395e-01f, 1.19172953e-01f,
  -8.41044113e-02f, -1.97435215e-01f, -1.77088991e-01f, -3.36930305e-02f, -2.77437293e-03f, -2.32502133e-01f, -1.36981830e-01f, -2.01601669e-01f, -1.39512777e-01f, -1.20136119e-01f,
  3.16176802e-01f, -5.06869078e-01f, 2.31862634e-01f, 2.41959199e-01f, 2.46894240e-01f, 4.29010063e-01f, 2.25203440e-01f, 2.59771049e-01f, 2.44010210e-01f, -5.84676191e-02f,
  -1.99360549e-01f, -6.59712180e-02f, -6.40940219e-02f, -4.91032600e-02f, -7.25237355e-02f, 1.78446993e-01f, 2.34398052e-01f, 1.87136009e-01f, 1.96225211e-01f, 2.39131048e-01f,
  2.41432898e-02f, 5.04212780e-03f, -1.37703702e-01f, 4.06794176e-02f, -7.69145265e-02f, 4.92809266e-02f, -3.73691544e-02f, -1.25018179e-01f, -1.89120293e-01f, -2.14609161e-01f,
  -4.27138299e-01f, -2.59577423e-01f, 1.55556843e-01f, -8.84233043e-02f, -8.58043730e-02f, 3.98189016e-02f, -5.36952429e-02f, 3.11103389e-02f, 2.88708182e-03f, -6.16463795e-02f,
  -1.19714841e-01f, -1.49994701e-01f, 2.34910822e-03f, 6.50548041e-02f, 9.44032222e-02f, -1.93158984e-02f, 2.84782108e-02f, 1.22229993e-01f, 1.08959265e-02f, -1.00296102e-01f,
  -8.59794319e-02f, 3.55308577e-02f, 9.15912762e-02f, 8.97852033e-02f, 2.08591476e-01f, 1.21484861e-01f, 1.64975375e-02f, 8.00959542e-02f, 2.22839862e-01f, 1.17652290e-01f,
  -8.88816416e-02f, 1.13047525e-01f, 7.14292154e-02f, -2.85043810e-02f, 8.66525248e-02f, 6.01427257e-02f, 5.98838776e-02f, -6.55982941e-02f, 1.31889895e-01f, -2.71112658e-02f,
  8.46259296e-02f, -7.84137286e-04f, 7.35742450e-02f, -4.40353490e-02f, -1.62921295e-01f, -8.78159106e-02f, 4.14393395e-02f, -1.16240241e-01f, -1.33930460e-01f, 9.76687819e-02f,
  5.12545370e-02f, 1.78193599e-02f, -2.21854419e-01f, -8.03755373e-02f, -4.22399603e-02f, 6.20183609e-02f, -1.20623827e-01f, -3.25398333e-02f, -1.38714045e-01f, -2.00619567e-02f,
  -1.27934208e-02f, -1.54310092e-01f, 3.13005112e-02f, -8.18133280e-02f, 5.72462119e-02f, -1.69911563e-01f, -3.86190750e-02f, -5.82390018e-02f, -1.75894648e-02f, 5.31935552e-03f,
  -1.06644727e-01f, -8.47948939e-02f, -1.41331598e-01f, -3.32563976e-03f, 8.28474537e-02f, 8.05937219e-03f, -1.19805997e-02f, 1.14075147e-01f, 5.32427728e-02f, -1.41058505e-01f,
  -1.01323523e-01f, 1.94420546e-01f, 4.94825915e-02f, 1.44670680e-01f, 5.01378402e-02f, 1.32510513e-01f, 3.43321450e-03f, 5.79380468e-02f, 7.15620741e-02f, 2.05701500e-01f,
  4.70991611e-01f, -2.72477299e-01f, 3.84923846e-01f, -2.01041535e-01f, -5.84898710e-01f, -4.70688850e-01f, -5.77417850e-01f, -1.11649364e-01f, -1.45341545e-01f, -3.15273881e-01f,
  -2.61739850e-01f, -1.21569768e-01f, -2.19957740e-03f, 2.71396160e-01f, 3.56038272e-01f, 2.36461628e-02f, 1.91882476e-01f, 5.65043390e-01f, 5.02309442e-01f, 4.92174504e-03f,
  -1.91041365e-01f, 2.23986506e-01f, 5.00195622e-01f, 3.96073520e-01f, -1.36598170e-01f, -5.54815494e-02f, 6.46291301e-02f, -4.60707396e-02f, -7.57787600e-02f, 1.64279982e-01f,
  1.54769085e-02f, 9.79493484e-02f, 1.10373214e-01f, -2.68303361e-02f, -1.13994302e-03f, 1.53516144e-01f, 4.37603928e-02f, 9.37475637e-02f, -3.06050051e-02f, 3.29293460e-02f,
  -8.31875354e-02f, 1.23723783e-01f, 3.50959077e-02f, 3.45754414e-03f, -1.36853099e-01f, 5.57127930e-02f, 9.81506035e-02f, 1.83331564e-01f, 9.58370976e-03f, 2.72210166e-02f,
  -2.27940112e-01f, -2.78350800e-01f, -1.23055242e-01f, -2.25053988e-02f, 1.83043275e-02f, -1.02887684e-02f, -6.08185083e-02f, -7.70666497e-03f, 4.23966870e-02f, -7.10657286e-03f,
  -3.88157368e-02f, -3.17075774e-02f, -1.10529244e-01f, -9.40735862e-02f, -4.70696911e-02f, -2.42674090e-02f, -4.85000536e-02f, -9.06680822e-02f, 1.86587572e-02f, 9.05731022e-02f,
  -1.11384802e-01f, -9.91677791e-02f, -1.74875204e-02f, -3.06011550e-02f, 4.10546437e-02f, -3.75472195e-02f, -8.28142613e-02f, 1.18889939e-02f, 1.76648460e-02f, -4.26858179e-02f,
  6.42310530e-02f, 1.78605020e-02f, 6.75445376e-03f, 1.54517349e-02f, 8.08030739e-03f, -3.21902186e-02f, 2.74194404e-02f, -2.73687532e-03f, -9.32900384e-02f, -1.04573101e-01f,
  -3.77871096e-01f, 1.28552437e-01f, 1.19794294e-01f, 8.46714303e-02f, 4.39602435e-02f, 6.47080913e-02f, -4.44808006e-02f, 3.56804356e-02f, -7.39217699e-02f, 4.79880571e-02f,
  -9.82181206e-02f, 1.54604837e-01f, 5.09964153e-02f, 9.62068811e-02f, 6.99524954e-02f, -4.21637446e-02f, 7.42773665e-03f, 1.55833028e-02f, 3.44347842e-02f, -1.58654321e-02f,
  -5.14646322e-02f, -1.27694577e-01f, -1.67444557e-01f, -1.82147503e-01f, -2.37488430e-02f, 6.04172284e-03f, -1.00302234e-01f, -1.10631548e-02f, -2.31464710e-02f, -2.46273056e-01f,
  -3.89153570e-01f, -2.88481921e-01f, -6.30795538e-01f, -3.59948963e-01f, -5.46732068e-01f, -2.78383464e-01f, -3.36281687e-01f, -7.49507174e-02f, -2.08292659e-02f, -3.77662033e-01f,
  -1.69422597e-01f, 2.12184545e-02f, -1.95199717e-02f, -1.52821779e-01f, -2.38524184e-01f, -5.15223801e-01f, -4.84330297e-01f, -3.24709594e-01f, -2.43166581e-01f, -1.80640891e-01f,
  -2.67462224e-01f, -3.29917967e-01f, -2.49923140e-01f, -1.09335154e-01f, -1.06511161e-01f, -4.49371450e-02f, -3.05008233e-01f, -1.62016943e-01f, -2.39271864e-01f, -3.95307541e-01f,
  -2.12851554e-01f, 5.53974696e-03f, 1.32745221e-01f, 1.43528730e-01f, -1.04718491e-01f, 6.88277185e-02f, -4.13724892e-02f, 2.31504608e-02f, 9.85869318e-02f, -4.07222882e-02f,
  9.38709155e-02f, 1.19020842e-01f, -1.81172800e-03f, 4.00882103e-02f, -9.99107659e-02f, 1.69247538e-02f, 1.42844468e-01f, -2.34357687e-03f, -5.44255637e-02f, 1.39448434e-01f,
  7.93936923e-02f, -1.03536504e-03f, 1.08762287e-01f, 1.53547660e-01f, 2.35428527e-01f, 1.23472326e-01f, 1.19533479e-01f, 2.47812063e-01f, 1.32354945e-01f, 1.47642314e-01f,
  -1.25005707e-01f, 2.87722107e-02f, -7.61192963e-02f, -1.10447906e-01f, -4.42375094e-02f, 3.22464481e-02f, -4.29808944e-02f, -1.69042256e-02f, 3.45559791e-04f, -6.64477050e-02f,
  9.34651936e-04f, -9.37131941e-02f, 4.65627499e-02f, 3.37539576e-02f, 7.59528065e-03f, 1.86419813e-03f, -7.42876437e-03f, 1.39729558e-02f, 6.23007640e-02f, 1.51960805e-01f,
  -3.04646399e-02f, 1.40207112e-01f, -4.96625062e-03f, 4.24419856e-03f, -1.52542308e-01f, -2.96847466e-02f, 1.02634236e-01f, 2.66257618e-02f, 7.17456266e-02f, 1.15768239e-01f,
  1.29660647e-02f, -2.69397885e-01f, -1.15282916e-01f, 1.94124371e-01f, -7.29184598e-02f, 8.41329992e-02f, 1.06523279e-02f, 1.09722011e-01f, 3.13515514e-02f, -8.20441078e-03f,
  1.36022687e-01f, 4.42430712e-02f, -8.11038259e-03f, 5.49691059e-02f, -5.81507348e-02f, -1.11271925e-01f, 3.68463062e-02f, -8.84695873e-02f, 5.72358891e-02f, 4.11592275e-02f,
  1.08020455e-01f, 1.14351183e-01f, 2.36929255e-03f, 1.89855993e-01f, 8.59340876e-02f, 1.67372003e-02f, -3.24672237e-02f, 1.63502365e-01f, -6.00100011e-02f, -3.19966115e-02f,
  -5.05941689e-01f, -6.31106347e-02f, -2.19534412e-01f, -6.20998085e-01f, -1.44332141e-01f, 2.11648673e-01f, 1.46511823e-01f, 2.48839229e-01f, -4.82632555e-02f, -1.35138884e-01f,
  -5.62400483e-02f, -1.48717701e-01f, -3.92165571e-01f, 3.48489992e-02f, 2.47633904e-02f, -1.30913168e-01f, -3.60889912e-01f, -2.46655360e-01f, 2.43059695e-01f, 3.58580530e-01f,
  1.77205741e-01f, -2.01054394e-01f, -2.39399448e-01f, -1.19259737e-01f, -2.37767547e-01f, -3.12787920e-01f, -4.39797401e-01f, -2.81689674e-01f, -1.50944471e-01f, -4.26946551e-01f,
  -1.22314632e-01f, 3.61971445e-02f, 8.39242935e-02f, -2.15668857e-01f, -2.35934332e-01f, 8.24446697e-03f, -1.30979896e-01f, -1.29342467e-01f, -5.33786044e-02f, -6.70079365e-02f,
  -1.36720017e-01f, 7.76021034e-02f, -2.11434677e-01f, 2.14923933e-01f, -1.13381959e-01f, 9.59332809e-02f, -1.25709560e-03f, -1.00499326e-02f, -2.16762386e-02f, 2.29315206e-01f,
  5.10916784e-02f, -7.06805587e-02f, -2.64416277e-01f, 4.82212529e-02f, 1.75182372e-01f, -1.08265541e-01f, 2.44887695e-01f, 1.97356313e-01f, -4.44133729e-02f, -1.65921777e-01f,
  1.49961829e-01f, -8.76767561e-03f, 6.07364774e-02f, 1.08253144e-01f, 4.03319299e-02f, 1.56120248e-02f, -1.06602602e-01f, -5.28122261e-02f, 2.87676305e-02f, -4.12261225e-02f,
  8.12227577e-02f, 1.36170149e-01f, 7.27643892e-02f, -1.99400693e-01f, -1.02947623e-01f, -1.13921715e-02f, 5.40738292e-02f, -7.06136003e-02f, -1.78375430e-02f, -5.11240363e-02f,
  -6.07358702e-02f, -9.86370891e-02f, -4.06373478e-02f, 1.08804598e-01f, 2.55909225e-04f, -7.25735426e-02f, 6.87927753e-02f, 1.95689276e-01f, 5.09636141e-02f, 1.57240212e-01f,
  -3.08867604e-01f, 1.33139491e-01f, -2.26947516e-01f, -1.13734147e-02f, -1.27200499e-01f, -3.82759236e-02f, -2.28380039e-01f, 6.87553585e-02f, -7.09953532e-02f, -9.93285701e-02f,
  2.27246270e-01f, -5.64922243e-02f, -1.22912586e-01f, 2.37636268e-01f, 5.30530922e-02f, -1.01387188e-01f, -4.98461872e-02f, -2.32023790e-01f, 1.05328940e-01f, 1.86705559e-01f,
  4.85149287e-02f, -6.58570603e-02f, -2.82396138e-01f, -1.09081976e-01f, -8.42583179e-02f, -1.90486595e-01f, -1.22598723e-01f, 5.86614646e-02f, -2.61672080e-01f, -2.03201845e-01f,
  7.79938042e-01f, 5.35078764e-01f, 1.73598200e-01f, 1.04898788e-01f, 1.03271231e-01f, 2.51216501e-01f, 5.14319777e-01f, 3.03487897e-01f, 9.43835378e-02f, 1.74681351e-01f,
  1.56645671e-01f, -1.26312301e-01f, -3.05516571e-02f, -1.41414925e-01f, 1.85388744e-01f, 7.35548586e-02f, 4.63889688e-02f, 1.18542261e-01f, 4.49747965e-02f, 7.19628260e-02f,
  8.34293216e-02f, 1.23004541e-01f, 1.70697406e-01f, 1.45308465e-01f, 7.70568550e-02f, -4.53223959e-02f, 1.12006910e-01f, 1.59254625e-01f, 4.30024303e-02f, 1.09998658e-01f,
  -1.94833398e-01f, 4.42474991e-01f, -2.11742759e-01f, 8.92888755e-02f, -1.01505835e-02f, -5.36815487e-02f, -1.36590153e-01f, -1.96148455e-02f, 4.61612865e-02f, 7.52921915e-03f,
  2.79905945e-02f, -1.94374453e-02f, 2.18911679e-03f, -1.02055520e-01f, -1.77542381e-02f, 3.97559702e-02f, 3.52557749e-03f, -2.18790006e-02f, -1.34849608e-01f, -5.38815511e-03f,
  -5.47476709e-02f, -2.93107387e-02f, -6.84720278e-03f, -1.47489727e-01f, -1.21878438e-01f, -1.80665895e-01f, 8.64898860e-02f, -5.63993901e-02f, -1.09997310e-01f, 9.48137119e-02f,
  -1.30476177e-01f, 7.41669089e-02f, 8.59032124e-02f, 1.40305841e-03f, -1.45831369e-02f, -3.39950845e-02f, -1.00315638e-01f, 4.05161502e-03f, 7.50119910e-02f, 3.06885373e-02f,
  -1.47148103e-01f, -1.55400947e-01f, 2.18910929e-02f, -1.69635430e-01f, -1.03586823e-01f, -3.46232951e-02f, 6.79886993e-03f, 3.55543494e-02f, -1.11260891e-01f, -1.46650404e-01f,
  -1.06393220e-02f, -3.53537053e-02f, -1.56540610e-02f, -4.98519242e-02f, -7.36130998e-02f, -1.41603455e-01f, -3.88928168e-02f, -2.33656839e-02f, -2.23656949e-02f, 6.13496378e-02f,
  -4.38142926e-01f, -2.89407045e-01f, -1.68996543e-01f, 5.23404665e-02f, 4.57382724e-02f, 8.43982249e-02f, -1.35755427e-02f, -1.43327322e-02f, 1.36882123e-02f, 4.45833802e-03f,
  1.86797649e-01f, -6.54870421e-02f, 7.09585920e-02f, 2.01839209e-03f, -4.40819673e-02f, -1.15010500e-01f, 1.75893493e-03f, 1.05486296e-01f, -1.72196701e-02f, -3.92365269e-02f,
  1.13230981e-02f, 4.13679034e-02f, -1.65235810e-02f, -3.24028805e-02f, -7.44563118e-02f, -2.32964054e-01f, -9.01867077e-02f, 1.53959822e-02f, -1.27876565e-01f, 6.50219619e-02f,
  -5.19903302e-01f, -8.37232471e-02f, -3.15633893e-01f, 9.61268619e-02f, 1.28873020e-01f, -4.58993614e-02f, -1.63938284e-01f, -1.64091103e-02f, 8.62947777e-02f, 8.96188840e-02f,
  8.00835639e-02f, 1.95027828e-01f, 1.06658600e-01f, 1.11941189e-01f, 1.53147848e-02f, -2.52724756e-02f, 8.45631212e-02f, -4.12432551e-02f, -2.10598662e-01f, -5.83772659e-02f,
  8.39145388e-03f, -9.70248207e-02f, -4.58818786e-02f, 8.28093588e-02f, 1.90466926e-01f, 1.70726776e-01f, 1.06844530e-01f, 2.26763278e-01f, 1.64599076e-01f, 3.68396014e-01f,
  9.63087846e-03f, 3.22100846e-03f, 1.14271611e-01f, 8.40633139e-02f, 3.43725085e-02f, -1.09978803e-02f, -3.00174416e-03f, 4.65564467e-02f, -7.50217028e-03f, -4.14831638e-02f,
  9.13355425e-02f, -1.01059720e-01f, -5.03530465e-02f, -5.52212596e-02f, -1.72014406e-03f, -1.19070143e-01f, -5.76941408e-02f, 5.05851544e-02f, 1.43361554e-01f, 5.24683706e-02f,
  2.05850556e-01f, 1.17153227e-02f, 1.14478931e-01f, -3.10907548e-04f, 8.13577250e-02f, 1.85597524e-01f, 1.65410027e-01f, 1.14208721e-01f, 2.30299011e-01f, 2.33469099e-01f,
  1.85817242e-01f, 3.89168859e-02f, -4.28228732e-03f, -6.07592352e-02f, -4.57305759e-02f, -1.20883979e-01f, -8.37777480e-02f, -4.49884236e-02f, -2.53590643e-02f, -1.10398225e-01f,
  -5.74974343e-03f, -3.10557596e-02f, -8.04877728e-02f, -3.68105210e-02f, 5.87171316e-02f, 4.40843813e-02f, -1.09130815e-01f, -2.52378676e-02f, 1.02641582e-02f, 1.47884235e-01f,
  3.08983177e-02f, -3.61424573e-02f, -6.73467666e-02f, 9.32205543e-02f, 8.93917605e-02f, 8.48697796e-02f, 2.97100861e-02f, 3.43868844e-02f, -7.08810762e-02f, 1.66089758e-01f,
  1.42465904e-01f, 8.68621841e-02f, -2.60510519e-02f, 1.45710617e-01f, -3.55657712e-02f, -2.63065714e-02f, 2.02471372e-02f, -4.47158106e-02f, -3.68710682e-02f, -1.87147669e-02f,
  5.09861410e-02f, -1.36646718e-01f, -4.28406447e-02f, -8.48398730e-02f, -1.51009530e-01f, -1.59892023e-01f, 9.70259011e-02f, 3.95399816e-02f, 1.26842454e-01f, 8.98305252e-02f,
  2.11473815e-02f, 8.42218399e-02f, 1.06245105e-03f, -1.02340765e-01f, -3.77110839e-02f, 3.31566632e-02f, -1.01678200e-01f, 9.00994167e-02f, -4.27589193e-02f, -1.56825468e-01f,
  -1.14509746e-01f, -2.54743159e-01f, -1.47202715e-01f, 3.66267860e-01f, 2.28354514e-01f, -1.01031139e-01f, -2.32515693e-01f, -8.47019926e-02f, 2.09493369e-01f, 6.38073757e-02f,
  2.36050978e-01f, 3.52227539e-01f, 3.15854371e-01f, 2.63490826e-01f, -4.24794219e-02f, -3.16568427e-02f, 2.60519803e-01f, 1.77190930e-01f, 3.84792015e-02f, 1.61206409e-01f,
  2.43423507e-01f, 1.98784918e-01f, 1.28504574e-01f, 1.57813281e-01f, 2.86792397e-01f, 3.11596632e-01f, 4.52018678e-02f, -1.58228837e-02f, -7.80902430e-03f, 2.53934324e-01f,
  -1.56691700e-01f, -1.38749093e-01f, 2.32479066e-01f, 3.11573911e-02f, 1.30888164e-01f, -1.14637688e-01f, -6.99055046e-02f, -7.95949474e-02f, -2.15141475e-02f, 2.91735884e-02f,
  1.19016968e-01f, -5.57697043e-02f, 1.47649407e-01f, -3.75028513e-03f, -6.73601404e-02f, -2.62729786e-02f, 3.82599495e-02f, -6.82617128e-02f, -5.35517745e-02f, -4.52972315e-02f,
  3.47564965e-01f, 1.17578611e-01f, -1.64634496e-01f, -1.40910313e-01f, -1.56468466e-01f, 1.29208311e-01f, -1.34111330e-01f, -8.23161155e-02f, -2.12337375e-01f, -3.61122005e-03f,
  2.25194588e-01f, 6.39522895e-02f, 8.15053135e-02f, 8.20068195e-02f, 1.78351939e-01f, 2.00561658e-02f, 5.87872565e-02f, 6.78421259e-02f, 1.40127940e-02f, -4.81026098e-02f,
  3.39130796e-02f, -2.15966683e-02f, 8.61876179e-04f, -9.88928974e-03f, 1.42573506e-01f, -9.09409523e-02f, 2.32348628e-02f, 1.84852391e-01f, 7.59998038e-02f, -3.39162955e-03f,
  2.31271461e-02f, -6.53331429e-02f, 6.11319765e-02f, 2.45018844e-02f, -5.53345941e-02f, 1.15355970e-02f, -2.29564216e-03f, -5.51390201e-02f, 2.81662457e-02f, 2.88480483e-02f,
  -1.66644529e-01f, -5.00885881e-02f, 1.56555891e-01f, -7.42081404e-02f, -2.22363286e-02f, -1.16518633e-02f, 6.58697635e-02f, 2.46606432e-02f, 1.42315244e-02f, -5.17725497e-02f,
  -1.20870776e-01f, 1.11474916e-02f, -1.09507125e-02f, -1.09012634e-01f, 5.20669967e-02f, 3.35154794e-02f, -7.80500297e-04f, -3.94562781e-02f, -9.94701535e-02f, -1.34941593e-01f,
  -4.18020859e-02f, -2.73755580e-01f, -1.60659850e-01f, -2.06394225e-01f, -9.09613743e-02f, 1.68742403e-01f, -1.46614283e-01f, -2.03969195e-01f, -2.38172323e-01f, -3.20311755e-01f,
  3.98556173e-01f, -7.33469188e-01f, 1.55935764e-01f, 1.52689189e-01f, 2.45547101e-01f, 2.04472288e-01f, -1.39722135e-02f, 7.56132901e-02f, 1.19517528e-01f, -1.56115100e-01f,
  -3.92618418e-01f, -2.34090030e-01f, -2.97082454e-01f, -1.79581538e-01f, 4.54343529e-03f, 4.18267259e-03f, 2.07798883e-01f, 3.16463947e-01f, 3.88998687e-01f, 1.25084579e-01f,
  -1.04534008e-01f, -6.88357353e-02f, 7.86214173e-02f, 4.26849611e-02f, -8.77561942e-02f, 1.21331677e-01f, -4.46786545e-02f, -3.34991738e-02f, -1.85218006e-01f, -1.17105007e-01f,
  -1.55630792e-02f, -3.42696011e-02f, 8.80712867e-02f, -1.87036961e-01f, -1.68060303e-01f, 3.06881536e-02f, -1.55754685e-02f, -5.48672415e-02f, -5.19889221e-02f, -4.02995870e-02f,
  -5.57914786e-02f, -3.90046276e-02f, 2.33507864e-02f, -6.30487576e-02f, 2.02001166e-02f, 1.22383088e-02f, 7.90897943e-03f, -2.35783290e-02f, -1.75465897e-01f, -1.40302151e-01f,
  -2.05138445e-01f, 1.33405598e-02f, 1.37337565e-01f, 3.53145748e-02f, -3.72151961e-03f, 1.19845122e-01f, -8.57828781e-02f, 1.70001965e-02f, 9.29086506e-02f, 1.48798367e-02f,
  -5.10383211e-02f, -1.23998024e-01f, 1.60226747e-01f, -3.86731960e-02f, 9.31236371e-02f, 2.57335864e-02f, 6.77708238e-02f, 4.98911105e-02f, 2.23635398e-02f, 9.00635049e-02f,
  5.13175689e-02f, 8.48233700e-02f, -5.70737235e-02f, -9.42365360e-03f, -4.25771028e-02f, 5.53381816e-02f, 1.10527590e-01f, -8.26988444e-02f, -1.67286843e-02f, 1.14140694e-03f,
  8.78524333e-02f, 1.24068052e-01f, 6.70183450e-02f, 4.93007945e-03f, -2.84749139e-02f, 3.81583497e-02f, 3.15480381e-02f, -1.15432115e-02f, 2.92974953e-02f, 3.31996456e-02f,
  -2.88500518e-01f, 1.33440748e-01f, 8.77017155e-02f, -4.81609665e-02f, 9.24970657e-02f, -1.48102241e-02f, -1.68014672e-02f, -6.22239858e-02f, -8.98840427e-02f, -2.48762295e-02f,
  1.40992969e-01f, 9.70807970e-02f, -6.20370582e-02f, 5.75405881e-02f, 2.62896955e-01f, 9.33192670e-02f, -6.53680712e-02f, -9.00940895e-02f, -1.22023128e-01f, -1.56445771e-01f,
  -1.23335831e-01f, 1.06903598e-01f, 1.80784196e-01f, 1.69067338e-01f, 1.48204744e-01f, 3.02624077e-01f, 1.32911876e-01f, 1.45080104e-01f, 2.75441200e-01f, -2.40872558e-02f,
  3.12815905e-01f, 2.23224968e-01f, 1.93687037e-01f, 1.43088311e-01f, 1.18715078e-01f, 2.55315721e-01f, 4.98905063e-01f, 1.25736564e-01f, -6.39821589e-02f, 1.18159190e-01f,
  4.26720642e-02f, -1.46619886e-01f, -1.18353352e-01f, -2.04129070e-01f, 1.65820550e-02f, 3.95781770e-02f, 6.46633357e-02f, 1.14858663e-02f, -9.85039771e-02f, -2.48206221e-02f,
  -5.06288595e-02f, 1.13432355e-01f, 1.40148923e-01f, -2.85525974e-02f, 1.88817419e-02f, -2.30157793e-01f, 1.06434368e-01f, 1.24747224e-01f, 1.37341961e-01f, -4.07124497e-02f,
  1.21111996e-01f, 5.07436991e-01f, -3.07925135e-01f, -1.53650701e-01f, 2.69333180e-02f, -2.38505453e-02f, -9.39927399e-02f, -6.47258013e-02f, -6.94961846e-02f, 4.56425473e-02f,
  2.28772294e-02f, 8.71786568e-03f, 1.99628949e-01f, 7.61338025e-02f, 1.49431512e-01f, 7.21865594e-02f, 4.84471545e-02f, 3.02903634e-02f, -5.44649176e-02f, 1.00709818e-01f,
  6.98084086e-02f, 1.71167508e-01f, 2.62294888e-01f, 7.40473121e-02f, 1.39253870e-01f, 2.93563846e-02f, 1.72015131e-02f, 2.99270712e-02f, -7.17783272e-02f, 4.29435894e-02f,
  2.25128494e-02f, 7.81445801e-02f, 1.57384668e-03f, 9.05529931e-02f, 9.32785645e-02f, 5.93716651e-02f, 8.15213099e-02f, 2.89887860e-02f, 8.25544223e-02f, 1.30463138e-01f,
  5.17918468e-02f, -4.06689309e-02f, 1.12694383e-01f, 1.61898091e-01f, 2.44013071e-02f, 1.30429506e-01f, 8.24031606e-02f, 1.07510827e-01f, 2.18350038e-01f, 2.14573950e-01f,
  1.38615137e-02f, 6.80486113e-02f, 2.31946111e-01f, 7.37703964e-02f, 4.39362749e-02f, 1.24845281e-01f, 7.99427480e-02f, 1.14011109e-01f, 1.26839682e-01f, 2.45863557e-01f,
  -1.40219316e-01f, 2.84264117e-01f, -2.54311651e-01f, -1.39217734e-01f, 1.19703628e-01f, 3.57645415e-02f, -5.54778799e-02f, -9.40593183e-02f, -1.10057414e-01f, -9.59926378e-03f,
  -5.70794754e-02f, 1.85703151e-02f, 1.68771908e-01f, 1.57417104e-01f, 4.26128134e-02f, -9.73484013e-03f, 4.45910636e-03f, -4.53398935e-02f, -1.63850442e-01f, 1.14481943e-02f,
  -6.70096427e-02f, -4.37483303e-02f, -1.53752685e-01f, -1.12612285e-01f, -9.51386839e-02f, -2.23144397e-01f, -6.75546899e-02f, -1.35687783e-01f, -2.05879137e-01f, -1.06388882e-01f,
  8.76415074e-01f, -3.27538103e-01f, 6.30115941e-02f, 1.84515044e-01f, -1.07284941e-01f, 1.37983151e-02f, -2.53496587e-01f, 1.72577724e-02f, 1.44198000e-01f, 6.61927611e-02f,
  1.68318003e-01f, 4.75286365e-01f, 4.10995662e-01f, 3.28756690e-01f, 2.92931348e-01f, -2.48543575e-01f, -1.63996190e-01f, 3.19023490e-01f, 3.86304557e-01f, -2.68912390e-02f,
  -1.96339145e-01f, -2.50687301e-01f, 3.42845693e-02f, -3.89957763e-02f, -4.51075315e-01f, 8.64449218e-02f, -2.43787467e-01f, -2.61047274e-01f, -2.22596034e-01f, -4.20488358e-01f,
  -3.54178511e-02f, 2.97035635e-01f, 1.89514413e-01f, 1.52765006e-01f, 4.83174175e-02f, 4.16203914e-03f, 1.27933159e-01f, 4.32172697e-03f, -2.26022407e-01f, -1.54083654e-01f,
  -5.57956696e-02f, 5.88446558e-02f, 2.53063496e-02f, -3.40335220e-02f, -1.63441554e-01f, 1.48489373e-02f, -8.83297101e-02f, 7.26846606e-02f, 8.06990117e-02f, -1.64630804e-02f,
  -3.88562754e-02f, 5.84639385e-02f, 1.50311530e-01f, 1.49987126e-03f, 3.02398279e-02f, 1.20414458e-01f, 1.10733397e-02f, -4.26506922e-02f, 1.64998353e-01f, -4.61540483e-02f,
  3.81756178e-03f, 6.48635253e-02f, 7.78678432e-02f, 1.18885487e-01f, 2.98338942e-02f, 7.24484166e-03f, -4.51381840e-02f, -8.33144635e-02f, 1.03401825e-01f, -6.51434883e-02f,
  -5.35554923e-02f, 1.57302245e-01f, 4.35986109e-02f, -9.59749334e-03f, 1.64582998e-01f, 3.00507043e-02f, -4.41162176e-02f, -3.19057517e-02f, 4.99092042e-02f, 5.51908463e-02f,
  5.97540773e-02f, -1.85812324e-01f, -1.05574347e-01f, 6.74813753e-03f, -5.51754795e-03f, 1.32273901e-02f, -5.03798295e-03f, 9.66743231e-02f, -8.33543614e-02f, -1.43782213e-01f,
  -7.76113644e-02f, 5.09653330e-01f, 2.70383414e-02f, -4.02851932e-04f, -7.51407593e-02f, -1.32205352e-01f, 1.50238857e-01f, -1.22109339e-01f, -9.46773812e-02f, -6.86641634e-02f,
  -5.90455309e-02f, -1.72983594e-02f, -3.06270383e-02f, -1.43306181e-01f, -3.89806740e-02f, 1.56123145e-02f, -7.57044367e-03f, 1.04402132e-01f, 5.28151989e-02f, -1.48657575e-01f,
  -2.58481741e-01f, 5.97587042e-02f, 1.78216830e-01f, 1.67579100e-01f, -1.10834809e-02f, 2.38601446e-01f, -4.99910861e-02f, -4.26198263e-03f, 1.88799039e-01f, -1.47648618e-01f,
  7.57374763e-01f, 5.97893596e-02f, 2.55735636e-01f, 5.84207987e-03f, -1.37201950e-01f, 1.02267638e-01f, 9.93641838e-02f, 8.64261091e-02f, -4.16601496e-03f, 2.59861480e-02f,
  -1.72242075e-01f, -2.51872629e-01f, -2.89578617e-01f, -7.20613301e-02f, -7.56812394e-02f, 1.11324258e-01f, -1.30346688e-02f, 1.29248723e-01f, 1.16496086e-01f, 8.38079751e-02f,
  -1.62828594e-01f, 1.63847357e-01f, 2.20155746e-01f, 2.80795898e-02f, 1.30810454e-01f, -1.05111949e-01f, 1.44106559e-02f, 1.00583412e-01f, -3.63862924e-02f, 1.12969391e-01f,
  7.38100559e-02f, 2.20630229e-01f, 5.01691923e-03f, -2.56214850e-02f, -5.33638410e-02f, 1.30815774e-01f, 6.15554899e-02f, 1.23169059e-02f, -4.80222292e-02f, -6.26137480e-02f,
  -9.41388234e-02f, 8.54579359e-03f, -1.24467514e-01f, -9.44082588e-02f, -1.28163313e-02f, -3.41131277e-02f, 1.31738856e-01f, 1.19253114e-01f, 1.03596672e-01f, -8.63591433e-02f,
  -1.07157364e-01f, -7.92199299e-02f, -1.95934772e-01f, -1.58224672e-01f, 2.93145459e-02f, -1.88808180e-02f, -4.56459336e-02f, -3.44409235e-02f, -1.23418197e-02f, 1.60729274e-01f,
  6.60242513e-02f, -3.45588177e-02f, -9.24328994e-03f, -4.07393165e-02f, -5.04893996e-02f, -3.51928659e-02f, 9.73976478e-02f, -4.89078499e-02f, 6.52766414e-03f, 1.04001872e-01f,
  -7.29450211e-02f, -9.87585485e-02f, 5.30839935e-02f, 1.80982333e-02f, -6.50641993e-02f, 5.09483181e-03f, 8.04314613e-02f, -1.00597836e-01f, -8.61980990e-02f, 4.21014652e-02f,
  3.91574949e-02f, -2.69848853e-02f, 1.24487430e-01f, 3.98996100e-02f, -5.04475012e-02f, -1.18992865e-01f, -3.77098881e-02f, -8.37808624e-02f, -1.10616356e-01f, -1.32383676e-02f,
  -7.26719499e-02f, 5.07721044e-02f, 3.08346897e-02f, -1.89375728e-02f, 1.20905608e-01f, 1.11661367e-01f, 2.31282085e-01f, 6.04888313e-02f, -6.15222426e-03f, -3.67510654e-02f,
  9.82715636e-02f, 8.35935697e-02f, 6.84293881e-02f, 8.23691264e-02f, 1.72722995e-01f, 5.70535138e-02f, 2.86278460e-04f, 5.61423451e-02f, 7.18459561e-02f, 2.89205369e-02f,
  3.10485158e-03f, -1.65500659e-02f, 1.38226952e-02f, 2.37651113e-02f, 2.58241277e-02f, -4.81342152e-02f, -1.71415117e-02f, 1.27145439e-01f, 4.57292283e-03f, 4.49177772e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.36076474e-01f, 3.19115102e-01f, 2.77322143e-01f, 3.15480530e-01f, -3.52979042e-02f, -1.47812679e-01f, 1.37697086e-01f, 2.16307372e-01f, 7.20151186e-01f, 3.90958607e-01f,
  4.53032494e-01f, 2.39888430e-01f, 4.53965396e-01f, 4.95696217e-01f, 3.51199567e-01f, 1.31842852e-01f, 3.54953080e-01f, 5.49349010e-01f, 3.04619402e-01f, 5.04190207e-01f,
  2.84915343e-02f, 3.43989938e-01f, 1.82492822e-01f, 3.59232783e-01f, 6.91858381e-02f, 2.19928712e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.34557277e-01f, -4.82328869e-02f, -8.04845765e-02f, -4.58349921e-02f, -4.57586423e-02f, 5.77223450e-02f, -3.15210760e-01f, -1.98296607e-01f, -4.47270691e-01f, 3.70188169e-02f,
  -4.86624762e-02f, 4.37260866e-02f, -3.88052538e-02f, -6.33058930e-03f, 3.22703689e-01f, -7.74097722e-03f, -1.64626222e-02f, 4.69571531e-01f, -8.00171420e-02f, 1.35508135e-01f,
  2.01590732e-01f, 1.90356940e-01f, -6.22302294e-02f, -2.43519962e-01f, -4.55615707e-02f, -1.16734326e-01f, -2.74838153e-02f, -2.58475661e-01f, 2.60694653e-01f, 1.27110034e-01f,
  7.29138404e-02f, 2.47692421e-01f, -7.84482285e-02f, -9.68778208e-02f, -5.97492866e-02f, 2.02992857e-01f, 6.65153265e-02f, -1.79348618e-01f, 3.05090725e-01f, 2.10520297e-01f,
  -6.93271458e-02f, -3.19068938e-01f, 2.60664433e-01f, 9.38028172e-02f, -4.89325123e-03f, 9.38088149e-02f, -2.25187838e-01f, -2.13650167e-01f, -5.64360321e-02f, -2.50581920e-01f,
  -1.41622484e-01f, -2.79957801e-01f, 2.29294792e-01f, -6.25683591e-02f, 3.06020737e-01f, -8.79544988e-02f, -3.47195506e-01f, 3.24555375e-02f, -9.16381106e-02f, 6.33567572e-03f,
  -3.42914425e-02f, 9.18143839e-02f, 3.22032198e-02f, 1.48389190e-01f, 2.17618588e-02f, 4.25270274e-02f, -7.51564428e-02f, -3.05878609e-01f, 6.44505695e-02f, -5.38899973e-02f,
  4.21918780e-01f, 1.63967326e-01f, -4.30725515e-01f, -1.42599568e-01f, 9.95002389e-02f, -2.46618241e-01f, 1.86088588e-02f, 3.73804688e-01f, 1.03440404e-01f, -1.59112006e-01f,
  -4.74063903e-02f, 1.99892446e-01f, 2.97748130e-02f, 2.61946589e-01f, -8.44302848e-02f, 1.52355582e-01f, 5.00600897e-02f, 1.51587240e-02f, 2.19726473e-01f, -1.48168907e-01f,
  1.14480294e-02f, 8.20532441e-02f, 2.09242538e-01f, -1.19566858e-01f, -1.90273434e-01f, -2.40521990e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.13020301e-01f, 2.33993322e-01f, 1.72279075e-01f, 8.19254667e-02f, 7.72893382e-03f, -4.86274473e-02f, 3.30064625e-01f, -1.59086421e-01f, 3.01858723e-01f, -3.80458534e-01f,
  -2.89914131e-01f, -1.12204678e-01f, 5.84635586e-02f, 2.66149700e-01f, 1.26240239e-01f, -1.09556027e-01f, 1.44089669e-01f, 3.41555238e-01f, 2.52309680e-01f, 2.08502576e-01f,
  3.10293257e-01f, -1.20768681e-01f, -4.28780019e-01f, 1.81686848e-01f, -3.53708327e-01f, 4.93242070e-02f, 1.36400923e-01f, 2.76917577e-01f, -1.98956549e-01f, 2.10034251e-01f,
  -2.83195972e-01f, -1.94218352e-01f, 3.76413494e-01f, 2.86518574e-01f, 3.04927468e-01f, 2.64462322e-01f, -2.80874670e-01f, 3.59755680e-02f, -3.35573375e-01f, -1.53792456e-01f,
  2.59368122e-01f, -5.89751489e-02f, -2.50909746e-01f, -1.26105472e-01f, 6.14921153e-02f, -1.26744896e-01f, 3.15527886e-01f, 2.79394656e-01f, 1.19922392e-01f, -1.01631552e-01f,
  -1.68863147e-01f, -8.77129957e-02f, 1.32417232e-01f, 1.41615033e-01f, -1.30291298e-01f, 1.15850888e-01f, -1.51456475e-01f, 3.37338924e-01f, -2.32922405e-01f, -1.62848234e-01f,
  3.24456036e-01f, 4.39392239e-01f, -9.10026729e-02f, -5.89531101e-03f, 5.11288583e-01f, 2.54128605e-01f, 2.95447201e-01f, 1.26058459e-01f, 4.34507318e-02f, 2.09377915e-01f,
  -4.43057001e-01f, 5.48750818e-01f, 1.82621419e-01f, 6.91708177e-02f, -1.61323965e-01f, -3.79210919e-01f, -5.05177304e-02f, 7.25052729e-02f, -5.06937265e-01f, 3.22813123e-01f,
  2.22746208e-01f, 2.25149274e-01f, -1.18849441e-01f, -3.78170729e-01f, 1.22175321e-01f, -1.27525134e-02f, -1.02419659e-01f, 4.06402349e-01f, 2.68320918e-01f, 1.30128965e-01f,
  -3.95610809e-01f, -1.18841507e-01f, 1.85817912e-01f, 2.24878550e-01f, 4.58689362e-01f, -1.30519360e-01f, 1.07320305e-02f, 1.87449306e-02f, 2.89221853e-01f, -1.15970843e-01f,
  2.18556926e-01f, 3.86567354e-01f, 2.35372886e-01f, 1.32242963e-01f, -3.27353805e-01f, -1.54913545e-01f, -8.76576379e-02f, -3.80512066e-02f, -2.61204571e-01f, 2.35980585e-01f,
  1.49394944e-01f, 1.40559480e-01f, -5.04348762e-02f, 5.51637709e-01f, 2.92001456e-01f, 4.60843891e-01f, 2.66525477e-01f, -2.06132337e-01f, -5.47120035e-01f, 4.23233688e-01f,
  3.41394156e-01f, -3.68286557e-02f, 1.34250104e-01f, 7.22444849e-03f, -4.68904257e-01f, 2.18502656e-01f, -3.65877748e-01f, -1.97476596e-01f, 1.07872829e-01f, -9.72718000e-02f,
  8.40290040e-02f, 4.92411792e-01f, -5.72055280e-02f, -2.11904701e-02f, 3.64851952e-01f, -4.70012277e-01f, 3.65123510e-01f, -1.27919823e-01f, 1.12208882e-02f, -1.78689420e-01f,
  2.08871737e-01f, -1.00235410e-01f, 5.75005030e-03f, 1.60522431e-01f, 2.13842452e-01f, 6.46875352e-02f, 3.19908768e-01f, -9.92755592e-02f, 3.68886650e-01f, 4.81241569e-03f,
  1.06133141e-01f, 7.17595369e-02f, -1.14761770e-01f, 5.11688590e-01f, 1.04313314e-01f, 1.22157685e-01f, -1.69932440e-01f, 2.65519649e-01f, -1.67825431e-01f, 2.42595419e-01f,
  1.25488728e-01f, 1.95240587e-01f, 1.65750220e-01f, -2.80029535e-01f, -3.53169799e-01f, 2.70661175e-01f, 7.13604540e-02f, -1.56764746e-01f, -3.56874019e-01f, -2.43945241e-01f,
  -9.78951454e-02f, -1.22593910e-01f, -3.33757587e-02f, 3.16268891e-01f, 5.14175355e-01f, -3.62763464e-01f, 2.45196849e-01f, 5.01653969e-01f, 2.60416061e-01f, 2.53668040e-01f,
  -1.18486695e-01f, 2.82042958e-02f, -4.63597029e-01f, -1.93506274e-02f, 2.13666365e-01f, -1.37239188e-01f, -7.24116489e-02f, 3.39625627e-01f, 1.86601818e-01f, -2.55271811e-02f,
  -3.56839448e-01f, -2.88907766e-01f, -3.74002149e-03f, 2.13300258e-01f, 3.69978845e-01f, 5.47278881e-01f, -8.42267796e-02f, 1.13805108e-01f, 1.05993509e-01f, -4.17509764e-01f,
  4.39857095e-01f, -5.49328625e-02f, 2.10899636e-02f, 1.51275814e-01f, 5.27490899e-02f, 1.63248464e-01f, 4.94096726e-01f, 3.25528204e-01f, -5.16385287e-02f, 1.35591626e-01f,
  1.15832157e-01f, -4.11800807e-03f, 1.15799710e-01f, 1.63714126e-01f, 1.45131543e-01f, -8.85789320e-02f, -6.82954118e-02f, 1.38900012e-01f, -2.52064556e-01f, -2.22121656e-01f,
  2.71535397e-01f, 2.59924591e-01f, -4.33423132e-01f, 2.38988131e-01f, 3.68270755e-01f, 1.99248642e-01f, 2.92527914e-01f, 2.20917985e-01f, -7.94462264e-02f, -8.53542686e-02f,
  6.42494559e-01f, 2.83775300e-01f, -1.46915019e-01f, -4.38037142e-02f, -7.03075081e-02f, -8.56489465e-02f, -2.20250972e-02f, 2.80483007e-01f, -3.48991990e-01f, 3.14912982e-02f,
  8.40955228e-02f, -3.05691678e-02f, 2.14800254e-01f, -1.49824604e-01f, 4.76792604e-01f, -1.87530145e-01f, 2.75254279e-01f, 2.47449819e-02f, -3.16697598e-01f, 3.70063394e-01f,
  3.67269665e-02f, -2.98170075e-02f, -1.58496648e-02f, 4.31657612e-01f, 2.17409842e-02f, 1.01533353e-01f, 5.02204709e-02f, 1.14572555e-01f, 3.43766123e-01f, 8.02094266e-02f,
  -2.45597228e-01f, 7.53864720e-02f, 5.35753429e-01f, 6.67076781e-02f, -2.73413330e-01f, -1.81094825e-01f, -1.88481793e-01f, -1.16453823e-02f, -4.87256736e-01f, 3.71317148e-01f,
  -3.87749046e-01f, 1.44725397e-01f, 1.07468575e-01f, 2.28188455e-01f, 7.32092978e-03f, -4.38158453e-01f, 5.05465627e-01f, -8.39480758e-02f, -5.73413253e-01f, 2.01788008e-01f,
  -1.80953756e-01f, 3.84107828e-01f, -2.91010435e-03f, -8.66718143e-02f, -3.19824815e-01f, 3.31293732e-01f, -1.91178676e-02f, 8.87634009e-02f, 2.72110015e-01f, 2.51561671e-01f,
  2.30006561e-01f, -7.32262850e-01f, -4.85089570e-02f, -6.26944751e-02f, -2.98793167e-01f, 3.22031587e-01f, -1.00568183e-01f, 4.86164331e-01f, 2.34986588e-01f, -2.13663951e-01f,
  -2.98025429e-01f, 3.13258097e-02f, 2.32896060e-01f, -3.44601035e-01f, 2.90527880e-01f, 2.05156311e-01f, 5.85816950e-02f, 2.22318079e-02f, -2.42667466e-01f, -2.69472063e-01f,
  4.08093363e-01f, 4.04837132e-01f, 2.62328982e-01f, -1.82216510e-01f, -1.84712768e-01f, 3.50881040e-01f, 2.35148743e-02f, -6.36424273e-02f, 1.78610981e-01f, -5.27490675e-01f,
  -8.48847777e-02f, -1.18471429e-01f, 2.22880363e-01f, -1.67909056e-01f, 1.19483247e-01f, 2.97906529e-02f, -2.64126569e-01f, -4.43914145e-01f, 2.00494930e-01f, 1.62967056e-01f,
  1.43045232e-01f, -1.07997574e-01f, -3.53738181e-02f, 4.74256873e-02f, 9.24098492e-02f, -9.07287225e-02f, 2.59231508e-01f, 2.90709853e-01f, 2.94833332e-01f, 2.04427317e-01f,
  5.04399687e-02f, 1.57614931e-01f, -2.42352828e-01f, 1.88016653e-01f, 1.21481910e-01f, 4.00406808e-01f, -7.74418861e-02f, 2.45255738e-01f, -3.61897975e-01f, -7.03354776e-02f,
  2.17348352e-01f, 7.03226924e-02f, 1.04810923e-01f, -1.10674538e-01f, -3.83008607e-02f, 8.88316035e-02f, 2.84151882e-01f, -2.94951815e-03f, 2.41599996e-02f, 2.51948029e-01f,
  1.58976704e-01f, -2.13709801e-01f, 1.64359942e-01f, -9.65556502e-02f, 2.34833285e-01f, -2.89244503e-01f, -8.56927112e-02f, 2.16459945e-01f, -8.58471766e-02f, -1.37271181e-01f,
  -3.27182889e-01f, 2.92558640e-01f, -1.05711661e-01f, 1.71777785e-01f, 2.41536617e-01f, 2.86802202e-01f, 4.58794646e-03f, 1.84507281e-01f, 7.21333399e-02f, 1.87427789e-01f,
  -3.13094929e-02f, -1.74885452e-01f, 3.32738429e-01f, 1.64520457e-01f, 1.28707811e-01f, -4.27102074e-02f, 1.91564530e-01f, 2.81660050e-01f, 2.02770486e-01f, 1.28132880e-01f,
  -4.75624740e-01f, 4.38560426e-01f, 3.98710728e-01f, -1.03614248e-01f, 1.72005430e-01f, -2.35497102e-01f, 1.79132856e-02f, -1.71322405e-01f, -2.21265212e-01f, 2.39785984e-01f,
  -2.19211891e-01f, 6.44935891e-02f, -6.52274564e-02f, 3.01119238e-02f, -3.62091418e-03f, 3.88047993e-01f, 1.59762338e-01f, 3.76295745e-01f, 2.62046784e-01f, 1.96773022e-01f,
  -9.13750529e-02f, -5.21896500e-03f, 2.16595069e-01f, 1.45429865e-01f, 4.78740275e-01f, 3.66816707e-02f, 3.34776163e-01f, 3.49684745e-01f, 1.12484910e-01f, -5.24751544e-01f,
  -3.47063094e-01f, -1.06797934e-01f, -1.62103064e-02f, 1.12503208e-01f, -3.67377728e-01f, -2.61254221e-01f, -8.64842832e-02f, -2.04587340e-01f, -3.12211335e-01f, 3.88536334e-01f,
  3.55455160e-01f, -8.09978470e-02f, 1.80005983e-01f, 2.72514611e-01f, 3.87930661e-01f, 3.72337520e-01f, 1.07612796e-01f, -1.97743643e-02f, 2.42564157e-01f, 9.59916934e-02f,
  1.50049806e-01f, -2.75269449e-01f, 6.74546808e-02f, 2.86885530e-01f, 2.09197044e-01f, 5.33625931e-02f, -3.78607959e-01f, -9.15572718e-02f, -7.59318518e-03f, 1.46076530e-01f,
  1.86113164e-01f, 3.72342616e-01f, -3.14416707e-01f, -8.60714018e-02f, 4.23520982e-01f, -4.02573854e-01f, -1.48164913e-01f, -3.48120451e-01f, 4.88576107e-02f, -3.70894708e-02f,
  1.58447206e-01f, 4.41735908e-02f, 6.35047555e-02f, -1.72828585e-01f, 2.58536935e-01f, -1.14467859e-01f, 1.79260761e-01f, -4.86709848e-02f, 4.66533422e-01f, -1.01925611e-01f,
  4.49945599e-01f, -5.14836311e-01f, -3.90284449e-01f, 3.40395451e-01f, -2.64554650e-01f, -2.21028656e-01f, -1.37363344e-01f, 1.70186311e-01f, -2.20693678e-01f, 1.37777388e-01f,
  1.33257121e-01f, 3.37107420e-01f, 2.80105442e-01f, -1.89365387e-01f, -2.09677026e-01f, -6.70210645e-02f, 3.08707923e-01f, 1.35893717e-01f, -2.52943009e-01f, -4.64001000e-02f,
  1.69960663e-01f, -3.38356495e-01f, 7.05906972e-02f, 3.46460730e-01f, 5.49505539e-02f, 9.90822241e-02f, 1.99391112e-01f, -1.63119901e-02f, 2.06552714e-01f, 1.51577041e-01f,
  3.54509026e-01f, -1.00454293e-01f, -1.20613702e-01f, -9.52315629e-02f, -1.13354199e-01f, 1.98461592e-01f, 4.54680473e-02f, 4.88392025e-01f, 2.38704860e-01f, 3.83828253e-01f,
  -1.24129914e-01f, 9.54026133e-02f, 3.89617324e-01f, 3.78219098e-01f, 3.35755885e-01f, 1.41854599e-01f, -4.77042459e-02f, 1.90728813e-01f, 4.86286491e-01f, -2.94790834e-01f,
  1.75086215e-01f, -1.32770509e-01f, 2.25339383e-01f, -2.04570293e-01f, 3.47368449e-01f, 2.14409441e-01f, 3.72386396e-01f, 1.71428502e-01f, 2.41121486e-01f, 7.66241923e-02f,
  3.52283567e-01f, 3.17166448e-01f, 2.82999098e-01f, 1.31523600e-02f, 2.06763446e-01f, -6.14833273e-02f, -4.40926477e-02f, 2.47936368e-01f, -2.36591354e-01f, 5.30123234e-01f,
  2.92234331e-01f, 3.91582876e-01f, 1.60931110e-01f, 6.53819693e-03f, 1.78029522e-01f, 5.01262605e-01f, -9.31400154e-03f, -5.80269434e-02f, 3.26115161e-01f, -2.99936146e-01f,
  3.33318472e-01f, 7.56030083e-01f, 1.31731778e-01f, 1.30110592e-01f, 2.86617815e-01f, 1.40790343e-01f, 4.38955426e-02f, 1.22464821e-01f, -4.33981031e-01f, -1.90249249e-01f,
  2.72435807e-02f, -2.78847128e-01f, -1.22982748e-01f, 2.61080861e-01f, -1.20756596e-01f, -8.30814168e-02f, 7.40494967e-01f, -2.72162389e-02f, 7.30511993e-02f, -1.68893244e-02f,
  1.15235709e-01f, 3.39754760e-01f, 8.50065351e-02f, -6.06648102e-02f, 1.86922967e-01f, 3.00428092e-01f, 3.77462864e-01f, 3.03130955e-01f, 2.84542412e-01f, -5.82407564e-02f,
  -1.99608803e-02f, 2.73066789e-01f, -7.60002062e-02f, 3.73263747e-01f, 1.73244476e-02f, -3.69454563e-01f, -1.06838115e-01f, 2.55139396e-02f, -3.67469221e-01f, 8.48349556e-02f,
  4.09892619e-01f, -1.09007202e-01f, 9.30628106e-02f, 4.22382653e-01f, 3.54197055e-01f, 2.59189904e-01f, 1.40083626e-01f, -1.96771279e-01f, -2.68701240e-02f, 3.79031956e-01f,
  4.71857607e-01f, -1.38719514e-01f, 8.41011256e-02f, 2.06852525e-01f, -1.34433329e-01f, 8.10807869e-02f, -6.09778881e-01f, -9.38685313e-02f, 2.92312831e-01f, 1.40950084e-01f,
  2.52223611e-01f, 2.55531669e-01f, 4.98409718e-01f, 3.10963303e-01f, 1.52700350e-01f, 5.74897341e-02f, 5.77141762e-01f, 4.16984409e-01f, -3.83301854e-01f, 6.26167729e-02f,
  2.91028321e-01f, -3.72254550e-01f, 4.22746092e-01f, 2.44599998e-01f, -3.44372541e-01f, -1.50333077e-01f, -2.57326420e-02f, 8.58398676e-02f, -4.02955085e-01f, 6.67095929e-02f,
  1.62471253e-02f, 1.93293840e-01f, 7.70561472e-02f, 2.07869243e-02f, -3.94887298e-01f, -7.35306367e-02f, 6.65111542e-02f, -9.04419348e-02f, -2.26730749e-01f, -2.48354569e-01f,
  3.16018462e-01f, 4.70503479e-01f, 3.57035279e-01f, 3.24786663e-01f, 3.64649594e-01f, 2.41408393e-01f, 4.06766117e-01f, 1.22042589e-01f, 1.42486274e-01f, -1.32657453e-01f,
  -3.80100608e-01f, 1.46574259e-01f, -1.60745814e-01f, 4.66289669e-01f, 1.88226655e-01f, 6.89530671e-02f, 2.14398369e-01f, 3.13034505e-01f, 4.52241451e-01f, 1.03821486e-01f,
  1.86436132e-01f, -2.27055680e-02f, -7.44346619e-01f, 2.79168069e-01f, 1.51836559e-01f, 1.82998385e-02f, 2.35375777e-01f, 2.87802577e-01f, -5.89494884e-01f, 7.75275379e-02f,
  -3.17340821e-01f, 2.99328491e-02f, 3.11993897e-01f, 4.04779427e-02f, 4.44762595e-02f, 5.39290845e-01f, 4.35173869e-01f, 2.57487111e-02f, 3.12875330e-01f, 3.71117353e-01f,
  5.08283377e-01f, -5.66784084e-01f, -4.60624576e-01f, 2.27103978e-01f, -1.14357226e-01f, -9.22526792e-02f, -2.54433692e-01f, 2.68028855e-01f, -3.97593051e-01f, -1.53013662e-01f,
  1.58230454e-01f, 3.12404603e-01f, -9.82706770e-02f, 7.82305002e-02f, -1.99273467e-01f, 1.92189798e-01f, 1.07962683e-01f, 5.74225895e-02f, 1.11728199e-01f, 2.57957041e-01f,
  -3.81493330e-01f, -3.28926779e-02f, 1.18319571e-01f, -3.30375656e-02f, 1.68158576e-01f, 3.11597049e-01f, 1.48541406e-01f, 1.44334033e-01f, 3.65418464e-01f, 1.94091290e-01f,
  -4.14973125e-02f, -2.05976125e-02f, 3.48995388e-01f, 1.77566797e-01f, -1.28935501e-01f, 7.56655112e-02f, 7.94894099e-02f, -2.34992146e-01f, 1.72918320e-01f, 1.69371665e-01f,
  -2.24678725e-01f, -2.37901270e-01f, -1.68162838e-01f, -4.14573662e-02f, -1.51531950e-01f, 2.18358010e-01f, 3.56266260e-01f, 1.47589236e-01f, -1.14293747e-01f, -7.93001950e-02f,
  -2.77658314e-01f, 9.45892259e-02f, 1.43483892e-01f, -3.32725719e-02f, 9.34573188e-02f, 6.68714270e-02f, 7.72107914e-02f, 2.90485501e-01f, 4.62688237e-01f, 5.19072533e-01f,
  4.98405695e-01f, 1.22811817e-01f, -8.07949603e-02f, -2.95899287e-02f, 4.52058196e-01f, 2.97252625e-01f, -4.07760382e-01f, 1.74045771e-01f, 3.53794366e-01f, -2.39455074e-01f,
  2.86454648e-01f, 3.33289132e-02f, -3.78490776e-01f, -2.66662180e-01f, -3.26648448e-03f, 2.27273285e-01f, -3.62450421e-01f, -3.76759350e-01f, -2.22306505e-01f, 5.87292351e-02f,
  2.10541621e-01f, 1.40047029e-01f, -3.66695076e-01f, 8.12167451e-02f, -4.25730467e-01f, -3.81745584e-02f, -2.85004407e-01f, -8.62930864e-02f, 4.80708070e-02f, 1.12008177e-01f,
  -4.04169783e-02f, -2.47976586e-01f, -4.92516346e-02f, 3.04875702e-01f, 1.13512330e-01f, 9.28379074e-02f, -2.55710725e-02f, 4.06743616e-01f, 2.31707007e-01f, -1.98894978e-01f,
  3.95539433e-01f, 2.81009674e-01f, 1.49074271e-01f, 7.08412677e-02f, 4.07004595e-01f, 2.56007642e-01f, -1.12502694e-01f, 2.37434238e-01f, -2.58973837e-01f, 2.88855076e-01f,
  8.71578902e-02f, -1.90275356e-01f, -1.47265896e-01f, -2.38582343e-01f, 9.40064490e-02f, 2.26130456e-01f, 5.20102561e-01f, -7.02644810e-02f, 1.88713789e-01f, 1.15198061e-01f,
  3.15648496e-01f, 1.39554888e-01f, 1.68139383e-01f, -1.58469617e-01f, 4.59244326e-02f, 1.74607337e-01f, -2.02362373e-01f, -5.30611992e-01f, 4.00762931e-02f, 2.59451866e-01f,
  4.67031524e-02f, 1.70987785e-01f, -4.93251532e-02f, 1.36045828e-01f, 6.43224537e-01f, 7.65083581e-02f, 2.74959087e-01f, 4.70844060e-01f, 1.54791787e-01f, 6.75228462e-02f,
  3.42121683e-02f, 3.27156931e-01f, -5.16586840e-01f, 1.31225035e-01f, 1.75224259e-01f, 1.11036360e-01f, 1.45124912e-01f, 5.65600097e-02f, -1.82142317e-01f, -5.22646084e-02f,
  6.58562258e-02f, -2.20866159e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  4.68518622e-02f, 1.97238043e-01f, 5.42928338e-01f, 3.22288364e-01f, 1.22322656e-01f, 1.23612545e-01f, 4.08195525e-01f, 3.37629229e-01f, 3.55295628e-01f, 3.53636563e-01f,
  7.88053647e-02f, -7.07137436e-02f, 1.91651598e-01f, 2.72918105e-01f, -9.15237293e-02f, 1.48786277e-01f, 4.74273890e-01f, 1.59453332e-01f, 3.36044759e-01f, 5.34535170e-01f,
  4.10393834e-01f, 3.76090795e-01f, 2.58400768e-01f, 4.10556048e-01f, 4.64408584e-02f, 1.92051932e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.47395430e-02f, 1.66307077e-01f, 7.07964599e-02f, 4.04582582e-02f, -1.80347309e-01f, -2.83236325e-01f, -1.60547420e-01f, 1.79430738e-01f, 8.09665099e-02f, -2.65029877e-01f,
  -5.89628108e-02f, -2.31258988e-01f, 6.47811964e-02f, -1.32060498e-01f, -1.91173971e-01f, -1.44005746e-01f, -1.49387285e-01f, 3.03450096e-02f, 6.51012361e-02f, 3.57569456e-02f,
  -3.23848985e-02f, -1.06319383e-01f, 2.05865577e-01f, 1.05551414e-01f, 5.56568541e-02f, 2.15370715e-01f, -3.26701738e-02f, 1.53960362e-01f, 4.98984940e-02f, 1.76382214e-01f,
  -8.54552388e-02f, 9.15830731e-02f, -4.11244661e-01f, 8.01218152e-02f, -4.83375452e-02f, 4.06772166e-01f, 2.26048212e-02f, -2.34816819e-01f, -7.02747628e-02f, 1.22092843e-01f,
  -1.07504632e-02f, 3.92204970e-02f, 1.47506714e-01f, 2.77556404e-02f, 3.64629984e-01f, 1.22509629e-01f, 2.42399171e-01f, -1.37902334e-01f, 2.00284734e-01f, -1.66196495e-01f,
  -8.77383053e-02f, 1.00990370e-01f, 1.02063254e-01f, -5.35719916e-02f, -3.91304642e-02f, -1.26636788e-01f, -3.15271765e-02f, -7.44046941e-02f, -1.25177100e-01f, 4.91008209e-03f,
  -3.46426964e-02f, 1.26655037e-02f, -1.88637245e-02f, 2.12796420e-01f, -4.97897446e-01f, 7.94876963e-02f, -3.30518574e-01f, 4.95574653e-01f, 4.83608134e-02f, -1.40252337e-01f,
  -1.68819770e-01f, 1.57451749e-01f, 5.37864352e-03f, -2.10927740e-01f, -2.25314219e-02f, -1.25302896e-01f, 2.09391966e-01f, 4.09684516e-02f, 2.37786040e-01f, -1.47754565e-01f,
  -2.61974543e-01f, -1.43130139e-01f, -7.57072344e-02f, 7.65157714e-02f, -5.44709712e-02f, 6.18502796e-02f, -1.37674645e-01f, -5.66799864e-02f, -9.24238116e-02f, 9.11700875e-02f,
  -8.38856120e-03f, -5.29531203e-02f, 3.64773348e-02f, -3.22703958e-01f, 6.18354417e-02f, 1.62587702e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.41225129e-01f, 2.86174983e-01f, 2.58758396e-01f, 1.06463261e-01f, -2.01926291e-01f, 4.96864356e-02f, -3.70784402e-01f, 2.01704070e-01f, 3.92460763e-01f, -1.37389272e-01f,
  -2.80285001e-01f, 3.31631601e-01f, 1.32203013e-01f, -2.60300696e-01f, -1.24563254e-01f, 1.96118429e-01f, 2.63211783e-02f, 3.68206017e-02f, 4.33967561e-01f, 1.42709717e-01f,
  -1.01858065e-01f, -7.80179128e-02f, 1.99352130e-01f, -2.10131526e-01f, 1.54649490e-03f, 6.03551185e-03f, -2.97774136e-01f, -3.98611486e-01f, 1.96196273e-01f, -1.05428010e-01f,
  3.87165360e-02f, 4.50982563e-02f, -3.95068303e-02f, 2.00002380e-02f, 1.01039059e-01f, 3.02333623e-01f, 3.13121080e-02f, -4.54910994e-01f, 2.11190898e-02f, 4.79907990e-01f,
  4.93409306e-01f, -7.63148427e-01f, 2.27114424e-01f, -4.28562015e-01f, 8.77865404e-02f, 3.62111151e-01f, -1.11439414e-01f, 2.78855294e-01f, 2.78466009e-02f, 1.59426257e-01f,
  1.62762940e-01f, -1.18215673e-01f, 3.48137319e-01f, 2.77178466e-01f, 3.67707223e-01f, 1.91951752e-01f, -1.54131189e-01f, 1.01470083e-01f, -4.56264228e-01f, -9.57013965e-02f,
  1.95976764e-01f, -1.90852970e-01f, -1.09523483e-01f, -2.77503014e-01f, 5.59714675e-01f, 1.41158029e-01f, 1.76883221e-01f, -3.30659807e-01f, -1.77673936e-01f, 2.88560420e-01f,
  -1.37335109e-02f, -8.97859782e-02f, 1.84278160e-01f, 5.05726039e-01f, -1.30786657e-01f, -6.94580525e-02f, -1.97193041e-01f, -2.43871152e-01f, -3.50052208e-01f, 3.71136129e-01f,
  1.40961140e-01f, 3.04559439e-01f, 1.00530423e-01f, 2.22175151e-01f, -1.44981965e-01f, -1.35487974e-01f, -1.35260578e-02f, 1.11210719e-01f, 4.57741857e-01f, 2.51059771e-01f,
  2.16700703e-01f, 4.75692511e-01f, -2.25919504e-02f, 4.53541636e-01f, -2.03683712e-02f, 2.32898414e-01f, -2.25198846e-02f, 9.67244059e-02f, -9.83178392e-02f, -3.36386919e-01f,
  3.93285871e-01f, 3.69136095e-01f, -2.76174903e-01f, 3.88221033e-02f, 3.67969394e-01f, -1.18739501e-01f, -2.05128491e-01f, -2.34565705e-01f, -4.80612606e-01f, 3.72910142e-01f,
  1.32462874e-01f, 5.28566778e-01f, -2.07855776e-01f, 3.64686906e-01f, 4.30848122e-01f, 3.05070430e-01f, -1.89561062e-02f, 2.81830221e-01f, 4.29558642e-02f, 4.55165237e-01f,
  2.63829887e-01f, -1.45748422e-01f, -1.02613710e-01f, 2.93002367e-01f, 1.54753663e-02f, -2.45436043e-01f, 1.42375633e-01f, -2.76161641e-01f, -2.23993450e-01f, 5.94751835e-01f,
  -4.09483880e-01f, -2.57126421e-01f, -1.17287770e-01f, 1.13222711e-01f, 3.18482488e-01f, -7.54248947e-02f, 4.68767852e-01f, 2.08351463e-01f, -6.27391636e-02f, 2.50960678e-01f,
  -4.83112067e-01f, -1.34444356e-01f, 1.98196173e-01f, 2.08104718e-02f, 3.55623841e-01f, 2.98497796e-01f, 3.79187196e-01f, 2.34671421e-02f, -3.79193962e-01f, 1.63876817e-01f,
  1.73602864e-01f, 1.77551702e-01f, 2.72372782e-01f, -1.61357448e-01f, 3.71057391e-01f, 5.19857168e-01f, -5.86571358e-02f, -2.18486980e-01f, 1.05016582e-01f, 2.21691757e-01f,
  -1.03828833e-01f, 2.88018018e-01f, 3.11742157e-01f, -1.22705773e-01f, -2.17265502e-01f, 1.12633474e-01f, 3.60122532e-01f, 1.99693903e-01f, -2.73074865e-01f, 7.64020532e-02f,
  7.04318797e-03f, 3.07430893e-01f, 3.93254280e-01f, 1.07523583e-01f, 1.76120296e-01f, -2.77319252e-02f, -1.89442635e-01f, -8.25306401e-02f, -2.60697305e-01f, 1.96063310e-01f,
  -4.10706580e-01f, 4.69088703e-02f, 1.32029772e-01f, -5.72978966e-02f, 4.40725051e-02f, 4.13963795e-01f, 3.36777121e-01f, -1.25357300e-01f, 1.85452908e-01f, 1.62170529e-01f,
  2.04832882e-01f, 1.52391300e-01f, -5.42827658e-02f, 3.58785987e-01f, -5.62957190e-02f, -2.21618429e-01f, 3.60401332e-01f, 1.05684534e-01f, 1.83107436e-01f, 2.22554684e-01f,
  9.15417373e-02f, 1.51597261e-01f, -8.25485736e-02f, 2.44764313e-01f, -8.49023461e-03f, 3.57764423e-01f, 5.48641682e-01f, 2.45053440e-01f, 2.32278127e-02f, -3.60469520e-01f,
  -2.71538943e-01f, 4.22006220e-01f, 5.07578021e-03f, 2.82221884e-01f, 1.82170510e-01f, -9.05779153e-02f, 2.57271171e-01f, -3.05550307e-01f, 3.75073642e-01f, -2.24960804e-01f,
  -3.30341756e-01f, -3.27322543e-01f, -2.88768709e-01f, -3.33604701e-02f, -4.60324436e-01f, 2.63100475e-01f, 2.16534436e-01f, 3.84330958e-01f, -6.57629445e-02f, -4.88415845e-02f,
  3.43594044e-01f, 3.18464488e-01f, 1.85133263e-01f, 6.28052279e-02f, 2.88996458e-01f, -2.65221536e-01f, 1.11843303e-01f, 2.90318817e-01f, 2.72303969e-01f, -5.14869615e-02f,
  -2.40642905e-01f, 1.89550355e-01f, 3.00773561e-01f, -5.66086620e-02f, 6.56868890e-02f, -1.74620226e-02f, 2.27682889e-01f, -3.15714836e-01f, 1.36080831e-01f, 3.05091709e-01f,
  3.04785818e-01f, 4.61693436e-01f, -6.36725798e-02f, -5.28913131e-03f, -1.36110157e-01f, 1.10338770e-01f, 3.28858197e-01f, -3.45493346e-01f, 3.89533967e-01f, -1.28275588e-01f,
  -2.55392939e-02f, 6.27147615e-01f, -3.24383199e-01f, -3.38415727e-02f, -6.17596693e-02f, -6.20551966e-02f, -5.47445007e-02f, 1.94542900e-01f, 4.93861914e-01f, -1.90101385e-01f,
  -4.50896859e-01f, 1.16664693e-01f, -3.55422567e-03f, 5.18964380e-02f, 4.59271669e-02f, 3.01559925e-01f, -2.68726081e-01f, -8.87386873e-02f, 2.67529726e-01f, 1.17548980e-01f,
  2.94153422e-01f, 3.31553757e-01f, 1.11429483e-01f, 9.84642059e-02f, 6.27204478e-02f, 1.01897195e-01f, -1.51835650e-01f, 2.65246421e-01f, 5.04310489e-01f, 7.17053004e-03f,
  -6.52407184e-02f, -1.05271049e-01f, -4.05413598e-01f, -2.96579272e-01f, -2.16871232e-01f, -6.16223551e-02f, 3.09369653e-01f, 1.92214280e-01f, -3.02000018e-03f, 8.51203129e-02f,
  -1.72590211e-01f, -2.05119252e-01f, -2.02116564e-01f, 6.05711639e-01f, 2.31459993e-03f, -3.67476106e-01f, 2.70653605e-01f, 1.15286857e-02f, -8.34247470e-02f, -3.94733369e-01f,
  -1.68387756e-01f, -2.19444767e-01f, 2.55965292e-01f, 4.13913131e-01f, 2.24569917e-01f, 1.47582725e-01f, 1.56648174e-01f, 5.35195649e-01f, -4.38664287e-01f, 1.20831951e-02f,
  4.28281605e-01f, -2.69222021e-01f, 6.36569560e-02f, -1.18009493e-01f, -3.10363740e-01f, -2.11022377e-01f, -2.36325756e-01f, -3.12161781e-02f, 4.84846234e-01f, 1.49747580e-01f,
  -4.03586984e-01f, 8.35949257e-02f, -4.68392193e-01f, -3.20427194e-02f, -1.63433000e-01f, 7.04992115e-01f, 1.39036596e-01f, -3.81666362e-01f, -4.76876944e-02f, 1.20600298e-01f,
  -9.04268995e-02f, -1.41440034e-01f, -6.18296638e-02f, 1.30121946e-01f, 2.79005259e-01f, 9.35810208e-02f, -2.79630236e-02f, -2.22396821e-01f, 5.75989112e-02f, 3.91094089e-02f,
  1.87683646e-02f, 3.51959467e-01f, 9.12635177e-02f, 7.49657869e-01f, 2.40243271e-01f, -1.28445849e-01f, -4.92822975e-01f, -5.06301939e-01f, -1.08655401e-01f, 2.25793153e-01f,
  4.05587167e-01f, -1.00638652e-02f, 1.32831901e-01f, -5.44273734e-01f, 1.57959983e-01f, 1.80202693e-01f, 2.72813350e-01f, -3.16452056e-01f, 1.74014166e-01f, 1.27691239e-01f,
  3.51305932e-01f, -2.94573337e-01f, -3.67351413e-01f, 2.87352093e-02f, 3.11373286e-02f, 1.04993291e-01f, -7.14390725e-02f, 2.79682308e-01f, 1.65475681e-01f, 4.26140547e-01f,
  1.14827968e-01f, 3.87583911e-01f, 1.39655024e-01f, -1.08070396e-01f, -3.45552027e-01f, 1.41897402e-03f, -1.75683558e-01f, -2.36105710e-01f, 1.03023306e-01f, -1.86562777e-01f,
  2.50819713e-01f, -4.00752664e-01f, -3.01747352e-01f, -2.03725725e-01f, 1.44825429e-01f, 2.37878442e-01f, -2.96426892e-01f, 3.23009610e-01f, -7.87870213e-02f, 2.15482339e-02f,
  3.13201398e-02f, 1.38444290e-01f, -5.08674562e-01f, 1.04757138e-01f, 3.63869518e-01f, 2.95074821e-01f, 3.89418930e-01f, 2.23946616e-01f, -2.63077378e-01f, -2.04837725e-01f,
  1.81116045e-01f, -3.69161665e-01f, 1.41647300e-02f, -5.08812629e-02f, 3.03170621e-01f, -1.58153549e-01f, 8.39861989e-01f, -3.76483321e-01f, -5.28700426e-02f, -1.25755832e-01f,
  -9.44615677e-02f, -5.70447028e-01f, -3.92465383e-01f, -8.40312219e-04f, 1.81678370e-01f, 1.24839535e-02f, -4.09847081e-01f, 7.17186034e-02f, -9.18901861e-02f, -3.63459170e-01f,
  -4.45711523e-01f, 4.13772106e-01f, 3.72454911e-01f, -5.91852814e-02f, 1.66632131e-01f, 7.10860118e-02f, -1.70103639e-01f, -3.14880610e-01f, -1.29667833e-01f, 1.14437947e-02f,
  6.85027018e-02f, 4.12040859e-01f, 4.70057577e-02f, 7.19305724e-02f, 1.67000949e-01f, 3.65380943e-01f, -4.66580510e-01f, 2.62964606e-01f, 3.35796297e-01f, 2.85538077e-01f,
  8.48273560e-02f, 3.07007611e-01f, -3.80938590e-01f, -6.45813704e-01f, -3.89003428e-03f, 5.41406214e-01f, 2.97917306e-01f, -4.42146838e-01f, 3.06138903e-01f, -3.75315964e-01f,
  5.51559746e-01f, 1.16531208e-01f, -5.12887612e-02f, -6.33459568e-01f, 3.82114388e-02f, 8.86846706e-02f, 3.05445671e-01f, -1.38431579e-01f, 3.23064029e-01f, 1.06830724e-01f,
  3.73189300e-01f, -1.71080351e-01f, -8.86804760e-02f, 1.51152492e-01f, -1.46041796e-01f, -3.55562270e-02f, 1.94466695e-01f, 2.72030175e-01f, -1.16831951e-01f, 1.50174682e-03f,
  -6.87158227e-01f, 4.35748905e-01f, -3.91074866e-01f, 7.73504972e-01f, -2.08063766e-01f, -3.28941733e-01f, 2.95014996e-02f, 3.68796855e-01f, 3.04185718e-01f, -4.71095264e-01f,
  -1.39758483e-01f, 1.05243854e-01f, 1.56271532e-02f, -1.38982413e-02f, -1.06220216e-01f, 1.80815563e-01f, -1.05362065e-01f, 1.87478989e-01f, 3.00048918e-01f, -2.09114268e-01f,
  -1.62281707e-01f, 2.40274087e-01f, 1.07625648e-01f, -7.95956934e-04f, -2.76713789e-01f, 1.96714327e-01f, -3.45660478e-01f, -3.57345313e-01f, 1.82475269e-01f, -3.18816841e-01f,
  2.92021602e-01f, 4.67797443e-02f, 1.88764542e-01f, -4.04853299e-02f, 2.96918869e-01f, 3.06427479e-01f, -2.52959460e-01f, -1.73871070e-01f, -1.68341976e-02f, 1.88425690e-01f,
  5.29195331e-02f, 9.87330750e-02f, 1.19909488e-01f, -2.82401264e-01f, 4.42379296e-01f, -2.00984299e-01f, -4.60314423e-01f, -1.72699019e-01f, 4.10953956e-03f, -6.85560331e-02f,
  1.43762499e-01f, -2.35182032e-01f, -9.70866978e-02f, 6.21671490e-02f, 3.06921780e-01f, -7.96501711e-02f, 4.95239422e-02f, 2.80458421e-01f, 1.83917895e-01f, 1.84566483e-01f,
  -3.33273262e-02f, 5.36368072e-01f, -8.94625336e-02f, 1.14398845e-01f, 2.65386840e-03f, -8.20752323e-01f, 4.54338156e-02f, -6.20339066e-03f, 4.57563438e-02f, 5.49662590e-01f,
  5.38552813e-02f, 1.29213586e-01f, -1.70444041e-01f, -5.73876500e-03f, 6.55769855e-02f, 6.34341300e-01f, 1.33373812e-01f, -1.72236152e-02f, -8.09713081e-02f, 1.46299988e-01f,
  2.12286040e-01f, -6.62101582e-02f, -1.70202300e-01f, 3.76129419e-01f, 4.02912766e-01f, 7.71997795e-02f, 1.60205558e-01f, -3.84064972e-01f, 2.83114493e-01f, -2.23534778e-01f,
  8.96252617e-02f, -3.10207754e-01f, -7.97696114e-02f, -8.97866488e-02f, 1.48798525e-01f, 1.01968035e-01f, -4.45458382e-01f, -1.93260714e-01f, -7.72834867e-02f, -2.51851887e-01f,
  6.91506267e-01f, 8.48435044e-01f, 3.46506462e-02f, -3.78034115e-01f, -4.76864606e-01f, -7.32178211e-01f, -9.81792714e-03f, 1.40060917e-01f, 1.01061411e-01f, 3.29320073e-01f,
  9.98240933e-02f, 4.84275997e-01f, -1.80406436e-01f, -6.19756468e-02f, -3.99562657e-01f, 3.10134083e-01f, 1.60372064e-01f, 3.71052116e-01f, 8.62935111e-02f, 5.39093256e-01f,
  -1.31366298e-01f, -1.55138403e-01f, 2.53336757e-01f, 1.65283717e-02f, 2.27036625e-01f, -7.86737353e-02f, 1.54936269e-01f, -2.21867546e-01f, 2.79954463e-01f, -1.12087190e-01f,
  1.01993546e-01f, -3.76413882e-01f, 2.43600622e-01f, -2.18521282e-01f, 1.37532339e-01f, 3.42799246e-01f, -1.81012005e-01f, -3.76337647e-01f, 1.38506025e-01f, -2.29588583e-01f,
  7.01361775e-01f, 2.61552989e-01f, 2.44210958e-01f, -5.63252091e-01f, -1.79978907e-01f, -1.98597834e-01f, 7.14884996e-02f, -4.28830869e-02f, 4.74098712e-01f, 7.70331547e-02f,
  1.69278711e-01f, 8.06699023e-02f, 4.59236838e-02f, 2.43233457e-01f, 1.64073452e-01f, 8.87051299e-02f, 2.46929172e-02f, 5.99663019e-01f, -2.02847794e-01f, -3.06153685e-01f,
  -1.82438999e-01f, 1.39167085e-01f, -2.46727824e-01f, 3.96074802e-01f, -5.06011367e-01f, -6.28435165e-02f, 4.38010752e-01f, 2.03056738e-01f, 1.05843522e-01f, 4.01450247e-01f,
  -4.00732681e-02f, 5.60202241e-01f, 1.21960193e-01f, -1.55803878e-04f, 1.87652886e-01f, 1.40512407e-01f, 2.56174952e-01f, -2.62327224e-01f, -2.14699492e-01f, 2.71643609e-01f,
  -8.35315436e-02f, 2.08319381e-01f, 1.90259125e-02f, -2.52984256e-01f, -2.10354030e-02f, 1.69422105e-01f, 1.95088938e-01f, -4.49111789e-01f, -9.33831483e-02f, -3.81193869e-02f,
  3.74990314e-01f, 4.45092291e-01f, 3.59414607e-01f, 7.09255934e-01f, -1.24313995e-01f, -5.65003276e-01f, 7.43717253e-02f, -6.75706863e-01f, 3.61556619e-01f, 6.80738837e-02f,
  -2.61533521e-02f, -6.79512415e-03f, 3.50624949e-01f, -7.04674458e-04f, 1.88540488e-01f, 4.85064298e-01f, 6.36709392e-01f, -2.98896104e-01f, 1.93642721e-01f, -7.10719032e-03f,
  -8.11544210e-02f, -3.80062982e-02f, -2.98302591e-01f, 2.99485147e-01f, 1.95983857e-01f, -2.67993033e-01f, 8.21494684e-02f, 4.61676344e-02f, 3.24183851e-01f, 2.30868474e-01f,
  -1.11705750e-01f, 2.80985773e-01f, -2.41482854e-01f, 1.22847043e-01f, -9.21633616e-02f, 1.13086961e-02f, 1.79855525e-01f, -3.52421314e-01f, -1.33186638e-01f, -3.20553988e-01f,
  3.82560104e-01f, -2.11194134e-03f, -3.58084857e-01f, -7.26308525e-02f, 4.35626835e-01f, 1.01732910e-01f, 7.80812725e-02f, 8.97045732e-02f, 1.71566486e-01f, -2.35118553e-01f,
  2.19593987e-01f, 1.54769480e-01f, -3.18412334e-01f, -8.02923590e-02f, 3.43680024e-01f, 1.66402429e-01f, 2.96839386e-01f, 9.41678286e-02f, -2.58888990e-01f, -3.02870333e-01f,
  2.00723901e-01f, -3.67049307e-01f, -2.32762948e-01f, -9.28607211e-02f, 2.30216622e-01f, 2.60831207e-01f, 3.28404410e-03f, 2.74398834e-01f, 2.44809955e-01f, 2.02869549e-01f,
  -3.60372394e-01f, -3.00583035e-01f, 1.61385968e-01f, 2.14367390e-01f, 1.32631257e-01f, -2.86028653e-01f, -1.15209386e-01f, 1.56735852e-01f, 5.17029524e-01f, -1.42190203e-01f,
  -3.38511050e-01f, -1.95457429e-01f, -3.11998557e-02f, -6.88817427e-02f, -2.02377468e-01f, -6.72605112e-02f, -4.56679970e-01f, -1.24946959e-01f, 8.40206221e-02f, -2.79101133e-01f,
  1.27849400e-01f, 5.03878534e-01f, 1.26738727e-01f, -7.72563275e-03f, 2.87718803e-01f, 2.63528436e-01f, 3.44881252e-03f, 1.07963704e-01f, 3.90514433e-01f, 1.64247394e-01f,
  2.12735459e-01f, 1.19857758e-01f, -3.19289118e-01f, -5.74179411e-01f, -7.71309435e-02f, 2.66272500e-02f, 1.04544044e-01f, -2.25388646e-01f, -2.50402123e-01f, -1.76824763e-01f,
  -2.79431880e-01f, 1.02646761e-01f, -3.42600375e-01f, 5.59233367e-01f, 6.98566213e-02f, -7.23255575e-02f, -2.91866791e-02f, -3.06697100e-01f, -1.50393158e-01f, 9.11963880e-02f,
  2.71109015e-01f, 4.49478999e-02f, -1.50295734e-01f, 3.03497106e-01f, -7.71936402e-02f, -1.84933826e-01f, 1.22727223e-01f, 3.89869720e-01f, 7.03441948e-02f, 9.80743244e-02f,
  -2.10064009e-01f, 4.05500382e-01f, -1.53012767e-01f, -3.74776572e-01f, 1.15067042e-01f, 6.34819925e-01f, -2.23172963e-01f, -7.52370283e-02f, 1.50163770e-01f, 5.31694472e-01f,
  -2.94250727e-01f, 8.69882479e-02f, -5.07285357e-01f, 2.46637136e-01f, 3.60544384e-01f, 1.78240269e-01f, -4.14748281e-01f, -8.95679966e-02f, 7.34172612e-02f, 6.39852643e-01f,
  -4.96014446e-01f, -3.52288573e-03f, 1.89293921e-01f, 1.04955457e-01f, 4.94872749e-01f, -2.22566575e-01f, 3.28351378e-01f, 5.20153977e-02f, -4.04619992e-01f, -2.03699514e-01f,
  4.18739580e-02f, -2.53980070e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.12741876e-01f, 1.33207098e-01f, -2.13827547e-02f, 2.10078999e-01f, -1.08661078e-01f, 1.79121628e-01f, 2.10078359e-02f, 3.29975635e-02f, 2.27552205e-01f, 2.71556437e-01f,
  1.41039789e-01f, 7.46704638e-02f, 1.89874247e-01f, 3.82255204e-02f, 1.37991846e-01f, 1.70279726e-01f, 1.65391073e-01f, 4.40740958e-02f, 4.92973536e-01f, 1.78784609e-01f,
  1.31544948e-01f, 3.21691841e-01f, -6.04737587e-02f, 4.09412920e-01f, 1.68254375e-01f, 2.22995281e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -4.17975575e-01f, -2.94821471e-01f, -5.52071109e-02f, 1.73170552e-01f, -9.66239795e-02f, 2.91468650e-01f, -7.75214583e-02f, -4.47600037e-01f, 3.44049960e-01f, 1.44314662e-01f,
  1.23521313e-01f, -3.38759512e-01f, -5.42380989e-01f, 2.47569084e-01f, 2.41212308e-01f, 2.71877021e-01f, 7.34917149e-02f, 1.38272271e-01f, -7.86466151e-02f, 1.79557446e-02f,
  -3.59819859e-01f, -3.96758348e-01f, 1.54790059e-01f, -3.68175745e-01f, 2.38020741e-03f, -3.44576389e-01f, -6.37463987e-01f, -6.02244794e-01f, -2.20738500e-02f, -2.31022343e-01f,
  -2.50917166e-01f, -2.53446195e-02f, -2.54299581e-01f, 7.40624815e-02f, 2.64358193e-01f, 2.38791823e-01f, -4.37132657e-01f, -2.88240761e-01f, 2.73333251e-01f, 4.37146723e-01f,
  -9.91993472e-02f, 1.71292290e-01f, 1.52051851e-01f, -2.26686984e-01f, -3.73912185e-01f, -8.18799138e-02f, -1.46574944e-01f, 1.63754448e-01f, 2.49202073e-01f, 2.17487544e-01f,
  1.04597315e-01f, 1.67842120e-01f, 1.67828798e-01f, 3.21394205e-01f, -1.94874927e-02f, -1.93325192e-01f, -3.58895898e-01f, -5.03032804e-01f, -4.68623862e-02f, -4.56749536e-02f,
  3.14935371e-02f, -6.59675151e-02f, 2.89791673e-01f, -6.41960859e-01f, 2.99792737e-01f, -1.38645440e-01f, 2.97143191e-01f, -3.93053554e-02f, -5.00790656e-01f, -2.59921908e-01f,
  -4.40311711e-03f, 2.13297695e-01f, 1.64650634e-01f, 4.14337039e-01f, -1.17912732e-01f, -1.17544264e-01f, 2.03334555e-01f, -9.36052680e-01f, 3.93010527e-01f, -4.74364758e-01f,
  7.22016469e-02f, -2.02242896e-01f, -5.04449382e-02f, -3.79006714e-01f, -2.57317781e-01f, -1.61731899e-01f, -2.97178298e-01f, -1.81938305e-01f, 3.84563565e-01f, -9.35198367e-02f,
  -5.81929445e-01f, -5.23110032e-01f, -6.22265995e-01f, -4.01268363e-01f, -1.08193571e-03f, 3.13298851e-01f, -1.78350687e-01f, 6.91482946e-02f, -1.30474910e-01f, -1.45286039e-01f,
  5.77415153e-02f, -7.39613622e-02f, 2.76153177e-01f, -7.54695758e-02f, 8.28606412e-02f, -4.48098704e-02f, 1.20288700e-01f, -1.15523994e-01f, 7.77631104e-02f, -2.15354651e-01f,
  3.23395222e-01f, 1.58892900e-01f, 1.74793079e-01f, -7.35079169e-01f, -6.87305629e-01f, 2.20362157e-01f, -1.24291897e-01f, 1.26026273e-01f, -2.67158359e-01f, 5.15345871e-01f,
  -6.58650458e-01f, -1.58513337e-01f, 2.44981945e-01f, -2.05749482e-01f, -6.78815663e-01f, 4.16339487e-02f, -1.63046852e-01f, 1.75588503e-01f, 3.23828965e-01f, 1.13321096e-01f,
  -4.93248641e-01f, -3.69081408e-01f, -2.74538904e-01f, -4.45933342e-01f, -1.93895414e-01f, -5.24339736e-01f, 1.50362611e-01f, 3.08297239e-02f, 2.21900403e-01f, 1.52117357e-01f,
  1.31333172e-01f, 9.62642953e-02f, -3.39920335e-02f, 1.97135676e-02f, -3.16247456e-02f, 2.11488768e-01f, -8.68306383e-02f, -6.38982952e-01f, -1.44885629e-01f, -3.01379889e-01f,
  -2.61676908e-01f, -6.07218146e-01f, -6.86269343e-01f, -4.34995532e-01f, 7.37819821e-02f, 2.73919702e-01f, 4.43075448e-02f, -1.25113189e-01f, -2.80141294e-01f, 3.08315486e-01f,
  -3.82376797e-02f, 2.26781622e-01f, 1.48591269e-02f, 2.42175803e-01f, 9.37968940e-02f, -2.33976007e-01f, -1.49402782e-01f, -2.42810115e-01f, 1.38019562e-01f, -4.41289574e-01f,
  1.32775842e-03f, 3.05299401e-01f, -5.41439056e-01f, 1.07940212e-01f, 2.65797585e-01f, 9.15589333e-02f, -3.02027881e-01f, 3.22981268e-01f, -1.37049600e-01f, 9.40656960e-02f,
  2.67204404e-01f, -6.01979434e-01f, 2.95665413e-01f, -5.22958755e-01f, -7.46356696e-02f, 1.79863721e-01f, -2.34365687e-01f, 4.86928254e-01f, -1.44427717e-01f, 3.22641373e-01f,
  -3.93284336e-02f, -2.02619880e-01f, 2.23521397e-01f, -2.90492475e-02f, -2.85851032e-01f, -1.70529470e-01f, 4.16734844e-01f, -5.26175022e-01f, -1.54482499e-01f, 3.16192776e-01f,
  -4.26569551e-01f, 7.26538450e-02f, -4.24214035e-01f, -8.43951553e-02f, -1.49171010e-01f, -2.16204375e-01f, -1.77325428e-01f, -4.44082208e-02f, -1.82767794e-01f, -1.40849173e-01f,
  3.58161420e-01f, 1.13265207e-02f, 1.08092047e-01f, -6.57531798e-01f, -1.16518028e-01f, 1.84456572e-01f, 2.80230880e-01f, 4.33202505e-01f, -4.26722407e-01f, -7.56938085e-02f,
  3.67861509e-01f, -2.10859403e-02f, -1.57653049e-01f, -6.62647545e-01f, -1.52183086e-01f, -2.27391496e-01f, 5.00297993e-02f, 1.56844631e-01f, 2.62505621e-01f, 4.08240467e-01f,
  -2.35338435e-01f, -3.93515497e-01f, -5.63132390e-03f, -2.30825260e-01f, 1.20598264e-01f, 1.93088919e-01f, 1.61802173e-01f, -3.17282736e-01f, -6.66799722e-03f, -6.58335984e-01f,
  1.98910475e-01f, -4.51767519e-02f, 1.37767345e-01f, -2.60113150e-01f, -2.41517276e-01f, 8.36844295e-02f, -1.10139698e-01f, 2.81742334e-01f, -5.89794256e-02f, -9.08301026e-02f,
  4.79314655e-01f, -2.39418875e-02f, 7.64787644e-02f, 8.87154266e-02f, -1.14828415e-01f, -4.09620911e-01f, -2.50920504e-01f, -2.16866747e-01f, -1.29930571e-01f, 3.49123590e-02f,
  2.75175333e-01f, 4.33766663e-01f, 4.03929591e-01f, 2.65727073e-01f, -4.91439611e-01f, -3.58977616e-01f, -3.93021941e-01f, 3.52668732e-01f, -2.36094430e-01f, 2.23859504e-01f,
  2.18355328e-01f, -6.81541026e-01f, -4.47467834e-01f, 1.51666746e-01f, -1.02857791e-01f, -5.19162953e-01f, 2.00127900e-01f, 4.36863989e-01f, 2.44696632e-01f, 2.55147874e-01f,
  1.91552460e-01f, -2.18598545e-01f, 1.35001227e-01f, -5.65621734e-01f, -9.00812745e-02f, 5.03981829e-01f, 1.54027492e-02f, -2.23502204e-01f, 6.91505894e-02f, 4.88565534e-01f,
  1.58759385e-01f, -2.42511824e-01f, 1.53430596e-01f, 2.14327216e-01f, -2.81065315e-01f, -1.30054370e-01f, -6.35546207e-01f, 1.83258519e-01f, 1.19574539e-01f, 1.82479903e-01f,
  3.46074969e-01f, 1.15791913e-02f, -2.36712620e-01f, -3.24525595e-01f, -8.83424163e-01f, -2.32704878e-01f, 2.55714744e-01f, -7.68756941e-02f, -5.30023813e-01f, 2.78549254e-01f,
  -4.80923921e-01f, 9.81196538e-02f, 4.46014971e-01f, -1.90269668e-02f, -2.33437479e-01f, 1.60821021e-01f, -9.11877975e-02f, -3.94391686e-01f, -2.79461779e-02f, 1.61596701e-01f,
  2.12048054e-01f, 1.59553215e-01f, 1.05524264e-01f, 2.94291854e-01f, -2.15220124e-01f, -2.98773229e-01f, 2.05694251e-02f, -2.35841185e-01f, 1.29497766e-01f, -6.78688526e-01f,
  -6.99088871e-01f, 2.28737250e-01f, -2.66835153e-01f, -3.38080406e-01f, 1.81713119e-01f, 4.49939013e-01f, 5.63180149e-01f, -1.25423163e-01f, -3.11971635e-01f, 5.84016562e-01f,
  -2.46781796e-01f, -4.11200941e-01f, 1.42483592e-01f, -2.60220826e-01f, -1.53909400e-01f, -3.67794394e-01f, 3.42915505e-01f, -4.16614056e-01f, -6.57942951e-01f, 3.56901556e-01f,
  5.84866166e-01f, -4.99671131e-01f, 1.12287775e-01f, -2.00243980e-01f, 7.64446035e-02f, -1.26423570e-03f, -1.82935908e-01f, 6.78357184e-01f, -2.36870170e-01f, 2.52470285e-01f,
  -4.22207952e-01f, -1.47439167e-01f, -4.14883971e-01f, 1.66854821e-02f, 2.88005441e-01f, 3.24442178e-01f, -5.72491109e-01f, -3.09494644e-01f, -2.24667974e-02f, 1.20166093e-01f,
  -2.12889478e-01f, -4.97335345e-02f, 3.08198988e-01f, 2.38357186e-02f, 1.87774189e-02f, -1.90168664e-01f, -5.30926287e-01f, 2.82037228e-01f, 1.38433337e-01f, 2.82394052e-01f,
  2.81735342e-02f, -3.15482527e-01f, -3.33649665e-01f, -2.02529758e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.36087905e-02f, -4.90267389e-02f, 4.66371924e-02f, 4.58256900e-03f, 7.92316943e-02f, 1.88521326e-01f, -4.96172905e-03f, -7.84930289e-02f, -8.26740637e-03f, 2.01135337e-01f,
  -5.86161725e-02f, -1.59725115e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    