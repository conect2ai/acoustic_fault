/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.03484702e-01f, 1.75644681e-01f, 2.10918829e-01f, -2.12170690e-01f, 1.20245991e-02f, 1.15680099e-02f, -1.44742876e-01f, -1.49056494e-01f, -7.28161186e-02f, 8.32382962e-02f,
  2.34749690e-02f, 9.55022406e-03f, 1.62870497e-01f, 1.41344085e-01f, -9.44194570e-02f, 2.13335361e-02f, 5.94382808e-02f, 8.41752589e-02f, -5.54635711e-02f, -1.08334355e-01f,
  5.36808670e-02f, -1.17637202e-01f, -1.11425124e-01f, -2.80234721e-02f, 1.48429409e-01f, -1.16001267e-03f, 8.80438313e-02f, 1.37171358e-01f, 1.94683567e-01f, 3.40990543e-01f,
  2.63924152e-01f, -3.97156402e-02f, -3.58882062e-02f, -7.26208836e-02f, 7.17122331e-02f, -4.04375046e-02f, -7.42232874e-02f, 8.54024291e-03f, 2.98767630e-02f, 5.06412610e-02f,
  1.62617094e-03f, 1.92427468e-02f, -5.10233454e-03f, -4.60075997e-02f, 2.18254374e-03f, -6.41424500e-04f, -6.20308183e-02f, 4.37639318e-02f, -3.11928801e-02f, 4.04735468e-02f,
  6.94792047e-02f, 7.04333037e-02f, -3.00653521e-02f, 1.34598501e-02f, -4.37257066e-02f, 3.48134190e-02f, -7.81724975e-03f, 1.59005709e-02f, 1.22060135e-01f, 1.10611759e-01f,
  -4.84048910e-02f, 3.91786136e-02f, 1.14104869e-02f, -7.48584419e-02f, -2.89236270e-02f, 1.76065159e-03f, 1.14695774e-02f, 1.64002571e-02f, -2.56094467e-02f, -3.13887186e-02f,
  -1.65615156e-02f, 7.19208568e-02f, 1.11560496e-02f, 3.73832509e-03f, 5.86419515e-02f, 4.07704748e-02f, 9.38366074e-03f, 3.67434174e-02f, 3.04483380e-02f, -4.44756933e-02f,
  6.23743096e-03f, 5.64350747e-02f, 5.12498058e-02f, 1.90364439e-02f, 1.46074966e-02f, 2.86556277e-02f, -2.82180477e-02f, 2.05237214e-02f, -7.64100477e-02f, 5.19580059e-02f,
  -1.34189710e-01f, 3.93726751e-02f, 3.93515974e-02f, -1.87753874e-03f, 4.72578891e-02f, 4.47863750e-02f, 8.03997293e-02f, 5.44120604e-03f, 8.95760879e-02f, -2.98803374e-02f,
  7.42586562e-03f, -5.26823439e-02f, 3.15091051e-02f, 6.23953063e-04f, -8.05089474e-02f, -6.98640496e-02f, -6.63832426e-02f, 6.51715919e-02f, 2.95978058e-02f, 4.69596200e-02f,
  -2.42726691e-02f, -5.05161732e-02f, -1.28542081e-01f, 1.44202774e-03f, 2.11815108e-02f, -5.75679429e-02f, 2.61947978e-02f, -6.39479142e-03f, -7.71329403e-02f, -2.73077816e-01f,
  4.97889638e-01f, -1.88809350e-01f, -1.48283109e-01f, 2.56509662e-01f, -1.99834213e-01f, -1.30234301e-01f, -1.65378541e-01f, 1.06385037e-01f, 2.65246391e-01f, -4.68118377e-02f,
  -1.05619729e-01f, -6.36763051e-02f, 8.56841132e-02f, -2.49754339e-02f, 1.85314287e-02f, -6.18912689e-02f, -1.04731657e-01f, -8.51254538e-02f, 1.10971689e-01f, -1.10255122e-01f,
  -2.11189136e-01f, 5.63133433e-02f, 1.98993340e-01f, 1.99749261e-01f, -9.12064612e-02f, 6.68491125e-02f, 5.49626052e-02f, -9.11085457e-02f, -1.26973480e-01f, -2.69932956e-01f,
  -1.07993059e-01f, -7.57491738e-02f, -3.34948897e-02f, -2.85564382e-02f, -9.62892175e-02f, 1.27499685e-01f, -4.90149073e-02f, -1.33207496e-02f, -1.92801934e-02f, 4.24221437e-03f,
  -1.21200398e-01f, -3.89905646e-02f, -5.57177588e-02f, -1.67126046e-03f, 4.90966737e-02f, 1.31639997e-02f, 3.86907607e-02f, 1.75002068e-02f, 4.42856513e-02f, -4.28854972e-02f,
  -1.56890541e-01f, -1.09901577e-01f, -9.47308913e-02f, -1.90021731e-02f, -9.29793995e-03f, -1.06984295e-01f, -7.77919143e-02f, -2.14736499e-02f, -5.85424565e-02f, 5.47567941e-02f,
  2.81993225e-02f, -1.84522644e-02f, -4.35687266e-02f, 3.52997743e-02f, 2.97647323e-02f, 4.21895087e-03f, 3.14957928e-03f, 6.65260188e-04f, 1.40091847e-03f, 4.46798839e-02f,
  -3.93858328e-02f, 5.31544983e-02f, -3.35428379e-02f, 4.08398621e-02f, 6.46062121e-02f, -5.94294220e-02f, -2.17042994e-02f, 3.32237519e-02f, 1.83691382e-02f, 7.35782692e-03f,
  -1.92022715e-02f, -4.14047241e-02f, 7.93217197e-02f, 2.99611362e-03f, -7.87557736e-02f, 7.38030523e-02f, -5.96962608e-02f, -2.63497103e-02f, 1.28112212e-02f, -1.21883256e-02f,
  2.85204560e-01f, -2.48042569e-01f, 3.73608619e-02f, -2.15126220e-02f, 4.14771624e-02f, -1.19886920e-02f, 2.00119391e-02f, -3.38856876e-03f, -3.17225531e-02f, 1.16177285e-02f,
  2.81151962e-02f, 1.64930224e-02f, -9.69258603e-03f, 1.14574535e-02f, 2.22563185e-02f, -4.35811505e-02f, 1.07980408e-02f, 2.29888856e-02f, -9.39714611e-02f, 6.43993765e-02f,
  6.96531758e-02f, 1.63052991e-01f, 6.79248273e-02f, 6.89810514e-03f, -7.08323121e-02f, 3.42906278e-04f, 2.43611801e-02f, 6.26938976e-03f, 5.29799908e-02f, 3.65942538e-01f,
  2.03246206e-01f, -2.90167093e-01f, 3.14146429e-02f, -7.28593618e-02f, -4.40131091e-02f, -6.60367459e-02f, -2.17388168e-01f, -2.41659917e-02f, 1.39649048e-01f, -2.01104745e-01f,
  -1.24864399e-01f, 5.85571267e-02f, 1.36773800e-02f, 1.24656878e-01f, 7.55950296e-03f, -1.52126461e-01f, -1.37059838e-01f, 6.24859110e-02f, 3.26868385e-01f, 4.04782631e-02f,
  -7.73549229e-02f, 8.38516429e-02f, 1.78565338e-01f, 6.44550845e-02f, -6.08525090e-02f, 7.55166411e-02f, -4.58210744e-02f, 2.82439962e-02f, -4.07727621e-02f, -2.05009997e-01f,
  -7.59957135e-02f, 5.86621910e-02f, 1.00552462e-01f, 2.47832742e-02f, -7.95066953e-02f, 6.84925243e-02f, 9.71042085e-03f, 9.32177603e-02f, 3.37320007e-02f, -6.88739866e-02f,
  -3.58092971e-02f, 3.91715728e-02f, -4.16599400e-02f, -2.29144539e-03f, 4.67685349e-02f, 5.18050836e-03f, 1.21971853e-01f, 8.06742087e-02f, 7.44702965e-02f, 7.14625046e-02f,
  -8.26114342e-02f, 1.87174827e-02f, -2.79669110e-02f, 8.98622274e-02f, 3.04024164e-02f, -1.90227926e-02f, 4.16179560e-02f, 8.26648176e-02f, 1.53480232e-01f, -1.68030217e-01f,
  -6.08064383e-02f, 4.96719554e-02f, -3.52029838e-02f, 1.77261475e-02f, -4.95831892e-02f, 3.13983252e-03f, 1.14716068e-02f, 8.04756582e-03f, 4.29209471e-02f, -6.96526542e-02f,
  -1.29758921e-02f, -6.81411028e-02f, 7.68071460e-03f, -1.64518226e-02f, -3.10545135e-02f, 5.62217012e-02f, -1.77924975e-03f, -6.36833683e-02f, 3.45494524e-02f, 3.56844650e-03f,
  3.60568427e-02f, 2.47441176e-02f, 2.12573688e-02f, 1.83600560e-02f, -7.52844214e-02f, -1.02576101e-02f, 6.45508543e-02f, 5.20518096e-03f, 6.48672879e-03f, 1.15549900e-02f,
  2.13178154e-02f, 1.28997132e-01f, -4.24972810e-02f, 5.52010275e-02f, 6.14254288e-02f, 8.02655593e-02f, -3.37838270e-02f, 3.10219117e-02f, 3.91480932e-03f, 1.30870109e-02f,
  -8.29060096e-03f, -2.75560934e-02f, 2.27879826e-02f, -2.61937380e-02f, -6.46635145e-02f, 4.42043021e-02f, -6.95953816e-02f, -2.34402977e-02f, 4.82065901e-02f, 4.66562212e-02f,
  1.13851884e-02f, -1.49958825e-03f, 1.16025373e-01f, 2.13996600e-02f, 5.47748320e-02f, 1.28321514e-01f, 1.38507873e-01f, 1.63348615e-01f, 1.52905509e-01f, -1.53435778e-03f,
  4.67452645e-01f, 3.09853014e-02f, 8.59591886e-02f, 5.76677442e-01f, 2.96833485e-01f, 3.27353156e-03f, -1.19376136e-02f, -1.43866584e-01f, 1.14484869e-01f, 1.65034086e-02f,
  -5.79021405e-03f, 1.42753452e-01f, -6.61097746e-03f, -3.39939594e-02f, -1.28705055e-01f, -1.69853315e-01f, 8.58322755e-02f, 9.66890529e-02f, 8.20608661e-02f, 1.51555225e-01f,
  1.68651238e-01f, 3.57516259e-01f, 2.86557645e-01f, 6.60916616e-04f, 1.21942936e-02f, 2.11132057e-02f, -4.79165241e-02f, 1.66829914e-01f, -1.51550919e-01f, 3.46017033e-01f,
  8.31865519e-02f, -4.35310602e-02f, 3.62401679e-02f, 6.25242963e-02f, 1.32009327e-01f, -8.37104097e-02f, -1.66072026e-02f, -4.59855087e-02f, -1.82180479e-02f, -6.64704144e-02f,
  7.96911269e-02f, 4.53659240e-03f, 6.14093579e-02f, 1.01009853e-01f, 3.03971842e-02f, 3.48646119e-02f, -4.17142920e-02f, 2.79768445e-02f, -2.78298631e-02f, -6.28828257e-02f,
  1.13212660e-01f, 3.85128371e-02f, -8.28344151e-02f, -6.28180802e-02f, -1.01611011e-01f, 9.70296934e-02f, -1.21706584e-02f, -1.19504388e-02f, -1.56335652e-01f, 8.97184163e-02f,
  2.19393931e-02f, -9.97277275e-02f, 1.15121519e-02f, 2.47095861e-02f, -5.05344663e-03f, -2.80679669e-02f, 4.47032154e-02f, 4.05594036e-02f, -4.43744063e-02f, 6.06474429e-02f,
  -6.02955632e-02f, 8.18389952e-02f, -1.86989941e-02f, -8.02551676e-03f, -3.53473611e-02f, 4.88833375e-02f, -1.23193348e-02f, 5.44654988e-02f, -3.09578869e-02f, -3.63917947e-02f,
  1.19150626e-02f, -5.35805672e-02f, 3.75232697e-02f, -1.82508659e-02f, -1.21706221e-02f, 4.25621518e-04f, 7.02387514e-03f, -6.96849674e-02f, -2.11914871e-02f, 2.41132937e-02f,
  3.59982736e-02f, -1.21594379e-02f, 1.04150720e-01f, -2.40223482e-02f, -1.52471401e-02f, -2.67426148e-02f, 7.45922551e-02f, -7.40403011e-02f, 4.69774082e-02f, 5.48031665e-02f,
  -1.72276143e-02f, -4.99311602e-03f, 3.73321362e-02f, -9.56203490e-02f, 4.58663702e-02f, -1.02210946e-01f, 2.78965291e-02f, 9.22214687e-02f, -6.99955672e-02f, -7.83846155e-02f,
  -8.37508291e-02f, -1.08464472e-01f, 8.97309091e-03f, -9.93708000e-02f, -7.97687769e-02f, 1.11641936e-01f, -6.45123869e-02f, -5.79851978e-02f, -2.15289313e-02f, -1.59304902e-01f,
  -2.67638098e-02f, -8.81251693e-02f, 4.44082916e-01f, -1.65908620e-01f, 2.36424193e-01f, 2.57914037e-01f, 2.47136593e-01f, -1.86588660e-01f, -1.41768008e-01f, 2.03883320e-01f,
  1.30845830e-01f, -1.94325358e-01f, 1.75701305e-01f, 5.81200570e-02f, 8.91323388e-02f, 2.16423705e-01f, 2.94592917e-01f, 1.76923364e-01f, 1.55169606e-01f, 2.39811968e-02f,
  9.93284676e-03f, -1.24523029e-01f, -2.54208297e-02f, -1.22667030e-01f, -2.27017105e-02f, 8.90368968e-02f, 2.75963575e-01f, 1.56447113e-01f, 4.62131947e-02f, 1.51188318e-02f,
  4.01139379e-01f, -9.53212529e-02f, 1.78297907e-01f, -5.01436256e-02f, 1.69684678e-01f, -4.18189913e-02f, 2.37071104e-02f, -5.69655448e-02f, -2.17712279e-02f, -3.18666697e-02f,
  1.00200824e-01f, 3.80361006e-02f, 4.47033718e-03f, -4.31686305e-02f, 1.22939097e-02f, 2.07163375e-02f, 2.66040079e-02f, 3.50750908e-02f, 3.64158303e-02f, 1.33258635e-02f,
  1.51371015e-02f, -7.97802862e-03f, 6.73997849e-02f, -7.61198327e-02f, 4.32481132e-02f, 3.94559316e-02f, -1.51755959e-01f, -4.34814133e-02f, -4.20446508e-02f, -2.18540486e-02f,
  2.31370945e-02f, 2.88138893e-02f, 4.93930168e-02f, -8.22858438e-02f, -8.31697695e-03f, 4.42318339e-03f, -2.26661586e-03f, 3.49682309e-02f, 2.25228388e-04f, -5.14464080e-02f,
  -2.20131520e-02f, 2.20634546e-02f, -9.18472558e-02f, 3.47496732e-03f, 1.75525527e-02f, -1.07232239e-02f, -3.45221814e-03f, 4.72794138e-02f, -9.85827148e-02f, -1.21928351e-02f,
  -4.61509498e-03f, -2.64255498e-02f, -2.17515733e-02f, -7.00752363e-02f, 4.49396158e-03f, -2.39294022e-02f, 4.91229147e-02f, -5.43970102e-03f, -4.28953096e-02f, -1.71826817e-02f,
  -9.67671722e-02f, 1.99431971e-01f, 4.31087613e-02f, 6.71009943e-02f, 9.03622899e-03f, -4.00102045e-03f, 1.94704290e-02f, 9.33157206e-02f, -1.77205037e-02f, 1.17275201e-01f,
  -2.67882831e-02f, -3.70731205e-02f, 3.23335044e-02f, 1.38336020e-02f, -1.09406309e-02f, -2.95514595e-02f, -6.06799908e-02f, 1.35024721e-02f, -2.48967353e-02f, -7.70539567e-02f,
  -4.37444597e-02f, -1.01029314e-01f, -5.16331829e-02f, 2.28273459e-02f, -3.93722132e-02f, 5.70134521e-02f, 7.03753829e-02f, 1.76022816e-02f, 8.10262114e-02f, 7.70944878e-02f,
  -1.07930362e-01f, -5.61897317e-03f, -3.39794964e-01f, 2.04532538e-02f, 5.60845882e-02f, -5.52136451e-02f, -1.64411679e-01f, -6.70267716e-02f, 1.05914779e-01f, 2.09024660e-02f,
  1.67326719e-01f, 1.74937457e-01f, 1.07343048e-01f, 5.05160913e-02f, -1.75452411e-01f, -2.50664175e-01f, -2.38478810e-01f, -2.22280607e-01f, -8.09226632e-02f, -4.04322781e-02f,
  2.97973454e-02f, 3.14086601e-02f, -1.37664229e-01f, -5.04373573e-02f, 2.98668072e-03f, 9.02697891e-02f, 5.46856550e-03f, -6.00745715e-02f, -6.96583791e-03f, 6.15587011e-02f,
  -3.12662460e-02f, -1.70830667e-01f, 1.53597454e-02f, 9.77318585e-02f, 1.04974965e-02f, -2.82363612e-02f, -5.74223250e-02f, -4.66814898e-02f, -4.07329984e-02f, 7.72310188e-03f,
  2.37683970e-02f, 1.07717052e-01f, -4.20202538e-02f, 5.99088892e-02f, -4.54749428e-02f, 4.14303429e-02f, 1.69088331e-03f, -1.69276476e-01f, -1.31754443e-01f, 3.83288898e-02f,
  1.64601967e-01f, 1.12342067e-01f, -2.34173238e-02f, -7.96270594e-02f, -5.35995476e-02f, 4.51935120e-02f, 1.47512611e-02f, -3.41099426e-02f, -9.08467025e-02f, 6.39331490e-02f,
  -1.11909518e-02f, -3.81883793e-02f, -4.54718396e-02f, 1.48008354e-02f, 6.91057518e-02f, -1.21215160e-03f, -5.11203893e-02f, 4.83595468e-02f, 4.41891998e-02f, -2.04127729e-02f,
  -2.14546416e-02f, -2.13566944e-02f, -1.15667693e-02f, -2.14917157e-02f, 1.08303707e-02f, -5.83808050e-02f, 4.46438044e-03f, -9.80630610e-03f, 1.06278874e-01f, -1.02978431e-01f,
  3.97833399e-02f, -2.57808156e-02f, -6.25798106e-02f, 2.47799698e-02f, -3.04932036e-02f, -1.34920143e-02f, 9.95943099e-02f, 6.82504028e-02f, 3.78080495e-02f, 2.38585789e-02f,
  7.78656974e-02f, -8.36311430e-02f, -1.26777869e-02f, 3.01441811e-02f, 7.22470805e-02f, 4.28810008e-02f, 7.53220394e-02f, 1.43871568e-02f, 7.44658038e-02f, 9.09961760e-02f,
  6.08186834e-02f, -5.53143471e-02f, 1.20136226e-02f, -9.03661549e-03f, 9.08553749e-02f, 3.91757935e-02f, 4.20065932e-02f, -3.08538601e-02f, 1.05864089e-02f, -8.47308058e-03f,
  -6.19696639e-02f, -2.89123859e-02f, 5.99083714e-02f, -4.97835129e-02f, 2.88123842e-02f, 6.83986917e-02f, -4.46855873e-02f, 3.51854786e-02f, -1.38090625e-01f, -1.16836615e-01f,
  -2.50824243e-01f, -4.30267453e-01f, -2.26171806e-01f, 9.87481251e-02f, 2.06119120e-01f, -4.10066210e-02f, -2.93035835e-01f, -6.89543337e-02f, 1.63725078e-01f, -1.68688875e-02f,
  3.92131135e-02f, 3.16915125e-01f, 7.18228668e-02f, 7.06845820e-02f, -1.99930027e-01f, -1.41501799e-01f, -6.62912801e-02f, 6.06807433e-02f, 3.56538296e-02f, 1.78124964e-01f,
  2.06667453e-01f, 1.51454723e-02f, -1.34562012e-02f, -2.64976552e-04f, -2.80784294e-02f, 1.71825606e-02f, -8.82568210e-02f, -7.12376088e-02f, -1.37714252e-01f, -5.08376211e-02f,
  -8.24658498e-02f, -1.00890242e-01f, 3.78084220e-02f, 7.75440037e-03f, 4.32029292e-02f, -9.24904495e-02f, -1.01162821e-01f, -3.54047976e-02f, -2.42425036e-02f, 2.85165310e-02f,
  1.39658406e-01f, 3.24005410e-02f, 3.28434706e-02f, 7.33531713e-02f, 7.35400652e-04f, -1.61437672e-02f, 1.46546764e-02f, 1.41535848e-02f, -7.73412734e-02f, 1.70532297e-02f,
  7.12118223e-02f, 1.63396329e-01f, -1.51453987e-01f, -4.42908285e-03f, -1.22276738e-01f, 1.09672107e-01f, -4.39627245e-02f, -1.08449943e-01f, -1.34828076e-01f, -2.50806987e-01f,
  -2.76311170e-02f, 4.98941764e-02f, 1.97377577e-02f, -4.74524945e-02f, -3.39639932e-02f, 3.95205505e-02f, -4.44403850e-02f, -5.85693605e-02f, 9.45418980e-03f, -7.89841712e-02f,
  -2.64096409e-02f, -1.98713224e-02f, -2.22163275e-02f, -7.00187311e-02f, 3.22395079e-02f, -5.40179610e-02f, 2.78047249e-02f, -1.81314740e-02f, -2.40595117e-02f, -1.78191625e-02f,
  8.92516226e-03f, -1.45798037e-02f, 5.78123070e-02f, 6.53077941e-03f, 4.53121029e-02f, 1.58681199e-02f, 3.58840008e-03f, 5.52292308e-03f, 6.41337708e-02f, 5.59566682e-03f,
  -1.31484391e-02f, 7.49340802e-02f, -5.14572449e-02f, -2.31227428e-02f, 4.16637622e-02f, 4.86524068e-02f, 5.45302778e-02f, 2.69105211e-02f, -3.63996364e-02f, -3.60182002e-02f,
  -1.15408273e-02f, -1.49433194e-02f, -5.12707718e-02f, 2.01981533e-02f, -8.37086812e-02f, -3.47880870e-02f, -5.06505668e-02f, -5.29771298e-03f, -4.12167870e-02f, 3.04496847e-02f,
  -6.74399920e-03f, -8.00896734e-02f, -1.04926780e-01f, -1.56841740e-01f, -9.28540677e-02f, 6.64313138e-02f, -1.73233688e-01f, -4.18309420e-02f, -9.58529934e-02f, -4.34713364e-01f,
  9.30326730e-02f, 7.11358339e-02f, 1.15937024e-01f, -1.85154393e-01f, 1.20727129e-01f, 2.33036861e-01f, 4.10040230e-01f, 5.79178706e-02f, -7.87030160e-03f, 1.64215490e-02f,
  1.37120172e-01f, 7.82648996e-02f, 9.88591928e-03f, 6.70135096e-02f, 1.89581305e-01f, 4.34740782e-02f, -9.49322954e-02f, -7.69658759e-02f, 1.30494788e-01f, 1.46166086e-01f,
  -7.35362843e-02f, -1.13389648e-01f, -1.78335860e-01f, -6.66209217e-03f, -9.91559401e-02f, -1.17533639e-01f, -2.02812105e-01f, -1.40115499e-01f, -2.98829805e-02f, -3.76357883e-01f,
  1.40919060e-01f, 5.49704246e-02f, -4.07999195e-02f, 3.51543836e-02f, -2.86838767e-04f, 1.44779333e-03f, 1.10504523e-01f, -7.24503323e-02f, 4.78762388e-02f, 9.06850919e-02f,
  7.61073688e-03f, 3.42645124e-02f, -2.68517956e-02f, -4.98181619e-02f, -2.22332235e-02f, -3.03390902e-02f, 2.25478057e-02f, -5.82316741e-02f, 1.65001135e-02f, 9.08708051e-02f,
  3.91326621e-02f, 3.31672281e-02f, 1.53830022e-01f, -4.38013449e-02f, 2.48131845e-02f, -4.67022397e-02f, -6.29714178e-03f, -4.17128317e-02f, -8.76393393e-02f, -1.82635888e-01f,
  -1.10954598e-01f, -2.91995183e-02f, 3.64833400e-02f, -3.10455225e-02f, -3.94730046e-02f, 3.36477421e-02f, -3.08145247e-02f, -9.40398127e-02f, -2.88697388e-02f, 9.99333523e-03f,
  5.89096285e-02f, 2.63135899e-02f, -2.89658979e-02f, -5.68628013e-02f, -3.40066701e-02f, -2.79478729e-02f, 1.05811069e-02f, 4.18716222e-02f, -5.99976219e-02f, -3.36469896e-02f,
  1.22667588e-02f, 6.49138764e-02f, 6.15894236e-02f, -1.48403803e-02f, 9.74625796e-02f, -2.89274212e-02f, -7.65287876e-02f, -1.34863565e-02f, 4.17052433e-02f, 4.85765487e-02f,
  -5.38704135e-02f, 8.76989588e-02f, -5.86825237e-02f, -6.89590573e-02f, -9.23825130e-02f, 4.49039750e-02f, -8.99549015e-03f, -6.60223216e-02f, -4.40285206e-02f, 4.69974466e-02f,
  8.62474889e-02f, 9.93926730e-03f, 4.84572649e-02f, 4.70884778e-02f, -5.87644763e-02f, 1.89677496e-02f, -6.03418164e-02f, -4.29954194e-03f, -1.99069292e-03f, 8.19388870e-03f,
  9.20783430e-02f, 8.89676288e-02f, 5.33460304e-02f, -8.90877657e-03f, 8.35056901e-02f, 9.43077356e-02f, 1.26667917e-01f, -5.93301794e-03f, 1.67877793e-01f, -8.88054073e-02f,
  4.17258441e-02f, 2.93532193e-01f, -2.66717225e-02f, -3.63045670e-02f, -2.70293970e-02f, 6.13158233e-02f, 1.84666336e-01f, 6.15979731e-02f, -1.73667334e-02f, 3.56966592e-02f,
  -3.90930735e-02f, -2.13314146e-01f, -1.73460037e-01f, 4.19462798e-03f, 1.13911144e-02f, 2.60161847e-01f, 2.48368800e-01f, -2.87022628e-02f, -1.21449292e-01f, -9.60522741e-02f,
  -9.84345526e-02f, -5.75215146e-02f, 2.40697935e-02f, -8.81009400e-02f, 1.08325981e-01f, -2.95080483e-01f, -2.93796957e-02f, -7.92525336e-03f, -9.00054350e-02f, 1.37242168e-01f,
  -4.27242219e-02f, 7.26981536e-02f, -1.34103417e-01f, -6.85930476e-02f, -1.14333548e-01f, 1.07716024e-01f, 2.51450017e-03f, 4.44156379e-02f, -8.09352398e-02f, 1.02080308e-01f,
  1.65317412e-02f, -7.15308189e-02f, -7.87800774e-02f, -5.87887466e-02f, 9.69570875e-02f, 1.06842844e-02f, 1.22671284e-01f, -2.49869116e-02f, 2.55995337e-02f, 6.96915984e-02f,
  2.73078997e-02f, 4.12852839e-02f, 1.02719748e-02f, 1.16153255e-01f, 8.74765292e-02f, -1.37542516e-01f, 7.55793527e-02f, 1.10044908e-02f, -4.92343605e-02f, 6.44864738e-02f,
  -4.62941639e-02f, -2.20722817e-02f, -2.03105565e-02f, 1.00567462e-02f, 5.26753105e-02f, -3.11073475e-02f, -8.16904102e-03f, -2.84174997e-02f, -1.68407634e-02f, -1.97884603e-03f,
  -1.62684694e-02f, 9.83695462e-02f, -7.47870561e-03f, 2.93333251e-02f, 1.62886188e-03f, 3.22197825e-02f, -4.38980199e-02f, 9.66838673e-02f, -2.63654944e-02f, 5.13447821e-02f,
  -8.06921273e-02f, -1.93728728e-03f, 9.18038748e-03f, 5.36998920e-03f, -3.07161249e-02f, -1.33703966e-02f, 4.09887917e-02f, 6.87834807e-03f, 2.06763372e-02f, -3.78707275e-02f,
  -5.14203981e-02f, -9.69979465e-02f, -3.95118892e-02f, 1.36617373e-03f, -6.41815960e-02f, 1.59607418e-02f, 4.18956988e-02f, -7.34570622e-02f, 1.16859656e-03f, 1.22994687e-02f,
  2.10510734e-02f, 9.91167724e-02f, -6.58338424e-03f, -1.31396679e-02f, -8.81381631e-02f, 5.89504093e-02f, 5.02612591e-02f, -6.98322058e-02f, 7.43506551e-02f, 1.18889362e-01f,
  5.41853681e-02f, 7.32242242e-02f, 4.43389453e-02f, -5.58193214e-03f, 4.88224924e-02f, 1.00839650e-02f, 1.28457826e-02f, -2.76413467e-02f, -3.10262647e-02f, 9.80547145e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.95501727e-02f, -1.69262707e-01f, 1.97714925e-01f, 8.76939669e-02f, 3.37073237e-01f, 3.78845662e-01f, 3.50957423e-01f, 1.30940884e-01f, -2.43482739e-03f, 3.59417908e-02f,
  -2.74455212e-02f, -1.80338383e-01f, -1.43933222e-01f, -2.10336715e-01f, -8.56979117e-02f, 1.22474059e-01f, 1.42896444e-01f, -6.23730347e-02f, 9.74796489e-02f, 1.59036368e-01f,
  -4.96592857e-02f, 4.12449874e-02f, -1.45559922e-01f, -1.44255921e-01f, -9.05676857e-02f, -2.12847441e-02f, 2.86011975e-02f, 1.18185813e-02f, 8.16605985e-04f, 1.62227768e-02f,
  -1.11341178e-01f, 7.60968998e-02f, -5.52239344e-02f, -1.20239824e-01f, 2.78541679e-03f, 2.18157619e-02f, -4.94596399e-02f, -7.82254860e-02f, -8.41718987e-02f, -3.82137746e-02f,
  1.96171794e-02f, -1.11793811e-02f, 4.84073274e-02f, 5.84333725e-02f, 4.81382720e-02f, 1.00838989e-01f, -1.09265402e-01f, -1.05286144e-01f, -6.80019930e-02f, -6.86643273e-02f,
  3.66477855e-02f, 6.71181232e-02f, 8.51219967e-02f, 1.07638545e-01f, 1.77445579e-02f, -7.24438205e-02f, -3.26740257e-02f, -7.10697472e-02f, 2.05134936e-02f, -4.85762730e-02f,
  5.40919341e-02f, -4.63216379e-03f, 1.93417002e-03f, 5.13641536e-02f, -6.55679479e-02f, -2.98522366e-03f, 8.37838859e-04f, -4.62192930e-02f, 8.56140703e-02f, -7.30946809e-02f,
  -3.11017931e-02f, -2.74626561e-03f, 1.85884945e-02f, -4.15660404e-02f, -3.27822343e-02f, 5.11021353e-02f, 1.44934086e-02f, -6.77368743e-03f, -4.10633385e-02f, -3.39431539e-02f,
  -1.01598138e-02f, 3.08525097e-02f, 8.80729035e-02f, -6.89742863e-02f, 3.34568396e-02f, -1.91630032e-02f, -2.06956938e-02f, 7.68321101e-03f, -4.13666442e-02f, 6.60732612e-02f,
  -1.29314318e-01f, 7.74665922e-02f, -6.00613803e-02f, -2.44248584e-02f, 1.20922819e-01f, -1.32823050e-01f, 3.92235406e-02f, -1.21440105e-01f, 3.47508527e-02f, -2.69896910e-02f,
  5.31175658e-02f, -5.47085963e-02f, 2.29942724e-02f, 2.64427178e-02f, 1.14596523e-01f, -2.67516896e-02f, 1.25964405e-02f, 8.78347009e-02f, -4.83910926e-03f, 7.95840845e-02f,
  -1.00127243e-01f, 4.87831281e-03f, 1.47737125e-02f, 6.73048571e-02f, -1.23661734e-01f, -1.76989008e-02f, 8.79526213e-02f, 3.79559360e-02f, -2.64341547e-03f, -6.25444129e-02f,
  1.90954939e-01f, -4.41248477e-01f, 3.82869355e-02f, -7.95116797e-02f, 7.74795935e-02f, 9.72721130e-02f, 9.37426612e-02f, -4.99714874e-02f, -6.52633235e-02f, -9.61796790e-02f,
  -1.59697235e-01f, 6.92244917e-02f, 4.89183106e-02f, -4.81240787e-02f, 3.79586816e-02f, -1.65807176e-02f, -6.77141920e-02f, 1.31985992e-02f, 4.06589478e-01f, 2.31764466e-01f,
  -5.00999689e-02f, 2.66245697e-02f, -6.23614080e-02f, 6.38488457e-02f, -6.51622191e-02f, 1.17934480e-01f, -1.68452248e-01f, -1.02810010e-01f, -1.78048201e-02f, -2.46555492e-01f,
  2.50127017e-01f, -2.56638765e-01f, 1.09337538e-01f, -7.84691200e-02f, -5.15611693e-02f, -6.24721358e-03f, 7.64969513e-02f, -3.48821320e-02f, 3.91250253e-02f, 6.05342025e-03f,
  -6.02358207e-02f, -2.70097721e-02f, 5.31066060e-02f, -5.67279831e-02f, -1.45052550e-02f, 1.34836182e-01f, -1.50343254e-01f, -3.46830450e-02f, 3.75850126e-02f, -2.54689828e-02f,
  -1.49307102e-01f, -6.71517253e-02f, -7.04712197e-02f, -3.03535871e-02f, -5.15348054e-02f, -2.92477477e-02f, -1.34741634e-01f, -1.45025015e-01f, -5.00366427e-02f, 5.31073101e-03f,
  2.49852072e-02f, 5.96277229e-02f, -1.98440123e-02f, -6.82396116e-04f, 8.51600170e-02f, 2.21589301e-02f, 1.82458535e-02f, 9.87508222e-02f, -1.87736470e-02f, 3.05727888e-02f,
  -4.79935445e-02f, 7.64516741e-03f, 2.91100983e-02f, 2.91311853e-02f, -2.41753310e-02f, -9.20801163e-02f, 5.91055378e-02f, -2.91560553e-02f, -1.67278759e-02f, -4.21306156e-02f,
  -2.39405483e-02f, -1.04233315e-02f, -4.70592156e-02f, 2.37948950e-02f, -1.25037014e-01f, -4.93311174e-02f, 4.52600680e-02f, 4.21227738e-02f, -2.91909389e-02f, -7.06572756e-02f,
  6.83847591e-02f, -2.18491957e-01f, 4.69288118e-02f, 9.93806347e-02f, 4.70049493e-02f, -1.46378353e-01f, 4.90534604e-02f, -3.89962681e-02f, -9.88978073e-02f, 1.59287937e-02f,
  1.80012882e-02f, 4.41712439e-02f, 1.11032678e-02f, -1.33367196e-01f, 1.79648593e-01f, 1.60135608e-02f, -1.04847118e-01f, 9.48249027e-02f, -1.03804342e-01f, -1.35692013e-02f,
  2.45902892e-02f, 1.66134521e-01f, 1.94670305e-01f, 1.33168921e-01f, 1.03516169e-01f, 1.79112062e-01f, 1.35379016e-01f, 9.86988693e-02f, 1.90338239e-01f, 1.47756159e-01f,
  -2.11787969e-02f, 7.51328841e-02f, -1.10002793e-02f, 1.12254076e-01f, -2.45782677e-02f, 8.70109648e-02f, 8.56863111e-02f, 1.28064156e-01f, 4.84109577e-03f, 7.94395804e-02f,
  -5.35070971e-02f, -4.62458134e-02f, -1.12187513e-03f, 1.08297221e-01f, 6.39780238e-02f, 2.22396657e-01f, 1.73637450e-01f, 5.68453819e-02f, 1.12097487e-01f, -1.02806063e-02f,
  7.65488818e-02f, -2.84915464e-03f, 1.32745802e-02f, -2.72046011e-02f, 1.97357059e-01f, 9.32239071e-02f, 2.14736983e-02f, -1.11797182e-02f, -5.50906286e-02f, 2.47891203e-01f,
  -8.98390859e-02f, 2.11211238e-02f, -1.79781429e-02f, 5.48059754e-02f, -3.80393453e-02f, -2.68025715e-02f, -8.00484885e-03f, 6.41842335e-02f, 5.08011924e-03f, -2.04028022e-02f,
  -2.79668812e-02f, 4.26535355e-03f, 1.51889864e-02f, -6.49905652e-02f, 7.02346489e-02f, -2.70902123e-02f, 4.95544029e-03f, 1.27761230e-01f, -2.93878503e-02f, 2.87634172e-02f,
  -1.15704266e-02f, -1.03124836e-03f, -1.75836682e-02f, -2.33631544e-02f, 5.03733903e-02f, -2.65703257e-02f, -1.32753178e-01f, 6.00263886e-02f, -9.94793624e-02f, 6.00312874e-02f,
  -8.83879662e-02f, -7.37018883e-02f, -1.88143235e-02f, -2.88961176e-02f, -2.84117591e-02f, -2.49952860e-02f, -1.06546655e-02f, 2.48822197e-02f, -7.34120533e-02f, -2.55861972e-02f,
  -4.64891456e-02f, -2.34993035e-03f, 6.73031732e-02f, 1.57528743e-02f, -8.05908665e-02f, -2.26268955e-02f, -9.06751771e-03f, -8.13902244e-02f, -4.72621322e-02f, 9.35231522e-02f,
  -3.62992585e-02f, 7.83258528e-02f, 3.40418741e-02f, 6.84510842e-02f, -4.12294231e-02f, -1.04616128e-01f, -2.86778454e-02f, -6.87020794e-02f, 3.86092835e-03f, 5.07499166e-02f,
  7.85493553e-02f, -7.79981986e-02f, 1.45838395e-01f, 1.34624839e-01f, -1.99197624e-02f, 1.89787671e-02f, 3.18772160e-02f, 6.78980201e-02f, 6.62378594e-02f, 1.42546028e-01f,
  8.46858248e-02f, -2.38692835e-02f, 8.06381777e-02f, -8.55393782e-02f, -6.70550391e-02f, -2.49007624e-02f, 3.14623900e-02f, 1.37725368e-01f, 5.64585440e-02f, 2.76641920e-02f,
  -1.07588870e-02f, -8.89030918e-02f, -1.09358832e-01f, 5.01556210e-02f, 3.32464129e-02f, -4.41551395e-02f, -7.17990706e-03f, 1.59548931e-02f, 2.57202983e-03f, -3.15771736e-02f,
  -3.15041602e-01f, -2.24618554e-01f, 9.85823721e-02f, -1.72042936e-01f, -2.88396534e-02f, 1.95060447e-01f, -1.10895932e-01f, 1.07630268e-01f, -6.55998141e-02f, -2.71915913e-01f,
  -3.57314907e-02f, -7.48186558e-02f, -5.63671580e-03f, 7.72714689e-02f, -5.92155457e-02f, -1.84783965e-01f, -2.51387537e-01f, -6.02128357e-02f, 1.35836110e-01f, 1.50502831e-01f,
  -8.64802152e-02f, -6.65355101e-02f, 6.93822699e-03f, 5.83721250e-02f, -5.05697094e-02f, 2.29380108e-04f, 1.68509651e-02f, -5.03223054e-02f, 5.28778955e-02f, -2.89386988e-01f,
  -9.32884067e-02f, 7.45067671e-02f, 4.77358550e-02f, -8.43776092e-02f, -5.18317632e-02f, 6.24212250e-02f, -9.19142067e-02f, -2.70366613e-02f, 1.03328958e-01f, -3.80233862e-02f,
  -6.21054918e-02f, 3.79550196e-02f, -1.21178307e-01f, 6.31877482e-02f, -3.04421061e-03f, -4.30930741e-02f, 9.49949101e-02f, 7.80434012e-02f, -5.04952669e-02f, -1.16508249e-02f,
  -3.16089094e-02f, -9.58437566e-03f, -8.90410226e-03f, 6.41055778e-02f, 1.01736732e-01f, 1.07157625e-01f, 5.34706227e-02f, 1.03253558e-01f, 4.15905304e-02f, -1.84402630e-01f,
  -6.70441566e-03f, -2.29546949e-02f, -2.06334330e-02f, 5.84144928e-02f, -7.47310836e-03f, 5.01411362e-03f, 6.07498363e-02f, -4.45375443e-02f, 2.07495373e-02f, 5.30061498e-03f,
  -2.87246639e-05f, 8.22593868e-02f, 1.55380764e-03f, -9.59117711e-02f, 5.96900992e-02f, 1.69458031e-03f, 2.33742204e-02f, -6.86951773e-03f, -5.40177077e-02f, 3.50875780e-02f,
  -3.61019671e-02f, -5.85062383e-03f, -6.61285743e-02f, 5.95103689e-02f, -1.04765803e-01f, -2.86360458e-02f, 5.46525698e-03f, 2.11098175e-02f, 4.18501198e-02f, 2.29923148e-02f,
  -8.14379603e-02f, 1.82006955e-02f, -1.68255836e-01f, 3.52161564e-02f, -7.39417225e-02f, 8.71723052e-03f, 7.38680288e-02f, -4.88085449e-02f, 5.42338118e-02f, 5.02506346e-02f,
  5.32004014e-02f, -1.38939684e-02f, 3.06744291e-03f, 1.95924602e-02f, -1.29009262e-02f, 3.43780071e-02f, -1.26573563e-01f, -1.45236868e-02f, 5.61257675e-02f, 1.82881970e-02f,
  -1.38564289e-01f, -2.11314246e-01f, -1.46183535e-01f, 3.44634578e-02f, -5.18575795e-02f, -5.67953214e-02f, 6.93287551e-02f, 5.84159195e-02f, -1.20744899e-01f, -1.18805654e-01f,
  -4.00894135e-01f, -1.25408806e-02f, -9.19610485e-02f, -1.14985153e-01f, 1.97717473e-01f, 1.01136252e-01f, 1.39438659e-01f, 6.45518005e-02f, 3.85575704e-02f, 1.07708700e-01f,
  2.55176108e-02f, 5.13041094e-02f, -7.54999071e-02f, 1.10789120e-01f, -8.64069387e-02f, 9.65313241e-02f, 6.14573769e-02f, -1.67821437e-01f, -5.21159619e-02f, 5.41716963e-02f,
  9.87203345e-02f, -4.23485637e-02f, -2.74318188e-01f, -7.06816986e-02f, 1.07966833e-01f, -1.24778531e-01f, -1.40436918e-01f, -4.23478633e-02f, 7.41106318e-03f, 3.22870798e-02f,
  6.56346083e-02f, -5.94008230e-02f, 5.56560867e-02f, -8.20939988e-02f, -1.05815023e-01f, -1.20156305e-02f, 1.64818112e-02f, -9.33005512e-02f, 1.55377919e-02f, -7.61198550e-02f,
  1.74737703e-02f, 3.30354162e-02f, -4.92343009e-02f, 6.63029030e-02f, -3.35541740e-02f, -5.67581365e-03f, -1.97921768e-02f, -9.18571278e-02f, -4.97463346e-02f, 7.45832101e-02f,
  1.11183859e-01f, 1.22217927e-02f, -1.07922196e-01f, 4.95115183e-02f, -2.60009784e-02f, -2.10854206e-02f, -1.81942116e-02f, -1.71466637e-02f, -8.48529395e-03f, -1.48725256e-01f,
  9.90095586e-02f, 5.23435697e-02f, -1.48678627e-02f, 6.09988682e-02f, -2.23047305e-02f, -4.65887226e-02f, 1.05997816e-01f, 1.02685310e-01f, -2.22902037e-02f, -6.91137882e-03f,
  -2.02595275e-02f, 2.01096795e-02f, 2.21396498e-02f, 3.27237733e-02f, -1.81710962e-02f, 1.58890765e-02f, -1.88795347e-02f, -7.03839511e-02f, -5.63867763e-03f, 8.49644989e-02f,
  -3.07737719e-02f, -4.80345031e-03f, 2.26416085e-02f, 6.21962585e-02f, -3.61434072e-02f, -2.70817373e-02f, 3.66983865e-03f, -6.79351273e-04f, -8.83890316e-02f, -4.27625254e-02f,
  -2.68181741e-01f, 3.36468132e-04f, -4.50895447e-03f, 9.07808691e-02f, 4.05869521e-02f, -3.34822200e-02f, -6.14236444e-02f, -8.48480761e-02f, -8.32509075e-04f, -8.00452083e-02f,
  2.01568659e-02f, -7.97333121e-02f, -2.00026147e-02f, 2.90952455e-02f, -3.20444778e-02f, -1.99852651e-03f, 4.69689891e-02f, 1.67721249e-02f, -8.20316598e-02f, -3.10067963e-02f,
  -5.92627302e-02f, -8.08756724e-02f, -8.19633976e-02f, -8.27497542e-02f, -1.57740265e-02f, -1.30582780e-01f, -8.49098936e-02f, -1.06886148e-01f, -3.49553041e-02f, -1.53292120e-01f,
  6.27389371e-01f, -2.48208776e-01f, -2.83384770e-01f, 1.38543323e-01f, -1.00528523e-01f, 4.62538265e-02f, -1.00749373e-01f, -5.55052869e-02f, 3.77125107e-02f, -7.29551390e-02f,
  3.10557652e-02f, 2.18654647e-01f, 2.29933411e-01f, 1.41128048e-01f, 2.24826500e-01f, -2.23160386e-01f, -2.14475393e-01f, 1.25708142e-02f, 1.84966579e-01f, -4.67662746e-03f,
  4.71137501e-02f, -1.04923867e-01f, 5.64401746e-02f, 2.19721291e-02f, -1.51074156e-01f, -2.52243634e-02f, -2.71110445e-01f, -1.41475663e-01f, -8.82166531e-03f, -2.50533432e-01f,
  -1.03867128e-01f, 3.02857757e-02f, 1.18866809e-01f, 1.21041663e-01f, -4.39754575e-02f, 4.55682762e-02f, -2.29547592e-03f, -5.93532957e-02f, 3.15369815e-02f, -7.54574537e-02f,
  5.68915941e-02f, 2.11665183e-02f, -2.16445532e-02f, -6.60072193e-02f, -2.17108075e-02f, -4.59674671e-02f, -9.06039253e-02f, -2.13796310e-02f, 2.82010678e-02f, 3.46141122e-02f,
  1.85482632e-02f, -5.88825457e-02f, -5.88988140e-02f, -6.32154942e-02f, 6.89667985e-02f, 1.32902473e-01f, -1.05790064e-01f, -2.85701063e-02f, 4.44804691e-02f, -8.22321996e-02f,
  -7.24026514e-03f, 1.85434967e-02f, 9.93078575e-02f, -1.20352827e-01f, 5.37900627e-02f, 3.31741897e-03f, -1.01731226e-01f, -3.00255045e-02f, 8.33744463e-03f, -2.03887243e-02f,
  -2.86022928e-02f, 5.04781157e-02f, 1.35983881e-02f, 7.70893274e-03f, -2.63474137e-02f, 5.65942489e-02f, 1.15243504e-02f, 2.38754898e-02f, -3.07768211e-02f, 7.20156431e-02f,
  3.27570066e-02f, 3.55293266e-02f, -6.44795373e-02f, -5.95742371e-03f, -1.03220334e-02f, 7.83409458e-03f, 6.51273504e-03f, 1.60319591e-03f, -1.64929386e-02f, 4.82466817e-02f,
  3.71368136e-04f, 2.15671629e-01f, 7.38972202e-02f, 1.80380531e-02f, -4.56927493e-02f, -1.46543868e-02f, 5.57985716e-02f, 2.96526793e-02f, 4.19883505e-02f, -8.95725843e-03f,
  4.99988049e-02f, 8.71255528e-03f, -1.10541999e-01f, 1.67264082e-02f, -5.45841604e-02f, 5.82250245e-02f, 1.00834593e-02f, 6.65784031e-02f, 3.20800059e-02f, -3.47130261e-02f,
  -1.17448956e-01f, 2.60289218e-02f, 1.75626621e-01f, 2.67474335e-02f, -5.99381048e-04f, 1.90782487e-01f, -1.39558375e-01f, -6.30549565e-02f, 1.14422008e-01f, -5.04259057e-02f,
  1.28693968e-01f, -7.36103356e-02f, -4.11714502e-02f, 1.43793970e-01f, -2.63447985e-02f, 1.08869988e-02f, -1.35240719e-01f, 5.42015843e-02f, 2.76954137e-02f, -1.94425303e-02f,
  6.14857078e-02f, 2.93913186e-01f, 2.18680993e-01f, 2.25587592e-01f, 1.36868030e-01f, 4.96845730e-02f, -1.33897111e-01f, 6.95960298e-02f, 1.09401427e-01f, 4.28276509e-03f,
  -2.47051613e-03f, -1.20425418e-01f, 7.50416238e-03f, 1.89038012e-02f, -1.16911002e-01f, 5.95794581e-02f, -7.91835710e-02f, -1.05117619e-01f, -1.77695770e-02f, -9.09694582e-02f,
  1.24235526e-01f, 4.82850485e-02f, 1.06173828e-01f, 3.26092318e-02f, -8.94781724e-02f, 4.87814471e-02f, 5.65520376e-02f, -2.02551577e-02f, 6.13894919e-03f, -9.77842510e-02f,
  9.62679163e-02f, -8.93910155e-02f, -1.07945809e-02f, -2.61660423e-02f, 7.09493784e-03f, 5.97668327e-02f, -1.24227311e-02f, 6.36038557e-02f, 2.91505568e-02f, -2.67410185e-03f,
  -3.18510719e-02f, 3.22012492e-02f, 1.17327347e-01f, 4.02206331e-02f, 3.66370603e-02f, 1.07215479e-01f, 5.97814918e-02f, 3.92160639e-02f, -1.93967130e-02f, -8.91993716e-02f,
  2.73584779e-02f, -5.24693765e-02f, 9.56446305e-03f, 5.74874431e-02f, 8.73062611e-02f, -6.66180998e-02f, 9.49985906e-02f, 8.63687787e-03f, -8.79080370e-02f, -5.52292988e-02f,
  -4.98290807e-02f, 6.12114705e-02f, -3.93513814e-02f, 3.02135143e-02f, -2.00767275e-02f, -3.17028277e-02f, -1.01489760e-01f, 8.95272642e-02f, 8.54830965e-02f, 3.44092324e-02f,
  -7.58820819e-03f, -1.46342032e-02f, 5.18323332e-02f, -8.18765536e-02f, -1.21536590e-02f, 2.30996939e-03f, 1.15875322e-02f, -7.16892928e-02f, -1.57717653e-02f, -4.12784293e-02f,
  -2.15119608e-02f, 7.22196773e-02f, 7.98580945e-02f, -2.11399030e-02f, -5.75611480e-02f, -4.28082747e-03f, -2.82223453e-03f, 4.59237173e-02f, -3.67924087e-02f, -4.97457422e-02f,
  -3.72882374e-03f, 7.91534502e-03f, 6.88785501e-03f, -9.94215459e-02f, -8.04237789e-04f, -3.51951830e-02f, 3.28887105e-02f, 9.44756418e-02f, 4.20530140e-02f, -2.82302182e-02f,
  -5.28621338e-02f, 1.25517502e-01f, 2.12116688e-01f, 1.13407403e-01f, -4.83078090e-03f, 5.97397648e-02f, 2.44317763e-02f, 3.30097489e-02f, 1.30992919e-01f, -4.44977470e-02f,
  -7.13757947e-02f, 4.60066050e-02f, 1.36120776e-02f, 7.16929659e-02f, 8.44725519e-02f, 8.52262005e-02f, 5.26459254e-02f, -5.16437590e-02f, 4.80122939e-02f, -3.97642031e-02f,
  7.85766765e-02f, -3.56772691e-02f, -1.68098938e-02f, -7.96676576e-02f, -5.16531654e-02f, -8.16610232e-02f, -4.28815708e-02f, 5.26102781e-02f, 3.73291336e-02f, 5.18060327e-02f,
  -2.39373203e-02f, -2.41397396e-02f, -7.48611838e-02f, 3.83813232e-02f, -4.37745191e-02f, 4.53714281e-02f, -5.30476645e-02f, 2.48929579e-02f, 1.33956652e-02f, -3.92229616e-04f,
  1.06145546e-01f, -4.46779132e-02f, -9.82825756e-02f, 2.74342187e-02f, 7.54924640e-02f, -1.04034521e-01f, -2.48302817e-02f, -2.36440860e-02f, -6.44570515e-02f, -3.16200964e-02f,
  -6.73364848e-02f, -3.49377394e-02f, 5.58662005e-02f, -7.51886293e-02f, -1.05923176e-01f, -8.06305632e-02f, -9.57598388e-02f, -7.17898831e-02f, -5.43366559e-02f, -9.04782638e-02f,
  9.31881659e-04f, -9.75145176e-02f, -2.37289909e-02f, -1.11821808e-01f, -4.06737402e-02f, 4.89901081e-02f, -6.10011257e-02f, -3.60610522e-02f, -9.19572785e-02f, 1.64471772e-02f,
  3.71747315e-02f, 9.16281193e-02f, -6.73730522e-02f, -2.95633413e-02f, 1.69807859e-02f, 5.39918840e-02f, -6.70787171e-02f, -2.61289459e-02f, 1.13270268e-01f, -1.21834772e-02f,
  4.36863527e-02f, 1.05745986e-01f, 9.82024372e-02f, 1.30790872e-02f, 4.30039726e-02f, 5.54705784e-02f, 1.84348281e-02f, 6.84897304e-02f, 1.44575695e-02f, 7.87110627e-02f,
  1.11458106e-02f, 5.57796545e-02f, 2.89217159e-02f, 7.32287914e-02f, 5.69645911e-02f, -4.89885279e-04f, 3.66056301e-02f, 1.50925629e-02f, 1.39845125e-02f, 8.80069137e-02f,
  1.37546882e-01f, 2.10422613e-02f, -5.86693175e-02f, -7.87107423e-02f, -1.53132519e-02f, -1.69751775e-02f, -3.10593396e-02f, -4.86541167e-02f, -2.83918940e-02f, -3.76728200e-03f,
  7.70754553e-03f, -3.25196795e-02f, -2.52620727e-02f, 1.32940337e-02f, -1.04212061e-01f, 2.30597947e-02f, 9.36385393e-02f, -3.85629758e-02f, -6.11298122e-02f, 7.83237666e-02f,
  1.83496941e-02f, -9.56403837e-02f, 1.61857232e-02f, -5.23779169e-02f, 9.09532420e-03f, -7.08871335e-02f, 5.80601841e-02f, 2.68605947e-02f, -5.37471808e-02f, 2.86607631e-02f,
  -7.37768263e-02f, -3.70237641e-02f, -1.06357016e-01f, 1.61044002e-01f, 1.36480168e-01f, 4.46299277e-02f, 2.81535480e-02f, 1.68937907e-01f, 2.69724503e-02f, 3.61406729e-02f,
  5.83035201e-02f, 7.64806196e-02f, 9.38945562e-02f, 1.62161179e-02f, 1.46404222e-01f, 8.22391212e-02f, 9.30325538e-02f, 9.67887789e-02f, 3.91287357e-02f, 1.00901291e-01f,
  7.13020712e-02f, -5.62774390e-02f, -6.85273409e-02f, -2.16558259e-02f, -2.49450803e-02f, 3.63469943e-02f, -5.96067458e-02f, -3.47645059e-02f, -6.40266091e-02f, -2.78371051e-02f,
  -1.61133081e-01f, -3.87609415e-02f, 7.51237869e-02f, 8.69019255e-02f, -5.06920107e-02f, 3.33313942e-02f, -2.89773699e-02f, -3.72873135e-02f, -2.27590799e-02f, 7.67604262e-02f,
  -5.19258566e-02f, -2.38808114e-02f, -3.81053984e-02f, -4.86617647e-02f, -2.43322109e-03f, -1.03050554e-02f, -7.46738389e-02f, 5.95545396e-04f, 7.01618493e-02f, -5.41493706e-02f,
  5.65423630e-02f, -9.78130773e-02f, -1.80054866e-02f, -1.64574254e-02f, 7.21392706e-02f, 4.73342054e-02f, -4.54313979e-02f, -8.62606168e-02f, 6.57148808e-02f, 1.33993234e-02f,
  -1.71549525e-02f, -9.49490909e-03f, 3.66608128e-02f, -4.75743711e-02f, 6.92553520e-02f, 2.76066624e-02f, 8.84986892e-02f, -4.96271849e-02f, 1.78191327e-02f, -8.93363282e-02f,
  -4.98899035e-02f, -2.56149042e-02f, 7.41703808e-02f, -5.22125177e-02f, 6.11036830e-02f, 1.14988834e-01f, -1.35647506e-02f, 1.53023582e-02f, -3.45760249e-02f, -3.36297527e-02f,
  3.13588940e-02f, 8.38580653e-02f, -7.44986981e-02f, 1.44631509e-02f, -2.03568731e-02f, -1.01638930e-02f, -3.98033150e-02f, -4.50868830e-02f, 5.81204630e-02f, -3.49771604e-02f,
  -8.54434147e-02f, -2.62881927e-02f, 6.16573915e-02f, -1.83020141e-02f, -7.19157681e-02f, -2.11836956e-02f, 3.60106234e-03f, -6.86113611e-02f, -5.17074689e-02f, -4.65938114e-02f,
  6.79151118e-02f, -5.77151477e-02f, 1.01902643e-02f, -7.06252530e-02f, -9.45804268e-03f, -1.02522708e-01f, 1.57534480e-02f, 3.60568017e-02f, 5.69590330e-02f, -8.33540633e-02f,
  -9.93030742e-02f, 5.37880277e-03f, 5.51625527e-02f, 1.05203815e-01f, -2.79561803e-02f, 1.27347425e-01f, 4.98271920e-02f, -9.20543913e-03f, 1.46272061e-02f, 1.81994606e-02f,
  -8.17208141e-02f, 1.01966679e-01f, -1.67918652e-01f, 2.37509459e-01f, 3.81344371e-02f, -1.60084769e-01f, 9.75970179e-02f, -1.06777567e-02f, 7.52610341e-02f, -1.72151811e-03f,
  -1.11837938e-01f, 7.32033700e-02f, 4.06508259e-02f, 1.25541821e-01f, -1.90001298e-02f, 1.80786550e-01f, 3.11742365e-01f, -7.48446165e-03f, -3.42089683e-02f, 9.76088047e-02f,
  2.64785826e-01f, -2.96770334e-02f, 1.58252406e-05f, 8.30594450e-02f, 2.08851546e-01f, -4.84342389e-02f, 5.39896898e-02f, 4.46340479e-02f, -5.28527889e-03f, 4.34740603e-01f,
  -6.38119653e-02f, -1.42212044e-02f, -4.39189523e-02f, 5.42019494e-02f, -3.90887819e-02f, 1.81884300e-02f, -6.74839541e-02f, -3.92522439e-02f, -4.65732887e-02f, 3.03111430e-02f,
  2.32542492e-03f, -3.13204229e-02f, 1.82719100e-02f, 7.34225288e-02f, 3.57721038e-02f, 6.08863831e-02f, 6.28277957e-02f, -5.13133854e-02f, -2.09812615e-02f, -8.14604983e-02f,
  1.56671405e-01f, -7.11336955e-02f, -9.57027301e-02f, -6.42499700e-03f, 3.49944793e-02f, 8.46574269e-03f, -1.36144519e-01f, 6.26698956e-02f, -6.06578700e-02f, 4.32684012e-02f,
  -3.97945382e-02f, 6.82756081e-02f, -1.20288596e-01f, 2.75740996e-02f, 1.23005874e-01f, 7.26828948e-02f, 2.84569338e-02f, 1.63942873e-02f, 1.05470635e-01f, 2.91293561e-02f,
  -9.79072750e-02f, -4.37593013e-02f, -1.02535814e-01f, 4.82785376e-03f, 4.83623929e-02f, -2.16530450e-02f, 1.04926331e-02f, 2.00766735e-02f, -7.52659962e-02f, -1.76079702e-02f,
  9.21823904e-02f, -6.03149496e-02f, 5.56835756e-02f, -3.15939113e-02f, -2.53300965e-02f, 6.82831928e-03f, 8.43806490e-02f, 1.39521221e-02f, -5.18708564e-02f, 6.89672679e-02f,
  1.09231412e-01f, -3.40058357e-01f, 4.51179668e-02f, 5.55173531e-02f, 2.63485499e-02f, 1.12062069e-02f, -4.31037210e-02f, -2.01316662e-02f, -4.43497039e-02f, -2.94583645e-02f,
  9.46319848e-03f, -4.61162850e-02f, -5.01906872e-02f, 5.32137789e-03f, -1.16876718e-02f, -3.37458728e-03f, -1.02114454e-01f, -8.63196030e-02f, -1.56089524e-02f, -5.21011883e-03f,
  -7.05790818e-02f, -5.97980879e-02f, -1.19293287e-01f, 1.61723979e-02f, -6.26502931e-02f, -6.80124909e-02f, -6.24868795e-02f, -6.01957962e-02f, -2.37330601e-01f, -7.22295120e-02f,
  1.61633752e-02f, -1.16574466e-01f, -1.74687237e-01f, 3.84872891e-02f, -3.77895753e-03f, 3.87848802e-02f, -9.73333046e-03f, 6.40715063e-02f, 5.74076287e-02f, 5.44504039e-02f,
  -1.45786643e-01f, -2.92757601e-02f, -1.00830927e-01f, -4.33849990e-02f, 6.95641413e-02f, -4.57461476e-02f, 1.03601545e-01f, -1.62412729e-02f, 6.20076954e-02f, 7.15427799e-03f,
  7.05763744e-03f, 8.88984352e-02f, -5.21420948e-02f, 1.31883249e-01f, 7.55775049e-02f, -1.79996397e-02f, -4.01636325e-02f, -8.76091979e-03f, 1.25289252e-02f, -1.84228718e-02f,
  -1.09730966e-01f, -1.51836336e-01f, 7.04551339e-02f, 2.31699608e-02f, -6.84451833e-02f, 3.92289385e-02f, -8.77567381e-02f, -8.13581273e-02f, 1.38035342e-02f, 2.50549102e-03f,
  -8.72011185e-02f, 5.83171025e-02f, 1.54653918e-02f, -8.43185782e-02f, -3.44075300e-02f, -1.44497165e-02f, -4.45711240e-02f, 3.20162512e-02f, -6.00619055e-03f, -7.90384933e-02f,
  -8.59763697e-02f, -1.15588620e-01f, 2.28394661e-02f, -2.83027790e-03f, -5.10276034e-02f, 4.97369803e-02f, -2.68511008e-02f, 3.53235845e-03f, -1.31000638e-01f, 2.88485773e-02f,
  -2.42954437e-02f, -9.24389884e-02f, 4.89593484e-02f, 6.20462149e-02f, 1.70588680e-02f, 4.30237465e-02f, -6.06666543e-02f, -2.27799900e-02f, 4.96996567e-03f, -1.29962973e-02f,
  -5.41031249e-02f, 6.11740686e-02f, 2.85769366e-02f, -5.92528656e-02f, 1.49854356e-02f, 1.95647012e-02f, -6.87452592e-03f, 6.65550902e-02f, 6.72218502e-02f, 2.77422145e-02f,
  2.14984976e-02f, -6.46170229e-02f, -3.32235657e-02f, -2.20512059e-02f, 3.62827182e-02f, -7.30075501e-03f, 3.82525697e-02f, 1.68835595e-02f, -9.09955055e-03f, 4.17852402e-02f,
  6.57247379e-02f, -1.42075002e-01f, -5.07676322e-03f, -8.47374201e-02f, 6.17865622e-02f, 4.59343828e-02f, -6.27801865e-02f, 1.90420561e-02f, -5.13084866e-02f, 3.83036584e-02f,
  -1.36809602e-01f, 1.80966537e-02f, -6.31348938e-02f, -4.31094095e-02f, 6.73320889e-02f, 1.06337167e-01f, 1.09311067e-01f, -1.18870735e-02f, -2.33034957e-02f, -6.40400052e-02f,
  8.68623890e-03f, 1.08544871e-01f, -2.36297827e-02f, 7.25191180e-03f, -6.61953166e-02f, -4.00882401e-02f, -8.40575472e-02f, -5.58159016e-02f, 8.11876878e-02f, 1.19198732e-01f,
  -3.66272062e-01f, 6.83004260e-02f, 2.14173809e-01f, -2.59087741e-01f, -1.12102330e-01f, 3.60351875e-02f, 7.18022957e-02f, -4.38176952e-02f, -9.08278152e-02f, 4.40112986e-02f,
  9.41044763e-02f, 4.26761918e-02f, 4.46166843e-02f, 7.79494410e-03f, -1.86271727e-01f, -5.92099838e-02f, -5.08571267e-02f, -1.59627616e-01f, -1.47839468e-02f, 2.62610205e-02f,
  -1.61024317e-01f, -2.06728846e-01f, -1.33054867e-01f, -1.16299480e-01f, 2.59614401e-02f, 2.44233143e-02f, -2.70555764e-02f, -6.13977984e-02f, 5.34011610e-02f, -1.07613057e-01f,
  3.59164387e-01f, -1.38344869e-01f, -1.18623592e-01f, -1.41147465e-01f, 7.98031390e-02f, -6.46580756e-02f, 6.24434315e-02f, -2.53149197e-02f, -9.45140198e-02f, -4.13487777e-02f,
  6.32009748e-03f, 4.10054699e-02f, 4.90669273e-02f, -1.48301991e-02f, 8.26498419e-02f, 1.85994972e-02f, -8.40016827e-02f, -5.55540621e-02f, -3.27829048e-02f, 3.82470638e-02f,
  7.78998211e-02f, 2.27803476e-02f, 5.42506538e-02f, 1.06739402e-01f, 3.04689240e-02f, -9.35733616e-02f, 9.83556509e-02f, 1.02843188e-01f, 1.07911758e-01f, 1.13084562e-01f,
  -3.85042466e-02f, -6.44749869e-03f, 9.93861333e-02f, -6.90716803e-02f, 1.99791342e-02f, 1.03583150e-02f, -3.73064615e-02f, 2.37322599e-02f, -2.21528765e-02f, 2.44611744e-02f,
  8.11670627e-03f, -6.74539581e-02f, 8.53534192e-02f, 4.03914048e-04f, 7.01170340e-02f, 1.61587577e-02f, -1.15912110e-01f, -7.55492821e-02f, 4.02900688e-02f, -3.05802133e-02f,
  5.08327149e-02f, -4.91611660e-02f, 1.77111980e-02f, 4.55056131e-02f, 1.18291732e-02f, -1.21260257e-02f, -1.03718169e-01f, 8.78180638e-02f, 4.51829955e-02f, -9.35550556e-02f,
  1.42723292e-01f, -1.39575243e-01f, -8.68335087e-03f, -1.52193299e-02f, -5.36524802e-02f, 6.17813282e-02f, -1.87683981e-02f, 5.95640950e-03f, -7.01599121e-02f, -4.67433184e-02f,
  -2.40096226e-02f, -5.71855530e-02f, 2.40719914e-02f, 7.56860673e-02f, -2.41932943e-02f, -5.70716299e-02f, 2.45826822e-02f, -9.76619050e-02f, -7.50394398e-03f, 3.39879654e-02f,
  3.54423299e-02f, -8.17738473e-03f, -3.79738621e-02f, -9.11962427e-03f, -4.91478853e-02f, -4.50910404e-02f, 1.36600286e-01f, 7.68676698e-02f, 5.99144325e-02f, -2.09418200e-02f,
  -1.83794439e-01f, 4.69499305e-02f, -4.94562322e-03f, -6.78976253e-02f, 1.46130592e-01f, 1.18376099e-01f, 1.01473041e-01f, 5.57474531e-02f, -7.55747259e-02f, -5.74255660e-02f,
  -8.75785723e-02f, 6.37805462e-02f, 2.77932989e-03f, -3.47937830e-02f, 7.88060110e-03f, 3.08869313e-02f, 3.62803303e-02f, -9.75373313e-02f, -3.73474360e-02f, -6.04492463e-02f,
  1.10797314e-02f, -3.57217938e-02f, 5.22155035e-03f, 2.18350217e-02f, 1.21261567e-01f, -6.48834929e-02f, -7.92683363e-02f, 1.02020791e-02f, 4.75252196e-02f, 1.19582713e-01f,
  9.08272564e-02f, -2.57834438e-02f, -1.43332362e-01f, -5.28554507e-02f, -8.07753578e-02f, 1.31108398e-02f, 4.13187705e-02f, -1.11080527e-01f, 2.18908750e-02f, 3.93957235e-02f,
  5.80479428e-02f, 4.34779972e-02f, -2.45021470e-02f, 2.04811413e-02f, -3.59896035e-03f, 1.03585003e-02f, -4.76469984e-03f, 3.46068246e-03f, -5.62918596e-02f, 8.32921732e-03f,
  1.16279749e-02f, 1.00196406e-01f, -2.13375241e-02f, -1.21247470e-02f, -1.70464665e-02f, 3.51760127e-02f, 1.49309635e-02f, -8.52446705e-02f, -7.88931400e-02f, 1.73014384e-02f,
  4.40503024e-02f, 9.88173038e-02f, 2.60509271e-02f, -7.31577817e-03f, 6.40993342e-02f, 4.13769707e-02f, 2.32299957e-02f, -8.91063586e-02f, -4.15891372e-02f, -4.22429927e-02f,
  -9.09088403e-02f, 3.76341701e-03f, -1.28163904e-01f, -1.21775940e-01f, -9.60623026e-02f, 4.91691120e-02f, -3.01653892e-02f, 7.96742663e-02f, 5.69062233e-02f, 3.23878787e-02f,
  -6.08927058e-03f, -7.51332566e-02f, -3.01856380e-02f, 4.07016277e-02f, 5.56988344e-02f, 7.47290850e-02f, -7.81672262e-03f, -5.93239143e-02f, 2.04210337e-02f, 7.25632161e-02f,
  -2.67483909e-02f, 3.53414565e-02f, -7.32416240e-03f, 1.42127126e-02f, 8.14672559e-04f, -5.67586198e-02f, 3.59050632e-02f, -7.53958076e-02f, -5.34189492e-02f, -1.09169878e-01f,
  -1.15036555e-01f, -4.87690233e-02f, -4.77972366e-02f, 5.93183599e-02f, -1.84867028e-02f, -1.11535348e-01f, -1.95926670e-02f, 1.54874520e-02f, -7.80000836e-02f, -2.01858394e-02f,
  6.26696274e-02f, 3.77194360e-02f, -2.33902354e-02f, -1.02919854e-01f, -2.46345010e-02f, -9.13528539e-03f, -7.49713555e-03f, -1.03172481e-01f, -4.49186601e-02f, -1.33936629e-01f,
  4.79490543e-03f, -6.88814186e-03f, 2.37029865e-01f, 8.83828104e-02f, 3.11603040e-01f, 3.10019821e-01f, 3.62679988e-01f, 1.73977092e-01f, -3.19115538e-03f, 1.10194482e-01f,
  6.40740916e-02f, -1.05630778e-01f, -5.32906316e-02f, -1.12164810e-01f, -5.47164902e-02f, 1.19482629e-01f, 8.00605789e-02f, -7.97873586e-02f, 9.45789274e-03f, -1.25041977e-02f,
  -5.98956458e-02f, 3.97538505e-02f, -1.20384604e-01f, -1.28619343e-01f, -4.34634686e-02f, 4.98811379e-02f, 2.69025080e-02f, 8.01490694e-02f, -4.45833169e-02f, -1.46418676e-01f,
  -1.24256939e-01f, 9.23302099e-02f, 7.75199682e-02f, -4.74380888e-02f, 1.37694962e-02f, -5.75696751e-02f, -9.77478698e-02f, 4.82665747e-02f, -2.35114321e-02f, 5.48136756e-02f,
  -3.88370194e-02f, -4.39456515e-02f, 9.58298296e-02f, -1.59123540e-02f, 4.61571924e-02f, -6.55986369e-03f, -1.70655772e-02f, 2.61043496e-02f, -4.35027592e-02f, -4.25503738e-02f,
  -6.54267222e-02f, 1.32863894e-01f, 1.13402016e-01f, 1.12249076e-01f, 8.74313712e-02f, 1.18067022e-02f, -3.85360382e-02f, -5.75168245e-02f, 6.88230805e-03f, -1.48099735e-01f,
  -6.23974167e-02f, 3.92045565e-02f, 3.77551839e-02f, 2.25369609e-03f, 2.14572754e-02f, 1.41483750e-02f, 8.68735556e-03f, 5.11510633e-02f, 1.10411746e-02f, 5.15156379e-03f,
  -8.72760359e-03f, 4.96500097e-02f, -2.18739565e-02f, 7.54726455e-02f, -3.69929820e-02f, 2.96030398e-02f, -1.35097886e-02f, -1.70798674e-02f, 5.62635660e-02f, -3.76641676e-02f,
  -2.14681476e-02f, -5.03100862e-04f, -2.00232584e-02f, 6.06211983e-02f, 4.10082797e-03f, -5.87759018e-02f, 1.96851119e-02f, -2.15980802e-02f, -6.39700331e-03f, 8.65541212e-03f,
  -1.78078577e-01f, 5.74243329e-02f, -6.50266698e-03f, -8.40770602e-02f, -2.23950446e-02f, -5.88929728e-02f, 5.21986969e-02f, -3.87643091e-02f, 4.88457233e-02f, 2.50177756e-02f,
  7.36240819e-02f, -5.83257899e-02f, -4.77692857e-02f, 3.26803923e-02f, -3.82242501e-02f, -5.26934955e-03f, -7.24549294e-02f, 2.22710222e-02f, -7.46028200e-02f, -9.47490111e-02f,
  2.09223926e-02f, -6.80688024e-03f, -5.88349551e-02f, 1.90907065e-02f, 7.03462064e-02f, 7.14951083e-02f, 8.97191316e-02f, 2.74206586e-02f, 1.33183062e-01f, -6.41071424e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.91482112e-01f, 2.34264508e-01f, 2.76115295e-02f, 2.18061611e-01f, 6.84070662e-02f, 1.78021610e-01f, 8.78526419e-02f, 2.00091988e-01f, 7.37827942e-02f, -1.07446976e-01f,
  1.55679137e-01f, 5.62580079e-02f, -1.95207261e-02f, 7.96097070e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.16254296e-02f, 2.57683516e-01f, -9.40526873e-02f, -4.88961712e-02f, 1.92212224e-01f, -1.14823759e-01f, -6.70673028e-02f, -1.65627182e-01f, -1.40902579e-01f, 3.61742347e-01f,
  -1.26516610e-01f, 1.10922903e-01f, 5.24511114e-02f, -2.56435480e-02f, 2.77353942e-01f, 2.68103987e-01f, 1.60652161e-01f, -3.38030636e-01f, -2.52305895e-01f, 7.42967948e-02f,
  -1.55359711e-02f, 3.47538501e-01f, -1.57658886e-02f, 1.87283874e-01f, 1.76126957e-01f, 1.71531469e-01f, -1.91533297e-01f, -4.01137799e-01f, -2.84943253e-01f, 2.46664062e-01f,
  1.12280928e-01f, -4.76542413e-02f, -3.00938517e-01f, 5.71266003e-02f, -8.30058381e-02f, -3.85721952e-01f, -2.39507943e-01f, -2.69004971e-01f, -3.09863538e-01f, -3.55417490e-01f,
  7.59860035e-03f, 1.44464448e-01f, -1.63796842e-01f, 3.32342982e-02f, -4.09165740e-01f, -1.27056867e-01f, 4.42482680e-02f, 1.40677139e-01f, -8.40770826e-02f, 2.23741159e-01f,
  -2.90881574e-01f, -1.42609939e-01f, -1.71351165e-01f, 2.98502535e-01f, 1.32785678e-01f, -3.23289454e-01f, -1.21129841e-01f, -1.82757661e-01f, -2.11814910e-01f, -1.19913116e-01f,
  -1.17642872e-01f, -7.44374171e-02f, 2.34987900e-01f, -2.29203582e-01f, 1.47222176e-01f, 3.48150969e-01f, 3.41146588e-01f, 1.40067473e-01f, -6.34444579e-02f, 1.22998640e-01f,
  -3.78543347e-01f, -1.79612175e-01f, 1.59749866e-01f, 1.61818460e-01f, -1.93382397e-01f, -1.78339574e-02f, -1.26717702e-01f, -2.45294794e-02f, 3.26046571e-02f, -4.62462828e-02f,
  -1.63021341e-01f, -1.86480433e-01f, -7.54612461e-02f, -9.45907831e-02f, -1.67671382e-01f, 2.59510338e-01f, 1.88470095e-01f, -1.76634908e-01f, -2.86141019e-02f, 2.47967318e-02f,
  3.50667350e-02f, -1.47134876e-02f, -2.19996795e-02f, 1.60962373e-01f, -7.94206932e-02f, -3.03878281e-02f, 1.44699052e-01f, -2.81739563e-01f, -4.34070140e-01f, -3.66972953e-01f,
  2.71713972e-01f, -8.78068432e-02f, 3.02139282e-01f, 2.27514714e-01f, 1.31111965e-01f, 9.85625386e-02f, -3.40407252e-01f, -1.77038044e-01f, 1.69014588e-01f, -1.51330367e-01f,
  -1.44894749e-01f, -2.24287793e-01f, 3.50337058e-01f, -8.11037421e-02f, 2.57870942e-01f, -1.83808297e-01f, -8.88835359e-03f, -1.29472569e-01f, 1.84123278e-01f, 3.11106265e-01f,
  1.64692536e-01f, -7.95160085e-02f, 3.71879302e-02f, 4.97845672e-02f, -2.44818822e-01f, 2.31011193e-02f, 8.09110999e-02f, 1.76293984e-01f, -1.01989597e-01f, 1.12082567e-02f,
  1.07943930e-01f, 2.20288515e-01f, -3.72047812e-01f, -7.54249319e-02f, -3.51934321e-02f, 1.35681391e-01f, 1.06235899e-01f, -3.37228060e-01f, 5.59073329e-01f, 1.15975566e-01f,
  -2.78293669e-01f, 1.62367430e-02f, 1.59677491e-01f, 2.06123084e-01f, -1.38298199e-01f, -3.27761710e-01f, 4.96656671e-02f, 3.58984649e-01f, -3.92071344e-02f, -2.36636735e-02f,
  -2.77653933e-01f, 3.29265296e-01f, 1.90448582e-01f, 9.47766658e-03f, 1.22936584e-01f, -3.64029817e-02f, 2.84423083e-01f, -1.57621101e-01f, -9.73011702e-02f, 4.52892333e-02f,
  -5.10302261e-02f, 3.93446714e-01f, 1.61918476e-01f, -7.43805021e-02f, -3.42749536e-01f, -2.71011572e-02f, 1.77907234e-04f, -6.76978845e-04f, 3.85094248e-02f, 2.35710200e-03f,
  1.04643323e-01f, 3.29405010e-01f, -2.09755599e-01f, 2.65959769e-01f, -4.12752889e-02f, 1.07152844e-02f, 1.84924990e-01f, -3.33120972e-01f, 1.41895398e-01f, 2.86723524e-01f,
  -2.67946690e-01f, 2.81847894e-01f, -2.37314418e-01f, 2.37837702e-01f, 1.37625011e-02f, -5.91924563e-02f, -2.44494807e-02f, -3.06974292e-01f, -5.95992012e-03f, -1.85248390e-01f,
  -1.70707136e-01f, -1.63318157e-01f, 1.46205753e-01f, 2.23904133e-01f, 1.00297011e-01f, -1.12216011e-01f, -9.27370265e-02f, -2.02944432e-03f, 1.70333207e-01f, 4.68402840e-02f,
  -1.43195659e-01f, -1.12529039e-01f, 3.38311434e-01f, 2.53640592e-01f, -3.12093437e-01f, -1.75383519e-02f, 3.14829499e-02f, -2.75726855e-01f, 8.64854530e-02f, -2.85118707e-02f,
  8.12894553e-02f, 2.80776113e-01f, 1.56828016e-01f, 1.63880825e-01f, -1.55739188e-01f, 2.51552880e-01f, 1.83752760e-01f, -8.56878385e-02f, 6.19720295e-02f, -2.36615077e-01f,
  1.21002786e-01f, -7.83124790e-02f, 4.18295525e-02f, -3.75096835e-02f, 3.66069488e-02f, -1.04860023e-01f, 1.49476260e-01f, -6.74841329e-02f, 2.60208815e-01f, 9.27533805e-02f,
  1.43937811e-01f, -1.12433080e-02f, -1.55166388e-01f, 2.90692538e-01f, -2.62749642e-01f, -3.07708383e-01f, 3.65523338e-01f, -1.41003102e-01f, -4.88584861e-02f, -9.04133394e-02f,
  -4.67726700e-02f, 4.48954582e-01f, 1.99408442e-01f, -2.97051072e-02f, 8.23803097e-02f, -1.65151685e-01f, 1.00237779e-01f, -3.72937739e-01f, -4.79445383e-02f, 9.11854208e-02f,
  1.76811472e-01f, 1.86944008e-01f, -5.56532405e-02f, 2.90077757e-02f, 1.11422740e-01f, 5.54536283e-02f, 2.92378962e-02f, -2.76899666e-01f, 1.23976432e-01f, 3.63702983e-01f,
  3.19598876e-02f, -9.90489125e-02f, 1.87016517e-01f, -5.20889834e-02f, 1.35122135e-01f, -1.38937667e-01f, 3.63983393e-01f, -1.04201980e-01f, 3.57863903e-01f, -2.24824697e-01f,
  -9.37897414e-02f, -3.51133823e-01f, -3.10519010e-01f, 2.97993273e-01f, 9.16440785e-02f, 1.25309795e-01f, 2.50900954e-01f, -5.13590753e-01f, -2.58832633e-01f, 1.48321673e-01f,
  -3.13449502e-01f, 9.76516083e-02f, -4.54358160e-02f, 2.35396355e-01f, -6.42169565e-02f, -1.98117420e-01f, 2.01068725e-02f, -5.85505553e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.27219844e-01f, 2.64260918e-01f, -7.11278245e-02f, 1.59690574e-01f, 1.12372011e-01f, 9.88609642e-02f, 1.28962830e-01f, 2.20392495e-01f, 1.17852695e-01f, -1.05931483e-01f,
  -2.87332311e-02f, 2.07115382e-01f, 2.98149697e-02f, 4.87475067e-01f, -2.86637664e-01f, -2.35887691e-01f, 3.86431903e-01f, 8.90835822e-02f, 4.87203240e-01f, 4.92172807e-01f,
  -2.55440623e-01f, 9.74652693e-02f, 6.66101649e-02f, 9.17288437e-02f, 5.19954972e-02f, -2.70032287e-02f, 1.90217532e-02f, -7.30957650e-03f, 5.87847792e-02f, 1.63583174e-01f,
  4.12192419e-02f, 4.47638154e-01f, 2.62767911e-01f, -3.23798843e-02f, 1.33584619e-01f, 3.12812328e-01f, 4.09183614e-02f, 1.53779253e-01f, -4.12936397e-02f, 2.67201751e-01f,
  1.91824846e-02f, 7.05679208e-02f, -6.86006472e-02f, -1.57936171e-01f, 5.78659140e-02f, 3.39770883e-01f, -2.05340199e-02f, -2.25794926e-01f, 1.62171304e-01f, -1.28741255e-02f,
  3.19694847e-01f, 2.11130798e-01f, -8.70902091e-02f, 3.54153104e-02f, 7.58412806e-03f, -3.05316925e-01f, -9.37993452e-02f, 5.88715859e-02f, -2.04057530e-01f, -2.65608490e-01f,
  1.24565899e-01f, 3.75668079e-01f, -2.79062465e-02f, 2.93537378e-01f, 2.09989995e-01f, 1.16021641e-01f, -1.28321677e-01f, -2.00100645e-01f, -1.88107386e-01f, 2.82279909e-01f,
  -2.47894134e-02f, 3.53218138e-01f, 1.00225128e-01f, 1.01313032e-01f, 1.71642989e-01f, -1.63077936e-01f, -3.84302974e-01f, -5.39865457e-02f, 5.44315755e-01f, 2.89153844e-01f,
  3.22156459e-01f, -3.92424583e-01f, 6.71458384e-03f, 2.74566054e-01f, -1.93217948e-01f, 6.41115159e-02f, 3.84428203e-01f, 5.25474131e-01f, 3.29486042e-01f, 2.57592678e-01f,
  2.56782740e-01f, 3.03844303e-01f, -1.64807844e-03f, 2.58925140e-01f, -2.59243101e-02f, 1.98095754e-01f, -9.14600715e-02f, -6.58076555e-02f, 2.16873903e-02f, -2.59149950e-02f,
  -1.28386110e-01f, -1.07995324e-01f, 6.50946274e-02f, -9.37810317e-02f, -1.20444812e-01f, -1.59769416e-01f, 3.87423970e-02f, -1.71724819e-02f, 8.11583083e-03f, 1.19641520e-01f,
  4.89810342e-03f, 4.40741237e-03f, 1.42336205e-01f, -3.83830070e-02f, -1.19445361e-01f, 8.02310184e-02f, -1.36882007e-01f, -1.44087031e-01f, 7.54403472e-02f, 8.87680277e-02f,
  -1.29304022e-01f, -9.82578397e-02f, 7.69855529e-02f, 6.19430244e-02f, -5.50107658e-02f, -6.14891797e-02f, -2.59367283e-02f, -5.38058616e-02f, 3.88673507e-02f, 4.08623777e-02f,
  1.82563081e-01f, 8.84653628e-02f, 1.14222534e-01f, 1.95465177e-01f, 2.37385392e-01f, 6.35917624e-03f, 2.57645130e-01f, 6.19969005e-03f, 6.58348128e-02f, -1.64087951e-01f,
  2.24194914e-01f, -1.84796572e-01f, -1.02488045e-02f, -1.14270836e-01f, -2.89673656e-01f, 4.47905064e-03f, 8.18453059e-02f, -1.48170948e-01f, 1.93734244e-01f, -1.71408772e-01f,
  4.42147255e-02f, 2.41140917e-01f, 6.21619746e-02f, -4.37119380e-02f, -1.21714294e-01f, 2.60801613e-01f, 4.24443707e-02f, -5.04246987e-02f, 9.75460932e-02f, -1.52074739e-01f,
  2.36723036e-01f, 8.23063701e-02f, 7.88704082e-02f, -1.21269859e-01f, 4.71747726e-01f, 1.98192179e-01f, 2.97671527e-01f, 2.74356663e-01f, 1.83921829e-01f, 6.14854336e-01f,
  -5.23733139e-01f, -7.83186182e-02f, 5.58029115e-01f, -6.02761991e-02f, 9.67816636e-02f, 3.80610526e-01f, -3.17761362e-01f, -1.33466855e-01f, 5.12331761e-02f, -3.50315183e-01f,
  9.10216495e-02f, 1.70446485e-01f, 3.20206553e-01f, -2.55680650e-01f, -1.70057863e-01f, 8.25797953e-03f, 5.21437339e-02f, 3.73543888e-01f, 8.55849311e-02f, -6.39560223e-02f,
  2.71792114e-01f, -1.66906342e-01f, 3.97718370e-01f, 2.23703608e-01f, 5.03411412e-01f, -1.05411559e-01f, 3.16735685e-01f, 4.32520419e-01f, 1.59331039e-01f, 5.05027473e-02f,
  2.56280541e-01f, 3.63045812e-01f, 7.47554749e-02f, -2.62059718e-01f, -5.55652499e-01f, -2.15257723e-02f, 3.68412167e-01f, -4.67464663e-02f, 3.64673175e-02f, 3.60385398e-03f,
  -1.02433391e-01f, -1.04708783e-01f, -9.81333107e-02f, 3.14940810e-01f, 4.43707928e-02f, -3.34390551e-01f, 2.86418140e-01f, 2.59088606e-01f, -1.88192844e-01f, -2.33072966e-01f,
  -1.38138503e-01f, 5.78093112e-01f, 2.77079772e-02f, -1.37392282e-01f, -2.22793836e-02f, -3.47701758e-02f, -4.88328151e-02f, 3.11062783e-02f, 1.31602272e-01f, -3.78063843e-02f,
  2.01952338e-01f, 1.51381657e-01f, 1.73167109e-01f, -9.32340547e-02f, 1.46377906e-02f, -1.79095685e-01f, 4.98536192e-02f, -1.00500397e-01f, 6.62150793e-03f, -1.81417465e-01f,
  -3.43991369e-02f, 1.01928804e-02f, 9.67536308e-03f, 2.07698531e-02f, 1.36981204e-01f, 4.74809073e-02f, 2.23873317e-01f, -1.22867189e-01f, -1.58009976e-01f, -4.10284810e-02f,
  4.76860404e-02f, 1.81813106e-01f, 1.95151418e-01f, -7.57083744e-02f, -1.87226590e-02f, -1.16483442e-01f, -1.10776260e-01f, -6.65570572e-02f, -6.56214058e-02f, 8.48015919e-02f,
  -1.36718750e-01f, 9.26772319e-03f, -1.03871308e-01f, -6.60457462e-02f, 9.09383669e-02f, -1.06719680e-01f, -4.76487912e-02f, 8.67134407e-02f, 1.50167122e-01f, 2.22869098e-01f,
  -1.64767534e-01f, -1.45233616e-01f, -7.17343017e-02f, 5.15486747e-02f, 2.68042326e-01f, 2.74195641e-01f, -8.47482961e-03f, -1.11620970e-01f, 1.09439313e-01f, -4.35158834e-02f,
  -8.86838958e-02f, -3.13882157e-02f, -1.43346921e-01f, -6.79508895e-02f, 1.34878159e-01f, 4.67108786e-02f, 1.01719946e-01f, 2.16468200e-01f, 8.50161165e-02f, 2.76333481e-01f,
  5.13809882e-02f, 4.18492734e-01f, 2.79727697e-01f, 2.64481723e-01f, 3.41755450e-01f, 2.00292036e-01f, 2.88695186e-01f, 6.94527924e-02f, 3.31748307e-01f, 2.21555233e-01f,
  -1.54224843e-01f, 4.96870965e-01f, -3.64049733e-01f, -3.51814836e-01f, 2.53067523e-01f, -1.87227428e-01f, 2.67029330e-02f, 5.19755304e-01f, 3.98296714e-02f, 1.27145290e-01f,
  -3.27165514e-01f, -2.25455344e-01f, -5.36956154e-02f, 1.87129289e-01f, 3.80216492e-03f, -6.00854866e-02f, -3.70397717e-02f, 2.73232281e-01f, -1.79203376e-01f, 2.80248821e-02f,
  1.56741455e-01f, -6.37215599e-02f, 7.53297191e-03f, 4.42303196e-02f, -1.06989034e-01f, -6.42882288e-02f, 8.20956528e-02f, 1.51968583e-01f, 2.97772259e-01f, -2.73730755e-01f,
  -9.41880494e-02f, 1.56133816e-01f, -8.77194554e-02f, 2.70682722e-01f, -1.26382932e-01f, -2.35215113e-01f, 1.91853002e-01f, 9.88337621e-02f, 4.50235069e-01f, 3.19933712e-01f,
  4.92210612e-02f, 1.65886998e-01f, 1.08448498e-01f, 1.42167702e-01f, -1.96739376e-01f, 2.35829443e-01f, 5.47795556e-02f, 8.11309516e-02f, 2.31813759e-01f, -5.23243472e-02f,
  1.42269224e-01f, 3.70613962e-01f, -5.90191409e-02f, -8.47823173e-02f, 1.10414729e-01f, -7.95796886e-02f, 5.08118011e-02f, -2.26446427e-02f, -1.57617882e-01f, 8.20547119e-02f,
  2.77037546e-02f, -1.42320082e-01f, 1.16863057e-01f, 8.64330381e-02f, 1.38139293e-01f, 8.05957615e-02f, -5.74340262e-02f, 1.82522863e-01f, -6.03332743e-02f, -1.31317889e-02f,
  -1.53314993e-01f, -1.07306883e-01f, -9.44502726e-02f, -1.24936745e-01f, -3.60570364e-02f, 5.21792583e-02f, 1.67622536e-01f, 7.29239583e-02f, 2.00130418e-02f, 1.27443671e-01f,
  -1.33205697e-01f, 7.97147900e-02f, -1.70877248e-01f, 7.45967776e-02f, 7.57698491e-02f, 4.36580852e-02f, 7.09982216e-02f, 2.85601635e-02f, 1.36762124e-03f, -1.68268666e-01f,
  8.86233710e-03f, -9.52744409e-02f, -1.17933966e-01f, 6.40572906e-02f, -1.77074503e-02f, -1.44086137e-01f, 5.27048483e-02f, 1.36212781e-01f, 4.29629982e-02f, -6.25471584e-03f,
  -2.53475048e-02f, -7.65724257e-02f, -5.27469777e-02f, 4.31037974e-03f, 3.34329426e-01f, -3.93668562e-03f, -1.41911775e-01f, 8.23969021e-02f, 2.12915421e-01f, -9.21238288e-02f,
  5.57829514e-02f, -1.24873416e-02f, -1.12058140e-01f, 9.97537971e-02f, 1.00922994e-02f, 1.57418057e-01f, 1.25287473e-02f, -1.39029518e-01f, 2.13634789e-01f, 1.04673669e-01f,
  -3.81842479e-02f, 1.63730741e-01f, 8.77274126e-02f, -5.79839908e-02f, 2.00338855e-01f, 1.00313425e-01f, 1.26632541e-01f, 1.63611621e-01f, 9.61480942e-03f, -4.58823051e-03f,
  1.24440491e-01f, -1.58256441e-01f, 1.15566187e-01f, -1.30027816e-01f, 6.43808618e-02f, 9.10108685e-02f, -7.02445060e-02f, -1.34574315e-02f, 1.00902449e-02f, 8.36131498e-02f,
  5.61854281e-02f, -4.82379757e-02f, 2.40514651e-01f, 2.04781547e-01f, -3.22888419e-02f, -5.42528816e-02f, -5.97034246e-02f, 3.92831936e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.99483827e-01f, 1.91495612e-01f, 1.68839395e-01f, -6.93975538e-02f, 1.73578948e-01f, 4.39515471e-01f, 3.89186293e-01f, -9.64517146e-02f, 7.53097609e-02f, 3.02035827e-02f,
  1.89582452e-01f, -2.40851846e-03f, 2.08120309e-02f, -6.76880032e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.22666204e-01f, -4.95763645e-02f, 3.20604034e-02f, -2.25237951e-01f, -1.05127148e-01f, -1.73939437e-01f, -2.29877164e-03f, -1.59652591e-01f, -2.40320876e-01f, -1.48175806e-01f,
  2.52882332e-01f, 1.35659978e-01f, 3.61788049e-02f, -2.54885614e-01f, 2.42834672e-01f, 2.41905928e-01f, -2.04073802e-01f, -2.64984995e-01f, 3.06859016e-01f, 1.54807329e-01f,
  1.26455426e-01f, -8.52665585e-03f, -2.55445749e-01f, -5.08526087e-01f, 2.42019504e-01f, -1.05104111e-01f, -3.97862978e-02f, 2.48912707e-01f, 2.33731180e-01f, 1.09360673e-01f,
  -2.03590587e-01f, -1.85035088e-03f, 3.82195301e-02f, -7.37666339e-02f, -3.47604938e-02f, -1.77028164e-01f, -2.09412932e-01f, -4.82331574e-01f, -2.13910192e-01f, -4.53161031e-01f,
  -1.56194018e-02f, 1.82053447e-01f, -3.89568135e-02f, -1.26118436e-01f, 5.09600163e-01f, -3.28226298e-01f, 9.41775367e-02f, -2.09183320e-01f, 9.48411226e-02f, -1.18872896e-01f,
  4.24719661e-01f, -1.41871646e-01f, 3.09793204e-02f, 1.72087863e-01f, -7.71073550e-02f, 2.05982521e-01f, -2.67539620e-01f, -1.95364714e-01f, -1.50444955e-01f, 2.49363601e-01f,
  1.38185307e-01f, -1.37238532e-01f, 1.37265414e-01f, 1.21603310e-02f, 1.07862405e-01f, 1.70686692e-01f, -1.80487812e-01f, -8.62832591e-02f, 1.36479586e-01f, 2.56129682e-01f,
  2.91159958e-01f, -1.05340399e-01f, 7.03440383e-02f, 3.62369567e-02f, 1.05577648e-01f, 3.00488323e-01f, -1.69621259e-01f, -3.95635664e-01f, 5.75541519e-03f, 2.18228519e-01f,
  9.39261466e-02f, -2.24015802e-01f, 2.28548974e-01f, 2.01785967e-01f, -3.75234634e-01f, 1.03284404e-01f, -8.67037475e-02f, -4.88320887e-02f, 3.80037963e-01f, -7.95133878e-03f,
  1.25448450e-01f, 3.21929395e-01f, -1.17257573e-01f, -3.91679183e-02f, 1.75542571e-02f, -1.65155917e-01f, 2.29134828e-01f, -1.96657822e-01f, 1.63889438e-01f, 7.37695992e-02f,
  9.82397497e-02f, -4.51326855e-02f, -1.35804296e-01f, -2.41290808e-01f, 3.09952408e-01f, -3.37327346e-02f, -2.31581539e-01f, -1.73219800e-01f, 5.40644765e-01f, -3.81057948e-01f,
  -2.14793026e-01f, -1.88460514e-01f, 1.74860001e-01f, 1.73209414e-01f, 2.75393552e-03f, -1.95172161e-01f, 1.97950706e-01f, -3.59841995e-02f, 1.52307883e-01f, 1.02826580e-01f,
  -1.88537747e-01f, -1.38112351e-01f, -1.77682668e-01f, -4.10630345e-01f, -9.88205150e-02f, -4.06569690e-02f, 3.60953510e-02f, -1.28435627e-01f, 1.46085903e-01f, 3.65691960e-01f,
  -6.13386072e-02f, -8.00445005e-02f, 4.97189499e-02f, 2.76601315e-01f, -5.69050349e-02f, 2.03290060e-01f, 3.08548152e-01f, 2.54121512e-01f, 4.88944203e-01f, 6.81466684e-02f,
  -4.63869832e-02f, -1.17481828e-01f, 1.60932451e-01f, 1.25407368e-01f, -2.74137497e-01f, -5.66423953e-01f, 5.28403893e-02f, -1.78175673e-01f, 3.90360653e-01f, 4.33570594e-02f,
  -5.02409749e-02f, -3.99631858e-01f, 4.38547790e-01f, 1.63028594e-02f, -2.57613927e-01f, 2.98769046e-02f, -2.24634439e-01f, 8.23223814e-02f, 2.42235124e-01f, -1.67791784e-01f,
  1.54824927e-01f, 3.42929333e-01f, -6.30992576e-02f, 9.83260572e-02f, 2.40994126e-01f, 5.32716326e-02f, 1.56453192e-01f, -3.72228064e-02f, 1.77304260e-02f, 2.44622961e-01f,
  1.45025864e-01f, 1.18584344e-02f, 5.12276636e-03f, -4.15760130e-01f, 1.09541779e-02f, -1.84998706e-01f, 1.60710752e-01f, 1.92266237e-02f, -2.82620162e-01f, -1.69579312e-01f,
  2.02550650e-01f, -8.25067461e-02f, -2.39305682e-02f, 4.93824989e-01f, 1.01387709e-01f, -1.03349969e-01f, 1.08541213e-01f, -4.58407968e-01f, -1.45583842e-02f, -7.58208334e-02f,
  5.48821166e-02f, -1.34446561e-01f, -2.22897604e-02f, -3.02094787e-01f, 1.13539279e-01f, -2.55960971e-01f, -1.14823930e-01f, -2.61823267e-01f, -1.75481975e-01f, -3.44949752e-01f,
  9.33094993e-02f, -4.35223013e-01f, -8.94908607e-02f, -4.28764939e-01f, 1.39932066e-01f, 1.56686902e-01f, -2.38729212e-02f, -1.63301185e-01f, 8.93452615e-02f, 3.46797317e-01f,
  2.77265579e-01f, 1.22695021e-01f, 7.79882446e-02f, 1.45777419e-01f, -1.09128818e-01f, -2.50103325e-01f, -4.74624574e-01f, 1.25724137e-01f, -1.53471336e-01f, 3.78003865e-02f,
  3.62950146e-01f, -6.60633296e-02f, 1.70996469e-02f, -1.68216944e-01f, 1.60073429e-01f, 3.39889467e-01f, -3.77832986e-02f, 2.24843957e-02f, 1.17877617e-01f, 4.67123687e-02f,
  5.52656464e-02f, 1.65593117e-01f, -5.32699237e-03f, 1.52376443e-01f, 4.63434756e-01f, 3.39329928e-01f, -3.76187205e-01f, -7.10961893e-02f, 1.19706377e-01f, -1.42725155e-01f,
  -2.41082117e-01f, -5.12734056e-01f, -5.27851209e-02f, 2.06321806e-01f, 9.21556130e-02f, -9.46588889e-02f, -2.76310384e-01f, -3.54773223e-01f, 4.31019038e-01f, -4.56858277e-02f,
  -1.86347023e-01f, -1.52462512e-01f, 6.85419515e-02f, 1.78045794e-01f, 1.26718044e-01f, -6.83838129e-02f, 1.24464869e-01f, 2.44907826e-01f, 4.17292714e-01f, 2.74822921e-01f,
  1.68416142e-01f, 4.47658211e-01f, 3.54623884e-01f, 3.10851604e-01f, 2.81237066e-02f, -3.08002770e-01f, -4.39803928e-01f, -6.06837459e-02f, -2.87646148e-02f, -8.25998783e-02f,
  -3.30430895e-01f, 1.10869281e-01f, 1.75615162e-01f, 5.55338264e-01f, -1.54198959e-01f, -1.01495378e-01f, -4.16460067e-01f, 9.11970288e-02f, 3.01888853e-01f, -2.74796430e-02f,
  1.26774162e-01f, 5.22226691e-02f, -4.39451560e-02f, -3.18200678e-01f, -4.52556973e-03f, -5.55269569e-02f, -1.96965247e-01f, 1.12695433e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.61563510e-02f, -1.49332792e-01f, 2.98983813e-03f, 1.10744745e-01f, 1.42618433e-01f, -1.27634212e-01f, -4.98283282e-02f, -3.24551538e-02f, -7.45743513e-02f, 1.34795055e-01f,
  -1.72937632e-01f, -6.66870922e-02f, -1.52442679e-01f, 1.47160396e-01f, 7.25338385e-02f, 3.70015297e-03f, -6.22297637e-02f, 1.63215190e-01f, -1.43173859e-01f, -3.51001811e-03f,
  1.46633059e-01f, 9.32687894e-02f, 2.94607375e-02f, 1.88215896e-01f, 5.67093603e-02f, 1.39118955e-01f, -2.47360114e-02f, -8.00739378e-02f, 8.01553018e-03f, -1.51120067e-01f,
  1.87414885e-01f, -2.04076432e-03f, -1.16509102e-01f, -1.20885625e-01f, 1.33760069e-02f, -3.36063132e-02f, 1.28315315e-01f, -9.88170207e-02f, -1.45386413e-01f, -7.50937685e-02f,
  -2.55397595e-02f, 1.12938404e-01f, 5.57266269e-03f, 3.93897556e-02f, -6.70164004e-02f, 7.86772221e-02f, -3.98011766e-02f, -9.02386010e-02f, -1.26522586e-01f, -1.30036563e-01f,
  -5.56933954e-02f, -2.27080733e-02f, -1.29900828e-01f, -1.43612340e-01f, 1.84301555e-01f, 7.91144371e-02f, -2.54528616e-02f, -1.51638865e-01f, -2.64818426e-02f, -1.08241685e-01f,
  -9.04482324e-03f, 9.78343114e-02f, 1.98836789e-01f, 1.30868256e-01f, -1.40581489e-01f, 1.06414869e-01f, -3.28151844e-02f, -1.31349996e-01f, -1.73671469e-01f, -8.61046240e-02f,
  -8.89577866e-02f, 7.42359161e-02f, 1.41499236e-01f, 1.58081092e-02f, -1.57577470e-01f, 1.13847360e-01f, 1.00368761e-01f, -4.09465246e-02f, -8.01744387e-02f, 1.32933885e-01f,
  2.41582990e-02f, 3.84765007e-02f, -9.58483592e-02f, 4.54005487e-02f, -8.64368677e-02f, -1.66565657e-01f, 1.48088560e-01f, -5.20966435e-03f, -9.74174738e-02f, -7.32570887e-02f,
  7.97600448e-02f, -9.41581801e-02f, -6.15595505e-02f, -1.05555058e-01f, 1.18351787e-01f, -1.30398095e-01f, 1.68219417e-01f, -6.61245408e-03f, 1.12795662e-02f, 1.49906591e-01f,
  2.58731544e-01f, -1.58910770e-02f, -6.73241392e-02f, 2.27949604e-01f, 4.27820347e-02f, -8.05560499e-02f, 2.18678743e-01f, 2.09880814e-01f, -3.95057738e-01f, 5.16010672e-02f,
  2.82795697e-01f, 8.39476101e-03f, -1.89197622e-02f, -1.71052441e-01f, 2.71443069e-01f, 2.80780941e-01f, -1.86118126e-01f, -1.84743963e-02f, -1.76783595e-02f, -5.57349585e-02f,
  9.16362479e-02f, -1.98755443e-01f, 1.74390033e-01f, 2.39189804e-01f, 2.55157650e-01f, 2.56886948e-02f, 6.53914362e-02f, -2.17623383e-01f, 1.01035401e-01f, -1.40671864e-01f,
  -7.78196380e-02f, 1.28270581e-01f, 4.41241264e-02f, 7.52884746e-02f, -1.19687051e-01f, -2.37476379e-01f, -1.14301205e-01f, 8.48930620e-04f, 1.40939623e-01f, 1.02728046e-01f,
  -2.06837542e-02f, 1.80249184e-01f, 3.02635133e-01f, 1.69351950e-01f, -2.46834546e-01f, -2.27309093e-01f, 5.36227785e-02f, -1.93081740e-02f, 3.16639930e-01f, 1.71929210e-01f,
  -3.80188860e-02f, -1.95833780e-02f, -1.84106842e-01f, -1.51044980e-01f, 2.59813969e-03f, -4.85178120e-02f, 2.34728381e-01f, 7.64842108e-02f, -1.51788160e-01f, 1.60323322e-01f,
  -8.87095481e-02f, 1.15548456e-02f, 4.14648317e-02f, -1.63780138e-01f, 9.81892496e-02f, -1.58123270e-01f, -1.39374018e-01f, -1.60415575e-01f, -1.47579998e-01f, -1.21056832e-01f,
  9.63545591e-02f, 6.84364736e-02f, 5.03895842e-02f, -4.06801924e-02f, -1.54148296e-01f, -7.28910267e-02f, 2.16304399e-02f, -1.22524746e-01f, 5.05355150e-02f, -5.40141463e-02f,
  1.11412920e-01f, 1.43396258e-01f, -2.72021983e-02f, -8.27691406e-02f, -8.59473944e-02f, 5.85867725e-02f, -1.52944088e-01f, -6.34193495e-02f, -1.16588973e-01f, 6.09572716e-02f,
  -7.01780394e-02f, -1.10945806e-01f, 2.40108684e-01f, 2.54846513e-01f, 1.46363288e-01f, 4.07981314e-02f, 1.40790671e-01f, 2.00018603e-02f, 8.21734965e-02f, 2.77742535e-01f,
  9.87812132e-02f, 1.21225297e-01f, 1.12575047e-01f, 2.98002064e-01f, -1.63282335e-01f, 2.92640239e-01f, 8.45336989e-02f, 5.54775633e-02f, -1.27198607e-01f, -3.23997051e-01f,
  -7.75842071e-02f, 3.72114056e-03f, 6.93405390e-01f, 5.74225886e-03f, -6.20465837e-02f, 7.68233240e-02f, 3.84748548e-01f, -5.14920428e-02f, -2.57526562e-02f, -2.86882609e-01f,
  1.38502270e-01f, -1.58645272e-01f, -2.16206148e-01f, -7.03222537e-03f, 4.50179577e-02f, -5.46309277e-02f, 9.29633677e-02f, -1.97324246e-01f, 5.99101074e-02f, -7.25065246e-02f,
  -7.07519129e-02f, -3.77434492e-01f, -2.01567411e-01f, 2.98987925e-01f, 6.98614866e-02f, -7.19469562e-02f, -9.95188802e-02f, 1.88172370e-01f, 3.20696920e-01f, 2.53170758e-01f,
  -2.99523413e-01f, -2.60184377e-01f, 1.67604074e-01f, -1.85549304e-01f, 4.81216699e-01f, -1.00447074e-01f, 9.15166363e-02f, -2.06311166e-01f, -5.13686575e-02f, -1.61710694e-01f,
  -2.04194203e-01f, 6.35365844e-02f, 1.36476919e-01f, 1.20078400e-01f, 5.97458668e-02f, 5.80459200e-02f, 7.01209679e-02f, 1.87404186e-01f, 3.08318496e-01f, 2.12295532e-01f,
  2.57263124e-01f, 1.84541181e-01f, 4.41432238e-01f, 1.97380304e-01f, -1.72018856e-01f, 8.43469892e-03f, -4.43447262e-01f, 2.12337151e-01f, 4.97262269e-01f, -8.16257834e-01f,
  -5.12390137e-01f, -1.26474947e-01f, 5.87280750e-01f, 4.31975216e-01f, 1.19443260e-01f, 3.03224206e-01f, -9.67754126e-02f, 1.11768523e-03f, 3.13701153e-01f, 9.70252395e-01f,
  3.63278657e-01f, 1.40082404e-01f, 1.04897492e-01f, -1.85720727e-01f, 1.60982147e-01f, -9.78462398e-02f, -4.68687415e-02f, -1.96523339e-01f, -1.59817189e-02f, -2.28195831e-01f,
  3.91564339e-01f, -1.70058850e-02f, -7.82596599e-03f, 2.94557840e-01f, -1.35842457e-01f, 1.92361057e-01f, 1.66222036e-01f, -3.52134943e-01f, -6.08123578e-02f, -3.37424308e-01f,
  1.26794651e-01f, 4.68102455e-01f, 1.53539136e-01f, 4.90589052e-01f, 4.43415046e-02f, 2.54587471e-01f, 7.63622820e-01f, 3.26231182e-01f, 3.94269913e-01f, -9.13613066e-02f,
  4.12423117e-03f, -4.37453181e-01f, 2.90513813e-01f, -3.42064351e-02f, 4.74911407e-02f, 7.97505736e-01f, 5.99452555e-01f, -7.63762891e-02f, -1.01554722e-01f, 1.68741196e-01f,
  2.96205819e-01f, 4.98531580e-01f, 1.41745374e-01f, 4.12864089e-01f, 3.42622787e-01f, 4.84771669e-01f, 1.44969061e-01f, 3.46962571e-01f, 5.28738022e-01f, 3.02596956e-01f,
  -2.84224004e-01f, 1.82151973e-01f, -6.14434898e-01f, 3.62542838e-01f, 1.17121391e-01f, 1.42004758e-01f, -4.46172990e-02f, -6.92627952e-02f, -3.30462605e-01f, -2.93135587e-02f,
  1.44169644e-01f, 2.50677858e-02f, 3.29791874e-01f, 2.60526985e-01f, 8.28889489e-01f, -1.66355118e-01f, -1.52462423e-01f, 2.47399479e-01f, -4.12774622e-01f, 1.22437574e-01f,
  1.90331992e-02f, 4.55878153e-02f, -2.01101005e-01f, 4.20079902e-02f, 1.48455128e-01f, -1.06286757e-01f, -1.96455270e-02f, -3.15337092e-01f, 9.37876850e-02f, -2.77309507e-01f,
  -5.38020544e-02f, -2.54361421e-01f, -1.78001717e-01f, 3.12858373e-02f, -3.85328569e-02f, -1.35152057e-01f, -1.34314314e-01f, -3.89563874e-03f, 4.54753451e-02f, 1.99492201e-01f,
  -1.19074658e-01f, -9.49182361e-02f, 1.30873501e-01f, -1.54799759e-01f, 1.94625542e-01f, 3.84496897e-01f, -1.56433925e-01f, 2.50689000e-01f, 7.00985491e-02f, -6.78958744e-02f,
  -5.76170487e-03f, -6.14048541e-02f, 1.83871761e-01f, 1.71404868e-01f, 6.11951128e-02f, -3.29512864e-01f, -4.22794558e-02f, -7.20216602e-04f, 2.48899549e-01f, -3.02232411e-02f,
  2.57107824e-01f, 5.99992722e-02f, 4.35666203e-01f, 6.48256466e-02f, -5.30932248e-01f, 1.65505379e-01f, -1.38647512e-01f, -1.76725894e-01f, 1.27872765e-01f, -9.89926010e-02f,
  -1.61414836e-02f, 3.32075953e-01f, 4.76777822e-01f, 5.26236653e-01f, -5.49223721e-01f, 1.27125874e-01f, 1.41853541e-02f, 3.19324493e-01f, -1.04251713e-01f, -4.07246351e-02f,
  2.88696319e-01f, 3.89159918e-01f, 3.24557483e-01f, -1.50701359e-01f, -8.78053233e-02f, -1.12950578e-02f, -1.43062696e-01f, 5.36442772e-02f, -1.60945341e-01f, -2.05061421e-01f,
  1.52313456e-01f, 9.87060666e-02f, -5.18102013e-02f, 1.33828923e-01f, 1.09444492e-01f, 3.90300125e-01f, -7.11866543e-02f, 3.50276642e-02f, 2.33299524e-01f, -2.66692668e-01f,
  1.32950440e-01f, -3.63837625e-03f, -3.55697027e-03f, -5.45425951e-01f, 2.08746895e-01f, 4.44953322e-01f, 3.00150365e-01f, -6.96012452e-02f, -3.16752732e-01f, 2.55832583e-01f,
  3.79254609e-01f, 3.34082767e-02f, 1.96192831e-01f, 3.28807645e-02f, -3.27984840e-02f, 1.05880708e-01f, -1.86576545e-01f, 2.57443450e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.41858950e-01f, 2.15684194e-02f, 5.17709833e-03f, -7.05547184e-02f, 1.95368156e-01f, -1.72077734e-02f, 2.42710859e-01f, -1.24122553e-01f, 3.49361479e-01f, 9.18705165e-02f,
  2.54583418e-01f, -9.85889658e-02f, 3.15727592e-01f, 1.24423236e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.37154210e-01f, 2.65322894e-01f, 3.05304617e-01f, -1.60078168e-01f, -3.60273987e-01f, 3.23306292e-01f, -2.75635183e-01f, -6.25740111e-01f, -2.35359237e-01f, 1.57611921e-01f,
  -2.30131015e-01f, 1.63551837e-01f, -4.21267390e-01f, 2.86911547e-01f, 3.27698141e-01f, -5.61608076e-01f, 3.46659660e-01f, -6.06694996e-01f, 1.70249976e-02f, 3.58458771e-03f,
  -1.76012948e-01f, 2.14641631e-01f, 5.52799344e-01f, 1.60062481e-02f, 5.31700253e-01f, 5.96249878e-01f, -8.67130041e-01f, -1.78085461e-01f, 9.37251449e-02f, 6.54437691e-02f,
  -3.94836575e-01f, 1.74816735e-02f, 2.42401093e-01f, 1.13126874e-01f, 3.88501197e-01f, 2.30969518e-01f, -7.90496022e-02f, 1.27992406e-01f, 4.00494874e-01f, 4.99774605e-01f,
  3.51875722e-01f, 3.21149707e-01f, 6.07025504e-01f, -4.57520962e-01f, 2.01497972e-01f, 5.30314028e-01f, -4.47630823e-01f, 4.81535673e-01f, -3.30943942e-01f, -6.70551896e-01f,
  -2.68097948e-02f, 2.06638407e-02f, -2.01076288e-02f, -3.14613402e-01f, 2.69421309e-01f, 1.47607818e-01f, -9.91757959e-02f, 5.06611884e-01f, -5.94443500e-01f, 7.65476048e-01f,
  -2.36962065e-01f, 1.18207484e-01f, -3.17362428e-01f, 2.95839249e-03f, 2.63809353e-01f, 1.67132080e-01f, -2.73036093e-01f, 1.03590325e-01f, 6.87163174e-01f, 4.06044275e-01f,
  -2.28966191e-01f, 8.39493096e-01f, 1.60994381e-01f, -4.73978341e-01f, -2.46307194e-01f, 2.64698684e-01f, -3.09625447e-01f, 5.29213965e-01f, 2.90066481e-01f, -4.13826466e-01f,
  2.53330112e-01f, 3.08826387e-01f, 5.25921807e-02f, 1.82204157e-01f, 9.13721509e-03f, 1.76303223e-01f, 7.95917064e-02f, -2.99809873e-02f, -4.85413000e-02f, -1.17024817e-01f,
  -1.29417166e-01f, -3.76735121e-01f, 7.46390462e-01f, -2.28077382e-01f, 5.89273274e-01f, -7.94804022e-02f, 2.90895075e-01f, 4.07070607e-01f, -2.90660560e-01f, 4.63193476e-01f,
  -2.98490822e-01f, -5.02709448e-01f, -2.79064566e-01f, 2.08309386e-02f, 2.39776149e-01f, 2.81052887e-01f, 1.25126064e-01f, 1.79666623e-01f, 2.27718218e-03f, 6.92247093e-01f,
  3.01441640e-01f, -6.25416189e-02f, 7.80475676e-01f, -2.91066673e-02f, -1.40857011e-01f, -8.71443376e-02f, -1.76821366e-01f, -1.18746199e-01f, -2.39172772e-01f, 9.33320075e-02f,
  2.27874126e-02f, -3.69695455e-01f, 7.74356663e-01f, -3.06833208e-01f, -1.40413329e-01f, -5.49013987e-02f, -5.02675712e-01f, 4.29951102e-01f, 3.46804202e-01f, -4.49643821e-01f,
  -1.80955216e-01f, 5.77160455e-02f, -3.79784644e-01f, -9.97881889e-02f, -4.17032242e-01f, -6.60019457e-01f, 2.91050911e-01f, 8.83871615e-02f, -2.40592837e-01f, 2.19246030e-01f,
  -1.11119613e-01f, -2.55326211e-01f, 3.98033589e-01f, 1.76332802e-01f, 3.16493481e-01f, 3.11047658e-02f, 8.49815458e-02f, -1.24071270e-01f, 5.09925671e-02f, 2.19587281e-01f,
  -1.45582575e-02f, 9.99580994e-02f, 3.68614286e-01f, -1.29351586e-01f, -2.65786260e-01f, -3.38062376e-01f, 7.90593207e-01f, 1.32322401e-01f, -5.86835444e-01f, 1.35538489e-01f,
  5.04537940e-01f, -1.52701244e-01f, 4.50853646e-01f, 2.05502346e-01f, 4.45227176e-01f, 3.21413666e-01f, 7.63917565e-01f, 2.78122395e-01f, 7.85940066e-02f, 2.00532272e-01f,
  -7.55729139e-01f, -1.38984457e-01f, -5.37924111e-01f, -3.62535492e-02f, -6.93671823e-01f, 1.39773995e-01f, -9.63267609e-02f, 6.85775399e-01f, 1.62348926e-01f, -9.84408110e-02f,
  -3.29160541e-02f, -5.93184531e-02f, -1.09759249e-01f, 2.46148482e-02f, 1.11065276e-01f, -3.41182142e-01f, -2.95281321e-01f, 7.11005628e-01f, 2.77676821e-01f, -2.57549174e-02f,
  -1.78281009e-01f, -5.20778477e-01f, -1.24248683e-01f, 4.98125046e-01f, 2.60519218e-02f, 9.80708152e-02f, 4.49867658e-02f, 2.19484359e-01f, 4.94042367e-01f, -2.23961726e-01f,
  -7.33041286e-01f, -4.56898212e-01f, 1.25109851e-01f, 2.33893037e-01f, 2.24341676e-01f, -5.79325497e-01f, 4.39484119e-01f, -4.91421729e-01f, -6.14135623e-01f, -9.84010100e-02f,
  -4.75990288e-02f, 5.28975800e-02f, -5.25960401e-02f, -2.56563663e-01f, 4.22735810e-02f, 1.60869762e-01f, -7.64850020e-01f, -1.20442145e-01f, 8.62632096e-01f, -3.51978838e-01f,
  -1.04481533e-01f, 3.20288032e-01f, 2.03594416e-01f, -7.29734123e-01f, -7.99209625e-02f, -2.92641670e-01f, 2.67986864e-01f, -2.96631455e-01f, -4.50924933e-01f, 1.11240663e-01f,
  1.32531136e-01f, -4.37659502e-01f, 1.31971404e-01f, -3.44341040e-01f, 3.56786847e-01f, -7.01600075e-01f, 5.19852996e-01f, -2.93397576e-01f, 2.97865152e-01f, 5.93997240e-01f,
  -2.36641586e-01f, -2.04964116e-01f, 1.62816510e-01f, 1.54484659e-01f, 1.27107337e-01f, -2.89339691e-01f, 7.69892707e-02f, -1.40789971e-01f, 7.40368366e-02f, 1.54826924e-01f,
  7.03584254e-01f, -3.97728801e-01f, -8.83522749e-01f, 5.46041191e-01f, 3.03449392e-01f, -1.03889883e-01f, -2.64336258e-01f, 7.59440800e-03f, -1.84389483e-02f, -4.05100256e-01f,
  1.68663174e-01f, -4.35672432e-01f, -1.54936999e-01f, -3.71926464e-02f, 6.67767553e-03f, 5.69228306e-02f, 1.89343840e-02f, 1.31469041e-01f, -3.59264672e-01f, -5.53646445e-01f,
  -9.69507620e-02f, 4.62409139e-01f, -4.10685867e-01f, -3.33881289e-01f, 1.45767570e-01f, 5.77889159e-02f, -1.65530726e-01f, 5.12421310e-01f, 1.51439726e-01f, 4.30648364e-02f,
  -4.08789128e-01f, -2.24404976e-01f, -3.59003454e-01f, 6.66501641e-01f, -7.12010443e-01f, -1.02333352e-01f, 4.18074936e-01f, -3.17371301e-02f, -4.56683338e-01f, 2.58772075e-01f,
  2.70435542e-01f, -1.97708845e-01f, 8.43118489e-01f, -5.74314237e-01f, -2.92298287e-01f, 6.83991790e-01f, -3.13023716e-01f, -1.77990586e-01f, -3.80652845e-02f, -1.50787801e-01f,
  5.21087110e-01f, -2.32605726e-01f, 1.87371269e-01f, -4.52377230e-01f, -4.38828021e-01f, 1.72573879e-01f, 1.95865095e-01f, -6.98049217e-02f, -1.60400137e-01f, -2.05678195e-01f,
  2.86864880e-02f, -1.30523995e-01f, 8.81477892e-02f, 6.90072477e-02f, 6.52774692e-01f, -8.94505203e-01f, 3.67375582e-01f, 4.86354381e-02f, -1.22657754e-01f, 2.86458638e-02f,
  -5.72388887e-01f, -3.88485077e-03f, -6.51822507e-01f, -6.09289348e-01f, -2.21138075e-01f, -1.36037007e-01f, 1.41305670e-01f, -2.01246336e-01f, -5.59337363e-02f, 1.57649741e-01f,
  7.77658001e-02f, 4.01709927e-03f, -1.31066665e-01f, 1.96988881e-01f, -5.53703964e-01f, -3.32135677e-01f, 1.63936332e-01f, -5.31041622e-01f, -1.43066272e-01f, 4.98974249e-02f,
  -6.36218488e-02f, 1.79971486e-01f, -1.90246880e-01f, -1.22402303e-01f, -1.92435458e-01f, -4.63848636e-02f, -2.94545621e-01f, 4.53122377e-01f, 2.80397534e-01f, 1.09365590e-01f,
  1.39200285e-01f, 4.51562792e-01f, 1.99990928e-01f, -7.38962218e-02f, -3.19520146e-01f, 2.18544975e-01f, 1.12343907e-01f, 4.82930064e-01f, 2.33522043e-01f, 1.35000318e-01f,
  -1.77050188e-01f, 3.32469702e-01f, 2.01931804e-01f, 3.69141191e-01f, 3.83119851e-01f, -3.34163874e-01f, -5.12881339e-01f, 5.55461287e-01f, -2.10112214e-01f, 1.79552853e-01f,
  -2.34903395e-02f, 5.00289463e-02f, 7.93396682e-02f, 1.48568228e-01f, -8.71206149e-02f, -1.64565548e-01f, -4.67885584e-01f, -2.10867882e-01f, 3.95742953e-01f, 8.37745294e-02f,
  -6.10038757e-01f, -3.23363572e-01f, 7.33964086e-01f, 1.26366079e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.25660801e-01f, 5.37672453e-02f, 4.83372957e-02f, -7.75904581e-02f, -1.13346249e-01f, 1.53668523e-01f, 9.26800743e-02f, -6.79740161e-02f, -2.58492827e-01f, -3.72050069e-02f,
  -4.51412857e-01f, 8.71627256e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    