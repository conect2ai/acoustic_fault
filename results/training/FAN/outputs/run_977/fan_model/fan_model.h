/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.45392138e-01f, -4.00471419e-01f, -1.85839444e-01f, -4.53249887e-02f, -3.71519536e-01f, -1.86691657e-02f, -1.99711561e-01f, 1.74674913e-01f, 1.75159484e-01f, -2.26339951e-01f,
  -2.80649185e-01f, -7.91735947e-02f, -9.23281834e-02f, 7.16387779e-02f, 2.42437154e-01f, -8.16743970e-02f, -1.44959584e-01f, 1.29915625e-01f, 2.93397546e-01f, 2.06601635e-01f,
  5.14274947e-02f, -8.79689455e-02f, 1.25925988e-01f, 2.65121430e-01f, -7.39130378e-02f, -9.42509174e-02f, -2.33519703e-01f, -2.32103601e-01f, -1.04301050e-01f, -1.35185152e-01f,
  -1.64887920e-01f, 9.02196690e-02f, 8.95939320e-02f, -2.01585591e-02f, -1.75511047e-01f, 1.49260759e-01f, -3.06842271e-02f, -2.73525752e-02f, -2.09113099e-02f, -9.63492412e-03f,
  -2.52619553e-02f, 7.80056044e-02f, -3.79159376e-02f, 6.64144531e-02f, 6.17041402e-02f, 7.10717216e-02f, 4.40627262e-02f, 1.33149192e-01f, 1.37431681e-01f, 5.86695410e-02f,
  -1.29585162e-01f, -1.73523337e-01f, -1.33015290e-01f, 1.26977056e-01f, 1.72444835e-01f, 3.19090188e-02f, 3.98125425e-02f, 2.10994959e-01f, 1.96937099e-01f, 7.23939538e-02f,
  1.25710130e-01f, -1.29385497e-02f, -3.29533219e-02f, -5.77686466e-02f, -6.77968040e-02f, -1.45991504e-01f, -1.94575563e-02f, -6.52977973e-02f, 1.86307728e-02f, 1.46935889e-02f,
  1.82370376e-02f, -6.45999145e-03f, 3.03895082e-02f, -3.31157004e-03f, 2.47191936e-02f, -2.45692860e-02f, 4.30256799e-02f, -1.07951891e-02f, 5.81529876e-03f, -9.63835884e-03f,
  -1.66833624e-02f, -1.36140455e-02f, -3.14010940e-02f, 7.63996243e-02f, -1.55561892e-02f, 4.10949700e-02f, 2.75893733e-02f, 1.95825510e-02f, 3.44941691e-02f, -2.16191411e-02f,
  2.45556305e-03f, -3.39918248e-02f, 6.58929646e-02f, 7.63322711e-02f, 2.70699412e-02f, 3.57916653e-02f, 3.75425145e-02f, 9.91880968e-02f, 4.07450572e-02f, 8.85591581e-02f,
  4.13406864e-02f, 5.95528744e-02f, -7.80673921e-02f, 6.84003979e-02f, 5.04428819e-02f, 7.28665739e-02f, -6.84397817e-02f, -1.23338997e-02f, 8.77855495e-02f, 1.29911125e-01f,
  4.51535583e-02f, 5.56961671e-02f, -6.33248091e-02f, 2.48414907e-03f, 8.29423964e-02f, 1.04686460e-02f, -2.54805218e-02f, 6.42341468e-03f, 4.28297976e-03f, -2.39844341e-02f,
  3.84769887e-02f, -2.00690567e-01f, -4.82956171e-01f, -2.33296350e-01f, -3.27799678e-01f, -1.14715807e-01f, -2.15266153e-01f, 6.85269386e-02f, 1.14382401e-01f, -4.02495414e-01f,
  4.66511659e-02f, 2.53164202e-01f, 3.69814038e-02f, 1.65674955e-01f, 2.16890961e-01f, -3.08521211e-01f, -3.81131679e-01f, 1.23503981e-02f, 3.31569195e-01f, 1.15209579e-01f,
  2.11886287e-01f, 1.32242903e-01f, 3.57457817e-01f, 1.84026390e-01f, -2.87713408e-01f, -6.14567213e-02f, -1.99516356e-01f, -1.40111580e-01f, -5.42659163e-02f, -5.76894224e-01f,
  -2.82861352e-01f, -1.27186745e-01f, 1.00035168e-01f, 1.75657704e-01f, 5.57973720e-02f, 8.52469876e-02f, -3.21572684e-02f, 7.72185102e-02f, 8.33938494e-02f, 9.29707196e-03f,
  -1.00182872e-02f, 1.19854346e-01f, 6.20774738e-02f, 1.90030236e-03f, -6.80388464e-03f, -3.37572917e-02f, -2.83472203e-02f, 5.29139787e-02f, 3.29585075e-02f, -6.12871088e-02f,
  -1.68925434e-01f, -9.39240530e-02f, -1.55721307e-01f, -4.90572974e-02f, 1.29951373e-01f, 9.95189324e-02f, 8.89176801e-02f, 4.24562506e-02f, 8.89856517e-02f, -6.60409182e-02f,
  -8.56018066e-02f, 4.07819711e-02f, -4.15762849e-02f, -7.54169282e-03f, 1.10501960e-01f, 4.37395908e-02f, -1.87789537e-02f, 3.22635062e-02f, 6.18162239e-03f, -4.28771563e-02f,
  -2.72339588e-04f, -7.98899755e-02f, 4.55992147e-02f, -4.71191220e-02f, -1.11386731e-01f, -5.30998036e-02f, -2.90529449e-02f, -8.28852784e-03f, 3.96257453e-02f, 9.41381678e-02f,
  9.67832208e-02f, 3.03105954e-02f, -9.46199074e-02f, 5.99038303e-02f, -9.96258855e-02f, -1.03883289e-01f, -5.23888022e-02f, -5.63808121e-02f, -1.16968229e-01f, -1.32311042e-02f,
  3.35200608e-01f, 1.04327932e-01f, -5.57657741e-02f, 9.04387143e-03f, -1.13114426e-02f, 5.82422055e-02f, -7.13553652e-02f, 1.42027944e-01f, 1.28473312e-01f, 2.50466028e-03f,
  6.29242230e-03f, 2.45660152e-02f, -2.60181651e-02f, -4.01138104e-02f, 3.14402720e-03f, 3.61500271e-02f, 2.18772478e-02f, -6.31997734e-02f, 2.03883499e-01f, -7.23841740e-03f,
  3.83343436e-02f, 5.00265770e-02f, 6.64137974e-02f, 6.75140470e-02f, 8.41612890e-02f, 1.06392026e-01f, 3.12053449e-02f, 2.83856876e-02f, 8.99920389e-02f, 6.55581504e-02f,
  1.75536573e-01f, -1.86119020e-01f, 2.20473483e-01f, 3.03424895e-02f, -3.27316791e-01f, -2.74919719e-01f, -5.67979991e-01f, -2.61453658e-01f, 4.39624265e-02f, -7.28674904e-02f,
  -1.64179116e-01f, 1.25708714e-01f, 2.91626126e-01f, 1.75097004e-01f, -8.48545879e-03f, 2.05340013e-02f, 2.04642102e-01f, 3.42728227e-01f, -6.28126860e-02f, -4.07792360e-01f,
  -3.17299157e-01f, -1.82052299e-01f, 3.74193750e-02f, -2.46043094e-02f, 9.89512354e-03f, 3.93721052e-02f, 9.52497274e-02f, -3.15165892e-02f, 3.98173779e-02f, 4.83200550e-01f,
  3.99638377e-02f, -1.43108055e-01f, -3.16254087e-02f, 8.59635696e-02f, -3.91824841e-02f, 7.64005482e-02f, -5.95250586e-03f, 1.62908807e-01f, -9.21643863e-04f, 6.50443509e-02f,
  7.08173066e-02f, 4.36896309e-02f, -1.50675122e-02f, 3.19926701e-02f, -5.64990975e-02f, -3.64284255e-02f, 1.72889844e-01f, 6.97810575e-02f, 2.98071392e-02f, -6.11758418e-02f,
  -6.01310395e-02f, -4.88617495e-02f, -1.00174032e-01f, -1.60496786e-01f, 8.43066350e-03f, 2.30233874e-02f, -1.25913173e-01f, -1.15327549e-03f, 6.19401038e-02f, 5.69754802e-02f,
  -1.32395640e-01f, -3.10964230e-02f, -6.57873601e-02f, -1.02553956e-01f, -4.67961133e-02f, -4.76970822e-02f, 1.67265274e-02f, -9.68030021e-02f, -4.22872007e-02f, 2.66372599e-02f,
  1.86479073e-02f, -2.85077058e-02f, -3.17484923e-02f, 1.84375104e-02f, 2.00564507e-03f, 4.01223730e-03f, 2.49134526e-02f, -1.77403521e-02f, -1.60438847e-02f, 6.35297447e-02f,
  -2.63815336e-02f, -4.01117057e-02f, 6.82784989e-02f, 1.48660280e-02f, 3.90911847e-02f, 4.13950570e-02f, 3.42896879e-02f, -1.83008313e-02f, 2.22490057e-02f, 2.81079225e-02f,
  -9.85292867e-02f, 4.80967760e-02f, 1.12224922e-01f, 1.36991525e-02f, 9.74189639e-02f, 6.86666295e-02f, 2.01435294e-02f, -3.04142535e-02f, 5.81094855e-03f, -7.26990104e-02f,
  -4.90098856e-02f, 1.81799044e-03f, 5.81335090e-02f, 4.67994213e-02f, -1.77888609e-02f, -1.88436043e-02f, -5.94131574e-02f, -7.42271496e-03f, 5.12655973e-02f, 8.21402073e-02f,
  2.28719153e-02f, -9.18181092e-02f, -1.36952847e-01f, 3.88211906e-02f, -7.03092515e-02f, -2.65982710e-02f, -5.00799753e-02f, -2.29849387e-03f, 7.33599588e-02f, -2.23339006e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.59595186e-01f, -5.35751343e-01f, 8.67744863e-01f, -2.69976668e-02f, 3.35642040e-01f, 5.08933246e-01f, 3.54323357e-01f, 5.41453250e-03f, -2.00509593e-01f, 1.46469086e-01f,
  -4.91806239e-01f, -8.34400713e-01f, -5.81925452e-01f, -5.09312630e-01f, -2.06207260e-01f, 2.50296474e-01f, 3.75283360e-01f, 3.36188734e-01f, 4.67005998e-01f, 1.08399197e-01f,
  -4.44886714e-01f, 6.42812997e-02f, 1.10567063e-01f, 6.34806156e-02f, -1.46903977e-01f, -1.91525146e-01f, 2.55495638e-01f, 7.72083923e-02f, -1.49704427e-01f, -6.86800927e-02f,
  -7.24895392e-03f, 2.64218271e-01f, -5.15688360e-02f, -2.55389065e-01f, -1.11364461e-01f, -9.66679975e-02f, -6.44809827e-02f, -4.60585803e-02f, -9.23155993e-02f, 2.14593988e-02f,
  -1.02939002e-01f, -2.92309131e-02f, 2.11681165e-02f, 3.85426842e-02f, 1.93900853e-01f, 3.58449966e-02f, 3.17995735e-02f, 1.42146805e-02f, -1.41535476e-01f, -1.22770622e-01f,
  -3.69950950e-01f, 4.33838218e-02f, 2.29921699e-01f, -1.02449514e-01f, -9.14228186e-02f, -6.22671358e-02f, -4.80521135e-02f, 5.88716231e-02f, 2.69379206e-02f, -1.38872609e-01f,
  5.66931777e-02f, 1.74007472e-02f, -4.75542918e-02f, 1.02326989e-01f, 3.35501926e-03f, 9.97565612e-02f, 2.92670988e-02f, -4.52210642e-02f, -6.05749711e-02f, 5.73300645e-02f,
  -5.84799685e-02f, -2.16729078e-03f, -1.00269895e-02f, -8.29091966e-02f, -2.19963089e-01f, 7.80975446e-02f, 1.06196608e-02f, -1.46157861e-01f, -7.05399960e-02f, -9.83678550e-02f,
  -2.38408241e-02f, 3.29092965e-02f, 8.14702064e-02f, 2.27016304e-03f, -1.07517615e-01f, 2.52395999e-02f, 1.11901518e-02f, -1.83012024e-01f, -3.42191905e-02f, 3.67277190e-02f,
  -4.65868533e-01f, 3.38950679e-02f, -1.05259091e-01f, 4.36566137e-02f, 1.59689248e-01f, -1.43953994e-01f, -8.42569396e-02f, 1.87846564e-03f, 5.07178269e-02f, 3.51069681e-02f,
  3.54921892e-02f, -2.61662342e-02f, -9.60898772e-02f, -7.62922168e-02f, 1.81620046e-01f, 2.30486430e-02f, -1.91886485e-01f, -2.43089367e-02f, -5.76701872e-02f, 8.97784084e-02f,
  -1.77374780e-01f, 6.20129518e-02f, -1.85234919e-02f, -3.64476070e-02f, -7.03500360e-02f, 1.44338474e-01f, 9.47785005e-02f, 6.37532771e-02f, 7.85007551e-02f, 9.28168669e-02f,
  -7.38009095e-01f, 1.09336071e-01f, -1.96136773e-01f, 4.88586836e-02f, 2.83573896e-01f, -2.50218213e-01f, -5.62418342e-01f, -4.83799100e-01f, 1.37232840e-01f, -6.79548755e-02f,
  -1.67289544e-02f, 2.27075785e-01f, 2.09209993e-01f, 3.12992819e-02f, -4.65123266e-01f, -1.28956541e-01f, 5.10707736e-01f, 7.45851472e-02f, -2.52835423e-01f, -1.80539519e-01f,
  4.29444790e-01f, 3.83419305e-01f, -6.52672797e-02f, 3.50854434e-02f, 2.89794832e-01f, 2.88424551e-01f, 4.02756214e-01f, 4.05472785e-01f, 2.34689012e-01f, 7.68491685e-01f,
  -3.28664571e-01f, -3.30332339e-01f, -1.62289485e-01f, -3.76380421e-02f, 6.95148855e-02f, -2.14164928e-01f, -2.93846577e-01f, -1.08729720e-01f, -1.02644572e-02f, -4.31257263e-02f,
  3.20205510e-01f, 4.73413728e-02f, 1.79288149e-01f, -2.45967936e-02f, -1.68991864e-01f, -2.08867580e-01f, -8.16604029e-03f, -2.99252212e-01f, -3.01509112e-01f, -3.15061718e-01f,
  4.04573709e-01f, 1.61733210e-01f, -5.16293108e-01f, -2.12547109e-01f, -1.67187080e-01f, 1.46449938e-01f, -2.56996661e-01f, -2.00629234e-01f, -1.57264546e-01f, -6.16033487e-02f,
  5.39357513e-02f, 1.30116731e-01f, -9.50390548e-02f, -2.61188224e-02f, -2.16946900e-02f, 1.59026429e-01f, 2.54703224e-01f, 7.30357096e-02f, 4.57086228e-02f, -1.00374341e-01f,
  1.18297040e-01f, -1.62000149e-01f, 1.79756023e-02f, -1.24099009e-01f, -9.39342156e-02f, 2.83962954e-02f, 3.43419090e-02f, -4.66679372e-02f, -3.40497158e-02f, -1.16410172e-02f,
  1.94750112e-02f, 1.41290590e-01f, 1.62836164e-01f, 7.80997425e-02f, -9.16006416e-02f, 1.33069724e-01f, 1.20232493e-01f, -7.03830272e-02f, -8.98045227e-02f, 5.76208122e-02f,
  -2.52683818e-01f, 1.16556130e-01f, -1.43478304e-01f, 5.27556986e-02f, 8.23036805e-02f, 1.87180087e-01f, 2.22283185e-01f, -1.87969673e-02f, -4.63976748e-02f, -1.27008155e-01f,
  -3.53297532e-01f, -1.95898414e-01f, -3.48886549e-02f, -2.06585787e-02f, -2.27654353e-01f, -8.45618024e-02f, 1.10702612e-01f, -2.16060430e-01f, -1.00037031e-01f, 3.56439985e-02f,
  1.35489739e-02f, -5.28015435e-01f, -6.70398057e-01f, -4.16587591e-01f, -1.12711884e-01f, -5.48731804e-01f, -3.12063545e-01f, -4.63980108e-01f, -6.35385811e-01f, -9.14206207e-01f,
  -9.54405725e-01f, -1.50170609e-01f, 4.89212185e-01f, -3.40969324e-01f, 1.30691066e-01f, 1.58034906e-01f, 4.04522687e-01f, 4.76305485e-02f, -1.16218016e-01f, -1.74064599e-02f,
  -2.53983796e-01f, -1.93894908e-01f, -1.26109511e-01f, -1.80572703e-01f, -1.79096863e-01f, 3.18818331e-01f, 8.92363861e-02f, 1.06525503e-01f, 2.94832259e-01f, 2.29122773e-01f,
  -1.70526970e-02f, -7.43367523e-02f, -2.18512893e-01f, -1.18153758e-01f, 1.37250066e-01f, 2.74479598e-01f, 1.61064535e-01f, 3.42909582e-02f, 1.03557631e-01f, 2.80864984e-01f,
  5.92639923e-01f, -3.84415746e-01f, 1.53880581e-01f, -2.08809033e-01f, -6.18438981e-02f, -8.01372975e-02f, 1.07481755e-01f, -5.11515699e-02f, -1.07979134e-01f, 1.93018019e-01f,
  -7.29816779e-02f, -1.40460476e-01f, -1.12387955e-01f, 3.89781594e-02f, 2.35523172e-02f, -7.42519926e-03f, -1.98581964e-01f, -1.80849992e-02f, -7.64711993e-03f, 1.23042144e-01f,
  -1.40033782e-01f, -5.58681004e-02f, 1.79753929e-01f, 4.25463878e-02f, -1.35766417e-01f, -9.28140879e-02f, 6.14220686e-02f, -6.26638234e-02f, 7.27774873e-02f, 1.33368641e-01f,
  3.08414381e-02f, -5.72162354e-03f, -2.26644114e-01f, -1.12837860e-02f, -9.57668647e-02f, -4.13021706e-02f, 4.90266606e-02f, 7.29472563e-02f, -4.90285344e-02f, -5.47997281e-02f,
  1.53913662e-01f, 5.68626914e-03f, -1.81527175e-02f, 8.20411593e-02f, -8.23184848e-02f, -1.02105647e-01f, -5.21511845e-02f, -3.44570354e-02f, -6.76963031e-02f, -1.65812269e-01f,
  -1.40580505e-01f, 1.71600059e-01f, -1.47753861e-03f, 8.74856561e-02f, 6.26166090e-02f, -3.95287154e-03f, 6.04760349e-02f, 5.33824712e-02f, -4.24085259e-02f, 1.29310817e-01f,
  2.64554977e-01f, -3.00096512e-01f, 2.68316597e-01f, 6.68909177e-02f, -3.72822117e-03f, -3.94751988e-02f, -2.80741472e-02f, -1.55064315e-02f, 4.86562625e-02f, 1.09770887e-01f,
  -5.77275082e-02f, -6.63264543e-02f, 1.36819230e-02f, 2.58265883e-02f, 8.46124664e-02f, -1.41512426e-02f, -2.68452227e-01f, -4.61357972e-03f, 4.03456651e-02f, 3.58487852e-02f,
  1.06495894e-01f, 8.79346430e-02f, 2.25216106e-01f, 1.18436947e-01f, 6.98895976e-02f, 2.15297028e-01f, 3.67244959e-01f, 1.57806516e-01f, 2.05070674e-01f, 2.93467402e-01f,
  5.59672356e-01f, 2.68604100e-01f, 7.17866063e-01f, 1.87493399e-01f, 2.66354710e-01f, 5.55892110e-01f, 7.79199064e-01f, 3.56366783e-01f, -1.14078328e-01f, 1.08288817e-01f,
  -2.51580507e-01f, -3.98686320e-01f, -2.29177862e-01f, -2.34958693e-01f, 6.86572567e-02f, 2.60488331e-01f, 1.06754370e-01f, 1.38198584e-01f, 2.88506411e-02f, -1.41264070e-02f,
  -1.23071134e-01f, 1.06777854e-01f, 6.52312040e-02f, 7.67203048e-02f, -7.85946473e-02f, -2.31971651e-01f, 9.12570488e-03f, 9.10236165e-02f, -4.18520197e-02f, -2.74882644e-01f,
  -4.18254942e-01f, 3.23373765e-01f, -4.06212717e-01f, -3.99512947e-01f, -1.13668285e-01f, -1.54723272e-01f, -1.65064007e-01f, -9.02347267e-02f, -2.51980033e-02f, -1.81448143e-02f,
  -1.80886090e-01f, 2.99106892e-02f, 1.27891958e-01f, 5.97104663e-03f, 2.24081159e-01f, 1.24112211e-01f, 1.16921961e-01f, 1.53988123e-01f, 6.76075667e-02f, 3.05688940e-03f,
  -1.98844858e-02f, 1.10329047e-01f, 3.19027871e-01f, 1.22557342e-01f, 1.83394447e-01f, 7.35082105e-03f, 4.83115427e-02f, -2.35032104e-02f, 4.24849540e-02f, -6.60239607e-02f,
  -2.24905312e-01f, -4.99221347e-02f, 5.74586168e-02f, -3.70529555e-02f, 7.03929067e-02f, -5.71536720e-02f, -1.98243894e-02f, 7.88801461e-02f, 4.71705087e-02f, 1.50662094e-01f,
  9.61275250e-02f, -3.05996817e-02f, -3.80784459e-02f, -5.77555187e-02f, -1.02295779e-01f, 2.78823450e-02f, 2.08898768e-01f, -3.12353596e-02f, 7.36210793e-02f, 8.89784098e-02f,
  2.09772497e-01f, 8.68824944e-02f, 2.47048549e-02f, 8.65635946e-02f, 5.13278544e-02f, -6.57566339e-02f, 3.64823528e-02f, 1.17260069e-01f, -1.99612956e-02f, -2.06836360e-03f,
  -3.58090281e-01f, 3.38139802e-01f, -2.45909855e-01f, -1.10292092e-01f, 9.45056975e-02f, 6.05705148e-03f, -8.40587914e-02f, -1.42407253e-01f, -1.73976764e-01f, -1.43482804e-01f,
  -7.54037201e-02f, -7.25301802e-02f, 1.50413960e-01f, 1.60934791e-01f, -5.66481519e-03f, -4.02661264e-02f, -1.78335398e-01f, -5.32599650e-02f, -1.15248887e-02f, -1.61318123e-01f,
  -1.47471458e-01f, 8.86920020e-02f, 3.53875458e-02f, -9.09615904e-02f, -5.04027344e-02f, -1.00683555e-01f, -3.21774930e-02f, -5.30424826e-02f, 1.71776995e-01f, 2.13883035e-02f,
  1.34818304e+00f, -5.65717995e-01f, -1.12827599e+00f, 4.85826463e-01f, -3.86966132e-02f, -2.61505008e-01f, -8.34170699e-01f, 1.03373669e-01f, 6.23179674e-01f, -6.04273379e-01f,
  -6.21473230e-02f, 3.80582154e-01f, 1.41471222e-01f, -3.42302844e-02f, -4.39683199e-01f, -1.07781005e+00f, -1.01240826e+00f, -6.09715044e-01f, -2.55317062e-01f, 2.16197282e-01f,
  1.51453048e-01f, 4.11048494e-02f, 1.87713802e-01f, -3.84483635e-02f, 1.69156358e-01f, 1.17009878e-01f, -5.47063470e-01f, 7.80248716e-02f, -2.93854117e-01f, -2.55645543e-01f,
  -4.30923402e-01f, -3.29837017e-02f, 4.77054529e-02f, 1.51861385e-01f, -1.18586302e-01f, 1.51175454e-01f, -1.01935394e-01f, -2.02315867e-01f, 1.05491960e-02f, -4.34797481e-02f,
  8.18216950e-02f, 1.07001467e-02f, -1.78625118e-02f, 2.51815561e-02f, 9.74745676e-02f, -4.38754931e-02f, -1.86163202e-01f, -2.43223414e-01f, -2.55251288e-01f, -2.46448383e-01f,
  -3.40593643e-02f, -1.82182297e-01f, -2.64224827e-01f, -3.27272534e-01f, -2.60797888e-01f, 3.28374095e-02f, -2.98659891e-01f, 7.44274482e-02f, -4.15418744e-01f, 8.59725773e-02f,
  -1.47931781e-02f, -1.27533332e-01f, -4.31523211e-02f, -3.79655883e-02f, 2.41758022e-02f, -2.12424565e-02f, 6.50059357e-02f, -3.46028209e-02f, -8.50265622e-02f, -2.08199490e-02f,
  -2.94703618e-02f, -1.62501991e-01f, 2.54079215e-02f, -1.21886015e-01f, -1.38944671e-01f, -6.65550530e-02f, -8.32331832e-03f, -1.79932848e-01f, -4.63598594e-02f, -5.76421730e-02f,
  1.06408939e-01f, 1.39097162e-02f, 9.81914476e-02f, 1.39265740e-03f, -1.54726002e-02f, -1.04887605e-01f, 3.13563831e-02f, 9.63862836e-02f, 9.89008695e-02f, 8.36446136e-02f,
  2.68868327e-01f, -1.85502604e-01f, 1.89926133e-01f, 1.32240606e-02f, -4.43595462e-02f, -1.60315230e-01f, -3.66040841e-02f, -1.37871265e-01f, 2.13860258e-01f, 9.18416679e-02f,
  -1.13973282e-01f, 1.36562541e-01f, -4.89527509e-02f, -1.12610303e-01f, 1.48808397e-02f, 5.27675115e-02f, -1.46827206e-01f, 1.46288335e-01f, -1.24002390e-01f, 9.84928533e-02f,
  1.96349751e-02f, -1.59166202e-01f, 1.91977516e-01f, -3.34310643e-02f, 2.80365217e-02f, 1.68876976e-01f, -2.49369264e-01f, 1.55702859e-01f, -2.51887858e-01f, -2.48221800e-01f,
  8.21682334e-01f, 1.92000479e-01f, -6.00802898e-01f, 5.27663887e-01f, -4.83308494e-01f, -5.11841655e-01f, 2.33509555e-01f, 3.50753725e-01f, 2.45371059e-01f, 3.44601512e-01f,
  -2.65337616e-01f, -4.11375731e-01f, -2.34256864e-01f, -1.85081378e-01f, 2.87382631e-03f, 4.55905259e-01f, 1.07489079e-01f, -1.70330703e-01f, -2.49239340e-01f, 1.08426072e-01f,
  1.46186039e-01f, 4.20889646e-01f, 4.82963264e-01f, 2.20059857e-01f, 1.28528386e-01f, -9.69727412e-02f, -1.23824971e-03f, -2.34148607e-01f, -8.88669118e-02f, -9.72312242e-02f,
  -4.30766553e-01f, -2.98628151e-01f, -1.49987251e-01f, -8.91029909e-02f, -4.53247011e-01f, 1.89806614e-02f, -1.60584711e-02f, -1.57279938e-01f, -1.04099140e-01f, 7.69293830e-02f,
  -2.17341170e-01f, 7.38668516e-02f, -2.86105692e-01f, -1.69657245e-01f, -2.60042828e-02f, -4.53413874e-02f, -3.66717614e-02f, -1.14301801e-01f, -1.00596443e-01f, -2.15249866e-01f,
  -7.92269856e-02f, -4.42424923e-01f, -4.58964795e-01f, -1.81256652e-01f, -3.27943087e-01f, -4.12436038e-01f, -2.09103838e-01f, -1.47186309e-01f, -3.67090672e-01f, 3.31247032e-01f,
  1.00872559e-04f, -3.87904122e-02f, -9.49595571e-02f, 1.62678808e-02f, 1.24643125e-01f, 7.74386525e-03f, 2.38451473e-02f, -3.84530090e-02f, 2.04856806e-02f, 9.60548595e-02f,
  -1.53700471e-01f, 1.08149901e-01f, -5.21235466e-02f, 1.33415043e-01f, -8.10578912e-02f, -1.23450913e-01f, 3.29418257e-02f, 5.05416989e-02f, -1.52949467e-01f, 1.07472464e-01f,
  8.65043253e-02f, -2.46401913e-02f, -8.58923234e-03f, 1.44846678e-01f, -1.29222035e-01f, -1.27692908e-01f, 1.45178944e-01f, -1.97211429e-01f, 1.68398201e-01f, -5.64434305e-02f,
  4.12767917e-01f, -4.42915559e-01f, 3.30824018e-01f, 2.71574538e-02f, 1.11183859e-01f, 5.62763847e-02f, -3.96362133e-02f, -5.88064007e-02f, -3.01908255e-02f, 8.95514712e-02f,
  -2.62955762e-02f, 7.39317164e-02f, 4.21440117e-02f, 1.86280697e-03f, 6.48431405e-02f, 3.79886702e-02f, 7.84411952e-02f, -1.73733700e-02f, 1.10741526e-01f, 8.80056806e-03f,
  3.16425234e-01f, 1.75903827e-01f, 3.11258912e-01f, -1.78105710e-03f, 7.04179481e-02f, -1.79982223e-02f, -6.92084581e-02f, 1.05065428e-01f, -3.74207906e-02f, 9.81850863e-01f,
  1.28618729e+00f, 7.54982829e-01f, 4.64148343e-01f, 2.06126437e-01f, -2.61312395e-01f, -1.30214989e-01f, 8.26276187e-03f, 1.76999047e-02f, -1.76922202e-01f, 8.20948631e-02f,
  9.24519822e-02f, -1.07972324e-01f, -1.52236000e-01f, -1.43627420e-01f, 7.07572177e-02f, -7.51790479e-02f, -2.57716149e-01f, 2.19074100e-01f, 9.71208364e-02f, 1.23314627e-01f,
  -6.70166090e-02f, -5.05232550e-02f, 2.28217974e-01f, 1.31460488e-01f, 2.65555799e-01f, -2.34203581e-02f, 6.67018294e-02f, 1.18968546e-01f, 1.65529698e-01f, 5.76453686e-01f,
  7.58543730e-01f, 6.72749639e-01f, -5.75751364e-01f, -1.80491567e-01f, -1.44258728e-02f, 1.28525108e-01f, 1.03982881e-01f, -5.94580173e-02f, -1.40333071e-01f, -5.77117205e-02f,
  -1.35959283e-01f, 1.21833542e-02f, 1.09252790e-02f, -6.37198761e-02f, -5.39121479e-02f, -7.24168196e-02f, 4.65784669e-02f, 7.30158314e-02f, -1.26890317e-01f, 1.37363777e-01f,
  -3.42701226e-02f, -5.33340983e-02f, -6.50957674e-02f, -2.54788518e-01f, 1.29390866e-01f, -8.85611549e-02f, 5.52945025e-02f, 1.55805767e-01f, 1.41375199e-01f, 3.57564777e-01f,
  -9.35849845e-02f, 1.52234718e-01f, 1.77897178e-02f, 7.19664097e-02f, 8.24045092e-02f, 2.31416225e-02f, 6.62354082e-02f, -7.83972209e-04f, -4.61863354e-02f, 2.02761218e-02f,
  5.49075939e-02f, 1.51254628e-02f, 7.95851797e-02f, -3.10649537e-03f, -6.42817616e-02f, -2.77725514e-02f, 3.12817469e-02f, -9.08141956e-02f, -1.29603986e-02f, -2.31539737e-02f,
  1.41773466e-02f, -8.03494155e-02f, 2.62099206e-02f, -2.36283299e-02f, 2.21896432e-02f, 9.00974572e-02f, 9.13092867e-02f, 6.46125823e-02f, 6.91311657e-02f, -6.41055107e-02f,
  -6.04442239e-01f, -6.26310349e-01f, 7.71203637e-02f, -1.86549664e-01f, 6.92310184e-02f, -7.09366519e-03f, 5.50888292e-02f, 6.38260394e-02f, -4.97819670e-02f, 1.12403169e-01f,
  2.29414105e-02f, 2.37597898e-01f, 5.13476953e-02f, -1.02879917e-02f, -9.74740162e-02f, -1.53973386e-01f, -9.75561142e-02f, -1.29552975e-01f, -1.99858293e-01f, -6.86921999e-02f,
  -1.74355924e-01f, -3.67606223e-01f, -3.00000787e-01f, -1.51349530e-01f, -6.84198141e-02f, -3.49872559e-01f, -1.03224106e-01f, -7.52911866e-02f, -2.27808550e-01f, -1.10934108e-01f,
  1.31751847e+00f, -8.57185423e-01f, -2.91542470e-01f, 2.74670631e-01f, -1.56415939e-01f, 1.37373507e-01f, -9.18167904e-02f, 2.56938059e-02f, 3.30040663e-01f, -1.79412719e-02f,
  5.59873842e-02f, 3.19964796e-01f, 2.20337048e-01f, 2.30434954e-01f, 2.95870483e-01f, -1.21671304e-01f, -2.55041778e-01f, 2.83400089e-01f, 4.41053540e-01f, 1.60996065e-01f,
  -1.50026694e-01f, -1.36840433e-01f, 9.47218388e-02f, 4.93995510e-02f, -3.54952455e-01f, 1.39759943e-01f, -1.87662527e-01f, -2.25816861e-01f, -1.87864035e-01f, -3.31649661e-01f,
  -1.76858753e-01f, -4.48783711e-02f, 2.94829935e-01f, 5.49951531e-02f, -1.89753637e-01f, 1.23963065e-01f, 5.04869036e-02f, -5.41799180e-02f, -5.16200028e-02f, -1.57848939e-01f,
  -5.43232523e-02f, -5.46876825e-02f, -6.32295534e-02f, -1.73585519e-01f, -3.70089374e-02f, -5.36713935e-02f, -8.34824368e-02f, 4.43775021e-02f, 3.87577601e-02f, -4.27419692e-02f,
  -2.25864053e-01f, -5.44084273e-02f, -2.58717742e-02f, -3.55214179e-02f, 5.92963696e-02f, 1.31747052e-01f, -8.05692822e-02f, -3.56151722e-02f, 2.20303401e-01f, 1.11160532e-01f,
  1.38568774e-01f, 1.82691038e-01f, 6.23829514e-02f, -4.68866974e-02f, 1.09763518e-01f, 4.09466922e-02f, -5.31712314e-03f, 8.69370550e-02f, 1.62407979e-01f, -4.93756980e-02f,
  -8.27797577e-02f, 1.75810885e-02f, 4.80081216e-02f, 4.62564826e-02f, -1.48195238e-03f, -1.05352685e-01f, -3.16786617e-02f, -3.12081464e-02f, -8.47351402e-02f, -5.62662594e-02f,
  2.26637796e-02f, 1.59481958e-01f, 6.22445717e-03f, -2.25993365e-01f, -1.23733975e-01f, 5.61156683e-03f, -7.32209384e-02f, -1.31512269e-01f, -1.53597407e-02f, -4.36310545e-02f,
  7.43254460e-03f, 1.89258888e-01f, 8.74381810e-02f, 6.25911281e-02f, -2.04849169e-02f, -5.18159494e-02f, 4.22266684e-02f, -6.96460977e-02f, -1.50508016e-01f, 3.83414589e-02f,
  -6.09079318e-04f, 5.54679818e-02f, -9.84196067e-02f, 1.50979136e-03f, 5.45234643e-02f, 2.52330713e-02f, -7.94885214e-03f, 1.28486797e-01f, 5.39963692e-02f, -9.91543755e-02f,
  -2.02722162e-01f, 3.05606991e-01f, 3.65777731e-01f, 2.62006611e-01f, 2.36182436e-01f, 4.39133942e-01f, 3.27622634e-04f, -2.56371088e-02f, 3.22081834e-01f, 3.63332368e-02f,
  -1.26381207e+00f, 1.98203966e-01f, 3.27584952e-01f, -8.11677456e-01f, -4.84809250e-01f, -1.81552038e-01f, -4.26907577e-02f, 3.44364368e-03f, -1.13572292e-01f, 1.25002906e-01f,
  1.35612294e-01f, -8.55434164e-02f, 1.23722501e-01f, -2.91453093e-01f, -6.66877806e-01f, -2.22728893e-01f, -5.07006645e-01f, -6.89713538e-01f, -4.92988169e-01f, -5.36997378e-01f,
  -4.44265217e-01f, -6.13241971e-01f, -5.91669202e-01f, -2.09229112e-01f, -1.32167846e-01f, -7.18132854e-02f, 2.58557647e-01f, -2.13669568e-01f, 1.55437410e-01f, -2.92340100e-01f,
  2.95257598e-01f, -1.40996143e-01f, -1.44612510e-02f, -4.41667080e-01f, 6.88630268e-02f, 1.33761242e-01f, 8.92747566e-02f, -9.48281512e-02f, 4.16216962e-02f, 1.04181342e-01f,
  -2.79184252e-01f, 2.18894742e-02f, -3.87482077e-01f, 5.60022444e-02f, -2.03105092e-01f, -2.55831242e-01f, 2.58657429e-02f, -1.18889630e-01f, -1.86008513e-01f, 2.15323538e-01f,
  -3.48551035e-01f, -3.68456811e-01f, -2.94354886e-01f, 3.10703725e-01f, 3.56389701e-01f, -5.50060645e-02f, 4.71863508e-01f, 9.09499824e-02f, 3.78561646e-01f, 1.44139439e-01f,
  1.15200669e-01f, 4.40659642e-01f, 6.19451776e-02f, -5.93639351e-02f, 1.23026110e-02f, 7.13390335e-02f, -2.72395816e-02f, 9.91755514e-04f, -6.49148747e-02f, 6.28701150e-02f,
  1.68548718e-01f, -7.84633756e-02f, 5.60308993e-03f, -8.50886256e-02f, 1.29061967e-01f, -3.47060561e-01f, -1.04051884e-02f, 1.02358416e-01f, -2.23188758e-01f, -1.09824471e-01f,
  -2.61618555e-01f, -5.21658957e-02f, -4.00235690e-02f, 7.30805174e-02f, -6.34056255e-02f, 7.55709689e-03f, -1.00033149e-01f, -1.21234439e-01f, -1.50718791e-02f, -2.23281026e-01f,
  1.74107775e-01f, -1.50804639e-01f, -1.53985262e-01f, 1.14261778e-02f, -1.47231494e-03f, 1.19250298e-01f, -3.53323258e-02f, 1.16085500e-01f, -1.61740273e-01f, 6.09169379e-02f,
  -1.13074742e-01f, 1.33184031e-01f, 1.02437831e-01f, 2.84340203e-01f, -3.05326041e-02f, 3.30865122e-02f, -2.41174296e-01f, -9.56080034e-02f, -1.26767606e-01f, 3.00968945e-01f,
  -1.31318480e-01f, -3.20897281e-01f, -4.01887417e-01f, -1.39498673e-02f, -1.39978323e-02f, -2.83093095e-01f, 6.85051531e-02f, -9.12885927e-03f, -1.57544598e-01f, 1.90384462e-01f,
  -1.10044777e+00f, -2.58783877e-01f, -4.57601786e-01f, -6.29215479e-01f, 2.37348676e-01f, 3.06285739e-01f, 5.52756190e-01f, 2.80871570e-01f, -1.82725817e-01f, -2.16374710e-01f,
  -7.25982934e-02f, -5.62755018e-02f, -3.70788515e-01f, 1.39614135e-01f, 2.77374774e-01f, 1.68314368e-01f, 1.81185365e-01f, -2.37702839e-02f, 2.15259641e-01f, 5.38623571e-01f,
  5.01826465e-01f, -2.51078963e-01f, -5.14081419e-01f, -1.20407432e-01f, -8.83494911e-04f, 8.77626427e-03f, -3.50706607e-01f, -1.87775746e-01f, 1.01336271e-01f, -1.33748457e-01f,
  -2.09780201e-01f, -3.95429403e-01f, 3.36703002e-01f, 4.93555479e-02f, -1.29690096e-01f, -2.16518059e-01f, 5.16631044e-02f, -3.83615553e-01f, -4.15839488e-03f, -1.67120948e-01f,
  -2.31653571e-01f, -8.12583789e-02f, -2.60853410e-01f, 1.32308632e-01f, -1.84439719e-01f, -6.43135607e-02f, -1.69696346e-01f, -6.21335097e-02f, -2.04332754e-01f, -5.37719280e-02f,
  4.95740116e-01f, 1.37458798e-02f, -2.05504104e-01f, 2.89940089e-01f, 1.12808213e-01f, 1.62898123e-01f, 1.64729327e-01f, 3.22378069e-01f, 1.16577052e-01f, -5.01378894e-01f,
  1.38633221e-01f, -4.37790342e-02f, -2.78358962e-02f, -1.04341283e-02f, 2.28340514e-02f, -1.98553056e-01f, 6.30170777e-02f, 9.19260234e-02f, 1.09571358e-02f, -1.89347863e-01f,
  1.01080537e-01f, 1.58363879e-02f, 9.92129073e-02f, -1.67326227e-01f, -7.51301646e-02f, -3.11214775e-02f, 2.55981013e-02f, -3.80497724e-02f, -5.54085709e-03f, -1.89911619e-01f,
  4.39596176e-02f, 1.22990524e-02f, -1.26410514e-01f, 1.14614598e-01f, 1.64697424e-01f, 2.37544905e-02f, 3.60956974e-02f, 9.42384452e-02f, -6.50803819e-02f, 6.69536006e-04f,
  -3.96175444e-01f, 3.30946565e-01f, -3.74925703e-01f, 8.97888094e-02f, -1.70809150e-01f, 1.13175966e-01f, -6.50794059e-02f, 7.90913962e-03f, -1.08704798e-01f, 1.02333985e-02f,
  1.68583915e-01f, -3.77190523e-02f, -1.03219628e-01f, 1.38452157e-01f, 7.81939477e-02f, 3.36279310e-02f, 6.46413788e-02f, -7.92008862e-02f, 8.25448185e-02f, -1.43862739e-01f,
  1.28011256e-01f, 5.12687564e-02f, -2.44003385e-01f, -7.37400353e-02f, 5.08629829e-02f, 6.25246614e-02f, -2.39124492e-01f, -7.59992609e-03f, -7.02638701e-02f, -3.25042725e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.02502215e+00f, 8.34869444e-01f, 2.78974771e-01f, 9.08796430e-01f, 6.21161938e-01f, 4.01286155e-01f, 8.26618314e-01f, 4.83100951e-01f, 1.00336671e+00f, 4.77403492e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -7.89595675e-03f, 3.75477672e-01f, 1.93431839e-01f, -8.41482133e-02f, 3.66189092e-01f, -1.88582405e-01f, -3.97516647e-03f, 4.68442310e-03f, -1.09286182e-01f, -7.22799748e-02f,
  -4.72373553e-02f, 5.74249446e-01f, -1.25529900e-01f, -2.61544175e-02f, 4.66984026e-02f, -2.95732826e-01f, -2.59063125e-01f, -8.10789466e-02f, -1.32619992e-01f, 7.03093112e-02f,
  -9.26779807e-02f, -6.92860484e-01f, -2.25508481e-01f, 1.77184612e-01f, -2.91021317e-01f, 1.90238833e-01f, 2.54468501e-01f, -4.83760759e-02f, -3.00812632e-01f, -4.98618990e-01f,
  5.26582152e-02f, 1.31131962e-01f, 2.39869133e-02f, -2.70086676e-01f, 1.46185711e-01f, -4.53268737e-02f, 2.00095937e-01f, -2.70404398e-01f, 3.99228126e-01f, 7.26642683e-02f,
  2.48646036e-01f, 1.00246407e-01f, -4.95255053e-01f, 4.38040286e-01f, -5.59516549e-01f, -2.46994346e-01f, 1.44330263e-01f, 2.85193503e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.04607081e-01f, -4.45315063e-01f, 5.09734333e-01f, -3.38707954e-01f, 6.45147115e-02f, -6.26059398e-02f, -3.51178199e-01f, 9.96767163e-01f, -2.86878377e-01f, -9.82059240e-02f,
  2.55238593e-01f, -7.39780784e-01f, -2.74027467e-01f, -5.78945160e-01f, 1.85291812e-01f, 1.45329607e+00f, 2.28212714e-01f, -1.09678328e-01f, 2.09553614e-01f, 4.50620115e-01f,
  1.41935840e-01f, 5.54792762e-01f, -1.14952445e+00f, 4.52357143e-01f, -4.77345079e-01f, -1.01513922e-01f, 1.42193389e+00f, 6.17897868e-01f, 6.61502719e-01f, 6.99878454e-01f,
  -2.65281852e-02f, -8.03517163e-01f, 7.11511731e-01f, 7.25835502e-01f, -1.38400123e-01f, 4.09028381e-01f, 7.66866028e-01f, 8.68641138e-01f, 6.76006913e-01f, 5.45627356e-01f,
  -3.24673504e-02f, 4.05755639e-02f, -7.73451030e-01f, 9.43936259e-02f, -3.12529095e-02f, -6.32839501e-01f, 3.87833089e-01f, 1.02308643e+00f, 1.19942918e-01f, 2.80453295e-01f,
  1.57280564e-01f, -2.95327872e-01f, -1.09222162e+00f, -5.51459134e-01f, -1.63777787e-02f, 4.57096577e-01f, -3.74869794e-01f, 4.47633892e-01f, 6.23003840e-01f, -5.47605991e-01f,
  9.77880895e-01f, -1.20364988e+00f, -1.13570106e+00f, -4.03676555e-02f, 8.55383813e-01f, 3.14034939e-01f, 5.36236048e-01f, 3.54023784e-01f, -5.04718184e-01f, -5.68641484e-01f,
  1.75236857e+00f, -1.33102968e-01f, -2.03966990e-01f, 1.00639415e+00f, -9.94594693e-01f, 7.01823711e-01f, 4.57290560e-01f, -3.87435630e-02f, -1.46603119e+00f, -2.88363516e-01f,
  -3.67793262e-01f, -7.77929604e-01f, 4.78238672e-01f, 4.88673784e-02f, -3.16254884e-01f, -7.30657160e-01f, -4.23303038e-01f, 1.96149442e-02f, -6.19856536e-01f, 5.84677994e-01f,
  9.00492728e-01f, -8.03364933e-01f, 3.11762094e-01f, 3.26536775e-01f, 4.56782311e-01f, 1.03308797e+00f, 2.69721538e-01f, 6.03146970e-01f, 6.84887767e-01f, -2.13391542e-01f,
  5.51763892e-01f, -1.39754951e+00f, -5.44138730e-01f, 3.41146253e-02f, 3.62430602e-01f, 8.47303867e-02f, 2.54226178e-01f, 1.32276940e+00f, -6.67162478e-01f, -1.08627844e+00f,
  9.81146336e-01f, 8.73425245e-01f, 3.87965232e-01f, 1.31961107e+00f, 9.59313959e-02f, 3.22944492e-01f, 8.82297277e-01f, 1.99557021e-01f, 7.44416356e-01f, 5.29290974e-01f,
  -9.62485969e-01f, 6.38486207e-01f, -8.65102932e-02f, -1.20745122e+00f, -1.78974450e-01f, -7.59087682e-01f, 4.55579251e-01f, -2.89564580e-01f, 6.50495708e-01f, -4.24242258e-01f,
  -1.01615995e-01f, 1.96218356e-01f, 1.89419314e-01f, 1.03741014e+00f, 7.01228499e-01f, 8.29181552e-01f, -5.32913566e-01f, 9.78549793e-02f, -2.68420488e-01f, -1.42199561e-01f,
  1.67038798e-01f, -6.62331939e-01f, -6.09985113e-01f, 5.96762002e-01f, 5.11711001e-01f, 1.35559189e+00f, 3.91747326e-01f, -6.00975752e-01f, 1.15996949e-01f, 7.04032302e-01f,
  -1.47120610e-01f, 5.94139516e-01f, 5.40149212e-01f, -7.67098904e-01f, 5.56417815e-02f, -8.16403806e-01f, 4.77468938e-01f, -8.65890205e-01f, 3.31934631e-01f, -1.16624427e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.48465410e-01f, 7.97040999e-01f, 2.30630636e-01f, 8.49378824e-01f, 3.35957646e-01f, 5.44448160e-02f, 6.15402162e-01f, 4.31236297e-01f, 6.42832696e-01f, 7.04736054e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  3.55277568e-01f, -5.20167768e-01f, 3.50932442e-02f, -7.67779171e-01f, -6.45811856e-02f, -4.55435395e-01f, 4.38031793e-01f, 3.15022886e-01f, -1.05973411e+00f, -4.91151214e-01f,
  -8.59167933e-01f, 4.44794178e-01f, 1.78587779e-01f, -1.51909381e-01f, 1.99456200e-01f, -1.06759858e+00f, 1.22617334e-01f, -5.07678032e-01f, -4.41895902e-01f, 9.78439987e-01f,
  -3.68282199e-01f, -1.06362069e+00f, -9.16121840e-01f, 8.28884006e-01f, -4.82779711e-01f, -3.34071159e-01f, 3.58055681e-02f, 1.02937305e+00f, -1.38420141e+00f, -8.16036820e-01f,
  -1.00371253e+00f, -6.82048142e-01f, 4.14562732e-01f, -3.77734333e-01f, 4.45699543e-01f, -1.66305318e-01f, -2.51809955e-01f, -3.49656433e-01f, 3.41905385e-01f, 2.22077876e-01f,
  1.01123941e+00f, -1.30201411e+00f, -7.09087133e-01f, -6.93127453e-01f, -1.54859006e+00f, 7.47286022e-01f, 7.27343142e-01f, 1.44252732e-01f, -3.25938225e-01f, 1.75148785e-01f,
  -7.93389380e-01f, 4.33311969e-01f, 5.29199064e-01f, 3.30816358e-01f, 4.16135997e-01f, -1.31943154e+00f, 9.21950817e-01f, -1.34194505e+00f, -4.69474345e-01f, 8.16534013e-02f,
  3.13583374e-01f, 2.65186340e-01f, -1.12145150e+00f, -9.56538141e-01f, -2.47929007e-01f, -4.35513020e-01f, 3.86266142e-01f, -4.23964262e-02f, 2.62004077e-01f, -5.72091699e-01f,
  -3.49707961e-01f, 2.57592469e-01f, -2.29910966e-02f, -9.97314572e-01f, -8.76147076e-02f, -2.31466129e-01f, 7.78160542e-02f, 6.09119892e-01f, -1.05258048e+00f, 1.07330072e+00f,
  -5.74841022e-01f, 9.86524224e-01f, 7.72126555e-01f, 1.20697880e+00f, -1.65253684e-01f, 3.82180691e-01f, -1.19903719e+00f, 4.48671162e-01f, -6.07215643e-01f, -4.80124742e-01f,
  -1.38250947e-01f, -3.71699631e-01f, 9.10510182e-01f, -1.57204777e-01f, -5.17041862e-01f, -1.13884962e+00f, -2.49692127e-02f, -1.06131613e+00f, -6.83212578e-01f, -8.09707999e-01f,
  -1.89912692e-01f, -5.88733315e-01f, -1.84036219e+00f, 2.71578699e-01f, 1.35124207e-01f, 5.30916274e-01f, -5.06323092e-02f, -1.07286298e+00f, -6.31411135e-01f, -7.40426719e-01f,
  4.51170683e-01f, 3.94701697e-02f, -8.20209444e-01f, -3.17339659e-01f, 8.38922486e-02f, -8.02701533e-01f, 4.02020097e-01f, 1.32738698e+00f, 1.05400980e+00f, -4.62344550e-02f,
  2.57651329e-01f, -4.43451181e-02f, -1.75904140e-01f, -9.55508351e-02f, -5.76127172e-01f, -1.52414775e+00f, 4.03900445e-01f, -7.88832724e-01f, 4.32920754e-01f, -4.70652282e-01f,
  -1.18512833e+00f, -1.91974252e-01f, -4.90582198e-01f, 6.39956415e-01f, 8.42353180e-02f, -1.13576865e+00f, -7.03995302e-02f, -9.43489313e-01f, 8.81857932e-01f, -6.36226118e-01f,
  -6.90867722e-01f, -6.59153342e-01f, -1.34538427e-01f, -7.45250463e-01f, 3.39259535e-01f, 5.39163291e-01f, -5.32832682e-01f, 1.71830878e-02f, 5.14937222e-01f, -6.99624717e-01f,
  5.54836273e-01f, -3.28846946e-02f, -5.13293028e-01f, 4.73557502e-01f, -1.12861872e+00f, -3.61512691e-01f, -1.04992080e+00f, -5.57456970e-01f, 7.71246627e-02f, 1.16006124e+00f,
  5.47317453e-02f, -6.22217469e-02f, -6.14090741e-01f, 6.94508493e-01f, -7.74045467e-01f, 6.27810478e-01f, -6.63115144e-01f, -1.52881646e+00f, 3.16672735e-02f, -7.16297805e-01f,
  -6.77537143e-01f, -8.13943088e-01f, 1.21242070e+00f, -1.00602555e+00f, -4.80744720e-01f, 6.46873236e-01f, -2.40978822e-01f, 8.68229091e-01f, 5.16053200e-01f, -3.09699416e-01f,
  2.01226532e-01f, -4.74338323e-01f, -5.64838767e-01f, -9.80127931e-01f, -6.47920966e-01f, 6.31265759e-01f, 1.73640639e-01f, 4.43052679e-01f, -2.88865894e-01f, 3.77499580e-01f,
  -1.25260279e-01f, -9.70330119e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.91694224e-01f, -3.21292996e-01f, 1.85831606e-01f, -4.70686644e-01f, 1.37452900e-01f, 3.34308475e-01f, 3.16927023e-02f, 6.94842279e-01f, -2.50616018e-02f, -1.99161932e-01f,
  -1.19965345e-01f, -3.98702085e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    