/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.50199211e-01f, -2.56689310e-01f, -7.36610442e-02f, -2.17201456e-01f, 9.57075432e-02f, 1.19062282e-01f, -8.42239186e-02f, -6.95124641e-02f, -7.97323287e-02f, 3.88444960e-03f,
  2.64830858e-01f, 4.14489150e-01f, 3.41877341e-01f, 1.93666443e-01f, -4.38284092e-02f, -2.18969434e-01f, -4.20001239e-01f, -2.77684420e-01f, 8.66427198e-02f, 1.12599675e-02f,
  1.50794610e-02f, -3.48070383e-01f, -3.67096603e-01f, -2.83891588e-01f, 4.80655879e-02f, 1.88532218e-01f, -1.67050108e-01f, -8.15043524e-02f, -7.10935751e-03f, -2.30400503e-01f,
  4.08407152e-01f, -1.03463493e-01f, 7.93291926e-02f, 4.79545631e-02f, 7.96141773e-02f, 2.96147671e-02f, 2.46839691e-02f, -8.52699503e-02f, 4.22992408e-02f, -5.98204769e-02f,
  1.59190707e-02f, 3.89076881e-02f, 6.44248724e-02f, -8.05494860e-02f, -3.93166728e-02f, 9.68679041e-02f, -1.41748399e-01f, -4.23229970e-02f, -4.80778515e-02f, 1.73752919e-01f,
  4.35506701e-02f, -4.13910188e-02f, 6.23923764e-02f, -5.38621098e-02f, -3.15342098e-02f, 1.12799153e-01f, 8.67609009e-02f, 1.13965787e-01f, 8.16640407e-02f, -2.84797810e-02f,
  -1.21283732e-01f, 5.03154658e-02f, 3.98346186e-02f, 1.14213089e-02f, -4.97239754e-02f, -1.26726329e-02f, -2.09719650e-02f, -4.17700335e-02f, -5.96406963e-03f, -4.02611867e-02f,
  3.08982395e-02f, 1.85118616e-02f, 8.91403388e-03f, -6.80343434e-02f, 2.74923071e-02f, -3.01342886e-02f, -8.39784294e-02f, -4.04346995e-02f, -1.14866607e-02f, -7.04273283e-02f,
  6.11306615e-02f, 5.23544289e-02f, -1.86471250e-02f, -2.83085573e-02f, -1.63590908e-02f, -4.99049872e-02f, 2.03569401e-02f, -4.50138785e-02f, 3.20469216e-02f, -3.26337740e-02f,
  2.01104507e-01f, -5.78575060e-02f, 4.75142039e-02f, -1.50033059e-02f, 5.92197627e-02f, 2.99698347e-03f, 4.10355851e-02f, -3.66497338e-02f, -6.29309267e-02f, 1.02655143e-02f,
  6.40618056e-02f, -8.11131150e-02f, -2.29968429e-02f, -2.74898931e-02f, 1.63646527e-02f, 6.33430555e-02f, -1.34432957e-01f, 4.70958613e-02f, 2.18856409e-02f, 6.69083446e-02f,
  -9.64221656e-02f, -4.25941646e-02f, 2.92191338e-02f, 6.67997226e-02f, 8.50484371e-02f, 1.35126278e-01f, 4.07522731e-02f, 1.29446343e-01f, 1.62154853e-01f, -7.77355358e-02f,
  9.11387324e-01f, -4.52855617e-01f, 3.56427133e-01f, 1.06454372e-01f, 8.91045183e-02f, 3.46986204e-01f, 5.30249774e-02f, 4.62416187e-02f, 1.08272424e-02f, -1.38379768e-01f,
  -5.41242622e-02f, -3.33719663e-02f, -3.47082764e-02f, -2.76078726e-03f, 4.14993495e-01f, 1.37745485e-01f, 2.91075319e-01f, 5.24364412e-01f, 6.11868799e-01f, 1.72272384e-01f,
  -1.50815338e-01f, 1.06599502e-01f, 2.54240304e-01f, 2.76497096e-01f, -1.63357019e-01f, -1.46370336e-01f, 5.75799830e-02f, 1.66465506e-01f, 1.14648387e-01f, -1.59243777e-01f,
  4.11252379e-02f, 1.80739269e-01f, 2.68971056e-01f, 1.65510774e-01f, 1.13102697e-01f, 1.76719844e-01f, 1.28711551e-01f, 1.80895075e-01f, 1.10238828e-01f, 4.25348952e-02f,
  1.93982229e-01f, 1.32757336e-01f, 2.05067724e-01f, -4.40051407e-02f, 1.86993152e-01f, 1.29687816e-01f, 8.51821750e-02f, 2.04824477e-01f, 2.31861293e-01f, 8.72736722e-02f,
  -2.59862319e-02f, 1.92820564e-01f, 2.90185243e-01f, 1.52484462e-01f, 2.26716518e-01f, 2.90845305e-01f, 1.61656052e-01f, 2.17305243e-01f, 2.45705530e-01f, -1.14639603e-01f,
  -1.91260844e-01f, -4.19307314e-02f, -1.12182334e-01f, -1.45762220e-01f, -2.12184489e-01f, -9.06995013e-02f, -6.16439991e-02f, -1.42842576e-01f, -7.50195682e-02f, -7.17172474e-02f,
  -1.32459700e-01f, -9.70700979e-02f, -1.46575168e-01f, -8.16396624e-02f, -1.07848309e-01f, -2.58972868e-02f, 4.59025800e-02f, -1.31136626e-01f, -8.69096220e-02f, -9.00705308e-02f,
  -1.50038563e-02f, -3.22230048e-02f, -4.63942252e-02f, -1.38545692e-01f, -9.18646082e-02f, -6.37988374e-02f, -3.42103168e-02f, -1.17982604e-01f, -7.96559379e-02f, -2.94698495e-02f,
  -2.87404627e-01f, 3.48796308e-01f, 1.04261734e-01f, 2.00070769e-01f, 1.14518158e-01f, 1.72192365e-01f, 6.94615915e-02f, 2.15597883e-01f, 1.14609592e-01f, 6.72622845e-02f,
  1.02124825e-01f, 1.76536530e-01f, 1.23244897e-01f, 6.15229942e-02f, 1.79173112e-01f, 8.66815373e-02f, 6.08481206e-02f, 1.19656093e-01f, 1.61052272e-01f, 3.03521659e-03f,
  6.31977692e-02f, 1.31169349e-01f, 2.88444608e-02f, -6.96914503e-03f, 1.18777759e-01f, 2.03751728e-01f, 2.62319148e-02f, 5.21849282e-02f, 2.99829483e-01f, -1.95269987e-01f,
  -8.84206295e-01f, -2.80890644e-01f, 4.49269325e-01f, -1.15775734e-01f, 3.42495918e-01f, 3.99332583e-01f, 1.98172450e-01f, 7.17486516e-02f, -3.61512527e-02f, -1.48743764e-01f,
  8.21678564e-02f, -3.54849160e-01f, -3.19045126e-01f, -1.78088412e-01f, -1.95415646e-01f, 1.20097976e-02f, 1.99170455e-01f, -6.68462068e-02f, -1.71827767e-02f, -3.09658591e-02f,
  -1.12324739e-02f, -1.90839872e-01f, -3.16245049e-01f, -2.62784570e-01f, -2.70922154e-01f, -3.77304256e-01f, -1.30476221e-01f, -2.02325478e-01f, -1.33044481e-01f, -3.75194579e-01f,
  -1.88543007e-01f, -5.92480972e-02f, -9.93616730e-02f, -4.95072268e-02f, -2.45446283e-02f, -2.46800989e-01f, -9.93586257e-02f, -2.00509578e-01f, -1.31821141e-01f, -1.40021577e-01f,
  -5.57705089e-02f, -1.08831584e-01f, -1.20994724e-01f, -3.32330950e-02f, -5.89525811e-02f, -7.43908212e-02f, -8.37117732e-02f, -9.39815715e-02f, 1.18699437e-02f, 1.10048298e-02f,
  8.44798014e-02f, 8.91945586e-02f, 6.51227683e-02f, 5.49520068e-02f, 5.74029163e-02f, 9.26537290e-02f, -1.09378688e-01f, -1.17973395e-01f, 2.58253366e-02f, -3.82149577e-01f,
  -3.15623882e-04f, 2.19272077e-02f, 8.55516121e-02f, 5.86825535e-02f, -1.93322655e-02f, 3.93806286e-02f, 4.09491733e-02f, 3.88367772e-02f, 7.68978596e-02f, -2.76206117e-02f,
  2.54360568e-02f, 1.86538860e-01f, 7.09133521e-02f, -6.08515888e-02f, -1.08273663e-02f, 1.58871144e-01f, 3.60026062e-02f, -8.98790509e-02f, 7.19236508e-02f, 8.24839324e-02f,
  6.17390499e-02f, 7.15915337e-02f, 7.54641816e-02f, 1.23350555e-02f, 1.51039526e-01f, 9.63386148e-02f, 7.12773353e-02f, 1.75828803e-02f, 2.02687234e-02f, 9.84609053e-02f,
  -2.04743788e-01f, 1.93019211e-01f, -2.50752628e-01f, -8.26501846e-02f, -3.47924791e-02f, -2.98294388e-02f, -5.90289682e-02f, -2.13980377e-02f, -1.45821972e-02f, -7.49823451e-02f,
  -4.50408366e-03f, -1.44078657e-01f, -5.11754081e-02f, -7.17883259e-02f, -4.42584977e-02f, -4.36240919e-02f, -1.12286601e-02f, -6.56090453e-02f, -1.43714556e-02f, 3.99691351e-02f,
  -1.94277754e-03f, -7.46269375e-02f, -1.64862365e-01f, -6.47232234e-02f, -3.34345289e-02f, -3.46354954e-02f, -1.47506267e-01f, -9.93599743e-02f, -4.80530523e-02f, -3.34461600e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.34694646e-02f, 4.27275524e-02f, 1.23218429e+00f, 1.29446656e-01f, -1.72746107e-01f, -2.24334538e-01f, -8.59105229e-01f, -8.00413117e-02f, 3.10666621e-01f, -2.34446093e-01f,
  -4.65544224e-01f, -7.97834754e-01f, -2.43515864e-01f, -2.95924932e-01f, -5.21078765e-01f, -3.65422845e-01f, 1.29929736e-01f, 2.67057717e-01f, -1.80628031e-01f, -7.18345106e-01f,
  -9.64824378e-01f, -2.15251774e-01f, 2.55484045e-01f, 1.85003459e-01f, 3.42308939e-01f, -1.77231655e-01f, 9.20160592e-01f, 4.11759943e-01f, -2.20892727e-02f, 4.65336204e-01f,
  1.82760715e-01f, 9.55377519e-01f, 6.25700727e-02f, -4.08517689e-01f, -5.85216098e-02f, -7.30106886e-03f, -2.08077744e-01f, 6.66515648e-01f, -1.98742047e-01f, 1.97476327e-01f,
  -1.67814374e-01f, -4.29115802e-01f, 6.10775724e-02f, -2.09251732e-01f, -3.84275243e-03f, -1.25335127e-01f, 4.35276389e-01f, 1.11062251e-01f, 3.49813662e-02f, 4.77294251e-02f,
  -6.84844434e-01f, -2.43633807e-01f, 1.86236814e-01f, 3.07106107e-01f, 3.18070799e-01f, -4.60969776e-01f, 3.64095420e-01f, 4.95902658e-01f, 6.52801096e-01f, 3.11615884e-01f,
  -1.75095677e-01f, 1.96833298e-01f, -1.44797817e-01f, 1.32382229e-01f, -1.93618000e-01f, 1.27375886e-01f, 2.30446637e-01f, -1.11124545e-01f, -2.44953092e-02f, -9.34973173e-03f,
  -4.59160935e-03f, 2.35176403e-02f, -9.41457599e-02f, 1.61946073e-01f, 1.45001924e-02f, 1.67667732e-01f, -2.10952729e-01f, -7.15221912e-02f, 8.48291442e-02f, 2.95339730e-02f,
  -4.90899198e-02f, -4.27410789e-02f, 7.43120834e-02f, -1.20848529e-01f, -7.01831058e-02f, 1.76777348e-01f, 3.23889144e-02f, -6.12023063e-02f, 7.44192675e-02f, 2.21585426e-02f,
  -4.04730886e-01f, 9.09403488e-02f, -4.29098755e-01f, -1.18431792e-01f, -2.99478769e-02f, 2.49615699e-01f, 2.61568874e-01f, -9.49561149e-02f, 1.30400136e-01f, -4.08302754e-01f,
  -6.16671965e-02f, -8.03754032e-02f, 2.38916382e-01f, 4.75622937e-02f, -4.51606303e-01f, -5.84235117e-02f, -6.09213233e-01f, -4.33767438e-01f, -1.26572788e-01f, -2.36578092e-01f,
  -4.30248044e-02f, -5.22881567e-01f, -9.50102985e-01f, -6.06172144e-01f, 1.26387343e-01f, -9.32366014e-01f, -3.70826572e-01f, -1.72201261e-01f, -5.46027601e-01f, -1.18042111e+00f,
  -1.71812010e+00f, 8.54909956e-01f, 5.32249391e-01f, -9.84944701e-01f, -9.62184444e-02f, 5.86305737e-01f, 1.00225723e+00f, 1.70469806e-01f, -3.42462510e-01f, 3.98004442e-01f,
  5.42127080e-02f, -5.26254296e-01f, -1.39741138e-01f, 2.33641993e-02f, 2.18855411e-01f, 8.94817472e-01f, 5.70623517e-01f, -7.13362470e-02f, -4.71854597e-01f, -2.07719222e-01f,
  7.90846068e-04f, -6.29038334e-01f, -8.16578925e-01f, -3.01023871e-01f, 1.18088216e-01f, -2.23852053e-01f, 2.95673132e-01f, -2.25177184e-01f, 3.93506199e-01f, 5.44095576e-01f,
  7.85205841e-01f, -1.67789504e-01f, -3.55979234e-01f, -4.78521109e-01f, 7.81426504e-02f, -7.81677514e-02f, 1.02234952e-01f, -2.62589544e-01f, -1.86202571e-01f, 5.57441404e-03f,
  -2.33311001e-02f, 1.46251708e-01f, -2.20396966e-01f, 1.69110641e-01f, -1.27417043e-01f, -1.62251107e-02f, -2.18866323e-03f, 2.00434551e-02f, 1.03590630e-01f, 5.52600920e-01f,
  3.81358802e-01f, -6.84473813e-02f, -1.88489780e-01f, 2.56044477e-01f, 3.68485451e-01f, -3.13027561e-01f, 2.36045480e-01f, 7.24658892e-02f, 2.33099088e-02f, 1.52251567e-03f,
  -1.84910461e-01f, -6.96623474e-02f, 4.23289873e-02f, -1.45811513e-02f, -1.10715300e-01f, 9.71054286e-03f, -1.10708224e-02f, -1.46629572e-01f, -3.36540192e-02f, -1.94709867e-01f,
  3.94691154e-03f, 7.21632242e-02f, 2.75200792e-02f, -4.39504795e-02f, -3.36208418e-02f, -8.81268159e-02f, 1.57557622e-01f, 1.03010021e-01f, -4.30927761e-02f, -5.06243668e-02f,
  -1.80568710e-01f, 7.94259161e-02f, -1.01735897e-01f, 1.37683198e-01f, 2.52591133e-01f, 2.56914068e-02f, -2.99300719e-02f, -2.46602185e-02f, -1.26524404e-01f, -3.56977731e-02f,
  -2.06710994e-01f, -2.33403429e-01f, 1.64908469e-01f, 9.29602236e-02f, 3.59038240e-03f, -1.16621293e-01f, -1.42145082e-01f, -1.79160938e-01f, -3.27887125e-02f, -3.94498259e-02f,
  5.76760657e-02f, -1.46569178e-01f, 1.16149373e-01f, 1.46905571e-01f, -2.99014449e-01f, 2.23354418e-02f, -5.54999970e-02f, -3.05142831e-02f, 1.52296379e-01f, 1.03308395e-01f,
  1.75930887e-01f, -1.90479681e-01f, -3.99988800e-01f, 5.67846671e-02f, -4.21693735e-03f, -5.23454726e-01f, 6.44866675e-02f, -1.14792772e-01f, -1.42179191e-01f, -6.60145953e-02f,
  -1.39069736e+00f, -1.30169928e-01f, -2.24772006e-01f, 1.78054944e-02f, 7.85494804e-01f, -2.33330444e-01f, -6.39287472e-01f, -1.00836909e+00f, -2.41465703e-01f, 7.01886863e-02f,
  5.36914289e-01f, 6.30848587e-01f, 2.98826247e-01f, -1.68234762e-02f, -6.68763101e-01f, 8.33419040e-02f, 4.65541810e-01f, -2.49904260e-01f, -8.28976452e-01f, -7.51002610e-01f,
  4.76568699e-01f, 9.12461802e-02f, -5.28776288e-01f, -5.40714502e-01f, 5.06013036e-01f, 6.08091891e-01f, 3.37425202e-01f, 5.38385451e-01f, 4.05334800e-01f, 8.93282950e-01f,
  3.69879544e-01f, -7.31493413e-01f, 1.63428888e-01f, 3.99287462e-01f, 6.05052888e-01f, -5.80412209e-01f, -3.09972316e-01f, -2.62943149e-01f, 9.11451690e-03f, -5.05215943e-01f,
  2.87427306e-01f, 3.54431123e-02f, 2.64891446e-01f, 2.28371665e-01f, -3.66154224e-01f, -3.47766280e-01f, -5.26170194e-01f, -1.02428865e+00f, -5.97261548e-01f, -7.46482372e-01f,
  7.63819039e-01f, 5.19505322e-01f, -3.29984367e-01f, -7.24105358e-01f, -3.10384274e-01f, 4.07146037e-01f, -3.61092806e-01f, -3.21317106e-01f, -6.82146311e-01f, -2.29106948e-01f,
  1.79542497e-01f, 1.53635353e-01f, 1.23495027e-01f, -6.83415532e-02f, -6.51328340e-02f, 1.98970571e-01f, 1.12526082e-01f, 1.26731932e-01f, -2.40946501e-01f, -6.60093129e-02f,
  -5.90546057e-02f, 1.17915794e-02f, -2.21519321e-01f, -2.48380661e-01f, 9.43046734e-02f, 2.37578988e-01f, 7.98372030e-02f, -2.20348582e-01f, -4.52245139e-02f, 1.02923490e-01f,
  -7.96335936e-02f, -2.72361428e-01f, 4.09177750e-01f, -2.49791533e-01f, 1.97315440e-01f, -1.09037496e-01f, -7.89953023e-02f, -4.60569300e-02f, -1.80609137e-01f, -2.02959910e-01f,
  1.24085374e-01f, 2.50925928e-01f, 3.73622663e-02f, -4.48740214e-01f, 1.87917307e-01f, 1.50577277e-01f, 2.42022797e-01f, 2.57799774e-02f, 9.44847986e-02f, -2.91177928e-01f,
  -2.69977421e-01f, -1.24845363e-01f, 1.51493087e-01f, 4.55549918e-03f, -4.71797921e-02f, -9.28857550e-02f, 2.49769896e-01f, 1.93388686e-01f, -2.42485017e-01f, 2.49005063e-03f,
  2.61683166e-02f, -4.54270244e-01f, -1.09317064e-01f, -1.23084031e-01f, 2.49093510e-02f, -1.12757899e-01f, 4.43613343e-02f, -6.51966259e-02f, -3.56792957e-01f, -2.93611497e-01f,
  -1.26048994e+00f, -2.44695708e-01f, -5.21410465e-01f, -5.14032781e-01f, 3.56730282e-01f, 5.63199341e-01f, 8.16253722e-01f, 5.51642478e-01f, -4.58659381e-01f, -4.80866760e-01f,
  -2.92071551e-01f, -1.90836027e-01f, -6.25088453e-01f, -7.95457512e-02f, 3.51161003e-01f, -1.09853953e-01f, -2.73507178e-01f, -1.58349514e-01f, 5.13908327e-01f, 1.03619814e+00f,
  6.69190586e-01f, 3.58142704e-01f, -4.51943502e-02f, 1.93413675e-01f, -4.73265648e-01f, -2.22360671e-01f, -3.97591829e-01f, -1.49835467e-01f, 1.18983716e-01f, -6.43107474e-01f,
  -1.02158689e+00f, -3.35731238e-01f, 4.80181754e-01f, -1.99646622e-01f, -1.27839804e-01f, -2.94269204e-01f, -2.88978182e-02f, 7.71879801e-04f, -1.53824426e-02f, -2.39370212e-01f,
  -2.32658908e-01f, -1.23678222e-02f, 3.31108943e-02f, 2.45638117e-01f, 4.51136343e-02f, -4.10921499e-03f, 1.28314734e-01f, 1.44172199e-02f, -4.48621005e-01f, -2.34926753e-02f,
  2.93763489e-01f, 5.12925051e-02f, -4.84483689e-01f, 5.00774741e-01f, 2.10037947e-01f, -2.86101788e-01f, 2.94462055e-01f, 1.77197829e-01f, 1.07961230e-01f, -9.02960122e-01f,
  9.62757766e-02f, -1.57504857e-01f, 1.18391246e-01f, -8.13841354e-03f, 2.75220703e-02f, -4.36033532e-02f, -6.59389794e-02f, -4.36355509e-02f, 3.40633392e-02f, -5.73953353e-02f,
  1.54646724e-01f, -1.59632131e-01f, -4.28279862e-02f, -1.13125607e-01f, -2.09163744e-02f, -3.93592082e-02f, 3.91711518e-02f, 5.50747812e-02f, -9.07801166e-02f, 3.68951969e-02f,
  -2.98191067e-02f, -1.43604025e-01f, -9.88384858e-02f, 3.06129679e-02f, 1.59131080e-01f, 6.41661361e-02f, -8.45168978e-02f, 1.09788671e-01f, -3.32364403e-02f, -7.72204250e-02f,
  -4.94989902e-01f, 1.01905310e+00f, -7.88397849e-01f, -2.17792466e-02f, -2.65729189e-01f, 1.25337303e-01f, -5.29644527e-02f, 4.94003147e-02f, -4.18340355e-01f, -1.82706743e-01f,
  1.27042860e-01f, -5.54156117e-02f, -2.82602578e-01f, 2.72109061e-01f, 1.41288042e-01f, -1.56340510e-01f, 6.68043345e-02f, -2.84614593e-01f, 2.22208843e-01f, -1.06503338e-01f,
  -7.26731867e-02f, -9.42949578e-02f, -5.94758153e-01f, -3.12745690e-01f, 1.12271858e-02f, -4.24695522e-01f, -4.06773835e-01f, -4.10787225e-01f, -3.41761380e-01f, -7.91956484e-01f,
  7.87026882e-01f, 2.84626305e-01f, 1.22110330e-01f, 5.79762876e-01f, 2.47273728e-01f, 1.12022817e-01f, 1.49597511e-01f, 1.30954117e-01f, 1.96378842e-01f, 2.42922947e-01f,
  1.83037192e-01f, 4.30479437e-01f, 2.47084215e-01f, 2.77375519e-01f, 2.13520020e-01f, 2.79206783e-01f, 3.01606089e-01f, 2.38183588e-01f, -1.98319107e-02f, 2.98623979e-01f,
  4.29372847e-01f, 1.85164705e-01f, 2.76858788e-02f, 1.25663117e-01f, 3.81850094e-01f, 3.27114850e-01f, 1.99050173e-01f, 1.01120465e-01f, 2.16296598e-01f, 6.59392357e-01f,
  4.99063805e-02f, 3.55297953e-01f, 1.79910697e-02f, -1.48575846e-02f, -6.39844760e-02f, -1.20476298e-01f, -6.70468388e-03f, -8.76654610e-02f, -9.97616649e-02f, -1.08413309e-01f,
  1.46949682e-02f, -9.06826332e-02f, -2.17629243e-02f, -4.57504690e-02f, -1.86341479e-01f, -1.32021889e-01f, -3.85485962e-02f, 7.90404230e-02f, 9.51524973e-02f, 4.69833724e-02f,
  2.25748226e-01f, 1.27148196e-01f, -1.67845830e-01f, -1.73692912e-01f, 7.60995969e-02f, -1.13508038e-01f, -1.80659503e-01f, 1.15717500e-01f, -1.69584215e-01f, 2.44903862e-01f,
  3.52178633e-01f, 1.28642216e-01f, 2.15256050e-01f, 1.56124607e-01f, 1.33622572e-01f, 1.69050306e-01f, -4.16434929e-02f, 4.23027202e-02f, 1.55901134e-01f, 7.99813643e-05f,
  -5.79259284e-02f, 1.29409030e-01f, 2.30677295e-04f, 7.93650150e-02f, 7.51921907e-02f, 5.15226610e-02f, -6.03581779e-02f, -5.23000062e-02f, -2.37598550e-02f, -5.08068539e-02f,
  4.88338284e-02f, -8.38625133e-02f, -2.68144310e-01f, -3.63959447e-02f, -1.42267823e-01f, -8.33862349e-02f, -1.65830962e-02f, -7.49435723e-02f, -1.91904962e-01f, -7.59212580e-03f,
  -8.24685872e-01f, -6.69865012e-02f, 3.82233918e-01f, 2.36603066e-01f, 6.79780990e-02f, -1.40866011e-01f, 2.61723995e-01f, -5.28744496e-02f, -2.27196708e-01f, -2.84128506e-02f,
  -1.71181321e-01f, -3.21058743e-02f, -3.10095623e-02f, -2.01439098e-01f, -2.74615794e-01f, -1.47313997e-01f, 9.48368944e-03f, 1.24220245e-01f, 4.27799560e-02f, -2.02386193e-02f,
  -2.06467792e-01f, -1.17243908e-01f, -2.78258592e-01f, -8.25284272e-02f, 2.85487361e-02f, -2.23611340e-01f, -3.41020316e-01f, -1.88551873e-01f, -3.53594840e-01f, -2.61626869e-01f,
  8.95741582e-01f, -1.13325703e+00f, -8.30956772e-02f, 7.78969944e-01f, 4.69491154e-01f, 3.79272282e-01f, 8.59110355e-02f, 2.98530400e-01f, 4.47707772e-01f, -1.10625857e-02f,
  -7.56377757e-01f, -5.96085966e-01f, -5.07915199e-01f, -5.52976370e-01f, -4.09191877e-01f, 2.33879089e-01f, 5.72959900e-01f, 3.13317835e-01f, 3.84012103e-01f, 1.82070047e-01f,
  3.33900005e-02f, 3.78510356e-01f, 1.94373831e-01f, 1.81513280e-01f, -1.39423817e-01f, 9.12544429e-02f, -3.02384663e-02f, -3.47023487e-01f, -6.45913661e-01f, -3.42149913e-01f,
  -2.41040260e-01f, -6.91574514e-01f, 3.51544440e-01f, -1.42797530e-01f, -2.60282427e-01f, 2.17424985e-02f, 1.09540306e-01f, -1.70052331e-02f, -1.19041167e-01f, 1.81922793e-01f,
  -1.74921572e-01f, -1.08473383e-01f, -1.20520644e-01f, -1.31482221e-02f, 1.71183884e-01f, 1.63463011e-01f, -9.84903052e-02f, -8.87744948e-02f, -2.09307835e-01f, -3.20002377e-01f,
  -5.18403530e-01f, -2.11888716e-01f, 2.01340881e-03f, -8.51557553e-02f, -3.25959921e-01f, -1.99359450e-02f, -2.63011932e-01f, -3.11819196e-01f, -6.18047900e-02f, 8.35258588e-02f,
  7.99088255e-02f, -1.57385513e-01f, -7.99323395e-02f, -2.75696442e-02f, 3.93897034e-02f, 9.51412469e-02f, 7.93050751e-02f, -6.02606032e-03f, -7.97902793e-03f, 2.10051425e-02f,
  -4.88782637e-02f, -1.24910660e-01f, -5.58955781e-02f, 3.82807627e-02f, 2.15842668e-02f, 1.38834985e-02f, -1.95036922e-03f, -1.21083207e-01f, -7.28372857e-02f, 5.01736961e-02f,
  -1.29573584e-01f, 4.56184261e-02f, 3.07186078e-02f, -1.04468301e-01f, -1.87502578e-01f, -5.58342598e-02f, 4.73956689e-02f, -5.70284612e-02f, 5.39048342e-03f, 1.04019694e-01f,
  5.01437366e-01f, -1.07484855e-01f, 1.85427994e-01f, -1.34274304e-01f, -9.45186988e-02f, -2.35916257e-01f, -1.49468288e-01f, -5.21719418e-02f, -7.79811069e-02f, 1.11795515e-02f,
  -3.16962332e-01f, -1.41180130e-02f, -1.80396214e-01f, 4.22719978e-02f, 3.78943443e-01f, 1.26326278e-01f, -1.66859210e-01f, 3.24348845e-02f, -1.05626799e-01f, -3.22147720e-02f,
  -9.03039351e-02f, 2.28168905e-01f, 2.75450081e-01f, 1.70520440e-01f, -4.06182930e-02f, 3.66962194e-01f, 1.45747930e-01f, 1.89161301e-01f, 2.59274840e-01f, 6.93695724e-01f,
  1.20823753e+00f, 5.08532166e-01f, -2.22738886e+00f, 4.34240043e-01f, -9.01436508e-01f, -1.05297577e+00f, -6.59198046e-01f, 3.37009877e-01f, 9.07688677e-01f, 4.96955752e-01f,
  3.90240669e-01f, -1.35136873e-01f, -4.23151404e-01f, -7.40378380e-01f, -7.31538594e-01f, -3.40918690e-01f, -6.33326471e-01f, -1.63197362e+00f, -1.85941672e+00f, -7.86100090e-01f,
  -1.93566114e-01f, -4.93843794e-01f, -3.56747895e-01f, -2.29516178e-01f, -1.51743844e-01f, -7.84750640e-01f, -6.29476845e-01f, -9.32447731e-01f, -9.58471239e-01f, -1.07887983e+00f,
  -1.25140035e+00f, -1.03054099e-01f, -3.71402025e-01f, 2.37296730e-01f, -2.03769892e-01f, 5.06570578e-01f, -5.45755848e-02f, 4.39742878e-02f, 3.85406584e-01f, -8.15399084e-03f,
  -1.09962426e-01f, 2.43631229e-01f, 7.22572654e-02f, -3.53673786e-01f, -2.65730709e-01f, -3.18856806e-01f, -4.95413281e-02f, -2.55444914e-01f, -3.00010443e-01f, 1.65920004e-01f,
  2.50376552e-01f, -5.42615652e-01f, -6.56150162e-01f, 1.29353687e-01f, -3.02368045e-01f, -3.50085199e-01f, -2.30209351e-01f, -3.14414054e-01f, -7.48670876e-01f, -1.90231383e-01f,
  1.45232543e-01f, 3.48563120e-02f, -1.35305941e-01f, 5.09463064e-02f, 1.76611453e-01f, 1.71821248e-02f, 4.05370407e-02f, 3.50776464e-02f, -4.92482372e-02f, -2.33088642e-01f,
  -1.19214304e-01f, 1.69433117e-01f, -8.05889890e-02f, 6.49449751e-02f, -1.26494765e-01f, 2.89180633e-02f, 1.27716646e-01f, 1.67768240e-01f, -9.44875181e-02f, 6.13400750e-02f,
  -2.33809978e-01f, -8.29930604e-02f, -8.12471360e-02f, -7.50327436e-03f, 8.64457747e-04f, -9.67456624e-02f, -4.55761701e-02f, 4.19784307e-01f, -9.74458642e-03f, 5.05691618e-02f,
  6.24609515e-02f, 2.70721525e-01f, 5.41806459e-01f, 5.55300480e-03f, -2.75087748e-02f, 3.80886346e-02f, 1.09812491e-01f, 2.83744484e-01f, 3.25898081e-01f, -3.48867513e-02f,
  -1.74866706e-01f, 1.45733431e-01f, -1.09537505e-01f, 2.09263533e-01f, -2.98959255e-01f, -2.61275321e-01f, 4.93295878e-01f, -1.59019113e-01f, -1.57806352e-01f, 3.50167602e-01f,
  3.15886527e-01f, -1.18511073e-01f, -8.73719454e-02f, 3.18198167e-02f, -3.37886326e-02f, -1.79450840e-01f, -2.24787652e-01f, -2.15450287e-01f, -2.59458214e-01f, 3.31628829e-01f,
  7.94655442e-01f, -7.46395588e-01f, -1.73089892e-01f, 5.48899591e-01f, -5.04034877e-01f, -8.49296391e-01f, -1.68713903e+00f, -4.12264794e-01f, 5.87008893e-01f, -5.35558999e-01f,
  -2.37730682e-01f, 6.70107424e-01f, 1.02472054e-02f, 1.55092999e-01f, -4.13103312e-01f, -1.03079271e+00f, -4.73920405e-01f, 3.29875737e-01f, 4.27068502e-01f, 3.91266525e-01f,
  1.26057997e-01f, 5.74952722e-01f, 8.48335624e-01f, 4.32602167e-01f, 4.05057341e-01f, 2.05074787e-01f, -2.15860575e-01f, 1.32518038e-01f, -5.23034692e-01f, 3.49634081e-01f,
  3.54481608e-01f, 1.01336695e-01f, -1.06017329e-01f, 2.70440966e-01f, 2.36742422e-01f, 1.41326234e-01f, 8.93385187e-02f, 3.24642122e-01f, -1.82119831e-02f, -1.87924430e-01f,
  2.83676386e-01f, 3.19318980e-01f, 6.90272525e-02f, 2.03575179e-01f, 1.60691589e-01f, 3.80679220e-02f, 3.28445524e-01f, 1.49060741e-01f, -6.43019080e-02f, 7.31398687e-02f,
  -6.09242320e-02f, -1.29522935e-01f, -2.53512800e-01f, -3.86778891e-01f, -1.41493231e-01f, 2.07086548e-01f, -1.18675821e-01f, 4.53500688e-01f, -2.06508353e-01f, 1.15149366e-02f,
  -5.80438636e-02f, -1.56941965e-01f, 5.19002695e-03f, -2.52862517e-02f, -2.14677081e-01f, -9.28726494e-02f, -1.06019758e-01f, -3.57140720e-01f, -3.19317877e-02f, -1.67510454e-02f,
  -6.27719462e-02f, -1.99445024e-01f, 3.78135853e-02f, -7.39170611e-02f, 1.28857046e-01f, 1.21836826e-01f, 3.56407389e-02f, -2.74665561e-02f, -9.20901746e-02f, 3.54692936e-02f,
  2.91060768e-02f, -1.42558619e-01f, 4.81914245e-02f, 2.29736622e-02f, 7.34214038e-02f, 1.33155063e-01f, 2.32704028e-01f, 2.85313791e-03f, 1.70671374e-01f, -3.01586017e-02f,
  1.27194569e-01f, -6.11556709e-01f, -2.60020904e-02f, 1.88857704e-01f, -1.90813765e-01f, 2.77578294e-01f, 9.55832079e-02f, 4.52051051e-02f, 9.48407315e-03f, 5.80831654e-02f,
  1.00176990e-01f, 8.29699785e-02f, -2.31492639e-01f, 1.40889019e-01f, -5.89475110e-02f, 7.35337064e-02f, -9.75877196e-02f, -2.81152219e-01f, -1.59910500e-01f, 2.81086475e-01f,
  3.22335251e-02f, -6.65516734e-01f, -6.17710173e-01f, -4.84342903e-01f, 4.63770516e-02f, -2.09574461e-01f, -4.45038021e-01f, -2.84581214e-01f, -8.49518359e-01f, -1.17007518e+00f,
  1.41556370e+00f, 7.17967391e-01f, 1.55506998e-01f, 5.26367307e-01f, 5.81994116e-01f, 3.78815025e-01f, 6.07153535e-01f, 2.32589431e-02f, -3.44876796e-01f, 3.60690236e-01f,
  5.83791018e-01f, -1.25890359e-01f, -3.06069225e-01f, -4.56794709e-01f, -1.49270013e-01f, -3.28492075e-01f, -5.82819641e-01f, -3.77888352e-01f, -3.10571313e-01f, 9.45589095e-02f,
  1.39834866e-01f, 7.44188070e-01f, 6.18030667e-01f, 7.44568110e-02f, 1.03187107e-01f, -2.15478957e-01f, 3.73684824e-01f, 5.04515469e-01f, 4.27950203e-01f, -3.82494807e-01f,
  -3.52610573e-02f, 7.27727115e-01f, -6.84631169e-01f, 3.53509141e-03f, 2.43094519e-01f, -1.35533080e-01f, 2.72049252e-02f, -5.71314394e-02f, 1.29908407e-02f, -1.61515608e-01f,
  3.82689983e-02f, 6.25799596e-02f, 1.73509642e-01f, -1.33914901e-02f, 2.61364907e-01f, 9.74248946e-02f, -1.88375600e-02f, -6.65966198e-02f, -1.72419026e-01f, 4.69501540e-02f,
  -1.49461245e-02f, 5.24037123e-01f, 3.86155397e-01f, -1.69139072e-01f, -1.20393522e-01f, -7.77671561e-02f, 2.63694167e-01f, 2.53102910e-02f, -2.00786013e-02f, -2.46787667e-01f,
  -2.47103393e-01f, 4.16646041e-02f, 1.88985407e-01f, 7.04400381e-03f, 2.93191433e-01f, -1.46354005e-01f, -1.33853272e-01f, -5.08178435e-02f, -3.76120917e-02f, 1.54552907e-01f,
  -2.11882934e-01f, -8.48641768e-02f, -2.07270697e-01f, 2.38363698e-01f, -7.08305612e-02f, 2.10639283e-01f, 6.12759255e-02f, 3.30805853e-02f, 1.98974282e-01f, 7.77075365e-02f,
  9.64183137e-02f, -1.49276063e-01f, 1.04546040e-01f, -1.05157763e-01f, -6.13764003e-02f, -2.71149911e-02f, -3.33483629e-02f, 2.75194168e-01f, 1.88315809e-01f, 2.05272600e-01f,
  4.37775850e-02f, 3.35995972e-01f, -1.71480775e-01f, -3.20429355e-01f, 1.11929670e-01f, -1.51142172e-04f, 2.13146687e-01f, -1.57698423e-01f, 9.48126912e-02f, -1.02765411e-01f,
  1.39452770e-01f, -3.02565604e-01f, 2.08150521e-01f, -1.19980844e-02f, -6.60180226e-02f, -1.24065600e-01f, 6.57651052e-02f, -2.12344974e-01f, -2.67058432e-01f, -2.11264297e-01f,
  -1.38507381e-01f, -3.18369299e-01f, -2.77895004e-01f, -4.62080300e-01f, -3.06998760e-01f, -2.87172943e-01f, -1.65831596e-01f, -2.99568892e-01f, -2.19880909e-01f, -3.26745331e-01f,
  -5.27837947e-02f, -9.43911791e-01f, 6.56659782e-01f, -9.74532068e-01f, -6.30568445e-01f, -3.37591052e-01f, -5.74438870e-01f, -3.67821544e-01f, -5.23751020e-01f, -5.72446764e-01f,
  2.36480579e-01f, 9.63053405e-01f, 1.05332053e+00f, 8.91346037e-01f, 9.07892883e-01f, -6.44550860e-01f, -6.89150274e-01f, 8.02514076e-01f, 1.08845699e+00f, -2.13754904e-02f,
  -2.04156011e-01f, -4.90603387e-01f, 2.71600019e-02f, -6.89034024e-03f, -9.49313104e-01f, 2.74194151e-01f, -2.77476579e-01f, -3.51538748e-01f, -8.16268548e-02f, -7.27585912e-01f,
  4.86636251e-01f, -1.81367382e-01f, 4.15282875e-01f, -1.34475425e-01f, -5.40420115e-02f, 2.38943361e-02f, 8.82422701e-02f, 5.71497306e-02f, -5.28581515e-02f, -1.63349330e-01f,
  -7.55491480e-03f, 7.12955184e-03f, -4.46433872e-02f, 5.38404696e-02f, -1.24862827e-01f, -1.09376227e-02f, -2.88040429e-01f, -6.91236556e-02f, -7.74103403e-02f, -8.66094381e-02f,
  -1.35416508e-01f, -3.81192341e-02f, 5.07290810e-02f, 2.62162153e-04f, -3.75312455e-02f, 2.82693624e-01f, -4.91657667e-02f, 6.68551549e-02f, 9.13792849e-02f, -3.48158747e-01f,
  -2.11997591e-02f, 1.00818105e-01f, -8.20809801e-04f, -9.24149342e-03f, -6.68632388e-02f, 1.45295888e-01f, -5.47160627e-03f, -4.19131145e-02f, 1.05740756e-01f, 8.36387128e-02f,
  -1.39862195e-01f, 8.20324849e-03f, 7.02741146e-02f, -1.99094415e-01f, -6.48089200e-02f, -4.34237793e-02f, 5.76948337e-02f, -6.09535277e-02f, 9.85817015e-02f, -2.03235149e-01f,
  9.94579196e-02f, 2.17878073e-02f, 6.14483096e-02f, 1.82663813e-01f, -1.72337040e-01f, 1.02122381e-01f, -8.76681656e-02f, -3.78829148e-03f, -8.31512734e-02f, -7.10783601e-02f,
  -3.86114903e-02f, 6.24201298e-01f, 1.11571170e-01f, 1.76609635e-01f, -2.71582544e-01f, -1.53549254e-01f, 3.46000562e-03f, -8.55080560e-02f, -1.31897822e-01f, -1.38280481e-01f,
  9.57941860e-02f, 1.64057501e-02f, 1.81012284e-02f, -5.04395403e-02f, 3.27110142e-02f, 6.41956553e-02f, -2.22733021e-01f, 1.41737804e-01f, -1.37710273e-01f, -2.84713030e-01f,
  -3.52255762e-01f, 5.70791308e-04f, 2.92496204e-01f, 1.15506500e-01f, -1.72649145e-01f, 3.74057710e-01f, 2.01291963e-01f, 1.61220461e-01f, 3.21976632e-01f, -4.83692318e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  8.98742497e-01f, 1.55424190e+00f, 8.41041625e-01f, 8.21235776e-01f, 4.03621912e-01f, 1.62707043e+00f, 1.73895121e+00f, 1.17686772e+00f, 1.31902325e+00f, 1.00446618e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.01223028e-01f, 1.65113304e-02f, -1.55426919e-01f, 2.81874597e-01f, -6.70182481e-02f, 6.20113730e-01f, -1.11517930e+00f, -1.59219980e+00f, -9.54762876e-01f, 1.53654575e+00f,
  -1.42527497e+00f, -7.61373520e-01f, 2.83416361e-01f, 6.38361156e-01f, -1.26003754e+00f, -1.85942277e-01f, 5.46496034e-01f, 4.19380695e-01f, 6.57138675e-02f, 6.10190690e-01f,
  7.16271043e-01f, -5.02802789e-01f, -1.39085186e+00f, -1.35531139e+00f, -1.96158504e+00f, -1.06558108e+00f, 4.61107999e-01f, -3.72076571e-01f, 1.37624308e-01f, -2.98248678e-01f,
  2.81838357e-01f, 1.47876954e+00f, 2.30556861e-01f, 1.83323085e-01f, 4.20065016e-01f, -6.99261189e-01f, 7.47910917e-01f, 3.15523982e-01f, 9.25746918e-01f, -8.48343670e-01f,
  -2.85326445e-04f, 8.99924695e-01f, -1.11670947e+00f, -2.79158711e-01f, -1.44706476e+00f, 7.75125206e-01f, -1.55446208e+00f, 4.55886483e-01f, -3.75432283e-01f, 5.15724830e-02f,
  -7.53965139e-01f, 4.67439681e-01f, -6.74960539e-02f, 5.51950812e-01f, -8.25646743e-02f, 1.06205118e+00f, 1.10945016e-01f, 1.01057231e+00f, -1.77678227e+00f, -1.58138299e+00f,
  8.65802318e-02f, -2.13270473e+00f, -1.61649394e+00f, -4.06760007e-01f, 1.52077198e-01f, -2.99039513e-01f, -1.76283531e-02f, 4.76781607e-01f, -2.08480030e-01f, 1.00339735e+00f,
  1.17815340e+00f, 3.88524055e-01f, 1.45982757e-01f, -1.30132675e+00f, 3.39263201e-01f, -1.46863031e+00f, 3.37302804e-01f, -8.79880190e-02f, -1.33743501e+00f, -8.56401861e-01f,
  6.42018318e-01f, 2.36270651e-01f, 1.87514678e-01f, -9.00087431e-02f, -8.06467950e-01f, -7.20603764e-01f, -2.24393296e+00f, -1.24780357e+00f, -9.13802162e-02f, -4.14918542e-01f,
  -2.79090643e-01f, 4.44745570e-01f, 7.21922338e-01f, -3.31394732e-01f, 4.14318502e-01f, -1.66471505e+00f, -8.14731240e-01f, 3.91596228e-01f, -5.86263418e-01f, -4.33968008e-01f,
  3.33824933e-01f, -5.33009350e-01f, 1.03620553e+00f, 1.15893424e-01f, -1.33106434e+00f, -1.75938344e+00f, 2.06220344e-01f, -5.96910298e-01f, -1.80178416e+00f, 7.32944727e-01f,
  -3.12733918e-01f, -6.25673532e-01f, -2.61414289e-01f, -1.63836583e-01f, -2.32822597e-01f, -3.78019273e-01f, -2.10394487e-02f, 9.93048698e-02f, -1.20382583e+00f, 8.71655643e-01f,
  6.97461784e-01f, 6.81901991e-01f, 4.18358028e-01f, -2.13207841e-01f, -1.48083675e+00f, -1.56853592e+00f, -9.19433713e-01f, -1.11460996e+00f, 5.86133450e-02f, -1.96865201e-01f,
  4.50723469e-01f, -4.17419104e-03f, 5.68259060e-01f, 2.79496282e-01f, -4.44149345e-01f, -3.49889070e-01f, -1.92016289e-01f, -3.64170432e-01f, -1.34360477e-01f, 1.74823201e+00f,
  -1.55165029e+00f, -1.50816345e+00f, -5.47375619e-01f, -6.68466866e-01f, 5.37408352e-01f, 2.58315027e-01f, 1.08970493e-01f, -3.22381794e-01f, -3.87045354e-01f, -4.29126531e-01f,
  -2.54751354e-01f, -1.04822230e+00f, 1.41955686e+00f, -1.34709549e+00f, -2.03863695e-01f, -1.58330107e+00f, -3.43087971e-01f, 8.23320210e-01f, 4.08970676e-02f, -1.47551668e+00f,
  -7.25957751e-01f, -1.87318474e-01f, 4.04942423e-01f, 3.53540599e-01f, -8.01011682e-01f, -4.99840409e-01f, -9.56479609e-01f, 7.33307779e-01f, 5.69219828e-01f, -1.31145525e+00f,
  -1.00942802e+00f, -2.42408767e-01f, -9.36106801e-01f, -1.27704442e+00f, -1.41544986e+00f, 1.63972831e+00f, -3.73406075e-02f, 6.05388954e-02f, 1.96987167e-01f, -4.94244039e-01f,
  4.47971791e-01f, 3.18500966e-01f, 3.99027288e-01f, 3.69082451e-01f, -1.00086164e+00f, 6.92020431e-02f, -6.72460377e-01f, -1.24465704e+00f, -5.27961612e-01f, -1.31514013e+00f,
  1.39454734e+00f, -2.17448995e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.39233787e-03f, 3.95831764e-01f, 2.13146627e-01f, -6.81377172e-01f, 8.84790421e-02f, 7.20118225e-01f, -2.11441636e-01f, -2.42775962e-01f, -1.68547243e-01f, -3.92152071e-01f,
  -4.88040537e-01f, -5.62821090e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    