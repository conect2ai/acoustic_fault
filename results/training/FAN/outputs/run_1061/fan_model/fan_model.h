/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.11730814e-01f, 1.95723191e-01f, -2.88910508e-01f, 5.60024157e-02f, -3.18622231e-01f, -9.52848718e-02f, -1.02056526e-01f, 1.51502877e-01f, 1.19634032e-01f, 1.06950291e-01f,
  1.03913687e-01f, 2.46020615e-01f, 1.82835773e-01f, 1.98412240e-01f, 2.39361957e-01f, -7.64619261e-02f, -2.79567987e-01f, -1.23089157e-01f, -2.55106632e-02f, 1.05515428e-01f,
  5.34776039e-03f, 1.13507092e-01f, 6.74978867e-02f, 1.04495138e-01f, -2.28733327e-02f, -6.90547302e-02f, -7.97043666e-02f, -1.19127303e-01f, -9.82757136e-02f, -1.00097746e-01f,
  1.15067244e-01f, 2.78302431e-01f, 5.77193499e-02f, 9.76263136e-02f, -5.30986525e-02f, 1.39585957e-01f, 1.43111736e-01f, 1.54078588e-01f, 1.01361729e-01f, -5.09158857e-02f,
  3.40886996e-03f, 1.13820642e-01f, 6.71960339e-02f, 1.44143462e-01f, 1.16422199e-01f, 1.37285367e-01f, 1.17160797e-01f, 2.41410546e-02f, -9.98780318e-03f, 8.69112983e-02f,
  -1.49723468e-02f, -8.83749686e-03f, 3.48208360e-02f, -2.23328862e-02f, 2.07305867e-02f, 1.09297290e-01f, 8.22217464e-02f, 8.75461288e-03f, 5.17156124e-02f, 1.97192892e-01f,
  3.34277228e-02f, 2.93341391e-02f, -8.61611888e-02f, 6.51696920e-02f, 7.34644011e-02f, -3.01467478e-02f, -4.47725430e-02f, -5.61433211e-02f, 8.11635181e-02f, -2.59963572e-02f,
  9.10488237e-03f, -1.16831839e-01f, 7.47834938e-03f, 6.81059435e-02f, 1.87051222e-02f, 1.67510062e-02f, -3.99912000e-02f, -3.30834351e-02f, -1.60312455e-03f, -6.35472015e-02f,
  -5.16126454e-02f, -8.79137367e-02f, -2.28285175e-02f, -1.00027151e-01f, -1.29597192e-03f, -9.52409953e-02f, 6.23359196e-02f, 2.03027599e-03f, 2.43204017e-03f, 3.30542517e-03f,
  2.31066614e-01f, -7.35486532e-03f, 3.33520062e-02f, 7.30379671e-02f, 7.26321666e-03f, 3.86954173e-02f, -1.70494523e-02f, -9.95552354e-03f, -3.90078351e-02f, 1.00684285e-01f,
  9.58890945e-04f, 1.70178324e-01f, 2.93491017e-02f, 1.97831020e-02f, -9.24233645e-02f, 3.30800004e-02f, 5.96842542e-02f, 1.24889472e-02f, -5.60609549e-02f, -5.19507937e-03f,
  7.30102435e-02f, 4.93315086e-02f, 4.13749600e-03f, -3.66498157e-02f, 5.88317635e-03f, -3.29989158e-02f, -1.76149432e-03f, 1.92799754e-02f, -2.37893742e-02f, 1.52820036e-01f,
  -3.64918619e-01f, 2.02806637e-01f, 1.57935649e-01f, -1.29900454e-02f, 7.84369558e-02f, 2.39598416e-02f, 1.99790925e-01f, -1.00053333e-01f, -1.05250619e-01f, 2.30986029e-02f,
  1.11019261e-01f, 1.02313403e-02f, 4.49384972e-02f, -4.38785516e-02f, -1.98868178e-02f, 1.14290558e-01f, 1.95904091e-01f, -3.39963520e-03f, -6.14836738e-02f, -1.62562311e-01f,
  -8.68582875e-02f, -1.30211070e-01f, -1.72836438e-01f, 4.18892875e-03f, 1.62585109e-01f, 1.53343692e-01f, 1.48676321e-01f, 8.88336077e-02f, 1.94312066e-01f, 2.50584155e-01f,
  2.57445782e-01f, -3.17825633e-03f, -4.62221466e-02f, -7.41173849e-02f, 7.29422718e-02f, -8.15790296e-02f, 2.71430295e-02f, -1.03566349e-01f, -8.24550614e-02f, 7.98335671e-03f,
  3.93235125e-03f, 3.84812765e-02f, -2.14062203e-02f, -1.24320146e-02f, -3.94658223e-02f, -2.86777355e-02f, -1.07786600e-02f, -5.57961240e-02f, -5.29453196e-02f, 3.64341028e-02f,
  -3.06376227e-04f, 5.65922484e-02f, 1.45573122e-02f, 1.03400402e-01f, 7.26661040e-03f, -2.46553682e-02f, 8.33533108e-02f, 3.80530469e-02f, 1.25764340e-01f, 7.98685700e-02f,
  -1.64571982e-02f, 6.00720309e-02f, -6.96298480e-02f, -6.51726574e-02f, 5.82163893e-02f, 6.45303130e-02f, 5.72670624e-02f, 9.76356938e-02f, -5.32518253e-02f, 6.51272759e-02f,
  5.37628457e-02f, -1.03304842e-02f, 5.29112220e-02f, 3.41243632e-02f, 4.58174422e-02f, 4.60796393e-02f, 2.90459450e-02f, -6.46983087e-03f, 1.52874906e-02f, 2.39749793e-02f,
  -7.56522920e-03f, 6.03182800e-02f, 1.51839992e-03f, 2.99217831e-02f, 1.28932884e-02f, 7.40307197e-02f, -4.72961366e-02f, -1.03531644e-01f, -8.78078714e-02f, 6.13930076e-02f,
  -5.15569188e-02f, -1.30894870e-01f, 1.07824072e-01f, -2.75871009e-02f, -1.98798683e-02f, 3.44718806e-02f, -5.32011576e-02f, 2.03727670e-02f, 9.99693107e-03f, 4.94321473e-02f,
  -5.22528216e-02f, -7.89134800e-02f, 4.54717688e-02f, 1.60437245e-02f, -4.82806787e-02f, 1.31006995e-02f, -5.77270910e-02f, 3.62809226e-02f, 3.22576053e-03f, 2.30510626e-02f,
  6.13938235e-02f, 1.09844141e-01f, -7.61787668e-02f, -4.04199436e-02f, 6.41547069e-02f, -1.50025729e-02f, 1.27711490e-01f, -3.00537422e-02f, 7.72711411e-02f, 3.29869576e-02f,
  4.07931022e-02f, 1.11731000e-01f, -1.27566189e-01f, 8.65481421e-02f, -3.38321403e-02f, -2.25811452e-01f, -2.08653912e-01f, -3.72456796e-02f, 1.94037855e-01f, 1.55888900e-01f,
  -1.58143461e-01f, -9.83783677e-02f, -1.24754429e-01f, -1.41950518e-01f, -1.59990579e-01f, 4.05868515e-02f, 6.49063587e-02f, -2.19483644e-01f, -2.57698119e-01f, 7.17245936e-02f,
  8.50914940e-02f, 1.02544911e-01f, 2.50095669e-02f, 1.19868524e-01f, 1.99379861e-01f, 1.06783397e-01f, 1.23545546e-02f, 1.23404860e-01f, -1.53731380e-03f, 3.05321276e-01f,
  7.27235898e-02f, 1.15274787e-01f, -6.18595146e-02f, 5.31009138e-02f, 4.54856828e-02f, 1.71963558e-01f, 1.55326407e-02f, 6.95172995e-02f, -3.37254852e-02f, 1.95566580e-01f,
  4.14060839e-02f, 1.25669613e-01f, 5.47397844e-02f, 1.89194307e-01f, 1.47548104e-02f, 1.11395665e-01f, 5.66410013e-02f, 6.93172291e-02f, 5.62208071e-02f, 1.79146126e-01f,
  1.34572640e-01f, 1.32948995e-01f, -1.18206657e-01f, 6.57919347e-02f, 3.90919074e-02f, -9.00936872e-02f, 1.07068613e-01f, 1.00524500e-01f, -1.04954913e-02f, 2.91531086e-01f,
  1.24538340e-01f, -1.62826721e-02f, -1.77102908e-02f, 2.16288380e-02f, -1.02884695e-01f, 2.03527790e-02f, -1.03636332e-01f, -7.61549994e-02f, -6.45283833e-02f, 1.53311593e-02f,
  -7.76809305e-02f, -2.48183869e-02f, -4.03716229e-02f, 9.94806457e-03f, -8.69971961e-02f, -3.18454020e-02f, -1.36306420e-01f, -2.36924030e-02f, -1.06418744e-01f, 2.03804206e-02f,
  -9.00817737e-02f, -9.93452594e-02f, 2.69883801e-03f, -2.00689118e-02f, -6.80710524e-02f, -7.58000165e-02f, -2.43260860e-02f, -8.25490355e-02f, -3.98353525e-02f, 1.13095246e-01f,
  2.03509424e-02f, -2.43417591e-01f, 1.25487328e-01f, 8.80952850e-02f, 9.81158987e-02f, 5.54807968e-02f, 1.02060616e-01f, 6.65492639e-02f, -3.09461784e-02f, 8.86764750e-02f,
  -2.44746935e-02f, 1.65511034e-02f, 4.69933152e-02f, 2.08176002e-02f, 1.00523897e-01f, 1.12869598e-01f, 8.22682008e-02f, -6.21315390e-02f, 3.74199562e-02f, 1.24850541e-01f,
  7.71612599e-02f, -3.70181277e-02f, -1.00819319e-01f, -9.23128724e-02f, -1.35204466e-02f, -1.36927202e-01f, -3.63284908e-02f, 3.19294035e-02f, -3.64530869e-02f, -4.06078674e-04f,
  5.00258282e-02f, 3.13216895e-01f, 7.06781074e-02f, 3.05427969e-01f, 2.60413200e-01f, 2.16403008e-01f, 1.46506190e-01f, 4.61534336e-02f, 5.09664230e-02f, 2.87972152e-01f,
  1.06646135e-01f, 7.52696097e-02f, 2.25697905e-01f, 1.40361562e-01f, -4.34117056e-02f, 1.98794723e-01f, 1.51110038e-01f, -7.37645850e-02f, -1.04681157e-01f, 4.51697148e-02f,
  2.07366511e-01f, 1.04341514e-01f, -4.96114753e-02f, -3.67745608e-02f, 9.47989747e-02f, 4.59275395e-02f, 1.46777004e-01f, 6.76651597e-02f, -2.19294578e-02f, 2.14416146e-01f,
  4.06591929e-02f, 8.85256827e-02f, 7.49649629e-02f, 1.30170714e-02f, 9.87853110e-03f, 8.58858973e-02f, 1.59568563e-01f, 3.29452679e-02f, 8.32944885e-02f, 1.35595515e-01f,
  3.39300781e-02f, 8.24143887e-02f, 6.68470860e-02f, 6.60953000e-02f, 5.12964390e-02f, 2.09439229e-02f, -4.22699861e-02f, 1.57442912e-02f, -1.78380962e-02f, 1.65120289e-01f,
  1.78570375e-01f, 3.20469402e-02f, -3.14594321e-02f, -4.36152099e-03f, 2.76773311e-02f, 7.23139420e-02f, 6.21772930e-02f, 2.57527102e-02f, -6.69892877e-03f, -2.73030549e-02f,
  -5.88391088e-02f, -1.38737068e-01f, -2.51354128e-02f, -1.18425459e-01f, -7.49569805e-03f, 7.75970444e-02f, -2.74922401e-02f, -3.34631391e-02f, -5.31088188e-02f, -1.50916411e-03f,
  -8.09167996e-02f, 1.02074053e-02f, -8.60520005e-02f, -4.49318923e-02f, -1.24032274e-02f, -1.04961671e-01f, -2.66170297e-02f, 1.97299086e-02f, -1.10253908e-01f, -5.07686436e-02f,
  8.98057222e-03f, -7.85651579e-02f, -9.56262369e-03f, -1.75404083e-02f, -6.99165612e-02f, -3.09235882e-03f, 1.87984835e-02f, -9.33597237e-02f, 4.35711928e-02f, -5.23484647e-02f,
  4.92908284e-02f, 6.34809062e-02f, 2.75208235e-01f, 8.98369998e-02f, 1.18326038e-01f, 1.16126858e-01f, 1.06486596e-01f, 1.16456270e-01f, 1.17776282e-01f, 1.53102815e-01f,
  1.45993412e-01f, 8.74066278e-02f, 9.81755182e-02f, 6.65384019e-03f, 1.26505315e-01f, 1.78039566e-01f, 1.54222056e-01f, 1.29543811e-01f, 6.47503287e-02f, 1.45520061e-01f,
  2.42632896e-01f, 8.75165910e-02f, 4.27309051e-02f, 5.20503409e-02f, 3.25530656e-02f, 2.03672275e-01f, 1.46945402e-01f, 3.46904472e-02f, -2.98612006e-02f, 8.64008069e-02f,
  -3.58034492e-01f, -2.66388565e-01f, 5.37102036e-02f, 2.23476186e-01f, 3.14538836e-01f, 5.94531782e-02f, -1.64188758e-01f, -1.38030246e-01f, 5.11861406e-02f, -6.61824793e-02f,
  -2.83650272e-02f, 2.51238883e-01f, 4.73312251e-02f, -3.63106467e-02f, -2.94438303e-01f, -1.08070709e-01f, -4.38541658e-02f, 8.70708153e-02f, 1.85468018e-01f, 1.83708578e-01f,
  3.05639774e-01f, 1.49927229e-01f, 1.42920227e-03f, -3.53615358e-02f, 2.55574524e-01f, 2.52099514e-01f, -4.92719151e-02f, 8.04787055e-02f, 8.29096884e-02f, 1.63544640e-01f,
  1.31220549e-01f, -2.36411154e-01f, 1.35077924e-01f, -2.39892621e-02f, 1.35704845e-01f, -9.01761055e-02f, 2.56016571e-02f, -4.96742316e-02f, 4.97686751e-02f, -5.14922589e-02f,
  9.77227390e-02f, 7.29430839e-02f, 1.67759374e-01f, 8.39609057e-02f, 7.49368370e-02f, 1.03179805e-01f, -9.13873985e-02f, -8.75355154e-02f, -1.13609441e-01f, -7.90301338e-02f,
  1.44445688e-01f, 1.47951424e-01f, -5.96693084e-02f, -1.23155294e-02f, -1.33151561e-01f, 3.99219282e-02f, -5.39215654e-02f, -6.09419048e-02f, -1.21549740e-01f, -1.09465411e-02f,
  -5.13580702e-02f, -6.59986073e-03f, -9.62710381e-03f, -1.11523084e-01f, -1.52202570e-04f, -5.42620048e-02f, -1.81410760e-02f, 5.65597527e-02f, 5.82580604e-02f, 8.00841395e-03f,
  -4.37203646e-02f, -1.02195211e-01f, -3.66086699e-02f, -1.24677848e-02f, 8.72202143e-02f, -1.07892640e-02f, 2.55518649e-02f, 1.03519680e-02f, 7.18197376e-02f, -6.57364279e-02f,
  -4.81754057e-02f, -2.44512502e-02f, 1.04576789e-01f, -1.08736292e-01f, -1.08768679e-01f, -4.02466916e-02f, 5.51719144e-02f, 6.27292693e-02f, -3.78146879e-02f, 7.10386410e-02f,
  1.27759233e-01f, -1.75968915e-01f, -2.92189047e-02f, 4.01977822e-03f, 3.51847857e-02f, -7.22582191e-02f, 1.35505721e-01f, 3.09653096e-02f, 7.27964938e-02f, 1.18724152e-01f,
  2.68286616e-02f, 1.45637039e-02f, 8.17158818e-02f, 4.52704132e-02f, 1.79042786e-01f, 9.60201249e-02f, -1.69683527e-02f, 3.18692066e-02f, -4.07235585e-02f, 5.29058352e-02f,
  1.46316281e-02f, -6.61743879e-02f, 8.26893151e-02f, 9.33659002e-02f, 4.45364751e-02f, 1.70105726e-01f, 1.71940237e-01f, 8.94713327e-02f, 3.82656083e-02f, -5.68993315e-02f,
  -3.44810337e-02f, 1.63095504e-01f, 3.12550515e-01f, 2.80320048e-01f, 8.93199593e-02f, 9.04772710e-03f, 1.36832353e-02f, 3.10647748e-02f, 9.22671892e-03f, 1.93299264e-01f,
  -9.06242281e-02f, 8.03591684e-02f, 1.86983496e-01f, 1.24715462e-01f, 1.03065543e-01f, 1.77838951e-01f, 2.81513363e-01f, 1.94630772e-01f, 4.48507257e-02f, 1.52424589e-01f,
  1.99030861e-01f, 2.77131259e-01f, 2.18294531e-01f, 1.60098150e-01f, 1.34547487e-01f, 1.61815569e-01f, 2.49890208e-01f, 1.24690555e-01f, 1.76418915e-01f, 3.48166913e-01f,
  2.95788914e-01f, 4.20872718e-02f, 7.84860477e-02f, 3.56556498e-03f, 3.49819697e-02f, 2.87272669e-02f, 9.42684785e-02f, 3.37121524e-02f, -6.10891469e-02f, 2.28548353e-03f,
  6.71734065e-02f, -2.99321860e-02f, 4.10876349e-02f, 1.19431727e-01f, 1.20530285e-01f, 2.07482912e-02f, -1.73506867e-02f, 1.17848448e-01f, 9.52091813e-02f, 1.13129750e-01f,
  3.28119807e-02f, -1.08460933e-02f, -5.12197949e-02f, -1.40475691e-03f, -3.43734957e-03f, 4.29561436e-02f, 5.21656722e-02f, -1.91364195e-02f, -1.07819252e-02f, 9.67276618e-02f,
  5.30371666e-02f, -2.72072051e-02f, -6.47627413e-02f, -3.86454910e-02f, -5.30779473e-02f, -7.08815679e-02f, 5.11238426e-02f, -5.57526536e-02f, -3.60541567e-02f, -2.40678596e-03f,
  -7.82719105e-02f, 4.07679845e-03f, 5.82945719e-02f, 9.43163857e-02f, 3.69167812e-02f, -5.57476580e-02f, -2.83603258e-02f, 4.14363630e-02f, 1.35437073e-02f, -1.09121613e-01f,
  -4.43463679e-03f, -1.57673273e-03f, -5.71132777e-03f, -9.23383310e-02f, 3.87342721e-02f, 8.39667171e-02f, -1.02144599e-01f, -1.48866594e-01f, -1.49789542e-01f, -5.31061143e-02f,
  -1.26957633e-02f, -4.88892794e-02f, 7.10960990e-03f, -8.53157863e-02f, 7.95136318e-02f, -5.41443843e-03f, 2.41403524e-02f, 1.70659237e-02f, 4.74087335e-02f, 1.32012501e-01f,
  -5.87838814e-02f, 3.35025489e-02f, 8.68558735e-02f, -6.97874799e-02f, 3.38283405e-02f, 1.46299740e-02f, -1.31970793e-02f, 1.07841887e-01f, 4.26322855e-02f, 5.43297492e-02f,
  -5.21033853e-02f, -3.66682410e-02f, -1.21014528e-01f, -4.18356918e-02f, 2.42430940e-02f, -2.71946546e-02f, -4.99326698e-02f, -1.13901660e-01f, -2.37229150e-02f, -7.74855446e-03f,
  3.26321274e-01f, -3.82380396e-01f, -1.40163586e-01f, -2.09200770e-01f, -1.11812517e-01f, 6.86611086e-02f, -1.24545962e-01f, -2.84960289e-02f, -6.95410594e-02f, -1.52219415e-01f,
  -8.81575271e-02f, -2.75556706e-02f, -8.91760439e-02f, 4.05465625e-02f, 1.08317286e-01f, -1.54920399e-01f, -9.33754146e-02f, 2.41440341e-01f, 3.94054711e-01f, 1.80165276e-01f,
  5.00172526e-02f, -2.44323220e-02f, 1.87382609e-01f, 1.00740694e-01f, -2.23126352e-01f, -1.20170020e-01f, -2.65319645e-01f, -7.45790005e-02f, -2.19091430e-01f, -4.15581405e-01f,
  -9.32792723e-02f, -2.34926969e-01f, 1.31393515e-03f, -2.39099432e-02f, -8.83862227e-02f, 2.74763089e-02f, -1.03155151e-01f, -1.21961139e-01f, -9.01009664e-02f, -3.60810161e-02f,
  -1.13271900e-01f, -5.26224300e-02f, -8.13630670e-02f, -5.11541553e-02f, 3.18997130e-02f, -4.63763885e-02f, 1.13648595e-02f, -1.31212967e-02f, 1.75463054e-02f, -9.98888537e-02f,
  -1.19380996e-01f, -1.70204908e-01f, 3.18736397e-02f, -7.96022490e-02f, -4.83504236e-02f, 4.12412435e-02f, -7.39280432e-02f, -1.36295125e-01f, 5.78649677e-02f, -2.85419337e-02f,
  3.54794674e-02f, -2.46553048e-02f, 3.39914039e-02f, 4.70472760e-02f, 7.83517137e-02f, 1.24860264e-03f, 8.73839017e-03f, 1.10696562e-01f, 3.06563824e-02f, -1.25996768e-02f,
  1.11712262e-01f, 7.85434172e-02f, 2.17162482e-02f, -2.32833787e-03f, -3.75434086e-02f, -1.49399508e-02f, 1.10342270e-02f, 1.05370767e-02f, 5.63656166e-02f, 5.66602638e-03f,
  7.06509575e-02f, 6.35099858e-02f, 1.56452134e-02f, 8.90013576e-02f, 5.79509698e-02f, 8.90853852e-02f, 7.72484392e-02f, 4.70557772e-02f, 8.98979157e-02f, 5.48022352e-02f,
  -7.03627989e-02f, 1.64246112e-01f, 5.70267532e-03f, 1.03191724e-02f, -6.19152449e-02f, -6.16019638e-03f, -1.39950141e-01f, -6.71233833e-02f, -1.25715390e-01f, -8.03503767e-03f,
  -4.01214091e-03f, -5.37656993e-02f, -5.02393693e-02f, -8.05851817e-02f, 1.46273486e-02f, 2.68835966e-02f, -8.88428688e-02f, 3.09007484e-02f, 5.46599180e-02f, -1.89274251e-02f,
  -8.78225565e-02f, 3.83714028e-02f, 9.45816562e-02f, 1.09978113e-03f, -1.12301549e-02f, 8.25390890e-02f, 4.93354909e-02f, -2.59899180e-02f, 1.34031445e-01f, 5.80291301e-02f,
  -2.66222477e-01f, -3.15819345e-02f, -1.97330564e-01f, -1.38602212e-01f, 1.42811671e-01f, 1.63519084e-01f, 1.39908224e-01f, 5.25136888e-02f, 2.25209305e-03f, -1.14668518e-01f,
  1.04393490e-01f, 6.19284324e-02f, 1.10475317e-01f, 1.39465764e-01f, 7.69604519e-02f, -1.08881839e-01f, -7.64453933e-02f, -1.27723604e-01f, 7.16471579e-03f, 1.18929952e-01f,
  1.59672052e-01f, -1.58391461e-01f, -2.34332904e-01f, -8.63812044e-02f, -1.76985599e-02f, -3.74410339e-02f, -1.39538333e-01f, -7.71367401e-02f, 1.00430556e-01f, -1.62250325e-01f,
  -1.71295732e-01f, 3.50106470e-02f, 1.04013614e-01f, 2.00906947e-01f, 5.42081185e-02f, -1.60405971e-02f, 1.81168690e-02f, 6.40620440e-02f, 1.18054643e-01f, -4.57354635e-02f,
  7.74506181e-02f, 1.60422735e-02f, 1.20824702e-01f, 1.54730268e-02f, -2.67257560e-02f, 4.23197486e-02f, 2.38787234e-02f, -8.22785497e-02f, -5.31139262e-02f, 8.75317603e-02f,
  1.87965766e-01f, 7.73339644e-02f, -7.57566700e-03f, 5.44605292e-02f, 9.61621925e-02f, 1.10659651e-01f, 9.48297828e-02f, 3.66294906e-02f, 2.66455095e-02f, -2.08459310e-02f,
  -7.46501684e-02f, -1.63357742e-02f, -2.87110023e-02f, -8.25889707e-02f, 1.55729027e-02f, -5.67082651e-02f, 3.03943027e-02f, -3.19750048e-02f, -2.27376409e-02f, -5.28520090e-04f,
  4.31945845e-02f, -6.48535904e-04f, -3.15059945e-02f, -5.79279512e-02f, 1.26788700e-02f, 3.67263854e-02f, -4.10132296e-02f, 4.92715500e-02f, -1.32907266e-02f, -3.70874032e-02f,
  -7.07906485e-02f, -3.70836668e-02f, -1.07340753e-01f, 7.23659024e-02f, 2.33697575e-02f, 4.41858657e-02f, -8.61811563e-02f, 5.58722727e-02f, -5.76610491e-03f, 1.38981687e-02f,
  -1.94257811e-01f, 2.94912755e-01f, -7.59286657e-02f, 1.05111308e-01f, 2.48105247e-02f, 7.11054308e-04f, 3.52614559e-02f, -4.36593732e-03f, 1.18999578e-01f, 2.07961537e-02f,
  1.02988012e-01f, 7.89956227e-02f, -3.37163582e-02f, 1.10264368e-01f, 1.25525137e-02f, 3.92758138e-02f, -2.63601393e-02f, -5.93724400e-02f, -1.77429970e-02f, 3.74443904e-02f,
  -2.70095970e-02f, -1.10600814e-01f, -9.93780345e-02f, -3.32250893e-02f, -4.74302582e-02f, -1.07042626e-01f, -1.15217365e-01f, 5.81096895e-02f, 2.94937510e-02f, -1.48846328e-01f,
  -1.68992668e-01f, -4.43106517e-02f, -9.84524041e-02f, 1.39536366e-01f, -1.07911997e-01f, -1.52797699e-01f, -2.94330120e-02f, 1.44044623e-01f, 1.75458025e-02f, -3.06318495e-02f,
  -3.63160461e-01f, -2.16019452e-01f, -9.44354013e-02f, -8.84370357e-02f, 1.06882796e-01f, 2.68547148e-01f, 3.99159253e-01f, 1.24322571e-01f, 9.39667672e-02f, -9.06875953e-02f,
  2.43558232e-02f, 2.16005057e-01f, 1.89368829e-01f, 2.62982905e-01f, 2.19922259e-01f, 4.18691076e-02f, 2.17722431e-01f, -6.71984162e-03f, 7.60951266e-02f, 1.90340757e-01f,
  -2.42270947e-01f, -1.30825311e-01f, -3.66342478e-02f, -1.47017166e-02f, -7.79007524e-02f, 3.21548767e-02f, -1.01391137e-01f, -5.29147976e-04f, -1.22415259e-01f, 6.52552769e-03f,
  -1.51496172e-01f, -1.07131042e-01f, -1.97858177e-02f, 1.58638414e-02f, -2.66918801e-02f, -2.62607317e-02f, 9.30650160e-02f, 1.51747778e-01f, -2.16737200e-04f, -5.89452982e-02f,
  -1.10097788e-02f, -9.50329900e-02f, -1.57569349e-01f, 8.27931166e-02f, -4.19544093e-02f, 7.00526461e-02f, -5.94856478e-02f, 9.65856388e-02f, 1.17433593e-01f, 3.66405696e-02f,
  -4.77222390e-02f, -7.34842643e-02f, -8.35448410e-03f, -6.23145103e-02f, -6.17719926e-02f, -1.28225610e-02f, -4.48425971e-02f, -6.90210462e-02f, -4.81271278e-03f, -2.06148587e-02f,
  -1.35592595e-02f, -3.70532237e-02f, -3.66211906e-02f, 5.23370467e-02f, 8.91535170e-03f, -5.78341596e-02f, -1.38910701e-02f, 8.56738817e-03f, 2.00201874e-03f, -6.26390427e-02f,
  -7.79756252e-03f, -8.72036293e-02f, -3.74511033e-02f, 7.27003962e-02f, 1.74651202e-02f, 6.56398945e-03f, -3.92585434e-02f, -4.67892587e-02f, -1.45547763e-02f, -8.27691853e-02f,
  9.59054232e-02f, -1.28104975e-02f, 5.33756688e-02f, 1.25762045e-01f, -2.54743434e-02f, 5.02984971e-02f, -2.79293358e-02f, -2.48656534e-02f, -6.09883294e-02f, -5.90709969e-02f,
  -5.41300103e-02f, 9.58113931e-03f, -2.33418494e-02f, -4.25955504e-02f, -9.49846655e-02f, 3.36590335e-02f, 4.44761254e-02f, 8.34505111e-02f, 1.05558388e-01f, -6.19893186e-02f,
  1.07764222e-01f, 1.72452498e-02f, -4.10764776e-02f, 4.71580029e-02f, -3.67009863e-02f, 3.35779861e-02f, 1.32087739e-02f, 1.59230959e-02f, 4.47369665e-02f, 2.82767773e-01f,
  -4.44254190e-01f, 5.72067559e-01f, -1.61281630e-01f, 3.89337502e-02f, 1.50853157e-01f, 4.81163375e-02f, 2.27051601e-01f, 7.33423755e-02f, 9.18599367e-02f, 2.21898243e-01f,
  2.90427327e-01f, 1.04877383e-01f, 6.67966576e-03f, -1.01630613e-01f, -1.12536162e-01f, 1.74221814e-01f, 1.32832855e-01f, -3.07876676e-01f, -3.49919707e-01f, -6.38777390e-02f,
  1.69979021e-01f, -5.31010376e-03f, -1.81071952e-01f, -9.76498276e-02f, 2.61311233e-01f, 4.51768115e-02f, 1.94723487e-01f, 2.00309813e-01f, 1.83351025e-01f, 4.15679842e-01f,
  -1.06590696e-01f, 8.41367319e-02f, -1.74456984e-01f, 1.42362490e-01f, 1.26015723e-01f, 8.76893103e-03f, 9.36527327e-02f, -7.11922199e-02f, 6.82925433e-02f, 9.86156017e-02f,
  9.25934017e-02f, -3.39810620e-03f, 1.05767265e-01f, 1.04806863e-01f, 8.37972909e-02f, 1.27797693e-01f, 1.17711090e-01f, -7.54496008e-02f, 6.79520667e-02f, 1.37970760e-01f,
  2.66405910e-01f, 1.47034749e-01f, 6.03136867e-02f, 1.07234500e-01f, 1.09521627e-01f, -3.35860811e-02f, 1.22410305e-01f, 1.07915603e-01f, 2.70068198e-02f, 2.12336868e-01f,
  1.09993499e-02f, -6.48273826e-02f, -4.45015728e-02f, -4.51038331e-02f, -7.32946396e-03f, 7.65017793e-03f, -9.78108644e-02f, -2.98401751e-02f, -1.01516701e-01f, -7.60878399e-02f,
  -9.06306580e-02f, -3.06109600e-02f, -2.72015631e-02f, -6.96337670e-02f, -2.56515313e-02f, -8.35023522e-02f, -5.31470701e-02f, -5.02529033e-02f, -4.52548787e-02f, -9.12614316e-02f,
  -1.07605286e-01f, -6.51815459e-02f, -8.23894441e-02f, -9.43150446e-02f, -4.91994917e-02f, -1.28545523e-01f, -3.08331810e-02f, -1.25675295e-02f, -7.30876699e-02f, -7.13521913e-02f,
  -2.51212269e-02f, 5.18306494e-02f, -1.26967877e-02f, 3.88430171e-02f, 1.30042033e-02f, 1.06254697e-01f, 4.39492501e-02f, 1.08798273e-01f, 3.70420776e-02f, 6.33571148e-02f,
  1.26314297e-01f, -1.64013058e-02f, 7.97635317e-02f, 9.72980857e-02f, -5.03980257e-02f, 1.19350925e-02f, 2.15392977e-01f, 2.33563986e-02f, 3.69717292e-02f, 1.52607769e-01f,
  1.06603786e-01f, 4.01681289e-03f, -7.24387914e-02f, 3.11911441e-02f, 7.62648433e-02f, -5.28982654e-02f, 1.53824063e-02f, -7.69210234e-03f, -1.17089108e-01f, -1.06305061e-02f,
  2.51111478e-01f, 3.23112190e-01f, 3.53776932e-01f, 2.63655521e-02f, -2.32208762e-02f, -1.06306570e-02f, 2.32972562e-01f, 8.62464309e-02f, -1.48072526e-01f, 1.77166104e-01f,
  -8.23011622e-02f, -3.19222778e-01f, -2.23004937e-01f, -1.71626478e-01f, -1.59136325e-01f, 2.51103580e-01f, 1.62230939e-01f, 2.83871628e-02f, -1.66326493e-01f, -2.20862925e-01f,
  -1.83734074e-01f, -6.06743582e-02f, -7.08323121e-02f, -1.13107458e-01f, 1.36848018e-01f, -6.09863661e-02f, 1.43830270e-01f, 1.44702448e-02f, 6.36947230e-02f, 1.93653330e-01f,
  1.77603811e-01f, 1.06361307e-01f, -1.31566659e-01f, -1.73874021e-01f, -1.19166404e-01f, 7.02065676e-02f, 2.31470838e-02f, 8.19479153e-02f, -5.30969799e-02f, 2.16577444e-02f,
  2.08579772e-03f, -5.44310994e-02f, -5.82361186e-04f, -7.63438195e-02f, -2.72905026e-02f, 4.04356197e-02f, 8.22930411e-03f, -9.62326527e-02f, -1.04493545e-02f, 3.17183137e-02f,
  -1.07091889e-01f, -6.10153712e-02f, 5.52374497e-02f, 3.56225483e-02f, 4.64577638e-02f, -8.24982822e-02f, 3.54291759e-02f, -5.63966595e-02f, 2.68810671e-02f, 2.54131317e-01f,
  1.94862741e-03f, 3.81752364e-02f, -7.70091265e-02f, 5.54904975e-02f, 7.85687342e-02f, 7.15214089e-02f, 3.94654721e-02f, 6.13577291e-02f, 1.82065424e-02f, 5.60525469e-02f,
  4.65934165e-02f, 1.20416535e-02f, 6.63566589e-02f, 4.50267382e-02f, -2.75515765e-02f, 8.24575871e-02f, 3.21545899e-02f, 5.28047942e-02f, -5.78579865e-02f, 6.15305156e-02f,
  7.56567568e-02f, 8.66737738e-02f, 2.54399534e-02f, 2.66625155e-02f, -1.47310151e-02f, 3.60258929e-02f, 5.99847697e-02f, 7.62933567e-02f, 2.88792178e-02f, 7.40678459e-02f,
  1.15854979e-01f, -2.78084099e-01f, 5.08999005e-02f, -2.10562553e-02f, 4.16063331e-03f, -1.71953276e-01f, -2.39336975e-02f, -1.15191594e-01f, -9.80701074e-02f, 8.09982419e-03f,
  -2.34144498e-02f, -3.63045335e-02f, 8.07247087e-02f, -9.15034674e-03f, -3.20092514e-02f, -9.66375247e-02f, -3.96926068e-02f, -4.52885702e-02f, -1.45522043e-01f, -3.94727327e-02f,
  -2.93986090e-02f, 9.18394104e-02f, 1.27829969e-01f, 7.14227110e-02f, -8.63390863e-02f, 7.45633710e-03f, 3.55594233e-02f, 6.57388270e-02f, 3.44934594e-03f, 2.55317330e-01f,
  4.63255465e-01f, -1.28008842e-01f, 1.19879365e-01f, 9.88449529e-03f, 9.76970047e-02f, 2.68089950e-01f, 3.30703944e-01f, 1.37625501e-01f, 7.66235664e-02f, -3.19167264e-02f,
  -7.68747404e-02f, -2.45757222e-01f, -1.51183248e-01f, -2.25507021e-01f, 1.13322072e-01f, 1.44775547e-02f, -4.94574271e-02f, 9.73989293e-02f, 6.74528331e-02f, 7.01545700e-02f,
  -3.65271680e-02f, 4.31529470e-02f, -2.68789697e-02f, 1.45505546e-02f, -2.14795440e-01f, -8.86550993e-02f, -2.16921605e-02f, -3.36775370e-02f, -6.39961958e-02f, -2.17339069e-01f,
  -1.52762294e-01f, -5.40485084e-02f, -2.39749579e-03f, -9.05381888e-02f, -1.07806459e-01f, -7.26240650e-02f, -7.33481022e-03f, -1.88997075e-01f, -1.23073183e-01f, -1.00456178e-01f,
  3.66070159e-02f, -4.76153344e-02f, -1.08047523e-01f, -2.08543375e-01f, -3.40350308e-02f, -7.10992292e-02f, -8.78282115e-02f, -1.33402333e-01f, -1.12308469e-02f, -8.75149295e-02f,
  -2.17885479e-01f, 6.65492862e-02f, 1.44114390e-01f, -7.45157599e-02f, -5.06423339e-02f, -5.69267757e-03f, -1.96061879e-02f, -1.24064945e-01f, 1.19183213e-02f, -2.66338103e-02f,
  -2.88693383e-02f, 1.10329635e-01f, -1.64290760e-02f, -9.38826334e-03f, 4.53983806e-02f, 6.99898228e-02f, -3.53944972e-02f, 1.11264132e-01f, 2.36085355e-02f, 4.23467606e-02f,
  3.25584406e-05f, 9.87104699e-03f, -1.17309839e-02f, 1.22812614e-01f, -7.75137097e-02f, 1.09641127e-01f, -1.46262697e-03f, 9.07953549e-03f, 3.16834524e-02f, -9.62991267e-03f,
  -2.44514216e-02f, 7.61764124e-02f, 2.82864813e-02f, -8.66588391e-03f, -5.40076494e-02f, 9.89099666e-02f, 1.27409682e-01f, 4.41235583e-03f, 4.63484004e-02f, 6.33371025e-02f,
  -2.17458412e-01f, 1.72404274e-02f, -1.90707281e-01f, -6.84259608e-02f, -6.18351400e-02f, -1.56322703e-01f, -7.13999495e-02f, -1.40429959e-01f, -5.23542129e-02f, -3.07732467e-02f,
  -3.30343843e-03f, 6.86727762e-02f, -3.58116254e-02f, -5.94985448e-02f, 4.35592458e-02f, -8.83628130e-02f, 7.26015912e-03f, -4.17044275e-02f, -8.73046815e-02f, -4.39186618e-02f,
  3.11089177e-02f, 7.24292994e-02f, 1.63978994e-01f, 7.23125488e-02f, -1.08694751e-02f, 1.13450594e-01f, -3.97894382e-02f, 8.47943947e-02f, 2.04193190e-01f, 1.72345400e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.00921828e-01f, 5.38393617e-01f, -6.85468093e-02f, -2.31122687e-01f, -6.77148625e-02f, 2.50654072e-01f, 6.20658815e-01f, 3.10123503e-01f, -1.06635258e-01f, 4.04687017e-01f,
  3.24518830e-01f, -3.24563563e-01f, -1.74694881e-01f, -2.65732586e-01f, 1.63902014e-01f, 2.26627991e-01f, -1.86409727e-01f, -3.23743880e-01f, -2.87757128e-01f, 2.38086116e-02f,
  2.80591268e-02f, 1.81646332e-01f, 1.59808338e-01f, -1.89715847e-01f, -1.92781165e-01f, -4.65385407e-01f, 4.28860411e-02f, 1.33648574e-01f, 1.07386902e-01f, -4.46670294e-01f,
  -2.70384431e-01f, 2.76771843e-01f, -2.90181011e-01f, -1.55587628e-01f, -1.26199629e-02f, 5.11714183e-02f, -2.24392079e-02f, 5.49560823e-02f, 1.77754998e-01f, 9.06762928e-02f,
  -2.12115534e-02f, 4.35463786e-02f, 7.20955878e-02f, 2.57435683e-02f, 1.33051530e-01f, 8.98852050e-02f, -6.54661749e-03f, -7.24985674e-02f, -4.72778194e-02f, 2.19832957e-02f,
  -7.85894170e-02f, -2.55101768e-04f, 4.76919673e-02f, 6.30422086e-02f, 7.88885751e-04f, -2.76959389e-01f, 1.24444693e-01f, -1.40074968e-01f, -3.98173183e-02f, -1.15170836e-01f,
  -4.67091352e-02f, -3.38802077e-02f, -9.32698995e-02f, -1.10535368e-01f, 7.29909167e-02f, -3.18773873e-02f, -9.90766063e-02f, -2.70443950e-02f, 3.26653384e-02f, 4.19246145e-02f,
  7.29548857e-02f, 8.17274824e-02f, 1.00922205e-01f, 9.67213064e-02f, -1.15700483e-01f, -7.97483698e-03f, 1.33046322e-03f, 1.08163394e-01f, -3.54065113e-02f, 5.52361198e-02f,
  2.14134641e-02f, -1.30598256e-02f, 4.22008224e-02f, 6.74914867e-02f, 8.92971002e-04f, -2.93459632e-02f, -9.29823816e-02f, 6.15786538e-02f, 4.84956205e-02f, 1.56077310e-01f,
  7.89665356e-02f, 2.66969860e-01f, -2.22054824e-01f, -1.00104883e-01f, -8.89492407e-02f, 4.23326008e-02f, -1.49861813e-01f, -5.14658401e-03f, -4.86597745e-03f, 1.36737213e-01f,
  5.64624323e-03f, 2.07707360e-02f, 2.32249916e-01f, 7.57941976e-02f, 1.10640988e-01f, 7.21498057e-02f, 4.09677178e-02f, -1.15607053e-01f, -1.25593454e-01f, -1.11930847e-01f,
  8.23044404e-02f, 9.38799977e-02f, -5.18291863e-03f, -4.72585633e-02f, -1.76347628e-01f, -2.22201839e-01f, 9.22138430e-03f, -1.21553726e-01f, 4.34626974e-02f, 2.18268439e-01f,
  5.04218340e-01f, -2.41277978e-01f, 1.57022133e-01f, -1.91991493e-01f, -6.21257484e-01f, -5.47720611e-01f, -6.83566988e-01f, -4.22439247e-01f, -2.72978932e-01f, -5.86929142e-01f,
  -5.21241844e-01f, -1.43795311e-01f, -3.44700038e-01f, -3.21889669e-02f, 1.58387542e-01f, -2.95607060e-01f, 1.54408470e-01f, 6.13394618e-01f, 6.50628686e-01f, 5.10022223e-01f,
  2.86419094e-01f, 6.26082242e-01f, 6.93973720e-01f, 5.53730309e-01f, 1.20560147e-01f, -4.82513011e-02f, 2.77892477e-03f, 1.87723160e-01f, 8.59651566e-02f, 3.21411222e-01f,
  -2.27416620e-01f, 4.76941802e-02f, -4.10960801e-02f, -6.38961941e-02f, -1.18387051e-01f, 1.23189375e-01f, -8.21206048e-02f, 3.79976600e-01f, -7.91082438e-03f, 6.24638982e-02f,
  -2.57546902e-01f, 4.57049571e-02f, -1.14985503e-01f, 1.10416003e-02f, -1.88321844e-02f, -3.22734118e-02f, 2.49168485e-01f, 3.69803160e-01f, 8.93285349e-02f, 1.68266650e-02f,
  -1.72060505e-01f, -9.68517363e-02f, -3.49207520e-01f, -3.41104448e-01f, -5.64321056e-02f, 6.29374757e-02f, -1.38558412e-03f, 6.20128103e-02f, -1.10891119e-01f, 1.52568966e-01f,
  -1.15508903e-02f, 9.69002396e-03f, -1.67177364e-01f, -6.61747828e-02f, -8.25139210e-02f, -2.52389669e-01f, 7.02377502e-03f, -8.35361183e-02f, -5.27024530e-02f, -6.74487054e-02f,
  -6.17568679e-02f, 1.00999512e-02f, 1.90017954e-01f, 2.05502957e-02f, -2.39871466e-03f, -1.98528357e-03f, 5.99707104e-03f, 1.94268435e-01f, -6.30953014e-02f, -8.78402144e-02f,
  5.04253767e-02f, -1.69884801e-01f, 1.52846098e-01f, 2.02707544e-01f, -1.07604548e-01f, 2.15463173e-02f, 1.22681744e-01f, 5.29083572e-02f, -5.13371453e-03f, -1.05144382e-01f,
  -2.99542934e-01f, -1.27833724e-01f, -1.00214623e-01f, 4.74071093e-02f, -5.49390465e-02f, 4.03640996e-04f, -1.47478983e-01f, 2.12979447e-02f, -1.52666122e-01f, 6.76410794e-02f,
  -2.61817902e-01f, -1.10085279e-01f, -1.27464116e-01f, 7.67225996e-02f, -1.55604966e-02f, -2.55618393e-01f, -3.91850591e-01f, -1.44512787e-01f, 2.24794745e-02f, -1.95806809e-02f,
  -1.90786332e-01f, -3.24317038e-01f, -3.92353147e-01f, -7.01424658e-01f, -2.50769258e-01f, -3.54748756e-01f, -1.92548916e-01f, -2.19320536e-01f, -6.45976722e-01f, -5.43661594e-01f,
  -6.78195179e-01f, -1.99437529e-01f, -6.00397825e-01f, -9.54052806e-01f, -6.08681321e-01f, -1.74031824e-01f, 2.30623424e-01f, -2.19365302e-02f, -4.48090583e-01f, -1.97687283e-01f,
  2.30292574e-01f, 4.82550293e-01f, 1.54848471e-01f, 2.93790996e-01f, 4.71938282e-01f, -2.47874424e-01f, -5.74193180e-01f, -1.35848969e-01f, 3.49755585e-01f, 4.42776084e-01f,
  1.05268240e-01f, -3.54367316e-01f, -3.24676961e-01f, -1.66934744e-01f, -4.75764692e-01f, -1.53702423e-01f, -4.59070861e-01f, -3.99207503e-01f, 5.88061213e-02f, -5.10847807e-01f,
  2.47871593e-01f, -4.27493811e-01f, 8.13455358e-02f, 1.03267131e-03f, -7.40786493e-02f, 2.19343714e-02f, 4.97063957e-02f, -2.79983848e-01f, -9.58650485e-02f, -1.15976244e-01f,
  -2.15962067e-01f, 1.16910031e-02f, -7.54370121e-03f, -7.59188607e-02f, -2.75905281e-01f, -5.33733927e-02f, -1.20382950e-01f, -4.60488796e-02f, -1.43918842e-01f, 1.50269449e-01f,
  1.25517741e-01f, -5.00063188e-02f, -2.58018840e-02f, 1.70853704e-01f, -1.07588964e-02f, -6.02033325e-02f, 2.34210282e-03f, -2.48347614e-02f, 1.22813610e-02f, -2.37288192e-01f,
  -6.54792860e-02f, -3.71946581e-02f, -3.93122956e-02f, 1.31742088e-02f, -1.89839210e-02f, -1.40254302e-02f, -1.10546254e-01f, 5.79389930e-03f, 4.78212014e-02f, 1.03609301e-01f,
  2.43479181e-02f, -8.86734352e-02f, 1.85219981e-02f, -1.03900181e-02f, 8.15267414e-02f, -1.68527916e-01f, 7.92312175e-02f, 1.36131585e-01f, -2.91121304e-02f, -8.97848159e-02f,
  2.98535284e-02f, -8.17913264e-02f, -1.66779011e-01f, 4.18760367e-02f, 5.41163189e-03f, -1.01475678e-01f, -6.69512004e-02f, 1.18469298e-01f, -4.05165032e-02f, -1.72466621e-01f,
  3.15574437e-01f, 1.78926453e-01f, -3.40988524e-02f, -1.22195175e-02f, -1.65830687e-01f, 9.02024098e-03f, -6.47687167e-02f, -3.38056013e-02f, -2.63028331e-02f, 1.19496351e-02f,
  3.32197770e-02f, 3.78732607e-02f, -2.17579175e-02f, -7.61325331e-03f, -3.31491679e-02f, 1.36673599e-01f, 4.62211743e-02f, -8.14092755e-02f, 7.24872872e-02f, -7.44305626e-02f,
  -6.97778240e-02f, -2.18930226e-02f, 2.49345765e-01f, 1.54956132e-01f, 3.88216153e-02f, 6.12485819e-02f, 2.47738585e-01f, 2.09773466e-01f, 2.43433386e-01f, 8.03627633e-03f,
  8.93366456e-01f, -1.24096699e-01f, 3.48235339e-01f, 2.18590096e-01f, 9.46925133e-02f, 3.46236527e-01f, 3.26930165e-01f, 1.67094365e-01f, 1.95403993e-01f, 1.17926747e-01f,
  2.80635543e-02f, -1.10277906e-01f, -7.41690397e-02f, -2.67174449e-02f, 1.10945575e-01f, 1.02774270e-01f, -2.62426734e-02f, 1.89381614e-01f, 2.05930203e-01f, 1.62966818e-01f,
  -7.56845102e-02f, -4.43232171e-02f, 1.21569015e-01f, 6.73023611e-03f, -1.08133152e-01f, -2.97295637e-02f, -1.50501847e-01f, -1.21709235e-01f, -3.80423516e-02f, -1.26647055e-01f,
  -7.88172055e-03f, 4.79866797e-03f, 4.04661410e-02f, -1.61152661e-01f, -2.03803539e-01f, 3.91767398e-02f, -2.63063554e-02f, -4.54446338e-02f, 3.49691622e-02f, -1.15631841e-01f,
  -1.19902082e-01f, -8.44098628e-02f, -1.85879916e-01f, -4.40954417e-02f, -1.15771152e-01f, 3.42297740e-02f, -1.57161698e-01f, 1.61668491e-02f, -8.77871364e-02f, -8.98854434e-03f,
  -1.55758590e-01f, -1.55572325e-01f, -7.61481076e-02f, 2.99338922e-02f, -2.79532932e-02f, -6.19480163e-02f, -1.65197030e-02f, -8.13244134e-02f, -2.22990103e-02f, 4.66562174e-02f,
  -9.15245488e-02f, -7.19817430e-02f, -3.46191712e-02f, 4.20254953e-02f, -4.06304235e-03f, 4.74743452e-03f, -1.42172158e-01f, -1.69171631e-01f, -9.21854526e-02f, -2.59269811e-02f,
  -1.45789474e-01f, 9.96441096e-02f, 9.82025117e-02f, -9.36956797e-03f, 4.59982604e-02f, -3.58522385e-02f, -2.93308706e-03f, -6.14633076e-02f, -5.03987707e-02f, 9.87613052e-02f,
  9.40168835e-03f, -1.99810825e-02f, -7.79942945e-02f, -1.00210570e-01f, 5.86937107e-02f, 3.61767784e-02f, 5.22969849e-02f, 1.72343906e-02f, -2.92393472e-02f, 1.08800612e-01f,
  -1.48972660e-01f, 1.09772190e-01f, 2.06703227e-02f, -9.98751670e-02f, -1.14788450e-02f, 2.17401292e-02f, 4.52231243e-02f, 1.89931951e-02f, 6.36337399e-02f, -4.34532017e-02f,
  -2.21628696e-02f, -7.64191151e-02f, -1.14593379e-01f, -1.23880737e-01f, 4.68768924e-02f, -5.94497882e-02f, -6.06961250e-02f, -1.11901529e-01f, -1.08317040e-01f, -1.70824528e-01f,
  -1.38859123e-01f, 7.24302307e-02f, 1.70716956e-01f, 3.77031155e-02f, -1.99387409e-02f, 1.33896515e-01f, -2.58170981e-02f, -9.42565277e-02f, 1.02302425e-01f, 1.48905054e-01f,
  4.20600414e-01f, -1.58047587e-01f, -2.11838409e-01f, 2.30267838e-01f, -1.46887541e-01f, -2.03514233e-01f, -3.39090765e-01f, -2.77275145e-02f, 1.46992132e-01f, 3.17913666e-02f,
  1.23857543e-01f, 1.91169724e-01f, 2.61577338e-01f, 2.18009427e-01f, -2.93576196e-02f, -1.10838681e-01f, -2.16156274e-01f, 6.01382554e-02f, 1.03052601e-01f, -2.41820477e-02f,
  5.00509068e-02f, -8.79155546e-02f, -3.35614616e-03f, 1.17281862e-02f, -6.30461723e-02f, 6.44333735e-02f, -1.65928528e-01f, -1.16611242e-01f, -2.55117118e-01f, -1.70242265e-01f,
  1.12741692e-02f, 1.69932604e-01f, 2.84513146e-01f, 3.14325899e-01f, 1.96811035e-01f, 2.45242208e-01f, 1.59086734e-01f, 1.14084214e-01f, 5.10885715e-02f, -4.93737520e-04f,
  1.13167726e-01f, 1.41136646e-01f, 1.18073225e-01f, 7.61049390e-02f, 8.64686817e-02f, 1.52537897e-01f, 1.95846349e-01f, 7.67163932e-02f, 1.12569928e-01f, 1.44857481e-01f,
  2.28486620e-02f, 2.16940278e-03f, 9.48619749e-03f, -1.54853798e-02f, 1.07053384e-01f, 1.15984820e-01f, -2.14853720e-03f, 1.32074267e-01f, 3.32152508e-02f, -3.83913815e-02f,
  1.17515467e-01f, 4.03195620e-02f, 1.06501125e-01f, 1.91684347e-02f, -7.23976316e-03f, 1.15618981e-01f, -4.59816530e-02f, -6.19749464e-02f, 7.82772340e-03f, 3.67992260e-02f,
  -1.13198474e-01f, -6.41576722e-02f, -4.77417186e-02f, -1.44588957e-02f, 1.59040123e-01f, 1.81663688e-02f, -1.71061113e-01f, -8.20829161e-03f, 1.46859065e-01f, 6.12385459e-02f,
  7.56170228e-03f, -1.64073691e-01f, -5.09336889e-02f, -4.10752334e-02f, -9.64672640e-02f, 5.58880903e-02f, 3.61121744e-02f, -5.80753051e-02f, -1.17258154e-01f, -1.42393053e-01f,
  4.75492813e-02f, 3.97509784e-01f, 1.67733207e-01f, 2.37830095e-02f, -5.25449961e-02f, 4.86380197e-02f, 5.60787879e-02f, -1.86045724e-03f, 3.60117331e-02f, 1.80255566e-02f,
  4.31800224e-02f, 1.20788023e-01f, 8.03917870e-02f, -1.97718125e-02f, 2.50301920e-02f, 5.57008758e-02f, 1.14781156e-01f, 5.68630248e-02f, 1.42935604e-01f, 4.65576053e-02f,
  1.42967952e-02f, -7.29008690e-02f, -8.64878669e-02f, 7.78021812e-02f, -1.16695222e-02f, 1.25311002e-01f, 1.14229014e-02f, 4.80848690e-03f, 7.28670433e-02f, -1.01488434e-01f,
  5.66579700e-01f, 7.85527825e-01f, 1.78635672e-01f, 2.21272204e-02f, 1.58448309e-01f, 4.64876853e-02f, 3.56549859e-01f, 2.56775886e-01f, -2.11175196e-02f, 1.02271721e-01f,
  -1.45023093e-01f, -2.62014806e-01f, -5.98973818e-02f, -1.79197967e-01f, 1.61229316e-02f, 1.49086297e-01f, 1.83236048e-01f, -9.96092260e-02f, -2.96135873e-01f, -3.12267512e-01f,
  -1.89635009e-01f, -1.04194604e-01f, -1.29911989e-01f, -7.15247765e-02f, 2.25667819e-01f, -1.99077073e-02f, 2.05119893e-01f, 1.22464433e-01f, 4.88575883e-02f, 2.21804425e-01f,
  -4.30370897e-01f, 5.71471751e-01f, -8.10690224e-01f, -2.29494885e-01f, 9.29312257e-04f, -7.29093775e-02f, -1.12296715e-01f, 7.75013939e-02f, -4.39134315e-02f, 7.40451068e-02f,
  -3.61388884e-02f, -1.08544961e-01f, 2.49627858e-01f, 8.39639902e-02f, 8.59291628e-02f, -6.23556226e-02f, 1.46877319e-01f, 1.88771486e-01f, 7.55444318e-02f, -4.83764522e-02f,
  -1.32446572e-01f, -1.83048937e-02f, 2.28670850e-01f, -2.40978710e-02f, 1.06921971e-01f, -1.31191373e-01f, 1.10116534e-01f, 3.62719484e-02f, -4.82674409e-03f, 2.22769246e-01f,
  -2.19495803e-01f, 8.61600265e-02f, 1.03390239e-01f, -6.06079586e-02f, -1.89155310e-01f, 3.69967893e-02f, 1.12039432e-01f, 1.46950185e-01f, -1.22645579e-01f, 1.35269910e-01f,
  -5.15952408e-02f, -1.94018558e-01f, 6.21833764e-02f, 5.52962087e-02f, -1.61731109e-01f, 1.87326938e-01f, -3.72779444e-02f, -7.36681521e-02f, -1.57888010e-02f, 8.17525480e-03f,
  -7.23386481e-02f, 9.79653075e-02f, 1.96235240e-01f, -2.60263421e-02f, -1.00072011e-01f, 4.48236465e-02f, -1.47845745e-01f, 4.51501012e-02f, 1.12367675e-01f, 3.64660583e-02f,
  -4.32555020e-01f, -5.64165115e-01f, -6.24827802e-01f, -2.35512443e-02f, 2.10993543e-01f, -3.73470373e-02f, -1.69137284e-01f, -1.55841038e-01f, 1.57212988e-01f, 6.26584738e-02f,
  8.30897093e-02f, -1.44139245e-01f, 2.28833154e-01f, 4.59820256e-02f, -1.31869093e-01f, -1.75694063e-01f, -1.44571558e-01f, 7.91424811e-02f, -3.10538933e-02f, 2.16369435e-01f,
  2.24233754e-02f, -3.66597354e-01f, -2.62654513e-01f, -1.64214224e-01f, -1.85766459e-01f, -6.32234693e-01f, -2.91142404e-01f, -2.02913076e-01f, -2.99427718e-01f, -1.17498143e-02f,
  6.55345440e-01f, 6.67620361e-01f, 1.03824049e-01f, 2.60431945e-01f, 1.05436452e-01f, 3.17315280e-01f, 3.66764069e-01f, 4.98483062e-01f, 3.29186767e-01f, 3.30729544e-01f,
  3.24211627e-01f, 2.09454477e-01f, 3.24727207e-01f, 3.52002800e-01f, 2.78585941e-01f, 3.54519129e-01f, 2.95374811e-01f, 6.89940304e-02f, -1.78654101e-02f, 6.90432340e-02f,
  1.18076257e-01f, 1.56587809e-01f, 1.07311077e-01f, 1.16630115e-01f, 6.83491826e-02f, 6.20229803e-02f, 1.65859506e-01f, 1.33074224e-02f, 1.14645302e-01f, 1.62411675e-01f,
  -2.85430402e-01f, 4.14523035e-02f, -1.01569276e-02f, -3.05321347e-02f, -1.88459784e-01f, -5.00437282e-02f, 1.17048901e-02f, -4.38550115e-02f, -6.70041442e-02f, -6.95189834e-02f,
  -6.31880239e-02f, -3.03235874e-02f, -1.87207416e-01f, -3.81500497e-02f, -1.65961280e-01f, -9.57815349e-02f, -7.90881887e-02f, 9.74650532e-02f, -2.52616927e-02f, -7.96217769e-02f,
  -5.57019711e-02f, -1.68790832e-01f, -5.96419387e-02f, -1.15140833e-01f, 7.75738582e-02f, -1.70009926e-01f, -6.60525449e-03f, -1.01064883e-01f, 1.23933842e-02f, -8.78726318e-02f,
  1.04771934e-01f, 2.20399454e-01f, -1.29557997e-01f, -1.40706420e-01f, -7.59983212e-02f, -1.59350440e-01f, -1.28612176e-01f, -4.34606615e-03f, 3.10075209e-02f, -6.83439896e-02f,
  -4.08011042e-02f, -7.05756098e-02f, -6.27469942e-02f, -2.29372069e-01f, -1.19782314e-01f, 9.64117981e-03f, 2.22716073e-04f, -1.21067636e-01f, -3.16289276e-01f, -8.81284662e-03f,
  -8.07932913e-02f, 3.02895438e-03f, -2.59365231e-01f, -1.17778681e-01f, -6.20408952e-02f, -8.32039788e-02f, -1.21192567e-01f, -1.03353508e-01f, -1.14779547e-01f, -5.77352494e-02f,
  -1.70806229e-01f, -2.26986021e-01f, 1.00423664e-01f, 3.05115134e-01f, -3.79838794e-02f, 1.12924963e-01f, 7.23000616e-02f, -3.74657959e-02f, -8.47837031e-02f, -1.48191312e-02f,
  9.60813276e-03f, -3.36814411e-02f, 1.01207066e-02f, -1.95067208e-02f, -1.44504830e-01f, -1.64544731e-01f, 1.01580769e-02f, 1.21513575e-01f, 4.15995605e-02f, -1.20363094e-01f,
  1.19894877e-01f, -7.04876631e-02f, -9.85144731e-03f, -3.36981714e-02f, 1.08659066e-01f, -9.87910554e-02f, -2.13215426e-01f, -1.41877234e-01f, -1.30409643e-01f, -1.82554945e-01f,
  -3.47843528e-01f, -4.23614919e-01f, -8.43752801e-01f, -1.98479649e-02f, 2.55498439e-01f, 3.51293445e-01f, 4.53752458e-01f, 2.57239938e-01f, -7.65957683e-02f, -2.52359986e-01f,
  -3.24962109e-01f, -7.20260814e-02f, -5.88512540e-01f, -3.09291808e-03f, 8.54163393e-02f, -7.95577019e-02f, 2.50192769e-02f, -1.72904551e-01f, 3.92737478e-01f, 6.17627800e-01f,
  4.81333941e-01f, 2.52361029e-01f, 9.29787606e-02f, 1.50781587e-01f, -1.29413173e-01f, 1.58829596e-02f, -4.41236436e-01f, -1.47917330e-01f, -5.55558763e-02f, -3.50743353e-01f,
  -9.36433911e-01f, -6.11469388e-01f, 2.19208151e-01f, 6.76686317e-02f, -9.76282582e-02f, -3.28294307e-01f, -2.09949426e-02f, -4.00998831e-01f, -2.92512536e-01f, -2.22666278e-01f,
  -3.14368568e-02f, -1.87185675e-01f, -3.28609437e-01f, -4.77112867e-02f, -4.14815322e-02f, -1.00668762e-02f, 1.24634430e-01f, -6.08360730e-02f, -4.04303759e-01f, -2.50591725e-01f,
  3.49869251e-01f, -2.11782623e-02f, -4.09682959e-01f, -8.32241103e-02f, -2.88655937e-01f, -8.95705000e-02f, -2.05782250e-01f, -5.69968261e-02f, -3.67007911e-01f, -2.62901396e-01f,
  1.91408515e-01f, -6.89690281e-03f, 2.93112826e-02f, 8.83441493e-02f, 2.79124916e-01f, -1.09402791e-01f, 3.44326394e-03f, 1.09334908e-01f, -9.24281850e-02f, -9.66643393e-02f,
  -8.52988735e-02f, -8.92262757e-02f, 1.86495371e-02f, -1.07072674e-01f, -1.62385464e-01f, -1.11466751e-01f, 1.15184978e-01f, 4.56529520e-02f, 7.38659082e-03f, -3.09975147e-02f,
  -6.16076365e-02f, 1.12970890e-02f, -1.10415453e-02f, 1.05975583e-01f, 4.70531471e-02f, 5.15115038e-02f, -1.23462401e-01f, 1.07724341e-02f, -6.95315227e-02f, -1.03291273e-01f,
  -2.06789374e-01f, 2.82168865e-01f, -5.40176511e-01f, 5.85654415e-02f, -1.34197131e-01f, -8.44976585e-03f, 4.32842690e-03f, -4.39139269e-02f, -2.93841451e-01f, -1.89104393e-01f,
  -1.88050177e-02f, -2.38228980e-02f, -2.93543845e-01f, 3.05701625e-02f, 1.31528482e-01f, -9.58810374e-02f, 2.81721056e-01f, 1.55894816e-01f, 5.79179563e-02f, -2.81525385e-02f,
  1.94029674e-01f, 2.42795005e-01f, 1.06955342e-01f, -1.17754102e-01f, 5.01211472e-02f, 7.10867196e-02f, -2.74918169e-01f, 1.13976069e-01f, -2.09154710e-01f, 7.86857456e-02f,
  8.34161222e-01f, -2.37576678e-01f, -3.70776087e-01f, 7.77472258e-01f, 3.57071087e-02f, -4.07557309e-01f, -5.10336161e-01f, 4.22905833e-02f, 5.80341578e-01f, 1.34640366e-01f,
  -4.16588128e-01f, -5.34995317e-01f, -2.34659180e-01f, -5.63665330e-01f, -7.76108384e-01f, -7.47796372e-02f, 1.06797978e-01f, -3.64186704e-01f, -7.35162556e-01f, -8.05576861e-01f,
  -2.04526201e-01f, 1.48527324e-01f, 1.18700461e-02f, -9.20267776e-02f, 3.32514256e-01f, 1.12786293e-01f, 4.27584708e-01f, -9.11629423e-02f, -5.23931146e-01f, 1.01074286e-01f,
  -3.00083101e-01f, -1.09248944e-01f, -2.93136835e-01f, -6.23769797e-02f, 1.76209345e-01f, 2.49804761e-02f, -1.53885275e-01f, 1.83937281e-01f, 4.68022898e-02f, 1.71708297e-02f,
  -2.95058578e-01f, -3.79160017e-01f, -3.18421602e-01f, -1.98011369e-01f, -1.32242486e-01f, -2.65648872e-01f, 1.16091780e-01f, -2.19801411e-01f, 1.45526290e-01f, -2.70452678e-01f,
  -4.78587121e-01f, -3.95881444e-01f, -5.93951438e-03f, -2.93228915e-03f, -1.21754639e-01f, -1.96541160e-01f, -1.55304179e-01f, -2.62561858e-01f, -1.25624299e-01f, 5.26831448e-01f,
  -5.10075949e-02f, 7.55224079e-02f, 4.97523770e-02f, 9.76128727e-02f, 1.47861823e-01f, 9.07586738e-02f, 4.00283001e-02f, -1.58809066e-01f, -2.46161237e-01f, -4.23289090e-03f,
  -1.77358054e-02f, -1.33386115e-02f, -1.33925915e-01f, 6.23566359e-02f, -1.74456313e-02f, -1.29026324e-01f, 2.05363911e-02f, -1.02859639e-01f, -1.84810713e-01f, 9.23193246e-02f,
  -1.06458046e-01f, 2.39237957e-02f, 1.98321179e-01f, 4.99904677e-02f, -1.75703838e-02f, -3.36359590e-02f, -4.54826541e-02f, -2.21152171e-01f, -6.76332638e-02f, 1.30031528e-02f,
  4.58201498e-01f, -4.13118094e-01f, 3.75467777e-01f, -1.33510411e-01f, 1.30925030e-01f, 2.06402838e-01f, 7.39570521e-03f, -1.05842307e-01f, 1.66688338e-02f, -1.81542903e-01f,
  -6.18604779e-01f, -1.95487633e-01f, -1.21233091e-02f, -5.39849736e-02f, -7.33419582e-02f, -1.59855694e-01f, 6.59132451e-02f, 2.27614678e-02f, -9.69258100e-02f, 1.03601394e-02f,
  2.39219114e-01f, 2.50948638e-01f, 2.85869300e-01f, 3.57472688e-01f, 3.55102904e-02f, 7.95117393e-02f, 6.78009242e-02f, -1.91370759e-03f, -1.30529478e-01f, 8.39315593e-01f,
  -3.69791061e-01f, 5.23941576e-01f, 5.43216348e-01f, -4.33083087e-01f, -3.22733402e-01f, 1.16025127e-01f, 3.76513749e-01f, 1.80951104e-01f, -3.77345473e-01f, -3.05888485e-02f,
  -2.52851874e-01f, -3.84479970e-01f, -2.02640548e-01f, 6.07576445e-02f, 3.82049471e-01f, 5.44241905e-01f, 3.63350391e-01f, 2.72171527e-01f, 1.63722795e-03f, -1.16172722e-02f,
  -1.26099497e-01f, -2.48837620e-01f, -1.68882340e-01f, 6.74395338e-02f, -1.78121224e-01f, -2.98989177e-01f, 1.57659933e-01f, -9.14282724e-02f, 2.23692790e-01f, 2.08221257e-01f,
  2.10251242e-01f, -1.19526498e-01f, -4.66763675e-02f, -4.64376450e-01f, -3.43532674e-02f, 1.74569696e-01f, 1.16370864e-01f, -6.60273479e-03f, -2.88522174e-03f, 1.85249299e-01f,
  -1.41943678e-01f, 7.19783008e-02f, -6.74451515e-02f, 1.96160331e-01f, 3.79465930e-02f, 7.45138666e-03f, 2.42584497e-01f, 2.06076115e-01f, 2.26154640e-01f, 1.22747973e-01f,
  8.85159373e-02f, -3.92917365e-01f, -2.70718366e-01f, 5.39260954e-02f, 1.77582443e-01f, -2.84996837e-01f, 3.21470425e-02f, -8.75027701e-02f, 5.85580282e-02f, -3.96756129e-03f,
  -6.33574501e-02f, 7.67401233e-02f, 7.13093355e-02f, 2.91573375e-01f, 2.82530159e-01f, 2.00015113e-01f, 3.04155648e-01f, 1.22453049e-01f, -4.87898476e-03f, 1.39297679e-01f,
  5.10758944e-02f, 5.50374314e-02f, 2.72058785e-01f, 1.24610029e-01f, -1.39192209e-01f, 8.30907896e-02f, 9.21119526e-02f, -1.56569958e-01f, -9.65261385e-02f, -5.93024120e-02f,
  -3.55221689e-01f, 4.31304844e-03f, -8.02663863e-02f, 2.19721317e-01f, 8.41212422e-02f, 4.89174761e-02f, 1.24238515e-02f, -8.31589699e-02f, -1.15006238e-01f, 6.73439959e-03f,
  -3.97811443e-01f, 1.74512684e-01f, 3.37545797e-02f, 3.64836231e-02f, -1.09027065e-01f, 1.67997107e-02f, -6.44250363e-02f, -8.29093903e-02f, -3.26354295e-01f, -6.23988137e-02f,
  8.10494125e-02f, 3.65766138e-02f, 8.01763982e-02f, 3.29442322e-01f, -3.07710283e-03f, -3.04469168e-01f, -1.24478107e-02f, -2.47644931e-02f, 1.62307993e-02f, 4.40292526e-04f,
  1.19286306e-01f, -3.13259184e-01f, -5.39258480e-01f, -2.12386355e-01f, -2.52931148e-01f, -5.51701903e-01f, -1.21687829e-01f, -6.54724687e-02f, -1.06842108e-01f, -1.45325750e-01f,
  -5.27642727e-01f, -2.37406403e-01f, 8.80827680e-02f, 4.38932031e-01f, 5.16408980e-01f, 4.70385224e-01f, 4.26887900e-01f, 3.85307133e-01f, 3.36168110e-01f, 1.54481739e-01f,
  -3.06758638e-02f, 3.06566879e-02f, 7.99914598e-02f, 9.57147554e-02f, 1.29363656e-01f, 3.08184683e-01f, 5.62439919e-01f, 2.20847920e-01f, 2.47836754e-01f, 3.08702588e-01f,
  2.28542313e-01f, 1.55825377e-01f, 1.52087715e-02f, 6.69926107e-02f, 1.26562089e-01f, 3.44944537e-01f, 2.63480633e-01f, 2.96231538e-01f, 1.79136947e-01f, 3.26196492e-01f,
  -1.98295951e-01f, -3.66633922e-01f, 1.49089038e-01f, -5.44834659e-02f, -1.25375628e-01f, -2.69184053e-01f, 3.39698792e-02f, -8.85556564e-02f, -3.50542031e-02f, 5.66896349e-02f,
  -3.20159495e-02f, -1.18191823e-01f, -8.22787210e-02f, -2.50003841e-02f, 3.86961363e-02f, 1.95580628e-02f, -4.84011061e-02f, 1.57545224e-01f, 5.05824313e-02f, -6.14169650e-02f,
  -5.94433434e-02f, 1.11254513e-01f, 1.73578843e-01f, 1.07806526e-01f, -1.05806939e-01f, -1.26693519e-02f, -1.00518174e-01f, -1.16528906e-01f, 3.35911438e-02f, 1.62044857e-02f,
  1.85175583e-01f, -4.14868705e-02f, -5.14710434e-02f, 7.84028545e-02f, 2.44349241e-02f, -4.05257046e-02f, 1.89278841e-01f, 1.86197460e-01f, 7.62580559e-02f, 2.85123959e-02f,
  1.97131544e-01f, 9.87691507e-02f, 5.20132929e-02f, 1.34752452e-01f, -2.25672536e-02f, 1.25480533e-01f, 7.72223100e-02f, -4.54877988e-02f, -2.02795759e-01f, -6.36178181e-02f,
  1.23318862e-02f, 3.15469317e-02f, 5.15599027e-02f, -4.34255637e-02f, 8.82520676e-02f, 6.46032691e-02f, 8.69156942e-02f, 1.08876489e-01f, 2.54917648e-02f, 6.57845959e-02f,
  4.78578120e-01f, -2.10975096e-01f, -4.09068987e-02f, -9.43750143e-02f, -1.73162520e-02f, -1.79493904e-01f, -2.29766414e-01f, -3.87155600e-02f, -1.89467501e-02f, 1.36936307e-01f,
  -9.37922392e-03f, -2.41570160e-01f, -1.22280367e-01f, -2.15628296e-02f, 1.09734863e-01f, 5.64893745e-02f, -1.57851040e-01f, 5.75587749e-02f, 2.94144433e-02f, 4.70115878e-02f,
  -6.55631945e-02f, 3.16967160e-01f, 1.67013943e-01f, 1.65038899e-01f, 7.77199492e-02f, 6.79957047e-02f, 5.44784255e-02f, -5.30882403e-02f, 1.46816105e-01f, 5.82648031e-02f,
  1.26699194e-01f, 1.54578835e-01f, -6.72733843e-01f, 1.10635594e-01f, -3.72028708e-01f, -4.63226140e-01f, -2.41944253e-01f, 2.07893014e-01f, 3.79133403e-01f, 2.92989999e-01f,
  -7.63950311e-03f, -2.77350545e-01f, -4.03219402e-01f, -5.46741843e-01f, -5.09208381e-01f, -1.41256928e-01f, -2.37398103e-01f, -6.26221836e-01f, -7.22245634e-01f, -2.09072262e-01f,
  -1.76452488e-01f, -2.24455193e-01f, -2.89419651e-01f, -1.72188506e-01f, 1.13844804e-01f, -3.17821980e-01f, -2.13846192e-01f, -2.51027614e-01f, -4.06836092e-01f, -1.69035524e-01f,
  -4.96581435e-01f, -2.34178185e-01f, -3.75213146e-01f, 5.16056083e-03f, 8.87633953e-03f, 5.70087396e-02f, -1.99814528e-01f, -1.44509852e-01f, 1.90792009e-01f, 1.09024055e-01f,
  -1.94810390e-01f, 2.52426326e-01f, 3.46439555e-02f, -1.09941296e-01f, -1.41925678e-01f, -3.46470550e-02f, 1.46172857e-02f, -2.90046006e-01f, -2.56211888e-02f, 1.70678541e-01f,
  3.55765894e-02f, -4.86237735e-01f, -5.15382171e-01f, 1.14611544e-01f, -5.00106961e-02f, -2.85382330e-01f, -1.62481368e-01f, -1.95817709e-01f, -3.32698792e-01f, 1.93601757e-01f,
  2.15747625e-01f, 1.41076952e-01f, -4.65555210e-03f, 6.87969103e-02f, 1.62075832e-01f, -1.29125357e-04f, 1.82474852e-01f, -2.15550512e-02f, -2.88356375e-02f, 1.30170450e-01f,
  4.22961302e-02f, 1.78267896e-01f, 2.11274455e-04f, 3.66414860e-02f, -1.88327581e-01f, -1.00831635e-01f, 6.96338862e-02f, 2.19514985e-02f, -9.72191170e-02f, 7.07310662e-02f,
  -1.73857853e-01f, -7.82415196e-02f, -1.03094548e-01f, 2.26308294e-02f, -3.98428850e-02f, 1.80459749e-02f, -2.21059918e-02f, 1.38816327e-01f, 3.80757302e-02f, 8.77385512e-02f,
  -1.79359131e-02f, -3.39400411e-01f, -1.08079888e-01f, -1.06445469e-01f, -2.03893989e-01f, 5.03303818e-02f, 7.28408918e-02f, 8.32385495e-02f, 5.46566620e-02f, -2.66063921e-02f,
  -1.02153398e-01f, 1.72285095e-01f, -4.44824398e-02f, -1.27435938e-01f, -1.65871203e-01f, -1.20860167e-01f, 1.52359575e-01f, -1.77614063e-01f, -1.10705085e-01f, 2.19504073e-01f,
  2.59734124e-01f, -1.48359120e-01f, -2.15249807e-02f, 3.96531820e-03f, 2.32532937e-02f, -2.10343912e-01f, -1.90291911e-01f, -1.23838313e-01f, -1.13000020e-01f, 6.38668299e-01f,
  6.72826231e-01f, -4.60849814e-02f, 1.89198360e-01f, 2.22968012e-01f, 6.85425922e-02f, 1.22249454e-01f, 1.48715496e-01f, 4.16331403e-02f, -7.00600073e-03f, 6.67184591e-02f,
  1.86342016e-01f, 8.64898935e-02f, 3.38026658e-02f, 9.04386267e-02f, 1.70849904e-01f, -4.56006005e-02f, -8.05792585e-03f, 1.06796086e-01f, 1.81297243e-01f, 1.13498226e-01f,
  2.01300345e-02f, -4.92700143e-03f, 5.70922866e-02f, 1.28466591e-01f, -7.96425566e-02f, 1.50493858e-02f, -3.41273099e-02f, 6.76080436e-02f, -2.09776126e-02f, -3.12332548e-02f,
  2.13962600e-01f, 4.39146273e-02f, 1.10221758e-01f, 7.98042417e-02f, 6.21929765e-02f, 6.54303804e-02f, 1.25595301e-01f, -2.43600365e-02f, 5.31731397e-02f, -7.63852894e-02f,
  3.88967879e-02f, 2.43499149e-02f, -1.93798579e-02f, 1.84212867e-02f, 7.21484870e-02f, 5.79253510e-02f, -2.73718163e-02f, 4.59030420e-02f, 1.79895572e-02f, 5.77819422e-02f,
  -6.68255333e-03f, 7.79819414e-02f, 7.77746364e-02f, -7.20839426e-02f, 6.05341755e-02f, -3.85346524e-02f, 2.32871110e-03f, 2.78264321e-02f, -4.02756929e-02f, 5.96841872e-02f,
  1.36966527e-01f, 2.95134574e-01f, 3.50862652e-01f, 1.84790254e-01f, 1.79023519e-01f, 1.74069256e-01f, 1.03444934e-01f, 9.37007368e-02f, 1.97379351e-01f, 1.28786102e-01f,
  3.27575542e-02f, 2.04834446e-01f, 1.06598921e-01f, 2.07634956e-01f, 2.32945099e-01f, 2.56959498e-01f, 2.79704183e-01f, 1.64767787e-01f, 8.71048048e-02f, 5.73664084e-02f,
  2.00802177e-01f, -3.62003944e-03f, 6.91293478e-02f, -1.52868526e-02f, 7.18553513e-02f, 1.35380313e-01f, 1.11072704e-01f, 1.31509349e-01f, 1.10256866e-01f, 1.53851151e-01f,
  -2.13408813e-01f, -8.41994658e-02f, 1.43866360e-01f, -5.41747771e-02f, -1.03252186e-02f, -1.13102958e-01f, -1.08567744e-01f, -1.86016455e-01f, -1.87525973e-01f, -1.61653757e-01f,
  -1.22324735e-01f, -1.03098013e-01f, 2.82135922e-02f, -9.01739150e-02f, 3.70266773e-02f, 5.02652153e-02f, -1.30844459e-01f, -8.42225645e-03f, -5.29205911e-02f, -1.35963187e-01f,
  -1.46417573e-01f, 8.29177648e-02f, 1.02384679e-01f, 2.92568747e-02f, -1.17522851e-01f, 7.43019804e-02f, -1.24373190e-01f, 4.45977673e-02f, 1.40387937e-01f, 5.33860624e-02f,
  7.04555452e-01f, 2.20392555e-01f, 3.36607337e-01f, 1.25368223e-01f, -2.76743472e-02f, 3.44891613e-03f, -1.51120201e-01f, -1.21877857e-01f, 2.77688168e-02f, 6.20496199e-02f,
  1.79606944e-01f, 1.20832138e-01f, -2.19441741e-03f, 4.73184884e-02f, 2.37628873e-02f, -9.13731977e-02f, 9.56076290e-03f, 2.29948178e-01f, 1.11686759e-01f, 1.44866541e-01f,
  7.35294586e-03f, 2.01832965e-01f, 1.97935298e-01f, 1.24530114e-01f, 7.15872422e-02f, 4.58594561e-02f, 1.22026227e-01f, 1.92880914e-01f, 5.38054295e-02f, 1.60572886e-01f,
  4.11031187e-01f, 4.13863778e-01f, -7.24913925e-02f, 4.07132916e-02f, 7.26543292e-02f, 3.23252380e-02f, -8.98777414e-03f, 1.77124850e-02f, -4.47241291e-02f, 2.04471089e-02f,
  -6.19515264e-03f, 7.28883073e-02f, 1.04085661e-01f, 4.41420898e-02f, -1.44019509e-02f, -8.87544751e-02f, -7.51342177e-02f, -2.53670923e-02f, -6.55804668e-03f, 2.94253789e-02f,
  -4.29793485e-02f, 8.27486888e-02f, 4.72313352e-02f, -4.22829688e-02f, -9.69528686e-03f, 7.41216764e-02f, -3.70918028e-02f, 1.12466209e-01f, -3.82315665e-02f, 4.24695201e-02f,
  1.54020309e-01f, 1.65577233e-01f, 2.50828803e-01f, 2.13300526e-01f, 7.36466944e-02f, 3.80883217e-02f, -2.76350603e-02f, 2.82084048e-02f, 2.42546853e-02f, 1.09153673e-01f,
  1.82481168e-03f, 1.99026197e-01f, 6.83895079e-03f, 8.69820490e-02f, 4.11478579e-02f, 1.52592197e-01f, 7.58089647e-02f, -5.46494909e-02f, 4.18893024e-02f, -8.26702788e-02f,
  1.34715170e-01f, -9.67981294e-02f, 2.34491359e-02f, -9.77117792e-02f, 1.69475228e-02f, 1.08126506e-01f, 3.82150263e-02f, -2.35622972e-02f, 1.32022668e-02f, 1.50127903e-01f,
  -5.61553895e-01f, 7.45064318e-02f, 4.17002700e-02f, -6.19906001e-02f, 5.79829179e-02f, 4.58064899e-02f, 5.04034460e-02f, -9.73474085e-02f, -5.89057095e-02f, -1.19924322e-01f,
  -5.02516776e-02f, -4.23028804e-02f, -8.56292695e-02f, -1.02265239e-01f, -7.04212999e-03f, -4.81278598e-02f, -6.86511919e-02f, 1.35916276e-02f, -1.07567497e-01f, -1.87640954e-02f,
  -1.12488084e-01f, -8.62568468e-02f, -1.48426712e-01f, -2.38667414e-01f, -1.70585990e-01f, -8.66130665e-02f, -7.74737597e-02f, -8.58688354e-02f, -4.13626246e-02f, -1.86368957e-01f,
  -5.44384599e-01f, 5.72418809e-01f, 5.24857998e-01f, -5.41648805e-01f, -3.61770913e-02f, 3.59828830e-01f, 6.33400679e-01f, 1.09650210e-01f, -3.20640028e-01f, 7.81711489e-02f,
  -7.94768333e-02f, -4.17348891e-01f, -1.82771444e-01f, -1.35491014e-01f, 2.13971868e-01f, 3.73073012e-01f, 2.56556898e-01f, 1.81659862e-01f, -3.75135690e-02f, -2.42305353e-01f,
  -2.54060179e-01f, -2.03874648e-01f, -1.16685919e-01f, -1.24255702e-01f, -1.20071225e-01f, -2.28950888e-01f, 2.87813425e-01f, 1.71369538e-01f, 2.42673844e-01f, -4.21507619e-02f,
  -2.57445544e-01f, 2.38155037e-01f, -3.75039071e-01f, -2.99853891e-01f, 3.43690589e-02f, -2.57871211e-01f, -1.82503417e-01f, -6.35979101e-02f, 9.58677605e-02f, 3.08483839e-02f,
  -2.29645237e-01f, 6.02163523e-02f, 7.09994510e-02f, 1.56422019e-01f, 1.10684708e-02f, -6.34986162e-02f, 3.66480350e-02f, 1.70262545e-01f, 9.59414840e-02f, 2.13143960e-01f,
  -5.25989123e-02f, -7.19958469e-02f, 2.21756443e-01f, 2.06352189e-01f, 3.63430887e-01f, -1.87588960e-01f, 1.75848231e-01f, -9.19866711e-02f, 2.09239468e-01f, -2.66026616e-01f,
  -1.49824843e-01f, 1.04491428e-01f, 1.98775798e-01f, -3.54124904e-02f, -3.60572785e-02f, -1.09723307e-01f, 2.37020869e-02f, -1.17447926e-03f, -1.01657659e-02f, -1.74950495e-01f,
  -2.08157182e-01f, -5.41327149e-02f, -1.26978680e-01f, -1.38310403e-01f, -1.75476640e-01f, 2.95667257e-03f, -2.25938149e-02f, 1.03974633e-01f, 1.65560260e-01f, 1.05979845e-01f,
  -4.48805727e-02f, 6.84869662e-02f, -4.96909879e-02f, -7.20991148e-03f, -1.86134949e-02f, -9.55928583e-03f, -1.73311442e-01f, -3.61482538e-02f, -4.46861759e-02f, -6.96674511e-02f,
  -5.53100586e-01f, 4.16595697e-01f, -3.70228171e-01f, 3.90929058e-02f, 5.84551618e-02f, 1.40633523e-01f, 1.24343287e-03f, 2.71096472e-02f, 5.01835048e-02f, -1.71694934e-01f,
  1.01491787e-01f, -2.18730733e-01f, -6.79947063e-02f, 1.64924040e-02f, -3.75659525e-01f, -1.29035443e-01f, -4.27679904e-02f, -3.37474436e-01f, 3.15895788e-02f, -9.22361538e-02f,
  3.10877282e-02f, -1.53986320e-01f, -3.95109057e-01f, -1.63274974e-01f, -2.14820504e-01f, -6.14969969e-01f, -3.41684103e-01f, -2.26877570e-01f, -7.29683554e-03f, -2.28978574e-01f,
  1.13675845e+00f, -4.08217877e-01f, -5.19594491e-01f, 2.51930535e-01f, -2.07345590e-01f, -3.94742966e-01f, -8.50651383e-01f, -4.26025420e-01f, 3.55730027e-01f, -4.32108790e-01f,
  1.64992988e-01f, 9.95104909e-01f, 5.04042566e-01f, 3.17493789e-02f, -3.76664996e-01f, -8.04688931e-01f, -7.12637424e-01f, -3.80595624e-01f, -2.10696012e-01f, -2.23552495e-01f,
  5.18253334e-02f, -5.86066023e-03f, -1.03186360e-02f, -1.87594905e-01f, -1.63709641e-01f, 3.04841816e-01f, -4.91109103e-01f, -2.40602225e-01f, -5.07557213e-01f, -2.04055265e-01f,
  -3.38476896e-01f, -1.52681902e-01f, -1.47476375e-01f, 1.98918909e-01f, 7.47053698e-02f, 2.37113163e-01f, -7.00475425e-02f, -2.85349339e-01f, 1.03684127e-01f, -2.11562380e-01f,
  2.04547822e-01f, 6.52099177e-02f, 1.00679472e-01f, 4.66774888e-02f, -1.75734922e-01f, -1.79511368e-01f, -3.20301712e-01f, -3.42452854e-01f, -1.27849907e-01f, -3.22317183e-01f,
  5.81808202e-03f, 6.22896403e-02f, -1.93854854e-01f, -3.69106323e-01f, -4.10153061e-01f, 1.95426911e-01f, -4.96616215e-01f, -2.03946754e-01f, -3.27622205e-01f, -3.38002503e-01f,
  -1.30344376e-01f, -5.92934377e-02f, -1.99193776e-01f, -4.80434820e-02f, -6.00497611e-02f, -3.24800126e-02f, 4.44077067e-02f, -2.01375023e-01f, 1.56245772e-02f, -1.66510016e-01f,
  -3.81325595e-02f, -4.11879420e-02f, 1.32340387e-01f, -2.51858145e-01f, -1.74744561e-01f, -2.15184361e-01f, -6.03268854e-02f, -2.13343889e-01f, -2.10754782e-01f, 1.10121323e-02f,
  -3.59533611e-03f, -4.44251150e-02f, 1.11247867e-01f, 7.24730939e-02f, -9.11465380e-03f, -3.20233107e-02f, 1.42345773e-02f, -8.52132142e-02f, 6.03397191e-02f, -2.54226625e-01f,
  3.82497042e-01f, 4.97904718e-02f, 1.28974453e-01f, -8.21432769e-02f, -1.87888309e-01f, 1.12200022e-01f, 1.55154586e-01f, -2.56679147e-01f, 1.61439955e-01f, -2.02410389e-02f,
  -1.58461794e-01f, 9.04946327e-02f, 5.95461286e-04f, 9.39721614e-03f, -1.18906789e-01f, -9.10009909e-03f, -3.08369212e-02f, 1.63531214e-01f, -7.23428726e-02f, -2.31752498e-03f,
  -1.47220761e-01f, -2.44539797e-01f, 2.93225110e-01f, 2.20669992e-02f, -1.71101063e-01f, 2.74996042e-01f, -2.76831210e-01f, -2.48338178e-01f, 6.85217557e-03f, -4.25951421e-01f,
  5.18468082e-01f, -5.51510036e-01f, -1.82962880e-01f, 9.86561086e-03f, 1.02059759e-01f, 2.38567755e-01f, -6.40471503e-02f, 1.71444882e-02f, 9.65676606e-02f, -2.21623592e-02f,
  -7.22489282e-02f, 2.10532829e-01f, 2.00252458e-01f, 1.40451908e-01f, 5.14689460e-02f, -2.58559757e-03f, -2.11684275e-02f, 8.99456665e-02f, 1.43189296e-01f, 1.12405106e-01f,
  -1.44057602e-01f, -2.49303132e-01f, -9.07969922e-02f, -2.25184023e-01f, -4.82321322e-01f, -5.70628457e-02f, -2.60604650e-01f, -2.07138866e-01f, -2.97441125e-01f, -4.06145483e-01f,
  -4.33985502e-01f, -1.07921004e-01f, 7.12587908e-02f, -7.72317797e-02f, -4.87917922e-02f, -3.32337245e-02f, 7.81773031e-02f, -1.32653743e-01f, 5.22108637e-02f, 2.97474619e-02f,
  1.50292758e-02f, -5.17284311e-02f, 2.23365203e-02f, -5.30733429e-02f, -1.16546914e-01f, -1.97500940e-02f, -6.82493746e-02f, 2.62615848e-02f, -3.37554701e-02f, -9.59772393e-02f,
  -1.07888028e-01f, 5.30232815e-03f, -3.30848061e-02f, 1.93731003e-02f, 2.43610606e-01f, 1.34392947e-01f, -1.02196261e-01f, 2.37898319e-03f, 1.89128399e-01f, 7.71170706e-02f,
  6.86272606e-02f, -5.78742027e-02f, 2.56202407e-02f, 1.49838044e-03f, 1.27294973e-01f, 4.48408164e-03f, 7.24996105e-02f, -2.66572274e-03f, 7.18261972e-02f, -3.07321753e-02f,
  -7.43508758e-03f, 1.44236952e-01f, 7.63725266e-02f, -3.10356729e-02f, -1.03550538e-01f, -4.63065272e-03f, -9.09843743e-02f, -8.27619284e-02f, 2.51669213e-02f, -4.82174344e-02f,
  1.50685310e-01f, -1.13102846e-01f, -1.40626237e-01f, -1.21791184e-01f, -9.16362330e-02f, 3.39142084e-02f, -9.22183469e-02f, -9.89332572e-02f, 3.33431400e-02f, -1.20042644e-01f,
  -3.37267220e-01f, 3.42793167e-01f, 9.28120017e-02f, 1.57205418e-01f, -4.44082245e-02f, -1.10157117e-01f, 1.08658768e-01f, -1.20503940e-01f, -1.16670184e-01f, -6.03919886e-02f,
  -1.18915305e-01f, -9.59694758e-02f, -1.86392412e-01f, -7.13955685e-02f, 1.41874209e-01f, 1.03815958e-01f, 1.46300010e-02f, 7.40875006e-02f, 4.23549302e-03f, -8.08474347e-02f,
  3.19580315e-03f, 1.52185678e-01f, 1.95736140e-01f, 2.07227319e-01f, 1.31563559e-01f, 2.16155440e-01f, -1.36427460e-02f, 8.17331374e-02f, 5.60951345e-02f, 3.37936878e-02f,
  -8.29601288e-01f, -4.71998364e-01f, 1.82744220e-01f, -6.30124360e-02f, 5.13319135e-01f, -2.23136291e-01f, -9.87083256e-01f, -6.06370986e-01f, -6.60294667e-02f, -1.89860240e-01f,
  4.42569882e-01f, 4.44809616e-01f, 2.56701596e-02f, -9.29964855e-02f, -5.95550418e-01f, -5.04889190e-01f, -1.87020972e-01f, -2.23514691e-01f, -1.60003811e-01f, 5.68712689e-02f,
  2.29188651e-01f, 2.52777841e-02f, -1.17164582e-01f, -9.46566686e-02f, 2.37238526e-01f, 3.19731414e-01f, 2.51282156e-01f, 1.75407887e-01f, 1.01705357e-01f, 1.58857718e-01f,
  -5.48329167e-02f, -3.97948742e-01f, 3.48597020e-02f, 4.84672397e-01f, 4.80592728e-01f, -2.72856474e-01f, -3.02480847e-01f, -3.58076058e-02f, -9.85340327e-02f, -2.44714350e-01f,
  4.16580945e-01f, 1.82862148e-01f, 1.36331776e-02f, 4.58974987e-02f, -1.20802604e-01f, -3.27353328e-01f, 7.17323124e-02f, -3.34711701e-01f, -3.00675273e-01f, 8.18868652e-02f,
  4.81890529e-01f, 2.45136961e-01f, -4.66817290e-01f, -3.22226673e-01f, -4.61916864e-01f, 3.70402746e-02f, -2.26226985e-01f, -2.09751993e-01f, -6.60143912e-01f, -6.87281787e-01f,
  3.34121063e-02f, 5.85597381e-02f, 7.67725259e-02f, 4.45241332e-02f, -7.36179724e-02f, 4.82526943e-02f, 3.81348431e-02f, 6.72040731e-02f, 1.46561703e-02f, -4.40129004e-02f,
  2.91163530e-02f, -6.41452074e-02f, 5.12199383e-03f, -1.10834628e-01f, -7.66676292e-03f, 1.03275917e-01f, 2.46189777e-02f, -4.08105366e-02f, 1.49443792e-02f, -9.81143583e-03f,
  3.94051475e-03f, 9.07885656e-03f, 1.84059143e-01f, -3.60910483e-02f, -1.76516790e-02f, -9.93451402e-02f, 2.02754457e-02f, 1.06775187e-01f, -1.06059927e-02f, 9.84626170e-03f,
  -7.70708993e-02f, 1.48750231e-01f, -3.38499427e-01f, -6.98316693e-02f, 7.74859264e-02f, 2.61825264e-01f, 3.74164782e-03f, 6.24914914e-02f, 1.26883283e-01f, -9.12706777e-02f,
  -9.16325226e-02f, -3.13829690e-01f, -5.37388362e-02f, 2.12534796e-02f, -4.22264123e-03f, -7.56106386e-03f, 3.85171510e-02f, 6.89906031e-02f, -1.39103323e-01f, 1.02791838e-01f,
  -1.97255448e-01f, -3.55684489e-01f, -6.44740403e-01f, -4.66652453e-01f, -2.71971196e-01f, -3.43895495e-01f, -4.58192885e-01f, -2.29029253e-01f, -5.99033058e-01f, -8.65112066e-01f,
  -8.23089838e-01f, -5.53427264e-02f, 3.15379709e-01f, -5.04349649e-01f, 3.86903584e-01f, 6.17981434e-01f, 7.22900271e-01f, 2.50645995e-01f, -1.43209919e-01f, 3.69835384e-02f,
  -8.69665295e-02f, -4.27332997e-01f, -4.37373549e-01f, -2.42560551e-01f, -2.31246222e-02f, 3.86885732e-01f, 2.99229145e-01f, -3.93014960e-02f, -7.42677087e-03f, 2.49517336e-01f,
  9.68608186e-02f, -1.97761044e-01f, -3.81233156e-01f, -2.14025050e-01f, -2.40601361e-01f, -1.16666347e-01f, 1.40514029e-02f, -1.29462644e-01f, 1.34060785e-01f, -1.21479921e-01f,
  2.46746302e-01f, -2.32474908e-01f, 1.77235514e-01f, -1.49708986e-01f, -3.65578197e-02f, -1.74122438e-01f, 8.81056413e-02f, -1.00449391e-01f, -1.58435285e-01f, -8.34080949e-02f,
  -1.15025856e-01f, -5.03235906e-02f, -2.14089319e-01f, 2.76380987e-03f, 5.89971663e-03f, -7.11616054e-02f, -2.13483989e-01f, -2.72273988e-01f, -1.31407648e-01f, 6.40662536e-02f,
  7.06005916e-02f, -2.41386835e-02f, 7.56872967e-02f, 5.13972994e-03f, -1.64388984e-01f, -1.85096785e-01f, -5.47828600e-02f, 7.30242115e-03f, -1.01070985e-01f, -1.19083695e-01f,
  8.05833265e-02f, 6.43851096e-03f, -7.21621364e-02f, 5.47237061e-02f, -1.04045019e-01f, 7.41851865e-04f, 1.48583818e-02f, -1.07010707e-01f, 8.68880674e-02f, -7.66308466e-03f,
  -6.18175156e-02f, -5.22845564e-03f, -3.56272347e-02f, -3.49436924e-02f, -1.23976775e-01f, -1.15421683e-01f, 5.90197183e-02f, -4.81292643e-02f, -4.42058928e-02f, -6.37745857e-02f,
  -3.78022939e-02f, 2.35439446e-02f, -1.31848633e-01f, 5.21725863e-02f, -8.97869561e-03f, -5.53664938e-02f, -7.43131414e-02f, 1.56969279e-02f, -4.11101878e-02f, 1.05987415e-01f,
  -4.43007350e-02f, -6.95323870e-02f, 1.14527777e-01f, -7.79383704e-02f, 1.12287118e-03f, -1.19959470e-02f, -5.90143315e-02f, 1.71243539e-03f, -1.19657271e-01f, 8.92868116e-02f,
  2.27351859e-02f, -5.47190048e-02f, -1.06391072e-01f, 6.28109276e-02f, 1.13103822e-01f, 1.35384843e-01f, 7.74382651e-02f, -1.15252342e-02f, -4.41821478e-02f, 1.06213717e-02f,
  1.31665794e-02f, 1.18830420e-01f, 5.16466238e-02f, 9.03419182e-02f, 3.56084742e-02f, 4.19924930e-02f, 1.74618348e-01f, 2.65734315e-01f, 1.75305352e-01f, 3.74472588e-01f,
  -6.77960038e-01f, -5.47742248e-02f, -4.05621044e-02f, -4.82166320e-01f, 1.47574479e-02f, 4.78599876e-01f, 2.26180777e-01f, 2.07307547e-01f, 7.48022739e-03f, 4.00447636e-04f,
  3.04574426e-02f, -2.53514409e-01f, -4.52249974e-01f, -1.79129794e-01f, -2.18917370e-01f, -3.20988923e-01f, -4.25094187e-01f, -4.68994498e-01f, -2.15240210e-01f, 1.45230725e-01f,
  4.81666028e-02f, -3.73204380e-01f, -1.78801641e-01f, -5.55207692e-02f, -1.75112844e-01f, -3.25264215e-01f, -1.17154941e-01f, -1.04508922e-01f, 8.03228766e-02f, -3.90273482e-01f,
  -3.41599077e-01f, 2.17618212e-01f, 2.24526301e-02f, -1.65352672e-01f, -6.05436694e-03f, 3.56806666e-02f, 3.62167098e-02f, -3.61032337e-02f, -5.61608188e-02f, -4.71628420e-02f,
  5.62203042e-02f, 2.09110137e-02f, -1.01403438e-01f, -2.28258930e-02f, 6.57407716e-02f, -9.11551341e-03f, 4.07970771e-02f, -1.39856204e-01f, 3.31271589e-02f, 3.13147902e-01f,
  2.16040701e-01f, -1.77216846e-02f, 2.22388189e-02f, 2.08413839e-01f, 2.49352947e-01f, 8.74609351e-02f, 1.49357572e-01f, 2.67452419e-01f, 1.36342958e-01f, -1.50784343e-01f,
  2.29766872e-02f, -1.14849232e-01f, -3.82469110e-02f, 2.60523744e-02f, 4.67970669e-02f, -5.69635257e-02f, -7.70071074e-02f, -9.06386748e-02f, 3.68232094e-02f, -6.04715124e-02f,
  -6.19494282e-02f, 5.71256392e-02f, -8.19493905e-02f, -2.56429520e-02f, 1.74955688e-02f, -4.88314182e-02f, 1.17423600e-02f, 4.19898629e-02f, 6.31896481e-02f, -1.92157160e-02f,
  -2.70238761e-02f, 1.29102454e-01f, -1.03023030e-01f, -2.53511388e-02f, 7.56455883e-02f, 8.63194582e-04f, 1.44162595e-01f, 2.03668639e-01f, 3.83440889e-02f, 9.20467749e-02f,
  -6.83740437e-01f, 8.29218701e-02f, -3.27670544e-01f, -6.97322786e-02f, -1.82415601e-02f, 1.37833774e-01f, -3.09060831e-02f, -4.45078220e-03f, -1.17102407e-01f, 2.02775523e-02f,
  2.33142421e-01f, -8.23926255e-02f, -1.09162852e-01f, -1.72587903e-03f, -6.92259073e-02f, 5.16512133e-02f, 2.70582177e-03f, -2.21150056e-01f, 9.20671076e-02f, 2.28040874e-01f,
  1.11268021e-01f, -4.67117168e-02f, -2.84471512e-01f, -6.71270937e-02f, 1.90937802e-01f, -4.53196391e-02f, -5.88348359e-02f, -4.04363275e-02f, -6.36692066e-03f, -4.00457501e-01f,
  2.13387057e-01f, -3.96954507e-01f, 4.16610628e-01f, -6.65247738e-02f, 4.59217101e-01f, 5.49338162e-01f, 5.11362612e-01f, 1.22992732e-01f, -1.38167841e-02f, -2.07088932e-01f,
  -3.99451405e-01f, -4.61515188e-01f, -5.31302154e-01f, -3.51886719e-01f, -1.65473938e-01f, 2.12460712e-01f, 1.76431090e-01f, 1.77481204e-01f, 3.23424965e-01f, 4.04217690e-01f,
  -1.21225044e-01f, 3.98151483e-03f, -6.84029460e-02f, -5.74732274e-02f, -1.36210635e-01f, -2.04231486e-01f, -1.91071332e-02f, 1.23150393e-01f, -7.77927786e-02f, -2.94488579e-01f,
  -2.31289983e-01f, -5.97246438e-02f, 8.61626118e-03f, -2.14737266e-01f, -5.96642159e-02f, -4.41175066e-02f, 3.00775506e-02f, -1.28960744e-01f, -9.46921185e-02f, 9.16360244e-02f,
  -6.05611466e-02f, -7.28903115e-02f, -3.48446667e-02f, -1.02237500e-01f, 1.17045455e-01f, 1.01355217e-01f, 2.10792813e-02f, -4.86013032e-02f, -7.11511672e-02f, -1.14452772e-01f,
  -2.27268547e-01f, 4.76868674e-02f, 1.33404180e-01f, -8.75032227e-03f, 1.02339976e-01f, -2.59998608e-02f, 8.16862509e-02f, 5.97653091e-02f, 1.13508031e-01f, 2.83591952e-02f,
  4.45534252e-02f, -4.33931360e-03f, -9.61877108e-02f, -7.34921992e-02f, 3.87530252e-02f, 1.88585296e-02f, -1.05986483e-02f, 3.15958336e-02f, 4.92884256e-02f, 8.31705108e-02f,
  -6.82847351e-02f, -1.18117400e-01f, -1.02916583e-01f, -4.36189622e-02f, -2.31795102e-01f, -9.29478258e-02f, 9.68398228e-02f, -1.68041915e-01f, -9.67677459e-02f, -5.87739684e-02f,
  -4.53169383e-02f, 2.20902264e-03f, 3.03126033e-03f, -8.97421390e-02f, -7.43131936e-02f, -6.15215078e-02f, -5.75630786e-03f, -1.00011893e-01f, -6.48092702e-02f, -2.87506990e-02f,
  -6.32215500e-01f, 1.14309741e-02f, -7.25988522e-02f, -1.66089416e-01f, -2.92112306e-03f, -1.03881873e-01f, -2.33496889e-01f, -9.58063453e-03f, 5.22035249e-02f, 3.21078822e-02f,
  1.46203399e-01f, -6.37832880e-02f, -1.82826236e-01f, -4.54616994e-02f, 1.55058950e-01f, 1.55339137e-01f, 2.21096464e-02f, -1.40850246e-01f, -1.11440467e-02f, -2.56998837e-02f,
  -1.56456798e-01f, 2.16988578e-01f, 1.43463552e-01f, -9.59364846e-02f, 8.78349394e-02f, 5.07161617e-02f, 1.33460402e-01f, 1.11813480e-02f, 2.73247540e-01f, 1.73756346e-01f,
  -8.78637016e-01f, 5.92094123e-01f, -3.80371898e-01f, -1.86447427e-01f, 1.03593111e-01f, 2.47849394e-02f, 6.47996426e-01f, 1.86853603e-01f, 2.21264243e-01f, 5.48871100e-01f,
  -4.85614948e-02f, -2.76913404e-01f, -1.52029365e-01f, -6.53892234e-02f, -3.58580798e-02f, 8.08674157e-01f, 6.69187546e-01f, -4.58452493e-01f, -8.62279892e-01f, -2.95832306e-01f,
  3.44599575e-01f, -8.19072649e-02f, -5.99584281e-01f, -2.86474228e-01f, 1.49262026e-01f, -5.76461181e-02f, 2.34929204e-01f, -2.07489014e-01f, 8.70249271e-02f, 2.05764592e-01f,
  -2.70443648e-01f, -4.05249774e-01f, -9.57247242e-02f, -2.39992440e-01f, -5.19603528e-02f, -8.99193138e-02f, -1.47295713e-01f, -1.91973120e-01f, -6.81732520e-02f, -1.90204624e-02f,
  -1.49439737e-01f, -1.75129369e-01f, -1.93663925e-01f, -1.00993119e-01f, -1.98959246e-01f, -1.59397542e-01f, 2.18557492e-02f, -1.56311154e-01f, -1.82406768e-01f, -1.10511668e-01f,
  1.13285311e-01f, -4.12124932e-01f, -3.17247957e-01f, 6.70480877e-02f, -1.96882352e-01f, -2.91987926e-01f, -1.64010897e-01f, -3.26944619e-01f, -4.11248326e-01f, 9.48759839e-02f,
  1.46264974e-02f, -4.05997671e-02f, 1.70906950e-02f, 1.06057547e-01f, 1.19733974e-01f, -3.17254215e-02f, -1.35430163e-02f, -1.66385341e-02f, -7.87868053e-02f, -2.28393860e-02f,
  -1.92054018e-01f, -3.81676741e-02f, -7.58787096e-02f, 2.62188143e-03f, 5.15319817e-02f, -8.73892605e-02f, 7.54229212e-03f, 2.12070331e-01f, -7.06448555e-02f, 6.53658733e-02f,
  -1.35888811e-02f, -7.98210800e-02f, -3.06727737e-02f, 8.44653174e-02f, 1.15474805e-01f, -9.63794217e-02f, 9.29450467e-02f, -1.98780552e-01f, -8.86996314e-02f, 3.64372097e-02f,
  4.68986213e-01f, -1.35497063e-01f, 3.10546458e-01f, 3.00776213e-02f, 6.23268001e-02f, 1.51335029e-02f, 1.00262485e-01f, 6.76338747e-02f, 9.05574206e-03f, -1.78996116e-01f,
  -1.72138646e-01f, -1.16613783e-01f, 1.40614808e-01f, -1.62654854e-02f, -1.20793231e-01f, -6.51357248e-02f, 2.96852171e-01f, 1.84034836e-03f, 1.72096625e-01f, 1.45939618e-01f,
  3.24384779e-01f, 1.80450097e-01f, 1.91843808e-01f, 3.28463644e-01f, 1.54384181e-01f, 9.82608125e-02f, 1.16643786e-01f, 1.45390287e-01f, 8.75724480e-02f, 6.52918816e-01f,
  -8.57327953e-02f, 2.34441802e-01f, -6.68233275e-01f, -2.40057651e-02f, 1.33930117e-01f, 2.75172055e-01f, 5.01879692e-01f, 4.15311456e-01f, -1.82536896e-02f, -1.88815710e-03f,
  -2.90285442e-02f, -2.80201226e-01f, -3.31070036e-01f, -1.40525907e-01f, 1.45144194e-01f, 9.22452752e-03f, -2.05760241e-01f, -3.73607367e-01f, -6.22098111e-02f, 3.32939237e-01f,
  2.12248817e-01f, 1.52618289e-01f, -1.84935629e-02f, -1.64869986e-02f, -1.24737881e-01f, -2.36684784e-01f, -4.60074127e-01f, -1.28671557e-01f, -1.90442175e-01f, -3.73432726e-01f,
  -5.09546161e-01f, 2.76372284e-02f, 7.24634677e-02f, 6.70822337e-02f, 5.19149080e-02f, 7.39113539e-02f, 1.59557670e-01f, 7.65735954e-02f, 8.37632418e-02f, 1.48239359e-01f,
  7.31991902e-02f, 6.68022186e-02f, 1.88685104e-01f, 1.86593458e-02f, 3.64145190e-02f, 9.15598571e-02f, -6.50990978e-02f, 7.67685920e-02f, -2.97237299e-02f, 1.69462431e-02f,
  9.07365903e-02f, -6.89519569e-02f, -4.93365489e-02f, 1.37493029e-01f, 1.39844408e-02f, -1.34709895e-01f, -5.26501890e-03f, 7.87344482e-03f, -1.06863886e-01f, -1.74770560e-02f,
  4.46934626e-02f, 1.77251678e-02f, 1.87695548e-01f, 5.94044700e-02f, 6.05346151e-02f, 8.68029520e-02f, -4.37999368e-02f, 3.15851346e-02f, 1.51597381e-01f, 1.52607173e-01f,
  1.14086106e-01f, -1.05384670e-01f, -3.65654603e-02f, 3.41740549e-02f, -1.61917970e-01f, -5.77076562e-02f, -1.06673762e-01f, -2.55224369e-02f, 3.26438174e-02f, 1.25410691e-01f,
  -7.50402585e-02f, -3.17007490e-02f, -1.06903315e-01f, -1.64314043e-02f, -2.85943355e-02f, -5.45012094e-02f, -3.90396304e-02f, -1.52843688e-02f, 6.87080622e-03f, 5.42981038e-03f,
  -1.58585031e-02f, -7.74836242e-02f, -3.82432304e-02f, -1.55217692e-01f, -1.24642648e-01f, -1.55808479e-01f, -2.60361850e-01f, -2.00793043e-01f, 1.79712195e-02f, 1.67363137e-02f,
  6.95306584e-02f, -6.44894615e-02f, 1.33303732e-01f, 8.40762481e-02f, 4.76484944e-04f, -3.42735834e-02f, 1.41204679e-02f, -1.03207767e-01f, -2.76248436e-03f, 2.43307166e-02f,
  7.72977397e-02f, 6.71967715e-02f, -4.96231616e-02f, 2.94994880e-02f, 4.46956381e-02f, -9.12916139e-02f, 7.78015750e-03f, -7.58904442e-02f, -1.81206718e-01f, 1.03028998e-01f,
  4.19707149e-01f, 6.30642653e-01f, 1.75331026e-01f, -1.47880027e-02f, 9.90741253e-02f, 7.13973641e-02f, 3.92039299e-01f, -5.69782183e-02f, -2.15761110e-01f, 1.95687354e-01f,
  1.30635530e-01f, -3.24110836e-01f, -7.62158185e-02f, -2.55959153e-01f, -4.31696512e-02f, 6.98569566e-02f, 3.26423789e-04f, -1.23373039e-01f, -4.15118009e-01f, -1.10427454e-01f,
  1.73201002e-02f, -6.28920570e-02f, -1.39971614e-01f, -1.23304144e-01f, 2.06300825e-01f, -2.70270467e-01f, 2.65504010e-02f, 2.82027960e-01f, 2.83822328e-01f, 4.66218442e-01f,
  2.28676334e-01f, 3.76623720e-01f, -5.49590349e-01f, 1.13945175e-03f, 1.58693552e-01f, -1.05582580e-01f, -1.90496415e-01f, -1.42887443e-01f, -6.67826086e-02f, -6.46197796e-02f,
  1.68434724e-01f, -1.74009185e-02f, 1.14798404e-01f, 7.35835824e-03f, 9.85312238e-02f, -2.23307777e-02f, -4.33516391e-02f, -9.43241343e-02f, -1.20486468e-01f, 4.15989645e-02f,
  2.56797727e-02f, 2.79054612e-01f, 1.59159422e-01f, -1.12022087e-01f, 3.70088480e-02f, -1.75153285e-01f, 1.42094433e-01f, 7.81364217e-02f, -1.76499277e-01f, 6.94060093e-03f,
  -3.80925775e-01f, -1.51736308e-02f, -4.46203500e-02f, -1.66890115e-01f, -1.88289747e-01f, -1.93377316e-01f, 5.18072303e-03f, 5.54987043e-02f, -1.06467642e-01f, -6.84172511e-02f,
  -1.20234311e-01f, -1.78431720e-01f, -7.69525841e-02f, -1.93795666e-01f, -2.02547818e-01f, 3.90572809e-02f, 6.45374507e-02f, -9.22760516e-02f, -1.05584942e-01f, -1.50903463e-01f,
  -8.47199857e-02f, -2.85152365e-02f, -9.01328623e-02f, -7.64129534e-02f, -1.64063171e-01f, -1.72213897e-01f, -2.23216236e-01f, -2.12616161e-01f, -1.07772194e-01f, 2.65712719e-02f,
  -4.03010696e-01f, -3.81874472e-01f, -1.61285862e-01f, 1.35389298e-01f, 3.40729624e-01f, 8.20372477e-02f, 3.84664163e-02f, 3.77972163e-02f, 1.69189066e-01f, 1.97692402e-02f,
  9.22536626e-02f, 4.46832813e-02f, 1.28329486e-01f, -2.53591649e-02f, -1.82686329e-01f, -5.68079129e-02f, 5.30026183e-02f, -8.64711031e-02f, -1.62486896e-01f, 1.07198901e-01f,
  -2.40775589e-02f, -1.76326185e-01f, -4.06270772e-01f, -3.12059999e-01f, -1.56228289e-01f, -5.10952592e-01f, -2.94216543e-01f, -1.90481260e-01f, -2.82102764e-01f, -3.89631122e-01f,
  -1.00848937e+00f, 6.24261238e-02f, 6.49179280e-01f, -1.54426247e-01f, 3.40627998e-01f, -2.21390828e-01f, -4.26216751e-01f, -4.77553874e-01f, -2.77637452e-01f, -1.44942716e-01f,
  -6.52464330e-02f, -7.35273808e-02f, 2.88532138e-01f, 1.38596788e-01f, -1.74246326e-01f, 1.30328253e-01f, 6.70654356e-01f, 3.29186618e-01f, -2.81979710e-01f, -7.16338038e-01f,
  -1.81411877e-01f, -1.27757251e-01f, -2.34316960e-01f, -7.39964694e-02f, 1.57241121e-01f, 8.30401108e-02f, 4.44525898e-01f, 3.36559355e-01f, 8.04885477e-02f, 4.55526143e-01f,
  -1.69238359e-01f, -2.53636569e-01f, 1.09877475e-01f, 3.04223765e-02f, 2.62702972e-01f, -3.88717443e-01f, -3.18196416e-01f, 2.19372496e-01f, -6.90178201e-02f, -3.14742476e-02f,
  2.17325687e-01f, -2.73802113e-02f, 1.50315151e-01f, -2.70832509e-01f, -4.44001257e-01f, -3.82822692e-01f, 3.54429218e-03f, -2.61348516e-01f, -5.47485566e-03f, -5.14429629e-01f,
  1.21169575e-01f, -1.05009854e-01f, 6.55880794e-02f, -2.91336954e-01f, -2.34122381e-01f, 1.14949077e-01f, -9.03376713e-02f, -5.08532584e-01f, -3.20966572e-01f, -4.65353340e-01f,
  8.37501436e-02f, 9.24253762e-02f, 1.08627863e-01f, 2.74192214e-01f, -1.41422391e-01f, 8.34665522e-02f, 1.68426260e-01f, 7.90070668e-02f, 4.74709272e-02f, -8.18328932e-02f,
  1.05775461e-01f, -1.13611937e-01f, -8.65879133e-02f, 3.35263647e-02f, -3.17353057e-04f, 1.67288855e-02f, -6.20373338e-02f, 5.11920229e-02f, 1.46876037e-01f, -8.01423714e-02f,
  -2.50641424e-02f, 9.03234333e-02f, 1.80344343e-01f, -1.21212281e-01f, 3.70931290e-02f, 2.05693930e-01f, -3.31796939e-03f, -6.46852031e-02f, 5.38744032e-02f, 1.32914810e-02f,
  -2.66213506e-01f, 3.26672494e-01f, -2.19491586e-01f, -1.71765581e-01f, -4.82505448e-02f, 3.67901661e-02f, 1.04015402e-01f, -3.14484090e-02f, 8.13984349e-02f, -1.71692640e-01f,
  -2.38679156e-01f, -1.17188573e-01f, 2.46002004e-01f, 1.47684991e-01f, -3.88507873e-01f, -4.97474633e-02f, 1.37299687e-01f, -3.21481340e-02f, -1.92146897e-01f, -2.12082580e-01f,
  1.68907344e-01f, -5.54885864e-01f, -4.98344034e-01f, -4.23444510e-01f, -3.47270340e-01f, -4.40248281e-01f, -1.65130466e-01f, -4.35906708e-01f, -3.31203610e-01f, -7.53362775e-01f,
  2.78885186e-01f, -3.92948329e-01f, -7.01384306e-01f, -2.61099577e-01f, -5.02368212e-01f, -4.07755911e-01f, -5.37429154e-01f, -2.91507244e-02f, -4.91895974e-02f, -5.88179290e-01f,
  -2.93056995e-01f, 5.28809845e-01f, 1.27110139e-01f, 1.61445305e-01f, 2.83086628e-01f, -7.13883460e-01f, -7.28711903e-01f, -1.68538347e-01f, 2.22880259e-01f, 1.53022259e-01f,
  -4.38638479e-02f, -9.71995592e-02f, 9.83620137e-02f, -1.65578410e-01f, -4.05733973e-01f, -5.80169335e-02f, -6.34621322e-01f, -4.09449518e-01f, -3.57686758e-01f, -6.52490377e-01f,
  -4.97603677e-02f, -1.40487015e-01f, 2.68887598e-02f, 6.36325032e-02f, -1.43159464e-01f, 4.40030806e-02f, 5.33102266e-02f, -1.91930551e-02f, -3.95419113e-02f, -1.11174852e-01f,
  -1.13071591e-01f, 8.78392607e-02f, 1.87736601e-01f, -1.15553133e-01f, -5.29549010e-02f, 2.28815302e-02f, -7.47828856e-02f, -6.28684014e-02f, -1.28341854e-01f, -8.38586986e-02f,
  -1.38884693e-01f, -1.77567139e-01f, -3.36568058e-02f, -1.70796424e-01f, -1.03472888e-01f, -8.64243135e-02f, -7.50384554e-02f, -4.21927199e-02f, -1.59448281e-01f, -3.09657812e-01f,
  -1.47309139e-01f, -4.70584668e-02f, 5.63252158e-02f, 7.05562085e-02f, 4.82875854e-02f, -1.91507177e-04f, 7.26329982e-02f, 2.98029054e-02f, 1.92703828e-02f, 1.82357430e-01f,
  1.70777738e-02f, -1.90145433e-01f, -2.61132009e-02f, -6.53823838e-02f, 7.26215094e-02f, -4.95845564e-02f, -3.84186059e-02f, -3.42689082e-02f, -3.93132120e-02f, -2.38996614e-02f,
  -4.32577170e-02f, 3.04665845e-02f, -1.37530072e-02f, -1.52511066e-02f, -1.25732511e-01f, -1.34802610e-01f, 1.52161261e-02f, 1.23627730e-01f, -1.20512233e-03f, -1.36848927e-01f,
  7.93627858e-01f, 1.55465961e-01f, 1.85113207e-01f, 1.44380238e-02f, -1.09677002e-01f, -8.15046653e-02f, -9.83860344e-02f, 9.79420543e-02f, 7.29539767e-02f, 5.95827848e-02f,
  3.32003669e-03f, 2.02688724e-01f, 4.70517650e-02f, -1.76548138e-02f, -1.02954753e-01f, -7.07607483e-03f, 1.00178003e-01f, 2.27003684e-03f, 2.06902623e-02f, -1.19606592e-01f,
  -1.90041095e-01f, 1.06262900e-01f, 4.05794472e-01f, 1.68508559e-01f, 4.89140935e-02f, 2.02815995e-01f, 2.10912406e-01f, 4.89119291e-02f, 3.69329542e-01f, 8.70397687e-03f,
  3.89038205e-01f, -3.65582526e-01f, -3.40340704e-01f, 1.41729757e-01f, 1.87299132e-01f, 1.57632753e-01f, 1.28154606e-01f, 8.46763402e-02f, 2.60321379e-01f, 5.70128560e-02f,
  -5.81818223e-02f, 1.90109506e-01f, 7.41384104e-02f, 1.39076114e-01f, 8.42044130e-02f, -1.27177527e-02f, 4.47746627e-02f, 9.48867500e-02f, 5.11221401e-02f, 1.55585587e-01f,
  1.47558704e-01f, -9.44932923e-03f, 1.31564423e-01f, 3.92156541e-02f, -3.60937804e-01f, 3.46361920e-02f, -1.43264398e-01f, -2.85335571e-01f, -3.35412055e-01f, -3.20125818e-01f,
  -4.16638881e-01f, -3.27296495e-01f, 1.02016069e-01f, -1.28429020e-02f, -9.01623145e-02f, -4.71608974e-02f, -6.73641264e-02f, -9.41108912e-02f, -5.31740226e-02f, 9.22723934e-02f,
  -1.38613552e-01f, -5.58019988e-02f, -4.20600884e-02f, -8.28646794e-02f, -5.24337888e-02f, 3.96854579e-02f, -8.97603482e-02f, -1.48376361e-01f, -1.13826595e-01f, -1.49640039e-01f,
  -1.75353780e-01f, -7.72876367e-02f, -1.33880764e-01f, 6.05109781e-02f, -9.25085694e-03f, -3.18169035e-03f, -8.52690116e-02f, -1.35994747e-01f, 1.08960895e-02f, -4.03518416e-02f,
  -3.44955735e-02f, -1.01072844e-02f, -9.55077261e-02f, -1.51400845e-02f, 1.09773219e-01f, -5.32837119e-03f, -2.49317642e-02f, 4.24679331e-02f, 3.76775339e-02f, 1.51165560e-01f,
  -3.34825553e-02f, -2.77615506e-02f, -1.51398599e-01f, 1.10296503e-01f, 6.81844121e-03f, -1.49632946e-01f, -9.43253115e-02f, -5.44107221e-02f, -5.05403467e-02f, -1.70335174e-02f,
  -8.59860033e-02f, -1.83225553e-02f, -1.31757945e-01f, -7.63608590e-02f, -1.30873501e-01f, -9.22784805e-02f, 4.19548005e-02f, -9.45191924e-03f, 2.20837537e-02f, 7.29572475e-02f,
  1.52795106e-01f, -2.49796156e-02f, 8.23539197e-02f, -1.83460534e-01f, -1.96907982e-01f, -6.07692488e-02f, -1.12673573e-01f, -1.64177671e-01f, -1.28307268e-01f, -5.62579818e-02f,
  2.55909637e-02f, 6.02468699e-02f, -1.22360085e-04f, 1.25887215e-01f, 2.10503355e-01f, 1.20527349e-01f, 2.09893212e-02f, -5.66925779e-02f, -5.43183126e-02f, 3.68687958e-02f,
  5.35291852e-03f, 1.80399209e-01f, 3.02183956e-01f, 2.09259227e-01f, 2.24024326e-01f, 2.47847170e-01f, 1.77945256e-01f, 1.08857535e-01f, 1.83574542e-01f, 3.60716283e-01f,
  2.86133617e-01f, 3.19271147e-01f, 3.14906798e-02f, 1.58610076e-01f, 5.36825955e-01f, 1.88069627e-01f, -1.50036052e-01f, -2.43341774e-01f, 1.50111750e-01f, 3.31926852e-01f,
  3.92595023e-01f, -2.24251792e-01f, -2.35373527e-01f, -6.94866836e-01f, -9.53171313e-01f, -5.83479464e-01f, -4.86849129e-01f, -9.03367996e-01f, -9.91739810e-01f, -6.45690680e-01f,
  -1.85612708e-01f, -1.85480088e-01f, -3.46690774e-01f, -2.45819613e-01f, 6.34157598e-01f, 1.83881640e-01f, 5.80688894e-01f, 4.00472671e-01f, 1.04075462e-01f, 1.96427479e-01f,
  -1.14133274e-02f, 3.65174174e-01f, -4.11668867e-01f, -2.57966161e-01f, 1.66316077e-01f, -2.92087346e-01f, -1.66096330e-01f, 2.01454409e-03f, -1.93792269e-01f, -2.19303370e-01f,
  8.27720761e-02f, 2.15792432e-02f, -2.23752856e-01f, -1.20523676e-01f, -5.21078147e-02f, -3.27565849e-01f, -3.00404638e-01f, -6.92995191e-01f, -4.12185192e-01f, -1.60347149e-01f,
  -1.53830394e-01f, 1.41960934e-01f, 9.42253768e-02f, -1.10646345e-01f, -8.28031003e-02f, -2.80680686e-01f, 2.74424314e-01f, 2.68036097e-01f, 1.16956659e-01f, 1.89633146e-01f,
  -1.70430318e-01f, -8.86804834e-02f, -4.13902439e-02f, 2.49770924e-01f, -5.35568483e-02f, 1.27607733e-01f, 4.23902534e-02f, -5.63429929e-02f, 9.80094150e-02f, -3.84677649e-02f,
  -2.80953590e-02f, -3.76537517e-02f, 1.16682276e-01f, 1.72113106e-02f, 6.05989993e-03f, -8.96273088e-03f, 4.34616357e-02f, -1.15754269e-01f, -6.03253767e-02f, 2.03375369e-01f,
  -2.04564873e-02f, -6.41993061e-02f, 1.30254880e-01f, -6.08765334e-02f, 7.54512846e-02f, 1.11208878e-01f, 9.43908915e-02f, -2.88596451e-02f, -6.12326898e-02f, 1.17495321e-01f,
  1.39244109e-01f, -1.95607767e-01f, 1.57455817e-01f, -4.07549590e-01f, -1.68125611e-02f, 2.15059817e-01f, 2.78404921e-01f, -1.69326618e-01f, 7.14882314e-02f, -9.09701139e-02f,
  4.27341908e-02f, -6.21975996e-02f, 1.61631793e-01f, -2.90213466e-01f, -2.40451232e-01f, 2.14826278e-02f, -2.91025609e-01f, -1.34105474e-01f, -3.33079308e-01f, 1.42678544e-01f,
  -8.65044296e-02f, -2.19842091e-01f, -3.68148267e-01f, -2.27613986e-01f, -8.13333988e-02f, -3.72873276e-01f, -1.47886470e-01f, 6.38737753e-02f, -4.75023270e-01f, -1.20012023e-01f,
  6.14666283e-01f, 8.33984762e-02f, 7.56758526e-02f, 2.93095019e-02f, -1.76742569e-01f, -6.05311878e-02f, -2.46602595e-02f, 4.86569945e-03f, -5.96186519e-03f, 5.56305125e-02f,
  2.09595874e-01f, 3.17996979e-01f, 1.99841350e-01f, 3.01157534e-01f, 1.85668617e-01f, 6.93036094e-02f, 7.50325695e-02f, 2.49942735e-01f, 1.58222944e-01f, 6.92249537e-02f,
  2.38328740e-01f, 6.93510249e-02f, 8.94114524e-02f, 1.05193630e-02f, 1.24234043e-01f, 1.08312376e-01f, 3.52452025e-02f, -3.12513076e-02f, 1.41746238e-01f, 2.34366909e-01f,
  3.96494985e-01f, 1.31063998e-01f, -6.20394647e-02f, 1.81400962e-02f, -5.14554083e-02f, 7.84249008e-02f, 4.06026952e-02f, -3.54544409e-02f, 4.78557684e-02f, -4.30855405e-04f,
  -1.14464484e-01f, -5.77584431e-02f, 8.66211765e-03f, -1.38234451e-01f, -1.32696927e-01f, -4.60287705e-02f, 4.28052731e-02f, 9.23463479e-02f, 9.96116549e-02f, 4.80117127e-02f,
  8.11085552e-02f, -1.35294586e-01f, -5.57034612e-02f, -3.30282114e-02f, -3.12107392e-02f, -5.96360564e-02f, 4.28622030e-02f, 3.57116363e-03f, -1.33334175e-01f, -7.82437772e-02f,
  1.29694492e-01f, -2.44434066e-02f, 1.30841315e-01f, 2.85783976e-01f, 3.34403247e-01f, 1.47781432e-01f, 3.02656908e-02f, 1.26210928e-01f, 1.35597929e-01f, -3.25226225e-02f,
  -5.78371361e-02f, 5.03067710e-02f, 6.73847124e-02f, -1.21478057e-02f, 9.79047939e-02f, 8.83850604e-02f, -5.62162623e-02f, -2.15442479e-01f, 7.02850148e-02f, -7.01590404e-02f,
  1.00888170e-01f, -1.10316060e-01f, -7.14033991e-02f, -6.96021318e-03f, -6.62505627e-02f, -1.07749224e-01f, 5.47523089e-02f, -4.19340618e-02f, -4.94674593e-02f, -7.96564966e-02f,
  -5.04874110e-01f, -1.11925341e-01f, 1.35036007e-01f, 2.70351395e-03f, -1.24656312e-01f, -1.39907822e-01f, 3.23213041e-02f, -4.51620258e-02f, -2.58013420e-02f, 6.14650594e-03f,
  -1.07722096e-01f, 2.62697302e-02f, -1.47015914e-01f, -4.48294431e-02f, -1.77282631e-01f, -1.11987643e-01f, 1.93067193e-02f, 1.25335939e-02f, 3.62669230e-02f, -4.43679988e-02f,
  -1.07611492e-01f, -1.57019258e-01f, -1.58647850e-01f, -4.97680753e-02f, -4.82466035e-02f, -1.56962872e-01f, -1.11587495e-01f, -7.83595890e-02f, -8.91163722e-02f, -1.55066684e-01f,
  -7.14633167e-01f, -4.55425769e-01f, 4.32340384e-01f, -8.82375911e-02f, 1.34684339e-01f, -1.54218361e-01f, -2.28576049e-01f, -3.11312109e-01f, -6.38091862e-02f, -4.17597890e-02f,
  -2.92704523e-01f, -1.46761656e-01f, -7.90944174e-02f, -2.38364264e-01f, -3.43548387e-01f, 5.09412587e-02f, -4.91064508e-03f, -1.73532248e-01f, -2.77435958e-01f, -2.92725772e-01f,
  -2.50801355e-01f, -1.61953226e-01f, -2.90384054e-01f, -1.31399393e-01f, 1.04681268e-01f, -1.58099473e-01f, 2.14093328e-01f, -1.60704732e-01f, -2.92731196e-01f, -1.21030454e-02f,
  5.43472290e-01f, -3.22853506e-01f, -1.24207444e-01f, -2.56019741e-01f, -1.03189081e-01f, -1.46899939e-01f, -1.15394711e-01f, -2.23654155e-02f, -5.33039719e-02f, 1.30795226e-01f,
  -3.95513251e-02f, -4.86332476e-02f, 5.63069014e-03f, -1.81629267e-02f, 2.49359552e-02f, -1.17655471e-02f, 3.90739515e-02f, -1.21864654e-01f, -4.85116392e-02f, 1.45388037e-01f,
  -5.81015721e-02f, -2.33697277e-02f, 6.23393133e-02f, -9.73302498e-02f, -3.03729679e-02f, -3.25123966e-02f, -5.86263165e-02f, -7.18222633e-02f, -3.66093628e-02f, -3.19509814e-03f,
  2.63278127e-01f, 1.30474254e-01f, -4.72470261e-02f, 8.60014409e-02f, 1.27519831e-01f, 1.76807027e-02f, 1.65837869e-01f, 8.33886787e-02f, -6.40349239e-02f, -2.52397787e-02f,
  -8.89838934e-02f, -6.70521110e-02f, -1.35162547e-01f, -2.51873694e-02f, -4.32632342e-02f, -9.44267586e-02f, -1.15726613e-01f, 4.43183705e-02f, 8.90641212e-02f, -1.25682130e-01f,
  -1.81658283e-01f, -8.62340108e-02f, 1.07058652e-01f, 2.81609222e-02f, -1.58847243e-01f, 4.26736474e-02f, 8.54496099e-03f, -4.72473465e-02f, 2.24669985e-02f, -1.50668785e-01f,
  1.02795854e-01f, -3.42366993e-01f, 6.91272924e-03f, 1.67597495e-02f, 1.36799961e-01f, 4.84558195e-03f, 5.95595390e-02f, -7.39921555e-02f, -2.30410900e-02f, 1.05156176e-01f,
  8.88150856e-02f, 1.26573205e-01f, 1.45902872e-01f, 4.39188033e-02f, 1.41815126e-01f, 9.65407789e-02f, -2.63030007e-02f, 1.54823838e-02f, 2.76821479e-02f, 2.24629343e-01f,
  1.19480081e-01f, -1.16543239e-03f, 2.07289726e-01f, 2.10517973e-01f, 1.25245871e-02f, 6.86664954e-02f, 2.43102476e-01f, 1.64598465e-01f, 9.74601358e-02f, 2.02416018e-01f,
  5.71694136e-01f, -2.69944698e-01f, 2.41061747e-01f, 1.32648736e-01f, 3.21227103e-01f, 3.83207381e-01f, 1.79562047e-01f, 2.04736859e-01f, 1.54466003e-01f, -2.26323754e-02f,
  2.48841997e-02f, 8.32948014e-02f, 5.43298051e-02f, 4.11615223e-02f, 1.38825431e-01f, -1.00818217e-01f, 1.37273930e-02f, 1.81214824e-01f, 3.22121501e-01f, 1.48425967e-01f,
  -1.72138810e-01f, -9.10875276e-02f, 1.33251920e-02f, -2.53286771e-02f, -2.84141034e-01f, -8.41739960e-03f, -1.33745044e-01f, -1.08062692e-01f, 9.53364372e-03f, -3.05071712e-01f,
  -1.64167672e-01f, 2.32360676e-01f, 1.03049859e-01f, -1.38941944e-01f, -1.18671797e-01f, -1.34121433e-01f, -5.13713211e-02f, -1.09367847e-01f, -1.76470339e-01f, -2.10895255e-01f,
  -6.77491874e-02f, -7.34919384e-02f, -4.89653321e-03f, -1.21721722e-01f, 1.26458900e-02f, 5.61889671e-02f, -5.05874045e-02f, 1.07771019e-02f, 3.62010971e-02f, -9.50467214e-03f,
  -1.62223116e-01f, 1.33875072e-01f, 1.68778718e-01f, 1.08510934e-01f, 1.56019181e-01f, 1.46545276e-01f, 3.99336852e-02f, -8.76076743e-02f, -1.50106046e-02f, -1.99130490e-01f,
  2.80638039e-02f, 1.08321376e-01f, 1.51235268e-01f, 1.36096492e-01f, 1.08512037e-01f, 1.23245500e-01f, -6.45193681e-02f, 3.90379839e-02f, 1.41351268e-01f, 1.10985041e-01f,
  6.59155250e-02f, 1.47464663e-01f, 1.35787576e-01f, 4.46660109e-02f, 2.62009315e-02f, -3.45348427e-03f, -3.31880376e-02f, -5.64838052e-02f, 4.70605902e-02f, 5.42260371e-02f,
  1.11230731e-01f, 2.76952069e-02f, -1.27132773e-01f, -6.48377240e-02f, -1.12255611e-01f, 1.02090590e-01f, -8.50423351e-02f, 2.44686715e-02f, -1.08234294e-01f, -4.21636784e-03f,
  -3.46065283e-01f, 6.22795284e-01f, 4.78582904e-02f, 3.97450365e-02f, -2.63692420e-02f, -1.46817461e-01f, 1.20091148e-01f, -1.61937296e-01f, -2.18170360e-01f, -1.99684173e-01f,
  -5.16933901e-03f, 1.71396025e-02f, 7.31096864e-02f, -2.77636703e-02f, 5.57699278e-02f, 7.60614574e-02f, -4.45091166e-03f, 2.93868594e-02f, 3.87929752e-02f, -1.09813131e-01f,
  -1.33277357e-01f, 1.46168485e-01f, 1.33915737e-01f, 1.86153948e-01f, 1.02138616e-01f, 2.35665575e-01f, 1.58137716e-02f, 1.08258829e-01f, 2.62491524e-01f, -6.92806169e-02f,
  9.04036582e-01f, 2.11638078e-01f, 3.12110960e-01f, 1.06860749e-01f, -3.08630262e-02f, 1.31512552e-01f, 1.19999491e-01f, 6.22554384e-02f, 1.75553590e-01f, 1.35244101e-01f,
  2.35640377e-01f, 1.98480785e-01f, 1.83236122e-01f, 1.72726691e-01f, 4.71020453e-02f, -5.47043160e-02f, -1.57341495e-01f, 6.19325712e-02f, 6.00176230e-02f, 6.35231212e-02f,
  -1.84426159e-01f, -6.07027002e-02f, 1.49672970e-01f, 3.27781104e-02f, -5.62286340e-02f, -1.11646978e-02f, 7.84365907e-02f, -6.53441623e-02f, 4.70556282e-02f, -1.20511770e-01f,
  -2.31162965e-01f, 2.62286663e-01f, 1.42640099e-02f, -2.48600971e-02f, 1.11014016e-01f, 6.05350100e-02f, 4.71242554e-02f, -1.19029339e-02f, -1.77249908e-01f, -1.95379734e-01f,
  -7.08075836e-02f, 8.96739662e-02f, -6.47703633e-02f, 7.50271007e-02f, -8.93981233e-02f, -6.42004162e-02f, 1.69599086e-01f, 8.92966688e-02f, -6.58901259e-02f, 3.80712561e-02f,
  -5.26880920e-02f, 9.29815918e-02f, 2.55754068e-02f, -9.22645554e-02f, 8.57934635e-03f, 2.87690237e-02f, -1.12492219e-02f, 1.01332240e-01f, 4.01389860e-02f, 1.11241125e-01f,
  1.64980069e-02f, 3.40516806e-01f, 2.55138904e-01f, 5.99159226e-02f, -2.50585377e-02f, 1.49574548e-01f, -9.89936963e-02f, -1.94372386e-01f, -1.08451480e-02f, -3.64752449e-02f,
  -1.83535472e-01f, -8.82781073e-02f, 1.63389057e-01f, 4.26095873e-02f, -2.18790839e-03f, 2.75556855e-02f, -2.05214582e-02f, -1.02006674e-01f, 4.35225852e-02f, -9.19080228e-02f,
  -1.16201118e-01f, -1.63248882e-01f, 1.65207997e-01f, 5.26481941e-02f, 8.95806625e-02f, 1.44854799e-01f, -9.93978307e-02f, -9.27558541e-03f, 1.51832789e-01f, -7.13630766e-02f,
  -2.51525462e-01f, 1.22808285e-01f, -4.87260073e-02f, -1.09828696e-01f, 4.22301739e-02f, -7.46700261e-03f, -3.87901030e-02f, -1.16858725e-02f, -2.79793561e-01f, -1.23579778e-01f,
  -1.88655168e-01f, 1.75478049e-02f, 2.07970925e-02f, -4.23300453e-02f, 1.56528375e-03f, -1.13104500e-01f, 3.39666568e-02f, -3.47658768e-02f, -1.66123152e-01f, -1.40084147e-01f,
  3.47158872e-02f, -1.61883105e-02f, 3.02585289e-02f, -4.86503020e-02f, -1.05152093e-01f, 6.72092438e-02f, 2.17219554e-02f, 1.09057901e-02f, 1.09739244e-01f, 1.53167397e-02f,
  2.96810180e-01f, -4.54724312e-01f, -1.29937798e-01f, -1.56731546e-01f, -5.16590238e-01f, -2.80533463e-01f, -3.81268054e-01f, 1.74529687e-01f, -4.01013047e-02f, -4.70301002e-01f,
  -7.10540950e-01f, -3.18889737e-01f, -2.96432108e-01f, -1.04654543e-01f, 1.85723096e-01f, -2.81593174e-01f, -2.42712975e-01f, 2.79988229e-01f, 7.17237294e-01f, 3.33053321e-01f,
  -2.68497825e-01f, 7.36045390e-02f, 4.52374935e-01f, 4.02617514e-01f, 5.39704002e-02f, 2.82540247e-02f, -1.11407861e-01f, -1.75294116e-01f, 1.70377316e-04f, -2.30605409e-01f,
  -2.98548609e-01f, 3.86785805e-01f, 4.90833148e-02f, -1.13169560e-02f, -2.51407206e-01f, 2.29593236e-02f, -1.17671572e-01f, 2.56696865e-02f, 5.15966341e-02f, 2.89959162e-02f,
  -2.36126319e-01f, -6.72627464e-02f, -1.31431744e-01f, -1.04628868e-01f, 1.01161655e-03f, 2.01761276e-01f, 1.29757822e-01f, 3.42545897e-01f, -2.20686924e-02f, -1.66545454e-02f,
  -4.04428333e-01f, -2.51198977e-01f, 3.51305306e-02f, 1.68793246e-01f, 3.97665560e-01f, -1.40190810e-01f, 1.43717185e-01f, 3.67125392e-01f, 3.02116841e-01f, 2.19117805e-01f,
  -3.12289726e-02f, -1.61612451e-01f, -1.95067050e-03f, 1.32268071e-01f, -3.92688140e-02f, -5.75820506e-02f, 7.11657330e-02f, -9.45200096e-04f, 5.17061725e-02f, 1.70718860e-02f,
  1.82639454e-02f, -1.74834549e-01f, 8.40643868e-02f, 4.26051281e-02f, -5.19374534e-02f, -1.79947570e-01f, -1.36361837e-01f, 7.15236068e-02f, -1.35511532e-02f, 4.05032001e-02f,
  1.85245484e-01f, 7.39326254e-02f, -6.36212751e-02f, 8.22929665e-02f, 1.63121689e-02f, 1.90346614e-01f, -1.02339182e-02f, 2.96662860e-02f, -2.08287865e-01f, -1.93579253e-02f,
  -3.40505749e-01f, -2.07244396e-01f, -3.50595117e-01f, 2.95900285e-01f, -1.62982821e-01f, 9.44971815e-02f, -2.68706173e-01f, -8.32256302e-03f, 5.73430248e-02f, -2.92877480e-02f,
  1.34903952e-01f, -9.08066034e-02f, -1.58469856e-01f, -4.61027101e-02f, -9.06774029e-02f, 1.91602949e-02f, -3.49452764e-01f, -2.21746400e-01f, -5.48246354e-02f, -1.79344967e-01f,
  -1.82782263e-01f, -1.13624401e-01f, -3.53583038e-01f, -2.58410454e-01f, -1.18335344e-01f, -1.59925595e-01f, -1.46441624e-01f, -1.38264835e-01f, -9.41429213e-02f, -4.84145969e-01f,
  1.03569996e+00f, 4.13740247e-01f, -1.12536478e+00f, 4.69127804e-01f, -5.23873210e-01f, -5.51911116e-01f, 2.36971881e-02f, 2.76083291e-01f, 2.71292716e-01f, 1.76578671e-01f,
  -3.73075783e-01f, -2.16701046e-01f, -4.39163804e-01f, -2.29914859e-01f, -1.62387326e-01f, -2.39937767e-01f, -4.61759031e-01f, -5.50537765e-01f, -3.27658653e-01f, 3.97164345e-01f,
  5.42047441e-01f, 6.45586967e-01f, 5.90411782e-01f, 2.88011301e-02f, 4.24331985e-02f, -6.61342964e-02f, -3.78436983e-01f, -3.41578061e-03f, -1.32866144e-01f, 1.84136629e-02f,
  -5.30766010e-01f, 2.37246938e-02f, -4.82487470e-01f, -2.48517524e-02f, -2.35740095e-01f, 7.37153664e-02f, -1.95065796e-01f, -1.91340148e-01f, -8.17897841e-02f, -2.21071690e-02f,
  -4.02652770e-01f, 1.36690226e-03f, -2.19248921e-01f, -7.31813610e-02f, -3.02543417e-02f, -1.83571562e-01f, 3.96149792e-02f, -1.13646373e-01f, -9.82174650e-02f, -1.72258034e-01f,
  9.81450826e-02f, -2.43097693e-01f, -6.37606621e-01f, -4.32895958e-01f, -3.26280653e-01f, -5.51550806e-01f, -3.72360051e-01f, -1.54737979e-01f, -4.07658190e-01f, 3.23295534e-01f,
  3.21338587e-02f, -5.11942431e-02f, 3.65589038e-02f, 1.20957077e-01f, 1.91151232e-01f, -4.97319847e-02f, 1.39620513e-01f, 2.14192659e-01f, -2.68897843e-02f, 3.42927016e-02f,
  -1.14467971e-01f, -2.00641397e-02f, -3.54888737e-02f, 1.97965056e-02f, 4.42832243e-03f, -4.64115404e-02f, -4.85813171e-02f, 3.21891516e-01f, 4.06321101e-02f, 1.03737913e-01f,
  3.52163762e-02f, -6.95170611e-02f, -2.48157494e-02f, -5.66772707e-02f, -1.09648131e-01f, -1.71180651e-01f, 5.50334416e-02f, 1.21658981e-01f, 6.94993092e-03f, 5.86423054e-02f,
  3.81473660e-01f, -3.20092261e-01f, 4.53980528e-02f, 5.78399748e-02f, -1.53469130e-01f, -1.71105310e-01f, 7.00600967e-02f, 4.16740701e-02f, -5.83010763e-02f, 1.05099771e-02f,
  -2.53629655e-01f, -1.99432313e-01f, -1.49440154e-01f, -1.21853212e-02f, -7.93781970e-03f, -1.36296228e-01f, 1.47009820e-01f, -1.23978034e-01f, -6.17967546e-02f, -5.91550246e-02f,
  3.19848001e-01f, 1.40105590e-01f, 9.41135287e-02f, -1.52500182e-01f, 1.94881320e-01f, -5.19444086e-02f, -2.31964961e-01f, 7.15233237e-02f, -2.16022521e-01f, 7.15110421e-01f,
  -5.23895681e-01f, -3.51609647e-01f, 4.14199352e-01f, -6.72902226e-01f, -4.59192619e-02f, 4.59826052e-01f, 3.34508479e-01f, -9.29707512e-02f, -3.57162178e-01f, -6.27060980e-02f,
  -3.88200060e-02f, 3.36909620e-03f, -1.01598069e-01f, 4.43245918e-02f, 2.20624804e-01f, 3.13730359e-01f, 5.54501750e-02f, 1.30017012e-01f, 4.25985605e-01f, 2.96318948e-01f,
  -8.37110952e-02f, -3.21471512e-01f, -2.94336498e-01f, -3.50514561e-01f, -3.53009939e-01f, -1.24922745e-01f, -2.52855211e-01f, -3.55040103e-01f, 1.77418813e-02f, -4.61193830e-01f,
  3.40946317e-01f, -3.77096087e-01f, 1.31953791e-01f, -1.79234147e-01f, -4.38890494e-02f, -8.76450762e-02f, -1.89496583e-04f, -2.07245722e-01f, -1.05276339e-01f, 1.00914557e-02f,
  -1.91121370e-01f, -5.48627265e-02f, -6.09402955e-02f, -7.18105992e-04f, -9.63220093e-03f, -4.91955951e-02f, -2.38539457e-01f, -1.58928797e-01f, -1.96826905e-02f, -2.56619304e-02f,
  -5.94658740e-02f, 1.60269961e-02f, 1.00408472e-01f, 5.11575341e-02f, -8.30701068e-02f, 9.58565921e-02f, -2.85496041e-02f, -2.37799361e-02f, -6.14896417e-03f, -1.71453893e-01f,
  1.52470559e-01f, -4.34418442e-03f, 5.06567955e-02f, -8.80790874e-02f, -4.50809374e-02f, -2.67302748e-02f, -4.19766083e-02f, 3.74231637e-02f, -1.03075556e-01f, -3.28381248e-02f,
  -2.47029420e-02f, 4.12732549e-02f, 3.89352553e-02f, -7.01215863e-02f, -2.97462987e-03f, -1.35909794e-02f, -5.18423226e-03f, -1.03428259e-01f, -8.72466415e-02f, -6.85466751e-02f,
  -1.29870355e-01f, -7.20830560e-02f, -2.06286944e-02f, -7.49630779e-02f, -1.25808537e-01f, 4.03170735e-02f, -5.38675115e-02f, 1.11185526e-02f, 1.36311995e-02f, -9.25054103e-02f,
  9.21277255e-02f, 1.78046927e-01f, -6.51718006e-02f, -1.73445940e-01f, -2.08435319e-02f, -9.34639052e-02f, 9.32035688e-03f, 5.41910063e-03f, -5.85977212e-02f, 1.53153464e-01f,
  -2.89075961e-03f, 3.96780074e-02f, -5.18480949e-02f, -1.49669990e-01f, 2.59138234e-02f, 5.14473766e-02f, -1.50806248e-01f, -3.48249562e-02f, -5.00402004e-02f, -7.73034543e-02f,
  -1.04031898e-01f, 2.02878892e-01f, 3.01009148e-01f, 2.00090244e-01f, 1.10915177e-01f, 3.38754296e-01f, 2.21253470e-01f, 1.38485596e-01f, 3.29699934e-01f, 1.00999191e-01f,
  -8.54135811e-01f, -1.84072912e-01f, 2.53895633e-02f, -3.76882911e-01f, -1.97212905e-01f, -1.72757968e-01f, -2.58799702e-01f, 1.24510325e-01f, 1.33838981e-01f, -1.23708054e-01f,
  -1.33723333e-01f, 4.60814387e-02f, -4.45243455e-02f, -1.49056464e-01f, -2.80072778e-01f, -3.68623585e-01f, -4.60514277e-01f, -3.21783662e-01f, -1.49486512e-01f, -8.87173861e-02f,
  -2.85708398e-01f, -2.49699920e-01f, -2.38864109e-01f, -1.18169770e-01f, 2.67458767e-01f, 3.90422381e-02f, 1.38766810e-01f, -9.93479192e-02f, -2.56420732e-01f, -2.83728242e-01f,
  3.76006693e-01f, 7.28779510e-02f, 9.26792696e-02f, -1.84522033e-01f, 1.66874513e-01f, -5.83690815e-02f, -5.60258748e-03f, 5.61868660e-02f, -1.07032485e-01f, -7.90313482e-02f,
  -1.60909310e-01f, -7.21195829e-05f, -2.12091710e-02f, 1.52428269e-01f, 1.64545942e-02f, 6.43271953e-02f, 9.28651989e-02f, 6.11692593e-02f, 3.98100130e-02f, 2.60706514e-01f,
  -1.66944638e-01f, -3.62297446e-01f, -1.16004087e-01f, 1.96138903e-01f, 2.90580153e-01f, -1.39466897e-01f, 3.50667089e-01f, 2.45328426e-01f, 1.06910281e-01f, 6.62595406e-02f,
  1.40200049e-01f, 1.05795331e-01f, -1.90583486e-02f, 1.30908772e-01f, -8.64814371e-02f, 6.60057366e-02f, -9.63104069e-02f, -1.22032240e-01f, -9.50112194e-03f, 1.76677868e-01f,
  1.11536622e-01f, 5.12856469e-02f, 1.21097058e-01f, -4.74429056e-02f, -2.77940109e-02f, -1.77973166e-01f, -2.43401855e-01f, -1.69786382e-02f, -1.14845209e-01f, -1.95662811e-01f,
  -1.62154213e-01f, -1.19877592e-01f, 1.51252402e-02f, 9.86700282e-02f, -1.23500027e-01f, -9.22965854e-02f, -1.03865951e-01f, -6.66290596e-02f, 9.14480016e-02f, -1.09536782e-01f,
  4.75161970e-01f, -3.26020479e-01f, -1.09251114e-02f, -1.15081228e-01f, 2.27765143e-02f, 1.02518164e-01f, -7.97798708e-02f, -1.90762624e-01f, 2.04378180e-02f, 3.62063572e-02f,
  -9.71971676e-02f, -4.61887456e-02f, 3.64821777e-02f, 3.20742913e-02f, -4.14704047e-02f, 4.23038714e-02f, -2.24820226e-01f, -1.76806241e-01f, -1.76133215e-01f, 7.75099844e-02f,
  -1.90191805e-01f, -4.76732999e-01f, -3.06469023e-01f, -9.07619148e-02f, 1.92011252e-01f, -3.73902857e-01f, 2.26134375e-01f, 1.13216519e-01f, -1.12314686e-01f, -3.33275385e-02f,
  -4.55798358e-01f, -9.29739475e-01f, 3.70754063e-01f, -6.85385287e-01f, -3.60417187e-01f, 2.69077457e-02f, -6.37718260e-01f, -3.60165238e-01f, -1.89349934e-01f, -3.73115897e-01f,
  -2.02012047e-01f, 5.02439179e-02f, 3.46435495e-02f, 7.02198073e-02f, 3.02946329e-01f, -2.51993775e-01f, 2.61453331e-01f, 5.00227809e-01f, 5.03163934e-01f, -1.81572542e-01f,
  -3.89482379e-01f, -3.48375052e-01f, 3.09330355e-02f, -8.58396962e-02f, -6.01992667e-01f, -1.88420907e-01f, -2.48922616e-01f, -3.46709609e-01f, -6.42303005e-02f, -5.17996013e-01f,
  -3.39803576e-01f, -2.96182454e-01f, 1.85139656e-01f, 4.52897698e-02f, -2.54507840e-01f, 8.16970244e-02f, -1.09841399e-01f, 6.47761673e-02f, -3.13072791e-03f, -5.30633032e-02f,
  -6.97098002e-02f, -1.00600272e-01f, -1.00479849e-01f, -1.77339911e-01f, -3.30563009e-01f, -2.42291372e-02f, 9.31033343e-02f, 1.87107712e-01f, 2.40228146e-01f, 4.84805368e-02f,
  -8.80813003e-02f, 5.46330698e-02f, 1.33877337e-01f, 1.12000428e-01f, 1.37089655e-01f, 3.86055440e-01f, -2.24462703e-01f, -1.43865719e-02f, 3.05717617e-01f, -5.04723668e-01f,
  -7.72041678e-02f, 1.55801261e-02f, -1.56208081e-02f, -1.90160070e-02f, 1.52519345e-02f, 1.16580054e-01f, -7.92191327e-02f, -1.13385826e-01f, -2.19098441e-02f, -1.68646276e-01f,
  -6.98707849e-02f, -3.78239974e-02f, -4.80809733e-02f, -1.42780349e-01f, 1.11104706e-02f, -1.01736747e-02f, 7.61471167e-02f, -5.81185408e-02f, 4.88935001e-02f, 8.63020122e-02f,
  8.83350000e-02f, 2.43422911e-02f, 1.89400256e-01f, 2.77568743e-05f, 2.13425726e-01f, 6.51238486e-02f, 1.16439112e-01f, 4.72743139e-02f, -1.32479668e-01f, 1.34811983e-01f,
  -3.03102136e-01f, 4.85618114e-01f, -3.28880280e-01f, 4.42483909e-02f, -3.34066339e-02f, 9.05040279e-02f, -7.57109299e-02f, 1.35477200e-01f, 2.05521584e-02f, -8.71429965e-02f,
  -3.68792005e-02f, -1.10003956e-01f, 3.14021818e-02f, 3.29560973e-02f, -8.54677483e-02f, 1.68869330e-03f, 4.90060188e-02f, 2.62572076e-02f, 1.97423413e-01f, -6.40662313e-02f,
  3.66105363e-02f, 2.00551927e-01f, -9.50116515e-02f, 3.88393812e-02f, 1.57111627e-03f, 2.84307361e-01f, -5.39214201e-02f, 5.16905375e-02f, 2.79671341e-01f, -3.82624775e-01f,
  -9.26679373e-02f, 7.67371384e-03f, -1.55279383e-01f, 3.54340553e-01f, 3.82480651e-01f, 1.06518373e-01f, 3.04147676e-02f, -9.01191011e-02f, 2.19944328e-01f, 1.44871220e-01f,
  3.70289028e-01f, 3.71889442e-01f, 2.58218437e-01f, 2.22704947e-01f, 1.00050211e-01f, 1.14569858e-01f, 2.03090653e-01f, 2.21234068e-01f, 1.12021357e-01f, 2.99271911e-01f,
  2.92754471e-01f, 2.19821289e-01f, 1.22778893e-01f, 6.49681017e-02f, 3.72312129e-01f, 2.91189313e-01f, 1.89021975e-01f, 3.19101304e-01f, 3.73590529e-01f, 4.01320219e-01f,
  3.40150535e-01f, -2.66604722e-01f, -2.95719337e-02f, 6.23949096e-02f, -5.55521734e-02f, -1.99814990e-01f, -2.02541053e-01f, -2.61806101e-01f, -8.85590166e-02f, -2.90591139e-02f,
  5.50302826e-02f, -3.56417224e-02f, -7.97554776e-02f, -1.09146558e-01f, -8.72172639e-02f, -4.14260067e-02f, -1.88118592e-01f, -1.87091261e-01f, -2.19048485e-02f, 2.47649942e-02f,
  2.85293132e-01f, 1.46903962e-01f, -1.14924945e-01f, -3.60133983e-02f, 1.61848981e-02f, 1.23470865e-01f, -7.34898448e-02f, -7.32641518e-02f, -1.58370808e-01f, -7.83901066e-02f,
  2.25353390e-01f, 1.04158543e-01f, 1.21029116e-01f, -6.57179505e-02f, 1.21098004e-01f, 1.32272720e-01f, 7.74955004e-02f, 1.24111295e-01f, -2.34547686e-02f, -1.27627879e-01f,
  1.31144850e-02f, 1.03272587e-01f, -2.21292935e-02f, 1.13719985e-01f, 1.83141634e-01f, -9.00374353e-02f, -6.94661364e-02f, 6.92368597e-02f, -6.70237094e-02f, -7.33968392e-02f,
  1.11015297e-01f, -6.94087967e-02f, -1.33627504e-01f, -1.07623227e-01f, -4.25863452e-02f, 2.79258844e-02f, 3.72091457e-02f, 1.89191643e-02f, 4.03902084e-02f, -8.34408700e-02f,
  3.48488241e-02f, -2.44574592e-01f, 4.73874733e-02f, -1.61719218e-01f, -6.42538369e-02f, -5.95229305e-02f, -1.22465670e-01f, -1.52769148e-01f, -8.17780346e-02f, -1.75449446e-01f,
  -2.43201535e-02f, -4.13102843e-02f, -2.53078025e-02f, -7.12961927e-02f, -1.16191924e-01f, -1.89875662e-02f, -2.66370755e-02f, 2.00476367e-02f, -1.07660871e-02f, -1.50652409e-01f,
  -9.34960842e-02f, -2.10130721e-01f, -1.02031298e-01f, -1.57556191e-01f, -8.15375969e-02f, -1.25489002e-02f, -7.67229497e-02f, -3.39636691e-02f, -1.23810321e-01f, -2.18381733e-01f,
  -7.89212227e-01f, 6.33483708e-01f, 1.33078158e-01f, -4.47994411e-01f, -1.59190014e-01f, -1.27175793e-01f, 4.43688691e-01f, -9.24338177e-02f, -4.02970344e-01f, 1.61309883e-01f,
  2.11622566e-01f, -4.82222199e-01f, -1.83862790e-01f, -2.71205008e-01f, -1.01611160e-01f, 3.40487182e-01f, -3.70366760e-02f, -4.63856518e-01f, -5.89219093e-01f, -3.46916646e-01f,
  -3.27383488e-01f, -3.96938205e-01f, -6.17873132e-01f, -3.20345014e-01f, -1.56584263e-01f, -4.31597769e-01f, -1.21784732e-01f, -3.45997661e-01f, -1.50861572e-02f, -2.19031036e-01f,
  4.52350140e-01f, 4.54335660e-02f, -1.46301016e-01f, -2.46559396e-01f, 6.42038435e-02f, 6.64641112e-02f, -3.21336091e-02f, -1.74505711e-02f, 3.53503670e-03f, 1.57087415e-01f,
  -2.34045945e-02f, -9.96042714e-02f, -8.97050202e-02f, 1.64293692e-01f, -7.26371482e-02f, 3.02832332e-02f, 1.17575429e-01f, 1.69241820e-02f, 2.00243980e-01f, 1.85299143e-01f,
  2.49080509e-01f, 9.43232030e-02f, 2.74849594e-01f, 2.08335057e-01f, 1.96614891e-01f, -8.06647316e-02f, 1.70326382e-01f, -4.46334332e-02f, -2.90835351e-02f, 1.80335522e-01f,
  -1.02028912e-02f, 6.32241666e-02f, -3.17611210e-02f, -1.32623389e-01f, 1.03296533e-01f, 1.37038752e-01f, -1.82635579e-02f, 1.74862698e-01f, -9.68031883e-02f, 1.21661067e-01f,
  2.49869928e-01f, 1.71393529e-01f, 8.04595202e-02f, 2.26705316e-02f, -1.08780496e-01f, 3.10890190e-02f, 1.56469103e-02f, 1.51315242e-01f, 1.08927660e-01f, 1.22731626e-02f,
  -2.85989395e-03f, 3.07454895e-02f, -4.09544818e-02f, -4.20140242e-03f, 1.27956107e-01f, 3.44032533e-02f, 1.85974259e-02f, -2.28048097e-02f, 3.56566883e-03f, -5.56900129e-02f,
  -3.33124846e-02f, -6.06927276e-02f, 1.19987704e-01f, -1.36821792e-01f, -1.05678821e-02f, 2.59125475e-02f, -8.18750486e-02f, -1.20154852e-02f, 4.18021791e-02f, -1.46876900e-02f,
  -8.49381760e-02f, -5.01499400e-02f, 2.13783428e-01f, 1.51353508e-01f, -1.50217757e-01f, -8.26896355e-02f, 8.67811590e-02f, 5.53679988e-02f, 4.21298631e-02f, 2.02656448e-01f,
  2.76898712e-01f, 8.66160635e-03f, 9.69108045e-02f, 9.51802507e-02f, -1.82974115e-02f, -2.59539098e-01f, 1.68130040e-01f, 2.58847401e-02f, 1.96410362e-02f, 1.13900036e-01f,
  -9.56137359e-01f, 1.36391535e-01f, 4.39940244e-01f, -6.06744707e-01f, 1.68666258e-01f, 5.03713071e-01f, 2.20921725e-01f, 2.99778193e-01f, 9.92602259e-02f, -4.31854762e-02f,
  9.21241492e-02f, -7.60468170e-02f, -1.28282502e-01f, 4.13010567e-02f, -2.71115690e-01f, 6.92887530e-02f, 7.40108043e-02f, -3.23809266e-01f, -1.47101134e-01f, -1.16293043e-01f,
  -1.33012936e-01f, -4.12869662e-01f, -5.27391076e-01f, -2.17894405e-01f, -2.78500617e-01f, -3.22477102e-01f, -1.70015737e-01f, -2.17824876e-01f, -2.39089236e-01f, -4.72853392e-01f,
  -6.02576137e-01f, 9.63962302e-02f, 2.83328116e-01f, -2.07132846e-02f, 1.18166789e-01f, -2.27767050e-01f, 2.00446229e-02f, -6.89264759e-02f, -1.15627190e-02f, -2.70269588e-02f,
  -4.54589128e-02f, 2.06643716e-01f, -1.46027058e-01f, 4.63469885e-02f, -6.11988716e-02f, -1.33578494e-01f, 1.08727820e-01f, -1.58773273e-01f, -1.01204924e-01f, 1.86033219e-01f,
  1.37372106e-01f, -4.12365943e-01f, -4.46719378e-01f, 9.21049193e-02f, 8.66654143e-02f, -2.93079615e-01f, -1.51522726e-01f, -1.84784710e-01f, -3.58426541e-01f, -6.44158304e-01f,
  -1.81709006e-02f, 1.21969748e-02f, 1.48460925e-01f, 6.37627095e-02f, -1.36021882e-01f, 8.69146883e-02f, -1.41078010e-01f, -4.98244204e-02f, -4.75390218e-02f, -8.44643936e-02f,
  1.98612094e-01f, 1.40874803e-01f, 6.51095062e-02f, -8.48469958e-02f, -1.77508965e-01f, -2.39116654e-01f, -7.18475878e-02f, -1.31096676e-01f, -1.34496957e-01f, -3.51452418e-02f,
  -1.88503892e-03f, -8.28742981e-02f, -6.61621569e-03f, -1.89365834e-01f, -3.81954713e-03f, -9.10778046e-02f, -8.79005939e-02f, 1.00688115e-01f, 1.04537420e-01f, 6.79749474e-02f,
  -3.43688518e-01f, 1.06579244e-01f, -3.86664003e-01f, -5.04316054e-02f, -3.88382748e-02f, 2.08092391e-01f, -1.34820595e-01f, -5.14661931e-02f, 4.17895317e-02f, 9.89317894e-03f,
  9.67033803e-02f, -2.18467731e-02f, -5.16452231e-02f, 2.34714985e-01f, -2.41529401e-02f, 1.54043268e-02f, -2.70090997e-01f, -9.77598205e-02f, -2.19349917e-02f, -1.00947827e-01f,
  1.21928398e-02f, -4.42461044e-01f, -7.46399820e-01f, -3.53648365e-01f, -3.82660180e-01f, -5.08764446e-01f, -5.28883040e-01f, -3.04220825e-01f, -5.26529789e-01f, -7.83932090e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  6.76227331e-01f, 4.47006732e-01f, 4.01019871e-01f, 5.74575186e-01f, 5.79123676e-01f, 3.92524868e-01f, 1.25202969e-01f, 6.65188789e-01f, 6.95586026e-01f, 5.99058509e-01f,
  2.02235788e-01f, 6.46575630e-01f, 4.90677357e-01f, 4.29998338e-01f, 7.57709980e-01f, 7.68198192e-01f, 5.71933270e-01f, 4.19505686e-01f, 8.81682634e-01f, 3.77780497e-01f,
  6.39493763e-01f, 9.81474102e-01f, 5.44013798e-01f, 4.67659116e-01f, 6.16500080e-01f, 2.98831880e-01f, 7.56573200e-01f, 6.65497541e-01f, 5.52804053e-01f, 4.97790366e-01f,
  6.91532671e-01f, 4.27605867e-01f, 6.54388189e-01f, 6.65396571e-01f, 6.95286751e-01f, 1.42651394e-01f, 6.88303888e-01f, 1.93185195e-01f, 5.94376147e-01f, 6.98514879e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.66424900e-01f, -5.68377078e-01f, -1.30326569e-01f, -1.35303259e-01f, -2.00855583e-01f, -1.35746777e-01f, 2.24077646e-02f, -2.95405090e-01f, -3.18922043e-01f, -5.60637303e-02f,
  -3.62368345e-01f, -1.02018818e-01f, 1.45192862e-01f, -3.58095840e-02f, 9.00383219e-02f, 6.92997575e-02f, 3.87616791e-02f, 1.87542081e-01f, 4.32284057e-01f, 3.21097016e-01f,
  -2.68084984e-02f, -6.29924312e-02f, 1.82853788e-01f, -1.00999705e-01f, -1.30995959e-01f, 2.40464240e-01f, 3.01046044e-01f, -1.15788266e-01f, 2.16336906e-01f, -9.95773554e-01f,
  -2.58322537e-01f, 8.58741045e-01f, -4.51658249e-01f, -5.83137989e-01f, -5.91837347e-01f, 1.55991673e-01f, -5.23968816e-01f, -1.68307707e-01f, -5.99643588e-01f, 1.51863024e-01f,
  2.33330950e-02f, 5.58195859e-02f, -1.65439844e-01f, 3.30146283e-01f, -1.92101747e-01f, -9.26195145e-01f, 3.53817165e-01f, -8.17963719e-01f, -8.55869412e-01f, 4.05279219e-01f,
  -2.75267929e-01f, -1.62378550e-01f, -2.35366747e-01f, -3.15273702e-01f, -1.35130122e-01f, -3.05322856e-01f, 6.31603360e-01f, 2.59593606e-01f, -2.29793102e-01f, 2.88154751e-01f,
  5.22304699e-02f, -3.22100446e-02f, -7.40346387e-02f, 1.74595281e-01f, -2.22557113e-02f, 4.30618599e-03f, -7.25064352e-02f, -2.29177862e-01f, -9.46159810e-02f, -1.69909894e-01f,
  -2.19302401e-01f, 1.83320820e-01f, 1.99981526e-01f, -1.04796089e-01f, 1.91559345e-01f, 1.31677419e-01f, 2.71689773e-01f, -2.35722944e-01f, -4.53863800e-01f, 2.36058468e-03f,
  -2.57869422e-01f, 1.72985554e-01f, 3.29606712e-01f, 2.71990206e-02f, -2.39781365e-01f, -2.35779107e-01f, -3.19926530e-01f, 1.79114074e-01f, -3.74337673e-01f, -6.95636988e-01f,
  4.15070713e-01f, 2.45453537e-01f, 9.40357149e-02f, -3.58755738e-01f, -1.87377562e-03f, -1.77976415e-01f, -1.72073305e-01f, -9.00692165e-01f, -1.46453768e-01f, -1.09938808e-01f,
  2.23810285e-01f, 2.77980894e-01f, -8.67865801e-01f, 8.84832501e-01f, 5.32836616e-01f, -7.64692366e-01f, -7.68987715e-01f, -2.32650667e-01f, -1.43201411e-01f, -9.49843228e-01f,
  -4.39338744e-01f, -1.36090606e-01f, -7.38696396e-01f, 7.72324502e-01f, 3.48143697e-01f, -1.18826878e+00f, 3.79702091e-01f, -4.35587257e-01f, 3.23549241e-01f, 3.08186501e-01f,
  1.69291750e-01f, -2.06677124e-01f, -1.46615669e-01f, -5.35117149e-01f, 6.17869616e-01f, 3.37422609e-01f, -5.93846917e-01f, -6.53336585e-01f, -7.43610784e-02f, 1.19614027e-01f,
  8.53976682e-02f, 8.62533376e-02f, 1.47590443e-01f, 2.26664707e-01f, 2.31288865e-01f, 1.28598422e-01f, 1.97275400e-01f, -3.45519409e-02f, -4.44337353e-02f, 2.80696571e-01f,
  -2.74133921e-01f, -1.14609659e-01f, -2.75931358e-01f, -4.96993452e-01f, 1.05507866e-01f, 3.21277857e-01f, 1.58664525e-01f, -4.96376269e-02f, 4.88426328e-01f, -4.48233575e-01f,
  -4.11058724e-01f, -2.85696834e-01f, -2.94411898e-01f, 6.44774497e-01f, -4.32889998e-01f, -2.69014835e-01f, 2.38601059e-01f, -5.85306108e-01f, -5.10908902e-01f, 1.89767450e-01f,
  -2.69272447e-01f, 2.85575002e-01f, -2.51871318e-01f, -3.98329347e-01f, -2.37749144e-01f, -2.77566761e-01f, 4.13957089e-01f, -1.05783448e-01f, -5.87342270e-02f, 3.38949472e-01f,
  -3.93417954e-01f, -3.36926490e-01f, -6.74602836e-02f, -2.75894850e-01f, -5.83734274e-01f, -6.75663531e-01f, 7.38794863e-01f, -3.99014324e-01f, 1.38416544e-01f, -8.48104715e-01f,
  -1.84610888e-01f, 1.27680212e-01f, 1.80065781e-01f, 6.04778901e-02f, 6.58620656e-01f, -9.92618203e-01f, 2.88466308e-02f, -1.07480854e-01f, 6.56898975e-01f, -3.15615833e-01f,
  -9.01041865e-01f, 2.12002005e-02f, -2.08290473e-01f, 8.36246535e-02f, -2.48505473e-01f, 7.26688355e-02f, -2.63548762e-01f, 1.01684958e-01f, -7.75184408e-02f, -4.68172103e-01f,
  -2.00834155e-01f, -1.12118021e-01f, -1.85172588e-01f, -1.43225774e-01f, -3.03639531e-01f, -4.19006981e-02f, -3.75688747e-02f, -1.83216438e-01f, -3.87455136e-01f, -6.43162578e-02f,
  -8.33616704e-02f, 2.42570296e-01f, 6.88404739e-02f, 4.47943628e-01f, -2.00279415e-01f, -6.78176954e-02f, 3.58374476e-01f, -5.39589524e-01f, 3.47375214e-01f, 7.67249614e-02f,
  -7.45834887e-01f, -6.35242522e-01f, -3.50401103e-01f, -4.52235080e-02f, -9.65748250e-01f, 7.02798307e-01f, -6.22602642e-01f, -8.07049870e-03f, -3.83951634e-01f, -3.55859637e-01f,
  7.41134346e-01f, -5.28572083e-01f, -5.10494923e-03f, 2.01524626e-02f, 6.95905387e-01f, 4.59069103e-01f, 2.21199930e-01f, 4.91873771e-01f, 1.07483894e-01f, -9.88290757e-02f,
  1.09192327e-01f, -5.15349805e-01f, -4.35442120e-01f, -1.82768196e-01f, -5.97349145e-02f, -2.48620361e-01f, -1.82548881e-01f, -1.83809534e-01f, -2.08949730e-01f, -7.80747354e-01f,
  3.83366704e-01f, -1.17884822e-01f, 4.91851449e-01f, -5.14261365e-01f, 4.53445047e-01f, 3.80913585e-01f, 1.45982988e-02f, 6.39948109e-03f, 5.37571348e-02f, -1.01843938e-01f,
  -1.11055486e-01f, 1.99729316e-02f, -3.20519181e-03f, 2.45023221e-01f, 6.06967285e-02f, -9.61091891e-02f, 7.33900145e-02f, -2.47371420e-01f, -1.69650279e-03f, 8.12134296e-02f,
  3.16903472e-01f, -3.39465946e-01f, -2.60293651e-02f, -4.09515947e-01f, -3.84593099e-01f, -5.86936697e-02f, 2.53032334e-02f, 2.55947173e-01f, -2.66159147e-01f, -1.15637265e-01f,
  -2.03316689e-01f, -6.02028370e-01f, -3.24490994e-01f, -5.33671491e-02f, 1.99424885e-02f, 5.10194600e-01f, 1.83473885e-01f, -1.30039096e+00f, 5.27361572e-01f, -2.49736086e-01f,
  2.01526329e-01f, 2.06098884e-01f, -7.48139471e-02f, -3.37423921e-01f, -8.56747627e-02f, 4.48640473e-02f, -2.15627521e-01f, 2.57565379e-01f, -4.57392573e-01f, 1.39682204e-01f,
  -4.94449347e-01f, 3.81521462e-03f, -5.37531853e-01f, -1.26484960e-01f, 3.33582789e-01f, -2.03706250e-01f, -3.98966759e-01f, 6.39508426e-01f, -1.58228025e-01f, 5.32415032e-01f,
  -1.30435392e-01f, 2.51318902e-01f, -8.62080511e-03f, -4.20145720e-01f, -6.41575277e-01f, 3.04571331e-01f, 3.66740860e-02f, -5.13432264e-01f, 2.70769864e-01f, 2.60110199e-01f,
  1.96999125e-02f, 5.18359244e-02f, 3.48849855e-02f, 5.74777909e-02f, 1.20847523e-01f, -1.15547523e-01f, 2.54810780e-01f, 1.23513073e-01f, 1.78284511e-01f, 3.37850600e-01f,
  1.99767649e-01f, 1.34736076e-01f, 3.94485086e-01f, -2.45153561e-01f, 1.48998603e-01f, -2.42033787e-02f, -3.50413352e-01f, -5.21162629e-01f, 1.39030203e-01f, -2.40954414e-01f,
  3.99195462e-01f, 6.26226887e-02f, 1.45246178e-01f, 2.67298147e-02f, 6.01891279e-01f, -2.47339129e-01f, -1.64873093e-01f, 9.67883766e-02f, 5.14323935e-02f, -5.00127792e-01f,
  1.60941690e-01f, 4.71863270e-01f, 7.53302872e-01f, -7.14294016e-01f, 1.13173530e-01f, 5.65811813e-01f, -4.11517620e-02f, -2.28359982e-01f, -7.11901963e-01f, 3.30082737e-02f,
  -1.47801787e-01f, -3.98611218e-01f, -4.46605325e-01f, -4.63842750e-01f, -6.21976331e-02f, 6.88475549e-01f, 6.77168846e-01f, -5.16963124e-01f, -7.63538599e-01f, 9.45518166e-02f,
  3.97516161e-01f, -1.05627641e-01f, -2.77211249e-01f, -6.18389472e-02f, -9.03409481e-01f, -2.17078447e-01f, -7.72960186e-01f, 1.00606453e+00f, -5.31724751e-01f, -1.76259324e-01f,
  -7.38043070e-01f, 3.12750526e-02f, 6.24948293e-02f, -7.36115158e-01f, 1.18606783e-01f, 1.42204419e-01f, -2.83712447e-01f, 2.53753781e-01f, 2.32391819e-01f, -3.78690451e-01f,
  1.30335957e-01f, 3.28122079e-02f, 7.55901486e-02f, -1.54553261e-02f, -8.30330625e-02f, 4.54678247e-03f, 3.52412879e-01f, 3.82096432e-02f, 4.16144431e-01f, 6.41814396e-02f,
  -6.54249549e-01f, 4.21914347e-02f, -1.60103455e-01f, -3.77485871e-01f, 1.96903303e-01f, 1.13799488e-02f, 2.63118088e-01f, 8.77328310e-03f, -3.68466914e-01f, 6.73482656e-01f,
  -3.05207402e-01f, -1.64203897e-01f, 8.69250298e-02f, 3.18324596e-01f, 4.20812190e-01f, -5.18684626e-01f, -2.68543303e-01f, 7.15149224e-01f, -4.73466486e-01f, -4.94195223e-01f,
  1.57390274e-02f, 3.48668188e-01f, -1.97137251e-01f, -9.37914789e-01f, -4.26623404e-01f, -9.49633956e-01f, -4.47940707e-01f, -6.16123915e-01f, -7.12241054e-01f, -3.25382859e-01f,
  -8.57810900e-02f, 3.57676685e-01f, -3.65836084e-01f, -2.98716784e-01f, -4.20271486e-01f, -4.34456706e-01f, 3.35656375e-01f, -2.59714931e-01f, -6.95527494e-01f, -7.11776391e-02f,
  1.01292133e+00f, 4.15888757e-01f, -2.17816353e-01f, -3.66070539e-01f, -4.42862093e-01f, -2.11366937e-01f, -6.11275315e-01f, -8.23771358e-01f, -1.84250832e-01f, -1.80561423e-01f,
  -2.79667497e-01f, -1.86382860e-01f, -6.01064414e-02f, -1.69265866e-01f, -2.69255459e-01f, -3.82134944e-01f, -3.07623923e-01f, -1.81804061e-01f, 9.70423371e-02f, 4.75271419e-02f,
  -2.49792233e-01f, -9.30461846e-03f, -7.60784969e-02f, 1.16071023e-01f, -2.48409924e-03f, 4.69751619e-02f, -8.97895843e-02f, 3.84908259e-01f, 3.05317581e-01f, 1.79353908e-01f,
  -8.61240402e-02f, -9.72594768e-02f, -4.88178730e-01f, -6.85303926e-01f, -5.26598513e-01f, -3.35080057e-01f, -3.19193117e-02f, 3.66320461e-01f, 1.01740040e-01f, 5.89850843e-01f,
  -3.38391006e-01f, 3.86385053e-01f, 4.12492603e-01f, -4.25000936e-01f, -4.07129496e-01f, -5.27463078e-01f, 3.24740946e-01f, -4.83773768e-01f, -8.38291198e-02f, -1.77859172e-01f,
  2.49197647e-01f, -3.77284557e-01f, -4.97042894e-01f, 9.63655651e-01f, 1.79978654e-01f, -2.77832078e-05f, 6.30149007e-01f, -1.35656402e-01f, -1.75299972e-01f, -4.22552794e-01f,
  -6.19202554e-02f, -1.54322863e-01f, -7.17021972e-02f, -5.40482819e-01f, -2.12149411e-01f, -6.91726282e-02f, -5.20752743e-02f, -1.67810753e-01f, -2.15101242e-01f, 2.27287203e-01f,
  -3.60149264e-01f, 2.79221922e-01f, 2.07101703e-01f, 2.72234201e-01f, 2.31071442e-01f, -9.08723399e-02f, -4.68023308e-02f, 1.61734775e-01f, -1.48848906e-01f, -2.64275577e-02f,
  1.59788519e-01f, 1.20904982e-01f, -1.76782668e-01f, -2.23580793e-01f, -5.21419525e-01f, 1.61144078e-01f, -8.29656050e-02f, 1.79349974e-01f, 3.62195283e-01f, 8.51167962e-02f,
  2.71488309e-01f, -3.77050698e-01f, 2.94003248e-01f, -3.16283643e-01f, 3.20042640e-01f, 3.43884110e-01f, -1.54792055e-01f, -2.37285540e-01f, -8.09193254e-01f, 5.26356220e-01f,
  -3.29366177e-01f, -6.56844527e-02f, -3.93083245e-01f, 3.09513718e-01f, 6.54493690e-01f, 1.00431129e-01f, 3.80529314e-01f, -4.28653747e-01f, 2.08658621e-01f, -7.06483647e-02f,
  -4.97182339e-01f, -7.61328578e-01f, 1.96542099e-01f, -2.96389371e-01f, 7.87292063e-01f, -5.83118618e-01f, 8.77640903e-01f, 8.43390897e-02f, -1.23716384e-01f, -3.28733087e-01f,
  -2.54572719e-01f, -5.63644528e-01f, 3.15439194e-01f, -6.54379129e-01f, -3.72283727e-01f, 2.86612272e-01f, 2.75385767e-01f, -1.18441515e-01f, 4.42474596e-02f, -6.03366077e-01f,
  4.33083981e-01f, -3.27708751e-01f, 1.47385716e-01f, -3.15763146e-01f, -8.93946826e-01f, -3.00742239e-01f, 3.19134951e-01f, 6.63453341e-02f, -1.00047335e-01f, 2.04961553e-01f,
  -1.43472701e-01f, 2.59432733e-01f, 1.23567339e-02f, -3.27581502e-02f, 1.33325323e-01f, 4.50866222e-02f, 2.49004707e-01f, -4.35285419e-02f, -1.65556803e-01f, 2.95794666e-01f,
  4.83082265e-01f, 2.75609463e-01f, 6.36274278e-01f, 1.03857860e-01f, -3.99672002e-01f, -2.95521840e-02f, -5.09658039e-01f, 4.85127091e-01f, -3.35269779e-01f, -5.32377303e-01f,
  -1.03762972e+00f, 1.35598913e-01f, -6.17563248e-01f, -8.80031288e-01f, 1.74986333e-01f, -8.38929415e-02f, -1.23812966e-01f, -6.44851401e-02f, 8.34888741e-02f, -9.29954648e-01f,
  -2.25309849e-01f, 2.19099969e-01f, 3.19879562e-01f, 4.29074019e-01f, -6.13433659e-01f, 7.06465364e-01f, -3.87745053e-01f, 8.28082561e-01f, -5.28416753e-01f, -1.30220026e-01f,
  -4.83075708e-01f, -8.83490086e-01f, -3.94030273e-01f, 1.13753162e-01f, 4.41913545e-01f, -6.55543685e-01f, -3.50219965e-01f, 7.21939802e-01f, 1.91456899e-01f, -1.29457921e-01f,
  -7.05812752e-01f, -3.26898515e-01f, -9.83697951e-01f, 9.99011025e-02f, -6.85408831e-01f, -4.25294995e-01f, -9.14533377e-01f, 4.61943328e-01f, -5.41777670e-01f, -4.53845084e-01f,
  7.06874058e-02f, 1.84089899e-01f, -2.42586378e-02f, -5.27393743e-02f, 8.10993277e-03f, 2.04253912e-01f, 1.16149716e-01f, 2.30660643e-02f, 1.68166369e-01f, 2.70361513e-01f,
  3.16711655e-03f, 2.22164199e-01f, -8.77767205e-02f, 4.20695633e-01f, -3.28128994e-01f, -2.35030092e-02f, 3.87590200e-01f, -3.67238298e-02f, 1.32544577e-01f, -1.94589242e-01f,
  -2.25152940e-01f, -1.98785231e-01f, 3.43381792e-01f, -2.82306314e-01f, -4.26700741e-01f, -2.99850076e-01f, 7.78683901e-01f, -1.15495227e-01f, -4.11151260e-01f, -3.22908789e-01f,
  -2.58439243e-01f, -3.12808186e-01f, -4.64265078e-01f, 2.29155019e-01f, -3.03910911e-01f, -4.68501627e-01f, -4.83147763e-02f, -4.37528610e-01f, -4.70458567e-01f, -6.36958838e-01f,
  -4.78042752e-01f, -4.80659157e-01f, 6.05073631e-01f, -9.85140443e-01f, -6.58437729e-01f, 7.01090991e-01f, -5.67452073e-01f, -3.13441932e-01f, -2.93163836e-01f, 3.57763469e-01f,
  8.19925517e-02f, -4.83414412e-01f, 1.62085131e-01f, 4.58550662e-01f, -5.98438323e-01f, -4.65723962e-01f, -4.33770597e-01f, -3.52589309e-01f, 6.56671464e-01f, 5.64989746e-01f,
  -4.09858704e-01f, 1.82197392e-01f, 3.48320425e-01f, -6.34562731e-01f, -6.87890202e-02f, -4.21861559e-03f, 1.31285498e-02f, 1.03574395e-01f, 2.96973381e-02f, 2.73134202e-01f,
  7.30685005e-03f, 6.59683198e-02f, -4.50088754e-02f, 9.88155697e-03f, 2.38405392e-02f, -1.06031291e-01f, -1.44542838e-02f, 1.30721316e-01f, -3.68794292e-01f, 1.57511130e-01f,
  -4.16583657e-01f, 8.17355067e-02f, -1.34834945e-01f, 2.14608610e-01f, -4.64625061e-01f, 3.11653674e-01f, 2.78138101e-01f, 4.91293371e-01f, 9.07543182e-01f, -6.86007261e-01f,
  -1.17153078e-01f, 4.54766415e-02f, -3.51660460e-01f, 6.19841099e-01f, 7.20043555e-02f, -4.74340737e-01f, -4.05872285e-01f, 4.16954085e-02f, -3.73449683e-01f, -5.81614196e-01f,
  3.36792022e-02f, 2.34938473e-01f, 8.02686036e-01f, -4.57741559e-01f, -5.40416181e-01f, -3.76211315e-01f, -5.50263263e-02f, 1.66194290e-01f, 4.42823142e-01f, -7.41160154e-01f,
  1.95127934e-01f, 5.95968544e-01f, 4.90980037e-02f, 1.67071167e-02f, -5.97778738e-01f, 4.34818268e-01f, -1.51499555e-01f, -4.17555630e-01f, 5.18028498e-01f, 2.13108376e-01f,
  -8.66229355e-01f, -5.21699846e-01f, -1.02136493e-01f, -2.75234938e-01f, -2.26766065e-01f, -3.01533729e-01f, 3.90280575e-01f, -1.37704447e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.00869972e-01f, 2.07114354e-01f, 1.98172584e-01f, -8.69216621e-02f, -1.24907233e-01f, 2.27704421e-01f, 8.53208080e-02f, -1.67769045e-02f, -5.20589724e-02f, 1.55042052e-01f,
  1.62221715e-01f, -9.64304954e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    