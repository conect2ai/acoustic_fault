/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.49472636e-02f, 2.52454907e-01f, -2.50768870e-01f, 2.23616716e-02f, -1.14386626e-01f, -1.83236450e-01f, -7.71139413e-02f, -1.35624027e-02f, 7.12233502e-03f, 1.54448479e-01f,
  6.88737407e-02f, 1.63032904e-01f, 2.27518201e-01f, 1.76202044e-01f, 8.64799470e-02f, -7.19381198e-02f, -6.54970184e-02f, -2.23047197e-01f, -6.50812015e-02f, -4.74101193e-02f,
  -2.80132927e-02f, 8.01460445e-02f, 1.22504905e-02f, -7.47688682e-05f, 2.42483127e-03f, 1.15658179e-01f, 3.84476930e-02f, -5.02883121e-02f, -8.88002515e-02f, -9.91757661e-02f,
  1.19685322e-01f, 7.18146143e-03f, 6.33157194e-02f, 1.77411914e-01f, 3.14764678e-02f, -4.24880460e-02f, 3.43975201e-02f, 9.60391760e-02f, 1.00963362e-01f, 3.44825424e-02f,
  7.93727040e-02f, -9.09791980e-03f, -8.59617442e-02f, -3.29871029e-02f, 3.30587700e-02f, -4.77597937e-02f, 5.84018789e-02f, -7.10207149e-02f, -6.84101507e-02f, 4.28958647e-02f,
  -5.09300530e-02f, -1.37446195e-01f, -7.37092569e-02f, -7.12483078e-02f, -1.89245306e-02f, -2.21990645e-02f, -3.68968099e-02f, 7.48746619e-02f, -9.72914398e-02f, 1.84427947e-01f,
  -3.86978313e-02f, -6.92180246e-02f, -7.41925016e-02f, -2.30349433e-02f, 2.77233329e-02f, 6.07309118e-02f, -7.01303482e-02f, -3.47621106e-02f, -7.13542402e-02f, -3.76399755e-02f,
  1.89106241e-02f, -1.58261545e-02f, 2.35027764e-02f, -1.76020376e-02f, 5.61061352e-02f, -4.21249606e-02f, -4.62124087e-02f, 1.02420732e-01f, -3.89588065e-02f, -1.40856411e-02f,
  6.46047220e-02f, -8.33284855e-02f, -1.15334298e-02f, 6.88783173e-03f, 8.56945233e-04f, -3.68719758e-03f, 2.98748165e-02f, 1.53150521e-02f, 1.56319365e-02f, -8.55334625e-02f,
  2.49549940e-01f, -1.11274824e-01f, 1.53576404e-01f, 8.65673199e-02f, 4.95415879e-03f, 4.17462587e-02f, -7.42100254e-02f, 6.34463206e-02f, -5.06172776e-02f, 5.48404939e-02f,
  -1.01976581e-02f, -6.85919821e-02f, 1.63401347e-02f, 1.85404178e-02f, -3.83764356e-02f, -7.13462308e-02f, 2.99874097e-02f, -1.13529183e-01f, 9.24467519e-02f, 7.52337128e-02f,
  3.34147960e-02f, 3.76019701e-02f, 1.48272626e-02f, -3.71413901e-02f, 2.22719498e-02f, -3.97269242e-02f, -5.14490269e-02f, 5.82273044e-02f, 6.61067246e-03f, 1.70070589e-01f,
  -2.22178936e-01f, -1.01886533e-01f, -5.37750609e-02f, -5.21823131e-02f, 4.57255319e-02f, -7.60917962e-02f, -2.38510326e-01f, 3.72387581e-02f, 1.98530555e-01f, -9.21155438e-02f,
  1.36548102e-01f, 4.61672433e-02f, 5.02075814e-02f, 1.30659968e-01f, 5.82485050e-02f, -4.72212471e-02f, -1.38842180e-01f, -5.64454012e-02f, 3.68985832e-02f, -7.78227001e-02f,
  2.84663914e-03f, -4.65948582e-02f, -8.38822722e-02f, 4.80254553e-02f, -7.38360509e-02f, -4.42406610e-02f, -9.03859213e-02f, -1.44374773e-01f, -1.03703171e-01f, -2.11200640e-01f,
  -3.83370742e-02f, 1.34452641e-01f, 9.80828255e-02f, -7.67669678e-02f, 8.46481323e-02f, -5.86523116e-02f, 7.68801942e-03f, -1.67659298e-02f, 6.56778291e-02f, -9.80855804e-03f,
  4.35935818e-02f, -4.89728246e-03f, -1.02732833e-02f, 3.75572555e-02f, 6.73462600e-02f, -1.99964009e-02f, 1.88922808e-02f, 8.71147066e-02f, 4.27887728e-03f, 7.20079467e-02f,
  -5.18406294e-02f, -1.29745856e-01f, -2.47724075e-03f, 1.36160463e-01f, 6.39963895e-02f, -3.47325020e-02f, 3.67143527e-02f, 6.40681013e-02f, -7.82340318e-02f, -1.99758455e-01f,
  2.10633166e-02f, -3.50808948e-02f, 9.88765061e-02f, 3.54758091e-02f, 4.60580774e-02f, 9.56825688e-02f, 8.53933394e-02f, 1.37482239e-02f, 7.13895336e-02f, -5.87417372e-02f,
  2.84715183e-02f, -2.44600661e-02f, 1.11099698e-01f, 5.41906208e-02f, 2.41864733e-02f, -2.00012736e-02f, -7.76035944e-03f, 8.98460746e-02f, 1.09048793e-02f, 3.40018533e-02f,
  -2.95360060e-03f, -2.36889087e-02f, 4.94762808e-02f, 2.67920252e-02f, 8.37997347e-02f, 2.13061795e-02f, 5.18756872e-03f, -1.80344563e-02f, 3.41113284e-02f, 6.34798035e-02f,
  1.07091807e-01f, 1.09242097e-01f, -9.51638967e-02f, -7.16270059e-02f, 4.93774191e-02f, 1.55509915e-02f, 3.22727039e-02f, 2.56291274e-02f, 1.01326391e-01f, -3.19837481e-02f,
  6.11445569e-02f, -1.16587954e-03f, 2.44581606e-02f, -8.14845599e-03f, 3.71248312e-02f, 7.74131343e-02f, 2.51335762e-02f, -6.16955571e-02f, -4.90950979e-02f, -7.29000345e-02f,
  -7.66913667e-02f, -1.50270745e-01f, -1.18018411e-01f, -9.21162814e-02f, -8.07641298e-02f, -8.10037255e-02f, -5.62091637e-03f, -1.48298502e-01f, -1.20356800e-02f, -1.59579143e-01f,
  -2.47749999e-01f, -3.77079397e-02f, -2.18045250e-01f, -1.30182728e-01f, -1.44204557e-01f, -2.43417993e-01f, -1.23578846e-01f, -1.71046242e-01f, 2.85905488e-02f, -1.46595731e-01f,
  1.07549448e-02f, -4.74721454e-02f, -1.08695939e-01f, 8.82590935e-02f, -9.79449302e-02f, -2.05562979e-01f, -6.27007410e-02f, -2.03276891e-02f, -2.22551953e-02f, -1.86686233e-01f,
  -5.00300676e-02f, -8.62962976e-02f, 4.72401269e-02f, -1.67759731e-02f, -1.30546719e-01f, -1.28582507e-01f, 4.15365444e-04f, -9.61586740e-03f, -9.96591076e-02f, -4.04093079e-02f,
  -3.74945045e-01f, -1.48420990e-01f, -2.74086464e-02f, 5.73455244e-02f, -1.14594050e-01f, -1.81278642e-02f, -1.03745654e-01f, 6.23081811e-02f, 6.61341995e-02f, -1.26314983e-01f,
  -4.68512774e-02f, 4.11722250e-02f, -4.13618330e-03f, 8.83973262e-04f, -9.29868296e-02f, -9.61221308e-02f, 3.21157165e-02f, -1.24365194e-02f, 7.19091594e-02f, 5.69403730e-02f,
  1.17432615e-02f, 5.16128214e-03f, -2.32350477e-03f, 2.07225233e-02f, 1.21013541e-02f, 8.62291828e-02f, -4.37907055e-02f, -4.09404263e-02f, 6.55175969e-02f, -1.15278699e-01f,
  -3.36163901e-02f, 8.82264972e-03f, 5.06468788e-02f, 1.07110433e-01f, 1.70889184e-01f, 8.48259702e-02f, 3.34331878e-02f, 1.06287543e-02f, 8.57264549e-02f, 6.08158521e-02f,
  9.91801396e-02f, 3.62532958e-02f, 1.05118684e-01f, 2.29329523e-02f, 1.24648109e-01f, 5.80422617e-02f, 1.37411013e-01f, 4.07180563e-02f, 1.06265716e-01f, 1.51095927e-01f,
  8.65687057e-02f, 1.58719197e-01f, 1.23478666e-01f, 1.27627954e-01f, 1.45443259e-02f, 1.23701796e-01f, -9.51083435e-04f, 2.07666866e-02f, -1.95610281e-02f, 2.15319153e-02f,
  -3.08122247e-01f, 1.52413383e-01f, -6.14958555e-02f, 2.88222078e-02f, -5.48940971e-02f, -3.74314263e-02f, 9.91684105e-03f, 7.07993805e-02f, -7.91856367e-03f, -9.21787471e-02f,
  -6.90204278e-02f, -6.67822957e-02f, -1.22650005e-01f, -2.78437734e-02f, -1.08921356e-01f, -4.62433659e-02f, 1.83177833e-02f, -7.27211311e-02f, -2.78893323e-03f, 7.94960707e-02f,
  -8.64126999e-03f, -3.42450626e-02f, -1.41973540e-01f, -3.66678573e-02f, -5.44988140e-02f, -7.08023012e-02f, -1.21420339e-01f, 1.94593966e-02f, 4.39372584e-02f, -7.36927427e-03f,
  1.95855543e-01f, 3.49241376e-01f, 3.37633580e-01f, 7.88081288e-02f, -1.65489748e-01f, -1.50006749e-02f, 8.33797380e-02f, -2.23578587e-02f, 6.78422302e-02f, 1.75617203e-01f,
  5.73737174e-02f, -4.27395850e-02f, 1.47710994e-01f, 2.92341728e-02f, -2.50905491e-02f, 1.83571294e-01f, 1.52688488e-01f, 1.26603628e-02f, -1.00024909e-01f, -1.20847292e-01f,
  -1.08363174e-01f, 1.63297042e-01f, 2.85412818e-02f, 1.13494083e-01f, 1.83853403e-01f, 3.92235890e-02f, 2.38805935e-01f, 2.47306779e-01f, 1.13130249e-01f, 1.78110361e-01f,
  3.02123547e-01f, 2.25315541e-01f, -6.54146895e-02f, -2.35856343e-02f, 4.47545014e-02f, 3.84283774e-02f, 5.95128760e-02f, 1.31765917e-01f, 3.65728922e-02f, 6.41302392e-02f,
  -1.42307477e-02f, 6.74462467e-02f, 1.27360523e-01f, 6.02765754e-02f, 1.07714519e-01f, 7.24345744e-02f, 1.73516169e-01f, 1.16183989e-01f, 1.24940388e-01f, 1.06471263e-01f,
  -7.96605553e-03f, 3.15563404e-03f, 1.79829940e-01f, 1.18640997e-01f, 8.63737762e-02f, 3.81399989e-02f, 2.31048048e-01f, 4.15409021e-02f, 1.17204040e-01f, 3.76841813e-01f,
  -5.13214208e-02f, -6.77871704e-02f, -1.85817257e-02f, -8.40467513e-02f, -1.72289059e-01f, -9.68394652e-02f, -9.92861912e-02f, -5.93122132e-02f, -9.91711393e-02f, -3.33532095e-02f,
  -1.98692113e-01f, -1.74384683e-01f, -1.40990213e-01f, -1.70753211e-01f, -1.54062793e-01f, -1.50344551e-01f, -1.88509375e-01f, -1.63897052e-01f, -2.43286759e-01f, -2.16199666e-01f,
  -2.30442628e-01f, -1.43441081e-01f, -1.49823785e-01f, -1.09853327e-01f, -6.98738992e-02f, -7.37407506e-02f, -1.82704255e-01f, -1.45428315e-01f, -6.21928610e-02f, -8.48890245e-02f,
  1.79298222e-03f, -6.80691451e-02f, 1.35864183e-01f, 5.04152589e-02f, 1.27864406e-01f, 1.54026687e-01f, 1.33488029e-01f, -4.55317870e-02f, -1.07908063e-02f, 1.99946910e-01f,
  -2.48053111e-02f, 8.92158896e-02f, 1.27301663e-01f, 7.07373619e-02f, -3.50794308e-02f, 1.54574802e-02f, 2.18542330e-02f, 7.89548680e-02f, -6.61229342e-02f, 9.99258608e-02f,
  6.62924424e-02f, -2.53653396e-02f, -1.42947268e-02f, 1.17917597e-01f, 4.99330685e-02f, 6.01368695e-02f, 2.20811799e-01f, 1.60053715e-01f, 1.10605270e-01f, 2.07832217e-01f,
  -4.44703579e-01f, 9.26525742e-02f, -1.12655923e-01f, -2.35948488e-01f, 2.30904389e-02f, 1.61039248e-01f, 2.92120665e-01f, 1.18174434e-01f, -2.51279604e-02f, -8.35586488e-02f,
  -5.18708527e-02f, -2.31010035e-01f, -2.55438656e-01f, -1.74381822e-01f, -4.57416885e-02f, -3.39485444e-02f, -1.60170108e-01f, -2.45933160e-01f, -1.97897315e-01f, 5.18319346e-02f,
  -4.77816872e-02f, -1.37467697e-01f, -1.17910512e-01f, -1.61936074e-01f, -6.69416115e-02f, -9.02339518e-02f, 4.71236445e-02f, 8.07895232e-03f, 2.67313104e-02f, -2.41384193e-01f,
  -3.31844240e-01f, 6.72971597e-04f, -6.38450831e-02f, -1.72864646e-01f, -3.97003405e-02f, -3.57863605e-02f, -1.22287676e-01f, -1.18120313e-01f, -1.26493022e-01f, -1.13781363e-01f,
  -6.53172098e-03f, -1.14504443e-02f, -1.63090721e-01f, -6.11745194e-02f, -3.73136476e-02f, 2.54361834e-02f, -2.35789139e-02f, -8.03885907e-02f, -1.13442943e-01f, -1.14685394e-01f,
  -2.87501123e-02f, -1.11144915e-01f, 3.27162147e-02f, -4.98910323e-02f, 5.04696257e-02f, -1.79353446e-01f, 2.85145435e-02f, -1.21730454e-02f, -5.72970994e-02f, -8.12487602e-02f,
  2.41186973e-02f, 2.68172715e-02f, 1.02764487e-01f, 2.27031186e-02f, 3.44850123e-02f, 1.06483549e-01f, -3.99966240e-02f, 9.26978290e-02f, 6.50761323e-03f, 4.98679578e-02f,
  1.00835584e-01f, 5.16167507e-02f, 1.25501379e-02f, 9.37391073e-02f, 3.58286285e-04f, 1.26728863e-02f, 7.01569812e-03f, -6.01782985e-02f, 1.29998803e-01f, 8.11211988e-02f,
  -2.13703960e-02f, 8.54839385e-02f, 6.79072142e-02f, -1.03867454e-02f, 1.29091620e-01f, -5.61811291e-02f, 7.97332078e-02f, 1.23282462e-01f, 2.71951850e-03f, 9.86584127e-02f,
  -1.51998252e-01f, -1.29100278e-01f, -2.30825767e-01f, -1.24918297e-01f, -8.20004642e-02f, -3.54913846e-02f, -1.55740246e-01f, -1.56461418e-01f, -8.18081424e-02f, -9.78543758e-02f,
  -1.70337874e-02f, -8.65638033e-02f, -6.78479746e-02f, -1.07480764e-01f, -4.03795252e-03f, -1.00906998e-01f, -1.42545953e-01f, -2.39652842e-01f, -2.31023151e-02f, -9.92199685e-03f,
  -1.75865307e-01f, -8.14961269e-02f, -1.55872449e-01f, -3.59673984e-02f, -9.64897051e-02f, -2.39578679e-01f, -3.83635871e-02f, -7.96236172e-02f, -5.53300381e-02f, -7.33989850e-02f,
  3.90183330e-01f, 2.38156632e-01f, 2.07329541e-02f, 2.23539218e-01f, 2.11849380e-02f, -5.93372472e-02f, 1.86662823e-01f, 1.12824716e-01f, 8.61967504e-02f, 1.58605278e-01f,
  -3.43792364e-02f, 1.04715385e-01f, 1.00725368e-01f, 6.89766258e-02f, 2.01207101e-01f, 2.56843150e-01f, 2.42983326e-01f, 1.23705387e-01f, -6.20855130e-02f, -5.77602535e-02f,
  9.87383649e-02f, 4.43393812e-02f, 6.20513596e-02f, -2.48018932e-02f, 1.41055673e-01f, 4.50634807e-02f, -1.10586025e-02f, 2.53117792e-02f, 5.05975038e-02f, 1.27095684e-01f,
  6.27011508e-02f, 1.56093299e-01f, -5.94637170e-03f, 1.25729933e-01f, -2.56083049e-02f, 5.51692955e-02f, 3.06109153e-02f, 1.17073447e-01f, 9.94330272e-02f, 7.23512098e-02f,
  3.99322212e-02f, 1.46918446e-01f, 1.33427739e-01f, 1.62709996e-01f, 1.93144605e-02f, 2.17313357e-02f, 1.71055838e-01f, 1.99838683e-01f, 1.91732094e-01f, 1.04847744e-01f,
  1.83550894e-01f, 5.74326180e-02f, -2.12219134e-02f, 4.96539362e-02f, 7.67810345e-02f, 5.80168217e-02f, 1.27089277e-01f, 1.10918343e-01f, 5.37709892e-02f, 1.07674353e-01f,
  -4.51933853e-02f, -1.50223181e-01f, -1.17360897e-01f, -1.03486925e-01f, -1.62755735e-02f, -3.93323563e-02f, -8.63225833e-02f, -1.64932981e-02f, -9.32650566e-02f, -1.08539343e-01f,
  -1.01105981e-01f, -2.35399175e-02f, -3.29467887e-03f, -8.08938071e-02f, -6.10475764e-02f, -1.05332315e-01f, -2.77240109e-03f, -1.00426517e-01f, -4.65252697e-02f, -3.91887240e-02f,
  -9.47290137e-02f, -1.40923992e-01f, -1.30846918e-01f, 1.69937201e-02f, 3.19731492e-03f, 1.11776544e-02f, -9.90210250e-02f, -1.59802407e-01f, -1.12887338e-01f, 2.17645708e-03f,
  -8.66547599e-02f, -1.20826496e-03f, 1.52655810e-01f, 9.60471109e-02f, 7.49888197e-02f, 1.09918579e-01f, 8.97498056e-02f, 3.00041959e-02f, 1.21651031e-01f, 4.18374687e-02f,
  9.10941660e-02f, 6.68767393e-02f, 8.67318064e-02f, 2.94184294e-02f, -1.74536202e-02f, 3.46974283e-02f, 1.35988310e-01f, 6.98888525e-02f, 1.58816591e-01f, 2.31535360e-02f,
  1.13354117e-01f, -1.89828069e-03f, -6.00254722e-02f, 5.74994981e-02f, 2.03293981e-03f, -7.64321834e-02f, -3.38551067e-02f, 4.43495251e-02f, -8.82738456e-02f, 2.16094516e-02f,
  1.46021545e-01f, -2.22391412e-01f, 8.08233023e-02f, 5.29370755e-02f, -6.10658973e-02f, -3.10333557e-02f, -2.36498684e-01f, 9.13088769e-02f, 2.05999985e-01f, -1.22453950e-01f,
  -1.61196515e-01f, 1.24787003e-01f, 2.11932495e-01f, 2.12961182e-01f, 3.16469759e-01f, 1.24583773e-01f, 2.39605039e-01f, 3.24969471e-01f, 2.73581713e-01f, 2.15412393e-01f,
  5.10577373e-02f, 1.84496358e-01f, 2.97139347e-01f, 1.36815146e-01f, 5.61998179e-03f, 9.69128311e-02f, 1.67577580e-01f, 9.31866094e-02f, 3.87021266e-02f, -1.48995500e-02f,
  1.63466260e-02f, 1.12448260e-01f, 2.29599476e-01f, 1.74606740e-01f, 8.46916363e-02f, 2.09001154e-01f, 1.32084906e-01f, 1.21414915e-01f, 1.28173932e-01f, 1.95936263e-01f,
  9.82739255e-02f, 1.59954831e-01f, 7.02428520e-02f, 2.06775680e-01f, 8.43255296e-02f, 1.85347572e-01f, 1.93665504e-01f, 2.81485826e-01f, 2.54013866e-01f, 4.37230952e-02f,
  -4.45196107e-02f, 1.38318107e-01f, 1.49705917e-01f, 7.24140927e-02f, 2.33463824e-01f, 2.53641158e-01f, 1.14943393e-01f, 1.87550604e-01f, 2.13397890e-01f, 6.18371069e-02f,
  -8.00102651e-02f, -8.81323405e-03f, 5.36645874e-02f, -5.34930490e-02f, -5.23566529e-02f, -6.44947514e-02f, 1.14289504e-02f, -1.01391718e-01f, 6.10850081e-02f, 5.19391075e-02f,
  -3.27249467e-02f, -3.11564915e-02f, 4.59633395e-02f, 2.20934264e-02f, -4.25661728e-02f, -2.01446982e-03f, 4.25227135e-02f, -6.47784546e-02f, 2.46882103e-02f, -3.22311409e-02f,
  7.05553219e-02f, -6.07303306e-02f, -6.29007444e-02f, 3.21719795e-02f, -2.86915828e-03f, 1.71115585e-02f, 8.16940814e-02f, 8.98740627e-03f, 4.82901698e-03f, -6.54123425e-02f,
  1.19015619e-01f, 1.98086500e-01f, 8.97924080e-02f, 1.32085934e-01f, 7.21280798e-02f, 3.88932787e-02f, 5.90217067e-03f, 1.53237373e-01f, 5.80819622e-02f, 1.09755479e-01f,
  8.11072737e-02f, 1.21516228e-01f, 9.70215052e-02f, 2.87819039e-02f, 1.50693670e-01f, 9.49051231e-02f, -1.79460626e-02f, 4.50000428e-02f, 1.57411322e-01f, 7.23298416e-02f,
  4.63516591e-03f, 1.07711263e-01f, 6.58532754e-02f, 1.12942718e-01f, 4.05966267e-02f, 1.54374301e-01f, 1.04260422e-01f, 1.36225283e-01f, 2.02153534e-01f, -4.61223945e-02f,
  -4.30786610e-01f, 2.87882239e-01f, 1.52460501e-01f, -2.32834339e-01f, -5.14375828e-02f, -2.88747586e-02f, 2.49293759e-01f, 1.01527311e-01f, -4.73509356e-02f, 5.47197051e-02f,
  9.80128795e-02f, -5.57328053e-02f, 1.47648770e-02f, 1.03229627e-01f, 1.15151934e-01f, 1.31378099e-01f, 1.29230335e-01f, -9.84774753e-02f, -4.21726033e-02f, -9.72389504e-02f,
  -8.94697607e-02f, -7.67414877e-03f, 1.81712657e-02f, -8.68233503e-04f, 7.12940097e-02f, -3.84114422e-02f, 1.64661989e-01f, 1.27190590e-01f, 8.11780542e-02f, -9.57740694e-02f,
  -2.64212806e-02f, -1.05774537e-01f, -1.23107359e-01f, -5.03147058e-02f, 4.66810018e-02f, -3.97459082e-02f, -1.46996275e-01f, -9.40851960e-03f, -3.76783386e-02f, -1.25083290e-02f,
  -9.84278992e-02f, -8.55280682e-02f, 1.05037633e-03f, 1.78726744e-02f, -5.69855906e-02f, 3.77039425e-02f, 1.03788719e-01f, 6.36565909e-02f, 4.80999127e-02f, 2.15073675e-02f,
  -2.60672458e-02f, -9.62322280e-02f, 8.88451040e-02f, 1.58989236e-01f, 5.44442274e-02f, -5.22037819e-02f, 1.28604293e-01f, -1.63604058e-02f, 1.31684586e-01f, -4.83991615e-02f,
  7.80209750e-02f, -2.13491805e-02f, -5.25387935e-03f, 9.88777652e-02f, -2.92679667e-02f, 3.14892456e-02f, 1.47848669e-02f, 7.49291331e-02f, -8.65652971e-03f, -1.16319871e-02f,
  3.60404588e-02f, -2.99113337e-02f, 7.38792568e-02f, -8.45690444e-02f, 1.54829472e-02f, -3.17030251e-02f, 4.07160707e-02f, 7.45954290e-02f, 2.23143045e-02f, 9.18194558e-03f,
  -1.39841000e-02f, -3.26299295e-02f, -9.10951495e-02f, 8.13872144e-02f, -7.10195750e-02f, 1.82725452e-02f, -7.69897178e-02f, -5.67444488e-02f, -1.28118845e-03f, 3.73851019e-03f,
  -3.71181853e-02f, 9.18444991e-03f, -8.26594904e-02f, -7.83549175e-02f, -1.29701987e-01f, -4.62934338e-02f, -4.05965047e-03f, 6.65473416e-02f, -9.46296826e-02f, -6.71758279e-02f,
  -5.86250275e-02f, 5.68728196e-03f, 4.63893339e-02f, 3.53823751e-02f, -8.80337844e-04f, -4.11520228e-02f, -1.28325429e-02f, 2.23915204e-02f, -6.11300319e-02f, 6.26787171e-02f,
  7.12875053e-02f, 5.28409332e-03f, -1.72319971e-02f, 3.35262679e-02f, 4.45965379e-02f, -4.31292057e-02f, 1.17877297e-01f, 8.31228346e-02f, 2.03456786e-02f, 1.19858965e-01f,
  3.91886353e-01f, 3.84779572e-01f, -7.93662220e-02f, 5.56476675e-02f, -1.02406684e-02f, -7.94407427e-02f, 7.91623220e-02f, 4.77986410e-03f, -1.03852533e-01f, -3.07871122e-02f,
  1.12350464e-01f, 7.56847411e-02f, -6.21154644e-02f, -2.68078018e-02f, 7.93358078e-04f, -1.61362901e-01f, -1.23922467e-01f, -1.95792586e-01f, -2.78569579e-01f, -2.20617622e-01f,
  -1.49181738e-01f, -1.14058666e-01f, -8.48024637e-02f, -2.27784161e-02f, -1.38721406e-01f, -6.65236413e-02f, -1.37256399e-01f, -1.05910957e-01f, -8.63899067e-02f, -1.31630346e-01f,
  -1.76752098e-02f, 2.87126690e-01f, -7.88568556e-02f, 1.29790321e-01f, 5.17813042e-02f, -4.66578528e-02f, 7.10950345e-02f, -8.99146423e-02f, -4.23064977e-02f, 7.18798041e-02f,
  8.73978622e-03f, 1.09360524e-01f, 2.10827496e-02f, 1.95623692e-02f, -1.56246405e-02f, -1.94194578e-02f, 3.15881483e-02f, 2.61951983e-02f, -4.87994999e-02f, -2.84337299e-03f,
  3.59817632e-02f, 1.22018851e-01f, 6.44320622e-02f, -4.91194651e-02f, -4.90878746e-02f, 3.35064121e-02f, 5.58200181e-02f, 3.20068635e-02f, 3.30163613e-02f, 4.45378646e-02f,
  5.44806421e-02f, 4.12276946e-02f, 6.48034289e-02f, 7.01494589e-02f, -2.52525359e-02f, -1.35604907e-02f, -9.07980725e-02f, -5.74983247e-02f, -7.48108998e-02f, 1.46800894e-02f,
  4.57244851e-02f, -5.25732078e-02f, -5.59427589e-03f, -2.40127407e-02f, -2.78796852e-02f, -1.03428453e-01f, 1.28113152e-02f, 1.30333733e-02f, -1.47217676e-01f, -5.39454911e-03f,
  -8.00399482e-02f, -7.05454201e-02f, -9.19259861e-02f, -7.48903900e-02f, 4.67537418e-02f, -2.50865910e-02f, -7.22542778e-02f, -3.11609469e-02f, -3.35908234e-02f, 4.37091477e-02f,
  -5.63391559e-02f, 1.27896547e-01f, -5.92694618e-02f, -2.54512653e-02f, -6.95926249e-02f, -7.36797228e-02f, -4.67699673e-03f, 5.78734353e-02f, 7.68697038e-02f, -9.84504372e-02f,
  -3.76598835e-02f, -5.23326173e-02f, -4.53246012e-02f, -6.74226284e-02f, -1.42068118e-01f, 3.27584185e-02f, -3.58487666e-02f, -8.63733515e-02f, -1.59341730e-02f, 6.90789521e-02f,
  -1.70280896e-02f, -8.31898451e-02f, -1.63347527e-01f, 2.13142820e-02f, -8.32446069e-02f, -1.78861674e-02f, -1.23988070e-01f, -1.28148058e-02f, -9.58765820e-02f, -2.27999631e-02f,
  -2.21985951e-01f, 1.30420968e-01f, 2.45432332e-02f, 1.45333447e-02f, 1.56876504e-01f, 7.65802339e-02f, 3.04180942e-02f, -1.29374757e-01f, 4.16405965e-03f, 6.39972016e-02f,
  8.01515020e-03f, 4.50486114e-04f, 3.89111377e-02f, -6.57335445e-02f, -5.35273775e-02f, -3.80209982e-02f, 7.04131722e-02f, -9.54422504e-02f, -5.11732362e-02f, 8.28449503e-02f,
  1.46552905e-01f, -8.71524438e-02f, -1.95740327e-01f, -6.74522575e-03f, 6.96209818e-02f, 7.72681087e-02f, 7.13706836e-02f, 1.00336820e-01f, 1.15571186e-01f, 9.71813574e-02f,
  1.70593798e-01f, -6.11385852e-02f, -2.81347856e-02f, -5.44214696e-02f, -4.98996191e-02f, -1.47141784e-01f, -1.35940999e-01f, -7.30828494e-02f, -6.39538839e-02f, -8.96048844e-02f,
  5.38480952e-02f, 2.97636725e-02f, -1.59527902e-02f, -6.30341619e-02f, -9.94754303e-03f, -4.95023243e-02f, -1.06672913e-01f, -1.33773327e-01f, -1.49922490e-01f, -4.10091206e-02f,
  -1.92564714e-03f, 2.91353688e-02f, -8.30393136e-02f, -8.62624943e-02f, -1.18264571e-01f, 3.92370149e-02f, -6.03485145e-02f, -1.20635167e-01f, -1.70531705e-01f, 1.07069043e-02f,
  -1.11985721e-01f, 5.70922531e-02f, 8.34493488e-02f, 1.84359103e-02f, 1.84398647e-02f, 5.65213077e-02f, 5.29713780e-02f, 7.62230977e-02f, 3.04808058e-02f, -5.90807945e-02f,
  -2.69369055e-02f, -2.39325389e-02f, 4.57021827e-03f, 2.60619000e-02f, -5.25261462e-03f, 2.91707646e-03f, 6.86201081e-02f, -8.71038660e-02f, -2.62844153e-02f, -9.83912125e-03f,
  -3.32334898e-02f, -1.43372407e-02f, 3.92027199e-02f, -3.84745374e-02f, 9.51908529e-03f, 1.12697389e-02f, 6.05345070e-02f, 2.03838246e-03f, -1.25424955e-02f, -2.00669039e-02f,
  -1.88824698e-01f, -1.52593479e-01f, -5.20649739e-03f, -9.86949056e-02f, 1.29071632e-02f, 2.76887827e-02f, 6.68857172e-02f, -1.02914415e-01f, 3.59014012e-02f, -7.86686763e-02f,
  -5.76732270e-02f, -4.40459959e-02f, -9.33688134e-02f, 4.27983701e-02f, -2.57926416e-02f, -1.05642177e-01f, 4.41878736e-02f, 4.99969237e-02f, -1.85486469e-02f, -1.10126667e-01f,
  -6.37449026e-02f, -7.90706947e-02f, -3.82248983e-02f, -9.53735635e-02f, -7.64381662e-02f, -1.88116327e-01f, -8.76132920e-02f, -1.88166425e-02f, -8.48627612e-02f, -2.52214611e-01f,
  3.83754432e-01f, -1.04170041e-02f, -1.59371961e-02f, 6.23130351e-02f, -1.79355457e-01f, -3.19990516e-02f, -1.38447704e-02f, 2.90478300e-02f, 8.45296979e-02f, 1.71695892e-02f,
  -4.52775843e-02f, 3.71606089e-02f, -3.15566920e-02f, 1.08064385e-03f, 2.99386848e-02f, -9.05789360e-02f, -1.65333703e-01f, 8.48987773e-02f, 1.52542591e-01f, -1.68019831e-02f,
  -5.70297167e-02f, -2.88943406e-02f, 2.01741517e-01f, 9.91806984e-02f, -2.14214227e-03f, 1.11510083e-02f, 1.73148103e-02f, 5.24641089e-02f, -5.66033199e-02f, -1.05647445e-01f,
  1.96749270e-01f, 1.62080705e-01f, 4.20140624e-02f, -8.06638673e-02f, -8.41212124e-02f, 8.17885324e-02f, 5.65395541e-02f, 1.02483250e-01f, -3.28955576e-02f, 5.22686690e-02f,
  1.66991111e-02f, 3.74691933e-02f, -4.85389531e-02f, 7.42918253e-02f, 5.70585690e-02f, 5.73828779e-02f, -2.59333644e-02f, 3.40170711e-02f, 8.16652402e-02f, 1.10879891e-01f,
  -5.45158684e-02f, -6.33227406e-03f, 1.12714194e-01f, 2.84774359e-02f, -4.92677372e-03f, -9.47800130e-02f, -6.45327419e-02f, -7.53158797e-03f, -5.48419133e-02f, 4.53150161e-02f,
  -3.74696963e-02f, -7.29275448e-03f, -6.26611039e-02f, 6.82285801e-02f, -1.07541360e-01f, 3.66669632e-02f, 2.29956694e-02f, -4.28317524e-02f, 1.57324467e-02f, -2.96463855e-02f,
  -4.28479277e-02f, 4.69838381e-02f, -5.68097048e-02f, -1.54309440e-02f, -1.19619966e-02f, -4.77185100e-02f, -8.10803846e-02f, -6.84317872e-02f, 2.80140396e-02f, -3.32418345e-02f,
  -7.26910830e-02f, 1.56099806e-02f, -6.03196472e-02f, 6.43868223e-02f, -1.40433222e-01f, -5.41026630e-02f, -9.02640074e-02f, 2.06285762e-03f, -3.81093030e-03f, -5.87497186e-03f,
  9.51870680e-02f, -1.27520129e-01f, -3.03002521e-02f, -1.86116099e-02f, 8.37650970e-02f, -8.64423662e-02f, 4.58814576e-02f, -7.11429864e-02f, -5.20660952e-02f, 7.12206215e-02f,
  2.00423636e-02f, 4.23391573e-02f, 5.10374978e-02f, 6.51000738e-02f, 1.13563582e-01f, -5.36684692e-03f, -1.16943315e-01f, -7.79559510e-03f, 4.43163551e-02f, 1.89893264e-02f,
  -4.56381142e-02f, 1.07747251e-02f, 1.09375052e-01f, 2.92773619e-02f, 1.22411335e-02f, 3.83437611e-02f, 3.11406888e-02f, 5.59885837e-02f, 6.50155693e-02f, -6.78949850e-03f,
  2.98447102e-01f, 5.95760271e-02f, -1.36818558e-01f, 2.56836087e-01f, 8.62955824e-02f, -1.08292468e-01f, -1.27679437e-01f, 3.21434960e-02f, 1.21855855e-01f, 7.39538521e-02f,
  4.54089902e-02f, 1.04872569e-01f, 7.18509704e-02f, 1.36486972e-02f, -1.37112573e-01f, -4.56487499e-02f, -1.41758136e-02f, -1.57316729e-01f, -1.24424741e-01f, -8.98340775e-04f,
  2.31167935e-02f, 1.84621379e-01f, 1.44859076e-01f, 1.27431884e-01f, 1.38474390e-01f, 1.99310750e-01f, 2.10642014e-02f, 5.98755628e-02f, 7.17302784e-02f, 1.16982237e-01f,
  -9.18304548e-02f, -8.97387192e-02f, 7.43386224e-02f, 1.07343152e-01f, 1.80906449e-02f, 7.77713731e-02f, 1.11600935e-01f, -2.65352465e-02f, 1.28277779e-01f, 7.31714442e-02f,
  9.15422738e-02f, 4.24577333e-02f, 6.91398829e-02f, 7.89195895e-02f, 1.75014883e-02f, 2.99497265e-02f, 1.40605075e-02f, -5.44521548e-02f, 6.57472834e-02f, 6.84494451e-02f,
  5.49808256e-02f, 7.31832385e-02f, 4.55114990e-02f, -4.84986082e-02f, -9.16083157e-02f, 1.33813852e-02f, -2.92339586e-02f, 3.63454446e-02f, 1.00613646e-02f, 6.62419051e-02f,
  -3.23694274e-02f, 7.64347287e-03f, -1.15085219e-03f, -5.39255738e-02f, 3.71795259e-02f, 4.09754701e-02f, -7.90483281e-02f, -2.22697109e-02f, -1.36911916e-02f, -7.25226551e-02f,
  -3.19769308e-02f, -6.27419874e-02f, -1.35613710e-01f, -1.09400086e-01f, -4.51422706e-02f, -1.12743318e-01f, -7.70530701e-02f, -4.47801724e-02f, -4.29185927e-02f, 3.33393775e-02f,
  -1.74498055e-02f, -9.11402479e-02f, -3.22480057e-03f, -1.52350008e-01f, -2.56613586e-02f, -8.73101875e-02f, -7.30082989e-02f, -2.05191970e-02f, 7.16487393e-02f, -1.04674630e-01f,
  2.50176370e-01f, -1.15514407e-02f, 1.09561346e-01f, -8.13616142e-02f, 8.14260021e-02f, 5.22820987e-02f, 1.15860276e-01f, 7.18729869e-02f, 4.48060594e-02f, -5.54423854e-02f,
  2.45896447e-02f, 3.16295996e-02f, 3.20894942e-02f, 9.53505859e-02f, 1.12629183e-01f, 9.99018252e-02f, 1.38088018e-01f, -4.08577354e-04f, 9.76765305e-02f, -5.91961620e-03f,
  4.78650369e-02f, 1.18544325e-01f, 1.24629349e-01f, 3.48409195e-03f, 8.23863894e-02f, 1.08671449e-01f, 7.49520063e-02f, 1.36510313e-01f, -4.39997576e-02f, 8.05259421e-02f,
  4.17171121e-02f, -1.78097993e-01f, 6.37595206e-02f, -2.43142173e-02f, -7.47195184e-02f, -8.17398056e-02f, -1.85608551e-01f, -4.41973396e-02f, -5.37084751e-02f, -1.21320866e-01f,
  -6.26538768e-02f, 6.99500069e-02f, 1.05227891e-03f, 1.29872160e-02f, -5.25702313e-02f, -1.26492992e-01f, -1.24511085e-01f, -8.33211765e-02f, -5.86242322e-03f, 5.65048307e-02f,
  -2.30800696e-02f, 1.87254101e-02f, 2.86694453e-03f, 6.23222068e-02f, 6.29561916e-02f, 9.39098746e-02f, 1.35181203e-01f, -2.21167691e-02f, 3.10393143e-02f, -7.38018751e-02f,
  2.15194583e-01f, -1.99186988e-02f, -8.55062306e-02f, -2.46851202e-02f, -4.92745405e-03f, 6.65116496e-03f, 5.33128306e-02f, 1.06143534e-01f, -3.00458856e-02f, -9.41752736e-03f,
  -8.17403868e-02f, 9.79017168e-02f, 3.15120560e-03f, 4.87533659e-02f, 3.45425457e-02f, 9.06767137e-03f, -4.79792990e-02f, 3.36097665e-02f, 6.79533705e-02f, 1.17687613e-01f,
  4.42949543e-03f, -7.47382417e-02f, -6.28115386e-02f, 1.85020047e-03f, -2.32021511e-03f, 8.28912780e-02f, 8.33511166e-03f, 6.41583651e-02f, 3.84624265e-02f, -2.51267571e-02f,
  -8.43376592e-02f, 9.27908719e-03f, -2.43663061e-02f, 2.45081168e-02f, -9.41767320e-02f, 1.62313860e-02f, 1.41528025e-02f, -9.73315984e-02f, -9.37453508e-02f, -1.02030993e-01f,
  -6.96688443e-02f, -7.03163296e-02f, 8.08828883e-03f, -6.28108680e-02f, -5.34519777e-02f, -7.09852129e-02f, -1.57638863e-01f, -3.44998538e-02f, -2.48642750e-02f, -3.54193412e-02f,
  -1.03212353e-02f, -7.32837617e-02f, 3.82861309e-02f, -8.35883394e-02f, -6.90568015e-02f, -1.81892097e-01f, -3.07698343e-02f, -1.47184208e-01f, -1.16534948e-01f, -7.59693682e-02f,
  2.38074854e-01f, -8.35125148e-02f, 2.70023029e-02f, 7.63299465e-02f, 9.83476043e-02f, 3.59265804e-02f, -5.03540523e-02f, -4.94518243e-02f, 9.23177525e-02f, -6.04638606e-02f,
  -8.43438581e-02f, -5.11733582e-04f, -3.72798629e-02f, 6.10598661e-02f, -8.41173753e-02f, 3.36315259e-02f, 2.29763500e-02f, 7.79351592e-02f, 6.76729381e-02f, 5.05851805e-02f,
  7.76872486e-02f, -4.94826883e-02f, -3.35657746e-02f, 8.56714770e-02f, -7.35604912e-02f, 4.36662622e-02f, 3.40093896e-02f, 5.00606485e-02f, 6.84789792e-02f, -6.49446808e-03f,
  -2.97424436e-01f, -3.50766927e-01f, -1.58199370e-01f, -1.85724571e-01f, -1.66457165e-02f, -1.72116280e-01f, -2.90072441e-01f, -2.42380932e-01f, -1.87741481e-02f, -1.96583733e-01f,
  -1.55455358e-02f, 5.74339107e-02f, 8.99582505e-02f, 5.19268997e-02f, -1.89355742e-02f, -2.86581308e-01f, -1.66532069e-01f, 6.61958307e-02f, 1.70746133e-01f, -8.10763091e-02f,
  -2.36898083e-02f, -1.99289560e-01f, -8.05902779e-02f, -1.24172635e-01f, -7.82387778e-02f, -5.29349782e-02f, -1.97952822e-01f, -1.28749117e-01f, -1.17453538e-01f, -8.19602981e-02f,
  4.16011140e-02f, -3.13932568e-01f, 9.24473256e-02f, -9.86066312e-02f, -1.36966303e-01f, -1.76657364e-01f, -1.73416138e-01f, -4.75099944e-02f, -8.37030113e-02f, -2.23571092e-01f,
  -8.48360732e-02f, -7.36759678e-02f, -1.50175259e-01f, -1.41221046e-01f, -1.25660315e-01f, -8.23930278e-02f, -1.41893655e-01f, -2.12512314e-01f, -1.62198931e-01f, -1.18554033e-01f,
  -1.36921450e-01f, -8.88250545e-02f, -2.11661369e-01f, -9.28958058e-02f, -1.70728579e-01f, 5.79474494e-03f, -1.63506567e-01f, -5.76460510e-02f, -1.39029339e-01f, -2.82234550e-01f,
  -1.26596903e-02f, 1.15099736e-01f, 8.02873150e-02f, -3.51902097e-02f, 1.15985781e-01f, 1.06106021e-01f, 5.68573363e-02f, 7.85658434e-02f, 7.60425776e-02f, 7.38097504e-02f,
  1.10192768e-01f, -4.15464258e-03f, 8.10741633e-02f, 3.86090539e-02f, 1.00327283e-01f, 2.59857494e-02f, 3.94740440e-02f, -1.84994880e-02f, 8.78920928e-02f, 5.45508638e-02f,
  8.45502838e-02f, 1.26861194e-02f, 8.53302702e-02f, 1.88529752e-02f, 3.58741581e-02f, 8.52565542e-02f, 5.87658696e-02f, 8.58443528e-02f, -1.36281941e-02f, 9.99944583e-02f,
  1.15594233e-03f, 1.51114697e-02f, -3.43803167e-02f, -9.39187482e-02f, -7.19583482e-02f, -1.77929141e-02f, -1.40658170e-01f, -5.90587854e-02f, -1.62153646e-01f, -1.91274211e-01f,
  -1.01446129e-01f, -5.77116199e-02f, -1.42567545e-01f, -1.36003196e-01f, -1.17845416e-01f, -8.51400718e-02f, -1.63018227e-01f, -4.76556532e-02f, -9.23543125e-02f, -7.04300404e-02f,
  -8.24679211e-02f, -1.90588430e-01f, -1.21055000e-01f, -4.32412326e-02f, -7.57426172e-02f, -1.03546176e-02f, -5.28614633e-02f, -1.89618781e-01f, -1.71933934e-01f, -3.03737402e-01f,
  -1.08855233e-01f, 9.32574347e-02f, 9.90021303e-02f, 2.01350320e-02f, 5.94050530e-03f, 3.50108668e-02f, 3.44416089e-02f, -6.47538975e-02f, 1.93124358e-02f, 8.49037170e-02f,
  1.48814306e-01f, 2.19038919e-01f, 1.97811559e-01f, 1.22220688e-01f, 5.77593446e-02f, 5.06674610e-02f, 5.24302460e-02f, 5.18256091e-02f, 1.27225250e-01f, 5.76458313e-02f,
  9.05725136e-02f, 6.13963716e-02f, 1.92786753e-02f, 1.07132383e-01f, 2.17830434e-01f, 1.02809807e-02f, 2.74562389e-02f, 2.13163808e-01f, 1.05721377e-01f, 1.92125246e-01f,
  1.50807202e-01f, 1.61631271e-01f, 3.55280563e-02f, 1.39240161e-01f, 9.22217742e-02f, 4.37962040e-02f, 1.07345819e-01f, 7.44764879e-02f, 1.99770760e-02f, 1.19913176e-01f,
  1.82463780e-01f, 5.98464422e-02f, 5.41196428e-02f, 3.68150510e-02f, 1.00488439e-02f, 6.12437353e-02f, -1.94793623e-02f, 2.31445506e-02f, 1.42196771e-02f, 6.90060407e-02f,
  1.27875373e-01f, 1.72190294e-01f, 5.30814752e-03f, 9.90589522e-03f, 1.40952831e-02f, -8.10715184e-03f, 5.18047698e-02f, 1.11067668e-01f, 1.04228541e-01f, 1.23122009e-02f,
  -5.84081793e-03f, -4.88159470e-02f, -3.02498844e-02f, -3.40789743e-02f, -1.07681096e-01f, -4.74298559e-02f, 3.40032304e-04f, -1.26470476e-01f, -2.12743189e-02f, -8.66577849e-02f,
  5.41387238e-02f, -5.62910810e-02f, -5.13503924e-02f, 6.74496219e-02f, -8.23312327e-02f, 1.44862579e-02f, -3.48991044e-02f, -3.48882712e-02f, -1.25509515e-01f, -1.13257855e-01f,
  -1.92551762e-02f, 1.08060045e-02f, -1.00294799e-02f, -8.50056931e-02f, -9.99162793e-02f, 4.06909324e-02f, -4.80909757e-02f, -9.42378789e-02f, -2.92156804e-02f, 2.87043815e-03f,
  -6.18304983e-02f, 1.31967962e-01f, -5.00945142e-03f, 4.47872691e-02f, 2.63528880e-02f, 1.11894608e-01f, -8.29873048e-03f, 9.06468276e-03f, 1.17123760e-01f, 5.80225736e-02f,
  1.29333124e-01f, 5.09062670e-02f, 3.38606238e-02f, -1.47970906e-02f, 2.32796688e-02f, 6.18502572e-02f, -1.09879673e-01f, 6.55839145e-02f, 5.34175299e-02f, -4.29798998e-02f,
  -5.29942140e-02f, -8.92345086e-02f, -4.55383100e-02f, -1.18243076e-01f, 5.55817932e-02f, -2.92934962e-02f, 3.41479778e-02f, -2.28990186e-02f, -9.48398784e-02f, -1.23831734e-01f,
  3.50539923e-01f, 1.44358054e-01f, -8.96920264e-02f, 7.40392283e-02f, -4.48335856e-02f, -1.08536333e-01f, -1.89068854e-01f, -7.66757280e-02f, 1.53788164e-01f, 7.13558728e-03f,
  1.19374648e-01f, 1.71068788e-01f, 1.28370836e-01f, 1.04468077e-01f, -3.62503082e-02f, -1.29885733e-01f, -1.86826810e-01f, -2.60228850e-02f, -9.63051319e-02f, -1.30675733e-01f,
  -6.41794652e-02f, 1.16700031e-01f, 1.62963122e-01f, 6.72814995e-02f, 1.87941026e-02f, -2.41210852e-02f, 1.41578123e-01f, 1.24815620e-01f, 2.31215581e-02f, 1.05646797e-01f,
  1.40069157e-01f, 3.83045882e-01f, 9.50975716e-03f, 1.50627211e-01f, 8.49376023e-02f, 1.27397731e-01f, 7.47327087e-03f, 1.60912618e-01f, 1.22548744e-01f, 7.85851926e-02f,
  1.55311123e-01f, 2.07421586e-01f, 1.39742523e-01f, 1.71755224e-01f, 4.84151691e-02f, 1.19117543e-01f, 1.92152441e-01f, 5.97389974e-02f, 1.57620654e-01f, 9.55690220e-02f,
  2.51200795e-02f, 9.63497311e-02f, -2.95382347e-02f, 3.14520672e-02f, 8.07649940e-02f, 3.83431390e-02f, 1.15022808e-01f, 1.49366960e-01f, 1.55013055e-01f, 2.56957293e-01f,
  -7.35829473e-02f, -9.97568369e-02f, -8.61288831e-02f, -8.06316510e-02f, -1.44998804e-01f, -1.62071854e-01f, -1.07698746e-01f, -6.04915842e-02f, -1.65614173e-01f, -1.44520536e-01f,
  -5.69125898e-02f, -1.26973480e-01f, -1.32375658e-01f, -5.73928691e-02f, -1.28703162e-01f, -4.48189862e-02f, -1.53886661e-01f, -8.31289366e-02f, -8.44421163e-02f, -1.57511175e-01f,
  -1.12617299e-01f, -1.42183885e-01f, -1.02600545e-01f, -8.07817653e-02f, -9.54868868e-02f, -1.57049477e-01f, -1.64874241e-01f, -2.74948273e-02f, -8.38420764e-02f, -6.55012429e-02f,
  1.10585235e-01f, 4.16584909e-02f, 1.56538934e-01f, 1.51506931e-01f, 7.81165883e-02f, 8.11954513e-02f, 1.13459013e-01f, 1.78069204e-01f, 1.29532263e-01f, 1.44714311e-01f,
  2.04176888e-01f, 2.06018895e-01f, 1.55405596e-01f, 7.05572367e-02f, 9.96042602e-03f, 1.61716715e-01f, 1.52558208e-01f, 9.87523645e-02f, 2.18593217e-02f, 1.56034708e-01f,
  1.10916972e-01f, -4.79292087e-02f, 2.79108286e-02f, -4.51762602e-02f, 4.73090038e-02f, -9.98791866e-03f, 1.53161027e-02f, 2.13003643e-02f, -4.81129065e-03f, 5.61394356e-02f,
  -2.20615268e-01f, 8.68398175e-02f, 1.00658938e-01f, -8.24944228e-02f, -1.26371710e-02f, -1.00452326e-01f, -1.64559215e-01f, -2.46778488e-01f, -1.60456404e-01f, -8.36497396e-02f,
  7.25705177e-02f, 7.36212358e-02f, -2.51295101e-02f, -1.33168921e-01f, -1.60440922e-01f, -3.51323150e-02f, 1.02297597e-01f, -4.19355370e-02f, -1.69584721e-01f, -5.94687313e-02f,
  5.39394803e-02f, -1.25335176e-02f, -1.38225734e-01f, -1.25936285e-01f, 1.21455625e-01f, 9.21519473e-02f, 6.02275617e-02f, 7.23846927e-02f, 1.26615278e-02f, 2.40405723e-01f,
  5.52465618e-02f, -1.70674115e-01f, -1.45093814e-01f, 3.49303819e-02f, -2.94256210e-02f, -1.09838612e-01f, 1.82434171e-02f, -1.00078605e-01f, -4.11295220e-02f, -3.10866609e-02f,
  8.30923691e-02f, 1.38773248e-04f, 4.35167179e-02f, -6.42694905e-02f, -6.73967972e-02f, -4.82108928e-02f, -6.82293475e-02f, -1.70078769e-01f, -5.25317267e-02f, -2.58466154e-02f,
  3.80540593e-03f, 1.05204441e-01f, -6.03062809e-02f, -1.43473193e-01f, -7.57364556e-02f, -3.40294205e-02f, -8.29385072e-02f, -8.73251110e-02f, -1.17854662e-01f, -1.25866264e-01f,
  -9.30772200e-02f, 1.11563787e-01f, 3.53649296e-02f, -3.20991576e-02f, 2.12265868e-02f, -1.74344480e-02f, 1.55863389e-02f, 3.05516031e-02f, 8.37838203e-02f, 7.86122158e-02f,
  1.70820262e-02f, 7.60695264e-02f, 9.19412896e-02f, 3.13150808e-02f, 6.60796836e-02f, 1.03575736e-01f, 1.13416336e-01f, -1.11239487e-02f, 9.49141756e-02f, 3.87470089e-02f,
  4.45613675e-02f, 6.34658858e-02f, 1.13155141e-01f, 2.72757299e-02f, 2.16144025e-02f, 1.37506098e-01f, 3.70775349e-02f, 9.43743251e-03f, 9.48197767e-02f, 1.20513648e-01f,
  -1.36356786e-01f, -1.74905270e-01f, 4.47043553e-02f, -1.16711721e-01f, -1.25880726e-02f, -1.05141006e-01f, -5.55486195e-02f, -3.25077423e-03f, 4.40424047e-02f, -3.48179676e-02f,
  -1.15544744e-01f, -9.77730826e-02f, -5.91515638e-02f, -4.93114144e-02f, -1.24677792e-01f, -6.82163462e-02f, -8.63638595e-02f, -4.10583653e-02f, -6.89102560e-02f, -9.52237621e-02f,
  1.55398464e-02f, -4.91769947e-02f, -8.69850293e-02f, -1.30186602e-01f, -9.77875143e-02f, -1.20996498e-01f, 8.47839657e-03f, -1.26681089e-01f, -1.81632102e-01f, -2.40194798e-01f,
  2.86846638e-01f, -9.41667613e-03f, -1.45886183e-01f, -3.17176580e-02f, -1.71742350e-01f, -1.38000757e-01f, -1.31803930e-01f, 7.68572390e-02f, -6.23492934e-02f, 1.39468247e-02f,
  -1.83975697e-01f, -1.21664189e-01f, 2.59611346e-02f, -4.52338457e-02f, 5.96682355e-02f, 3.09030004e-02f, -1.02562204e-01f, 6.99464977e-02f, 4.82568853e-02f, -1.72699779e-01f,
  -2.26968020e-01f, -2.88427644e-03f, 1.62500203e-01f, 2.06686854e-02f, -1.52806133e-01f, -1.55904889e-01f, -1.00264445e-01f, -6.10285923e-02f, -1.77752987e-01f, -2.63072133e-01f,
  -2.43855834e-01f, 8.83342326e-02f, -8.57725292e-02f, 3.27460049e-03f, -1.01566024e-01f, 3.21913771e-02f, 1.23063605e-02f, -6.03648834e-03f, 4.19875532e-02f, 3.59815583e-02f,
  -1.17395967e-01f, -1.52746579e-02f, -2.24890783e-02f, -1.15675911e-01f, 3.57272141e-02f, -1.16780758e-01f, 9.33248666e-05f, 8.26975703e-02f, -7.61201382e-02f, -1.31872654e-01f,
  -1.79302633e-01f, -7.16910884e-02f, -7.73278475e-02f, 1.36395488e-02f, -1.10385425e-01f, -5.13473265e-02f, -1.77179947e-01f, -7.24276528e-02f, 3.55142169e-02f, 2.75370665e-02f,
  4.38140444e-02f, -5.13776578e-02f, 2.23951489e-02f, 3.79783474e-02f, 8.16997066e-02f, 8.07992369e-03f, 4.72930595e-02f, -9.91000533e-02f, -2.21301354e-02f, -1.78018883e-02f,
  -4.88530425e-03f, 1.85651574e-02f, 3.81244309e-02f, 7.10397959e-02f, -4.18570004e-02f, -1.73481752e-03f, 2.62965877e-02f, 1.05810739e-01f, -4.31905547e-03f, 3.20539623e-02f,
  4.19019684e-02f, -1.01290662e-02f, -3.51063535e-02f, -2.73086838e-02f, -2.73652747e-02f, 4.16834317e-02f, -3.47763300e-02f, 1.88155062e-02f, 2.20751557e-02f, -5.45153134e-02f,
  -4.47470993e-02f, 1.21915126e-02f, 1.69836376e-02f, -8.97937119e-02f, -9.31988470e-03f, 3.02266572e-02f, -3.03613469e-02f, -1.64513960e-02f, -6.85971752e-02f, -1.20790891e-01f,
  -8.72679278e-02f, -5.08047715e-02f, -2.18712091e-02f, -1.43797854e-02f, -1.24349795e-01f, -3.71912606e-02f, 4.27510627e-02f, -3.95820551e-02f, -1.42772257e-01f, -1.44087881e-01f,
  -7.82890804e-03f, -8.00388828e-02f, -1.19956709e-01f, 6.71480829e-03f, 2.91697308e-03f, 2.31399145e-02f, -3.27565596e-02f, -1.33220509e-01f, 7.94325676e-03f, 5.64851761e-02f,
  3.93677205e-01f, 2.46381149e-01f, 2.02398881e-01f, 2.65764892e-01f, 3.32102627e-01f, 2.66351014e-01f, 2.28290826e-01f, 1.05655365e-01f, 1.40613258e-01f, 7.93121159e-02f,
  5.87240867e-02f, 8.73255879e-02f, -5.53280786e-02f, 2.03732587e-02f, -4.05386984e-02f, 1.94302455e-01f, 1.90307975e-01f, 1.05361067e-01f, 1.33133650e-01f, 2.13842347e-01f,
  2.41624922e-01f, 2.56901443e-01f, 1.95720613e-01f, 1.62953779e-01f, 8.40471536e-02f, 1.59824833e-01f, 1.24299638e-01f, 1.03968725e-01f, 1.06339872e-01f, 2.33817801e-01f,
  1.58417121e-01f, 2.52306193e-01f, -9.76400077e-03f, 1.17369063e-01f, 8.46550688e-02f, 1.05811685e-01f, 9.43814442e-02f, 3.05807423e-02f, 7.09617659e-02f, 4.73116450e-02f,
  5.67989945e-02f, 4.98056188e-02f, 4.39032614e-02f, 1.87255055e-01f, 1.31612465e-01f, 1.99134529e-01f, 1.22421747e-02f, 1.07682526e-01f, 9.31428820e-02f, 9.62974131e-02f,
  6.88060746e-02f, 1.82935730e-01f, 1.16043754e-01f, 4.66982313e-02f, 8.49207565e-02f, 5.10201752e-02f, -4.03839722e-02f, 4.96541858e-02f, 1.14914682e-02f, 1.66715100e-01f,
  8.32025521e-03f, -3.53294834e-02f, -1.08174317e-01f, -1.44501440e-02f, -6.26548678e-02f, -8.68665278e-02f, -5.78593537e-02f, 8.33842624e-03f, -5.73350117e-02f, -1.11560240e-01f,
  3.08708334e-03f, 3.10937092e-02f, -1.58319194e-02f, -1.42280264e-02f, -1.75409168e-02f, 6.57738149e-02f, 3.89561290e-03f, -1.06762545e-02f, -1.00591883e-01f, -1.67396255e-02f,
  3.84780318e-02f, -8.25772583e-02f, -6.69045076e-02f, 1.89537704e-02f, 1.89439580e-02f, 4.79605887e-03f, -2.91086994e-02f, 3.62060877e-04f, 2.18951646e-02f, 1.32635593e-01f,
  4.41033691e-02f, 3.89861055e-02f, 1.35356277e-01f, 1.03630215e-01f, 1.23999774e-01f, -6.71975911e-02f, 1.39421433e-01f, 1.02181569e-01f, 7.36971647e-02f, 1.16359666e-01f,
  1.39582291e-01f, 4.92804870e-03f, 5.51524051e-02f, -3.02053592e-03f, 6.44608140e-02f, 4.94190156e-02f, 3.37463319e-02f, 9.55611467e-02f, 2.10169870e-02f, 7.59234130e-02f,
  -3.16601470e-02f, 7.63510689e-02f, 3.02461884e-03f, -5.41973747e-02f, 1.29150888e-02f, 9.79962647e-02f, 5.44189885e-02f, 2.54375786e-02f, 3.48939933e-02f, -6.04370832e-02f,
  3.86274844e-01f, 3.18093479e-01f, -2.21010953e-01f, 1.40531152e-01f, 8.41537118e-02f, 1.85264453e-01f, 1.72879100e-01f, 1.88718021e-01f, 1.87215909e-01f, 1.49349585e-01f,
  7.06946775e-02f, -1.23310715e-01f, -1.56720966e-01f, -1.50714487e-01f, -1.59943163e-01f, -1.04739189e-01f, -6.38005212e-02f, -2.26504475e-01f, -2.20237747e-01f, 1.13453321e-01f,
  1.73274234e-01f, 1.34118557e-01f, 1.30590603e-01f, 6.29976913e-02f, 1.45504117e-01f, 1.45423770e-01f, -1.14177624e-02f, 1.13355331e-01f, -2.40574926e-02f, 1.41019478e-01f,
  -1.24007210e-01f, 8.69285874e-03f, -1.05078205e-01f, 1.27382278e-01f, 8.26883614e-02f, 4.96719964e-03f, -5.42023499e-03f, 4.69696289e-03f, 6.56868964e-02f, 1.11087471e-01f,
  -3.77993612e-03f, 1.50760338e-02f, 3.42336185e-02f, -4.67904918e-02f, 1.32802814e-01f, -8.77047796e-03f, 3.90888937e-02f, -5.91037385e-02f, 3.15431468e-02f, -2.47700140e-02f,
  9.66055468e-02f, 1.20863415e-01f, 6.30951077e-02f, 4.25734334e-02f, 2.15788148e-02f, -4.57136631e-02f, 7.90681615e-02f, 5.45253828e-02f, 1.08979344e-01f, 2.61512429e-01f,
  -2.97498852e-02f, 1.23993875e-02f, -5.43311685e-02f, -3.62601578e-02f, 9.51056108e-02f, -3.15408595e-02f, -1.11941122e-01f, -1.70627367e-02f, -4.44214940e-02f, 4.98431623e-02f,
  -1.09600075e-01f, 1.11365877e-02f, -6.17139339e-02f, -1.13278683e-02f, -5.51990382e-02f, -9.59705561e-02f, 2.02434678e-02f, -3.67604122e-02f, -2.76889419e-03f, 1.85198970e-02f,
  -1.09267861e-01f, -1.10119795e-02f, -6.25985339e-02f, -3.66501845e-02f, 5.32990182e-03f, -7.41421729e-02f, -7.38243610e-02f, 2.08152831e-02f, 6.46216720e-02f, -3.16367708e-02f,
  1.23481363e-01f, -9.79385749e-02f, 1.46455303e-01f, -2.68469788e-02f, 1.34529293e-01f, 1.12715721e-01f, 5.69122359e-02f, 1.31808385e-01f, 3.72069441e-02f, 1.28320113e-01f,
  1.15962625e-01f, 2.83341780e-02f, 7.09438473e-02f, 1.05037335e-02f, 9.28631704e-03f, 1.17325783e-01f, 1.72417670e-01f, 4.28767651e-02f, 1.50632877e-02f, 1.31675810e-01f,
  1.56609893e-01f, 2.10160375e-01f, 7.53078014e-02f, 8.89931545e-02f, 1.26287296e-01f, 5.49191311e-02f, 2.55230479e-02f, 7.64490217e-02f, 8.87761638e-02f, 2.18580544e-01f,
  -2.74770141e-01f, 9.04207900e-02f, -1.48513868e-01f, -1.63091362e-01f, 1.39172047e-01f, -3.33490223e-02f, 1.29991118e-02f, -1.45652682e-01f, 3.41984630e-03f, -2.74315197e-02f,
  4.23866771e-02f, -6.74374849e-02f, 5.03101237e-02f, -7.49100000e-02f, -6.61916882e-02f, 3.60752493e-02f, 9.67458636e-02f, -1.79950967e-01f, -1.75459012e-01f, -9.21981875e-03f,
  4.30056266e-02f, 2.95534078e-02f, -1.97339997e-01f, -1.14595003e-01f, 3.10707483e-02f, 9.88555178e-02f, 1.22930005e-01f, 1.23788878e-01f, 1.15044944e-01f, 6.61004111e-02f,
  -6.73369244e-02f, -1.27606958e-01f, -8.61324277e-03f, 8.63297749e-03f, 1.28723934e-01f, -8.37483779e-02f, -8.24259520e-02f, -3.85057516e-02f, -3.85895632e-02f, -1.16922982e-01f,
  9.84216779e-02f, 2.82161031e-02f, 1.78390592e-02f, -1.00212075e-01f, -3.30111049e-02f, -8.94976258e-02f, -1.46089837e-01f, -1.27403781e-01f, -1.56589016e-01f, -4.51739058e-02f,
  9.76441205e-02f, 2.60440372e-02f, -1.45812333e-01f, -1.00228637e-01f, -1.02852307e-01f, 5.46149053e-02f, -8.55231211e-02f, -3.37174125e-02f, -7.55908340e-02f, -1.88005969e-01f,
  3.51560749e-02f, -1.62996594e-02f, 1.70303341e-02f, -6.11179508e-02f, -5.63250668e-02f, 1.44088194e-02f, -5.30940220e-02f, 2.35906132e-02f, -8.54850784e-02f, 4.01560217e-03f,
  1.64603051e-02f, -7.70458356e-02f, 2.75775306e-02f, 3.36782485e-02f, 5.37265204e-02f, 6.80858642e-02f, 6.48402981e-03f, -2.91962735e-02f, 4.88756560e-02f, 5.02839983e-02f,
  -1.84548646e-02f, -4.66531217e-02f, -3.65055501e-02f, 2.39241123e-02f, 5.58885969e-02f, -2.76146568e-02f, -5.15527017e-02f, 5.80854937e-02f, 4.46889885e-02f, 7.41359144e-02f,
  -1.69467226e-01f, 1.43650010e-01f, -1.20757155e-01f, -4.41040508e-02f, 8.60474482e-02f, 1.37690073e-02f, -1.53003326e-02f, -4.41536754e-02f, -3.36025213e-03f, 3.58712161e-03f,
  -5.43485247e-02f, -1.33606881e-01f, -4.56282124e-02f, -1.13155328e-01f, -1.50649622e-01f, -4.27411720e-02f, -4.99876067e-02f, -4.40460816e-02f, 2.92154700e-02f, -7.75141933e-04f,
  -7.62800574e-02f, -2.84241084e-02f, -1.95336029e-01f, -1.38681918e-01f, 1.18397800e-02f, -6.39607683e-02f, -1.33640930e-01f, -1.31768331e-01f, -1.20326884e-01f, -1.63674206e-01f,
  -2.53186196e-01f, -1.22533068e-01f, -2.51086414e-01f, -1.76802367e-01f, -1.95280299e-01f, -1.84990078e-01f, -2.09068164e-01f, -1.76808223e-01f, -6.67660907e-02f, -8.94259438e-02f,
  -8.39437693e-02f, 9.96859521e-02f, 4.99166735e-02f, -5.39585995e-03f, -6.62832782e-02f, -1.82374135e-01f, -1.97143734e-01f, -1.75881624e-01f, -1.74934432e-01f, -1.72032088e-01f,
  -4.16957065e-02f, -4.48385552e-02f, -6.67489469e-02f, -1.65536091e-01f, -4.90412302e-02f, 6.42051315e-03f, -1.11033246e-01f, -1.06525160e-01f, 2.86361910e-02f, -1.28278300e-01f,
  4.81055453e-02f, -2.46718228e-01f, -4.19832133e-02f, -4.43385355e-02f, -8.96396488e-02f, -8.86552967e-03f, -6.29976839e-02f, -7.22332075e-02f, -1.34875566e-01f, -3.54880951e-02f,
  -1.31297544e-01f, -1.68794721e-01f, -7.00582042e-02f, -1.71838894e-01f, -7.68432468e-02f, -8.16964507e-02f, -1.20442770e-01f, -2.25803927e-01f, -1.17268786e-01f, -9.56927612e-02f,
  -4.50570993e-02f, -2.30721861e-01f, -2.69263744e-01f, -9.11490172e-02f, -1.54642686e-01f, -4.13674675e-02f, -1.53888196e-01f, -3.99357863e-02f, -1.82577536e-01f, 2.64335368e-02f,
  -6.08327473e-03f, 8.68917853e-02f, 5.76067828e-02f, 4.34940793e-02f, 1.52338177e-01f, 1.05092399e-01f, 5.44445664e-02f, 2.54444219e-02f, 2.77552679e-02f, 4.15823609e-02f,
  1.07011863e-03f, 6.31393567e-02f, 1.06389925e-03f, 5.85008832e-03f, 2.39219107e-02f, 4.24936926e-03f, 5.68826720e-02f, 8.38380009e-02f, 2.33785026e-02f, 7.51231238e-02f,
  3.61692570e-02f, 2.82203276e-02f, -1.24414880e-02f, 8.42380375e-02f, -3.25393304e-02f, 6.26652986e-02f, -2.04410311e-02f, 7.33514577e-02f, -3.55596817e-03f, -8.10799887e-04f,
  1.18945174e-01f, -2.01393396e-01f, 5.67431338e-02f, -8.53865370e-02f, -3.08172256e-02f, 5.92444390e-02f, -4.93916608e-02f, -9.62552875e-02f, 2.96727605e-02f, -9.38038006e-02f,
  -1.27144024e-01f, -1.00531645e-01f, -1.34022564e-01f, -1.72419921e-02f, -1.13595940e-01f, -6.35258108e-02f, 4.59675826e-02f, -9.08020660e-02f, -9.44527239e-02f, -7.68318400e-02f,
  -5.26575595e-02f, -1.17978051e-01f, -3.52047384e-02f, -8.20904300e-02f, 1.50966663e-02f, 3.30324546e-02f, 6.72120005e-02f, -9.65020210e-02f, 1.19676273e-02f, 2.52775960e-02f,
  -1.30841434e-01f, 3.31394285e-01f, 5.43926023e-02f, -3.65868807e-02f, 1.11100882e-01f, 5.22013567e-02f, 3.09192538e-01f, 1.39838323e-01f, 6.44860119e-02f, 2.45134071e-01f,
  3.96761559e-02f, -2.33788386e-01f, -6.68627694e-02f, -7.81835392e-02f, -8.07046294e-02f, 1.47328258e-01f, 1.40665814e-01f, -1.26615867e-01f, -3.45662087e-01f, -1.30037099e-01f,
  -7.50323087e-02f, -6.41310588e-02f, -1.81353614e-01f, -1.04381114e-01f, 2.10628603e-02f, -3.72908637e-02f, 1.03024393e-01f, 2.08618119e-03f, -3.31354747e-03f, 7.10968822e-02f,
  -2.15562377e-02f, 3.26239318e-02f, -2.24701799e-02f, -1.28409594e-01f, 2.19614767e-02f, -6.68985695e-02f, 3.09557803e-02f, 1.25736250e-02f, 1.75597966e-02f, 1.97626348e-03f,
  -2.41707899e-02f, -6.31120354e-02f, -8.62402245e-02f, -6.55897111e-02f, 2.54550055e-02f, -8.41980502e-02f, -8.01277906e-02f, -1.36499420e-01f, 3.19817103e-02f, 2.41549267e-03f,
  -9.92655903e-02f, 3.90343592e-02f, -4.78310250e-02f, 5.42681552e-02f, -1.14421904e-01f, -1.37676299e-01f, -8.63375142e-03f, -1.52551204e-01f, -9.81553271e-02f, 4.91047241e-02f,
  -4.19095680e-02f, 1.95216592e-02f, 8.72512236e-02f, -1.03612524e-02f, 9.00246296e-03f, 4.09093425e-02f, 4.62802239e-02f, 8.80393088e-02f, -8.47188309e-02f, 5.70506081e-02f,
  -2.12415829e-02f, -2.80260108e-03f, -3.05458400e-02f, 1.07758820e-01f, -4.63763289e-02f, 3.23271975e-02f, 9.84386578e-02f, -1.04004107e-02f, -4.18157987e-02f, 7.14170337e-02f,
  -4.79430258e-02f, -2.61235926e-02f, 4.43704911e-02f, -5.64253777e-02f, -1.88542735e-02f, 1.20561738e-02f, 2.55586132e-02f, -1.02130577e-01f, -8.85682330e-02f, 2.61907279e-02f,
  9.14481282e-02f, -1.15733460e-01f, 4.10763659e-02f, -7.25908950e-02f, -4.00477573e-02f, -1.39053956e-01f, -5.56980669e-02f, -6.68792874e-02f, -4.76204082e-02f, -4.74258922e-02f,
  -4.80257720e-02f, -1.06942290e-02f, -3.70190479e-02f, -1.01649702e-01f, -6.14039339e-02f, -2.32409164e-02f, 3.06752361e-02f, -6.25143871e-02f, -6.35508895e-02f, -1.48981307e-02f,
  -9.44540184e-03f, 7.36297071e-02f, 1.40413819e-02f, 2.06554625e-02f, -1.20835036e-01f, -1.08637951e-01f, -3.01743392e-03f, 2.06832830e-02f, -7.39404112e-02f, 2.15710551e-01f,
  -3.34027410e-01f, 8.68134275e-02f, -2.84950674e-01f, 6.74364418e-02f, 1.51613401e-02f, -1.51488230e-01f, -3.01361047e-02f, -4.74446267e-02f, 1.29186228e-01f, 9.43828300e-02f,
  2.35338113e-03f, 1.00575723e-01f, 9.89510342e-02f, 7.74852037e-02f, -1.09948747e-01f, 1.49675369e-01f, 4.13185321e-02f, -1.27143100e-01f, -2.80498087e-01f, 5.59237674e-02f,
  1.92429528e-01f, 9.96087212e-04f, -1.99904725e-01f, -8.91333744e-02f, 1.01778135e-01f, 1.62229896e-01f, 3.57310772e-02f, -9.16447118e-02f, 4.09146324e-02f, 1.95836067e-01f,
  -3.31641361e-02f, -2.41018355e-01f, 2.11340990e-02f, 8.03309456e-02f, 1.42826736e-02f, -8.78040865e-02f, -7.70216659e-02f, -3.63399796e-02f, -5.00268117e-02f, -3.66727822e-02f,
  -2.14674510e-02f, -4.14192267e-02f, 8.53649899e-03f, 4.04625125e-02f, -3.67929041e-02f, -6.52870834e-02f, -7.61683807e-02f, -1.81250665e-02f, -4.10489514e-02f, 2.74550393e-02f,
  1.36844665e-01f, -9.05064214e-03f, -8.16713646e-02f, -5.70879958e-04f, -3.55112292e-02f, -6.92911670e-02f, -7.05150217e-02f, 1.96267292e-02f, -6.09198622e-02f, -2.89913621e-02f,
  -1.14835864e-02f, 1.83905177e-02f, 4.31230292e-02f, -5.34570729e-03f, -2.56170537e-02f, 3.71665023e-02f, 1.19087775e-03f, 5.32702357e-02f, -2.08745189e-02f, 4.72053997e-02f,
  -4.22432199e-02f, -1.24489209e-02f, -1.19141834e-02f, 2.02819612e-02f, -1.74116232e-02f, -8.76312796e-03f, -9.08530205e-02f, 5.29013462e-02f, -4.08761762e-03f, -6.65803254e-02f,
  6.32285140e-04f, 1.13123674e-02f, -2.24484205e-02f, 2.02400964e-02f, -8.63123238e-02f, -2.12220009e-02f, 3.73667926e-02f, -4.36258800e-02f, 2.25792844e-02f, -1.12017728e-01f,
  2.71047741e-01f, -1.22753344e-01f, 2.51354519e-02f, 3.55894044e-02f, 9.83648747e-02f, 7.11952448e-02f, 1.34014800e-01f, 9.02098492e-02f, 9.41326171e-02f, -5.34980651e-03f,
  -1.71578415e-02f, 3.57052200e-02f, 4.71281148e-02f, 1.67183280e-02f, 2.69308649e-02f, 2.96517704e-02f, 1.85461923e-01f, 2.44319737e-02f, 4.41272035e-02f, 1.54255822e-01f,
  2.06676826e-01f, 2.98528541e-02f, -2.62016021e-02f, 1.10762089e-01f, 9.51995105e-02f, -2.58990768e-02f, 5.34165949e-02f, -1.99482422e-02f, 4.28026952e-02f, 1.96729496e-01f,
  -1.80006117e-01f, -2.60101467e-01f, -2.24872995e-02f, -1.30921885e-01f, 7.31651187e-02f, 2.29801565e-01f, 1.93537116e-01f, -6.66347099e-03f, -1.47681922e-01f, -1.66893274e-01f,
  4.50733155e-02f, 3.53702605e-02f, 5.59415706e-02f, 8.82347450e-02f, 4.39467393e-02f, 5.29419519e-02f, 4.37237769e-02f, 1.56555057e-01f, 2.76447743e-01f, 1.43458322e-01f,
  1.03664845e-01f, -1.07487775e-01f, -1.32528335e-01f, -9.47059691e-02f, -1.70847461e-01f, 2.67465413e-02f, -1.45198882e-01f, -6.73667043e-02f, 7.74657503e-02f, -2.18454540e-01f,
  -9.65091363e-02f, -1.28135473e-01f, -5.27168484e-03f, -7.42406547e-02f, -3.60722728e-02f, -9.46932510e-02f, -7.90747721e-03f, -4.40578647e-02f, -5.98386638e-02f, -4.45869565e-02f,
  -8.14161226e-02f, -6.27394840e-02f, -2.78062131e-02f, -7.41996989e-02f, -1.02227986e-01f, -5.23047522e-03f, -1.29058778e-01f, -4.20718379e-02f, -2.93373894e-02f, -1.00796677e-01f,
  2.28883270e-02f, 7.85451978e-02f, -6.08994998e-02f, -5.03709018e-02f, 7.82739893e-02f, 1.38867013e-02f, -6.45646006e-02f, -8.48596022e-02f, 2.40022093e-02f, -1.42568007e-01f,
  5.16533852e-02f, -2.06189305e-02f, 1.23486333e-01f, 8.10861066e-02f, 8.63684267e-02f, 5.89778908e-02f, 7.79003352e-02f, 4.70281243e-02f, 6.71239942e-02f, -3.68598825e-03f,
  1.17753416e-01f, 4.09294441e-02f, 5.31097129e-02f, 1.19882978e-01f, -3.34980860e-02f, 1.32844701e-01f, 8.36192816e-02f, 1.96523815e-02f, 5.02354316e-02f, -2.21334375e-03f,
  4.16740179e-02f, 9.93459821e-02f, 4.54433002e-02f, 3.98843884e-02f, 6.58937022e-02f, 1.44486934e-01f, 1.43180564e-01f, 6.99112192e-02f, 1.67553499e-02f, 3.54168378e-02f,
  -2.20716432e-01f, 1.23661570e-01f, -8.59378874e-02f, -5.50174341e-02f, -2.27184147e-01f, -1.69894472e-01f, -5.34231327e-02f, -7.56892562e-02f, -1.01226933e-01f, -5.97403534e-02f,
  -1.04434237e-01f, -8.20539668e-02f, -6.44791722e-02f, -1.55310929e-01f, -2.00456139e-02f, -1.28908724e-01f, -1.11367717e-01f, -6.92764819e-02f, -9.26829726e-02f, -7.38175809e-02f,
  -1.12120070e-01f, -4.83191535e-02f, 7.41082206e-02f, -1.65694691e-02f, -5.43305241e-02f, -2.26531755e-02f, 6.44257218e-02f, -7.41464272e-02f, -5.22026652e-03f, -7.09661245e-02f,
  -2.83755008e-02f, -9.99117717e-02f, 2.55104542e-01f, -2.15976968e-01f, -8.17377791e-02f, 1.68171734e-01f, 2.14731023e-01f, 3.87989171e-02f, -2.37221390e-01f, -5.25479466e-02f,
  1.99067313e-02f, 1.80681441e-02f, 4.69038449e-02f, 9.18664858e-02f, 1.25650957e-01f, -6.86964542e-02f, -4.78529744e-02f, 1.79800168e-01f, 1.88892126e-01f, 1.29807547e-01f,
  -1.39725402e-01f, -1.96684346e-01f, -1.33272424e-01f, -2.85240840e-02f, -1.85743615e-01f, -8.08186755e-02f, -1.61199450e-01f, -2.32120026e-02f, -1.10310251e-02f, -2.03500256e-01f,
  8.73677880e-02f, 7.22203702e-02f, 6.24762364e-02f, -8.79889950e-02f, -7.42208585e-02f, -8.18643719e-02f, -2.86787543e-02f, -9.53794792e-02f, -5.71766421e-02f, -7.35311434e-02f,
  1.75219751e-03f, 6.51514670e-03f, 8.41652509e-04f, -1.15159914e-01f, -1.13470629e-01f, 2.02227086e-02f, -1.58858478e-01f, 3.88253406e-02f, 9.23677906e-02f, 6.94301501e-02f,
  -8.75610784e-02f, -2.24124938e-02f, 5.15963882e-02f, 6.24509566e-02f, 2.37199236e-02f, 7.90786743e-02f, 1.26026139e-01f, -5.73503673e-02f, 1.72863007e-01f, -7.51971081e-02f,
  -1.61421131e-02f, 1.10258348e-04f, 3.98863852e-02f, -1.32964537e-01f, 1.49172889e-02f, -7.10287690e-02f, -7.12068230e-02f, 4.18905914e-02f, -2.62880046e-02f, 4.37403545e-02f,
  1.34115405e-02f, 6.51961640e-02f, -2.99860332e-02f, -1.41705563e-02f, -9.66797248e-02f, 4.61252872e-04f, 3.19135822e-02f, 8.77065212e-03f, 7.89072085e-03f, 3.22332755e-02f,
  -2.81656161e-02f, 1.21716432e-01f, -6.85457140e-02f, -2.87017915e-02f, 4.26639467e-02f, 9.82724354e-02f, -8.80904030e-03f, -1.60472430e-02f, 4.79333568e-03f, 9.40761250e-03f,
  -1.79518610e-01f, 2.50370130e-02f, -3.49761010e-03f, 2.42884047e-02f, -2.37962860e-03f, -2.64886785e-02f, -3.57682891e-02f, -2.22986657e-02f, -6.23592697e-02f, -2.30844021e-02f,
  9.28497389e-02f, -1.80609692e-02f, -3.16100232e-02f, -3.22320522e-03f, -7.94326514e-02f, 1.86929144e-02f, -5.21216840e-02f, -4.39453274e-02f, -2.08673440e-03f, -7.73347765e-02f,
  -1.01164095e-01f, 4.16763574e-02f, -4.20921808e-03f, 3.58105674e-02f, 1.78346336e-02f, 1.22270308e-01f, 1.00037441e-01f, 1.47273513e-02f, 9.93000045e-02f, -1.72217056e-01f,
  -3.56041998e-01f, -1.69501066e-01f, -1.65091500e-01f, -2.30839610e-01f, -1.10601299e-01f, -1.38651987e-03f, 1.03403293e-01f, -6.20614924e-02f, -9.67776775e-02f, -1.27842844e-01f,
  -6.27277941e-02f, -1.02436310e-02f, -1.33469626e-01f, 5.20735942e-02f, 8.96626487e-02f, 5.98780960e-02f, 4.99698892e-02f, -8.28234404e-02f, 1.48513198e-01f, 8.95963758e-02f,
  5.39411306e-02f, -1.47898659e-01f, -1.85104221e-01f, -7.94289410e-02f, -1.21742077e-01f, 7.41377426e-03f, -1.96803838e-01f, -2.49477521e-01f, -7.86307007e-02f, -2.90746987e-01f,
  -2.40789950e-01f, -3.82180899e-01f, 3.63532156e-02f, -6.86771795e-02f, -5.75711913e-02f, -1.29063576e-01f, -6.63678944e-02f, -1.88807830e-01f, -9.70414355e-02f, -8.48801881e-02f,
  -5.71013726e-02f, -3.89836878e-02f, -5.57316765e-02f, -7.39438608e-02f, -7.62518793e-02f, -1.52480416e-02f, -9.97830629e-02f, -1.08224943e-01f, -1.89060494e-02f, -9.88850966e-02f,
  -1.40543103e-01f, -1.04511827e-01f, -1.34012848e-01f, -1.26657188e-01f, -1.13186806e-01f, 4.73722396e-03f, -7.04248399e-02f, -7.76748657e-02f, -1.77053288e-01f, -1.38966501e-01f,
  5.08978553e-02f, -1.71574056e-02f, -2.19412372e-02f, -2.79000029e-02f, 2.86847837e-02f, -1.34972166e-02f, -7.92931914e-02f, -4.72137071e-02f, -4.28280868e-02f, -3.95202488e-02f,
  -1.97201800e-02f, -3.34592722e-02f, -6.80823252e-02f, 1.30560417e-02f, -2.06511617e-02f, -1.18320420e-01f, -6.01185635e-02f, 3.49248294e-04f, 3.16745043e-02f, -3.36471908e-02f,
  1.70698240e-02f, -9.08271000e-02f, 8.36801901e-03f, -1.87549703e-02f, -1.01043925e-01f, -6.36903644e-02f, -6.75189793e-02f, 1.42716477e-02f, -2.77120005e-02f, 1.88981090e-03f,
  1.24965906e-02f, 3.61932106e-02f, -8.52823034e-02f, -7.74736479e-02f, -1.25890046e-01f, 1.46975489e-02f, -1.22142881e-01f, -8.13593864e-02f, -1.42014980e-01f, -3.76546979e-02f,
  -7.30055198e-02f, -4.24343124e-02f, -7.05150738e-02f, -1.06743677e-02f, 2.33260896e-02f, 1.88234877e-02f, 5.92557862e-02f, 4.78340164e-02f, 1.30893765e-02f, -2.05611140e-02f,
  7.22710639e-02f, -1.90725997e-02f, -2.04556622e-02f, -2.41908729e-02f, -1.16085537e-01f, -3.41585204e-02f, 4.26752791e-02f, -6.24615662e-02f, 9.02364254e-02f, 1.27216518e-01f,
  -2.06980169e-01f, 2.60430314e-02f, -1.37875080e-01f, 6.56553369e-04f, 3.63308145e-03f, 6.76356703e-02f, -1.23947076e-02f, 4.85679768e-02f, -6.98243780e-03f, -1.74572505e-02f,
  2.17332598e-02f, -9.04847383e-02f, 1.26429610e-02f, 7.11359130e-03f, -9.94496346e-02f, 3.52212414e-02f, 8.90282169e-02f, -8.44332501e-02f, -1.51508152e-01f, 3.60349379e-02f,
  4.55629118e-02f, -7.36179501e-02f, -1.74219295e-01f, -7.98587874e-02f, 2.30894625e-01f, 5.46722375e-02f, 4.50791232e-02f, 9.75000486e-03f, 1.09412082e-01f, 1.27772957e-01f,
  1.06978789e-02f, 4.35531698e-03f, -8.80837366e-02f, 3.31814364e-02f, 2.78385673e-02f, -2.64881440e-02f, 3.71107878e-03f, 6.22944385e-02f, 1.32363057e-02f, 1.04199760e-02f,
  7.13849515e-02f, 1.10296503e-01f, 4.39012796e-02f, 1.33665979e-01f, 8.59649628e-02f, -5.22757433e-02f, 7.06420541e-02f, 2.70276479e-02f, 3.53378756e-03f, 9.35471654e-02f,
  1.08106114e-01f, 8.31526220e-02f, -7.41234934e-03f, -3.83312814e-02f, -7.85425771e-03f, 1.15841115e-02f, 2.47794557e-02f, 6.98457733e-02f, 3.88357304e-02f, 7.48183653e-02f,
  -1.67267770e-01f, 6.33667484e-02f, 7.24491701e-02f, -4.06325571e-02f, 3.18506248e-02f, -2.01815390e-03f, 3.74694658e-03f, -1.97869483e-02f, -1.46935079e-02f, 4.58430573e-02f,
  -1.25510488e-02f, -9.49166119e-02f, -2.34062057e-02f, 1.75726842e-02f, -1.55491643e-02f, 2.89439317e-03f, 5.48516735e-02f, 6.28603920e-02f, 1.63071472e-02f, -4.90027964e-02f,
  -3.85580733e-02f, 9.82293114e-03f, -2.12034974e-02f, -2.32894924e-02f, -3.06083765e-02f, -5.30174486e-02f, -3.56030352e-02f, 4.24590036e-02f, 9.07370304e-06f, -7.57231610e-03f,
  -1.20041743e-01f, -1.37241796e-01f, -1.26809150e-01f, -4.12750803e-02f, 4.61657196e-02f, -1.49606019e-02f, -6.50603324e-02f, -3.30912918e-02f, 8.46068026e-04f, -8.19440335e-02f,
  -6.83395490e-02f, 1.66683681e-02f, -4.05310765e-02f, -5.52319409e-03f, 1.05419103e-02f, 3.41112167e-02f, -1.47525826e-02f, -7.76837114e-03f, 4.50468063e-02f, 2.49342378e-02f,
  3.83940153e-02f, -1.04469135e-01f, -5.56052737e-02f, -2.24183425e-02f, 5.41529842e-02f, -1.18779428e-01f, -9.69709828e-03f, -6.97696730e-02f, -2.25742720e-02f, -1.28509000e-01f,
  1.79743543e-01f, 1.50386840e-01f, -2.77752578e-02f, -6.11394867e-02f, -2.17881516e-01f, -1.64463669e-01f, -1.06789157e-01f, -3.38124074e-02f, -1.69251952e-02f, -7.47984126e-02f,
  -1.10307401e-02f, -2.33698711e-01f, -1.50459215e-01f, -3.99761125e-02f, -3.24881524e-02f, 8.85253549e-02f, -4.32360023e-02f, -1.41076073e-01f, -2.62803227e-01f, -2.66485542e-01f,
  -2.72050261e-01f, -1.35324478e-01f, -5.52399457e-02f, -1.52960476e-02f, -1.01209775e-01f, -1.61397070e-01f, 4.27737609e-02f, 7.58296102e-02f, -7.60156214e-02f, 5.99741079e-02f,
  1.13071129e-02f, 1.82290152e-01f, -1.26506150e-01f, -3.09047624e-02f, 4.78085168e-02f, 7.58732334e-02f, -5.41461669e-02f, 7.42379427e-02f, -5.45202382e-02f, 4.65563266e-03f,
  3.49483155e-02f, -1.31721392e-01f, -8.47932398e-02f, -2.68422458e-02f, 4.03812826e-02f, -4.42305766e-02f, 9.46666822e-02f, 7.72651210e-02f, -4.21659946e-02f, 2.37501450e-02f,
  -8.14491287e-02f, 9.00452659e-02f, -4.85608447e-03f, 7.87655041e-02f, 7.97804147e-02f, -1.32094190e-01f, 6.16875216e-02f, -1.66512057e-02f, 1.77855846e-02f, 5.45094348e-02f,
  -1.82626471e-02f, 4.39784899e-02f, -1.62869170e-02f, -3.82083990e-02f, 3.87584940e-02f, -6.60091871e-03f, -3.70209180e-02f, -4.73280530e-03f, -4.24751937e-02f, 8.52756351e-02f,
  -2.54877415e-02f, 8.96179080e-02f, 6.30386993e-02f, -1.79573502e-02f, -6.71082363e-02f, 2.08531171e-02f, 2.40941551e-02f, 5.33958040e-02f, 7.42002875e-02f, 4.32188585e-02f,
  -2.62921490e-02f, 2.76563819e-02f, 7.65846372e-02f, -5.98039366e-02f, -3.35946074e-03f, 4.84106503e-02f, -6.74178153e-02f, -2.71296548e-03f, -6.41465932e-02f, -6.60521910e-02f,
  -2.43876621e-01f, -3.34872827e-02f, 9.34366195e-04f, 1.15475245e-03f, -7.73967430e-02f, 1.53212801e-01f, 5.81527874e-02f, 3.08338180e-02f, 3.52453515e-02f, -5.75759709e-02f,
  6.69351965e-02f, -1.19269127e-02f, -3.32310945e-02f, 6.47216290e-02f, -1.14452995e-01f, 5.19081717e-03f, -4.51183580e-02f, -3.23382951e-02f, -4.37966036e-03f, 3.01942024e-02f,
  6.95610270e-02f, 1.97949130e-02f, -5.94758540e-02f, -2.55984236e-02f, 6.82775676e-02f, -6.29127249e-02f, 4.01088558e-02f, 4.77982089e-02f, -4.36033197e-02f, -1.28289223e-01f,
  3.24776143e-01f, -1.14339396e-01f, -4.18638028e-02f, -1.11016938e-02f, -7.97098354e-02f, 1.50598986e-02f, -8.70223641e-02f, 7.59396777e-02f, 3.25395055e-02f, -9.71868336e-02f,
  -1.49404436e-01f, -1.37715116e-01f, -1.55839771e-01f, -9.44109187e-02f, 2.74909083e-02f, -1.72080666e-01f, -2.18459904e-01f, -2.68868711e-02f, 1.51264369e-01f, 7.33140558e-02f,
  -3.12397256e-02f, 7.31589124e-02f, 7.83322752e-02f, -4.83148135e-02f, -1.50484949e-01f, -1.72921550e-02f, 4.35277307e-03f, -3.50822285e-02f, -1.59784868e-01f, -1.68790549e-01f,
  -2.52017602e-02f, -3.46437618e-02f, 4.30611931e-02f, -4.50124666e-02f, -8.20743069e-02f, -3.70726809e-02f, -9.54581797e-02f, -1.01373293e-01f, -7.54697993e-02f, -1.12292670e-01f,
  -3.37715005e-03f, -6.59193546e-02f, -1.60807714e-01f, -2.67918240e-02f, -3.67038622e-02f, -2.56852396e-02f, 1.42784873e-02f, -8.38889554e-02f, -9.04176533e-02f, -1.61795765e-02f,
  -8.43302831e-02f, -3.79170328e-02f, 1.96587257e-02f, -7.83061013e-02f, 2.61583179e-02f, 6.62144572e-02f, 7.28575438e-02f, 2.86907833e-02f, 1.41144842e-01f, 9.48799849e-02f,
  8.18153992e-02f, 1.05369881e-01f, 6.57858402e-02f, 5.32187149e-02f, 5.74148186e-02f, -1.10203831e-03f, 2.26348247e-02f, -3.15778120e-03f, 5.48071403e-04f, 1.05428688e-01f,
  1.57968923e-01f, -3.97156429e-04f, 3.22996378e-02f, 1.54687896e-01f, -1.24646425e-02f, 1.38802096e-01f, 2.33893711e-02f, -4.31031249e-02f, 4.29300312e-03f, 1.17038324e-01f,
  1.22322356e-02f, 4.61290441e-02f, 7.19589666e-02f, 4.71576974e-02f, 9.12661012e-03f, 8.69452730e-02f, 8.92016068e-02f, 1.65148422e-01f, 1.90140218e-01f, 1.97246999e-01f,
  1.17412627e-01f, 2.50348691e-02f, -1.82025924e-01f, -1.95259433e-02f, -3.27417478e-02f, -5.20170815e-02f, -1.27343506e-01f, -9.29132178e-02f, -9.59539637e-02f, -5.46104684e-02f,
  5.53623354e-03f, -2.73241866e-02f, -1.12726107e-01f, -1.47171676e-01f, -1.16597481e-01f, -7.50039937e-03f, -5.12082689e-02f, -3.28367762e-02f, -1.34756073e-01f, -6.47363514e-02f,
  -4.99034077e-02f, 6.89496472e-02f, 9.84042734e-02f, -1.27983361e-01f, -1.43092498e-02f, 4.94421646e-02f, -1.61186175e-03f, 1.99098792e-02f, 7.68328132e-03f, 4.33594920e-02f,
  1.94027394e-01f, -7.68410042e-02f, -1.35742366e-01f, -1.10593915e-01f, 5.39309457e-02f, 1.85870200e-01f, 1.05181254e-01f, -2.17112321e-02f, -2.76354086e-02f, 1.23706413e-02f,
  2.48850174e-02f, -1.00415692e-01f, -2.34144162e-02f, -2.20990293e-02f, 1.02874944e-02f, -1.30249243e-02f, -2.35463262e-01f, -1.13393918e-01f, 1.33456618e-01f, 6.70133680e-02f,
  7.92568456e-03f, -1.19554728e-01f, -1.20856516e-01f, -1.69966102e-01f, -2.87914813e-01f, -4.96754423e-02f, -2.89639562e-01f, -1.47011995e-01f, -7.16535598e-02f, -3.62731576e-01f,
  -1.33566454e-01f, -1.66276142e-01f, -4.47650366e-02f, 7.05349818e-02f, -4.27804329e-02f, -7.37133548e-02f, -2.03100853e-02f, -2.01997325e-01f, -1.40530132e-02f, -1.59360990e-01f,
  -2.40716916e-02f, -6.21597730e-02f, -1.49878472e-01f, -7.33984634e-02f, -1.36697978e-01f, -3.10930219e-02f, -1.28740743e-01f, -2.30204135e-01f, -1.21933371e-01f, 1.52153634e-02f,
  -1.36989340e-01f, -2.68330108e-02f, -1.16536073e-01f, -1.46251097e-01f, -1.81973696e-01f, -1.40749559e-01f, -1.14491306e-01f, -8.74325112e-02f, -6.35368079e-02f, -8.29598159e-02f,
  1.50371328e-01f, -4.07700352e-02f, 7.89736509e-02f, -6.29908754e-04f, -8.50862067e-04f, 8.08978155e-02f, 3.49101238e-02f, -7.47020915e-03f, 1.24406710e-01f, 8.37963596e-02f,
  -5.66409752e-02f, 4.50365879e-02f, 4.64869142e-02f, 7.59736672e-02f, 7.26385936e-02f, -2.86516342e-02f, 9.29091275e-02f, 1.01648852e-01f, -4.47333120e-02f, 1.13072649e-01f,
  1.02567829e-01f, 2.67342385e-03f, 3.13108638e-02f, 4.06021625e-03f, -3.75941433e-02f, -4.52537015e-02f, -1.77081209e-04f, 6.53092191e-02f, 6.46540672e-02f, 6.88484088e-02f,
  2.11224966e-02f, -2.77442712e-04f, 7.52887055e-02f, -8.63395557e-02f, -1.49448112e-01f, -9.46916640e-02f, -7.42920786e-02f, -6.41797036e-02f, -3.16829211e-03f, -8.34074393e-02f,
  -5.96610121e-02f, -1.42193586e-02f, -3.37234885e-02f, -3.19701731e-02f, -4.32856716e-02f, 3.79886366e-02f, -2.53354497e-02f, -3.16846110e-02f, -3.62909324e-02f, -1.38166890e-01f,
  2.07149182e-02f, 8.23790506e-02f, 8.08530524e-02f, 7.44188428e-02f, -1.59891397e-02f, 1.02211006e-01f, 2.77594700e-02f, 5.66404462e-02f, 9.33304429e-02f, 1.33562371e-01f,
  4.50836986e-01f, 9.81357023e-02f, 2.55585849e-01f, 1.56951398e-01f, -2.38671489e-02f, -7.82192722e-02f, 1.96547601e-02f, -2.87041049e-02f, 4.15522680e-02f, 1.37514979e-01f,
  1.07184714e-02f, 1.34406343e-01f, 2.15999946e-01f, 1.49445415e-01f, 1.84121132e-01f, 1.43623590e-01f, 1.45387515e-01f, 3.27273607e-01f, 2.81045765e-01f, -9.60276369e-03f,
  -3.31843533e-02f, 2.17191651e-01f, 2.79435009e-01f, 1.44857064e-01f, 2.33799275e-02f, 9.97726619e-02f, 5.23691587e-02f, 5.53215556e-02f, 2.59064417e-02f, 2.16690645e-01f,
  1.47757038e-01f, 1.82894066e-01f, -8.30994826e-03f, 8.68080184e-02f, 1.19388908e-01f, 1.71614453e-01f, 9.41340700e-02f, 8.78948867e-02f, 2.16357298e-02f, 1.60294503e-01f,
  1.24709815e-01f, 1.51574155e-02f, 5.72574064e-02f, 6.28905371e-02f, 4.76046354e-02f, 8.51979032e-02f, 6.94681257e-02f, 2.37167001e-01f, 1.54102817e-01f, 5.21004237e-02f,
  5.34630986e-03f, 1.31135881e-02f, 1.96668908e-01f, -4.77405824e-03f, 4.33596298e-02f, 1.25138417e-01f, 9.72845927e-02f, -4.45650890e-02f, 6.49758428e-02f, 2.15798412e-02f,
  4.34468165e-02f, -9.78705660e-02f, -8.05667788e-02f, -8.88595134e-02f, -2.01357439e-01f, -3.69779207e-02f, -1.04852624e-01f, -1.20381780e-01f, -1.08376786e-01f, -5.98277524e-02f,
  -9.99091044e-02f, -8.10161605e-02f, -8.13879296e-02f, -1.23644553e-01f, -1.14700772e-01f, -9.03921574e-02f, -1.21640280e-01f, -8.52966309e-02f, -8.75413120e-02f, -8.47926438e-02f,
  -9.41002592e-02f, -1.04671270e-01f, -5.49909957e-02f, -1.38486430e-01f, -1.57509699e-01f, -2.52629314e-02f, -7.89156258e-02f, -1.95032120e-01f, -1.87202066e-01f, -6.65703192e-02f,
  1.39325961e-01f, 1.06582396e-01f, 1.74036488e-01f, 7.20651522e-02f, 1.32529885e-01f, 1.90296415e-02f, 9.89004448e-02f, 8.00673142e-02f, 8.92690271e-02f, -3.11093009e-03f,
  3.86037380e-02f, 1.53629929e-01f, 2.85572354e-02f, -3.30539830e-02f, 1.27265573e-01f, 8.84907395e-02f, 6.87299967e-02f, 4.19153236e-02f, 1.23913378e-01f, 3.64675522e-02f,
  3.89756337e-02f, 1.82072669e-01f, 2.07090348e-01f, 7.71408677e-02f, 1.02321535e-01f, 6.98218495e-02f, 1.30564004e-01f, 1.08316086e-01f, 1.32745683e-01f, 1.50838375e-01f,
  -3.41968834e-01f, 4.14541125e-01f, -1.07688643e-01f, -1.47022724e-01f, 7.81501681e-02f, 1.68703139e-01f, 3.29207957e-01f, -1.87923778e-02f, -6.17354326e-02f, 2.20169410e-01f,
  1.23729050e-01f, -7.67513067e-02f, -1.55849248e-01f, -1.28086016e-01f, -2.10022971e-01f, 6.51751012e-02f, -6.55925795e-02f, -1.90750375e-01f, -3.48159194e-01f, -4.77285907e-02f,
  1.00696571e-01f, -1.33174760e-02f, -2.20245704e-01f, -1.75496846e-01f, 2.04936177e-01f, -7.43187815e-02f, 1.78155020e-01f, 8.44154358e-02f, 1.22783050e-01f, 2.38275453e-02f,
  1.42602781e-02f, 1.08056732e-01f, -8.59600976e-02f, -4.70112078e-02f, 6.05615713e-02f, -3.46610472e-02f, 4.80798669e-02f, 3.71356048e-02f, -3.74029689e-02f, 8.61139819e-02f,
  4.73251343e-02f, -5.63992895e-02f, 9.42148548e-03f, 4.67798747e-02f, -2.13946979e-02f, 3.85174640e-02f, -1.08318374e-01f, -9.57490653e-02f, -4.28012647e-02f, 6.51117042e-02f,
  5.93912341e-02f, 3.29266042e-02f, 9.46279690e-02f, 6.12656865e-03f, 7.51655325e-02f, -1.37730241e-02f, 3.98459211e-02f, 1.19839422e-01f, 1.98945170e-03f, 7.45060816e-02f,
  7.20100179e-02f, -8.38887785e-03f, -1.23268552e-02f, 5.03357165e-02f, 6.99006692e-02f, 6.60235509e-02f, 3.32471877e-02f, 3.35001126e-02f, 3.31848525e-02f, 3.61547247e-02f,
  2.33480483e-02f, 6.88028783e-02f, -2.14866046e-02f, -1.60258375e-02f, 1.49831865e-02f, -4.99115558e-03f, -7.34509528e-02f, 7.84240067e-02f, 3.10441125e-02f, 3.12494114e-02f,
  -2.07953178e-03f, 1.70052908e-02f, 7.40042552e-02f, 5.78421764e-02f, 3.08106709e-02f, -6.79485276e-02f, -5.86293684e-03f, 5.76995574e-02f, -3.08296923e-03f, 1.23471536e-01f,
  1.30561531e-01f, -7.23048002e-02f, -4.31538112e-02f, 1.99888311e-02f, -1.62961297e-02f, -1.61243659e-02f, 7.90646225e-02f, 2.50283796e-02f, 5.58776036e-02f, -3.27753015e-02f,
  7.88609833e-02f, -3.58371288e-02f, -3.01386677e-02f, -3.42656334e-04f, -9.67647135e-02f, 4.83780727e-02f, 7.77326301e-02f, -3.79481241e-02f, -4.01771860e-03f, 1.16731152e-01f,
  -6.48097470e-02f, -4.73524407e-02f, -1.60055980e-01f, -3.20815556e-02f, -3.34136486e-02f, -8.42011943e-02f, 1.26732260e-01f, 1.03951842e-02f, 2.70482269e-03f, 3.83599028e-02f,
  -3.68265003e-01f, -4.85463552e-02f, 2.47501850e-01f, -2.42282405e-01f, 4.56816703e-02f, 1.29638538e-01f, 6.92821294e-02f, -1.34526610e-01f, -2.53411770e-01f, -7.80227110e-02f,
  -2.94014830e-02f, -1.10515900e-01f, 8.02385993e-03f, 7.74050057e-02f, 9.42257196e-02f, 9.68346521e-02f, 1.29011035e-01f, 6.08083569e-02f, -4.50851247e-02f, -9.71078780e-03f,
  5.15746837e-03f, -1.38905654e-02f, -8.38818178e-02f, 3.97188142e-02f, -1.33880675e-02f, 2.32206890e-03f, 9.32613090e-02f, 1.20951690e-01f, 7.21773058e-02f, -1.34314951e-02f,
  -9.22054052e-02f, 3.29629965e-02f, -3.04174231e-04f, -7.31120557e-02f, 5.62315360e-02f, -6.34704232e-02f, -4.82074916e-03f, -1.75572913e-02f, -9.85748041e-03f, -7.08758980e-02f,
  1.27141709e-02f, -2.42843125e-02f, -5.52445650e-02f, -1.82041395e-02f, -9.29073319e-02f, -8.02407786e-03f, 6.10966282e-03f, 3.26765478e-02f, -2.82996744e-02f, 4.95117381e-02f,
  -7.91786122e-04f, 2.44551525e-03f, -1.67276412e-02f, 8.33104998e-02f, -9.37263190e-04f, -3.31617184e-02f, 1.05122402e-01f, 3.23576629e-02f, 1.94757562e-02f, -2.14075938e-01f,
  -5.12778722e-02f, 1.13936905e-02f, 6.71074688e-02f, 8.96224112e-04f, 9.16175637e-03f, 1.28201902e-01f, 1.21032357e-01f, -4.59351055e-02f, -2.55621821e-02f, -1.48295676e-02f,
  1.18230268e-01f, 3.03397197e-02f, 1.16080418e-01f, -1.13643399e-02f, 7.33835399e-02f, 5.74932098e-02f, 3.95954736e-02f, -3.00510749e-02f, 2.00655963e-02f, -6.09572930e-03f,
  9.10720229e-03f, 1.04741119e-01f, 7.12249726e-02f, -6.23182440e-03f, 5.17024174e-02f, 6.84680417e-02f, -2.12940630e-02f, 4.48648594e-02f, 9.21193697e-03f, 9.04386193e-02f,
  -2.77201444e-01f, 1.72970876e-01f, -7.52309635e-02f, -4.44862172e-02f, -3.22896875e-02f, 5.85719496e-02f, 1.53838675e-02f, -1.27079915e-02f, 3.51819508e-02f, -3.66679952e-02f,
  4.80850451e-02f, -4.84163165e-02f, -5.04902825e-02f, 2.32184324e-02f, -8.50413740e-02f, -7.02503994e-02f, 2.34016348e-02f, -1.18680042e-03f, 9.66308545e-03f, -1.02756985e-01f,
  5.34841530e-02f, -6.26045838e-03f, -7.57055059e-02f, -1.25228673e-01f, 1.06318165e-02f, -6.81405365e-02f, -5.31232469e-02f, -1.53261021e-01f, -1.24335453e-01f, -2.50593543e-01f,
  9.15063620e-02f, 1.27161637e-01f, 4.33975458e-02f, -2.15179965e-01f, 7.79068097e-03f, 7.81771541e-02f, 3.26111525e-01f, 5.46454750e-02f, -1.09619081e-01f, 8.88686851e-02f,
  2.17315555e-02f, -1.55466169e-01f, -7.22950995e-02f, 1.00228153e-02f, 7.35754147e-02f, 1.19875148e-01f, 4.17766608e-02f, -6.33410737e-02f, 9.98279303e-02f, 1.29517898e-01f,
  -1.36069179e-01f, -1.33333072e-01f, -5.10517098e-02f, -6.83523715e-02f, -1.86942786e-01f, -6.43177703e-02f, -1.20143080e-02f, -2.20059361e-02f, 1.54218767e-02f, -1.41250670e-01f,
  6.07512854e-02f, 5.54782525e-02f, 2.04809643e-02f, -8.74515343e-03f, -1.52700156e-01f, -1.25277434e-02f, 7.25594088e-02f, -5.40488921e-02f, -5.32737263e-02f, -7.64315575e-02f,
  -6.25963435e-02f, 3.16463336e-02f, -6.51976885e-03f, -1.56267900e-02f, -4.54016626e-02f, -1.08407745e-02f, -6.07587956e-02f, -1.17000431e-01f, -2.51317471e-02f, -2.40003839e-02f,
  -7.58730546e-02f, 3.62912118e-02f, 1.52535394e-01f, -1.90937575e-02f, 4.44821604e-02f, -8.30236375e-02f, -1.76894646e-02f, 1.46451937e-02f, 1.33652464e-01f, 8.14280957e-02f,
  -6.24939986e-02f, 1.21206453e-03f, -2.25438047e-02f, -3.21407951e-02f, -1.83001044e-03f, -6.29381239e-02f, -6.70581385e-02f, 2.42980719e-02f, -8.96127224e-02f, -1.28897548e-01f,
  -3.22788730e-02f, 2.68020928e-02f, -2.66364999e-02f, -7.46363029e-03f, -5.72970212e-02f, 5.73348887e-02f, 2.54586190e-02f, -1.08497933e-01f, -2.81840488e-02f, 1.18766502e-02f,
  4.79646819e-03f, -1.84966009e-02f, -7.95268174e-03f, -7.70010874e-02f, -2.63211168e-02f, -4.34091575e-02f, -6.56475201e-02f, -6.04424886e-02f, 3.93757876e-03f, 4.33455668e-02f,
  -8.82743597e-02f, 1.64071396e-01f, 7.78825488e-04f, -3.85457128e-02f, 3.77519429e-02f, 3.28464247e-02f, 1.93749350e-02f, -1.45625882e-02f, -2.71113347e-02f, 1.04896627e-01f,
  8.37111920e-02f, -1.25301145e-02f, 7.71162286e-02f, -3.47149838e-03f, 4.80142515e-03f, -3.21192667e-02f, 9.36014205e-02f, 4.23117653e-02f, -8.83374549e-03f, -2.89994515e-02f,
  -5.85352108e-02f, 3.61175202e-02f, 1.42030001e-01f, 1.04751028e-01f, 4.67116311e-02f, 1.01227805e-01f, 2.90731844e-02f, 7.10769296e-02f, 8.08888823e-02f, 1.04144529e-01f,
  6.52240142e-02f, 1.60639644e-01f, -1.59557074e-01f, 5.84619157e-02f, -5.10687903e-02f, -1.87805638e-01f, 8.83179158e-03f, -9.91389677e-02f, -1.93265062e-02f, 6.50928840e-02f,
  -3.86992767e-02f, -1.38986617e-01f, -1.86680958e-01f, -1.10803001e-01f, -1.30493164e-01f, -1.39498278e-01f, -8.77844766e-02f, -2.53914654e-01f, -3.02840650e-01f, -4.97254170e-02f,
  -4.84084673e-02f, 1.14126936e-01f, -5.58426082e-02f, 3.74763943e-02f, 1.05957359e-01f, -1.60679728e-01f, -6.00240417e-02f, 5.48625886e-02f, 7.28557482e-02f, 1.75697878e-01f,
  -9.69222561e-02f, 2.19333127e-01f, -7.24633336e-02f, 1.33794639e-02f, 5.61400913e-02f, -4.24606763e-02f, 4.09640372e-03f, 6.16805069e-02f, -6.23280331e-02f, -2.67405361e-02f,
  -1.84097415e-04f, 6.16154671e-02f, 3.23725231e-02f, -9.36767086e-03f, 8.77232403e-02f, 2.48355344e-02f, 3.50507759e-02f, -1.09446101e-01f, -4.01118025e-02f, 9.67004001e-02f,
  -2.27204263e-02f, 1.41389176e-01f, -8.05115253e-02f, 9.89994593e-03f, 3.48439030e-02f, -1.38501942e-01f, -8.85460377e-02f, -6.34275153e-02f, -1.60285771e-01f, -1.72270779e-02f,
  -9.50584710e-02f, -1.11316353e-01f, -2.83008758e-02f, -5.70258349e-02f, 4.67610732e-02f, -1.05999410e-01f, -6.70151506e-03f, -1.11316383e-01f, -3.51654366e-02f, 2.54767481e-02f,
  -7.10901916e-02f, -5.29753044e-02f, -2.23193392e-02f, 2.98684966e-02f, -7.90365860e-02f, 3.32151987e-02f, -5.40772192e-02f, -7.34261200e-02f, 7.24580586e-02f, -6.88565001e-02f,
  -6.18986078e-02f, 6.28084876e-03f, 4.84317541e-03f, 2.47887876e-02f, -1.49038862e-02f, -8.24731588e-02f, 1.50482608e-02f, -1.45263586e-03f, -8.65744650e-02f, -1.02399133e-01f,
  -1.08484425e-01f, -8.93335640e-02f, -5.19395024e-02f, 3.55912186e-02f, 3.58221717e-02f, -5.84637709e-02f, 7.58571848e-02f, -3.12123187e-02f, -8.83391779e-03f, -1.42361652e-02f,
  9.57967062e-03f, -1.10632874e-01f, 6.73873350e-02f, 1.20183006e-02f, -1.22248471e-01f, -1.47272355e-03f, -7.69655928e-02f, -1.29942089e-01f, -3.64921205e-02f, -1.79975051e-02f,
  -3.63407917e-02f, -9.26670507e-02f, -9.78744254e-02f, -1.76293552e-01f, -1.33577436e-01f, -2.02900305e-01f, -1.62319198e-01f, -1.91621453e-01f, -2.56390035e-01f, -1.73029914e-01f,
  -5.98646104e-02f, -1.76655635e-01f, 2.53474772e-01f, -8.04282576e-02f, -3.93493064e-02f, 1.95784256e-01f, 2.15468079e-01f, 6.48208484e-02f, -2.31234655e-02f, -1.27212748e-01f,
  -5.08158579e-02f, 8.05722475e-02f, -1.62867010e-02f, 9.08177793e-02f, 1.52041525e-01f, -3.42091620e-02f, -1.17018223e-02f, 8.67488831e-02f, 3.07326078e-01f, 9.38574374e-02f,
  -9.74027961e-02f, -1.49084553e-01f, -1.17446430e-01f, -9.62698460e-02f, -1.79108202e-01f, -1.47083979e-02f, -2.35171579e-02f, -1.38693452e-01f, -5.38129695e-02f, -1.52298778e-01f,
  2.14824811e-01f, 2.91412193e-02f, 9.86067057e-02f, -2.50276402e-02f, 2.24830937e-02f, -5.23096435e-02f, -3.72017324e-02f, 9.15589184e-03f, -4.32145409e-02f, -1.07911818e-01f,
  2.67783720e-02f, 6.01728167e-03f, -1.98194515e-02f, -1.46104088e-02f, -3.91570330e-02f, 1.48925195e-02f, -1.17106520e-01f, -3.53185348e-02f, 6.45561814e-02f, 9.09915492e-02f,
  -4.67685647e-02f, -4.06089798e-02f, 2.09457483e-02f, 7.19579086e-02f, 6.32920712e-02f, -7.71123096e-02f, 1.65638812e-02f, 1.37867955e-02f, 1.06527150e-01f, -1.50137752e-01f,
  -2.79750973e-02f, 1.51479328e-02f, -2.63373516e-02f, -8.30951631e-02f, 6.17429148e-03f, -4.29641083e-03f, -1.86105240e-02f, 4.90230285e-02f, 3.15556712e-02f, -6.90327436e-02f,
  -1.40712457e-02f, -5.33372499e-02f, 5.98413721e-02f, 6.43922889e-04f, -3.73754837e-02f, -9.37839318e-03f, 9.31636095e-02f, -2.77698264e-02f, 6.41203811e-03f, -2.42018793e-02f,
  -4.22165357e-02f, 8.21679235e-02f, -3.48365493e-02f, 4.14229110e-02f, -5.19280694e-02f, -6.60114661e-02f, 1.16748745e-02f, 1.79001838e-02f, -6.17486909e-02f, -1.10643484e-01f,
  -5.75886667e-02f, 1.04474295e-02f, 5.71123101e-02f, 2.99547482e-02f, 4.73222928e-03f, 2.86092237e-02f, 1.98105779e-02f, -1.00395717e-02f, -3.51786986e-02f, 7.10134581e-02f,
  -2.90823877e-02f, -2.52852384e-02f, 1.87239947e-03f, 1.64125077e-02f, 6.93730116e-02f, 3.03402171e-02f, -7.27576390e-02f, 7.54556060e-02f, -7.26672262e-03f, -2.62658875e-02f,
  -1.03292435e-01f, 9.24664140e-02f, 1.33655682e-01f, 8.61348957e-02f, -3.27088013e-02f, 1.28720179e-01f, 6.30618930e-02f, 8.61316249e-02f, 1.69645995e-01f, -7.19642639e-02f,
  5.40412009e-01f, 2.62023300e-01f, 3.23968120e-02f, 2.46825635e-01f, -6.39417395e-03f, 4.07139920e-02f, 1.38695076e-01f, 1.77853420e-01f, 1.03946023e-01f, 1.51656345e-01f,
  2.76856404e-02f, -1.40273750e-01f, -5.71905002e-02f, -9.87401977e-03f, -4.22125012e-02f, 1.28729656e-01f, 9.00072530e-02f, 4.47596684e-02f, -8.92566144e-02f, -3.44434604e-02f,
  -3.05537973e-02f, 5.69636859e-02f, 8.68602917e-02f, 3.93628776e-02f, -4.49561290e-02f, -1.50037915e-01f, -7.93725103e-02f, 1.02239214e-02f, -1.16603509e-01f, 9.79493707e-02f,
  -6.00324012e-02f, 1.96802139e-01f, -3.76382507e-02f, -7.01076537e-02f, -9.88081768e-02f, -3.65893878e-02f, 1.89379454e-02f, -8.41560587e-02f, -2.53702868e-02f, 2.63158400e-02f,
  -5.61669003e-03f, -4.28661518e-02f, 5.96110821e-02f, -6.80248439e-02f, -1.00858212e-02f, 1.03077069e-01f, -1.72253177e-02f, 4.81997617e-02f, -1.88053194e-02f, 2.53417250e-02f,
  3.43917571e-02f, 8.62044692e-02f, 3.06300782e-02f, -5.52182607e-02f, -1.75034590e-02f, -7.45618418e-02f, 1.26299951e-02f, 4.63812761e-02f, -1.92618910e-02f, -2.36152392e-02f,
  4.71928194e-02f, 2.34073065e-02f, 6.95369989e-02f, 6.04607090e-02f, 1.00799620e-01f, 3.74026992e-03f, 1.51748424e-02f, 2.57112551e-02f, -7.98893720e-03f, 7.54775247e-03f,
  7.85328820e-02f, 5.34645934e-03f, -2.98212860e-02f, 1.52765378e-01f, 1.46323116e-03f, 6.08858578e-02f, 6.89085200e-02f, 8.12190771e-02f, 9.47613195e-02f, 8.05979818e-02f,
  8.74382108e-02f, 7.96688795e-02f, 1.59519464e-02f, 2.61129206e-03f, 1.40751958e-01f, 9.02932063e-02f, 1.24969944e-01f, -2.56077908e-02f, 3.01420595e-02f, 1.20895967e-01f,
  1.11171408e-02f, -5.61859831e-02f, 7.06187561e-02f, 1.16194561e-02f, 2.10223142e-02f, -2.84538586e-02f, 4.74178791e-03f, -1.09746158e-01f, 3.15936655e-02f, 8.98854136e-02f,
  -3.62334866e-03f, -3.71874543e-03f, 7.98713043e-02f, -2.37476081e-02f, -5.57417795e-02f, -1.35861272e-02f, 1.26436017e-02f, -8.48984122e-02f, -4.31123711e-02f, -9.07345191e-02f,
  -5.86045794e-02f, -2.05187537e-02f, 2.04062145e-02f, 1.45386715e-04f, -3.67951579e-02f, -4.56423387e-02f, -8.04777369e-02f, -1.06797084e-01f, -1.41399894e-02f, 7.67733753e-02f,
  4.87079471e-01f, -1.52125344e-01f, -1.39249325e-01f, 9.53263864e-02f, -8.24856237e-02f, 3.03949062e-02f, -3.52516249e-02f, 5.63177047e-03f, 7.11011440e-02f, -5.87465018e-02f,
  -2.57607967e-01f, -6.39607608e-02f, -1.26464739e-01f, -7.46540204e-02f, 4.24252786e-02f, -2.50658896e-02f, 1.17012814e-01f, 6.35109050e-03f, -1.12849951e-03f, -5.09471633e-02f,
  -1.52036715e-02f, -2.77586449e-02f, 6.62959889e-02f, -6.10201247e-02f, -1.68447979e-02f, -3.97322029e-02f, -1.20422490e-01f, 3.79909836e-02f, -1.75816506e-01f, 1.00331172e-01f,
  -1.62061408e-01f, 1.96122639e-02f, -4.61921804e-02f, 2.78218053e-02f, -2.47967094e-02f, -4.14661132e-02f, 4.44595562e-03f, 9.28011164e-02f, 2.18564123e-02f, -6.02138564e-02f,
  2.37245727e-02f, -3.00842542e-02f, 5.23585789e-02f, -1.05446920e-01f, 3.71538699e-02f, -5.62951639e-02f, -7.76210129e-02f, 3.09368200e-03f, -8.79583061e-02f, -1.39823422e-01f,
  -4.09543738e-02f, -3.66936475e-02f, -9.75450873e-03f, -1.12725504e-01f, 2.72306195e-03f, -6.20472943e-03f, -9.50046852e-02f, -1.06977105e-01f, -1.35501578e-01f, 4.61436324e-02f,
  -2.87087318e-02f, -9.35780182e-02f, 8.77234153e-03f, 1.04174033e-01f, 4.83673289e-02f, 7.00736120e-02f, 8.82214680e-02f, 4.27126661e-02f, 1.01869732e-01f, 4.68055792e-02f,
  7.12121949e-02f, 6.77607115e-03f, 4.84987758e-02f, 8.37743580e-02f, 7.04522654e-02f, -1.15752211e-02f, 8.02547112e-02f, -3.54438741e-03f, 1.41833395e-01f, 1.17164753e-01f,
  1.44141123e-01f, -3.47696766e-02f, -1.04409212e-03f, 3.17691863e-02f, 4.21879366e-02f, -2.37149540e-02f, -2.21728440e-02f, -2.36334279e-02f, 7.97055513e-02f, 3.33064795e-02f,
  -1.04897603e-01f, 9.71446838e-03f, 5.99753633e-02f, 6.57970533e-02f, 8.91057402e-03f, -7.16684312e-02f, -7.99242035e-02f, 1.41600007e-03f, -6.82728216e-02f, -6.92448616e-02f,
  -6.81234524e-02f, -4.23488095e-02f, -3.79090942e-02f, -1.26234949e-01f, -2.57635769e-02f, 2.14728098e-02f, -7.25918785e-02f, -1.15200682e-02f, -6.87745586e-03f, -3.68553735e-02f,
  5.58185577e-03f, 3.82921621e-02f, 3.30857486e-02f, -1.05735302e-01f, -3.96542475e-02f, -4.43027131e-02f, -9.46235880e-02f, -1.33619100e-01f, 7.24445656e-03f, -1.68276690e-02f,
  -1.95251212e-01f, 1.17762111e-01f, 1.06487922e-01f, -2.86367446e-01f, 5.07062823e-02f, 1.35829523e-01f, 2.16009125e-01f, -8.55047107e-02f, -2.50579208e-01f, -6.65392950e-02f,
  6.66068820e-03f, -3.09628040e-01f, -2.34783158e-01f, -1.97695330e-01f, 2.08605058e-03f, 9.47084501e-02f, 2.89239734e-03f, -1.65888846e-01f, -1.34165481e-01f, -1.76257834e-01f,
  -2.47418895e-01f, -1.81882009e-01f, -2.05398574e-01f, -2.12187499e-01f, -1.48416936e-01f, -1.82257250e-01f, -6.77214563e-02f, -3.54073457e-02f, -2.50901319e-02f, -1.48829848e-01f,
  -6.28167987e-02f, -1.24721080e-01f, -2.21408993e-01f, -1.88995883e-01f, -2.00835019e-01f, -1.40172556e-01f, -2.01905459e-01f, -8.25505406e-02f, -1.43766090e-01f, -1.97910890e-01f,
  -1.25796840e-01f, -2.18046024e-01f, -9.99294147e-02f, -1.85543492e-01f, -1.37314066e-01f, -1.31040111e-01f, -7.70635158e-02f, -1.60939455e-01f, -6.95688128e-02f, -5.96540533e-02f,
  -2.18005389e-01f, -1.71513394e-01f, -1.07948139e-01f, -1.02841012e-01f, -7.03100264e-02f, -1.37274325e-01f, -2.61195730e-02f, -1.52317062e-01f, -1.47716939e-01f, -1.46755397e-01f,
  -4.28206958e-02f, 1.01911590e-01f, 1.00895360e-01f, 8.05792660e-02f, 7.00297505e-02f, 8.91988948e-02f, 1.44644752e-01f, 3.58602256e-02f, 1.01482525e-01f, 5.28360717e-02f,
  7.76328072e-02f, 1.04429871e-01f, 9.82851908e-02f, 3.86375077e-02f, 2.23129019e-02f, 1.49286792e-01f, 3.57817486e-02f, 6.52845111e-03f, 4.49033603e-02f, 5.18110534e-03f,
  1.92761142e-02f, 1.35280877e-01f, 5.09997122e-02f, 1.34803593e-01f, 1.48247316e-01f, 1.03266768e-01f, 5.83421402e-02f, 1.27606124e-01f, 5.42971678e-02f, 5.73499948e-02f,
  -9.46094394e-02f, -9.62105989e-02f, -2.06304327e-01f, -2.05631495e-01f, -8.91118646e-02f, -1.95973024e-01f, -1.19123437e-01f, -1.87283397e-01f, -1.29798084e-01f, -1.96936145e-01f,
  -1.96254745e-01f, -8.83460715e-02f, -1.29054874e-01f, -7.12685138e-02f, -1.26705423e-01f, -6.95022643e-02f, -1.76588193e-01f, -1.12524003e-01f, -1.46675617e-01f, -1.65701956e-01f,
  -4.70233671e-02f, -6.27805218e-02f, -7.41738677e-02f, 6.30716886e-03f, -8.22228640e-02f, -1.48109049e-01f, -7.76929334e-02f, -2.62986459e-02f, 2.74896659e-02f, -9.76967216e-02f,
  -1.80519745e-01f, 8.81639719e-02f, -9.45796352e-03f, 9.43098888e-02f, 2.19200417e-01f, 2.51992077e-01f, 3.68708432e-01f, 6.06995933e-02f, 2.99520064e-02f, 1.24325432e-01f,
  -4.87192906e-02f, -2.27607638e-01f, -2.16937393e-01f, -1.18190639e-01f, -2.45143414e-01f, 1.81703299e-01f, 1.26133144e-01f, -1.86882436e-01f, -2.21834302e-01f, 6.84485659e-02f,
  1.08163290e-01f, -4.28605005e-02f, -1.08841039e-01f, -7.36839175e-02f, 1.13074094e-01f, -2.54946649e-02f, 1.26424104e-01f, 9.70256627e-02f, 4.30091098e-02f, 3.89143266e-02f,
  -1.21610686e-01f, -3.69058712e-03f, 1.27403513e-01f, 6.86281174e-02f, 9.24474075e-02f, 2.93020569e-02f, 7.19581097e-02f, 1.35405287e-02f, -2.75653489e-02f, -3.48347030e-03f,
  9.14516523e-02f, 6.55877516e-02f, -7.66376704e-02f, 6.81683123e-02f, -1.66532788e-02f, 3.92927497e-04f, -6.73832223e-02f, -8.58368650e-02f, -5.35420589e-02f, 5.51265739e-02f,
  -1.92619506e-02f, 5.01452163e-02f, 1.04204737e-01f, 1.04183860e-01f, -3.21468934e-02f, -7.86239468e-03f, 6.78353980e-02f, 2.06352249e-02f, 4.39674109e-02f, 1.04328938e-01f,
  3.11985333e-02f, 7.35517070e-02f, 1.22295273e-02f, 8.32119361e-02f, -2.17860695e-02f, 5.85531369e-02f, -8.59590992e-02f, 2.17771567e-02f, 5.97836636e-02f, -2.60771457e-02f,
  -6.41929060e-02f, 3.85452397e-02f, 1.46748060e-02f, -7.81587604e-03f, 1.69411171e-02f, 2.20002048e-02f, -3.18378094e-03f, 6.17495365e-03f, -6.32888153e-02f, -2.37501375e-02f,
  -2.32197233e-02f, -6.30043447e-02f, -7.12916702e-02f, 2.25979201e-02f, -5.06007560e-02f, -5.91331115e-03f, -4.20261137e-02f, 3.52654397e-03f, 4.95567843e-02f, 4.88360524e-02f,
  -1.52923286e-01f, -2.99040340e-02f, -5.35509475e-02f, 2.50803120e-02f, 4.36985306e-02f, 6.98178783e-02f, 4.77701314e-02f, 7.72378743e-02f, 6.90815896e-02f, 4.19354439e-02f,
  -7.11904168e-02f, 3.07250042e-02f, -7.01602101e-02f, 8.11990723e-02f, 1.02027692e-01f, 7.29962811e-02f, 8.46064240e-02f, 1.27369845e-02f, 8.92949179e-02f, 2.48819012e-02f,
  8.61880779e-02f, 1.13037013e-01f, -5.36064059e-03f, 1.02481119e-01f, 4.97986637e-02f, 5.57146221e-02f, 3.85737158e-02f, 1.39317047e-02f, -7.13536069e-02f, 1.62115917e-01f,
  -1.56590283e-01f, -1.08561091e-01f, 9.13346782e-02f, -3.67082246e-02f, -9.97562483e-02f, 6.92879781e-02f, -1.35150656e-01f, -9.17096883e-02f, -9.02395695e-02f, -8.35344493e-02f,
  -1.32866159e-01f, 5.03866673e-02f, 4.52582762e-02f, 1.06179848e-01f, 1.48325056e-01f, 4.92390320e-02f, 4.95831743e-02f, 2.11830124e-01f, 3.54131579e-01f, 1.75516650e-01f,
  -1.79791003e-02f, -1.52744567e-02f, 8.84257182e-02f, 2.06884816e-01f, 1.58620119e-01f, 2.40706891e-01f, 1.69388369e-01f, 6.72380626e-02f, 1.87049001e-01f, 2.08789751e-01f,
  1.79010406e-01f, -1.58361927e-01f, 2.08060607e-01f, 1.43981978e-01f, 1.43064365e-01f, 8.30000639e-02f, 1.49741784e-01f, 1.28563702e-01f, 5.24013676e-03f, 8.77315104e-02f,
  1.34671301e-01f, -3.78288440e-02f, 1.22558206e-01f, 1.55856013e-01f, -4.29493235e-03f, 1.16907217e-01f, 7.72364810e-02f, 1.64402947e-01f, 1.89432919e-01f, 1.39091834e-01f,
  1.49676353e-02f, 5.55771999e-02f, 1.93168297e-01f, 1.63351208e-01f, 1.92502379e-01f, 1.83318809e-01f, 1.57370627e-01f, 2.49726072e-01f, 2.64382690e-01f, 2.05675140e-01f,
  1.08795334e-02f, -1.99836660e-02f, -9.44392607e-02f, -7.11915642e-02f, -5.13765588e-02f, -1.07946582e-01f, -4.67006676e-02f, -6.64769905e-03f, -5.04095145e-02f, 5.72419129e-02f,
  -6.59027547e-02f, -2.83716787e-02f, -7.86618590e-02f, -2.81562731e-02f, -6.91552740e-03f, -1.20878005e-02f, -1.14369780e-01f, -4.73356061e-02f, -4.55975346e-02f, -1.00462444e-01f,
  3.69993821e-02f, -6.75809085e-02f, -9.47332010e-02f, 4.00566235e-02f, -9.14669633e-02f, -3.25820260e-02f, -2.78911516e-02f, 3.79401706e-02f, -1.13133132e-01f, -1.23532616e-01f,
  -1.43380128e-02f, 1.00110345e-01f, -2.68649608e-02f, 4.30992022e-02f, 3.40149589e-02f, 6.79561719e-02f, 1.16866037e-01f, 8.66234452e-02f, -2.64511779e-02f, 2.18108818e-02f,
  2.00198647e-02f, 1.36616424e-01f, -3.79009321e-02f, -1.98703241e-02f, 1.04630642e-01f, 1.12143736e-02f, 2.20636800e-02f, 3.75200063e-02f, 8.99679661e-02f, -4.16187793e-02f,
  3.40383500e-02f, 2.66062636e-02f, 1.89005122e-01f, 1.04416549e-01f, 5.77809103e-02f, 1.33774877e-01f, 6.72251806e-02f, 1.87777728e-01f, 2.22293407e-01f, 1.58302143e-01f,
  -2.07486004e-01f, -1.40648512e-02f, -1.74585432e-01f, -1.23089299e-01f, -1.85917869e-01f, -6.66168705e-02f, -2.02971756e-01f, -1.17101595e-01f, -3.26323807e-02f, -8.76961201e-02f,
  8.53149667e-02f, -7.75736291e-03f, -5.77537417e-02f, 3.58702429e-02f, -6.92784712e-02f, -1.11070484e-01f, -1.41643211e-01f, -1.47777572e-01f, -2.05387682e-01f, -7.41518140e-02f,
  -4.85006757e-02f, -9.08649638e-02f, -8.60057622e-02f, -1.00576639e-01f, -5.73568286e-05f, -5.19729517e-02f, -1.09680176e-01f, -3.21490578e-02f, -6.67321682e-02f, -1.20964214e-01f,
  -8.41822922e-02f, -7.86484182e-02f, -1.11678317e-01f, -9.63529348e-02f, -1.56426936e-01f, -1.07589617e-01f, 4.85192286e-03f, -7.75766000e-02f, -5.28748930e-02f, -1.13146668e-02f,
  -3.22072282e-02f, 1.33041339e-02f, -3.94954160e-02f, 4.97145765e-03f, -4.40686271e-02f, -9.45559293e-02f, -1.36972800e-01f, -5.65666519e-02f, -2.57012993e-02f, -8.77902955e-02f,
  5.64206913e-02f, -9.07048434e-02f, -7.80810267e-02f, -1.38671741e-01f, -4.37876098e-02f, -3.26385978e-03f, -1.08479492e-01f, -1.81855485e-02f, 1.11037241e-02f, -9.72759351e-02f,
  1.21535644e-01f, 1.85236216e-01f, -5.48064150e-02f, 7.82552734e-03f, 3.16077517e-03f, -1.90564264e-02f, -7.33921351e-03f, -1.16785550e-02f, 1.22000903e-01f, 6.65652156e-02f,
  2.26896051e-02f, 2.70752776e-02f, 1.18840493e-01f, 7.64229372e-02f, 8.12479630e-02f, -6.55906573e-02f, 7.29292911e-03f, 2.29251329e-02f, 8.64687264e-02f, 1.11559285e-02f,
  1.10160246e-01f, -1.01749422e-02f, 4.24395129e-03f, 2.76938789e-02f, 2.00210251e-02f, 7.88167715e-02f, 1.42979875e-01f, 1.53565064e-01f, 4.88573126e-02f, 4.79783230e-02f,
  -1.00631170e-01f, 1.16551042e-01f, -1.18137337e-01f, -2.49520056e-02f, -2.03284949e-01f, -1.14190578e-01f, -2.82083470e-02f, -9.65963379e-02f, 4.93532903e-02f, -1.66988850e-01f,
  -2.28334293e-02f, -1.18749999e-01f, -7.86664635e-02f, -2.43359376e-02f, -6.43070862e-02f, -1.40436962e-01f, -1.39939964e-01f, -3.67637165e-02f, -1.04310244e-01f, -1.63794473e-01f,
  -1.66791722e-01f, -1.08606614e-01f, -1.37855902e-01f, -8.62186775e-02f, -1.18769355e-01f, -5.59990443e-02f, -1.02934450e-01f, -1.42283887e-01f, -8.01070854e-02f, -8.85572210e-02f,
  -2.47316867e-01f, -8.73213261e-03f, -1.62037864e-01f, -2.95615289e-02f, 1.40321059e-02f, -1.36604592e-01f, -7.08856732e-02f, -8.60255733e-02f, -5.00399694e-02f, -1.16206102e-01f,
  -1.30584270e-01f, -2.95691788e-02f, -1.74999878e-01f, -1.63457766e-01f, -1.09781452e-01f, 7.75591284e-03f, 7.31485197e-03f, -2.07311168e-01f, -1.37082949e-01f, -7.46369595e-04f,
  -3.30733508e-02f, -9.63973626e-02f, -2.31737465e-01f, -6.76346496e-02f, 1.67767219e-02f, -2.59292126e-02f, -9.68748406e-02f, -1.16057368e-02f, -5.79537153e-02f, 1.54063581e-02f,
  -6.41928017e-02f, -2.67297745e-01f, -1.30064562e-01f, -1.73908353e-01f, -1.12315409e-01f, -1.58970296e-01f, -2.06817478e-01f, -2.27810383e-01f, -1.90673769e-01f, -1.72654122e-01f,
  -1.46609724e-01f, -6.79752454e-02f, -7.19391406e-02f, -3.73893604e-02f, -1.48505300e-01f, -8.16928819e-02f, -1.73061356e-01f, -1.32913813e-01f, -2.70578802e-01f, -1.60335973e-01f,
  1.44248158e-02f, -8.11190680e-02f, -2.24132061e-01f, -1.29580140e-01f, -2.26720765e-01f, -1.20798647e-01f, -1.77616149e-01f, -2.40115553e-01f, -1.48950785e-01f, -1.22027032e-01f,
  1.32546052e-01f, 2.09520411e-04f, 5.18886559e-02f, 8.71385038e-02f, 5.35351150e-02f, 9.74570885e-02f, 1.78864941e-01f, 1.18686676e-01f, 5.33692501e-02f, 2.80052349e-02f,
  9.75959972e-02f, 5.97749949e-02f, 9.67313051e-02f, 1.21323891e-01f, 1.82600677e-01f, 2.58951094e-02f, 1.32069334e-01f, 1.51632249e-01f, 9.31446403e-02f, 8.91631469e-02f,
  6.37734160e-02f, 6.76652789e-02f, 4.39223982e-02f, 1.46151200e-01f, 7.34462738e-02f, 4.11139540e-02f, 9.65705141e-02f, 1.14626125e-01f, 1.12281054e-01f, 7.16056526e-02f,
  -4.43364903e-02f, -1.41832247e-01f, -5.36276624e-02f, -9.08013880e-02f, -1.73753336e-01f, -2.01750562e-01f, -6.54981732e-02f, -2.19849661e-01f, -1.31075218e-01f, -1.23501651e-01f,
  -1.00056320e-01f, -8.65661725e-02f, -8.38351846e-02f, -1.92674831e-01f, -1.01136692e-01f, -1.58576339e-01f, -1.11550093e-01f, -1.20918296e-01f, -1.69340804e-01f, -1.79949194e-01f,
  -1.11245632e-01f, -1.43102169e-01f, -6.86862767e-02f, -1.83244407e-01f, -2.41897419e-01f, -8.12454596e-02f, -1.65729642e-01f, -1.08340897e-01f, -2.87733436e-01f, -1.66861191e-01f,
  1.58646554e-01f, 1.34688571e-01f, 2.37877015e-03f, 1.05316609e-01f, 3.01984623e-02f, 4.37908247e-03f, 1.33325383e-02f, 1.19319648e-01f, 2.26167357e-03f, 1.15223572e-01f,
  -1.00137461e-02f, -8.49665627e-02f, -1.25205785e-01f, 4.72117737e-02f, -3.83298434e-02f, 4.47611846e-02f, 1.17794044e-01f, 1.39613524e-01f, 3.67955603e-02f, 1.53867528e-01f,
  8.89669433e-02f, 1.95836410e-01f, 1.30573854e-01f, 1.66379988e-01f, 1.71610177e-01f, 1.94464952e-01f, 1.88611507e-01f, 2.37710640e-01f, 1.73245594e-01f, 2.15176895e-01f,
  2.51984298e-02f, 1.96014553e-01f, 8.71366411e-02f, 2.34552938e-02f, 1.33401155e-01f, 8.02474245e-02f, 3.31827402e-02f, 1.70356750e-01f, 1.53730810e-02f, 9.14005786e-02f,
  5.72800487e-02f, 2.22020317e-02f, 1.14298381e-01f, 4.54300530e-02f, 2.02761707e-03f, 5.44997677e-02f, 1.10516787e-01f, 5.00068851e-02f, -1.78773012e-02f, 1.26554742e-01f,
  1.28830254e-01f, 2.00632825e-01f, 2.70071238e-01f, 1.26519144e-01f, 2.38875747e-02f, 1.14539206e-01f, 1.22511812e-01f, 1.68605551e-01f, 9.32423323e-02f, 1.58106565e-01f,
  -1.53734600e-02f, -9.64884683e-02f, -4.47540395e-02f, -4.19631600e-02f, -4.15035486e-02f, -1.63173944e-01f, -1.56482384e-01f, -1.23469800e-01f, -9.52113643e-02f, -5.54509647e-02f,
  -8.99456069e-02f, -2.63826270e-02f, -3.83971743e-02f, -3.88007537e-02f, -1.20513804e-01f, -3.73276770e-02f, -1.17582642e-01f, -1.41805500e-01f, 9.27794911e-03f, -1.69911049e-02f,
  -4.41404395e-02f, -4.45669442e-02f, -4.64204438e-02f, -1.42163128e-01f, -9.71698463e-02f, -1.03346922e-01f, -1.32373691e-01f, -1.90373108e-01f, -1.06722221e-01f, -1.74549893e-01f,
  -6.05893768e-02f, -7.56156147e-02f, 8.17969590e-02f, 9.65480208e-02f, 1.99029580e-01f, 6.55063018e-02f, 9.12746787e-02f, 1.20808534e-01f, 2.18013092e-03f, 5.07245027e-02f,
  6.04743026e-02f, 5.86887263e-03f, 9.37386975e-03f, 9.51995328e-02f, 5.31228893e-02f, 7.15461448e-02f, 1.58542022e-01f, 1.21676035e-01f, 7.12904558e-02f, 7.95243606e-02f,
  5.28639331e-02f, 2.83215880e-01f, 1.64015725e-01f, 1.01172067e-01f, 7.30976686e-02f, 1.56088233e-01f, 6.56653866e-02f, 1.63155749e-01f, 1.28959328e-01f, 1.60670623e-01f,
  -2.35436395e-01f, 1.30158648e-01f, -2.71608591e-01f, 5.42177856e-02f, 2.36314256e-02f, -2.02657327e-01f, -1.74302384e-02f, -2.03653827e-01f, -5.16340137e-02f, -3.46775312e-04f,
  -1.33582115e-01f, -1.76005527e-01f, -1.18586875e-01f, -1.45682365e-01f, -1.31206140e-01f, -1.49133176e-01f, -1.07939310e-01f, -1.56136498e-01f, -2.35621467e-01f, -1.19333431e-01f,
  7.98379332e-02f, 2.90255360e-02f, -1.47105142e-01f, -3.55634429e-02f, 9.72480774e-02f, -1.53469667e-01f, -5.78487851e-02f, 3.83695289e-02f, 4.44549955e-02f, 9.87855643e-02f,
  -2.43434697e-01f, 1.68765686e-03f, -2.50332236e-01f, -8.10075849e-02f, -9.99420062e-02f, -2.02227548e-01f, -1.74321726e-01f, -1.49160787e-01f, -1.79503083e-01f, -7.88176581e-02f,
  -7.96138484e-04f, -1.42396197e-01f, -1.52039886e-01f, -1.40915886e-01f, -3.26437615e-02f, -1.82960078e-01f, -1.38763174e-01f, -2.09968895e-01f, -2.21281260e-01f, -7.47453049e-02f,
  -2.65426189e-02f, -8.67740214e-02f, -1.49197936e-01f, -1.86484098e-01f, -1.55632153e-01f, -1.72774002e-01f, -1.61466017e-01f, -1.19583391e-01f, -2.39897475e-01f, -1.47078544e-01f,
  1.02285566e-02f, 1.40138865e-01f, 1.85213581e-01f, 1.08954191e-01f, 1.52951032e-01f, 1.18891872e-01f, 1.33695900e-01f, 1.49300843e-01f, 6.27822876e-02f, 1.48164093e-01f,
  1.22641496e-01f, 1.33218560e-02f, 1.20380640e-01f, 6.86873794e-02f, 8.31323266e-02f, 1.01777144e-01f, 1.79174528e-01f, 9.58767533e-02f, 1.30262390e-01f, 1.53275385e-01f,
  6.39605299e-02f, 9.85901058e-02f, 1.21700600e-01f, 1.14157110e-01f, 5.59722446e-02f, 1.35571718e-01f, 3.05813141e-02f, 9.78394598e-02f, 1.02773704e-01f, 9.92241427e-02f,
  -1.37358919e-01f, -2.81131506e-01f, -8.86545256e-02f, -2.42589071e-01f, -1.78644985e-01f, -8.89359862e-02f, -1.43696114e-01f, -1.09773882e-01f, -3.22464816e-02f, -1.29561141e-01f,
  -1.22014917e-01f, -1.06976531e-01f, -5.82603812e-02f, -7.25194588e-02f, -1.45027831e-01f, -1.08227842e-01f, -8.55840296e-02f, -9.82154682e-02f, -1.91860110e-01f, -1.04069971e-01f,
  -1.57325063e-02f, -1.38535112e-01f, -2.13926271e-01f, -1.12923436e-01f, -1.59369409e-01f, -1.47313520e-01f, -2.45712698e-01f, -1.40550703e-01f, -1.39157623e-01f, -2.08776996e-01f,
  2.40286186e-01f, -5.27482256e-02f, 1.60595216e-02f, 2.18685731e-01f, 1.35052845e-01f, -1.80417486e-02f, 1.19893126e-01f, 1.39205620e-01f, 9.85430628e-02f, 3.35142948e-02f,
  -2.53270835e-01f, -2.69593477e-01f, -2.75831103e-01f, -2.72247791e-01f, -2.37229139e-01f, 1.62590429e-01f, 2.60138065e-01f, 5.07760420e-02f, -1.20448790e-01f, -2.75348139e-04f,
  3.30217294e-02f, 1.21975198e-01f, 3.93435322e-02f, 1.86907742e-02f, 1.96544901e-01f, 2.46918909e-02f, 1.53108910e-01f, 3.68233174e-02f, -3.83014642e-02f, 1.92115515e-01f,
  -5.69603406e-03f, -4.70118448e-02f, -1.16810389e-02f, -1.11609839e-01f, -4.99543436e-02f, -8.47005844e-02f, 3.81972045e-02f, -6.22204207e-02f, -9.15175490e-03f, -8.81677493e-02f,
  -9.40772519e-02f, 3.80939022e-02f, -4.39059213e-02f, -1.77545603e-02f, 5.48923910e-02f, -8.00611302e-02f, 2.39900332e-02f, 2.62801293e-02f, -1.22605853e-01f, -1.20868780e-01f,
  3.45481597e-02f, -3.46308574e-02f, -1.00497790e-01f, 2.08094697e-02f, -8.77269655e-02f, -1.34188449e-02f, -4.23267148e-02f, -6.43813908e-02f, -3.73484828e-02f, 1.79822490e-01f,
  9.45599005e-02f, -1.53762391e-02f, -5.81011437e-02f, -1.00547010e-02f, 3.03948876e-02f, -6.30476624e-02f, -8.69225934e-02f, 4.32598703e-02f, 1.32612623e-02f, -1.97264068e-02f,
  -4.74610962e-02f, -1.03006661e-01f, 8.00804496e-02f, -1.95565000e-02f, -4.49600331e-02f, 3.29137556e-02f, -3.74651030e-02f, -3.32720857e-03f, 6.40432490e-03f, -5.74448444e-02f,
  -7.42101818e-02f, 7.00880494e-03f, 6.42299280e-02f, -7.53766298e-02f, 2.12999769e-02f, -3.45522463e-02f, 5.57660311e-02f, -5.60382232e-02f, 1.08570680e-02f, 6.39805272e-02f,
  1.38203472e-01f, -2.03774020e-01f, 8.95365998e-02f, 7.72398859e-02f, 6.60040379e-02f, -3.96619141e-02f, -6.57304469e-03f, -4.32905033e-02f, -1.15584575e-01f, -1.09807432e-01f,
  -4.06607389e-02f, -4.39036377e-02f, -5.47794439e-02f, 1.28280942e-03f, -3.20872404e-02f, 2.81455442e-02f, 9.06366482e-02f, -1.24894464e-02f, 3.76060084e-02f, 7.22093284e-02f,
  1.47463560e-01f, 1.09610803e-01f, 1.17817514e-01f, 8.35058000e-03f, 9.35759321e-02f, 4.21277508e-02f, 8.32040757e-02f, -2.98901014e-02f, -8.04967061e-02f, 2.38446295e-01f,
  4.02883500e-01f, -2.59878159e-01f, -1.66389495e-01f, 1.36370525e-01f, -8.86254907e-02f, -1.52808830e-01f, -1.80376425e-01f, -2.68265009e-02f, 1.73352629e-01f, 4.96256538e-02f,
  -3.15243304e-01f, -1.48899838e-01f, -5.55026159e-02f, -9.63621214e-02f, 7.65054226e-02f, 7.21258670e-02f, 7.13566169e-02f, 7.38450885e-02f, 1.59960780e-02f, 1.46613382e-02f,
  1.76615939e-02f, 5.09711653e-02f, 4.68209013e-02f, 4.16795723e-03f, -1.84866935e-02f, 2.42309049e-02f, -8.44996572e-02f, -1.16598770e-01f, -1.59977749e-01f, 3.33832055e-02f,
  -8.88837799e-02f, -4.00883555e-02f, -2.85384022e-02f, -2.92689893e-02f, -7.72386566e-02f, 7.02004954e-02f, 7.35221431e-02f, -5.85390367e-02f, -2.61611696e-02f, 5.88314831e-02f,
  -1.03128739e-01f, -7.07773194e-02f, -2.10545002e-03f, -1.41683118e-02f, -3.93133201e-02f, 1.15192801e-01f, 7.13809952e-02f, 7.85078779e-02f, -6.92010894e-02f, -5.85147291e-02f,
  -1.57390043e-01f, -1.65436313e-01f, -5.52226678e-02f, -6.54131100e-02f, -6.50234744e-02f, -1.58794317e-02f, -1.60906613e-01f, 3.07405926e-02f, -1.89104918e-02f, 1.37931937e-02f,
  3.65316533e-02f, -2.50832159e-02f, -9.69047565e-03f, 5.11456653e-02f, 1.46380544e-03f, -9.52817425e-02f, 8.16987082e-02f, -5.38977049e-02f, -3.51739787e-02f, 4.63568866e-02f,
  2.20489514e-04f, 2.01547518e-02f, -6.12891614e-02f, 9.41474512e-02f, -6.34868490e-03f, -5.48388101e-02f, 3.77874635e-02f, -4.80596088e-02f, -2.74488926e-02f, -4.95917276e-02f,
  1.15037141e-02f, -8.01839903e-02f, -1.37309935e-02f, 3.25664543e-02f, 5.93381748e-03f, 2.04994194e-02f, 1.10137470e-01f, -1.08663119e-01f, -2.29799543e-02f, 4.37530354e-02f,
  1.26353487e-01f, -1.57527581e-01f, 7.90546164e-02f, 2.74711028e-02f, -1.32105872e-02f, -3.68600115e-02f, -4.22086194e-02f, -7.92415664e-02f, 1.13882693e-02f, 2.76421253e-02f,
  -5.57120554e-02f, 1.40348710e-02f, -9.34819877e-02f, 1.55498553e-02f, 7.35184327e-02f, -3.40985730e-02f, 2.76407786e-02f, 6.17923476e-02f, 1.85593013e-02f, 2.14254800e-02f,
  3.72736307e-04f, 7.47624189e-02f, 7.41410628e-02f, -7.59435864e-03f, -2.00391710e-02f, 8.02897960e-02f, 1.19439298e-02f, 7.51751140e-02f, -1.24929231e-02f, 2.42270380e-01f,
  2.78584152e-01f, 3.36680114e-01f, -9.37345028e-02f, 1.40559912e-01f, 1.73816960e-02f, -1.32835627e-01f, 2.63960976e-02f, -8.35878029e-02f, 5.31611890e-02f, 2.01561257e-01f,
  3.21906328e-01f, 1.58906832e-01f, 1.71291083e-01f, 1.53241996e-02f, -1.01360202e-01f, -3.67494719e-03f, -5.00770584e-02f, -6.98968992e-02f, -1.56449527e-01f, 1.10066578e-01f,
  1.60611585e-01f, 1.60854444e-01f, 5.78507148e-02f, 6.27368987e-02f, 2.40263447e-01f, 1.39733464e-01f, 4.04610531e-03f, 2.19611421e-01f, 1.64012939e-01f, 2.10568756e-01f,
  2.28265509e-01f, 2.87787050e-01f, 7.31617287e-02f, 1.21462226e-01f, 1.26887873e-01f, 8.48166272e-02f, 1.63393945e-01f, 1.43228337e-01f, 1.42704234e-01f, 7.12978095e-02f,
  1.10312462e-01f, 6.25274405e-02f, 1.64318427e-01f, 5.36036380e-02f, 9.87867936e-02f, 8.42119902e-02f, 5.86663075e-02f, 1.12411343e-02f, -4.51701023e-02f, 1.40937120e-01f,
  5.70397601e-02f, 1.86375022e-01f, 7.66118318e-02f, 1.18680745e-01f, 3.28639597e-02f, -1.77136324e-02f, 5.25990687e-02f, 1.47699550e-01f, 1.08353227e-01f, 8.88051987e-02f,
  -8.18265006e-02f, -6.46635294e-02f, -1.33560658e-01f, -9.58196297e-02f, -3.81152965e-02f, -4.31027450e-02f, -7.24420920e-02f, -4.15126756e-02f, -9.56385285e-02f, 8.10494833e-03f,
  -1.12665042e-01f, -9.96103138e-02f, -5.02332337e-02f, 8.48837662e-03f, -1.08904228e-01f, -9.21034887e-02f, -1.33575916e-01f, -7.02256709e-02f, 1.12798787e-03f, 3.49640287e-03f,
  -8.97417516e-02f, -2.77360417e-02f, -9.41418856e-02f, -2.49967743e-02f, -9.75402892e-02f, -1.35357752e-01f, -1.30713850e-01f, -1.25800073e-01f, -1.36370271e-01f, -1.39214471e-01f,
  1.71375260e-01f, -7.08452566e-03f, 1.46276176e-01f, 1.55818596e-01f, 1.48913622e-01f, 6.38364553e-02f, 9.49185714e-02f, 1.55390799e-01f, 1.06668591e-01f, 7.65672550e-02f,
  1.80035532e-01f, 6.42296597e-02f, 1.59071878e-01f, 1.64056495e-01f, 1.31443098e-01f, 8.62076432e-02f, 7.39290863e-02f, 8.23664665e-02f, 1.68611966e-02f, 1.80410802e-01f,
  3.50246392e-02f, 7.30613992e-02f, 5.56687713e-02f, 1.42722592e-01f, 5.72544299e-02f, -5.18218090e-04f, 1.02312751e-01f, 1.03208780e-01f, -5.48568107e-02f, 3.71940956e-02f,
  -6.09832332e-02f, -1.29650414e-01f, -1.30928621e-01f, -2.04757392e-01f, -2.14141026e-01f, -5.78345247e-02f, -1.02806300e-01f, -1.84801817e-02f, -1.11533150e-01f, -4.23570983e-02f,
  -2.27851477e-02f, -6.69692233e-02f, 4.19945382e-02f, 8.85587372e-03f, 2.05364805e-02f, -3.68840955e-02f, -6.74720183e-02f, -1.05875984e-01f, -1.77423760e-01f, -1.83020502e-01f,
  -1.22630797e-01f, -1.26579702e-01f, -1.47078440e-01f, -3.27367298e-02f, -1.16768584e-01f, 1.93615255e-04f, -1.65706389e-02f, -4.32942100e-02f, -5.61984628e-02f, -1.16926521e-01f,
  -4.38553952e-02f, -4.74912859e-02f, 1.02049392e-02f, 7.77683333e-02f, -2.22866866e-03f, 8.97658467e-02f, -1.95973609e-02f, 3.33186314e-02f, 1.58248588e-01f, 7.96320438e-02f,
  -2.68395199e-03f, 2.10228693e-02f, 7.65195787e-02f, -8.33691005e-03f, -4.61482815e-02f, 5.22835925e-02f, 3.67247127e-02f, -3.61052938e-02f, 1.25952095e-01f, 2.67550126e-02f,
  6.32043406e-02f, -5.37121557e-02f, 1.84271745e-02f, 1.47080302e-01f, 6.61085397e-02f, 1.11410923e-01f, 1.75211318e-02f, 4.45370525e-02f, 8.11097622e-02f, 1.51736870e-01f,
  -8.20740759e-02f, -2.93487906e-02f, -5.18722348e-02f, -3.45380208e-03f, 4.68804911e-02f, -1.02187572e-02f, -1.54178003e-02f, -2.51240097e-02f, -8.96466076e-02f, -4.22401130e-02f,
  -1.06950514e-01f, -3.96384075e-02f, -7.51550421e-02f, -4.61803898e-02f, -8.04665163e-02f, -7.27822185e-02f, -6.38002157e-02f, -4.88747470e-02f, 1.36505710e-02f, -1.17390543e-01f,
  -5.16987368e-02f, -1.45438956e-02f, -4.84317169e-02f, -3.25643681e-02f, -9.08675324e-03f, -6.63233250e-02f, -2.25891490e-02f, -2.11172123e-02f, -1.84466615e-02f, -1.20316327e-01f,
  7.75174499e-02f, 3.48761417e-02f, -4.36121132e-03f, 7.78301340e-03f, 6.58624023e-02f, 1.14505515e-01f, 1.30872607e-01f, 1.52006358e-01f, 3.82095855e-03f, -4.71525192e-02f,
  3.54380757e-02f, 3.80198546e-02f, 1.01818256e-01f, -2.19081081e-02f, 3.53197493e-02f, -2.73385961e-02f, 1.58710673e-01f, -5.01230080e-03f, 1.65631160e-01f, 7.87028223e-02f,
  1.54481307e-01f, 2.04747304e-01f, 1.13285862e-01f, 1.29235834e-01f, 6.68897703e-02f, 1.15465313e-01f, 1.59192726e-01f, 9.07611623e-02f, 1.55406162e-01f, 1.18891180e-01f,
  -2.21492514e-01f, 2.32345611e-01f, 3.02114040e-01f, -1.41731083e-01f, 6.20424598e-02f, 2.64877886e-01f, 2.99213350e-01f, 6.64237365e-02f, -2.64368325e-01f, 6.70781955e-02f,
  -1.06997594e-01f, -2.07360893e-01f, -1.56159520e-01f, -4.14715186e-02f, -4.13012411e-03f, 1.57971755e-01f, 1.57170147e-01f, 1.20590568e-01f, -6.65701777e-02f, -2.01680101e-02f,
  -2.12681547e-01f, -2.22170427e-01f, -1.80065885e-01f, -4.58832271e-02f, -2.05276366e-02f, -3.15869190e-02f, 5.96437007e-02f, 4.04571593e-02f, 1.83703929e-01f, 7.96822160e-02f,
  2.47326627e-01f, 6.97251335e-02f, -5.46323396e-02f, -1.36866435e-01f, 1.45707782e-02f, 3.42479646e-02f, 4.01900671e-02f, 1.37613239e-02f, -5.81865720e-02f, -1.23868305e-02f,
  -6.99745938e-02f, -9.61629078e-02f, -4.12046313e-02f, 3.24089192e-02f, 3.66329812e-02f, -2.52123568e-02f, -1.37262233e-02f, 1.00778192e-02f, 2.47906372e-02f, -1.09776212e-02f,
  -7.92762265e-02f, 6.71043396e-02f, 7.68155009e-02f, 1.10738777e-01f, 1.11163877e-01f, 5.65940961e-02f, 1.44821495e-01f, 1.26735434e-01f, 1.99231297e-01f, 1.19120747e-01f,
  -1.50354654e-02f, 7.55391689e-03f, 1.59539022e-02f, 2.10980121e-02f, 1.87986121e-02f, 1.40433265e-02f, 5.49419783e-02f, -3.09136454e-02f, -3.15264128e-02f, 7.18979761e-02f,
  1.18374638e-02f, 2.14823103e-03f, -3.02545615e-02f, 7.07397386e-02f, -2.79438235e-02f, -1.75562426e-02f, 6.67269677e-02f, 2.89075058e-02f, -3.36702503e-02f, -2.68285722e-03f,
  -3.14521529e-02f, 5.50615713e-02f, 3.38501707e-02f, 1.59704592e-02f, 3.44855115e-02f, 1.35140672e-01f, -7.11295055e-04f, 1.02193274e-01f, 9.64980107e-03f, -7.62675144e-03f,
  -1.36505768e-01f, 1.57257691e-01f, 8.42848271e-02f, 2.13236036e-03f, 2.76212371e-03f, 8.17950815e-03f, 4.03752998e-02f, 4.21104319e-02f, 4.34444426e-03f, 1.02519445e-01f,
  1.12719201e-01f, 7.67472908e-02f, 8.91939085e-03f, -2.84883659e-02f, 6.06017523e-02f, -6.10498972e-02f, -3.07227932e-02f, -3.02674100e-02f, 9.17997435e-02f, -1.61801279e-02f,
  5.35598071e-03f, 6.54675066e-03f, 2.54594125e-02f, 1.18236624e-01f, 3.51502001e-02f, 1.60692595e-02f, 1.58726126e-01f, 5.60529605e-02f, 7.68184662e-02f, 1.11071067e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.86547637e-01f, -3.31480294e-01f, -4.51343536e-01f, -3.97860780e-02f, -8.48445222e-02f, 7.76796192e-02f, -6.21016603e-03f, 1.01723842e-01f, 1.96148276e-01f, -1.85123727e-01f,
  -1.39231771e-01f, 4.09000175e-04f, -1.75678074e-01f, -1.29182860e-01f, -6.30785525e-02f, -2.37215981e-01f, -2.06555635e-01f, -1.55877605e-01f, 1.19799927e-01f, 1.43574908e-01f,
  -9.29679573e-02f, -1.14768617e-01f, -4.48939800e-02f, -1.56263094e-02f, -2.02023238e-01f, -1.07762530e-01f, -3.61244321e-01f, -2.49187857e-01f, -2.00040817e-01f, -3.98038894e-01f,
  -3.52874309e-01f, -6.72766268e-02f, 1.17285758e-01f, 1.21407770e-01f, -4.96734791e-02f, 7.13327453e-02f, -1.42393839e-02f, -2.23620031e-02f, 1.62359495e-02f, 4.83285971e-02f,
  -4.32506502e-02f, 2.18682755e-02f, -3.10630798e-02f, -2.12467536e-02f, 7.59196728e-02f, 4.53356281e-02f, 8.46904814e-02f, 8.84798691e-02f, -6.05963543e-02f, -4.98034209e-02f,
  -6.57217354e-02f, 1.13708481e-01f, 1.29890084e-01f, 5.61456680e-02f, 5.91175370e-02f, 8.01791325e-02f, 9.78727788e-02f, 6.49833009e-02f, 9.32642892e-02f, 9.56827775e-02f,
  -9.90744680e-02f, 1.34149119e-02f, 2.75895260e-02f, 1.28323808e-01f, 2.38951802e-01f, 1.30857557e-01f, 3.11405770e-02f, 1.74060106e-01f, 1.57733664e-01f, 1.08208068e-01f,
  5.05714230e-02f, -8.98747817e-02f, 1.02852024e-01f, -1.21248201e-01f, -1.58129439e-01f, 5.15676197e-03f, 1.21788867e-01f, -9.27085280e-02f, -6.40236214e-02f, -4.31415923e-02f,
  7.72019997e-02f, 5.27359806e-02f, -1.46014780e-01f, -1.98576450e-01f, -1.19474173e-01f, 2.14415090e-03f, -5.78757860e-02f, -4.13732454e-02f, -7.90506676e-02f, -5.61242290e-02f,
  -1.44071534e-01f, -1.78119931e-02f, -8.30600858e-02f, 1.02764424e-02f, 1.38855744e-02f, -1.03143699e-01f, -1.10653736e-01f, -9.39650368e-03f, -6.53772205e-02f, -4.72132750e-02f,
  -1.46422181e-02f, 4.40755486e-02f, -1.58889860e-01f, 4.36356338e-03f, 2.13034689e-01f, 1.27776489e-01f, 9.84582603e-02f, 9.55328047e-02f, -2.33045593e-02f, -9.31984782e-02f,
  -8.71242359e-02f, 2.01449335e-01f, 1.48009360e-01f, 1.86652094e-01f, 2.59476274e-01f, 1.54385492e-01f, 7.15387659e-03f, 1.10537827e-01f, 7.93999955e-02f, 1.66210994e-01f,
  5.66034317e-01f, -1.25439331e-01f, -4.45832200e-02f, 2.24110365e-01f, 8.39609802e-02f, 3.78196761e-02f, 6.95662349e-02f, 1.18442357e-01f, 1.28669024e-01f, 1.02575958e-01f,
  3.44819464e-02f, 2.71334238e-02f, 1.23512149e-01f, -5.25857210e-02f, -3.46090756e-02f, -1.05201125e-01f, -5.57355396e-03f, -1.12960227e-02f, 3.12428512e-02f, -1.03448825e-02f,
  5.17254509e-02f, -3.58765833e-02f, 1.02931321e-01f, 2.54352614e-02f, -8.03294107e-02f, -4.47437838e-02f, -4.78900000e-02f, -1.27810881e-01f, -1.20605797e-01f, -2.01882258e-01f,
  -2.02961937e-01f, -1.16715856e-01f, 8.72753412e-02f, -8.28030184e-02f, -7.03485534e-02f, -4.14624512e-02f, -4.69113477e-02f, 4.68657762e-02f, 5.69366850e-02f, 1.42869586e-02f,
  -1.54255936e-02f, -1.35686174e-01f, -5.20062521e-02f, -2.07637008e-02f, -1.09473884e-01f, 4.41543246e-03f, -8.20291415e-02f, 4.39233407e-02f, -6.03954904e-02f, -6.12024916e-03f,
  -9.38726664e-02f, -6.83903247e-02f, 8.43534339e-03f, -1.05959080e-01f, -4.70174849e-02f, 1.48066534e-02f, -1.53559074e-02f, 1.23741832e-02f, -1.30943716e-01f, -6.18157908e-02f,
  7.76860192e-02f, 1.61758423e-01f, 1.26853377e-01f, -9.64785069e-02f, -6.18532449e-02f, 1.13671914e-01f, -1.89207084e-02f, -8.80836323e-02f, -3.04923952e-02f, -3.43476273e-02f,
  -3.45687456e-02f, -8.21653381e-02f, -6.52861521e-02f, 8.37360099e-02f, 1.42727971e-01f, -2.78192814e-02f, 4.55464516e-03f, 2.15372667e-02f, -2.94586197e-02f, 1.12668432e-01f,
  7.86568299e-02f, 1.21120758e-01f, 7.27102980e-02f, -2.68146265e-02f, 7.92136590e-04f, -1.87920090e-02f, 1.18070036e-01f, 2.05230322e-02f, 6.79765046e-02f, 1.33392841e-01f,
  1.11100525e-02f, -4.51933331e-04f, 1.36527538e-01f, 2.35846452e-02f, -1.31011128e-01f, -5.21291718e-02f, -4.78557423e-02f, -1.08556245e-02f, -7.82037340e-03f, 1.63809918e-02f,
  -8.55137780e-02f, 7.88752958e-02f, -2.53363997e-02f, 3.79506163e-02f, 1.70317050e-02f, 2.65833959e-02f, 4.26032320e-02f, 6.94770832e-03f, 4.15762477e-02f, 2.83021778e-02f,
  -3.58744189e-02f, 2.67943069e-02f, 8.82465914e-02f, 1.04237936e-01f, -5.39577119e-02f, 6.47262111e-02f, 3.58424038e-02f, 4.22114432e-02f, 7.79059157e-02f, 1.15036972e-01f,
  6.08163595e-01f, 6.16466552e-02f, 3.01025987e-01f, -3.23489718e-02f, -2.09806800e-01f, -1.41055912e-01f, -9.39957947e-02f, -2.06531137e-02f, 2.56450046e-02f, 5.14343940e-02f,
  4.25514355e-02f, 2.30496600e-01f, 2.04575881e-01f, 1.86882049e-01f, 2.38859326e-01f, 1.48181811e-01f, 1.08855963e-01f, 3.90366793e-01f, 2.29152709e-01f, 2.17213348e-01f,
  1.22662231e-01f, 5.48194721e-02f, 2.73008972e-01f, 1.11269630e-01f, -4.35698703e-02f, 1.50563583e-01f, -7.79054972e-05f, 8.24846625e-02f, 1.26046941e-01f, 2.15334058e-01f,
  2.33257771e-01f, 1.65270478e-01f, -5.15414029e-02f, -1.07981814e-02f, 6.44435212e-02f, 4.26202565e-02f, -9.02642682e-02f, 3.54097784e-02f, -2.53382884e-02f, -1.29141152e-01f,
  -5.07279150e-02f, 1.18412174e-01f, 5.56061491e-02f, 7.23996460e-02f, -1.07820630e-01f, -6.36545867e-02f, 1.70279238e-02f, 1.52475670e-01f, -3.58193778e-02f, 1.94723848e-02f,
  -5.37594706e-02f, 7.63644977e-03f, -1.35387119e-03f, -3.16587947e-02f, 4.12582457e-02f, -4.61925939e-02f, 2.68904176e-02f, 1.16986610e-01f, 3.82044800e-02f, 1.30390853e-01f,
  9.05987844e-02f, 1.31918564e-01f, 1.95985883e-01f, 2.06294671e-01f, 1.77388921e-01f, 6.96470812e-02f, -1.09003792e-02f, 9.05084386e-02f, 2.32133381e-02f, 1.14951305e-01f,
  1.40882835e-01f, 6.53527677e-02f, 2.52287574e-02f, 1.24081068e-01f, -1.74401924e-02f, 1.63792502e-02f, 2.82690991e-02f, 8.12593997e-02f, -2.58559473e-02f, -6.85546994e-02f,
  1.24676995e-01f, -8.19234177e-03f, 7.31742084e-02f, 1.13218911e-01f, -4.04184684e-03f, 7.25829154e-02f, -2.26869583e-02f, 6.12124503e-02f, -3.97411101e-02f, 1.06858552e-01f,
  -3.43488455e-01f, 8.80429521e-02f, 9.19493064e-02f, -3.24165598e-02f, 1.86780337e-02f, -1.45815471e-02f, 1.06367224e-04f, -7.43039995e-02f, -1.70384899e-01f, -2.28253808e-02f,
  -9.81386825e-02f, 1.76443364e-02f, -4.74522933e-02f, 1.47583401e-02f, -4.97273803e-02f, -1.65352136e-01f, -2.39086710e-03f, -6.53271079e-02f, -7.89897237e-03f, -1.57552138e-01f,
  -4.51773219e-02f, -1.03661783e-01f, -1.33200452e-01f, -1.16426356e-01f, -1.66096345e-01f, -1.43565252e-01f, -1.71231315e-01f, -1.20859660e-01f, -3.35889161e-02f, -8.20687711e-02f,
  -4.24338818e-01f, -1.89501032e-01f, 8.08872059e-02f, 2.31316939e-01f, 2.73096710e-01f, 8.02002698e-02f, -8.12055543e-03f, 2.88018864e-03f, 5.48976175e-02f, 3.50852609e-02f,
  2.09451281e-02f, 2.83912718e-01f, 1.34827897e-01f, 2.53289074e-01f, 7.62545839e-02f, 1.18158132e-01f, 2.06915587e-01f, 8.22337344e-02f, 2.23539472e-01f, 1.64725244e-01f,
  1.32393584e-01f, -3.48408036e-02f, -2.96495352e-02f, 1.05038814e-01f, 9.92826298e-02f, 3.55355561e-01f, 1.14046998e-01f, 7.38301501e-02f, 1.87341511e-01f, 2.29568169e-01f,
  3.53195786e-01f, -1.61968246e-01f, 1.16598615e-02f, -1.59141392e-01f, -1.65934935e-01f, -2.14774996e-01f, -4.79945540e-02f, -1.06988244e-01f, -1.78553522e-01f, 5.26910573e-02f,
  -3.87905538e-02f, -4.34825681e-02f, -1.00592934e-01f, -3.80923450e-02f, 3.47613953e-02f, -8.17474425e-02f, -1.35262981e-01f, 1.82937235e-02f, 1.17234113e-02f, -6.03044499e-03f,
  -4.35192920e-02f, 7.49628022e-02f, -2.60309651e-02f, -2.42028423e-02f, -6.76077383e-04f, 5.38312644e-02f, -9.92471054e-02f, -1.61020868e-02f, -4.22573201e-02f, 8.28594863e-02f,
  2.85661191e-01f, 9.30864885e-02f, -1.52017903e-02f, 5.37575483e-02f, 4.18590456e-02f, 5.06995097e-02f, 7.45235756e-02f, 1.08824857e-01f, 5.40384613e-02f, -4.28983942e-03f,
  2.06880160e-02f, 1.09771371e-01f, 8.13249797e-02f, -4.55188602e-02f, -3.64398882e-02f, -2.51276437e-02f, -8.30022842e-02f, -1.09924451e-02f, -1.44789591e-01f, -1.40007570e-01f,
  -1.13281071e-01f, 1.93595402e-02f, -1.83324784e-01f, -2.40195151e-02f, 1.35327997e-02f, -3.45925763e-02f, 1.92371458e-02f, 2.93964297e-02f, -1.11367688e-01f, -1.82831485e-03f,
  3.02434474e-01f, 5.18225394e-02f, 1.60933450e-01f, -5.47786355e-02f, -1.41256765e-01f, -1.01858556e-01f, 1.03767075e-01f, -7.80041143e-02f, -1.26959652e-01f, 2.55614184e-02f,
  -1.12419873e-01f, -7.55785108e-02f, -6.64949194e-02f, 3.41053307e-02f, 3.44441570e-02f, -5.76577894e-02f, -5.42196780e-02f, 1.05762206e-01f, -4.42660414e-03f, 2.42786054e-02f,
  -8.02102834e-02f, 1.22083329e-01f, 1.89319268e-01f, 1.41958579e-01f, 1.38797686e-01f, 2.14929670e-01f, 8.40503126e-02f, -8.81383102e-03f, 8.23175758e-02f, -2.14349460e-02f,
  -6.26555607e-02f, -1.71966046e-01f, -1.99293345e-01f, -2.38641053e-01f, -4.07039315e-01f, -3.50919008e-01f, -4.32695985e-01f, -1.23275131e-01f, -2.62234390e-01f, -4.44476664e-01f,
  -3.09647107e-03f, 4.93552685e-01f, 3.07718247e-01f, 3.05988520e-01f, 3.34577292e-01f, -2.33587191e-01f, -3.44708115e-01f, 1.09981962e-01f, 3.90530288e-01f, 7.19489604e-02f,
  -8.89595002e-02f, -1.08069412e-01f, 8.67284369e-03f, -3.12957391e-02f, -1.96216017e-01f, 7.85260722e-02f, -2.96165556e-01f, -6.26990125e-02f, -1.26350135e-01f, -3.69774818e-01f,
  3.05756629e-01f, -2.48023584e-01f, -9.48183760e-02f, 3.72007452e-02f, 1.03504181e-01f, -1.17093287e-01f, 4.06280681e-02f, -1.34663284e-01f, -9.31504294e-02f, -1.65305734e-01f,
  -3.75705473e-02f, 3.49434763e-02f, 2.04537585e-01f, 7.51457959e-02f, -4.12032381e-02f, 3.07197347e-02f, -8.10858980e-02f, -4.37118709e-02f, -7.33587146e-02f, -9.49587021e-03f,
  -1.11110331e-02f, -1.06655434e-01f, 1.68620974e-01f, -2.59072836e-02f, -1.17874136e-02f, 1.24687217e-01f, -6.71475977e-02f, 1.49144671e-05f, 9.04034451e-02f, -2.24787652e-01f,
  -9.18352157e-02f, 7.92145506e-02f, -5.10743354e-03f, -2.19187997e-02f, 1.02423439e-02f, 2.44947877e-02f, 4.72631305e-02f, 7.67827407e-02f, 6.27966151e-02f, 3.72343510e-02f,
  -8.27204138e-02f, -1.13493420e-01f, 3.36918347e-02f, 1.75157674e-02f, 1.49538731e-02f, 3.49491313e-02f, 1.50841353e-02f, 8.00084621e-02f, 7.70671992e-03f, -1.12713471e-01f,
  -4.68802638e-02f, -1.17213152e-01f, -4.10548039e-02f, 4.11727279e-02f, -1.14209190e-01f, -6.79620430e-02f, -3.73331979e-02f, 9.38438550e-02f, -1.22014642e-01f, -6.85632601e-02f,
  4.69663411e-01f, -1.31607935e-01f, 2.30193026e-02f, 1.25783950e-01f, -1.50517663e-02f, -6.83061481e-02f, 4.44672219e-02f, -9.08494294e-02f, -1.40936468e-02f, 1.80654712e-02f,
  -1.10170998e-01f, 2.15420537e-02f, 6.08122200e-02f, -1.21507883e-01f, -7.38535672e-02f, 6.73315078e-02f, -1.38596877e-01f, 2.34289244e-02f, -9.93529409e-02f, -1.15079634e-01f,
  -7.50733614e-02f, -5.77445105e-02f, 2.54575580e-01f, 1.60985216e-01f, 1.86216868e-02f, 1.45066634e-01f, 1.13742702e-01f, 1.01297006e-01f, 1.53127447e-01f, 1.55743100e-02f,
  -6.48915112e-01f, -3.63257915e-01f, -1.59431264e-01f, -3.63581330e-01f, -9.33763087e-02f, 6.18200842e-03f, -4.94371057e-02f, 5.67913428e-02f, -9.43982229e-02f, -2.20691934e-01f,
  -1.83017910e-01f, -1.31241634e-01f, -2.04882726e-01f, -2.64719483e-02f, 2.46911347e-02f, -1.22081041e-01f, -2.19799548e-01f, -5.31722270e-02f, 1.58174247e-01f, 1.09602913e-01f,
  -9.89236310e-02f, -1.66316256e-01f, -2.36775324e-01f, -1.27323598e-01f, -2.63820946e-01f, -1.33825839e-01f, -2.38874495e-01f, -1.72565967e-01f, 6.76045641e-02f, -3.28365028e-01f,
  -1.41697392e-01f, -9.80489105e-02f, 8.90159681e-02f, -5.95723204e-02f, -1.14428595e-01f, -4.96075563e-02f, -1.14267044e-01f, -1.63444310e-01f, 5.03254645e-02f, 3.26286480e-02f,
  -3.78053896e-02f, 1.20932251e-01f, -1.15465537e-01f, -3.62496786e-02f, -6.58031851e-02f, 2.61583365e-02f, 7.35962316e-02f, -1.03911310e-01f, -1.78402215e-02f, 1.42022803e-01f,
  6.46059355e-03f, -8.07414725e-02f, -9.86686498e-02f, 1.13042518e-01f, 8.25098231e-02f, -8.39888304e-03f, 1.07725225e-02f, 2.06780463e-01f, 2.39651889e-01f, -1.97051451e-01f,
  6.27090558e-02f, 5.74199483e-03f, -1.93175033e-03f, -3.93409990e-02f, 6.46085367e-02f, -8.89368802e-02f, -3.75574343e-02f, -8.55062902e-02f, -8.14082846e-02f, -2.01166391e-01f,
  -9.76073667e-02f, 6.13324456e-02f, 3.15078683e-02f, -8.18625614e-02f, -1.54589787e-01f, -1.06552422e-01f, 2.42347065e-02f, -7.43890107e-02f, 3.48193534e-02f, -9.81013775e-02f,
  2.83063948e-02f, -1.42886965e-02f, -7.74011910e-02f, 7.18088746e-02f, -1.78149231e-02f, 1.59825310e-02f, 3.05046067e-02f, 3.20375599e-02f, 1.12095974e-01f, 5.68123907e-02f,
  -3.38546723e-01f, 9.39125866e-02f, -2.81204432e-01f, 8.53233226e-03f, 1.62127540e-02f, 5.10199293e-02f, -2.96912901e-02f, 1.69627182e-02f, 5.31084649e-02f, 7.68248960e-02f,
  2.41117597e-01f, -5.22053288e-03f, -3.19768898e-02f, -1.11638624e-02f, -1.29826352e-01f, 7.09747374e-02f, -1.82478689e-02f, -1.15968294e-01f, 1.39856711e-01f, 1.03322774e-01f,
  1.35423809e-01f, 7.81871080e-02f, 2.27622725e-02f, 1.78486097e-03f, 1.22983351e-01f, 3.72099876e-02f, 4.98732813e-02f, 1.19835883e-01f, 1.20518461e-01f, -7.94529840e-02f,
  -2.63986468e-01f, 1.78237736e-01f, 2.12133792e-03f, -2.25607194e-02f, 1.45839632e-01f, 1.25367045e-01f, 2.12732106e-01f, 1.69412836e-01f, 1.13588512e-01f, 1.41920105e-01f,
  1.41295984e-01f, 8.30654949e-02f, 3.08148526e-02f, 1.04697887e-02f, 1.41343877e-01f, 5.23292972e-03f, 1.09306753e-01f, -4.03575925e-03f, -1.05117977e-01f, 3.57396640e-02f,
  5.13694324e-02f, -1.41865462e-01f, -1.76043570e-01f, -1.36334866e-01f, 3.61886481e-03f, -3.40584926e-02f, 4.14267816e-02f, -3.02844271e-02f, 3.13335434e-02f, -2.42626276e-02f,
  1.83247700e-01f, 2.46573329e-01f, 4.58437391e-02f, -8.07555839e-02f, -1.63306743e-01f, -7.82784745e-02f, -4.86939177e-02f, -1.21971546e-02f, -9.99383852e-02f, -9.52883959e-02f,
  4.25572582e-02f, -5.13583235e-02f, 1.33721799e-01f, 7.02099269e-03f, 5.28326072e-02f, -3.20801735e-02f, -5.41981682e-02f, 1.06793374e-01f, 1.08889647e-01f, 1.53623223e-01f,
  1.42111912e-01f, 1.31457061e-01f, 1.62311912e-01f, 3.39880995e-02f, 6.30489811e-02f, -2.26647165e-02f, 6.85411543e-02f, -7.65373036e-02f, 3.31972837e-02f, -1.92059148e-02f,
  3.44310962e-02f, -1.51565850e-01f, 3.13965417e-02f, 3.88840623e-02f, 1.58020873e-02f, 7.42857018e-03f, 1.00483326e-02f, -2.15035141e-03f, -2.81293062e-03f, 2.93494482e-02f,
  1.42626911e-01f, 1.49010882e-01f, 9.37475786e-02f, 1.52553804e-03f, 1.00750998e-01f, 1.23162940e-01f, 2.21109185e-02f, 6.08069338e-02f, 1.65967897e-01f, 9.37517285e-02f,
  1.99987516e-01f, 1.13655210e-01f, 6.08464107e-02f, 1.19869098e-01f, 6.40808493e-02f, 2.92392336e-02f, 2.32954267e-02f, 7.07612513e-03f, -2.98119918e-03f, 4.01601195e-04f,
  1.77730143e-01f, 4.49112773e-01f, 8.54526088e-02f, 7.24511817e-02f, -7.34543875e-02f, -8.13607499e-02f, 7.07680508e-02f, -4.72688079e-02f, 2.26269220e-03f, 7.32562505e-03f,
  -2.47418657e-02f, -5.55232503e-02f, 6.57688826e-02f, 2.74406169e-02f, -1.46247968e-01f, -3.37404571e-02f, -1.04948275e-01f, 7.97482580e-02f, 1.54500887e-01f, 7.31651559e-02f,
  2.68704612e-02f, 1.39694661e-02f, 2.81895362e-02f, 9.34293643e-02f, 1.20635889e-01f, -3.10666990e-02f, -9.06656012e-02f, 2.03449838e-02f, 7.40339682e-02f, -7.59924427e-02f,
  -6.57766104e-01f, 2.17202939e-02f, -1.67522162e-01f, -1.39462888e-01f, -2.49199048e-01f, -1.61513865e-01f, 4.99820802e-03f, -6.61747232e-02f, -1.27837822e-01f, -3.42507362e-02f,
  8.52705166e-02f, 5.52824177e-02f, -5.58343995e-03f, 4.14172411e-02f, -9.07759240e-04f, -6.37176409e-02f, -1.24290496e-01f, -1.24911383e-01f, -2.20642835e-01f, -5.50428145e-02f,
  -1.01324089e-01f, -2.33227655e-01f, -2.91222394e-01f, -1.59156427e-01f, -1.30852440e-03f, -1.59685109e-02f, -9.97110754e-02f, -2.85729747e-02f, -8.37660059e-02f, -1.52110711e-01f,
  3.80506426e-01f, -6.71159998e-02f, 4.05507237e-02f, -1.60522927e-02f, 8.79573822e-02f, 2.49991231e-02f, -1.16589665e-02f, 8.45668018e-02f, 1.46302536e-01f, 1.58020243e-01f,
  3.98307331e-02f, 8.26948509e-03f, -6.64996803e-02f, 7.95924515e-02f, 2.08256785e-02f, 1.74161121e-02f, 2.91014798e-02f, 1.17499232e-01f, 3.63392606e-02f, 2.19798252e-01f,
  -2.62860907e-03f, -2.11730078e-02f, 2.45716851e-02f, 1.01000242e-01f, 4.84586433e-02f, -5.48561923e-02f, 3.89415771e-02f, 1.38994157e-01f, 1.31854147e-01f, 1.17700018e-01f,
  -1.41699925e-01f, 2.38736570e-02f, 4.60053310e-02f, -2.85115167e-02f, -9.90584493e-03f, 1.23557569e-02f, 3.38843204e-02f, 6.19250201e-02f, 5.45287877e-02f, -5.01049235e-02f,
  1.78381532e-01f, -8.54635835e-02f, -7.06544966e-02f, -6.47898763e-02f, -1.02734186e-01f, -1.07222408e-01f, -2.66598891e-02f, 1.25995800e-01f, 4.01054788e-03f, -5.84420096e-03f,
  4.09171656e-02f, 9.02694277e-03f, 9.82246473e-02f, 7.33451322e-02f, 8.88194963e-02f, 1.12672858e-01f, -4.30051535e-02f, -2.78379433e-02f, -1.09944619e-01f, -8.27162713e-02f,
  1.97949082e-01f, -3.65787208e-01f, -6.48005679e-02f, -3.83710712e-02f, -1.19505301e-01f, 5.13757626e-03f, -1.27248570e-01f, -5.38120829e-02f, 8.32449719e-02f, 1.36738703e-01f,
  6.91485479e-02f, -6.09889720e-03f, 3.83774936e-02f, 9.52335149e-02f, -2.77002286e-02f, -6.17221789e-03f, -1.76386591e-02f, 8.64638539e-04f, 3.07022035e-03f, 1.86736733e-01f,
  7.60661066e-02f, -2.76403725e-02f, 4.16324958e-02f, 1.21460423e-01f, -4.89657186e-02f, 9.38861351e-03f, 7.15668360e-03f, 3.29134092e-02f, 7.52669796e-02f, 2.72304062e-02f,
  -6.41928256e-01f, -3.73700947e-01f, 1.31119549e-01f, 1.51908085e-01f, 3.69662702e-01f, 2.94359326e-01f, 1.02165028e-01f, 9.88901034e-02f, 7.57705048e-02f, -3.36318687e-02f,
  -3.33771884e-01f, -1.53039008e-01f, -1.99544072e-01f, -1.09861061e-01f, -2.50817044e-04f, 2.96994388e-01f, 2.57880270e-01f, 9.81879160e-02f, 2.06633002e-01f, 8.10214058e-02f,
  8.54408592e-02f, 9.74349454e-02f, -6.38372377e-02f, 5.85192703e-02f, 1.14695821e-02f, 2.81922668e-02f, 1.33937046e-01f, 9.48454142e-02f, 4.67213430e-02f, 1.66832209e-02f,
  1.53534994e-01f, -2.61869401e-01f, 4.05082665e-02f, -2.40471840e-01f, -2.52758861e-01f, -1.32150501e-01f, -9.10457075e-02f, -1.55316368e-01f, -2.79726740e-02f, 1.61276255e-02f,
  -3.93563397e-02f, -1.53010175e-01f, 4.60417159e-02f, -9.03233066e-02f, 4.27004788e-03f, -1.13526657e-01f, -5.71056306e-02f, -8.86548832e-02f, 4.70800214e-02f, -2.24678311e-02f,
  -9.20240209e-02f, 8.68513733e-02f, 1.63256116e-02f, -5.13464818e-03f, -1.12707123e-01f, 6.28654212e-02f, -1.45885304e-01f, 3.60040995e-03f, 1.26054930e-02f, -1.75412018e-02f,
  1.01007715e-01f, 4.56626415e-02f, -5.68241067e-02f, 1.00013928e-03f, 1.26614077e-02f, 1.11398526e-01f, 8.00785944e-02f, 1.10199600e-01f, -4.01144251e-02f, 2.34507192e-02f,
  7.13608600e-03f, 8.01711157e-02f, -4.39478457e-02f, -3.34399641e-02f, -1.73795372e-01f, -8.13491568e-02f, 6.71025515e-02f, -7.97790810e-02f, -9.61520746e-02f, -8.87117758e-02f,
  -2.92456942e-03f, 4.82359789e-02f, -9.42717195e-02f, 8.35179836e-02f, -1.10633135e-01f, 3.73388305e-02f, -9.35620070e-02f, -1.52615368e-01f, -1.55730069e-01f, 7.56117469e-03f,
  2.03346580e-01f, -2.95732655e-02f, -2.21768152e-02f, -2.38611344e-02f, 3.43049914e-02f, -2.04631999e-01f, -9.78180319e-02f, 5.34640960e-02f, 8.65987614e-02f, 1.01672612e-01f,
  -4.01398912e-02f, -2.11754665e-02f, -2.86673591e-03f, 2.73248274e-02f, 4.50052582e-02f, 1.41161188e-01f, -1.01863086e-01f, 1.39814541e-01f, 1.76865190e-01f, 7.30254799e-02f,
  -6.72187880e-02f, 1.94959000e-01f, 1.31532758e-01f, 1.31976902e-01f, 4.06250879e-02f, 2.53130227e-01f, 1.14534117e-01f, 1.53083920e-01f, 1.87626183e-01f, 1.35412440e-01f,
  5.01783788e-01f, 5.69844560e-04f, 7.81081244e-02f, 1.13486625e-01f, 6.11806698e-02f, 6.36751428e-02f, -3.58467177e-02f, 5.32876817e-04f, 5.73505424e-02f, 8.88861120e-02f,
  8.99636969e-02f, 2.53524166e-02f, 9.56369638e-02f, 6.47827312e-02f, -8.36083665e-02f, -1.29102945e-01f, -1.57575622e-01f, 1.75130386e-02f, 1.16875440e-01f, 4.68811132e-02f,
  -1.97721235e-02f, -2.40182355e-02f, -2.60042157e-02f, -7.59480894e-02f, -5.58078438e-02f, 3.43523771e-02f, -1.94233835e-01f, -2.09347665e-01f, -9.46777537e-02f, -6.66599125e-02f,
  1.23577110e-01f, 3.13666403e-01f, 1.13883562e-01f, 1.07789531e-01f, 1.21101409e-01f, 4.37823450e-03f, 2.76202746e-02f, -7.02758739e-03f, 3.92190926e-02f, 1.82250738e-02f,
  7.50314910e-03f, 8.34790245e-02f, 2.83512417e-02f, 1.31076500e-02f, 5.86795472e-02f, 1.13496192e-01f, 8.94820541e-02f, -6.81357905e-02f, -2.31281128e-02f, -1.62019357e-02f,
  -9.50906053e-03f, 1.14265271e-01f, 1.04899198e-01f, -1.43059865e-02f, 1.44294780e-02f, 7.12687895e-02f, 1.26616240e-01f, 1.50655964e-02f, 7.18523115e-02f, -1.02366477e-01f,
  -1.90342680e-01f, -1.25054225e-01f, 5.95138110e-02f, -2.28678938e-02f, -1.97917610e-01f, 5.32884300e-02f, 7.66201243e-02f, -1.37718522e-03f, -4.98881340e-02f, -1.91969797e-01f,
  -5.78715429e-02f, -4.29996997e-02f, 5.00241667e-02f, 1.71871996e-03f, 1.51424944e-01f, 1.01881810e-01f, -6.83921650e-02f, 8.10854584e-02f, 7.27454871e-02f, 7.79103534e-03f,
  -3.02940644e-02f, -6.59050494e-02f, 2.30659898e-02f, -5.67297377e-02f, -3.87854725e-02f, -2.84914244e-02f, -8.70361808e-04f, -7.41338953e-02f, -5.98158389e-02f, -4.96509299e-02f,
  9.57296137e-03f, 2.02650711e-01f, 1.38759494e-01f, 5.02696224e-02f, 1.47779644e-01f, 1.28065363e-01f, 2.24511176e-01f, 1.34269744e-01f, 7.05476254e-02f, 1.24288395e-01f,
  6.75697848e-02f, 7.81010166e-02f, -8.39688536e-03f, -1.27174541e-01f, -1.08926192e-01f, 9.28363279e-02f, 4.24509794e-02f, -2.06050128e-02f, 3.48578021e-02f, 7.01908022e-02f,
  -5.13734035e-02f, 9.31094736e-02f, 9.35013667e-02f, 1.16607442e-01f, -9.20823812e-02f, -5.16435085e-03f, -3.49977124e-03f, 5.36523499e-02f, 1.06961749e-01f, -1.37819096e-01f,
  5.80955565e-01f, 5.37863851e-01f, -3.85577641e-02f, 1.71425581e-01f, 6.39792830e-02f, 2.48892568e-02f, 2.89097100e-01f, 3.83020461e-01f, 2.83289582e-01f, 1.67822808e-01f,
  9.34532359e-02f, 1.05328254e-01f, 2.29556486e-01f, 1.47590324e-01f, 2.23424137e-01f, 9.19835940e-02f, 1.72024801e-01f, -3.64202745e-02f, 1.77242439e-02f, 3.54681606e-03f,
  1.48719996e-01f, 3.44395302e-02f, 7.65057281e-02f, 6.68484867e-02f, 2.61255377e-03f, 1.32229656e-01f, 3.95224616e-02f, 6.39709532e-02f, 6.19518757e-02f, 2.02007890e-01f,
  -3.30807626e-01f, 6.25220910e-02f, 1.13560952e-01f, 3.54310707e-03f, -7.43152872e-02f, 1.03790551e-01f, -9.44290832e-02f, 3.27368975e-02f, 9.24094021e-02f, -8.46999362e-02f,
  -7.74194375e-02f, -6.70340210e-02f, -4.39462252e-02f, 8.66436400e-03f, -1.60049781e-01f, -1.27641380e-01f, 1.01481289e-01f, 1.69845879e-01f, 1.79793715e-01f, -1.16052739e-01f,
  -5.60072698e-02f, -1.61971338e-02f, -6.78130165e-02f, 5.50435670e-02f, -2.90218424e-02f, -2.55176332e-02f, -8.94332156e-02f, 3.29845846e-02f, 3.54586132e-02f, 1.67034697e-02f,
  -7.03644753e-02f, 1.48569852e-01f, -3.61403190e-02f, -4.60223183e-02f, -1.98369306e-02f, -5.79299591e-02f, -2.09372994e-02f, 2.22068857e-02f, -3.44042778e-02f, 4.81616743e-02f,
  -5.60406446e-02f, -7.96326697e-02f, 4.54261787e-02f, -3.90989855e-02f, -1.06089227e-01f, 3.20472680e-02f, 1.05749248e-02f, 1.59277488e-02f, -1.97319001e-01f, 1.28230959e-01f,
  -3.60976346e-02f, 9.91549576e-04f, -9.72220525e-02f, -1.58186138e-01f, -5.53274937e-02f, -1.23117872e-01f, -1.36900246e-01f, -1.40585741e-02f, -8.83163884e-02f, -3.32638100e-02f,
  1.03232853e-01f, -2.45359212e-01f, 4.12298366e-02f, 1.88825503e-01f, -9.99213979e-02f, -3.12001724e-02f, -9.51303095e-02f, 4.75432090e-02f, -1.27809774e-02f, -1.38095573e-01f,
  -7.77960792e-02f, -9.79635939e-02f, -2.05160156e-02f, -4.44974527e-02f, -2.09961250e-01f, -1.12461001e-01f, 1.22045595e-02f, 1.99401423e-01f, 7.24901706e-02f, -2.52854954e-02f,
  -9.16670039e-02f, 2.94560175e-02f, 4.09534872e-02f, 6.48538098e-02f, 2.38173921e-02f, -1.48754522e-01f, -9.15598273e-02f, -9.64233205e-02f, -1.98344171e-01f, 2.38723792e-02f,
  -3.59171599e-01f, -2.60847539e-01f, -2.09738553e-01f, -3.94258708e-01f, -3.37363109e-02f, 2.27646939e-02f, -1.52700379e-01f, 1.70647807e-03f, -1.15177922e-01f, -2.06074730e-01f,
  -2.72656530e-02f, 9.17280018e-02f, -5.52593283e-02f, 8.73757750e-02f, 3.07032242e-02f, -2.07720056e-01f, -2.03554958e-01f, 1.80743858e-02f, 3.10258061e-01f, 2.98775762e-01f,
  4.89921272e-02f, 6.31596521e-03f, 6.50282577e-02f, 2.11044662e-02f, -2.87294090e-01f, -2.13337820e-02f, -2.12505445e-01f, -1.08046912e-01f, 5.45841418e-02f, -3.99531692e-01f,
  -2.21067563e-01f, -8.17470253e-02f, 1.40297577e-01f, 6.35385141e-02f, -1.31028846e-01f, 3.46259288e-02f, 4.41872142e-02f, -8.69925693e-02f, -3.92731428e-02f, -1.61230490e-01f,
  -3.83687988e-02f, 1.33819148e-01f, -2.58519836e-02f, -6.56271651e-02f, -8.73486027e-02f, 2.27366406e-02f, 4.58160453e-02f, 4.44789641e-02f, 5.08512706e-02f, 4.86187171e-03f,
  -3.76335084e-02f, 1.16053992e-03f, -8.35733265e-02f, -6.96007162e-02f, 1.03621453e-01f, 5.78274354e-02f, 1.27443090e-01f, 1.31104663e-01f, 9.97245833e-02f, -1.39982551e-01f,
  9.10413563e-02f, -8.68781134e-02f, 7.05218762e-02f, -1.75180603e-02f, 5.23731299e-02f, -2.08712351e-02f, 2.45610159e-03f, -1.01010814e-01f, 8.37115347e-02f, 1.68955717e-02f,
  3.74725126e-02f, -3.76521647e-02f, 4.95171994e-02f, -9.59498659e-02f, -6.45611510e-02f, -4.64452989e-02f, 1.12075144e-02f, -1.14719644e-02f, -6.23882636e-02f, 4.33986250e-04f,
  1.10428497e-01f, 8.79736990e-03f, -1.63621400e-02f, 8.78800824e-02f, 9.40497033e-03f, -9.62155685e-02f, 1.75305437e-02f, 3.09527982e-02f, -1.83264613e-02f, 1.26439147e-02f,
  -4.49107029e-02f, 1.85947642e-01f, -2.10830286e-01f, 5.01444861e-02f, -4.49488163e-02f, -4.44116965e-02f, -1.09133527e-01f, 9.59830880e-02f, -5.38854860e-02f, 7.33737275e-03f,
  8.98360685e-02f, -1.97546929e-02f, -3.98719870e-02f, 3.79662067e-02f, 7.32839406e-02f, 6.42115101e-02f, -3.50075811e-02f, -2.84007005e-02f, 1.25067174e-01f, -1.57287717e-02f,
  -3.09450626e-02f, -8.66504759e-02f, -1.52135268e-01f, -6.53138757e-02f, -8.46980065e-02f, 1.13896895e-02f, -1.79032572e-02f, -8.03185850e-02f, 4.59709875e-02f, -2.54210949e-01f,
  -3.04159080e-03f, 6.70814514e-02f, 4.65390319e-03f, 6.48383945e-02f, 2.69790500e-01f, -2.62495548e-01f, -4.74686146e-01f, -3.33675027e-01f, 2.02279076e-01f, 9.26658064e-02f,
  1.87525809e-01f, 3.48799914e-01f, 3.74890380e-02f, -1.90506160e-01f, -6.28183961e-01f, -3.95677775e-01f, -2.72483945e-01f, -3.46943885e-01f, -3.08026433e-01f, -2.65915450e-02f,
  9.36355144e-02f, 1.89817101e-02f, -2.18812436e-01f, -1.42120391e-01f, 3.41392726e-01f, 7.22105652e-02f, 4.61310335e-02f, 6.63528889e-02f, -1.39472425e-01f, 6.83694258e-02f,
  8.25858861e-02f, 1.40397474e-01f, 1.48628205e-02f, 1.32018581e-01f, 1.30972385e-01f, -7.27863610e-02f, -5.28854467e-02f, -3.94689851e-02f, 1.44335896e-01f, 5.57278395e-02f,
  2.23898783e-01f, 1.36175737e-01f, 2.10695446e-01f, 3.44789965e-04f, -6.58712983e-02f, -6.32470772e-02f, -1.32012427e-01f, -2.19364226e-01f, -2.62393355e-01f, -1.36563316e-01f,
  1.45885590e-02f, 7.08308369e-02f, -2.32401028e-01f, -2.47000530e-01f, -2.43533298e-01f, -2.86754267e-03f, -8.60055387e-02f, 3.03577092e-02f, -2.82173574e-01f, -2.19538808e-01f,
  -3.45563050e-04f, 1.08990939e-02f, -3.28893866e-03f, 2.28850488e-02f, 1.09759839e-02f, 1.18608288e-01f, 1.08551033e-01f, -4.09571119e-02f, 2.85235867e-02f, 9.47214663e-03f,
  -5.42766936e-02f, 2.08589453e-02f, 7.50039369e-02f, -2.64247786e-02f, 2.00663023e-02f, 2.14516893e-02f, -2.15354376e-02f, -2.01315850e-01f, -1.88560247e-01f, 1.19666509e-01f,
  3.23272757e-02f, 1.14817038e-01f, 1.28960863e-01f, -8.78922939e-02f, 4.17205729e-02f, -9.22478884e-02f, 1.04657300e-01f, -1.56106018e-02f, 2.64364686e-02f, 6.66044280e-02f,
  -9.24343318e-02f, -7.50674456e-02f, 2.26702932e-02f, -1.36794850e-01f, -8.23165104e-02f, -1.33341411e-02f, 2.18101203e-01f, -5.87087981e-02f, 1.40869483e-01f, -7.76162669e-02f,
  6.86126500e-02f, -3.91122652e-03f, 7.58111700e-02f, 9.49866623e-02f, -4.03161161e-02f, 3.18760946e-02f, -2.63833046e-01f, -6.32185414e-02f, -1.65649772e-01f, 5.66265499e-03f,
  -2.47407898e-01f, -2.65724570e-01f, -2.69389033e-01f, -2.75213003e-01f, 7.24801272e-02f, -3.75215560e-02f, -2.52103865e-01f, -4.99754325e-02f, -4.15537477e-01f, -5.03337145e-01f,
  -8.76691192e-02f, 5.79308718e-02f, -1.15488112e-01f, 1.93381235e-01f, 2.74694502e-01f, 1.66840270e-01f, 2.45751217e-01f, 1.62162572e-01f, 2.28061035e-01f, 2.07978591e-01f,
  1.93558946e-01f, 1.46941975e-01f, 3.22944432e-01f, 2.54914999e-01f, 8.21781829e-02f, 2.09480554e-01f, 8.53690878e-02f, 1.26288444e-01f, 1.20165244e-01f, 8.41491297e-02f,
  2.40905941e-01f, 4.38104235e-02f, -1.16320796e-01f, 8.70862976e-02f, 8.17278028e-02f, 2.18272507e-01f, 6.22571670e-02f, -3.16191725e-02f, 1.45017743e-01f, 3.47049125e-02f,
  -2.01933011e-01f, -6.40749559e-02f, 4.66413274e-02f, -3.60853330e-04f, -2.03784302e-01f, -1.44202247e-01f, 4.27993312e-02f, -7.51627535e-02f, -4.91408966e-02f, -3.56018310e-03f,
  1.82267707e-02f, -1.11919850e-01f, -7.08155409e-02f, -1.34599850e-01f, -1.20983653e-01f, -7.48019740e-02f, -9.42792892e-02f, -1.05124502e-03f, 6.01664893e-02f, 9.47032869e-02f,
  9.60844532e-02f, 3.60714719e-02f, -8.77179056e-02f, 6.40895814e-02f, 5.58809154e-02f, -1.47680072e-02f, 7.27361441e-02f, -5.00009954e-02f, -2.42015924e-02f, -9.63886380e-02f,
  2.31983200e-01f, 2.42732167e-02f, -6.75381380e-05f, 8.22725892e-02f, -2.51256563e-02f, 9.89295244e-02f, 9.01808366e-02f, 8.68852660e-02f, 1.81545869e-01f, -1.08681349e-02f,
  -1.09357506e-01f, -4.33680005e-02f, 9.47651193e-02f, 5.07425331e-02f, 3.29034105e-02f, 7.61865973e-02f, -3.30265872e-02f, -4.53145802e-02f, -9.09713283e-02f, -5.05078211e-02f,
  -3.73142473e-02f, -4.26452160e-02f, -5.77348657e-02f, -2.36929711e-02f, -7.73466229e-02f, 8.52377340e-02f, 4.93735671e-02f, -5.76917902e-02f, -8.68697912e-02f, -1.48808667e-02f,
  1.51645858e-02f, 2.44749844e-01f, 1.71324462e-01f, 6.31157830e-02f, -8.41814503e-02f, -1.87810495e-01f, 1.51182562e-01f, -7.16644898e-02f, 5.45088341e-03f, -1.00850854e-02f,
  -8.06552544e-03f, -9.50789154e-02f, -1.98619515e-02f, -1.05069093e-01f, -1.05166242e-01f, -4.77368347e-02f, 5.28127067e-02f, 3.07449400e-02f, 1.60456255e-01f, -3.69431190e-02f,
  1.21014960e-01f, 7.17287660e-02f, 5.86765073e-02f, 1.47643417e-01f, 1.30463988e-01f, 4.36944254e-02f, -1.08367831e-01f, 8.34244955e-03f, -4.12954912e-02f, -8.16095248e-02f,
  5.86986303e-01f, 1.12089984e-01f, 2.58883178e-01f, -1.18670240e-03f, -4.38385397e-01f, -2.91682839e-01f, -2.68663406e-01f, -2.11533369e-03f, 8.67490619e-02f, -3.26691270e-02f,
  -1.06346779e-01f, -9.42708552e-02f, 6.94868937e-02f, 1.20342776e-01f, 2.88738817e-01f, 8.70496631e-02f, 4.82545123e-02f, 2.95741856e-01f, 1.61863804e-01f, -5.02136275e-02f,
  4.11626473e-02f, 1.66882202e-01f, 2.39606932e-01f, 2.27362648e-01f, -4.07212600e-02f, -5.67509793e-02f, 2.23580990e-02f, -1.43179847e-02f, -5.65030612e-02f, 2.58565634e-01f,
  -9.35871378e-02f, 9.60984752e-02f, -5.06244004e-02f, 2.09031235e-02f, 2.09206827e-02f, 1.10124268e-01f, 2.55231299e-02f, -2.55169198e-02f, 1.16650492e-03f, -6.59139976e-02f,
  5.50715029e-02f, -7.75042474e-02f, -1.21509627e-01f, -1.05765469e-01f, -1.21326141e-01f, -1.39072716e-01f, -5.95379621e-03f, 8.17995816e-02f, 1.11786555e-02f, -1.19531900e-02f,
  -1.20923318e-01f, -2.03959763e-01f, -1.73117429e-01f, -2.50089109e-01f, -2.12643674e-04f, -8.06926861e-02f, -1.86562687e-01f, 4.58770879e-02f, 1.49842091e-02f, -2.61102095e-02f,
  -9.49140415e-02f, -7.96425268e-02f, -7.82037750e-02f, -6.62207156e-02f, -7.37699047e-02f, -2.80746371e-02f, -7.43682012e-02f, -1.07484840e-01f, 4.81528267e-02f, 2.58600339e-02f,
  -1.23539679e-01f, -9.23392922e-02f, -6.11043982e-02f, -5.57581484e-02f, -8.21939185e-02f, -3.32098939e-02f, 2.17848737e-02f, -1.26295000e-01f, -1.39701039e-01f, 1.02477362e-02f,
  -3.03380266e-02f, -2.08501867e-03f, -8.49685296e-02f, -6.32559210e-02f, -1.76509731e-02f, -1.56557590e-01f, -7.68301040e-02f, -1.61164120e-01f, -1.68632194e-01f, 4.21948992e-02f,
  -4.15185660e-01f, -1.47907689e-01f, 2.02272475e-01f, 1.88469872e-01f, 5.79049885e-02f, 9.23749730e-02f, 1.30590215e-01f, 5.12138680e-02f, 3.04328874e-02f, 5.84623627e-02f,
  -3.45650688e-02f, 8.99268687e-02f, -1.08142812e-02f, -2.46875100e-02f, -3.42436619e-02f, 4.36286926e-02f, 8.65473151e-02f, 5.89627698e-02f, 5.09298928e-02f, -3.52834426e-02f,
  3.14084478e-02f, -1.19791262e-01f, -2.05557793e-01f, -1.76673219e-01f, 2.85286456e-02f, -9.94332507e-02f, -1.05004214e-01f, -1.03361132e-02f, -2.85589285e-02f, 2.36825738e-03f,
  4.63120252e-01f, -1.72516406e-01f, 4.72482711e-01f, 8.36298838e-02f, -2.73290247e-01f, -4.94698845e-02f, -1.84032507e-02f, 4.28005829e-02f, -4.03648429e-02f, -1.25868067e-01f,
  -1.91367686e-01f, -2.31729105e-01f, 1.16935726e-02f, 2.37498246e-03f, 1.53709590e-01f, 1.78213567e-01f, 2.85956800e-01f, 4.52282369e-01f, 3.34535897e-01f, -2.84833927e-02f,
  -1.35279328e-01f, 2.65468694e-02f, 2.52933830e-01f, 2.01289520e-01f, 4.04466353e-02f, -3.79609573e-03f, -3.89786996e-02f, -6.81182146e-02f, 1.31543512e-02f, 1.08198658e-01f,
  -7.53595829e-02f, -2.95634083e-02f, -2.71729175e-02f, -2.40413487e-01f, -2.49188300e-02f, -4.40234020e-02f, -3.85152325e-02f, 2.90450491e-02f, -1.94695068e-03f, -3.57558951e-02f,
  -1.56097844e-01f, -3.55505645e-02f, -2.82527097e-02f, 6.96224421e-02f, 6.43309727e-02f, -1.48865748e-02f, 1.83925897e-01f, 6.05683811e-02f, 1.29160345e-01f, -6.00674041e-02f,
  -1.74835950e-01f, -1.16179757e-01f, 7.34123066e-02f, 2.74978988e-02f, 2.23553423e-02f, -3.76887992e-02f, -3.07097808e-02f, -3.66836996e-03f, 5.13615012e-02f, 4.95773368e-02f,
  -1.21802039e-01f, 8.75680298e-02f, 7.13364929e-02f, 2.95802020e-02f, -3.62256393e-02f, 9.37166214e-02f, 4.89482656e-02f, -9.75651219e-02f, 2.59423684e-02f, 9.32142437e-02f,
  3.36295217e-02f, 1.56174842e-02f, -8.66594200e-04f, -7.28013963e-02f, -6.03418518e-03f, -7.49674812e-02f, 1.69507321e-02f, -8.51178691e-02f, -8.47743377e-02f, -2.96591334e-02f,
  3.11038923e-02f, 2.95819640e-02f, 1.29250868e-03f, 1.40906021e-01f, -9.21623111e-02f, -2.61283498e-02f, 1.96189675e-02f, -1.76037923e-01f, -7.49723464e-02f, -3.87564525e-02f,
  -3.13900262e-01f, -9.69667062e-02f, -8.85107592e-02f, -2.41762716e-02f, -3.72042321e-02f, -3.02897282e-02f, -4.90680449e-02f, -2.62233932e-02f, -8.58608559e-02f, -1.25692129e-01f,
  -9.84670594e-03f, 2.88146399e-02f, -5.09729311e-02f, 1.00054055e-01f, 4.89117801e-02f, -1.44751593e-01f, -1.35709047e-01f, -4.20027077e-02f, -6.70908689e-02f, -2.68509472e-03f,
  9.10004899e-02f, -3.67683247e-02f, -6.69087917e-02f, -4.90888469e-02f, -4.17688750e-02f, -1.26396060e-01f, -2.71539390e-02f, -4.63932566e-02f, 1.12052530e-01f, -9.81890783e-02f,
  7.41532087e-01f, -1.05435610e-01f, -6.44325972e-01f, 1.50984218e-02f, -2.82204360e-01f, -1.99558556e-01f, -3.18481535e-01f, 1.75986484e-01f, 1.10376142e-01f, -1.50670588e-01f,
  9.00071934e-02f, 3.97118866e-01f, 2.04700366e-01f, 1.06147602e-01f, 1.96595311e-01f, -3.98360223e-01f, -3.40336740e-01f, -1.72990635e-01f, 1.04770280e-01f, 6.61757439e-02f,
  7.35041276e-02f, 6.95346966e-02f, 1.84995681e-01f, 1.37379602e-01f, -2.09732413e-01f, 6.46222234e-02f, -4.28139836e-01f, -2.33298123e-01f, -1.80606782e-01f, -3.56569171e-01f,
  -3.07094783e-01f, -1.41480351e-02f, -3.08413687e-03f, 2.28912771e-01f, 1.59563869e-02f, 1.64103255e-01f, 5.38984239e-02f, -1.00531980e-01f, 1.34506389e-01f, -5.12775481e-02f,
  2.01381687e-02f, 6.96049333e-02f, 1.64776370e-01f, 4.81359139e-02f, -7.11808875e-02f, 6.71293586e-02f, -1.46812871e-01f, 2.26884577e-02f, -8.84127617e-03f, -1.40471563e-01f,
  1.47421774e-03f, -7.25220814e-02f, 3.88095081e-02f, -5.84201403e-02f, -1.33297876e-01f, 8.85271467e-03f, -1.48890689e-01f, -1.25654683e-01f, -5.14075346e-02f, -2.50793904e-01f,
  -5.57303280e-02f, -8.67221802e-02f, -3.54086123e-02f, -3.75772901e-02f, 1.73524972e-02f, 1.88877825e-02f, 9.90851596e-02f, -4.34415154e-02f, 5.11252554e-04f, -4.98092547e-03f,
  -1.19199883e-02f, -2.69087255e-02f, 3.92093174e-02f, -1.33393914e-01f, 3.53971566e-03f, -4.78805006e-02f, -7.23073259e-02f, -7.65574798e-02f, 1.83737632e-02f, 1.57977641e-01f,
  1.39806435e-01f, -3.79713438e-02f, -1.29476106e-02f, 8.03596899e-02f, -3.00119929e-02f, 1.01389620e-03f, -2.16671526e-02f, 5.12262434e-02f, 6.70798570e-02f, 9.73359346e-02f,
  1.69841975e-01f, 9.41917598e-02f, -6.21898733e-02f, 1.89154618e-03f, -1.18460938e-01f, -4.01226282e-02f, -1.54604524e-01f, -3.15850973e-02f, 2.12379128e-01f, 5.62766287e-03f,
  9.38139018e-03f, -2.48873513e-03f, -1.24108635e-01f, -9.97459367e-02f, 1.90811660e-02f, 3.55510530e-03f, 4.00588214e-02f, 8.68645236e-02f, 8.37997347e-02f, -8.40328932e-02f,
  -2.15869769e-02f, 9.85989496e-02f, 1.30087927e-01f, -2.50464920e-02f, 2.25278009e-02f, 1.24947205e-01f, -1.41387712e-02f, 1.97396558e-02f, -1.03891771e-02f, 3.29329073e-02f,
  -2.81268924e-01f, -2.97812343e-01f, -2.24081911e-02f, -7.54055530e-02f, 5.15277907e-02f, -5.28900772e-02f, -4.64506060e-01f, -2.57498007e-02f, 8.51051807e-02f, -3.78808469e-01f,
  -1.65610045e-01f, 1.25199467e-01f, -9.83671993e-02f, 1.12663880e-01f, -4.82821353e-02f, -4.30456370e-01f, -1.79077804e-01f, -2.72629913e-02f, 3.74151975e-01f, 2.04193980e-01f,
  8.25107470e-02f, -5.32638542e-02f, 1.97893560e-01f, 1.54874414e-01f, -1.85091838e-01f, -9.19157863e-02f, -2.28573427e-01f, -4.92814556e-02f, -5.95657267e-02f, -3.62325162e-01f,
  -3.78438115e-01f, -5.06314300e-02f, 1.60849750e-01f, -1.21016465e-02f, 9.87941623e-02f, 1.57603081e-02f, 1.51833026e-02f, 7.69362971e-02f, 1.19984662e-02f, -1.13681428e-01f,
  -5.41275404e-02f, 5.87467216e-02f, -9.06343199e-03f, 8.89880359e-02f, -6.15519879e-04f, -1.90205481e-02f, 1.17841467e-01f, 1.83331087e-01f, -6.86971992e-02f, -1.07972257e-01f,
  -2.24276975e-01f, -1.96137920e-01f, -9.19640157e-03f, -1.27165895e-02f, -2.52602878e-03f, 2.11999223e-01f, 4.58423980e-02f, 7.33942315e-02f, -5.78337407e-04f, -3.88463736e-01f,
  -6.95904419e-02f, 6.63458705e-02f, 6.20100275e-02f, 4.88195233e-02f, 1.82411410e-02f, -6.75147325e-02f, -6.37592822e-02f, -3.35749872e-02f, -5.83618367e-03f, -5.21227308e-02f,
  5.14153065e-03f, 4.70840409e-02f, 6.48890063e-02f, -2.91676987e-02f, -8.96205828e-02f, 3.27108428e-02f, 4.73224651e-03f, -6.31235093e-02f, -6.79002106e-02f, -9.56260134e-03f,
  -4.50937496e-03f, 3.83504257e-02f, -3.47514339e-02f, 3.72728631e-02f, -1.99386001e-01f, 4.34330441e-02f, 1.34595521e-02f, 1.31820694e-01f, 4.33218703e-02f, -4.69075814e-02f,
  3.77753153e-02f, 2.56859571e-01f, -2.42356002e-01f, 5.36365695e-02f, -4.89284396e-02f, 6.05859570e-02f, -3.36497873e-02f, 1.47629008e-01f, 9.97581258e-02f, -7.16863200e-02f,
  1.35727869e-02f, -1.89874366e-01f, -1.60602003e-01f, 1.14860348e-01f, -1.10564204e-02f, -8.10524151e-02f, -1.83054850e-01f, -7.49161690e-02f, 7.50580132e-02f, 5.81658110e-02f,
  -2.37416290e-02f, -1.73828751e-01f, -1.33737519e-01f, -1.82656839e-01f, -1.25860721e-01f, -9.12216585e-03f, -1.72123924e-01f, 1.01666749e-02f, -6.27316609e-02f, -4.32052940e-01f,
  2.83729017e-01f, -3.75486374e-01f, -4.33362365e-01f, 3.08855772e-02f, 6.92419708e-02f, 2.07805082e-01f, 2.18747675e-01f, 2.86656946e-01f, 2.13961750e-01f, 2.93602496e-02f,
  -8.25463459e-02f, 7.04898164e-02f, -1.95540741e-01f, -9.53991786e-02f, -1.40500473e-04f, -1.27412856e-01f, -1.76506966e-01f, -1.15187116e-01f, 2.20998585e-01f, 4.33629632e-01f,
  1.68344676e-01f, 1.30558580e-01f, 1.81057870e-01f, 4.11459655e-02f, -6.48656860e-02f, 5.21385483e-02f, -2.76503921e-01f, -1.61254972e-01f, -1.89919204e-01f, -4.43983853e-01f,
  -3.72327089e-01f, -2.16361597e-01f, 1.11301139e-01f, 1.94066186e-02f, -7.90425017e-02f, 1.09226912e-01f, 1.51392847e-01f, 6.77086487e-02f, -1.70217678e-02f, -2.35385913e-02f,
  -1.33532465e-01f, 2.67754234e-02f, 7.58029567e-03f, -4.33550365e-02f, 7.22393990e-02f, 1.08980305e-01f, -6.65833056e-02f, -1.15892880e-01f, -2.48575404e-01f, -6.29995763e-02f,
  -1.63488239e-01f, -6.78788275e-02f, -1.69413671e-01f, 5.19206142e-03f, -7.73708150e-02f, -1.96348563e-01f, -1.96288228e-01f, -1.29986018e-01f, -5.95698804e-02f, -1.31619096e-01f,
  4.00398485e-02f, -2.15489045e-02f, 1.29810320e-02f, 1.16786063e-02f, 4.69056256e-02f, -4.73234653e-02f, -8.07704106e-02f, -1.11877598e-01f, -2.55538691e-02f, 1.05357163e-01f,
  -2.26757377e-02f, 1.38829397e-02f, -4.52530570e-02f, 3.78300399e-02f, -8.47021341e-02f, -9.12737846e-03f, -2.67458474e-03f, -4.82480600e-02f, -7.97374081e-03f, -4.23284806e-02f,
  2.71969717e-02f, -5.90996146e-02f, 4.21780422e-02f, 6.58623725e-02f, -2.65041124e-02f, -4.97874171e-02f, 1.13340691e-01f, 6.74048811e-02f, 6.88807219e-02f, 1.80088952e-01f,
  3.96853268e-01f, -3.44960727e-02f, 6.40692562e-02f, -1.10228911e-01f, -1.51532069e-01f, -3.32433246e-02f, -6.84394464e-02f, -7.35108778e-02f, -1.07135326e-01f, 2.67171878e-02f,
  -3.69022079e-02f, -4.16952781e-02f, -6.47920594e-02f, 9.35542285e-02f, 1.19071394e-01f, 5.03440686e-02f, -1.89580545e-01f, -2.18503281e-01f, -4.43984335e-03f, 3.99684757e-02f,
  -1.36727188e-02f, 1.57085732e-01f, 1.35328308e-01f, -3.24045718e-02f, 1.85290221e-02f, 1.72713459e-01f, 3.40820290e-02f, 7.15111867e-02f, 9.95695591e-02f, 4.04356301e-01f,
  -2.20205784e-01f, 2.44877487e-01f, 4.19141859e-01f, -2.87833124e-01f, 3.54204953e-01f, 5.06128430e-01f, 7.00110912e-01f, 8.88510346e-02f, -3.53495806e-01f, 2.02889442e-01f,
  2.14325368e-01f, -3.03506970e-01f, -2.50378907e-01f, -2.37384140e-01f, 8.10685828e-02f, 2.32341498e-01f, 2.52019703e-01f, -8.54948163e-02f, -1.01401754e-01f, 2.03136615e-02f,
  -1.03647970e-01f, -1.50536329e-01f, -2.71500528e-01f, -2.26342589e-01f, -2.63964474e-01f, -2.07500979e-01f, 6.42540529e-02f, 9.77517813e-02f, 1.71898961e-01f, -1.86844468e-01f,
  -8.46804380e-02f, 2.13072419e-01f, -5.23585752e-02f, -2.00384811e-01f, 6.73028827e-02f, -7.28541687e-02f, 3.12659680e-03f, -1.55235499e-01f, 3.79751101e-02f, -5.79098910e-02f,
  -1.24911994e-01f, 8.73641483e-03f, -1.11861251e-01f, 6.71989322e-02f, 6.30070940e-02f, 9.81954858e-02f, 1.93745214e-02f, -1.06394604e-01f, -2.15774447e-01f, 2.53851409e-03f,
  -1.34689346e-01f, 7.69215673e-02f, 2.25448817e-01f, 9.17578414e-02f, -8.46740678e-02f, -1.72615364e-01f, 5.39109185e-02f, -5.94003722e-02f, -3.66123170e-02f, -3.23408186e-01f,
  -8.09259862e-02f, 8.17619711e-02f, 1.09448560e-01f, 5.40723614e-02f, -3.54180373e-02f, -6.57630861e-02f, -9.53476727e-02f, 9.42363171e-04f, 8.20048153e-03f, 6.08231947e-02f,
  -1.96887949e-03f, 1.68983862e-02f, 1.12832952e-02f, 7.58493915e-02f, 2.22683375e-04f, -1.71861444e-02f, 4.62854207e-02f, 6.27763395e-04f, -2.81166118e-02f, 1.40647693e-02f,
  -1.02956176e-01f, 2.79976260e-02f, -5.28577566e-02f, -1.35306299e-01f, 1.34560153e-01f, -7.07003102e-02f, -7.13873804e-02f, 8.38010684e-02f, -6.17924184e-02f, 2.09851358e-02f,
  -2.38280296e-01f, 2.60184437e-01f, -2.27432415e-01f, -7.26607488e-03f, 2.06527367e-01f, -4.70591756e-03f, -8.35798099e-04f, 2.08491627e-02f, 7.56986886e-02f, -8.43566954e-02f,
  1.57389984e-01f, -3.46606746e-02f, 4.66094390e-02f, 3.72150503e-02f, 5.80029227e-02f, -4.09667473e-03f, 8.99236351e-02f, 1.31074339e-03f, -6.21428415e-02f, -8.36682133e-03f,
  -1.51386054e-03f, 1.82292372e-01f, -1.55700184e-02f, -6.78341836e-02f, -1.41866133e-01f, -1.92293853e-01f, 1.58351269e-02f, 6.32322207e-02f, 1.52853712e-01f, -7.67287388e-02f,
  -4.62089002e-01f, -1.11920282e-01f, -1.68236300e-01f, -4.01978135e-01f, -8.13971832e-02f, 1.11983187e-01f, -5.70242479e-02f, 9.16203856e-02f, 2.67806631e-02f, -1.24451585e-01f,
  -7.76897892e-02f, -2.15069111e-02f, -1.41437918e-01f, -3.01972106e-02f, -1.32951900e-01f, -2.81498551e-01f, -2.99797773e-01f, -2.44787782e-01f, 8.00691023e-02f, 1.91981539e-01f,
  -4.46605943e-02f, -2.01389223e-01f, -1.29443586e-01f, 4.16146442e-02f, -1.04745001e-01f, -9.52350050e-02f, -2.47910008e-01f, -1.53835401e-01f, 3.76983695e-02f, -2.79106855e-01f,
  -2.56233156e-01f, 3.53341736e-02f, 3.84350419e-02f, 1.30787995e-02f, -1.78167030e-01f, -2.79982071e-02f, 3.40493098e-02f, -9.99005660e-02f, 1.92357879e-02f, -1.25616297e-01f,
  -5.84963039e-02f, 1.57814220e-01f, -2.25076228e-02f, -6.04811087e-02f, -7.32770488e-02f, 1.88276786e-02f, 6.22707680e-02f, 3.43894213e-02f, -1.07177589e-02f, 1.01948045e-01f,
  4.16946523e-02f, 9.71808955e-02f, 7.48054078e-03f, 1.34854287e-01f, 1.76764533e-01f, -1.62664410e-02f, 1.05500847e-01f, 2.00848669e-01f, 1.51788875e-01f, -1.25314191e-01f,
  6.59023523e-02f, -5.07237203e-02f, 2.84691411e-03f, -6.93119736e-03f, -3.93796805e-03f, 9.08963941e-03f, -3.36338989e-02f, 1.50105404e-02f, -2.10596006e-02f, 2.36415006e-02f,
  -1.34427398e-02f, -1.76503174e-02f, -4.75223213e-02f, 2.97415834e-02f, -4.86270450e-02f, 6.23983778e-02f, -7.87602067e-02f, 2.37336587e-02f, 4.81125563e-02f, -6.16926812e-02f,
  1.33287050e-02f, 4.04488780e-02f, 4.02294658e-02f, 3.52969952e-02f, -3.57019417e-02f, -1.30664960e-01f, 7.32029825e-02f, 3.51955891e-02f, -1.02457665e-02f, -4.72301915e-02f,
  -2.30671510e-01f, -4.27532196e-03f, -2.01560557e-01f, 6.62274659e-02f, -6.29585311e-02f, 1.04018025e-01f, -1.20038286e-01f, 4.25332859e-02f, -8.64503160e-02f, -8.22891146e-02f,
  1.13973849e-01f, -8.63570943e-02f, -1.16000719e-01f, 7.35510364e-02f, -5.29914722e-02f, 1.15646543e-02f, -3.13663413e-03f, -9.50407088e-02f, 1.77869231e-01f, 1.37379006e-01f,
  7.08159655e-02f, 8.33709817e-03f, -2.88465172e-02f, -2.42825393e-02f, 1.51002064e-01f, -1.26243204e-01f, -9.49818492e-02f, 7.27010667e-02f, 8.29189122e-02f, -3.08412105e-01f,
  -2.49671768e-02f, 2.35320792e-01f, 1.35951325e-01f, -2.59336606e-02f, 1.13245271e-01f, -9.86559317e-02f, -2.25839183e-01f, -1.79776877e-01f, 3.24646235e-02f, 1.32156443e-03f,
  4.61923406e-02f, -1.82137024e-02f, 1.33765548e-01f, 7.12165982e-02f, -1.28173813e-01f, 4.48023751e-02f, 1.96268424e-01f, 8.58484209e-02f, -2.71284997e-01f, -2.03632981e-01f,
  3.81022878e-02f, 1.47176072e-01f, 2.69037876e-02f, -6.97200671e-02f, 1.71218812e-01f, -3.74691710e-02f, 1.50140956e-01f, 2.19711289e-01f, 9.39659327e-02f, 3.70791316e-01f,
  2.08533369e-02f, -4.82305661e-02f, -2.02411875e-01f, 6.72406182e-02f, 1.52838856e-01f, -9.61520374e-02f, -1.15289934e-01f, 2.09392160e-01f, 1.16128465e-02f, 9.74027365e-02f,
  1.30459771e-01f, 1.54397696e-01f, 1.96120441e-01f, -3.32701579e-02f, -1.08097002e-01f, -1.82792470e-01f, 5.45675717e-02f, 1.00089975e-01f, -6.34940714e-02f, -5.86299552e-03f,
  4.72213253e-02f, 4.11214754e-02f, -5.25397249e-03f, -1.39083131e-03f, 1.45982489e-01f, -1.05574600e-01f, -9.68068615e-02f, 6.30214289e-02f, -1.31354913e-01f, 1.34020105e-01f,
  -1.67460501e-01f, 1.95203312e-02f, 1.55783415e-01f, -1.05910869e-02f, -1.15574822e-01f, -5.57747893e-02f, 5.81609011e-02f, -9.19083729e-02f, -8.07605218e-03f, 2.06319243e-02f,
  -1.53921202e-01f, -1.24741867e-01f, -5.50207756e-02f, -1.09621882e-01f, -2.17000693e-01f, 9.68951359e-02f, -1.24368057e-01f, -4.52752262e-02f, -4.33469191e-02f, -4.97821532e-02f,
  6.24644011e-02f, -4.44527250e-03f, 2.20555086e-02f, -5.14872335e-02f, -7.86390901e-02f, -1.51355192e-01f, -1.14485905e-01f, -5.01060635e-02f, -5.65786287e-02f, -9.28423330e-02f,
  2.55091432e-02f, -1.15249015e-01f, -9.57768038e-02f, -1.21444538e-01f, -4.05506976e-02f, 6.95138723e-02f, -6.82074800e-02f, -9.24689695e-02f, 2.86324862e-02f, -3.28171194e-01f,
  -8.82088989e-02f, -2.80631155e-01f, 1.50753126e-01f, -1.16330031e-02f, -1.65304378e-01f, -5.44178970e-02f, -1.01696558e-01f, -8.33066106e-02f, -8.42499062e-02f, 6.57805353e-02f,
  -1.93469562e-02f, -3.87032419e-01f, -3.72885615e-01f, -2.03181371e-01f, -1.45832360e-01f, -4.75297302e-01f, -3.64899755e-01f, -1.29487380e-01f, -2.90457577e-01f, -3.56291354e-01f,
  -4.53838587e-01f, -1.27275184e-01f, -3.29812497e-01f, -1.24394141e-01f, 3.38809580e-01f, 9.30859223e-02f, -5.83739579e-02f, -3.92450131e-02f, 3.79183851e-02f, -1.38170376e-01f,
  1.52031168e-01f, 1.69146135e-01f, 3.38421911e-02f, 5.96894547e-02f, -7.66859576e-02f, 4.83566374e-02f, 9.39572081e-02f, -1.18991137e-01f, 9.06355754e-02f, 4.22159761e-01f,
  4.27306384e-01f, 1.05559878e-01f, -7.91980997e-02f, 1.39255999e-02f, 1.92380652e-01f, 1.67598203e-01f, -3.88368033e-02f, 9.33132414e-03f, 9.88984779e-02f, 5.63157024e-03f,
  -4.15125877e-01f, -3.47601622e-01f, 1.86529607e-01f, 1.47023901e-01f, 8.47194567e-02f, -1.16519801e-01f, -5.67167439e-02f, -2.13151455e-01f, -1.25386506e-01f, -1.22358643e-01f,
  -1.67297833e-02f, -7.16659278e-02f, 7.64559805e-02f, 8.07905495e-02f, -1.00231133e-02f, -1.30548865e-01f, -1.71152890e-01f, -1.50146469e-01f, -3.15816015e-01f, -7.58521408e-02f,
  3.13752830e-01f, 9.03776437e-02f, -1.92115903e-01f, -4.25022468e-02f, -1.35233954e-01f, -2.21470091e-02f, -1.79508775e-01f, -8.78430158e-02f, -3.33172381e-01f, -3.37156564e-01f,
  -1.53758200e-02f, -2.23805383e-02f, -4.98421416e-02f, -1.21671461e-01f, -1.94562171e-02f, -8.62051360e-03f, -6.08795322e-02f, 3.11557222e-02f, 1.40812442e-01f, -2.60946508e-02f,
  6.12039343e-02f, -1.10773398e-02f, -6.70046583e-02f, -1.15783408e-01f, 4.70524468e-02f, 2.06896216e-02f, 5.34907803e-02f, 3.37457992e-02f, -2.88383216e-02f, -6.44466653e-02f,
  -1.99602265e-02f, -7.28455037e-02f, -9.09190327e-02f, 7.06194784e-04f, 7.77498493e-03f, -2.03415275e-01f, 1.82566466e-03f, -8.73034298e-02f, -1.63741991e-01f, -1.16956115e-01f,
  -1.58104017e-01f, 3.57841738e-02f, -2.25598924e-02f, 7.71958753e-03f, -5.36228493e-02f, 4.64266911e-02f, -9.33781862e-02f, 7.34792948e-02f, -1.38150990e-01f, -4.91145402e-02f,
  -1.10709434e-02f, -1.55365810e-01f, -8.68083686e-02f, 1.11335166e-01f, 1.15702845e-01f, -5.84153719e-02f, 1.29456460e-01f, 1.39001058e-02f, 7.52426386e-02f, 8.94881412e-02f,
  -1.02673501e-01f, -6.70708790e-02f, -1.19171120e-01f, -1.71816379e-01f, 6.90784901e-02f, -1.57884732e-01f, -1.92397773e-01f, -6.29639551e-02f, -2.40816757e-01f, -2.70220280e-01f,
  -1.00057475e-01f, 2.22397551e-01f, -3.82449180e-02f, 3.37887332e-02f, -4.49766777e-02f, -2.28562117e-01f, -1.57399744e-01f, 7.15022907e-02f, 2.25638807e-01f, 7.54592270e-02f,
  -2.69061737e-02f, -2.33683705e-01f, -1.02255186e-02f, -1.73207849e-01f, -4.11205918e-01f, -1.18088551e-01f, -8.66410807e-02f, -3.14114571e-01f, -5.74140191e-01f, -4.53381330e-01f,
  -2.45542109e-01f, -2.57379770e-01f, -2.13213652e-01f, -1.86475858e-01f, 1.77691385e-01f, -1.07954942e-01f, 1.39616475e-01f, -5.13588190e-02f, -1.55859455e-01f, 7.05601275e-02f,
  5.95900938e-02f, 9.94699597e-02f, -8.60153511e-02f, -1.70242488e-01f, 1.06689267e-01f, 2.13305298e-02f, -1.70010105e-01f, 5.40284663e-02f, -1.81400776e-02f, 4.10123914e-02f,
  -1.14517607e-01f, -1.14774600e-01f, -1.62297547e-01f, -9.71948728e-02f, -1.67917475e-01f, -1.96786687e-01f, -6.23649098e-02f, -1.33774683e-01f, 6.35381497e-04f, -1.20617121e-01f,
  -2.98636883e-01f, -2.91979164e-01f, -9.03057232e-02f, 3.14176008e-02f, -1.08873464e-01f, -1.38350874e-01f, 5.10957800e-02f, 8.81946087e-02f, -2.45490223e-02f, 2.70987958e-01f,
  2.19118688e-02f, -5.05413115e-03f, -2.45016208e-03f, 9.54435766e-02f, 1.56246200e-01f, 7.72606283e-02f, -1.34890703e-02f, -1.45218605e-02f, 5.67923626e-03f, -1.22591006e-02f,
  4.11954671e-02f, 4.01434377e-02f, -1.87949501e-02f, 1.11617548e-02f, -3.87006029e-02f, -2.44236160e-02f, 2.80860960e-02f, -7.85152540e-02f, -5.30219935e-02f, -3.06330509e-02f,
  -6.55601844e-02f, -2.13639662e-02f, -4.81328182e-03f, -7.26541802e-02f, 4.07533310e-02f, -7.38549186e-03f, 4.44689393e-02f, -3.76025587e-02f, 1.32940412e-01f, -3.90903242e-02f,
  1.49117947e-01f, -2.20399693e-01f, 1.11188173e-01f, -7.64421448e-02f, -7.13687241e-02f, -6.14286028e-02f, 1.59812391e-01f, 6.49504215e-02f, 6.59198090e-02f, -1.96705505e-01f,
  -1.95345283e-01f, -2.03638319e-02f, 8.78147855e-02f, 6.49954826e-02f, -1.14223398e-01f, -2.01161988e-02f, -4.98069189e-02f, -6.35225996e-02f, -1.69334680e-01f, -5.43108117e-03f,
  4.25813571e-02f, -1.81957617e-01f, -1.05958201e-01f, 1.73738807e-01f, 7.91305453e-02f, -1.26603916e-01f, 1.73063785e-01f, 1.28848121e-01f, -9.69380736e-02f, 2.98951209e-01f,
  -5.91226757e-01f, -3.41972895e-02f, -8.51459652e-02f, -2.51843363e-01f, 2.06831396e-01f, 2.82483965e-01f, 4.30552423e-01f, 2.43144985e-02f, -1.15945809e-01f, 2.00619176e-01f,
  1.92763641e-01f, 2.75569130e-02f, 3.80751155e-02f, 1.49683043e-01f, 2.27093771e-01f, 3.53244126e-01f, 1.90171286e-01f, 8.77483655e-03f, -5.64625971e-02f, 6.57223836e-02f,
  1.28541097e-01f, -1.55001685e-01f, -3.75280052e-01f, -1.34487763e-01f, -7.18667507e-02f, -9.99149680e-02f, -1.08815119e-01f, -1.51592866e-01f, 1.56995624e-01f, -8.49213544e-03f,
  -1.46212175e-01f, -3.93405616e-01f, 1.15648933e-01f, -5.34106717e-02f, -8.62707421e-02f, -1.47044033e-01f, -4.98654582e-02f, -2.17276603e-01f, 2.17489852e-03f, -1.79135718e-03f,
  -1.06533438e-01f, -1.43586788e-02f, -4.87054884e-02f, -5.21158241e-02f, -1.72853515e-01f, -7.94386566e-02f, -8.61694366e-02f, -1.09410159e-01f, -8.14427584e-02f, -1.93888828e-01f,
  2.66674608e-01f, -1.49389237e-01f, -3.37608486e-01f, 9.23867002e-02f, -3.71302590e-02f, -1.06578395e-01f, -2.38028884e-01f, -3.61412883e-01f, -1.28865078e-01f, -4.07196999e-01f,
  -6.68150431e-04f, -6.68907017e-02f, 3.01883332e-02f, -1.09735698e-01f, 3.02762985e-02f, 7.65566677e-02f, 3.56677584e-02f, 5.29590212e-02f, 6.87140450e-02f, -1.33057430e-01f,
  -4.14526872e-02f, 2.98868734e-02f, -1.65321082e-01f, 2.21729986e-02f, -2.61802971e-02f, -9.41689909e-02f, 2.25667376e-02f, -3.53605933e-02f, 3.76373045e-02f, -1.75522529e-02f,
  4.89902087e-02f, 7.02435523e-02f, -1.77889258e-01f, -2.86545921e-02f, 1.88456580e-01f, 1.28127215e-02f, -1.26026034e-01f, -5.50513566e-02f, -1.62639603e-01f, 2.50652879e-02f,
  -1.71259224e-01f, 1.82221502e-01f, -4.56579775e-02f, 8.45436156e-02f, -5.50018847e-02f, 6.59719035e-02f, -8.59251469e-02f, 2.46035843e-03f, -9.81414225e-04f, -5.22107109e-02f,
  -3.31003703e-02f, -7.10850209e-02f, 4.98165675e-02f, 3.66473645e-02f, 3.97184715e-02f, 1.27925515e-01f, 2.32258737e-01f, 9.56237838e-02f, 5.63203543e-02f, -1.96305349e-01f,
  2.09781881e-02f, -3.65588069e-02f, -2.14089960e-01f, 2.29550293e-03f, -4.80592474e-02f, -1.45884544e-01f, -2.67193198e-01f, -1.28152415e-01f, -9.92352292e-02f, -8.54866877e-02f,
  5.79008102e-01f, 1.99482545e-01f, -3.37069966e-02f, 6.45846874e-02f, -4.19620872e-02f, 2.14874566e-01f, 2.29654923e-01f, 2.01458305e-01f, 1.73440516e-01f, 1.28011733e-01f,
  2.32149288e-01f, 1.63047746e-01f, 2.09030256e-01f, 6.94593489e-02f, 6.98223785e-02f, -4.64166813e-02f, -1.03365943e-01f, 4.33482416e-02f, 1.40715495e-01f, 1.05416343e-01f,
  8.51243064e-02f, -5.29309288e-02f, 1.02868453e-01f, -1.72598511e-02f, -1.84153929e-01f, -1.50515348e-01f, -9.93504748e-02f, -1.12147346e-01f, 3.28881405e-02f, -2.27406189e-01f,
  -2.90154546e-01f, 1.17731698e-01f, -3.39635164e-02f, -2.82115564e-02f, -1.44384220e-01f, 4.47160676e-02f, -6.47953674e-02f, -1.25722036e-01f, -8.99265781e-02f, -8.54979530e-02f,
  -1.34847090e-01f, 2.04523723e-03f, 1.10941306e-01f, 7.38215521e-02f, -1.34000793e-01f, 4.67962399e-02f, -4.55310196e-02f, 6.71860343e-03f, -8.90326947e-02f, 4.41183411e-02f,
  7.35807419e-02f, 6.10163584e-02f, 1.45273292e-02f, 1.44264787e-01f, 1.33285075e-01f, -3.28241251e-02f, 3.25005837e-02f, 1.61468480e-02f, 1.28515631e-01f, 7.06642866e-02f,
  2.76962183e-02f, 1.15985408e-01f, 1.27672687e-01f, -1.24354511e-02f, 1.09096281e-01f, -7.25041404e-02f, -1.00794271e-01f, -8.23283568e-02f, 1.67549669e-03f, 8.71585980e-02f,
  3.55146937e-02f, 1.04826158e-02f, 1.89760909e-03f, 1.32980078e-01f, 1.21979639e-01f, -3.20661962e-02f, 3.52768563e-02f, 9.51593742e-02f, -2.35429741e-02f, -2.56479569e-02f,
  1.84612691e-01f, -6.93088919e-02f, -5.16491290e-03f, 5.72467502e-03f, 4.56959903e-02f, -1.14378026e-02f, 2.31158417e-02f, 5.18787699e-03f, 4.87876870e-02f, -9.04360879e-03f,
  -1.50419682e-01f, 3.12096953e-01f, -9.77820531e-03f, -1.11812819e-02f, -1.74226061e-01f, 4.38725613e-02f, 8.75718817e-02f, -5.07292598e-02f, -2.15002716e-01f, -1.91894650e-01f,
  -7.76028354e-03f, 4.16733250e-02f, 7.38219544e-02f, 5.21767400e-02f, -4.47223149e-02f, -3.42640765e-02f, -3.75576876e-02f, 8.52388442e-02f, -9.09056813e-02f, -1.78962260e-01f,
  2.84086410e-02f, 1.03207111e-01f, -2.65442152e-02f, 8.51106942e-02f, 4.89364229e-02f, 9.11932960e-02f, -1.22827224e-01f, -1.20986655e-01f, 7.45449737e-02f, 7.72136152e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.38413537e-02f, 2.27453485e-01f, 3.49165052e-01f, 1.18439563e-01f, 2.28841916e-01f, 1.88699424e-01f, -1.58026498e-02f, 1.51777461e-01f, 2.56989509e-01f, -1.09801531e-01f,
  1.32320628e-01f, 1.58527702e-01f, 9.48263705e-02f, 3.62664945e-02f, 1.71345487e-01f, 4.09606516e-01f, 2.95821130e-01f, 1.80697098e-01f, 4.69241768e-01f, 4.13012266e-01f,
  7.72497952e-02f, 5.11601150e-01f, 3.44251543e-01f, 1.09158404e-01f, 1.85718775e-01f, 1.65007502e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  1.41736552e-01f, -7.53026307e-02f, -4.32124287e-02f, -2.08447371e-02f, 2.49508191e-02f, 9.21498612e-03f, 9.21913907e-02f, -6.13518022e-02f, 7.12090870e-03f, 7.78108314e-02f,
  3.88637185e-02f, 8.42978954e-02f, 3.98110077e-02f, 4.36355509e-02f, 2.26444900e-02f, 2.64164452e-02f, 1.44332588e-01f, 2.63960864e-02f, -4.93736379e-02f, -3.24668400e-02f,
  -5.88527545e-02f, -2.23503187e-02f, 1.49712250e-01f, 5.63310981e-02f, -1.10072335e-02f, 8.98484662e-02f, -3.40291858e-02f, -8.88158754e-03f, 9.11624059e-02f, 8.37235302e-02f,
  -1.03654079e-01f, -7.28592575e-02f, 1.31653041e-01f, -1.48871437e-01f, 1.13762945e-01f, 1.33913904e-01f, 9.95181128e-02f, 6.28696233e-02f, 4.41298895e-02f, -4.00011130e-02f,
  -7.64197633e-02f, -6.53422028e-02f, -8.86903703e-03f, 1.47102540e-02f, 3.85880433e-02f, 2.06627846e-02f, -1.32829383e-01f, 1.83855951e-01f, 1.08186781e-01f, -2.38826014e-02f,
  1.53280906e-02f, -2.94740237e-02f, -7.14674965e-03f, -1.03801891e-01f, -1.09954793e-02f, -5.80101535e-02f, -1.47169426e-01f, 2.68267810e-01f, -1.10825794e-02f, 2.62746569e-02f,
  -5.85065819e-02f, 1.20568767e-01f, -4.25658841e-03f, 4.80217375e-02f, -3.76517996e-02f, -4.29553799e-02f, -1.86302029e-02f, -8.09273496e-02f, 1.51690647e-01f, -1.18224218e-01f,
  -1.58974737e-01f, -1.26644522e-01f, -6.42499849e-02f, -8.48441646e-02f, -1.95589378e-01f, -3.85870598e-02f, 6.57425821e-02f, -5.56885153e-02f, -7.99645334e-02f, -4.56335731e-02f,
  4.86063883e-02f, -4.18657921e-02f, 6.13722764e-02f, -8.23851749e-02f, 8.03773329e-02f, 2.18885258e-01f, -1.71488121e-01f, 7.09465295e-02f, 2.84922775e-02f, -6.46214336e-02f,
  1.90631784e-02f, -1.62744924e-01f, 1.05835564e-01f, -3.24464701e-02f, -1.10734412e-02f, -4.07787710e-02f, -9.12043750e-02f, -4.01565433e-02f, -5.54356864e-03f, -1.01878494e-01f,
  -1.15177147e-01f, 1.32835701e-01f, 1.78406656e-01f, -1.49575109e-02f, 6.02518283e-02f, -1.08299784e-01f, 3.67104113e-02f, 2.80287564e-01f, -1.50603443e-01f, 1.96013451e-02f,
  -8.24007541e-02f, 4.00775746e-02f, 5.57253975e-03f, 2.74206921e-02f, -2.37922087e-01f, -1.87433273e-01f, 1.14500038e-01f, 2.01543227e-01f, 4.83232960e-02f, 1.31027237e-01f,
  1.85258240e-01f, 1.55651271e-01f, 1.33003891e-01f, -7.35082626e-02f, -1.78765669e-01f, -1.77633256e-01f, 2.50784005e-03f, -1.07596420e-01f, -5.24297692e-02f, 1.24842431e-02f,
  -1.95759404e-02f, -2.69923415e-02f, 1.60104446e-02f, -1.65528301e-02f, 3.54957469e-02f, 1.64164715e-02f, -1.13111310e-01f, -4.32784483e-03f, 4.47706059e-02f, 2.24071126e-02f,
  1.82367414e-02f, -1.45972297e-02f, -5.50263487e-02f, 5.61823174e-02f, 4.70105559e-02f, 9.54451859e-02f, -8.60833749e-02f, 1.08710658e-02f, 6.56239614e-02f, -1.49114020e-02f,
  5.66149727e-02f, -2.46292781e-02f, 1.65185049e-01f, -7.31011927e-02f, -2.26405039e-02f, 7.27943704e-02f, -6.23875372e-02f, 2.08140742e-02f, 3.49502303e-02f, -1.54339582e-01f,
  -2.64535323e-02f, 9.70470756e-02f, 3.91485170e-02f, -6.76722601e-02f, -4.32858802e-02f, -1.23959891e-01f, 3.78445201e-02f, 8.48253369e-02f, 3.67152393e-02f, -1.31679118e-01f,
  7.35754594e-02f, 2.87909657e-02f, 8.15550704e-03f, 1.23077091e-02f, 1.34937316e-01f, 2.67483033e-02f, 1.92920398e-02f, -5.44442423e-02f, -2.10653301e-02f, -5.26042618e-02f,
  7.74593726e-02f, -8.46911594e-02f, 5.55949844e-02f, 7.55519047e-02f, -1.94485605e-01f, -6.64709434e-02f, 1.85347535e-02f, 1.16102695e-01f, -3.04332618e-02f, 5.55224270e-02f,
  3.67725194e-02f, -4.19883206e-02f, -5.06582148e-02f, 7.22310878e-03f, 1.08807258e-01f, -1.04450904e-01f, -3.01780961e-02f, 3.38287354e-02f, 1.79185927e-01f, -4.59600203e-02f,
  3.27838026e-03f, -3.62438522e-02f, -1.23546198e-01f, 3.25024128e-02f, 7.27051497e-02f, -3.84533480e-02f, -1.37644917e-01f, 5.69648072e-02f, 1.35096340e-02f, 4.62088771e-02f,
  -4.45423601e-03f, 6.00473993e-02f, -7.57073909e-02f, 1.12008154e-01f, -1.36653442e-04f, 2.60126572e-02f, 1.44141084e-02f, -5.87745309e-02f, 7.20992088e-02f, 2.00606640e-02f,
  7.51506016e-02f, -6.19626343e-02f, -8.18744600e-02f, 1.27447033e-02f, -6.44093826e-02f, -1.00336112e-01f, -3.71156633e-02f, 6.75816163e-02f, -5.34572825e-02f, 4.75790016e-02f,
  6.52042255e-02f, 2.46445742e-02f, -1.52671844e-01f, -4.34999913e-02f, 8.31347480e-02f, -1.45246133e-01f, 5.91114163e-02f, 6.91751465e-02f, -1.14919068e-02f, 1.83747724e-01f,
  2.05865681e-01f, 8.92631784e-02f, 3.03522348e-02f, -5.31051215e-03f, -3.23433131e-02f, -1.32443130e-01f, 3.98016386e-02f, 1.36540309e-01f, 1.03640273e-01f, 1.02580108e-01f,
  8.42841938e-02f, -1.73275292e-01f, -5.94069883e-02f, 1.98241517e-01f, -1.15760669e-01f, 7.95271173e-02f, -1.16932241e-03f, 7.04038590e-02f, -1.71774209e-01f, -5.29744029e-02f,
  1.11655757e-01f, -8.48161951e-02f, 1.35642048e-02f, 5.30712912e-03f, 1.11333683e-01f, 1.55752888e-02f, 5.73221780e-02f, 1.07857220e-01f, -5.16846441e-02f, 2.90478189e-02f,
  1.04267985e-01f, 5.75264655e-02f, 1.31216228e-01f, -5.53865135e-02f, 6.36679074e-03f, 8.38030800e-02f, 3.62401456e-02f, 4.02966328e-02f, 1.51198814e-02f, 2.58267913e-02f,
  8.89723822e-02f, -3.70612554e-02f, -3.47337089e-02f, -1.58971101e-01f, 1.14963382e-01f, 3.24980430e-02f, 3.31587642e-02f, -2.12388225e-02f, -1.88322410e-01f, -2.26951186e-02f,
  -1.61791295e-02f, 1.91371422e-02f, -1.30293936e-01f, 7.94834569e-02f, -6.36480898e-02f, -4.53120433e-02f, 5.98546788e-02f, 5.11086285e-02f, 6.47586063e-02f, -2.03965809e-02f,
  -4.67686392e-02f, 3.73151759e-03f, 4.03500758e-02f, 7.10123181e-02f, 3.70418909e-03f, -7.22880512e-02f, -1.28711183e-02f, 1.62641972e-01f, 6.07533157e-02f, -2.18868144e-02f,
  -2.18258402e-03f, -8.65967572e-02f, 4.71162163e-02f, 1.45453155e-01f, 4.09256248e-03f, -1.28559142e-01f, -1.35565609e-01f, 1.26782553e-02f, -1.32068649e-01f, 6.33873269e-02f,
  1.27609760e-01f, 8.58892724e-02f, 5.19215912e-02f, -1.20307900e-01f, 9.82070491e-02f, -4.20094952e-02f, -5.31359687e-02f, -6.89675659e-02f, -8.80456120e-02f, -2.40727782e-01f,
  -1.35527924e-01f, 3.50224078e-02f, 4.22871858e-02f, 6.85922280e-02f, -6.80624470e-02f, -8.31213221e-02f, 1.17174499e-01f, 9.02503431e-02f, 1.67102858e-01f, -1.02683261e-01f,
  5.93211735e-03f, -1.15641700e-02f, -1.29836917e-01f, 6.79720342e-02f, 7.09077856e-03f, 9.28937420e-02f, -4.23471667e-02f, -3.30470026e-01f, 1.20615758e-01f, -2.23245267e-02f,
  -4.14972976e-02f, -1.35165498e-01f, -1.46910876e-01f, -2.57058978e-01f, -2.48428658e-02f, -1.19023130e-03f, 8.41889903e-02f, 2.64364090e-02f, -6.90156445e-02f, -3.02759502e-02f,
  1.14853740e-01f, -1.30424842e-01f, 3.31679851e-01f, 3.29501107e-02f, -9.45343673e-02f, -3.17771733e-02f, -2.01005444e-01f, -8.13486278e-02f, -9.18960795e-02f, 1.30206317e-01f,
  -1.91465884e-01f, -5.35166785e-02f, 6.91517144e-02f, 1.18708991e-01f, 2.31540114e-01f, 1.27180755e-01f, 9.09141302e-02f, -1.73379362e-01f, -2.01648436e-02f, 2.95770541e-02f,
  -1.23433031e-01f, -2.08174676e-01f, -2.52849847e-01f, 2.20068847e-03f, -1.16485409e-01f, 1.13357469e-01f, 1.37481513e-02f, 2.33130939e-02f, 1.95955336e-02f, 3.07337707e-03f,
  -2.72566807e-02f, 1.43599555e-01f, 5.79056330e-02f, 1.54778883e-02f, -3.40777412e-02f, -6.40410334e-02f, 9.81227160e-02f, 5.47559783e-02f, 6.59398409e-03f, -2.23791152e-02f,
  -1.29741251e-01f, -4.25884277e-02f, -1.10121600e-01f, 1.09567717e-01f, 1.55599965e-02f, 4.71775420e-02f, -5.89686930e-02f, -5.17844595e-02f, -7.24922270e-02f, 5.76040149e-02f,
  1.37659013e-02f, 4.77384068e-02f, -6.93544075e-02f, -2.90117860e-02f, -5.88006293e-03f, -2.30232254e-02f, 6.89648930e-03f, -4.18000035e-02f, 5.37290946e-02f, 4.17790487e-02f,
  5.44503890e-02f, -2.19017118e-02f, 5.93624450e-02f, -2.64371838e-02f, 4.08994146e-02f, 1.56041637e-01f, 3.14103253e-02f, -8.84992406e-02f, 1.55960485e-01f, 2.17536697e-03f,
  -5.11184521e-02f, 5.67848757e-02f, -4.67906445e-02f, -8.33092406e-02f, 1.95263755e-02f, 5.93644939e-02f, 9.69666839e-02f, -7.25921318e-02f, -1.25073614e-02f, -1.07075229e-01f,
  9.28157344e-02f, -2.81586591e-02f, 1.34104555e-02f, 1.49693433e-02f, 1.08780667e-01f, 3.82162369e-04f, -4.97683734e-02f, -2.96008941e-02f, 1.61040984e-02f, 3.97642218e-02f,
  -8.40160903e-03f, 1.07280217e-01f, 5.91944605e-02f, 3.12783197e-02f, -6.56237900e-02f, -1.96177699e-02f, -1.95561480e-02f, -1.21802688e-01f, -7.60631636e-02f, 6.03289232e-02f,
  -3.98227610e-02f, 1.04893535e-01f, 2.82322727e-02f, 4.28561168e-03f, -2.88510863e-02f, -4.27716970e-02f, 4.53451723e-02f, -1.83148123e-02f, 1.42522296e-02f, -1.81127358e-02f,
  -4.13460396e-02f, 7.90185779e-02f, -8.13463889e-03f, 1.75899878e-01f, 3.33579108e-02f, -1.60017282e-01f, 6.06455803e-02f, -8.57633799e-02f, 5.18154055e-02f, -3.87741104e-02f,
  7.31220022e-02f, 3.09100430e-02f, -2.30594445e-02f, -1.88006550e-01f, -1.79457635e-01f, -1.22890696e-01f, -1.36586756e-01f, 6.90986589e-03f, 1.63535625e-01f, 8.23774263e-02f,
  2.13730708e-01f, 7.94037953e-02f, -7.99532384e-02f, -1.57778308e-01f, 5.52164856e-03f, -1.31746933e-01f, 1.93770416e-02f, 8.11543390e-02f, -4.15681630e-01f, 6.95976317e-02f,
  9.13563669e-02f, 9.09543112e-02f, 1.54259026e-01f, 1.11292405e-02f, -2.36116409e-01f, -2.61503965e-01f, -8.93552750e-02f, -5.48613667e-02f, 4.38242331e-02f, -1.70103237e-01f,
  1.71270445e-01f, 3.65341008e-02f, 7.45514259e-02f, 1.70983933e-02f, -3.51622514e-02f, -7.85615202e-03f, -6.97662234e-02f, -1.32250823e-02f, -8.01979005e-02f, 9.07949284e-02f,
  7.81533122e-02f, 3.78683507e-02f, -9.20325741e-02f, 5.80468215e-02f, -2.28513852e-02f, 5.11436388e-02f, 3.01898513e-02f, 4.23795125e-03f, -7.20040426e-02f, 5.92391491e-02f,
  -6.72218651e-02f, 3.35469618e-02f, 1.35498177e-02f, -4.65582758e-02f, -1.12412963e-02f, 1.05656691e-01f, -6.79033697e-02f, 2.46317536e-02f, -5.02869301e-02f, -7.45401829e-02f,
  2.95270178e-02f, -5.40467054e-02f, 6.20871261e-02f, -2.73847654e-02f, 3.33484486e-02f, 6.32088026e-03f, 3.87279014e-03f, 4.66985032e-02f, -6.59628287e-02f, 7.26394653e-02f,
  9.70135853e-02f, 1.37885800e-02f, 5.26503697e-02f, 2.32585408e-02f, -2.86085587e-02f, -4.78474982e-02f, -1.61451916e-03f, -1.37108583e-02f, -4.53740843e-02f, 2.31236033e-02f,
  -7.79990926e-02f, 6.65187789e-03f, -2.10824073e-03f, -7.86697641e-02f, 2.82245725e-02f, -2.65344270e-02f, -9.58839282e-02f, -1.04894973e-01f, -6.28527403e-02f, -5.30460803e-03f,
  -2.59762704e-01f, -7.83838108e-02f, -1.54972374e-02f, -2.08682157e-02f, 1.41555220e-01f, -1.26641676e-01f, 2.72238236e-02f, 8.33525211e-02f, -2.08136756e-02f, 6.57861158e-02f,
  -6.67722225e-02f, 4.49809507e-02f, 1.03524670e-01f, 8.42822269e-02f, 1.23056471e-01f, -1.21402159e-01f, 3.64356227e-02f, 5.00192307e-02f, -1.74268603e-01f, 4.11547497e-02f,
  7.02261627e-02f, -1.01111226e-01f, -6.32368727e-03f, 9.81144700e-03f, 3.62405814e-02f, -3.15995514e-02f, -1.67604145e-02f, -1.82963721e-02f, 9.95721966e-02f, -1.27573043e-01f,
  -4.59995307e-02f, 6.96837008e-02f, -7.96774253e-02f, 1.19546980e-01f, -1.17424056e-01f, 8.00452307e-02f, -1.59695335e-02f, 7.86195993e-02f, 4.45928089e-02f, 4.47298251e-02f,
  8.12710822e-02f, 6.59778193e-02f, -5.73285483e-02f, -1.04142666e-01f, -3.32880504e-02f, 3.32111642e-02f, 6.90447837e-02f, 1.47366628e-01f, -2.19067961e-01f, -1.25832811e-01f,
  1.17747113e-02f, -1.67798951e-01f, 1.76495761e-01f, 4.77740951e-02f, 2.14850176e-02f, -1.00392856e-01f, 1.54605240e-01f, 1.48172975e-01f, -6.97209090e-02f, -2.20967099e-01f,
  1.01044048e-02f, -2.91250665e-02f, 1.00542143e-01f, -2.73078024e-01f, -5.11928871e-02f, -1.10694565e-01f, 2.79275477e-01f, -1.58852369e-01f, 4.57162149e-02f, 1.22558009e-02f,
  5.06501347e-02f, 1.04330726e-01f, -2.73614936e-03f, -2.27527879e-02f, 6.94863126e-03f, -3.11634932e-02f, -5.59338219e-02f, 4.24724026e-03f, -6.01965711e-02f, 4.19212580e-02f,
  -4.98384871e-02f, 1.81473475e-02f, 5.07993698e-02f, 3.95992026e-02f, 8.48044455e-02f, 6.91976026e-02f, -3.66591550e-02f, 1.09352116e-02f, -1.04917567e-02f, -4.07093577e-02f,
  -3.46203782e-02f, -3.45342830e-02f, -2.34423392e-02f, -2.97133159e-02f, 8.93663093e-02f, -1.92496598e-01f, -2.54521221e-02f, -3.51351239e-02f, -9.39841717e-02f, 4.79509309e-02f,
  -2.16423757e-02f, 7.94371590e-02f, 5.59810735e-02f, -3.51398811e-02f, -7.20023960e-02f, 6.26112819e-02f, -1.07125506e-01f, 9.21898289e-04f, 1.15458630e-01f, -5.39131202e-02f,
  2.87108943e-02f, -6.21784143e-02f, -1.04072668e-01f, -5.69091439e-02f, 2.88710166e-02f, 6.52958779e-03f, -5.19909412e-02f, -1.70158204e-02f, 3.25255841e-02f, -5.11219800e-02f,
  -4.44149673e-02f, 4.28288952e-02f, -7.42214918e-02f, -1.07702002e-01f, 1.10524572e-01f, -8.29437524e-02f, -9.58910808e-02f, 3.73337939e-02f, 3.27054076e-02f, -4.03168984e-02f,
  9.86671448e-02f, 4.05977247e-03f, 6.07774407e-02f, 1.12117797e-01f, 2.68629063e-02f, -9.42321420e-02f, -2.59770751e-01f, 7.44057298e-02f, 7.81588070e-03f, -6.14011437e-02f,
  4.42441888e-02f, -1.96762234e-02f, 6.27302155e-02f, 1.35049462e-01f, 2.15456933e-01f, -2.25053981e-01f, -1.44725919e-01f, 5.18958643e-02f, -6.59211800e-02f, 8.41386896e-03f,
  1.29908338e-01f, 3.55164818e-02f, 1.13460802e-01f, 1.32467121e-01f, -1.29833639e-01f, -1.09610789e-01f, -7.30444118e-02f, -1.11358061e-01f, 3.34200002e-02f, 2.10853014e-02f,
  -3.14108767e-02f, 2.39638500e-02f, -5.51194884e-02f, -1.14647046e-01f, 1.48988307e-01f, -1.01543322e-01f, 5.75929023e-02f, 7.86795020e-02f, 1.08281106e-01f, 2.91057210e-02f,
  6.01181202e-02f, -3.03800404e-02f, -5.80202490e-02f, 1.34707503e-02f, -1.00309893e-01f, 1.05996408e-01f, 1.29232466e-01f, -1.13568127e-01f, -1.83047950e-01f, 1.78819269e-01f,
  1.38113633e-01f, 2.60992702e-02f, -1.61776524e-02f, -2.53546000e-01f, 5.80145195e-02f, 4.01014313e-02f, -7.31791332e-02f, -2.15904802e-01f, 6.79981662e-04f, -1.77075461e-01f,
  1.30767763e-01f, -1.73556224e-01f, -2.40062833e-01f, -1.03769712e-01f, -6.62050694e-02f, 1.35032192e-01f, -1.09707035e-01f, -5.71241230e-02f, 1.52221071e-02f, -4.90965098e-02f,
  2.37551089e-02f, -3.21833491e-02f, 3.54122967e-02f, 1.67802218e-02f, 1.42565086e-01f, 6.14249110e-02f, 6.06024116e-02f, -3.29956822e-02f, 7.58574950e-03f, 2.36318503e-02f,
  -1.01395920e-01f, 2.31912620e-02f, -5.07938638e-02f, 2.73782504e-03f, -5.48700280e-02f, 1.63320303e-02f, 1.52411021e-03f, 5.52331917e-02f, -3.82600054e-02f, 3.79585451e-03f,
  -1.15088582e-01f, 1.88811406e-01f, -6.75495639e-02f, 3.88524421e-02f, -1.00946368e-03f, -7.99309462e-03f, 7.03688487e-02f, 6.95076436e-02f, -1.73799098e-02f, -3.28216441e-02f,
  4.17589955e-03f, 1.04949035e-01f, -1.09446138e-01f, 1.14441082e-01f, -4.24345843e-02f, 4.60911095e-02f, 4.21020128e-02f, -7.46635199e-02f, -5.14070736e-04f, -3.18070538e-02f,
  -7.25439936e-02f, 4.07906771e-02f, 4.24697250e-02f, -1.04214624e-03f, -1.76884551e-02f, 1.23227723e-01f, -1.22590341e-01f, -6.22209422e-02f, -3.58058587e-02f, -1.54267782e-02f,
  1.02071218e-01f, 1.68091848e-01f, -4.64964435e-02f, 3.84938903e-02f, 8.33891798e-03f, 2.18381971e-01f, -9.20808241e-02f, 6.99331090e-02f, -3.49804908e-02f, 2.92865597e-02f,
  2.86268834e-02f, 1.13411151e-01f, -3.11256852e-02f, -5.28853945e-02f, -8.76360536e-02f, 9.08526108e-02f, 4.40349877e-02f, 3.82962148e-03f, -4.43444252e-02f, 1.38973184e-02f,
  1.22956708e-01f, -1.36194155e-01f, -7.20543936e-02f, -1.47935912e-01f, -1.37698650e-01f, 7.43938386e-02f, 6.81500584e-02f, 1.11257963e-01f, 2.43638735e-02f, -1.27550781e-01f,
  1.19414411e-01f, -2.08536044e-01f, 1.82574000e-02f, -8.53854865e-02f, 9.33917090e-02f, -1.90848753e-01f, -1.10918418e-01f, -2.85475291e-02f, -1.13613307e-01f, -3.64542045e-02f,
  2.52661612e-02f, 8.63295607e-03f, 5.65041788e-02f, -1.31230831e-01f, -6.45200387e-02f, -1.37036398e-01f, 4.29004021e-02f, -5.78098297e-02f, 1.00673713e-01f, -1.05070673e-01f,
  1.60067275e-01f, -8.63738731e-02f, 4.04739529e-02f, -5.62783331e-02f, 7.62675330e-02f, 3.13077830e-02f, -8.24730322e-02f, -6.55502379e-02f, -7.51083344e-02f, -1.39878795e-01f,
  3.11770886e-02f, 5.80185093e-03f, 5.76032251e-02f, -1.36181489e-01f, -1.00239329e-01f, -4.40903716e-02f, 2.26906210e-01f, 2.45287761e-01f, -2.76872073e-03f, -2.38825887e-01f,
  1.36999071e-01f, 3.82654779e-02f, 4.23472151e-02f, 1.58037215e-01f, -1.90501451e-01f, 7.41234198e-02f, -1.60865724e-01f, -3.31379212e-02f, 1.13614080e-02f, 1.22745693e-01f,
  4.12308127e-02f, -2.92220004e-02f, 5.48913255e-02f, -1.00465529e-01f, 5.59300035e-02f, 1.05361141e-01f, -1.89388450e-02f, -9.06403586e-02f, 7.14588240e-02f, 1.63098648e-02f,
  -7.81758055e-02f, 8.28772187e-02f, -3.81365977e-02f, -9.03353747e-03f, -1.23937763e-01f, 7.33946264e-02f, -7.79758319e-02f, -4.14368473e-02f, 2.66174637e-02f, -1.38152596e-02f,
  5.89696467e-02f, -9.37053468e-03f, 2.36703362e-02f, 9.26314592e-02f, 6.28156662e-02f, 7.92592391e-02f, 4.19919938e-02f, 1.85207780e-02f, 1.79213397e-02f, -9.09127891e-02f,
  6.31956905e-02f, -2.97436118e-03f, 1.26945138e-01f, -8.62916335e-02f, -9.46100429e-02f, -9.90497693e-02f, 1.08422361e-01f, 1.13812321e-05f, 2.57811863e-02f, 8.93970355e-02f,
  -9.03637707e-02f, 2.33220868e-02f, 1.06787467e-02f, 1.59076788e-02f, 2.98759318e-03f, 4.23010662e-02f, 9.20530930e-02f, -4.65659015e-02f, -1.08105853e-01f, -1.01910837e-01f,
  -5.80578744e-02f, 1.74784422e-01f, 4.33637984e-02f, -1.22649454e-01f, 6.17317185e-02f, 1.81016490e-01f, 1.24209695e-01f, -5.36228903e-02f, -7.54042268e-02f, -2.18129195e-02f,
  -1.10261366e-01f, 9.12352130e-02f, -1.77259147e-01f, -1.01723619e-01f, -6.50403053e-02f, -2.19733249e-02f, 1.64250791e-01f, -5.58001325e-02f, 6.67451099e-02f, 1.37402698e-01f,
  1.57349810e-01f, 6.83586486e-03f, 1.26863450e-01f, 1.48941934e-01f, -1.58685327e-01f, 9.37831998e-02f, 1.03431538e-01f, 8.94476101e-02f, 2.81501561e-02f, 1.62140161e-01f,
  -5.43691702e-02f, 2.02394441e-01f, 8.40920135e-02f, 1.12250997e-02f, 5.20129167e-02f, 6.76979795e-02f, 7.95684904e-02f, 2.16092452e-01f, 1.74180453e-03f, -1.05104841e-01f,
  2.79036611e-02f, 3.08401510e-02f, 3.83000262e-02f, 2.95313690e-02f, 7.41705894e-02f, -7.88203254e-02f, 2.07645208e-01f, 1.40583906e-02f, 7.70797655e-02f, 6.76074624e-02f,
  -4.65047508e-02f, -2.10559577e-01f, -1.61353737e-01f, -8.23326334e-02f, -6.58682510e-02f, 1.19626731e-01f, -9.65219736e-02f, 1.31602317e-01f, -9.77395102e-02f, -1.27946362e-01f,
  9.73375216e-02f, -1.72999918e-01f, 7.81566873e-02f, 8.58761743e-02f, -1.35511577e-01f, -3.48371923e-01f, 2.79662400e-01f, 4.11486894e-01f, -6.59607202e-02f, 3.72414142e-02f,
  -1.19718954e-01f, 2.91142434e-01f, 1.50724500e-01f, -2.86346842e-02f, -1.92993192e-03f, 2.05637485e-01f, 1.61230285e-02f, -4.49158922e-02f, -1.02763511e-01f, -2.56781047e-03f,
  6.48683589e-03f, 5.39682284e-02f, 3.40888612e-02f, -1.71308238e-02f, -4.24080864e-02f, -1.74367651e-02f, 4.89956662e-02f, -1.82942918e-03f, 2.77458075e-02f, 2.95202341e-02f,
  2.59331465e-02f, -6.96745841e-03f, -2.56621391e-02f, 9.13887843e-02f, 7.52055719e-02f, -4.55735922e-02f, 6.58935914e-03f, -8.81938040e-02f, -6.42072558e-02f, -2.07100878e-03f,
  -1.75654627e-02f, 8.27413239e-03f, 1.55563524e-03f, -3.08653861e-02f, -1.28380045e-01f, 1.16082288e-01f, 8.16858113e-02f, 2.34051850e-02f, 7.85910040e-02f, 1.70839243e-02f,
  -4.75466102e-02f, -9.16890129e-02f, 9.10575017e-02f, -1.66098237e-01f, 4.88518691e-03f, 4.31402959e-02f, -6.39973208e-03f, -2.59145461e-02f, 1.32055329e-02f, -3.70774977e-02f,
  -1.21395960e-02f, -4.77164611e-02f, 9.17330161e-02f, -4.90497947e-02f, 5.36901783e-03f, 4.62470530e-03f, -5.87835163e-02f, 2.61007715e-02f, 2.92246453e-02f, -1.58149488e-02f,
  1.37937423e-02f, -1.14552550e-01f, -1.61828369e-01f, 1.66252330e-01f, 1.03472456e-01f, 2.22558305e-01f, 2.75416095e-02f, -3.65618896e-03f, 4.19608243e-02f, 1.32787734e-01f,
  -3.83480266e-02f, 4.73638475e-02f, 2.81581338e-02f, 1.28629297e-01f, -6.67387852e-03f, 1.25141097e-02f, -2.60753091e-02f, 3.84093309e-03f, -9.86096188e-02f, 9.58884042e-03f,
  -7.54741661e-04f, -9.90957096e-02f, -8.70915130e-02f, 1.41115397e-01f, -1.08322807e-01f, -4.30886634e-02f, 1.31407633e-01f, -1.66442707e-01f, -1.98524043e-01f, -3.79852988e-02f,
  2.40004621e-03f, -1.62713584e-02f, 1.20218150e-01f, 1.67219669e-01f, 1.10234879e-02f, -1.94831640e-01f, 3.13150622e-02f, 3.95738073e-02f, -8.80633667e-03f, -5.86262718e-02f,
  -7.92779550e-02f, -7.69096687e-02f, -5.66936918e-02f, 1.87990800e-01f, -1.36336060e-02f, 3.13716009e-02f, -9.18780640e-02f, -1.42480269e-01f, 3.15635145e-01f, 7.78974220e-02f,
  1.68105870e-01f, -1.04763597e-01f, 1.40073702e-01f, -6.29762039e-02f, -1.15282059e-01f, -1.70414895e-02f, -6.02041278e-03f, -1.25182599e-01f, 1.68514829e-02f, 5.37938550e-02f,
  -4.57412447e-04f, 9.66873914e-02f, 2.89740205e-01f, -1.97353303e-01f, -2.39061490e-01f, -9.89190266e-02f, -1.21506169e-01f, 1.37782156e-01f, -2.66540408e-01f, -9.71675813e-02f,
  -3.34900022e-01f, 1.58310235e-01f, -3.54389027e-02f, -7.35467812e-03f, 1.39584884e-01f, -1.10273130e-01f, 1.17207788e-01f, 1.05694826e-05f, 7.88591206e-02f, 7.58577213e-02f,
  -6.60881549e-02f, 6.08678535e-03f, 7.11610094e-02f, -1.48086585e-02f, 3.99240591e-02f, 4.76748794e-02f, 1.16410956e-01f, -4.77010645e-02f, 5.51375188e-02f, -3.42283882e-02f,
  1.41228931e-02f, 1.16987839e-01f, -1.19307660e-01f, 2.59889793e-02f, -6.36292845e-02f, 4.95859571e-02f, -9.07296017e-02f, 1.36308402e-01f, 2.20557041e-02f, 2.95663960e-02f,
  8.67092516e-03f, 8.09746981e-02f, 8.24994370e-02f, 4.07690518e-02f, -3.51454988e-02f, 2.97678746e-02f, -3.41905421e-03f, -6.07728884e-02f, 1.83014181e-02f, 4.17831019e-02f,
  -6.03890931e-03f, 1.21868141e-01f, -4.12195921e-02f, -7.38550797e-02f, 1.27250388e-01f, -1.42024457e-02f, -1.33167893e-01f, -4.77581471e-02f, -9.77668092e-02f, 7.65419155e-02f,
  -9.84386429e-02f, -5.16881347e-02f, 3.13193202e-02f, -3.23601738e-02f, 6.42024204e-02f, 1.01289913e-01f, -1.10272385e-01f, 7.21384510e-02f, -1.64663911e-01f, 6.95037004e-03f,
  4.31745648e-02f, 2.61598229e-02f, -3.69502231e-02f, -9.49772522e-02f, 5.68988435e-02f, 1.21929161e-02f, -1.33984210e-02f, -3.09493262e-02f, 6.41631633e-02f, -5.88891432e-02f,
  7.55843893e-02f, -1.51572526e-01f, 6.09156489e-02f, 1.35755986e-01f, 1.63542405e-01f, -1.66571930e-01f, 1.49709597e-01f, -8.82868767e-02f, -2.07008589e-02f, 1.30349398e-01f,
  -1.52791187e-01f, 1.01391762e-01f, -2.59696431e-02f, 8.43180194e-02f, -7.38339946e-02f, 3.82522754e-02f, -6.60706013e-02f, 8.82740505e-03f, -2.91887000e-02f, 2.84129158e-02f,
  -2.21631572e-01f, -4.34695855e-02f, -4.76508103e-02f, 5.54949716e-02f, 1.26452148e-01f, 9.02391672e-02f, -1.02488756e-01f, 5.19829094e-02f, -9.72366706e-02f, -9.23138261e-02f,
  -1.69504825e-02f, -3.19076329e-02f, 3.03428452e-02f, -7.39748329e-02f, 1.44259036e-01f, 1.17586628e-02f, -1.42526448e-01f, -4.69771326e-02f, 1.55819267e-01f, 1.49789006e-01f,
  -2.42494959e-02f, 9.33233723e-02f, 3.90013643e-02f, 1.47105847e-02f, -1.34752050e-01f, 2.47269511e-01f, -5.74538438e-03f, -2.96210852e-02f, -2.26366684e-01f, -8.44260454e-02f,
  2.49026671e-01f, 2.37445414e-01f, 2.65487194e-01f, 9.28086266e-02f, 1.04948238e-01f, 8.12376663e-03f, 8.44718590e-02f, 5.76035157e-02f, -8.52980167e-02f, 2.72266120e-02f,
  -3.67545225e-02f, 1.18244603e-01f, 8.12861770e-02f, 5.78809753e-02f, 4.68548536e-02f, -1.80634484e-01f, 1.14561673e-02f, 9.71407443e-03f, 3.05621475e-02f, 3.63562629e-02f,
  -6.04160950e-02f, -3.64329340e-03f, 1.07901447e-01f, 1.12526482e-02f, 1.32820249e-01f, 9.80167165e-02f, 8.18740278e-02f, 3.80471721e-02f, 9.10951197e-02f, -7.36430138e-02f,
  -3.08955647e-02f, -1.29466161e-01f, -5.82784191e-02f, -4.16883044e-02f, -5.43541182e-03f, 7.19076470e-02f, 2.21853834e-02f, 3.47793698e-02f, -8.23474862e-03f, 1.47872195e-01f,
  -5.60743660e-02f, -5.12355892e-03f, -7.60097131e-02f, -8.39745179e-02f, 8.19013715e-02f, 2.00350638e-02f, 4.39543314e-02f, 1.39694493e-02f, -4.83113937e-02f, 8.54070634e-02f,
  6.24394603e-02f, -8.02082121e-02f, -4.56652492e-02f, 6.71443865e-02f, -3.83044295e-02f, 5.71340360e-02f, 1.47843093e-01f, -3.04479394e-02f, 1.21926121e-01f, 1.12003610e-01f,
  1.09600492e-01f, 5.87165356e-03f, -3.77779491e-02f, 6.87843338e-02f, 7.67661035e-02f, 3.57775427e-02f, -6.12213053e-02f, 1.48217250e-02f, 9.45973247e-02f, -2.61212811e-02f,
  -5.95458783e-02f, 7.99668655e-02f, -1.58632118e-02f, -4.00727242e-02f, -2.98637487e-02f, 3.79607715e-02f, -1.22125484e-01f, -1.06993563e-01f, 7.14274645e-02f, 4.65166988e-03f,
  5.85485250e-02f, -4.45180573e-02f, -6.86362758e-02f, 1.11818321e-01f, 6.39432715e-03f, 4.45321836e-02f, 5.06924465e-02f, 1.34058401e-01f, -1.94216087e-01f, 8.07416737e-02f,
  5.23654297e-02f, 1.91205457e-01f, 2.85356361e-02f, -7.60792568e-02f, -7.57227913e-02f, 1.71473939e-02f, -1.12449363e-01f, 1.01072900e-01f, -1.38221294e-01f, 3.61904353e-02f,
  6.22111671e-02f, -1.18511669e-01f, 9.70964283e-02f, 7.86597095e-03f, -1.12869561e-01f, 6.49098232e-02f, -5.92478700e-02f, -2.15314571e-02f, 4.47066352e-02f, -1.53352141e-01f,
  3.61438096e-02f, 1.61870085e-02f, -7.60852396e-02f, 3.97205465e-02f, -1.35163441e-01f, 4.69716405e-03f, 2.72091985e-01f, -2.38710254e-01f, -2.21283585e-02f, 5.13585880e-02f,
  1.33835778e-01f, 1.00716211e-01f, 9.93054509e-02f, -5.94200976e-02f, -2.12940559e-01f, 6.63321614e-02f, 3.48112844e-02f, 1.04007430e-01f, -7.99820200e-02f, 4.27424610e-02f,
  3.67192104e-02f, 3.66573147e-02f, -1.36985078e-01f, -6.11084700e-02f, -2.36019522e-01f, 6.56616921e-03f, 3.20006236e-02f, -1.28896877e-01f, -9.30577517e-02f, -1.33797107e-02f,
  1.03926480e-01f, -8.79380777e-02f, -1.93232238e-01f, -1.14271678e-01f, 4.12461646e-02f, 6.41524792e-02f, -1.07777312e-01f, -8.94588828e-02f, -6.79368228e-02f, 6.72432706e-02f,
  -3.96299213e-02f, 7.19997510e-02f, -3.47118801e-03f, 4.42316337e-03f, -4.93875667e-02f, 9.78753716e-02f, 2.38585211e-02f, 1.11461990e-01f, -3.44566479e-02f, -5.91725484e-02f,
  2.94730607e-02f, 3.44720110e-02f, 3.57351899e-02f, -8.41062814e-02f, -3.67145576e-02f, 5.62470928e-02f, -3.97797897e-02f, -5.43415360e-02f, -1.76325589e-02f, 7.11844265e-02f,
  -2.86800526e-02f, 1.29582509e-01f, -3.25148292e-02f, 5.36178946e-02f, -6.15576878e-02f, 1.33760348e-01f, 1.29771486e-01f, -1.42006855e-02f, 7.68055841e-02f, -1.41988084e-01f,
  -6.74310401e-02f, -9.04481299e-03f, -1.25590026e-01f, -3.87482457e-02f, -3.89785916e-02f, 8.27003345e-02f, -1.93648580e-02f, -9.23568532e-02f, 1.97031237e-02f, -9.22029987e-02f,
  4.47780406e-03f, -1.32542271e-02f, -4.68728021e-02f, 7.92454276e-03f, 4.97772619e-02f, -3.61892469e-02f, -1.22329623e-01f, -2.47194935e-02f, 2.06477996e-02f, 2.80320123e-02f,
  -2.45637074e-02f, -4.84809279e-02f, 1.11673728e-01f, 1.56791478e-01f, 5.96021041e-02f, 1.07396506e-01f, -1.22753819e-02f, 3.49999592e-02f, -1.65952131e-01f, 5.33053838e-02f,
  6.88839331e-02f, -7.55310133e-02f, -1.90138042e-01f, -1.44053757e-01f, -2.18442127e-01f, -8.53041261e-02f, 2.46459454e-01f, 2.27135159e-02f, -1.52176991e-01f, -2.97863632e-01f,
  3.02712508e-02f, -4.23366241e-02f, 8.81952271e-02f, -2.28134662e-01f, 1.09209932e-01f, -1.14057853e-03f, 8.63796007e-03f, -6.10451289e-02f, 2.00386830e-02f, -1.19163685e-01f,
  -3.26713137e-02f, 1.90854073e-02f, -2.38044709e-02f, 2.04005139e-03f, -2.52777059e-03f, -4.71815420e-03f, -9.67254490e-02f, 1.56059578e-01f, -2.12189164e-02f, -7.49684498e-02f,
  -8.29752162e-02f, -2.83638872e-02f, 2.90905982e-01f, 3.68570089e-02f, -5.78735396e-02f, -1.41888931e-01f, -7.10599241e-04f, 7.34746754e-02f, 9.37752947e-02f, 4.26558331e-02f,
  3.35881561e-02f, -1.31515667e-01f, 2.38162607e-01f, -2.04345863e-02f, 1.48998365e-01f, -2.01911014e-02f, -6.82607666e-02f, 9.40449312e-02f, -3.66103381e-01f, -2.31143236e-01f,
  -3.16044539e-02f, -1.02108652e-02f, 1.13267675e-01f, 3.46714742e-02f, -1.68138057e-01f, -1.57144934e-01f, -3.08749848e-03f, -3.00082490e-02f, -2.57713795e-02f, -6.43975511e-02f,
  -5.30726537e-02f, 1.89328641e-02f, 8.91336054e-02f, 1.05570503e-01f, 3.09880897e-02f, -3.62662748e-02f, 6.42280355e-02f, 2.14284100e-02f, -1.76375523e-01f, -5.00588072e-03f,
  -3.49916406e-02f, 1.53624881e-02f, 5.52461576e-03f, 1.57494411e-01f, 1.37802005e-01f, -3.48936208e-02f, -1.68211997e-01f, 5.02961241e-02f, -2.79240143e-02f, -1.06565785e-04f,
  8.19006041e-02f, 3.78146172e-02f, 2.54500564e-03f, -1.41969994e-02f, 7.40560666e-02f, -2.93994378e-02f, 6.94531342e-03f, -4.21606936e-02f, -6.03330992e-02f, -6.16889074e-02f,
  -8.94267391e-03f, 9.90430713e-02f, 1.99989453e-02f, -1.73456948e-02f, -2.13089809e-02f, 7.29337260e-02f, 4.78746444e-02f, -3.75107825e-02f, -1.71480868e-02f, 4.92465906e-02f,
  -8.04477856e-02f, 5.59355831e-04f, 2.28239014e-03f, 1.21038901e-02f, 7.25302612e-04f, 7.57679716e-02f, 8.79993737e-02f, 5.95949665e-02f, 3.43311280e-02f, 4.02176380e-02f,
  2.58328840e-02f, 1.37931660e-01f, -2.33764555e-02f, -7.28462189e-02f, 6.37162179e-02f, -1.39369518e-01f, -8.45925584e-02f, -1.07034072e-01f, -5.24530821e-02f, 1.62868127e-01f,
  8.68918374e-03f, -2.86641275e-03f, -1.11244336e-01f, 9.17538032e-02f, 6.64411532e-03f, -6.71562254e-02f, -8.50611851e-02f, 7.48870373e-02f, 1.18541874e-01f, 2.81797443e-03f,
  6.95159286e-02f, -1.42075121e-01f, 1.17194012e-01f, 1.73020497e-01f, 2.08809614e-01f, -7.29589537e-02f, -1.30764753e-01f, -1.76220149e-01f, -9.97328684e-02f, 9.72492397e-02f,
  2.11490318e-01f, -1.00159645e-01f, -1.49779851e-02f, -3.44987959e-02f, -1.59884736e-01f, -1.00526817e-01f, -8.29020143e-02f, 1.44435927e-01f, 5.27779646e-02f, -1.04731629e-02f,
  1.24018021e-01f, -9.24319997e-02f, 9.01079029e-02f, -2.11178228e-01f, -1.37189060e-01f, 1.63619980e-01f, -3.67690474e-02f, -1.38245188e-02f, -1.58567309e-01f, -1.64552331e-01f,
  9.33810323e-02f, 4.32964973e-02f, -5.66183925e-02f, 2.74264365e-02f, 2.78094243e-02f, 1.71210632e-01f, 1.34229183e-01f, -1.39572307e-01f, -6.14072159e-02f, 7.55194053e-02f,
  1.87917396e-01f, -2.20395308e-02f, 8.92868191e-02f, -5.74302636e-02f, -2.93621302e-01f, 2.89707631e-02f, -1.21883504e-01f, 5.09542935e-02f, 2.14586109e-01f, 1.05146535e-01f,
  3.93547341e-02f, 1.36711478e-01f, 1.03358932e-01f, -1.75898984e-01f, 4.91907597e-02f, -4.29524370e-02f, 1.18304953e-01f, 2.35576537e-02f, -7.16692284e-02f, -7.85831586e-02f,
  1.74165592e-02f, -6.62133396e-02f, 1.23505451e-01f, -3.35026020e-03f, -3.04968871e-05f, -1.90625712e-02f, -2.78213508e-02f, 1.28242448e-02f, -1.58574712e-02f, 2.13791076e-02f,
  -6.32031411e-02f, -2.16289777e-02f, 1.27947301e-01f, -4.57583815e-02f, 4.69219983e-02f, -1.13239713e-01f, 8.60619247e-02f, 1.08668797e-01f, -3.37676629e-02f, -3.39962021e-02f,
  -3.93516533e-02f, -1.50471441e-02f, 6.32792339e-02f, -6.01132661e-02f, 7.29622543e-02f, -4.41143066e-02f, -2.11527705e-01f, 7.12490221e-03f, 1.71993040e-02f, -4.08756249e-02f,
  1.90410614e-02f, 2.91634221e-02f, -1.75797660e-02f, 2.74030566e-02f, 2.32150629e-02f, 6.12782277e-02f, -4.19117734e-02f, -5.09118177e-02f, 4.11101952e-02f, -1.20689675e-01f,
  6.61887676e-02f, 7.65110701e-02f, -4.03638221e-02f, 1.49072409e-01f, 1.08805180e-01f, -1.67786926e-02f, 9.63064954e-02f, 5.00649922e-02f, 3.08842794e-03f, -9.97032002e-02f,
  -7.28533417e-02f, 1.58858579e-02f, 2.67294012e-02f, -8.30773637e-02f, -3.20981331e-02f, 6.63919491e-06f, -9.87876579e-02f, 2.58041844e-02f, 1.29328430e-01f, 1.79653410e-02f,
  1.30644499e-03f, 1.81692466e-02f, -1.41744465e-02f, -7.37126768e-02f, -2.42370386e-02f, 6.14329278e-02f, 9.32551920e-02f, -5.69658056e-02f, 1.22890577e-01f, 6.72306269e-02f,
  -2.47166026e-02f, 7.85589218e-02f, -6.60435110e-02f, -1.71771348e-01f, -5.07180765e-02f, -1.64747283e-01f, -2.87777018e-02f, -5.32761309e-03f, 8.00022334e-02f, 1.29431055e-03f,
  -7.36107007e-02f, 9.82837845e-03f, -1.74178347e-01f, -1.72915280e-01f, -2.55546309e-02f, 6.44985810e-02f, 5.21688461e-02f, -4.82690670e-02f, 1.17656188e-02f, 7.02928975e-02f,
  -6.94061741e-02f, -2.41071414e-02f, -1.49588510e-01f, -1.31228298e-01f, 6.52049035e-02f, -8.93262997e-02f, -2.75343925e-01f, -1.53727427e-01f, -1.73290446e-01f, 1.14347056e-01f,
  8.97055343e-02f, -6.05575927e-02f, 1.45191491e-01f, 1.45068139e-01f, -3.58382538e-02f, 5.33852633e-03f, -1.10302687e-01f, -2.76070796e-02f, 8.18868130e-02f, 3.11622377e-02f,
  -2.60063291e-01f, -8.21707323e-02f, -2.60504007e-01f, 1.30442202e-01f, -3.39434236e-01f, 7.03806281e-02f, -8.20133537e-02f, 1.07935533e-01f, 4.25846018e-02f, 4.93646823e-02f,
  2.22539842e-01f, -1.19032137e-01f, -3.38204391e-02f, 3.45320590e-02f, -8.27812823e-04f, -7.47652650e-02f, -8.69022831e-02f, 2.35134945e-03f, 6.66157231e-02f, -5.03199883e-02f,
  -5.87483943e-02f, -1.17545366e-01f, 1.03645802e-01f, 1.07640930e-01f, -4.67810929e-02f, -4.48246347e-03f, 1.14928618e-01f, 6.31150976e-02f, -4.14622836e-02f, -2.27150992e-02f,
  -1.28194783e-02f, 1.77067786e-01f, 3.77333537e-02f, 6.97305128e-02f, -2.31496710e-02f, 6.86082896e-03f, -5.36267608e-02f, 1.22218847e-01f, -1.11595996e-01f, 1.65884681e-02f,
  -6.90903142e-02f, -3.67317796e-02f, -8.38202238e-02f, 3.52279507e-02f, -9.30262879e-02f, 6.47238037e-03f, -6.52579814e-02f, 7.72550032e-02f, -1.24884218e-01f, 1.51735082e-01f,
  -8.22443515e-02f, 2.04655901e-02f, -3.86085622e-02f, 1.72096584e-02f, 3.23352963e-02f, -8.25757235e-02f, -5.84153570e-02f, 1.12560811e-02f, 1.19628318e-01f, 6.39492422e-02f,
  3.01186331e-02f, 1.39228061e-01f, 4.29479480e-02f, 5.60431592e-02f, 9.29323360e-02f, 4.64400500e-02f, -1.01095557e-01f, -1.01189114e-01f, -3.97638679e-02f, 2.44584288e-02f,
  5.82991280e-02f, -1.22628115e-01f, -2.53625661e-02f, -1.33529186e-01f, 1.04373813e-01f, 1.18472567e-02f, 1.40246749e-01f, 1.28168747e-01f, 8.04720595e-02f, 1.12010308e-01f,
  -4.55881692e-02f, -1.81233883e-01f, -1.14337420e-02f, 1.33541837e-01f, 5.33808628e-03f, -8.27054530e-02f, 1.13169871e-01f, 3.49799879e-02f, -4.34417017e-02f, 4.88722734e-02f,
  3.30445841e-02f, -5.50148301e-02f, -1.39085516e-01f, -8.95669535e-02f, -1.32194608e-01f, -1.48685232e-01f, 2.05202296e-01f, -1.73432544e-01f, -3.87104154e-02f, -8.83253589e-02f,
  -2.47563183e-01f, -1.22797534e-01f, -1.17791027e-01f, -8.75360444e-02f, -2.57889796e-02f, 8.69263485e-02f, 1.18665196e-01f, -4.00222689e-02f, 8.46440569e-02f, -2.15478703e-01f,
  -1.65502757e-01f, 5.25368229e-02f, 9.18364674e-02f, 4.12056223e-03f, 1.26603572e-03f, 8.54911730e-02f, -8.00097436e-02f, 1.06833220e-01f, 1.30972860e-03f, 2.62431771e-01f,
  -5.31063182e-03f, 7.23000094e-02f, 6.58350587e-02f, 1.01792581e-01f, -1.61929466e-02f, 2.35463604e-01f, 2.37757772e-01f, 9.50521156e-02f, -1.03187218e-01f, -1.73859596e-01f,
  -6.94906563e-02f, 3.71203631e-01f, -2.79713154e-01f, -1.88111067e-01f, 5.76477498e-02f, 1.62858758e-02f, 1.87722161e-01f, 3.37529182e-02f, 1.88066468e-01f, -1.90027118e-01f,
  1.94638558e-02f, -8.09966028e-02f, -9.98638198e-02f, -4.19892035e-02f, 5.56656420e-02f, 4.13668305e-02f, 4.19252226e-03f, -2.87779644e-02f, -3.77938822e-02f, -2.73821428e-02f,
  5.70620410e-02f, 5.55409491e-03f, -8.27141479e-03f, 2.19338965e-02f, -5.20816557e-02f, -7.13739991e-02f, -3.56211625e-02f, -7.03913718e-02f, -1.66903958e-02f, 1.56223968e-01f,
  -7.01426044e-02f, -8.39096233e-02f, 3.80001515e-02f, 1.00852333e-01f, -4.07393818e-04f, -3.97324264e-02f, 6.79718256e-02f, -2.64608394e-03f, 1.28812671e-01f, 7.70748183e-02f,
  -1.29872849e-02f, 1.07564114e-01f, -5.14621884e-02f, 2.59923600e-02f, 4.93389294e-02f, -2.78594461e-03f, 7.78659061e-03f, -9.11359396e-03f, -7.17327371e-02f, -1.96805783e-02f,
  -6.59333244e-02f, -1.25176415e-01f, -4.16246764e-02f, -5.68581261e-02f, -9.20321885e-03f, 6.35201409e-02f, -8.21933597e-02f, 1.01280771e-01f, 3.93679589e-02f, -2.43805926e-02f,
  -1.28119871e-01f, 1.07064378e-03f, -1.86096912e-03f, -5.92080355e-02f, -5.21663204e-02f, -2.69297441e-03f, 5.35817817e-02f, -3.68454680e-02f, -1.80400312e-01f, -7.71419108e-02f,
  1.09906718e-02f, 8.95358995e-02f, 4.56214808e-02f, 7.31827132e-03f, -4.67807837e-02f, 3.56864855e-02f, 8.31524804e-02f, 7.05468729e-02f, -9.61124822e-02f, 7.80994520e-02f,
  6.74018497e-03f, -4.97098602e-02f, 1.15956396e-01f, -4.86418940e-02f, -6.38892278e-02f, -3.65930237e-02f, -1.44381020e-02f, -5.23321331e-02f, 3.73201296e-02f, -1.95162699e-01f,
  1.20321557e-01f, -2.25035045e-02f, -5.42516038e-02f, -2.89027318e-02f, 2.83214473e-03f, -4.55439985e-02f, -3.06634028e-02f, 5.45039698e-02f, 5.13419090e-03f, 4.41861041e-02f,
  -5.55018783e-02f, 2.72119418e-02f, 1.03016637e-01f, -1.03020988e-01f, -2.18719449e-02f, 7.13627934e-02f, -5.14654927e-02f, 2.44157612e-02f, -2.70902626e-02f, 1.29440753e-02f,
  -4.70664836e-02f, 2.59390455e-02f, 1.24217467e-02f, -7.18369707e-02f, 7.62195811e-02f, 1.41729131e-01f, 5.06418869e-02f, 5.48594743e-02f, -1.17173761e-01f, -7.06152804e-03f,
  1.27564177e-01f, -9.50590372e-02f, -1.16195977e-01f, 1.19813837e-01f, 8.92281756e-02f, -1.61981910e-01f, 1.12182662e-01f, 1.04208894e-01f, -7.36902505e-02f, 1.07805476e-01f,
  1.45444393e-01f, -1.00927599e-01f, 1.94387048e-01f, -4.38208170e-02f, 3.08887046e-02f, -6.63508251e-02f, -4.05480176e-01f, -7.64127413e-04f, 1.21458098e-01f, 2.98025329e-02f,
  -6.84524551e-02f, -8.59281570e-02f, -1.04842626e-01f, 4.18915264e-02f, 1.03714533e-01f, 3.98399718e-02f, -5.04313558e-02f, -5.65355234e-02f, 5.26846247e-03f, 1.33721545e-01f,
  -4.75042909e-02f, -3.97253670e-02f, -6.21531382e-02f, 2.44740769e-02f, -1.64482832e-01f, 4.77566123e-02f, 3.92362066e-02f, 9.22659934e-02f, 9.66588408e-03f, 3.69077735e-02f,
  7.56687522e-02f, -4.07614894e-02f, -8.08549970e-02f, -6.59965351e-02f, 1.13879819e-03f, -1.66319042e-01f, -8.77538472e-02f, -8.77097026e-02f, 1.10666426e-02f, -9.11771208e-02f,
  4.98113222e-02f, 6.36651516e-02f, 4.19629738e-02f, 1.15797639e-01f, -1.85198728e-02f, 4.51685302e-02f, -8.04055184e-02f, -6.81048334e-02f, -5.16621210e-02f, 3.43719311e-02f,
  -2.58768760e-02f, -1.05439601e-02f, -3.72702628e-02f, -1.71574745e-02f, 8.10087919e-02f, -3.52954119e-02f, 7.01785833e-02f, -5.71431108e-02f, -2.05926318e-02f, 1.98387597e-02f,
  6.28409088e-02f, -1.18439741e-01f, -1.44962609e-01f, 3.14831705e-04f, -1.52993808e-02f, -5.41488528e-02f, -2.02230692e-01f, 1.23140467e-02f, 7.47545287e-02f, -1.44673176e-02f,
  1.50528550e-01f, 6.67365491e-02f, 8.42130184e-02f, 9.01522860e-03f, 7.18166232e-02f, 1.35734379e-01f, -7.94561729e-02f, 1.28299713e-01f, 9.91317481e-02f, 7.29955882e-02f,
  -6.85632043e-03f, -3.35988142e-02f, -2.52937675e-02f, 7.34096393e-02f, 2.47534859e-04f, -1.17778696e-01f, -6.22229325e-03f, 2.77268067e-02f, 8.26360732e-02f, 1.07084535e-01f,
  -2.13784464e-02f, 2.72009522e-02f, -1.31082058e-01f, 8.32883790e-02f, 2.34611444e-02f, -2.99150888e-02f, 5.73445819e-02f, 6.15835842e-03f, -1.02469288e-01f, 7.30574876e-02f,
  -5.55186048e-02f, 5.76593587e-03f, 3.75282057e-02f, 1.44152762e-02f, -3.61773744e-03f, -2.78833210e-02f, -8.25339407e-02f, 1.73387632e-01f, 2.28219349e-02f, -1.34515762e-01f,
  1.33595020e-01f, 8.18669721e-02f, -1.04543887e-01f, 9.94341299e-02f, -1.09055348e-01f, -7.04954416e-02f, 2.36298027e-03f, -1.21320207e-02f, 8.39237198e-02f, 1.53208658e-01f,
  -1.24342656e-02f, 4.16860823e-03f, 1.39181629e-01f, 1.28440812e-01f, -2.59843796e-01f, -2.44974419e-01f, 3.57325584e-01f, -1.47592038e-01f, 1.11457482e-01f, 4.39186245e-02f,
  4.66803387e-02f, 7.92390332e-02f, 3.02221388e-01f, -9.65673253e-02f, 2.24099919e-01f, 4.86182533e-02f, 7.34370425e-02f, -1.87869743e-03f, -1.01987928e-01f, -8.54927301e-02f,
  -2.72781681e-02f, 9.58929360e-02f, -1.51546567e-03f, -3.36229289e-03f, 1.43442834e-02f, -8.69889408e-02f, 1.24196541e-02f, -3.55717679e-03f, 1.03135310e-01f, 4.21874970e-02f,
  1.14959516e-02f, 1.36776790e-02f, -3.77965043e-03f, 7.08804503e-02f, 5.84916361e-02f, 2.72291768e-02f, 3.80736962e-02f, 5.52415699e-02f, 2.78032869e-02f, 6.96593150e-02f,
  2.43191533e-02f, -1.35000423e-01f, 6.51183352e-02f, -5.48202284e-02f, 1.35108367e-01f, -7.99320117e-02f, -3.19494158e-02f, 1.48956133e-02f, 4.39452380e-03f, 1.02734074e-01f,
  -4.38885018e-02f, -9.66689587e-02f, 4.59600836e-02f, 7.60071054e-02f, 9.94885266e-02f, -2.54749209e-02f, -5.89358211e-02f, 1.97313540e-03f, -1.03937060e-01f, 4.14346568e-02f,
  -1.22553051e-01f, -7.29057342e-02f, -2.18186844e-02f, 2.99971784e-03f, 8.25730041e-02f, -3.22348475e-02f, -1.20429091e-01f, -2.06041574e-01f, 4.04209346e-02f, 2.90804077e-03f,
  -4.27805167e-03f, -1.14266820e-01f, 4.88777459e-02f, 8.23138356e-02f, -3.90071906e-02f, -1.07613198e-01f, -5.32471910e-02f, -2.85594463e-02f, 5.88704273e-02f, 1.64439604e-02f,
  1.02042265e-01f, 2.82378420e-02f, 1.17651947e-01f, 6.09174035e-02f, 4.73373123e-02f, 4.38593775e-02f, 3.93029563e-02f, -5.94430091e-03f, 1.62250139e-02f, -1.78895667e-01f,
  -2.77483404e-01f, 1.12583742e-01f, 3.74886915e-02f, -1.65071920e-01f, 1.90660963e-03f, 4.50349692e-03f, 8.05063248e-02f, -1.21071845e-01f, -6.93721399e-02f, -2.01742530e-01f,
  8.98061544e-02f, -1.36229649e-01f, 3.52917239e-02f, 1.45612553e-01f, 7.55530270e-03f, 4.20277268e-02f, -6.61711246e-02f, 6.74091885e-03f, 1.36081278e-01f, 5.92412949e-02f,
  -4.65883501e-02f, -2.33027656e-02f, -3.77003811e-02f, 5.02415560e-02f, 1.20078884e-02f, -8.47682077e-03f, -1.10764243e-01f, -6.37038276e-02f, 1.74589623e-02f, 5.89774512e-02f,
  5.70424423e-02f, 1.23347215e-01f, 2.28572190e-02f, -1.52964696e-01f, -1.53834879e-01f, -3.72409672e-02f, 2.32303873e-01f, 7.63232857e-02f, -9.23998363e-04f, 1.26384556e-01f,
  8.30459520e-02f, -4.66341302e-02f, 5.26405610e-02f, 1.44064292e-01f, -4.07585129e-02f, 2.79637933e-01f, 3.10110040e-02f, -1.19257137e-01f, -1.03896800e-02f, -6.14498220e-02f,
  1.94073662e-01f, -1.62216440e-01f, -1.16602086e-01f, -1.54878646e-01f, 4.22352888e-02f, -8.10176209e-02f, 1.42093956e-01f, -2.42560003e-02f, 3.51488739e-02f, -7.77800521e-03f,
  7.45095760e-02f, -3.67546007e-02f, 2.64441166e-02f, 6.33923262e-02f, 5.76701984e-02f, -1.44200940e-02f, 1.09280884e-01f, -1.20625924e-02f, 5.35873249e-02f, -1.38278436e-02f,
  5.93010522e-02f, 3.37178935e-03f, 1.80959739e-02f, -1.26931250e-01f, -1.19267981e-02f, 5.59128933e-02f, -1.01015657e-01f, -9.89815593e-02f, 9.74011868e-02f, -7.64882714e-02f,
  -5.95158488e-02f, -7.74416402e-02f, 1.35396570e-02f, -1.11149177e-01f, -7.07354248e-02f, -3.70146707e-02f, 3.89260650e-02f, 6.15076236e-02f, 7.17126280e-02f, -1.36698755e-02f,
  1.21475883e-01f, -1.05417073e-01f, 1.20333716e-01f, -5.58376051e-02f, -6.69185221e-02f, 3.18717360e-02f, 3.59762162e-02f, 2.03959011e-02f, -5.15909167e-03f, -1.62756350e-02f,
  -4.32096273e-02f, -1.51940845e-02f, -4.83574383e-02f, 3.17278802e-02f, -2.66731363e-02f, -7.38926977e-02f, 9.87120271e-02f, -2.02307850e-02f, 4.17553261e-02f, 1.68881621e-02f,
  -2.81466520e-04f, 1.04300149e-01f, 6.83688372e-02f, -1.94859633e-03f, 2.85818009e-03f, 4.90482934e-02f, -7.08724260e-02f, 3.06807961e-02f, -9.03752446e-02f, 2.43016891e-02f,
  1.26453683e-01f, -1.08961752e-02f, -6.24513775e-02f, -1.34963155e-01f, 6.03230968e-02f, -4.53464314e-02f, -4.60643694e-02f, -1.25058666e-01f, -5.37017323e-02f, 4.73692566e-02f,
  2.11054042e-01f, -9.87854972e-03f, -5.04757278e-02f, 1.51197672e-01f, 2.42410880e-02f, -2.54468024e-02f, 9.15997550e-02f, -1.00029744e-01f, 1.20172590e-01f, -2.17083320e-02f,
  -6.57265186e-02f, 4.58231308e-02f, -3.11974231e-02f, -1.15583546e-01f, 4.13798094e-02f, -5.76862320e-02f, 7.25229383e-02f, 6.67963773e-02f, -9.58126187e-02f, -7.76374638e-02f,
  -1.33390846e-02f, -8.81727114e-02f, 1.27693824e-02f, -1.47438511e-01f, 3.71056907e-02f, 1.14495851e-01f, -1.61646709e-01f, -5.14768921e-02f, 9.25224572e-02f, -1.26238704e-01f,
  -1.01451837e-01f, 1.42930552e-01f, 1.05293415e-01f, -4.95984443e-02f, -1.71897992e-01f, 6.26170710e-02f, -3.56051996e-02f, 2.74691600e-02f, 3.05739734e-02f, 1.94513220e-02f,
  1.33719176e-01f, 1.20958470e-01f, -3.35468724e-02f, 2.73107260e-01f, -2.35345393e-01f, 5.24891466e-02f, 2.03341052e-01f, 2.01501802e-01f, -1.85379848e-01f, 1.17638357e-01f,
  -1.42110527e-01f, 1.14490628e-01f, -3.40369493e-02f, -1.33459158e-02f, -4.53495532e-02f, -1.29903639e-02f, 1.33824542e-01f, -2.20828075e-02f, 1.07804453e-02f, 1.91150140e-03f,
  1.85541883e-02f, -1.90207064e-02f, 3.63345593e-02f, -6.01466792e-03f, -6.70281574e-02f, 5.59345745e-02f, 6.63469061e-02f, -3.30099873e-02f, 8.07468873e-03f, 4.26713489e-02f,
  7.20827207e-02f, 7.80473114e-04f, -1.57120191e-02f, -4.32945862e-02f, -9.57254693e-03f, -3.34712118e-02f, -2.68549491e-02f, 3.08718570e-02f, -2.31222827e-02f, -1.67074464e-02f,
  4.27343175e-02f, -4.84413654e-02f, 3.10225226e-02f, -1.88391078e-02f, -6.82650879e-02f, -7.92175997e-03f, -4.21295427e-02f, 1.14506312e-01f, -4.11966257e-02f, -4.95047122e-02f,
  -7.72229210e-02f, -7.82109052e-02f, -1.09045655e-01f, 4.16235719e-03f, -5.67747578e-02f, -5.46992309e-02f, -1.41189927e-02f, -1.29351377e-01f, 1.85921136e-02f, 3.62421535e-02f,
  -6.25447854e-02f, -4.30771559e-02f, -2.32690386e-02f, -1.53186629e-02f, 1.04506396e-01f, 1.81043401e-01f, -1.58212911e-02f, 7.56155932e-03f, -5.74618839e-02f, 1.13359481e-01f,
  -2.79604066e-02f, 2.67303772e-02f, -5.65361157e-02f, -3.58281918e-02f, 5.66963777e-02f, 8.20528790e-02f, 1.03542022e-01f, -2.33810563e-02f, 6.64826930e-02f, 1.03431001e-01f,
  8.37931558e-02f, -1.48471892e-01f, -1.02336824e-01f, -4.41733077e-02f, 1.21562779e-01f, -1.18717805e-01f, -1.46107242e-01f, -2.31957193e-02f, 1.63676925e-02f, 1.09399952e-01f,
  -2.09674723e-02f, 1.14208907e-01f, 1.47904098e-01f, -9.98453051e-03f, 3.91222723e-02f, -5.86321317e-02f, 8.10730159e-02f, -1.70361176e-02f, 4.66733472e-03f, -6.20805547e-02f,
  -7.50199258e-02f, -1.90721489e-02f, 3.72310542e-02f, -1.18741572e-01f, 1.37710690e-01f, 4.88569103e-02f, -1.97494030e-02f, 2.46550199e-02f, 5.92680424e-02f, -7.99454469e-03f,
  -5.61129786e-02f, 6.50099888e-02f, 1.97350159e-02f, 1.41627539e-03f, 6.46389574e-02f, -1.13016903e-01f, -7.89663419e-02f, -1.50405928e-01f, 1.83554381e-01f, 1.57307252e-01f,
  8.17082003e-02f, 5.67891002e-02f, -6.11933917e-02f, -1.00064345e-01f, -1.02277532e-01f, 1.22345202e-01f, -5.44760376e-02f, -9.14320648e-02f, -1.03790998e-01f, 3.52999456e-02f,
  2.81443328e-01f, 1.43713713e-01f, -3.52426874e-03f, -2.47555915e-02f, 7.21341372e-02f, 1.41933396e-01f, -5.08152656e-02f, -2.11798847e-02f, -1.58168197e-01f, 6.06644861e-02f,
  -4.36435267e-03f, 1.26260323e-02f, -2.95395125e-02f, 8.57361481e-02f, 8.57801735e-02f, 1.22176424e-01f, -8.98933411e-02f, 6.61729574e-02f, -4.09917049e-02f, -3.24386696e-04f,
  8.39401186e-02f, -6.51172996e-02f, -1.56419590e-01f, 1.17248282e-01f, -3.48994173e-02f, -1.69680323e-02f, 3.43424305e-02f, -2.70688292e-02f, -4.27701324e-03f, 6.15865970e-03f,
  -4.25124764e-02f, -9.00869370e-02f, 9.45261121e-02f, -6.30793348e-02f, 3.17739733e-02f, -6.21613041e-02f, -4.82750684e-02f, -2.96440013e-02f, -9.43580046e-02f, 1.09399535e-01f,
  1.25387385e-02f, 1.21342167e-01f, 1.46623880e-01f, 7.62223676e-02f, 4.94743064e-02f, 1.76598012e-01f, -8.13065376e-03f, 3.97811830e-02f, -3.49002406e-02f, -3.11981179e-02f,
  4.76911142e-02f, 6.63733855e-02f, 4.83451635e-02f, -6.38650730e-02f, -1.49028808e-01f, -5.18162996e-02f, 3.44615914e-02f, -1.58997402e-02f, 6.20662533e-02f, -1.00376062e-01f,
  1.08229212e-01f, -7.93294534e-02f, -6.66117072e-02f, -1.70208141e-01f, -1.40064899e-02f, 1.83236852e-01f, 1.50367588e-01f, -1.02587812e-01f, 3.69154960e-02f, 1.11023627e-01f,
  -3.07247452e-02f, -8.85378867e-02f, 6.47174846e-03f, -5.42044304e-02f, -6.54103756e-02f, -3.27902921e-02f, 8.30374360e-02f, -4.46315333e-02f, 5.78367375e-02f, 7.01406300e-02f,
  9.14544798e-03f, 4.87885252e-02f, -1.99583191e-02f, 2.00893283e-01f, -1.99550744e-02f, -2.77821600e-01f, -1.15001269e-01f, -1.55456126e-01f, -1.90560725e-02f, 1.48809180e-01f,
  6.18059076e-02f, -1.58566117e-01f, 9.66166183e-02f, 2.44615570e-01f, 8.52226540e-02f, 7.09727332e-02f, 2.21912891e-01f, -1.49678215e-01f, 2.02096343e-01f, -6.48696348e-02f,
  7.88588747e-02f, 1.51283652e-01f, -8.43679756e-02f, -1.61960889e-02f, -3.29068825e-02f, 4.29979376e-02f, -4.48608883e-02f, 1.89665973e-01f, 6.44524395e-02f, 2.34868973e-02f,
  -7.17032254e-02f, -4.19754535e-02f, 1.35128230e-01f, -9.08652917e-02f, 8.51431563e-02f, 1.94162056e-02f, -2.52617121e-01f, -2.54411194e-02f, -2.80931611e-02f, 1.66259408e-02f,
  7.75863752e-02f, -7.32826367e-02f, -3.01244780e-02f, -2.48340935e-01f, 1.72066033e-01f, -1.35839000e-01f, 1.43081352e-01f, 9.38278884e-02f, -1.75333709e-01f, -2.14371368e-01f,
  4.46195193e-02f, 4.76217344e-02f, 1.18028605e-02f, 4.03930955e-02f, -5.10182008e-02f, 1.24162734e-01f, -1.93324059e-01f, -8.01724419e-02f, 3.48774791e-02f, 6.91275671e-02f,
  9.84334201e-02f, 7.36256093e-02f, -5.77047132e-02f, 5.49093895e-02f, 8.24883506e-02f, 3.87156233e-02f, 2.13606078e-02f, 1.14886537e-01f, 1.50748447e-01f, -4.97268997e-02f,
  9.81791317e-03f, -5.46921119e-02f, 7.81113356e-02f, 1.19314447e-01f, 8.25081617e-02f, -5.94226271e-02f, 2.56631486e-02f, -5.76909296e-02f, 3.21709588e-02f, -1.52524952e-02f,
  -8.60002339e-02f, -4.87486552e-03f, -5.75121082e-02f, 1.37553900e-01f, 1.07147686e-01f, 2.48398893e-02f, 3.25298831e-02f, 1.30245402e-01f, -1.19372509e-01f, -1.10133648e-01f,
  -1.72885478e-01f, 3.11385468e-02f, 1.43237645e-02f, 1.54439390e-01f, 8.04467779e-03f, 2.99419090e-02f, -6.15854487e-02f, 1.31376177e-01f, 6.38732910e-02f, -1.17735445e-01f,
  2.05923002e-02f, -1.12156710e-02f, 9.35750257e-04f, 1.04893044e-01f, 1.66181669e-01f, 6.78276923e-03f, 4.24732156e-02f, -4.33843844e-02f, -1.54558755e-02f, 9.13593844e-02f,
  9.81538892e-02f, 3.22655998e-02f, 4.25594952e-03f, 8.04240108e-02f, -5.28011248e-02f, 4.19770218e-02f, 8.55061337e-02f, -3.93557921e-03f, 6.92942506e-03f, 3.57274674e-02f,
  -4.69797887e-02f, -1.46773206e-02f, 4.36059460e-02f, -2.09985320e-02f, 2.90874485e-02f, -7.12693036e-02f, 1.04404084e-01f, -1.76276445e-01f, 2.31833290e-02f, -2.95806602e-02f,
  1.71644986e-02f, -7.46486858e-02f, 1.17328621e-01f, -4.87339534e-02f, -1.20169200e-01f, 6.75554425e-02f, -1.06786519e-01f, 1.60980523e-01f, 6.65066913e-02f, -1.68068353e-02f,
  -2.10770010e-03f, -2.58244891e-02f, -4.40169536e-02f, -7.40048587e-02f, -1.19068563e-01f, -9.63210128e-03f, -5.14487512e-02f, 2.60975864e-02f, -9.62757096e-02f, -1.13060802e-01f,
  2.58594216e-03f, -8.73320326e-02f, -3.32335941e-02f, -1.46642193e-01f, -2.54369862e-02f, -1.07473128e-01f, 8.69160667e-02f, -8.95625874e-02f, 1.00017458e-01f, -1.04994729e-01f,
  8.87785405e-02f, 6.90786317e-02f, -9.79421735e-02f, -4.24980856e-02f, 3.00754458e-01f, -2.42303777e-02f, -5.71286306e-02f, 1.01078153e-01f, -1.72843114e-01f, 6.04258627e-02f,
  8.69201794e-02f, 5.38813360e-02f, -6.53196946e-02f, -4.67487704e-03f, -9.31523293e-02f, 9.37369652e-03f, 2.38373026e-01f, 2.64485598e-01f, 2.21553892e-01f, -3.29484552e-01f,
  7.23770037e-02f, -1.02907769e-01f, -2.80983709e-02f, 1.11369878e-01f, -1.92225531e-01f, -6.84188083e-02f, -5.56110498e-03f, -1.29943546e-02f, 2.38984209e-02f, -8.00908729e-02f,
  5.52415140e-02f, -5.57132438e-02f, 1.17865823e-01f, -1.96349453e-02f, 5.80743281e-03f, 1.21297976e-02f, 1.71952266e-02f, -5.71804866e-02f, 8.97101685e-02f, 1.12725079e-01f,
  -4.44512703e-02f, -2.62981877e-02f, 8.60366970e-02f, -7.90511742e-02f, 5.21362610e-02f, 1.17209971e-01f, 3.36177722e-02f, -3.84616293e-02f, -2.65839305e-02f, -8.80765393e-02f,
  -9.87071916e-02f, -3.04914881e-02f, -6.27222136e-02f, 5.64844236e-02f, -2.00472996e-02f, 1.03066057e-01f, -7.96661377e-02f, 5.25758304e-02f, -1.77865308e-02f, -7.43228942e-02f,
  -7.04554701e-03f, -6.94295093e-02f, 3.29241380e-02f, -1.06621899e-01f, 2.28157938e-02f, -9.96076036e-03f, 7.85534009e-02f, -4.04795669e-02f, 2.05361359e-02f, -6.86246082e-02f,
  4.28569242e-02f, 2.87198164e-02f, -2.32239291e-02f, -9.98040102e-03f, 2.62311026e-02f, -4.88838181e-03f, -6.37730658e-02f, 6.41499683e-02f, -1.04112193e-01f, 3.27075861e-04f,
  4.56478670e-02f, 1.42283499e-01f, 5.17495582e-03f, -8.50273222e-02f, 4.92148623e-02f, 1.18095107e-01f, -4.25068215e-02f, 4.44133617e-02f, -1.30417347e-01f, -3.85507271e-02f,
  -4.67832424e-02f, 6.14314154e-02f, -1.60006322e-02f, -1.54215768e-01f, -1.15856849e-01f, 5.39572649e-02f, -6.00651428e-02f, -1.44154370e-01f, -1.84437111e-02f, 7.50371441e-02f,
  -2.07915250e-02f, -6.95599988e-03f, 1.36973169e-02f, -1.46954227e-02f, 1.01757802e-01f, 1.55140102e-01f, -3.61620262e-02f, -1.69709772e-01f, -2.43398584e-02f, 1.25407353e-01f,
  -4.36702892e-02f, 3.47688198e-02f, 1.42302603e-01f, 1.00357354e-01f, 1.59162566e-01f, -4.99624945e-02f, 8.25239867e-02f, -1.82586402e-01f, -9.29539800e-02f, 5.06644137e-02f,
  1.12795308e-02f, -2.50711348e-02f, 5.97418211e-02f, 6.86325505e-02f, -1.28648713e-01f, 8.39809179e-02f, -4.27273959e-02f, 4.97710109e-02f, 1.71634741e-02f, -2.78840940e-02f,
  7.22358301e-02f, -1.40720263e-01f, 2.03332514e-01f, 1.47055790e-01f, 7.98918121e-03f, 1.67385675e-02f, -1.81135163e-01f, -1.25719145e-01f, 3.39927226e-02f, -2.47593448e-02f,
  3.01603097e-02f, -1.87923647e-02f, 1.62261575e-01f, -1.46716952e-01f, -8.12783837e-02f, -8.45890939e-02f, 4.53274399e-02f, 1.52215615e-01f, 8.83666351e-02f, -1.64718181e-01f,
  -9.91361812e-02f, 1.75389901e-01f, -6.79613277e-02f, 8.83613005e-02f, -1.35215178e-01f, 2.04530209e-02f, 4.91822362e-02f, -1.74423959e-02f, -1.01516008e-01f, -6.94053769e-02f,
  -9.81968939e-02f, 6.55048788e-02f, -2.94198748e-02f, 1.73783358e-02f, -3.61871943e-02f, -1.25081211e-01f, 3.41575928e-02f, -5.50682433e-02f, 4.57611270e-02f, -4.85887192e-02f,
  -2.90612597e-02f, 5.38966767e-02f, -7.08533600e-02f, -1.62616950e-02f, 4.23305742e-02f, -1.22808199e-02f, -6.68024346e-02f, -2.02900216e-01f, 1.55108320e-02f, -1.29497796e-01f,
  -2.46710386e-02f, 7.36638084e-02f, -9.35540497e-02f, -3.80460769e-02f, 8.86933785e-03f, -4.92561236e-02f, 3.91036301e-04f, -7.86858350e-02f, 1.69595163e-02f, -5.35682328e-02f,
  -3.75596583e-02f, -9.83078852e-02f, 4.67150882e-02f, 6.11014664e-02f, -1.15095206e-01f, 2.49254275e-02f, 4.89867926e-02f, -5.33218831e-02f, -5.79935759e-02f, 6.94961986e-03f,
  5.70756607e-02f, 8.18357524e-03f, 5.42997383e-02f, 5.58165461e-02f, 3.09811742e-03f, 1.68276038e-02f, -7.91130289e-02f, -3.58939208e-02f, 4.05071042e-02f, 7.54296780e-02f,
  4.46135625e-02f, -8.75294730e-02f, 1.67342618e-01f, 1.38081878e-01f, 1.16066327e-02f, -1.06252037e-01f, -1.03783302e-01f, -1.26125038e-01f, -1.08175285e-01f, 9.98891070e-02f,
  -5.42323664e-02f, -5.61045855e-02f, -3.13167498e-02f, 6.43736348e-02f, -7.03649595e-02f, 1.35718361e-01f, -1.12052411e-01f, 1.37520842e-02f, -8.22405368e-02f, -4.12709974e-02f,
  3.67504358e-02f, -5.70303835e-02f, -5.87323979e-02f, -2.87383888e-02f, -1.31519781e-02f, -9.18852091e-02f, -2.33147033e-02f, 4.54553813e-02f, 1.95419624e-01f, 5.40393218e-03f,
  9.04743224e-02f, 1.66828372e-02f, 1.53718498e-02f, -1.45494938e-02f, 1.32495761e-01f, 6.34534210e-02f, -1.69379152e-02f, -1.45821301e-02f, -1.49046956e-02f, -4.76800427e-02f,
  1.09652072e-01f, 5.06599508e-02f, -1.44733407e-03f, 9.50554665e-03f, -3.26162577e-02f, 6.20357879e-02f, -2.14290172e-01f, -1.32719159e-01f, 5.25335222e-02f, 3.06487661e-02f,
  -2.00993866e-01f, -1.03861630e-01f, 1.39616400e-01f, -1.44367412e-01f, -1.00188136e-01f, 5.69638498e-02f, -3.32126655e-02f, -8.81199911e-02f, 1.83292124e-02f, 2.65194532e-02f,
  1.21220406e-02f, 1.09049372e-01f, -2.31826290e-01f, -1.50957689e-01f, -2.68152446e-01f, 3.61023732e-02f, -6.78740740e-02f, 1.33791029e-01f, -1.14648707e-01f, 4.24440159e-03f,
  4.65028808e-02f, 9.63660926e-02f, 5.44346459e-02f, 3.65698934e-02f, 2.86772512e-02f, -1.49619743e-01f, 1.55927479e-01f, 4.10845596e-03f, 1.17407097e-02f, 4.18552123e-02f,
  -1.10977627e-01f, -1.97385494e-02f, -5.19633200e-03f, -9.14918780e-02f, 1.25359997e-01f, 1.16887033e-01f, -9.78404749e-03f, 8.30524489e-02f, 2.40373462e-02f, -9.47949439e-02f,
  -1.45397857e-02f, 3.32073122e-02f, 2.85317339e-02f, 4.41931784e-02f, 8.02759007e-02f, -8.16718861e-02f, 5.62148839e-02f, 3.22508365e-02f, -7.26827160e-02f, 4.76507619e-02f,
  4.36638435e-03f, -3.61799039e-02f, 7.92585537e-02f, -4.66188826e-02f, 4.31648567e-02f, 1.11574598e-01f, 4.12624404e-02f, -3.64066176e-02f, -2.97336783e-02f, -1.80274025e-02f,
  -5.25634885e-02f, 5.31440899e-02f, -4.46325354e-02f, -9.70152840e-02f, -5.06668091e-02f, -9.94704757e-03f, -7.06858635e-02f, -4.18514833e-02f, -2.61856586e-01f, -9.51717123e-02f,
  -4.49502841e-02f, 9.12757441e-02f, -1.30406963e-02f, -3.31656523e-02f, -6.66617826e-02f, -1.87069431e-01f, 1.33203834e-01f, 5.45720682e-02f, -5.55663146e-02f, -7.31876716e-02f,
  1.42788813e-01f, 9.82190203e-03f, 3.20199877e-02f, 5.67802377e-02f, -8.26885086e-03f, -6.80909380e-02f, -1.14905231e-01f, -1.95327047e-02f, 1.52009591e-01f, 7.63626620e-02f,
  4.44503091e-02f, 4.72685397e-02f, -1.06114715e-01f, 1.14769205e-01f, -7.89607093e-02f, 1.45780414e-01f, -9.42485705e-02f, -1.93625689e-01f, -7.54685998e-02f, -1.05807260e-01f,
  1.44556850e-01f, 7.33468728e-03f, 4.95897233e-02f, -1.34089604e-01f, -7.79138040e-03f, 1.48590833e-01f, 6.95620030e-02f, -6.80018663e-02f, 4.28471118e-02f, -1.93140674e-02f,
  7.67422467e-02f, 7.33466223e-02f, -5.81370182e-02f, 1.34699345e-01f, -1.79616250e-02f, 6.26524389e-02f, 5.08894287e-02f, -7.44144022e-02f, 1.48420939e-02f, 1.34723663e-01f,
  1.35840345e-02f, 3.25010903e-02f, -3.03519005e-03f, 8.66117626e-02f, -1.15764260e-01f, -1.16217442e-01f, 1.22915730e-01f, -3.31789441e-02f, -3.32873687e-02f, -7.70869479e-02f,
  -1.20175049e-01f, 4.46294248e-02f, -6.65134192e-02f, 1.22493505e-03f, 8.91343132e-02f, -2.32510716e-01f, 1.55414104e-01f, -1.20769605e-01f, 1.86764210e-01f, 8.82547498e-02f,
  -1.92394808e-01f, -9.18608308e-02f, -1.30411342e-01f, -6.95458287e-03f, -8.11698139e-02f, 1.78989455e-01f, -2.14724213e-01f, 7.50223100e-02f, -2.62253106e-01f, -1.88571885e-01f,
  -4.67456616e-02f, -8.75690803e-02f, 5.66217341e-02f, -4.79144827e-02f, -5.05380593e-02f, -9.20939073e-02f, 9.31355208e-02f, -3.24449949e-02f, 8.78223106e-02f, 3.41109037e-02f,
  4.88687828e-02f, 5.36627434e-02f, 4.97714728e-02f, -2.17319913e-02f, 1.66845229e-02f, -3.45698372e-02f, -3.77093777e-02f, -5.14592789e-02f, 6.75431592e-03f, 1.31895706e-01f,
  3.10492553e-02f, 4.60322611e-02f, -1.61479652e-01f, 3.73814665e-02f, 1.02183990e-01f, 8.27224553e-03f, -4.91533093e-02f, 4.88079228e-02f, 1.45177528e-01f, 6.25308976e-02f,
  -5.46540432e-02f, 4.36553359e-02f, -2.12111682e-01f, -5.87685220e-02f, -6.44265413e-02f, 2.41628606e-02f, -6.80533350e-02f, 8.29357207e-02f, -7.69075602e-02f, 9.26292967e-03f,
  2.24858690e-02f, -2.56972555e-02f, 4.82654981e-02f, 6.62454963e-03f, 5.52537180e-02f, 1.88144390e-02f, 4.97692488e-02f, 2.04949468e-01f, -9.68811885e-02f, -2.58958968e-03f,
  -9.77601036e-02f, 3.72019666e-03f, 3.62791084e-02f, 1.14679426e-01f, 1.34325065e-02f, -6.79145381e-02f, 7.02868849e-02f, 3.85227688e-02f, 2.22905204e-02f, -2.94474065e-02f,
  -4.94724028e-02f, 5.96838407e-02f, -8.75933021e-02f, 6.39301986e-02f, 5.05198874e-02f, 9.21457559e-02f, 3.74693647e-02f, -7.19395503e-02f, -7.24936053e-02f, -1.29656002e-01f,
  -7.08201081e-02f, -5.81216775e-02f, 9.57109481e-02f, -7.91464075e-02f, -1.15849935e-01f, 2.00531811e-01f, 1.39362484e-01f, -9.99862608e-03f, -1.94851905e-02f, -6.99550062e-02f,
  -3.25873867e-02f, -1.11799322e-01f, -4.80226763e-02f, 2.24506320e-03f, 7.19900951e-02f, -1.47783726e-01f, -1.09910496e-01f, 2.06561983e-01f, -2.31767446e-01f, -1.59664780e-01f,
  9.65686291e-02f, -1.63956597e-01f, 1.15022287e-01f, 6.21087104e-02f, -6.01434410e-02f, -5.99872367e-03f, 6.63251728e-02f, -2.48481333e-01f, -1.79884002e-01f, -6.58439472e-02f,
  6.21720888e-02f, 6.46824166e-02f, -2.12978244e-01f, -8.26977286e-03f, 1.61474034e-01f, -7.13180471e-03f, 2.11072654e-01f, 9.09728184e-02f, -1.20505601e-01f, -1.80835333e-02f,
  -8.49824250e-02f, -3.51289771e-02f, -2.77154474e-03f, 2.34720781e-01f, 1.92980561e-02f, -1.81722213e-02f, 1.38830289e-01f, 6.29630014e-02f, -8.11764896e-02f, 2.42765382e-01f,
  -2.79416472e-01f, -8.42728764e-02f, 2.06785157e-01f, -1.18983723e-01f, -7.85791427e-02f, -5.25973998e-02f, 6.69186041e-02f, 7.78505877e-02f, 1.30682096e-01f, -1.13942623e-01f,
  -2.69006807e-02f, -1.76061820e-02f, 8.98900777e-02f, 7.26341736e-04f, 2.38893833e-02f, -9.11804363e-02f, -9.79914609e-03f, -7.43018687e-02f, 4.27710116e-02f, -1.68545935e-02f,
  -8.33631530e-02f, -2.51641888e-02f, -5.91867454e-02f, -6.89959079e-02f, -2.08234806e-02f, 3.81468274e-02f, -2.57243644e-02f, -1.68119539e-02f, -4.33654990e-04f, -5.49738668e-02f,
  5.39396144e-02f, -4.04703468e-02f, 6.51795641e-02f, -9.26682074e-03f, -2.23905314e-02f, -4.99611385e-02f, -3.88093665e-02f, 2.35465020e-02f, 1.15790792e-01f, -3.36939469e-02f,
  -1.50860831e-01f, -7.29449391e-02f, 1.49020702e-02f, 8.00906122e-02f, -5.07193916e-02f, -3.58921848e-02f, -6.21874556e-02f, 1.86818838e-02f, -6.16697744e-02f, -7.15743601e-02f,
  4.52387407e-02f, 1.14295423e-01f, -8.21811706e-02f, -8.57499149e-03f, -1.20257951e-01f, 4.58644591e-02f, 2.11155284e-02f, 7.95338750e-02f, -1.70367258e-03f, 1.11920172e-02f,
  -1.60949416e-02f, -8.32272619e-02f, -1.78187266e-02f, 1.83655266e-02f, -2.31737308e-02f, 1.27125978e-02f, -7.02139959e-02f, -1.19045272e-01f, -6.37469068e-02f, -8.03090632e-02f,
  -3.99181694e-02f, -4.24911221e-03f, -9.14975107e-02f, 5.12300618e-02f, -7.76443705e-02f, -1.05341353e-01f, -8.97519141e-02f, -1.47167861e-01f, 6.10103570e-02f, 4.02009636e-02f,
  -1.36348670e-02f, -3.74292694e-02f, -1.27128914e-01f, 1.22255646e-01f, 1.03889830e-01f, 7.05629811e-02f, 3.57505716e-02f, -8.65986273e-02f, -2.36994158e-02f, 7.03669041e-02f,
  -7.59211332e-02f, 1.20103069e-01f, 1.12441130e-01f, 1.21537760e-01f, -3.89726609e-02f, 1.86336249e-01f, 2.01920439e-02f, -1.46332353e-01f, 1.41602363e-02f, 1.48058519e-01f,
  7.68576413e-02f, 3.46275568e-02f, -1.27137164e-02f, 8.29817578e-02f, -5.54434732e-02f, -1.37158096e-01f, -4.36107069e-02f, -3.24792713e-02f, -1.67751033e-03f, 5.11654094e-02f,
  -3.55885364e-02f, -9.79066640e-02f, -2.14149579e-01f, -3.02830581e-02f, -1.06097348e-01f, 2.64415294e-01f, 3.11749186e-02f, -5.45959510e-02f, 1.95007667e-01f, -1.06030509e-01f,
  -1.46101668e-01f, 1.18664436e-01f, -2.32268497e-02f, -3.08775045e-02f, -6.60705715e-02f, 4.64895777e-02f, -2.88723439e-01f, 5.74452151e-03f, 1.00897588e-01f, 3.41544688e-01f,
  2.11481974e-01f, -9.78044793e-03f, 9.18909386e-02f, -8.63735452e-02f, 2.79137999e-01f, 1.87596306e-02f, 7.18035772e-02f, -7.86446407e-02f, -3.59653719e-02f, -7.29977041e-02f,
  3.01048625e-02f, 6.15020320e-02f, -1.10300355e-01f, -2.28572153e-02f, -2.36741416e-02f, 2.00140569e-02f, 8.58961344e-02f, 9.25831944e-02f, -3.84121612e-02f, -2.04954110e-02f,
  -2.44980082e-02f, -2.56381626e-03f, -1.53631046e-01f, 7.95825794e-02f, 3.92591916e-02f, 6.45869449e-02f, 4.39104177e-02f, -3.82600315e-02f, 3.58739272e-02f, 1.78822950e-01f,
  2.11615916e-02f, -9.47790518e-02f, 1.09294936e-01f, 1.26462772e-01f, 1.09279908e-01f, -8.15654993e-02f, 1.02978371e-01f, 1.77866127e-02f, 4.32448685e-02f, -3.78843471e-02f,
  -4.33720760e-02f, -9.80873182e-02f, -4.13553901e-02f, 2.10135914e-02f, 6.15571141e-02f, 2.72638928e-02f, 3.56109142e-02f, 9.39754173e-02f, -9.72273201e-02f, -1.00447573e-01f,
  2.17900965e-02f, -2.68366840e-02f, -9.88333859e-03f, 1.08248793e-01f, 2.48114448e-02f, 1.05700016e-01f, -9.54565480e-02f, -1.10868111e-01f, 2.08439622e-02f, 1.74894810e-01f,
  -5.42440787e-02f, -1.27758637e-01f, -3.96385156e-02f, 1.37214944e-01f, -7.95039162e-02f, -2.86370933e-01f, -8.06629360e-02f, -9.01710838e-02f, 6.54332116e-02f, 2.89912149e-03f,
  3.69485542e-02f, -5.07347994e-02f, -4.64534275e-02f, 1.67358026e-01f, -1.08225927e-01f, 7.84802958e-02f, -1.21938542e-01f, 1.52291536e-01f, -1.01685515e-02f, -2.52992183e-01f,
  -2.13991087e-02f, 5.58478981e-02f, -1.63986340e-01f, 1.67642273e-02f, -1.00173153e-01f, -2.05602407e-01f, -1.57307073e-01f, -1.59752443e-01f, -3.91456336e-02f, -7.18121305e-02f,
  2.73904707e-02f, -1.09002352e-01f, -6.43408252e-03f, -1.23553807e-02f, -9.99406055e-02f, 2.99541000e-02f, -1.20617464e-01f, 1.56757906e-02f, 9.68663469e-02f, 5.95109686e-02f,
  -4.03266167e-03f, 5.13692275e-02f, 8.46761391e-02f, 1.14216633e-01f, 1.07198276e-01f, -9.09214746e-03f, -7.90205877e-03f, 1.16000660e-02f, 6.42200634e-02f, 3.46195279e-03f,
  3.16503271e-02f, 1.79767638e-01f, -6.31082878e-02f, -1.32019334e-02f, -7.98775181e-02f, -2.53889203e-01f, 1.13836944e-01f, -2.32430529e-02f, -6.33382052e-02f, 2.82598227e-01f,
  2.01572493e-01f, 1.23584546e-01f, -1.36338145e-01f, -1.49811180e-02f, 1.95514783e-02f, 3.48330736e-01f, 3.38500068e-02f, -1.50260687e-01f, 9.02188271e-02f, -2.18146313e-02f,
  2.40360022e-01f, -8.17270353e-02f, 2.83799544e-02f, 2.00543683e-02f, -2.33463719e-02f, -5.09393066e-02f, 7.00184628e-02f, -3.39508206e-02f, -5.08273393e-02f, 3.21673825e-02f,
  -1.02361180e-01f, -4.51584067e-03f, -6.03565127e-02f, -2.21689064e-02f, -3.07099875e-02f, -7.67605230e-02f, -8.38606581e-02f, 2.17643864e-02f, 1.15954671e-02f, 8.09506476e-02f,
  3.21618319e-02f, 2.81824023e-02f, -8.88071507e-02f, -8.07667449e-02f, 4.11427319e-02f, 6.66474625e-02f, -8.06480348e-02f, -1.07979393e-02f, -2.42410190e-02f, 8.23467299e-02f,
  1.41201466e-02f, 1.73222774e-03f, -7.56278411e-02f, -5.20100929e-02f, -7.83968940e-02f, -3.56885828e-02f, 1.14108756e-01f, -1.72895975e-02f, -4.88718040e-02f, -1.71381270e-03f,
  3.87381800e-02f, -7.51554072e-02f, 5.43482527e-02f, 1.25605181e-01f, -1.05924681e-02f, 1.13020018e-01f, 2.53673848e-02f, -7.29225343e-03f, -9.98969190e-03f, -1.03285849e-01f,
  1.44372076e-01f, -4.01491374e-02f, 2.24208832e-02f, 8.29557925e-02f, 1.83951296e-02f, 3.47401039e-03f, 7.60081038e-02f, 6.90644654e-03f, 2.08336506e-02f, 6.55401796e-02f,
  8.88742059e-02f, 1.27225339e-01f, -9.76799801e-03f, 1.04707226e-01f, 8.03802311e-02f, -4.88717780e-02f, -8.58115498e-03f, 2.44182404e-02f, 3.83791444e-03f, 1.37188649e-02f,
  -2.43020058e-02f, -1.36225462e-01f, 1.14631681e-02f, 1.46154519e-02f, -2.53318250e-02f, 5.40706655e-03f, -8.01845044e-02f, 1.01463782e-04f, 1.04806714e-01f, 5.91532663e-02f,
  -3.57365329e-03f, 3.59044671e-02f, 7.47455508e-02f, 9.99919027e-02f, -9.46249589e-02f, 1.92579105e-02f, -2.03874148e-02f, -1.79222152e-01f, 4.67281369e-03f, 4.76572365e-02f,
  -4.89156544e-02f, 1.14905369e-02f, -2.71953456e-02f, -9.96944308e-02f, -7.98861459e-02f, -1.09578393e-01f, -1.14514688e-02f, 8.45446512e-02f, -1.72593892e-02f, -1.42161489e-01f,
  7.54863024e-02f, -1.71788961e-01f, -4.14698794e-02f, -8.36658329e-02f, -1.02777041e-01f, -3.00718881e-02f, -5.78781404e-03f, 1.35364473e-01f, -9.80603024e-02f, -8.76663849e-02f,
  -1.13188714e-01f, -3.17070819e-02f, -1.36713274e-02f, 7.88670033e-02f, -1.51157677e-01f, 7.97642171e-02f, 1.33308545e-01f, 1.94034517e-01f, 3.91213447e-02f, 1.26837179e-01f,
  -1.78143695e-01f, -2.27583393e-01f, 2.55107045e-01f, 2.40902066e-01f, -1.35838632e-02f, -9.13557783e-02f, 2.38509119e-01f, -7.33682513e-02f, 1.87450185e-01f, 7.66910911e-02f,
  2.97700793e-01f, 7.75236785e-02f, 1.38144821e-01f, 1.64882578e-02f, 1.74906179e-02f, 8.05994868e-02f, -1.45319536e-01f, 9.50802043e-02f, 3.69667038e-02f, 2.96291765e-02f,
  6.27255067e-02f, 9.47777480e-02f, 2.52350383e-02f, 9.35413316e-02f, -1.69734567e-01f, -7.36356750e-02f, -6.23882227e-02f, -6.01386912e-02f, 3.35070565e-02f, -8.20404142e-02f,
  -1.09828543e-02f, 9.68690291e-02f, 2.74015721e-02f, 9.81582776e-02f, 4.47733775e-02f, 1.31833687e-01f, 1.85142726e-01f, 5.39411837e-03f, -6.32414743e-02f, 4.12467793e-02f,
  -2.10720543e-02f, -6.85962196e-03f, 4.02232772e-03f, 6.77557960e-02f, -2.98892297e-02f, 3.63177359e-02f, -4.84103896e-02f, -1.18530425e-03f, 4.83489484e-02f, 1.58856854e-01f,
  1.64467111e-01f, 6.97444156e-02f, 2.20625605e-02f, -2.20919624e-02f, 1.87275447e-02f, 1.31417185e-01f, -6.81496710e-02f, -8.39731656e-03f, -4.99867126e-02f, -4.40959167e-03f,
  2.95867603e-02f, 4.19342592e-02f, 5.66179901e-02f, -5.51771708e-02f, 5.75405993e-02f, 1.45919457e-01f, 1.08374357e-02f, -1.00619130e-01f, 3.65275554e-02f, 2.48739913e-01f,
  8.31593573e-02f, 4.66299430e-02f, 1.94607377e-02f, 4.75410372e-03f, 3.66576873e-02f, 7.99678862e-02f, -2.72394507e-03f, 5.65508902e-02f, 7.17183053e-02f, 1.98261395e-01f,
  3.91635969e-02f, -9.12249610e-02f, -8.16013217e-02f, 9.93520301e-03f, 1.20497957e-01f, 5.33145480e-02f, -1.44663617e-01f, -6.60076290e-02f, -4.92191948e-02f, -1.94097117e-01f,
  6.21787161e-02f, 1.30276754e-01f, -6.16132990e-02f, -1.41502619e-01f, -4.63093184e-02f, -5.19506335e-02f, 8.05993155e-02f, -6.62377551e-02f, 5.66283353e-02f, -4.22946215e-02f,
  1.53825451e-02f, -2.73829047e-02f, -7.18977526e-02f, -5.85095324e-02f, -1.02502927e-01f, 7.62070119e-02f, -4.55470942e-02f, -7.75966197e-02f, 3.43882069e-02f, -1.19218126e-01f,
  4.56546769e-02f, 4.80942316e-02f, -9.17490851e-03f, -6.97120056e-02f, 8.88090283e-02f, 9.90840271e-02f, 1.15908287e-01f, -1.47376552e-01f, -2.37859368e-01f, 7.12032616e-02f,
  -2.55727936e-02f, 4.15892564e-02f, -1.03970423e-01f, 1.21132210e-01f, -1.27717435e-01f, -1.40996724e-01f, 2.21029654e-01f, -1.15920171e-01f, 3.39246213e-01f, 2.92724054e-02f,
  -9.25955251e-02f, 1.37981340e-01f, -2.37255245e-01f, -2.95723706e-01f, -6.88694641e-02f, 2.97600061e-01f, -1.49124088e-02f, 1.18439779e-01f, -1.57737046e-01f, -9.62606594e-02f,
  5.60536049e-02f, 4.20899205e-02f, -2.52496172e-02f, -2.89165322e-03f, 1.19723622e-02f, 7.76810423e-02f, -1.90184012e-01f, 9.76805836e-02f, -8.12797323e-02f, -7.09532425e-02f,
  4.82405676e-03f, -7.65635371e-02f, -6.47049211e-03f, 1.63657237e-02f, -1.37280583e-01f, 5.32792546e-02f, 4.70754132e-02f, 2.32135076e-02f, 3.87038291e-02f, -2.12172158e-02f,
  -1.39642023e-02f, -1.61302984e-01f, 5.34413718e-02f, -4.50996347e-02f, -1.02523744e-01f, -7.20846206e-02f, -3.96244451e-02f, -1.17039137e-01f, -1.35615692e-01f, -3.89148481e-02f,
  -6.19286783e-02f, -4.30548266e-02f, 1.69731751e-01f, 1.45019457e-01f, -1.24102710e-02f, -6.02599233e-03f, -6.15824163e-02f, -6.56953081e-02f, 4.23410609e-02f, -1.76278636e-01f,
  2.93985214e-02f, 1.30508039e-02f, -4.47403491e-02f, -3.04921549e-02f, -6.53771013e-02f, -6.06433637e-02f, 7.56067317e-03f, 1.37818689e-02f, 1.69065744e-01f, 3.11824046e-02f,
  -1.14101171e-01f, 1.14477605e-01f, 6.75612241e-02f, -1.04766347e-01f, -3.71395610e-02f, -4.78667840e-02f, 1.00610323e-01f, -3.88817899e-02f, -6.80034757e-02f, 9.40913036e-02f,
  7.53102303e-02f, 3.57185118e-02f, -2.17053783e-03f, 4.21889871e-02f, 1.72497749e-01f, 1.35935945e-02f, 1.20792566e-02f, 3.89608108e-02f, -1.54251596e-02f, -5.34103997e-02f,
  1.10328101e-01f, -1.56908661e-01f, -4.21725167e-03f, -4.11522016e-02f, 2.63658315e-01f, -6.16496950e-02f, -6.69581592e-02f, 5.83511405e-02f, -4.11139103e-03f, 5.60585633e-02f,
  -5.20310253e-02f, 4.11509760e-02f, -3.40209454e-02f, 2.94708107e-02f, -1.28228456e-01f, -5.70388027e-02f, 9.57695842e-02f, 2.48278063e-02f, 6.11678138e-02f, -1.06519699e-01f,
  -6.69153184e-02f, -1.13182709e-01f, -5.57747222e-02f, 6.19885847e-02f, 3.54265720e-02f, 3.16103399e-02f, -4.82300110e-02f, -1.14374049e-01f, -5.39046153e-02f, 1.68794125e-01f,
  7.18006715e-02f, 8.26365966e-03f, 6.51142187e-03f, -4.24732268e-02f, 5.63981906e-02f, 7.80294761e-02f, 1.11025423e-01f, 2.43113376e-03f, 7.30429515e-02f, 1.07889332e-01f,
  -1.98592633e-01f, 9.53243077e-02f, -9.76546928e-02f, -1.47173822e-01f, 2.06510127e-01f, -3.32055837e-02f, -1.09987468e-01f, -2.36248165e-01f, 2.96155244e-01f, -1.16901629e-01f,
  6.55619130e-02f, -3.60749215e-01f, 5.52349612e-02f, -1.85677662e-01f, 9.82688516e-02f, 2.39840299e-01f, 7.43024498e-02f, 6.42341971e-02f, 6.01990242e-03f, 1.49762528e-02f,
  9.46100987e-03f, -7.83367455e-03f, -5.22687510e-02f, 1.02365702e-01f, -4.80862521e-02f, 1.07786432e-01f, -1.00328639e-01f, 3.60163823e-02f, 9.14942771e-02f, 6.02930412e-02f,
  1.16742915e-02f, -7.28222281e-02f, 6.17169775e-02f, -7.41777122e-02f, -3.02911066e-02f, -6.33274838e-02f, 1.18718766e-01f, -6.15863204e-02f, 2.46488955e-03f, 6.39583394e-02f,
  1.23445578e-02f, -7.64600113e-02f, -5.87345846e-02f, -3.30874510e-02f, 5.37795275e-02f, 3.01909316e-02f, -2.48443447e-02f, 1.03917122e-01f, 8.49239063e-03f, -3.06532551e-02f,
  -8.34109262e-03f, 4.55880053e-02f, 1.64912979e-03f, 1.18101008e-01f, 5.10976277e-02f, 2.31144996e-03f, -3.18064168e-02f, -7.47618750e-02f, -1.00650385e-01f, -1.57806240e-02f,
  -3.96237373e-02f, 4.02551657e-03f, -1.91368051e-02f, -4.08282243e-02f, 4.84423377e-02f, 9.11834911e-02f, 7.60047212e-02f, -3.02827917e-03f, 5.48866428e-02f, 1.57038137e-01f,
  2.12431759e-01f, 1.07899837e-01f, -9.02633183e-03f, 3.26360129e-02f, 1.06981965e-02f, 1.93173997e-02f, -2.49274038e-02f, -1.53016839e-02f, 8.11399966e-02f, 3.84532772e-02f,
  7.15159476e-02f, 2.66651101e-02f, 1.38545379e-01f, 5.25306314e-02f, 3.06036044e-02f, 8.99168923e-02f, -4.76758853e-02f, -1.37874737e-01f, -7.69110769e-02f, 5.02409153e-02f,
  -2.11644545e-02f, 3.32969837e-02f, -1.15623072e-01f, -9.98768434e-02f, -6.29404783e-02f, -6.85086772e-02f, 5.32493927e-02f, 3.61009836e-02f, -1.36876376e-02f, -2.14213654e-01f,
  1.46060446e-02f, -1.54091874e-02f, 1.18570924e-01f, -4.44058962e-02f, -3.88770294e-03f, -7.34068900e-02f, -2.80504907e-03f, -3.34967710e-02f, -3.59686241e-02f, -1.99594945e-01f,
  -6.38390332e-02f, 8.64503756e-02f, -4.63172533e-02f, -1.27214745e-01f, 4.29824851e-02f, -3.56430635e-02f, -1.47798732e-01f, 3.86773562e-03f, 1.14680408e-02f, -1.86175525e-01f,
  -2.03153208e-01f, -2.55194437e-02f, 1.51611164e-01f, -1.94653515e-02f, 3.60777862e-02f, -1.18948311e-01f, -2.03495678e-02f, -1.61537364e-01f, -2.98203304e-02f, -1.41515166e-01f,
  -2.39530094e-02f, -1.21488705e-01f, 1.65664837e-01f, 3.32212225e-02f, 6.89706951e-02f, -9.50480998e-02f, 3.18256542e-02f, 6.24724105e-02f, -3.27797532e-01f, -1.56820446e-01f,
  -1.33674771e-01f, 2.04176024e-01f, -8.20353627e-02f, 2.02336490e-01f, -3.11145276e-01f, -2.46879943e-02f, -1.54300049e-01f, 4.06305641e-02f, 3.07552461e-02f, 9.25303176e-02f,
  6.48059845e-02f, -5.85736893e-02f, -5.64708710e-02f, 3.96055356e-02f, -1.15911610e-01f, 5.65547571e-02f, 1.29792586e-01f, 8.16776380e-02f, 3.37004028e-02f, 1.22307390e-01f,
  8.96771997e-03f, 9.98044014e-03f, 1.77711118e-02f, -8.76313597e-02f, 1.08725272e-01f, -5.20478077e-02f, -5.70965856e-02f, -2.56176572e-02f, 4.92665283e-02f, 1.13003043e-04f,
  -7.82040730e-02f, -5.57614602e-02f, -2.44994666e-02f, -4.28639911e-02f, 8.64253342e-02f, 2.72020511e-02f, -6.11812957e-02f, -3.03785466e-02f, -2.25895606e-02f, 3.12927403e-02f,
  6.01370558e-02f, 8.16830322e-02f, -6.69797882e-02f, -1.05626108e-02f, 1.00945355e-02f, -1.79654714e-02f, -1.52568355e-01f, -4.89031114e-02f, -3.48106921e-02f, 6.40660971e-02f,
  -3.27309668e-02f, -6.67429268e-02f, -5.92734702e-02f, -2.65859179e-02f, -4.92551252e-02f, 1.11127488e-01f, -7.94641674e-02f, 1.60894126e-01f, -2.39158213e-01f, -1.95746999e-02f,
  -1.05040427e-02f, 2.92808283e-02f, -1.15303636e-01f, -1.16637170e-01f, -2.07324494e-02f, -2.23453958e-02f, 1.42478123e-01f, -4.02352726e-03f, -5.60682919e-03f, -1.78024322e-02f,
  -4.06235605e-02f, 5.28820278e-03f, -1.77893221e-01f, 1.03844509e-01f, -8.22075680e-02f, 1.38028800e-01f, 1.14387991e-02f, 1.80112377e-01f, 1.47842512e-01f, 4.76820618e-02f,
  1.33057117e-01f, -1.22414544e-01f, -1.08802304e-01f, 5.63842840e-02f, -6.34447336e-02f, -4.06303443e-02f, -2.45877616e-02f, 2.00943984e-02f, -1.67338699e-02f, 1.01402506e-01f,
  -1.12895191e-01f, 9.03313234e-02f, 2.18925271e-02f, -1.09196529e-01f, -5.66322617e-02f, 3.70286740e-02f, -5.14282174e-02f, 1.66578606e-01f, -3.64985205e-02f, -7.67502263e-02f,
  3.12321559e-02f, 6.80239275e-02f, 5.43808425e-03f, 3.10158819e-01f, 4.76748571e-02f, 1.45125493e-01f, 1.72071196e-02f, 1.81196444e-03f, 9.61874947e-02f, -4.04224312e-03f,
  6.08078167e-02f, 3.28055359e-02f, -9.78652164e-02f, 5.51035395e-03f, -8.97876080e-03f, 5.06676733e-02f, 1.09022064e-02f, -8.82101357e-02f, -8.99595618e-02f, -2.56406188e-01f,
  1.10046789e-01f, -1.83793277e-01f, -1.14306986e-01f, -9.23688933e-02f, -1.11715637e-01f, -3.43771785e-01f, 1.54824361e-01f, 7.47558549e-02f, -1.54024497e-01f, 1.56761315e-02f,
  -1.33444697e-01f, 2.03850403e-01f, -7.11967051e-02f, -1.44536719e-02f, 4.37012222e-03f, -1.42215043e-02f, 2.33902186e-02f, 3.05845914e-03f, -1.91356331e-01f, -6.75136968e-02f,
  1.96965095e-02f, -6.03465959e-02f, 1.11645445e-01f, 1.65769048e-02f, 5.77677414e-02f, 3.43563631e-02f, 6.61097541e-02f, -1.35200068e-01f, 4.11844030e-02f, 4.50975969e-02f,
  -1.41900837e-01f, -7.01044276e-02f, -1.86037403e-02f, -2.36514956e-02f, 6.22390099e-02f, 3.02889477e-02f, -6.81840628e-02f, -1.14486367e-01f, 1.48417708e-02f, -1.97007768e-02f,
  1.42608145e-02f, -6.15932271e-02f, -2.96535902e-02f, -5.21204472e-02f, 9.04837996e-02f, -4.71319966e-02f, 4.17028889e-02f, 3.62039320e-02f, -8.58600996e-03f, 8.06706622e-02f,
  5.86117320e-02f, -1.20916359e-01f, 3.89978550e-02f, -5.03287651e-02f, -4.08000201e-02f, -1.64325777e-02f, 1.71139576e-02f, -2.96617597e-02f, 1.05744153e-01f, 1.03568509e-01f,
  8.95485803e-02f, -1.67394876e-02f, -1.04595348e-01f, 7.44782910e-02f, -2.78575644e-02f, -6.93774000e-02f, 1.67254105e-01f, 6.25169417e-03f, -1.35441884e-01f, 6.18003048e-02f,
  -1.44256447e-02f, 3.65492739e-02f, -6.51773214e-02f, 7.70160332e-02f, -4.33351547e-02f, -2.26048976e-01f, -1.53155932e-02f, 8.76656026e-02f, 3.11657991e-02f, -7.44095817e-02f,
  1.69540808e-01f, 4.04160917e-02f, -1.47059053e-01f, -1.00647300e-01f, -3.89775373e-02f, 1.11717302e-02f, 8.34220350e-02f, -3.50577291e-03f, 5.65629750e-02f, 1.63973734e-01f,
  1.10172115e-01f, 6.07251525e-02f, 7.72786960e-02f, 2.51000584e-03f, -4.19036038e-02f, -6.61231205e-02f, -5.62136807e-02f, 1.54535130e-01f, 9.99218896e-02f, 2.14794166e-02f,
  1.96358621e-01f, -4.82802503e-02f, -2.29005404e-02f, -1.08944148e-01f, -1.14978917e-01f, -3.99720594e-02f, -2.32516304e-02f, 9.06800032e-02f, 2.00355127e-02f, 9.83505845e-02f,
  -3.55464295e-02f, -1.75441742e-01f, -1.33653522e-01f, 1.55336976e-01f, 4.04727235e-02f, -3.08666248e-02f, -2.01727897e-01f, -8.16000700e-02f, -4.27519390e-03f, -4.93266657e-02f,
  -1.32905523e-04f, -7.24696135e-03f, -1.48720503e-01f, -9.80994180e-02f, -1.44842952e-01f, -1.59326836e-01f, 5.26240319e-02f, 2.19460189e-01f, 2.18133241e-01f, -3.28028165e-02f,
  -4.18204665e-02f, -2.73952708e-02f, 9.28404275e-03f, 1.96947873e-01f, -8.42515305e-02f, 1.15094997e-01f, 1.17644332e-01f, 2.00951993e-01f, 1.92558393e-01f, -1.03635183e-02f,
  1.28273427e-01f, -1.93061218e-01f, -2.74517145e-02f, -6.40639290e-03f, 9.17806029e-02f, 4.33388837e-02f, -9.36458632e-02f, 3.92192714e-02f, -8.67774338e-02f, 4.63810861e-02f,
  4.39022817e-02f, 1.64256897e-02f, -6.53810874e-02f, -3.04336846e-02f, -4.54852544e-02f, -2.57890187e-02f, -2.20088754e-03f, -3.26997153e-02f, 2.35918984e-02f, -4.50292043e-02f,
  8.70440155e-02f, -6.19557425e-02f, -2.24796440e-02f, 1.52356267e-01f, -9.34655145e-02f, -1.37095600e-01f, 1.02751041e-02f, -2.35373378e-02f, 2.69309841e-02f, -2.48178095e-02f,
  1.09414058e-02f, 9.34545919e-02f, 1.27916008e-01f, 6.90823272e-02f, -3.66637036e-02f, 2.54478883e-02f, -1.12617776e-01f, -3.17196399e-02f, 1.44410014e-01f, -5.92916235e-02f,
  6.47618994e-02f, 6.27942681e-02f, -8.85534808e-02f, -4.55694795e-02f, 4.12265249e-02f, -1.54463304e-02f, -4.99606021e-02f, 1.11816600e-01f, -1.00964002e-01f, -7.23436996e-02f,
  -7.36659253e-03f, 3.03265993e-02f, 6.91738799e-02f, -6.48714676e-02f, -1.96646005e-02f, 8.47761780e-02f, 8.33773427e-03f, 1.36068985e-01f, 1.97618425e-01f, -4.77260388e-02f,
  1.01267159e-01f, -5.23627270e-03f, -1.19446225e-01f, -2.47495528e-02f, -1.94698013e-02f, -9.03801546e-02f, -9.09889936e-02f, -1.29178897e-01f, -2.59871501e-02f, 1.50119260e-01f,
  7.22674504e-02f, 2.69034244e-02f, -4.17142026e-02f, 3.80440652e-02f, -1.60979312e-02f, 1.62502497e-01f, 1.74744859e-01f, -9.38804522e-02f, -6.54245317e-02f, -2.94344733e-03f,
  2.01113939e-01f, 9.27558169e-02f, 6.58160960e-03f, 9.59687606e-02f, -1.33915320e-01f, 1.27847612e-01f, 1.58520505e-01f, -2.01220177e-02f, 6.29576594e-02f, -9.04689133e-02f,
  2.22146269e-02f, 1.32172123e-01f, -9.26915789e-04f, 2.58063525e-01f, -1.16433732e-01f, -2.13249382e-02f, -2.21815370e-02f, 1.44241592e-02f, -1.32262241e-02f, 1.04218446e-01f,
  -4.26399745e-02f, -3.60883288e-02f, -6.21356703e-02f, 4.06794995e-02f, -9.89533588e-02f, -1.67930365e-01f, -3.34392264e-02f, -1.09525416e-02f, -3.31642270e-01f, 1.88815176e-01f,
  -1.02886386e-01f, 1.72320917e-01f, 1.81180462e-02f, -6.23062365e-02f, -6.09508529e-02f, -1.38758987e-01f, 1.63062111e-01f, 2.24903654e-02f, 1.04654372e-01f, 5.64932339e-02f,
  -2.34960482e-01f, -1.59758717e-01f, -2.25501284e-02f, 1.44819573e-01f, -3.64872627e-02f, 2.10127503e-01f, -6.43890947e-02f, 8.91981795e-02f, 1.06854670e-01f, -4.24802043e-02f,
  1.37565741e-02f, -1.70789614e-01f, 4.36246768e-02f, -7.46624125e-03f, 9.15726572e-02f, 9.36059803e-02f, -2.76456065e-02f, -1.13549028e-02f, 3.71237770e-02f, -1.40896169e-02f,
  -4.23987349e-03f, -1.95348561e-02f, -6.39925823e-02f, 2.20168140e-02f, -4.59032226e-03f, 3.63210402e-02f, 2.08309405e-02f, 6.34442782e-03f, -1.02801800e-01f, 1.75184701e-02f,
  4.27378304e-02f, 1.86276555e-01f, 5.56688718e-02f, -2.18267944e-02f, 4.88877147e-02f, 7.32921362e-02f, 3.19947749e-02f, 1.55971393e-01f, 7.98451751e-02f, 8.38284492e-02f,
  1.32116094e-01f, 8.56513977e-02f, 8.84487480e-02f, 6.60736710e-02f, -1.63468346e-02f, 1.10671446e-01f, 8.47616512e-03f, 1.11916520e-01f, 6.52529523e-02f, -5.15627712e-02f,
  2.97175050e-02f, -1.54601447e-02f, -2.01941039e-02f, 1.24521896e-01f, -2.24310309e-02f, 9.59986970e-02f, 1.11495137e-01f, 1.42783269e-01f, -1.02398448e-01f, 1.42875448e-01f,
  5.14356345e-02f, 1.13468610e-01f, 6.12417348e-02f, 5.95645681e-02f, 1.19024239e-01f, 9.69264191e-03f, -9.21537578e-02f, -8.29813108e-02f, 2.59831160e-01f, 5.43444194e-02f,
  1.71455219e-02f, -4.05409858e-02f, 4.27518450e-02f, 5.63804097e-02f, 3.96959623e-03f, 1.53556511e-01f, 8.38070991e-04f, 1.34882554e-01f, 8.42133015e-02f, -1.28727868e-01f,
  -4.21151333e-02f, 3.78337093e-02f, 1.05512746e-01f, 1.79385900e-01f, -9.47901532e-02f, -2.42761537e-01f, 5.91106974e-02f, -1.16122916e-01f, 1.19547181e-01f, 1.33464232e-01f,
  -1.41241578e-02f, -1.79728463e-01f, -4.41964343e-02f, 8.35707113e-02f, 9.13537368e-02f, -9.61995646e-02f, 1.04688577e-01f, -1.03563577e-01f, -1.68435052e-01f, -1.55494466e-01f,
  -2.88988687e-02f, 3.89760453e-03f, -6.01473525e-02f, 2.48855390e-02f, -4.02276963e-02f, -6.14647334e-03f, -2.36825589e-02f, 1.22784682e-01f, -3.30940373e-02f, 6.02493621e-03f,
  3.86225879e-02f, -1.42952707e-02f, -2.34536737e-01f, -6.74740374e-02f, -1.62138063e-02f, 1.17834523e-01f, 3.30511183e-02f, -9.84097570e-02f, -6.78869616e-03f, 2.88779065e-02f,
  5.34448326e-02f, -1.32160932e-01f, 1.07479254e-02f, -6.80378303e-02f, 2.85355151e-01f, -1.05309628e-01f, 1.07787684e-01f, -1.53330773e-01f, -7.89755508e-02f, 1.08456910e-01f,
  1.69855691e-02f, 3.11357621e-02f, -4.44742404e-02f, 4.01882231e-01f, -1.68735743e-01f, 3.52439642e-01f, -2.90190011e-01f, -2.74160244e-02f, 2.35265270e-02f, 8.66423361e-03f,
  -2.80616526e-02f, -2.81256419e-02f, 8.39205459e-02f, -1.86304878e-02f, 2.94379555e-02f, -5.83470501e-02f, 5.20969965e-02f, -7.75204897e-02f, -9.70121473e-02f, -1.87671836e-02f,
  -1.16210766e-01f, 5.79685606e-02f, 4.40084040e-02f, -1.03906430e-01f, -1.61207885e-01f, 5.79048134e-03f, -6.76015019e-02f, 1.24474242e-01f, -4.20875428e-03f, 2.29907054e-02f,
  -7.91762769e-02f, 2.39644036e-01f, 2.50385031e-02f, -9.14252996e-02f, -1.44331828e-01f, 4.51327115e-02f, 1.00411944e-01f, -5.06052114e-02f, -7.40278512e-02f, 3.93746011e-02f,
  8.00678656e-02f, 1.66207314e-01f, -1.59038939e-02f, -6.23738840e-02f, -1.79842375e-02f, 5.61602153e-02f, 1.02824219e-01f, -7.39248842e-03f, -1.28519731e-02f, -7.61774033e-02f,
  1.51779298e-02f, -5.08747771e-02f, -1.32986587e-02f, -4.97456230e-02f, 6.05067350e-02f, -5.57087101e-02f, -1.30537838e-01f, -1.43562227e-01f, -8.13646838e-02f, -1.58206120e-01f,
  1.02224328e-01f, 3.01808864e-03f, -3.61619480e-02f, -1.94000736e-01f, 1.28248721e-01f, 5.31047434e-02f, -1.50832951e-01f, -5.39164199e-03f, 7.71845281e-02f, 7.59145543e-02f,
  8.33069012e-02f, -1.45664409e-01f, -6.38165548e-02f, -7.96366632e-02f, 3.02493889e-02f, 1.10918447e-01f, -1.05897389e-01f, 1.66016504e-01f, 5.39035462e-02f, -1.48639828e-01f,
  8.81413370e-02f, 1.40780918e-02f, -2.18117893e-01f, -8.78196508e-02f, -1.39995441e-01f, -1.33046702e-01f, 3.74057963e-02f, 1.11986056e-01f, -8.23526233e-02f, -3.90565246e-02f,
  1.07275210e-02f, -7.18612149e-02f, -5.56319356e-02f, -1.41007826e-01f, -3.54144443e-03f, -3.41826752e-02f, -1.71604846e-02f, 5.30851930e-02f, 3.86992260e-03f, 6.99073076e-03f,
  1.19080931e-01f, 1.18243128e-01f, -2.11984180e-02f, -8.42041150e-02f, -1.18419677e-02f, 4.69695106e-02f, 1.99711055e-01f, 3.77314948e-02f, -1.12463392e-01f, 7.99374562e-03f,
  -4.21515554e-02f, 8.23697224e-02f, 1.63193986e-01f, 1.91287801e-01f, 5.43141291e-02f, -2.55395651e-01f, 3.03723998e-02f, -2.20383421e-01f, 1.79683924e-01f, 1.25426158e-01f,
  2.37888008e-01f, -5.88461049e-02f, 7.13018924e-02f, 1.08460791e-01f, 4.91887517e-02f, 1.02974758e-01f, 2.64643103e-01f, 8.52984339e-02f, -3.91857326e-02f, -3.89060020e-01f,
  -1.00835383e-01f, -2.42111851e-02f, -7.73648843e-02f, -1.22414343e-01f, -2.65626252e-01f, -4.99024540e-02f, 9.12821293e-03f, 1.12888418e-01f, -9.10953060e-02f, -1.27952695e-01f,
  -8.65919590e-02f, 3.37440930e-02f, 1.47973355e-02f, 3.02888993e-02f, 8.10155179e-03f, -2.46307775e-02f, 4.82093357e-02f, -6.92875981e-02f, 1.70991588e-02f, 6.73345253e-02f,
  2.72761844e-03f, 8.70153308e-03f, -4.27987613e-02f, -2.89355610e-02f, 8.69057849e-02f, -9.02215135e-04f, 2.49347594e-02f, -3.96315418e-02f, -5.02743199e-02f, -1.22814111e-01f,
  1.06030673e-01f, 1.63936417e-03f, -4.56400514e-02f, -4.69586365e-02f, 6.47671744e-02f, 6.08718023e-02f, -4.49783206e-02f, 3.34727345e-04f, 5.82873859e-02f, -2.30413284e-02f,
  2.94509996e-03f, 2.14512963e-02f, 7.39164054e-02f, -1.22080445e-01f, -5.19011468e-02f, -7.20704021e-03f, -1.24284131e-02f, 7.87411779e-02f, 7.19719194e-03f, 3.68007049e-02f,
  -2.22357064e-02f, 4.13494706e-02f, 3.76726501e-02f, -1.28047228e-01f, -8.20163265e-02f, 5.77780344e-02f, -3.80129591e-02f, 4.05110829e-02f, -1.61117446e-02f, 4.19265442e-02f,
  6.66874344e-04f, 4.48793508e-02f, 1.17799625e-01f, 2.16601901e-02f, 1.67578056e-01f, 2.34481677e-01f, 8.59262142e-03f, 4.92157601e-02f, -3.38530801e-02f, 3.77716199e-02f,
  -6.81733564e-02f, -5.39313480e-02f, 1.73261557e-02f, 8.91193375e-03f, 5.33650443e-02f, -6.03886545e-02f, -2.69770492e-02f, 4.17084210e-02f, -8.17627311e-02f, -4.03470034e-03f,
  -6.26045391e-02f, -2.64810584e-02f, -3.25377397e-02f, 8.34785923e-02f, -5.39438687e-02f, 7.79779404e-02f, 1.98586211e-02f, 3.97847146e-02f, 2.66209990e-02f, -1.30227953e-02f,
  5.22087552e-02f, 1.96568176e-01f, 6.35167137e-02f, -7.48451501e-02f, 1.61044449e-01f, 1.15285024e-01f, 3.29003856e-02f, -5.58450036e-02f, -3.38792503e-02f, 1.13463290e-01f,
  -4.34118584e-02f, -5.00217117e-02f, 5.53000942e-02f, 7.82457143e-02f, 1.62375141e-02f, 1.17579721e-01f, 1.13251016e-01f, 3.95961665e-02f, 9.47380513e-02f, -3.21296193e-02f,
  1.70805618e-01f, -2.96058148e-01f, -1.43111363e-01f, -1.16879843e-01f, -6.42702030e-03f, 2.23008581e-02f, -2.78077751e-01f, 6.35473654e-02f, 4.37148735e-02f, -1.86254770e-01f,
  -1.99890465e-01f, -1.51902869e-01f, 1.51901647e-01f, 1.88092053e-01f, -6.31523058e-02f, -1.87730148e-01f, -1.24700859e-01f, 1.08692452e-01f, -1.02270059e-01f, 1.96504027e-01f,
  -2.01792464e-01f, 1.16208628e-01f, -1.87341496e-01f, -6.42962530e-02f, 7.80140385e-02f, 1.47794023e-01f, 5.27661368e-02f, 6.01083897e-02f, -7.28403591e-03f, 1.05932374e-02f,
  6.54926896e-03f, 7.97571167e-02f, 2.17742454e-02f, 8.59334413e-03f, 2.16757283e-02f, -8.18786100e-02f, -3.68895754e-02f, -1.84553973e-02f, 3.60473283e-02f, 7.30090737e-02f,
  -7.29979500e-02f, 1.62384659e-02f, -7.08876029e-02f, 5.84770143e-02f, 8.88324901e-02f, -1.39212042e-01f, 7.04584196e-02f, -5.76233007e-02f, 4.84310724e-02f, 1.08057342e-01f,
  4.57924865e-02f, 5.15988432e-02f, -5.31748086e-02f, -4.06945124e-02f, -7.57216141e-02f, -2.60311086e-02f, 2.39810813e-02f, 2.16988213e-02f, 5.22885583e-02f, -5.34365587e-02f,
  4.00846563e-02f, 5.07238954e-02f, 4.46357392e-02f, 8.64288583e-02f, -3.64238471e-02f, 3.15073580e-02f, -1.04543671e-01f, 3.04616522e-02f, 4.67945002e-02f, -1.06788337e-01f,
  -2.40907706e-02f, -2.85622440e-02f, 8.90733153e-02f, -8.04688931e-02f, 6.27307519e-02f, 5.21251410e-02f, 3.80107686e-02f, -1.71271682e-01f, -3.98869440e-02f, -1.79105029e-01f,
  4.40247059e-02f, -5.20393960e-02f, 2.74947677e-02f, -2.93129161e-02f, 1.33524276e-03f, 2.30669484e-01f, -5.26971929e-02f, -4.75363806e-02f, 3.50320153e-02f, -9.41973254e-02f,
  5.34050576e-02f, 1.12637377e-03f, 1.95114091e-02f, 9.13055018e-02f, 6.64510503e-02f, -2.34095261e-01f, -1.26226398e-03f, 5.66242337e-02f, -3.76660787e-02f, 1.74693149e-02f,
  1.00804836e-01f, -4.97677810e-02f, -4.05703187e-02f, 2.54520327e-02f, 1.81703418e-02f, 9.65425745e-02f, -5.22074439e-02f, -4.07586284e-02f, -1.00906849e-01f, 5.91161065e-02f,
  -8.75221863e-02f, 8.63719359e-02f, 1.18048824e-01f, 1.14999816e-01f, 5.30556068e-02f, -1.51774287e-01f, -4.06065024e-02f, -5.56048341e-02f, 3.49105224e-02f, -1.09594911e-02f,
  -4.47566211e-02f, 4.16178666e-02f, 1.81440279e-01f, 3.33911739e-02f, 6.61029369e-02f, 3.26543185e-03f, -9.49257314e-02f, 6.93629608e-02f, 4.11341004e-02f, 1.31432042e-01f,
  2.38837391e-01f, 1.67876221e-02f, 4.55368236e-02f, 4.94838730e-02f, 1.21416636e-01f, 1.47500038e-01f, -7.88614452e-02f, -1.25841228e-02f, -2.40431592e-01f, 9.55611467e-02f,
  1.31176755e-01f, 1.45671442e-01f, 1.17368810e-01f, -2.45417684e-01f, 1.16131909e-01f, -1.18440740e-01f, 1.41207367e-01f, -2.69420207e-01f, -1.62446395e-01f, -2.31744111e-01f,
  -1.19277919e-02f, -6.53933138e-02f, 1.10321671e-01f, 3.07947826e-02f, 1.61908455e-02f, -8.77911225e-03f, 7.66800856e-03f, 5.44363447e-02f, 1.33372515e-01f, -6.74629956e-02f,
  3.94068367e-04f, -2.00821832e-02f, 2.89060604e-02f, -2.84530818e-02f, 5.21290787e-02f, -1.36501282e-01f, 2.02493500e-02f, -2.61193197e-02f, 6.42846450e-02f, 9.40537173e-03f,
  -2.22682115e-02f, -7.41188899e-02f, 6.16114624e-02f, -6.60369247e-02f, -5.08860759e-02f, 4.40404750e-02f, -9.07078385e-02f, 1.43813327e-01f, 2.40580924e-02f, -2.32791118e-02f,
  9.23930928e-02f, 1.06196903e-01f, -5.49792424e-02f, 6.76439479e-02f, -7.62331784e-02f, -3.50666023e-03f, 7.81101510e-02f, 2.35388055e-02f, 1.03479318e-01f, -5.60853146e-02f,
  4.07548212e-02f, -1.29733570e-02f, 6.37940988e-02f, -1.71767883e-02f, 4.61160131e-02f, 4.72732820e-03f, -2.32213698e-02f, 1.09238438e-01f, 1.21447228e-01f, -5.36546484e-03f,
  2.84198113e-02f, 7.27646872e-02f, 4.24055196e-02f, 1.86083633e-02f, -6.51939064e-02f, 1.07786134e-01f, -1.28048491e-02f, 6.85020983e-02f, 2.25549797e-03f, 2.50153057e-02f,
  -5.71180880e-03f, -2.81229932e-02f, -3.73790204e-03f, -1.20303154e-01f, -1.41097143e-01f, 7.79833123e-02f, -4.41143475e-03f, -3.80483828e-02f, 1.59181338e-02f, -2.21471205e-01f,
  -8.50289613e-02f, -9.13795903e-02f, 3.88681050e-03f, 4.54461686e-02f, 1.75370649e-02f, -2.73453798e-02f, 5.94866686e-02f, 7.11624846e-02f, 1.69805467e-01f, 1.94565862e-01f,
  -8.54712725e-02f, 7.94751644e-02f, -4.16449793e-02f, 1.45623693e-02f, -3.46356556e-02f, 9.53355618e-03f, -8.71584266e-02f, -2.84096096e-02f, -1.02119744e-02f, 9.97873470e-02f,
  -9.37637091e-02f, -2.22787157e-01f, 7.99942389e-02f, -4.41593155e-02f, -4.55224849e-02f, -1.42210469e-01f, -7.07291141e-02f, -2.18224879e-02f, -4.98532578e-02f, -2.20472887e-01f,
  -6.39704093e-02f, -9.15060192e-03f, 1.28851235e-02f, 5.54751828e-02f, 1.72854304e-01f, -7.79375853e-03f, 1.19156465e-02f, 1.35207688e-02f, 2.04065159e-01f, 8.36231411e-02f,
  -2.27465425e-02f, 1.08096041e-01f, -1.15465440e-01f, 2.78841872e-02f, -3.22674215e-03f, 2.07470492e-01f, -1.40714884e-01f, -2.17925720e-02f, -1.97031081e-01f, 5.80572430e-03f,
  1.54123828e-01f, 9.31724086e-02f, 4.80901860e-02f, 2.15026736e-01f, 1.75601080e-01f, -1.17407031e-01f, 1.80800855e-02f, 6.18760213e-02f, 2.06521481e-01f, 2.15549082e-01f,
  -4.00309600e-02f, -6.14344701e-02f, 1.01377340e-02f, -8.35295320e-02f, -6.01508282e-02f, 1.28624752e-01f, 9.19946097e-03f, 2.44354494e-02f, 6.03831857e-02f, -4.10529338e-02f,
  1.36622295e-01f, -1.65519714e-02f, -1.08619541e-01f, 3.48371342e-02f, -5.91362920e-03f, 2.07676943e-02f, -8.49392191e-02f, 4.64935936e-02f, 8.47327337e-02f, -5.53597920e-02f,
  -6.68959543e-02f, -7.21678138e-02f, 1.00128353e-01f, -4.05998230e-02f, -7.38391504e-02f, 7.89276958e-02f, 3.96832898e-02f, -1.08728521e-01f, -1.19180717e-01f, -7.33645260e-02f,
  -2.90134121e-02f, -8.47609993e-03f, 3.45155858e-02f, 6.57666400e-02f, -7.95853883e-02f, 1.07658222e-01f, -1.92416105e-02f, -4.68759798e-03f, 6.73367381e-02f, -4.90207747e-02f,
  -2.91647948e-02f, 5.16918972e-02f, 1.44416075e-02f, -7.21570253e-02f, 3.32539305e-02f, -1.63719449e-02f, 9.97693092e-02f, -4.93827648e-02f, 5.22168316e-02f, 1.43112615e-02f,
  1.15789883e-02f, 5.45960441e-02f, 1.89150304e-01f, 4.21651974e-02f, -1.16895869e-01f, -9.41377059e-02f, -9.01280716e-02f, 9.46322456e-02f, -8.02203044e-02f, 9.62106064e-02f,
  -7.27479681e-02f, 1.26098432e-02f, 7.41895214e-02f, 5.26374243e-02f, 1.42603561e-01f, 4.91570821e-03f, 7.22584352e-02f, 1.17808037e-01f, 1.28864020e-01f, -4.66443524e-02f,
  1.43426424e-02f, 8.40989873e-03f, 1.05070561e-01f, -2.42032036e-02f, 1.68600515e-01f, -1.66045297e-02f, -8.00585747e-02f, 1.34868938e-02f, 1.34993359e-01f, 1.18158579e-01f,
  -1.04324654e-01f, -7.94258565e-02f, 2.71090288e-02f, 1.28194941e-02f, 4.95464504e-02f, -2.09184781e-01f, 6.44441247e-02f, -1.36872575e-01f, 2.72373296e-02f, -1.35694340e-01f,
  -7.04308674e-02f, -1.69135913e-01f, -1.04737386e-01f, -1.58902347e-01f, 1.13863178e-01f, -5.43736033e-02f, -6.54586852e-02f, 6.60459474e-02f, -1.44707024e-01f, 1.27974942e-01f,
  4.30466346e-02f, -1.33062452e-01f, -1.91762775e-01f, -1.86141264e-02f, -7.52658173e-02f, 4.91822474e-02f, -2.17326000e-01f, -4.22481261e-02f, 1.02732368e-01f, 1.82039902e-01f,
  -3.26262899e-02f, 9.70034525e-02f, -5.24415933e-02f, -8.88427943e-02f, 2.55276233e-01f, -3.05697066e-03f, -2.00023949e-01f, -2.64927238e-01f, 1.22386590e-01f, 8.21470171e-02f,
  -2.15563532e-02f, -2.66699344e-01f, 1.56438828e-01f, -6.06602058e-02f, 1.60078153e-01f, 2.07878977e-01f, -5.75677454e-02f, -1.21050365e-01f, -2.29257196e-02f, -9.57003981e-02f,
  -4.40245531e-02f, -1.74860489e-02f, 1.38468042e-01f, -7.81425312e-02f, -3.18205580e-02f, -5.14865927e-02f, 1.00220516e-01f, 6.64475486e-02f, -1.62321199e-02f, -1.76661946e-02f,
  9.22264829e-02f, -2.74389405e-02f, -7.72427842e-02f, -5.31322844e-02f, -9.50595550e-03f, 4.90730144e-02f, -3.40279900e-02f, -1.89085845e-02f, 2.18930319e-02f, 1.81542840e-02f,
  -1.00149468e-01f, 4.47548777e-02f, -6.03124164e-02f, 3.02732233e-02f, 1.82136577e-02f, -7.04383552e-02f, -9.54455510e-02f, -2.26856768e-02f, -4.95710932e-02f, -4.38298024e-02f,
  1.40771735e-02f, -9.44962800e-02f, -1.08822621e-01f, 2.23153154e-03f, 7.30932131e-02f, -8.14418122e-02f, 2.28896197e-02f, -5.74163795e-02f, -1.48436517e-01f, 2.37484220e-02f,
  1.31945029e-01f, 2.34514344e-02f, 1.37266777e-02f, 1.55434432e-02f, 9.22336616e-03f, 7.70419091e-02f, 1.77438576e-02f, -7.61136115e-02f, 1.18719742e-01f, -7.54094496e-02f,
  2.12565660e-01f, 5.00156544e-02f, -5.65549694e-02f, -1.04235187e-02f, -8.50186497e-03f, 1.60856992e-01f, -7.36586526e-02f, 1.95260212e-01f, -6.00702614e-02f, -4.96069863e-02f,
  -1.20830819e-01f, 3.26121897e-02f, 3.02574039e-02f, 4.35666740e-02f, 1.37898833e-01f, -2.38139793e-01f, 1.10209391e-01f, -2.71989778e-02f, -8.55578110e-02f, -5.89934587e-02f,
  1.87251084e-02f, -2.00098813e-01f, -1.13108568e-01f, 4.69842218e-02f, 1.77460343e-01f, -6.71401396e-02f, -1.24304615e-01f, -1.37898896e-03f, -1.62373886e-01f, 7.78000511e-04f,
  1.23177662e-01f, -2.78199941e-01f, 2.55066633e-01f, 3.99404056e-02f, -5.33014387e-02f, 1.76613078e-01f, -6.41805008e-02f, -5.60059510e-02f, -4.59349118e-02f, -3.17716599e-01f,
  -6.61174953e-02f, 3.85119580e-02f, -1.02296220e-02f, 7.35907117e-03f, -1.34896040e-01f, -2.57031560e-01f, -4.49139513e-02f, -1.07908010e-01f, -4.69111651e-02f, -6.96534663e-02f,
  -6.69787601e-02f, -6.86129034e-02f, 2.39716265e-02f, -5.22240810e-03f, 6.73863962e-02f, -8.60989019e-02f, 8.14749226e-02f, -4.26836945e-02f, -8.25290233e-02f, 1.25656053e-01f,
  -2.33563129e-02f, 2.56264776e-01f, -7.40072876e-03f, 1.74432546e-01f, 7.82855675e-02f, -2.89605614e-02f, 4.29534875e-02f, 3.62539530e-01f, -1.23889953e-01f, -1.69208661e-01f,
  2.16008946e-01f, -1.84147879e-01f, -6.31361604e-02f, -2.32842833e-01f, -4.26185131e-03f, 1.86420575e-01f, 7.26140216e-02f, 7.40340203e-02f, -4.87576192e-03f, -3.84580232e-02f,
  1.94369853e-02f, 5.25080226e-02f, -4.83021401e-02f, 3.83098908e-02f, -4.61654104e-02f, -6.11427836e-02f, -6.21880293e-02f, 9.22117084e-02f, -3.21285613e-02f, -5.62767982e-02f,
  1.14659257e-02f, 4.28712480e-02f, 6.14842735e-02f, 3.88970450e-02f, 2.37611439e-02f, -5.21996096e-02f, -7.53060207e-02f, 1.56106167e-02f, 2.00439766e-01f, 9.76152122e-02f,
  6.46493630e-04f, 4.37838845e-02f, 5.09465970e-02f, 2.44402681e-02f, -9.91165787e-02f, 8.32907632e-02f, 6.07066415e-02f, 3.99155803e-02f, 1.30823478e-01f, 1.20096177e-01f,
  6.74437732e-02f, 1.82802062e-02f, 1.09279417e-01f, 8.80441070e-02f, 1.45138800e-01f, 1.04758479e-01f, 3.34499143e-02f, 5.35094067e-02f, 1.75070961e-03f, 1.14736125e-01f,
  -1.03441909e-01f, -7.09876940e-02f, 4.88383211e-02f, 7.99686834e-02f, 4.64864150e-02f, -1.23457320e-01f, -6.12173267e-02f, -8.94004107e-02f, 2.25029420e-02f, 9.12414491e-02f,
  2.04344224e-02f, -1.53726861e-01f, -2.04219427e-02f, 3.31651717e-02f, -2.92387418e-02f, 1.12255611e-01f, 4.21109656e-03f, 2.55342163e-02f, 1.82372201e-02f, -7.88412057e-03f,
  9.85993668e-02f, -9.90609825e-02f, 4.50091138e-02f, 5.87419383e-02f, 6.69538528e-02f, 6.08415157e-03f, -3.06741502e-02f, 9.36860405e-03f, -2.56591383e-02f, -1.79499723e-02f,
  -1.31403700e-01f, -1.64880663e-01f, -1.25076205e-01f, 3.85559462e-02f, -1.27121415e-02f, 2.49960255e-02f, -3.68538573e-02f, -1.96101874e-01f, 9.60508212e-02f, -8.23269933e-02f,
  -8.92495438e-02f, -9.06044245e-02f, 1.02589279e-01f, -1.73958451e-01f, 5.40379174e-02f, 1.51607990e-01f, -1.27153238e-02f, -5.11859767e-02f, -7.69357309e-02f, -3.52126360e-02f,
  -1.36095896e-01f, -3.68166976e-02f, 2.44874973e-02f, -2.76078992e-02f, 1.28522068e-01f, -8.54380429e-02f, -1.37588039e-01f, -1.12378389e-01f, 8.72341916e-03f, 1.13359667e-01f,
  1.47389412e-01f, 1.93181336e-02f, -7.54510835e-02f, -2.60190725e-01f, 3.14367190e-02f, -1.39504656e-01f, 1.07983060e-01f, -5.28885648e-02f, 7.41682425e-02f, -1.09311812e-01f,
  8.27712044e-02f, 9.22107771e-02f, -1.27819687e-01f, 1.54804215e-01f, -1.49125792e-02f, 2.24664658e-02f, -1.63429424e-01f, -1.55259475e-01f, -2.17219498e-02f, 2.11651355e-01f,
  -8.42841566e-02f, 1.68038726e-01f, -1.06528468e-01f, 2.88759731e-02f, 7.04728514e-02f, -1.46866277e-01f, -8.24381486e-02f, -2.65352372e-02f, -5.53627834e-02f, -3.93418036e-02f,
  -4.76431921e-02f, 3.49494964e-02f, -5.48239537e-02f, -1.40146948e-02f, -2.18456145e-02f, 1.45342480e-02f, 3.42860743e-02f, -3.17377001e-02f, 4.94950265e-02f, -1.55684818e-02f,
  -1.03051208e-01f, 6.96932226e-02f, 3.28782909e-02f, 1.83903482e-02f, 2.47156285e-02f, 1.19970568e-01f, -1.28657762e-02f, 1.27454057e-01f, -2.48866621e-02f, 8.20497647e-02f,
  -3.44116613e-02f, -1.23146988e-01f, 1.00269139e-01f, 2.14484334e-02f, -6.26432970e-02f, -3.30949351e-02f, -1.59215495e-01f, -6.43259138e-02f, 3.98932770e-02f, -4.00448497e-03f,
  -1.31501183e-01f, 3.71522121e-02f, -2.00296808e-02f, -1.25562381e-02f, -4.78885248e-02f, -3.31370905e-02f, -2.55506355e-02f, 3.16629186e-02f, -6.88152853e-03f, 1.89476684e-02f,
  -6.26736805e-02f, 1.92574027e-03f, -3.97573747e-02f, -2.70230845e-02f, -4.08967026e-02f, -7.75596872e-02f, 1.09115906e-01f, -1.75506230e-02f, -1.10453203e-01f, -5.31333871e-02f,
  -5.77463433e-02f, 3.66205769e-03f, -8.51425156e-02f, -1.26208797e-01f, -2.58543007e-02f, 3.55691016e-02f, -1.76661871e-02f, 1.65469851e-02f, 2.64781956e-02f, 2.32454911e-02f,
  -4.92619835e-02f, -9.11477506e-02f, -1.37608707e-01f, -2.61013191e-02f, -9.80751589e-02f, -2.11138595e-02f, 3.77615951e-02f, -2.15242848e-01f, -7.15929866e-02f, 2.25471154e-01f,
  1.95275664e-01f, 2.25466546e-02f, 4.01559658e-02f, -8.30206722e-02f, -4.93990956e-03f, 1.29091606e-01f, -6.99118823e-02f, -8.22907537e-02f, -3.39360796e-02f, 1.20179862e-01f,
  -1.84795529e-01f, 2.46175975e-01f, -2.02569529e-01f, -1.27036899e-01f, 8.01745951e-02f, -3.71900983e-02f, 1.10778302e-01f, 2.43134443e-02f, 9.42616723e-03f, 9.28691868e-03f,
  -1.96105745e-02f, -1.34716243e-01f, -2.51552593e-02f, -1.46667108e-01f, -1.03519462e-01f, 2.43586153e-01f, -2.29595825e-02f, -4.67337407e-02f, 7.44627742e-03f, 1.33347511e-01f,
  8.28518644e-02f, 1.40733764e-01f, -4.82179038e-02f, -1.04018062e-01f, 1.23375103e-01f, -1.60611153e-01f, -1.30293313e-02f, 3.18987250e-01f, -1.02831453e-01f, 2.09708400e-02f,
  -1.26846001e-01f, 1.56604558e-01f, -1.64120179e-02f, 1.96702257e-01f, 4.20122854e-02f, 2.07590640e-01f, 1.02430463e-01f, -2.51572341e-01f, 1.83945373e-01f, -1.99433103e-01f,
  1.72218040e-01f, -2.42723874e-03f, 1.77203713e-03f, -1.19757935e-01f, 3.59529145e-02f, -3.70985828e-02f, 8.79890025e-02f, -3.28931101e-02f, -7.48257414e-02f, -1.38447985e-01f,
  2.90810540e-02f, 9.85926092e-02f, -6.64778054e-02f, -1.19834794e-02f, -3.30794901e-02f, -6.14171736e-02f, 3.24003352e-03f, -3.71984430e-02f, 1.02799885e-01f, -4.03290130e-02f,
  1.05204687e-01f, -4.18884531e-02f, 5.69137596e-02f, -1.22489594e-01f, -6.29827380e-02f, 6.11658320e-02f, 3.05058323e-02f, 1.49235437e-02f, -6.35929629e-02f, -3.01892795e-02f,
  5.45913726e-02f, 3.85269262e-02f, 2.54014740e-03f, -4.52444553e-02f, -7.44257346e-02f, -4.49072868e-02f, 3.54597270e-02f, -2.85239741e-02f, -8.96309614e-02f, -5.65007515e-03f,
  -4.11983654e-02f, 1.64110977e-02f, -1.89654641e-02f, -6.09592013e-02f, 7.24607185e-02f, -2.19838265e-02f, 5.08360565e-02f, 1.18984826e-01f, 8.06420576e-03f, 1.28198102e-01f,
  9.66649950e-02f, 7.56438300e-02f, -6.96329623e-02f, 1.64218359e-02f, 1.22800261e-01f, 6.34430647e-02f, 1.53922737e-01f, -3.26258806e-03f, -2.84728836e-02f, 9.92931277e-02f,
  1.31308377e-01f, -1.97235554e-01f, -8.85903388e-02f, -1.12995831e-02f, -4.68713120e-02f, 5.80728725e-02f, 1.33286223e-01f, -2.61625554e-02f, 9.71605107e-02f, -4.50142846e-02f,
  -1.12475380e-01f, -2.41387961e-03f, -1.17490597e-01f, -3.34229320e-02f, 3.06366868e-02f, -1.06725112e-01f, 1.20427638e-01f, 3.91149633e-02f, 1.42261256e-02f, 3.47827040e-02f,
  4.47706785e-03f, -1.06599726e-01f, -2.91178133e-02f, -1.41167389e-02f, -9.39413831e-02f, 3.21663767e-02f, 5.76698072e-02f, -1.10737413e-01f, -3.92645113e-02f, 1.08939998e-01f,
  -2.29166090e-01f, -2.07627922e-01f, -4.29138402e-03f, -1.43803120e-01f, 6.97881654e-02f, 5.57591952e-03f, -5.00189923e-02f, -1.05644362e-02f, -9.95374173e-02f, -2.20515326e-01f,
  2.38998681e-02f, -1.34162396e-01f, -7.32055008e-02f, 5.85120209e-02f, -2.50102449e-02f, -2.51391586e-02f, 1.83852110e-02f, 2.18297187e-02f, 3.46770257e-01f, 1.55493170e-01f,
  3.35503668e-02f, 1.16027286e-02f, -1.13407038e-01f, -2.61581149e-02f, -1.30508929e-01f, 2.07648560e-01f, -1.59208421e-02f, 1.36124313e-01f, 1.68433972e-02f, 5.81887662e-02f,
  -1.19420350e-01f, 2.83986300e-01f, -1.58678871e-02f, -1.32443845e-01f, 6.73158541e-02f, -1.34623751e-01f, -5.34160733e-02f, 7.23172501e-02f, 5.99724799e-02f, 1.19881995e-01f,
  -1.18956938e-01f, -8.29054117e-02f, -6.91867899e-03f, 5.19394269e-03f, 6.68839067e-02f, -1.42395496e-01f, 2.51159295e-02f, -5.59400916e-02f, 7.72782564e-02f, -6.29092231e-02f,
  6.29462972e-02f, -5.96863665e-02f, -1.49447873e-01f, -7.21601248e-02f, -3.85304242e-02f, -1.61455702e-02f, -1.42917931e-02f, -4.19662185e-02f, -9.23696160e-02f, -7.10501298e-02f,
  4.93477099e-02f, -1.24702983e-01f, -1.66904226e-01f, -1.70224443e-01f, -5.22710942e-02f, -4.44410555e-02f, -3.48613225e-02f, -7.97030404e-02f, -8.07266962e-03f, -2.15022918e-02f,
  9.12171379e-02f, 9.79872700e-03f, 2.07558610e-02f, -1.44115597e-01f, -5.72237968e-02f, 7.78556094e-02f, -1.87982872e-01f, -7.27679208e-02f, -1.58363193e-01f, -6.11345172e-02f,
  -4.83476333e-02f, -9.87615213e-02f, 6.52472861e-03f, -5.94074391e-02f, 7.09185451e-02f, 5.65167749e-03f, 7.46380016e-02f, 7.67337391e-03f, -7.56910164e-03f, -6.39529824e-02f,
  4.58775312e-02f, 5.26989922e-02f, 1.12061031e-01f, 8.58751610e-02f, 1.48512647e-01f, 7.25115985e-02f, 8.85853097e-02f, -1.96413994e-02f, 2.23068930e-02f, -1.26214912e-02f,
  -4.49887849e-02f, -1.86957985e-01f, -4.85758148e-02f, 1.04890382e-02f, -4.41268198e-02f, 7.87288882e-03f, -7.02191517e-02f, -1.27178645e-02f, -6.36506751e-02f, 4.15077657e-02f,
  6.16985783e-02f, 1.37092307e-01f, -1.28329601e-02f, 3.54758166e-02f, 9.05080065e-02f, 1.16119809e-01f, 5.89796975e-02f, -4.91220504e-03f, 1.07057743e-01f, -3.39451991e-02f,
  -2.85559380e-03f, 1.08293884e-01f, -1.21486083e-01f, 2.08732530e-01f, 1.39639124e-01f, -6.74334168e-03f, 1.47105353e-02f, -3.85739421e-03f, 1.44441854e-02f, 3.93990651e-02f,
  1.28757775e-01f, 2.99426883e-01f, -1.33881308e-02f, 1.29849911e-01f, 1.10522583e-02f, 5.30327074e-02f, 2.20593531e-02f, 1.40210735e-02f, -1.46035939e-01f, 3.09783127e-02f,
  -5.28723262e-02f, 1.64955020e-01f, -2.34633043e-01f, 6.56722859e-03f, -7.15520754e-02f, -9.76228714e-02f, -1.35550857e-01f, 5.31720109e-02f, 1.45360008e-01f, -5.07979952e-02f,
  7.48525858e-02f, -4.38762419e-02f, 5.18123880e-02f, 4.19858210e-02f, 6.97227344e-02f, 1.33058235e-01f, -1.35647655e-01f, -8.05444643e-02f, -4.86034453e-01f, -1.18159376e-01f,
  -2.15129748e-01f, 1.92387700e-01f, 1.07482806e-01f, 7.27352276e-02f, 6.46259040e-02f, 2.73948116e-03f, 2.66255617e-01f, 8.67314115e-02f, -9.32933763e-03f, 1.08009018e-01f,
  -2.83393078e-03f, 5.06560244e-02f, -8.61560255e-02f, -3.71023193e-02f, -6.84494153e-02f, 8.61062557e-02f, -4.24420163e-02f, -3.75940255e-03f, 2.25853138e-02f, -6.06197305e-02f,
  -1.86286382e-02f, 1.30272925e-01f, -8.47677886e-02f, 4.61535202e-03f, -5.20383269e-02f, -3.83475833e-02f, 2.04290003e-02f, -1.11260461e-02f, -6.80530518e-02f, 2.43983753e-02f,
  1.01227232e-03f, 7.32193366e-02f, 2.24070670e-03f, -1.18720412e-01f, -9.40950364e-02f, -2.27508377e-02f, -5.42470701e-02f, 1.05873987e-01f, 7.88395479e-02f, 7.05697015e-02f,
  1.22722156e-01f, 2.51045916e-02f, -1.55041730e-02f, -1.01771891e-01f, -1.43494746e-02f, 7.75267482e-02f, -5.79719134e-02f, 1.27841616e-02f, 5.82526587e-02f, 8.99417978e-03f,
  -7.33991480e-03f, -1.53122634e-01f, -4.90943016e-03f, -8.82154852e-02f, -7.67507181e-02f, -7.74033964e-02f, 4.77787554e-02f, -5.48659228e-02f, 7.65514076e-02f, 3.31624150e-02f,
  -1.25853300e-01f, -9.26210135e-02f, 7.25134686e-02f, 5.62125817e-02f, 5.87578006e-02f, -1.62770674e-01f, -4.83661629e-02f, 3.53563903e-03f, 1.81120704e-03f, -4.87469137e-03f,
  -4.61648731e-03f, -9.72014442e-02f, -4.48206142e-02f, -2.24023983e-02f, -5.72878793e-02f, 3.80687527e-02f, -3.69917378e-02f, 1.37369618e-01f, -2.36111153e-02f, 3.04718921e-03f,
  -1.15211159e-01f, 8.97944197e-02f, 7.28449076e-02f, -4.27501239e-02f, -1.87851973e-02f, 2.42740307e-02f, 2.30693426e-02f, -4.61283810e-02f, 1.09856218e-01f, 9.61602703e-02f,
  -6.55989302e-03f, -4.31771465e-02f, -1.21530145e-01f, 1.74401671e-01f, 1.65842324e-01f, -6.74405135e-03f, 1.77255362e-01f, 1.66909561e-01f, -1.03946850e-02f, 1.20073773e-01f,
  -1.56461466e-02f, 4.72414792e-02f, 8.66862386e-02f, 3.43244821e-02f, 6.78593442e-02f, 1.35822028e-01f, 1.17865041e-01f, -1.04804672e-01f, -1.82493091e-01f, 1.48431420e-01f,
  -1.94496848e-02f, 4.84646298e-02f, -8.37967023e-02f, 4.44187447e-02f, -1.59757107e-01f, -1.56813100e-01f, 1.16170265e-01f, -8.67307838e-03f, 1.52828559e-01f, -7.58251129e-03f,
  1.39645323e-01f, -7.10383356e-02f, -9.62009206e-02f, 1.46346644e-01f, 7.23326430e-02f, 8.42427909e-02f, -4.22607772e-02f, -1.96838573e-01f, -7.08680227e-02f, 1.52561039e-01f,
  -1.67874530e-01f, -7.76503161e-02f, -1.09767476e-02f, -1.10622056e-01f, 8.45429227e-02f, 1.04621155e-02f, -4.36040610e-02f, -4.66973037e-02f, -5.43895774e-02f, 1.07172936e-01f,
  -5.21645993e-02f, 2.78350711e-02f, 1.28456637e-01f, 2.08089929e-02f, 1.98845729e-01f, -5.97219765e-02f, 7.31181428e-02f, -1.59797072e-02f, -1.94528094e-03f, -1.06985874e-01f,
  -1.35874851e-02f, -1.38003808e-02f, 4.58741095e-03f, -9.88682583e-02f, -4.17565368e-02f, -5.97589128e-02f, 5.97489141e-02f, 3.15214996e-03f, -1.35962032e-02f, 3.40063758e-02f,
  -6.71617240e-02f, -1.34619102e-02f, 1.49630811e-02f, -2.35549477e-03f, -1.29253538e-02f, 5.33747040e-02f, 2.21635103e-02f, -1.17517509e-01f, -9.14616585e-02f, 6.74761692e-03f,
  -4.46518185e-03f, -9.84403342e-02f, 6.14976957e-02f, -1.66918620e-01f, 2.58142082e-03f, 7.48085454e-02f, 2.18900312e-02f, -4.04058071e-03f, 2.02510785e-02f, -1.25952791e-02f,
  1.42841756e-01f, 8.83967895e-03f, 1.73701063e-01f, -1.94021165e-02f, -1.05067223e-01f, 7.28479773e-02f, -4.03592028e-02f, 7.95463473e-02f, 3.84987891e-02f, -4.17812355e-03f,
  -1.29063185e-02f, -1.27503080e-02f, 8.44068080e-02f, -1.59271918e-02f, 7.46953636e-02f, 2.29791924e-01f, 1.21048521e-02f, 5.35207707e-03f, 8.20819847e-03f, 7.23018646e-02f,
  2.02131644e-02f, -3.41493972e-02f, 1.55366451e-01f, -4.72145937e-02f, 2.15638056e-02f, 1.59989689e-02f, 4.78441007e-02f, -1.28653785e-02f, 1.51254572e-02f, -1.35548636e-01f,
  -1.34109572e-01f, 1.39763400e-01f, 1.49384260e-01f, 1.92592479e-02f, -1.09421954e-01f, 8.17106441e-02f, -2.61114687e-02f, -1.74037740e-02f, 6.80810884e-02f, -2.07612514e-01f,
  -1.76723711e-02f, 9.88320112e-02f, 1.62467565e-02f, 1.05074652e-01f, 4.83297855e-02f, -5.69658503e-02f, 7.07344040e-02f, -1.63669750e-01f, -8.98523033e-02f, 1.61946807e-02f,
  -1.21731214e-01f, 1.98490620e-02f, -1.08510435e-01f, -2.16139719e-01f, -1.19007081e-01f, -3.71800661e-02f, 7.35305473e-02f, 4.48765270e-02f, -8.29772949e-02f, -2.19466295e-02f,
  -2.69439500e-02f, 3.50128412e-02f, 5.22791483e-02f, -1.43521801e-01f, -1.61969308e-02f, -6.84777349e-02f, -1.15766779e-01f, 1.23746008e-01f, -2.56917216e-02f, 2.40325734e-01f,
  -1.11892946e-01f, 8.09409767e-02f, 1.46576948e-02f, -6.12109788e-02f, 2.04462960e-01f, 1.58405334e-01f, -1.21680662e-01f, 6.63243458e-02f, 2.13718697e-01f, 4.04470637e-02f,
  3.87988687e-02f, -1.00106105e-01f, 2.53325887e-02f, 1.91400558e-01f, -5.32881878e-02f, 1.11795917e-01f, -6.19528219e-02f, 4.18619700e-02f, 2.94921305e-02f, -4.31545861e-02f,
  -3.44416387e-02f, -4.40553091e-02f, 2.50469238e-01f, -6.38458431e-02f, -8.47610459e-02f, -2.88420282e-02f, 3.50870118e-02f, -7.05612684e-03f, -8.71126503e-02f, -9.59933102e-02f,
  -1.18054718e-01f, 8.88196081e-02f, 9.26721469e-02f, 6.31421506e-02f, -9.07028541e-02f, -7.53387734e-02f, 1.70359313e-02f, -4.81969640e-02f, 2.96223052e-02f, 4.46682759e-02f,
  1.74744017e-02f, -4.29788306e-02f, -9.59935784e-03f, 3.02921347e-02f, -7.02966675e-02f, -1.25010461e-01f, -1.52789345e-02f, -1.30876619e-02f, -2.53770780e-02f, -8.37837532e-03f,
  4.08538915e-02f, -8.33524466e-02f, -1.44230604e-01f, 4.44942601e-02f, -4.68551600e-03f, 1.19719699e-01f, 1.25918821e-01f, -1.25219315e-01f, 2.47044384e-01f, 3.13766673e-02f,
  7.17406943e-02f, -1.31061018e-01f, -8.97011813e-03f, -1.39143601e-01f, -9.13598388e-02f, 4.90548536e-02f, 4.55266237e-02f, 2.79933456e-02f, -8.26305225e-02f, -2.18179934e-02f,
  4.00914736e-02f, -1.00190766e-01f, 8.28575268e-02f, 2.19985485e-01f, -7.33008012e-02f, -2.64418591e-03f, 4.70848978e-02f, 9.01040900e-03f, 1.24691622e-02f, -7.21778646e-02f,
  -1.78303886e-02f, -1.34916425e-01f, 1.29102136e-03f, 2.51761079e-02f, 9.92871672e-02f, -1.12746641e-01f, 2.76541486e-02f, 7.52796233e-02f, -2.43134261e-03f, 5.65852374e-02f,
  1.12596534e-01f, 8.28271359e-02f, 5.46749905e-02f, -3.76380570e-02f, 8.80009234e-02f, 1.11320004e-01f, -3.73785868e-02f, 3.75220855e-03f, -7.67406598e-02f, 1.96805716e-01f,
  -3.56853120e-02f, 1.00492924e-01f, -3.85366082e-02f, 1.87229346e-02f, 7.25700632e-02f, 3.12892012e-02f, -7.93749094e-02f, 3.28249782e-02f, 8.92383829e-02f, -8.02664086e-02f,
  5.76094091e-02f, -8.47588945e-03f, -9.75553319e-02f, 1.43976137e-02f, -1.57268703e-01f, 1.07178306e-02f, -2.38035806e-02f, -2.10283343e-02f, -2.33488157e-01f, 1.76834300e-01f,
  6.25358522e-02f, -1.89578906e-02f, 2.08684191e-01f, -1.99857876e-02f, 1.28541619e-01f, -4.41113114e-02f, 1.37033165e-01f, 1.40963301e-01f, -1.35784045e-01f, 3.60412121e-01f,
  -1.90686837e-01f, -1.90964818e-01f, 1.89859301e-01f, -2.54770312e-02f, 1.15587153e-01f, 2.76523620e-01f, 1.96673915e-01f, -1.14913039e-01f, 9.40271020e-02f, -1.08817309e-01f,
  1.83279261e-01f, 3.02216589e-01f, -7.14986473e-02f, 6.85986876e-02f, -6.49404228e-02f, -2.88085509e-02f, 9.77197587e-02f, -5.57443127e-03f, -7.78714120e-02f, -3.41377370e-02f,
  -7.49175809e-03f, 3.92069183e-02f, 3.91260982e-02f, 1.02616139e-01f, 7.03866556e-02f, -2.35319566e-02f, 6.18353970e-02f, 7.81748593e-02f, 8.76659229e-02f, -7.78710172e-02f,
  -9.19756144e-02f, -4.29393444e-03f, 6.21203966e-02f, 1.92792378e-02f, 7.63898417e-02f, 8.79856199e-02f, 3.95113155e-02f, -7.64276832e-02f, -2.43312214e-02f, 1.92089367e-03f,
  6.68833330e-02f, 7.40267485e-02f, -3.33508551e-02f, -6.30662963e-02f, -2.07845755e-02f, -7.92656094e-02f, 5.83496802e-02f, -4.32023518e-02f, 4.79341857e-03f, 1.92072242e-02f,
  -5.53986169e-02f, 1.69525165e-02f, -3.64264543e-03f, -1.27407223e-01f, -4.84960387e-03f, 9.87423509e-02f, 9.34955850e-03f, 5.51003218e-02f, 9.06340927e-02f, -4.77439649e-02f,
  1.83517516e-01f, -4.53889146e-02f, -6.23978302e-02f, 3.13144065e-02f, 5.75180203e-02f, -1.25073809e-02f, 6.73935711e-02f, -6.08720407e-02f, -2.85915360e-02f, 1.51259825e-01f,
  1.66960940e-01f, -1.30219191e-01f, 9.85701010e-03f, 1.80785134e-01f, -4.29643355e-02f, 3.74320894e-02f, -3.91696468e-02f, -2.30974406e-02f, -4.20851773e-03f, -6.72822725e-03f,
  8.77930149e-02f, 1.64466929e-02f, 9.27728266e-02f, -1.13867939e-01f, 4.83570993e-02f, 1.66845862e-02f, -1.72440112e-01f, 1.95234902e-02f, 1.07863620e-01f, -6.47004172e-02f,
  -1.57665536e-01f, -4.54505756e-02f, 7.89965317e-02f, 1.07213698e-01f, 5.24464212e-02f, -2.31869817e-01f, -4.47533429e-02f, -6.16535544e-02f, -1.45364776e-01f, 2.39324197e-01f,
  5.02727479e-02f, 6.02691807e-02f, 6.75849840e-02f, -1.10516697e-01f, 8.46394598e-02f, 4.54281494e-02f, -3.49531732e-02f, 3.97363268e-02f, 5.84098161e-04f, 4.85931113e-02f,
  3.09231076e-02f, -4.45147045e-02f, 6.97759166e-02f, 2.75099110e-02f, -7.17963353e-02f, 1.16283812e-01f, -3.19699235e-02f, 5.35713434e-02f, 3.35898817e-01f, -1.77717239e-01f,
  2.57600229e-02f, 6.77278787e-02f, 1.91199049e-01f, 1.37644112e-01f, 7.23920465e-02f, -6.04638346e-02f, -1.74683586e-01f, -3.15375216e-02f, 3.17620486e-02f, 9.41061974e-02f,
  9.74710658e-02f, 1.11142322e-01f, 1.64491348e-02f, -2.27133751e-01f, -1.26589596e-01f, -8.34884867e-03f, -2.53512442e-01f, 1.02104165e-01f, -1.32845178e-01f, -7.33919144e-02f,
  7.54326284e-02f, 1.21829160e-01f, 2.18830556e-02f, -4.21762560e-03f, -2.16113664e-02f, -4.52446565e-02f, -5.02218530e-02f, 1.73931755e-02f, 6.68047965e-02f, 7.40218966e-04f,
  8.68317112e-02f, -7.71490708e-02f, -2.03766469e-02f, 3.62896174e-03f, 1.34203350e-02f, 4.66163456e-03f, -5.85556915e-03f, -3.47787216e-02f, -5.80767766e-02f, 4.27184962e-02f,
  -7.10089365e-03f, 3.55045572e-02f, -4.17608842e-02f, -2.47319378e-02f, -3.05733401e-02f, -2.00707167e-02f, 8.43270570e-02f, 4.87577058e-02f, -9.07247886e-03f, -4.55129668e-02f,
  3.33573595e-02f, -1.11826912e-01f, 1.97490305e-02f, 3.70425321e-02f, -8.29520077e-02f, -7.50780702e-02f, -4.74039428e-02f, -4.33391780e-02f, -3.94581184e-02f, 4.72732447e-03f,
  7.30185956e-02f, 4.01687659e-02f, -1.13228098e-01f, -7.24374503e-02f, -6.90435944e-03f, 5.67868017e-02f, -7.26700411e-04f, -2.44419556e-02f, -9.71155893e-03f, 1.68662425e-02f,
  -4.54776436e-02f, 1.07376464e-01f, -5.57032712e-02f, -1.63654134e-01f, 2.01233864e-01f, -7.34160542e-02f, 5.08886948e-02f, -2.71083545e-02f, -7.75129497e-02f, 4.98804599e-02f,
  1.13438126e-02f, 1.05543815e-01f, 1.76148847e-01f, 4.67354469e-02f, -6.16696365e-02f, -1.09876506e-01f, 6.34602681e-02f, 6.46828767e-03f, 9.10026804e-02f, 7.14470819e-02f,
  5.18635400e-02f, -1.28588736e-01f, 1.14427246e-02f, -9.17680413e-02f, -1.65924549e-01f, -8.05954039e-02f, -3.22999135e-02f, -1.68804690e-01f, -3.58748063e-02f, 9.32612866e-02f,
  1.06753401e-01f, 3.77822854e-02f, -5.60863912e-02f, -8.67517591e-02f, -1.34192467e-01f, 1.96887866e-01f, 2.31724116e-03f, 3.80291929e-03f, 1.65298939e-01f, 2.04719454e-01f,
  9.70154330e-02f, -1.82557493e-01f, -1.64149821e-01f, -1.02497973e-01f, 3.50506157e-02f, -4.21486050e-02f, 7.96826184e-02f, 2.67047212e-02f, 1.04685590e-01f, 2.19759896e-01f,
  6.59559434e-03f, 2.99074519e-02f, -2.58494839e-02f, 1.52431428e-01f, 2.91101754e-01f, -1.16852023e-01f, 1.18436657e-01f, -2.94886172e-01f, -8.78689066e-02f, -6.13334402e-02f,
  -1.00987919e-01f, -2.84704398e-02f, 1.07470304e-01f, -8.36525038e-02f, -1.26265958e-01f, -1.50828129e-02f, 3.26673090e-01f, 2.28991434e-02f, 2.89711863e-01f, -1.56880766e-01f,
  1.04391268e-02f, -1.41402513e-01f, -5.31531647e-02f, -1.72889933e-01f, -2.86658198e-01f, -5.62868193e-02f, -2.63562471e-01f, -1.23941740e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  8.21858421e-02f, -6.53977226e-03f, 1.17828429e-03f, 4.24685329e-02f, 1.14769079e-01f, -3.45439464e-02f, 7.30435401e-02f, 8.38951543e-02f, -4.90796715e-02f, 9.18899104e-02f,
  1.38278306e-01f, -6.49362355e-02f, 5.56258820e-02f, 1.07576206e-01f, -4.49363850e-02f, 1.80956379e-01f, 9.85551849e-02f, -4.79494780e-02f, -5.49457222e-02f, 5.11579635e-03f,
  5.08931205e-02f, -4.66781706e-02f, 6.81268424e-02f, 6.99293390e-02f, -1.22635543e-01f, 7.91612640e-02f, 1.31878462e-02f, 1.50121972e-02f, -1.61812261e-01f, 1.04196139e-01f,
  2.01989748e-02f, 7.67354202e-03f, 4.00111265e-02f, 5.18070683e-02f, 9.70812365e-02f, 1.81627020e-01f, 7.94453621e-02f, 1.32313778e-03f, 1.80304945e-01f, 1.05213942e-02f,
  1.40247256e-01f, -1.50250599e-01f, 1.00615181e-01f, 1.36923641e-01f, -6.92578331e-02f, 1.88955680e-01f, 1.99284762e-01f, 5.61025329e-02f, 4.72371392e-02f, -1.70991607e-02f,
  -4.55731675e-02f, 1.14302322e-01f, 1.13079868e-01f, 8.31371099e-02f, 4.96682711e-02f, 1.26263902e-01f, -1.98923387e-02f, 7.31211901e-02f, 1.01664416e-01f, 2.68656239e-02f,
  -3.67028899e-02f, -2.23811027e-02f, 1.15696266e-01f, 4.11251150e-02f, -1.08083680e-01f, 7.20058009e-02f, 3.67683582e-02f, -1.87282473e-01f, 1.38476998e-01f, -1.36204675e-01f,
  1.94683537e-01f, -3.76093527e-03f, 5.67529611e-02f, 1.43317983e-01f, 2.24569082e-01f, -5.67849837e-02f, -1.36776298e-01f, 3.07037458e-02f, -1.45089794e-02f, 2.97363520e-01f,
  2.15462726e-02f, -5.15827676e-03f, -3.90489548e-02f, 8.03717524e-02f, -2.04156712e-01f, -1.67254850e-01f, 3.21271792e-02f, -1.61212325e-01f, 3.57284658e-02f, -5.21634854e-02f,
  -9.11442712e-02f, 1.05251282e-01f, -9.75485146e-02f, 4.87351008e-02f, -1.11940531e-02f, -4.94151153e-02f, -2.39813551e-02f, 7.41628557e-02f, 7.10633909e-03f, 1.53412893e-02f,
  3.31612714e-02f, -6.71221986e-02f, 3.17910343e-01f, 1.12103168e-02f, -1.74566165e-01f, -7.92107955e-02f, 3.68597023e-02f, 8.95609893e-03f, -8.32333788e-02f, 1.54618546e-01f,
  -3.16472650e-02f, 4.12192242e-03f, 1.53568596e-01f, 2.28395630e-02f, 7.08020255e-02f, 1.01419412e-01f, -2.21224427e-01f, -2.21112564e-01f, 3.06284249e-01f, 8.41929093e-02f,
  3.00349325e-01f, -2.40871251e-01f, 9.36305672e-02f, -5.70355402e-03f, -1.34720691e-02f, 4.07044917e-01f, -4.48950790e-02f, 1.29493669e-01f, 7.11863935e-02f, 3.44620138e-01f,
  -2.11900361e-02f, 3.64924334e-02f, 1.31823152e-01f, 3.17571051e-02f, -6.62175342e-02f, 1.44667283e-01f, 9.77321267e-02f, 1.51959229e-02f, 4.36760671e-02f, -4.74537648e-02f,
  1.10045686e-01f, -1.20812180e-02f, -3.52093913e-02f, 3.20085622e-02f, 1.26202069e-02f, 8.43107849e-02f, 6.96151853e-02f, 7.08397776e-02f, 1.08651936e-01f, 1.11725472e-01f,
  1.59452230e-01f, 3.65399607e-02f, 1.91811040e-01f, 1.80261374e-01f, 1.19156130e-01f, 1.61538333e-01f, 5.60694560e-02f, 4.04648967e-02f, 6.29749149e-02f, 1.36258611e-02f,
  1.18895292e-01f, -6.66773319e-02f, 1.02136202e-01f, 1.50955886e-01f, 2.23875433e-01f, 1.87357381e-01f, 1.19725183e-01f, 9.49984640e-02f, 1.07333511e-01f, 2.33962432e-01f,
  -2.00567674e-02f, -9.19127092e-03f, 1.08744659e-01f, 9.72327366e-02f, 2.21568510e-01f, -3.65588069e-03f, 5.33100367e-02f, 1.27308816e-01f, 1.60766721e-01f, 8.50010887e-02f,
  -3.07172835e-02f, 1.18763205e-02f, -9.55527425e-02f, -1.94264382e-01f, 8.14990178e-02f, 5.84100373e-03f, -5.51201664e-02f, 2.16925830e-01f, 3.43975984e-02f, 2.41049752e-02f,
  1.94662258e-01f, -4.67456020e-02f, 3.03719696e-02f, 2.53579859e-03f, -2.69822460e-02f, 3.41372117e-02f, 1.89381048e-01f, 5.84362261e-02f, 4.33024392e-02f, 7.64553547e-02f,
  -7.03504980e-02f, -2.77781058e-02f, 1.57846078e-01f, -1.52398320e-02f, -2.94932246e-01f, 8.16876162e-03f, -1.44066975e-01f, 4.45249565e-02f, 1.12197176e-01f, -6.35177782e-03f,
  1.17537789e-01f, -1.45093784e-01f, -1.38995662e-01f, -4.98575333e-04f, 4.32659760e-02f, -2.30902344e-01f, 7.23577961e-02f, 1.04982547e-01f, -2.07827259e-02f, -1.93293840e-01f,
  -2.32899323e-01f, 2.85558403e-02f, 9.62411538e-02f, -1.53383315e-01f, 1.22862577e-01f, 2.42027596e-01f, 8.52715895e-02f, 3.99169587e-02f, 1.62922144e-02f, -2.92289406e-01f,
  6.68982714e-02f, 1.96860328e-01f, 1.18002273e-01f, -2.13928167e-02f, 1.02082863e-01f, -1.86278462e-01f, -1.52312234e-01f, -1.01093970e-01f, 1.73253417e-01f, -1.06951922e-01f,
  1.25485331e-01f, -9.97692645e-02f, -9.00021940e-02f, 9.80802253e-02f, 2.11450323e-01f, -5.92456721e-02f, 3.77385229e-01f, -2.21038803e-01f, 1.62580818e-01f, -9.86918435e-03f,
  -1.47189036e-01f, 1.79164439e-01f, 1.69476762e-01f, -1.24960586e-01f, 8.97757336e-02f, -4.02300507e-02f, 6.50908053e-02f, 4.35968228e-02f, 1.77481864e-02f, 1.29669541e-02f,
  -7.39879608e-02f, 4.16498035e-02f, 6.01877123e-02f, 1.14753991e-01f, 1.74852774e-01f, 2.59305388e-02f, 7.79585913e-02f, 5.16033284e-02f, 6.58682808e-02f, 1.31973554e-03f,
  8.92446339e-02f, 2.08381731e-02f, -1.79554932e-02f, 1.27791122e-01f, -2.72369925e-02f, 3.01540866e-02f, 5.02907969e-02f, 2.69728806e-02f, 1.83736794e-02f, 1.38750315e-01f,
  8.41792375e-02f, 1.78321764e-01f, 9.75105762e-02f, 3.55501436e-02f, 2.48838186e-01f, 5.74835911e-02f, -3.94050218e-02f, 5.98955229e-02f, -1.27419857e-02f, 7.16503859e-02f,
  1.08159639e-01f, 5.87775782e-02f, 1.50412008e-01f, 5.76171093e-02f, 5.40226959e-02f, -9.99409258e-02f, 7.12353364e-02f, 1.30766109e-01f, 1.14680849e-01f, -8.36418010e-03f,
  2.27706097e-02f, -2.66649853e-02f, 3.22857499e-02f, 1.43045709e-01f, -1.10335937e-02f, 6.97066262e-02f, 1.58239268e-02f, 6.13744557e-03f, 1.58482224e-01f, 1.57051042e-01f,
  -6.26039505e-02f, -7.71181285e-02f, 2.22561043e-02f, 1.26781300e-01f, -9.12756175e-02f, -1.99326035e-02f, -9.69983861e-02f, 9.06750560e-02f, 1.75581314e-02f, 4.56606522e-02f,
  -3.93117703e-02f, 1.17183834e-01f, 7.12209269e-02f, 5.09869680e-02f, 7.16331750e-02f, -1.08390391e-01f, -1.06048740e-01f, -5.80359772e-02f, -3.43479887e-02f, -3.31657290e-01f,
  -2.42663935e-01f, 3.93580608e-02f, -5.12915328e-02f, -6.27728030e-02f, -6.25037774e-02f, -5.11750653e-02f, 6.35474324e-02f, -1.54563308e-01f, -4.33212854e-02f, -2.40911901e-01f,
  2.38098335e-02f, -1.96461752e-01f, 6.24982752e-02f, -9.20245945e-02f, -5.83826154e-02f, 3.65472622e-02f, 2.62987614e-02f, -3.00043195e-01f, 1.11239716e-01f, 4.49139811e-02f,
  6.03784695e-02f, -2.37420835e-02f, -2.13680230e-02f, -1.51470140e-01f, 8.00262839e-02f, -9.46056992e-02f, -1.63518965e-01f, -8.79105181e-02f, 9.51971412e-02f, -1.18042659e-02f,
  4.66057330e-01f, -1.16657764e-01f, 8.86334255e-02f, 7.66422525e-02f, -1.44271448e-01f, -1.72503591e-01f, -1.77303582e-01f, -2.99462259e-01f, -7.25424290e-02f, 2.69034743e-01f,
  6.40030205e-02f, -1.46594331e-01f, 2.26105839e-01f, 3.12436163e-01f, 2.13788092e-01f, 3.69741857e-01f, 9.74904001e-02f, -2.98569739e-01f, 1.02800578e-01f, 1.83332324e-01f,
  6.48257285e-02f, -2.01526493e-01f, -1.98567837e-01f, -1.70311868e-01f, 1.86519518e-01f, 2.34639738e-02f, -5.94052896e-02f, -4.14495841e-02f, -3.72077264e-02f, 1.53619992e-02f,
  1.28012877e-02f, 4.26916108e-02f, -5.40814251e-02f, -4.18450572e-02f, -6.52011111e-03f, -2.24147737e-02f, -3.05241793e-02f, -3.00877299e-02f, -3.42343673e-02f, 6.40200302e-02f,
  -3.47743593e-02f, 3.70603763e-02f, 5.87192224e-03f, -7.93208107e-02f, 3.30726393e-02f, -1.70800775e-01f, 1.15637012e-01f, 1.40586302e-01f, 1.62713900e-01f, 3.79232951e-02f,
  4.85051386e-02f, 9.97699127e-02f, 1.73493132e-01f, 9.89529043e-02f, 1.93682224e-01f, 4.56593148e-02f, 1.24903888e-01f, 2.40900084e-01f, 6.40829355e-02f, 8.05600137e-02f,
  4.57856543e-02f, -1.39323547e-01f, 1.39096603e-01f, -8.65538344e-02f, 4.48852330e-02f, 2.81573348e-02f, 5.94984889e-02f, 6.27541468e-02f, -1.55595630e-01f, 7.17052221e-02f,
  1.16859615e-01f, 5.34072705e-02f, 6.11520186e-02f, 4.27610651e-02f, -1.75471827e-01f, 5.47029786e-02f, -3.14326063e-02f, 8.73380750e-02f, -8.03139061e-02f, 5.77113852e-02f,
  -1.00522965e-01f, -1.19628884e-01f, -3.35971206e-01f, 1.36732787e-01f, -1.44047245e-01f, 7.98271596e-02f, -8.76182411e-03f, 5.87016717e-02f, 9.20172408e-02f, 1.17153443e-01f,
  1.28548771e-01f, -1.81058556e-01f, -7.49436095e-02f, 2.18360778e-02f, 1.04461133e-01f, 7.85567015e-02f, -6.03467785e-03f, -1.05790541e-01f, -2.27966279e-01f, -5.02332225e-02f,
  2.69973725e-02f, -3.25462148e-02f, 8.04553032e-02f, 5.22489510e-02f, 2.16471963e-02f, 3.55416164e-02f, -9.43352468e-03f, 2.16031209e-01f, -8.44589397e-02f, 7.59728253e-02f,
  3.22544932e-01f, 5.13549370e-04f, 7.42234439e-02f, -6.80917576e-02f, -1.41547576e-01f, -5.56982048e-02f, -1.39831766e-01f, -4.89573106e-02f, 4.51265387e-02f, 1.22907385e-02f,
  8.69275928e-02f, -1.92607850e-01f, -1.12068214e-01f, 3.73188019e-01f, -5.62404357e-02f, -1.01649873e-01f, 2.42799044e-01f, -4.90458831e-02f, 1.48865744e-01f, -2.94391394e-01f,
  -5.52588888e-02f, 1.13010906e-01f, 2.16681793e-01f, 9.62264277e-03f, -3.17139804e-01f, 3.80714200e-02f, -7.42095262e-02f, 1.49126932e-01f, 3.08950573e-01f, -1.53672084e-01f,
  -1.91400856e-01f, -1.51882529e-01f, 1.22090451e-01f, 2.00597167e-01f, 7.41746575e-02f, 6.79147303e-01f, 1.87175140e-01f, -3.65250919e-04f, 2.70413667e-01f, -1.14346109e-01f,
  -7.09433332e-02f, 1.78804547e-01f, 5.74321561e-02f, 2.98713028e-01f, 3.11696511e-02f, -6.97951531e-03f, 3.43987495e-02f, -3.77439447e-02f, 3.91882733e-02f, 2.46278979e-02f,
  2.24613637e-01f, 8.77856649e-03f, -1.47545466e-03f, 1.31468475e-01f, 1.26707777e-01f, -3.58206443e-02f, 1.94429606e-02f, 9.54405311e-03f, 1.25555143e-01f, 7.62326941e-02f,
  1.63458579e-03f, 5.80185503e-02f, 2.19135821e-01f, -1.15564331e-01f, 8.02869536e-03f, 2.58630794e-02f, 1.26652256e-01f, 1.87420145e-01f, 1.26885727e-01f, 8.97050872e-02f,
  1.05538405e-01f, 7.27759972e-02f, 1.26336008e-01f, -1.65320337e-02f, 6.39463663e-02f, 1.87778659e-02f, 8.12409446e-02f, 7.47440085e-02f, 1.40927643e-01f, 1.40304370e-02f,
  1.48242731e-02f, -4.87710387e-02f, 4.79960330e-02f, 5.08471392e-02f, 5.32869026e-02f, -4.08191048e-02f, 1.31327212e-01f, 1.16683476e-01f, 2.52772152e-01f, 1.07097968e-01f,
  1.48868486e-01f, 9.20103788e-02f, 5.44608571e-02f, 5.89008331e-02f, 1.42206073e-01f, 4.31777164e-03f, 1.08802609e-01f, -4.45763767e-02f, 4.21833666e-03f, -3.61568481e-02f,
  1.66668728e-01f, 1.46899521e-01f, -1.22241318e-01f, -7.38749653e-03f, -9.75243971e-02f, 6.10404313e-02f, 5.98766133e-02f, 6.45527095e-02f, 1.08116530e-01f, -1.09202914e-01f,
  -6.80811629e-02f, -1.21732727e-01f, -1.48884043e-01f, -1.57133684e-01f, -4.01554592e-02f, 2.15617176e-02f, -2.06857502e-01f, 1.50035083e-01f, 3.33431304e-01f, 9.54180434e-02f,
  -2.69191951e-01f, 1.27393752e-01f, 3.16029112e-03f, 2.70858612e-02f, -1.06932148e-02f, -8.02343786e-02f, 3.09736445e-03f, 2.40158960e-01f, -2.23256364e-01f, 3.10555428e-01f,
  -1.62956119e-01f, -2.38597453e-01f, 2.08652616e-01f, -2.53651321e-01f, 3.96909751e-02f, 4.92565259e-02f, 1.14035443e-03f, -6.54978678e-02f, -6.57658577e-02f, -3.46130639e-01f,
  -2.00940043e-01f, 8.80544167e-03f, 1.43789882e-02f, 1.46626607e-01f, -1.35191619e-01f, -6.45417371e-04f, 3.32403094e-01f, -1.24274045e-02f, 4.97305632e-01f, 1.79241635e-02f,
  -6.77006170e-02f, -5.43613657e-02f, -1.38465866e-01f, -5.00493124e-02f, 1.05478212e-01f, 6.83913231e-02f, -1.28252670e-01f, -4.89594303e-02f, 1.21324129e-01f, 2.39347965e-01f,
  1.32988900e-01f, 3.21748815e-02f, -2.61553496e-01f, 3.51954341e-01f, 1.60737596e-02f, 1.83961526e-01f, -3.91069591e-01f, -6.39837794e-03f, 1.08850233e-01f, 1.35973528e-01f,
  9.51864291e-03f, 2.11780122e-03f, 1.49505854e-01f, 3.24683338e-02f, 1.43476114e-01f, 7.92401135e-02f, 2.60222349e-02f, 1.38280869e-01f, -2.99531315e-02f, 1.63690746e-01f,
  9.33646504e-03f, -9.58273932e-03f, -2.94694807e-02f, 1.47405311e-01f, 6.98321983e-02f, 1.05826743e-01f, 1.56892732e-01f, 9.38060954e-02f, 1.26006573e-01f, -1.21229917e-01f,
  -3.54833007e-02f, 1.26536801e-01f, 7.50219375e-02f, -8.58194828e-02f, 2.45733699e-03f, 9.49705243e-02f, -1.13225440e-02f, 1.71185583e-01f, -1.38065934e-01f, 1.32480681e-01f,
  -6.65676373e-04f, -8.56688470e-02f, 1.05246469e-01f, 6.25521168e-02f, 1.89105317e-01f, 2.40391359e-01f, 1.91919208e-01f, 8.16834569e-02f, 1.93735555e-01f, -1.81010477e-02f,
  1.54443532e-01f, 4.24343571e-02f, 9.79186222e-02f, 5.02441488e-02f, -7.05361068e-02f, 3.03950701e-02f, 9.33822691e-02f, 1.63220949e-02f, -3.97592038e-03f, 4.50369455e-02f,
  1.50894076e-01f, 3.37159038e-02f, -2.96709444e-02f, 1.48788512e-01f, 1.62943885e-01f, 1.86690539e-01f, 1.23779379e-01f, -4.21760343e-02f, 1.46615237e-01f, 2.33302668e-01f,
  -5.97310923e-02f, -4.60023209e-02f, -2.73741651e-02f, -5.56971692e-03f, -1.86402068e-01f, -3.65091674e-02f, -1.34632252e-02f, -3.45658846e-02f, 1.46386057e-01f, -1.18656680e-01f,
  1.49669051e-01f, 1.99957117e-01f, 2.09967829e-02f, 3.21299225e-01f, 2.48344034e-01f, -2.42695570e-01f, -3.11397314e-01f, 1.76100910e-01f, 9.92551073e-02f, 2.17966288e-01f,
  -7.58677199e-02f, -4.66519557e-02f, -4.22773585e-02f, 3.96895289e-01f, -9.68549475e-02f, 9.67345759e-02f, 1.40854791e-01f, -3.18532348e-01f, 4.94274423e-02f, -7.63991699e-02f,
  -1.48574680e-01f, 3.40972155e-01f, -1.98075682e-01f, -7.89285228e-02f, -4.70941365e-02f, -6.91960230e-02f, 2.14302093e-02f, 2.17175752e-01f, 1.75951310e-02f, 2.04479620e-02f,
  1.14501372e-01f, -1.57717824e-01f, 1.55612126e-01f, 1.51049010e-02f, -1.92203298e-01f, -2.77534574e-01f, -2.45244563e-01f, 1.31236106e-01f, -4.06349450e-02f, 1.50354892e-01f,
  -1.93716079e-01f, -1.55011222e-01f, 1.29131481e-01f, -1.22893035e-01f, 2.00749129e-01f, 6.83211610e-02f, -2.33191580e-01f, -2.00391904e-01f, 6.80957967e-03f, -1.51278889e-02f,
  3.26121509e-01f, 1.45118773e-01f, 2.83766240e-01f, 3.24276805e-01f, 1.66857675e-01f, 3.64082515e-01f, 3.12323958e-01f, 1.09205648e-01f, 3.12487572e-03f, -1.57406721e-02f,
  8.06479380e-02f, -8.47438816e-03f, -8.63098912e-03f, 9.11044478e-02f, -3.66897844e-02f, 1.06792159e-01f, -3.69138713e-03f, 1.48105733e-02f, 1.32554835e-02f, -5.72649948e-02f,
  -3.35606597e-02f, 1.22296914e-01f, -3.10229813e-03f, 1.20037518e-01f, 3.26269865e-02f, 1.02600101e-02f, 8.77264664e-02f, 7.32512921e-02f, 1.50538623e-01f, 7.00905100e-02f,
  2.44119197e-01f, 3.68070677e-02f, -5.89783974e-02f, -5.05647203e-03f, -2.13364214e-02f, 1.32852018e-01f, -1.59692056e-02f, 3.54634523e-02f, 1.69445351e-02f, 5.74980527e-02f,
  2.12018222e-01f, 1.68800116e-01f, 8.47967938e-02f, 8.34948719e-02f, 1.43402487e-01f, 4.45471480e-02f, 1.55114412e-01f, -3.93270738e-02f, 1.17716797e-01f, -5.39958384e-03f,
  -5.96415251e-02f, 4.67940867e-02f, -4.15171385e-02f, 7.88604468e-02f, 9.95688960e-02f, 1.12283686e-02f, 4.98856530e-02f, -5.71427830e-02f, 1.37206027e-02f, 1.83231726e-01f,
  -1.19664155e-01f, 1.56521246e-01f, -2.61854175e-02f, 3.65726762e-02f, 9.33925807e-03f, -1.07237913e-01f, 4.49367464e-02f, 1.38053641e-01f, 7.00525194e-02f, 1.79128349e-01f,
  1.09359443e-01f, -3.74097489e-02f, -5.89399189e-02f, -2.46845564e-04f, 1.84606425e-02f, 1.15683846e-01f, 4.97114770e-02f, -5.89589626e-02f, 8.64556432e-02f, 1.60675004e-01f,
  4.48935851e-02f, 1.92138329e-01f, 2.88710326e-01f, -1.82327673e-01f, -4.08447564e-01f, 1.49770901e-02f, 1.81115597e-01f, 1.47358447e-01f, 8.05565417e-02f, 3.33356075e-02f,
  -5.45136817e-02f, 2.36299261e-01f, -2.70689279e-01f, -1.45372584e-01f, 2.28299350e-01f, -3.80047232e-01f, 1.26709208e-01f, 1.40261594e-02f, -1.97691962e-01f, 7.59642422e-02f,
  -1.37638941e-01f, 4.60281484e-02f, -2.21464504e-02f, -4.25795987e-02f, 7.84511566e-02f, 2.96721309e-01f, 9.60142910e-02f, 1.28690168e-01f, 7.64871091e-02f, -2.01211929e-01f,
  -1.73779652e-02f, 9.85756069e-02f, 5.59187084e-02f, -3.45615223e-02f, -7.84942731e-02f, -1.23377228e-02f, -6.35261908e-02f, 5.19154966e-03f, -1.87800631e-01f, -1.27213418e-01f,
  -1.25485063e-02f, -1.35884792e-01f, 4.25637484e-01f, 1.05985235e-02f, -1.46782354e-01f, -2.56212175e-01f, 1.34099081e-01f, -5.83953969e-02f, 3.58376354e-01f, -4.12596047e-01f,
  1.10537581e-01f, 1.95107028e-01f, 2.22452044e-01f, 2.52019316e-01f, -2.70688444e-01f, -4.57360782e-02f, 1.36258781e-01f, 6.63543940e-02f, 2.13716045e-01f, 6.99861795e-02f,
  1.57978028e-01f, 5.53421564e-02f, 3.75348255e-02f, 7.92584270e-02f, 2.58594267e-02f, 2.12037358e-02f, 1.42015576e-01f, 9.14571807e-02f, -6.71173632e-02f, 2.42799595e-02f,
  6.00383878e-02f, -3.05937603e-04f, 7.09920153e-02f, 1.81266665e-01f, 6.54415190e-02f, 5.57081178e-02f, 1.13776974e-01f, -7.51618147e-02f, 1.41248405e-01f, 1.01292089e-01f,
  1.68539897e-01f, 1.31266490e-01f, -4.91874218e-02f, 1.60067707e-01f, 1.07268989e-01f, 1.13735050e-01f, 7.23067001e-02f, 6.06989041e-02f, -1.18020773e-02f, 2.64664561e-01f,
  8.72554034e-02f, 4.25973311e-02f, -2.33689640e-02f, 4.76640053e-02f, 1.84825696e-02f, 1.97901460e-03f, 2.29229599e-01f, -3.91406082e-02f, -4.48399335e-02f, 7.75354728e-02f,
  -8.64569843e-02f, 7.45033994e-02f, 1.49261534e-01f, 1.92775071e-01f, 7.01574832e-02f, 1.87840611e-01f, -7.52415210e-02f, 2.60389358e-01f, 5.51482774e-02f, -4.03151028e-02f,
  1.11477949e-01f, 8.25168416e-02f, -2.13126317e-01f, -1.00496426e-01f, 1.08268127e-01f, 1.17307775e-01f, -7.69229606e-02f, 2.68233512e-02f, 1.18360221e-02f, 1.38230354e-01f,
  6.21694326e-02f, 5.13446592e-02f, 2.15405766e-02f, -3.88039052e-02f, -1.05363801e-01f, -4.42295596e-02f, 2.64863580e-01f, 1.30734831e-01f, 1.51083082e-01f, 3.19902897e-01f,
  1.77092671e-01f, -1.71646342e-01f, 2.45764549e-03f, -5.83087951e-02f, 1.21648744e-01f, 7.37415776e-02f, -4.84706648e-02f, 5.87456860e-02f, -1.12228684e-01f, 3.12174380e-01f,
  -2.45331191e-02f, -6.95032184e-04f, 3.28395814e-02f, 3.55590433e-02f, -2.17661858e-01f, -1.88972384e-01f, 4.23862711e-02f, 1.13336205e-01f, -1.92618787e-01f, 3.89983840e-02f,
  1.28893275e-02f, -3.23437043e-02f, 1.26953339e-02f, -1.75798774e-01f, -1.88824907e-01f, 1.68101087e-01f, 7.99804553e-02f, 4.58763465e-02f, -7.17836320e-02f, -8.82079750e-02f,
  -5.49808070e-02f, -7.18218833e-02f, 1.77285716e-01f, 1.90745682e-01f, 1.40569702e-01f, 2.20146060e-01f, 2.58106738e-02f, -4.12253253e-02f, -3.31478000e-01f, -3.14624608e-02f,
  5.16999125e-01f, -2.44159862e-01f, -1.29568398e-01f, -3.59378457e-01f, -3.02034140e-01f, -2.01968998e-02f, -6.55553639e-02f, 2.10127905e-01f, 1.90932170e-01f, 2.12159470e-01f,
  4.08027368e-03f, 3.60235482e-01f, -1.30503133e-01f, -8.34346339e-02f, 2.17281163e-01f, 4.64970432e-02f, 1.09557740e-01f, -9.84947104e-03f, 9.34507772e-02f, 1.44251436e-01f,
  1.10380221e-02f, 8.90768543e-02f, 1.19829319e-01f, 1.39500394e-01f, 1.85638443e-01f, -5.37819192e-02f, 1.92187637e-01f, 8.14409330e-02f, -3.76534499e-02f, 1.11237191e-01f,
  3.73776034e-02f, -1.98339708e-02f, -1.73231661e-02f, 3.17861512e-03f, 1.80904508e-01f, 7.21350983e-02f, -3.83089706e-02f, -4.82600229e-03f, 1.25378817e-01f, 5.54250591e-02f,
  -1.04636019e-02f, 1.68765217e-01f, 1.79039508e-01f, 1.42357394e-01f, -1.52633768e-02f, 1.41616780e-02f, 2.19802484e-02f, 1.35451287e-01f, 1.98747180e-02f, 1.20267071e-01f,
  1.56846434e-01f, 4.83161509e-02f, 2.02290192e-01f, -3.09844259e-02f, 5.79251312e-02f, 2.94688400e-02f, 9.85263214e-02f, 3.69334705e-02f, 6.08863607e-02f, -2.17727013e-02f,
  8.78059193e-02f, -7.57218758e-03f, 1.08150929e-01f, 1.17707834e-01f, 1.00081250e-01f, -1.46765441e-01f, -2.89314166e-02f, -6.32151170e-03f, 1.43369958e-01f, 5.97525761e-02f,
  4.50895214e-03f, -1.15326121e-01f, -9.18784589e-02f, 1.80222243e-01f, 7.52538070e-02f, 5.39907254e-02f, -1.15732856e-01f, -4.09925543e-03f, -3.15022729e-02f, 8.41681063e-02f,
  1.38860807e-01f, 1.40537202e-01f, 1.07297793e-01f, -1.46540934e-02f, -8.11077771e-05f, -3.28655317e-02f, -9.04934928e-02f, -1.54453456e-01f, -2.36279994e-01f, -1.89858422e-01f,
  -1.35584623e-02f, -6.33877367e-02f, -1.95666216e-03f, 1.55213878e-01f, 6.09721541e-02f, -1.07450321e-01f, 2.21591275e-02f, 1.15135878e-01f, 9.86224934e-02f, 4.96366546e-02f,
  1.62628308e-01f, -7.52318501e-02f, 1.42133325e-01f, 8.88509676e-03f, -1.45352796e-01f, -2.19271779e-02f, 2.31437571e-03f, 5.92683628e-02f, 5.97503260e-02f, -9.53034440e-04f,
  7.08342642e-02f, -2.26061866e-02f, -1.46410525e-01f, 1.40710473e-01f, -7.36755431e-02f, -5.65952435e-02f, -2.10465521e-01f, 4.39481325e-02f, 1.19441457e-01f, -2.52037644e-01f,
  -1.68964744e-01f, -1.21584177e-01f, 4.97897081e-02f, -9.83249024e-03f, -6.90350085e-02f, 2.39683002e-01f, 1.17027923e-01f, -6.52182251e-02f, 2.80666620e-01f, -1.89637318e-01f,
  2.93546528e-01f, 1.22150838e-01f, -8.63865614e-02f, 3.74269336e-02f, -1.60854697e-01f, 7.46650696e-02f, 4.75118607e-02f, 3.57584029e-01f, -1.03433385e-01f, -1.38414338e-01f,
  -3.30157220e-01f, 3.17988992e-02f, 1.59525707e-01f, 8.52025151e-02f, 3.81106138e-02f, 8.73331577e-02f, 4.28617671e-02f, 1.05054066e-01f, 4.02899832e-02f, 5.39401807e-02f,
  1.44773483e-01f, 4.76421714e-02f, 2.69956351e-03f, -2.95920242e-02f, 1.50040209e-01f, 7.10894465e-02f, 1.15279637e-01f, 2.41846573e-02f, -1.10750407e-01f, -7.57444836e-03f,
  -1.13635622e-02f, 1.05101593e-01f, 1.22370042e-01f, 1.10399574e-01f, 3.89174819e-02f, 1.48084790e-01f, 1.41960010e-01f, 7.94238299e-02f, 7.78616369e-02f, 1.25765115e-01f,
  7.81226456e-02f, 8.57314914e-02f, 4.51773033e-03f, 7.26887733e-02f, -3.37978825e-02f, 1.89718604e-01f, 6.30830973e-02f, -4.82990183e-02f, 5.50402887e-02f, 1.38616651e-01f,
  1.19756803e-01f, -6.43932298e-02f, -5.65407518e-03f, 1.95015073e-01f, -1.22583471e-02f, 2.35031899e-02f, -1.19966753e-02f, 8.76668692e-02f, -1.99199058e-02f, 1.31313413e-01f,
  6.84857816e-02f, 5.79556748e-02f, 1.77015737e-01f, -8.10200199e-02f, -1.86349936e-02f, 9.55769867e-02f, -1.95273515e-02f, -1.53448567e-01f, -2.98953522e-02f, -4.26388420e-02f,
  -1.67258814e-01f, 8.85769725e-02f, 1.27001386e-02f, -9.29821953e-02f, 4.66996282e-02f, -1.17048442e-01f, 8.02332815e-03f, 7.37007335e-02f, 1.59186617e-01f, 2.37229288e-01f,
  7.47592468e-03f, -4.62096912e-04f, -1.51901305e-01f, 8.40459466e-02f, 3.92693132e-02f, -2.19067454e-01f, -1.36982039e-01f, -2.03468770e-01f, -2.24882290e-02f, -8.73535946e-02f,
  1.90388069e-01f, 5.46982884e-02f, 2.20387559e-02f, -1.57647058e-01f, 1.25400856e-01f, -6.45580739e-02f, 2.40228117e-01f, -1.30557060e-01f, 9.88408551e-03f, -1.19857259e-01f,
  -1.05689645e-01f, 1.46230847e-01f, -1.18292265e-01f, -1.64732322e-01f, 1.28673524e-01f, 9.08188522e-02f, 2.38121091e-03f, -2.22227685e-02f, -7.39242733e-02f, -4.99049313e-02f,
  -1.32516414e-01f, 9.80049521e-02f, -6.72293901e-02f, -1.04095228e-01f, -1.45580366e-01f, -6.21892624e-02f, 4.67316717e-01f, -2.10535333e-01f, -3.16265710e-02f, 1.03163272e-01f,
  -5.37788160e-02f, -8.50241557e-02f, -1.23914093e-01f, 1.19670972e-01f, -1.18448928e-01f, -2.12179050e-01f, 3.68280470e-01f, -1.83876574e-01f, 4.77244973e-01f, 8.94192308e-02f,
  -1.34841919e-01f, -3.77453805e-04f, -3.33660394e-01f, -1.95976004e-01f, -7.27332532e-02f, 1.60225451e-01f, -6.24291673e-02f, 1.39337644e-01f, -2.75667638e-01f, -1.37462959e-01f,
  1.81318685e-01f, 3.73220518e-02f, -1.09898746e-01f, 1.17641546e-01f, 6.94817901e-02f, 1.12026289e-01f, 1.34743467e-01f, 3.82010229e-02f, 1.01364881e-01f, 1.19517326e-01f,
  1.03124544e-01f, 5.61645366e-02f, 8.04640576e-02f, 2.24925820e-02f, 1.40440717e-01f, 4.11550840e-03f, 6.23290241e-02f, 9.93550196e-02f, -2.10856069e-02f, -1.69625893e-01f,
  4.11989912e-02f, 5.13738878e-02f, 9.24338400e-02f, 5.86865060e-02f, 1.77108973e-01f, 2.74808079e-01f, 1.90928400e-01f, 1.60958171e-01f, 1.53150052e-01f, -2.34670169e-03f,
  1.17971301e-01f, 7.61086633e-03f, 4.54973653e-02f, 1.34316221e-01f, 8.16521049e-02f, 1.55074045e-01f, 2.70512074e-01f, 9.48987727e-04f, 1.38457060e-01f, 6.28638193e-02f,
  -9.03763715e-03f, -3.97747867e-02f, -6.58964142e-02f, -4.71167043e-02f, 6.94336668e-02f, 2.14878209e-02f, 7.31952712e-02f, 3.63981500e-02f, 8.38178322e-02f, 1.56096086e-01f,
  1.65119156e-01f, -8.79658759e-02f, 6.73499554e-02f, 8.10230896e-03f, -1.34162933e-01f, 1.55724674e-01f, -6.30431399e-02f, 6.31329715e-02f, -6.25989735e-02f, -8.01412761e-02f,
  -7.75379166e-02f, -2.01124713e-01f, -2.28967592e-01f, -3.18158753e-02f, -1.92361437e-02f, 9.93608832e-02f, -8.85202885e-02f, -1.77513972e-01f, -1.51207864e-01f, 6.79748598e-03f,
  -2.75113992e-02f, 7.43907616e-02f, -1.20685823e-01f, 6.12609349e-02f, -2.08952010e-01f, 3.47850472e-01f, 2.07764879e-01f, 1.08432837e-01f, 4.00212817e-02f, -1.10194348e-01f,
  -6.30221814e-02f, 1.03838444e-01f, -7.89526552e-02f, 3.99678759e-02f, 2.32952565e-01f, 3.38517666e-01f, -9.39600095e-02f, 2.01510683e-01f, -7.83936307e-02f, -1.93307489e-01f,
  1.67061031e-01f, 1.82127550e-01f, 4.68628369e-02f, -3.41261365e-02f, -6.66652694e-02f, 1.70273229e-03f, -5.71942814e-02f, -1.15052320e-01f, -6.62306696e-02f, -1.68776155e-01f,
  -2.37607956e-02f, 1.53532565e-01f, 1.24371275e-01f, -1.25055358e-01f, 1.60967745e-02f, -1.25404730e-01f, -6.58693090e-02f, 2.94597745e-01f, 1.99809283e-01f, 5.80540895e-02f,
  2.44184360e-01f, 4.79419678e-02f, -4.37542886e-01f, 3.25354129e-01f, -3.67773585e-02f, 4.47137700e-03f, -1.20002769e-01f, 3.00763935e-01f, -1.83756635e-01f, 3.08258861e-01f,
  1.07319266e-01f, 6.91219449e-01f, 2.80965358e-01f, 1.20081222e-02f, 1.96227282e-01f, -1.31519869e-01f, 4.13295448e-01f, 1.25726730e-01f, 7.91025981e-02f, 1.14261182e-02f,
  -1.03346087e-01f, 9.79965404e-02f, 5.17329797e-02f, -2.38010809e-02f, -2.44720131e-02f, -4.47703563e-02f, -5.87157980e-02f, 6.86032930e-03f, -8.84483289e-03f, 2.28734389e-02f,
  3.17971110e-02f, 7.29792519e-03f, 1.82897318e-02f, 6.13638870e-02f, 3.13145258e-02f, 8.27814415e-02f, -4.47586812e-02f, 9.94626656e-02f, -1.64919518e-04f, 3.85520305e-03f,
  8.08067024e-02f, 2.14011282e-01f, 6.04543611e-02f, 3.34544778e-02f, 8.12040642e-02f, 3.76420538e-03f, 5.68387955e-02f, 6.78422824e-02f, 8.52454007e-02f, 3.38687859e-02f,
  1.19255923e-01f, 4.71591689e-02f, 2.39745807e-02f, 8.70768204e-02f, 5.73557653e-02f, 1.24837689e-01f, 1.64013356e-01f, 6.73922524e-02f, 8.76827072e-03f, 1.70403544e-03f,
  1.14682782e-02f, 7.48751834e-02f, 3.70309949e-02f, 1.42061457e-01f, -6.68544546e-02f, 5.24241701e-02f, 3.33721116e-02f, 9.72970109e-03f, 1.15704156e-01f, 1.10999765e-02f,
  -9.54422355e-02f, -1.32314488e-02f, -1.19983397e-01f, -2.27586702e-01f, -3.68245058e-02f, 9.06261206e-02f, -1.07667178e-01f, 5.59737720e-02f, -1.26489282e-01f, 1.67507939e-02f,
  4.55495603e-02f, 5.14152087e-03f, -2.30205134e-02f, 3.43717523e-02f, 1.07473582e-01f, -1.23752303e-01f, 3.49773429e-02f, 1.13187917e-01f, 6.82261065e-02f, 3.36737037e-02f,
  3.89331542e-02f, -1.70255736e-01f, -1.24664150e-01f, -6.57705814e-02f, 1.08891867e-01f, -1.55559570e-01f, -1.99903756e-01f, -7.72786215e-02f, 1.05462760e-01f, 1.60149321e-01f,
  1.00258209e-01f, -9.79146138e-02f, -1.12517722e-01f, 6.58332855e-02f, 2.85928622e-02f, 4.76040617e-02f, 1.29874244e-01f, 9.89953354e-02f, -4.94037336e-03f, 1.38396770e-01f,
  -4.06717882e-02f, -1.00976855e-01f, -1.04813419e-01f, 1.36778995e-01f, 9.15277451e-02f, 3.81306820e-02f, 9.51530710e-02f, -9.41565167e-03f, -9.73340496e-03f, 2.82618925e-02f,
  3.37082058e-01f, 1.58225060e-01f, 3.92047316e-01f, 6.54104352e-02f, 3.11853481e-03f, 7.76794329e-02f, 5.21073043e-02f, -3.20086032e-01f, -2.77490728e-02f, 3.94074321e-02f,
  -2.86903549e-02f, -4.10618186e-02f, -1.36963844e-01f, 2.27806587e-02f, 1.69678584e-01f, 2.81974435e-01f, 2.68698037e-01f, -2.47601466e-03f, 1.66605189e-01f, 3.67065743e-02f,
  -8.16519409e-02f, -2.79890060e-01f, -1.74296126e-01f, -1.63780421e-01f, -1.01206504e-01f, 3.00746799e-01f, -2.46973964e-03f, 1.39976740e-01f, 4.97070961e-02f, 2.89621651e-02f,
  -7.44224563e-02f, -5.55956066e-02f, 1.42608792e-01f, 6.79726824e-02f, -5.37557043e-02f, -2.95398589e-02f, 1.27066681e-02f, -6.39945045e-02f, 5.16596809e-02f, -3.32954787e-02f,
  -3.57009619e-02f, 1.62406981e-01f, 1.24043755e-01f, 5.55223115e-02f, 2.14404538e-02f, 1.23234481e-01f, 1.78348437e-01f, -2.63268817e-02f, 1.08014345e-01f, 1.47514075e-01f,
  5.05564101e-02f, 3.63397636e-02f, 7.65958279e-02f, 4.91208956e-02f, -2.49927994e-02f, 1.56575978e-01f, 2.61254907e-02f, -2.53254529e-02f, 7.27282837e-02f, 1.06953628e-01f,
  4.92008924e-02f, 1.19181462e-02f, 2.43163314e-02f, -1.72380619e-02f, 1.43187374e-01f, 6.64186403e-02f, 1.28788963e-01f, 4.62824889e-02f, 7.95122609e-02f, 1.46668628e-01f,
  9.71808061e-02f, 2.23067820e-01f, 1.25429705e-01f, 1.53827965e-01f, 8.72198120e-03f, -1.21417224e-01f, 5.00121228e-02f, 2.10981637e-01f, 9.76599287e-03f, 1.64325058e-01f,
  5.28920814e-03f, -1.23456270e-02f, 1.27485707e-01f, 1.01141527e-01f, -6.53941631e-02f, 8.58466178e-02f, 1.20471241e-02f, 9.05845091e-02f, 1.10964574e-01f, -3.42784934e-02f,
  -1.34879176e-03f, -2.62369998e-02f, 1.16944820e-01f, -1.13216974e-01f, 2.29993369e-02f, 1.84413232e-02f, 3.66164111e-02f, 7.91395903e-02f, 1.23160109e-01f, -1.20134987e-02f,
  5.19285835e-02f, -1.17566846e-01f, -8.51402432e-02f, 8.94206110e-03f, -2.72754692e-02f, 1.51527867e-01f, 6.80468529e-02f, 6.89822659e-02f, 4.77628261e-02f, -1.74225688e-01f,
  -2.51834244e-01f, -1.15566306e-01f, 1.01941392e-01f, -1.01437375e-01f, 8.70364532e-02f, -1.29999872e-02f, -7.98074901e-02f, -2.47983962e-01f, -9.57296565e-02f, 3.72581556e-02f,
  1.33084385e-02f, -5.75817525e-02f, 7.65322372e-02f, 6.10644259e-02f, 1.26644537e-01f, 1.42289316e-02f, 6.01393543e-02f, -2.55992919e-01f, 3.16578537e-01f, 1.04700036e-01f,
  2.86992908e-01f, 8.54063872e-03f, 2.96201020e-01f, -7.62279406e-02f, -7.98818916e-02f, -2.34624222e-02f, -2.27330118e-01f, -3.13794683e-03f, 2.35138416e-01f, 1.12373903e-02f,
  7.22569823e-02f, 3.14247385e-02f, 3.17542613e-01f, 5.46163805e-02f, 4.84352469e-01f, 1.46773458e-01f, 2.29772255e-01f, -4.63444293e-01f, 2.22816113e-02f, -2.29195893e-01f,
  -1.33170247e-01f, 2.30060369e-01f, -1.61639556e-01f, 3.23525183e-02f, 1.78766444e-01f, 9.55099538e-02f, 4.50915173e-02f, 1.42772377e-01f, 2.10383520e-01f, 8.59941021e-02f,
  7.55051151e-02f, 4.35304195e-02f, 1.54148862e-01f, 1.25387296e-01f, 8.39699432e-02f, 9.68852714e-02f, -9.09717754e-03f, 1.56246319e-01f, 8.59941319e-02f, 5.59458416e-03f,
  1.61382750e-01f, -3.17717157e-03f, -1.68194398e-02f, -1.63403004e-01f, -4.51844037e-02f, 3.95674482e-02f, 1.38893649e-01f, 3.64648253e-02f, 1.32019550e-01f, 1.55188501e-01f,
  9.73812863e-02f, 2.57474005e-01f, 1.97191581e-01f, -5.64595908e-02f, 1.28450707e-01f, 8.47869888e-02f, 7.27315620e-02f, 1.02738619e-01f, 9.79478210e-02f, 2.46539444e-01f,
  1.55889869e-01f, 1.17602617e-01f, 1.24341875e-01f, -2.61629187e-02f, 8.66967514e-02f, 1.21314451e-02f, 3.16272601e-02f, 5.22590466e-02f, -5.71903922e-02f, 1.66293215e-02f,
  -4.47819978e-02f, 8.44348446e-02f, 7.77809620e-02f, -2.59235911e-02f, 8.19403902e-02f, -2.58920103e-01f, -9.38728154e-02f, -5.67158237e-02f, 3.11412048e-02f, 1.11813702e-01f,
  7.57037476e-02f, 4.06573191e-02f, -1.20704211e-02f, -1.25047505e-01f, -8.08229074e-02f, -3.69225927e-02f, -1.46634102e-01f, -1.09139666e-01f, -2.08625451e-01f, 5.89042008e-02f,
  -5.51829971e-02f, -4.69385870e-02f, 1.22746095e-01f, 8.49069431e-02f, 5.90131171e-02f, 4.10146788e-02f, -1.17805779e-01f, 1.24541655e-01f, -3.10268998e-01f, 2.21796528e-01f,
  1.31191835e-01f, -1.62710540e-03f, 1.34139592e-02f, -1.23370618e-01f, 1.38489395e-01f, -5.07537946e-02f, 1.22627653e-02f, 4.91232574e-02f, 2.09069028e-01f, 1.37777314e-01f,
  2.85884794e-02f, 5.92384040e-02f, 6.88251033e-02f, 6.53344840e-02f, 1.08870164e-01f, 3.48967522e-01f, 9.94440541e-02f, -5.11728600e-02f, -5.35320453e-02f, 1.27142742e-01f,
  -1.81812700e-02f, 2.83482462e-01f, 1.21461950e-01f, -2.21214324e-01f, -2.11158097e-01f, 2.24117592e-01f, 2.14018062e-01f, 3.11055239e-02f, -1.76328178e-02f, -1.61413431e-01f,
  -3.88353020e-01f, 2.34773755e-01f, -1.17701270e-01f, -1.81040570e-01f, 4.10917640e-01f, -8.59897882e-02f, 2.37386301e-02f, 2.07826003e-01f, -1.61275938e-01f, -9.13115442e-02f,
  3.22440602e-02f, 5.51109016e-01f, -5.28224349e-01f, 1.18588038e-01f, 1.88230604e-01f, 5.99528790e-01f, 1.36595100e-01f, 2.70086795e-01f, 5.05717993e-02f, -1.87427133e-01f,
  1.75127342e-01f, -9.60605815e-02f, 4.79792282e-02f, 1.95218325e-01f, 1.46274760e-01f, 9.24626552e-03f, 1.88348833e-02f, 9.76802707e-02f, 4.01958078e-03f, 1.42088771e-01f,
  1.41892478e-01f, 9.10581946e-02f, 9.23695490e-02f, -1.46778403e-02f, 9.58667248e-02f, 3.94860096e-02f, 1.67130996e-02f, 2.76931003e-02f, 3.47169451e-02f, 4.57599536e-02f,
  1.87246904e-01f, -8.93541202e-02f, 8.40770379e-02f, 1.35129049e-01f, 1.85295135e-01f, -1.01589542e-02f, 6.86329678e-02f, 9.68700871e-02f, 4.32088263e-02f, 2.06581861e-01f,
  1.49145082e-01f, 9.07316282e-02f, 8.01274702e-02f, -2.67114453e-02f, 1.84017137e-01f, -4.10842616e-03f, 1.43238604e-01f, 2.11081371e-01f, 2.41863027e-01f, 1.59526289e-01f,
  1.59248546e-01f, 1.02009233e-02f, 1.84058562e-01f, 6.04115911e-02f, 4.18843478e-02f, 7.16952756e-02f, -7.48683140e-02f, -3.26293372e-02f, 1.62977487e-01f, -5.86660579e-03f,
  -5.02194576e-02f, 4.36142460e-03f, 2.21612319e-01f, 5.86191751e-02f, -2.20303219e-02f, 1.57134593e-01f, 7.15566352e-02f, -2.47501797e-04f, 4.25136909e-02f, -1.10386126e-01f,
  2.72013456e-01f, 1.68220609e-01f, 3.12680341e-02f, -5.86505011e-02f, 2.92724706e-02f, -2.99245678e-02f, -4.06705588e-02f, -8.48514959e-02f, -1.12202585e-01f, 6.93139806e-02f,
  1.12318099e-01f, -1.10900616e-02f, 4.82874624e-02f, 1.77127004e-01f, 3.81048173e-02f, 2.47055992e-01f, 3.10864627e-01f, -6.50309101e-02f, -2.90877551e-01f, 1.25573426e-01f,
  3.65964100e-02f, 1.59527063e-01f, 1.25799254e-02f, 6.63031533e-04f, -2.24926248e-02f, 1.82797372e-01f, 3.35369557e-02f, -3.96635234e-02f, -2.76331622e-02f, -3.13100785e-01f,
  1.05418423e-02f, -2.22243741e-02f, -1.21482611e-02f, 8.06718096e-02f, -1.15501300e-01f, 5.61745241e-02f, -2.85699163e-02f, -6.25341162e-02f, -2.73005553e-02f, 2.54223168e-01f,
  2.69035771e-02f, 8.91399384e-03f, 8.83734077e-02f, -1.41940042e-01f, -4.24420014e-02f, -8.25406983e-02f, 9.39528644e-02f, -1.05164424e-01f, -4.30336148e-02f, -1.16797671e-01f,
  -6.21475615e-02f, 1.46030746e-02f, -1.31076455e-01f, -3.29990178e-01f, 1.07442468e-01f, -2.09056735e-01f, 3.52186374e-02f, 6.18524253e-02f, -6.97272271e-02f, 2.39387304e-02f,
  2.18911953e-02f, -1.41146079e-01f, 1.03034258e-01f, 2.60833558e-02f, -1.58172935e-01f, 3.54312181e-01f, -6.38799965e-02f, 2.29336843e-01f, 1.38260886e-01f, 4.30838279e-02f,
  1.97121933e-01f, 1.02154717e-01f, 1.13008909e-01f, -8.94277394e-02f, 9.22048986e-02f, 1.52014187e-02f, 3.00700683e-03f, 1.31145999e-01f, -2.35320739e-02f, -4.78394475e-04f,
  1.48013353e-01f, 4.23987433e-02f, 1.33420184e-01f, 4.37324569e-02f, 8.18648785e-02f, 9.37899761e-03f, 5.07875085e-02f, 1.05960220e-01f, 1.33660987e-01f, 3.31370942e-02f,
  9.50281993e-02f, -4.91720773e-02f, 1.04089873e-02f, 9.55790952e-02f, 1.12294540e-01f, -7.68723618e-03f, 1.12949766e-01f, 6.15165010e-02f, 6.96920007e-02f, 2.19689235e-02f,
  1.17248408e-01f, -7.69593269e-02f, -4.54888999e-04f, 2.33697202e-02f, 5.34763969e-02f, -9.99195427e-02f, -8.58475491e-02f, 9.57301483e-02f, 1.32011563e-01f, -2.34533828e-02f,
  1.58677474e-01f, 1.14685230e-01f, -1.97923277e-02f, 3.37737314e-02f, 1.09706722e-01f, -2.80796289e-02f, 8.93122181e-02f, 1.99555486e-01f, 5.99105619e-02f, 1.36595637e-01f,
  -2.15342835e-01f, 2.98119243e-02f, -7.70059414e-03f, -5.05675338e-02f, -1.24967143e-01f, -3.90350744e-02f, -1.74378514e-01f, 2.54138820e-02f, 1.19428821e-02f, -1.83264196e-01f,
  6.26065582e-02f, -9.42070633e-02f, 9.37406793e-02f, -4.48868535e-02f, 2.91868120e-01f, 3.26621681e-02f, -6.83051422e-02f, 4.91977036e-02f, -2.37903953e-01f, -1.19780295e-01f,
  -2.04172954e-01f, 8.96075591e-02f, 5.79893216e-02f, -1.82736248e-01f, 3.60087752e-01f, 3.27992253e-02f, -5.84294498e-02f, 7.23170191e-02f, 1.48470327e-01f, -2.39422902e-01f,
  5.90391904e-02f, -2.15849191e-01f, -1.47538364e-01f, 1.86037067e-02f, 8.28635544e-02f, -2.52541304e-01f, -3.75951678e-02f, -5.82657121e-02f, -2.97870338e-01f, -7.39683360e-02f,
  -1.54464781e-01f, -1.34323105e-01f, 1.87491447e-01f, -6.34535849e-02f, 2.70392261e-02f, -5.73820621e-02f, 9.56598893e-02f, -7.88816214e-02f, -1.79190770e-01f, -7.83940628e-02f,
  1.08486056e-01f, -1.23605564e-01f, -2.35502049e-01f, -1.67978212e-01f, -5.18785566e-02f, 3.41060013e-01f, 4.28665400e-01f, -6.82108253e-02f, 6.60261288e-02f, 8.45710635e-02f,
  1.95496738e-01f, -1.42452583e-01f, -8.56735855e-02f, 1.22393526e-01f, 4.25550282e-01f, 1.19460329e-01f, -2.41928399e-01f, -1.70028850e-01f, -1.76212177e-01f, 2.71636009e-01f,
  -4.44585085e-02f, -1.35914579e-01f, -1.30975977e-01f, 3.41058880e-01f, 4.72565085e-01f, 1.12643734e-01f, 9.39937830e-02f, -4.03956234e-01f, 2.04063401e-01f, 4.72304113e-02f,
  -9.67835113e-02f, 3.68266031e-02f, 1.02816718e-02f, 1.32684067e-01f, 6.71535172e-03f, -2.34557893e-02f, 4.15060744e-02f, 1.83137171e-02f, -1.23443669e-02f, 1.39384925e-01f,
  1.15070669e-02f, 9.67141986e-03f, 1.25813246e-01f, 1.35867879e-01f, 1.91952705e-01f, 3.73102836e-02f, 1.22274399e-01f, 1.52842388e-01f, -7.95162562e-03f, -2.19219308e-02f,
  5.68200229e-03f, 1.08723812e-01f, 1.83080509e-01f, 1.14856385e-01f, 9.06173661e-02f, 9.91506502e-02f, 1.54108629e-01f, 2.12023966e-02f, 8.18754435e-02f, 1.11968458e-01f,
  -2.07132008e-02f, 8.04404244e-02f, 1.09632440e-01f, 3.74678709e-02f, -8.34024400e-02f, 8.13773498e-02f, 1.19836852e-01f, -6.53753206e-02f, 3.25010438e-03f, 1.01698004e-01f,
  9.07750651e-02f, -7.33483359e-02f, 1.40199170e-01f, 2.02453867e-01f, 1.09239317e-01f, 1.87170982e-01f, 5.19507341e-02f, 1.30094990e-01f, 5.54360449e-02f, -5.96205667e-02f,
  -7.24659041e-02f, -4.08410802e-02f, -1.46753088e-01f, -1.59120157e-01f, -1.65134847e-01f, 6.90381154e-02f, -5.95862009e-02f, -2.38238394e-01f, -1.38331398e-01f, 2.66218502e-02f,
  4.11366113e-02f, -4.63257395e-02f, 1.53273880e-01f, -4.24872264e-02f, -1.14961110e-01f, -1.55228265e-02f, -1.11574918e-01f, -1.20413207e-01f, -1.00049183e-01f, 2.48274393e-02f,
  9.28731859e-02f, 3.50759588e-02f, 6.98349578e-03f, 1.38684977e-02f, 1.30821645e-01f, 1.09840073e-01f, -1.70541540e-01f, -1.48738652e-01f, 7.83506632e-02f, 1.98467538e-01f,
  1.11970164e-01f, -1.23167008e-01f, -7.43877068e-02f, 8.53297710e-02f, -2.51055628e-01f, 2.75069714e-01f, -1.33093938e-01f, -2.26594899e-02f, -1.02471985e-01f, -2.56010275e-02f,
  9.58331749e-02f, -2.46757343e-02f, -1.81687549e-01f, -1.58587005e-02f, -1.36254683e-01f, -7.95234069e-02f, 3.09571233e-02f, -5.67496158e-02f, 7.57020935e-02f, 1.67526841e-01f,
  1.83493003e-01f, 1.41937926e-01f, 2.29674965e-01f, 6.20038882e-02f, 4.47733760e-01f, -4.79364507e-02f, 1.15506902e-01f, -1.90118164e-01f, 2.72882599e-02f, 1.76029827e-03f,
  -2.45102689e-01f, 5.51139824e-02f, -2.11463675e-01f, 1.19804218e-01f, 2.19490398e-02f, 2.43223578e-01f, 2.62472391e-01f, 2.48983409e-02f, 1.19503453e-01f, 5.46163991e-02f,
  -7.35863969e-02f, -2.62055993e-01f, -7.75529221e-02f, -6.07679263e-02f, -5.46776578e-02f, 1.32214203e-01f, 1.29954174e-01f, 6.21689521e-02f, 3.51740122e-02f, 1.03647541e-02f,
  3.35503742e-02f, 1.91935629e-01f, -9.26004350e-02f, 4.60388176e-02f, -4.29819375e-02f, 3.10632419e-02f, 6.32833242e-02f, -2.06792839e-02f, 1.53843477e-01f, 1.72196940e-01f,
  -2.06895452e-02f, 1.03254065e-01f, -3.26581150e-02f, 1.30833685e-01f, -6.16680197e-02f, 1.07835658e-01f, -4.79474552e-02f, 1.72644585e-01f, 2.40348410e-02f, 9.24055055e-02f,
  1.96479224e-02f, 3.07680834e-02f, 1.89299226e-01f, 5.78555912e-02f, 5.15837688e-03f, -2.39657555e-02f, 1.00102514e-01f, 4.52031344e-02f, 4.34593260e-02f, 1.09789558e-01f,
  8.23026597e-02f, 9.71544255e-03f, 1.18439615e-01f, 1.57607675e-01f, 8.29928443e-02f, 7.60672018e-02f, 1.44712910e-01f, 1.25209555e-01f, 5.76883778e-02f, 1.10394014e-02f,
  3.46823819e-02f, 1.07864104e-01f, 8.52223020e-03f, 1.04872726e-01f, 2.86403974e-03f, 1.34936487e-02f, 6.74599484e-02f, -7.67357871e-02f, 9.93502513e-02f, 1.23228617e-01f,
  3.88792865e-02f, 2.26124469e-02f, 9.97104272e-02f, -7.70402476e-02f, 5.00789359e-02f, 1.02354355e-01f, 1.02526188e-01f, -9.65034515e-02f, 6.45867288e-02f, -1.09515502e-03f,
  1.35787269e-02f, 8.83398503e-02f, -4.25100029e-02f, 1.03589058e-01f, 1.65810809e-02f, -1.09708101e-01f, -8.36049393e-02f, -4.03899699e-03f, 1.97818726e-02f, 2.94595752e-02f,
  2.03824207e-01f, 6.67045861e-02f, -1.12938538e-01f, 8.67111087e-02f, 1.63957223e-01f, 4.93758684e-03f, -1.49993405e-01f, -1.53061777e-01f, 4.99530742e-03f, 1.82944730e-01f,
  1.57168478e-01f, -6.08299598e-02f, 8.53173286e-02f, -1.90867752e-01f, -5.93163930e-02f, -2.22460143e-02f, -5.95220104e-02f, 1.31226584e-01f, 2.98012663e-02f, 5.27852327e-02f,
  1.29262218e-02f, -1.48266345e-01f, 2.39842925e-02f, -1.90383121e-01f, -1.72588527e-01f, -1.31382912e-01f, 5.87252080e-02f, -1.63961962e-01f, -3.62683266e-01f, -3.28103565e-02f,
  -2.19911993e-01f, 6.82865977e-02f, -2.25301355e-01f, 2.20396444e-01f, 6.69946447e-02f, 7.48449415e-02f, 7.37597272e-02f, -3.54421395e-03f, 6.46716505e-02f, 3.80625427e-02f,
  2.45280296e-01f, 9.53985974e-02f, -3.65702659e-01f, -9.89354849e-02f, -1.78160340e-01f, 5.04738875e-02f, -2.90231943e-01f, 1.45803303e-01f, 7.18393028e-02f, 3.40445697e-01f,
  3.12442571e-01f, 2.63770908e-01f, 3.83662522e-01f, -1.61874905e-01f, 3.77695300e-02f, 1.30623952e-01f, 8.82673338e-02f, -3.12383170e-03f, 2.31647454e-02f, -3.33783366e-02f,
  -1.98297072e-02f, 4.46924828e-02f, 9.03422087e-02f, 4.92320620e-02f, 1.09510086e-01f, 1.12921797e-01f, 3.59516591e-03f, 3.10426597e-02f, 6.92853630e-02f, 9.58520696e-02f,
  1.58025160e-01f, 1.20028310e-01f, 1.34856179e-01f, 1.75584629e-01f, 8.29398781e-02f, -8.66733212e-03f, 1.55381694e-01f, 1.86015725e-01f, 1.69564858e-01f, 8.00876170e-02f,
  7.97614381e-02f, 1.59707412e-01f, 9.60409641e-02f, 1.05130196e-01f, -5.43892086e-02f, 2.74158847e-02f, 9.78418365e-02f, 1.04612507e-01f, 1.08151667e-01f, 1.00250252e-01f,
  1.20543115e-01f, 8.99757966e-02f, 1.74005643e-01f, -5.52832223e-02f, 1.74041748e-01f, -4.10954021e-02f, -4.46602590e-02f, 8.40782225e-02f, -5.53968064e-02f, 9.28238928e-02f,
  7.72375837e-02f, 1.87198460e-01f, 1.53403133e-01f, -3.66517752e-02f, 4.16453518e-02f, 1.20758051e-02f, -4.58225645e-02f, -1.43732622e-01f, -5.07597327e-02f, -1.24377526e-01f,
  -7.48190135e-02f, 1.87700897e-01f, -1.70671359e-01f, -2.40518451e-01f, -1.88119099e-01f, 1.55302703e-01f, 3.32586206e-02f, -2.64140195e-03f, 3.13829929e-02f, -1.93120334e-02f,
  -1.41863137e-01f, -1.00275643e-01f, 1.24124512e-01f, 4.93938215e-02f, 1.15460582e-01f, -4.37457189e-02f, 6.27462044e-02f, -6.08101971e-02f, -1.51387900e-01f, -1.25711620e-01f,
  -1.25323236e-01f, 2.65710452e-03f, -5.26961610e-02f, -9.28685218e-02f, 1.62099391e-01f, 1.18992545e-01f, 8.20944905e-02f, -2.43349522e-01f, -1.97928578e-01f, -1.09000519e-01f,
  -1.15702510e-01f, 4.55351062e-02f, 6.63702041e-02f, 1.00420259e-01f, -4.87658232e-02f, -1.14633165e-01f, -2.18846630e-02f, 2.25394359e-03f, -4.74326909e-02f, 3.06726787e-02f,
  -1.82773359e-02f, 2.16982886e-01f, 2.76337534e-01f, 6.34490862e-04f, -6.19185492e-02f, -4.20615226e-02f, 4.94494230e-01f, 1.26187056e-01f, -7.77587714e-03f, -8.30630511e-02f,
  3.28491241e-01f, -1.27615646e-01f, -2.11665258e-01f, 1.16283931e-01f, 1.08900338e-01f, 1.30385384e-01f, 3.70034436e-03f, 1.07753128e-01f, -6.76794797e-02f, -6.43657297e-02f,
  1.72359571e-01f, 1.07127875e-01f, 2.91170448e-01f, 1.60760924e-01f, 6.18858933e-01f, -1.67915463e-01f, -9.27868262e-02f, -2.68845707e-01f, 6.69689551e-02f, -5.88459447e-02f,
  -1.09059513e-01f, -1.27640098e-01f, -9.14415419e-02f, 3.40540521e-02f, 6.83626682e-02f, 9.70544517e-02f, -1.62016805e-02f, 5.46561219e-02f, -1.11091547e-02f, -2.22972408e-02f,
  -3.18047665e-02f, -1.72584087e-01f, 1.86157562e-02f, 2.65061650e-02f, -1.95947643e-02f, 7.28263408e-02f, 5.40698990e-02f, -2.73165368e-02f, -2.51258910e-02f, 6.34197965e-02f,
  -1.07902493e-02f, 1.52276069e-01f, -4.74825539e-02f, 5.00882827e-02f, 1.81896165e-01f, 3.84779349e-02f, 6.08885325e-02f, 6.35612011e-02f, 1.23179741e-01f, -1.38966339e-02f,
  -1.44381061e-01f, 1.59946922e-02f, -2.57364213e-02f, -5.86271919e-02f, 9.88017544e-02f, -1.35238683e-02f, 1.28180787e-01f, 4.54397686e-02f, -8.58141575e-03f, 8.82009938e-02f,
  -1.84033532e-02f, 2.01086309e-02f, 3.62853669e-02f, 6.15281751e-03f, 9.54773873e-02f, 1.42286057e-02f, 9.87134129e-02f, 9.49764922e-02f, 1.24229886e-01f, -5.20348288e-02f,
  5.64126261e-02f, -1.09534539e-01f, 9.99976918e-02f, 3.71447615e-02f, -3.61602344e-02f, 7.99681842e-02f, -2.39881441e-01f, -1.41207799e-01f, -3.59147750e-02f, 8.97548795e-02f,
  -1.11487694e-01f, 1.41188372e-02f, -9.40245092e-02f, 1.07934969e-02f, 7.97685012e-02f, -2.21534483e-02f, 7.92381726e-03f, 4.83937655e-03f, -1.25898629e-01f, -1.54772997e-01f,
  3.66500765e-02f, 1.78767174e-01f, 5.73193170e-02f, 7.78933167e-02f, -1.19901840e-02f, -1.07954238e-02f, 7.57488310e-02f, 8.28997120e-02f, -6.42600358e-02f, 5.86574003e-02f,
  -6.41313046e-02f, -9.63801146e-02f, -3.15879770e-02f, 1.59793258e-01f, -4.36332487e-02f, -1.73052832e-01f, -1.85959414e-01f, -4.35185805e-03f, 2.03910749e-02f, -1.27135562e-02f,
  1.21736370e-01f, 6.49327338e-02f, 4.67955768e-02f, -4.10874374e-02f, -1.60444364e-01f, 4.72545549e-02f, -6.79870546e-02f, 8.74707662e-03f, 6.75451104e-03f, 1.21552557e-01f,
  1.97518170e-01f, -8.54653865e-02f, -1.36136953e-02f, -1.85538843e-01f, 3.58838022e-01f, 2.03792006e-01f, 4.98589799e-02f, 2.12000549e-01f, 1.83342341e-02f, 1.00254221e-02f,
  -7.18486086e-02f, -1.08950406e-01f, 6.15610145e-02f, 7.70729780e-02f, 2.18313858e-01f, 4.95011061e-02f, -9.45876688e-02f, 3.51954162e-01f, 2.82111187e-02f, 7.32426867e-02f,
  4.41388488e-01f, 7.91487694e-02f, 4.28456485e-01f, -2.82268256e-01f, 2.48136427e-02f, -3.26663136e-01f, 2.13662803e-01f, 1.11746944e-01f, 1.96096286e-01f, 2.01900065e-01f,
  2.64451951e-01f, 1.98662896e-02f, -7.33952075e-02f, -2.41951309e-02f, -1.23709418e-01f, 1.99400887e-01f, -8.67018923e-02f, 3.71546596e-02f, 1.63499527e-02f, -6.71640933e-02f,
  1.91018190e-02f, 1.22396514e-01f, 8.74563828e-02f, 4.18028124e-02f, 3.19410264e-02f, -3.09622269e-02f, -8.05319101e-02f, 4.80369367e-02f, -4.47847135e-02f, 4.73052934e-02f,
  -5.16144410e-02f, 5.00342101e-02f, 4.58551981e-02f, 1.30927414e-01f, -8.14613253e-02f, 6.17640875e-02f, 8.04711729e-02f, 1.38167381e-01f, 4.21527997e-02f, -9.35216919e-02f,
  1.69559613e-01f, -3.44329923e-02f, 1.79815829e-01f, 1.08015381e-01f, 4.15097326e-02f, 1.12579703e-01f, 9.21310484e-03f, 1.59376845e-01f, 9.45337042e-02f, -3.50355320e-02f,
  7.91753754e-02f, 3.60257439e-02f, 6.21818984e-03f, 4.57327925e-02f, -1.00049064e-01f, -1.43177258e-02f, 2.30518788e-01f, 1.16177443e-02f, 7.43809808e-03f, 8.03514421e-02f,
  -6.83313282e-03f, -1.24513850e-01f, 2.07576230e-01f, 1.99123770e-01f, -1.12245962e-01f, -1.12641841e-01f, -3.82711552e-02f, 3.28741828e-03f, -2.38553017e-01f, 4.51091640e-02f,
  8.96163657e-02f, -2.44443327e-01f, 8.01874921e-02f, 5.63244708e-02f, 1.15174405e-01f, 1.71704933e-01f, 1.48745939e-01f, 1.54293897e-02f, -7.31466115e-02f, -2.13147625e-02f,
  -1.21265072e-02f, 1.24103539e-01f, 4.52644862e-02f, -1.53114319e-01f, 1.44450843e-01f, 1.17266610e-01f, -1.49860665e-01f, 3.30175459e-02f, 1.21696107e-01f, 7.51640126e-02f,
  -6.57492429e-02f, -8.80700946e-02f, 7.65318237e-03f, -1.81197271e-01f, 9.46685821e-02f, -2.75353819e-01f, 5.99914007e-02f, -1.72934443e-01f, -1.67740539e-01f, -6.66395202e-02f,
  -6.87787309e-02f, -2.50012390e-02f, -3.72422449e-02f, -2.47056764e-02f, -1.07553173e-02f, 7.86270723e-02f, 1.19148582e-01f, -5.52034676e-02f, -1.08953990e-01f, 1.05901457e-01f,
  4.43435460e-03f, -2.03096896e-01f, 1.63942024e-01f, -2.74650604e-02f, -6.62941486e-02f, 1.15870677e-01f, -2.58303732e-01f, 2.74689019e-01f, -1.85645465e-02f, 1.03926629e-01f,
  1.81432217e-01f, 1.23293862e-01f, -1.09776400e-01f, 1.94956362e-01f, 3.70951444e-01f, -7.82246329e-03f, -2.76760936e-01f, -1.51458174e-01f, 1.92398310e-01f, 2.59555489e-01f,
  8.11094977e-03f, -1.98839352e-01f, 2.46316940e-01f, 9.56355631e-02f, 5.57233572e-01f, 9.11379382e-02f, 3.55011880e-01f, -3.87393832e-02f, 2.17790920e-02f, 1.17653176e-01f,
  3.73650976e-02f, -3.18815596e-02f, -3.61623382e-03f, -5.46766706e-02f, -5.41244261e-02f, 1.43489331e-01f, 7.13737085e-02f, 6.97724000e-02f, 4.07598391e-02f, 4.02892865e-02f,
  6.01620562e-02f, 2.25413591e-01f, 9.94649455e-02f, -5.30099571e-02f, -4.37270440e-02f, 2.92613413e-02f, 4.66429666e-02f, 1.83844745e-01f, -8.15203506e-03f, 7.80484304e-02f,
  8.97375401e-04f, 2.30811715e-01f, 1.38788089e-01f, 8.58197883e-02f, -1.09590665e-02f, 1.23808354e-01f, 1.89212635e-01f, -3.17394175e-02f, -1.38572171e-01f, 1.01370983e-01f,
  -4.06849422e-02f, 9.93252546e-02f, 4.11382541e-02f, 6.05484098e-02f, -6.46373630e-02f, 9.76574495e-02f, 6.23142496e-02f, -1.29627790e-02f, 5.74848652e-02f, 2.40596235e-01f,
  3.35621014e-02f, -3.20183523e-02f, 1.22862644e-01f, -2.70811245e-02f, -6.83605447e-02f, 1.93833902e-01f, 1.46573186e-02f, -1.83016644e-04f, 1.13988712e-01f, 2.64748037e-02f,
  -1.30685255e-01f, 1.41342590e-02f, 4.02866006e-02f, -1.22785069e-01f, 4.79414463e-02f, 1.33049823e-02f, -1.77852929e-01f, -3.03069260e-02f, 1.64558470e-01f, 8.91164988e-02f,
  3.00415214e-02f, -2.86036311e-03f, 6.68553030e-03f, 2.41868291e-03f, -1.94952041e-02f, 3.40205401e-01f, -1.89071533e-03f, 2.05758989e-01f, -1.25304028e-01f, -7.74908885e-02f,
  9.92741138e-02f, -2.70222604e-01f, -3.46890651e-02f, -1.26133457e-01f, -1.29615426e-01f, -1.25816926e-01f, 1.35113299e-01f, -6.78480715e-02f, -1.30647033e-01f, -1.24186695e-01f,
  6.18352834e-03f, -1.89770609e-01f, -1.06312335e-01f, -1.26911312e-01f, 1.51233375e-01f, -1.26073539e-01f, 1.03161991e-01f, 1.78732365e-01f, -6.34225011e-02f, -2.54039556e-01f,
  1.49149463e-01f, 5.28795421e-02f, 1.02087110e-01f, 1.18228229e-04f, -4.76218155e-03f, 1.57832295e-01f, 1.40502065e-01f, 1.16863139e-01f, 5.19465934e-03f, -9.65763777e-02f,
  -2.60045916e-01f, -2.15385240e-02f, 4.60208356e-01f, 1.21414408e-01f, 5.71709983e-02f, -3.09513986e-01f, -6.71558157e-02f, -8.94427579e-03f, -1.10200629e-01f, -2.41073333e-02f,
  -7.17047378e-02f, -1.17438890e-01f, 1.98213950e-01f, -3.38601470e-02f, 4.11886930e-01f, 1.57329157e-01f, 2.89339758e-02f, -1.33214489e-01f, -2.22078398e-01f, -5.09588480e-01f,
  -2.09154472e-01f, 1.73985139e-02f, -4.87814145e-03f, -2.00491071e-01f, -2.18344897e-01f, -3.71065110e-01f, -5.97709417e-02f, 1.09559797e-01f, 7.94650987e-02f, 8.98499135e-03f,
  9.13311541e-02f, -1.54462531e-01f, 9.22756270e-02f, 1.03723444e-01f, 1.35041848e-01f, -2.29564756e-02f, -6.30105063e-02f, 7.67408833e-02f, 1.06283404e-01f, 6.03436790e-02f,
  7.53336772e-02f, 1.13784801e-02f, 2.07532719e-02f, -6.58374056e-02f, -3.15203778e-02f, 2.16582879e-01f, 1.21067517e-01f, 7.75643736e-02f, -1.82715815e-03f, 6.94245845e-03f,
  2.14162603e-01f, 9.44938809e-02f, 1.31135443e-02f, 1.28328472e-01f, 7.77296349e-02f, 2.88218074e-02f, 1.47079881e-02f, -7.32628852e-02f, 1.07267452e-02f, 1.18208490e-01f,
  1.02671586e-01f, -1.72213048e-01f, 2.79803276e-02f, -4.32462990e-02f, 7.71954656e-02f, 8.26650336e-02f, 9.62252915e-02f, 7.36867711e-02f, 5.74860945e-02f, -7.73131773e-02f,
  9.18302089e-02f, 1.75892264e-02f, -5.23783974e-02f, 1.16597757e-01f, 4.50258739e-02f, -5.85615449e-02f, 1.53204590e-01f, 1.58944502e-01f, -1.25413582e-01f, -4.48799767e-02f,
  1.08230719e-02f, 1.32480683e-02f, 7.32612535e-02f, 9.80219617e-02f, 2.31518056e-02f, -6.49588555e-02f, 2.65174545e-02f, 1.39766783e-01f, 2.78442949e-02f, -4.00371663e-02f,
  1.23500742e-01f, -6.56506643e-02f, -4.41992481e-04f, 1.49443122e-02f, -1.59761403e-02f, -1.76350456e-02f, -5.62328398e-02f, -5.09114116e-02f, -9.86176729e-03f, -2.03106090e-01f,
  -3.56709622e-02f, -1.11156181e-01f, 1.13381058e-01f, -6.40542433e-02f, -2.80870125e-02f, -1.31720468e-01f, -8.97864923e-02f, 1.40087843e-01f, 6.14507385e-02f, 3.59649658e-02f,
  -8.53992328e-02f, 2.34910729e-03f, -6.09076321e-02f, 1.68437243e-01f, -4.55686972e-02f, 7.95538053e-02f, -4.32489328e-02f, -1.71122864e-01f, 3.31008099e-02f, 4.72257808e-02f,
  -7.69708455e-02f, -2.62252241e-02f, -2.27403380e-02f, -2.12451220e-01f, 5.15157059e-02f, -6.23690803e-03f, -6.67336583e-02f, 1.04511708e-01f, 8.90944228e-02f, 8.82703513e-02f,
  2.18827516e-01f, -1.02119640e-01f, 4.47395355e-01f, 3.15092355e-02f, -7.27954432e-02f, -8.06117877e-02f, -1.82282686e-01f, 1.13620386e-02f, 1.11601740e-01f, -8.11791699e-03f,
  -2.78236926e-01f, 1.21912837e-01f, 2.25892529e-01f, 1.85428724e-01f, 8.82553011e-02f, -1.25006139e-01f, -6.75774133e-03f, -3.00285429e-01f, -5.97961582e-02f, -1.93555087e-01f,
  -3.66967052e-01f, 1.70431957e-02f, -1.23048946e-01f, 2.44079754e-02f, -3.22689749e-02f, -1.08293518e-01f, -8.57296586e-02f, 1.19166940e-01f, 1.56374425e-01f, 3.66553515e-02f,
  5.62789366e-02f, 3.62518355e-02f, -4.39329166e-03f, 3.45409587e-02f, 1.94900390e-02f, -1.79082174e-02f, 6.42198250e-02f, 4.48810793e-02f, 8.31716731e-02f, -3.14677618e-02f,
  8.84617120e-02f, 8.34978968e-02f, -1.12549961e-01f, 1.14194565e-01f, 8.69484097e-02f, 1.47906184e-01f, 1.94850996e-01f, 7.85070434e-02f, 3.24092247e-02f, -2.46583540e-02f,
  1.22485245e-02f, 8.55604112e-02f, -8.59937519e-02f, 4.04927693e-02f, 7.81078264e-02f, 1.69222560e-02f, 1.12126917e-01f, 1.96783394e-01f, 1.70239136e-01f, -1.25874817e-01f,
  5.36189079e-02f, 4.15482968e-02f, 7.38771334e-02f, 7.27919936e-02f, 9.95624661e-02f, 1.07633382e-01f, 9.13937688e-02f, 1.44922599e-01f, -8.73867869e-02f, -4.54427535e-03f,
  -9.61087868e-02f, 1.54495552e-01f, 5.82426675e-02f, -7.13638216e-02f, 8.70672092e-02f, -1.63230240e-01f, 4.59325407e-03f, -3.98248807e-02f, 1.09011121e-01f, 1.24870427e-01f,
  -8.74932203e-03f, -9.45087075e-02f, 6.40107617e-02f, 2.09681928e-01f, 1.16661452e-01f, -1.32422820e-01f, -1.25321254e-01f, -9.23618767e-03f, -8.56013894e-02f, 3.77526470e-02f,
  1.47036016e-01f, 1.08096845e-01f, -1.39367551e-01f, 8.64921287e-02f, 8.00468326e-02f, 1.53367236e-01f, -1.00169204e-01f, 9.80414972e-02f, 4.11777422e-02f, -1.43922784e-03f,
  -6.48464188e-02f, -7.56410435e-02f, 2.04072952e-01f, 7.98744038e-02f, -2.21977174e-01f, -1.24147207e-01f, -8.00307170e-02f, 2.70068109e-01f, 1.18511349e-01f, 6.70050234e-02f,
  2.36554965e-01f, -6.64668456e-02f, 1.09210774e-01f, 2.68042590e-02f, 1.07311346e-01f, 2.47936502e-01f, -3.54017839e-02f, -8.61668214e-02f, -1.04230260e-02f, 4.24009822e-02f,
  9.03779939e-02f, 9.00705382e-02f, -1.17091835e-01f, 2.75983308e-02f, 1.15336962e-02f, 1.02170579e-01f, -3.09779197e-01f, -9.36208889e-02f, -5.59692085e-02f, 8.86539072e-02f,
  -2.11824328e-01f, 1.17141582e-01f, 6.12363182e-02f, -1.19773336e-01f, 5.41166738e-02f, 6.09160028e-02f, 2.10770279e-01f, -8.34193230e-02f, 3.57208848e-01f, 2.43966281e-01f,
  -9.61706042e-02f, 1.14149444e-01f, -2.40845546e-01f, -1.82355642e-01f, -4.81854439e-01f, 2.75463074e-01f, 1.49170235e-01f, 5.25902689e-01f, 9.06096175e-02f, 3.40281546e-01f,
  2.93700933e-01f, -1.75906606e-02f, 9.90711898e-02f, 1.20924897e-01f, -4.66489196e-02f, -9.27640870e-03f, -8.05020332e-03f, 6.97326735e-02f, -6.76072463e-02f, 3.38410176e-02f,
  2.72272993e-02f, 1.19320489e-01f, 1.15844965e-01f, 5.52279018e-02f, 1.79021955e-02f, 2.08571162e-02f, -1.71796996e-02f, 2.90179104e-02f, 7.41306320e-02f, 1.00609116e-01f,
  1.48503995e-03f, 3.29072103e-02f, 1.30291030e-01f, 5.40097803e-02f, 1.31356284e-01f, 1.37201861e-01f, 3.86789553e-02f, 1.06226176e-01f, 1.70156047e-01f, 8.81815180e-02f,
  5.94007373e-02f, 9.30370837e-02f, 5.47637530e-02f, -6.00592233e-02f, 7.88490623e-02f, 5.40099032e-02f, 1.15331970e-01f, 1.77894965e-01f, 1.82575181e-01f, 8.98507982e-02f,
  1.19791664e-01f, -1.36554733e-01f, 1.27380997e-01f, 1.47428155e-01f, -5.50038777e-02f, -2.84696445e-02f, 4.95631881e-02f, 6.17930926e-02f, 3.55075374e-02f, 1.08334415e-01f,
  9.26730111e-02f, 6.64099380e-02f, -5.08757606e-02f, 4.45648730e-02f, 1.36179000e-01f, 1.03230588e-01f, -9.89611298e-02f, -3.51205654e-02f, -7.52366260e-02f, 1.10230513e-01f,
  -1.94571853e-01f, 3.35882828e-02f, -1.36590540e-01f, 1.52706029e-03f, 6.33381978e-02f, 9.76599902e-02f, -4.42560464e-02f, -3.88003066e-02f, 5.27943820e-02f, -1.50042802e-01f,
  1.09354049e-01f, -8.16787034e-02f, 2.13828124e-02f, -4.81908247e-02f, -1.61142796e-02f, -2.14670524e-01f, 2.10816283e-02f, 8.06774851e-03f, -7.89037719e-02f, 1.20845675e-01f,
  -1.99329525e-01f, -3.80096100e-02f, 4.64791954e-02f, 1.16424322e-01f, -7.40372157e-03f, -2.55027235e-01f, -1.56587198e-01f, -6.30667359e-02f, -1.47581562e-01f, 3.27440538e-02f,
  -4.61727455e-02f, 3.96708958e-02f, -1.54752493e-01f, -8.48442316e-02f, 3.16077024e-02f, -1.50646735e-02f, -8.89285511e-05f, 4.99120448e-03f, -7.89515153e-02f, 3.70530933e-02f,
  1.75192609e-01f, -1.07545078e-01f, -4.05495130e-02f, -1.26036927e-01f, 1.98230311e-01f, 2.33513609e-01f, -1.36567712e-01f, 2.90917587e-02f, 7.29563683e-02f, 1.03444204e-01f,
  3.89325880e-02f, -1.29154027e-01f, -8.80683139e-02f, -1.71397299e-01f, -8.90388805e-03f, 2.39201084e-01f, -1.22566737e-01f, 2.19317749e-02f, 3.64517281e-03f, -2.01137513e-02f,
  3.93976003e-01f, 2.84951806e-01f, 4.72386658e-01f, -1.01215824e-01f, 1.10076211e-01f, -1.78320333e-01f, 1.79547369e-01f, -1.06961459e-01f, 6.99693337e-02f, 5.76226152e-02f,
  -5.72161712e-02f, 2.81929392e-02f, -5.28149307e-02f, 1.27781957e-01f, 1.35723218e-01f, 6.10486791e-02f, -7.55030476e-03f, -2.01567560e-02f, -4.01935615e-02f, -6.50287047e-02f,
  1.80863757e-02f, 4.46918234e-02f, 8.57120082e-02f, -1.62056964e-02f, 5.82972681e-03f, -7.25492984e-02f, 1.15989268e-01f, 9.02058557e-02f, 4.57689017e-02f, 1.21612087e-01f,
  -4.68881726e-02f, -1.47251368e-01f, 2.26225689e-01f, 2.58166119e-02f, 1.64282531e-01f, -1.98051091e-02f, 1.20135784e-01f, 8.45142454e-02f, -9.87975672e-02f, 1.09228818e-02f,
  5.56490123e-02f, 1.60133634e-02f, 1.46582082e-01f, 1.84926409e-02f, 9.91237983e-02f, -7.52175227e-02f, -6.81587458e-02f, 9.93105117e-03f, 4.77023907e-02f, 5.34435622e-02f,
  1.11354508e-01f, 7.12720677e-03f, 1.86747238e-02f, -4.93884422e-02f, 1.08486950e-01f, 2.53991168e-02f, 6.46127313e-02f, 1.36852026e-01f, 1.39416382e-01f, -1.36235848e-01f,
  4.91608195e-02f, -4.03716266e-02f, -6.75396249e-02f, -1.26404539e-01f, 1.26708429e-02f, 2.54487582e-02f, -8.40572715e-02f, 2.98950262e-02f, 1.04676247e-01f, -1.81866273e-01f,
  1.43515207e-02f, 7.71424919e-02f, -5.08535691e-02f, -1.13313846e-01f, 6.11551991e-03f, -2.71668099e-02f, -7.20048845e-02f, -7.37321377e-02f, -5.04954308e-02f, 2.01115981e-01f,
  -6.77791014e-02f, -1.52956005e-02f, -6.46768734e-02f, 1.98399320e-01f, 1.18084930e-01f, 2.05975175e-01f, 1.24792211e-01f, 3.69376391e-02f, 4.64690030e-02f, -2.62089550e-01f,
  -1.12992423e-02f, 4.79019573e-03f, -3.63446437e-02f, 1.19573325e-01f, -1.04538845e-02f, 1.55229405e-01f, -2.76037306e-02f, 2.18098149e-01f, -5.41753918e-02f, -4.05894183e-02f,
  7.85602629e-02f, 1.04684904e-01f, 3.75669748e-02f, -8.23091865e-02f, -3.49069610e-02f, 2.29704715e-02f, -2.79936660e-02f, -1.07737789e-02f, -5.75367659e-02f, -5.35951853e-02f,
  -1.61759868e-01f, 1.78249508e-01f, -1.66211471e-01f, -2.82624085e-02f, -1.20907575e-01f, 2.27539033e-01f, 5.03122687e-01f, 3.28632891e-02f, 2.64136016e-01f, 5.96979931e-02f,
  2.36400008e-01f, -9.75561813e-02f, 7.99848512e-02f, -9.42172706e-02f, 3.33955674e-03f, 1.93372488e-01f, -3.07593673e-01f, 1.02081396e-01f, -2.08726585e-01f, -2.10360467e-01f,
  -5.20177819e-02f, 3.77183586e-01f, -1.30119517e-01f, 1.79847553e-01f, 2.33800009e-01f, 1.48333818e-01f, 3.80791575e-01f, 1.16167210e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.18981682e-01f, 6.98935837e-02f, 1.06285520e-01f, 1.13768786e-01f, 2.04377502e-01f, 2.47819826e-01f, 1.04730844e-01f, 3.01028818e-01f, 1.22328021e-01f, 1.58146724e-01f,
  5.59390597e-02f, 1.30063578e-01f, 7.98499584e-02f, 1.96435109e-01f, 1.46754041e-01f, 2.41934627e-01f, 8.16953480e-02f, 1.34912536e-01f, 4.31024879e-02f, 2.35087387e-02f,
  1.12731591e-01f, 9.95737761e-02f, 7.97822401e-02f, 2.73474187e-01f, 4.38017584e-02f, 8.75144824e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -3.78047153e-02f, -6.81064725e-02f, 1.81451291e-02f, 9.89860147e-02f, -4.49975953e-02f, -1.35341391e-01f, -1.45247355e-01f, 1.24678776e-01f, -9.01174471e-02f, 1.85245395e-01f,
  -1.91658005e-01f, -7.88170472e-02f, 1.34721473e-01f, 3.80839296e-02f, -6.43268749e-02f, -2.84755558e-01f, 2.27055326e-02f, -3.10066249e-02f, -9.61687341e-02f, -2.36800283e-01f,
  -5.26972748e-02f, -9.97248441e-02f, -1.38818413e-01f, 1.50088975e-02f, -1.87700182e-01f, -9.23150554e-02f, 5.09497486e-02f, -2.60650605e-01f, -7.63172731e-02f, 2.57557947e-02f,
  -1.40335903e-01f, -3.19096521e-02f, -1.64765015e-01f, -1.68779030e-01f, -2.33386412e-01f, 1.80975735e-01f, 2.11034250e-02f, -2.39433527e-01f, 1.95306033e-01f, -1.61833510e-01f,
  -1.49479702e-01f, -5.38439900e-02f, 1.82149075e-02f, 7.32224882e-02f, -1.60697743e-01f, -2.02059314e-01f, -1.25594303e-01f, -1.02987804e-01f, 1.62862819e-02f, 9.63429287e-02f,
  -1.49228454e-01f, 1.84977666e-01f, 1.15914129e-01f, 2.14026809e-01f, -2.69299626e-01f, 3.00741792e-02f, -1.77433733e-02f, -3.46907340e-02f, -2.84309059e-01f, -4.88441586e-02f,
  -2.55199105e-01f, -2.07309693e-01f, -3.04840505e-04f, 1.82003394e-01f, -2.08142966e-01f, -2.18958035e-02f, 2.34389216e-01f, 5.80081083e-02f, 1.53126642e-01f, 2.43562851e-02f,
  -7.59525076e-02f, -2.62667060e-01f, -1.68517888e-01f, 1.70263574e-01f, 2.33668461e-01f, -6.96818158e-02f, 2.47233644e-01f, 1.66420013e-01f, 4.87985276e-02f, -1.50705844e-01f,
  -1.52172716e-02f, -1.10967472e-01f, -3.16379368e-01f, -5.33006601e-02f, 9.97048169e-02f, -2.06753835e-01f, 2.25734293e-01f, -1.12046033e-01f, 1.15910210e-01f, -1.35188937e-01f,
  -1.27710670e-01f, 6.94270581e-02f, 1.67928323e-01f, -2.45725170e-01f, 3.17294985e-01f, 5.28453290e-03f, -3.64233293e-02f, 1.17230505e-01f, 1.75278172e-01f, 2.08674073e-01f,
  -1.99088708e-01f, -1.03281163e-01f, 1.06017061e-01f, -2.72560060e-01f, 2.68260449e-01f, 2.89722472e-01f, -3.16928715e-01f, -1.99897476e-02f, 1.75943539e-01f, 2.27766987e-02f,
  -2.45871879e-02f, -2.89616764e-01f, 5.03987521e-02f, -1.08254418e-01f, 6.46479130e-02f, -2.30674416e-01f, -3.90708864e-01f, 1.68521345e-01f, -1.53246313e-01f, -1.38017982e-01f,
  2.04505622e-01f, -2.50489376e-02f, 1.58832729e-01f, -5.34901880e-02f, -1.23752259e-01f, -6.26329958e-01f, 2.63997257e-01f, -5.46037853e-01f, -3.30279738e-01f, -1.15162820e-01f,
  -2.99885541e-01f, 1.92501277e-01f, -8.75868946e-02f, 6.59862235e-02f, -2.01995805e-01f, 2.36399740e-01f, -1.31575316e-02f, -1.07728191e-01f, 2.32668780e-03f, 5.98127358e-02f,
  -1.73984781e-01f, 3.55429985e-02f, 1.91925883e-01f, -7.32507184e-02f, -1.93090156e-01f, 2.29766741e-01f, 1.24922097e-01f, -3.86364520e-01f, -9.18222368e-02f, 3.88905630e-02f,
  1.27339080e-01f, 4.51111235e-02f, -2.54292309e-01f, 1.37901559e-01f, 1.91938113e-02f, 5.88258617e-02f, 1.39784664e-02f, 2.29163215e-01f, 3.58448289e-02f, 3.00476193e-01f,
  -2.26650506e-01f, 8.39435458e-02f, -2.36349896e-01f, -1.98165849e-02f, -1.02481626e-01f, 2.50393059e-02f, -2.88728148e-01f, -1.42379135e-01f, 2.01318145e-01f, -3.72732669e-04f,
  1.20965214e-02f, 9.62036103e-02f, 6.76134899e-02f, -1.20372169e-01f, -4.61344942e-02f, -1.58168614e-01f, 2.20995583e-02f, -1.31285608e-01f, -1.02641843e-01f, -1.27253026e-01f,
  4.76082824e-02f, 6.49071336e-02f, 4.57259744e-01f, -1.09974422e-01f, -1.30858094e-01f, -1.05748899e-01f, -3.58402938e-01f, 1.74112737e-01f, -2.67388880e-01f, 1.45498693e-01f,
  -4.22254466e-02f, -2.06511587e-01f, -1.03529140e-01f, 1.61894888e-01f, -1.63705304e-01f, 2.31557131e-01f, 1.76115893e-02f, 4.38952185e-02f, 5.75555563e-02f, -2.34879971e-01f,
  -5.66934161e-02f, -1.11454427e-01f, 9.73151028e-02f, -3.56668271e-02f, 1.67018086e-01f, -7.13808089e-02f, 2.09692448e-01f, 3.37342262e-01f, 1.68457255e-02f, 2.20862985e-01f,
  -3.13738674e-01f, -2.51469970e-01f, -8.50639120e-02f, 7.95722380e-02f, -1.64465100e-01f, 2.37672687e-01f, -9.50852484e-02f, 1.54161185e-01f, 1.33417726e-01f, -1.66626200e-01f,
  3.14230621e-01f, 1.29238069e-01f, 1.15497299e-01f, 1.87173039e-01f, 1.38923645e-01f, -1.09172218e-01f, 2.86763132e-01f, 3.25603902e-01f, 2.72049129e-01f, 1.36985824e-01f,
  5.83106764e-02f, 6.69092983e-02f, 1.25816166e-01f, -5.24251424e-02f, 2.91172892e-01f, -5.05762696e-01f, -4.16281402e-01f, -4.21180964e-01f, -2.20515564e-01f, -3.18954922e-02f,
  -1.66203216e-01f, 2.48991758e-01f, 2.53940791e-01f, -3.03970724e-01f, -4.50989246e-01f, -3.80158931e-01f, 1.60564452e-01f, -2.56371737e-01f, 1.39280736e-01f, 1.75858051e-01f,
  -2.86713354e-02f, -3.97818051e-02f, 1.78722009e-01f, -4.55429628e-02f, 2.26982072e-01f, 9.09183919e-03f, -5.38417175e-02f, 2.92276423e-02f, -1.74533099e-01f, -1.04700126e-01f,
  1.24811284e-01f, -1.94772985e-02f, -2.14600325e-01f, -2.23075837e-01f, 1.20995954e-01f, 1.27461433e-01f, -4.61605191e-02f, 4.55280915e-02f, -4.65573147e-02f, 9.06895995e-02f,
  -1.54599726e-01f, -7.55062252e-02f, -7.82423913e-02f, -1.10475086e-01f, -1.59805626e-01f, -3.37773673e-02f, -8.23212266e-02f, -5.06964736e-02f, -2.10653707e-01f, 3.93108241e-02f,
  6.35591373e-02f, -1.68265000e-01f, -1.86099000e-02f, -2.22421318e-01f, -6.55708760e-02f, -1.25580609e-01f, -2.44055271e-01f, -4.82828617e-02f, -2.71875650e-01f, -3.82371955e-02f,
  2.83718854e-02f, -1.68654040e-01f, 2.52198040e-01f, 1.47788972e-01f, 7.54658207e-02f, 4.72758301e-02f, -1.26308396e-01f, -1.73956692e-01f, -1.06605729e-02f, -4.66535725e-02f,
  7.92567506e-02f, -4.60717455e-02f, -3.22305262e-02f, -3.55129503e-02f, -4.87388968e-02f, -1.50736779e-01f, 9.09637064e-02f, 8.98629203e-02f, -3.50324094e-01f, 2.22354993e-01f,
  4.83282536e-01f, 8.53005424e-02f, 6.94967294e-03f, 2.84870356e-01f, -3.33216846e-01f, 7.55611435e-02f, 1.33617207e-01f, 1.59983441e-01f, 1.85391679e-01f, -1.37922298e-02f,
  3.22510123e-01f, 1.62934095e-01f, -6.10310622e-02f, -2.74497569e-01f, 2.74934843e-02f, 2.99998581e-01f, 7.25674629e-02f, -2.60263175e-01f, 3.21478724e-01f, -1.96918070e-01f,
  -3.76670025e-02f, -6.16826825e-02f, 1.76709995e-01f, -2.19716311e-01f, -1.36841476e-01f, 1.25427902e-01f, 1.09888762e-01f, -1.51730627e-01f, 3.54388148e-01f, -1.18424401e-01f,
  7.03528970e-02f, -9.70322862e-02f, 7.14325532e-02f, 1.07915193e-01f, 7.64977112e-02f, -3.60285878e-01f, 2.25944728e-01f, 2.15793233e-02f, 2.88852960e-01f, 9.28359404e-02f,
  2.58515984e-01f, 2.36752197e-01f, -1.56003479e-02f, -2.23079488e-01f, 3.00639063e-01f, -1.67181596e-01f, 7.16501400e-02f, -2.45434284e-01f, -1.76551551e-01f, -3.64340916e-02f,
  3.34065288e-01f, -9.96780246e-02f, 1.69471815e-01f, -2.66953677e-01f, -5.35943270e-01f, -2.27387384e-01f, 1.37061819e-01f, 1.49906471e-01f, 2.31746167e-01f, 4.32126131e-03f,
  -1.06287211e-01f, 5.35593778e-02f, 4.09733392e-02f, 1.52476683e-01f, 1.76333934e-01f, 4.87078726e-02f, 1.51482364e-02f, -1.12495244e-01f, 1.17120177e-01f, 3.53428274e-02f,
  -7.09401369e-02f, -2.56755352e-01f, 9.53289717e-02f, -3.12710762e-01f, -5.57304844e-02f, 1.58296078e-01f, -5.63782975e-02f, 3.39836664e-02f, 5.10845259e-02f, -2.66383111e-01f,
  3.73614967e-01f, -8.48248228e-02f, -2.10606351e-01f, -1.25467256e-01f, 7.51898140e-02f, -2.92002931e-02f, -3.00284177e-01f, 9.27703921e-03f, -1.66975975e-01f, -3.81382592e-02f,
  1.19371228e-01f, 3.53754126e-02f, 7.03928620e-02f, 1.55813724e-01f, 1.13618299e-01f, 3.05903733e-01f, 5.14360853e-02f, -7.75782615e-02f, -1.61539793e-01f, -8.15218166e-02f,
  -4.53176826e-01f, 2.60851651e-01f, -6.15489893e-02f, 2.06222042e-01f, 2.39103556e-01f, -1.81835115e-01f, -3.52983698e-02f, -1.13411568e-01f, -2.95518264e-02f, -1.35216411e-04f,
  -2.77872741e-01f, -1.63012996e-01f, 3.02178152e-02f, -2.27124959e-01f, 1.80542991e-01f, 1.00717202e-01f, -6.75764605e-02f, -2.66616903e-02f, 4.72158613e-03f, 1.02646589e-01f,
  4.92786169e-02f, 1.13124410e-02f, -3.51250544e-02f, -1.11581653e-01f, -2.82292962e-01f, 2.48151228e-01f, 4.05461751e-02f, -1.31819695e-01f, -1.38869807e-01f, -1.04519360e-01f,
  -1.39869899e-01f, 1.81198359e-01f, 6.17661960e-02f, -5.03543317e-02f, 8.77650753e-02f, -1.94218665e-01f, -4.49105144e-01f, 1.46262813e-02f, 1.97196066e-01f, 1.07823528e-01f,
  -3.68678011e-02f, 1.36273593e-01f, -2.33888149e-01f, 1.11087866e-01f, 1.90400884e-01f, 1.55231478e-02f, -7.74200037e-02f, 6.52996078e-02f, -2.14289755e-01f, -1.17083736e-01f,
  2.31573626e-01f, 2.20963970e-01f, -2.01424072e-03f, 5.28815947e-02f, 1.48302149e-02f, 2.87722517e-02f, -3.33121061e-01f, 2.80669164e-02f, 8.56414288e-02f, 2.65815228e-01f,
  7.78753087e-02f, 1.98087320e-01f, -1.73218623e-01f, -1.01381809e-01f, -1.97744086e-01f, 9.59965289e-02f, 1.26774341e-01f, -4.10464317e-01f, 4.76025403e-01f, 1.59780681e-01f,
  3.68994743e-01f, -2.15604916e-01f, 1.83828786e-01f, 4.44076955e-01f, -2.70912647e-01f, 1.93468601e-01f, -9.07900855e-02f, -3.77112061e-01f, -1.39545962e-01f, 7.71255791e-02f,
  1.47039756e-01f, 1.48741916e-01f, -1.86757341e-01f, 1.58256382e-01f, -3.76494974e-01f, -2.92445242e-01f, 4.31444705e-01f, -2.63565898e-01f, -4.11394507e-01f, 2.19029635e-01f,
  -3.13427933e-02f, -1.95722803e-01f, -1.02872632e-01f, 1.96492001e-01f, -4.07251745e-01f, -3.43177259e-01f, 3.21040861e-02f, 1.79116987e-02f, -1.60716653e-01f, 1.02493942e-01f,
  -8.88580754e-02f, -6.49722442e-02f, 9.92106795e-02f, -8.84545445e-02f, 2.10372880e-01f, -3.01623881e-01f, 1.05311431e-01f, 2.43311465e-01f, -1.71276182e-02f, 9.68853757e-02f,
  4.43092373e-04f, -1.96315899e-01f, 1.93294421e-01f, 1.16579287e-01f, -1.15356356e-01f, 1.13413990e-01f, -1.74598038e-01f, 9.36743319e-02f, 2.59330034e-01f, 8.46295133e-02f,
  -2.82037612e-02f, 1.49202034e-01f, -1.39062153e-02f, -1.19383030e-01f, 2.02641755e-01f, 1.00380415e-02f, 1.94444299e-01f, 9.62150395e-02f, 2.79144704e-01f, -6.82769939e-02f,
  -9.52204224e-03f, -2.86471695e-01f, -7.60323480e-02f, 8.51278678e-02f, 7.69356489e-02f, 9.58841853e-03f, 5.43892980e-02f, -3.74639094e-01f, -6.31549284e-02f, 9.93168261e-03f,
  -3.77567746e-02f, 3.69294062e-02f, -1.82428285e-01f, 1.05956383e-01f, -2.28888951e-02f, 1.13461144e-01f, 4.30641808e-02f, 1.93713233e-01f, -3.44030187e-02f, 1.10040084e-01f,
  3.82202840e-03f, 1.40801236e-01f, -1.99899450e-01f, -2.09217658e-03f, 2.87845522e-01f, -2.64111668e-01f, -2.61106193e-01f, -2.87056029e-01f, 1.50490580e-02f, 2.11712718e-02f,
  2.97160119e-01f, -2.49668956e-01f, 2.01815322e-01f, -1.98264062e-01f, 3.82554412e-01f, 1.65348098e-01f, 2.58331239e-01f, 9.63094085e-02f, -2.85516842e-03f, 1.85053870e-02f,
  -1.23874366e-01f, 2.27337271e-01f, 2.08994508e-01f, 2.31555700e-01f, 2.41049320e-01f, 1.71062633e-01f, -2.23432764e-01f, 9.40536857e-02f, -3.25498469e-02f, 5.78455478e-02f,
  -2.15696942e-04f, 1.23147614e-01f, 7.43935853e-02f, 2.75614709e-01f, 5.07253528e-01f, 4.79188003e-02f, 2.82660276e-02f, 2.43479639e-01f, -1.78643152e-01f, -4.56082731e-01f,
  4.44343165e-02f, -2.39203721e-01f, 2.92260259e-01f, 1.33686021e-01f, 1.23081520e-01f, 2.90576786e-01f, -4.47241127e-01f, 9.47708413e-02f, -3.00468892e-01f, -7.67844617e-02f,
  -1.59554213e-01f, -3.13673645e-01f, -2.15997640e-02f, -2.88066119e-01f, 1.74242213e-01f, -4.94099379e-01f, -1.20086856e-01f, -8.28605890e-03f, -1.66249961e-01f, 1.93368703e-01f,
  2.14024708e-01f, 2.28232905e-01f, -8.46361890e-02f, 9.41703990e-02f, -2.53853202e-01f, 5.21743251e-03f, 2.27904078e-02f, -4.01440352e-01f, 7.25256801e-02f, 6.71589300e-02f,
  -3.19210827e-01f, 1.70753658e-01f, -2.01943517e-01f, -3.23870480e-02f, 4.92039360e-02f, -4.16500360e-01f, -2.97404714e-02f, 1.78387180e-01f, -1.92550674e-01f, 5.45618171e-03f,
  1.95029050e-01f, 1.04342461e-01f, 2.34291822e-01f, -8.49481672e-03f, 2.43962239e-02f, 8.76835957e-02f, 9.10281539e-02f, -1.04677975e-01f, 6.67918175e-02f, -6.14009984e-02f,
  6.94463402e-02f, -3.20290998e-02f, 1.24580584e-01f, -2.10220329e-02f, 9.39946175e-02f, 1.32285610e-01f, -9.12592933e-02f, 3.12240589e-02f, 2.72436254e-02f, 2.12293446e-01f,
  7.37562999e-02f, -1.66594788e-01f, 6.70679891e-03f, -1.02269217e-01f, 1.50067881e-01f, -1.60638183e-01f, -1.69468045e-01f, 8.27009305e-02f, -3.21114808e-02f, 4.15062942e-02f,
  -3.74907292e-02f, 1.57167822e-01f, 1.62424773e-01f, 1.22598238e-01f, 1.59428030e-01f, 1.97372306e-02f, 7.53857270e-02f, 7.39647970e-02f, 3.08701545e-01f, 3.11718229e-02f,
  1.02196284e-01f, 8.32751840e-02f, 1.05340160e-01f, 3.94824669e-02f, -2.27613468e-02f, -1.72973737e-01f, 2.28117004e-01f, 3.81866544e-02f, 1.58369970e-02f, 1.44602627e-01f,
  2.67564982e-01f, 7.88581520e-02f, 8.33664611e-02f, -4.17638160e-02f, 1.19966000e-01f, -9.80599318e-03f, 2.09417254e-01f, 1.59970611e-01f, 2.90889800e-01f, 5.33426926e-03f,
  2.37407073e-01f, 1.07305117e-01f, -2.80920535e-01f, -3.54543447e-01f, -3.35527748e-01f, -2.36762315e-01f, -2.54634649e-01f, -1.25910968e-01f, -3.31819117e-01f, -3.04911554e-01f,
  2.11256802e-01f, -1.17054507e-02f, 1.26212895e-01f, 8.09944794e-02f, -1.67981789e-01f, -1.10323489e-01f, -3.69764686e-01f, -2.64067113e-01f, -2.10486248e-01f, 1.81173846e-01f,
  1.02914870e-01f, -1.51410941e-02f, 4.94407862e-02f, 2.73670167e-01f, -1.95649475e-01f, -1.84311852e-01f, 1.05356172e-01f, -1.87034950e-01f, 1.21371888e-01f, 3.06730330e-01f,
  1.69899613e-01f, 8.90320688e-02f, -3.03831935e-01f, 5.11303470e-02f, -4.34575886e-01f, -1.41678244e-01f, -2.20243841e-01f, -6.15911856e-02f, -2.03097537e-02f, -6.71308264e-02f,
  2.12305933e-02f, 1.65758744e-01f, 1.78452924e-01f, 1.79993510e-01f, -2.52519459e-01f, -1.16990842e-01f, -2.43091300e-01f, 4.06132132e-01f, 3.78239155e-01f, -1.51391700e-01f,
  -8.97377282e-02f, -4.07481909e-01f, -4.33270216e-01f, -2.90991385e-02f, 2.07292840e-01f, -5.08714952e-02f, 3.77791315e-01f, -2.74800599e-01f, -1.13652579e-01f, -1.82456970e-01f,
  1.80087566e-01f, 1.33174315e-01f, -6.44447878e-02f, -2.30711266e-01f, -7.72313261e-03f, -2.07629278e-01f, 1.76439717e-01f, -1.95006147e-01f, 8.05107206e-02f, 4.40421477e-02f,
  9.22907665e-02f, -1.46236286e-01f, 1.03037648e-01f, -4.88131754e-02f, 1.25565648e-01f, 2.40491368e-02f, -8.76083001e-02f, -1.79302976e-01f, 1.44109577e-01f, -2.81216562e-01f,
  1.01642646e-01f, -2.25583643e-01f, 9.99605954e-02f, 5.13670333e-02f, -1.80428755e-02f, 1.14404820e-02f, -4.46962602e-02f, 1.47087321e-01f, -2.61379004e-01f, 6.06276132e-02f,
  1.13118440e-01f, 3.63141373e-02f, -1.95043534e-01f, 4.33180220e-02f, -2.88573265e-01f, 1.45461246e-01f, -1.37244731e-01f, -4.84894700e-02f, -1.46480706e-02f, -5.82218319e-02f,
  7.36593306e-02f, 1.01390362e-01f, -1.71015076e-02f, -2.27704505e-03f, -1.01314180e-01f, -6.67665228e-02f, 7.83208087e-02f, 1.14317304e-02f, 4.56969403e-02f, 7.06272125e-02f,
  -3.23953256e-02f, -8.49187896e-02f, 7.93398619e-02f, 5.26173785e-03f, 2.80169453e-02f, -3.29714082e-02f, -1.01336345e-01f, 1.54412955e-01f, -2.08444402e-01f, 4.75226976e-02f,
  -8.86592045e-02f, 2.72388816e-01f, 1.87856063e-01f, 7.63657270e-03f, -3.22134607e-03f, 5.07519394e-03f, 1.41870240e-02f, -1.65187672e-01f, -1.44531995e-01f, -1.80209890e-01f,
  9.90966856e-02f, -1.19915903e-02f, -2.75702178e-01f, -3.88431340e-01f, 6.86184466e-02f, -5.04883766e-01f, 1.37599632e-01f, 3.33474755e-01f, -1.09055452e-01f, 1.75355375e-01f,
  -1.68893740e-01f, 2.02675968e-01f, 3.16461086e-01f, 1.99762404e-01f, 1.86920464e-02f, -3.95208932e-02f, -3.51681337e-02f, -8.92418697e-02f, 3.94185148e-02f, -6.75022975e-02f,
  -4.06304486e-02f, 2.17800140e-02f, -2.03909889e-01f, 1.23176593e-02f, 6.76742345e-02f, 9.17814299e-03f, 3.95317554e-01f, 2.46011749e-01f, -2.76123494e-01f, -1.52023286e-01f,
  4.22608992e-03f, -4.18100245e-02f, -1.17625535e-01f, -8.07809904e-02f, 4.71543055e-03f, 1.25070557e-01f, -1.20737426e-01f, -2.28552163e-01f, 1.71825200e-01f, 2.51033127e-01f,
  -3.27432901e-01f, -6.24594279e-03f, 3.09136212e-01f, -5.35908759e-01f, 6.17363378e-02f, -2.81069696e-01f, 6.60541952e-02f, -5.28814793e-01f, 2.60762781e-01f, 2.28999138e-01f,
  -4.93905425e-01f, -1.45440595e-02f, 1.41132861e-01f, 5.15957661e-02f, 1.65004209e-01f, -3.78264844e-01f, -2.58811682e-01f, -1.94207057e-01f, 2.73593161e-02f, -1.03780240e-01f,
  -4.31408048e-01f, 3.67338359e-01f, 2.87762225e-01f, 7.11355209e-02f, -4.29405421e-01f, -3.17326784e-01f, -1.89370722e-01f, 1.67103652e-02f, -4.91964966e-02f, -8.93790200e-02f,
  -1.92206338e-01f, 3.92512828e-02f, -1.35188967e-01f, 1.19495988e-01f, 1.13786578e-01f, 1.74484372e-01f, -8.35705325e-02f, 1.12114847e-02f, -4.58636507e-02f, -7.21426830e-02f,
  -1.86184153e-01f, -1.94363579e-01f, -2.86386549e-01f, 2.46943459e-02f, -1.15934305e-01f, -2.47863978e-01f, -1.19556628e-01f, -8.31553414e-02f, -2.04746187e-01f, 6.97235465e-02f,
  -1.11084878e-02f, -2.41725240e-02f, 2.39602011e-02f, -1.22355670e-01f, -1.25003263e-01f, 1.71308368e-01f, 1.06293380e-01f, -2.27031797e-01f, -7.98050687e-02f, 2.97046863e-02f,
  -1.06645927e-01f, 9.07038897e-02f, 1.65313631e-01f, -1.34349361e-01f, -2.34753683e-01f, 1.09311014e-01f, -1.87461734e-01f, -1.26438558e-01f, -5.23354635e-02f, -7.25428686e-02f,
  5.79774976e-02f, -2.25392774e-01f, -2.75050998e-01f, 6.81043714e-02f, -6.25217706e-02f, -1.64401874e-01f, 1.34498402e-02f, -1.34038016e-01f, -2.60605603e-01f, 1.23614341e-01f,
  3.56010720e-02f, -9.41672456e-03f, -9.31094692e-04f, -2.16169078e-02f, -1.91637501e-01f, -1.32955387e-01f, -1.65473167e-02f, -2.64412016e-02f, 2.11264879e-01f, 9.63345915e-02f,
  2.15024948e-01f, 2.06892684e-01f, -1.19447075e-01f, -2.32973751e-02f, 7.36968815e-02f, -2.16850191e-01f, -6.59066811e-02f, 2.83702705e-02f, -6.08725194e-03f, -1.61485940e-01f,
  1.10496454e-01f, -4.15641963e-02f, -1.97100163e-01f, -5.32431230e-02f, -9.48374271e-02f, 1.56486392e-01f, 7.27873668e-03f, 6.62681833e-02f, -4.91615571e-02f, -1.30098835e-01f,
  9.36470404e-02f, 1.16036691e-01f, -1.24802575e-01f, 1.09521277e-01f, -1.40752703e-01f, -1.09017327e-01f, -6.99769706e-02f, 1.04304977e-01f, -1.19736642e-01f, 4.70417133e-03f,
  -3.98809370e-03f, -5.31762242e-02f, 1.98967934e-01f, 1.59158096e-01f, -1.77833036e-01f, 1.99560165e-01f, -1.73105702e-01f, -1.19878307e-01f, -1.67650387e-01f, 6.51546940e-02f,
  -3.68737042e-01f, -2.99593002e-01f, -2.86125153e-01f, 1.88610777e-01f, 1.73417442e-02f, -3.78846645e-01f, -2.84334600e-01f, -2.46391803e-01f, 8.65753740e-03f, -2.00800166e-01f,
  -2.77144849e-01f, 1.57786503e-01f, 1.54700711e-01f, 3.46389920e-01f, -2.79069364e-01f, 3.16970706e-01f, -4.71509069e-01f, 3.22222337e-02f, 3.59731577e-02f, -1.68045431e-01f,
  -5.53046092e-02f, 1.88440576e-01f, -2.87794352e-01f, 2.81305611e-01f, -2.55135689e-02f, 2.05503628e-02f, 2.74251681e-02f, 1.61211248e-02f, 6.27465080e-03f, 1.63647071e-01f,
  -6.11292496e-02f, 2.33633369e-02f, -2.38667126e-03f, 1.61877081e-01f, 3.58126201e-02f, -6.28155693e-02f, 9.95043293e-02f, -1.13349080e-01f, -1.69296246e-02f, 7.34907165e-02f,
  1.51789822e-02f, -1.65317729e-01f, -1.25846535e-01f, -1.00124344e-01f, 2.27431014e-01f, 1.52346998e-01f, -1.15245387e-01f, -6.40945733e-02f, 2.00825840e-01f, -1.31054938e-01f,
  9.22010243e-02f, -6.03884347e-02f, -5.23975566e-02f, -1.88133903e-02f, -1.47104591e-01f, -3.31155598e-01f, 1.28259912e-01f, -1.19365804e-01f, 1.13525890e-01f, 7.72374794e-02f,
  6.48883060e-02f, 4.43345606e-02f, -2.18895391e-01f, 1.96248263e-01f, -2.51063377e-01f, -6.42961860e-02f, 5.34597263e-02f, -1.03019901e-01f, 7.19006136e-02f, 9.55913439e-02f,
  -1.27427369e-01f, 7.44144842e-02f, 6.88581765e-02f, -1.15755968e-01f, 7.65084624e-02f, 2.52099454e-01f, 8.22195783e-02f, -2.37789601e-01f, -3.15244168e-01f, 1.95209935e-01f,
  4.83548194e-02f, -2.08235770e-01f, 3.14810365e-01f, -3.20003629e-01f, 1.34501934e-01f, 1.57015070e-01f, -1.31270126e-01f, -2.08378538e-01f, -2.34609321e-01f, -1.83415666e-01f,
  5.55239022e-01f, 4.85944562e-02f, 2.68065661e-01f, -2.78703362e-01f, -2.90562719e-01f, 1.94689080e-01f, -2.40870446e-01f, -3.19553465e-01f, -3.31465483e-01f, -5.29628247e-02f,
  -2.99761713e-01f, 3.47502053e-01f, 2.90504426e-01f, -4.59580779e-01f, -9.95562598e-02f, -2.63980269e-01f, -8.96584988e-02f, 1.11492775e-01f, -1.56995356e-01f, -1.27795413e-01f,
  -1.94452509e-01f, 1.41313463e-01f, -2.72052675e-01f, 6.79320171e-02f, -1.82134539e-01f, -1.87847182e-01f, -2.18010128e-01f, 5.64867780e-02f, 2.09611535e-01f, -1.89946294e-01f,
  -3.04863423e-01f, 1.77210942e-01f, -3.84391338e-01f, -1.11146502e-01f, 1.72112450e-01f, -1.60342995e-02f, -2.79827178e-01f, -5.24719581e-02f, -2.05133647e-01f, -1.26714230e-01f,
  -2.41010621e-01f, -3.31317335e-01f, -2.85608947e-01f, -3.05409789e-01f, -3.43869716e-01f, -8.20624754e-02f, 2.41127744e-01f, 2.64150113e-01f, -2.06541613e-01f, 4.45348948e-01f,
  -2.90269107e-01f, -1.44126832e-01f, 2.97934234e-01f, -1.68929458e-01f, 2.24277213e-01f, -3.08361184e-02f, -1.11831583e-01f, -7.31587633e-02f, -9.84364375e-02f, -1.62162513e-01f,
  9.55982879e-02f, 1.08502179e-01f, 5.90547845e-02f, -8.28557014e-02f, 1.01194896e-01f, 1.00158155e-02f, -2.53514081e-01f, 6.52874559e-02f, 2.34760903e-02f, -5.52401133e-02f,
  -1.09402552e-01f, 1.60484686e-01f, -1.83651716e-01f, -2.51865774e-01f, 2.11378038e-01f, 1.84939787e-01f, 1.54642045e-01f, 1.19868852e-01f, 3.01092938e-02f, -2.85267178e-02f,
  1.34049922e-01f, 1.14627462e-02f, 9.13113430e-02f, 1.58559054e-01f, 3.78227653e-03f, 5.70410118e-02f, 1.77249387e-01f, 2.23414689e-01f, -1.27352610e-01f, -1.98227450e-01f,
  2.66518891e-01f, -1.38410926e-01f, 3.46576393e-01f, -1.95083931e-01f, 1.47207454e-01f, -6.63873330e-02f, 9.25606862e-03f, 1.13114342e-01f, -1.01843409e-01f, 2.70547926e-01f,
  -4.06458974e-02f, 1.43827721e-01f, 1.14998169e-01f, 5.48988283e-02f, 8.73164684e-02f, 2.02379059e-02f, 1.50102302e-01f, 9.19389427e-02f, 1.21555984e-01f, 4.71097194e-02f,
  1.10090770e-01f, -7.82744065e-02f, 3.03144038e-01f, -3.56988132e-01f, -2.71912903e-01f, -1.31697804e-01f, -2.11046696e-01f, 2.70977497e-01f, -1.48864025e-02f, 6.71818778e-02f,
  -8.20024908e-02f, 2.53582954e-01f, -2.52691805e-02f, -2.55579591e-01f, 5.45876026e-02f, 1.06459841e-01f, -7.37619698e-02f, 3.93037528e-01f, 8.26646388e-02f, 6.08205199e-01f,
  1.47218987e-01f, -1.10665224e-01f, -1.28599316e-01f, 1.80328652e-01f, -2.16153339e-01f, -2.27176860e-01f, -1.43073974e-02f, 2.30671808e-01f, -7.09193051e-02f, -2.17299297e-01f,
  6.35618046e-02f, -1.00489050e-01f, 9.27030519e-02f, 3.01446408e-01f, 6.70893788e-02f, 1.50899142e-01f, 9.06935781e-02f, -1.35056391e-01f, -1.04596049e-01f, 3.40450644e-01f,
  -5.04060611e-02f, -2.58022174e-02f, -3.34690273e-01f, 4.28053290e-01f, -1.36008129e-01f, -2.33410634e-02f, -1.09825224e-01f, -3.00527006e-01f, -1.68319136e-01f, -5.26483171e-03f,
  2.55005490e-02f, -1.83787748e-01f, -2.67788529e-01f, 1.21331081e-01f, -4.19373393e-01f, 1.07922681e-01f, -1.98831335e-02f, 1.03872992e-01f, -1.87050462e-01f, -2.69839793e-01f,
  2.74947256e-01f, 1.22703224e-01f, 1.44840822e-01f, 2.15673462e-01f, -4.34813142e-01f, -6.65419847e-02f, -8.23638663e-02f, -3.71438742e-01f, 5.72822466e-02f, 3.96243662e-01f,
  -5.77301644e-02f, 1.19191304e-01f, -1.70707032e-01f, -2.58953243e-01f, 1.96552932e-01f, 2.80445725e-01f, -2.61033267e-01f, -2.17335057e-02f, -2.33197048e-01f, -2.29983956e-01f,
  1.39853895e-01f, 4.88895439e-02f, 2.20852103e-02f, 1.52070269e-01f, 2.29698699e-02f, 1.65354684e-02f, 1.50312379e-01f, -3.63715477e-02f, 1.05550721e-01f, -7.66081437e-02f,
  -1.76982015e-01f, 5.35346456e-02f, 2.79249139e-02f, -6.91209882e-02f, 9.49900597e-02f, 8.54222178e-02f, 1.17451057e-01f, 5.93561344e-02f, 1.01508901e-01f, 1.70616701e-01f,
  1.58231668e-02f, -3.35697606e-02f, 9.51835811e-02f, -1.71818689e-01f, 9.80192646e-02f, 9.88613889e-02f, 1.54186532e-01f, 1.77959293e-01f, 1.23130940e-01f, -1.71225928e-02f,
  1.52350992e-01f, 2.22550947e-02f, 8.98973867e-02f, 1.23338588e-01f, 8.12945422e-03f, -6.89518228e-02f, -6.08375110e-02f, -9.47403014e-02f, -1.14757121e-01f, -1.36643186e-01f,
  7.87779018e-02f, -1.07016325e-01f, 2.68926341e-02f, 1.51699856e-01f, -2.13439047e-01f, 8.15668255e-02f, 6.97924197e-02f, 8.97043943e-02f, 7.97202215e-02f, -1.88680023e-01f,
  1.27957806e-01f, 4.71337698e-02f, 8.58044401e-02f, 1.67337343e-01f, -1.09007858e-01f, -2.91086376e-01f, 3.11525106e-01f, -2.77788311e-01f, 7.30249658e-02f, -1.33135095e-01f,
  1.25962496e-01f, 1.73619553e-01f, -4.79841530e-02f, 2.65495002e-01f, 2.65634209e-01f, 1.85305133e-01f, 2.35970050e-01f, -1.83040962e-01f, -1.38457075e-01f, -3.12143803e-01f,
  7.04835579e-02f, -1.84691429e-01f, 2.28792533e-01f, 2.66560704e-01f, -1.53646767e-01f, 4.35118526e-02f, 3.01159471e-01f, 9.89893004e-02f, -1.97722867e-01f, -2.57820606e-01f,
  -3.21540773e-01f, 1.75074518e-01f, -1.04586124e-01f, 1.97509170e-01f, -1.96835816e-01f, -1.03018753e-01f, 1.92812830e-01f, -2.27664873e-01f, -2.28979051e-01f, 1.77895099e-01f,
  1.44942567e-01f, -1.74718156e-01f, -1.97789878e-01f, -3.45441550e-01f, 1.80990830e-01f, 2.28776589e-01f, -2.19578117e-01f, -1.69116870e-01f, -2.00379133e-01f, 2.14698841e-03f,
  2.20873117e-01f, -1.67237058e-01f, -6.07096329e-02f, -1.49710074e-01f, -3.10416698e-01f, -4.11710203e-01f, 3.45062524e-01f, -3.47462237e-01f, -2.07325041e-01f, 3.45892876e-01f,
  -3.11662167e-01f, -1.61127821e-01f, 3.17573315e-03f, -3.39806110e-01f, -5.60067780e-02f, -3.08462143e-01f, -2.23616753e-02f, 4.45054591e-01f, 2.59248078e-01f, -1.19516589e-01f,
  7.63442442e-02f, -3.27818543e-01f, -3.61281872e-01f, -1.50697216e-01f, 2.41252437e-01f, -3.94093156e-01f, -1.35460198e-01f, 4.48054105e-01f, 1.46073908e-01f, 6.42527593e-03f,
  1.05117798e-01f, 1.59735337e-01f, 1.63387254e-01f, -1.01355664e-01f, -3.88106774e-03f, -1.30698597e-02f, -9.38611291e-03f, 1.05458930e-01f, 1.81871522e-02f, 2.16019526e-01f,
  2.17290863e-01f, -7.07518831e-02f, 9.77763385e-02f, 5.52681424e-02f, 2.04068974e-01f, -2.44772285e-02f, -3.11126709e-02f, 1.54141486e-01f, -5.60619645e-02f, -4.81261685e-02f,
  -5.20297252e-02f, 1.69344526e-02f, 6.06825668e-03f, 7.81754628e-02f, 1.92070037e-01f, 1.47417441e-01f, 2.14410514e-01f, 5.62826619e-02f, -2.33232066e-01f, 2.25987256e-01f,
  -1.94928423e-02f, 1.85587883e-01f, 4.55249995e-02f, -3.02026700e-02f, 2.08164141e-01f, -2.15820577e-02f, 1.82959974e-01f, 2.14026291e-02f, -2.49866825e-02f, 1.48485467e-01f,
  2.91073415e-03f, -5.44146746e-02f, -8.32739994e-02f, 9.11321044e-02f, 9.08811241e-02f, 1.61852650e-02f, 2.67218910e-02f, 1.28126383e-01f, 1.28930524e-01f, -9.52578112e-02f,
  3.33769381e-01f, -8.13535973e-02f, -2.42664158e-01f, -1.82617411e-01f, -1.90414190e-01f, -2.79132426e-01f, 2.06479356e-01f, 2.88456649e-01f, -2.75857091e-01f, -5.07812947e-02f,
  8.33730027e-02f, -1.74039811e-01f, -1.58371687e-01f, -3.37358922e-01f, -2.67988265e-01f, 4.57111709e-02f, -1.53913528e-01f, 1.50333405e-01f, -1.81228846e-01f, 1.12514153e-01f,
  -2.34630182e-01f, 2.40525693e-01f, 3.43556076e-01f, 1.81343988e-01f, -2.08137736e-01f, 1.42367676e-01f, -2.96919852e-01f, -1.07238367e-01f, -3.30584943e-02f, -1.55221328e-01f,
  -3.32279876e-02f, -3.07705365e-02f, 1.71284512e-01f, 1.87982954e-02f, 1.19874351e-01f, 2.91847959e-02f, 3.71286690e-01f, 2.78564952e-02f, 8.07589963e-02f, -2.08960429e-01f,
  -6.51343614e-02f, 1.85160935e-01f, -1.64971903e-01f, -1.55915588e-01f, 3.04345936e-01f, 1.84201345e-01f, 2.80344635e-01f, 1.07867077e-01f, -1.84245870e-01f, 1.76823735e-01f,
  -2.74965554e-01f, 1.07066222e-01f, -3.17562282e-01f, 5.42926192e-01f, 2.72436768e-01f, 7.74519518e-02f, -1.07079722e-01f, 1.23027839e-01f, 2.29328364e-01f, 5.68816531e-03f,
  1.74568579e-01f, 2.08674427e-02f, -9.40632373e-02f, 1.78018853e-01f, 9.13851112e-02f, -2.83689439e-01f, -9.54585522e-02f, -4.04262580e-02f, -4.56124276e-01f, -3.26063126e-01f,
  -6.38618469e-01f, -3.42149854e-01f, -9.34862271e-02f, 1.72417656e-01f, -4.26975667e-01f, 6.24235831e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.31151378e-01f, 5.97454570e-02f, 4.58828434e-02f, 1.96766425e-02f, 1.02623731e-01f, -1.77145265e-02f, 2.36422289e-02f, 7.31559023e-02f, -4.65864688e-03f, 6.21379316e-02f,
  1.41127314e-02f, 6.55862242e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    