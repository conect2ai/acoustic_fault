/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.14315124e-02f, -5.64267188e-02f, 2.50488430e-01f, 8.32170695e-02f, 1.25167131e-01f, 8.21257755e-02f, 5.69656491e-02f, -3.69276814e-02f, 8.67728367e-02f, -7.34254792e-02f,
  -7.57127553e-02f, 4.84484024e-02f, -1.24568507e-01f, 3.70484521e-03f, -8.41726363e-02f, -1.21180177e-01f, -4.79601063e-02f, -6.93725655e-03f, 2.86559761e-02f, -5.44152968e-02f,
  3.31479236e-02f, -7.40213841e-02f, -7.62551231e-03f, -7.81395584e-02f, 1.35086775e-01f, 2.48586126e-02f, 8.98497365e-03f, -1.27503760e-02f, -1.25263017e-02f, 9.30450857e-02f,
  -2.73818038e-02f, 2.42812149e-02f, 1.16728460e-02f, -1.14220582e-01f, -1.34976255e-02f, -5.45271710e-02f, 6.77268654e-02f, -9.59444419e-03f, 4.06674966e-02f, 8.31880867e-02f,
  -5.22366762e-02f, -6.11877143e-02f, 1.40168229e-02f, 1.44322952e-02f, -5.11561986e-03f, -1.05495550e-01f, -6.12710696e-03f, -4.15169224e-02f, -1.87351108e-02f, 1.71250049e-02f,
  4.48342897e-02f, 2.00577807e-02f, 6.84356913e-02f, 5.07993810e-02f, -4.81612757e-02f, -5.47249010e-03f, 1.38592152e-02f, 1.25520900e-01f, -5.86261898e-02f, 3.49074490e-02f,
  3.59725356e-02f, -5.53872064e-02f, -7.08495751e-02f, -4.32954766e-02f, -4.54852656e-02f, -4.61222371e-03f, 5.06343246e-02f, -2.17513815e-02f, 4.02232036e-02f, -3.09952460e-02f,
  5.59307374e-02f, 6.38135383e-03f, -2.18878929e-02f, -3.35471407e-02f, 1.08953519e-02f, -7.15472782e-03f, -5.51537834e-02f, 8.09393078e-02f, 1.45227453e-02f, -8.77122730e-02f,
  -2.46094801e-02f, 1.40106715e-02f, -9.10267606e-02f, -1.32308668e-03f, -2.26529948e-02f, -1.15755051e-02f, -3.06364242e-02f, 4.84120362e-02f, -4.95168343e-02f, -1.99267045e-02f,
  -7.15764984e-02f, 6.79677278e-02f, 4.02970612e-02f, 1.74157266e-02f, 4.86309156e-02f, -3.34309004e-02f, -4.77320468e-03f, -4.16165125e-03f, -5.35278954e-02f, -2.63623204e-02f,
  -7.00603873e-02f, 6.17860556e-02f, -6.19407976e-03f, -7.47865997e-03f, -3.97476032e-02f, 3.95078100e-02f, -2.12480910e-02f, -4.12051268e-02f, -1.09487660e-02f, -7.33212829e-02f,
  -1.04409549e-02f, -4.84234318e-02f, 2.14972403e-02f, -2.44327374e-02f, 1.55245708e-02f, 1.71298850e-02f, 4.72166948e-02f, 8.72149039e-03f, 1.29988864e-02f, 6.45330846e-02f,
  -3.31096292e-01f, 3.53003778e-02f, -1.95157081e-01f, -5.59822470e-02f, -2.35689148e-01f, 2.20034108e-01f, 2.46977061e-01f, -1.25747100e-01f, 1.80532709e-01f, 3.91266227e-01f,
  1.19171351e-01f, 2.00290903e-02f, 2.45466769e-01f, 1.17887393e-01f, 1.62875861e-01f, 2.67330319e-01f, 1.62501872e-01f, 6.69807866e-02f, -5.27720302e-02f, -1.44506782e-01f,
  -1.38130128e-01f, 3.29563133e-02f, -1.21112637e-01f, -1.03460938e-01f, -2.30361223e-01f, -1.80453479e-01f, -5.28231561e-02f, -1.26120612e-01f, -2.80365236e-02f, 4.10403199e-02f,
  -1.03994817e-01f, -9.86178666e-02f, -1.62761882e-01f, -2.70543247e-02f, -7.46707469e-02f, -5.29218884e-03f, -5.08531812e-04f, -6.69216178e-03f, -2.68897768e-02f, -2.56244931e-03f,
  -3.02754366e-03f, -2.44759209e-02f, 4.57501635e-02f, 5.50725013e-02f, -6.87973127e-02f, -6.75484166e-02f, -1.80310998e-02f, -3.80206034e-02f, -3.93376313e-02f, -2.82766633e-02f,
  -3.47993039e-02f, -3.50579619e-02f, -1.72274224e-02f, 7.69242197e-02f, -1.56969938e-03f, 2.31796466e-02f, 1.88922733e-02f, -1.21659329e-02f, -1.89205296e-02f, 3.09880506e-02f,
  1.26459571e-02f, 9.57343876e-02f, 2.11281776e-02f, -2.40820181e-02f, 1.17302574e-02f, -2.39413232e-02f, 8.26177672e-02f, -2.00960767e-02f, -2.70041246e-02f, -2.63748989e-02f,
  2.18121503e-02f, -8.46275464e-02f, -3.15265879e-02f, 1.48713458e-02f, -1.47280879e-02f, -2.77453903e-02f, 1.89179387e-02f, 1.41096869e-02f, -4.79660220e-02f, -3.51198912e-02f,
  -2.32490525e-02f, 6.39551356e-02f, 1.69188704e-03f, -2.02338994e-02f, 8.79571214e-02f, 1.55972159e-02f, -3.55262756e-02f, 9.80468467e-03f, -2.58653387e-02f, 1.32638598e-02f,
  2.50797957e-01f, 9.81981233e-02f, 7.79379159e-02f, 2.07588673e-02f, 4.71117273e-02f, -1.47726284e-02f, 1.32875117e-02f, -3.75362299e-02f, 2.87738144e-02f, 3.49675901e-02f,
  -5.24259247e-02f, -1.09867426e-02f, 6.54997826e-02f, 1.37526467e-02f, 4.22496945e-02f, 3.67353633e-02f, 9.87072848e-03f, 7.88501650e-02f, -1.89873371e-02f, -1.80590227e-02f,
  -1.21524194e-02f, 1.98891442e-02f, 3.65823731e-02f, -9.66613218e-02f, -1.57246664e-02f, 4.39487658e-02f, 2.23617498e-02f, -2.04687752e-03f, 3.59825417e-02f, 4.28501591e-02f,
  1.54967919e-01f, -1.21988282e-01f, -4.26792532e-01f, -7.76895508e-02f, 3.20831060e-01f, 1.68851301e-01f, -1.53918594e-01f, 7.62015581e-02f, -8.95127729e-02f, 1.16659239e-01f,
  1.75976858e-01f, -1.05326332e-01f, -2.05406144e-01f, 3.38311270e-02f, -9.79777053e-02f, -1.89192906e-01f, -5.13870940e-02f, -4.07713167e-02f, -7.86761269e-02f, 3.07138357e-02f,
  -4.32589129e-02f, 2.10880101e-01f, -2.07882002e-01f, 1.92944884e-01f, 2.92948764e-02f, -2.05970854e-02f, 1.86835915e-01f, -5.59113808e-02f, 2.18808532e-01f, 2.28896104e-02f,
  8.48628208e-02f, -1.61020067e-02f, -2.05136240e-02f, -3.38797197e-02f, 8.62405598e-02f, 3.47199515e-02f, 2.12544687e-02f, -5.93303181e-02f, -4.06726189e-02f, 2.26385500e-02f,
  4.94843721e-02f, 7.90190548e-02f, 1.64955035e-02f, -5.20537980e-02f, 5.01850154e-03f, 2.13466734e-02f, 5.71605861e-02f, 1.50507467e-03f, -9.00645852e-02f, 1.62845217e-02f,
  -6.88553080e-02f, 1.17724910e-02f, -6.46077618e-02f, -9.47081205e-03f, -7.89510682e-02f, -1.35586234e-02f, -6.34074733e-02f, -4.81224060e-02f, 5.13860546e-02f, 3.16256434e-02f,
  1.58446413e-02f, -4.93148342e-02f, -1.20061217e-02f, -1.20077459e-02f, 3.23262699e-02f, 5.62358722e-02f, -2.37057265e-02f, 4.38365266e-02f, -2.89740115e-02f, 3.10312640e-02f,
  5.47786951e-02f, 6.74927747e-03f, 2.07747370e-02f, -3.60816084e-02f, -3.26092122e-03f, 1.41598424e-02f, 1.13819605e-02f, 1.65365003e-02f, -4.68127839e-02f, 6.13297429e-03f,
  -6.10717721e-02f, -4.74694837e-03f, 1.00671779e-02f, 4.37844358e-03f, 3.59902857e-03f, -2.83459947e-02f, 1.59338233e-03f, -5.30360080e-02f, 1.87388959e-03f, -2.10078489e-02f,
  1.77713096e-01f, 7.44378641e-02f, -1.44031877e-02f, 4.90878262e-02f, 3.66198574e-03f, 8.03587362e-02f, -6.23493865e-02f, 3.78520675e-02f, 1.49244368e-02f, -3.98783870e-02f,
  1.11901956e-02f, 8.30550306e-03f, 1.03694119e-01f, -2.00290363e-02f, -1.24505693e-02f, 4.00651060e-02f, -2.47933008e-02f, 2.15971321e-02f, 7.55793452e-02f, 6.51205378e-03f,
  3.27933878e-02f, 2.09921058e-02f, 8.58123228e-03f, 1.59194618e-02f, 6.53522015e-02f, 3.69539112e-02f, 1.73512287e-02f, -1.79876368e-02f, 2.56477762e-02f, -1.04366809e-01f,
  1.81925908e-01f, -2.80151427e-01f, 4.38328497e-02f, 1.43778607e-01f, 1.34639323e-01f, 9.48850885e-02f, 1.37204394e-01f, 5.43024875e-02f, 1.70282841e-01f, -2.52488852e-01f,
  -8.22896510e-02f, -2.62899138e-02f, -1.37621179e-01f, 1.33462334e-02f, 1.60658345e-01f, -4.56522666e-02f, -3.48719358e-02f, 1.14238849e-02f, -4.19679433e-02f, -1.49424776e-01f,
  6.79929159e-04f, -5.73007427e-02f, 1.28937429e-02f, -7.26015195e-02f, 4.28259633e-02f, 4.63146204e-03f, 3.02733872e-02f, -3.47331874e-02f, -1.18449278e-01f, 7.21990317e-02f,
  5.76715283e-02f, -3.43509093e-02f, 1.18158404e-02f, -2.66210511e-02f, 1.52176283e-02f, 5.34074232e-02f, -8.49155523e-03f, 4.54868898e-02f, 3.86464555e-04f, 1.36529387e-03f,
  -4.48740795e-02f, 2.67505031e-02f, -6.81921316e-04f, 4.23435792e-02f, -6.14195084e-03f, -6.63623288e-02f, 4.65315580e-02f, 5.41598983e-02f, 3.81349660e-02f, -3.13688628e-02f,
  -1.66747402e-02f, 9.04853940e-02f, -5.25042452e-02f, 1.56172160e-02f, -5.84701896e-02f, 5.52472658e-02f, 5.09278104e-02f, -3.16967554e-02f, 2.85842293e-03f, 2.04117666e-03f,
  3.24038491e-02f, 1.70230065e-02f, -1.87563039e-02f, -1.81910917e-02f, -3.53821777e-02f, 1.72894751e-03f, 4.25043469e-03f, -2.61343494e-02f, 4.44114693e-02f, 8.01195484e-03f,
  5.22261895e-02f, 1.61232091e-02f, 1.72916893e-02f, 1.47408585e-03f, -3.58900353e-02f, 3.05429641e-02f, 7.01715332e-03f, -7.15315118e-02f, 1.61076281e-02f, 1.08806500e-02f,
  8.56242627e-02f, 8.16812217e-02f, 2.63326778e-03f, 3.09700947e-02f, 5.52502237e-02f, 1.08110970e-02f, -2.06365090e-04f, 3.10544688e-02f, 4.70400713e-02f, 5.91132566e-02f,
  -6.03609867e-02f, -1.69246718e-01f, -2.50856094e-02f, -2.51595993e-02f, -8.68960321e-02f, -3.17863151e-02f, -1.52480546e-02f, 6.79223761e-02f, -3.11038122e-02f, -5.37510626e-02f,
  3.02581284e-02f, 3.39353010e-02f, -7.82950968e-03f, 3.82005121e-03f, 9.66365561e-02f, -6.98636100e-02f, -8.47117677e-02f, 6.67228783e-03f, -3.15792337e-02f, -2.66028326e-02f,
  4.73056473e-02f, -6.22139536e-02f, 8.80006701e-02f, -4.78536673e-02f, 3.12198028e-02f, 3.94266509e-02f, -6.86427578e-02f, -5.16260639e-02f, 3.71133126e-02f, -5.12901098e-02f,
  1.68716803e-01f, 4.59668726e-01f, -1.45939514e-01f, 1.41288161e-01f, -3.95067669e-02f, 1.05532221e-01f, 1.33384923e-02f, 3.53872515e-02f, 1.48334369e-01f, 2.66549945e-01f,
  2.25096308e-02f, 6.36071712e-02f, 7.97509775e-02f, 9.33323056e-02f, -1.80081040e-01f, 8.28866586e-02f, 1.91302329e-01f, 1.96994811e-01f, -6.40253797e-02f, 1.80249825e-01f,
  -7.42937475e-02f, 9.96685773e-02f, -2.27431178e-01f, -3.69588286e-02f, -8.87333881e-03f, -5.19273207e-02f, -5.15960157e-02f, -1.65296748e-01f, 5.32327108e-02f, -8.66344050e-02f,
  -1.01731181e-01f, 5.07916883e-02f, -1.02330111e-01f, -7.00238124e-02f, -2.06214841e-02f, 3.60780545e-02f, -4.49828692e-02f, -8.23933333e-02f, -6.96406513e-02f, 2.55805440e-02f,
  -3.02117341e-03f, -6.86803311e-02f, -2.46771630e-02f, 1.01782875e-02f, 1.99126154e-02f, -1.58499759e-02f, 3.87998065e-03f, -4.46133092e-02f, -8.49690009e-03f, -6.28022179e-02f,
  2.99637485e-02f, 3.93299758e-02f, 2.87773646e-02f, -6.60462352e-03f, -2.64006257e-02f, 4.71935757e-02f, -2.80118845e-02f, -7.84642622e-02f, 2.28367690e-02f, 5.90733401e-02f,
  8.40847194e-02f, 6.10129982e-02f, 3.95817310e-03f, -3.21395248e-02f, 2.57493574e-02f, -4.60081100e-02f, 7.17732310e-02f, -4.92675379e-02f, -8.65417905e-03f, -1.25866744e-03f,
  1.96214598e-02f, -1.27459094e-02f, 4.54631597e-02f, -8.80879723e-03f, -1.61195714e-02f, 4.26766369e-03f, -7.89800361e-02f, 7.88060948e-03f, 3.32487412e-02f, -9.40037742e-02f,
  -3.13476138e-02f, 1.02328947e-02f, 1.40251108e-02f, -1.82628538e-02f, 5.54153733e-02f, -6.71632290e-02f, 1.58589073e-02f, 6.05990179e-03f, -3.46032791e-02f, 2.20838541e-04f,
  1.75419793e-01f, 3.79846394e-01f, 6.03685379e-02f, -3.73920389e-02f, 4.70624715e-02f, 7.80382603e-02f, 2.52738949e-02f, 4.14280593e-02f, 7.77062550e-02f, -2.58516092e-02f,
  2.51431875e-02f, -3.54960863e-03f, 4.93932068e-02f, -2.97427941e-02f, 2.92668268e-02f, 6.14784483e-04f, 2.34271679e-02f, -2.37823222e-02f, -2.97619086e-02f, 3.64815034e-02f,
  8.06735530e-02f, -9.32138320e-03f, -7.96621479e-03f, -1.93302315e-02f, 9.47123021e-02f, 1.71679892e-02f, 4.14275527e-02f, -2.94570532e-02f, 4.91075292e-02f, 4.76739258e-02f,
  -1.54510930e-01f, 2.42182672e-01f, 1.31489873e-01f, 6.07200712e-02f, -1.99254572e-01f, -2.02654645e-01f, -2.04180256e-02f, -1.09874606e-01f, -1.98348299e-01f, 2.05745950e-01f,
  2.30084639e-02f, 1.41448900e-01f, 1.22367769e-01f, 1.45939663e-01f, -9.02131796e-02f, 5.77792479e-03f, 6.67173117e-02f, 9.24686864e-02f, -2.63958462e-02f, 1.14918843e-01f,
  1.47104459e-02f, -9.20819417e-02f, 1.24396667e-01f, -5.78977875e-02f, 9.99139175e-02f, 2.58024540e-02f, 1.13143228e-01f, -4.20435891e-02f, 9.43481177e-02f, -7.55309388e-02f,
  -4.94442582e-02f, -1.33038941e-03f, 6.19737469e-02f, 6.13769367e-02f, -1.18270274e-02f, 5.36141694e-02f, -4.12947759e-02f, -4.21811193e-02f, -2.58462764e-02f, 1.42140174e-02f,
  1.60023291e-02f, -2.18068506e-03f, -7.56013766e-02f, -9.87001136e-03f, -9.01242867e-02f, -1.03510655e-02f, -3.78175676e-02f, -5.59644923e-02f, 3.85380648e-02f, -5.90674542e-02f,
  8.60235915e-02f, 7.06833750e-02f, -1.19990390e-02f, 3.70374285e-02f, 1.25573566e-02f, -4.22275402e-02f, 7.24586472e-03f, -9.70932283e-03f, 6.32845750e-03f, 1.10438485e-02f,
  4.74575646e-02f, 2.54883692e-02f, 6.15601661e-03f, -2.19620224e-02f, -3.58128287e-02f, -1.13995280e-02f, -3.03235631e-02f, -1.76312251e-03f, 5.55938892e-02f, 1.81291047e-02f,
  -3.79269980e-02f, 3.05775609e-02f, -8.16325173e-02f, 3.03972084e-02f, -5.11835739e-02f, -5.29891662e-02f, 6.73961965e-03f, -4.32142057e-02f, 4.34572101e-02f, -1.10180154e-02f,
  -2.29466278e-02f, -2.59553026e-02f, -4.09376156e-03f, -6.73501799e-03f, -1.53945582e-02f, -2.01214626e-02f, 7.03985803e-03f, -3.77595425e-02f, -4.34661098e-03f, 1.76617820e-02f,
  3.53274196e-02f, 1.03616156e-01f, -1.01272538e-02f, -7.41326734e-02f, 5.57285137e-02f, -9.65563301e-03f, -1.23027135e-02f, 4.78070565e-02f, 2.61220299e-02f, -2.38513593e-02f,
  -1.14565212e-02f, 9.01608914e-02f, -2.55440902e-02f, 5.16759157e-02f, 8.14763159e-02f, -2.65754145e-02f, 9.28634778e-03f, 5.19738421e-02f, 9.46521852e-03f, 2.14398429e-02f,
  2.06108503e-02f, -1.22708306e-02f, 4.51800115e-02f, -5.60905710e-02f, -4.47083870e-03f, 5.80145232e-02f, -1.20274974e-02f, 2.32316609e-02f, -3.36921290e-02f, -2.86008529e-02f,
  5.82238495e-01f, -8.95285755e-02f, -1.90543197e-02f, 1.70962021e-01f, 3.33947167e-02f, 1.31231666e-01f, 1.92187190e-01f, -6.41176552e-02f, 1.49669975e-01f, -1.74534649e-01f,
  6.34701028e-02f, 2.02243030e-01f, -1.22412527e-03f, 8.05535242e-02f, 3.91135603e-01f, 5.63453250e-02f, 6.03332557e-02f, 6.60225600e-02f, 8.72334614e-02f, -4.85407114e-02f,
  -1.56072835e-02f, 8.33580494e-02f, -1.56091654e-03f, -1.28629476e-01f, -9.24681723e-02f, -1.39988169e-01f, -9.07806903e-02f, -2.49392148e-02f, -1.56669378e-01f, 6.33354038e-02f,
  -1.18895933e-01f, -8.74323323e-02f, -8.91827270e-02f, 3.25989351e-02f, 2.90706586e-02f, 1.33853871e-02f, 4.16360982e-02f, 6.31979257e-02f, 2.38427315e-02f, 3.77212763e-02f,
  1.07239097e-01f, 1.33049851e-02f, 4.42088582e-02f, -1.03397695e-02f, -6.82904851e-03f, 3.99598405e-02f, -3.65246907e-02f, -1.83988959e-02f, -2.21903790e-02f, -7.30341254e-03f,
  -4.19880543e-03f, -5.78141958e-02f, -9.64348298e-03f, 2.10271664e-02f, -5.10713691e-03f, 1.65671911e-02f, 1.48400781e-03f, 4.43722457e-02f, 5.23069724e-02f, 4.87162471e-02f,
  6.26112055e-03f, 3.92252440e-03f, 8.56429525e-03f, -5.07834107e-02f, 7.11620972e-02f, -5.89120984e-02f, 4.89230081e-03f, 1.40365735e-02f, 1.67658199e-02f, -2.47946270e-02f,
  1.11019816e-02f, -6.02346566e-03f, -2.98404787e-02f, 3.25151235e-02f, -2.17422284e-02f, -3.33593637e-02f, 6.30787434e-03f, -6.95683509e-02f, 1.26387654e-02f, 5.07212651e-04f,
  -4.41513807e-02f, 4.11337726e-02f, -3.84658873e-02f, -1.83764547e-02f, 1.98341571e-02f, -1.75177096e-03f, -1.85288731e-02f, -5.16505577e-02f, 1.32366661e-02f, 3.05622276e-02f,
  8.83089676e-02f, 8.21606964e-02f, 2.38242485e-02f, 1.69983283e-02f, -2.93801483e-02f, -5.32601029e-03f, 4.57612760e-02f, 1.66052468e-02f, -2.08059661e-02f, -1.07726501e-02f,
  -3.40339616e-02f, 1.24209989e-02f, 1.89381395e-03f, -1.14276558e-02f, -1.93914510e-02f, 5.74704318e-04f, -1.01041524e-02f, -1.62607133e-02f, 5.97900450e-02f, 1.17981303e-02f,
  -9.79214255e-03f, 4.93709110e-02f, -4.76456108e-03f, 7.01189321e-03f, 1.34142116e-02f, -6.27128989e-04f, 3.32063623e-02f, -1.19460626e-02f, -1.31772943e-02f, -3.13287158e-03f,
  -4.20073986e-01f, -3.93715203e-02f, 3.12261302e-02f, -2.43482947e-01f, -1.43405870e-01f, -1.40108630e-01f, -1.29809737e-01f, -6.83724433e-02f, -1.89944878e-01f, 4.82351594e-02f,
  1.02469534e-01f, -7.71192238e-02f, 1.32264212e-01f, -5.35193346e-02f, -2.32827500e-01f, 1.36720985e-01f, -1.19229890e-01f, 2.96603050e-02f, 1.75974239e-02f, -1.90039471e-01f,
  -5.45218959e-02f, -2.17357457e-01f, 1.53068841e-01f, -1.15013935e-01f, -1.30368173e-01f, -4.13120575e-02f, -2.21372489e-02f, 1.73659865e-02f, -7.69882798e-02f, -2.62823794e-02f,
  -1.17356833e-02f, 2.07522940e-02f, 8.98256227e-02f, 1.20688584e-02f, -2.79738363e-02f, -6.05482608e-03f, -2.14422606e-02f, 8.12662169e-02f, 2.16318965e-02f, 7.90130347e-03f,
  -2.45454162e-02f, -4.54606998e-05f, -5.41135781e-02f, -1.06765823e-04f, -3.97832468e-02f, 3.35069522e-02f, 3.18596489e-04f, 9.73043516e-02f, -1.15549788e-02f, 4.21724357e-02f,
  6.29168525e-02f, 5.77055849e-02f, 3.11802644e-02f, 3.05274930e-02f, 6.55632243e-02f, 2.43985304e-03f, 2.96570901e-02f, 1.79902855e-02f, -1.85200498e-02f, -2.74641439e-02f,
  2.37601101e-02f, -7.21892864e-02f, 1.32840099e-02f, -5.72501458e-02f, 8.28521326e-03f, -4.10564356e-02f, -3.50691564e-02f, 2.63380464e-02f, -3.10324710e-02f, -3.37579772e-02f,
  1.16342185e-02f, -2.29413453e-02f, 2.12030895e-02f, 3.19208093e-02f, -6.74423352e-02f, 1.43627245e-02f, -2.00813487e-02f, -3.15924063e-02f, -3.88049483e-02f, 4.96854745e-02f,
  -4.55899583e-03f, -3.82739417e-02f, 1.33344913e-02f, 1.56703894e-03f, 2.86505409e-02f, -1.53112877e-02f, 4.27117683e-02f, 3.37116495e-02f, 2.43098214e-02f, -7.80749740e-03f,
  -3.59628469e-01f, -3.52537334e-01f, -4.59335558e-02f, -5.77489808e-02f, -5.46706505e-02f, 2.64582094e-02f, -2.45744418e-02f, -3.14227901e-02f, -7.73128942e-02f, -8.42172354e-02f,
  2.25681458e-02f, -5.47989458e-02f, -5.96055239e-02f, -3.62591334e-02f, -2.81151868e-02f, -2.47921795e-02f, -5.97221553e-02f, -1.34862727e-02f, -7.73537308e-02f, -5.47803417e-02f,
  7.85465073e-03f, -4.64627631e-02f, -4.43964042e-02f, -1.31291421e-02f, -4.54729944e-02f, 5.87143600e-02f, -1.22459821e-01f, 4.70184535e-03f, -2.09648777e-02f, -7.56819472e-02f,
  -1.29985929e-01f, -1.32792532e-01f, 6.10542707e-02f, -1.95861116e-01f, 2.77420461e-01f, -9.83761251e-03f, -3.30259204e-02f, 1.18563212e-01f, 2.52459291e-02f, -1.25122204e-01f,
  -3.23641077e-02f, -1.81812178e-02f, -4.82039414e-02f, -4.44962606e-02f, -2.46859655e-01f, -3.02281827e-01f, -1.32360429e-01f, -1.37373358e-01f, 4.09502201e-02f, 2.83183833e-03f,
  -1.10483333e-01f, -4.80261371e-02f, -1.47788212e-01f, 1.55917943e-01f, 1.26773342e-01f, 1.18331335e-01f, -9.91059020e-02f, 1.70221254e-01f, -2.04565050e-03f, -1.38343852e-02f,
  -2.25396417e-02f, 1.59418341e-02f, 4.95527685e-02f, 5.64123802e-02f, 3.38802151e-02f, 7.38617107e-02f, -3.03375954e-03f, 1.31292688e-03f, 2.69050431e-02f, 3.65815721e-02f,
  9.34890565e-03f, 7.17331171e-02f, -3.80893163e-02f, 4.52945903e-02f, 7.35729858e-02f, 8.74288082e-02f, 7.34094903e-02f, 7.13189691e-03f, 1.13548957e-01f, 4.59554000e-03f,
  5.25701456e-02f, -5.39138280e-02f, -1.43189365e-02f, -1.39734879e-01f, -9.50628240e-03f, 5.55377267e-02f, -7.08787367e-02f, -2.29172446e-02f, 5.50386161e-02f, -9.17839259e-03f,
  -2.22174376e-02f, -8.79679341e-03f, 1.27107929e-02f, -2.51965132e-02f, 2.23433413e-02f, 2.20309701e-02f, 4.19613756e-02f, 2.27367575e-03f, 1.97294112e-02f, 5.42973243e-02f,
  -5.18114828e-02f, -7.16622770e-02f, 5.31853363e-03f, 3.66732217e-02f, -3.13817300e-02f, -4.07742448e-02f, 3.57099366e-03f, -3.08430474e-02f, 2.19606943e-02f, 2.57070130e-03f,
  -7.31722936e-02f, -8.22881702e-03f, -1.70354545e-02f, -1.53354760e-02f, 3.38600986e-02f, 6.60262182e-02f, 2.58752760e-02f, -2.27787700e-02f, -9.35484692e-02f, 2.11862791e-02f,
  -1.93116158e-01f, -2.09374741e-01f, 1.41621437e-02f, 4.30384949e-02f, -1.45103540e-02f, -4.67138626e-02f, -3.42354388e-03f, 5.31070083e-02f, 5.46571910e-02f, -2.91507952e-02f,
  3.39589119e-02f, -2.07901243e-02f, 1.02499109e-02f, 4.58998680e-02f, 1.49636632e-02f, -7.31087551e-02f, -1.07503489e-01f, -3.55459005e-02f, -3.36879641e-02f, 5.40527515e-02f,
  1.17436575e-03f, 4.44674864e-02f, 3.21809575e-02f, 7.83127397e-02f, 7.74090178e-03f, -3.59683670e-02f, 2.33837334e-03f, 2.50140429e-02f, 1.80709548e-03f, 2.81349663e-02f,
  3.00391585e-01f, -2.69554675e-01f, -1.72064960e-01f, 1.78625643e-01f, 7.64040425e-02f, 1.47851519e-02f, 2.09406704e-01f, -8.30139220e-02f, 8.16137046e-02f, -3.74784954e-02f,
  1.87042668e-01f, 3.80845442e-02f, 4.19319980e-02f, 2.47241825e-01f, 4.91656423e-01f, 1.54532120e-01f, 3.60342860e-01f, 1.61974609e-01f, 8.39231834e-02f, 5.37787229e-02f,
  1.28344610e-01f, 1.08469456e-01f, 8.32404122e-02f, -1.53380752e-01f, -7.46479258e-02f, -2.19772995e-01f, -7.05407485e-02f, -2.08863139e-01f, 3.31525393e-02f, 6.10906333e-02f,
  4.62739319e-02f, 4.54630591e-02f, -4.77536879e-02f, -1.07350461e-01f, 6.89708209e-03f, -7.71755427e-02f, -6.65984750e-02f, 7.09325890e-04f, 5.68027496e-02f, 2.53161304e-02f,
  -2.36873236e-02f, 6.95747044e-03f, 4.98908535e-02f, -5.11178598e-02f, -3.50742564e-02f, 1.19867884e-02f, 3.15559059e-02f, -2.19462421e-02f, 1.30095463e-02f, 3.24190967e-02f,
  9.92643461e-02f, 2.27206014e-02f, 2.91395728e-02f, 2.32509356e-02f, 3.32398713e-02f, 3.06305420e-02f, 8.58724676e-03f, 6.37677964e-04f, 2.04704832e-02f, 3.20987105e-02f,
  -2.50637941e-02f, 4.17614914e-02f, 4.18212265e-02f, 3.74439619e-02f, -2.61916034e-03f, -7.59281125e-03f, 5.34054749e-02f, 8.46608728e-03f, 5.25684468e-02f, -1.12232752e-02f,
  1.27544056e-03f, -2.49899202e-03f, 1.47649609e-02f, -2.37927632e-03f, 4.24390733e-02f, -4.44660857e-02f, -3.80597226e-02f, 7.89258257e-02f, 1.64958474e-03f, 1.00294258e-02f,
  3.47616114e-02f, -3.33982632e-02f, -2.94390414e-02f, -7.15837255e-03f, -2.92798355e-02f, 2.43193526e-02f, 1.76860280e-02f, -5.33562303e-02f, 1.39018483e-02f, 4.92719980e-03f,
  -1.35985717e-01f, -1.08111516e-01f, 1.59431137e-02f, 1.73058622e-02f, -1.97487492e-02f, 4.79043424e-02f, 4.57478240e-02f, -4.28446494e-02f, -2.06718128e-02f, 1.86175834e-02f,
  -1.74670760e-02f, 1.27598271e-02f, -1.03347048e-01f, 2.45986655e-02f, -2.11604014e-02f, 4.21847180e-02f, 2.46523856e-03f, -1.05245315e-01f, -5.23645058e-02f, 2.79054530e-02f,
  -9.45694074e-02f, 4.60361056e-02f, -1.17552222e-03f, -3.96878347e-02f, 2.35429984e-02f, -4.89628911e-02f, 1.06385127e-02f, -5.03159352e-02f, -5.71844168e-03f, -2.72959359e-02f,
  1.57539815e-01f, 1.76343575e-01f, 2.45245948e-01f, 2.84431309e-01f, -8.36855024e-02f, 1.28790542e-01f, 1.15930669e-01f, 6.10786416e-02f, 3.76919121e-01f, -6.89875428e-03f,
  -1.90099314e-01f, 1.58883721e-01f, -5.30060157e-02f, 1.27358913e-01f, -1.00583941e-01f, 1.76796153e-01f, 6.92511573e-02f, 8.76125246e-02f, 1.68835089e-01f, -2.95206215e-02f,
  1.10673390e-01f, -1.74720228e-01f, 5.78605458e-02f, -2.00840712e-01f, -7.16716722e-02f, -3.39475647e-02f, -3.31826806e-01f, -6.05473667e-02f, -1.14605203e-01f, -1.08966358e-01f,
  3.65923606e-02f, 8.61847550e-02f, 1.39061343e-02f, 5.23747429e-02f, -2.33266745e-02f, 3.02400496e-02f, -1.09921485e-01f, -3.94666977e-02f, 1.09824063e-02f, 6.56925365e-02f,
  1.92326319e-03f, -5.59545355e-03f, 4.24531959e-02f, -1.26607879e-03f, 7.93635994e-02f, 2.75172871e-02f, 2.01113932e-02f, 5.30526266e-02f, 6.04193583e-02f, 3.38639170e-02f,
  1.26414001e-01f, 4.23302986e-02f, -2.24948172e-02f, -4.21611778e-03f, 9.35567729e-03f, -1.95432808e-02f, 6.09841838e-04f, -7.29895458e-02f, 7.76289031e-02f, 1.92160215e-02f,
  -1.39823323e-02f, -7.40383985e-03f, -2.04588380e-02f, -2.50222739e-02f, 1.43737542e-02f, -2.83994433e-03f, -1.13602271e-02f, -7.39660114e-02f, 2.33893897e-02f, 3.42926523e-03f,
  -4.93786018e-03f, 2.59997398e-02f, 2.46330816e-02f, 6.15213159e-03f, 1.45796686e-02f, 1.45405522e-02f, -2.67146546e-02f, -1.61647927e-02f, 3.34910676e-02f, 9.38769057e-03f,
  -1.20354481e-02f, -4.53741784e-04f, -1.05475809e-03f, -1.98268723e-02f, 3.45135108e-02f, 8.92712828e-03f, 1.31368004e-02f, 4.26497571e-02f, 2.22811513e-02f, -2.63050254e-02f,
  -3.61028053e-02f, -8.09845328e-02f, 9.21136979e-03f, -1.41033595e-02f, 4.63825986e-02f, -1.85726099e-02f, 5.33757582e-02f, 3.01287025e-02f, 5.54542057e-04f, -3.23252939e-02f,
  -1.80976652e-02f, -1.07623069e-02f, -6.24070838e-02f, -1.34433117e-02f, -1.27815013e-03f, -4.90732305e-02f, -9.57399490e-04f, -2.12140512e-02f, -7.39455000e-02f, -1.43557284e-02f,
  -8.63020346e-02f, -5.96953668e-02f, -3.18197794e-02f, -1.42872548e-02f, 6.12313952e-03f, -3.91083919e-02f, -3.54201980e-02f, 1.82061046e-02f, -9.06985402e-02f, 3.15862857e-02f,
  4.24625009e-01f, 2.66999137e-02f, 7.55355880e-02f, 2.47888938e-01f, 4.84798811e-02f, -7.26835653e-02f, -1.18693151e-02f, 9.98577029e-02f, 1.33373588e-01f, -2.42601763e-02f,
  -1.17427763e-02f, 8.25131312e-04f, -1.21804602e-01f, 1.49839958e-02f, 8.07582587e-02f, -1.30978763e-01f, 2.10104406e-01f, -2.12566946e-02f, 3.54169542e-03f, 1.29870251e-01f,
  8.78309682e-02f, -5.07974811e-02f, -1.69601478e-02f, -1.03688464e-01f, 1.21251129e-01f, 1.07386418e-01f, 5.84729761e-02f, -1.05656154e-01f, 3.00098769e-02f, -7.38443062e-02f,
  3.94242853e-02f, -8.40935037e-02f, 2.93038990e-02f, -2.11584978e-02f, 2.60939309e-03f, 3.08834780e-02f, 3.36657055e-02f, 9.72286053e-03f, 1.14516658e-03f, -2.70793773e-02f,
  -2.42612641e-02f, -3.68179195e-02f, 1.83261093e-02f, -4.92475182e-02f, 6.34771883e-02f, 2.51843948e-02f, 3.63124274e-02f, 8.25420320e-02f, -3.47368829e-02f, -2.19879393e-02f,
  8.01716652e-03f, -5.17212152e-02f, 6.15515448e-02f, -4.09098230e-02f, 7.77289793e-02f, 2.65482590e-02f, -1.82027239e-02f, -4.14826982e-02f, 2.05921438e-02f, -1.15625514e-02f,
  -1.21354554e-02f, 4.41879332e-02f, 3.45445275e-02f, -6.77851634e-03f, 1.20569682e-02f, -5.27785765e-03f, 1.98013056e-02f, 3.93944187e-03f, -3.29826586e-02f, -2.34401692e-02f,
  2.21345052e-02f, 2.28074417e-02f, 7.43981637e-03f, 1.14060109e-02f, 1.75634380e-02f, 2.51705181e-02f, -1.15519657e-03f, 2.22840914e-04f, 1.61234867e-02f, 4.54962254e-02f,
  -4.45768237e-03f, 2.04531290e-02f, -5.92878088e-03f, 1.05916867e-02f, 6.02808362e-03f, -2.90474687e-02f, 3.87929962e-04f, -2.37118202e-05f, -1.11576291e-02f, 3.06275059e-02f,
  -1.16309576e-01f, 4.64636311e-02f, -1.03721172e-02f, 8.57939385e-03f, -5.45604043e-02f, 4.15793210e-02f, -3.66484374e-02f, 7.91462604e-04f, -5.95552437e-02f, 1.83117725e-02f,
  6.94928393e-02f, 2.37416010e-03f, -2.61769015e-02f, -1.82668082e-02f, -4.24682982e-02f, -7.76468776e-03f, -9.76284384e-04f, 5.76553755e-02f, 7.12201446e-02f, 2.95067206e-03f,
  7.07911104e-02f, 2.66597420e-02f, -1.96992196e-02f, -2.79071578e-03f, -3.76947187e-02f, -1.27689149e-02f, 5.62490597e-02f, 4.49707396e-02f, -2.17416342e-02f, -5.05802371e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.34191373e-01f, 8.05238709e-02f, 9.53257978e-02f, 1.43672794e-01f, 1.86875816e-02f, -5.90657368e-02f, 6.11538664e-02f, -2.81145666e-02f, 2.27058649e-01f, -6.22308291e-02f,
  -1.40518889e-01f, 1.77123010e-01f, -1.49796262e-01f, 1.70996394e-02f, -2.42177591e-01f, -1.77383199e-01f, 7.45052844e-02f, 5.08718612e-03f, 2.96299756e-02f, 9.21802297e-02f,
  6.28625751e-02f, -1.85130119e-01f, -1.76612526e-01f, -1.81112289e-01f, 9.58914831e-02f, 1.72501713e-01f, -9.88770053e-02f, -1.25583842e-01f, 4.29921560e-02f, -3.57471481e-02f,
  -4.25253110e-03f, 8.02817270e-02f, 3.28647420e-02f, 2.86842063e-02f, 3.76923569e-02f, 5.62330224e-02f, 4.53197807e-02f, -7.13655353e-02f, 4.76702601e-02f, 8.88471007e-02f,
  1.75990108e-02f, -5.88556798e-03f, 7.11469054e-02f, 2.10539587e-02f, -3.16660888e-02f, -1.31313568e-02f, 4.67726290e-02f, 1.49633586e-01f, 3.83207798e-02f, 3.60903144e-02f,
  1.57151241e-02f, 8.86065736e-02f, 5.95791265e-03f, 2.13848129e-02f, 2.68875472e-02f, -5.94009086e-03f, 8.67307484e-02f, -5.49803674e-02f, 5.99545203e-02f, 1.62383057e-02f,
  -2.85229664e-02f, 4.24212823e-03f, -3.71565409e-02f, -1.45071028e-02f, 6.55721128e-02f, -5.95898256e-02f, 5.94857670e-02f, 1.26852058e-02f, 1.30979829e-02f, -1.10469619e-03f,
  -8.56758468e-03f, 5.90802096e-02f, 3.22009549e-02f, 9.82041587e-04f, -6.15669182e-03f, -8.66101775e-03f, -1.76934022e-02f, 3.85888331e-02f, 6.24396000e-03f, -2.13606879e-02f,
  -9.21355411e-02f, -6.29144581e-03f, -2.56635845e-02f, -9.16418247e-03f, -5.49343526e-02f, -1.28149427e-02f, -2.28976775e-02f, 3.26033980e-02f, -1.10464944e-02f, -6.98261335e-02f,
  4.95163389e-02f, -1.07523784e-01f, -5.47854267e-02f, -4.55063172e-02f, 2.43308991e-02f, 3.21207307e-02f, 2.97014453e-02f, 1.37278596e-02f, -7.58564025e-02f, 5.22761652e-03f,
  -1.77825626e-03f, 3.26979235e-02f, 6.29830584e-02f, -2.83966176e-02f, -8.74596536e-02f, 8.00846331e-03f, -7.06714019e-03f, -8.43430609e-02f, -3.67309675e-02f, 2.03916002e-02f,
  6.60941154e-02f, -8.18413123e-02f, -1.46701634e-02f, -2.89772693e-02f, 3.36335339e-02f, -3.77620906e-02f, 9.19707045e-02f, 6.78355992e-02f, 1.34375915e-02f, -1.18532255e-02f,
  2.80754976e-02f, -2.78556675e-01f, 2.50994623e-01f, -8.29231143e-02f, 1.38601407e-01f, 1.47755146e-01f, 3.28842610e-01f, -1.68933451e-01f, -2.71329194e-01f, -3.01702291e-01f,
  3.11370566e-02f, 1.46475062e-01f, 2.00971991e-01f, -1.91894665e-01f, 3.71275961e-01f, 8.79956931e-02f, -8.67619738e-02f, 3.97588313e-03f, 5.46632754e-03f, -3.16460207e-02f,
  -5.48398681e-02f, -1.31023303e-01f, 2.12280974e-01f, -1.58373713e-01f, -6.38431683e-02f, -2.09618852e-01f, -2.08722074e-02f, 2.54303515e-01f, -1.34644285e-01f, 5.90149350e-02f,
  -4.46312167e-02f, -1.36831358e-01f, -4.25157771e-02f, 3.21408696e-02f, -2.88433004e-02f, 6.81570843e-02f, 7.56537467e-02f, 1.92815810e-01f, 1.71706546e-02f, -2.86392961e-02f,
  5.70285972e-03f, 3.08773411e-03f, -5.56919798e-02f, -1.02870567e-02f, -6.19585812e-02f, -6.38642013e-02f, -4.03753221e-02f, -1.48819052e-02f, -1.13461623e-02f, 5.26530296e-02f,
  9.84133929e-02f, -2.12169718e-02f, 1.41200889e-02f, -2.85110958e-02f, 8.48152116e-02f, -3.77484295e-03f, 1.89890829e-03f, 6.80991858e-02f, -7.29274994e-04f, -2.69020814e-02f,
  1.13266673e-04f, 7.32189119e-02f, -4.27518040e-02f, -2.63197888e-02f, 7.89190526e-05f, -9.61267352e-02f, 2.81662885e-02f, -1.60887651e-02f, 1.13142598e-02f, 3.74326552e-03f,
  -1.55986724e-02f, 3.56886759e-02f, 7.00660516e-03f, -2.84373406e-02f, -2.65437691e-03f, -5.71457446e-02f, -2.32670386e-03f, -6.52071312e-02f, 4.21881340e-02f, -4.32203636e-02f,
  -3.46643515e-02f, -5.53535484e-03f, 5.98898828e-02f, 1.42284883e-02f, -2.30472907e-02f, 6.44747727e-03f, 1.95302851e-02f, -8.45729411e-02f, -2.77702473e-02f, 2.74049528e-02f,
  -6.06853291e-02f, -2.55063593e-01f, -6.00832291e-02f, -6.72133043e-02f, -5.25203533e-02f, 6.19083643e-03f, -2.39887163e-02f, -4.42602970e-02f, -1.34779699e-02f, -3.64763960e-02f,
  -9.53607820e-03f, 2.86817178e-02f, 2.11551767e-02f, -4.07151915e-02f, 1.85625795e-02f, -1.46330567e-02f, 5.32058924e-02f, -7.62654170e-02f, -3.28628756e-02f, -4.63140132e-05f,
  -4.78329770e-02f, -3.00599951e-02f, 4.18421719e-03f, -5.41393496e-02f, -6.74628094e-02f, 6.40492188e-03f, -2.79140696e-02f, 4.75469530e-02f, 4.84318025e-02f, 6.27368987e-02f,
  -5.83846234e-02f, -1.05857104e-01f, -2.99320996e-01f, -2.01625913e-01f, -9.22190398e-02f, -5.29874384e-01f, -4.96399134e-01f, -1.77944779e-01f, 9.93102416e-02f, -2.06975386e-01f,
  -1.15677081e-01f, 8.47673137e-03f, 1.21818252e-01f, -2.76522249e-01f, 7.64128417e-02f, 1.04994096e-01f, -4.11268950e-01f, -2.38258675e-01f, 1.21981472e-01f, -1.26755327e-01f,
  2.77761044e-03f, -1.39312252e-01f, -7.29620084e-02f, -5.22035100e-02f, -2.10028425e-01f, 1.35959778e-03f, 8.11237618e-02f, 5.99075928e-02f, -2.63190299e-01f, -4.18007374e-02f,
  1.01871602e-02f, 9.96141583e-02f, -9.95539576e-02f, -1.87025927e-02f, -8.64981562e-02f, -7.81634301e-02f, -3.54430862e-02f, 9.40814763e-02f, 3.36071514e-02f, 2.63214298e-03f,
  2.28401255e-02f, 4.48001996e-02f, -2.63797324e-02f, 2.35930346e-02f, -1.56000452e-02f, -3.14478017e-02f, -6.14961330e-03f, -2.51274444e-02f, 1.88767556e-02f, -4.87780012e-02f,
  -3.58685888e-02f, -5.60439080e-02f, -1.32261291e-01f, 1.91099662e-02f, -3.72365229e-02f, -2.87758578e-02f, -2.51305383e-02f, -5.51292254e-03f, -6.54289797e-02f, -6.55556843e-02f,
  -8.33557919e-02f, -1.85449366e-02f, -4.85204458e-02f, -1.14474189e-03f, -2.00005639e-02f, -6.15566736e-03f, -1.51972715e-02f, 3.89291905e-02f, 1.68527178e-02f, 3.76285426e-02f,
  -2.12998837e-02f, 4.05611433e-02f, 8.61245033e-04f, -1.14836678e-01f, -1.61669571e-02f, 5.35755511e-03f, 5.77580594e-02f, 6.19250955e-03f, -8.01824331e-02f, -3.34491581e-02f,
  5.45559600e-02f, -2.43399162e-02f, -2.69883983e-02f, -3.02832462e-02f, 3.05965748e-02f, 8.77317041e-02f, -7.73077980e-02f, 1.55436229e-02f, -4.89116907e-02f, -2.59518623e-03f,
  -1.76080823e-01f, -1.85495794e-01f, -3.90395086e-04f, 1.21318083e-02f, 8.46575946e-02f, -5.59127005e-03f, -1.10258302e-02f, -7.72266909e-02f, -1.58213288e-01f, 4.09327727e-03f,
  -1.18354224e-01f, 2.14733593e-02f, -6.18537515e-02f, 1.14879692e-02f, 7.88611919e-03f, -3.22625302e-02f, -1.97243560e-02f, -3.12422160e-02f, -5.40164262e-02f, -9.05985311e-02f,
  3.85500211e-03f, 1.68996770e-02f, 1.07244283e-01f, -4.02085669e-02f, -4.25094068e-02f, -6.93059415e-02f, 4.17177938e-02f, 7.42768571e-02f, -5.90671338e-02f, -1.47623178e-02f,
  8.11141822e-03f, 2.86198616e-01f, 2.47072265e-01f, 2.78720617e-01f, -2.26938069e-01f, -3.06001008e-01f, -2.27462992e-01f, 2.77965330e-02f, 1.45724744e-01f, -4.48400788e-02f,
  -1.34715185e-01f, 2.91406512e-01f, -1.07949786e-01f, 8.52303952e-02f, 2.70572398e-02f, 2.60822624e-02f, 2.23156111e-03f, 7.07926825e-02f, -3.40381116e-02f, 1.20355673e-01f,
  3.34286578e-02f, -1.06534518e-01f, 1.65339828e-01f, -8.81580636e-02f, -1.22546051e-02f, 1.31562307e-01f, 1.26146927e-01f, 2.19873935e-02f, 1.04117706e-01f, -3.07936426e-02f,
  -2.97298245e-02f, 9.16677937e-02f, 5.71688265e-02f, 5.35685085e-02f, 5.06540500e-02f, -2.84063946e-02f, 7.55167454e-02f, -6.82011843e-02f, -5.46723381e-02f, 5.72878607e-02f,
  3.92626747e-02f, 4.28629778e-02f, 2.51819044e-02f, 1.90895069e-02f, -5.81821203e-02f, 2.06395593e-02f, 2.73812488e-02f, -4.59136115e-03f, 5.50678149e-02f, -5.10364771e-03f,
  3.01615112e-02f, -4.06327732e-02f, -7.00904289e-04f, -9.12308972e-03f, 7.73913562e-02f, 3.46871987e-02f, 2.49277689e-02f, 5.84267043e-02f, 6.37152866e-02f, 2.44142748e-02f,
  -5.15276417e-02f, 4.36926372e-02f, 6.48841485e-02f, -4.08110656e-02f, 5.31168766e-02f, 9.33504030e-02f, 5.00109717e-02f, -3.35016660e-02f, 1.15884490e-01f, -5.75531200e-02f,
  1.84742070e-03f, -2.90448368e-02f, -5.58328778e-02f, -2.09707227e-02f, -4.68497761e-02f, 7.48513862e-02f, -1.11326631e-02f, -8.29355717e-02f, 1.72644053e-02f, 3.37002911e-02f,
  2.03464217e-02f, 2.41215620e-02f, 6.19272217e-02f, 4.02959250e-03f, 1.27992090e-02f, 2.57215686e-02f, 8.87310728e-02f, -4.62680049e-02f, -3.50911319e-02f, -5.23703098e-02f,
  2.35367045e-02f, 2.20531419e-01f, 1.35312211e-02f, -4.02117707e-02f, -5.99048287e-02f, -4.95322496e-02f, 4.03028876e-02f, 2.25855075e-02f, 9.05920193e-02f, -4.46804389e-02f,
  -1.15372445e-02f, -5.48367389e-02f, 6.99713007e-02f, -5.31157479e-02f, -3.82015333e-02f, 5.34366407e-02f, 7.44370818e-02f, 1.89546477e-02f, 4.88778986e-02f, 4.99071330e-02f,
  -2.84195449e-02f, 3.88414562e-02f, -5.70451899e-04f, 2.71189511e-02f, 2.10403954e-03f, 3.01914569e-02f, 5.10303378e-02f, -2.02652998e-02f, -3.51594761e-02f, 9.00198370e-02f,
  -1.15174428e-01f, -1.02454543e-01f, -1.49798347e-02f, 8.94627124e-02f, 8.57225060e-03f, -1.41613407e-03f, -1.29510313e-01f, 5.58842719e-02f, -1.25730783e-01f, 9.58697796e-02f,
  4.08598892e-02f, -2.43317168e-02f, -4.52495255e-02f, 1.12162508e-01f, 3.99928801e-02f, -2.81689204e-02f, 1.53749883e-01f, 7.75768608e-02f, -9.75001883e-03f, -4.44413461e-02f,
  3.07752248e-02f, 1.09227203e-01f, 2.75164265e-02f, 1.13672741e-01f, -1.14376053e-01f, 6.83878660e-02f, 3.16816159e-02f, -1.84333101e-02f, 1.59056380e-01f, 5.59472553e-02f,
  1.08396308e-02f, -3.80862728e-02f, -5.99164777e-02f, 1.00028731e-01f, -2.85842866e-02f, 2.44259797e-02f, -8.93364549e-02f, -2.99843810e-02f, -7.46223629e-02f, -2.30640881e-02f,
  -1.85460951e-02f, -4.86407382e-03f, -8.25082697e-03f, 4.87022623e-02f, -2.56897006e-02f, 3.43930721e-02f, -1.36031304e-03f, -8.19047689e-02f, -1.73530765e-02f, -5.69452196e-02f,
  -4.58971746e-02f, 5.36396243e-02f, -2.96662841e-02f, 2.78583281e-02f, 8.13994855e-02f, -2.68619265e-02f, 1.14493277e-02f, 4.83803637e-02f, -3.84590253e-02f, 7.86217526e-02f,
  -5.85527234e-02f, 4.52106297e-02f, 4.93166149e-02f, 3.59270014e-02f, 5.07549495e-02f, 5.54370740e-03f, 5.70467953e-03f, 2.17254311e-02f, 7.44395889e-03f, 2.39890795e-02f,
  -8.80280286e-02f, 5.46359904e-02f, 4.16656695e-02f, -3.60293500e-02f, 4.04803455e-02f, 3.34341004e-02f, -1.11633490e-04f, 3.19361836e-02f, -1.90132353e-02f, 4.31626514e-02f,
  -2.30918732e-02f, -5.16261235e-02f, 2.04384271e-02f, -8.18595141e-02f, 2.60112919e-02f, -5.61725944e-02f, 2.25822777e-02f, 8.43306351e-03f, 5.63903749e-02f, 4.45884503e-02f,
  -7.40865022e-02f, -1.90706633e-04f, -3.12505327e-02f, 1.71760079e-02f, -8.55753198e-03f, 6.78063110e-02f, 1.12507464e-02f, 4.63522598e-02f, -6.82249898e-03f, -6.11620732e-02f,
  4.34312746e-02f, -1.37824658e-02f, -6.00107685e-02f, 1.47823635e-02f, 5.78236021e-02f, -2.04192158e-02f, 5.57261221e-02f, -3.33410539e-02f, -4.29263450e-02f, -2.87496485e-02f,
  -6.90294504e-02f, -6.94638044e-02f, 9.13499221e-02f, 2.80099194e-02f, 6.22410290e-02f, -7.76601434e-02f, 1.71054844e-02f, -4.28409167e-02f, 8.39873180e-02f, 1.75223015e-02f,
  2.37795532e-01f, 1.99310202e-02f, -2.88890861e-02f, 6.65778220e-02f, 2.26122495e-02f, 8.85885879e-02f, 4.19882983e-02f, -5.57979159e-02f, -4.72040772e-02f, -4.40328233e-02f,
  2.65613161e-02f, -5.44007979e-02f, 2.64890911e-03f, -2.60847099e-02f, 6.17342144e-02f, -3.75819542e-02f, 1.61776811e-01f, 6.66123033e-02f, -3.98876518e-02f, -2.28958838e-02f,
  -6.93739504e-02f, 6.32658005e-02f, -1.20267630e-01f, 9.05128643e-02f, 1.29632190e-01f, 6.88103552e-04f, 3.92989554e-02f, -5.72115630e-02f, 7.74577409e-02f, 1.67518184e-02f,
  4.25158925e-02f, -8.33516493e-02f, 1.03064999e-01f, 3.54597047e-02f, 1.29602030e-02f, -2.07499806e-02f, 7.42987841e-02f, 7.52626639e-03f, -3.54501754e-02f, -3.50445919e-02f,
  -9.79369357e-02f, -7.48438165e-02f, -1.06904007e-01f, 5.09613566e-02f, 1.03077700e-03f, -3.68537381e-02f, -6.09500632e-02f, -1.88886989e-02f, 2.38849651e-02f, -4.96635097e-04f,
  -6.92645460e-02f, -8.62037241e-02f, -1.76442489e-02f, -4.87662405e-02f, 5.61480485e-02f, -9.75969285e-02f, -8.33021030e-02f, -1.08624017e-02f, -4.41966429e-02f, -2.91931201e-02f,
  8.57693329e-02f, 4.33079936e-02f, -4.27162796e-02f, -4.55245562e-02f, -1.87671538e-02f, 1.56645905e-02f, 1.56916007e-02f, -3.15516852e-02f, 1.90995000e-02f, 1.14439465e-01f,
  2.36150380e-02f, 5.11047721e-04f, 6.09716363e-02f, 5.96818589e-02f, -3.25457752e-02f, -1.56376865e-02f, -4.88516316e-02f, -4.53317501e-02f, 2.61596497e-02f, -4.18190435e-02f,
  9.01439190e-02f, 3.35880592e-02f, 3.48926708e-02f, -8.19324516e-03f, 3.44819501e-02f, -6.39257580e-03f, 4.66106944e-02f, -3.25354822e-02f, -1.00515764e-02f, 1.55691532e-02f,
  6.91334307e-02f, 5.71341626e-02f, -4.58199717e-02f, -7.23770559e-02f, -6.26098886e-02f, 1.12608559e-01f, 7.79971154e-03f, 4.42602895e-02f, 6.30110279e-02f, 6.05793484e-02f,
  2.22484320e-02f, -7.07885399e-02f, -1.16005940e-02f, 7.09987208e-02f, 6.20126985e-02f, -5.98009676e-02f, -4.12742570e-02f, 5.46159707e-02f, 2.83099692e-02f, -5.97363561e-02f,
  9.46312845e-02f, 2.48832460e-02f, -5.78767993e-02f, 4.14542034e-02f, 6.49674684e-02f, 5.39518781e-02f, -6.05375506e-03f, -2.92623267e-02f, -4.39324342e-02f, -9.88578517e-03f,
  -2.44728345e-02f, 3.94030847e-03f, -3.58365360e-03f, 2.93103665e-01f, -1.64193496e-01f, -2.29352415e-01f, -2.38742039e-01f, 4.57618944e-03f, -1.58899233e-01f, -1.72177762e-01f,
  4.49234284e-02f, -3.49049196e-02f, -1.03962936e-01f, 1.37436211e-01f, 2.01684326e-01f, -1.33729085e-01f, 4.64558862e-02f, -3.33520048e-03f, -6.18170649e-02f, 1.22323766e-01f,
  1.34378165e-01f, 2.28598729e-01f, 2.81913191e-01f, 2.73866922e-01f, 9.89584774e-02f, 1.98139697e-01f, 3.13171685e-01f, -5.03674895e-03f, 2.56895810e-01f, 1.12382591e-01f,
  -5.77109344e-02f, -3.90891507e-02f, 4.41906415e-02f, 6.85842112e-02f, 6.41744211e-03f, 3.55066545e-02f, -8.89305994e-02f, -1.10423118e-02f, 1.82723403e-02f, 4.66654189e-02f,
  -8.04455057e-02f, 1.44358752e-02f, 6.35732636e-02f, 4.86636572e-02f, -3.70642617e-02f, 5.13954312e-02f, -1.32532343e-02f, 4.05199789e-02f, 6.02697320e-02f, 8.66099435e-04f,
  -1.66237857e-02f, -2.76160650e-02f, -1.98282488e-02f, 3.90616022e-02f, -4.20826720e-03f, -5.61056770e-02f, -3.53191234e-03f, -5.99302724e-02f, -4.83916104e-02f, 2.47156044e-04f,
  3.77582572e-02f, -4.18404192e-02f, -1.14208020e-01f, 2.27091555e-02f, -1.68485790e-02f, 1.02628935e-02f, 7.29547208e-03f, 3.19276489e-02f, -4.02108803e-02f, 4.64977212e-02f,
  3.65660824e-02f, 2.04480835e-04f, -1.38938315e-02f, -7.15616494e-02f, -8.00542310e-02f, -8.65573213e-02f, 5.40592521e-02f, -3.18040065e-02f, -7.91881233e-03f, -2.45074686e-02f,
  -5.25898933e-02f, 6.33683577e-02f, -1.13341995e-02f, 5.90512678e-02f, 3.06726098e-02f, 1.06916735e-02f, 5.94155528e-02f, -2.80479863e-02f, -1.76414512e-02f, -2.10565627e-02f,
  2.92233508e-02f, 1.56863764e-01f, -4.80304733e-02f, -4.24994044e-02f, 3.07560619e-02f, -9.33257788e-02f, 8.52258801e-02f, 4.57709171e-02f, 1.24938749e-01f, -2.42309943e-02f,
  -1.05245663e-02f, 2.19916683e-02f, -5.85667416e-02f, 9.07007158e-02f, 5.33960499e-02f, 7.14351330e-03f, -2.01301295e-02f, -1.68724246e-02f, 2.16935342e-03f, 6.98635280e-02f,
  3.13140564e-02f, -1.32818609e-01f, 6.16380572e-03f, 1.26970410e-02f, -2.98915002e-02f, 5.49757741e-02f, -2.67144404e-02f, 3.68793719e-02f, 2.99963206e-02f, 8.05616453e-02f,
  -4.34711128e-02f, 8.50930214e-02f, 1.15824060e-03f, 3.10215876e-02f, -1.29937083e-01f, -2.05509931e-01f, -1.70374036e-01f, 7.89315719e-03f, 1.34629399e-01f, 1.10056847e-01f,
  -3.94337662e-02f, 2.66129017e-01f, 2.62883604e-02f, -9.82810408e-02f, -1.77120924e-01f, -1.30710036e-01f, -1.40980765e-01f, -9.25256163e-02f, 5.33666536e-02f, -1.70986876e-01f,
  -1.44637376e-01f, -1.83947057e-01f, -1.35849327e-01f, 2.96926145e-02f, -5.34872301e-02f, 1.04144923e-01f, -9.09412503e-02f, -8.61447379e-02f, -2.94850785e-02f, 7.35568926e-02f,
  -5.69710545e-02f, 1.23662561e-01f, 1.00454651e-01f, 4.87257279e-02f, -1.57098889e-01f, 1.59201678e-02f, 5.37663838e-03f, -3.05221584e-02f, 9.64867324e-03f, 1.49384560e-02f,
  -9.95534658e-03f, -4.72240075e-02f, -2.96408497e-03f, -1.16546024e-02f, 8.19170177e-02f, 1.06177658e-01f, -5.59719221e-04f, 2.35855486e-02f, -1.10885995e-02f, -2.96275355e-02f,
  7.99088851e-02f, -3.27336118e-02f, -9.64830145e-02f, 1.63142607e-02f, 9.81868152e-03f, -6.77968422e-03f, -9.77284759e-02f, 7.00068325e-02f, 8.25125072e-03f, -2.43603792e-02f,
  3.54507528e-02f, 1.31585384e-02f, 3.97238284e-02f, 5.72883636e-02f, 2.92637330e-02f, 6.37672544e-02f, 5.55717908e-02f, 4.94631529e-02f, 3.71964425e-02f, -5.59133291e-02f,
  -3.94184776e-02f, -1.41751394e-02f, -5.90086579e-02f, -1.88783556e-02f, -6.65502176e-02f, 1.08182477e-02f, -4.59219590e-02f, -1.69395562e-02f, 7.76054570e-03f, -1.95721947e-02f,
  1.43470429e-03f, -1.35323675e-02f, 8.09117407e-02f, -3.60740982e-02f, 1.15081035e-02f, 1.25939464e-02f, 6.64249584e-02f, -2.79170051e-02f, -7.87652470e-03f, 2.50669569e-03f,
  3.74578242e-03f, 2.84078578e-03f, 1.09573035e-02f, 1.00652009e-01f, -7.08861798e-02f, 2.67431699e-02f, -5.70259653e-02f, 4.53247391e-02f, -1.53300527e-03f, -6.00216985e-02f,
  2.53199693e-02f, 7.97720905e-03f, 2.00953409e-02f, 6.78440258e-02f, 9.36019979e-03f, -1.51545298e-03f, -4.67829928e-02f, 4.35294285e-02f, 4.55142856e-02f, 9.34929401e-02f,
  4.59687710e-02f, 5.69392592e-02f, 3.35212387e-02f, -4.66257334e-02f, -1.21517694e-02f, 9.85677540e-02f, 7.44963586e-02f, 3.00348327e-02f, -4.36071679e-03f, -5.61815128e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.21433844e-02f, 1.40206888e-01f, -1.37936950e-01f, -8.10753088e-03f, -2.63526458e-02f, 5.87130487e-02f, -1.26313537e-01f, 9.52517167e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  4.97040413e-02f, 2.10122481e-01f, -1.87108636e-01f, 5.81567213e-02f, -1.31487086e-01f, 8.15761685e-02f, -2.32612669e-01f, 5.75075671e-02f, -6.35806248e-02f, -2.49942720e-01f,
  8.42550918e-02f, 5.82466424e-02f, -5.23722097e-02f, -4.62141186e-02f, 3.96107912e-01f, 4.53333706e-02f, 1.49779603e-01f, -5.53324856e-02f, 2.23767757e-01f, -2.16007754e-01f,
  -4.32399213e-02f, -1.27605155e-01f, -4.64458883e-01f, -6.46824688e-02f, -1.19392239e-01f, 3.56545113e-02f, 2.50447929e-01f, 5.75086921e-02f, -1.32955819e-01f, 5.82531318e-02f,
  7.54828006e-02f, 3.27934958e-02f, 1.00509785e-01f, 8.49652737e-02f, -3.06201607e-01f, -4.33262512e-02f, -9.86583009e-02f, -1.25250414e-01f, 9.07723680e-02f, 5.18273525e-02f,
  1.90715343e-01f, -5.00575192e-02f, 1.78622790e-02f, 1.19897760e-02f, -8.43691826e-02f, 2.17252318e-03f, 3.47706079e-01f, 1.29860759e-01f, -1.77872688e-01f, -2.59534538e-01f,
  3.05538714e-01f, -2.66810238e-01f, 4.84831072e-02f, 9.02770534e-02f, -2.15785597e-02f, 2.22074881e-01f, 7.46463388e-02f, 1.31151363e-01f, -2.20623091e-01f, -3.33853841e-01f,
  -1.50564183e-02f, 2.45995224e-01f, -7.78979734e-02f, -3.36992532e-01f, 2.41901785e-01f, 3.09880048e-01f, -9.63725597e-02f, -2.09855244e-01f, 2.99752709e-02f, -3.73772122e-02f,
  -5.94673641e-02f, 5.60863987e-02f, 1.98112205e-01f, -3.96260649e-01f, 2.10816383e-01f, 9.29513499e-02f, 1.82466671e-01f, -9.23413485e-02f, 1.39239594e-01f, 1.24201044e-01f,
  -3.42331737e-01f, -1.47226766e-01f, -3.50630254e-01f, 7.50630498e-02f, 4.11255091e-01f, -1.65224701e-01f, -2.36824840e-01f, 1.18004441e-01f, 1.21660799e-01f, 1.26419321e-01f,
  -2.11294219e-01f, -2.17433617e-01f, 6.31504357e-02f, -5.91727644e-02f, -1.49084091e-01f, 1.83715045e-01f, 6.39801554e-04f, 1.00852504e-01f, 9.06524807e-02f, -2.34879777e-02f,
  1.91192478e-01f, 2.87045888e-03f, 6.79802075e-02f, 1.95580363e-01f, -5.93300723e-02f, -3.90467197e-01f, 1.01891764e-01f, -1.22186013e-01f, -3.40344235e-02f, -3.44553679e-01f,
  -2.11666878e-02f, 2.35619247e-02f, -2.76744306e-01f, 1.97699040e-01f, -4.47755665e-01f, 4.12829310e-01f, 1.73704222e-01f, -3.24373841e-01f, -1.95602283e-01f, 9.85573679e-02f,
  -7.68381506e-02f, 6.57700375e-02f, -1.03181817e-01f, 1.04362667e-01f, 2.37747878e-01f, -1.21047564e-01f, 2.33348057e-01f, -5.46940006e-02f, 1.01156905e-02f, 2.38425229e-02f,
  -1.71188727e-01f, 6.95436448e-02f, -2.12037563e-01f, 8.38136896e-02f, -5.22591732e-02f, -1.58738211e-01f, 6.72472492e-02f, 4.03029680e-01f, -4.27148826e-02f, 1.09649144e-01f,
  -5.68936206e-02f, 3.96923095e-01f, 1.14178181e-01f, 1.45423025e-01f, 1.36582702e-01f, -1.14054240e-01f, 4.27145958e-01f, -3.23333353e-01f, -3.31038862e-01f, 3.30676705e-01f,
  -9.58154276e-02f, -1.41986504e-01f, -1.55135304e-01f, -4.25958633e-02f, 4.22694713e-01f, -1.60367057e-01f, -1.38772145e-01f, 1.65692791e-01f, -1.71584919e-01f, 6.53065965e-02f,
  -5.11412024e-02f, -1.36176035e-01f, -1.12536676e-01f, 1.70383882e-02f, 1.11534912e-02f, 1.67982355e-01f, -4.75937687e-02f, -1.35621084e-02f, -9.54393297e-02f, 1.03461526e-01f,
  -1.49027675e-01f, -1.12629399e-01f, -2.35676363e-01f, 2.33207569e-01f, 2.67232750e-02f, -1.84112489e-01f, 4.09803778e-01f, -4.48261760e-02f, 1.69040058e-02f, -1.60815239e-01f,
  -2.07114190e-01f, 1.60869285e-01f, -1.14781238e-01f, -1.32964090e-01f, 8.07886645e-02f, -4.03388768e-01f, 3.69878769e-01f, 1.20374277e-01f, -1.54996589e-01f, -1.19642638e-01f,
  -2.97325440e-02f, -2.29586549e-02f, 1.35401234e-01f, 1.58262163e-01f, -2.64571588e-02f, -8.58625993e-02f, -1.18808873e-01f, -2.34444723e-01f, 6.97278976e-02f, 1.84047088e-01f,
  1.89300507e-01f, 1.94830745e-02f, -3.54526460e-01f, -3.11623588e-02f, 1.85515672e-01f, -3.17600161e-01f, -1.48438126e-01f, 2.14504644e-01f, -1.08871032e-02f, -6.61174357e-02f,
  1.08443104e-01f, -2.28334442e-01f, 1.66915521e-01f, -1.27989829e-01f, 8.83227289e-02f, 2.73240477e-01f, 2.27584496e-01f, -1.41796246e-01f, -2.93039531e-01f, 2.13890702e-01f,
  -2.22160015e-02f, 3.13938968e-02f, 2.38051519e-01f, -4.54893112e-02f, -1.81892470e-01f, -2.81186193e-01f, 1.88831817e-02f, -6.10795766e-02f, -1.87399581e-01f, -1.75518006e-01f,
  1.04118511e-01f, -2.51302153e-01f, -7.97664300e-02f, 1.87856451e-01f, 6.65373355e-02f, -1.65419564e-01f, -1.10210562e-02f, 3.56027842e-01f, -1.11371994e-01f, 2.31444091e-01f,
  -8.63668974e-03f, -1.63081914e-01f, 4.35114443e-01f, -3.70845288e-01f, -3.00182909e-01f, 3.74842405e-01f, 1.32974401e-01f, 3.04820001e-01f, -2.93627948e-01f, -2.12200750e-02f,
  2.23096237e-02f, -3.63607891e-02f, 1.06591552e-01f, 1.54788837e-01f, 4.43621039e-01f, -1.93626225e-01f, -5.19171394e-02f, -2.05815464e-01f, 2.73539722e-01f, 8.36643428e-02f,
  -3.05200890e-02f, -2.02432573e-01f, 9.89203304e-02f, -1.16414446e-02f, 6.53538927e-02f, 1.69115737e-01f, 1.34832010e-01f, -9.07740183e-03f, -2.03769326e-01f, 4.14225869e-02f,
  -4.69882250e-01f, 1.55504541e-02f, -1.94419548e-01f, 8.17429274e-02f, 1.00317456e-01f, 6.51474595e-02f, -2.57506579e-01f, 4.80085332e-03f, -5.71766011e-02f, -9.50660110e-02f,
  -1.38194993e-01f, 5.20589463e-02f, -9.08630788e-02f, 2.91979134e-01f, -1.41358897e-01f, -1.17349759e-01f, 2.27637216e-01f, -1.33219436e-01f, 4.86186147e-02f, 3.04119773e-02f,
  3.77357937e-03f, 1.17422558e-01f, -2.10395642e-02f, -1.27662227e-01f, -1.19317852e-01f, 1.63900241e-01f, -9.09512714e-02f, 2.37709880e-01f, 1.08155094e-01f, 9.34930444e-02f,
  -2.70862505e-03f, 5.52762076e-02f, -3.41815561e-01f, -6.44470449e-04f, 1.67448804e-01f, 9.99705195e-02f, 2.89267767e-02f, 3.06293964e-01f, -1.47703841e-01f, 2.15015143e-01f,
  1.22909658e-01f, -3.47812921e-01f, -1.23992689e-01f, 2.08138883e-01f, 1.82090640e-01f, -1.55317649e-01f, -2.39259332e-01f, -2.36009449e-01f, -1.90102503e-01f, 2.58257449e-01f,
  2.23697405e-02f, 2.45854855e-01f, -3.62056404e-01f, -6.49531037e-02f, -2.63956428e-01f, 1.70435846e-01f, -2.16293171e-01f, -6.64615631e-02f, 3.03787813e-02f, -3.33190262e-01f,
  -1.63017623e-02f, 9.42160338e-02f, -1.38795748e-01f, 2.66155303e-01f, 4.40908760e-01f, -5.08009493e-02f, 4.94429581e-02f, -1.24119990e-01f, -1.02899231e-01f, -7.97313526e-02f,
  2.41139814e-01f, 5.70729077e-02f, -5.21142364e-01f, -2.57405788e-01f, -1.74050391e-01f, -1.37540504e-01f, 1.57093778e-01f, -4.23290998e-01f, 8.52123946e-02f, 1.88407525e-01f,
  7.59843960e-02f, 8.95709731e-03f, -1.49753049e-01f, -1.64580137e-01f, -2.61254102e-01f, 1.96346298e-01f, -5.20641133e-02f, 4.51791473e-02f, -3.98326106e-02f, 1.59595206e-01f,
  1.26678109e-01f, -6.51568845e-02f, -3.65761280e-01f, -5.94572686e-02f, -8.99838656e-03f, 1.55688509e-01f, 7.64566585e-02f, -1.47732422e-01f, 3.16781938e-01f, 2.51345634e-01f,
  1.53137252e-01f, -2.94501930e-01f, -7.01842681e-02f, 1.96793210e-02f, -9.36492905e-02f, 2.62255222e-01f, 8.45717564e-02f, -2.68456519e-01f, -3.34936500e-01f, 1.42207816e-01f,
  1.26907289e-01f, 1.98091753e-02f, 2.70001739e-01f, -2.11638473e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  9.10762772e-02f, -1.02047786e-01f, 8.37763250e-02f, 1.56480476e-01f, -1.25421673e-01f, -3.73274460e-02f, -9.08887237e-02f, -1.59443349e-01f, -1.19743295e-01f, 4.40080911e-02f,
  1.10063113e-01f, -1.22300677e-01f, 4.41539427e-03f, 9.33971107e-02f, -1.72386631e-01f, 2.27476228e-02f, -2.56393570e-02f, 1.77086845e-01f, 1.35659024e-01f, -8.18873793e-02f,
  4.28598635e-02f, -5.10792388e-03f, 9.54712108e-02f, 4.76828078e-03f, -1.61534771e-01f, -4.69516702e-02f, 9.00973603e-02f, -6.84634820e-02f, -1.00363664e-01f, 1.97874121e-02f,
  1.63477123e-01f, 9.57486220e-03f, -5.59145957e-03f, 3.24192017e-01f, -1.11966588e-01f, 8.45737010e-02f, -1.77732930e-01f, 1.39431924e-01f, 1.87867105e-01f, 5.18159866e-02f,
  3.36894616e-02f, -1.56207249e-01f, 1.67850450e-01f, 1.89311206e-01f, 1.32897049e-01f, -1.72534913e-01f, -4.04537804e-02f, 1.92771509e-01f, -4.74722147e-01f, -1.40191307e-02f,
  2.22716853e-01f, 1.02476766e-02f, 4.15400155e-02f, 2.02566415e-01f, -2.70282805e-01f, 2.16647461e-01f, -1.90790191e-01f, 5.13697624e-01f, 1.75381929e-01f, 1.70997642e-02f,
  -8.42003673e-02f, -7.25413114e-03f, 3.63787830e-01f, -1.51431948e-01f, -1.37617126e-01f, -3.68660949e-02f, -1.30777135e-01f, -5.28585054e-02f, -1.74626946e-01f, 1.91836447e-01f,
  1.48483580e-02f, 1.25263080e-01f, 1.90957561e-01f, 1.20748639e-01f, -4.90954183e-02f, 1.76956698e-01f, 1.89048350e-01f, 1.72783688e-01f, 1.66067064e-01f, 1.89203948e-01f,
  -1.75900370e-01f, -1.03772298e-01f, 3.15292180e-01f, -2.55166143e-01f, -1.54319629e-01f, 6.98528215e-02f, 7.59871751e-02f, 9.00145173e-02f, 2.21631099e-02f, 1.42040357e-01f,
  4.31505824e-03f, -1.88756004e-01f, -3.70265469e-02f, -2.40774006e-02f, 1.34183392e-01f, -4.75813821e-02f, -7.64683485e-02f, 2.40611240e-01f, -1.90184504e-01f, 2.21938059e-01f,
  -2.55517401e-02f, 2.39301443e-01f, 6.88371882e-02f, 1.34749770e-01f, 4.33132425e-03f, 5.71520068e-02f, 3.71633172e-01f, 2.57793367e-01f, -1.32063866e-01f, 3.96399498e-01f,
  -1.56435445e-01f, 1.51450843e-01f, -8.36576298e-02f, 6.12550452e-02f, 2.29326710e-01f, 2.36989632e-01f, -6.19912669e-02f, 2.53066450e-01f, -1.42449170e-01f, -2.44331777e-01f,
  -1.75906688e-01f, 5.40285349e-01f, 4.34045821e-01f, -1.50600523e-01f, -3.17697413e-02f, 8.86417329e-02f, -2.17558607e-01f, 4.10705851e-03f, 9.28346589e-02f, -6.35790527e-02f,
  3.01420182e-01f, 6.78410009e-02f, 1.05777055e-01f, 1.00173987e-01f, 1.92918643e-01f, 2.55188137e-01f, 1.90790430e-01f, 1.03500210e-01f, -2.42428020e-01f, 1.71414256e-01f,
  2.45433986e-01f, -1.31058022e-01f, -9.59073603e-02f, 1.42371058e-01f, 2.34237149e-01f, 6.18322007e-02f, 3.26146960e-01f, -1.52307041e-02f, 1.22779690e-01f, 1.28390521e-01f,
  2.26494700e-01f, 2.35387191e-01f, 3.81960213e-01f, 1.44226208e-01f, -2.33132154e-01f, 3.05053562e-01f, -1.65889874e-01f, 5.93382567e-02f, -2.65344292e-01f, 1.69928029e-01f,
  1.23457611e-01f, 1.49138510e-01f, 2.57269472e-01f, 1.86307654e-01f, 1.38962403e-01f, 2.78737634e-01f, 1.75532289e-02f, 1.65964320e-01f, -6.11425340e-02f, 2.51339793e-01f,
  3.08900267e-01f, -8.82721990e-02f, 3.76124308e-03f, -1.81110334e-02f, -1.96967974e-01f, -5.16322404e-02f, 1.11489557e-02f, -2.31338397e-01f, -2.25662664e-01f, 3.21375906e-01f,
  1.73666164e-01f, -2.40844458e-01f, 2.43596628e-01f, -4.26089466e-01f, 2.50046968e-01f, 9.37336087e-02f, 6.18692875e-01f, 1.06584124e-01f, -8.40211511e-02f, -1.58192962e-01f,
  -3.01904202e-01f, 3.63405913e-01f, 1.34569153e-01f, -1.04767531e-02f, -2.96511184e-02f, -2.33665090e-02f, 1.75506070e-01f, -7.81696364e-02f, 2.16861013e-02f, 2.09574718e-02f,
  -5.15006036e-02f, -1.09685980e-01f, -1.15591094e-01f, -9.14997607e-02f, 1.69803128e-01f, -1.36159182e-01f, -1.04640909e-01f, 5.22357039e-02f, 1.69008017e-01f, -8.01011473e-02f,
  5.72372600e-02f, -1.67474806e-01f, 9.21172202e-02f, -5.47773726e-02f, 1.51415318e-01f, 1.20577939e-01f, 1.03661440e-01f, -1.62585169e-01f, -4.89643635e-03f, -1.28103197e-01f,
  3.18781212e-02f, -6.46814033e-02f, 2.95077115e-02f, 2.44273581e-02f, 1.01850875e-01f, 2.89219409e-01f, 1.09842226e-01f, 2.07710952e-01f, 2.15378087e-02f, 2.62186021e-01f,
  -3.86737213e-02f, 9.83441025e-02f, 2.94502378e-01f, 5.26041836e-02f, -9.00836736e-02f, 2.00131878e-01f, -1.73275266e-02f, -1.28615322e-02f, 2.25135759e-01f, 1.76228553e-01f,
  -5.21556847e-02f, -2.59006590e-01f, 1.44077577e-02f, -2.03163877e-01f, 1.20437302e-01f, 3.93339843e-02f, 3.20233181e-02f, 1.76863775e-01f, -8.21516141e-02f, 1.74812585e-01f,
  1.04049891e-01f, -2.33013168e-01f, -1.02423996e-01f, 2.63414383e-02f, -8.43780115e-02f, -1.48165867e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -1.16976164e-01f, 1.33267492e-01f, 2.22987920e-01f, 2.45681480e-01f, 7.98656493e-02f, 3.70598286e-01f, 4.38620560e-02f, 2.41057232e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.92557774e-03f, -3.95471267e-02f, -1.74340025e-01f, -7.61556700e-02f, -2.96295404e-01f, -4.42931578e-02f, -2.78675873e-02f, 3.42281789e-01f, 1.57207735e-02f, -1.50063142e-01f,
  -1.86777502e-01f, 8.33044015e-03f, 3.07993335e-03f, -3.17495465e-02f, -2.71579802e-01f, -1.73592955e-01f, 3.48776393e-02f, 3.28202620e-02f, 4.54476893e-01f, 3.14918071e-01f,
  2.19309896e-01f, 5.03271297e-02f, -2.51699090e-01f, -1.13850676e-01f, 4.30144779e-02f, 3.41199160e-01f, 2.87781864e-01f, 7.17704296e-02f, 3.50309670e-01f, 3.77726704e-02f,
  1.76659852e-01f, 7.53468722e-02f, -2.69890972e-03f, 1.66729853e-01f, -8.66758823e-02f, -7.14518726e-02f, -1.20269179e-01f, 6.48941472e-02f, 2.16961786e-01f, -1.56978980e-01f,
  -1.68708056e-01f, 6.14868887e-02f, 1.72406554e-01f, 2.10634872e-01f, 3.21034431e-01f, 8.34841579e-02f, 1.73628479e-01f, 8.90279785e-02f, 5.00947796e-02f, -7.14620426e-02f,
  1.54411644e-01f, 3.42488974e-01f, -1.14814676e-01f, -4.29737478e-01f, 4.46893424e-01f, 4.65018481e-01f, -6.63439557e-03f, 1.32904977e-01f, 1.36487558e-01f, -1.15695290e-01f,
  -1.26987204e-01f, -4.21267360e-01f, -1.87180594e-01f, 1.30180582e-01f, 1.27815261e-01f, 3.64728682e-02f, -1.42853141e-01f, 1.23098381e-01f, 1.25894500e-02f, -1.22140877e-01f,
  -8.29683095e-02f, 1.60926670e-01f, 4.86745639e-03f, -1.00702338e-01f, -3.66133787e-02f, 3.78679372e-02f, 2.62900621e-01f, 2.35526606e-01f, 3.59060436e-01f, 4.48860586e-01f,
  -1.95837408e-01f, -2.03334004e-01f, 2.11570099e-01f, 3.09868068e-01f, 2.05008924e-01f, -4.22309905e-01f, 3.24631095e-01f, 1.42267793e-01f, -5.86147346e-02f, 3.77449721e-01f,
  1.07093891e-02f, 1.14415593e-01f, -1.87751099e-01f, -4.60506260e-01f, -4.10930924e-02f, -6.09830543e-02f, -8.25226828e-02f, 8.92560035e-02f, 1.32156968e-01f, 1.75522685e-01f,
  2.83555925e-01f, -5.52494936e-02f, -1.25237957e-01f, 5.51118314e-01f, -1.33391127e-01f, -2.54076365e-02f, 2.46452354e-02f, -2.96088587e-02f, -1.81283832e-01f, 1.69625223e-01f,
  -1.35356769e-01f, 1.18269332e-01f, 3.16403396e-02f, -7.13338749e-03f, 1.00851484e-01f, 3.58111382e-01f, 4.66452956e-01f, -7.73382410e-02f, -8.03719684e-02f, 6.23144656e-02f,
  3.29866144e-03f, 1.56909302e-01f, 2.44170532e-01f, 1.26555068e-02f, 4.13279310e-02f, -6.40338361e-01f, -8.03646520e-02f, -1.41623870e-01f, 1.15325198e-01f, -1.87395498e-01f,
  -3.28208894e-01f, -2.39978239e-01f, -3.10356200e-01f, -2.48383522e-01f, -1.74835309e-01f, 4.13751230e-03f, 5.43694161e-02f, -8.96884203e-02f, 8.85555074e-02f, 1.14647418e-01f,
  3.26168656e-01f, -1.41163975e-01f, -4.45496917e-01f, -2.14662552e-01f, 5.22690237e-01f, 3.98836076e-01f, -9.91823301e-02f, 4.28290337e-01f, -2.45072097e-01f, 2.11731538e-01f,
  3.64201486e-01f, 3.11936438e-01f, 1.20700434e-01f, -3.40876579e-02f, 2.50560880e-01f, 2.00006157e-01f, -9.25158933e-02f, -5.65809458e-02f, 9.83455777e-02f, -2.42268503e-01f,
  -1.96279928e-01f, -6.99640717e-03f, -6.06715083e-02f, -1.39680952e-02f, -2.10187107e-01f, -9.61065441e-02f, 1.18735023e-01f, -3.52523208e-01f, 1.30027726e-01f, 8.01245123e-02f,
  -3.63747180e-02f, -8.23360234e-02f, 2.73503631e-01f, 1.71819508e-01f, 2.64024705e-01f, -6.17012419e-02f, 2.61645645e-01f, 4.39381897e-02f, -4.65080708e-01f, -2.41886824e-01f,
  -3.24727267e-01f, 2.69601732e-01f, 3.71052831e-01f, -2.99409240e-01f, 1.33643582e-01f, 9.69994161e-03f, -3.46061625e-02f, 3.57943952e-01f, 1.64027885e-02f, 3.09653338e-02f,
  -7.53873140e-02f, 1.99910417e-01f, -2.10343841e-02f, 6.92837387e-02f, 8.06413963e-02f, 1.63068399e-01f, 2.55386472e-01f, 3.24420959e-01f, 5.21033481e-02f, -2.96290100e-01f,
  2.84370303e-01f, -1.07882112e-01f, -1.13327175e-01f, 4.02671874e-01f, -2.28378564e-01f, -1.80601031e-01f, 2.86107302e-01f, 3.12877178e-01f, -3.21593434e-01f, -1.31731138e-01f,
  1.44288719e-01f, 8.97402018e-02f, -6.63625821e-02f, -6.72816038e-02f, 1.87333524e-01f, -6.63248375e-02f, 4.43873666e-02f, -2.05484629e-01f, 2.66209687e-03f, -3.47420424e-01f,
  -1.90858603e-01f, 2.08288625e-01f, 8.36186260e-02f, -3.66741762e-04f, -2.03173365e-02f, 8.59404877e-02f, -2.78705768e-02f, -1.86992332e-01f, -2.09535897e-01f, 1.17356470e-02f,
  -4.08948287e-02f, 1.42369732e-01f, -1.12903751e-01f, 1.78226531e-02f, -1.20116480e-01f, -2.07778756e-02f, -9.31513011e-02f, -1.86714485e-01f, -5.70191085e-01f, -1.37943000e-01f,
  1.34685025e-01f, 3.15583587e-01f, -2.79512964e-02f, 4.46885347e-01f, 3.54503393e-01f, 1.02499329e-01f, -8.54122639e-02f, 3.72162670e-01f, 1.34919941e-01f, -1.89750433e-01f,
  -2.03560799e-01f, -1.45121172e-01f, 1.72189802e-01f, 1.08577214e-01f, 1.04251102e-01f, -1.07193455e-01f, 2.19863188e-02f, -1.01229638e-01f, -1.33618116e-01f, -2.13012576e-01f,
  -2.59453386e-01f, -1.25435814e-01f, -1.15206227e-01f, 4.67469156e-01f, 1.98185015e-02f, -2.45510593e-01f, 1.67615697e-01f, 5.42206690e-02f, 2.29683205e-01f, 1.77880540e-01f,
  -3.30319814e-02f, -3.22400630e-01f, 5.24450898e-01f, 3.88217956e-01f, -2.27574244e-01f, 3.12094301e-01f, -4.34706658e-02f, -9.49888155e-02f, 2.90105253e-01f, 1.05522394e-01f,
  -1.19466841e-01f, 2.04453673e-02f, 1.16414994e-01f, 2.75227875e-01f, -2.05677643e-01f, -1.70953736e-01f, -1.64992750e-01f, 1.26983389e-01f, -1.60922587e-01f, -1.96386054e-01f,
  1.34038001e-01f, 5.89912571e-02f, 6.57413527e-02f, 7.83250947e-03f, -2.11605698e-01f, -3.62117678e-01f, -2.44292952e-02f, -1.12762466e-01f, 4.14020456e-02f, -1.36286914e-01f,
  2.86866307e-01f, -1.36849135e-01f, 2.07896195e-02f, 3.15484285e-01f, -2.48093843e-01f, 2.89443761e-01f, -2.56246626e-01f, 1.89026799e-02f, 4.28626500e-03f, -9.13783982e-02f,
  -8.55781138e-02f, 1.13900907e-01f, -1.44712955e-01f, 3.53354216e-02f, -2.13843092e-01f, -1.55819625e-01f, -4.42343742e-01f, 3.39733422e-01f, -1.14323460e-02f, -1.44543931e-01f,
  7.15066791e-02f, -1.63950533e-01f, -1.00977033e-01f, -3.98642838e-01f, -2.12488264e-01f, -1.18991639e-02f, 1.75730497e-01f, -2.02360805e-02f, -4.97319773e-02f, -2.49008894e-01f,
  7.57545233e-02f, 1.80283666e-03f, 2.23183170e-01f, -1.61530860e-02f, -1.45799816e-01f, -3.09547931e-01f, 6.27567649e-01f, 5.13712585e-01f, -1.34409919e-01f, 1.10707274e-02f,
  -1.01866208e-01f, 1.61113665e-01f, 4.24426109e-01f, 1.08354837e-01f, -1.35705441e-01f, -2.96164095e-01f, 1.04596205e-01f, 2.19626471e-01f, -1.18334733e-01f, 1.84249625e-01f,
  2.46793721e-02f, 8.61829668e-02f, 9.10334196e-03f, -1.08784698e-01f, 4.34053391e-02f, 6.31190613e-02f, -1.21900640e-01f, -1.32904276e-01f, 1.97384730e-02f, -3.47913504e-01f,
  1.18392650e-02f, 1.54110610e-01f, -1.63950697e-01f, -3.20709914e-01f, 5.51864058e-02f, -2.74006546e-01f, 3.85225236e-01f, -8.75359923e-02f, -1.90229267e-01f, 8.93677026e-02f,
  -3.16894092e-02f, -4.11210060e-01f, -1.01140132e-02f, 1.88644171e-01f, -5.02816029e-02f, -3.98030013e-01f, 1.34763509e-01f, -3.47258672e-02f, -1.04108334e-01f, -6.33512437e-02f,
  1.82170212e-01f, 4.82012182e-01f, 8.59136507e-02f, -1.08005889e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.90142205e-02f, -1.60681661e-02f, 5.85270524e-02f, -3.13723944e-02f, 3.24811637e-02f, 2.24617645e-01f, 6.70148283e-02f, 8.43560174e-02f, -2.15254962e-01f, 5.73141277e-02f,
  -7.33488128e-02f, 1.85741335e-01f, 2.32985601e-01f, -3.08362126e-01f, -2.31163979e-01f, 1.08356513e-01f, -4.64192629e-02f, -5.55997156e-02f, 3.27485889e-01f, 3.39582086e-01f,
  2.72759259e-01f, -3.25187147e-01f, -1.38363123e-01f, 1.58699900e-01f, 1.52562916e-01f, 2.79859722e-01f, -1.47335768e-01f, -2.09580928e-01f, 1.91376749e-02f, -2.57530421e-01f,
  -1.72869280e-01f, -1.18342591e-02f, 2.17586309e-01f, 3.30725551e-01f, -6.98123202e-02f, -2.75294840e-01f, 1.37764394e-01f, 1.77772436e-02f, 3.48916464e-02f, 2.22455800e-01f,
  2.23779127e-01f, 2.77586251e-01f, 1.84063599e-01f, 3.11714292e-01f, -7.35835806e-02f, 4.30077106e-01f, -1.91191837e-01f, -4.88497168e-01f, 4.46806103e-01f, -7.21586570e-02f,
  1.80516183e-01f, 4.36428994e-01f, -1.17621541e-01f, -2.05815524e-01f, -1.03814356e-01f, 1.54060602e-01f, -1.69592619e-01f, -1.05951637e-01f, 3.15214753e-01f, -5.93952388e-02f,
  3.96238863e-01f, -1.49546221e-01f, -3.87341306e-02f, 3.67132366e-01f, 4.55259234e-02f, 2.71524817e-01f, 4.48332652e-02f, 1.19508073e-01f, 1.35011002e-01f, 8.39262083e-02f,
  2.71013305e-02f, 4.91560191e-01f, 2.48035759e-01f, 6.05735965e-02f, 2.15540513e-01f, -9.35038105e-02f, -2.08827958e-01f, -1.98412389e-01f, -3.72635871e-01f, -4.02630657e-01f,
  3.50626022e-01f, 1.60546497e-01f, -3.49554181e-01f, -8.35007150e-03f, 2.96781987e-01f, 4.51836884e-01f, -1.44492581e-01f, -2.19310120e-01f, 8.11481699e-02f, 9.66895968e-02f,
  -9.59227011e-02f, 5.05215347e-01f, -5.35491817e-02f, 2.34953865e-01f, 4.61017080e-02f, 6.62731975e-02f, 2.87216008e-01f, 3.95356834e-01f, 4.00038324e-02f, -6.42730370e-02f,
  2.24663779e-01f, 3.75712931e-01f, 3.06251585e-01f, 7.88401216e-02f, 1.18115440e-01f, 3.15241456e-01f, 1.05443805e-01f, 5.70884764e-01f, -3.68285626e-02f, -3.65195066e-01f,
  -3.00813258e-01f, 3.52687649e-02f, -2.48674706e-01f, -4.80784960e-02f, 4.60938364e-01f, -1.11440487e-01f, 2.06567436e-01f, -2.79120117e-01f, -2.05053568e-01f, 4.34062690e-01f,
  1.82512719e-02f, 1.44999446e-02f, -2.24659503e-01f, -2.71866858e-01f, 5.55946410e-01f, 1.44637041e-02f, 1.35809720e-01f, -3.63680050e-02f, 6.12907531e-03f, 2.01389194e-02f,
  -6.80934414e-02f, -2.01849043e-02f, 7.64369667e-02f, -1.27260044e-01f, 8.13601539e-02f, -8.31664503e-02f, 6.41549751e-02f, -1.39239505e-01f, -2.56275246e-03f, -7.59477317e-02f,
  -7.07015917e-02f, -3.24907638e-02f, 6.11372925e-02f, 1.53510705e-01f, -4.24849316e-02f, -4.27518338e-02f, -5.50717115e-02f, 8.51823315e-02f, 1.41460434e-01f, 1.64741799e-01f,
  1.65959805e-01f, 1.17002606e-01f, -7.82313496e-02f, -1.77423835e-01f, -1.16490297e-01f, -9.21231210e-02f, 1.67033687e-01f, 3.56721506e-02f, 1.51179880e-02f, -1.64048031e-01f,
  6.53545707e-02f, 4.82508019e-02f, 1.61777705e-01f, 1.06741384e-01f, 3.08198780e-01f, -8.32053199e-02f, 6.51826039e-02f, 2.62435615e-01f, 3.91739234e-03f, -1.36170834e-01f,
  2.42907614e-01f, -1.47885084e-01f, -3.28737646e-01f, -4.53412890e-01f, -3.91596764e-01f, 6.76364601e-02f, 1.73834592e-01f, -1.84976216e-02f, -1.33974239e-01f, -6.91033378e-02f,
  4.94514823e-01f, 3.54390204e-01f, -3.84304434e-01f, -1.90586373e-01f, 2.13155802e-02f, 3.77241552e-01f, -7.14088827e-02f, 5.53128958e-01f, -1.82601407e-01f, 5.33355117e-01f,
  -6.67828247e-02f, -1.41596720e-01f, -1.49596795e-01f, -1.88138336e-01f, -1.46073818e-01f, -1.57342002e-01f, 7.90378004e-02f, 9.43774451e-03f, 9.10619199e-02f, 1.29374713e-01f,
  -1.28407300e-01f, 2.51604691e-02f, 3.10144909e-02f, -1.05371028e-01f, 1.04220510e-01f, -1.12489171e-01f, -9.96834859e-02f, -1.15357742e-01f, -1.40252650e-01f, -1.56053960e-01f,
  -4.41515408e-02f, -5.84056228e-02f, 2.11682785e-02f, -8.51227418e-02f, 1.59656346e-01f, -1.11174518e-02f, -1.51549593e-01f, 6.46728277e-02f, 1.20273046e-01f, -2.34053493e-03f,
  1.28338218e-01f, -5.67636527e-02f, -7.80792534e-03f, -9.44938436e-02f, 1.49269179e-01f, 1.17746755e-01f, 2.08633497e-01f, 1.98186845e-01f, 3.08603168e-01f, -9.45661813e-02f,
  3.65982115e-01f, 1.73825979e-01f, 1.16095051e-01f, -1.72346539e-03f, 4.31915641e-01f, 1.76578090e-01f, 3.56144249e-01f, 3.81915182e-01f, 5.95642805e-01f, 1.93058521e-01f,
  -7.24683776e-02f, -2.02817678e-01f, -9.89510864e-02f, -1.77160189e-01f, -3.50110143e-01f, -2.68112957e-01f, 5.44912636e-01f, -2.77943432e-01f, -3.44245508e-02f, 6.72523499e-01f,
  2.04009876e-01f, 5.81790924e-01f, -2.16480389e-01f, -8.48305002e-02f, 8.62761214e-02f, 4.34768289e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.77472204e-01f, 2.31780320e-01f, 8.64855573e-02f, 3.16191316e-01f, 1.69131637e-01f, -3.16591971e-02f, -8.18657037e-03f, 2.89664984e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.12752879e-01f, -3.10135424e-01f, -1.30258992e-01f, 4.08312052e-01f, 7.33632088e-01f, 2.12764710e-01f, 7.32387379e-02f, 2.65172660e-01f, 4.37637299e-01f, 4.11921263e-01f,
  4.31398720e-01f, 5.05675852e-01f, -1.68597847e-01f, -4.05132025e-01f, -5.38904369e-01f, 7.13011026e-02f, -1.19931541e-01f, -1.46687210e-01f, 7.87789002e-02f, 4.69375998e-01f,
  -1.40794009e-01f, -2.07763046e-01f, -6.16906360e-02f, 3.57548669e-02f, -2.58441240e-01f, -3.67491692e-01f, 5.04067898e-01f, 5.69979362e-02f, 4.58573177e-02f, 3.94669473e-01f,
  -5.46787903e-02f, -6.01271272e-01f, 1.99610338e-01f, 7.30103478e-02f, 5.72135985e-01f, 1.44951969e-01f, 1.39493942e-01f, -1.12010561e-01f, -1.67736225e-02f, 4.19148773e-01f,
  -3.13477576e-01f, 5.63140139e-02f, 1.28431126e-01f, -1.49844825e-01f, 8.81549045e-02f, 6.86491847e-01f, 1.35968119e-01f, 1.58708647e-01f, 6.50286615e-01f, 3.61501068e-01f,
  -4.01589513e-01f, 5.96576631e-02f, 8.06074500e-01f, -5.33942759e-01f, 7.62180448e-01f, -5.82540751e-01f, -1.31772235e-01f, 4.84098643e-01f, 1.39202476e-01f, -1.06386587e-01f,
  1.37507483e-01f, -5.68658888e-01f, 4.86636087e-02f, 3.19292665e-01f, 1.64662719e-01f, -3.71383697e-01f, -9.79653835e-01f, -1.12701818e-01f, 3.96509953e-02f, 3.03580575e-02f,
  -1.53598770e-01f, -1.58336908e-01f, 2.86488980e-01f, -1.34057552e-01f, 5.38391955e-02f, -1.27472401e-01f, 2.29809970e-01f, 6.90471411e-01f, 6.00527167e-01f, 4.84942764e-01f,
  -6.65885881e-02f, -3.76243621e-01f, 2.69708157e-01f, -3.90869975e-01f, 3.46762210e-01f, -4.26691294e-01f, -1.03282772e-01f, -4.12670135e-01f, 1.14456944e-01f, 7.88395777e-02f,
  -5.93699396e-01f, -2.95309443e-02f, 2.18496565e-03f, -4.84449536e-01f, -1.31464899e-01f, 7.18992352e-01f, 1.26536936e-01f, -1.03040610e-03f, -6.88422248e-02f, -6.61438286e-01f,
  3.40277225e-01f, -2.61057347e-01f, -2.39741560e-02f, 4.32150587e-02f, -1.71981961e-01f, -4.46978360e-01f, 5.27471602e-01f, -6.61075175e-01f, -6.59019530e-01f, -3.38169724e-01f,
  -5.52484334e-01f, 3.23964328e-01f, -3.47774416e-01f, 3.67672056e-01f, 3.68490577e-01f, -2.31786281e-01f, -4.16623741e-01f, 1.16537786e+00f, 3.00326288e-01f, 1.66569903e-01f,
  1.02333657e-01f, -2.88373291e-01f, 1.98530722e-02f, -6.49086773e-01f, 8.10270384e-03f, 1.46879405e-01f, 2.77053379e-02f, 2.48436630e-01f, 4.68142837e-01f, -1.81228742e-01f,
  -1.02603152e-01f, -1.94834486e-01f, -7.28387058e-01f, 2.84377933e-01f, 3.24352145e-01f, -1.41333908e-01f, -5.84776998e-01f, 4.54790533e-01f, 2.17850745e-01f, -4.74057794e-02f,
  -1.83966145e-01f, -2.21401468e-01f, -1.14528149e-01f, -8.99624348e-01f, -4.86767590e-02f, 2.27141738e-01f, 1.57533884e-01f, -3.25542301e-01f, -5.84155977e-01f, 1.62761822e-01f,
  -4.25551802e-01f, 3.46388340e-01f, 9.55022573e-02f, -5.21833062e-01f, 3.78118247e-01f, -3.11066389e-01f, -6.89652339e-02f, 3.95335048e-01f, -5.48500270e-02f, 1.95009276e-01f,
  -5.49877226e-01f, 3.76203120e-01f, -3.68005246e-01f, 8.41934979e-02f, 3.17817092e-01f, -5.85640445e-02f, -2.23766752e-02f, -1.13169700e-01f, 3.02483082e-01f, -4.61347789e-01f,
  -7.53009617e-02f, 1.82143226e-01f, 3.96083653e-01f, -2.82518566e-01f, -6.27153218e-01f, -5.12369908e-02f, 5.82160234e-01f, -1.63531244e-01f, -3.09992909e-01f, 5.46580374e-01f,
  3.90431225e-01f, -2.29249388e-01f, 5.66319585e-01f, -2.02554539e-01f, -3.57079953e-02f, 7.37740755e-01f, 3.18868101e-01f, 2.50476092e-01f, 5.78395044e-03f, -3.60437413e-03f,
  1.57136142e-01f, -6.58635199e-01f, -1.76022977e-01f, 4.58869010e-01f, 5.70057869e-01f, 3.90017152e-01f, -7.48661160e-01f, 2.52814531e-01f, 3.86630177e-01f, 1.19691372e-01f,
  -9.66454577e-03f, -3.70352238e-01f, -4.60930318e-01f, 5.63954234e-01f, 4.49674517e-01f, -2.77988136e-01f, 4.83305514e-01f, 3.69949639e-01f, -3.24784130e-01f, -2.49761596e-01f,
  3.81259881e-02f, -3.45285296e-01f, -4.18473780e-01f, -4.58721310e-01f, -3.04054767e-01f, 1.23436138e-01f, -1.61432996e-01f, 5.36953866e-01f, -2.21800312e-01f, 9.55591425e-02f,
  8.50342512e-02f, -3.66782129e-01f, -1.43795177e-01f, 1.13432869e-01f, -4.89023775e-02f, -4.11195308e-01f, -2.15067610e-01f, -3.49111021e-01f, 5.10569848e-02f, -1.35979503e-01f,
  9.56266094e-03f, 6.24001920e-02f, -1.35925874e-01f, -1.85580611e-01f, -6.23594284e-01f, -2.72542626e-01f, 2.43997544e-01f, 4.73503396e-02f, -2.77469873e-01f, -1.65513065e-02f,
  8.84511411e-01f, 4.32133824e-01f, -5.28787196e-01f, 2.59712160e-01f, 7.90317595e-01f, 5.48082352e-01f, 4.27113801e-01f, 1.77311629e-01f, -1.14273906e-01f, -3.56716424e-01f,
  5.05929053e-01f, -6.24715447e-01f, -8.94719511e-02f, 5.92105567e-01f, -9.22712982e-02f, -1.98510647e-01f, -1.12985000e-01f, 6.62973523e-02f, 1.16159894e-01f, 1.17634133e-01f,
  -2.78593153e-02f, -7.46923625e-01f, 1.98517129e-01f, -7.75980996e-04f, -1.66416660e-01f, 9.54156592e-02f, -2.49525353e-01f, 1.75040498e-01f, 1.39618680e-01f, 3.50495517e-01f,
  6.35340095e-01f, 6.83490336e-01f, -2.35006303e-01f, -6.44429922e-01f, -5.94222806e-02f, 5.29492438e-01f, -2.62981117e-01f, 1.61850736e-01f, -4.08625811e-01f, -3.16552371e-01f,
  7.71373451e-01f, -2.41338611e-01f, -1.95157439e-01f, 5.67565382e-01f, -7.73634091e-02f, 1.59707442e-01f, -1.12994596e-01f, -5.14066577e-01f, -3.91839236e-01f, 1.77453905e-01f,
  3.34768057e-01f, 2.17011333e-01f, -3.60820740e-02f, -3.07862014e-01f, -2.66968429e-01f, -1.68620408e-01f, 9.49271992e-02f, -4.62328017e-01f, 2.05013588e-01f, 2.51188844e-01f,
  8.22283551e-02f, -1.34380683e-01f, 5.60332358e-01f, 2.97289073e-01f, -2.59863526e-01f, 4.85182792e-01f, -6.91608369e-01f, -2.07346857e-01f, 8.76977965e-02f, -4.79697496e-01f,
  -2.90950507e-01f, 2.34342292e-01f, -2.81303436e-01f, -1.87947527e-01f, 1.64032072e-01f, -5.84217548e-01f, 1.42193422e-01f, 2.18891472e-01f, -1.25298500e-01f, 4.73852187e-01f,
  2.59196401e-01f, 2.13693872e-01f, 5.18498421e-01f, -3.73680711e-01f, -1.75640658e-01f, -2.96731628e-02f, -6.41088262e-02f, -1.63632363e-01f, -2.22991571e-01f, 3.81744653e-01f,
  3.97109628e-01f, 2.16897100e-01f, -6.77573562e-01f, 6.06113553e-01f, 5.25083959e-01f, -4.28474963e-01f, -4.37145382e-01f, 4.71141905e-01f, 1.71499908e-01f, -4.86592770e-01f,
  -4.39927429e-01f, 1.19389325e-01f, -1.08570360e-01f, 4.06884074e-01f, -2.71660462e-02f, -1.07470267e-01f, -6.22423828e-01f, 3.04778397e-01f, 1.54825468e-02f, -7.37632453e-01f,
  1.61128119e-01f, 4.85966235e-01f, 1.23725004e-01f, -2.17639133e-01f, -1.78541943e-01f, -3.28788310e-01f, -2.37762943e-01f, 3.73211920e-01f, -7.65097663e-02f, 3.31350327e-01f,
  -8.21624935e-01f, 4.32400614e-01f, -1.35645881e-01f, -3.03139538e-01f, 3.30265373e-01f, -5.23090482e-01f, -6.23348236e-01f, -5.09125173e-01f, -2.28135720e-01f, -3.16488028e-01f,
  3.45599562e-01f, 6.81724250e-02f, 8.47180337e-02f, -2.33756984e-03f, -4.78481382e-01f, 3.24335515e-01f, -1.30853027e-01f, -2.76526153e-01f, -2.68156707e-01f, 6.60204589e-01f,
  9.74067897e-02f, -1.28602415e-01f, -9.16826203e-02f, -7.21287608e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.58819854e-01f, 1.21479854e-01f, -7.70561025e-02f, 2.43045643e-01f, 9.79873724e-03f, -1.31075323e-01f, 8.01339522e-02f, -2.78137535e-01f, 3.18218768e-02f, -1.18248686e-01f,
  2.76742250e-01f, 3.01960260e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    