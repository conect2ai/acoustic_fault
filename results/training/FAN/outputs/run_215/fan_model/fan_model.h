/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.30817220e-01f, 6.36414960e-02f, -2.08543614e-01f, 1.41297430e-01f, 1.40982106e-01f, 1.19992010e-02f, -1.39060125e-01f, 1.99647099e-01f, -1.68371320e-01f, 1.29979938e-01f,
  1.61686599e-01f, -1.58481181e-01f, -6.30403310e-02f, 1.30389348e-01f, -1.11771256e-01f, -1.71102464e-01f, 1.34158790e-01f, 4.86989617e-02f, -1.06800474e-01f, 1.70909271e-01f,
  4.99594323e-02f, 2.38315880e-01f, -6.44212216e-02f, 1.40389860e-01f, 1.53109759e-01f, 5.14867119e-02f, 2.36728206e-01f, -1.04015701e-01f, 2.39557639e-01f, -4.03902568e-02f,
  -1.14111388e-02f, -1.30919060e-02f, 4.60755918e-03f, 2.43388377e-02f, 8.74608234e-02f, 2.21179109e-02f, -1.14401327e-02f, -1.11080885e-01f, -7.47289136e-02f, 3.87634942e-03f,
  -1.63453799e-02f, -3.19304876e-02f, 3.49252559e-02f, -6.11624047e-02f, 5.12316311e-03f, 4.36958857e-03f, -4.04474512e-02f, 3.01538426e-02f, -3.72946039e-02f, -1.95047595e-02f,
  -8.55697170e-02f, 1.99979395e-02f, -1.29986443e-02f, 2.55150516e-02f, -3.24121788e-02f, -3.23489681e-02f, -8.51111785e-02f, -2.05523744e-02f, 6.06114343e-02f, -1.79241337e-02f,
  3.20914239e-02f, -7.83036873e-02f, -9.83004831e-03f, 4.44266247e-03f, -4.69113654e-03f, 4.10811268e-02f, -2.38073114e-02f, 2.45369654e-02f, -4.87732701e-02f, 4.42859158e-02f,
  1.90832503e-02f, 2.38979459e-02f, -1.58686414e-02f, -5.89690078e-03f, 1.13702482e-02f, -1.38808624e-03f, -1.68424677e-02f, 1.55252563e-02f, -8.52988660e-03f, -8.79568327e-03f,
  -3.95923182e-02f, -1.75566226e-03f, -1.23443790e-02f, 2.36594062e-02f, 3.91332386e-03f, -3.29132602e-02f, 3.02694719e-02f, -1.13836406e-02f, -2.64331438e-02f, 9.08733625e-03f,
  3.68947566e-01f, 1.74140096e-01f, 2.79486831e-02f, -1.40838847e-02f, 5.43236092e-04f, 3.74451242e-02f, -1.88209582e-02f, 2.78809480e-02f, 3.16173583e-02f, 6.93850312e-03f,
  2.12901756e-02f, 3.58066112e-02f, -4.18519154e-02f, 5.43546602e-02f, 1.24856308e-02f, 5.84275201e-02f, -4.12911363e-03f, 4.57904451e-02f, 1.14277422e-01f, 5.05396128e-02f,
  8.20827112e-02f, -1.70425302e-03f, -2.42710188e-02f, 3.64462882e-02f, 7.57918283e-02f, 1.51777454e-02f, 6.51920289e-02f, -5.03202854e-03f, -3.58541613e-04f, 1.17854157e-03f,
  8.05214882e-01f, -1.11560054e-01f, 3.15289088e-02f, 1.79860309e-01f, 2.61085421e-01f, -1.90672383e-01f, 5.99574745e-02f, 1.10819645e-01f, 2.85792917e-01f, -3.21267426e-01f,
  3.06245744e-01f, 4.55588400e-02f, 5.43110557e-02f, 3.66249159e-02f, 5.99519193e-01f, 1.05543748e-01f, 1.96622163e-01f, 5.78223579e-02f, 1.08217053e-01f, 6.14499748e-02f,
  1.46246895e-01f, 1.14596717e-01f, 5.12406938e-02f, 3.79402563e-02f, -3.29511873e-02f, -1.14051081e-01f, -7.32352212e-02f, -7.33688325e-02f, -9.32822376e-02f, 5.50521798e-02f,
  -1.37799000e-02f, 3.92267741e-02f, -5.24115637e-02f, -6.08479157e-02f, -5.76319220e-03f, -6.77337945e-02f, -1.48425046e-02f, 3.87953734e-03f, 6.19629510e-02f, -3.93987517e-04f,
  1.30268047e-02f, 3.87477018e-02f, -8.32234323e-03f, 3.79884802e-02f, -3.79487313e-02f, 7.40503743e-02f, -2.66533326e-02f, 3.22959456e-03f, 3.53305414e-02f, -5.75281754e-02f,
  9.96610150e-03f, -3.94078530e-02f, -4.09858003e-02f, -7.45362118e-02f, -3.82557185e-03f, 1.09737040e-02f, -7.35305101e-02f, 2.67227273e-03f, -9.31557734e-03f, 3.57675478e-02f,
  1.03466902e-02f, -1.52863413e-02f, 1.49750290e-02f, 1.46791898e-02f, 7.02425018e-02f, 1.10928155e-02f, -1.21619636e-02f, 1.68033019e-02f, 6.82160491e-03f, 2.49663871e-02f,
  3.55837941e-02f, 7.05614220e-03f, 6.76748753e-02f, -4.53853905e-02f, -1.11607676e-02f, -8.07926152e-03f, -3.37460544e-03f, 8.42868071e-03f, -1.11997658e-02f, 3.88980247e-02f,
  2.56537050e-02f, 4.37503867e-02f, -5.72417909e-03f, -3.16208228e-02f, 4.97861914e-02f, 1.09738670e-02f, -4.06820700e-03f, -2.13401578e-02f, -7.73390895e-03f, -3.28673609e-02f,
  1.19203173e-01f, 1.21420875e-01f, 5.24266176e-02f, 5.14533482e-02f, -4.64094505e-02f, 3.87061276e-02f, 6.81454735e-03f, 3.02012246e-02f, -3.08113005e-02f, 2.59811822e-02f,
  -6.26590699e-02f, -5.08633703e-02f, -1.57395061e-02f, 1.59597280e-03f, 1.50405709e-02f, -3.54909338e-02f, -4.01932672e-02f, -2.97984481e-02f, -7.05763581e-04f, 3.45226899e-02f,
  -3.47560309e-02f, -6.56669959e-03f, -6.85883779e-03f, 1.71989016e-02f, -6.12062356e-03f, -3.44893783e-02f, 6.20685443e-02f, -2.17635445e-02f, 4.78853518e-03f, -2.79176384e-02f,
  6.32299423e-01f, -3.00452083e-01f, -1.32833347e-01f, 7.90011138e-02f, 1.87567890e-01f, -1.77322984e-01f, -2.67743289e-01f, 5.30746318e-02f, 7.33062774e-02f, -1.94568560e-02f,
  3.69939096e-02f, -1.13484547e-01f, -3.05784464e-01f, -1.58583396e-03f, -2.54860699e-01f, -2.07562476e-01f, -6.55501708e-03f, -2.15835012e-02f, -2.20514368e-02f, 3.25997770e-02f,
  8.57790411e-02f, 3.45696658e-02f, -1.00000277e-01f, 8.60276744e-02f, 1.44233778e-02f, 1.12277374e-01f, 2.00497843e-02f, -3.76935787e-02f, 1.17119633e-01f, -6.53944025e-03f,
  2.36800253e-01f, 1.88880295e-01f, -3.10742371e-02f, -3.14641334e-02f, -7.23312376e-04f, 2.30504069e-02f, -1.77295804e-02f, -4.52494770e-02f, 5.88801056e-02f, -2.34178305e-02f,
  -5.82749583e-02f, 4.18892652e-02f, 2.72996016e-02f, 2.11525999e-04f, 3.59972529e-02f, 5.83588984e-03f, 4.60634194e-02f, 4.95756194e-02f, -6.64978195e-03f, -9.37780458e-03f,
  -6.44731820e-02f, 3.93619016e-02f, 3.02618686e-02f, -3.17266956e-02f, 5.34725783e-04f, -1.00148721e-02f, 3.16031575e-02f, -6.01665340e-02f, 1.74987819e-02f, 5.14759198e-02f,
  1.65854339e-02f, 4.76768129e-02f, -1.47672417e-03f, 3.39964889e-02f, -3.68613154e-02f, 3.85051891e-02f, -3.79839493e-03f, -1.97946150e-02f, 1.64124630e-02f, -7.51270345e-05f,
  5.14853708e-02f, -1.26939882e-02f, 3.45272832e-02f, 7.32211024e-03f, 6.26556277e-02f, 3.85595448e-02f, 3.44441039e-03f, 2.23020781e-02f, -2.21331120e-02f, 1.93468034e-02f,
  2.43935548e-02f, -4.27395217e-02f, -2.75328010e-02f, -3.20252031e-03f, -8.94837268e-03f, -6.85391352e-02f, 1.53115811e-02f, -1.28717264e-02f, -2.79832836e-02f, -5.02777286e-03f,
  -3.30653310e-01f, -1.53464049e-01f, 1.67926017e-03f, 2.22914629e-02f, -1.55989593e-02f, 8.32618680e-03f, -9.47711989e-03f, 1.91161763e-02f, -4.00140993e-02f, -2.80679995e-03f,
  1.12093650e-01f, 5.07972687e-02f, 4.15252186e-02f, 1.49619505e-02f, -4.90634032e-02f, -6.05373411e-03f, -1.62926095e-03f, 8.15305579e-03f, -9.63086635e-03f, -7.72764068e-03f,
  2.86781099e-02f, 5.46729192e-03f, 3.86194028e-02f, 1.41200274e-02f, 1.16967950e-02f, 1.29014878e-02f, -1.18857464e-02f, 2.83576269e-02f, -6.78737136e-03f, -5.24899997e-02f,
  -6.83092952e-01f, -2.75758147e-01f, -2.38854602e-01f, -1.20720990e-01f, -1.41132638e-01f, -2.84062088e-01f, -2.55037367e-01f, -5.63921547e-03f, -3.87512296e-01f, 1.15889721e-01f,
  1.67560369e-01f, -3.21389914e-01f, 1.28996596e-01f, -3.22500505e-02f, -8.02647993e-02f, -1.26953414e-02f, -3.13927839e-03f, -3.03628985e-02f, -8.23122188e-02f, -4.93328273e-02f,
  -1.49055151e-02f, 1.12635270e-01f, 1.74383204e-02f, 1.87157422e-01f, -4.88900207e-02f, -4.25893664e-02f, 1.79542959e-01f, 2.35655252e-02f, 1.13665715e-01f, 2.46229805e-02f,
  -6.06477400e-03f, -5.95142208e-02f, -2.14637127e-02f, 3.15560885e-02f, 1.63966790e-02f, 5.00272401e-02f, -3.94318206e-03f, 1.15330890e-02f, -3.65558104e-03f, -3.49800773e-02f,
  -1.96073484e-02f, 1.25716086e-02f, -1.41014569e-02f, 1.73900351e-02f, -6.56687468e-02f, -1.07152555e-02f, -1.06483116e-03f, -5.48400059e-02f, -7.02171996e-02f, -1.16633996e-02f,
  -2.24980209e-02f, 5.31506613e-02f, -1.87348295e-02f, -2.14718543e-02f, -4.94584255e-02f, 8.20521079e-03f, -2.22197715e-02f, 2.20279079e-02f, -2.25986466e-02f, -2.19229255e-02f,
  2.20358446e-02f, 2.09549423e-02f, 1.29030775e-02f, 4.61641736e-02f, 4.53373138e-03f, 3.46882753e-02f, -8.17911874e-04f, 6.02386445e-02f, -5.34371473e-02f, 2.72674058e-02f,
  -4.55939472e-02f, -1.51999891e-02f, -2.20642029e-03f, -2.28851046e-02f, 3.02347839e-02f, -1.12786070e-02f, -2.38951836e-02f, 5.94067760e-03f, -4.87384647e-02f, 2.34337267e-03f,
  3.51235345e-02f, -3.57933156e-02f, 2.16606967e-02f, 2.18740180e-02f, 3.11148409e-02f, 4.50494746e-03f, 1.45596750e-02f, -3.47597972e-02f, 1.58184231e-03f, 2.34478246e-02f,
  4.38105762e-02f, 4.17138450e-02f, -1.13004856e-02f, -6.38267398e-02f, -3.28607410e-02f, 7.35299487e-04f, -1.29493326e-02f, -4.48144861e-02f, -2.05448009e-02f, 1.56312864e-02f,
  4.82614562e-02f, -9.79719800e-04f, -1.03387292e-02f, 1.91632044e-02f, 6.18491881e-02f, 1.73427770e-03f, 3.15573476e-02f, -6.08838862e-03f, 5.25246337e-02f, 4.33645546e-02f,
  3.48558761e-02f, -5.29386997e-02f, -1.07362373e-02f, 2.36659590e-02f, 2.75371894e-02f, 9.18422733e-03f, -4.19827141e-02f, -5.37562370e-02f, 8.24397504e-02f, -9.19687282e-03f,
  -4.60752755e-01f, 2.74197072e-01f, -1.37822390e-01f, -5.62220067e-02f, -1.66190982e-01f, 9.35925469e-02f, -6.37082458e-02f, 6.97359890e-02f, 7.21268803e-02f, 2.28506222e-01f,
  7.05975220e-02f, -2.04123780e-01f, 1.32982939e-01f, 6.60307109e-02f, -1.76902592e-01f, 1.46590412e-01f, 6.18897453e-02f, -4.94124135e-03f, -2.98967697e-02f, 4.41205949e-02f,
  -1.41772538e-01f, 7.83199295e-02f, -2.74804235e-01f, -9.85145196e-03f, -1.88006043e-01f, -2.23098937e-02f, -8.82374272e-02f, -8.72781351e-02f, -2.95712948e-02f, -1.29331108e-02f,
  -1.68335870e-01f, 1.68469593e-01f, -1.12533338e-01f, 8.56782049e-02f, -5.80796264e-02f, -4.26847575e-04f, -5.63029349e-02f, -4.87789549e-02f, -1.35615850e-02f, -2.35986803e-02f,
  6.54264027e-03f, -1.29126040e-02f, 2.61188541e-02f, -1.56163154e-02f, 2.40756851e-02f, -8.68002921e-02f, -5.70272766e-02f, 4.21899147e-02f, -6.39585704e-02f, -8.38214830e-02f,
  -6.54641241e-02f, -7.73878694e-02f, 9.86487698e-03f, 5.76106533e-02f, -4.68737632e-02f, 8.08806811e-03f, 3.15503702e-02f, -1.06580041e-01f, 1.94566939e-02f, 4.56978865e-02f,
  3.29125077e-02f, -4.29971190e-03f, -3.50637478e-04f, -3.64570953e-02f, 4.54904363e-02f, -1.59223527e-02f, 4.04993370e-02f, -1.87071729e-02f, -8.56839214e-03f, 1.61778443e-02f,
  1.99247971e-02f, -3.87509353e-02f, -2.13144533e-03f, 1.41343346e-03f, 1.02627203e-02f, 2.52839308e-02f, 1.55602721e-03f, 1.11694857e-02f, -3.28403637e-02f, -3.81103307e-02f,
  3.65841426e-02f, -1.26514481e-02f, -1.03405043e-02f, 4.41987161e-03f, 6.92479964e-03f, -9.34685916e-02f, -1.28299790e-02f, -2.97431406e-02f, -8.04205090e-02f, -1.27899908e-02f,
  3.37495714e-01f, 3.70019138e-01f, 4.72446084e-02f, -1.05779178e-01f, 5.66340834e-02f, -1.33206323e-03f, 5.35667948e-02f, 2.50791404e-02f, 8.78447518e-02f, 2.60610078e-02f,
  -5.38261533e-02f, -2.10639201e-02f, 3.98811065e-02f, -1.87510904e-02f, -2.45601814e-02f, 8.76926631e-02f, 3.34615889e-03f, 1.03065958e-02f, 2.72820666e-02f, 1.66257396e-02f,
  -1.06113951e-03f, 6.59972355e-02f, 7.58721959e-03f, -7.42605552e-02f, 3.92721109e-02f, 9.90658905e-03f, 2.95306295e-02f, 3.80069837e-02f, -2.02157069e-02f, -2.42189579e-02f,
  -1.00901999e-01f, -2.36390367e-01f, -3.23980808e-01f, 7.71745518e-02f, 2.98303124e-02f, -3.37400176e-02f, 7.92748481e-02f, -1.12180263e-01f, -1.44169718e-01f, 1.18341245e-01f,
  4.74784784e-02f, -1.90969333e-02f, -2.38134727e-01f, 2.48136982e-01f, 1.26198441e-01f, -5.97989112e-02f, 1.60907775e-01f, 9.02476460e-02f, -1.08130835e-01f, 2.53554657e-02f,
  -3.06878448e-03f, 3.45658809e-01f, -2.42752861e-03f, 1.44228756e-01f, 5.39188460e-03f, -7.93661922e-02f, 1.76444188e-01f, -1.16114818e-01f, 2.16892481e-01f, 1.35287642e-01f,
  1.35109648e-01f, 8.13142862e-03f, -8.82171988e-02f, -4.46153618e-02f, -4.25769761e-02f, -1.96879059e-02f, 8.05015713e-02f, 1.77173633e-02f, -2.60931086e-02f, -5.08025959e-02f,
  -8.20398703e-02f, 4.16788310e-02f, 1.72840129e-03f, -1.47573883e-02f, 9.29852948e-03f, -4.24779207e-02f, -6.78023100e-02f, -3.13050002e-02f, -7.40409736e-03f, -6.30897656e-02f,
  -1.03910960e-01f, -2.37718970e-02f, -2.43482902e-03f, 2.94313431e-02f, -2.11544912e-02f, 1.59754455e-02f, 3.53698172e-02f, -4.25950885e-02f, -2.93868817e-02f, -1.31965848e-02f,
  3.76495495e-02f, 1.79695114e-02f, -1.29583552e-02f, 5.28697148e-02f, -2.90583703e-05f, 4.61961329e-02f, 1.08547751e-02f, 4.04696204e-02f, -1.82365850e-02f, 2.32976507e-02f,
  1.18165445e-02f, 2.74329283e-03f, 1.02191484e-02f, -4.26296704e-02f, -2.22099200e-03f, 3.16563956e-02f, -1.10049546e-02f, 2.57613859e-03f, -5.20715071e-03f, 2.21373024e-03f,
  1.21742068e-02f, 3.81211862e-02f, -3.11267450e-02f, -1.29948966e-02f, 2.79835481e-02f, -3.84642486e-03f, 2.34838035e-02f, -2.90717334e-02f, -2.58755367e-02f, -5.68902604e-02f,
  -6.73353747e-02f, -1.51276052e-01f, 5.89647144e-03f, 5.35983704e-02f, 2.19620783e-02f, 4.03096108e-03f, -1.75512359e-02f, -1.56502649e-02f, 6.16850890e-03f, 2.05660686e-02f,
  3.96854952e-02f, 2.61933934e-02f, 2.49033514e-02f, 7.22045973e-02f, -1.72052868e-02f, 7.12328497e-03f, 9.51880887e-02f, 1.05186049e-02f, 3.34405005e-02f, -3.03719635e-03f,
  4.89224680e-02f, 1.29802069e-02f, -3.66338603e-02f, 1.56854484e-02f, 4.09234017e-02f, -1.75965633e-02f, -3.54915336e-02f, -2.15849672e-02f, 1.37886554e-02f, -1.45561211e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.62366810e-02f, -1.94523972e-03f, -6.18422866e-01f, -1.47908345e-01f, -2.62609690e-01f, -5.30848145e-01f, -4.53313798e-01f, -2.80470252e-01f, 1.62540436e-01f, 1.76262006e-01f,
  -3.82923260e-02f, 1.81945339e-01f, 3.42443138e-01f, -1.97184235e-01f, 1.86807066e-01f, 4.75048423e-01f, -2.19598114e-01f, -9.84832179e-03f, 8.46657753e-02f, -1.58438116e-01f,
  2.28610355e-02f, -1.67348310e-01f, -1.05630822e-01f, -2.01874956e-01f, -3.72243732e-01f, -1.06644139e-01f, 1.37850046e-01f, -2.56205440e-01f, -2.97773182e-01f, -1.23895653e-01f,
  1.28939496e-02f, 6.47165552e-02f, -2.61149049e-01f, 1.27167314e-01f, -3.03845406e-02f, -1.09806262e-01f, -1.16790280e-01f, -2.15545688e-02f, 4.09702361e-02f, 3.77667695e-02f,
  1.10692650e-01f, 6.43728450e-02f, -4.81172204e-02f, 4.13969792e-02f, -9.54034179e-02f, -6.72313944e-02f, 3.42839994e-02f, -4.78339419e-02f, -2.84079276e-02f, 3.85119319e-02f,
  -1.06593080e-01f, -5.60850166e-02f, -1.10937215e-01f, 3.25971330e-03f, -5.13092168e-02f, -2.54837722e-02f, 8.66746530e-02f, 2.43508653e-03f, 1.17563168e-02f, -1.98442349e-03f,
  4.26599048e-02f, 3.87828276e-02f, 7.34621063e-02f, -8.93175974e-03f, -2.71492600e-02f, -4.92486171e-02f, 2.30189934e-02f, -7.42309615e-02f, 2.35894434e-02f, -2.15723496e-02f,
  -3.70563827e-02f, 4.13187593e-02f, 1.25734024e-02f, 4.52896655e-02f, 6.97163045e-02f, 3.12616676e-02f, 3.81472846e-03f, 3.45467553e-02f, -8.76083598e-02f, 3.59779187e-02f,
  9.60295796e-02f, -5.75866997e-02f, -3.37402150e-02f, -1.11727407e-02f, -1.76918786e-02f, 5.29810563e-02f, -2.66229790e-02f, 3.35637964e-02f, 1.66169330e-02f, 2.79283021e-02f,
  -3.53489839e-03f, -8.61577541e-02f, -2.31451541e-02f, -2.90411133e-02f, -4.67269570e-02f, -3.08564119e-02f, -3.48485708e-02f, -8.15740079e-02f, -5.27406149e-02f, -4.91816886e-02f,
  2.17800438e-02f, 2.38197763e-02f, -3.22928168e-02f, -3.68396677e-02f, 1.04003297e-02f, 2.24984586e-02f, 4.86480854e-02f, 8.99612457e-02f, -1.56811054e-03f, -2.39660889e-02f,
  5.41061834e-02f, 6.35225102e-02f, 1.17553547e-01f, -3.87789798e-03f, 7.46292109e-03f, -8.24467931e-03f, -1.51907979e-02f, -4.07507606e-02f, -9.49598290e-03f, 3.36669758e-02f,
  -5.21555126e-01f, 1.76475286e-01f, -7.71278366e-02f, -4.04674411e-01f, 1.14323489e-01f, -4.73688781e-01f, -2.79465675e-01f, 1.02913477e-01f, 1.20850809e-01f, -2.99817119e-02f,
  -6.03525788e-02f, -1.13022044e-01f, 2.24068061e-01f, -3.36164623e-01f, -4.87781823e-01f, -2.16868985e-02f, -5.61549067e-01f, -2.63486534e-01f, 1.49177551e-01f, -1.76143244e-01f,
  -1.72911763e-01f, -1.09095253e-01f, -1.53587833e-01f, 2.90879458e-01f, -3.75132486e-02f, 1.04301222e-01f, -8.13663453e-02f, 2.88567573e-01f, -2.41129786e-01f, 1.38398893e-02f,
  1.04412682e-01f, 3.57045799e-01f, 7.25007355e-02f, 1.17470630e-01f, -1.18197143e-01f, -1.16349787e-01f, -1.09254315e-01f, 6.51796609e-02f, -2.33564042e-02f, -1.13541251e-02f,
  -6.33018762e-02f, 2.56164242e-02f, -5.94508089e-02f, 1.20405801e-01f, 4.00917716e-02f, 6.01988025e-02f, -4.15554829e-03f, 2.50014034e-03f, 1.20237924e-01f, -2.01210123e-03f,
  3.89956944e-02f, -8.41361657e-02f, -1.57016680e-01f, -1.05312049e-01f, -1.19692190e-02f, 4.02945131e-02f, -6.05780669e-02f, 1.18131079e-02f, -5.91530576e-02f, -6.46957681e-02f,
  -8.00665021e-02f, -1.73941366e-02f, -6.17839731e-02f, 4.47867662e-02f, -5.69993369e-02f, 7.32023939e-02f, -1.01018082e-02f, -1.55382343e-02f, 1.61004290e-02f, -9.77615733e-03f,
  -8.85557830e-02f, 3.28027122e-02f, 3.94195057e-02f, -1.14982270e-01f, -7.44302794e-02f, 2.81010997e-02f, -1.07340077e-02f, 6.13441691e-02f, -2.58753803e-02f, -1.11001981e-02f,
  5.55453449e-02f, -5.62608801e-02f, 3.26158553e-02f, -2.45095380e-02f, 2.66226884e-02f, 2.68989261e-02f, 3.60231777e-03f, -1.43626994e-02f, 1.25260996e-02f, -8.81957263e-02f,
  -2.00794458e-01f, -2.05199465e-01f, 2.07929704e-02f, 7.90251270e-02f, 3.84553196e-03f, -6.98275268e-02f, -2.83017922e-02f, -2.01164968e-02f, -7.37423971e-02f, 9.69589781e-03f,
  -1.02145486e-01f, -3.50218974e-02f, -1.03197008e-01f, -7.77140586e-03f, -2.51823012e-02f, -6.09201975e-02f, -6.39370829e-02f, -6.64848881e-03f, -1.31804749e-01f, -1.11406520e-02f,
  -7.01169372e-02f, 2.35337578e-02f, -4.09815125e-02f, 2.61196326e-02f, -3.20182182e-02f, -9.34290364e-02f, -3.83503884e-02f, -7.56734284e-03f, -7.67953843e-02f, 6.74649980e-03f,
  -2.09506035e-01f, 4.29648995e-01f, 8.07141438e-02f, -5.34506328e-02f, -1.72075853e-01f, -5.21860383e-02f, -6.40415698e-02f, -9.16156843e-02f, -5.37686609e-02f, 2.22947761e-01f,
  -4.96621653e-02f, 3.55901450e-01f, -1.17373638e-01f, 9.66713727e-02f, -3.95488948e-01f, -9.02780369e-02f, 3.85649987e-02f, 1.53215438e-01f, 4.17085364e-02f, 5.68296202e-02f,
  -4.35009785e-02f, -1.81089178e-01f, -3.38972881e-02f, -1.02575339e-01f, -1.69908460e-02f, 1.66700467e-01f, -1.74162298e-01f, -1.13151819e-01f, 1.88411474e-01f, -1.40760943e-01f,
  2.05350325e-01f, -1.20468494e-02f, 1.66614000e-02f, 4.73824441e-02f, 1.12842284e-02f, -6.45071194e-02f, 1.04796685e-01f, -9.17735547e-02f, 6.33074343e-03f, 3.52138728e-02f,
  6.77323788e-02f, -8.79647862e-03f, 2.94215754e-02f, -7.53974319e-02f, 1.22628724e-02f, 1.16192922e-01f, 1.80745088e-02f, -5.11440309e-03f, 1.28938898e-01f, 1.93280149e-02f,
  1.11805923e-01f, 6.59782439e-02f, 1.30456658e-02f, 6.82651484e-03f, 5.89040015e-03f, 1.05472161e-02f, 4.16620634e-02f, -2.06413940e-02f, 1.28760204e-01f, -6.13989159e-02f,
  -9.15566012e-02f, -5.33629097e-02f, -2.34319940e-02f, -7.83163309e-03f, -5.65949604e-02f, -6.42056548e-05f, -6.23546541e-02f, -3.59579958e-02f, -2.62908638e-02f, 7.38012884e-03f,
  -1.63552482e-02f, -2.77386084e-02f, -6.84019178e-02f, 6.46477640e-02f, -3.74329910e-02f, 5.29976077e-02f, -4.72218767e-02f, 1.26280943e-02f, -4.78962250e-02f, -9.92429629e-03f,
  -1.40437651e-02f, -5.86469797e-03f, -5.01588173e-02f, 2.30412334e-02f, 5.84058613e-02f, -6.61850944e-02f, 4.50701546e-03f, -1.59536880e-02f, 2.59862971e-02f, -1.14851251e-01f,
  1.26232840e-02f, -1.45981848e-01f, 4.08625007e-02f, 2.12019309e-02f, -1.94967519e-02f, 1.29678566e-03f, -3.88678275e-02f, -1.62494520e-03f, 3.47442776e-02f, -1.03553850e-02f,
  6.16026931e-02f, -5.81147373e-02f, -2.63122320e-02f, 2.04830542e-02f, -4.87206802e-02f, -9.65280086e-03f, -4.76552919e-02f, 1.86023917e-02f, -5.07621765e-02f, -4.42026556e-02f,
  4.44707461e-02f, -4.74390527e-03f, 4.89949025e-02f, 4.66451645e-02f, -1.57974083e-02f, -3.23351845e-02f, 2.18672957e-02f, 3.96716893e-02f, 2.11816933e-03f, 9.38492119e-02f,
  5.52126467e-02f, 4.51003432e-01f, 2.76454300e-01f, 3.43385905e-01f, -2.74117947e-01f, -2.22048685e-01f, -8.01165178e-02f, 6.76851720e-02f, 1.95226997e-01f, 4.72177565e-02f,
  -1.05338797e-01f, 2.40386978e-01f, 9.18391645e-02f, 1.99727900e-02f, 3.79241593e-02f, 6.23933598e-02f, 1.43953487e-01f, -8.03916657e-04f, 4.53635156e-02f, 2.11579457e-01f,
  1.61598191e-01f, -1.82445645e-02f, 1.27082437e-01f, 7.37726409e-03f, -6.31069690e-02f, 2.23832563e-01f, 1.72518834e-01f, 3.66121009e-02f, 3.20577547e-02f, -3.26052494e-02f,
  -2.84430593e-01f, 2.56309286e-02f, 2.09487751e-02f, 5.64355887e-02f, -1.52752260e-02f, -1.47167025e-02f, -5.54251997e-03f, -8.50781798e-02f, -1.12427019e-01f, -2.94891745e-02f,
  -2.54960489e-02f, -2.98586525e-02f, -3.96114960e-02f, 3.51441205e-02f, 1.38411974e-03f, -4.79980670e-02f, 2.85884589e-02f, -6.53361976e-02f, 1.03799561e-02f, -2.22180858e-02f,
  5.16970158e-02f, -4.90476117e-02f, 2.77607478e-02f, 6.45501316e-02f, 3.52949016e-02f, 2.39340048e-02f, -6.10305835e-03f, -1.65534448e-02f, -2.17269138e-02f, -2.04343293e-02f,
  -7.61930794e-02f, -1.45258727e-02f, -7.08065554e-02f, -7.99404383e-02f, -3.24953049e-02f, -4.90203826e-03f, -2.13519800e-02f, 1.62147004e-02f, 1.37293001e-03f, 4.26288433e-02f,
  6.30556326e-03f, -1.40529359e-02f, -3.95525992e-02f, -3.49383876e-02f, 6.55870512e-03f, -2.30917521e-02f, -3.74683142e-02f, -1.22311572e-02f, 9.52638835e-02f, 7.09517207e-03f,
  5.93279395e-03f, 4.25049942e-03f, 1.43876122e-02f, -1.92722622e-02f, -5.06650731e-02f, -1.11650592e-02f, -3.33094993e-03f, 7.63073843e-03f, -3.38575654e-02f, 7.05553172e-03f,
  2.12740809e-01f, 5.96159637e-01f, 9.86028761e-02f, -7.18506202e-02f, -6.54974906e-03f, -9.72923785e-02f, 3.03129666e-02f, 6.82382211e-02f, 1.97692290e-01f, 7.50320554e-02f,
  -5.44786733e-03f, 1.03035150e-02f, -3.23768817e-02f, -1.02760438e-02f, 2.53058467e-02f, 4.58694436e-02f, 9.15130228e-02f, 6.39637113e-02f, 7.15808421e-02f, 3.74479741e-02f,
  4.61840704e-02f, -5.79507649e-02f, -4.64088991e-02f, -2.66894174e-04f, 4.50972021e-02f, -2.84468010e-03f, -2.07014494e-02f, 4.29545939e-02f, 3.13966796e-02f, 7.03306198e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -7.78346136e-03f, 4.90381569e-01f, 2.95643806e-01f, 6.28300756e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.02739483e-02f, -1.30753070e-01f, -9.73106325e-02f, 2.28827521e-01f, -1.42536774e-01f, -2.27746174e-01f, -1.34882852e-01f, 3.19603413e-01f, 5.58017790e-01f, -6.14082575e-01f,
  -9.62407351e-01f, -3.01516615e-02f, -1.79716751e-01f, -4.16579247e-01f, -1.95362091e-01f, -7.33009204e-02f, 1.05862312e-01f, -3.54007751e-01f, -8.24764669e-02f, -9.19704080e-01f,
  -9.18768274e-05f, 2.86587626e-01f, 4.11472321e-01f, -4.08866554e-01f, 7.62712836e-01f, -6.39868062e-03f, -8.21245760e-02f, -6.06779158e-01f, -3.80230188e-01f, 2.11823761e-01f,
  1.99900508e-01f, 5.26412547e-01f, 5.28123379e-01f, 3.09666693e-01f, -2.54342824e-01f, -1.83802247e-01f, 1.06060788e-01f, -3.85282964e-01f, -5.17754078e-01f, -3.44348252e-01f,
  -5.15510142e-01f, -2.31648371e-01f, 6.32296920e-01f, 1.14524379e-01f, 1.76298007e-01f, 2.02260092e-01f, 3.88092309e-01f, -2.91845918e-01f, 6.68197930e-01f, -2.91870147e-01f,
  -2.74468064e-01f, -4.78943586e-01f, -9.35437232e-02f, -1.01872876e-01f, 1.77656546e-01f, -6.46580517e-01f, 6.89444721e-01f, 4.38847035e-01f, -2.11675018e-02f, -1.52333066e-01f,
  -2.61667877e-01f, 4.26606417e-01f, 3.89087826e-01f, -1.90051287e-01f, -4.14031059e-01f, -4.58329678e-01f, -2.44805619e-01f, -2.12626249e-01f, -6.87264279e-02f, 5.90391532e-02f,
  6.18344307e-01f, 5.99594414e-01f, 4.21685487e-01f, -2.17490792e-02f, 3.33423495e-01f, 4.34552222e-01f, 3.80441606e-01f, -1.61947653e-01f, -3.77308249e-01f, 2.70358235e-01f,
  -2.48581469e-01f, 1.75162897e-01f, -2.10701022e-02f, 1.43434912e-01f, -2.49741703e-01f, 7.77893841e-01f, -6.41859651e-01f, 6.42781436e-01f, -7.69648850e-01f, -3.85239869e-02f,
  2.78287321e-01f, 9.75151211e-02f, 3.62182468e-01f, 2.75207818e-01f, -2.91934222e-01f, 2.40922466e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.87697870e-02f, 4.03733879e-01f, 1.73926786e-01f, -1.11042880e-01f, -1.63802393e-02f, 8.20401758e-02f, -1.45760641e-01f, 6.61554754e-01f, -3.57072562e-01f, -3.64036888e-01f,
  7.44199455e-01f, 2.01794162e-01f, 1.22539687e+00f, 1.45947739e-01f, 1.30878583e-01f, 4.42251153e-02f, -1.09141752e-01f, -5.63157499e-02f, 3.75850081e-01f, 6.90928221e-01f,
  5.37873566e-01f, 6.35317504e-01f, 7.82724082e-01f, -4.67338979e-01f, -3.59581828e-01f, 1.17782223e+00f, 7.28766739e-01f, 3.60512257e-01f, 1.34283245e-01f, 4.82661217e-01f,
  3.02178949e-01f, 2.31399134e-01f, 2.47440442e-01f, -6.23176359e-02f, 5.47978818e-01f, -1.19259939e-01f, 2.89150596e-01f, 8.61189485e-01f, -8.06290686e-01f, -2.81710535e-01f,
  5.55686295e-01f, -3.17619056e-01f, -9.07742977e-01f, -7.97755957e-01f, -4.28745672e-02f, 1.39293790e+00f, -8.43026564e-02f, -5.96571207e-01f, 3.46334487e-01f, 7.76794434e-01f,
  7.15712368e-01f, 5.82410581e-02f, 5.83264768e-01f, 3.89974207e-01f, -8.26943457e-01f, 1.59948349e-01f, -4.33225483e-01f, -9.99055266e-01f, -4.24412638e-01f, -1.01636612e+00f,
  -6.84640184e-02f, -2.08076894e-01f, 4.79212731e-01f, 5.81470668e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.19608718e-01f, 6.90047801e-01f, 5.49357533e-01f, 4.65657055e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.64946389e-01f, -1.82908341e-01f, -4.34856057e-01f, 6.74271941e-01f, 2.28292525e-01f, 1.58243820e-01f, -5.46832621e-01f, -6.77725911e-01f, 1.23478508e+00f, 6.50830686e-01f,
  -6.11275554e-01f, 6.84698105e-01f, 3.89712483e-01f, 8.40134263e-01f, -8.00063848e-01f, -8.38286579e-01f, 7.62199521e-01f, -3.85984361e-01f, 1.24876821e+00f, 9.78335552e-03f,
  -3.76932845e-02f, 6.62459195e-01f, -5.66471815e-01f, -9.80267167e-01f, -4.46392447e-01f, -7.42983639e-01f, 5.32885909e-01f, 3.38339835e-01f, 4.60289836e-01f, 6.68401599e-01f,
  -8.55332434e-01f, -8.13148797e-01f, 2.98329085e-01f, 4.69709992e-01f, 5.10898054e-01f, 6.65861011e-01f, 1.00697565e+00f, 3.33683714e-02f, 1.36690271e+00f, -3.53295982e-01f,
  -6.88915670e-01f, 5.52353740e-01f, 1.49456680e-01f, -1.38781881e+00f, -5.28951645e-01f, -5.14679886e-02f, -5.40206015e-01f, -7.65756667e-01f, -8.89762998e-01f, -1.87761746e-02f,
  -4.19782102e-01f, -7.71631539e-01f, -4.61498469e-01f, -2.44100496e-01f, 6.42386228e-02f, 4.23970759e-01f, 3.20459872e-01f, 3.34305435e-01f, -2.72463888e-01f, 5.57938635e-01f,
  -1.69029310e-01f, 2.02762485e-01f, 9.93737817e-01f, -5.52599072e-01f, 5.65645918e-02f, 4.09347266e-01f, -2.60373205e-01f, 1.07487953e+00f, -9.65144217e-01f, 1.49640590e-01f,
  -9.31804538e-01f, -5.41912317e-01f, 8.30874264e-01f, 1.34462208e-01f, -4.97371763e-01f, 2.19099820e-01f, -4.77735490e-01f, 1.17192701e-01f, 7.10298300e-01f, 3.35119218e-01f,
  6.40372396e-01f, 4.61925745e-01f, -1.35397732e-01f, -2.45217904e-01f, 1.75547883e-01f, -3.38526964e-01f, -4.71440673e-01f, -4.89269257e-01f, 8.73306036e-01f, -6.40804052e-01f,
  -4.05366898e-01f, 7.26038992e-01f, 8.07574272e-01f, -5.92648387e-01f, -9.57153380e-01f, 8.88281286e-01f, -1.30386561e-01f, 7.00234771e-01f, 4.30469185e-01f, 4.04257536e-01f,
  4.98521537e-01f, 8.63290787e-01f, 1.08606219e+00f, 9.47953939e-01f, -4.99401987e-01f, 2.33608469e-01f, -7.97015522e-03f, 6.31238967e-02f, -1.74299315e-01f, -9.19161141e-01f,
  9.63042915e-01f, 2.33052984e-01f, -1.85550023e-02f, -7.06601620e-01f, -5.15446782e-01f, -5.59252620e-01f, -9.49196443e-02f, -5.78379154e-01f, -8.11519697e-02f, -2.03895524e-01f,
  3.76576364e-01f, -1.09721906e-01f, 3.17723006e-01f, -9.89958048e-02f, 1.10876501e+00f, -1.82067618e-01f, 2.66698718e-01f, -3.88895214e-01f, 2.78990299e-01f, 3.82984281e-01f,
  -1.01003504e+00f, 2.54924260e-02f, -2.18966082e-01f, 1.12054147e-01f, -3.90713841e-01f, 9.42176640e-01f, -1.07483065e+00f, -8.81959558e-01f, 9.01556253e-01f, 5.93873143e-01f,
  -5.62204346e-02f, 7.88569689e-01f, -4.59236145e-01f, 9.51494724e-02f, 2.48660266e-01f, -3.82496417e-01f, 5.11961758e-01f, -5.00743151e-01f, -2.21350074e-01f, -3.70655596e-01f,
  1.07261312e+00f, -8.39261889e-01f, -5.31957150e-01f, -7.39875972e-01f, -4.00100917e-01f, 5.31375825e-01f, -2.63871346e-02f, -8.12321067e-01f, 3.55883390e-01f, 7.72211552e-01f,
  -2.78294235e-01f, -1.55037060e-01f, 3.52057874e-01f, -4.18812513e-01f, 3.91850471e-02f, 3.37388158e-01f, -9.42802370e-01f, 8.34414601e-01f, -6.72617555e-01f, 1.03998232e+00f,
  -1.66011557e-01f, -8.37244928e-01f, -5.42343438e-01f, 9.22128141e-01f, 2.26190001e-01f, -5.56559324e-01f, 6.46731913e-01f, -6.31989717e-01f, 2.39379138e-01f, -1.91995487e-01f,
  -5.93229473e-01f, 3.80711704e-02f, -4.64494079e-02f, 1.09691322e+00f, 6.75849855e-01f, 9.73689198e-01f, -8.62050727e-02f, -1.10165930e+00f, -2.36410856e-01f, -3.69747877e-01f,
  5.29461026e-01f, 1.00958765e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.68112516e-01f, 2.23898083e-01f, 5.28103709e-01f, -4.13826257e-01f, 4.58371453e-02f, 8.12868625e-02f, -2.11157531e-01f, -3.71273220e-01f, -5.48313968e-02f, -4.27969582e-02f,
  -2.45666102e-01f, -3.46458286e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    