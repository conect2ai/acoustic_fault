/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.75676656e-01f, 5.40481746e-01f, 4.57980372e-02f, 2.40261048e-01f, -2.97078788e-01f, -1.14597656e-01f, -5.56771569e-02f, 1.49608999e-01f, 9.50280875e-02f, 3.09392095e-01f,
  -1.41652143e-02f, 1.07061110e-01f, 1.42950028e-01f, 3.78060073e-01f, -3.55953187e-01f, 2.84830868e-01f, 5.24588712e-02f, 7.97281936e-02f, 7.65812844e-02f, -2.28435267e-02f,
  -7.52509534e-02f, 1.19814910e-01f, 4.87634428e-02f, 1.18946461e-02f, 1.00533932e-01f, -8.90170634e-02f, -1.83856994e-01f, -7.64476657e-02f, 4.68739532e-02f, -2.59927083e-02f,
  1.01462103e-01f, 1.80267259e-01f, 2.57941168e-02f, 9.05995723e-03f, -9.45195928e-02f, -1.02228723e-01f, -6.57819584e-02f, -4.31961603e-02f, -3.73122655e-02f, 7.05732079e-03f,
  2.29246654e-02f, -2.52004135e-02f, 7.66243339e-02f, 1.38900569e-02f, 1.64441671e-03f, 1.52630899e-02f, 5.89328147e-02f, 9.02303010e-02f, 1.11975469e-01f, 1.62032098e-02f,
  -9.89630073e-03f, 2.68288460e-02f, -1.90835819e-02f, 4.67841625e-02f, -1.12303011e-01f, -3.59183922e-03f, -3.96227501e-02f, -1.29865378e-01f, 8.29135925e-02f, -1.17117420e-01f,
  -6.88982606e-02f, -2.62723584e-02f, 1.64808463e-02f, 9.29630399e-02f, 4.50263433e-02f, 2.63079461e-02f, 8.31733197e-02f, 1.28940446e-02f, -3.19613293e-02f, 4.27180752e-02f,
  -2.64561623e-02f, 7.39488155e-02f, 8.38310048e-02f, -4.67769131e-02f, -1.75767615e-02f, 5.33061512e-02f, -2.25782692e-02f, -5.48126101e-02f, -4.96941581e-02f, 2.83607561e-02f,
  4.36792448e-02f, -3.30604985e-03f, 1.13224853e-02f, -2.58525275e-02f, 7.28919506e-02f, -5.96189350e-02f, 1.64311193e-02f, -1.63972136e-02f, -5.09164855e-02f, -6.53790459e-02f,
  -2.90932190e-02f, -2.47194637e-02f, 5.49903587e-02f, -1.33638345e-02f, 1.01234876e-01f, 2.98393611e-02f, 7.77190849e-02f, 5.82166761e-02f, 2.21505598e-03f, -2.60885358e-02f,
  -1.64774328e-01f, -2.53724698e-02f, 5.05166361e-03f, -2.92444825e-02f, -2.26508570e-03f, -2.47029625e-02f, -3.97675075e-02f, -8.62994120e-02f, -3.34246494e-02f, -3.28719616e-02f,
  -2.64930651e-02f, -1.15186527e-01f, -1.11203548e-02f, -1.67021919e-02f, 6.81291744e-02f, -9.45221186e-02f, -6.07484467e-02f, -1.98227596e-02f, 2.88111065e-02f, 9.28123668e-02f,
  6.87857568e-01f, -3.84921849e-01f, -2.50690520e-01f, 3.43416542e-01f, 1.05529875e-01f, -2.76952863e-01f, -4.59942557e-02f, -1.29399933e-02f, 3.80443692e-01f, -2.40719751e-01f,
  -4.87417392e-02f, 4.51994501e-02f, -1.05073690e-01f, 6.26886263e-02f, 2.38487437e-01f, 8.88312683e-02f, 7.66601861e-02f, 2.14646608e-02f, 8.49260911e-02f, -3.57181057e-02f,
  7.09894523e-02f, 4.73739021e-02f, -1.60837561e-01f, -1.24883831e-01f, -4.81998585e-02f, -2.75191218e-02f, -1.38407513e-01f, -1.37484401e-01f, -4.57513444e-02f, -7.64111662e-03f,
  -6.92375377e-02f, 6.93960860e-02f, 4.00501825e-02f, -2.94603892e-02f, -3.59054245e-02f, -1.18646361e-02f, -6.72757719e-03f, 4.49560508e-02f, 7.87649453e-02f, 3.54342274e-02f,
  -4.28415602e-03f, -4.08518352e-02f, 7.07459226e-02f, 7.62552395e-02f, 7.36621618e-02f, 3.89371999e-02f, -3.11527494e-02f, -1.87414773e-02f, -2.93183234e-02f, -1.05581181e-02f,
  -1.57246478e-02f, -2.58300882e-02f, -1.42452326e-02f, 1.24861365e-02f, 2.40952950e-02f, 1.56277127e-03f, -1.70941092e-02f, -3.78822945e-02f, 1.43411653e-02f, 3.31834257e-02f,
  2.81701963e-02f, 5.03209569e-02f, 3.93730402e-02f, 4.72666603e-03f, 5.43400086e-02f, 4.45185825e-02f, 9.54421684e-02f, -5.67312576e-02f, 6.31809533e-02f, -5.72559461e-02f,
  3.47721688e-02f, 4.92962450e-02f, -4.03008331e-03f, 2.62403637e-02f, 3.28895412e-02f, 1.69375129e-02f, 2.55282735e-03f, -1.24902017e-01f, 2.68748291e-02f, -3.55755538e-02f,
  -2.36832723e-02f, -3.28957513e-02f, -1.39918244e-02f, -1.42686116e-02f, -3.25917676e-02f, 2.85854586e-03f, -2.66706031e-02f, -4.73092012e-02f, -2.55506001e-02f, 3.06595974e-02f,
  -1.99863851e-01f, -2.75052994e-01f, -1.83047466e-02f, 7.13345548e-03f, -1.59784697e-03f, -3.60828564e-02f, 8.41076486e-03f, -2.09081732e-02f, 1.92202115e-03f, -1.85959935e-02f,
  -2.33481955e-02f, 5.80207892e-02f, -9.32475477e-02f, 1.76930730e-03f, -2.53838170e-02f, -8.90187845e-02f, -1.82931940e-03f, -1.06524210e-02f, 1.86002720e-02f, -2.06545331e-02f,
  -4.09130864e-02f, -1.94492843e-03f, 9.77795199e-02f, 7.56742852e-03f, -3.63162048e-02f, -8.02402422e-02f, -8.01649839e-02f, 8.81452262e-02f, -8.31387192e-03f, 1.18275257e-02f,
  -4.67044860e-01f, -4.12337333e-01f, -4.84120362e-02f, -2.05470949e-01f, -3.05747315e-02f, 2.13570148e-02f, 5.17890267e-02f, -2.84225792e-01f, -1.96945101e-01f, -8.41439813e-02f,
  3.26789543e-02f, -2.82682955e-01f, 4.75456230e-02f, -7.84090720e-03f, 3.57439309e-01f, 2.99228102e-01f, 1.68702170e-01f, -1.79719720e-02f, -7.49536753e-02f, -1.79499671e-01f,
  9.56080258e-02f, 1.17771722e-01f, 2.85784781e-01f, 3.74056622e-02f, -9.24612433e-02f, -1.82115227e-01f, 1.02039941e-01f, 4.94594425e-02f, -5.45184128e-02f, 8.81470516e-02f,
  -2.34628581e-02f, -1.77754551e-01f, -7.55937621e-02f, 8.60129148e-02f, 1.06497876e-01f, 3.80452126e-02f, 5.14899231e-02f, 6.02011085e-02f, 1.93232149e-02f, -2.46435236e-02f,
  1.04418341e-02f, -3.31855640e-02f, -1.16755767e-02f, 5.57715446e-02f, -5.98535687e-02f, -5.20005077e-02f, -6.96968362e-02f, -2.11741216e-02f, -1.13756008e-01f, 1.20038437e-02f,
  1.87076498e-02f, 7.89953303e-03f, 2.73933969e-02f, 5.88923916e-02f, -4.64189090e-02f, -6.93146959e-02f, 3.87917347e-02f, 1.29331462e-02f, -6.15992136e-02f, -6.87604398e-02f,
  1.18700631e-01f, -1.21289501e-02f, 9.47334990e-03f, -2.85326205e-02f, 2.65830685e-03f, 8.11862946e-02f, 6.95217922e-02f, 6.82649314e-02f, -9.13357726e-05f, -3.30607854e-02f,
  -1.33039644e-02f, -1.22356147e-01f, -1.51703153e-02f, 1.54242134e-02f, 2.49081496e-02f, 4.05201688e-02f, 3.51622552e-02f, -3.91686857e-02f, 2.11774446e-02f, -5.32791689e-02f,
  -3.57081145e-02f, -1.85182635e-02f, -1.07295942e-02f, 1.07260160e-02f, 7.35711912e-03f, -3.26638259e-02f, -9.48206335e-02f, 1.57269295e-02f, 4.92866561e-02f, 3.08962818e-02f,
  -1.92688882e-01f, -2.05188304e-01f, 4.43444960e-03f, -5.91979176e-02f, -4.24034800e-03f, 1.85316242e-02f, -1.44061930e-02f, -2.62463111e-02f, -1.52647225e-02f, 6.07483760e-02f,
  2.87895964e-04f, 2.88098995e-02f, 1.05746253e-03f, -4.72966991e-02f, 6.31302893e-02f, -2.54245810e-02f, 4.79298234e-02f, 3.00524905e-02f, 3.76060717e-02f, -3.02065220e-02f,
  2.59343088e-02f, 9.03414190e-02f, 6.73936456e-02f, 3.08463313e-02f, 7.20659494e-02f, 2.63364594e-02f, -3.65715809e-02f, -2.23479867e-02f, 6.57470673e-02f, 7.96093605e-03f,
  -3.31772566e-01f, 1.36101946e-01f, 2.18075380e-01f, -8.09345990e-02f, -7.06558526e-02f, 3.83533120e-01f, 1.78299502e-01f, 1.63390040e-02f, 2.40399361e-01f, -8.73935316e-03f,
  6.75250916e-03f, -3.93901378e-01f, 1.42860323e-01f, 7.12123588e-02f, -2.39620777e-03f, 3.82379860e-01f, 1.98112190e-01f, 1.14008524e-02f, 1.75926208e-01f, -1.06894210e-01f,
  1.02708578e-01f, -1.76682353e-01f, 4.90541682e-02f, -1.23487219e-01f, -1.14645742e-01f, -8.08691904e-02f, -2.73281842e-01f, -1.62724033e-02f, -1.24414399e-01f, -1.17679529e-01f,
  -3.83688286e-02f, -1.02832869e-01f, -3.73018999e-03f, 4.79919761e-02f, -1.71451382e-02f, 5.50309010e-02f, -2.75225844e-02f, -4.33819406e-02f, -1.49147736e-03f, -1.50546164e-03f,
  -2.58147996e-02f, -7.63989463e-02f, -7.40184858e-02f, -2.52385595e-04f, 6.05514459e-02f, -4.46741506e-02f, -1.18899466e-02f, 7.93933347e-02f, -2.10163221e-02f, 3.25301848e-02f,
  6.89926669e-02f, 8.12878385e-02f, 9.53772515e-02f, 2.62442138e-02f, 1.63850244e-02f, 7.28717670e-02f, 1.01073928e-01f, 4.96930853e-02f, 2.94813477e-02f, -2.32776385e-02f,
  8.27050582e-02f, 1.13437101e-01f, 1.24602662e-02f, -6.97521716e-02f, -5.19338390e-03f, -7.92049244e-02f, -2.00924352e-02f, -3.76978479e-02f, 2.26143319e-02f, -2.70593050e-03f,
  -1.07966691e-01f, -6.04582652e-02f, -4.09947671e-02f, 4.39400189e-02f, -3.93502824e-02f, -4.19058651e-02f, -1.67895237e-03f, -6.71146140e-02f, -2.63231862e-02f, -4.92139580e-03f,
  -7.58373120e-04f, 3.47527675e-02f, -7.57112503e-02f, -8.78340844e-03f, 1.89733375e-02f, -2.02322155e-02f, 5.96363619e-02f, 7.02885091e-02f, 3.35033014e-02f, -3.73622589e-02f,
  6.64824247e-02f, 8.03900510e-02f, -1.48183899e-02f, -6.76307157e-02f, -6.42893016e-02f, -2.60621216e-02f, 7.82629624e-02f, -9.26123280e-03f, 2.31054127e-02f, -2.80766357e-02f,
  1.80854164e-02f, -1.56290922e-02f, -5.70301488e-02f, 1.47867603e-02f, -5.98527230e-02f, 2.70916075e-02f, -3.06889545e-02f, -1.97904129e-02f, 9.11379349e-04f, -3.28818671e-02f,
  -4.39122058e-02f, -2.72882804e-02f, -1.79558434e-02f, -2.53672525e-02f, -2.83531453e-02f, -5.91954775e-02f, -6.11775182e-02f, 2.94319578e-02f, -1.11186886e-02f, 2.52317842e-02f,
  3.83030623e-01f, -3.94607216e-01f, -1.79713130e-01f, 2.22701561e-02f, -1.03751905e-01f, 2.85029382e-01f, 7.10556507e-02f, -1.54891297e-01f, 1.69788957e-01f, -2.25218982e-01f,
  2.13081449e-01f, 3.11905388e-02f, 9.82891619e-02f, 1.52030066e-01f, 6.13956392e-01f, 2.36975968e-01f, 2.72941291e-01f, 1.53739333e-01f, 1.52516201e-01f, 1.12013808e-02f,
  6.39901534e-02f, 7.71679878e-02f, -1.36380240e-01f, -2.41957709e-01f, -1.62603527e-01f, -2.79938757e-01f, -5.55423610e-02f, -1.72898218e-01f, -9.34262425e-02f, 9.13212746e-02f,
  -4.01852746e-03f, -7.05898479e-02f, -1.30810440e-01f, -4.08746190e-02f, 3.58190089e-02f, -3.20852585e-02f, -1.19525408e-02f, -3.74115780e-02f, 4.30984721e-02f, -9.29666869e-03f,
  4.01042141e-02f, 5.44786267e-02f, 5.09107858e-02f, -9.55339428e-03f, -1.32168662e-02f, 2.69005746e-02f, 4.45693918e-02f, 2.56259739e-03f, -4.79157977e-02f, 4.01912183e-02f,
  4.67887819e-02f, 5.38923331e-02f, 6.25718758e-02f, 9.80885029e-02f, 1.91353671e-02f, 4.88161594e-02f, -9.51036997e-03f, 5.87809645e-03f, 5.12554310e-02f, 5.00722490e-02f,
  4.78943437e-02f, 1.05916448e-02f, -5.03713600e-02f, -6.43451661e-02f, -8.37319065e-03f, -6.55626133e-02f, 2.76251324e-02f, 4.55119126e-02f, -2.35171225e-02f, 1.99177628e-03f,
  7.37069920e-02f, -8.00330788e-02f, 2.35425401e-02f, -1.56260543e-02f, 2.62072682e-02f, -7.35236630e-02f, -2.05527013e-03f, 4.21210080e-02f, 2.47383751e-02f, 3.64668332e-02f,
  -6.68233931e-02f, 3.97699587e-02f, -5.09781353e-02f, 2.18158588e-03f, -2.51151994e-03f, -5.83280139e-02f, 5.55571839e-02f, -6.93233535e-02f, -6.51967227e-02f, 4.46691290e-02f,
  1.31439924e-01f, -4.05259579e-02f, -1.76777150e-02f, -4.29523177e-02f, 7.12887209e-04f, -1.12633882e-02f, 3.05038430e-02f, 3.58060151e-02f, -4.92802635e-02f, -9.84860212e-03f,
  -3.54585499e-02f, -5.27608059e-02f, -6.04943149e-02f, 6.46100342e-02f, 4.85902615e-02f, 2.18819138e-02f, -7.10133929e-03f, -2.83014607e-02f, -4.10504173e-03f, 1.74551960e-02f,
  -7.48744681e-02f, 3.12803909e-02f, -2.24294364e-02f, -6.66935593e-02f, 2.49337964e-02f, -8.06102809e-03f, 1.75646823e-02f, -6.72938600e-02f, 2.45230403e-02f, 1.45424763e-02f,
  -4.67844397e-01f, 2.74878234e-01f, 2.95426220e-01f, -4.63745743e-02f, -2.80953553e-02f, 7.30548128e-02f, 1.19677214e-02f, 3.71049740e-03f, -1.28460467e-01f, -1.04145251e-01f,
  8.30921233e-02f, 6.49245903e-02f, 2.53185689e-01f, 7.76654631e-02f, 5.13376653e-01f, 2.91410267e-01f, 2.85046101e-02f, -1.00737490e-01f, -8.94615613e-03f, 3.11403051e-02f,
  -1.07717449e-02f, 1.24632567e-01f, 2.20698595e-01f, 5.62181547e-02f, -9.69225094e-02f, -1.50603458e-01f, -6.87671406e-03f, 1.60218552e-01f, -1.11990757e-01f, -3.74399796e-02f,
  -2.56328955e-02f, -4.10574600e-02f, 2.12371442e-02f, -4.43026721e-02f, 7.18369265e-04f, -2.42970977e-02f, -1.08168721e-01f, 6.08849488e-02f, 6.94493204e-02f, -7.60857621e-03f,
  -1.25545692e-02f, -5.65896630e-02f, 4.10374301e-03f, 8.56044590e-02f, -6.85530975e-02f, 2.14390866e-02f, 1.13220708e-02f, -1.44550085e-01f, 3.58436219e-02f, -1.11308932e-01f,
  4.39637341e-02f, -3.98558155e-02f, -1.30984738e-01f, -3.41580361e-02f, 3.83226969e-03f, -4.12331186e-02f, -3.83168808e-03f, 4.62616794e-02f, -2.54727881e-02f, -1.20260194e-01f,
  -5.75171411e-02f, -5.09613305e-02f, 1.08927839e-01f, -1.69309378e-02f, 1.69608891e-01f, -2.17522290e-02f, 7.83953220e-02f, 5.27318940e-02f, -2.58187205e-02f, 5.10289669e-02f,
  7.66047910e-02f, -8.80781212e-04f, -2.58973688e-02f, -1.35942204e-02f, -7.90431350e-02f, -9.53917503e-02f, 1.50857083e-02f, 6.47650333e-03f, -2.71431897e-02f, 7.19572604e-03f,
  2.25730445e-02f, 4.42310609e-02f, 3.60221006e-02f, -1.43413171e-01f, 4.34956998e-02f, 7.12189972e-02f, -3.70714962e-02f, 1.37656787e-02f, -1.68535933e-02f, 4.80934344e-02f,
  1.71198338e-01f, 3.25764686e-01f, 3.23721021e-02f, -2.76036728e-02f, 1.07625864e-01f, 8.31901208e-02f, 2.43594367e-02f, -2.11805720e-02f, 7.02886879e-02f, 7.13248970e-03f,
  -1.34748176e-01f, -7.06854016e-02f, -6.75041899e-02f, -6.48591220e-02f, 3.20953056e-02f, -1.46172494e-02f, -2.16709916e-02f, -1.20556373e-02f, 6.13884181e-02f, -1.56238517e-02f,
  9.95815033e-04f, 5.77034280e-02f, 3.34755816e-02f, -3.33052911e-02f, -2.16668546e-02f, -8.32676217e-02f, -1.97812431e-02f, -4.87849899e-02f, 9.63147357e-02f, 3.96585800e-02f,
  9.29609984e-02f, 3.80788483e-02f, -6.90849870e-02f, -2.55657345e-01f, 2.34677330e-01f, 2.94924080e-01f, -1.28758878e-01f, 1.18994981e-01f, -3.54588538e-01f, -1.19629428e-01f,
  1.52978048e-01f, 1.72768876e-01f, -1.29644245e-01f, 1.10079482e-01f, 2.48667654e-02f, -3.08413357e-01f, -8.29802752e-02f, -1.03208162e-01f, -1.69899255e-01f, -7.02603254e-03f,
  -9.54111069e-02f, 5.44591211e-02f, -4.36328687e-02f, 1.70125902e-01f, 1.78284988e-01f, 3.80236767e-02f, 1.58353105e-01f, 1.63461715e-01f, 3.27133685e-01f, 2.44961694e-01f,
  4.53704596e-02f, -7.83799067e-02f, -8.73109847e-02f, -2.76369397e-02f, 5.34654129e-03f, 7.26052597e-02f, 8.07253718e-02f, 1.58446953e-01f, -8.79083120e-04f, -3.58365662e-02f,
  -3.17041017e-02f, 8.52511600e-02f, 7.62358541e-04f, 3.87923941e-02f, 2.80519314e-02f, -1.22894803e-02f, 5.79705648e-02f, 3.87601118e-04f, -1.52063044e-02f, 1.14803903e-01f,
  -6.95306947e-03f, 1.89853087e-02f, 1.21566974e-01f, -4.25135810e-03f, -5.22275791e-02f, -5.46477921e-02f, -5.42949885e-02f, 1.04330622e-01f, -1.03009669e-02f, -2.38742810e-02f,
  1.47337932e-02f, -4.27760929e-02f, 4.78265584e-02f, -1.21976539e-01f, -7.40443822e-03f, -3.69291157e-02f, -4.84177172e-02f, 4.81367446e-02f, 4.94078547e-02f, -3.62045541e-02f,
  -8.09622929e-03f, -2.66497917e-02f, -3.24475430e-02f, -2.83802897e-02f, 3.93531770e-02f, -9.65118334e-02f, -3.79016693e-03f, 3.60876955e-02f, -1.12193272e-01f, -3.82133899e-03f,
  -4.48394492e-02f, -5.72898425e-02f, -2.93178950e-02f, -2.26697139e-02f, -1.09796040e-01f, -4.39481251e-03f, 4.34891842e-02f, -5.74723026e-03f, 2.52789701e-03f, 2.84866970e-02f,
  5.54945283e-02f, 8.18392336e-02f, -3.40738520e-02f, 4.03020643e-02f, -1.22080274e-01f, 5.49289584e-02f, -1.25495285e-01f, 9.37967598e-02f, 2.40685064e-02f, -2.15077288e-02f,
  9.69980657e-02f, -4.18382734e-02f, -8.82013980e-03f, 7.55659044e-02f, -9.56774130e-03f, -4.75541465e-02f, -8.12770426e-02f, -6.29102737e-02f, 5.24385879e-03f, 9.77017656e-02f,
  8.19164366e-02f, -2.17528432e-03f, -4.50225361e-02f, 4.02187817e-02f, -1.28659932e-02f, 2.50521824e-02f, 3.51946726e-02f, 5.41702332e-03f, 9.26830173e-02f, -5.39183542e-02f,
  -3.51804674e-01f, 1.04942610e-02f, -8.10323134e-02f, 2.37871017e-02f, 5.68084000e-03f, 2.85525799e-01f, 8.66117179e-02f, 9.43185836e-02f, 2.20313445e-01f, 1.49139380e-02f,
  2.62964070e-01f, -1.30505696e-01f, 1.92191914e-01f, 3.47385943e-01f, 6.31317496e-02f, 3.50352526e-01f, 6.80383742e-02f, 1.33870512e-01f, 5.01180850e-02f, -8.96374583e-02f,
  -2.92947683e-02f, 2.37381402e-02f, 1.13965735e-01f, -1.26989782e-01f, -8.54054540e-02f, -2.31362775e-01f, -2.63033569e-01f, -1.28517643e-01f, -8.95567909e-02f, 3.26706772e-03f,
  5.35305357e-03f, 2.34923866e-02f, -2.05122605e-02f, -5.43975532e-02f, -5.47157526e-02f, -3.85413021e-02f, -1.23630300e-01f, -1.12934159e-02f, 9.01024416e-03f, 4.46102209e-02f,
  8.61545727e-02f, -2.02133842e-02f, 2.21827812e-02f, 3.02289817e-02f, -6.41000941e-02f, 3.55791003e-02f, 1.08001076e-01f, 4.19549793e-02f, 3.51777002e-02f, 8.90326574e-02f,
  9.79680121e-02f, 1.97096970e-02f, -7.25341812e-02f, 4.27878840e-04f, -1.12038646e-02f, -4.96093743e-02f, -4.98763546e-02f, -5.38648590e-02f, -2.50755176e-02f, -2.34523546e-02f,
  -4.41923477e-02f, -2.92140674e-02f, 5.26397787e-02f, -1.72267028e-03f, 1.98497940e-02f, -1.45771308e-02f, -4.03354168e-02f, 2.13720761e-02f, -4.38977033e-02f, 2.25902423e-02f,
  -5.57907566e-04f, -4.39380370e-02f, -2.30608694e-02f, 7.95549713e-03f, -6.29537329e-02f, 3.66082713e-02f, -8.19195583e-02f, -2.22951584e-02f, 4.40891162e-02f, 5.90915047e-02f,
  -1.12136910e-02f, -5.48491105e-02f, 2.48618498e-02f, -1.22046554e-02f, 9.57362726e-03f, -2.76258364e-02f, -4.51413952e-02f, 5.10847494e-02f, 1.03274904e-01f, -4.63448279e-02f,
  -1.31668150e-01f, -4.37231928e-01f, 4.47140709e-02f, -2.20176671e-02f, -1.98762845e-02f, 2.39570681e-02f, 4.14520092e-02f, 5.92517927e-02f, -1.32036284e-01f, -1.74270272e-02f,
  -6.86311945e-02f, -2.84633972e-02f, -1.92742273e-01f, -1.23959957e-02f, 4.31159511e-02f, 2.13873591e-02f, -7.09859580e-02f, -1.17329434e-01f, -1.08258158e-01f, -2.06090957e-02f,
  -1.19703345e-01f, -8.73423517e-02f, 4.51965556e-02f, 3.12521076e-03f, -5.65851852e-02f, 5.83428927e-02f, -4.68253382e-02f, -1.45955803e-02f, -2.53005996e-02f, -2.00417303e-02f,
  -1.46854743e-01f, 2.71957189e-01f, -3.96576285e-01f, 8.32585543e-02f, -7.84066468e-02f, -2.08411664e-01f, -4.51103970e-02f, 5.77787124e-03f, 1.35267004e-01f, 3.16035032e-01f,
  2.03694683e-02f, -8.50144029e-02f, 1.30506009e-01f, -6.53227471e-05f, -1.19994618e-01f, 4.38828692e-02f, 8.75957161e-02f, 8.11081231e-02f, 4.32790853e-02f, 1.66112542e-01f,
  -4.56573665e-02f, 2.11490050e-01f, -2.53212154e-01f, 1.14090957e-01f, -1.62176803e-01f, -7.15943947e-02f, 1.87512577e-01f, -4.20540459e-02f, -6.92192838e-02f, -9.16033983e-02f,
  -1.57858394e-02f, 7.20724240e-02f, -7.98207372e-02f, -1.20577961e-02f, -6.56206459e-02f, -1.54413143e-02f, -3.24490890e-02f, -4.66160998e-02f, -8.41912907e-03f, -5.19210361e-02f,
  1.49046415e-02f, -4.85522486e-02f, -1.82192214e-02f, 2.09182221e-02f, 4.24354896e-02f, 1.44982754e-04f, -1.02806278e-01f, -7.78719559e-02f, -9.11192223e-03f, -1.03158161e-01f,
  -4.95941825e-02f, -1.57962769e-01f, -3.85620110e-02f, -2.48737279e-02f, -9.98036116e-02f, -3.93189602e-02f, -7.61518329e-02f, -3.64408903e-02f, -2.16700584e-02f, 4.21944121e-03f,
  5.90416379e-02f, 4.49548066e-02f, -3.54849249e-02f, -8.26347917e-02f, 5.55368476e-02f, -8.65267888e-02f, 1.45189157e-02f, -1.41019626e-02f, -7.05175400e-02f, 6.31693304e-02f,
  -3.74171734e-02f, 1.95813887e-02f, 1.18661327e-02f, 1.15044601e-02f, 1.47447614e-02f, 4.96171862e-02f, -7.96709135e-02f, -4.30114120e-02f, 2.06885766e-02f, -1.12895712e-01f,
  4.81021740e-02f, 3.70654128e-02f, 3.08069140e-02f, -2.59613544e-02f, -1.06140478e-02f, 3.35758589e-02f, 3.52914929e-02f, -4.14791778e-02f, 3.97856943e-02f, -7.00945035e-02f,
  3.80633354e-01f, 4.81989086e-01f, 6.63315877e-02f, -3.35283950e-02f, -8.54509324e-03f, -5.71788661e-02f, -1.74902435e-02f, -5.15299998e-02f, 9.07937586e-02f, 7.61858076e-02f,
  -1.60963852e-02f, -2.49440828e-03f, 2.55059712e-02f, -3.13576721e-02f, -1.88360643e-02f, -2.31736228e-02f, 7.27382377e-02f, 6.16890676e-02f, 4.77262363e-02f, 3.71349901e-02f,
  -3.43031879e-03f, 7.63129368e-02f, -9.97331217e-02f, 3.13889273e-02f, 3.28077599e-02f, -2.90934555e-02f, 7.14895055e-02f, -3.55220363e-02f, 2.62466520e-02f, 4.02174033e-02f,
  -5.91902435e-01f, -1.35092750e-01f, -5.89241646e-02f, -2.76541531e-01f, -1.23905398e-01f, -2.03102931e-01f, -4.20459881e-02f, -1.59579217e-01f, -6.68589100e-02f, 3.20812427e-02f,
  -2.31296457e-02f, -1.16915284e-02f, 2.71738529e-01f, -6.88028857e-02f, 1.41744778e-01f, 3.09646070e-01f, -2.80323267e-01f, -7.05592707e-02f, 1.02875456e-01f, -2.95664579e-01f,
  -1.38279334e-01f, -4.81783934e-02f, 2.42037103e-02f, 6.44951127e-03f, -2.58322269e-01f, -2.52408832e-01f, -8.14762861e-02f, 1.69782430e-01f, -1.95060268e-01f, 1.18050665e-01f,
  4.58834916e-02f, 5.91687858e-02f, -4.63912897e-02f, 3.71767581e-02f, -2.38994867e-01f, -4.72695939e-02f, -8.31878185e-02f, 1.76620588e-01f, 8.24241638e-02f, -2.61218660e-02f,
  -4.53235917e-02f, -6.30607130e-03f, -3.94440703e-02f, 6.25578091e-02f, -4.94651832e-02f, -2.71023042e-03f, -4.00149338e-02f, -8.11368600e-02f, 4.25744504e-02f, 1.70798749e-02f,
  1.34932259e-02f, -4.49647531e-02f, -1.78327858e-01f, -3.15439738e-02f, -1.00532092e-01f, 2.02355464e-03f, 2.01980770e-02f, -1.65075362e-02f, 1.05741257e-02f, -7.14754462e-02f,
  -1.29991188e-03f, 8.15103110e-03f, -4.77140993e-02f, 8.72086268e-03f, 1.07131405e-02f, -6.58649672e-03f, -6.87221736e-02f, -2.59502116e-03f, 5.76904928e-03f, -6.09659925e-02f,
  -9.47677121e-02f, -5.24319597e-02f, -1.23680113e-02f, -3.36497314e-02f, -8.10017288e-02f, -7.80605478e-03f, -1.78905744e-02f, -8.75558518e-03f, -1.06067598e-01f, 1.46238077e-02f,
  3.22373174e-02f, 2.83346530e-02f, 5.11272214e-02f, 6.32230267e-02f, 3.87169328e-03f, -2.22960282e-02f, -3.94982062e-02f, -4.44464199e-02f, 5.42326719e-02f, 3.09662633e-02f,
  -3.25275064e-02f, -2.22484320e-01f, -2.19790927e-05f, 8.98160413e-02f, 1.00142680e-01f, 3.12509537e-02f, 8.41961801e-02f, -1.13967717e-01f, -4.82598580e-02f, 3.34374718e-02f,
  -1.47243589e-01f, 3.62378149e-03f, -1.06524728e-01f, 8.93328246e-03f, 1.16679026e-02f, -4.58002603e-03f, -5.41769341e-02f, 1.32232262e-02f, -9.63220298e-02f, -9.73547176e-02f,
  -5.28731011e-02f, 8.92072916e-04f, -1.45424427e-02f, -4.29899618e-02f, -8.34322125e-02f, -8.62203464e-02f, -5.59814312e-02f, 3.01035661e-02f, -3.66566405e-02f, -1.30498419e-02f,
  -4.88251925e-01f, -1.52839929e-01f, 1.63113102e-01f, -2.80086279e-01f, -1.18663304e-01f, 2.44688645e-01f, 4.41431016e-01f, -1.27811342e-01f, -2.32171372e-01f, 9.55537781e-02f,
  -2.25984201e-01f, 4.25390042e-02f, -2.60448847e-02f, -2.35513840e-02f, -7.97280297e-02f, -1.70539901e-01f, 4.02539745e-02f, 1.49916425e-01f, 1.92230612e-01f, -1.90453216e-01f,
  -1.19322978e-01f, -1.91652417e-01f, -3.68038029e-03f, 4.25489619e-02f, -5.71021661e-02f, 2.89675109e-02f, 2.51260195e-02f, 1.99966103e-01f, 1.31207958e-01f, 8.27711076e-02f,
  -4.23936844e-02f, -1.14347212e-01f, 3.38562913e-02f, 3.86915617e-02f, -5.05846404e-02f, 2.20804568e-02f, 1.93124160e-01f, 6.66208565e-02f, 1.66969802e-02f, 7.60249719e-02f,
  5.28162569e-02f, 1.77516863e-02f, 3.99571694e-02f, -1.73734836e-02f, -8.12700856e-03f, -1.00850211e-02f, -5.58127016e-02f, -7.60030448e-02f, -2.59599499e-02f, -6.38532592e-03f,
  -5.60812876e-02f, -2.03847550e-02f, -8.78918543e-02f, -2.23663519e-03f, 9.42187442e-04f, -4.50971164e-03f, 1.12331696e-02f, 7.14526027e-02f, -3.85329165e-02f, 2.04453357e-02f,
  1.56600654e-01f, 8.48434344e-02f, -5.96769787e-02f, 3.44405845e-02f, -7.15234429e-02f, -3.56421173e-02f, 4.72828466e-03f, -7.56372958e-02f, 3.44867297e-02f, -5.73161505e-02f,
  -4.95814905e-02f, -2.03871611e-03f, -4.15784866e-02f, -3.23303719e-03f, -1.91915967e-03f, -7.22179934e-02f, 8.57717730e-03f, -3.79252136e-02f, 5.82937934e-02f, 9.65843573e-02f,
  -7.49329396e-04f, -2.52825916e-02f, -4.38797139e-02f, 6.16164990e-02f, 1.90965384e-02f, -7.43371248e-02f, -5.40006533e-02f, -3.25854719e-02f, -2.40148641e-02f, -1.20270150e-02f,
  -1.77812278e-01f, -1.23993747e-01f, 8.13736767e-02f, -5.14197797e-02f, 5.97851053e-02f, -2.96210051e-02f, 3.45727727e-02f, -7.43626058e-02f, -1.23063838e-02f, -2.13190727e-02f,
  3.04004066e-02f, 3.32724415e-02f, -3.76462489e-02f, -3.42562124e-02f, 7.39502236e-02f, -5.95629886e-02f, 1.05800908e-02f, -1.23672925e-01f, 5.33837080e-03f, 4.93025966e-02f,
  -1.13735870e-02f, -4.32996973e-02f, 1.40450194e-01f, -5.58629669e-02f, 8.55799913e-02f, -2.00335328e-02f, -7.72899762e-02f, 5.33500426e-02f, 2.42929589e-02f, 4.58507165e-02f,
  -2.09231660e-01f, 1.45519838e-01f, 5.69934957e-02f, 5.31700552e-02f, -7.85941109e-02f, 3.84713769e-01f, 2.18804777e-01f, 8.56501609e-02f, -1.01396397e-01f, 2.05411956e-01f,
  1.71634808e-01f, -3.28607798e-01f, 1.55095220e-01f, 3.56894076e-01f, 1.34954959e-01f, 2.18121558e-01f, 2.92629868e-01f, -2.23039766e-03f, -3.03032640e-02f, -6.58720266e-03f,
  -3.46441113e-04f, 2.46185899e-01f, 2.64855415e-01f, -2.72155683e-02f, 1.05655082e-01f, -1.65355906e-01f, 7.66500160e-02f, -1.93471268e-01f, 8.61515477e-02f, -2.76850518e-02f,
  2.38209695e-01f, -7.23641962e-02f, -8.14197212e-02f, 1.02548872e-03f, 1.18969701e-01f, -1.24228662e-02f, -6.53673783e-02f, -3.96649465e-02f, -3.56277004e-02f, -2.96941306e-02f,
  -7.97452256e-02f, -1.24061983e-02f, -4.38130759e-02f, -1.00224428e-01f, -4.57185656e-02f, -7.02665299e-02f, 1.39656272e-02f, 1.26609102e-01f, 2.33501587e-02f, 4.74228375e-02f,
  -5.72100002e-03f, 6.02478534e-02f, 7.94682726e-02f, -2.80921720e-02f, -2.34722514e-02f, 3.08540463e-03f, 6.85260911e-03f, -3.95143181e-02f, 1.14692580e-02f, -1.78201329e-02f,
  -1.88779011e-02f, 2.44460851e-02f, 1.68819744e-02f, 3.72985490e-02f, -1.05515737e-02f, 2.82532554e-02f, -4.53365454e-03f, 9.13144462e-03f, -6.66767955e-02f, 7.02873543e-02f,
  -2.47577708e-02f, -8.02885219e-02f, -5.38846590e-02f, 2.43527964e-02f, 2.30755769e-02f, 2.37096678e-02f, -4.32391688e-02f, -5.26589341e-02f, 6.43014312e-02f, 4.73711714e-02f,
  -1.74251664e-02f, 1.59130841e-02f, -2.31324229e-02f, 2.92307734e-02f, 5.26107624e-02f, -1.44601276e-03f, 3.88811827e-02f, 8.07261467e-03f, 3.97486947e-02f, 9.16361110e-04f,
  7.79266432e-02f, -4.74742241e-03f, -2.19315589e-05f, -3.87940407e-02f, -9.94911268e-02f, -9.19190235e-03f, 2.50769990e-05f, 3.40104029e-02f, -2.88909487e-02f, 3.65573689e-02f,
  3.94485034e-02f, -3.55475917e-02f, 4.99379821e-02f, 2.32103206e-02f, 4.93982341e-03f, 1.03097901e-01f, -2.22143028e-02f, -1.12063698e-01f, -1.61670250e-04f, -4.65474650e-02f,
  2.23772079e-02f, -9.22269002e-02f, -5.15803955e-02f, 3.20056006e-02f, 5.39463609e-02f, -2.47249100e-02f, 1.18090296e-02f, -1.82945412e-02f, -2.58915909e-02f, 9.43330303e-03f,
  6.82702363e-01f, -9.86844376e-02f, 1.30620983e-03f, 3.73780698e-01f, 1.95847616e-01f, 2.66517222e-01f, 2.53533632e-01f, 1.30459696e-01f, 2.25995243e-01f, -1.52776062e-01f,
  1.21283241e-01f, -2.53602602e-02f, -6.53105825e-02f, 1.56772867e-01f, 5.01564085e-01f, -5.63940145e-02f, 2.70602375e-01f, 5.16592227e-02f, -2.30421554e-02f, 1.91188797e-01f,
  1.43172592e-01f, 1.56781331e-01f, 1.09186575e-01f, -3.55038270e-02f, 1.18951574e-01f, -9.02514383e-02f, -6.57565743e-02f, -1.54610649e-01f, 2.95489607e-03f, 1.08679924e-02f,
  1.25470981e-01f, 9.41394493e-02f, -4.87701185e-02f, -4.34257053e-02f, 9.50558409e-02f, -2.35190727e-02f, 1.12970518e-02f, -5.77972606e-02f, 3.98078031e-04f, 1.91315617e-02f,
  -3.33692133e-02f, 4.34771962e-02f, 9.98032186e-03f, -4.63461801e-02f, 3.32212858e-02f, 9.11515690e-06f, 4.63058054e-02f, -1.97624322e-02f, -1.51056360e-04f, 1.35922786e-02f,
  -3.39679755e-02f, 2.11632326e-02f, -2.31880089e-03f, -1.91634782e-02f, 2.29898212e-03f, -1.22087297e-03f, -9.49577056e-03f, -4.53019813e-02f, 7.08467374e-03f, 1.05761498e-01f,
  7.38893300e-02f, -4.56724167e-02f, -6.23200610e-02f, -1.09211011e-02f, 2.95232125e-02f, -2.12618336e-02f, -1.95061881e-02f, 1.25958044e-02f, -8.07736889e-02f, 4.76998836e-02f,
  6.81720972e-02f, 1.04616780e-03f, 5.13722487e-02f, 3.21715958e-02f, -6.32248772e-03f, 3.28693017e-02f, -6.03987090e-02f, 1.22432681e-02f, 2.17463411e-02f, 2.55493019e-02f,
  8.69856216e-03f, -3.58548656e-04f, -4.05801609e-02f, -2.43939310e-02f, 2.60666106e-02f, -9.83265601e-03f, -3.63195799e-02f, 2.17710249e-03f, 3.88482101e-02f, 3.41408439e-02f,
  1.55298933e-01f, 2.42137909e-01f, -3.15408111e-02f, 5.65561466e-02f, -6.20648973e-02f, -1.44201869e-04f, 2.24887859e-02f, -2.86034634e-03f, 3.40432785e-02f, 5.79839014e-02f,
  1.01700490e-02f, -3.54811326e-02f, 1.69552211e-02f, -3.02066449e-02f, -2.92511974e-02f, 1.62021688e-03f, 2.77898507e-03f, -2.33348180e-02f, 6.00622669e-02f, -1.25995548e-02f,
  3.02614886e-02f, -1.35188252e-02f, -5.95173379e-03f, -1.45576624e-02f, -1.35079110e-02f, 2.47541871e-02f, 5.99317513e-02f, -5.32434974e-03f, -8.31218157e-03f, -6.20950572e-02f,
  -5.47904611e-01f, 6.49515539e-02f, -4.34456527e-01f, 4.11685789e-03f, 1.77167095e-02f, 2.82906055e-01f, 5.29425330e-02f, -4.25709747e-02f, -1.73906609e-01f, 2.06782803e-01f,
  1.32793471e-01f, -1.10778034e-01f, -9.00430530e-02f, 2.06798598e-01f, -4.08207215e-02f, 1.55375525e-02f, 1.71499312e-01f, 1.03317410e-01f, -4.20875512e-02f, -1.01822279e-01f,
  -8.16597790e-02f, 3.51782262e-01f, -1.24768645e-01f, 1.83089361e-01f, -9.90917981e-02f, -7.58260339e-02f, 5.23432940e-02f, -8.37052912e-02f, 2.50761926e-01f, 7.64382929e-02f,
  -7.96231106e-02f, -3.62028271e-01f, -1.15222551e-01f, -9.95826647e-02f, -6.45482764e-02f, -6.87542884e-03f, -5.14365286e-02f, -6.26639789e-03f, -5.67933135e-02f, 3.98592614e-02f,
  -8.70537758e-02f, -3.10024153e-02f, 3.29389051e-02f, 7.56195048e-03f, 1.68433320e-02f, 5.24626253e-03f, -2.01823786e-02f, -1.72444433e-03f, 3.58570740e-03f, -9.62693542e-02f,
  -7.99026992e-03f, 1.03747249e-02f, 4.24393220e-03f, 7.62964860e-02f, -6.51421100e-02f, 1.96780134e-02f, -6.44618820e-04f, -6.05506077e-02f, 6.74278587e-02f, 3.64717357e-02f,
  1.23416968e-02f, -5.77370375e-02f, -9.97714419e-03f, 3.70488837e-02f, 9.40957665e-03f, -7.57769775e-03f, 8.15855712e-02f, 4.35487069e-02f, -2.02802047e-02f, -3.84393483e-02f,
  6.18369319e-02f, -3.66459861e-02f, 1.84342787e-02f, 1.27705950e-02f, 1.98423099e-02f, -1.96599644e-02f, -8.84318259e-03f, -2.66879750e-03f, 2.84966119e-02f, 2.97988076e-02f,
  -3.17229182e-02f, -2.58896798e-02f, 3.32173035e-02f, 4.42063902e-03f, 7.32071102e-02f, -4.62768972e-02f, -2.46224888e-02f, 6.06840383e-03f, -5.42074330e-02f, -5.13587408e-02f,
  -1.45969307e-02f, -5.19346036e-02f, 3.53486203e-02f, 1.29853174e-01f, 6.83759227e-02f, 1.21115930e-02f, -2.49685217e-02f, -2.54674517e-02f, 2.69205477e-02f, -3.52130234e-02f,
  -2.59469729e-02f, -3.58746224e-03f, -7.67234992e-03f, -4.54945955e-03f, 6.15179315e-02f, -1.97325815e-02f, 3.78348604e-02f, -5.54591743e-03f, 3.93540226e-02f, 3.41972671e-02f,
  -1.09863235e-02f, 2.17815731e-02f, 1.83251817e-02f, 6.82850415e-03f, -5.14208339e-03f, 2.99673621e-02f, -6.55358508e-02f, 2.35730633e-02f, 1.11734532e-02f, 2.14723293e-02f,
  1.63569581e-02f, -3.73859018e-01f, -5.49180172e-02f, 1.78655520e-01f, 2.76332438e-01f, -4.78033513e-01f, -1.09422937e-01f, -4.26589511e-03f, 4.50554073e-01f, -2.39009306e-01f,
  -1.26243621e-01f, -9.19268802e-02f, -5.17479591e-02f, -9.41122249e-02f, -1.00019900e-02f, 5.41567579e-02f, -1.35009214e-01f, 3.48461866e-02f, 2.09719688e-01f, -6.55789673e-02f,
  1.08780880e-02f, -1.34681631e-02f, -1.57536194e-01f, 5.78227155e-02f, -2.44670421e-01f, -3.09317373e-02f, -1.33946210e-01f, 1.07097290e-01f, -1.97425216e-01f, 1.93621945e-02f,
  -1.23265885e-01f, 1.61059901e-01f, -1.44446537e-01f, -3.33702378e-02f, -1.44774720e-01f, -9.76687018e-03f, -1.34112671e-01f, 7.73143694e-02f, 7.02539608e-02f, 2.10339557e-02f,
  2.98908958e-03f, 1.21473670e-01f, 3.53953824e-03f, 1.11085288e-01f, 6.05208054e-02f, 1.34674432e-02f, -3.77237098e-03f, -1.02634817e-01f, -2.20680069e-02f, 3.94044928e-02f,
  5.16639799e-02f, -7.10801482e-02f, -1.40907079e-01f, -6.28426671e-02f, 7.21202744e-03f, 6.67749643e-02f, 3.37436609e-02f, -3.20100761e-03f, -9.65382680e-02f, 4.46840003e-02f,
  1.32799089e-01f, 3.62115912e-02f, 1.02379238e-02f, 3.94539125e-02f, -1.49339726e-02f, 2.99049504e-02f, -5.89958206e-03f, -1.23758009e-02f, -8.80069681e-04f, -5.66220731e-02f,
  -3.61888297e-02f, 9.38377529e-02f, 5.97384609e-02f, -2.11892221e-02f, 7.76580274e-02f, -2.15252545e-02f, -5.27298190e-02f, 8.55491087e-02f, -1.01135932e-01f, 5.23834638e-02f,
  6.12240136e-02f, -5.67667000e-02f, 1.12393368e-02f, -2.91657597e-02f, 3.10898032e-02f, -1.30292471e-03f, -3.46121266e-02f, -2.32554674e-02f, -4.60331775e-02f, -6.85263947e-02f,
  -2.89143533e-01f, -1.21859968e-01f, -7.94636682e-02f, -7.74325952e-02f, 3.26348990e-02f, -8.46363157e-02f, 2.16093421e-01f, -5.25732487e-02f, -3.52577120e-02f, 1.41682355e-02f,
  -1.44970044e-02f, -5.89570254e-02f, -9.82194766e-02f, 3.47166061e-02f, -1.16463881e-02f, -3.38475257e-02f, 4.02822979e-02f, -9.46421251e-02f, -1.46803990e-01f, -7.84692392e-02f,
  -1.04555279e-01f, 4.91900258e-02f, 6.04163446e-02f, -3.75653505e-02f, -8.45078528e-02f, -1.32909447e-01f, 5.08316085e-02f, 8.78215134e-02f, 5.40185831e-02f, -4.13883775e-02f,
  2.64621139e-01f, 4.70846407e-02f, 1.59318641e-01f, 9.18783098e-02f, -4.55336869e-01f, -3.96265239e-01f, 6.50380999e-02f, -2.53594577e-01f, -2.65172422e-01f, 7.27903321e-02f,
  -1.09854229e-01f, 1.98844656e-01f, 2.47391939e-01f, 2.51891278e-02f, 1.94459960e-01f, 7.88837373e-02f, 1.56476162e-02f, -5.94214424e-02f, -1.34219602e-01f, -5.33925891e-02f,
  3.48789431e-02f, -1.13533810e-01f, 3.23689044e-01f, -1.73457593e-01f, 8.08638036e-02f, -6.10426720e-03f, 9.37778130e-02f, -4.00776006e-02f, 1.48680612e-01f, -1.19825028e-01f,
  -1.35486862e-02f, -3.43245938e-02f, 3.99440937e-02f, 1.11066155e-01f, -2.24790052e-02f, -7.61702135e-02f, 6.56026080e-02f, -8.38735700e-03f, 8.44486207e-02f, 6.63362965e-02f,
  1.02314688e-01f, 7.37559870e-02f, 5.79251628e-03f, -5.22041395e-02f, -2.93328334e-02f, 2.07044259e-02f, -4.93666157e-03f, -3.57188210e-02f, 1.70322042e-02f, 7.39579871e-02f,
  7.77038336e-02f, -1.00078257e-02f, -1.23577841e-01f, -6.45019254e-03f, 7.75643513e-02f, 7.92904273e-02f, 5.42345867e-02f, -3.00262254e-02f, -2.05927398e-02f, -9.12158284e-03f,
  -2.22083665e-02f, -1.53529895e-02f, 5.41840505e-04f, 4.66351323e-02f, -8.16409811e-02f, 9.17801261e-03f, -6.92663388e-03f, -3.20203751e-02f, -2.43727397e-03f, 6.77148346e-03f,
  -1.18029863e-01f, 5.54736052e-03f, -7.53202438e-02f, -3.19844075e-02f, 9.19174999e-02f, 5.45041114e-02f, -2.83552427e-02f, -6.96244389e-02f, -1.02923431e-01f, -5.12254331e-03f,
  3.67844626e-02f, 3.35292034e-02f, 2.85435170e-02f, 2.66959146e-02f, 6.49331063e-02f, 2.69414391e-02f, -9.38054919e-02f, 2.04228554e-02f, -5.68059422e-02f, 2.02903597e-04f,
  -1.16737582e-01f, -3.58441263e-01f, 2.16202196e-02f, 1.86558429e-03f, -2.31126491e-02f, -3.07950526e-02f, -3.62556987e-02f, -1.30738199e-01f, 2.06745081e-02f, -1.05663948e-01f,
  -6.63000196e-02f, -7.17753638e-03f, -9.41092670e-02f, 2.28838287e-02f, 1.58995390e-02f, -1.43616423e-01f, 9.50732082e-02f, -3.83129232e-02f, -6.58370554e-03f, -2.19918694e-02f,
  5.58655486e-02f, -1.23238176e-01f, 1.43870234e-01f, -1.51623830e-01f, -3.89974937e-02f, 1.04857134e-02f, -1.49891317e-01f, 3.53797898e-02f, 8.56905878e-02f, -5.93550950e-02f,
  -3.09455872e-01f, 2.12397352e-01f, 7.40539934e-03f, -1.99276701e-01f, -7.88241476e-02f, -2.95703948e-01f, -3.53331149e-01f, 1.25218765e-03f, -2.75442749e-01f, -1.83183461e-01f,
  -7.52605051e-02f, 7.40681365e-02f, -1.20154142e-01f, 1.22799590e-01f, -2.11200818e-01f, -6.13323338e-02f, -1.68867230e-01f, -1.04567878e-01f, -1.53413760e-02f, -6.96721151e-02f,
  -9.87007543e-02f, -1.30456731e-01f, 2.67097410e-02f, 7.31325969e-02f, 2.36336520e-04f, 6.22603744e-02f, -4.35407758e-02f, 1.98629731e-03f, 1.73266202e-01f, 1.48073360e-01f,
  7.07105268e-03f, -8.10122192e-02f, -5.15742041e-02f, -2.70794760e-02f, -1.84709683e-01f, -7.09418431e-02f, -1.22392504e-02f, 9.57521982e-03f, -1.35127073e-02f, 6.60990225e-03f,
  3.37794481e-04f, 3.43664400e-02f, 8.55712071e-02f, 3.74691747e-02f, -8.03098083e-02f, -8.65496416e-03f, 3.10349278e-02f, 4.18218635e-02f, -1.60389747e-02f, 6.07835948e-02f,
  3.24023068e-02f, 9.25011709e-02f, -2.88028922e-02f, 2.23203544e-02f, -2.02023722e-02f, -3.92753407e-02f, 3.16288434e-02f, 3.71844955e-02f, -2.91026924e-02f, -9.50768143e-02f,
  1.98958796e-02f, -5.44142015e-02f, -5.75266555e-02f, 6.59090579e-02f, -7.31939226e-02f, 5.49333170e-02f, -5.44914156e-02f, 5.63797206e-02f, -3.64721566e-02f, -4.93735038e-02f,
  3.14857438e-02f, 1.37453154e-03f, 4.00149357e-03f, -8.70589465e-02f, -3.15041770e-03f, -7.68294185e-02f, -3.87954502e-03f, 3.37869152e-02f, 1.56385042e-02f, 4.84280474e-02f,
  -3.95755544e-02f, -2.39007454e-02f, -3.29925912e-03f, 3.28193791e-02f, -6.03918396e-02f, -1.87003016e-02f, 1.04735261e-02f, 5.93145657e-03f, 5.97553030e-02f, 1.37083689e-02f,
  -3.53168577e-01f, -4.46275800e-01f, -4.67775576e-02f, -6.54521212e-02f, 1.62085891e-02f, -4.36427779e-02f, 4.35873270e-02f, 5.03966659e-02f, -8.57949629e-02f, -1.04321092e-01f,
  1.85790360e-02f, -4.50784899e-02f, -4.49806973e-02f, -5.76794185e-02f, 7.46314079e-02f, -1.78634655e-02f, -1.23618655e-02f, 8.06804188e-03f, -1.22368537e-01f, -5.80428960e-03f,
  -4.52840216e-02f, -8.90838951e-02f, 3.06335986e-02f, -9.55753028e-03f, 4.74381521e-02f, -3.87053154e-02f, -7.16594383e-02f, 5.91399409e-02f, 2.25336547e-03f, 5.55299409e-02f,
  -9.87512022e-02f, -2.58018106e-01f, -3.03486347e-01f, 2.49164224e-01f, 6.37750849e-02f, 4.29664731e-01f, 3.12798083e-01f, -1.02019273e-01f, 1.93564817e-01f, 1.18130736e-01f,
  2.52832800e-01f, 8.46890062e-02f, -1.48954511e-01f, 3.22772294e-01f, 3.56051296e-01f, -6.75072595e-02f, 4.30194885e-01f, 1.59713954e-01f, -1.69196025e-01f, 3.51284668e-02f,
  6.73539471e-04f, 2.52126336e-01f, -1.21444762e-02f, -4.70975935e-02f, 9.15660895e-03f, -2.35723555e-01f, -2.18936168e-02f, -1.77284241e-01f, 1.24571495e-01f, 8.95754155e-03f,
  -4.17179279e-02f, -1.64232135e-01f, -1.97140668e-02f, 8.83423630e-03f, 9.07962099e-02f, -3.35082947e-03f, -3.29034366e-02f, 2.73121730e-03f, -2.67235879e-02f, 2.32520979e-02f,
  7.61980191e-03f, -3.64682749e-02f, 7.44645745e-02f, 3.93597968e-03f, -1.88063662e-02f, -8.58229324e-02f, -1.50375605e-01f, -2.21279748e-02f, -1.28418922e-01f, -9.46827307e-02f,
  -1.96761526e-02f, -4.61685210e-02f, 2.57992242e-02f, 1.73278842e-02f, -4.91478816e-02f, 2.02756119e-03f, 1.53521802e-02f, 3.63145210e-02f, -3.92849147e-02f, -2.44040471e-02f,
  -7.10002109e-02f, 4.17195149e-02f, -2.79566105e-02f, -3.65010276e-02f, 1.35358283e-02f, -8.44656080e-02f, 1.04531124e-02f, -3.91003005e-02f, -6.08907901e-02f, -6.01156708e-03f,
  2.45730039e-02f, -1.05165644e-02f, 1.64028499e-02f, 5.03528789e-02f, 5.99745288e-02f, -3.93163413e-02f, -2.31324006e-02f, -6.49766475e-02f, 7.72903934e-02f, -1.33615369e-02f,
  2.70157587e-02f, 1.29996315e-02f, 1.65165160e-02f, -5.75330518e-02f, 1.99690480e-02f, 4.60624881e-02f, 9.12980735e-03f, -6.24195039e-02f, -8.94282013e-03f, 5.74868955e-02f,
  2.33894214e-01f, 9.65395793e-02f, 4.43830788e-02f, 5.18955197e-03f, 3.28044258e-02f, 8.29860121e-02f, 9.19306725e-02f, -4.61074943e-03f, 3.00501520e-03f, -3.99111249e-02f,
  5.65480404e-02f, 1.29009131e-02f, 4.43951152e-02f, 2.04271376e-02f, 4.73421216e-02f, 6.07706942e-02f, 3.89581546e-02f, 7.98146278e-02f, 1.19811170e-01f, -2.47815140e-02f,
  -2.12782528e-04f, -7.17258304e-02f, 7.64988735e-02f, 5.04953861e-02f, 8.13825652e-02f, -1.25323990e-02f, 2.22903602e-02f, -4.33898196e-02f, -3.28935608e-02f, 2.22036336e-02f,
  3.70923042e-01f, -3.33434701e-01f, 3.41657579e-01f, 1.12905450e-01f, -9.50025693e-02f, 1.92872807e-01f, 1.70286924e-01f, -1.92104429e-01f, -6.52006716e-02f, -3.97432029e-01f,
  -2.35834822e-01f, 6.89444914e-02f, -2.44766548e-01f, -1.83406904e-01f, 4.39891249e-01f, -1.71578959e-01f, 2.08632290e-01f, -6.01891167e-02f, -4.95048538e-02f, -4.79167625e-02f,
  3.19487154e-02f, -1.78212151e-01f, 1.15305081e-01f, -1.31601289e-01f, 2.07184888e-02f, 1.83964834e-01f, -7.76905473e-03f, 1.52958930e-01f, 8.28641504e-02f, 9.23732109e-03f,
  -1.22787856e-01f, -1.92909196e-01f, -1.17375199e-02f, -3.48992385e-02f, -1.01108002e-02f, 1.44466385e-02f, 7.52532855e-02f, 9.65707302e-02f, 5.24741262e-02f, -1.63726509e-02f,
  -1.91724803e-02f, -5.97842708e-02f, -4.12198715e-02f, -4.50255146e-04f, -1.85088050e-02f, -7.80066242e-03f, -1.02391519e-01f, -2.26893928e-02f, 3.81751778e-03f, -3.52259725e-02f,
  -3.81050892e-02f, -5.54037094e-02f, 5.05476631e-02f, -3.11321262e-02f, 1.56419635e-01f, -8.28964694e-04f, 4.49760184e-02f, 1.07003383e-01f, 4.24814820e-02f, -5.48393913e-02f,
  -3.43614407e-02f, -7.25817978e-02f, -7.03704283e-02f, -8.46323967e-02f, -1.98074467e-02f, -4.40413356e-02f, -3.02788708e-02f, -6.19223304e-02f, 6.12581782e-02f, 5.50770620e-03f,
  -6.44207420e-03f, 2.27251500e-02f, -9.14796963e-02f, 6.56864420e-02f, 1.44237382e-02f, -4.18939330e-02f, 7.05437586e-02f, -1.79295335e-02f, -1.46393012e-02f, -1.45981843e-02f,
  1.12197567e-02f, 2.98057832e-02f, -2.84765717e-02f, 5.24125211e-02f, 8.52371380e-03f, 4.25376445e-02f, -3.88690531e-02f, 2.50137839e-02f, 2.13354547e-02f, 8.96917284e-02f,
  9.76746455e-02f, -3.07909194e-02f, -1.23315090e-02f, -3.75336818e-02f, 2.13097800e-02f, -3.58681902e-02f, 4.97409068e-02f, -8.39957222e-03f, 2.46421136e-02f, -2.04000659e-02f,
  -2.44028959e-02f, 2.66298349e-03f, 3.47782746e-02f, 3.23117338e-02f, 3.31367627e-02f, -2.02360824e-02f, 2.98652984e-02f, 9.19160433e-03f, 9.68487412e-02f, -3.55602168e-02f,
  -2.93073934e-02f, -3.35884690e-02f, -1.03183081e-02f, 1.18093751e-02f, -6.16925806e-02f, 4.78572503e-04f, 1.18352607e-01f, 4.17282991e-03f, 2.65234783e-02f, 1.22045716e-02f,
  -6.75854862e-01f, 1.75195888e-01f, 1.97839677e-01f, -3.64981800e-01f, -2.18620598e-01f, 1.86781794e-01f, 1.61347687e-01f, -2.02525228e-01f, -1.63207293e-01f, 1.61007538e-01f,
  8.86829849e-03f, -1.00211829e-01f, 3.77677351e-01f, -2.61172444e-01f, -8.94481018e-02f, 2.51886785e-01f, -2.53209770e-01f, -3.09956856e-02f, -7.01308772e-02f, -2.25397676e-01f,
  -8.41923356e-02f, -1.92396358e-01f, -4.86460999e-02f, -7.38979364e-03f, -2.30702311e-01f, -1.11332685e-01f, -1.16716295e-01f, 1.62622169e-01f, -1.04084827e-01f, -2.66415421e-02f,
  -8.36297497e-02f, -1.68348506e-01f, -9.04798359e-02f, 4.70731221e-02f, -7.83651769e-02f, 3.94772664e-02f, -5.77635057e-02f, 8.12098905e-02f, 3.71228973e-03f, -1.62092801e-02f,
  8.14427510e-02f, -6.80305585e-02f, -7.17835054e-02f, 1.04576267e-01f, -1.81736574e-02f, 3.26201469e-02f, -2.28559710e-02f, -2.85223629e-02f, -4.92552156e-03f, -6.60002381e-02f,
  9.59810764e-02f, -3.78754288e-02f, -1.39791034e-02f, 6.81604743e-02f, 5.00807650e-02f, 8.59114677e-02f, -4.80364598e-02f, 1.15752101e-01f, -2.32758354e-02f, -4.56338674e-02f,
  4.50389972e-03f, -3.67987193e-02f, -3.14336200e-03f, -2.54419371e-02f, 4.16687988e-02f, -4.07061018e-02f, 7.74628995e-03f, -5.38045019e-02f, 1.40506644e-02f, -3.34412940e-02f,
  -7.73321241e-02f, -6.74620122e-02f, -2.12730303e-01f, -3.68392305e-03f, 1.40680233e-02f, -1.68157425e-02f, 2.66233794e-02f, -8.11763033e-02f, -8.10925439e-02f, -3.79272625e-02f,
  3.97433825e-02f, 3.85994799e-02f, -6.37725834e-03f, -5.38182072e-02f, -2.45515760e-02f, -1.70553811e-02f, -4.60431799e-02f, -1.79731213e-02f, -1.88617725e-02f, 4.52578515e-02f,
  1.51436618e-02f, -5.43667525e-02f, 3.77416541e-03f, 8.13792925e-03f, -2.07253173e-02f, -8.64668842e-03f, -4.33796681e-02f, -4.25579250e-02f, 1.32411838e-01f, -5.23468014e-03f,
  3.95351425e-02f, -8.46014619e-02f, -1.41072003e-02f, -4.87283990e-02f, 1.97451990e-02f, -2.83802096e-02f, 8.02984461e-04f, 1.49568878e-02f, -1.38358567e-02f, -5.07912859e-02f,
  5.14391949e-03f, 4.28706110e-02f, 8.76193643e-02f, -7.88768157e-02f, -7.57270074e-03f, 3.06669553e-03f, -5.93402535e-02f, 6.82243519e-03f, 2.43767053e-02f, 4.44114814e-03f,
  1.88472033e-01f, -5.07139444e-01f, 4.41306308e-02f, -1.92415658e-02f, 4.87597167e-01f, -4.05989066e-02f, -9.09732431e-02f, 9.49090049e-02f, -2.17265874e-01f, -3.40338200e-01f,
  4.06663716e-02f, 6.73840344e-02f, -8.54223594e-02f, -2.54072875e-01f, 2.99856424e-01f, -3.68600547e-01f, -2.42094491e-02f, -2.01768614e-02f, -6.21313043e-02f, 2.18170166e-01f,
  1.72305748e-01f, 1.80462867e-01f, 2.35826969e-01f, 2.21795410e-01f, 1.33817241e-01f, 1.07224688e-01f, 2.12608546e-01f, 1.11746050e-01f, 1.21018328e-01f, 1.11115612e-01f,
  -1.03147276e-01f, -1.23358697e-01f, 3.29029933e-02f, -5.41928709e-02f, 1.17713846e-01f, 1.18499644e-01f, 3.38438749e-02f, 6.27043098e-02f, 9.58579630e-02f, -5.51769603e-03f,
  -3.93690988e-02f, 6.12176657e-02f, 3.61752436e-02f, 1.29543077e-02f, 3.28486860e-02f, 1.54002598e-02f, 2.65009776e-02f, -1.44856684e-02f, 2.09330255e-03f, 1.69529561e-02f,
  1.23948967e-02f, 6.41995389e-03f, 1.95317362e-02f, -2.45372877e-02f, 6.44771755e-02f, -4.13618870e-02f, 6.93645445e-04f, 1.87046528e-01f, -3.12793851e-02f, 5.80959208e-02f,
  -1.68490522e-02f, 5.94726540e-02f, 7.93503970e-02f, -6.68670386e-02f, 1.16235567e-02f, -2.85098571e-02f, -1.03805825e-01f, 5.28439991e-02f, 1.34562319e-02f, -3.54139805e-02f,
  -3.45511101e-02f, 3.95889096e-02f, -1.48505000e-02f, 3.74945439e-02f, 2.99111251e-02f, 3.28204148e-02f, 4.69180085e-02f, 2.66926493e-02f, 1.89536270e-02f, 1.10619396e-01f,
  -6.79906234e-02f, 1.66913792e-02f, 2.30277404e-02f, 3.33069861e-02f, -1.14622764e-01f, 7.41390660e-02f, -3.70168649e-02f, -5.58437593e-02f, 9.06987339e-02f, 8.03342462e-02f,
  -1.42799169e-01f, -7.11252913e-02f, -1.37147298e-02f, 5.14829941e-02f, -8.52301866e-02f, -2.23731939e-02f, -5.26713505e-02f, -3.01738121e-02f, -3.20224240e-02f, -1.68477967e-02f,
  1.11472838e-01f, 8.68927464e-02f, -1.05366424e-01f, 5.10650165e-02f, -4.42507826e-02f, -6.21388741e-02f, -3.10949469e-03f, 4.40748632e-02f, 1.15825951e-01f, 3.40580679e-02f,
  5.12920842e-02f, 9.20226574e-02f, 1.17272912e-02f, 9.96148586e-02f, 9.22295675e-02f, -5.03522828e-02f, 6.69416413e-02f, -6.89506233e-02f, 1.02921277e-01f, -1.01466142e-01f,
  4.71749514e-01f, -3.61216992e-01f, -2.98319552e-02f, 2.42550895e-02f, 3.01255494e-01f, 3.67585778e-01f, 2.38203302e-01f, 8.80895182e-02f, 3.60979401e-02f, -3.53577971e-01f,
  -6.31968528e-02f, -1.91481858e-01f, -1.72392026e-01f, 3.55569869e-02f, 4.55366105e-01f, -6.59137815e-02f, 2.26841792e-01f, 6.47561923e-02f, 1.09773790e-02f, 4.35617380e-02f,
  1.06974915e-01f, 5.09087741e-02f, 2.79613435e-02f, -3.06783970e-02f, 1.36018038e-01f, -7.91778043e-02f, 1.68159846e-02f, -7.71897286e-02f, -3.81814353e-02f, 7.94182420e-02f,
  1.20430931e-01f, -1.68299034e-01f, -8.72077979e-03f, -4.76167277e-02f, 4.52657603e-02f, -1.61614064e-02f, -2.60527115e-02f, 2.27375720e-02f, 4.59939390e-02f, 7.22739752e-03f,
  -1.10500753e-02f, 5.62113523e-02f, 2.31418628e-02f, -8.12495686e-03f, 2.62525175e-02f, -3.52858426e-03f, 3.34525928e-02f, 4.15168144e-02f, -6.59922585e-02f, 6.05886132e-02f,
  -6.03687018e-03f, 7.77594699e-03f, 4.41720523e-02f, -1.14195399e-01f, 2.59433966e-03f, -2.72176694e-02f, 8.40937719e-03f, -1.91950728e-03f, 2.28947531e-02f, 9.27435514e-03f,
  -1.65814850e-02f, -6.10446278e-03f, 2.88414564e-02f, -2.49322271e-04f, 3.06121819e-02f, 1.26671344e-02f, 4.20580246e-02f, -6.17855936e-02f, -3.30322087e-02f, -1.35077187e-03f,
  -1.55753782e-02f, -1.56111373e-02f, -2.63035949e-03f, 6.04011267e-02f, -3.71385291e-02f, -2.41733305e-02f, 1.07128418e-03f, -3.45359556e-02f, -4.84904423e-02f, 7.24321008e-02f,
  1.20496470e-02f, 3.94233875e-02f, -5.99726029e-02f, -1.00901201e-02f, 3.15437652e-02f, 1.21681364e-02f, -6.86185956e-02f, 6.30332856e-04f, -6.84983097e-03f, 4.50506844e-02f,
  -3.58602852e-02f, -2.11164057e-01f, -7.69175440e-02f, -1.87716931e-02f, -1.03002824e-01f, -2.60074786e-03f, 1.26473326e-02f, 9.41815227e-02f, -1.40499147e-02f, -4.56076581e-04f,
  3.50402370e-02f, -2.82507930e-02f, 1.88938677e-02f, 1.75186470e-02f, 7.54325651e-03f, 8.11426248e-03f, -7.09653050e-02f, -2.97738574e-02f, 4.55730781e-02f, -5.87233193e-02f,
  2.03044116e-02f, -2.66068545e-03f, 3.23715396e-02f, 3.78280692e-02f, -9.40142665e-03f, -9.18090343e-03f, 4.65419702e-02f, 1.90020688e-02f, -1.83065294e-03f, -1.35252178e-02f,
  4.69984025e-01f, -2.17066973e-01f, -5.68610653e-02f, 1.29107445e-01f, -3.54277194e-02f, 5.71204461e-02f, 2.03727737e-01f, 1.56862531e-02f, 1.04746215e-01f, -4.35659289e-02f,
  2.46838659e-01f, -1.31549701e-01f, 1.57885015e-01f, 1.25314772e-01f, 3.30362827e-01f, 1.99711233e-01f, 2.65241861e-01f, 5.34167662e-02f, -8.24295133e-02f, 7.01660365e-02f,
  5.14071360e-02f, 1.28889337e-01f, 2.28686556e-01f, -2.34794915e-01f, -9.78283118e-04f, -1.37418240e-01f, 2.00523317e-01f, -2.56524086e-01f, -1.27076404e-02f, -2.96270065e-02f,
  -1.41935498e-01f, 2.19211504e-02f, -1.10837836e-02f, -1.23483263e-01f, 1.11086711e-01f, 1.06591033e-03f, -3.61680686e-02f, -6.43513799e-02f, 4.03546393e-02f, -6.21852800e-02f,
  -3.18215974e-02f, -7.80346841e-02f, -6.53571561e-02f, -1.09933568e-02f, -1.13607030e-02f, -9.37631056e-02f, 2.11732164e-02f, 3.44170183e-02f, -9.22506973e-02f, 1.30189713e-02f,
  -1.61136291e-03f, -5.16169742e-02f, 2.45357808e-02f, 4.18192558e-02f, 4.16307990e-03f, -4.78522368e-02f, -3.36471805e-03f, -4.85857651e-02f, 1.03499191e-02f, 6.79434314e-02f,
  1.12980068e-01f, -2.96213124e-02f, 1.68987755e-02f, -4.27369922e-02f, -3.57979126e-02f, -8.51572677e-02f, -1.58463586e-02f, -1.17340563e-02f, -3.25147174e-02f, 4.80239242e-02f,
  1.34470500e-02f, -4.33202051e-02f, 2.17669252e-02f, -7.34238769e-04f, 4.90136296e-02f, 1.17174797e-02f, 4.79908772e-02f, -3.36815715e-02f, 2.74337493e-02f, 4.21700515e-02f,
  -9.36775580e-02f, 3.97565253e-02f, -5.45080472e-03f, -2.25937590e-02f, -3.88277881e-02f, -2.22972725e-02f, -3.41364853e-02f, 2.91892178e-02f, -8.02487228e-03f, 1.21543653e-01f,
  2.31996074e-01f, 3.53177696e-01f, 6.94810459e-03f, -4.86365855e-02f, -1.23784035e-01f, 3.48943435e-02f, 3.76182119e-03f, -8.92285164e-03f, 6.82109641e-03f, 5.08538708e-02f,
  5.47998585e-03f, 3.62522118e-02f, 6.84352815e-02f, -3.84990945e-02f, -1.00528114e-01f, 1.16031118e-01f, 7.61124045e-02f, -9.11762193e-03f, 6.79689497e-02f, -4.29665819e-02f,
  -3.26730050e-02f, -7.86861032e-03f, -3.10648512e-02f, -2.28313953e-02f, 1.34226559e-02f, 4.87292148e-02f, 1.24255084e-01f, -5.21519445e-02f, 5.29865138e-02f, -5.26084565e-02f,
  3.10930926e-02f, -2.39835128e-01f, 3.38607609e-01f, -5.52179776e-02f, -1.76665366e-01f, -1.16127275e-01f, -1.66447595e-01f, -2.24127695e-01f, -2.78243542e-01f, -2.52972960e-01f,
  -2.73610324e-01f, 4.09082361e-02f, -1.30671024e-01f, -4.02354747e-01f, 3.63080353e-01f, -1.51751608e-01f, -4.94932011e-02f, -6.59977794e-02f, -1.82355866e-01f, -4.00285460e-02f,
  7.49183213e-03f, -2.67074049e-01f, 7.79571235e-02f, -1.43250525e-01f, -1.01140983e-01f, 1.70606092e-01f, 3.34505945e-01f, 5.69737591e-02f, 1.41081244e-01f, 3.67596373e-02f,
  -2.14157984e-01f, -2.84562349e-01f, -1.61571205e-02f, 7.21009076e-02f, 4.98675220e-02f, 4.63082939e-02f, 1.72343969e-01f, 1.16738036e-01f, -4.00468707e-02f, -2.44159084e-02f,
  2.08715592e-02f, -7.30935484e-02f, -6.69511408e-02f, -1.27936266e-02f, -3.70596573e-02f, 4.91458848e-02f, 4.79071587e-03f, -2.76356265e-02f, -9.24180225e-02f, 5.14735561e-03f,
  -4.05782312e-02f, -3.47879194e-02f, 4.66171699e-03f, 7.22304732e-02f, 6.08690158e-02f, -2.14975309e-02f, 7.96474442e-02f, 1.18279830e-01f, 5.92666082e-02f, 1.02418996e-02f,
  -2.90994812e-02f, 6.33792356e-02f, -2.49094218e-02f, -1.01103805e-01f, 1.99051667e-02f, -6.81831455e-03f, -4.71581221e-02f, -2.87999511e-02f, 1.45538365e-02f, 4.15252196e-03f,
  -1.82138365e-02f, -2.56748833e-02f, -7.06395060e-02f, 1.20994644e-02f, -1.15552805e-02f, -4.75320555e-02f, 3.78912911e-02f, -3.97424661e-02f, -5.28603867e-02f, -4.83018458e-02f,
  -7.00925663e-02f, 3.60648297e-02f, -2.23458279e-02f, -2.62159808e-03f, -7.71469399e-02f, 3.69615890e-02f, -8.80912878e-03f, 3.80213037e-02f, -3.04796137e-02f, 5.65243438e-02f,
  7.98619390e-02f, 2.94696867e-01f, -7.93614015e-02f, -8.87161344e-02f, 3.56437936e-02f, -2.65935110e-03f, -6.73105642e-02f, 8.51988967e-04f, 1.25188366e-01f, -8.09805691e-02f,
  4.52409238e-02f, 3.55807841e-02f, 9.32581350e-02f, -9.34327394e-03f, 5.72249256e-02f, 6.57044956e-03f, 4.94224019e-02f, 1.00941435e-01f, 1.39769375e-01f, 2.14775316e-02f,
  3.13327424e-02f, 2.88793314e-02f, 1.96356070e-03f, 3.61602195e-03f, 1.68471057e-02f, -5.32861939e-03f, 3.74049358e-02f, 2.10388657e-02f, 4.52394746e-02f, 2.61048228e-03f,
  -1.86886445e-01f, 1.24009311e-01f, -3.15339476e-01f, 2.55370364e-02f, -4.67442684e-02f, -4.42110449e-02f, -9.79352966e-02f, -2.87880674e-02f, -4.05795217e-01f, 1.26347154e-01f,
  2.36063123e-01f, -9.39114839e-02f, 6.40579686e-02f, 2.88714379e-01f, -1.65265258e-02f, -2.53509246e-02f, 1.73209414e-01f, 1.59603164e-01f, 1.96546055e-02f, 9.10756513e-02f,
  1.92265920e-02f, 3.12812001e-01f, 1.77083090e-01f, 3.06404859e-01f, 1.27445951e-01f, -5.34343310e-02f, 2.45359018e-01f, 5.60354330e-02f, 2.42499903e-01f, 7.33297085e-03f,
  2.40171496e-02f, -6.41263053e-02f, 4.19938341e-02f, -8.73313025e-02f, -7.09234038e-03f, 2.54399236e-02f, 1.83127802e-02f, 9.53662768e-03f, -1.09844603e-01f, -4.72364612e-02f,
  -5.90054393e-02f, -8.72720033e-02f, -8.26504268e-03f, -1.13587528e-01f, -4.57795002e-02f, -7.15024695e-02f, -8.56945105e-03f, 2.38015298e-02f, -1.42797362e-02f, -4.24975902e-02f,
  -7.50368312e-02f, -4.83264178e-02f, -3.17916907e-02f, -5.55241890e-02f, -8.65717158e-02f, -4.50846218e-02f, -9.33149308e-02f, -2.41770837e-02f, 8.38643685e-03f, 1.78175326e-02f,
  8.36661533e-02f, -9.84793412e-04f, -4.88272728e-03f, 1.41695365e-02f, -2.58399714e-02f, -5.31718396e-02f, 2.27413494e-02f, 4.88012619e-02f, -9.46849808e-02f, -3.78117524e-02f,
  2.20469441e-02f, 2.11576112e-02f, -4.87125777e-02f, -1.00252263e-01f, 4.80309501e-02f, -1.17692007e-02f, -3.11461836e-02f, -4.28838022e-02f, 1.30850365e-02f, 6.56724200e-02f,
  -3.48651111e-02f, -2.98223551e-02f, 6.51238188e-02f, -1.55389123e-02f, -8.17604586e-02f, -5.25970049e-02f, -2.54333504e-02f, -1.06848225e-01f, -1.25236604e-02f, 7.86476061e-02f,
  1.01385787e-01f, 1.89012259e-01f, 2.58498341e-02f, -2.91981660e-02f, 1.85397901e-02f, 4.35626991e-02f, 3.37745855e-03f, -4.64096293e-03f, 6.20886758e-02f, 5.65412408e-03f,
  2.02841647e-02f, -2.15633065e-02f, -1.78655759e-02f, 3.86959151e-03f, 1.98168680e-02f, -4.71924141e-04f, -4.83980067e-02f, -6.13043383e-02f, 8.06005150e-02f, 1.18218444e-01f,
  -1.59973849e-03f, -5.89790456e-02f, -3.22577879e-02f, 2.62117218e-02f, 2.82454696e-02f, 5.70297800e-03f, -1.37963658e-02f, -5.58274286e-03f, 3.56582887e-02f, 1.74345020e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.94786566e-01f, -3.56379390e-01f, -5.68432748e-01f, -2.17790380e-01f, 3.99820924e-01f, 5.88243067e-01f, -1.89787462e-01f, 1.53648620e-03f, -4.64548141e-01f, 1.00964628e-01f,
  7.71371797e-02f, -2.02624664e-01f, -5.83685577e-01f, 2.81888753e-01f, 1.27705216e-01f, -5.22616863e-01f, 2.49765530e-01f, 1.83239147e-01f, -2.54218727e-01f, 5.64775802e-02f,
  -1.53156845e-02f, 5.76596797e-01f, -4.10946161e-01f, 4.52303618e-01f, 4.44968611e-01f, -7.78069198e-02f, 1.80835724e-01f, -3.27973396e-01f, 3.75868291e-01f, 2.74225682e-01f,
  7.85328448e-02f, -1.19606428e-01f, 2.85940133e-02f, 4.70697619e-02f, 9.11279023e-03f, 1.61248371e-01f, 3.50878090e-02f, -2.20029727e-02f, -1.34972557e-01f, -1.36390954e-01f,
  8.49933401e-02f, 4.20365371e-02f, 1.34335175e-01f, -1.08670361e-01f, 1.83334768e-01f, 4.40425910e-02f, -3.89111228e-02f, -7.20913187e-02f, -9.14599225e-02f, -3.73187289e-02f,
  -2.20013022e-01f, 1.35939037e-02f, -3.58623862e-02f, -7.54123852e-02f, -8.27642083e-02f, -1.09784156e-02f, -9.77898482e-04f, -6.72373027e-02f, 1.22043528e-01f, 1.23047411e-01f,
  1.61873385e-01f, 3.69885042e-02f, 2.70693377e-02f, 3.40713263e-02f, 6.37751967e-02f, 1.78898238e-02f, 7.17937723e-02f, 1.00022964e-01f, -5.82759492e-02f, 8.50407779e-02f,
  8.13552830e-03f, -2.18940116e-02f, 9.35482047e-03f, 1.09903783e-01f, 1.34191409e-01f, 4.17599604e-02f, -1.34082111e-02f, 3.74381654e-02f, -1.52840987e-01f, 2.82542203e-02f,
  -4.61895242e-02f, 8.30247924e-02f, -1.92661565e-02f, -2.28918158e-03f, 4.27719615e-02f, -1.19799085e-01f, 1.61316767e-01f, 1.72918066e-02f, -1.58398837e-01f, 7.72463670e-03f,
  2.34877318e-02f, 5.45234233e-02f, -9.56341699e-02f, 9.12240334e-03f, -1.58666633e-03f, 2.33473599e-01f, 4.42579994e-03f, 1.06057130e-01f, -3.34271155e-02f, 5.66736832e-02f,
  9.28027183e-02f, -5.41710444e-02f, 1.62992135e-01f, -1.86721664e-02f, 9.18614957e-03f, 1.40598156e-02f, 7.09272549e-02f, -1.44132751e-03f, 1.26485690e-01f, 8.15767646e-02f,
  3.63010466e-02f, 5.37159573e-03f, 5.66606522e-02f, 5.73701374e-02f, 1.43209994e-01f, -3.44080222e-03f, 1.73634917e-01f, -1.30149052e-01f, 6.90113157e-02f, -7.69643113e-02f,
  1.99009106e-01f, -6.28869712e-01f, -2.26822212e-01f, 4.70371880e-02f, -2.63682365e-01f, -1.55631796e-01f, 5.12574255e-01f, -4.55802292e-01f, -2.11325675e-01f, -5.38828224e-02f,
  2.41403610e-01f, 2.06008166e-01f, 4.19383645e-01f, 1.31742105e-01f, 6.42697334e-01f, 4.31632996e-01f, 5.59960604e-02f, 3.24485868e-01f, -1.80236727e-01f, -9.11544263e-02f,
  -4.43371758e-02f, -2.82512549e-02f, 1.56635866e-01f, -5.08979678e-01f, -2.86574870e-01f, -4.38427269e-01f, 1.71467125e-01f, -6.48945197e-02f, -1.97039634e-01f, 2.91222662e-01f,
  -5.91155738e-02f, -1.18784800e-01f, -2.97368653e-02f, -1.13453642e-01f, -1.49695188e-01f, -6.17800876e-02f, 1.51208550e-01f, 2.80508459e-01f, 9.90489647e-02f, -4.83293086e-02f,
  9.06131789e-02f, -6.31823987e-02f, -1.40566260e-01f, 1.92274936e-02f, -8.55654255e-02f, -1.67445809e-01f, -1.18534572e-01f, 5.87528087e-02f, -4.31600101e-02f, 3.18711586e-02f,
  -4.10807729e-02f, -4.42768522e-02f, -9.61738266e-03f, 5.36829419e-02f, -6.43497407e-02f, -1.15501732e-01f, 4.91306074e-02f, 4.25090194e-02f, -6.05915971e-02f, -8.21085274e-02f,
  -1.21887904e-02f, 8.77060220e-02f, -7.56241828e-02f, 5.09482212e-02f, -5.39273322e-02f, 9.10752278e-04f, 5.82058653e-02f, 1.38163015e-01f, -2.51905378e-02f, 6.71450607e-03f,
  -3.17751914e-02f, 1.81330834e-02f, -9.82601270e-02f, -5.45363091e-02f, 2.06216741e-02f, 6.91659302e-02f, 1.65447026e-01f, -9.68831927e-02f, -1.06797285e-01f, -8.13308917e-03f,
  1.20925382e-01f, -3.58547084e-02f, -2.51695421e-03f, 1.07073002e-01f, 1.37452334e-02f, 1.21096253e-01f, -7.59075209e-02f, -3.89177352e-02f, -3.61742303e-02f, 1.23041503e-01f,
  -6.58634827e-02f, -2.85636216e-01f, -3.23574580e-02f, -5.09461090e-02f, 5.00598699e-02f, -1.88129067e-01f, 5.67764118e-02f, -1.30830020e-01f, -6.66803718e-02f, -7.04734176e-02f,
  -6.66422471e-02f, 8.40956718e-02f, -1.82553902e-01f, 1.38290236e-02f, 1.91506241e-02f, -7.92775750e-02f, 1.03099607e-01f, 1.63967516e-02f, 9.08085108e-02f, -1.33205563e-01f,
  2.10716780e-02f, -4.69570979e-02f, 1.26113534e-01f, -1.52983427e-01f, 5.36027066e-02f, 1.03159167e-01f, -1.25580847e-01f, -9.02004465e-02f, -1.76675599e-02f, 4.25380218e-04f,
  2.09977821e-01f, -3.44019324e-01f, 4.04072285e-01f, -5.00826180e-01f, 2.49262303e-01f, 1.99688718e-01f, 1.45632267e-01f, -2.69813985e-01f, -3.16413790e-01f, -5.72213829e-01f,
  -3.10332865e-01f, -1.08388565e-01f, 2.45105788e-01f, -4.96892363e-01f, 7.61359692e-01f, 1.82814062e-01f, -2.91351408e-01f, -4.35047120e-01f, 4.89913896e-02f, -4.40562189e-01f,
  -9.48468596e-02f, -4.31722641e-01f, 2.83548713e-01f, -3.57260793e-01f, -2.01525763e-01f, -3.04244518e-01f, -2.22486630e-01f, 1.33292034e-01f, -4.32044774e-01f, 1.40010893e-01f,
  9.03846473e-02f, -1.66771695e-01f, 2.19605699e-01f, 4.17626835e-02f, 1.07132673e-01f, 9.61011425e-02f, -4.60471809e-02f, 1.27164781e-01f, 4.69940938e-02f, 2.86548752e-02f,
  -8.29089582e-02f, 7.58748949e-02f, -1.70834526e-01f, 2.83752289e-02f, -3.34002264e-02f, -9.84251872e-02f, 8.59514475e-02f, 7.20883384e-02f, -1.46608427e-02f, 1.74754441e-01f,
  4.73296344e-02f, 7.52401799e-02f, 4.70092222e-02f, -1.13414764e-01f, 6.47684187e-02f, -9.54860374e-02f, 4.94504254e-03f, 1.22389577e-01f, -4.76141497e-02f, 3.83873098e-02f,
  -1.33279160e-01f, 7.00796908e-03f, 9.26770344e-02f, 5.73336659e-03f, 9.40171108e-02f, -2.38838326e-02f, -7.37439841e-02f, 5.74426726e-02f, -1.20200794e-02f, 7.21912980e-02f,
  -6.14369214e-02f, 4.01281491e-02f, -3.73182842e-03f, -8.70112181e-02f, -3.65880318e-02f, -2.86857449e-02f, -9.74847295e-04f, -1.14466578e-01f, 2.51706019e-02f, -2.29744352e-02f,
  -6.98547140e-02f, -9.00815502e-02f, 9.61448550e-02f, -8.08119625e-02f, -4.72513121e-03f, 6.96353689e-02f, -1.31623849e-01f, 8.58122706e-02f, 5.94830774e-02f, 3.62647176e-02f,
  -5.50395586e-02f, -4.39542383e-01f, -4.59521124e-03f, -7.77613595e-02f, -1.31430607e-02f, 2.09381998e-01f, 4.72248569e-02f, -1.34980202e-01f, -3.10884975e-02f, -2.08477434e-02f,
  -1.39570743e-01f, -1.18677117e-01f, 7.13585643e-04f, -9.90225654e-03f, -9.81535390e-02f, 8.39238241e-02f, -1.95044637e-01f, -1.52057514e-01f, -5.99662140e-02f, -1.26163423e-01f,
  -1.44218802e-01f, -1.58489645e-01f, 6.61211908e-02f, -1.26404956e-01f, -2.37486109e-01f, -6.47856481e-03f, -7.42704142e-03f, -1.20847687e-01f, -2.47376189e-02f, 2.94332094e-02f,
  2.50245273e-01f, 3.16902906e-01f, -2.14942530e-01f, 3.52223217e-01f, 1.70775235e-01f, 2.54611224e-01f, -1.24668367e-01f, 1.92813069e-01f, -3.25407460e-02f, -2.69508719e-01f,
  -3.67526487e-02f, -9.45579335e-02f, -3.87100726e-01f, 3.91437113e-01f, 4.61366445e-01f, -6.49843737e-02f, 4.74284023e-01f, 1.90964267e-01f, 2.19562933e-01f, 2.71679878e-01f,
  2.71520555e-01f, 5.77191055e-01f, 1.23599514e-01f, 3.77625257e-01f, 2.38592580e-01f, 1.12600297e-01f, 1.50029331e-01f, -1.03927448e-01f, 2.33267650e-01f, 3.10600191e-01f,
  6.58191219e-02f, 9.06279162e-02f, -3.32191996e-02f, -1.17221195e-02f, -1.63297709e-02f, -9.43389982e-02f, -1.20879054e-01f, -6.19028695e-02f, -6.34652153e-02f, -5.82024157e-02f,
  -1.40808538e-01f, 3.90702561e-02f, 1.73141763e-01f, 3.42751183e-02f, 9.11405832e-02f, -1.52744334e-02f, -4.62854989e-02f, -7.33287036e-02f, -1.08527720e-01f, 1.42715564e-02f,
  -2.03161892e-02f, 2.61142454e-03f, 7.17652515e-02f, 9.42835882e-02f, 1.17070280e-01f, 7.95118138e-02f, -1.24424294e-01f, -7.33733326e-02f, 1.39557431e-02f, 1.49882793e-01f,
  1.18854091e-01f, -1.32182827e-02f, -8.94377287e-03f, -8.39806069e-03f, 1.00070916e-01f, 1.34161547e-01f, 2.20576916e-02f, -8.02189261e-02f, -2.80411076e-02f, -2.42826976e-02f,
  -3.60478833e-02f, 3.35287414e-02f, 7.22078755e-02f, -9.84516218e-02f, 7.83932805e-02f, -3.58980359e-03f, -5.64093478e-02f, -9.73659903e-02f, -1.45188291e-02f, -1.01843514e-01f,
  -1.69469118e-02f, 1.22353986e-01f, 8.13104957e-03f, -8.01308826e-02f, 1.02475323e-01f, -2.57110335e-02f, -4.73821312e-02f, -5.27768992e-02f, -1.05468504e-01f, -2.02448945e-02f,
  2.14044616e-01f, 4.34829473e-01f, 8.14544130e-03f, 6.40859362e-03f, 3.48649658e-02f, 7.39060864e-02f, 8.01621452e-02f, 1.15737759e-01f, 2.43057281e-01f, 4.43890505e-02f,
  -6.45706356e-02f, -1.01577602e-01f, -3.71992737e-02f, 2.58517079e-02f, 3.03491559e-02f, 8.89418274e-02f, -8.33566859e-02f, 5.24538867e-02f, 1.25157610e-01f, 1.02415733e-01f,
  -1.13373036e-02f, -1.53896203e-02f, -3.22370615e-05f, 5.54011725e-02f, -1.00711156e-02f, -3.07470039e-02f, 8.20909515e-02f, -4.89912331e-02f, -4.65317164e-03f, 3.21163125e-02f,
  3.48299980e-01f, 8.26081574e-01f, 3.29327017e-01f, 4.43794698e-01f, -4.33502227e-01f, 2.54986465e-01f, 3.31236929e-01f, 3.45796272e-02f, 2.56577075e-01f, 3.73196751e-01f,
  -3.82633090e-01f, 6.04767382e-01f, -1.77505910e-01f, 3.26048017e-01f, -2.65420020e-01f, -4.76911142e-02f, 3.09922189e-01f, 2.93073028e-01f, -5.92196509e-02f, 2.37480253e-01f,
  -7.75630698e-02f, -1.55861765e-01f, -1.17417745e-01f, -2.12611362e-01f, 1.57599568e-01f, 2.18513340e-01f, -4.12240237e-01f, -1.46246687e-01f, 1.53128102e-01f, -1.63292155e-01f,
  3.58187258e-02f, 6.07955791e-02f, 1.51760176e-01f, 8.37617368e-02f, 1.99312530e-02f, 7.06887767e-02f, 9.39941481e-02f, -5.76647781e-02f, -1.33537829e-01f, 8.92262086e-02f,
  1.01627111e-01f, -3.44141275e-02f, 9.09773186e-02f, -3.27305198e-02f, 1.09677419e-01f, 6.53419048e-02f, -2.24415325e-02f, -1.17350342e-02f, 1.28031462e-01f, -4.84656775e-03f,
  1.55423433e-01f, 8.27972963e-02f, -2.49012262e-02f, 2.63135340e-02f, -7.19197765e-02f, 3.85937952e-02f, 8.79051685e-02f, 7.50051513e-02f, 1.68053821e-01f, 1.09743975e-01f,
  5.39117120e-03f, 4.64225672e-02f, 7.63947144e-02f, -1.66812297e-02f, 1.46999024e-02f, -1.47741079e-01f, -1.32744014e-02f, -1.14213265e-01f, 3.02255303e-02f, 1.77403037e-02f,
  -8.97843614e-02f, 3.23222727e-02f, -7.90555999e-02f, 4.44875136e-02f, 3.87720540e-02f, 4.59656753e-02f, -6.28349483e-02f, 2.56231409e-02f, 3.95465605e-02f, -9.26756784e-02f,
  -1.12871677e-01f, -4.05106358e-02f, -3.96050885e-02f, -1.11322731e-01f, 1.94637347e-02f, -9.50697213e-02f, -2.44400743e-02f, 2.02973578e-02f, -3.25568095e-02f, -6.54265732e-02f,
  2.43297756e-01f, 4.98852104e-01f, 1.05766281e-01f, 2.08222941e-02f, 2.39884816e-02f, 5.06121218e-02f, 7.89404958e-02f, 1.28523827e-01f, 3.89768705e-02f, 1.60917398e-02f,
  -3.73652726e-02f, 1.28966533e-02f, -5.48974127e-02f, -4.82816296e-03f, -6.03937469e-02f, 7.19762892e-02f, 1.80787407e-02f, -1.43373040e-02f, 3.04765832e-02f, 3.93979810e-02f,
  3.55562121e-02f, 4.88687381e-02f, 1.60368346e-02f, -2.49179713e-02f, -1.22586954e-02f, -2.15507932e-02f, 2.06539303e-01f, 4.36633825e-02f, -4.97458279e-02f, 3.85212600e-02f,
  -3.76637310e-01f, 1.12267777e-01f, 4.38798010e-01f, -3.04924995e-02f, -3.27739306e-02f, -3.21143031e-01f, -4.85215485e-01f, 4.26227301e-01f, -1.82408825e-01f, -1.85207397e-01f,
  -1.43138126e-01f, -4.01459873e-01f, 2.92477101e-01f, -2.18836427e-01f, 1.34353623e-01f, 6.51545078e-02f, 1.03272356e-01f, -1.57700285e-01f, 2.79767573e-01f, 3.69065762e-01f,
  2.94918001e-01f, -4.65267785e-02f, 5.81229627e-01f, 4.20911074e-01f, 2.64633477e-01f, 2.14771822e-01f, 2.57703900e-01f, 2.05863193e-01f, 3.06700140e-01f, -2.07863718e-01f,
  -2.66987413e-01f, 6.51942566e-02f, 1.15108080e-01f, 6.63825795e-02f, 2.43110165e-01f, -1.13006152e-01f, 8.44294131e-02f, -1.11857980e-01f, -9.11970511e-02f, 3.45624834e-02f,
  -4.97521739e-03f, 1.43962011e-01f, -4.34612893e-02f, 8.24143924e-03f, -4.45924401e-02f, 9.28814039e-02f, 1.22106604e-01f, -1.81392431e-02f, 4.07163166e-02f, 6.16044104e-02f,
  1.65124148e-01f, -1.24816410e-02f, 5.90157323e-02f, -2.22913828e-02f, 1.21458165e-01f, -3.09102852e-02f, -1.03402123e-01f, 3.68767828e-02f, -5.20903766e-02f, -1.07423559e-01f,
  7.71840438e-02f, -2.94492152e-02f, -2.02691350e-02f, -3.41599919e-02f, -1.36467800e-01f, -9.64381099e-02f, -6.50293678e-02f, -6.50755465e-02f, -5.02233468e-02f, -7.39078969e-02f,
  -4.91857231e-02f, -4.75842617e-02f, -4.96669561e-02f, -3.90706845e-02f, -1.04861625e-01f, -1.07976794e-01f, -1.57790113e-04f, 1.32951522e-02f, 7.74712116e-02f, 1.14825606e-01f,
  -1.03619650e-01f, 8.24540947e-03f, -5.49349980e-03f, 3.90585549e-02f, -9.68492627e-02f, 3.29511240e-02f, 1.91052020e-01f, -5.16270921e-02f, -2.93506123e-03f, 1.45230398e-01f,
  7.75739253e-02f, 3.63458484e-01f, 1.01482995e-01f, -2.22704619e-01f, -5.61581738e-03f, -3.54814157e-02f, 6.01901766e-03f, 3.02994084e-02f, 7.11405352e-02f, -3.66317183e-02f,
  1.13599159e-01f, -2.53144652e-02f, -6.33626431e-02f, -1.28020227e-01f, 4.53936420e-02f, -1.90958921e-02f, -9.16663557e-02f, -1.77143433e-03f, 5.90157397e-02f, 2.90603817e-01f,
  9.59148258e-02f, -6.32408634e-02f, 1.13287196e-02f, 1.11722335e-01f, 3.05156223e-02f, -3.29721197e-02f, -7.61918724e-02f, -1.48425279e-02f, 1.60351038e-01f, 2.00189613e-02f,
  -3.63221139e-01f, 2.79684842e-01f, 5.07723331e-01f, 5.10214232e-02f, 3.38706315e-01f, 5.61930418e-01f, 1.78750157e-01f, 5.09881258e-01f, 6.83462679e-01f, -1.52402684e-01f,
  -2.69904673e-01f, -7.35879540e-02f, -1.61263317e-01f, -3.11814211e-02f, -4.17759875e-03f, 8.57608914e-02f, 2.04029158e-01f, -4.11268994e-02f, 3.45670462e-01f, 1.67076141e-01f,
  1.11057974e-01f, -2.01925129e-01f, -2.07808271e-01f, -6.22208975e-02f, -3.29338610e-02f, 2.77257022e-02f, -4.87017274e-01f, 8.89608189e-02f, -3.14029098e-01f, 1.42032474e-01f,
  -7.30774850e-02f, 2.60546133e-02f, -1.84642315e-01f, -5.17592113e-03f, -8.92840885e-03f, 1.08682830e-03f, -1.10963054e-01f, -1.33474246e-02f, 7.57781649e-03f, -1.46262404e-02f,
  -1.63746998e-01f, 7.85037503e-03f, 4.40839529e-02f, -1.76331643e-02f, 1.88280940e-01f, 6.13208152e-02f, 9.03754383e-02f, 1.11766860e-01f, 9.35517102e-02f, 1.29527062e-01f,
  3.27457897e-02f, 8.51466656e-02f, 7.00908825e-02f, 1.90705415e-02f, 2.54401416e-02f, 2.97448765e-02f, 1.27474278e-01f, -4.93333749e-02f, -1.01170719e-01f, 1.99399173e-01f,
  5.63896671e-02f, 1.42337143e-01f, -3.61535214e-02f, -6.71646968e-02f, -2.51242146e-02f, 1.01588266e-02f, -4.74290811e-02f, -6.76134452e-02f, 5.73053909e-03f, -1.15472473e-01f,
  1.49280834e-03f, -1.02607466e-01f, 1.48238689e-01f, 9.20976773e-02f, 3.19458991e-02f, 5.75358458e-02f, -1.64429814e-01f, -5.81801124e-02f, 1.16884977e-01f, -1.83630157e-02f,
  -1.02732312e-02f, -9.50213871e-05f, -1.24147730e-02f, -1.74336452e-02f, 8.56177323e-03f, 1.86676718e-02f, -2.42641494e-02f, 8.36371854e-02f, -2.24790331e-02f, -1.01636171e-01f,
  -1.20863435e-03f, 5.01071140e-02f, -1.15239374e-01f, -1.10022090e-01f, -4.06008735e-02f, -1.07468084e-01f, -1.22236535e-02f, 2.52786116e-03f, -1.35706197e-02f, -3.12305838e-02f,
  1.09110456e-02f, -4.13844585e-02f, -6.45424426e-03f, -6.49251342e-02f, -4.59830426e-02f, -3.27615850e-02f, -3.15350443e-02f, 3.93305235e-02f, -6.05775081e-02f, -4.81357798e-02f,
  -1.14175573e-01f, -6.30539507e-02f, -6.27330914e-02f, -7.13379309e-02f, -1.01820096e-01f, -1.13227338e-01f, -6.66963682e-03f, -2.26256344e-02f, -7.15237111e-02f, 1.36432778e-02f,
  -4.41799134e-01f, -2.31965035e-01f, -4.18289632e-01f, -2.33898908e-01f, 6.07697248e-01f, -1.92293376e-01f, 1.53052792e-01f, 2.26862743e-01f, 1.56624228e-01f, -1.02955848e-02f,
  5.40731475e-03f, -6.79830372e-01f, 7.25796912e-03f, -6.07200503e-01f, -6.10976934e-01f, -5.56063771e-01f, -6.54963076e-01f, -4.55199003e-01f, -8.06126595e-02f, -1.88008308e-01f,
  -1.47128418e-01f, 7.91044608e-02f, -2.69931465e-01f, 4.05688733e-01f, 7.67338425e-02f, 3.73501331e-01f, 1.92446470e-01f, 3.93857211e-01f, -2.14966670e-01f, -3.51851992e-02f,
  1.16046555e-02f, 8.90716240e-02f, 7.55673349e-02f, 1.75715610e-02f, 8.58276933e-02f, 9.00074542e-02f, -9.32589844e-02f, 1.50468294e-02f, 3.71770225e-02f, -4.14204970e-02f,
  3.20159504e-03f, -4.17427160e-02f, -1.48642868e-01f, 3.92010771e-02f, 2.11111322e-01f, -1.42069161e-02f, -1.49888307e-01f, 1.68535847e-03f, 3.46470028e-02f, -2.33764976e-01f,
  -1.07538402e-01f, -1.56184390e-01f, -4.54190560e-02f, -1.41855747e-01f, -6.77402318e-03f, 9.03915763e-02f, -5.49151152e-02f, -1.49020880e-01f, -5.47982454e-02f, 2.60086060e-02f,
  -5.60725406e-02f, 4.17324081e-02f, -7.81209841e-02f, 1.26052648e-01f, 1.62140764e-02f, 8.37841779e-02f, -2.94336933e-03f, 4.92911115e-02f, 1.07616901e-01f, 1.54064652e-02f,
  1.59390513e-02f, 7.72964656e-02f, -1.20738521e-02f, -1.06074279e-02f, -6.79525286e-02f, 4.67460304e-02f, -4.27976996e-02f, -1.75005510e-01f, 2.88443062e-02f, -6.93361536e-02f,
  1.12612218e-01f, 4.09598388e-02f, -3.18826884e-02f, -1.89756472e-02f, 2.01774761e-02f, -2.70180237e-02f, -3.90460379e-02f, -3.01072970e-02f, 5.32621257e-02f, 5.69512974e-03f,
  -5.52960895e-02f, -1.18094206e-01f, 1.52495578e-01f, 9.95389149e-02f, 2.51943455e-03f, 1.25677045e-02f, -1.95366759e-02f, -6.31810576e-02f, 1.06019154e-01f, -4.10302542e-02f,
  4.75716889e-02f, 1.37134388e-01f, -4.24935222e-02f, -1.43600270e-01f, 4.67892103e-02f, -3.89584294e-03f, -2.82739103e-02f, 1.29160777e-01f, 1.29529014e-01f, -4.17485163e-02f,
  9.40643623e-02f, 1.76433586e-02f, 4.26527187e-02f, 2.06505522e-01f, 8.80167075e-03f, 7.94717818e-02f, -2.35437881e-02f, 3.21357027e-02f, -6.89702779e-02f, -1.21739030e-01f,
  1.12905109e+00f, -8.27135667e-02f, 3.86323571e-01f, 5.79744339e-01f, 1.64683327e-01f, -2.20013395e-01f, 4.51957732e-01f, -1.10750653e-01f, 4.58915621e-01f, -3.34847271e-01f,
  -1.25489026e-01f, 2.99596906e-01f, -1.32572010e-01f, 3.32763419e-02f, -3.44136387e-01f, -2.84078270e-01f, 5.14282063e-02f, 1.08208917e-01f, 1.96146637e-01f, 1.58859923e-01f,
  1.26797810e-01f, -4.90702957e-01f, 4.15365733e-02f, -4.20138836e-01f, 3.93968493e-01f, 1.58192873e-01f, -4.04507339e-01f, -9.60609764e-02f, -1.69090807e-01f, -1.88891515e-01f,
  8.81601050e-02f, 2.41122231e-01f, 2.29554012e-01f, -7.23912492e-02f, 4.04974595e-02f, 9.51671749e-02f, -1.13830538e-02f, -4.16824734e-03f, 1.15240820e-01f, 1.12973340e-01f,
  4.23685797e-02f, -1.42494470e-01f, -8.54649171e-02f, -7.13697076e-02f, 1.92608744e-01f, 2.58805286e-02f, 1.25545129e-01f, 1.17177390e-01f, 9.28638950e-02f, 1.43581703e-01f,
  2.56759435e-01f, 1.51533693e-01f, 1.14111438e-01f, -8.23285282e-02f, 9.39635411e-02f, 3.46522629e-02f, -1.00431278e-01f, 3.11108269e-02f, -1.16280606e-03f, -1.41303279e-02f,
  -1.12667456e-02f, -1.28060013e-01f, 4.68742475e-03f, 5.66745549e-02f, 2.93652732e-02f, 6.29064888e-02f, 1.27303777e-02f, -4.64974940e-02f, 3.98038812e-02f, 1.71063151e-02f,
  3.47788632e-02f, -7.04212114e-03f, -2.19252612e-02f, 5.80851249e-02f, 4.17497158e-02f, 8.23529884e-02f, 2.70900410e-02f, -4.14298326e-02f, 8.19747075e-02f, 7.30049461e-02f,
  -7.40997270e-02f, -2.80854162e-02f, 5.05918339e-02f, 2.02169903e-02f, -6.10004589e-02f, -9.49529335e-02f, -9.90636796e-02f, 7.76972324e-02f, -4.48031984e-02f, -5.27589545e-02f,
  -2.88346618e-01f, -5.74984491e-01f, 3.03390156e-02f, -4.25268672e-02f, -6.20585531e-02f, 7.38294469e-03f, -4.10642065e-02f, 4.01187427e-02f, -8.59872624e-02f, -2.44177487e-02f,
  -3.48121673e-02f, 4.44463976e-02f, -4.90510501e-02f, -4.98556904e-03f, -1.06330432e-01f, -8.76534358e-02f, -6.32839799e-02f, -6.70181289e-02f, -9.85537022e-02f, -1.16614923e-01f,
  2.93303877e-02f, 2.18516421e-02f, -3.22471634e-02f, 7.54455328e-02f, -9.69761459e-06f, -5.04314005e-02f, -2.54120976e-02f, -4.91022021e-02f, -2.60120183e-02f, -8.69920328e-02f,
  1.49954706e-01f, 1.62444428e-01f, -4.33291435e-01f, -6.56576633e-01f, -1.11570053e-01f, -3.67853284e-01f, -5.08914292e-01f, -1.10830575e-01f, -1.93339258e-01f, 8.84823315e-03f,
  -4.14731428e-02f, -3.67173627e-02f, 2.79974043e-01f, -2.12109104e-01f, -1.04369983e-01f, 2.15037838e-01f, -5.59557855e-01f, -2.97014683e-01f, 1.62688836e-01f, -2.13779017e-01f,
  -1.17924094e-01f, -1.64431408e-02f, -1.92236766e-01f, 2.30898589e-01f, -2.93921590e-01f, -1.33064166e-01f, -8.95061269e-02f, 6.93865418e-02f, -2.84795612e-01f, 5.67499213e-02f,
  1.10376053e-01f, 2.94197887e-01f, -1.18772514e-01f, -3.40973623e-02f, -1.00232616e-01f, -5.60349412e-02f, -1.73678309e-01f, 5.70015945e-02f, -9.42486525e-02f, -5.63574173e-02f,
  -4.84410301e-02f, 1.42076179e-01f, -5.29724024e-02f, 4.14707847e-02f, 7.01280730e-03f, -7.28848502e-02f, -1.40848495e-02f, -1.36510149e-01f, 1.20700710e-01f, 1.36724457e-01f,
  3.59994397e-02f, 5.22774346e-02f, -1.99781388e-01f, -1.55220687e-01f, -8.86122286e-02f, 5.01507595e-02f, -1.28531769e-01f, -3.65036651e-02f, -1.27669618e-01f, -1.12641037e-01f,
  1.10330522e-01f, -1.18453847e-03f, 1.03394605e-01f, -8.62109214e-02f, 2.42401920e-02f, 1.21959848e-02f, -8.50445684e-03f, -4.06225063e-02f, -1.12402827e-01f, 1.80761032e-02f,
  -1.53096139e-01f, -9.20358151e-02f, 1.01924397e-01f, -1.29796192e-01f, -6.32090345e-02f, 8.20098910e-03f, 1.02772593e-01f, 1.96476933e-02f, -1.55872092e-01f, -1.04763858e-01f,
  -6.00708053e-02f, 6.45081475e-02f, -1.23452671e-01f, -1.15004100e-01f, 5.92763685e-02f, 5.11432104e-02f, -4.89904098e-02f, 4.37907577e-02f, -4.73436937e-02f, 5.03617106e-03f,
  -9.70588699e-02f, -9.92864743e-02f, -2.46482082e-02f, -7.38390684e-02f, -6.75382838e-02f, -3.50745879e-02f, -7.02268407e-02f, -7.20144361e-02f, -1.49104297e-01f, -3.06236129e-02f,
  -1.33872643e-01f, -2.04449922e-01f, -8.31785202e-02f, -3.58018167e-02f, -1.42099112e-01f, -8.69198516e-02f, 6.15646169e-02f, -1.19198069e-01f, -1.82959780e-01f, -7.79245198e-02f,
  -3.32493596e-02f, -2.19873469e-02f, -1.90566778e-02f, -1.53431654e-01f, -8.50462765e-02f, -6.01006597e-02f, -8.23452845e-02f, 6.45859465e-02f, 9.77298394e-02f, -1.28673792e-01f,
  1.79720238e-01f, -2.50153512e-01f, -3.42987329e-01f, 1.04661331e-01f, 1.46049738e-01f, 4.61645573e-02f, 7.95022175e-02f, 2.34063029e-01f, -1.81318715e-01f, 2.18224972e-01f,
  2.29034185e-01f, -5.31431258e-01f, -8.30438212e-02f, 2.76477933e-02f, -5.02042919e-02f, -1.85387388e-01f, 2.16839567e-01f, -1.69474240e-02f, -8.06994662e-02f, 1.83787704e-01f,
  7.33743981e-02f, 4.15988505e-01f, -2.03393679e-02f, 1.42235547e-01f, 2.34345451e-01f, 7.16414973e-02f, 4.45792019e-01f, -4.51224223e-02f, 2.79438525e-01f, -1.65075690e-01f,
  4.92697582e-02f, 1.10404097e-01f, -1.18072247e-02f, -9.13714170e-02f, 2.16335788e-01f, 1.12813242e-01f, 2.38400903e-02f, -2.31471341e-02f, -2.25718301e-02f, -1.85168702e-02f,
  -1.48330003e-01f, -5.18314242e-02f, 3.20217609e-02f, 5.28953485e-02f, -4.85063251e-03f, -1.80234760e-02f, -9.99803767e-02f, -4.35698479e-02f, -1.59647658e-01f, -7.76665062e-02f,
  -6.21538870e-02f, 3.65330316e-02f, -1.54910609e-01f, -6.57058135e-02f, -1.74972892e-01f, -5.33534624e-02f, -6.22281432e-02f, 1.65548194e-02f, 1.03283087e-02f, -5.68979569e-02f,
  1.90721303e-01f, 1.05808794e-01f, 4.65657823e-02f, -5.32548092e-02f, 1.10927066e-02f, -2.82768738e-02f, -1.19834162e-01f, -1.28245234e-01f, -3.20148915e-02f, 7.27970991e-03f,
  1.28023952e-01f, -3.42862941e-02f, -3.74038555e-02f, 7.11304471e-02f, 1.04975857e-01f, -9.74840075e-02f, -4.47697416e-02f, 9.89304036e-02f, 1.71648249e-01f, -3.88262235e-02f,
  -1.35369509e-01f, -6.09424375e-02f, 6.97829872e-02f, 9.31247994e-02f, -3.05299684e-02f, 6.85522556e-02f, 9.71217602e-02f, 5.38139716e-02f, -7.07542896e-02f, 3.57372165e-02f,
  9.07906815e-02f, 1.87805831e-01f, -2.82396954e-02f, -3.22884955e-02f, -9.81962159e-02f, 2.97342744e-02f, -1.35098740e-01f, -7.80756027e-02f, -9.06925369e-03f, 7.18002245e-02f,
  1.21347941e-01f, -2.56953835e-02f, 1.21709965e-01f, 1.00410506e-01f, 6.19637175e-03f, 2.16815323e-01f, -5.86963594e-02f, -6.42846525e-02f, 6.33814260e-02f, 7.36801103e-02f,
  1.83888271e-01f, 2.85361767e-01f, -6.44059479e-02f, -1.15180403e-01f, 5.63788824e-02f, 9.04027745e-02f, 1.23456763e-02f, 3.55029143e-02f, 1.04227059e-01f, -7.46738836e-02f,
  7.26377442e-02f, 2.82786757e-01f, -1.69349924e-01f, 1.15679251e-02f, -4.37483102e-01f, -2.30785191e-01f, -3.30334038e-01f, -1.76068011e-03f, 4.85605568e-01f, 1.87731639e-01f,
  -5.12299895e-01f, 5.96017480e-01f, -2.99844965e-02f, -5.16945541e-01f, -6.24156184e-02f, 1.93646252e-01f, -9.54975113e-02f, 1.56744003e-01f, 1.52644694e-01f, -5.59687032e-04f,
  -3.00587844e-02f, -3.31893325e-01f, -4.37532544e-01f, -2.91479170e-01f, -4.23023164e-01f, -6.89400658e-02f, -2.69081801e-01f, -2.22941831e-01f, -4.22338724e-01f, -1.85057655e-01f,
  -2.19641238e-01f, 1.20337181e-01f, -1.00277312e-01f, 5.23352548e-02f, 5.41541120e-03f, 6.64513186e-02f, -7.08943754e-02f, -1.80015877e-01f, 1.07700014e-02f, -2.08260063e-02f,
  2.57362843e-01f, -2.31358632e-02f, 3.15887928e-02f, -9.96700767e-03f, 1.45543907e-02f, -6.90810904e-02f, 2.30214838e-02f, -1.09407045e-01f, -3.51978056e-02f, -1.26618788e-01f,
  -8.18919465e-02f, 5.19124679e-02f, -1.31803349e-01f, 9.04319063e-02f, 2.16860883e-02f, -1.49927037e-02f, 3.62724736e-02f, -5.79184480e-02f, -7.50427023e-02f, 6.86274320e-02f,
  5.18966205e-02f, 4.46954102e-04f, -6.43556193e-02f, -9.68368053e-02f, -1.65528148e-01f, -6.46216050e-02f, 2.29378827e-02f, -4.57931012e-02f, 4.08506058e-02f, -8.34963620e-02f,
  -3.28698568e-02f, -8.02037679e-03f, -4.82177064e-02f, 3.23878974e-02f, -8.79769586e-03f, 9.67420191e-02f, -1.59384236e-02f, 1.21500138e-02f, 3.40293273e-02f, 7.67556652e-02f,
  -1.33673139e-02f, -6.30483329e-02f, 3.26017402e-02f, -8.06439146e-02f, -5.92863522e-02f, -1.78319998e-02f, -9.43210628e-03f, -8.79558828e-03f, 8.08361173e-02f, -9.26916674e-03f,
  6.94796368e-02f, 4.72299010e-01f, 1.13537453e-01f, 8.55358019e-02f, 1.52451500e-01f, -2.86479611e-02f, 9.47776996e-03f, 5.95441796e-02f, 1.53926402e-01f, 1.80109758e-02f,
  -3.62030417e-02f, 9.07745436e-02f, 6.61199167e-02f, -1.01193048e-01f, 7.50796348e-02f, -6.84900433e-02f, 8.32596049e-02f, 1.84711263e-01f, 4.02055085e-02f, -2.08334886e-02f,
  1.25907678e-02f, 1.70036227e-01f, 2.20707372e-01f, 4.54105139e-02f, 1.83579504e-01f, 8.86792764e-02f, 4.28902060e-02f, 1.86792538e-02f, 3.19374315e-02f, 7.65258893e-02f,
  2.50395358e-01f, -3.08450937e-01f, 2.91946709e-01f, 5.80656290e-01f, 1.92221895e-01f, -7.63877332e-01f, -5.15444100e-01f, 3.26337889e-02f, 4.39560860e-01f, -6.28381729e-01f,
  -1.20923020e-01f, 5.03884964e-02f, -6.49716794e-01f, 4.49071437e-01f, 1.76520318e-01f, -4.46782529e-01f, 3.43918204e-01f, -6.89112069e-03f, 1.05235599e-01f, 8.15973133e-02f,
  4.70566720e-01f, 1.00466900e-01f, 3.58743489e-01f, 1.46272197e-01f, 1.20811887e-01f, 2.85609663e-01f, 3.08757544e-01f, -1.32123739e-01f, 2.67679036e-01f, -9.08111930e-02f,
  2.58006789e-02f, 2.36417532e-01f, 8.71156901e-02f, 2.49138549e-02f, 1.13783469e-02f, -4.24840786e-02f, -1.56082273e-01f, -1.73438743e-01f, 1.34419575e-01f, -6.55946359e-02f,
  -1.51374400e-01f, 3.80239449e-02f, 8.43005851e-02f, -5.66726737e-02f, 1.01908892e-01f, 1.74281657e-01f, 1.04250550e-01f, -3.42442072e-03f, 7.37378001e-02f, 1.76810604e-02f,
  2.02394351e-02f, 9.32484716e-02f, 5.11390120e-02f, 6.11967668e-02f, 1.38375789e-01f, 1.22465976e-01f, 7.97441974e-03f, -4.24833745e-02f, 2.83169746e-02f, 1.84750855e-01f,
  1.66490115e-03f, -1.98791862e-01f, -6.35073557e-02f, -3.81731577e-02f, -2.54228767e-02f, 1.40269771e-01f, -3.98690589e-02f, 4.18794118e-02f, -1.65865023e-03f, 1.43673935e-03f,
  1.18031673e-01f, 4.76847515e-02f, 7.53820464e-02f, 9.75313410e-03f, 3.61898132e-02f, 1.46082595e-01f, -6.18336461e-02f, -1.71389118e-01f, 8.75150338e-02f, 1.03254104e-02f,
  3.19139995e-02f, -7.06393551e-03f, -6.99533001e-02f, 6.43490860e-03f, -7.49643072e-02f, -1.17149740e-01f, 1.43914716e-02f, -6.22993615e-03f, 2.49207187e-02f, -5.19599728e-02f,
  -6.02327138e-02f, 2.18777545e-02f, -1.83770750e-02f, -5.04565798e-02f, -2.63391668e-03f, -4.64850031e-02f, 5.18495739e-02f, 6.71589300e-02f, -6.25229925e-02f, -6.67641759e-02f,
  -4.36066538e-02f, -1.00224596e-02f, -4.85173203e-02f, 1.29763773e-02f, 6.12127781e-02f, -4.00613956e-02f, -1.35712802e-01f, 1.19256794e-01f, 7.36555830e-02f, -2.28771064e-02f,
  1.16388835e-02f, -2.49391034e-01f, 1.53634205e-01f, 7.72603825e-02f, 4.35623825e-02f, 2.89607048e-03f, 8.70928913e-03f, 5.82724027e-02f, -3.62075232e-02f, 7.67947063e-02f,
  -7.30863154e-01f, 3.69364351e-01f, -5.02232075e-01f, 3.73061970e-02f, -7.27416202e-02f, -2.10711882e-01f, 1.23422496e-01f, 7.18509592e-03f, -3.41627240e-01f, 6.20438397e-01f,
  5.95193624e-01f, -4.41022724e-01f, 3.38178635e-01f, 4.43239093e-01f, -5.66135645e-01f, 1.47431880e-01f, 2.94864058e-01f, 1.70925617e-01f, -2.74826676e-01f, 1.56264856e-01f,
  -2.66777068e-01f, 4.30316478e-01f, -1.86281800e-02f, 1.21391095e-01f, 1.30576849e-01f, -1.45004198e-01f, 4.94821906e-01f, -1.88604176e-01f, 1.97816014e-01f, -1.14629067e-01f,
  3.34463194e-02f, 1.42173514e-01f, 9.51648690e-03f, -1.85563907e-01f, 1.57556459e-02f, 1.38848960e-01f, 2.02262178e-02f, -1.93539441e-01f, -1.65632650e-01f, -6.55242205e-02f,
  -5.17445467e-02f, -1.18282467e-01f, -6.67547435e-02f, -6.34910017e-02f, 6.34052267e-04f, -4.27701846e-02f, -5.42820543e-02f, -3.49281989e-02f, 3.08801141e-02f, 5.21393754e-02f,
  -3.10647544e-02f, 1.38440244e-02f, 1.25941634e-01f, 8.15168247e-02f, -5.82965575e-02f, -5.76817654e-02f, -3.57252639e-03f, 2.97718942e-02f, 3.83898392e-02f, -3.50520462e-02f,
  -7.15220068e-03f, -7.27303103e-02f, -1.98685052e-03f, 3.63866463e-02f, -3.59862931e-02f, 1.64702326e-01f, 1.28141725e-02f, 1.96219794e-02f, -1.59818351e-01f, 7.96199217e-02f,
  1.07046841e-02f, -4.80534360e-02f, 8.54216218e-02f, 6.82321042e-02f, 1.00547679e-01f, 1.68666188e-02f, -9.15615559e-02f, -4.89553213e-02f, -6.25405759e-02f, -1.78736895e-02f,
  4.57519032e-02f, -8.18078145e-02f, 4.63420078e-02f, 1.27191484e-01f, -1.94613989e-02f, -2.16748612e-03f, 5.35265319e-02f, 4.36010323e-02f, 1.06889769e-01f, -5.41140186e-03f,
  2.46270642e-01f, 1.65333480e-01f, -2.98478436e-02f, 1.84556879e-02f, -1.47380475e-02f, 4.05466706e-02f, -2.39868294e-02f, -9.93619561e-02f, -1.05223674e-02f, -7.24732131e-02f,
  -1.09530604e-02f, 1.45004198e-01f, 1.79954115e-02f, 1.32099018e-02f, -1.13495000e-01f, 1.37269109e-01f, 1.43832952e-01f, -3.48303206e-02f, 4.82817180e-02f, 6.06589764e-02f,
  1.01487994e-01f, -1.74238775e-02f, -3.68700139e-02f, 1.19578607e-01f, 8.83256793e-02f, 1.42518938e-01f, -2.67584566e-02f, -1.19172774e-01f, -3.30251232e-02f, 1.06549002e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.95180851e-01f, 5.01421034e-01f, 5.92611015e-01f, 4.75847960e-01f, 5.63017607e-01f, 4.16106224e-01f, 4.71940637e-01f, 6.46850586e-01f, 4.44758356e-01f, 4.15866703e-01f,
  3.91999751e-01f, 4.33279842e-01f, 3.97790760e-01f, 4.68941092e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -4.67596829e-01f, -1.41234219e-01f, -3.90584707e-01f, -3.83364469e-01f, 9.46025252e-02f, 8.40934515e-02f, 4.67703789e-02f, -5.84385931e-01f, 1.44080505e-01f, 5.98594844e-02f,
  1.93987623e-01f, -6.32804692e-01f, 2.11858749e-01f, -5.00225484e-01f, 8.43155533e-02f, 2.30489537e-01f, 1.41414255e-01f, -1.52849406e-01f, -3.60585749e-01f, -1.61541820e-01f,
  -5.75736344e-01f, 2.08639532e-01f, 2.27399096e-01f, -2.40276501e-01f, 6.06384613e-02f, 3.88048470e-01f, -2.83752203e-01f, 5.32765985e-01f, 3.96186680e-01f, 2.77459100e-02f,
  1.31146861e-02f, -5.80168188e-01f, 3.32342088e-01f, 1.35178104e-01f, 3.15315574e-01f, 3.71188581e-01f, 2.79654175e-01f, -4.95902747e-01f, 2.86211371e-01f, -4.02583331e-01f,
  3.91598314e-01f, 1.38446927e-01f, 5.36444604e-01f, -3.35196525e-01f, 4.87182349e-01f, -3.69843751e-01f, -4.38242972e-01f, 4.51763242e-01f, -2.17845529e-01f, 4.50966328e-01f,
  -3.93946409e-01f, 5.52757502e-01f, -6.39954388e-01f, -3.27068299e-01f, -8.41203146e-04f, -4.41813111e-01f, -4.28896755e-01f, -4.16981995e-01f, -1.94808096e-01f, -1.99570298e-01f,
  2.47894928e-01f, -5.19958436e-01f, -1.89255387e-01f, 9.68272746e-01f, 1.59819096e-01f, 1.27640530e-01f, 3.89683396e-01f, 3.94887209e-01f, -2.68682569e-01f, -1.10076122e-01f,
  1.37652248e-01f, 1.15707301e-01f, -4.75591049e-02f, -4.27330472e-02f, -5.61890490e-02f, -2.88795233e-01f, -2.86158532e-01f, -3.02768677e-01f, -2.99913406e-01f, -4.63269383e-01f,
  -2.87016600e-01f, -5.40909879e-02f, 3.14450860e-01f, 2.16937184e-01f, 5.82067609e-01f, -3.98691334e-02f, -4.25672323e-01f, -2.07214817e-01f, -3.14010121e-02f, 1.42574549e-01f,
  4.33110036e-02f, -2.55698979e-01f, -1.92013651e-01f, 4.25840974e-01f, -1.31127566e-01f, 5.91755271e-01f, 3.76387417e-01f, 3.87792528e-01f, -4.94942635e-01f, -5.59468985e-01f,
  5.14440238e-01f, 4.68440682e-01f, 3.77343982e-01f, -6.04829192e-01f, -1.90720722e-01f, -2.26087481e-01f, -2.37829804e-01f, -5.15240431e-01f, -5.43307602e-01f, -1.48351148e-01f,
  5.47484457e-01f, 2.80373603e-01f, -6.63773477e-01f, 4.97926831e-01f, 7.91890204e-01f, 1.30923271e-01f, -5.00845816e-03f, 5.39306104e-01f, 2.13263500e-02f, -4.96875972e-01f,
  -2.90525258e-01f, -7.31679857e-01f, -1.44457623e-01f, 3.66873473e-01f, 3.91159266e-01f, -6.94039941e-01f, -8.59019339e-01f, 2.46602148e-01f, -1.56028479e-01f, -1.58695251e-01f,
  -2.08526433e-01f, -1.88607961e-01f, -1.98422581e-01f, -7.06165433e-02f, -3.58966649e-01f, 2.03874707e-01f, -2.38865331e-01f, 7.46785244e-03f, 1.41913861e-01f, 1.64785564e-01f,
  -8.36651325e-02f, -3.22389215e-01f, 2.12879613e-01f, 6.28626496e-02f, 9.16085020e-02f, -1.64987996e-01f, -2.26127148e-01f, -4.20811296e-01f, -4.64774549e-01f, -3.82950544e-01f,
  9.31757092e-02f, 1.24471672e-01f, 6.63638487e-02f, -2.86426753e-01f, 3.41096103e-01f, 3.42481911e-01f, -3.70065719e-01f, -5.28935231e-02f, -1.81609020e-01f, 1.86910287e-01f,
  -1.23608194e-01f, -4.37396616e-01f, -1.16725169e-01f, 3.72538030e-01f, -6.45150989e-02f, 1.99702829e-01f, 4.85625058e-01f, 3.56687456e-01f, -7.41682500e-02f, 4.56145972e-01f,
  3.84103715e-01f, 3.88686985e-01f, -2.31963784e-01f, 1.72643483e-01f, 3.31113935e-01f, -2.18809843e-01f, 2.27404445e-01f, 4.32972819e-01f, 6.90579414e-01f, 2.03883693e-01f,
  -5.61115563e-01f, 4.86458361e-01f, -5.71342528e-01f, -2.48806506e-01f, -5.07476985e-01f, 1.84389204e-01f, -6.96640313e-01f, -5.61199546e-01f, 1.74076989e-01f, -2.47075066e-01f,
  6.47124887e-01f, -7.66772091e-01f, 1.04707159e-01f, 5.62484637e-02f, -2.22605243e-01f, 2.44136021e-01f, -6.03669763e-01f, 4.33871821e-02f, 2.26619184e-01f, 5.43329418e-01f,
  -5.94777726e-02f, -1.14995547e-01f, -2.73443729e-01f, -1.63721323e-01f, -4.21672136e-01f, 3.40156406e-02f, 4.05281521e-02f, 1.11100964e-01f, -3.55578989e-01f, -4.26361114e-01f,
  -6.72482550e-01f, -2.41994873e-01f, 5.62272966e-02f, -5.55311680e-01f, -6.94790542e-01f, -3.05494189e-01f, 3.18640649e-01f, 7.41871655e-01f, -1.64989427e-01f, -2.51651257e-01f,
  -2.72492766e-01f, -2.42763758e-01f, 1.19240381e-01f, 2.45258566e-02f, 2.47239888e-01f, 3.80330026e-01f, 6.25471056e-01f, -3.19819599e-02f, -4.56869632e-01f, 1.70818791e-01f,
  1.64653435e-01f, 6.72517896e-01f, -2.70136476e-01f, 3.12508374e-01f, -3.22765470e-01f, -2.70179540e-01f, 3.34933341e-01f, -4.79030669e-01f, -1.06567182e-01f, -1.92243323e-01f,
  -6.35924518e-01f, -1.52011896e-02f, -8.55487823e-01f, -3.37283701e-01f, -6.21360779e-01f, -2.19700947e-01f, -2.80716687e-01f, -1.31632984e-01f, -1.56414926e-01f, 6.99959338e-01f,
  -1.97818533e-01f, 5.33027887e-01f, -1.66493431e-01f, 7.17890039e-02f, -1.74055323e-01f, 3.01766753e-01f, 3.18240941e-01f, -7.87887275e-02f, -6.04932159e-02f, -2.79321015e-01f,
  5.45611799e-01f, -7.72884414e-02f, 4.15520787e-01f, -8.10104534e-02f, 1.79266885e-01f, 1.77925229e-01f, 7.17420429e-02f, 2.41655797e-01f, 3.39364588e-01f, 7.43537322e-02f,
  2.20309541e-01f, 2.67374963e-01f, 7.22572878e-02f, 4.60274428e-01f, 3.39274853e-01f, -4.41303819e-01f, -5.17826043e-02f, 4.34606403e-01f, 2.56821383e-02f, 2.04698905e-01f,
  -1.28263310e-01f, 2.52444148e-01f, -7.66781926e-01f, 2.44893998e-01f, 6.28283322e-01f, -4.07146692e-01f, 5.10737360e-01f, 1.19777784e-01f, 5.60277581e-01f, -6.03127658e-01f,
  4.64059561e-01f, 5.19628763e-01f, 6.25477433e-01f, -7.42648304e-01f, 1.10748082e-01f, -1.12672761e-01f, -2.26249456e-01f, 6.01737559e-01f, -6.25067592e-01f, -2.56527178e-02f,
  3.87628227e-01f, -7.92206302e-02f, 1.81965947e-01f, -5.66851735e-01f, -2.18773827e-01f, -1.38319418e-01f, -2.04500452e-01f, -8.02460074e-01f, 6.05608046e-01f, -1.65103078e-02f,
  -2.39133582e-01f, 5.92903733e-01f, 6.90907300e-01f, -3.07722151e-01f, -5.35778224e-01f, 1.73415542e-01f, -1.21860340e-01f, -4.61691409e-01f, -4.89649355e-01f, -3.88363451e-01f,
  1.82102785e-01f, 3.59729171e-01f, 3.55349004e-01f, -3.01334172e-01f, 2.16758624e-01f, 2.28585660e-01f, -1.65275350e-01f, 2.96983421e-01f, 2.09202439e-01f, 2.11729079e-01f,
  -6.37361258e-02f, 3.66058111e-01f, 1.88924745e-01f, 4.72371906e-01f, 1.39875352e-01f, -1.87659692e-02f, -2.53912777e-01f, -4.05751504e-02f, 9.31694955e-02f, 3.86786759e-01f,
  -2.66873300e-01f, 4.27760839e-01f, 2.69623548e-01f, 3.22217718e-02f, 3.07053536e-01f, 1.84968188e-01f, 3.16487074e-01f, -1.97948173e-01f, 1.62386045e-01f, 7.54345000e-01f,
  5.22913992e-01f, -4.36103284e-01f, -1.64588988e-01f, 7.07043529e-01f, -1.21295732e-02f, 1.38206556e-01f, 1.39845654e-01f, 5.65578401e-01f, 1.73369005e-01f, 2.44369298e-01f,
  -4.85129267e-01f, -7.13446438e-01f, 8.99084270e-01f, 3.33379030e-01f, 3.68650168e-01f, -5.24614751e-01f, 1.25645503e-01f, 3.78839433e-01f, 2.24515259e-01f, -4.78518099e-01f,
  -3.13720852e-01f, -2.57864237e-01f, -4.89843160e-01f, 3.23734939e-01f, 6.72857046e-01f, -5.85755587e-01f, 5.53671062e-01f, -6.44149125e-01f, -3.94128174e-01f, -2.82147795e-01f,
  -7.03262091e-01f, 7.09413886e-01f, -2.34086603e-01f, -6.98969364e-01f, -3.50101814e-02f, -5.80792785e-01f, 3.43816608e-01f, 1.54318675e-01f, 8.06806833e-02f, -1.23042669e-02f,
  7.55829811e-02f, -2.35936001e-01f, -1.08520865e-01f, -7.35685900e-02f, 2.40103215e-01f, 1.60734758e-01f, -5.88556588e-01f, -1.00799024e-01f, -4.75146145e-01f, 4.50254641e-02f,
  3.60445306e-02f, 1.60510749e-01f, 7.12771714e-02f, -2.21236914e-01f, 9.48303938e-02f, -4.99286443e-01f, 1.43733984e-02f, 7.14420304e-02f, -1.94671750e-01f, -3.58277768e-01f,
  5.34841239e-01f, -3.04017454e-01f, 2.20664024e-01f, -1.17575951e-01f, -5.67843258e-01f, -5.80096722e-01f, 1.96121052e-01f, -4.41162527e-01f, -5.24452925e-01f, -4.50009704e-01f,
  1.02403946e-01f, 2.73972303e-01f, -4.32241410e-01f, 5.98075867e-01f, -3.65457892e-01f, -5.40709317e-01f, -2.48639267e-02f, 2.38611475e-01f, -7.07009792e-01f, 2.75242567e-01f,
  3.96393657e-01f, 3.48221779e-01f, -5.52520931e-01f, -4.50343102e-01f, -3.36499274e-01f, -2.96711504e-01f, 1.98741090e-02f, -1.50220439e-01f, -4.68024939e-01f, -1.15409605e-01f,
  3.89044762e-01f, 5.21042168e-01f, 7.74220645e-01f, -5.08344114e-01f, 1.95989117e-01f, -3.70342284e-01f, 4.70356554e-01f, -3.74851704e-01f, 2.73281541e-02f, -2.11058393e-01f,
  -9.64375958e-02f, -1.47229448e-01f, 3.30016129e-02f, 8.63965601e-02f, -3.36847544e-01f, 2.73559019e-02f, -4.48421799e-02f, -1.41525537e-01f, 1.67656764e-02f, -3.09087306e-01f,
  -1.98971197e-01f, -1.09134398e-01f, -4.17079061e-01f, -1.20852701e-01f, -1.81247875e-01f, -8.59794617e-02f, 1.47432774e-01f, -6.98467642e-02f, 3.75022553e-02f, 1.26073256e-01f,
  1.64875671e-01f, -1.82642996e-01f, -1.69451535e-01f, -2.13017851e-01f, 4.43894029e-01f, 2.85188943e-01f, -4.23017628e-02f, 3.25730175e-01f, -3.07777464e-01f, -1.65822074e-01f,
  -9.08181816e-02f, 2.79189050e-02f, 1.68300286e-01f, -3.88020337e-01f, -2.61534393e-01f, -2.71890551e-01f, -3.53136688e-01f, 2.81364590e-01f, 2.81469077e-01f, 1.95088714e-01f,
  -2.04050541e-01f, -3.34518701e-01f, -2.26740107e-01f, -1.58163622e-01f, -3.18051010e-01f, 8.55659619e-02f, 3.43466878e-01f, -1.31494835e-01f, -2.78364837e-01f, 1.67815238e-01f,
  3.77252162e-01f, -2.68681526e-01f, -4.85025346e-01f, -1.45028472e-01f, -4.74822462e-01f, -8.50582421e-02f, -4.39299732e-01f, 5.08845747e-01f, -3.36910278e-01f, 7.30326653e-01f,
  2.69720256e-01f, -4.58652407e-01f, 3.75811160e-02f, 1.27599448e-01f, -2.51516867e-02f, -1.47662759e-01f, 1.62652105e-01f, -3.23072940e-01f, -1.40081629e-01f, -2.90225625e-01f,
  -3.48786525e-02f, -2.33632728e-01f, -1.72059700e-01f, 1.36933252e-01f, 3.09587382e-02f, 7.70095959e-02f, 1.49963349e-01f, -9.92590096e-03f, 9.91079137e-02f, 5.73126636e-02f,
  -4.13616486e-02f, -3.29697609e-01f, -1.66627482e-01f, 1.90633506e-01f, -1.66033864e-01f, -1.44251168e-01f, -2.44453326e-01f, 2.40807652e-01f, 4.83982032e-03f, -2.08125919e-01f,
  -2.78259635e-01f, -4.00287628e-01f, 4.42579508e-01f, 1.34943709e-01f, -3.32323700e-01f, 3.85715365e-01f, -2.44147733e-01f, -4.75403756e-01f, 2.73041073e-02f, 2.05129057e-01f,
  -4.75206405e-01f, -3.71115133e-02f, 4.09013212e-01f, -1.17956199e-01f, -1.80905819e-01f, 3.84880863e-02f, -2.39676639e-01f, 2.95265347e-01f, -3.43402267e-01f, 3.97137612e-01f,
  4.29351360e-01f, 1.70885712e-01f, -5.11214435e-01f, -1.91993073e-01f, -4.07525957e-01f, 4.30884212e-01f, 5.11636697e-02f, 6.82860076e-01f, -4.55334187e-01f, -5.46069503e-01f,
  -2.83659160e-01f, -2.82620430e-01f, 2.95593083e-01f, -3.91892865e-02f, 6.35813236e-01f, 7.50788301e-02f, -1.83674917e-01f, 1.76571548e-01f, -2.01278359e-01f, 2.92467594e-01f,
  -8.71450454e-02f, 1.88505515e-01f, 6.67807162e-02f, 2.39438936e-01f, -3.44917357e-01f, 2.94688165e-01f, -1.08282551e-01f, 1.03402235e-01f, 3.21837813e-01f, 1.95690736e-01f,
  1.99295193e-01f, 1.18633196e-01f, 1.54948339e-01f, 3.09260964e-01f, -5.00684261e-01f, 2.88270026e-01f, 3.54070552e-02f, -2.78584838e-01f, 1.94166020e-01f, 8.39272588e-02f,
  7.52497315e-02f, -6.33524776e-01f, 8.63439366e-02f, 5.04819870e-01f, -6.60657436e-02f, 4.90180671e-01f, 3.75977218e-01f, 2.81702608e-01f, 6.96451515e-02f, -2.96880573e-01f,
  3.23979825e-01f, 4.63170230e-01f, -1.69166237e-01f, 3.74305636e-01f, -5.36836207e-01f, -4.89088222e-02f, 5.84018111e-01f, -1.75703436e-01f, 3.24958920e-01f, 3.83239985e-01f,
  4.16175485e-01f, 6.29622877e-01f, 3.49796951e-01f, 3.88730586e-01f, 5.87282658e-01f, -3.22705805e-01f, -3.78284067e-01f, 8.15525711e-01f, 6.42504096e-01f, -5.63234746e-01f,
  -6.02257609e-01f, -5.29499710e-01f, -3.69640470e-01f, -6.40720129e-01f, 1.61748484e-01f, -3.57149929e-01f, -4.13732529e-01f, -5.14724493e-01f, -6.75998211e-01f, -1.83829248e-01f,
  -5.34923077e-02f, -3.28792453e-01f, 2.42167965e-01f, 1.82531029e-01f, -5.92713095e-02f, 2.25117281e-02f, -1.55508533e-01f, -4.58934397e-01f, 6.60793781e-02f, 1.11279376e-01f,
  2.51509875e-01f, 2.15934858e-01f, 1.95001245e-01f, 7.25655034e-02f, 1.72384270e-02f, -2.15444311e-01f, 3.90733659e-01f, 2.06051916e-01f, 3.57848197e-01f, 2.88572311e-01f,
  2.40659505e-01f, 2.90441692e-01f, 3.15192610e-01f, 1.73427284e-01f, 1.42843187e-01f, -7.38620877e-01f, -3.33545297e-01f, -2.56217659e-01f, -1.83528706e-01f, -2.71315575e-01f,
  -5.58869302e-01f, 2.90005773e-01f, -5.62876761e-01f, 2.81337589e-01f, -5.75859070e-01f, 8.08825046e-02f, -2.11440995e-01f, -5.07420063e-01f, 1.11131549e-01f, -5.52060604e-01f,
  -4.70963120e-01f, -2.76617110e-01f, -8.83824304e-02f, -2.57833451e-01f, 5.43758795e-02f, 5.87317109e-01f, -3.67265791e-01f, -3.29712898e-01f, 6.15344346e-01f, 1.76551789e-01f,
  3.89305770e-01f, -3.63214076e-01f, -5.15896738e-01f, -8.36562097e-01f, -3.47137332e-01f, 1.94195122e-01f, -5.04098833e-01f, 5.51803946e-01f, -4.04351026e-01f, -2.57347256e-01f,
  4.38390732e-01f, -5.71728824e-03f, -6.05144143e-01f, 3.38840634e-01f, 1.04098402e-01f, 2.11590245e-01f, -5.00379384e-01f, 2.86558419e-01f, -1.19832158e-01f, -1.92846969e-01f,
  1.67098731e-01f, 9.19486210e-02f, -1.74138267e-02f, -1.17544502e-01f, 3.92913148e-02f, -3.03109642e-02f, 2.21376315e-01f, -1.41946584e-01f, 2.64723524e-02f, 1.34080365e-01f,
  7.57227987e-02f, -6.38842285e-02f, 2.36510798e-01f, 1.86074093e-01f, 3.14333767e-01f, 1.28979459e-01f, -1.31858796e-01f, 1.80683583e-01f, -1.98607463e-02f, 4.30253416e-01f,
  7.23965392e-02f, -3.95591885e-01f, -2.90743023e-01f, -5.03878832e-01f, -5.23960352e-01f, 1.75952032e-01f, -4.48571503e-01f, -4.75865692e-01f, -4.78384316e-01f, 2.22958773e-02f,
  -3.90790999e-01f, -4.47518975e-01f, -2.70390242e-01f, -3.84846240e-01f, 4.74452078e-01f, 3.60677361e-01f, -4.71212059e-01f, 1.49868801e-01f, -2.42731839e-01f, -1.55616343e-01f,
  -3.96027833e-01f, -5.43243110e-01f, 1.14347979e-01f, -8.48572552e-02f, -1.84947774e-01f, -5.93221188e-01f, -4.31974888e-01f, -6.44939840e-01f, 8.08632731e-01f, -1.97881624e-01f,
  2.16710642e-02f, -5.85215628e-01f, 8.23328555e-01f, -4.29621875e-01f, -4.91277605e-01f, 3.47394943e-01f, 9.06422138e-02f, -3.01891983e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.04783781e-02f, -1.21474311e-01f, 6.29477296e-03f, 9.09715891e-02f, 9.79593992e-02f, 5.97524606e-02f, -1.89714253e-01f, -5.30680045e-02f, -5.37542999e-02f, 1.09703783e-02f,
  -3.06869596e-02f, 6.69352487e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    