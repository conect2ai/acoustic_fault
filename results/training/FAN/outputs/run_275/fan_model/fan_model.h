/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.01750946e-01f, 2.43543714e-01f, 1.71705320e-01f, -8.11908916e-02f, -2.16006055e-01f, -1.57179967e-01f, -2.08016410e-01f, -3.76708917e-02f, -2.81941444e-02f, 1.26273736e-01f,
  -1.77108362e-01f, -1.24285497e-01f, 4.18824144e-02f, -2.13860616e-01f, -4.30255055e-01f, 3.65673751e-02f, -1.32070035e-01f, 6.53065101e-04f, 3.17848101e-02f, 5.93204275e-02f,
  -2.55380385e-02f, -1.58876598e-01f, -4.99002635e-02f, 5.01587279e-02f, -3.81751992e-02f, 1.48023427e-01f, 3.25817876e-02f, 7.54738972e-02f, 3.31445620e-03f, -1.24104328e-01f,
  -8.57889373e-03f, 1.05434410e-01f, 1.62725952e-02f, 6.55705780e-02f, 1.60253067e-02f, 2.97810268e-02f, -2.03416310e-02f, -1.04240969e-01f, -2.93146670e-02f, 3.24581303e-02f,
  -2.70505063e-03f, 1.48228919e-02f, 1.08188088e-03f, 4.23085243e-02f, -6.56953380e-02f, 2.40643993e-02f, -1.52421696e-02f, 4.01208103e-02f, 1.35686398e-02f, -4.44933511e-02f,
  -1.06805339e-02f, -1.15331332e-03f, 4.84825745e-02f, 4.58490513e-02f, -1.68005005e-02f, 1.90678183e-02f, 3.92079614e-02f, -2.66503375e-02f, 8.36460963e-02f, 1.61337443e-02f,
  -1.43633839e-02f, -1.83448032e-03f, 8.18299595e-03f, -1.15028722e-02f, -2.79636960e-02f, 7.06146657e-02f, -5.30751310e-02f, -2.77251154e-02f, -1.79818552e-02f, -1.69230904e-03f,
  2.90930015e-03f, -6.58393726e-02f, 1.55774485e-02f, -1.18329450e-02f, -5.60183749e-02f, 1.55971693e-02f, -3.00364830e-02f, -1.03033856e-02f, 4.30550575e-02f, -7.39953518e-02f,
  8.15344974e-02f, -4.86212689e-03f, 1.07542314e-02f, 1.89138278e-02f, -1.64103676e-02f, -1.00641258e-01f, -2.85685547e-02f, -1.96700301e-02f, 1.08717466e-02f, 1.99122708e-02f,
  -8.62578582e-03f, 2.84069404e-02f, -4.12806347e-02f, -1.93799045e-02f, 1.31634651e-02f, 2.76602665e-03f, 1.07116485e-02f, -1.81103032e-02f, 1.01700880e-01f, -6.63273921e-03f,
  5.55656329e-02f, -2.09392030e-02f, 7.35135674e-02f, -2.61312462e-02f, -2.53037596e-03f, 1.88490003e-02f, 7.60546401e-02f, 3.98699008e-02f, -5.63831292e-02f, 5.65918395e-03f,
  -2.53279344e-04f, 4.41635698e-02f, 1.32281724e-02f, 2.67359708e-03f, 3.41215283e-02f, -3.89794186e-02f, 1.14395190e-02f, 2.76415199e-02f, -3.06143779e-02f, 2.53565796e-02f,
  3.52596134e-01f, 9.10460278e-02f, 4.51353997e-01f, 1.23572826e-01f, -1.22308150e-01f, -1.45438546e-02f, 2.04884663e-01f, 4.54258267e-03f, 2.82343119e-01f, -8.33496973e-02f,
  -8.13498572e-02f, 1.80986628e-01f, 1.66521847e-01f, -1.26854047e-01f, 2.61675268e-01f, 1.03794783e-01f, -2.35465690e-02f, -5.14550358e-02f, 9.35708582e-02f, -2.03547440e-02f,
  9.62627456e-02f, -1.59131497e-01f, 1.58939645e-01f, -2.17466578e-01f, -1.21769905e-02f, 6.54764920e-02f, -8.11387822e-02f, 4.00348613e-03f, -2.11691394e-01f, -4.07907777e-02f,
  -2.02131905e-02f, -1.92172043e-02f, 7.94886276e-02f, 5.49514145e-02f, 4.81078215e-02f, -5.58749437e-02f, 5.94210206e-03f, -2.43725870e-02f, 3.01736649e-02f, 1.33870849e-02f,
  -1.43959476e-02f, 1.85038056e-02f, 8.59949272e-03f, 5.88477850e-02f, -5.05246175e-03f, 7.40333274e-03f, 1.05265621e-02f, 6.32941350e-02f, -4.43354528e-03f, 1.82346590e-02f,
  6.46577105e-02f, 4.44235234e-03f, 1.59774686e-03f, 1.98439863e-02f, 2.43748743e-02f, 1.94386821e-02f, 2.47202720e-02f, -3.14864852e-02f, -6.07550656e-03f, 2.20788922e-02f,
  -7.67132938e-02f, -2.11500307e-03f, -1.00430464e-02f, 1.28348814e-02f, -8.47519748e-03f, -3.46139483e-02f, -3.98873910e-03f, -7.68102109e-02f, 9.47433189e-02f, -3.31785381e-02f,
  3.47255580e-02f, -8.41068663e-03f, 3.52179520e-02f, 1.34129692e-02f, -3.13844010e-02f, -1.15333553e-02f, 2.44382489e-02f, -1.64785318e-03f, 1.18774874e-02f, -2.27257870e-02f,
  1.75701606e-03f, 1.78153161e-02f, -2.68040802e-02f, -7.56558701e-02f, 2.46850476e-02f, -1.47908265e-02f, -2.27241293e-02f, -7.03104888e-04f, 9.50645469e-03f, -3.34023661e-03f,
  -1.00355349e-01f, 2.13140678e-02f, 3.20108458e-02f, -4.19431590e-02f, 4.44125347e-02f, 1.55766271e-02f, 6.42448142e-02f, -4.92266603e-02f, 9.73156374e-03f, 5.97320497e-03f,
  -8.15985445e-03f, 1.59011595e-03f, -2.69310586e-02f, -9.80885606e-03f, 2.34224834e-02f, 1.16190943e-03f, -1.92540344e-02f, -4.59863916e-02f, 2.98948120e-02f, -3.64557467e-02f,
  -4.19513062e-02f, -1.24036763e-02f, 4.83461693e-02f, -1.94845833e-02f, -8.30119476e-02f, -4.93074059e-02f, 2.28434280e-02f, 5.42791188e-02f, -8.48384947e-02f, 3.29961348e-03f,
  -2.30265632e-02f, 5.40630594e-02f, -1.61105633e-01f, 2.28550479e-01f, -1.54044122e-01f, 7.62038827e-02f, 4.36559916e-02f, 6.59610669e-04f, -1.03889704e-01f, 3.69761556e-01f,
  2.81998038e-01f, -8.93159509e-02f, 4.40225229e-02f, 1.96333423e-01f, -2.37756446e-01f, -3.92026082e-02f, 1.01090327e-01f, 1.67226717e-01f, -1.34959623e-01f, 1.17710516e-01f,
  -3.86987068e-02f, 1.99325740e-01f, -7.14895204e-02f, -2.29289811e-02f, 3.13541591e-02f, 3.31822447e-02f, 4.00338881e-02f, -7.72141144e-02f, 3.62252183e-02f, -4.15725149e-02f,
  -3.73848975e-02f, 1.61547750e-01f, 4.25627641e-03f, -2.79224198e-02f, 1.03781670e-01f, 1.04229506e-02f, 2.39657648e-02f, -1.03347637e-01f, -3.52579132e-02f, -5.38805313e-03f,
  -2.80456804e-02f, -1.89411268e-02f, 1.88652929e-02f, -6.31296858e-02f, -1.90045666e-02f, -1.43798739e-02f, -7.55551457e-02f, -2.05354709e-02f, -1.39897950e-02f, -5.15059456e-02f,
  -5.71669592e-03f, 8.64432231e-02f, 6.32225946e-02f, 1.54409306e-02f, -9.04904008e-02f, 1.07518323e-01f, 2.24720556e-02f, -5.72711192e-02f, 7.55251944e-02f, 1.97090246e-02f,
  -2.13864222e-02f, -3.15456577e-02f, 3.71198403e-03f, 8.21855012e-03f, 7.72289559e-02f, 7.94386342e-02f, 3.62780765e-02f, 9.58311278e-03f, 2.29994114e-02f, 7.72379637e-02f,
  -4.18926813e-02f, 4.47810441e-02f, 2.19036429e-03f, 4.79251370e-02f, 4.46524471e-02f, 5.59076369e-02f, -1.86445750e-02f, -2.12212261e-02f, -1.87228154e-02f, 7.64631154e-03f,
  2.02769395e-02f, 5.44752972e-03f, -2.97909044e-03f, 1.18771577e-02f, 8.13219026e-02f, -8.31604097e-03f, 4.59786057e-02f, -2.00325996e-02f, -7.74909481e-02f, -1.82712656e-02f,
  2.19236597e-01f, 2.97835767e-01f, -7.49374693e-03f, 1.00077232e-02f, 4.52624150e-02f, -6.76970417e-03f, -5.95964044e-02f, -1.96524430e-02f, 2.35037692e-02f, -4.71419096e-03f,
  3.09038907e-02f, 4.02403288e-02f, -2.95820013e-02f, 1.81169547e-02f, 2.77962983e-02f, 3.85364369e-02f, 8.35716128e-02f, -2.96266321e-02f, -2.17110035e-03f, -4.64257831e-03f,
  7.38603016e-03f, 9.63119511e-03f, -2.58607964e-04f, 2.23041773e-02f, 9.08303075e-03f, 1.65519607e-03f, -1.62349697e-02f, -3.97914648e-02f, -9.87517647e-03f, -2.04094108e-02f,
  1.88804448e-01f, -2.35885987e-03f, 2.49255732e-01f, 6.82582036e-02f, -1.78474598e-02f, -1.46603063e-02f, 7.41831809e-02f, 5.88890277e-02f, 2.93438941e-01f, -2.56256640e-01f,
  -2.13247105e-01f, 2.43236974e-01f, 3.29959020e-02f, -2.16573790e-01f, -2.82230861e-02f, 8.97444934e-02f, -1.83212906e-01f, 1.18226968e-02f, 1.86382100e-01f, -3.88129093e-02f,
  7.77682215e-02f, -3.39657336e-01f, -4.99505885e-02f, -2.03179419e-01f, -1.83443893e-02f, 4.69183065e-02f, -3.37145656e-01f, 1.18139265e-02f, -2.28449896e-01f, -4.35574725e-02f,
  9.89077017e-02f, 1.30539581e-01f, -8.58301762e-04f, 3.01649049e-02f, -4.59925644e-02f, -3.67289558e-02f, -3.01438291e-02f, 2.49983296e-02f, 7.11104795e-02f, 9.09162685e-02f,
  2.56922506e-02f, -7.36858919e-02f, -2.41546184e-02f, -1.01307323e-02f, 4.07075323e-02f, 2.28077490e-02f, -1.63091738e-02f, 3.09065152e-02f, 7.22225830e-02f, 1.64556075e-02f,
  4.36317883e-02f, 3.57227959e-02f, -1.70371383e-02f, -3.43934470e-03f, 7.62241781e-02f, 2.73607429e-02f, 2.28483435e-02f, 3.15626487e-02f, 1.48967812e-02f, 3.81756872e-02f,
  -8.25362746e-03f, -1.92673244e-02f, -2.12063408e-03f, -2.80580446e-02f, 3.11839264e-02f, -1.66497864e-02f, -2.07988173e-02f, -2.25666035e-02f, 1.99150257e-02f, -1.30408043e-02f,
  -1.76366363e-02f, 1.51899857e-02f, 1.33848777e-02f, 2.88465582e-02f, -4.18210849e-02f, 1.11586498e-02f, 1.66894887e-02f, -4.88950536e-02f, 1.84701439e-02f, -3.56886685e-02f,
  1.58116240e-02f, -1.36360596e-03f, -2.86837365e-03f, -2.64034551e-02f, 2.42271256e-02f, 4.82545681e-02f, -1.94108132e-02f, 8.68016109e-03f, 3.32845934e-02f, 6.70957437e-04f,
  -6.64050803e-02f, -5.05354814e-02f, 2.21787747e-02f, 4.09331098e-02f, -1.78764190e-03f, -6.99221492e-02f, -2.01562345e-02f, 1.31745562e-02f, -4.74600531e-02f, -4.08924408e-02f,
  -7.52639920e-02f, -1.84602868e-02f, 1.97005998e-02f, -4.66490425e-02f, 5.34117781e-02f, -3.60694490e-02f, -1.22509897e-02f, -2.80382466e-02f, -9.75175500e-02f, -3.05693541e-02f,
  -5.83297201e-02f, 1.97286848e-02f, 5.38367704e-02f, -3.49577665e-02f, -1.39149964e-01f, -3.66211608e-02f, 3.07472702e-02f, 6.35007173e-02f, -2.57016942e-02f, -3.57049108e-02f,
  2.87835419e-01f, 2.78981864e-01f, 2.86972165e-01f, 2.16072202e-01f, -1.92113258e-02f, -8.63966346e-02f, -4.77300622e-02f, 1.58688694e-01f, 2.73860604e-01f, 2.35702787e-02f,
  -2.50716861e-02f, 1.65989384e-01f, -2.81121675e-02f, 2.04763398e-01f, -2.14802161e-01f, 8.93991441e-03f, 1.32641509e-01f, 2.19676588e-02f, 1.05469696e-01f, 1.25518546e-01f,
  -2.35348530e-02f, 2.29303129e-02f, 4.63653989e-02f, -3.66116166e-02f, 1.06874935e-01f, 5.26763462e-02f, -1.16091147e-01f, -7.22505674e-02f, -3.27558964e-02f, -1.18521459e-01f,
  -4.95414026e-02f, 1.52428132e-02f, 2.14060899e-02f, 7.99657628e-02f, -2.55472269e-02f, 1.05633847e-02f, -6.57780468e-02f, -9.55812857e-02f, -2.22993363e-02f, -2.31147408e-02f,
  -3.80044766e-02f, 8.65281653e-03f, 1.42104113e-02f, 2.90095042e-02f, 6.08253554e-02f, 1.71947517e-02f, 5.92266247e-02f, 6.90676644e-02f, 6.07723594e-02f, 1.67246517e-02f,
  6.28548041e-02f, -3.43438275e-02f, 2.45063696e-02f, -4.50008325e-02f, 2.48052157e-03f, 4.81403992e-02f, -5.88888042e-02f, -2.04863753e-02f, 2.85218433e-02f, 2.99999733e-02f,
  -5.69595844e-02f, 3.77441347e-02f, 1.31275700e-02f, 3.51300910e-02f, 5.66028357e-02f, -6.25600070e-02f, 2.39363983e-02f, -9.47658345e-03f, -1.41946031e-02f, -3.37311067e-02f,
  3.82495411e-02f, 5.46698133e-03f, 4.19599004e-02f, 2.27990635e-02f, -2.06721537e-02f, 7.06151873e-02f, -7.52071850e-03f, 1.17212925e-02f, 7.25795142e-03f, 5.33839315e-02f,
  -1.12787532e-02f, -3.35214660e-02f, 5.64205786e-03f, -6.33317605e-02f, -2.22448092e-02f, -3.26730423e-02f, 5.66997826e-02f, 5.95880598e-02f, 1.62904523e-02f, -3.67921516e-02f,
  -3.23286355e-02f, 1.43789858e-01f, 1.47503056e-02f, -4.80101816e-02f, 2.38298718e-02f, -3.81072313e-02f, -1.62674431e-02f, 2.41898447e-02f, -9.54435952e-03f, 5.56488708e-02f,
  -1.22075342e-02f, 2.14635255e-03f, -2.27024145e-02f, -2.85619348e-02f, -6.86268732e-02f, 2.17771884e-02f, -5.58044855e-03f, -4.86954562e-02f, -7.15864636e-03f, 8.36101733e-03f,
  5.60391229e-03f, -3.57931666e-02f, -2.44229864e-02f, 3.70559865e-03f, -6.67333826e-02f, -5.85896410e-02f, -2.72795539e-02f, 9.33568273e-03f, -5.78371584e-02f, 1.61315165e-02f,
  -3.94579768e-01f, -2.56031882e-02f, -4.01607603e-02f, -1.18890733e-01f, -3.01917840e-04f, 3.23593915e-01f, 1.82821825e-01f, -6.94688410e-02f, 1.21898316e-01f, 1.79300606e-01f,
  4.02047485e-02f, 6.74336627e-02f, 4.87870201e-02f, 9.22251195e-02f, -4.67821173e-02f, 1.43536478e-01f, 1.21682838e-01f, 8.64387602e-02f, 1.40283620e-02f, -9.30170938e-02f,
  -9.93948206e-02f, 4.37603518e-02f, -7.02242181e-02f, -1.33296356e-01f, -9.79865715e-02f, -2.26286069e-01f, -9.97365862e-02f, 5.69254626e-03f, -7.53482059e-02f, 5.11031300e-02f,
  -6.19537197e-02f, -6.54257983e-02f, -9.69495997e-02f, 2.00949106e-02f, -6.70182034e-02f, -3.71039584e-02f, 7.06572086e-03f, 4.68261838e-02f, 2.26441417e-02f, -7.30927987e-03f,
  1.03831626e-01f, -1.69071101e-03f, -4.35277596e-02f, 8.12487081e-02f, 3.78959887e-02f, 2.44681779e-02f, -3.03085819e-02f, 1.28344987e-02f, -1.41810765e-02f, -6.74964935e-02f,
  -2.49088928e-02f, 6.72555668e-03f, 5.29970042e-02f, 4.94853081e-03f, -6.44881353e-02f, 5.99271134e-02f, 7.76488110e-02f, 3.09322849e-02f, -1.25115877e-02f, 5.66257760e-02f,
  -1.06564090e-01f, 4.68886122e-02f, 4.20650430e-02f, -8.17841440e-02f, -1.05530061e-01f, -1.19881988e-01f, 4.17536609e-02f, -5.88821732e-02f, -6.87163621e-02f, 2.35438882e-03f,
  -3.32491696e-02f, 3.43270563e-02f, -5.99749163e-02f, 7.59788379e-02f, 2.78552044e-02f, -4.65302505e-02f, 3.29858661e-02f, -8.02259427e-03f, -2.75658397e-03f, -5.27488180e-02f,
  6.69212220e-03f, 4.08813776e-03f, 3.13105285e-02f, 5.78127690e-02f, -1.61124561e-02f, 5.23996688e-02f, 4.18418460e-02f, -1.21829165e-02f, 3.68864313e-02f, 1.86290441e-03f,
  -3.19428183e-03f, -1.21168740e-01f, 1.62816159e-02f, -5.66826202e-05f, 3.53604183e-03f, -2.97532231e-02f, 5.52956611e-02f, -4.80288602e-02f, -2.44451314e-03f, -1.31429518e-02f,
  -3.60496975e-02f, -7.07051950e-03f, 7.83530325e-02f, -2.45961305e-02f, 1.12085436e-02f, 6.90369459e-04f, 6.18555658e-02f, -1.31630097e-02f, -1.94929168e-02f, -1.98779609e-02f,
  3.22566787e-03f, 1.93915819e-03f, 1.17579736e-02f, -9.48423296e-02f, 2.51597754e-04f, 1.48524297e-02f, 2.47323141e-02f, 3.93706188e-02f, -5.25197834e-02f, 1.41857332e-02f,
  -1.19811147e-01f, -2.24133432e-01f, 6.32594600e-02f, -2.48172030e-01f, 8.70465264e-02f, -1.08515397e-01f, -9.88096520e-02f, -4.74533625e-02f, -7.07468539e-02f, -8.12514685e-03f,
  -8.76800194e-02f, 1.58494160e-01f, 4.66353893e-02f, -2.78562307e-01f, -1.79400772e-01f, -1.40089482e-01f, -4.11954582e-01f, -6.92904741e-02f, -1.58923510e-02f, -9.41436216e-02f,
  -1.36549875e-01f, -1.79842263e-01f, -5.54565340e-02f, -2.39051245e-02f, 1.63587909e-02f, 9.64180827e-02f, -4.49333265e-02f, 1.23683043e-01f, -5.91829419e-02f, 9.78019927e-03f,
  3.41481492e-02f, 5.12361377e-02f, 6.38178065e-02f, 4.16743308e-02f, -2.59739179e-02f, -1.31825209e-02f, 5.49887400e-03f, 2.39678714e-02f, 3.93157713e-02f, -2.36998429e-03f,
  3.28727663e-02f, 7.35980421e-02f, -3.60802189e-02f, 5.86952269e-02f, 7.11540552e-03f, -2.25883853e-02f, -5.45197539e-03f, -7.75531773e-03f, 5.09047881e-03f, -3.91812995e-02f,
  2.26967428e-02f, 6.07297197e-02f, -2.22069658e-02f, 1.19912932e-02f, -5.13699185e-03f, -5.02838232e-02f, -5.24644516e-02f, 8.61760378e-02f, -6.19854312e-03f, 5.11263823e-03f,
  -6.07143007e-02f, 1.40571063e-02f, -2.65378156e-04f, -5.03662564e-02f, 7.13479370e-02f, -5.04834950e-02f, 1.82641428e-02f, -4.57956381e-02f, 4.20509130e-02f, -3.01078744e-02f,
  -4.69415933e-02f, 4.95368652e-02f, -3.73158306e-02f, -1.07686436e-02f, -5.04131243e-03f, -3.60180065e-02f, 3.43683623e-02f, -2.32040305e-02f, -3.70099582e-02f, 2.58605881e-03f,
  -5.96430190e-02f, -2.78422851e-02f, -1.48880957e-02f, -5.64211756e-02f, 8.07562750e-03f, 3.81396227e-02f, 2.28256006e-02f, -6.47758786e-03f, 2.50201486e-03f, -2.55207233e-02f,
  -1.39537007e-01f, -8.23973939e-02f, 1.00578303e-02f, -2.92293187e-02f, 6.12904765e-02f, -1.30665796e-02f, -8.52765366e-02f, -1.49069093e-02f, -7.20005408e-02f, 3.25603448e-02f,
  6.66722516e-03f, -2.08013263e-02f, 1.35864569e-02f, -8.41997564e-03f, -2.06523202e-02f, -8.71462077e-02f, 1.10882632e-02f, 1.76261291e-02f, 1.62815228e-02f, 3.57343033e-02f,
  6.43585101e-02f, -3.11582498e-02f, 3.63293141e-02f, 1.02481386e-02f, -1.83861796e-02f, 4.75242883e-02f, 6.23389380e-03f, -4.51211967e-02f, 1.16701573e-02f, 1.03073074e-02f,
  -4.38464046e-01f, 5.87629192e-02f, -2.04214558e-01f, -2.19501898e-01f, -1.00949861e-01f, 2.02594608e-01f, 1.91231236e-01f, -1.19242206e-01f, -8.53573624e-03f, 2.33822376e-01f,
  8.66191685e-02f, 7.40379766e-02f, 1.87505931e-01f, 1.79516628e-01f, 3.71564440e-02f, 1.64557219e-01f, -3.67729738e-02f, 3.76333781e-02f, -2.48465836e-02f, -5.86200766e-02f,
  -8.61502066e-02f, 9.64217782e-02f, -3.34550180e-02f, -6.34983480e-02f, -4.98325936e-02f, -1.73346594e-01f, -5.39895557e-02f, -7.78716654e-02f, -6.40236884e-02f, 7.78197264e-03f,
  7.69230500e-02f, 5.74178249e-02f, 2.39896271e-02f, -1.64149962e-02f, -1.75715648e-02f, -5.50047494e-04f, -3.07930950e-02f, 3.12212966e-02f, 1.22494400e-02f, 7.03458488e-02f,
  2.43658349e-02f, -2.34805932e-03f, -1.96962245e-02f, -6.79438487e-02f, -3.85978147e-02f, -4.18105908e-02f, -1.89966336e-02f, 6.38777949e-03f, 3.95243205e-02f, 5.73262908e-02f,
  -2.94246012e-03f, -3.24909687e-02f, -2.76047792e-02f, 1.93111389e-03f, 2.48228610e-02f, -3.29102539e-02f, 3.77284288e-02f, 1.41480519e-02f, 1.12695498e-02f, -6.89600408e-02f,
  3.85785679e-04f, -1.89825259e-02f, 1.70597564e-02f, -1.19775790e-03f, 3.86896096e-02f, 3.97384129e-02f, -3.03005148e-03f, 3.65463831e-02f, -3.12884301e-02f, 2.68122554e-02f,
  -1.92537066e-02f, -1.06873736e-02f, 1.46847509e-03f, 6.03462011e-02f, 7.87298632e-05f, 5.68461940e-02f, -3.29118334e-02f, 1.83711164e-02f, -9.06776786e-02f, 5.55393146e-03f,
  5.59755776e-04f, -2.31821351e-02f, 1.34674581e-02f, -3.22485380e-02f, 3.74324955e-02f, -3.60774100e-02f, -2.90431315e-03f, -7.07151815e-02f, 1.83741450e-02f, -3.82027030e-02f,
  7.57613704e-02f, -8.72447807e-03f, -4.95920554e-02f, -3.68180349e-02f, 4.05058414e-02f, 9.65873972e-02f, 8.45250711e-02f, -5.74062839e-02f, 1.31578995e-02f, -7.19061419e-02f,
  3.60730547e-03f, -1.96499154e-02f, -4.37567011e-02f, -5.20010181e-02f, -3.10653783e-02f, 4.03976589e-02f, -1.88628696e-02f, 3.76114063e-03f, -3.68757150e-03f, 1.66825037e-02f,
  2.91118864e-02f, 1.18323989e-01f, -1.03944847e-02f, -2.22063791e-02f, -2.51477938e-02f, -5.73412888e-02f, -2.55797314e-03f, -7.75809735e-02f, 2.15554312e-02f, 3.30986828e-02f,
  2.83123255e-01f, 9.23866499e-03f, 3.23261917e-01f, 1.00297213e-01f, 1.37565330e-01f, 3.82644475e-01f, 2.54518270e-01f, 4.00424115e-02f, -4.22291383e-02f, -1.18403479e-01f,
  7.25023672e-02f, 1.14721768e-01f, -1.58227593e-01f, 5.31176254e-02f, 1.44244909e-01f, -2.02068105e-01f, 1.57816261e-01f, 2.83627631e-03f, -1.14453450e-01f, 1.54723853e-01f,
  5.26866801e-02f, -1.34407906e-02f, 6.96219727e-02f, -1.72744393e-02f, 1.26325384e-01f, -3.07935253e-02f, -1.83433779e-02f, 2.71748099e-02f, 5.92703745e-02f, -1.44044161e-02f,
  -8.94108936e-02f, -1.57941893e-01f, 7.38315657e-02f, 2.64026374e-02f, 1.31052971e-01f, 6.57939464e-02f, 6.46211654e-02f, -1.66425146e-02f, -2.57582753e-03f, -1.86457450e-03f,
  -1.77717389e-04f, 1.08631290e-02f, 2.68145967e-02f, -3.53977419e-02f, -8.54602270e-03f, 2.32213456e-02f, 6.84547275e-02f, -1.53709659e-02f, -1.95248853e-02f, 3.30082327e-02f,
  1.15570258e-02f, 2.78196316e-02f, 8.53728205e-02f, -4.35621180e-02f, 4.84822802e-02f, 3.82287893e-03f, 1.94670223e-02f, -3.35200317e-02f, 6.12620823e-02f, 2.28903983e-02f,
  -7.23357964e-03f, -5.99583872e-02f, 1.74442157e-02f, -3.46747525e-02f, 4.76649730e-03f, -5.47999740e-02f, 3.32729220e-02f, -2.52872743e-02f, -2.25906260e-02f, -1.72772799e-02f,
  4.43738373e-03f, 1.53298490e-02f, 1.40254060e-02f, 1.04446951e-02f, 5.81317879e-02f, 2.43769865e-02f, -7.73563795e-03f, -8.41805805e-03f, 3.66640054e-02f, -2.55583022e-02f,
  -5.76705895e-02f, 2.90745050e-02f, -4.88649718e-02f, 3.60111780e-02f, 2.78781150e-02f, 3.66003066e-03f, -1.78679675e-02f, 1.86412539e-02f, -7.30600115e-03f, 5.56388386e-02f,
  7.14420155e-02f, 1.22080415e-01f, -5.16402125e-02f, -3.10365902e-03f, -9.46982428e-02f, 2.11755298e-02f, 3.46180028e-03f, 1.96071863e-02f, 1.59779638e-02f, 5.24341054e-02f,
  8.71585086e-02f, 3.32250372e-02f, 5.45336753e-02f, -1.08975666e-02f, -2.38620061e-02f, -2.16574166e-02f, -1.17850099e-02f, 1.18769053e-02f, 5.53536452e-02f, -3.14213894e-02f,
  -1.79770216e-02f, -3.96576663e-03f, -5.26164472e-02f, 3.04072704e-02f, -4.73209703e-03f, 5.21647371e-02f, 5.55150956e-02f, -1.79986320e-02f, 2.44588368e-02f, 3.69048603e-02f,
  2.47230083e-01f, -5.20148456e-01f, -1.45369824e-02f, -1.51545748e-01f, 2.34783679e-01f, 4.38003875e-02f, 4.89670336e-02f, -8.96299705e-02f, -9.27192271e-02f, -2.24836245e-01f,
  1.27721354e-02f, -9.97160599e-02f, -1.92520082e-01f, -1.94574058e-01f, 7.94923753e-02f, -2.11666003e-01f, -1.21762834e-01f, -6.82635978e-02f, -1.37314815e-02f, -1.20529249e-01f,
  -1.77629795e-02f, 3.17219198e-02f, -1.42572701e-01f, -5.00774793e-02f, 3.85542214e-02f, -1.03433318e-02f, 3.53203453e-02f, 6.43269047e-02f, 1.31037151e-02f, 8.20528436e-03f,
  5.74721135e-02f, -7.70180626e-03f, 2.21355446e-02f, 8.94631818e-02f, 2.97341822e-03f, 4.99680638e-02f, -1.49353994e-02f, 7.26995841e-02f, 1.03239007e-01f, -2.05190387e-02f,
  -5.40098920e-03f, 2.91237608e-02f, -5.37106618e-02f, 3.54762003e-02f, -9.92762391e-03f, 1.35673191e-02f, 5.00300713e-03f, 7.67094344e-02f, -2.36483663e-03f, -1.06978668e-02f,
  -3.13251577e-02f, -3.53416055e-02f, 2.74110795e-03f, -3.36956717e-02f, -1.66010857e-02f, 1.36636654e-02f, -4.56916243e-02f, -1.64990928e-02f, 3.35494876e-02f, 4.56703594e-03f,
  -3.14773619e-02f, 9.09487437e-03f, -9.13427025e-03f, 3.18516903e-02f, -1.97022744e-02f, 6.98919669e-02f, -3.37352492e-02f, 3.71202715e-02f, -1.60901397e-02f, 1.96234193e-02f,
  -2.10678503e-02f, -9.62202623e-03f, 1.31029058e-02f, 2.51283608e-02f, 2.24122815e-02f, 5.11980392e-02f, -1.16441213e-02f, 2.97246668e-02f, 2.88492106e-02f, 1.31089548e-02f,
  3.52776833e-02f, 2.11356543e-02f, 9.51090921e-03f, 7.18271965e-03f, -3.86090949e-03f, 4.22171354e-02f, -9.21762839e-04f, -2.83049252e-02f, 3.46470661e-02f, -3.41587849e-02f,
  -1.91685706e-01f, -3.12069803e-01f, -8.54033008e-02f, 2.75184144e-03f, -2.28826851e-02f, 1.38155383e-03f, 1.44845797e-02f, -8.01858082e-02f, -8.50804597e-02f, 1.06459977e-02f,
  5.20944744e-02f, -1.09105213e-02f, -6.73948927e-03f, -4.17360850e-02f, 2.41478700e-02f, -7.03440746e-03f, -3.08894105e-02f, -1.06715532e-02f, -6.99695274e-02f, 4.04379293e-02f,
  -5.72724268e-03f, 5.45323901e-02f, 2.30394863e-02f, -4.45836782e-02f, -2.84277834e-02f, -3.41862366e-02f, 1.21483048e-02f, 4.65810634e-02f, -4.86095250e-03f, -7.02455044e-02f,
  -5.40963888e-01f, 1.05267376e-01f, 9.60343480e-02f, -2.40554214e-01f, -1.62593976e-01f, 1.18464241e-02f, -2.64117308e-02f, -1.56888351e-01f, -7.44274780e-02f, 9.86926816e-03f,
  -9.58961621e-02f, 7.15972334e-02f, 1.23843923e-01f, -1.42555460e-02f, -3.34028639e-02f, 1.30582854e-01f, -1.33229300e-01f, -7.25667477e-02f, 1.34143084e-02f, -1.05888002e-01f,
  -5.94705865e-02f, -4.96281236e-02f, 9.49162096e-02f, -5.99164404e-02f, 1.40416864e-02f, -6.90119565e-02f, 1.03524653e-03f, 8.69800597e-02f, -1.05409749e-01f, -7.24927755e-03f,
  -9.11683515e-02f, -1.37161255e-01f, -5.00927232e-02f, 7.03306645e-02f, -3.86688933e-02f, -3.15830931e-02f, 3.58644389e-02f, 3.51866428e-03f, -2.86481492e-02f, -3.77876647e-02f,
  2.86882999e-03f, -9.46478453e-03f, -3.64815257e-02f, 2.24170312e-02f, 7.42526129e-02f, 1.48268891e-02f, 3.87125015e-02f, -8.42222292e-03f, -8.98886658e-03f, 6.51611835e-02f,
  2.73485985e-02f, 2.31928118e-02f, -2.60129869e-02f, 3.08975559e-02f, -2.12664232e-02f, 1.31710889e-02f, 2.36031115e-02f, 4.45410460e-02f, -9.16323364e-02f, -3.40754986e-02f,
  -4.43017576e-03f, -2.23464519e-02f, 5.60851069e-03f, 1.69585608e-02f, -1.22479340e-02f, -6.28243461e-02f, -3.07023805e-02f, 3.28302314e-03f, -8.82893894e-03f, -3.18834409e-02f,
  -5.17902635e-02f, -3.62478271e-02f, 8.83540604e-03f, -1.60975270e-02f, -1.91709660e-02f, -3.59801129e-02f, -2.34807227e-02f, 1.42027522e-02f, 4.89284582e-02f, -1.31972332e-03f,
  -1.92481186e-02f, 2.45384574e-02f, -1.24449190e-02f, -2.18156143e-03f, 7.06210826e-03f, 7.26110786e-02f, 3.63900363e-02f, 8.58128890e-02f, 2.87617464e-02f, -5.15037999e-02f,
  6.72410578e-02f, -1.00845113e-01f, 5.01919873e-02f, -3.53176855e-02f, 3.66967060e-02f, -3.36667919e-03f, -7.42270565e-03f, 1.09931761e-02f, 5.43263322e-03f, -3.01738182e-04f,
  1.36528406e-02f, 3.48543227e-02f, -3.83338593e-02f, 1.18476134e-02f, 6.98536215e-03f, -2.16032029e-03f, -1.64932720e-02f, -6.98915198e-02f, -5.41092530e-02f, -1.73722692e-02f,
  -4.46370728e-02f, -2.29912754e-02f, -2.81663183e-02f, -5.08261472e-02f, -6.23617545e-02f, 5.95275573e-02f, -4.10822555e-02f, -2.57051759e-03f, -1.49300378e-02f, 4.85889688e-02f,
  1.75504684e-01f, -2.64959157e-01f, -1.30583467e-02f, 1.70674697e-01f, -1.18269421e-01f, -1.05251372e-01f, 7.38326868e-04f, -6.80279881e-02f, 7.72186071e-02f, -8.99989456e-02f,
  1.07190691e-01f, -5.63937798e-02f, 1.98351875e-01f, 1.34492340e-02f, 4.80176896e-01f, 2.36195952e-01f, 1.97437823e-01f, 2.55959444e-02f, 6.15178607e-02f, -2.17109770e-02f,
  1.87063664e-01f, 4.77354825e-02f, 1.56723872e-01f, -8.27920958e-02f, -1.26237810e-01f, -9.17236507e-02f, -3.05024511e-03f, -7.61404485e-02f, -1.00530773e-01f, -6.20363168e-02f,
  1.44033497e-02f, 3.62411402e-02f, -6.11784111e-04f, -2.19610967e-02f, 8.88303109e-03f, -8.14912692e-02f, -9.30508748e-02f, -6.97188731e-03f, -1.26994485e-02f, -7.89662264e-03f,
  -2.09313594e-02f, 7.32389092e-02f, 4.31459025e-02f, 5.56431413e-02f, -9.70422328e-02f, 7.82993343e-03f, -3.19837518e-02f, 1.60562787e-02f, -1.30363842e-02f, 2.20994875e-02f,
  7.97393825e-03f, 1.91976957e-04f, -5.02995253e-02f, 7.39025995e-02f, 1.29341101e-02f, -3.59112304e-03f, 1.55646894e-02f, -6.58218237e-03f, -1.97162665e-02f, -5.32408664e-03f,
  -3.15002315e-02f, 5.90136833e-02f, -5.18247597e-02f, -1.07006645e-02f, 5.62001392e-03f, 1.30238030e-02f, 2.91760708e-03f, 3.48261818e-02f, -2.91602351e-02f, -1.47627881e-02f,
  -3.54163512e-03f, -3.42605151e-02f, 1.55519424e-02f, -4.28736433e-02f, 4.15356383e-02f, -7.30393901e-02f, -2.82039437e-02f, -3.46302725e-02f, -1.08018285e-02f, -7.24234106e-03f,
  1.68604963e-02f, -1.25260148e-02f, -4.49275374e-02f, -9.06980317e-03f, 5.90140745e-02f, 1.46391038e-02f, 1.70657970e-02f, -1.56148244e-02f, -2.17436980e-02f, -7.32689397e-03f,
  -6.49867766e-03f, -6.20844103e-02f, 1.83435045e-02f, -1.72452405e-02f, -1.60220955e-02f, 1.12793138e-02f, 3.12494710e-02f, -5.52620739e-02f, 3.86180952e-02f, -1.20497784e-02f,
  6.87587215e-03f, -5.23548424e-02f, -4.33908626e-02f, -2.05834191e-02f, 4.14813645e-02f, 1.00868493e-02f, 3.10772285e-02f, -1.33687621e-02f, -4.94670011e-02f, 1.90627519e-02f,
  -8.16953778e-02f, -6.09273240e-02f, 6.72940910e-02f, -4.36471216e-02f, 6.31025434e-02f, -1.76542606e-02f, -4.55688313e-02f, 1.50484522e-03f, 3.08151245e-02f, 6.74057752e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.61711240e-01f, 2.85558671e-01f, 1.23704813e-01f, 1.72191098e-01f, -3.56091373e-02f, 3.88680175e-02f, 9.44317132e-03f, -2.62262262e-02f, 1.55818373e-01f, 3.16216163e-02f,
  -1.01929031e-01f, 1.73780471e-01f, -1.57686338e-01f, 8.34417269e-02f, -1.48968995e-01f, -1.89954072e-01f, 7.99820498e-02f, 1.14981167e-01f, 2.74730753e-02f, 1.56311706e-01f,
  4.42297123e-02f, -1.74451694e-01f, -1.77598730e-01f, -8.64994302e-02f, 1.47733107e-01f, 1.61743298e-01f, -1.35332674e-01f, 3.22147645e-02f, -1.09198671e-02f, -9.52663273e-02f,
  -7.59289861e-02f, 4.07678261e-02f, 6.96161836e-02f, -8.62217566e-04f, -2.85360161e-02f, 8.75049271e-03f, 3.28238048e-02f, 3.81544493e-02f, 3.50811817e-02f, 3.97825874e-02f,
  1.14391081e-01f, -6.22547530e-02f, 1.86680481e-02f, -2.30115261e-02f, 9.26747825e-03f, -3.04604555e-03f, 6.14639893e-02f, 5.67735918e-02f, -2.85353903e-02f, 4.01944965e-02f,
  1.20183639e-01f, 2.52264217e-02f, 3.65187749e-02f, 9.28401500e-02f, 1.02713309e-01f, -4.28138338e-02f, 8.34550783e-02f, 6.01450279e-02f, -3.73714417e-02f, 2.57525896e-03f,
  -1.76593987e-03f, 8.01369455e-03f, -4.21070447e-03f, -5.41704372e-02f, -1.67081486e-02f, 2.87289675e-02f, -4.21476774e-02f, -1.57273598e-02f, 2.45079156e-02f, 1.55264987e-02f,
  -3.32255140e-02f, 8.20661560e-02f, 7.07894797e-03f, 9.53657031e-02f, 8.29613805e-02f, -4.65613157e-02f, -4.55357246e-02f, 2.92610787e-02f, 5.83244152e-02f, 2.24986044e-03f,
  -6.37889728e-02f, 3.65969837e-02f, 2.13521961e-02f, -8.17023392e-04f, -1.91307552e-02f, 7.84329101e-02f, -3.54658477e-02f, 3.95821407e-02f, -3.25808004e-02f, -9.77851823e-02f,
  1.23316616e-01f, 1.03045203e-01f, 2.22857017e-02f, -2.56811995e-02f, 5.71021475e-02f, 7.88000003e-02f, 5.27661666e-02f, -2.67163292e-03f, 3.84113938e-02f, -5.85109554e-02f,
  8.08845758e-02f, -1.19053032e-02f, -1.78836826e-02f, -9.80258826e-03f, 3.69400121e-02f, -6.72560856e-02f, -6.60773739e-02f, 4.37862575e-02f, -3.69495228e-02f, 1.26395272e-02f,
  4.90449630e-02f, 8.22314546e-02f, -6.14707731e-02f, 2.41577509e-03f, 9.86153856e-02f, 7.86370039e-02f, 6.16665520e-02f, 1.16532603e-02f, -6.90555349e-02f, 8.30977783e-02f,
  1.37292087e-01f, 1.05939684e-02f, -2.60795560e-02f, 1.25726014e-01f, -3.08351945e-02f, -2.01548949e-01f, -1.73204795e-01f, 8.30013677e-02f, -1.86833754e-01f, -4.88225557e-02f,
  3.71996947e-02f, 8.72583501e-03f, -1.45389587e-01f, 1.12873428e-01f, 4.69777621e-02f, -2.67955333e-01f, 1.16050385e-01f, -2.15538349e-02f, -4.84472550e-02f, 1.08873010e-01f,
  1.20070867e-01f, 2.28245109e-01f, 8.43370110e-02f, 2.70612776e-01f, 1.23245217e-01f, 1.44640163e-01f, 3.94036025e-01f, 3.33936922e-02f, 2.67820835e-01f, 1.68812722e-01f,
  -3.40224244e-02f, 6.61007781e-03f, -6.52649626e-03f, 7.10237622e-02f, 6.88955635e-02f, 1.23425247e-02f, -2.67440137e-02f, 4.60229069e-03f, -1.92456990e-02f, 3.28686088e-02f,
  -8.88591353e-03f, 8.27281028e-02f, 4.21886779e-02f, 1.85974464e-02f, 7.25813210e-02f, 4.37120311e-02f, -5.76843284e-02f, -5.49331792e-02f, -3.67207751e-02f, -8.49655923e-03f,
  -1.44116715e-01f, 1.26687279e-02f, 1.54949203e-02f, -1.34106688e-02f, -8.59013274e-02f, 1.68075953e-02f, 1.39007606e-02f, -1.96648948e-02f, -7.06263930e-02f, 6.06503338e-02f,
  -7.40434555e-03f, -3.40312757e-02f, 7.11601302e-02f, -4.43163421e-03f, -1.14182206e-02f, -4.24895510e-02f, -2.00198069e-02f, -4.22999933e-02f, 1.64144710e-02f, 7.75991380e-03f,
  -4.34639677e-02f, -1.28617473e-02f, -1.12073012e-02f, -5.21146208e-02f, -7.30632767e-02f, -1.05883881e-01f, -7.37109408e-02f, 2.99363397e-02f, 3.29088303e-03f, -1.04198329e-01f,
  -3.52010280e-02f, 3.83089222e-02f, -4.95546833e-02f, -6.59506321e-02f, 8.92493129e-03f, 4.68010083e-02f, 7.69769847e-02f, -4.42601033e-02f, 7.31478911e-03f, 5.73747559e-04f,
  -2.72546709e-02f, 1.21642232e-01f, -1.70658026e-02f, -3.79281715e-02f, 4.25684191e-02f, -1.63954105e-02f, -2.24781130e-02f, 1.77142641e-03f, 4.36431728e-02f, -4.10058349e-02f,
  7.88255967e-03f, 1.47702182e-02f, -2.07269434e-02f, 9.46632922e-02f, 6.01743460e-02f, 5.43354172e-03f, 2.25401353e-02f, 1.52070737e-02f, 2.25377157e-02f, 8.42961818e-02f,
  9.83152017e-02f, -3.10914908e-02f, 1.12066500e-01f, -7.19017461e-02f, -2.51137614e-02f, -7.41541833e-02f, 1.08131431e-01f, 9.12984237e-02f, 6.59203157e-02f, -3.55752632e-02f,
  -1.30661443e-01f, -3.95367406e-02f, 1.79707691e-01f, -1.58710908e-02f, -4.81717177e-02f, 6.49049506e-02f, 6.83488101e-02f, 1.14471920e-01f, 5.49068302e-02f, -7.22071975e-02f,
  4.80132103e-02f, -8.67985785e-02f, -8.72576833e-02f, -5.18825538e-02f, -6.59677535e-02f, -6.48848265e-02f, 3.13771353e-03f, 5.18018603e-02f, 5.72685115e-02f, 6.34214357e-02f,
  -8.10988173e-02f, -1.01821586e-01f, 1.64525062e-02f, 2.11675465e-02f, 7.13867396e-02f, 3.23204622e-02f, 3.91838215e-02f, 3.99318663e-03f, -2.90270299e-02f, -9.16864201e-02f,
  -6.18773093e-03f, 2.64102537e-02f, -1.53315002e-02f, 7.50788897e-02f, 1.55116618e-01f, 7.02017397e-02f, 8.49334970e-02f, -9.01396573e-03f, 3.49660888e-02f, 4.19759005e-03f,
  -1.20791160e-02f, 7.76598379e-02f, -8.15857854e-03f, 6.49461448e-02f, 5.97391687e-02f, 7.32040824e-03f, 7.61739165e-03f, -3.07594035e-02f, 8.02855715e-02f, 9.64399427e-02f,
  2.18266640e-02f, 7.67371356e-02f, 1.95712480e-03f, 9.94539708e-02f, 9.81137231e-02f, 8.41733962e-02f, 3.54708061e-02f, 2.56196372e-02f, 4.23266180e-02f, -5.01628444e-02f,
  9.34990123e-03f, 1.17717773e-01f, 1.96097400e-02f, 3.97581831e-02f, -9.75142568e-02f, -1.09243847e-01f, 4.83127572e-02f, -2.51300521e-02f, 3.27512398e-02f, 2.81670713e-03f,
  -6.83034435e-02f, -1.42246922e-02f, 7.27000355e-04f, 5.24278358e-03f, 2.16598921e-02f, -8.70909169e-02f, -7.82571640e-03f, 8.91986024e-03f, 5.79178967e-02f, -5.11842072e-02f,
  -7.35643283e-02f, 1.77706853e-02f, -3.75662930e-02f, -9.86588597e-02f, 2.01774817e-02f, -1.00583462e-02f, -4.73420955e-02f, -8.77830237e-02f, -2.60189120e-02f, -7.29025453e-02f,
  -2.71810517e-02f, 1.87062606e-01f, 6.65058196e-02f, 6.85458928e-02f, 1.61674269e-03f, 3.04695275e-02f, -1.19866608e-02f, 7.22623393e-02f, -1.88889094e-02f, 4.00577262e-02f,
  -5.16484976e-02f, 1.52902026e-02f, 1.55388163e-02f, 3.07004377e-02f, 1.58671662e-02f, 7.59610683e-02f, -1.76912956e-02f, 5.96886966e-03f, 5.01070283e-02f, 9.63278934e-02f,
  1.28742615e-02f, -8.94853100e-02f, 8.50462243e-02f, -6.47210777e-02f, 2.85381451e-02f, -3.71899493e-02f, -2.83622220e-02f, 6.52719960e-02f, 7.28375912e-02f, 7.07008839e-02f,
  4.80689779e-02f, -5.62972948e-02f, -1.32675797e-01f, -7.95287564e-02f, 4.03682254e-02f, 8.66817981e-02f, 2.83963722e-03f, -2.75393017e-02f, -1.19743727e-01f, -3.01921275e-02f,
  1.24025680e-01f, -2.79875547e-02f, -5.23503982e-02f, 7.16082975e-02f, 5.02122045e-02f, 5.09167276e-02f, 5.91223910e-02f, 7.00575262e-02f, 3.24359946e-02f, -9.66222771e-03f,
  -1.01303861e-01f, 1.20164901e-01f, -4.60918806e-02f, 8.10885727e-02f, 5.48172668e-02f, -7.57441372e-02f, 1.14501668e-02f, 8.22127834e-02f, 5.24758175e-02f, -6.91527352e-02f,
  3.27446149e-03f, 7.80617818e-02f, 1.08657509e-01f, 1.17638446e-01f, 6.59985393e-02f, -4.73203231e-03f, -6.43532304e-03f, -3.28864716e-02f, -8.57365876e-02f, 5.16566746e-02f,
  4.55566309e-03f, 2.16087587e-02f, 4.84773330e-03f, -3.41013726e-03f, -4.33299392e-02f, -1.20855048e-01f, -1.01090930e-01f, 1.33218393e-02f, -1.17345087e-01f, 9.05630291e-02f,
  -8.27792808e-02f, 6.24481328e-02f, -2.76539270e-02f, -4.50551100e-02f, -5.83951958e-02f, 4.17502895e-02f, -9.54707712e-02f, 4.42336164e-02f, -3.89093496e-02f, 3.18030193e-02f,
  1.10290647e-01f, -4.30353768e-02f, -3.91878448e-02f, -1.08972611e-02f, 1.09763416e-02f, 5.80620319e-02f, 1.34180514e-02f, 4.04828191e-02f, -2.04793364e-03f, 4.67954539e-02f,
  -3.22332866e-02f, 4.93926331e-02f, 6.55466095e-02f, -6.36652038e-02f, 4.34437022e-02f, 8.59881565e-02f, -3.86242047e-02f, 5.56431105e-03f, 2.87418868e-02f, -6.93028141e-03f,
  -7.82172903e-02f, 9.56681520e-02f, -4.42780480e-02f, -9.55970399e-03f, 8.37999955e-02f, -8.01785756e-03f, 5.24926484e-02f, 1.00772701e-01f, -5.75574208e-03f, -2.15656906e-02f,
  7.20298588e-02f, -7.05302460e-04f, -6.49717003e-02f, 2.56001297e-02f, 3.01732030e-02f, -1.85711663e-02f, 2.23501562e-03f, 3.30002755e-02f, 9.68882665e-02f, 9.59191322e-02f,
  -6.03247061e-03f, -6.14930578e-02f, 2.52085384e-02f, 4.20467742e-02f, -6.75374568e-02f, -1.93252508e-03f, 5.63608184e-02f, 3.42655592e-02f, -4.66226451e-02f, 6.80536926e-02f,
  6.15485869e-02f, -5.47603741e-02f, -5.18780947e-02f, 2.45756842e-02f, -1.59525741e-02f, 6.91411793e-02f, -1.47477472e-02f, 4.37711962e-02f, 7.93747231e-02f, 3.30736004e-02f,
  7.82551095e-02f, -2.85984986e-02f, 1.31244227e-01f, 2.96366010e-02f, -6.32172450e-02f, -1.34656459e-01f, -7.94315115e-02f, 9.63263027e-03f, 7.87168369e-02f, -9.78507027e-02f,
  -9.37248468e-02f, 4.73114550e-02f, -7.40998834e-02f, -8.64201486e-02f, -9.15905181e-03f, 6.71811476e-02f, -9.00675356e-02f, 2.74425540e-02f, 2.85142530e-02f, 4.23130058e-02f,
  3.20321172e-02f, -6.30197152e-02f, 1.39860332e-01f, -5.13596274e-02f, 7.58822262e-02f, 1.71039104e-01f, 3.08363028e-02f, 3.76965501e-03f, -3.03236973e-02f, -6.19561933e-02f,
  -4.82733585e-02f, -3.97594832e-02f, 1.18152782e-01f, -7.10314363e-02f, -5.58494367e-02f, -8.09110850e-02f, 5.19751478e-03f, 6.64598634e-03f, -9.63925272e-02f, -4.96266112e-02f,
  1.53615149e-02f, -5.95143400e-02f, -6.63222000e-02f, 2.26113629e-02f, -3.03369164e-02f, 3.82469557e-02f, -2.24602483e-02f, 5.31762652e-02f, 4.71364036e-02f, -7.87991285e-03f,
  -2.23333128e-02f, 9.28786676e-03f, -3.55366729e-02f, -5.05787991e-02f, 8.52792189e-02f, -6.25964627e-02f, -4.94240411e-02f, 7.40117654e-02f, 3.14820074e-02f, -7.67077804e-02f,
  5.67014106e-02f, -6.26310483e-02f, -2.85100974e-02f, -8.10979381e-02f, -6.09391890e-02f, 7.61095760e-03f, -2.98679247e-02f, -4.60974015e-02f, 4.12283130e-02f, 3.67795862e-02f,
  5.69475777e-02f, 1.45852854e-02f, -5.39336167e-02f, -9.37499478e-02f, -4.79943585e-03f, 4.38563563e-02f, 5.10314927e-02f, -1.33098308e-02f, 1.03845363e-02f, -1.85828675e-02f,
  -4.42651510e-02f, 5.45344017e-02f, 8.88388511e-03f, 4.66738567e-02f, 5.46766929e-02f, 1.98649913e-02f, -8.29916447e-03f, 5.06274775e-02f, -2.16507986e-02f, -7.30701834e-02f,
  3.77880782e-02f, 5.61144985e-02f, 5.69713674e-03f, -8.01994130e-02f, -4.11742628e-02f, -1.04453057e-01f, 4.46204916e-02f, -6.82166219e-02f, 6.25197217e-02f, -6.48915991e-02f,
  5.30837514e-02f, 7.92808086e-02f, 3.22355926e-02f, -5.10643274e-02f, 4.80566034e-03f, 4.10743691e-02f, 3.12564000e-02f, -7.35981464e-02f, -8.94044340e-03f, 8.56656656e-02f,
  1.07304320e-01f, -9.55512561e-03f, -7.47148320e-02f, -2.07504281e-03f, 3.14047784e-02f, 6.98004887e-02f, 8.94781277e-02f, 2.10406370e-02f, 1.77579522e-02f, -5.10430709e-02f,
  -1.91473514e-01f, 2.59395957e-01f, -2.45739482e-02f, 6.90346807e-02f, 1.65292352e-01f, 2.01006278e-01f, 1.12121239e-01f, 1.93558082e-01f, 1.64168492e-01f, -1.25294074e-01f,
  -1.36110440e-01f, -5.28201051e-02f, -6.45748526e-02f, 4.06342633e-02f, 2.28514764e-02f, -4.26802114e-02f, 4.18261103e-02f, 9.86589584e-03f, 2.13798165e-01f, -6.11482449e-02f,
  6.63298815e-02f, 9.96082574e-02f, -2.87274774e-02f, 2.10604854e-02f, -5.33970296e-02f, -1.09409250e-01f, -1.60677239e-01f, 5.53623140e-02f, 7.02107837e-03f, 5.04863411e-02f,
  -6.87305033e-02f, 4.58539911e-02f, -4.01372053e-02f, 1.61799621e-02f, 5.33322282e-02f, -1.30499259e-01f, -4.29501571e-02f, -6.80022314e-02f, 2.83809546e-02f, 1.74764358e-02f,
  4.06009555e-02f, -4.44147103e-02f, 4.49714139e-02f, -8.57986361e-02f, -3.90385725e-02f, -4.68165688e-02f, -4.34663557e-02f, 1.58095006e-02f, -3.33733298e-02f, -2.12281030e-02f,
  -3.13446149e-02f, 8.59350711e-03f, 2.87631974e-02f, -1.14973029e-02f, 1.68940686e-02f, -4.17695753e-02f, 4.12534922e-02f, -7.55593330e-02f, 2.00333167e-02f, 5.58806211e-02f,
  3.30478586e-02f, -7.68437225e-04f, -4.46559563e-02f, -3.81315351e-02f, -9.59219225e-03f, -7.20338374e-02f, 2.37040035e-02f, -5.90125620e-02f, 3.67466211e-02f, -5.22523075e-02f,
  6.60699308e-02f, 7.02626556e-02f, 6.16624719e-04f, -8.93128663e-03f, -5.74963354e-03f, -2.87536010e-02f, -2.02570930e-02f, -2.29094867e-02f, 5.62157519e-02f, 2.93686148e-02f,
  3.25539000e-02f, 8.15952718e-02f, -6.92535937e-02f, 8.91827196e-02f, 2.97693145e-02f, 2.12249588e-02f, 6.14212118e-02f, -1.35221547e-02f, 2.96207741e-02f, 1.58269480e-02f,
  6.33051097e-02f, 3.06803528e-02f, 3.10987812e-02f, -3.09716575e-02f, -2.56878808e-02f, -5.00262454e-02f, -3.05133369e-02f, -5.57914265e-02f, -1.99696478e-02f, 2.95322631e-02f,
  7.85181820e-02f, -7.16270432e-02f, -1.43103010e-03f, -2.18824716e-03f, 6.02982156e-02f, 5.47692971e-03f, -4.11964506e-02f, 2.30553076e-02f, 4.87070270e-02f, 4.41558585e-02f,
  7.16663292e-03f, -2.18154378e-02f, -1.08202867e-01f, -4.08300608e-02f, -4.41710949e-02f, 3.83449569e-02f, -1.15720881e-03f, -5.40760681e-02f, 7.44144693e-02f, 5.90834441e-03f,
  -1.61859572e-01f, 3.33909765e-02f, 1.07534684e-01f, 1.90293994e-02f, -1.85527027e-01f, -8.79411120e-03f, 2.65644747e-03f, 8.93175155e-02f, -4.02631462e-02f, 6.99232891e-02f,
  -7.69988215e-03f, -3.56923193e-02f, 1.50501773e-01f, 4.81459908e-02f, 9.54774097e-02f, 5.04004471e-02f, 1.00589357e-01f, 9.74534675e-02f, -4.84578423e-02f, 7.91012309e-03f,
  1.12210840e-01f, 1.11244461e-02f, 1.70620129e-01f, 2.79573351e-03f, 3.84911522e-02f, -5.80295958e-02f, 5.54990321e-02f, -6.14138134e-02f, -1.12480722e-01f, -3.73192728e-02f,
  -1.15603499e-01f, -4.97427098e-02f, -9.61304381e-02f, 2.00593062e-02f, 7.84379058e-03f, 5.62132783e-02f, -5.95549680e-02f, 4.91812872e-03f, 1.86942983e-02f, -4.17159498e-02f,
  -3.64076011e-02f, -1.50603214e-02f, -4.52152304e-02f, -2.01627538e-02f, -3.66042070e-02f, -8.18942264e-02f, 1.67937856e-02f, -2.02805325e-02f, 2.19419301e-02f, -6.93606213e-02f,
  6.77407384e-02f, -7.96465948e-03f, -2.31417213e-02f, 7.99587518e-02f, -2.75502503e-02f, -7.14133307e-02f, -4.47776839e-02f, -7.26527795e-02f, -3.63491615e-03f, -6.76580518e-02f,
  9.81267169e-02f, 3.52142602e-02f, 6.97732866e-02f, -1.09083662e-02f, -6.70094639e-02f, 4.43073601e-04f, -4.22588177e-02f, 5.34298010e-02f, -3.99799831e-02f, 8.03279430e-02f,
  -8.84061754e-02f, 1.78474281e-02f, 5.78845441e-02f, -7.96123967e-02f, 2.86165979e-02f, 6.13370240e-02f, 7.66652375e-02f, -4.76822443e-02f, -5.65077830e-03f, 9.07725096e-02f,
  5.26493713e-02f, -3.77876079e-03f, 8.58024042e-03f, 1.18799591e-02f, -7.37626329e-02f, 8.95912573e-02f, -1.04298908e-02f, 1.55298244e-02f, -6.81335398e-04f, -4.27572057e-02f,
  -8.78600553e-02f, -4.18826826e-02f, 8.09048768e-03f, -2.57666968e-02f, 4.17141989e-02f, -4.10894677e-02f, 4.81949784e-02f, 6.93436041e-02f, -9.91317257e-02f, 3.04756034e-02f,
  -2.21960731e-02f, 1.07459221e-02f, -9.27030370e-02f, -1.97226228e-03f, 5.24105169e-02f, -7.61509761e-02f, -9.36707631e-02f, 9.42046121e-02f, 7.28521543e-03f, -1.63563080e-02f,
  -4.71804962e-02f, 3.89502645e-02f, 7.85574690e-02f, -1.87827479e-02f, -3.00221723e-02f, -3.14614326e-02f, 5.81177697e-02f, -5.54146655e-02f, -3.38819548e-02f, -8.80703144e-03f,
  5.36230169e-02f, 2.40744501e-01f, 4.71826307e-02f, -1.99179370e-02f, -1.38797402e-01f, -3.66013646e-01f, -2.43677229e-01f, 3.00274114e-03f, 1.15486458e-01f, 1.27071977e-01f,
  -6.60152361e-02f, 2.20412850e-01f, 2.63436269e-02f, -1.31115811e-02f, -2.00965062e-01f, -1.62476348e-03f, -1.99010044e-01f, -1.45613715e-01f, -1.15790710e-01f, -2.34797411e-02f,
  -2.43144147e-02f, -9.27061439e-02f, -1.59671411e-01f, 2.15997435e-02f, -1.31760255e-01f, 1.10204570e-01f, -3.58878970e-02f, 5.26654795e-02f, -1.69417472e-03f, -2.59607434e-02f,
  -4.65123095e-02f, 5.16768731e-02f, 7.97243193e-02f, 2.58008968e-02f, -8.46871510e-02f, -5.51076718e-02f, -8.38643610e-02f, -1.62679181e-02f, 1.66320428e-02f, -3.47099528e-02f,
  5.78700937e-02f, 4.76723053e-02f, 1.16562117e-02f, -7.84870144e-03f, 5.90265878e-02f, 6.65557534e-02f, -5.22501655e-02f, -5.05911894e-02f, 7.14968666e-02f, 6.90686405e-02f,
  -4.56384607e-02f, -1.79208200e-02f, -4.52029221e-02f, -3.54995579e-02f, -2.50881631e-02f, 3.37411799e-02f, -4.16864678e-02f, -2.91160662e-02f, 2.77211843e-03f, 4.54382934e-02f,
  4.57684100e-02f, -1.00290544e-01f, -5.54393418e-02f, -1.67867262e-02f, -8.43441635e-02f, 5.60454745e-03f, -1.20740384e-02f, 3.11938711e-02f, 7.39605119e-03f, -5.30003123e-02f,
  3.48568596e-02f, 8.95314962e-02f, -1.24702146e-02f, -2.91849170e-02f, 3.54731083e-02f, 2.58485619e-02f, 6.01508208e-02f, 4.42817621e-02f, -4.64134738e-02f, -2.43624430e-02f,
  4.51229885e-02f, 1.26297642e-02f, 2.85223080e-03f, 2.00967342e-02f, -2.72045676e-02f, -9.78282071e-04f, 1.99301708e-02f, 4.61077951e-02f, -5.96456155e-02f, -3.93384416e-03f,
  -9.50328559e-02f, 1.79483797e-02f, -7.34612718e-02f, -4.72140685e-02f, -4.40174192e-02f, -5.00268154e-02f, 1.37425875e-02f, -1.71554368e-02f, -7.12796748e-02f, 1.51559925e-02f,
  -1.22186039e-02f, -9.07605514e-02f, -2.40277983e-02f, -1.71276822e-03f, -7.01961741e-02f, -2.49149557e-02f, 2.59076189e-02f, 6.16063587e-02f, -9.39742327e-02f, -4.33511008e-03f,
  -3.06992177e-02f, -6.80027306e-02f, -1.34081962e-02f, -4.97311540e-02f, -2.43025366e-02f, 3.48550491e-02f, 1.83300860e-02f, 3.65884490e-02f, 1.30445696e-02f, -3.13381702e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.62257656e-01f, 3.91968004e-02f, 7.42362738e-02f, 8.89222994e-02f, 5.40478751e-02f, 1.87071607e-01f, -3.56664998e-03f, 2.10814297e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.06019774e-01f, -1.48217782e-01f, -9.59472954e-02f, -3.80551778e-02f, -1.61594838e-01f, 3.97348762e-01f, -2.59946715e-02f, 1.42549857e-01f, -1.96495190e-01f, 1.39871001e-01f,
  -8.03770125e-02f, -1.73290700e-01f, 2.92627305e-01f, -2.27617949e-01f, -2.69563287e-01f, 5.53053953e-02f, -1.21860914e-01f, -4.45886515e-02f, 3.75517517e-01f, 1.70492068e-01f,
  -2.36493666e-02f, 2.90701836e-01f, 1.42548725e-01f, -2.16911823e-01f, -6.68148920e-02f, -8.32407847e-02f, 1.21771663e-01f, 3.32640707e-02f, 1.26416311e-01f, -7.85193592e-02f,
  -1.00261942e-01f, 1.60905998e-02f, 2.93497648e-02f, 1.36276469e-01f, -8.29415172e-02f, -2.66299900e-02f, -9.18444619e-02f, 4.51299489e-01f, 1.98857710e-02f, 3.90534788e-01f,
  -4.13678169e-01f, 3.07786107e-01f, 1.66292131e-01f, -1.14808129e-02f, 3.06683421e-01f, -4.52435622e-03f, -2.73851246e-01f, 4.70647544e-01f, -2.09646404e-01f, -7.08255395e-02f,
  3.88537824e-01f, 6.91317990e-02f, -1.93932772e-01f, -3.89650837e-03f, 2.36690015e-01f, -1.77572578e-01f, 2.48175904e-01f, -1.63118064e-01f, -6.73590675e-02f, -2.60804892e-02f,
  -1.48957595e-01f, -1.81029856e-01f, -1.88389406e-01f, 3.29985589e-01f, -9.61400643e-02f, 3.00329179e-02f, -2.01519758e-01f, -1.31759644e-01f, -3.69450897e-02f, -1.25531942e-01f,
  -1.21553972e-01f, -1.86200827e-01f, -8.65742415e-02f, 3.89802642e-02f, -1.39400661e-01f, -9.11709964e-02f, 1.75430536e-01f, -1.98576719e-01f, 7.64379948e-02f, -8.80444795e-02f,
  5.52348979e-02f, 1.72906652e-01f, -1.76331252e-01f, 2.48209313e-01f, -3.38462830e-01f, -1.68188035e-01f, 1.60635382e-01f, 1.66692287e-01f, -1.88945502e-01f, 1.18043803e-01f,
  3.56469490e-02f, 1.69901043e-01f, 1.19181350e-01f, 5.67157753e-02f, 1.11223750e-01f, 2.50860691e-01f, -3.02945435e-01f, -1.43678728e-02f, 2.21786305e-01f, 1.10404953e-01f,
  -1.01839975e-01f, -3.96704301e-02f, -8.91567469e-02f, -4.36712354e-02f, 2.22308375e-02f, -1.87762808e-02f, -1.11626178e-01f, -2.57545352e-01f, -6.92470744e-02f, -1.85644656e-01f,
  2.19214261e-02f, -1.02207102e-01f, 3.49492878e-01f, -2.00779632e-01f, -1.17927022e-01f, -2.66589612e-01f, -1.20232878e-02f, 1.76648200e-01f, -2.76359856e-01f, -3.25075358e-01f,
  1.88990578e-01f, 3.10846150e-01f, -1.09927051e-01f, -9.67389718e-02f, 8.80434066e-02f, 1.77950263e-01f, 4.80341353e-03f, -1.08406385e-02f, -1.81830138e-01f, -1.21448068e-02f,
  -1.06028363e-01f, -1.95775926e-01f, 1.30740618e-02f, -2.50606108e-02f, -7.61866570e-02f, -1.37889683e-01f, -1.82501599e-01f, -2.52702422e-02f, -3.81432176e-02f, 1.08865187e-01f,
  -5.84742904e-01f, -7.92920962e-02f, -1.10899664e-01f, -7.75507390e-02f, -1.87355801e-02f, -9.28324908e-02f, -1.76438361e-01f, 5.24962246e-02f, 3.22359979e-01f, 2.32200384e-01f,
  -2.66174853e-01f, 5.27235031e-01f, -2.23678306e-01f, 2.12009028e-01f, -2.80220538e-01f, 1.59392223e-01f, -6.07015006e-02f, -1.58118367e-01f, -1.70511261e-01f, -1.60640001e-01f,
  -3.96294333e-02f, -7.96627030e-02f, 2.28060722e-01f, 9.73265842e-02f, -1.91538721e-01f, 2.10954711e-01f, -8.28719139e-03f, 1.17785513e-01f, 1.34076253e-02f, -1.21145837e-01f,
  2.23165855e-01f, -4.18013930e-02f, -5.39159998e-02f, -6.32752478e-02f, -8.38807523e-02f, -6.88741133e-02f, -2.69486815e-01f, -2.08024219e-01f, 4.15267438e-01f, -2.85755336e-01f,
  2.75442034e-01f, 4.52578694e-01f, -9.28551331e-02f, 1.32315278e-01f, 8.46039057e-02f, 7.13984296e-02f, 9.42738727e-02f, -1.47234768e-01f, 2.04186946e-01f, -3.43217820e-01f,
  7.93360099e-02f, 8.77813771e-02f, -1.51413217e-01f, -1.18418910e-01f, 2.01598294e-02f, -2.42881373e-01f, -1.23116851e-01f, -7.02312812e-02f, 1.49471745e-01f, -1.76029459e-01f,
  -8.34364146e-02f, -1.07277118e-01f, -1.61541343e-01f, -2.04277381e-01f, -3.60759318e-01f, 3.74203146e-01f, -2.96713442e-01f, 8.75713602e-02f, -1.94822341e-01f, -6.61804080e-02f,
  -3.69532406e-03f, -2.71329254e-01f, 3.26458722e-01f, 3.92861426e-01f, -3.89202088e-01f, 4.13916171e-01f, -1.49523124e-01f, 1.57533199e-01f, -2.10548759e-01f, -1.96154907e-01f,
  1.01396888e-01f, -2.12644875e-01f, 4.96980473e-02f, 4.31544818e-02f, -3.59551515e-03f, -2.78041828e-02f, -2.22013697e-01f, -7.08119571e-02f, -9.46934968e-02f, 7.73515701e-02f,
  -1.76545769e-01f, 2.65494138e-01f, -3.47258866e-01f, 1.97595954e-01f, 2.01304201e-02f, -5.77654429e-02f, 3.21350135e-02f, -2.54501790e-01f, -3.07032645e-01f, 6.00983985e-02f,
  -1.99085608e-01f, -2.17521906e-01f, 2.51466542e-01f, 9.84806120e-02f, -2.10255593e-01f, 2.31925562e-01f, 2.28369996e-01f, -1.45362867e-02f, -1.53110877e-01f, -5.48710860e-02f,
  -5.23173772e-02f, -1.46399841e-01f, -1.14600621e-01f, -1.07167497e-01f, 3.77345656e-04f, 1.66036785e-01f, -1.23089574e-01f, 3.83107923e-02f, 6.86318427e-02f, 1.53675795e-01f,
  1.50618315e-01f, 2.64860570e-01f, -8.13159496e-02f, 2.83735484e-01f, 1.00094952e-01f, 1.66161776e-01f, 6.56566694e-02f, 5.92199787e-02f, -1.23325907e-01f, -2.22663030e-01f,
  2.90160347e-02f, -1.23318292e-01f, -4.40561831e-01f, -4.87422273e-02f, 3.15786153e-01f, 1.45225301e-01f, 6.71332628e-02f, 3.42026502e-01f, 7.65196234e-02f, 7.75170997e-02f,
  -4.13016602e-02f, 1.49127364e-01f, 1.84079595e-02f, -5.26056550e-02f, 5.57432044e-03f, -1.28145829e-01f, -1.43366754e-01f, -2.70396993e-02f, -2.79164702e-01f, -1.45645693e-01f,
  5.56087382e-02f, -5.76531552e-02f, 2.09792137e-01f, 1.92061990e-01f, 1.20420810e-02f, 3.51027213e-02f, 2.94587731e-01f, 2.69222017e-02f, -2.33769417e-01f, 1.14878081e-01f,
  -2.13316977e-01f, -4.24684167e-01f, 9.00556985e-03f, -4.04541433e-01f, -3.76427621e-01f, 1.94925934e-01f, -1.29029617e-01f, 1.39955372e-01f, 1.87671021e-01f, 2.32323170e-01f,
  1.07228383e-01f, -1.77015409e-01f, -1.05683498e-01f, 1.34802567e-05f, 1.69877961e-01f, 1.40147567e-01f, -1.94919154e-01f, 1.48339897e-01f, 3.16148736e-02f, -2.40763903e-01f,
  9.91236418e-02f, -2.26536393e-01f, -5.71085401e-02f, -1.47133991e-01f, -1.47959188e-01f, -2.17876762e-01f, -1.06687061e-02f, 4.00690399e-02f, 2.83139944e-01f, -2.96027303e-01f,
  -6.53441772e-02f, -5.90946041e-02f, -2.71581233e-01f, 2.16527551e-01f, 1.96378708e-01f, -6.52725622e-02f, -1.04326434e-01f, 1.73454940e-01f, -2.32358947e-01f, 7.46126473e-03f,
  7.32350424e-02f, 3.33441794e-02f, -2.72055537e-01f, -4.23129573e-02f, 9.05442089e-02f, 5.39399832e-02f, 1.27296299e-02f, -1.41846180e-01f, -9.96015966e-02f, -1.14293229e-02f,
  -5.52763045e-02f, -2.22688168e-01f, -2.09176004e-01f, -1.43461823e-01f, 2.48075888e-01f, -1.40553832e-01f, -2.33054370e-01f, 6.69583008e-02f, 3.24025867e-03f, -1.43239334e-01f,
  4.46561813e-01f, 6.70458898e-02f, 1.30087574e-04f, -1.83235511e-01f, -2.72454530e-01f, 4.19480652e-02f, 2.56621033e-01f, 1.16265669e-01f, 3.46349359e-01f, -3.52077484e-01f,
  -2.14416996e-01f, -4.60533530e-01f, 4.70986843e-01f, -4.32019569e-02f, -5.43065727e-01f, -3.18506896e-01f, 4.63335007e-01f, 2.83843905e-01f, 6.84316829e-03f, -7.41860643e-02f,
  1.45152397e-02f, 1.07045740e-01f, -2.63122886e-01f, -1.10464878e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.26445234e-01f, -6.42596036e-02f, 3.25702056e-02f, -6.46299273e-02f, 6.94541261e-02f, 1.07625410e-01f, -1.64015125e-02f, -1.41312122e-01f, 7.66378120e-02f, 1.38696870e-02f,
  7.51637593e-02f, 3.59107889e-02f, -1.12024762e-01f, 2.37291947e-01f, -6.34599105e-02f, 4.79190089e-02f, 2.36840799e-01f, -3.71627510e-01f, -2.12517321e-01f, -3.67587388e-01f,
  -1.04208346e-02f, -6.96379170e-02f, -3.36176455e-01f, 2.16105040e-02f, -8.78931896e-04f, 3.01177561e-01f, 1.07346326e-01f, -5.57062402e-02f, 2.18759462e-01f, -8.06721952e-03f,
  -3.73604707e-02f, 2.34941900e-01f, 4.28932667e-01f, 2.25729555e-01f, 2.65534610e-01f, 1.30726263e-01f, -7.50160143e-02f, 1.05281183e-02f, 9.03498307e-02f, 1.24387063e-01f,
  3.07948530e-01f, 3.41762155e-02f, 2.44338557e-01f, 3.20921838e-01f, 1.53045595e-01f, 3.64331692e-01f, -2.60726124e-01f, 4.41671371e-01f, 2.01013148e-01f, -2.26693358e-02f,
  -1.28695503e-01f, 8.35495889e-02f, 2.55015969e-01f, -3.21333915e-01f, 2.09063217e-01f, 2.92109568e-02f, 1.69785216e-01f, -1.83240190e-01f, 2.61139125e-01f, -8.81632864e-02f,
  3.06075923e-02f, 1.76254198e-01f, 1.87688589e-01f, 1.99170664e-01f, -1.48532584e-01f, -1.54110119e-01f, 6.56717867e-02f, 2.27889717e-01f, 5.75468801e-02f, 2.28095770e-01f,
  1.44052982e-01f, 2.40509570e-01f, 1.13995135e-01f, -3.13106775e-02f, 3.67608368e-02f, -1.47550125e-02f, 2.15189621e-01f, -2.69568503e-01f, 9.25642699e-02f, -2.86878109e-01f,
  -1.83203146e-01f, 5.82104996e-02f, 1.19351095e-03f, -2.80237831e-02f, -6.96747284e-03f, 6.13874309e-02f, 9.40364087e-04f, -8.18527415e-02f, 9.25706774e-02f, 1.66505098e-01f,
  1.96306750e-01f, 1.41304135e-01f, -4.93132509e-02f, 1.96210012e-01f, -7.08201975e-02f, 1.19099878e-01f, 2.40830809e-01f, 4.91541764e-03f, 1.62338123e-01f, 1.62483484e-01f,
  2.13063192e-02f, -1.88099697e-01f, 1.10118672e-01f, 5.00635207e-02f, 3.15632045e-01f, 3.00455093e-02f, -5.90014458e-03f, -9.42238569e-02f, -1.60909787e-01f, 2.20979109e-01f,
  2.98994839e-01f, -9.98813286e-02f, 2.03923240e-01f, -1.66744396e-01f, 2.36394648e-02f, -2.12499067e-01f, -8.60301107e-02f, -3.56158674e-01f, -2.03699514e-01f, 1.29065648e-01f,
  2.59987444e-01f, 1.62077740e-01f, 1.90437570e-01f, -6.31232280e-03f, 1.27506793e-01f, -7.29035288e-02f, 5.12199514e-02f, 1.21196784e-01f, -5.40345870e-02f, 1.01656895e-02f,
  2.06101954e-01f, -1.45798638e-01f, -2.62200348e-02f, 2.53432970e-02f, 4.86074239e-02f, 1.83792785e-01f, 2.22774699e-01f, -5.86272702e-02f, -3.08963396e-02f, -1.06172666e-01f,
  -2.91950349e-02f, 7.95104951e-02f, -1.36093318e-01f, -1.47122547e-01f, -1.30088758e-02f, -1.09326780e-01f, -1.55101299e-01f, -3.87427695e-02f, 2.10707381e-01f, 1.35638744e-01f,
  1.04320042e-01f, -1.03584386e-01f, 2.24057704e-01f, 1.15020841e-01f, -1.21241093e-01f, 7.74589479e-02f, 1.29806578e-01f, 8.10995921e-02f, -1.08656459e-01f, -1.37788460e-01f,
  3.90539795e-01f, 5.80075532e-02f, 4.78972495e-02f, 3.07677984e-01f, 2.40701154e-01f, 1.92416325e-01f, 3.64518225e-01f, 2.50518709e-01f, 2.37110374e-03f, 1.28501847e-01f,
  2.53687024e-01f, 4.90298063e-01f, -2.21069068e-01f, 6.43051565e-01f, -4.89752054e-01f, 5.07701159e-01f, -2.07221955e-01f, 1.05924353e-01f, 1.46787658e-01f, 1.01717621e-01f,
  4.65417504e-01f, 2.37812966e-01f, 1.64650753e-01f, 4.36967045e-01f, -8.38753432e-02f, -4.17594492e-01f, 2.33572394e-01f, 4.74227779e-02f, 9.54367742e-02f, 1.80845186e-01f,
  1.81803361e-01f, -2.56266981e-01f, 8.37970152e-02f, 5.06531633e-02f, 1.64213404e-01f, -2.65229680e-02f, 2.69354671e-01f, -2.77941018e-01f, -1.24293594e-02f, -7.13961720e-02f,
  3.96010317e-02f, 1.52373686e-01f, 2.33843639e-01f, -5.71108703e-03f, -1.66116133e-01f, -3.03209890e-02f, 2.91536063e-01f, -2.81512469e-01f, -2.39718091e-02f, -8.02333578e-02f,
  -2.01921001e-01f, 1.75247282e-01f, 6.13321140e-02f, -2.03646228e-01f, 1.01251164e-02f, 1.47499591e-01f, 6.59350306e-02f, 1.65095031e-01f, -1.21132560e-01f, -2.00921316e-02f,
  -1.25292428e-02f, -2.41723899e-02f, 1.94748774e-01f, 1.43297354e-03f, 2.36098111e-01f, 1.00483969e-01f, -1.69186756e-01f, 6.44301549e-02f, 1.81054264e-01f, 1.17059588e-01f,
  -1.47647802e-02f, 8.56995024e-03f, -2.32520044e-01f, 7.05172494e-02f, 1.18757524e-02f, 1.92089692e-01f, 1.77360475e-01f, -2.35145360e-01f, -9.50156078e-02f, -7.53478333e-02f,
  -1.61618575e-01f, -1.18898742e-01f, 2.44580984e-01f, 3.31827179e-02f, -2.22927615e-01f, -3.20458296e-03f, 1.01360697e-02f, 3.06611061e-01f, -1.77634090e-01f, -6.59646690e-02f,
  1.03509970e-01f, -2.06932537e-02f, 7.19020441e-02f, -2.21765682e-01f, -2.75433809e-03f, 2.34215230e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.47201771e-01f, 1.97682440e-01f, 2.47084752e-01f, 1.91889122e-01f, 2.75872070e-02f, 2.47708578e-02f, 1.54794931e-01f, 7.99764395e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  5.18865101e-02f, 4.62803453e-01f, 1.10772727e-02f, -2.38622069e-01f, 5.18050045e-02f, -3.05631369e-01f, -5.15632927e-02f, 4.20919284e-02f, -2.28669867e-01f, -2.40653694e-01f,
  2.87469685e-01f, 1.40340030e-01f, -3.87772977e-01f, -1.51728824e-01f, 1.35974705e-01f, -2.60817647e-01f, 3.47754508e-01f, -2.42820308e-01f, -1.99133739e-01f, -4.04908538e-01f,
  -1.14359505e-01f, 5.19882202e-01f, 3.41522276e-01f, -8.33492950e-02f, -3.48021179e-01f, -1.02050684e-01f, 1.07341707e-01f, -2.55944639e-01f, 8.01005960e-02f, 1.44741401e-01f,
  1.84038743e-01f, -1.39863670e-01f, -1.42514780e-01f, 2.18341231e-01f, -6.15466423e-02f, 1.69395328e-01f, -2.42064431e-01f, -8.69494304e-02f, 8.85955244e-02f, -1.90019518e-01f,
  -6.61374535e-04f, -1.85032979e-01f, 2.32737035e-01f, 2.05890357e-01f, -3.88364755e-02f, -3.99185449e-01f, -8.98331869e-04f, 2.99255282e-01f, 1.51354238e-01f, 4.04912010e-02f,
  2.55110383e-01f, -3.32673877e-01f, -2.64806859e-02f, -2.98494995e-02f, 2.01880455e-01f, 5.82717657e-01f, 1.35433286e-01f, -1.90589249e-01f, -9.11263283e-03f, 2.55785733e-01f,
  1.25952978e-02f, -2.74836749e-01f, 4.32330742e-02f, -1.41185373e-01f, -2.31825747e-02f, -2.62444466e-02f, -1.04658440e-01f, -1.16497204e-01f, 3.17996442e-01f, 6.73864633e-02f,
  1.80249140e-01f, -3.84898424e-01f, 2.44175702e-01f, -5.87735251e-02f, 2.08671272e-01f, -1.40815184e-01f, -1.41466886e-01f, -5.10381937e-01f, 1.48799002e-01f, 2.05210194e-01f,
  4.07499105e-01f, -1.50913239e-01f, 8.22705030e-02f, -8.68813992e-02f, -2.57041544e-01f, -1.50715467e-03f, -1.59275848e-02f, 2.19696701e-01f, 2.43390352e-01f, -2.50745207e-01f,
  -8.01383629e-02f, 1.86194703e-01f, 8.65583271e-02f, -2.22062215e-01f, 1.38299763e-01f, 1.41040370e-01f, 3.05227965e-01f, -1.09828644e-01f, 2.55778790e-01f, 5.31760510e-03f,
  -2.21066043e-01f, 1.62669092e-01f, -8.64038840e-02f, 4.37659174e-01f, 1.09117649e-01f, -9.15734246e-02f, -2.43558139e-02f, 9.90956426e-02f, 3.76948774e-01f, 2.76383534e-02f,
  -1.41757563e-01f, 5.21440245e-02f, 1.42356092e-02f, 7.32771531e-02f, -3.12022597e-01f, 3.37209970e-01f, 2.83355772e-01f, 4.61211652e-01f, -3.80312920e-01f, -1.57770753e-01f,
  -7.25811720e-02f, -9.65620577e-02f, 3.76333714e-01f, -2.94824570e-01f, 1.34684682e-01f, -3.02066714e-01f, -1.94638029e-01f, -1.08246550e-01f, 2.27365106e-01f, -1.66660324e-01f,
  2.19631523e-01f, 3.25479209e-02f, 1.33249864e-01f, -7.44840279e-02f, -1.59550220e-01f, 8.29621479e-02f, -9.17793512e-02f, 7.38529116e-02f, -1.78108618e-01f, -3.23694527e-01f,
  1.95565790e-01f, -3.11552789e-02f, 4.08510745e-01f, -1.99797899e-01f, -1.40488490e-01f, -2.20504075e-01f, -1.76603094e-01f, 2.46010676e-01f, 8.32173601e-02f, 8.16567466e-02f,
  -2.38091603e-01f, -6.95503831e-01f, -2.66046047e-01f, -1.27171591e-01f, -1.93813384e-01f, -2.09732309e-01f, -1.68208510e-01f, 9.51830074e-02f, 1.01466246e-01f, 2.93385774e-01f,
  -3.54194902e-02f, 3.80874798e-02f, 1.32183284e-01f, -1.44372702e-01f, 3.31508964e-01f, -1.72741458e-01f, 1.25985429e-01f, -1.38474107e-01f, 1.44268349e-01f, 9.78543684e-02f,
  -3.42746675e-02f, -4.06859487e-01f, -4.75481264e-02f, -3.56857538e-01f, 8.18352848e-02f, 5.93905263e-02f, 6.98021352e-01f, 1.38505831e-01f, 6.41545415e-01f, 2.50292897e-01f,
  -1.21187624e-02f, -9.21808183e-02f, 6.82291538e-02f, -7.43748918e-02f, 4.15984504e-02f, -2.36195877e-01f, -2.45646775e-01f, -2.70159692e-01f, -1.67720973e-01f, 1.87774450e-01f,
  1.08973004e-01f, 1.16794974e-01f, 1.29630432e-01f, -5.80801442e-02f, -2.97627658e-01f, -2.76310593e-01f, 1.52007133e-01f, -1.11123145e-01f, 1.83833256e-01f, -1.84259582e-02f,
  -1.83760405e-01f, -1.09084666e-01f, -1.55757189e-01f, -1.31718740e-01f, 1.79320335e-01f, 4.14174855e-01f, -1.70593977e-01f, -8.85245502e-02f, -2.75667310e-01f, 1.92867622e-01f,
  1.98455483e-01f, 1.23583980e-01f, -8.39766115e-02f, -1.13292888e-01f, 2.54849810e-02f, -2.15727061e-01f, -9.14281160e-02f, 3.11833233e-01f, -1.99292764e-01f, -1.50229573e-01f,
  -1.34609547e-02f, 6.26002133e-01f, -1.70845523e-01f, 8.25075135e-02f, -1.14849366e-01f, 2.18826801e-01f, 2.96539009e-01f, 2.08826944e-01f, 2.33153000e-01f, 1.80865675e-01f,
  -2.74758309e-01f, 8.10463056e-02f, 2.89634466e-01f, 3.03149611e-01f, 1.33925751e-01f, 2.72666842e-01f, 2.21194588e-02f, -8.36259350e-02f, 3.04154962e-01f, 4.87546809e-02f,
  -2.12805912e-01f, -2.94975162e-01f, -5.11174560e-01f, -2.16124058e-01f, 2.66407635e-02f, 2.94032604e-01f, 6.60196766e-02f, 5.65888323e-02f, -3.01899984e-02f, -9.97462347e-02f,
  1.03389069e-01f, 1.51863903e-01f, -1.68636471e-01f, -4.30050075e-01f, 2.80078709e-01f, 1.46140814e-01f, -1.00252368e-02f, -3.22933674e-01f, -1.41903944e-03f, -1.32769465e-01f,
  -1.42584220e-01f, 5.69698587e-02f, -2.28105485e-01f, -7.67588988e-02f, 1.58711765e-02f, -1.37420893e-01f, -3.12394440e-01f, -3.09027225e-01f, 2.52742857e-01f, 3.25498134e-01f,
  3.37780714e-01f, 5.42665878e-03f, -3.31211060e-01f, -1.65277839e-01f, -3.26165348e-01f, 3.03654939e-01f, 1.60437867e-01f, -1.52788609e-01f, -1.97526187e-01f, -2.95614362e-01f,
  -2.69214302e-01f, -4.71883453e-02f, -8.73679668e-03f, -1.61840782e-01f, -1.65439680e-01f, -3.88843343e-02f, -1.79270819e-01f, 1.96695715e-01f, -2.30200514e-01f, -4.20399874e-01f,
  -1.74788982e-01f, 1.08538240e-01f, -2.06771389e-01f, 1.23820439e-01f, 3.55259073e-03f, -4.01102006e-02f, 1.13095663e-01f, -2.30852962e-01f, -1.26945451e-01f, -2.68905252e-01f,
  9.57992971e-02f, -8.09046626e-02f, 1.05143718e-01f, 4.08184916e-01f, 1.13545284e-01f, 3.08542937e-01f, 3.96761179e-01f, 1.23013437e-01f, -1.94009617e-01f, -2.41187140e-01f,
  -9.02164057e-02f, 6.50225103e-01f, 2.71896392e-01f, -2.25253075e-01f, 3.52831781e-02f, 5.52430004e-02f, -3.59810926e-02f, -3.05271327e-01f, -1.20181497e-02f, 1.50359631e-01f,
  1.04001999e-01f, 3.77410203e-01f, 1.32612690e-01f, 3.98196243e-02f, -1.09854108e-02f, -2.32985448e-02f, 2.93012619e-01f, 2.87685513e-01f, -1.84419885e-01f, -7.08101839e-02f,
  1.51497900e-01f, 2.74491549e-01f, -4.57867905e-02f, -5.12966514e-03f, -3.40902299e-01f, 3.52518223e-02f, 3.28242987e-01f, 2.58674741e-01f, 3.97651233e-02f, -1.51696295e-01f,
  4.14884269e-01f, 4.40848470e-01f, 2.90989522e-02f, -9.53929499e-02f, -2.03003973e-01f, -2.99664766e-01f, -1.38188177e-03f, -6.93637952e-02f, 9.62373391e-02f, 3.40192020e-01f,
  -2.13860184e-01f, -8.73990484e-06f, 1.98373482e-01f, -1.14595212e-01f, 5.01018427e-02f, 1.44755051e-01f, 2.53995091e-01f, -2.19578650e-02f, -1.79275312e-02f, 9.65704769e-02f,
  -1.91842318e-02f, 9.89883095e-02f, 2.91483793e-02f, -2.16803998e-01f, 1.50971651e-01f, 3.30810100e-01f, 1.73331454e-01f, -3.70238006e-01f, -2.75635749e-01f, -3.20942819e-01f,
  -6.36895597e-01f, 3.29367578e-01f, 1.69294402e-01f, -7.67504796e-02f, -1.91478178e-01f, -6.30829632e-01f, -1.28641203e-01f, 1.12492301e-01f, -2.41175983e-02f, -1.25070766e-01f,
  -2.00392380e-01f, -3.44730616e-02f, -4.79191951e-02f, 7.53913075e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.23178720e-01f, 1.65131718e-01f, -4.33635078e-02f, -7.40770996e-02f, -8.61200038e-03f, -1.71047673e-02f, -9.25663952e-03f, -3.89475673e-02f, -8.72116461e-02f, 1.38344020e-01f,
  1.12441637e-01f, 1.57174796e-01f, -1.09003186e-01f, -1.02881052e-01f, -1.45825846e-02f, 1.73852608e-01f, 1.33517757e-01f, 7.81663060e-02f, 1.48402900e-01f, -2.08055153e-01f,
  2.00929955e-01f, 2.55323529e-01f, -1.07540160e-01f, -5.96095063e-02f, -5.22937253e-02f, -1.26256704e-01f, 4.18164805e-02f, 1.68871344e-03f, 1.32824192e-02f, -8.89972150e-02f,
  2.26522729e-01f, 1.43429473e-01f, -1.15148269e-01f, 2.98544228e-01f, -1.97002850e-02f, -1.46569923e-01f, 2.26721987e-01f, -1.08169347e-01f, 8.26676413e-02f, -4.72002439e-02f,
  2.48364992e-02f, 2.58358300e-01f, 6.46901280e-02f, 2.91682005e-01f, -1.88910067e-01f, -9.38819200e-02f, 1.93879142e-01f, -1.89200893e-01f, 1.47475880e-02f, -6.01326823e-02f,
  1.77505538e-02f, -2.75405914e-01f, -4.70523871e-02f, -1.57898888e-01f, 3.97712141e-02f, -2.02775404e-01f, -1.99346498e-01f, 1.17303520e-01f, 8.71258527e-02f, 1.29676208e-01f,
  2.75292946e-03f, 4.21110511e-01f, 1.63685054e-01f, -2.10581288e-01f, 3.30378979e-01f, -7.40548000e-02f, 3.00729901e-01f, 1.15350656e-01f, 2.17827752e-01f, -8.86736736e-02f,
  7.76914358e-02f, 6.33166060e-02f, -1.65262878e-01f, -9.33082104e-02f, 8.53207260e-02f, 2.19817609e-01f, 2.32083440e-01f, 2.38582581e-01f, -2.75300831e-01f, -1.26735866e-02f,
  3.72269824e-02f, 3.57805908e-01f, -1.01032071e-01f, 1.85802832e-01f, 4.26856816e-01f, 1.77128628e-01f, -2.47782797e-01f, 3.67047668e-01f, 1.16449639e-01f, 2.83783600e-02f,
  2.56319702e-01f, 4.42728354e-03f, 2.05843538e-01f, -3.88547368e-02f, 1.55154049e-01f, 2.30688065e-01f, 2.56497920e-01f, 2.76959956e-01f, -1.38733943e-03f, 1.84741631e-01f,
  2.35286996e-01f, -4.16517071e-02f, -2.21418608e-02f, 8.35687146e-02f, 2.61966169e-01f, 1.69560239e-01f, -5.66272065e-03f, 1.11514375e-01f, -1.19188793e-01f, 3.18490565e-01f,
  -2.68168688e-01f, -1.78969875e-01f, 1.55941457e-01f, -1.07359268e-01f, 3.72079968e-01f, -1.83684587e-01f, 9.88865197e-02f, -5.90380002e-03f, -7.22291023e-02f, -9.58506167e-02f,
  -1.07033052e-01f, 3.00710499e-01f, -1.69862509e-01f, -3.57931554e-02f, -3.19039747e-02f, 8.16317677e-01f, -1.96237937e-01f, -2.71519244e-01f, 1.82902873e-01f, -2.30358303e-01f,
  1.16372958e-01f, -1.20622940e-01f, -1.25446788e-03f, -3.32995784e-03f, 6.62639067e-02f, 4.39385660e-02f, 4.29052487e-02f, -1.30976409e-01f, -8.38456005e-02f, -2.21359953e-01f,
  -8.83095637e-02f, 1.69360206e-01f, -1.01028726e-01f, -1.31654173e-01f, 8.43122005e-02f, 7.54323006e-02f, 9.72697139e-02f, -1.08918272e-01f, -1.32540250e-02f, 1.62619412e-01f,
  -8.59187990e-02f, 3.06176934e-02f, -5.67665957e-02f, 1.10453807e-01f, -6.58657178e-02f, 1.41735487e-02f, 2.06077650e-01f, 6.69408441e-02f, -2.34706756e-02f, 3.83490399e-02f,
  -1.30851895e-01f, -1.80641785e-02f, 2.09755644e-01f, 3.33008289e-01f, -2.34608524e-04f, 2.14218795e-01f, 1.52611315e-01f, 1.26736891e-02f, 3.21387589e-01f, 1.62419863e-02f,
  4.61191535e-02f, 1.32954776e-01f, -2.50924289e-01f, -2.75534660e-01f, 4.11480993e-01f, -9.39408243e-02f, 1.85766593e-01f, -4.10436839e-01f, -8.58170018e-02f, -1.75128192e-01f,
  -1.03043843e-04f, 7.78748840e-02f, -1.12751544e-01f, -7.55887330e-02f, -1.65092740e-02f, -1.38873160e-01f, 5.26224496e-03f, 2.33981356e-01f, 1.80790499e-02f, -2.51292586e-01f,
  3.29524755e-01f, 1.86317608e-01f, -2.30948746e-01f, 3.38645488e-01f, 2.64763623e-01f, -4.12310138e-02f, 3.50423574e-01f, -1.94173418e-02f, 2.36743912e-01f, -1.80301115e-01f,
  4.14146274e-01f, 1.83586299e-01f, 3.07441294e-01f, -2.19217345e-01f, -2.55063176e-01f, -1.22900143e-01f, 2.65559684e-02f, -7.28169382e-02f, -4.60712731e-01f, -2.50004470e-01f,
  -4.64238465e-01f, -2.98177481e-01f, -4.76464152e-01f, -3.77403200e-01f, -3.91535722e-02f, 5.99035844e-02f, 1.86952680e-01f, 7.52478004e-01f, -1.43932372e-01f, 2.54166961e-01f,
  1.22945430e-02f, 3.59466016e-01f, -1.69656388e-02f, 2.11422965e-02f, 3.09461445e-01f, -1.18309028e-01f, 9.14642364e-02f, -1.48343876e-01f, 1.32571653e-01f, -1.54864565e-01f,
  2.28210092e-01f, 2.63487995e-01f, 2.71980669e-02f, -9.53939334e-02f, 2.86696672e-01f, 1.31571531e-01f, 2.07198143e-01f, 1.47028714e-01f, -2.96820343e-01f, -1.84510186e-01f,
  1.35891482e-01f, 4.63650167e-01f, 2.84410834e-01f, 6.77507445e-02f, 3.05950046e-01f, -2.66876280e-01f, -4.14642767e-04f, -3.82408611e-02f, 1.66480884e-01f, 1.88642107e-02f,
  3.61706540e-02f, 2.40177676e-01f, -1.93390474e-02f, 2.15649307e-01f, 2.06275247e-02f, 2.67574579e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.36464126e-02f, -5.54672144e-02f, 3.39545369e-01f, -1.14801019e-01f, 1.68456078e-01f, 3.15820426e-01f, 5.69153130e-02f, 1.20775402e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -1.08038798e-01f, 4.22212571e-01f, 3.05099487e-01f, 2.84013182e-01f, 9.13318396e-02f, 2.90107816e-01f, 1.07426465e-01f, -7.68106222e-01f, 5.72348952e-01f, -3.69142801e-01f,
  7.89506808e-02f, -3.99378724e-02f, 4.99133289e-01f, -3.84997070e-01f, 2.48167172e-01f, -4.18355197e-01f, 9.67579007e-01f, -1.91215321e-01f, -4.48092878e-01f, 2.21486449e-01f,
  -1.96936354e-01f, -1.97712764e-01f, -4.19369847e-01f, 4.39160049e-01f, 1.15646213e-01f, 1.82635605e-01f, -4.06706661e-01f, -2.95070499e-01f, -1.61842421e-01f, 3.96103799e-01f,
  2.25104749e-01f, -4.09800410e-01f, -2.02600688e-01f, 3.29476357e-01f, 7.69614801e-02f, 3.03117484e-01f, 5.06041884e-01f, 1.94289148e-01f, -4.36172068e-01f, -5.01202881e-01f,
  -3.36675137e-01f, 2.58662194e-01f, -7.43055195e-02f, 6.23392999e-01f, 6.60529971e-01f, 6.54300570e-01f, 5.89236259e-01f, 5.29551767e-02f, -3.02924275e-01f, -8.74871761e-02f,
  -5.04835129e-01f, 2.74772495e-01f, -4.46734041e-01f, -4.82701629e-01f, 4.02262896e-01f, -6.07565224e-01f, 6.49304837e-02f, 3.47196385e-02f, -3.02022062e-02f, -1.69070944e-01f,
  1.60218391e-03f, 6.73930407e-01f, -3.07984591e-01f, -2.90341645e-01f, 3.81572098e-01f, -4.97604162e-02f, 1.62157401e-01f, 1.21520951e-01f, -3.54130208e-01f, 1.47883549e-01f,
  -3.97128873e-02f, 3.63770038e-01f, -4.57856596e-01f, 5.17961860e-01f, -1.16611972e-01f, -6.21960521e-01f, 4.49760467e-01f, 7.65938222e-01f, 3.63268733e-01f, 3.69432479e-01f,
  -5.11402130e-01f, 5.52724481e-01f, -4.25912887e-01f, -1.58783972e-01f, -6.49968758e-02f, 5.99918127e-01f, 2.75496364e-01f, -7.06216395e-01f, 2.76523292e-01f, -2.65334487e-01f,
  3.41266096e-01f, -2.18165085e-01f, 2.67663151e-01f, -1.66973695e-01f, -6.29429877e-01f, 1.04661830e-01f, -5.25311470e-01f, -3.51898134e-01f, -1.49267748e-01f, -5.54413140e-01f,
  -2.77640224e-01f, -1.93486631e-01f, 4.56108093e-01f, 1.23463543e-02f, -3.02239656e-01f, 4.67445344e-01f, 1.55194819e-01f, -6.06917262e-01f, -3.96058649e-01f, -4.28287625e-01f,
  -4.91608053e-01f, 5.64890325e-01f, 7.76928008e-01f, -5.16720712e-01f, -2.42152914e-01f, 4.08153772e-01f, 8.82799149e-01f, -3.03550988e-01f, -5.26012063e-01f, 5.03973901e-01f,
  -4.44602147e-02f, -2.77018398e-01f, 5.01810238e-02f, -1.47799432e-01f, -5.68285659e-02f, 1.87699229e-01f, -5.41962564e-01f, -2.57162631e-01f, 4.97405738e-01f, -7.12805033e-01f,
  -3.21870804e-01f, 1.98650628e-01f, 1.09191701e-01f, -2.14913979e-01f, -9.47260335e-02f, 4.72365886e-01f, 6.25996292e-01f, -7.63912797e-01f, -1.47333279e-01f, -5.30439436e-01f,
  -1.43471777e-01f, -2.47391611e-01f, -2.20694080e-01f, 7.54696310e-01f, 6.42007768e-01f, -4.20696259e-01f, 3.19036067e-01f, 8.42472836e-02f, 2.46517614e-01f, 1.22891225e-01f,
  3.36836547e-01f, 3.10454398e-01f, -9.76322740e-02f, -3.60516757e-02f, -5.45557402e-02f, 3.40923965e-01f, 9.49512944e-02f, -7.48765841e-02f, 3.99671227e-01f, -2.40131736e-01f,
  3.29589754e-01f, 9.79232341e-02f, 3.18415314e-01f, -4.04029608e-01f, 2.71737501e-02f, -3.04663777e-01f, 3.20418477e-01f, 9.88674089e-02f, -1.67699844e-01f, -5.23129702e-01f,
  2.46154562e-01f, 2.64669150e-01f, 4.16836560e-01f, -1.18663393e-01f, -2.40459606e-01f, -6.66932464e-01f, -2.76967674e-01f, -4.41977710e-01f, 2.91087598e-01f, 4.99235541e-01f,
  -2.60700792e-01f, 1.20472377e-02f, 8.56601968e-02f, 9.92256030e-02f, -1.82185128e-01f, 4.00451511e-01f, -3.44684750e-01f, 1.56440407e-01f, 6.51831646e-03f, -2.32282192e-01f,
  6.05616033e-01f, -4.12369668e-01f, 2.10218951e-01f, 4.82416362e-01f, 4.17370081e-01f, -2.29744464e-01f, -2.78851837e-01f, 3.76118347e-02f, 1.40366614e-01f, 3.29969853e-01f,
  -6.13309622e-01f, 3.71175319e-01f, -1.38983289e-02f, -1.97980404e-01f, -3.48289341e-01f, 1.03866585e-01f, 1.30849242e-01f, -5.49125373e-01f, -3.48675221e-01f, 4.46101516e-01f,
  5.95149696e-01f, -3.91747326e-01f, -6.89407364e-02f, -3.08161110e-01f, 4.94593382e-01f, -8.29407930e-01f, -3.56951915e-02f, -3.20436805e-02f, -1.40515700e-01f, 6.11683369e-01f,
  -1.23352386e-01f, -1.51677489e-01f, 2.39272211e-02f, 2.11903788e-02f, -3.47756296e-01f, -6.03867590e-01f, 3.54997963e-01f, 3.62608492e-01f, -3.29443574e-01f, 4.54460502e-01f,
  -3.78836989e-01f, 3.05054337e-01f, 2.04814628e-01f, 2.37292990e-01f, 2.69911557e-01f, -5.17262697e-01f, -4.10252303e-01f, -2.87393123e-01f, -1.70395270e-01f, 2.31671691e-01f,
  6.57190323e-01f, 1.02810788e+00f, 3.50563914e-01f, -5.24476409e-01f, 7.73415565e-01f, -1.74514920e-01f, -2.78324913e-02f, 5.29660165e-01f, -2.02773467e-01f, -1.98629528e-01f,
  2.95073837e-01f, -1.12786606e-01f, 1.81934342e-01f, 3.86972167e-02f, -4.62693013e-02f, 3.66795033e-01f, -4.92018275e-02f, -2.66754717e-01f, -4.26625907e-01f, -3.44711721e-01f,
  -3.03821892e-01f, 1.17055997e-02f, -2.92398006e-01f, -1.36573538e-01f, -5.38042605e-01f, 2.15513915e-01f, 2.48970821e-01f, -1.48665771e-01f, -5.43296039e-01f, 6.04375064e-01f,
  5.02899349e-01f, -6.94275320e-01f, -3.28937054e-01f, 8.10340717e-02f, -2.99329847e-01f, 1.12474188e-01f, -1.14014670e-01f, 7.32919931e-01f, -7.57238865e-01f, -5.70713162e-01f,
  -1.64933264e-01f, 8.40375349e-02f, -1.99420780e-01f, -4.43707377e-01f, -2.26035193e-01f, 3.62130731e-01f, 4.45435375e-01f, 9.16488692e-02f, -5.89440390e-03f, -4.18374352e-02f,
  -3.34986031e-01f, 3.12156975e-01f, 5.80572903e-01f, 2.59706713e-02f, -1.95103347e-01f, 1.53032362e-01f, -1.48211285e-01f, -5.12857497e-01f, -5.91558754e-01f, 2.61307955e-01f,
  1.46298215e-01f, -4.11713004e-01f, -4.13386941e-01f, -4.44506034e-02f, 2.80196499e-02f, 5.89011371e-01f, 3.31959903e-01f, -6.83997869e-01f, -6.04694128e-01f, 1.16327740e-01f,
  1.05383866e-01f, -1.35031408e-02f, -2.24866550e-02f, 4.20551866e-01f, -4.44858940e-03f, 5.26009023e-01f, -5.15165627e-02f, -1.97752535e-01f, -4.88017589e-01f, 3.90582502e-01f,
  4.93340582e-01f, 3.83216619e-01f, 9.93691981e-02f, -4.21278894e-01f, 4.46685672e-01f, -5.56203604e-01f, 1.32530734e-01f, -2.75257021e-01f, 6.96159363e-01f, 2.46820301e-01f,
  -1.86970964e-01f, 2.07108051e-01f, -3.98543984e-01f, -1.04389593e-01f, -4.16650623e-01f, 3.03596735e-01f, -2.41491631e-01f, -3.52021903e-01f, -2.24642590e-01f, 4.16094840e-01f,
  -2.00166136e-01f, -4.90160793e-01f, 3.67844224e-01f, 3.06106120e-01f, -4.19672299e-03f, -1.93170145e-01f, 6.92005694e-01f, -3.98794651e-01f, -1.79733947e-01f, -2.87165165e-01f,
  -5.62654734e-01f, 2.59239376e-01f, -7.09707379e-01f, 5.32150030e-01f, 8.08368400e-02f, 3.58850896e-01f, -7.80765042e-02f, -6.35215461e-01f, 5.06894402e-02f, 3.19989860e-01f,
  6.33982539e-01f, 5.47570765e-01f, 3.11664134e-01f, 3.02241057e-01f, -4.95568633e-01f, -2.19308734e-01f, -2.33842328e-01f, -3.00983265e-02f, -7.15992928e-01f, -4.36795443e-01f,
  3.63281637e-01f, -2.55857587e-01f, -3.25847685e-01f, 3.33923459e-01f, -5.05615652e-01f, -7.87768364e-02f, -2.94086814e-01f, -3.01874161e-01f, 1.21095501e-01f, 1.33488635e-02f,
  1.53618276e-01f, -1.51777625e-01f, 3.11021000e-01f, 1.06713302e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.37326849e-02f, 1.92483276e-01f, 2.25445911e-01f, 2.30454743e-01f, 7.48597234e-02f, -3.50665957e-01f, -1.83360890e-01f, -6.07625581e-02f, -1.06704853e-01f, -1.05427615e-01f,
  2.23174438e-01f, -9.86438245e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    