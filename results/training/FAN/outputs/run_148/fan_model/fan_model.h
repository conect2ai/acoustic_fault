/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.99871540e-01f, -7.01971799e-02f, 1.18436016e-01f, 1.76842690e-01f, -4.05985117e-02f, -2.25344896e-01f, -1.05885960e-01f, -1.25875205e-01f, -7.37136900e-02f, -7.90711567e-02f,
  1.95670016e-02f, -2.64668912e-02f, -2.54657567e-01f, 1.08739056e-01f, -1.65920585e-01f, -2.61500567e-01f, 8.17604586e-02f, -3.77289504e-02f, 8.15187395e-02f, -4.64189462e-02f,
  2.18529925e-02f, 7.37892371e-03f, 4.09976440e-03f, 1.79323589e-03f, 7.96156451e-02f, 2.37089634e-01f, 1.46245167e-01f, 1.44635350e-01f, 2.53845692e-01f, 6.61667436e-02f,
  -4.50304076e-02f, 8.70709587e-03f, 9.76989567e-02f, -1.70478225e-02f, 2.69855279e-02f, -3.91655117e-02f, -5.29942699e-02f, -4.97028641e-02f, 2.75297351e-02f, 3.80492583e-02f,
  -6.51695728e-02f, -4.46415171e-02f, 1.99428603e-01f, -7.75975063e-02f, -5.92004247e-02f, 1.02021031e-01f, 1.05361808e-02f, -1.02309652e-01f, -7.90874511e-02f, -1.54380025e-02f,
  7.01182261e-02f, 6.03976957e-02f, 8.92381370e-02f, 8.38996843e-02f, 9.11988765e-02f, 1.25222266e-01f, 1.41111538e-01f, 5.06699942e-02f, 1.15785822e-01f, 8.63714889e-02f,
  -9.97173935e-02f, 6.82655126e-02f, 5.83777651e-02f, 3.93752381e-02f, 9.12796482e-02f, 1.05660588e-01f, 9.87339299e-03f, 2.41927076e-02f, 1.00591471e-02f, 3.26946378e-02f,
  5.43923303e-02f, 4.52021472e-02f, 1.83297240e-03f, -5.73554672e-02f, 2.86029801e-02f, -3.07667088e-02f, -1.04885781e-02f, 4.71196584e-02f, 5.55862337e-02f, -8.26032758e-02f,
  4.11282368e-02f, -8.16509873e-02f, -6.19520955e-02f, -2.91722491e-02f, -4.52325828e-02f, 3.85388881e-02f, -2.62800008e-02f, -1.82497427e-02f, -5.74165434e-02f, -7.66431689e-02f,
  -6.50943890e-02f, 1.37152314e-01f, 7.38490745e-02f, -3.77448574e-02f, 9.98566896e-02f, -1.51544129e-02f, -2.59735640e-02f, -3.49090546e-02f, 7.24681318e-02f, 2.67311260e-02f,
  -3.91216129e-02f, 6.99359458e-03f, -1.18394298e-02f, -3.70390415e-02f, -6.93050027e-02f, -3.74086984e-02f, 2.06965432e-02f, 4.58579846e-02f, 7.64646009e-02f, 7.16861933e-02f,
  4.47728038e-02f, 2.60769650e-02f, 1.81710385e-02f, 9.42104161e-02f, 1.69303995e-02f, 5.46575859e-02f, -5.87014817e-02f, 4.86287996e-02f, 4.24437076e-02f, 1.22101195e-01f,
  -3.81708175e-01f, 4.47548807e-01f, -1.75497368e-01f, -4.68594171e-02f, 1.48652628e-01f, 9.22188461e-02f, 1.73642814e-01f, 2.05144227e-01f, 1.64062884e-02f, 3.43489826e-01f,
  3.73057753e-01f, 1.59760434e-02f, 2.50218153e-01f, 3.13250750e-01f, 1.18052803e-01f, 1.86579183e-01f, 1.05934061e-01f, 7.41010979e-02f, 7.04877172e-03f, 6.62329197e-02f,
  -6.37694299e-02f, 2.32645333e-01f, 1.05090439e-01f, 2.90575892e-01f, 9.25539806e-02f, -2.46627077e-01f, 1.48259297e-01f, 1.13506697e-01f, 4.84647974e-02f, 1.15250655e-01f,
  -2.60196254e-02f, -1.75473634e-02f, -6.44107014e-02f, -1.25822261e-01f, -1.00486957e-01f, -9.26556140e-02f, -6.85593933e-02f, -2.48581488e-02f, -7.98439328e-03f, -6.78944737e-02f,
  -1.25792287e-02f, -2.73553524e-02f, -4.50955480e-02f, 2.92729475e-02f, 2.69208495e-02f, -3.27525958e-02f, 6.88664988e-02f, -5.89723466e-03f, 1.38563678e-01f, 3.46523151e-02f,
  4.37338278e-02f, -1.73274502e-02f, -2.28548944e-02f, 8.82569030e-02f, 2.55090613e-02f, 9.52949002e-02f, -2.91433241e-02f, 1.91771034e-02f, 1.74187496e-02f, -8.05869475e-02f,
  -1.80600043e-02f, -3.43748108e-02f, 6.73315749e-02f, -6.80724159e-03f, 2.27823872e-02f, -6.22176705e-03f, 1.00979984e-01f, -8.32666643e-03f, -1.19342186e-01f, 8.08284953e-02f,
  -7.06636608e-02f, -7.25626433e-03f, 9.36506465e-02f, 5.52326739e-02f, -5.98833784e-02f, -7.96984136e-02f, -5.86871952e-02f, -1.74298529e-02f, -6.26374707e-02f, 6.69353008e-02f,
  9.46704969e-02f, 2.52233632e-02f, 5.82617591e-04f, -6.91629052e-02f, 6.02930747e-02f, 6.43440858e-02f, 1.24151900e-01f, -2.93463394e-02f, 7.90951401e-02f, -6.94048703e-02f,
  -3.46199572e-02f, 1.66874021e-01f, -7.53016844e-02f, 2.54497165e-03f, -1.84831787e-02f, -5.19087985e-02f, -3.93802002e-02f, 6.65011555e-02f, -2.80796345e-02f, -1.77517962e-02f,
  5.32209594e-03f, 8.70442297e-03f, -5.18676043e-02f, -2.25189328e-02f, 3.40148322e-02f, 1.06037244e-01f, 6.75027817e-02f, 9.10306275e-02f, 2.73871105e-02f, 6.16478734e-02f,
  7.45392367e-02f, 5.03102764e-02f, -3.79136694e-03f, -3.32117602e-02f, -4.28342726e-03f, 2.72601135e-02f, 6.14586659e-03f, -1.71966702e-02f, -2.50560846e-02f, 1.48376171e-02f,
  2.07214892e-01f, -5.07126033e-01f, -2.23999575e-01f, -5.72099984e-02f, 1.59353673e-01f, -1.85501993e-01f, -7.94877633e-02f, -1.08982183e-01f, 4.59030382e-02f, -2.52564073e-01f,
  1.11999991e-03f, -2.20471695e-01f, -9.78922546e-02f, -2.65801102e-01f, 7.17497319e-02f, -2.38660514e-01f, -1.06054060e-01f, -8.81530270e-02f, -2.86437925e-02f, 1.29311124e-03f,
  8.37376155e-03f, -8.58930778e-03f, -1.20590128e-01f, 1.81419700e-02f, -4.95700650e-02f, -2.24666893e-02f, 2.08053350e-01f, 1.78719778e-02f, -1.18361972e-01f, 2.07459424e-02f,
  -4.82963584e-02f, -3.42777967e-02f, -4.41168807e-02f, -4.40715700e-02f, -4.47385795e-02f, 5.08042192e-03f, 1.05083957e-01f, -1.11618442e-02f, -7.99152162e-03f, -8.58617276e-02f,
  2.12992597e-02f, -2.46129837e-02f, -9.61391702e-02f, 7.60272518e-02f, 3.56257781e-02f, -1.06302677e-02f, -6.64279684e-02f, 4.49444428e-02f, -5.64382114e-02f, -1.06141783e-01f,
  -8.71420950e-02f, -1.44631371e-01f, 4.70455736e-02f, -5.40242866e-02f, -4.99224849e-03f, -1.73917189e-02f, -1.01104155e-01f, 5.22953412e-03f, -5.10061383e-02f, -1.09299116e-01f,
  4.17556539e-02f, -4.97251935e-02f, -4.81053330e-02f, -3.54692563e-02f, -2.03962512e-02f, -8.75439309e-03f, 6.53469861e-02f, 2.53059883e-02f, 4.66930717e-02f, -3.73660997e-02f,
  8.12145993e-02f, -4.95887473e-02f, 4.46957871e-02f, -1.11355493e-02f, -4.41660685e-03f, -9.99705195e-02f, -5.45550399e-02f, -1.96126197e-02f, 9.97745320e-02f, 1.37188882e-02f,
  -4.14771177e-02f, -3.58542167e-02f, -3.43344323e-02f, 6.73392862e-02f, -2.94666346e-02f, -5.71834482e-02f, -4.70484328e-03f, -7.42542148e-02f, 3.14810649e-02f, 8.68150070e-02f,
  -6.94722682e-02f, -8.93936530e-02f, 2.08616368e-02f, 4.02483456e-02f, 1.84802469e-02f, 4.17018682e-02f, 2.42651049e-02f, 1.91527680e-02f, -3.35358083e-02f, -4.64130715e-02f,
  1.67412646e-02f, 3.56646478e-02f, 1.08046038e-02f, 8.68470371e-02f, 2.52248049e-02f, -2.52224710e-02f, 6.35284185e-02f, 9.86319259e-02f, 7.72770718e-02f, -5.58318421e-02f,
  6.97206110e-02f, 6.07653484e-02f, -2.87705455e-02f, -2.83401702e-02f, 2.29488574e-02f, 3.86899337e-02f, 2.10821945e-02f, 7.55771180e-05f, -9.68598202e-03f, -3.53146195e-02f,
  2.13737682e-01f, 8.09982046e-02f, -1.32954642e-01f, 2.73081541e-01f, -2.28234023e-01f, 6.55004382e-02f, 2.52001006e-02f, -1.42638236e-01f, 1.89826861e-01f, -8.00687238e-04f,
  2.47814178e-01f, -8.39444343e-03f, -7.90389106e-02f, 3.37750256e-01f, 2.20912427e-01f, 2.34406486e-01f, 1.49353340e-01f, 2.55332440e-01f, 9.84465890e-03f, 8.19943324e-02f,
  -4.81823571e-02f, 2.04283074e-02f, -1.51353553e-01f, -2.53904730e-01f, -1.16143346e-01f, -1.66550070e-01f, -1.85387358e-02f, -2.35578224e-01f, -9.56676602e-02f, -1.43954828e-01f,
  9.28710401e-02f, 8.31060559e-02f, 2.19589025e-02f, -6.51254356e-02f, 7.66575430e-03f, -2.33346354e-02f, 1.21260017e-01f, -7.06803352e-02f, 5.96793629e-02f, -3.06536108e-02f,
  -8.09040666e-03f, -2.07388327e-02f, -3.18863541e-02f, -5.12536503e-02f, -2.96911355e-02f, -3.53751406e-02f, -3.12600210e-02f, 5.68401106e-02f, -5.55629171e-02f, -6.64338470e-02f,
  4.13885666e-03f, -9.35579911e-02f, -5.44750411e-03f, -5.24851382e-02f, -3.68650332e-02f, 2.64905374e-02f, -1.56784207e-01f, -7.90754408e-02f, 2.06611324e-02f, 7.92997517e-03f,
  1.18031323e-01f, -9.54590663e-02f, -1.39978454e-01f, -2.72066928e-02f, -4.52058688e-02f, 1.64855998e-02f, 1.20276399e-02f, -4.19644155e-02f, 3.54266576e-02f, 1.63894016e-02f,
  -1.53663410e-02f, 4.24961559e-02f, 1.84994414e-02f, -7.30371177e-02f, -5.31105660e-02f, -3.11565809e-02f, -3.01916655e-02f, -4.08301577e-02f, 9.01270658e-03f, 3.48349027e-02f,
  -1.83144845e-02f, 5.07734045e-02f, 2.19141431e-02f, -6.28870279e-02f, 9.53150466e-02f, -1.33043185e-01f, -1.14142358e-01f, -4.25143801e-02f, 1.05745830e-01f, -4.08888198e-02f,
  9.62826386e-02f, 4.20863815e-02f, -5.21973930e-02f, -6.53999001e-02f, 5.58198765e-02f, 9.45363045e-02f, 5.50914789e-03f, 8.00633579e-02f, -3.71447057e-02f, 2.78791636e-02f,
  -4.91495850e-03f, -2.11682543e-02f, -5.75073510e-02f, 8.17640051e-02f, 3.90549190e-02f, 5.67513183e-02f, 3.57960537e-02f, 6.75306693e-02f, -7.34937489e-02f, 3.54070999e-02f,
  -1.82924997e-02f, -8.62454902e-03f, -3.14600244e-02f, -6.55327961e-02f, -4.95523587e-02f, -8.36913213e-02f, 5.06648235e-02f, -4.36252058e-02f, -1.28910374e-02f, -1.42586790e-02f,
  -2.26276442e-01f, 3.57960224e-01f, 2.07189977e-01f, 2.99808055e-01f, -2.96635091e-01f, -3.05226564e-01f, 3.28240693e-01f, -3.88802700e-02f, 6.97308779e-02f, 2.12631673e-01f,
  -3.72265629e-03f, 2.16886103e-01f, 1.96093813e-01f, 2.36502767e-01f, -2.38155335e-01f, 7.69168958e-02f, -4.69778925e-02f, 1.91168398e-01f, 2.91158203e-02f, 1.02792218e-01f,
  -3.01547945e-02f, -8.09557512e-02f, 1.77379027e-01f, -7.89226964e-02f, 1.55811887e-02f, 6.10466897e-02f, -4.75331768e-03f, 4.82033007e-02f, 7.88997784e-02f, -4.77814265e-02f,
  2.76531223e-02f, 3.41200307e-02f, -9.47661232e-03f, 2.66835187e-02f, -6.64578378e-02f, -3.89379933e-02f, -4.51471045e-04f, -5.04190251e-02f, 4.11303379e-02f, 1.17676802e-01f,
  -1.80281117e-03f, -4.74721193e-02f, -1.37965977e-02f, 4.67201741e-03f, -9.91700962e-03f, 9.75106563e-03f, 2.19829474e-02f, -1.77005865e-02f, 1.31575465e-01f, -1.11595526e-01f,
  6.63500354e-02f, -5.13574779e-02f, -1.20637402e-01f, 7.75961280e-02f, -6.54843748e-02f, -8.13977346e-02f, -5.15012108e-02f, 1.07757859e-02f, -4.38906588e-02f, -9.51241776e-02f,
  -8.48376453e-02f, 4.89917807e-02f, 1.40454825e-02f, 5.26050963e-02f, -1.62464865e-02f, 3.70405503e-02f, -2.19617202e-03f, 2.63579935e-02f, 8.65955353e-02f, -2.20794305e-02f,
  -7.02892663e-03f, 4.00732867e-02f, -2.10210271e-02f, 1.33095374e-02f, -5.54591082e-02f, -6.22355219e-05f, -5.04592508e-02f, 1.28586456e-01f, -1.37316678e-02f, 3.35671715e-02f,
  4.19917926e-02f, 6.12527877e-03f, 1.15996890e-01f, -9.51604173e-03f, 7.25943819e-02f, 3.82783040e-02f, 3.78159829e-03f, -3.20428461e-02f, 8.02394301e-02f, 4.95088510e-02f,
  -1.06937811e-01f, 4.12828848e-02f, 6.15594089e-02f, -1.15889013e-02f, 1.34284168e-01f, -3.27858180e-02f, 1.53899509e-02f, -3.06027830e-02f, -5.66058606e-02f, -4.88946997e-02f,
  -8.50075111e-02f, 4.06155996e-02f, -1.93509664e-02f, 8.90618749e-03f, -3.02464385e-02f, 8.61827563e-03f, 8.70759562e-02f, 1.03865817e-01f, -6.82938024e-02f, -7.53327012e-02f,
  5.18675335e-03f, 1.71948839e-02f, 3.35706994e-02f, -4.59005944e-02f, -1.47913573e-02f, -3.97507884e-02f, -2.67751776e-02f, -7.61015166e-04f, -3.89235206e-02f, 1.85612254e-02f,
  -2.95110792e-01f, 1.24714494e-01f, -1.17783524e-01f, 1.40408963e-01f, 2.26494730e-01f, 1.57991499e-01f, -3.03770322e-02f, 1.84305817e-01f, -2.18699053e-02f, 9.24130529e-02f,
  8.08928311e-02f, -1.95338979e-01f, -1.23112746e-01f, 1.26185492e-01f, -2.79659629e-02f, -6.51959032e-02f, 3.01501423e-01f, 8.66445228e-02f, 4.95829172e-02f, 2.16578394e-01f,
  7.81092942e-02f, 2.41619304e-01f, 1.66096419e-01f, 2.92150110e-01f, 1.54534489e-01f, -8.58532358e-03f, 1.72349542e-01f, 1.64123122e-02f, 2.54621953e-01f, -4.12168764e-02f,
  -5.47677055e-02f, -1.66684553e-01f, -1.54571310e-01f, -1.47123083e-01f, 6.43033981e-02f, -9.27140340e-02f, 4.36841808e-02f, -7.68217966e-02f, -7.06479698e-02f, -7.93948174e-02f,
  -1.88125335e-02f, -6.45136610e-02f, 2.00842731e-02f, -3.62742245e-02f, 3.01690754e-02f, 3.96474525e-02f, 4.52611335e-02f, 2.04774179e-02f, -3.64945526e-03f, 3.52126248e-02f,
  5.70771331e-03f, -3.41081694e-02f, 6.69582188e-02f, 4.15717028e-02f, 6.80033118e-02f, 1.00281812e-01f, 1.37000168e-02f, -4.79161702e-02f, 9.32104290e-02f, -1.67405047e-03f,
  -2.12059673e-02f, -9.58512910e-03f, 8.27045292e-02f, -8.24981481e-02f, 1.10420790e-02f, -4.11124155e-02f, 6.59768656e-02f, -3.93283628e-02f, -2.99468432e-02f, 1.01232342e-01f,
  1.19382136e-01f, 1.97886899e-02f, 6.02467284e-02f, 9.70905349e-02f, 2.23326664e-02f, -1.56780146e-02f, 1.95560250e-02f, 2.30315831e-02f, 9.79537368e-02f, 1.15654454e-01f,
  -8.36258382e-03f, 1.27153501e-01f, -5.06849028e-02f, -1.05896182e-02f, -6.99781161e-03f, -5.75769693e-02f, 1.23155288e-01f, 8.47939309e-03f, 5.63187599e-02f, -1.58798788e-02f,
  7.29051009e-02f, 1.45073667e-01f, -3.92585844e-02f, -5.17382734e-02f, 3.45866522e-03f, 1.33823175e-02f, 1.33058866e-02f, 6.03689477e-02f, -2.12111250e-02f, -4.73369956e-02f,
  8.59571993e-02f, -5.13130426e-03f, 2.54623163e-02f, -3.69796939e-02f, 1.47573933e-01f, 1.13543846e-01f, 1.14407472e-01f, 1.27838468e-02f, 5.28551042e-02f, 1.41713336e-01f,
  1.42067656e-01f, 6.66812882e-02f, 2.22236738e-02f, 1.04915380e-01f, 1.18978411e-01f, 8.02579056e-03f, -7.58453272e-03f, -1.98118985e-02f, 6.17605373e-02f, 1.82967354e-02f,
  -4.71284032e-01f, 1.58831567e-01f, -6.44512996e-02f, -4.08188045e-01f, -8.30513686e-02f, -1.84963375e-01f, -2.66538143e-01f, -1.11292519e-01f, -1.29604891e-01f, 2.11173922e-01f,
  -9.92332175e-02f, -6.98717535e-02f, 6.22668341e-02f, -4.49222811e-02f, -4.57452595e-01f, -9.99887567e-03f, -7.44380429e-02f, 1.77107248e-02f, -2.70154662e-02f, -1.27553105e-01f,
  -1.19487591e-01f, -4.80705686e-02f, -1.60793111e-01f, 2.02369153e-01f, -2.92516798e-02f, 7.67199770e-02f, 4.72360812e-02f, 8.92366618e-02f, 6.18144125e-02f, 1.57028101e-02f,
  -9.84725878e-02f, -2.18286768e-01f, 5.65783866e-02f, 1.26983091e-01f, -4.90383320e-02f, 3.02703455e-02f, -7.91546050e-03f, 2.15452481e-02f, -5.13180643e-02f, -8.31473470e-02f,
  4.55858335e-02f, -5.64788692e-02f, 9.13850032e-03f, 5.58814295e-02f, 7.33611137e-02f, -7.23639727e-02f, 2.24564075e-02f, 5.49459234e-02f, -9.89338942e-03f, -1.09886779e-02f,
  2.89510768e-02f, -8.02295655e-02f, 6.84897602e-02f, 9.66983940e-03f, -9.95695405e-03f, -1.53159657e-02f, -1.21596688e-02f, 4.40469272e-02f, -1.15879752e-01f, -1.40590921e-01f,
  1.41251003e-02f, 5.92164174e-02f, 7.16229603e-02f, -3.02326828e-02f, -4.14789803e-02f, 3.75882126e-02f, 1.04455702e-01f, 1.86148146e-03f, 1.24951661e-01f, -7.93669522e-02f,
  -1.07649840e-01f, -2.17520911e-02f, -2.50401907e-02f, 1.04935579e-02f, -2.28041243e-02f, -3.57616134e-02f, 3.24649103e-02f, 3.16132279e-03f, 6.46150559e-02f, 3.21274102e-02f,
  3.71222496e-02f, 3.15544754e-02f, -1.81315355e-02f, 5.46650141e-02f, 8.43496844e-02f, -9.98418592e-03f, 8.16920623e-02f, 2.98107304e-02f, -4.95486818e-02f, -1.97462253e-02f,
  -9.33129042e-02f, -2.13967130e-01f, 3.41579542e-02f, -5.52136488e-02f, 1.01651341e-01f, 1.00263348e-02f, 9.03768316e-02f, 2.08830342e-01f, -8.36682171e-02f, -3.89486477e-02f,
  7.36274794e-02f, 9.58095118e-02f, -7.85440281e-02f, 1.36719644e-01f, 2.49197893e-02f, -5.12747467e-03f, -6.00419119e-02f, -1.48599071e-03f, -1.31963745e-01f, 3.40740159e-02f,
  5.92920696e-03f, -3.57037112e-02f, 3.74754295e-02f, -3.54981497e-02f, 8.54383036e-02f, -6.33439515e-03f, -6.81159943e-02f, 4.74465042e-02f, 4.84500360e-03f, 3.44673730e-02f,
  6.75690314e-03f, 4.73391004e-02f, -2.11568907e-01f, -8.42966978e-03f, -2.16368344e-02f, 2.73738801e-01f, 1.18266180e-01f, -3.58965658e-02f, -2.40322173e-01f, 7.45717809e-02f,
  8.66537467e-02f, -1.40638128e-01f, -9.91975516e-02f, 1.66924998e-01f, 1.04495741e-01f, -9.36355144e-02f, 2.85693437e-01f, 1.66343436e-01f, -1.31294861e-01f, 1.05004750e-01f,
  -6.34902790e-02f, 1.95370287e-01f, -3.41435857e-02f, 4.99687679e-02f, 2.20661089e-01f, 1.29384948e-02f, 1.46370679e-01f, -2.02621251e-01f, 1.94988698e-01f, -8.51565041e-03f,
  1.02885328e-01f, -1.19108438e-01f, -2.14332677e-02f, 2.88233086e-02f, 9.09298062e-02f, 5.64097054e-03f, 4.42161784e-02f, 4.53797840e-02f, -6.71544746e-02f, -5.97734824e-02f,
  -3.32076102e-02f, 5.09905163e-03f, 3.00555043e-02f, -1.03158601e-01f, -6.91519957e-03f, -2.98839025e-02f, -9.56284404e-02f, 7.08413944e-02f, -8.97118896e-02f, -3.78031693e-02f,
  -1.74601957e-01f, 5.31997308e-02f, 4.69740704e-02f, 2.56910976e-02f, -7.15277568e-02f, -7.37764537e-02f, 2.89988630e-02f, 1.15857972e-03f, 1.68934818e-02f, 4.97560529e-03f,
  2.22543739e-02f, 1.11938812e-01f, 5.57917580e-02f, -1.45653011e-02f, 5.60982991e-03f, 3.90698761e-02f, 2.13476159e-02f, 8.56784284e-02f, 1.07872672e-03f, 2.13815868e-02f,
  3.96841280e-02f, -1.10939853e-02f, -2.67721582e-02f, 2.22048797e-02f, 5.47034033e-02f, 2.55244244e-02f, 7.86927044e-02f, -3.16332169e-02f, -6.75209844e-03f, 7.23112049e-03f,
  1.93907153e-02f, 8.03126469e-02f, -1.65158398e-02f, 3.45760919e-02f, 8.92296731e-02f, 9.72739886e-03f, -3.06696258e-02f, -3.42495218e-02f, -2.13125311e-02f, -2.27064583e-02f,
  2.42173910e-01f, 2.11545080e-01f, -3.76741476e-02f, 3.71761546e-02f, -2.66875308e-02f, -4.82261218e-02f, -2.19400246e-02f, 6.16404302e-02f, 1.15220044e-02f, -2.91932542e-02f,
  3.79114156e-03f, 9.20149013e-02f, 5.55214472e-02f, 1.00685924e-01f, 3.10161356e-02f, 3.07774311e-03f, -4.78931256e-02f, -5.89680746e-02f, 6.99742809e-02f, 4.43433002e-02f,
  4.37509790e-02f, -7.36785633e-03f, 1.80531517e-02f, -2.55643316e-02f, 9.64317285e-03f, -1.80033445e-02f, 6.97030351e-02f, -7.43411854e-02f, 6.02565929e-02f, 4.33611590e-03f,
  2.32605517e-01f, -2.35060081e-01f, 1.18582137e-01f, 1.01451382e-01f, 2.73155123e-01f, -2.64554352e-01f, -6.48457464e-03f, 1.27886072e-01f, 3.13108087e-01f, -5.00557274e-02f,
  2.58763343e-01f, -3.08844447e-03f, 1.83711901e-01f, -2.00824142e-01f, 2.68226359e-02f, -1.13239534e-01f, -1.37289479e-01f, -8.52311924e-02f, 1.01563081e-01f, 5.70524409e-02f,
  2.00444250e-03f, -6.44748136e-02f, 2.54846681e-02f, -4.12329379e-03f, 1.34645164e-01f, 2.73028333e-02f, 2.25706801e-01f, 1.61946774e-01f, -5.78436591e-02f, -1.92568172e-02f,
  -2.83345312e-01f, 1.40369058e-01f, 2.11495142e-02f, -8.22715685e-02f, 3.28331105e-02f, 1.23509439e-02f, -5.52274808e-02f, -7.72833973e-02f, -2.44193599e-02f, 1.67966168e-02f,
  2.22076904e-02f, -3.68598513e-02f, -8.20756778e-02f, 8.83769169e-02f, 9.01083574e-02f, 1.07969224e-01f, 5.44117168e-02f, -4.90004420e-02f, 7.05425218e-02f, -2.69306032e-03f,
  5.95243871e-02f, 2.83851894e-03f, 9.02406052e-02f, -1.87182578e-03f, 7.16763586e-02f, 6.92005306e-02f, -4.05762121e-02f, 7.07803592e-02f, -2.80385907e-03f, 3.90938893e-02f,
  4.51832563e-02f, -5.96480630e-03f, 5.25745042e-02f, 2.38727778e-02f, -1.27473352e-02f, -2.13272199e-02f, 2.96933111e-02f, -6.93437904e-02f, 1.17004707e-01f, 3.72293405e-02f,
  -8.47542379e-03f, 6.01523630e-02f, 1.44420281e-01f, 2.28653569e-02f, 7.73357053e-04f, -5.21396697e-02f, -6.98482767e-02f, -8.07403587e-03f, 4.92772497e-02f, -3.48028429e-02f,
  3.79176959e-02f, 6.28925189e-02f, -7.42863789e-02f, -1.22226350e-01f, -3.96618396e-02f, 1.61270112e-01f, 8.08875784e-02f, -3.00847255e-02f, 6.41633943e-02f, 2.37591062e-02f,
  -2.02292800e-01f, 2.89683547e-02f, -6.57725111e-02f, -1.23336703e-01f, -5.19980453e-02f, 3.23636197e-02f, -8.23775008e-02f, -1.46401245e-02f, -9.23044607e-02f, 8.07660725e-03f,
  2.56981291e-02f, -5.27988039e-02f, 1.29263452e-03f, -6.98980829e-03f, 5.67750446e-02f, 1.22459494e-01f, 9.06905010e-02f, 7.34145194e-02f, 7.25385621e-02f, 1.00047439e-02f,
  7.47411251e-02f, 5.11412881e-02f, 4.40222658e-02f, 2.10472364e-02f, 2.00923365e-02f, 4.16976474e-02f, -2.94131935e-02f, -1.32344710e-02f, 1.15622906e-02f, -1.71254994e-03f,
  -2.68507272e-01f, 4.23439965e-02f, 2.03035418e-02f, 1.90441743e-01f, -1.15594357e-01f, -1.57038867e-01f, -1.15009673e-01f, -1.42925307e-02f, -2.54363924e-01f, 9.39163379e-03f,
  1.45201996e-01f, -1.97933272e-01f, -2.29337830e-02f, 1.83308065e-01f, 3.59576009e-02f, 1.50005847e-01f, 1.75818503e-01f, 1.88418217e-02f, 1.68661296e-01f, 8.07171687e-02f,
  1.16328984e-01f, 1.75931230e-01f, 1.57095909e-01f, 4.30242121e-02f, 6.99233860e-02f, 1.15804449e-02f, 4.54188175e-02f, 2.74587842e-03f, 9.25237387e-02f, -9.40432623e-02f,
  -5.68727031e-02f, 2.37437915e-02f, -1.18821710e-01f, -6.55380338e-02f, -7.43555650e-02f, -3.33598405e-02f, -2.27224249e-02f, -2.54409797e-02f, 1.05365701e-01f, -2.81166695e-02f,
  -6.42568544e-02f, 1.02540161e-02f, 3.16141956e-02f, 4.76323105e-02f, -5.51425219e-02f, 3.28096002e-03f, 6.95087463e-02f, 1.31144032e-01f, 5.63383996e-02f, 1.58435106e-02f,
  6.33127289e-03f, 1.06140077e-01f, 5.62654920e-02f, -3.99240889e-02f, 2.65530832e-02f, -5.68394968e-03f, -1.13216368e-03f, -1.08632527e-01f, -4.49519530e-02f, -1.17596939e-01f,
  6.19384833e-02f, -4.56516482e-02f, 4.91877366e-03f, -2.54311394e-02f, -4.78574783e-02f, -3.65032535e-03f, 4.05159704e-02f, 5.51858768e-02f, 1.26149808e-03f, 3.00656911e-02f,
  2.33484078e-02f, 6.77218437e-02f, 3.91652174e-02f, -5.83573952e-02f, 1.10445246e-01f, -1.79688428e-02f, 3.88672277e-02f, -6.52652234e-02f, -2.35919049e-03f, 3.20307575e-02f,
  -3.08026038e-02f, -9.96684581e-02f, -1.48122723e-03f, -2.51623895e-02f, -2.13910663e-03f, -1.26858531e-02f, 8.86988714e-02f, 7.47946203e-02f, -2.65715253e-02f, 4.27032076e-02f,
  -2.36705989e-01f, -1.22436650e-01f, -1.25507101e-01f, -2.18535401e-02f, -9.99147352e-03f, 5.92444278e-02f, 7.27363005e-02f, 6.36370331e-02f, -4.89669964e-02f, -1.13285281e-01f,
  -3.30452472e-02f, 3.55803967e-02f, 2.60868240e-02f, -8.00668597e-02f, -1.89031493e-02f, -8.63671452e-02f, 9.67526287e-02f, -5.54901846e-02f, -2.02811122e-01f, -3.13497745e-02f,
  7.84756558e-04f, 2.15079021e-02f, 5.19922860e-02f, 2.30758153e-02f, 3.05834133e-02f, 1.40738282e-02f, -1.01271629e-01f, 3.52598205e-02f, 6.20515086e-04f, -4.30544093e-03f,
  8.79027545e-02f, 3.36576015e-01f, 1.49324104e-01f, 1.63902372e-01f, -1.49018213e-01f, -2.32895926e-01f, -3.41827631e-01f, 1.09657794e-01f, 8.95727500e-02f, -4.68412787e-02f,
  -2.35897094e-01f, 2.72438467e-01f, -3.04279607e-02f, 5.24558574e-02f, -1.32403746e-01f, -7.10348487e-02f, 1.70343835e-02f, -4.87967357e-02f, 7.87248835e-02f, 1.62883043e-01f,
  8.80120024e-02f, -6.52110875e-02f, 1.43997282e-01f, 6.50527328e-02f, 3.01727541e-02f, 2.08404914e-01f, 5.61878383e-02f, -4.02095988e-02f, 5.99417090e-02f, -7.34479874e-02f,
  -8.13959017e-02f, 5.20904772e-02f, 7.55972490e-02f, -4.90757124e-03f, -1.08759895e-01f, -8.43067467e-02f, 1.40638594e-02f, -9.30104330e-02f, 1.31847081e-03f, 2.33786348e-02f,
  -1.30311754e-02f, -1.12278871e-02f, -4.14784364e-02f, 6.65720403e-02f, -4.52213082e-03f, -2.90194452e-02f, 7.48487748e-03f, 3.17541324e-02f, 9.72253531e-02f, 5.86165674e-02f,
  4.87106927e-02f, -4.51625586e-02f, -2.35803649e-02f, 2.57866923e-03f, -7.19079748e-03f, -5.08994684e-02f, -1.63798425e-02f, -1.34787261e-02f, -8.81466419e-02f, -3.42202969e-02f,
  -7.92303309e-03f, -1.14912097e-03f, -2.01611686e-02f, 2.33394429e-02f, -3.10685597e-02f, -3.12218275e-02f, 2.69399304e-02f, -1.13307498e-02f, 1.09904476e-01f, -5.52177913e-02f,
  -1.05642281e-01f, -6.51341677e-02f, -2.47046053e-02f, -5.28786853e-02f, -1.76377855e-02f, 2.19413359e-02f, -5.81799634e-02f, 7.02551529e-02f, 3.57574299e-02f, 3.04179918e-02f,
  -1.96869355e-02f, -7.01715350e-02f, -1.36097120e-02f, -1.42831774e-02f, -7.72622675e-02f, -3.82220373e-02f, 1.14100231e-02f, 5.65006174e-02f, -6.89917570e-03f, -1.37169994e-02f,
  -7.17452392e-02f, 8.08813646e-02f, 9.60332109e-04f, -8.99609774e-02f, 2.68222373e-02f, -2.96059456e-02f, 9.37194750e-03f, 6.44654185e-02f, 7.54096126e-03f, -7.67346248e-02f,
  4.57270928e-02f, -2.81308573e-02f, -4.39363010e-02f, 6.48627505e-02f, -4.29686941e-02f, -1.46565558e-02f, -4.86510210e-02f, -2.07067840e-02f, -1.01691820e-01f, -5.69986552e-02f,
  -2.95344228e-03f, -8.06761757e-02f, -1.42846117e-02f, -1.38053358e-01f, -3.98966521e-02f, -4.19548936e-02f, 2.09151767e-02f, 6.25057146e-02f, -3.98852490e-02f, -9.33137815e-03f,
  3.26127440e-01f, -2.79335767e-01f, -1.37657270e-01f, 1.67611510e-01f, 2.27024332e-01f, -2.29340475e-02f, -1.54860437e-01f, 2.38514051e-01f, -1.30513206e-01f, -1.22366734e-01f,
  7.96430558e-02f, 1.25952167e-02f, -2.27636486e-01f, 9.09646451e-02f, 1.43487483e-01f, -2.00969949e-01f, 1.28747255e-01f, 3.18179689e-02f, 7.07487166e-02f, 2.45665118e-01f,
  4.33537178e-02f, 2.36034155e-01f, 6.44441172e-02f, 1.09342225e-01f, 1.51807591e-01f, 1.14475623e-01f, 6.06367253e-02f, -4.73837703e-02f, 1.09021455e-01f, -4.53998614e-03f,
  9.32909474e-02f, 1.03840508e-01f, 1.06962591e-01f, 5.72393974e-03f, 1.11888602e-01f, -2.15485715e-03f, -2.19488498e-02f, -7.70854950e-02f, 4.86739054e-02f, 4.15758900e-02f,
  -3.70279700e-02f, 1.39940187e-01f, 2.53651887e-02f, -5.03803715e-02f, 3.11887618e-02f, 8.89848918e-02f, 1.99888684e-02f, 1.09711602e-01f, -8.23252462e-03f, -6.69790357e-02f,
  -5.47978990e-02f, 5.90242930e-02f, -3.35252136e-02f, -3.73039469e-02f, -2.32246928e-02f, -5.50895035e-02f, -6.78878501e-02f, -4.03386056e-02f, 1.42404646e-01f, 1.03497937e-01f,
  -7.46579170e-02f, -7.49719888e-02f, -4.09492888e-02f, 1.12125710e-01f, -8.79370868e-02f, -5.70510607e-03f, -9.72604826e-02f, 1.17309682e-01f, -1.09624393e-01f, 1.13999516e-01f,
  1.36176214e-01f, 1.33763105e-01f, 2.74655595e-02f, -1.31128922e-01f, 2.75249686e-02f, -3.29581685e-02f, -3.78966108e-02f, 3.77115645e-02f, 2.60352269e-02f, 1.04213074e-01f,
  5.84986918e-02f, -7.03949332e-02f, 3.82421315e-02f, -1.74707975e-02f, -6.01322576e-02f, 2.91720908e-02f, -4.93925177e-02f, -9.17880833e-02f, 2.71039456e-02f, 8.96489993e-02f,
  2.32785270e-02f, 9.69487578e-02f, 2.44676303e-02f, 1.08340532e-01f, 6.65837377e-02f, 7.30842128e-02f, 4.54433560e-02f, -1.16408570e-02f, 1.36413341e-02f, 5.50924912e-02f,
  -2.34059617e-02f, -3.81568521e-02f, 6.17243834e-02f, 2.09812149e-02f, -1.05202198e-01f, -5.37215173e-03f, -3.56213078e-02f, 6.46708235e-02f, 1.93370774e-01f, 1.61868632e-02f,
  5.39723784e-02f, 1.17899306e-01f, -5.99136986e-02f, 4.23261896e-02f, 3.44201247e-03f, -6.93136528e-02f, 6.88949004e-02f, -7.52321482e-02f, -4.71742004e-02f, 7.79645666e-02f,
  -3.28541070e-01f, 1.57505542e-01f, -3.28349620e-02f, -3.92263472e-01f, -1.79102316e-01f, 1.22992881e-01f, 7.01646805e-02f, -3.55011038e-02f, -3.13335657e-02f, 1.48063079e-01f,
  -1.66679863e-02f, -7.74370283e-02f, 2.08431304e-01f, -3.31533879e-01f, -3.59366775e-01f, 1.64037019e-01f, -1.54935688e-01f, -6.28469810e-02f, 1.24340154e-01f, -1.02018163e-01f,
  -1.64660677e-01f, -3.85012776e-01f, -1.13515779e-01f, -4.72043715e-02f, -1.86661065e-01f, 7.86130354e-02f, -2.41910994e-01f, 9.86732244e-02f, -2.66385168e-01f, -7.21758604e-02f,
  1.06053852e-01f, -7.85458311e-02f, 2.26475392e-02f, 8.90494660e-02f, 4.75974753e-02f, 4.04081792e-02f, 8.86831135e-02f, -6.56810850e-02f, -2.65486930e-02f, -1.02602653e-02f,
  -8.34573712e-03f, -1.06598914e-01f, -9.91315693e-02f, -5.16090728e-02f, -9.86052826e-02f, -6.63865283e-02f, -7.04557225e-02f, 4.15727943e-02f, -6.20242953e-02f, -7.80009702e-02f,
  -5.55318594e-02f, -1.30133564e-02f, -1.26014486e-01f, 2.33576670e-02f, -5.45104081e-03f, -4.13694941e-02f, -4.50717146e-03f, -3.01554892e-02f, -1.64288823e-02f, -3.40864435e-02f,
  -9.52306017e-02f, 1.98141430e-02f, 8.45321082e-03f, -2.84427614e-03f, -8.78426898e-03f, 2.74371356e-02f, -2.80175433e-02f, 6.06257729e-02f, 4.78919037e-02f, 5.28005846e-02f,
  6.37720451e-02f, 9.91002023e-02f, -5.29107004e-02f, -6.02286234e-02f, 2.83158757e-02f, -3.48407254e-02f, -4.75240350e-02f, 1.39174154e-02f, 1.48789540e-01f, 7.91380405e-02f,
  8.36413950e-02f, -3.53161059e-02f, 8.95431116e-02f, -6.06216723e-03f, 2.44133715e-02f, -4.04140651e-02f, -5.01111336e-02f, -4.11997586e-02f, -4.44568209e-02f, -7.22306892e-02f,
  6.83409646e-02f, 9.92937386e-02f, 5.03370278e-02f, 6.43160269e-02f, 1.20088272e-01f, -3.50821875e-02f, -2.00004447e-02f, -4.84998859e-02f, -1.61087848e-02f, -9.80642736e-02f,
  -4.62507233e-02f, 7.95858167e-03f, 8.82997811e-02f, 1.92265790e-02f, 4.23118956e-02f, -3.79409641e-03f, -1.27420230e-02f, 6.35483786e-02f, -3.56293805e-02f, 4.10693623e-02f,
  -4.77104187e-02f, 2.62344698e-03f, -1.16634123e-01f, -7.99684897e-02f, -4.29965854e-02f, -3.32536213e-02f, -1.48390858e-02f, 6.01844154e-02f, -5.75750135e-02f, 8.11512247e-02f,
  2.91220427e-01f, -8.88533220e-02f, 7.97661766e-02f, -1.84003532e-01f, 2.06998214e-01f, 3.37414980e-01f, 2.40899146e-01f, -1.99966244e-02f, -9.60048437e-02f, -1.35764211e-01f,
  1.06431572e-02f, -9.09385011e-02f, 2.16983572e-01f, -1.36086896e-01f, 4.24340934e-01f, 6.88936487e-02f, -4.29145172e-02f, -1.42824367e-01f, -8.68134946e-03f, 6.08174875e-02f,
  4.26953547e-02f, 6.73813447e-02f, 1.31112244e-02f, -2.53239796e-02f, 1.27779633e-01f, -1.02550440e-01f, -5.80666140e-02f, 4.90535796e-02f, -1.82580873e-01f, 1.30415246e-01f,
  2.28523221e-02f, -1.02611221e-01f, -7.44359493e-02f, 3.77456173e-02f, 1.73766930e-02f, 2.90130321e-02f, 4.85443324e-02f, 8.73909146e-02f, -6.88786209e-02f, 9.13274381e-03f,
  -7.59609044e-02f, 1.94529269e-03f, -6.65654838e-02f, 3.70047465e-02f, -9.78243910e-03f, -1.72768891e-01f, 6.07215166e-02f, 4.29029390e-02f, -5.82809225e-02f, 6.08931072e-02f,
  1.08143464e-01f, -7.09831640e-02f, 6.07041735e-03f, -9.33101997e-02f, -2.32544988e-02f, -2.61374097e-02f, -3.95866670e-02f, 1.24403715e-01f, -1.24116555e-01f, 4.10335213e-02f,
  3.77641767e-02f, -7.41677657e-02f, -6.73136935e-02f, -6.28966391e-02f, 5.69662265e-02f, -2.37998217e-02f, -5.02041504e-02f, -1.40460907e-02f, 1.23533882e-01f, -4.96189967e-02f,
  -5.85785955e-02f, -5.67716956e-02f, -3.44338529e-02f, -1.24293091e-02f, -2.19112448e-03f, -8.20521340e-02f, 2.40334440e-02f, 2.50123497e-02f, -1.68696314e-03f, 1.20389061e-02f,
  -1.16867155e-01f, 1.09610088e-01f, 6.35389462e-02f, -4.03126106e-02f, -5.89225963e-02f, -2.73488853e-02f, -5.46134301e-02f, -6.61571249e-02f, 1.94409490e-02f, 3.41053493e-02f,
  1.78861901e-01f, -1.13717970e-02f, -2.62885168e-02f, 3.69095430e-02f, -8.27606395e-02f, 7.02762529e-02f, 5.64782554e-03f, 2.19168141e-02f, -4.94054966e-02f, -5.79530001e-03f,
  1.16718384e-02f, -8.73235762e-02f, -4.37899604e-02f, 1.98611971e-02f, -1.11468025e-01f, 9.49975774e-02f, 5.09123057e-02f, -4.88903448e-02f, -6.53067753e-02f, -8.36225450e-02f,
  -6.60405215e-03f, 2.32088771e-02f, -3.11881956e-02f, -2.62146518e-02f, -8.04124475e-02f, 4.11153734e-02f, 3.72621864e-02f, 1.11062257e-02f, 6.68451115e-02f, -1.12918265e-01f,
  -2.18898490e-01f, -1.92988694e-01f, 8.27581249e-03f, -1.79957196e-01f, -1.34954140e-01f, 2.08120733e-01f, 1.44198820e-01f, -2.16225296e-01f, -1.97039276e-01f, 1.34876091e-02f,
  -4.09562103e-02f, 3.13218907e-02f, 2.19256893e-01f, -1.15679391e-02f, 2.68618107e-01f, 2.71607667e-01f, 3.99185438e-03f, 1.58183903e-01f, -7.59767592e-02f, -1.93457216e-01f,
  -5.24457991e-02f, -5.57077080e-02f, 6.21542633e-02f, -1.45721480e-01f, -1.07405514e-01f, -1.75904453e-01f, -4.80564646e-02f, -6.94546402e-02f, -1.32724307e-02f, 1.26080453e-01f,
  -5.50078740e-03f, -1.91659391e-01f, -8.79456550e-02f, 8.84835795e-02f, -5.64165302e-02f, 6.04767986e-02f, 8.72907266e-02f, 1.62586778e-01f, 1.94471758e-02f, 5.87831885e-02f,
  1.46632999e-01f, 5.73579706e-02f, -9.75430608e-02f, 1.50727063e-01f, 8.41708332e-02f, -1.56074716e-02f, 1.87156647e-02f, 1.00817993e-01f, 1.53480349e-02f, 2.35773679e-02f,
  -5.12202568e-02f, 7.01512489e-03f, 8.96446407e-04f, 4.79015000e-02f, -2.55916659e-02f, -2.00321563e-02f, 2.95809004e-02f, 5.01120798e-02f, -1.83140915e-02f, -1.76673993e-01f,
  4.68980521e-02f, -6.32068515e-02f, -3.18054445e-02f, 1.81185417e-02f, -7.09612519e-02f, -6.73548132e-02f, 4.05776538e-02f, -2.46636514e-02f, -7.87487477e-02f, -1.14619941e-01f,
  -2.91161966e-02f, -9.27022994e-02f, -5.64825423e-02f, 4.22647856e-02f, -1.02982812e-01f, -1.29134953e-01f, 6.45483360e-02f, 1.82257295e-02f, 8.94051138e-03f, -1.12469541e-02f,
  -2.58171894e-02f, 5.73953427e-02f, -5.93590550e-02f, 5.59136495e-02f, 8.64802208e-03f, -7.77302086e-02f, 6.62102327e-02f, 3.19124311e-02f, 2.58648600e-02f, 8.52839798e-02f,
  -1.45907357e-01f, -2.56835938e-01f, 3.54805477e-02f, -2.37671975e-02f, -8.68382305e-03f, -1.55135458e-02f, 6.39288798e-02f, 9.33047831e-02f, -2.09185518e-02f, 3.85530218e-02f,
  2.74298470e-02f, -4.04245872e-03f, -2.87076868e-02f, 8.83736834e-02f, 6.51398897e-02f, -8.19882601e-02f, -7.21862679e-03f, 8.30673948e-02f, -8.67043659e-02f, -7.35714063e-02f,
  -1.27068618e-02f, 4.87250909e-02f, 5.01933470e-02f, -8.51208046e-02f, 1.01419248e-01f, -6.34567067e-02f, -5.07889949e-02f, 1.41233588e-02f, 1.61926113e-02f, 2.93556880e-02f,
  1.47489846e-01f, -8.86507034e-02f, -9.10780728e-02f, -1.65133372e-01f, -1.56963989e-02f, -3.21002424e-01f, -2.44505354e-03f, -1.61176056e-01f, 4.24879938e-02f, 3.93336453e-02f,
  -9.08711106e-02f, 2.26562858e-01f, 1.45111561e-01f, -2.97761738e-01f, -2.06360996e-01f, 8.89334977e-02f, -3.10723126e-01f, -4.80219759e-02f, 4.69071306e-02f, -1.89301363e-06f,
  -7.42227361e-02f, -1.12490632e-01f, -1.12052687e-01f, -5.47248945e-02f, -7.43616149e-02f, 3.62695009e-02f, -6.75852895e-02f, 9.43014249e-02f, -2.72511095e-01f, 5.57816625e-02f,
  -1.95704311e-01f, 1.46107167e-01f, -4.89180572e-02f, -2.04450637e-02f, -9.56858546e-02f, -2.50349175e-02f, -8.87108073e-02f, -5.83103579e-03f, 2.60764733e-02f, -4.13931310e-02f,
  4.60917428e-02f, 5.37863299e-02f, -2.63122711e-02f, 1.06875867e-01f, 6.76107174e-03f, 2.71587837e-02f, -6.60905242e-02f, -1.12487733e-01f, -1.70046855e-02f, -3.08076441e-02f,
  3.04979291e-02f, -3.11284028e-02f, -1.13771334e-01f, 7.28379488e-02f, 3.78749929e-02f, 4.60778438e-02f, -1.04393894e-02f, 1.86163876e-02f, 2.47136541e-02f, 9.92823765e-03f,
  1.51547575e-02f, 3.32770124e-02f, 3.87094654e-02f, 5.36315143e-02f, 3.11891120e-02f, -6.18311018e-02f, -4.03563268e-02f, 1.09333917e-01f, -7.99656436e-02f, 6.40478125e-03f,
  4.43311594e-02f, 9.26722679e-03f, -9.76726692e-03f, -7.51814544e-02f, -3.01774181e-02f, -2.45554131e-02f, -4.14583385e-02f, 1.83511134e-02f, -1.71678271e-02f, -7.94677883e-02f,
  8.07180181e-02f, -8.48237425e-02f, 1.77373905e-02f, -6.99614137e-02f, -8.39800462e-02f, 5.56835346e-02f, -3.20457406e-02f, -1.32845361e-02f, -1.18961990e-01f, 1.72057096e-02f,
  -1.03785321e-01f, -3.92973423e-02f, 8.37713480e-02f, 3.55317593e-02f, 7.86766931e-02f, -7.14937747e-02f, 2.23881640e-02f, -1.48559481e-01f, -4.18796316e-02f, -1.12713287e-02f,
  -6.69239461e-02f, -6.95381463e-02f, 3.14572975e-02f, -4.07494903e-02f, -4.60272059e-02f, -1.05825230e-01f, -3.14381532e-03f, -2.57598236e-02f, 3.36379595e-02f, 1.35784794e-03f,
  1.61416624e-02f, 1.22026324e-01f, -1.76769905e-02f, 1.75285607e-03f, -4.20956202e-02f, -1.21971546e-02f, 8.30962043e-03f, -1.76731218e-02f, -3.76379229e-02f, -9.14874300e-03f,
  -7.23552555e-02f, -2.11953316e-02f, -2.51729131e-01f, -1.88137162e-02f, 6.99441656e-02f, 1.96295634e-01f, -4.74568270e-02f, 4.64468673e-02f, -1.01108052e-01f, 4.34954725e-02f,
  5.03233708e-02f, -2.09655538e-01f, -8.04811120e-02f, 1.27990112e-01f, 1.92788452e-01f, -7.72166327e-02f, 2.73624361e-01f, 8.50595236e-02f, -1.05779544e-02f, 2.21910179e-01f,
  -6.36145994e-02f, 2.68014282e-01f, -5.99018224e-02f, 1.08547367e-01f, 1.11565264e-02f, -7.71073177e-02f, 1.70226887e-01f, -1.10905759e-01f, 1.89230278e-01f, -3.92188206e-02f,
  1.55554637e-01f, -5.11445738e-02f, -1.12874672e-01f, -3.80157344e-02f, 9.65340808e-02f, -4.72040698e-02f, -7.30121657e-02f, -1.11156233e-01f, -2.98123602e-02f, -6.15038462e-02f,
  -8.14285278e-02f, -1.17526215e-03f, 4.04667556e-02f, -1.07491352e-01f, -3.66448723e-02f, 1.76593624e-02f, -6.09413944e-02f, -1.70617085e-02f, -1.11603193e-01f, -1.21836171e-01f,
  -1.30656093e-01f, -2.25233729e-03f, -1.19469492e-02f, -6.39787838e-02f, -1.15968451e-01f, -8.79108813e-03f, 1.03256041e-02f, -6.60829246e-02f, 2.26503909e-02f, 6.95541501e-02f,
  -8.48637670e-02f, 1.39958173e-01f, 4.09201570e-02f, 1.43000767e-01f, 6.42808080e-02f, 4.34634648e-02f, 1.07297026e-01f, 1.01997174e-01f, 1.51088266e-02f, 1.85666069e-01f,
  1.51547909e-01f, 1.03912294e-01f, 1.85572430e-02f, 2.19538733e-02f, 7.26102740e-02f, 2.45912708e-02f, 4.44200411e-02f, -1.09358421e-02f, 2.48725880e-02f, -2.68865433e-02f,
  6.58783549e-03f, 5.46748526e-02f, 9.17619541e-02f, -1.47618921e-02f, 3.02431267e-02f, 1.26058366e-02f, 5.43460576e-03f, 1.49074951e-02f, 1.70607716e-02f, -4.74137925e-02f,
  2.91968346e-01f, 2.93541402e-01f, 3.86924185e-02f, 7.74317682e-02f, 9.18309763e-02f, 2.72145513e-02f, 2.68257763e-02f, -1.26621798e-01f, 5.12441210e-02f, 2.66486071e-02f,
  -3.39256972e-02f, 6.31907731e-02f, 1.16471902e-01f, -4.66207862e-02f, 7.47520700e-02f, 3.09910681e-02f, 8.68820027e-02f, 2.08089110e-02f, 1.21177793e-01f, 1.38593152e-01f,
  3.08989938e-02f, 9.48813856e-02f, -5.84003702e-02f, 1.87944472e-02f, -2.23853048e-02f, 3.22571397e-02f, 3.12218796e-02f, -1.36053190e-01f, 1.51756767e-03f, 2.74445508e-02f,
  3.41564268e-01f, -2.95848191e-01f, -3.37952882e-01f, 2.48588428e-01f, 3.86118256e-02f, 4.61202115e-02f, 1.64356098e-01f, -1.41704783e-01f, 1.53791264e-01f, -4.31225337e-02f,
  1.44784957e-01f, -1.82377502e-01f, -1.56813085e-01f, 1.81375235e-01f, 9.82673913e-02f, -1.60521530e-02f, 1.28542855e-01f, -4.30639274e-02f, 3.45521681e-02f, 9.58657414e-02f,
  5.14541082e-02f, 2.92668164e-01f, -9.31684375e-02f, -9.17767212e-02f, -1.05974199e-02f, -1.50997013e-01f, -2.10934624e-01f, -1.53756842e-01f, 6.02762029e-03f, -2.23390572e-02f,
  9.78296995e-02f, 2.47236148e-01f, 5.79924211e-02f, 1.04624527e-02f, 9.13921595e-02f, 1.01931810e-01f, -5.44916876e-02f, 2.72849505e-03f, 1.23531394e-01f, 1.66868716e-02f,
  -2.73990761e-02f, -2.70950533e-02f, 7.88338482e-02f, 5.80254123e-02f, -5.57031436e-03f, 1.90670434e-02f, -4.22596000e-02f, -7.07999989e-02f, -9.46343243e-02f, -6.45691603e-02f,
  -8.09548125e-02f, -6.14306564e-03f, -7.64428824e-02f, -4.73960163e-03f, -3.48933898e-02f, -3.94918136e-02f, 7.94601452e-04f, -1.78819984e-01f, 1.63791310e-02f, 7.58260023e-03f,
  -3.75896469e-02f, 9.58110765e-02f, 5.91754075e-03f, 7.72041306e-02f, 1.03857137e-01f, -3.60252298e-02f, 5.45735061e-02f, 1.44873969e-02f, 2.80992538e-02f, 2.69039534e-03f,
  2.76534073e-02f, 4.45244312e-02f, 6.93289638e-02f, -3.20016593e-02f, 7.56371692e-02f, 2.36905590e-02f, -2.19871700e-02f, -3.94125246e-02f, -7.54849426e-03f, -9.32505429e-02f,
  -9.68452618e-02f, -3.32635595e-03f, -5.31835072e-02f, -1.01187900e-02f, -4.73309420e-02f, -3.31710503e-02f, 5.49533106e-02f, -7.83257335e-02f, -1.63828712e-02f, -7.02628493e-02f,
  -1.71057507e-02f, -1.31468222e-01f, 2.40428317e-02f, 8.31285864e-02f, 3.56296934e-02f, 2.25358289e-02f, 4.45413850e-02f, -7.00415820e-02f, 7.97822922e-02f, 3.44030969e-02f,
  -2.01007351e-02f, 3.82036604e-02f, -4.41448502e-02f, 1.41415186e-02f, 2.06577554e-02f, -9.75665227e-02f, -4.51456010e-02f, -2.20946763e-02f, 1.50121665e-02f, -2.36492027e-02f,
  -6.81670979e-02f, -5.15257707e-03f, -2.78704669e-02f, 8.05684477e-02f, 4.09139059e-02f, -1.43553531e-02f, 6.95358291e-02f, -3.96023178e-03f, -9.49401930e-02f, -2.12019421e-02f,
  -2.43723631e-01f, -9.93790403e-02f, 1.39698356e-01f, -3.07017207e-01f, 8.29989314e-02f, -6.98488206e-02f, -1.53606713e-01f, -1.16989754e-01f, -2.00816408e-01f, -1.51156008e-01f,
  -5.05004041e-02f, 1.41527951e-02f, 2.69729108e-01f, -3.13078314e-01f, -2.05353610e-02f, 1.37019455e-01f, -3.60837668e-01f, -1.96786240e-01f, 9.34307575e-02f, -1.38479784e-01f,
  5.96209802e-02f, -2.15028927e-01f, 1.09516695e-01f, -9.37554054e-03f, -1.23234659e-01f, 9.62844677e-03f, 5.01865074e-02f, 1.52015835e-01f, -1.25540882e-01f, 8.63771066e-02f,
  -1.98682755e-01f, -1.37337744e-01f, 2.80198157e-02f, -3.34828272e-02f, -6.35233372e-02f, 6.88608959e-02f, 7.92197883e-02f, 8.29288140e-02f, 4.29324321e-02f, -4.67329659e-02f,
  2.13285591e-02f, -2.05058362e-02f, -1.06045585e-02f, 8.64485800e-02f, -3.76062803e-02f, -6.14123978e-02f, 2.11038571e-02f, 3.39730233e-02f, -8.51799920e-03f, 2.04284005e-02f,
  4.20233458e-02f, -1.06890853e-02f, -1.53846638e-02f, -5.59738884e-03f, 8.31177086e-02f, 4.66910563e-02f, 3.47457789e-02f, 3.82581130e-02f, -9.78261158e-02f, -8.73173103e-02f,
  4.17223712e-03f, 3.29014882e-02f, 2.62178686e-02f, -2.95512155e-02f, -4.68264595e-02f, -2.37335563e-02f, 1.46782352e-02f, -4.06826288e-02f, 6.06564339e-03f, -4.09009680e-02f,
  -1.05933741e-01f, -9.96689349e-02f, 2.47011688e-02f, 3.01108789e-02f, -2.22663525e-02f, -3.94686721e-02f, 4.59476970e-02f, 4.11266647e-02f, -2.00374611e-02f, -3.81669365e-02f,
  -6.24138787e-02f, 4.54512723e-02f, -6.14622869e-02f, -5.26483112e-04f, -2.55876803e-03f, 2.46957899e-03f, 4.59709913e-02f, 6.06025010e-02f, 9.00279954e-02f, 5.36722131e-02f,
  -1.80762902e-01f, -2.06029832e-01f, 2.77882647e-02f, -2.78101247e-02f, 1.54885519e-02f, 4.93551493e-02f, 9.64110345e-03f, 3.83747108e-02f, -4.95610666e-03f, -2.90047955e-02f,
  2.17108410e-02f, -6.06060326e-02f, 4.23843376e-02f, -1.02935262e-01f, -8.18410814e-02f, -5.47578782e-02f, 6.36368245e-02f, 3.28685306e-02f, -1.25469998e-01f, -5.17610647e-02f,
  -7.27764145e-02f, -4.49532568e-02f, 6.77733719e-02f, -5.82602210e-02f, -1.44080156e-02f, 5.24430200e-02f, -5.58921807e-02f, 1.30728213e-02f, 1.65473185e-02f, -6.35010675e-02f,
  -2.30739579e-01f, -4.92425002e-02f, 1.91262309e-02f, -5.65874437e-03f, -1.23186134e-01f, -2.79011637e-01f, -2.35892162e-01f, -1.40057638e-01f, -1.75543264e-01f, -7.45151043e-02f,
  5.68423271e-02f, -1.59398466e-01f, 1.15109958e-01f, 1.17515467e-01f, 6.34984151e-02f, 4.74242866e-02f, -9.92099792e-02f, -1.08544208e-01f, -2.31761858e-02f, -1.62918732e-01f,
  7.71216378e-02f, 1.92862958e-01f, 1.23705372e-01f, 3.32675651e-02f, -1.08911693e-01f, -5.96844926e-02f, 2.04730332e-01f, -1.29900035e-02f, -2.32961643e-02f, 4.77922894e-02f,
  7.39567950e-02f, -3.39698456e-02f, -2.22551823e-02f, 1.08885467e-01f, -1.38493450e-02f, -8.49852040e-02f, 1.16163962e-01f, 1.36339255e-02f, -3.51272582e-04f, -8.46863836e-02f,
  -1.10902272e-01f, 7.94738997e-03f, -1.74984131e-02f, 3.76222059e-02f, -1.69592425e-01f, -7.30261952e-02f, -1.89899225e-02f, -1.25267044e-01f, -8.50546211e-02f, -3.00683770e-02f,
  -2.86708977e-02f, -1.13008298e-01f, 2.66472772e-02f, 2.18236614e-02f, -3.57638821e-02f, -7.46246800e-02f, -1.28132086e-02f, -2.18493142e-03f, -1.43659338e-01f, -6.44495562e-02f,
  -8.65166858e-02f, 1.36890724e-01f, -1.30865788e-02f, 4.46076272e-03f, 4.50884849e-02f, 1.25022382e-01f, 5.25815599e-02f, 1.21011354e-01f, 1.33837089e-02f, 2.49100793e-02f,
  -2.37635076e-02f, -6.87007792e-03f, -4.05316316e-02f, -4.37023677e-03f, 4.58888784e-02f, -9.63077247e-02f, 5.97459869e-03f, 3.16989534e-02f, 1.05270185e-01f, 8.09635743e-02f,
  -1.53521392e-02f, -5.53425550e-02f, -3.77502777e-02f, 8.59143361e-02f, 9.84175131e-02f, 1.27781862e-02f, 5.59622161e-02f, -3.71750779e-02f, 1.91457034e-03f, 3.36659327e-02f,
  1.29267564e-02f, -1.08983502e-01f, 8.73262659e-02f, 1.19779492e-02f, 1.22244485e-01f, -8.27996582e-02f, 1.03968017e-01f, 5.81239946e-02f, -1.78909853e-01f, -2.13220492e-01f,
  -1.37490928e-01f, 6.14627004e-02f, -8.38157907e-02f, 5.56419306e-02f, 9.00964346e-03f, 9.19137597e-02f, -4.21762317e-02f, -4.28149328e-02f, -8.34449977e-02f, -2.76261475e-02f,
  -1.84414294e-02f, -9.01205391e-02f, -8.31911527e-03f, -1.11480117e-01f, -1.64923742e-02f, 6.55922201e-03f, -7.22304583e-02f, -3.17874514e-02f, 7.04185739e-02f, -2.47470755e-02f,
  1.82541192e-01f, -9.47315171e-02f, -1.19050115e-01f, 5.00102192e-02f, 6.85982034e-02f, -1.72730237e-01f, -9.51981172e-02f, -2.27684677e-02f, 3.49260867e-01f, 5.08461660e-03f,
  2.77414434e-02f, 1.17395930e-01f, -2.80431584e-02f, 8.07479620e-02f, 2.40244836e-01f, 1.51211709e-01f, 8.22314322e-02f, 1.93031766e-02f, -3.64901274e-02f, 2.65637450e-02f,
  8.21965262e-02f, 2.10300222e-01f, -1.97817042e-01f, -1.03533976e-01f, -1.07572801e-01f, -2.10196123e-01f, -1.62716225e-01f, -4.96337339e-02f, -4.69463468e-02f, -2.02332977e-02f,
  -3.85311358e-02f, 6.07564896e-02f, -5.43863960e-02f, 7.62529150e-02f, -8.38456452e-02f, -6.43416792e-02f, -2.50897108e-04f, 9.44845006e-02f, 2.22502783e-01f, 5.74203320e-02f,
  8.10851157e-02f, 1.98703229e-01f, 2.51268242e-02f, 1.38895348e-01f, 2.96894647e-02f, 5.80708273e-02f, 8.31175894e-02f, -1.07919969e-01f, 2.47918218e-02f, 4.47554216e-02f,
  -4.75330688e-02f, -2.18742844e-02f, -4.24744301e-02f, 1.61636341e-02f, 5.07774130e-02f, 9.92073864e-02f, 2.21580267e-02f, -1.01208128e-01f, 3.95743549e-02f, 1.34292528e-01f,
  1.78144753e-01f, 1.01533264e-01f, -7.94182643e-02f, -2.46378947e-02f, -6.84218854e-02f, -1.23324782e-01f, 6.70291707e-02f, -1.18381672e-01f, -9.99919698e-02f, -6.81051984e-03f,
  -1.22855179e-01f, 8.07243120e-03f, 2.32746676e-02f, 2.08864827e-02f, 6.09750189e-02f, 3.34259146e-03f, -2.62995251e-02f, -7.16876164e-02f, -1.16053917e-01f, -1.28891677e-01f,
  1.39757708e-01f, -2.61921156e-02f, 6.55237883e-02f, -1.85292438e-02f, -5.56568764e-02f, 1.33948877e-01f, 7.30905607e-02f, 9.13263410e-02f, -5.72914146e-02f, -7.99695402e-02f,
  6.96189851e-02f, 1.88655868e-01f, -4.50959094e-02f, 5.86977229e-02f, -1.01844572e-01f, 6.16697446e-02f, 5.59585243e-02f, 4.38800156e-02f, 1.78784624e-01f, 2.30269344e-03f,
  1.43425986e-01f, -1.42285256e-02f, -4.92940955e-02f, -8.87333602e-03f, 1.86633263e-02f, 3.20366211e-02f, 1.22415304e-01f, 5.17782457e-02f, 1.60290506e-02f, -4.63628583e-02f,
  -5.11044897e-02f, 1.58108771e-01f, 7.25315511e-02f, 1.56835802e-02f, 3.99372466e-02f, -2.95868795e-03f, 2.06475481e-02f, 5.59399929e-03f, 4.27897461e-02f, 2.41829921e-02f,
  2.08808646e-01f, -4.82345745e-02f, 3.61526646e-02f, 3.97684753e-01f, 8.17281306e-02f, 3.56432378e-01f, 4.68005627e-01f, 2.44758278e-02f, 2.14528710e-01f, 8.16520005e-02f,
  2.89775997e-01f, 1.58439241e-02f, -3.60080451e-02f, 4.02729779e-01f, 2.13285729e-01f, 7.87692070e-02f, 4.03220177e-01f, 2.86615282e-01f, 1.63956787e-02f, 1.92227568e-02f,
  -1.66629907e-02f, 1.89936489e-01f, 1.10040843e-01f, -2.13255242e-01f, 1.44295558e-01f, -2.01383859e-01f, -6.01023212e-02f, -1.44800127e-01f, 1.38982296e-01f, 3.84451263e-02f,
  6.46213368e-02f, -4.34022881e-02f, -1.75803043e-02f, -1.18506335e-01f, 5.49030341e-02f, -3.41681875e-02f, 1.55535713e-02f, -4.95054154e-03f, 2.86436025e-02f, 4.77360040e-02f,
  5.57337739e-02f, -3.46317850e-02f, 6.53969422e-02f, 1.26359267e-02f, -1.90457441e-02f, -1.33328056e-02f, 9.26650465e-02f, 8.96173045e-02f, 1.95532646e-02f, 4.84439470e-02f,
  1.24775127e-01f, 4.71993871e-02f, 8.78133923e-02f, 6.34739771e-02f, 4.73478884e-02f, 5.15190512e-02f, 3.10605112e-02f, 7.06197843e-02f, 9.10824239e-02f, 5.40753081e-02f,
  -5.39886253e-03f, -1.53672174e-01f, -1.00141831e-01f, -1.31421104e-01f, -3.58623676e-02f, -9.19192061e-02f, -1.84515081e-02f, -7.36252740e-02f, -1.80080608e-02f, -1.32895727e-02f,
  4.59091598e-03f, -2.56313500e-03f, -3.21940403e-03f, 3.65000740e-02f, 6.51398301e-02f, -4.36996780e-02f, -5.34394532e-02f, 7.18960911e-02f, 1.84638612e-02f, 6.85626715e-02f,
  -5.44297062e-02f, -6.18561655e-02f, -6.60775080e-02f, -6.70372844e-02f, -2.85631209e-03f, 2.05135625e-03f, -1.79278273e-02f, -1.96829420e-02f, 7.11080292e-03f, 1.08838491e-01f,
  -4.08678353e-02f, -1.37348279e-01f, -2.31551914e-03f, -9.70909968e-02f, -3.25896144e-02f, 5.96505441e-02f, -5.14535457e-02f, 1.78406686e-02f, -3.55037302e-02f, 3.71598639e-02f,
  4.62342389e-02f, -5.74299227e-03f, -7.38171041e-02f, -5.23008332e-02f, 1.60588231e-02f, 1.46451686e-02f, 1.45151699e-02f, 7.77696222e-02f, 2.38132700e-02f, -3.73126902e-02f,
  3.88359814e-03f, 1.24215093e-02f, 7.97320008e-02f, 2.42136344e-02f, 1.15652420e-01f, 3.26457364e-03f, -1.97588513e-03f, 1.25400070e-03f, 1.41421966e-02f, 4.88768034e-02f,
  -3.70515019e-01f, 2.61156142e-01f, 6.00191541e-02f, -1.38392642e-01f, -2.87657771e-02f, -3.21967691e-01f, -3.05481523e-01f, 1.40511513e-01f, 1.75496981e-01f, 1.70709208e-01f,
  2.18386832e-03f, -6.63094297e-02f, 1.01117775e-01f, -2.29702801e-01f, -1.94330856e-01f, 1.20469846e-01f, -3.14542860e-01f, -1.92884609e-01f, 1.84175164e-01f, 5.18044718e-02f,
  -3.06275878e-02f, -1.66091815e-01f, -1.14308409e-02f, 1.84871063e-01f, -2.19304204e-01f, 7.67628029e-02f, 2.90982779e-02f, 1.66142330e-01f, -1.19607694e-01f, -1.70021877e-01f,
  -1.31643504e-01f, 8.86560753e-02f, 2.40615122e-02f, -3.16854194e-02f, -3.99770550e-02f, -8.50410610e-02f, -2.11381271e-01f, -1.11167803e-01f, 2.17211340e-02f, -1.41464490e-02f,
  -8.18191469e-02f, -1.29769608e-01f, -6.50059283e-02f, -5.76835172e-03f, -1.01882085e-01f, 5.68504147e-02f, -1.55672831e-02f, -4.87781540e-02f, 2.95056254e-02f, -6.89153597e-02f,
  2.70714629e-02f, 1.76861417e-02f, -5.53504899e-02f, -6.66364804e-02f, -8.55484307e-02f, 4.82345521e-02f, -7.54205231e-03f, -7.41204992e-02f, -6.01546317e-02f, 4.83972440e-03f,
  -1.05356976e-01f, 1.33305848e-01f, 2.52346862e-02f, 1.07609890e-01f, 8.32973048e-02f, 2.23059524e-02f, 4.99547757e-02f, 6.34959042e-02f, 5.99929430e-02f, 9.26827565e-02f,
  1.33143410e-01f, 4.39442210e-02f, 2.79194452e-02f, -4.96743359e-02f, -4.00922112e-02f, 6.20057918e-02f, 3.27997538e-03f, -5.82564436e-02f, -5.91268688e-02f, -1.67754851e-02f,
  1.14650339e-01f, -3.90616581e-02f, 9.52427462e-02f, -9.64821726e-02f, 1.29901832e-02f, 2.20581535e-02f, 3.25782807e-04f, 1.71540398e-02f, 5.21861501e-02f, -1.68183640e-01f,
  7.54939094e-02f, 1.89705849e-01f, 5.04115298e-02f, -4.89759073e-03f, 6.65373132e-02f, 3.82762142e-02f, -5.54302335e-02f, -1.22793704e-01f, -1.73815954e-02f, -3.52639109e-02f,
  -1.64158106e-01f, -6.84107020e-02f, 5.74799627e-02f, -1.62830174e-01f, -5.26406020e-02f, 2.97666844e-02f, 1.79177616e-02f, -8.23380705e-03f, -4.84103002e-02f, 6.75631166e-02f,
  -1.02405576e-02f, -2.63320617e-02f, -2.93568857e-02f, -1.41729275e-02f, -1.11165628e-01f, -7.93351140e-03f, 2.59559229e-02f, -3.23210889e-03f, -1.02047965e-01f, 5.68444841e-02f,
  4.02744040e-02f, -2.33705461e-01f, 2.59669542e-01f, 2.07839027e-01f, -1.49582162e-01f, 2.99116801e-02f, 8.82062837e-02f, -5.76769821e-02f, 1.09219074e-01f, -3.11414093e-01f,
  -2.11317495e-01f, 1.20195419e-01f, -1.09538384e-01f, -1.46967262e-01f, 3.15678000e-01f, 1.01081699e-01f, -1.17469747e-02f, -7.24249333e-02f, 2.05881193e-01f, -1.19058546e-02f,
  6.47912472e-02f, -1.45978972e-01f, 2.78489560e-01f, -9.36541334e-02f, -1.84997797e-01f, 1.35836862e-02f, -1.85955822e-01f, 9.39500332e-02f, -2.25173850e-02f, -8.12265500e-02f,
  -1.34915411e-01f, -6.36836700e-03f, 1.04693975e-02f, 4.59585339e-02f, -7.83698186e-02f, 2.26753242e-02f, 5.60312755e-02f, 3.45790200e-02f, 1.72438815e-01f, 6.91363066e-02f,
  -8.12809169e-03f, -7.09566697e-02f, 3.59600261e-02f, 5.42783402e-02f, -3.11260074e-02f, 1.90471821e-02f, 6.53753504e-02f, 6.19664490e-02f, 1.67592559e-02f, 9.47985724e-02f,
  4.29890715e-02f, 3.47677544e-02f, -2.10286900e-02f, -6.04237802e-02f, 1.00260071e-01f, -3.49882082e-03f, 1.43641859e-01f, -4.78240009e-03f, -4.91197361e-03f, 3.85092571e-03f,
  -3.66109833e-02f, 7.52656236e-02f, 8.40803385e-02f, 3.71592417e-02f, 3.10421046e-02f, -3.89439166e-02f, -1.79295298e-02f, -5.35764433e-02f, -4.11702543e-02f, -5.24102412e-02f,
  -1.71421953e-02f, 6.10983372e-02f, 7.25595979e-03f, -4.22151126e-02f, 1.45504931e-02f, 4.94424328e-02f, 4.95809726e-02f, -7.27778301e-02f, -3.39978375e-02f, -6.99072108e-02f,
  5.47329187e-02f, 1.43202608e-02f, -1.05229184e-01f, -5.61026335e-02f, -6.60808757e-02f, 8.02556351e-02f, 2.80071888e-02f, -7.23863440e-03f, 5.00949770e-02f, 2.34664120e-02f,
  -2.03784645e-01f, -6.33936226e-02f, -1.39674284e-02f, -1.42058611e-01f, -4.34610136e-02f, 6.10092841e-02f, -1.29275385e-03f, -4.27377820e-02f, 8.61053094e-02f, -4.36423942e-02f,
  3.19649950e-02f, -9.23317298e-02f, 6.11159727e-02f, -7.51805007e-02f, 6.60665631e-02f, -1.47995697e-02f, 4.87277955e-02f, -2.10340675e-02f, 5.47907036e-03f, -8.24046060e-02f,
  8.24366789e-03f, -8.45194049e-03f, -4.02707495e-02f, 1.03232086e-01f, -1.53698847e-02f, -9.44444463e-02f, -1.92256384e-02f, 7.37914294e-02f, -1.05750240e-01f, 2.39222106e-02f,
  -2.26181313e-01f, 2.40481362e-01f, -2.42348820e-01f, -2.28874579e-01f, 9.40366648e-03f, 3.26458388e-03f, -2.15451464e-01f, 3.59077789e-02f, -7.47755468e-02f, 2.08799243e-01f,
  3.63695584e-02f, 4.99131233e-02f, 2.14518547e-01f, 3.56414635e-03f, -1.27008870e-01f, 9.66010839e-02f, 5.62493131e-03f, -2.84639448e-02f, -5.34819514e-02f, 8.73227566e-02f,
  -8.17081481e-02f, 1.90692544e-01f, -2.18904078e-01f, 1.45245448e-01f, -3.29418033e-02f, -1.89861059e-01f, 9.95464250e-02f, -6.88735992e-02f, -6.66588172e-03f, 7.75809679e-03f,
  1.09714761e-01f, 6.74145594e-02f, -1.03578828e-01f, 8.80492032e-02f, -5.71652874e-02f, -3.50869149e-02f, -2.98236366e-02f, -4.78774346e-02f, -3.96889597e-02f, -4.57074605e-02f,
  2.82286312e-02f, 1.12052619e-01f, -6.22087084e-02f, -1.66099258e-02f, -6.93419250e-03f, 2.30858866e-02f, -1.87795442e-02f, -1.04286984e-01f, 2.94355340e-02f, -2.56901253e-02f,
  -1.52110055e-01f, -3.03901564e-02f, -9.68233868e-02f, 1.70305446e-02f, -7.36393183e-02f, -2.84593459e-02f, -5.55984788e-02f, -1.50745902e-02f, 4.25842591e-03f, 4.50491793e-02f,
  -5.76474555e-02f, 8.11305456e-03f, -1.94417480e-02f, 1.55210551e-02f, 3.70314382e-02f, -2.91238390e-02f, 4.98270951e-02f, 8.22365284e-02f, -7.63132945e-02f, 1.52009949e-01f,
  8.89533851e-03f, 9.30153951e-03f, -4.23742794e-02f, -1.39250318e-02f, 5.47350422e-02f, -1.92541424e-02f, 2.37847604e-02f, 6.24600053e-02f, -4.04603109e-02f, -1.13084786e-01f,
  6.76305741e-02f, -8.95638205e-03f, 8.38423744e-02f, 8.39296132e-02f, -5.03352061e-02f, 4.26693931e-02f, 2.09236555e-02f, 3.78834717e-02f, -7.47876316e-02f, -5.27769364e-02f,
  2.44674310e-01f, 2.71888554e-01f, -1.46230329e-02f, 7.69565701e-02f, 5.61859123e-02f, -1.81604419e-02f, 8.98810625e-02f, -8.39857236e-02f, 9.42190811e-02f, 5.68204597e-02f,
  6.18438870e-02f, -2.32019741e-02f, 4.62324955e-02f, -1.32570434e-02f, 1.98473316e-02f, -1.31899146e-02f, 1.92208719e-02f, -3.54041369e-03f, 5.85039482e-02f, 6.97162598e-02f,
  3.62238437e-02f, 4.12667589e-03f, -9.73421112e-02f, -1.92557983e-02f, 8.88264645e-03f, 8.49077664e-03f, 2.58566979e-02f, -8.56024399e-02f, 1.89168043e-02f, 3.63612175e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.03804633e-01f, -2.87259370e-01f, -4.75669540e-02f, -2.06422620e-02f, 7.12538660e-02f, -1.39666945e-01f, 5.73809147e-02f, -2.98487991e-01f, -2.20834479e-01f, -1.24963269e-01f,
  -9.19203684e-02f, 1.91038430e-01f, 1.13308705e-01f, -2.72513568e-01f, 1.54049128e-01f, -6.07749932e-02f, -2.29078710e-01f, -1.75862033e-02f, -8.20610076e-02f, -1.70074496e-03f,
  -7.83118233e-02f, -3.65749121e-01f, -9.60220583e-03f, -3.59553844e-01f, -1.57411844e-01f, 2.14957707e-02f, 1.99977472e-01f, 1.56369388e-01f, 4.33135703e-02f, -5.61214164e-02f,
  -1.53993621e-01f, -4.76201139e-02f, 2.29586065e-02f, -1.15692019e-01f, 3.73206288e-02f, 8.01742822e-02f, 6.18014522e-02f, 3.27776298e-02f, 5.23828231e-02f, 2.00665109e-02f,
  7.92249218e-02f, 7.20611960e-02f, -5.03341705e-02f, 7.32034892e-02f, -1.33440226e-01f, -9.75437742e-03f, -4.15073126e-04f, 3.02584115e-02f, -5.23893768e-03f, 1.59029067e-01f,
  8.52743611e-02f, 3.91974598e-02f, -4.87159193e-02f, -1.54123763e-02f, 5.67338467e-02f, -9.95525252e-03f, 1.31518230e-01f, 1.77236512e-01f, 6.30119219e-02f, 5.28998906e-03f,
  -3.26807760e-02f, 5.37891500e-02f, -1.82418562e-02f, -1.30666345e-01f, -1.25591280e-02f, -6.45686537e-02f, -1.25110587e-02f, -3.21220383e-02f, -1.48035968e-02f, 5.65238856e-02f,
  3.41217406e-02f, 1.05984919e-02f, -1.34817153e-01f, 5.63929416e-02f, 1.56331174e-02f, 6.47895038e-02f, 9.72509384e-02f, -1.52474958e-02f, -3.29564326e-02f, -9.05223787e-02f,
  9.83426645e-02f, -5.91822714e-02f, -1.57164957e-03f, 1.02900499e-02f, -1.43036753e-01f, 1.26901746e-01f, -5.04833683e-02f, 4.24103625e-02f, -6.65925220e-02f, -7.21927062e-02f,
  -7.24681281e-03f, -1.31543074e-02f, -2.64231302e-02f, -1.45381549e-02f, -1.15412287e-02f, 3.39285731e-02f, -1.48519263e-01f, -1.64792225e-01f, 7.72329941e-02f, -9.75806639e-02f,
  4.97038513e-02f, 7.71453679e-02f, 7.30312765e-02f, -5.66817857e-02f, 1.01493169e-02f, -1.14979576e-02f, 4.11477610e-02f, 8.36407170e-02f, 9.26933140e-02f, 4.03959267e-02f,
  9.91585031e-02f, 1.13408417e-01f, -1.80445239e-03f, 3.48561853e-02f, 1.28494175e-02f, 1.30043462e-01f, 5.41575924e-02f, 3.90723571e-02f, 7.45854601e-02f, 1.04893759e-01f,
  -3.15733105e-01f, -2.59623468e-01f, 3.18779141e-01f, -1.83712885e-01f, 2.25351900e-01f, 2.21228778e-01f, 1.78671390e-01f, -1.06160067e-01f, -1.21996529e-01f, -2.81252474e-01f,
  -1.70548603e-01f, -3.82631868e-02f, -1.58388764e-01f, -9.12483301e-05f, 4.31806505e-01f, 1.26852198e-02f, -2.45248284e-02f, -5.85659072e-02f, 9.71373171e-02f, -6.67730579e-03f,
  1.47531582e-02f, -2.57101730e-02f, 1.65652752e-01f, 6.99798986e-02f, -1.06966877e-02f, 1.81993674e-02f, -6.72227517e-03f, 3.44820529e-01f, 9.78012383e-02f, 2.05763221e-01f,
  -1.12925172e-01f, -1.10275522e-01f, -6.24564588e-02f, 4.94702607e-02f, -7.30603114e-02f, -3.33927455e-04f, 6.00370429e-02f, 1.40273824e-01f, 7.86610544e-02f, -1.71909891e-02f,
  -3.39657702e-02f, 1.17164202e-01f, -1.65428431e-03f, 5.13444617e-02f, 1.87151060e-02f, -5.09436056e-02f, -8.68952554e-03f, -8.67636651e-02f, -3.14554758e-02f, 2.85061765e-02f,
  6.96597807e-03f, -3.64137739e-02f, -1.09091222e-01f, 6.98831677e-02f, 7.77610838e-02f, -1.02274887e-01f, -2.91757621e-02f, 1.12592012e-01f, 1.36499675e-02f, -8.31452683e-02f,
  1.15897499e-01f, 7.85870105e-02f, 1.44632841e-02f, -2.57323384e-02f, -3.10811326e-02f, -9.24512297e-02f, 6.83499277e-02f, -2.10168790e-02f, 1.88483973e-03f, -7.20601827e-02f,
  -9.45254564e-02f, 1.98271852e-02f, 2.41972040e-02f, 6.83400929e-02f, -1.85882337e-02f, -1.33969411e-01f, -5.00848256e-02f, 4.76535968e-02f, -4.64618541e-02f, 3.32214497e-02f,
  -2.29251385e-02f, 9.23945531e-02f, -1.20163718e-02f, 3.12505849e-02f, 5.68604581e-02f, 4.56342436e-02f, -1.37142120e-02f, 2.96385325e-02f, -8.60770568e-02f, 4.06657159e-02f,
  -2.33005092e-01f, -1.25709787e-01f, -4.04401235e-02f, -1.35085687e-01f, 5.76813780e-02f, -5.46255372e-02f, 1.23029336e-01f, 2.86119822e-02f, -7.48081803e-02f, -2.15024762e-02f,
  -1.76820606e-02f, 9.62151773e-03f, -7.44969323e-02f, 1.25069141e-01f, 6.73595667e-02f, -4.21559066e-02f, 5.74604571e-02f, -1.10893212e-01f, -9.02330652e-02f, -5.62188067e-02f,
  -1.18879646e-01f, 1.41102271e-02f, -4.78288196e-02f, -6.05699196e-02f, 1.91819519e-02f, -1.61310155e-02f, -3.30648646e-02f, -2.26329472e-02f, 1.02940001e-01f, -4.21429127e-02f,
  -4.68336232e-02f, 1.75154805e-01f, 6.18305244e-03f, -5.62459743e-03f, 4.31131423e-02f, -6.42624199e-02f, -1.17236882e-01f, -3.22494023e-02f, -1.08844705e-01f, 1.43423885e-01f,
  -1.51742205e-01f, 1.83066875e-01f, -2.68288195e-01f, -4.92095612e-02f, -5.24347007e-01f, -4.25559670e-01f, -6.79432154e-02f, 4.44193333e-02f, -1.39605671e-01f, 8.33831280e-02f,
  -1.37578830e-01f, -1.90717652e-01f, -1.28202423e-01f, 9.46725011e-02f, 1.77993044e-01f, 2.89014399e-01f, 9.31616500e-02f, 1.42102808e-01f, 2.85958797e-01f, -2.76885275e-03f,
  -5.67722172e-02f, -7.59221092e-02f, 1.02136984e-01f, 1.17278565e-02f, -8.89673531e-02f, 5.78393266e-02f, 1.01943664e-01f, -2.98357215e-02f, -3.48897278e-02f, 4.24598083e-02f,
  5.69763817e-02f, 4.36769910e-02f, -3.08543425e-02f, -6.16562879e-03f, 4.77728173e-02f, 4.65958826e-02f, -1.69640537e-02f, 4.82579470e-02f, 5.11497185e-02f, 2.95411944e-02f,
  2.07212865e-02f, 8.39282349e-02f, 2.50861477e-02f, 6.84265094e-03f, 4.80436906e-02f, 1.92347225e-02f, 4.90516685e-02f, 9.70785096e-02f, 7.99293816e-02f, -2.24450021e-03f,
  3.69161442e-02f, 1.34043833e-02f, -4.29274887e-02f, -4.04112600e-02f, -4.25790250e-02f, -1.15713123e-02f, -5.06675392e-02f, 4.85529006e-02f, 2.73624137e-02f, 2.21834946e-02f,
  1.93925854e-02f, 5.28280735e-02f, -2.43372819e-03f, 6.70153052e-02f, -1.02711422e-02f, 9.34208371e-03f, -3.52883153e-02f, 2.39585731e-02f, -1.81587860e-02f, -2.48289276e-02f,
  2.67166421e-02f, -4.55907099e-02f, -2.84766071e-02f, 3.86372618e-02f, -1.45232588e-01f, -4.40927688e-03f, 4.87784334e-02f, -1.07184034e-02f, 1.94640495e-02f, -7.40165710e-02f,
  3.30359191e-02f, -3.36181596e-02f, -5.07707000e-02f, 7.07943961e-02f, -9.14976466e-03f, 3.06231156e-02f, -1.08788475e-01f, 4.61469181e-02f, -4.54696678e-02f, -4.58541997e-02f,
  4.55019996e-02f, 5.95560186e-02f, 7.48997256e-02f, -4.72617988e-03f, 2.52312347e-02f, -7.83112645e-02f, -1.56865343e-02f, 7.95669556e-02f, 7.88748637e-02f, 6.58991635e-02f,
  8.84717330e-02f, 6.90756366e-02f, 1.69492827e-03f, 2.64854394e-02f, 7.60960951e-02f, 5.10853678e-02f, 7.18407854e-02f, -4.33790013e-02f, -2.20671552e-03f, -1.78127810e-02f,
  6.65748492e-02f, 9.68295634e-02f, 1.15228876e-01f, 2.30680555e-01f, -2.11712405e-01f, -1.80956587e-01f, -2.12346271e-01f, -2.69614179e-02f, -1.11668140e-01f, -1.05650932e-01f,
  -7.85088763e-02f, 1.22638278e-01f, -2.11761579e-01f, 2.60307193e-01f, 4.50522751e-02f, -1.70012042e-01f, 2.51070231e-01f, 1.62072510e-01f, -5.38185351e-02f, 1.98997244e-01f,
  1.88883796e-01f, 1.88305289e-01f, 1.19471386e-01f, 6.52744845e-02f, 1.17158532e-01f, 1.81560650e-01f, 1.02650605e-01f, -7.88632333e-02f, 3.39617729e-01f, 6.93555772e-02f,
  1.71568803e-02f, -4.42489795e-03f, 8.20493922e-02f, 3.61702070e-02f, -5.85982902e-03f, 1.07543375e-02f, 7.33553022e-02f, -3.22072506e-02f, -7.42239431e-02f, 1.17433788e-02f,
  6.87783286e-02f, 1.02191910e-01f, 9.64924917e-02f, 2.64571123e-02f, 9.52456146e-02f, 1.04798503e-01f, 1.65944044e-02f, -4.85721640e-02f, 2.58249324e-02f, 1.50564089e-02f,
  3.76637541e-02f, 2.57610474e-02f, 7.79025555e-02f, 9.61068645e-02f, 3.07332650e-02f, 2.86303763e-03f, -3.47474851e-02f, 4.69007120e-02f, 1.30952939e-01f, 3.05347424e-02f,
  9.12338272e-02f, -1.05450034e-01f, -1.29950494e-01f, -4.17484716e-02f, -5.23124933e-02f, 1.13431942e-02f, -9.96228009e-02f, -4.53832261e-02f, -8.50427970e-02f, -7.44235367e-02f,
  -1.05933063e-02f, 9.13206767e-03f, -5.67631014e-02f, -5.83730638e-02f, 1.25836944e-02f, -3.51359509e-02f, -7.67470747e-02f, -3.19070220e-02f, 3.86471972e-02f, -7.10564256e-02f,
  -8.77600685e-02f, -3.92871201e-02f, -2.08069989e-03f, 6.14777468e-02f, -1.80492494e-02f, -3.82315554e-02f, -1.50542269e-02f, 5.78375682e-02f, -1.21553473e-01f, 2.05724165e-02f,
  1.03968769e-01f, 1.26639456e-01f, -4.39173356e-02f, 5.87548390e-02f, 7.13079199e-02f, 1.58488508e-02f, 6.57220483e-02f, 1.45406738e-01f, 3.80835347e-02f, -1.16858453e-01f,
  8.34973902e-02f, -1.60173532e-02f, 2.99898684e-02f, 4.98675220e-02f, 8.15039054e-02f, -2.82432623e-02f, -2.81910747e-02f, -1.80232357e-02f, 9.07128155e-02f, 1.47456586e-01f,
  9.52784419e-02f, -8.47162902e-02f, 1.14005111e-01f, -4.82049398e-02f, 1.05864882e-01f, 4.40709554e-02f, -3.57847884e-02f, 9.09164771e-02f, 2.23677028e-02f, 6.35411069e-02f,
  -6.13082290e-01f, 3.75086904e-01f, 5.36858775e-02f, -2.74483770e-01f, 1.44367158e-01f, 1.67597622e-01f, 1.86437480e-02f, 1.12954453e-01f, -3.66996750e-02f, 1.34502873e-01f,
  1.29763223e-02f, -1.43334255e-01f, 2.09832206e-01f, 6.55685216e-02f, -2.01537728e-01f, 1.62698105e-01f, -1.50484163e-02f, -8.03132728e-02f, 7.98900127e-02f, -8.15106481e-02f,
  -1.30235050e-02f, -8.81337374e-03f, 1.35838628e-01f, 1.80887803e-01f, 9.62701719e-03f, -8.68417397e-02f, -1.28524542e-01f, 9.42643732e-02f, -6.86083455e-03f, -3.48618180e-02f,
  -2.89221108e-02f, -1.98254302e-01f, 2.20087655e-02f, 1.74878049e-03f, -7.89658651e-02f, -6.31761849e-02f, -9.92442593e-02f, 4.92907763e-02f, 3.17920488e-03f, 6.48902580e-02f,
  -3.85129335e-03f, 8.05054754e-02f, -4.16809954e-02f, 1.10360794e-01f, -1.70174781e-02f, 3.48537341e-02f, 1.13683179e-01f, 6.21995926e-02f, 9.55136120e-02f, -6.55988092e-03f,
  1.15578264e-01f, 2.07305513e-02f, -7.35421106e-03f, -1.05762117e-01f, 4.37696166e-02f, -1.80432610e-02f, 3.40375938e-02f, -4.35657315e-02f, -1.29399588e-02f, -1.06292158e-01f,
  2.15197150e-02f, 2.44080257e-02f, 5.89520857e-02f, -2.03073416e-02f, 3.08542568e-02f, -2.52068583e-02f, 3.78874457e-03f, 8.07638653e-03f, -5.13528921e-02f, -2.86171865e-02f,
  -2.43864357e-02f, 4.21441719e-03f, 9.62620415e-03f, 5.71579970e-02f, -4.43593189e-02f, 5.58283366e-03f, 2.68293428e-03f, -2.58073248e-02f, -4.10363413e-02f, 5.77992387e-03f,
  3.65127437e-02f, 4.58526909e-02f, -1.06014602e-01f, 3.17339227e-02f, -4.14587837e-03f, -1.89713705e-02f, 2.32360456e-02f, 2.46857926e-02f, 3.81896086e-02f, -6.13172874e-02f,
  -1.71050996e-01f, -2.74358004e-01f, 5.97083382e-02f, 2.67871227e-02f, 2.19098525e-03f, 8.19058269e-02f, 1.15914822e-01f, -4.83721355e-03f, -9.18603092e-02f, 5.75156212e-02f,
  3.59633788e-02f, 5.12292311e-02f, -3.22757363e-02f, 2.36154553e-02f, 1.23680448e-02f, 5.34396321e-02f, -9.52406302e-02f, 9.38401092e-03f, -7.41490573e-02f, -5.14958762e-02f,
  3.44985276e-02f, -1.70338135e-02f, 2.21573766e-02f, 5.46391010e-02f, -2.79878303e-02f, -5.85651398e-02f, -9.95306671e-02f, 6.56884164e-02f, -7.73728266e-02f, 6.52597323e-02f,
  -9.03906003e-02f, 3.31662238e-01f, 1.79508150e-01f, -1.36748888e-02f, -5.04260473e-02f, -5.16581945e-02f, -2.18851455e-02f, 1.62634626e-02f, -1.43987849e-01f, 2.07081988e-01f,
  1.07867708e-02f, 3.36591005e-01f, 3.44113074e-03f, -3.40637639e-02f, -3.52018535e-01f, -2.01885074e-01f, -8.87174979e-02f, 1.72048789e-02f, -1.35849893e-01f, -4.75320481e-02f,
  -1.21943943e-01f, -2.90768683e-01f, -1.04112230e-01f, -1.12901680e-01f, 1.12798706e-01f, 1.19540051e-01f, -8.92446190e-02f, 1.19158238e-01f, 1.24325067e-01f, 2.99494453e-02f,
  -8.47955793e-02f, -2.95179412e-02f, 1.50156450e-02f, 2.77149696e-02f, -6.94871843e-02f, -8.59647430e-03f, 3.49170640e-02f, -3.42459185e-03f, -3.20261940e-02f, -2.81562493e-03f,
  2.39944346e-02f, -7.01063871e-02f, -2.29799259e-03f, -8.91069472e-02f, 3.63757163e-02f, 9.48506072e-02f, 7.15356097e-02f, 9.24827680e-02f, 3.68562005e-02f, 8.92140567e-02f,
  1.03392884e-01f, 9.73984078e-02f, 3.71361487e-02f, 2.30797343e-02f, -1.49420071e-02f, 1.90334618e-02f, -2.59947255e-02f, 6.40085265e-02f, 2.28003711e-02f, -1.62875708e-02f,
  -6.19055629e-02f, -4.29474935e-02f, -4.35901247e-03f, -2.40012053e-02f, -4.24849130e-02f, -1.51292095e-02f, 9.93585307e-03f, 6.72320947e-02f, 3.45389061e-02f, -1.42554119e-02f,
  -1.85946636e-02f, 5.02777621e-02f, -5.13981543e-02f, -8.73245113e-03f, -5.24371192e-02f, -2.12326180e-02f, -6.32562265e-02f, -3.00410967e-02f, 4.13488299e-02f, -2.53055375e-02f,
  1.51270460e-02f, 5.90143632e-03f, -4.95631136e-02f, 2.36285981e-02f, -1.51666105e-02f, -7.53042549e-02f, 8.59925225e-02f, -1.64212508e-03f, 1.87479630e-02f, -4.46691923e-02f,
  -1.74495906e-01f, -1.93383232e-01f, -7.99736455e-02f, -1.38248736e-03f, -3.02392058e-02f, 3.06279268e-02f, -6.07440509e-02f, -2.43503749e-02f, -2.41025127e-02f, -8.86459127e-02f,
  2.58249301e-03f, -2.95052752e-02f, -2.07796711e-02f, -1.10783234e-01f, -2.97741927e-02f, -3.31743434e-02f, 1.20118735e-02f, 2.22087614e-02f, 2.95394547e-02f, 1.05784290e-01f,
  9.14543942e-02f, 3.53481807e-02f, -1.51389763e-02f, -1.07391760e-01f, -1.11859515e-02f, 9.25406143e-02f, 1.78224146e-02f, 4.45105806e-02f, -6.47049118e-03f, 2.47841608e-02f,
  -1.00276105e-01f, -2.97133833e-01f, -7.53631368e-02f, 7.85466209e-02f, 1.15410939e-01f, -1.84442759e-01f, -2.14013726e-01f, 6.07279725e-02f, -1.09368436e-01f, -1.68227717e-01f,
  3.03292889e-02f, -1.84186921e-01f, -2.59814858e-01f, -2.84135312e-01f, 1.07665628e-01f, -3.34613204e-01f, -2.26527024e-02f, -1.99238285e-01f, 5.72817773e-03f, 2.83352695e-02f,
  1.04495972e-01f, -6.73805131e-03f, 1.86617270e-01f, 1.54187173e-01f, -3.71999480e-03f, 2.01586723e-01f, 3.36578071e-01f, 1.08576387e-01f, 2.01801702e-01f, 9.55350325e-03f,
  -1.51084930e-01f, -5.06155333e-03f, 6.70042336e-02f, -5.71713001e-02f, 1.87901035e-01f, 5.45507856e-02f, 9.90272406e-03f, 2.07599136e-03f, 9.34967548e-02f, 2.29872614e-02f,
  3.28279436e-02f, -2.92506162e-02f, -4.31291126e-02f, -2.65660193e-02f, -2.89746579e-02f, 6.28590509e-02f, 1.25158634e-02f, 2.63924096e-02f, -4.79509160e-02f, -5.34855425e-02f,
  -3.55222635e-02f, 2.46643368e-02f, -9.00180917e-03f, 1.46059170e-01f, -1.58855245e-02f, 2.16024686e-02f, 5.88089228e-02f, 7.51089901e-02f, -4.05756161e-02f, 8.23473856e-02f,
  3.80083695e-02f, -1.07328466e-03f, -1.04491271e-01f, -8.53983313e-02f, -8.27422887e-02f, 3.80151011e-02f, -5.03367409e-02f, -3.61913219e-02f, -9.17312354e-02f, 4.77127060e-02f,
  1.37770668e-01f, 1.42547742e-01f, -2.83852089e-02f, 3.47860577e-03f, 7.63754323e-02f, 1.00200027e-02f, 6.84466958e-02f, -1.59066588e-01f, 1.19411848e-01f, -1.24460697e-01f,
  7.19541591e-03f, -4.13056165e-02f, 8.62091780e-02f, 2.60086264e-02f, -9.88897681e-02f, 1.89737394e-01f, -7.79789872e-03f, 5.01147425e-03f, -3.15453298e-02f, -1.79361906e-02f,
  8.46671164e-02f, 1.46032497e-01f, 1.70613285e-02f, -8.43267888e-02f, -6.97661862e-02f, -5.96142188e-02f, -1.65987149e-01f, -1.13780834e-01f, 1.32990345e-01f, -7.39472918e-03f,
  1.89370826e-01f, 4.29837145e-02f, 9.21046585e-02f, -6.38568103e-02f, 1.06391609e-01f, 9.04369205e-02f, 6.11446984e-02f, 1.93346992e-01f, 1.99154690e-01f, 2.34451905e-01f,
  9.80093479e-02f, 4.87043113e-02f, -1.53994262e-02f, 8.64773616e-02f, 3.27253900e-02f, 9.62652266e-02f, 1.20510543e-02f, 5.66936694e-02f, -5.21634631e-02f, 1.82704199e-02f,
  -5.88728130e-01f, 2.51929816e-02f, 4.28415775e-01f, -3.86284858e-01f, 1.58074096e-01f, 4.48849052e-01f, 2.46671945e-01f, -1.35617061e-02f, -2.34263331e-01f, -3.94391753e-02f,
  8.26090500e-02f, -3.16430666e-02f, 2.53135562e-01f, -6.22899756e-02f, 3.98953259e-01f, 1.45063952e-01f, 8.52313999e-04f, -2.88626365e-03f, -4.36905622e-02f, -1.72914192e-01f,
  5.37410204e-04f, -9.28542018e-02f, 1.20504841e-01f, -1.52198657e-01f, 5.80842756e-02f, -2.53806055e-01f, -7.24477619e-02f, 2.13176131e-01f, -1.77729037e-02f, 1.51689053e-01f,
  -4.09981124e-02f, -2.83884346e-01f, -8.70367289e-02f, -4.82661603e-03f, 1.97795872e-02f, 1.63431596e-02f, 2.06412431e-02f, 6.18098415e-02f, -2.47773845e-02f, 2.59233266e-02f,
  2.00292598e-02f, 3.97920050e-02f, -6.96885213e-02f, 6.15596250e-02f, -1.47556886e-02f, 2.44816504e-02f, 1.06984384e-01f, 8.39262977e-02f, 3.59308571e-02f, 5.53828478e-02f,
  1.07075959e-01f, 6.41021281e-02f, 6.93265647e-02f, -5.31176031e-02f, 5.06269112e-02f, -1.56971738e-02f, -5.54582402e-02f, 9.52078477e-02f, 5.57586811e-02f, 3.51469629e-02f,
  -3.53548042e-02f, -9.44533013e-03f, -4.03554067e-02f, -5.68321086e-02f, -6.25400245e-02f, -5.28913504e-03f, 1.06598937e-03f, 9.21046175e-03f, 3.48974988e-02f, 3.31693999e-02f,
  -1.90241858e-02f, -1.06463498e-02f, -1.49437087e-02f, -2.98008937e-02f, -9.05145928e-02f, -9.99983475e-02f, -8.98283068e-03f, -1.85657144e-02f, 8.69443640e-02f, 4.74045277e-02f,
  -1.92967486e-02f, 5.77460043e-02f, 8.23439807e-02f, -3.33875157e-02f, 7.36999512e-02f, 1.47860393e-01f, -6.58347225e-03f, 1.96207892e-02f, -9.23818722e-02f, 1.62874743e-01f,
  -7.20078722e-02f, -1.69070885e-01f, -1.10866390e-01f, -5.37010394e-02f, -4.36706096e-02f, 1.10475197e-01f, -7.92169347e-02f, -3.27494107e-02f, 3.29257213e-02f, 1.41073531e-02f,
  -3.92682999e-02f, 2.13800650e-02f, 2.94012832e-03f, -6.44906387e-02f, 5.97110353e-02f, 3.78046855e-02f, -2.27982793e-02f, -3.06898840e-02f, -2.40008719e-03f, -3.15108672e-02f,
  -1.78084690e-02f, -8.43313783e-02f, 7.83244148e-02f, -9.45008323e-02f, -8.17785561e-02f, 2.19586156e-02f, -5.56649193e-02f, -2.10454427e-02f, 4.95585985e-02f, 7.37227574e-02f,
  -2.68640101e-01f, 2.18418241e-01f, -1.05191745e-01f, -2.78689951e-01f, -1.05360022e-03f, -1.00132897e-01f, -2.61916280e-01f, 6.86893612e-02f, 1.16108112e-01f, -3.87356360e-03f,
  -1.83772631e-02f, 5.06568700e-02f, 2.78909326e-01f, -2.01595977e-01f, 1.69386137e-02f, 1.31774530e-01f, -3.15783501e-01f, -2.00623795e-01f, 1.51323661e-01f, -2.34510645e-01f,
  -3.93886492e-02f, -1.15469597e-01f, -1.24575533e-01f, 8.22772682e-02f, -2.39395484e-01f, -7.42239729e-02f, -1.48392990e-01f, 1.14480875e-01f, -2.58918136e-01f, 2.64935791e-02f,
  8.04705825e-03f, 6.10464998e-02f, -3.16868387e-02f, 2.48802789e-02f, -1.00675002e-01f, -8.37802514e-02f, -8.99925083e-02f, 1.87900774e-02f, 3.54927406e-02f, 5.63244298e-02f,
  3.08783422e-03f, 7.99217522e-02f, -1.28588500e-02f, 1.25712559e-01f, 5.97081147e-03f, 3.86423543e-02f, -8.21833033e-03f, -1.29038513e-01f, 1.30205043e-02f, 3.25352512e-02f,
  2.05650572e-02f, -1.06107704e-02f, -6.66276589e-02f, -6.25123978e-02f, -1.11282682e-02f, -1.25569943e-02f, -8.39134455e-02f, -6.08370900e-02f, 3.17863305e-03f, -8.78525674e-02f,
  -2.59697847e-02f, -8.03359970e-02f, -4.78079170e-02f, 4.85011488e-02f, 1.63229294e-02f, 1.04089230e-02f, 1.24766096e-01f, -3.86067145e-02f, 3.71856131e-02f, -1.59452558e-02f,
  -6.66753575e-02f, -1.02188680e-02f, -3.64069594e-04f, -4.68680747e-02f, -9.28128883e-02f, -9.50155966e-03f, -6.90916553e-02f, 3.80398370e-02f, -5.20331077e-02f, -5.18367812e-03f,
  6.03862330e-02f, -2.79648714e-02f, 3.64499874e-02f, 2.37682667e-02f, 3.37764919e-02f, 1.79660274e-03f, 3.60071287e-02f, -4.48175669e-02f, 2.52406057e-02f, 1.18138893e-02f,
  -2.32168548e-02f, -1.32848352e-01f, 6.58225194e-02f, 1.08016692e-01f, 5.47459312e-02f, -1.03593376e-02f, 7.86389410e-03f, 1.79703608e-02f, -4.10814360e-02f, 8.19040835e-03f,
  -5.31392917e-02f, -7.50461146e-02f, -1.28237262e-01f, 3.03947888e-02f, 1.71975400e-02f, -3.50076333e-03f, -6.97499439e-02f, -5.11292033e-02f, -1.46080479e-01f, 6.24396577e-02f,
  2.35555749e-02f, 1.73691809e-02f, 1.07106805e-01f, -5.76555394e-02f, -6.61794022e-02f, -3.01305503e-02f, -3.21125463e-02f, 4.26051542e-02f, -5.05081639e-02f, -2.67369393e-03f,
  -2.81481892e-01f, 2.34483689e-01f, 2.59936541e-01f, -2.61484962e-02f, -5.55458739e-02f, 4.65302095e-02f, -1.52648706e-02f, 5.10200150e-02f, 4.15315703e-02f, -1.48977071e-01f,
  -6.49477541e-02f, -1.93268418e-01f, 5.67133017e-02f, -6.53074682e-02f, 7.42617846e-02f, 2.10097700e-01f, 1.87756903e-02f, -7.18351454e-02f, 1.83958441e-01f, -6.96612895e-02f,
  -8.67132843e-02f, -2.40475148e-01f, 1.55220926e-01f, -4.42689173e-02f, -1.09176449e-01f, 1.54967785e-01f, 1.57675482e-02f, 2.14655697e-01f, -2.07338389e-02f, 9.27576274e-02f,
  6.75855651e-02f, -8.36358033e-03f, 6.76486045e-02f, 2.00959474e-01f, 9.78929922e-02f, -1.30822942e-01f, -9.11730006e-02f, 1.27113640e-01f, 6.70391275e-03f, -2.28892080e-02f,
  -1.17853068e-01f, -8.66238698e-02f, 3.00072823e-02f, -4.03973237e-02f, -1.08098999e-01f, -3.41978297e-02f, 2.89378390e-02f, -1.12268506e-02f, 1.20108970e-01f, 3.32134888e-02f,
  4.17366205e-03f, 3.02051250e-02f, -4.15377468e-02f, 1.09308332e-01f, 1.28704846e-01f, 1.35313198e-01f, 5.54465242e-02f, 1.12692684e-01f, 4.38485220e-02f, 3.38541977e-02f,
  -6.46874830e-02f, 8.21539387e-02f, 5.08620590e-02f, 1.68058164e-02f, -7.16410503e-02f, 1.37223816e-03f, -1.30480498e-01f, -4.84971888e-02f, -5.40274009e-02f, 9.06177983e-03f,
  1.00640602e-01f, 3.67437489e-02f, -8.44803676e-02f, -1.59541711e-01f, -1.46229684e-01f, -5.56803159e-02f, 3.59450430e-02f, 4.21538204e-02f, -5.59450574e-02f, -1.70040540e-02f,
  -2.76076999e-02f, -8.81661922e-02f, 2.29692762e-03f, -6.03234880e-02f, -5.27191125e-02f, -7.54847229e-02f, -1.69608057e-01f, -1.33382566e-02f, 8.17620605e-02f, 4.66248058e-02f,
  2.51651138e-01f, 3.53928238e-01f, 1.50719300e-01f, 6.05313033e-02f, 1.01436183e-01f, -2.09978502e-02f, 5.03719300e-02f, 9.20536928e-04f, 1.17614903e-01f, 2.92808916e-02f,
  -1.03151791e-01f, -5.54222008e-03f, -1.06656656e-01f, -6.08172081e-02f, -5.50084598e-02f, 7.00246841e-02f, -3.97648513e-02f, 8.80459920e-02f, 1.40485153e-01f, 7.42652938e-02f,
  -3.09462640e-02f, -7.36157224e-02f, -3.06053404e-02f, -1.13700949e-01f, -4.42996584e-02f, 1.99544970e-02f, -4.06445637e-02f, 5.82603589e-02f, -3.55107441e-05f, 1.29577696e-01f,
  2.80869037e-01f, 1.97139367e-01f, -1.26630142e-01f, 6.01668544e-02f, 2.87423581e-02f, -3.59108299e-01f, -4.55246754e-02f, 5.27778314e-03f, 1.77646935e-01f, 9.12412778e-02f,
  -1.21409222e-01f, 1.91485107e-01f, 5.51152676e-02f, -1.45852119e-01f, -4.17578995e-01f, -1.49629593e-01f, -2.65502840e-01f, -8.67229253e-02f, 9.02571678e-02f, -8.14005509e-02f,
  -4.04910482e-02f, -5.56368865e-02f, -1.03412688e-01f, 8.29521716e-02f, 2.01808706e-01f, 1.82706773e-01f, -1.74983758e-02f, 2.17864066e-01f, -1.58344150e-01f, -3.82569395e-02f,
  -9.11296606e-02f, 8.66649449e-02f, 9.67260227e-02f, 6.88258633e-02f, -1.33095548e-01f, 1.42783727e-02f, 1.10689839e-02f, 2.48711109e-02f, -2.15351637e-02f, -1.76958684e-02f,
  1.21088468e-01f, 1.19911715e-01f, 6.07847124e-02f, -1.12132281e-02f, 1.67136192e-01f, 6.26935065e-02f, 1.60860550e-03f, 6.99377665e-03f, 1.38645709e-01f, 6.00781217e-02f,
  5.59414364e-02f, -8.88921246e-02f, -9.51028243e-03f, 8.64271149e-02f, 1.46381147e-02f, 3.38380784e-02f, -5.54876477e-02f, -4.35333699e-02f, -2.02692114e-02f, 3.76815349e-02f,
  1.09838329e-01f, -3.17483954e-02f, 5.02425879e-02f, 2.28040349e-02f, -1.75780222e-01f, -2.91977283e-02f, 4.78447527e-02f, -7.19965100e-02f, -2.37733945e-02f, 8.58814223e-04f,
  -8.51128027e-02f, 1.40049219e-01f, 9.39407498e-02f, -9.40287858e-02f, 3.86287831e-02f, 1.11683995e-01f, -1.40835065e-02f, -2.46546790e-02f, 1.90666169e-02f, -6.54509366e-02f,
  1.24544851e-01f, -1.56581607e-02f, -3.23325470e-02f, 7.34367967e-02f, -5.48275281e-03f, 5.29443845e-02f, 4.04822230e-02f, -1.11687267e-02f, -7.55443424e-02f, -7.73682594e-02f,
  -1.79995611e-01f, -2.78820783e-01f, 3.01807430e-02f, -2.00540740e-02f, -1.06740184e-01f, -3.00470162e-02f, -3.01131848e-02f, -1.55333336e-02f, 1.89245325e-02f, -9.27468091e-02f,
  1.55799659e-02f, -1.92253832e-02f, -1.06351875e-01f, 2.05400810e-02f, 9.17061940e-02f, -4.98219728e-02f, 8.80470052e-02f, 2.75060423e-02f, 1.87531244e-02f, -1.30005842e-02f,
  1.11279916e-03f, 2.46253591e-02f, 2.25239769e-02f, 1.36932293e-02f, -2.30559520e-03f, 3.69626135e-02f, -1.11058950e-01f, 5.59581704e-02f, 2.91103907e-02f, 3.32536437e-02f,
  -5.98387159e-02f, 4.79621708e-01f, 3.30053300e-01f, -7.56758898e-02f, 1.64342090e-01f, 4.35263515e-01f, -6.25536889e-02f, 2.26279005e-01f, 2.61542976e-01f, 1.45751223e-01f,
  -1.82561517e-01f, 1.50287375e-01f, -1.62234142e-01f, 1.35213211e-01f, -4.44038659e-02f, 4.66254689e-02f, 8.68043900e-02f, -5.06073534e-02f, -1.22875705e-01f, -1.56102069e-02f,
  -1.20329134e-01f, -1.41592026e-01f, -1.44418985e-01f, -9.12266970e-02f, -9.45951696e-03f, -4.46458608e-02f, -1.99584916e-01f, -1.28273174e-01f, 1.33489855e-02f, 5.27817570e-02f,
  1.39759481e-02f, -4.09601778e-02f, 4.55643609e-03f, 5.07370979e-02f, 6.64706081e-02f, 4.49633598e-02f, 8.17271620e-02f, 5.96385971e-02f, -1.16090946e-01f, 1.30610585e-01f,
  2.17938167e-03f, 9.92390364e-02f, 5.28143384e-02f, 5.44401817e-02f, -1.08589744e-02f, 1.03163414e-01f, 8.44757631e-02f, 8.28466043e-02f, 5.32256030e-02f, 1.23838380e-01f,
  6.20817542e-02f, 1.34503990e-01f, 8.57820660e-02f, 6.54922873e-02f, 7.36102238e-02f, 8.21036473e-02f, 1.55158117e-01f, 5.94649725e-02f, 9.89221409e-02f, 1.48671031e-01f,
  2.13213228e-02f, 1.02311708e-01f, 4.38310690e-02f, 2.99038668e-03f, 9.40867737e-02f, 3.49195786e-02f, -4.13858704e-02f, -1.40590570e-03f, -2.62046270e-02f, 4.99715237e-03f,
  -1.06889963e-01f, -2.15950590e-02f, -1.62876137e-02f, 5.36496527e-02f, 2.31693393e-05f, -5.75339375e-03f, -3.13386507e-02f, -3.10538430e-02f, 8.02486110e-03f, -1.09701775e-01f,
  -2.82685488e-01f, -7.55718648e-02f, -1.28189698e-01f, -2.58902349e-02f, -2.19940506e-02f, -2.87943389e-02f, 7.57283904e-03f, 2.03679986e-02f, -4.59121764e-02f, -7.99311325e-02f,
  1.85487583e-01f, 2.24267676e-01f, -5.82598746e-02f, 2.25049835e-02f, -2.46715527e-02f, -7.33572990e-03f, -5.05141122e-03f, 1.58303708e-01f, 7.46427625e-02f, 9.62982997e-02f,
  3.88788469e-02f, -1.92588605e-02f, 1.01529457e-01f, -1.00331262e-01f, 3.95396575e-02f, 1.75362676e-01f, -1.92246847e-02f, -2.98373345e-02f, 2.94118486e-02f, -6.54132813e-02f,
  3.89491655e-02f, 2.76445737e-03f, -2.14712750e-02f, 5.15564196e-02f, 4.83778752e-02f, 3.14938091e-02f, 6.33085817e-02f, 2.12691575e-02f, 2.99165547e-02f, 4.41160388e-02f,
  1.40456572e-01f, 1.26099095e-01f, 3.16623867e-01f, 4.95681882e-01f, 1.69435650e-01f, -4.93362635e-01f, -1.86977327e-01f, 2.96344846e-01f, 2.76072204e-01f, -9.47785005e-02f,
  4.72372063e-02f, -2.13279873e-01f, 5.13120368e-02f, 1.91472128e-01f, -3.60241264e-01f, -2.34940369e-02f, -9.36794356e-02f, -8.26792270e-02f, 1.73951574e-02f, 7.93715492e-02f,
  7.08743259e-02f, 1.35623336e-01f, 1.54901311e-01f, 1.10403866e-01f, 2.71456152e-01f, 2.43975729e-01f, 3.53398249e-02f, 1.40159074e-02f, 5.07903844e-02f, -3.40297580e-01f,
  -1.21095315e-01f, 3.39613199e-01f, 8.24315920e-02f, -1.23761054e-02f, -1.42643498e-02f, -2.36374959e-01f, -7.82681182e-02f, -5.97397164e-02f, 4.88316156e-02f, 6.82257563e-02f,
  1.01728865e-03f, 8.10415670e-02f, -8.75155479e-02f, 5.60643859e-02f, -3.72337773e-02f, 1.31354958e-01f, 1.04914092e-01f, 4.93642911e-02f, 1.70181468e-01f, 3.22593488e-02f,
  1.24167241e-01f, -1.30681507e-02f, -9.76160318e-02f, -1.01170428e-01f, 1.12443000e-01f, 6.80356845e-03f, -1.16536997e-01f, -8.73141140e-02f, 3.32082366e-03f, -2.83330362e-02f,
  1.27936393e-01f, -8.85543004e-02f, 2.00780444e-02f, 1.89013500e-02f, 1.15422077e-01f, 1.01436444e-01f, 2.24173125e-02f, -9.59703550e-02f, -3.62687260e-02f, -8.31246302e-02f,
  -2.32123863e-02f, -2.63337009e-02f, 2.57584220e-03f, 1.21545769e-01f, -1.07676722e-03f, 7.18641207e-02f, -1.84112880e-02f, -4.16823523e-03f, 2.93853506e-02f, 1.02758437e-01f,
  6.17114231e-02f, -1.92978457e-02f, 4.70868312e-03f, -7.56485909e-02f, -6.99134842e-02f, 7.69373402e-02f, 1.32433206e-01f, 6.72673807e-02f, -2.31645419e-03f, -9.17493626e-02f,
  -2.98083723e-01f, 4.11665700e-02f, -6.36358783e-02f, -2.14692466e-02f, -2.90616620e-02f, -1.43920407e-01f, 3.66180018e-02f, 2.30903123e-02f, -7.49860555e-02f, 3.60428728e-02f,
  -2.83409040e-02f, 6.57718852e-02f, -8.75547379e-02f, 3.38463895e-02f, -8.15510079e-02f, 1.95090156e-02f, 2.10459791e-02f, -1.08130403e-01f, -6.01351187e-02f, -2.37760004e-02f,
  1.04541138e-01f, 3.52241797e-03f, -8.72831941e-02f, 6.09269850e-02f, -1.56333447e-01f, -3.87728028e-02f, 1.92231257e-02f, -5.53237181e-03f, 4.05997671e-02f, -3.13158557e-02f,
  3.52576673e-01f, 1.67675301e-01f, 6.41872585e-02f, -5.48029803e-02f, -1.47137776e-01f, -1.14539139e-01f, -1.44980028e-01f, -2.68933014e-03f, -4.39161621e-02f, -2.55263671e-02f,
  -1.04117967e-01f, -1.54421329e-02f, 5.57831414e-02f, 1.98284149e-01f, 2.52188686e-02f, 1.20857865e-01f, 5.14592975e-04f, 4.96376269e-02f, 1.36908844e-01f, 1.28764406e-01f,
  1.18915968e-01f, 1.44947320e-03f, 1.93655774e-01f, 1.32292673e-01f, 3.23861629e-01f, 6.77341148e-02f, 1.61895808e-02f, -6.19559698e-02f, -6.23893961e-02f, -1.64684784e-02f,
  1.51076272e-01f, 9.22791213e-02f, 1.37808472e-01f, 7.69802183e-02f, 1.67036012e-01f, 1.07258223e-02f, -6.31839633e-02f, -8.30464810e-02f, -4.28798348e-02f, -5.21644503e-02f,
  -4.52780724e-02f, -4.51255180e-02f, 1.30302673e-02f, 2.18073111e-02f, -1.19093116e-02f, 7.09481537e-03f, 4.33279276e-02f, 1.08260132e-01f, -1.60297245e-01f, 1.81707725e-01f,
  3.30213383e-02f, -1.83967203e-02f, 3.56415398e-02f, -3.76189873e-02f, -1.11865290e-01f, -1.39374673e-01f, -1.07568182e-01f, -6.90804096e-04f, -6.18376136e-02f, -7.46340156e-02f,
  8.65891501e-02f, 6.06402941e-02f, 2.79091541e-02f, -2.87845880e-02f, -1.78148765e-02f, -8.24939087e-02f, -1.26260087e-01f, -6.81033060e-02f, 1.12908952e-01f, 1.79426745e-02f,
  -1.73966318e-01f, -3.98758836e-02f, -5.32073379e-02f, -5.12386821e-02f, 3.49991247e-02f, 7.60452822e-02f, -1.42847940e-01f, -7.57838413e-02f, -4.68116114e-03f, 3.89451794e-02f,
  -8.83973911e-02f, -1.16111115e-01f, 3.35685089e-02f, -6.55540675e-02f, -4.77968380e-02f, -1.65341906e-02f, 3.49929519e-02f, 4.68136035e-02f, 8.40994641e-02f, 7.20183784e-03f,
  -4.28243317e-02f, 3.01411096e-02f, 7.52513558e-02f, -1.65476993e-01f, -6.41323114e-03f, 7.83858076e-02f, 9.28916484e-02f, -5.32024466e-02f, -8.59451294e-02f, 1.70853566e-02f,
  -9.77262855e-02f, -9.50015187e-02f, -8.36716220e-02f, 1.17261440e-01f, -9.35120881e-02f, -6.28375122e-03f, -1.91215158e-01f, -1.18221357e-01f, -1.87595934e-01f, 3.41777541e-02f,
  -1.02802590e-01f, -2.05923747e-02f, 1.07151857e-02f, -1.08784378e-01f, -1.47262111e-01f, -1.18191823e-01f, 3.57636064e-02f, 9.23357978e-02f, -2.55340301e-02f, -1.26671150e-01f,
  1.60732910e-01f, -1.32042333e-01f, -1.30372435e-01f, 6.54735193e-02f, -8.77293497e-02f, 2.19885841e-01f, 4.32172686e-01f, -1.66923866e-01f, -1.80079281e-01f, 4.73843627e-02f,
  9.60705355e-02f, 1.55292332e-01f, 3.02818060e-01f, 2.58783191e-01f, 3.39795202e-01f, 2.17476487e-01f, 1.62935004e-01f, 2.41145074e-01f, -1.34413257e-01f, 2.49285772e-02f,
  1.69345585e-03f, 1.92256570e-01f, 4.05204948e-03f, -2.81648070e-01f, 1.52439058e-01f, -2.82900095e-01f, 2.53163511e-03f, 7.26549327e-03f, -4.59199697e-02f, 1.41434789e-01f,
  -9.00898222e-03f, -6.81911455e-03f, 7.56467110e-04f, -3.63419093e-02f, -2.13605948e-02f, 2.67860270e-03f, 1.54037759e-01f, 1.08839937e-01f, -4.22041789e-02f, 1.26466015e-03f,
  8.45768154e-02f, 2.62348894e-02f, -1.54973209e-01f, 1.18494235e-01f, 4.08216082e-02f, -1.66554898e-01f, -1.06686875e-01f, -4.72455621e-02f, 9.85336863e-03f, 8.46408084e-02f,
  3.59333344e-02f, -1.10521033e-01f, -2.55409516e-02f, -9.50252078e-03f, -3.75199132e-02f, -8.99504051e-02f, 2.60484889e-02f, 1.11797899e-01f, -2.32159272e-02f, -6.01454228e-02f,
  1.37463845e-02f, 4.94758785e-02f, -4.05457802e-03f, -6.40769675e-02f, -1.67271700e-02f, -7.62109458e-02f, -1.95377469e-02f, -4.37874114e-03f, 2.57974584e-02f, -4.98792483e-03f,
  -9.31645557e-02f, -1.13864817e-01f, -5.79776801e-02f, 5.55443205e-02f, 6.10120073e-02f, -2.24777926e-02f, 4.49054241e-02f, 5.87608255e-02f, -2.18490586e-02f, -1.76425830e-01f,
  1.82668455e-02f, 1.13326497e-02f, -2.65510269e-02f, -2.84683108e-02f, 8.71852133e-03f, -3.89771573e-02f, 5.87862693e-02f, 1.35591598e-02f, -9.87130776e-02f, 9.78146791e-02f,
  5.33299148e-02f, 1.66388229e-02f, -1.07161090e-01f, -4.59916294e-02f, -5.70435636e-02f, 5.03318720e-02f, 1.01685584e-01f, 1.50568737e-03f, -1.39978351e-02f, 5.60675897e-02f,
  -2.53093727e-02f, -1.39722601e-03f, -9.35176834e-02f, 6.08172850e-04f, -9.02101696e-02f, -1.00516662e-01f, 1.20346300e-01f, -5.25901765e-02f, -4.41596247e-02f, -1.65581509e-01f,
  3.77013832e-02f, 2.01936029e-02f, 8.89719129e-02f, -3.16389576e-02f, -6.02339134e-02f, 5.04710153e-02f, -1.14723913e-01f, -4.59887786e-03f, 5.08383736e-02f, -7.10182115e-02f,
  3.62997577e-02f, 2.39652202e-01f, 1.51967987e-01f, -1.13969475e-01f, -9.39463526e-02f, -1.63072705e-01f, -3.06652218e-01f, -3.55752409e-02f, 1.40319809e-01f, 2.46553943e-02f,
  -1.79841474e-01f, 2.55373627e-01f, 1.67536177e-02f, -1.44166276e-01f, -5.81949018e-02f, -1.96975600e-02f, -1.92292526e-01f, -5.96988723e-02f, -1.88276805e-02f, -2.06442267e-01f,
  -6.32085204e-02f, -3.57186973e-01f, 1.29017085e-02f, -2.29937881e-01f, -9.44881961e-02f, 8.67391974e-02f, -9.95028093e-02f, -2.39820741e-02f, -6.21081516e-02f, 4.40569408e-02f,
  1.13060996e-01f, 4.03311588e-02f, 8.68509933e-02f, 3.75383832e-02f, -1.39086157e-01f, -5.82997687e-02f, 2.80495081e-02f, 3.32439691e-02f, -5.09611294e-02f, -5.56582697e-02f,
  -3.19412583e-03f, 9.27648395e-02f, -6.50026724e-02f, 4.32268269e-02f, -1.82668853e-03f, 1.04915217e-01f, -6.40963716e-03f, -3.45268585e-02f, 8.53703991e-02f, 1.44615918e-01f,
  3.07156425e-02f, 7.22390860e-02f, 1.19798509e-02f, 3.75558138e-02f, 5.52804023e-03f, -3.19002680e-02f, 4.21702489e-02f, 9.92172509e-02f, 3.40024731e-03f, 5.13863862e-02f,
  -6.33250102e-02f, -9.68239456e-02f, 1.53587451e-02f, 1.03389937e-02f, -8.65345374e-02f, 8.68991092e-02f, -2.43307427e-02f, -3.36811529e-03f, -5.31189889e-02f, 2.05865838e-02f,
  5.21603487e-02f, 4.20893207e-02f, -4.49045971e-02f, -6.35832176e-02f, -7.78502896e-02f, 5.64010553e-02f, 1.14439800e-02f, 3.60665880e-02f, -1.67345405e-02f, 5.17016836e-02f,
  2.38721771e-03f, 8.40203278e-03f, 7.52662309e-03f, 8.28997418e-02f, -5.52212559e-02f, 3.11491098e-02f, 2.24995054e-02f, 1.59401014e-01f, -3.63393165e-02f, -9.22744498e-02f,
  -2.08922178e-02f, -2.55952954e-01f, -5.95977604e-02f, 8.62930939e-02f, 1.78263914e-02f, -1.10939639e-02f, -3.90994623e-02f, 7.39396438e-02f, -1.33778855e-01f, -7.50778466e-02f,
  -4.74831201e-02f, -1.90363377e-02f, -3.76371597e-03f, 5.76849990e-02f, 2.48956028e-02f, 1.33310305e-02f, -2.57032104e-02f, 1.73903648e-02f, -6.33286685e-02f, 6.67043179e-02f,
  1.55025525e-02f, -4.02403846e-02f, -2.46023741e-02f, -3.75482216e-02f, -3.37779261e-02f, -9.86328069e-03f, 1.31689180e-02f, 8.63568038e-02f, -8.94111320e-02f, -4.10170620e-03f,
  2.44188994e-01f, -2.22254708e-01f, -2.68811524e-01f, 2.11200994e-02f, 1.50523586e-02f, 3.18773776e-01f, 4.27412838e-01f, -6.49547726e-02f, -1.07857682e-01f, 1.64020777e-01f,
  1.99357733e-01f, 2.22982075e-02f, 1.55973047e-01f, 3.60179126e-01f, 3.24898422e-01f, 2.15832844e-01f, 2.99921751e-01f, 2.49384195e-01f, -1.92717418e-01f, 2.75441352e-03f,
  1.55770436e-01f, 3.43604624e-01f, 8.93776193e-02f, -1.75117701e-01f, 2.08441556e-01f, -2.69950539e-01f, 5.09021915e-02f, -9.19664204e-02f, 1.20575927e-01f, 2.20727697e-01f,
  1.38091976e-02f, -9.75725949e-02f, -1.90174039e-02f, -6.33044764e-02f, -3.66645306e-02f, -3.74348238e-02f, 5.19853830e-02f, 1.56435948e-02f, -5.31012416e-02f, -3.97632197e-02f,
  6.41327053e-02f, -4.88134660e-02f, 7.18686059e-02f, 3.30639295e-02f, 3.08810640e-02f, -5.32722063e-02f, -5.64055666e-02f, -5.61813042e-02f, -2.32087206e-02f, 5.39047197e-02f,
  -1.50040891e-02f, -7.91642219e-02f, 1.85035951e-02f, -6.33083656e-02f, 3.15118544e-02f, -2.40285862e-02f, 6.40844135e-03f, -1.99257117e-02f, -1.48792434e-02f, -3.00610494e-02f,
  7.12385178e-02f, 8.52259051e-04f, 1.30897155e-02f, 2.33486965e-02f, -4.60635424e-02f, -2.24054065e-02f, 4.90891561e-02f, -9.36468989e-02f, -7.93769881e-02f, -2.78013721e-02f,
  -5.60501181e-02f, -1.01267293e-01f, -1.19195189e-02f, 9.07237828e-02f, 2.60248575e-02f, -5.73367886e-02f, 8.67054053e-03f, 1.28840789e-01f, -3.12552974e-02f, -8.86620581e-02f,
  -5.05398214e-02f, 2.51581129e-02f, -3.36541347e-02f, 7.10360482e-02f, 6.87037781e-02f, 5.56310862e-02f, 7.31250942e-02f, -6.25383155e-03f, 8.57653655e-03f, 6.41506240e-02f,
  2.15705950e-02f, -6.88262209e-02f, -1.28148999e-02f, -6.78118467e-02f, -4.10276279e-02f, -2.31870655e-02f, 9.37225670e-02f, -3.18041965e-02f, -5.56275658e-02f, -4.29485328e-02f,
  3.59936692e-02f, -7.38992766e-02f, -7.16713816e-02f, 3.85900289e-02f, 7.42076896e-03f, 6.61428869e-02f, 1.16753116e-01f, -8.73597637e-02f, -1.42760249e-02f, -1.18873388e-01f,
  2.45146230e-02f, 1.49758589e-02f, 5.76875918e-02f, -4.67393994e-02f, 4.42363732e-02f, 5.97393746e-03f, -1.03892677e-01f, -5.80957308e-02f, 1.41831324e-01f, -1.00540660e-01f,
  1.08273745e-01f, 1.75329193e-01f, -1.60111472e-01f, 3.99646983e-02f, 2.97072547e-04f, -1.88413486e-01f, -2.56868273e-01f, 5.58976494e-02f, -2.66758204e-01f, 9.61267576e-02f,
  1.48902878e-01f, -3.03569764e-01f, 6.27804920e-02f, 3.01160902e-01f, 6.34498149e-02f, 4.99818474e-02f, 1.99349508e-01f, 3.60821262e-02f, -3.99257615e-03f, 1.98567122e-01f,
  1.29131526e-01f, 4.54397172e-01f, 1.95832565e-01f, 2.64137357e-01f, 2.38458142e-01f, -5.07381633e-02f, 1.31568894e-01f, 4.37238514e-02f, 1.69041812e-01f, -2.00481731e-02f,
  4.56970232e-03f, 1.08003058e-01f, -8.53461176e-02f, -1.08514041e-01f, 8.79920125e-02f, 3.11584398e-02f, -6.05021454e-02f, -4.67562713e-02f, -9.52172726e-02f, -2.78188623e-02f,
  -1.03225432e-01f, 5.06957248e-02f, 1.39276367e-02f, 3.32553945e-02f, 3.99962291e-02f, -1.57653734e-01f, 4.89126928e-02f, -1.18119508e-01f, -5.07475100e-02f, 1.63949102e-01f,
  4.85083088e-02f, -6.34719357e-02f, -6.97028711e-02f, -5.03909476e-02f, -7.87723437e-02f, -6.39018938e-02f, -8.56042281e-02f, -3.74556296e-02f, -6.47364557e-02f, -4.17187810e-02f,
  1.87154159e-01f, -4.18991409e-02f, -1.89903304e-02f, -1.26478434e-01f, -2.09055915e-02f, -4.26294515e-04f, -1.14391692e-01f, -7.87599012e-03f, -3.18026841e-02f, 2.74039302e-02f,
  1.35727634e-03f, -5.58508746e-02f, 1.17165521e-02f, 1.12079613e-01f, 8.96216705e-02f, -6.36947975e-02f, -4.54333751e-03f, 7.09294751e-02f, 3.08371559e-02f, -5.07079512e-02f,
  -1.23175144e-01f, 3.11934389e-02f, -8.14822912e-02f, 7.99400359e-02f, -4.30006199e-02f, -1.18265525e-01f, 1.06826551e-01f, 8.75869244e-02f, -7.28746131e-02f, 1.28993332e-01f,
  9.77636129e-02f, 1.39023438e-01f, -5.83591964e-03f, -1.07827693e-01f, -4.88024987e-02f, 9.06957686e-02f, 3.58977988e-02f, 8.27405378e-02f, 8.04199954e-04f, 3.46068069e-02f,
  1.02847204e-01f, -1.11136168e-01f, 5.48329949e-02f, 7.72317797e-02f, -1.06927879e-01f, -8.29111785e-03f, 5.92558319e-03f, -1.65728778e-01f, -1.98717430e-01f, 5.54852895e-02f,
  7.14579150e-02f, 1.85848307e-02f, -1.39607117e-01f, -1.18731372e-01f, -1.10963313e-03f, 3.94880585e-03f, -1.20924659e-01f, 2.45866254e-02f, 1.68044880e-01f, -4.66357023e-02f,
  4.40961421e-01f, -4.50592935e-01f, 1.63082629e-01f, 3.60460550e-01f, 2.15189531e-01f, -1.67925991e-02f, 2.49964386e-01f, -1.37010172e-01f, 9.66294855e-02f, -3.70129287e-01f,
  9.52012688e-02f, -2.68691540e-01f, -1.25942170e-04f, -1.29398346e-01f, 3.49356771e-01f, -4.19581085e-02f, -1.10585876e-02f, -3.56477425e-02f, 9.75778699e-02f, 5.35551310e-02f,
  2.24375084e-01f, 5.50456643e-02f, 1.74925700e-02f, -2.55004525e-01f, 7.79073313e-02f, -5.08239344e-02f, -3.63022424e-02f, -9.12375282e-03f, -1.77699685e-01f, -1.12767071e-01f,
  8.43862295e-02f, 3.97998327e-03f, -6.61371276e-02f, -4.65447903e-02f, 2.44314093e-02f, -8.58572498e-02f, -3.72516289e-02f, 1.06413096e-01f, 1.46443874e-01f, 2.35506222e-02f,
  5.11268936e-02f, 3.60760093e-02f, -8.10572281e-02f, 3.90285328e-02f, 9.72091630e-02f, -2.49605738e-02f, 6.10141605e-02f, -1.46675901e-02f, 6.32323790e-03f, -9.32046492e-03f,
  2.06833761e-02f, -1.48090310e-02f, 1.87238157e-01f, -6.97686821e-02f, 4.34066504e-02f, 3.77001129e-02f, -6.19511902e-02f, 1.62205305e-02f, -7.17860386e-02f, -1.44996867e-01f,
  -5.95579073e-02f, -9.95788723e-02f, 3.75754461e-02f, 7.80509040e-02f, 6.79882914e-02f, 5.09288460e-02f, 8.03380981e-02f, 1.01724174e-02f, 8.28873590e-02f, -3.74280848e-02f,
  4.77079228e-02f, 7.84522817e-02f, 5.16252294e-02f, 3.26895416e-02f, -4.38736901e-02f, -6.16097078e-02f, 1.24118045e-01f, -1.18375577e-01f, 4.22146358e-02f, 6.18331395e-02f,
  -9.50357132e-03f, 3.29295248e-02f, -5.51268980e-02f, 1.41009698e-02f, 3.10302470e-02f, -6.75908700e-02f, -5.21140210e-02f, 5.53692654e-02f, -3.51440161e-02f, 8.66908133e-02f,
  -1.10959888e-01f, -4.38558668e-01f, -5.76287173e-02f, -5.70649393e-02f, -5.16464710e-02f, 2.64661331e-02f, -5.77738285e-02f, 1.75568908e-02f, -5.69143035e-02f, -1.04579807e-03f,
  -1.51870837e-02f, 9.53650996e-02f, 4.24470901e-02f, 1.39804393e-01f, -1.16375908e-02f, -2.57232543e-02f, -4.91976850e-02f, -3.84280384e-02f, -8.46713856e-02f, -2.20182706e-02f,
  7.95779005e-03f, 2.72230282e-02f, 2.61529852e-02f, 6.40486693e-03f, -8.17902014e-02f, -3.50225978e-02f, -8.80439654e-02f, -7.17560276e-02f, 1.04353286e-01f, -4.01609987e-02f,
  1.62557185e-01f, -3.23598564e-01f, 7.20702633e-02f, 8.07943419e-02f, 5.37163429e-02f, -1.59811318e-01f, 2.81887129e-02f, -1.06654249e-01f, 5.29147200e-02f, -2.50068724e-01f,
  -2.34717671e-02f, 1.89007908e-01f, 9.80665609e-02f, -1.78388238e-01f, 3.78129750e-01f, 1.11158192e-01f, -1.57333910e-01f, 7.83713534e-02f, 8.14613849e-02f, -1.89821020e-01f,
  1.68946816e-03f, -2.58550793e-01f, 1.24644220e-01f, -3.95092428e-01f, -2.19335929e-01f, -1.18227653e-01f, 5.05238771e-03f, -8.52025859e-03f, -2.17181832e-01f, 1.11100502e-01f,
  -1.61480308e-01f, -1.56128079e-01f, -3.49441767e-02f, -1.22039258e-01f, -1.61094919e-01f, -1.13390479e-02f, 9.12278444e-02f, 1.32155299e-01f, 4.90887091e-02f, -8.32131580e-02f,
  6.08171150e-02f, -5.09065613e-02f, -1.13259219e-01f, -1.10021476e-02f, -8.77271220e-02f, -2.51422618e-02f, 1.75654609e-02f, -2.58135088e-02f, -9.90518648e-03f, 1.42348886e-01f,
  3.43305059e-02f, 2.48542819e-02f, 4.69992422e-02f, 2.88223568e-02f, 1.45177394e-01f, 5.14054596e-02f, 7.66293332e-02f, 9.81568620e-02f, 3.86665873e-02f, 2.44084280e-02f,
  -7.59909349e-03f, 9.88933723e-03f, 5.08224964e-02f, -3.74168418e-02f, -2.32000630e-02f, 1.54880686e-02f, -3.54087502e-02f, 1.36237508e-02f, 2.65499856e-02f, 4.45100628e-02f,
  -2.26716045e-02f, 4.85741235e-02f, 1.86066702e-03f, -2.51039602e-02f, -2.77711097e-02f, 3.48826982e-02f, 4.18694317e-02f, 4.72144261e-02f, -1.79295719e-03f, 7.08309859e-02f,
  4.64808866e-02f, -8.14746134e-03f, -4.86428738e-02f, -9.30052996e-03f, -1.58392023e-02f, 7.90928677e-02f, -1.58668533e-02f, -4.05957177e-02f, -2.25441996e-03f, -3.14252488e-02f,
  -1.60668224e-01f, -2.80130565e-01f, -5.44042848e-02f, -5.87952211e-02f, -3.66965421e-02f, -2.05530487e-02f, 1.01339603e-02f, -7.60621503e-02f, -6.92918003e-02f, -5.60291111e-02f,
  -1.26281738e-01f, -5.45151904e-03f, -2.41158828e-02f, -1.03167202e-02f, -2.28505954e-02f, -3.97212431e-02f, 2.52687056e-02f, -1.20600336e-03f, -1.36092706e-02f, -2.90830922e-03f,
  9.10635386e-03f, -2.33347923e-03f, 3.46385576e-02f, 1.45657565e-02f, -1.35364234e-02f, 9.86101404e-02f, 2.33257599e-02f, 8.27623308e-02f, -2.81742942e-02f, -4.29428276e-03f,
  -3.74673069e-01f, 7.96440020e-02f, 7.14332089e-02f, -3.07151049e-01f, 4.14240688e-01f, 5.19898713e-01f, -1.39973417e-01f, 3.12117338e-01f, -2.51491725e-01f, 8.57798681e-02f,
  2.37465471e-01f, -1.05706222e-01f, -8.42060596e-02f, 1.42890051e-01f, 1.20930657e-01f, 2.33536717e-02f, 1.04765862e-01f, 1.90071445e-02f, -1.27380386e-01f, -1.19358420e-01f,
  -1.51689097e-01f, 1.78082108e-01f, 9.19448491e-03f, 9.59903151e-02f, 1.04394905e-01f, -1.64469630e-01f, -4.60870452e-02f, -1.76509097e-01f, 1.89115286e-01f, 1.44835904e-01f,
  2.66664438e-02f, -2.42326349e-01f, 1.72589384e-02f, 2.74568480e-02f, 1.20041743e-01f, -4.13246527e-02f, 2.86601228e-03f, 1.85773242e-02f, -7.50576183e-02f, 3.38648185e-02f,
  -4.01512235e-02f, -1.24720624e-02f, 1.73395574e-02f, -9.05379504e-02f, 1.98722929e-02f, 1.33979455e-01f, 1.55817956e-01f, 1.19535848e-01f, 6.38842285e-02f, 7.38027394e-02f,
  5.27384318e-02f, 1.35360479e-01f, 2.61509102e-02f, 1.22764476e-01f, 1.48626700e-01f, 1.41074702e-01f, -9.27567482e-02f, -4.52459157e-02f, 1.65693790e-01f, 1.54234797e-01f,
  -5.54888397e-02f, -9.92498621e-02f, 9.51601416e-02f, 1.14589497e-01f, -6.37415275e-02f, 4.74246852e-02f, 5.87645881e-02f, 9.26340073e-02f, -9.88315791e-02f, 1.28757074e-01f,
  5.37848063e-02f, 2.41717398e-02f, -5.24496436e-02f, -5.36745153e-02f, -1.75635442e-02f, -7.74307773e-02f, 2.68621072e-02f, 6.14675842e-02f, -2.24717669e-02f, 1.78316317e-03f,
  -9.14569870e-02f, -3.94236445e-02f, 1.28912251e-03f, 8.09700191e-02f, 3.09663787e-02f, 4.02916968e-02f, 1.07791096e-01f, 1.22538172e-01f, 2.11672559e-02f, 6.66812882e-02f,
  8.46187323e-02f, -1.71998039e-01f, -2.24528760e-02f, 4.74043861e-02f, -1.13191418e-02f, 8.55266675e-02f, -4.91454862e-02f, 1.14093147e-01f, 1.07722685e-01f, 6.66436851e-02f,
  1.85426399e-02f, -1.22119963e-01f, 4.07110155e-02f, -7.95577988e-02f, -7.53881633e-02f, 1.51490629e-01f, -2.44847033e-02f, -1.14393637e-01f, 1.44172505e-01f, 1.47522435e-01f,
  3.70466560e-02f, -3.21872234e-02f, -8.30372125e-02f, 1.50193483e-01f, -3.65264006e-02f, 5.93897998e-02f, 2.71694660e-02f, -1.10776663e-01f, 6.86641484e-02f, 4.27385643e-02f,
  -1.90736309e-01f, -3.23051885e-02f, 2.01024279e-01f, 8.80055279e-02f, -6.80881590e-02f, -6.61082268e-02f, 6.57254681e-02f, -1.09152816e-01f, -1.94270879e-01f, -2.61825562e-01f,
  -1.53882280e-01f, 6.30836859e-02f, 6.75560236e-02f, 7.35512674e-02f, 4.75256830e-01f, -6.57708272e-02f, 6.82960972e-02f, -6.15093373e-02f, 2.60365978e-02f, 1.35205641e-01f,
  1.17162079e-01f, 1.28352150e-01f, 3.14300448e-01f, 1.63066499e-02f, 3.46602798e-02f, 1.09813824e-01f, 2.59935111e-01f, 2.19351783e-01f, 2.39738822e-01f, 1.17024377e-01f,
  -1.15290590e-01f, -8.17796215e-02f, 1.96161363e-02f, 2.55385172e-02f, -8.18651319e-02f, -8.73603597e-02f, 2.90015899e-02f, 1.50450349e-01f, -5.33482712e-03f, 8.18921253e-02f,
  1.88880134e-02f, 4.49594706e-02f, -2.73932759e-02f, 5.65130003e-02f, -1.09429479e-01f, -6.56096116e-02f, 1.46164857e-02f, -1.05389707e-01f, 1.10733032e-01f, -9.67597663e-02f,
  5.23536541e-02f, -1.79236475e-03f, 1.94983520e-02f, 7.82054290e-02f, 1.51027963e-01f, -1.90778926e-01f, -1.12451546e-01f, 9.68252569e-02f, 1.86366066e-02f, -6.91201761e-02f,
  7.35011846e-02f, 2.97525972e-02f, -9.34862643e-02f, -8.06456730e-02f, -1.30143445e-02f, -4.13363576e-02f, -1.50545007e-02f, -8.73147398e-02f, 6.72630146e-02f, 1.81284379e-02f,
  -9.27830413e-02f, -1.34596273e-01f, -6.42459616e-02f, -1.06611140e-01f, -9.09347907e-02f, -1.77784964e-01f, -2.12375652e-02f, 3.55754271e-02f, -5.42207509e-02f, -8.00286159e-02f,
  -6.89046865e-04f, -2.06654985e-02f, -4.15437184e-02f, 4.04880894e-03f, -3.79978083e-02f, 6.48756027e-02f, 7.30528682e-02f, 1.31445716e-03f, 2.84905639e-02f, 2.07022458e-01f,
  -6.21550754e-02f, 2.17085168e-01f, 1.20765530e-02f, -6.54739738e-02f, 2.02510674e-02f, -9.05285310e-03f, 8.73219445e-02f, 1.73913855e-02f, 2.36189328e-02f, 7.57291093e-02f,
  -4.82106619e-02f, 1.80705655e-02f, -6.80350810e-02f, 2.78583560e-02f, 6.66434094e-02f, 1.91125348e-02f, 1.16032995e-01f, -2.27184892e-02f, -3.11566573e-02f, -3.28120613e-03f,
  1.02739185e-01f, 5.58823086e-02f, 1.26950905e-01f, -1.72690116e-02f, -1.44436181e-01f, 3.52208167e-02f, -7.96011388e-02f, -6.98189586e-02f, 4.88417670e-02f, 6.79513514e-02f,
  7.54016489e-02f, -2.06322819e-01f, -8.87835398e-02f, 1.23933941e-01f, 1.39829561e-01f, 1.20254397e-01f, 6.97907060e-03f, -4.27535502e-03f, -8.95472094e-02f, -4.11942080e-02f,
  -2.45144349e-02f, -1.41116947e-01f, -2.83474624e-01f, -2.21291033e-04f, 9.23592895e-02f, -2.46717587e-01f, 2.07281053e-01f, 9.97609273e-03f, -2.24215180e-01f, 3.53707522e-02f,
  9.31789353e-02f, 2.30768383e-01f, -2.11982116e-01f, 1.99684128e-01f, 1.89619958e-01f, 1.07053779e-01f, 2.83884943e-01f, -1.43623212e-02f, 2.31501073e-01f, 1.54610187e-01f,
  -6.87937811e-02f, -1.06412962e-01f, 1.80525100e-03f, 1.97706167e-02f, 7.62515515e-02f, 8.44096318e-02f, 1.75231248e-01f, 1.61129248e-03f, -7.55403042e-02f, -5.23985513e-02f,
  2.32696440e-02f, 9.88514647e-02f, 7.98326209e-02f, 6.65140301e-02f, 5.63735254e-02f, -1.25062112e-02f, -4.60721232e-04f, 3.97529081e-03f, 6.52684495e-02f, -1.66814119e-01f,
  -1.63262680e-01f, -1.09020241e-01f, 5.60738668e-02f, 7.71311522e-02f, -1.61160366e-03f, -2.79438663e-02f, -1.06942460e-01f, 5.46141230e-02f, 4.01889011e-02f, -2.10233615e-03f,
  2.65169870e-02f, 2.01102486e-03f, 1.85408834e-02f, -1.44570246e-01f, -1.39467989e-03f, 6.60291463e-02f, 4.35427129e-02f, -9.14061964e-02f, 9.68817919e-02f, -2.85035353e-02f,
  3.22844125e-02f, 3.43122669e-02f, -2.83912802e-03f, -4.42597317e-03f, 5.86143956e-02f, -2.81552896e-02f, 2.95284130e-02f, 3.11429501e-02f, 1.22748679e-02f, -8.46543163e-02f,
  5.23384800e-03f, 1.83515266e-01f, -1.04570717e-01f, 2.61434335e-02f, -8.07401687e-02f, -4.64794114e-02f, 6.82207122e-02f, 2.45058071e-02f, -1.87066764e-01f, 1.49723977e-01f,
  -2.72796713e-02f, 4.69985791e-02f, -6.50038496e-02f, 7.23038288e-03f, -3.26254703e-02f, 1.40887752e-01f, 7.45424703e-02f, 1.56314284e-01f, -9.74376723e-02f, 2.06565727e-02f,
  1.32591531e-01f, -3.60573977e-02f, 6.60058260e-02f, 8.38726088e-02f, -2.73261243e-03f, 8.30064341e-03f, 2.72372626e-02f, 6.83951527e-02f, 1.29113808e-01f, -6.34163385e-03f,
  -7.86960274e-02f, -1.37922965e-04f, 1.35403536e-02f, 4.59030718e-02f, 5.68505712e-02f, 2.36808835e-03f, -7.62544423e-02f, -8.84147827e-03f, 5.39208911e-02f, -2.44313572e-02f,
  -3.01286638e-01f, -4.26665246e-02f, -3.82434964e-01f, -5.61348908e-02f, 1.11679122e-01f, 2.87481517e-01f, 1.70561850e-01f, -1.30926070e-04f, -2.59013385e-01f, 3.39366645e-01f,
  2.63336211e-01f, -3.17489117e-01f, 4.95353974e-02f, 1.42325714e-01f, -2.71826744e-01f, -4.99920323e-02f, 1.78167522e-01f, 1.30986840e-01f, -1.32433742e-01f, 6.43619001e-02f,
  -8.04321170e-02f, 1.96998179e-01f, 1.65196520e-03f, 7.38102570e-02f, 1.59420058e-01f, -9.06225219e-02f, 3.95339936e-01f, -8.13428778e-03f, 2.81675696e-01f, -1.19802311e-01f,
  2.64409161e-03f, -1.47422716e-01f, -9.23373923e-02f, -1.00234687e-01f, 9.46289673e-02f, 9.69644189e-02f, 1.27063602e-01f, 1.52879895e-03f, -7.32134059e-02f, -9.49770883e-02f,
  5.82155921e-02f, -2.99762413e-02f, -1.09311134e-01f, -6.63997009e-02f, -9.02501792e-02f, -6.61637634e-02f, -9.41445902e-02f, 1.55317619e-01f, 8.26001447e-03f, -4.46135178e-03f,
  -7.12653622e-02f, -3.39574888e-02f, 1.03208616e-01f, 6.15453289e-04f, -7.57486969e-02f, -1.18335269e-01f, 2.04812083e-02f, 8.69806632e-02f, 8.59567821e-02f, -9.29829031e-02f,
  5.58061786e-02f, 6.52003512e-02f, 1.25457436e-01f, -6.67169988e-02f, -3.57507728e-02f, -6.87976321e-03f, 3.16926986e-02f, 7.42921559e-03f, -9.53056961e-02f, 1.23738209e-02f,
  -1.00379005e-01f, -7.43451640e-02f, -2.52522412e-03f, 9.12926123e-02f, 3.86296846e-02f, -3.62528791e-03f, -6.88128099e-02f, 4.12383936e-02f, -8.36867318e-02f, 5.86025864e-02f,
  -4.37226053e-03f, -3.91569883e-02f, -1.16472812e-02f, 1.57644972e-01f, 1.36329621e-01f, -1.26733556e-01f, 5.04487939e-02f, -7.22693056e-02f, 7.96535015e-02f, 3.77726890e-02f,
  1.38150126e-01f, 2.93742605e-02f, -6.79982156e-02f, -7.93362558e-02f, -2.71598399e-02f, 1.92036480e-02f, -9.24399421e-02f, 1.52329849e-02f, -2.97239758e-02f, -4.00313437e-02f,
  1.14140064e-01f, 7.14178383e-02f, 5.81636541e-02f, -7.99236745e-02f, -3.20869982e-02f, 1.11846648e-01f, 5.61661832e-02f, 1.06263839e-01f, 1.52929248e-02f, 3.67631093e-02f,
  1.11069717e-01f, -1.71938315e-02f, -5.42010888e-02f, 3.28500080e-03f, 8.80467370e-02f, 3.91182192e-02f, -3.28391907e-04f, -2.18116306e-02f, 7.89229795e-02f, -3.07251904e-02f,
  2.69959152e-01f, -2.09258541e-01f, 2.48399645e-01f, -5.87386228e-02f, 2.89136767e-01f, 2.79404134e-01f, 1.74415052e-01f, 1.70117125e-01f, 2.01837763e-01f, -2.34290436e-01f,
  -5.40777370e-02f, -3.25901210e-01f, 1.86674614e-02f, -1.81900799e-01f, 3.32341522e-01f, 6.67609200e-02f, -5.47010563e-02f, -1.93590671e-01f, 1.53750796e-02f, -5.23169972e-02f,
  -1.24119714e-01f, -3.41446936e-01f, 1.73099879e-02f, -2.58458316e-01f, -1.25577942e-01f, -8.70980173e-02f, -3.14071387e-01f, 1.65127777e-02f, -2.64584929e-01f, -4.99800183e-02f,
  7.95737505e-02f, 2.98153628e-02f, -4.56830859e-02f, -5.86005710e-02f, 1.96718305e-01f, 7.09487125e-03f, -2.10628077e-01f, 5.02144918e-02f, 1.91082150e-01f, 1.16545074e-01f,
  -1.40286475e-01f, -4.84387390e-02f, -4.91250865e-02f, 4.53747576e-03f, -1.10979993e-02f, 7.32148141e-02f, 1.59181599e-02f, 7.71473646e-02f, -2.29020859e-03f, 1.06102705e-01f,
  4.86515984e-02f, 9.85807553e-02f, 6.13353439e-02f, -7.38071203e-02f, -1.84348188e-02f, -2.24163588e-02f, 4.47201543e-02f, -3.72056402e-02f, 4.15381417e-02f, 3.04627083e-02f,
  -2.42937267e-01f, -4.48792875e-02f, 9.61651802e-02f, 6.88274428e-02f, 7.77958706e-02f, 1.17981449e-01f, 5.84001765e-02f, 3.91280744e-03f, 1.02002606e-01f, 6.10391162e-02f,
  3.12588289e-02f, 5.61869554e-02f, 1.88438911e-02f, 3.27429883e-02f, -5.77114895e-02f, -3.13440822e-02f, 3.93298008e-02f, -1.68911591e-02f, -3.42243724e-02f, 4.97050174e-02f,
  -3.17829731e-03f, -3.73591408e-02f, 1.05065191e-02f, -9.88241732e-02f, 6.47848248e-02f, 9.41509530e-02f, -1.78150415e-01f, 1.31126210e-01f, 6.11676052e-02f, -1.71196818e-01f,
  -3.44800577e-02f, -3.23694736e-01f, -8.06509703e-02f, -1.22309037e-01f, -7.36437878e-03f, 5.35669774e-02f, -7.08467513e-02f, -5.51438071e-02f, -1.96899492e-02f, 3.76597159e-02f,
  -1.05212323e-01f, -4.86750267e-02f, 1.69721693e-02f, 9.36928578e-03f, -1.35999829e-01f, 8.12190846e-02f, -2.21506506e-01f, -5.39101548e-02f, -5.20349517e-02f, -2.79664323e-02f,
  -1.13549240e-01f, 5.28229997e-02f, -7.62283355e-02f, 4.43684915e-03f, -1.25234559e-01f, -5.38191721e-02f, 3.65363546e-02f, -4.93285730e-02f, -5.44358827e-02f, -5.29280584e-03f,
  4.02568012e-01f, -2.30724573e-01f, -1.31703138e-01f, 2.64101118e-01f, 1.78784654e-01f, -1.26598343e-01f, -1.92199707e-01f, 1.13345407e-01f, 4.44480330e-02f, -2.81767160e-01f,
  4.05932628e-02f, 5.96993603e-03f, -2.29743347e-01f, 3.11844230e-01f, 3.96252334e-01f, -3.07471037e-01f, 2.70248234e-01f, 2.98152640e-02f, -5.02102114e-02f, 1.47644833e-01f,
  3.48609060e-01f, 2.51478732e-01f, 1.09964542e-01f, 1.69968903e-01f, 1.60336360e-01f, -1.71130709e-02f, 1.95823863e-01f, -2.15009198e-01f, 1.56730816e-01f, 1.00383662e-01f,
  -6.24685287e-02f, 3.87270898e-02f, 3.14443000e-02f, -4.94457111e-02f, -5.64378081e-03f, -7.09590910e-04f, -4.91053984e-02f, -2.72607878e-02f, -1.21574542e-02f, -1.87298432e-01f,
  -2.79687773e-02f, 5.91401495e-02f, 1.32210299e-01f, -2.85418960e-03f, 1.31955847e-01f, -5.62811643e-02f, 4.83562052e-02f, -6.41793236e-02f, -5.79145215e-02f, 7.55269155e-02f,
  1.30193653e-02f, -4.67808768e-02f, 3.89006622e-02f, 1.59664024e-02f, 7.08020180e-02f, 3.50424983e-02f, -3.80853638e-02f, -9.40136313e-02f, -1.11059971e-01f, -4.16828468e-02f,
  2.35947575e-02f, -6.23485073e-02f, -8.96744654e-02f, -8.13830793e-02f, -5.15914941e-03f, -2.61954274e-02f, 3.29573229e-02f, -7.17654079e-03f, -8.54254067e-02f, -9.17707607e-02f,
  -8.72472152e-02f, 1.83827244e-02f, -2.15532612e-02f, 2.46271794e-03f, 4.08015661e-02f, 6.66018277e-02f, -1.29623804e-02f, -1.28485426e-01f, -4.25684825e-02f, -2.83335056e-02f,
  -1.27109855e-01f, 8.68464261e-02f, -4.63896766e-02f, 7.30809793e-02f, -1.04313836e-01f, -8.48460197e-03f, 8.96602646e-02f, -6.50599748e-02f, -5.82233742e-02f, -2.82224710e-03f,
  -2.47386638e-02f, 6.52588755e-02f, -1.12100653e-01f, 1.90765765e-02f, -8.18133354e-02f, 3.00977044e-02f, 3.43311876e-02f, 1.03199475e-01f, -8.73604119e-02f, -6.37839660e-02f,
  4.36245315e-02f, -2.99455505e-03f, -2.80070826e-02f, 1.11829437e-01f, -8.89399499e-02f, 8.05116892e-02f, 4.35074382e-02f, -1.10621430e-01f, 2.20812336e-02f, 7.46297091e-02f,
  2.84077376e-02f, -7.65317306e-02f, -2.93010641e-02f, -1.33099947e-02f, 7.47492686e-02f, 1.07823990e-01f, -3.31815816e-02f, -1.00089181e-02f, -2.24879030e-02f, -6.21348247e-02f,
  -1.51722431e-02f, -6.49589812e-03f, 2.89487004e-01f, 5.29949591e-02f, -6.84205536e-03f, 1.03078045e-01f, 3.11771899e-01f, -1.52311981e-01f, 1.55531382e-02f, -2.55773962e-01f,
  -1.05630197e-01f, 6.90052882e-02f, 1.01362273e-01f, 1.64497979e-02f, 1.72493279e-01f, 9.28408429e-02f, 5.66936471e-02f, 7.26438966e-03f, -3.95135576e-04f, -1.28503088e-02f,
  2.45739892e-02f, -8.71236250e-02f, 1.94905072e-01f, -2.19459251e-01f, 4.59435433e-02f, -1.14927314e-01f, -1.55823603e-02f, 1.11048661e-01f, -1.55427024e-01f, 6.49098009e-02f,
  -7.21197948e-02f, 5.37819155e-02f, 1.21969283e-01f, -3.09876651e-02f, -8.94979537e-02f, 1.60029959e-02f, 1.14962690e-01f, 1.46520391e-01f, 1.21053243e-02f, -8.85092318e-02f,
  -5.00935949e-02f, -9.00046527e-02f, -9.31324139e-02f, -8.89629126e-02f, 3.72063462e-03f, -5.71426041e-02f, 6.27804324e-02f, 1.09706577e-02f, 1.01081412e-02f, 3.17643471e-02f,
  3.56779620e-02f, -4.04096693e-02f, 6.58365116e-02f, -1.84757765e-02f, 1.32018194e-01f, 3.07193827e-02f, 6.46501109e-02f, 7.67456368e-02f, -4.72098552e-02f, -4.94591892e-02f,
  1.22433022e-01f, 1.27042219e-01f, 3.87875773e-02f, -7.33279288e-02f, -1.05843097e-01f, -1.89345449e-01f, -4.31883559e-02f, -4.62964140e-02f, 4.91227098e-02f, -4.10500774e-03f,
  -7.74084628e-02f, 6.83053508e-02f, 4.27653790e-02f, 7.59888068e-02f, 1.64082814e-02f, -3.97569984e-02f, 8.65425691e-02f, -6.08259775e-02f, -3.34522910e-02f, -5.46113253e-02f,
  -1.56165473e-02f, 2.78571397e-02f, 1.60587803e-02f, 5.63895470e-03f, -8.56974442e-03f, 5.42682447e-02f, -2.80120876e-02f, 8.66447017e-03f, 4.35594618e-02f, 1.52405456e-01f,
  -1.02006212e-01f, -1.58032496e-02f, 9.77078155e-02f, -4.53599729e-02f, 1.60347149e-02f, -5.30083179e-02f, 9.03689563e-02f, 1.44665930e-02f, -2.62255799e-02f, -2.56197788e-02f,
  -1.62596643e-01f, -3.77765670e-02f, -3.92162353e-02f, -1.54758831e-02f, 6.43043518e-02f, -1.07558034e-02f, 1.16281189e-01f, 6.64886087e-03f, -1.25719444e-03f, -2.12593190e-02f,
  -2.48399749e-02f, 1.84063544e-03f, -9.79345590e-02f, -4.56073545e-02f, 3.04442290e-02f, -7.71078141e-03f, -7.48387054e-02f, 5.16883694e-02f, -1.45091896e-03f, -1.72051676e-02f,
  -3.35215777e-01f, -1.19403116e-01f, -1.53094143e-01f, -1.72178283e-01f, 1.79995090e-01f, 4.36345845e-01f, -1.86215445e-01f, 3.62265036e-02f, -2.02591151e-01f, -2.61630446e-01f,
  -5.34898341e-02f, -1.43853113e-01f, -3.02301258e-01f, 3.13898996e-02f, 2.37511754e-01f, -5.01308739e-02f, 1.26127273e-01f, 1.34498533e-02f, 4.88360338e-02f, -3.52826267e-02f,
  6.68437034e-02f, 1.66498333e-01f, 1.92265902e-02f, 2.41171747e-01f, 4.05831784e-02f, 7.97851477e-03f, -1.80282779e-02f, -6.27779355e-03f, 2.36355975e-01f, 1.28817931e-01f,
  6.49719462e-02f, -2.71855831e-01f, -6.88618645e-02f, 2.35377271e-02f, -7.48093650e-02f, -1.36048481e-01f, 6.69127377e-03f, 6.90667182e-02f, -1.66318882e-02f, 8.77735298e-03f,
  -5.94203360e-02f, 9.04026702e-02f, -7.22282054e-03f, 1.72442198e-02f, 6.11958615e-02f, 4.71900664e-02f, 9.73250270e-02f, 8.72167200e-03f, 1.02498733e-01f, -1.38024930e-02f,
  1.99278034e-02f, 1.98815968e-02f, 8.98181088e-03f, 5.37250340e-02f, -2.38820501e-02f, 2.66628824e-02f, -2.89299693e-02f, -3.83147560e-02f, 1.08532012e-01f, -2.55557639e-03f,
  -4.22114730e-02f, -2.38502678e-03f, -7.77138770e-02f, -2.72485428e-02f, -5.24991378e-02f, -4.80285324e-02f, 6.93449676e-02f, 1.46064982e-02f, -6.09182157e-02f, -9.16536525e-03f,
  -1.30978107e-01f, -1.07136488e-01f, -4.54214998e-02f, 5.67798577e-02f, -2.90954057e-02f, -6.87088594e-02f, 1.64367054e-02f, 3.88371497e-02f, -1.16927631e-01f, 4.09751646e-02f,
  -3.39613482e-02f, 6.96420670e-02f, -9.73811299e-02f, 7.87050575e-02f, 1.03827037e-01f, 5.61000481e-02f, 4.25929949e-02f, -3.62667665e-02f, -4.66267131e-02f, -1.91485304e-02f,
  -6.34262152e-03f, -2.39337042e-01f, -7.78316185e-02f, 1.26695856e-01f, -2.57480945e-02f, -9.80315637e-03f, 4.42326404e-02f, 5.64965904e-02f, -8.75822529e-02f, -3.02275002e-04f,
  1.81023497e-02f, -5.25278710e-02f, 2.55453940e-02f, 1.70077235e-02f, 1.40053272e-01f, -5.88133074e-02f, 2.25701500e-02f, 1.68948770e-02f, 6.01894557e-02f, -2.23320629e-02f,
  -2.95546092e-02f, -5.03192917e-02f, 2.54391716e-03f, 7.54909739e-02f, 4.66185762e-03f, -1.13407914e-02f, -1.17939733e-01f, 4.38932469e-03f, 9.25803483e-02f, -6.50387304e-03f,
  4.74221915e-01f, 2.45392248e-01f, 8.66300613e-02f, 8.53948668e-02f, -7.84812197e-02f, 3.83789651e-02f, 6.26944425e-03f, -8.23745430e-02f, -1.18890051e-02f, 1.14147484e-01f,
  -1.60183951e-01f, 2.21416861e-01f, -1.28535196e-01f, 1.83455512e-01f, -1.76086783e-01f, -2.65728027e-01f, 3.75603810e-02f, 4.08460163e-02f, -6.26904666e-02f, 1.41004354e-01f,
  9.14220437e-02f, -4.43916731e-02f, -4.03915532e-03f, -1.86666865e-02f, 1.92152902e-01f, 1.46482199e-01f, -1.47393376e-01f, -3.54804210e-02f, 1.20552063e-01f, -6.68092519e-02f,
  7.82000348e-02f, 3.42050344e-02f, 1.39401883e-01f, 3.45222726e-02f, -4.86592054e-02f, 9.06414166e-02f, 8.44680443e-02f, -1.23095281e-01f, 3.10348459e-02f, -4.44970578e-02f,
  5.13699092e-02f, 3.05115357e-02f, -5.63099161e-02f, -3.34966704e-02f, 1.89186305e-01f, -1.30783580e-02f, 6.81691021e-02f, 8.22803676e-02f, 1.61217470e-02f, 2.50496808e-02f,
  1.25191957e-01f, 4.28168476e-02f, 1.18797988e-01f, -6.92714825e-02f, 2.84815691e-02f, -1.88161880e-02f, 4.76760492e-02f, -2.57696211e-02f, -5.47674038e-02f, 4.38752882e-02f,
  -3.16396467e-02f, 3.35585475e-02f, 2.05226475e-03f, 2.70037856e-02f, -1.07564945e-02f, -9.94814932e-02f, 6.33240566e-02f, -8.93097594e-02f, 5.62511049e-02f, -4.21145111e-02f,
  -1.20183326e-01f, -3.28759402e-02f, -4.18525971e-02f, 7.24766345e-04f, 6.27952591e-02f, 8.28020945e-02f, 8.08583666e-03f, -4.73972596e-02f, -3.62688629e-03f, -3.17056552e-02f,
  -1.02202788e-01f, 6.28600717e-02f, 1.41797354e-02f, 1.88456737e-02f, -3.64769734e-02f, -6.06134795e-02f, -2.85305381e-02f, 3.88089828e-02f, -3.38532701e-02f, -1.75033752e-02f,
  -7.60246664e-02f, -2.43554831e-01f, -6.01259358e-02f, 1.09805865e-02f, -9.12072808e-02f, 2.28016116e-02f, 6.97316304e-02f, 5.25772646e-02f, -7.02365786e-02f, -8.08625743e-02f,
  8.26644152e-02f, 3.25527564e-02f, -2.69266013e-02f, 9.80745330e-02f, -8.46817419e-02f, -4.07369211e-02f, -5.19640930e-02f, -4.66344543e-02f, -1.18916854e-01f, -8.63187909e-02f,
  4.40478958e-02f, 7.41307437e-03f, 3.02512851e-02f, -6.67960346e-02f, 4.16418649e-02f, -3.99885997e-02f, -1.75690075e-04f, 6.74448982e-02f, -4.23058607e-02f, -8.19082335e-02f,
  -7.61270046e-01f, 3.70461226e-01f, 8.60567540e-02f, -1.52172297e-01f, -1.78562403e-02f, 5.73440492e-02f, 4.05372567e-02f, 1.67280603e-02f, 1.15103635e-03f, 2.11405098e-01f,
  1.05231136e-01f, -9.39486474e-02f, 2.21223980e-01f, 2.18180567e-01f, -2.33334139e-01f, 2.60895789e-01f, -8.74298140e-02f, -4.14058901e-02f, 2.59957537e-02f, -1.19559303e-01f,
  -1.49359867e-01f, -3.73040512e-02f, 7.46299401e-02f, 5.78412712e-02f, -7.24537224e-02f, -8.88388902e-02f, -1.28016680e-01f, 8.78771916e-02f, 8.34563002e-03f, 4.19715717e-02f,
  -2.62750149e-01f, -2.60025561e-01f, -1.99994907e-01f, -1.34241179e-01f, -1.69040173e-01f, -6.74839765e-02f, -1.10814609e-01f, -3.23766135e-02f, -3.55763920e-02f, -1.47556774e-02f,
  -8.52267444e-03f, 5.21220341e-02f, -2.08805241e-02f, 2.76223645e-02f, -1.73930768e-02f, 2.90800706e-02f, 1.12168789e-01f, 1.03526171e-02f, 2.40011513e-02f, 5.92041835e-02f,
  6.50471672e-02f, 7.82896876e-02f, -4.19924408e-02f, 3.46098393e-02f, 5.39921049e-04f, 7.77446628e-02f, 7.35981762e-02f, -2.41638888e-02f, -9.57133546e-02f, 3.89404804e-03f,
  -2.65339892e-02f, -3.27340029e-02f, -5.23467362e-02f, -4.42466466e-03f, 3.84027883e-02f, 2.40202285e-02f, 1.74705510e-03f, -2.59542633e-02f, 3.49897444e-02f, 1.87160186e-02f,
  5.75469621e-02f, -2.22804677e-02f, -5.66806644e-02f, -1.48490388e-02f, 2.66570225e-02f, -2.67525725e-02f, -4.31656912e-02f, -1.17280334e-02f, -7.15968851e-03f, -2.59989556e-02f,
  -4.29295823e-02f, 5.19466996e-02f, 6.72651501e-03f, -7.15001312e-04f, -7.11721703e-02f, -1.09179807e-03f, -1.80107206e-02f, 1.12057589e-02f, 2.21468764e-03f, -5.93099333e-02f,
  -4.47074234e-01f, -3.50002587e-01f, -1.05629973e-01f, -7.04359412e-02f, -9.98004824e-02f, 3.50944349e-03f, 9.86945629e-02f, -7.46206120e-02f, -7.09940270e-02f, -1.59694850e-02f,
  6.15115091e-03f, 3.78095135e-02f, -6.85046986e-02f, 1.31172501e-02f, 4.08849157e-02f, 3.23903412e-02f, -3.13323960e-02f, -4.90029082e-02f, -1.45976171e-01f, -4.31656763e-02f,
  1.52619937e-02f, -1.80165712e-02f, 3.72258015e-02f, -2.76895203e-02f, -3.98650728e-02f, -1.13303289e-01f, -9.66719538e-02f, 3.18777487e-02f, -7.83638880e-02f, 8.65318701e-02f,
  -1.54321998e-01f, -3.15253824e-01f, 1.22136883e-01f, 1.46330819e-02f, 1.51374549e-01f, 1.84036613e-01f, 1.57380715e-01f, -1.64663509e-01f, -2.39126429e-01f, -1.40454590e-01f,
  6.09998070e-02f, 2.40655560e-02f, -2.75618196e-01f, -1.14414260e-01f, 2.43900985e-01f, -1.84534624e-01f, -9.67929512e-02f, 8.82524624e-02f, -2.53170520e-01f, -5.85921332e-02f,
  6.84730592e-04f, -1.09385900e-01f, 9.67680663e-02f, -2.51005422e-02f, -6.39298037e-02f, 6.81873262e-02f, 1.24452248e-01f, 2.36724451e-01f, 2.63909578e-01f, 2.42802054e-01f,
  2.91065965e-02f, -2.22295970e-01f, -1.24093376e-01f, -4.32130357e-04f, -2.58685905e-03f, 8.51452649e-02f, 1.27969623e-01f, 1.76240876e-01f, 2.65212148e-01f, -1.52021140e-01f,
  4.54250611e-02f, 6.64567873e-02f, -1.82552248e-01f, 1.33730352e-01f, 1.21121770e-02f, 2.27939431e-02f, 1.59991521e-03f, -8.11159164e-02f, 5.66169946e-03f, -2.50539575e-02f,
  -9.86976251e-02f, -6.41561821e-02f, -7.77762011e-02f, 5.23250811e-02f, 5.57164960e-02f, -9.77765652e-04f, 6.72413409e-02f, -1.53985377e-02f, -6.36984855e-02f, 1.23522744e-01f,
  -1.35161325e-01f, -2.59386431e-02f, -8.94637629e-02f, -8.41209367e-02f, -1.50426954e-01f, 8.01986083e-02f, 2.94551742e-03f, -8.68837535e-02f, -4.03948463e-02f, -9.34357103e-03f,
  3.55166458e-02f, 4.91625257e-02f, 4.80069183e-02f, 1.43388912e-01f, -1.33216381e-01f, -2.25696281e-01f, 9.98788700e-02f, -4.16464657e-02f, -9.97827481e-03f, 5.11124916e-02f,
  2.76840199e-03f, 9.04353335e-02f, 8.69391635e-02f, 9.05396417e-02f, -7.12037459e-02f, 6.51169643e-02f, 7.18419254e-02f, -1.95090566e-02f, -3.51223350e-02f, 9.09859389e-02f,
  2.56303921e-02f, -1.46926895e-01f, -1.16140500e-01f, 9.05165225e-02f, -5.03267422e-02f, -9.33996215e-02f, -6.08251356e-02f, -5.56255616e-02f, 2.03339085e-02f, -1.94825277e-01f,
  5.99931292e-02f, 1.17194727e-01f, -2.18742006e-02f, 8.61042514e-02f, 1.19532607e-01f, 4.39751893e-02f, 1.55506626e-01f, -1.54389010e-03f, 8.12846720e-02f, 8.42131153e-02f,
  4.71995100e-02f, 3.64993364e-02f, -1.32033564e-02f, -1.06828608e-01f, -2.92829461e-02f, -5.53361103e-02f, 7.09913019e-03f, -3.93380821e-02f, -1.90719999e-02f, -8.43568053e-03f,
  -1.25606835e-01f, 2.21297786e-01f, -3.86918068e-01f, 7.09849969e-02f, -7.74674490e-02f, 1.26983032e-01f, 2.75690615e-01f, 4.11396101e-02f, -7.81696886e-02f, 4.26602304e-01f,
  3.77662331e-01f, -1.30804256e-01f, 3.10183823e-01f, 4.40067708e-01f, -1.89838871e-01f, 4.15098816e-01f, 2.80394018e-01f, 2.01567322e-01f, 4.17773388e-02f, 1.17093451e-01f,
  2.85736490e-02f, 4.31054145e-01f, 8.89409930e-02f, 2.48854198e-02f, 1.69703633e-01f, -2.22123563e-01f, -9.97235253e-03f, -1.54228836e-01f, 8.30666125e-02f, -7.92581961e-03f,
  9.20355693e-02f, 1.11950748e-01f, -4.63766009e-02f, -7.71588534e-02f, -4.29773033e-02f, -4.89142397e-03f, -7.31284320e-02f, -1.61229521e-01f, -1.40679434e-01f, 3.58099379e-02f,
  -7.72920474e-02f, 1.02667948e-02f, 2.78245360e-02f, 3.45016532e-02f, 2.73588356e-02f, -1.43733665e-01f, 3.04845963e-02f, -2.09941622e-02f, -5.67542799e-02f, 8.57768133e-02f,
  -4.30247895e-02f, 8.20040423e-03f, 3.25693609e-03f, 1.04038656e-01f, -2.86023859e-02f, -1.12946099e-02f, 1.20360563e-02f, -8.04300904e-02f, -3.44497487e-02f, -8.20885599e-02f,
  -6.93871677e-02f, 1.14955075e-01f, 7.06702620e-02f, -3.00433114e-03f, -1.93213914e-02f, 6.65151551e-02f, 1.66387185e-01f, 8.82262457e-03f, -9.99506265e-02f, 5.21609411e-02f,
  -5.76818436e-02f, -6.89963400e-02f, 4.75681759e-02f, 4.80112154e-03f, 1.65810645e-01f, -1.37719680e-02f, -2.19637565e-02f, 1.03648648e-01f, -3.14979814e-02f, -8.38922635e-02f,
  -8.20317566e-02f, 2.07790509e-02f, 7.01323077e-02f, 3.98889929e-03f, 9.73441452e-02f, 1.64054371e-02f, 1.77153587e-01f, 6.67669028e-02f, 4.07281891e-02f, -7.18258619e-02f,
  1.44307420e-01f, 1.26546308e-01f, 1.96624943e-03f, 1.76337659e-02f, -1.05509736e-01f, 2.45448723e-02f, -4.96965386e-02f, -1.69186220e-02f, 3.94522399e-03f, 8.46037418e-02f,
  -7.78401494e-02f, 3.86782992e-03f, -5.63682429e-02f, -2.64791958e-02f, -5.47184125e-02f, 2.86431592e-02f, 1.03811167e-01f, -1.36903390e-01f, -1.34348780e-01f, -7.71405473e-02f,
  -4.71806824e-02f, 1.30148232e-02f, -6.12707436e-02f, 1.06436186e-01f, 9.52163562e-02f, 2.89002303e-02f, -1.18593261e-01f, -5.68083078e-02f, -3.08080819e-02f, 5.59841320e-02f,
  2.84002155e-01f, -3.74475539e-01f, 1.03319377e-01f, 2.71171212e-01f, 2.22990498e-01f, -3.76305282e-02f, 1.94594860e-01f, 5.46756424e-02f, 1.72300339e-01f, -3.15980107e-01f,
  -1.36910314e-02f, -8.46127868e-02f, 3.57507402e-03f, -1.44148260e-01f, 2.05438614e-01f, -8.52853879e-02f, -5.22429608e-02f, -1.46092564e-01f, 2.37689377e-03f, -4.90323231e-02f,
  9.40805897e-02f, -2.54968822e-01f, 7.70868734e-02f, -2.99073815e-01f, 8.23786780e-02f, -4.92102914e-02f, -1.30563229e-01f, -3.38588469e-02f, -1.43756971e-01f, -4.24003750e-02f,
  -7.40960389e-02f, -6.55927807e-02f, 5.93649202e-05f, -4.19855379e-02f, -2.95754131e-02f, -5.91170043e-02f, -1.37949726e-02f, 6.20441884e-02f, 7.20004365e-02f, 1.66027881e-02f,
  -3.01723145e-02f, 1.21598849e-02f, -6.64756745e-02f, -4.48679700e-02f, -4.51529212e-02f, 5.75201884e-02f, 2.97835264e-02f, -2.20411811e-02f, 1.77943185e-02f, 1.28482252e-01f,
  1.13926493e-01f, -7.99384806e-03f, 3.71414982e-02f, -1.81851927e-02f, 5.46140186e-02f, 2.40740180e-02f, -2.11211778e-02f, 9.53894109e-03f, -4.39294009e-03f, 9.60410386e-02f,
  -9.25919488e-02f, -1.42915845e-02f, -9.65343788e-02f, 4.45570536e-02f, -2.97617167e-02f, 8.76701623e-02f, 2.28322707e-02f, 1.12648373e-02f, -4.30474542e-02f, 5.61629273e-02f,
  3.95210385e-02f, -3.87648828e-02f, -5.04142568e-02f, 2.14523287e-03f, -4.46917489e-02f, 9.11226571e-02f, 9.04516354e-02f, -1.35745993e-02f, 5.73249981e-02f, 2.05683857e-02f,
  -3.99326682e-02f, 2.34874357e-02f, -6.03702888e-02f, 1.05844557e-01f, 1.10838264e-02f, -9.76305339e-04f, -5.33101195e-03f, 8.13446641e-02f, 3.08300294e-02f, -1.17244005e-01f,
  -2.58717507e-01f, -4.07579929e-01f, -7.10774735e-02f, 1.35810468e-02f, -9.13239419e-02f, -7.10137933e-02f, -3.66518013e-02f, -2.92678326e-02f, -1.51656762e-01f, -6.13854527e-02f,
  -8.73671621e-02f, 6.34990782e-02f, -6.01586848e-02f, 6.05218299e-02f, -1.26785517e-01f, 1.20286187e-02f, 2.84577757e-02f, -1.17628515e-01f, 2.58155190e-03f, -3.02777276e-03f,
  -6.00720681e-02f, -6.68394640e-02f, 7.28940144e-02f, 1.52236279e-02f, -3.70255336e-02f, 2.76978463e-02f, 5.03582973e-03f, 1.32832387e-02f, -8.24377872e-03f, 7.98595324e-02f,
  -3.48710507e-01f, 1.32216707e-01f, -1.50429606e-01f, -1.84596196e-01f, -1.60416625e-02f, 8.19132030e-02f, 3.98791768e-02f, 1.46256266e-02f, -3.05661857e-01f, 2.63927609e-01f,
  2.20708400e-01f, -2.48189241e-01f, 2.48002291e-01f, -7.00950390e-03f, -1.72892436e-01f, 1.19923636e-01f, 4.71816473e-02f, 7.77324587e-02f, 6.02430152e-03f, 1.37753919e-01f,
  -2.61426740e-03f, 2.31024593e-01f, 1.77183017e-01f, 1.94496647e-01f, 1.84280314e-02f, -4.32666801e-02f, 1.48475632e-01f, 8.90635401e-02f, 8.75161961e-02f, -6.32282719e-02f,
  2.31792741e-02f, -4.24401052e-02f, 7.65012428e-02f, -1.27687365e-01f, 1.23322636e-01f, 1.72759015e-02f, 1.47947609e-01f, -1.14716381e-01f, -1.31030649e-01f, 4.21773456e-03f,
  -2.74516251e-02f, -3.81860882e-02f, -2.02458754e-01f, -8.99048224e-02f, -6.75638244e-02f, -1.43302366e-01f, 5.88615946e-02f, 2.40768585e-02f, -2.12378297e-02f, 4.49942462e-02f,
  -1.60031451e-03f, -1.81240350e-01f, -3.22756357e-02f, -5.24581922e-03f, -2.93455124e-02f, -3.96947116e-02f, -6.65001124e-02f, 4.99241501e-02f, -5.34931459e-02f, -9.89497080e-02f,
  -1.19647346e-02f, -2.49509532e-02f, 3.51401344e-02f, 1.55240707e-02f, -3.80853862e-02f, 6.08820766e-02f, -4.06260341e-02f, 4.98619229e-02f, -5.06424271e-02f, 4.76750433e-02f,
  1.64465792e-02f, -6.33101389e-02f, 4.37693968e-02f, 6.82513055e-04f, -2.21840870e-02f, -1.39420375e-01f, -1.19322725e-02f, 8.34127590e-02f, -2.15632981e-03f, 9.48006436e-02f,
  -5.82123287e-02f, -6.31142557e-02f, 1.18743442e-03f, 7.70959035e-02f, 2.09643524e-02f, -1.04935482e-01f, 1.57165807e-04f, 1.46877049e-02f, 2.01202139e-01f, -7.86806084e-03f,
  1.26895353e-01f, 8.17157924e-02f, 5.10671586e-02f, -6.64100200e-02f, 4.46426421e-02f, 1.42008886e-02f, -9.55157280e-02f, 2.54094377e-02f, 3.86061147e-02f, -8.63933191e-02f,
  6.97431862e-02f, -3.66806351e-02f, -3.82454954e-02f, -2.40120739e-02f, -2.54446045e-02f, 1.05438486e-01f, 5.71432188e-02f, -4.28388231e-02f, -9.87315476e-02f, 3.07008158e-02f,
  2.92025763e-03f, -1.75481867e-02f, -1.19762912e-01f, -2.04238780e-02f, -8.68414249e-03f, -3.14869396e-02f, 1.38403932e-02f, -1.80844273e-02f, 1.89111624e-02f, -6.91658035e-02f,
  -1.42390072e-01f, 3.43714327e-01f, -2.80119985e-01f, 8.19296986e-02f, -1.59167796e-01f, 2.10803673e-01f, 3.51250559e-01f, -3.09260059e-02f, 2.22879484e-01f, 4.41584706e-01f,
  7.87511170e-02f, 1.54189780e-01f, 1.71200126e-01f, 3.91350716e-01f, 1.16518110e-01f, 3.35746795e-01f, 2.13836715e-01f, 2.89752513e-01f, 1.01094849e-01f, 3.85266617e-02f,
  1.34255454e-01f, 2.84893394e-01f, -7.82453790e-02f, 5.21689840e-02f, -2.83708028e-03f, -2.43094116e-01f, -7.22787306e-02f, -1.80650949e-01f, 8.47277194e-02f, 2.23117098e-02f,
  3.52497250e-02f, 9.35625285e-02f, -1.78777590e-01f, -1.60499290e-02f, -9.98295844e-02f, -1.14690989e-01f, -1.92177240e-02f, -1.33845642e-01f, -1.56253427e-01f, -3.10586207e-02f,
  5.82646765e-02f, -3.28672379e-02f, 4.87756878e-02f, 5.58863021e-02f, -3.33514065e-02f, -1.22982934e-01f, 3.38970236e-02f, -5.97396009e-02f, 1.57568452e-03f, -1.00460974e-02f,
  2.65082456e-02f, -5.52000180e-02f, -1.70909520e-02f, 6.03049695e-02f, -7.35805556e-02f, 1.33650908e-02f, 1.46047235e-01f, -7.31845126e-02f, 5.42357704e-03f, 3.62122506e-02f,
  -1.07152507e-01f, 1.70140639e-01f, 3.20386849e-02f, -5.95014244e-02f, -8.42744578e-03f, -1.13579392e-01f, 8.98438916e-02f, 2.33650152e-02f, 2.39816122e-02f, 6.34496137e-02f,
  -6.76181167e-02f, -6.72117397e-02f, 8.55898634e-02f, 6.56606928e-02f, 1.48168236e-01f, -1.39019666e-02f, -1.33051008e-01f, 9.25286487e-02f, 3.48706194e-03f, -1.04671553e-01f,
  2.65702605e-03f, 1.46648049e-01f, 1.14235654e-02f, -8.79977718e-02f, 5.44513315e-02f, -2.57010404e-02f, 1.35672912e-01f, -3.40894051e-02f, 4.33321809e-03f, -4.18574028e-02f,
  1.66686699e-01f, 2.50776917e-01f, 1.39282802e-02f, 3.21706943e-03f, -8.12599286e-02f, -5.03397994e-02f, -3.71054001e-03f, -4.02224585e-02f, -4.18179668e-03f, -7.86249060e-03f,
  -3.31967995e-02f, 6.54901266e-02f, -1.96541026e-02f, -5.18352352e-02f, -3.70971523e-02f, 1.91896990e-01f, 1.45385727e-01f, 1.48752043e-02f, -6.88419268e-02f, -2.37677805e-02f,
  -5.04536182e-02f, 4.49911542e-02f, -3.49841714e-02f, 2.64769420e-02f, 6.34423271e-02f, 5.75672090e-02f, 5.82343228e-02f, -6.24170192e-02f, -4.36192155e-02f, 3.50298807e-02f,
  -2.93791384e-01f, 3.10519248e-01f, 4.28521901e-01f, -2.59641141e-01f, 2.30530016e-02f, 1.92095101e-01f, -1.10722885e-01f, 1.50713652e-01f, -1.28652066e-01f, -1.23124449e-02f,
  -1.32897541e-01f, 2.16754869e-01f, 4.35639657e-02f, -1.36725947e-01f, -2.34442040e-01f, -1.47576079e-01f, -1.98878527e-01f, -2.00322598e-01f, -3.33370408e-04f, -5.43247387e-02f,
  -9.50474590e-02f, -2.26750463e-01f, 3.70663330e-02f, 8.86647105e-02f, 6.18896373e-02f, 6.72795773e-02f, -2.29815960e-01f, 1.71848178e-01f, 5.31923287e-02f, 3.84887867e-02f,
  -8.56913850e-02f, 2.23262589e-02f, -8.87195542e-02f, 7.16073886e-02f, -2.64936723e-02f, -3.60081345e-02f, 2.50926707e-02f, -7.92179927e-02f, -1.74688771e-02f, 1.36548956e-03f,
  7.38660097e-02f, 8.97742808e-02f, -6.15278967e-02f, 4.13889624e-02f, 2.16490068e-02f, 1.18194558e-01f, 9.49730724e-02f, 1.18997078e-02f, 2.29022447e-02f, 1.31348297e-01f,
  6.18968904e-02f, 6.31661490e-02f, 5.58963977e-02f, 6.18149564e-02f, 9.36633795e-02f, 5.12677468e-02f, 1.20020774e-03f, 1.03474304e-01f, 1.18112713e-01f, 5.60637452e-02f,
  2.46346965e-02f, -5.26863448e-02f, 1.63193364e-02f, 5.53595498e-02f, -3.58875692e-02f, 1.07701473e-01f, 3.41453291e-02f, -6.33761361e-02f, -3.20531279e-02f, 3.07288580e-02f,
  -3.23657990e-02f, 2.13423297e-02f, -5.37401717e-03f, -2.92152427e-02f, -7.28098005e-02f, -2.64529679e-02f, -4.31260914e-02f, -4.00691256e-02f, -7.35313222e-02f, -8.91135167e-03f,
  -4.71762158e-02f, -2.46298611e-02f, 1.60018802e-02f, -1.91025306e-02f, -2.05538850e-02f, 2.29090173e-02f, 7.73350075e-02f, 1.54685713e-02f, -2.22724229e-02f, -6.47806451e-02f,
  -2.84339041e-01f, -2.18027458e-01f, -1.09814189e-01f, 1.56694297e-02f, -9.95342210e-02f, -1.43695883e-02f, -9.69419852e-02f, -4.69591804e-02f, -6.71623787e-03f, -2.63295472e-02f,
  8.30817819e-02f, -5.63724786e-02f, -4.04656716e-02f, -3.62349749e-02f, -5.71400225e-02f, -2.74733100e-02f, -1.10087715e-01f, -1.40976146e-01f, -1.02785617e-01f, 5.30346818e-02f,
  -1.61179192e-02f, -3.21878679e-02f, 8.11649933e-02f, 5.95479235e-02f, 1.73722990e-02f, 7.87309092e-03f, -1.29623460e-02f, 2.30549183e-02f, -1.87777146e-03f, 5.18875383e-02f,
  -9.13398117e-02f, 1.75942868e-01f, -1.88514024e-01f, 9.97015759e-02f, -1.78515136e-01f, 4.05211926e-01f, 4.48254168e-01f, 3.30783948e-02f, 1.66015267e-01f, 3.09516758e-01f,
  2.18955055e-01f, 8.22911486e-02f, 1.99326560e-01f, 2.68205911e-01f, 1.17984891e-01f, 3.60913306e-01f, 3.01524043e-01f, 2.70908952e-01f, -4.27016690e-02f, 3.31295058e-02f,
  -2.42103692e-02f, 1.94590971e-01f, -4.17544208e-02f, -1.68337300e-01f, -3.10466848e-02f, -3.00808400e-01f, -1.16088793e-01f, -2.29055941e-01f, 3.07898708e-02f, -6.20868569e-03f,
  -1.25514688e-02f, -2.06235535e-02f, -1.17545359e-01f, -1.49282903e-04f, -5.38956970e-02f, -1.26061052e-01f, -5.32702394e-02f, -5.99451102e-02f, -1.23214172e-02f, 2.97977254e-02f,
  1.15218647e-01f, 1.05649857e-02f, -1.24334879e-02f, 1.98315047e-02f, -5.14245592e-02f, -2.26717386e-02f, -5.60284406e-02f, 3.49749327e-02f, -8.53006321e-04f, -3.46141011e-02f,
  -2.30074991e-02f, -1.61616430e-02f, 6.27077697e-03f, 1.24749057e-01f, 5.72607573e-03f, 8.83606896e-02f, 1.44726476e-02f, 1.85427498e-02f, 3.38744894e-02f, -3.59257497e-02f,
  4.33536954e-02f, 1.02628255e-03f, 2.02104189e-02f, 1.08338520e-03f, -9.42090247e-03f, -6.56991228e-02f, 2.14987248e-02f, 2.38742046e-02f, -9.57610607e-02f, -3.11299879e-02f,
  -1.54584507e-03f, -2.32062284e-02f, -1.35445381e-02f, 7.54397810e-02f, -1.83291510e-02f, -2.03266041e-03f, -8.61834958e-02f, 5.20494394e-02f, 1.00904554e-01f, -2.13392358e-02f,
  -3.80019769e-02f, -1.48620447e-02f, -3.35890725e-02f, 1.90400891e-02f, 4.06608284e-02f, -6.93251267e-02f, 2.08566263e-02f, 4.33375463e-02f, 1.57638080e-03f, 2.39330195e-02f,
  2.38362312e-01f, 1.52774289e-01f, 6.55651018e-02f, -2.95306696e-03f, -7.61588961e-02f, -7.66796246e-02f, 1.71101969e-02f, -6.29220381e-02f, 4.21474129e-02f, 6.04910031e-02f,
  2.61077867e-03f, 1.19706793e-02f, 4.48421314e-02f, -1.14878833e-01f, 4.90247682e-02f, 5.73316626e-02f, 2.86981054e-02f, -1.36340782e-02f, 7.23225921e-02f, -1.38298824e-01f,
  -1.01034930e-02f, 3.12914811e-02f, 2.67313961e-02f, 3.12964395e-02f, 6.14483878e-02f, -7.44555844e-03f, -1.92319248e-02f, -1.10620325e-02f, 1.69287920e-02f, 1.01315901e-01f,
  -3.06340277e-01f, -4.03410681e-02f, -6.30679354e-02f, -1.42381221e-01f, -5.20828784e-01f, 2.90103797e-02f, -1.34550989e-01f, -1.54912868e-03f, 1.60997473e-02f, 2.14190051e-01f,
  -2.47125998e-01f, 6.05279319e-02f, 2.53970891e-01f, -1.09982342e-01f, 1.63502365e-01f, 3.16147178e-01f, 4.55202870e-02f, 1.07401945e-01f, -1.37084886e-01f, -9.28354636e-02f,
  -3.53537165e-02f, -1.75290778e-01f, 2.71886010e-02f, -9.04008970e-02f, -3.96912217e-01f, -2.80658692e-01f, -1.12761036e-01f, -3.32694232e-01f, -2.57321745e-01f, -2.77880222e-01f,
  -1.40207469e-01f, -1.25969514e-01f, -6.51936531e-02f, 1.34882465e-01f, -2.33292840e-02f, -1.50365541e-02f, -9.13927779e-02f, -1.52747706e-01f, -1.51646927e-01f, -1.78358853e-02f,
  1.07782744e-01f, -6.07155375e-02f, 1.51365651e-02f, 3.31915282e-02f, -1.11555934e-01f, -9.82723981e-02f, -1.30062317e-02f, 2.60754563e-02f, -5.20259738e-02f, -2.54575573e-02f,
  3.47357690e-02f, 8.37328061e-02f, -1.19398780e-01f, 3.38256285e-02f, -1.53605998e-01f, -2.86804885e-02f, 3.86963710e-02f, -4.35608700e-02f, 7.38699455e-03f, -9.70296040e-02f,
  -5.79939671e-02f, -3.29369586e-03f, 1.08364346e-02f, -6.49914071e-02f, -3.45786959e-02f, 1.80232637e-02f, 1.13923103e-01f, -1.95531026e-02f, 3.86940986e-02f, 1.69944130e-02f,
  -6.22234866e-02f, -6.01171851e-02f, 3.47599983e-02f, 1.03156447e-01f, 8.60587787e-03f, 7.89329186e-02f, -6.27483353e-02f, -9.35901254e-02f, 3.94778512e-02f, 9.08281356e-02f,
  -3.11849825e-02f, 3.99862230e-02f, -3.55556346e-02f, -3.06835417e-02f, 6.96891025e-02f, 4.55402881e-02f, 3.64700817e-02f, 4.71029729e-02f, 4.05656993e-02f, 5.05080931e-02f,
  -5.87339811e-02f, -1.28556073e-01f, -1.56026073e-02f, -1.90739967e-02f, 1.21140257e-01f, 1.78599358e-02f, 2.52281874e-02f, 4.20604786e-03f, -8.29051062e-02f, -5.27765565e-02f,
  2.16500983e-02f, 8.60924572e-02f, 7.46505558e-02f, -1.00281937e-02f, 1.21521585e-01f, 5.75739564e-03f, 2.17370521e-02f, 6.47438988e-02f, -8.13405737e-02f, -4.51876894e-02f,
  1.11610077e-01f, 3.22962031e-02f, 1.47645548e-01f, 3.33853178e-02f, 1.21079266e-01f, 5.50971273e-03f, -3.01047731e-02f, 4.67651300e-02f, -3.93621847e-02f, -2.00385675e-02f,
  1.69232056e-01f, 3.34733725e-01f, 1.47131756e-01f, 1.03810959e-01f, 3.41624804e-02f, -3.23783815e-01f, -1.78778335e-01f, -3.59245948e-02f, -7.28048906e-02f, 1.96307246e-02f,
  -1.68200225e-01f, 2.36748949e-01f, -1.93733677e-01f, -6.98423535e-02f, -4.95500535e-01f, -3.44582260e-01f, -7.66280368e-02f, -1.07199140e-01f, -6.86820969e-02f, 6.14145286e-02f,
  -1.17996849e-01f, -8.63629803e-02f, 1.07120322e-02f, 1.46641701e-01f, 1.78630397e-01f, 1.77764595e-01f, 9.51219574e-02f, 4.33549061e-02f, 1.28523126e-01f, -3.28764692e-02f,
  -4.46163788e-02f, 3.09078731e-02f, 4.41567600e-02f, 7.96736851e-02f, -3.19140963e-02f, 5.28775901e-02f, 7.27301165e-02f, -2.38292641e-03f, 4.20581773e-02f, 8.65059197e-02f,
  7.80185759e-02f, 1.04132546e-02f, 4.61123101e-02f, -7.75016088e-04f, 5.87694868e-02f, 1.11598738e-01f, -2.10154280e-02f, 3.24721411e-02f, -2.94853817e-03f, 5.97026013e-02f,
  -2.82780100e-02f, 4.06599231e-02f, 8.81873742e-02f, 1.76811237e-02f, -4.73133363e-02f, -3.86263877e-02f, 4.42149751e-02f, 1.07222795e-01f, 6.72379062e-02f, 5.72533831e-02f,
  -1.55297806e-03f, 6.97756335e-02f, 1.03122279e-01f, -2.14286838e-02f, 3.18450704e-02f, 4.99112606e-02f, -2.89357565e-02f, -9.27953646e-02f, 4.68780175e-02f, 4.67667766e-02f,
  -7.17288926e-02f, 5.21373823e-02f, -3.61821358e-03f, 1.01325540e-02f, 1.42515302e-02f, 6.31169528e-02f, 5.94742261e-02f, 8.18994194e-02f, -7.54179880e-02f, -3.28892469e-02f,
  3.96111235e-02f, -7.48357847e-02f, 6.90521151e-02f, -2.09487099e-02f, -1.04850382e-01f, -4.16753553e-02f, 1.57758445e-02f, 5.14575057e-02f, -3.13042779e-03f, -3.72161320e-03f,
  -3.82028557e-02f, 1.87108256e-02f, -8.31597298e-02f, 4.32920046e-02f, 2.43783817e-02f, 5.01262248e-02f, -4.39068563e-02f, 2.06121919e-03f, 5.30891446e-03f, 4.34041992e-02f,
  1.30100921e-01f, 7.96740949e-02f, 8.08166107e-04f, 1.08080730e-02f, -4.93243113e-02f, -2.30634352e-03f, 2.45661344e-02f, 1.03759110e-01f, -5.21587022e-03f, 6.91331625e-02f,
  5.40371425e-02f, 5.75474165e-02f, 7.50675723e-02f, 8.03065579e-03f, -3.29294614e-02f, -6.85318932e-03f, 1.51715637e-03f, -1.24225104e-02f, 2.30326448e-02f, -1.88567229e-02f,
  -3.14417630e-02f, 2.75296748e-01f, 1.45575941e-01f, 1.13498926e-01f, 1.30540788e-01f, -8.26963037e-02f, 7.28767514e-02f, 1.91427946e-01f, 3.33682090e-01f, 2.14008428e-02f,
  -6.41153008e-02f, 9.69626009e-02f, 7.82712474e-02f, 1.49222389e-01f, -3.76997232e-01f, -1.02713980e-01f, -1.90655038e-01f, -1.70753133e-02f, 9.62015539e-02f, -1.81784164e-02f,
  -1.17027275e-02f, -2.26116702e-01f, -1.21020935e-01f, -2.84620374e-03f, 8.46033543e-02f, 1.28270194e-01f, -2.87535369e-01f, 1.07090876e-01f, -4.79982160e-02f, -1.13648586e-02f,
  1.30010061e-02f, 3.09649378e-01f, 1.08230568e-01f, 1.42900169e-01f, -8.74134749e-02f, -6.58627450e-02f, -7.17244223e-02f, 2.47655753e-02f, 2.26183813e-02f, 1.06791928e-01f,
  8.25461466e-03f, 8.56413506e-04f, 4.54031006e-02f, 1.47065431e-01f, 1.12120293e-01f, 2.66111474e-02f, 5.30192144e-02f, -5.04778326e-02f, 1.53966054e-01f, 5.19558676e-02f,
  6.51963875e-02f, 7.13256523e-02f, 8.41960683e-03f, -5.46415569e-03f, -8.08298402e-03f, 8.50003436e-02f, 1.12873083e-03f, -2.06308509e-03f, 3.91048715e-02f, 5.99762751e-03f,
  -7.07157031e-02f, -5.09344302e-02f, 1.38548268e-02f, 3.23222615e-02f, 5.41191958e-02f, 7.98306018e-02f, 1.08360007e-01f, -6.56569675e-02f, -3.83556671e-02f, -5.87270409e-02f,
  -4.78150286e-02f, 9.70796868e-02f, 9.84521732e-02f, 6.30666986e-02f, -1.03582563e-02f, 5.43241538e-02f, -7.52850547e-02f, 6.21874034e-02f, -3.99759971e-02f, -5.81910871e-02f,
  1.83784571e-02f, -1.10129610e-01f, 8.55906084e-02f, 5.27736507e-02f, 1.02978675e-02f, 7.51683116e-02f, 5.00209928e-02f, 1.08556002e-01f, -3.14304605e-02f, -9.86755118e-02f,
  -2.95424998e-01f, -9.32901874e-02f, -8.03077891e-02f, 7.78136179e-02f, -2.03574281e-02f, -6.40256777e-02f, -1.73559636e-02f, 5.56065403e-02f, -5.39411418e-02f, 3.37787680e-02f,
  -5.84017374e-02f, 6.58407761e-03f, -1.05718896e-01f, 4.00178097e-02f, -9.50217992e-02f, -6.97030500e-02f, -4.57192026e-03f, -1.18284058e-02f, -1.39555991e-01f, -6.85646683e-02f,
  -2.09672395e-02f, -5.13165221e-02f, -5.35510257e-02f, -1.95747670e-02f, -1.86232403e-02f, -6.65853396e-02f, 7.93333258e-03f, 1.59465745e-02f, -7.28604048e-02f, -6.16295114e-02f,
  2.37997130e-01f, -4.75886948e-02f, -2.72554487e-01f, 3.62370126e-02f, -1.08957998e-01f, -1.08052842e-01f, -2.57524878e-01f, -1.03967376e-02f, -1.65759176e-01f, 1.22819711e-02f,
  5.64329624e-02f, 1.14158377e-01f, -2.50469804e-01f, 2.00934902e-01f, 4.10612702e-01f, -1.55649036e-01f, 2.89388746e-01f, 1.93342075e-01f, -1.92549787e-02f, 1.63651660e-01f,
  3.57691139e-01f, 4.11493957e-01f, -2.05006264e-02f, 3.29912782e-01f, 1.93565845e-01f, 8.91655758e-02f, 2.41488948e-01f, -8.41045901e-02f, 2.62324870e-01f, 1.15653224e-01f,
  -2.20349897e-02f, -4.90049906e-02f, -8.64453241e-02f, 1.40095800e-02f, -7.99032003e-02f, -7.32890517e-02f, -4.42145253e-03f, -5.77821583e-02f, -7.06942081e-02f, -4.50493731e-02f,
  -4.32958081e-02f, 6.63426742e-02f, 4.41327877e-02f, 3.07763685e-02f, 7.24333003e-02f, 1.56426691e-02f, 3.38160656e-02f, -1.18170694e-01f, -5.42431325e-02f, 4.31326404e-02f,
  -3.92172784e-02f, -8.61457884e-02f, -1.01257185e-03f, -7.71325156e-02f, -8.41271784e-03f, 3.69258113e-02f, -6.17372245e-02f, -2.44178884e-02f, 1.11614754e-05f, -6.15019687e-02f,
  1.14240378e-01f, -2.08770800e-02f, -6.13107570e-02f, -1.31221220e-01f, -1.37573108e-02f, -5.24017587e-02f, 4.35720459e-02f, -8.80029649e-02f, 4.87501770e-02f, -3.49602252e-02f,
  -9.28663611e-02f, -1.35943830e-01f, 9.89876986e-02f, -5.43497643e-03f, -1.19039565e-02f, -1.44361220e-02f, 7.41774263e-03f, 2.05535088e-02f, -3.08163743e-02f, -7.39188418e-02f,
  -7.28312954e-02f, 1.49787441e-01f, 3.94097492e-02f, 3.49083245e-02f, 1.22774327e-02f, 1.28210420e-02f, 1.12318315e-01f, 3.55838276e-02f, -1.24071136e-01f, -4.59171347e-02f,
  5.42325824e-02f, 2.38940120e-01f, -2.59149149e-02f, -2.58952077e-03f, -5.11860624e-02f, 9.12157968e-02f, 9.89104584e-02f, 1.18322074e-01f, 6.43754750e-03f, -2.24255640e-02f,
  9.97934267e-02f, -4.95729223e-02f, 3.36878151e-02f, -2.59313434e-02f, -7.32262060e-03f, 1.24381758e-01f, 7.59260803e-02f, -1.21070653e-01f, -8.33357405e-03f, 1.39920890e-01f,
  5.35571352e-02f, -5.81734851e-02f, 9.61717069e-02f, -1.96068078e-01f, 4.92501706e-02f, 4.08093818e-02f, 6.42290562e-02f, 5.07705770e-02f, 8.30763206e-02f, -1.08384080e-01f,
  1.11119643e-01f, -3.19680214e-01f, 2.25496799e-01f, 1.56074956e-01f, 1.68620452e-01f, 3.73540185e-02f, 6.60538897e-02f, 1.08013697e-01f, -1.16293533e-02f, -3.76020223e-01f,
  -4.56933752e-02f, -1.08727217e-01f, -1.44668072e-01f, -4.21152152e-02f, 2.69698143e-01f, -5.32171456e-03f, 1.16810575e-01f, -4.68427874e-03f, 2.46019706e-01f, 2.09151894e-01f,
  2.58443892e-01f, 7.85919949e-02f, 3.33132893e-01f, 1.13869153e-01f, 9.79406387e-02f, 9.73289087e-03f, 2.71208980e-03f, 1.54439062e-01f, -5.23296092e-03f, -3.24800350e-02f,
  -1.17665730e-01f, 4.95397039e-02f, -2.56171376e-02f, -5.17362356e-02f, -6.95325732e-02f, -7.80311227e-02f, -1.74133219e-02f, 5.16655296e-02f, 6.54458925e-02f, 6.07525408e-02f,
  -3.28451954e-02f, 6.53646588e-02f, 2.68087294e-02f, -9.20496241e-04f, -1.49932094e-02f, 5.28422780e-02f, 4.08317074e-02f, -3.68462987e-02f, 4.39668819e-02f, 6.55152947e-02f,
  1.76658228e-01f, -5.05070351e-02f, 6.77779689e-02f, 1.05162356e-02f, 1.40576795e-01f, -3.17950286e-02f, 7.53517672e-02f, 3.13367024e-02f, -7.78213814e-02f, -5.62001066e-03f,
  3.13163921e-02f, 8.52187723e-02f, -8.10555462e-03f, 2.35288180e-02f, -1.54269831e-02f, -2.74049062e-02f, -1.33645842e-02f, 3.97894951e-03f, -6.38462007e-02f, -1.17115684e-01f,
  -4.67477329e-02f, 6.92165568e-02f, 8.96325260e-02f, 1.23619828e-02f, -3.90593782e-02f, 8.54532197e-02f, 2.17478052e-02f, -2.22178064e-02f, -6.73820972e-02f, -2.27074660e-02f,
  -5.26366802e-03f, -4.97493967e-02f, -3.27324979e-02f, 1.62625685e-01f, 3.01938448e-02f, 1.90231856e-02f, -3.03968624e-03f, -3.96622829e-02f, 9.58641768e-02f, 2.33222675e-02f,
  -3.54846686e-01f, -1.82825118e-01f, -5.94201721e-02f, -1.03795104e-01f, -9.75816399e-02f, -6.59991503e-02f, 3.65643054e-02f, -1.88124634e-03f, -1.07070729e-01f, 7.86595941e-02f,
  -1.64881838e-03f, 4.88853641e-02f, -1.84730202e-01f, -4.79935110e-03f, -1.72207458e-03f, 3.48866470e-02f, 8.46342184e-03f, -1.56102762e-01f, -6.79476857e-02f, -3.51493992e-02f,
  -6.60738200e-02f, -3.15727517e-02f, 8.39787051e-02f, 8.86156037e-02f, 1.15813695e-01f, -1.65556818e-02f, -1.12594636e-02f, -3.90371755e-02f, 7.49730691e-02f, 1.15156164e-02f,
  -3.62231322e-02f, 1.99226424e-01f, 3.61869961e-01f, 2.29978263e-01f, -2.55684286e-01f, -2.61545807e-01f, -1.65732235e-01f, 1.36069320e-02f, -2.04791561e-01f, -9.41245630e-02f,
  -1.10939890e-01f, 2.26422906e-01f, -2.60544289e-02f, 5.84235191e-02f, 3.43668699e-01f, -3.41508947e-02f, 8.35056826e-02f, 4.93906392e-03f, 2.07632631e-01f, 3.46860856e-01f,
  5.54611571e-02f, -1.61191136e-01f, 3.66491199e-01f, 5.95721006e-02f, 2.44659454e-01f, 3.25573951e-01f, 1.37664586e-01f, 1.04963534e-01f, 1.04439430e-01f, 1.03901587e-02f,
  -5.35193384e-02f, -4.04785089e-02f, 8.50571021e-02f, -1.80264726e-01f, 9.80826747e-03f, -7.35996440e-02f, -5.95744066e-02f, -7.97900259e-02f, -1.06547796e-03f, -1.34953046e-02f,
  -6.91019446e-02f, -9.00939405e-02f, -1.06366649e-02f, 4.22235169e-02f, -1.87780440e-01f, 8.93786326e-02f, -5.95415533e-02f, 6.61724433e-02f, -1.64869875e-02f, 4.96945232e-02f,
  8.48490894e-02f, -9.62802097e-02f, -8.52686726e-03f, -2.06586020e-03f, -9.15620290e-03f, -9.70668942e-02f, -7.84516986e-03f, 3.08084730e-02f, 1.56843825e-03f, 5.64982034e-02f,
  -1.91067383e-01f, -1.32444471e-01f, -9.66721475e-02f, 1.58220083e-01f, 2.85048969e-02f, -4.12888899e-02f, -6.44985437e-02f, -1.90056954e-02f, 5.07805906e-02f, -1.20823689e-01f,
  8.63695070e-02f, 5.38741425e-02f, -1.17216386e-01f, -1.09151147e-01f, 1.28012034e-03f, -1.55196646e-02f, 1.94439180e-02f, 7.70581737e-02f, 2.29521804e-02f, 5.13865724e-02f,
  -8.83686244e-02f, -7.42832348e-02f, 5.68235256e-02f, -1.26184775e-02f, -1.48002043e-01f, -8.58922079e-02f, 4.41076346e-02f, 3.40375528e-02f, 6.15021884e-02f, 2.18057811e-01f,
  5.14755100e-02f, 2.20944554e-01f, -1.20514948e-02f, -1.27072170e-01f, 2.86741611e-02f, 9.97143239e-02f, -9.79185775e-02f, -9.10467729e-02f, 4.99452511e-03f, 1.46607701e-02f,
  -1.14218906e-01f, -7.32909888e-02f, -7.59198517e-02f, -9.70288925e-03f, 2.07868572e-02f, -1.41875809e-02f, -1.54736768e-02f, 6.94716163e-03f, 2.69531040e-03f, 1.20192423e-01f,
  1.13929078e-01f, -1.84806466e-01f, 5.40480725e-02f, -3.74712758e-02f, -1.18395038e-01f, -8.62864703e-02f, 7.57608339e-02f, -5.42833023e-02f, -9.09975637e-03f, 7.20935455e-03f,
  -3.24157238e-01f, 2.36753657e-01f, 2.41701975e-01f, 3.32922190e-01f, -4.09848511e-01f, -4.17425543e-01f, -2.47890130e-03f, 1.51553180e-03f, 7.31912777e-02f, 1.38134837e-01f,
  4.73210178e-02f, 5.22034727e-02f, 1.79624513e-01f, 1.80529371e-01f, -3.00873369e-01f, 9.65855047e-02f, 2.19368756e-01f, 3.07899266e-02f, -1.27541512e-01f, 1.22424796e-01f,
  8.57258514e-02f, 2.41511222e-02f, 2.76796341e-01f, -1.57565325e-01f, 2.89853942e-02f, 1.35134995e-01f, 1.70793414e-01f, -5.38795907e-03f, 9.71919224e-02f, -2.02361137e-01f,
  -1.73222385e-02f, 1.41412422e-01f, 1.27707347e-01f, 3.48740704e-02f, 1.45949438e-01f, -3.10551301e-02f, 4.60880585e-02f, -1.91536061e-02f, -3.67835984e-02f, 7.46672004e-02f,
  -7.37760365e-02f, -4.10564095e-02f, 3.74453291e-02f, -1.56064674e-01f, -1.12761624e-01f, 2.18735542e-03f, 1.16781173e-02f, -7.05951005e-02f, 1.65705313e-03f, 1.30957011e-02f,
  1.40234008e-01f, 1.23454466e-01f, 1.39250576e-01f, 2.29035243e-01f, 4.10678424e-02f, 3.56850252e-02f, -1.49044394e-01f, 7.06824884e-02f, 3.89495529e-02f, -2.22693868e-02f,
  1.69872362e-02f, 1.24443313e-02f, 5.41002974e-02f, -6.54607341e-02f, -2.02913165e-01f, 4.86648008e-02f, -6.61014486e-03f, -3.79245467e-02f, -1.41693234e-01f, 2.32076664e-02f,
  3.73784937e-02f, 3.34394835e-02f, -9.22811776e-02f, -9.11978632e-02f, -8.09894726e-02f, 2.86572054e-02f, -1.16927095e-01f, -6.98572993e-02f, 1.38119370e-01f, 3.43370326e-02f,
  9.02032200e-03f, -1.33800507e-01f, 2.97630019e-02f, 1.22487284e-01f, 3.41191478e-02f, -2.98820641e-02f, -1.54361073e-02f, -2.14847475e-02f, 1.65487938e-02f, 1.41080068e-02f,
  1.47766545e-01f, 1.62115365e-01f, 1.42125949e-01f, -1.53310494e-02f, 1.05939075e-01f, -5.97918108e-02f, -5.19424006e-02f, 8.52034800e-03f, 8.78311098e-02f, -1.12719290e-01f,
  -2.03904342e-02f, -2.11138297e-02f, 9.16083716e-03f, -7.22477585e-02f, 5.76241352e-02f, 3.34101729e-02f, 1.12986423e-01f, 3.51156183e-02f, 1.72126532e-01f, 8.56626499e-03f,
  2.60554999e-02f, -2.84290742e-02f, 1.33464694e-01f, 2.83887461e-02f, 5.22678122e-02f, 1.24343731e-01f, -2.63256460e-01f, 4.69122976e-02f, 1.08414991e-02f, 1.35560200e-01f,
  5.48658632e-02f, -8.59172344e-02f, -6.93308515e-03f, -2.19252750e-01f, 4.89390977e-02f, -7.86660612e-02f, -2.22637877e-01f, -1.46835208e-01f, -1.17567167e-01f, -1.32798344e-01f,
  -1.02109931e-01f, -6.97166920e-02f, -9.09555983e-03f, -7.74035081e-02f, 2.19089255e-01f, 2.06598997e-01f, -2.10745737e-01f, -1.82348281e-01f, 8.07657987e-02f, -1.27710968e-01f,
  -4.97440919e-02f, -8.42254236e-02f, 6.70375600e-02f, -1.05629593e-01f, -1.93642646e-01f, -1.08552217e-01f, -1.69782080e-02f, 1.14119546e-02f, -1.15444869e-01f, -6.30820468e-02f,
  3.57092246e-02f, 9.81165692e-02f, 2.57088076e-02f, -1.19126728e-02f, -5.66055672e-03f, -6.39276356e-02f, -4.89797741e-02f, 9.57614705e-02f, 2.23986264e-02f, 6.33618981e-03f,
  -1.09344840e-01f, 2.40448620e-02f, -1.22752532e-01f, 9.61093605e-02f, -1.47577569e-01f, -4.73029399e-03f, -3.32675949e-02f, 1.50421951e-02f, -1.92012433e-02f, 4.45301384e-02f,
  -2.92429663e-02f, 5.37588932e-02f, -9.36126485e-02f, -4.63844351e-02f, 9.65671352e-05f, -1.16787523e-01f, 1.79705068e-01f, 3.69374752e-02f, 1.77364163e-02f, -2.53843572e-02f,
  -1.00890379e-02f, 6.80587664e-02f, 1.73845887e-01f, 8.61807019e-02f, 7.24524483e-02f, 2.47711428e-02f, 5.80728473e-03f, 1.05616666e-01f, -2.15606354e-02f, 2.53946614e-02f,
  2.33108979e-02f, -6.30484428e-03f, 4.23498601e-02f, 2.04446781e-02f, -4.09929492e-02f, 7.69979581e-02f, 1.34927318e-01f, -2.27262471e-02f, -9.55603495e-02f, -4.29580314e-03f,
  2.79152878e-02f, 2.80583221e-02f, 3.93895395e-02f, -4.56926711e-02f, 3.00584058e-03f, -4.17360803e-03f, 1.00246714e-02f, 1.17014349e-02f, -1.32915080e-02f, -7.56605640e-02f,
  1.44832889e-02f, -1.00997366e-01f, -5.43338321e-02f, -3.91441472e-02f, -4.34166985e-03f, 2.12399941e-02f, -2.18338110e-02f, -1.34148166e-01f, -1.21584117e-01f, 1.07712382e-02f,
  -1.19554333e-01f, -2.19434258e-02f, -3.26108597e-02f, -6.74513876e-02f, -6.68643713e-02f, -5.83973229e-02f, -9.62621421e-02f, -6.03578836e-02f, -8.44695345e-02f, -5.37339859e-02f,
  -8.26906785e-02f, 7.28806481e-02f, -7.34818131e-02f, 6.01450540e-02f, -5.68137355e-02f, -1.30585134e-01f, 1.43580467e-01f, -7.26741925e-02f, -1.25852507e-02f, -7.37668294e-03f,
  6.81214035e-02f, 2.69316081e-02f, 3.25986743e-02f, 2.02239648e-01f, -1.41527116e-01f, -1.85172260e-01f, -6.92183748e-02f, -1.66138619e-01f, 4.72096622e-01f, -1.08682282e-01f,
  -2.00137123e-01f, 2.71072656e-01f, -9.79914442e-02f, -8.47823247e-02f, 6.00898564e-02f, 2.28831753e-01f, -5.64434007e-02f, 1.12251475e-01f, 2.20234975e-01f, -4.00073491e-02f,
  7.33984783e-02f, -2.93355048e-01f, -1.60313740e-01f, -3.29542249e-01f, -3.58647764e-01f, 4.29651998e-02f, -2.17459828e-01f, -4.83119972e-02f, -1.73557773e-01f, -1.23005345e-01f,
  -5.18822484e-02f, 1.78807050e-01f, 4.67666015e-02f, 9.46899652e-02f, 9.16510448e-02f, -1.29159421e-01f, -5.40642403e-02f, -2.06638891e-02f, 1.76914915e-01f, 5.26070930e-02f,
  5.83612956e-02f, -3.27242613e-02f, 5.94481044e-02f, -1.18749030e-01f, 1.09336823e-01f, 5.43065965e-02f, 1.65711552e-01f, 5.26826456e-02f, 4.21394482e-02f, -1.36200652e-01f,
  3.20005119e-02f, 1.43055603e-01f, 5.94109483e-02f, 3.09723586e-01f, 1.53200477e-01f, 1.68976560e-01f, 1.30672753e-02f, 9.06150714e-02f, 1.65259853e-01f, 1.59385875e-01f,
  -5.22180609e-02f, 6.40466660e-02f, -5.50513417e-02f, -5.46454228e-02f, -1.15064513e-02f, -2.87043396e-03f, -3.35488878e-02f, -4.32624519e-02f, 1.10378616e-01f, 6.86306506e-02f,
  6.77985698e-02f, 5.68421222e-02f, 6.75752461e-02f, 8.53988007e-02f, 1.63072385e-02f, 1.26119796e-02f, 2.43874509e-02f, 5.73619455e-02f, 8.82619545e-02f, -4.11784910e-02f,
  -1.55445179e-02f, -1.07910270e-02f, 2.90620010e-02f, -1.51225016e-01f, -9.69615728e-02f, 9.98400897e-02f, -7.05486014e-02f, -1.43894285e-01f, -1.81863382e-02f, -7.15648234e-02f,
  1.88841432e-01f, 1.06294796e-01f, 1.00650057e-01f, 9.12544802e-02f, 8.06882530e-02f, -1.16047822e-01f, -6.37946278e-02f, -1.07589485e-02f, 1.51496097e-01f, -4.40262370e-02f,
  -4.25057523e-02f, -2.68212287e-03f, 1.38508677e-01f, -9.18780565e-02f, 1.15774304e-01f, -1.58221290e-01f, 1.97433099e-01f, 2.04221413e-01f, 1.18559197e-01f, -2.78462525e-02f,
  -8.53040293e-02f, 1.21673331e-01f, 1.00966595e-01f, 1.03501864e-01f, 2.22040340e-02f, 1.36882290e-01f, -3.58268456e-03f, 1.74908452e-02f, 3.13730165e-02f, 1.43356383e-01f,
  -4.36158404e-02f, 3.13887805e-01f, -7.52063096e-02f, -1.56551987e-01f, -2.99792048e-02f, -3.53698641e-01f, -2.16931373e-01f, -9.37311724e-02f, 7.57087767e-02f, 1.49974570e-01f,
  -1.88768223e-01f, 2.61537194e-01f, 5.60959429e-02f, -9.95575637e-02f, -3.38056594e-01f, 2.13881135e-02f, -2.91450471e-01f, -5.29976189e-02f, 1.17235653e-01f, -1.62016660e-01f,
  -1.51795462e-01f, -2.04000920e-01f, -1.24350220e-01f, -1.08603314e-01f, -9.96256992e-02f, 8.65531936e-02f, -3.94720063e-02f, 4.39962000e-02f, -1.13973767e-01f, 7.48253753e-03f,
  -4.07813862e-02f, 1.91363692e-02f, 2.29958724e-02f, -3.87919918e-02f, -1.79900229e-01f, -2.74373218e-02f, -1.96653903e-02f, 4.94957045e-02f, 7.86461588e-03f, -3.48062254e-02f,
  3.76668088e-02f, 3.69157083e-03f, -5.37226500e-04f, 3.14831920e-02f, 6.01925030e-02f, 2.03609876e-02f, 1.19521115e-02f, -1.55174872e-02f, 2.22655851e-02f, 2.00606659e-02f,
  -6.13678759e-03f, -3.87910614e-03f, -1.13089591e-01f, 7.65743107e-03f, -3.13217901e-02f, 1.04264114e-02f, -9.64447483e-02f, -9.08846594e-03f, -5.90644665e-02f, -4.98147234e-02f,
  -3.00770588e-02f, -7.18113631e-02f, -5.43447249e-02f, 2.15575937e-02f, -5.67098074e-02f, -7.81980716e-03f, 1.92420129e-02f, 6.02355599e-02f, 5.27059957e-02f, -7.53751432e-04f,
  -1.80481039e-02f, 8.13735556e-03f, -5.80532337e-03f, -8.75491872e-02f, -6.60827383e-02f, -1.37007348e-02f, -2.90120561e-02f, -1.63132921e-02f, -1.14952296e-01f, 3.01025677e-02f,
  3.22151557e-02f, -7.31809214e-02f, -2.08293311e-02f, -2.56188456e-02f, 1.90269537e-02f, 2.13671494e-02f, -1.93291623e-02f, 9.58926789e-03f, 5.06252497e-02f, -9.32820812e-02f,
  -2.02368930e-01f, -2.56603599e-01f, 2.61185337e-02f, 1.91965494e-02f, 3.72077674e-02f, 1.46966781e-02f, 3.50386612e-02f, 8.77730101e-02f, -9.74193029e-03f, -9.85995680e-02f,
  -3.49641815e-02f, -7.49357939e-02f, -1.46285474e-01f, 4.82239127e-02f, -3.30357347e-03f, -2.28159241e-02f, 2.30928715e-02f, 7.75871947e-02f, -1.13320552e-01f, -1.52123393e-02f,
  -3.40625644e-02f, -2.92687956e-02f, -1.22329425e-02f, -4.66218293e-02f, -5.40518388e-03f, -9.66164004e-03f, -2.80570760e-02f, 5.94878383e-02f, -2.34196223e-02f, 2.61136517e-02f,
  7.85431266e-02f, 2.40888104e-01f, 1.33945808e-01f, 2.02269882e-01f, -1.89080223e-01f, -2.60229260e-01f, -1.85937792e-01f, 7.55368471e-02f, -1.47149554e-02f, 1.44940391e-02f,
  -1.18823545e-02f, 8.25609788e-02f, 6.69877380e-02f, -3.11318543e-02f, 8.55661109e-02f, 6.32646233e-02f, 1.39788046e-01f, -1.47495881e-01f, 8.36426094e-02f, 1.69200212e-01f,
  9.31937546e-02f, 6.43893182e-02f, 1.67216375e-01f, 2.28611343e-02f, -4.34850017e-03f, 6.03891388e-02f, 1.56373218e-01f, -7.85410479e-02f, -6.16519041e-02f, 3.41867330e-03f,
  -1.54243633e-01f, 1.57937124e-01f, -5.87154701e-02f, 1.45673258e-02f, 4.49131690e-02f, -1.07121527e-01f, -1.95557311e-01f, 1.91323776e-02f, 2.87597496e-02f, -7.54857250e-03f,
  1.12550549e-01f, -6.93249479e-02f, 4.96671982e-02f, -1.03061805e-02f, -7.93905407e-02f, 5.20528182e-02f, 2.39969138e-02f, -6.25630617e-02f, 5.63482866e-02f, 4.34099250e-02f,
  3.93607877e-02f, 1.03207445e-02f, 8.53039473e-02f, 1.09183162e-01f, 1.30568802e-01f, 1.02230674e-02f, -1.90234203e-02f, 2.57108435e-02f, 1.33603111e-01f, 1.11792870e-01f,
  4.71216999e-02f, -1.05374388e-01f, -8.29421158e-04f, -1.11263551e-01f, 4.21298705e-02f, -2.25196946e-02f, -1.46198776e-02f, -1.01905927e-01f, -7.07467943e-02f, -6.13463297e-03f,
  -9.21984785e-04f, 2.23931726e-02f, -2.73858607e-02f, -5.37745804e-02f, 8.04734528e-02f, -2.83916444e-02f, 6.16534380e-04f, -3.82889211e-02f, -2.05564220e-02f, -2.42735352e-02f,
  4.21438292e-02f, -3.54723670e-02f, -1.24713005e-02f, -4.53053191e-02f, -1.17636226e-01f, 3.82015258e-02f, 7.56166801e-02f, 2.89505627e-02f, -6.12478331e-02f, 9.94569585e-02f,
  1.09138757e-01f, 3.28290761e-01f, 3.31468247e-02f, -3.02036908e-02f, -3.07987910e-02f, 1.24802969e-01f, -3.77399065e-02f, 4.31238599e-02f, 1.66217193e-01f, 3.28983441e-02f,
  1.53768331e-01f, -6.05039708e-02f, 1.46003882e-03f, -9.40645039e-02f, 6.18420262e-03f, 1.44153774e-01f, 3.29348966e-02f, 1.01594843e-01f, 1.85743570e-01f, 1.18343145e-01f,
  2.17416734e-02f, 4.60695252e-02f, 1.26626790e-01f, -5.08518592e-02f, 1.11220881e-01f, 1.10808231e-01f, 5.91683015e-03f, 2.86344462e-03f, 1.16269365e-01f, 1.08773082e-01f,
  -9.28787738e-02f, -2.43963674e-01f, -9.16313380e-04f, 7.53360540e-02f, 8.83220360e-02f, -1.21693753e-01f, -2.62920201e-01f, -1.72770947e-01f, -3.03323209e-01f, -2.86567271e-01f,
  -8.34913626e-02f, 5.87193258e-02f, -1.94259882e-01f, 2.13346615e-01f, 3.82596940e-01f, 1.86001603e-02f, 1.71888545e-01f, 5.93666323e-02f, 2.47694068e-02f, -2.40115654e-02f,
  5.92332042e-04f, 8.82342234e-02f, 2.50086516e-01f, 1.46633834e-01f, 9.61626843e-02f, 1.36802062e-01f, 2.22970963e-01f, 8.15810561e-02f, 2.04163283e-01f, 1.84475675e-01f,
  2.70439330e-02f, 4.25035991e-02f, -3.38602588e-02f, 1.73003860e-02f, -3.36326659e-02f, -5.18910848e-02f, 3.87679711e-02f, 1.41279459e-01f, 1.03358496e-02f, 4.48532999e-02f,
  1.07507907e-01f, 3.67238675e-03f, 1.49108037e-01f, -5.19273430e-02f, -1.54311359e-01f, 3.72860301e-03f, -1.11366689e-01f, -6.08992949e-02f, -9.74621177e-02f, 2.60282662e-02f,
  -1.49842829e-01f, 3.52562964e-02f, -3.29152569e-02f, 9.53854341e-03f, -1.09447703e-01f, -1.17912702e-01f, 9.56513081e-03f, 4.76740859e-02f, 4.15080413e-02f, -4.34371382e-02f,
  7.78679177e-02f, -1.25163883e-01f, 1.47850448e-02f, -1.67883858e-02f, -1.34093044e-02f, 3.29294452e-03f, 2.48354767e-02f, 3.04704858e-03f, -7.81946406e-02f, 2.94837430e-02f,
  1.18032200e-02f, 9.69881862e-02f, -4.29927632e-02f, -8.25035125e-02f, -3.15490216e-02f, 9.83726308e-02f, 1.16091281e-01f, -4.37174551e-02f, -1.56146690e-01f, 9.30616558e-02f,
  -1.58230271e-02f, -3.66876908e-02f, -2.04098802e-02f, 7.74523383e-03f, -1.13076240e-01f, -8.01846087e-02f, -6.48482367e-02f, -2.74450295e-02f, 1.01286665e-01f, -2.12329477e-02f,
  7.09379762e-02f, 9.67088193e-02f, 2.40486860e-03f, -6.69052079e-02f, 3.78484875e-02f, 4.80009615e-02f, 4.38061059e-02f, -4.30581421e-02f, 7.57743344e-02f, -8.82579107e-03f,
  7.46572614e-02f, 3.14225606e-03f, -3.74138122e-03f, -1.20059296e-03f, 1.20373972e-01f, -1.12266883e-01f, 4.80142701e-03f, 7.22552091e-03f, -1.17095523e-02f, 8.12766626e-02f,
  -4.98129055e-02f, 1.34781133e-02f, -4.02692035e-02f, -1.92444015e-03f, -3.99639308e-02f, -9.55833048e-02f, 1.04971670e-01f, -2.80310269e-02f, 3.52384560e-02f, 3.75692099e-02f,
  -3.43099654e-01f, -2.80880392e-01f, 1.09340273e-01f, 8.10135156e-02f, -3.28962713e-01f, 9.48191807e-02f, 3.29443485e-01f, -2.72975445e-01f, -1.13229752e-01f, 8.43763053e-02f,
  -1.40114620e-01f, -2.59177829e-03f, 2.81238347e-01f, 3.76461707e-02f, 3.06920469e-01f, 3.08482170e-01f, 1.27689749e-01f, 2.48786256e-01f, -1.36661366e-01f, -1.45677447e-01f,
  -1.94554806e-01f, -1.59803420e-01f, 1.08522423e-01f, -1.64038941e-01f, -2.65730411e-01f, -1.56316712e-01f, -4.78564687e-02f, -5.27648954e-03f, -1.21352285e-01f, -1.00666270e-01f,
  -1.72037140e-01f, -2.18380988e-01f, -9.43072811e-02f, -5.44752441e-02f, -7.56059960e-02f, 5.96990734e-02f, 2.31875069e-02f, 1.15181133e-01f, 4.45902944e-02f, -2.94052307e-02f,
  1.72896199e-02f, 1.09637761e-02f, -9.95942801e-02f, 8.99541155e-02f, -1.05266660e-01f, -1.66908473e-01f, -3.57774347e-02f, -1.32561088e-01f, -1.40008092e-01f, -1.80495158e-02f,
  -2.68819220e-02f, -8.66133869e-02f, -3.13899294e-02f, 2.00105570e-02f, -1.32226244e-01f, -4.43374775e-02f, 6.55836537e-02f, -2.19487008e-02f, -2.68501993e-02f, -7.91650116e-02f,
  7.79710710e-04f, -3.98884602e-02f, -3.33385468e-02f, 6.39416128e-02f, 1.39182340e-02f, 6.59695268e-02f, 1.05472371e-01f, 3.04043181e-02f, 2.35906038e-02f, -8.82269293e-02f,
  4.95800488e-02f, -1.35045582e-02f, -4.62405346e-02f, 3.02396528e-02f, -1.42240124e-02f, 5.36352061e-02f, 4.05005962e-02f, -2.98939720e-02f, 4.69144918e-02f, 2.69046836e-02f,
  5.41260019e-02f, 3.81099246e-02f, -2.14778539e-02f, 7.49764591e-02f, 1.98436733e-02f, -6.51220139e-03f, 1.23440875e-02f, 8.75087306e-02f, -4.41323221e-02f, -2.68708169e-02f,
  -1.83051914e-01f, -1.63016051e-01f, -1.31996736e-01f, -6.11055754e-02f, 5.31617552e-02f, -6.70751557e-02f, 4.12572846e-02f, -1.89760905e-02f, 1.76750973e-03f, 1.08325155e-02f,
  -1.70733295e-02f, 6.32693097e-02f, -4.60010655e-02f, 8.68676454e-02f, 5.28248698e-02f, -3.77333052e-02f, 6.33088425e-02f, -1.10117940e-03f, -7.91750327e-02f, -6.97628856e-02f,
  9.64700431e-03f, -1.50051937e-02f, 1.13719821e-01f, -1.08642198e-01f, -2.00379454e-02f, 2.96891201e-02f, -4.31930870e-02f, -1.15267202e-01f, -3.30212875e-03f, 9.65959684e-04f,
  -1.42894804e-01f, -2.09534138e-01f, -4.14191186e-01f, -2.22906902e-01f, 1.74045488e-01f, -3.04759890e-01f, -2.57940143e-01f, -3.84037495e-02f, 3.18814181e-02f, 1.96487486e-01f,
  -2.44203266e-02f, -1.55678391e-01f, 8.79905298e-02f, -3.33092630e-01f, -4.10043597e-01f, -2.08984658e-01f, -3.93118054e-01f, -1.97205335e-01f, 3.12039051e-02f, -5.74930049e-02f,
  -1.01495199e-01f, -6.72311187e-02f, -2.51703262e-01f, 2.94693649e-01f, -1.32709324e-01f, 6.14545569e-02f, 1.89736113e-01f, 1.75527215e-01f, -8.71140435e-02f, -5.80943190e-03f,
  -7.92236626e-02f, 2.96527445e-02f, -1.57702625e-01f, -1.78141799e-02f, -4.90019172e-02f, 1.49989545e-01f, -1.17355593e-01f, -6.23640195e-02f, 7.25204200e-02f, 3.05529777e-03f,
  5.37935784e-03f, 1.08031973e-01f, -3.53017636e-02f, 9.93362144e-02f, 1.02261886e-01f, 5.52698560e-02f, -1.54365180e-02f, -8.19908902e-02f, 5.79067022e-02f, -5.60460538e-02f,
  -5.40651269e-02f, 8.75531584e-02f, 1.20575475e-02f, -4.44316014e-04f, -1.45203974e-02f, -2.32393872e-02f, -1.99022796e-02f, -1.23082116e-01f, 2.60219891e-02f, 2.01545097e-02f,
  -2.69696079e-02f, 6.33862391e-02f, 5.76744489e-02f, 2.69973893e-02f, 3.58963571e-02f, -2.18731742e-02f, 6.26098663e-02f, 3.27415429e-02f, 2.10923515e-02f, 8.63319449e-03f,
  7.11611882e-02f, -7.48797655e-02f, 5.02145849e-02f, -1.64182708e-02f, -2.72208154e-02f, 4.09063473e-02f, 6.40513450e-02f, -6.83066174e-02f, -1.40812173e-01f, -1.71557218e-01f,
  6.26442879e-02f, -3.23277488e-02f, -2.89017744e-02f, 3.07738036e-02f, -1.27604559e-01f, 1.71853289e-01f, 1.38786986e-01f, -5.05633093e-02f, -3.72815244e-02f, -6.45004306e-03f,
  -7.11073503e-02f, 1.25622958e-01f, -7.52054602e-02f, 9.64155048e-02f, -5.92305698e-02f, 4.54711355e-02f, -1.06745474e-01f, -1.41620412e-01f, -3.16560082e-02f, 1.12231433e-01f,
  2.22367980e-02f, 9.12763029e-02f, 2.22621858e-01f, -1.03202075e-01f, -3.93536277e-02f, -5.08195423e-02f, 1.21631488e-01f, 6.18447624e-02f, 1.52167967e-02f, 3.43618058e-02f,
  1.16889574e-01f, 1.45522296e-01f, 3.23404446e-02f, 1.41078696e-01f, 1.28616095e-01f, 3.93914394e-02f, 4.16900814e-02f, 1.08053377e-02f, 7.51660839e-02f, 2.11588889e-02f,
  -1.49855152e-01f, 8.55141878e-02f, 2.56602645e-01f, 1.35867625e-01f, -1.38963237e-01f, -8.25116690e-03f, 1.18818484e-01f, -3.68524678e-02f, -2.81588763e-01f, 1.11715961e-02f,
  1.52532294e-01f, 1.75131962e-01f, 1.02437876e-01f, 9.03564021e-02f, -9.87961814e-02f, -1.53034136e-01f, 3.55910808e-02f, 2.10197225e-01f, -1.05713256e-01f, -4.49004695e-02f,
  -9.90062281e-02f, -2.53810048e-01f, 2.82349259e-01f, -2.38548681e-01f, 1.49311408e-01f, 9.40535590e-02f, -1.51904941e-01f, 5.36224321e-02f, 1.37784556e-01f, -5.06387800e-02f,
  1.43515497e-01f, -1.19444743e-01f, 8.18794072e-02f, 1.07560314e-01f, 2.83008907e-02f, 1.22132838e-01f, 1.44893885e-01f, 7.07109496e-02f, 1.30964592e-01f, -7.60380551e-02f,
  1.31724805e-01f, 2.49915430e-03f, -1.43071413e-01f, 1.71746071e-02f, -2.36114934e-02f, -3.82324122e-02f, 7.12060183e-02f, 1.32123590e-01f, 1.00068927e-01f, -3.92960459e-02f,
  -1.04072504e-02f, 3.16687971e-02f, -2.30039675e-02f, -8.18078890e-02f, -6.17698543e-02f, -6.86782748e-02f, -9.30704325e-02f, 1.73590574e-02f, -5.34136109e-02f, -1.75918117e-01f,
  -1.07724868e-01f, -1.61364421e-01f, -1.41426399e-01f, 1.40912622e-01f, -1.31225675e-01f, 1.12073004e-01f, -3.84464897e-02f, 1.33477226e-01f, -9.63656530e-02f, 3.54090892e-03f,
  1.16228551e-01f, 7.76411742e-02f, 3.76625657e-02f, -5.59585541e-02f, -8.57586637e-02f, -7.10796267e-02f, 1.14974909e-01f, 1.17874444e-01f, -6.60613626e-02f, 1.62314370e-01f,
  1.03201553e-01f, 9.20745879e-02f, 8.11737552e-02f, -2.23557185e-02f, -2.58375774e-03f, 2.21488941e-02f, 1.26459589e-02f, 1.07207686e-01f, 1.30299538e-01f, -2.68153492e-02f,
  5.15609458e-02f, -2.89511144e-01f, -1.15553020e-02f, 9.92410779e-02f, 1.31604383e-02f, 6.75135478e-02f, -3.29685844e-02f, -2.13250387e-02f, 8.57437253e-02f, -2.49254197e-01f,
  1.25567645e-01f, 7.93841630e-02f, -3.61971296e-02f, 6.62933588e-02f, 3.55320126e-02f, -1.33409023e-01f, 4.32417877e-02f, 8.11831951e-02f, 3.97849269e-03f, -3.59322317e-02f,
  -4.41902839e-02f, -7.72280544e-02f, -2.21799742e-02f, -9.05088931e-02f, -9.22017843e-02f, -1.02348505e-02f, -5.94275296e-02f, -1.18025273e-01f, 2.68007373e-03f, 7.86587317e-03f,
  -1.85476104e-03f, -1.46919444e-01f, -1.72987163e-01f, -2.65255094e-01f, -3.20386253e-02f, -3.49896736e-02f, -1.82545245e-01f, -5.36109917e-02f, -5.05836457e-02f, 2.66114801e-01f,
  -9.08270255e-02f, 6.28334880e-02f, 1.05207674e-02f, -1.75061196e-01f, -1.20402537e-01f, 4.77049574e-02f, -2.59633034e-01f, -1.91217706e-01f, 2.46793162e-02f, -8.90698656e-02f,
  -7.47236889e-03f, -8.85961652e-02f, -1.59597769e-01f, 9.93711129e-02f, -2.27665856e-01f, -6.88176826e-02f, 3.34001593e-02f, 3.45720276e-02f, -7.13255852e-02f, -1.36829719e-01f,
  -1.21384509e-01f, 1.25851765e-01f, -2.06261445e-02f, 3.38622108e-02f, 5.13014309e-02f, 1.19625226e-01f, -3.86904180e-02f, 4.77723368e-02f, 5.92173487e-02f, 1.76031049e-02f,
  1.02682598e-02f, 1.27674967e-01f, 8.81205872e-02f, 1.05479984e-02f, -6.64221346e-02f, 5.99686764e-02f, -1.67991612e-02f, -6.54024258e-02f, 3.05964351e-02f, -2.00595614e-02f,
  -1.04827784e-01f, 3.85320857e-02f, -9.42626745e-02f, -8.56132731e-02f, -5.16942143e-02f, -7.06539974e-02f, 1.29004613e-01f, -3.50713618e-02f, -4.73184250e-02f, 2.87558399e-02f,
  -2.30019633e-02f, 8.63775015e-02f, 7.23114610e-02f, 4.72893286e-03f, 6.59313947e-02f, -6.08512349e-02f, -6.56787958e-03f, 8.26656725e-03f, 4.75151911e-02f, -1.73071232e-02f,
  -1.79352742e-02f, -4.55537587e-02f, 9.28330868e-02f, 6.60419837e-02f, 3.47907692e-02f, 3.62242460e-02f, 1.03222080e-01f, 5.07605029e-03f, -1.62565917e-01f, -4.12164591e-02f,
  2.61033177e-02f, 2.54936367e-02f, 1.57691538e-02f, -9.54592973e-02f, -1.36289209e-01f, 1.53639270e-02f, 8.45283344e-02f, -3.96265537e-02f, -9.67042372e-02f, -3.07172481e-02f,
  -4.42814603e-02f, 1.63450643e-01f, 5.31488843e-02f, -1.05434163e-02f, -1.09452613e-01f, 1.13784984e-01f, 4.58545908e-02f, -7.42977858e-02f, -7.74387047e-02f, 1.39111742e-01f,
  1.93417780e-02f, 4.70188335e-02f, 2.52444595e-02f, -1.72957897e-01f, -9.31589082e-02f, -5.54035120e-02f, 1.30985118e-02f, 5.83686344e-02f, -2.89266426e-02f, -3.42084356e-02f,
  8.72171521e-02f, 9.30248350e-02f, 2.12784875e-02f, 5.85459359e-02f, 1.57730635e-02f, -1.02643967e-01f, 1.73532233e-01f, -8.31475779e-02f, -1.89865159e-03f, -2.08722241e-02f,
  5.18759429e-01f, 2.71008015e-01f, 8.42270851e-02f, 4.70235586e-01f, 2.55725663e-02f, 1.37016445e-01f, 1.94675788e-01f, 1.58939376e-01f, 4.63949353e-01f, 2.59968378e-02f,
  -1.40254274e-01f, 1.34963036e-01f, -8.84653404e-02f, 1.48015127e-01f, -1.72685027e-01f, -2.05060989e-01f, 2.50488073e-01f, 1.76408723e-01f, 1.95853516e-01f, 8.58223811e-02f,
  7.95676857e-02f, -1.39933646e-01f, -2.62990117e-01f, -9.93707478e-02f, 1.32705882e-01f, 7.34863505e-02f, -3.43411177e-01f, -8.95414203e-02f, -4.83224355e-02f, -4.10667211e-02f,
  9.28009972e-02f, 1.76779717e-01f, 8.06547552e-02f, 8.22392777e-02f, 7.13838488e-02f, 3.56830261e-03f, -5.87354507e-03f, -8.97723213e-02f, 3.77558395e-02f, 1.50736555e-01f,
  4.43792194e-02f, -1.67546347e-02f, 3.59204337e-02f, 1.82182633e-03f, 5.91123961e-02f, 3.90427671e-02f, 7.35219717e-02f, 4.28992733e-02f, 5.26258424e-02f, 6.15022294e-02f,
  9.13355574e-02f, 4.72981902e-03f, 1.52163401e-01f, -2.57118884e-02f, 2.92534959e-02f, 1.12008475e-01f, 6.26489194e-03f, -4.54942025e-02f, -1.79127473e-02f, 2.35355478e-02f,
  1.41207278e-02f, -2.86252378e-03f, 5.79257235e-02f, 9.10954401e-02f, 1.04214892e-01f, -2.51877997e-02f, 1.36007986e-03f, -7.14560747e-02f, 1.96301445e-01f, -4.08091247e-02f,
  -4.72484641e-02f, 4.00615111e-03f, 8.99895728e-02f, 2.87378263e-02f, -1.56782586e-02f, 4.29177284e-02f, -7.69009963e-02f, 8.08770657e-02f, 1.15785442e-01f, -1.39800742e-01f,
  -5.20081557e-02f, 3.36640421e-03f, -2.66555175e-02f, -7.36008137e-02f, -4.40590046e-02f, 9.67590883e-03f, 6.44723624e-02f, 9.92466286e-02f, -2.66292784e-02f, -3.72363031e-02f,
  -4.19214629e-02f, 2.80652605e-02f, -5.35083227e-02f, 2.08935570e-02f, -3.71840410e-02f, 1.07274421e-01f, 1.16892159e-01f, 1.58454970e-01f, -1.85880065e-02f, 4.90301140e-02f,
  1.66093260e-02f, 1.24284543e-01f, -1.25447452e-01f, -2.41448637e-02f, -1.03937924e-01f, 7.01477155e-02f, -1.68209299e-02f, 4.68839854e-02f, -2.31450349e-01f, -8.70293677e-02f,
  -1.26332324e-02f, 3.08559965e-02f, 4.88347225e-02f, 1.80099141e-02f, 6.86731488e-02f, -1.25312656e-01f, 2.88156979e-02f, 3.03331744e-02f, -5.31946942e-02f, -6.86573014e-02f,
  1.45030811e-01f, 3.38687189e-02f, -6.98724091e-02f, 1.49361387e-01f, -1.19344614e-01f, -1.66742012e-01f, -2.59229183e-01f, 6.25984818e-02f, 4.05794621e-01f, 2.07911916e-02f,
  -1.47611737e-01f, 2.11084396e-01f, -7.38386884e-02f, -8.95651877e-02f, 1.18735798e-01f, 1.13216497e-01f, -1.16198950e-01f, 3.77335660e-02f, 6.22089282e-02f, 4.59346967e-03f,
  1.52213544e-01f, -2.20421702e-01f, -1.78429872e-01f, -1.25899971e-01f, -1.90647319e-01f, -3.91159952e-02f, -1.61813200e-01f, -1.37756109e-01f, -1.79335803e-01f, -2.06592660e-02f,
  -4.28955667e-02f, -3.15793231e-02f, -1.88545704e-01f, 6.82677981e-03f, -8.35110694e-02f, -2.49575619e-02f, 1.17029041e-01f, -4.77761328e-02f, -8.36927816e-02f, 7.86164179e-02f,
  1.15793504e-01f, 1.07138529e-01f, 1.94849055e-02f, -3.07205990e-02f, -4.49341536e-03f, -7.15042949e-02f, 2.85193007e-02f, -6.28313199e-02f, -2.11786870e-02f, 3.49741131e-02f,
  -1.26706739e-03f, -1.03851955e-03f, -6.14264794e-02f, -3.89467478e-02f, 6.57363376e-03f, -3.24148014e-02f, 6.32673427e-02f, -6.17193207e-02f, -3.34490836e-02f, 1.06293902e-01f,
  -3.05829402e-02f, 4.34146971e-02f, -8.59482512e-02f, -3.79111692e-02f, -1.05411008e-01f, -3.75877693e-03f, 8.95995796e-02f, -4.73040566e-02f, -4.83676381e-02f, -1.43831633e-02f,
  -4.55474257e-02f, -6.98087737e-02f, 1.13724627e-01f, -8.32108315e-03f, 2.46487875e-02f, 3.16986232e-03f, -1.41661480e-01f, -1.60704050e-02f, 5.66960350e-02f, 1.29263639e-01f,
  -8.92781168e-02f, -2.65398957e-02f, -2.25171633e-02f, 1.45145521e-01f, -1.00386433e-01f, -1.19270599e-02f, 1.53895006e-01f, -7.61933997e-02f, 6.66615963e-02f, -7.86050409e-02f,
  -4.10046875e-02f, 1.72944590e-02f, -4.62153405e-02f, 6.88253418e-02f, 8.09610114e-02f, 1.17590632e-02f, 8.90454501e-02f, 1.81688160e-01f, -1.50494844e-01f, -5.58254682e-03f,
  2.10015643e-02f, -1.42615382e-02f, 1.40012987e-02f, 2.50100195e-02f, -1.96717214e-02f, 1.35515921e-03f, 3.75149548e-02f, -1.34997433e-02f, -9.41435099e-02f, 5.77860586e-02f,
  -5.26188165e-02f, 7.90914074e-02f, -1.03828693e-02f, -3.76916975e-02f, -5.23307174e-02f, -7.50005245e-02f, 8.02248865e-02f, -1.20619452e-02f, -7.47388080e-02f, 4.55158167e-02f,
  1.27255814e-02f, -1.24644309e-01f, -2.34247655e-01f, 7.52198324e-02f, 1.02115177e-01f, -2.95781288e-02f, -9.05846134e-02f, 7.05227181e-02f, -1.20374709e-01f, 1.74734086e-01f,
  2.92572498e-01f, -1.05431050e-01f, -8.45710263e-02f, 2.11910740e-01f, 4.41947319e-02f, -1.34515420e-01f, 2.79185355e-01f, 1.56843126e-01f, -1.46514788e-01f, 7.80414119e-02f,
  1.73503071e-01f, 3.55501950e-01f, 3.71739231e-02f, 2.20895886e-01f, 1.74414411e-01f, -7.85850361e-02f, 1.87529951e-01f, -7.56198913e-02f, 2.78847873e-01f, 1.07691243e-01f,
  5.94342686e-02f, 7.55386334e-03f, -1.05232857e-02f, -6.92286268e-02f, 7.10517690e-02f, 7.00618327e-02f, 4.86275740e-02f, -1.49046436e-01f, -1.65413514e-01f, -7.56972795e-03f,
  -1.32008903e-02f, 8.26003525e-05f, -8.24210495e-02f, 6.48875441e-03f, 1.31870538e-01f, -1.33073911e-01f, -5.11195324e-02f, -1.62713567e-03f, -6.43618181e-02f, -3.39098759e-02f,
  -1.05667554e-01f, -5.42449988e-02f, 3.30443718e-02f, -7.50418147e-03f, -5.67859337e-02f, -8.30922043e-04f, -8.86842087e-02f, -5.49961627e-02f, -4.22572680e-02f, -9.11392551e-03f,
  2.23588329e-02f, 1.95763595e-02f, -1.45065278e-01f, -5.49038053e-02f, -1.43851722e-02f, -3.80916856e-02f, 7.45512247e-02f, 7.17225764e-03f, -3.96919027e-02f, -1.51765542e-02f,
  2.11837143e-02f, -3.33499946e-02f, 5.80049828e-02f, 6.20434657e-02f, 9.72891748e-02f, -1.25417784e-01f, -1.01346865e-01f, 1.41805122e-02f, 4.48643528e-02f, -7.93370008e-02f,
  1.00377097e-03f, 4.39821444e-02f, -7.88091794e-02f, -4.17175144e-03f, 5.83312102e-02f, -5.98501787e-03f, 1.78498045e-01f, 1.76492648e-03f, -8.49518401e-04f, 8.47191662e-02f,
  9.42179412e-02f, -4.49149311e-02f, 2.94371415e-02f, -5.83546013e-02f, -4.85207932e-03f, 6.36733398e-02f, 5.14799468e-02f, -3.65275051e-03f, -4.36890870e-03f, -7.25074187e-02f,
  5.99725731e-02f, -3.91253047e-02f, 7.15393275e-02f, 2.48642843e-02f, 8.47155228e-02f, 6.01038635e-02f, 7.71267563e-02f, -6.71525672e-02f, 8.04328471e-02f, 2.93266755e-02f,
  -2.73283627e-02f, -6.95947707e-02f, 1.22508183e-01f, -1.46046191e-01f, 5.96214160e-02f, 1.18166953e-01f, -1.08812414e-01f, 7.68066496e-02f, 3.06530427e-02f, -9.92771760e-02f,
  3.53003800e-01f, -1.93176106e-01f, -2.88138479e-01f, 1.50539614e-02f, 3.05785835e-01f, 1.30326703e-01f, -1.54997617e-01f, 1.83673259e-02f, -7.35341059e-03f, -1.45205900e-01f,
  1.59807969e-02f, -9.63040516e-02f, -3.24841261e-01f, 2.02599704e-01f, 3.61840814e-01f, -1.68184921e-01f, 2.45973974e-01f, 8.82088989e-02f, 1.24474980e-01f, 4.47037220e-02f,
  2.44638219e-01f, 4.45209801e-01f, -3.16916555e-02f, 1.42203346e-01f, 1.89384475e-01f, -9.95348915e-02f, 9.65221822e-02f, -1.94980636e-01f, 6.45494834e-02f, 1.03015214e-01f,
  2.99927723e-02f, 7.60018378e-02f, 4.80550788e-02f, -1.90381967e-02f, 1.11786539e-04f, 1.45585403e-01f, -5.37350075e-04f, -4.40444648e-02f, 3.15368325e-02f, -1.10669397e-01f,
  -9.11261365e-02f, 1.40987337e-01f, -2.27397420e-02f, 6.59244582e-02f, 1.90541238e-01f, 3.34667526e-02f, -2.66200341e-02f, 8.36490467e-02f, -4.12855372e-02f, -1.28865764e-01f,
  -5.96245378e-02f, -1.02686241e-01f, 2.89418865e-02f, -8.61760899e-02f, -1.94254473e-01f, 4.45255870e-03f, -9.42566525e-03f, -1.65125892e-01f, -1.37876973e-01f, 9.15198680e-03f,
  2.80148908e-02f, 3.95255126e-02f, 4.48969193e-02f, -2.41264571e-02f, -4.32730131e-02f, -6.53913766e-02f, 9.74729210e-02f, 1.00697000e-02f, -7.72738680e-02f, -7.64669999e-02f,
  -8.94789323e-02f, -1.43640600e-02f, 9.92831308e-03f, -9.74100456e-03f, 1.24985322e-01f, 8.68414342e-02f, 1.93661340e-02f, -6.78419024e-02f, -2.67789396e-03f, -5.69190346e-02f,
  4.66853902e-02f, 8.51216391e-02f, -6.83992803e-02f, -2.86285542e-02f, -3.32639813e-02f, -1.34253681e-01f, -1.44694373e-02f, -4.63376790e-02f, -4.99698222e-02f, 1.22603238e-01f,
  -1.12223819e-01f, -2.54170537e-01f, -6.68633804e-02f, 1.73119865e-02f, -1.30068764e-01f, 1.87608972e-01f, 9.03355852e-02f, 3.37197557e-02f, -3.82719375e-02f, -6.20451532e-02f,
  3.22296992e-02f, 2.60076970e-02f, -1.32738845e-02f, 1.10183015e-01f, 5.81611600e-03f, -3.37700099e-02f, -6.04573600e-02f, 7.63245896e-02f, -2.64995676e-02f, -1.29653886e-01f,
  -6.36144876e-02f, -2.91136671e-02f, 5.42836376e-02f, -1.39466096e-02f, 2.45863497e-02f, -7.57026076e-02f, 6.84701055e-02f, -2.73183603e-02f, -4.87789838e-03f, -3.21258828e-02f,
  4.34214860e-01f, -3.85333180e-01f, -2.27236509e-01f, 1.17250010e-01f, 2.40042269e-01f, 2.51606882e-01f, 1.79521963e-01f, -1.18602246e-01f, -1.69188738e-01f, -2.58575052e-01f,
  2.50353575e-01f, -1.08169354e-01f, -4.74800132e-02f, 2.26857051e-01f, 4.36765969e-01f, -4.92844507e-02f, 2.12005585e-01f, 5.34029342e-02f, -2.22997367e-02f, 7.05967769e-02f,
  2.17770711e-01f, 2.98229277e-01f, 7.59956166e-02f, -4.62252200e-02f, 2.63428718e-01f, -1.77123576e-01f, -1.07761391e-03f, -6.12459518e-02f, 8.16863552e-02f, 1.94542915e-01f,
  1.38941690e-01f, -5.14626354e-02f, 1.06756099e-01f, -3.55350412e-03f, 1.10302223e-02f, 9.55401435e-02f, 5.17178215e-02f, -3.83457690e-02f, 6.92297518e-02f, -7.67791122e-02f,
  -9.34691578e-02f, -1.25784166e-02f, -2.94442270e-02f, 4.64545116e-02f, 8.38822499e-02f, -1.39042675e-01f, -2.57503297e-02f, 5.04422188e-02f, -1.07775658e-01f, -5.64476214e-02f,
  -9.42565408e-03f, -6.14780858e-02f, 5.76798283e-02f, -9.82865319e-02f, -1.46223560e-01f, -4.55618724e-02f, -1.32290438e-01f, -3.87362093e-02f, -1.53088525e-01f, -1.57031029e-01f,
  -5.31764776e-02f, 8.39792341e-02f, -1.67485252e-02f, 2.22210474e-02f, 1.25823542e-02f, 5.25147691e-02f, 1.05575569e-01f, -1.91861074e-02f, 1.15057314e-02f, 9.69130266e-03f,
  6.39315099e-02f, -4.74563129e-02f, 4.61571530e-04f, 7.18617663e-02f, 9.54990759e-02f, -6.65972417e-04f, 6.18652366e-02f, 7.81061535e-04f, 4.49492782e-02f, 6.29962534e-02f,
  1.83719639e-02f, 8.81450027e-02f, 4.53610346e-02f, 2.53422204e-02f, 2.07131798e-03f, 6.72196373e-02f, -9.76223033e-03f, 6.59140274e-02f, 2.94971038e-02f, 1.12417221e-01f,
  -1.51882187e-01f, -4.05183315e-01f, -3.93252634e-02f, -1.37008922e-02f, 7.66822696e-03f, -4.67347621e-04f, 6.53636232e-02f, 2.27873437e-02f, -1.71195827e-02f, 6.29185513e-02f,
  -5.79996454e-03f, -4.43921089e-02f, 2.63480078e-02f, 1.98198542e-01f, -1.34894410e-02f, -6.63783476e-02f, -1.22929616e-02f, 1.47574106e-02f, -1.43545761e-03f, -6.25146627e-02f,
  -1.00647382e-01f, -3.85717824e-02f, -4.12908532e-02f, -7.51489103e-02f, -3.36094052e-02f, -6.50411748e-05f, -1.29106253e-01f, -7.02250674e-02f, -6.38907403e-02f, -1.08352810e-01f,
  2.04098657e-01f, -2.25184515e-01f, -1.30592003e-01f, -1.87772632e-01f, -1.34438708e-01f, -1.80047676e-01f, -5.28545585e-03f, -2.11895466e-01f, -2.35449210e-01f, -1.16761766e-01f,
  -2.32415751e-01f, 2.15053350e-01f, 2.57088002e-02f, -2.23731503e-01f, 3.88332307e-01f, 1.77420467e-01f, -1.18177980e-01f, -3.88591387e-03f, -1.74875423e-01f, -7.34870955e-02f,
  -8.57721642e-02f, -1.10293113e-01f, 9.44509655e-02f, -2.28088140e-01f, -2.58442968e-01f, -1.37060508e-01f, 2.86535290e-03f, -5.07787801e-02f, -1.28578305e-01f, -8.83479267e-02f,
  -1.13723487e-01f, -6.88372925e-02f, 4.04503532e-02f, -1.54231293e-02f, -8.94109905e-02f, 5.77091835e-02f, 8.19481462e-02f, 7.41698444e-02f, 4.70065549e-02f, 1.56517640e-01f,
  1.05226047e-01f, 2.05495283e-02f, -6.44385889e-02f, 1.03088073e-01f, -1.14071801e-01f, 8.13099742e-02f, -6.85373247e-02f, 7.99993277e-02f, 6.55984879e-02f, 1.08367451e-01f,
  3.89175266e-02f, 6.56008646e-02f, -1.19453892e-01f, 1.28094658e-01f, -1.08490735e-02f, 1.29237510e-02f, 1.72181711e-01f, 1.07897282e-01f, 1.11111298e-01f, 8.86751041e-02f,
  -4.73531969e-02f, 2.79951729e-02f, 1.99526884e-02f, 3.55223529e-02f, 2.22907085e-02f, -1.12755328e-01f, -6.71953941e-03f, -1.09117827e-03f, -9.93955731e-02f, 1.54273016e-02f,
  -7.15664923e-02f, -2.49764249e-02f, -2.59888060e-02f, -4.43043523e-02f, -1.82215571e-02f, 7.96608329e-02f, 1.18595280e-01f, 5.80844693e-02f, -1.40501961e-01f, -6.87657818e-02f,
  -7.24076927e-02f, 2.60148998e-02f, -1.15717620e-01f, -8.63500535e-02f, -9.52949151e-02f, 6.51142821e-02f, 4.24618945e-02f, 7.78861810e-03f, -2.14216858e-01f, 3.75779644e-02f,
  -6.92762509e-02f, -1.13662653e-01f, -1.18490338e-01f, 5.00369109e-02f, -9.73558705e-03f, 3.34735848e-02f, -4.50306349e-02f, -7.27831200e-02f, 2.42585894e-02f, 6.27151057e-02f,
  3.86926979e-02f, -3.19701917e-02f, -6.27076551e-02f, -7.35102519e-02f, -1.33763589e-02f, -4.63578850e-02f, 7.21468478e-02f, 3.46957855e-02f, 6.41145632e-02f, 4.22437191e-02f,
  2.51478888e-02f, -1.76833589e-02f, 1.27928287e-01f, 2.16142535e-02f, -3.67702208e-02f, 2.32132357e-02f, 5.08303568e-02f, 6.80350438e-02f, 9.74855199e-02f, 8.88832435e-02f,
  -4.60535645e-01f, 1.83907315e-01f, 1.76317722e-01f, 2.33063146e-01f, -2.91935027e-01f, 2.45142922e-01f, 3.05250436e-01f, 5.04506119e-02f, 3.77797484e-01f, 3.00312787e-01f,
  -2.60580052e-02f, -2.82856375e-02f, 7.21192583e-02f, 2.40364358e-01f, 1.69319508e-03f, 2.82840163e-01f, 2.75492907e-01f, 1.68176144e-01f, -7.24900439e-02f, -4.50985506e-02f,
  2.76471931e-03f, 3.17807449e-03f, -4.19372693e-02f, -1.69686913e-01f, -1.97171971e-01f, -1.91019878e-01f, -1.53371185e-01f, -1.14057995e-01f, 2.85880901e-02f, -5.87296262e-02f,
  -1.14520751e-01f, -1.53435141e-01f, -1.78555965e-01f, -3.36691737e-02f, -1.17480956e-01f, -3.97674441e-02f, -1.69867603e-03f, -5.31536937e-02f, -4.89907786e-02f, -4.31984104e-02f,
  -2.31853575e-02f, -3.14950943e-02f, -3.05854790e-02f, 1.13052562e-01f, 9.48069617e-02f, 1.58474576e-02f, -2.10418813e-02f, 5.39012775e-02f, 2.02635434e-02f, -3.85288857e-02f,
  -2.83722393e-02f, -2.27211341e-02f, 7.11581036e-02f, 8.56035296e-03f, -5.35848625e-02f, 3.60492952e-02f, 1.28693819e-01f, -5.91245554e-02f, -9.18528903e-03f, -6.89819548e-03f,
  3.00040990e-02f, 1.52478851e-02f, 1.25337578e-02f, 1.93627633e-03f, -6.89018890e-02f, -5.50373793e-02f, 7.31620342e-02f, -1.76038928e-02f, -4.29760888e-02f, 1.43313222e-02f,
  3.80313471e-02f, -5.66357449e-02f, -2.76765916e-02f, 5.31266257e-02f, 2.46085767e-02f, 7.79405981e-02f, -1.37351938e-02f, -1.05381176e-01f, -1.53579749e-03f, 3.75229819e-03f,
  5.69180511e-02f, 9.45203006e-02f, -4.90472317e-02f, -3.29294354e-02f, -8.57033208e-03f, -2.41295807e-02f, 9.23323184e-02f, 5.98361343e-02f, -1.51663506e-03f, -6.31963462e-02f,
  4.33095209e-02f, 4.31767404e-02f, -6.04966208e-02f, -8.91118050e-02f, 4.17366065e-02f, 3.69100571e-02f, 8.90072584e-02f, -1.76994316e-02f, 6.79945275e-02f, 1.09219179e-02f,
  -4.98379096e-02f, -8.50539748e-03f, 5.82104623e-02f, 9.39332545e-02f, 5.62671348e-02f, 7.70612061e-02f, -2.12510247e-02f, 4.57369909e-02f, -3.74653004e-02f, -9.50357094e-02f,
  -6.57615587e-02f, -5.63332103e-02f, 3.42084169e-02f, -4.28129621e-02f, -3.99411879e-02f, -1.28038907e-02f, -8.71503204e-02f, -3.07159293e-02f, -3.77329029e-02f, 6.46013999e-03f,
  2.16339201e-01f, -2.29754016e-01f, -3.30210701e-02f, -7.01781660e-02f, 2.96305239e-01f, 3.87475580e-01f, 9.58593115e-02f, 3.78443748e-02f, -2.60369658e-01f, -1.57214962e-02f,
  2.60819290e-02f, -1.68471783e-01f, -2.24492654e-01f, -1.43781349e-01f, -1.00372754e-01f, -2.98118830e-01f, -1.00854579e-02f, 2.72464622e-02f, -2.12168321e-01f, 1.57511935e-01f,
  7.91459158e-02f, 2.00540684e-02f, -1.40652299e-01f, 3.97257768e-02f, 2.11636022e-01f, 1.56493947e-01f, 2.43110359e-01f, -8.97935592e-03f, 8.64361823e-02f, -1.72431931e-01f,
  -3.57108377e-02f, -7.91846886e-02f, -5.05440198e-02f, -1.80064309e-02f, 9.00812820e-02f, 6.79128468e-02f, 2.02611578e-03f, -6.98321685e-02f, 8.95856395e-02f, 1.93515955e-03f,
  5.90539761e-02f, -9.72967148e-02f, -3.69077213e-02f, 8.18046182e-02f, 7.39466250e-02f, 2.70895213e-02f, -1.16515169e-02f, 2.05928180e-02f, -1.10550277e-01f, -1.03862859e-01f,
  -8.24539289e-02f, 9.87897739e-02f, 3.62897106e-02f, -1.48369178e-01f, 2.03609336e-02f, 5.77655528e-03f, 3.50720473e-02f, 7.61608109e-02f, -7.78469071e-02f, -1.81192458e-02f,
  6.39351159e-02f, 8.60482156e-02f, 1.77312225e-01f, -8.20952877e-02f, 6.24479018e-02f, -4.41466048e-02f, 1.96840037e-02f, 5.24621159e-02f, 6.77520037e-02f, -3.52591686e-02f,
  1.24794848e-01f, -3.59415449e-02f, -1.33498907e-01f, 8.16679671e-02f, 2.31415848e-03f, -1.38990758e-02f, 1.59754176e-02f, -3.04591507e-02f, 4.42405678e-02f, 4.07331213e-02f,
  -1.24039717e-01f, 9.13377106e-02f, 6.93441182e-03f, 1.98145397e-02f, -6.58652112e-02f, 9.09712985e-02f, 2.35378705e-02f, 2.67715380e-02f, 5.93251064e-02f, -1.34812212e-02f,
  3.08618266e-02f, -6.42708763e-02f, -1.53152913e-01f, -1.54457586e-02f, -9.14574414e-02f, 1.25728905e-01f, -3.52801941e-02f, 2.01910976e-02f, -5.71744032e-02f, 1.38330618e-02f,
  1.11931399e-01f, 9.73439291e-02f, 1.66410223e-01f, 9.38589722e-02f, -8.92818943e-02f, 1.06566295e-01f, 3.68750729e-02f, 1.01583451e-02f, -1.56287834e-01f, 6.29918128e-02f,
  1.27966404e-01f, 1.82977110e-01f, -4.30627465e-02f, -4.05270755e-02f, 4.34614047e-02f, 2.18411768e-03f, 4.94935317e-03f, 5.37200868e-02f, -1.09174035e-01f, -6.56622425e-02f,
  -5.42312898e-02f, 5.99814653e-02f, -2.46632919e-01f, -1.72372743e-01f, 1.14348968e-02f, -1.08050957e-01f, -5.04232757e-02f, 1.12967469e-01f, -1.85786322e-01f, 2.85340369e-01f,
  1.80093616e-01f, -1.20285526e-01f, 2.15734780e-01f, -7.11217895e-02f, -2.72308409e-01f, -1.25296667e-01f, 9.37959272e-03f, -3.96280698e-02f, -1.43011004e-01f, 2.32042506e-01f,
  3.23323235e-02f, 2.98820138e-01f, -2.26310715e-01f, 2.14355573e-01f, 1.61812842e-01f, -1.18380226e-02f, 2.19822496e-01f, 8.89617801e-02f, 9.01304111e-02f, -2.25569289e-02f,
  -9.81421992e-02f, -2.62496732e-02f, -8.86310712e-02f, -5.69026694e-02f, 8.41653626e-03f, 8.82090181e-02f, 9.87821072e-02f, 2.00733673e-02f, -1.22736432e-01f, -3.18891183e-02f,
  1.33278236e-01f, -2.40556411e-02f, 3.75772528e-02f, -1.20707517e-02f, 5.65533191e-02f, -4.14181128e-02f, -4.90618274e-02f, -1.41540980e-02f, -3.25619541e-02f, -5.79948211e-03f,
  -1.09230196e-02f, -7.90387765e-02f, 6.69485480e-02f, -7.48341382e-02f, -4.29085605e-02f, -6.52678637e-03f, -1.19984336e-01f, -1.85363796e-02f, 1.51920514e-02f, -1.22603081e-01f,
  1.68761238e-01f, 6.38046190e-02f, -3.09734363e-02f, -7.00384304e-02f, -9.72548500e-02f, -1.27742007e-01f, -7.95721263e-03f, -9.08082947e-02f, -9.93331596e-02f, -5.23427874e-03f,
  -5.40509028e-03f, -6.81772381e-02f, 8.10369328e-02f, 4.07244526e-02f, 2.00315583e-02f, -4.35757898e-02f, 1.35769788e-03f, 6.50973916e-02f, 3.09694968e-02f, -5.12621179e-02f,
  -8.16034153e-02f, 2.95677371e-02f, -1.06903359e-01f, 9.54902321e-02f, 3.63437533e-02f, 6.86335713e-02f, 1.19676918e-01f, -3.90025862e-02f, -6.51875585e-02f, 1.25512734e-01f,
  3.05545758e-02f, 2.61447072e-01f, 2.42514499e-02f, 3.19249444e-02f, 1.30873937e-02f, 1.04949690e-01f, 2.69415174e-02f, 7.84220248e-02f, 3.99287269e-02f, 3.64372507e-02f,
  1.52017206e-01f, 1.28110424e-02f, 1.21011920e-01f, 5.79325631e-02f, -7.09975138e-02f, 6.34789318e-02f, 1.09356098e-01f, -3.63194793e-02f, 2.93517448e-02f, -2.02845428e-02f,
  1.14933163e-01f, -1.37306117e-02f, 7.23063350e-02f, -8.46167058e-02f, 7.50834122e-02f, 1.10005178e-01f, -1.76654682e-02f, -5.19346297e-02f, 1.20826863e-01f, -7.81447291e-02f,
  -1.38215959e-01f, 7.70486565e-03f, -6.07913136e-02f, 1.00306675e-01f, 2.94879019e-01f, 2.64619142e-01f, -9.62275192e-02f, 1.87874094e-01f, 1.56937003e-01f, -2.12100506e-01f,
  -1.47294685e-01f, -8.99948999e-02f, -3.95278126e-01f, 3.55236605e-02f, 2.24084482e-01f, -8.82455334e-02f, 2.51448303e-01f, 1.01048015e-01f, 1.48282781e-01f, -6.43898845e-02f,
  2.67850626e-02f, 1.93359360e-01f, -2.15054840e-01f, 1.07703529e-01f, -6.15461804e-02f, 3.14571485e-02f, -1.11021005e-01f, -5.14787696e-02f, 7.82444030e-02f, 1.73642099e-01f,
  1.19559631e-01f, -8.32062066e-02f, -7.55285695e-02f, 9.10636932e-02f, -1.05038956e-01f, 3.50899696e-02f, -1.23199876e-02f, -5.42402314e-03f, 8.02711472e-02f, -4.96890359e-02f,
  -1.71763033e-01f, 6.12167455e-02f, -1.18445298e-02f, -4.01489623e-03f, 8.17297027e-02f, 9.71325934e-02f, -5.79410344e-02f, -1.03198066e-01f, -7.38459304e-02f, -5.05262427e-02f,
  -1.86935157e-01f, -6.77502304e-02f, -9.27843451e-02f, 9.95787978e-02f, -2.45015826e-02f, 8.82012472e-02f, 1.60686132e-02f, 1.92540474e-02f, -2.65424885e-03f, 8.33961070e-02f,
  -1.05064645e-01f, 8.26911554e-02f, 7.97819253e-03f, -1.18516050e-02f, 3.48357297e-02f, 4.69222814e-02f, 6.31783828e-02f, 7.18039721e-02f, 6.53336570e-02f, 2.06273049e-02f,
  4.77524772e-02f, 7.16746673e-02f, 6.12808354e-02f, 9.46687981e-02f, -5.47418967e-02f, -4.33017779e-03f, -5.40969968e-02f, -3.46608460e-02f, 1.74671251e-04f, -3.18209305e-02f,
  4.94547300e-02f, 1.31397501e-01f, -5.43073639e-02f, -2.43540592e-02f, 1.54869989e-01f, 4.98243980e-02f, -2.67200340e-02f, -1.38227507e-01f, -9.84268486e-02f, -5.48873022e-02f,
  1.18103176e-01f, 1.19031191e-01f, -4.41233926e-02f, 4.90959845e-02f, 2.71624979e-03f, 6.28798231e-02f, 1.15295522e-01f, 9.36678872e-02f, 1.26000240e-01f, -4.90011573e-02f,
  -4.47290018e-02f, -5.27563877e-02f, -6.36676773e-02f, 1.00586444e-01f, 5.68859242e-02f, 1.13531044e-02f, -6.06396841e-03f, 9.18137133e-02f, 2.51885336e-02f, -5.59077822e-02f,
  -1.55568555e-01f, -6.31586537e-02f, 1.93931106e-02f, 5.31900376e-02f, 5.38005084e-02f, -8.37342367e-02f, -5.53362444e-03f, 3.15627791e-02f, -1.28856879e-02f, 1.06163733e-01f,
  1.38183832e-01f, 6.46794355e-03f, 2.85353392e-01f, 1.70495138e-01f, 2.01220632e-01f, 1.92114055e-01f, 2.33899042e-01f, 1.21057935e-01f, 2.79108524e-01f, -2.00036585e-01f,
  -1.94343939e-01f, 3.83242071e-02f, 4.44447286e-02f, -8.69162530e-02f, 1.09659038e-01f, -1.35231707e-02f, 1.24454694e-02f, -1.90563649e-02f, 1.66847423e-01f, 3.29466909e-02f,
  9.14151669e-02f, -1.70329913e-01f, 9.25004408e-02f, -7.63920620e-02f, 1.33732945e-01f, -1.67228319e-02f, -2.69383520e-01f, 1.41045198e-01f, -2.17132360e-01f, 3.05874050e-02f,
  8.86493325e-02f, -5.92376292e-02f, 4.96406443e-02f, -2.98734475e-02f, 2.33886559e-02f, -5.35905659e-02f, -2.53934022e-02f, -4.45892327e-02f, 5.71952462e-02f, -3.60144414e-02f,
  -2.05872245e-02f, -3.44739854e-02f, -2.64628651e-03f, 8.14127736e-03f, 1.37811542e-01f, 1.03967600e-02f, 8.46519917e-02f, 1.30209759e-01f, 2.42776871e-02f, 7.13959560e-02f,
  1.13482989e-01f, 9.89447534e-02f, 1.01134114e-01f, -4.44039740e-02f, 1.31966481e-02f, 2.98135895e-02f, 6.38540834e-03f, -2.24211328e-02f, 5.70128225e-02f, 3.74961421e-02f,
  1.17728077e-02f, 2.84073893e-02f, -4.44573313e-02f, -4.62961644e-02f, -7.37803876e-02f, -3.47729847e-02f, -3.83427590e-02f, -4.56393212e-02f, 2.09951233e-02f, -5.65596446e-02f,
  -5.21000586e-02f, -5.92294224e-02f, 4.85324338e-02f, 5.62387109e-02f, -5.27581535e-02f, -8.80074874e-02f, -8.70141983e-02f, -6.35946095e-02f, 3.68482955e-02f, 8.86944011e-02f,
  8.74876305e-02f, -2.45289840e-02f, 1.15695819e-02f, -8.15360621e-02f, -7.28847273e-03f, 6.50334060e-02f, -8.14887974e-03f, -4.36266810e-02f, 1.37534710e-02f, 1.22466376e-02f,
  -3.75893824e-02f, -2.08324686e-01f, -4.93573816e-03f, -8.13174620e-02f, -8.81255046e-02f, -8.65020677e-02f, -2.17483938e-02f, 8.37496668e-03f, 1.65626295e-02f, -5.63507676e-02f,
  6.95576593e-02f, -6.33190721e-02f, 2.55128611e-02f, 3.23599130e-02f, -1.45566612e-02f, -1.16966190e-02f, -1.09981500e-01f, 2.90961619e-02f, -3.38685475e-02f, -1.28377631e-01f,
  -7.82340206e-03f, 2.31727324e-02f, -8.19972064e-03f, 2.36088689e-02f, -2.82701221e-04f, -7.54242688e-02f, -1.43516093e-01f, -1.37191918e-02f, 1.51009345e-02f, 3.41869779e-02f,
  -4.82923239e-01f, 2.53186047e-01f, 3.18537414e-01f, -2.90341169e-01f, 1.37088165e-01f, 5.60398512e-02f, 2.34999857e-03f, -9.56374854e-02f, -1.84975311e-01f, 4.38611489e-03f,
  -2.38375086e-02f, 1.31982744e-01f, 2.85775155e-01f, -1.12011805e-01f, -6.43672422e-02f, 1.19827889e-01f, -1.81107178e-01f, -9.94308591e-02f, 4.26874962e-03f, -1.09167129e-01f,
  -5.35121944e-04f, -1.06867552e-01f, 1.51520437e-02f, -2.75246371e-02f, -6.65376559e-02f, -1.03893198e-01f, -2.08195016e-01f, 1.31771684e-01f, -1.65767327e-01f, 7.76933273e-03f,
  -1.50719240e-01f, -1.60177246e-01f, -1.91390589e-02f, -7.95239359e-02f, -1.26446918e-01f, 1.82827953e-02f, -5.78723624e-02f, 4.22235169e-02f, -6.19160151e-03f, 2.95316689e-02f,
  -8.17731488e-03f, 3.66688184e-02f, -6.74913004e-02f, 1.42125323e-01f, -9.20382962e-02f, -3.05719152e-02f, 4.08013128e-02f, -6.23529137e-04f, 7.06443489e-02f, -3.93294506e-02f,
  1.74044654e-01f, 2.22789422e-02f, -7.10721537e-02f, -7.43362159e-02f, -1.44504532e-02f, 2.81558037e-02f, -4.34152707e-02f, 8.00349098e-03f, -4.35189456e-02f, -1.04682125e-01f,
  -6.27421439e-02f, 5.38996942e-02f, 9.73305255e-02f, 2.17187628e-02f, 1.07874833e-02f, -3.41943316e-02f, -1.24837412e-02f, -5.13556488e-02f, 2.69914442e-03f, 2.92372946e-02f,
  -9.04109403e-02f, -2.13413388e-02f, -5.53489774e-02f, -6.88098818e-02f, -4.65654843e-02f, -4.41902727e-02f, 5.72856627e-02f, 5.55893704e-02f, -2.03191247e-02f, -3.31889950e-02f,
  -2.91821193e-02f, -6.18144795e-02f, -8.45766738e-02f, -5.39584011e-02f, 5.63320816e-02f, 8.78169090e-02f, -4.02436033e-02f, 7.22388737e-03f, -2.72756144e-02f, 8.21040571e-02f,
  -3.29931319e-01f, -3.93296719e-01f, 3.18228193e-02f, -8.13555196e-02f, -1.51130334e-02f, -3.29770683e-03f, 2.70664692e-03f, -1.89397763e-02f, -8.85092467e-02f, -9.26750991e-03f,
  -9.56646204e-02f, -1.41743869e-01f, -8.96612480e-02f, 2.11390797e-02f, 2.79340111e-02f, -5.64735085e-02f, -4.08467427e-02f, 5.20065986e-02f, 1.50981992e-02f, -4.07714881e-02f,
  3.34239043e-02f, -5.35749132e-03f, 3.51486690e-02f, -1.23397619e-01f, -3.81295271e-02f, -1.05224267e-01f, -7.04445690e-02f, 1.22067705e-02f, -5.32373339e-02f, -5.85021731e-03f,
  -5.52700877e-01f, 1.60482377e-01f, -2.71278054e-01f, -1.32658884e-01f, 1.38950780e-01f, -1.50897279e-01f, 7.98795372e-02f, 7.94568509e-02f, -1.12393908e-01f, 3.55783433e-01f,
  2.88525581e-01f, -2.25265384e-01f, 1.88633040e-01f, -1.69653490e-01f, -5.33776939e-01f, -1.86653107e-01f, -2.29142234e-01f, -4.16299552e-02f, -1.38033688e-01f, 2.33084578e-02f,
  -1.67553470e-01f, 6.84914887e-02f, -9.58016664e-02f, 2.52270579e-01f, 9.10021067e-02f, 9.49927419e-03f, 2.42964312e-01f, 1.86391011e-01f, -6.24260539e-03f, -9.52155069e-02f,
  4.72250804e-02f, 2.07866021e-02f, 1.49283288e-02f, -6.84934184e-02f, -6.77076876e-02f, 3.10924519e-02f, 5.27117774e-02f, -1.17717668e-01f, 4.09188308e-02f, -5.70217445e-02f,
  7.40839392e-02f, 1.68100279e-02f, -8.97584483e-02f, -3.12139676e-03f, 2.03347467e-02f, 4.14353721e-02f, -4.84657772e-02f, -3.03933546e-02f, 1.13721013e-01f, -8.19424540e-02f,
  1.54781602e-02f, -1.06894160e-02f, -5.06081209e-02f, 5.39994538e-02f, -8.32371339e-02f, -6.66410476e-02f, -7.40580037e-02f, -8.31782818e-03f, 3.13831531e-02f, -6.25485554e-02f,
  -1.97553560e-02f, -4.66668559e-03f, 1.46443220e-02f, 3.04082911e-02f, -7.89031312e-02f, 2.27802638e-02f, 4.35427576e-03f, -3.57508771e-02f, -1.08488798e-01f, 5.67850508e-02f,
  6.21784106e-03f, 8.74092989e-03f, -3.26046348e-02f, 1.89724788e-02f, -8.77884775e-02f, -8.86451602e-02f, -6.97245225e-02f, 1.18337478e-02f, 3.16838473e-02f, -4.20432128e-02f,
  1.52572587e-01f, -5.15096001e-02f, -9.38617717e-03f, 8.88692737e-02f, 6.58256486e-02f, -3.29553485e-02f, 3.41516100e-02f, -3.42652872e-02f, 9.55905486e-03f, 3.17717437e-03f,
  3.72575559e-02f, 1.16761759e-01f, 2.39513312e-02f, 3.94252911e-02f, 9.11367536e-02f, -8.13932419e-02f, -1.44054756e-01f, -1.68179139e-01f, 4.99124359e-03f, -7.30353370e-02f,
  2.87308116e-02f, 2.16077305e-02f, 9.88284200e-02f, -6.87860921e-02f, -1.73481870e-02f, -8.19269475e-03f, 1.27914101e-01f, 1.07111968e-01f, 1.06636748e-01f, 5.86876571e-02f,
  7.53182769e-02f, 1.95778325e-01f, -3.05568613e-02f, 5.55341840e-02f, 1.51109220e-02f, 1.05674252e-01f, 5.34105115e-04f, 1.57952658e-03f, -2.75925994e-02f, 2.58798134e-02f,
  2.39871010e-01f, 4.96380031e-02f, -1.62542537e-01f, -1.95887759e-01f, -1.87892839e-01f, 3.15228373e-01f, 6.59982190e-02f, -1.71609148e-01f, -3.83871078e-01f, 1.39253870e-01f,
  -3.16068232e-02f, -1.40766844e-01f, 2.34780282e-01f, 2.55663488e-02f, 9.84566361e-02f, 1.39984965e-01f, -6.56944327e-03f, 2.85107661e-02f, -9.38233361e-03f, 9.21960175e-02f,
  6.26115203e-02f, 1.12580948e-01f, 3.40008102e-02f, 7.75858238e-02f, 1.55018523e-01f, -2.47532576e-02f, -4.68029417e-02f, -9.59327593e-02f, -1.08142942e-01f, -1.27970114e-01f,
  6.88961223e-02f, -7.87490327e-03f, -1.17005222e-02f, 2.07938179e-02f, 9.29525197e-02f, 1.54940886e-02f, 8.11841115e-02f, -2.93399952e-02f, -1.97873145e-01f, -3.59953195e-02f,
  -2.60668714e-02f, -7.11173611e-03f, -3.48133072e-02f, -5.03704771e-02f, -6.27737939e-02f, -2.33875699e-02f, 4.55162711e-02f, 1.45943807e-02f, -9.14910883e-02f, 1.49454653e-01f,
  9.86283273e-02f, -8.52244943e-02f, -1.24083282e-02f, -9.12123248e-02f, -9.49386433e-02f, -7.31513426e-02f, 1.67220265e-01f, 6.03730939e-02f, -9.41239819e-02f, -7.85903782e-02f,
  8.76685977e-02f, 1.02284029e-01f, 1.13706246e-01f, 7.08650649e-02f, -1.82172749e-03f, 2.07769200e-02f, -4.30458672e-02f, -1.73174422e-02f, 9.56673920e-02f, 2.86160689e-02f,
  -2.43528727e-02f, -1.82903349e-01f, -9.36451554e-03f, 2.72631701e-02f, 1.03946872e-01f, 2.08131205e-02f, -1.29634170e-02f, 4.01874352e-03f, 4.96259928e-02f, 7.66048580e-02f,
  -1.37335747e-01f, 1.02558471e-01f, 1.13487756e-02f, -1.14355482e-01f, -2.44548861e-02f, -6.30470887e-02f, 1.01094367e-02f, 3.33905057e-03f, -1.71722267e-02f, -3.73719819e-02f,
  -5.97221404e-02f, -5.12234345e-02f, 5.65286241e-02f, 2.64430754e-02f, 4.14522452e-04f, -1.00967055e-03f, -2.58501265e-02f, -1.22618480e-02f, -1.39798686e-01f, 4.31511737e-02f,
  2.36043357e-03f, -3.68412957e-02f, 1.42515851e-02f, 1.79016739e-02f, -1.49599642e-01f, 8.34704265e-02f, 1.03468679e-01f, -4.08567823e-02f, -1.62566736e-01f, -5.59619367e-02f,
  -6.89920317e-03f, 6.84414580e-02f, -7.41371233e-03f, 2.88019665e-02f, -6.86333179e-02f, -8.39507282e-02f, 1.10973723e-01f, 3.72804366e-02f, -5.19896410e-02f, -1.14922076e-01f,
  -2.48798043e-01f, 2.02000007e-01f, -1.08952649e-01f, -1.82272896e-01f, -1.72162987e-02f, -2.50878260e-02f, -1.04421183e-01f, 1.69389293e-01f, 1.29077330e-01f, 1.08168758e-01f,
  7.48575330e-02f, 2.76555829e-02f, 2.68576980e-01f, -1.26963928e-01f, -2.09945753e-01f, 6.74624145e-02f, -1.78963229e-01f, -9.25442055e-02f, 5.91089353e-02f, -1.45157790e-02f,
  -1.25761271e-01f, -4.65386510e-02f, -2.86075741e-01f, 1.58413842e-01f, -1.98257580e-01f, -5.18661663e-02f, -2.41942316e-01f, 7.35693723e-02f, -3.35268170e-01f, -2.94715874e-02f,
  -8.02745447e-02f, 4.28729095e-02f, -1.11810647e-01f, -1.27422109e-01f, -1.17654920e-01f, -5.53705879e-02f, -1.33909881e-01f, 7.44479243e-03f, 7.19100460e-02f, -1.70829166e-02f,
  3.40089351e-02f, 9.69875827e-02f, 7.22386017e-02f, 1.40595928e-01f, 5.61995385e-03f, -1.16800340e-02f, -1.10406384e-01f, -1.05040625e-01f, -1.77954510e-02f, -1.15947574e-01f,
  -9.95611586e-03f, -4.56637032e-02f, -9.02830064e-02f, -1.36997178e-01f, -7.55778924e-02f, -2.34882385e-02f, -1.30706966e-01f, -6.56695291e-02f, -1.05488352e-01f, -4.70772944e-02f,
  4.46479470e-02f, -5.55049889e-02f, -5.04200868e-02f, 7.97720999e-02f, 1.09955229e-01f, 4.51047122e-02f, 1.28110377e-02f, -2.13864110e-02f, 4.31720875e-02f, -1.13624901e-01f,
  -4.78848331e-02f, -5.26900329e-02f, 4.52218913e-02f, -5.86438319e-03f, -5.58618736e-03f, 7.52755702e-02f, 2.43376257e-04f, 3.89828980e-02f, -2.79522296e-02f, 1.39424857e-02f,
  1.84341017e-02f, 5.32750711e-02f, 4.76607457e-02f, -2.80657690e-02f, 3.13342810e-02f, -3.53314131e-02f, 4.87183370e-02f, -3.00993416e-02f, -5.11416011e-02f, 5.61441742e-02f,
  -1.44233137e-01f, -4.11370695e-02f, -4.31155749e-02f, -6.63645118e-02f, -3.57601047e-02f, -2.95721274e-02f, -1.53493294e-02f, -2.01263558e-02f, 5.19868545e-03f, 6.39591217e-02f,
  2.87088640e-02f, -2.08945014e-02f, -3.62165049e-02f, 1.78941097e-02f, 8.31002444e-02f, -3.93400341e-02f, -4.13917117e-02f, -5.08374646e-02f, -4.76184823e-02f, 5.46782790e-03f,
  -6.18875632e-03f, 1.34318937e-02f, 6.69304803e-02f, -8.81964117e-02f, -5.69345988e-02f, -1.50669897e-02f, -3.69461216e-02f, -5.97930364e-02f, 1.33528281e-02f, -4.75786291e-02f,
  -4.44538414e-01f, -5.09959608e-02f, -2.11869881e-01f, -4.31330837e-02f, -2.03597724e-01f, -2.13836014e-01f, -3.67484130e-02f, -1.79406300e-01f, -4.79321331e-02f, 2.73243725e-01f,
  2.18748778e-01f, -2.86196649e-01f, 1.63783610e-01f, 1.03779070e-01f, -3.85926276e-01f, 2.85094440e-01f, -3.79806794e-02f, -6.80740625e-02f, -4.19617482e-02f, -3.31831664e-01f,
  -2.00804785e-01f, -3.07398625e-02f, -9.40949768e-02f, -6.76233247e-02f, -1.53089494e-01f, -1.38930663e-01f, 1.50179639e-01f, -9.06307325e-02f, 7.20911548e-02f, -5.80164269e-02f,
  -1.67821065e-01f, -1.18067048e-01f, -5.17716929e-02f, -1.33250989e-02f, 3.26703768e-03f, 4.26499285e-02f, -2.12059598e-02f, 1.11175636e-02f, 8.01282097e-03f, -4.87349071e-02f,
  -8.88194367e-02f, -1.30392298e-01f, -2.86225490e-02f, 7.15824589e-03f, -1.16083398e-02f, -3.58875133e-02f, -3.63409407e-02f, 9.52862129e-02f, -4.86631542e-02f, -2.72721890e-02f,
  -9.72380489e-02f, 1.68627594e-02f, -2.04998385e-02f, 4.94410060e-02f, -1.59416944e-02f, -2.47046743e-02f, 1.08065091e-01f, -7.38326535e-02f, -7.78343296e-03f, 1.59928426e-02f,
  1.44460592e-02f, 2.34737620e-02f, -1.48784546e-02f, 4.26173955e-02f, 2.77006123e-02f, 6.58407211e-02f, -3.94937880e-02f, 2.12357193e-02f, 4.11913879e-02f, -8.38469528e-03f,
  -2.22119614e-02f, 3.31474319e-02f, -1.65830646e-02f, 2.65551284e-02f, 8.93387944e-02f, 6.28035441e-02f, -6.65421188e-02f, -9.34069827e-02f, 4.23340276e-02f, 3.54459533e-03f,
  -3.09961028e-02f, -3.21066827e-02f, 2.48918328e-02f, 6.71936339e-03f, -7.81069845e-02f, -3.28564681e-02f, -8.23332835e-03f, 3.80786099e-02f, -4.04942445e-02f, -8.13608989e-02f,
  -2.96108216e-01f, -2.56061941e-01f, -9.49009359e-02f, -4.25058156e-02f, -7.36405747e-03f, 4.10123803e-02f, 6.13537468e-02f, 2.33916920e-02f, -3.19824032e-02f, -3.47322300e-02f,
  -1.09118447e-01f, 8.86814147e-02f, 1.51958484e-02f, 8.90783668e-02f, -2.87143607e-02f, 8.33048820e-02f, -1.13059737e-01f, 6.05608150e-03f, -1.02054767e-01f, -1.25066653e-01f,
  -6.48288894e-03f, -6.78218529e-02f, 1.17761046e-02f, 4.99325544e-02f, 7.81719238e-02f, -5.43439528e-03f, -8.19837376e-02f, 5.75096346e-02f, 2.39695851e-02f, 3.00016403e-02f,
  3.72593454e-03f, 2.65279800e-01f, 1.63343310e-01f, 1.45178556e-01f, 4.39020395e-02f, 2.89339870e-01f, 1.60707563e-01f, -9.48613510e-03f, 1.96170360e-01f, 1.07933946e-01f,
  -1.97702125e-01f, 3.73191863e-01f, -2.82701291e-02f, -1.67726412e-01f, -1.06248647e-01f, -2.13156305e-02f, 4.15357091e-02f, 1.69502825e-01f, 8.96282047e-02f, 1.34562939e-01f,
  -8.09883401e-02f, -6.52654171e-02f, -2.71782607e-01f, -1.16161659e-01f, 6.91739321e-02f, 2.64194235e-02f, -1.76721200e-01f, 1.00290552e-01f, -4.72576311e-03f, 1.00346338e-02f,
  -4.57657091e-02f, -1.00979144e-02f, -3.05049941e-02f, 1.89210270e-02f, -8.23829509e-03f, 1.42279655e-01f, 6.97547570e-03f, 9.31336582e-02f, 5.09387776e-02f, 3.60072311e-03f,
  5.62866293e-02f, 2.85496539e-03f, -4.49994914e-02f, 9.29190889e-02f, -1.11674182e-02f, -2.24693771e-02f, -1.42589537e-02f, -5.29056266e-02f, -6.58990666e-02f, 5.75582981e-02f,
  -3.03746387e-02f, -5.58416136e-02f, -4.06916812e-02f, -1.28813647e-03f, -6.60667419e-02f, 6.83374032e-02f, 1.93849638e-01f, 8.61820579e-02f, 2.87415436e-03f, 1.36567861e-01f,
  4.28125029e-03f, 2.07289323e-01f, 2.30855751e-03f, -2.17194203e-02f, -1.82261188e-02f, 3.90668511e-02f, 1.22279292e-02f, -1.11114988e-02f, 4.01605554e-02f, 9.46112573e-02f,
  -2.30851825e-02f, 9.51173380e-02f, -7.43650049e-02f, 7.62655735e-02f, 1.53671890e-01f, 3.89732234e-02f, 3.25665716e-03f, 1.04209773e-01f, -1.30578810e-02f, 5.10867871e-02f,
  -3.52449641e-02f, -3.15108821e-02f, 2.83648819e-02f, 4.22122609e-03f, -5.97273447e-02f, -9.46014374e-02f, 2.76983287e-02f, -1.01259053e-01f, -5.95584605e-03f, 9.91705954e-02f,
  1.52690902e-01f, 3.60688448e-01f, 2.65629310e-03f, -6.40833527e-02f, -1.08253844e-02f, 6.42702356e-02f, 1.06322110e-01f, 8.40758905e-02f, 1.35377288e-01f, 1.74840987e-01f,
  4.79853339e-02f, 1.10132605e-01f, -1.77519629e-03f, -8.15903842e-02f, -7.98934996e-02f, 1.16477892e-01f, 4.95499261e-02f, 5.95351346e-02f, -5.86931184e-02f, 2.64910087e-02f,
  -2.58320011e-02f, 6.34275302e-02f, 9.13034305e-02f, 5.05051129e-02f, 4.44692597e-02f, -1.94514971e-02f, 5.22001944e-02f, -2.18120571e-02f, 2.49852203e-02f, 5.52208014e-02f,
  9.71721038e-02f, 5.24871759e-02f, 3.21420878e-01f, 1.53494492e-01f, 1.42690867e-01f, 1.92197755e-01f, 1.48147747e-01f, 1.22081906e-01f, 4.36060935e-01f, -1.64612964e-01f,
  -2.07819372e-01f, 5.71439937e-02f, 4.65569980e-02f, 3.99077125e-03f, 6.31471127e-02f, 7.60343596e-02f, 1.42263889e-01f, 1.29724219e-01f, 9.64290872e-02f, -3.81227620e-02f,
  1.23617202e-01f, -2.65174538e-01f, -1.16286958e-02f, -1.43837720e-01f, 1.05894141e-01f, 5.66475093e-02f, -2.06983954e-01f, 1.05604239e-01f, -1.26681402e-01f, 4.21039797e-02f,
  -7.34377885e-03f, -4.14309166e-02f, -1.26318466e-02f, 3.29669416e-02f, -1.65530089e-02f, -4.78397543e-03f, 4.91270982e-02f, 1.10602714e-02f, -3.15183140e-02f, -1.24468710e-02f,
  4.05679718e-02f, -1.55408606e-02f, -9.94313732e-02f, -3.42177637e-02f, 1.07800201e-01f, -5.82070928e-03f, 8.54632854e-02f, 7.85486624e-02f, 5.44706695e-02f, 1.15270086e-01f,
  1.70789599e-01f, 4.81537730e-02f, 1.04419589e-02f, -3.93179730e-02f, -3.41762602e-02f, 4.94798733e-05f, 7.11513683e-02f, -3.02536823e-02f, 2.53463779e-02f, -3.47416066e-02f,
  -2.01243944e-02f, 6.94963103e-03f, -4.42746319e-02f, -1.89046450e-02f, -3.96348648e-02f, 2.41963509e-02f, 6.66597933e-02f, -6.53356761e-02f, 3.16842683e-02f, -3.71473059e-02f,
  -2.65840124e-02f, -1.22285664e-01f, 1.35581776e-01f, 4.58310433e-02f, -2.13017762e-02f, -4.57565449e-02f, -2.60259528e-02f, 7.69746676e-02f, 7.93783292e-02f, -7.43662268e-02f,
  4.93623363e-03f, 6.72325194e-02f, -8.27562809e-02f, 5.97525574e-02f, -5.05761430e-02f, 3.46669890e-02f, 3.01646832e-02f, 1.06277436e-01f, -4.06424813e-02f, -3.80685218e-02f,
  -1.11685224e-01f, -1.08604327e-01f, -2.32201461e-02f, -9.37578604e-02f, 7.47847930e-02f, -1.74045891e-01f, 2.56630778e-02f, -3.27991061e-02f, -3.53602096e-02f, -6.26931414e-02f,
  -7.81641994e-03f, -3.22995484e-02f, -3.46070863e-02f, 4.97323871e-02f, -1.05200849e-01f, -7.24621117e-02f, 2.36775242e-02f, -5.73205948e-02f, -4.74955291e-02f, -5.58154881e-02f,
  8.72619823e-03f, -6.47581741e-02f, 6.46300754e-03f, -8.34245384e-02f, -1.97570715e-02f, -1.03608847e-01f, -9.21941400e-02f, 7.98834302e-03f, -4.21727970e-02f, -6.25289837e-03f,
  -1.61619440e-01f, 2.33572602e-01f, 4.34315577e-02f, -2.37156078e-01f, -1.61279105e-02f, 2.77706921e-01f, -5.92662096e-02f, 1.73093125e-01f, 2.31342465e-01f, -1.85211394e-02f,
  -2.18806580e-01f, -1.20073318e-01f, 6.49403641e-03f, -2.48858646e-01f, 1.03410304e-01f, 2.00254068e-01f, -6.95241289e-03f, -1.45729661e-01f, 1.61188915e-01f, -9.23447311e-02f,
  -1.50188699e-01f, -3.78921807e-01f, -1.32421270e-01f, -4.10474762e-02f, -2.76282042e-01f, 1.86174009e-02f, -2.56207466e-01f, 9.80204064e-03f, -2.19593585e-01f, 8.98234323e-02f,
  -2.92711891e-02f, -6.22586235e-02f, -9.02878791e-02f, -7.79242162e-03f, 1.46913782e-01f, 1.64422616e-02f, -4.15658345e-03f, -1.03390194e-03f, 6.31882772e-02f, -2.55373586e-02f,
  -3.11266282e-03f, 1.91413555e-02f, -3.03359963e-02f, -7.59089813e-02f, -1.07177839e-01f, -2.25924999e-02f, -6.91953450e-02f, 7.19245989e-03f, 6.29040180e-03f, -3.65090147e-02f,
  -1.19967602e-01f, 2.99309231e-02f, -2.57885605e-02f, 3.27160470e-02f, -3.86419781e-02f, -1.02662623e-01f, 5.57631403e-02f, -3.60311680e-02f, 4.69898395e-02f, 9.18785483e-02f,
  9.10670012e-02f, -1.36649963e-02f, -5.35531528e-02f, -8.51682499e-02f, 3.39987837e-02f, 1.06132396e-01f, -9.87418070e-02f, 1.82875078e-02f, 5.41911125e-02f, -1.10518888e-01f,
  -2.80457307e-02f, -9.78202000e-03f, 5.37420250e-02f, -1.04156375e-01f, 2.97854422e-03f, -9.53764841e-02f, -1.36067094e-02f, -2.44620536e-02f, -1.07124308e-02f, 3.48894112e-02f,
  1.32948335e-03f, -3.68044339e-02f, -8.73043016e-02f, 8.57582409e-03f, 5.59787452e-03f, -3.28912213e-03f, -6.33638352e-02f, -9.97919682e-03f, -2.10266691e-02f, -1.42173752e-01f,
  1.22976623e-01f, 3.59159112e-01f, 1.63710117e-02f, -5.66727407e-02f, 9.00009274e-02f, -6.37829769e-03f, 7.40385652e-02f, 1.86675768e-02f, 1.43655688e-01f, 2.88503617e-03f,
  -1.09645329e-01f, 3.67656141e-03f, 2.73757894e-02f, -3.72080766e-02f, 4.77038957e-02f, -3.11314315e-02f, 2.30286010e-02f, -4.66997502e-03f, 1.47588462e-01f, 1.28669411e-01f,
  -1.23027079e-01f, 7.46955574e-02f, -9.50379372e-02f, -4.10483666e-02f, -6.73674792e-02f, -1.02869391e-01f, 3.03433016e-02f, -9.88999233e-02f, 9.64330789e-03f, 1.91804066e-01f,
  2.36003712e-01f, -1.34691581e-01f, 1.93046048e-01f, 3.43767285e-01f, 1.50499761e-01f, -8.35776180e-02f, 1.83932707e-02f, 1.29016954e-02f, 3.15131783e-01f, -1.67838231e-01f,
  -1.50807187e-01f, 8.91723931e-02f, -3.46948594e-01f, 2.25997746e-01f, -1.53283179e-01f, -2.25055903e-01f, 2.28686213e-01f, 5.26432246e-02f, 3.47921476e-02f, 1.27226245e-02f,
  1.99810550e-01f, -1.18388787e-01f, -5.89770116e-02f, 2.23992597e-02f, 9.40036252e-02f, 2.32745230e-01f, -1.65476233e-01f, -6.97267279e-02f, 3.01729947e-01f, 4.37321253e-02f,
  2.50108372e-02f, -1.78806670e-03f, 7.93242007e-02f, 3.83494906e-02f, 2.16143392e-02f, -6.41447231e-02f, -5.69809824e-02f, -9.10290480e-02f, -2.91869082e-02f, 6.08576983e-02f,
  -6.96146935e-02f, 6.08577486e-03f, 3.46230082e-02f, 3.91173027e-02f, 6.01278767e-02f, 8.05312470e-02f, 1.29302427e-01f, 2.55011301e-03f, 5.68173863e-02f, 8.92434968e-04f,
  5.60946800e-02f, 5.24609759e-02f, 4.65433002e-02f, 6.82893768e-02f, 2.42135189e-02f, 1.49934068e-01f, 1.02298237e-01f, 2.41800752e-02f, 1.10252887e-01f, 1.23966403e-01f,
  -3.73963080e-02f, -5.06719984e-02f, -1.15356937e-01f, -1.69512387e-02f, -2.22475082e-02f, 1.55631388e-02f, -6.95697963e-03f, -9.08160880e-02f, 5.53782564e-03f, -3.67036574e-02f,
  2.75229830e-02f, -4.22674902e-02f, -2.86523290e-02f, 4.62645628e-02f, -5.53342588e-02f, 1.09855020e-02f, 2.05845777e-02f, 7.81439617e-02f, 1.96439046e-02f, 7.44750649e-02f,
  -1.72236636e-02f, 2.96249520e-02f, -5.85347526e-02f, -1.72630809e-02f, 4.40765768e-02f, -1.12289391e-01f, 4.09650058e-02f, 3.83146554e-02f, 7.46411784e-03f, -1.54649585e-01f,
  -3.05688202e-01f, -3.25905502e-01f, 8.54720324e-02f, 3.09193730e-02f, 1.91694871e-02f, -9.16360170e-02f, -6.56020362e-03f, -1.70780104e-02f, -1.63904920e-01f, -1.49727641e-02f,
  1.71540841e-03f, 4.71161818e-03f, -4.70805988e-02f, 1.09461814e-01f, -1.26057188e-03f, -9.67434943e-02f, -1.06169945e-02f, -5.70781715e-02f, -6.11475334e-02f, 2.20588241e-02f,
  3.39203142e-02f, -1.42620236e-01f, 1.27821397e-02f, 3.07596140e-02f, 6.90447390e-02f, -5.89889623e-02f, -5.94325177e-02f, 7.80571178e-02f, 1.00542726e-02f, -1.61412377e-02f,
  -1.49641648e-01f, 1.56162500e-01f, 4.14923020e-02f, 1.04990229e-01f, 1.96707994e-01f, 1.83322057e-01f, 1.72427788e-01f, 3.11321795e-01f, 3.19816887e-01f, -2.30242103e-01f,
  -1.94774672e-01f, -2.69104272e-01f, -5.14523610e-02f, -3.14545578e-05f, 1.37434267e-02f, 2.82765906e-02f, 9.60858837e-02f, -1.50810957e-01f, 3.71425271e-01f, -5.90277985e-02f,
  1.19218476e-01f, -8.43231604e-02f, 1.41035914e-02f, 1.37001231e-01f, -3.57213691e-02f, 1.01388633e-01f, -1.09214932e-01f, 1.95234105e-01f, -2.16605827e-01f, 5.27255163e-02f,
  -3.58673919e-04f, 1.10358037e-01f, -4.15309146e-02f, -6.65961280e-02f, -1.03526242e-01f, -6.84071258e-02f, -1.31982133e-01f, -1.00430846e-01f, 7.52733201e-02f, -4.20113653e-02f,
  -1.25485837e-01f, -8.66382495e-02f, 1.19885541e-02f, 7.80327916e-02f, 1.47247881e-01f, -3.01627330e-02f, -1.44402375e-02f, 3.86193246e-02f, 1.08382255e-01f, 2.66187489e-02f,
  -7.30268843e-03f, -3.17729078e-02f, 3.41772400e-02f, -4.50582169e-02f, -2.54052486e-02f, 1.31757468e-01f, -1.19245946e-01f, -5.23165949e-02f, -7.31852651e-02f, 2.72521824e-02f,
  1.52563572e-01f, 1.24796972e-01f, -5.80114573e-02f, -1.10541098e-03f, -4.98053133e-02f, -3.53509672e-02f, -9.95494947e-02f, -1.19894817e-01f, -8.57960284e-02f, -3.43113206e-02f,
  3.25435586e-02f, -4.18575993e-03f, 6.44480512e-02f, 4.34289649e-02f, 2.22988054e-02f, -5.66092692e-02f, -3.32742790e-03f, -8.04615170e-02f, 2.50720270e-02f, 1.12888180e-01f,
  2.71292794e-02f, 1.09856296e-02f, -2.31343582e-02f, -8.15680549e-02f, 4.51360755e-02f, -7.99223036e-03f, 1.39326463e-02f, 1.99495815e-02f, 1.16498508e-02f, -7.70407077e-03f,
  -8.05668682e-02f, -8.86257142e-02f, 5.09049408e-02f, -4.03695107e-02f, -7.64815211e-02f, -7.18376227e-03f, -4.62427512e-02f, -3.48743051e-02f, 2.45556477e-02f, -5.80441691e-02f,
  -7.92356953e-03f, -1.69910908e-01f, -1.29205465e-01f, -8.35074461e-04f, 4.60222028e-02f, -3.39776315e-02f, -5.41717522e-02f, 1.00186393e-01f, -3.31879556e-02f, 1.72836296e-02f,
  -8.67312625e-02f, -6.41034544e-02f, -7.18466416e-02f, 4.50415015e-02f, -1.00828111e-01f, -4.32699136e-02f, -1.06220841e-01f, 2.11724360e-02f, -1.13883883e-01f, 1.37387207e-02f,
  3.79349828e-01f, 2.49355629e-01f, 1.25777990e-01f, 2.95356393e-01f, 3.15621763e-01f, 3.09772968e-01f, 4.56739683e-03f, 2.27812365e-01f, 4.62024063e-01f, 2.54290737e-03f,
  8.93234760e-02f, 5.93184121e-02f, -1.95768863e-01f, 1.19310856e-01f, -1.78579669e-02f, -5.07020168e-02f, 2.79730201e-01f, 1.71722531e-01f, 1.14731610e-01f, 1.78974286e-01f,
  6.60129040e-02f, -4.12905067e-02f, -3.25930655e-01f, -1.49707735e-01f, 8.02418515e-02f, -8.75210837e-02f, -4.08152103e-01f, -2.44309366e-01f, -1.36623651e-01f, -7.69214109e-02f,
  -8.90778750e-03f, 9.79804322e-02f, -1.32303894e-01f, -1.80657461e-01f, 9.56542343e-02f, 4.33561727e-02f, -1.17797539e-01f, -1.36015534e-01f, -1.57414246e-02f, -4.34063524e-02f,
  -2.52266717e-03f, -6.05924465e-02f, -6.40501792e-04f, -8.21271390e-02f, 6.70404360e-02f, 7.37122372e-02f, -9.53877869e-04f, 5.32940477e-02f, 9.43647698e-03f, -2.02541687e-02f,
  -1.16599789e-04f, 1.12628780e-01f, 1.60611928e-01f, 3.52583849e-03f, 4.00392078e-02f, 3.03625241e-02f, -6.10886663e-02f, 5.75302243e-02f, 7.65135735e-02f, 6.24996163e-02f,
  -7.43835196e-02f, -6.04395336e-03f, -6.66925833e-02f, -1.15022920e-01f, 6.23738719e-03f, 5.12054190e-02f, 6.21576123e-02f, 2.08378397e-02f, 1.07173428e-01f, 4.63526212e-02f,
  4.64514345e-02f, 7.79563636e-02f, 1.27926826e-01f, 2.30698586e-02f, 1.48251981e-01f, 7.73846880e-02f, -5.42789698e-03f, 6.98569641e-02f, 1.53199598e-01f, -7.82113895e-03f,
  -5.46364672e-02f, 2.04316061e-02f, -1.00373670e-01f, -2.17190180e-02f, -1.14856139e-02f, -5.15485816e-02f, 4.72055599e-02f, 7.24527538e-02f, -5.50449919e-03f, 1.08168565e-01f,
  1.42684430e-01f, 1.98700368e-01f, -4.16066051e-02f, -1.65446866e-02f, 2.51438580e-02f, 1.56160101e-01f, 2.84596384e-02f, 1.20557941e-01f, 1.59135431e-01f, 8.79380777e-02f,
  8.96001607e-02f, -9.85746384e-02f, 1.08314723e-01f, -3.71539406e-02f, -4.15020250e-02f, 7.87338894e-03f, -6.43402487e-02f, 7.92329684e-02f, 6.43502101e-02f, -6.19592890e-02f,
  -9.78638679e-02f, 1.12555720e-01f, 6.73861504e-02f, 4.87906523e-02f, 1.19762763e-01f, 3.46306115e-02f, 3.28868777e-02f, -4.31214236e-02f, 4.84790206e-02f, 3.80699523e-02f,
  -2.70695418e-01f, -1.23625984e-02f, 1.28377229e-01f, -2.34277681e-01f, -6.76672012e-02f, -1.04567967e-01f, -3.58142793e-01f, 1.61665320e-01f, 2.57594120e-02f, -1.01574317e-01f,
  -1.32227406e-01f, -1.09073795e-01f, 1.53160468e-01f, -7.10462555e-02f, 1.96276471e-01f, 1.65167600e-01f, -1.92607492e-02f, -3.02603766e-02f, 6.83381334e-02f, -1.17406875e-01f,
  1.67304784e-01f, -1.39954850e-01f, 2.71131217e-01f, 1.39311507e-01f, -9.26131830e-02f, 9.95539576e-02f, 1.46282971e-01f, 7.13845789e-02f, 1.28195703e-01f, 1.90187469e-02f,
  -2.87302565e-02f, -1.07779719e-01f, -1.49224568e-02f, 1.34711847e-01f, 1.14781044e-01f, -5.07278517e-02f, -4.17016894e-02f, -1.62565184e-03f, -7.03651384e-02f, 9.22645554e-02f,
  9.02686734e-03f, 1.13844074e-01f, -3.09652854e-02f, -8.06342624e-03f, 6.64841803e-03f, 7.55769536e-02f, 1.52704701e-01f, 3.58321108e-02f, -6.70411512e-02f, 3.45008867e-03f,
  6.84882328e-02f, 9.64733139e-02f, 2.03628596e-02f, 6.63246736e-02f, 2.47404296e-02f, -1.56519152e-02f, 1.93166509e-02f, 6.66299909e-02f, 3.55325243e-03f, 2.78497655e-02f,
  4.87795807e-02f, 2.07493585e-02f, 1.55419307e-02f, 3.94323878e-02f, -8.16586167e-02f, -8.14530551e-02f, -4.29965518e-02f, -1.22013576e-02f, -5.65228276e-02f, -2.58101504e-02f,
  -5.94285876e-02f, -8.92843306e-02f, -2.39508729e-02f, 5.42843454e-02f, 1.89670920e-02f, -8.37319344e-02f, 9.00149625e-03f, 6.54078573e-02f, 6.44950345e-02f, -2.01659533e-03f,
  -9.20295343e-02f, 8.27608407e-02f, 2.21876837e-02f, 2.54740566e-02f, -5.42730168e-02f, 3.80695872e-02f, 4.18326370e-02f, -3.83378379e-02f, 8.26436654e-02f, 3.60983983e-02f,
  1.57670919e-02f, 3.55046131e-02f, -1.94076337e-02f, -8.36059898e-02f, -3.94444130e-02f, -2.66443230e-02f, 1.41629344e-02f, 2.04569418e-02f, -2.19523031e-02f, -2.23937836e-02f,
  6.60597458e-02f, 6.52415156e-02f, -4.53674719e-02f, -6.54424503e-02f, 1.23023905e-01f, 8.13674647e-03f, 3.52654234e-02f, -3.02081089e-02f, -4.65231165e-02f, 1.26137724e-02f,
  2.88688596e-02f, -3.92688103e-02f, 4.03803214e-02f, 9.03827511e-03f, -1.06091395e-01f, -6.45935088e-02f, -8.93138349e-02f, 3.36944833e-02f, 8.80315248e-03f, -6.53412491e-02f,
  -3.81692648e-01f, 1.21223219e-01f, -4.49627191e-01f, -1.27351224e-01f, 3.05789441e-01f, 6.24358989e-02f, 1.98628046e-02f, 1.73588902e-01f, 4.09481563e-02f, 3.47629815e-01f,
  3.46965671e-01f, 1.07363604e-01f, 1.08255029e-01f, 1.28551751e-01f, -2.73245811e-01f, -1.96722299e-02f, -1.36491433e-01f, -1.06073350e-01f, -1.15502223e-01f, -4.90773469e-02f,
  -2.06744611e-01f, 2.35582560e-01f, -2.36059487e-01f, 9.72630903e-02f, 1.21181272e-01f, -6.43987805e-02f, 3.41015570e-02f, 9.50827375e-02f, 1.11697175e-01f, 2.38988027e-01f,
  -1.44376028e-02f, -6.90641254e-02f, -1.02669615e-02f, -9.65561196e-02f, -6.38941526e-02f, -4.43079025e-02f, -1.13637269e-01f, 9.25636142e-02f, 8.11633393e-02f, -2.06834823e-02f,
  -2.18467098e-02f, 1.41019011e-02f, 2.88788974e-02f, 3.64384726e-02f, -4.17638868e-02f, 5.08625098e-02f, 3.67586836e-02f, 4.21572998e-02f, 1.74868982e-02f, -1.07028984e-01f,
  -5.57070039e-02f, -1.12494081e-01f, -6.79555312e-02f, 2.26662727e-03f, -5.11155929e-03f, 6.83164522e-02f, -4.14543934e-02f, -5.80351539e-02f, -1.12584472e-01f, 4.12231646e-02f,
  -8.13471749e-02f, -5.16636595e-02f, -7.99444132e-03f, 1.13298735e-02f, 4.74650636e-02f, 4.92258836e-03f, 6.31105080e-02f, 6.17350964e-03f, 3.14244069e-02f, 5.36111817e-02f,
  -1.09070614e-02f, -6.65505156e-02f, 6.13497198e-02f, -1.06468156e-01f, -3.80757474e-03f, 1.36894714e-02f, -2.71728933e-02f, 1.93675943e-02f, -3.20005901e-02f, -8.11448321e-02f,
  1.42588601e-01f, -5.43310083e-02f, 9.19924527e-02f, 5.58350561e-03f, -3.57734524e-02f, 6.89094663e-02f, -5.26975729e-02f, 6.16303384e-02f, 2.24485379e-02f, -4.31544594e-02f,
  -6.11556768e-02f, -2.12116957e-01f, 1.20277278e-01f, 6.91445097e-02f, 5.32677211e-02f, -3.06742974e-02f, -4.48804237e-02f, 3.76982614e-02f, 3.71472873e-02f, 7.76721304e-03f,
  -1.45661473e-01f, -3.05660330e-02f, -1.14913896e-01f, 1.47387208e-02f, -1.42683217e-03f, 9.35456231e-02f, 5.04338630e-02f, 1.00083359e-01f, 1.93622690e-02f, 1.15794642e-02f,
  1.75038055e-02f, -6.78669754e-03f, 2.27544755e-02f, 3.27633210e-02f, -1.47509883e-04f, 1.09696515e-01f, 4.15305719e-02f, 4.30419110e-02f, 5.07376669e-03f, -6.32236805e-03f,
  4.07297641e-01f, -1.99951783e-01f, 1.72069848e-01f, 3.77334803e-01f, 1.70709804e-01f, -2.17999108e-02f, 2.20054194e-01f, 9.78754163e-02f, 4.32964057e-01f, -2.00940534e-01f,
  -3.67595181e-02f, 5.16729318e-02f, 1.00168571e-01f, -9.94988456e-02f, 4.68541496e-02f, -1.72757525e-02f, 5.69396801e-02f, 7.20000491e-02f, 2.27319717e-01f, 1.77344963e-01f,
  2.30437800e-01f, -1.92359522e-01f, -3.75713743e-02f, -1.97907716e-01f, -5.65186236e-03f, 2.05592904e-02f, -2.52227545e-01f, -2.55453447e-03f, -2.26276159e-01f, -8.32023472e-02f,
  1.41047835e-02f, 5.26942052e-02f, -5.62093668e-02f, -8.72481763e-02f, 5.24457395e-02f, -1.18966922e-02f, -4.63830121e-02f, -1.93950478e-02f, 7.53027275e-02f, -4.42786179e-02f,
  1.19691128e-02f, -1.73786078e-02f, -1.10087939e-01f, -2.47448254e-02f, 9.60298106e-02f, 1.46655226e-02f, 4.87214252e-02f, 5.59587888e-02f, -3.11562363e-02f, 1.94287859e-02f,
  1.20008655e-01f, -2.42398456e-02f, 3.35566327e-02f, -1.38191938e-01f, -2.84184851e-02f, -2.76295803e-02f, -2.76486725e-02f, -1.20491602e-01f, 2.75148470e-02f, -4.06995006e-02f,
  -1.59903735e-01f, 1.83606707e-02f, -5.71352914e-02f, 3.82234231e-02f, 5.79925673e-03f, 1.14454016e-01f, 6.04104437e-02f, -2.85727289e-02f, 6.24512210e-02f, 4.01141793e-02f,
  2.35835370e-02f, -5.60377575e-02f, 1.27698341e-02f, 7.05312118e-02f, 4.60524336e-02f, -8.65653739e-04f, -1.63624454e-02f, 3.15923505e-02f, 8.05578455e-02f, 6.06125221e-02f,
  -4.10978012e-02f, 4.51119840e-02f, -3.26271914e-02f, 1.18081467e-02f, 5.42682633e-02f, 1.14665970e-01f, 4.11729552e-02f, 8.36017877e-02f, -5.45826135e-03f, 4.85224836e-02f,
  -1.15309581e-01f, -1.01740986e-01f, -3.51300798e-02f, -3.91707309e-02f, -5.36461510e-02f, -1.05302818e-01f, 2.24913564e-03f, -2.05805767e-02f, -2.35019135e-03f, -4.86183390e-02f,
  -9.76246875e-03f, -1.46061257e-02f, -1.39214061e-02f, 7.26227183e-03f, 1.10051911e-02f, -6.26574308e-02f, 3.51715460e-02f, 2.88037006e-02f, -9.15561691e-02f, -2.08001863e-02f,
  5.59890643e-02f, 1.36736585e-02f, 1.81258898e-02f, -5.07170483e-02f, -1.23739794e-01f, -6.40434623e-02f, 4.48015593e-02f, -4.11612242e-02f, -1.58530287e-02f, -3.96578237e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  2.56923646e-01f, 2.54889280e-01f, 2.83018142e-01f, 2.03057468e-01f, 1.59979522e-01f, 2.88364351e-01f, 2.41418242e-01f, 2.11880207e-01f, 1.22146592e-01f, 1.46397129e-01f,
  3.38625968e-01f, 3.61968100e-01f, 3.52703422e-01f, 1.17641464e-01f, 2.62202710e-01f, 1.92611486e-01f, 2.06804246e-01f, 1.94609866e-01f, 1.08723551e-01f, 5.28171547e-02f,
  2.94240773e-01f, 3.25349241e-01f, 2.88498551e-01f, 1.94829211e-01f, 2.60828227e-01f, 2.37295225e-01f, 2.62715250e-01f, 2.17748567e-01f, 2.12303057e-01f, 2.27690130e-01f,
  2.21111536e-01f, 1.61061570e-01f, 1.90508038e-01f, 2.74723917e-01f, 1.57057479e-01f, 2.32051492e-01f, 2.28771195e-01f, 9.85097587e-02f, 2.79654801e-01f, 3.13107103e-01f,
  1.40067950e-01f, 2.24144161e-01f, 2.37411588e-01f, 2.28412479e-01f, 1.22011699e-01f, 2.14697927e-01f, 1.73618823e-01f, 1.55525982e-01f, 1.15653910e-01f, 2.47367486e-01f,
  2.20680326e-01f, 2.63328403e-01f, 2.01946542e-01f, 2.53658563e-01f, 2.22406745e-01f, 1.67826489e-01f, 1.59173355e-01f, 2.39134312e-01f, 1.27709225e-01f, 1.79894775e-01f,
  2.68029749e-01f, 3.36481392e-01f, 1.85511351e-01f, 3.20198208e-01f, 3.06244403e-01f, 2.07600549e-01f, 2.44763613e-01f, 1.82813793e-01f, 1.64510787e-01f, 2.89556056e-01f,
  2.79388130e-01f, 1.62033170e-01f, 2.19214931e-01f, 2.57238269e-01f, 2.68124342e-01f, 2.44517118e-01f, 2.10993797e-01f, 1.97135851e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  5.77902459e-02f, -1.70798689e-01f, -7.65978619e-02f, -1.64943207e-02f, -1.99488595e-01f, 3.58819775e-02f, -1.05793804e-01f, 4.75405417e-02f, -1.62937969e-01f, -1.55393243e-01f,
  -1.86719254e-01f, -2.42217854e-01f, 5.41416183e-02f, -7.67434314e-02f, -2.17536941e-01f, -3.53514105e-02f, 7.25202188e-02f, -2.43994761e-02f, 9.22358483e-02f, -1.53577700e-01f,
  1.23781405e-01f, -1.32892922e-01f, 1.44703150e-01f, 1.31053347e-02f, -2.01216061e-02f, -2.40848213e-03f, 8.27445835e-02f, -1.41625702e-01f, 2.92034566e-01f, 3.99450839e-01f,
  1.12312153e-01f, 4.01139975e-01f, 2.81753808e-01f, -1.80007577e-01f, 2.89633542e-01f, -1.27466768e-01f, -3.09336990e-01f, 2.18525812e-01f, -4.39597696e-01f, 2.36566141e-01f,
  -2.23482862e-01f, 6.30601943e-02f, 6.11673817e-02f, -1.65892556e-01f, 2.33524933e-01f, -1.25562862e-01f, 2.32546955e-01f, 5.46034873e-02f, -5.56079857e-02f, 2.03243718e-02f,
  -1.45288646e-01f, -3.29758346e-01f, -2.09775031e-01f, -4.83800955e-02f, 2.49809042e-01f, 7.32405931e-02f, -1.21838227e-01f, 5.56195639e-02f, -3.34663182e-01f, 4.12307009e-02f,
  -2.18067124e-01f, -2.26122528e-01f, -7.58926347e-02f, -5.73632419e-02f, 1.09321617e-01f, -2.84514874e-01f, 1.64667383e-01f, 6.21067919e-02f, -1.08760782e-01f, -6.09764718e-02f,
  -5.82453050e-02f, -2.34959453e-01f, -2.60875881e-01f, 3.27551872e-01f, -4.11390126e-01f, -4.71890569e-01f, 2.45301612e-03f, -1.83527857e-01f, -1.77216455e-01f, 4.13611650e-01f,
  -9.98127833e-02f, 4.50988263e-01f, -1.42788991e-01f, 3.09899479e-01f, 3.38950485e-01f, -3.40908557e-01f, 2.93763578e-01f, 3.39778811e-01f, -1.65903240e-01f, -1.41312554e-01f,
  -3.07825357e-01f, -2.77877659e-01f, -4.12506312e-01f, 4.94642884e-01f, -5.29484078e-02f, -9.84687954e-02f, 2.70060915e-03f, -1.59552217e-01f, -1.42921209e-01f, 4.45093721e-01f,
  -2.52902329e-01f, 3.22220683e-01f, -1.88730106e-01f, -2.50123352e-01f, -3.08083355e-01f, 1.20289907e-01f, -5.55218399e-01f, -7.78805763e-02f, -2.18473822e-01f, 5.40265739e-01f,
  -2.32396126e-01f, -7.80421570e-02f, -3.46180350e-01f, -3.67888480e-01f, -4.93268818e-02f, 1.53438359e-01f, 1.22228868e-01f, -1.92237437e-01f, 6.12131298e-01f, -4.74359870e-01f,
  -1.54092312e-01f, -3.26539755e-01f, -7.97323585e-02f, -2.46717080e-01f, -4.32927072e-01f, -1.03340015e-01f, 3.20414118e-02f, -3.72723907e-01f, 2.48758122e-01f, -2.69673347e-01f,
  5.90255931e-02f, -3.35657820e-02f, -3.00352816e-02f, -1.12687789e-01f, 4.74936776e-02f, -2.85543114e-01f, 2.70606391e-02f, 1.52775459e-02f, 5.29114436e-03f, 3.76184881e-02f,
  1.20919302e-01f, -3.55969882e-04f, 2.01232880e-01f, 3.06350738e-02f, -2.24856824e-01f, 6.93578497e-02f, -2.48267978e-01f, 6.67413324e-02f, 5.93152083e-02f, -2.02536047e-01f,
  7.30344676e-04f, -1.06237672e-01f, -3.59427114e-03f, -2.50364244e-01f, 3.44778836e-01f, -2.36636981e-01f, 3.09088647e-01f, -2.30706781e-01f, 2.21884653e-01f, -3.91599685e-01f,
  1.81371897e-01f, -7.51651824e-02f, -1.82838187e-01f, -2.15340644e-01f, 3.64576846e-01f, -4.38457131e-01f, 4.58420575e-01f, -2.31135622e-01f, -1.32484138e-01f, 3.06475043e-01f,
  3.49308014e-01f, -2.92312235e-01f, -1.96791306e-01f, 2.98390955e-01f, -3.48129682e-02f, -3.69606972e-01f, -4.55240369e-01f, 3.78026485e-01f, -8.96380022e-02f, -4.42239285e-01f,
  -1.77369639e-01f, -1.35351894e-02f, -3.86661917e-01f, -1.66476488e-01f, -1.70484483e-01f, 4.18943033e-04f, -1.43307358e-01f, -3.06148589e-01f, 1.65438548e-01f, 1.77408621e-01f,
  -2.48624414e-01f, 1.76765352e-01f, 2.36495584e-01f, -2.78295904e-01f, 3.41206163e-01f, 3.23402911e-01f, 5.66697959e-03f, -6.12824708e-02f, 4.66074407e-01f, -2.11570963e-01f,
  1.05044127e-01f, 1.44774824e-01f, 2.75597461e-02f, 1.35192260e-01f, -3.82621586e-01f, -2.13421602e-02f, 1.27249569e-01f, -4.79631066e-01f, -4.31363165e-01f, 3.44469517e-01f,
  -3.56271327e-01f, 6.33453205e-02f, 2.70000935e-01f, -1.52152091e-01f, 2.48805538e-01f, -4.24302906e-01f, -4.49711457e-02f, -2.26804987e-01f, 2.83160806e-01f, -3.58339310e-01f,
  -3.35530758e-01f, -3.99177402e-01f, 9.88608226e-02f, -5.05406201e-01f, -1.04692854e-01f, 6.28057751e-04f, 3.26495506e-02f, -4.61473107e-01f, -1.72896031e-02f, -1.85050696e-01f,
  8.24962929e-02f, 2.33931746e-02f, -3.10087353e-01f, 1.51228711e-01f, 2.62637466e-01f, 2.40676612e-01f, 6.29852489e-02f, -7.19653144e-02f, 1.63510218e-01f, 1.17336437e-01f,
  6.68931678e-02f, -2.16322973e-01f, -3.29709142e-01f, -2.66656518e-01f, 2.60097802e-01f, -4.12929296e-01f, -3.91653299e-01f, 4.38728742e-02f, -3.94187659e-01f, -1.84787482e-01f,
  -4.43909407e-01f, -3.00271779e-01f, 3.19542646e-01f, -2.74689555e-01f, 2.53494829e-01f, -2.71383226e-01f, -1.86810493e-01f, 7.31996670e-02f, -3.20600010e-02f, -1.19044498e-01f,
  -1.04824528e-01f, -1.34425655e-01f, 4.91280556e-02f, -4.88191955e-02f, -4.05707769e-02f, -9.01605636e-02f, 2.55190320e-02f, -2.39851087e-01f, -3.74647766e-01f, 1.14954524e-01f,
  8.75246376e-02f, -1.76059529e-01f, -1.13181487e-01f, -2.00762957e-01f, -7.69755244e-02f, -1.72618106e-02f, -1.31291062e-01f, 1.32134045e-03f, -2.44273201e-01f, 7.18793198e-02f,
  -2.38677580e-02f, 2.73857862e-01f, -1.91281334e-01f, 3.09097201e-01f, -1.49653703e-01f, -2.25644276e-01f, 1.45917743e-01f, -4.50531580e-02f, 1.59626469e-01f, -1.63211316e-01f,
  2.28894532e-01f, -7.13032335e-02f, 1.49530262e-01f, -5.08605316e-02f, -1.28634557e-01f, 6.05429001e-02f, -2.36228079e-01f, 1.80551365e-01f, 1.30879909e-01f, -1.43184904e-02f,
  1.59553751e-01f, -2.37310752e-02f, 1.68625742e-01f, -2.35276580e-01f, 2.18363091e-01f, -3.58014852e-01f, -2.83496767e-01f, 3.02177459e-01f, 2.59081602e-01f, 2.49116614e-01f,
  -1.40542775e-01f, -8.00816268e-02f, 2.09464088e-01f, -2.64747083e-01f, -1.15033299e-01f, -2.38484025e-01f, -2.39024997e-01f, -2.62000173e-01f, -1.65230453e-01f, -3.40408742e-01f,
  -7.72537366e-02f, -7.79349580e-02f, 9.33822617e-02f, 1.42277097e-02f, 2.70447098e-02f, -6.43626526e-02f, 7.05236867e-02f, 1.47625074e-01f, 3.52255315e-01f, -3.47936377e-02f,
  -2.89545149e-01f, 3.43036026e-01f, -2.86829919e-01f, 4.28563982e-01f, 3.51420939e-02f, -1.01118721e-01f, 3.46968830e-01f, -3.87673855e-01f, -5.86120337e-02f, -3.75570476e-01f,
  -2.43000075e-01f, -1.23524785e-01f, -3.01741481e-01f, -8.83163884e-02f, 6.07488677e-02f, -1.54177979e-01f, 2.71205813e-01f, 2.09092274e-01f, -1.06498837e-01f, -4.26544160e-01f,
  -1.68244675e-01f, -2.70264633e-02f, -8.89370367e-02f, -4.39377457e-01f, 3.47111434e-01f, 3.33659612e-02f, -1.20920889e-01f, 1.35639325e-01f, -3.35583359e-01f, -2.02427998e-01f,
  -5.15514873e-02f, 2.29505971e-01f, 3.63817960e-01f, 3.55654538e-01f, -4.87825274e-02f, -3.06271553e-01f, 1.12018533e-01f, -4.09436107e-01f, 3.45791340e-01f, -2.26830453e-01f,
  -1.18738331e-01f, -9.95239764e-02f, -4.26566780e-01f, -4.56289984e-02f, -2.19326541e-02f, -2.61279315e-01f, -2.79640287e-01f, -1.07659809e-01f, 3.68073434e-01f, -1.30991846e-01f,
  -4.24082786e-01f, -5.03203198e-02f, 2.86134495e-03f, -2.74366498e-01f, 1.49961799e-01f, -6.99408213e-03f, 1.98862046e-01f, -2.54097637e-02f, 8.92267376e-03f, 1.20305248e-01f,
  -3.06925267e-01f, -1.72351539e-01f, -1.57845289e-01f, 7.80643476e-03f, 8.36043358e-02f, -6.42845556e-02f, -1.32895038e-01f, -3.69230881e-02f, -4.11385819e-02f, -2.88784385e-01f,
  6.06372692e-02f, 2.38476191e-02f, -1.00557350e-01f, -9.42290127e-02f, 9.27814841e-03f, -2.96843082e-01f, -3.47084492e-01f, -7.22819045e-02f, -1.62886217e-01f, -1.87862478e-02f,
  3.65020424e-01f, 1.34667352e-01f, -2.23220885e-01f, 2.68091470e-01f, -2.06662402e-01f, -8.84922445e-02f, -3.61710638e-01f, 1.96050957e-01f, 6.02207147e-03f, 6.50587231e-02f,
  -2.64967531e-01f, -6.45460635e-02f, -3.00905883e-01f, -1.39761209e-01f, 2.43228853e-01f, -3.06736290e-01f, 5.51846363e-02f, 1.93950236e-01f, 1.08247004e-01f, 1.52158320e-01f,
  -2.34064922e-01f, 1.08671844e-01f, -2.93724805e-01f, 2.31617913e-01f, -3.74970019e-01f, -7.04241842e-02f, 3.78114954e-02f, -1.64655745e-01f, 3.31760615e-01f, 1.29048005e-01f,
  -3.96642238e-01f, -1.67825699e-01f, 3.60744566e-01f, -5.66989407e-02f, 3.69598508e-01f, -3.26467961e-01f, 4.38097358e-01f, -1.45697445e-01f, -1.65834352e-01f, 3.25721912e-02f,
  -7.94306397e-02f, 1.16475262e-01f, -4.57125790e-02f, -3.42571676e-01f, -2.27098659e-01f, -2.20886171e-01f, -4.25272703e-01f, -1.68908566e-01f, -4.88158017e-01f, -9.16864276e-02f,
  -9.71889049e-02f, -2.54372299e-01f, -1.86502188e-01f, 3.35513651e-01f, -2.91146755e-01f, 7.20434114e-02f, -3.73247057e-01f, 1.39271930e-01f, -1.22916169e-01f, 2.17940420e-01f,
  -3.56343955e-01f, -2.72209227e-01f, 5.05893379e-02f, 4.08368677e-01f, -1.82584941e-01f, -1.78788289e-01f, -2.53212243e-01f, 3.78904603e-02f, 2.66146902e-02f, -3.30535434e-02f,
  3.88069659e-01f, 4.38202210e-02f, -1.73687965e-01f, -3.67276222e-01f, 4.13147449e-01f, -2.55178928e-01f, 2.08211854e-01f, -3.49626951e-02f, -7.98050463e-02f, -1.37595773e-01f,
  -8.21865797e-02f, -1.07718788e-01f, -3.76797795e-01f, -3.78447145e-01f, -4.77473736e-01f, 1.89466491e-01f, -9.18153115e-03f, -1.91287503e-01f, 3.55711073e-01f, 3.79438937e-01f,
  -3.90786141e-01f, 4.29564714e-01f, 2.34360993e-01f, 1.16171828e-02f, -3.02369893e-01f, -8.09724256e-02f, -2.37403572e-01f, 1.14505857e-01f, -4.17554468e-01f, -1.93651795e-01f,
  4.63531137e-01f, -1.22335628e-01f, 5.29236607e-02f, 9.71537903e-02f, -2.49257479e-02f, 1.19632110e-01f, 1.31362662e-01f, -8.99479911e-02f, 2.21141309e-01f, 1.63356304e-01f,
  4.71079201e-02f, -1.59870103e-01f, 1.63332149e-01f, -1.26805037e-01f, -4.12476324e-02f, -3.48192989e-03f, -5.91809340e-02f, 1.44384772e-01f, -1.85453258e-02f, -6.38310611e-02f,
  3.24618369e-02f, 6.08882904e-02f, 1.09732531e-01f, 3.39801669e-01f, 2.17962220e-01f, 4.01949883e-02f, 2.14752361e-01f, -2.08134711e-01f, 1.39251947e-01f, -2.42329240e-01f,
  -4.07899141e-01f, -2.23961011e-01f, 1.09922595e-01f, 3.97926480e-01f, -1.80743605e-01f, -2.95214862e-01f, 3.16756964e-01f, -4.45911773e-02f, -8.00689310e-02f, 3.64919931e-01f,
  2.03293547e-01f, 2.83142209e-01f, -1.38874233e-01f, -1.50683552e-01f, -4.52478409e-01f, 4.61184531e-01f, 1.87167481e-01f, -3.24412286e-01f, -3.42235178e-01f, 4.12789047e-01f,
  2.52712429e-01f, 7.83511326e-02f, -3.28920722e-01f, 3.85410845e-01f, -3.52451235e-01f, -1.28847852e-01f, 3.93865854e-01f, 6.56394809e-02f, -1.76049337e-01f, 5.23730755e-01f,
  1.43527806e-01f, 3.14980716e-01f, -3.41399312e-01f, 3.43096852e-01f, -1.99927315e-01f, 2.18828306e-01f, -4.50987428e-01f, 1.64296746e-01f, -3.94780934e-01f, 5.68493158e-02f,
  -3.00648630e-01f, -3.19221854e-01f, 5.03601491e-01f, 2.30690688e-01f, -3.08947712e-01f, -2.14325562e-01f, 2.09860787e-01f, -3.81584793e-01f, 2.19077822e-02f, 4.35664296e-01f,
  -7.34302625e-02f, 4.11439389e-01f, -1.01488516e-01f, -2.95686126e-01f, -1.12314276e-01f, 2.30090365e-01f, -3.46823633e-01f, 4.73235995e-01f, -2.82378465e-01f, 2.99952086e-02f,
  -5.49573302e-01f, 1.70282423e-01f, -1.45664096e-01f, 2.50311255e-01f, 2.03213349e-01f, -2.65001625e-01f, 1.75314948e-01f, -3.61827374e-01f, -1.07806623e-01f, -1.28928393e-01f,
  1.81134000e-01f, -1.01678722e-01f, -5.10016918e-01f, 1.71648767e-02f, -1.41015369e-03f, -3.35284382e-01f, -1.59884632e-01f, -1.47313640e-01f, -8.35270360e-02f, -8.66205990e-02f,
  -1.90163791e-01f, 7.52226636e-02f, 6.27859309e-02f, -3.46899837e-01f, 4.63107564e-02f, 1.44531876e-01f, 3.15150648e-01f, -2.24227801e-01f, 2.00739354e-01f, 2.95642763e-02f,
  -4.74710763e-02f, -1.90979972e-01f, 2.06419453e-01f, 2.19771653e-01f, -1.44245908e-01f, 2.67941922e-01f, -1.82701766e-01f, 4.12780017e-01f, -1.15216643e-01f, -3.10674638e-01f,
  -2.92633027e-01f, 3.48279089e-01f, 7.47069865e-02f, 4.90341242e-03f, 1.08870581e-01f, 2.39131168e-01f, 1.81637153e-01f, 2.90323377e-01f, 1.06150627e-01f, 9.22896117e-02f,
  2.18094364e-01f, 1.56240225e-01f, 1.28510240e-02f, 1.98196381e-01f, 6.67696148e-02f, 1.21671647e-01f, 2.68851101e-01f, 2.31342763e-01f, 1.47626117e-01f, 1.97468573e-04f,
  4.15408202e-02f, 1.93378210e-01f, 2.44248569e-01f, 3.19704086e-01f, 1.74329355e-01f, 2.09649112e-02f, 9.46881697e-02f, -2.29513228e-01f, 3.96077901e-01f, 2.87827432e-01f,
  1.11016491e-02f, -2.78793216e-01f, 1.10667244e-01f, -2.84803957e-01f, -4.07218754e-01f, 8.11386704e-02f, -2.42155701e-01f, 1.92821428e-01f, 5.99234812e-02f, 7.69664422e-02f,
  8.51700753e-02f, 1.82203442e-01f, 1.63826734e-01f, -3.91034424e-01f, -2.47300446e-01f, 2.81322956e-01f, 2.91153580e-01f, 2.96052243e-03f, 2.38550052e-01f, 4.14683111e-02f,
  -9.00053009e-02f, 8.00249279e-02f, -2.12596178e-01f, 2.47746203e-02f, -1.13825880e-01f, -3.48716438e-01f, -3.03004682e-01f, -2.49861956e-01f, 3.11333686e-03f, 3.61217290e-01f,
  -4.09457535e-01f, 2.99313635e-01f, -3.82805198e-01f, -2.21911937e-01f, 1.38633758e-01f, -2.87608922e-01f, -6.66568130e-02f, -5.55886865e-01f, -6.00578249e-01f, -4.05348539e-01f,
  -4.04468566e-01f, 1.75774485e-01f, 1.02853492e-01f, -5.66601753e-01f, -1.88299477e-01f, -2.29512021e-01f, 1.18368998e-01f, -2.33015358e-01f, -4.31039184e-02f, -2.23511100e-01f,
  7.97684565e-02f, -1.36217177e-01f, -3.24012876e-01f, -2.94046313e-01f, 3.40311021e-01f, -4.72805470e-01f, 2.93296218e-01f, 4.28351790e-01f, -3.65615845e-01f, 5.77515028e-02f,
  -5.03536873e-02f, -3.71027529e-01f, 3.77755216e-03f, 6.58050328e-02f, -2.47462571e-01f, 3.69895726e-01f, -3.67713600e-01f, 2.48207122e-01f, -2.19420567e-01f, 1.91210225e-01f,
  -1.98486432e-01f, -4.39069778e-01f, 1.06242679e-01f, 3.56642514e-01f, 2.51163632e-01f, -4.32947576e-01f, -3.33463252e-01f, -6.29993081e-01f, 9.14879143e-02f, 4.05816048e-01f,
  -1.89105496e-01f, -3.79429460e-02f, 2.65291452e-01f, 1.63705051e-01f, -1.77926213e-01f, -3.84234935e-01f, 1.28843322e-01f, 2.18408048e-01f, -5.27056456e-01f, 4.33974206e-01f,
  3.25554669e-01f, 4.09818709e-01f, 5.66626079e-02f, 3.30482513e-01f, 3.82848471e-01f, -2.06453294e-01f, -4.41361099e-01f, 1.71596155e-01f, 1.87568426e-01f, -4.40872014e-02f,
  5.30001856e-02f, -2.91067630e-01f, 3.89065966e-02f, -2.49260850e-02f, -2.27029040e-01f, 6.98141307e-02f, -6.64301068e-02f, 6.86799921e-03f, 8.27071294e-02f, 2.91220713e-02f,
  -9.95494332e-03f, 4.79524918e-02f, 5.03296480e-02f, 1.84062347e-01f, 2.54551489e-02f, -2.41942361e-01f, 1.32909849e-01f, -2.22682003e-02f, 6.75248429e-02f, -7.89655969e-02f,
  5.43427989e-02f, -3.24029364e-02f, -2.48775125e-01f, -1.40505522e-01f, -2.46800527e-01f, 4.18184072e-01f, 8.36084783e-02f, -2.56011754e-01f, 4.43169884e-02f, -2.16178626e-01f,
  -2.61488557e-01f, 3.55080158e-01f, -7.71984830e-03f, -3.15945186e-02f, 3.78287256e-01f, -3.26788098e-01f, 1.22727856e-01f, -2.80411184e-01f, -6.40450120e-02f, -1.87336266e-01f,
  3.29890341e-01f, -2.15149999e-01f, -1.52918071e-01f, 6.41548187e-02f, 1.16444662e-01f, 2.10911054e-02f, 2.81105965e-01f, -2.78392524e-01f, -2.45859519e-01f, -1.63934693e-01f,
  -3.47634137e-01f, -2.74018675e-01f, -9.46645066e-03f, -4.76180166e-01f, 1.74127311e-01f, -4.57687855e-01f, -1.61468759e-01f, -2.21706852e-01f, 1.91307947e-01f, -1.74072459e-01f,
  4.52512711e-01f, 1.57200515e-01f, -1.91493869e-01f, -1.42027199e-01f, -1.08194388e-01f, -1.99415833e-01f, 4.70707595e-01f, 4.04517576e-02f, -2.50608742e-01f, -3.70822012e-01f,
  4.20828648e-02f, -2.16376513e-01f, 4.37395722e-01f, 2.62857646e-01f, 8.85394141e-02f, -2.55678803e-01f, 1.46557018e-01f, -3.64580870e-01f, -2.44405404e-01f, -1.76776588e-01f,
  4.88665521e-01f, -2.50113785e-01f, -2.03272626e-01f, -1.42925665e-01f, -1.32745445e-01f, -4.31788146e-01f, -1.59719095e-01f, 2.09932119e-01f, -3.21912259e-01f, 3.43306750e-01f,
  -3.74422908e-01f, -1.00568697e-01f, -1.10568836e-01f, 2.03041106e-01f, -2.10704580e-01f, -1.09321609e-01f, -6.55410707e-01f, -3.80775064e-01f, 6.38195202e-02f, -2.07931846e-01f,
  -1.90866783e-01f, 3.86371702e-01f, 2.89126217e-01f, -1.02562597e-02f, 2.32749999e-01f, 2.29802161e-01f, -3.67533386e-01f, -1.09219581e-01f, 1.30741850e-01f, -2.71911860e-01f,
  1.30126690e-02f, 3.36754560e-01f, -5.79047263e-01f, -1.38854846e-01f, -7.71186426e-02f, -2.50720471e-01f, 5.70411831e-02f, -1.45386502e-01f, 2.91022599e-01f, -1.55633509e-01f,
  3.84718984e-01f, 3.56218636e-01f, 3.38990867e-01f, -1.85420051e-01f, -2.69800901e-01f, 4.30334508e-01f, -1.32712752e-01f, -4.43273550e-03f, -1.69888750e-01f, -5.29388338e-03f,
  -5.71648255e-02f, -1.31639674e-01f, 5.34297936e-02f, -1.81746364e-01f, -1.36502460e-01f, 7.20204562e-02f, -1.36799380e-01f, -7.78031647e-02f, -4.89302091e-02f, -4.03516218e-02f,
  -9.08913761e-02f, -2.79840231e-01f, -1.33410648e-01f, -1.66290887e-02f, -1.94985464e-01f, -5.08519597e-02f, -2.47124936e-02f, -1.07970886e-01f, -6.76381886e-02f, -1.11449808e-01f,
  -4.57018577e-02f, -1.28615007e-01f, -2.47103319e-01f, 1.79428950e-01f, 1.03626870e-01f, -1.43838510e-01f, -2.15319976e-01f, 2.14759514e-01f, -1.20338993e-02f, 1.29501238e-01f,
  -3.13119031e-02f, 8.87780711e-02f, -5.37650213e-02f, 4.96970788e-02f, -1.61799341e-01f, 2.20016941e-01f, 1.97462216e-01f, -2.04850510e-01f, -1.71662584e-01f, 1.01320915e-01f,
  1.75246164e-01f, 1.44272357e-01f, -1.20472878e-01f, 1.68139830e-01f, 1.38434425e-01f, -1.13785034e-02f, 2.99067914e-01f, -1.21035501e-01f, -2.11801112e-01f, -1.37155369e-01f,
  -2.12980583e-01f, -1.01869456e-01f, 1.35727614e-01f, -1.33967578e-01f, 3.31041932e-01f, -1.84414431e-01f, 1.14642300e-01f, -2.87411451e-01f, -2.35754073e-01f, 4.77192644e-03f,
  -9.24182013e-02f, 3.91192526e-01f, -2.95077324e-01f, -1.26875252e-01f, -5.55218197e-02f, 3.27522844e-01f, -1.96296856e-01f, -4.79369350e-02f, -7.02220127e-02f, -1.26689002e-01f,
  9.75377560e-02f, 6.92808181e-02f, -1.47716701e-01f, -1.48882642e-01f, -1.83734626e-01f, -3.28678116e-02f, -1.06802180e-01f, -2.47804552e-01f, 8.49724859e-02f, -6.08756840e-02f,
  1.05565317e-01f, -1.80158332e-01f, -1.38122499e-01f, 3.18450302e-01f, -9.58273187e-03f, -2.82061666e-01f, 3.68648022e-02f, -1.48308113e-01f, 4.43481393e-02f, -1.96109697e-01f,
  2.70787209e-01f, 3.98936480e-01f, 3.31437707e-01f, 5.51344603e-02f, 7.00528920e-02f, 4.69226055e-02f, 2.65343487e-01f, -2.60794669e-01f, 2.20877737e-01f, -1.85920194e-01f,
  3.83868873e-01f, -8.78706649e-02f, 4.60083149e-02f, -2.93360025e-01f, 2.88287610e-01f, -1.37383983e-01f, -7.87174255e-02f, -2.38786727e-01f, -1.55922741e-01f, -1.75398946e-01f,
  1.16771564e-01f, -2.59784311e-01f, -1.39311142e-02f, 1.20153643e-01f, 2.39457592e-01f, -2.15997592e-01f, -1.85672000e-01f, 1.22720197e-01f, -1.38738573e-01f, -1.08570278e-01f,
  -1.46919474e-01f, 2.97560513e-01f, -3.11175704e-01f, -6.79214075e-02f, -2.96761215e-01f, -9.09449160e-02f, 4.46341708e-02f, 1.60340264e-01f, 7.34313577e-03f, -6.69921562e-02f,
  -2.01747715e-02f, 1.34347705e-02f, 1.04902836e-03f, -1.63943276e-01f, -2.55289793e-01f, -2.76967511e-02f, -1.87794924e-01f, -6.51035458e-03f, -2.34032437e-01f, -1.08892910e-01f,
  -1.19996466e-01f, -5.54618565e-03f, -1.03465728e-01f, 6.38110191e-02f, -7.03144521e-02f, 9.00100991e-02f, -8.33902732e-02f, 8.82300138e-02f, 3.51293012e-03f, 2.63318062e-01f,
  2.54087985e-01f, -6.47057220e-02f, -1.93807438e-01f, 2.61086196e-01f, 2.03647718e-01f, -2.31349096e-01f, 6.67176247e-02f, 2.10786536e-01f, 2.13253126e-01f, 3.50819468e-01f,
  1.92029104e-01f, -2.49527141e-01f, -1.87287107e-01f, -7.94229731e-02f, -1.01624347e-01f, 1.95456415e-01f, -2.72269189e-01f, -9.00567994e-02f, 2.12989360e-01f, -3.82088893e-03f,
  -7.00520575e-02f, 2.50585973e-01f, 4.46340367e-02f, 1.49726465e-01f, -5.76527491e-02f, -1.90664589e-01f, -6.87431023e-02f, 3.14647555e-01f, -1.54283807e-01f, -1.89992368e-01f,
  2.42111191e-01f, -1.53580472e-01f, -1.06624424e-01f, 1.28169551e-01f, -1.72795042e-01f, -8.62666517e-02f, 4.88560200e-01f, 5.87256812e-02f, -1.22419052e-01f, -1.98805675e-01f,
  -1.08131498e-01f, 3.08396578e-01f, -8.98094773e-02f, -1.04879200e-01f, -2.74373561e-01f, 4.07855630e-01f, 7.17647225e-02f, -1.34040311e-01f, -2.27854237e-01f, 2.80927390e-01f,
  -7.40128756e-02f, -2.89574891e-01f, -1.19057640e-01f, -1.25914380e-01f, -2.12581709e-01f, -1.64743170e-01f, -1.59371972e-01f, -5.78472577e-02f, -1.99228600e-01f, -1.66711360e-01f,
  -2.74144650e-01f, -1.06253847e-01f, 1.81725785e-01f, -5.58896065e-02f, 3.05922896e-01f, 1.54158309e-01f, 5.83067715e-01f, 4.16354150e-01f, -2.59901255e-01f, -2.55625378e-02f,
  -2.55811632e-01f, 4.11239266e-01f, 2.34298408e-01f, -1.61706015e-01f, -2.89330244e-01f, -2.10493319e-02f, -2.40499601e-01f, -8.05814564e-02f, -9.42327678e-02f, 1.52228177e-01f,
  -1.93955466e-01f, -3.11768383e-01f, -2.13738978e-01f, 5.14431298e-03f, -2.46030062e-01f, 1.40247598e-01f, -2.07714885e-01f, -2.61414111e-01f, -1.16429292e-01f, -2.89886385e-01f,
  -3.18276316e-01f, -8.56204703e-02f, -1.10374503e-01f, 5.76670235e-03f, -1.28892079e-01f, -1.05454093e-02f, -1.74866125e-01f, -1.63160935e-01f, -2.54724324e-02f, 2.51278937e-01f,
  -2.36866102e-01f, 8.66618827e-02f, 1.13445394e-01f, -1.76251456e-02f, 4.24389578e-02f, 2.79683858e-01f, 3.62272561e-03f, -5.73302545e-02f, -3.18850279e-02f, 1.28184631e-01f,
  2.14896679e-01f, 1.95391148e-01f, -1.19083010e-01f, 1.37099296e-01f, 9.41495299e-02f, -2.68623769e-01f, -1.40156329e-01f, 3.13193053e-02f, -1.45262787e-02f, 7.45278969e-02f,
  1.08313337e-01f, 3.45290639e-02f, 1.05066774e-02f, 2.26954639e-01f, -1.14607424e-01f, -1.54228285e-01f, -5.38495481e-02f, -2.02439219e-01f, -1.69733495e-01f, 2.24078670e-01f,
  -4.35605906e-02f, 1.49496540e-03f, -4.17496651e-01f, -3.02806824e-01f, -6.68249503e-02f, 1.79283381e-01f, -2.15357587e-01f, -2.24450707e-01f, -1.66610688e-01f, -2.35362966e-02f,
  2.64255732e-01f, 3.29569548e-01f, 2.12310478e-01f, -2.28772253e-01f, 7.39338472e-02f, 4.19714063e-01f, 1.22272782e-01f, -5.01442328e-02f, 2.57520288e-01f, -2.08275601e-01f,
  1.17148355e-01f, -1.36818394e-01f, 4.69936579e-01f, 4.35407609e-01f, -1.43216655e-01f, -4.07017142e-01f, -2.83372343e-01f, 5.01268767e-02f, -1.39350533e-01f, 3.77552330e-01f,
  -2.09710091e-01f, -4.71436679e-02f, -1.90695122e-01f, -3.34751427e-01f, -5.20463765e-01f, -3.13378960e-01f, 4.24793392e-01f, -4.85233925e-02f, 2.79980034e-01f, -3.33452106e-01f,
  3.64065409e-01f, 4.85507846e-01f, -2.82114267e-01f, 3.65137100e-01f, -6.34594262e-02f, -5.30723482e-02f, 2.05547988e-01f, -8.94450545e-02f, 4.09916222e-01f, -1.40514597e-01f,
  -2.59762615e-01f, -2.08037466e-01f, 4.30960804e-01f, -2.85788447e-01f, 2.81238496e-01f, -2.15283394e-01f, -3.52431566e-01f, -4.25400697e-02f, -6.48393482e-02f, -7.80088753e-02f,
  -1.29055083e-01f, -3.71173352e-01f, -4.78164375e-01f, 1.73725173e-01f, 7.03506023e-02f, -1.08470470e-01f, 1.62230119e-01f, -1.65128723e-01f, -1.79875970e-01f, -1.12955593e-01f,
  1.79905653e-01f, 3.39925349e-01f, -2.89752156e-01f, 2.72251219e-01f, -3.00035000e-01f, -5.43983757e-01f, -2.74381697e-01f, -2.82918692e-01f, -2.38322333e-01f, 3.24134588e-01f,
  3.67810756e-01f, -2.53399491e-01f, -1.11001246e-02f, -1.19120784e-01f, -4.25193727e-01f, 1.44285068e-01f, 1.64966688e-01f, -1.64313585e-01f, 3.77251655e-02f, -2.77712733e-01f,
  -2.16305450e-01f, 2.23788451e-02f, 7.00003877e-02f, -3.19573015e-01f, -2.90038735e-01f, -2.35272825e-01f, -4.76344496e-01f, -2.25861073e-01f, -3.57320942e-02f, 1.06822312e-01f,
  1.18512020e-01f, 1.62398577e-01f, -6.33809194e-02f, -2.86394320e-02f, 1.77185878e-01f, 1.71562731e-01f, -1.61182098e-02f, 1.69500738e-01f, 1.02936894e-01f, 1.02102868e-01f,
  4.69453260e-02f, 2.46428937e-01f, 7.17289224e-02f, 9.78348870e-03f, 1.33725286e-01f, 2.63481885e-01f, 1.09758116e-01f, 8.32428858e-02f, 2.36666113e-01f, 9.76599380e-02f,
  8.33252743e-02f, -3.71907391e-02f, 2.45906726e-01f, -9.49732736e-02f, 5.97005934e-02f, 1.53350696e-01f, -1.65831685e-01f, 4.05427814e-01f, -2.07939491e-01f, -3.12079698e-01f,
  3.30092907e-01f, 4.09240365e-01f, 3.01978052e-01f, 1.52009875e-01f, -2.84492582e-01f, -1.78018495e-01f, 2.05149129e-01f, 2.27217421e-01f, 1.10138599e-02f, -1.94335014e-01f,
  7.70555511e-02f, 3.34986448e-01f, -2.81013429e-01f, 1.92967370e-01f, -9.60485935e-02f, -3.45020533e-01f, -3.40467125e-01f, 2.77139187e-01f, -2.40285933e-01f, 2.93562055e-01f,
  3.32340270e-01f, -1.37684166e-01f, 3.11914653e-01f, -2.13251725e-01f, -1.47072569e-01f, 8.87201279e-02f, 4.88621444e-01f, -2.89621055e-01f, -3.07209164e-01f, -1.34611830e-01f,
  -5.50726838e-02f, 8.50252807e-02f, -2.69243032e-01f, -3.56587410e-01f, -1.17626078e-01f, -3.50340724e-01f, -2.17967436e-01f, -2.83107683e-02f, -1.39038891e-01f, -1.43621683e-01f,
  6.08212687e-02f, -1.33696467e-01f, 3.51646960e-01f, 4.64908868e-01f, -8.16055462e-02f, -3.39310467e-01f, -1.97948247e-01f, 2.59779505e-02f, -8.13319236e-02f, -4.71447140e-01f,
  3.12443376e-01f, -2.66175896e-01f, -1.38934046e-01f, 3.26487333e-01f, -2.36535087e-01f, -1.99433118e-02f, -2.30884016e-01f, -7.63906538e-02f, 1.48422897e-01f, -4.03589219e-01f,
  -1.20614998e-01f, -2.63153464e-01f, -2.55447775e-01f, -7.32844099e-02f, -2.59968072e-01f, -1.90557316e-01f, -2.24800333e-01f, -1.09036788e-01f, -3.59977990e-01f, -1.41652212e-01f,
  4.62516934e-01f, -1.64743338e-03f, 2.24674717e-01f, -2.66488165e-01f, -1.56342149e-01f, 1.92438662e-01f, -2.54938930e-01f, -3.02595884e-01f, -1.41932279e-01f, -1.22022785e-01f,
  5.12692392e-01f, 4.70830530e-01f, -1.53992429e-01f, -1.44490778e-01f, -4.48955089e-01f, 4.08029318e-01f, 9.02598202e-02f, -1.13018520e-01f, 6.20864443e-02f, 1.33304551e-01f,
  -1.27677962e-01f, 4.89764847e-02f, -2.60156602e-01f, -3.40780526e-01f, 3.79222743e-02f, 1.26112565e-01f, -5.27855046e-02f, -1.40478775e-01f, 9.98896286e-02f, -1.00921452e-01f,
  -3.78209613e-02f, 6.29383028e-02f, -1.77567691e-01f, 8.11823159e-02f, 1.17820121e-01f, 8.30691494e-03f, 8.29468444e-02f, 1.58489740e-03f, -1.92255914e-01f, 4.08841744e-02f,
  9.00434777e-02f, -7.31593445e-02f, 2.74919812e-02f, 2.90423352e-02f, -1.23587541e-01f, 3.16629149e-02f, 9.45002809e-02f, -2.88328100e-02f, -6.26162961e-02f, 1.59736037e-01f,
  5.18810414e-02f, 1.04900651e-01f, 8.89023691e-02f, 6.78144544e-02f, -2.51804650e-01f, -3.30554008e-01f, -8.89918506e-02f, 3.49525541e-01f, -2.22642705e-01f, 2.03454494e-01f,
  -4.58190143e-02f, -1.41341954e-01f, 6.37614960e-03f, 3.68786335e-01f, 7.15549989e-03f, 3.90786715e-02f, -2.83083320e-01f, -1.22753434e-01f, 1.26844004e-01f, -2.88070917e-01f,
  -1.76003575e-01f, -1.53005093e-01f, -2.53456146e-01f, -1.07070349e-01f, -3.08220778e-02f, -6.05377592e-02f, 8.56571048e-02f, -2.60908663e-01f, 1.37476638e-01f, -3.37736398e-01f,
  4.53931123e-01f, 2.30930671e-01f, -2.16653258e-01f, 4.72671092e-01f, -4.39930916e-01f, -3.41853827e-01f, -2.70052463e-01f, -2.52580047e-01f, 3.40236306e-01f, 2.63465345e-01f,
  2.10767820e-01f, 1.19155996e-01f, -2.13347480e-01f, 3.42982352e-01f, -2.13788703e-01f, -1.72627985e-01f, -2.75122046e-01f, -1.07887119e-01f, -6.94742799e-02f, -3.26173186e-01f,
  -1.73781246e-01f, -1.04782410e-01f, -1.72815323e-01f, -1.75304070e-01f, -7.97279365e-03f, -1.85971305e-01f, 5.46652138e-01f, -1.63409427e-01f, -5.79983927e-02f, -2.33200073e-01f,
  9.38190892e-03f, -2.41794333e-01f, -2.76388735e-01f, 3.20450336e-01f, -2.70055294e-01f, -1.82179391e-01f, 4.28316861e-01f, 3.49198818e-01f, -1.99688599e-01f, -2.56214201e-01f,
  1.95283845e-01f, 1.81405529e-01f, -2.28348926e-01f, 1.33116245e-01f, 2.48179093e-01f, -7.18155801e-02f, -2.75718749e-01f, -1.81270316e-01f, -3.12308609e-01f, 3.48662198e-01f,
  -1.53338298e-01f, 3.95909816e-01f, 1.38684213e-01f, -1.59700170e-01f, -2.71293253e-01f, -2.90029645e-01f, 1.83091722e-02f, -1.41425982e-01f, 4.65503260e-02f, -1.80928081e-01f,
  -2.38635093e-01f, 1.40549034e-01f, 2.43046228e-02f, -2.37488806e-01f, -6.31745681e-02f, -1.92430764e-01f, -2.47722849e-01f, 2.41445139e-01f, 2.15869471e-01f, -3.08755726e-01f,
  3.86096090e-01f, -2.43381813e-01f, 1.72845751e-01f, -1.77210242e-01f, -2.81431288e-01f, 1.08060509e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.36338768e-02f, 4.32227701e-02f, -1.10968485e-01f, 3.31463069e-02f, 3.07194758e-02f, 5.91277331e-02f, -2.79498920e-02f, -5.13064675e-02f, -1.47342833e-03f, 5.25426231e-02f,
  2.81081311e-02f, -7.43740648e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    