/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.00209486e-01f, -1.42627478e-01f, 2.89702773e-01f, 3.92585248e-02f, -2.30157107e-01f, 1.32703427e-02f, -1.04167484e-01f, -3.35603580e-02f, -1.53692542e-02f, -1.26448035e-01f,
  -7.03768656e-02f, -1.39061272e-01f, 3.06920577e-02f, 8.85763168e-02f, 1.95885375e-01f, 2.76866313e-02f, -8.77847746e-02f, 3.56569916e-01f, 4.62439328e-01f, 1.40923783e-01f,
  -1.84715211e-01f, 4.73046955e-03f, 2.45387271e-01f, 1.11974232e-01f, -2.03829497e-01f, 4.35602218e-02f, -1.80672705e-01f, -9.95955616e-02f, -8.45519304e-02f, -2.23930761e-01f,
  1.06277026e-01f, 3.75580862e-02f, 1.01607740e-01f, -6.30051121e-02f, 1.36406153e-01f, 1.18209898e-01f, 8.98681283e-02f, 1.45844638e-01f, 7.30631780e-03f, 5.84146306e-02f,
  -9.26163606e-03f, 2.32159942e-02f, -6.17170557e-02f, -1.03046216e-01f, 2.93619167e-02f, 4.10026722e-02f, -2.71531171e-03f, 1.70243740e-01f, 1.86538875e-01f, 4.16477025e-02f,
  -1.80464968e-01f, -2.72971988e-02f, 1.37631178e-01f, 7.24974275e-02f, 4.04084101e-02f, -1.24500031e-02f, -5.74338809e-02f, 7.72741809e-02f, 1.84078261e-01f, 1.25016915e-02f,
  2.77578980e-02f, -4.19484563e-02f, 7.86693394e-03f, -8.10780935e-03f, 2.14556083e-02f, -5.97508624e-02f, 1.04933409e-02f, -7.44528845e-02f, 1.96818765e-02f, -5.05141914e-02f,
  -2.46523041e-02f, 6.81159273e-02f, 9.13059190e-02f, -2.40783319e-02f, 7.76681080e-02f, -1.90907922e-02f, -4.51663472e-02f, 5.57415597e-02f, 2.42796186e-02f, 3.56843732e-02f,
  3.77299450e-02f, 6.46242723e-02f, -3.90148908e-02f, -1.40814548e-02f, -2.40115984e-03f, 8.61065462e-02f, 4.29523662e-02f, 1.79404151e-02f, 1.82093158e-02f, -2.97874790e-02f,
  1.29104042e-02f, -1.38753951e-02f, 1.10940911e-01f, 7.39609748e-02f, 6.59188256e-02f, 8.41924641e-03f, 1.53533220e-02f, 1.01345204e-01f, 4.55742143e-02f, 8.56386721e-02f,
  2.16172729e-02f, 1.14549264e-01f, -1.11769419e-02f, 1.91518962e-02f, -5.21820486e-02f, 6.61223158e-02f, -1.53115809e-01f, 7.20621794e-02f, 8.77698064e-02f, 1.73245240e-02f,
  1.56896822e-02f, 3.73630263e-02f, 1.21660471e-01f, 1.00359917e-01f, -3.79142016e-02f, 5.44055663e-02f, 7.22909123e-02f, 8.12984481e-02f, 6.20786510e-02f, 1.22396365e-01f,
  -2.46110409e-01f, -2.56905667e-02f, -1.72008544e-01f, 3.80249433e-02f, 1.06467411e-01f, 7.79599920e-02f, 1.79010823e-01f, 1.97071172e-02f, 1.00703925e-01f, 1.08278520e-01f,
  -1.52280375e-01f, -1.49898231e-01f, -9.29214433e-02f, -1.02192633e-01f, -1.11132421e-01f, 1.37113407e-01f, 3.03453565e-01f, -1.12974964e-01f, -1.06567748e-01f, 3.40366215e-02f,
  1.60808057e-01f, 1.53291123e-02f, -1.97419807e-01f, -5.12682274e-02f, 1.46216214e-01f, -6.37362450e-02f, 1.11029282e-01f, -1.49033433e-02f, 9.39903855e-02f, 3.26313883e-01f,
  -3.02297890e-01f, -9.98882800e-02f, 1.53788164e-01f, 1.14213817e-01f, -8.67225081e-02f, 4.49554361e-02f, 2.64866068e-03f, 5.53115718e-02f, -8.10565948e-02f, -1.47561450e-02f,
  -5.75035848e-02f, 2.45688967e-02f, -8.49979296e-02f, -7.35052153e-02f, -2.65456047e-02f, -1.47227079e-01f, -7.87162334e-02f, -7.74512291e-02f, -5.17705604e-02f, 3.21042677e-03f,
  6.78710938e-02f, -6.25603367e-03f, -1.39667485e-02f, 9.27316993e-02f, -2.92650890e-02f, -1.95709858e-02f, -1.26919180e-01f, 5.31918779e-02f, -2.54049897e-02f, 1.32718503e-01f,
  -4.08863276e-02f, 1.33533161e-02f, 3.98742780e-03f, 4.12763506e-02f, -5.14594018e-02f, -4.68644015e-02f, 6.00486854e-03f, -4.59924266e-02f, -6.41980767e-03f, -1.17460005e-01f,
  5.13041876e-02f, 3.80438119e-02f, -9.21726823e-02f, 4.07610387e-02f, -3.67124863e-02f, 4.10598069e-02f, -4.52104304e-03f, 1.55062461e-02f, -3.49892937e-02f, 7.61448666e-02f,
  -2.15764940e-02f, 1.87343154e-02f, -1.05303988e-01f, -1.09399483e-01f, 1.08498801e-02f, 1.13393135e-01f, -5.11813648e-02f, -4.67919670e-02f, -4.94232122e-03f, 3.96456197e-02f,
  2.64054853e-02f, -9.25624073e-02f, 1.93218198e-02f, 1.56607814e-02f, -7.94478208e-02f, 2.14351458e-03f, 1.93381850e-02f, -3.80620509e-02f, -9.35282558e-02f, 2.52391491e-02f,
  -3.91645245e-02f, -7.43416473e-02f, -6.98140189e-02f, 1.95945110e-02f, -9.56207588e-02f, 1.29850889e-02f, -3.97295505e-03f, -3.66557129e-02f, 4.37463559e-02f, -4.78378311e-03f,
  8.07192102e-02f, 1.22173876e-01f, -5.68340495e-02f, 8.09963942e-02f, -8.16212818e-02f, -4.73881047e-03f, -2.68986095e-02f, -4.39620856e-03f, -2.05472484e-02f, 3.87902372e-02f,
  -3.81100208e-01f, -2.12241128e-01f, 1.31192029e-01f, -4.40471768e-01f, -3.07380795e-01f, -1.82547033e-01f, -1.94806784e-01f, -1.21097513e-01f, -1.04160219e-01f, -1.91677719e-01f,
  -1.74433067e-01f, -1.12484194e-01f, -4.31757793e-02f, -2.40623988e-02f, 1.08242258e-01f, 4.89349850e-02f, -4.04036418e-02f, 4.94226888e-02f, -1.08460039e-01f, -2.82368302e-01f,
  -3.27568561e-01f, -3.14629167e-01f, -2.41629303e-01f, -7.79666565e-03f, -2.48065799e-01f, -5.25707304e-02f, 6.25546426e-02f, -1.29830599e-01f, -6.93374947e-02f, -2.78076053e-01f,
  5.09383157e-02f, -4.87780385e-02f, 1.24666087e-01f, -5.83944656e-02f, -3.89532857e-02f, 4.87783365e-02f, -8.73071104e-02f, 1.22789130e-01f, 4.15299907e-02f, 5.37468195e-02f,
  -1.42126068e-01f, -2.93861106e-02f, 2.10812334e-02f, -1.18971996e-01f, -2.07212400e-02f, -1.02695756e-01f, -3.54648530e-02f, 2.60111745e-02f, 8.48494545e-02f, -4.32141423e-02f,
  -1.28430709e-01f, -2.13602185e-01f, 5.44402339e-02f, 1.59299329e-01f, 1.28599256e-01f, -6.14854693e-02f, 1.19001098e-01f, 4.58454192e-02f, 2.88621839e-02f, 5.38475998e-02f,
  5.60944015e-03f, -2.78015584e-02f, 2.61822809e-02f, -6.20729104e-02f, -3.25589776e-02f, 8.21425468e-02f, -2.95679141e-02f, -8.46073218e-03f, 2.07766630e-02f, -1.20829590e-01f,
  9.35347602e-02f, -1.12310268e-01f, 3.09812222e-02f, 3.90852317e-02f, -1.61923245e-02f, -7.57923052e-02f, -3.87332700e-02f, -6.27850741e-03f, 5.70361093e-02f, -7.76214227e-02f,
  -1.02427773e-01f, -3.38756405e-02f, 1.07111633e-02f, -6.71904394e-03f, 2.00727209e-02f, -6.81943595e-02f, -9.02081802e-02f, -1.11721642e-02f, 1.36018207e-03f, -5.37370928e-02f,
  -1.28962442e-01f, 1.33203179e-01f, -3.69811617e-03f, 2.92794406e-02f, 1.44190863e-01f, 1.32374182e-01f, -4.41794880e-02f, 1.84754446e-01f, 4.01658453e-02f, 5.91809861e-02f,
  -4.06023376e-02f, 2.11308841e-02f, 5.90142831e-02f, 1.50474548e-01f, -1.74543466e-02f, 9.75693297e-03f, 2.75422782e-02f, -5.50781265e-02f, 8.79169330e-02f, 6.78354800e-02f,
  1.22929595e-01f, 7.69430101e-02f, 7.77897164e-02f, 6.31085932e-02f, 8.88221338e-02f, -4.42060046e-02f, 1.75230011e-01f, 1.07068561e-01f, 1.34612322e-01f, 8.86928141e-02f,
  -1.36620015e-01f, 2.74780661e-01f, -1.30396470e-01f, 2.51099356e-02f, 1.31773455e-02f, -1.68062419e-01f, 8.78341421e-02f, -1.15076534e-01f, -1.09790266e-01f, 1.16446532e-01f,
  4.71636169e-02f, 3.36857513e-02f, 1.75983291e-02f, -9.56120342e-02f, -7.22391456e-02f, 5.87326176e-02f, 1.66841835e-01f, -1.08038299e-02f, -3.34889770e-01f, -4.13307473e-02f,
  -4.07047495e-02f, -9.52460244e-02f, -9.71567556e-02f, -1.43905506e-01f, 9.45889801e-02f, -2.00097814e-01f, -6.42059594e-02f, -1.32106796e-01f, 4.48318943e-02f, 2.38551587e-01f,
  -6.30189702e-02f, -1.95589829e-02f, -1.36995703e-01f, -2.03598142e-02f, -5.74849322e-02f, -1.32878214e-01f, -1.33924950e-02f, -2.94714365e-02f, -5.92317022e-02f, -8.32219869e-02f,
  6.94858376e-03f, -7.40168467e-02f, -7.09374100e-02f, -1.66596040e-01f, -7.59824812e-02f, -7.62145221e-02f, -1.05817392e-01f, -5.70973344e-02f, -1.26599699e-01f, -8.25754628e-02f,
  9.91135836e-02f, -5.30871265e-02f, -1.76794440e-01f, -1.86010465e-01f, -1.41328961e-01f, -2.36533985e-01f, -2.14571759e-01f, -7.92376101e-02f, -1.62301958e-01f, -1.68008029e-01f,
  6.28962219e-02f, 7.99578726e-02f, 9.50075313e-03f, 7.73086846e-02f, 3.70976105e-02f, 6.62495419e-02f, 1.39411017e-01f, 2.63421563e-03f, 8.70609283e-02f, -6.12264127e-02f,
  -1.48239002e-01f, 3.42825055e-02f, 3.48184407e-02f, -3.65125872e-02f, 6.64371550e-02f, 7.42565691e-02f, 1.36610977e-02f, 2.01825565e-03f, -7.26693729e-03f, -2.89477967e-02f,
  -4.45113592e-02f, 6.83305133e-03f, 6.12593293e-02f, -4.07332890e-02f, 2.67384760e-03f, -3.52913253e-02f, 4.37377878e-02f, -9.63144675e-02f, 3.60135287e-02f, 3.57756019e-02f,
  -1.57009199e-01f, -3.13180238e-02f, -1.27334520e-01f, -7.64837638e-02f, -1.22469828e-01f, -8.07156265e-02f, 1.04059398e-01f, -1.11709768e-02f, 8.73625576e-02f, -4.16442528e-02f,
  -4.97250222e-02f, 1.33112364e-03f, -6.10582307e-02f, -5.29011637e-02f, -1.33388057e-01f, -9.00815055e-03f, 4.83799949e-02f, -1.11180767e-01f, -8.52592736e-02f, -4.51979190e-02f,
  1.53676840e-02f, -2.13006914e-01f, -2.26582021e-01f, -1.08200468e-01f, -8.49453285e-02f, -1.34903252e-01f, -2.44746462e-01f, -2.30188683e-01f, -1.33534923e-01f, -2.82128394e-01f,
  -4.83132631e-01f, 1.92136973e-01f, 5.09766936e-02f, -1.72314882e-01f, 2.74311215e-01f, 3.72550279e-01f, 5.17391026e-01f, 1.56329244e-01f, -2.11506382e-01f, 1.47882327e-01f,
  3.18266116e-02f, -1.78446293e-01f, -1.48513153e-01f, -3.18753198e-02f, 4.96746227e-03f, 2.30495185e-01f, 6.27190024e-02f, -2.32319921e-01f, 2.83031054e-02f, 8.73893946e-02f,
  1.54413953e-01f, -1.32582700e-02f, -3.13217700e-01f, -1.62221953e-01f, -1.11589745e-01f, -1.55115217e-01f, -5.22263758e-02f, 4.91263978e-02f, 1.36882782e-01f, -2.43766487e-01f,
  9.74084660e-02f, -4.38315570e-02f, 1.61336772e-02f, -4.24958356e-02f, 5.90774715e-02f, -3.87511291e-02f, 1.52787194e-02f, -6.36722296e-02f, -3.51073705e-02f, -3.59855182e-02f,
  -1.03345839e-02f, 1.08479559e-02f, 1.57154035e-02f, 5.77013977e-02f, 4.42896746e-02f, 4.32676002e-02f, -8.24860930e-02f, -1.83950551e-02f, 8.05362538e-02f, 1.50212333e-01f,
  4.19078656e-02f, 4.99756299e-02f, 1.63435996e-01f, 8.68290886e-02f, 5.06829731e-02f, -8.66189674e-02f, 1.05849080e-01f, 1.94497313e-02f, 2.34650308e-03f, -8.07420388e-02f,
  -7.19683319e-02f, -8.10847580e-02f, 2.27660742e-02f, 1.36550650e-01f, 1.02415696e-01f, 9.40860882e-02f, 3.55170816e-02f, 4.53649573e-02f, -4.29486111e-02f, -2.59437654e-02f,
  4.06909138e-02f, 1.07756719e-01f, 1.25721935e-02f, 8.46918579e-03f, 4.57026176e-02f, 8.86025205e-02f, 1.56535152e-02f, -1.48577308e-02f, 8.58976245e-02f, 1.23896189e-02f,
  1.12770177e-01f, 3.30038965e-02f, 9.46550444e-02f, 4.30929363e-02f, 7.75940018e-03f, 8.12958628e-02f, 4.28450629e-02f, -8.44141543e-02f, 4.48012389e-02f, 7.08371261e-03f,
  -2.30222922e-02f, 7.21212551e-02f, -4.74537648e-02f, -7.60686323e-02f, -4.39052982e-03f, -9.81660709e-02f, -6.82966709e-02f, -5.37117869e-02f, -6.94539398e-03f, 1.41368229e-02f,
  1.13336049e-01f, 9.05662328e-02f, 1.36728538e-02f, -1.63747817e-02f, 2.01807674e-02f, 6.87465221e-02f, 6.31372109e-02f, -9.97401774e-03f, 2.93979654e-03f, 3.85764688e-02f,
  8.73037893e-03f, 9.68040004e-02f, 6.81219622e-02f, 1.54435411e-01f, 1.43741772e-01f, 4.54391213e-03f, 6.15664236e-02f, 1.29465256e-02f, 9.83441249e-02f, 1.07082829e-01f,
  2.11175218e-01f, -1.39691189e-01f, -1.63902685e-01f, 1.62563518e-01f, -1.07018016e-01f, -4.23038639e-02f, -8.45281631e-02f, 7.98686147e-02f, 9.08017680e-02f, -1.68343317e-02f,
  -6.75620213e-02f, 3.73474583e-02f, 2.24133302e-02f, -3.68407997e-03f, -5.32963201e-02f, -1.24039121e-01f, -1.32702395e-01f, -1.24156900e-01f, 9.65415090e-02f, 1.11828908e-01f,
  2.62997393e-02f, 6.10771887e-02f, 6.74181804e-02f, 1.02579780e-01f, 8.77590664e-03f, 1.58212885e-01f, 5.29546812e-02f, -6.07737713e-02f, -4.54779044e-02f, -8.18059146e-02f,
  -7.48523548e-02f, 1.04023442e-01f, 1.46481752e-01f, 2.22911850e-01f, 1.32906124e-01f, 2.06608981e-01f, 1.60770968e-01f, 3.39960940e-02f, 1.24672875e-01f, 7.25170001e-02f,
  1.62008613e-01f, 6.39460608e-02f, 5.75288124e-02f, 5.33876568e-02f, 1.94733471e-01f, 1.27563804e-01f, 1.65103838e-01f, 8.64862353e-02f, 1.96662188e-01f, 1.47046030e-01f,
  1.52226174e-02f, 5.96700460e-02f, 1.37514947e-02f, 1.01423755e-01f, 1.82594106e-01f, 8.63659084e-02f, 2.01772660e-01f, 1.99558452e-01f, 1.96684912e-01f, 1.36872962e-01f,
  8.08075741e-02f, -1.07171573e-01f, -1.01505063e-01f, -5.47924004e-02f, -5.38253635e-02f, 4.77941334e-02f, -4.82171550e-02f, -3.96668054e-02f, -1.87330954e-02f, 7.58054629e-02f,
  7.41544887e-02f, 1.25069814e-02f, -1.06868043e-03f, 8.15432221e-02f, -3.99143621e-02f, -2.99378540e-02f, 2.05488293e-03f, 3.54362710e-04f, 1.51819764e-02f, -7.76802003e-02f,
  -1.96468011e-02f, 7.83655886e-03f, 3.49063762e-02f, -5.42716682e-02f, 1.74592226e-03f, 4.38547321e-02f, -3.24292853e-02f, 3.17657068e-02f, 9.35127661e-02f, -6.47069737e-02f,
  1.87869847e-01f, -4.87356782e-02f, 1.21185638e-01f, 1.24218747e-01f, 8.05368200e-02f, 1.41610324e-01f, 8.28719437e-02f, 1.59038156e-01f, 7.59953260e-02f, 1.92262724e-01f,
  1.66181952e-01f, 1.39513835e-01f, 1.08760230e-01f, 4.66726869e-02f, 1.26961425e-01f, 1.62452966e-01f, 7.82160461e-02f, 6.50630891e-02f, 6.44801110e-02f, 1.74428850e-01f,
  1.82043165e-01f, 7.82041028e-02f, 1.79250583e-01f, 1.12741612e-01f, 1.45330206e-01f, 7.46394098e-02f, 9.06406268e-02f, 2.25246444e-01f, 4.04869542e-02f, 3.48296136e-01f,
  -2.82543898e-01f, -2.14088157e-01f, 5.99977784e-02f, 1.77375853e-01f, 1.91866547e-01f, 7.15151653e-02f, -7.80627429e-02f, -3.80739979e-02f, 1.82246074e-01f, 9.81407799e-03f,
  1.54993743e-01f, 1.96136728e-01f, 9.34745297e-02f, 1.31470338e-01f, 9.50870663e-03f, 4.66094129e-02f, 2.00782284e-01f, 4.20996696e-02f, 1.24459676e-01f, 1.76904783e-01f,
  3.13935667e-01f, 4.89753038e-02f, 1.10367291e-01f, 8.66037309e-02f, -5.59325628e-02f, 4.08680066e-02f, -9.11156014e-02f, -4.72404920e-02f, -1.00234888e-01f, -8.07737112e-02f,
  -7.81939849e-02f, -1.08038791e-01f, 1.54442057e-01f, 2.16027424e-01f, -2.81535778e-02f, 5.32709621e-02f, 7.30904043e-02f, -1.10379562e-01f, 5.99075630e-02f, 4.33976911e-02f,
  6.33961633e-02f, 4.33210470e-02f, 1.09975085e-01f, 5.60824573e-02f, 7.26937363e-03f, 2.55713947e-02f, 8.03300440e-02f, -1.03770129e-01f, -4.07265127e-02f, 2.14070566e-02f,
  1.87427983e-01f, 8.26413631e-02f, -8.23561102e-02f, -2.05208659e-02f, -1.03722073e-01f, 6.19615726e-02f, -1.98631212e-01f, -1.17690653e-01f, -1.67114392e-01f, -1.99053451e-01f,
  6.63261339e-02f, -3.55994813e-02f, -4.32367846e-02f, -1.73901871e-01f, -5.93903176e-02f, -5.29866740e-02f, -7.23569887e-03f, -4.13445570e-02f, -7.28884572e-03f, -1.00432552e-01f,
  -1.66012440e-02f, 3.83590959e-04f, -1.24645047e-01f, -1.17548205e-01f, 6.03722185e-02f, -6.81793243e-02f, -4.00797166e-02f, -3.80530395e-02f, 4.00584377e-03f, -1.15144491e-01f,
  -5.62601723e-03f, -5.83271571e-02f, -5.15969098e-02f, -1.42053336e-01f, -1.24073252e-02f, -5.28085940e-02f, 5.76650351e-03f, -1.66400224e-02f, 1.75144505e-02f, -3.46751735e-02f,
  1.22897491e-01f, 1.39262572e-01f, 1.50107995e-01f, 8.45851749e-02f, 1.68000296e-01f, 1.46014318e-01f, 1.15309186e-01f, 1.76052377e-01f, 8.00322816e-02f, 4.43074070e-02f,
  1.05704203e-01f, 2.98527274e-02f, 5.16356155e-02f, 8.98002833e-02f, 1.03421241e-01f, 1.24508262e-01f, 1.36480585e-01f, 1.66202471e-01f, 1.09745473e-01f, 6.37807474e-02f,
  8.01594332e-02f, 1.86504096e-01f, 1.01581715e-01f, 1.12813033e-01f, 7.29672015e-02f, 1.63325578e-01f, 2.55218591e-03f, 3.78500350e-04f, -2.78397575e-02f, -1.32049382e-01f,
  4.22026187e-01f, -3.21710259e-02f, 2.03216448e-01f, 1.51371453e-02f, -1.13516062e-01f, -1.28009558e-01f, -6.73792511e-02f, -1.14827141e-01f, -8.58597010e-02f, 1.13329897e-02f,
  -5.87750524e-02f, -1.66787744e-01f, -8.91204923e-02f, -1.94708660e-01f, -1.50399119e-01f, 1.09513968e-01f, 2.88391821e-02f, 9.39592123e-02f, -1.55008316e-01f, -1.41284361e-01f,
  -8.98235962e-02f, 1.80055946e-02f, -9.20952670e-03f, -1.27979472e-01f, -4.82335649e-02f, -3.07030112e-01f, -3.74749377e-02f, -1.17444046e-01f, -2.01194346e-01f, 1.93542019e-02f,
  4.62411493e-02f, 6.53371401e-03f, -2.83597767e-01f, -1.54257137e-02f, -6.09941259e-02f, 3.55028734e-02f, 3.61637212e-02f, 1.93970092e-02f, 1.96025823e-03f, 2.96324864e-02f,
  -1.03755765e-01f, 1.62053164e-02f, -3.97056229e-02f, -5.84989823e-02f, 8.00147727e-02f, -1.06230304e-01f, 3.79160754e-02f, 5.10021895e-02f, 5.75477891e-02f, -1.69963520e-02f,
  -1.27665281e-01f, 1.69115122e-02f, -3.91592756e-02f, -1.41315490e-01f, -9.14711133e-02f, -4.89324741e-02f, -1.15884952e-01f, -7.80730927e-03f, -1.33209273e-01f, 3.77177708e-02f,
  -8.01381096e-02f, 3.63123044e-02f, -6.22154959e-02f, -3.97783034e-02f, 9.95049812e-03f, -3.18964683e-02f, 5.94447739e-02f, -9.41785648e-02f, 3.10790520e-02f, -7.06534553e-03f,
  -5.98777384e-02f, 1.03728943e-01f, 9.82828662e-02f, -3.40208188e-02f, 2.97125336e-02f, 6.33738190e-02f, -6.49373531e-02f, 3.02960612e-02f, -2.27058996e-02f, 6.90647885e-02f,
  1.14877582e-01f, 6.38208091e-02f, 3.85763906e-02f, 4.91389818e-02f, 2.91200988e-02f, 5.66137349e-03f, -4.59409095e-02f, -3.75565998e-02f, -2.19992176e-02f, 1.74739268e-02f,
  -1.45095155e-01f, -2.21757501e-01f, -1.00153185e-01f, -1.20035350e-01f, -1.24793969e-01f, -1.68429270e-01f, -6.59040436e-02f, 2.23133694e-02f, -4.47183512e-02f, -9.04477984e-02f,
  -1.48616612e-01f, -1.87339447e-02f, -1.12830335e-02f, 5.42919850e-03f, -8.26477483e-02f, -4.94973734e-02f, -4.71225381e-02f, -5.29275909e-02f, -6.61028922e-02f, -7.38295168e-02f,
  -6.42378479e-02f, -1.25613511e-01f, -8.14171955e-02f, -1.32408887e-01f, -1.73086494e-01f, -1.83303669e-01f, -8.52973163e-02f, -1.18848704e-01f, -1.98615238e-01f, -1.27450943e-01f,
  4.22619402e-01f, 6.67841360e-02f, 7.92285055e-02f, 2.01636299e-01f, -9.22232568e-02f, 1.06555760e-01f, 6.38512671e-02f, 1.06435657e-01f, 4.76489365e-02f, -1.65052023e-02f,
  2.36791410e-02f, -6.09990628e-03f, 8.57327133e-02f, -7.25328624e-02f, 1.47026256e-01f, -4.15276960e-02f, -2.45153904e-01f, 6.15032949e-02f, 1.07598439e-01f, 1.50741294e-01f,
  -1.57931685e-01f, -1.35000292e-02f, 1.85067654e-01f, 1.15370147e-01f, 1.02639444e-01f, 5.95429055e-02f, 1.40639827e-01f, 1.24814592e-01f, 2.94448528e-03f, -1.81459770e-01f,
  1.35905638e-01f, 1.74370781e-01f, 4.13015448e-02f, 2.95938272e-02f, 6.48139492e-02f, 1.26721352e-01f, 1.44565716e-01f, -5.12938434e-03f, 5.17157931e-03f, 3.33067849e-02f,
  3.72479334e-02f, 1.16219744e-01f, 5.76581210e-02f, -2.26165708e-02f, 1.45415077e-02f, 9.19547081e-02f, 3.62875462e-02f, 1.18938461e-02f, -1.74400285e-02f, -8.57870746e-03f,
  -1.52197704e-01f, -2.89290515e-03f, 1.06815770e-01f, 2.12609917e-02f, 1.27121001e-01f, 2.45956890e-02f, 1.42308891e-01f, 1.48485094e-01f, 1.39742687e-01f, 6.83020009e-03f,
  1.44273918e-02f, 1.40288193e-02f, 7.79080912e-02f, 1.30638033e-01f, 4.54705767e-02f, 1.64062008e-02f, 7.08054453e-02f, 5.79169132e-02f, -9.82975066e-02f, 5.93682341e-02f,
  -2.50443649e-02f, 5.31442314e-02f, -5.55423647e-03f, 1.58191666e-01f, -7.25920051e-02f, 4.91272705e-03f, -2.28785612e-02f, 1.44252870e-02f, -7.36840675e-03f, -2.30577867e-02f,
  2.62144562e-02f, -5.36586232e-02f, -2.59025320e-02f, -9.85644311e-02f, 3.89827229e-02f, -5.81622720e-02f, -1.99005362e-02f, -9.10730381e-03f, 2.92898491e-02f, -2.60934103e-02f,
  1.23912722e-01f, -4.83868904e-02f, -2.32261308e-02f, 1.03723044e-02f, 3.40821221e-02f, 2.76875012e-02f, 2.28742324e-02f, 7.23159239e-02f, 3.73756103e-02f, -3.86801958e-02f,
  1.55770227e-01f, 1.31078079e-01f, -8.90350062e-03f, -7.39881173e-02f, 7.28964955e-02f, -2.03640684e-02f, -9.33128297e-02f, -1.64177194e-02f, -8.45912378e-04f, 2.92964149e-02f,
  -5.21382652e-02f, 1.16238676e-01f, 2.33494759e-01f, -1.64451897e-02f, -2.92524183e-03f, 1.72305480e-01f, 2.03921616e-01f, 2.17975378e-01f, 2.16650426e-01f, 2.41266623e-01f,
  -3.05935591e-01f, -4.02897090e-01f, -1.62707791e-01f, -2.19460934e-01f, -1.13601752e-01f, -2.31340118e-02f, -1.18097693e-01f, -1.00817308e-01f, -1.82602614e-01f, -2.25681871e-01f,
  -1.16549760e-01f, 3.54347490e-02f, 2.81411572e-03f, -3.26235667e-02f, -8.74155760e-03f, -1.46035522e-01f, -3.22181791e-01f, -9.10140350e-02f, 5.23817167e-02f, 9.38889310e-02f,
  -1.05157889e-01f, -1.20977961e-01f, -2.13773683e-01f, -9.96837541e-02f, -2.74158627e-01f, -2.98752487e-02f, -1.24164298e-01f, -2.29677573e-01f, -8.84179771e-02f, -3.93474281e-01f,
  -1.51481023e-02f, -3.08445483e-01f, -7.21700415e-02f, -1.47585392e-01f, -1.73714429e-01f, -9.02472958e-02f, -1.25794291e-01f, -1.79795146e-01f, -1.99988052e-01f, -1.75931200e-01f,
  -1.17553741e-01f, -1.84799969e-01f, -1.63224056e-01f, -8.86332840e-02f, -1.63621724e-01f, -1.14764303e-01f, -2.53389001e-01f, -1.31605074e-01f, -2.11027130e-01f, -1.12102374e-01f,
  -1.33755639e-01f, -2.35680386e-01f, -2.58713394e-01f, -1.27414092e-01f, -1.92546338e-01f, -8.06944221e-02f, -2.51463562e-01f, -1.64623365e-01f, -1.37230366e-01f, -1.46190464e-01f,
  -4.84141009e-03f, 1.82028159e-01f, 1.97993293e-01f, 2.31109545e-01f, 2.66939491e-01f, 2.73627251e-01f, 2.19255015e-01f, 3.02830130e-01f, 3.27339470e-01f, 1.50674611e-01f,
  2.02691182e-01f, 2.36293435e-01f, 2.04320714e-01f, 2.07264721e-01f, 2.64463097e-01f, 2.10761428e-01f, 1.77755192e-01f, 2.71251321e-01f, 1.58185437e-01f, 1.29537880e-01f,
  1.71407357e-01f, 1.65255129e-01f, 2.01470181e-01f, 2.81768054e-01f, 1.37460008e-01f, 2.47931764e-01f, 1.69705003e-01f, 2.71952420e-01f, 1.72266185e-01f, 1.26018032e-01f,
  -4.06301394e-02f, -1.25253379e-01f, -7.51033723e-02f, -1.74836054e-01f, -9.60734338e-02f, -1.38551161e-01f, -8.20497125e-02f, -7.39600658e-02f, -8.89228731e-02f, -1.78809658e-01f,
  -1.83299750e-01f, -6.75198808e-02f, -1.47840962e-01f, -1.37445226e-01f, -8.86625871e-02f, -3.96349877e-02f, -4.58890907e-02f, -1.10738672e-01f, -1.41178101e-01f, -1.06482148e-01f,
  -1.09983705e-01f, 2.90726707e-03f, -5.66401239e-03f, -4.91566807e-02f, -1.05704688e-01f, 8.70899111e-02f, 5.17478697e-02f, -2.95729991e-02f, 6.34694938e-03f, -1.69971325e-02f,
  -1.46486014e-01f, 2.11777732e-01f, 8.67737010e-02f, 2.21249368e-03f, -6.60067284e-03f, 7.38540143e-02f, 1.32282466e-01f, 1.96827069e-01f, 5.05933613e-02f, 4.11671996e-02f,
  1.18343206e-02f, -8.00780877e-02f, 3.92276272e-02f, 1.12376753e-02f, 1.25895292e-01f, 8.33679140e-02f, -3.16703469e-02f, 6.15443587e-02f, -4.49952409e-02f, 1.31727522e-02f,
  4.07139361e-02f, -1.18495755e-01f, -1.23853073e-01f, 9.58778486e-02f, -1.26956969e-01f, -1.75215498e-01f, -1.65426463e-01f, -1.73176512e-01f, -1.54970929e-01f, -2.32172415e-01f,
  -1.52294412e-01f, 1.10797241e-01f, 5.84959202e-02f, -6.13443134e-03f, 1.31073400e-01f, 1.23796433e-01f, 2.29082052e-02f, 2.53326874e-02f, 3.42543870e-02f, 8.45314935e-02f,
  5.77130392e-02f, -8.64038803e-03f, -7.34852776e-02f, -2.35086889e-03f, 3.59576531e-02f, -3.02937310e-02f, 2.21715998e-02f, 1.18829854e-01f, 1.60795778e-01f, 2.15544235e-02f,
  1.06029257e-01f, 2.30455808e-02f, -3.33257578e-02f, 1.19881794e-01f, 1.16200395e-01f, 1.74561199e-02f, -2.95487139e-02f, -4.86821905e-02f, -8.48323107e-02f, -2.10577548e-01f,
  -3.11682940e-01f, -1.31016269e-01f, 3.11484188e-02f, -8.13024938e-02f, 4.34722044e-02f, -5.09693213e-02f, -5.55080473e-02f, -2.61604469e-02f, -1.54033666e-02f, 6.66067377e-02f,
  8.19900408e-02f, 2.96780318e-02f, 5.70151582e-02f, 5.86796440e-02f, 4.33450937e-02f, 3.20983343e-02f, 6.93837553e-02f, -4.98906039e-02f, 6.12919629e-02f, 2.62920815e-03f,
  2.50475258e-02f, -3.09531367e-03f, -4.55056578e-02f, 1.20593607e-02f, -4.22375761e-02f, -2.72995271e-02f, -8.80801212e-03f, -1.54885871e-04f, 5.32993339e-02f, 1.20951273e-02f,
  -1.22079000e-01f, 1.07789367e-01f, 9.21774954e-02f, -6.41730800e-02f, -1.88930389e-02f, -2.21964922e-02f, 6.56582117e-02f, 7.96172693e-02f, 1.40572011e-01f, 4.50424924e-02f,
  8.06974843e-02f, -3.49382907e-02f, 6.11406490e-02f, -4.70242202e-02f, 7.34402314e-02f, -1.09640136e-02f, 2.62064929e-03f, 9.88992229e-02f, 1.14771888e-01f, 7.70951509e-02f,
  3.83989215e-02f, -9.22514349e-02f, 2.00059880e-02f, 1.05114684e-01f, -3.09771728e-02f, -1.91347264e-02f, -6.90099224e-02f, -1.55321360e-01f, 5.01621328e-02f, -4.38758433e-02f,
  -3.58116597e-01f, -4.60703708e-02f, 5.87859154e-02f, -3.37693542e-01f, -1.81264907e-01f, -2.29766518e-02f, -1.42321214e-01f, -1.40411779e-01f, -1.01847231e-01f, -3.32568698e-02f,
  4.46793064e-02f, 1.94777265e-01f, 1.43254951e-01f, 1.11156449e-01f, 5.34800701e-02f, -7.88116157e-02f, -2.62816519e-01f, 1.61870196e-02f, 3.81728038e-02f, -6.78875670e-02f,
  -7.63103738e-02f, -1.52724147e-01f, 1.32561019e-02f, -8.87759700e-02f, -6.77862242e-02f, -3.12748030e-02f, -4.57725786e-02f, -8.09995458e-03f, -2.76956204e-02f, -1.39452040e-01f,
  8.25530812e-02f, -3.63008939e-02f, 1.03243805e-01f, -1.50627363e-03f, 1.08882405e-01f, 1.55143052e-01f, 5.05024046e-02f, 5.79219759e-02f, 1.00251079e-01f, -3.18112154e-03f,
  -2.04356294e-02f, 8.05428848e-02f, 6.01640306e-02f, 5.74252196e-02f, 7.91380033e-02f, 2.46435590e-02f, 8.44571143e-02f, -5.00145461e-03f, 1.06577985e-01f, 1.63728297e-01f,
  -2.11690436e-03f, -8.90352484e-03f, 2.49762423e-02f, 7.51284361e-02f, 1.36955395e-01f, 7.77163059e-02f, 1.47731885e-01f, -2.84115747e-02f, 7.44303614e-02f, 8.67920090e-03f,
  -2.21993178e-02f, -2.63392646e-02f, 7.94382915e-02f, -4.84336168e-02f, -1.23918829e-02f, -5.84720224e-02f, -1.51702225e-01f, -3.36795561e-02f, -6.61132112e-02f, -5.99746704e-02f,
  -9.54034328e-02f, -5.63078709e-02f, -3.51662195e-04f, -6.20164834e-02f, -2.09694579e-02f, -8.92636273e-03f, 4.24853228e-02f, 3.75751331e-02f, 1.03955343e-01f, 1.56838400e-03f,
  6.01970516e-02f, 4.35186066e-02f, -5.96978702e-02f, -3.21697555e-02f, 2.22824346e-02f, 5.48977219e-02f, 5.61913708e-03f, 7.08875135e-02f, -7.09700212e-02f, -3.83469984e-02f,
  1.73616648e-01f, 2.92404145e-01f, 2.42710803e-02f, 8.01406503e-02f, -2.81210709e-02f, 1.49785668e-01f, 1.10212490e-01f, 9.59298983e-02f, 1.37162000e-01f, 1.04326926e-01f,
  5.32938093e-02f, 2.46991627e-02f, 8.68467987e-02f, 4.80583198e-02f, -5.59147634e-02f, -3.51405218e-02f, -1.57553293e-02f, 4.22043614e-02f, 1.11720050e-02f, 2.33384520e-02f,
  1.27237309e-02f, -6.28405958e-02f, 1.57532357e-02f, -1.18705081e-02f, 1.22800037e-01f, -7.31352791e-02f, 4.30073775e-02f, 3.45967188e-02f, 1.60174057e-01f, 1.41232358e-02f,
  3.26823652e-01f, 2.24241018e-01f, -1.50858820e-03f, 1.57476798e-01f, 6.77344576e-02f, 1.57783881e-01f, 3.68563592e-01f, -3.18654021e-03f, -1.10034607e-01f, 9.23509598e-02f,
  2.25037560e-02f, -1.27238616e-01f, -1.81940302e-01f, -1.95079774e-01f, 4.87714522e-02f, 2.02375621e-01f, 7.72765428e-02f, -2.79544503e-03f, -6.36282191e-03f, 8.77079293e-02f,
  -3.40803377e-02f, -2.57999753e-03f, -1.24769330e-01f, -3.65732163e-02f, 1.29319027e-01f, -1.10078871e-01f, -1.07832082e-01f, -5.19089447e-03f, -2.22570989e-02f, 1.52375072e-01f,
  1.15245715e-01f, 1.92648500e-01f, -3.91110778e-02f, -1.15073070e-01f, -4.91478033e-02f, -4.94071618e-02f, 8.59405249e-02f, -3.17720417e-03f, -4.04391252e-03f, 1.09699063e-01f,
  -1.25615075e-01f, -5.56986220e-02f, 1.83213840e-03f, -3.04460190e-02f, 8.34873840e-02f, 5.19055128e-02f, -1.95917562e-02f, -8.61410126e-02f, -2.49134563e-03f, 3.74256470e-03f,
  -9.41572860e-02f, -2.98636388e-02f, -6.80129752e-02f, -9.80330184e-02f, -6.64136857e-02f, -1.50947794e-01f, 1.51154082e-02f, -9.19266716e-02f, -5.81952557e-02f, 1.20038085e-01f,
  -1.36139140e-01f, -3.10591795e-02f, -7.26904199e-02f, 1.02846950e-01f, 2.97443587e-02f, -3.30015272e-02f, -4.10018663e-04f, 7.32507110e-02f, 1.59605630e-02f, 4.70051952e-02f,
  -2.35990640e-02f, -3.99280107e-03f, -4.91272137e-02f, 4.60394323e-02f, 1.53652707e-03f, -1.15202861e-02f, -2.20686421e-02f, -8.69934559e-02f, -5.23458160e-02f, 3.03464732e-03f,
  -6.60112733e-03f, 1.69280753e-03f, -5.59663065e-02f, -4.16833721e-02f, -4.03523110e-02f, -3.90359238e-02f, 2.36193016e-02f, -6.99685737e-02f, -6.50638118e-02f, 3.14511247e-02f,
  4.84156460e-02f, -1.07418843e-01f, 2.38989040e-01f, 6.88545704e-02f, -4.47811708e-02f, -9.84200165e-02f, 2.89333500e-02f, -6.54145330e-02f, 5.47480360e-02f, 5.59561066e-02f,
  5.24811596e-02f, 9.11910385e-02f, 2.61152200e-02f, 6.15399592e-02f, 2.17712075e-02f, -4.55046594e-02f, 2.49359012e-02f, 4.36647981e-02f, -5.76248839e-02f, 2.14322731e-02f,
  -1.69070009e-02f, -1.11782188e-04f, 3.49533819e-02f, 3.73951718e-02f, 2.24840790e-02f, 4.68756706e-02f, -4.00408842e-02f, 7.25411400e-02f, 5.58221191e-02f, 2.19846368e-01f,
  1.83704346e-01f, -2.91798562e-01f, 1.20523579e-01f, 1.55781686e-01f, -2.33808428e-01f, -1.51295260e-01f, -4.68399912e-01f, -1.40136167e-01f, 1.08899109e-01f, -2.11074561e-01f,
  4.37261164e-02f, 3.19814682e-01f, 2.21987039e-01f, 1.16278172e-01f, 1.02719134e-02f, -2.72714585e-01f, -1.17835417e-01f, 1.47791371e-01f, 2.19017953e-01f, -3.63943838e-02f,
  -1.65286124e-01f, -5.49866259e-03f, 2.17928112e-01f, 1.72345378e-02f, -7.62093216e-02f, 9.64815468e-02f, -2.10906435e-02f, -5.88362813e-02f, -3.40971909e-02f, 9.26475003e-02f,
  3.90512824e-01f, -1.79787651e-01f, 5.95649444e-02f, -1.90785658e-02f, 6.04439573e-03f, -7.27899820e-02f, 8.02227035e-02f, 5.40346280e-02f, -3.22695188e-02f, 2.33425684e-02f,
  -3.97558473e-02f, -9.59855914e-02f, 3.42588276e-02f, -7.99268633e-02f, -1.06422952e-03f, -4.89723459e-02f, -1.87270567e-02f, -5.43678887e-02f, -3.30879465e-02f, -4.98858355e-02f,
  -5.70407957e-02f, -6.31952705e-03f, -8.41893554e-02f, -1.38241142e-01f, -1.13981724e-01f, 5.96052371e-02f, 3.57677676e-02f, -3.21628749e-02f, -8.97755101e-02f, 2.90936846e-02f,
  9.56011564e-02f, 9.45522189e-02f, -1.30185978e-02f, -1.53658502e-02f, -5.05234934e-02f, -4.82320748e-02f, 4.43433858e-02f, 2.05389261e-02f, 6.29161969e-02f, 5.28490394e-02f,
  -3.76856700e-02f, 3.66938561e-02f, 2.48747375e-02f, 5.22976406e-02f, 4.06079702e-02f, -3.34767811e-02f, 1.75246168e-02f, 1.95658188e-02f, 1.74288750e-02f, -2.94693429e-02f,
  1.44038117e-02f, 4.71380390e-02f, -1.49961542e-02f, 1.31634688e-02f, -6.65102452e-02f, 3.66264745e-03f, 7.79178813e-02f, -7.84988850e-02f, 6.32260591e-02f, -2.56193578e-02f,
  1.97318941e-01f, -1.29254878e-01f, -1.57614741e-02f, 8.96567926e-02f, -5.26325442e-02f, -2.53855251e-03f, 5.19349948e-02f, 1.54162142e-02f, -6.55011907e-02f, 1.71204433e-02f,
  -5.24418950e-02f, 5.27451336e-02f, -5.30607952e-03f, -7.70622343e-02f, 2.53814775e-02f, 9.34961904e-03f, -3.34154442e-02f, 9.88959372e-02f, -5.90270497e-02f, -6.70562014e-02f,
  -1.29639348e-02f, -7.69874826e-03f, 1.29101992e-01f, 9.79015306e-02f, 7.16040954e-02f, 1.29448608e-01f, 3.17273065e-02f, 3.75085175e-02f, 5.81974946e-02f, -5.96410148e-02f,
  -1.13600917e-01f, 3.11925381e-01f, 1.41499951e-01f, 4.89457995e-02f, 8.42062011e-02f, 7.67657831e-02f, 2.70472348e-01f, 1.04506128e-01f, 9.79239400e-03f, 1.43998295e-01f,
  6.08895011e-02f, 1.58694363e-03f, 8.10247362e-02f, 1.18905017e-02f, 8.25747102e-02f, 2.42909342e-01f, 2.62567282e-01f, -2.45632511e-02f, -2.83732355e-01f, 6.12900704e-02f,
  2.53883861e-02f, -1.34954853e-02f, -1.38894310e-02f, 7.75387138e-02f, 3.13581705e-01f, 5.44198193e-02f, 2.32434854e-01f, 2.28526071e-01f, 1.95244819e-01f, 5.86965322e-01f,
  1.58745274e-01f, 2.10736379e-01f, -7.24457204e-02f, 8.81602094e-02f, 6.00875802e-02f, -3.11130043e-02f, 4.80691046e-02f, 1.65210217e-02f, -1.16562014e-02f, 1.14904165e-01f,
  1.67705715e-01f, 7.35665262e-02f, 1.96796536e-01f, 5.73850349e-02f, 9.50567499e-02f, 1.12062186e-01f, 9.91646871e-02f, 1.71149656e-01f, 1.19945712e-01f, 1.63921848e-01f,
  1.51111454e-01f, -9.59344301e-03f, 3.49088423e-02f, 1.44064292e-01f, 1.81842923e-01f, -2.33467016e-02f, 7.18557090e-02f, 2.06454724e-01f, -2.68387003e-03f, 2.53667414e-01f,
  -6.45564124e-02f, -1.87316507e-01f, -8.05541873e-02f, -3.31183150e-02f, -4.42493409e-02f, -2.06739195e-02f, -5.38812801e-02f, -1.98953319e-02f, -1.10377140e-01f, 8.04749224e-03f,
  -6.12244708e-03f, -1.61693096e-01f, -6.75788745e-02f, -2.80916840e-02f, -1.84736297e-01f, -1.28866509e-02f, -8.44374001e-02f, -1.97435301e-02f, -5.85339852e-02f, -1.00176379e-01f,
  -1.25818565e-01f, 1.79041997e-02f, -8.52859244e-02f, -8.62143934e-02f, -1.16959903e-02f, -1.47137314e-01f, -9.02237836e-03f, -2.73895990e-02f, -6.65207952e-02f, -7.01582357e-02f,
  -1.66606709e-01f, -4.80461568e-02f, 1.38159871e-01f, 6.56429902e-02f, 1.09147795e-01f, 7.79797062e-02f, -1.03164483e-02f, 1.00260451e-01f, 1.35033866e-02f, 6.57783300e-02f,
  1.42203569e-01f, 7.43293986e-02f, 1.25322580e-01f, 9.25131366e-02f, 3.50970924e-02f, 1.05103746e-01f, 1.50690854e-01f, 4.20895889e-02f, 4.14726287e-02f, 4.48687673e-02f,
  8.10123384e-02f, -3.57068926e-02f, 6.84784958e-03f, 1.35628949e-03f, 1.23703733e-01f, -1.22488126e-01f, 4.47931625e-02f, 6.47659749e-02f, -7.91978613e-02f, 1.43977646e-02f,
  -9.72683206e-02f, -2.69516438e-01f, -1.56564146e-01f, -1.89514384e-02f, -7.34851658e-02f, -6.05922565e-02f, -2.10601464e-01f, 3.44091021e-02f, 1.34755433e-01f, -9.64966342e-02f,
  2.18325704e-02f, 2.21959442e-01f, 7.69944116e-02f, 1.80741902e-02f, -7.61061488e-03f, -1.22400180e-01f, -6.54344931e-02f, -8.59476104e-02f, 5.22958115e-02f, 2.83618290e-02f,
  1.17831774e-01f, -2.84704957e-02f, -1.85818654e-02f, 2.96824723e-02f, -1.48681849e-01f, 6.65016398e-02f, -2.31032878e-01f, -1.36148900e-01f, -9.25851762e-02f, -4.24506456e-01f,
  -1.78427681e-01f, -3.51982206e-01f, 3.98844518e-02f, 2.55175736e-02f, -1.47795320e-01f, -1.02651522e-01f, -7.26225972e-02f, -1.08558491e-01f, -1.59058452e-01f, -2.40804851e-02f,
  -1.10678323e-01f, -1.90557614e-01f, -1.74009517e-01f, -1.20760113e-01f, -1.48162723e-01f, -8.66793469e-02f, -1.68588787e-01f, -1.47211745e-01f, -2.02596441e-01f, -1.59933120e-01f,
  -1.59785539e-01f, -1.03308134e-01f, -2.09045053e-01f, -8.65875259e-02f, -5.18730879e-02f, -5.58029115e-02f, -2.57992059e-01f, -1.55868858e-01f, -2.02438757e-01f, -1.56172648e-01f,
  1.01550288e-01f, 1.32958055e-01f, -3.58739197e-02f, 6.75459951e-02f, 5.99587001e-02f, 4.83218990e-02f, -4.71449718e-02f, -5.43631688e-02f, 1.32868364e-02f, 9.10129547e-02f,
  2.08049882e-02f, 9.58482474e-02f, 5.79853356e-02f, -1.16794622e-02f, 4.80650514e-02f, -3.51215899e-02f, 3.49656004e-03f, -7.05843866e-02f, 7.27050006e-02f, 6.05176315e-02f,
  4.75837067e-02f, -2.78094262e-02f, 3.92568950e-03f, -5.60014583e-02f, -4.02960554e-02f, 3.00957523e-02f, 1.17456809e-01f, -2.59793684e-04f, 3.19482423e-02f, 9.26162750e-02f,
  6.91557378e-02f, -8.82611349e-02f, 5.60439788e-02f, -1.57371387e-02f, -1.48474082e-01f, -2.72191260e-02f, -6.90995529e-02f, -1.18485034e-01f, -1.07684590e-01f, -1.05634496e-01f,
  -1.04074113e-01f, -1.37496591e-01f, -4.70513664e-02f, -1.44391641e-01f, 3.36516229e-03f, 5.76392142e-03f, -8.05664584e-02f, -1.23162270e-01f, -8.28709006e-02f, -1.05663739e-01f,
  -3.81644256e-02f, -1.42997839e-02f, 2.92880908e-02f, 5.76116033e-02f, -3.09399236e-03f, 9.70128998e-02f, -6.23313785e-02f, -1.36076629e-01f, -8.21066946e-02f, 7.08358437e-02f,
  -5.00480771e-01f, 6.79839477e-02f, 3.18269044e-01f, -2.38523245e-01f, -1.03727877e-01f, -7.62679428e-02f, -6.91357628e-02f, -1.59673393e-01f, -1.27004012e-01f, -7.05499435e-03f,
  1.72785804e-01f, 1.39460102e-01f, 1.30301595e-01f, -1.55248897e-04f, -1.39315695e-01f, -8.25012624e-02f, -4.55548391e-02f, -6.98547438e-02f, 1.00077521e-02f, 2.29359954e-03f,
  -1.60132676e-01f, -1.33990347e-01f, -5.67212477e-02f, -2.11764295e-02f, -6.69521317e-02f, 7.00972602e-02f, 7.20676500e-04f, 4.21144860e-03f, 6.82429746e-02f, -1.16352895e-02f,
  3.70541483e-01f, -1.13067254e-01f, -1.68349445e-01f, -1.60224348e-01f, 2.44221743e-02f, -7.74943829e-02f, -3.17638144e-02f, 5.65085234e-03f, -1.30078763e-01f, 2.05791537e-02f,
  -3.43384743e-02f, -4.66364771e-02f, 2.38285903e-02f, -5.31806834e-02f, -7.03375861e-02f, -4.66955714e-02f, -8.24848861e-02f, -9.76789817e-02f, -8.08799416e-02f, 8.30006674e-02f,
  -1.08540058e-01f, -9.42696407e-02f, -6.00479729e-02f, 1.18204299e-02f, -3.19620259e-02f, -4.00791243e-02f, 7.22896829e-02f, -5.58380689e-03f, 5.97579256e-02f, -2.24190056e-02f,
  3.15309241e-02f, 8.93486962e-02f, 6.95800781e-02f, 9.45355892e-02f, 7.39428215e-04f, 9.73780081e-02f, 8.48514885e-02f, 1.05371132e-01f, 1.25020772e-01f, 9.14131999e-02f,
  1.17502280e-01f, 1.35810405e-01f, 7.10670501e-02f, 7.82721341e-02f, 2.05548450e-01f, 1.34632170e-01f, 6.94874451e-02f, 1.28402725e-01f, 1.26493350e-01f, 5.02213202e-02f,
  3.26549485e-02f, 3.06338388e-02f, 1.03328601e-01f, 8.34991634e-02f, 3.84422094e-02f, 9.33753923e-02f, 1.49526030e-01f, 1.51030853e-01f, 1.78321809e-01f, 3.72141488e-02f,
  7.54570216e-02f, -7.73871019e-02f, -2.16144845e-01f, -1.37316808e-01f, -1.75698325e-01f, -1.17562681e-01f, -1.13557890e-01f, -4.45432588e-02f, -1.05245657e-01f, -5.59251681e-02f,
  -5.92055321e-02f, -3.51045169e-02f, -1.00362767e-02f, -1.18458480e-01f, -1.31781012e-01f, -6.75753281e-02f, -1.53408751e-01f, -1.50995865e-01f, -1.36825174e-01f, -4.03092392e-02f,
  -1.19506203e-01f, -2.52582878e-01f, -2.06285760e-01f, -7.15024844e-02f, -1.49912223e-01f, -7.54478052e-02f, -5.92443682e-02f, -1.33277670e-01f, -1.40874773e-01f, -3.45562786e-01f,
  -2.26821913e-03f, -4.65704083e-01f, -1.27900122e-02f, 1.41459763e-01f, 4.68945131e-02f, -8.64328668e-02f, -3.15830469e-01f, -7.29139149e-02f, 1.88520908e-01f, -2.17313334e-01f,
  -7.74988681e-02f, 2.58346766e-01f, 1.82378605e-01f, 2.68623650e-01f, 9.34991091e-02f, -2.33278334e-01f, -1.21891471e-02f, 2.10235834e-01f, 3.27943146e-01f, 1.09323122e-01f,
  -3.39422934e-03f, -3.37980576e-02f, -3.51332780e-03f, 1.85547397e-01f, -2.27011606e-01f, 1.18438087e-01f, -2.51200914e-01f, -1.66564003e-01f, -2.16999516e-01f, -1.65654719e-01f,
  -1.41996920e-01f, -1.34479553e-01f, 1.50629908e-01f, 9.84502137e-02f, -1.39680177e-01f, -6.34625852e-02f, -1.06906109e-01f, -7.34254047e-02f, -1.09545596e-01f, -4.45476025e-02f,
  5.73766942e-04f, -9.94376373e-03f, -1.90027598e-02f, -1.35873463e-02f, -8.35327059e-02f, -3.68154272e-02f, -3.07311285e-02f, -2.49799397e-02f, -3.25733349e-02f, -7.98577517e-02f,
  5.87869249e-02f, 5.65054975e-02f, -2.72005815e-02f, -2.21838206e-02f, 9.64184478e-02f, 1.87209770e-01f, 1.98492296e-02f, -4.68693394e-03f, 1.22227535e-01f, -1.13080226e-01f,
  -1.37800813e-01f, 4.67487834e-02f, 1.91549584e-02f, -1.00324146e-01f, -6.45084446e-03f, -5.63809499e-02f, -3.91091453e-03f, -9.03186947e-03f, 5.64822331e-02f, -4.68203351e-02f,
  1.85613725e-02f, 7.96941966e-02f, 3.89257930e-02f, -1.22115575e-02f, 4.87461034e-03f, 4.56302874e-02f, 9.86640435e-03f, 8.95513408e-03f, 1.39194489e-01f, 5.59590906e-02f,
  2.53606420e-02f, -6.90544844e-02f, 3.74485403e-02f, -5.48280627e-02f, 3.87035497e-02f, 5.73206544e-02f, 8.79993476e-03f, -3.33916247e-02f, -7.25933015e-02f, -3.74214537e-02f,
  -3.96134406e-02f, 3.30590039e-01f, 3.17917392e-02f, 7.97935426e-02f, 3.61795048e-03f, 1.53242527e-02f, 5.52548170e-02f, -1.74882507e-03f, 1.22056134e-01f, 7.31914341e-02f,
  1.71320159e-02f, 1.37806749e-02f, -5.23390919e-02f, 2.86839847e-02f, 5.77761419e-02f, 6.32683933e-02f, 1.22300796e-02f, 8.57824534e-02f, 5.79614453e-02f, 8.61063898e-02f,
  3.23794745e-02f, 5.08008786e-02f, 1.01594716e-01f, 1.28752977e-01f, 9.07105431e-02f, 1.42142370e-01f, -9.01911259e-02f, -1.16643747e-02f, 2.03470942e-02f, -1.56011701e-01f,
  -3.74241948e-01f, 1.80511206e-01f, -6.52339309e-02f, -1.57047495e-01f, 1.20965153e-01f, 2.08605930e-01f, 2.72311747e-01f, 3.04498430e-02f, -5.20432927e-02f, 1.71849094e-02f,
  1.13479219e-01f, 1.51344880e-01f, 1.12935066e-01f, 1.90627903e-01f, 2.29798511e-01f, 2.23302230e-01f, 1.01617150e-01f, 1.20055862e-01f, 1.62407547e-01f, 1.66936964e-01f,
  2.50859886e-01f, -7.96594694e-02f, -1.73714876e-01f, -9.20098927e-03f, 8.27590376e-02f, -3.60144489e-02f, 6.04441110e-03f, -2.15476770e-02f, 4.47607450e-02f, 1.02802850e-01f,
  -6.73121065e-02f, 5.41231558e-02f, 1.86973244e-01f, 1.25213474e-01f, 9.72614437e-02f, -3.67383808e-02f, -1.01511013e-02f, 6.61759153e-02f, 3.83430272e-02f, 1.23905450e-01f,
  1.59881324e-01f, 1.12394162e-01f, 6.40479550e-02f, 5.59252314e-02f, 9.50364396e-02f, 6.60108924e-02f, 1.13007635e-01f, 1.12533167e-01f, 1.89979553e-01f, 1.21081412e-01f,
  2.52023369e-01f, 2.82467335e-01f, 6.20417483e-02f, 1.51414171e-01f, 1.93427697e-01f, 2.26839721e-01f, 1.19528435e-01f, 2.19114169e-01f, 6.39219359e-02f, 5.30259237e-02f,
  1.17412396e-01f, -1.52652822e-02f, -1.41650841e-01f, -1.05784133e-01f, -8.20599943e-02f, -3.02690733e-02f, -5.25769293e-02f, -2.35646367e-02f, -2.61338241e-03f, -1.02024585e-01f,
  -7.52178580e-02f, -1.49799019e-01f, 3.27020139e-02f, -1.44448131e-01f, -3.04731447e-02f, 3.41263935e-02f, 4.19767294e-03f, -1.07656889e-01f, -1.23822644e-01f, -8.29186812e-02f,
  -7.66009018e-02f, -1.14173360e-01f, -2.11700022e-01f, 4.76137698e-02f, -7.53954872e-02f, -8.05822909e-02f, -1.22313388e-01f, -6.00688979e-02f, -2.20863789e-01f, -7.82340318e-02f,
  -8.81823003e-02f, 2.35036179e-01f, 8.09579790e-02f, 2.75678098e-01f, 7.59668872e-02f, 6.85719699e-02f, 1.17646642e-01f, 1.64059877e-01f, 1.66645914e-01f, 1.16674110e-01f,
  1.73098281e-01f, 1.20053709e-01f, 1.69615149e-01f, 1.25332221e-01f, 1.26395509e-01f, 1.22264855e-01f, 1.40131384e-01f, 1.57933801e-01f, 1.59359470e-01f, 9.51343626e-02f,
  1.07472159e-01f, 2.04281315e-01f, 4.30657603e-02f, 1.63275585e-01f, 2.19915584e-01f, 6.15960620e-02f, 3.85878608e-02f, 7.90871680e-02f, 1.17614307e-01f, -1.10781506e-01f,
  -2.42553517e-01f, 3.72852951e-01f, -1.37105599e-01f, 1.43313989e-01f, 1.41998053e-01f, 9.34570748e-03f, -5.13802171e-02f, -9.66203734e-02f, 1.36814818e-01f, 1.94348380e-01f,
  1.46377653e-01f, 5.37429452e-02f, 1.05090082e-01f, -4.52007726e-02f, -2.55543411e-01f, 2.20859535e-02f, 5.50655462e-02f, -2.42079750e-01f, -3.60882610e-01f, -3.36041339e-02f,
  2.03927934e-01f, -2.56382860e-02f, -1.49944827e-01f, -1.00522324e-01f, 2.58214027e-01f, -8.03618133e-03f, 1.28153265e-01f, 1.31423071e-01f, 5.12962006e-02f, 2.07343698e-01f,
  6.58074720e-03f, 1.07910365e-01f, -1.52289718e-01f, 6.21574745e-02f, 6.81545734e-02f, 2.30417261e-03f, -3.45459953e-02f, -2.07746793e-02f, 5.43637909e-02f, 4.18496765e-02f,
  6.91654384e-02f, 5.48753627e-02f, -2.76595335e-02f, 2.86576953e-02f, 2.33281683e-02f, -9.93159041e-02f, -1.97598245e-02f, -7.53730014e-02f, -2.96232030e-02f, 1.11708216e-01f,
  1.01143911e-01f, 1.75421640e-01f, -1.79962050e-02f, 1.31931258e-02f, -4.18836735e-02f, -2.63129398e-02f, -3.52572352e-02f, 9.28688496e-02f, -6.39645308e-02f, -3.20431637e-03f,
  -4.17747609e-02f, 3.98231111e-02f, 3.64648029e-02f, -4.69029546e-02f, 1.05460631e-02f, -4.90067527e-03f, -3.52016240e-02f, -6.94165751e-02f, 2.03150734e-02f, -4.32957523e-02f,
  -8.80510639e-03f, -2.67991330e-02f, 1.55076729e-02f, -4.21199091e-02f, 6.05322011e-02f, 9.63938609e-02f, 5.10123484e-02f, 3.14134434e-02f, 1.01124451e-01f, 5.02074175e-02f,
  -3.21362987e-02f, -6.63954020e-02f, 5.83871529e-02f, -5.07752560e-02f, -6.49343953e-02f, -5.50098754e-02f, -4.64828722e-02f, 3.56596592e-03f, -4.95532639e-02f, 4.53783572e-02f,
  2.79094912e-02f, -1.01426564e-01f, 2.78093815e-02f, 8.23863894e-02f, 4.02036197e-02f, 7.56980330e-02f, 1.25488698e-01f, 9.67092738e-02f, 9.67165604e-02f, -1.01448379e-01f,
  3.60782295e-02f, -5.35620786e-02f, 1.63302924e-02f, -4.43436168e-02f, -8.70456845e-02f, -3.06431595e-02f, 1.24613671e-02f, -3.41482833e-02f, -2.59773713e-02f, 2.11588498e-02f,
  6.03692010e-02f, 3.75226103e-02f, -5.18370755e-02f, -3.15374807e-02f, 2.85294186e-03f, -4.77038771e-02f, -6.41546994e-02f, -1.51582882e-02f, -1.92145094e-01f, -6.37707189e-02f,
  7.18349755e-01f, -1.10471018e-01f, 3.03325027e-01f, 8.17785189e-02f, -2.09901273e-01f, -3.14325750e-01f, -2.92451471e-01f, -1.82815135e-01f, -1.09571673e-03f, -3.75127606e-02f,
  -1.36670232e-01f, 1.36954105e-02f, 1.42189682e-01f, -4.34696265e-02f, -4.30413196e-03f, -1.25331357e-01f, -7.36083910e-02f, 2.11038232e-01f, 2.06951108e-02f, -2.25919306e-01f,
  -1.39910504e-01f, 6.35527149e-02f, 1.31910950e-01f, 3.34500559e-02f, 1.05093298e-02f, 7.81505555e-02f, -4.23384123e-02f, 3.05288453e-02f, -1.57384470e-01f, 1.58943936e-01f,
  2.28377491e-01f, 4.28768396e-02f, -1.24850333e-01f, -9.89110619e-02f, -2.02086358e-03f, 1.47718549e-01f, -2.10748278e-02f, 9.01459008e-02f, 1.27720339e-02f, -3.37848179e-02f,
  -4.05157544e-02f, -2.55865194e-02f, 2.72446759e-02f, 4.44145426e-02f, 1.66224148e-02f, -5.23921065e-02f, 9.41189751e-02f, 1.40138760e-01f, 4.63976376e-02f, 2.34811772e-02f,
  -1.10404827e-01f, -1.00042000e-01f, -4.21887338e-02f, -1.73851207e-01f, -5.95295653e-02f, -7.76822791e-02f, -5.63987158e-02f, 9.01259407e-02f, 3.24229971e-02f, 1.33159474e-01f,
  -7.26049915e-02f, 6.99869692e-02f, 1.06642172e-02f, -4.24850872e-03f, 3.01387720e-03f, 6.18339516e-02f, 3.38823274e-02f, -5.87735549e-02f, 1.51491491e-03f, 3.31590548e-02f,
  1.13974437e-02f, 4.40997109e-02f, -5.62826451e-03f, -1.07315443e-02f, -9.71005410e-02f, 5.05157895e-02f, 3.50408666e-02f, -1.67617258e-02f, -1.81853455e-02f, 1.02188075e-02f,
  2.54705306e-02f, 3.33364494e-02f, 6.26450107e-02f, -4.17366177e-02f, -2.70228982e-02f, -2.67945556e-03f, 3.74206677e-02f, 1.99540425e-03f, 2.03378424e-02f, -2.35554948e-02f,
  -1.29589345e-02f, -1.60935029e-01f, 6.76696077e-02f, -5.09257577e-02f, 5.64915538e-02f, -3.00111971e-03f, 1.39010148e-02f, 3.36895213e-02f, 7.08439723e-02f, -6.49014488e-02f,
  -3.36039737e-02f, 1.81592256e-02f, 4.97848243e-02f, -2.34087855e-02f, 2.61039380e-03f, -4.80412170e-02f, -1.24381743e-01f, 1.10393148e-02f, -1.20351642e-01f, -5.75821921e-02f,
  -1.10649519e-01f, -1.24590605e-01f, 4.40593436e-02f, 2.32702550e-02f, -7.81273618e-02f, 9.89541709e-02f, 4.49348465e-02f, 5.20083830e-02f, 1.65136680e-02f, -1.89399067e-02f,
  -1.17324255e-01f, -2.38413393e-01f, 1.32331580e-01f, -1.38541624e-01f, -8.17446485e-02f, -2.38008909e-02f, 4.30418551e-02f, -1.51483014e-01f, -1.54374748e-01f, -1.81963563e-01f,
  -3.43447685e-01f, -3.79132062e-01f, -2.77426928e-01f, -6.18535765e-02f, -4.37849723e-02f, 1.24266915e-01f, 8.05275142e-02f, 2.20675655e-02f, 1.06763467e-02f, -3.84871736e-02f,
  -1.12768762e-01f, 1.10700279e-02f, -5.86297773e-02f, -5.06965108e-02f, -1.22645684e-02f, -4.08038199e-02f, -4.43461277e-02f, -8.70030671e-02f, -1.36182263e-01f, 9.14848298e-02f,
  -8.06703418e-02f, -2.23334819e-01f, -9.84838828e-02f, -1.67121932e-01f, -3.08451235e-01f, -1.73744261e-01f, -1.59809694e-01f, -1.60039797e-01f, -2.44851425e-01f, -9.95816439e-02f,
  -2.38582671e-01f, -2.36926705e-01f, -1.11114509e-01f, -1.04868904e-01f, -8.11470449e-02f, -1.11952975e-01f, -1.06261089e-01f, -7.21114650e-02f, -5.15295640e-02f, -2.32800394e-01f,
  -1.89884752e-01f, -1.11672796e-01f, -2.02599794e-01f, -1.26857951e-01f, -1.26052320e-01f, -1.40246928e-01f, -1.98517308e-01f, -1.46386400e-01f, -1.96383476e-01f, -5.85209876e-02f,
  -5.28916270e-02f, 2.24634614e-02f, 8.94643888e-02f, 1.41616940e-01f, 2.92645046e-03f, 4.36105654e-02f, 1.41110763e-01f, 4.29510064e-02f, 1.65986001e-01f, 1.62873089e-01f,
  9.33251157e-02f, 1.45599321e-01f, 5.17366715e-02f, 1.85628548e-01f, 1.78109244e-01f, 1.06404662e-01f, 2.34086961e-01f, 1.74153745e-01f, 8.89305249e-02f, 1.07162282e-01f,
  3.93334106e-02f, 1.75032541e-01f, 9.88635272e-02f, 1.86344117e-01f, 1.61996529e-01f, 4.16397080e-02f, 2.11303368e-01f, 1.32334977e-01f, 4.25582789e-02f, 1.60702735e-01f,
  -1.70054972e-01f, -2.00340077e-01f, -6.41859621e-02f, -1.21297263e-01f, -1.50105774e-01f, -6.58099204e-02f, -1.56056821e-01f, -1.06125057e-01f, -9.89134535e-02f, -1.05840705e-01f,
  -1.10559590e-01f, -1.41475230e-01f, -1.24281541e-01f, -3.30016129e-02f, -4.66794707e-02f, -1.54190451e-01f, -1.05355181e-01f, -1.37346804e-01f, -1.32377446e-01f, -1.64446369e-01f,
  -1.29266366e-01f, -1.47228360e-01f, -1.02869503e-01f, -9.68334898e-02f, -6.38850406e-02f, -1.70806780e-01f, -1.22624956e-01f, -6.21867515e-02f, -1.11380495e-01f, -7.67808557e-02f,
  -4.29127097e-01f, -1.77862152e-01f, 1.51314959e-01f, -8.64954218e-02f, -9.41657424e-02f, -1.84516340e-01f, -4.06591445e-01f, -3.41947287e-01f, -1.37858719e-01f, -5.57897575e-02f,
  -6.81570470e-02f, 1.11883283e-01f, 3.60050914e-03f, 7.95115829e-02f, -7.40626529e-02f, -2.07984671e-01f, -6.48552701e-02f, 8.82487521e-02f, -5.21853454e-02f, -1.20054603e-01f,
  -8.80349055e-02f, -3.36172432e-02f, -5.64548075e-02f, -7.67678544e-02f, 2.99213566e-02f, 5.75481988e-02f, 8.82985294e-02f, 1.41045395e-02f, 9.06103179e-02f, 2.15805918e-01f,
  2.80110627e-01f, -1.62271068e-01f, -4.09921706e-02f, 6.68920949e-02f, 2.62686536e-02f, -6.10473342e-02f, -1.20114982e-01f, -8.28648359e-02f, -2.48297653e-03f, 4.31566946e-02f,
  -2.99437530e-03f, -2.52761170e-02f, -1.13773048e-01f, -2.57363375e-02f, -1.25805065e-01f, -2.14678980e-02f, -3.12724300e-02f, -4.51300256e-02f, -7.51095414e-02f, -3.16288136e-02f,
  -1.14482336e-01f, -5.72912917e-02f, -1.25698656e-01f, -1.44811161e-02f, -6.22453168e-02f, -2.17355415e-02f, 3.33730616e-02f, 1.67509951e-02f, -4.79364023e-02f, -1.20097540e-01f,
  1.48927733e-01f, -8.71639252e-02f, -5.34825623e-02f, -3.99126858e-02f, -1.26266256e-01f, 2.66278572e-02f, -1.48724439e-02f, 7.87940025e-02f, 2.37734560e-02f, 9.44887027e-02f,
  -2.78509501e-02f, 5.79921156e-02f, -4.74440455e-02f, 2.58743018e-02f, 8.25943649e-02f, -1.69843249e-02f, -4.30303626e-02f, 2.72973515e-02f, 4.58332635e-02f, 2.88798995e-02f,
  4.06411253e-02f, -9.69553888e-02f, 7.90469069e-03f, -3.80979776e-02f, 7.04857931e-02f, -1.60779525e-02f, 4.47965674e-02f, 5.91893084e-02f, -1.41530484e-02f, 7.18241781e-02f,
  -4.29478707e-03f, 1.56535953e-02f, -1.43213440e-02f, -5.86161166e-02f, -2.37565301e-02f, 2.15331931e-02f, 9.48126428e-03f, 2.99755223e-02f, -2.04549544e-02f, -6.83116317e-02f,
  -8.84032026e-02f, -8.81776512e-02f, -2.62691323e-02f, -2.53362283e-02f, -2.18641888e-02f, 1.93787348e-02f, -9.93570760e-02f, -1.28676057e-01f, -1.01871230e-01f, -2.03697500e-03f,
  -1.04477599e-01f, -5.20768501e-02f, -4.56855372e-02f, -1.71331257e-01f, -1.16861733e-02f, -9.53257978e-02f, -1.00256629e-01f, -3.02885612e-03f, -2.02562287e-01f, -1.61548182e-01f,
  3.35004300e-01f, 1.29281238e-01f, 6.32024035e-02f, 1.48270309e-01f, 6.35267422e-02f, -1.18128732e-01f, -2.37983204e-02f, -1.30314246e-01f, -1.90380827e-01f, 1.06992498e-02f,
  -1.75118577e-02f, -1.93324670e-01f, -1.84096724e-01f, -1.29616961e-01f, -1.71163052e-01f, 4.73055691e-02f, 4.62288707e-02f, 6.91934675e-02f, -9.61854309e-02f, -5.44966534e-02f,
  -1.41515300e-01f, 3.39039154e-02f, -8.78870562e-02f, -1.83990166e-01f, 8.73913541e-02f, -1.76105544e-01f, 3.89510044e-03f, 1.03459612e-01f, 4.22325470e-02f, 2.33435169e-01f,
  9.22685415e-02f, 2.12633133e-01f, -1.22691415e-01f, -9.54142362e-02f, 3.85364108e-02f, -1.18350312e-01f, -3.37069817e-02f, -1.02826521e-01f, -8.05895030e-02f, -1.95409264e-02f,
  -2.18444541e-02f, 5.34520112e-03f, -5.17484583e-02f, -9.09080878e-02f, -4.38840874e-02f, -1.59608185e-01f, -4.84212153e-02f, 1.05917931e-01f, 5.64446263e-02f, -1.16824284e-01f,
  1.40642887e-02f, 4.30352129e-02f, 6.65507093e-02f, 9.93549079e-03f, 5.09694070e-02f, 6.76838383e-02f, -3.79707292e-02f, -1.69169542e-03f, -9.55041200e-02f, 7.49055967e-02f,
  -5.49262837e-02f, -5.22659160e-02f, -5.97028770e-02f, -8.81442428e-03f, 1.16038792e-01f, -4.98305596e-02f, 3.38569358e-02f, 1.03606246e-01f, 1.15604419e-02f, 4.75357138e-02f,
  3.75951007e-02f, 3.70119326e-02f, 9.64648649e-02f, 3.45529802e-02f, -2.23672614e-02f, 1.48448125e-01f, 3.77222360e-03f, -4.87451665e-02f, 8.91472623e-02f, -3.54471020e-02f,
  8.14306512e-02f, 1.83850005e-02f, 4.43763062e-02f, 1.53703918e-03f, 1.16526753e-01f, 1.09528378e-01f, 9.61376429e-02f, 1.30232451e-02f, 9.15532112e-02f, 8.63872319e-02f,
  -2.25610256e-01f, -3.71593945e-02f, 2.87818015e-02f, 3.85558121e-02f, -3.86794843e-02f, -6.23816662e-02f, -2.52213217e-02f, -1.35394633e-01f, 4.33251038e-02f, -4.88661267e-02f,
  1.24005117e-01f, -5.40173799e-02f, -6.43412769e-02f, -4.35765088e-02f, -2.23497078e-02f, -6.57358542e-02f, -8.54514167e-02f, -5.56964502e-02f, -4.68803272e-02f, 6.30481821e-03f,
  -8.02135095e-02f, -1.22838013e-01f, -9.22350958e-02f, -6.96459487e-02f, -9.31494385e-02f, -6.95703253e-02f, 1.19630182e-02f, -8.34510177e-02f, -1.17152415e-01f, -2.01880276e-01f,
  3.60613674e-01f, -7.39417896e-02f, 2.35323742e-01f, 1.54005334e-01f, -9.60690081e-02f, -9.99597739e-03f, -9.74841639e-02f, -1.20737940e-01f, 5.52202128e-02f, 6.68465570e-02f,
  -3.28399613e-02f, -2.19698641e-02f, 2.52466667e-02f, -7.13486969e-02f, -1.09487399e-01f, -1.64924413e-02f, -3.92751768e-02f, 5.72879389e-02f, -1.14217900e-01f, -1.91683084e-01f,
  -1.60219386e-01f, -1.41437808e-02f, 1.28305495e-01f, -1.74332280e-02f, 2.40243897e-02f, -3.06841321e-02f, 2.37811282e-02f, 4.74911183e-02f, -5.11320271e-02f, 3.42878670e-01f,
  2.85022199e-01f, 3.12325746e-01f, -1.02402695e-01f, 4.65888120e-02f, 7.49036148e-02f, 7.09789917e-02f, 1.38389707e-01f, 5.41766323e-02f, -1.06118592e-02f, 8.11407864e-02f,
  5.19666635e-02f, -1.50461057e-02f, 9.64720100e-02f, 8.41339156e-02f, 6.94915503e-02f, 1.43843338e-01f, -9.63428430e-03f, 5.24112023e-02f, 1.11067668e-01f, 3.71704325e-02f,
  -5.79320490e-02f, 9.38315392e-02f, 9.08004567e-02f, 7.70164728e-02f, 1.20608293e-01f, 2.82133967e-02f, 1.81066349e-01f, 5.30202202e-02f, 1.88666433e-01f, 1.62022367e-01f,
  2.38402057e-02f, 7.26466179e-02f, 1.31651521e-01f, 1.66959018e-02f, 2.63031963e-02f, -8.44153389e-03f, 1.88951567e-02f, 6.17530160e-02f, -4.78910729e-02f, 6.35323599e-02f,
  7.28528127e-02f, -2.03692410e-02f, 2.19684970e-02f, 8.57568812e-03f, -1.44803151e-02f, 3.63782905e-02f, 4.34517078e-02f, 8.05821456e-03f, 1.25143245e-01f, 9.90449917e-03f,
  9.21542477e-03f, 4.82145324e-02f, 1.22104295e-01f, 8.07990059e-02f, -2.40582377e-02f, 9.29109454e-02f, 3.70080471e-02f, -3.83037850e-02f, -3.36066517e-03f, 3.47073786e-02f,
  1.41365647e-01f, -1.23825103e-01f, 6.02998026e-02f, 6.18095361e-02f, 1.11570001e-01f, 6.00574836e-02f, 2.04160959e-02f, 1.09325990e-01f, 4.01827646e-03f, 5.65145211e-03f,
  8.02124012e-03f, 1.56208321e-01f, 1.08786359e-01f, 6.64558560e-02f, 1.10651739e-02f, 7.44066164e-02f, 5.64988144e-02f, 7.89802223e-02f, -2.83199884e-02f, 2.57417280e-02f,
  -5.70877269e-02f, -4.64391112e-02f, 3.69413681e-02f, -2.83053834e-02f, 9.01245698e-02f, 1.22362010e-01f, 9.12010763e-03f, -2.86490060e-02f, 6.81557358e-05f, -3.33865844e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.95079847e-02f, 2.90598780e-01f, 2.51339711e-02f, 1.95872068e-01f, -2.21964847e-02f, -2.39084557e-01f, 1.26728743e-01f, 4.07493524e-02f, -8.42119753e-02f, 2.24091113e-01f,
  2.67665327e-01f, -2.59525508e-01f, -1.43595442e-01f, -2.83919871e-01f, -1.63705885e-01f, 1.65275782e-01f, 2.13478170e-02f, -3.43135417e-01f, -7.54237175e-01f, -3.03189367e-01f,
  -1.60489544e-01f, 1.05279781e-01f, -8.52945149e-02f, -1.64748311e-01f, 1.99511185e-01f, -1.64530188e-01f, 2.28971273e-01f, 3.73677649e-02f, -5.24939448e-02f, 6.07964620e-02f,
  2.54796773e-01f, -5.04652634e-02f, -2.18274787e-01f, -1.44931436e-01f, 1.32372707e-01f, -1.27913579e-01f, -1.37297302e-01f, 2.96483599e-02f, 5.72794713e-02f, -5.25112916e-03f,
  -1.21586218e-01f, -1.66068733e-01f, -1.72825158e-01f, -1.95553571e-01f, -5.37044518e-02f, -1.35016948e-01f, -7.13960752e-02f, -5.97936250e-02f, -1.86898336e-01f, -4.67437692e-03f,
  -1.39954016e-01f, -2.38361940e-01f, -1.26186311e-01f, 1.41148642e-01f, -9.00440142e-02f, -1.32807627e-01f, 1.22019708e-01f, -1.85434788e-01f, -1.84438154e-01f, 4.65255737e-01f,
  7.31434301e-02f, -1.14820735e-03f, 1.32846283e-02f, 1.09413326e-01f, 1.44489584e-02f, -1.34388767e-02f, -5.12515903e-02f, -6.86180890e-02f, 1.82906054e-02f, 4.37332839e-02f,
  3.72572951e-02f, 9.70085710e-02f, 5.44409920e-03f, 1.21937118e-01f, -9.66519117e-03f, -1.56030832e-02f, -9.03497711e-02f, 5.29366583e-02f, -2.39985827e-02f, -4.64667566e-02f,
  -8.35788995e-02f, -5.39459661e-02f, 1.01983674e-01f, -6.40353337e-02f, -9.52792317e-02f, -7.96108916e-02f, 6.95382245e-03f, -9.23473835e-02f, 5.77678531e-02f, -6.23007864e-02f,
  2.52566874e-01f, -3.12189132e-01f, 2.14553490e-01f, -2.03450192e-02f, 1.24213044e-02f, -7.20039308e-02f, 4.46411334e-02f, 6.33431748e-02f, 3.18474211e-02f, 1.30867824e-01f,
  -1.53616995e-01f, 3.54695655e-02f, 1.06677555e-01f, 1.74868092e-01f, -9.44808405e-03f, -1.30812330e-02f, 1.61008090e-01f, 1.06908763e-02f, -1.17989555e-01f, -1.13236485e-03f,
  1.67052612e-01f, 5.38823567e-03f, 6.79171160e-02f, 8.17761123e-02f, 7.75026605e-02f, -9.65418573e-03f, 1.63083494e-01f, 1.36574346e-03f, -1.49293825e-01f, 4.91778791e-01f,
  -1.52609125e-01f, -3.59437734e-01f, -2.97661155e-01f, -2.27829412e-01f, -4.13371235e-01f, -2.16823965e-01f, -1.02096051e-01f, -1.54242322e-01f, -2.11744398e-01f, -3.29456329e-01f,
  -9.14271697e-02f, 3.17077190e-01f, 1.12492919e-01f, 1.58520699e-01f, 3.85294378e-01f, -1.41527295e-01f, -3.18441540e-01f, 6.91311732e-02f, 4.39513087e-01f, 1.28617972e-01f,
  -8.77509341e-02f, 1.11296386e-01f, 7.16356235e-03f, -5.79913370e-02f, -2.44632363e-01f, 1.69573650e-01f, -2.34417155e-01f, -2.05730438e-01f, -1.84748024e-01f, -5.05833268e-01f,
  3.87519598e-01f, -3.12042177e-01f, -6.92297742e-02f, -4.78245504e-02f, 8.54607020e-03f, -1.50619999e-01f, 3.34360525e-02f, -1.16776243e-01f, 6.38659149e-02f, -7.28597417e-02f,
  -2.06509113e-01f, -7.40786716e-02f, 1.70855582e-01f, -5.44509292e-03f, 7.00758994e-02f, 6.17190637e-02f, -5.87738007e-02f, -2.77767759e-02f, -4.98070307e-02f, 1.35900755e-03f,
  -4.15400509e-03f, -1.20112211e-01f, 5.39876856e-02f, -4.11218032e-02f, -1.03974670e-01f, -2.67052054e-02f, -1.16673402e-01f, -2.50604879e-02f, -3.52505893e-02f, -9.01646614e-02f,
  6.85793608e-02f, 5.15932105e-02f, 1.63750667e-02f, 8.31620321e-02f, 5.47928736e-02f, 1.42542988e-01f, 1.50965303e-01f, -4.23062593e-03f, 1.03555299e-01f, 5.06123267e-02f,
  -2.02619955e-02f, -1.25877157e-01f, 4.81473655e-03f, 2.86946204e-02f, -3.67244743e-02f, -1.05569474e-01f, -6.37967885e-02f, 6.54156953e-02f, -1.43488720e-01f, -2.06967234e-03f,
  -1.76345429e-03f, -7.60776550e-02f, -1.62186965e-01f, 5.10460064e-02f, -1.71141386e-01f, -1.23064592e-02f, -1.37729958e-01f, 4.39488841e-03f, 6.49347203e-03f, -8.15183297e-02f,
  4.10482198e-01f, -1.94997564e-01f, 1.61333010e-01f, 4.85781021e-02f, -4.27234508e-02f, -1.19043238e-01f, -1.88878864e-01f, -9.97508019e-02f, -1.11631013e-01f, -2.12370586e-02f,
  -1.62961364e-01f, 2.62074973e-02f, 7.93308467e-02f, -4.60633337e-02f, 1.38283834e-01f, -5.75374588e-02f, -1.28973559e-01f, 6.58654049e-02f, -1.55197289e-02f, -5.95685504e-02f,
  -1.19594269e-01f, -1.95836537e-02f, 2.90087163e-01f, 3.15490179e-02f, 8.58830735e-02f, 2.62515217e-01f, 1.47575706e-01f, 1.65274128e-01f, 2.02543646e-01f, 2.01029852e-01f,
  7.77807534e-01f, -6.60305619e-02f, -7.85142183e-01f, 3.89526099e-01f, -3.30608726e-01f, -3.82744491e-01f, -4.73323822e-01f, -2.12575053e-03f, 4.46855426e-01f, -1.42622963e-01f,
  -2.23688334e-01f, 6.43047318e-02f, 9.29679200e-02f, -1.63155228e-01f, -1.11494370e-01f, -2.74054915e-01f, -2.90127039e-01f, -1.93330020e-01f, -2.58657634e-01f, -2.76492387e-01f,
  -1.25879385e-02f, 2.51594573e-01f, 3.38979423e-01f, 3.80882472e-02f, 8.48164335e-02f, -2.59555709e-02f, -1.58821985e-01f, 8.09545815e-02f, -2.59679496e-01f, -9.67609137e-02f,
  -3.68897766e-01f, 3.41443419e-02f, -2.00554863e-01f, 1.24574423e-01f, -6.77630007e-02f, 1.81535929e-01f, -7.85360336e-02f, -2.77173761e-02f, 3.82052921e-02f, -5.75708412e-02f,
  -1.06208716e-02f, -1.23637035e-01f, -3.74028683e-02f, -1.60487384e-01f, -7.21221877e-05f, -3.06906495e-02f, 5.10536507e-02f, -6.44390136e-02f, 1.20087378e-02f, 3.42429727e-02f,
  -3.63912657e-02f, -1.59148201e-01f, -1.67830318e-01f, -2.00903639e-01f, -1.42853677e-01f, -2.33758837e-02f, -2.21670106e-01f, -1.58853218e-01f, -2.31728762e-01f, 1.91299766e-01f,
  -1.84096247e-02f, 8.80898684e-02f, -8.41192808e-03f, 8.33697617e-03f, 5.92272766e-02f, -2.95991376e-02f, -8.18756316e-03f, 2.96560191e-02f, -8.07729438e-02f, 5.68992458e-02f,
  -4.82380986e-02f, -1.96594261e-02f, -3.37605998e-02f, -1.51136648e-02f, -4.02340442e-02f, 2.58888528e-02f, 5.57906227e-03f, 4.89897169e-02f, 1.00002196e-02f, 7.49280900e-02f,
  6.94572181e-02f, -2.81047653e-02f, 1.19835936e-01f, -3.14731034e-03f, -8.32652897e-02f, 9.40626860e-02f, -5.37720546e-02f, 3.55673581e-02f, 1.02827000e-02f, 5.12751425e-03f,
  5.10545850e-01f, -2.75611073e-01f, 1.45485714e-01f, -3.39924102e-03f, 1.13495030e-02f, 3.41431331e-03f, 6.26597777e-02f, -2.20299717e-02f, 9.74950492e-02f, 1.01118147e-01f,
  -3.68503369e-02f, 7.24860886e-03f, -6.91345427e-03f, -1.00019261e-01f, -4.66262251e-02f, 1.54308248e-02f, 2.24436875e-02f, 6.32885918e-02f, -8.43430683e-03f, 2.15255395e-01f,
  8.64556506e-02f, -4.19397205e-02f, 1.28670365e-01f, 3.06715444e-02f, 1.36661947e-01f, 1.65715486e-01f, -2.49003675e-02f, 4.22563441e-02f, -5.78856654e-03f, 2.14277193e-01f,
  -6.89869463e-01f, -1.89685270e-01f, -1.06002137e-01f, -2.13555798e-01f, -8.58573839e-02f, 3.96518335e-02f, -7.32941329e-02f, -3.75508033e-02f, -8.87675360e-02f, -2.47282863e-01f,
  -1.44440025e-01f, -2.06738159e-01f, -2.40301788e-01f, -1.53107643e-01f, -3.82358581e-01f, -4.37499970e-01f, -3.68853927e-01f, -3.55935544e-01f, -1.90553740e-01f, 1.76457483e-02f,
  -9.23480019e-02f, -2.91658938e-01f, -2.41394743e-01f, -4.57632244e-02f, 9.55212340e-02f, 1.26423374e-01f, 2.28255428e-02f, 5.93315403e-04f, 1.12047464e-01f, -1.12481162e-01f,
  3.21718492e-02f, 8.52339715e-02f, 1.62810355e-01f, -8.12055320e-02f, 3.09767900e-03f, -6.47355914e-02f, -9.49768871e-02f, -2.81171054e-02f, -4.40250970e-02f, -3.30354273e-02f,
  -5.47442697e-02f, 3.48882116e-02f, -9.74187106e-02f, 1.75936013e-01f, 1.23490449e-02f, 5.43716922e-02f, 1.08433157e-01f, 2.33050957e-02f, 4.16924097e-02f, 9.90010202e-02f,
  -7.10961074e-02f, 8.89977589e-02f, -7.58123538e-03f, 1.66687608e-01f, 1.82984233e-01f, 1.30719408e-01f, 1.75735295e-01f, 1.90304860e-01f, 2.95179188e-01f, 2.46154279e-01f,
  -1.55888543e-01f, -7.00778514e-02f, 8.32540393e-02f, 8.12738314e-02f, 3.00412555e-03f, -2.83893831e-02f, 1.74786523e-02f, -8.96259248e-02f, 7.21817613e-02f, 6.43385854e-03f,
  3.65556292e-02f, -1.04645133e-01f, -1.00555278e-01f, 5.34767509e-02f, 8.27723444e-02f, 9.56574804e-04f, -7.09617212e-02f, 2.81860977e-02f, 1.29100233e-01f, -2.61556800e-03f,
  8.58591273e-02f, 1.14221379e-01f, -1.24735944e-01f, -2.04388760e-02f, 7.01009780e-02f, 2.56273150e-02f, -4.77335304e-02f, -1.21241614e-01f, -1.23297893e-01f, 1.33669889e-02f,
  4.07332405e-02f, -5.94436228e-02f, -2.76683234e-02f, -3.74671724e-03f, -7.18154758e-03f, 4.90464941e-02f, 3.01842578e-02f, -7.23294094e-02f, -4.40501310e-02f, 1.71791792e-01f,
  3.45847830e-02f, -3.76575179e-02f, -7.45775998e-02f, 1.90226272e-01f, 1.62709475e-01f, 8.98583531e-02f, 1.30639121e-01f, 5.44338487e-02f, -4.73343581e-02f, 1.55631661e-01f,
  -1.19378501e-05f, -7.79124051e-02f, -1.25581920e-01f, 1.50993243e-01f, 7.60330334e-02f, -6.06975518e-02f, -1.48553168e-02f, 1.68496087e-01f, -4.33453657e-02f, -5.31846955e-02f,
  -4.34266567e-01f, -2.84624994e-01f, 1.70773063e-02f, -2.91127652e-01f, 3.66400555e-02f, 3.63367647e-02f, -2.74573267e-01f, 1.01594208e-02f, -4.02199514e-02f, -4.17913496e-01f,
  -1.54284224e-01f, 9.37793702e-02f, -1.28666788e-01f, -2.39859782e-02f, -1.83123097e-01f, -5.73779404e-01f, -3.18236887e-01f, 7.08152354e-02f, 4.38800246e-01f, 2.89321125e-01f,
  1.16670048e-02f, 4.95900633e-03f, 1.23354279e-01f, 1.96838766e-01f, -3.15575808e-01f, 2.98280325e-02f, -1.73626825e-01f, -3.60504128e-02f, -1.85536861e-01f, -4.45995361e-01f,
  -4.01141167e-01f, 2.97528435e-03f, 1.99078202e-01f, -3.72412987e-02f, -5.65956272e-02f, 2.89780293e-02f, -4.45915572e-03f, -9.53888223e-02f, 1.50914386e-01f, -7.37525150e-02f,
  -1.00737615e-02f, 9.07183290e-02f, -4.13816869e-02f, 1.74662888e-01f, 5.25607616e-02f, -4.93468419e-02f, 3.24768461e-02f, 4.48299982e-02f, 1.21802405e-01f, -1.53874055e-01f,
  -1.26733109e-01f, -1.28856897e-01f, -4.87778485e-02f, -9.65954550e-03f, -1.15968868e-01f, 1.16295494e-01f, 2.26392169e-02f, 1.80709273e-01f, 1.05866030e-01f, -4.04833823e-01f,
  -1.17688924e-01f, -2.82629766e-03f, 3.95832993e-02f, 1.01467513e-01f, 2.61070561e-02f, -7.56034479e-02f, -8.77223015e-02f, -1.76708233e-02f, 8.37630332e-02f, -6.13004565e-02f,
  -2.50294525e-02f, 1.49948999e-01f, 2.04658151e-01f, -1.45132527e-01f, -5.01273014e-02f, 4.15015221e-02f, -1.54240146e-01f, -1.69716440e-02f, -9.95802730e-02f, 3.72866518e-03f,
  8.77896175e-02f, 4.37694369e-03f, -6.41519502e-02f, 4.92265150e-02f, -1.25584200e-01f, -6.25771806e-02f, 2.25020684e-02f, -1.17371501e-02f, 4.31497768e-02f, 2.60200631e-02f,
  -5.84045947e-02f, 2.25938365e-01f, -2.42508054e-01f, 3.20812017e-02f, -1.12095937e-01f, -7.65650049e-02f, -1.02076098e-01f, 6.98783323e-02f, 5.23344390e-02f, -9.27920640e-03f,
  -2.84540374e-02f, -7.23647550e-02f, -1.17482476e-01f, 6.05799668e-02f, 2.65215077e-02f, -1.47851020e-01f, -1.75300777e-01f, -3.56170349e-02f, 2.26209641e-01f, -2.69329920e-02f,
  -3.02133113e-01f, -1.36848211e-01f, -1.16053917e-01f, -8.13069269e-02f, -1.06422022e-01f, 1.98378712e-02f, -1.58905193e-01f, 2.25894451e-02f, -1.14360087e-01f, -3.68914217e-01f,
  6.53922379e-01f, 2.18479976e-01f, 1.99691236e-01f, 4.57067974e-02f, -1.08833738e-01f, 9.83082354e-02f, 1.50993004e-01f, 1.51513070e-01f, 3.60576548e-02f, 7.69838467e-02f,
  3.30603570e-01f, 3.07589233e-01f, 1.70234397e-01f, 1.25259936e-01f, 8.81246552e-02f, -6.60319114e-03f, -2.57046878e-01f, 3.21443267e-02f, 9.84770507e-02f, 1.47135854e-01f,
  -3.25089917e-02f, -1.58592537e-01f, -6.25339374e-02f, -3.13011110e-02f, -1.50255308e-01f, -3.47709544e-02f, -8.53869170e-02f, -1.99210912e-01f, -1.05025873e-01f, -1.50400907e-01f,
  5.16276479e-01f, 2.79775351e-01f, 1.68514535e-01f, 1.10017225e-01f, 7.50653744e-02f, 4.81981225e-03f, 2.31534466e-01f, 1.47322367e-03f, 1.03843942e-01f, -6.35168925e-02f,
  5.53063005e-02f, 2.95840669e-02f, -1.04848169e-01f, -5.55209303e-03f, -1.13980107e-01f, -6.62434325e-02f, 1.02090314e-02f, 1.04382470e-01f, 1.95251569e-01f, 1.00436816e-02f,
  -1.03299946e-01f, -4.08905186e-02f, 9.29766074e-02f, 1.52134240e-01f, 4.30085277e-03f, 8.69655535e-02f, 5.74274026e-02f, 2.36633383e-02f, 3.08123473e-02f, 4.73085493e-02f,
  5.94489835e-02f, 7.81182647e-02f, 1.64723292e-01f, 8.98097754e-02f, 9.53968167e-02f, 7.52581507e-02f, 1.60641037e-02f, -6.64248168e-02f, -3.75458971e-02f, -1.09021835e-01f,
  -5.08989319e-02f, 1.45117581e-01f, 1.97389036e-01f, 1.94330141e-02f, 7.11104870e-02f, -7.16735572e-02f, 1.05312355e-02f, 2.53900886e-03f, 1.20161753e-02f, -6.93487525e-02f,
  5.59609495e-02f, 1.66832116e-02f, -1.28682226e-01f, -1.48075655e-01f, -1.15371533e-01f, -4.45879288e-02f, -1.47957161e-01f, -5.20328917e-02f, -9.21952948e-02f, -6.39592260e-02f,
  3.70563537e-01f, 1.79951578e-01f, 1.23176567e-01f, 4.23145629e-02f, -4.45187017e-02f, -1.59198567e-02f, 4.34544161e-02f, -7.71243721e-02f, -1.31435141e-01f, 1.96705238e-04f,
  -6.55729398e-02f, -4.18024436e-02f, -8.92068446e-02f, -3.00833639e-02f, -1.82062313e-01f, -5.95238432e-02f, -1.08223632e-01f, 9.95209888e-02f, -2.60810088e-02f, -1.10719293e-01f,
  -1.30998835e-01f, -3.85881513e-02f, 1.49886772e-01f, 2.21923254e-02f, -6.16829060e-02f, -1.75330937e-02f, -1.31578490e-01f, -3.59825529e-02f, -2.47607250e-02f, -1.12538844e-01f,
  3.32461119e-01f, -5.97155690e-02f, -4.16281447e-02f, 2.12758277e-02f, -9.71971527e-02f, -1.25275046e-01f, -2.89591312e-01f, -9.91088375e-02f, -1.10642891e-02f, 5.01339287e-02f,
  1.11118160e-01f, 1.31752580e-01f, 1.08788855e-01f, 1.10320404e-01f, -4.42854203e-02f, -7.19025880e-02f, -1.29981935e-01f, 5.76553456e-02f, 7.16355303e-03f, -5.69316335e-02f,
  -1.12686418e-01f, -2.09205598e-01f, -9.90843251e-02f, -1.43685624e-01f, 1.33768711e-02f, 1.33995801e-01f, -1.68148696e-01f, -1.65500134e-01f, -1.40564725e-01f, -8.23599696e-02f,
  4.22704011e-01f, 2.10012630e-01f, 1.60219505e-01f, 1.40355304e-01f, 5.20718358e-02f, 4.58827019e-02f, 5.44658452e-02f, -6.45582899e-02f, 6.11624122e-02f, -5.97884357e-02f,
  6.38700426e-02f, -1.60331592e-01f, -9.53496695e-02f, -6.36316314e-02f, -2.33746171e-01f, -1.23534249e-02f, -7.83770531e-02f, -7.69445524e-02f, -1.83739029e-02f, -1.71451550e-02f,
  7.56414086e-02f, -2.11790986e-02f, 7.51188621e-02f, -9.12033245e-02f, 1.68831367e-02f, 4.23510484e-02f, 3.83890048e-02f, 8.90847221e-02f, 6.36220276e-02f, -1.08855795e-02f,
  -1.33486792e-01f, -6.49997666e-02f, -2.35313848e-02f, -7.24089295e-02f, -4.54202332e-02f, -4.02585976e-03f, -7.12644458e-02f, -1.56813711e-01f, -8.32403153e-02f, -1.22283399e-01f,
  -1.07934885e-01f, 6.69064447e-02f, 1.50753319e-01f, -8.05445090e-02f, 2.95837075e-02f, 9.77992937e-02f, -5.42539451e-03f, 1.46115124e-01f, -2.30442081e-02f, -4.53041457e-02f,
  -1.29092604e-01f, 4.57086600e-03f, -1.12001762e-01f, -1.13498010e-01f, -1.45415380e-03f, 8.97063222e-03f, -5.47619537e-03f, 3.31716873e-02f, -1.19934164e-01f, -1.48246467e-01f,
  1.99101195e-01f, 3.58890146e-01f, 2.50757843e-01f, 1.28945142e-01f, -2.07781512e-02f, -4.07089777e-02f, 1.83807880e-01f, 1.54668123e-01f, 1.86249509e-01f, 2.58242786e-01f,
  1.14381894e-01f, 1.03965305e-01f, -8.44997540e-02f, -1.06082305e-01f, -9.56897363e-02f, -3.05754039e-02f, 5.73219918e-02f, 1.06316932e-01f, 9.15828347e-02f, 1.99202910e-01f,
  7.60290958e-03f, 1.35152563e-01f, 7.00049028e-02f, 1.21206000e-01f, 3.56726944e-02f, 1.18036434e-01f, 6.31930679e-02f, 3.25755775e-02f, 2.84326840e-02f, -2.13234261e-01f,
  4.08168256e-01f, -3.36902320e-01f, 1.71088040e-01f, 3.71592432e-01f, 8.50865915e-02f, 1.31776601e-01f, 4.94804420e-03f, 1.39068961e-01f, 1.87159851e-01f, 2.18697309e-01f,
  9.53932181e-02f, 3.70222390e-01f, 2.45171204e-01f, 2.53299862e-01f, 2.57505983e-01f, 5.35446927e-02f, 1.02981843e-01f, 1.73000276e-01f, 3.30148816e-01f, 2.99311429e-01f,
  2.25892216e-01f, -6.83228225e-02f, -7.39745572e-02f, 9.54246297e-02f, 1.29021868e-01f, 2.87293255e-01f, -3.18809934e-02f, -4.62004133e-02f, 3.66266146e-02f, 2.16948375e-01f,
  -2.84617990e-02f, -9.90134627e-02f, 5.25677986e-02f, -6.60821870e-02f, -2.05991283e-01f, -2.56768376e-01f, -1.77696086e-02f, -6.30777925e-02f, -1.58991173e-01f, -7.08877370e-02f,
  -2.28609294e-01f, -1.09244637e-01f, -1.43433869e-01f, -1.49628952e-01f, -9.91742983e-02f, -1.67639822e-01f, -4.99641337e-02f, 1.20406613e-01f, 1.11062177e-01f, 7.92622119e-02f,
  -2.06137542e-02f, 1.17663540e-01f, 9.98092517e-02f, -4.27211216e-03f, -1.35773616e-02f, 1.04658797e-01f, -4.62553129e-02f, 1.91051792e-02f, 8.99722874e-02f, 2.66285446e-02f,
  2.03862920e-01f, 1.66607872e-01f, 2.12027013e-01f, 1.48590997e-01f, 7.57805929e-02f, 5.99878505e-02f, 4.81692329e-02f, 5.58877513e-02f, 2.01866239e-01f, -5.24796061e-02f,
  9.00166575e-03f, 1.43861786e-01f, 1.66280329e-01f, 8.42947364e-02f, 1.56181470e-01f, 9.59788859e-02f, -5.28949238e-02f, 2.83916648e-02f, -1.22278877e-01f, -1.38281301e-01f,
  8.74329417e-04f, -7.59546757e-02f, -8.71919617e-02f, -1.04323506e-01f, -6.57338127e-02f, 1.03747368e-01f, 1.42388105e-01f, 1.78566147e-02f, -7.64973089e-02f, -1.65218189e-01f,
  -1.10636748e-01f, 1.16336793e-01f, 1.99361295e-01f, 1.06180860e-02f, -1.92794949e-01f, -1.37664720e-01f, 1.55364901e-01f, -8.85703266e-02f, -2.12259904e-01f, 6.12668023e-02f,
  -1.01086348e-01f, 8.74591544e-02f, 3.48488390e-02f, -7.74932839e-03f, -6.01252541e-02f, -5.62085174e-02f, -1.15929700e-01f, 4.04097736e-02f, 1.11509509e-01f, -9.11995992e-02f,
  -9.99441929e-03f, 2.40779206e-01f, 1.69234157e-01f, 8.38981196e-02f, 1.67894244e-01f, 1.07615888e-01f, 3.75301540e-02f, -1.29855022e-01f, -1.00367948e-01f, 3.79735157e-02f,
  -6.67238593e-01f, -3.48063894e-02f, 3.98350120e-01f, -1.80272564e-01f, 1.99863896e-01f, 4.30983871e-01f, 5.48437595e-01f, 9.65152681e-02f, -1.51719242e-01f, -1.17367031e-02f,
  -2.34011680e-01f, -1.81566566e-01f, -2.22935557e-01f, 1.45569202e-02f, 7.33681470e-02f, 3.61741006e-01f, 2.20402002e-01f, 1.68946177e-01f, 2.08812818e-01f, 1.66281849e-01f,
  -3.20367888e-03f, 6.53514713e-02f, -2.52993733e-01f, -2.89233476e-02f, -8.53776559e-02f, -1.16548650e-01f, 6.21551974e-03f, 5.17378375e-03f, 9.86721814e-02f, -4.70191203e-02f,
  3.11710209e-01f, -4.06857640e-01f, -1.37494549e-01f, -1.32727683e-01f, -5.05489148e-02f, -5.08439019e-02f, -2.98810508e-02f, 4.29645665e-02f, 2.00150372e-03f, 4.22561914e-02f,
  2.09812485e-02f, -7.13837147e-02f, -9.19226706e-02f, -4.65115272e-02f, 5.91006987e-02f, 8.38406011e-02f, -4.30137068e-02f, 7.46046081e-02f, 4.30524163e-02f, 6.85333759e-02f,
  -1.40085481e-02f, -2.89813560e-02f, 7.96778724e-02f, -1.85201615e-02f, 6.94776475e-02f, -8.24125186e-02f, -1.24896076e-02f, -6.66617677e-02f, -1.03407934e-01f, -1.59677520e-01f,
  1.88447446e-01f, 1.40865013e-01f, -2.14323122e-02f, -1.83023334e-01f, -3.23843025e-02f, 8.24751984e-03f, -3.06771547e-02f, 1.40313044e-01f, 5.60200028e-02f, 3.22027458e-03f,
  -5.72217181e-02f, 1.20586972e-03f, 2.50164210e-03f, -9.55083892e-02f, -1.82268649e-01f, 7.39521310e-02f, 1.57284528e-01f, -4.13085595e-02f, -8.50851089e-02f, -1.34033263e-01f,
  -5.59071265e-02f, 1.44232646e-01f, -1.64264217e-01f, 3.89850512e-02f, -8.29925612e-02f, -9.19110849e-02f, 3.46893370e-02f, -9.57046729e-03f, 1.97899081e-02f, 1.85418949e-02f,
  4.32176381e-01f, -4.37441200e-01f, -7.16892704e-02f, -1.38601335e-02f, 2.81909034e-02f, -1.45815745e-01f, -5.67597076e-02f, -6.12917654e-02f, 1.41705960e-01f, 1.19146131e-01f,
  -3.61890383e-02f, 1.23519795e-02f, 5.86269423e-03f, -1.16406670e-02f, 6.10207580e-02f, -3.06251962e-02f, -1.44183412e-01f, 9.29369852e-02f, 1.90745503e-01f, 2.14233443e-01f,
  1.15976669e-01f, 7.61990398e-02f, 1.77988827e-01f, 1.63571566e-01f, 1.25722408e-01f, 1.37615204e-02f, 1.72358185e-01f, 1.87886670e-01f, 1.49449661e-01f, -6.66354550e-04f,
  -8.80308151e-01f, 1.42404974e-01f, -1.27975792e-01f, -7.33024001e-01f, -2.63822645e-01f, 1.18525036e-01f, 2.36800507e-01f, 1.47848368e-01f, -2.84433126e-01f, -1.18209176e-01f,
  2.60996073e-02f, -1.27994627e-01f, -2.80154228e-01f, 7.73760453e-02f, 1.93242013e-01f, 2.93242931e-02f, -1.93778276e-01f, -2.09272340e-01f, 1.56034648e-01f, 3.76167297e-01f,
  1.70353368e-01f, -2.96060711e-01f, -1.55010894e-01f, -4.09628004e-02f, -1.07485078e-01f, -2.83421546e-01f, -3.37262541e-01f, -2.73370206e-01f, 2.68558394e-02f, -4.50365096e-01f,
  3.25597972e-02f, -1.23367637e-01f, 6.04769289e-02f, -7.96593260e-03f, -1.63009033e-01f, 2.03258935e-02f, -4.03963700e-02f, -5.90202436e-02f, -5.03777489e-02f, -4.64104153e-02f,
  -1.87989056e-01f, -2.45221686e-02f, -1.43564358e-01f, 1.06496653e-02f, -5.14704585e-02f, 7.39933597e-03f, 5.27154515e-03f, 3.61057813e-03f, 3.39102261e-02f, 2.02790514e-01f,
  1.38181165e-01f, -3.67247052e-02f, -7.16752335e-02f, 7.59715438e-02f, 1.05049931e-01f, 1.27764130e-02f, 1.17626660e-01f, 7.95856044e-02f, 1.46225363e-01f, -1.06437385e-01f,
  1.60966307e-01f, 4.07238603e-02f, 6.69180378e-02f, -3.77026834e-02f, 3.00329719e-02f, 2.26390157e-02f, -1.02128789e-01f, 3.16554680e-02f, 2.98693590e-02f, -3.27192433e-02f,
  -2.37231776e-02f, 5.62328175e-02f, 3.11947777e-04f, -3.91158313e-02f, -9.45932642e-02f, 6.59465268e-02f, 4.20703599e-03f, 1.47970645e-02f, 1.31827801e-01f, -7.64659569e-02f,
  -6.10964783e-02f, 2.35975236e-02f, -4.44704033e-02f, 1.13230430e-01f, 3.53076272e-02f, -2.10049916e-02f, -5.09494729e-02f, 1.63194537e-01f, -2.42116693e-02f, 2.17691325e-02f,
  -2.15085432e-01f, -6.61641583e-02f, -1.54721677e-01f, 3.88179012e-02f, -1.03623942e-01f, 1.53637066e-01f, 2.01649647e-02f, 7.24888220e-02f, -3.68831083e-02f, -4.40699933e-03f,
  2.26492658e-01f, 5.52724749e-02f, -4.80120443e-02f, -1.74186639e-02f, -1.77483752e-01f, 4.97330837e-02f, 2.61600893e-02f, -9.56951007e-02f, 3.30560580e-02f, 1.36882082e-01f,
  1.63336024e-01f, -2.13529170e-02f, -7.61864781e-02f, -3.95763246e-03f, 5.70344143e-02f, -9.37605873e-02f, 1.30337641e-01f, 1.41702309e-01f, -4.21461016e-02f, 1.42090172e-02f,
  -1.47072583e-01f, -1.30507365e-01f, 4.86608446e-02f, 5.51722869e-02f, -2.33320251e-01f, -4.33858544e-01f, -5.27026117e-01f, -1.50140882e-01f, -6.57112151e-02f, -1.14578523e-01f,
  -1.65069371e-01f, 2.71365315e-01f, 1.51520923e-01f, 2.54404336e-01f, 1.09415658e-01f, 2.01541469e-01f, 4.91687477e-01f, 3.50555778e-01f, 1.66259483e-01f, 9.55656096e-02f,
  1.44455507e-01f, 1.44594938e-01f, 1.53052643e-01f, 1.26734540e-01f, 1.56980053e-01f, 1.12742394e-01f, -4.97834980e-02f, 2.37434264e-02f, 3.04374490e-02f, 6.81253195e-01f,
  3.11592333e-02f, -1.22211978e-01f, 1.35799900e-01f, 1.12522125e-01f, 2.76429821e-02f, -3.52702923e-02f, -6.13174886e-02f, 3.50758322e-02f, -8.24425220e-02f, -8.57442711e-03f,
  -8.02777708e-03f, 4.71475571e-02f, 4.82726023e-02f, -1.25777470e-02f, -5.48497066e-02f, -8.94957259e-02f, 6.71238452e-02f, 1.55644327e-01f, -4.77799866e-03f, -1.99527249e-01f,
  9.98960957e-02f, -1.12680875e-01f, -1.94210336e-01f, -1.58678174e-01f, -7.00260922e-02f, 7.80712739e-02f, -2.32461616e-02f, -6.31500483e-02f, -2.26385787e-01f, 1.17706344e-01f,
  1.16772063e-01f, -1.04687132e-01f, -5.98499961e-02f, 4.51855175e-02f, 2.35943086e-02f, 5.21506071e-02f, 1.11034401e-01f, 5.42071760e-02f, 2.58027278e-02f, -6.53557293e-03f,
  2.40965132e-02f, 4.24361303e-02f, 1.03360815e-02f, -1.87103212e-01f, -4.60448600e-02f, 2.24997364e-02f, -1.24370912e-02f, -1.10027604e-02f, -7.78912976e-02f, -4.84501161e-02f,
  -1.24137886e-02f, 5.15445732e-02f, -4.01558094e-02f, 1.53536990e-01f, -6.01261109e-02f, 5.16849495e-02f, -1.24862611e-01f, -1.08037248e-01f, -5.94545603e-02f, -1.22383170e-01f,
  -3.98452789e-01f, -2.16999292e-01f, 1.86338842e-01f, 1.18738949e-01f, 3.81542370e-02f, -1.24414727e-01f, -5.53724691e-02f, 2.95819454e-02f, -4.69502546e-02f, 1.97354686e-02f,
  -1.84456930e-01f, -6.84460476e-02f, 1.81671195e-02f, -1.62284803e-02f, -4.77572568e-02f, -5.74867576e-02f, 9.77380648e-02f, 3.21192369e-02f, 4.02330868e-02f, -1.05336681e-01f,
  3.95643935e-02f, -1.59173951e-01f, -2.06161380e-01f, -7.46943131e-02f, -3.32886912e-03f, -3.86167243e-02f, -2.38136604e-01f, -2.37529218e-01f, -3.02568883e-01f, -2.49609113e-01f,
  3.91184092e-01f, -4.56488669e-01f, -5.23588777e-01f, 9.40289423e-02f, -4.65019271e-02f, 1.87299214e-02f, -1.51347190e-01f, 2.48390764e-01f, 2.39762858e-01f, -2.93903708e-01f,
  -5.69364317e-02f, 1.95387289e-01f, -4.67915200e-02f, -7.69951195e-02f, 6.32493198e-02f, -3.12842041e-01f, -3.69104832e-01f, -4.33280729e-02f, 3.61747712e-01f, 3.27459812e-01f,
  1.12873979e-01f, 1.54078394e-01f, 1.28361166e-01f, 1.86436459e-01f, -2.34016120e-01f, -1.09899327e-01f, -4.80559796e-01f, -1.46460235e-01f, -2.88584888e-01f, -5.55478036e-01f,
  -5.23542225e-01f, -1.84968814e-01f, 1.64756820e-01f, 9.56770480e-02f, -1.26036048e-01f, 1.15638867e-01f, 1.16653562e-01f, 1.39818117e-02f, 1.20988764e-01f, -1.28705306e-02f,
  1.17864506e-02f, 1.03154629e-01f, 2.00961977e-01f, 1.01816840e-01f, 3.54316905e-02f, 1.32862270e-01f, 4.09708209e-02f, 7.32677281e-02f, -6.01998195e-02f, -1.20021567e-01f,
  -1.15033396e-01f, -5.30097298e-02f, -1.20537169e-02f, -4.52887826e-02f, -2.07051858e-02f, -1.19609258e-03f, -1.31114140e-01f, -5.72199896e-02f, -7.87551552e-02f, -8.55213106e-02f,
  -4.96472465e-03f, -4.10076156e-02f, -1.46711379e-01f, 4.67267670e-02f, 7.57340640e-02f, 4.84792180e-02f, -1.09798223e-01f, -1.47730333e-03f, 6.77035600e-02f, 5.59738986e-02f,
  6.31534830e-02f, -5.38421050e-02f, 8.87185782e-02f, -3.40671465e-02f, -1.51674241e-01f, -6.02274910e-02f, -2.81482358e-02f, -5.53804934e-02f, -2.40736809e-02f, 6.34703785e-02f,
  1.46545647e-02f, 5.92477657e-02f, -1.26185581e-01f, -1.84414443e-02f, -1.73474386e-01f, 2.76160426e-02f, -1.15219921e-01f, -2.96292622e-02f, 9.77013707e-02f, 7.07883062e-03f,
  7.37291723e-02f, -6.77816048e-02f, 3.63084627e-03f, 8.17739591e-02f, 3.63552128e-03f, -1.12739712e-01f, -2.22390935e-01f, -1.82097219e-02f, 3.04988846e-02f, 6.05478808e-02f,
  -5.74136898e-02f, 3.18613201e-02f, -5.69309518e-02f, 5.57777174e-02f, 2.35083610e-01f, 3.64351948e-03f, 4.09531780e-02f, -8.53961930e-02f, -1.17412336e-01f, -9.14486423e-02f,
  -7.85350651e-02f, 2.72643805e-01f, 1.79704234e-01f, -3.32785808e-02f, 2.11069603e-02f, 8.84277597e-02f, 3.73560153e-02f, -8.59161764e-02f, -2.47786567e-02f, 6.48294985e-02f,
  -4.14259583e-01f, -6.75013885e-02f, -5.84757291e-02f, 1.54926777e-01f, 4.58075225e-01f, 1.01571223e-02f, -3.71569395e-01f, -4.29359823e-01f, 4.99559455e-02f, -1.30415261e-01f,
  1.99259266e-01f, 3.65286589e-01f, 7.60362372e-02f, -1.50601774e-01f, -5.92304945e-01f, -3.17879945e-01f, -2.25555012e-03f, -2.24421710e-01f, -3.00221682e-01f, -4.98352759e-02f,
  1.53012291e-01f, -5.61364666e-02f, -3.30746084e-01f, -2.07313567e-01f, 1.45935789e-01f, 6.12363890e-02f, -1.32830115e-03f, -5.64480871e-02f, -1.28615975e-01f, 2.29652211e-01f,
  2.86613911e-01f, -2.60169543e-02f, 9.60525870e-02f, 6.12245277e-02f, 1.17070831e-01f, -1.21806569e-01f, -1.28431048e-03f, -5.42139634e-03f, 5.79932369e-02f, 8.40096176e-03f,
  1.30704120e-01f, 5.35355806e-02f, 1.74252555e-01f, 7.76249096e-02f, -6.83485046e-02f, -2.74909198e-01f, -1.51638418e-01f, -1.55784994e-01f, -3.10426474e-01f, -9.06777084e-02f,
  3.23200732e-01f, 2.30121255e-01f, -7.96730965e-02f, -1.24192566e-01f, -2.12027624e-01f, 4.88855615e-02f, -1.95443496e-01f, -2.63797522e-01f, -3.31219137e-01f, -2.41699040e-01f,
  6.25893474e-02f, 5.42562157e-02f, 1.32654682e-01f, 3.81894074e-02f, 5.35245948e-02f, 2.30847269e-01f, 9.38621014e-02f, 6.98394626e-02f, 7.42770061e-02f, -1.09930634e-01f,
  4.78536822e-02f, -2.41434090e-02f, -8.99017900e-02f, -1.03006355e-01f, -9.53304321e-02f, -7.72530865e-03f, -4.58838455e-02f, -1.13158986e-01f, -1.03050873e-01f, -4.71593924e-02f,
  -9.64530334e-02f, 4.38449271e-02f, 9.45886001e-02f, -1.57470815e-03f, -6.16739169e-02f, -8.46618712e-02f, 1.62212946e-03f, -1.87721416e-01f, -1.40124664e-01f, -6.70032203e-02f,
  1.29010394e-01f, -7.67040849e-02f, -3.68227973e-03f, -5.59386350e-02f, 3.18973251e-02f, 4.12023105e-02f, -4.57628407e-02f, -6.00212626e-03f, 1.22898016e-02f, -1.02657117e-01f,
  -2.22540516e-02f, 4.15371545e-02f, -3.62074585e-03f, 2.72024609e-02f, -1.48621157e-01f, 2.63884179e-02f, -1.59506813e-01f, 8.64970386e-02f, -1.24908410e-01f, 1.36870027e-01f,
  -1.93788543e-01f, -1.79923967e-01f, -1.87702373e-01f, -1.30679235e-01f, 2.29806546e-03f, -2.03921571e-01f, -2.21662626e-01f, -1.17500968e-01f, -3.47990364e-01f, -4.94526595e-01f,
  -9.48696397e-03f, -7.99889565e-01f, 4.17939603e-01f, 1.58247560e-01f, 3.84639442e-01f, 3.57313007e-01f, 2.61894584e-01f, 2.86409110e-02f, 3.23818177e-02f, -5.31025752e-02f,
  -3.07065964e-01f, -4.62628841e-01f, -4.22330469e-01f, -3.14805150e-01f, -2.10743532e-01f, 3.23337018e-01f, 3.07766736e-01f, 1.92799345e-01f, 1.77040309e-01f, 9.36567411e-02f,
  -2.90384591e-02f, 1.53193856e-02f, -1.30000100e-01f, -1.43451318e-01f, -1.05905659e-01f, -9.00025368e-02f, 6.52806386e-02f, 3.47430855e-02f, -2.78424054e-01f, -5.37891835e-02f,
  2.27264673e-01f, -6.23181388e-02f, 1.27989188e-01f, -2.65797704e-01f, -1.70066878e-01f, -9.28000659e-02f, -1.86262820e-02f, -4.85819429e-02f, -1.51073232e-01f, 3.85001600e-02f,
  -1.65437862e-01f, -1.39983326e-01f, 2.40763631e-02f, -7.11668879e-02f, 4.35354337e-02f, -7.60805085e-02f, -1.17534228e-01f, -1.27806619e-01f, -1.44104153e-01f, 2.11461112e-02f,
  -1.04468256e-01f, 3.99021432e-02f, 9.16491300e-02f, -1.45625025e-01f, -4.20699678e-02f, -5.17096631e-02f, -9.23247784e-02f, -1.35121435e-01f, -1.17912874e-01f, -8.20249617e-02f,
  3.90046053e-02f, -1.95118207e-02f, 3.87671660e-03f, 9.71823484e-02f, 9.11462009e-02f, 1.35479361e-01f, 5.91730438e-02f, -8.62137675e-02f, 1.26414066e-02f, 1.91504285e-02f,
  -5.56522608e-02f, 1.07949562e-01f, -3.18149738e-02f, -1.06017523e-01f, -1.00062251e-01f, -2.86336187e-02f, 1.14587257e-02f, -2.38799602e-02f, -3.91484387e-02f, -7.49314800e-02f,
  -1.45161003e-01f, 4.88502765e-03f, 5.72397597e-02f, -1.84047259e-02f, -6.46753386e-02f, -4.65634353e-02f, -1.08850360e-01f, -1.42675877e-01f, -3.23360190e-02f, -1.22087933e-02f,
  2.00232118e-01f, 1.92045972e-01f, 2.33741641e-01f, -7.20216930e-02f, 9.81017426e-02f, -7.80738071e-02f, -7.12573230e-02f, 3.28672975e-02f, 7.54721761e-02f, 3.51550616e-02f,
  -5.24162687e-02f, -7.24884942e-02f, 2.79703476e-02f, 2.87264939e-02f, 1.65985674e-01f, 5.82147464e-02f, -2.20501143e-02f, 1.00304566e-01f, -1.29402345e-02f, 3.46072651e-02f,
  -7.95677886e-04f, 3.27624343e-02f, 1.15138069e-01f, 1.02243207e-01f, 1.11627348e-01f, 1.19918369e-01f, 1.33622766e-01f, 9.40369293e-02f, 1.84807718e-01f, 1.52657852e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.57149577e-01f, 3.12813371e-01f, 2.45483384e-01f, -6.43064529e-02f, 2.15614632e-01f, 1.77606374e-01f, -1.73508704e-01f, 2.09530428e-01f, 3.41366753e-02f, 1.33785769e-01f,
  2.05577329e-01f, 4.40623797e-02f, 1.68878943e-01f, 3.35898846e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.02679634e-01f, 5.49627021e-02f, 7.77229592e-02f, -1.54844485e-02f, -3.97203825e-02f, 3.56320105e-02f, 8.70902315e-02f, 7.73552284e-02f, 7.40741119e-02f, -3.14259622e-03f,
  -6.02758154e-02f, -1.00335367e-01f, -2.88813300e-02f, 3.09283622e-02f, 5.39218374e-02f, -5.13800159e-02f, 9.19597074e-02f, 8.39201435e-02f, 2.19881088e-02f, 9.84507333e-03f,
  1.53506443e-01f, -1.19449841e-02f, 8.44181851e-02f, -3.52139212e-02f, 8.89405683e-02f, -2.45260494e-03f, -5.72161041e-02f, 1.28619850e-01f, 9.30734258e-03f, 1.83838949e-01f,
  -2.40025762e-02f, -5.79380989e-02f, 1.37485620e-02f, 1.01495743e-01f, -1.46318728e-03f, 5.54776415e-02f, -2.75285617e-02f, -1.56581059e-01f, -7.42423087e-02f, -1.12461895e-01f,
  -1.94571987e-01f, 8.55565146e-02f, -9.92691070e-02f, 2.69347969e-02f, 2.06666114e-03f, -2.85455942e-01f, -6.72308356e-02f, 1.57424152e-01f, 1.25862518e-03f, -1.11093022e-01f,
  1.82256624e-01f, 8.12251046e-02f, -4.42686796e-01f, 1.39031634e-01f, 1.72292858e-01f, 6.59983307e-02f, 3.78917716e-02f, -1.24896042e-01f, -1.11294210e-01f, 3.59564215e-01f,
  -2.03911066e-01f, 3.44620571e-02f, 1.41853124e-01f, -3.02363515e-01f, -2.05749601e-01f, 1.50915217e-02f, 8.47519264e-02f, -6.80784658e-02f, -1.09432973e-01f, -3.16089541e-02f,
  -6.70208037e-02f, -4.67348099e-02f, 1.07455645e-02f, -3.89868990e-02f, 7.55485967e-02f, 8.40714797e-02f, -6.16411008e-02f, -5.09558879e-02f, -8.87894109e-02f, 4.15948033e-02f,
  1.28399566e-01f, 7.64532462e-02f, 7.13034300e-04f, -1.19611219e-01f, 1.90091599e-02f, 3.96508630e-03f, -2.50838790e-02f, -1.04143970e-01f, -4.56852280e-02f, -2.42684763e-02f,
  4.96409368e-03f, -7.50591308e-02f, 7.70364627e-02f, -4.87321131e-02f, -9.87097528e-03f, -1.72520369e-01f, 3.57677825e-02f, -3.20750996e-02f, -9.01118591e-02f, -4.40455042e-02f,
  -1.40606975e-02f, 6.34111315e-02f, 9.08060148e-02f, 1.03207052e-01f, -3.33630852e-02f, -1.36814028e-01f, 2.46294603e-01f, 1.20629385e-01f, -1.92133524e-02f, 2.69066155e-01f,
  7.86047950e-02f, -1.05969742e-01f, 1.35861456e-01f, 1.44678652e-01f, -1.36373490e-01f, -8.03456903e-02f, 1.14311196e-01f, -1.59814060e-01f, -1.77471265e-01f, -9.94117782e-02f,
  -1.75132796e-01f, 1.70486107e-01f, -5.02762794e-02f, -1.48523152e-01f, 3.96873355e-01f, 3.05739135e-01f, -1.49714023e-01f, 2.14650974e-01f, 5.44570349e-02f, -9.27084237e-02f,
  6.06406629e-02f, -8.36795270e-02f, 6.91769645e-02f, -2.19911300e-02f, -4.07515801e-02f, -3.62512134e-02f, 2.59924103e-02f, -4.83426303e-02f, 1.34529015e-02f, 1.83311831e-02f,
  -1.45739019e-02f, -3.47120240e-02f, -4.06326056e-02f, 8.78067389e-02f, 1.29029527e-01f, -3.92702706e-02f, 2.00887527e-02f, 9.26716104e-02f, -2.75913905e-02f, 8.03239644e-03f,
  -1.91769153e-02f, 7.58257359e-02f, -5.52830137e-02f, -2.07860465e-03f, -9.31606535e-03f, 1.03777140e-01f, -9.80708003e-03f, 6.15742989e-02f, -1.49509124e-02f, 9.24180746e-02f,
  -6.58566952e-02f, -1.21303629e-02f, -6.60548136e-02f, -2.17248388e-02f, 1.31665422e-02f, -8.28683302e-02f, -1.87213141e-02f, -5.93593866e-02f, 1.05199173e-01f, 5.53116351e-02f,
  9.54891592e-02f, 2.50675008e-02f, -9.90467891e-02f, -1.55250773e-01f, 7.34438598e-02f, 1.35532767e-01f, -5.58887236e-02f, -1.08525112e-01f, -1.63536310e-01f, 1.98487550e-01f,
  -2.70438135e-01f, 6.03559688e-02f, 1.62675634e-01f, -1.83038905e-01f, -1.42300129e-01f, 9.16087925e-02f, -2.31484517e-01f, 3.37395996e-01f, 1.82249174e-01f, 1.47726357e-01f,
  -1.14785895e-01f, -4.47688662e-02f, 4.25438434e-02f, 1.28498420e-01f, 2.69740336e-02f, 4.10182290e-02f, -5.23839518e-02f, 1.45648837e-01f, 1.01739943e-01f, 1.13121448e-02f,
  2.83886846e-02f, 1.96537711e-02f, 8.33912566e-02f, 1.43120636e-03f, 5.20251989e-02f, -4.03299853e-02f, 1.22460552e-01f, 5.52182570e-02f, -5.27382782e-03f, -1.01176932e-01f,
  5.52187450e-02f, 1.41990639e-03f, 1.09639116e-01f, 1.85905658e-02f, 3.34113799e-02f, 5.52454330e-02f, 8.50656852e-02f, 1.06688946e-01f, -2.66800553e-01f, 9.66945067e-02f,
  1.87649205e-02f, -1.12243608e-01f, -2.95091067e-02f, -1.56270880e-02f, -6.97361492e-03f, -7.86708947e-03f, -1.03870049e-01f, -2.01257631e-01f, 8.99035111e-02f, 7.66843632e-02f,
  1.12923279e-01f, -1.53467543e-02f, 1.81117328e-03f, -8.35162867e-03f, 2.59163659e-02f, 3.19674164e-02f, 6.80058682e-03f, 1.82972506e-01f, 5.66033050e-02f, 7.78931081e-02f,
  -1.61709003e-02f, 4.39813407e-03f, -5.52327260e-02f, 2.69206464e-01f, 7.00493529e-02f, -8.50209221e-02f, 9.56713781e-02f, 1.64531857e-01f, 2.52844572e-01f, -2.97746062e-02f,
  3.10200499e-03f, -2.14712828e-01f, 6.56195208e-02f, 9.23634693e-03f, -2.05397353e-01f, 1.60344347e-01f, 2.93018091e-02f, 1.25573594e-02f, -1.09603032e-01f, -1.41560450e-01f,
  -1.11346217e-02f, -3.72878276e-02f, -1.65055081e-01f, -1.97317656e-02f, 3.34578380e-02f, 6.29782351e-03f, -1.91363990e-01f, -7.01150596e-02f, 1.08752854e-01f, 4.00068723e-02f,
  1.35089368e-01f, 1.28528187e-02f, -1.41881734e-01f, -6.89140037e-02f, 1.39069585e-02f, -1.43998489e-01f, -9.63654816e-02f, 2.95859165e-02f, -2.54373364e-02f, 1.86123978e-02f,
  5.35441637e-02f, -1.28918260e-01f, 7.36436434e-03f, 2.38866154e-02f, 1.14205014e-02f, 9.62358862e-02f, 4.83133271e-02f, 1.22277737e-01f, -6.40831292e-02f, 8.49513635e-02f,
  -8.24926198e-02f, 3.72880287e-02f, -6.64732158e-02f, -9.78658646e-02f, 1.84042275e-01f, -1.52118076e-02f, 6.02006651e-02f, -8.25293213e-02f, -2.50360277e-02f, 5.88973090e-02f,
  2.29925498e-01f, -2.03695625e-01f, -7.15485513e-02f, 2.04229251e-01f, -5.81045896e-02f, 1.05569854e-01f, -5.75244352e-02f, -9.09435600e-02f, -2.43665978e-01f, 5.60179688e-02f,
  3.17664862e-01f, -1.22802973e-01f, 3.84526141e-03f, 1.11738145e-02f, 9.67726409e-02f, 2.55148292e-01f, -1.33438185e-01f, 3.79834734e-02f, 3.47114176e-01f, -2.65549958e-01f,
  1.24517031e-01f, -2.79499236e-02f, 8.96909013e-02f, 1.61294356e-01f, 9.85941514e-02f, -4.66495417e-02f, -1.99758336e-02f, 1.70745373e-01f, -1.41112551e-01f, 2.52489112e-02f,
  3.69520858e-02f, -5.25271222e-02f, -2.09055796e-01f, -4.91639227e-03f, -9.47819725e-02f, 6.34963810e-02f, -1.04399258e-02f, -4.99119684e-02f, 6.96673468e-02f, -2.64458694e-02f,
  -3.51844504e-02f, 7.38633610e-03f, -7.00385123e-02f, 6.45662174e-02f, 5.32764569e-02f, -1.27650961e-01f, 6.75328597e-02f, 7.30781034e-02f, 4.12866883e-02f, -2.43965864e-01f,
  -2.15865791e-01f, 8.80068243e-02f, -4.98154387e-02f, -8.32742453e-02f, -9.89376530e-02f, 1.57572672e-01f, -4.77517731e-02f, -2.25865766e-01f, -8.35632160e-02f, -1.80467308e-01f,
  6.61942586e-02f, -2.12208465e-01f, 2.98577011e-01f, -7.51811564e-02f, 6.27748482e-03f, -1.97291434e-01f, -9.98512954e-02f, 2.52325647e-02f, -1.14002243e-01f, -1.54499516e-01f,
  -1.98978782e-01f, -1.90172151e-01f, 2.46633887e-01f, 1.51756063e-01f, 2.86604196e-01f, -5.38242199e-02f, 4.99452464e-02f, 2.67903000e-01f, -8.64357278e-02f, 2.51744986e-01f,
  1.31556978e-02f, 1.21884413e-01f, 1.83474481e-01f, -2.66228378e-01f, -1.39364049e-01f, -4.15190682e-02f, -3.57608572e-02f, -7.47238323e-02f, 1.99444458e-01f, -1.05840247e-02f,
  -1.41757339e-01f, -6.30763024e-02f, -4.80167940e-02f, -6.30456880e-02f, -1.92907006e-01f, -7.30897337e-02f, -1.88668460e-01f, 1.15929991e-01f, -2.84330524e-03f, -9.18562934e-02f,
  -1.36339441e-01f, 1.10295601e-01f, -9.75510776e-02f, -1.08977489e-01f, -1.76377475e-01f, 6.08952269e-02f, -1.08312100e-01f, -2.98046153e-02f, -1.48834676e-01f, -2.16814756e-01f,
  7.56292371e-03f, 4.95034643e-02f, 4.71241474e-02f, -2.80236512e-01f, 1.74259376e-02f, 2.69431621e-01f, -1.07888147e-01f, -7.63305426e-02f, 5.83051071e-02f, 5.85720576e-02f,
  -1.43597618e-01f, -1.00495607e-01f, 3.91419202e-01f, -4.60294634e-02f, 1.23577252e-01f, -1.45406380e-01f, 9.99082997e-02f, 7.02306405e-02f, 2.75170624e-01f, 6.72390759e-02f,
  -9.05504003e-02f, -1.32404268e-01f, -3.83838564e-02f, -2.03718580e-02f, -1.73287258e-01f, -3.79498959e-01f, 5.49560785e-01f, 5.88412546e-02f, -1.06587641e-01f, -3.07533920e-01f,
  -4.22515161e-02f, 6.90069497e-02f, -2.05381542e-01f, -3.02233458e-01f, 1.94180738e-02f, 2.60378093e-01f, 3.04196179e-01f, 1.37848444e-02f, 5.72579578e-02f, 6.70791417e-02f,
  3.24762724e-02f, 1.34258255e-01f, -4.21713702e-02f, 1.11893959e-01f, -1.05396556e-02f, -7.26929158e-02f, 5.81580251e-02f, 9.33092460e-03f, 1.87870543e-02f, 1.91582546e-01f,
  -2.60006264e-03f, 2.54266034e-03f, -2.66820621e-02f, 8.36137012e-02f, -6.68728650e-02f, 3.39839384e-02f, -1.19545422e-02f, 1.10943839e-01f, 4.95809945e-04f, 5.71565032e-02f,
  9.74697769e-02f, 1.89994469e-01f, -8.44729915e-02f, 2.78412849e-01f, 1.48278460e-01f, 2.60567486e-01f, 3.19172032e-02f, -4.16359566e-02f, 3.10688633e-02f, -1.35567740e-01f,
  -1.55765684e-02f, 9.08251107e-02f, -1.04613177e-01f, 1.07928567e-01f, -1.26512155e-01f, -1.12979710e-01f, 1.46184906e-01f, 1.11586682e-03f, 6.89259870e-03f, 9.09805857e-03f,
  1.49574965e-01f, 4.13896255e-02f, -2.13793933e-01f, 4.38394286e-02f, 1.35492355e-01f, 7.91516751e-02f, -1.21834343e-02f, -1.23984694e-01f, -1.76608227e-02f, 1.72558188e-01f,
  1.13316506e-01f, 8.18099529e-02f, 2.23787859e-01f, 9.57822800e-02f, 2.01100633e-02f, -2.01035008e-01f, 6.06991462e-02f, 1.65799856e-01f, 5.07029966e-02f, 3.33506882e-01f,
  -1.62116319e-01f, -2.71685630e-01f, -1.92588940e-01f, 3.03830802e-02f, -1.26217559e-01f, 1.42290926e-04f, 2.16477171e-01f, -1.00872390e-01f, -4.47260141e-02f, 6.39243284e-03f,
  2.78681293e-02f, -4.21542861e-02f, -2.05181748e-01f, -2.68720146e-02f, -2.54746508e-02f, 5.82799166e-02f, 4.43510972e-02f, -6.61998754e-03f, -1.22781657e-01f, 2.62699258e-02f,
  -4.01050188e-02f, -3.07868812e-02f, -1.17084935e-01f, 1.80595532e-01f, 1.45430326e-01f, 1.68907598e-01f, -6.89066723e-02f, -2.40392581e-01f, 2.34420568e-01f, -7.17948973e-02f,
  3.29251774e-02f, -7.04010203e-02f, -1.05729491e-01f, 4.53559756e-01f, -2.16098875e-01f, -1.01878241e-01f, 1.76412001e-01f, 3.33948992e-02f, -9.97303426e-02f, -7.64005855e-02f,
  1.94896515e-02f, -1.00727551e-01f, 3.01558912e-01f, -1.60309985e-01f, 1.45147562e-01f, 3.32046370e-03f, 1.37235433e-01f, -2.48188928e-01f, 1.20467789e-01f, 1.09944744e-02f,
  -1.47022545e-01f, -6.36950135e-02f, 7.98268169e-02f, -2.86737308e-02f, 2.79931307e-01f, 1.78290516e-01f, -3.63683403e-02f, -8.90536979e-03f, 1.40974030e-01f, -4.74218279e-02f,
  1.30105317e-01f, 1.42476082e-01f, -1.03732452e-01f, 1.03724547e-01f, 3.37616146e-01f, -6.53055543e-03f, 3.42755839e-02f, 1.56222343e-01f, -1.04643717e-01f, 2.87225153e-02f,
  2.01289162e-01f, 2.86017973e-02f, -2.91894283e-03f, 2.12992746e-02f, -1.71046153e-01f, -4.45637591e-02f, 8.80871713e-03f, 1.51963651e-01f, 1.16274677e-01f, -1.64378449e-01f,
  -1.71860754e-01f, -5.65263033e-02f, 8.87824744e-02f, -8.34660828e-02f, -1.61305279e-01f, 1.66886047e-01f, 1.19900919e-01f, 9.67717450e-03f, -1.42123392e-02f, -1.00630382e-02f,
  4.98603620e-02f, 8.09510425e-02f, 3.58184837e-02f, -9.24300700e-02f, 8.84996653e-02f, 7.42686391e-02f, 4.21345197e-02f, -5.41270785e-02f, -2.52319984e-02f, 1.07383244e-01f,
  8.59196708e-02f, 5.41669317e-02f, -3.79556231e-02f, 1.14488844e-02f, 4.35037576e-02f, -2.46093813e-02f, 6.14881366e-02f, -1.64996609e-01f, 1.18685374e-02f, -6.78789318e-02f,
  -1.32487088e-01f, 4.93509062e-02f, -1.88884571e-01f, -1.23038240e-01f, -3.57267127e-04f, -1.20575592e-01f, -1.76650472e-02f, 1.46675095e-01f, 3.10742885e-01f, -4.19871390e-01f,
  -4.14607257e-01f, -3.81528400e-02f, -1.65881008e-01f, 1.74639016e-01f, -1.23409405e-01f, -1.40213713e-01f, -3.24723393e-01f, 2.14637846e-01f, -1.87700152e-01f, -1.46333635e-01f,
  2.08340839e-01f, -3.43138129e-02f, -7.40861520e-02f, 2.55258903e-02f, -8.26863945e-02f, 1.14591874e-01f, -3.54309678e-02f, -5.79897501e-02f, 1.52053565e-01f, -1.44521724e-02f,
  1.05329953e-01f, 7.87573457e-02f, 6.23717494e-02f, 1.21560641e-01f, 4.19050036e-03f, 2.42000166e-02f, 2.01950409e-02f, 8.99533853e-02f, 1.00484885e-01f, 1.23978496e-01f,
  2.56961495e-01f, -1.82701889e-02f, 3.59903760e-02f, 3.90154123e-02f, 7.64027759e-02f, -6.00336026e-03f, -1.30208895e-01f, 1.23349987e-01f, -9.05239731e-02f, -2.39110604e-01f,
  -2.35607065e-02f, -1.59884796e-01f, 1.17112938e-02f, 1.87467262e-01f, 7.31616095e-02f, -8.68911296e-02f, -6.27340004e-02f, 3.01087592e-02f, 1.54425681e-01f, -7.11063817e-02f,
  1.59764886e-02f, -7.35768601e-02f, -5.36336601e-02f, 1.48849813e-02f, -2.28302721e-02f, 1.09378593e-02f, 9.60253775e-02f, -9.07573104e-02f, -1.47703826e-01f, 1.64716702e-03f,
  2.91650444e-01f, 7.62619525e-02f, 4.62290525e-01f, 9.45339212e-04f, 4.96985801e-02f, 1.25531092e-01f, -1.75553024e-01f, 1.14332750e-01f, -2.69563645e-02f, -1.12152204e-01f,
  5.74243702e-02f, -1.19340681e-01f, 1.12869836e-01f, -8.23205709e-02f, 6.96263909e-02f, -7.05492869e-02f, -5.08515164e-02f, 3.08268629e-02f, 4.12277803e-02f, -1.26165614e-01f,
  -1.13174550e-01f, -1.86896548e-02f, -1.31713867e-01f, 2.25338973e-02f, -3.73823307e-02f, 8.86068344e-02f, -7.96874762e-02f, -7.20795020e-02f, -5.94090223e-02f, -9.77537706e-02f,
  -9.57003683e-02f, 1.82905331e-01f, 6.63230419e-02f, 3.41833718e-02f, -5.99012487e-02f, -6.20962167e-03f, 7.49245659e-02f, -6.69076368e-02f, -1.44944862e-01f, -2.68783092e-01f,
  1.37013316e-01f, 2.62020472e-02f, 9.15626958e-02f, 1.02754973e-01f, 9.92177203e-02f, -1.44861594e-01f, -6.01499714e-02f, 2.82371081e-02f, 1.27456058e-03f, 6.64355308e-02f,
  -1.45357111e-02f, 1.14751898e-01f, -2.54592240e-01f, 1.75275058e-01f, -4.02848646e-02f, -1.41206728e-02f, -4.16714281e-01f, -6.86804354e-02f, 1.88373849e-01f, 6.66340142e-02f,
  -5.59508279e-02f, 3.56580392e-02f, 1.42048940e-01f, 4.31778729e-02f, 2.93624550e-01f, -3.76577884e-01f, 3.07440348e-02f, 3.06249022e-01f, -2.93688267e-01f, -5.61306067e-02f,
  1.11160167e-02f, -1.39132172e-01f, 1.39571682e-01f, -5.98231927e-02f, 2.38900378e-01f, -7.83404633e-02f, 2.26516277e-01f, 1.46344364e-01f, -2.14498080e-02f, -2.69742254e-02f,
  9.99308154e-02f, -1.25887152e-02f, 4.12585251e-02f, -6.28790110e-02f, -8.92244801e-02f, 9.93320569e-02f, -2.28169262e-02f, 2.78998893e-02f, -7.19760433e-02f, 1.63164839e-01f,
  -1.18991278e-01f, -1.47599876e-01f, -4.23588902e-02f, 7.71057308e-02f, 2.77978722e-02f, -4.64805290e-02f, 1.49180582e-02f, -9.93953422e-02f, 9.67261195e-03f, -1.28504168e-02f,
  -7.54074678e-02f, 1.17061124e-03f, -5.30481264e-02f, -2.09261566e-01f, -5.30572757e-02f, 1.02489315e-01f, 2.20256492e-01f, -1.82931811e-01f, -2.01964304e-01f, 2.22909942e-01f,
  3.33823338e-02f, 2.65322551e-02f, -2.96841785e-02f, -3.79862147e-03f, -1.21474028e-01f, -3.69040906e-01f, -1.15633190e-01f, 1.29386748e-03f, -1.26832146e-02f, 1.71516776e-01f,
  2.24848732e-01f, 4.16243263e-02f, 4.09694295e-03f, -1.20580420e-01f, -7.04499334e-02f, 3.77149917e-02f, -4.73372499e-03f, -1.14667043e-01f, -2.09529117e-01f, -4.06211793e-01f,
  -1.88758612e-01f, 4.81867529e-02f, 2.91881859e-01f, -2.07843408e-01f, 3.39247435e-02f, -1.00741684e-01f, -1.15312953e-02f, 2.11307570e-01f, 1.85533166e-01f, -1.06232110e-02f,
  4.97872204e-01f, -2.62018256e-02f, 1.64851062e-02f, 7.61654228e-02f, 6.56484738e-02f, 5.15138321e-02f, 1.09475672e-01f, -2.24303175e-02f, 3.47609967e-02f, -3.95408124e-02f,
  -1.58172045e-02f, 5.25449701e-02f, 1.08386735e-02f, 1.36629373e-01f, 1.41068861e-01f, 1.00257255e-01f, 7.56160244e-02f, 7.57734403e-02f, 1.35770235e-02f, 1.24685779e-01f,
  -8.53341669e-02f, 5.47579192e-02f, 3.12430859e-02f, 8.77312943e-02f, 1.15430497e-01f, 9.79641601e-02f, -1.12815738e-01f, -5.08076791e-03f, -5.12723997e-02f, 5.18886559e-02f,
  1.38089374e-01f, -1.33814961e-01f, 1.11564308e-01f, 5.80926016e-02f, -9.98456851e-02f, -6.73649684e-02f, 2.42325244e-03f, -3.50912404e-03f, -5.29575534e-02f, -2.05577761e-02f,
  2.36627057e-01f, -1.07313255e-02f, -4.32754792e-02f, 1.52587384e-01f, 2.19811410e-01f, 5.96031547e-02f, -7.81706423e-02f, 1.12713113e-01f, 5.57451099e-02f, 6.67226985e-02f,
  -3.24720666e-02f, -1.28637284e-01f, -1.85485810e-01f, 4.94019762e-02f, 4.70979452e-01f, -1.57095045e-01f, 9.02235624e-04f, 3.58495675e-02f, 1.83269698e-02f, 2.93885678e-01f,
  -1.93156794e-01f, -6.87535331e-02f, 4.23696309e-01f, 3.98279935e-01f, -2.43040264e-01f, 1.55784085e-01f, -3.09704673e-02f, -1.02894157e-01f, -7.27630183e-02f, 1.57429799e-02f,
  -3.89200635e-02f, -3.10132932e-02f, 1.58799253e-02f, -5.07302284e-02f, -2.48967495e-04f, -4.54493053e-03f, 5.69213778e-02f, 4.27847207e-02f, 2.07558125e-02f, -2.66175531e-02f,
  5.68965450e-02f, -2.67476011e-02f, 4.95978408e-02f, 6.75869314e-03f, -4.22254130e-02f, -1.40679270e-01f, -1.72123313e-01f, -2.66501401e-03f, 6.99802041e-02f, -1.11516945e-01f,
  -7.00171441e-02f, -2.23258466e-01f, 8.57928544e-02f, -9.04512405e-02f, 6.70451596e-02f, -1.84179433e-02f, 6.60629645e-02f, -2.26062819e-01f, 7.32239634e-02f, -6.87835664e-02f,
  -1.49117531e-02f, 5.87542094e-02f, -2.33430490e-02f, 1.91760957e-01f, -2.99059868e-01f, 1.34220093e-01f, -9.26329568e-02f, -9.86009389e-02f, -2.48917058e-01f, -1.24344237e-01f,
  2.34244362e-01f, -9.53910202e-02f, 2.82848179e-02f, 6.88879862e-02f, 7.23086521e-02f, 6.33882284e-02f, 2.10359856e-01f, -4.73664403e-01f, 1.20758325e-01f, 4.47177254e-02f,
  -2.06144691e-01f, 1.26760364e-01f, 8.16273168e-02f, 1.52565375e-01f, 8.73458460e-02f, -9.13638920e-02f, 2.34041780e-01f, -2.09211752e-01f, -2.31988709e-02f, -3.67690980e-01f,
  -1.08858578e-01f, 2.76671979e-03f, -1.97944090e-01f, -1.53330982e-01f, -1.11740306e-01f, 2.78767124e-02f, -6.32926971e-02f, -4.79019023e-02f, 2.31307875e-02f, -8.79182369e-02f,
  -1.14995643e-01f, -1.74782693e-01f, 2.06692400e-03f, -1.62110943e-02f, -8.29354599e-02f, -2.32597459e-02f, -1.44580295e-02f, 6.08337857e-02f, 1.16280250e-01f, -1.04971394e-01f,
  -1.81905314e-01f, -3.92423421e-02f, -2.67199129e-01f, -1.37456566e-01f, -7.27381706e-02f, -2.82776415e-01f, 1.80588290e-02f, 4.97704446e-02f, 1.89704880e-01f, -1.31366178e-02f,
  -9.64789018e-02f, -1.04327267e-02f, 7.07501695e-02f, -9.11672264e-02f, -1.83189645e-01f, -3.15246433e-02f, 4.73974757e-02f, 8.78420018e-04f, -2.15107352e-01f, 1.66901618e-01f,
  -6.70289770e-02f, 5.32349683e-02f, -1.83104187e-01f, 3.86515297e-02f, 2.48315319e-01f, 1.52337506e-01f, -1.17962539e-01f, -9.12508443e-02f, 7.65347555e-02f, 4.17500436e-02f,
  -2.70590186e-02f, -2.99735636e-01f, -3.36150490e-02f, 1.29418178e-02f, -4.19822745e-02f, 1.57504916e-01f, 2.95308083e-02f, 1.78754330e-01f, -1.33788198e-01f, -1.70150280e-01f,
  1.00436900e-02f, -3.43455911e-01f, 2.90727198e-01f, -2.95192689e-01f, -4.44726273e-03f, -6.78605307e-03f, -7.73262531e-02f, -1.54388519e-02f, -1.77628785e-01f, 5.83764864e-03f,
  8.72776657e-02f, -1.34465480e-02f, 3.62083339e-03f, 3.66439186e-02f, 2.19525367e-01f, 2.66333558e-02f, 1.38188654e-03f, -3.36670130e-02f, 3.72867845e-02f, 1.14369355e-01f,
  1.30851999e-01f, 3.11609507e-02f, -5.08759134e-02f, 8.47713724e-02f, 6.55429214e-02f, -2.98880134e-02f, -3.93475071e-02f, 1.23957247e-01f, 1.41604304e-01f, 2.43776366e-01f,
  -2.80524101e-02f, -1.99257314e-01f, -7.68516436e-02f, -2.82276217e-02f, -1.32354805e-02f, -1.68675557e-01f, 1.85197890e-02f, -9.39427689e-02f, -8.35049599e-02f, -8.62773508e-02f,
  6.69360906e-02f, -4.93984260e-02f, 1.77903533e-01f, -4.87394594e-02f, -7.19390213e-02f, -1.80657264e-02f, -1.35824531e-01f, 6.99833632e-02f, 4.22448106e-02f, 2.82715559e-01f,
  1.36267081e-01f, 1.61814108e-01f, 7.37723112e-02f, 1.09531187e-01f, 1.07823675e-02f, -5.63588068e-02f, -2.43376732e-01f, 2.75443587e-02f, 1.45989299e-01f, -3.52469506e-03f,
  9.03153270e-02f, 1.04083657e-01f, 1.26162082e-01f, -7.80983269e-02f, 2.58047581e-01f, -3.02572310e-01f, 1.91431031e-01f, -2.16628566e-01f, -1.00365028e-01f, 1.53601721e-01f,
  4.97538671e-02f, 9.54903364e-02f, -2.94591337e-02f, 1.70922548e-01f, 9.10183266e-02f, 1.37344643e-01f, -8.85830149e-02f, 6.82664150e-03f, 7.64342546e-02f, 1.59589038e-03f,
  5.94231337e-02f, 1.40409872e-01f, -3.46445367e-02f, -9.67161879e-02f, -7.77969733e-02f, -7.50561208e-02f, 1.22730918e-01f, -3.01185958e-02f, 2.21875235e-01f, -2.13649943e-02f,
  8.77406150e-02f, 1.08670197e-01f, -5.70571683e-02f, 2.39604324e-01f, -7.60554597e-02f, 5.39523326e-02f, -5.57939485e-02f, -1.86783299e-01f, -6.30381098e-03f, 1.90308049e-01f,
  -2.86325929e-03f, 9.50534046e-02f, 9.65257641e-03f, 2.38009095e-02f, 1.45815074e-01f, -1.65336147e-01f, 1.20292850e-01f, -1.13191642e-01f, 6.84671476e-02f, -6.60627633e-02f,
  2.85138816e-01f, 4.52780724e-03f, -2.56950349e-01f, -4.63449135e-02f, 3.99130816e-03f, 2.88869794e-02f, -9.07351673e-02f, 1.78265758e-02f, -3.76706839e-01f, 3.60240489e-01f,
  -1.34473965e-01f, -1.00741349e-01f, 4.52678174e-01f, 4.48381267e-02f, 1.28267229e-01f, 1.04776040e-01f, 1.87254474e-01f, 8.34275633e-02f, -2.07399607e-01f, -7.73971947e-03f,
  -1.64230779e-01f, 1.70494363e-01f, -1.15552999e-01f, -2.35350709e-02f, 1.21484034e-01f, 2.03205273e-02f, -1.36019111e-01f, 9.26249549e-02f, -7.57427588e-02f, -6.93747699e-02f,
  1.87848508e-02f, -2.36523096e-02f, -1.06947206e-01f, 5.85087854e-03f, 1.46694928e-02f, 2.88381595e-02f, -2.36915573e-02f, -7.95966089e-02f, 5.59783876e-02f, -8.42775106e-02f,
  -1.24317326e-01f, -1.99764237e-01f, 5.43434210e-02f, -7.84618035e-02f, 2.01171506e-02f, -1.48707852e-01f, -9.48803499e-02f, 6.56415969e-02f, -1.80945382e-01f, 9.93724391e-02f,
  -1.25061974e-01f, -1.91108525e-01f, -1.07744047e-02f, 7.10250810e-02f, -1.28891394e-01f, 4.97014634e-02f, -2.23694146e-02f, -7.23008290e-02f, 1.23610690e-01f, -1.10917166e-01f,
  3.13618451e-01f, 9.37654004e-02f, -1.03674032e-01f, 1.06045358e-01f, 1.17703691e-01f, 1.70073196e-01f, 9.97331440e-02f, 2.56576508e-01f, 1.41624570e-01f, 3.29509497e-01f,
  -9.67061222e-02f, 1.53391242e-01f, -3.20567377e-02f, 3.31905097e-01f, 2.90431529e-01f, 5.30837402e-02f, 6.05716519e-02f, -5.20623848e-02f, 6.40824735e-02f, 1.74715111e-04f,
  2.21596435e-01f, -2.67314881e-01f, 3.13610882e-02f, 4.29802835e-01f, -6.58194423e-02f, -9.43344980e-02f, -2.93966848e-02f, 1.74541213e-02f, -2.88054887e-02f, -2.67632678e-02f,
  -1.57984644e-02f, -8.11437964e-02f, 3.76863666e-02f, 1.43706322e-01f, -1.32841431e-02f, -1.30114807e-02f, 1.88697092e-02f, -7.61435777e-02f, 4.95870635e-02f, 1.14320733e-01f,
  5.86698242e-02f, 1.34299755e-01f, -4.62247692e-02f, -6.57641739e-02f, -1.08777009e-01f, 5.86319715e-02f, 7.39461482e-02f, 3.50252463e-04f, 1.19781569e-02f, -5.33319125e-03f,
  1.96201690e-02f, 2.57494170e-02f, -4.97316644e-02f, -1.07291706e-01f, -1.21795982e-01f, -5.76888695e-02f, 5.79364635e-02f, 7.84739256e-02f, 7.44174346e-02f, -5.81305362e-02f,
  5.97046986e-02f, 7.94159248e-02f, 1.52579144e-01f, 6.32777438e-02f, 1.52711347e-01f, -2.58016642e-02f, -1.14291415e-01f, -4.58880104e-02f, 9.59955156e-02f, 1.34675741e-01f,
  -9.83449891e-02f, 7.97211230e-02f, -1.79627296e-02f, 4.36168052e-02f, 5.98981343e-02f, -1.56924613e-02f, -2.54398316e-01f, 2.34179303e-01f, -1.98544994e-01f, -6.90391734e-02f,
  -6.07270049e-03f, -8.21458325e-02f, -1.83586121e-01f, 6.30127713e-02f, 1.24725647e-01f, 6.23334870e-02f, 3.53161037e-01f, 1.08204726e-02f, -2.81973839e-01f, 3.08560282e-01f,
  -3.00043467e-02f, -6.71112835e-02f, 1.30149066e-01f, 5.80283143e-02f, -4.28734198e-02f, -6.19482659e-02f, 8.73576105e-03f, 2.00341009e-02f, -6.29689991e-02f, -1.05464742e-01f,
  6.77562412e-03f, 1.30738923e-03f, -1.63022459e-01f, -3.45225967e-02f, 5.95982149e-02f, 8.79834816e-02f, -2.33190833e-03f, -9.09075737e-02f, 1.10114012e-02f, 8.30748491e-03f,
  2.14448553e-02f, -2.72019934e-02f, -1.94696307e-01f, 6.31624386e-02f, -7.05538318e-02f, -9.31056216e-02f, -6.85180072e-03f, 9.00922939e-02f, 6.09994866e-02f, -3.68933752e-02f,
  -1.41310558e-01f, 2.92260828e-03f, -1.14364669e-01f, -2.99682328e-03f, 5.15085496e-02f, 1.32793590e-01f, 1.87077224e-02f, -1.03098482e-01f, 2.73072999e-02f, 4.51637469e-02f,
  -1.64551456e-02f, 1.63708612e-01f, 1.26529887e-01f, -2.79970653e-02f, 2.72075325e-01f, -2.07255900e-01f, 9.37342644e-02f, 1.56432360e-01f, 5.71855344e-03f, -1.09224342e-01f,
  -2.81378459e-02f, -1.89163238e-01f, -3.61662447e-01f, 2.05762610e-01f, 3.75181139e-01f, -1.17876194e-01f, -1.92162693e-01f, -1.28089450e-03f, 9.07576159e-02f, 2.32574448e-01f,
  -3.19768637e-02f, -1.93833530e-01f, 4.36974883e-01f, -2.03091562e-01f, 1.06515530e-02f, -1.01863116e-01f, 1.04571454e-01f, 5.24715856e-02f, -1.18894443e-01f, 7.83510208e-02f,
  -7.14491904e-02f, -8.34904015e-02f, 9.20630544e-02f, -6.91513270e-02f, -9.33926702e-02f, 1.10724397e-01f, -1.91761971e-01f, 1.32278621e-01f, -1.61976088e-02f, 7.32491538e-02f,
  1.50611669e-01f, -1.43259633e-02f, 5.60987927e-02f, -2.92760711e-02f, 8.43347684e-02f, -1.87784946e-03f, -7.91095048e-02f, 1.05397925e-01f, 2.01563779e-02f, 1.95226610e-01f,
  -1.62334815e-01f, -2.36132741e-02f, -5.41412644e-02f, -2.63383150e-01f, 2.54524816e-02f, -7.43953884e-02f, 8.84220004e-02f, 8.09125528e-02f, -1.08439021e-01f, -5.93211502e-02f,
  -1.03880093e-01f, -1.98142827e-01f, 3.58318627e-01f, -6.69177845e-02f, -2.88822595e-03f, 3.69079933e-02f, 1.26360074e-01f, 5.80015443e-02f, -2.61345860e-02f, 3.63435507e-01f,
  -3.67834023e-03f, 1.66668594e-01f, -2.93379761e-02f, 7.85784945e-02f, -5.44419102e-02f, 2.87033077e-02f, 4.24662143e-01f, 1.88147519e-02f, 1.43314138e-01f, 4.10633013e-02f,
  1.13485157e-01f, 8.08255896e-02f, -2.43674994e-01f, -8.91162008e-02f, 1.28668258e-02f, 1.86443359e-01f, -1.73046980e-02f, -4.36765760e-01f, 1.85927466e-01f, 8.57433081e-02f,
  7.95928091e-02f, -3.33852135e-02f, -6.71518445e-02f, -7.36787021e-02f, -5.16584259e-04f, -2.99571287e-02f, 2.83293407e-02f, -1.45371422e-01f, 2.09001191e-02f, -5.68397976e-02f,
  1.57153308e-01f, 2.71433294e-02f, 1.10460296e-02f, -5.38327284e-02f, 2.20502503e-02f, -2.91320924e-02f, 1.76948085e-01f, 6.79144263e-02f, 2.74768565e-02f, 1.18829887e-02f,
  -7.63897672e-02f, -6.28042072e-02f, 4.33949977e-02f, 4.09020893e-02f, 5.19502759e-02f, 1.86725110e-02f, 4.08479199e-02f, 3.51876095e-02f, -1.06825493e-01f, -2.85793334e-01f,
  1.43712372e-01f, 3.48002627e-03f, 9.16919783e-02f, -1.25100672e-01f, -1.85707267e-02f, 2.56867200e-01f, -1.39306590e-01f, 1.82907265e-02f, -2.11827099e-01f, 1.63812116e-01f,
  -2.93639034e-01f, -6.03138320e-02f, -6.79970831e-02f, -7.21998289e-02f, -4.40095440e-02f, 8.53280723e-02f, 7.26484358e-02f, -3.32694426e-02f, 4.68086898e-01f, 1.85724851e-02f,
  -2.68719941e-01f, 3.50916050e-02f, -4.69372660e-01f, -5.17869890e-02f, -1.42652899e-01f, -3.17199051e-01f, 1.71910167e-01f, 1.04979388e-01f, -7.04579875e-02f, -6.01513758e-02f,
  -2.24995062e-01f, 1.59429714e-01f, 1.07881114e-01f, 4.27216254e-02f, 7.49166831e-02f, -1.67085141e-01f, 8.81481990e-02f, 4.32385318e-02f, 1.28203273e-01f, 1.09428883e-01f,
  1.43828914e-02f, 9.25419033e-02f, -9.15414095e-02f, 1.34474456e-01f, 4.09636125e-02f, 9.61192995e-02f, 1.23118937e-01f, -2.62099653e-02f, -2.70695761e-02f, 1.39293835e-01f,
  -1.18782945e-01f, 9.72141623e-02f, 7.46759921e-02f, -4.58012894e-03f, -2.10646540e-01f, -4.77773286e-02f, 1.19053446e-01f, -3.48446667e-01f, -3.11174747e-02f, -7.18426779e-02f,
  1.70713305e-01f, -1.53827161e-01f, 2.44556032e-02f, -7.85962865e-02f, 5.69062792e-02f, -1.25769507e-02f, -1.73075899e-01f, 7.83432857e-04f, 3.27923894e-02f, -4.50432673e-03f,
  -2.39612311e-02f, -9.19915736e-02f, -1.25673681e-01f, 1.39733832e-02f, -2.19378963e-01f, -2.89088309e-01f, 3.23346436e-01f, 1.61488369e-01f, 3.71642001e-02f, 1.61368102e-02f,
  1.34676829e-01f, 1.68112218e-01f, 2.48429179e-01f, -2.21742075e-02f, 3.93250018e-01f, 1.85344787e-03f, -9.84772667e-02f, -3.05421576e-02f, 2.38886359e-03f, 3.96708259e-03f,
  -2.68841147e-01f, -3.37004066e-01f, -1.71614185e-01f, -1.78914845e-01f, 1.60613656e-01f, 2.39414632e-01f, -1.60214603e-01f, -3.06251063e-03f, 1.70816153e-01f, -9.22690183e-02f,
  3.86468507e-02f, -4.74097300e-03f, -1.16753221e-01f, 1.16923684e-02f, -9.43663158e-03f, -1.30237862e-01f, 4.05899957e-02f, -5.32356501e-02f, -7.10952431e-02f, 9.32831764e-02f,
  2.69229151e-02f, 2.42982339e-03f, -3.18093859e-02f, 5.26721077e-03f, 8.12834278e-02f, -6.35913536e-02f, -1.66622743e-01f, -7.16172084e-02f, -1.62983492e-01f, 4.97523732e-02f,
  6.06303848e-03f, -4.65324335e-02f, 2.12915346e-01f, 5.54939210e-02f, -1.17458187e-01f, -1.45939574e-01f, -5.55195063e-02f, 2.35676870e-01f, 1.85980257e-02f, -1.79348484e-01f,
  -4.37110960e-02f, 1.03800707e-01f, -1.22032978e-01f, 5.18380255e-02f, 3.25079486e-02f, -1.90084085e-01f, -3.56322676e-02f, -4.13638279e-02f, 2.18215942e-01f, -2.63772141e-02f,
  7.00599179e-02f, -6.10826463e-02f, 6.90728128e-02f, 8.87727141e-02f, -9.34352726e-02f, -5.53984120e-02f, -1.73047021e-01f, -2.45510489e-01f, -1.41192237e-02f, 4.07389402e-01f,
  2.79701114e-01f, -1.21399380e-01f, 3.27964053e-02f, -1.84709132e-02f, -1.84112400e-01f, 6.33170977e-02f, 1.66912019e-01f, 2.89035682e-02f, 3.87389153e-01f, 6.76440969e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.74487187e-02f, 1.55218676e-01f, 1.30633593e-01f, 3.98706160e-02f, 2.84062058e-01f, 1.89422369e-02f, -6.71072304e-02f, 5.74392565e-02f, 1.99045092e-01f, -7.04258978e-02f,
  6.59251660e-02f, -6.45182468e-03f, -3.54513712e-02f, 1.72112226e-01f, 2.71619171e-01f, 4.07196395e-02f, 4.69052866e-02f, 1.87105805e-01f, 2.77991444e-02f, 1.47866741e-01f,
  5.16760722e-02f, 1.72117665e-01f, -8.44964087e-02f, 4.05128226e-02f, -6.53864965e-02f, -2.19882980e-01f, 5.16774505e-02f, 3.51769663e-02f, 8.66986662e-02f, -4.31650765e-02f,
  5.78763187e-02f, 1.31545942e-02f, 9.63505134e-02f, -1.09184794e-02f, -1.71488021e-02f, 1.80680424e-01f, -1.25831053e-01f, 1.86995968e-01f, -6.48349524e-02f, -4.53241169e-03f,
  9.68434960e-02f, -1.28040537e-01f, -4.69753444e-02f, -2.49527413e-02f, -6.94535971e-02f, -2.60603309e-01f, 2.19856557e-02f, -2.04702377e-01f, -3.15392949e-02f, -2.30680332e-01f,
  2.53525317e-01f, -1.76650912e-01f, 2.92303801e-01f, 1.46446854e-01f, -3.82486801e-03f, 2.11628769e-02f, -1.12182528e-01f, 1.94912642e-01f, -1.32118881e-01f, 1.30191892e-01f,
  -2.37414286e-01f, 5.56062341e-01f, -6.14426695e-02f, -4.46491361e-01f, 1.23810776e-01f, 9.06737819e-02f, 2.14207470e-01f, 2.51848511e-02f, 1.23700693e-01f, 5.24843251e-03f,
  2.86290109e-01f, 4.60612401e-02f, 1.03641920e-01f, 1.31552517e-01f, 3.08636189e-01f, 2.88874120e-01f, 2.83251882e-01f, 2.00058311e-01f, 1.28222182e-01f, 1.76746640e-02f,
  -3.51169333e-02f, 2.63747334e-01f, -2.49553099e-02f, 1.40812904e-01f, 2.12308746e-02f, 2.29401603e-01f, 3.65930535e-02f, 5.56446463e-02f, -5.53482100e-02f, -1.39407530e-01f,
  3.26578826e-01f, -1.27672058e-04f, 1.62903577e-01f, 3.13217998e-01f, 7.40016922e-02f, -1.71245471e-01f, 2.13328764e-01f, -1.24414913e-01f, -1.52467594e-01f, -1.80110723e-01f,
  -7.00687915e-02f, 2.75263160e-01f, -5.42853415e-01f, 3.25374007e-02f, -6.56340830e-03f, -1.66262016e-01f, -4.35509086e-01f, 3.27302553e-02f, 1.10665947e-01f, -2.65435427e-01f,
  -4.71814424e-02f, -2.83521980e-01f, 1.18295588e-01f, 1.03298083e-01f, 3.53325784e-01f, 2.41465755e-02f, 2.91206270e-01f, -2.09990367e-01f, -4.10174966e-01f, -1.97998479e-01f,
  -1.97494417e-01f, -2.40820944e-02f, 2.91622877e-01f, -1.41210303e-01f, 4.81511466e-02f, 1.05027430e-01f, -2.96236753e-01f, 4.49069947e-01f, -2.62282677e-02f, -1.41501985e-02f,
  -7.15372665e-03f, 5.24430275e-02f, 1.69153139e-01f, -7.08521903e-02f, -2.42346779e-01f, -1.60213441e-01f, 7.97417536e-02f, -3.50051001e-02f, -2.67789289e-02f, -1.51200876e-01f,
  -1.75677583e-01f, 1.01157829e-01f, -3.44633730e-03f, -9.13593024e-02f, 4.86324318e-02f, -9.98359993e-02f, -1.86598510e-01f, 1.90988053e-02f, -5.04757687e-02f, -5.29014990e-02f,
  1.69695064e-01f, -3.63146290e-02f, -2.67704390e-02f, 4.68738489e-02f, -2.52513438e-01f, 1.22725986e-01f, -2.67469548e-02f, 3.99397500e-02f, 2.77025729e-01f, 5.64284483e-03f,
  -9.92378965e-03f, 1.35653004e-01f, 7.68106282e-02f, 2.79401219e-03f, 8.23193565e-02f, 1.00030482e-01f, 1.38978347e-01f, -7.44530186e-02f, -5.30637540e-02f, -3.82432416e-02f,
  1.94979832e-01f, 4.51556145e-04f, -7.47274309e-02f, 2.43157800e-02f, -1.61246024e-02f, -7.28359073e-02f, -2.19907220e-02f, 4.87135425e-02f, -1.96815357e-02f, 1.23482943e-01f,
  3.23913157e-01f, -5.20476662e-02f, 1.04685783e-01f, 1.24993078e-01f, -5.55611774e-02f, 7.18119144e-02f, -4.13612098e-01f, 1.12480581e-01f, -1.73927456e-01f, 5.65404654e-01f,
  7.81129748e-02f, -3.13469023e-01f, -4.50194217e-02f, -1.30143255e-01f, -2.39117280e-01f, 1.32154375e-01f, 2.21307576e-01f, -1.23956706e-02f, 1.05842024e-01f, 8.30028802e-02f,
  1.15020938e-01f, -4.21520397e-02f, 4.87106405e-02f, -5.51362708e-02f, 1.29395917e-01f, -2.13401094e-01f, 1.86802238e-01f, 1.59374341e-01f, 7.86636472e-02f, 5.47934808e-02f,
  9.39214006e-02f, 3.59340385e-02f, -2.74796247e-01f, 2.72148363e-02f, -1.33011854e-05f, -2.01647487e-02f, 1.48048431e-01f, -3.68047953e-01f, 1.99608967e-01f, -2.52421558e-01f,
  8.96785930e-02f, 2.20313758e-01f, -1.25779927e-01f, 2.62470305e-01f, -1.09484121e-01f, 2.14215647e-03f, 2.32097339e-02f, 2.69238860e-03f, -1.11138530e-01f, 2.01848462e-01f,
  -1.51238069e-01f, 2.17967212e-01f, -8.38234350e-02f, -4.92816977e-02f, -6.41740635e-02f, 9.29748341e-02f, 5.65753691e-02f, -2.20297396e-01f, -1.81143284e-02f, -1.66867867e-01f,
  1.68144912e-01f, -8.00386816e-02f, -9.13703628e-03f, -2.45937154e-01f, -1.62212104e-01f, -4.99002263e-02f, 5.44297844e-02f, -6.90206438e-02f, -3.14163864e-02f, 7.34455278e-03f,
  2.04603866e-01f, 1.27898201e-01f, 4.03336108e-01f, -4.57856596e-01f, 2.22089142e-01f, 3.73725832e-01f, 9.74365547e-02f, 1.20273419e-01f, 3.49008292e-01f, 1.32723719e-01f,
  1.60842657e-01f, -1.87281687e-02f, 1.87618226e-01f, 1.74445525e-01f, -1.35588154e-01f, 1.04607843e-01f, -1.91550374e-01f, 2.89548159e-01f, 1.34734705e-01f, 2.83444554e-01f,
  2.14864984e-01f, 3.21110338e-01f, 1.04962058e-01f, 6.07216209e-02f, 1.73950523e-01f, -4.05149981e-02f, 2.81928837e-01f, 1.56697586e-01f, -4.80777472e-02f, 2.60861754e-01f,
  2.50539660e-01f, -3.80754650e-01f, 1.65592507e-01f, 1.23481667e-02f, 1.61404312e-01f, -3.10663432e-01f, 1.10992856e-01f, 3.49055618e-01f, -1.49819791e-01f, -1.92453563e-01f,
  5.76789714e-02f, -1.27066700e-02f, 7.86135420e-02f, -4.10318762e-01f, 2.30127946e-01f, -2.49554113e-01f, 6.47113100e-02f, 2.45638371e-01f, 6.15161620e-02f, 1.75526552e-02f,
  3.77006590e-01f, -1.28933340e-01f, -7.04320595e-02f, 2.40476087e-01f, -1.14315026e-01f, -8.26900266e-03f, 3.17796350e-01f, -1.58632651e-01f, 1.42960057e-01f, 2.32117429e-01f,
  2.36664563e-01f, -3.75635684e-01f, -3.95579636e-01f, -1.57710597e-01f, -2.25909919e-01f, 2.38714479e-02f, 1.93932816e-01f, -1.67914420e-01f, 5.01618803e-01f, 3.56031209e-02f,
  -1.12298420e-02f, 1.65025190e-01f, -1.83485970e-01f, 3.30891635e-04f, 1.40881270e-01f, 9.98588279e-02f, -1.14866778e-01f, 4.54532467e-02f, 1.83711275e-01f, 1.23600572e-01f,
  6.67828619e-02f, -8.75291228e-02f, -1.97434742e-02f, 1.84672773e-01f, -1.44506302e-02f, 2.49427304e-01f, 6.78105056e-02f, 1.57561809e-01f, 3.90363298e-02f, 4.04390097e-02f,
  1.86178610e-01f, 2.27901995e-01f, -8.14148933e-02f, 1.00555038e-02f, 8.85867253e-02f, -2.92816669e-01f, -1.55959398e-01f, -3.56765777e-01f, 1.32075727e-01f, -1.48865312e-01f,
  5.63837849e-02f, -1.34818166e-01f, 2.12410316e-01f, -1.04301274e-01f, -6.40630722e-02f, -1.35121495e-01f, 5.60084470e-02f, 4.84903157e-02f, 2.17869341e-01f, 2.10813135e-01f,
  -2.48844236e-01f, 2.17331007e-01f, -1.25808120e-01f, 8.69555846e-02f, 3.55488896e-01f, 2.53940552e-01f, -2.16204107e-01f, 7.83985555e-02f, 2.35559031e-01f, 1.63511679e-01f,
  1.30173238e-03f, -2.61007398e-01f, -2.27903146e-02f, 8.25647563e-02f, -6.15019575e-02f, 9.79022458e-02f, -8.56785700e-02f, 1.76928893e-01f, -2.81174302e-01f, -1.07460685e-01f,
  1.01868622e-01f, -4.44820821e-01f, 2.36130491e-01f, -8.34508613e-03f, -9.26984996e-02f, -3.16524506e-02f, -1.89138517e-01f, -6.27919585e-02f, 1.37314066e-01f, 4.93554100e-02f,
  -8.76309946e-02f, 1.76014602e-01f, 4.20041662e-03f, 6.13173433e-02f, -5.89512214e-02f, -2.60293726e-02f, 5.26874997e-02f, 7.36292545e-03f, -2.38160118e-02f, 1.47291645e-01f,
  -7.92745277e-02f, -5.97444363e-02f, 1.14899918e-01f, -2.01796323e-01f, 2.20753197e-02f, -3.85649595e-03f, 4.18933369e-02f, 1.01090431e-01f, 1.38154566e-01f, -8.31960887e-02f,
  5.30737415e-02f, -1.63159087e-01f, 5.47133982e-02f, -8.22641999e-02f, 6.34126067e-02f, 1.48428828e-01f, -9.16452557e-02f, -7.32394606e-02f, 3.64307240e-02f, 5.43531775e-02f,
  -1.43679559e-01f, -5.36219822e-03f, 1.28018320e-01f, 1.28101990e-01f, -2.21988466e-02f, -2.96902526e-02f, -8.59644711e-02f, -6.77213818e-02f, 2.30786558e-02f, 1.21312834e-01f,
  -4.87871431e-02f, -1.91652283e-01f, -4.74086255e-02f, 9.09245387e-03f, -9.20171961e-02f, -3.69293869e-01f, 2.03829736e-01f, 1.59955546e-01f, 8.34540427e-02f, 2.24162772e-01f,
  3.21738124e-01f, 1.19077660e-01f, 4.76262085e-02f, 2.36201938e-02f, 2.69635003e-02f, -3.35960060e-01f, 3.98787677e-01f, -6.31362647e-02f, 6.56490996e-02f, 2.05523260e-02f,
  -7.63751343e-02f, 6.82765096e-02f, 1.61836043e-01f, 2.23575085e-02f, -7.56129771e-02f, 2.99872104e-02f, 2.52315581e-01f, -1.01159597e-02f, -8.52069817e-03f, 9.87053886e-02f,
  -9.86976922e-02f, 6.58321008e-02f, 1.28361091e-01f, -1.91202648e-02f, 1.40805826e-01f, 2.12794542e-03f, 2.68043913e-02f, 1.75757870e-01f, 8.73029828e-02f, 9.55770463e-02f,
  1.83723822e-01f, 1.38701469e-01f, 1.82815239e-01f, -3.65482271e-02f, -1.10884488e-01f, 1.46636456e-01f, 1.23780901e-02f, -4.19141650e-02f, -2.53883842e-02f, 1.56319395e-01f,
  -1.07412353e-01f, 2.27653444e-01f, 4.99682762e-02f, 9.85932499e-02f, -1.00222811e-01f, -1.78434610e-01f, 1.02638662e-01f, 1.51891401e-02f, 3.85457166e-02f, -1.35624092e-02f,
  1.70447588e-01f, -6.17700927e-02f, -1.05408140e-01f, -2.86847949e-02f, 5.14983274e-02f, -4.14437475e-03f, -1.41812786e-01f, -1.08132489e-01f, 1.78253502e-01f, 3.19975346e-01f,
  3.69482696e-01f, 2.89323986e-01f, 3.33209366e-01f, 1.70556232e-01f, 1.36588756e-02f, 7.38735721e-02f, -2.73570448e-01f, 2.78235435e-01f, -6.34152489e-03f, 1.01639375e-01f,
  7.16609806e-02f, -2.16901511e-01f, 1.54833287e-01f, 1.72921389e-01f, -5.61766401e-02f, -2.00236328e-02f, -8.33372399e-02f, 1.64668828e-01f, 2.91342437e-01f, -3.08533967e-03f,
  -3.53386141e-02f, 8.70925784e-02f, 3.40728015e-02f, 6.71335086e-02f, 8.98141265e-02f, 2.26936623e-01f, 7.99075365e-02f, 4.39832211e-02f, 3.62027064e-02f, -5.41913621e-02f,
  -4.58126748e-03f, 1.55662760e-01f, 2.23123492e-03f, -1.03741623e-01f, 2.35149592e-01f, 1.47845879e-01f, -4.74746339e-02f, 5.00303805e-01f, -1.42817730e-02f, -1.07986219e-01f,
  -1.60699293e-01f, -4.63603586e-01f, 1.14689566e-01f, -2.04375505e-01f, -8.59379023e-03f, 9.52546149e-02f, -1.68068796e-01f, 8.50530416e-02f, 1.66906476e-01f, -1.72907814e-01f,
  3.19650799e-01f, 5.37648937e-03f, -2.07230479e-01f, -1.79580212e-01f, 2.82703370e-01f, 5.90674728e-02f, -1.58674762e-01f, 4.85099196e-01f, -1.22152939e-01f, 3.39587405e-02f,
  1.49333224e-01f, 2.71785378e-01f, -3.94986063e-01f, 1.70057341e-01f, 3.15589994e-01f, -7.32011572e-02f, 1.28670603e-01f, -2.01956239e-02f, -3.55834588e-02f, 2.02111483e-01f,
  -3.34219217e-01f, -1.76998779e-01f, 5.10820866e-01f, -5.66434450e-02f, -2.59451300e-01f, 6.27217516e-02f, 1.70474708e-01f, 2.45422274e-01f, 1.58543587e-01f, -6.36977097e-03f,
  1.15300275e-01f, 1.13531686e-01f, 4.99256849e-02f, 1.09675728e-01f, -4.83613387e-02f, -4.50799540e-02f, 1.96429044e-01f, 2.12910011e-01f, 3.79143730e-02f, 1.43752307e-01f,
  3.18530619e-01f, 8.96752402e-02f, -6.23121411e-02f, 9.29895267e-02f, 2.27109715e-01f, 8.95039923e-03f, 3.52696180e-01f, -3.14903073e-02f, 8.05877745e-02f, 4.04546894e-02f,
  1.14358813e-02f, 1.22440308e-01f, 8.77366886e-02f, 2.59160280e-01f, 8.57136399e-03f, -1.33512929e-01f, 4.32440033e-03f, 2.61972457e-01f, 1.39358908e-01f, -3.69501263e-02f,
  5.28018661e-02f, 9.00400057e-02f, 2.00497489e-02f, -7.40394071e-02f, -1.20330006e-02f, 7.29044713e-03f, 1.30534634e-01f, 2.85618305e-02f, -1.10372849e-01f, -2.65416689e-02f,
  -9.08418298e-02f, -1.90522313e-01f, 2.16720905e-02f, 2.99041957e-01f, -2.74532408e-01f, -7.84028918e-02f, 4.99283791e-01f, 3.83055747e-01f, -9.97670591e-02f, 2.70554215e-01f,
  1.44535780e-01f, -3.14110518e-01f, -1.69525757e-01f, 5.02056489e-03f, 3.66947711e-01f, 4.22275513e-01f, -2.79521674e-01f, 2.37797663e-01f, 1.25216976e-01f, 4.05430943e-01f,
  -1.58517566e-02f, 1.42870769e-01f, -1.30836278e-01f, 1.04567960e-01f, -2.26422418e-02f, 1.08105522e-02f, 7.08338693e-02f, 2.81396639e-02f, 1.03993677e-01f, 3.44327949e-02f,
  -1.19898200e-01f, 1.55451357e-01f, 1.90059528e-01f, -2.81913541e-02f, 6.01206198e-02f, 7.44351596e-02f, -5.13312407e-02f, 2.01999545e-01f, 7.73971379e-02f, -4.80522700e-02f,
  6.28603697e-02f, 3.95482592e-02f, 1.86326951e-01f, 9.06227827e-02f, 1.85340896e-01f, -2.27436304e-01f, 1.09037131e-01f, -7.25921839e-02f, 1.33052304e-01f, -3.60367894e-01f,
  -1.88018158e-02f, -2.76617646e-01f, 1.77521840e-01f, -5.19293454e-03f, -1.08468913e-01f, 6.23412207e-02f, -3.77440527e-02f, 5.86157292e-02f, 2.33487859e-01f, 9.45488513e-02f,
  8.24297294e-02f, 2.05066130e-02f, -4.79592718e-02f, 1.70835614e-01f, 3.32818270e-01f, 5.83087802e-01f, 2.52901353e-02f, 2.07702756e-01f, 6.90661296e-02f, 1.82144687e-01f,
  2.74247289e-01f, -1.44499131e-02f, 2.38769531e-01f, -7.15378374e-02f, -3.66485044e-02f, -1.67293385e-01f, -7.60111809e-02f, 8.28298703e-02f, -5.90903908e-02f, -3.58910024e-01f,
  4.34553266e-01f, -2.12923497e-01f, 2.91474134e-01f, 3.44684790e-03f, -1.58045620e-01f, 1.61414947e-02f, -9.47752222e-02f, 1.12862159e-02f, 7.73259029e-02f, -6.07156754e-02f,
  -1.52208239e-01f, 8.96975696e-02f, 3.26910801e-02f, 1.14421025e-01f, 1.04488090e-01f, -1.63658097e-01f, -1.35173993e-02f, 2.78369803e-03f, -9.47357342e-03f, 1.01745978e-01f,
  7.66555145e-02f, -3.55379060e-02f, 3.17626968e-02f, 4.43978906e-02f, -9.30172503e-02f, 2.82315779e-02f, -6.92338049e-02f, -7.56952539e-02f, -1.81397676e-01f, 2.70994790e-02f,
  -5.93611784e-02f, -3.14305872e-02f, 9.14067701e-02f, 2.06920549e-01f, -3.49105038e-02f, 9.39762592e-02f, -5.42333387e-02f, -3.10083143e-02f, 4.80931625e-02f, 6.37073517e-02f,
  -4.47229892e-02f, 9.94610116e-02f, -2.24314928e-01f, -8.06351155e-02f, -5.64643669e-05f, -2.67350879e-02f, 2.42906153e-01f, 1.31082878e-01f, -1.84790924e-01f, -3.74397129e-01f,
  4.45350818e-02f, -8.33458304e-02f, 1.57734022e-01f, -1.34508833e-01f, -3.17199409e-01f, 1.55717462e-01f, -6.75804242e-02f, 2.97120959e-02f, 3.26061338e-01f, 6.22585155e-02f,
  -1.04062418e-02f, 2.24430338e-01f, -3.93918678e-02f, 1.54367611e-02f, 1.49484724e-01f, 5.27190387e-01f, -2.84780692e-02f, 1.51652381e-01f, 1.72736067e-02f, 8.96185637e-02f,
  8.12629685e-02f, 3.99473263e-03f, 5.31027503e-02f, 1.57016665e-01f, 1.10297166e-01f, 1.21968552e-01f, 4.63488288e-02f, -3.07384450e-02f, 1.58619955e-01f, -6.98738992e-02f,
  -1.87918562e-02f, -2.08346359e-02f, 3.56966071e-02f, -6.49005100e-02f, -3.98789626e-03f, 7.55543262e-02f, 1.69026405e-01f, -1.57386549e-02f, 3.01028937e-01f, -4.55243513e-02f,
  6.14951178e-02f, -8.38912965e-04f, 7.72328526e-02f, 5.34492694e-02f, -7.73932412e-02f, 9.90607813e-02f, -1.92855462e-01f, 1.79834232e-01f, 7.24985749e-02f, 1.22683749e-01f,
  -1.28886029e-01f, 7.73572177e-02f, 3.49436849e-02f, 1.62540004e-01f, 1.40204653e-01f, 7.49844313e-02f, 7.52374679e-02f, 6.00089282e-02f, 9.93240625e-02f, -9.21245888e-02f,
  -3.37303355e-02f, -9.54279769e-03f, -2.69306451e-01f, 7.72443879e-03f, -4.86691520e-02f, -8.15110803e-02f, -7.39889070e-02f, 5.59967235e-02f, 8.73367935e-02f, 3.42570066e-01f,
  2.06452936e-01f, -2.07871534e-02f, -3.29294056e-01f, 1.44438475e-01f, -1.02505133e-01f, 3.77279460e-01f, 1.47931769e-01f, -4.28982228e-02f, -4.03785706e-01f, 2.87843108e-01f,
  -2.29652613e-01f, 5.90290315e-03f, 9.43328142e-02f, 7.33845308e-02f, 1.19160064e-01f, -7.01765344e-02f, 2.55271524e-01f, 3.44427745e-03f, 1.51730195e-01f, 1.37084022e-01f,
  9.38326865e-02f, 1.01750933e-01f, 5.10676876e-02f, 3.77942286e-02f, 1.50931373e-01f, 2.69002408e-01f, 1.27909645e-01f, 3.58363241e-02f, 5.26806153e-02f, 2.37055600e-01f,
  4.98823375e-02f, 9.10276249e-02f, 8.49262178e-02f, 1.04327478e-01f, 9.32555124e-02f, 2.31671050e-01f, 3.18354070e-01f, -1.38205737e-01f, -1.18138514e-01f, 3.84354234e-01f,
  4.72028665e-02f, -1.53338477e-01f, 2.06891075e-02f, 8.19685236e-02f, -9.31345075e-02f, 1.46358326e-01f, 8.44205990e-02f, 4.27825097e-03f, 2.25094128e-02f, 9.20858756e-02f,
  2.22434074e-01f, -1.02441281e-01f, 2.03801870e-01f, 9.31010544e-02f, -5.40173799e-02f, -4.98927943e-02f, 2.75339514e-01f, -1.60618126e-01f, -1.98356032e-01f, 2.83492301e-02f,
  -8.97208229e-02f, -9.79910642e-02f, 5.44843972e-01f, 3.58830318e-02f, 5.54025769e-01f, 1.53403595e-01f, -4.01386246e-02f, 1.78683951e-01f, 8.90317187e-03f, -3.67629856e-01f,
  -1.16734482e-01f, -1.18282571e-01f, -1.32710397e-01f, 2.42502183e-01f, 1.39334902e-01f, -4.06049341e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.29378396e-02f, 2.84293771e-01f, -1.61546707e-01f, -5.14977612e-03f, 1.02795623e-01f, 2.41130088e-02f, -3.61064076e-02f, 1.03659183e-01f, 9.43094268e-02f, 1.58306770e-02f,
  1.52251169e-01f, 4.27748784e-02f, 1.25003994e-01f, 2.55761802e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.01683807e-01f, -3.46623987e-01f, -1.99464262e-01f, 1.22240297e-01f, -7.70940334e-02f, -2.61405986e-02f, -4.70787399e-02f, 1.69214271e-02f, -3.13033760e-01f, -2.84446210e-01f,
  1.94721743e-01f, 6.60609975e-02f, 1.27998009e-01f, -1.42942533e-01f, 5.82649633e-02f, -1.46802619e-01f, 1.45143494e-01f, -1.00419663e-01f, -1.02311544e-01f, -1.30581051e-01f,
  -1.40405580e-01f, 5.59172891e-02f, 1.22617431e-01f, 1.69460937e-01f, -4.23019193e-02f, -9.50185657e-02f, -2.50929017e-02f, 2.03744143e-01f, -1.24680445e-01f, -1.77956056e-02f,
  -1.22615278e-01f, -1.69032544e-01f, -2.18340084e-02f, 1.00190617e-01f, -2.95241714e-01f, -6.27785176e-02f, -9.03471932e-02f, 1.69783935e-01f, 2.68071592e-01f, -5.19556850e-02f,
  -5.29269092e-02f, -8.82169157e-02f, 4.90047298e-02f, 9.00600329e-02f, 1.35557920e-01f, 1.14092447e-01f, -1.73012555e-01f, 9.81265157e-02f, -4.31989916e-02f, 1.49514927e-02f,
  -1.05879769e-01f, 1.44502833e-01f, -5.59215620e-02f, 4.01656255e-02f, 3.84416878e-02f, -6.31525815e-02f, -8.79907236e-02f, 1.79624408e-02f, 3.75486501e-02f, 2.48994574e-01f,
  -4.72385883e-02f, 1.26644280e-02f, 4.02292889e-03f, -2.36473471e-01f, 1.09017208e-01f, 3.91123332e-02f, -1.64514199e-01f, -9.21120420e-02f, 2.60517061e-01f, 1.48615107e-01f,
  1.00537445e-02f, -5.87176681e-02f, 8.83774087e-02f, -2.63074934e-02f, -3.15940887e-01f, -1.25022799e-01f, 8.97843838e-02f, 4.51193392e-01f, -2.43870378e-03f, 1.40508801e-01f,
  2.17651829e-01f, -3.77531014e-02f, -2.02504411e-01f, 2.93410290e-02f, -1.14915192e-01f, 2.95302905e-02f, -9.89601165e-02f, -6.74954578e-02f, -6.07388876e-02f, 3.64129186e-01f,
  -5.21515422e-02f, -9.82147008e-02f, -1.15823001e-01f, 1.63972840e-01f, -1.22951437e-02f, 2.97009647e-01f, -2.70495303e-02f, 8.05576444e-02f, -8.95840302e-02f, -1.33630782e-01f,
  6.54487684e-02f, -2.50952728e-02f, -4.31738287e-01f, 3.05245161e-01f, 1.01785716e-02f, 1.88079983e-01f, -2.78946534e-02f, -4.82021570e-02f, -1.60941705e-01f, 2.01095849e-01f,
  1.21020742e-01f, -1.85098425e-01f, -5.41637130e-02f, 9.22640115e-02f, -2.33052209e-01f, -2.13361949e-01f, 8.32340494e-02f, 1.47738039e-01f, -7.29158297e-02f, 1.12646341e-01f,
  2.62836814e-01f, 1.23416588e-01f, -1.94706142e-01f, -6.99754059e-02f, -9.92921442e-02f, 1.82143673e-01f, 4.94332239e-02f, 1.64523423e-01f, 1.68826908e-01f, -1.01957500e-01f,
  -3.28881711e-01f, 3.78866121e-02f, -2.85563786e-02f, 1.15477182e-01f, -1.48652911e-01f, 1.09396145e-01f, -1.01066820e-01f, 2.39262506e-01f, -7.01257214e-02f, 5.85807301e-02f,
  -1.36091560e-02f, 2.08421111e-01f, -1.50317907e-01f, 2.63506137e-02f, -3.97856049e-02f, -2.36531924e-02f, 7.04601184e-02f, -1.60151981e-02f, 1.96784344e-02f, 3.17583270e-02f,
  1.28656670e-01f, 1.43605411e-01f, -1.22913383e-01f, -1.11928701e-01f, 1.38919562e-01f, 1.92030847e-01f, -2.21553400e-01f, -2.60218292e-01f, -1.25913709e-01f, -1.74345851e-01f,
  1.21770851e-01f, -1.50754020e-01f, -1.06569966e-02f, -9.51047093e-02f, 1.40137032e-01f, -3.36908013e-01f, 1.09136797e-01f, 2.32389614e-01f, 4.46755923e-02f, 1.78374618e-01f,
  -2.79266596e-01f, 1.08298510e-01f, -4.35282625e-02f, -5.04080020e-02f, -9.25576761e-02f, 2.21340150e-01f, -1.31361768e-01f, -2.18655020e-01f, -2.74025202e-01f, 1.33675069e-01f,
  -1.69141769e-01f, 3.39809656e-02f, -2.08089530e-01f, 1.43825814e-01f, -1.58680379e-01f, 5.85227879e-03f, 8.77431780e-02f, 4.01791744e-03f, 2.14490026e-01f, -1.92302272e-01f,
  -7.80583397e-02f, -1.92316696e-01f, -1.27997369e-01f, -1.26034347e-02f, -2.15269580e-01f, -2.56578833e-01f, 6.29285201e-02f, 2.65740138e-03f, -2.44671963e-02f, 1.92314424e-02f,
  4.00466956e-02f, 1.38230085e-01f, 2.40466632e-02f, -1.97759628e-01f, -1.21171519e-01f, -1.32261023e-01f, -2.17967834e-02f, -1.40822589e-01f, 1.09977111e-01f, -3.68731081e-01f,
  -9.29248929e-02f, -1.02467917e-01f, 1.43776706e-03f, -2.37468779e-01f, -1.95029333e-01f, 1.81741357e-01f, -3.33216786e-02f, -2.39336610e-01f, -2.09301244e-02f, 5.22264361e-01f,
  -2.73278683e-01f, -5.09569533e-02f, -1.88014835e-01f, -5.89853227e-02f, -1.83344241e-02f, -1.06465347e-01f, -7.58559257e-02f, 8.83275568e-02f, -5.61498292e-02f, -1.10361278e-01f,
  2.58360028e-01f, -2.15767875e-01f, -1.36200249e-01f, 2.43392102e-02f, 5.93689233e-02f, -1.48446679e-01f, 1.85691595e-01f, -9.43734273e-02f, -4.41596121e-01f, 5.49173169e-02f,
  -1.01917438e-01f, 4.46177311e-02f, -8.91447589e-02f, 4.23368923e-02f, 3.20210792e-02f, 3.24275568e-02f, -1.04628898e-01f, -4.96774763e-02f, -1.00151472e-01f, 1.15013786e-01f,
  1.65859517e-02f, 6.67081326e-02f, -1.08495310e-01f, 2.27193013e-01f, 9.81965363e-02f, -1.34654939e-01f, 1.46916494e-01f, -1.58533081e-02f, 9.10206810e-02f, 1.48645520e-01f,
  9.27503109e-02f, 2.90056784e-02f, 5.17400429e-02f, 4.00864147e-02f, -2.15790514e-02f, 6.29231855e-02f, -2.27166936e-01f, -4.76588048e-02f, 6.68932572e-02f, 2.21982598e-01f,
  1.07379459e-01f, 3.68487269e-01f, 1.73002169e-01f, -9.44805071e-02f, 4.86274920e-02f, 2.25272611e-01f, -2.66090054e-02f, 2.40864307e-01f, 1.91201329e-01f, -1.62115350e-01f,
  -1.21155657e-01f, 4.82836306e-01f, -1.92513783e-03f, -3.34304750e-01f, -2.87777893e-02f, 1.73230842e-01f, -1.81890905e-01f, 8.08426514e-02f, 2.04129323e-01f, -1.03322998e-01f,
  1.99079346e-02f, 8.37081522e-02f, 1.59794703e-01f, -9.04493593e-03f, -4.91229981e-01f, 8.09544027e-02f, -1.27987593e-01f, 1.52680144e-01f, 2.40252107e-01f, 3.65347378e-02f,
  -2.76524723e-01f, 1.96686089e-01f, -6.66712821e-02f, -1.55233229e-02f, -6.08523451e-02f, 4.14286777e-02f, -2.74997987e-02f, -1.04887918e-01f, -9.82775986e-02f, -2.43001450e-02f,
  5.21326847e-02f, -2.30637640e-02f, -1.22027494e-01f, -4.51451018e-02f, -1.89633727e-01f, 2.48547643e-01f, -2.05727562e-01f, -2.45113969e-01f, -3.58722098e-02f, 7.91589469e-02f,
  2.08012849e-01f, -1.31253615e-01f, 4.69170697e-02f, -2.81149894e-01f, 8.81256815e-03f, 7.71584339e-04f, 9.93404314e-02f, 1.45731205e-02f, 2.30948299e-01f, -3.85910273e-02f,
  2.10530281e-01f, -2.15899921e-03f, -2.71852225e-01f, 1.36092633e-01f, -1.08380392e-01f, -1.83317825e-01f, -2.36297920e-02f, -2.13739932e-01f, 9.36000794e-02f, 1.05288558e-01f,
  4.57721800e-02f, 7.04512373e-02f, 5.65333292e-03f, 4.92075831e-02f, 3.63326818e-01f, -5.58705963e-02f, -2.79220730e-01f, -5.08965328e-02f, 1.99516460e-01f, -7.64017850e-02f,
  1.04210310e-01f, -1.25161812e-01f, 3.20729882e-01f, 1.41667694e-01f, 6.38322458e-02f, 1.66015372e-01f, -2.04701141e-01f, -1.43387794e-01f, 6.86574653e-02f, -1.59013972e-01f,
  -9.92395654e-02f, -7.84503594e-02f, -5.47651993e-03f, 7.40453750e-02f, -1.18221365e-01f, -1.59085751e-01f, -1.59226414e-02f, 1.13247946e-01f, 1.05014041e-01f, -1.67258903e-01f,
  -5.86933158e-02f, -2.34637633e-01f, -6.05553426e-02f, -1.29589483e-01f, -2.59491086e-01f, 5.30419946e-02f, 9.13911685e-02f, 1.63178500e-02f, 2.71249920e-01f, 1.43168166e-01f,
  1.79706458e-02f, -2.61404067e-02f, 3.63714159e-01f, -1.98666155e-01f, 5.26857190e-02f, -1.26264468e-01f, 2.90870816e-01f, -9.27100182e-02f, 8.18717852e-02f, 1.97412536e-01f,
  9.18736234e-02f, 8.22767615e-02f, 1.57271653e-01f, 2.20106691e-02f, 1.13823954e-02f, 4.61863913e-02f, -1.17724776e-01f, 2.32274439e-02f, -3.31314862e-01f, 1.77075893e-01f,
  6.31141067e-02f, -3.24098051e-01f, 3.33704472e-01f, -3.96293886e-02f, -1.11525461e-01f, -1.05995394e-01f, -1.74682721e-01f, -5.81859872e-02f, 1.94288075e-01f, -4.71765064e-02f,
  -1.57600846e-02f, -2.41369139e-02f, -1.03282697e-01f, 1.33312911e-01f, 7.68735446e-03f, 2.57137865e-01f, -1.24122374e-01f, 7.32726604e-02f, 4.01394367e-02f, -6.99150413e-02f,
  1.00389294e-01f, -2.50584483e-01f, -1.29765272e-01f, 1.73065618e-01f, 3.40719253e-01f, 5.03782555e-02f, -1.02836847e-01f, 1.18662238e-01f, 7.29613155e-02f, -1.56012371e-01f,
  1.98705360e-01f, -1.54148579e-01f, 2.59345807e-02f, -2.23451648e-02f, -8.10711607e-02f, -6.86361408e-03f, 6.89055994e-02f, 1.98109016e-01f, -1.31661281e-01f, 1.00112647e-01f,
  1.93292111e-01f, 9.57748517e-02f, 5.23816124e-02f, -2.55507261e-01f, 1.50722876e-01f, -1.66898519e-01f, -5.22411503e-02f, 3.10245957e-02f, 9.00411606e-02f, -2.33532884e-03f,
  5.61213866e-02f, -5.72998151e-02f, 1.14424400e-01f, 5.90077974e-03f, -1.18040167e-01f, 3.72660719e-02f, -2.07419433e-02f, -1.31868616e-01f, 1.54744476e-01f, -8.12889338e-02f,
  8.19910131e-03f, 1.00405691e-02f, 3.43601145e-02f, 5.92897786e-03f, 2.53840648e-02f, 1.94170773e-01f, -1.50037274e-01f, 2.53352702e-01f, 7.81441703e-02f, 9.27049294e-02f,
  3.99099700e-02f, -1.46185920e-01f, -3.62220407e-02f, -4.42932010e-01f, 4.92402315e-02f, -4.31069225e-01f, 2.05336303e-01f, -8.50121453e-02f, 2.53342241e-01f, -9.66797248e-02f,
  -4.61008288e-02f, -1.71111003e-02f, 1.73099469e-02f, -9.67996120e-02f, 1.20749369e-01f, 7.64537603e-02f, -1.93628654e-01f, 7.92224407e-02f, 9.73771065e-02f, 1.76075920e-01f,
  2.30807122e-02f, -2.90037356e-02f, -1.67624041e-01f, -3.82342227e-02f, -1.82471871e-01f, -1.88434333e-01f, -3.74475680e-02f, -1.69790819e-01f, -7.29399547e-02f, 8.32991004e-02f,
  -2.24235788e-01f, 4.98202965e-02f, -8.33590180e-02f, 1.79674685e-01f, 1.62947580e-01f, -1.74943149e-01f, 1.02077715e-01f, -2.24504173e-01f, -1.38680011e-01f, 1.40953222e-02f,
  1.16979934e-01f, -1.60678074e-01f, -2.02194229e-02f, -3.12696546e-01f, 4.80199605e-03f, 7.51027092e-02f, -3.59775610e-02f, 2.77213454e-01f, 1.23163015e-02f, 2.24271372e-01f,
  -1.77345231e-01f, 3.62233818e-03f, 1.65870667e-01f, 1.34004951e-01f, 1.00730337e-01f, 8.48058835e-02f, -6.83290064e-02f, -1.19891029e-03f, -6.96481094e-02f, 9.66877788e-02f,
  2.77209997e-01f, 7.61265531e-02f, -1.94308817e-01f, 3.18921506e-01f, 1.19468853e-01f, 1.70673981e-01f, 1.60563335e-01f, -7.13317394e-02f, 1.48429066e-01f, -9.87851396e-02f,
  1.35413229e-01f, -4.15665656e-03f, 8.20236467e-03f, -2.91738778e-01f, 4.88261394e-02f, -1.12308934e-02f, 1.19764611e-01f, -6.58404604e-02f, -4.05879840e-02f, -3.05263847e-01f,
  5.95912822e-02f, 2.43207008e-01f, 2.61985464e-03f, 1.10394910e-01f, 2.57623702e-01f, -2.07251877e-01f, -1.25051722e-01f, -3.52079242e-01f, 1.93762109e-02f, -2.70841178e-02f,
  9.68421176e-02f, -1.23351112e-01f, 8.92104283e-02f, 4.66941632e-02f, 2.30600256e-02f, -4.68675941e-02f, -7.21725151e-02f, 1.01305366e-01f, -1.07630573e-01f, 1.35634551e-02f,
  2.06406787e-01f, 4.50769588e-02f, -3.64429243e-02f, -8.22910666e-02f, 1.79834798e-01f, 7.77414292e-02f, 3.66127715e-02f, 1.72130749e-01f, 8.65622684e-02f, -1.43546769e-02f,
  1.24352694e-01f, 2.13685095e-01f, 1.07788533e-01f, 2.40299463e-01f, 1.09437957e-01f, 2.92197224e-02f, -9.56947580e-02f, -5.88869750e-02f, 1.27643630e-01f, -5.95255643e-02f,
  1.08432092e-01f, -2.39157816e-03f, -1.23938672e-01f, -3.39065269e-02f, 2.50777155e-01f, 1.48398295e-01f, -7.17704445e-02f, 1.24386489e-01f, 2.20361635e-01f, -1.13026649e-01f,
  1.00361314e-02f, -5.69400638e-02f, 1.57057673e-01f, -2.60523230e-01f, 8.34776387e-02f, -3.18211704e-01f, 1.57490484e-02f, 6.98748082e-02f, -3.13538648e-02f, -1.49138927e-01f,
  1.83664054e-01f, 6.68994933e-02f, -5.39722992e-03f, -3.59349191e-01f, 5.89004271e-02f, 1.42869070e-01f, -4.91662621e-02f, 9.65603888e-02f, -1.48368686e-01f, -2.09247515e-01f,
  2.10626855e-01f, -2.12551594e-01f, 1.29431739e-01f, -5.15289232e-02f, 4.13507111e-02f, 1.50991753e-01f, -6.25396818e-02f, -1.01782739e-01f, -1.00789368e-01f, -9.07005370e-02f,
  -5.86329140e-02f, 2.58206069e-01f, 2.00424969e-01f, -2.88387071e-07f, 3.09440732e-01f, -9.94390175e-02f, 1.15810320e-01f, -8.13666172e-03f, -1.38862833e-01f, -2.60133133e-03f,
  1.05563939e-01f, -8.27143788e-02f, 3.69978547e-02f, 8.87093991e-02f, -3.96450758e-02f, -9.47413892e-02f, -1.16499774e-01f, -1.32141888e-01f, -1.25913560e-01f, -1.21476613e-01f,
  -1.31962985e-01f, -5.13531677e-02f, 6.87506795e-03f, -1.44601375e-01f, 2.10703745e-01f, 3.69768962e-02f, -2.31772304e-01f, 3.76584709e-01f, 1.27323061e-01f, 4.33635041e-02f,
  -1.09654054e-01f, 9.46903974e-02f, 2.43148990e-02f, -2.38819703e-01f, -1.35576352e-01f, 1.40264407e-01f, -7.60571957e-02f, -3.08998346e-01f, 2.79600263e-01f, 2.00364664e-01f,
  1.51927710e-01f, 1.70960337e-01f, -2.43899948e-03f, 1.22180454e-01f, 4.04761434e-02f, -2.71468520e-01f, 4.50353213e-02f, 9.71477181e-02f, 2.35030241e-02f, 3.01050156e-01f,
  1.38782665e-01f, -2.06891939e-01f, 2.07505658e-01f, -1.06837273e-01f, -2.61247396e-01f, -1.76216349e-01f, 3.86815131e-01f, -8.98713171e-02f, 1.51526496e-01f, 4.82325740e-02f,
  2.44469553e-01f, -6.04730062e-02f, 3.94529226e-04f, -1.44285351e-01f, 1.02514245e-01f, 1.00334592e-01f, 1.46551281e-01f, 1.36354655e-01f, 1.02155529e-01f, -9.78194848e-02f,
  8.04374963e-02f, -1.11522555e-01f, 2.04149872e-01f, 9.54188332e-02f, 3.52428108e-01f, 3.47719640e-01f, -1.97015300e-01f, -1.83833823e-01f, 3.54849786e-01f, -1.25544235e-01f,
  -1.16021149e-01f, 6.06860071e-02f, 7.43973181e-02f, 4.33817774e-01f, -9.47266519e-02f, -5.05174920e-02f, -5.23539223e-02f, 2.77933955e-01f, 1.26841322e-01f, -9.36775133e-02f,
  6.17605522e-02f, -3.02684512e-02f, 1.38644636e-01f, 7.49331433e-03f, 1.94072887e-01f, 1.43146008e-01f, -8.54279548e-02f, -8.87723546e-03f, -8.88700932e-02f, 2.66105741e-01f,
  1.10595904e-01f, -2.32687116e-01f, 2.08386153e-01f, -1.20773993e-01f, -1.23776436e-01f, 7.97286406e-02f, 1.29923820e-01f, -1.76814869e-01f, -2.74083484e-02f, 2.28811875e-01f,
  7.37500703e-03f, 1.16131395e-01f, -1.89241409e-01f, 2.31101245e-01f, 1.56818181e-01f, 1.15877077e-01f, 1.29809365e-01f, 2.68670022e-01f, 7.58771896e-02f, 3.42099778e-02f,
  2.30157807e-01f, -1.28236562e-01f, 3.95075865e-02f, -1.44404531e-01f, -1.41413122e-01f, -6.69921115e-02f, -2.55934447e-01f, -2.04760551e-01f, 1.50802890e-02f, 2.50325143e-01f,
  2.49970686e-02f, 5.22243306e-02f, 9.72982869e-02f, -1.43002020e-02f, 9.45986360e-02f, 6.85026422e-02f, -4.77047339e-02f, 4.27502133e-02f, 1.23619046e-02f, 1.21916682e-01f,
  -6.82843700e-02f, -1.02503739e-01f, -3.19795087e-02f, 3.25391674e-03f, -1.27280988e-02f, -5.33591546e-02f, 9.10117477e-02f, 1.41447842e-01f, -1.78937409e-02f, -8.80875885e-02f,
  7.48934317e-03f, 1.18893810e-01f, 1.17433608e-01f, -1.37855813e-01f, 2.07796603e-01f, -1.01671994e-01f, -2.23371893e-01f, 2.43428752e-01f, 1.08695127e-01f, 5.85266165e-02f,
  -2.16465950e-01f, 1.84222329e-02f, -6.03133589e-02f, 4.74399537e-01f, -2.13137925e-01f, 2.06237093e-01f, -1.14931844e-01f, 2.01875925e-01f, -1.47065790e-02f, 1.83402240e-01f,
  -2.11591669e-03f, 5.54531477e-02f, 3.93322229e-01f, 1.86765730e-01f, 1.07611855e-02f, -6.71063811e-02f, -2.66802818e-01f, 8.39484110e-02f, -4.91843447e-02f, -1.09573804e-01f,
  -1.95042808e-02f, 5.08769304e-02f, -2.74206735e-02f, -3.47116292e-02f, 5.66610396e-02f, 9.04787481e-02f, 3.07580247e-03f, -1.46581784e-01f, 1.68669999e-01f, -8.44657570e-02f,
  2.13151082e-01f, -1.35386273e-01f, -2.85589229e-02f, -1.66769195e-02f, -3.41825992e-01f, 1.69120163e-01f, -4.61403728e-02f, -4.64390218e-02f, -6.96443170e-02f, -6.88233376e-02f,
  -4.40819236e-03f, 2.31181264e-01f, -2.41611928e-01f, -1.51549339e-01f, 3.55254859e-03f, -3.78280059e-02f, -9.19116214e-02f, 2.79642008e-02f, 1.93337575e-02f, -7.13283494e-02f,
  -2.39668023e-02f, 1.64288599e-02f, -1.37437835e-01f, -1.43693045e-01f, -1.17656201e-01f, -2.62233078e-01f, 2.26663053e-02f, 2.81278491e-02f, 2.04877388e-02f, 2.79893354e-02f,
  -1.59918264e-01f, -1.48591951e-01f, -2.31798157e-01f, -1.31171063e-01f, 1.98320355e-02f, 1.54671833e-01f, 4.20782492e-02f, -1.81972682e-01f, -4.05578241e-02f, -1.17869258e-01f,
  -6.46918043e-02f, 1.02449037e-01f, -4.47900742e-02f, -1.39399692e-01f, -9.68323648e-02f, 9.29969177e-02f, 1.77463889e-01f, -1.18959069e-01f, -4.16626148e-02f, -1.51203498e-01f,
  1.21096440e-01f, -2.66242772e-01f, -1.51035205e-01f, -4.08258915e-01f, 1.02341548e-01f, -2.21006513e-01f, 7.77233616e-02f, -2.43847206e-01f, -2.34709308e-01f, 3.57638821e-02f,
  2.19266172e-02f, 8.17173570e-02f, 9.17285830e-02f, -2.36245058e-02f, 2.74295032e-01f, 7.89152160e-02f, 3.22768837e-02f, -2.31667161e-01f, -7.46779144e-03f, 1.40899673e-01f,
  -3.92616019e-02f, 4.53951322e-02f, -1.67391941e-01f, 1.10019758e-01f, -1.12487517e-01f, 1.18254118e-01f, 1.83158040e-01f, 3.98224518e-02f, 2.62888558e-02f, -1.32398412e-01f,
  8.70354325e-02f, 3.62959094e-02f, -1.96780071e-01f, -4.33227345e-02f, -9.94902551e-02f, 1.21588580e-01f, 1.06802516e-01f, -2.14351982e-01f, 9.47568864e-02f, 6.56001642e-03f,
  1.85464054e-01f, -2.49696106e-01f, 2.55718708e-01f, -2.95903645e-02f, -3.35643679e-01f, -6.80599958e-02f, -1.24658801e-01f, 1.41397506e-01f, -3.27165145e-03f, 2.17457220e-01f,
  -1.14530697e-01f, -1.23125397e-01f, -1.18234351e-01f, -1.39749320e-02f, -2.96985433e-02f, -1.16118819e-01f, -1.14853963e-01f, -7.38405585e-02f, 4.92900200e-02f, -1.05133340e-01f,
  1.30212814e-01f, -8.99541825e-02f, -1.04501642e-01f, -2.40592182e-01f, 1.16790965e-01f, -4.13147174e-02f, -1.65082067e-01f, -1.74153790e-01f, 1.76476523e-01f, 1.19110513e-02f,
  -1.81895763e-01f, -2.59181023e-01f, -1.35413572e-01f, 2.59990841e-01f, 7.75667652e-02f, -3.42249982e-02f, -2.72828098e-02f, 3.57573330e-02f, 3.42374295e-03f, -1.61427855e-01f,
  -1.90593302e-01f, -8.61818716e-02f, -1.57498848e-02f, -3.08353491e-02f, 1.92831308e-02f, 2.01202128e-02f, -1.36307985e-01f, 8.40674415e-02f, 2.98218131e-01f, -1.45725489e-01f,
  7.77762905e-02f, -3.65592279e-02f, 2.68103421e-01f, 8.95979255e-02f, 8.95198509e-02f, -9.82184261e-02f, 1.09278277e-01f, -5.85189015e-02f, 1.05065316e-01f, -1.06791511e-01f,
  -7.57890940e-02f, -2.01639354e-01f, -2.72338241e-01f, -2.12326139e-01f, -4.76320572e-02f, -1.61442116e-01f, -1.77839041e-01f, 8.17931816e-02f, 4.25090753e-02f, -7.04826415e-02f,
  -1.08986683e-01f, -1.10690547e-02f, -1.84671253e-01f, -2.53711283e-01f, -3.13665830e-02f, 1.43112719e-01f, -1.81972057e-01f, 2.78588772e-01f, 1.55404940e-01f, -3.39487046e-02f,
  2.09742635e-01f, -5.00221588e-02f, 1.43178448e-01f, 5.37397489e-02f, -2.95999408e-01f, 2.21508015e-02f, -3.31985503e-01f, -1.28493637e-01f, 2.45350599e-01f, -3.69306028e-01f,
  -4.24906472e-03f, 1.13833971e-01f, 1.16182037e-01f, 1.12926260e-01f, -2.12913640e-02f, 1.39830187e-01f, 1.65421739e-01f, 4.03007530e-02f, 4.11278829e-02f, -1.17606156e-01f,
  8.06842670e-02f, -1.59016147e-01f, 6.71769157e-02f, -2.08330125e-01f, 6.38829172e-02f, 9.29523259e-02f, 1.40964001e-01f, 1.70983989e-02f, 1.34592997e-02f, 1.06926076e-01f,
  -1.51186660e-01f, 3.07510812e-02f, 2.03207269e-01f, 1.47962645e-01f, -4.01310921e-02f, -8.33778828e-03f, 4.36130971e-01f, 1.07549801e-01f, -5.03634959e-02f, -1.13768972e-01f,
  7.37510175e-02f, -6.47919113e-03f, 2.86485478e-02f, -9.82658099e-03f, 2.09922612e-01f, 2.00511247e-01f, -1.10858038e-01f, -3.42426986e-01f, 1.29621401e-01f, -2.04824150e-01f,
  -1.27143115e-01f, 2.46703979e-02f, 1.73516259e-01f, -6.74408600e-02f, 1.60363078e-01f, 3.57245766e-02f, 1.91975057e-01f, -8.95508900e-02f, -5.42944185e-02f, -3.28410387e-01f,
  -6.27391115e-02f, -1.43544108e-01f, 3.66688311e-01f, 5.74593246e-02f, 2.08226204e-01f, -6.76016212e-02f, 5.66865802e-02f, -1.56094134e-01f, -1.38110071e-02f, 1.45930782e-01f,
  -1.64358154e-01f, 1.27500249e-02f, 3.01970869e-01f, -6.17793165e-02f, 2.69211829e-02f, -1.54349133e-01f, -1.76472053e-01f, 8.87924507e-02f, 6.40377924e-02f, 1.14454702e-02f,
  1.58551797e-01f, 9.65882242e-02f, 9.68648642e-02f, 3.98996174e-02f, -1.34354383e-01f, 1.93631038e-01f, -2.71184057e-01f, -1.72496870e-01f, 7.57765444e-03f, 1.56191006e-01f,
  -2.11198971e-01f, -1.08499087e-01f, 3.49166393e-01f, -3.73314368e-03f, 7.92350620e-02f, -2.22094670e-01f, 1.35601565e-01f, -8.95317644e-02f, 1.99283630e-01f, 1.38581932e-01f,
  -9.40326452e-02f, -1.98783260e-02f, 1.26983970e-01f, 7.55403042e-02f, 8.77721682e-02f, -1.26839697e-01f, 9.58613306e-02f, 1.39234111e-01f, -3.82737577e-01f, 4.41273190e-02f,
  -1.92171872e-01f, -4.95460778e-02f, 2.90092025e-02f, -2.15412080e-02f, -1.50362447e-01f, 5.01636341e-02f, 1.63585320e-03f, -3.77433091e-01f, -1.49869584e-02f, 1.53034199e-02f,
  2.44975507e-01f, -8.03809147e-03f, 1.62039343e-02f, 4.34720106e-02f, 1.60212979e-01f, -9.36766192e-02f, 2.29983613e-01f, -1.11595178e-02f, -9.20167193e-02f, 5.22925481e-02f,
  1.85368836e-01f, -4.59921882e-02f, 9.01131481e-02f, 5.12533933e-02f, 8.15757886e-02f, -1.71450928e-01f, 3.61288339e-02f, -9.76868570e-02f, -1.03485987e-01f, 5.48637547e-02f,
  6.78528026e-02f, 5.28054871e-02f, -1.16111852e-01f, -1.57027498e-01f, 2.07563728e-01f, -1.51722759e-01f, -6.09397069e-02f, -7.32607543e-02f, -1.28356189e-01f, 1.67548448e-01f,
  -1.36070892e-01f, -1.93947613e-01f, -3.77621315e-03f, -1.27895921e-01f, 1.25536639e-02f, -3.10517192e-01f, 1.41076356e-01f, 1.67750284e-01f, 1.39118895e-01f, -1.19265161e-01f,
  -3.36452313e-02f, 1.35588609e-02f, -1.35837393e-02f, -1.05001897e-01f, 9.77097303e-02f, -2.36902595e-01f, 8.43866449e-03f, -1.24971308e-01f, -4.40411121e-02f, -5.99743277e-02f,
  1.28562033e-01f, -2.65260994e-01f, -7.08333701e-02f, 2.74043232e-01f, -1.14712305e-01f, 1.82764962e-01f, 4.10594791e-01f, 3.66433486e-02f, 2.22783595e-01f, 6.11564890e-02f,
  -4.99238707e-02f, 8.98212343e-02f, 1.60933658e-01f, 1.84107199e-01f, 1.77488729e-01f, -4.98795807e-02f, 5.76045066e-02f, 2.46854305e-01f, -2.49738440e-01f, 9.40072536e-02f,
  1.99763611e-01f, 2.44266987e-01f, 2.22594384e-02f, 4.87334654e-02f, 2.06707090e-01f, 1.85496435e-01f, -2.98704535e-01f, -2.13375762e-01f, -1.14728175e-01f, 3.45436722e-01f,
  -1.67070925e-01f, -3.73398699e-02f, 5.62191904e-02f, -1.27069697e-01f, 1.61369324e-01f, 3.17245483e-01f, -6.02768511e-02f, 2.55337805e-01f, 1.55655801e-01f, 5.05397469e-02f,
  -1.17513478e-01f, -4.97311316e-02f, 1.62882172e-02f, 1.39306486e-02f, -9.48272571e-02f, -3.76991928e-02f, 1.42179564e-01f, -3.26628163e-02f, 2.67836720e-01f, 2.69897748e-02f,
  -2.15867624e-01f, 3.19644213e-02f, -1.00706279e-01f, 2.66376557e-03f, 5.30622452e-02f, 1.80320010e-01f, 4.56685126e-02f, -1.11653293e-02f, 6.88051954e-02f, 8.95316526e-02f,
  4.53216843e-02f, -7.10857138e-02f, 1.72120512e-01f, 3.43531892e-02f, -5.82783334e-02f, -8.73935446e-02f, 9.18139145e-02f, 1.23677351e-01f, -1.06786564e-01f, -8.45455453e-02f,
  1.23163350e-02f, -2.88413078e-01f, 1.13483064e-01f, 5.88990338e-02f, -1.44333661e-01f, -1.42644033e-01f, -2.85467058e-01f, -1.35873675e-01f, -9.05130655e-02f, -1.27766907e-01f,
  -5.03128767e-02f, 3.31052840e-02f, -1.92802861e-01f, 2.96979129e-01f, -1.07135959e-01f, -1.78277209e-01f, -5.09689413e-02f, 1.56643525e-01f, -7.48396441e-02f, 2.70516574e-01f,
  1.72730714e-01f, 1.10599846e-02f, 7.73782432e-02f, -1.07247091e-03f, 2.08791882e-01f, -4.55186218e-01f, -1.30141512e-01f, -2.27272972e-01f, -1.18827097e-01f, 1.47980198e-01f,
  6.68225959e-02f, 4.62373793e-02f, 1.50505766e-01f, 6.15149550e-02f, 2.78511643e-01f, 1.33832663e-01f, -2.33517997e-02f, 1.13770433e-01f, 2.67924458e-01f, -2.15110034e-01f,
  1.22959234e-01f, -1.91471115e-01f, -1.31179765e-01f, 8.33999217e-02f, 2.39151604e-02f, 1.89713001e-01f, 5.25645465e-02f, -1.52505249e-01f, 1.40337482e-01f, 1.46160766e-01f,
  -7.11238831e-02f, 7.54977688e-02f, 2.13314474e-01f, 1.60264328e-01f, -9.71323438e-03f, -2.11373158e-02f, 7.52726942e-02f, -4.74132150e-02f, -1.17062896e-01f, -2.21840322e-01f,
  1.25184223e-01f, -1.62303690e-02f, 1.09836787e-01f, -9.70476493e-02f, -4.07897234e-01f, 1.78602666e-01f, -1.13579596e-03f, 9.89743788e-03f, -7.02207237e-02f, 4.11697701e-02f,
  -7.03137293e-02f, -2.27142990e-01f, -1.87506780e-01f, 1.73498005e-01f, -1.17017709e-01f, -2.62526542e-01f, 2.27612257e-01f, 2.21813291e-01f, -9.69594195e-02f, -2.78562337e-01f,
  1.20408952e-01f, -2.47739270e-01f, -1.97593734e-01f, -2.43917942e-01f, -1.23359449e-01f, 1.17607154e-01f, 8.70599523e-02f, -2.18274686e-02f, 8.24971795e-02f, -4.94494326e-02f,
  2.16892436e-01f, 1.19809322e-01f, -2.23999873e-01f, -1.83143541e-01f, 7.99636170e-02f, 3.86596732e-02f, -1.23718061e-01f, 1.53202657e-02f, 1.31800041e-01f, 8.79515111e-02f,
  -2.66162485e-01f, -7.14552402e-02f, 1.04244985e-02f, 2.68109560e-01f, -9.82968360e-02f, -8.32773075e-02f, 1.29947767e-01f, -1.36926249e-01f, 2.56201059e-01f, -1.71104342e-01f,
  1.07008576e-01f, -1.33888470e-02f, -3.91879976e-02f, -1.43212542e-01f, 5.87566234e-02f, 1.05694763e-01f, -1.18248940e-01f, 4.98147830e-02f, 7.74207488e-02f, -2.35957474e-01f,
  -6.06716461e-02f, -7.95948878e-02f, 1.66070238e-01f, 1.64391115e-01f, 2.25861371e-01f, -2.20621154e-01f, -1.40543967e-01f, 1.06971048e-01f, 1.38862237e-01f, -1.35077104e-01f,
  1.00762166e-01f, -9.39438269e-02f, 1.10947669e-01f, -9.95752364e-02f, -2.25182548e-01f, -1.12463288e-01f, -5.59134223e-02f, 6.74061477e-02f, -8.63453746e-02f, -1.23784751e-01f,
  2.29878575e-01f, 3.71779501e-01f, -5.27995467e-01f, 8.72531161e-02f, 3.24293286e-01f, -1.38085121e-02f, 1.41867653e-01f, 1.42365858e-01f, 6.44274428e-02f, -1.70664161e-01f,
  -1.01611875e-01f, 2.79532701e-01f, 9.22766179e-02f, 1.82455152e-01f, -1.50536284e-01f, 1.31360948e-01f, 2.96328254e-02f, -1.10897273e-01f, -2.49102771e-01f, 3.87038253e-02f,
  1.39931634e-01f, -1.98159531e-01f, -1.06148854e-01f, 4.14670557e-01f, 6.32719547e-02f, -1.61883265e-01f, -1.78739130e-01f, 1.82318777e-01f, 1.26085579e-01f, 1.07215792e-01f,
  3.56055275e-02f, -6.49460629e-02f, 5.24860732e-02f, -4.59465720e-02f, 6.29682541e-02f, 2.53253430e-02f, 5.29142432e-02f, -1.54815212e-01f, -5.32092638e-02f, -2.60524377e-02f,
  3.27392161e-01f, 9.40217376e-02f, -1.63026229e-01f, 2.50380367e-01f, -2.85764873e-01f, -1.68511063e-01f, -2.21262723e-02f, 1.15051590e-01f, -2.52403952e-02f, 6.82363361e-02f,
  -6.60013631e-02f, -1.30113170e-01f, -1.24460915e-02f, -9.23727602e-02f, -1.77218184e-01f, 8.75850469e-02f, -6.10028254e-03f, 1.56365380e-01f, 1.02273345e-01f, -1.26976054e-02f,
  -1.66062303e-02f, -1.20799638e-01f, -1.80992216e-01f, 3.38043749e-01f, -3.42498511e-01f, 8.16937983e-02f, 1.55090794e-01f, 6.45830412e-04f, 7.29099382e-03f, 6.18636981e-02f,
  -5.97982332e-02f, -9.09509435e-02f, -7.81459659e-02f, -8.92588049e-02f, -1.91691101e-01f, -6.08631931e-02f, -1.29170328e-01f, -3.72218579e-01f, 6.22236654e-02f, -4.71803732e-02f,
  -3.85109782e-02f, 4.14840654e-02f, -1.30634144e-01f, 7.85305724e-02f, 1.82032748e-03f, 3.11494261e-01f, 9.06139612e-03f, -2.10332215e-01f, 1.21984817e-01f, 4.85114492e-02f,
  1.17871784e-01f, -2.23193571e-01f, -5.18082902e-02f, -5.12187593e-02f, -5.94126955e-02f, 1.39264762e-01f, -1.82209387e-01f, -1.92275960e-02f, -6.56987652e-02f, -5.62068250e-04f,
  8.14594179e-02f, 7.89426714e-02f, 6.69275457e-03f, 1.47098035e-01f, -1.68670759e-01f, 3.17034215e-01f, -8.25934708e-02f, 1.45100340e-01f, 1.23570658e-01f, -1.24028377e-01f,
  -1.96350917e-01f, 2.43429631e-01f, 3.95547077e-02f, 1.08069353e-01f, -1.61857218e-01f, 5.15208207e-02f, -1.16077267e-01f, 1.06285088e-01f, 4.58226539e-02f, 1.96168438e-01f,
  -1.73784316e-01f, -1.77095652e-01f, 7.30272606e-02f, 2.39128228e-02f, -3.35874073e-02f, 4.93384600e-02f, 1.25295892e-01f, 1.18890360e-01f, 3.12894844e-02f, -1.97402179e-01f,
  1.81579024e-01f, 1.61974400e-01f, -3.09056714e-02f, -3.82321745e-01f, -1.00296445e-01f, -1.96987435e-01f, 3.61988097e-02f, -2.72561274e-02f, 8.75028446e-02f, -4.81878258e-02f,
  -1.35041416e-01f, -2.01850384e-01f, -1.44524872e-01f, -3.56657431e-02f, 2.13710204e-01f, -1.31135926e-01f, -8.63039419e-02f, 3.91015522e-02f, -2.45735154e-01f, 1.58229291e-01f,
  6.01948313e-02f, -2.51304001e-01f, 1.31163001e-01f, 1.99140519e-01f, 1.63157836e-01f, -2.27741912e-01f, -9.33598075e-03f, -1.26376316e-01f, -1.75020397e-01f, 3.95717360e-02f,
  -1.65592492e-01f, 2.65667588e-01f, -1.89337581e-01f, 9.02119726e-02f, 1.04836851e-01f, -8.29619393e-02f, -2.16712996e-01f, 2.43204609e-02f, 2.97173828e-01f, 1.62561104e-01f,
  -1.68604985e-01f, -4.08086441e-02f, -1.59654263e-02f, -4.65500914e-02f, 1.30895838e-01f, -7.26201897e-03f, -2.41631195e-01f, 1.23822354e-02f, 1.36399940e-01f, -1.39974669e-01f,
  3.42749238e-01f, 2.84003727e-02f, 2.83933859e-02f, 2.68953681e-01f, -2.21296959e-02f, 2.54157037e-01f, -5.21805882e-02f, 1.00026563e-01f, 1.83383316e-01f, -3.33657324e-01f,
  -2.45843560e-01f, 3.35120142e-01f, -2.35392869e-01f, -4.01859403e-01f, 3.18714142e-01f, 1.28975734e-01f, 8.58970433e-02f, 1.37807801e-01f, -6.45228773e-02f, -9.17754993e-02f,
  1.30710021e-01f, 1.44726232e-01f, 1.97322294e-02f, 3.48975480e-01f, -1.28969461e-01f, 2.06376955e-01f, -5.53615158e-04f, -1.66371331e-01f, 9.15244743e-02f, -1.19544677e-02f,
  -1.93211034e-01f, 2.90490631e-02f, 1.50323913e-01f, 9.43726450e-02f, 2.43038476e-01f, 1.53973371e-01f, 1.51468366e-01f, -9.50246155e-02f, 1.81790069e-01f, -7.67229423e-02f,
  1.70234784e-01f, -7.38967136e-02f, 1.49898872e-01f, -5.25098890e-02f, -3.07421535e-01f, -3.93411107e-02f, -1.71778202e-01f, 1.07350998e-01f, 1.28517151e-01f, 8.32025185e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.65746272e-01f, 3.64420563e-01f, 1.55003518e-01f, 2.49173298e-01f, -1.03481442e-01f, -1.43966228e-01f, -4.57568123e-04f, 8.17921683e-02f, -6.30835071e-02f, -2.36841347e-02f,
  4.12589878e-01f, 2.51818627e-01f, 2.09608048e-01f, -1.12001352e-01f, 3.44164222e-01f, 1.44537151e-01f, 4.87378925e-01f, 3.55517507e-01f, -6.83572069e-02f, 4.96334612e-01f,
  -1.36778399e-01f, -8.93275887e-02f, 2.02070355e-01f, 1.06093712e-01f, 6.51255995e-02f, -1.98789716e-01f, 3.69568989e-02f, 1.21909268e-01f, -3.50514293e-01f, -1.74559891e-01f,
  1.55155092e-01f, -2.97431707e-01f, -1.97524861e-01f, -2.97672185e-03f, 4.16999012e-01f, -1.10092290e-01f, 2.67880678e-01f, 8.83748382e-02f, 1.02503590e-01f, 7.36669078e-02f,
  -8.91080722e-02f, -3.34006473e-02f, 8.21159396e-04f, -4.94901925e-01f, 5.39946295e-02f, -2.41928369e-01f, -5.38961172e-01f, -1.70077309e-01f, 1.15731150e-01f, 2.24689782e-01f,
  2.66232431e-01f, 6.23623848e-01f, 7.59942159e-02f, 4.47490484e-01f, 1.30655870e-01f, -2.16456234e-01f, -9.33380872e-02f, -1.31408051e-01f, -5.20317078e-01f, 2.83478349e-01f,
  -1.22699805e-01f, 1.34311855e-01f, 3.23423222e-02f, 1.98794246e-01f, 1.94704328e-02f, -3.40011381e-02f, 2.37962767e-01f, 2.47840405e-01f, 1.14024051e-01f, -3.08968630e-02f,
  1.23374589e-01f, 8.44212770e-02f, 7.04232827e-02f, 3.31181794e-01f, 6.20588064e-02f, 1.09940171e-01f, 1.78131476e-01f, 2.50631094e-01f, 5.44082969e-02f, 3.00856292e-01f,
  4.40083444e-02f, 9.39996168e-02f, 2.55976111e-01f, 6.68505654e-02f, 4.43235487e-01f, 4.62294891e-02f, 3.47405374e-01f, -2.61051893e-01f, -2.44598120e-01f, 1.98534146e-01f,
  1.13225579e-01f, -1.14708617e-01f, 2.14431420e-01f, 2.72619367e-01f, 1.58611447e-01f, 5.79015732e-01f, 1.29600421e-01f, -9.07485411e-02f, -1.80808932e-01f, 2.33699247e-01f,
  2.16214165e-01f, 4.82251376e-01f, 1.84909075e-01f, 9.11237746e-02f, 4.03159261e-02f, 2.85201579e-01f, -3.67095135e-02f, 5.16021490e-01f, -1.82676643e-01f, 4.28521991e-01f,
  4.93719667e-01f, -1.25657812e-01f, 3.28049898e-01f, 3.48747611e-01f, -9.56114605e-02f, -1.45176485e-01f, 4.87976447e-02f, -2.31265619e-01f, 5.21835864e-01f, 1.82326809e-01f,
  -7.43665593e-03f, 3.11435107e-02f, 2.16102123e-01f, 1.54753327e-01f, 6.00485921e-01f, -2.56545395e-01f, -2.79643983e-01f, 1.16293922e-01f, -1.08175136e-01f, 2.35018209e-01f,
  -1.69177145e-01f, 5.29984981e-02f, -1.28044337e-01f, -4.38229561e-01f, 1.79336309e-01f, -1.27359867e-01f, 2.12335765e-01f, 2.95950565e-03f, 2.06220299e-01f, -2.72441477e-01f,
  -8.29087496e-02f, -1.23916855e-02f, 9.23901945e-02f, -1.79495394e-01f, 1.01056471e-02f, -3.23473841e-01f, 1.96397975e-01f, 2.66078617e-02f, -1.27655432e-01f, -1.84189733e-02f,
  -1.66686788e-01f, 2.51840204e-02f, 1.75347194e-01f, 8.24861676e-02f, 1.98205024e-01f, 4.50570047e-01f, -1.08692370e-01f, -2.55151335e-02f, 2.80317873e-01f, -2.59732634e-01f,
  1.53901160e-01f, 7.96595402e-03f, 4.76898886e-02f, 2.34707460e-01f, -1.26326784e-01f, 3.39917600e-01f, -5.26247993e-02f, -2.17328191e-01f, -1.60475314e-01f, 1.50650173e-01f,
  1.59615353e-01f, -2.99029239e-03f, -1.79500386e-01f, 2.00608432e-01f, 2.31080979e-01f, -2.33500332e-01f, 2.13427078e-02f, 2.74913102e-01f, 1.85687974e-01f, -5.90068460e-01f,
  9.63360965e-02f, -9.15589556e-02f, 3.61213446e-01f, 2.17842966e-01f, 2.63618588e-01f, 3.63897979e-01f, 5.32513738e-01f, 1.74046844e-01f, 2.15017144e-02f, 5.54378564e-03f,
  -8.81556198e-02f, -1.82340778e-02f, 3.35190892e-01f, 7.35775828e-02f, 1.71831280e-01f, 1.11477189e-01f, 2.11619705e-01f, 2.03500897e-01f, 5.39414823e-01f, 2.09110543e-01f,
  4.55194246e-03f, 1.64395999e-02f, -3.12405705e-01f, 2.43009076e-01f, 5.19637801e-02f, -9.30394679e-02f, 3.34052086e-01f, 1.85545087e-01f, -3.13214570e-01f, 5.19569874e-01f,
  4.80786711e-01f, 1.71912722e-02f, -1.06443040e-01f, 2.56251872e-01f, 3.57893139e-01f, -4.42993283e-01f, 3.41063082e-01f, -3.78288627e-01f, 1.66794226e-01f, -4.52902526e-01f,
  3.12744617e-01f, -3.16498756e-01f, 2.54988074e-01f, 1.02450043e-01f, 4.44986105e-01f, -1.10799976e-01f, 1.96942449e-01f, -1.42292619e-01f, -3.48594338e-02f, -2.08236054e-01f,
  4.06950444e-01f, -1.53125033e-01f, -5.15385158e-02f, -3.76276255e-01f, -7.07323104e-02f, 1.12638243e-01f, -1.42374367e-01f, -4.29627687e-01f, 5.83282769e-01f, -1.54897764e-01f,
  8.35523829e-02f, 2.91304141e-02f, 2.44409665e-01f, 3.12121749e-01f, 1.06837235e-01f, -2.69282877e-01f, 2.20769987e-01f, 1.70683309e-01f, -1.12595402e-01f, 5.93146160e-02f,
  2.97951013e-01f, -1.74857795e-01f, 4.39196646e-01f, -4.14268672e-01f, 8.06077756e-03f, 2.39337280e-01f, -1.15870260e-01f, 6.06063545e-01f, -3.42658550e-01f, -2.44212002e-01f,
  -7.18462616e-02f, -9.54092294e-02f, 2.03318596e-01f, -2.51816422e-01f, 3.97240311e-01f, 1.39774814e-01f, 1.27512654e-02f, -1.05393030e-01f, 1.50041897e-02f, -2.39422113e-01f,
  -1.87954411e-01f, -3.59688044e-01f, 5.17581264e-03f, -4.30195689e-01f, -1.78528130e-02f, 1.35165811e-01f, -8.51096287e-02f, -3.66002619e-01f, -1.50251552e-01f, 3.68686527e-01f,
  2.32772216e-01f, -1.58254951e-01f, 4.82559234e-01f, 6.21064147e-03f, 2.97109872e-01f, -2.06526622e-01f, 6.18104869e-03f, -8.23655203e-02f, -1.54735878e-01f, -1.65160388e-01f,
  2.93220162e-01f, 3.70479792e-01f, -4.81361389e-01f, -2.21634582e-01f, 4.53179628e-01f, -1.03860572e-01f, -2.11816281e-01f, -5.44594638e-02f, 3.58654529e-01f, -1.86150998e-01f,
  4.56725210e-01f, -1.77495405e-01f, 2.14276209e-01f, -3.10829550e-01f, 3.23857157e-03f, 6.94158897e-02f, 3.34400624e-01f, 6.20692736e-04f, 4.54489946e-01f, 1.08161699e-02f,
  -4.43392582e-02f, 1.55525701e-02f, -2.45170314e-02f, 3.80491197e-01f, 6.12123668e-01f, -3.36933061e-02f, 2.14262865e-02f, 2.37646714e-01f, 9.11647677e-02f, 2.09537074e-02f,
  -2.00241357e-01f, 1.08115897e-02f, 3.21293712e-01f, 4.83052403e-01f, -8.30437541e-02f, -2.92608529e-01f, 1.59659967e-01f, 1.26706585e-01f, 4.46320586e-02f, 6.77156076e-02f,
  1.34216413e-01f, 2.40951374e-01f, -3.68720181e-02f, -1.52441695e-01f, 4.42757547e-01f, 7.00649396e-02f, -1.18591994e-01f, 2.63110369e-01f, 3.89011979e-01f, -1.03069961e-01f,
  -1.49770854e-02f, 6.62170798e-02f, 2.36878857e-01f, -2.24819288e-01f, -2.37689421e-01f, 1.42311640e-02f, 1.53400943e-01f, 2.70555139e-01f, -2.63174593e-01f, 2.85619408e-01f,
  4.86084878e-01f, 2.25624681e-01f, -5.56871928e-02f, 3.70967537e-01f, -6.37979135e-02f, -1.60827965e-01f, -9.61164534e-02f, 3.33650351e-01f, 9.34353173e-02f, -1.71014026e-01f,
  -8.08268264e-02f, -1.49859831e-01f, -6.89203367e-02f, -2.26070099e-02f, -5.34768403e-01f, 2.75231093e-01f, 2.50472963e-01f, -3.37748587e-01f, 3.11885923e-01f, 5.00741661e-01f,
  3.30021501e-01f, 8.87861773e-02f, 5.92061551e-04f, 8.96237120e-02f, 7.73675382e-01f, -4.09149937e-02f, 1.71387896e-01f, 2.64275074e-01f, -1.07392900e-01f, 2.13557512e-01f,
  1.73777759e-01f, 2.48548239e-02f, -5.08987494e-02f, 2.82194018e-01f, 3.92566711e-01f, 1.08848587e-02f, 1.81069851e-01f, 1.55804694e-01f, 6.79218099e-02f, 2.48597980e-01f,
  2.15447381e-01f, 2.97602683e-01f, -1.12055145e-01f, 1.89012617e-01f, -4.20937151e-01f, 1.37652248e-01f, 2.28374556e-01f, 4.14168417e-01f, 4.92771834e-01f, 3.25396478e-01f,
  2.41393596e-01f, 4.51110303e-01f, -8.97191092e-02f, 2.18518779e-01f, 2.49819905e-02f, 4.03457224e-01f, 3.11464369e-01f, -3.39481682e-01f, 6.68354779e-02f, 9.63832512e-02f,
  1.85857248e-02f, -8.45295966e-01f, 1.79982275e-01f, 9.21558514e-02f, 6.72265589e-02f, 2.31858283e-01f, 8.29087719e-02f, 1.24552906e-01f, 3.92796069e-01f, -3.18194330e-01f,
  2.43732363e-01f, 1.24609275e-02f, -2.40074277e-01f, 3.24654967e-01f, 3.07169855e-02f, -2.87066270e-02f, 5.70512265e-02f, 2.28625044e-01f, -3.87949258e-01f, -8.93556401e-02f,
  2.32387602e-01f, 9.86581948e-03f, 2.95169950e-01f, -2.89645851e-01f, 3.31141174e-01f, 3.70759606e-01f, 7.18576238e-02f, 1.27950311e-03f, -4.28063516e-03f, 2.34167993e-01f,
  2.81277299e-02f, 4.27188389e-02f, -1.96337223e-01f, -3.71467918e-02f, 2.78236896e-01f, -2.42874920e-01f, 2.23730892e-01f, 1.95790663e-01f, 1.77842855e-01f, 3.94114181e-02f,
  -1.99873254e-01f, -3.52697372e-01f, 2.54915714e-01f, 1.45392194e-01f, 1.99225232e-01f, 2.31478244e-01f, 1.91806480e-01f, 9.53260064e-02f, 3.04766279e-02f, 4.77710217e-02f,
  5.42746782e-02f, 1.96787775e-01f, 1.32104248e-01f, -6.50425851e-02f, 1.06968924e-01f, -9.12742093e-02f, -5.38892150e-02f, 2.92330801e-01f, -2.37314180e-01f, 6.32421821e-02f,
  7.57358409e-03f, 3.97140384e-02f, 4.58495706e-01f, -2.79467434e-01f, 9.16459691e-03f, -4.26395029e-01f, -3.88065502e-02f, -1.30371734e-01f, 3.55166616e-03f, 1.30669132e-01f,
  -1.23527162e-01f, 4.97984961e-02f, 3.81217390e-01f, 9.05801635e-03f, 8.87004882e-02f, -3.08990836e-01f, 1.26910135e-01f, 1.00505121e-01f, 1.56633500e-02f, -1.78510666e-01f,
  3.49535584e-01f, -1.76905021e-01f, 4.76809032e-02f, -4.47485983e-01f, -2.04817638e-01f, -1.20524384e-01f, 2.51465261e-01f, -1.39405370e-01f, 9.51115340e-02f, 3.26351643e-01f,
  2.19930351e-01f, 4.48498428e-01f, -3.76319051e-01f, 1.49268463e-01f, 7.04481266e-03f, -3.72152776e-02f, 3.55056375e-01f, 4.85965498e-02f, 1.57657519e-01f, 7.72931799e-02f,
  3.35367262e-01f, -1.53595963e-02f, -1.26872584e-02f, -2.09792972e-01f, 4.62191515e-02f, -2.17934713e-01f, 2.37708539e-01f, 2.57228334e-02f, 1.56191617e-01f, 5.13312161e-01f,
  7.36331120e-02f, 4.26091477e-02f, 1.48466855e-01f, 8.52814391e-02f, 2.52823114e-01f, 3.02689493e-01f, -8.41260403e-02f, 2.36580744e-01f, -8.36527050e-02f, 1.16360359e-01f,
  2.04697564e-01f, 2.13507459e-01f, 1.26074851e-01f, 1.10899277e-01f, -1.23135513e-02f, 1.01790093e-01f, 2.46256575e-01f, -5.01511335e-01f, -1.31068036e-01f, -6.26293778e-01f,
  -1.70699030e-01f, 1.83941219e-02f, 2.18000308e-01f, 2.45383140e-02f, -2.35706896e-01f, 7.91482553e-02f, -2.69164115e-01f, -1.27214845e-02f, 3.23477328e-01f, -5.36745973e-02f,
  3.88115793e-01f, 4.97801244e-01f, 4.27055418e-01f, 3.01467836e-01f, -1.98129579e-01f, -5.25705144e-03f, 1.03257924e-01f, -2.63444424e-01f, 6.32666200e-02f, -1.07553296e-01f,
  -2.03764141e-01f, -9.12692994e-02f, 2.04982534e-01f, 2.53500611e-01f, -1.76949903e-01f, 5.30480444e-01f, -1.36811733e-01f, 3.69865656e-01f, 1.80882141e-01f, 2.43129786e-02f,
  1.36838675e-01f, -7.64649689e-01f, 2.37438783e-01f, 8.87861550e-02f, 6.71080500e-02f, -7.09267706e-02f, -1.16823755e-01f, -1.58885657e-03f, -4.33792584e-02f, 5.89700229e-02f,
  -3.61238196e-02f, 1.81314319e-01f, 8.83909836e-02f, 3.18712264e-01f, -9.90926027e-02f, 1.66649565e-01f, 3.14739019e-01f, 7.07756728e-02f, 3.43096316e-01f, -2.46398002e-01f,
  -9.15288255e-02f, 2.86634136e-02f, 1.84614688e-01f, 8.21111277e-02f, -1.98991746e-01f, -2.32783020e-01f, 1.42341316e-01f, 1.36247531e-01f, 4.31810617e-01f, 9.69556049e-02f,
  1.75620779e-01f, -3.40656757e-01f, 2.87446052e-01f, -2.61816919e-01f, 1.11817762e-01f, -3.89619052e-01f, -3.49259257e-01f, -6.16630912e-01f, -1.03233241e-01f, -2.41170600e-01f,
  1.10401459e-01f, 1.98948145e-01f, 9.02293101e-02f, -3.12113941e-01f, -8.95564631e-03f, 2.23265469e-01f, -8.49125609e-02f, -1.98894992e-01f, -1.48250327e-01f, -2.43853956e-01f,
  4.41723943e-01f, -2.90513664e-01f, -5.45539439e-01f, 4.08474982e-01f, 1.49714544e-01f, -1.95126250e-01f, -2.72852182e-01f, 4.85682756e-01f, -3.23193938e-01f, 1.40919581e-01f,
  -3.49348247e-01f, -1.84721556e-02f, -1.57021329e-01f, -5.79567552e-01f, 2.70707190e-01f, -2.38424633e-03f, 1.41998723e-01f, -2.08845120e-02f, 1.99975237e-01f, -4.18167561e-01f,
  4.59651768e-01f, 1.78447962e-01f, 2.71420509e-01f, -4.42081802e-02f, 1.17614046e-01f, 3.72571573e-02f, 1.59052417e-01f, -8.81548412e-03f, 1.52469784e-01f, 2.97104139e-02f,
  -1.03947088e-01f, 6.44983873e-02f, 1.09865434e-01f, 3.39014292e-01f, -2.13018224e-01f, 1.25926003e-01f, 1.09657951e-01f, 2.45979726e-01f, -1.02139570e-01f, 3.79394144e-01f,
  3.50043267e-01f, 2.02150017e-01f, -8.98677260e-02f, 1.53398767e-01f, 2.40854353e-01f, 4.95411813e-01f, -3.77827227e-01f, -3.31343681e-01f, 4.35244352e-01f, -1.24451354e-01f,
  -3.75349796e-03f, -4.78355855e-01f, -6.45556077e-02f, -3.48430455e-01f, -1.10128455e-01f, 4.15425867e-01f, -1.49872648e-02f, -4.05016214e-01f, -3.14754874e-01f, 3.36813927e-01f,
  1.56736657e-01f, 4.39015687e-01f, 1.59569114e-01f, 4.52363119e-02f, 1.10850342e-01f, -2.72158962e-02f, -3.59425619e-02f, 2.08574161e-01f, 1.13961481e-01f, -4.35497969e-01f,
  1.16584279e-01f, -1.19414933e-01f, 1.31858379e-01f, -1.70329601e-01f, -3.02213728e-01f, 1.39269277e-01f, -1.36057198e-01f, 3.88972700e-01f, 3.21944028e-01f, -1.23840548e-01f,
  -1.21804126e-01f, -6.72457963e-02f, 9.08771455e-02f, 4.43932176e-01f, -1.94444582e-01f, -2.65446484e-01f, -9.14926678e-02f, -3.92670520e-02f, 1.04769319e-01f, 1.99835077e-01f,
  4.98602018e-02f, 3.26591551e-01f, -6.29222840e-02f, -9.18736458e-02f, 4.48913783e-01f, 2.15266645e-01f, 3.40982489e-02f, 2.19551727e-01f, 1.66784793e-01f, 3.32409710e-01f,
  7.67465457e-02f, 4.06415462e-02f, 4.86564755e-01f, 1.26176044e-01f, 9.32328478e-02f, 2.12238103e-01f, 1.77484185e-01f, 1.84488177e-01f, 1.99994206e-01f, 7.57146552e-02f,
  1.38714209e-01f, 3.07108670e-01f, -4.08320785e-01f, 1.42198697e-01f, 2.05607206e-01f, -2.70834833e-01f, 2.24700883e-01f, 2.40886629e-01f, -3.21294427e-01f, -1.23962022e-01f,
  2.75126100e-01f, 1.82734653e-01f, -1.88037187e-01f, 1.71777785e-01f, 1.35749765e-02f, 6.32579982e-01f, -1.44768238e-01f, 6.30098453e-04f, 1.73774734e-01f, 2.44065836e-01f,
  1.59119759e-02f, -1.58059910e-01f, -1.88807681e-01f, 2.39739195e-01f, -1.86258703e-01f, 5.67262657e-02f, -4.70138758e-01f, 3.23619694e-01f, 4.17476654e-01f, 2.74737865e-01f,
  1.25898411e-02f, 7.82190785e-02f, 1.95017219e-01f, 5.12243658e-02f, 2.93220788e-01f, -2.87631243e-01f, -2.87097663e-01f, -1.28271896e-02f, 1.04162015e-01f, 1.06491737e-01f,
  2.00186506e-01f, -3.77711952e-01f, 4.86556962e-02f, 7.51893371e-02f, 6.63326979e-02f, -3.52257580e-01f, 2.94425070e-01f, -1.67976961e-01f, -4.46218729e-01f, 2.95092389e-02f,
  -3.81185412e-01f, -8.53618756e-02f, -2.92288303e-01f, -1.39675558e-01f, -1.14865147e-01f, -2.29876041e-01f, -1.50114939e-01f, 1.06780902e-01f, 1.85500067e-02f, 5.08721769e-02f,
  -1.79168820e-01f, 2.35181704e-01f, 1.97746888e-01f, 1.81803316e-01f, -3.98832917e-01f, 2.05442742e-01f, 4.04471070e-01f, -3.40130776e-02f, -3.95874828e-01f, 1.31193399e-01f,
  1.96287595e-02f, 9.10296105e-03f, -2.79911041e-01f, 1.10902488e-01f, -1.37675971e-01f, -5.29543698e-01f, 3.74006689e-01f, -4.33759034e-01f, -8.18984807e-02f, -1.00689344e-01f,
  3.10612589e-01f, 2.44466543e-01f, 2.96110123e-01f, -2.28769630e-01f, 1.17174350e-01f, 1.21747948e-01f, 8.86620283e-02f, -3.27289581e-01f, 1.88807473e-01f, 1.71685204e-01f,
  3.10148567e-01f, -6.20598830e-02f, -5.80485389e-02f, -1.22415818e-01f, 9.92727056e-02f, 1.75581858e-01f, 7.71371871e-02f, 3.58798474e-01f, -1.31523520e-01f, 1.93945497e-01f,
  2.84401625e-01f, 4.28066403e-01f, 7.16447607e-02f, -2.69668493e-02f, 1.85778365e-02f, 3.46089363e-01f, -3.66256908e-02f, 1.44505292e-01f, -3.73277217e-01f, 4.13227193e-02f,
  6.63976744e-02f, 1.36719763e-01f, 8.95047933e-02f, 3.22891593e-01f, 1.05179429e-01f, 3.99710655e-01f, 3.64377767e-01f, -1.48435444e-01f, 3.40207696e-01f, 1.67625546e-01f,
  -1.91147238e-01f, 3.08748394e-01f, 2.47038931e-01f, 2.62425065e-01f, 3.42721015e-01f, -4.38079424e-02f, 1.57882422e-01f, 3.33603710e-01f, -1.92768395e-01f, -1.79618716e-01f,
  3.05611849e-01f, -1.63331032e-01f, -2.24824950e-01f, -4.28862125e-01f, 2.86755383e-01f, -1.84966266e-01f, 1.36824310e-01f, 2.31925547e-01f, -1.34360686e-01f, -2.56550133e-01f,
  -4.99868512e-01f, -2.19849110e-01f, -8.28516707e-02f, -1.81149989e-01f, 4.31454480e-02f, -8.34772512e-02f, 1.08882770e-01f, -1.50062829e-01f, -5.08514643e-01f, 3.58657688e-01f,
  1.71328053e-01f, -2.75492430e-01f, 3.54250590e-03f, 4.46623087e-01f, -3.94896567e-01f, -3.95839550e-02f, 1.10056169e-01f, 1.45962480e-02f, -3.62996221e-01f, -1.22208160e-03f,
  -3.46039474e-01f, 5.76533079e-01f, -1.94699034e-01f, -3.35515380e-01f, 2.27969483e-01f, 1.25505939e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  8.66333917e-02f, 4.49291281e-02f, 2.45590415e-02f, 1.39778033e-01f, 1.41418129e-01f, -7.70687163e-02f, 2.15739444e-01f, 1.55046314e-01f, 3.17984670e-01f, 1.76162317e-01f,
  6.95353225e-02f, 1.36488363e-01f, 7.07416832e-02f, 1.64514676e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.79278582e-01f, 1.82526961e-01f, 3.65948514e-03f, 1.54764473e-01f, 1.47763267e-01f, 2.21073076e-01f, -3.71512771e-01f, 9.68906656e-02f, -1.43479377e-01f, -5.68202853e-01f,
  -5.94344847e-02f, 1.49235040e-01f, -4.15933907e-01f, -4.64206129e-01f, 1.27147660e-01f, -2.09546134e-01f, -2.12527886e-01f, -1.75074220e-01f, -2.03027204e-01f, -1.52138442e-01f,
  -2.79415727e-01f, -9.18421149e-03f, -3.36120993e-01f, -5.55736840e-01f, -1.79412842e-01f, 3.04948777e-01f, 1.71995595e-01f, 2.38264635e-01f, 1.52367502e-01f, -2.43844185e-02f,
  3.52397468e-03f, -3.22873324e-01f, 2.84874380e-01f, -1.84287757e-01f, -1.62073761e-01f, 7.70730078e-02f, -9.84913334e-02f, -1.77312829e-02f, 1.93001837e-01f, -3.56370538e-01f,
  -5.08414861e-03f, 4.78975661e-02f, -9.67741087e-02f, -4.10175435e-02f, -6.76288828e-02f, -1.23823911e-01f, -6.06441319e-01f, 2.05705345e-01f, -4.61118668e-02f, 4.01308462e-02f,
  -1.25622272e-01f, 6.77635446e-02f, 1.21018149e-01f, -4.97970581e-01f, 2.91668683e-01f, 9.90146548e-02f, -5.73811054e-01f, -4.29430962e-01f, -1.91814870e-01f, -1.35968536e-01f,
  5.22093847e-02f, -5.63373446e-01f, 2.14620098e-01f, -3.04796398e-01f, 1.44354135e-01f, 2.25189745e-01f, -1.56758457e-01f, 1.57172754e-01f, 1.04278773e-02f, -5.79472601e-01f,
  4.95905578e-02f, -2.52485126e-01f, -1.63755536e-01f, 2.17358880e-02f, 6.77018315e-02f, 3.43553871e-02f, -5.16992770e-02f, 6.64408877e-02f, -1.14858739e-01f, -3.47142786e-01f,
  1.87593296e-01f, 9.23807323e-02f, 4.03401464e-01f, -2.53277212e-01f, 3.38403285e-01f, 8.76406133e-02f, 8.92831609e-02f, 1.99682295e-01f, 3.37276846e-01f, -4.57745165e-01f,
  7.16044456e-02f, -3.47085178e-01f, 3.12968642e-01f, -5.55877030e-01f, -2.54927605e-01f, 5.13923824e-01f, -4.30836827e-02f, 5.35983220e-03f, -5.79424500e-02f, 1.57023802e-01f,
  1.60664156e-01f, -1.96828008e-01f, -7.29688909e-03f, 2.19956160e-01f, 2.12727308e-01f, -5.68327233e-02f, -1.22397594e-01f, -1.31468758e-01f, -1.67613134e-01f, -9.74544212e-02f,
  2.70836167e-02f, -1.28148228e-01f, -8.40392411e-02f, -1.40473098e-01f, -4.10609484e-01f, -7.49377608e-01f, 1.99804991e-01f, -7.29722008e-02f, 4.31779802e-01f, -2.72271037e-01f,
  -1.32420793e-01f, 2.68298745e-01f, 2.63333231e-01f, -2.34679893e-01f, 2.25912973e-01f, -4.57447499e-01f, 5.83891533e-02f, -4.55657363e-01f, 1.15787648e-01f, 2.49691438e-02f,
  2.87113309e-01f, 1.86772183e-01f, 1.16600767e-01f, 9.99766439e-02f, 2.35845998e-01f, 2.02454135e-01f, 8.73688459e-02f, -1.60619065e-01f, 2.37238213e-01f, -2.00528309e-01f,
  -9.60598886e-02f, -4.29174937e-02f, -1.46752680e-02f, -1.49360284e-01f, -3.35081875e-01f, 1.09667920e-01f, -1.67317763e-02f, 2.00824127e-01f, 3.00183862e-01f, -1.08810894e-01f,
  1.33061320e-01f, 8.93542543e-02f, 7.22912475e-02f, -1.94331557e-01f, -4.45946664e-01f, -2.82783866e-01f, -6.01039156e-02f, -3.02180648e-02f, 1.93155378e-01f, -2.96199501e-01f,
  -3.18012953e-01f, -2.09055528e-01f, 4.83283073e-01f, 1.07568249e-01f, 2.23543003e-01f, -8.25538710e-02f, -3.02890301e-01f, -1.68613404e-01f, 3.66826713e-01f, 3.69534731e-01f,
  4.45659876e-01f, 3.42085361e-01f, 1.91923067e-01f, 1.13140441e-01f, 3.51390898e-01f, -1.89055234e-01f, -3.49447638e-01f, -2.33002707e-01f, -4.34663832e-01f, 2.16770723e-01f,
  3.63671541e-01f, 2.72155721e-02f, 2.11475149e-01f, 1.56568829e-02f, -8.38625491e-01f, -4.00107205e-01f, -4.97114956e-01f, -1.65282235e-01f, -7.37519637e-02f, 1.48951039e-01f,
  -1.85742676e-01f, -2.02710763e-01f, -4.92924333e-01f, 2.92030632e-01f, -9.30218622e-02f, 2.16683194e-01f, -1.09474536e-03f, 7.66989440e-02f, -3.12065005e-01f, -2.10868105e-01f,
  1.85014158e-01f, -1.11190304e-01f, 1.93011910e-01f, -4.04619277e-01f, 4.38999623e-01f, -1.37921169e-01f, 1.40778765e-01f, 1.82403237e-01f, -1.28505185e-01f, -5.15285075e-01f,
  -1.77278697e-01f, 1.91236168e-01f, 2.32008621e-01f, -2.01860964e-02f, 1.17798790e-01f, -3.22491139e-01f, 2.40007088e-01f, 7.39215538e-02f, 5.11359312e-02f, -1.77364841e-01f,
  1.33319860e-02f, 1.85510799e-01f, -8.97068158e-02f, -2.06151471e-01f, -4.91110027e-01f, 2.52414286e-01f, -2.91975886e-01f, -8.60528369e-03f, -4.88296241e-01f, 1.81087866e-01f,
  3.02033365e-01f, -2.24927440e-01f, 1.78017631e-01f, -2.36970425e-01f, -2.53834516e-01f, 2.04562113e-01f, 2.91454464e-01f, -2.46420160e-01f, 4.04011399e-01f, 2.60876920e-02f,
  2.82670468e-01f, 2.00341538e-01f, 4.13895279e-01f, -3.80834907e-01f, 2.21686736e-01f, -7.03748345e-01f, -3.30015361e-01f, 1.76149562e-01f, -4.55797642e-01f, -3.58636707e-01f,
  -9.42799151e-01f, -2.12391600e-01f, -3.51996005e-01f, 2.88982809e-01f, -4.64854181e-01f, 1.41188130e-01f, 4.42628205e-01f, -1.70480728e-01f, -2.64177740e-01f, -2.06907034e-01f,
  -7.08533823e-01f, -2.22256035e-02f, 4.42958415e-01f, -2.09839687e-01f, 1.51188821e-01f, 2.20796943e-01f, -2.24922478e-01f, 2.36749381e-01f, 5.84402978e-02f, 4.89234507e-01f,
  -3.89622241e-01f, -6.83213770e-02f, 2.86814779e-01f, 1.84863195e-01f, -2.27185562e-01f, -3.85376215e-02f, -2.70761162e-01f, 2.18195051e-01f, 3.06445211e-01f, 2.12830737e-01f,
  -5.62288642e-01f, 1.54093638e-01f, 4.11488473e-01f, -3.23277675e-02f, -2.09442809e-01f, 1.20506257e-01f, 2.22474374e-02f, 1.57707185e-02f, -2.10479423e-01f, -2.98971146e-01f,
  -7.26579279e-02f, -1.11075528e-01f, 3.19553018e-02f, 3.49322885e-01f, -1.52759358e-01f, -5.10963053e-03f, -1.02563225e-01f, -4.04788762e-01f, -2.56381601e-01f, -2.39128038e-01f,
  1.80508628e-01f, -2.86055237e-01f, 2.96073370e-02f, 3.03914517e-01f, 4.75582294e-02f, 6.94210529e-02f, -2.89135009e-01f, 3.63446712e-01f, 6.52210042e-02f, -5.78657575e-02f,
  -5.37096798e-01f, 2.23443612e-01f, 1.29819989e-01f, -2.70529389e-01f, -1.78901881e-01f, -2.17762083e-01f, -8.13033730e-02f, -1.89566519e-02f, -2.09904134e-01f, -1.83217257e-01f,
  -2.50087529e-02f, -2.74321228e-01f, -1.80518568e-01f, 1.67783529e-01f, 4.34681892e-01f, 1.89307332e-01f, 1.11242920e-01f, -1.74101427e-01f, -4.61089499e-02f, 1.99798897e-01f,
  -2.62920439e-01f, 6.06873445e-02f, -2.55712820e-03f, 2.30551623e-02f, 2.44906336e-01f, -1.71037599e-01f, -5.80594912e-02f, 6.88166916e-02f, 1.30479679e-01f, -5.02319783e-02f,
  -3.97368968e-01f, -8.23729038e-02f, -1.07638679e-01f, 5.64106330e-02f, -2.42459431e-01f, -3.21190178e-01f, -3.01976472e-01f, -2.47276291e-01f, -1.58478647e-01f, -3.28401923e-02f,
  2.94811368e-01f, -1.04934849e-01f, -2.45140865e-01f, 1.51807934e-01f, 1.51729673e-01f, 1.72342383e-03f, -1.29169941e-01f, 4.54531729e-01f, 3.07279825e-01f, 2.07576931e-01f,
  1.66699871e-01f, 1.34445116e-01f, 2.11612523e-01f, 5.18516362e-01f, -1.88104197e-01f, -9.95999426e-02f, 6.42551184e-02f, 4.85472158e-02f, 1.55389294e-01f, 4.98432457e-01f,
  2.69839346e-01f, -3.42058957e-01f, -2.37176687e-01f, 4.72310275e-01f, -5.28171547e-02f, 8.55981559e-02f, 2.70293832e-01f, 5.13251312e-02f, -2.16124371e-01f, -6.18691742e-01f,
  -4.42969985e-02f, -7.13156581e-01f, 2.28659268e-02f, -1.72687247e-02f, 1.54087216e-01f, -4.39475775e-01f, -4.90729183e-01f, -2.17818812e-01f, 1.65988877e-01f, 2.88337737e-01f,
  -2.47563064e-01f, 5.24056815e-02f, -3.97082120e-01f, 6.58343807e-02f, 9.43256468e-02f, 1.55935392e-01f, -3.32355767e-01f, 5.58772944e-02f, 1.66362211e-01f, 1.10539943e-01f,
  -4.70272869e-01f, 7.38809034e-02f, -5.54133177e-01f, -1.31358951e-01f, -7.44160339e-02f, 1.09481573e-01f, -1.63278267e-01f, 1.07868344e-01f, -1.59350783e-01f, -1.09010547e-01f,
  -2.76435196e-01f, -1.50380773e-03f, -3.15917611e-01f, -4.42202762e-02f, 3.94862294e-01f, 2.58724689e-01f, 2.85730839e-01f, -9.51448679e-02f, -1.00733377e-01f, 2.80776083e-01f,
  2.89798439e-01f, -2.12750405e-01f, -1.24170803e-01f, -4.20451969e-01f, -8.44961926e-02f, -2.92553335e-01f, 3.59957874e-01f, -2.82072365e-01f, -2.71207362e-01f, 1.05422199e-01f,
  -5.54962933e-01f, -1.41201898e-01f, -4.10943091e-01f, -2.47758895e-01f, -6.28282011e-01f, -1.98063403e-02f, -3.35945040e-01f, 2.50037819e-01f, -2.17788845e-01f, -4.99161482e-01f,
  1.21683367e-02f, 5.23006693e-02f, 2.65067279e-01f, 3.82266015e-01f, 6.92153051e-02f, 1.87525854e-01f, -3.23723145e-02f, -4.37485516e-01f, 1.16815589e-01f, 5.77524006e-02f,
  2.06132814e-01f, 1.85655449e-02f, -1.60909399e-01f, -2.98443675e-01f, -1.25449058e-02f, 4.62433361e-02f, 2.61720687e-01f, 2.77557135e-01f, -1.41795287e-02f, -4.34782393e-02f,
  -2.05838904e-01f, 1.42081037e-01f, -1.56672388e-01f, -9.49939489e-02f, -6.41227439e-02f, -2.13280976e-01f, -1.81700308e-02f, 1.09553307e-01f, -2.97578812e-01f, -2.10880917e-02f,
  -1.28781199e-01f, 1.59712955e-02f, 2.41427183e-01f, 4.09044981e-01f, 1.51785076e-01f, 2.05911845e-01f, 2.46723205e-01f, -4.54239577e-01f, -2.60631442e-01f, 2.00752020e-01f,
  1.84956476e-01f, -6.55556768e-02f, 8.25198516e-02f, -2.85473347e-01f, -3.16897988e-01f, -3.19883376e-02f, -2.41932124e-01f, -2.71102905e-01f, -3.68556410e-01f, -3.27849805e-01f,
  -2.92876959e-01f, -5.43872081e-02f, 1.52562540e-02f, 1.85075283e-01f, 2.32767001e-01f, -1.27577074e-02f, -3.12425703e-01f, -3.49318802e-01f, 4.68149871e-01f, -7.70438910e-02f,
  -2.42636949e-01f, -5.31003058e-01f, -2.37859607e-01f, -6.57692328e-02f, -2.78266162e-01f, 1.17348090e-01f, 2.80904353e-01f, 1.79040834e-01f, -5.63474476e-01f, 2.43993521e-01f,
  9.93362516e-02f, -5.38903177e-01f, -4.85161096e-02f, -5.00700295e-01f, 2.46655107e-01f, -2.64228702e-01f, 1.94762796e-01f, 1.19267656e-02f, -1.04903011e-03f, 3.69424492e-01f,
  -2.35530972e-01f, 2.07058251e-01f, -2.97658831e-01f, 1.15053460e-01f, -7.11978525e-02f, 1.64984584e-01f, -2.49109134e-01f, 2.11922184e-01f, -2.90370345e-01f, -4.44502942e-02f,
  1.68694213e-01f, 1.09421007e-01f, 2.41556972e-01f, 4.29047868e-02f, 9.61978137e-02f, -2.00869262e-01f, -4.14989367e-02f, 5.85039556e-01f, 2.76730135e-02f, 2.28321046e-01f,
  4.30438846e-01f, -2.25098848e-01f, 1.53226629e-01f, -2.76954114e-01f, -6.01604721e-03f, -5.89993931e-02f, 8.07971507e-02f, -5.03696203e-01f, -1.58997715e-01f, -6.73208714e-01f,
  2.71485746e-01f, 6.19128160e-02f, 3.74058075e-02f, 1.28320187e-01f, 9.73982736e-02f, -3.05718571e-01f, 4.70445454e-01f, -1.82002947e-01f, -1.22539997e-01f, -4.08032894e-01f,
  6.38847053e-02f, -4.34418887e-01f, 1.60940289e-01f, -4.28685457e-01f, -2.52738237e-01f, -4.93249297e-02f, 1.98456749e-01f, -3.13379228e-01f, -5.61806895e-02f, 2.36013070e-01f,
  -3.92638683e-01f, 4.24364209e-01f, -4.78115410e-01f, -3.03651750e-01f, -1.93432476e-02f, 1.74026519e-01f, -3.56786996e-01f, 2.88682848e-01f, 3.55979323e-01f, -2.39421934e-01f,
  1.25725418e-01f, 1.30453303e-01f, -3.77029240e-01f, 2.43598059e-01f, 2.57108390e-01f, -3.96802843e-01f, -1.96649000e-01f, -2.67323643e-01f, 1.72294885e-01f, -2.75479466e-01f,
  -3.05136628e-02f, 3.85977566e-01f, 3.38915884e-02f, 1.12915523e-01f, 4.99445647e-01f, -6.86854869e-02f, 3.56191963e-01f, -5.13966195e-02f, -1.88438669e-01f, -2.62101352e-01f,
  2.29247183e-01f, -1.95427224e-01f, 1.90317973e-01f, 3.22167128e-01f, -7.26494268e-02f, 1.19022936e-01f, -2.64541090e-01f, 3.57648820e-01f, 2.55124241e-01f, 2.86857158e-01f,
  -1.63182288e-01f, 1.54639378e-01f, 2.47819394e-01f, -1.58699036e-01f, 1.64607808e-01f, 2.75303781e-01f, -2.72003055e-01f, 5.22460341e-01f, -1.56326534e-03f, 1.55815482e-01f,
  -1.49718523e-01f, 4.07775752e-02f, 4.03520882e-01f, -1.38335764e-01f, 6.30066544e-02f, 2.66628325e-01f, -4.89076912e-01f, 3.07307541e-01f, -6.21502995e-02f, 1.19272701e-01f,
  -2.87633330e-01f, 1.17771208e-01f, 1.30890399e-01f, 4.43646125e-02f, 1.70474485e-01f, -6.39778197e-01f, -1.61367491e-01f, 1.51323229e-01f, -7.85240054e-01f, -4.58089739e-01f,
  7.86616206e-02f, 2.09139466e-01f, 4.23129976e-01f, -1.94322020e-01f, -3.78946424e-01f, -1.67811409e-01f, 2.36591301e-03f, -5.90928979e-02f, 2.32109189e-01f, -8.66238996e-02f,
  1.67316243e-01f, -1.54275775e-01f, 1.10513680e-01f, 2.25541994e-01f, -2.64765382e-01f, -2.04120412e-01f, 3.19137335e-01f, 2.72938497e-02f, -3.04261744e-01f, -4.34940904e-02f,
  -5.21288335e-01f, -2.80012280e-01f, -2.88106263e-01f, -3.02782834e-01f, 2.19917864e-01f, 1.82177618e-01f, 1.73131943e-01f, 7.42019117e-02f, 2.86101520e-01f, 2.44835749e-01f,
  -3.44735831e-02f, -3.42420161e-01f, -3.23419750e-01f, 1.32095546e-01f, -5.15041292e-01f, -6.21408045e-01f, 3.13903093e-01f, 5.43742120e-01f, -3.06359436e-02f, 2.07441360e-01f,
  3.08992594e-01f, -2.21229196e-01f, 1.53422728e-01f, 1.80767030e-01f, 3.48394573e-01f, -1.82570785e-01f, -2.52579570e-01f, 4.88900065e-01f, 1.13512486e-01f, -2.09844157e-01f,
  -3.09368402e-01f, -1.59551233e-01f, -3.50353241e-01f, -7.39614606e-01f, -2.23847583e-01f, -4.31022286e-01f, -7.27769174e-03f, -1.74959749e-02f, -6.76427186e-01f, -3.41558367e-01f,
  2.75554597e-01f, -1.05344228e-01f, 3.16610694e-01f, 4.80571091e-01f, -7.00507388e-02f, 2.50449866e-01f, -7.02724978e-02f, 3.39690894e-02f, -2.19083354e-01f, 2.46993065e-01f,
  3.97290617e-01f, -7.22980425e-02f, -3.06833863e-01f, -1.09889925e-01f, 3.17720592e-01f, -1.43921375e-01f, 4.60069984e-01f, -2.34840870e-01f, 1.08098805e-01f, -1.48584098e-01f,
  4.33336288e-01f, 8.18707570e-02f, 9.67603028e-02f, -6.55672513e-03f, 1.78868920e-01f, -1.58347815e-01f, 1.33102000e-01f, 2.53316581e-01f, 9.15633813e-02f, -3.61898124e-01f,
  2.22231448e-01f, 2.65333265e-01f, -4.70705956e-01f, 4.80020940e-01f, 9.17591993e-03f, -5.53409830e-02f, 1.95939198e-01f, 2.23502710e-01f, 3.15037727e-01f, -9.69866291e-02f,
  2.04744369e-01f, 9.53791142e-02f, -4.07800913e-01f, 1.60769463e-01f, -2.13412285e-01f, -3.53999659e-02f, -2.44332373e-01f, -2.33565122e-01f, -3.59835476e-01f, 1.72426105e-01f,
  -3.23730588e-01f, 7.55472705e-02f, 5.72781324e-01f, 3.42706025e-01f, 2.11148411e-01f, -1.94825888e-01f, -4.64960247e-01f, -6.78484961e-02f, -4.84002203e-01f, -4.60732102e-01f,
  2.92355835e-01f, 3.54868472e-02f, -5.08279130e-02f, 1.78045109e-01f, 3.75451505e-01f, -1.53854430e-01f, -5.08867562e-01f, 3.28265607e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.14876056e-02f, -7.13221133e-02f, 1.47750899e-01f, -1.38288990e-01f, 6.22914843e-02f, -4.52273674e-02f, -3.12335207e-03f, 2.62726955e-02f, 6.52672723e-02f, -9.95683149e-02f,
  4.83949296e-02f, -8.23033378e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    