/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.69474328e-01f, 5.17465532e-01f, 2.70607203e-01f, 1.02673560e-01f, -3.59674901e-01f, -2.82204058e-02f, 7.75742456e-02f, 6.39594570e-02f, -7.06691369e-02f, 2.96500772e-01f,
  -4.15299088e-03f, 7.77557194e-02f, 1.35158107e-01f, 2.66141862e-01f, -3.51288468e-01f, 2.13477656e-01f, 1.73045814e-01f, 1.18154146e-01f, -6.68182671e-02f, 6.34768158e-02f,
  -8.74291807e-02f, -2.09657010e-03f, 1.48981556e-01f, 3.76372272e-03f, -1.15172386e-01f, 4.14356999e-02f, -4.75911843e-03f, 6.04945123e-02f, 9.85564291e-02f, -8.29207376e-02f,
  -3.67492810e-02f, 1.66322589e-01f, 3.29807475e-02f, 2.11335570e-02f, 3.99971530e-02f, 4.90056053e-02f, -6.07144125e-02f, 1.71827190e-02f, -2.64837295e-02f, -2.23885924e-02f,
  -4.13336605e-02f, -3.26061174e-02f, 4.34562080e-02f, -3.00124213e-02f, -9.60201398e-02f, -1.75745878e-02f, -1.21505246e-01f, 2.84239203e-02f, 1.04045391e-01f, 1.52776744e-02f,
  -7.07149580e-02f, 3.24753225e-02f, 3.14944750e-03f, 3.17176394e-02f, -1.96277164e-02f, 6.38565049e-02f, 1.17699079e-01f, -4.96395938e-02f, -3.28878569e-03f, -7.30890930e-02f,
  -1.22903019e-01f, 1.09710312e-02f, 5.38144782e-02f, -5.32116033e-02f, 1.46796601e-02f, -5.67096360e-02f, -1.34015512e-02f, -5.96002676e-02f, 2.86017340e-02f, -8.16254243e-02f,
  7.52616627e-03f, -2.22958215e-02f, -9.00521353e-02f, 9.36699659e-03f, -8.71245004e-03f, 9.64381546e-03f, -2.72271838e-02f, 6.01915158e-02f, -5.77430204e-02f, -2.40144301e-02f,
  5.42361140e-02f, -6.02857843e-02f, 9.18719918e-02f, -4.12462167e-02f, 2.06683595e-02f, 1.96576733e-02f, 1.26691973e-02f, -1.63192246e-02f, -2.33271271e-02f, -5.70313409e-02f,
  1.56296253e-01f, 1.33026406e-01f, 8.33441913e-02f, -3.05087306e-03f, -2.47615273e-03f, -1.19654603e-01f, 3.06949560e-02f, -8.55171606e-02f, 1.07148580e-01f, -1.47503344e-02f,
  -6.18005134e-02f, 6.40090406e-02f, -1.76762212e-02f, -1.89680641e-03f, 4.58339676e-02f, 3.21803093e-02f, 1.35787651e-01f, -1.48911802e-02f, -4.97298986e-02f, 2.42812131e-02f,
  6.76282570e-02f, -7.43330568e-02f, -5.37199080e-02f, -5.25845140e-02f, -2.44009551e-02f, -5.45748025e-02f, -1.38442650e-01f, 4.13042791e-02f, -4.97452132e-02f, 8.66718739e-02f,
  -6.23356402e-01f, 6.79074228e-02f, -5.60623169e-01f, 1.30153462e-01f, -6.10219426e-02f, 6.08326137e-01f, -3.46661843e-02f, 8.49998295e-02f, -1.00743845e-01f, 1.57632157e-01f,
  1.14089392e-01f, -1.00046247e-01f, -1.35549277e-01f, 1.80127963e-01f, 1.23820178e-01f, 3.85751575e-02f, 1.19377322e-01f, 3.88256498e-02f, -2.47547198e-02f, -6.24128170e-02f,
  -8.27535540e-02f, 4.23679471e-01f, -1.60745889e-01f, 1.73959374e-01f, -8.02858472e-02f, -2.93127839e-02f, -6.74057007e-02f, -8.39080811e-02f, 7.92097896e-02f, 7.01674297e-02f,
  2.52318960e-02f, -2.60332644e-01f, -1.52809739e-01f, -5.50652035e-02f, -5.01261791e-03f, -5.85329644e-02f, -3.33749577e-02f, -6.22415617e-02f, -4.59747687e-02f, -7.77689368e-03f,
  1.24787008e-02f, -3.42519581e-02f, 1.09736202e-02f, 3.05167772e-02f, 1.47012491e-02f, -2.02029552e-02f, -1.19245118e-02f, -5.04001044e-02f, -3.25635821e-02f, -5.61098792e-02f,
  -2.57962141e-02f, -6.20797789e-03f, -8.65775570e-02f, -4.97345719e-03f, -2.15240531e-02f, -4.77403291e-02f, -1.16033189e-01f, 4.50952090e-02f, 4.23994847e-02f, 6.44465238e-02f,
  3.41589078e-02f, -1.89266782e-02f, -1.83029920e-02f, -1.23788416e-02f, -1.64119769e-02f, -3.39007601e-02f, 4.13148366e-02f, -4.18850854e-02f, -4.80397157e-02f, 9.57970787e-03f,
  1.33519480e-02f, -7.86661655e-02f, 1.85181946e-02f, -4.56568561e-02f, -2.17955257e-03f, -4.43672342e-03f, -2.54321769e-02f, -1.87214687e-02f, 2.18103547e-02f, 6.18236177e-02f,
  -4.29868177e-02f, 8.85633286e-03f, 1.02129281e-02f, 4.89882864e-02f, 6.62914431e-03f, -4.88377437e-02f, -7.15294760e-03f, -1.54550849e-02f, -2.99477912e-02f, 3.26949317e-04f,
  3.04408640e-01f, 3.31630588e-01f, 1.00101337e-01f, 3.93720120e-02f, 6.00510859e-04f, 4.34213392e-02f, 6.66895211e-02f, 8.10361579e-02f, 1.30105400e-02f, 5.71645536e-02f,
  2.12101992e-02f, 2.57983711e-02f, 2.68592453e-03f, -2.28036866e-02f, 4.01286818e-02f, 7.25366324e-02f, -1.82443094e-02f, -2.68840929e-03f, 7.49918148e-02f, -2.56386101e-02f,
  -8.57651886e-03f, -3.08447238e-02f, -1.11300498e-02f, 1.21384487e-01f, 6.97697885e-03f, 4.51730229e-02f, 1.28957331e-01f, -6.68573231e-02f, 1.93472914e-02f, -3.86404619e-03f,
  8.71271312e-01f, -1.06501982e-01f, 1.63252875e-01f, 4.22737837e-01f, 2.03655362e-01f, 3.12429845e-01f, 3.55516791e-01f, -5.77683523e-02f, 2.34707803e-01f, -1.25953496e-01f,
  1.04739688e-01f, -1.44018680e-01f, -7.85184205e-02f, 3.49480622e-02f, 4.48403984e-01f, -3.32394093e-02f, 2.61135638e-01f, -4.45476547e-03f, 6.88364264e-03f, -1.09496899e-01f,
  1.88226238e-01f, 1.07518747e-01f, 1.00782298e-01f, -9.78758633e-02f, 3.75794806e-02f, -1.20408051e-01f, -6.56724498e-02f, -7.31974244e-02f, -1.15444381e-02f, 9.06820688e-03f,
  5.13965860e-02f, -8.78461152e-02f, 2.63534095e-02f, -1.34889290e-01f, 5.75432852e-02f, 4.26432081e-02f, -8.08751583e-02f, -1.00540249e-02f, 9.89168510e-02f, -4.47420701e-02f,
  -4.62324470e-02f, 1.97438635e-02f, 1.35303137e-03f, -3.10199801e-02f, 2.04148460e-02f, 4.65681218e-03f, 7.36322477e-02f, 7.03812242e-02f, -4.10550684e-02f, -2.31758207e-02f,
  4.16757837e-02f, 5.40480390e-02f, 2.60061640e-02f, 1.05406940e-02f, 6.56267852e-02f, 1.30042182e-02f, -2.96172891e-02f, 5.79561479e-02f, -7.96041861e-02f, 9.56519991e-02f,
  -1.52432090e-02f, 1.86575688e-02f, 2.66905818e-02f, 1.50133763e-02f, 6.35099933e-02f, 2.72843800e-02f, 3.49535607e-02f, -4.83952314e-02f, 3.20422351e-02f, -4.30647703e-03f,
  5.21687120e-02f, 3.22599709e-02f, 4.01076414e-02f, 3.13908346e-02f, 5.55015132e-02f, 4.57091304e-03f, -1.25410631e-02f, -9.19157192e-02f, 1.90074127e-02f, 3.46882232e-02f,
  -1.45011488e-02f, 4.45237849e-03f, -5.18519990e-02f, -5.42709865e-02f, 3.69517729e-02f, 5.45830233e-03f, 2.53830608e-02f, 2.41999570e-02f, 2.17708815e-02f, 1.45031158e-02f,
  -5.97536862e-02f, -1.21173047e-01f, -6.43753214e-03f, 1.75296851e-02f, -6.02685362e-02f, -4.35446724e-02f, 6.16746284e-02f, 2.48369891e-02f, -6.64236248e-02f, 1.54494241e-01f,
  -2.76458357e-03f, 1.84616894e-02f, 7.13811293e-02f, 1.00517139e-01f, -1.01483229e-03f, -4.01866762e-03f, -1.16079655e-02f, -7.77598694e-02f, 4.99062538e-02f, -1.03033289e-01f,
  -2.53732353e-02f, 2.06572295e-04f, 3.06197209e-03f, 3.94143090e-02f, 7.51987519e-03f, 6.13813614e-03f, 9.66615081e-02f, -9.99817904e-03f, 3.27479877e-02f, -5.95541783e-02f,
  -8.53989720e-01f, -2.76275694e-01f, -1.10474207e-01f, -4.34418619e-01f, -1.66363120e-01f, 2.44254127e-01f, -2.93033361e-01f, -3.29770260e-02f, -1.61566943e-01f, -8.22260007e-02f,
  2.49997303e-02f, -2.95568168e-01f, -3.26641910e-02f, -4.65727001e-02f, -1.67004392e-01f, 1.12306409e-01f, -1.91397458e-01f, -2.22188517e-01f, 5.03708459e-02f, -2.13259622e-01f,
  -1.00211591e-01f, -1.12114832e-01f, -9.82633010e-02f, 2.13420048e-01f, -1.12661727e-01f, 8.27180445e-02f, -1.44154578e-01f, 2.85930987e-02f, -7.75867375e-03f, 8.42230171e-02f,
  1.37287274e-01f, 3.62341292e-02f, 1.18010908e-01f, -4.38665077e-02f, -6.38051480e-02f, -2.12177541e-02f, -3.50093395e-02f, 1.03910595e-01f, 5.50102741e-02f, 4.74283807e-02f,
  -4.28352728e-02f, 1.05415799e-01f, 1.16482973e-01f, 7.26991370e-02f, -4.04376201e-02f, -3.57522145e-02f, 5.14565874e-03f, -6.12927862e-02f, 2.86356900e-02f, 4.00565751e-02f,
  1.22094555e-02f, 2.21692864e-02f, -1.34670258e-01f, -7.73821585e-03f, 4.30215672e-02f, 7.35818669e-02f, -1.33882361e-02f, 1.66903585e-02f, -1.52798012e-01f, 2.51804981e-02f,
  1.18148141e-01f, 6.59713820e-02f, 6.53144345e-02f, 4.01662812e-02f, 2.66273171e-02f, 4.61142436e-02f, 6.84099495e-02f, 6.30621463e-02f, 1.99052673e-02f, -6.83171153e-02f,
  3.20341550e-02f, -9.14452821e-02f, 1.40838567e-02f, 9.73590999e-04f, -4.93323319e-02f, 2.34409850e-02f, 9.98498127e-03f, -4.54850309e-02f, 3.44026424e-02f, -8.74829963e-02f,
  -2.82671507e-02f, -2.23022476e-02f, -6.40430003e-02f, -5.81401326e-02f, -1.05988802e-02f, 7.04838932e-02f, 1.31131196e-02f, -2.59535965e-02f, -2.23326287e-03f, 1.70594901e-02f,
  -2.76217818e-01f, -5.07060826e-01f, -6.19490910e-03f, -4.76749800e-02f, 6.58293515e-02f, -2.74185999e-03f, -1.94920134e-02f, 1.42269079e-02f, -6.37197718e-02f, -4.37173732e-02f,
  -3.37759070e-02f, -1.01304032e-01f, -1.15729392e-01f, -2.05322970e-02f, -1.98275340e-03f, 8.36119801e-03f, 1.79563975e-03f, 6.77558780e-03f, -9.38739181e-02f, -9.87343192e-02f,
  -1.83244124e-02f, -4.43449356e-02f, 9.66051742e-02f, -5.33710234e-02f, 6.75430223e-02f, -3.19155790e-02f, -1.00693993e-01f, -3.28348465e-02f, 6.12432584e-02f, 6.27237335e-02f,
  -5.73125243e-01f, -3.39409351e-01f, -1.18433163e-01f, 5.85766099e-02f, 2.69765276e-02f, -1.09227493e-01f, 3.11415344e-01f, -4.22683246e-02f, -4.15332258e-01f, 7.10063130e-02f,
  3.81141692e-01f, -1.39644071e-01f, 1.54252470e-01f, 1.35088474e-01f, 2.12613925e-01f, 5.43712229e-02f, 1.17579080e-01f, -2.79514492e-02f, -1.21226951e-01f, -5.06193377e-02f,
  2.42356751e-02f, 1.44261405e-01f, 2.77416229e-01f, 2.03834716e-02f, 9.30063776e-04f, -1.08365543e-01f, 2.13461652e-01f, 9.87214446e-02f, 1.87381431e-02f, -2.76654586e-02f,
  2.93575913e-01f, -1.17713325e-01f, 2.55159400e-02f, -1.14011012e-01f, -6.41503632e-02f, 2.93973889e-02f, 1.01254195e-01f, 1.25201419e-01f, 1.30716398e-01f, -3.96528952e-02f,
  -5.72669832e-03f, -1.10834418e-02f, -6.43418916e-03f, -4.37659696e-02f, -1.04285181e-01f, -1.04187325e-01f, -1.34316189e-02f, 3.86047885e-02f, -6.22074604e-02f, 5.46641909e-02f,
  -3.35589312e-02f, 4.09938842e-02f, 2.19892282e-02f, 3.77193317e-02f, -6.31155893e-02f, -3.15271318e-02f, 2.15581767e-02f, -4.06939425e-02f, 2.16712113e-02f, -5.81927449e-02f,
  -1.05747707e-01f, -7.91373849e-02f, -1.69877596e-02f, 3.31625752e-02f, 2.66537089e-02f, 1.07737649e-02f, 1.19333677e-02f, 5.52532040e-02f, -2.57285945e-02f, 3.66199911e-02f,
  1.00655276e-02f, 1.94896627e-02f, -4.99425717e-02f, -2.65904516e-02f, -6.70578750e-03f, 3.85684776e-03f, 2.37923339e-02f, 1.06206052e-02f, -5.18689714e-02f, 7.44373575e-02f,
  7.77516589e-02f, -4.12997752e-02f, -3.07839811e-02f, 5.76107875e-02f, 4.49188277e-02f, 4.05298807e-02f, -9.12242308e-02f, 2.54319310e-02f, 6.15302799e-03f, 7.89996088e-02f,
  -8.91789272e-02f, -2.50091106e-01f, 2.10521859e-03f, 2.94046476e-02f, 8.06188658e-02f, -6.37937337e-02f, -7.00088665e-02f, -2.70688366e-02f, -1.04465224e-01f, 4.05332446e-02f,
  -4.42620041e-03f, 1.65083278e-02f, -2.42777523e-02f, 5.72031513e-02f, 4.46250616e-03f, 1.22263329e-02f, -3.08973715e-02f, -1.08286021e-02f, 6.93897754e-02f, 4.63335635e-03f,
  2.99397539e-02f, -6.02309331e-02f, -4.12250385e-02f, 2.15669908e-02f, 5.79430461e-02f, 4.57292534e-02f, -1.04251452e-01f, -1.78264955e-03f, 7.78355822e-02f, -2.18305644e-02f,
  2.54797369e-01f, -9.72145330e-03f, -9.81265977e-02f, 2.76732743e-01f, 8.27312842e-02f, 5.34166574e-01f, 5.18158555e-01f, -2.90655475e-02f, 8.26906785e-02f, 2.25797579e-01f,
  4.51534986e-02f, 3.51283699e-01f, -2.59907600e-02f, 2.10785955e-01f, 8.77729990e-03f, 8.93590320e-03f, 2.98743576e-01f, 3.17585796e-01f, -6.05353080e-02f, 6.00379109e-02f,
  -3.96772511e-02f, 3.71940024e-02f, -9.23902169e-02f, -1.41007319e-01f, 6.43442348e-02f, -2.66095307e-02f, -1.70169652e-01f, -9.31040719e-02f, 1.29224383e-03f, 8.87781940e-03f,
  4.60994877e-02f, -1.43791780e-01f, -1.12263737e-02f, 7.54843876e-02f, 2.74694860e-02f, -2.52051204e-02f, 1.45903692e-01f, 1.30234316e-01f, 2.63037588e-02f, 5.38833020e-03f,
  1.00893714e-01f, -6.02905825e-02f, 1.55912891e-01f, 2.60752775e-02f, 9.09997597e-02f, -9.20680985e-02f, -7.58536234e-02f, -6.68879822e-02f, 5.11562219e-03f, -2.56636981e-02f,
  3.60129215e-02f, 1.77050440e-03f, -8.29299092e-02f, 3.17462385e-02f, -3.60859744e-02f, -3.51534411e-02f, 6.37069345e-02f, -1.39943939e-02f, 4.35993411e-02f, 8.01555738e-02f,
  -2.86171269e-02f, 1.42216394e-02f, -1.09564168e-02f, -4.80136722e-02f, -1.83467269e-02f, -6.11838810e-02f, 8.31549466e-02f, 1.39049571e-02f, 4.62119170e-02f, 4.47422080e-02f,
  -9.13695991e-03f, 1.00635178e-02f, -1.91774145e-02f, 2.82264743e-02f, -6.60478091e-03f, 5.14631383e-02f, 4.31970209e-02f, -7.62813985e-02f, 1.15218222e-01f, -1.31212361e-02f,
  -3.74882966e-02f, -7.24718943e-02f, -5.69818802e-02f, -1.50123090e-02f, -9.81266722e-02f, -6.61254962e-05f, 4.96882433e-03f, -4.63216528e-02f, 2.02559568e-02f, 8.08880851e-02f,
  4.85251695e-02f, 1.28843278e-01f, 1.34791983e-02f, 1.39199570e-02f, 7.80282840e-02f, 3.92920710e-02f, -2.12750155e-02f, -3.56619582e-02f, 3.77918743e-02f, -6.80784807e-02f,
  -9.55539495e-02f, 7.31058419e-02f, -4.97955382e-02f, -9.77295041e-02f, 8.36024154e-03f, 6.15523718e-02f, -2.91334111e-02f, 1.86507046e-01f, -2.01929398e-02f, 1.87964849e-02f,
  -5.05867191e-02f, -6.45184936e-03f, 5.70560209e-02f, -5.06058112e-02f, 8.16823095e-02f, 4.26641256e-02f, -4.63386588e-02f, 5.97310178e-02f, -1.56038301e-02f, 2.01114267e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.82148921e-01f, -2.95859694e-01f, 1.62887916e-01f, -9.93228674e-01f, -3.76141131e-01f, 3.89429897e-01f, 2.31293723e-01f, -6.91706896e-01f, -5.32777190e-01f, -3.53969753e-01f,
  -5.59492767e-01f, 2.13158339e-01f, 8.31262410e-01f, -7.47357905e-01f, 1.36934268e+00f, 9.08155441e-01f, -3.46659303e-01f, 2.12194994e-02f, -2.35091209e-01f, -5.91466784e-01f,
  -2.53972411e-01f, -5.35069644e-01f, 3.48294139e-01f, -5.59745848e-01f, -7.44618058e-01f, -4.85870868e-01f, 6.20122328e-02f, 2.69556612e-01f, -4.55706894e-01f, 2.94478685e-01f,
  -5.07881939e-01f, -7.40306735e-01f, -3.86377066e-01f, 1.83908015e-01f, -2.26815566e-01f, -1.75064057e-02f, 1.23643547e-01f, 4.05647099e-01f, -1.87427327e-01f, -2.19966341e-02f,
  1.42979085e-01f, 3.15219834e-02f, -3.80437821e-01f, 1.57848120e-01f, -2.42719389e-02f, -8.12668800e-02f, -3.97203378e-02f, -2.18589976e-01f, -1.30541459e-01f, 6.95967451e-02f,
  -1.11257106e-01f, -1.58165425e-01f, -3.18288952e-01f, 1.04205027e-01f, 8.16229954e-02f, -2.52781987e-01f, 9.91284996e-02f, 4.96395290e-01f, -2.98436196e-03f, -1.26058251e-01f,
  3.41039188e-02f, 1.20280892e-01f, 7.42592365e-02f, -1.84233516e-01f, 3.51112895e-02f, -1.49277344e-01f, -2.46179000e-01f, 6.53216168e-02f, -1.35170743e-01f, -2.00662568e-01f,
  -2.59728640e-01f, -1.18079565e-01f, -3.61607298e-02f, -9.31885689e-02f, -9.90850851e-02f, -1.87564418e-01f, -2.54096910e-02f, -6.22132234e-02f, -3.93247120e-02f, 8.21917281e-02f,
  -1.19399307e-02f, 4.77910563e-02f, -2.68623140e-02f, 4.72939797e-02f, -5.58971912e-02f, 1.91758409e-01f, 3.07883006e-02f, 2.77088862e-02f, 1.96458399e-02f, 1.51850536e-01f,
  -3.16125341e-02f, 1.90468222e-01f, -1.40326247e-01f, -1.67412460e-01f, -1.54307829e-02f, -1.01085296e-02f, 7.03254575e-03f, -2.18410671e-01f, 1.11680694e-01f, -8.10516328e-02f,
  -1.02401078e-01f, 8.28987211e-02f, 1.06754184e-01f, -2.05249012e-01f, 1.37624621e-01f, -6.55557960e-02f, 1.04856171e-01f, 1.96396429e-02f, -2.00959355e-01f, -1.10206030e-01f,
  -1.60271470e-02f, 1.86461553e-01f, 2.77017653e-01f, -7.39056021e-02f, -3.31124902e-01f, 1.09026022e-01f, -1.03293113e-01f, -8.35772604e-02f, 1.06898881e-02f, -2.68898904e-02f,
  -9.71764207e-01f, 5.09886518e-02f, -8.99124503e-01f, -5.23983777e-01f, 1.47450268e-01f, -3.74400198e-01f, -5.21328807e-01f, -3.37351233e-01f, -4.05659854e-01f, 6.25774860e-01f,
  -3.41092229e-01f, -1.48484886e-01f, 3.18180770e-02f, -1.41076076e+00f, -1.91013527e+00f, -6.96849048e-01f, -1.23002172e+00f, -2.78190881e-01f, -3.48335117e-01f, -6.08502805e-01f,
  -5.89137614e-01f, -6.97761118e-01f, -7.60806382e-01f, 1.36498272e-01f, -3.45065922e-01f, 2.81322807e-01f, 4.64101404e-01f, 6.43397629e-01f, 1.13533013e-01f, -1.93967625e-01f,
  -4.08883005e-01f, -6.20116619e-03f, 6.91861957e-02f, -3.17204297e-01f, 3.27769481e-02f, 1.02040388e-01f, 1.24582000e-01f, 2.75563180e-01f, 1.02014177e-01f, -2.03824580e-01f,
  -1.14452448e-02f, 7.19505623e-02f, -3.87711704e-01f, 4.64010797e-02f, -1.30237311e-01f, -1.51664138e-01f, -2.06837486e-02f, 7.00074732e-02f, 1.18721783e-01f, -1.72543555e-01f,
  -1.40598282e-01f, 3.51913758e-02f, -4.59958203e-02f, 7.49212131e-02f, 4.78882790e-02f, -2.15404928e-01f, -5.91971725e-02f, 2.13236436e-01f, -1.05989827e-02f, -5.16202161e-03f,
  -9.51241478e-02f, 1.24069422e-01f, -1.02392480e-01f, 1.17357075e-02f, 5.47284223e-02f, 1.04306199e-01f, -3.44548710e-02f, 7.60750845e-02f, 1.15975976e-01f, -1.02163717e-01f,
  -3.42633910e-02f, -5.68616949e-03f, -6.60065711e-02f, -1.45602990e-02f, -1.40214220e-01f, -2.99067721e-02f, -8.03374872e-02f, -6.39974549e-02f, -2.14724839e-01f, -6.17229789e-02f,
  -6.67035878e-02f, 1.14174020e-02f, 5.99829257e-02f, 5.09721972e-03f, -9.87142846e-02f, 1.14654168e-01f, 1.71594486e-01f, 8.77598152e-02f, 1.60218626e-01f, -5.36470637e-02f,
  -6.93607703e-02f, 3.45915498e-04f, 7.70172803e-04f, 1.90278932e-01f, -1.06944248e-01f, -6.18690886e-02f, -3.61442149e-01f, -9.67624187e-02f, 8.24876428e-02f, -6.64066523e-02f,
  7.15290830e-02f, 1.97064459e-01f, 1.98635593e-01f, -2.28120089e-01f, 1.12669863e-01f, -1.43433794e-01f, 9.68439132e-02f, 2.39021212e-01f, -1.25831440e-02f, 6.09718747e-02f,
  2.46915311e-01f, -3.54933143e-02f, 1.16077021e-01f, 1.45113558e-01f, -7.03508034e-02f, 2.66069412e-01f, 6.62392750e-02f, 2.60284632e-01f, 9.06146467e-02f, -1.44434527e-01f,
  1.41541183e-01f, -4.52961028e-01f, -8.75598431e-01f, 2.21071276e-03f, 4.16464031e-01f, -2.90982537e-02f, -7.77019918e-01f, 9.27799493e-02f, -1.07409894e+00f, 3.47950874e-04f,
  4.57841754e-02f, -3.40103582e-02f, -4.72420335e-01f, 1.65022220e-02f, 7.50782728e-01f, -8.25922847e-01f, 6.63764954e-01f, 2.68426985e-01f, -5.49886465e-01f, 7.49854386e-01f,
  8.19948241e-02f, 8.11137021e-01f, 1.95692226e-01f, 7.65492737e-01f, 2.63505518e-01f, 3.90816569e-01f, 1.65315032e+00f, 6.07430451e-02f, 1.08170998e+00f, 3.61386359e-01f,
  -2.47267812e-01f, -1.64688751e-01f, -7.84491003e-02f, -1.31955013e-01f, 1.56689465e-01f, 2.90388614e-01f, 3.65438998e-01f, 9.99056920e-02f, -2.65599847e-01f, -1.95638966e-02f,
  -1.48332044e-01f, 2.26110488e-01f, -3.59861888e-02f, -1.38108253e-01f, -7.94548690e-02f, 4.88202646e-02f, -1.26376107e-01f, -1.97659627e-01f, -4.04275566e-01f, -6.67586476e-02f,
  -3.83735746e-01f, -2.20058233e-01f, -3.82751040e-02f, 1.58437982e-01f, 6.89044669e-02f, 8.20352733e-02f, -9.39772204e-02f, 5.93313724e-02f, -2.55984254e-02f, 9.40528810e-02f,
  2.39942402e-01f, 2.77109951e-01f, -8.51749815e-03f, -2.60880560e-01f, 4.55754101e-02f, -1.90833464e-01f, -8.94164946e-03f, 1.56386673e-01f, -1.16180338e-01f, -6.15337268e-02f,
  3.95637564e-02f, -4.68843244e-02f, -1.00561880e-01f, 9.35040712e-02f, 1.31599784e-01f, -1.94004551e-01f, 3.96853164e-02f, -3.02116685e-02f, 3.22520584e-02f, -2.28294432e-01f,
  -2.00781420e-01f, 1.61570176e-01f, 7.12170638e-03f, -1.90975703e-02f, -3.30221295e-01f, 1.36192366e-01f, 2.44832590e-01f, -1.37483045e-01f, -1.14144422e-01f, 1.01133592e-01f,
  5.00155613e-02f, 9.23320711e-01f, -1.90675199e-01f, -1.05052255e-01f, -2.39974141e-01f, 2.06445754e-01f, -2.10191503e-01f, 1.22107178e-01f, 7.75514469e-02f, -8.35083053e-02f,
  4.36485291e-01f, -3.83821726e-02f, 1.19768664e-01f, 1.15203410e-01f, 3.13658752e-02f, 1.85250223e-01f, 2.01081470e-01f, 1.48732156e-01f, 2.71981180e-01f, 2.68592685e-01f,
  1.73942327e-01f, 1.73819840e-01f, 9.21577811e-02f, -1.18020274e-01f, 1.40529513e-01f, 1.82008088e-01f, 1.25840798e-01f, -2.75734998e-02f, 1.00352682e-01f, 1.38203744e-02f,
  1.36580735e-01f, 3.46528500e-01f, -1.16722596e+00f, -4.65945512e-01f, -2.36277804e-01f, 7.41042137e-01f, 4.89815980e-01f, -3.40843916e-01f, -6.59632027e-01f, 1.02321160e+00f,
  6.12819254e-01f, -5.18611431e-01f, 8.18053842e-01f, 6.58677280e-01f, -6.30099177e-01f, 7.55882621e-01f, 4.21893239e-01f, 4.21394616e-01f, -3.81575167e-01f, -1.05709858e-01f,
  -4.03436363e-01f, 8.89936924e-01f, -4.47589427e-01f, 3.30932349e-01f, -1.50529310e-01f, -5.88274181e-01f, 4.86633003e-01f, -3.20879728e-01f, 1.60832241e-01f, 4.60713021e-02f,
  4.93739657e-02f, 9.30429772e-02f, -2.94079244e-01f, -1.18474223e-01f, -1.17056191e-01f, 1.41562477e-01f, 4.71409922e-03f, -4.56642099e-02f, -3.06216806e-01f, 6.56962320e-02f,
  7.19768405e-02f, -7.41096884e-02f, -1.16932951e-01f, -1.07902631e-01f, 1.35189295e-01f, -1.96886316e-01f, -1.95831105e-01f, -1.27943516e-01f, -2.05061004e-01f, 5.19433431e-02f,
  -2.24655345e-01f, -1.31670102e-01f, -8.97470042e-02f, -3.50923873e-02f, -2.44724631e-01f, -5.45725301e-02f, -1.49097130e-01f, -9.38377983e-04f, -7.83277303e-02f, -5.13907447e-02f,
  3.09752077e-02f, 1.31508365e-01f, 2.60618389e-01f, -6.34277910e-02f, 8.23229365e-03f, -2.63482947e-02f, -6.42855987e-02f, 1.35245202e-02f, -2.50885636e-01f, 2.24392220e-01f,
  2.58146580e-02f, -9.98114571e-02f, 3.87843102e-02f, 1.16560794e-01f, 1.35782331e-01f, -3.39384861e-02f, 1.70350686e-01f, -9.08988714e-03f, -4.52383002e-03f, -1.73816413e-01f,
  -4.86643128e-02f, 1.73161656e-01f, -6.20493367e-02f, 6.23818897e-02f, 3.64229009e-02f, -7.10956380e-02f, 1.38182476e-01f, -8.09020251e-02f, 2.06781775e-02f, 3.51913422e-02f,
  -2.84119975e-02f, 8.72857645e-02f, -1.62121534e-01f, -1.20620459e-01f, -1.03186995e-01f, 1.90921128e-01f, 3.37802805e-02f, -1.23167656e-01f, 1.16564996e-04f, 3.95371486e-03f,
  1.50589779e-01f, -3.09737362e-02f, -5.20627163e-02f, -2.80028526e-02f, -1.74086928e-01f, 1.99513555e-01f, 3.21626455e-01f, -1.69259891e-01f, -5.14473878e-02f, -1.63331121e-01f,
  9.55763608e-02f, 1.49109647e-01f, 6.14659628e-03f, -5.09211421e-02f, 4.62178402e-02f, 9.08252075e-02f, -1.46739066e-01f, -2.06786335e-01f, 4.66453396e-02f, -8.40210766e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.22500968e+00f, 1.32430887e+00f, 7.87160993e-01f, 9.36386883e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -2.37361193e+00f, -8.19706738e-01f, 2.68445343e-01f, -1.73971087e-01f, -1.57155204e+00f, 3.05501074e-01f, 6.63929582e-01f, 8.68394732e-01f, -4.90766883e-01f, 1.21719599e+00f,
  1.81101382e+00f, 4.92458075e-01f, -1.93672284e-01f, -9.36363935e-01f, -1.23526716e+00f, 1.25531304e+00f, 1.20962465e+00f, -1.54238880e+00f, -3.48656833e-01f, -1.10781893e-01f,
  1.29199013e-01f, -8.36377800e-01f, -3.72497767e-01f, -2.78054893e-01f, 1.72723091e+00f, -1.40537453e+00f, 6.45617068e-01f, -2.70599782e-01f, -1.76131177e+00f, -1.07539749e+00f,
  3.52935910e-01f, 1.15906394e+00f, -8.01307678e-01f, -3.98884475e-01f, -2.00925440e-01f, 1.28200781e+00f, -1.01675391e+00f, 4.30436909e-01f, -1.93080425e+00f, 1.68883741e+00f,
  1.31937957e+00f, 7.38023162e-01f, 1.29299307e+00f, 5.51187634e-01f, -8.12697113e-01f, -5.64070165e-01f, 1.08085394e+00f, -1.72541344e+00f, -1.43170446e-01f, 6.58921897e-01f,
  -2.63729429e+00f, -1.67305911e+00f, -3.17704260e-01f, -1.36798882e+00f, 1.34358644e+00f, -5.02521098e-01f, -1.67331621e-01f, 1.21994555e+00f, 6.69598058e-02f, -1.13847637e+00f,
  -8.90520036e-01f, 9.35768902e-01f, -2.45797825e+00f, 2.48173103e-01f, 1.02819622e+00f, 1.15945494e+00f, 1.63832676e+00f, -1.69279611e+00f, 1.02517354e+00f, 1.28096390e+00f,
  1.06544936e+00f, 9.40367341e-01f, -1.52751863e+00f, 2.38634992e+00f, 4.09834385e-01f, -2.02463317e+00f, 7.38663673e-01f, -4.17978823e-01f, -8.32625866e-01f, -4.03616816e-01f,
  8.46742392e-01f, 1.13743031e+00f, 7.38944590e-01f, 5.20161927e-01f, 8.95991981e-01f, -1.20800710e+00f, 1.96773744e+00f, 2.50210595e+00f, 4.95203584e-01f, -1.02406657e+00f,
  -3.08448291e+00f, 1.78042066e+00f, 4.56738204e-01f, -2.09759045e+00f, -6.28564537e-01f, -7.81663954e-02f, -9.32907343e-01f, 1.22080910e+00f, -2.80871916e+00f, 1.14007306e+00f,
  1.87463617e+00f, 9.29808915e-01f, -2.44884038e+00f, -2.03809118e+00f, 1.38905895e+00f, -1.25061142e+00f, -1.53045678e+00f, 6.08162642e-01f, -1.17450786e+00f, -9.70716059e-01f,
  -5.67437828e-01f, -8.65475178e-01f, -1.67363095e+00f, -1.45553064e+00f, 2.68737793e-01f, -9.66284573e-01f, -1.32904780e+00f, -1.88492644e+00f, -1.60413003e+00f, -1.14760041e+00f,
  -9.07364786e-01f, -4.09216493e-01f, -1.10491359e+00f, -8.31320465e-01f, 8.63910735e-01f, 3.43901664e-01f, 3.65758166e-02f, -4.14535612e-01f, -4.38430190e-01f, 7.93690205e-01f,
  8.48935127e-01f, -1.56308746e+00f, 2.92846709e-01f, -7.04264343e-01f, 2.13405132e+00f, -1.06601024e+00f, -9.73582685e-01f, -6.54770613e-01f, 6.80764019e-01f, -1.58206427e+00f,
  -1.46133995e+00f, -1.48521745e+00f, 1.16885054e+00f, -1.15161991e+00f, -4.78592873e-01f, 1.43453822e-01f, -3.67810071e-01f, 1.40268838e+00f, -1.04930353e+00f, 2.36072809e-01f,
  -1.11319101e+00f, -1.50758350e+00f, 1.63304496e+00f, 1.55321300e-01f, 2.08183813e+00f, 7.88455248e-01f, 1.22593307e+00f, -9.53617215e-01f, -5.79627872e-01f, -5.94773710e-01f,
  5.86935222e-01f, 3.25134993e-01f, 1.11391902e-01f, 1.24521983e+00f, -2.99834222e-01f, 2.91557163e-01f, -1.00146329e+00f, 7.69712329e-01f, -1.22222161e+00f, 1.87109202e-01f,
  -1.04430830e-02f, -6.69011891e-01f, -1.08981013e+00f, 7.46267259e-01f, 2.72805363e-01f, -2.39761814e-01f, 1.17828381e+00f, -1.74208248e+00f, 1.70800412e+00f, 8.41307104e-01f,
  -1.44094825e+00f, 1.34374917e+00f, 1.35236311e+00f, -2.10758638e+00f, -1.75801921e+00f, -1.97019243e+00f, -8.25223148e-01f, 1.55982316e+00f, -1.62686634e+00f, 4.79169309e-01f,
  -1.03489780e+00f, -9.10031915e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.71316141e-01f, -3.33487302e-01f, -4.84142482e-01f, -3.02370369e-01f, 6.07456267e-01f, 4.67199296e-01f, 1.26565897e+00f, -5.48573494e-01f, 1.04896337e-01f, -7.46375442e-01f,
  -1.18763661e+00f, 1.32106185e+00f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    