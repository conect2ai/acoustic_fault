/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.82238489e-01f, -1.82632245e-02f, -1.61773652e-01f, -4.24345918e-02f, 1.45060167e-01f, 5.31189740e-01f, 3.08775008e-01f, 1.92232430e-02f, -1.88087612e-01f, -5.74062541e-02f,
  6.76984638e-02f, -2.51079082e-01f, 4.00945060e-02f, -9.92897451e-02f, 3.46847773e-01f, -2.75078546e-02f, 5.97228594e-02f, -1.26686275e-01f, -1.64818212e-01f, 5.20627312e-02f,
  7.86913410e-02f, 4.52498496e-02f, 5.96190169e-02f, 2.24771313e-02f, 1.17348179e-01f, -1.61567390e-01f, 8.20220262e-02f, -4.89067426e-03f, -7.80597329e-02f, 1.62464023e-01f,
  1.08596012e-01f, -1.54703736e-01f, -9.03984234e-02f, -9.29974541e-02f, 9.29457694e-02f, 1.04877315e-01f, 2.00029835e-02f, -2.88924016e-02f, 1.21235168e-02f, 9.29903891e-03f,
  2.59305481e-02f, 4.77458313e-02f, -1.25485465e-01f, -3.37954350e-02f, -2.39269971e-03f, -8.72827098e-02f, -1.38305034e-02f, 4.34360765e-02f, -8.66547003e-02f, -7.68745616e-02f,
  -7.81429186e-03f, -8.80450010e-03f, -4.61075967e-03f, 5.13768792e-02f, 3.19810174e-02f, -7.05026165e-02f, -4.16399799e-02f, 2.61574723e-02f, 4.01308201e-02f, -4.82841730e-02f,
  2.08717640e-02f, -1.05086647e-01f, -1.98765416e-02f, -8.93071145e-02f, -1.79516803e-03f, -9.02471691e-02f, 5.82629517e-02f, 1.19953804e-01f, -2.99939644e-02f, 9.08013210e-02f,
  4.07622159e-02f, -2.92762369e-03f, -1.45428358e-02f, 6.63611665e-02f, -1.69951878e-02f, -6.04132414e-02f, -6.00183196e-02f, -3.93666625e-02f, 1.38335720e-01f, -5.01530208e-02f,
  -2.37884056e-02f, 1.06791921e-01f, 6.91151991e-02f, 9.96166393e-02f, 1.24422356e-01f, -1.81745552e-02f, 3.94753814e-02f, 4.42633871e-03f, -1.31785929e-01f, 1.11643143e-01f,
  1.83103234e-01f, -6.67689815e-02f, 1.45160314e-02f, 6.23730831e-02f, -1.14429794e-01f, 8.67857318e-03f, -5.89458719e-02f, -2.84726452e-02f, -4.56168950e-02f, -6.54950365e-02f,
  -7.45283440e-03f, 6.00671861e-03f, 2.86454223e-02f, 4.87776473e-02f, -3.01418663e-03f, -1.16627580e-02f, 3.30350697e-02f, 7.99325705e-02f, 7.69002438e-02f, 7.87577182e-02f,
  5.77648170e-02f, 3.36206630e-02f, -3.28403488e-02f, 4.92109470e-02f, 3.56764495e-02f, 6.68773800e-02f, 2.99633890e-02f, -9.69493389e-02f, -4.02433984e-02f, -6.26518130e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.44860962e-01f, -2.32813969e-01f, -4.28973198e-01f, -4.67518985e-01f, -3.96855809e-02f, -3.70687753e-01f, -4.03519779e-01f, -2.06650376e-01f, -2.50204772e-01f, 2.34881133e-01f,
  -4.38262485e-02f, -2.42042273e-01f, 2.91853517e-01f, -6.98378026e-01f, -5.61143875e-01f, -2.30828986e-01f, -6.08688533e-01f, -3.95658076e-01f, 2.98300870e-02f, -1.20233566e-01f,
  -1.75432444e-01f, -6.84854612e-02f, -4.31325912e-01f, 2.00706318e-01f, -2.68134981e-01f, 1.21575020e-01f, 5.41317582e-01f, 2.11492762e-01f, -1.03699550e-01f, -1.16697378e-01f,
  -2.11231872e-01f, -1.53185248e-01f, -2.84101754e-01f, 4.54765521e-02f, -7.80794071e-03f, 1.58510551e-01f, 1.05724968e-01f, -6.66064546e-02f, 3.51048037e-02f, -1.50621077e-02f,
  8.66193548e-02f, 1.30722269e-01f, -1.69938952e-01f, 1.35451406e-01f, 1.13178112e-01f, -1.34907356e-02f, -7.89641663e-02f, -5.55104725e-02f, -4.71604243e-02f, -1.49910513e-03f,
  -2.03202546e-01f, 2.84448033e-03f, 6.15129014e-04f, -1.39700575e-02f, -9.67051759e-02f, -4.20337804e-02f, -1.47384062e-01f, -9.62020233e-02f, -4.13573068e-03f, -5.24180103e-03f,
  1.72067657e-01f, 1.28193900e-01f, 9.70851108e-02f, 1.06041124e-02f, -2.73869727e-02f, 3.80264781e-03f, 4.27866168e-02f, -1.13472797e-01f, -1.12982867e-02f, -2.53093578e-02f,
  1.00041904e-01f, 2.70525948e-03f, 5.40394597e-02f, 3.38259973e-02f, -6.54789656e-02f, -3.63038704e-02f, -2.82393601e-02f, 1.38896272e-01f, -2.74536572e-02f, -1.99977145e-01f,
  -6.14968911e-02f, 2.10173298e-02f, 9.13849846e-02f, 1.81613639e-01f, -1.25279769e-01f, 2.99337078e-02f, 2.46043637e-01f, -9.12672579e-02f, 5.94272725e-02f, 4.28389385e-02f,
  -1.85395420e-01f, -9.40041840e-02f, -1.28702596e-01f, 6.38843998e-02f, -8.85500237e-02f, -3.88296954e-02f, -1.54423207e-01f, -7.58673698e-02f, -1.89869642e-01f, 1.64371818e-01f,
  1.50724679e-01f, 4.58374396e-02f, 1.25242144e-01f, 5.00451289e-02f, -9.03745592e-02f, -1.29967913e-01f, 9.67288762e-02f, 3.34388278e-02f, -7.19883442e-02f, 1.01124264e-01f,
  7.29483292e-02f, 1.07712977e-01f, -1.32134147e-02f, -5.25499322e-03f, 8.25876545e-04f, 9.47671831e-02f, 2.09302176e-02f, 1.07388869e-01f, 1.34317666e-01f, -1.30514130e-01f,
  -1.10452697e-01f, -7.76080191e-02f, -4.51356232e-01f, -3.67254883e-01f, 5.00549003e-02f, -5.70938468e-01f, -4.85220999e-01f, -2.30058327e-01f, 5.56900341e-04f, -3.05161297e-01f,
  -4.04608786e-01f, 1.69971943e-01f, 1.73259512e-01f, -4.63224828e-01f, 6.73502609e-02f, 2.81376123e-01f, -5.98090291e-01f, -2.94608951e-01f, 1.65134028e-01f, -3.79234582e-01f,
  -9.60139632e-02f, -3.99047792e-01f, -8.65310133e-02f, -1.36791617e-01f, -4.84755814e-01f, -2.03274935e-01f, 3.79872695e-02f, -2.27488261e-02f, -3.83753151e-01f, -1.19253561e-01f,
  -7.77802616e-02f, 1.95985734e-01f, -2.62084547e-02f, -5.68764545e-02f, -2.15021834e-01f, 3.09029650e-02f, -1.53867334e-01f, 2.18268916e-01f, 7.78661370e-02f, -7.88530484e-02f,
  2.55517196e-02f, 1.18061177e-01f, -1.27130568e-01f, 1.54658034e-01f, -6.26244694e-02f, -3.89197618e-02f, 1.18921036e-02f, -1.21978894e-01f, 1.00840570e-03f, -1.47824956e-03f,
  -4.93645929e-02f, -7.97059238e-02f, -3.21782291e-01f, -2.94061992e-02f, -1.01610593e-01f, -6.16167448e-02f, 1.17938578e-01f, 7.83753842e-02f, -1.64974704e-01f, -1.09817050e-01f,
  8.68128091e-02f, 1.53271062e-02f, -1.56620964e-02f, -1.50647089e-01f, 1.82508454e-01f, -1.26259014e-01f, -3.78968269e-02f, 2.41035479e-03f, -5.49529418e-02f, 2.11693458e-02f,
  -1.18345059e-01f, 8.34856480e-02f, 1.52957691e-02f, -1.31353259e-01f, -8.45113173e-02f, -3.45530286e-02f, 2.89610177e-02f, 3.35644782e-02f, -3.25322270e-01f, -8.28168169e-02f,
  1.21942803e-01f, 6.55637607e-02f, -1.57202408e-01f, -4.65466529e-02f, -2.71622222e-02f, 4.15052734e-02f, -7.02869892e-02f, 5.68019599e-02f, 1.02634065e-01f, -1.06011383e-01f,
  -5.19027151e-02f, 1.40320715e-02f, 6.91226497e-02f, 2.95215379e-02f, 1.01535946e-01f, -8.06857124e-02f, -3.35262455e-02f, -5.20870015e-02f, -5.09553552e-02f, 1.56963523e-02f,
  -1.60230428e-01f, -1.28076091e-01f, -1.00140683e-01f, -1.01337738e-01f, -1.69034824e-01f, -7.76311532e-02f, 7.08657429e-02f, 1.93765759e-02f, -1.32868886e-01f, -1.33343160e-01f,
  -1.19686097e-01f, 7.85553530e-02f, 9.05187353e-02f, 7.86014181e-03f, 5.24377078e-02f, -1.48860857e-01f, 9.19018313e-02f, 1.43375143e-01f, 1.83197893e-02f, -8.43203217e-02f,
  8.55724812e-02f, -1.80372268e-01f, -2.74355650e-01f, 1.43498674e-01f, -3.43642719e-02f, -3.82993102e-01f, -6.44742668e-01f, 4.15778637e-01f, -3.51020008e-01f, -5.16737737e-02f,
  4.11083579e-01f, -1.54044136e-01f, -2.36389175e-01f, 4.49932039e-01f, 4.75760400e-01f, -2.05268607e-01f, 4.71748382e-01f, 4.67597917e-02f, -1.08140685e-01f, 3.75378966e-01f,
  3.51431966e-01f, 5.12996852e-01f, 3.87704521e-01f, 5.69632471e-01f, 1.94506839e-01f, 2.12408274e-01f, 6.07183993e-01f, -1.10920165e-02f, 6.57268047e-01f, 1.78424701e-01f,
  -1.13972954e-01f, 5.51050939e-02f, -5.70660159e-02f, -2.26500288e-01f, 1.43175229e-01f, 6.93521649e-02f, -6.74807578e-02f, -4.32830676e-02f, 6.08415566e-02f, -2.47845761e-02f,
  -1.22578196e-01f, 5.07787056e-02f, 3.91062237e-02f, 7.87891913e-03f, -3.07893963e-03f, -1.13643557e-01f, -1.85423568e-02f, -8.09824988e-02f, -1.31871864e-01f, -3.39665301e-02f,
  -8.73245299e-02f, -1.50368968e-02f, -7.95313343e-02f, -3.86816114e-02f, -1.97215881e-02f, -1.19924285e-01f, -1.67037785e-01f, -8.10222477e-02f, -1.05883390e-01f, 9.76382121e-02f,
  1.39648363e-01f, 5.91254933e-03f, -8.68423507e-02f, -1.42586499e-01f, 2.46203989e-02f, -1.16722941e-01f, 2.29507089e-02f, -1.92626454e-02f, 8.40613060e-03f, -4.03776467e-02f,
  -1.15753869e-02f, 7.27994964e-02f, 6.12897277e-02f, -5.68759479e-02f, 1.27004161e-01f, -1.27177127e-02f, -7.38200620e-02f, 8.04669261e-02f, -9.61540267e-02f, 4.83634584e-02f,
  -9.39236283e-02f, 1.06864400e-01f, 3.04179396e-02f, -5.91732487e-02f, -7.00656325e-02f, 6.28235042e-02f, 9.77898538e-02f, 7.95321092e-02f, -2.52865665e-02f, 5.82958907e-02f,
  1.45392805e-01f, 4.29026186e-01f, -1.27283365e-01f, -7.50072002e-02f, -6.97230324e-02f, 5.63743524e-02f, -1.29516542e-01f, 1.26557454e-01f, 1.15122244e-01f, 5.09052053e-02f,
  2.30797648e-01f, 3.20363715e-02f, 1.39239375e-02f, -4.02824162e-03f, 5.66086248e-02f, 1.18333148e-02f, 1.80903375e-01f, 3.69115770e-02f, 1.61635995e-01f, 1.63815901e-01f,
  1.35421574e-01f, -2.53059827e-02f, -7.21402690e-02f, -7.93899819e-02f, 1.40989712e-02f, 8.46722052e-02f, 3.72111760e-02f, -6.72111809e-02f, 1.36678845e-01f, -5.70543334e-02f,
  3.16846579e-01f, 5.35744488e-01f, 1.31952032e-01f, 2.01462030e-01f, -3.18970054e-01f, -4.61149663e-01f, -1.25174031e-01f, -1.83202386e-01f, -4.48592640e-02f, 1.44650862e-02f,
  -2.27783635e-01f, 5.91943502e-01f, 1.06347367e-01f, -1.51209593e-01f, -3.77883434e-01f, -1.28400326e-01f, -3.82868171e-01f, 9.05246809e-02f, -1.08683176e-01f, -1.09059110e-01f,
  -2.30642006e-01f, -4.06542897e-01f, -8.95310193e-02f, -1.86823666e-01f, 6.67079864e-03f, 1.88307092e-01f, -1.56344891e-01f, -8.98079723e-02f, 1.24108262e-01f, 8.59462470e-02f,
  -2.48149052e-01f, 1.07363900e-02f, 1.23191155e-01f, -7.39311799e-02f, -1.46984383e-01f, 3.85576300e-02f, 1.06579065e-01f, 1.51895061e-01f, -1.19942732e-01f, -2.23508738e-02f,
  2.00617090e-01f, -2.70695761e-02f, 5.38189709e-02f, -5.90596348e-04f, 4.17144522e-02f, 5.45478426e-02f, -2.07154499e-03f, 3.13950889e-03f, 6.70296922e-02f, 3.73155586e-02f,
  1.57387748e-01f, 5.36686415e-03f, -1.34172337e-02f, 3.99067737e-02f, -1.72835998e-02f, -2.06427630e-02f, -2.20993385e-02f, 9.23779979e-02f, 3.10491566e-02f, 2.93840375e-03f,
  -7.08020851e-02f, -1.02202736e-01f, -7.25691542e-02f, -2.10708585e-02f, -2.82150768e-02f, -1.24034807e-01f, 1.15915807e-02f, 7.06060529e-02f, 1.54605180e-01f, -3.11033912e-02f,
  -1.37269109e-01f, 1.58226937e-01f, -5.39420694e-02f, -4.08596136e-02f, -1.13631815e-01f, 6.90960363e-02f, 8.85203704e-02f, 6.35417062e-04f, 5.18587232e-02f, -9.29044262e-02f,
  8.51793513e-02f, -1.58084214e-01f, 2.18424097e-01f, 4.75286469e-02f, -1.27796158e-01f, -1.49777420e-02f, 4.73785549e-02f, 1.60598472e-01f, -8.31897631e-02f, -1.74783006e-01f,
  -5.71039975e-01f, -4.54943448e-01f, -1.38881505e-01f, 1.48667172e-01f, -2.47795079e-02f, 5.25118858e-02f, -7.65691251e-02f, 4.76136468e-02f, -1.36874035e-01f, -4.62967120e-02f,
  -1.25248164e-01f, 4.06938456e-02f, -1.56632662e-01f, -2.15215925e-02f, -6.26231916e-03f, -7.55331069e-02f, -6.66484684e-02f, -7.28765726e-02f, -1.31354526e-01f, -5.11328429e-02f,
  -3.05857677e-02f, 3.37114781e-02f, -9.08483416e-02f, -9.87434573e-03f, 1.34533972e-01f, -4.68327515e-02f, 1.44180553e-02f, 4.90387231e-02f, 2.48435531e-02f, -1.35617316e-01f,
  -3.67916375e-02f, 9.02665593e-03f, -4.97657150e-01f, -3.15451212e-02f, -4.56612676e-01f, 4.15919209e-03f, 2.92848259e-01f, -1.37023687e-01f, 5.19164763e-02f, 6.25457823e-01f,
  3.80396307e-01f, 1.65955305e-01f, 5.21887481e-01f, 4.47490871e-01f, -4.51368153e-01f, 6.14061773e-01f, 1.69604436e-01f, 3.21670026e-01f, -1.11201242e-01f, -3.90326343e-02f,
  -2.39548013e-01f, 2.67437220e-01f, -3.79713699e-02f, -5.40717617e-02f, -2.13254154e-01f, -3.46603960e-01f, -2.87213232e-02f, -7.11601079e-02f, 1.18294358e-01f, -1.95415571e-01f,
  1.15515552e-01f, 5.30427396e-02f, -1.48953319e-01f, 3.15506868e-02f, -5.10621406e-02f, -1.13080427e-01f, -5.64706996e-02f, 3.28719988e-02f, 4.95937169e-02f, 7.49244913e-02f,
  1.52052611e-01f, 4.39216197e-02f, 1.41790295e-02f, -1.51439697e-01f, -2.81073786e-02f, -9.79982689e-02f, -1.85851023e-01f, -6.17012791e-02f, 1.43386215e-01f, -4.73841429e-02f,
  7.63952881e-02f, -3.50356847e-02f, -5.07595763e-02f, 4.57372628e-02f, -1.43099368e-01f, 7.42066503e-02f, 1.24881260e-01f, -1.22682057e-01f, -4.15473580e-02f, -1.20841660e-01f,
  3.15112025e-02f, 1.57340080e-01f, 3.59278992e-02f, -1.46681154e-02f, -1.44658864e-01f, -9.78429317e-02f, 8.04742053e-03f, 1.03012599e-01f, -1.45959295e-02f, -1.54660409e-02f,
  4.54088636e-02f, -7.24196360e-02f, 1.51362672e-01f, -7.40718143e-03f, 6.76683784e-02f, 8.82909074e-02f, -3.26100104e-02f, 1.06631525e-01f, -4.45020758e-02f, -6.03368022e-02f,
  5.14849126e-02f, 4.93708029e-02f, 2.55758241e-02f, 8.96908119e-02f, 2.25205477e-02f, -5.65159768e-02f, -2.20377301e-03f, -1.86663538e-01f, 1.12971991e-01f, -1.00429013e-01f,
  -2.54717227e-02f, -2.49285214e-02f, 6.07925728e-02f, 9.18002054e-02f, 1.56685691e-02f, -1.19110487e-01f, -3.34982085e-03f, -1.41769484e-01f, -2.84075011e-02f, -3.56015973e-02f,
  3.45565565e-02f, 1.12401046e-01f, -6.92982674e-02f, 5.54336384e-02f, 1.51045704e-02f, 2.43561063e-03f, 2.44628832e-01f, 5.78110628e-02f, -2.29966789e-02f, -6.42986372e-02f,
  4.13652137e-02f, 1.14474647e-01f, 7.20061660e-02f, 5.22094853e-02f, 1.13540024e-01f, -1.03049660e-02f, -1.59658328e-01f, -3.04766148e-02f, -1.80844694e-01f, -5.74756972e-02f,
  -1.32717752e+00f, 5.82770467e-01f, -5.25143221e-02f, -2.92950094e-01f, -5.44992369e-03f, -1.79427698e-01f, 6.79721311e-02f, 2.72947457e-02f, 2.13237014e-03f, 2.05626309e-01f,
  -7.28197545e-02f, -1.31009102e-01f, 2.10769132e-01f, 1.93598449e-01f, -3.83344233e-01f, 3.67760181e-01f, -1.27774343e-01f, -7.70127624e-02f, 1.06456794e-01f, -1.76135346e-01f,
  -7.49678165e-02f, -1.31690660e-02f, 7.57466108e-02f, 2.54045248e-01f, -1.73679993e-01f, -4.77622263e-02f, -1.76460370e-01f, 9.87677947e-02f, -1.44489005e-01f, 5.87151349e-02f,
  -3.44796658e-01f, -2.73995608e-01f, -9.27482918e-02f, -1.53076887e-01f, -2.17026159e-01f, -1.25658661e-01f, -1.17718101e-01f, -1.30118206e-01f, -1.88859925e-01f, -1.81385763e-02f,
  -7.79055580e-02f, -2.57818047e-02f, -6.70643896e-02f, 5.54918870e-02f, -6.27178699e-02f, -3.24120373e-02f, 1.30096167e-01f, 2.02019978e-02f, 7.50261694e-02f, 6.36956617e-02f,
  1.00724339e-01f, 4.06350903e-02f, 6.56182691e-02f, 9.64925289e-02f, 4.78542224e-03f, 2.63713412e-02f, -3.01633663e-02f, -5.27375303e-02f, -8.33543688e-02f, -3.79843265e-02f,
  1.67029779e-02f, -6.92920387e-02f, -3.56787518e-02f, -5.47089148e-03f, -5.71994483e-02f, 6.22471161e-02f, 4.50905710e-02f, -7.03908429e-02f, -2.68789269e-02f, -1.87918246e-02f,
  -1.20906509e-01f, -1.66378662e-01f, -5.37788384e-02f, -3.39738466e-02f, -9.45403147e-03f, -3.23181855e-03f, -1.03568956e-01f, -6.16939701e-02f, 1.06962271e-01f, -7.56830629e-03f,
  -4.66144867e-02f, 5.07368632e-02f, 4.42921817e-02f, 2.76416484e-02f, -3.72877121e-02f, 5.54565573e-03f, 1.04641438e-01f, 7.39554986e-02f, 7.55033419e-02f, -4.96430993e-02f,
  -7.66622245e-01f, -6.20339632e-01f, -9.63062271e-02f, -2.38759384e-01f, -3.98538560e-02f, -5.40488251e-02f, 1.71812065e-02f, -1.95709560e-02f, -5.61020188e-02f, 9.51808877e-03f,
  -1.03580236e-01f, -8.63673463e-02f, -1.21592566e-01f, -5.54190651e-02f, 4.39496972e-02f, -2.60476097e-02f, -6.05947152e-02f, -7.05951173e-03f, -1.52358934e-01f, -4.69175950e-02f,
  -7.60796964e-02f, -4.02091257e-02f, 9.14935768e-02f, -2.24707779e-02f, -6.27014786e-02f, -7.10549131e-02f, -1.29317492e-01f, -5.29106334e-03f, -1.10553853e-01f, 1.30553201e-01f,
  2.51412094e-01f, 6.06291950e-01f, -1.03465140e-01f, 1.86968237e-01f, 1.76676929e-01f, 6.21660352e-01f, 6.07921302e-01f, 2.49546573e-01f, 4.51481700e-01f, 2.41465226e-01f,
  1.26993567e-01f, 6.45241216e-02f, -1.26007609e-02f, 3.80122334e-01f, 2.61737317e-01f, 1.89414173e-01f, 5.57637870e-01f, 2.60392308e-01f, 1.09847710e-01f, 2.06643462e-01f,
  9.42233652e-02f, 2.44857520e-01f, -2.27116331e-01f, -9.77294445e-02f, 6.79575130e-02f, -1.67116806e-01f, -3.01398247e-01f, -1.98344722e-01f, -3.27039808e-02f, 1.23797148e-01f,
  -3.90748195e-02f, 3.03148534e-02f, -3.14725377e-02f, -6.31400198e-02f, -1.60747245e-01f, -8.50544199e-02f, -1.06973290e-01f, -8.67486000e-02f, -1.43476784e-01f, 9.53296274e-02f,
  2.76330486e-02f, 6.95473328e-02f, 1.16689399e-01f, 1.58841945e-02f, 9.93128642e-02f, -3.70384194e-02f, -2.92092208e-02f, 5.92319947e-03f, 1.78108457e-02f, -5.17359860e-02f,
  -1.75426960e-01f, -1.26504213e-01f, 3.22700329e-02f, 1.32775351e-01f, 1.07750505e-01f, 1.46953136e-01f, 1.00318521e-01f, 1.42157897e-02f, -1.49841318e-02f, 1.01022400e-01f,
  1.65533908e-02f, -7.58938212e-03f, -1.57402232e-02f, -1.73900858e-01f, -5.82212508e-02f, -8.26076325e-03f, 6.05907105e-02f, -1.23367347e-01f, 8.96133929e-02f, -4.36296761e-02f,
  1.83634683e-02f, -9.93940979e-02f, -3.64337899e-02f, -1.70209140e-01f, -1.84339413e-03f, -2.61443183e-02f, 1.74598838e-03f, 1.15090972e-02f, 9.57619101e-02f, -1.43610597e-01f,
  8.59242976e-02f, 2.10347041e-01f, -1.23072974e-01f, -8.40434954e-02f, 4.29834090e-02f, -1.41543284e-01f, 5.20942062e-02f, 2.53306963e-02f, 1.32589759e-02f, -3.49325538e-02f,
  1.88095570e-01f, 4.51038539e-01f, -9.22210142e-02f, 5.68204001e-02f, -2.25925315e-02f, -1.60342082e-02f, 8.00420493e-02f, 1.71786144e-01f, 1.72111288e-01f, 1.13304675e-01f,
  2.19200328e-02f, -8.35993215e-02f, 1.47582740e-01f, -9.17518698e-03f, -1.10113099e-01f, 9.98591259e-02f, 6.98840320e-02f, 4.25330512e-02f, 2.89289318e-02f, -1.76643193e-01f,
  -2.40419731e-01f, 2.29164977e-02f, 4.93606217e-02f, 1.54894788e-03f, 5.19285128e-02f, -9.30452794e-02f, 1.67048693e-01f, -8.27448219e-02f, -1.05381750e-01f, 1.30933017e-01f,
  1.93961605e-01f, 7.31037632e-02f, -4.91432697e-01f, -4.48742397e-02f, -3.24461311e-02f, 7.97554493e-01f, 4.33933944e-01f, -1.37431160e-01f, -1.73331171e-01f, 4.24933463e-01f,
  3.41879278e-01f, -1.51144832e-01f, 3.82359372e-03f, 7.14261532e-01f, 9.79407802e-02f, 2.77222782e-01f, 6.43503964e-01f, 5.52863240e-01f, -2.17899963e-01f, 7.84497485e-02f,
  -9.73670632e-02f, 6.44870460e-01f, -1.75798729e-01f, 7.86916167e-02f, 1.98592126e-01f, -3.98936182e-01f, -8.63260105e-02f, -2.77604640e-01f, 2.79088944e-01f, 2.99366146e-01f,
  1.19789906e-01f, -1.07848505e-02f, -6.54026419e-02f, 3.65553014e-02f, 1.03081867e-01f, 2.01037183e-01f, 1.01574101e-01f, 7.70239905e-02f, -1.51921839e-01f, -5.01279011e-02f,
  2.21047755e-02f, 8.87902901e-02f, 3.95784006e-02f, -3.20056789e-02f, 1.08896616e-04f, -6.90607727e-02f, -2.13619053e-01f, -1.30259350e-01f, -1.03422850e-01f, -1.13384880e-01f,
  -1.49223641e-01f, -2.68017277e-02f, -1.45204321e-01f, -6.75404891e-02f, -2.10529104e-01f, -2.32607536e-02f, 1.09367803e-01f, -9.06086341e-02f, 8.58434811e-02f, 5.30343726e-02f,
  5.21922186e-02f, 9.22106430e-02f, 1.05723076e-01f, 9.29570869e-02f, 5.96003933e-03f, 8.33029449e-02f, -3.96226943e-02f, 6.41189963e-02f, -1.24487624e-01f, 1.08499736e-01f,
  -3.75484824e-02f, -4.21406664e-02f, 8.66056904e-02f, 1.04466341e-01f, 1.61605239e-01f, 3.77241969e-02f, -3.09298113e-02f, -1.90932546e-02f, -1.05592562e-02f, -5.82756661e-02f,
  -2.05520429e-02f, 5.03155887e-02f, -9.24869999e-03f, 3.20471562e-02f, 1.65260993e-02f, -1.52841032e-01f, 1.83403715e-01f, 1.72651988e-02f, -1.82455853e-01f, -1.18777007e-01f,
  4.60825413e-02f, 1.47112384e-01f, -1.34174943e-01f, 8.34747255e-02f, -1.63647290e-02f, 8.36314932e-02f, 1.26475826e-01f, 2.23010536e-02f, -3.03086713e-02f, 3.61386575e-02f,
  1.41015723e-01f, -2.05847360e-02f, -3.90923060e-02f, -1.23134293e-02f, -8.50349367e-02f, -9.13898740e-03f, 1.63991302e-01f, 2.44922098e-02f, 4.74407338e-02f, -5.80466501e-02f,
  1.31579703e-02f, 7.12366868e-03f, 2.34195683e-03f, -8.67275819e-02f, 4.12455620e-03f, 5.94898351e-02f, -6.40613586e-02f, -6.02513254e-02f, -7.77467946e-03f, -2.07702983e-02f,
  6.47773564e-01f, -1.11348188e+00f, -1.95647210e-01f, 5.02113461e-01f, 5.96404135e-01f, 1.68838516e-01f, 3.45729142e-01f, -8.09944943e-02f, -1.09306306e-01f, -6.23124480e-01f,
  2.01070830e-01f, -1.55921325e-01f, -4.39938277e-01f, 1.44455388e-01f, 6.21239245e-01f, -3.95249516e-01f, 2.04462036e-01f, 1.45073190e-01f, -1.07410721e-01f, -3.20642479e-02f,
  2.38876149e-01f, 2.35374168e-01f, -6.77488893e-02f, -1.77264303e-01f, 2.77501702e-01f, -1.19321093e-01f, -1.15638033e-01f, -2.03443915e-01f, 2.09286928e-01f, 1.77921176e-01f,
  8.20128247e-02f, -7.47700781e-02f, 1.34873062e-01f, -1.60974100e-01f, -1.80033356e-01f, 8.18033814e-02f, -5.33989966e-02f, 1.49728209e-01f, 1.65396526e-01f, -1.15877262e-03f,
  -1.50406007e-02f, 6.94969073e-02f, 1.47793561e-01f, 6.09470299e-03f, -7.06578000e-03f, 1.64123550e-02f, 1.11028980e-02f, 6.64968044e-02f, -8.04896429e-02f, 2.00910252e-02f,
  -9.61199552e-02f, 1.75259949e-04f, 8.79953727e-02f, -8.11067820e-02f, 4.66525070e-02f, 7.81186670e-03f, 2.18377635e-02f, -5.07628806e-02f, -6.39755726e-02f, 3.14711630e-02f,
  -3.38917784e-02f, 4.01941035e-03f, -6.73105717e-02f, 1.27695147e-02f, -4.81297374e-02f, 1.00237541e-01f, -2.58957595e-02f, 3.96135338e-02f, 2.85838433e-02f, -4.76887189e-02f,
  1.48450166e-01f, -1.96800791e-02f, 2.85639949e-02f, 1.08839097e-02f, 3.17573994e-02f, -1.79549791e-02f, 4.61169034e-02f, -1.48856463e-02f, 7.51349702e-03f, 3.64094265e-02f,
  -4.59521823e-02f, 9.75713134e-02f, -1.44158274e-01f, -1.44886207e-02f, -2.77065625e-03f, -8.53041783e-02f, -3.72112989e-02f, -2.49416865e-02f, 5.47392778e-02f, 1.95916127e-02f,
  -6.88631356e-01f, -9.61717367e-01f, -1.31272316e-01f, 1.10016666e-01f, -4.80623469e-02f, -7.13741854e-02f, 1.60372388e-02f, 5.57135232e-02f, -2.15408191e-01f, -6.21059649e-02f,
  -1.94025617e-02f, 1.30970344e-01f, -9.54157561e-02f, 3.21400277e-02f, -3.42163444e-02f, -4.53194194e-02f, -6.18667062e-03f, -4.76729795e-02f, -4.76940870e-02f, -1.39093906e-01f,
  -7.33819529e-02f, -7.13972468e-03f, 1.08884878e-01f, 1.45706475e-01f, 7.73891658e-02f, -5.49133755e-02f, 2.26899460e-02f, 8.59982148e-03f, -2.49326415e-02f, -8.63364935e-02f,
  -5.40117800e-01f, -2.47340947e-01f, 6.63185775e-01f, -5.37532151e-01f, -8.57958570e-02f, 5.79142272e-01f, 5.19454360e-01f, -3.46419841e-01f, -4.08022016e-01f, -2.17717513e-01f,
  -1.72709644e-01f, 1.47800520e-01f, 5.97715080e-01f, -1.51693627e-01f, 7.88006902e-01f, 5.04950583e-01f, 2.82004625e-02f, 2.15553492e-02f, -8.66290554e-02f, -2.29433954e-01f,
  -1.72810569e-01f, -3.12289149e-01f, 2.99611002e-01f, -3.94152433e-01f, -2.48929217e-01f, -1.96364865e-01f, -2.68918633e-01f, 3.17243159e-01f, -1.55765250e-01f, 1.06006615e-01f,
  -9.91777703e-02f, -4.22129214e-01f, -2.12921336e-01f, 7.24214613e-02f, -3.95166613e-02f, 7.54782781e-02f, 1.77500561e-01f, 2.62511313e-01f, 2.01798640e-02f, 3.68612111e-02f,
  1.19201392e-01f, 8.28107297e-02f, -1.52209997e-01f, 7.04657063e-02f, -1.79037198e-01f, -6.85211495e-02f, -1.10996189e-02f, -5.91356792e-02f, -7.17865601e-02f, 1.05589442e-01f,
  6.28126636e-02f, -4.16859286e-03f, -2.99615487e-02f, -1.72314211e-03f, 3.86265777e-02f, -3.57292891e-02f, 1.55333310e-01f, 2.02579632e-01f, 3.40350792e-02f, -1.32287726e-01f,
  -1.54975494e-02f, 7.14672953e-02f, 1.29271047e-02f, -1.22501597e-01f, -3.59256901e-02f, -1.12398371e-01f, 3.99861624e-03f, -5.95665462e-02f, 1.97769348e-02f, -3.89984027e-02f,
  -6.42931834e-02f, -8.51151496e-02f, -4.28254306e-02f, 4.94514704e-02f, -8.84900242e-02f, -1.65852472e-01f, 1.14284121e-01f, -3.69335003e-02f, -6.25925362e-02f, -9.86430719e-02f,
  -2.52568591e-02f, 7.30839595e-02f, 4.59726751e-02f, 7.95194805e-02f, -4.73338515e-02f, 7.54219070e-02f, -3.10851838e-02f, 2.21131966e-02f, 6.02448219e-03f, 6.59848154e-02f,
  -1.99625850e-01f, -3.30737323e-01f, -1.76144853e-01f, -5.74161820e-02f, -2.18842104e-02f, -2.49266271e-02f, 1.26452744e-02f, -2.31362320e-02f, 1.80007182e-02f, 8.61817971e-03f,
  -1.75522100e-02f, 4.29877453e-02f, 2.51442194e-02f, -9.39267948e-02f, 6.10255376e-02f, -1.95365995e-02f, 2.84450166e-02f, -9.97285917e-02f, -6.68469584e-03f, -1.01194382e-01f,
  -4.74635698e-02f, -1.35737378e-02f, 6.28504679e-02f, -1.49450064e-01f, -7.93198720e-02f, -5.47530390e-02f, -8.39034989e-02f, -6.03152700e-02f, 5.07577509e-02f, 4.18312065e-02f,
  -8.83698404e-01f, 4.50896434e-02f, -1.48638487e-01f, -5.60151517e-01f, 3.52988422e-01f, 3.39555442e-01f, -2.46016085e-01f, 1.78187832e-01f, -4.43444163e-01f, 1.83903247e-01f,
  8.24375376e-02f, -3.50696355e-01f, -1.59853309e-01f, -4.08338666e-01f, -5.63881993e-01f, -5.19320250e-01f, -3.08687985e-02f, -4.75119986e-03f, -3.06069613e-01f, 1.10117212e-01f,
  -5.76843284e-02f, -9.08322558e-02f, -1.76451370e-01f, 4.71923769e-01f, 3.75689529e-02f, 1.23299152e-01f, 2.05609173e-01f, 1.15244500e-01f, 2.51625776e-01f, -3.84669844e-03f,
  -1.66043267e-01f, -2.15371579e-01f, -2.88017634e-02f, 6.15052357e-02f, 1.79740667e-01f, 2.33626038e-01f, -5.59074394e-02f, -2.73867194e-02f, -1.05498858e-01f, -4.08662446e-02f,
  5.55271320e-02f, 3.44107896e-02f, -1.16126342e-02f, -9.23467577e-02f, 1.67022999e-02f, 2.11290140e-02f, -6.47055581e-02f, -4.78523187e-02f, 6.04785308e-02f, -1.66957900e-01f,
  1.48827937e-02f, -6.96009351e-03f, 1.02943704e-01f, 2.53365561e-02f, 6.62094429e-02f, 1.89430488e-03f, 9.08802375e-02f, 4.14102785e-02f, 1.35557973e-04f, -6.23988025e-02f,
  -2.45615859e-02f, 1.48420379e-01f, 4.13992815e-02f, -9.53745246e-02f, -1.38757944e-01f, 1.10326983e-01f, -9.28294733e-02f, 8.40263367e-02f, -1.08178649e-02f, -6.49460917e-03f,
  -6.56091720e-02f, 2.42903940e-02f, -3.41655165e-02f, 9.41129848e-02f, -6.70865104e-02f, 2.36649942e-02f, 3.03910896e-02f, 1.44614903e-02f, -5.64724170e-02f, -9.77863185e-03f,
  1.43181011e-01f, -7.35397190e-02f, -3.19654830e-02f, -3.23760584e-02f, 3.17925252e-02f, -1.62320778e-01f, 1.63079221e-02f, 9.11172926e-02f, -2.05059554e-02f, -3.63734141e-02f,
  2.16590869e-03f, 2.33458541e-02f, -3.55989090e-03f, -6.75214753e-02f, -6.39825761e-02f, -4.82603572e-02f, -1.09236486e-01f, 1.04466565e-01f, -1.40385311e-02f, -8.27430412e-02f,
  8.89504179e-02f, 3.85026447e-02f, 2.28334859e-01f, -1.04607671e-01f, 5.60632944e-02f, 1.17572524e-01f, 7.10482448e-02f, -6.81218505e-02f, 7.84804448e-02f, -4.59088683e-02f,
  1.48695884e-02f, 9.04182568e-02f, -7.01253116e-02f, 4.88346517e-02f, 1.40950710e-01f, 8.64675920e-03f, 3.50876004e-02f, -3.06139085e-02f, 4.78103422e-02f, -1.43093280e-02f,
  -7.72219658e-01f, 5.71808100e-01f, -1.90012574e-01f, -3.10853988e-01f, 1.05284013e-01f, -3.35214138e-01f, -1.12340093e-01f, 4.13932502e-01f, 1.60740837e-01f, 2.23969504e-01f,
  2.54436024e-02f, -1.15670413e-01f, 1.52359724e-01f, -6.69346005e-02f, -6.82524860e-01f, -2.73949981e-01f, -6.08610272e-01f, -3.78791600e-01f, -9.03352723e-03f, -4.15784866e-02f,
  -2.65495330e-01f, 3.10281217e-02f, -3.62186372e-01f, 2.48923838e-01f, 1.79429501e-01f, 2.43423298e-01f, 8.88009593e-02f, 3.65271300e-01f, -7.03461990e-02f, 4.06854749e-02f,
  -6.50963485e-02f, 1.93656534e-01f, 1.74175128e-01f, 1.49339527e-01f, -8.18482712e-02f, -8.50137249e-02f, 4.79319617e-02f, 2.18317062e-01f, 8.24958235e-02f, -2.74020154e-02f,
  4.94365506e-02f, -2.11307500e-02f, -1.28373474e-01f, -3.15706693e-02f, 1.27194121e-01f, 2.69004470e-03f, -6.83358982e-02f, 1.44955106e-02f, 2.10863203e-02f, -1.87583655e-01f,
  -1.32812664e-01f, 9.75778699e-02f, -2.08728075e-01f, -9.13807824e-02f, -1.29014030e-01f, 9.77327749e-02f, -1.91729590e-01f, -1.85987111e-02f, -6.76529258e-02f, 7.25715607e-03f,
  -2.03072414e-01f, -1.40425727e-01f, 1.19125232e-01f, -1.79607067e-02f, -2.13497947e-03f, -1.07198887e-01f, -3.47472355e-02f, 7.73142725e-02f, -1.62352815e-01f, 1.00594699e-01f,
  1.57857388e-01f, -1.42558403e-02f, 1.23743966e-01f, 8.16169474e-03f, 3.00415419e-03f, 2.83628367e-02f, -2.01243367e-02f, 1.08380817e-01f, -1.35958254e-01f, -9.93040353e-02f,
  5.29322699e-02f, 8.76878574e-02f, 1.28251597e-01f, 1.94417834e-02f, -3.15704104e-03f, 2.21856739e-02f, 1.12755604e-01f, 1.19685210e-01f, -3.16109173e-02f, 1.25326458e-02f,
  7.19102100e-02f, 2.31708914e-01f, 3.94616686e-02f, 2.21243948e-01f, 7.71205276e-02f, -8.89840536e-03f, 1.99378077e-02f, 9.31378454e-03f, -1.30935134e-02f, -6.37119487e-02f,
  -5.89263737e-02f, 3.98518816e-02f, -1.15744114e-01f, 5.77351414e-02f, 8.70887283e-03f, -1.80151448e-01f, 6.14277571e-02f, 1.51781589e-01f, 5.22378366e-03f, 1.23125426e-02f,
  4.85468581e-02f, -6.51489943e-02f, -1.64774939e-01f, -4.49962132e-02f, 1.85252354e-02f, -1.35270339e-02f, -1.15412816e-01f, 7.35317096e-02f, -5.48740290e-02f, -7.37004727e-02f,
  6.00679636e-01f, -8.02736506e-02f, 2.06758007e-01f, 3.61626327e-01f, 7.36223534e-02f, 2.43421551e-02f, 3.58995020e-01f, 6.66968375e-02f, 8.47226977e-01f, -4.32578683e-01f,
  -5.46454847e-01f, 2.27179211e-02f, -3.95172313e-02f, -4.39930409e-01f, 2.28803873e-01f, 2.20968634e-01f, 7.57737532e-02f, -1.18859924e-01f, 2.01257363e-01f, -1.27563670e-01f,
  1.63326770e-01f, -2.45684832e-01f, 1.79786049e-03f, -4.49870795e-01f, -1.63515866e-01f, -1.45858809e-01f, -2.98967540e-01f, -7.93599233e-04f, -6.98820353e-01f, 3.64430510e-02f,
  -4.97713499e-03f, 4.95798849e-02f, -4.34559844e-02f, -5.37820309e-02f, 2.34972090e-02f, -1.26553029e-01f, -2.07841113e-01f, 2.01232242e-03f, 1.09655254e-01f, 6.03519566e-02f,
  3.91363353e-02f, -8.27058330e-02f, -7.97112063e-02f, 4.51219305e-02f, 2.50601113e-01f, 1.21802902e-02f, 4.61538509e-02f, -8.59852061e-02f, -1.00499310e-01f, -1.14644200e-01f,
  4.80204038e-02f, -2.66364831e-02f, 8.12887549e-02f, -7.48864338e-02f, 3.95991281e-02f, 4.65512536e-02f, -5.66770881e-02f, -2.31589898e-02f, 2.43084915e-02f, 1.60945982e-01f,
  -1.13555826e-01f, 1.12417676e-01f, 4.88804542e-02f, -7.05415532e-02f, -8.05806071e-02f, -6.70960872e-03f, -1.36079937e-01f, -6.23009987e-02f, 1.72585528e-02f, -1.06397390e-01f,
  2.60310695e-02f, -4.80084643e-02f, 9.78138521e-02f, 7.68861547e-02f, 8.87305886e-02f, 9.43307653e-02f, -3.36295813e-02f, -1.16070129e-01f, 6.77332729e-02f, 3.46696191e-02f,
  3.33742686e-02f, 6.75060973e-02f, 2.29241676e-03f, -8.68342910e-03f, -6.70025945e-02f, 4.08121236e-02f, -6.93567172e-02f, -8.80909786e-02f, 9.04976800e-02f, -5.83551452e-02f,
  -5.13724387e-02f, 8.61251727e-03f, 8.79475009e-03f, -1.42710000e-01f, -3.11449692e-02f, -1.48127884e-01f, 3.28309834e-02f, 2.42606159e-02f, 7.61476532e-02f, -2.58248970e-02f,
  -1.45933360e-01f, -1.37228116e-01f, 9.70959142e-02f, -3.39194536e-02f, 8.12594816e-02f, -9.68193635e-02f, 3.71231176e-02f, -6.28194287e-02f, 7.00207874e-02f, -1.91231966e-01f,
  -1.60201162e-01f, -3.93840224e-02f, -2.16320734e-02f, -9.94200632e-02f, -1.15739688e-01f, -7.80009478e-02f, 4.36739735e-02f, -4.82278019e-02f, -5.62252887e-02f, 4.98680659e-02f,
  5.71616888e-01f, 1.19768351e-01f, 3.37674916e-01f, 2.41682634e-01f, 4.00207974e-02f, 7.39713162e-02f, -6.33415133e-02f, -4.48725745e-02f, 3.83280337e-01f, 5.94765767e-02f,
  -2.92454600e-01f, 4.65061963e-01f, -3.07948947e-01f, -6.49541989e-02f, -5.29103696e-01f, -3.85617763e-01f, 1.11317925e-01f, 3.13422889e-01f, 4.88936827e-02f, 3.08370978e-01f,
  5.98552413e-02f, -4.83857453e-01f, -3.18315536e-01f, -1.18458882e-01f, 2.72929162e-01f, 3.54190767e-01f, -4.08552885e-01f, -1.92873985e-01f, 6.44538030e-02f, -3.91093463e-01f,
  -8.35644081e-02f, 6.17680838e-03f, 6.18297048e-02f, 6.76160008e-02f, 2.13916138e-01f, 8.01643804e-02f, -3.14025767e-02f, -1.92537129e-01f, -2.63341479e-02f, 2.31256131e-02f,
  1.11584790e-01f, -7.00431243e-02f, -5.73510900e-02f, -1.27298042e-01f, -1.48234945e-02f, -1.55639546e-02f, 9.56148431e-02f, 1.66946948e-01f, 1.18499018e-01f, 1.94182307e-01f,
  2.17405021e-01f, 8.31310377e-02f, 1.13493904e-01f, -5.49032651e-02f, -8.73569399e-03f, -7.78040215e-02f, 1.28185034e-01f, -1.50577417e-02f, 5.91783486e-02f, 3.69303934e-02f,
  3.96890566e-02f, 3.98830734e-02f, -2.90289260e-02f, -1.52886920e-02f, -5.41186752e-03f, 5.38984537e-02f, 7.38672018e-02f, -9.43429992e-02f, 3.44060995e-02f, -8.81601125e-02f,
  1.98488273e-02f, -1.25694111e-01f, 1.85429566e-02f, 1.19741417e-01f, 7.05819726e-02f, 6.20528162e-02f, -1.30943954e-01f, 5.95590053e-03f, 1.25298813e-01f, -9.45873111e-02f,
  -1.75996885e-01f, 3.57320122e-02f, -1.00285277e-01f, 8.78879279e-02f, -1.24268129e-01f, -1.10440864e-03f, 1.43296182e-01f, 1.89676270e-01f, -7.79170692e-02f, 1.19617535e-02f,
  3.71951386e-02f, 1.91072166e-01f, 1.01523399e-01f, -8.75533149e-02f, -3.57741467e-03f, 5.78755736e-02f, 7.04551190e-02f, 8.78549889e-02f, 9.36280284e-03f, -1.98884681e-02f,
  1.18175589e-01f, 1.85579777e-01f, 7.19699934e-02f, -1.34347633e-01f, -1.26745388e-01f, 6.29283711e-02f, 1.01792105e-01f, 1.45943025e-02f, -7.57124051e-02f, -3.24886963e-02f,
  1.70777097e-01f, 6.71861097e-02f, 2.00340450e-01f, 4.55998927e-02f, 3.96945998e-02f, -6.04486652e-03f, 8.28835443e-02f, 1.31752685e-01f, -3.18350606e-02f, -1.36358347e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.08318460e-01f, 3.85155231e-02f, 4.51470286e-01f, 3.85817081e-01f, 2.19364554e-01f, 3.68002355e-01f, 5.11320531e-01f, 5.71317792e-01f, 1.73254177e-01f, 6.31628931e-01f,
  8.23915660e-01f, 4.92471397e-01f, 5.56156874e-01f, 8.20511043e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.62323612e-01f, 5.04823625e-01f, 9.32480842e-02f, -5.67167290e-02f, -2.81954378e-01f, 3.03078026e-01f, 3.26344073e-01f, -1.41948536e-01f, 3.34197193e-01f, 2.77559936e-01f,
  -2.90727764e-01f, -3.49313885e-01f, -2.64760762e-01f, -4.36814666e-01f, 2.41740197e-01f, 2.64925241e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.23671854e-01f, -5.91460705e-01f, -2.23944917e-01f, -2.66950160e-01f, -3.51488352e-01f, -3.87601346e-01f, 2.80286521e-01f, 1.00522935e+00f, 1.65596649e-01f, -2.56159361e-02f,
  -6.27591550e-01f, 4.32208180e-01f, 9.95555222e-01f, 9.97402608e-01f, -5.07747903e-02f, 2.64853686e-01f, 6.87903687e-02f, -8.46445799e-01f, 6.43424913e-02f, -2.26122066e-01f,
  7.29966760e-01f, 2.06302986e-01f, 1.72798932e-01f, 2.60639936e-01f, 3.42242955e-03f, 3.60650152e-01f, 4.16014582e-01f, -3.80667061e-01f, 7.07844555e-01f, 2.79017240e-01f,
  -7.78109610e-01f, 2.36031130e-01f, 4.53815341e-01f, 6.57854915e-01f, -1.55530259e-01f, -5.18512964e-01f, -1.69717837e-02f, -1.99732855e-01f, -5.65678656e-01f, 7.96617344e-02f,
  -4.55117762e-01f, -4.79796708e-01f, 9.46486890e-01f, 8.19048643e-01f, 6.39732003e-01f, 1.72117025e-01f, 8.09297085e-01f, 4.47194397e-01f, 6.29232585e-01f, -6.91019977e-03f,
  -3.32813293e-01f, 3.86132002e-02f, -4.69486445e-01f, 5.38006008e-01f, 1.39466330e-01f, -6.30177617e-01f, 3.56910050e-01f, -1.93396553e-01f, 3.42532992e-01f, 7.03321457e-01f,
  -8.24974179e-01f, 2.08199888e-01f, 1.10168231e+00f, 6.90241337e-01f, 2.89140165e-01f, -1.92041516e-01f, 9.41063881e-01f, 1.47060409e-01f, -4.07381952e-01f, 8.09855819e-01f,
  4.38818246e-01f, -1.06839441e-01f, 4.01352406e-01f, 1.65485010e-01f, 8.37251842e-02f, -4.91155744e-01f, 4.37838942e-01f, 2.57963408e-03f, 5.96896648e-01f, 7.82014191e-01f,
  5.37119985e-01f, 9.35735345e-01f, 5.13886333e-01f, 7.06893027e-01f, 4.91585523e-01f, -6.59667492e-01f, -4.99608755e-01f, 4.24398221e-02f, 4.90708530e-01f, 3.19473803e-01f,
  -7.84244597e-01f, 3.03624928e-01f, 2.52793342e-01f, -4.84402478e-02f, 3.88387352e-01f, 1.99297026e-01f, 4.72460806e-01f, -3.73497069e-01f, -6.65144145e-01f, -2.92771101e-01f,
  8.02236438e-01f, 6.75340176e-01f, -3.78820509e-01f, 1.72283113e-01f, 4.05766159e-01f, -4.48967189e-01f, -4.99100477e-01f, 1.04625154e+00f, -4.90799099e-01f, 3.40888381e-01f,
  -4.46964847e-03f, 6.97411001e-01f, 2.40092739e-01f, 4.64030623e-01f, 5.25065899e-01f, 2.22357169e-01f, 2.56875068e-01f, 8.07083845e-02f, 8.45142484e-01f, 2.56577104e-01f,
  8.58191431e-01f, 9.09853876e-01f, 2.66472012e-01f, 3.94378126e-01f, -6.29156828e-01f, -6.93279982e-01f, 5.10936081e-01f, -2.27754042e-01f, 2.38648102e-01f, -1.41219035e-01f,
  8.43997717e-01f, -6.36654019e-01f, 7.53910720e-01f, -4.54621166e-01f, -2.58774012e-01f, -3.46230209e-01f, 5.89395225e-01f, 2.63331383e-01f, 7.53839731e-01f, -8.98302972e-01f,
  5.52447379e-01f, 6.00345254e-01f, 3.76775563e-01f, 5.92054427e-01f, 6.92560613e-01f, 1.02463758e+00f, 3.61683697e-01f, -3.27248484e-01f, 2.18282714e-02f, -4.70843017e-01f,
  5.53350508e-01f, -6.02185607e-01f, 8.78268421e-01f, 9.09146905e-01f, -4.65199947e-01f, -2.32058808e-01f, 6.46654248e-01f, -1.47471443e-01f, -6.47807643e-02f, 4.93812948e-01f,
  -5.85973077e-02f, -5.77539563e-01f, 4.46787655e-01f, 8.56322706e-01f, -1.75252005e-01f, 7.72816658e-01f, -1.35633230e-01f, 7.16661513e-01f, -2.43167996e-01f, -6.16075158e-01f,
  -4.75593239e-01f, 1.57188550e-01f, 5.69720924e-01f, 7.58836508e-01f, -1.20357703e-02f, 5.78420460e-01f, -8.74596238e-02f, 4.35028136e-01f, -6.98430300e-01f, 3.89189243e-01f,
  -1.69908956e-01f, -5.02930060e-02f, 7.14210510e-01f, 6.52407527e-01f, -1.16577335e-01f, 8.48854780e-01f, 9.14510071e-01f, 8.39167476e-01f, 1.89544261e-01f, 5.95557511e-01f,
  -2.66771525e-01f, -5.62785625e-01f, 2.99375206e-01f, -6.61865294e-01f, 3.50782752e-01f, 3.86618376e-01f, -5.45258701e-01f, 1.42584115e-01f, 9.02521729e-01f, 8.84810150e-01f,
  4.15606529e-01f, 3.67783725e-01f, -7.34155953e-01f, 5.80716990e-02f, 1.32957712e-01f, 5.03804624e-01f, 1.74546212e-01f, -6.80129509e-03f, -1.14751473e-01f, -5.48731945e-02f,
  4.95829016e-01f, 8.34067523e-01f, 9.42001641e-01f, -1.06493540e-01f, 1.73561990e-01f, 4.17377710e-01f, -1.07723758e-01f, 5.09130001e-01f, 3.48387748e-01f, 6.35493577e-01f,
  3.36167812e-01f, 1.92062572e-01f, -5.49569964e-01f, -5.84344864e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.60625547e-01f, 2.97047704e-01f, 4.14210141e-01f, 2.38821223e-01f, 2.31197346e-02f, 5.95579207e-01f, 3.59909952e-01f, 3.65811944e-01f, 1.83758140e-01f, 2.12354690e-01f,
  1.35811806e-01f, 6.20484114e-01f, -1.21204592e-01f, 2.93825388e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.22209945e-01f, 4.99857545e-01f, 4.35338497e-01f, 7.59535283e-02f, -8.24099660e-01f, -7.06704259e-01f, -3.09029132e-01f, -6.10840797e-01f, -5.87196887e-01f, 3.48153830e-01f,
  -1.15415883e+00f, 5.70808649e-02f, -5.29334307e-01f, 5.44728041e-01f, 5.35173595e-01f, 1.91196233e-01f, -7.63519034e-02f, 5.73439538e-01f, -1.26906061e+00f, -1.74706563e-01f,
  -6.21652305e-01f, -1.01215911e+00f, 1.91350058e-02f, 3.97260934e-01f, -7.85869300e-01f, 4.66678500e-01f, 1.64040416e-01f, 7.08846748e-01f, -4.67685252e-01f, 7.99803212e-02f,
  -2.67082810e-01f, 2.45261848e-01f, -1.57257080e-01f, -5.65543890e-01f, -5.29721558e-01f, 7.38165021e-01f, 2.59221584e-01f, -5.03463924e-01f, -9.27630246e-01f, -6.93577766e-01f,
  -6.57334268e-01f, -8.50994885e-02f, 5.69742680e-01f, -5.17197251e-01f, -6.17888331e-01f, 5.29928744e-01f, -1.94841400e-01f, 3.08801562e-01f, -5.34321308e-01f, 5.70732281e-02f,
  3.66565943e-01f, 2.28914768e-01f, -8.02879214e-01f, -7.00001895e-01f, -6.89550256e-03f, -5.01467943e-01f, -7.09022403e-01f, -7.61321902e-01f, -2.80819088e-01f, -9.78439569e-01f,
  5.42664647e-01f, 4.82763313e-02f, 5.94060004e-01f, 2.06622124e-01f, 3.47651213e-01f, -1.06911695e+00f, 6.90049589e-01f, -2.91308522e-01f, 4.50860083e-01f, -5.57650805e-01f,
  -8.26419234e-01f, 6.33102596e-01f, 2.93318301e-01f, -2.95645386e-01f, -8.88400078e-01f, -4.24348950e-01f, 1.84401691e-01f, 4.64361250e-01f, -1.78527221e-01f, 1.72534361e-01f,
  -3.55439425e-01f, -2.17015017e-02f, 6.33859262e-02f, -9.05885816e-01f, -7.77059793e-01f, 7.61535943e-01f, 9.93624777e-02f, 3.07638496e-01f, 3.67756814e-01f, 3.10621411e-01f,
  -4.23042327e-01f, 4.50190306e-01f, -7.55971193e-01f, -1.03615493e-01f, 4.20801908e-01f, -8.70762885e-01f, 5.78871250e-01f, 6.53758466e-01f, -7.84399867e-01f, -4.22270119e-01f,
  6.79260075e-01f, 4.47266519e-01f, 4.25894886e-01f, -2.32062116e-01f, -7.31257021e-01f, 6.89813048e-02f, 7.21358478e-01f, -3.81905168e-01f, -5.98697484e-01f, 6.17743954e-02f,
  -7.02913880e-01f, -9.60039318e-01f, -1.64016426e-01f, 3.10917288e-01f, -6.83502555e-01f, -4.16123211e-01f, -2.73058981e-01f, -1.56559423e-01f, 3.33923459e-01f, 1.52683333e-01f,
  -3.91818732e-01f, 3.10092211e-01f, -8.41680288e-01f, -6.02736712e-01f, 5.33571184e-01f, -4.90644783e-01f, 3.14796776e-01f, 2.66390294e-01f, -2.43843883e-01f, -3.13649803e-01f,
  -3.00311506e-01f, 5.34784794e-01f, -5.42687178e-01f, -1.96328670e-01f, -6.02596939e-01f, 2.23323032e-01f, 1.02640891e+00f, -2.30082646e-01f, 3.29083592e-01f, -4.59924072e-01f,
  -2.24394292e-01f, -7.96211064e-01f, -5.67426443e-01f, 4.45800006e-01f, 1.43317506e-01f, -5.56535602e-01f, -7.60512412e-01f, -4.77376819e-01f, 5.50266683e-01f, 6.62640572e-01f,
  -6.47676945e-01f, -2.66853832e-02f, 3.05572093e-01f, 1.25193462e-01f, -1.20184398e+00f, -6.85824096e-01f, -6.73952818e-01f, 6.96666539e-01f, -8.58975172e-01f, 3.38875890e-01f,
  -5.44493347e-02f, -2.56497771e-01f, 3.24191749e-01f, 2.80284584e-01f, 1.14060812e-01f, -7.80334771e-01f, 7.79071301e-02f, 3.64360273e-01f, -6.28770709e-01f, -8.29399347e-01f,
  3.50917906e-01f, 3.75422865e-01f, -7.75911883e-02f, -6.90610468e-01f, -2.29496434e-01f, 8.86780545e-02f, -1.38140514e-01f, 3.74267071e-01f, -3.08674932e-01f, 3.27545673e-01f,
  -2.35161278e-02f, 3.34920406e-01f, 6.48902655e-01f, -7.47088194e-01f, 5.60598731e-01f, -5.05713642e-01f, -4.19679791e-01f, -1.18046284e-01f, 4.46999997e-01f, -5.07717907e-01f,
  -3.26183736e-01f, -7.15752304e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.91729167e-02f, -2.77701825e-01f, -1.47361964e-01f, -3.61973673e-01f, 2.95933366e-01f, -6.04968257e-02f, -3.47436033e-03f, -1.92756116e-01f, 1.90775827e-01f, -3.55091505e-02f,
  -3.47153693e-01f, 1.82904452e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    