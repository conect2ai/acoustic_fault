/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.23596334e-01f, 9.49450806e-02f, -2.92120248e-01f, 3.28190438e-02f, -4.92109433e-02f, 8.02420378e-02f, 1.07575141e-01f, 1.64256006e-01f, -7.00593144e-02f, 3.37596059e-01f,
  1.59201920e-02f, -4.49743494e-02f, -3.60772431e-01f, 3.30363959e-01f, -6.93746746e-01f, -1.23332322e-01f, 2.18536273e-01f, 1.92681059e-01f, -1.32230848e-01f, 8.74502063e-02f,
  -9.57845822e-02f, 1.51543543e-02f, -1.17594250e-01f, 5.73689081e-02f, 9.47512686e-02f, 8.52259398e-02f, 7.88826942e-02f, -3.00275594e-01f, 3.99668366e-01f, -1.50230573e-02f,
  9.24607366e-02f, -1.25332385e-01f, 8.19370970e-02f, -7.32656866e-02f, 1.39044806e-01f, 5.49108200e-02f, 2.71073729e-02f, -8.91584828e-02f, -6.88525811e-02f, -6.77321777e-02f,
  -7.65813738e-02f, -6.33523092e-02f, 9.20439959e-02f, -2.10972145e-01f, 1.86898466e-02f, -5.93681931e-02f, -4.58409600e-02f, 7.67456293e-02f, -1.50451109e-01f, -1.06294444e-02f,
  -4.41400930e-02f, -8.16166103e-02f, 5.96117154e-02f, 2.00439334e-01f, -7.19119385e-02f, -5.50030135e-02f, 1.51518315e-01f, 1.99116208e-02f, 6.83384985e-02f, 1.53941259e-01f,
  -3.33516896e-02f, -3.70860845e-02f, 7.09245801e-02f, 2.06779893e-02f, -6.08568490e-02f, 1.44646987e-01f, -2.10936517e-01f, 1.14506915e-01f, 1.08364085e-02f, -3.35964002e-02f,
  7.66648799e-02f, 2.26446278e-02f, 4.75001931e-02f, 4.61691320e-02f, 9.30714309e-02f, 1.82025239e-01f, -4.30339612e-02f, 2.08529308e-01f, 1.30002365e-01f, 9.67207924e-02f,
  -7.96363875e-02f, 2.25733686e-02f, -7.70372450e-02f, 8.09011608e-02f, -1.10013664e-01f, -9.16394144e-02f, -3.34457457e-02f, 7.70053500e-03f, -5.24381781e-03f, -1.24334760e-01f,
  1.18345283e-01f, 2.91977618e-02f, 2.82453327e-03f, 2.15899646e-02f, 3.85692838e-04f, -7.95922875e-02f, -1.51733384e-01f, 1.36422426e-01f, -1.57266840e-01f, 4.32699285e-02f,
  2.26737306e-04f, 7.95907304e-02f, -2.42206361e-02f, 1.16619624e-01f, -4.70340960e-02f, -6.73257709e-02f, -6.04385436e-02f, 6.42305538e-02f, 1.13332801e-01f, 1.10846698e-01f,
  -5.45930900e-02f, -1.69949308e-02f, -7.82042369e-02f, 8.53388160e-02f, 7.87329078e-02f, 5.55942813e-03f, 3.20434868e-02f, -5.85437007e-02f, 2.54266821e-02f, -1.60803616e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.03742909e+00f, 1.83097258e-01f, -2.30340064e-01f, -1.00981164e+00f, 2.20599085e-01f, 2.00288922e-01f, -7.17513263e-01f, 2.06054747e-01f, -4.97959703e-01f, 2.05248594e-01f,
  1.05478792e-02f, -6.04739487e-01f, 2.55963773e-01f, -1.08603370e+00f, -5.09384573e-01f, -3.04553598e-01f, -7.68182397e-01f, -5.09182990e-01f, 1.61835566e-01f, -2.53357053e-01f,
  -3.06609154e-01f, -4.99546617e-01f, -2.23127007e-01f, 3.86910796e-01f, -4.00613189e-01f, 1.84014633e-01f, 4.24092203e-01f, 3.69592845e-01f, -2.34816924e-01f, -2.31198192e-01f,
  9.20448527e-02f, -1.54608503e-01f, 2.21416485e-02f, 1.59449339e-01f, -3.21392692e-03f, 2.87296250e-02f, 2.02949926e-01f, -1.72453955e-01f, 1.57460675e-01f, 3.74886170e-02f,
  -5.51543832e-02f, -7.37341866e-02f, -2.27264732e-01f, -1.02222949e-01f, -8.24478120e-02f, 2.89106369e-02f, -2.21890099e-02f, 3.63939077e-01f, -6.81549450e-03f, -3.24327260e-01f,
  -1.24750242e-01f, -1.34153189e-02f, 2.89573409e-02f, -6.17335998e-02f, -7.92194456e-02f, -1.62080586e-01f, -8.01605061e-02f, -2.12761033e-02f, 2.43430957e-02f, -1.50431320e-01f,
  -1.53703511e-01f, 4.17763777e-02f, 2.32929569e-02f, 1.16436705e-02f, -1.18054964e-01f, 8.72176066e-02f, -8.15651864e-02f, -8.88473261e-03f, 2.29466185e-02f, -5.52244782e-02f,
  -3.79979648e-02f, -1.87827960e-01f, 2.50793938e-02f, 1.48293078e-01f, -1.24782927e-01f, -7.51137286e-02f, -9.50925425e-02f, 4.24058996e-02f, -1.79402884e-02f, -8.85805562e-02f,
  1.32972226e-01f, -4.57779728e-02f, 5.84706068e-02f, 2.18974184e-02f, 1.10258602e-01f, 2.46228799e-02f, 8.14343840e-02f, 6.79891184e-02f, 3.01882178e-01f, -2.03590505e-02f,
  2.66899109e-01f, -3.02646658e-03f, 6.45249560e-02f, 1.14635579e-01f, -3.38567491e-03f, 5.83329424e-02f, -6.40710909e-03f, -3.15131456e-01f, 1.12220004e-01f, -2.92857736e-01f,
  -2.66226269e-02f, 6.56638294e-02f, 2.49856755e-01f, -6.33143187e-02f, -4.10779454e-02f, 1.42186001e-01f, -2.08859239e-02f, 1.42506659e-01f, -4.35321108e-02f, 9.19988230e-02f,
  7.13855252e-02f, 1.23847932e-01f, -1.56796917e-01f, -6.64784312e-02f, 3.10164709e-02f, -2.37854328e-02f, 4.86298315e-02f, -2.75334325e-02f, 1.52879115e-02f, 7.30037391e-02f,
  -1.62488431e-01f, 1.17641248e-01f, 5.86521387e-01f, -6.89176381e-01f, 7.23453164e-02f, 2.41472930e-01f, -2.76683390e-01f, -2.36170873e-01f, -7.09299803e-01f, 1.13374582e-02f,
  -3.70370924e-01f, 6.77233279e-01f, -2.84987897e-01f, -2.40959868e-01f, -7.12092817e-01f, -5.83494008e-01f, -5.58805585e-01f, -1.44399375e-01f, -1.80604562e-01f, -1.09511107e-01f,
  -3.76590759e-01f, -7.79257715e-01f, -2.59414792e-01f, -8.89449045e-02f, 4.55583483e-01f, 3.70672643e-01f, -4.41085547e-01f, 5.73453188e-01f, 3.91624212e-01f, 2.00515389e-01f,
  -2.66964108e-01f, -4.64796454e-01f, 1.45903543e-01f, 1.48820236e-01f, -4.71597724e-02f, 5.12524955e-02f, 2.16378525e-01f, 1.76667437e-01f, -8.59427825e-02f, 4.05037142e-02f,
  2.21169919e-01f, 1.71686411e-01f, 1.20120347e-01f, -2.87543833e-02f, -6.18391447e-02f, 3.92661653e-02f, 6.62305504e-02f, 1.41064733e-01f, -1.73078571e-02f, 2.73475200e-01f,
  -2.58915573e-02f, 3.78281295e-01f, -6.83862194e-02f, 6.59154207e-02f, -1.93661898e-02f, -2.78492123e-02f, 8.01239833e-02f, 4.42529172e-01f, 1.42581061e-01f, -8.26642811e-02f,
  -4.61266935e-03f, 2.87241186e-03f, 1.92991614e-01f, -1.38836369e-01f, -1.66276306e-01f, 4.96374108e-02f, -3.75660062e-02f, 4.36493196e-02f, 8.17792639e-02f, -9.63731334e-02f,
  -1.87167957e-01f, 8.71541798e-02f, -1.15780167e-01f, -1.55973226e-01f, 7.55766854e-02f, -2.34894961e-01f, 6.38354346e-02f, -3.00253567e-04f, -1.98720530e-01f, -3.21171060e-02f,
  -1.62727743e-01f, -3.23849544e-02f, -7.59316934e-03f, 1.33639062e-02f, -1.18986264e-01f, -4.75799367e-02f, -1.30081356e-01f, 1.49566308e-01f, -3.29682499e-01f, 1.79920942e-01f,
  -7.91409731e-01f, -8.08376193e-01f, -1.28394619e-01f, -1.52599940e-03f, -1.23173028e-01f, 1.86772555e-01f, 2.69601457e-02f, 1.79556400e-01f, -3.75924408e-02f, -2.13215277e-01f,
  1.06374271e-01f, -1.79146528e-02f, 9.61902067e-02f, -1.39332801e-01f, -1.71872512e-01f, 3.62283215e-02f, 5.74442279e-03f, -1.21489190e-01f, -9.14241597e-02f, 4.53783982e-02f,
  -8.64934921e-02f, -1.65374100e-01f, 1.24199390e-01f, -2.07262665e-01f, 4.45695296e-02f, 2.20883153e-02f, -2.29506027e-02f, 6.68110922e-02f, 1.10629909e-01f, -5.07149920e-02f,
  -7.50113577e-02f, 2.09848374e-01f, -5.00713587e-01f, -1.82829812e-01f, -1.95691973e-01f, -1.08563352e+00f, -4.91241932e-01f, -3.40754598e-01f, 4.74631846e-01f, 1.82455942e-01f,
  -3.13924283e-01f, 8.24861825e-01f, 6.64260507e-01f, -5.52936494e-01f, -6.00805879e-01f, 3.37886274e-01f, -8.99843633e-01f, -1.66469231e-01f, 2.94126987e-01f, -4.75249112e-01f,
  -2.59972990e-01f, -3.65096420e-01f, -2.34260887e-01f, -1.53390720e-01f, -5.09963691e-01f, -1.14594363e-01f, -1.75062612e-01f, 1.70293048e-01f, -5.18481851e-01f, 2.87917797e-02f,
  -1.68115765e-01f, 4.67408389e-01f, 4.77200896e-02f, 1.99730724e-01f, -3.90046269e-01f, -1.29421815e-01f, -1.44508943e-01f, 1.29669905e-01f, 2.79905081e-01f, 1.73550352e-01f,
  2.33603463e-01f, 3.15686017e-01f, -4.75440919e-02f, 1.13097355e-01f, 1.35615468e-01f, 9.27396119e-02f, 1.36397794e-01f, -2.49791250e-01f, 3.53514493e-01f, -1.42763192e-02f,
  -3.92783582e-02f, -2.36992866e-01f, -2.59635448e-01f, 1.99668065e-01f, 1.55213848e-01f, 3.41253392e-02f, -1.16054274e-01f, -1.70323551e-02f, -5.57727702e-02f, 5.70191331e-02f,
  8.32967088e-03f, -9.62663814e-02f, -9.05343443e-02f, 1.07455160e-02f, 1.43887341e-01f, 3.85904266e-03f, 1.68633819e-01f, 1.43726632e-01f, 4.12515067e-02f, 6.56464696e-02f,
  -8.45113471e-02f, 1.11162327e-01f, 1.17245570e-01f, -1.18785173e-01f, -6.64023384e-02f, 1.63065702e-01f, -1.33825079e-01f, 1.92789480e-01f, -2.78958231e-01f, -1.77317604e-01f,
  1.74165145e-01f, -2.62985855e-01f, 1.68668941e-01f, -1.24827377e-01f, -8.77011642e-02f, 1.30643383e-01f, -1.73463020e-02f, 1.14361964e-01f, -9.70898196e-02f, -8.02500322e-02f,
  -2.54206419e-01f, 1.06643856e-01f, 1.49252832e-01f, 2.68389821e-01f, 1.52329057e-02f, -2.09828168e-01f, -2.88889874e-02f, -7.69090578e-02f, 2.03101896e-02f, -8.91227648e-02f,
  -7.46631324e-02f, -3.49853262e-02f, -2.35141575e-01f, -8.15724283e-02f, 2.99210362e-02f, -1.95612371e-01f, -9.54929441e-02f, 7.39299878e-02f, -1.92481741e-01f, -5.31791933e-02f,
  -6.34717895e-03f, 1.13331653e-01f, 7.23668635e-02f, -7.79927298e-02f, 1.31106183e-01f, 1.00620963e-01f, 3.32147591e-02f, 9.39099863e-02f, 7.45069459e-02f, -3.67424376e-02f,
  6.91200733e-01f, -8.78784537e-01f, 7.56614804e-02f, 6.97873414e-01f, 3.53875190e-01f, -3.36195260e-01f, -8.66872221e-02f, 2.89118402e-02f, 9.13346350e-01f, -6.20357037e-01f,
  -4.04390872e-01f, 1.03935041e-01f, -8.21361005e-01f, -2.82366008e-01f, 5.22545874e-01f, -3.50286990e-01f, 1.60385728e-01f, 9.93280206e-03f, 9.49331149e-02f, -3.54107380e-01f,
  3.14636111e-01f, -4.01026279e-01f, -2.26709187e-01f, -6.50629818e-01f, -1.96433946e-01f, 1.92897618e-01f, -1.65366247e-01f, -3.21321815e-01f, -3.12563092e-01f, -1.27048576e-02f,
  -2.71949679e-01f, -1.56326041e-01f, -1.03850022e-01f, -2.37975523e-01f, 1.56286791e-01f, 1.72346950e-01f, -1.50498990e-02f, -8.07770714e-02f, 1.73335224e-01f, -3.92091088e-02f,
  3.53332572e-02f, 1.11266054e-01f, -7.13794529e-02f, -2.60860212e-02f, 2.05919668e-01f, 1.88780986e-02f, 1.97715238e-01f, 3.68911885e-02f, -2.36070715e-02f, 1.43581226e-01f,
  1.92028850e-01f, 1.72137856e-01f, 1.25729591e-01f, 5.52418344e-02f, -7.62432516e-02f, 3.99120338e-02f, 7.69609306e-03f, -3.22550125e-02f, 2.79772542e-02f, 2.25251213e-01f,
  -1.51595742e-01f, -4.41432558e-03f, -5.75891286e-02f, 1.89901814e-02f, -6.82288967e-03f, 1.10079780e-01f, 3.17791291e-02f, 7.91991800e-02f, 1.13125153e-01f, -1.60337433e-01f,
  2.74693724e-02f, -9.03490186e-03f, 7.42218345e-02f, -5.65447249e-02f, 9.60420743e-02f, 2.59329349e-01f, -1.26550779e-01f, -1.28693238e-01f, 4.62710820e-02f, 1.34140164e-01f,
  -3.82040255e-03f, 4.98671196e-02f, -3.40562284e-01f, 1.41412094e-01f, -1.09164067e-01f, -3.44930701e-02f, -1.41781241e-01f, 1.47782281e-01f, 2.48817474e-01f, -1.43747851e-01f,
  -6.87877655e-01f, -8.17687094e-01f, -1.89765140e-01f, -8.33985358e-02f, -1.34770110e-01f, 3.51939201e-02f, 1.97945490e-01f, 1.34606108e-01f, -1.60368636e-01f, -1.00997180e-01f,
  -8.24100804e-04f, 2.57612839e-02f, -1.63143259e-02f, 1.16079323e-01f, -1.18436269e-01f, -5.60496375e-02f, -2.21229461e-03f, -1.05688483e-01f, -1.48986131e-01f, -1.28566712e-01f,
  -7.61652514e-02f, -9.14611518e-02f, 8.56059194e-02f, 1.74054176e-01f, -8.32321793e-02f, -5.22052916e-03f, 2.13400424e-01f, -5.37773073e-02f, -3.86390239e-02f, -4.55508567e-02f,
  -1.81185198e+00f, 6.55898988e-01f, -2.55013794e-01f, -4.03445244e-01f, -2.65774727e-01f, -2.65612155e-01f, 3.14487725e-01f, 6.36441931e-02f, 1.18186019e-01f, 6.26428783e-01f,
  3.37737530e-01f, -2.15968207e-01f, 9.17589426e-01f, 5.48765242e-01f, -8.62611353e-01f, 7.94820189e-01f, -3.10649455e-01f, -1.10989546e-04f, 2.51296103e-01f, -3.86824429e-01f,
  -2.37230748e-01f, 1.49784416e-01f, 1.17807455e-01f, 1.76965848e-01f, -6.00195885e-01f, -3.25000793e-01f, -3.52930397e-01f, 3.33131015e-01f, -3.58809710e-01f, -1.21247418e-01f,
  -8.45533192e-01f, -1.00293048e-01f, -8.69292170e-02f, -4.38656449e-01f, -3.88063759e-01f, -7.57492939e-03f, -1.88095465e-01f, 2.17330977e-01f, -1.05528794e-01f, 4.72526401e-02f,
  -1.33458406e-01f, -3.79720367e-02f, 1.66743230e-02f, 1.20312430e-01f, -2.66209275e-01f, -9.53684673e-02f, -9.13272277e-02f, -1.41595364e-01f, 2.51378808e-02f, -8.13145004e-03f,
  8.37079734e-02f, 6.33176416e-02f, -1.96195289e-01f, -1.79527327e-02f, -2.50583678e-01f, -2.13702042e-02f, 8.16081371e-03f, -7.53732398e-02f, -2.02215374e-01f, -2.00877607e-01f,
  -2.59049851e-02f, 1.18288375e-01f, 2.39620045e-01f, 3.18902954e-02f, 9.72701162e-02f, 4.92032357e-02f, -4.62750122e-02f, 2.64031142e-02f, -1.12151824e-01f, -3.04838475e-02f,
  -1.03166230e-01f, -1.05577156e-01f, -6.46509379e-02f, -1.25382051e-01f, 9.44163278e-02f, -2.17743274e-02f, 7.42565244e-02f, -1.16471276e-01f, -4.81330827e-02f, -1.44408256e-01f,
  1.13817640e-02f, -4.56391461e-02f, -9.06874368e-04f, 1.35568827e-01f, -9.57504287e-02f, -2.04777587e-02f, -1.46521349e-02f, -1.94922499e-02f, 7.21379444e-02f, -1.97419256e-01f,
  -1.32381225e+00f, -8.93008292e-01f, 1.24121301e-01f, -2.62895763e-01f, -3.12594548e-02f, -2.69406177e-02f, 1.46103129e-01f, -2.33157098e-01f, -3.33163410e-01f, -7.96424598e-02f,
  -1.24535203e-01f, -2.50157751e-02f, -2.67602503e-01f, -3.51358168e-02f, 1.43730536e-01f, -6.37301952e-02f, -1.00215608e-02f, -9.47838426e-02f, -2.93107808e-01f, -1.22016910e-02f,
  1.56073424e-03f, -6.81713372e-02f, -4.78597620e-04f, 2.63682567e-03f, 6.24779519e-03f, -1.78247735e-01f, -1.62300557e-01f, 1.65790617e-01f, -2.19968513e-01f, 2.41419822e-01f,
  -6.71327440e-03f, -3.34909648e-01f, 5.07581413e-01f, -6.02150559e-01f, 4.27400470e-01f, 6.00511491e-01f, 4.49850291e-01f, -9.38079283e-02f, 1.86394379e-01f, -7.04415560e-01f,
  -7.73444116e-01f, -1.72965024e-02f, 2.97624528e-01f, -7.10039854e-01f, 1.14075017e+00f, 6.85986459e-01f, -2.47907430e-01f, -1.76685631e-01f, 1.52252063e-01f, -2.71224529e-01f,
  -1.47109240e-01f, -5.31488299e-01f, -7.55860284e-02f, -6.13381326e-01f, -5.84310710e-01f, -3.01659584e-01f, -5.58203101e-01f, 2.27674589e-01f, -8.42301130e-01f, 1.72368199e-01f,
  -7.10865334e-02f, -2.26740777e-01f, -6.13608994e-02f, -1.78467911e-02f, 1.41078144e-01f, 1.42040417e-01f, 6.36529997e-02f, 2.65722215e-01f, 1.03458561e-01f, 1.19272657e-02f,
  -3.87235475e-03f, 8.58163387e-02f, -2.36896068e-01f, 4.26343195e-02f, -3.26400436e-02f, -2.49214426e-01f, -8.95545259e-02f, -2.34271586e-01f, -1.40548915e-01f, 1.74363494e-01f,
  -7.39240199e-02f, -1.30803689e-01f, -1.29370242e-01f, 4.22132388e-03f, -6.84853317e-03f, -1.67088777e-01f, 1.55641168e-01f, 9.60865095e-02f, -6.94606779e-03f, 1.27572238e-01f,
  -9.37290839e-04f, 3.52107823e-01f, -1.21572949e-01f, -4.12799753e-02f, -5.81433959e-02f, -1.83519851e-02f, -1.87263340e-01f, -1.15827471e-02f, -2.74154115e-02f, -5.12684435e-02f,
  -3.65427732e-02f, -5.07935248e-02f, 4.46716249e-02f, -3.55580263e-02f, -1.03748597e-01f, 6.55717961e-03f, 6.19959421e-02f, 1.41503602e-01f, -4.70473655e-02f, 5.32756485e-02f,
  -1.10125631e-01f, 1.12423114e-01f, -6.69878423e-02f, -1.99045822e-01f, -3.49207185e-02f, -8.19324329e-02f, -7.73975700e-02f, -5.51779643e-02f, -5.24885096e-02f, 5.27477898e-02f,
  1.56202048e-01f, 2.82773376e-01f, -2.41883807e-02f, -1.54072359e-01f, 9.63127017e-02f, -1.02958299e-01f, 7.22040907e-02f, -4.26089130e-02f, -8.87961686e-02f, 1.22303136e-01f,
  -2.31887266e-01f, -1.74183533e-01f, -4.91279934e-04f, 2.82968651e-03f, 2.96115018e-02f, 5.19922003e-02f, 1.07931502e-01f, -6.66820332e-02f, 1.62563488e-01f, -8.58973563e-02f,
  -1.46561161e-01f, -1.32231668e-01f, 1.02045396e-02f, -2.18115866e-01f, -2.32047543e-01f, 2.02448629e-02f, 1.01613693e-01f, -2.02427119e-01f, 6.74490025e-03f, 8.23535100e-02f,
  1.93566844e-01f, 1.02451527e+00f, 6.72302544e-01f, 3.23592663e-01f, 3.67341727e-01f, 1.62554905e-01f, -3.06303620e-01f, 8.77993882e-01f, 6.98395133e-01f, -2.04167843e-01f,
  -2.59816349e-01f, 1.66721836e-01f, -1.67305321e-02f, 2.45557889e-01f, -4.24013168e-01f, -1.72805801e-01f, -4.04569544e-02f, -1.35007367e-01f, 5.51582634e-01f, 6.26188815e-02f,
  2.99840897e-01f, -6.85640395e-01f, 3.15212727e-01f, -3.73597033e-02f, 5.61469913e-01f, 4.02273148e-01f, -8.27216268e-01f, 1.17699407e-01f, -2.40442187e-01f, -1.25799701e-01f,
  2.49424592e-01f, 3.28557253e-01f, 3.79706174e-01f, 1.17059447e-01f, 1.27711460e-01f, -5.72481044e-02f, -5.09424834e-03f, -1.77870706e-01f, 3.59359160e-02f, 3.82215641e-02f,
  -9.75930970e-03f, -1.51819102e-02f, -6.22447431e-02f, -2.90179513e-02f, 2.52605200e-01f, 3.26094359e-01f, 2.40786582e-01f, 2.78452724e-01f, 3.48968923e-01f, 3.53679240e-01f,
  4.66279536e-01f, 5.32736361e-01f, 5.23854829e-02f, -1.54415265e-01f, 1.17713369e-01f, 1.71263874e-01f, -9.94730964e-02f, 9.96027738e-02f, 1.38448894e-01f, 1.51909634e-01f,
  1.10680973e-02f, -1.26337081e-01f, -8.98422152e-02f, -6.46581352e-02f, -1.26518905e-01f, 1.64876565e-01f, -9.50197950e-02f, -2.07125038e-01f, -2.47483552e-02f, 3.18066515e-02f,
  -3.97307165e-02f, 1.06060855e-01f, 4.19817306e-03f, -7.09476173e-02f, -9.39644575e-02f, 7.48184025e-02f, -1.67411074e-01f, -8.48613456e-02f, 1.75456718e-01f, -8.65947572e-04f,
  -5.26064783e-02f, -1.76774397e-01f, -1.15939498e-01f, -8.46203864e-02f, -5.13317361e-02f, 7.55185261e-02f, 2.39460126e-01f, 2.32191786e-01f, 2.83645671e-02f, -2.59050634e-02f,
  -2.34301969e-01f, -4.89422560e-01f, 5.35880290e-02f, 4.19756472e-02f, -1.94478244e-01f, 8.58093030e-04f, -1.14170827e-01f, 1.96365163e-01f, -4.05058227e-02f, -2.62253825e-03f,
  3.14533077e-02f, -4.09639180e-02f, -1.58974379e-01f, -1.28079355e-01f, -1.31328776e-01f, -1.26330135e-02f, -2.08380640e-01f, -1.31663144e-01f, -2.32177511e-01f, 8.71038884e-02f,
  -6.75696060e-02f, -2.84830779e-01f, -3.42320949e-02f, 7.67412409e-02f, -7.67549453e-03f, -2.32388005e-01f, -1.72487333e-01f, 1.44202411e-01f, -1.76570997e-01f, -5.01761138e-02f,
  4.72074836e-01f, -5.25038838e-01f, -6.36192381e-01f, 1.25060588e-01f, 1.26066625e-01f, -3.68269295e-01f, -9.84276175e-01f, -8.79262760e-02f, -6.70643389e-01f, -3.07035536e-01f,
  -1.98753700e-02f, 4.84992266e-02f, -8.66588652e-01f, 7.52986610e-01f, 9.55619216e-01f, -5.46067297e-01f, 9.41459239e-01f, 3.75554770e-01f, -4.17512283e-02f, 2.30326280e-01f,
  3.91551346e-01f, 8.50868344e-01f, 1.31161168e-01f, 7.34444737e-01f, 5.47109544e-01f, 3.40418494e-03f, 8.10192943e-01f, -3.43648285e-01f, 7.93278575e-01f, 5.74210167e-01f,
  -2.23093163e-02f, -1.40401172e-02f, -1.35527238e-01f, -2.87500117e-02f, -9.14243609e-02f, 1.88027769e-01f, 7.58228004e-02f, 2.76870638e-01f, 8.54769722e-03f, -1.24157034e-01f,
  -4.86603044e-02f, 2.38240927e-01f, 7.30258524e-02f, 1.41928583e-01f, 7.08571449e-02f, 9.83330421e-03f, -1.61803499e-01f, -1.40956655e-01f, -3.51776421e-01f, 1.01382002e-01f,
  -3.41625810e-01f, -8.43132753e-03f, 4.41333838e-02f, -5.22228442e-02f, -3.03482562e-01f, -1.77274704e-01f, -1.39221936e-01f, -1.70867220e-01f, -6.77331164e-02f, 2.20722929e-01f,
  1.04567461e-01f, 6.05159178e-02f, -1.62285846e-02f, -1.42276600e-01f, 7.84272626e-02f, -6.63986355e-02f, 6.73851073e-02f, -1.95261892e-02f, -8.50887522e-02f, -2.86769234e-02f,
  -5.87506182e-02f, -1.05345987e-01f, -3.51881026e-05f, 1.46437921e-02f, 2.56618075e-02f, 2.28323843e-04f, 7.75982663e-02f, 1.32079255e-02f, -3.53091359e-01f, -1.77144364e-01f,
  1.37609676e-01f, 1.19820789e-01f, -2.83503115e-01f, -2.79397871e-02f, 1.52388990e-01f, -4.37812787e-03f, 2.11704791e-01f, 7.70122036e-02f, -1.50145292e-01f, 6.80243522e-02f,
  -6.10704301e-03f, 2.96741694e-01f, -3.15223366e-01f, -5.47110029e-02f, -3.58818732e-02f, 2.18650371e-01f, 1.46267474e-01f, 9.81032029e-02f, 1.69904098e-01f, -3.32884341e-02f,
  2.39050150e-01f, -1.05175376e-01f, 1.34288505e-01f, 1.68101951e-01f, 7.19120428e-02f, 7.71983638e-02f, 1.54361902e-02f, 3.30906734e-02f, 2.23520808e-02f, 1.84325650e-01f,
  -3.24038379e-02f, -2.88883328e-01f, 8.76160339e-02f, -3.63947004e-01f, -4.81304377e-02f, -8.30682516e-02f, 4.86241691e-02f, 3.76297534e-02f, 1.41936541e-02f, -1.14612378e-01f,
  -1.39023817e+00f, 1.75383627e-01f, -7.33039156e-02f, -6.21521950e-01f, 2.09340975e-01f, 1.06391406e+00f, 6.19126320e-01f, 1.03266373e-01f, -5.69581151e-01f, 2.24740192e-01f,
  4.98984009e-01f, -4.23431009e-01f, 4.90790755e-01f, 6.66987896e-01f, 8.17585588e-01f, 9.36947763e-01f, 5.27508616e-01f, 1.87380075e-01f, -2.01425627e-01f, -3.15143824e-01f,
  1.37676354e-02f, 6.03539824e-01f, 5.76309562e-01f, -9.59000587e-02f, 1.56487122e-01f, -6.34480000e-01f, -8.69210213e-02f, -1.26106128e-01f, 3.61272395e-01f, 2.64469862e-01f,
  1.04863597e-02f, -7.73504198e-01f, -6.62396923e-02f, -2.20341936e-01f, 1.46193713e-01f, -1.52883798e-01f, 5.38577773e-02f, 1.81171596e-02f, -1.16061538e-01f, 1.87175591e-02f,
  -4.22139727e-02f, 4.55825739e-02f, -1.26897052e-01f, -1.68121364e-02f, -1.05314188e-01f, -1.11277692e-01f, 2.26057604e-01f, 1.82692289e-01f, 3.15197371e-02f, 2.47141153e-01f,
  2.73892701e-01f, 2.31907904e-01f, 5.46438880e-02f, 5.08353412e-02f, 1.86965093e-01f, -6.33049104e-03f, 1.15805417e-01f, 7.17422068e-02f, 2.22604334e-01f, 1.28549337e-01f,
  -7.79927820e-02f, -7.66384369e-03f, 1.41317159e-01f, 7.45739490e-02f, 9.13965404e-02f, 7.35808760e-02f, 9.12311748e-02f, 3.48550230e-02f, -7.24770054e-02f, 1.93545565e-01f,
  -1.32179186e-01f, 8.37758034e-02f, -1.50007859e-01f, -2.45755576e-02f, 9.59150940e-02f, -7.13161305e-02f, 2.59784021e-04f, -9.89208668e-02f, -1.35601489e-02f, 1.02907427e-01f,
  -1.13431402e-01f, -1.82466194e-01f, -2.07674615e-02f, -5.36486097e-02f, 4.16544974e-02f, 9.96645987e-02f, -1.67810693e-01f, 3.97837199e-02f, 4.18124162e-02f, 6.39012828e-02f,
  -2.70656437e-01f, -6.41163051e-01f, 1.03507023e-02f, -1.29276201e-01f, -3.48132011e-03f, 1.00025587e-01f, -1.22217193e-01f, 4.44005355e-02f, -2.86530536e-02f, -5.47398776e-02f,
  -6.79483116e-02f, -1.65376782e-01f, -1.94573864e-01f, -2.14690007e-02f, -4.39018458e-02f, 9.94754732e-02f, -1.53655544e-01f, -3.79086763e-01f, 8.35134462e-02f, -1.35857165e-01f,
  -1.62964925e-01f, -9.54906568e-02f, 1.33227669e-02f, -2.67799068e-02f, 2.55513564e-02f, 4.78938110e-02f, -2.10779190e-01f, -1.20552860e-01f, 1.27855957e-01f, -8.72805715e-02f,
  -8.49861681e-01f, 9.39038336e-01f, 9.48096037e-01f, 6.45327568e-01f, -1.08767307e+00f, -1.03305215e-02f, 1.18003450e-01f, -2.28726659e-02f, 6.08753502e-01f, 3.11902225e-01f,
  -6.79605067e-01f, 4.59898919e-01f, 6.21107593e-02f, 2.44817063e-01f, -3.70320193e-02f, 6.15443408e-01f, 4.08688098e-01f, 2.50482768e-01f, 1.75437182e-01f, 1.03483133e-01f,
  9.70605016e-02f, -4.44181085e-01f, 2.02705771e-01f, -4.01263870e-03f, -4.87877846e-01f, 3.72397423e-01f, -2.65335262e-01f, 1.85891628e-01f, -1.03267096e-02f, -1.41237453e-01f,
  -4.94561404e-01f, -7.66043179e-03f, -2.44136393e-01f, 2.05438882e-01f, -5.93584776e-02f, -1.75025746e-01f, 5.48757911e-02f, -7.88283497e-02f, -5.06057031e-02f, 3.12281772e-02f,
  4.96126898e-02f, -8.37621279e-03f, -5.56112751e-02f, 6.54193982e-02f, -1.22023605e-01f, 6.60752580e-02f, -5.95396571e-03f, -3.61662358e-02f, 5.04930643e-03f, -1.08613878e-01f,
  9.76182669e-02f, -2.36082599e-02f, 9.01086181e-02f, 2.26063073e-01f, -1.09268419e-01f, -4.84679937e-02f, 2.00024679e-01f, 2.13317815e-02f, 1.82010993e-01f, 7.43461996e-02f,
  -6.99642301e-02f, 2.34748679e-03f, 6.03503101e-02f, -8.22021067e-02f, 6.78120703e-02f, -1.18146047e-01f, 1.02937944e-01f, -2.47722000e-01f, 6.93586245e-02f, -6.25239760e-02f,
  -2.91886590e-02f, -1.20911554e-01f, -8.19920525e-02f, 3.90381925e-02f, -1.03278063e-01f, 1.55343458e-01f, 7.57418945e-02f, -1.47077418e-03f, 3.87534164e-02f, -2.72391420e-02f,
  1.37651533e-01f, 1.10320829e-01f, -1.92612261e-01f, -1.35956824e-01f, -2.13092603e-02f, 3.99887972e-02f, 3.67338657e-02f, 8.76353756e-02f, -1.59726683e-02f, -1.00043647e-01f,
  2.02940136e-01f, 6.56609476e-01f, -8.86259880e-03f, -2.31175154e-01f, 2.03752518e-01f, -7.58481771e-02f, 1.31198213e-01f, 3.16857025e-02f, 4.08840239e-01f, 1.97748058e-02f,
  -1.03051744e-01f, 5.35574509e-03f, 4.54428829e-02f, -6.01148084e-02f, 2.07746223e-01f, 4.39663138e-03f, 1.09965354e-01f, 1.12484805e-01f, 4.38247025e-02f, -1.06195726e-01f,
  -1.34428322e-01f, -2.06176266e-02f, 7.98558891e-02f, -6.68658614e-02f, -1.21974654e-01f, -7.82418996e-02f, -6.51399493e-02f, -2.97634974e-02f, -1.22542381e-01f, 2.58209705e-01f,
  -6.08999193e-01f, 3.77427042e-01f, -2.43102506e-01f, -2.83301681e-01f, 3.38104993e-01f, -4.48805213e-01f, -5.67338884e-01f, 7.14105964e-01f, -4.71114576e-01f, 4.46076632e-01f,
  1.85280725e-01f, -6.70873702e-01f, 2.55578786e-01f, -6.39063537e-01f, -8.01563323e-01f, -7.06471622e-01f, -4.17840004e-01f, -3.95723134e-01f, -3.72293204e-01f, 3.81849229e-01f,
  -8.37557912e-02f, 3.21637392e-01f, -1.94915548e-01f, 8.93039405e-01f, 3.74810517e-01f, 6.00956559e-01f, 9.03430343e-01f, 5.40769398e-01f, 3.14026862e-01f, -1.60849348e-01f,
  -3.99953574e-01f, 8.14882591e-02f, 1.25327393e-01f, -2.74323761e-01f, 3.77709001e-01f, 2.80074954e-01f, -6.24637604e-02f, -9.27457437e-02f, -1.93971366e-01f, -1.66403130e-01f,
  5.55900037e-02f, -9.30301175e-02f, -6.46895096e-02f, -9.75045264e-02f, 1.44805610e-01f, 1.59474108e-02f, -1.17767110e-01f, -1.48629814e-01f, -1.59169078e-01f, -7.91525394e-02f,
  -3.98623087e-02f, -1.15053348e-01f, 1.98144808e-01f, -3.88529338e-02f, 5.52467778e-02f, -2.05493197e-02f, -1.69864550e-01f, 5.56964353e-02f, 5.45949973e-02f, 8.29820931e-02f,
  2.79887587e-01f, -4.15791683e-02f, 3.79166231e-02f, -8.23122263e-02f, -1.15283847e-01f, 2.11005658e-02f, -3.33558507e-02f, 9.94644780e-03f, -6.26412481e-02f, 2.99718324e-02f,
  -1.18743097e-02f, 8.63537267e-02f, 4.54020835e-02f, -8.69028941e-02f, -2.39658169e-02f, -1.92585424e-01f, -3.47354561e-02f, -9.85158533e-02f, -2.84751807e-03f, 7.14704841e-02f,
  -4.98575391e-03f, 5.03298678e-02f, -2.24034432e-02f, 2.13819116e-01f, -3.03001612e-01f, -1.90773048e-02f, 1.41504258e-01f, -1.24292709e-01f, -3.60339582e-02f, 2.50237048e-01f,
  2.27312252e-01f, 7.76286781e-01f, -1.74710061e-03f, -3.94545458e-02f, -1.49533167e-01f, 2.91737393e-02f, -3.52873504e-01f, 1.41360298e-01f, 6.96258470e-02f, 1.09268300e-01f,
  2.38299772e-01f, 7.05549270e-02f, 2.68197149e-01f, -1.84118479e-01f, 1.23588070e-01f, 2.56439239e-01f, 2.45277911e-01f, -1.67082518e-01f, 4.16680187e-01f, 3.62041593e-01f,
  3.22400749e-01f, 1.15676187e-01f, 8.72140080e-02f, 1.30434871e-01f, 3.75021935e-01f, 2.08572671e-01f, 1.30365327e-01f, -7.56488815e-02f, 3.94940406e-01f, 1.94744512e-01f,
  2.69270718e-01f, -3.61179590e-01f, 5.56047261e-01f, 7.65546083e-01f, -3.67321223e-01f, -4.95110750e-01f, 6.48150086e-01f, -3.26199591e-01f, -5.20920217e-01f, -5.15789032e-01f,
  1.73249602e-01f, 3.53133172e-01f, 7.63556302e-01f, -1.19555302e-01f, 4.84789282e-01f, 1.67863712e-01f, -3.52378264e-02f, 1.57772541e-01f, -5.28226458e-02f, 1.56777635e-01f,
  3.85581195e-01f, -4.01668280e-01f, 7.94509411e-01f, -7.78907657e-01f, 8.48861858e-02f, 1.49491727e-01f, 3.38815957e-01f, 1.98680118e-01f, -2.24479675e-01f, -8.52500275e-02f,
  -3.78874272e-01f, -6.16902225e-02f, 2.09809199e-01f, -2.32568696e-01f, -1.10619910e-01f, 1.83236480e-01f, 2.48409882e-01f, 3.06516498e-01f, 2.55493879e-01f, 1.00391153e-02f,
  4.69883010e-02f, 2.26852694e-03f, -2.88717538e-01f, 1.16068698e-01f, -2.19152719e-01f, -1.19552068e-01f, -1.42049417e-01f, 1.30699307e-01f, -9.19662509e-03f, 1.44829914e-01f,
  2.51603425e-01f, 9.09983292e-02f, 1.95952162e-01f, 4.07907739e-02f, 1.18040681e-01f, -9.29727033e-02f, 8.19941312e-02f, 1.98167190e-01f, -1.00499503e-01f, -1.65419579e-01f,
  -1.02445416e-01f, 1.81625206e-02f, 4.64143790e-02f, 7.80365197e-03f, 9.80198104e-03f, 6.46388903e-02f, 4.21693400e-02f, -3.28232422e-02f, -2.51777936e-03f, 8.16340968e-02f,
  -3.67826186e-02f, 8.10966417e-02f, -2.02280179e-01f, 5.63405268e-02f, -6.90879226e-02f, 1.18499525e-01f, 1.89545497e-01f, -5.64348847e-02f, -3.63238505e-03f, -1.25816120e-02f,
  1.70617789e-01f, -1.90124139e-01f, 4.57290597e-02f, 2.49279141e-02f, -8.65049139e-02f, 2.05177784e-01f, 4.88035418e-02f, 9.47916582e-02f, 1.60810933e-01f, 6.63828254e-02f,
  -1.89375132e-01f, -1.46888018e-01f, -1.08925052e-01f, -2.36016318e-01f, -7.55338296e-02f, -2.10203961e-01f, 1.94404740e-02f, -3.25013250e-01f, 5.88294072e-03f, -2.27063015e-01f,
  -1.11022547e-01f, 3.64319645e-02f, -1.62627235e-01f, -2.00579409e-02f, -7.96365812e-02f, 3.11006382e-02f, 1.23814143e-01f, -1.48985192e-01f, 5.11435382e-02f, 8.70453194e-02f,
  1.66144192e-01f, -4.45380211e-02f, -7.35481232e-02f, -2.55561918e-01f, -1.46711066e-01f, 9.17504057e-02f, -4.85051945e-02f, -1.10625543e-01f, -3.47489826e-02f, -2.07148306e-02f,
  8.80924702e-01f, 3.38144451e-01f, -4.56153482e-01f, 2.41435453e-01f, -4.52943057e-01f, 9.86248255e-01f, 1.01300502e+00f, -1.86752547e-02f, 2.77274847e-01f, 7.09008574e-01f,
  1.51426256e-01f, 2.68837035e-01f, 2.87936807e-01f, 9.21414018e-01f, 1.87212713e-02f, 4.70779061e-01f, 8.35883737e-01f, 5.44538558e-01f, -1.12890154e-01f, 3.97633910e-01f,
  8.54847133e-02f, 5.75200260e-01f, -5.74767470e-01f, -3.81732851e-01f, 3.18062395e-01f, -4.57185239e-01f, -4.63974804e-01f, -4.94011134e-01f, -6.99985772e-02f, -8.30707774e-02f,
  1.08936382e-02f, 1.78695723e-01f, 7.02059036e-03f, 2.27256492e-02f, -2.24734191e-02f, -2.29664221e-02f, -8.59647468e-02f, -2.93235302e-01f, -1.77999675e-01f, 3.23462039e-02f,
  1.45506874e-01f, -8.20592195e-02f, 3.48467976e-01f, -1.31605372e-01f, -6.53525069e-02f, -8.66452828e-02f, -6.28803298e-03f, -2.08084792e-01f, -2.16883142e-02f, 4.22749184e-02f,
  -3.53444666e-02f, 2.80532464e-02f, 6.94724843e-02f, -6.22480661e-02f, -6.12805821e-02f, 1.20646030e-01f, 1.52263965e-04f, -7.47509450e-02f, -5.24439849e-02f, 3.78735103e-02f,
  7.08117262e-02f, 2.01694056e-01f, 2.94252485e-01f, 1.52917404e-03f, -1.82825197e-02f, -1.31875262e-01f, 9.84340459e-02f, -7.96730891e-02f, -2.73751672e-02f, 1.15610778e-01f,
  -8.38267431e-02f, 4.02481779e-02f, -1.60475373e-02f, 1.18293129e-01f, 2.29372233e-01f, 3.68790813e-02f, -1.75773889e-01f, 2.23615784e-02f, 8.76417011e-02f, -1.68743879e-01f,
  -1.07521206e-01f, 4.17243540e-02f, 1.30787835e-01f, -6.39471561e-02f, 4.27677855e-03f, -4.51168977e-02f, 1.78339869e-01f, 5.32715358e-02f, -5.89458980e-02f, 1.06240220e-01f,
  1.11680977e-01f, 4.19846267e-01f, 2.21640185e-01f, 2.83945203e-02f, -1.09681696e-01f, 2.34022573e-01f, 9.54273343e-02f, 1.57790735e-01f, 3.52486745e-02f, 3.07368994e-01f,
  -7.49259070e-02f, 7.38018677e-02f, 9.95871797e-02f, -2.14261711e-01f, -1.96495235e-01f, 2.50825107e-01f, 1.82707161e-01f, 8.43135193e-02f, -1.22542754e-02f, -7.76071176e-02f,
  -3.64426821e-02f, 2.37299889e-01f, 7.14303777e-02f, 4.41831425e-02f, -8.18397552e-02f, 6.64412789e-03f, -5.76643050e-02f, -1.97397038e-01f, -5.10551557e-02f, -2.31905631e-03f,
  2.74543077e-01f, -1.13243878e+00f, 4.08250332e-01f, 5.53077281e-01f, 6.83819175e-01f, -7.50936707e-03f, -3.73257816e-01f, 2.19347149e-01f, -4.55043605e-03f, -1.01406693e+00f,
  -1.37911722e-01f, -6.39002144e-01f, -6.53926075e-01f, 3.04946721e-01f, 3.73202831e-01f, -1.81094512e-01f, 3.14078182e-01f, -2.45833188e-01f, 2.52031803e-01f, 3.85078877e-01f,
  5.25702000e-01f, 3.84941757e-01f, 3.37920755e-01f, 4.30007815e-01f, 1.84356675e-01f, 2.02132240e-01f, -3.01196903e-01f, 1.44811526e-01f, 1.90528661e-01f, 1.01615503e-01f,
  -1.21633917e-01f, 1.32199287e-01f, -7.03690872e-02f, -2.26541355e-01f, -8.40333663e-03f, -2.02124521e-01f, -1.40346989e-01f, 1.11402340e-01f, 2.01806694e-01f, 7.20640551e-03f,
  -2.79794604e-01f, 1.69188038e-01f, 7.86256790e-02f, -4.65143891e-03f, -1.68768987e-02f, 1.47617072e-01f, 1.13670163e-01f, 8.74984786e-02f, 8.20342917e-03f, 5.40029444e-02f,
  4.13312204e-02f, 8.09113607e-02f, 2.07784727e-01f, -3.52426581e-02f, 8.21774453e-02f, 1.03716888e-01f, 1.22118639e-02f, -1.17580652e-01f, -1.27423137e-01f, 1.07379638e-01f,
  3.01017594e-02f, -4.25670259e-02f, 1.91982314e-02f, 1.27406369e-04f, 7.37659261e-02f, -1.20155690e-02f, 1.63066447e-01f, -6.48348629e-02f, 1.84345972e-02f, -1.15604833e-01f,
  1.63075224e-01f, -1.54530898e-01f, 1.25855207e-01f, -2.03871951e-02f, -4.36797505e-03f, 5.25466725e-02f, 1.50097474e-01f, 8.44346806e-02f, -3.81412506e-02f, 7.69319981e-02f,
  -6.03185557e-02f, 7.41612166e-02f, -9.69053805e-02f, 5.84666245e-02f, -1.82497054e-01f, -1.08256355e-01f, 3.25307176e-02f, -1.18776344e-01f, -6.42634369e-03f, -2.08475813e-02f,
  -1.40399432e+00f, -8.58363450e-01f, 1.73394440e-03f, -1.03952430e-01f, -1.47148430e-01f, -1.56188250e-01f, 1.53121337e-01f, 2.13546023e-01f, -1.90089047e-01f, 1.22055009e-01f,
  -1.14946149e-01f, 1.42087871e-02f, -1.99433148e-01f, 9.78374183e-02f, -9.11127850e-02f, -5.32891490e-02f, -2.33630925e-01f, -4.14939582e-01f, -2.04739928e-01f, -1.70444384e-01f,
  -7.03664199e-02f, -7.67382532e-02f, 1.35996446e-01f, 2.56916732e-01f, -3.93750183e-02f, -2.17763349e-01f, -7.72896558e-02f, 7.10000694e-02f, 1.56561211e-01f, -5.18744029e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.08967400e+00f, 1.33600545e+00f, 2.20978081e-01f, 1.08766735e+00f, 2.83393592e-01f, 1.33247638e+00f, 1.35707057e+00f, 6.07735813e-01f, 9.34582114e-01f, 1.26785445e+00f,
  1.09361172e+00f, 7.68281221e-01f, 9.94523108e-01f, 7.02349186e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.76225436e-01f, 8.31123948e-01f, 2.31565639e-01f, -7.63495505e-01f, -9.05314445e-01f, -7.71682739e-01f, 9.72001076e-01f, -1.83029807e+00f, -1.51518357e+00f, -1.03621387e+00f,
  7.16910779e-01f, 4.76690441e-01f, -1.04263580e+00f, 9.79047790e-02f, 3.83032471e-01f, -7.70961761e-01f, 9.16609839e-02f, 1.41440737e+00f, -1.08642471e+00f, -9.52682793e-01f,
  -4.20895398e-01f, -7.66029418e-01f, -1.27023292e+00f, -1.85559347e-01f, -7.69409597e-01f, 8.25248361e-01f, 9.27384138e-01f, -1.33250475e+00f, -3.00832629e-01f, -8.49521935e-01f,
  7.82702148e-01f, -1.31729913e+00f, -5.11906520e-02f, -1.80422068e-01f, 8.13659653e-03f, 2.00192019e-01f, -8.17692101e-01f, 4.33791101e-01f, -7.24139929e-01f, -1.08582592e+00f,
  -1.17268336e+00f, 8.39729011e-01f, 9.49970856e-02f, -9.08601642e-01f, -5.39461851e-01f, -8.37577224e-01f, -1.18564308e+00f, 9.15645599e-01f, 1.99676096e-01f, -5.78492463e-01f,
  2.89044619e-01f, 2.12044641e-01f, 9.44086194e-01f, -1.23722529e+00f, 1.15265179e+00f, -1.23513150e+00f, -5.30685112e-02f, -9.34951127e-01f, -1.04461706e+00f, -2.83013701e-01f,
  2.08456069e-01f, -8.58393252e-01f, -9.48796272e-01f, 1.56471387e-01f, -6.40827656e-01f, -1.25270319e+00f, 6.97739065e-01f, 4.57828820e-01f, -1.07628417e+00f, -1.19923735e+00f,
  2.04737440e-01f, 5.28477371e-01f, 6.10156655e-01f, -3.93312961e-01f, 8.87088597e-01f, 2.13227227e-01f, -7.96566784e-01f, -7.84086227e-01f, -1.49679518e+00f, 4.40378696e-01f,
  2.61542380e-01f, -5.26479661e-01f, -1.05347729e+00f, -1.33573890e+00f, 4.05525230e-02f, 6.02944680e-02f, -1.45736516e-01f, 6.14833534e-01f, 1.45528704e-01f, -8.29517782e-01f,
  -7.26758301e-01f, 1.39015043e+00f, -1.08824289e+00f, -6.85440183e-01f, 8.48540127e-01f, -1.01956201e+00f, 1.01135969e+00f, -4.96938884e-01f, -1.31904155e-01f, -1.06600749e+00f,
  -1.28060341e+00f, 1.13745606e+00f, -1.03759861e+00f, 2.53644556e-01f, 7.04327464e-01f, -1.20439851e+00f, -1.15038764e+00f, -1.37993693e+00f, -2.65497994e-02f, -2.03553617e-01f,
  3.31572264e-01f, 8.90863538e-01f, -2.39808336e-01f, -3.64267796e-01f, 2.54816711e-01f, 1.01502553e-01f, 1.22937524e+00f, 7.91284561e-01f, 7.70077035e-02f, 2.65109748e-01f,
  -1.06705308e+00f, -1.89345106e-01f, -7.58023918e-01f, -4.90803123e-01f, -1.13176203e+00f, -8.34592208e-02f, -1.14605021e+00f, -8.52785051e-01f, -9.23510715e-02f, -9.55200016e-01f,
  -1.06781161e+00f, -1.20896924e+00f, -4.11887676e-01f, -1.09468317e+00f, -4.76483226e-01f, -9.53907371e-01f, 8.71709511e-02f, 5.09305179e-01f, -1.20683038e+00f, 8.47133815e-01f,
  8.53841543e-01f, 1.03343534e+00f, -3.57851893e-01f, -1.42119676e-01f, -5.02780139e-01f, -7.60860920e-01f, -1.18601906e+00f, 7.57594943e-01f, -1.18938282e-01f, 1.21823654e-01f,
  -8.75395179e-01f, 1.14738607e+00f, -1.36022389e+00f, -7.91592479e-01f, 4.37180519e-01f, -1.05388939e+00f, -7.38145590e-01f, 1.30987155e+00f, -7.86639690e-01f, 5.68953864e-02f,
  9.02016833e-02f, 9.95827019e-01f, 8.09536457e-01f, 6.11918032e-01f, -8.97942424e-01f, -6.38871193e-01f, -1.04399014e+00f, -5.54515183e-01f, -8.40450585e-01f, -5.53004086e-01f,
  -8.44614804e-01f, -5.37351549e-01f, 1.07863927e+00f, -2.97428548e-01f, -1.11761498e+00f, -9.32709694e-01f, -2.88080096e-01f, 8.88585508e-01f, -4.29197550e-01f, 1.26661670e+00f,
  3.50069255e-01f, 2.00167239e-01f, -8.33299816e-01f, -1.28109837e+00f, 9.74838555e-01f, -9.45575774e-01f, -8.41219366e-01f, 4.25058752e-01f, -5.21350324e-01f, 2.27286696e-01f,
  -2.81777918e-01f, -6.01069391e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.12662084e-01f, 8.21644813e-02f, -1.67309731e-01f, -4.56339449e-01f, 7.60833919e-02f, 9.68984589e-02f, 3.07429194e-01f, -6.65341616e-01f, -6.61778867e-01f, -8.58863890e-02f,
  1.03193030e-01f, -2.99428016e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    