/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.27847147e-01f, -5.94357729e-01f, 9.41394735e-03f, -2.33787462e-01f, 4.33240712e-01f, -2.75668830e-01f, -7.29245692e-02f, -9.17406455e-02f, 1.06196776e-01f, -3.66988301e-01f,
  -6.21664710e-02f, -2.59603947e-01f, -5.88648766e-02f, -2.32152879e-01f, 3.13191116e-01f, -8.98485556e-02f, 5.57465851e-03f, -1.18129402e-01f, 1.41158268e-01f, 1.51098622e-02f,
  1.39965385e-01f, -4.56959195e-02f, 1.54004008e-01f, 8.02635681e-03f, 9.50597785e-03f, -1.06853150e-01f, 3.09031978e-02f, -3.25102322e-02f, -7.47076944e-02f, 1.79779455e-02f,
  9.46329385e-02f, -8.79191607e-02f, 1.05840385e-01f, 9.17129777e-03f, -4.03935649e-02f, -1.22804314e-01f, 5.48127107e-03f, 2.22363006e-02f, 9.30093415e-03f, -2.56741513e-02f,
  -7.83960745e-02f, 4.00967114e-02f, -4.19140197e-02f, -2.36186441e-02f, 1.13715217e-01f, 4.41505499e-02f, 1.08173370e-01f, 1.16615884e-01f, -8.93365741e-02f, 4.96565271e-03f,
  5.92912398e-02f, 5.88982664e-02f, 9.62303653e-02f, -2.24807560e-01f, 3.27441506e-02f, -1.28790028e-02f, -1.35042444e-01f, -5.44729382e-02f, -3.50454194e-03f, -6.36063591e-02f,
  -5.34555092e-02f, -3.74642434e-03f, 1.24652870e-02f, 4.25340161e-02f, 1.11755813e-02f, 6.08190037e-02f, 3.41252238e-02f, -9.32638422e-02f, 1.00868620e-01f, 3.98747434e-05f,
  -4.62597646e-02f, -3.75595242e-02f, 5.38556278e-03f, 4.21143137e-02f, 3.37773897e-02f, -1.26365304e-01f, 4.58096936e-02f, -4.95121107e-02f, 2.39230823e-02f, 4.91721034e-02f,
  -1.03202470e-01f, 1.35220066e-02f, 2.41068611e-03f, -2.49604918e-02f, -2.56411675e-02f, 7.77002722e-02f, -9.22403485e-02f, 1.45229688e-02f, 3.53223421e-02f, 5.42885996e-02f,
  -2.82985419e-01f, -3.03069890e-01f, -4.98607755e-02f, -5.87690680e-04f, -6.13105409e-02f, 9.55552794e-03f, 7.58314058e-02f, 3.87880802e-02f, -5.18922368e-03f, 2.40766238e-02f,
  -8.09251070e-02f, -1.12191617e-01f, -5.95685653e-02f, 7.72967860e-02f, -3.86281051e-02f, -3.89043726e-02f, -1.20604321e-01f, -4.58433367e-02f, 1.38875678e-01f, -8.81737471e-03f,
  -5.63156456e-02f, -3.53387408e-02f, -6.43066466e-02f, 7.96047896e-02f, -2.69018095e-02f, -3.65753472e-02f, 7.74466023e-02f, -2.10993141e-02f, 3.38481888e-02f, 1.76251866e-02f,
  -5.91079831e-01f, -2.09510088e-01f, -4.32274520e-01f, -4.85288441e-01f, 1.31360427e-01f, 3.59292962e-02f, -3.46444160e-01f, -1.21543281e-01f, -3.86056721e-01f, 1.57444626e-01f,
  7.78018981e-02f, -2.74828553e-01f, -6.40265048e-02f, 1.68296769e-01f, -4.06814218e-02f, -8.80819783e-02f, -7.58970063e-03f, -1.72472358e-01f, -5.18483929e-02f, -2.38683581e-01f,
  -5.66346645e-02f, 1.64117292e-01f, -5.30878268e-02f, 6.42006174e-02f, -2.70405769e-01f, -2.03328624e-01f, 3.17462206e-01f, -1.17966905e-01f, 4.78555501e-01f, 1.04267314e-01f,
  4.53201458e-02f, -3.96405123e-02f, 1.81669354e-01f, -3.50925140e-02f, -5.02746627e-02f, 1.27623782e-01f, 1.06604218e-01f, -5.38582122e-03f, 3.38859074e-02f, -8.28163773e-02f,
  4.73189391e-02f, -4.76495251e-02f, -1.86767280e-02f, -3.06578334e-02f, 5.44021875e-02f, -2.04114914e-02f, 2.80829379e-03f, 6.66274652e-02f, -3.14909667e-02f, -9.36011076e-02f,
  -2.94801462e-02f, 1.09739885e-01f, -4.76536993e-03f, 5.58449179e-02f, -6.62519708e-02f, -3.42113711e-03f, -1.33256922e-02f, 6.39068242e-03f, 1.46471873e-01f, 1.72640178e-02f,
  1.98495612e-02f, 2.90750060e-02f, 8.02150834e-03f, -2.82872841e-02f, -9.25512090e-02f, 1.45407906e-02f, 2.74772681e-02f, -2.17904989e-02f, -8.12977180e-03f, -3.91762182e-02f,
  4.22836393e-02f, 6.54794350e-02f, 1.36386439e-01f, -1.66777581e-01f, -2.21433472e-02f, -3.16714346e-02f, -8.88120458e-02f, 6.72501847e-02f, 3.87659632e-02f, -9.90821049e-02f,
  -1.59612205e-02f, 1.02616072e-01f, 1.64125615e-03f, 1.54715292e-02f, 9.61680058e-03f, -1.09288782e-01f, -3.67235132e-02f, -1.42231137e-01f, 8.30468163e-03f, -6.75550243e-03f,
  5.20995446e-02f, -1.02513447e-01f, -3.38394381e-03f, 7.75546655e-02f, -3.33363041e-02f, 7.96174258e-03f, -1.23798147e-01f, 6.76562414e-02f, -1.35353908e-01f, -2.87946109e-02f,
  1.22597396e-01f, 1.14250146e-01f, 9.07727927e-02f, 9.59766060e-02f, 5.60807288e-02f, -4.93470542e-02f, -1.98286511e-02f, -1.24137970e-02f, 1.91683806e-02f, -6.12884155e-03f,
  1.77885424e-02f, -8.21594298e-02f, -5.35458811e-02f, 8.73226020e-03f, 1.17038526e-01f, 2.40485091e-02f, -1.18931577e-01f, 4.92713638e-02f, 1.85050685e-02f, -4.78032604e-02f,
  -2.67905563e-01f, -8.38254318e-02f, -1.40508385e-02f, -3.98148358e-01f, -3.02675180e-02f, -2.55805850e-01f, -5.21552324e-01f, 1.26805007e-01f, -1.74298242e-01f, 1.61179807e-03f,
  -1.11583732e-01f, -7.67024830e-02f, -8.04773569e-02f, -3.89107645e-01f, -4.58923340e-01f, 2.28352174e-02f, -4.18473601e-01f, -8.28443095e-02f, 3.81103046e-02f, -1.09799035e-01f,
  -2.42891070e-02f, -3.34345102e-01f, -1.54383495e-01f, 1.55909121e-01f, -5.77695891e-02f, 1.10676654e-01f, 1.18339360e-01f, 1.16441764e-01f, 8.28489885e-02f, 8.12651441e-02f,
  1.82270855e-02f, 2.99856719e-02f, -1.67387053e-02f, 9.15592629e-03f, -9.41002443e-02f, 3.74269411e-02f, 1.47540513e-02f, 5.47425300e-02f, -1.48568535e-02f, 3.88619937e-02f,
  2.13504601e-02f, -1.47102252e-02f, -3.01345214e-02f, -7.81601593e-02f, 2.86361366e-03f, 7.55467117e-02f, -4.74379882e-02f, 5.35664931e-02f, -2.98886467e-02f, -1.71669975e-01f,
  1.55250756e-02f, 2.35233828e-02f, -2.89939474e-02f, 2.52710916e-02f, 2.48579644e-02f, -1.10847235e-01f, 8.26053554e-04f, -1.10211282e-03f, 2.43824683e-02f, 2.19565295e-02f,
  -3.09412554e-02f, -2.08749473e-02f, -3.24819982e-02f, -1.15155829e-02f, -7.13485479e-02f, 3.33509408e-02f, -6.44751638e-02f, 7.00042471e-02f, 5.54668345e-03f, -2.12882031e-02f,
  4.92768399e-02f, -5.92340715e-02f, 1.77409537e-02f, -2.14486849e-02f, -3.65761295e-02f, 4.74584699e-02f, -8.49650800e-03f, -1.63149089e-02f, 5.95932826e-03f, -5.00761345e-03f,
  -8.80055875e-03f, 1.53486403e-02f, 5.06523326e-02f, 9.20935720e-02f, -7.27007911e-02f, -3.62036824e-02f, 3.49383764e-02f, 4.97096702e-02f, 2.70831622e-02f, -1.38220899e-02f,
  -7.17255026e-02f, -2.23022625e-01f, 1.31054118e-03f, 7.96358138e-02f, -4.11107317e-02f, -5.21303304e-02f, -4.67169359e-02f, 6.43512085e-02f, 1.25395313e-01f, 3.13199824e-03f,
  -1.59944184e-02f, -1.38176540e-02f, 4.13163714e-02f, 8.31341445e-02f, -1.06209163e-02f, -1.31332651e-01f, 5.68819493e-02f, -3.65362279e-02f, -3.97874638e-02f, 5.53018376e-02f,
  -6.40221452e-03f, -4.95010391e-02f, 1.48228486e-03f, 2.75868215e-02f, 1.19138081e-02f, 5.40812798e-02f, -3.88923436e-02f, -2.86004115e-02f, 1.58015564e-02f, 1.82447885e-03f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.98382181e-01f, 6.47735238e-01f, 4.04059738e-01f, -6.90768898e-01f, 1.85608029e-01f, 7.98545107e-02f, -7.16693223e-01f, 1.40704751e-01f, -2.85459101e-01f, -9.87317115e-02f,
  -4.43053097e-01f, 3.76975298e-01f, -1.12010047e-01f, -2.55216300e-01f, -4.31050330e-01f, -2.98407823e-01f, -4.59727168e-01f, -3.17648143e-01f, 1.31388724e-01f, -1.29410326e-01f,
  -1.93392396e-01f, -5.11544824e-01f, 1.45035028e-01f, 2.71693319e-01f, 5.56956641e-02f, 1.27589360e-01f, -5.40924668e-01f, 2.76608288e-01f, 4.22064178e-02f, 9.24345329e-02f,
  1.22762233e-01f, -1.52160048e-01f, 2.22978979e-01f, 8.67119506e-02f, 1.84252847e-03f, 4.20660758e-03f, -8.19287673e-02f, 7.80739561e-02f, -5.64199453e-03f, 7.96424821e-02f,
  1.56772733e-02f, 1.91718966e-01f, -8.38216543e-02f, 7.44339675e-02f, 4.19782251e-02f, 1.26327246e-01f, 2.26689473e-01f, 7.03969225e-02f, 1.98575735e-01f, 2.77785957e-01f,
  1.49607643e-01f, 2.35577151e-01f, -1.22686110e-01f, -9.52038392e-02f, 6.80994093e-02f, -5.11357747e-02f, 1.97431929e-02f, 1.31943062e-01f, 9.41981599e-02f, -9.55500677e-02f,
  4.68905494e-02f, -4.18476313e-02f, -2.84666102e-02f, 2.74824258e-03f, -2.16140673e-02f, 2.01291498e-02f, 2.30079866e-03f, -3.60205323e-02f, 2.30282303e-02f, -1.95188299e-01f,
  -1.18042268e-01f, -4.29309830e-02f, -1.76140338e-01f, -2.78271828e-02f, -1.28309190e-01f, -1.56635076e-01f, -2.29017828e-02f, 5.24504073e-02f, -2.85950508e-02f, 7.47722238e-02f,
  -1.12042353e-01f, -1.19211040e-01f, 3.54113244e-02f, -7.15105906e-02f, -3.68102416e-02f, 3.30048651e-02f, -1.91264469e-02f, 1.08302116e-01f, 2.82957666e-02f, -1.47031918e-01f,
  -4.77285475e-01f, -5.78710258e-01f, -1.34833500e-01f, 1.01475284e-01f, 1.64945424e-03f, -5.42897687e-05f, 1.07250452e-01f, 1.65771246e-02f, -1.41005442e-01f, -2.89590787e-02f,
  -5.29143773e-02f, -8.69338438e-02f, -4.47692312e-02f, -2.35153772e-02f, -6.64531365e-02f, -2.04927791e-02f, -2.76909202e-01f, -8.79669338e-02f, -1.13458253e-01f, 3.19649018e-02f,
  -3.55767906e-02f, -6.89323023e-02f, -4.64455187e-02f, 2.09653983e-03f, 1.25844842e-02f, -9.21383724e-02f, -1.01801418e-01f, 1.46900192e-01f, 1.45961146e-03f, 1.22748306e-02f,
  -1.15054280e-01f, 1.00630075e-01f, 6.85947835e-02f, 2.30154157e-01f, 1.40879065e-01f, -1.44941568e-01f, -4.49136764e-01f, 2.38051996e-01f, -6.09038234e-01f, 3.93397808e-02f,
  7.63130412e-02f, -1.25419021e-01f, -2.39074200e-01f, -1.13281019e-01f, -4.50590104e-01f, -8.14505041e-01f, 1.60625994e-01f, 5.42963669e-03f, -3.44733089e-01f, 4.87204343e-01f,
  -2.19646096e-02f, 2.29123875e-01f, 2.26150945e-01f, 4.30977523e-01f, 1.68883294e-01f, 6.40754580e-01f, 4.98309761e-01f, 5.61308414e-02f, 6.41538620e-01f, 1.81463975e-02f,
  -2.91144043e-01f, -2.91277349e-01f, -3.92039530e-02f, -1.21207684e-01f, 2.48204827e-01f, 1.64285436e-01f, 7.29370341e-02f, -1.88268572e-01f, -7.58251771e-02f, -7.75550082e-02f,
  -7.27769136e-02f, -7.93753937e-03f, 5.08394502e-02f, -1.54012963e-01f, 1.73424575e-02f, 3.85889634e-02f, 6.96861558e-03f, 6.29857136e-03f, -1.12229072e-01f, 3.53502035e-02f,
  7.62604848e-02f, 1.55733362e-01f, 2.02253029e-01f, 7.23604709e-02f, 6.78582191e-02f, 4.29800935e-02f, 6.49942383e-02f, 1.28489122e-01f, 4.41803187e-02f, -2.82603828e-03f,
  1.00661777e-01f, 8.00065473e-02f, 2.41902303e-02f, -4.36413400e-02f, -8.71795118e-02f, -7.72638619e-03f, -1.82187617e-01f, 5.12850583e-02f, 4.58633378e-02f, -7.41536468e-02f,
  1.45568848e-01f, 5.02260439e-02f, -1.70797810e-01f, 8.35607499e-02f, 3.46116349e-02f, 4.32679355e-02f, -8.26337785e-02f, 2.82239914e-02f, -9.91609786e-03f, 4.79583479e-02f,
  -1.35275543e-01f, 4.32245508e-02f, 5.83020644e-03f, 3.88450101e-02f, -3.28918248e-02f, 1.27843618e-01f, -3.26342620e-02f, -5.84380366e-02f, 5.17335534e-02f, 5.02221324e-02f,
  9.39842388e-02f, 4.46643710e-01f, 1.68541484e-02f, -6.35247678e-02f, -1.03606664e-01f, -5.67505695e-02f, -2.26781756e-01f, 6.31055757e-02f, 7.13540688e-02f, -2.72391923e-02f,
  1.49994940e-01f, 2.12106794e-01f, 8.44283924e-02f, 4.22086976e-02f, -3.05080116e-02f, 4.93390039e-02f, 8.30316469e-02f, 4.31218371e-02f, 2.35986799e-01f, 2.89136946e-01f,
  1.96499005e-01f, -8.58880952e-02f, 3.23545448e-02f, -8.53672624e-03f, 2.00538352e-01f, 1.63355023e-01f, 1.62839115e-01f, 1.55896097e-01f, 9.84029472e-02f, -9.10972524e-03f,
  -6.10238612e-01f, 7.67522931e-01f, 1.04446016e-01f, 4.42962945e-01f, 1.00167938e-01f, -9.53600645e-01f, -2.63533175e-01f, 3.64630967e-01f, 3.44721615e-01f, 2.63845891e-01f,
  2.33963951e-01f, 1.86764687e-01f, 5.66865087e-01f, 2.56738603e-01f, -5.38586915e-01f, 3.52737568e-02f, -3.00616860e-01f, -2.54272521e-01f, 1.61688477e-01f, 2.87679583e-01f,
  -2.01914027e-01f, 5.30454814e-01f, 8.26511383e-02f, 5.01756907e-01f, -1.96958512e-01f, 1.98404878e-01f, 7.64183421e-03f, 3.63822043e-01f, -1.06737427e-01f, -4.21570428e-03f,
  -6.63335323e-01f, 3.73860329e-01f, -4.64900024e-02f, -1.38757169e-01f, -3.90584081e-01f, -3.10936332e-01f, -1.72646180e-01f, -5.78927845e-02f, 6.03681728e-02f, 2.88086459e-02f,
  -2.28278562e-01f, 3.56257968e-02f, -3.47209126e-02f, 1.82727292e-01f, 7.31632113e-02f, 9.61956754e-02f, -8.79669376e-03f, -2.41245091e-01f, 9.41904187e-02f, -1.30421355e-01f,
  8.08568299e-02f, -1.04081012e-01f, 8.93494710e-02f, -6.69112727e-02f, 3.51400040e-02f, 5.02252392e-02f, -1.39527872e-01f, 1.68581940e-02f, -2.59470731e-01f, -6.83210418e-02f,
  4.42282781e-02f, 5.57951406e-02f, 5.73783331e-02f, 1.54793128e-01f, 1.03889108e-02f, 3.01620699e-02f, 3.59806567e-02f, -5.03278300e-02f, 2.62707993e-02f, -1.10762835e-01f,
  2.22938657e-02f, 8.70801210e-02f, 1.87794819e-01f, -5.04952297e-02f, 9.00232792e-03f, -2.41109896e-02f, 3.62511948e-02f, 1.56795233e-01f, -1.75009206e-01f, -4.73757610e-02f,
  2.38094300e-01f, -6.69606850e-02f, 1.48323983e-01f, -1.00487284e-01f, 1.23799756e-01f, 1.69608504e-01f, -2.10012551e-02f, -1.23024754e-01f, 1.03149489e-01f, -4.23861705e-02f,
  -3.12739044e-01f, 3.80351096e-01f, 8.81988779e-02f, -4.91210595e-02f, 7.37985736e-03f, -1.58804283e-01f, -7.42711797e-02f, -7.50633702e-02f, 1.68343354e-02f, -1.52788579e-01f,
  -1.16616197e-01f, -9.25549865e-03f, -3.03308427e-01f, 6.59249350e-02f, -6.99841231e-02f, -1.41864121e-01f, 8.71234164e-02f, 4.68686111e-02f, 1.42270112e-02f, 1.03183530e-01f,
  7.32902884e-02f, 3.56678590e-02f, -1.73656866e-01f, -1.37500629e-01f, -2.40672827e-02f, -1.35634750e-01f, -3.94519754e-02f, 3.92450392e-02f, 3.90956551e-03f, 5.02916686e-02f,
  6.62980974e-01f, -1.49957493e-01f, -1.48330137e-01f, 3.25777382e-01f, 2.52724200e-01f, -1.39115155e-01f, -8.81906033e-01f, 3.29886287e-01f, -2.93862760e-01f, -5.43074608e-01f,
  1.77673429e-01f, 1.49894625e-01f, -6.29483283e-01f, 6.84844553e-01f, 9.89607692e-01f, -3.13882381e-02f, 5.68320155e-01f, 2.60705680e-01f, 5.99215664e-02f, 1.82328880e-01f,
  4.80549783e-01f, 7.23414123e-01f, 2.70044565e-01f, 5.23069143e-01f, 3.70629460e-01f, 1.28901720e-01f, 3.56385320e-01f, -2.34292209e-01f, 6.01247013e-01f, 3.88170838e-01f,
  -9.43706930e-02f, 1.20999061e-01f, -1.01034760e-01f, -1.41758732e-02f, -3.03523596e-02f, -1.77437589e-02f, -1.75154239e-01f, 9.31791142e-02f, 1.50318947e-02f, -1.39560044e-01f,
  -5.17554060e-02f, 1.93973273e-01f, 9.86577943e-02f, 2.74652001e-02f, 3.92158590e-02f, 7.62718022e-02f, -6.59582317e-02f, -8.21478739e-02f, -2.06092864e-01f, 5.70210665e-02f,
  -9.76684317e-02f, 9.73192975e-03f, 8.21963921e-02f, -5.48207611e-02f, 3.97507884e-02f, -2.25593224e-02f, -9.95854959e-02f, -5.59746213e-02f, 1.32740347e-03f, 7.70743564e-02f,
  1.30927026e-01f, -4.80158366e-02f, 5.49832731e-02f, -2.29711402e-02f, 3.10610794e-02f, -1.60060991e-02f, 1.83804303e-01f, -5.81531301e-02f, 5.73573932e-02f, -4.72036973e-02f,
  4.48738411e-02f, -4.31416847e-04f, -2.51001921e-02f, -7.26314336e-02f, 5.12547269e-02f, -9.66754332e-02f, 4.95793484e-02f, 1.61588266e-02f, -1.13436095e-01f, -3.90229821e-02f,
  -7.17975050e-02f, -1.40165305e-02f, 1.05821313e-02f, -3.95775177e-02f, 1.76312234e-02f, -6.40458465e-02f, 1.46805346e-01f, 5.14870249e-02f, -2.04050660e-01f, -6.65142834e-02f,
  1.63529795e-02f, 2.71209806e-01f, -1.67976037e-01f, 7.72165507e-03f, -1.80257112e-01f, 1.59945443e-01f, -7.00765923e-02f, 3.34010899e-01f, 1.15331694e-01f, 1.27617478e-01f,
  2.88845669e-03f, -4.12535556e-02f, 3.55442539e-02f, 1.96669959e-02f, -2.53654327e-02f, 5.91050871e-02f, 9.39371139e-02f, -1.35227397e-01f, -1.53390842e-03f, 2.28479356e-02f,
  -1.83747988e-02f, -1.51162535e-01f, -3.46245915e-02f, -2.44766381e-02f, -1.08998157e-01f, 3.73866106e-03f, -6.98024109e-02f, -5.58225140e-02f, 4.14783843e-02f, -4.74790717e-03f,
  1.49105266e-01f, -4.89650339e-01f, 2.20460922e-01f, -1.82816729e-01f, -1.24794930e-01f, 2.72668689e-01f, 7.22823679e-01f, -5.53864300e-01f, -6.53532922e-01f, -2.52899915e-01f,
  -4.38024774e-02f, 4.49927270e-01f, 4.20050442e-01f, 4.40879799e-02f, 7.81446815e-01f, 1.89976364e-01f, 1.49627430e-02f, 2.68581718e-01f, -2.08238572e-01f, -8.85728151e-02f,
  -2.19320104e-01f, 1.23053439e-01f, 3.21906269e-01f, -4.84011114e-01f, -2.78739501e-02f, -4.94997710e-01f, -1.45442575e-01f, 2.56439298e-01f, -1.21100895e-01f, 4.07859921e-01f,
  1.42842144e-01f, -2.87506849e-01f, 5.62761277e-02f, 8.04742426e-02f, 1.70707516e-02f, -7.69531876e-02f, 1.66151300e-01f, 4.63828087e-01f, 9.48845819e-02f, -7.47429579e-02f,
  2.84420382e-02f, -1.91713944e-02f, -1.69517040e-01f, 4.81990092e-02f, -1.96899474e-01f, -2.51684308e-01f, -2.73912437e-02f, -1.60526857e-01f, -5.76296300e-02f, 1.71623662e-01f,
  1.26937211e-01f, -1.40967473e-01f, -1.38789847e-01f, 3.61843891e-02f, 2.97101997e-02f, -7.14605972e-02f, 2.10878160e-02f, 1.88030109e-01f, -3.04366387e-02f, -5.31431846e-02f,
  -3.12846452e-02f, -2.17755176e-02f, -3.61504070e-02f, -8.22614953e-02f, 3.57487798e-03f, -1.15394227e-01f, -7.77464733e-02f, 2.31992722e-01f, -2.47912239e-02f, 6.41405806e-02f,
  -6.86359182e-02f, -9.24381912e-02f, -9.82868075e-02f, 1.10191874e-01f, -6.98411316e-02f, -2.66983062e-02f, 2.75455624e-01f, 2.84109842e-02f, -4.89056148e-02f, -5.86746521e-02f,
  1.29386280e-02f, -1.63779650e-02f, 2.02935249e-01f, 4.59770262e-02f, -7.90930763e-02f, 1.79812387e-01f, -6.58499300e-02f, -8.08486417e-02f, -5.56367524e-02f, 2.10012972e-01f,
  -1.29155278e-01f, -3.30852032e-01f, 6.09829510e-03f, -5.58476448e-02f, 6.86916485e-02f, -8.82657841e-02f, -8.19854960e-02f, -2.11449474e-01f, -5.50885461e-02f, -4.49870620e-03f,
  -1.29026353e-01f, -3.29740085e-02f, -1.59008265e-01f, 2.63922717e-02f, -1.38120865e-02f, -1.72586560e-01f, 5.68027832e-02f, -3.53354551e-02f, 4.54818457e-02f, 4.36004996e-02f,
  3.90506238e-02f, 7.11610690e-02f, 7.30615705e-02f, -1.25355065e-01f, -5.25568537e-02f, 2.66375393e-02f, -5.61440848e-02f, 8.09685811e-02f, 1.14272870e-01f, -8.51010159e-03f,
  5.05728066e-01f, -6.28423572e-01f, 5.03122926e-01f, 1.78567678e-01f, 6.94125116e-01f, 3.99270594e-01f, 2.97416598e-01f, 3.36839586e-01f, -1.78544875e-02f, -6.70144081e-01f,
  -1.41032875e-01f, -1.41328741e-02f, -3.95774782e-01f, -7.99570326e-03f, 4.45131361e-01f, -1.79128647e-01f, 1.74086794e-01f, -1.31795794e-01f, 1.46891803e-01f, 7.89631903e-02f,
  2.11726978e-01f, 6.49421811e-02f, 2.93128371e-01f, -1.24328502e-01f, 6.71888441e-02f, 4.09598462e-02f, -1.58750787e-01f, 1.93477675e-01f, 6.15179613e-02f, 2.78381050e-01f,
  -3.30833435e-01f, -9.99827981e-02f, -8.97161663e-02f, -1.94216445e-01f, -8.09112415e-02f, -7.16851056e-02f, 4.61318493e-02f, 1.44448325e-01f, 1.59915611e-01f, -6.64851293e-02f,
  -1.75741926e-01f, 4.59362157e-02f, 1.74230471e-01f, 9.70950276e-02f, 1.56144530e-01f, 8.89473259e-02f, 1.27681553e-01f, -1.87621742e-01f, 8.18468109e-02f, 1.11269183e-01f,
  -2.45182272e-02f, 4.81482036e-03f, 4.83879447e-02f, 3.20093073e-02f, 8.06699097e-02f, 2.05999333e-02f, 1.10435635e-01f, 2.26413026e-01f, -5.01681268e-02f, 6.93333074e-02f,
  1.82451576e-01f, 9.53422934e-02f, -8.93887654e-02f, -1.34881571e-01f, 5.35305366e-02f, 6.91339299e-02f, -3.46231572e-02f, 5.17729782e-02f, -2.52793785e-02f, -3.75711098e-02f,
  2.09649876e-01f, 2.09912602e-02f, 6.67329654e-02f, -1.46073297e-01f, -1.00670770e-01f, -8.17766264e-02f, -7.44280741e-02f, -3.13213058e-02f, -1.15999453e-01f, -7.75560811e-02f,
  -7.04964325e-02f, 8.97982041e-04f, -1.76076218e-01f, 6.11782335e-02f, -4.59600389e-02f, -1.15701733e-02f, -9.61737856e-02f, -6.05020076e-02f, -2.60722209e-02f, 8.08872879e-02f,
  -1.31561565e+00f, -8.25206220e-01f, -1.19943693e-01f, -8.18243250e-02f, -2.05217987e-01f, -1.66241884e-01f, -5.35681881e-02f, -5.55310585e-02f, -1.73854306e-01f, 1.00961834e-01f,
  -1.01123482e-01f, 8.13962892e-02f, -1.66714117e-01f, 1.74593702e-01f, -1.28720760e-01f, -1.60404757e-01f, -1.02725953e-01f, -1.57005042e-01f, -2.04753786e-01f, -1.17656276e-01f,
  -6.62734360e-02f, -1.10045396e-01f, 1.86268523e-01f, 8.83423537e-02f, 2.53929198e-02f, 6.54876009e-02f, -1.03379972e-01f, 3.09781060e-02f, 2.77039185e-02f, -1.22907013e-02f,
  7.49964297e-01f, 1.71796247e-01f, 5.18211305e-01f, 8.61538708e-01f, 1.00639053e-01f, -3.41255337e-01f, -7.92194307e-02f, -3.49155106e-02f, 5.46950519e-01f, -2.46772572e-01f,
  -2.58653492e-01f, 5.39921343e-01f, -3.87162268e-01f, 3.87760907e-01f, -4.49272603e-01f, -3.62257183e-01f, 3.15914869e-01f, 2.53344953e-01f, 3.76569107e-02f, 1.37834474e-01f,
  1.15196288e-01f, -3.20595711e-01f, 9.55317244e-02f, -2.45400727e-01f, 5.96654654e-01f, 2.72524446e-01f, -3.95182282e-01f, -1.39559865e-01f, 2.87340671e-01f, -9.21763256e-02f,
  1.31330341e-01f, 1.65117919e-01f, 1.38291031e-01f, -2.23005880e-02f, -1.08256575e-03f, 7.90524408e-02f, 5.69845587e-02f, -7.03194588e-02f, 1.55298978e-01f, -7.37898648e-02f,
  -8.18701684e-02f, 4.50658649e-02f, -1.88951232e-02f, -3.90195586e-02f, 1.80534884e-01f, 1.59194380e-01f, 1.81677967e-01f, 2.86246270e-01f, 1.08869158e-01f, 2.21338063e-01f,
  3.20733339e-01f, 2.03697041e-01f, 3.60474847e-02f, -2.62492504e-02f, 1.41427323e-01f, 7.99023807e-02f, -2.74577383e-02f, 6.08978905e-02f, 1.22097641e-01f, 1.56535253e-01f,
  -1.02962911e-01f, -6.71762750e-02f, 1.33708566e-02f, 1.01312973e-01f, 2.93668360e-02f, -1.82097238e-02f, 1.15727633e-02f, -5.19872382e-02f, 1.73880458e-01f, -9.04997513e-02f,
  -7.84700885e-02f, -2.09765658e-02f, -3.32165211e-02f, 2.12977424e-01f, -5.38149439e-02f, 8.63385126e-02f, 4.83884662e-02f, 1.47302940e-01f, 1.47830859e-01f, 6.50159568e-02f,
  -1.88754052e-02f, 5.99806979e-02f, 3.02410871e-03f, 9.24943611e-02f, -4.17821854e-02f, 3.05943564e-02f, 1.44451097e-01f, 1.27900228e-01f, 7.93917552e-02f, -2.45131016e-01f,
  -4.23579603e-01f, -3.68766218e-01f, -7.34032914e-02f, 2.83293016e-02f, 7.84238707e-03f, 9.50925648e-02f, -1.70824945e-01f, 1.79504946e-01f, -1.11944474e-01f, -1.19586982e-01f,
  6.31047562e-02f, 1.31593630e-01f, -7.65202418e-02f, 1.22816592e-01f, -1.28171340e-01f, -6.36433214e-02f, -4.82202992e-02f, -2.57595509e-01f, -1.76128983e-01f, -1.19482860e-01f,
  9.74336043e-02f, -2.66556859e-01f, -9.16161612e-02f, -3.82510424e-02f, -1.67235695e-02f, 4.44058375e-03f, 5.30599691e-02f, 9.69430525e-03f, -2.72602844e-03f, -9.27505568e-02f,
  -1.45288932e+00f, 5.23664415e-01f, 3.08309436e-01f, -2.75942206e-01f, -4.13179129e-01f, 6.56815529e-01f, 5.10045886e-01f, 8.04417860e-03f, 1.37479424e-01f, 5.48012733e-01f,
  1.59359157e-01f, -2.98901230e-01f, 3.58385444e-01f, 5.10741949e-01f, 5.04230484e-02f, 5.83969116e-01f, 2.85051465e-01f, 2.52674669e-01f, 1.88074946e-01f, -2.02654451e-02f,
  -3.89844477e-02f, 2.50056416e-01f, 3.60750556e-01f, -6.26271144e-02f, 1.34853080e-01f, -1.74700901e-01f, -1.33200502e-02f, -6.96519092e-02f, -4.32577617e-02f, -5.18360250e-02f,
  -4.76548284e-01f, -4.56222713e-01f, -2.30800226e-01f, -1.03410609e-01f, -9.91525799e-02f, 3.73945385e-02f, -1.27436012e-01f, -1.45441011e-01f, -2.38014638e-01f, -5.95472194e-02f,
  -3.61448638e-02f, -3.49971605e-03f, -1.55291082e-02f, -1.43478632e-01f, -1.18851021e-01f, -5.18490933e-02f, 7.03176558e-02f, 6.44879937e-02f, 7.26251453e-02f, 1.92518726e-01f,
  1.83831334e-01f, 1.61679089e-01f, 2.16051415e-01f, 1.39378339e-01f, 5.83664253e-02f, 8.21916386e-02f, 1.84394076e-01f, 9.36751440e-02f, 9.93744284e-02f, 3.12628783e-02f,
  -1.01542715e-02f, 4.47321758e-02f, 1.30950272e-01f, -1.13136299e-01f, -3.25965211e-02f, 7.19236536e-03f, 7.63747748e-03f, -1.02862209e-01f, 1.09844886e-01f, -3.69746275e-02f,
  -1.09869182e-01f, -9.67362225e-02f, -1.97571367e-01f, 1.46677732e-01f, -1.93925779e-02f, -9.05836448e-02f, -7.45243654e-02f, -7.98829570e-02f, -5.13705388e-02f, -1.29395202e-01f,
  -9.81537551e-02f, -7.31433854e-02f, -9.19560120e-02f, 1.14983596e-01f, 2.79070227e-03f, 5.47194816e-02f, 1.13624193e-01f, 6.08947799e-02f, 1.57924667e-01f, -1.73263624e-01f,
  -4.48678702e-01f, -4.88432407e-01f, -7.01946840e-02f, -9.20238644e-02f, -6.11558296e-02f, -4.68700379e-02f, -3.29490751e-02f, 1.29598305e-01f, 1.51978314e-01f, -9.36332643e-02f,
  -5.89089729e-02f, 2.93018427e-02f, -1.17029123e-01f, 2.74551455e-02f, 1.54642425e-02f, 3.38827342e-01f, -8.37099403e-02f, -1.49029985e-01f, -1.36686265e-01f, -7.31588677e-02f,
  -1.10553801e-01f, -1.43823609e-01f, 9.06191841e-02f, -9.39576402e-02f, -1.00971527e-01f, 1.06156035e-03f, -3.17436546e-01f, -5.58974259e-02f, -7.24118128e-02f, 1.94086730e-01f,
  2.61066496e-01f, 2.88353831e-01f, 1.93547457e-02f, 2.94026956e-02f, -3.36286962e-01f, -1.85184941e-01f, -4.47105646e-01f, -1.17756747e-01f, 3.97754788e-01f, -1.66788176e-01f,
  -5.60366333e-01f, 3.43981445e-01f, -6.39464334e-02f, -4.56059724e-01f, 6.78713202e-01f, 5.92127323e-01f, -1.55230314e-01f, -1.57876670e-01f, 5.80930933e-02f, -3.38453442e-01f,
  1.50135487e-01f, -5.56085885e-01f, -1.69255555e-01f, -5.80473483e-01f, -8.02864313e-01f, -2.46009052e-01f, -2.20919818e-01f, -2.97579855e-01f, -5.09968758e-01f, -8.20976403e-03f,
  -2.50234693e-01f, 7.75794685e-02f, -1.77438796e-01f, 2.30049691e-03f, -1.02622204e-01f, -1.06407233e-01f, -1.11135334e-01f, -1.11302190e-01f, 3.06072347e-02f, 1.95228830e-02f,
  6.65499493e-02f, 1.07092373e-01f, -6.74038008e-03f, 2.60125324e-02f, -9.78281274e-02f, -1.28302380e-01f, -4.59997132e-02f, -1.86516285e-01f, -1.62275787e-02f, -2.12723494e-01f,
  -4.51430604e-02f, 7.63913337e-03f, -1.11393571e-01f, 4.36233282e-02f, 1.27130011e-02f, -7.06974277e-03f, 2.05017954e-01f, 6.94200248e-02f, 1.91663038e-02f, 1.42309174e-01f,
  -8.01933091e-03f, 7.78676802e-03f, 3.89918089e-02f, -1.68201998e-01f, -9.74352136e-02f, -7.80637190e-02f, 4.77510542e-02f, -9.90932807e-02f, 1.18355788e-01f, -1.39795497e-01f,
  2.89869700e-02f, -1.05614834e-01f, -9.88953039e-02f, -7.86674619e-02f, -1.04865126e-01f, 8.56627524e-02f, -2.78707836e-02f, -1.18697388e-02f, -5.18345973e-04f, 1.19348422e-01f,
  6.41969815e-02f, 1.45758986e-01f, 8.42052791e-03f, -6.50816113e-02f, 4.86962795e-02f, -4.99620959e-02f, -5.95250428e-02f, -1.23891249e-01f, -5.68325706e-02f, -6.75810501e-03f,
  -4.30161618e-02f, 1.87274039e-01f, 7.32690394e-02f, -5.58344554e-03f, 8.18603337e-02f, 2.70932652e-02f, -5.56399636e-02f, 1.43454717e-02f, 2.12724477e-01f, -8.05095807e-02f,
  -5.97553067e-02f, -8.14107358e-02f, 8.16527084e-02f, -6.66860417e-02f, 8.01456347e-02f, 1.17830053e-01f, 7.48901665e-02f, 5.50737083e-02f, 1.48393661e-01f, -5.59490174e-02f,
  -2.40292057e-01f, 3.79504748e-02f, 7.60953277e-02f, -2.33326584e-01f, -1.50576577e-01f, -9.38865319e-02f, 7.92120621e-02f, 1.50180817e-01f, -6.15278073e-02f, 1.34781525e-01f,
  2.87695885e-01f, 5.68387330e-01f, 1.20893262e-01f, 3.45328957e-01f, -2.99846023e-01f, -1.61687374e-01f, -4.71073948e-02f, 4.07795049e-02f, 5.15811563e-01f, 3.13003398e-02f,
  -5.25011659e-01f, 6.25857770e-01f, -1.75587162e-01f, -1.73164845e-01f, -3.09357867e-02f, 2.19507869e-02f, 1.81608081e-01f, 3.67627084e-01f, 2.40998194e-01f, 1.72591612e-01f,
  2.08445668e-01f, -4.43353057e-01f, -1.69566646e-01f, -3.10767144e-01f, -3.63201737e-01f, 6.86731488e-02f, -3.22969824e-01f, -8.00726041e-02f, -1.92347214e-01f, 8.82382467e-02f,
  -2.57602423e-01f, 7.87899196e-02f, 2.62572393e-02f, 1.17455788e-01f, -5.09555340e-02f, -1.35109022e-01f, 2.89561450e-02f, -4.67977636e-02f, -4.30342071e-02f, 1.52871087e-01f,
  1.79407567e-01f, 3.24620493e-02f, 5.40961996e-02f, -4.97696176e-03f, 1.35513991e-02f, -1.15581397e-02f, -3.50299403e-02f, -8.42225328e-02f, -3.97197306e-02f, -1.17566185e-02f,
  -1.42790526e-01f, 2.46979538e-02f, -7.22149611e-02f, 1.18520118e-01f, -2.22801184e-03f, 4.11314666e-02f, 3.96250524e-02f, -6.86638197e-03f, 3.73857431e-02f, 1.04473263e-01f,
  1.06166206e-01f, 1.52887762e-01f, -1.02217207e-02f, -1.53607145e-01f, -1.26294911e-01f, 9.74489748e-02f, 6.84493110e-02f, -8.34834054e-02f, 1.13719821e-01f, 8.30988213e-02f,
  1.45405278e-01f, 2.95178927e-02f, -2.11348962e-02f, 3.10514625e-02f, -2.08528042e-02f, 3.00868857e-03f, 2.29500085e-02f, 1.69812050e-02f, 7.69459456e-02f, -3.09467968e-02f,
  -3.92661691e-02f, -3.88004072e-02f, -2.95195542e-02f, -7.10384250e-02f, -1.15891874e-01f, -5.01671024e-02f, 4.72120196e-02f, 1.56797227e-02f, -3.89634296e-02f, -1.12212151e-01f,
  8.49800184e-02f, 3.55041653e-01f, 2.01059833e-01f, 9.50408354e-02f, 6.61091134e-02f, -9.58412066e-02f, 1.52176961e-01f, 1.39276013e-01f, 1.47971883e-01f, 4.65564579e-02f,
  -4.50705141e-02f, -3.95002626e-02f, -1.58108659e-02f, -1.50122270e-01f, 1.01032602e-02f, -1.98609993e-01f, 1.04739189e-01f, 1.69683352e-01f, 7.15033114e-02f, 5.66562042e-02f,
  3.21757756e-02f, 9.46555957e-02f, 2.65956879e-01f, -4.96393964e-02f, 3.94158624e-02f, 3.22981328e-02f, -1.82920974e-02f, 1.30463734e-01f, -9.61723551e-02f, 6.48469478e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  8.18737030e-01f, 8.42619121e-01f, 8.21875930e-01f, 7.21931696e-01f, 1.72682077e-01f, 9.76933002e-01f, 4.65637594e-01f, 5.31864882e-01f, 6.24569833e-01f, 4.34278965e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.39276811e-01f, -9.46136564e-02f, 1.32340759e-01f, -6.70548081e-01f, 8.80265832e-01f, -1.06890179e-01f, -5.18312454e-02f, -4.74818014e-02f, 2.46952027e-01f, -2.70036668e-01f,
  2.29667738e-01f, 6.00546505e-03f, -3.72623384e-01f, 5.16763106e-02f, -1.88563660e-01f, -2.46638149e-01f, -1.47879496e-01f, 3.93197477e-01f, 6.62452340e-01f, -3.01408023e-01f,
  6.69551075e-01f, 2.69254334e-02f, -4.65557985e-02f, 2.14355037e-01f, -3.46310943e-01f, -2.67338544e-01f, 3.74224395e-01f, 1.21240772e-01f, 1.61593899e-01f, 1.85206950e-01f,
  1.29127353e-01f, -1.97166249e-01f, 5.33104479e-01f, 2.92420030e-01f, -3.81896585e-01f, -3.93509381e-02f, 1.70317352e-01f, 3.12585384e-01f, -2.89642870e-01f, 3.28562647e-01f,
  -1.72118500e-01f, 3.16443652e-01f, 3.96196961e-01f, -1.76103339e-02f, -3.77699226e-01f, -1.84490144e-01f, -2.63923287e-01f, -2.74784595e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.57776374e-01f, 7.49291122e-01f, 8.84091258e-01f, -3.16791564e-01f, 5.23710847e-01f, -8.27118874e-01f, -1.37290135e-01f, -2.41182581e-01f, -6.17075145e-01f, 2.78165460e-01f,
  1.04291511e+00f, 7.59063065e-01f, 1.31840736e-01f, 1.03655577e+00f, 1.19357564e-01f, -1.56092107e-01f, 1.06543911e+00f, 9.90445375e-01f, -4.57600266e-01f, -6.62569582e-01f,
  2.57274508e-01f, 9.83703017e-01f, 1.31685424e+00f, 6.68117583e-01f, 3.70710999e-01f, 8.41449380e-01f, -1.59501895e-01f, -4.95017320e-01f, -6.02445938e-02f, 5.91494381e-01f,
  9.91263390e-01f, 5.12834191e-01f, 7.83464611e-01f, 2.56419033e-01f, -4.70451474e-01f, -1.58371365e+00f, 3.45749617e-01f, -8.19866240e-01f, -5.77127457e-01f, 9.33203936e-01f,
  8.52116764e-01f, 4.48399305e-01f, 1.44244239e-01f, -8.95046353e-01f, -3.79973829e-01f, 3.64480108e-01f, 2.16020625e-02f, 4.83449012e-01f, 7.31117845e-01f, 3.36081117e-01f,
  -2.96246946e-01f, 4.03382927e-01f, 4.43315923e-01f, -1.91720307e-01f, -3.14593315e-01f, 9.05715942e-01f, -8.17409009e-02f, 1.14001620e+00f, 7.06104040e-01f, 5.71890175e-01f,
  -2.43613288e-01f, -2.95815855e-01f, -3.94012183e-01f, -5.81154227e-01f, -6.78394288e-02f, 8.31848681e-02f, 2.94612557e-01f, -4.04615074e-01f, -5.22972107e-01f, -1.45006168e+00f,
  -6.43277228e-01f, -7.48225823e-02f, -7.17096850e-02f, -2.49454632e-01f, -5.86772740e-01f, 3.78162295e-01f, 7.20814526e-01f, 9.01307344e-01f, 2.17887208e-01f, 5.21588504e-01f,
  3.44365358e-01f, -9.28684473e-02f, 9.28574443e-01f, 3.47284317e-01f, 3.78382891e-01f, 1.40667510e+00f, 1.36829412e+00f, 9.10623431e-01f, 9.43644226e-01f, -2.80353166e-02f,
  -4.70232457e-01f, 7.84660816e-01f, 8.88854980e-01f, 1.78371787e-01f, -2.74005711e-01f, -6.93407431e-02f, -7.88370550e-01f, -2.60658383e-01f, -6.94028914e-01f, 1.37931323e+00f,
  3.91730964e-01f, -8.15166116e-01f, -2.12571338e-01f, 2.54107684e-01f, 2.17352789e-02f, 1.29689991e+00f, 1.31586403e-01f, 7.46369898e-01f, 1.84731066e-01f, -4.71642733e-01f,
  5.89035809e-01f, 1.31681308e-01f, -5.85402660e-02f, 9.86252666e-01f, 1.66140184e-01f, -9.92464304e-01f, 1.93794683e-01f, -8.60495210e-01f, 4.11432087e-01f, -6.03804171e-01f,
  8.76124918e-01f, 3.22709650e-01f, 1.04929399e+00f, -5.16934507e-02f, -7.85256982e-01f, 1.19166410e+00f, -1.21030174e-01f, -2.86370218e-01f, -1.94135472e-01f, 2.90845543e-01f,
  1.15917349e+00f, 1.26487839e+00f, -8.93844604e-01f, -2.16237083e-01f, 3.81967962e-01f, -7.42506564e-01f, -2.83243537e-01f, -2.97567129e-01f, 5.96457541e-01f, 8.00725102e-01f,
  7.07924068e-02f, 6.28607929e-01f, 1.02988088e+00f, 3.38695012e-02f, 4.62603182e-01f, -1.77855268e-01f, 5.10604540e-03f, -5.60934544e-01f, -1.51644266e+00f, -9.60954785e-01f,
  2.26469442e-01f, 1.31587222e-01f, 8.55453670e-01f, 2.35949010e-01f, 3.86492878e-01f, 6.06639683e-01f, 1.12243056e+00f, -4.61938530e-01f, 6.21520221e-01f, 1.14985216e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  5.46757460e-01f, 2.60160238e-01f, 8.17681551e-01f, 1.30060732e-01f, 8.27748060e-01f, 4.34431493e-01f, 2.34573469e-01f, 8.23336482e-01f, 6.19335413e-01f, -2.01391459e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -6.81562901e-01f, -4.49746072e-01f, 3.30305368e-01f, 1.05043650e+00f, 2.57228225e-01f, -2.77062953e-01f, 4.16059226e-01f, -4.11673486e-01f, 5.70411325e-01f, -1.04717410e+00f,
  6.27911031e-01f, -5.25258482e-01f, -1.34136772e+00f, 6.94617033e-01f, -7.60775656e-02f, -1.58329725e+00f, 4.79171515e-01f, 4.00496811e-01f, -3.99264455e-01f, 6.72269836e-02f,
  8.27015340e-02f, 9.95629430e-01f, 1.65192619e-01f, 3.16064537e-01f, 2.57696062e-01f, 5.47989786e-01f, -1.06530637e-01f, -1.33339632e+00f, -7.09550306e-02f, 5.21852672e-01f,
  -8.70741427e-01f, -8.55372846e-01f, 8.44311416e-02f, -1.48523599e-01f, -2.04824239e-01f, -1.44041345e-01f, -4.48300503e-03f, 1.42520204e-01f, 3.19072396e-01f, -6.68491244e-01f,
  -9.07058239e-01f, 7.64471412e-01f, -1.03945279e+00f, 1.29433572e-01f, 6.89783394e-01f, -1.13799870e+00f, -5.83016515e-01f, -5.13717592e-01f, -4.34806682e-02f, 6.41749427e-02f,
  3.25529844e-01f, 7.06068754e-01f, -1.17038727e+00f, -8.70523512e-01f, -1.04849577e+00f, 2.67632246e-01f, -7.88861215e-02f, -1.01106620e+00f, -1.37413526e+00f, 5.22145689e-01f,
  -1.33078182e+00f, 8.15743625e-01f, -1.26521218e+00f, 2.83736940e-02f, 4.02678162e-01f, 1.76592335e-01f, 1.85232118e-01f, -1.81021899e-01f, 4.52468365e-01f, -1.05002634e-01f,
  3.81190479e-01f, 3.55576605e-01f, -1.18321073e+00f, -3.76385421e-01f, -1.63221940e-01f, 6.23329580e-01f, -1.14298332e+00f, 1.20934941e-01f, 5.93274772e-01f, -1.12824237e+00f,
  -8.09363946e-02f, 3.98762912e-01f, 7.01163113e-02f, -6.05796814e-01f, -5.48617899e-01f, -7.36187220e-01f, 1.81309372e-01f, -3.51893939e-02f, 1.41018063e-01f, -9.00241435e-01f,
  7.26238012e-01f, -1.10725844e+00f, -9.30910707e-01f, -1.37893736e-01f, -1.18166590e-02f, 7.33821809e-01f, -5.86875439e-01f, 6.43654883e-01f, 5.86510934e-02f, -5.27520359e-01f,
  -2.12256331e-02f, -7.91036367e-01f, -2.21182600e-01f, -1.38842881e+00f, -1.14185512e+00f, -3.59252930e-01f, 8.32999408e-01f, 2.20996246e-01f, 6.07870579e-01f, -1.53609300e+00f,
  4.52840537e-01f, -4.44911094e-03f, -5.17762363e-01f, 2.25182772e-01f, -3.87999207e-01f, -4.42042530e-01f, -5.59565604e-01f, -2.51278013e-01f, -9.58188474e-01f, 7.83351541e-01f,
  -8.23318660e-01f, -8.87250066e-01f, -1.15324116e+00f, -7.21366048e-01f, 5.56696355e-01f, -6.27183616e-01f, 4.44991350e-01f, -1.45819291e-01f, -2.03724548e-01f, -4.97336060e-01f,
  -4.30253446e-01f, 1.77777261e-01f, -9.07895148e-01f, 2.90895365e-02f, -1.10016668e+00f, 9.09800082e-02f, 4.72881377e-01f, 3.46326083e-01f, -1.13655400e+00f, -2.33754069e-01f,
  -1.28391653e-01f, -6.75906479e-01f, -1.18579113e+00f, 6.09838307e-01f, 2.01198906e-01f, -8.82522583e-01f, 2.27966949e-01f, -2.47010648e-01f, 1.19458444e-01f, 4.64226425e-01f,
  5.43730497e-01f, -1.34651375e+00f, -9.85152304e-01f, 7.71513432e-02f, -3.18142325e-01f, -6.69421434e-01f, -3.20220232e-01f, 2.30147734e-01f, 6.89400256e-01f, 8.60814899e-02f,
  6.85508251e-01f, 4.29590791e-01f, 2.68364251e-01f, 8.27313662e-01f, 1.00155818e+00f, 9.40093935e-01f, -7.87565291e-01f, 5.49805701e-01f, 7.46731222e-01f, 2.13237375e-01f,
  -7.75408924e-01f, 5.50361514e-01f, -1.70168400e+00f, -1.64862156e+00f, -9.84649062e-01f, -8.80470753e-01f, -5.27634680e-01f, -2.40478963e-01f, -2.61020035e-01f, -3.58085364e-01f,
  5.33317387e-01f, -1.99609056e-01f, -1.74719021e-01f, 2.42000848e-01f, -1.01167285e+00f, -9.15276945e-01f, -5.99465296e-02f, 6.59907222e-01f, -1.23916101e+00f, -1.18402743e+00f,
  -7.65661895e-01f, 7.79529750e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.95867793e-03f, -1.09430894e-01f, -1.60637826e-01f, -9.35076848e-02f, -5.43118492e-02f, -2.10220337e-01f, 1.45871088e-01f, 2.05845937e-01f, -6.24265432e-01f, 3.11134700e-02f,
  3.65362138e-01f, -2.52082586e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    