/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.52194202e-01f, 7.82727823e-03f, 1.38932705e-01f, 4.54010248e-01f, 5.31261824e-02f, -6.75438941e-02f, -1.37178242e-01f, -5.48829697e-02f, 1.45977870e-01f, 1.46297673e-02f,
  -1.46524608e-01f, -6.71151504e-02f, -1.14965551e-01f, -1.42393246e-01f, -3.94453704e-02f, 5.73445205e-03f, 1.89171597e-01f, 7.33373091e-02f, -6.20958349e-03f, -1.60798952e-02f,
  -1.69238627e-01f, 3.81185770e-01f, 3.65062803e-01f, -7.50576612e-03f, 2.66182840e-01f, -9.91661847e-02f, -2.37541106e-02f, 1.52078718e-01f, -7.33406767e-02f, 4.65495735e-01f,
  1.78643260e-02f, 1.83794379e-01f, -8.60063434e-02f, 4.41374034e-02f, -6.90360460e-03f, -6.10946342e-02f, -1.17174983e-02f, 1.06249554e-02f, -3.70493568e-02f, 2.00816486e-02f,
  3.59998532e-02f, -3.26091200e-02f, 1.01929829e-01f, 6.74501935e-04f, 1.00479156e-01f, -9.21083055e-03f, 6.29156828e-02f, 9.46631655e-02f, 2.61194855e-02f, -1.30129486e-01f,
  -7.83767924e-02f, 4.10121307e-02f, 9.26030651e-02f, -1.25637621e-01f, -1.24948196e-01f, -5.10356724e-02f, -4.22982089e-02f, 1.53117413e-02f, -9.96814594e-02f, 1.19188659e-01f,
  1.59734339e-02f, -1.10390922e-02f, -4.06364426e-02f, -7.05044623e-03f, -7.18132453e-03f, 1.55050308e-02f, -5.24965161e-03f, 2.71810330e-02f, -6.01224937e-02f, 9.87301543e-02f,
  -7.90044516e-02f, 8.42615496e-04f, 3.47610307e-03f, 4.65803184e-02f, -1.44335153e-02f, 4.72349860e-02f, 2.12639738e-02f, 2.82165855e-02f, -4.12006304e-02f, 5.37438020e-02f,
  -3.75791831e-04f, -7.98573904e-03f, 4.12862338e-02f, -3.44716311e-02f, 5.65762259e-02f, -7.41212768e-03f, 2.00075191e-02f, -6.46857843e-02f, -3.81256491e-02f, 3.43731232e-02f,
  -8.11471269e-02f, -2.02884182e-01f, 2.86810882e-02f, -6.56326264e-02f, 3.89239453e-02f, -1.15721170e-02f, 1.45343198e-02f, -4.38122414e-02f, -5.34508936e-03f, 9.37758200e-03f,
  -1.27041377e-02f, -2.59969328e-02f, -1.38918310e-02f, -2.05160882e-02f, -3.74761820e-02f, -1.43962167e-03f, -2.15069149e-02f, 1.21634116e-03f, -4.51267138e-02f, 7.52999028e-03f,
  -1.25919068e-02f, -3.66744772e-02f, -2.45357100e-02f, -3.19841467e-02f, 3.75490123e-03f, -2.19894424e-02f, -4.80299592e-02f, 1.33520151e-02f, -6.40181229e-02f, -1.78503901e-01f,
  2.35689253e-01f, 2.01628760e-01f, -4.35997769e-02f, -2.25914657e-01f, -3.87023985e-01f, 8.57007653e-02f, 3.33396971e-01f, 1.25502422e-01f, -1.40426293e-01f, 1.38691932e-01f,
  -2.38324836e-01f, -2.64041036e-01f, -8.28093514e-02f, -4.74780239e-02f, 2.87960678e-01f, 3.58543515e-01f, 1.69257134e-01f, 1.03143863e-01f, 2.68233679e-02f, -1.33367546e-03f,
  -2.41363734e-01f, -8.03437009e-02f, 9.16761458e-02f, 4.94720191e-02f, -1.06994532e-01f, 4.35745008e-02f, 1.24313444e-01f, 8.59652180e-04f, 1.64126337e-01f, -1.20192818e-01f,
  4.37911451e-02f, 1.22148618e-01f, -7.88072720e-02f, -8.93219411e-02f, -1.64833426e-01f, 1.54024139e-01f, 1.02893047e-01f, 1.02468520e-01f, 6.10690564e-02f, -1.99968312e-02f,
  -1.34723708e-01f, 1.28451250e-02f, -7.98214674e-02f, -8.53932798e-02f, 1.11421403e-02f, -7.34272152e-02f, 1.27783343e-01f, 8.02180991e-02f, 2.17488613e-02f, 1.44004792e-01f,
  -2.16709375e-01f, -1.31624967e-01f, -1.72908083e-02f, -4.64225970e-02f, 9.55162123e-02f, -1.96739122e-01f, -2.46325526e-02f, 4.29368056e-02f, 9.16578770e-02f, 2.10711479e-01f,
  1.00071402e-03f, 1.39367930e-03f, -5.12226159e-03f, 8.29638727e-03f, -6.89683482e-03f, 1.08937714e-02f, -3.16961594e-02f, -5.24074119e-03f, -1.07570912e-03f, 7.34046251e-02f,
  -7.73025826e-02f, 2.03759503e-02f, -1.54429972e-02f, 1.88100226e-02f, -7.73917837e-03f, -2.16985643e-02f, -3.81979160e-02f, 2.85164658e-02f, -2.31943429e-02f, 4.03630249e-02f,
  2.58877389e-02f, -3.69128138e-02f, -6.73019188e-03f, -2.11781040e-02f, 1.34080173e-02f, -3.14674750e-02f, -4.57926840e-02f, -1.46589605e-02f, -5.14748655e-02f, 2.53171008e-02f,
  2.98754591e-02f, -1.41975150e-01f, 1.52221665e-01f, 7.98080713e-02f, 4.32368480e-02f, -5.81701621e-02f, -8.87484550e-02f, 3.64959165e-02f, -9.83061194e-02f, 5.78842871e-02f,
  -1.40604470e-02f, 6.30523823e-03f, 7.66420141e-02f, 2.90054604e-02f, 5.71676646e-04f, 1.56346075e-02f, 5.75467013e-04f, -1.05989100e-02f, 6.14037476e-02f, -6.69360012e-02f,
  7.33277947e-02f, 1.79341897e-01f, 1.71192095e-01f, 7.07808062e-02f, 3.63700353e-02f, 1.73536930e-02f, 2.08645985e-01f, 5.30026741e-02f, 1.91950932e-01f, 4.41761672e-01f,
  -2.77121603e-01f, -7.01991469e-02f, -1.12127468e-01f, -5.24072647e-02f, -7.04353005e-02f, -2.19571233e-01f, -1.67901322e-01f, -7.04030767e-02f, 2.24686563e-02f, -6.89631999e-02f,
  -2.64314562e-01f, -2.42194533e-02f, -1.33888066e-01f, 4.74471822e-02f, -4.97356895e-03f, 5.71189076e-02f, 1.46757454e-01f, -1.68057587e-02f, -4.89225090e-02f, 1.06039904e-01f,
  1.25306234e-01f, 1.30824968e-01f, 9.00112092e-02f, 4.23995331e-02f, 1.26631200e-01f, -1.05409451e-01f, 4.20283042e-02f, 1.06570810e-01f, 2.49519572e-02f, 3.02217633e-01f,
  -6.18768260e-02f, -1.08637707e-02f, 8.71164352e-02f, -7.88546819e-03f, -4.70291860e-02f, 4.27635722e-02f, -4.30866983e-03f, 9.40319821e-02f, -2.30772351e-03f, -1.70504451e-02f,
  -7.16659501e-02f, 7.54927099e-02f, -5.59193268e-02f, -2.18042731e-02f, -3.26074474e-02f, -5.40335514e-02f, 2.53672171e-02f, 4.23299447e-02f, -3.13425809e-02f, 5.18089347e-03f,
  -4.60566208e-03f, 5.44448048e-02f, -2.44501114e-01f, -2.83663515e-02f, 1.00969262e-02f, 7.85575956e-02f, -1.07409291e-01f, 5.34399189e-02f, 4.42153923e-02f, 6.32470325e-02f,
  5.70564345e-02f, 1.08087817e-02f, 2.47611031e-02f, -4.38267961e-02f, -3.42987068e-02f, 6.19611517e-03f, -2.67457943e-02f, -1.14786506e-01f, 6.21819422e-02f, -8.86483938e-02f,
  4.47679032e-03f, 5.76914707e-03f, -7.10109845e-02f, -4.88236658e-02f, -1.18172299e-02f, -2.29260661e-02f, -8.32151324e-02f, -4.25283723e-02f, 2.85287704e-02f, 3.68494466e-02f,
  4.19302732e-02f, 1.45071950e-02f, -5.84238116e-03f, -3.60784456e-02f, 1.42483816e-01f, 2.82576699e-02f, -1.67466998e-02f, 4.29871865e-02f, -1.00801654e-01f, 3.62878069e-02f,
  -3.21994096e-01f, 4.80340421e-02f, -6.99572563e-02f, 1.40687311e-03f, -5.81990741e-02f, 5.00835441e-02f, -4.73042168e-02f, 1.06209420e-01f, -4.22653407e-02f, -1.28407665e-02f,
  -4.45542000e-02f, -5.62565327e-02f, -2.44815256e-02f, 1.14539526e-01f, 1.10577922e-02f, -6.61734417e-02f, -7.50802159e-02f, -1.81737691e-02f, -1.18711470e-02f, -4.47448436e-03f,
  -1.26687577e-02f, -1.27971143e-01f, -1.45779476e-01f, -6.69944957e-02f, 3.02053783e-02f, -2.31365621e-01f, -2.21800908e-01f, -1.08338408e-01f, -2.07447365e-01f, -2.35223189e-01f,
  3.68405163e-01f, -2.27130339e-01f, -2.02236492e-02f, 1.45459741e-01f, -2.74536461e-01f, 2.48251315e-02f, 7.63235439e-04f, 1.46913260e-01f, 4.85297553e-02f, -6.93847388e-02f,
  -1.45540878e-01f, -1.15985408e-01f, 5.42810149e-02f, 3.71440575e-02f, 2.43657112e-01f, 7.17599913e-02f, 3.06535903e-02f, 1.77394345e-01f, 1.69228882e-01f, -3.61978710e-02f,
  -2.22842723e-01f, -6.26533553e-02f, 1.11953534e-01f, 1.13172540e-02f, -2.41490409e-01f, -1.83361601e-02f, 1.09864641e-02f, -1.32336617e-01f, 2.28016656e-02f, -4.12605405e-01f,
  -1.38936028e-01f, -8.77350569e-02f, 6.19513541e-02f, -2.50963755e-02f, -1.10895813e-01f, -5.15678264e-02f, -2.66464036e-02f, -7.54361153e-02f, -9.60960463e-02f, 2.33699866e-02f,
  -9.91533324e-02f, -7.97365382e-02f, -7.52789974e-02f, -1.69821717e-02f, -6.31719083e-02f, -2.18212046e-02f, 4.71537262e-02f, 2.82425527e-02f, 1.36553481e-01f, 4.84817475e-02f,
  -1.46185651e-01f, -5.60924821e-02f, 1.94909796e-02f, 3.49968523e-02f, 2.25600954e-02f, 3.17323282e-02f, -6.35095015e-02f, -3.43569219e-02f, 1.64214000e-02f, -9.71679911e-02f,
  -4.56153825e-02f, -5.01077026e-02f, 3.08817867e-02f, 2.76579689e-02f, -9.97555256e-03f, -2.93739904e-02f, 6.09242416e-04f, -8.31817184e-03f, 6.70606457e-03f, -7.93038681e-02f,
  4.62514870e-02f, 1.83309745e-02f, -3.42810377e-02f, 9.96450521e-03f, -2.31735576e-02f, -1.44266970e-02f, 1.23940744e-02f, 2.00228728e-02f, 1.00443177e-02f, 3.80730964e-02f,
  -3.14699151e-02f, 3.80377914e-03f, -2.71180235e-02f, -2.33004596e-02f, 4.28389236e-02f, 3.27316974e-03f, 1.16030434e-02f, -8.97047669e-03f, -3.35791893e-02f, 2.43269857e-02f,
  -1.03059865e-04f, 1.91571370e-01f, -9.03731585e-02f, -1.51434382e-02f, 2.03232337e-02f, 1.29342908e-02f, -4.79802899e-02f, -2.24375371e-02f, 7.83214271e-02f, -1.97192505e-02f,
  1.54205179e-02f, 9.37619880e-02f, 4.41590622e-02f, -1.59251615e-02f, -4.71522287e-03f, -8.88070278e-03f, -3.84363383e-02f, 2.26714239e-02f, 3.75021622e-02f, -1.08326748e-01f,
  4.48581800e-02f, 3.55125368e-02f, 4.45065796e-02f, -1.98370796e-02f, -1.02996230e-01f, 4.97658290e-02f, -1.38585553e-01f, -4.99645583e-02f, 1.63301781e-01f, 4.53908890e-02f,
  4.87914920e-01f, -4.81017619e-01f, -1.47171974e-01f, 3.38413715e-01f, -2.21907124e-01f, 2.19696644e-03f, -4.74748671e-01f, 1.23584270e-01f, 3.36929768e-01f, -2.89416224e-01f,
  -6.62237406e-02f, 2.35966474e-01f, 8.03533718e-02f, 4.01845165e-02f, -7.35988328e-03f, -3.34897608e-01f, -3.91191214e-01f, 1.96995344e-02f, 2.61954248e-01f, 1.83943704e-01f,
  7.05860853e-02f, -4.52947542e-02f, 2.24579751e-01f, 3.21973950e-01f, -2.71766365e-01f, 1.26437873e-01f, -3.27953279e-01f, -8.88544843e-02f, -1.83785051e-01f, -6.37663782e-01f,
  -8.85163322e-02f, -1.25463009e-01f, 9.74817425e-02f, 8.01957995e-02f, -8.05629864e-02f, 7.22419918e-02f, 7.06245452e-02f, -3.63232940e-02f, 3.22684199e-02f, 5.81188453e-03f,
  -6.05128109e-02f, 7.90316686e-02f, 3.97195555e-02f, -9.62024182e-02f, -3.75673324e-02f, -2.00249162e-02f, -1.47496408e-03f, 4.33373936e-02f, -1.79703869e-02f, 4.21586633e-03f,
  -9.18356404e-02f, -7.91715086e-02f, -1.94328099e-01f, -4.22768071e-02f, 1.32853955e-01f, 1.05643291e-02f, -1.56492010e-01f, 2.34055351e-02f, -2.20658183e-02f, -1.61517411e-01f,
  2.94555482e-02f, -5.43915480e-02f, -1.00414045e-02f, -2.65520960e-02f, 5.39479330e-02f, -6.83267892e-04f, -4.21149768e-02f, -1.74855832e-02f, 1.06717404e-02f, 2.19589435e-02f,
  -7.47809943e-04f, 6.51857909e-03f, 7.77865872e-02f, 1.95751078e-02f, -2.56738567e-05f, 1.36090834e-02f, 2.30282778e-03f, -6.50852872e-03f, 8.16638395e-03f, -2.31249519e-02f,
  3.72352302e-02f, -1.08587835e-02f, -1.83386989e-02f, 4.04484943e-03f, -1.60319731e-02f, -7.93988537e-03f, 1.38020073e-03f, 1.47494255e-02f, 6.52917400e-02f, 2.22832952e-02f,
  1.52359277e-01f, -7.07931742e-02f, 4.87694051e-04f, 1.08028529e-02f, -1.16254836e-02f, -3.28042731e-02f, -2.45274254e-03f, 1.00530200e-02f, -4.37979996e-02f, -1.87377613e-02f,
  2.52832612e-03f, -3.64494957e-02f, -6.48596883e-02f, 3.59362289e-02f, 5.55148395e-03f, 9.89734661e-03f, -3.76478173e-02f, -3.70798223e-02f, -1.53237702e-02f, 4.38085422e-02f,
  3.59451361e-02f, -1.49126016e-02f, 4.63371798e-02f, 1.65223405e-02f, 2.12927567e-04f, -9.95629840e-03f, -4.73672226e-02f, 1.58211542e-03f, -6.91063926e-02f, 1.10656135e-02f,
  4.07367051e-01f, -4.42733705e-01f, 3.64908844e-01f, -2.85551473e-02f, -1.97666690e-01f, -8.46401006e-02f, -3.55645359e-01f, -1.58694103e-01f, -1.68865896e-03f, -4.23472859e-02f,
  -1.63020894e-01f, 2.97633205e-02f, 1.17579028e-01f, 4.48989421e-02f, 3.47458310e-02f, 1.04284786e-01f, 1.96456060e-01f, 4.05155510e-01f, 2.49770179e-01f, -2.13309735e-01f,
  -1.52513131e-01f, -1.74742416e-02f, 2.00609073e-01f, -2.53295470e-02f, -4.50805537e-02f, 2.69196749e-01f, 1.62959844e-01f, -7.98958167e-02f, -7.03329444e-02f, 8.68517682e-02f,
  3.17415625e-01f, -2.01853871e-01f, 1.14252880e-01f, -2.76840795e-02f, 1.08199278e-02f, 3.30866575e-02f, -1.18199298e-02f, 4.39579599e-02f, -1.67744532e-02f, 3.32563184e-02f,
  2.38747406e-03f, -4.18897569e-02f, -1.54395932e-02f, 6.86358893e-03f, -1.97263863e-02f, -1.09691598e-01f, 1.12517718e-02f, 1.87349059e-02f, 7.81731531e-02f, -3.38079818e-02f,
  -1.26149341e-01f, -1.06541753e-01f, -1.40140370e-01f, -4.28052694e-02f, -1.30752167e-02f, 9.25193727e-02f, -1.46940574e-01f, -1.11011513e-01f, 4.58501056e-02f, -3.01031359e-02f,
  8.36064108e-03f, 8.35998654e-02f, 1.89702772e-02f, -8.56754482e-02f, 1.18596144e-02f, 5.61270770e-03f, -3.40967462e-03f, 3.52457277e-02f, -1.50578655e-02f, 1.31285386e-02f,
  -2.92341523e-02f, 3.80576737e-02f, -2.26805592e-03f, -1.33345164e-02f, 7.48290867e-02f, -8.63507316e-02f, 1.00350529e-02f, 1.47690028e-02f, 1.74842253e-02f, 1.89203564e-02f,
  -1.35642570e-02f, -1.84920896e-02f, 5.55561781e-02f, -4.70657535e-02f, -4.78067845e-02f, -1.86454542e-02f, -2.92984210e-02f, -4.32013394e-03f, -1.77393481e-02f, -1.97438095e-02f,
  3.58215794e-02f, 5.95880710e-02f, 1.36788249e-01f, -2.47223768e-04f, -3.81185301e-02f, 1.18074659e-02f, -3.25390659e-02f, -1.27394218e-03f, -1.80893741e-03f, -1.82983540e-02f,
  -6.02558404e-02f, 5.88717908e-02f, 2.52349507e-02f, 8.48488789e-03f, 7.48729287e-03f, 3.34671810e-02f, -4.88089807e-02f, 4.30146679e-02f, -6.48456439e-02f, -5.16818240e-02f,
  -4.63543497e-02f, -2.18101591e-02f, 5.59531488e-02f, 1.31198183e-01f, 9.05388675e-04f, 7.95724690e-02f, 1.55028567e-01f, 9.06720906e-02f, 3.29281799e-02f, 1.30782247e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.28502131e-01f, -1.10599048e-01f, -2.74205208e-01f, 2.94717431e-01f, 2.62096703e-01f, 1.99402362e-01f, 1.98209688e-01f, 1.44171581e-01f, 2.30844945e-01f, 4.31912430e-02f,
  9.98782739e-02f, 2.44772568e-01f, 2.41032079e-01f, 2.21712306e-01f, 1.05130352e-01f, 1.89577848e-01f, 2.53075212e-01f, -2.00514831e-02f, 6.26611244e-03f, 9.36825797e-02f,
  1.95514441e-01f, 9.52493995e-02f, -2.14429453e-01f, 4.32080664e-02f, 2.29941891e-03f, 1.62051097e-01f, -4.52927910e-02f, 3.74552198e-02f, 2.12449450e-02f, 9.12462473e-02f,
  -1.78112417e-01f, -1.24965392e-01f, 3.66697870e-02f, 5.64515702e-02f, -2.54052710e-02f, -2.16055602e-01f, -7.16538727e-02f, -2.15069264e-01f, -6.55521378e-02f, -8.40233192e-02f,
  1.30083431e-02f, -9.75026786e-02f, 5.30970395e-02f, -9.78377461e-02f, -2.78577935e-02f, -4.39192951e-02f, -5.36332950e-02f, -4.81892489e-02f, 1.38683483e-01f, 3.19760703e-02f,
  1.50176242e-01f, -1.03764810e-01f, -1.31340653e-01f, 5.08589298e-02f, 5.06590717e-02f, 2.93928701e-02f, -1.20774090e-01f, -4.99872006e-02f, 4.67611067e-02f, -1.28343552e-01f,
  1.93893537e-02f, -6.87455907e-02f, 4.55879197e-02f, 1.03095705e-02f, 3.42475921e-02f, 1.15077579e-02f, 1.17023177e-02f, -1.65819712e-02f, 1.65992100e-02f, -7.18580708e-02f,
  -2.29280461e-02f, 9.95841622e-02f, 3.69570926e-02f, 1.99300162e-02f, 6.14829548e-02f, -7.07223564e-02f, -3.23040015e-03f, 1.80826359e-03f, 5.12462296e-02f, -5.12526967e-02f,
  4.82048839e-02f, 4.64536482e-03f, 2.55188737e-02f, -9.44246829e-04f, 7.11489236e-03f, 6.71104714e-02f, 3.92106920e-02f, 1.10473186e-02f, -6.30769432e-02f, -1.27305761e-01f,
  1.41981259e-01f, 2.91925907e-01f, 1.84504524e-01f, 3.89835332e-03f, -1.70606114e-02f, -7.52689466e-02f, 1.10301234e-01f, -6.67991815e-03f, 1.86492559e-02f, 2.52496637e-03f,
  -9.69638079e-02f, -1.95326172e-02f, 9.48232859e-02f, -1.20962270e-01f, -9.27435830e-02f, -4.17657271e-02f, 4.60814834e-02f, 1.25646010e-01f, 2.04465017e-02f, -1.08138174e-01f,
  -2.11702026e-02f, -6.39784560e-02f, -1.26968706e-02f, -1.08435797e-02f, 5.48394583e-02f, 1.59992129e-01f, -1.16928473e-01f, -8.51133540e-02f, -3.54014859e-02f, -1.15319550e-01f,
  8.28757584e-01f, -3.82392973e-01f, 2.06135839e-01f, 4.11266148e-01f, 3.87596935e-01f, 3.52072626e-01f, 3.12401742e-01f, 1.30202696e-01f, 1.21450655e-01f, 1.34149089e-01f,
  1.28236283e-02f, -5.40409125e-02f, -5.99827766e-02f, -2.50832736e-01f, -3.33350226e-02f, -1.70251317e-02f, -9.04501453e-02f, 3.43416876e-04f, 3.42012137e-01f, 1.68829694e-01f,
  5.72851449e-02f, 6.18752725e-02f, 1.18989475e-01f, -8.95841494e-02f, -7.42215812e-02f, 7.44486302e-02f, 4.38551828e-02f, -1.41729876e-01f, -1.34908557e-01f, -3.34428638e-01f,
  -2.24280596e-01f, 1.02176145e-01f, 7.72235617e-02f, 1.86849944e-03f, -5.19432090e-02f, -2.78686564e-02f, 1.60087424e-03f, -3.11756227e-02f, -1.33312512e-02f, -1.67430472e-02f,
  -6.03579096e-02f, -7.12476857e-03f, -6.78014457e-02f, -6.78285351e-03f, -5.03987335e-02f, 3.21549661e-02f, -8.23827833e-02f, -8.17077607e-02f, -2.30309367e-02f, -9.77964625e-02f,
  -1.64958894e-01f, 4.24550548e-02f, 4.37801033e-02f, 4.45179529e-02f, -1.78492796e-02f, 2.42398046e-02f, -5.53900283e-03f, -8.37789625e-02f, 3.97391431e-02f, 9.98871867e-03f,
  5.50976209e-02f, 4.72189374e-02f, -4.79282998e-02f, -1.71936639e-02f, 8.61444231e-03f, 5.41349351e-02f, -9.17210057e-03f, -1.05668660e-02f, 5.75661324e-02f, -1.00171352e-02f,
  -4.66997437e-02f, 3.31832580e-02f, -3.34491022e-02f, 3.32472734e-02f, -4.80517969e-02f, 2.99245608e-03f, 2.22671730e-03f, -7.81692192e-02f, -1.81860942e-03f, -8.35160539e-03f,
  7.10988641e-02f, 2.77245007e-02f, 2.25380324e-02f, -7.69277662e-02f, -2.77907960e-02f, 3.21385264e-02f, -3.08880899e-02f, 1.29842591e-02f, 3.32439244e-02f, 2.51270346e-02f,
  -2.50231802e-01f, 6.70916662e-02f, -3.78996581e-02f, -1.25145927e-01f, 5.19934408e-02f, -1.55777767e-01f, 1.40249627e-02f, -7.90870264e-02f, -1.35576457e-01f, -8.12263638e-02f,
  -5.16011938e-03f, -2.93586329e-02f, -7.10556507e-02f, 1.23751611e-02f, 1.34091094e-01f, 8.97302181e-02f, -8.12512413e-02f, 7.39117488e-02f, -1.03218868e-01f, -9.18632224e-02f,
  -5.78075275e-02f, 1.00719444e-01f, 1.73602387e-01f, 6.94910213e-02f, 2.36555096e-03f, 2.25323632e-01f, -2.48692278e-02f, -1.26866847e-02f, 1.06286161e-01f, 1.79332405e-01f,
  -1.17473386e-01f, -2.64544994e-01f, -3.80981177e-01f, -1.81711510e-01f, -2.47569263e-01f, -2.32223615e-01f, -3.09939504e-01f, 9.81104597e-02f, 2.39089131e-02f, -3.66334915e-01f,
  1.12816736e-01f, 2.45974138e-01f, 2.20306203e-01f, 1.45223096e-01f, -8.40822980e-02f, -3.66391659e-01f, -4.18403864e-01f, -1.60773069e-01f, 2.30541285e-02f, -9.82570928e-03f,
  -8.70892555e-02f, -1.88593149e-01f, 6.18125834e-02f, 7.68237710e-02f, -5.82574867e-02f, 9.59202945e-02f, -2.05069348e-01f, -1.10479906e-01f, -4.89330925e-02f, -2.88267761e-01f,
  -1.17383473e-01f, 2.24879399e-01f, 6.09178357e-02f, -8.80010193e-04f, -8.78668725e-02f, 5.97753264e-02f, -4.50612605e-02f, 4.98705432e-02f, 1.27062067e-01f, 4.05799933e-02f,
  7.70309269e-02f, -4.63398956e-02f, 7.52303749e-02f, 4.61295247e-02f, 9.02664196e-03f, -3.33528779e-02f, -1.23818247e-02f, -2.60292366e-02f, -4.36927192e-02f, -1.25366911e-01f,
  -6.87756091e-02f, -3.04071438e-02f, 8.10074732e-02f, 1.53753057e-01f, 2.98980325e-02f, 6.67311549e-02f, 1.31018788e-01f, 4.34869081e-02f, 8.27618837e-02f, 5.30913845e-02f,
  -5.55148199e-02f, 1.28925860e-01f, 7.95106497e-03f, 1.09216860e-02f, -5.41055351e-02f, 3.33992764e-02f, 1.28138643e-02f, -3.03095728e-02f, 3.83083373e-02f, -5.14849983e-02f,
  -4.84451186e-03f, -6.60699457e-02f, -2.79176664e-02f, -4.28834260e-02f, -1.55123090e-02f, -1.09119780e-01f, -3.61490883e-02f, -3.14881615e-02f, 4.11992781e-02f, -1.59449410e-02f,
  2.14055460e-02f, 7.91438892e-02f, -6.10603066e-03f, 7.41151348e-02f, -6.08547479e-02f, -2.46054158e-02f, -4.84436527e-02f, 9.07683000e-02f, 3.73047916e-03f, -4.63448204e-02f,
  1.38126835e-01f, 4.35978957e-02f, -1.66548546e-02f, 6.89479783e-02f, -2.08773185e-02f, 1.32225258e-02f, 1.10907480e-02f, 1.18941786e-02f, 5.25694489e-02f, 1.37874309e-03f,
  6.91477209e-02f, 1.45803522e-02f, -4.29471657e-02f, 9.59627330e-04f, 2.94272769e-02f, 6.99996278e-02f, -6.96256310e-02f, 1.54284257e-02f, 6.03348762e-03f, -4.00180854e-02f,
  -1.47412583e-01f, -7.88027197e-02f, 8.63774642e-02f, 2.69853212e-02f, 7.64500126e-02f, 5.31269163e-02f, 1.61286935e-01f, 2.94539370e-02f, 1.22703463e-01f, -1.14458129e-01f,
  3.04856807e-01f, 2.01676413e-02f, -2.09466428e-01f, 1.22546621e-01f, -3.47233824e-02f, -2.47195493e-02f, 1.10196859e-01f, 1.05424814e-01f, 7.15375245e-02f, 2.92259231e-02f,
  2.03022748e-01f, 2.32938841e-01f, 2.44474545e-01f, 2.42989451e-01f, 2.07127437e-01f, 5.14013320e-02f, 4.97857593e-02f, 1.18872859e-01f, 1.88318826e-02f, 2.53336281e-02f,
  3.51381004e-02f, -3.35426219e-02f, 1.16774559e-01f, 7.17460364e-02f, -8.86220485e-02f, 1.16504081e-01f, -6.04184717e-02f, -9.78358537e-02f, -1.11263886e-01f, -5.90465143e-02f,
  -2.73747116e-01f, -1.08500071e-01f, 7.00687096e-02f, 1.84135854e-01f, -1.46866232e-01f, -1.29633307e-01f, -1.65771917e-02f, -1.11014210e-01f, -2.08557937e-02f, -1.04173101e-01f,
  1.54008912e-02f, -7.68116042e-02f, 6.38755709e-02f, -2.72651594e-02f, -6.15098700e-02f, -2.89192963e-02f, 3.62447975e-03f, -1.26497354e-03f, -4.37056758e-02f, -1.32883176e-01f,
  -2.61297487e-02f, 1.13896234e-02f, -4.51580808e-03f, 7.79361352e-02f, 5.16192708e-03f, 9.44738463e-02f, -7.45263025e-02f, -1.40412703e-01f, 4.65569235e-02f, -2.88993455e-02f,
  5.52637205e-02f, 1.11708622e-02f, -4.97589679e-03f, -3.71174552e-02f, 1.35989398e-01f, -1.80732389e-03f, -1.52690010e-02f, 2.07134616e-02f, 6.88759089e-02f, -8.63488857e-03f,
  2.61482541e-02f, -1.55483140e-02f, 2.83430275e-02f, 9.14216265e-02f, 3.29355448e-02f, 2.16887426e-02f, -5.96516393e-03f, -3.82089689e-02f, 5.85443601e-02f, -4.97434326e-02f,
  5.78854084e-02f, 4.27087210e-02f, -6.79723024e-02f, 3.57011706e-03f, -3.55753787e-02f, 6.52703345e-02f, -1.17536327e-02f, -2.93449331e-02f, 1.95533950e-02f, 3.77252139e-02f,
  -1.89096138e-01f, 2.32823133e-01f, 5.57209738e-03f, 2.02427357e-02f, -1.19075529e-01f, -5.91874029e-03f, -5.73063502e-03f, 6.63467217e-03f, -1.89513564e-01f, -9.17034689e-03f,
  -7.90864080e-02f, 1.04644205e-02f, -1.62899923e-02f, -1.38842566e-02f, -3.78263816e-02f, -1.05605930e-01f, -2.57695019e-02f, 1.56988669e-02f, -5.97030669e-03f, -1.24590866e-01f,
  2.01014038e-02f, 8.91899839e-02f, 1.57227024e-01f, 4.58259284e-02f, -4.33661155e-02f, 1.88351482e-01f, 3.12394742e-02f, -1.03667162e-01f, 2.47897040e-02f, 5.24455607e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -3.96913365e-02f, 2.97754973e-01f, 2.77760208e-01f, 2.79149443e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -4.34115171e-01f, -2.58164644e-01f, 3.17090675e-02f, 2.12786868e-01f, 3.54281634e-01f, -2.62725493e-03f, 3.57928187e-01f, -4.35380965e-01f, 8.28879654e-01f, -5.42178512e-01f,
  -1.63465410e-01f, -5.35985649e-01f, 1.02634184e-01f, -7.61865258e-01f, -1.63078517e-01f, 1.26249433e-01f, 5.41115165e-01f, -9.43405554e-02f, 1.27673686e-01f, -3.05263102e-01f,
  9.63002518e-02f, -2.15606213e-01f, 9.35077727e-01f, -4.18746769e-01f, 1.57284692e-01f, 4.66900542e-02f, -1.81849137e-01f, -2.99449768e-02f, 4.18082029e-01f, 5.23276448e-01f,
  -4.04502600e-01f, -3.51926386e-01f, -1.72035098e-01f, -2.78561801e-01f, -1.18707664e-01f, -1.46327972e-01f, 5.25076568e-01f, 6.88578263e-02f, 9.56973195e-01f, -5.95027328e-01f,
  5.91220021e-01f, -1.66308507e-01f, -2.80031234e-01f, 4.30051476e-01f, 3.58146489e-01f, -2.14085206e-01f, -6.52612507e-01f, 1.24459658e-02f, 8.24692905e-01f, -1.39388695e-01f,
  1.15034707e-01f, -5.51362157e-01f, -6.58574104e-01f, -2.79344261e-01f, -1.83788061e-01f, -5.94181836e-01f, 2.27287591e-01f, 3.12228411e-01f, 6.61268950e-01f, 4.14668582e-02f,
  2.62591630e-01f, -2.13416651e-01f, 4.30034697e-01f, 5.05576313e-01f, -4.69632037e-02f, -2.45971099e-01f, -3.44231367e-01f, -9.77998227e-02f, 1.04570973e+00f, 1.57915398e-01f,
  1.10497758e-01f, 1.84757948e-01f, -1.64582253e-01f, -4.73875493e-01f, 7.17228577e-02f, 1.05499828e+00f, -2.74267256e-01f, 5.86512312e-03f, -1.82695612e-01f, -6.84926957e-02f,
  -1.20836988e-01f, 1.84075221e-01f, 1.29139662e-01f, 8.23413879e-02f, 6.46773994e-01f, -1.23822726e-01f, -1.44754976e-01f, 7.90025294e-01f, 1.12979576e-01f, 5.44859052e-01f,
  3.98322374e-01f, 9.62354898e-01f, -1.57402679e-01f, 2.77045906e-01f, -4.29126978e-01f, 3.45625170e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.17948318e+00f, 2.47510374e-01f, 3.57616484e-01f, 2.81123191e-01f, 2.92017549e-01f, 2.77439147e-01f, -5.84196568e-01f, 5.62144339e-01f, -5.77844381e-01f, 4.20327336e-01f,
  1.13446331e+00f, 1.18792020e-01f, -1.27731159e-01f, 8.00678432e-01f, 2.29265183e-01f, 5.23052871e-01f, -4.43579882e-01f, 5.40990710e-01f, 3.87138188e-01f, 5.62233448e-01f,
  4.50947583e-01f, 1.14783145e-01f, 4.36878532e-01f, 2.00987637e-01f, 4.77430433e-01f, 2.22362503e-01f, -5.06983161e-01f, -4.68032092e-01f, -2.21936524e-01f, -3.80762480e-02f,
  -1.14385493e-01f, 2.11062461e-01f, 2.79740185e-01f, 1.63196936e-01f, 1.15069794e-03f, -2.48244293e-02f, -2.37522528e-01f, 1.87297210e-01f, 8.17541897e-01f, -2.55809009e-01f,
  1.08427837e-01f, -6.09765291e-01f, -5.44471800e-01f, -5.91901302e-01f, 7.06092179e-01f, 2.68444747e-01f, -4.40834850e-01f, 4.31194395e-01f, -4.86809947e-02f, -3.82147101e-03f,
  1.67290106e-01f, 3.16888899e-01f, 4.62443978e-01f, 3.50952208e-01f, -6.76698983e-01f, -1.93624645e-01f, 7.90605173e-02f, -3.74191552e-01f, 4.46799189e-01f, 2.25683957e-01f,
  -2.60402828e-01f, -4.75251615e-01f, 5.67271650e-01f, 2.15555429e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.99675190e-01f, 4.12208438e-01f, 1.74447969e-01f, 5.56488633e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  5.62561929e-01f, -8.15232217e-01f, -1.75496370e-01f, -4.34165955e-01f, -1.23658359e+00f, -1.18058240e+00f, 6.13771155e-02f, -7.87601233e-01f, -1.89816430e-01f, 5.41931152e-01f,
  -4.88921940e-01f, -7.76328444e-01f, -1.36399969e-01f, -3.84966224e-01f, -2.46993482e-01f, 5.59425473e-01f, -1.12084901e+00f, -4.58643436e-01f, -4.54724818e-01f, -7.50495791e-01f,
  3.80696416e-01f, -2.07398817e-01f, -3.55173737e-01f, -1.73062429e-01f, 3.18005532e-01f, 9.95492876e-01f, -3.26342762e-01f, 5.27816296e-01f, 9.78362322e-01f, -6.92557514e-01f,
  3.13140839e-01f, -6.97668493e-02f, 8.66008461e-01f, 7.72296846e-01f, 7.10726678e-01f, 6.46848321e-01f, 4.35889274e-01f, -2.02537090e-01f, -4.55080718e-02f, 2.15306461e-01f,
  1.01134992e+00f, 1.17975771e+00f, 6.04360223e-01f, 9.37335372e-01f, 4.02701467e-01f, 7.39806984e-03f, -6.51645124e-01f, 1.24588042e-01f, -2.55973847e-03f, 2.64511615e-01f,
  9.19140875e-01f, 6.23339474e-01f, 1.94083944e-01f, 5.85493386e-01f, 7.27046967e-01f, -1.10074651e+00f, -4.64744806e-01f, -9.05954421e-01f, -7.27046609e-01f, -5.76900542e-01f,
  -7.80863822e-01f, 7.51558959e-01f, -5.48629999e-01f, 4.39706221e-02f, 6.06273770e-01f, 1.86562408e-02f, 2.52923012e-01f, 6.28751695e-01f, 6.47624791e-01f, 3.80677938e-01f,
  5.55136740e-01f, -6.92052841e-01f, -9.80865240e-01f, 7.77167201e-01f, -7.09060729e-01f, -1.05645847e+00f, 3.21269810e-01f, -5.12090147e-01f, -4.54674624e-02f, 6.07546985e-01f,
  -4.96225245e-02f, 2.46987537e-01f, -6.24885023e-01f, 1.16601562e+00f, 2.44672373e-01f, 2.94277947e-02f, -1.17233074e+00f, -2.76484191e-01f, -7.30838060e-01f, 4.99757588e-01f,
  -2.42005184e-01f, 6.33556724e-01f, 9.81883228e-01f, -4.09850329e-02f, -2.35401183e-01f, -1.28646299e-01f, 2.30666474e-01f, 6.09456360e-01f, 3.71847689e-01f, -1.14379489e+00f,
  3.73228490e-01f, -2.61185825e-01f, 5.83733678e-01f, -1.50099516e-01f, 1.04499030e+00f, -9.52481568e-01f, 7.27834404e-01f, 1.06461906e+00f, -7.25963175e-01f, 5.93165517e-01f,
  2.62003485e-02f, -2.48839080e-01f, -5.03941357e-01f, -2.61114478e-01f, -2.41938680e-01f, 2.07661599e-01f, -2.86771923e-01f, -4.77463543e-01f, 1.32421479e-01f, 5.29879987e-01f,
  6.01825237e-01f, 9.89556551e-01f, -5.18769264e-01f, -6.85127497e-01f, -5.46729565e-01f, -1.27163939e-02f, 9.92064238e-01f, -5.05705178e-01f, -5.20143151e-01f, -3.57998431e-01f,
  2.85792857e-01f, -5.05001247e-01f, -4.29892510e-01f, -1.12803936e+00f, -4.71769832e-02f, 1.20110261e+00f, -3.83234471e-01f, -7.46877491e-01f, 4.70807344e-01f, 3.34152192e-01f,
  9.43770051e-01f, -1.92473873e-01f, -2.27630988e-01f, -6.70547605e-01f, -6.45676672e-01f, 3.67756754e-01f, -7.41858602e-01f, 7.11076319e-01f, 5.39115906e-01f, 7.01681197e-01f,
  7.71318972e-01f, 8.49620521e-01f, 5.43853819e-01f, -4.97972965e-01f, 9.53354239e-01f, -6.15938902e-01f, -8.51443052e-01f, 1.71064481e-01f, 3.90877485e-01f, 2.42432449e-02f,
  2.60119081e-01f, -6.19385898e-01f, -2.09260851e-01f, -2.03064099e-01f, -3.40448231e-01f, 4.17570502e-01f, -9.15479183e-01f, -7.54121602e-01f, -8.48487377e-01f, -1.12227821e+00f,
  1.36405861e+00f, 3.99934709e-01f, 3.64985093e-02f, -4.07637686e-01f, -3.75147671e-01f, 5.07878304e-01f, 5.46917021e-01f, 1.26556782e-02f, 1.04420388e+00f, -6.01365328e-01f,
  2.01107338e-01f, 4.72117931e-01f, -4.87171978e-01f, 1.17020524e+00f, -8.89575407e-02f, -1.04908574e+00f, -8.86030316e-01f, -3.68783563e-01f, -7.42731243e-02f, 4.64770287e-01f,
  3.97982121e-01f, -6.10951245e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.97364348e-01f, -2.08841026e-01f, -3.01294830e-02f, 1.29448026e-01f, -2.21316427e-01f, -1.81928366e-01f, 2.28326410e-01f, -3.49174067e-02f, -2.96037626e-02f, 3.63533199e-01f,
  1.54816598e-01f, 9.42410231e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    