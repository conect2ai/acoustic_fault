/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.89555097e-02f, -1.61265731e-01f, -2.94274271e-01f, -7.29836076e-02f, 4.93281968e-02f, 2.36332163e-01f, 1.67578727e-01f, 2.69070923e-01f, 1.65553391e-01f, -6.56175911e-02f,
  5.66765945e-03f, 5.96152507e-02f, 9.97910351e-02f, 1.22321881e-01f, 1.51857197e-01f, -8.08699653e-02f, -2.26431154e-02f, -1.20341353e-01f, 1.91052347e-01f, 1.17278613e-01f,
  3.84142548e-02f, 1.29398525e-01f, -3.85442711e-02f, -3.24936141e-03f, -1.48045629e-01f, 4.71994095e-02f, -6.29018992e-02f, -6.03612922e-02f, 1.77859813e-02f, -2.09407344e-01f,
  -1.70174271e-01f, -1.67628914e-01f, 1.60948753e-01f, 1.02612115e-02f, 4.43798751e-02f, 4.17852402e-02f, 8.76055583e-02f, -1.66364461e-02f, -1.83088658e-03f, 1.90917235e-02f,
  -1.17573828e-01f, 5.17731272e-02f, 6.70496076e-02f, 1.29954377e-02f, 1.32890912e-02f, 7.03432560e-02f, -3.18989009e-02f, -1.16577007e-01f, -2.17498858e-02f, 4.67576347e-02f,
  -5.15036248e-02f, -2.51731416e-03f, -1.40259340e-02f, 7.69158602e-02f, 1.88768934e-02f, -3.06192730e-02f, -3.89485769e-02f, -1.25504723e-02f, 7.81130046e-02f, 7.08462819e-02f,
  9.09164995e-02f, 6.68403283e-02f, 5.17003052e-02f, 2.61102132e-02f, 1.54542103e-01f, 2.06681695e-02f, -1.10237025e-01f, -1.10960323e-02f, -2.18937011e-03f, 9.45048034e-02f,
  -4.88776527e-02f, 2.57576387e-02f, -4.33838181e-03f, -1.19489573e-01f, -2.59339083e-02f, 6.63520545e-02f, 2.83146277e-02f, 4.36594114e-02f, 9.61012614e-04f, 4.78204302e-02f,
  -3.11469547e-02f, 3.45911607e-02f, 1.17269019e-02f, 4.63492423e-02f, -8.07808563e-02f, -3.76713090e-02f, -6.63260892e-02f, 1.02356970e-01f, 1.83641613e-02f, -6.50520548e-02f,
  1.86945528e-01f, -9.05106217e-02f, 4.43771370e-02f, 3.37861553e-02f, -8.59660953e-02f, 4.61095087e-02f, -4.28452641e-02f, -6.27944339e-03f, 7.18273371e-02f, 1.60529688e-01f,
  7.98958316e-02f, 8.24633166e-02f, 3.31895910e-02f, 5.15585802e-02f, 4.11907621e-02f, 1.00283206e-01f, 1.11091524e-01f, 7.26056993e-02f, 8.38793069e-02f, -1.86983254e-02f,
  2.66275518e-02f, 1.57215506e-01f, 1.36599481e-01f, 2.18675271e-01f, 1.67364553e-01f, 1.51172265e-01f, 7.74750039e-02f, 1.59933716e-01f, 1.78568780e-01f, 3.35155487e-01f,
  2.86179602e-01f, -4.62936163e-02f, 3.11376154e-01f, -1.18713491e-01f, -3.12834412e-01f, -5.09552397e-02f, 4.68978360e-02f, 6.55536354e-03f, -5.96714914e-02f, 1.22210113e-02f,
  -1.83113098e-01f, -1.11817181e-01f, -7.30351806e-02f, 7.83960149e-02f, 1.15889311e-01f, 1.52950644e-01f, 3.72043587e-02f, 2.82339841e-01f, 3.27472746e-01f, 5.49357645e-02f,
  -1.34327054e-01f, 7.83172697e-02f, 1.15452997e-01f, 4.67063747e-02f, 4.41808738e-02f, 1.40212044e-01f, 1.51738986e-01f, -1.07911155e-01f, -1.13815501e-01f, -2.14837287e-02f,
  1.56519830e-01f, -3.34460475e-02f, 1.31055444e-01f, -5.99207245e-02f, -1.04040608e-01f, 2.41873786e-02f, -5.28334416e-02f, -1.60464197e-02f, -3.87824662e-02f, 9.74659324e-02f,
  -3.76103111e-02f, -8.87380615e-02f, 5.07362932e-02f, 1.43687306e-02f, 1.26210541e-01f, 4.75763455e-02f, 3.70706357e-02f, 1.23274662e-01f, 2.75576152e-02f, 1.23697175e-02f,
  -4.85824049e-02f, -1.23751916e-01f, 1.17549717e-01f, 7.27170557e-02f, 6.96468446e-03f, -1.31979613e-02f, 1.17493503e-01f, -1.95099860e-02f, 1.47798315e-01f, 1.57176226e-01f,
  -5.37070446e-02f, 4.55076359e-02f, -5.68225756e-02f, 5.66461943e-02f, 2.90764421e-02f, -6.00282699e-02f, -8.96574091e-03f, 4.32084017e-02f, -2.06740219e-02f, 2.48772167e-02f,
  -1.32604465e-01f, -3.16071138e-02f, -1.89148374e-02f, 5.51167177e-03f, -2.47796648e-03f, 3.00620329e-02f, -7.99310952e-03f, 4.54388335e-02f, 9.03536938e-03f, 5.81377409e-02f,
  -6.73899949e-02f, -1.94945969e-02f, -7.49857873e-02f, -1.14413239e-02f, 4.15932201e-03f, 2.76833531e-02f, -2.31265072e-02f, 5.84727339e-03f, 6.69764951e-02f, 4.63172458e-02f,
  9.28310081e-02f, 6.42098859e-02f, 4.50650044e-02f, 7.63218999e-02f, 3.56006883e-02f, -3.96595560e-02f, -5.96591942e-02f, 2.13823188e-02f, -9.97461155e-02f, 1.18093155e-02f,
  -5.93943447e-02f, 1.19930832e-02f, 2.50360575e-02f, 4.39095162e-02f, -2.43349448e-02f, 2.79426910e-02f, -4.61876467e-02f, 3.49206589e-02f, 3.82601805e-02f, -4.94644009e-02f,
  9.36903059e-03f, 1.43555641e-01f, 1.13072284e-01f, -4.69557419e-02f, 5.32210572e-03f, 7.17635602e-02f, 7.97964036e-02f, 8.56930099e-04f, 1.76611081e-01f, 2.78823495e-01f,
  2.84017056e-01f, -3.41309279e-01f, -2.63075292e-01f, 6.39669523e-02f, -2.09410518e-01f, 4.85568494e-02f, -1.63882703e-01f, 6.34006131e-03f, 3.79582755e-02f, -1.31187648e-01f,
  2.41389172e-03f, 2.22512618e-01f, 1.11815587e-01f, 1.33458808e-01f, 1.24519065e-01f, -1.65293232e-01f, -2.35793635e-01f, 9.67029557e-02f, 1.59047171e-01f, 6.79534748e-02f,
  -3.89826521e-02f, 4.41237390e-02f, 5.61458543e-02f, 3.59983854e-02f, -8.33654776e-02f, 3.96691263e-02f, -1.75805569e-01f, -2.06017137e-01f, -1.71579644e-01f, -3.41780186e-01f,
  -6.43647537e-02f, -5.14409095e-02f, 7.79839382e-02f, -2.55327597e-02f, -5.43926843e-02f, -2.14561969e-02f, -1.23761550e-01f, -1.86551675e-01f, 1.48863373e-02f, 2.82250624e-02f,
  -1.34542823e-01f, -2.11391933e-02f, 2.61367243e-02f, -5.17531000e-02f, -7.23310784e-02f, -1.19879097e-01f, -9.38250870e-02f, -2.83829160e-02f, -1.05842799e-01f, -1.83286056e-01f,
  -6.09295107e-02f, -1.32336065e-01f, -1.18235290e-01f, -1.15068488e-01f, -1.17873333e-01f, 6.12432808e-02f, -1.79484084e-01f, -1.08485535e-01f, 2.18075351e-03f, -5.50750941e-02f,
  2.23675333e-02f, -2.03590080e-01f, -5.52775823e-02f, -3.86124663e-02f, 5.86984158e-02f, -1.33370742e-01f, -3.84191759e-02f, 9.99797042e-03f, 7.14990422e-02f, 7.24787591e-03f,
  -1.58869904e-02f, -4.32152152e-02f, 7.26672411e-02f, 8.29837192e-03f, -1.30950054e-02f, -4.44476083e-02f, 6.38166768e-03f, 4.74226996e-02f, -7.08134379e-03f, -1.15686916e-02f,
  -2.63918261e-03f, 6.28368706e-02f, 7.04561472e-02f, 5.24545610e-02f, 1.45398742e-02f, -2.31041536e-02f, 1.90845188e-02f, 7.64248073e-02f, 1.02875782e-02f, 5.06919390e-03f,
  2.30526701e-01f, -6.52696490e-02f, -1.29547985e-02f, 5.68150952e-02f, -2.26061698e-02f, -7.34326080e-04f, 5.01586683e-02f, -6.71238676e-02f, 8.68403818e-03f, 2.91902516e-02f,
  -1.13723045e-02f, 8.36735815e-02f, 4.04256731e-02f, 7.02167302e-03f, -2.20885538e-02f, -2.56316960e-02f, -4.16004546e-02f, 5.25511131e-02f, 4.01193872e-02f, -1.40501121e-02f,
  2.91454475e-02f, 5.74831478e-02f, 1.17548309e-01f, 3.36765945e-02f, -1.20783404e-01f, 7.93621615e-02f, 2.51607923e-03f, 9.54025611e-02f, 1.12700071e-02f, 8.89936164e-02f,
  3.83837610e-01f, 1.23787232e-01f, -1.42480984e-01f, 1.12760616e-02f, 2.45436151e-02f, 1.42563775e-01f, 3.01153839e-01f, 9.81011242e-02f, 3.31005380e-02f, 1.81029424e-01f,
  4.28754166e-02f, -1.11533664e-01f, -1.81698471e-01f, -5.62272072e-02f, -5.98086454e-02f, 1.49986595e-01f, -9.32807028e-02f, -5.57988770e-02f, -6.71065748e-02f, 5.70481084e-02f,
  8.02970666e-04f, -9.74264815e-02f, -7.38024116e-02f, -6.13408722e-02f, 2.84814704e-02f, -4.30961959e-02f, -1.62552759e-01f, -7.10211545e-02f, -6.83154836e-02f, -1.41683131e-01f,
  1.12934895e-01f, 2.65928924e-01f, 2.58111525e-02f, 1.26858383e-01f, -5.44433892e-02f, 1.81360722e-01f, 1.63291931e-01f, 9.58197266e-02f, -3.51753086e-02f, 6.13807291e-02f,
  3.52721512e-02f, 6.63781166e-02f, 4.38906997e-02f, 4.57856338e-03f, 7.05342591e-02f, 3.54457162e-02f, 7.08789825e-02f, -6.14466183e-02f, 6.46323850e-03f, 8.18609595e-02f,
  -4.35341895e-02f, 1.04693614e-01f, 1.15329601e-01f, 7.96900422e-05f, -1.77084422e-03f, -8.72081667e-02f, -2.12652069e-02f, -6.13932051e-02f, -5.90217486e-02f, 4.55857702e-02f,
  -6.94393665e-02f, -7.78882056e-02f, -1.18829012e-01f, -4.85438108e-02f, -1.24677636e-01f, -1.29002631e-01f, -2.61668682e-01f, -1.42827556e-01f, -1.08344048e-01f, -1.23725250e-01f,
  -1.77435517e-01f, -1.58302069e-01f, -5.41171469e-02f, -2.01838687e-01f, -1.53246924e-01f, -2.75535882e-01f, -2.59114772e-01f, -3.64988714e-01f, -2.60331452e-01f, -2.84005702e-01f,
  -2.79082388e-01f, -1.19432330e-01f, -2.66444564e-01f, -2.51952052e-01f, -1.71508431e-01f, -2.43017375e-01f, -2.97555476e-01f, -1.70060053e-01f, -1.47916511e-01f, -2.33925208e-01f,
  1.96636826e-01f, -6.31602332e-02f, 1.12881288e-01f, 9.78252962e-02f, 5.71681149e-02f, -1.40737481e-02f, -2.43318416e-02f, 3.51836905e-02f, -3.13305743e-02f, -6.28343448e-02f,
  1.91844851e-02f, -2.79501663e-04f, 7.59916157e-02f, -1.72648430e-02f, 4.31677140e-02f, 1.14909850e-01f, 3.28580514e-02f, 4.29841429e-02f, -4.10953388e-02f, 7.26590827e-02f,
  6.19879216e-02f, 1.63324550e-02f, 1.56902894e-01f, 5.97028956e-02f, 4.95181270e-02f, -4.18392755e-03f, 2.01215148e-02f, 9.89075005e-02f, 5.11728749e-02f, 9.73530337e-02f,
  7.70687312e-02f, 1.53038695e-01f, -8.07044934e-03f, 3.88606600e-02f, 6.81269616e-02f, 9.55099538e-02f, -7.35514686e-02f, 4.40696366e-02f, 3.13822217e-02f, 3.03065423e-02f,
  2.01760828e-01f, 1.78212702e-01f, 1.65626675e-01f, 2.07972288e-01f, 6.45829588e-02f, -1.16501160e-01f, -2.48502389e-01f, -7.75295123e-02f, -5.58732869e-03f, 3.49964797e-02f,
  9.35642943e-02f, -7.25320950e-02f, 1.27254292e-01f, 1.40722264e-02f, -1.32073343e-01f, -8.04437101e-02f, -3.61059755e-02f, -3.20343561e-02f, -1.06354295e-04f, -2.30225831e-01f,
  1.33803368e-01f, 3.18297237e-01f, 1.77539870e-01f, 1.47231191e-01f, 1.30766541e-01f, 2.57258136e-02f, 1.35754913e-01f, -6.09081192e-03f, 1.28159001e-01f, 5.83353192e-02f,
  2.18284309e-01f, 9.87633690e-02f, 1.98446602e-01f, 2.08264306e-01f, 1.00659996e-01f, 4.78512906e-02f, 1.19932465e-01f, 1.09697998e-01f, 7.25284293e-02f, 1.84943095e-01f,
  1.41180903e-01f, 2.47098848e-01f, 9.60447937e-02f, 7.66573772e-02f, 1.28951281e-01f, 9.51488540e-02f, 7.66447410e-02f, -4.44238037e-02f, 1.06441438e-01f, -1.23899959e-01f,
  -2.85234600e-02f, -2.20385939e-01f, -1.60762146e-01f, -1.45795837e-01f, -1.51580334e-01f, -1.02073535e-01f, -1.72965273e-01f, -1.37602091e-01f, -1.16740502e-01f, -1.49181008e-01f,
  -6.80259243e-02f, -2.12279230e-01f, -1.72985524e-01f, -8.26659519e-03f, -6.88583106e-02f, -1.70689672e-01f, -1.00682817e-01f, -1.03130229e-01f, -4.08689715e-02f, -1.13607466e-01f,
  -6.26203343e-02f, -3.57005037e-02f, -1.30448058e-01f, -1.10112585e-01f, -4.05890420e-02f, -2.09700406e-01f, -1.74191803e-01f, -7.34256804e-02f, -1.87982082e-01f, -1.20432936e-01f,
  -3.89547721e-02f, 4.14189011e-01f, 5.64789586e-02f, 7.44625852e-02f, 1.45959258e-01f, -2.24051457e-02f, -7.56363571e-03f, 8.52081627e-02f, 6.79673105e-02f, 1.40239611e-01f,
  5.87207302e-02f, 1.16559923e-01f, 2.30949342e-01f, 2.10757345e-01f, 6.25558943e-02f, 1.13563143e-01f, 9.37435105e-02f, 1.78674515e-02f, 7.74973854e-02f, 3.47027965e-02f,
  4.41273069e-03f, 4.63174842e-02f, 6.68464005e-02f, -4.98383027e-03f, -2.06906367e-02f, 9.00032371e-02f, 6.53062537e-02f, -3.28326859e-02f, 2.47214306e-02f, -6.18388690e-02f,
  1.84037387e-01f, -7.65010789e-02f, 1.52547523e-01f, -1.03126824e-01f, 3.71516380e-03f, 8.27893540e-02f, 1.01077348e-01f, -3.70761417e-02f, -7.80838951e-02f, -5.12485877e-02f,
  -4.28817142e-03f, 1.04508303e-01f, 5.02929650e-02f, 2.10241139e-01f, 2.39412472e-01f, 1.93838120e-01f, 1.95272654e-01f, 3.04494709e-01f, 1.41022027e-01f, -5.05239796e-03f,
  1.94076542e-02f, -1.12169608e-01f, 1.05202161e-02f, -3.10577322e-02f, -2.04435736e-01f, -2.56842561e-02f, -1.09439246e-01f, -6.03609793e-02f, -7.62487110e-03f, 1.14940979e-01f,
  6.23774305e-02f, -6.61909208e-02f, 9.68860760e-02f, 1.14510190e-02f, -7.82127753e-02f, -5.00751026e-02f, -7.86492154e-02f, -1.38386220e-01f, -1.24723008e-02f, -8.01972225e-02f,
  -1.16751797e-01f, -5.65824583e-02f, 6.13937480e-03f, -1.52400419e-01f, -1.53123349e-01f, -4.56754938e-02f, -2.17629910e-01f, 6.04900084e-02f, -9.19251144e-02f, -4.11737598e-02f,
  -1.50177889e-02f, -3.35086690e-04f, -5.04061244e-02f, -1.21366322e-01f, -8.41819271e-02f, 3.54464985e-02f, -4.39379439e-02f, -1.56226218e-01f, -1.15372740e-01f, -1.75366208e-01f,
  -4.48810086e-02f, 3.13115865e-02f, 9.96685401e-02f, -5.10338880e-03f, 4.19738553e-02f, 3.92029397e-02f, 1.49938077e-01f, 1.07685126e-01f, -1.51584093e-02f, -3.04908715e-02f,
  1.10762365e-01f, 1.03329182e-01f, 1.09965213e-01f, 1.07473843e-01f, 1.76469628e-02f, 2.46045589e-02f, 5.63636459e-02f, 1.06013410e-01f, 4.96986844e-02f, 1.20741777e-01f,
  -3.84269245e-02f, 7.26290271e-02f, 4.45268564e-02f, 9.04499367e-02f, 1.18602395e-01f, 8.00839290e-02f, 1.10431239e-01f, 5.85930273e-02f, -5.04672015e-03f, 7.06666559e-02f,
  -3.39597106e-01f, 1.58492669e-01f, -1.76991615e-02f, 2.63649970e-02f, 2.32031345e-02f, -6.81757703e-02f, -3.22438567e-03f, 2.81160995e-02f, -1.09026231e-01f, -2.89517883e-02f,
  -6.39953986e-02f, -6.93524405e-02f, -7.34257624e-02f, -1.04042217e-01f, 4.47651744e-02f, -8.85537714e-02f, -2.01527551e-02f, -2.41567884e-02f, 7.52232224e-02f, -7.07800984e-02f,
  -5.75328059e-02f, -1.01387613e-01f, 1.15078673e-01f, -7.30082567e-04f, -9.95466113e-02f, 1.06348097e-01f, -3.01235784e-02f, -1.22915186e-01f, 4.68598343e-02f, -7.14301988e-02f,
  2.45559856e-01f, -8.32404047e-02f, 1.14199288e-01f, 8.92423932e-03f, 1.36351734e-01f, 3.53720069e-01f, 2.72749692e-01f, 2.45752171e-01f, 5.46191111e-02f, -7.57995062e-03f,
  8.10516179e-02f, -8.03465694e-02f, -6.78656027e-02f, 4.65505123e-02f, 1.66743323e-01f, 8.92308168e-03f, -1.27245575e-01f, 3.75907286e-03f, 2.68071562e-01f, 2.87396580e-01f,
  -1.60332080e-02f, -3.05909552e-02f, 1.69005126e-01f, 1.04931459e-01f, -3.17155898e-01f, -2.19494432e-01f, -9.31776762e-02f, -1.09433308e-01f, 4.06564996e-02f, -4.27006930e-01f,
  -8.89898613e-02f, 1.76084384e-01f, 6.01979010e-02f, -8.11199695e-02f, -6.97247609e-02f, 3.62746343e-02f, -4.68158349e-03f, -1.65334214e-02f, 3.29808481e-02f, 2.48921327e-02f,
  -3.72193046e-02f, 3.88897248e-02f, -8.03774670e-02f, -5.74654602e-02f, -1.69919301e-02f, -6.60682376e-03f, -7.43858814e-02f, -1.71267018e-02f, 7.88674131e-02f, 9.73315984e-02f,
  -4.42515984e-02f, -5.39792925e-02f, 1.11790486e-01f, 4.33645174e-02f, 1.37906492e-01f, 4.01107520e-02f, 6.98528439e-02f, 5.01070987e-04f, 1.61311090e-01f, -5.81620596e-02f,
  4.68945578e-02f, 1.12870328e-01f, 1.87274769e-01f, -3.57983820e-02f, 5.08384034e-02f, 6.49169693e-03f, -2.91912332e-02f, -7.36675560e-02f, 5.17058186e-02f, -6.00862652e-02f,
  8.58034194e-03f, 4.44477983e-02f, 3.78546305e-02f, 7.93508068e-02f, -3.90936397e-02f, 2.11679563e-02f, -3.22557501e-02f, -5.71232140e-02f, -3.81178446e-02f, 4.74780016e-02f,
  2.05606595e-02f, -3.27433087e-02f, -1.11143710e-02f, -3.91581953e-02f, 4.69702203e-03f, -1.74943861e-02f, -1.97591707e-02f, 9.95937455e-03f, -1.52000822e-02f, 1.09716609e-01f,
  -2.40033910e-01f, 7.23896772e-02f, -1.32435113e-01f, -5.96943684e-02f, 4.36258353e-02f, -4.38370183e-02f, -7.63559788e-02f, -6.72771186e-02f, -2.20314856e-03f, 1.86990239e-02f,
  5.89838885e-02f, 1.18116513e-02f, 4.74732667e-02f, 2.92295590e-02f, 4.80181873e-02f, 9.04757679e-02f, 5.21906205e-02f, 7.94105679e-02f, -1.20798700e-01f, 8.89458880e-03f,
  -4.89024930e-02f, 1.81711361e-01f, 7.40042478e-02f, 3.96236219e-02f, -3.66125368e-02f, 2.43839566e-02f, -1.33973006e-02f, -7.98264444e-02f, 2.19980568e-01f, 1.12724856e-01f,
  3.49288285e-01f, 1.20920241e-01f, 4.93621044e-02f, 3.67068082e-01f, 3.66242230e-01f, 2.16540098e-01f, 1.98453858e-01f, 1.44951552e-01f, 3.71706486e-02f, 1.43474042e-01f,
  1.01825692e-01f, 2.42313799e-02f, -8.88907164e-02f, -6.69178441e-02f, -9.31250155e-02f, 5.26666865e-02f, 2.09951505e-01f, 2.93350890e-02f, 1.20360799e-01f, 1.30639002e-01f,
  1.64430782e-01f, 1.82867840e-01f, 7.13848174e-02f, 2.75818836e-02f, 1.07265614e-01f, -5.37212379e-03f, 2.78784111e-02f, 1.49657249e-01f, 5.74020892e-02f, 1.86112538e-01f,
  1.35236263e-01f, 3.31726372e-01f, 4.79125567e-02f, -3.77470069e-02f, 5.80279790e-02f, 2.00832132e-02f, 1.54474020e-01f, 2.91954763e-02f, 3.64960916e-02f, -6.56460924e-03f,
  9.84813944e-02f, 3.00488416e-02f, 1.52461037e-01f, -2.11027469e-02f, 5.96254282e-02f, 2.46783029e-02f, 2.10401528e-02f, 1.15750469e-01f, 4.92581399e-03f, -6.32866323e-02f,
  9.13431644e-02f, 9.40553844e-02f, 1.96537733e-01f, -4.07607369e-02f, 1.94116607e-02f, -2.30235402e-02f, -5.85904084e-02f, 3.72059941e-02f, -1.02814078e-01f, 2.83897482e-02f,
  6.53685704e-02f, -6.98096082e-02f, 6.96196854e-02f, -3.17942380e-04f, 5.74122481e-02f, 1.18197715e-02f, 3.37570235e-02f, 1.20816909e-01f, -2.90816259e-02f, 4.06865515e-02f,
  1.10133691e-02f, 2.35873982e-02f, 7.82312378e-02f, 3.33631448e-02f, 5.60150705e-02f, 1.43306449e-01f, 5.28962240e-02f, 1.86933167e-02f, -7.69992843e-02f, 9.84510221e-03f,
  6.17556833e-02f, 1.16917171e-01f, 1.27572820e-01f, 5.10381302e-03f, 9.33603570e-02f, 1.53412309e-03f, 1.23053856e-01f, 1.01903640e-02f, 2.90082581e-02f, 9.64019895e-02f,
  -5.44159263e-02f, 4.52814682e-04f, -1.91054377e-03f, -6.76244497e-03f, 8.39082450e-02f, -7.14467838e-02f, 1.27742086e-02f, 1.45794541e-01f, 6.81682825e-02f, 5.16791493e-02f,
  2.08541322e-02f, -1.45822931e-02f, -7.06001185e-03f, 6.05044328e-02f, -5.48560023e-02f, 1.04375660e-01f, -1.89487182e-03f, 1.90216210e-02f, -7.03893527e-02f, -8.47705007e-02f,
  2.91215349e-02f, 6.05198629e-02f, 1.14866391e-01f, -9.50682350e-03f, 1.19635172e-01f, 1.98588241e-02f, 7.39385933e-02f, 4.37889248e-02f, 7.22895116e-02f, -1.46895275e-02f,
  -4.04637158e-01f, -2.02402696e-02f, 1.39648076e-02f, -2.52354711e-01f, -5.01307473e-02f, 8.60487744e-02f, 3.50752175e-01f, 1.23953722e-01f, -1.90754458e-01f, -6.75424784e-02f,
  -2.24081948e-01f, -1.12841144e-01f, -1.06158391e-01f, -1.43654183e-01f, 8.76652896e-02f, 1.40534952e-01f, 1.16128534e-01f, 9.35407472e-04f, 9.96797755e-02f, 1.08508892e-01f,
  4.24837880e-02f, -9.29261297e-02f, -2.34102920e-01f, -1.15679622e-01f, -3.02413362e-03f, -2.35149991e-02f, -9.18858591e-03f, -1.14129648e-01f, -1.06445283e-01f, -9.25773159e-02f,
  -7.93360993e-02f, -1.03199616e-01f, -1.83844063e-02f, -2.10025519e-01f, -5.75613827e-02f, -5.12311272e-02f, -6.84674233e-02f, -1.23304538e-01f, -1.45595163e-01f, -4.02897596e-02f,
  -1.32603183e-01f, -1.17629394e-01f, -9.27903652e-02f, -3.23228464e-02f, -1.73862148e-02f, -1.97288282e-02f, -9.69618559e-02f, -3.20667811e-02f, 2.03406196e-02f, -3.51672526e-03f,
  -3.77310403e-02f, -1.22785822e-01f, -5.12740463e-02f, 1.61410514e-02f, -7.33389407e-02f, -3.19896787e-02f, -8.38524550e-02f, -1.02168404e-01f, -6.68638423e-02f, -2.16912124e-02f,
  8.06448534e-02f, 1.62660182e-01f, 5.55806682e-02f, 1.10122599e-01f, 1.38979420e-01f, 7.63916224e-02f, 2.79364940e-02f, 8.77975896e-02f, 2.56480128e-01f, 6.87484816e-02f,
  -1.72094302e-03f, 2.44141862e-01f, 3.58282514e-02f, 1.05574921e-01f, 1.22245796e-01f, 1.76874399e-01f, 4.99559641e-02f, 6.33815899e-02f, 9.68077630e-02f, 1.46487266e-01f,
  2.13708043e-01f, 1.07365839e-01f, 1.12246081e-01f, 2.84781829e-02f, 1.25136226e-01f, 1.50222942e-01f, 1.11099049e-01f, 1.46623343e-01f, 1.10684879e-01f, -1.05317088e-03f,
  -1.59823343e-01f, -1.00252673e-01f, 2.12878343e-02f, 1.68427429e-03f, -1.08396374e-01f, -7.62473494e-02f, 2.95196543e-03f, 5.73306046e-02f, -2.23617791e-03f, 4.69917580e-02f,
  -4.31056432e-02f, -1.08136579e-01f, -1.42876968e-01f, -8.97148848e-02f, -2.89097559e-02f, -1.03857890e-01f, 5.74273132e-02f, -2.56876964e-02f, -6.77759871e-02f, 1.96394343e-02f,
  5.63317426e-02f, 7.77119100e-02f, 1.40258178e-01f, 1.12357929e-01f, 8.76943395e-02f, 1.16590932e-01f, 9.23777744e-02f, 1.35472521e-01f, 8.36663786e-03f, 4.44107763e-02f,
  -1.45531312e-01f, -6.53509870e-02f, -2.25232244e-02f, 1.13385327e-01f, -8.89800265e-02f, -1.41465977e-01f, -1.97164819e-01f, -5.98726161e-02f, 1.50348872e-01f, -8.82761478e-02f,
  8.57691467e-02f, 1.50902897e-01f, 2.43043587e-01f, 1.00722730e-01f, 3.38669904e-02f, -8.92717838e-02f, -1.15640908e-01f, -9.09172744e-02f, 3.17290761e-02f, 1.02060512e-01f,
  5.43991402e-02f, 7.55999610e-02f, 1.50831277e-02f, 1.28040202e-02f, -1.71230704e-01f, -4.23505493e-02f, -1.52331129e-01f, -1.52160719e-01f, -5.78220598e-02f, -4.46283013e-01f,
  6.84098452e-02f, -4.35672328e-02f, -8.27969925e-04f, -3.73538733e-02f, 1.04824007e-02f, 2.29594726e-02f, 4.65199165e-02f, 6.68466315e-02f, 6.13736808e-02f, 1.46389216e-01f,
  -7.62785040e-03f, 5.80149069e-02f, 8.18527341e-02f, 7.26972073e-02f, 1.46279270e-02f, 8.00311416e-02f, -4.72162524e-03f, 1.80640638e-01f, 3.74646559e-02f, 1.14920534e-01f,
  1.27021894e-01f, 6.17034286e-02f, -1.71190295e-02f, 9.37842950e-02f, 4.03926633e-02f, 1.20060638e-01f, -1.24786995e-01f, -1.40745133e-01f, -5.94837926e-02f, -2.02993572e-01f,
  -8.91827792e-02f, 2.87936032e-02f, -9.06361267e-02f, -1.58077016e-01f, -9.02523473e-02f, 1.04112504e-02f, 5.77120446e-02f, 1.39311068e-02f, 5.61930053e-02f, 7.65495673e-02f,
  8.29054266e-02f, 4.23493087e-02f, 1.04912318e-01f, 3.95884886e-02f, -1.04168564e-01f, -2.26347670e-02f, -1.74108502e-02f, -1.96177363e-02f, -1.31622879e-02f, 1.88915450e-02f,
  3.30642015e-02f, -1.36860022e-02f, 5.51364617e-03f, -4.06083055e-02f, -7.15922117e-02f, -3.31836119e-02f, 4.89365570e-02f, 1.24243021e-01f, 1.21449500e-01f, 8.51198733e-02f,
  2.84627557e-01f, 1.18708305e-01f, 2.84549128e-03f, -5.20905247e-03f, 3.32006030e-02f, 3.05431634e-02f, 9.93043557e-02f, 8.52644220e-02f, 3.18266265e-02f, -5.00363782e-02f,
  2.17494406e-02f, 4.44114618e-02f, 6.39247298e-02f, 8.60391036e-02f, 7.75626004e-02f, 6.31885976e-02f, 2.34886836e-02f, 1.42982351e-02f, 2.55634766e-02f, -2.29679216e-02f,
  6.74119173e-03f, -5.46325883e-03f, -4.23296578e-02f, -7.31566027e-02f, 1.93736739e-02f, -1.03858307e-01f, -2.40897425e-02f, -1.19462311e-01f, -6.81368783e-02f, -1.96936622e-01f,
  -7.28573322e-01f, 2.38308646e-02f, -1.32703558e-01f, 3.71594690e-02f, 2.21272647e-01f, 1.07301705e-01f, -1.90987792e-02f, 5.30093797e-02f, 1.51819766e-01f, 4.15038131e-02f,
  1.69154227e-01f, 1.49430782e-01f, 1.71158805e-01f, 1.41063541e-01f, -6.42817467e-02f, -2.05055159e-02f, 1.73948556e-01f, 3.93649749e-02f, -1.37669789e-02f, 1.17924837e-02f,
  3.30467105e-01f, 8.17991644e-02f, -4.93010506e-02f, 6.45611361e-02f, 1.05491124e-01f, 2.12120086e-01f, 6.65477440e-02f, 1.80077001e-01f, 6.05696253e-02f, 6.95941001e-02f,
  -1.16484232e-01f, -7.19132721e-02f, 1.62078038e-01f, 2.05842450e-01f, 2.08966047e-01f, 7.21500814e-02f, 7.92717636e-02f, 1.01716280e-01f, 2.31849775e-01f, 6.86961412e-02f,
  1.40019089e-01f, 1.73968419e-01f, 1.37711182e-01f, 2.37416059e-01f, 3.24081071e-02f, 1.10878006e-01f, 9.97729599e-02f, -3.35702635e-02f, 1.00048378e-01f, 5.69906682e-02f,
  2.87014365e-01f, 1.01897746e-01f, 7.06983507e-02f, 1.43016145e-01f, 1.08822986e-01f, 1.45523086e-01f, 1.23957895e-01f, 1.41579693e-03f, -7.47542083e-02f, -2.47962680e-02f,
  8.90046731e-02f, -9.50571075e-02f, -6.07398935e-02f, -1.57541364e-01f, 3.33337970e-02f, 1.24449292e-02f, -2.18551923e-02f, -7.47321844e-02f, -6.06523231e-02f, -1.39421836e-01f,
  -1.19979508e-01f, -7.41495341e-02f, -9.60659049e-03f, -6.71923831e-02f, -5.97200952e-02f, -2.72903424e-02f, -9.22364816e-02f, -1.08493268e-01f, -1.00958191e-01f, -1.08548626e-01f,
  -8.20294097e-02f, -2.44630650e-02f, -1.41073356e-03f, -1.26970438e-02f, -8.61103758e-02f, -5.08405678e-02f, -1.62915468e-01f, -2.10969672e-02f, -2.37098280e-02f, -1.12394981e-01f,
  8.50328952e-02f, 9.94961243e-04f, -5.43465391e-02f, 7.48599395e-02f, 5.74817583e-02f, 1.35739610e-01f, 1.08925492e-01f, 4.99440506e-02f, 5.07755354e-02f, -4.26238962e-02f,
  3.43916789e-02f, -4.51637693e-02f, 5.24755055e-03f, 4.78253216e-02f, 3.20438616e-04f, 9.99814831e-04f, 4.20547947e-02f, 1.00710705e-01f, 1.60549860e-02f, 2.01378465e-01f,
  1.49599388e-01f, -3.20958383e-02f, 6.95173070e-02f, 1.18003353e-01f, 1.18821345e-01f, -1.52317313e-02f, 5.95706329e-02f, -5.87436818e-02f, -3.27684619e-02f, 2.55906135e-02f,
  1.33207202e-01f, 3.08255047e-01f, 5.20463772e-02f, 6.56426921e-02f, -1.76314205e-01f, -1.98509172e-01f, 6.14276677e-02f, 4.74487320e-02f, -1.43271565e-01f, 1.93168953e-01f,
  4.73682322e-02f, -1.72027990e-01f, -1.50830648e-03f, 1.43534550e-02f, -6.52188361e-02f, 1.03061683e-01f, 1.77306563e-01f, -5.36446199e-02f, -3.39905977e-01f, -1.88380867e-01f,
  4.93141450e-02f, -5.24056889e-03f, -8.20922777e-02f, -7.26935046e-04f, 1.02256745e-01f, -3.37122791e-02f, 1.41418070e-01f, 5.98473921e-02f, 1.36704564e-01f, 4.28925514e-01f,
  -5.78213809e-03f, 1.14441715e-01f, -1.20727696e-01f, 1.25917077e-01f, -7.33360499e-02f, -5.57731390e-02f, -1.05092809e-01f, 1.63186625e-01f, 4.01361696e-02f, 1.14423089e-01f,
  4.15484309e-02f, 1.06955513e-01f, -5.04968315e-02f, 6.64427355e-02f, -7.49627799e-02f, -6.26163930e-02f, -1.62854530e-02f, 5.89267462e-02f, -5.07717542e-02f, -5.79282409e-03f,
  1.61297768e-01f, -3.38392854e-02f, 8.57217908e-02f, 6.71450645e-02f, 1.74651463e-02f, -1.49218440e-02f, 6.72378764e-02f, -8.64075497e-02f, -1.63468104e-02f, 1.35850251e-01f,
  -1.81759819e-02f, -2.91365124e-02f, -1.00213513e-01f, -5.44018894e-02f, 7.05257012e-03f, -5.86243793e-02f, 1.18837943e-02f, 7.62760825e-03f, -1.98241509e-02f, -9.07478482e-03f,
  -7.13525712e-02f, -2.22533033e-03f, 7.29701370e-02f, -1.56669579e-02f, 2.21546832e-02f, 5.87506779e-02f, 6.00768402e-02f, 4.55666333e-02f, -3.47034074e-02f, 8.09282660e-02f,
  -4.90897000e-02f, 2.01828536e-02f, -1.39454929e-02f, -9.79143381e-03f, 1.60711613e-02f, -3.74346301e-02f, 2.80398317e-02f, -5.43360179e-03f, 7.05645084e-02f, -9.01115127e-03f,
  -1.41605422e-01f, -2.10222647e-01f, -9.33083668e-02f, 4.49969098e-02f, -2.29826737e-02f, 1.48296077e-02f, -4.79930826e-02f, -2.19984981e-03f, 7.27477903e-03f, -5.39034698e-03f,
  -7.08007738e-02f, -8.31108019e-02f, 1.80530157e-02f, 3.36661339e-02f, -1.86269134e-01f, -1.50146708e-02f, 3.21718864e-02f, -1.29641742e-01f, -6.50422275e-02f, -9.92351770e-02f,
  8.59502628e-02f, -1.72894865e-01f, -4.56297025e-02f, -6.65576383e-02f, -7.00879991e-02f, -2.48007163e-01f, -5.14591709e-02f, -8.38534459e-02f, -1.75208211e-01f, -8.23196098e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.18327567e-01f, 9.68311802e-02f, -5.84812880e-01f, 7.03081489e-03f, -2.64982283e-01f, -1.18884757e-01f, -1.74258530e-01f, 1.42893136e-01f, 1.07212208e-01f, -7.51034021e-02f,
  9.66880172e-02f, 1.77177459e-01f, 1.46345899e-01f, 7.19702663e-03f, 5.57627231e-02f, -2.69680262e-01f, -3.50307316e-01f, -2.02218175e-01f, 5.37524447e-02f, 1.41675910e-02f,
  -1.02650203e-01f, -1.79859065e-02f, 4.32165526e-02f, -3.26677151e-02f, -1.95873678e-01f, -1.11000270e-01f, -2.66750872e-01f, -2.26944476e-01f, -3.26222748e-01f, -5.37800193e-01f,
  -9.73775834e-02f, -7.83685446e-02f, 7.62714446e-02f, -5.31855151e-02f, -2.93808021e-02f, 1.27221063e-01f, -1.69329736e-02f, -9.22945049e-03f, 5.06343208e-02f, -2.40407754e-02f,
  -5.12655219e-03f, 7.03654066e-02f, 2.63657924e-02f, 8.74348804e-02f, -4.06549200e-02f, 2.08625104e-02f, -1.74119964e-03f, -9.55812261e-02f, -1.22161381e-01f, -8.23446661e-02f,
  -6.62128208e-03f, -8.45001116e-02f, 4.21455465e-02f, 8.46886188e-02f, 1.60673663e-01f, 8.27598050e-02f, -2.50477549e-02f, -6.00601770e-02f, -9.73717570e-02f, 4.87180986e-03f,
  -8.92513692e-02f, 1.20925531e-01f, 8.27756897e-02f, 8.51451755e-02f, 2.11703584e-01f, 2.32878059e-01f, 6.88084811e-02f, 2.06191704e-01f, 2.09510162e-01f, 7.81684965e-02f,
  1.37369588e-01f, -6.51569963e-02f, 2.15863176e-02f, -2.51526409e-03f, -5.65668084e-02f, -4.33607884e-02f, 3.60059887e-02f, 7.20338151e-02f, -3.27012278e-02f, 9.64391511e-03f,
  9.25252587e-02f, 2.81419288e-02f, -8.51083323e-02f, 2.85838209e-02f, -7.50426352e-02f, -8.98476616e-02f, -1.37252778e-01f, -4.42192368e-02f, 2.88142283e-02f, -7.28081241e-02f,
  2.21688151e-01f, -1.51898652e-01f, 1.12665474e-01f, 8.03653672e-02f, -1.13490127e-01f, -6.59614727e-02f, 4.29654345e-02f, -3.79270799e-02f, -1.09653853e-01f, 1.51727498e-02f,
  9.81500447e-02f, 1.54093340e-01f, 1.61728561e-01f, 1.09758936e-01f, 2.21302584e-01f, -8.79785698e-03f, 1.29479453e-01f, 4.76611033e-02f, -8.39121938e-02f, -4.03554402e-02f,
  1.27234623e-01f, 1.29565895e-01f, 2.13684261e-01f, 2.75636941e-01f, 9.99286845e-02f, 1.56336218e-01f, 1.60056710e-01f, 1.33190885e-01f, -5.40771447e-02f, 2.98666060e-01f,
  -3.47147942e-01f, -2.65205562e-01f, -1.09338410e-01f, -2.08897129e-01f, -1.74946487e-01f, 4.62607406e-02f, -9.23170671e-02f, -1.41090434e-02f, -3.49071287e-02f, -3.07210326e-01f,
  -1.58288732e-01f, -9.23317596e-02f, -3.63150053e-02f, 8.42809528e-02f, 4.73336689e-03f, -2.67680943e-01f, -1.72172442e-01f, -6.25116974e-02f, 1.02486022e-01f, 1.28193036e-01f,
  -8.50086585e-02f, -2.36563489e-01f, 7.75126591e-02f, 3.77374329e-02f, -1.72881931e-01f, -2.65284330e-01f, -3.83919328e-01f, -2.44684637e-01f, -1.50343269e-01f, -4.62965518e-01f,
  -2.58925438e-01f, -9.46907401e-02f, 5.02370186e-02f, 7.98947215e-02f, -7.52277076e-02f, 1.76366251e-02f, 5.59430607e-02f, 1.70175936e-02f, 1.07299291e-01f, 7.62117980e-03f,
  2.50051934e-02f, 6.53804168e-02f, -9.07383934e-02f, 1.09911235e-02f, 2.11270452e-02f, 5.47688920e-03f, -1.04021877e-01f, 9.26741287e-02f, -2.03100946e-02f, 9.69377309e-02f,
  -1.47621520e-02f, -1.49023319e-02f, -2.97823418e-02f, 2.89969090e-02f, 6.91796169e-02f, -1.04515336e-03f, -8.27558525e-03f, 1.02719590e-01f, 6.09342717e-02f, -2.42593765e-01f,
  -4.25828584e-02f, 4.33599995e-03f, 6.64956644e-02f, 5.32350615e-02f, 5.02857082e-02f, 1.14319474e-01f, 5.22191450e-02f, 3.22426558e-02f, -9.60603431e-02f, 1.16325254e-02f,
  1.07360044e-02f, -1.19870476e-01f, 3.12881768e-02f, -8.86253715e-02f, -4.04252596e-02f, -3.91928218e-02f, -2.15405095e-02f, -1.71746574e-02f, 9.75321606e-02f, -2.18294542e-02f,
  -9.07979310e-02f, 5.38230985e-02f, -1.90653205e-02f, -2.93007176e-02f, 2.25602277e-02f, 2.00023632e-02f, -1.40123218e-01f, -2.22604867e-04f, -6.10514581e-02f, -2.47962903e-02f,
  -2.56908715e-01f, 3.88608836e-02f, -7.58876503e-02f, 6.10178858e-02f, 4.38580429e-03f, 7.99872056e-02f, -1.29754007e-01f, -1.32395387e-01f, -1.09449387e-01f, -1.30584374e-01f,
  1.39820427e-02f, -5.82117066e-02f, -6.86938316e-02f, 6.20177276e-02f, -2.72583440e-02f, -3.15299667e-02f, -8.18768665e-02f, -6.65147901e-02f, 1.34236485e-01f, 1.78138062e-01f,
  1.11344546e-01f, 1.13548391e-01f, 4.12571430e-02f, -5.87159283e-02f, 8.09749514e-02f, -8.98209959e-03f, -1.38882473e-01f, -4.43948470e-02f, -1.72081694e-03f, -1.38946876e-01f,
  5.47613740e-01f, -2.10688666e-01f, -1.31198719e-01f, 1.38002783e-01f, -7.63331205e-02f, -2.14417756e-01f, -4.32648540e-01f, -2.69838095e-01f, -8.44776928e-02f, 1.47891724e-02f,
  6.20658472e-02f, 3.33732218e-01f, 2.47263983e-01f, 2.75233001e-01f, 1.36034582e-02f, -4.93707508e-02f, 9.12082270e-02f, 2.44338542e-01f, 1.08990401e-01f, 1.08304076e-01f,
  5.99608151e-03f, 3.53867225e-02f, 1.83516532e-01f, 1.61517382e-01f, 7.92867094e-02f, 1.47216186e-01f, 7.31908306e-02f, 9.19740126e-02f, 6.71086237e-02f, 3.36522877e-01f,
  5.45671862e-03f, 1.79468300e-02f, 1.96793288e-01f, 1.51474729e-01f, -3.00489198e-02f, 6.33802265e-02f, -3.55785340e-02f, -6.13570064e-02f, 4.76000495e-02f, -1.16642021e-01f,
  4.96673137e-02f, 4.09903154e-02f, 6.80283681e-02f, -6.48287460e-02f, -1.12189583e-01f, -1.32005051e-01f, -2.51330752e-02f, -5.40759489e-02f, -4.78550680e-02f, -1.14002988e-01f,
  5.94657026e-02f, 1.10344328e-02f, -1.18547909e-01f, -1.18939936e-01f, -1.96180008e-02f, 2.37122208e-01f, 7.45774880e-02f, 1.28418043e-01f, -2.05594972e-02f, 9.52985808e-02f,
  2.99425900e-01f, 7.43776262e-02f, 1.30288238e-02f, -2.75210049e-02f, 8.92570466e-02f, -1.15032956e-01f, -2.39979122e-02f, -7.84679689e-03f, 1.62721753e-01f, 7.07284808e-02f,
  -2.72044949e-02f, -3.90204415e-02f, -6.35760203e-02f, -1.47385225e-01f, 3.47930379e-02f, 4.76842858e-02f, -9.78122726e-02f, -1.34990942e-02f, 9.11301468e-03f, 4.17585820e-02f,
  2.87262518e-02f, 1.08303353e-02f, 6.12358795e-03f, -6.77085295e-02f, -2.65350807e-02f, 3.96902598e-02f, -3.88730248e-03f, 4.87569161e-02f, 3.48232798e-02f, 7.95059055e-02f,
  -5.41730702e-01f, 1.00018688e-01f, 2.63677120e-01f, 1.73338771e-01f, 6.49415925e-02f, 1.08369596e-01f, 1.74230590e-01f, 1.31350771e-01f, 3.20238173e-02f, -1.03584372e-01f,
  -1.09491564e-01f, 3.74744236e-02f, -4.14613225e-02f, -1.68013517e-02f, -4.46046097e-03f, 2.19780370e-03f, 1.14386551e-01f, 1.44995451e-01f, -1.97187215e-02f, -9.54333693e-02f,
  -6.17552549e-02f, -1.89743474e-01f, -1.58940673e-01f, -1.83476508e-01f, 5.93900084e-02f, 1.60642728e-01f, -5.93728833e-02f, -1.27833068e-01f, -1.06652655e-01f, -1.93497583e-01f,
  -1.43770397e-01f, 3.41658434e-03f, -1.93875998e-01f, 1.62820786e-01f, -4.57249209e-02f, -3.58740628e-01f, -5.31218410e-01f, -2.58278459e-01f, 7.64216110e-02f, 2.15087477e-02f,
  1.91828492e-03f, -2.99347118e-02f, -7.98593101e-04f, -2.99664199e-01f, -4.67239469e-01f, -1.83933854e-01f, -8.28255638e-02f, -4.17947322e-01f, -5.22207141e-01f, -2.59706855e-01f,
  -8.36549997e-02f, -1.44171998e-01f, -2.54994392e-01f, -1.29656717e-01f, 3.54999334e-01f, 6.49834871e-02f, -6.26927018e-02f, -1.33722639e-02f, -4.94562089e-02f, 1.77878395e-01f,
  1.35294795e-01f, 1.83284253e-01f, -8.47231969e-02f, 4.73867171e-04f, 2.55373746e-01f, 2.99228299e-02f, 1.58485491e-02f, 5.32154404e-02f, 7.15559721e-02f, 1.55469656e-01f,
  9.05658901e-02f, 9.16963220e-02f, -1.74654797e-02f, 1.54897481e-01f, 1.03879303e-01f, 4.63243984e-02f, 2.34259516e-01f, -4.16633748e-02f, -7.34465569e-02f, 2.08656818e-01f,
  1.70891017e-01f, 2.75624972e-02f, 4.37235683e-02f, -5.54001331e-02f, -9.01282392e-03f, 1.05839603e-01f, 4.41458076e-02f, 6.23563416e-02f, -4.77823652e-02f, 1.68215424e-01f,
  7.47476565e-03f, 1.45287275e-01f, -5.40959835e-03f, 1.43267764e-02f, -6.46439269e-02f, -9.62116662e-03f, -1.37824461e-01f, -7.20364600e-02f, -1.07801668e-01f, -1.84517987e-02f,
  8.82908553e-02f, 8.42544138e-02f, 5.46198264e-02f, -4.34487127e-02f, 4.66533415e-02f, -1.59587767e-02f, -1.12450950e-01f, -8.86580944e-02f, -9.04043391e-03f, 9.18504745e-02f,
  -2.78898701e-03f, 6.75864220e-02f, 1.08806796e-01f, 2.22483114e-03f, -2.69317888e-02f, -5.64946756e-02f, 1.24027625e-01f, -1.50538981e-02f, 1.04518449e-02f, -1.90129541e-02f,
  2.18384072e-01f, -3.25982422e-01f, 1.30922198e-02f, 1.24584541e-01f, 1.37852401e-01f, 1.18036523e-01f, 1.12500772e-01f, 1.89488176e-02f, 4.99329381e-02f, 1.94524214e-01f,
  9.49836709e-03f, -2.24069171e-02f, -7.21838996e-02f, -2.32225247e-02f, -1.05865225e-01f, 1.03880063e-01f, 1.39601469e-01f, -1.30249381e-01f, -1.33970842e-01f, 2.55770355e-01f,
  -5.32394722e-02f, -9.00031552e-02f, -1.50071502e-01f, -1.21430218e-01f, -2.08435003e-02f, -5.75646684e-02f, -2.15249434e-02f, 4.61544320e-02f, -2.25186169e-01f, -1.62635878e-01f,
  2.02542674e-02f, -1.49185851e-01f, 2.24162936e-02f, 1.14454247e-01f, -1.90596029e-01f, -9.32025984e-02f, -4.01933312e-01f, -6.90508783e-02f, -1.52383391e-02f, -3.68544340e-01f,
  -3.17481607e-01f, 2.96501797e-02f, -8.56014267e-02f, 2.10758764e-02f, -2.94854380e-02f, -3.62987906e-01f, -1.21403389e-01f, 1.83271527e-01f, 2.56105542e-01f, -1.15932085e-01f,
  -1.53534502e-01f, 1.14025101e-01f, 2.39637882e-01f, 2.35052615e-01f, -1.29130632e-01f, 9.09115970e-02f, 9.80659127e-02f, 1.29172668e-01f, -1.21236198e-01f, -8.80380198e-02f,
  -3.09863150e-01f, -9.82996896e-02f, -9.38868672e-02f, 3.43873985e-02f, -1.19742103e-01f, -2.73588896e-02f, -2.17364639e-01f, 1.85221866e-01f, -2.01127306e-02f, -5.89917488e-02f,
  -1.37747541e-01f, -2.33417600e-01f, 1.87313184e-01f, 1.33211195e-01f, 1.69882141e-02f, -3.93923894e-02f, 5.49169257e-02f, 5.94201162e-02f, 4.57028970e-02f, -5.39877340e-02f,
  -6.17765523e-02f, 2.95018051e-02f, -8.86827782e-02f, 1.58408750e-02f, 5.91438031e-03f, 9.11074504e-02f, -1.61106944e-01f, 3.79873216e-02f, 1.45486861e-01f, -9.86903161e-02f,
  6.87513351e-02f, -1.52659006e-02f, 5.25870509e-02f, -1.75557688e-01f, -1.62383039e-02f, 9.65368822e-02f, -2.34183564e-04f, 1.08903654e-01f, -1.89087633e-02f, -1.24370102e-02f,
  4.94430661e-02f, 5.19353375e-02f, 7.24305585e-02f, -7.06358701e-02f, 7.60861039e-02f, 1.11405082e-01f, -6.25887439e-02f, -1.00553907e-01f, 4.79986742e-02f, -5.07715866e-02f,
  1.34305760e-01f, 1.63857192e-01f, 7.76723027e-02f, 1.60339579e-01f, -7.07236072e-03f, 4.18020003e-02f, -7.34087899e-02f, -1.14086017e-01f, 5.21871150e-02f, -5.60256317e-02f,
  7.66675640e-03f, -9.03008953e-02f, -3.72447044e-01f, 2.72759632e-03f, 2.42321026e-02f, -1.22768968e-01f, -9.85058248e-02f, -3.34422849e-02f, 1.83107890e-02f, -1.14436641e-01f,
  -1.75420880e-01f, -7.22601116e-02f, 8.72954577e-02f, -7.47390976e-03f, 1.68024283e-02f, -1.30999058e-01f, -2.56127328e-01f, -1.02558576e-01f, 4.81276438e-02f, -1.41108051e-01f,
  2.02565044e-01f, -7.02154338e-02f, -2.16585055e-01f, -3.84706184e-02f, -9.91823301e-02f, 2.30362657e-02f, -1.02661759e-01f, 3.06077320e-02f, 3.94534618e-02f, -3.66424806e-02f,
  5.07102489e-01f, 1.68460965e-01f, 3.70526671e-01f, 3.38169903e-01f, 2.81158954e-01f, 1.63812861e-01f, 7.10289553e-02f, 6.34108335e-02f, -9.89415031e-03f, 6.81329966e-02f,
  6.01098724e-02f, -2.02459041e-02f, 2.01652162e-02f, -8.68608803e-02f, 4.41193730e-02f, -6.94886297e-02f, -1.46843463e-01f, 1.02995187e-01f, 5.69410995e-02f, 1.00063324e-01f,
  -5.65459691e-02f, -9.69012454e-02f, -1.16064139e-01f, -9.75795388e-02f, -9.71589610e-02f, -9.66406241e-02f, -5.76332472e-02f, 1.46987168e-02f, -8.67416933e-02f, -6.82678148e-02f,
  1.41336367e-01f, 2.55532861e-01f, -1.85818095e-02f, 1.55042969e-02f, -2.05035564e-02f, -2.89274543e-03f, 1.78198610e-02f, 1.47529677e-01f, 4.26288275e-03f, 8.30672979e-02f,
  9.18393955e-02f, -1.29452450e-02f, -6.40359521e-02f, -3.65630798e-02f, 4.71935607e-02f, 5.53534590e-02f, 5.12916520e-02f, -2.03985982e-02f, 1.56521752e-01f, -4.89400551e-02f,
  -1.08207993e-01f, 1.49963930e-01f, 8.60702917e-02f, 7.92581066e-02f, 7.09637254e-02f, 8.29337463e-02f, 1.35995522e-01f, 8.98752958e-02f, 4.56893370e-02f, -4.96488474e-02f,
  1.46335103e-02f, 1.05716996e-02f, 2.08457503e-02f, 1.77780930e-02f, -5.59528954e-02f, 6.53790683e-02f, 7.97631070e-02f, -4.35767844e-02f, -4.53787968e-02f, -1.22178160e-01f,
  -3.29910778e-02f, 6.94185197e-02f, 1.39551848e-01f, 7.70331472e-02f, -2.59535648e-02f, 7.62653500e-02f, 3.47515830e-04f, 7.04783052e-02f, 5.95302396e-02f, -5.53014055e-02f,
  7.56531060e-02f, -4.09364514e-02f, 4.72878441e-02f, -6.65819496e-02f, 2.46450864e-02f, -1.31673571e-02f, 4.33052070e-02f, -3.44542637e-02f, -1.29852474e-01f, -9.52506736e-02f,
  1.50524780e-01f, 1.40156746e-01f, -8.53369161e-02f, -5.71379066e-02f, 2.94966362e-02f, 9.96585786e-02f, 1.99367702e-01f, 1.94964379e-01f, 6.12015240e-02f, 6.52749315e-02f,
  2.42326185e-02f, 7.90638030e-02f, 7.06606954e-02f, -1.05958603e-01f, -1.22630157e-01f, 8.17188099e-02f, 2.55803857e-02f, 5.57447113e-02f, 9.88059714e-02f, 9.34063047e-02f,
  -3.96477878e-02f, 1.24270156e-01f, 2.44619027e-02f, 1.11023918e-01f, -2.75275554e-03f, 8.44201297e-02f, 8.59612375e-02f, -4.32957597e-02f, 2.89346185e-02f, -6.08475767e-02f,
  -3.55941802e-01f, 2.41332769e-01f, 2.43496463e-01f, -3.61062199e-01f, 1.45442560e-01f, 2.39591986e-01f, 3.22283119e-01f, 4.77554798e-02f, -8.94374996e-02f, 9.12951529e-02f,
  -1.19862771e-02f, -2.35022008e-01f, -2.07295254e-01f, -1.28280923e-01f, 3.39387022e-02f, 6.40755445e-02f, -4.87835705e-02f, -1.75192237e-01f, -1.91804036e-01f, -1.66897923e-02f,
  5.54410443e-02f, -2.50563085e-01f, -2.72672504e-01f, -1.34903207e-01f, -2.36408859e-01f, -4.30016279e-01f, -9.13200676e-02f, -8.76450613e-02f, 1.88064858e-01f, -2.03122526e-01f,
  -6.15972392e-02f, 1.87183112e-01f, 7.31794089e-02f, -1.19097836e-01f, 1.44387921e-02f, 3.14388461e-02f, -1.14980778e-02f, -3.91624719e-02f, -3.19742933e-02f, 5.16029038e-02f,
  -5.48195429e-02f, -9.64256353e-04f, -1.24467038e-01f, -7.20116943e-02f, -5.44101298e-02f, 6.12458363e-02f, -4.17223945e-03f, 2.31188592e-02f, 9.37020555e-02f, 1.72096789e-01f,
  1.27225518e-01f, 8.35414305e-02f, 2.58897871e-01f, 2.21310452e-01f, 1.93098083e-01f, 1.80674940e-01f, 1.84824273e-01f, 9.23823267e-02f, 1.42210782e-01f, -1.60810933e-01f,
  -9.95038003e-02f, -5.85625358e-02f, 5.89788817e-02f, 8.93491507e-02f, -2.31994782e-02f, 4.44679745e-02f, -1.48058489e-01f, 3.39615792e-02f, -1.01396725e-01f, -8.69517699e-02f,
  1.31381050e-01f, 1.01994745e-01f, -5.03256880e-02f, -6.98957741e-02f, -1.26440555e-01f, -6.02295846e-02f, -9.08125192e-03f, 3.06796134e-02f, 1.09722786e-01f, -1.46199493e-02f,
  -7.98781291e-02f, 1.81752637e-01f, -8.38104114e-02f, -7.90893734e-02f, 1.14574239e-01f, 4.32426184e-02f, 2.06217133e-02f, 2.52692606e-02f, 5.24289384e-02f, 5.11310697e-02f,
  -2.87337095e-01f, 1.49302319e-01f, -2.02908367e-01f, -1.64939225e-01f, -2.41103657e-02f, -9.26633254e-02f, 4.99255322e-02f, -6.91298619e-02f, -6.71835840e-02f, 7.12240711e-02f,
  5.79020828e-02f, -6.00869618e-02f, -9.25408024e-03f, 9.14721861e-02f, -6.44359365e-02f, -4.49761115e-02f, 9.15659405e-03f, -9.33075845e-02f, 1.46736443e-01f, 1.80622321e-02f,
  9.77726746e-03f, -8.05315822e-02f, -4.84614857e-02f, -6.90773129e-03f, 4.86031063e-02f, -1.15024559e-01f, -4.61179821e-04f, -3.51320989e-02f, 4.73755077e-02f, -1.42477125e-01f,
  -1.77991316e-01f, -3.21460485e-01f, 1.09188497e-01f, 8.04780349e-02f, -3.68506610e-02f, -1.91389434e-02f, -3.41171652e-01f, 1.22347679e-02f, 8.34928751e-02f, -2.73591101e-01f,
  -1.04931565e-02f, 2.84131348e-01f, 1.18046790e-01f, 7.70585090e-02f, 4.39208113e-02f, -3.82900298e-01f, -9.90708843e-02f, 9.93575826e-02f, 3.46281737e-01f, 1.58373311e-01f,
  9.90758613e-02f, 1.23781912e-01f, 1.96857527e-01f, 6.63624480e-02f, -1.76634297e-01f, 8.06945115e-02f, -1.88691214e-01f, -3.82288881e-02f, -7.20556602e-02f, -2.13613540e-01f,
  -2.19417378e-01f, -1.78465247e-01f, 5.92778847e-02f, -1.33888042e-02f, 3.61493509e-03f, -1.40071273e-01f, -5.38411736e-02f, -5.99222034e-02f, 1.39514226e-02f, 1.28440350e-01f,
  1.68951049e-01f, 2.20130190e-01f, -2.75616460e-02f, 9.73878205e-02f, -1.30969111e-03f, 6.85595647e-02f, 7.26591051e-02f, 2.17810646e-02f, -8.12211782e-02f, 8.87984186e-02f,
  -4.90483865e-02f, 1.43235251e-02f, -2.03436054e-02f, -8.79592448e-02f, -7.76660535e-03f, 1.62414983e-01f, 1.08793862e-01f, 6.98416159e-02f, -1.22686783e-02f, -2.28555277e-01f,
  -1.07866511e-01f, -1.01734474e-01f, 4.98373844e-02f, 1.06510691e-01f, 1.01044670e-01f, -4.20507602e-02f, 1.06726684e-01f, 6.26621544e-02f, -4.27605659e-02f, -4.23130244e-02f,
  1.18365444e-01f, -3.34277824e-02f, 7.38218939e-03f, -1.14951178e-01f, 4.67624776e-02f, 1.77854359e-01f, -5.73831573e-02f, -4.57387716e-02f, 1.16472177e-01f, 6.66643530e-02f,
  8.46507996e-02f, 1.74715724e-02f, 7.53138885e-02f, 1.82297900e-02f, -1.12045072e-01f, -3.14229988e-02f, 7.35287666e-02f, 6.08246475e-02f, 6.63045235e-03f, -1.46976532e-02f,
  -4.02515382e-02f, 5.29875420e-02f, -1.19229987e-01f, 7.90478662e-02f, 1.37030169e-01f, -1.63795039e-01f, -2.46689394e-02f, 3.71663086e-03f, 1.12885192e-01f, 1.07882775e-01f,
  -1.15461960e-01f, 7.36163259e-02f, -4.29105721e-02f, 2.68500801e-02f, -8.83913040e-03f, 9.10456702e-02f, -4.50185314e-02f, 1.42376900e-01f, -9.24895480e-02f, 9.61184129e-02f,
  -4.01603505e-02f, -1.10137537e-01f, -4.41992469e-02f, -6.10269420e-02f, 3.93181726e-05f, 9.05673765e-03f, -1.56936675e-01f, -1.64789736e-01f, -1.69318914e-01f, -3.53104323e-01f,
  -2.86165506e-01f, -3.54576498e-01f, -1.77985579e-02f, -8.43608454e-02f, 1.04844701e-02f, -2.58877464e-02f, -4.26700205e-01f, -1.85690135e-01f, -6.39216229e-03f, -4.80143338e-01f,
  -1.39112040e-01f, 2.73691653e-03f, -8.28546435e-02f, 1.81436837e-02f, -2.01425344e-01f, -5.47847867e-01f, -2.05250308e-01f, -3.91681530e-02f, 3.24639410e-01f, 1.20247558e-01f,
  -3.46759567e-03f, 1.19793423e-01f, 1.15526408e-01f, 1.51771784e-01f, -1.21477522e-01f, -5.75613603e-03f, -7.85293654e-02f, -2.47617103e-02f, 2.67079333e-03f, -2.02252865e-01f,
  -2.18313754e-01f, -1.95794851e-01f, 1.16444856e-01f, -9.69510898e-02f, -1.89126339e-02f, -5.34672737e-02f, -8.72692764e-02f, -4.52675447e-02f, -9.91171375e-02f, -7.60605559e-02f,
  4.71960306e-02f, 1.15634792e-01f, 1.05852462e-01f, 1.01203173e-01f, 9.74155217e-03f, -1.17812581e-01f, 1.04320467e-01f, -6.73968270e-02f, -1.31992027e-01f, -1.24898240e-01f,
  1.05082385e-01f, 2.28221286e-02f, -8.51022229e-02f, 6.61533177e-02f, -5.62135167e-02f, 9.98317525e-02f, -4.44232300e-03f, 1.51867062e-01f, 1.35077491e-01f, -3.20457488e-01f,
  -2.45824773e-02f, -9.43338349e-02f, -9.02854353e-02f, 3.20566595e-02f, -1.32708419e-02f, -1.50866574e-02f, -4.69190627e-02f, -8.69519114e-02f, 1.20651029e-01f, 5.69265261e-02f,
  -7.19216317e-02f, -3.07555385e-02f, 2.39838124e-03f, -1.78606987e-01f, 3.92129272e-02f, -1.03123207e-02f, -1.45345211e-01f, -8.89154524e-03f, -5.71423536e-03f, 3.63233988e-03f,
  -3.54931876e-03f, 1.69740811e-01f, -1.09011069e-01f, -4.11109291e-02f, -1.52947932e-01f, -9.42846853e-03f, -5.48949838e-02f, -3.26769389e-02f, 3.23633701e-02f, 7.86237568e-02f,
  -9.07413736e-02f, 1.76300660e-01f, -2.78634578e-01f, -1.94472726e-02f, 2.98901070e-02f, -2.96911784e-02f, -2.45821401e-02f, 3.54769491e-02f, -3.26786749e-02f, -4.48072851e-02f,
  3.40770148e-02f, -6.25854880e-02f, -1.62445381e-02f, -3.27354372e-02f, -3.90984155e-02f, 4.39787656e-03f, -1.80079609e-01f, -7.12042749e-02f, 5.43822208e-03f, 5.57998903e-02f,
  1.79609016e-01f, -9.37312394e-02f, -8.93496871e-02f, -7.37119466e-02f, -1.81215126e-02f, 1.93127878e-02f, 7.41164982e-02f, -4.64288145e-02f, -4.31290939e-02f, -3.04120839e-01f,
  -4.12568927e-01f, 1.49749666e-01f, 8.34770352e-02f, -1.74382716e-01f, 1.44522592e-01f, 7.61364866e-03f, -8.61838832e-02f, -2.01496720e-01f, 1.25519246e-01f, 1.37356520e-02f,
  1.16903476e-01f, 6.91452026e-02f, 1.37375608e-01f, 1.36658728e-01f, -2.00038031e-01f, -3.54579464e-02f, -1.98401123e-01f, -9.01675895e-02f, -1.59477383e-01f, 1.02483466e-01f,
  9.96780321e-02f, -1.51228672e-02f, -2.39804521e-01f, -1.27730295e-01f, 4.40857522e-02f, -9.75914672e-03f, 1.04400702e-01f, -1.89712085e-02f, 2.34030262e-01f, 8.97190943e-02f,
  1.54727027e-01f, -1.66405961e-02f, 1.82889894e-01f, -1.66362703e-01f, 2.90664528e-02f, 7.02895317e-03f, -5.03678843e-02f, -1.41754923e-02f, 4.98140454e-02f, -2.26197675e-01f,
  -1.39886737e-01f, 6.92570582e-02f, -1.13881506e-01f, -8.17036778e-02f, -4.85928804e-02f, -9.73029807e-02f, -1.09019682e-01f, 7.56725520e-02f, -1.84868813e-01f, -1.72129527e-01f,
  -1.34938583e-01f, -3.45114172e-02f, 1.06752463e-01f, 2.43659802e-02f, -3.79417948e-02f, -7.37881884e-02f, 9.59057808e-02f, 1.14012234e-01f, 3.81221548e-02f, -6.72392771e-02f,
  4.32899445e-02f, -2.36341963e-03f, 2.27773622e-01f, -1.66715551e-02f, -1.39262706e-01f, 4.99996869e-03f, -5.25862016e-02f, 9.46158916e-02f, 4.10079537e-03f, -1.37898382e-02f,
  -4.68092002e-02f, 2.62698606e-02f, -5.25843948e-02f, 2.54664253e-02f, 4.90581281e-02f, 8.39548260e-02f, -4.69137020e-02f, -3.99488136e-02f, -7.15221912e-02f, 8.89855027e-02f,
  2.26566452e-04f, -9.15856287e-03f, 1.31762549e-01f, -2.77451072e-02f, -5.03831767e-02f, 1.42465949e-01f, 1.92493170e-01f, 6.28161132e-02f, 3.05641443e-04f, 9.78574082e-02f,
  -7.99700469e-02f, 1.35151356e-01f, -2.75972728e-02f, -8.95072334e-03f, -7.91348815e-02f, -3.34514380e-02f, -1.36977255e-01f, -1.55125275e-01f, 2.23258473e-02f, -8.73066485e-02f,
  -1.42946735e-01f, -1.16858274e-01f, -8.79664198e-02f, 7.44080618e-02f, -2.04926319e-02f, 1.43798053e-01f, -1.87540367e-01f, -1.00352112e-02f, -5.68458512e-02f, -6.18183464e-02f,
  -2.47566819e-01f, -2.14899287e-01f, -1.26002580e-01f, -1.29965506e-02f, -6.16558157e-02f, -2.27620691e-01f, 1.19792810e-02f, 1.45453528e-01f, 7.90632591e-02f, -2.67528892e-01f,
  4.20822263e-01f, 1.13971122e-01f, -6.33672774e-02f, 1.98278591e-01f, 1.23555325e-01f, 9.82907265e-02f, 3.64988178e-01f, 1.04919165e-01f, 1.20472603e-01f, 8.14750940e-02f,
  -1.87629089e-01f, -3.96690488e-01f, -3.01857173e-01f, -2.97660738e-01f, -3.70752156e-01f, 1.73358336e-01f, 1.81546286e-01f, -2.30624408e-01f, -1.09292693e-01f, 8.97873417e-02f,
  7.27694333e-02f, 3.03062946e-01f, 1.68107003e-01f, 4.81843799e-02f, 1.34055719e-01f, 1.16933830e-01f, 1.87378526e-01f, 7.30597973e-02f, -5.98401502e-02f, -2.07089707e-02f,
  -3.71269673e-01f, -1.02710370e-02f, -2.53011882e-02f, 1.79649919e-01f, -2.39107534e-01f, -8.14126581e-02f, -1.11096710e-01f, -1.89608455e-01f, -2.02211127e-01f, -1.22673362e-01f,
  -1.99549586e-01f, -1.95819855e-01f, -2.65354842e-01f, -6.32186234e-02f, -1.19177990e-01f, -2.86184587e-02f, 8.34502503e-02f, -3.80914845e-02f, -1.87999621e-01f, -2.56605238e-01f,
  -1.61511868e-01f, -1.00147471e-01f, -1.31735608e-01f, 7.19501227e-02f, -2.47953311e-01f, -2.41617784e-01f, 3.78981642e-02f, -1.78205997e-01f, -1.19955599e-01f, 1.74135461e-01f,
  -8.81457478e-02f, -1.99694976e-01f, -9.34202522e-02f, 5.29941358e-02f, -7.12934434e-02f, -1.31052449e-01f, -8.79171118e-02f, -3.13069858e-02f, 1.50973657e-02f, 1.02255568e-01f,
  -1.61015853e-01f, -9.99770761e-02f, -1.10785671e-01f, -2.12773327e-02f, -1.41923400e-02f, -8.26947987e-02f, 4.27703187e-03f, 1.38601929e-01f, -2.30696741e-02f, 8.32374170e-02f,
  -9.63327438e-02f, 2.17260271e-02f, 3.89835276e-02f, -5.61936051e-02f, 1.17460832e-01f, -1.03503997e-02f, 4.07776423e-02f, 5.92527390e-02f, -4.69500087e-02f, 2.57410891e-02f,
  -5.76994382e-02f, -3.23144585e-01f, -1.55531103e-02f, 5.22494968e-03f, 1.38260527e-02f, -1.48701295e-01f, -1.36263043e-01f, -4.50788476e-02f, -9.82653424e-02f, -3.71276252e-02f,
  -5.51504977e-02f, -1.05884247e-01f, -7.53384978e-02f, 7.11539835e-02f, 1.30727943e-02f, -1.58362463e-01f, 6.65265322e-02f, 6.74368143e-02f, 5.05307205e-02f, -4.58039518e-04f,
  1.49027929e-01f, 3.09120595e-01f, 9.45642069e-02f, 1.00308098e-01f, -3.13854255e-02f, 2.33577229e-02f, 1.00082427e-01f, 6.66660666e-02f, -2.77948380e-02f, 2.78158903e-01f,
  -1.70185626e-01f, -1.03868999e-01f, -2.02843264e-01f, 2.37849951e-02f, -2.40742192e-01f, -1.26071051e-01f, -1.72077090e-01f, 9.89767686e-02f, 6.42454624e-02f, -2.39990488e-01f,
  4.61297147e-02f, 1.25966415e-01f, -1.40568307e-02f, 8.53576958e-02f, 1.67728230e-01f, -2.35467702e-01f, -2.02588558e-01f, -3.25212404e-02f, 1.65679231e-01f, 2.21595690e-02f,
  1.03693329e-01f, 9.11581516e-02f, 1.89218864e-01f, 1.75094113e-01f, -1.04493000e-01f, 2.41826788e-01f, 1.50711089e-01f, 8.35176483e-02f, -4.04057801e-02f, -2.49556988e-01f,
  -1.72236934e-01f, -7.63700828e-02f, 8.56517032e-02f, 7.05538467e-02f, -8.34142938e-02f, 6.06342256e-02f, -2.20463380e-01f, -6.98415264e-02f, -9.80549082e-02f, 2.84479801e-02f,
  -4.11230400e-02f, 2.67597064e-02f, -5.27195819e-02f, 1.17937595e-01f, 1.18459806e-01f, -9.95905623e-02f, -8.44738632e-02f, -3.45198549e-02f, -5.50513044e-02f, -1.46912158e-01f,
  3.39222029e-02f, -2.50561565e-01f, -2.47716606e-01f, 7.79967681e-02f, -6.32884502e-02f, -7.69565329e-02f, 9.04892683e-02f, 7.95631856e-02f, 2.46391833e-01f, 1.00989960e-01f,
  -1.18003758e-02f, 1.49183720e-02f, -6.67789504e-02f, -9.29349735e-02f, -5.20517305e-02f, -9.00872424e-02f, 1.50835486e-02f, 1.11602299e-01f, 7.60582462e-02f, 7.17003085e-03f,
  -1.21344402e-01f, -7.02056661e-02f, -8.73064902e-03f, 1.16262428e-01f, -3.80573585e-03f, 8.98395702e-02f, -5.00873737e-02f, 2.10363902e-02f, 8.07509348e-02f, 4.86250222e-03f,
  -9.73352138e-03f, -1.85725819e-02f, -3.42333354e-02f, 1.07524730e-01f, -3.18627767e-02f, -5.79831004e-02f, -3.09305042e-02f, 8.32753256e-03f, 5.96466996e-02f, 6.95350692e-02f,
  1.73275948e-01f, 3.92487347e-02f, -2.52498854e-02f, 3.68088204e-03f, -1.01709746e-01f, -2.36633942e-02f, -6.12147860e-02f, 3.89677323e-02f, 2.34277789e-02f, -9.50285271e-02f,
  -7.43658692e-02f, 6.45112945e-04f, 3.06827817e-02f, 1.34302899e-02f, -5.51159447e-03f, 6.81659654e-02f, -1.68247089e-01f, 2.39798725e-02f, 3.98823991e-02f, 1.39241228e-02f,
  -6.45036846e-02f, 1.89692751e-02f, -1.14499498e-02f, -4.23514321e-02f, -5.78435697e-02f, 8.15957189e-02f, 2.88283899e-02f, 9.39279124e-02f, 3.92942578e-02f, 6.37461171e-02f,
  -1.07101180e-01f, 1.82827070e-01f, 3.46307456e-02f, 4.55685705e-02f, 4.46743250e-01f, -1.13564402e-01f, -2.36507714e-01f, -3.17030400e-01f, -1.11610919e-01f, 4.01461087e-02f,
  3.64684194e-01f, 2.80385673e-01f, 1.31015405e-01f, -7.00776950e-02f, -4.57439005e-01f, -1.35859892e-01f, -1.53446719e-01f, -2.58747220e-01f, -4.47400868e-01f, -1.81956545e-01f,
  1.90285355e-01f, -7.70323649e-02f, -1.72812298e-01f, -8.55455697e-02f, 1.70989975e-01f, 9.66816023e-02f, 4.57071364e-02f, 1.13025561e-01f, 8.57077166e-02f, 4.61230844e-01f,
  2.49361217e-01f, -1.71808545e-02f, -1.02465317e-01f, 1.11636735e-01f, 1.73358321e-01f, -5.22091845e-03f, 2.35041101e-02f, -3.26420888e-02f, -1.07223697e-01f, -6.70440122e-02f,
  2.45752543e-01f, 8.05227757e-02f, 1.33687526e-01f, 9.19982512e-03f, -1.96855560e-01f, -1.48499101e-01f, -1.93253919e-01f, -1.62984505e-01f, -1.84209213e-01f, -2.42174491e-01f,
  1.46666348e-01f, 2.31412038e-01f, -6.78154361e-03f, -2.15786979e-01f, -3.19161117e-01f, 1.45247266e-01f, -5.87683870e-03f, -6.21762834e-02f, -3.04847658e-01f, 4.58384529e-02f,
  -9.20539126e-02f, -3.85747328e-02f, 6.58787861e-02f, -3.36029357e-03f, 3.65103595e-02f, 1.11174323e-01f, 5.28710634e-02f, -1.58762150e-02f, 3.92578263e-03f, -1.25818076e-02f,
  -8.18901360e-02f, -6.35023648e-03f, -1.00467935e-01f, 2.98573487e-02f, -1.07119419e-01f, 8.41019303e-02f, 8.23229328e-02f, 2.37018820e-02f, 2.22644489e-03f, -1.05353311e-01f,
  -3.48198507e-03f, -1.31081818e-02f, 9.84278228e-03f, 3.93114239e-02f, 1.80384107e-02f, -1.11494571e-01f, 4.63868538e-03f, -3.75677682e-02f, 8.19436759e-02f, 8.84427130e-02f,
  -2.76548527e-02f, -3.33387591e-02f, 9.31196511e-02f, -1.85334459e-01f, -1.68649312e-02f, 2.40262337e-02f, 8.70970041e-02f, 3.44647816e-03f, 8.76234621e-02f, -2.01249570e-01f,
  -2.58702450e-02f, 4.59874421e-03f, 8.02175924e-02f, 2.33165678e-02f, -6.66034520e-02f, -3.33377570e-02f, -1.05066039e-01f, 2.75059380e-02f, -1.87144220e-01f, 3.04502435e-03f,
  -1.68380812e-02f, -1.15169771e-01f, -1.06565185e-01f, 4.30607647e-02f, -1.14373848e-01f, -9.86524001e-02f, -8.60467032e-02f, 1.81331411e-02f, -1.76601067e-01f, -1.98148236e-01f,
  -2.80410834e-02f, 2.47356310e-01f, -5.18669009e-01f, -8.69496986e-02f, -2.01801240e-01f, -6.07078671e-02f, 6.77461177e-02f, 4.38773870e-01f, 3.28485191e-01f, -2.97978278e-02f,
  -2.76315641e-02f, -2.71155447e-01f, -2.46889830e-01f, -7.23887086e-02f, -1.24743693e-01f, -2.03971326e-01f, -1.70084327e-01f, -4.60981190e-01f, -3.76409411e-01f, 5.52828051e-02f,
  4.43975888e-02f, 4.01491784e-02f, 1.27378851e-01f, 2.18648225e-01f, 5.37343509e-03f, 2.97433939e-02f, -2.60875411e-02f, -7.06474995e-03f, 3.80471684e-02f, -1.07842647e-01f,
  -3.06954384e-01f, 1.62684441e-01f, -1.70436338e-01f, -6.65870123e-03f, -2.95464814e-01f, -7.50462934e-02f, -8.34954903e-02f, -1.61038995e-01f, 1.02771305e-01f, 5.27409017e-02f,
  -2.78245658e-01f, -3.10394727e-03f, -3.21605265e-01f, -9.93842036e-02f, -1.67837590e-01f, -1.53494969e-01f, 6.05848692e-02f, -9.56459567e-02f, -3.54162939e-02f, -4.09064293e-02f,
  1.96984001e-02f, -1.03256986e-01f, -1.32769287e-01f, 1.93683416e-01f, -5.41806929e-02f, -2.20236927e-01f, 2.07233548e-01f, 1.00778550e-01f, 1.40586302e-01f, 2.31487736e-01f,
  1.94533259e-01f, 4.66041826e-02f, 4.25011106e-02f, 1.56337261e-01f, 1.35794338e-02f, -2.57726870e-02f, -6.26111552e-02f, 1.52449444e-01f, 5.09832613e-02f, 4.72389609e-02f,
  -9.13125426e-02f, -1.48608953e-01f, 2.30336469e-02f, -1.12024061e-01f, 4.59777676e-02f, -1.84914187e-01f, -5.85577600e-02f, 2.23537348e-02f, 7.03868223e-03f, -6.97963238e-02f,
  -5.12848720e-02f, 1.25746727e-01f, -2.08879001e-02f, 7.54482299e-02f, -4.42202128e-02f, -1.06393054e-01f, -2.48971079e-02f, -6.70368597e-02f, 1.25337848e-02f, -2.15494763e-02f,
  5.35608903e-02f, -1.12148345e-01f, -9.49464068e-02f, -6.45808503e-02f, -1.96596101e-01f, -7.98484683e-02f, -2.46941186e-02f, 2.82983715e-03f, 1.48296179e-02f, -4.32238095e-02f,
  -2.10038610e-02f, -1.61551312e-01f, -6.28549159e-02f, -2.21001226e-02f, -1.12525918e-01f, -2.22356431e-02f, 6.55775517e-02f, 1.03550665e-01f, -3.44210044e-02f, -1.11044981e-01f,
  8.08238685e-02f, -7.46960985e-04f, -1.82121843e-02f, 8.80840644e-02f, 1.26371533e-01f, 3.52787711e-02f, 1.12279188e-02f, 1.04624920e-01f, -3.73075642e-02f, 2.13787034e-01f,
  -6.53718710e-01f, -3.28091122e-02f, -1.16110831e-01f, -7.36918986e-01f, -3.66068453e-01f, -1.68844178e-01f, 1.22727454e-01f, -2.49155283e-01f, -4.39015418e-01f, -1.11475751e-01f,
  7.38648251e-02f, 1.92766637e-01f, 1.49739847e-01f, 1.30404726e-01f, 3.61342043e-01f, 5.93735576e-02f, -1.41648382e-01f, 7.04422072e-02f, 2.16799662e-01f, 2.67388728e-02f,
  -1.98171102e-02f, -2.09430471e-01f, -2.27681398e-01f, -1.50079116e-01f, -2.46348888e-01f, -3.61729525e-02f, -1.77328736e-01f, -1.82008699e-01f, 5.84669970e-02f, -2.08962619e-01f,
  2.27852374e-01f, -2.98066199e-01f, -1.04027160e-01f, -4.34447341e-02f, -6.11396693e-02f, -4.47222628e-02f, -4.56111021e-02f, -1.57531500e-01f, -2.26655602e-02f, -5.86427413e-02f,
  -1.26471817e-01f, -5.29200621e-02f, -4.35226783e-02f, 1.09250739e-01f, -1.14753917e-01f, 2.18360052e-02f, -6.87304661e-02f, -7.47521743e-02f, -6.36736080e-02f, 1.55878335e-01f,
  1.51004851e-01f, 6.49866462e-02f, -3.84374186e-02f, 4.57908306e-03f, 7.08788587e-03f, 5.02105653e-02f, 1.29568800e-01f, -8.14222619e-02f, -7.49378353e-02f, -1.01692207e-01f,
  -6.32600635e-02f, -2.89359987e-02f, 3.75475436e-02f, -4.49300632e-02f, 1.07103229e-01f, -1.98960621e-02f, -4.04730588e-02f, -2.55075227e-02f, 2.80104131e-02f, 8.47639591e-02f,
  -8.43137801e-02f, 3.39726801e-03f, 8.09051245e-02f, -7.49003813e-02f, -8.19170773e-02f, 1.73772257e-02f, 8.80772471e-02f, 6.40996471e-02f, -9.89451110e-02f, -1.94783360e-02f,
  -8.56005307e-03f, -8.28856751e-02f, -1.15101457e-01f, -4.23964718e-03f, 6.39765039e-02f, 2.39920318e-02f, -3.76927927e-02f, 9.69795063e-02f, -1.69743989e-02f, 3.67243737e-02f,
  1.50806561e-01f, -3.29727307e-02f, -3.82264629e-02f, 1.08220309e-01f, -8.32420513e-02f, -3.42418812e-02f, 2.47743670e-02f, -1.04611434e-01f, -4.69464771e-02f, -1.72932781e-02f,
  -5.52370436e-02f, 4.14840728e-02f, 1.27171082e-02f, -7.15037659e-02f, 9.36303511e-02f, -1.04400180e-01f, 6.53828010e-02f, 3.38221788e-02f, -7.64370933e-02f, 3.83478738e-02f,
  -5.00209667e-02f, 5.47724366e-02f, 2.52999645e-02f, 1.08380698e-01f, 3.39251943e-02f, 2.22279891e-01f, 6.98746517e-02f, 8.36107135e-02f, 1.20667607e-01f, 1.54081285e-01f,
  -3.77580613e-01f, 2.15294480e-01f, 3.81824374e-02f, -2.15646014e-01f, 2.45425701e-01f, 2.11859584e-01f, 4.91554081e-01f, -3.06948107e-02f, -1.95616499e-01f, 2.01275468e-01f,
  1.87344015e-01f, -6.02658391e-02f, 3.34041491e-02f, 1.00674100e-01f, 5.89074716e-02f, 1.59709305e-01f, 1.67211771e-01f, -1.84202373e-01f, -2.36446142e-01f, -2.14767959e-02f,
  1.86216116e-01f, -9.29429978e-02f, -3.96196604e-01f, -2.41514817e-01f, 3.36342081e-02f, -1.64914086e-01f, -1.93222370e-02f, 6.08824240e-03f, 1.48830414e-01f, 1.43634051e-01f,
  4.11210172e-02f, -3.79964635e-02f, 2.37053111e-02f, -1.33046672e-01f, -8.26618001e-02f, -2.16706425e-01f, 7.26720765e-02f, -1.09753489e-01f, 3.94638777e-02f, -8.52125138e-02f,
  5.28162271e-02f, 1.88302398e-01f, 1.05342664e-01f, 8.20055008e-02f, 5.48146851e-03f, -9.95190889e-02f, 4.89722043e-02f, -6.81608319e-02f, -1.12291962e-01f, -6.52785003e-02f,
  1.05948612e-01f, 8.16088617e-02f, -1.78063419e-02f, 1.46308452e-01f, 7.85308629e-02f, -3.57749946e-02f, 1.44866407e-01f, 2.84729549e-03f, -2.48359311e-02f, -2.13392168e-01f,
  -9.93628576e-02f, -6.76552653e-02f, 3.81381474e-02f, -1.37225853e-03f, -1.60923079e-01f, -1.14707313e-01f, 6.05846196e-02f, 1.77764054e-02f, 2.83967108e-02f, -1.03676215e-01f,
  3.58980522e-02f, -7.41308406e-02f, -3.79281491e-02f, -6.42436296e-02f, -2.78732851e-02f, -1.60189252e-02f, 1.10647373e-01f, -5.94653562e-02f, 4.88225669e-02f, 2.47938484e-02f,
  -2.99567636e-02f, 1.90284587e-02f, -5.83654195e-02f, 3.72467488e-02f, 6.51849508e-02f, -1.23303913e-01f, -3.69186699e-02f, 7.02991150e-03f, 2.35344097e-03f, -5.19554652e-02f,
  -1.56141832e-01f, 1.90798938e-01f, -2.51591206e-01f, 3.39158252e-02f, 2.48717815e-02f, -2.07569636e-03f, -3.73503976e-02f, -1.06009118e-01f, -5.42415641e-02f, -1.15933828e-01f,
  -8.36834833e-02f, -1.98723879e-02f, -1.50866564e-02f, -6.26127422e-02f, -1.83943704e-01f, 5.15009277e-02f, 1.85794346e-02f, 3.53910998e-02f, 1.16538264e-01f, -1.44731238e-01f,
  -4.12560292e-02f, -2.43548572e-01f, -1.85897470e-01f, 8.58860277e-03f, -1.03190772e-01f, -1.40512824e-01f, -4.37601693e-02f, -1.71670560e-02f, -1.98445134e-02f, -1.11962132e-01f,
  -4.77922559e-01f, 1.69136915e-02f, -4.10889417e-01f, -1.06312789e-01f, 3.11076283e-01f, 2.09200662e-02f, 6.76072910e-02f, -6.96500540e-02f, 1.33486781e-02f, 1.12238444e-01f,
  4.81875055e-02f, 7.26353154e-02f, 4.43122536e-02f, 1.69227377e-01f, -7.96584114e-02f, 4.55256030e-02f, 1.36364937e-01f, -2.63043821e-01f, -9.75637063e-02f, 1.60212085e-01f,
  3.17930043e-01f, -1.17308967e-01f, -3.16363215e-01f, -3.50213088e-02f, 1.83041975e-01f, 1.43238306e-01f, 4.59514745e-02f, 1.10295109e-01f, 9.07368138e-02f, 1.26005739e-01f,
  -3.00400585e-01f, -1.15377381e-01f, 9.38362032e-02f, 2.07953036e-01f, -6.95905536e-02f, -1.90733626e-01f, -3.39126289e-02f, -9.39731598e-02f, 6.36303350e-02f, -4.16510813e-02f,
  -4.71620709e-02f, 6.42030239e-02f, 8.20592940e-02f, -1.57064423e-01f, -1.69175882e-02f, -1.23393185e-01f, -1.63288504e-01f, -2.26609409e-01f, -2.27744788e-01f, -2.68393785e-01f,
  3.04964572e-01f, -2.81384289e-02f, -1.37161389e-01f, 1.04148209e-01f, -7.82267153e-02f, 4.31926847e-02f, -9.38104913e-02f, 4.93778959e-02f, -5.66497073e-02f, -7.96103328e-02f,
  -5.38038462e-03f, 9.30886194e-02f, -1.40358791e-01f, -8.98014009e-02f, 6.71159625e-02f, 1.11319739e-02f, 1.26636639e-01f, 8.16666558e-02f, 2.76851119e-03f, -2.12483648e-02f,
  2.03942489e-02f, -1.24500073e-01f, -1.30934212e-02f, -5.87508604e-02f, 1.52944490e-01f, -8.10548440e-02f, 9.88556519e-02f, 5.33727221e-02f, -3.94253582e-02f, 7.86200762e-02f,
  -7.29807559e-03f, -5.38751371e-02f, 9.59018990e-03f, 4.82840696e-03f, -7.59719536e-02f, 1.84008088e-02f, -4.89092357e-02f, 2.38786801e-03f, -2.16819402e-02f, 3.37881930e-02f,
  -1.21642336e-01f, 1.31177261e-01f, -4.44583781e-02f, 3.72049287e-02f, -7.85255060e-02f, 1.62785631e-02f, 4.83507924e-02f, 3.11236363e-02f, 2.11738423e-02f, -5.55953085e-02f,
  5.48351705e-02f, -1.10019922e-01f, 7.40333088e-03f, -1.83195889e-01f, -4.74345349e-02f, -1.38868600e-01f, -2.93974895e-02f, -9.57758352e-02f, -8.90255570e-02f, 4.75489311e-02f,
  -1.31470606e-01f, -4.92001586e-02f, -1.89392865e-01f, -1.20334752e-01f, -5.18289581e-02f, -3.09029911e-02f, -5.09822704e-02f, -5.43846451e-02f, -9.41806212e-02f, -4.47522923e-02f,
  -4.47175466e-02f, 3.16973269e-01f, -1.10839792e-01f, -1.00325443e-01f, -7.53027797e-02f, 8.12886059e-02f, 4.29403245e-01f, 1.73598036e-01f, -9.60355625e-02f, 1.17480434e-01f,
  -2.09511980e-01f, -1.95267081e-01f, -2.25706063e-02f, 7.24446103e-02f, 2.14954540e-01f, 3.36537302e-01f, 1.86238408e-01f, 6.88899891e-04f, -6.90929294e-02f, -1.43008009e-01f,
  7.90516883e-02f, -8.12462121e-02f, -9.85909775e-02f, -3.87239382e-02f, 3.52525525e-02f, -1.36191681e-01f, -2.84049511e-02f, 8.00164714e-02f, 5.26633412e-02f, 1.19615905e-01f,
  -1.98476851e-01f, 7.54279643e-02f, -1.04934484e-01f, 6.59368113e-02f, -1.02866948e-01f, -5.32828318e-03f, -8.48008394e-02f, 7.08704740e-02f, -5.79303764e-02f, -1.96620431e-02f,
  1.10247493e-01f, 4.04065587e-02f, 3.75745371e-02f, 4.38629463e-02f, 1.34669125e-01f, 1.39792278e-01f, -5.53982109e-02f, 1.10068634e-01f, -9.46973190e-02f, -2.22825184e-01f,
  1.09732032e-01f, -1.43666402e-01f, -3.20494100e-02f, 4.05498296e-02f, 5.35367541e-02f, -2.37548366e-01f, -1.84904190e-03f, -2.18420359e-03f, -3.49399634e-02f, -9.91783291e-02f,
  -3.66147943e-02f, -3.65144499e-02f, 1.20913707e-01f, -1.30924545e-02f, 7.03943241e-03f, 4.99067269e-02f, 6.15829304e-02f, 3.02112754e-02f, 5.42038642e-02f, -1.84589047e-02f,
  -3.68461944e-02f, -1.82879031e-01f, -1.09324433e-01f, -2.22924491e-03f, 4.68887351e-02f, -3.62687930e-02f, -1.03895739e-01f, 9.29251537e-02f, -1.03541708e-03f, -8.36456567e-02f,
  2.06165519e-02f, -3.32424119e-02f, -1.41446412e-01f, 2.81937830e-02f, 1.18468677e-07f, -5.39399125e-02f, -1.12449832e-01f, 1.43811125e-02f, -6.43800944e-02f, 3.96908410e-02f,
  -3.68904024e-01f, -1.34693250e-01f, -1.50927737e-01f, 1.30414456e-01f, 9.29507148e-03f, 4.44051810e-02f, -1.43782407e-01f, -7.67443702e-02f, -2.71048881e-02f, 2.60932576e-02f,
  7.96230733e-02f, 2.28842162e-02f, 2.56853774e-02f, 1.17645394e-02f, -3.40415910e-02f, 5.73567161e-03f, -3.14863622e-02f, 2.44396888e-02f, -5.51409237e-02f, -2.75426477e-01f,
  -2.89512910e-02f, -9.04576108e-03f, -1.60635978e-01f, -1.89977661e-02f, -1.17533244e-01f, -2.49686539e-01f, -9.34963301e-02f, -5.49916700e-02f, -1.21049538e-01f, -7.14996308e-02f,
  -4.54445630e-01f, -1.06997170e-01f, -1.97604343e-01f, -2.19896629e-01f, 2.96770483e-01f, 1.94170833e-01f, -1.07128024e-02f, -1.16567425e-01f, -9.07915086e-02f, -1.19123198e-01f,
  1.86290368e-01f, 1.17410019e-01f, -2.37990860e-02f, -2.10846681e-02f, -1.00103766e-01f, -5.63519597e-02f, -1.85301661e-01f, -1.34722874e-01f, 1.81659386e-01f, 4.25183594e-01f,
  2.44985178e-01f, -2.83750147e-02f, -1.33284479e-01f, 1.27211332e-01f, 5.43458909e-02f, -3.23401317e-02f, -1.66320719e-03f, -1.56046785e-02f, 1.39007539e-01f, -1.86600778e-02f,
  -4.37042229e-02f, -1.40756965e-01f, 1.60090744e-01f, 5.97679093e-02f, 1.51195750e-01f, 6.66913167e-02f, -9.16578099e-02f, -1.04823951e-02f, -7.59020820e-02f, -1.39391795e-01f,
  -8.13457593e-02f, 6.11093491e-02f, -8.80985558e-02f, -2.23669037e-02f, 6.26709983e-02f, -1.02976173e-01f, -6.06769882e-02f, -1.09043099e-01f, 3.21043953e-02f, 1.35613441e-01f,
  -1.93379130e-02f, 9.98727083e-02f, 3.73064615e-02f, -5.01862913e-02f, -6.34390488e-02f, -1.95254087e-01f, 1.29215032e-01f, 1.47091806e-01f, 1.84849091e-02f, -2.59111494e-01f,
  2.44745359e-01f, 9.73162204e-02f, 1.45564482e-01f, -8.39241520e-02f, -3.12935226e-02f, -2.08484940e-02f, -5.08407317e-02f, 1.32702783e-01f, 1.81401595e-01f, -3.63283120e-02f,
  -1.46797011e-02f, -1.87128922e-03f, -2.69510243e-02f, -3.81501913e-02f, 1.27282199e-02f, -1.92336179e-02f, 1.05968930e-01f, -2.11836211e-03f, 1.92346387e-02f, -1.54794818e-02f,
  -2.04368513e-02f, -2.85795648e-02f, 2.68004313e-02f, 7.74255693e-02f, 1.01267628e-01f, 8.33817124e-02f, 9.51379240e-02f, -1.96258910e-02f, -2.19812468e-02f, -1.59212470e-01f,
  -2.86597908e-01f, 2.38903314e-02f, -1.93294570e-01f, -9.31424350e-02f, 5.63711748e-02f, 7.94998463e-03f, -1.32387996e-01f, 2.51786243e-02f, -1.71743140e-01f, -1.70030788e-01f,
  3.26642301e-03f, -1.36958376e-01f, -1.10030040e-01f, -1.27126381e-01f, -1.27963740e-02f, -1.19241029e-01f, -4.72873542e-03f, -6.69469759e-02f, 1.98970586e-01f, 1.25860259e-01f,
  5.01895230e-03f, -3.66448611e-02f, -1.72206610e-01f, -2.25412667e-01f, -2.50823367e-02f, -9.63664874e-02f, -1.39711350e-01f, -1.33135663e-02f, -1.40664041e-01f, -4.23426509e-01f,
  -5.63566029e-01f, 2.42401771e-02f, -4.01976705e-02f, 2.85024773e-02f, 8.24276544e-03f, -2.43668884e-01f, -2.89230645e-01f, -2.77451336e-01f, 5.36582880e-02f, -2.18212255e-03f,
  1.94185257e-01f, 1.88267618e-01f, 3.24149311e-01f, 1.93635806e-01f, -8.97950530e-02f, -3.31133455e-02f, -2.59505156e-02f, -1.56082600e-01f, -1.67100117e-01f, 2.96753738e-02f,
  9.64004695e-02f, 1.74823061e-01f, -4.43233661e-02f, 3.10550779e-02f, 1.18207060e-01f, 1.37775302e-01f, 1.01560488e-01f, 3.60438190e-02f, 1.91760391e-01f, 7.54912943e-02f,
  3.44438791e-01f, -2.37690926e-01f, -8.30389112e-02f, -7.84203485e-02f, -1.24418072e-01f, -6.34755120e-02f, -1.58355519e-01f, -2.37361655e-01f, -1.12576976e-01f, -6.93967640e-02f,
  1.15106128e-01f, -6.84725642e-02f, -3.82670686e-02f, -2.69072130e-02f, -6.65108114e-02f, -7.23625794e-02f, -1.51154429e-01f, -1.19657040e-01f, -2.18890890e-01f, -4.71230000e-02f,
  3.10774818e-02f, -1.05990976e-01f, 6.18164465e-02f, -8.99112225e-03f, -9.82456207e-02f, -9.49667208e-03f, -2.78355628e-02f, -2.91399192e-02f, -8.21688697e-02f, -2.65819039e-02f,
  -7.41475299e-02f, -9.16649848e-02f, 1.04532197e-01f, 5.45261288e-03f, 3.52417044e-02f, 4.05646153e-02f, 2.49988884e-02f, 1.17413672e-02f, 2.84295864e-02f, 1.31290192e-02f,
  -1.16736665e-01f, -5.62260412e-02f, 1.05731748e-01f, 2.85118930e-02f, 9.50494632e-02f, -4.20082919e-02f, -1.25818655e-01f, 9.62306485e-02f, 1.69411764e-01f, 3.01310346e-02f,
  1.97970662e-02f, -1.83570646e-02f, 4.85654827e-03f, -7.82040507e-02f, -7.83104300e-02f, -1.87199749e-02f, -5.40380478e-02f, -1.41705181e-02f, 7.53058344e-02f, -2.55130753e-02f,
  2.09336326e-01f, -3.47597129e-03f, -8.72456748e-03f, -2.29779743e-02f, -6.19098432e-02f, -8.66960585e-02f, -8.90431330e-02f, -1.09897323e-01f, -6.85658604e-02f, -2.49194920e-01f,
  -9.61974561e-02f, 5.56347184e-02f, 1.50926411e-01f, 1.27193779e-01f, 6.23149723e-02f, 1.06227733e-01f, 1.04822300e-01f, 4.58813757e-02f, 1.34751365e-01f, -1.13957569e-01f,
  -9.07103047e-02f, 1.06813915e-01f, 1.50861898e-02f, 4.07234915e-02f, -1.37463048e-01f, 9.15091783e-02f, 2.55441546e-01f, 7.37311915e-02f, -4.58920486e-02f, -3.77382003e-02f,
  8.33827376e-01f, 2.69225508e-01f, 2.82562792e-01f, 9.86213014e-02f, 1.50197610e-01f, 1.14494048e-01f, 2.48595968e-01f, -3.72872576e-02f, -1.21983841e-01f, 1.40513614e-01f,
  1.55431896e-01f, 1.81459803e-02f, -1.14974026e-02f, -3.24858949e-02f, 5.45943156e-02f, -1.13092475e-01f, -1.17121920e-01f, -5.26093468e-02f, 1.28966346e-01f, 1.52534559e-01f,
  2.11834181e-02f, 1.18628398e-01f, 1.12253860e-01f, -3.26991975e-02f, 2.03968212e-01f, -4.13181670e-02f, 6.76486874e-03f, 1.95546389e-01f, 5.69601208e-02f, -6.18889891e-02f,
  9.07135720e-04f, 2.71521181e-01f, -2.31945440e-01f, -1.60478894e-02f, 3.11724693e-02f, -1.46294951e-01f, 6.80667348e-03f, -1.45466790e-01f, -7.02363998e-02f, -1.33794382e-01f,
  -4.90665622e-02f, -4.03006282e-03f, 1.37776472e-02f, 1.07486099e-01f, 1.02805570e-01f, 3.40617076e-02f, -2.60169394e-02f, -6.10287450e-02f, 4.75824717e-03f, -4.36481535e-02f,
  5.80319837e-02f, 1.01702899e-01f, 1.41583413e-01f, 7.78965428e-02f, 3.38131539e-03f, 1.14246920e-01f, 1.83444619e-01f, 1.24326721e-01f, -2.32206262e-03f, 1.98497802e-01f,
  -2.21688271e-01f, 1.37844443e-01f, 1.01936184e-01f, 1.37450486e-01f, -2.60460414e-02f, -3.96871939e-02f, -3.04404087e-02f, -1.44538200e-02f, -1.18970918e-02f, 1.06908791e-01f,
  -6.13063164e-02f, 1.05901146e-02f, -2.23197676e-02f, 2.93331523e-03f, 3.47904637e-02f, -2.33421177e-02f, 4.75215837e-02f, -2.60338802e-02f, 8.69371220e-02f, -7.85509199e-02f,
  7.16207698e-02f, 4.30101752e-02f, 1.03715621e-01f, 7.79226124e-02f, 3.05687301e-02f, 2.13450175e-02f, 8.08260813e-02f, 1.29828334e-01f, 6.74733147e-02f, 4.01994959e-02f,
  -5.44506013e-01f, -9.84832719e-02f, -2.10021466e-01f, -5.30685037e-02f, 8.39815736e-02f, -2.12418046e-02f, 6.31176755e-02f, -2.04333160e-02f, -1.98086292e-01f, -1.60512447e-01f,
  4.59173247e-02f, -4.32754718e-02f, 8.64370987e-02f, -1.18472632e-02f, 1.12009617e-02f, -1.55902579e-01f, -4.08559106e-03f, -9.23794955e-02f, -2.91702636e-02f, -1.22673390e-02f,
  -6.03480116e-02f, -4.33087200e-02f, -4.15440090e-02f, -3.77341397e-02f, -1.12152785e-01f, 5.70816733e-02f, 5.56878280e-03f, 2.75723618e-02f, 2.62367781e-02f, 7.91143775e-02f,
  -3.06434214e-01f, -3.58111143e-01f, -2.62951374e-01f, 2.80155502e-02f, 1.92974582e-01f, -1.20586613e-02f, -1.77232891e-01f, -7.52093345e-02f, 1.46857768e-01f, -9.27727856e-03f,
  2.72960812e-01f, 3.50916684e-01f, 1.89978629e-01f, 1.69848293e-01f, 1.44398078e-01f, -4.17622179e-02f, 1.72130629e-01f, 1.20221891e-01f, -2.01637745e-02f, 9.41764638e-02f,
  1.17047735e-01f, -4.42508571e-02f, -5.13520427e-02f, 3.52776311e-02f, 9.05118585e-02f, 1.84248254e-01f, 6.66778460e-02f, 9.69883949e-02f, 1.38508990e-01f, 3.55230384e-02f,
  7.74392560e-02f, -1.47890195e-01f, -1.45172980e-03f, 5.46470061e-02f, -1.39749750e-01f, -2.88471252e-01f, -1.49054989e-01f, -1.38151258e-01f, -1.41927928e-01f, -6.03716969e-02f,
  -3.34125012e-02f, -1.00556128e-01f, 2.86728740e-02f, -1.55319244e-01f, -1.13347299e-01f, -1.42481312e-01f, -5.40141724e-02f, -6.87959976e-03f, 6.25675023e-02f, 7.88060352e-02f,
  5.87050579e-02f, 1.14064850e-01f, 1.95233315e-01f, 4.71640937e-02f, 6.62242919e-02f, 4.58590053e-02f, 1.22460581e-01f, 4.92632762e-02f, -5.54321334e-03f, -5.46779297e-02f,
  3.31946880e-01f, 1.07788168e-01f, 1.23935536e-01f, -1.86446607e-02f, -5.96677652e-04f, 2.85284072e-02f, -4.14976738e-02f, 2.95751337e-02f, 1.42780691e-02f, -1.38640106e-01f,
  -7.86302611e-02f, 8.24141651e-02f, -4.95734103e-02f, 7.49421585e-03f, 1.59316704e-01f, 2.15312801e-02f, -3.45150568e-02f, -2.80164275e-02f, 1.53033495e-01f, -1.56886727e-02f,
  7.00403601e-02f, -1.66475773e-01f, -4.29372899e-02f, -1.28969595e-01f, -4.21169437e-02f, 5.74375354e-02f, 4.21560705e-02f, 1.31664751e-02f, -5.34999091e-03f, 9.57159325e-02f,
  -7.99097791e-02f, 2.75614947e-01f, 1.74074546e-01f, 6.14835806e-02f, -1.19839638e-01f, -7.02692792e-02f, 1.41865805e-01f, 4.37241793e-02f, -5.55209890e-02f, -1.31702632e-01f,
  -5.46898209e-02f, -1.81221906e-02f, 3.98149379e-02f, -8.05876106e-02f, -2.27887556e-01f, -6.94864392e-02f, 2.01181248e-02f, 6.19940050e-02f, 1.12470433e-01f, 2.36047264e-02f,
  8.76200348e-02f, 7.10432455e-02f, 6.80372417e-02f, -5.04901707e-02f, 9.75996703e-02f, 1.14108935e-01f, -9.91321132e-02f, -7.56539255e-02f, -6.21452220e-02f, -1.92922041e-01f,
  4.40921634e-01f, -9.07867849e-02f, 7.83024728e-02f, -5.44561632e-02f, 1.00598559e-01f, 2.96724230e-01f, 7.49988779e-02f, -5.33423945e-02f, -1.58140376e-01f, -1.41842872e-01f,
  -4.38941754e-02f, -4.75991815e-02f, -9.34250876e-02f, 4.48741531e-03f, 1.15766428e-01f, -1.62612349e-01f, -2.32250944e-01f, 7.76739344e-02f, 1.34883076e-01f, 9.87124443e-02f,
  -1.55094430e-01f, -1.15747094e-01f, -8.20400938e-02f, -1.08607188e-01f, -3.32051992e-01f, -1.51940078e-01f, -1.23647764e-01f, -1.87785536e-01f, -3.68544683e-02f, -3.84981304e-01f,
  -9.30018350e-02f, 1.97707549e-01f, 3.10432278e-02f, 1.18409209e-01f, 3.66499014e-02f, -6.95736893e-03f, 8.23877007e-02f, -1.85308814e-01f, -6.72294497e-02f, -5.00664562e-02f,
  5.30240871e-02f, 9.15051904e-03f, 1.83435641e-02f, 4.47957143e-02f, 2.22546831e-02f, -1.19982855e-02f, -5.78007801e-03f, -7.94156939e-02f, -9.50910971e-02f, -9.76948738e-02f,
  3.45378928e-02f, 5.52872159e-02f, 1.34184733e-01f, 4.98695895e-02f, 1.88904643e-01f, 6.21984117e-02f, 7.67936558e-02f, 1.39629990e-01f, 1.52186126e-01f, -3.04801054e-02f,
  -2.49592245e-01f, 6.20333366e-02f, 5.59391864e-02f, 3.23802233e-02f, 1.83618650e-01f, 2.20525011e-01f, 6.91518979e-03f, 1.25905592e-02f, 7.73888901e-02f, -3.77036035e-02f,
  2.53572036e-02f, -1.22381873e-01f, 4.89609167e-02f, -4.62459847e-02f, 4.30754945e-02f, -6.76160073e-03f, -2.36059818e-02f, -3.68497111e-02f, -5.14313243e-02f, 1.88796185e-02f,
  6.45131767e-02f, -1.64953023e-01f, -1.88940465e-01f, -1.26272887e-01f, -1.12707645e-01f, -2.40174197e-02f, 3.85182872e-02f, -1.20460778e-01f, 1.06633939e-02f, -6.84657842e-02f,
  -3.22128713e-01f, 1.91284806e-01f, -1.50742605e-01f, -1.37034819e-01f, -7.32588675e-03f, 4.30433415e-02f, -7.63796568e-02f, -1.53182834e-01f, -1.42155141e-01f, -4.41624559e-02f,
  -3.01392041e-02f, -2.05773246e-02f, -6.83290213e-02f, -6.58688769e-02f, 2.18847930e-01f, 1.40459731e-01f, 1.87237170e-02f, -5.97369857e-02f, -1.00172803e-01f, -6.65327087e-02f,
  -1.33228377e-01f, 2.26952970e-01f, 1.24557056e-01f, 9.13115293e-02f, 1.22322343e-01f, 1.62726775e-01f, 6.83727562e-02f, 4.14016731e-02f, 1.98258340e-01f, -6.70815706e-02f,
  3.86520416e-01f, -1.35290325e-01f, 3.28208536e-01f, -5.09360433e-02f, -2.55870134e-01f, 5.24403602e-02f, -2.01059133e-01f, 2.76621226e-02f, 7.60486349e-03f, -5.06773852e-02f,
  1.10167138e-01f, 2.52278209e-01f, 2.48821646e-01f, 2.67271757e-01f, 2.79680431e-01f, -8.80024806e-02f, -7.14879930e-02f, 2.73368239e-01f, 4.14428443e-01f, 8.30251947e-02f,
  -2.21850961e-01f, -1.63430423e-01f, 2.73130894e-01f, 1.15647696e-01f, -1.80537075e-01f, 2.45406076e-01f, -3.85666788e-02f, -6.50909729e-03f, -5.56194447e-02f, -1.78024277e-01f,
  1.52295381e-01f, -2.34740704e-01f, 9.78032053e-02f, -6.31056502e-02f, -3.38728167e-02f, -1.32217677e-02f, 2.20369417e-02f, -9.66659561e-02f, -8.98275152e-02f, -4.14007716e-02f,
  -1.15528405e-02f, 3.29869464e-02f, -1.29141986e-01f, -1.73787177e-01f, -1.77155331e-01f, -2.85537411e-02f, -5.08126467e-02f, 2.18929220e-02f, 1.64628439e-02f, 9.57871601e-03f,
  -9.45458710e-02f, -2.37539440e-01f, -9.95286554e-02f, -8.19780603e-02f, -1.45632584e-04f, 3.54861915e-02f, 1.29603846e-02f, 4.48601134e-03f, 1.13116957e-01f, -4.01420780e-02f,
  -2.80053020e-02f, 3.47635038e-02f, 2.09528595e-01f, -2.58088727e-02f, 1.95808519e-04f, -4.96705286e-02f, -4.31415923e-02f, -7.51522183e-02f, -1.66518673e-01f, -4.92548123e-02f,
  8.10556337e-02f, 1.35707498e-01f, 9.21290442e-02f, -7.42309317e-02f, 2.38716304e-02f, -8.30731094e-02f, -2.83786748e-02f, 4.03769227e-05f, 4.87668179e-02f, -6.19791523e-02f,
  3.88382934e-02f, 5.43065146e-02f, -2.28274669e-02f, 7.94315934e-02f, 1.35810941e-01f, 4.55694273e-02f, 1.32349432e-02f, -5.46952970e-02f, -2.16296930e-02f, -6.66958988e-02f,
  -1.45606518e-01f, 1.68359861e-01f, 3.03235445e-02f, 2.79261288e-03f, -7.92049542e-02f, 9.27619934e-02f, 7.73865730e-02f, -6.44917339e-02f, -9.76210162e-02f, -4.48060781e-02f,
  5.38045261e-03f, 5.96323907e-02f, -8.19833726e-02f, -6.48812950e-02f, 4.33120579e-02f, -1.58880115e-01f, -1.37227863e-01f, -1.46150421e-02f, 3.86685617e-02f, -5.49302474e-02f,
  -8.47527832e-02f, -4.56471480e-02f, 1.30581290e-01f, 1.53087273e-01f, -5.21037541e-02f, 3.23224030e-02f, 2.00407952e-02f, 4.56502475e-02f, -3.46121541e-03f, -2.50882469e-02f,
  1.79729685e-01f, 3.88670899e-02f, -4.50333476e-01f, 2.81676620e-01f, -2.52545714e-01f, -1.99879125e-01f, 4.21241485e-02f, 2.46277645e-01f, 2.21970692e-01f, 7.48562859e-03f,
  -1.02328606e-01f, -6.70249611e-02f, -6.80502877e-02f, -7.92225599e-02f, -3.22890207e-02f, 2.86033358e-02f, -9.83105600e-02f, -2.25068852e-01f, -3.42117727e-01f, -1.44944802e-01f,
  -1.23281591e-02f, -3.51467840e-02f, 5.74151576e-02f, 6.42508781e-03f, 1.17614483e-02f, 6.42605737e-05f, -8.76151621e-02f, -1.18112825e-01f, -2.18161434e-01f, -1.64146170e-01f,
  -4.44543689e-01f, 8.65171384e-03f, -2.17182875e-01f, -1.51023790e-01f, -5.87979667e-02f, 1.06372602e-01f, -1.02497980e-01f, 9.87878535e-03f, 1.31641448e-01f, 1.02525346e-01f,
  -1.14586733e-01f, -4.13551591e-02f, -4.00886275e-02f, -1.39981464e-01f, -7.89262205e-02f, -6.37741536e-02f, 5.89922480e-02f, -9.22295451e-02f, -8.62384215e-02f, 1.25156567e-01f,
  -7.72298053e-02f, -1.50792792e-01f, -2.01161563e-01f, -4.90162671e-02f, -5.59069477e-02f, -6.79120123e-02f, 7.22242426e-03f, -1.41913146e-01f, -3.66015941e-01f, 2.19100490e-01f,
  1.29898682e-01f, -3.01827751e-02f, 1.36644598e-02f, 1.15579791e-01f, 1.99913248e-01f, 9.34678037e-03f, 2.01512650e-02f, 4.97744195e-02f, 1.03222422e-01f, -3.41198854e-02f,
  8.01509619e-02f, -1.25960290e-01f, 8.11060295e-02f, 4.15671878e-02f, -8.50593895e-02f, -3.22293416e-02f, 8.83259773e-02f, 6.30326942e-02f, -1.28563344e-02f, -2.91652773e-02f,
  -1.63582727e-01f, 7.74161937e-03f, 4.48963456e-02f, -2.40079165e-02f, -3.32815833e-02f, 8.58094990e-02f, -4.53189276e-02f, -3.87927890e-02f, 1.15554184e-02f, 6.55920655e-02f,
  1.98762417e-01f, -2.59477109e-01f, 2.14094892e-01f, -7.80490488e-02f, 5.95619529e-02f, 1.74396578e-02f, -1.97516486e-01f, 5.76265492e-02f, -3.58920693e-02f, -6.15210421e-02f,
  -2.02355772e-01f, 7.59177143e-03f, 5.51708862e-02f, -1.53005188e-02f, -1.04584090e-01f, -1.14020579e-01f, 1.04242720e-01f, -1.55122429e-01f, -6.41134754e-02f, 6.30472153e-02f,
  1.72190040e-01f, 8.70516226e-02f, 8.32981430e-03f, 6.78154975e-02f, 6.42863214e-02f, 6.44179713e-03f, 2.42655873e-02f, -6.94340989e-02f, -1.06840245e-02f, 2.03124419e-01f,
  7.76614189e-01f, 1.02057278e-01f, 1.74459368e-01f, 2.00064451e-01f, 2.74744123e-01f, 3.89619023e-01f, 3.58037680e-01f, 2.45243192e-01f, 8.53967667e-02f, 3.91773991e-02f,
  5.91951981e-02f, 6.19613491e-02f, -9.26760137e-02f, -1.02988787e-01f, -8.16543624e-02f, -2.99521885e-03f, -1.20326370e-01f, 3.68863866e-02f, 1.26095429e-01f, 4.18086313e-02f,
  -1.43555686e-01f, 1.02974502e-02f, 8.25757235e-02f, -1.41792476e-01f, -1.44892976e-01f, -2.59509653e-01f, -6.91112652e-02f, -5.30706272e-02f, -1.01703927e-01f, -5.06577909e-01f,
  -1.96532398e-01f, 1.84639186e-01f, -6.80484250e-02f, -2.36579347e-02f, -2.24115588e-02f, -5.87981790e-02f, -3.15983258e-02f, -1.69775765e-02f, 6.83931336e-02f, -7.06046401e-03f,
  -7.45156631e-02f, -3.93874459e-02f, 1.08351380e-01f, 2.89935842e-02f, 5.75516298e-02f, -2.46357638e-02f, 3.60109657e-02f, -3.83592136e-02f, -3.35245803e-02f, -9.72309783e-02f,
  3.59890657e-03f, 1.47252649e-01f, 2.77823746e-01f, 1.23061351e-01f, -1.02935210e-02f, -2.53543239e-02f, 5.55963442e-02f, -9.16638076e-02f, 5.31869531e-02f, -3.75674255e-02f,
  -8.54934454e-02f, 9.44308639e-02f, 1.22430429e-01f, 1.54513702e-01f, 3.39873843e-02f, 1.03205100e-01f, -7.70799816e-03f, -4.11571376e-03f, 2.67840959e-02f, -4.07623686e-02f,
  1.38197169e-02f, 1.98451877e-02f, 5.62356673e-02f, 8.59371573e-02f, -4.54751030e-02f, 5.19249290e-02f, 2.70670652e-02f, -7.23430514e-02f, -2.78503224e-02f, 4.50805090e-02f,
  4.90325429e-02f, -2.45991535e-02f, -4.65213321e-02f, -5.23366667e-02f, 4.33298526e-03f, -2.24600378e-02f, 1.83711369e-02f, -1.58804674e-02f, -8.68157893e-02f, -4.66424786e-02f,
  -1.39688969e-01f, 1.21749260e-01f, -2.05289781e-01f, -1.14126563e-01f, -1.11290447e-01f, 3.84298861e-02f, -2.46626567e-02f, -1.66072622e-01f, -6.15200773e-02f, -1.43955022e-01f,
  8.00087675e-02f, 4.43979225e-04f, -2.45481059e-02f, 5.74479699e-02f, 6.05363287e-02f, 8.66583064e-02f, 6.72889175e-03f, 7.87502900e-02f, -1.02108203e-01f, -1.58329025e-01f,
  -5.98584041e-02f, 2.69877195e-01f, 2.27500200e-01f, 1.15877397e-01f, -3.84194888e-02f, -4.78014052e-02f, -3.01494449e-02f, 1.32716512e-02f, 1.59661576e-01f, 1.23004377e-01f,
  2.87706494e-01f, -4.94045556e-01f, 1.72497854e-01f, -1.22043833e-01f, 1.27774805e-01f, 1.23643406e-01f, 2.05146760e-01f, -1.14241332e-01f, -1.22991815e-01f, -1.67738363e-01f,
  -2.05860928e-01f, 8.16304609e-03f, 7.15114921e-02f, 3.44751179e-02f, 1.40003368e-01f, 9.65481251e-02f, 9.36583057e-02f, 2.78917074e-01f, 3.60869110e-01f, -3.10336053e-02f,
  -2.06327915e-01f, -4.56801169e-02f, -6.83985054e-02f, 2.99723316e-02f, -1.48355678e-01f, 9.35388058e-02f, -7.25080371e-02f, -2.11918652e-02f, -1.95649207e-01f, -1.02081291e-01f,
  2.88836151e-01f, -9.68983173e-02f, 7.54674897e-02f, -4.87024598e-02f, -9.14128125e-02f, -1.24411970e-01f, 7.92780370e-02f, -1.18413001e-01f, 4.68443800e-03f, -4.18282710e-02f,
  3.51599902e-02f, -7.57182017e-02f, -2.16570478e-02f, -1.02647141e-01f, -1.20954536e-01f, 4.99892756e-02f, -2.09817618e-01f, -2.17147171e-01f, -1.65032059e-01f, -3.05107213e-03f,
  -2.12791935e-01f, -7.60197416e-02f, 2.69401167e-02f, 2.70623676e-02f, 2.48796549e-02f, 1.14641696e-01f, -8.17023963e-02f, -1.11698031e-01f, -6.33766428e-02f, -8.82150382e-02f,
  1.89445075e-02f, 1.43182665e-01f, 2.99075479e-03f, -6.51503429e-02f, 1.58692542e-02f, 1.40660211e-01f, -4.67890408e-04f, 6.08812198e-02f, -3.65965464e-03f, -7.74323475e-03f,
  -1.57341316e-01f, -4.72573303e-02f, -1.42152160e-01f, -2.99817137e-02f, -7.53434971e-02f, -3.38707641e-02f, 8.31838399e-02f, -4.03896198e-02f, -5.78724071e-02f, -7.66599923e-02f,
  -1.11457296e-01f, -2.84071057e-03f, 7.51003399e-02f, -7.56992996e-02f, -1.35282174e-01f, -5.97278811e-02f, 1.54704810e-03f, -4.27026227e-02f, 7.42091238e-02f, -9.52804089e-02f,
  -2.38109697e-02f, 1.52308166e-01f, 1.65197760e-01f, -4.89265146e-03f, 4.74844277e-02f, 2.85653165e-03f, 2.05036718e-02f, -3.81940678e-02f, 1.57530624e-02f, 9.08769201e-03f,
  -1.28356228e-02f, 6.40766248e-02f, 7.42357299e-02f, 1.65172666e-03f, 3.81821059e-02f, 1.28285185e-01f, -1.17898129e-01f, 1.27446845e-01f, -9.08454955e-02f, 8.04045573e-02f,
  -9.48068500e-02f, 2.22334146e-01f, 2.65618265e-01f, 1.27872214e-01f, 1.97058961e-01f, 3.64224315e-01f, 1.94178686e-01f, 5.11085205e-02f, 1.85425684e-01f, 1.57152325e-01f,
  -4.17507589e-01f, -9.51729491e-02f, -1.40086427e-01f, -2.54421055e-01f, 1.25336409e-01f, 1.04878239e-01f, 2.41015971e-01f, -1.57668799e-01f, -4.87665161e-02f, 3.72698791e-02f,
  1.69417664e-01f, 9.20003727e-02f, -7.76765030e-03f, 1.31067172e-01f, 4.71620485e-02f, 8.69363546e-02f, -2.54125847e-03f, -7.51978159e-02f, 6.48611784e-02f, 2.77778476e-01f,
  2.57447094e-01f, -8.40236619e-02f, -3.07384580e-01f, -6.22646473e-02f, -1.07506111e-01f, -2.03170236e-02f, -9.11431983e-02f, -1.20123163e-01f, 2.00368706e-02f, -1.25950202e-01f,
  9.17384494e-03f, -1.66387960e-01f, 5.14478013e-02f, 1.18595771e-01f, 5.31036630e-02f, -2.49919176e-01f, -1.69685736e-01f, -1.55200645e-01f, -9.91790742e-02f, -5.10645770e-02f,
  -9.73631889e-02f, 4.81711924e-02f, 9.16065276e-03f, 5.27773350e-02f, -4.08178419e-02f, -7.04824552e-02f, 3.46947950e-03f, -1.15861006e-01f, -2.59699225e-01f, -5.10899983e-02f,
  3.89138907e-02f, -4.87609878e-02f, 6.62813187e-02f, -9.51229334e-02f, -1.35991409e-01f, 3.20654027e-02f, -1.35344774e-01f, -1.82867125e-01f, -1.96889713e-01f, -4.83513474e-01f,
  1.28567234e-01f, 2.66544111e-02f, 7.09030330e-02f, -2.84140557e-02f, -3.57453451e-02f, -2.22212970e-02f, 7.22890869e-02f, 1.14506252e-01f, -6.66349940e-03f, -1.20252416e-01f,
  5.88235557e-02f, 1.74543664e-01f, 4.40766960e-02f, -1.12606501e-02f, -9.88082215e-03f, -3.04178987e-02f, 2.42588539e-02f, -1.30950645e-01f, -4.37944233e-02f, -9.91619527e-02f,
  1.64927348e-01f, 1.99422557e-02f, -1.15532175e-01f, -7.53475539e-03f, 9.97888744e-02f, 3.02244890e-02f, -1.87707081e-01f, 1.80459488e-02f, -1.11426026e-01f, -1.05228812e-01f,
  -2.71987110e-01f, 1.38146192e-01f, 3.14380676e-02f, 1.02857739e-01f, -8.78315791e-02f, -4.97491732e-02f, -7.66392425e-02f, 1.05799668e-01f, 2.33604357e-01f, 8.97589922e-02f,
  9.10026357e-02f, 4.29497985e-03f, -4.39975411e-02f, 9.72159505e-02f, 2.06368476e-01f, -5.15040420e-02f, 7.73489624e-02f, 4.17626537e-02f, -2.01182161e-02f, -2.30574608e-01f,
  -2.01037690e-01f, 1.14491925e-01f, -2.15894692e-02f, -2.67064646e-02f, -1.59982398e-01f, -7.08205858e-03f, -2.40818053e-01f, -1.59566864e-01f, -1.67281762e-01f, -3.61304253e-01f,
  1.95563152e-01f, -2.68784463e-01f, -2.23148093e-01f, -4.23159227e-02f, -2.18183383e-01f, -2.81857606e-02f, -2.09090352e-01f, 1.00218967e-01f, 1.13589332e-01f, -3.87251168e-01f,
  -9.56135765e-02f, 2.70855308e-01f, 1.26356691e-01f, 6.18332066e-02f, 2.48720959e-01f, -2.89399773e-01f, -2.87939608e-01f, 1.72947794e-01f, 3.04216206e-01f, 7.88381845e-02f,
  2.45315880e-02f, 1.18637748e-01f, 3.38047326e-01f, 1.09129548e-01f, -1.76572740e-01f, 1.30249828e-01f, -5.55974320e-02f, -8.94237906e-02f, -1.35525912e-01f, -4.73749936e-01f,
  -2.91954249e-01f, -7.85478875e-02f, 1.44663462e-02f, 2.07643643e-01f, -1.64133653e-01f, 7.14643672e-02f, -1.83857698e-02f, -8.23650733e-02f, -1.19209565e-01f, -1.17311351e-01f,
  -1.50916338e-01f, -2.72175614e-02f, 3.31427343e-02f, 2.05636807e-02f, -8.70410644e-04f, -8.69665220e-02f, -4.93755937e-02f, 8.25490206e-02f, -1.72649361e-02f, -1.66230872e-01f,
  -1.32281303e-01f, -1.40535101e-01f, -1.56689033e-01f, -3.52275968e-02f, -6.20716661e-02f, -6.73129363e-03f, -3.57098058e-02f, -8.65374878e-02f, 1.33217916e-01f, -1.07072592e-01f,
  -1.53725659e-02f, -7.63210431e-02f, -8.40952769e-02f, 8.84560030e-03f, -2.65952684e-02f, -7.95332938e-02f, -5.49126975e-02f, 6.33790195e-02f, 1.00022480e-02f, -1.45330086e-01f,
  -2.66348161e-02f, 1.05270473e-02f, -9.12144929e-02f, 8.93628895e-02f, 3.89763601e-02f, 6.38809949e-02f, -4.11541760e-02f, -6.95938617e-02f, 6.68442473e-02f, 4.38885614e-02f,
  7.68781975e-02f, -8.59429017e-02f, -1.70396883e-02f, -1.84681881e-02f, 6.27023354e-02f, -3.72703709e-02f, -6.57130033e-02f, -7.87383318e-03f, 1.38870597e-01f, 5.52592017e-02f,
  2.48283461e-01f, 1.06916815e-01f, -1.32442921e-01f, 1.64479360e-01f, -1.21853240e-01f, -6.79404214e-02f, -7.49498978e-02f, 5.80754094e-02f, 3.37074883e-02f, -2.00014301e-02f,
  3.47118117e-02f, 3.79341468e-02f, -1.21324034e-02f, -2.93951519e-02f, -6.17564917e-02f, 9.49070975e-02f, 1.84550025e-02f, 1.01005942e-01f, 1.15011521e-01f, -7.95313865e-02f,
  3.87270413e-02f, 8.78887847e-02f, 1.02316156e-01f, -1.15965165e-01f, 6.24805838e-02f, 5.21290712e-02f, -8.23583752e-02f, -1.38313428e-01f, 4.71150167e-02f, 2.41918559e-03f,
  2.05381155e-01f, 7.88832679e-02f, -1.19451597e-01f, -6.26585260e-02f, -2.69100577e-01f, -1.12353273e-01f, -9.11132023e-02f, 4.11330089e-02f, 8.89637470e-02f, -1.01514176e-01f,
  -1.15905486e-01f, 6.37027472e-02f, 1.57920271e-01f, 9.30145830e-02f, 2.09331051e-01f, -7.85680786e-02f, -1.89800739e-01f, -8.07682797e-03f, 2.17479929e-01f, -1.06457025e-02f,
  -1.62122324e-01f, 7.32697248e-02f, -5.07860817e-03f, 7.83703849e-03f, -1.69882253e-01f, 3.93220922e-03f, -2.10634336e-01f, -2.09254563e-01f, -9.68198106e-02f, -1.64377213e-01f,
  2.12880731e-01f, -1.29106581e-01f, -2.93890417e-01f, -1.45036638e-01f, -8.72446224e-02f, 1.42913405e-02f, 1.17887771e-02f, -1.07561857e-01f, -4.35139379e-03f, -1.86409548e-01f,
  -1.92621872e-01f, -8.58008787e-02f, 4.99480171e-03f, 1.71726555e-01f, -2.09198985e-02f, 2.12806389e-01f, -6.07356578e-02f, 8.65145326e-02f, 1.12496428e-02f, -3.76950055e-02f,
  1.04804682e-02f, -1.46279737e-01f, 2.44195629e-02f, 3.94002944e-02f, 1.15921363e-01f, 3.98831032e-02f, -1.16672911e-01f, 3.87465470e-02f, -9.97759681e-03f, 6.07221350e-02f,
  -1.41237810e-01f, 1.89327493e-01f, -6.48783296e-02f, 1.95876688e-01f, 1.77683666e-01f, -3.89764756e-02f, 3.33389826e-02f, 2.93854661e-02f, 3.63998339e-02f, -1.53861567e-01f,
  -5.08703804e-03f, -8.69556218e-02f, -1.16542362e-01f, 2.89504621e-02f, 4.66473959e-02f, -1.40832916e-01f, -3.87909114e-02f, 2.20086917e-01f, -9.42321718e-02f, -2.62721423e-02f,
  -4.54535931e-02f, -1.15228601e-01f, -1.33259416e-01f, -1.60637237e-02f, -7.21428543e-02f, -1.19084930e-02f, -8.98476392e-02f, -5.81980869e-03f, -1.00051783e-01f, 7.26942569e-02f,
  3.15591961e-01f, -2.37881541e-01f, 1.00637053e-03f, -3.53008471e-02f, -7.54390210e-02f, 4.06948887e-02f, -4.57993709e-02f, -2.77522486e-03f, -3.25115630e-03f, 7.47133605e-03f,
  -2.82538719e-02f, -2.61395816e-02f, 6.04686737e-02f, -1.01062916e-02f, -2.13358887e-02f, -7.95029998e-02f, 4.40432765e-02f, 1.00560121e-01f, -6.68856055e-02f, -2.48465419e-01f,
  -5.32891555e-03f, -5.35117835e-02f, 1.67585552e-01f, 1.07285194e-01f, 1.24237716e-01f, 1.19672172e-01f, 7.82298818e-02f, 4.83081378e-02f, 1.02982394e-01f, 3.12841162e-02f,
  2.59181624e-03f, 1.94129109e-01f, 1.43925861e-01f, 1.34453429e-02f, -2.72634774e-01f, -5.01045883e-01f, -3.59956056e-01f, -1.47395030e-01f, -8.66602287e-02f, -8.04432929e-02f,
  -2.43566588e-01f, -2.24884395e-02f, 1.81065947e-01f, 1.40278861e-01f, 3.69004868e-02f, 1.17364518e-01f, 3.56548607e-01f, 1.53507918e-01f, -1.14028007e-01f, -1.75622538e-01f,
  5.94345778e-02f, 1.48654923e-01f, 1.12778485e-01f, 1.17543377e-02f, 1.52350143e-01f, 3.28026190e-02f, 1.90469369e-01f, -5.66625968e-03f, -4.23184074e-02f, 4.79299933e-01f,
  1.23326741e-01f, -2.20290013e-02f, -1.10410459e-01f, -7.89923593e-02f, 6.95991367e-02f, 1.10253155e-01f, -1.04434052e-02f, 2.04132929e-01f, -5.94827160e-02f, 7.83894677e-03f,
  6.78124204e-02f, -7.33114481e-02f, -1.44830775e-02f, 3.98061834e-02f, -4.68020663e-02f, -1.34450316e-01f, 1.06069721e-01f, 3.00655723e-01f, 1.97907001e-01f, 1.11634910e-01f,
  1.29901707e-01f, -1.88808203e-01f, -2.04661638e-01f, -1.57021374e-01f, -8.52450281e-02f, -1.42554808e-02f, -2.17817441e-01f, -8.99070278e-02f, -1.68731317e-01f, 7.79803470e-02f,
  -4.53887023e-02f, 2.85672918e-02f, 1.50210246e-01f, 1.54307261e-01f, 1.76712777e-02f, 7.82144144e-02f, 2.48562787e-02f, 2.54871435e-02f, 2.68770941e-02f, 1.00209542e-01f,
  -1.20620072e-01f, -7.15107992e-02f, 5.77088520e-02f, 6.35310262e-02f, 2.47600134e-02f, 1.46434493e-02f, 3.80181931e-02f, -1.05726710e-02f, -1.34105450e-02f, -7.34074190e-02f,
  7.86915794e-02f, 1.52176455e-01f, 9.26379859e-02f, 9.00105685e-02f, -1.25819102e-01f, 3.46115641e-02f, -1.19587466e-01f, -9.23988372e-02f, 1.14003576e-01f, -7.00943097e-02f,
  -8.84053782e-02f, -1.21883027e-01f, 1.42872259e-01f, 1.36267111e-01f, 4.35737818e-02f, -9.04095024e-02f, 1.25837654e-01f, -3.44620571e-02f, -5.43647371e-02f, -2.36629415e-02f,
  -2.87793130e-01f, -4.46066484e-02f, 1.06327860e-02f, 8.93134028e-02f, -1.03369564e-01f, -1.45821109e-01f, 3.43859307e-02f, 5.08710146e-02f, 1.67207960e-02f, -4.97326627e-02f,
  -9.86445025e-02f, -3.49701732e-01f, -1.45054981e-01f, -6.47769794e-02f, 1.01331443e-01f, -2.77815610e-01f, -1.91431090e-01f, -2.20304653e-01f, -2.01659456e-01f, -3.98765266e-01f,
  -6.16597772e-01f, -3.82644027e-01f, 3.66933197e-01f, -1.05137832e-01f, 2.37934992e-01f, 3.26280475e-01f, 4.34420019e-01f, -3.77456844e-03f, -1.72241837e-01f, -1.34824077e-02f,
  -7.31839016e-02f, -2.43121773e-01f, -2.64008462e-01f, -1.46874547e-01f, 2.37928778e-02f, 3.20227534e-01f, 4.23338801e-01f, 1.27518460e-01f, 4.10537459e-02f, 7.21425116e-02f,
  7.16006979e-02f, -1.76150292e-01f, -4.18395042e-01f, -2.54384845e-01f, 1.85965579e-02f, -2.72970125e-02f, 6.54044300e-02f, -4.91278581e-02f, -4.49327007e-02f, -2.54323818e-02f,
  1.93643421e-01f, -1.96873143e-01f, 1.79887846e-01f, -2.58434206e-01f, 6.29844218e-02f, -1.67965204e-01f, 5.27056027e-03f, -4.69499826e-03f, -1.14693241e-02f, 5.28664561e-03f,
  -1.50882572e-01f, -1.00743428e-01f, -5.23433164e-02f, 6.69811741e-02f, 6.58219010e-02f, -9.75049809e-02f, -2.74074841e-02f, -1.65690199e-01f, -1.69997647e-01f, -6.91077337e-02f,
  1.36527158e-02f, -8.39865059e-02f, 6.38043582e-02f, 7.26097599e-02f, -2.15240475e-02f, -1.21900767e-01f, -1.34309277e-01f, -9.72103626e-02f, -1.16070732e-01f, 3.75436135e-02f,
  -4.93578659e-03f, 6.62877485e-02f, 3.63400988e-02f, 4.83143404e-02f, 9.34171155e-02f, 9.28117111e-02f, 8.06108117e-02f, 7.68582383e-03f, 1.37385363e-02f, -5.15276156e-02f,
  1.25137893e-02f, 8.83589983e-02f, 4.01947647e-02f, -5.40088788e-02f, -4.45599854e-02f, -1.40606552e-01f, 4.29597721e-02f, -5.63901067e-02f, 1.62136871e-02f, 4.84899879e-02f,
  -9.96451229e-02f, -4.87597361e-02f, -3.85996439e-02f, 6.05431711e-03f, -1.70570221e-02f, 2.16416661e-02f, -2.39776401e-03f, -1.56077430e-01f, 2.46656723e-02f, -5.33888750e-02f,
  4.57565598e-02f, -3.69357169e-02f, 1.30146518e-01f, -3.28413234e-03f, 4.53314222e-02f, -9.33384821e-02f, -1.04269199e-01f, -1.48966968e-01f, -3.22831087e-02f, -4.57395390e-02f,
  -1.26139402e-01f, 5.82484417e-02f, 8.46811309e-02f, 5.46267368e-02f, 1.45350501e-01f, 3.85926962e-02f, 3.41608189e-02f, -1.17493831e-02f, 7.90497661e-03f, 5.61262555e-02f,
  1.52536388e-02f, 5.84806167e-02f, 1.03193820e-01f, 1.21815361e-01f, 6.52300715e-02f, 1.38006732e-01f, 1.58565685e-01f, 1.12115659e-01f, 1.16742238e-01f, 2.44156912e-01f,
  3.86683822e-01f, 1.01733036e-01f, -5.10942796e-03f, 1.95509568e-01f, 6.95827678e-02f, -9.65621099e-02f, 4.59166579e-02f, -1.10902868e-01f, 3.00122108e-02f, -2.72135348e-05f,
  1.82691336e-01f, 4.90669347e-02f, 1.06794536e-01f, 9.87186655e-02f, 1.56811893e-01f, -4.71736379e-02f, -1.91460680e-02f, -1.95658933e-02f, 5.39833084e-02f, 3.70323882e-02f,
  -1.00444555e-01f, -2.80957995e-03f, -4.67478074e-02f, -1.72368467e-01f, -4.18451428e-02f, 2.14688834e-02f, -3.39987502e-02f, 2.74736341e-02f, 6.46215007e-02f, 1.43060461e-01f,
  2.50444621e-01f, 1.48032457e-01f, -1.31889760e-01f, -5.84047250e-02f, 7.59213269e-02f, -1.78900316e-01f, -1.19616471e-01f, -9.92027596e-02f, -1.24091193e-01f, -5.72900474e-03f,
  -2.60527432e-02f, 2.74506584e-03f, 1.10180870e-01f, 5.15789865e-03f, -1.17718466e-01f, -9.19956490e-02f, 3.05857211e-02f, -2.78330944e-03f, -2.37646792e-02f, -3.96704040e-02f,
  1.34761678e-02f, 7.37991855e-02f, 6.89900294e-02f, -6.95492774e-02f, 2.91917175e-02f, -2.66969815e-04f, 9.30927172e-02f, -4.74305637e-02f, -1.33066056e-02f, -2.07210258e-02f,
  -7.64728189e-02f, 3.00383568e-02f, 1.53117450e-02f, -2.75637936e-02f, -4.72899824e-02f, -1.29473256e-02f, 7.21292645e-02f, 1.55764192e-01f, 7.59246852e-03f, 4.60923389e-02f,
  3.94394733e-02f, -1.08292453e-01f, -7.20204040e-02f, -3.39458920e-02f, -9.88487061e-03f, -6.83295950e-02f, -1.36933364e-02f, -3.41015086e-02f, 1.36905476e-01f, -3.72821428e-02f,
  1.84640512e-02f, -6.96914084e-03f, -1.12583779e-01f, -5.07134758e-02f, -1.27872735e-01f, 1.20598450e-01f, -5.79938963e-02f, -1.58598259e-01f, -1.05860673e-01f, -2.74370939e-01f,
  -8.59929919e-02f, -4.09827903e-02f, 9.85598415e-02f, -4.91854884e-02f, 6.78676590e-02f, 3.62737626e-02f, 7.53038302e-02f, 3.65513191e-02f, 1.10431537e-02f, -4.09568101e-02f,
  6.54942989e-02f, 9.26359743e-02f, 1.70029569e-02f, -1.04315981e-01f, -1.62234545e-01f, -2.02767864e-01f, -2.72831824e-02f, -5.32807261e-02f, -1.71790361e-01f, -1.07087977e-01f,
  -1.44321159e-01f, -5.53038940e-02f, 3.25940317e-03f, -6.81842119e-02f, -1.55132756e-01f, -1.52627677e-01f, -5.54270856e-02f, -5.14553562e-02f, -7.48943165e-02f, -8.12047198e-02f,
  3.15396130e-01f, -1.39782384e-01f, 9.14946347e-02f, 2.31656715e-01f, -2.02294737e-01f, -2.26826563e-01f, -1.64239168e-01f, 1.51353572e-02f, -1.01386604e-03f, 3.13006490e-02f,
  -2.28036299e-01f, 8.93897936e-02f, 9.69150737e-02f, 1.63218286e-02f, -1.81335746e-03f, 9.80528221e-02f, 1.06294341e-01f, 1.20373294e-01f, 1.82364941e-01f, 6.79684430e-02f,
  -9.09263566e-02f, -1.17132552e-01f, -4.83764820e-02f, 1.08048081e-01f, 1.03550881e-01f, 9.75476354e-02f, -1.12817198e-01f, -6.43704683e-02f, -5.85236326e-02f, 2.73797005e-01f,
  -4.81164567e-02f, 1.35602638e-01f, 9.57826450e-02f, -7.23406598e-02f, -6.75849691e-02f, -4.98634540e-02f, 9.95207112e-04f, -9.29631218e-02f, -3.82053293e-02f, -8.51928294e-02f,
  -1.25493392e-01f, -1.33482113e-01f, -9.01965573e-02f, -4.56246622e-02f, 1.70927569e-02f, -4.09516273e-03f, 3.01927282e-03f, 9.73772537e-03f, 1.09403983e-01f, -7.82302916e-02f,
  -5.51712932e-03f, -1.09485209e-01f, -1.12505436e-01f, 7.32906675e-03f, 6.66709617e-02f, 6.72212690e-02f, -1.03548340e-01f, 3.85137461e-02f, 5.03808223e-02f, 7.96198472e-02f,
  8.86299014e-02f, 4.16423641e-02f, 1.71408057e-03f, 5.40124178e-02f, 1.55183837e-01f, 1.18868820e-01f, 4.69642878e-02f, 4.57731746e-02f, 5.30668423e-02f, 4.09315005e-02f,
  6.47149011e-02f, 1.17440082e-01f, 7.44634047e-02f, 3.03490553e-02f, 3.01285852e-02f, -9.32825282e-02f, -1.42751679e-01f, -1.87259987e-02f, 1.16739767e-02f, -7.87560195e-02f,
  1.90592229e-01f, 1.31002218e-01f, -2.33289134e-02f, 3.17858681e-02f, 1.16412945e-01f, 9.40850526e-02f, 7.29186684e-02f, 3.95364240e-02f, 7.90329501e-02f, -5.90829132e-03f,
  -5.10393977e-01f, -1.64154842e-01f, 2.82720216e-02f, -4.20522038e-03f, -6.95965365e-02f, -1.61512330e-01f, -3.08958516e-02f, -2.10126750e-02f, -2.21105769e-01f, 2.80214790e-02f,
  -6.11099973e-02f, -9.38636810e-03f, -1.71311185e-01f, 4.27997932e-02f, 6.79945275e-02f, -1.57384232e-01f, -1.10157177e-01f, -1.12426914e-01f, -1.35202423e-01f, 7.57159991e-03f,
  1.12480119e-01f, -1.50276229e-01f, -1.47753552e-01f, 3.32279168e-02f, 2.34030858e-02f, -6.38228580e-02f, -1.04685955e-01f, -3.33550051e-02f, -8.51964653e-02f, -5.12747169e-02f,
  -8.10431600e-01f, -3.46861929e-01f, 2.57470399e-01f, 6.44106343e-02f, 2.70260423e-01f, 2.09071428e-01f, 3.98499072e-01f, 2.29104251e-01f, -2.91689560e-02f, -1.10781468e-01f,
  -2.33090952e-01f, -4.67728488e-02f, -7.52231479e-02f, -9.62120146e-02f, 5.72990254e-02f, 2.94946998e-01f, 3.65624458e-01f, 6.34747222e-02f, 2.14216679e-01f, 5.48646823e-02f,
  1.84853211e-01f, 8.35219994e-02f, -1.96999773e-01f, -1.28629087e-02f, 4.61759008e-02f, 1.11510463e-01f, 1.14061825e-01f, 3.13128345e-02f, -9.25778076e-02f, 2.43872240e-01f,
  2.87878275e-01f, -1.65279165e-01f, -4.55762148e-02f, -1.88906074e-01f, -1.38316795e-01f, -1.30403534e-01f, -8.35331827e-02f, -6.44988641e-02f, 3.50952409e-02f, 4.56629274e-03f,
  3.43033262e-02f, 1.75340530e-02f, -2.18289737e-02f, -1.13425583e-01f, 1.13820180e-01f, 2.41905116e-02f, -1.46393999e-01f, -2.14994163e-03f, 2.17957690e-01f, 2.48130988e-02f,
  2.41131298e-02f, -8.09183419e-02f, -3.64461243e-02f, -4.90618730e-03f, -1.42478198e-03f, -9.84295364e-03f, -4.60751578e-02f, -1.56090409e-01f, -7.79768080e-02f, -9.64597836e-02f,
  5.26823290e-02f, -5.46181761e-02f, 4.78306599e-02f, -5.85186444e-02f, -2.07190309e-02f, 2.32334193e-02f, 7.47581571e-02f, 5.61447367e-02f, -5.78411110e-03f, -7.10809156e-02f,
  5.28974794e-02f, 5.93643412e-02f, 2.31723096e-02f, -4.70654033e-02f, 1.41899334e-02f, 5.24380282e-02f, 4.82026823e-02f, -7.64226075e-03f, -9.19219106e-02f, -1.20342337e-01f,
  -1.23084769e-01f, 9.93791148e-02f, 2.19677035e-02f, 8.61769319e-02f, 4.14345562e-02f, 4.08043526e-02f, 6.98851272e-02f, -6.23874925e-02f, -5.32774888e-02f, 1.77783109e-02f,
  3.45762640e-01f, -1.73695058e-01f, 6.13543913e-02f, -7.55018815e-02f, 7.88191613e-03f, -1.22512370e-01f, -3.06689348e-02f, -4.58769314e-02f, 1.16755180e-01f, 1.69741601e-01f,
  -3.26684378e-02f, -6.62416816e-02f, 6.12347806e-03f, 1.07157506e-01f, 2.94317473e-02f, 4.57299016e-02f, -4.03217785e-02f, 2.20954657e-01f, 1.93477079e-01f, 1.98947251e-01f,
  1.05223320e-02f, 1.83397859e-01f, 1.80877119e-01f, 1.04971796e-01f, 5.09699583e-02f, 1.92284763e-01f, 1.32186949e-01f, 1.29089639e-01f, 1.68112084e-01f, -5.98843247e-02f,
  -7.66502470e-02f, 1.70316175e-01f, -4.32182670e-01f, 2.34204456e-02f, -2.04971910e-01f, 9.75208431e-02f, -2.97607738e-04f, 2.46946692e-01f, 2.52902269e-01f, 3.17205377e-02f,
  5.32394201e-02f, -1.12962873e-04f, -3.97116430e-02f, 1.13686360e-02f, 2.77943518e-02f, 9.66921542e-03f, -1.34783298e-01f, -2.02165514e-01f, 6.69227354e-03f, 2.25526854e-01f,
  9.35849398e-02f, 1.35341957e-01f, 1.00238547e-01f, 2.25977674e-01f, 2.61456463e-02f, 9.19212773e-02f, -7.29669258e-02f, -5.96954226e-02f, -1.36501431e-01f, -4.65147257e-01f,
  -3.01183194e-01f, -2.37039119e-01f, -1.59360945e-01f, -1.16366073e-01f, -3.23049352e-02f, 3.89761269e-01f, 1.14294156e-01f, -1.03735179e-01f, -1.15847535e-01f, 6.36000410e-02f,
  -2.19788358e-01f, -5.73780062e-03f, 3.02731496e-04f, -1.77789778e-01f, 4.09881696e-02f, 6.38271049e-02f, 2.10558429e-01f, 1.48886684e-02f, 6.90934509e-02f, 2.95260195e-02f,
  -9.63592529e-02f, -1.75620750e-01f, -1.19877405e-01f, -8.96365196e-02f, -5.54056875e-02f, 7.41113946e-02f, 8.75656381e-02f, -6.11657798e-02f, -1.50611684e-01f, 1.19060099e-01f,
  5.60846068e-02f, -3.65447029e-02f, -6.43803030e-02f, 6.80491105e-02f, 8.32566619e-02f, 4.44764271e-02f, -1.68466404e-01f, -6.94478303e-02f, 9.73116904e-02f, -3.02624647e-02f,
  -2.23272983e-02f, -5.79525195e-02f, -3.12905833e-02f, 8.09786096e-02f, -1.30866826e-01f, -6.15336485e-02f, 3.03333607e-02f, -2.49740928e-02f, 6.22776598e-02f, -1.30956322e-01f,
  -5.07112555e-02f, -6.62998902e-03f, 1.42002434e-01f, 7.24335685e-02f, 2.49653356e-03f, 4.21224199e-02f, 1.19776823e-01f, -5.06149195e-02f, 1.13266371e-02f, 6.26669899e-02f,
  7.74893761e-02f, -8.99691805e-02f, 1.13585807e-01f, -5.09003364e-02f, -1.19057484e-01f, -2.92838439e-02f, -3.97705846e-02f, 1.39890268e-01f, -1.10757217e-01f, -8.92443731e-02f,
  -1.17131688e-01f, -5.31201251e-02f, -6.37314171e-02f, -8.11359361e-02f, 4.79738880e-03f, -7.60142580e-02f, 1.14353627e-01f, -1.29511297e-01f, 3.00063267e-02f, 1.15646809e-01f,
  8.06542933e-02f, 1.23216175e-01f, -3.87514010e-02f, -1.44832611e-01f, -6.32649586e-02f, -2.35633217e-02f, 4.93263714e-02f, -4.40382073e-03f, -1.29771248e-01f, 1.02184452e-01f,
  -5.65411448e-01f, 3.74594569e-01f, 1.23193227e-01f, -2.95483649e-01f, 1.43376410e-01f, 2.88777113e-01f, 5.85441887e-01f, 1.40842468e-01f, -1.28739432e-01f, -1.14532458e-02f,
  2.13609502e-01f, -3.22099209e-01f, -1.03678003e-01f, -3.32659110e-02f, 1.52230650e-01f, 2.43166581e-01f, 2.68930141e-02f, -1.52031705e-01f, -2.80174017e-01f, -9.94579792e-02f,
  -2.51819603e-02f, -2.07698330e-01f, -3.49259168e-01f, -2.25206763e-01f, -2.54094929e-01f, -3.28391016e-01f, 9.13513824e-03f, 1.87961087e-02f, 7.29386136e-02f, -1.81348190e-01f,
  -8.89112130e-02f, 2.62680948e-01f, -4.30852436e-02f, -1.65620044e-01f, -7.43875578e-02f, -1.38684034e-01f, -4.40410823e-02f, -9.26807150e-02f, 4.51702103e-02f, -1.63273867e-02f,
  -2.11459398e-02f, 1.12020791e-01f, -1.56121790e-01f, 1.73132271e-02f, 9.19840187e-02f, 5.36332577e-02f, 1.10631943e-01f, 7.52908066e-02f, 4.83237803e-02f, -1.30796048e-03f,
  1.70400754e-01f, 9.44082066e-02f, 1.30991250e-01f, 1.07617415e-01f, 1.82484582e-01f, 2.50533968e-02f, 8.62873942e-02f, 5.40693738e-02f, 7.01771975e-02f, -2.15553433e-01f,
  4.08739783e-02f, 3.04620583e-02f, -2.29392499e-02f, 1.55577250e-03f, 8.51385891e-02f, -1.10132746e-01f, -7.25679919e-02f, 1.04162082e-01f, -2.81583201e-02f, -4.89119720e-03f,
  6.27994314e-02f, 7.96923935e-02f, 5.47927730e-02f, -5.74981049e-02f, 5.68036735e-03f, 4.76820320e-02f, 7.34136179e-02f, 3.77661996e-02f, -1.15637275e-04f, 5.54254055e-02f,
  -5.81989959e-02f, 3.00889350e-02f, -7.52447248e-02f, -2.14663781e-02f, 1.73498899e-01f, -5.21099614e-03f, 7.41608115e-03f, 3.95400859e-02f, 2.22705901e-02f, 6.08205646e-02f,
  -2.05292270e-01f, 3.11086506e-01f, -2.37948716e-01f, 2.66322847e-02f, 2.15324126e-02f, 8.34582597e-02f, 5.03935143e-02f, -2.97858827e-02f, 2.42383610e-02f, 7.74979517e-02f,
  6.54285848e-02f, -1.27114449e-02f, 4.03261259e-02f, 2.13888120e-02f, -1.23530747e-02f, -3.66630107e-02f, 8.05236474e-02f, -1.01764008e-01f, 5.60305975e-02f, 4.13753614e-02f,
  3.47943865e-02f, -6.58400431e-02f, -1.29270434e-01f, -2.42162813e-02f, 4.47881036e-03f, -1.53342187e-01f, -3.04867737e-02f, -6.27633631e-02f, -1.42685957e-02f, -2.25501552e-01f,
  -2.96174824e-01f, -7.50392769e-03f, -2.51543909e-01f, 1.76606819e-01f, 2.22401142e-01f, 1.05880015e-01f, 2.56984413e-01f, 1.08507089e-01f, 1.01318941e-01f, 9.67287049e-02f,
  -5.69829196e-02f, 8.23787302e-02f, 1.64118022e-01f, 1.98454961e-01f, 1.77669093e-01f, 2.48599380e-01f, 2.50295222e-01f, -2.24315468e-02f, -1.24198154e-01f, 4.18784693e-02f,
  1.23839177e-01f, -3.25663686e-02f, -2.44008124e-01f, 6.05947487e-02f, 1.00304656e-01f, 1.67402104e-01f, -2.69792862e-02f, -3.35219763e-02f, 3.44329774e-02f, 1.86988458e-01f,
  -2.33330786e-01f, -2.07361192e-01f, 2.01799087e-02f, 1.43062966e-02f, -2.16092139e-01f, -2.37111375e-01f, -2.23089099e-01f, -1.93640217e-01f, -1.69250384e-01f, -2.05869988e-01f,
  -1.28052086e-01f, 6.54227706e-03f, 9.40262601e-02f, 8.48834217e-02f, -4.13453616e-02f, -5.54887466e-02f, 3.57069597e-02f, 1.29775345e-01f, 3.67581435e-02f, -1.56943630e-02f,
  2.04423621e-01f, -4.92802970e-02f, -4.01994474e-02f, 5.24067171e-02f, 1.30348414e-01f, -3.59490253e-02f, -1.12147473e-01f, -7.76081830e-02f, -1.28987744e-01f, 3.51320095e-02f,
  1.85444772e-01f, 1.29228784e-03f, -1.21571481e-01f, -8.10404420e-02f, 1.48290694e-02f, 1.41063724e-02f, 1.50130183e-01f, 9.77199152e-02f, 8.01325142e-02f, -1.33751512e-01f,
  -6.06405772e-02f, -7.23338723e-02f, 5.43991998e-02f, -2.04319088e-03f, -6.46776110e-02f, -1.08248089e-02f, -1.06608540e-01f, -4.19310890e-02f, -4.54838164e-02f, -3.42312343e-02f,
  1.01697631e-03f, -3.01400628e-02f, -1.52451262e-01f, 3.73377688e-02f, -4.00764942e-02f, -5.65103404e-02f, 5.51209338e-02f, 4.26234119e-02f, 4.44777384e-02f, -1.39795199e-01f,
  -5.55587746e-03f, -3.87364663e-02f, 1.68726981e-01f, 9.87070426e-02f, -7.46336132e-02f, -2.21818626e-01f, -7.70848095e-02f, -2.64054209e-01f, -1.83639210e-02f, -1.89904422e-01f,
  -2.09286451e-01f, -1.00784220e-01f, -2.78795939e-02f, 1.15152560e-01f, 4.57491800e-02f, 3.13345976e-02f, 2.85170358e-02f, 5.57553358e-02f, -3.23171057e-02f, -1.84992049e-03f,
  5.86853735e-02f, 1.55258775e-01f, 1.04124457e-01f, 1.84485808e-01f, 4.48710248e-02f, 1.18476860e-02f, -7.33936504e-02f, 1.51520651e-02f, -1.28037348e-01f, -3.87974642e-02f,
  4.01065081e-01f, -6.48505166e-02f, -1.38942242e-01f, 1.05661646e-01f, 6.75268993e-02f, -4.26982064e-03f, 2.63525452e-02f, 9.17510986e-02f, 5.82887046e-02f, 1.72605719e-02f,
  -4.86090481e-02f, 2.53242571e-02f, 1.26043886e-01f, 6.11040071e-02f, -3.76589634e-02f, 8.15821532e-03f, 4.76408564e-02f, 9.93874595e-02f, -1.09786075e-02f, 2.41314550e-03f,
  -6.89391559e-03f, -8.87525901e-02f, -1.45944342e-01f, -1.10317715e-01f, -9.99460220e-02f, -5.54647595e-02f, -1.91400915e-01f, -1.32365331e-01f, -1.10632904e-01f, 1.06797233e-01f,
  1.43677309e-01f, 2.53909767e-01f, 4.01192419e-02f, 7.13969255e-03f, -1.47695839e-01f, -3.64521891e-02f, -7.96272606e-02f, 7.43829384e-02f, 1.46517148e-02f, -1.17444061e-01f,
  -1.68047518e-01f, -1.25859946e-01f, 5.24526723e-02f, -7.85924122e-02f, -1.16134360e-01f, -5.20561598e-02f, -1.48087874e-01f, 1.21956624e-01f, 1.31531522e-01f, 1.47332437e-02f,
  -7.03215692e-03f, 2.99484413e-02f, 6.27614139e-03f, -4.11288068e-02f, -7.32624605e-02f, -5.45415469e-02f, -1.38557762e-01f, -3.62066105e-02f, -4.03475054e-02f, -6.06141239e-02f,
  1.93385538e-02f, -3.06904595e-02f, -1.26195569e-02f, 4.09062169e-02f, 1.11943632e-01f, -1.54945068e-02f, -4.78790440e-02f, -4.40415777e-02f, -8.55481252e-03f, 1.27708372e-02f,
  3.08849029e-02f, 1.09948650e-01f, 1.44072756e-01f, 1.33659720e-01f, -6.42161863e-03f, -1.27765238e-01f, -2.41869912e-02f, 1.78033933e-02f, 7.98521936e-02f, 7.55062476e-02f,
  1.74993485e-01f, -8.36720988e-02f, 1.11576505e-02f, 7.12493584e-02f, 6.08671531e-02f, 2.57817078e-02f, -7.93491751e-02f, -1.17571047e-02f, -1.53926358e-01f, -7.84474909e-02f,
  1.50349781e-01f, 2.21336603e-01f, -1.18181370e-02f, -8.80977809e-02f, -8.05584490e-02f, -5.98298162e-02f, 1.11179493e-01f, 1.97584048e-01f, 7.31202140e-02f, 1.06096923e-01f,
  -5.78246228e-02f, 1.35221984e-02f, -2.17582807e-02f, -9.93059278e-02f, -6.31847456e-02f, -1.35390982e-02f, 9.35523435e-02f, 1.61344275e-01f, -4.83449921e-03f, 5.68891950e-02f,
  -1.63196415e-01f, 8.47163722e-02f, 9.87447426e-02f, 8.27380344e-02f, 2.42810696e-02f, 4.90847640e-02f, -4.86433730e-02f, 2.46469229e-02f, 4.91058119e-02f, -1.13816909e-01f,
  2.25201305e-02f, -3.98150325e-01f, -3.43508184e-01f, -1.84396952e-01f, -1.22671098e-01f, -7.60455355e-02f, -1.36272192e-01f, -1.02749085e-02f, -6.46485388e-03f, -2.94694424e-01f,
  -1.18630536e-01f, 1.55671239e-01f, -2.34531402e-03f, 1.11600766e-02f, 2.74822146e-01f, -3.25017422e-01f, -1.60694703e-01f, 2.28677258e-01f, 4.52829599e-01f, 1.79980233e-01f,
  6.80471063e-02f, -4.34467457e-02f, 1.09855682e-01f, 8.59005451e-02f, -2.75748968e-01f, -5.65197654e-02f, -2.34855652e-01f, -4.83286902e-02f, 6.97340583e-03f, -4.72778440e-01f,
  -1.55379385e-01f, 1.05568580e-01f, 8.82222876e-02f, 1.47568136e-02f, -1.39710054e-01f, 4.92984541e-02f, -8.89572203e-02f, -3.14527154e-02f, 5.55786788e-02f, -3.34045216e-02f,
  1.05562791e-01f, -2.01141611e-02f, 5.87978214e-02f, 4.15777527e-02f, -1.66875303e-01f, 7.21624419e-02f, -6.27021715e-02f, -1.20318839e-02f, 5.05138561e-03f, 5.50547056e-03f,
  -1.09358579e-01f, -2.17925720e-02f, 1.09709151e-01f, -5.09052239e-02f, 1.33994371e-02f, 4.43259627e-02f, -7.40958080e-02f, 1.01621330e-01f, 3.89327779e-02f, -2.12812036e-01f,
  -1.77498013e-01f, -1.34313656e-02f, -5.02890274e-02f, -3.96729000e-02f, 1.37025565e-01f, -6.46373704e-02f, 1.11936852e-02f, -3.14906798e-02f, 2.10999306e-02f, 3.47874453e-03f,
  -9.61339325e-02f, -4.12762612e-02f, -2.62952428e-02f, -7.91085586e-02f, -8.32564905e-02f, -6.67996705e-02f, 4.03301930e-03f, -1.58940107e-01f, 6.26425594e-02f, -3.12808082e-02f,
  1.81541160e-01f, -1.35260373e-02f, 1.39257526e-02f, 4.63912822e-02f, 4.62890156e-02f, 4.05792845e-03f, 6.95302114e-02f, 4.27321233e-02f, -3.37572582e-03f, 2.16573924e-02f,
  -1.85251385e-01f, 1.63513914e-01f, -1.10401794e-01f, 1.29347503e-01f, -1.21774644e-01f, 6.90398039e-03f, -1.70003232e-02f, -3.23313661e-02f, 3.79251167e-02f, 3.76453139e-02f,
  -5.49357608e-02f, -1.00470945e-01f, -1.52338699e-01f, 3.62012722e-02f, -5.06368838e-02f, 1.38022617e-01f, -2.50888038e-02f, 5.96019700e-02f, 1.38161313e-02f, -1.16766252e-01f,
  -1.63170546e-01f, 7.15055913e-02f, -8.95481557e-04f, -1.20078705e-01f, 1.36863086e-02f, 5.44577390e-02f, -1.87061038e-02f, -1.01120576e-01f, -7.60736875e-03f, -2.56915927e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -6.31992817e-02f, -4.96722851e-03f, 2.05235183e-01f, 1.68418840e-01f, -1.33781418e-01f, -1.16484322e-01f, 6.70293421e-02f, 1.46105692e-01f, 5.18624969e-02f, -2.95096934e-02f,
  2.37307593e-01f, -9.96036977e-02f, -1.38614625e-02f, 3.69304568e-02f, -6.31016642e-02f, 4.86362576e-02f, -2.80628130e-02f, 1.15762018e-02f, 9.67266560e-02f, -2.90808752e-02f,
  1.10551588e-01f, -3.74418981e-02f, -2.19572903e-04f, 3.02062958e-01f, -1.38126925e-01f, 2.89801478e-01f, 1.59711361e-01f, -1.29730374e-01f, -1.66156031e-02f, -5.90679124e-02f,
  2.17190459e-01f, 1.61864638e-01f, -2.59050837e-04f, -6.76950365e-02f, -4.62358259e-02f, 8.16183835e-02f, 2.22385824e-01f, -1.31269827e-01f, 2.22609267e-01f, -9.97822955e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.22002417e-02f, 1.41197115e-01f, -1.90469265e-01f, -1.63256228e-01f, -2.73252912e-02f, 7.24621639e-02f, 1.15615642e-02f, -1.03030846e-01f, 8.85518268e-02f, -7.73209929e-02f,
  -3.95095572e-02f, 7.94406310e-02f, 9.08732340e-02f, -2.56051272e-02f, 2.09348246e-01f, -4.42059189e-02f, -5.54918312e-02f, -1.60605118e-01f, 1.28233328e-01f, -1.81174483e-02f,
  -7.46489763e-02f, 1.18740998e-01f, 3.91051620e-02f, -4.56240959e-02f, 1.95631027e-01f, -3.53651727e-03f, 1.22572063e-02f, -9.48001817e-02f, 1.80947542e-01f, 1.35400474e-01f,
  -6.98614866e-02f, 6.84326738e-02f, 9.51036066e-02f, -6.59377724e-02f, -9.11108926e-02f, 1.04177028e-01f, -2.45620772e-01f, 1.43380433e-01f, -4.51451838e-02f, -3.21626455e-01f,
  1.06852408e-02f, -6.84639141e-02f, 1.04577281e-01f, 1.07516041e-02f, -5.90124819e-03f, 2.44430646e-01f, 1.60050280e-02f, 1.30243912e-01f, 5.87931238e-02f, 1.87321752e-01f,
  -1.00638583e-01f, -3.15732323e-02f, 2.37845331e-01f, -4.42875549e-02f, -2.22451746e-01f, -5.27363181e-01f, -9.62187797e-02f, -1.13981582e-01f, -6.55484051e-02f, 1.19319312e-01f,
  -2.29186654e-01f, -5.23854606e-02f, 6.37868047e-02f, 1.77813187e-01f, -1.71619549e-01f, 4.80007790e-02f, -2.38993019e-01f, 4.07772437e-02f, 8.41701999e-02f, -9.01766345e-02f,
  -1.01397224e-01f, -2.00184956e-01f, 7.50897899e-02f, -5.52581027e-02f, 2.40262877e-03f, 6.67396635e-02f, 1.46017849e-01f, -6.00821562e-02f, 1.86920300e-01f, 2.52274293e-02f,
  -7.03840749e-03f, 6.72307462e-02f, 2.04448417e-01f, 1.93099290e-01f, 7.81438798e-02f, -3.32409479e-02f, -1.58037767e-02f, -1.34872213e-01f, 1.00243740e-01f, -2.92203575e-02f,
  -1.91081285e-01f, 8.00643489e-02f, -1.94925547e-01f, 1.75857857e-01f, -9.08673406e-02f, -7.62502104e-02f, -9.59717035e-02f, -1.07975893e-01f, 2.98924834e-01f, 8.10553059e-02f,
  -7.17730150e-02f, 1.98032126e-01f, -1.92110524e-01f, -1.66789070e-01f, 3.55064087e-02f, -1.79381937e-01f, 2.80623529e-02f, -1.64229900e-01f, 8.54586586e-02f, -1.29901350e-01f,
  -2.72333883e-02f, 2.72920020e-02f, 1.79173425e-01f, 4.62186988e-03f, -5.61315119e-02f, 1.37865975e-01f, 2.31988579e-01f, -9.46548209e-02f, -2.95899808e-01f, -2.56870985e-01f,
  -6.95084706e-02f, -1.39515027e-01f, 1.36367574e-01f, 1.78288698e-01f, 8.68601426e-02f, -8.70448649e-02f, 1.35766029e-01f, 9.54511166e-02f, 1.60846412e-02f, -2.61657704e-02f,
  5.47837391e-02f, -7.56111220e-02f, 7.57835992e-03f, 1.03756070e-01f, 1.74853690e-02f, 8.92873630e-02f, -1.69452861e-01f, 5.24618104e-02f, 1.47535682e-01f, -6.37720749e-02f,
  -4.18183357e-02f, -1.58357114e-01f, -1.51407748e-01f, 5.81226163e-02f, 5.32703176e-02f, -1.04720630e-01f, -1.99363708e-01f, -3.40217128e-02f, -2.00740680e-01f, 8.21216106e-02f,
  -6.42037094e-02f, 3.21852684e-01f, 5.06366976e-02f, -1.53373286e-01f, 1.37337461e-01f, 3.34811695e-02f, 1.75323505e-02f, 1.04748569e-01f, -1.79197177e-01f, -2.25395598e-02f,
  -9.18217897e-02f, -9.29041356e-02f, 7.36945495e-02f, -1.10551668e-02f, 1.96905822e-01f, 3.07898782e-02f, -1.74405009e-01f, 1.15327515e-01f, -2.03626826e-02f, 9.86671001e-02f,
  -1.18462652e-01f, 2.59481091e-02f, 4.36530896e-02f, 1.38181269e-01f, -2.34045953e-01f, -2.43053496e-01f, 1.97182357e-01f, -8.55799392e-02f, -7.93136656e-02f, -7.86637142e-02f,
  -1.17083892e-01f, 1.09500445e-01f, 2.40479484e-01f, -1.05253838e-01f, 1.04104802e-02f, 1.80568472e-01f, 1.23934135e-01f, 1.81165472e-01f, -7.07833618e-02f, 2.34276891e-01f,
  1.49486333e-01f, -1.38518244e-01f, -7.09463656e-02f, -5.96666634e-02f, -1.64611768e-02f, 5.48750535e-03f, 7.36212358e-02f, -5.97782480e-03f, -2.70083584e-02f, 5.14294207e-02f,
  8.25916380e-02f, 8.95266831e-02f, 4.68052514e-02f, 6.97783381e-02f, 4.12259474e-02f, 1.33037949e-02f, -8.20759963e-03f, -9.56198201e-02f, -9.88370702e-02f, -1.56680848e-02f,
  -1.24780916e-01f, -7.54278675e-02f, 2.73773894e-02f, 8.57842565e-02f, 1.21961564e-01f, 5.17043173e-02f, 1.31210074e-01f, -1.08442880e-01f, -1.76501632e-01f, 1.53477341e-01f,
  -9.33902785e-02f, 1.07434630e-01f, -3.01952604e-02f, -1.96257427e-01f, -2.28839427e-01f, 1.47942543e-01f, 2.83566326e-01f, 6.66349083e-02f, -1.81457072e-01f, 1.40993521e-01f,
  1.08167358e-01f, -2.45339647e-02f, 1.00695580e-01f, 2.07076177e-01f, -8.78577493e-03f, 1.84093788e-01f, -1.47859305e-01f, -1.24768071e-01f, -6.13162480e-02f, -1.17275402e-01f,
  1.04841799e-01f, -7.79911578e-02f, -7.27044716e-02f, -2.12349057e-01f, -1.38128132e-01f, -1.36211412e-02f, 4.36899692e-01f, 9.01474431e-03f, -1.35967806e-01f, -4.69538793e-02f,
  1.61419332e-01f, 1.75228864e-01f, 1.60353146e-02f, 9.05519500e-02f, 2.77120550e-03f, -2.65006781e-01f, 2.26342194e-02f, -5.28251901e-02f, 1.01888878e-02f, -1.94110423e-01f,
  -1.47476733e-01f, 6.58042356e-02f, -1.95568576e-01f, 4.57073115e-02f, -1.21093902e-03f, -8.08375254e-02f, 6.62107617e-02f, -1.52495265e-01f, 1.07157618e-01f, -4.36211862e-02f,
  1.97719447e-02f, -4.51768637e-02f, -1.96636528e-01f, 1.05702259e-01f, 4.54190187e-02f, 1.27546579e-01f, -2.21313946e-02f, -6.73662266e-03f, -4.35409062e-02f, 9.02726948e-02f,
  -2.00279639e-03f, -1.35141447e-01f, -7.08657801e-02f, 2.44854957e-01f, 8.62242579e-02f, 1.61831267e-02f, -5.68914004e-02f, -1.15707979e-01f, 8.68590665e-04f, -1.32162079e-01f,
  4.77456987e-01f, -1.05411872e-01f, 2.77563203e-02f, -9.36725587e-02f, -3.35075051e-01f, 1.04723133e-01f, 1.91975355e-01f, 1.19750336e-01f, -1.17613710e-01f, -9.06513706e-02f,
  -2.30283499e-01f, -6.11656494e-02f, -7.71683976e-02f, -3.64950538e-01f, 7.64858201e-02f, 3.41189541e-02f, 1.13697909e-01f, -7.80026093e-02f, 1.33839175e-02f, -1.15708888e-01f,
  1.20098636e-01f, 1.46579891e-01f, -1.16751060e-01f, -9.85356718e-02f, 1.64800435e-01f, -2.14980040e-02f, -9.87859145e-02f, 5.51483855e-02f, 2.81646959e-02f, -1.42130435e-01f,
  4.29046564e-02f, -1.48389097e-02f, -5.18781357e-02f, -4.80831377e-02f, 6.85305521e-02f, -3.28799477e-03f, 1.50341198e-01f, -6.41384348e-02f, -2.15149552e-01f, 8.48541558e-02f,
  4.05662395e-02f, 1.29188180e-01f, 8.16558599e-02f, -1.24019302e-01f, -5.16594574e-02f, 2.26856992e-02f, 3.52990143e-02f, 3.47936526e-02f, 1.68024860e-02f, 8.24967921e-02f,
  1.09512538e-01f, -9.80561227e-02f, 6.00244179e-02f, 1.07738957e-01f, -2.18436345e-01f, 1.19477138e-02f, -1.63800359e-01f, -5.40556461e-02f, -2.55045027e-01f, 1.25179037e-01f,
  1.22387819e-01f, -1.73645258e-01f, -1.20375603e-01f, 1.70676664e-01f, 2.10030481e-01f, -7.96098560e-02f, 4.94918451e-02f, 3.84822153e-02f, 9.65857878e-02f, 1.84538484e-01f,
  8.05153623e-02f, 1.15489155e-01f, -4.06773873e-02f, -9.31371450e-02f, 8.17951933e-02f, -1.61203668e-01f, -1.34884464e-02f, -1.51411161e-01f, -1.48282945e-01f, 5.82225993e-02f,
  2.02043466e-02f, 2.89784241e-02f, -2.27111429e-01f, -1.47506937e-01f, -6.38614595e-02f, 3.92525077e-01f, -2.23723166e-02f, -1.71620175e-01f, 6.14625290e-02f, -4.29909788e-02f,
  2.94267088e-01f, 9.19099078e-02f, -1.70960724e-02f, -2.15975732e-01f, -7.55623281e-02f, -7.31427521e-02f, 2.27816049e-02f, -4.04536026e-03f, -4.50196164e-03f, -9.96293034e-03f,
  -1.14955053e-01f, -1.98376179e-02f, -4.87090945e-02f, -1.29127735e-02f, -6.23007454e-02f, 7.15511665e-02f, -6.03250489e-02f, -1.42255083e-01f, -1.38548464e-01f, -4.12975177e-02f,
  -3.92766111e-02f, -3.26042771e-02f, 5.12723811e-02f, 6.84019625e-02f, 1.00486636e-01f, -1.86882466e-01f, 4.36922498e-02f, 2.78496653e-01f, -2.45598435e-01f, -2.35956963e-02f,
  -4.54547144e-02f, 5.43644652e-02f, -1.96128279e-01f, 1.55539960e-01f, 9.88464355e-02f, -1.70793235e-01f, -1.67840898e-01f, -1.48292668e-02f, 1.14010379e-01f, -1.53823150e-02f,
  3.21362317e-01f, 4.14870828e-02f, -3.26292925e-02f, 2.01694593e-01f, 2.07498610e-01f, 1.19949104e-02f, 1.48619726e-01f, -1.02441221e-01f, 1.39639810e-01f, 4.91614360e-03f,
  1.69429466e-01f, -3.50409180e-01f, -1.21402040e-01f, 1.22940414e-01f, 9.06111598e-02f, 4.10422385e-02f, -2.82249957e-01f, -2.23576397e-01f, -8.73562098e-02f, 1.51815146e-01f,
  -1.28761262e-01f, -9.62660834e-02f, -7.57309096e-03f, -4.30833139e-02f, 2.46321842e-01f, 2.33416688e-02f, -2.25181747e-02f, -1.50405943e-01f, 9.12570804e-02f, 4.07748260e-02f,
  -9.19691101e-02f, -6.16823211e-02f, -1.71738993e-02f, -2.50864141e-02f, 3.14475447e-02f, -4.82600331e-02f, 1.49925366e-01f, 8.88389722e-02f, -2.40992680e-02f, 2.55630352e-02f,
  -2.46371124e-02f, 1.40958160e-01f, -3.53284925e-02f, -1.04849249e-01f, 8.13704506e-02f, 1.09991848e-01f, 1.53186753e-01f, -1.80988386e-01f, 1.00342147e-01f, 1.21737890e-01f,
  3.55385616e-02f, -2.02539280e-01f, 2.03512937e-01f, 1.14543170e-01f, -1.31899953e-01f, -5.52837849e-02f, 1.04596354e-01f, -3.67654674e-02f, 5.14530800e-02f, 6.58308715e-02f,
  3.54445204e-02f, 1.44004049e-02f, -3.85435462e-01f, 2.08451226e-02f, -3.33538860e-01f, -8.55266601e-02f, 2.89227247e-01f, 7.27127194e-02f, -1.17199585e-01f, 3.58562887e-04f,
  9.95889604e-02f, -3.86381596e-02f, -1.40902698e-01f, -9.27631482e-02f, -7.54501671e-03f, 2.36795396e-01f, 6.58899592e-03f, -1.75619602e-01f, -1.53888892e-02f, 9.61487293e-02f,
  2.71291375e-01f, 9.21432152e-02f, -3.08215264e-02f, -2.13617887e-02f, 5.36203086e-02f, -7.40642101e-02f, -2.21069783e-01f, 2.95583550e-02f, 1.99674085e-01f, -6.85229078e-02f,
  -7.64555857e-02f, 8.73333067e-02f, -1.17723554e-01f, -1.12327144e-01f, 1.01832055e-01f, 7.62120187e-02f, -3.69091076e-03f, -7.51026273e-02f, -1.46304350e-02f, 1.17657304e-01f,
  -2.77577192e-01f, 7.62641132e-02f, 2.16786135e-02f, -1.34042248e-01f, 6.49017021e-02f, 6.14732169e-02f, 6.20035045e-02f, 1.60266668e-01f, -2.16947198e-01f, 5.65607939e-03f,
  -2.82689542e-01f, -2.59188414e-02f, 2.68141683e-02f, -1.55806035e-01f, 2.85831466e-02f, 2.71780267e-02f, 3.92197892e-02f, -3.37398350e-01f, 7.08049834e-02f, 2.87653387e-01f,
  1.46152964e-02f, 1.83566749e-01f, -2.15943411e-01f, -2.20278539e-02f, -1.70284659e-01f, -1.29283220e-01f, 2.26803526e-01f, -1.92263275e-01f, 1.41605899e-01f, -1.82234615e-01f,
  -1.02883223e-02f, -2.47765034e-01f, 4.08213474e-02f, 8.32202509e-02f, -1.12104639e-01f, -2.15339903e-02f, -1.60828620e-01f, 1.33714423e-01f, 1.06619984e-01f, -7.16173723e-02f,
  -4.84695584e-02f, -4.81655039e-02f, 2.05883116e-01f, -1.20135486e-01f, -1.55437171e-01f, 3.55669111e-02f, 1.28593042e-01f, 1.71452880e-01f, -1.43211991e-01f, 1.58377528e-01f,
  4.68270034e-01f, 4.65616994e-02f, -2.56708354e-01f, 3.14767271e-01f, 1.36750378e-02f, -6.43213019e-02f, 1.21249489e-01f, 5.16110361e-02f, -3.27573456e-02f, 1.98709723e-02f,
  1.22029476e-01f, 1.97761180e-03f, 8.24913085e-02f, 5.71691804e-02f, -1.18934978e-02f, 5.33682965e-02f, 1.19695356e-02f, -2.87015811e-02f, -1.06703892e-01f, 1.39108092e-01f,
  -6.25133933e-03f, -7.68871382e-02f, -2.02557743e-02f, 2.68740449e-02f, 6.37174919e-02f, 9.54109523e-03f, -8.07665884e-02f, 2.10013073e-02f, -7.12924302e-02f, -1.17399320e-01f,
  1.27982587e-01f, 1.61173809e-02f, -4.40023094e-02f, -1.17024444e-01f, 6.28665015e-02f, 1.45673856e-01f, -1.54087558e-01f, 7.35052675e-02f, 8.00630916e-03f, -1.34387314e-01f,
  -1.19739830e-01f, 2.50838939e-02f, -4.19476151e-01f, 7.10763335e-02f, 1.52320117e-01f, -2.39040390e-01f, -1.35120273e-01f, -1.35627478e-01f, -2.59659559e-01f, -1.10468112e-01f,
  -1.51538625e-01f, 3.79317440e-02f, -1.06399626e-01f, 2.81109095e-01f, 4.95203286e-02f, -7.88294431e-03f, 1.21840902e-01f, -9.48527828e-02f, 1.76408932e-01f, 1.84809923e-01f,
  5.08869290e-02f, -6.02434911e-02f, -6.90305978e-02f, -2.57382449e-02f, 1.73957869e-01f, 6.46919906e-02f, -2.22122014e-01f, -1.67698130e-01f, 1.65714771e-01f, 4.56635170e-02f,
  -3.08235902e-02f, 2.69825570e-02f, 4.67782915e-02f, -5.02595790e-02f, 5.94716184e-02f, 9.84455124e-02f, -9.76844430e-02f, -8.13139901e-02f, 2.52014071e-01f, -7.37501457e-02f,
  8.39920640e-02f, -1.81945984e-03f, -1.17533162e-01f, 7.47499764e-02f, 4.62133884e-02f, 7.48953084e-03f, 2.21229885e-02f, -9.42327976e-02f, -3.94815989e-02f, -1.05795480e-01f,
  2.15691961e-02f, 3.04375719e-02f, 1.01416096e-01f, 2.15312123e-01f, -9.88801122e-02f, -2.87987161e-02f, 3.51144783e-02f, 3.39094430e-01f, 1.40645623e-01f, 1.10155933e-01f,
  -1.08839497e-02f, 2.12215677e-01f, 1.58812068e-02f, 5.87469153e-02f, 1.96670532e-01f, 2.37920552e-01f, 1.98882803e-01f, -1.12155611e-02f, -3.16851884e-01f, -1.58487201e-01f,
  6.42464682e-02f, 3.15780155e-02f, 1.85733363e-01f, 4.88207862e-02f, -6.90329075e-03f, -4.18655723e-02f, -1.22681454e-01f, -1.46226883e-01f, -3.82871218e-02f, -1.73259586e-01f,
  -1.35147691e-01f, -1.56593487e-01f, 5.33180172e-03f, -2.61249393e-01f, 4.32960093e-01f, -1.85212508e-01f, -3.09214871e-02f, -4.04446013e-03f, -9.12697404e-04f, 1.64963141e-01f,
  1.73062328e-02f, 4.22717631e-02f, -1.31886363e-01f, 1.44645229e-01f, 3.96584719e-02f, -1.53297886e-01f, 1.93816513e-01f, 1.04465835e-01f, 5.51611930e-02f, -2.47288179e-02f,
  6.80780411e-02f, 5.58273382e-02f, -6.65903836e-02f, 1.16548657e-01f, -3.67938653e-02f, -1.47899494e-01f, -8.84819999e-02f, -1.59084231e-01f, -8.42305571e-02f, -1.31626446e-02f,
  -6.84314296e-02f, -9.10372064e-02f, -1.81788243e-02f, 7.48305991e-02f, 4.21974733e-02f, 8.43293443e-02f, -2.43086722e-02f, 2.07349062e-01f, -7.25398888e-04f, -2.08104298e-01f,
  3.17240022e-02f, 2.25212306e-01f, -6.43590018e-02f, 9.72799510e-02f, -1.22939117e-01f, -6.64458275e-02f, -5.99530078e-02f, -5.07974140e-02f, 1.02106649e-02f, -1.06780402e-01f,
  2.88623601e-01f, -1.75823346e-01f, -3.71099189e-02f, 1.94883219e-03f, 1.37277357e-02f, 1.69969708e-01f, -7.89930150e-02f, 1.34241149e-01f, 8.88097733e-02f, 7.28266919e-03f,
  4.04589996e-02f, -3.20481858e-03f, 1.08046412e-01f, -1.29503101e-01f, -9.56230387e-02f, -1.10443495e-01f, -4.26161475e-02f, -3.39671187e-02f, 2.74716616e-01f, 1.86468750e-01f,
  1.53549656e-01f, 5.50117269e-02f, 1.33142546e-01f, -1.10666573e-01f, -1.18793651e-01f, -2.79479064e-02f, -3.31578404e-02f, -1.57681793e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.93901372e-02f, 2.74548888e-01f, 2.10512225e-02f, -3.02273910e-02f, 8.89901668e-02f, -8.89646932e-02f, 3.97001952e-02f, 1.54270723e-01f, -1.49855033e-01f, 1.24346085e-01f,
  -2.52994224e-02f, 1.62667677e-01f, -1.49780035e-01f, -1.70216277e-01f, 2.72714734e-01f, 1.17040381e-01f, -8.60019922e-02f, -5.38803544e-03f, -3.76136191e-02f, 3.27230878e-02f,
  -5.08597046e-02f, 1.25664651e-01f, 1.12990580e-01f, 1.95019230e-01f, -3.31190884e-01f, -1.28748015e-01f, 5.79781877e-03f, -2.13853583e-01f, 1.40862033e-01f, 2.21840870e-02f,
  -2.98895985e-01f, 1.51289612e-01f, 1.96658581e-01f, -1.58201352e-01f, -1.60014629e-01f, -1.31802619e-01f, 3.06960285e-01f, -3.21603984e-01f, -2.26014405e-01f, 4.07505222e-02f,
  1.33560658e-01f, 2.02876758e-02f, 3.37806672e-01f, 8.86639655e-02f, -1.47649825e-01f, 1.63296282e-01f, -9.13510919e-02f, 3.28294449e-02f, -6.71812668e-02f, 9.81078595e-02f,
  1.00824058e-01f, 1.62616625e-01f, -7.60869458e-02f, -5.04284836e-02f, 1.34291518e-02f, -1.16869681e-01f, 2.53939480e-02f, -1.18242987e-01f, 2.56261732e-02f, 2.50347778e-02f,
  -2.63694674e-01f, 9.03061479e-02f, 1.04493663e-01f, -9.54232588e-02f, 2.91334186e-02f, -1.44206032e-01f, 3.07724420e-02f, -7.64177218e-02f, -6.75816974e-03f, 4.07244973e-02f,
  3.00632790e-02f, -5.08923307e-02f, -1.38681293e-01f, -2.38078963e-02f, 1.13944262e-02f, 6.87661469e-02f, 1.97891116e-01f, 2.33371973e-01f, 1.31012008e-01f, 1.51687399e-01f,
  -4.75355349e-02f, 1.49026498e-01f, 1.28571391e-01f, 4.13266681e-02f, -5.92624918e-02f, 9.42659974e-02f, -1.18885204e-01f, -1.72185525e-01f, -6.98939785e-02f, 1.91087961e-01f,
  2.76653208e-02f, -1.49842754e-01f, 4.49759923e-02f, 5.79234101e-02f, -1.24057420e-01f, 2.43872494e-01f, 1.38473213e-01f, -6.56019747e-02f, -3.17259341e-01f, -9.26305447e-03f,
  -2.26095412e-02f, 7.75840282e-02f, 9.55519676e-02f, -2.33707249e-01f, -1.82090942e-02f, -1.94193229e-01f, 5.06753735e-02f, 4.54123653e-02f, 1.12035207e-01f, 1.31256074e-01f,
  1.76790617e-02f, 1.48129240e-01f, -3.28954752e-03f, -8.47825110e-02f, 1.27426699e-01f, 8.65075663e-02f, 1.00781366e-01f, -4.08233516e-02f, -5.54990530e-01f, -4.72794659e-02f,
  -8.51510093e-02f, 2.14139476e-01f, -1.71031442e-03f, -9.74234194e-02f, -2.14689821e-01f, 1.16430290e-01f, 8.89907256e-02f, 1.56474829e-01f, 5.84279299e-02f, -5.73518276e-02f,
  7.60041643e-03f, 6.40508085e-02f, 7.31101483e-02f, -1.54744629e-02f, -8.56304988e-02f, 2.07625404e-01f, -3.30097275e-03f, 1.14618931e-02f, 8.51456374e-02f, 4.56682593e-02f,
  1.21003333e-02f, -5.16177714e-02f, 5.17255738e-02f, 5.24953641e-02f, -4.06530537e-02f, -2.35816523e-01f, -4.43584425e-03f, -5.96867651e-02f, -1.72936976e-01f, 5.36691695e-02f,
  -1.83858424e-02f, 4.39279806e-03f, 1.24684744e-01f, 1.08521767e-01f, -5.75974435e-02f, 3.40773314e-01f, -2.57584434e-02f, -4.77555431e-02f, 1.72328353e-01f, 4.27207537e-02f,
  -7.76269659e-02f, 1.28802076e-01f, 2.12121204e-01f, -3.41205001e-02f, 4.36359674e-01f, 2.25365803e-01f, -1.19097255e-01f, -4.66014110e-02f, 1.06794760e-01f, -1.76570237e-01f,
  7.34416023e-02f, 1.70342103e-01f, 5.47797754e-02f, -1.80076182e-01f, -2.11065039e-02f, -5.60612753e-02f, 2.03156292e-01f, 3.38654518e-02f, -1.87737763e-01f, 6.15822114e-02f,
  -1.61558479e-01f, 7.09941313e-02f, -1.52989045e-01f, -1.10794351e-01f, 2.91688684e-02f, -5.38625522e-03f, -8.86035636e-02f, 9.59090143e-02f, 8.87958407e-02f, -1.35237724e-01f,
  -9.70312133e-02f, -2.14969844e-01f, 1.22107752e-01f, -9.36014485e-03f, -2.78772917e-02f, 2.03533247e-01f, -2.98626069e-02f, 6.65543973e-02f, 1.30899996e-01f, -5.33418097e-02f,
  6.66086525e-02f, -1.40576378e-01f, -5.20752221e-02f, -9.63174775e-02f, 2.69264951e-02f, 6.92169508e-03f, 1.95677862e-01f, 9.70603451e-02f, 1.20427974e-01f, 1.11199200e-01f,
  3.21361065e-01f, 1.73549861e-01f, 1.91225242e-02f, -3.52664967e-03f, -7.28307888e-02f, -1.15742505e-01f, 6.18114956e-02f, 2.09158614e-01f, 1.10194040e-02f, -5.05830646e-01f,
  -8.43720511e-02f, 6.96411058e-02f, 2.79243231e-01f, -4.61822422e-03f, 1.66835353e-01f, -6.87517747e-02f, -2.01726973e-01f, -1.00720070e-01f, -1.65634632e-01f, 1.42852589e-02f,
  9.70571339e-02f, 1.06440522e-01f, 1.33831218e-01f, 2.09429231e-03f, 2.08438739e-01f, -2.56248623e-01f, 2.05544934e-01f, 3.20204049e-01f, 1.09197035e-01f, 1.28541052e-01f,
  -1.52653277e-01f, 2.38014624e-01f, 2.02436611e-01f, 4.56632078e-01f, 1.64429694e-01f, -2.77729202e-02f, -5.53429782e-01f, -2.63998881e-02f, 1.23864360e-01f, 1.01354606e-01f,
  4.99491096e-02f, -1.98230311e-01f, 2.45100379e-01f, 1.63082540e-01f, 7.02757165e-02f, 2.18279079e-01f, 2.30731280e-03f, 1.33998618e-01f, 1.09186858e-01f, -9.81596392e-03f,
  -5.81332576e-03f, 1.31531566e-01f, 7.51330033e-02f, -5.25234044e-02f, -8.58848840e-02f, -1.01772450e-01f, 7.72112682e-02f, 1.34276316e-01f, -5.38493320e-02f, -1.65304467e-01f,
  -2.05884978e-01f, -1.64475873e-01f, -6.24793954e-02f, 6.14793450e-02f, -1.72369301e-01f, -5.40840290e-02f, 4.45834510e-02f, -2.48299702e-03f, 4.66972813e-02f, 2.09377915e-01f,
  -1.11033596e-01f, -1.71472222e-01f, 5.81502765e-02f, 3.76954563e-02f, -2.07910240e-01f, -5.31146750e-02f, 4.55674566e-02f, 1.73940405e-01f, -6.15449809e-02f, 1.59584850e-01f,
  -1.53267160e-01f, -3.17451730e-02f, 2.98634142e-01f, -7.50154033e-02f, -7.16237798e-02f, 1.95846051e-01f, 2.52571940e-01f, 1.75115928e-01f, 1.52645245e-01f, -4.00158837e-02f,
  -4.05572690e-02f, 2.03445092e-01f, -1.47703186e-01f, -2.42457673e-01f, -1.38623953e-01f, -7.24933445e-02f, -1.93430707e-01f, 2.83170640e-01f, -1.25398114e-01f, -9.13562551e-02f,
  -1.57643016e-02f, 1.43192858e-01f, -6.31176820e-03f, -2.14222055e-02f, 1.98452994e-01f, -3.64537933e-04f, 3.05757523e-01f, 1.45146489e-01f, 1.33990407e-01f, -1.11108154e-01f,
  1.76521819e-02f, 1.05452769e-01f, 1.14092261e-01f, 1.35746270e-01f, 1.34357408e-01f, 2.17857063e-01f, 4.37143743e-02f, -3.50468904e-02f, -4.00578678e-02f, 1.48187608e-01f,
  1.49029359e-01f, -2.50719022e-03f, 2.26204380e-01f, 2.14015976e-01f, -8.23781043e-02f, 3.93681377e-02f, -1.99794754e-01f, -8.11282452e-03f, -1.20273931e-02f, 1.53412074e-01f,
  1.71327919e-01f, -2.68382519e-01f, 2.27727573e-02f, -1.03859261e-01f, 1.80332080e-01f, -5.47725745e-02f, -6.24292456e-02f, -1.68810204e-01f, -4.59865257e-02f, -1.80703282e-01f,
  -1.36852592e-01f, -3.37456584e-01f, -4.30284560e-01f, -1.29515871e-01f, 4.88483906e-01f, -5.81097379e-02f, -1.90637752e-01f, 1.27494335e-01f, 3.41822691e-02f, -4.54535559e-02f,
  6.05859011e-02f, 1.58824638e-01f, -6.74310401e-02f, -1.98257163e-01f, 2.66854733e-01f, -2.67805517e-01f, -9.88279656e-02f, 1.47979474e-02f, 7.77200386e-02f, 1.13963425e-01f,
  1.50335714e-01f, -1.68400407e-01f, 4.39837985e-02f, -1.21562080e-02f, 1.01794511e-01f, 2.83216596e-01f, 1.34936586e-01f, 6.36008233e-02f, 5.77314496e-02f, 1.05608635e-01f,
  1.16811179e-01f, 1.11004613e-01f, -5.65173924e-02f, -6.63527027e-02f, 1.38084769e-01f, 5.43616042e-02f, 1.25989735e-01f, 1.10600471e-01f, 9.38769355e-02f, 1.15873516e-01f,
  2.36669719e-01f, 1.57100156e-01f, 1.18174143e-02f, 2.42118418e-01f, 1.28453389e-01f, 4.46716473e-02f, -4.44252729e-01f, -1.22099556e-03f, -1.08023204e-01f, -3.44915292e-03f,
  1.66791886e-01f, 2.00910643e-01f, -1.24704883e-01f, 1.40131459e-01f, -2.05318868e-01f, -1.10442549e-01f, 2.64730910e-03f, 8.23588371e-02f, -2.32418969e-01f, -4.03655469e-02f,
  2.12482572e-01f, -1.93792075e-01f, 6.30997270e-02f, -7.11294562e-02f, 1.41892225e-01f, 2.01056227e-02f, 1.09364562e-01f, -1.48450732e-01f, -1.65299267e-01f, 4.62775002e-04f,
  2.56395310e-01f, -1.00350365e-01f, -1.96299642e-01f, 4.61090282e-02f, -1.54298902e-01f, 8.45729858e-02f, -1.54966682e-01f, -2.39375122e-02f, 1.50979087e-01f, 1.98350102e-02f,
  1.58511013e-01f, 2.50142753e-01f, -2.88106143e-01f, -7.13799596e-02f, -3.56258862e-02f, 6.46509184e-03f, 2.48995777e-02f, -2.10547760e-01f, 1.99215084e-01f, -4.47832614e-01f,
  3.03234041e-01f, 1.13764696e-01f, -1.90436676e-01f, -1.32912546e-01f, 1.63813367e-01f, -1.26191173e-02f, -4.83596250e-02f, 2.94651818e-02f, -4.85439599e-02f, 1.54654279e-01f,
  -1.83599427e-01f, 1.66695535e-01f, 7.02385679e-02f, -8.29893947e-02f, -6.50226250e-02f, -3.87848280e-02f, -1.57165658e-02f, -1.61915630e-01f, 8.90868381e-02f, 1.05257764e-01f,
  1.96776211e-01f, 1.81199554e-02f, 9.55450907e-02f, 9.67581943e-03f, 1.51235089e-01f, 5.88422418e-02f, 2.97650695e-01f, 4.61170040e-02f, 8.94128978e-02f, -4.78917472e-02f,
  -4.03767824e-02f, -4.32680510e-02f, 5.04312031e-02f, 1.54976055e-01f, 1.32296756e-01f, 1.88653544e-03f, 1.16432652e-01f, -3.61288339e-02f, 4.02368046e-02f, 2.22183634e-02f,
  1.89059347e-01f, -3.59346382e-02f, -1.94753200e-01f, 1.44042671e-01f, -5.92124462e-02f, 1.79071590e-01f, 1.25051169e-02f, -1.13910094e-01f, -3.87743525e-02f, -2.35978231e-01f,
  1.11570492e-01f, -1.28306791e-01f, 7.18812719e-02f, 2.07284048e-01f, -7.17681658e-04f, 4.28164676e-02f, 1.53472684e-02f, 4.69597094e-02f, 8.07286240e-03f, 1.56064793e-01f,
  2.21780598e-01f, 5.45180403e-02f, -3.29790711e-01f, -1.35559499e-01f, 6.97540641e-02f, 1.50847718e-01f, -2.42352188e-01f, 6.20277114e-02f, -5.79425395e-02f, 1.86952412e-01f,
  -3.93743254e-03f, 3.02359104e-01f, -3.20452936e-02f, 9.97787924e-04f, 9.69906747e-02f, -5.99307083e-02f, -2.44658021e-03f, 6.92959875e-02f, 1.76432401e-01f, 1.35227665e-01f,
  1.08538941e-02f, -1.12723626e-01f, -1.11160107e-01f, 4.19748109e-03f, -1.52470693e-01f, 5.55167980e-02f, -3.65537666e-02f, 1.53249409e-02f, 6.17079996e-02f, 3.97554692e-03f,
  -8.01507905e-02f, -4.80622798e-02f, -1.43198147e-01f, 1.40012085e-01f, 1.40693128e-01f, 1.04328175e-03f, -3.65383364e-02f, 4.15320359e-02f, 3.28968108e-01f, 2.26527117e-02f,
  2.69099683e-01f, 1.45732388e-02f, -4.77870367e-02f, 2.04798713e-01f, 1.97964057e-01f, 2.99649574e-02f, -2.09767535e-01f, -5.67482002e-02f, 3.09547950e-02f, -1.23349339e-01f,
  -7.41761625e-02f, -2.75420398e-01f, -1.44558474e-01f, -2.31126845e-01f, 5.52592576e-02f, -2.00288296e-01f, 2.26372302e-01f, 1.09493747e-01f, 9.55604762e-02f, 3.52771074e-01f,
  1.41259236e-02f, 5.93289882e-02f, 3.04635167e-02f, -1.49336979e-01f, 1.04320362e-01f, -1.00829355e-01f, 1.24469109e-01f, -4.77903515e-01f, 3.09083220e-02f, 1.36895284e-01f,
  -3.28779936e-01f, -1.98257379e-02f, -1.50064811e-01f, 2.05620863e-02f, 7.96311870e-02f, 2.85883278e-01f, -8.52261335e-02f, 1.83914155e-01f, 9.41281095e-02f, 3.78199504e-03f,
  2.21715961e-02f, 1.09559357e-01f, -1.82902887e-02f, 1.41409785e-01f, 1.39862731e-01f, 1.36472791e-01f, 1.15980424e-01f, 4.48245332e-02f, 1.21737741e-01f, -4.46267473e-03f,
  -1.17015511e-01f, 8.42473749e-03f, -5.02842255e-02f, -6.89910650e-02f, 1.40641436e-01f, 1.50589114e-02f, -1.77063011e-02f, -1.29106015e-01f, 9.64022279e-02f, 1.24408621e-02f,
  -2.06363872e-02f, 1.01941459e-01f, -3.41488719e-01f, 1.31881540e-03f, -2.48075247e-01f, 5.20311296e-02f, 2.53573418e-01f, 1.49721697e-01f, 1.17643684e-01f, 1.74710631e-01f,
  2.35294476e-01f, -5.55247217e-02f, 1.55772403e-01f, 1.96651384e-01f, 8.80384073e-02f, 7.78216869e-02f, 3.33898395e-01f, -3.33524197e-02f, 3.11405361e-01f, -1.42974049e-01f,
  3.49084139e-02f, -1.76192880e-01f, 1.04405135e-01f, -3.82900178e-01f, 1.16004057e-01f, 1.85099810e-01f, -3.67469966e-01f, 3.33293349e-01f, -3.51113193e-02f, -1.46306783e-01f,
  -1.73493579e-01f, 2.42550652e-02f, 8.48533772e-03f, -1.02932021e-01f, -6.78665712e-02f, 5.89762107e-02f, 2.13642627e-01f, 8.67162570e-02f, 3.02087720e-02f, -1.42361382e-02f,
  7.89068565e-02f, 1.35880083e-01f, 1.82167128e-01f, -5.52915372e-02f, 1.51043624e-01f, 5.72793335e-02f, 7.45998919e-02f, -4.49607782e-02f, -9.08794638e-04f, 2.21252628e-02f,
  1.05464526e-01f, 3.38808168e-03f, 4.53910325e-03f, -7.65017495e-02f, 1.04374327e-01f, 2.23990381e-02f, -2.72452347e-02f, 1.02063909e-01f, 5.70992902e-02f, -1.64277822e-01f,
  1.15731377e-02f, 2.76820287e-02f, 8.18932950e-02f, -1.81606367e-01f, 1.93712920e-01f, -4.88572614e-03f, -8.83197412e-02f, 1.77331328e-01f, -5.87380771e-03f, -1.15351088e-01f,
  1.20100975e-01f, 2.23236516e-01f, 1.69888616e-01f, 1.78363204e-01f, -2.75016963e-01f, 1.26274884e-01f, 1.47353485e-01f, 2.19313353e-01f, 3.94413203e-01f, 4.53917459e-02f,
  3.20673436e-01f, -1.99085653e-01f, 3.11328977e-01f, 1.36140466e-01f, -8.56689140e-02f, 5.04994094e-02f, 8.16279575e-02f, 8.83442983e-02f, -1.15874715e-01f, -2.41017073e-01f,
  -2.82794349e-02f, 2.32654452e-01f, 1.11328624e-01f, -3.67869623e-02f, -4.53384519e-02f, 2.14152306e-01f, 7.59177729e-02f, 9.04717594e-02f, 7.16688484e-02f, 5.36805689e-02f,
  -1.27932532e-02f, -2.28705704e-02f, -3.11444812e-02f, 1.50626764e-01f, 1.89928383e-01f, 1.60382211e-01f, 1.48551837e-01f, 1.59211003e-03f, 4.04480025e-02f, -5.79647534e-02f,
  -4.58352119e-02f, 1.07472137e-01f, 1.21011361e-01f, -1.53195038e-02f, 1.46714538e-01f, 2.36704379e-01f, -1.62490472e-01f, -1.63658969e-02f, 1.20786436e-01f, -1.34173445e-02f,
  -3.62107493e-02f, 7.83177000e-03f, -2.11271062e-01f, -1.55499771e-01f, -2.11220890e-01f, 1.96220055e-01f, -2.14205146e-01f, 1.93239048e-01f, 1.30970880e-01f, -2.25787759e-02f,
  3.88030410e-02f, 4.47783433e-02f, 3.31576645e-01f, -2.29400590e-01f, -3.78996022e-02f, 2.61062384e-01f, 2.18657136e-01f, 4.75936420e-02f, 9.74135101e-02f, 1.71343252e-01f,
  2.00041890e-01f, 1.89898774e-01f, -1.19607896e-01f, -2.79629171e-01f, -1.04193904e-01f, 5.65944565e-03f, -1.94038041e-02f, 2.17364788e-01f, -9.89375114e-02f, 1.48957208e-01f,
  -2.91536033e-01f, 1.66501790e-01f, 9.92788821e-02f, -1.40917927e-01f, -1.01942360e-01f, -7.28426725e-02f, 1.97610110e-01f, 1.28170233e-02f, 2.29538694e-01f, -2.09823728e-01f,
  9.22647640e-02f, 4.14448939e-02f, 3.97535935e-02f, 5.20601720e-02f, -2.55003572e-01f, -8.47818796e-03f, 3.78217129e-03f, -1.70832470e-01f, 4.37912345e-02f, 7.81536698e-02f,
  1.92318320e-01f, 4.19548489e-02f, 5.06634228e-02f, -1.06977962e-03f, 2.31249668e-02f, 1.04155252e-02f, 1.30690873e-01f, -8.97562504e-02f, 1.31767839e-01f, 2.55734362e-02f,
  -2.22793072e-01f, -1.21301398e-01f, -5.65845259e-02f, -2.09427327e-01f, -5.83085753e-02f, -8.07274505e-03f, -1.47197261e-01f, -1.07582659e-01f, -7.00121298e-02f, -1.16264299e-01f,
  6.19814768e-02f, 1.07795909e-01f, -1.38379067e-01f, 8.61120783e-03f, 2.28560902e-02f, -1.75494656e-01f, -2.24672601e-01f, -8.65154415e-02f, 1.41505688e-01f, -6.47702888e-02f,
  2.97467299e-02f, 1.56301469e-01f, -5.24164410e-03f, 1.34560326e-02f, 1.20055094e-01f, -1.07355542e-01f, 1.39113441e-01f, 3.06737155e-01f, 6.14679651e-03f, 8.50663409e-02f,
  4.31050584e-02f, 1.42270073e-01f, -2.10459173e-01f, 1.49688274e-01f, -7.01025948e-02f, -1.73000589e-01f, -1.72021240e-01f, -1.29888818e-01f, 1.25723511e-01f, 2.47644976e-01f,
  -9.15595293e-02f, -1.14814714e-01f, 1.22476898e-01f, 4.53851670e-01f, 3.49576212e-02f, -1.51184067e-01f, 1.35384306e-01f, -7.99423642e-03f, 1.71130255e-01f, 2.21456915e-01f,
  1.44234717e-01f, -7.16972873e-02f, 9.20080990e-02f, -2.85712760e-02f, -4.02330933e-03f, 8.85532424e-02f, -3.23767103e-02f, 8.30556974e-02f, 1.97029375e-02f, -1.19210936e-01f,
  1.07222475e-01f, 4.55386424e-03f, -2.02357277e-01f, -7.87086561e-02f, -4.72257435e-02f, 5.43432944e-02f, -1.30992934e-01f, 2.80107073e-02f, -2.06235815e-02f, 4.73161191e-02f,
  -5.73386028e-02f, 9.68903080e-02f, 1.30559534e-01f, -1.13340706e-01f, -1.57126427e-01f, 1.14001788e-01f, -4.54848856e-02f, 4.72591370e-02f, -3.71872544e-01f, 1.10413089e-01f,
  -1.19135231e-01f, -6.20456077e-02f, 1.44492239e-01f, -6.18083775e-02f, -1.11028820e-01f, 8.83035064e-02f, 2.21228585e-01f, -1.44262642e-01f, 4.91667837e-02f, 1.66417599e-01f,
  -2.79843062e-02f, 2.19762102e-01f, 6.67577758e-02f, 1.83798954e-01f, 4.54494692e-02f, -1.04368664e-02f, -1.90271821e-03f, -1.21096326e-02f, -2.87303403e-02f, -3.97658497e-01f,
  1.02471687e-01f, 2.96693314e-02f, -1.24220982e-01f, 2.86107883e-02f, -8.83926749e-02f, 3.40132900e-02f, 1.11656539e-01f, 6.26619607e-02f, 4.85947281e-02f, -1.62345886e-01f,
  -4.58990149e-02f, -2.07616817e-02f, 3.56502563e-01f, 1.65202290e-01f, 7.94982091e-02f, -1.61212698e-01f, -6.88650832e-02f, 7.57911280e-02f, -5.19640818e-02f, -1.85845774e-02f,
  8.86204392e-02f, 3.09096631e-02f, 3.82793993e-02f, 2.61167660e-02f, 1.79103151e-01f, -1.53913587e-01f, -1.87272078e-03f, 1.44606054e-01f, 1.18868202e-01f, -2.14211140e-02f,
  -2.43232027e-02f, -9.75440443e-03f, -3.76272015e-02f, -1.98753942e-02f, 8.23739171e-02f, -8.71429627e-04f, 8.85375440e-02f, 4.50144485e-02f, 7.36459270e-02f, -5.42926379e-02f,
  4.11633343e-01f, 1.22587554e-01f, -3.27624306e-02f, 3.61258956e-03f, 2.75346078e-02f, -1.42148407e-02f, 1.28313273e-01f, 7.99767300e-02f, 4.52977531e-02f, 1.48127049e-01f,
  7.54912049e-02f, 1.65212542e-01f, -1.77010566e-01f, 2.93573469e-01f, 2.82771960e-02f, -1.78130463e-01f, 2.40860939e-01f, 3.05972365e-03f, 1.07773714e-01f, 1.82616711e-02f,
  -3.11908424e-01f, 3.05405781e-02f, 9.56129953e-02f, -1.77244887e-01f, 2.69161046e-01f, 5.25294989e-02f, -1.84496686e-01f, 8.72602984e-02f, 2.76028067e-01f, 4.34087589e-02f,
  -1.76718444e-01f, -2.14891493e-01f, 9.60764010e-03f, -2.89180517e-01f, -1.09848954e-01f, 2.82698661e-01f, -1.79037273e-01f, 1.23755477e-01f, 4.25591804e-02f, 2.01393247e-01f,
  -7.91239217e-02f, 7.71182450e-03f, 1.46708652e-01f, 5.44695072e-02f, -6.71396265e-03f, 5.49225211e-02f, 6.98888153e-02f, 2.08954960e-02f, -6.18049875e-03f, 7.67248645e-02f,
  9.18984413e-02f, 2.88780387e-02f, -1.44705892e-01f, -9.18441638e-02f, -5.96477836e-02f, 4.03955281e-02f, 9.64573305e-03f, -6.32990226e-02f, -1.56226940e-02f, 1.02265157e-01f,
  1.06817216e-01f, 4.49663624e-02f, 1.48591980e-01f, 2.41825640e-01f, -2.10963070e-01f, -3.06273066e-03f, -7.57541880e-02f, 2.08193082e-02f, -2.20367149e-01f, 1.03238681e-02f,
  2.74882942e-01f, 6.09890074e-02f, -1.03329733e-01f, 1.91984087e-01f, 6.03020005e-03f, -1.92554668e-01f, 3.13047558e-01f, 1.94114715e-01f, 1.80084631e-01f, 2.15781078e-01f,
  2.55366176e-01f, -5.24788424e-02f, 2.31628984e-01f, 1.32391781e-01f, -9.23051387e-02f, 1.09982835e-02f, -1.88073784e-01f, -2.06504259e-02f, -9.35738236e-02f, -8.14180896e-02f,
  -2.26856470e-01f, 1.60754338e-01f, -2.31208548e-01f, -6.30020723e-03f, -7.72954896e-02f, 1.56767309e-01f, -6.13648966e-02f, 1.25179635e-02f, 1.25232369e-01f, 1.05739668e-01f,
  3.02464098e-01f, 5.49926236e-02f, 3.04689184e-02f, -1.28750265e-01f, 1.54499784e-01f, 6.64307252e-02f, 2.42993489e-01f, -6.82079196e-02f, 8.04030746e-02f, 1.27124339e-01f,
  -6.75328821e-02f, 3.14795524e-02f, 9.46571454e-02f, 4.34951857e-02f, 1.08553417e-01f, 2.27137685e-01f, -9.75992233e-02f, -3.45788717e-01f, -7.32599348e-02f, 3.91877331e-02f,
  3.15567583e-01f, 2.16844752e-02f, 1.47562563e-01f, -2.20815375e-01f, -5.85751310e-02f, 2.12078750e-01f, 3.12799305e-01f, 4.44074236e-02f, -1.46575525e-01f, -2.31905337e-02f,
  5.30268289e-02f, 7.35105500e-02f, 1.98664293e-01f, -2.18716636e-01f, 1.78957820e-01f, 2.50361592e-01f, 2.99097687e-01f, 2.43344471e-01f, 5.14454171e-02f, -1.99229587e-02f,
  4.36882913e-01f, -8.92016068e-02f, -2.31500134e-01f, 4.62444425e-02f, 3.17046826e-04f, -3.12016696e-01f, 2.26879969e-01f, 1.48976222e-01f, -9.01877284e-02f, 2.26084381e-01f,
  -8.55325535e-02f, 9.27931890e-02f, -2.14822948e-01f, -1.88381314e-01f, -1.76066846e-01f, 2.14773774e-01f, -6.32577017e-02f, -1.30150527e-01f, 1.41034067e-01f, -4.12703156e-02f,
  -1.31924793e-01f, -1.62579417e-01f, -1.49742231e-01f, 7.43619055e-02f, -2.40677111e-02f, -2.54711449e-01f, -2.32098892e-01f, 7.84447640e-02f, 2.10877523e-01f, -1.41073475e-02f,
  3.77030671e-02f, -5.79603277e-02f, 5.07750809e-02f, -8.92076194e-02f, -1.17279731e-01f, -3.61841060e-02f, -1.75948218e-01f, -9.66357961e-02f, -6.13355543e-03f, 6.41578510e-02f,
  2.14922443e-01f, -6.09472655e-02f, 4.38904285e-01f, 7.10204914e-02f, -3.89439315e-02f, 7.78737813e-02f, 3.62851880e-02f, -2.23263185e-02f, 2.97112158e-03f, 1.61512151e-01f,
  1.82268098e-01f, -5.66881662e-03f, -1.12641729e-01f, -9.69083328e-03f, 1.53806448e-01f, -5.99242300e-02f, -1.04181230e-01f, -1.81995794e-01f, -1.91188276e-01f, 3.92710194e-02f,
  -4.77501890e-03f, -2.75757331e-02f, -7.33429892e-03f, -4.16443050e-02f, 1.15618750e-01f, -1.92407906e-01f, -1.46370903e-01f, 1.95192859e-01f, 4.28675503e-01f, 1.55014530e-01f,
  2.36611724e-01f, 4.43967879e-02f, -2.07506835e-01f, 1.15415812e-01f, -1.45022720e-01f, -2.01705843e-02f, -3.63224372e-02f, -2.20116690e-01f, -9.29273665e-02f, 3.58160436e-01f,
  3.64180990e-02f, 6.52007014e-02f, -1.83091238e-01f, 1.49345204e-01f, 1.54338568e-01f, 1.34390414e-01f, -6.46465421e-02f, 1.70585494e-02f, 1.33700177e-01f, 2.08102420e-01f,
  5.39364293e-02f, -5.85656948e-02f, 1.21849902e-01f, 9.64101702e-02f, 1.61843419e-01f, 9.92860869e-02f, 9.06673595e-02f, -6.97055832e-02f, 1.12678334e-01f, 3.66316130e-03f,
  1.81215227e-01f, -1.28642628e-02f, 1.43739060e-01f, -1.32802762e-02f, -9.36140418e-02f, -9.40101966e-02f, 8.81611109e-02f, 1.80323410e-03f, -5.95002547e-02f, 5.00141270e-03f,
  6.59175888e-02f, -1.22319981e-01f, -5.38519546e-02f, 1.83320493e-01f, 2.86913849e-02f, -1.65238395e-01f, 8.52980167e-02f, 1.78592265e-01f, -1.21137321e-01f, 1.51057228e-01f,
  -2.80089099e-02f, -2.11186588e-01f, 2.03318670e-01f, 2.35103115e-01f, 3.18705589e-01f, 1.27839595e-01f, 1.96958575e-02f, -1.00728367e-02f, 2.56984591e-01f, 1.09924875e-01f,
  1.82179883e-01f, 9.72898751e-02f, 2.04192355e-01f, -1.32166177e-01f, 3.13793033e-01f, 2.10336134e-01f, -1.77101567e-01f, 1.77182317e-01f, -8.46638680e-02f, -3.42658833e-02f,
  -1.85730157e-03f, -3.23774889e-02f, -1.72385544e-01f, 2.01738924e-01f, -5.80466427e-02f, -3.18954736e-02f, -7.67588103e-03f, 1.26363067e-02f, 2.61618719e-02f, -9.57053453e-02f,
  -1.33346125e-01f, -1.24032851e-02f, 1.64804190e-01f, 1.18009530e-01f, -8.59846696e-02f, -1.44168869e-01f, 1.21993013e-01f, -3.48247439e-02f, -1.41407236e-01f, 8.30947980e-02f,
  1.67575069e-02f, 1.23238198e-01f, 8.14170018e-02f, -5.71780987e-02f, 1.60729587e-01f, -1.97542384e-01f, -1.14418074e-01f, 1.15006045e-01f, 1.83888689e-01f, -8.66349116e-02f,
  -2.48048548e-02f, 1.14659443e-01f, 9.80957747e-02f, -1.73897490e-01f, 2.07274780e-01f, -6.98193461e-02f, 1.77122690e-02f, 2.32610866e-01f, -1.91168755e-01f, -3.92787457e-02f,
  6.07758984e-02f, 2.22176891e-02f, -4.85002920e-02f, 2.95784827e-02f, 5.49222678e-02f, -7.25613460e-02f, 3.34635726e-03f, -1.19802222e-01f, -1.09614007e-01f, 9.24631953e-02f,
  1.93409011e-01f, 1.82421163e-01f, 8.50681681e-04f, 3.73269945e-01f, -1.07105494e-01f, 2.00278144e-02f, 1.28460303e-01f, 2.29117632e-01f, 1.13641098e-01f, -9.93811176e-04f,
  2.63975471e-01f, 1.92586780e-02f, -1.72833890e-01f, -2.34505147e-01f, 2.76571125e-01f, 2.21605256e-01f, -3.86704177e-01f, -4.04023454e-02f, 5.16482955e-03f, 1.71563569e-02f,
  -2.07343981e-01f, -2.77094871e-01f, 1.67828083e-01f, 9.36622769e-02f, -3.19981724e-01f, 3.66629958e-01f, 6.84302766e-03f, 1.16211623e-01f, 1.65420055e-01f, -1.03468366e-01f,
  4.06089276e-02f, -4.24155481e-02f, -1.85740769e-01f, 5.54499663e-02f, -2.36054398e-02f, -2.91091222e-02f, -8.71321112e-02f, -7.16313794e-02f, 3.19215655e-02f, -1.10186189e-01f,
  -1.62586316e-01f, -1.43786609e-01f, 2.27830838e-02f, 2.10609570e-01f, 2.17538789e-01f, -8.43615681e-02f, 1.25250770e-02f, 5.67289777e-02f, -4.90349866e-02f, -5.77722453e-02f,
  -1.17570519e-01f, 8.65854025e-02f, 1.02049388e-01f, -1.49519891e-01f, -6.71006590e-02f, 1.88274980e-01f, -4.06276472e-02f, 1.67386681e-01f, 1.95992351e-01f, 1.68235123e-01f,
  -1.82643570e-02f, 1.84439182e-01f, 1.47663474e-01f, 5.48908189e-02f, -3.73323977e-01f, 1.29919648e-01f, -2.75291298e-02f, -5.32761402e-02f, -4.25145663e-02f, -3.74169387e-02f,
  2.49815494e-01f, -2.24350587e-01f, 1.65422156e-01f, 7.51932859e-02f, -2.42648646e-01f, -2.43978593e-02f, 1.39725164e-01f, 4.61889729e-02f, -1.40286133e-01f, 1.18368208e-01f,
  -8.48771408e-02f, 2.43239641e-01f, 2.24047542e-01f, -9.61096305e-03f, -2.26664409e-01f, -3.09913903e-01f, 9.16222259e-02f, -9.33891628e-04f, 1.66329548e-01f, 7.42679313e-02f,
  -1.96154535e-01f, 2.53915116e-02f, 1.72550872e-01f, 2.84742206e-01f, -3.45810801e-02f, 1.99942455e-01f, 6.29724190e-02f, 1.20617645e-02f, 5.67761622e-02f, 1.17072225e-01f,
  -2.02774466e-03f, 2.09722474e-01f, -5.50586060e-02f, 1.51676923e-01f, -5.03888465e-02f, -5.07922359e-02f, 1.25712026e-02f, 1.98686674e-01f, 6.78580999e-02f, 2.65186187e-03f,
  1.31252661e-01f, 8.26814212e-03f, 5.26947435e-03f, -1.24905810e-01f, -1.23372719e-01f, -5.49225770e-02f, 1.41413838e-01f, 5.96608780e-03f, -1.52027473e-01f, -7.14680478e-02f,
  1.89257249e-01f, -9.37906280e-02f, 2.53818274e-01f, 3.55321094e-02f, -1.64611667e-01f, 1.44548655e-01f, 8.81468579e-02f, -9.14890617e-02f, -3.25992435e-01f, 3.80248763e-02f,
  -2.29840904e-01f, -2.59595484e-01f, 2.41412625e-01f, 1.87806301e-02f, 2.27067084e-03f, 3.85534242e-02f, -1.58111900e-01f, -1.10424653e-01f, -6.84786364e-02f, 6.93375850e-03f,
  -1.56882465e-01f, 2.48504192e-01f, -3.92930925e-01f, -2.59747505e-01f, 2.16420606e-01f, -4.03106734e-02f, 4.15331125e-02f, 1.38280660e-01f, 2.48394206e-01f, 4.48636003e-02f,
  3.92718166e-02f, -1.21153452e-01f, 1.59259260e-01f, -2.91690230e-01f, -2.44169906e-01f, -3.79954614e-02f, -5.66536412e-02f, 6.17787652e-02f, -1.43725530e-03f, 3.46054472e-02f,
  -9.75546055e-03f, 1.86609685e-01f, 7.53843188e-02f, 1.26010895e-01f, 7.39377886e-02f, -4.02665064e-02f, 1.48475513e-01f, 6.03509508e-02f, 1.68790668e-01f, 7.41003314e-03f,
  -1.55205373e-02f, 2.68202871e-02f, -8.87652040e-02f, -1.06458209e-01f, -7.65582845e-02f, 1.97424069e-01f, 2.94769973e-01f, 1.74587280e-01f, -1.17569650e-02f, 1.38058826e-01f,
  -1.64040670e-01f, -9.57843140e-02f, -9.06316936e-02f, -4.59237956e-02f, -1.08559318e-01f, -1.37517691e-01f, 1.04935281e-01f, 5.65769672e-02f, -6.21603103e-03f, 2.47449145e-01f,
  2.10358918e-01f, 8.11605379e-02f, -5.49442358e-02f, -7.76622593e-02f, -7.11182803e-02f, -2.15714559e-01f, 2.11600158e-02f, 5.36983609e-02f, -1.19043179e-01f, 1.24110378e-01f,
  1.04242779e-01f, -1.44652754e-01f, 1.38235427e-02f, -1.41817452e-02f, 2.31754199e-01f, 1.16361894e-01f, 3.43356133e-02f, 4.90573943e-02f, 2.16992766e-01f, 2.00179577e-01f,
  3.02184094e-02f, 3.51212882e-02f, -2.07059249e-01f, 2.15541385e-02f, 2.00986207e-01f, -1.80030927e-01f, -2.49391779e-01f, -2.16509640e-01f, -3.92287737e-03f, -1.52271971e-01f,
  -6.72171265e-02f, 2.14693934e-01f, 4.76496555e-02f, 2.79491872e-01f, 2.96402648e-02f, 1.15358166e-01f, 1.13027906e-02f, 1.34250820e-01f, 2.47272566e-01f, -1.38441185e-02f,
  7.04051033e-02f, 1.43195763e-01f, 1.08983545e-02f, 3.68132107e-02f, 2.03468218e-01f, 1.56154782e-01f, 1.25160649e-01f, -1.14113621e-01f, -1.61932781e-03f, -6.27977848e-02f,
  -6.46970645e-02f, -1.48468450e-01f, -2.97085177e-02f, 2.03448310e-02f, 9.70069543e-02f, -2.95512984e-03f, 2.31988445e-01f, -1.36246681e-01f, -2.58046448e-01f, -1.78654447e-01f,
  8.54103547e-03f, -1.85747430e-01f, 4.22696844e-02f, 4.00489308e-02f, -1.74329042e-01f, -1.19917832e-01f, 4.42036167e-02f, -3.39406286e-03f, -2.66676664e-01f, 1.09488562e-01f,
  2.55833834e-01f, -2.23865092e-01f, -3.46688665e-02f, 1.82858389e-02f, -1.39246345e-01f, 2.18524173e-01f, -1.87551498e-01f, 2.91179549e-02f, -1.15669966e-01f, 6.49955869e-02f,
  1.62265837e-01f, -1.34524971e-01f, -4.55639437e-02f, -1.84818521e-01f, 2.68814147e-01f, 9.34909880e-02f, -1.26954928e-01f, 1.17193744e-01f, -5.15764616e-02f, -2.55983979e-01f,
  -6.03011101e-02f, 1.89812258e-01f, -3.07557702e-01f, 1.35680526e-01f, -1.77622929e-01f, -4.91003096e-02f, 4.71401634e-03f, 2.21889708e-02f, 1.28569573e-01f, 1.90808460e-01f,
  3.74878757e-02f, 9.16446075e-02f, 4.31114621e-02f, -3.05775385e-02f, -5.72533347e-02f, 6.41463995e-02f, 1.81671605e-01f, 4.66202572e-02f, 2.01827779e-01f, 1.11201204e-01f,
  -3.02933529e-02f, 9.36604813e-02f, -1.62901089e-01f, 1.12696784e-02f, -3.76901478e-02f, 4.42124568e-02f, 1.42580450e-01f, 5.84456511e-03f, 1.11745067e-01f, -1.16593488e-01f,
  1.10629894e-01f, -2.25855887e-01f, -2.17623278e-01f, -1.43699691e-01f, -2.99067833e-02f, -6.89631253e-02f, -1.17932633e-01f, -1.83781639e-01f, -4.54739183e-01f, -5.25864959e-03f,
  2.94732422e-01f, 1.45849004e-01f, -1.84161738e-01f, -3.23598832e-02f, 2.16426358e-01f, -1.07201405e-01f, 2.11122841e-01f, 5.99395521e-02f, -6.45026341e-02f, 5.66285774e-02f,
  -9.67867076e-02f, -1.47849858e-01f, -1.05599061e-01f, 1.82597607e-01f, 3.32453325e-02f, -1.12284916e-02f, 1.27948686e-01f, -2.49956936e-01f, 9.71902534e-03f, 2.45583534e-01f,
  2.65413254e-01f, 4.16579604e-01f, -3.30023319e-02f, 1.36112139e-01f, 3.50276351e-01f, 1.85719162e-01f, -2.63604343e-01f, 9.78540555e-02f, -1.75968811e-01f, -1.29965842e-01f,
  -2.11032256e-02f, 1.17140174e-01f, -9.67682451e-02f, 2.71373808e-01f, 1.32162673e-02f, 3.28831896e-02f, 5.44425175e-02f, -1.86472058e-01f, 9.42415893e-02f, 1.36552706e-01f,
  -2.84182765e-02f, -1.83228552e-02f, 9.11524072e-02f, 1.22844480e-01f, 3.60647915e-03f, -2.27405485e-02f, -1.64580867e-01f, 2.15647310e-01f, 8.37278515e-02f, -3.26632410e-02f,
  1.52053878e-01f, -1.22015975e-01f, -7.88020939e-02f, 1.45828173e-01f, 7.31244236e-02f, 4.65072133e-02f, -1.69850841e-01f, -2.59735644e-01f, -1.59955338e-01f, -1.49695367e-01f,
  1.96707666e-01f, -2.05171391e-01f, -7.42765442e-02f, -6.38991594e-02f, 6.82875142e-02f, -8.53891149e-02f, -3.02731898e-02f, -2.92989723e-02f, 9.44408104e-02f, 1.64362043e-01f,
  -1.26530146e-02f, 2.85537481e-01f, -1.09888263e-01f, -2.86712080e-01f, 6.26270026e-02f, 2.07604207e-02f, -6.42232597e-02f, 1.15643471e-01f, 1.70565218e-01f, -4.20216061e-02f,
  -6.84179068e-02f, 4.24850918e-02f, 1.34131163e-02f, -5.51596247e-02f, 6.90248534e-02f, 8.35546404e-02f, 4.92225252e-02f, 1.96735620e-01f, 1.19475543e-01f, 7.20784888e-02f,
  3.79774660e-01f, 2.59444509e-02f, -3.28814760e-02f, 1.23964120e-02f, 5.89751676e-02f, 1.06324114e-01f, -1.14755005e-01f, 8.96786824e-02f, -8.70498493e-02f, 9.10672024e-02f,
  -5.79267181e-03f, 2.62240563e-02f, 5.04345223e-02f, 4.33414988e-02f, -1.77816540e-01f, 8.25136900e-02f, -8.86617042e-03f, -4.52829525e-02f, -6.82983920e-02f, 1.67080060e-01f,
  -7.64144287e-02f, -9.03958902e-02f, -1.02493525e-01f, -3.82774323e-02f, -5.55321015e-02f, 4.72946912e-02f, -1.71292648e-01f, 1.10456243e-01f, 1.52963340e-01f, 5.67672364e-02f,
  2.55189836e-01f, 1.22285366e-01f, 1.30024716e-01f, 6.56953827e-02f, -8.83254129e-03f, 2.45972350e-02f, 1.24548443e-01f, -7.50822276e-02f, -3.79468761e-02f, 6.85558319e-02f,
  6.60943985e-02f, 9.47142541e-02f, -1.93352595e-01f, -2.12129086e-01f, -2.36045361e-01f, 3.28239873e-02f, -7.44886696e-03f, 1.25915959e-01f, 3.32550228e-01f, 1.16008803e-01f,
  -3.63210924e-02f, 1.72203034e-01f, 1.15517870e-01f, 1.58281431e-01f, -1.81773290e-01f, 1.03568956e-01f, 1.79687157e-01f, 9.58652422e-02f, 1.40448576e-02f, -4.22125697e-01f,
  2.21998900e-01f, -2.25538723e-02f, -2.57628053e-01f, -7.88211226e-02f, -4.34906743e-02f, 5.75158596e-02f, 1.51144117e-01f, -4.25689667e-02f, 7.73535967e-02f, 2.23291833e-02f,
  1.41316295e-01f, 1.68228030e-01f, 5.64454906e-02f, 1.63236782e-01f, 4.70103808e-02f, 2.09879759e-03f, 8.34224224e-02f, 1.43218979e-01f, 1.61346048e-01f, -1.35766372e-01f,
  -2.46573742e-02f, -8.77982527e-02f, -6.15863763e-02f, -1.89514160e-02f, -4.80669923e-02f, -7.32008219e-02f, 1.36068389e-01f, 1.88186616e-01f, -1.50603414e-01f, -1.77302569e-01f,
  -1.38659477e-01f, 9.93322507e-02f, -4.04632628e-01f, -1.95530012e-01f, 1.10464759e-01f, -1.24264389e-01f, -6.96270913e-03f, 6.41853884e-02f, 8.43616202e-02f, 1.73481226e-01f,
  8.95935521e-02f, -9.07633919e-03f, 1.52069837e-01f, -1.15576945e-01f, 2.65553296e-01f, -1.16354361e-01f, -2.88253695e-01f, 1.57991126e-01f, 1.08737059e-01f, 8.77225325e-02f,
  1.32278860e-01f, -1.68649495e-01f, 1.09145083e-01f, 9.74547416e-02f, -1.63550720e-01f, -6.53877929e-02f, -6.95719495e-02f, 4.64157239e-02f, -9.50290412e-02f, 6.28541932e-02f,
  -2.35031754e-01f, 5.80624491e-03f, 1.79704100e-01f, 8.92637148e-02f, 1.54185638e-01f, 1.81583017e-01f, 1.56391159e-01f, -7.82995373e-02f, 3.43507826e-01f, -1.21038817e-01f,
  1.41003639e-01f, 3.56836691e-02f, -2.81798542e-02f, 8.70442390e-02f, 1.99204564e-01f, -9.39638615e-02f, 1.19814605e-01f, -3.27977240e-02f, 7.06287995e-02f, 1.33572489e-01f,
  3.30494344e-02f, -1.70365758e-02f, 5.93023039e-02f, 8.03391039e-02f, -1.17756583e-01f, 3.62052508e-02f, -4.46060821e-02f, -9.69304219e-02f, -8.59842598e-02f, -2.19629437e-01f,
  1.79259226e-01f, -1.94446400e-01f, 2.82228049e-02f, 1.00581996e-01f, 7.56922886e-02f, -4.24338840e-02f, 1.25482082e-01f, 1.30744785e-01f, -7.63232708e-02f, 1.09205291e-01f,
  2.56715864e-01f, -1.78692535e-01f, 1.38559654e-01f, 8.35610256e-02f, 2.63446957e-01f, 1.91613987e-01f, 5.18348739e-02f, -1.37215015e-03f, 1.07093461e-01f, 3.14527869e-01f,
  -1.32285699e-01f, -1.48166895e-01f, 1.49639443e-01f, -2.16610134e-01f, 1.89300522e-01f, 4.67695966e-02f, -2.61949897e-01f, 1.86691284e-01f, -8.11947584e-02f, -1.07242595e-02f,
  2.22587064e-01f, -9.62482020e-02f, -1.23354577e-01f, -4.35626097e-02f, 2.12018907e-01f, 1.80039316e-01f, 1.52169153e-01f, -3.86570878e-02f, -1.57503337e-01f, -2.15029507e-03f,
  5.51022664e-02f, 2.17961356e-01f, 1.06449112e-01f, -2.87707597e-01f, -2.70923197e-01f, 4.80459780e-02f, 7.52090514e-02f, 8.16489458e-02f, -8.30243453e-02f, 5.25873154e-02f,
  5.09031452e-02f, 1.52848810e-01f, 1.23140380e-01f, 1.87386975e-01f, 2.26905301e-01f, -1.32456003e-03f, -9.34886858e-02f, 1.29891504e-02f, -7.28672668e-02f, 9.75669082e-03f,
  -1.03576526e-01f, -3.07160169e-02f, -7.72424638e-02f, 1.28703743e-01f, 1.76749259e-01f, -6.25184029e-02f, -2.16326360e-02f, -4.03182730e-02f, -3.98315154e-02f, -3.89582962e-02f,
  2.60398000e-01f, 5.93640916e-02f, -2.88296103e-01f, -7.16854334e-02f, -3.14578451e-02f, 1.71404645e-01f, 1.16394825e-01f, 2.51666039e-01f, 2.75496364e-01f, 2.22089723e-01f,
  -1.96401224e-01f, 2.43590847e-02f, -1.07580535e-01f, 2.71694083e-02f, -4.70856437e-03f, 1.60000846e-01f, 7.00244531e-02f, 9.80624110e-02f, 2.49752745e-01f, -2.34471858e-01f,
  1.00888796e-01f, -1.80786401e-02f, 1.54559746e-01f, -8.66335332e-02f, -5.91630414e-02f, 2.22585127e-01f, -1.24354623e-01f, 1.19443335e-01f, 1.39645576e-01f, -9.70643461e-02f,
  -1.33909583e-01f, -1.86874524e-01f, 6.61640614e-02f, -1.00000069e-01f, -1.70350745e-01f, 4.49368767e-02f, 4.37833697e-01f, -2.85727829e-01f, -8.39134231e-02f, 1.63660765e-01f,
  1.23356201e-01f, 1.34869456e-01f, -1.24024712e-01f, 9.64210033e-02f, 2.06310153e-02f, 1.94321856e-01f, 1.37577221e-01f, 7.25760460e-02f, -9.80458315e-03f, 2.73162395e-01f,
  1.75953299e-01f, 2.91777432e-01f, 1.83093116e-01f, 1.87444478e-01f, 1.87300280e-01f, -1.68107934e-02f, -9.74496230e-02f, 1.26013234e-01f, 4.09766659e-03f, -7.09637674e-03f,
  -9.22468901e-02f, 2.00490952e-01f, 1.00558475e-01f, -2.21813068e-01f, 9.84581858e-02f, 4.98081036e-02f, -2.32211240e-02f, -1.15825780e-01f, 1.85819343e-01f, -9.17504355e-02f,
  -9.42761675e-02f, 1.01577871e-01f, -3.09979497e-03f, -1.46776184e-01f, 5.19324020e-02f, 1.55416384e-01f, -2.85352677e-01f, 1.44185666e-02f, 1.89059481e-01f, -3.36077571e-01f,
  4.10441495e-02f, -2.26809904e-02f, -7.59845972e-02f, -2.37057591e-03f, -1.48121566e-01f, -8.13189074e-02f, -8.23350623e-02f, 3.20739090e-01f, 1.73293501e-01f, 9.38920453e-02f,
  3.03528532e-02f, -1.73778877e-01f, 2.18434826e-01f, -3.72429974e-02f, -1.62837431e-01f, 5.57116000e-03f, 9.57151133e-05f, -1.55385748e-01f, -4.73371334e-02f, 2.40708411e-01f,
  -2.71336615e-01f, 1.86288521e-01f, 2.70529147e-02f, 6.03486598e-02f, 2.12522954e-01f, 1.41991733e-03f, 6.87842369e-02f, 1.68861777e-01f, 4.86554578e-02f, 3.19085009e-02f,
  1.49307266e-01f, -1.22077458e-01f, 6.73046708e-02f, 2.48198792e-01f, 3.16041447e-02f, 2.00066805e-01f, 3.27445537e-01f, -2.82617033e-01f, 1.50905848e-01f, 1.25185803e-01f,
  1.52387589e-01f, 1.66563347e-01f, 1.58725351e-01f, 5.13203144e-02f, 1.16413552e-02f, -1.12564743e-01f, 6.28806502e-02f, -8.41784924e-02f, 3.10660332e-01f, 8.11919272e-02f,
  -1.74631834e-01f, -1.52076155e-01f, -3.60077918e-01f, -1.52550414e-01f, 7.70979598e-02f, -1.86330751e-01f, -3.93394411e-01f, 4.71740775e-02f, 3.97966504e-01f, -1.44135058e-02f,
  -2.32304007e-01f, 5.31560136e-03f, 1.25263825e-01f, 1.61948174e-01f, 8.88403226e-03f, 8.01552609e-02f, -1.49709821e-01f, 8.82564485e-02f, -2.96886060e-02f, 9.86257344e-02f,
  -4.61712154e-03f, -7.97763020e-02f, 2.49027520e-01f, 2.17921287e-01f, 1.39140757e-02f, -2.33403919e-03f, 1.51559189e-01f, 1.34836631e-02f, -3.65211070e-01f, 2.80294746e-01f,
  -6.41586632e-02f, 8.80680308e-02f, 1.70336906e-02f, 2.60756705e-02f, 2.13692635e-01f, 4.08004299e-02f, 6.65742829e-02f, -2.17351615e-01f, 1.82904955e-02f, 1.24882020e-01f,
  2.29159549e-01f, 1.44124485e-03f, 5.43689728e-02f, 1.63752973e-01f, 5.00974916e-02f, 8.90988111e-03f, -6.29536947e-03f, 1.19387232e-01f, 7.46512562e-02f, 8.09730813e-02f,
  -1.95388868e-01f, 1.40653364e-03f, -1.19251959e-01f, -5.61738797e-02f, 6.20085187e-02f, -2.11914122e-01f, -1.39891729e-01f, -1.40377013e-02f, -3.50805074e-01f, 1.26987666e-01f,
  4.53739520e-03f, 1.17664151e-01f, 5.52805886e-02f, -3.30932550e-02f, 2.39458978e-01f, 3.91514391e-01f, 3.68845731e-01f, -1.95507389e-02f, -5.19230962e-02f, 1.32437497e-01f,
  2.08908439e-01f, -9.70083103e-03f, 1.22635052e-01f, 2.76835710e-01f, 1.73313394e-01f, 3.38699371e-02f, -4.58760336e-02f, -3.66711289e-01f, -1.51447892e-01f, -7.10035414e-02f,
  -6.98423311e-02f, 1.97733641e-01f, -9.19650570e-02f, -1.26858756e-01f, -3.05929203e-02f, 2.45396167e-01f, 1.50047451e-01f, -3.34587991e-01f, -5.51836826e-02f, -1.55657247e-01f,
  1.93877563e-01f, 2.35211160e-02f, 2.32285067e-01f, -2.14618504e-01f, 6.59995228e-02f, 6.49699792e-02f, -4.99949902e-02f, 1.63223352e-02f, -3.65390271e-01f, -2.26176530e-01f,
  5.61097153e-02f, -1.62949994e-01f, -2.33971570e-02f, -2.01668516e-02f, 2.09157094e-02f, 1.88569397e-01f, 1.31918997e-01f, 3.36317457e-02f, 5.66891283e-02f, 2.85966545e-01f,
  -3.87649052e-02f, 6.47734478e-02f, -3.07246260e-02f, -2.70565264e-02f, 9.29215699e-02f, -7.77459815e-02f, -2.49467194e-02f, 6.33583665e-02f, -2.91425176e-02f, -1.31808862e-01f,
  1.01152966e-02f, 2.07423046e-01f, 5.54314675e-03f, 8.58688280e-02f, -1.28782272e-01f, -1.10012433e-02f, -9.28139389e-02f, -1.53670430e-01f, 1.33045837e-01f, 9.68872849e-03f,
  -1.50908709e-01f, 1.53382763e-01f, 1.67832673e-01f, -1.59667924e-01f, -2.25134447e-01f, 1.61147360e-02f, -3.07612997e-02f, -1.51103497e-01f, 1.87128842e-01f, -1.32968277e-01f,
  -2.01194033e-01f, -9.73940268e-02f, -3.08601528e-01f, -9.38440040e-02f, -6.02842234e-02f, 5.72963133e-02f, 2.73961872e-01f, -1.27439126e-01f, -7.19467551e-02f, 2.99422950e-01f,
  1.78777277e-02f, 2.40318403e-02f, -1.52187064e-01f, 1.35520205e-01f, -7.16762766e-02f, 1.23220921e-01f, -2.61580616e-01f, -1.55390501e-01f, 2.02959940e-01f, 1.20882727e-01f,
  -3.44329141e-02f, -1.70159023e-02f, 3.56489085e-02f, -2.92083323e-02f, 6.35985211e-02f, -1.18381411e-01f, 2.73519494e-02f, 2.19532087e-01f, 2.91357696e-01f, 2.17068866e-01f,
  2.70499438e-01f, 9.04089212e-02f, 5.70735373e-02f, -1.18284620e-01f, 3.86271328e-02f, 2.48076096e-01f, 9.67950821e-02f, -1.67314753e-01f, -1.30705550e-01f, -1.82024598e-01f,
  -2.04197511e-01f, 1.57003641e-01f, -7.28848353e-02f, -7.77777880e-02f, -2.13717654e-01f, -6.66171033e-03f, 1.78002492e-02f, -6.95659034e-03f, 1.25684068e-01f, 1.80978253e-01f,
  8.15066099e-02f, 6.79821149e-02f, -1.82583788e-03f, 1.66305915e-01f, -2.47208532e-02f, -2.13168934e-01f, 1.28086880e-01f, -1.52435839e-01f, -4.23309729e-02f, 1.29572451e-01f,
  8.16521272e-02f, 2.74027064e-02f, 1.87158972e-01f, 1.80922315e-01f, 1.78829044e-01f, 9.88519639e-02f, 5.33909276e-02f, -6.17112033e-02f, -5.47045320e-02f, 3.46359521e-01f,
  -1.30095080e-01f, -2.04343302e-03f, -2.39628375e-01f, -1.45826727e-01f, 1.24875896e-01f, -2.96242356e-01f, -2.18076453e-01f, 3.39366347e-02f, -1.37425974e-01f, 4.46211211e-02f,
  2.64834296e-02f, 2.79968739e-01f, 8.04313496e-02f, -5.85603081e-02f, 1.67040020e-01f, 1.27760366e-01f, 9.20638070e-02f, 1.73847049e-01f, -1.61431134e-01f, -3.40286791e-01f,
  9.44848731e-02f, 1.61225006e-01f, -2.15616859e-02f, 2.57418692e-01f, 4.72146496e-02f, 5.16755059e-02f, 1.12820633e-01f, 9.69099849e-02f, 1.18042998e-01f, 1.78609326e-01f,
  3.76271363e-03f, -2.51940675e-02f, -8.89046863e-02f, 7.21403956e-02f, -7.46204481e-02f, 7.53035443e-03f, -6.09652475e-02f, 1.39771476e-02f, -6.12765271e-03f, 1.39528379e-01f,
  -2.04016969e-01f, -7.37471059e-02f, -2.10130230e-01f, 2.08422661e-01f, 2.73650527e-01f, 8.18490088e-02f, -3.59767452e-02f, 7.82830939e-02f, 8.87723789e-02f, 9.94159877e-02f,
  6.37783185e-02f, -2.18117744e-01f, -2.92720824e-01f, -1.35004982e-01f, 3.67942184e-01f, 3.12931240e-02f, -1.52706519e-01f, 5.80029637e-02f, -2.40179315e-01f, -5.75767756e-02f,
  -2.96664387e-01f, 2.10308820e-01f, -3.07254404e-01f, -1.64347783e-01f, 8.20903406e-02f, -1.82648674e-01f, 1.34138882e-01f, -1.13577738e-01f, 3.51054758e-01f, 2.33314961e-01f,
  4.81332187e-03f, -3.44554842e-01f, 1.06422342e-01f, -9.65629518e-02f, 1.62327960e-02f, -4.11387645e-02f, 1.04906507e-01f, 6.15270287e-02f, -1.10054515e-01f, 1.42112533e-02f,
  -6.47825748e-02f, -9.70824510e-02f, -5.93937486e-02f, 7.85676688e-02f, -3.73048037e-02f, 2.58970410e-02f, 3.32529396e-02f, 1.01350226e-01f, 5.29833604e-03f, 5.81280561e-03f,
  2.58018393e-02f, -5.84587529e-02f, -2.84525212e-02f, -6.20114543e-02f, 1.25585586e-01f, -1.83046516e-02f, 2.19512969e-01f, 1.10522494e-01f, -2.99340971e-02f, -4.45162728e-02f,
  -7.09390491e-02f, 3.30358595e-02f, 6.96964934e-02f, -1.22799955e-01f, -1.24412879e-01f, -1.45662546e-01f, -5.74844517e-02f, -9.58742127e-02f, 1.62566245e-01f, 2.65866786e-01f,
  3.05960447e-01f, -2.73032784e-01f, 2.52890855e-01f, 2.21479824e-03f, -1.28808171e-01f, 1.19135408e-02f, 2.33760461e-01f, -1.34100765e-01f, -1.11702941e-01f, -3.08368318e-02f,
  -2.49828830e-01f, -7.39798620e-02f, -1.65574218e-03f, -1.38994649e-01f, -2.22730696e-01f, 5.31200767e-02f, -1.19904980e-01f, -3.40520352e-01f, 4.86860164e-02f, -5.34854457e-02f,
  2.39977852e-01f, 3.19031298e-01f, 8.90521798e-03f, 1.06461890e-01f, 2.13939130e-01f, -1.13463648e-01f, 1.81053981e-01f, 1.46905929e-01f, 3.04068010e-02f, -1.90792978e-01f,
  1.66775972e-01f, 1.76620290e-01f, -2.06254423e-02f, 7.51583800e-02f, -4.12513673e-01f, 9.87697691e-02f, -2.52903998e-02f, 1.72312379e-01f, 7.22406292e-03f, 3.00662309e-01f,
  2.12579533e-01f, 4.17875871e-02f, 2.54414808e-02f, -1.29266018e-02f, -1.23438891e-02f, 2.62900293e-02f, 1.08171767e-02f, -5.51936775e-02f, 2.54988354e-02f, -9.46860686e-02f,
  2.76395585e-02f, 5.84908053e-02f, 4.55549769e-02f, -1.65140316e-01f, -3.17843631e-02f, 2.27007657e-01f, 1.46886900e-01f, 6.22641072e-02f, 5.04291207e-02f, -6.86078742e-02f,
  1.75303295e-01f, -2.03734577e-01f, -5.36791608e-03f, 1.00128554e-01f, 2.75038213e-01f, -2.39389688e-01f, -2.97585100e-01f, -8.92297775e-02f, 7.15910569e-02f, 2.25432944e-02f,
  2.12568209e-01f, 7.92470127e-02f, -2.99163401e-01f, -2.73216851e-02f, 6.02742359e-02f, -1.29105091e-01f, 2.40914151e-01f, 1.92238882e-01f, 2.26324782e-01f, 4.03690850e-03f,
  1.83601499e-01f, -4.10095649e-03f, -8.40755329e-02f, 1.74332544e-01f, -2.95883673e-03f, 1.92716524e-01f, -8.55900645e-02f, -1.13718033e-01f, 4.97681350e-02f, 3.73737127e-01f,
  -7.21980706e-02f, 3.52746136e-02f, -2.15687931e-01f, 2.52493829e-01f, 4.13746685e-02f, 3.99159193e-02f, -2.47793049e-02f, -7.77677968e-02f, -3.44736278e-02f, 2.76566833e-01f,
  7.48830885e-02f, 1.52617082e-01f, -1.26892820e-01f, 1.59445435e-01f, -1.07184120e-01f, 1.91094559e-02f, -9.66374278e-02f, 1.31342560e-01f, -4.70739864e-02f, -8.07235539e-02f,
  8.37473944e-02f, 1.42429605e-01f, 8.85732695e-02f, -4.41387445e-02f, 3.16720307e-02f, 4.25960869e-02f, 2.02889770e-01f, 1.38716459e-01f, 2.19071750e-02f, 1.51973113e-01f,
  -5.02046198e-02f, 1.21147027e-02f, -4.81126048e-02f, 8.70928541e-02f, 2.31523179e-02f, 1.06833555e-01f, 2.35252053e-01f, 1.40010253e-01f, 4.45675731e-01f, 1.14447482e-01f,
  1.33982971e-01f, 6.91456422e-02f, -4.99169789e-02f, 5.49001098e-02f, 1.09227106e-01f, -4.24538106e-02f, -8.74021724e-02f, 5.87965846e-02f, -2.22395658e-01f, 2.25072615e-02f,
  1.71105817e-01f, -1.75318152e-01f, -1.28829464e-01f, -2.81156916e-02f, -1.71892554e-01f, -8.49085599e-02f, -8.17113742e-02f, -5.48416078e-02f, -5.55502856e-03f, 9.63976830e-02f,
  -5.14126290e-03f, -2.14627162e-01f, 1.91263527e-01f, -3.85764949e-02f, 1.41254798e-01f, 1.54755756e-01f, 1.11150861e-01f, -5.34994751e-02f, 1.20678686e-01f, 7.53702642e-03f,
  -2.16906607e-01f, 1.13727234e-01f, -4.48296130e-01f, 7.11681321e-02f, 5.18520959e-02f, 2.71757066e-01f, 1.62122160e-01f, 4.02449332e-02f, -7.11202202e-03f, 1.97198600e-01f,
  1.39699578e-01f, 9.35253501e-02f, 1.06507763e-01f, -5.53826336e-03f, 5.31573035e-02f, 2.17961043e-01f, 1.26083726e-02f, -7.99705908e-02f, 1.99818179e-01f, 1.92297935e-01f,
  1.88214540e-01f, 1.09922342e-01f, 4.01520543e-02f, 2.52390001e-02f, -2.14160122e-02f, 5.13848998e-02f, 5.86763136e-02f, -1.58900693e-01f, -4.05964889e-02f, -1.46230757e-01f,
  -1.15841344e-01f, -5.98566607e-02f, 9.37639549e-02f, -6.94279894e-02f, 2.40659360e-02f, -1.80680946e-01f, -4.35146168e-02f, -8.66922066e-02f, -3.04798275e-01f, -1.02639243e-01f,
  2.37836391e-01f, 1.54447049e-01f, -2.85323203e-01f, -3.19701582e-02f, 2.32947260e-01f, -1.18758813e-01f, -2.43011266e-01f, -6.63856417e-02f, -2.03473613e-01f, 1.43363746e-02f,
  5.69947250e-02f, -3.25614989e-01f, 8.19864869e-02f, 1.41956821e-01f, 1.11438213e-02f, 1.05167076e-01f, 2.14103431e-01f, -3.23616296e-01f, 1.19618818e-01f, 2.70425200e-01f,
  1.02014169e-01f, 2.33344749e-01f, 7.51516037e-03f, 1.52428329e-01f, 1.32894039e-01f, 5.81706651e-02f, -4.44431663e-01f, 1.12830654e-01f, 7.90599287e-02f, -6.51642308e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -8.30092207e-02f, -8.41340646e-02f, 7.34022036e-02f, -2.11645551e-02f, 1.30493820e-01f, 1.15789190e-01f, 3.17782387e-02f, -5.00864536e-02f, 1.49633691e-01f, -6.78033456e-02f,
  3.38378437e-02f, 1.10966645e-01f, -7.01175854e-02f, 4.36119698e-02f, 6.36628494e-02f, -2.98517812e-02f, -3.31103392e-02f, -1.02987722e-01f, 1.53644711e-01f, 7.76241720e-02f,
  -3.16413641e-02f, -2.16333065e-02f, 1.76430941e-02f, 1.45783558e-01f, 1.77656233e-01f, 3.95843340e-03f, 8.74553770e-02f, 6.98353425e-02f, 2.07754478e-01f, 2.58155223e-02f,
  2.97086500e-02f, -1.16215982e-01f, 1.91012621e-01f, -5.80373518e-02f, 7.54019395e-02f, 5.05535193e-02f, 7.14017972e-02f, -2.05787271e-02f, 1.08372107e-01f, -2.39323508e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  8.06007087e-02f, -1.53851032e-01f, -1.78242669e-01f, -1.16098031e-01f, 9.94450524e-02f, 2.43607849e-01f, -1.63067609e-01f, -1.35237640e-02f, -1.33979479e-02f, -2.56058097e-01f,
  -3.41429212e-03f, 2.92877238e-02f, -3.01888943e-01f, -5.01595773e-02f, -5.24668917e-02f, 1.74275085e-01f, 1.05376989e-01f, 2.52463460e-01f, 3.50306407e-02f, 6.86639324e-02f,
  3.33263338e-01f, 1.32595420e-01f, -2.90950909e-02f, 1.07142888e-01f, 7.33812805e-03f, -1.30353153e-01f, -1.39532834e-01f, -6.63501844e-02f, 1.03377946e-01f, 9.82831977e-03f,
  -1.96659975e-02f, -8.87414888e-02f, 1.19014569e-01f, -7.51149729e-02f, 2.20142677e-03f, -2.71221437e-02f, 1.48241594e-01f, 4.38599437e-02f, 4.63624597e-02f, 6.57479092e-02f,
  -1.88363403e-01f, -1.26100900e-02f, 1.64356828e-02f, -1.39379367e-01f, -1.68969020e-01f, -3.56252044e-02f, -1.22713074e-01f, 1.55816665e-02f, 6.46232590e-02f, 1.21338248e-01f,
  -1.34377480e-01f, 2.78066564e-02f, -1.81863949e-01f, -1.30333558e-01f, -1.02173807e-02f, 4.93151471e-02f, -1.68502897e-01f, -2.04142019e-01f, 4.76444066e-02f, -1.07127838e-01f,
  1.44563883e-03f, 1.45247236e-01f, -1.23165391e-01f, 7.68989176e-02f, 1.78451404e-01f, -1.73333868e-01f, -3.07751894e-01f, 5.16895764e-02f, 1.16589718e-01f, -5.54465167e-02f,
  4.20841612e-02f, -1.13006182e-01f, -1.33991867e-01f, -2.59562016e-01f, 1.39785260e-01f, -6.90705255e-02f, -1.29863992e-01f, -6.62155449e-02f, 1.74659967e-01f, 6.37607202e-02f,
  2.88040817e-01f, 3.22731942e-01f, 4.33751225e-01f, -1.78550690e-01f, 1.47391766e-01f, -3.34642172e-01f, 1.29022598e-01f, 8.38505924e-02f, -1.47635117e-01f, -2.49032844e-02f,
  3.71240787e-02f, 1.28300646e-02f, 1.23762548e-01f, 2.24367008e-01f, 1.80269331e-01f, -9.86636057e-02f, -2.02742979e-01f, 4.71703075e-02f, 2.37134919e-02f, 7.78309181e-02f,
  1.37013257e-01f, -3.33822034e-02f, 5.42960828e-03f, 6.19288459e-02f, -4.36517186e-02f, 6.53097704e-02f, -8.59519560e-03f, 1.80421602e-02f, -1.30620137e-01f, -3.18875946e-02f,
  2.52551259e-03f, -1.61931410e-01f, -9.70518775e-03f, 7.59012103e-02f, -4.37245592e-02f, 1.16007335e-01f, 2.86073703e-02f, -4.11384106e-02f, -9.01399702e-02f, -9.72264353e-03f,
  -1.41748667e-01f, -2.64869370e-02f, 9.91025288e-03f, 1.36090487e-01f, -1.37831837e-01f, -1.49723306e-01f, -5.52861542e-02f, -3.31329219e-02f, -1.03155002e-01f, 4.30777967e-02f,
  2.22143039e-01f, -2.81666189e-01f, -8.10010284e-02f, -2.42049750e-02f, -1.07880682e-01f, 9.80527475e-02f, 4.95277454e-05f, 1.29800379e-01f, 2.95670360e-01f, -1.21003143e-01f,
  -1.77401558e-01f, -9.47959125e-02f, -5.71488477e-02f, -3.66204306e-02f, -5.09422644e-05f, 2.23061994e-01f, 8.03540051e-02f, -1.95737965e-02f, -2.25840196e-01f, -4.02672619e-01f,
  6.61746711e-02f, -8.05883929e-02f, -7.44859129e-02f, 5.29126339e-02f, -1.27388779e-02f, 5.72107099e-02f, 1.44425318e-01f, -5.40005341e-02f, -3.68414856e-02f, 5.99051034e-03f,
  -7.63801336e-02f, 2.49663778e-02f, 6.98491260e-02f, -2.30806708e-01f, 1.33857476e-02f, 1.98027775e-01f, 1.74448624e-01f, 1.22046530e-01f, 1.04028448e-01f, -3.46783102e-02f,
  1.11248426e-01f, 1.26956284e-01f, 8.99312273e-02f, 3.00635565e-02f, 7.64933974e-02f, -4.38254662e-02f, 2.53794855e-03f, 1.10586956e-01f, 1.38070723e-02f, 8.58306140e-03f,
  9.24807861e-02f, 2.09022552e-01f, -2.30040535e-01f, 1.36670768e-01f, -1.92463532e-01f, -5.66907637e-02f, -4.42935564e-02f, 1.98309541e-01f, 8.06606859e-02f, 5.49869873e-02f,
  1.44894838e-01f, -3.72222848e-02f, 5.22237159e-02f, 1.39615804e-01f, -7.74600133e-02f, 3.61856706e-02f, 4.65170555e-02f, -2.11752906e-01f, -6.22223429e-02f, -1.55612722e-01f,
  -3.02740671e-02f, 4.60240208e-02f, 1.16799101e-01f, 2.04822376e-01f, -2.39256863e-02f, -3.09057627e-02f, -5.24339378e-02f, -3.10045611e-02f, -9.11568999e-02f, 8.23099017e-02f,
  -3.18567455e-01f, 6.72881550e-04f, 9.22010690e-02f, 1.11130662e-02f, -9.53502208e-02f, 2.60207087e-01f, 2.22570375e-01f, 1.37623936e-01f, 1.06218075e-02f, 1.24124801e-02f,
  -8.70520771e-02f, 4.29187855e-03f, -7.66116334e-03f, -2.14668781e-01f, 2.99676619e-02f, 7.08618909e-02f, -2.77830474e-02f, -7.50048235e-02f, -1.73251480e-02f, -1.20386496e-01f,
  -1.91958219e-01f, 6.63568079e-02f, -1.21228784e-01f, -9.86280590e-02f, -2.51452804e-01f, -3.19844335e-01f, 6.43161535e-02f, 7.72708580e-02f, -1.56189933e-01f, 1.09066945e-02f,
  1.66084707e-01f, -9.83656645e-02f, -1.75489277e-01f, 1.38601467e-01f, -1.46660760e-01f, -8.46612304e-02f, 7.77371675e-02f, -3.17491242e-03f, 7.56291077e-02f, 1.08780615e-01f,
  3.55078615e-02f, 1.47936036e-04f, 3.27085406e-02f, -3.27680446e-02f, -3.66419554e-02f, 2.42004991e-01f, 5.34173176e-02f, 1.68939427e-01f, 2.00498015e-01f, 1.88944563e-02f,
  1.27556950e-01f, 2.17891000e-02f, -2.17683520e-02f, 1.26679167e-01f, 1.14342511e-01f, 9.52700824e-02f, 1.62957504e-01f, 6.54860958e-02f, -2.24417280e-02f, 6.64738119e-02f,
  2.56259233e-01f, -9.65277385e-03f, -1.28925890e-01f, 9.00132861e-03f, -1.70395762e-01f, 4.08152863e-02f, -2.17799976e-01f, 2.03047901e-01f, -4.37660143e-02f, 2.47364901e-02f,
  -1.02196783e-01f, 1.29491001e-01f, -1.75947007e-02f, 9.91469845e-02f, 1.10489491e-03f, 8.59049335e-02f, -6.51887655e-02f, -8.26556012e-02f, 1.92948222e-01f, -8.13093558e-02f,
  -1.45528644e-01f, -1.03242509e-01f, -8.25304911e-02f, 4.12888564e-02f, -1.13056034e-01f, -9.47937444e-02f, -1.45739436e-01f, -1.99803859e-01f, -1.40488550e-01f, 6.66325958e-03f,
  -8.54822919e-02f, 1.34765834e-01f, 1.80583656e-01f, 3.24286185e-02f, 1.04268752e-01f, 2.19603628e-01f, 2.42379516e-01f, 2.15220060e-02f, -1.39705449e-01f, 5.38041350e-03f,
  -2.04975139e-02f, 3.46965827e-02f, 2.12851893e-02f, 1.66341439e-01f, -2.20062092e-01f, 2.80794322e-01f, 1.12788126e-01f, -6.36578947e-02f, 1.57235190e-01f, 9.50413346e-02f,
  1.92708731e-01f, 1.70260578e-01f, -9.64872539e-02f, -4.68877070e-02f, 1.17230847e-01f, 3.31842065e-01f, 1.45716861e-01f, 1.29433498e-01f, -6.91568628e-02f, 3.12501416e-02f,
  3.44547629e-02f, -1.43949203e-02f, -7.30416626e-02f, 2.46470809e-01f, 1.06763102e-01f, 1.52756333e-01f, 2.19388828e-02f, 1.23349525e-01f, -1.28105521e-01f, 2.30466444e-02f,
  5.55068105e-02f, 2.10455060e-01f, -2.49642022e-02f, 5.91129959e-02f, -1.94931760e-01f, -1.18522681e-01f, 5.79346493e-02f, -1.43340737e-01f, -1.51041985e-01f, 2.43637219e-01f,
  1.12480804e-01f, -2.42998496e-01f, -9.11847875e-02f, -1.24857880e-01f, -1.51849046e-01f, -4.11371738e-02f, 4.81522679e-02f, 8.78040642e-02f, -1.18242372e-02f, -4.57801521e-02f,
  2.75476780e-02f, -1.64336264e-02f, -1.26219857e-02f, 3.95539664e-02f, -2.39028931e-01f, -1.04913287e-01f, -2.30110232e-02f, 2.32893795e-01f, 3.43184173e-01f, 1.02160089e-01f,
  -5.86486273e-02f, -1.28477216e-01f, -2.27431338e-02f, -1.72173560e-01f, -2.07766872e-02f, 1.35417044e-01f, 2.18967512e-01f, -1.16843738e-01f, 9.99335200e-03f, -1.47933578e-02f,
  -1.17311046e-01f, -4.09271531e-02f, 9.06283483e-02f, 1.92827418e-01f, 1.13233291e-02f, -1.02991588e-01f, -1.67733029e-01f, 1.04281714e-03f, -6.73045889e-02f, -8.45554024e-02f,
  1.30121456e-02f, -1.59745380e-01f, -1.20049931e-01f, -1.72907665e-01f, -1.46606147e-01f, 4.27873805e-02f, 8.13431516e-02f, 1.94373168e-02f, -1.35642160e-02f, -8.92021731e-02f,
  8.81914347e-02f, -5.41709848e-02f, 1.34515584e-01f, 3.24707502e-03f, 2.57762242e-02f, -3.34302723e-01f, -1.89072505e-01f, -7.64151663e-02f, 6.43527582e-02f, 1.28015116e-01f,
  1.75311595e-01f, 1.38284415e-01f, 2.02414766e-01f, -2.93582082e-01f, -1.56976178e-01f, 1.99590862e-01f, -2.93988595e-03f, 1.67820856e-01f, 3.88545766e-02f, 5.43352067e-02f,
  -5.30383587e-02f, 4.90886047e-02f, -2.75715590e-02f, 1.53950378e-01f, 8.16275105e-02f, 1.63292453e-01f, 1.39885440e-01f, 9.23918784e-02f, 1.21737503e-01f, -1.51883498e-01f,
  -1.20488882e-01f, -2.58410662e-01f, -1.91840261e-01f, 5.14577478e-02f, 7.74599835e-02f, 1.42482102e-01f, 9.80152339e-02f, -6.92228898e-02f, -2.56109089e-01f, -7.65796900e-02f,
  2.63769599e-03f, 6.83407187e-02f, 8.76317471e-02f, -1.55542955e-01f, -1.56990960e-01f, 6.83987886e-03f, 1.71990748e-02f, -1.99018925e-01f, -8.64249375e-03f, -4.27117012e-03f,
  2.29264833e-02f, -1.98927402e-01f, -2.94696051e-03f, -2.70070523e-01f, -1.80811644e-01f, -1.95266947e-01f, -8.88468176e-02f, 1.81052148e-01f, -3.40361260e-02f, 6.49711490e-02f,
  2.60923833e-01f, -1.31396984e-03f, -1.42700672e-01f, -2.33019516e-01f, -1.05723456e-01f, -1.67936552e-02f, -1.33572146e-01f, 2.37888336e-01f, 5.22532649e-02f, -5.27719520e-02f,
  -2.97862053e-01f, -2.30822951e-01f, 8.81725773e-02f, 5.95830604e-02f, -1.73147283e-02f, 1.26424924e-01f, -1.05109520e-03f, -1.54282019e-01f, 3.81923802e-02f, 1.86572120e-01f,
  2.63127536e-02f, -6.96757212e-02f, 5.17068431e-02f, -1.31960303e-01f, -6.87451810e-02f, -6.90084249e-02f, -6.00953698e-02f, 7.06453919e-02f, 2.60124449e-02f, -7.21648633e-02f,
  1.06874757e-01f, -1.42166197e-01f, 1.39644533e-01f, 1.08940057e-01f, 7.35499943e-03f, -1.09909669e-01f, -1.21958651e-01f, 9.05330107e-03f, 5.19569181e-02f, 4.84071895e-02f,
  1.49176449e-01f, 1.58859938e-01f, -1.07448183e-01f, -1.12377256e-01f, -1.04050465e-01f, 2.30356053e-01f, -1.21756725e-01f, -9.94212627e-02f, 2.69936249e-02f, -6.78699911e-02f,
  9.39278156e-02f, 1.81128550e-02f, -2.09509566e-01f, 3.88096124e-02f, 1.60175309e-01f, 2.37307549e-01f, 2.66727954e-01f, -1.33246094e-01f, -2.20734283e-01f, -3.17820138e-03f,
  6.98566362e-02f, 1.35669172e-01f, -1.45206498e-02f, 1.11798704e-01f, 3.28900695e-01f, 4.26009655e-01f, 3.88310850e-02f, 3.41184530e-03f, -2.38826722e-01f, 5.48665458e-03f,
  2.21239198e-02f, 1.67595699e-01f, -3.60267907e-01f, -7.84421861e-02f, -4.23674807e-02f, -1.56707525e-01f, 3.17444268e-04f, -8.25048657e-04f, -8.92792642e-02f, 1.83846224e-02f,
  5.42787462e-02f, 8.16795900e-02f, 3.06183174e-02f, 1.89314038e-01f, 6.78748935e-02f, -7.88527075e-03f, -4.76464517e-02f, 5.15405387e-02f, 1.22317486e-01f, -9.62579474e-02f,
  1.01848036e-01f, -3.41449566e-02f, 9.70098749e-02f, -6.77695349e-02f, 1.13664769e-01f, 2.25004315e-01f, -1.80400655e-01f, -7.73829371e-02f, -7.69049078e-02f, 8.76280591e-02f,
  -2.25921899e-01f, 1.49080129e-02f, -1.57436132e-02f, 1.12188645e-01f, 2.75219113e-01f, 5.77262565e-02f, 1.30901098e-01f, 8.83022174e-02f, -9.80305001e-02f, -4.90087159e-02f,
  -1.69710919e-01f, -1.81436315e-01f, 1.21680900e-01f, 6.27160594e-02f, -4.79249693e-02f, -1.68623850e-01f, -1.29003346e-01f, 2.60955393e-01f, -2.25924760e-01f, 1.23502582e-01f,
  -4.26938711e-03f, -2.69069791e-01f, 4.23532464e-02f, -1.32497862e-01f, 3.50652002e-02f, 1.00990005e-01f, -2.52373125e-02f, 4.16963138e-02f, 3.08792945e-02f, -9.11940858e-02f,
  -7.14008436e-02f, -2.68245369e-01f, -2.50996262e-01f, -1.08952761e-01f, -1.30160823e-01f, 1.51692405e-01f, -5.13089113e-02f, -1.36485770e-01f, -1.39337122e-01f, 9.68255997e-02f,
  8.06736052e-02f, 8.49723965e-02f, -4.95966189e-02f, 4.94136028e-02f, 1.42092407e-01f, 1.55756501e-02f, 2.01918185e-01f, -9.64200199e-02f, 9.74815041e-02f, 6.77310722e-03f,
  3.38501595e-02f, 1.71194375e-01f, -9.29966047e-02f, -4.97418642e-02f, -1.76442176e-01f, 1.25263780e-01f, -1.00749517e-02f, -2.87591815e-01f, -1.13963947e-01f, -3.10923666e-01f,
  1.25508770e-01f, 1.37318358e-01f, 8.63009766e-02f, 4.50414382e-02f, 1.02623291e-01f, 5.94374537e-02f, -8.63605067e-02f, 2.33702004e-01f, -1.16352126e-01f, 4.82635796e-02f,
  1.86803862e-01f, -1.99169684e-02f, 9.65722799e-02f, 1.75330624e-01f, -7.66029432e-02f, 1.04674496e-01f, -6.36176020e-02f, -1.39297381e-01f, -1.03056775e-02f, 1.58034548e-01f,
  8.87187198e-02f, 8.42788219e-02f, 2.49173939e-02f, 3.77828218e-02f, 1.08927995e-01f, 1.26123771e-01f, 1.89615011e-01f, 1.29013523e-01f, 5.75036369e-02f, 1.47804156e-01f,
  -1.60080224e-01f, -5.82919307e-02f, -1.30113745e-02f, 4.47842628e-02f, 2.14307338e-01f, 7.04372823e-02f, -9.04037058e-02f, -2.70483971e-01f, -3.41094345e-01f, -1.02040945e-02f,
  2.04087049e-01f, 9.67204720e-02f, 7.19583556e-02f, 7.22909123e-02f, 7.73284584e-03f, 6.80953711e-02f, 1.42232344e-01f, -1.74083844e-01f, -1.28046557e-01f, -1.31049678e-01f,
  -4.14394252e-02f, 1.98795944e-01f, 6.61681369e-02f, -1.28008947e-01f, 1.25457168e-01f, 2.07246423e-01f, -1.67189121e-01f, -1.05871953e-01f, 1.14885792e-01f, 1.36565221e-02f,
  -7.76307285e-02f, -4.01722230e-02f, 5.47246523e-02f, 1.03773117e-01f, -5.16544236e-03f, -1.36144161e-02f, -1.05406798e-01f, 9.54363942e-02f, 4.11828198e-02f, -7.29729831e-02f,
  6.32791594e-02f, -1.14174582e-01f, 9.14290324e-02f, -2.54587710e-01f, 6.98421523e-02f, -8.46524984e-02f, 3.87173027e-01f, -3.00940350e-02f, 1.53171033e-01f, 4.50423397e-02f,
  -7.80795328e-03f, -1.22016877e-01f, 3.65492791e-01f, 1.11509956e-01f, 1.22055933e-01f, -9.20288190e-02f, -3.85167807e-01f, -8.23155865e-02f, -2.31350183e-01f, 1.55747429e-01f,
  1.82341874e-01f, -1.45908937e-01f, -3.66601236e-02f, -1.27427783e-02f, 9.43630114e-02f, -2.86587536e-01f, -1.21961758e-01f, -2.65083555e-02f, 2.00700119e-01f, -1.74189851e-01f,
  1.31713733e-01f, 7.37343803e-02f, 8.17286447e-02f, -4.17327404e-01f, 4.59909230e-01f, 7.38279149e-02f, 2.02262327e-02f, 3.00236791e-01f, 1.92281380e-02f, 2.12783664e-02f,
  5.35956770e-02f, 2.44989231e-01f, 4.03311998e-02f, 2.55440585e-02f, 1.46556452e-01f, -2.83072907e-02f, -5.45893051e-02f, 8.68446976e-02f, -9.48855281e-02f, -1.25835717e-01f,
  -2.49342453e-02f, 1.34258687e-01f, -1.69266596e-01f, -3.33093256e-02f, 5.18299602e-02f, 2.78320998e-01f, -1.81868762e-01f, 7.62546733e-02f, 1.35697976e-01f, -3.83464657e-02f,
  6.91789612e-02f, -3.47997576e-01f, -1.18206032e-01f, -7.02594072e-02f, 1.60065651e-01f, 1.81014121e-01f, -2.32274726e-01f, -1.10819722e-02f, -1.26010820e-01f, -4.92615663e-02f,
  -2.61038113e-02f, 1.05516143e-01f, 5.52643389e-02f, 3.78351696e-02f, 1.49412528e-01f, 1.07956916e-01f, -7.72599876e-03f, 1.31542459e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.30417140e-02f, -1.57462612e-01f, -2.74070561e-01f, 2.49295473e-01f, 1.25336125e-01f, 1.88564479e-01f, 4.98250015e-02f, -1.62714094e-01f, -1.21315174e-01f, -1.75722227e-01f,
  3.63699086e-02f, -1.56880468e-02f, 3.13063040e-02f, -1.29497424e-02f, 1.56607777e-01f, -8.01495314e-02f, 8.24738145e-02f, -7.28869671e-03f, 1.19005091e-01f, -2.20455110e-01f,
  2.98138589e-01f, 4.33816165e-01f, 1.34089112e-01f, 1.57925580e-02f, 1.23813756e-01f, -4.48029563e-02f, -1.33156076e-01f, -1.48255378e-01f, 8.37090835e-02f, 1.51307017e-01f,
  2.15000302e-01f, -1.16615087e-01f, 2.43601173e-01f, -4.28468846e-02f, -1.28578827e-01f, 1.99335545e-01f, 1.50586516e-01f, -5.09833498e-03f, -7.47853741e-02f, -1.33694559e-01f,
  9.89983007e-02f, 2.67359138e-01f, 1.21130440e-02f, -1.62251964e-01f, -9.79612768e-02f, 1.74991235e-01f, -1.04380302e-01f, -1.18322790e-01f, -3.68500012e-03f, 1.86867580e-01f,
  3.70429382e-02f, 1.34744138e-01f, -7.45479390e-02f, -2.10872442e-01f, -8.97550210e-02f, -1.57390907e-01f, 5.84531389e-02f, -1.38206944e-01f, -4.70203161e-02f, -1.90134525e-01f,
  1.54065207e-01f, 2.19074711e-02f, 1.30313084e-01f, 1.16795845e-01f, -9.33838717e-04f, 1.40630722e-01f, -3.78968894e-01f, 9.15957429e-03f, -4.54474278e-02f, -2.27641817e-02f,
  -5.57948984e-02f, -2.31491193e-01f, -1.02813259e-01f, -1.89287484e-01f, 8.19834843e-02f, 2.07119975e-02f, -2.35989258e-01f, -3.69571924e-01f, 2.89932685e-03f, 2.52331793e-01f,
  2.21897379e-01f, 8.50078091e-02f, 8.39435980e-02f, 3.47337350e-02f, 2.92441905e-01f, -1.86265081e-01f, -4.35062200e-02f, 7.48033542e-03f, 2.04463974e-01f, -4.82676104e-02f,
  1.57525986e-01f, -4.74036932e-02f, 3.12166035e-01f, 3.17171253e-02f, 1.54057726e-01f, -1.72016859e-01f, -1.54603824e-01f, 1.66064519e-02f, 2.48754919e-01f, 2.42168121e-02f,
  1.89928144e-01f, 1.37727544e-01f, -1.48040712e-01f, 6.83365688e-02f, 6.32095858e-02f, 2.75088578e-01f, 2.53518760e-01f, -1.47071734e-01f, 5.73490895e-02f, 6.28007352e-02f,
  -2.60887563e-01f, 1.89167768e-01f, 2.80465186e-01f, 3.65848951e-02f, -2.63543993e-01f, -2.10923906e-02f, -1.09604947e-01f, -3.30823362e-01f, -1.37081712e-01f, 4.47212048e-02f,
  -2.24069327e-01f, -1.73827842e-01f, 1.34843528e-01f, -4.24905181e-01f, -1.62987620e-01f, 1.54166460e-01f, -1.18598551e-01f, -1.06121086e-01f, 3.17393959e-01f, 1.95596099e-01f,
  1.59066543e-01f, 1.89710870e-01f, 3.94818857e-02f, 1.49337456e-01f, 1.84494391e-01f, 2.09190533e-01f, 1.90584973e-01f, 2.03440592e-01f, -1.27557516e-01f, 6.68577701e-02f,
  -3.19288433e-01f, -2.33416840e-01f, 1.36434168e-01f, -1.60472870e-01f, 1.43255442e-01f, -3.10732037e-01f, 1.83270395e-01f, 1.41341193e-02f, 9.84941870e-02f, -4.69532222e-01f,
  4.55976963e-01f, 1.48872867e-01f, 2.18492970e-02f, -6.46785572e-02f, 1.26614481e-01f, -2.70085543e-01f, 1.01677582e-01f, -2.28557110e-01f, 3.30420256e-01f, 1.35096133e-01f,
  2.02876180e-01f, -9.26163420e-02f, 1.14709452e-01f, 2.66786844e-01f, 7.12685436e-02f, 4.05635238e-02f, -1.41763195e-01f, -5.10208458e-02f, 3.43159944e-01f, 4.55060042e-02f,
  1.57854781e-01f, -3.81114669e-02f, -1.11160271e-01f, -9.37282145e-02f, 1.28857777e-01f, -2.40449339e-01f, -1.12980053e-01f, 9.93454233e-02f, -4.09609117e-02f, 1.40714318e-01f,
  1.61500141e-01f, 9.29585323e-02f, -2.14318693e-01f, -3.76015276e-01f, 3.17564666e-01f, -1.34821534e-01f, 2.26487502e-01f, -2.49521270e-01f, -9.56951231e-02f, 1.85959265e-02f,
  -1.97744444e-01f, -1.80438414e-01f, 3.96522224e-01f, -1.20672174e-01f, 2.39987001e-02f, -1.69079863e-02f, 1.17851548e-01f, 3.09145272e-01f, 1.19113356e-01f, 4.97427993e-02f,
  1.93605691e-01f, 7.92022273e-02f, -3.50293517e-01f, 7.14454576e-02f, -5.90354018e-02f, -1.21404625e-01f, 3.75502259e-01f, 1.52962133e-01f, 1.70805573e-01f, -1.92640379e-01f,
  1.33013740e-01f, -3.10970545e-01f, -7.53292488e-03f, -3.77249867e-01f, 4.44751978e-01f, 3.02688688e-01f, 9.45519730e-02f, -1.43004313e-01f, 1.00967161e-01f, -3.20687145e-01f,
  5.02899885e-02f, -2.04392046e-01f, 2.47851446e-01f, -9.21916291e-02f, 2.01833710e-01f, -9.92274433e-02f, -8.92449841e-02f, 8.61253142e-02f, -1.25177160e-01f, 3.82000059e-02f,
  -2.36440822e-01f, -1.15158208e-01f, 1.61783323e-01f, -1.18376158e-01f, 1.03878297e-01f, 4.98207249e-02f, 7.86062703e-02f, 7.49605596e-02f, 1.43959031e-01f, -2.54932523e-01f,
  -2.23461255e-01f, -2.74455231e-02f, 1.23537898e-01f, 5.17421067e-02f, 2.00671658e-01f, 3.37441894e-03f, -3.10337842e-01f, -1.95278764e-01f, 2.23984510e-01f, -6.19234424e-03f,
  3.74889150e-02f, 2.20627129e-01f, -8.29917192e-02f, -7.22031444e-02f, 9.80008580e-03f, -1.51722744e-01f, 2.95385271e-01f, 1.33394813e-02f, 1.77381858e-01f, 7.09248707e-02f,
  1.94919825e-01f, 1.37684062e-01f, 1.13058956e-02f, 5.39012365e-02f, 1.57325447e-01f, 8.81434381e-02f, -1.83959603e-01f, 1.13837317e-01f, 1.50124375e-02f, -1.11914106e-01f,
  -9.28336754e-03f, -7.28823990e-02f, 9.68990922e-02f, -3.65659632e-02f, 1.12193665e-02f, 3.18236314e-02f, 4.10834961e-02f, -2.79218048e-01f, 9.30852741e-02f, -1.05097800e-01f,
  3.09580892e-01f, 5.10446839e-02f, 1.58595145e-01f, -2.07599886e-02f, 1.18834153e-01f, -7.63970017e-02f, -1.09845465e-02f, -1.09630032e-02f, 1.43225968e-01f, 9.57310200e-02f,
  3.58760357e-01f, 1.36368379e-01f, 2.96975132e-02f, -1.08527392e-01f, 1.76566970e-02f, 1.52016297e-01f, 4.85015482e-01f, 3.05091798e-01f, 2.46427462e-01f, -9.88324210e-02f,
  -9.13747922e-02f, -3.32922451e-02f, 2.26728041e-02f, 4.09241542e-02f, 9.86952633e-02f, -2.57632554e-01f, -7.60033354e-02f, -1.33525759e-01f, 2.86682338e-01f, 2.52804663e-02f,
  -5.51695898e-02f, 2.88396124e-02f, 1.72180504e-01f, -3.75635713e-01f, 2.70650119e-01f, -2.84943461e-01f, -4.03703570e-01f, 3.11553866e-01f, -1.30416170e-01f, -2.16132045e-01f,
  4.18008268e-01f, 2.00876538e-02f, 2.62011081e-01f, -1.27552480e-01f, 1.47616372e-01f, 1.93672270e-01f, 2.79194266e-01f, 2.45344415e-01f, 1.37088373e-01f, 4.34924722e-01f,
  5.55456206e-02f, 2.52331614e-01f, -2.20572963e-01f, -2.51178965e-02f, 8.95062312e-02f, 3.64196926e-01f, -2.04041060e-02f, 1.89416613e-02f, -4.39326104e-05f, 6.33839071e-02f,
  2.78819770e-01f, 5.34604527e-02f, 2.04246044e-01f, 3.47583383e-01f, -1.36183009e-01f, -1.16111912e-01f, 4.14694585e-02f, -3.04288149e-01f, -1.79954708e-01f, 1.31178126e-01f,
  -9.82536525e-02f, -7.38964602e-02f, -2.74574757e-01f, -1.63777277e-01f, 2.21321657e-01f, -4.66015115e-02f, 1.44066224e-02f, 6.79083243e-02f, -1.04983881e-01f, -1.42919365e-03f,
  5.61519526e-02f, -8.53910297e-03f, 1.26188844e-01f, -1.35630473e-01f, -1.18333094e-01f, 1.15199894e-01f, -1.15432486e-01f, 1.05289891e-01f, 2.59751260e-01f, -3.15297619e-02f,
  -1.67948753e-01f, -2.94483691e-01f, 1.33634359e-01f, -7.83621073e-02f, 7.87720084e-02f, 1.39608920e-01f, 8.70262533e-02f, -1.75038338e-01f, 3.59285206e-01f, -4.02196823e-03f,
  6.64305454e-03f, -1.08019605e-01f, 8.98798257e-02f, 1.58089161e-01f, 8.37476403e-02f, 4.14923206e-02f, 2.35131949e-01f, -1.66902021e-01f, -2.10785717e-01f, -2.16382965e-02f,
  -3.57053382e-03f, 1.50686681e-01f, 1.13045305e-01f, 3.34158778e-01f, -4.40522544e-02f, 4.98457886e-02f, -1.11647494e-01f, -1.87376998e-02f, 5.48425689e-02f, 3.41562092e-01f,
  2.45208696e-01f, 7.89981708e-03f, -1.47835851e-01f, -6.75573200e-02f, -6.61098361e-02f, -2.98118442e-01f, 3.93224925e-01f, 1.58878475e-01f, -4.54118289e-02f, -3.77050415e-02f,
  -2.04350591e-01f, 3.74058522e-02f, 1.96006268e-01f, 3.29129577e-01f, 1.42619153e-02f, -1.29329666e-01f, -1.43464684e-01f, -1.90289561e-02f, -1.22175418e-01f, 1.67607069e-01f,
  1.53435409e-01f, 9.44106802e-02f, -1.31826729e-01f, 1.65874496e-01f, -4.49543790e-04f, 5.75727858e-02f, 8.31449404e-02f, -5.89947999e-02f, 4.75062877e-02f, 2.49949768e-01f,
  7.74864480e-02f, 4.31799926e-02f, 5.42775914e-02f, 1.60706431e-01f, -2.01218147e-02f, 2.91841120e-01f, -5.79439998e-02f, -3.70301604e-02f, -5.16582951e-02f, 4.53956649e-02f,
  2.52123252e-02f, -9.13563594e-02f, 9.24615338e-02f, 5.99266477e-02f, 2.51541776e-03f, -1.15086347e-01f, 4.35158350e-02f, 1.02015011e-01f, 6.25056699e-02f, 1.96563169e-01f,
  2.76081800e-01f, 2.52516627e-01f, -2.53961459e-02f, 1.45667106e-01f, -8.35601762e-02f, -5.86056188e-02f, -4.65003625e-02f, -3.49942818e-02f, 1.83303416e-01f, 1.52023360e-01f,
  -3.60321969e-01f, -4.07304317e-02f, 8.07933584e-02f, -1.36447802e-01f, 1.81536376e-01f, 2.12841019e-01f, 2.24921897e-01f, -2.71848351e-01f, -3.34805548e-02f, -9.68747027e-03f,
  -4.88567278e-02f, 3.16283017e-01f, 6.31890073e-02f, 5.26296981e-02f, -2.61872709e-01f, 2.80558139e-01f, 1.80020213e-01f, 2.46177763e-01f, 2.43870944e-01f, -9.78269577e-02f,
  -1.08728707e-01f, 2.37780474e-02f, -3.64641137e-02f, -1.77830443e-01f, 2.70763915e-02f, 1.95460636e-02f, -2.29937345e-01f, 1.55099183e-01f, -1.65108338e-01f, 1.23000927e-01f,
  -1.83513582e-01f, -8.42420682e-02f, 1.57625340e-02f, 3.58892083e-02f, 1.70060828e-01f, -2.16044784e-01f, -1.58511415e-01f, 2.96259433e-01f, 1.18681788e-01f, 2.49973252e-01f,
  -1.70804977e-01f, 3.20107900e-02f, 3.59758548e-02f, 1.64996326e-01f, -1.34064287e-01f, 3.14665250e-02f, 4.37466279e-02f, -7.25961328e-02f, -7.98387006e-02f, 1.51340619e-01f,
  8.94155279e-02f, 5.94871603e-02f, 2.07263991e-01f, 3.86164039e-02f, 2.12123454e-01f, 1.70827881e-01f, 1.50549129e-01f, 1.52625963e-01f, 1.06164478e-02f, 1.73682541e-01f,
  -2.20615752e-02f, -2.47255284e-02f, 9.36116576e-02f, -1.07486462e-02f, 2.75775790e-01f, 3.36878031e-01f, -3.31134349e-02f, -1.19594298e-01f, -1.62978768e-02f, 1.03492327e-02f,
  1.19329639e-01f, -1.19957767e-01f, -7.11058453e-02f, 2.43701205e-01f, -1.90409943e-02f, -1.80421054e-01f, -1.50683522e-01f, -9.83400941e-02f, 5.26071340e-02f, 1.41948208e-01f,
  1.20971464e-02f, 4.38176803e-02f, 2.06090212e-02f, 2.15602979e-01f, 1.07418001e-01f, 1.47857994e-01f, 1.71477035e-01f, 7.18115866e-02f, -1.37156516e-01f, 1.46292541e-02f,
  1.04814708e-01f, -1.20332010e-01f, 7.22690001e-02f, -8.07515830e-02f, 1.56838357e-01f, 1.60354167e-01f, -4.72489893e-02f, -2.89494306e-01f, 9.77125913e-02f, -4.89786733e-03f,
  -1.17922910e-01f, 9.60792974e-02f, 4.51404303e-02f, -2.26512365e-02f, 1.64104432e-01f, 1.78816423e-01f, 1.25403926e-01f, 1.40843257e-01f, -1.77679267e-02f, 2.23300382e-02f,
  -2.49839768e-01f, 1.57670900e-01f, 6.43308163e-02f, 5.16418442e-02f, 6.04169630e-02f, -3.66840214e-02f, -1.22789964e-01f, 1.47989132e-02f, 6.95557967e-02f, -2.58709416e-02f,
  -1.07646219e-01f, -1.99593529e-01f, -8.64869878e-02f, -1.54477745e-01f, -3.85188721e-02f, -1.65730253e-01f, 4.06563189e-03f, 3.65683511e-02f, 2.55339723e-02f, 9.69563648e-02f,
  6.84814155e-02f, -8.09400156e-02f, -1.73027903e-01f, -9.26338322e-03f, -1.51793331e-01f, 3.75387147e-02f, 1.06516935e-01f, -4.82007265e-02f, 1.69228110e-02f, -2.72037499e-02f,
  1.44917995e-01f, -5.82914278e-02f, 8.55543464e-02f, 7.54010379e-02f, 6.97524101e-02f, 8.79258886e-02f, 1.36140272e-01f, 9.36597213e-02f, -3.48707259e-01f, -1.76931247e-01f,
  3.54913548e-02f, -6.02840222e-02f, -2.19759680e-02f, -1.84164718e-01f, -2.87906732e-02f, 7.83302635e-02f, 7.05429316e-02f, 1.63424417e-01f, 7.80432373e-02f, -4.15862212e-03f,
  -4.99585131e-03f, -1.96523629e-02f, -3.82592231e-02f, 5.48180304e-02f, 9.89063531e-02f, 1.28465712e-01f, -2.04382360e-01f, -4.24946919e-02f, -1.57726128e-02f, -2.01264977e-01f,
  1.96072206e-01f, -1.75636802e-02f, -7.64047876e-02f, -1.08693093e-01f, 1.23301446e-01f, -1.32118046e-01f, -5.10084629e-02f, 1.68550611e-01f, 3.02511007e-02f, -4.39910181e-02f,
  2.94598728e-01f, 1.21371187e-01f, -6.04256848e-03f, 1.72764167e-01f, -5.01764845e-03f, -1.14334077e-01f, -1.95051551e-01f, 3.61697786e-02f, 1.18907064e-01f, 8.90813768e-03f,
  -8.61894861e-02f, 1.13347463e-01f, -2.07470343e-01f, -1.09675996e-01f, 2.51066327e-01f, 1.00579612e-01f, -2.30730549e-01f, 3.79916310e-01f, 4.47162300e-01f, -1.07391074e-01f,
  -2.56398231e-01f, -4.96994823e-01f, 7.33339563e-02f, -1.27539292e-01f, 5.96736223e-02f, -2.90035486e-01f, -7.56655307e-03f, 1.90682672e-02f, 7.52925575e-02f, -6.52698725e-02f,
  2.49191567e-01f, -1.48981109e-01f, -9.05308798e-02f, 4.92378026e-02f, -1.23949759e-01f, -1.45385876e-01f, 1.94629729e-01f, 2.09954917e-01f, -6.03691302e-02f, 1.54591024e-01f,
  1.27727389e-01f, -2.03060248e-04f, 1.47378713e-01f, 8.96702558e-02f, -3.64827633e-01f, -1.36608347e-01f, 7.94501528e-02f, -8.64063650e-02f, -3.47562611e-01f, 1.06779315e-01f,
  -7.69648850e-02f, 6.87896386e-02f, 1.55601636e-01f, 1.40264019e-01f, -2.39263982e-01f, -3.91267575e-02f, -1.04796542e-02f, -1.69022858e-01f, 1.94618762e-01f, -1.12277649e-01f,
  -1.66646793e-01f, 3.69548798e-02f, -6.01558238e-02f, -1.84139282e-01f, -2.93711901e-01f, 1.54172666e-02f, -1.81934848e-01f, 2.45183095e-01f, 3.49621251e-02f, 1.76463366e-01f,
  -3.22001815e-01f, -1.21123837e-02f, 5.52337505e-02f, -3.25766623e-01f, 2.81434245e-02f, -8.98340531e-03f, -1.91652048e-02f, 1.41215861e-01f, -3.58669524e-04f, -1.75350755e-01f,
  -2.45101437e-01f, 4.94271442e-02f, -1.28100410e-01f, 1.39815912e-01f, 1.85294911e-01f, 4.60533202e-01f, -2.22324699e-01f, -9.69717577e-02f, 1.87837020e-01f, -1.92634538e-02f,
  -1.35359749e-01f, 9.08035226e-03f, -9.05903578e-02f, -4.37186584e-02f, 2.47575179e-01f, 1.21812783e-01f, 2.46932849e-01f, -1.81917250e-01f, 9.10819974e-03f, 6.38088211e-02f,
  -6.74251914e-02f, -1.26873791e-01f, 1.87775761e-01f, -1.28923252e-01f, -2.35595182e-01f, 7.33520985e-02f, -2.30415296e-02f, 3.92073691e-02f, -4.93987883e-03f, 9.88024846e-02f,
  -3.38911265e-02f, 1.06433138e-01f, -2.59780794e-01f, -2.16943081e-02f, 6.67637959e-02f, -1.10357858e-01f, 6.23856820e-02f, 6.75667599e-02f, -8.57515633e-03f, -4.28385399e-02f,
  -1.37034133e-02f, 6.65569305e-02f, -1.57011226e-01f, 4.90051433e-02f, 1.10222824e-01f, 1.09300584e-01f, 2.09514916e-01f, 1.45792495e-02f, 1.48451775e-01f, 9.59627051e-03f,
  9.07071382e-02f, 8.34607799e-03f, 2.91558534e-01f, 5.20777702e-01f, 4.23444480e-01f, 3.95942211e-01f, 1.63890317e-01f, 2.14666352e-01f, 1.63934320e-01f, 1.50814623e-01f,
  1.11622080e-01f, 4.30840969e-01f, 5.42478859e-01f, 3.31688225e-01f, 3.14650774e-01f, -6.83357641e-02f, 4.03408967e-02f, -4.14341092e-01f, -2.58391481e-02f, 1.08431160e-01f,
  4.40921277e-01f, 1.59032226e-01f, -1.74136758e-01f, -3.52788091e-01f, 1.85229450e-01f, -2.91459262e-01f, -3.65286469e-02f, 2.67497063e-01f, 6.19320106e-03f, -6.53632507e-02f,
  -1.17839292e-01f, 1.58040553e-01f, -2.32811555e-01f, 1.30679309e-01f, -2.20713988e-01f, 1.06174193e-01f, 2.33599022e-01f, -1.57976866e-01f, -2.22373262e-01f, -1.55436650e-01f,
  -1.11135952e-01f, 2.46329531e-01f, -2.76745707e-01f, -2.31009379e-01f, -1.43112168e-01f, 1.03773668e-01f, 5.70294969e-02f, 2.05802128e-01f, 8.19519907e-02f, 7.00787455e-02f,
  1.79387946e-02f, -8.28483328e-02f, 1.48393929e-01f, 1.89589426e-01f, 7.67544731e-02f, -1.02726277e-02f, 1.95385411e-01f, 3.18940669e-01f, -1.31531507e-01f, -2.29037508e-01f,
  3.73572111e-02f, 8.70997310e-02f, -7.72338584e-02f, 1.45511031e-01f, 5.65103665e-02f, -4.39745374e-04f, 2.01005593e-01f, 1.24972329e-01f, 1.51261864e-02f, 2.49747038e-01f,
  5.41173778e-02f, 1.41507220e-02f, 1.91069037e-01f, 1.19470477e-01f, 3.88186842e-01f, 3.64558131e-01f, 1.90657616e-01f, 8.27195644e-02f, -2.01552778e-01f, 1.21547110e-01f,
  2.41105873e-02f, -2.11456671e-01f, -1.34851202e-01f, -4.78744693e-02f, -3.32898945e-01f, 1.27568990e-02f, 1.33995796e-02f, -3.15473080e-02f, 1.69603899e-02f, 6.17001206e-02f,
  1.04965582e-01f, 1.30134180e-01f, 1.42026529e-01f, 4.80148615e-03f, 2.50222837e-03f, -6.83740601e-02f, -5.02641164e-02f, 8.64741579e-03f, 6.70929551e-02f, -6.82953000e-02f,
  -1.88197102e-02f, 1.06157973e-01f, -1.28337905e-01f, 2.44426697e-01f, -2.00105924e-02f, 5.64167619e-01f, -9.91643965e-02f, -2.54591256e-01f, -1.74918368e-01f, 1.73819348e-01f,
  -1.34050459e-01f, 2.32362542e-02f, 1.09351315e-01f, -9.76007506e-02f, -1.43574089e-01f, -2.92296827e-01f, 1.93735570e-01f, 1.33523151e-01f, -2.19156653e-01f, 9.44994465e-02f,
  1.16864100e-01f, -1.08324230e-01f, -5.90246134e-02f, 1.62133619e-01f, -5.15696406e-02f, -3.72453369e-02f, -1.95462987e-01f, -2.97200046e-02f, -1.56503126e-01f, 4.94284928e-02f,
  3.68183762e-01f, -1.35331988e-01f, 8.15804228e-02f, 1.17036097e-01f, -1.83020364e-02f, -5.86891845e-02f, 3.59068036e-01f, 2.03108028e-01f, -1.36818498e-01f, 8.84482861e-02f,
  -6.36353120e-02f, 8.07773545e-02f, 1.72380313e-01f, -1.66978955e-01f, -1.56590119e-01f, 1.81610659e-01f, 2.70700026e-02f, -3.40370536e-02f, 1.04109637e-01f, 1.61180794e-01f,
  3.19638282e-01f, -3.16408388e-02f, -3.15381438e-01f, 2.08910376e-01f, 2.27974951e-01f, -1.93536341e-01f, -3.55549380e-02f, -6.86430782e-02f, 1.81156248e-01f, 3.67497839e-02f,
  -8.27346966e-02f, 1.68131933e-01f, -3.48790884e-02f, -1.13006279e-01f, -1.01591900e-01f, 8.08896050e-02f, -3.66220474e-01f, 9.52084139e-02f, -1.86762303e-01f, 1.52232692e-01f,
  1.37363598e-01f, -8.08427855e-02f, -8.49743858e-02f, -7.27509111e-02f, 4.59153242e-02f, -1.61196560e-01f, 8.16237330e-02f, 6.90305308e-02f, -4.30800438e-01f, -6.65710270e-02f,
  -1.75797999e-01f, -1.81340635e-01f, -1.01885162e-01f, 1.08795308e-01f, -3.18637192e-02f, -2.39716135e-02f, 6.13465756e-02f, 1.17163271e-01f, -2.90166587e-01f, -9.69990063e-03f,
  -2.38972485e-01f, 3.58847827e-02f, 1.65411294e-01f, 1.96787920e-02f, -4.12583686e-02f, 5.06174564e-02f, 8.25487673e-02f, -2.05650763e-03f, 2.98994035e-02f, 2.57965177e-02f,
  1.83059454e-01f, 7.09239393e-02f, 8.13817680e-02f, 1.50601625e-01f, -2.05819950e-01f, -1.11025542e-01f, 1.92195941e-02f, -7.82406330e-02f, -1.35031426e-02f, 1.53371185e-01f,
  2.43572250e-01f, 2.67149478e-01f, -2.02741385e-01f, -1.54675290e-01f, -9.83066633e-02f, 1.86268054e-02f, 1.18473925e-01f, 1.46436349e-01f, -2.39856020e-02f, 1.88289583e-01f,
  -2.99391150e-01f, 1.04543291e-01f, -3.39504808e-01f, 8.61306489e-02f, 1.04513824e-01f, 9.80297849e-02f, 1.20030887e-01f, -1.00837745e-01f, 1.02300145e-01f, 6.76876456e-02f,
  -2.59382837e-02f, 1.06470160e-01f, 1.70968220e-01f, -1.10002264e-01f, 3.00856717e-02f, 1.61655955e-02f, 4.26408835e-02f, 1.98910549e-01f, 3.80352348e-01f, 6.30758777e-02f,
  -3.53234351e-01f, -1.74001917e-01f, -1.25250176e-01f, -6.48328140e-02f, 1.96883410e-01f, 2.97725052e-01f, -2.74320751e-01f, -4.01770929e-03f, 1.85341552e-01f, -4.42763232e-02f,
  1.04931243e-01f, 1.17094867e-01f, -2.32930407e-02f, 1.77484140e-01f, 1.49627626e-01f, -1.20058313e-01f, -1.82637647e-01f, 3.13775510e-01f, 2.79796064e-01f, 9.96510684e-02f,
  -1.44972220e-01f, -5.04594631e-02f, 6.97771013e-02f, -2.05308780e-01f, -6.84722736e-02f, 9.35461372e-02f, 3.37913364e-01f, 2.70786285e-01f, 1.28404453e-01f, -1.20314650e-01f,
  -1.52793974e-01f, -4.03840728e-02f, -8.90757442e-02f, 4.27369401e-02f, 1.01177678e-01f, 6.61798894e-01f, -8.93708020e-02f, 8.52227286e-02f, 1.31671913e-02f, -5.15679270e-02f,
  1.17395677e-01f, 2.63132807e-02f, -3.41456234e-02f, -2.26558670e-01f, 2.72313595e-01f, 8.50968584e-02f, 3.88115704e-01f, -2.50239462e-01f, -1.06138892e-01f, 2.17729226e-01f,
  6.12329841e-02f, -1.79722443e-01f, 3.41848172e-02f, 3.95767316e-02f, 5.31180315e-02f, -3.11195049e-02f, -1.19875334e-01f, 1.34633929e-01f, -1.39946252e-01f, -1.12833185e-02f,
  5.95861636e-02f, 1.25380293e-01f, -1.01273600e-02f, 4.40701880e-02f, 1.89548820e-01f, 9.40125342e-03f, -6.28229752e-02f, -1.34665743e-01f, 2.61219114e-01f, -1.73316523e-01f,
  3.39286119e-01f, 3.43808718e-02f, -1.06166847e-01f, -1.61210686e-01f, 1.00574978e-01f, 1.28222823e-01f, 2.32806623e-01f, -3.34836096e-02f, 3.73258069e-02f, 4.32640724e-02f,
  1.99616328e-01f, 7.92000294e-02f, 1.31538227e-01f, 1.25622734e-01f, 1.81629211e-01f, 1.24155328e-01f, 5.60387745e-02f, 3.01618010e-01f, 1.72531039e-01f, 4.83291335e-02f,
  -2.27794915e-01f, 6.88747242e-02f, -8.22708979e-02f, 2.39266574e-01f, 3.42745364e-01f, 2.00794429e-01f, -1.47149498e-02f, -4.44640927e-02f, 1.90017596e-01f, 2.34533086e-01f,
  -5.92927681e-03f, 1.85977638e-01f, -1.68570906e-01f, -1.44456014e-01f, -1.58691481e-01f, -2.37327009e-01f, -1.08410805e-01f, 2.81713337e-01f, -8.74866471e-02f, -1.63653731e-01f,
  -7.99556375e-02f, -4.92646843e-02f, -9.37610716e-02f, -4.35935780e-02f, 6.79114982e-02f, 2.58874334e-02f, -4.36935872e-02f, -1.54712036e-01f, -2.61364549e-01f, -3.54835391e-01f,
  -2.11940408e-01f, -1.06970742e-01f, -2.93907672e-01f, -2.42504645e-02f, -9.42447037e-02f, 1.27693325e-01f, 2.84022897e-01f, 2.15838961e-02f, -2.26562023e-01f, -5.37762120e-02f,
  3.78421731e-02f, -2.54451901e-01f, 1.00212321e-01f, 9.64874178e-02f, 7.76112378e-02f, -1.72834665e-01f, 1.18955687e-01f, -9.69342813e-02f, -6.06199400e-03f, 6.00364245e-03f,
  3.86566892e-02f, 2.58889914e-01f, 2.60490179e-01f, 3.23955044e-02f, -2.05655560e-01f, 1.81564435e-01f, 6.76414594e-02f, 2.12440610e-01f, 1.35167450e-01f, -2.73182411e-02f,
  1.28316641e-01f, -3.20737422e-01f, -1.20048165e-01f, -6.58473000e-02f, -1.66325167e-01f, -1.49849728e-01f, 2.80767940e-02f, 1.16594099e-01f, 3.10460571e-02f, 1.04777202e-01f,
  2.70093679e-01f, -3.01231652e-01f, 2.69291431e-01f, -1.77610204e-01f, -8.80633108e-03f, 2.18338534e-01f, -2.51856893e-02f, 1.28645450e-01f, 1.32531032e-01f, -1.61670297e-01f,
  2.06140831e-01f, -3.25330138e-01f, 8.81453380e-02f, 7.35183880e-02f, 1.33972228e-01f, 1.06923450e-02f, -1.99870747e-02f, 1.01895608e-01f, 1.87507033e-01f, 5.15041016e-02f,
  -1.47227004e-01f, 7.77568072e-02f, 1.93621606e-01f, 1.51931047e-01f, 2.98177134e-02f, -2.18405798e-02f, -2.55941957e-01f, 1.09002151e-01f, -2.08308175e-01f, -1.06232151e-01f,
  -7.37852082e-02f, -1.17266729e-01f, 8.69807322e-03f, 4.52539064e-02f, -7.58609995e-02f, -3.09741229e-01f, -2.35799700e-01f, -9.71430168e-02f, 1.68846458e-01f, 6.82064220e-02f,
  1.77618563e-01f, -1.25927061e-01f, -2.34068215e-01f, 1.50916368e-01f, 5.50344065e-02f, 1.07395671e-01f, 5.30431978e-03f, 1.20019704e-01f, 6.43046126e-02f, -2.77053695e-02f,
  1.61743954e-01f, 2.23145001e-02f, 3.40650320e-01f, 4.40483272e-01f, 1.45961955e-01f, 2.87181586e-01f, -6.44664466e-02f, 1.53913155e-01f, 1.17962211e-01f, 3.40860873e-01f,
  -5.20618483e-02f, 1.84847295e-01f, 8.46516341e-03f, -2.52262235e-01f, 1.27194837e-01f, -4.99275252e-02f, -3.77314091e-01f, -2.42384002e-01f, 2.76524246e-01f, -9.50575769e-02f,
  2.13851165e-02f, -1.02670565e-01f, 3.03966939e-01f, -1.26620516e-01f, -9.88404304e-02f, 7.30233565e-02f, -1.19393105e-02f, -9.99275818e-02f, -1.64552301e-01f, 3.26481044e-01f,
  -4.65974165e-03f, 6.43567145e-02f, -1.73789576e-01f, 2.35487029e-01f, 1.42330065e-01f, 8.45912695e-02f, 7.25744069e-02f, -1.85088351e-01f, -1.68364763e-03f, 3.69338006e-01f,
  5.41936532e-02f, -2.93181509e-01f, -9.44494382e-02f, -8.78474414e-02f, 1.07659288e-02f, -3.88964340e-02f, 5.92572466e-02f, -7.83789530e-02f, 2.41068184e-01f, 2.06791759e-01f,
  -1.55033141e-01f, 5.24179935e-02f, 6.04828186e-02f, 7.10205510e-02f, 1.85746685e-01f, 5.24840355e-02f, -1.78266898e-01f, -3.95780742e-01f, -2.57337809e-01f, -1.99279729e-02f,
  -9.68566313e-02f, 4.23167311e-02f, 6.73296824e-02f, 1.47658899e-01f, 1.55154690e-01f, 2.09500995e-02f, 2.66976774e-01f, 1.63889676e-02f, 1.56189382e-01f, 2.66769290e-01f,
  -3.96310212e-03f, 7.85734504e-02f, 9.54305232e-02f, -7.38406554e-02f, 4.33894098e-02f, 2.04971090e-01f, -2.33877420e-01f, -9.59406234e-03f, -2.58001924e-01f, 2.94291854e-01f,
  -7.96503574e-03f, 6.29920587e-02f, -9.88834798e-02f, -1.73576713e-01f, -1.04010023e-01f, -1.93790063e-01f, 2.58673996e-01f, -2.39330903e-01f, -2.61548012e-01f, -3.95250283e-02f,
  -3.64580899e-02f, 1.26655236e-01f, -1.64453447e-01f, 2.40991250e-01f, 2.52117664e-01f, 1.08145073e-01f, 5.48959449e-02f, 6.71625882e-02f, 2.17243746e-01f, -2.66269594e-02f,
  2.26881832e-01f, -9.10276026e-02f, 1.93304181e-01f, 1.78752929e-01f, 1.02237821e-01f, -5.30141294e-02f, -3.08311488e-02f, 2.86899626e-01f, 7.19500110e-02f, -9.67825502e-02f,
  -7.26576298e-02f, -3.77046168e-01f, 2.75299728e-01f, 1.90265566e-01f, 1.27454977e-02f, 1.36465624e-01f, 4.55781780e-02f, -1.85620070e-01f, 2.78245565e-02f, 1.22515731e-01f,
  -6.91133216e-02f, 1.17002837e-02f, 1.31439418e-01f, -1.18787408e-01f, -5.69085404e-02f, -2.34660003e-02f, 8.63872096e-02f, 2.16133565e-01f, 1.07971080e-01f, -3.65658454e-03f,
  -1.71201855e-01f, 2.08734050e-02f, 1.06119337e-02f, -9.51273665e-02f, 5.36906384e-02f, 5.17488457e-02f, 3.40639263e-01f, 2.22885698e-01f, 4.29262109e-02f, 2.75914166e-02f,
  -2.58859932e-01f, -3.51831727e-02f, -1.71730742e-01f, -5.14540561e-02f, -3.55313793e-02f, 2.71946430e-01f, -3.55280131e-01f, -2.68568993e-01f, 3.69575582e-02f, -6.89015016e-02f,
  -3.58214192e-02f, 3.83655950e-02f, 1.88723449e-02f, -2.03608468e-01f, 1.85968965e-01f, 2.30557159e-01f, 1.77711874e-01f, 9.88152176e-02f, -6.29283339e-02f, 7.76595110e-03f,
  9.40366834e-02f, -6.84114248e-02f, 2.04547957e-01f, -2.92770788e-02f, 1.44623807e-02f, 6.17056601e-02f, 1.00052916e-01f, -3.12813967e-02f, -1.53088467e-02f, -1.70735702e-01f,
  1.13416247e-01f, 1.03242368e-01f, -2.23140255e-01f, -2.48846710e-02f, 2.03226641e-01f, -8.48673955e-02f, 5.54509647e-02f, 1.07795976e-01f, 6.75056651e-02f, 4.35364805e-02f,
  7.56838396e-02f, -8.04814920e-02f, -1.38684601e-01f, -1.10307045e-01f, -6.31397069e-02f, 1.32886842e-01f, 6.09701760e-02f, -1.93717908e-02f, 9.64649767e-02f, -1.80391043e-01f,
  7.87500739e-02f, -3.05021815e-02f, -8.50789621e-02f, -1.55151114e-01f, -1.19859070e-01f, 3.09566166e-02f, 1.23057820e-01f, 2.32708976e-02f, -2.11100012e-01f, 2.93959267e-02f,
  -1.35980234e-01f, -1.18422024e-01f, -2.61303157e-01f, 4.64293547e-02f, -6.74954569e-03f, 3.99115160e-02f, 3.83213311e-02f, 3.54667902e-01f, 2.98305955e-02f, 2.29474843e-01f,
  7.93331265e-02f, 1.67269796e-01f, 1.12545282e-01f, -1.39436200e-01f, -1.62600607e-01f, -1.05700478e-01f, -4.00189310e-02f, -7.51891956e-02f, 3.67536359e-02f, -1.17332600e-01f,
  1.23232873e-02f, -1.76125482e-01f, 6.31718617e-03f, 1.48759142e-01f, -5.17323948e-02f, 4.88018095e-02f, -2.09262446e-01f, 5.76834306e-02f, 1.58232942e-01f, -2.98709497e-02f,
  -4.11193557e-02f, -2.43490353e-01f, -2.31449977e-01f, 1.98460579e-01f, 1.58813313e-01f, -6.38841046e-03f, -2.00714935e-02f, -5.97951077e-02f, -1.16357997e-01f, -1.51676565e-01f,
  9.61939245e-02f, -1.16385125e-01f, 2.62047619e-01f, -1.55172097e-02f, 4.96961959e-02f, -1.60177976e-01f, -9.16646868e-02f, -2.51451999e-01f, -7.01143444e-02f, 2.24822834e-01f,
  -6.79527149e-02f, 5.09686284e-02f, 1.86350849e-02f, -1.55798718e-01f, 2.61800259e-01f, -7.66849592e-02f, 9.60991234e-02f, 2.02774480e-01f, -1.48036093e-01f, 1.92756638e-01f,
  3.21888834e-01f, 1.67659640e-01f, 1.30477652e-01f, 1.38655543e-01f, 2.76310921e-01f, -2.01246530e-01f, 2.61518627e-01f, 3.69108677e-01f, 3.19974385e-02f, -2.23410413e-01f,
  -3.83307219e-01f, 3.60806167e-01f, -1.11703552e-01f, 4.01576012e-01f, 1.95606306e-01f, -1.52693363e-02f, -1.70977131e-01f, -2.15537414e-01f, -2.41162762e-01f, -2.26958454e-01f,
  -1.07389085e-01f, 2.48301655e-01f, 1.63482308e-01f, -4.38264944e-02f, 2.80320406e-01f, -6.56924397e-02f, -7.58387446e-02f, 2.03121692e-01f, 4.27509099e-02f, -2.41815165e-01f,
  1.16926320e-01f, -3.09648603e-01f, 1.11855641e-02f, -1.27770975e-01f, -1.71623677e-01f, -1.21840127e-01f, -7.62850568e-02f, 1.27131447e-01f, -5.18026128e-02f, 2.21923307e-01f,
  1.38803691e-01f, 3.80802527e-03f, 6.16425797e-02f, -9.90217105e-02f, -2.62207389e-02f, -6.24807701e-02f, 3.79438639e-01f, -1.10707739e-02f, 2.62445867e-01f, -1.87153332e-02f,
  -1.12455850e-02f, -4.54927143e-03f, -1.43064493e-02f, -4.10892144e-02f, 2.49486178e-01f, 6.85805976e-02f, -4.82607819e-02f, -7.40559548e-02f, -2.08418593e-01f, -1.59590304e-01f,
  -2.67575085e-01f, -5.34017459e-02f, -1.30133465e-01f, -4.39763248e-01f, -1.89192995e-01f, -4.21319246e-01f, 2.27477789e-01f, 7.75694102e-02f, 1.44785922e-02f, -1.66429747e-02f,
  -1.03794083e-01f, 2.39054188e-01f, 1.71279773e-01f, 4.93112773e-01f, 4.47132140e-01f, -1.67639386e-02f, 2.00072765e-01f, 1.62226215e-01f, 5.94042540e-02f, -1.79969668e-01f,
  6.08900636e-02f, 8.27316344e-02f, -1.28866628e-01f, 8.82026777e-02f, 3.03922296e-01f, 8.44420195e-02f, 5.37961908e-03f, -1.54731408e-01f, -2.86404282e-01f, 1.59944355e-01f,
  1.06401905e-01f, -2.75588512e-01f, 2.98630089e-01f, 5.38214445e-02f, -1.01886988e-02f, 9.56437662e-02f, -1.27028197e-01f, 2.30008528e-01f, 9.34995338e-02f, -1.93302147e-02f,
  3.93196493e-02f, 8.69614184e-02f, 5.70797641e-03f, -7.48658478e-02f, 2.95317918e-01f, 2.06343219e-01f, -3.48232090e-01f, 7.95321167e-03f, 5.48798330e-02f, 7.02432841e-02f,
  7.16710091e-02f, 6.26906082e-02f, -5.55563450e-01f, -2.11058363e-01f, 1.25128925e-01f, -2.44234085e-01f, -2.64818929e-02f, 1.60639599e-01f, -2.33298063e-01f, 2.76713390e-02f,
  1.92704529e-01f, 6.10927083e-02f, 3.43220502e-01f, 9.65099968e-03f, 9.44674164e-02f, 1.76024307e-02f, -4.46781032e-02f, 1.39233038e-01f, 2.03213930e-01f, -3.24336439e-02f,
  -1.44394696e-01f, 1.09082073e-01f, 4.72220927e-02f, -1.34653822e-01f, -1.43053710e-01f, 8.45799819e-02f, -2.44849436e-02f, -1.25805035e-01f, -1.90527678e-01f, 3.86928856e-01f,
  -2.03032106e-01f, -1.25166729e-01f, -1.65089406e-02f, -1.41684607e-01f, 1.26624614e-01f, 2.79352777e-02f, -4.77211848e-02f, 4.75528762e-02f, 1.85858030e-02f, -1.18906215e-01f,
  1.47405669e-01f, -6.60738200e-02f, -3.56745087e-02f, 4.51371744e-02f, 1.76582024e-01f, 1.44352943e-01f, 7.86099061e-02f, -1.29435882e-01f, 9.58901271e-02f, -3.64322625e-02f,
  3.18687946e-01f, 8.09350610e-03f, 1.78415954e-01f, -2.75211513e-01f, -6.99258745e-02f, -1.25407264e-01f, 1.39510194e-02f, 3.08718532e-01f, 9.00875032e-02f, 1.98545996e-02f,
  -7.22034052e-02f, -7.75640160e-02f, 2.36248240e-01f, -5.94618805e-02f, 1.81345299e-01f, -1.07946850e-01f, 7.70221576e-02f, -3.77312690e-01f, 9.94644314e-02f, -2.78454304e-01f,
  -1.67697579e-01f, 4.19447944e-02f, -8.98896605e-02f, -5.81644997e-02f, 1.15407147e-01f, 9.16200355e-02f, 1.90416612e-02f, -3.81801389e-02f, -4.93018404e-02f, 1.03377730e-01f,
  -6.55554757e-02f, 8.87318701e-02f, 8.09480101e-02f, -4.89443447e-03f, -1.36721842e-02f, -1.06976517e-01f, -2.69509703e-01f, -4.47265685e-01f, -1.67668760e-01f, -9.40708350e-03f,
  -1.36432275e-01f, -3.82810347e-02f, -7.58315623e-02f, 1.08289294e-01f, 2.77575105e-01f, 1.69302821e-02f, -3.35911699e-02f, 1.28759518e-01f, 1.41163096e-01f, 4.17268500e-02f,
  5.00479415e-02f, -2.37116724e-01f, -8.33913218e-03f, -2.39266351e-01f, 3.59430946e-02f, 4.32189777e-02f, -4.94991802e-03f, -2.00999543e-01f, 9.40975025e-02f, 1.60888717e-01f,
  1.85995951e-01f, -4.49226722e-02f, -1.30931422e-01f, 1.17637470e-01f, 4.90084477e-02f, -5.26101664e-02f, 1.27574652e-01f, -3.48597825e-01f, -1.49453580e-01f, 1.82456806e-01f,
  -1.58406630e-01f, -3.99494842e-02f, 1.42454445e-01f, -1.43095344e-01f, -1.18153952e-01f, 4.18591462e-02f, 7.65615562e-03f, -1.90363213e-01f, -1.33021668e-01f, 7.56492987e-02f,
  7.23496899e-02f, -1.93555474e-01f, 1.67936116e-01f, -2.43535802e-01f, -6.42035529e-03f, 1.57607585e-01f, 7.01764002e-02f, 2.87833083e-02f, -4.02249955e-02f, 7.39463419e-02f,
  3.87426376e-01f, 7.62570649e-02f, 1.15680978e-01f, 1.26171112e-01f, 2.89634138e-01f, 1.79110825e-01f, 6.09174185e-02f, 1.45258933e-01f, -2.98649400e-01f, 9.57241058e-02f,
  -1.16415128e-01f, 3.57828796e-01f, -2.04241514e-01f, 1.19438328e-01f, 6.57492131e-03f, -2.48188511e-01f, 2.62739751e-02f, 9.55778882e-02f, -5.35008609e-02f, -7.37146512e-02f,
  -1.35876145e-02f, -8.02149996e-02f, -4.94218588e-01f, -2.47512627e-02f, 2.18536511e-01f, -1.48735782e-02f, -2.49285266e-01f, -5.25285862e-02f, -2.22422630e-01f, 5.60187437e-02f,
  -5.16210310e-02f, 1.56689376e-01f, 2.02858627e-01f, 4.06215806e-03f, -9.75641385e-02f, 1.04867637e-01f, 2.56904811e-01f, 8.02158937e-02f, 1.09692723e-01f, -5.61989620e-02f,
  2.57198542e-01f, 2.22790077e-01f, -4.00576927e-02f, -2.18728080e-01f, 1.03792073e-02f, -6.49121925e-02f, 4.45174053e-02f, -2.13647988e-02f, -8.38018507e-02f, -2.71355748e-01f,
  3.56527805e-01f, -1.39454408e-02f, -2.18527531e-03f, 1.79646872e-02f, -4.91421930e-02f, -2.04254508e-01f, 2.14996248e-01f, -2.57308483e-01f, -2.37599447e-01f, 7.35538686e-03f,
  -4.13856581e-02f, -1.79557309e-01f, -3.00495893e-01f, -1.46412756e-02f, -2.45860755e-01f, 6.89109266e-02f, -1.73400566e-01f, -3.86238366e-01f, -2.60102272e-01f, -5.29309988e-01f,
  -2.78754920e-01f, -5.04314780e-01f, -4.51184176e-02f, -1.23472415e-01f, -6.54860735e-02f, 2.08784297e-01f, -4.59813595e-01f, -3.72276813e-01f, -1.88683122e-01f, 1.08814694e-01f,
  -1.42452735e-02f, 1.93545163e-01f, 2.32336000e-01f, 4.35832649e-01f, -2.33330816e-01f, -2.48000637e-01f, -7.41023719e-02f, -6.16620854e-02f, -1.32684782e-01f, 1.23610064e-01f,
  5.04726768e-02f, -1.58898719e-02f, -6.02986710e-03f, -2.78211497e-02f, 5.30744046e-02f, 4.40848358e-02f, 1.38604417e-01f, -1.99713677e-01f, 2.54099295e-02f, 8.60615522e-02f,
  1.15817748e-01f, -1.12831026e-01f, 3.33752632e-02f, -1.02327943e-01f, 4.78391014e-02f, -1.76087201e-01f, 2.32517347e-01f, -9.72386822e-02f, 9.30859372e-02f, 5.99393696e-02f,
  2.38010567e-02f, -6.98609184e-03f, -6.06999360e-02f, -3.51542495e-02f, 6.14886694e-02f, 2.00570047e-01f, 1.36156872e-01f, -7.43240938e-02f, -4.37348001e-02f, 8.09856281e-02f,
  -8.89932439e-02f, -2.98166759e-02f, 1.52367249e-01f, 1.97034672e-01f, 1.19317025e-01f, 3.70894149e-02f, 1.66821092e-01f, -5.76328784e-02f, -1.74604714e-01f, -3.09034418e-02f,
  6.84288517e-03f, 2.28267200e-02f, 9.21903625e-02f, -1.99561343e-01f, -6.00139052e-03f, -2.57364243e-01f, -2.65318854e-03f, -1.23199113e-01f, -1.85091365e-02f, -1.46895871e-01f,
  2.02855125e-01f, -7.19657019e-02f, 2.17448190e-01f, 2.94482917e-01f, 6.32049143e-02f, -1.00903094e-01f, 4.65955734e-02f, -3.30203116e-01f, 3.07823569e-01f, 1.85604379e-01f,
  2.26552878e-02f, 4.14994620e-02f, 1.50316328e-01f, -3.78269404e-02f, 8.29930156e-02f, -1.59296587e-01f, 1.67946383e-01f, 1.26606748e-01f, 6.16227128e-02f, -9.16579887e-02f,
  1.14726968e-01f, 1.10606842e-01f, 1.95081204e-01f, 1.43283889e-01f, -2.20423818e-01f, 1.66199952e-01f, 1.66952595e-01f, -8.77713263e-02f, 3.67039777e-02f, 1.93117216e-01f,
  9.72010836e-04f, 3.76941115e-02f, 2.76048481e-02f, -2.83270478e-01f, -1.54452443e-01f, 1.40721619e-01f, 5.25341481e-02f, 1.57774135e-01f, 4.40696807e-04f, 5.77753447e-02f,
  -2.05500677e-01f, 1.46678053e-02f, 4.11044434e-02f, 7.87646398e-02f, 6.21804669e-02f, -1.68520123e-01f, -3.55833657e-02f, -7.89768808e-03f, 5.93164153e-02f, -1.19192496e-01f,
  -2.29034767e-01f, 3.54746096e-02f, 2.38734484e-03f, -1.57369480e-01f, -2.77615309e-01f, -6.97858930e-02f, -2.38011107e-01f, -2.21026316e-01f, 1.54519647e-01f, 8.06704909e-02f,
  -1.81659609e-01f, -1.30668029e-01f, 2.49559045e-01f, -4.08848375e-02f, -5.17214127e-02f, -2.96017528e-01f, -1.98859408e-01f, -6.39062747e-02f, -2.89138079e-01f, 6.02913685e-02f,
  -7.69105926e-03f, 2.31818974e-01f, 7.81476721e-02f, -2.56509423e-01f, 6.26673326e-02f, -7.92195946e-02f, -1.79094635e-02f, 2.10587271e-02f, -2.50981659e-01f, -3.05616902e-03f,
  3.32884230e-02f, -9.54134203e-03f, 1.46083176e-01f, -7.26049468e-02f, 8.92972574e-02f, 1.19682766e-01f, -1.04044743e-01f, 2.56015509e-02f, 1.87603742e-01f, -1.43457279e-01f,
  -8.54215994e-02f, 8.92259702e-02f, 8.69962797e-02f, -1.19999819e-01f, 1.43002957e-01f, 2.15463847e-01f, 1.48084700e-01f, 1.26986831e-01f, 9.37397704e-02f, -1.29401967e-01f,
  -8.69275555e-02f, -2.29262367e-01f, 3.70256081e-02f, 1.12144919e-02f, 1.67986199e-01f, 6.54086694e-02f, -2.37902589e-02f, 5.86047545e-02f, -1.35219708e-01f, 2.54239365e-02f,
  1.72962118e-02f, -7.94879124e-02f, 3.00237566e-01f, 7.04770312e-02f, -3.43237966e-02f, 1.32374913e-01f, 1.21987201e-01f, 1.00704230e-01f, 9.41258818e-02f, 2.28377134e-02f,
  -1.21906705e-01f, 1.10133782e-01f, 9.77238193e-02f, 3.64320390e-02f, 1.37933716e-01f, 1.28412336e-01f, 5.71855120e-02f, 1.72836423e-01f, -8.13751575e-03f, -1.39875159e-01f,
  -1.19619034e-01f, 9.69288051e-02f, -4.24145497e-02f, -4.12508547e-02f, -2.02246923e-02f, 3.04254949e-01f, -2.83434689e-01f, -1.80793166e-01f, 7.09409639e-02f, 6.79745823e-02f,
  1.50747076e-01f, 5.99297583e-02f, -1.29159302e-01f, 3.86100747e-02f, 7.35088512e-02f, 1.52904361e-01f, 1.17920741e-01f, 1.84527457e-01f, 1.52029991e-02f, -7.89432451e-02f,
  1.50674969e-01f, 1.31992877e-01f, 1.92318454e-01f, 9.05284882e-02f, 1.35012969e-01f, -1.10524796e-01f, 4.76887114e-02f, 9.91770402e-02f, 9.03090648e-03f, -1.69382527e-01f,
  7.00837672e-02f, 2.03785598e-01f, 1.30023450e-01f, -1.49770126e-01f, 4.04414833e-02f, -1.43587962e-01f, 3.68087813e-02f, 5.99234886e-02f, 2.31046990e-01f, 1.27624571e-01f,
  -1.19607203e-01f, 5.94880693e-02f, -8.64944682e-02f, -8.51740595e-03f, 9.26492438e-02f, -3.53113115e-02f, -1.17488369e-01f, 1.75229684e-02f, 5.54670468e-02f, 2.99933046e-01f,
  9.69237462e-02f, 3.05720270e-01f, 1.20862007e-01f, 2.77821962e-02f, -3.75185348e-02f, 1.22978412e-01f, 1.28036141e-01f, -1.18068099e-01f, 2.10395724e-01f, 1.22715011e-01f,
  -2.13269461e-02f, 2.72734165e-01f, -3.95513289e-02f, -6.36972040e-02f, -3.00266981e-01f, 2.29717806e-01f, 2.29826480e-01f, -3.92110981e-02f, -1.86717257e-01f, -2.50105083e-01f,
  -2.71496326e-01f, -1.22375056e-01f, -1.44504502e-01f, -1.43661082e-01f, 2.22799167e-01f, -3.15447785e-02f, -1.43097535e-01f, 7.41878673e-02f, 1.89586179e-04f, 2.19988152e-02f,
  -1.66083246e-01f, 2.64525771e-01f, 1.85872093e-01f, -1.47486955e-01f, 1.68459073e-01f, 7.08035827e-02f, 2.21867234e-01f, 1.69997901e-01f, 2.23166943e-01f, -7.83784613e-02f,
  1.54425487e-01f, 2.09990546e-01f, 8.67975652e-02f, -1.97296441e-01f, 9.02886987e-02f, 6.30570650e-02f, -2.85503179e-01f, 1.78762734e-01f, 6.51193261e-02f, -1.55205905e-01f,
  1.26244262e-01f, 7.43497983e-02f, -1.25795484e-01f, 6.85731396e-02f, -2.43056327e-01f, -8.01783577e-02f, 1.60304144e-01f, 4.55163326e-03f, -1.68054566e-01f, 9.26442817e-02f,
  -1.20650023e-01f, -9.78933945e-02f, 1.71806574e-01f, -6.21692427e-02f, 2.76165679e-02f, 2.61249812e-03f, -3.04256622e-02f, 1.58995494e-01f, 2.47259382e-02f, 1.49501354e-01f,
  9.47166607e-02f, 1.09831847e-01f, 1.24454454e-01f, 7.70462751e-02f, -1.00666374e-01f, 8.42088386e-02f, -7.63274357e-02f, 3.78976703e-01f, 5.65990992e-02f, 2.96792567e-01f,
  9.64872241e-02f, 1.40488623e-02f, 2.80719828e-02f, 1.27189988e-02f, 1.01247162e-01f, 1.15218848e-01f, -1.87742025e-01f, -1.25286087e-01f, -1.29747748e-01f, -5.67324944e-02f,
  1.22736625e-01f, 2.07275957e-01f, 3.00163738e-02f, 6.18234351e-02f, -2.45908722e-01f, 1.07323520e-01f, 2.13885121e-02f, -8.50346163e-02f, 4.39207107e-02f, 9.11779329e-02f,
  3.98331955e-02f, 1.64510474e-01f, 9.18416306e-03f, -9.85985771e-02f, -2.37593018e-02f, -3.89201418e-02f, -2.85562336e-01f, -9.47697759e-02f, 1.14744842e-01f, 1.96731061e-01f,
  2.66092956e-01f, 1.93994507e-01f, -2.04366341e-01f, 4.69613224e-02f, -8.91151428e-02f, -6.53340966e-02f, 1.86825290e-01f, 1.91682279e-01f, -6.94704950e-02f, -1.53491318e-01f,
  2.49424994e-01f, -8.75388179e-03f, -6.63564801e-02f, -1.15836211e-01f, -2.10126922e-01f, 1.33020714e-01f, -2.08100706e-01f, 1.26884028e-01f, -1.29657328e-01f, 8.19542781e-02f,
  -1.26240045e-01f, -2.31876239e-01f, 2.71006078e-01f, 6.67629391e-02f, -2.38412499e-01f, 1.29665911e-01f, -3.37342739e-01f, -2.31203318e-01f, -3.10288191e-01f, 1.85398869e-02f,
  -3.94703746e-01f, -3.41476351e-02f, -1.26042828e-01f, -2.58676820e-02f, -9.77774486e-02f, -5.56285009e-02f, 3.30050327e-02f, -4.37228709e-01f, 6.49882928e-02f, -6.14317507e-02f,
  1.12907715e-01f, 1.07698284e-01f, 1.12343177e-01f, -1.91007346e-01f, -1.25369117e-01f, -4.40964490e-01f, -4.67364565e-02f, 7.16038048e-02f, 7.69782588e-02f, 1.12603456e-01f,
  -1.80175751e-02f, -7.09426031e-02f, -2.05421209e-01f, 1.44738361e-01f, 4.28587571e-02f, 1.65015440e-02f, 1.33768931e-01f, 7.54010081e-02f, 9.85728949e-02f, 1.02906423e-02f,
  2.29103833e-01f, 1.01887425e-02f, 5.90246655e-02f, -1.72159761e-01f, -5.51062450e-02f, -3.75497818e-01f, 1.50518224e-01f, 1.01809278e-01f, 1.92580864e-01f, 1.95281848e-01f,
  -3.76793817e-02f, -2.19252929e-01f, 1.24306731e-01f, 2.16307089e-01f, -5.10589359e-03f, 3.52613740e-02f, -8.10144991e-02f, 8.08005333e-02f, -1.27295256e-02f, -1.40884265e-01f,
  8.49184915e-02f, 1.81085438e-01f, 1.42815962e-01f, 1.61394238e-01f, 9.47746560e-02f, -8.77184123e-02f, 3.01194768e-02f, 1.53973505e-01f, 1.29160196e-01f, -1.80396542e-01f,
  2.94982754e-02f, 2.20210031e-01f, -7.53120929e-02f, 1.54234797e-01f, -2.51092046e-01f, -3.16512555e-01f, -2.13889316e-01f, 1.83014855e-01f, 4.05912936e-01f, -2.44555116e-01f,
  -2.87617713e-01f, -4.71953787e-02f, -1.07344501e-01f, -1.65794834e-01f, -2.54710466e-01f, -9.25904661e-02f, 2.19887495e-01f, 1.78362548e-01f, 1.00589104e-01f, 1.71741605e-01f,
  1.01881765e-01f, 1.39125377e-01f, -3.26227844e-02f, 2.66615413e-02f, 3.00889090e-02f, -2.55685359e-01f, -6.03430718e-02f, 6.37130812e-03f, -1.35284245e-01f, 1.70114622e-01f,
  1.66179731e-01f, -3.47120792e-01f, 9.84142572e-02f, -7.35488161e-02f, -2.27347359e-01f, -3.02183330e-01f, 1.96616784e-01f, -1.24447167e-01f, -1.16418749e-01f, 6.15577586e-02f,
  -7.26087368e-04f, 1.28147036e-01f, -5.18826358e-02f, 2.66576499e-01f, -4.88556270e-03f, 2.89333910e-01f, -2.99909208e-02f, 4.27417047e-02f, -2.97710039e-02f, 1.42150074e-01f,
  -1.43815756e-01f, -1.71928182e-01f, -1.36246115e-01f, 3.89191508e-02f, -1.25807030e-02f, 8.53859335e-02f, 1.49718761e-01f, 2.47083992e-01f, -1.47308095e-03f, 7.43776262e-02f,
  -3.80917005e-02f, -7.93382674e-02f, 9.98946801e-02f, 2.25352749e-01f, 8.83269310e-02f, 1.34991175e-02f, 2.25771099e-01f, 3.18620116e-01f, 1.28188878e-01f, -2.39792719e-01f,
  2.95768492e-02f, -5.89280389e-02f, -2.11213797e-01f, -9.65401903e-02f, 1.04491629e-01f, 5.29703677e-01f, -2.10228756e-01f, -2.21957564e-01f, 3.30250114e-02f, 8.07761550e-02f,
  -8.45460370e-02f, 2.19198018e-01f, -1.51965767e-02f, 1.09463938e-01f, 1.25080943e-01f, 2.03121692e-01f, 6.14156611e-02f, -1.36368170e-01f, 7.30644539e-02f, 6.18288107e-02f,
  -7.35992789e-02f, -1.49647415e-01f, 1.78532794e-01f, -1.20754935e-01f, -2.10669965e-01f, 8.31113756e-02f, -1.38263449e-01f, -3.63582596e-02f, 1.05681762e-01f, 1.00551203e-01f,
  2.08988652e-01f, 1.92529038e-01f, 1.29408941e-01f, 1.20863363e-01f, -1.94201758e-03f, 2.50017792e-02f, -1.12913623e-02f, 1.55772313e-01f, 3.00231993e-01f, 2.74672031e-01f,
  -2.35265680e-02f, -1.57901384e-02f, -7.89160375e-03f, 2.39965051e-01f, 2.63276815e-01f, 1.21024527e-01f, 7.43751004e-02f, 2.13889405e-01f, 6.16766512e-02f, -5.43430187e-02f,
  -3.15966547e-01f, -2.73556530e-01f, -1.71533421e-01f, -6.71058819e-02f, 2.41583183e-01f, -3.92947346e-02f, -4.46050204e-02f, 1.74190123e-02f, -1.15991138e-01f, -1.24132350e-01f,
  -2.01354641e-02f, -2.56698310e-01f, -2.07912456e-02f, 2.65892625e-01f, 2.22471058e-01f, 9.16280448e-02f, -1.25342146e-01f, 9.36703235e-02f, 1.09979190e-01f, -2.74103940e-01f,
  2.32093021e-01f, 6.49660528e-02f, 2.50045776e-01f, -6.23094141e-02f, -1.06833689e-01f, -1.12051904e-01f, 5.96282072e-02f, 4.91922237e-02f, 1.19098172e-01f, -2.26512596e-01f,
  -1.22389877e-02f, -6.04058467e-02f, -1.51489861e-02f, 7.03414455e-02f, 1.64931029e-01f, 1.45084457e-02f, -1.26324862e-01f, 5.67140989e-02f, -1.80299312e-01f, 3.43650915e-02f,
  -5.73298149e-02f, 2.12248880e-03f, 1.02048002e-01f, 2.83293456e-01f, -1.80432543e-01f, 1.74917802e-02f, 2.13983014e-01f, -5.90790771e-02f, -6.68204948e-02f, 7.56950676e-02f,
  -8.74995217e-02f, -1.59121111e-01f, -1.57976523e-01f, -4.90651000e-03f, -9.07025486e-02f, -1.29056806e-02f, 1.84302069e-02f, -9.38062817e-02f, 1.24192193e-01f, 1.44194126e-01f,
  -4.89100926e-02f, 1.29446149e-01f, 1.46530733e-01f, -1.05564378e-01f, 1.10068083e-01f, 4.13669981e-02f, 2.96972364e-01f, 2.54203171e-01f, 3.51563811e-01f, 1.85556188e-01f,
  6.13263734e-02f, 1.85600996e-01f, 1.81073219e-01f, 1.84746653e-01f, 1.92442045e-01f, 4.84261895e-03f, 3.64206284e-01f, 4.01750684e-01f, 1.29293740e-01f, -2.13702381e-01f,
  -2.43806958e-01f, 2.38934532e-01f, 8.57584085e-03f, 5.00180796e-02f, 4.25789982e-01f, 1.24100417e-01f, 5.64774079e-03f, -2.26651117e-01f, -6.86674565e-02f, -4.24558878e-01f,
  -7.65068904e-02f, 3.87393939e-03f, 1.90566480e-01f, -3.17789391e-02f, 4.66223918e-02f, -1.41991660e-01f, 1.22639567e-01f, 2.63653547e-01f, -1.11943416e-01f, -5.07692136e-02f,
  1.68232564e-02f, -2.07000896e-01f, 4.42748740e-02f, -9.83566344e-02f, 1.60056233e-01f, 3.97781953e-02f, -2.22238917e-02f, 1.22245453e-01f, -7.02094510e-02f, 2.66098142e-01f,
  7.31138214e-02f, -4.51209918e-02f, 3.52958366e-02f, -8.80036727e-02f, 1.91153362e-01f, -1.05809821e-02f, 1.10941328e-01f, -5.28126396e-02f, 2.81914353e-01f, -2.07301334e-01f,
  1.19643673e-01f, -5.45974001e-02f, -1.75303474e-01f, -1.70793980e-01f, -7.08925128e-02f, 6.62743375e-02f, 3.14395964e-01f, 3.96871194e-02f, 4.82404716e-02f, 1.31396234e-01f,
  1.54101819e-01f, -6.33968189e-02f, 2.39234373e-01f, 9.88679454e-02f, 5.66317290e-02f, 2.66525038e-02f, -3.07877809e-01f, 7.02604577e-02f, 2.61858284e-01f, 7.13192001e-02f,
  5.25891259e-02f, -1.87223643e-01f, -1.06986836e-01f, -2.48579189e-01f, -5.18439934e-02f, 7.02034608e-02f, -1.61372840e-01f, -4.64848042e-01f, 1.15037663e-02f, -7.09086657e-02f,
  6.98376149e-02f, 1.49255306e-01f, 1.74821183e-01f, -1.61132097e-01f, -1.01004437e-01f, -2.59537458e-01f, -7.82297403e-02f, -8.47164690e-02f, -5.14725298e-02f, 1.45889148e-01f,
  7.42571726e-02f, 2.42198631e-01f, 7.92140234e-03f, 1.05862670e-01f, -1.70678180e-02f, -6.63240775e-02f, 3.61052781e-01f, -2.30399147e-02f, 2.14346096e-01f, 1.02487549e-01f,
  1.33986115e-01f, -8.42638165e-02f, 1.04305252e-01f, -1.20587714e-01f, -1.18675299e-01f, -2.73551464e-01f, 6.19389825e-02f, -1.21953666e-01f, 3.56909990e-01f, 1.04577623e-01f,
  -2.71976404e-02f, -1.90576553e-01f, 1.68517068e-01f, 5.68865500e-02f, 2.67442763e-02f, 4.45851572e-02f, -1.86876386e-01f, -1.59036934e-01f, -1.55141540e-02f, 2.14983337e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -3.29076536e-02f, 5.09655811e-02f, 1.02429256e-01f, 2.28226051e-01f, 6.03005439e-02f, 1.47457439e-02f, 1.99736729e-01f, 2.09088847e-02f, -6.11867644e-02f, 2.13351659e-02f,
  7.22507462e-02f, -8.28529596e-02f, 1.78586524e-02f, -4.60872762e-02f, 2.48944014e-02f, 2.69978736e-02f, 8.32283869e-02f, 1.02199063e-01f, 5.91632314e-02f, 1.05290562e-01f,
  2.50805225e-02f, 8.32967088e-02f, -7.26648839e-03f, -4.90184985e-02f, 6.89628050e-02f, 1.13487383e-02f, -2.95671504e-02f, 5.42271659e-02f, -5.70717677e-02f, 1.38768241e-01f,
  -6.14206903e-02f, -3.21021490e-02f, -4.65053990e-02f, -4.02113385e-02f, -1.79313958e-01f, -1.67658944e-02f, 1.06854573e-01f, -1.91552844e-02f, 1.51445538e-01f, 1.02066964e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -4.69004139e-02f, -3.41076404e-02f, 1.70271784e-01f, 4.96049896e-02f, 8.73696618e-03f, -2.23925337e-01f, -8.02267194e-02f, -1.35091633e-01f, 2.75295395e-02f, 3.64837274e-02f,
  1.71906799e-01f, -3.77370371e-03f, -7.47694373e-02f, 6.44849762e-02f, -1.21578120e-01f, -4.99424636e-02f, 1.34605601e-01f, 1.63170069e-01f, 1.45511627e-01f, -6.27634153e-02f,
  -2.09905401e-01f, 9.96606722e-02f, 7.22974986e-02f, 2.49621615e-01f, 1.10882238e-01f, -2.10058466e-02f, 8.96079838e-02f, 1.94381565e-01f, 1.12306982e-01f, 3.00988909e-02f,
  2.14730818e-02f, -1.38748884e-01f, -6.74698651e-02f, 1.29489288e-01f, -1.22691423e-01f, -1.61760926e-01f, 1.29387662e-01f, -5.03191575e-02f, 9.18929838e-03f, -1.56597689e-01f,
  7.44596943e-02f, 5.96989840e-02f, -5.78575814e-03f, 7.80104054e-03f, -1.73859701e-01f, -1.50855714e-02f, 1.41033372e-02f, 7.97190368e-02f, -3.41770917e-01f, 1.14430502e-01f,
  4.94487993e-02f, 8.91044587e-02f, 2.88650468e-02f, 6.86065629e-02f, -2.06339598e-01f, -1.47260707e-02f, -9.31001157e-02f, -7.52741285e-03f, -9.88660678e-02f, -2.19991490e-01f,
  -1.49433196e-01f, 1.45348698e-01f, -2.53178701e-02f, 1.51016951e-01f, -2.09176794e-01f, -2.79609002e-02f, 1.50115025e-04f, 1.30973980e-01f, -5.54120466e-02f, 1.95101336e-01f,
  -9.04323347e-03f, 1.45262808e-01f, -9.44840014e-02f, 2.85719752e-01f, 5.12989089e-02f, -2.09714413e-01f, 1.69394180e-01f, 8.95274058e-02f, 3.51624459e-01f, -6.94388822e-02f,
  1.26257792e-01f, -1.05519712e-01f, -2.48680115e-01f, -9.88923237e-02f, -8.88371244e-02f, 6.99849129e-02f, -1.06986001e-01f, -2.70670764e-02f, 3.24791973e-03f, 9.41556543e-02f,
  1.98116124e-01f, 2.97399070e-02f, -3.49384099e-02f, 1.63695604e-01f, -2.42587812e-02f, 4.29570787e-02f, 1.25740180e-02f, 4.55796272e-02f, 1.37807772e-01f, -7.51874670e-02f,
  1.52466362e-02f, 3.34495194e-02f, -5.94297610e-02f, 1.35354042e-01f, -1.30871817e-01f, 7.87260011e-02f, -2.73824800e-02f, 1.55670233e-02f, -1.24030568e-01f, -1.15012228e-01f,
  -1.24036558e-01f, -1.28497416e-02f, 1.66495472e-01f, -3.20746116e-02f, -4.41709720e-02f, -8.18925351e-02f, -8.45745802e-02f, 2.20701769e-02f, -8.58154614e-03f, -1.25785202e-01f,
  -3.21660116e-02f, 1.39753073e-01f, -1.64976165e-01f, -1.02339298e-01f, -8.52947682e-02f, -7.15773329e-02f, 8.35651904e-02f, -4.68794693e-04f, 1.11480176e-01f, -1.74730960e-02f,
  -2.07905974e-02f, 3.07792097e-01f, 6.69491291e-02f, 3.76780666e-02f, 7.37431124e-02f, 1.58927947e-01f, 2.31344193e-01f, 2.44160995e-01f, -2.88984627e-01f, 7.76634887e-02f,
  -1.56580150e-01f, 1.80954784e-01f, -2.07518905e-01f, -3.15605938e-01f, 6.84405491e-02f, 6.20315969e-02f, 1.52356047e-02f, -1.69991732e-01f, 7.20998049e-02f, 7.97571838e-02f,
  1.32556528e-01f, -5.53085096e-03f, 7.57967168e-03f, -1.63271889e-01f, -1.18444405e-01f, 6.35136366e-02f, -2.30365813e-01f, -8.62589777e-02f, 6.40306696e-02f, -6.64258078e-02f,
  -6.76401556e-02f, -1.52759999e-01f, -1.49486503e-02f, -6.78256378e-02f, 8.80092159e-02f, 5.00329118e-03f, 1.26395062e-01f, -3.30122739e-01f, 6.73641860e-02f, 2.07707956e-02f,
  -1.06764091e-02f, -1.08125452e-02f, -1.19911052e-01f, -8.06876943e-02f, 4.95364405e-02f, 1.43785685e-01f, -1.81043372e-01f, -9.79820192e-02f, -9.04280767e-02f, -4.18519288e-01f,
  -6.99415877e-02f, -8.32441896e-02f, -2.19224885e-01f, -1.62737429e-01f, -2.33312368e-01f, 1.04876176e-01f, -2.64449894e-01f, -1.05748139e-02f, -1.81092814e-01f, -1.95333123e-01f,
  6.61938414e-02f, -2.86305636e-01f, -3.44340242e-02f, 2.19590634e-01f, 2.20552191e-01f, 3.14307272e-01f, 9.42099541e-02f, -1.89964231e-02f, 3.21772210e-02f, 5.50989769e-02f,
  -4.67849039e-02f, 2.38865778e-01f, -3.94827612e-02f, -5.47541631e-03f, -2.72245944e-01f, -8.08468275e-03f, -2.17008397e-01f, -4.17092554e-02f, -1.45936519e-01f, 6.82892129e-02f,
  -3.09429411e-02f, 6.12843111e-02f, 1.73823833e-02f, 1.08348116e-01f, 1.40860215e-01f, -1.64568707e-01f, 1.23951852e-01f, -4.16692756e-02f, 2.24118322e-01f, 1.39519021e-01f,
  1.08336188e-01f, -2.23356280e-02f, -2.31552362e-01f, -2.30601817e-01f, 4.19441424e-02f, -1.47957364e-02f, -1.41512498e-01f, -7.61319771e-02f, -3.47751938e-02f, -1.71867892e-01f,
  -9.60141271e-02f, -1.34876400e-01f, 1.20623723e-01f, 7.95339569e-02f, 7.12692961e-02f, 1.39805913e-01f, 3.53325307e-02f, 4.79672551e-02f, 1.97912827e-01f, -5.09004034e-02f,
  -1.06189623e-01f, 8.38284120e-02f, -5.79409115e-02f, -6.89819604e-02f, -2.04790056e-01f, -4.69019301e-02f, -9.55188870e-02f, -8.05364996e-02f, -1.05048448e-01f, 6.35167211e-02f,
  -1.38067365e-01f, -9.12413299e-02f, -2.22537175e-01f, -1.77099600e-01f, 1.86850369e-01f, 1.10403717e-01f, 1.23434454e-01f, 7.20841512e-02f, -9.16710198e-02f, -1.06401488e-01f,
  -1.39972521e-03f, 6.48373961e-02f, -8.55201110e-02f, -5.72299324e-02f, 6.11911826e-02f, -3.61898214e-01f, 6.55335095e-03f, 3.08542717e-02f, 1.05846643e-01f, -3.64498384e-02f,
  -2.29480758e-01f, 3.67689997e-01f, 1.25734374e-01f, 1.00571491e-01f, -2.37116590e-01f, -3.10943965e-02f, -1.69833317e-01f, -5.54629415e-02f, 5.24766624e-01f, -1.32966280e-01f,
  1.33218886e-02f, -1.47276536e-01f, -2.42113899e-02f, 6.07511289e-02f, 1.59516543e-01f, 2.46406347e-01f, -6.98257908e-02f, 1.36458039e-01f, 1.09615728e-04f, 3.82734695e-03f,
  -1.74694553e-01f, 1.19184799e-01f, -1.54711276e-01f, -2.05417559e-01f, 8.18524808e-02f, 5.61595382e-03f, 5.35474829e-02f, 3.31608392e-02f, -9.27409902e-02f, -8.18834379e-02f,
  1.63258642e-01f, -1.39041767e-01f, 2.77417034e-01f, -7.88850412e-02f, 1.50324740e-02f, 8.91680866e-02f, 6.63246959e-02f, 9.49530378e-02f, 7.77538717e-02f, 9.22969431e-02f,
  -9.72274616e-02f, 1.18287876e-01f, 5.07145338e-02f, -7.58387893e-02f, 2.21643731e-01f, 6.65646866e-02f, 1.60139680e-01f, -3.57472710e-02f, 1.18313812e-01f, -3.27416584e-02f,
  1.40583590e-01f, -1.91875890e-01f, -2.62443125e-01f, -8.19568858e-02f, -1.47667393e-01f, 1.27807437e-02f, -1.11462750e-01f, -4.09552129e-03f, -3.60130332e-02f, 1.43155664e-01f,
  -8.23593289e-02f, 7.36085549e-02f, 2.41239667e-01f, 4.45805602e-02f, 3.00843924e-01f, -2.21136287e-01f, 2.40927450e-02f, -1.64753512e-01f, -1.28165662e-01f, 7.19492435e-02f,
  2.93790668e-01f, -1.56759590e-01f, -1.99548099e-02f, -3.76076490e-01f, -1.29136130e-01f, -3.32955793e-02f, -1.26372650e-01f, 1.99915856e-01f, 1.06154839e-02f, 1.31394163e-01f,
  -1.62142336e-01f, -9.16572586e-02f, -6.18457794e-02f, -3.52689764e-03f, -1.31305279e-02f, 8.85335803e-02f, -1.40185177e-01f, -1.17534056e-01f, -1.71697289e-01f, 3.15113962e-02f,
  -1.20301954e-01f, -9.08797011e-02f, -6.37418106e-02f, -3.76369804e-04f, 1.08965516e-01f, 8.71814936e-02f, 2.11166635e-01f, 1.35064706e-01f, -3.21013659e-01f, 4.91057746e-02f,
  5.90834096e-02f, -1.36054516e-01f, -7.87889212e-02f, -2.51784623e-01f, 3.52600985e-03f, 1.41165689e-01f, -5.42095751e-02f, -5.10128774e-02f, 9.88455787e-02f, 1.04961162e-02f,
  -1.09770089e-01f, -9.97883603e-02f, -4.79806960e-02f, 1.29150212e-01f, 1.21488295e-01f, -1.61498860e-01f, 8.36128145e-02f, 3.47037464e-02f, 1.04111001e-01f, -5.88152856e-02f,
  1.25338852e-01f, -2.68797100e-01f, -3.26646715e-01f, 4.07874994e-02f, -7.97859300e-03f, -1.87878206e-01f, 3.76186550e-01f, 8.09125900e-02f, -3.99817526e-02f, 2.69799858e-01f,
  -4.94564101e-02f, -1.18479710e-02f, -5.62778302e-02f, -5.03886007e-02f, -4.28889781e-01f, 1.37881681e-01f, -2.24375218e-01f, 6.36850148e-02f, 8.58582780e-02f, -6.55501261e-02f,
  6.48308396e-02f, 6.06062189e-02f, -2.11031064e-01f, -5.23266532e-02f, 2.21155867e-01f, 1.98613971e-01f, -2.78135184e-02f, -7.81206042e-02f, 6.03300426e-03f, 1.48451224e-01f,
  -1.23092659e-01f, -2.16279943e-02f, 1.04802378e-01f, 5.55080026e-02f, -1.69518381e-01f, -8.12123269e-02f, 1.09312877e-01f, -5.75987063e-02f, -8.19373801e-02f, -7.94935673e-02f,
  -2.15480819e-01f, -7.38141313e-02f, -2.73554008e-02f, -1.35899886e-01f, 1.44866824e-01f, -6.31960258e-02f, 3.09320480e-01f, 1.24811262e-01f, 1.27374545e-01f, -9.67559367e-02f,
  6.50904626e-02f, 9.41313207e-02f, 1.54874444e-01f, -2.63838321e-02f, 4.04025503e-02f, 2.26364285e-01f, -9.43092927e-02f, -5.20903356e-02f, 1.37039721e-01f, 1.37023419e-01f,
  4.91041169e-02f, 9.65954810e-02f, -4.62236628e-02f, -7.13103339e-02f, 1.05381534e-01f, 7.25960881e-02f, -1.82145908e-01f, 1.40364245e-01f, 7.93980993e-03f, 3.00744129e-03f,
  -3.47925961e-01f, 3.86069268e-02f, -1.47100985e-01f, 1.08182080e-01f, -7.07840398e-02f, -3.24142158e-01f, 1.45299584e-01f, 1.12243436e-01f, 1.18544526e-01f, 2.51345813e-01f,
  1.27455786e-01f, -6.51196092e-02f, 1.15293823e-01f, -1.74619466e-01f, 1.66011900e-01f, 2.29085177e-01f, 5.21674044e-02f, -3.55574340e-02f, -2.34134495e-02f, 4.10345383e-02f,
  1.26942798e-01f, -7.62755889e-03f, -1.51741412e-02f, 1.09560698e-01f, -8.89342204e-02f, 7.68100750e-03f, -2.86435932e-02f, -1.41837567e-01f, 2.16969829e-02f, -1.62922964e-01f,
  1.53004542e-01f, 6.79747090e-02f, 2.07890689e-01f, 1.30458727e-01f, -1.44837825e-02f, 1.27294198e-01f, -4.36540209e-02f, 2.75362600e-02f, -8.08629170e-02f, 7.19321519e-02f,
  2.63817817e-01f, 2.68471092e-01f, -2.22465694e-02f, -1.94667671e-02f, 1.16205625e-01f, -1.40752286e-01f, 1.16417781e-01f, 1.07622661e-01f, 6.33096173e-02f, -3.46354302e-03f,
  6.86257258e-02f, 2.06461668e-01f, 8.55500847e-02f, -1.63687319e-01f, 8.15421343e-02f, 8.53987224e-03f, -2.60047726e-02f, -3.70035954e-02f, -2.77041614e-01f, 1.26071721e-02f,
  2.23007068e-01f, -2.75213048e-02f, -1.76115111e-01f, 1.66064277e-01f, -6.08960465e-02f, -7.37298727e-02f, -7.77098611e-02f, -1.43611163e-01f, -2.17221662e-01f, -1.68461859e-01f,
  2.26038292e-01f, -3.11446842e-02f, 3.59098852e-01f, -1.46394476e-01f, 2.93601751e-01f, -3.98126602e-01f, -2.15832759e-02f, -1.62804678e-01f, 1.68068066e-01f, 4.08503115e-02f,
  2.50023752e-01f, -1.92156360e-02f, -2.08196506e-01f, -2.18572933e-02f, 1.51454821e-01f, -9.13897008e-02f, 9.77009386e-02f, 3.37744877e-02f, 6.03388585e-02f, 1.04410447e-01f,
  8.37517753e-02f, -2.26443093e-02f, 1.45706832e-01f, 8.14639777e-03f, 3.66685241e-02f, 7.69552588e-02f, 2.52355784e-01f, 7.54190534e-02f, 2.46061683e-01f, 5.82610704e-02f,
  -1.67692408e-01f, 2.29056910e-01f, 1.81161202e-02f, 1.04666740e-01f, -1.85090646e-01f, 6.52866736e-02f, -1.09073445e-01f, -1.21704713e-02f, 1.18356749e-01f, 1.00748971e-01f,
  -3.93006802e-02f, 4.79469486e-02f, -9.46137458e-02f, -9.69812721e-02f, 1.37054518e-01f, 1.83097929e-01f, -1.03286952e-02f, 2.25173771e-01f, -1.64220929e-02f, -1.59757081e-02f,
  -9.34119895e-02f, -1.69341549e-01f, -1.41083688e-01f, 1.26350775e-01f, 1.41705200e-01f, -1.24566108e-01f, -1.01249449e-01f, -6.75990954e-02f, -7.93155506e-02f, 2.03522760e-03f,
  -2.20620617e-01f, 8.45823064e-02f, -2.14698873e-02f, -2.66320314e-02f, 6.56195879e-02f, 3.27560380e-02f, -1.12572186e-01f, 9.21143517e-02f, 3.78284268e-02f, 2.97138751e-01f,
  1.80132717e-01f, -2.75549088e-02f, -6.17584698e-02f, -1.45361632e-01f, 7.88820982e-02f, 8.79733115e-02f, 3.96724939e-02f, -9.30015743e-03f, -1.08133644e-01f, -4.58835438e-03f,
  -1.57284766e-01f, -4.44821194e-02f, -7.00714961e-02f, -2.97073033e-02f, 1.54972017e-01f, -8.36029723e-02f, 9.93188322e-02f, 1.08836278e-01f, 1.16589256e-01f, -5.11824451e-02f,
  -2.60574147e-02f, -5.33859208e-02f, -8.28285068e-02f, -8.95902812e-02f, 1.55584916e-01f, -7.49131441e-02f, 1.01072349e-01f, 2.89570875e-02f, -1.26512930e-01f, 1.03224732e-01f,
  -1.36086822e-01f, -9.78717133e-02f, -8.94353688e-02f, 7.49034062e-02f, 2.48360983e-03f, 1.62735321e-02f, -9.67721641e-02f, 1.41679198e-01f, -5.70924729e-02f, 7.67141059e-02f,
  -1.70391515e-01f, -3.71511132e-02f, -2.18910828e-01f, -1.17804587e-01f, 5.12311086e-02f, 1.35704920e-01f, -1.63563102e-01f, 1.21314019e-01f, -7.73622170e-02f, -1.32573936e-02f,
  -1.42984569e-01f, -1.35360911e-01f, -9.72134322e-02f, -2.08200842e-01f, -8.71386304e-02f, -6.17501400e-02f, -4.99509722e-01f, -7.32517913e-02f, 2.76456237e-01f, 2.13990793e-01f,
  4.00501750e-02f, -1.28141612e-01f, 1.22063801e-01f, -1.28919631e-01f, 5.20716645e-02f, 1.02511741e-01f, -6.52289391e-02f, 1.59188494e-01f, -4.79982197e-02f, 5.17420620e-02f,
  5.45224808e-02f, 7.10480660e-02f, -4.36670966e-02f, 8.04935768e-02f, -1.37879550e-01f, -1.04334010e-02f, 7.76463002e-02f, 2.78938729e-02f, 1.69046283e-01f, -5.58660626e-02f,
  1.62068475e-02f, -2.03879073e-01f, 2.34704390e-02f, 9.59921107e-02f, 2.75525898e-02f, -6.30658194e-02f, -1.16807155e-01f, -1.65812448e-02f, 5.94710968e-02f, -2.82941721e-02f,
  1.45610213e-01f, 4.55368571e-02f, -4.91488725e-02f, 1.83329329e-01f, -5.39977103e-02f, -9.87690687e-02f, -1.25104830e-01f, -1.14646405e-01f, 8.60287622e-02f, -4.18991596e-02f,
  -1.47084013e-01f, 1.71160072e-01f, 7.19673038e-02f, -6.15364648e-02f, 3.71014029e-02f, 6.20606914e-02f, -2.52775569e-02f, 4.16428596e-02f, -1.02265410e-01f, 1.58456758e-01f,
  4.60804813e-02f, 1.32294872e-03f, -3.76367830e-02f, 7.89870620e-02f, -3.54777068e-01f, -1.39925063e-01f, 1.60574820e-02f, 1.94604203e-01f, 1.59028709e-01f, -1.31788507e-01f,
  1.70824479e-03f, 8.70254263e-03f, -2.17704415e-01f, -3.00257057e-02f, -3.49362232e-02f, -6.58535585e-02f, -2.21882954e-01f, 1.44411668e-01f, 1.12910688e-01f, 1.72850043e-01f,
  -1.23563632e-01f, 2.70431135e-02f, -7.38601610e-02f, -2.99323708e-01f, 5.56266755e-02f, 1.24690607e-01f, -6.99207708e-02f, 1.64821688e-02f, -8.07243660e-02f, 9.49153677e-02f,
  8.35983604e-02f, -2.11352743e-02f, 1.61206886e-01f, 4.06219028e-02f, 1.79691121e-01f, -1.77726865e-01f, 1.60835743e-01f, 7.55534172e-02f, -2.71607004e-02f, 2.71156617e-03f,
  -6.13080934e-02f, 7.43048862e-02f, 9.00694877e-02f, -1.21380098e-01f, -5.45435175e-02f, -2.64282245e-02f, -6.13253936e-02f, -1.37342112e-02f, 8.95862058e-02f, -1.48338407e-01f,
  -1.17201954e-01f, 8.03613737e-02f, -3.85684855e-02f, 6.48735315e-02f, 1.03340305e-01f, 9.59707648e-02f, -1.27735898e-01f, -9.29912552e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.60862401e-01f, -1.22387685e-01f, -1.65297166e-01f, -2.07677796e-01f, -3.96330655e-02f, 1.49237350e-01f, -3.16791773e-01f, -2.46097460e-01f, -1.35990173e-01f, -2.60908425e-01f,
  2.31704965e-01f, -1.37123153e-01f, 1.82456017e-01f, -1.39385313e-01f, -1.20808281e-01f, -8.86596274e-03f, -1.93934530e-01f, -1.31586239e-01f, 1.67156354e-01f, -2.11727601e-02f,
  -4.45117503e-02f, 4.94642220e-02f, 3.41237336e-01f, -2.08189607e-01f, -1.46578521e-01f, -6.42159656e-02f, 2.30079126e-02f, 1.08346678e-01f, 1.14300353e-02f, -5.26647903e-02f,
  1.30462525e-02f, 5.94940372e-02f, 3.81276086e-02f, 1.05736470e-02f, -5.63108772e-02f, 4.74096462e-02f, -9.15987417e-02f, -9.94338915e-02f, -1.77254919e-02f, -1.68431878e-01f,
  6.14555329e-02f, -2.49574065e-01f, -1.46418199e-01f, 5.50678596e-02f, 1.82134598e-01f, 1.36705115e-01f, 8.34958106e-02f, -1.63008031e-02f, -5.77862322e-01f, 4.49820608e-02f,
  2.16843523e-02f, 1.47217333e-01f, 6.88526630e-02f, -4.45546918e-02f, 3.04782875e-02f, 1.06488736e-02f, 7.17973188e-02f, -1.45554736e-01f, 3.25203478e-01f, -9.20386910e-02f,
  3.86357680e-02f, 2.12323740e-02f, -6.72349930e-02f, 1.30353630e-01f, 5.49974553e-02f, 3.29126120e-02f, 1.46684632e-01f, -1.41814975e-02f, -2.30011553e-01f, -3.38220783e-02f,
  -7.98520222e-02f, 4.14724648e-02f, 1.18704915e-01f, 1.93952709e-01f, -3.02860551e-02f, 6.20396659e-02f, -2.06841424e-01f, 3.93137246e-01f, -4.73143980e-02f, 2.12287366e-01f,
  1.08779959e-01f, -1.61224212e-02f, -3.34442228e-01f, -8.72205049e-02f, 5.59846126e-02f, 3.09417367e-01f, -4.60099906e-01f, 1.44260347e-01f, -2.99782120e-02f, 7.07541108e-02f,
  -2.31551975e-02f, -4.43362594e-01f, -6.51253387e-02f, 3.42301512e-03f, 1.12627242e-02f, 2.21013248e-01f, 7.24879503e-02f, 1.87867880e-01f, 2.19920650e-01f, 1.44569114e-01f,
  -2.74748832e-01f, 2.00452834e-01f, 8.52423981e-02f, 2.14175090e-01f, -7.41852149e-02f, 1.05428033e-01f, 8.66668522e-02f, -6.62860274e-02f, -1.02919042e-01f, 1.17852591e-01f,
  2.31635585e-01f, 3.12575288e-02f, 4.41532284e-01f, 7.90760666e-02f, -9.15575325e-02f, -1.09654814e-02f, 1.98297217e-01f, 2.57128906e-02f, -1.66795906e-02f, 2.31126919e-01f,
  2.21959010e-01f, 1.87554836e-01f, -8.98068547e-02f, 3.26712698e-01f, 1.22676389e-02f, -2.47215852e-01f, -3.56874436e-01f, -2.94874042e-01f, -2.35099003e-01f, -6.09958284e-02f,
  1.69598326e-01f, 2.28804782e-01f, 2.04143509e-01f, -3.79384793e-02f, 2.20738411e-01f, 1.51047632e-01f, 1.48779050e-01f, 1.54009491e-01f, -1.12584010e-01f, -9.29360017e-02f,
  -2.64194787e-01f, -1.82683334e-01f, 6.44183084e-02f, -2.41476908e-01f, 3.21440756e-01f, -1.57880723e-01f, -9.37351286e-02f, 7.25722313e-02f, 1.94274828e-01f, 1.27890348e-01f,
  5.42385042e-01f, -4.92628776e-02f, 2.03327611e-01f, 8.62300172e-02f, -9.14159976e-03f, 2.28921711e-01f, -1.37413070e-01f, -2.66363949e-01f, -5.31933717e-02f, 1.84833463e-02f,
  -1.81623697e-02f, 1.99505970e-01f, 1.25033140e-01f, 2.24321917e-01f, 3.91313046e-01f, 2.05642372e-01f, 2.61206403e-02f, 2.98694111e-02f, 2.30553105e-01f, -1.04852468e-01f,
  2.74466723e-01f, -1.16509333e-01f, -1.03531852e-01f, 1.37718692e-01f, -5.16180284e-02f, 3.61929655e-01f, -1.30147457e-01f, -5.14352769e-02f, -3.14434469e-02f, -2.43259862e-01f,
  -1.61486551e-01f, 8.73688608e-02f, 1.45324394e-01f, 1.20816000e-01f, -9.30649117e-02f, 1.00687191e-01f, -1.75829947e-01f, -2.21789673e-01f, 9.67803076e-02f, 1.20739758e-01f,
  1.52125344e-01f, 5.16998656e-02f, -4.03447039e-02f, 9.13544744e-02f, 1.31276950e-01f, 2.25754753e-01f, 1.89159468e-01f, -1.63540378e-01f, 2.79321462e-01f, -1.22529790e-01f,
  1.58216953e-02f, 1.12960346e-01f, 3.15805882e-01f, -4.48361784e-02f, 2.59833872e-01f, -3.83741073e-02f, -1.04039408e-01f, 1.43380895e-01f, 3.16217422e-01f, 3.13450873e-01f,
  -4.30008382e-01f, 1.32984305e-02f, 2.91540995e-02f, 6.32538199e-01f, 3.46858293e-01f, 1.32482406e-02f, 3.58353071e-02f, -1.59493864e-01f, 2.99489889e-02f, -1.69366479e-01f,
  7.03260601e-02f, 1.74963363e-02f, -1.21676691e-01f, -9.35914274e-03f, 6.75565600e-02f, -1.28498316e-01f, -2.31379569e-01f, 1.48797289e-01f, -1.85138732e-01f, -1.08076818e-02f,
  -1.90242976e-01f, 1.35624751e-01f, 2.48676941e-01f, 3.34724635e-01f, -1.66396365e-01f, -2.07660034e-01f, 1.58127826e-02f, -6.36212677e-02f, 1.92006752e-01f, 3.94407749e-01f,
  7.17058107e-02f, 1.95647299e-01f, 2.03370526e-02f, -9.47370976e-02f, 3.49376678e-01f, -6.05474506e-03f, 3.72008175e-01f, 6.79284185e-02f, 4.39852066e-02f, 2.09549740e-01f,
  -1.14530735e-01f, 6.66297413e-03f, 2.66451478e-01f, -6.61833733e-02f, 1.29428655e-01f, -1.63476393e-02f, 3.50560658e-02f, -9.47245806e-02f, -7.74057070e-03f, 6.43468648e-02f,
  -7.10361153e-02f, -1.43263519e-01f, -7.58703873e-02f, -2.77674850e-03f, -9.32639986e-02f, -4.87400070e-02f, 7.89920092e-02f, 7.95238391e-02f, 1.63731009e-01f, 1.03167584e-02f,
  4.25526686e-02f, 5.33176074e-03f, 4.16089594e-02f, 4.35553491e-02f, 3.66227478e-02f, -4.66557145e-02f, -1.93845760e-02f, -7.32786059e-02f, 2.79912092e-02f, -1.56598445e-02f,
  -1.42491966e-01f, -4.37552668e-03f, -1.49494007e-01f, -3.76224443e-02f, -6.22447534e-03f, -5.09450994e-02f, -1.32787809e-01f, 3.90133611e-03f, -6.09778203e-02f, 1.12631455e-01f,
  9.96163115e-02f, -7.77784288e-02f, -1.15034483e-01f, 9.95215401e-03f, -2.91757789e-02f, -1.02630019e-01f, -1.48261830e-01f, 3.45380940e-02f, -7.58179650e-02f, -3.00549138e-02f,
  8.92634243e-02f, -6.42200485e-02f, -3.60065326e-02f, -7.93067366e-02f, 8.52492228e-02f, -7.39288926e-02f, -1.16080761e-01f, -1.29539162e-01f, -7.08023608e-02f, 2.43352205e-02f,
  -8.02675188e-02f, -1.13855615e-01f, -1.77251901e-02f, -1.05900049e-01f, -6.63306341e-02f, 6.25778809e-02f, -1.22180030e-01f, 7.63300657e-02f, 7.69653469e-02f, 6.75487444e-02f,
  3.16917598e-02f, -3.85647081e-02f, 6.29441068e-02f, -1.76494550e-02f, 1.80505320e-01f, -2.32086629e-01f, -3.15546431e-02f, -5.51746674e-02f, 1.15252055e-01f, -2.34705745e-03f,
  2.07071811e-01f, 3.72762494e-02f, -7.61127993e-02f, -1.57912657e-01f, -7.25348070e-02f, -4.74359132e-02f, -2.16657490e-01f, 1.42549232e-01f, 3.82851958e-01f, -1.14810534e-01f,
  1.34616867e-01f, -2.99710184e-01f, 2.12629482e-01f, -3.47654670e-01f, -8.62914845e-02f, 1.47203133e-01f, 1.85428604e-01f, 1.09153256e-01f, 3.87766540e-01f, 2.05310404e-01f,
  -1.91552579e-01f, -1.91904515e-01f, 1.61045820e-01f, 2.26976890e-02f, -5.31228865e-03f, -8.77558291e-02f, 1.84299216e-01f, 7.85548761e-02f, -1.64413229e-01f, 6.00620508e-02f,
  2.07387260e-04f, 1.79251879e-02f, -7.75618255e-02f, 2.84370184e-01f, 4.96095493e-02f, 1.56583991e-02f, 9.42284316e-02f, 3.69562954e-02f, -1.90999210e-01f, 2.28753701e-01f,
  1.17448516e-01f, 1.09134980e-01f, 1.03653006e-01f, 2.12854110e-02f, 8.86516925e-03f, 8.50089937e-02f, 2.02843085e-01f, -8.97978693e-02f, 2.16341242e-01f, -1.82667524e-01f,
  -1.62524194e-01f, -6.90409318e-02f, 1.77025795e-01f, 1.56907678e-01f, -3.09322891e-03f, -1.32280886e-01f, -2.03380242e-01f, -1.61920980e-01f, 1.64003875e-02f, -2.45863482e-01f,
  2.43719503e-01f, 8.74208286e-02f, 1.54425241e-02f, -9.74860266e-02f, -9.83165279e-02f, -1.25569656e-01f, 4.84885909e-02f, -3.31292033e-01f, 2.73202240e-01f, -3.11845779e-01f,
  -7.18477275e-03f, 8.65494385e-02f, -4.99462634e-02f, 1.67256445e-01f, 2.66135752e-01f, -6.76454544e-01f, 7.09820772e-03f, -3.10386688e-01f, -1.19955406e-01f, 1.95327789e-01f,
  -2.75588613e-02f, -1.34794667e-01f, 2.36344859e-02f, 1.49186835e-01f, -8.39831084e-02f, -1.36063367e-01f, -1.33230016e-01f, 7.14413822e-02f, -6.91769421e-02f, 3.06364056e-02f,
  1.29237607e-01f, 2.29407877e-01f, 2.84601361e-01f, 1.91722512e-01f, -9.94103998e-02f, -1.50915399e-01f, -7.88426921e-02f, 1.62728295e-01f, 3.04184377e-01f, 7.55824745e-02f,
  -1.81425706e-01f, 4.80553098e-02f, 2.06227899e-01f, 2.50312626e-01f, 9.38130915e-02f, 2.23496288e-01f, -4.65891920e-02f, -1.60678312e-01f, -2.05852259e-02f, 1.08689420e-01f,
  5.53336479e-02f, 1.39795199e-01f, -6.54078573e-02f, -2.69679904e-01f, 6.40206486e-02f, 2.02589795e-01f, 1.44633234e-01f, 8.42533559e-02f, -3.89371105e-02f, -8.24376494e-02f,
  1.55416533e-01f, -3.61170694e-02f, -3.76530021e-01f, 1.58839419e-01f, -7.17133731e-02f, -1.22647636e-01f, 1.36916742e-01f, 1.72822028e-02f, -1.60965800e-01f, -1.60134047e-01f,
  4.51056845e-02f, 1.61025688e-01f, 4.35990766e-02f, 3.13331187e-01f, -3.83723378e-02f, -1.33122727e-01f, -5.91316000e-02f, 2.08570108e-01f, 1.64675027e-01f, 4.04509187e-01f,
  -2.10992470e-02f, 5.15921786e-02f, -3.93923298e-02f, -1.41348526e-01f, -4.88210738e-01f, -1.73637003e-01f, -4.03841138e-01f, -2.05054358e-01f, -1.87165543e-01f, 1.71248734e-01f,
  1.17394239e-01f, 8.34990700e-04f, 4.62405682e-02f, 2.73596436e-01f, -2.25477755e-01f, 9.62324142e-02f, 1.43433541e-01f, 1.19146116e-01f, 3.75734180e-01f, -8.91147777e-02f,
  9.84007567e-02f, -2.43050322e-01f, -1.41711459e-01f, 1.62713125e-01f, -1.33734122e-01f, 6.10015951e-02f, 4.85292859e-02f, -2.57733073e-02f, -3.92696969e-02f, -3.09493542e-01f,
  1.29164234e-01f, -8.66815895e-02f, -1.04669640e-02f, 7.46031776e-02f, 1.32264765e-02f, -2.24691629e-01f, 1.75082982e-02f, 2.08687764e-02f, 4.71515097e-02f, -7.63878226e-02f,
  -9.65925306e-02f, -2.80293196e-01f, 3.32643300e-01f, 1.03988752e-01f, 1.53159454e-01f, 1.53610975e-01f, -8.65041763e-02f, -2.20028400e-01f, 9.58855227e-02f, 7.65694827e-02f,
  9.89576802e-04f, 1.88388303e-01f, -1.32776499e-01f, -1.64854422e-01f, -1.06177069e-01f, 4.11995620e-01f, -3.38030666e-01f, 7.86208212e-02f, -1.94853656e-02f, 1.30275518e-01f,
  1.33942395e-01f, -4.15713340e-02f, -1.29963504e-02f, 2.26742774e-01f, -4.66069371e-01f, 5.89737236e-01f, 1.07593276e-01f, 3.47438127e-01f, 1.60459936e-01f, 1.43972099e-01f,
  -4.43174280e-02f, -1.77114412e-01f, -6.58471957e-02f, -1.15928195e-01f, -1.52837262e-01f, 4.24766019e-02f, 1.54324293e-01f, 8.00513104e-02f, 4.14469652e-02f, -2.80583501e-02f,
  -9.44508761e-02f, -2.60636955e-02f, -7.01235458e-02f, 1.47201121e-01f, 1.28498152e-01f, 1.08935842e-02f, -1.18664891e-01f, -4.81147133e-02f, -2.38627687e-01f, -1.72248304e-01f,
  2.96388477e-01f, -5.41994013e-02f, 1.18941642e-01f, -1.99194744e-01f, 1.21681252e-02f, 1.37733176e-01f, -1.15896635e-01f, 3.59158702e-02f, 2.49642283e-02f, 6.32171929e-02f,
  -1.32596791e-01f, 1.65293813e-02f, -7.22756386e-02f, 1.03872687e-01f, -2.19277084e-01f, -2.81300656e-02f, 3.98137383e-02f, -3.51587757e-02f, 7.43868873e-02f, -3.02561801e-02f,
  6.59212172e-02f, 2.61312537e-02f, 2.89204773e-02f, 5.53616695e-02f, -3.69548053e-02f, -5.92297539e-02f, -5.79597875e-02f, -2.32246853e-02f, -5.04540373e-03f, -1.13010757e-01f,
  -9.12310183e-02f, -4.08562385e-02f, 1.18204216e-02f, 9.72201228e-02f, -1.52049605e-02f, -3.13547440e-02f, 1.15987323e-01f, 5.78547120e-02f, 6.32050708e-02f, -7.46325916e-03f,
  -1.74440131e-01f, -7.56108090e-02f, 1.11591496e-01f, -1.12942485e-02f, -1.37699060e-02f, 3.16850469e-02f, -3.91128734e-02f, -2.27878261e-02f, -1.18192717e-01f, 1.52337132e-02f,
  -6.05359674e-02f, -5.39001152e-02f, -4.98056486e-02f, -1.51802436e-01f, -9.35042351e-02f, -1.03998132e-01f, 6.89334199e-02f, 2.10509356e-02f, 8.02497938e-02f, -7.39292502e-02f,
  8.81589055e-02f, 2.74737403e-02f, -1.88155193e-02f, -1.02691770e-01f, 4.94510084e-02f, -8.51847902e-02f, -3.67787853e-02f, 5.64617440e-02f, -8.55980068e-02f, -6.61910623e-02f,
  -4.42442186e-02f, -9.49607939e-02f, 3.42897847e-02f, -1.24806710e-01f, 6.75198622e-03f, 7.78760985e-02f, -4.29982729e-02f, -8.62072036e-02f, -1.30017251e-01f, -8.57786089e-02f,
  2.80794185e-02f, -1.24814222e-02f, -1.09576650e-01f, 4.06016558e-02f, -1.14130050e-01f, -1.23143181e-01f, 9.19406116e-02f, -2.03321315e-02f, -7.10558966e-02f, -6.96063861e-02f,
  -6.71880171e-02f, -1.25415206e-01f, -3.45431492e-02f, -1.01509355e-01f, -8.15623999e-02f, 7.65244588e-02f, 6.59497604e-02f, -7.48622566e-02f, -7.98369274e-02f, 4.07728441e-02f,
  -4.29690816e-02f, -1.10126778e-01f, 7.38006979e-02f, 1.53085738e-01f, -6.70893416e-02f, -9.83797535e-02f, 7.77203366e-02f, -1.58030048e-01f, 7.11455271e-02f, 6.96453527e-02f,
  7.29431659e-02f, -1.38551304e-02f, -7.62031600e-02f, -1.21974386e-01f, -1.28185809e-01f, 1.75968949e-02f, -5.83976647e-03f, 8.03658143e-02f, -9.73179936e-02f, -1.11472048e-03f,
  8.09777454e-02f, -1.22270517e-01f, -9.67359543e-02f, 5.86962625e-02f, -4.22465196e-03f, -3.23489681e-02f, -1.44131705e-02f, -6.41238913e-02f, -4.21465337e-02f, -1.73787624e-02f,
  -9.80459601e-02f, -3.41344401e-02f, 4.24408726e-02f, 7.29417428e-02f, 6.84078084e-03f, -9.52617005e-02f, -8.84958580e-02f, -2.91901920e-02f, -1.31314367e-01f, -1.69726685e-02f,
  -6.22113049e-02f, 4.37391475e-02f, 6.73717111e-02f, 1.18226837e-02f, -1.44770369e-01f, 1.30980581e-01f, -1.17862791e-01f, -2.49342889e-01f, -7.78997391e-02f, 1.14501968e-01f,
  -1.75724790e-01f, 3.64983588e-01f, 1.12287395e-01f, 2.75085449e-01f, -1.21698357e-01f, 2.82363325e-01f, -4.03872609e-01f, 1.51791871e-01f, 3.27867240e-01f, -2.37253770e-01f,
  -3.19178194e-01f, -5.67360163e-01f, 5.18488228e-01f, 2.20068306e-01f, -5.15205786e-02f, -1.89612105e-01f, -3.23082000e-01f, -2.94488668e-01f, -7.04002827e-02f, 2.09647894e-01f,
  2.01383904e-01f, 1.09498583e-01f, 3.69187266e-01f, 2.22964704e-01f, -8.38357210e-03f, 6.41991049e-02f, -4.72254939e-02f, 9.76754948e-02f, 2.12524369e-01f, -1.53808191e-01f,
  -2.06723101e-02f, 1.46892471e-02f, -1.01981377e-02f, -1.24471430e-02f, -2.02815831e-01f, 5.16075194e-02f, 2.46616766e-01f, 5.62498234e-02f, 3.66244577e-02f, 2.37560999e-02f,
  3.33169401e-01f, -1.87480211e-01f, -2.55813412e-02f, 2.41479397e-01f, 2.39914760e-01f, 2.20981508e-01f, -1.73571944e-01f, 6.01805635e-02f, -8.64831731e-02f, 5.60435019e-02f,
  2.60965914e-01f, 1.82210088e-01f, -8.92290473e-02f, 2.54177600e-01f, -2.31812477e-01f, -1.11883571e-02f, -1.53102661e-02f, 1.54734701e-01f, 1.23871766e-01f, 2.17957675e-01f,
  1.03600495e-01f, 1.41728699e-01f, 2.97095090e-01f, -1.05390251e-01f, 7.45780766e-02f, 7.12075084e-02f, -1.08135156e-01f, -8.97476822e-02f, 2.62792706e-01f, -1.54430375e-01f,
  2.47000799e-01f, -4.42906097e-02f, 1.15033478e-01f, 3.61710906e-01f, -1.41773270e-02f, 3.54192346e-01f, -7.61633813e-02f, -3.49831551e-01f, -4.18628454e-01f, 2.66094893e-01f,
  5.65574646e-01f, 7.14968592e-02f, -3.88567373e-02f, -1.04741320e-01f, 2.17609972e-01f, 1.70485377e-01f, 1.43972144e-01f, 3.50557476e-01f, 8.25964659e-02f, -7.17434436e-02f,
  -1.14777520e-01f, 8.61233100e-02f, -2.57711411e-01f, -3.75154652e-02f, 1.67227998e-01f, -2.73325324e-01f, -2.61155456e-01f, 1.41375646e-01f, 1.85467586e-01f, 3.36232096e-01f,
  1.03716485e-01f, -1.06463626e-01f, -1.90339386e-02f, -1.29830673e-01f, -1.09547898e-02f, 2.54304230e-01f, -3.66468549e-01f, -3.42724659e-02f, 1.05913334e-01f, 9.16457698e-02f,
  6.64277598e-02f, -3.67910825e-02f, 2.21626282e-01f, -8.79241154e-02f, -1.84803873e-01f, -4.57379334e-02f, 3.19715619e-01f, -1.64956436e-01f, 1.35953829e-01f, 2.18747035e-01f,
  2.66131312e-01f, 1.53517991e-01f, 2.37290233e-01f, 7.94218704e-02f, 1.88829377e-01f, -1.68343425e-01f, -1.15606762e-01f, 2.36494914e-01f, -9.36886594e-02f, -7.03907162e-02f,
  -2.89411843e-02f, 4.31583412e-02f, 6.27858713e-02f, 1.15932047e-01f, 2.29933366e-01f, 5.27133159e-02f, 1.89315379e-01f, 3.28109443e-01f, 2.75210619e-01f, 3.78653258e-01f,
  -3.22515160e-01f, -2.26027295e-01f, -2.83429891e-01f, 1.20804869e-01f, 2.43391871e-01f, 8.88923556e-02f, 1.24515906e-01f, 1.84171274e-02f, -1.08243085e-01f, -6.91324919e-02f,
  -4.69432354e-01f, 2.85347283e-01f, 2.71153171e-02f, 2.37555310e-01f, 9.63726938e-02f, 3.45015451e-02f, -1.88707396e-01f, 1.02418073e-01f, 1.27776965e-01f, -2.59589612e-01f,
  1.00277431e-01f, 1.95158303e-01f, 1.09413087e-01f, 4.24643993e-01f, 1.77387819e-02f, -1.95244461e-01f, -2.98135400e-01f, -1.93710357e-01f, 8.33998993e-02f, 3.29095036e-01f,
  5.07832505e-02f, -3.24225128e-01f, 8.77209008e-02f, 3.77271846e-02f, 2.59001493e-01f, -1.15675025e-01f, 4.55251895e-02f, -5.55703901e-02f, -2.56743640e-01f, 1.54016227e-01f,
  -1.06545292e-01f, -8.45928937e-02f, 3.02380562e-01f, -1.58670563e-02f, 1.12478629e-01f, -3.83304596e-01f, 4.33176637e-01f, -9.60114449e-02f, 9.57070664e-02f, -7.54093900e-02f,
  -1.40302196e-01f, -6.40792176e-02f, -8.22700858e-02f, -3.23692895e-02f, -5.26560992e-02f, 1.59204714e-02f, -5.08234389e-02f, 1.04427755e-01f, -8.79671946e-02f, 3.47292662e-01f,
  -2.04318032e-01f, -5.69823664e-03f, -2.84749955e-01f, -1.97593406e-01f, 1.62816986e-01f, -8.27942267e-02f, -3.12264621e-01f, -1.13235816e-01f, -2.16900513e-01f, 1.64234802e-01f,
  8.42956603e-02f, 5.68739884e-02f, 1.87194601e-01f, 7.29954392e-02f, 3.58581319e-02f, -1.27395019e-01f, -8.88629556e-02f, 2.01024171e-02f, 1.20350542e-02f, 2.42897924e-02f,
  1.41788527e-01f, -1.63856354e-02f, -8.49979520e-02f, -4.03556228e-02f, -1.58100754e-01f, -3.49880904e-02f, 6.27628490e-02f, -1.64842755e-02f, 1.84437454e-01f, 4.70980331e-02f,
  7.15044737e-02f, 5.79011366e-02f, -3.19277406e-01f, -1.64425671e-01f, 3.35599631e-02f, -1.29238114e-01f, -6.92083612e-02f, 1.90402642e-01f, 1.61084369e-01f, 5.35952002e-02f,
  -6.13380112e-02f, -7.98487514e-02f, 1.80386260e-01f, -7.87676647e-02f, 1.41493395e-01f, -1.36105549e-02f, -1.33746848e-01f, -1.09094545e-01f, -2.82366830e-03f, 7.06760511e-02f,
  -6.69691563e-02f, -9.46485326e-02f, 1.25042826e-01f, -2.84271426e-02f, 1.14750654e-01f, 1.14395721e-02f, -1.53354838e-01f, -5.46932686e-04f, -9.62051004e-03f, 6.63392916e-02f,
  -5.38046435e-02f, -1.32806212e-01f, -1.54416692e-02f, 7.66773894e-02f, -1.30425999e-02f, 5.03601395e-02f, -1.98249929e-02f, 1.23549059e-01f, 1.40289776e-02f, -4.31309752e-02f,
  -1.29802123e-01f, 5.89645915e-02f, -8.58968124e-02f, -5.62225319e-02f, -3.76299471e-02f, 1.72877699e-01f, -3.04169282e-02f, -1.81573316e-01f, -5.36505096e-02f, -1.11254510e-02f,
  -3.96365821e-02f, -1.10528972e-02f, 8.46548751e-03f, 4.28806283e-02f, -5.55424131e-02f, -8.69052038e-02f, -5.31877056e-02f, -4.17724401e-02f, 1.15100004e-01f, 1.24963053e-01f,
  -4.98706959e-02f, 1.71581030e-01f, 7.26196989e-02f, -3.84594798e-02f, -3.90161686e-02f, 5.28033599e-02f, 6.62259683e-02f, -8.15805718e-02f, 5.08449301e-02f, 2.01932237e-01f,
  5.84073104e-02f, -1.05676480e-01f, -1.06026284e-01f, -1.72354534e-01f, -1.02310367e-01f, -1.33595744e-03f, -3.61565016e-02f, 3.22845168e-02f, -1.79503292e-01f, 8.22676159e-03f,
  -1.37224898e-01f, 2.42258999e-02f, 1.29482567e-01f, -1.30101398e-01f, 6.78924769e-02f, 7.22861066e-02f, -8.13161805e-02f, 1.47207022e-01f, -1.54004218e-02f, -2.37904992e-02f,
  -3.47548798e-02f, 1.73726395e-01f, 2.92268574e-01f, 6.72971234e-02f, -1.56159520e-01f, -5.31309806e-02f, -3.27327222e-01f, 1.69235513e-01f, -1.97183923e-03f, -2.22852770e-02f,
  -8.08418095e-02f, -2.05461025e-01f, 2.76877612e-01f, 4.07031067e-02f, -6.26792312e-02f, 5.00762761e-01f, -3.24633330e-01f, 4.59157765e-01f, 6.60536215e-02f, 1.59691006e-01f,
  6.60413760e-04f, 5.03345095e-02f, -1.40935211e-02f, -1.70825481e-01f, 4.60403003e-02f, 2.29501292e-01f, -5.37199304e-02f, 1.29609713e-02f, 1.36875153e-01f, 4.86410521e-02f,
  1.04408719e-01f, 2.30426311e-01f, 3.59147228e-02f, -3.47833559e-02f, 1.20802358e-01f, -1.02781840e-02f, 2.01994956e-01f, 7.50633329e-02f, -2.76521921e-01f, -5.52898683e-02f,
  -8.08214620e-02f, -9.13507715e-02f, 1.33289978e-01f, -1.43539697e-01f, -8.68316814e-02f, -3.25126767e-01f, -5.04995026e-02f, 2.19363376e-01f, -1.37826800e-01f, 8.98691937e-02f,
  1.51821196e-01f, 1.18337050e-01f, -2.76297331e-01f, 9.66968015e-03f, 7.88279697e-02f, -1.00138426e-01f, -2.09093943e-01f, -9.19034779e-02f, 2.10366458e-01f, 2.09679484e-01f,
  1.59008466e-02f, 1.93234295e-01f, 1.38033628e-01f, 1.51460422e-02f, -3.75436656e-02f, 3.36511761e-01f, 2.67960340e-01f, 2.34490409e-01f, 8.56555998e-02f, 1.02697812e-01f,
  -2.46649817e-01f, 3.31767082e-01f, -3.32939655e-01f, 1.81182083e-02f, -1.95449769e-01f, 3.77739668e-02f, 2.66382307e-01f, 1.05234511e-01f, -8.67116526e-02f, 1.42572403e-01f,
  6.81955963e-02f, 4.21756208e-01f, 4.46214378e-02f, 1.75577365e-02f, 7.26595297e-02f, 1.72187194e-01f, -2.53766831e-02f, -1.76003695e-01f, -1.59650430e-01f, 1.08940661e-01f,
  1.37596563e-01f, -7.48596415e-02f, 6.67150617e-02f, 1.31382763e-01f, 1.49078444e-01f, 1.14553109e-01f, 1.40774608e-01f, -1.99806109e-01f, 3.31049800e-01f, -1.34084314e-01f,
  2.52680331e-01f, 1.32592646e-02f, -1.75853178e-01f, 4.48414497e-02f, -1.29407749e-01f, -1.22706890e-01f, -1.62793964e-01f, -2.07861409e-01f, 5.63644432e-02f, 9.65701416e-02f,
  -1.45789891e-01f, 1.78951740e-01f, -1.68798849e-01f, -2.53889207e-02f, 1.02546550e-01f, -1.81106254e-01f, -5.08873016e-02f, 1.09713584e-01f, -5.76351359e-02f, 6.38678297e-03f,
  -7.81123117e-02f, -3.21417451e-02f, 6.16503917e-02f, -1.13805287e-01f, -3.18329521e-02f, -2.02023126e-02f, -1.19774258e-02f, -2.35107601e-01f, -1.00962296e-01f, -8.40171427e-02f,
  -1.45515114e-01f, -1.97579682e-01f, -1.32471204e-01f, -8.53549242e-02f, 2.64165625e-02f, 9.41623971e-02f, -1.05918877e-01f, 3.59145813e-02f, 1.23569528e-02f, 1.36316478e-01f,
  -8.49037096e-02f, -8.19525346e-02f, 1.18035227e-01f, 1.54460698e-01f, 4.71413921e-04f, -4.12496217e-02f, 1.96753293e-01f, -1.47394881e-01f, 8.12943280e-02f, 4.18411642e-02f,
  -7.92598650e-02f, 1.54320851e-01f, -7.77619705e-02f, -4.11994345e-02f, -8.60396400e-02f, 1.45209618e-02f, -1.86174676e-01f, 1.84908956e-01f, 6.64781108e-02f, -1.29883215e-01f,
  -6.89132735e-02f, -1.50485352e-01f, 7.16544613e-02f, 2.16185525e-01f, -1.65232375e-01f, -4.43471372e-02f, -2.47997254e-01f, -5.68779036e-02f, 6.06587946e-01f, 2.28957281e-01f,
  7.48291388e-02f, 1.24714963e-01f, 1.82982236e-01f, -2.02556048e-02f, -1.32310614e-01f, 2.44613457e-02f, 1.77688636e-02f, -2.18666345e-01f, -6.21388778e-02f, 1.15986824e-01f,
  -7.88642019e-02f, -5.15403569e-01f, 8.43643676e-03f, 1.22355923e-01f, 4.20445800e-02f, -5.07118069e-02f, -1.06618763e-03f, 3.84543352e-02f, 1.17803685e-01f, 1.05806649e-01f,
  7.34395022e-03f, 2.72267580e-01f, -1.41677782e-02f, 4.92720425e-01f, -4.90859933e-02f, 5.26023880e-02f, -2.93150336e-01f, -1.12024806e-01f, -8.92085508e-02f, 2.20680848e-01f,
  -9.64571610e-02f, -2.40191340e-01f, -4.33112741e-01f, -2.61306673e-01f, 3.23439687e-01f, 2.14744568e-01f, -1.28059313e-01f, 5.19495048e-02f, -5.34348488e-02f, 1.71309903e-01f,
  1.03224620e-01f, 2.03572735e-01f, 1.88405812e-01f, 2.96907097e-01f, 1.40045807e-01f, 1.78523898e-01f, 9.07289684e-02f, 5.22407517e-02f, -1.69564098e-01f, 2.23813094e-02f,
  2.21484661e-01f, -7.47109652e-02f, 2.67114222e-01f, 3.82202454e-02f, -9.96152610e-02f, -1.11685507e-01f, -2.33326964e-02f, 4.56380546e-02f, 1.31009936e-01f, 3.85704562e-02f,
  2.49560252e-02f, -1.72787346e-02f, -7.81149790e-02f, -4.47182395e-02f, 3.89552116e-03f, -6.49233535e-02f, 2.28965372e-01f, -1.23216599e-01f, -3.15529913e-01f, -1.93983987e-02f,
  -2.74240971e-01f, -1.46374553e-01f, 9.63182077e-02f, 1.94041297e-01f, 5.22278883e-02f, 9.70667079e-02f, -3.45023394e-01f, 3.49934101e-02f, 3.03156488e-02f, 9.47599765e-03f,
  -1.02025695e-01f, 9.65636820e-02f, -2.34409049e-01f, 1.43569380e-01f, 3.20383944e-02f, -9.62859020e-02f, 2.85812795e-01f, 6.15227185e-02f, 9.65401456e-02f, 2.40505561e-01f,
  2.60570762e-03f, -1.71344876e-01f, -3.14263076e-01f, 1.50159791e-01f, 1.56023860e-01f, -7.91193396e-02f, 3.48612159e-01f, 1.30364761e-01f, -1.25942811e-01f, 1.00999318e-01f,
  4.86724824e-01f, 1.42262727e-02f, -4.78403896e-01f, 1.65754221e-02f, -8.05304125e-02f, -1.62631646e-01f, -2.85438031e-01f, -1.63620412e-01f, -2.22384244e-01f, -1.38551712e-01f,
  -1.44683480e-01f, 7.38417823e-03f, 2.37125903e-01f, -1.42731085e-01f, 2.34405369e-01f, 4.74280231e-02f, 2.18142346e-01f, 3.64421993e-01f, 7.54560530e-02f, 2.46012434e-01f,
  1.84855893e-01f, 9.14805084e-02f, -3.11170146e-02f, 1.49926171e-01f, 2.03937754e-01f, 2.43626818e-01f, -2.28150234e-01f, 1.11144245e-01f, 9.83076468e-02f, 5.61909229e-02f,
  -3.79230291e-01f, 3.21491715e-03f, -1.15761552e-02f, -3.00659705e-02f, 3.38267647e-02f, 1.63843602e-01f, 3.09132397e-01f, 1.53728679e-01f, -1.22270368e-01f, 2.45909348e-01f,
  2.65529037e-01f, -2.01487511e-01f, -1.44716529e-02f, -1.26876757e-01f, 1.27626613e-01f, 1.82387963e-01f, 2.55630910e-01f, 3.47754747e-01f, 1.76516604e-02f, -9.00371596e-02f,
  9.59385484e-02f, 1.17281243e-01f, 5.19910268e-02f, 4.13140804e-02f, -5.07412031e-02f, 2.13927224e-01f, 9.16987285e-02f, 8.75058919e-02f, -1.21474802e-01f, 2.27032945e-01f,
  -1.34917825e-01f, -2.40008742e-01f, 6.57129735e-02f, 3.53953183e-01f, 9.93064344e-02f, 3.10194314e-01f, 2.41911218e-01f, -1.23775646e-01f, 2.57800221e-01f, 1.91048563e-01f,
  7.86803812e-02f, 1.01657778e-01f, 1.17521957e-01f, 1.07953198e-01f, -1.94867864e-01f, 3.66144292e-02f, 5.50397523e-02f, -7.34947762e-03f, 7.09695742e-02f, 2.57947356e-01f,
  -3.57916355e-01f, -6.96229562e-02f, -1.24361113e-01f, -1.38069913e-01f, 1.87075540e-01f, -1.29413173e-01f, 2.14052007e-01f, -1.59199342e-01f, 4.84270640e-02f, 1.17839165e-01f,
  1.87511638e-01f, 1.18016303e-01f, -4.72742692e-02f, 1.63000643e-01f, 1.31543607e-01f, -1.02017745e-01f, 2.60740399e-01f, 1.29584447e-01f, 1.22670650e-01f, 9.62379724e-02f,
  -1.02592863e-01f, -6.65874481e-02f, 1.38915420e-01f, -1.53368413e-01f, -6.63899584e-03f, 1.39494222e-02f, -1.36410594e-02f, 4.05977434e-03f, 1.78816825e-01f, -9.36086103e-03f,
  -1.26892760e-01f, 7.56660178e-02f, 5.23318201e-02f, -2.14193448e-01f, 2.27619126e-01f, -5.72097190e-02f, -1.21929862e-01f, -9.17445570e-02f, 1.53642505e-01f, 1.33123562e-01f,
  -1.01063341e-01f, -3.51881757e-02f, -2.25213900e-01f, -8.16273838e-02f, -3.43866833e-02f, -2.72854697e-02f, 2.36286551e-01f, 1.08957246e-01f, 3.95545453e-01f, -2.33688459e-01f,
  -1.56436756e-01f, -7.64652267e-02f, -1.10095158e-01f, 3.27486210e-02f, 9.19606090e-02f, 3.03586945e-02f, 3.11682299e-02f, -1.04296297e-01f, -2.67934829e-01f, -2.43918955e-01f,
  2.01849625e-01f, 2.61487186e-01f, -1.86747193e-01f, 1.27721727e-01f, 5.58879301e-02f, 7.65491873e-02f, -7.79272802e-03f, 4.75302301e-02f, 6.79333210e-02f, -2.53713906e-01f,
  -1.79523632e-01f, 2.06360593e-01f, 3.26296479e-01f, 1.86705872e-01f, -1.33028805e-01f, 8.81041810e-02f, 9.23706964e-02f, 7.25173205e-02f, -1.65400445e-01f, 9.45759267e-02f,
  8.45587924e-02f, -6.44942522e-02f, 1.85835600e-01f, 1.20609716e-01f, 2.50890076e-01f, 1.64221153e-02f, 1.56020939e-01f, 7.76536316e-02f, 1.52107120e-01f, 7.28258910e-03f,
  1.44501328e-01f, 1.17959537e-01f, 1.72988117e-01f, 1.28166974e-01f, 1.58037484e-01f, -1.05002798e-01f, 6.35193959e-02f, -1.65716201e-01f, -1.42526612e-01f, 9.96829122e-02f,
  -5.21898456e-02f, -7.18704052e-03f, 3.29644270e-02f, -1.44024175e-02f, 8.19007456e-02f, -1.06505089e-01f, -1.38143539e-01f, 1.84498373e-02f, -3.87051463e-01f, -2.52673060e-01f,
  2.65789866e-01f, 2.39739493e-01f, 6.20274059e-02f, -7.03777233e-03f, -7.61669427e-02f, -4.01734501e-01f, -5.39744273e-02f, 2.21102402e-01f, 1.21461026e-01f, -9.87512097e-02f,
  4.62479800e-01f, 3.90311092e-01f, -1.77965447e-01f, -8.41018930e-02f, 1.21720873e-01f, -1.02966830e-01f, -1.61850885e-01f, 2.27744263e-02f, -2.07757458e-01f, 1.52491018e-01f,
  2.41402879e-01f, 2.08948806e-01f, -9.51519832e-02f, -6.31076694e-02f, 1.92206234e-01f, 2.68941492e-01f, 2.24432766e-01f, 2.29797810e-01f, -5.98685117e-03f, -5.45161143e-02f,
  4.38114591e-02f, 3.40609580e-01f, 1.35306060e-01f, 6.46337122e-02f, 3.39750759e-02f, -8.42806026e-02f, 1.95744354e-03f, 1.30151719e-01f, 2.62319475e-01f, 2.96156630e-02f,
  1.12714857e-01f, -3.57989632e-02f, 2.35598013e-02f, 7.58997649e-02f, 1.95646197e-01f, 7.36358017e-02f, -5.12344502e-02f, -9.02962163e-02f, -4.32764553e-02f, -6.44830540e-02f,
  -9.77609213e-03f, -4.66496833e-02f, -1.41807795e-01f, -2.38202482e-01f, 1.04290269e-01f, -2.44930476e-01f, -1.82654887e-01f, -2.69858718e-01f, 8.78221840e-02f, -5.49313165e-02f,
  -1.48434028e-01f, 2.33842552e-01f, 7.96184018e-02f, 1.05372645e-01f, 2.15821430e-01f, -1.45169599e-02f, -3.05254072e-01f, -8.91027525e-02f, -2.44706511e-01f, 1.40015692e-01f,
  2.66204387e-01f, 2.54956186e-01f, 4.67411894e-03f, -1.28470346e-01f, -5.46540543e-02f, -1.47891268e-01f, 1.99200228e-01f, 1.83269247e-01f, -1.94252685e-01f, 1.44848093e-01f,
  -2.26990357e-02f, 1.24859117e-01f, -1.50107569e-03f, 1.17284201e-01f, 3.17811489e-01f, 2.43377835e-02f, 2.08058164e-01f, -6.37838691e-02f, 1.69822440e-01f, -1.27986893e-01f,
  -3.07163060e-01f, 1.33814305e-01f, -4.42848623e-01f, -2.36919113e-02f, 2.24670008e-01f, -1.37826130e-01f, 1.30988494e-01f, -1.79234922e-01f, 2.65461043e-03f, -1.24985371e-02f,
  -1.49165874e-03f, 1.14849292e-01f, -1.72198012e-01f, -1.00209117e-01f, 5.06505929e-02f, -2.69318759e-01f, 3.24241221e-02f, 1.01268873e-01f, -1.72367934e-02f, -8.48656744e-02f,
  -6.62967563e-02f, -3.68978113e-01f, -4.16823402e-02f, 2.11264089e-01f, 1.28107324e-01f, -2.19963059e-01f, 1.49717718e-01f, -2.05895938e-02f, -6.03155680e-02f, -1.24078661e-01f,
  -7.75329098e-02f, -2.96749383e-01f, 4.39791471e-01f, -1.91425964e-01f, -1.63736045e-01f, -1.43039122e-01f, 1.06964938e-01f, 1.27118751e-01f, -2.54654288e-01f, -1.50588259e-01f,
  -1.54108167e-01f, 1.38895428e-02f, 6.69834316e-01f, -8.53664950e-02f, 1.03925765e-01f, 2.59599149e-01f, -3.67789939e-02f, 1.14997979e-02f, 2.86608506e-02f, 2.87566543e-01f,
  1.86156675e-01f, -3.89896892e-02f, -1.60125285e-01f, 7.95841515e-02f, 2.39206851e-03f, 7.00913668e-02f, 2.16360778e-01f, -2.88971998e-02f, 2.45212857e-02f, 4.10136255e-03f,
  1.82155356e-01f, 4.76508886e-02f, -2.69659539e-03f, -1.15951203e-01f, 2.72087399e-02f, 5.95598407e-02f, 2.42476642e-01f, 3.75603437e-01f, 1.27587646e-01f, 9.04922374e-03f,
  1.54269084e-01f, -2.62678206e-01f, -4.05759364e-02f, 6.07905947e-02f, 2.26061866e-01f, -1.27641916e-01f, -2.05946863e-01f, 1.54443309e-01f, -1.37528375e-01f, -4.89981681e-01f,
  -1.64083969e-02f, 2.41579905e-01f, 2.50359982e-01f, -1.81768894e-01f, 1.52205765e-01f, 8.29739496e-02f, 1.43959522e-01f, -2.29524784e-02f, -6.10640049e-02f, 2.27943957e-01f,
  1.93492193e-02f, 4.89939898e-02f, -5.41962497e-02f, 1.35721222e-01f, 2.85388380e-01f, 9.27624851e-02f, -2.44110962e-03f, -1.08816266e-01f, 2.50339866e-01f, 1.07647680e-01f,
  3.83963406e-01f, 4.41021651e-01f, -4.23135847e-01f, -2.94690639e-01f, -2.99430341e-01f, -8.54498148e-02f, 1.43170208e-01f, 3.24064583e-01f, 1.19148649e-01f, -6.07276261e-02f,
  -1.57359168e-01f, -1.95150077e-01f, -2.79459506e-01f, 2.70086050e-01f, 2.45487988e-01f, 2.28741616e-01f, 7.34594390e-02f, -1.13130577e-01f, -9.82260332e-02f, -2.08717175e-02f,
  2.05134198e-01f, 1.30334705e-01f, 1.18242763e-01f, 2.71825582e-01f, -6.14415593e-02f, 4.19627041e-01f, -2.67439168e-02f, 2.05047950e-02f, -4.46188897e-02f, 1.42433671e-02f,
  5.72375283e-02f, 1.03466406e-01f, 3.50688472e-02f, -8.35325867e-02f, -1.08524062e-01f, 3.36273313e-02f, -1.80912703e-01f, -7.00520948e-02f, -5.36738113e-02f, 1.00941032e-01f,
  -9.96265113e-02f, 1.11296996e-01f, -1.76662058e-01f, 2.57278644e-02f, 1.96468085e-01f, 9.83878225e-02f, 2.58891582e-02f, -2.49165729e-01f, -3.30379039e-01f, 1.03496969e-01f,
  -3.07111025e-01f, -1.19246528e-01f, -7.12944102e-03f, 4.07362670e-01f, -4.08554494e-01f, 3.64422835e-02f, 1.55925276e-02f, -9.62342843e-02f, -2.28943750e-01f, -4.11153734e-01f,
  1.97302122e-02f, -1.77670956e-01f, 2.59759575e-01f, -9.57555696e-02f, -8.10222104e-02f, 4.67438996e-02f, 1.12683333e-01f, 7.01936409e-02f, -6.78133443e-02f, -9.89754200e-02f,
  2.53394067e-01f, 7.16341659e-02f, 8.68962407e-02f, 3.41564938e-02f, 2.13851631e-01f, 3.27475011e-01f, -1.04234852e-01f, 1.44638538e-01f, 2.12630361e-01f, 7.47003406e-02f,
  8.16984326e-02f, -2.87709963e-02f, 2.23917663e-02f, -1.66870117e-01f, 1.02742746e-01f, 4.88221422e-02f, 3.08548212e-01f, -2.16494977e-01f, -3.51128802e-02f, -1.75325964e-02f,
  2.41614077e-02f, 1.46138579e-01f, -1.41963869e-01f, -1.43876895e-01f, 3.57666388e-02f, -1.48351282e-01f, -4.86659825e-01f, 5.91091849e-02f, 1.05933622e-02f, 1.33677319e-01f,
  -3.40804547e-01f, 6.48674294e-02f, 5.36988070e-03f, -1.12857476e-01f, 1.19639412e-01f, -7.43201524e-02f, 5.29010259e-02f, 1.38811365e-01f, -9.35645849e-02f, 5.36587499e-02f,
  1.52781069e-01f, -4.69182916e-02f, -2.33503655e-01f, 8.63830224e-02f, 9.83586609e-02f, 1.33635104e-01f, 2.98984528e-01f, 6.21285569e-03f, -4.74705212e-02f, -6.88507687e-03f,
  -1.17869481e-01f, 7.72182941e-02f, -9.69476439e-03f, -8.03823769e-02f, -3.02856773e-01f, -4.92322519e-02f, 3.03985868e-02f, 1.23379983e-01f, 7.42199719e-02f, -1.50222376e-01f,
  1.99014127e-01f, 7.91870654e-02f, -2.18930125e-01f, 2.12033093e-01f, 5.66218421e-02f, -7.17051979e-03f, 1.34046435e-01f, 2.72736661e-02f, 1.02198586e-01f, 9.61131454e-02f,
  2.76796043e-01f, 1.35672435e-01f, 1.35553479e-01f, 1.26203746e-02f, -5.94157279e-02f, 1.60545349e-01f, -1.42778056e-02f, -2.06715930e-02f, 6.53677061e-02f, -5.67592420e-02f,
  -2.48731077e-02f, -2.11443141e-01f, -1.30394027e-02f, -5.70669062e-02f, 7.95880109e-02f, -7.49944821e-02f, -1.71858355e-01f, -2.38028131e-02f, 1.51911512e-01f, 9.66668129e-02f,
  -1.73558846e-01f, 8.40336680e-02f, 5.19631468e-02f, -1.33091941e-01f, 5.60357422e-02f, 1.58926472e-02f, -2.72775046e-03f, -1.70681626e-01f, -1.50951758e-01f, -1.24396324e-01f,
  2.88126860e-02f, -2.09867761e-01f, -9.11872759e-02f, 1.84539706e-01f, 4.70650271e-02f, 1.12358004e-01f, 1.55507490e-01f, 1.60471007e-01f, 1.48508875e-02f, 8.63564536e-02f,
  1.30539298e-01f, 2.90708184e-01f, 1.75890028e-01f, 1.31343871e-01f, 1.55791184e-02f, 2.90457994e-01f, 2.95550346e-01f, 3.15532267e-01f, -5.23912191e-01f, 2.78247505e-01f,
  -1.29926980e-01f, 1.33049041e-01f, 3.17459732e-01f, 2.66485661e-01f, -3.03230077e-01f, -3.28195661e-01f, -6.05309643e-02f, 1.06073759e-01f, -1.61848050e-02f, 4.13653731e-01f,
  6.15193658e-02f, -3.20643455e-01f, 5.97908394e-03f, 3.34553197e-02f, -2.29114339e-01f, -7.31979162e-02f, 9.45068672e-02f, 1.94804281e-01f, 2.13112369e-01f, -7.28319632e-03f,
  5.99121349e-03f, -1.31721094e-01f, 4.77446437e-01f, 4.26293090e-02f, -1.10141762e-01f, -8.37202556e-03f, 2.18299404e-02f, 1.55960128e-01f, -1.09485529e-01f, 2.93601602e-01f,
  -1.59200326e-01f, -2.67077312e-02f, 1.96467340e-02f, 8.03172737e-02f, -2.06023734e-02f, -2.59040236e-01f, -7.92592987e-02f, 4.42295745e-02f, -1.62232056e-01f, -9.24947560e-02f,
  -1.69553638e-01f, 1.06171407e-01f, 7.14403540e-02f, 1.73822045e-01f, -1.94012031e-01f, 4.21431929e-01f, 8.64975452e-02f, -2.47035444e-01f, 1.53401539e-01f, 9.24070999e-02f,
  1.28229067e-01f, -1.02791324e-01f, 9.28362086e-02f, -2.33239904e-01f, -3.33585963e-02f, -1.64732113e-02f, 6.13295622e-02f, 3.18645611e-02f, 1.18373260e-01f, 6.73872530e-02f,
  1.56311542e-02f, 2.24727869e-01f, -1.45022199e-02f, -1.95489600e-01f, 3.64187807e-01f, -1.72294618e-03f, -3.41082402e-02f, 9.00156796e-02f, -2.47187470e-03f, -2.68030852e-01f,
  -9.21762958e-02f, -5.32693446e-01f, -5.75048663e-02f, -2.47128710e-01f, -2.10873127e-01f, 3.50656390e-01f, -2.67308652e-02f, -1.55051023e-01f, 1.58052325e-01f, 3.85874808e-01f,
  1.45230666e-01f, -5.24042435e-02f, 7.77093619e-02f, 9.06061474e-03f, -2.03691348e-01f, -2.16553375e-01f, 3.03614259e-01f, 2.68371940e-01f, 2.55443037e-01f, 7.69696906e-02f,
  -2.53821731e-01f, 2.79557675e-01f, -1.01791568e-01f, 1.15262233e-01f, 7.77185708e-02f, -9.52005982e-02f, 1.04453944e-01f, -8.84001479e-02f, 1.17320955e-01f, 6.32595420e-02f,
  -2.77090613e-02f, 2.25195050e-01f, -5.32050207e-02f, -7.46490136e-02f, -2.06654929e-02f, 5.38696460e-02f, 1.70567632e-01f, 2.52982467e-01f, 2.65645050e-02f, 4.45486270e-02f,
  1.64396495e-01f, -1.59885526e-01f, -2.91282125e-03f, 9.82373208e-02f, 1.05826646e-01f, 4.34710570e-02f, 1.39063075e-01f, 8.76151100e-02f, -6.40003942e-03f, 1.49023561e-02f,
  -2.19772443e-01f, 1.05649285e-01f, 2.13832021e-01f, 2.96669066e-01f, -9.11433473e-02f, 2.61361271e-01f, -2.58914620e-01f, 3.23883928e-02f, 7.80215636e-02f, -1.61981359e-01f,
  -2.07272932e-01f, -2.00316176e-01f, 8.72262344e-02f, 1.83886960e-01f, 7.14838132e-02f, -1.68331265e-02f, -4.28940922e-01f, 2.17412293e-01f, 9.41168517e-02f, 3.53399783e-01f,
  1.87203437e-01f, 1.05372623e-01f, 1.07965685e-01f, 7.81088248e-02f, 2.31609106e-01f, 1.44329801e-01f, 7.29934722e-02f, 1.29969537e-01f, 2.27032796e-01f, -8.23485181e-02f,
  -9.71845258e-03f, -1.85441691e-02f, -8.33808780e-02f, -8.90505239e-02f, -1.04944579e-01f, 1.65506289e-03f, 1.78485662e-01f, 1.05115488e-01f, -2.00838238e-01f, -5.98322898e-02f,
  4.19566184e-02f, -1.20453812e-01f, 4.28805888e-01f, 8.30210745e-02f, 1.53170019e-01f, -1.71244949e-01f, -2.92798690e-02f, 1.20915957e-01f, -1.61582410e-01f, 4.07503061e-02f,
  6.85915872e-02f, 2.50817239e-01f, -9.71147791e-02f, 2.09565192e-01f, -1.27467304e-01f, -3.01270392e-02f, -1.75354123e-01f, -4.24285978e-02f, -1.26221508e-01f, 1.58976108e-01f,
  -1.40768573e-01f, 2.33072653e-01f, -2.27761269e-02f, 1.88545868e-01f, 2.41562277e-02f, 1.28549427e-01f, 2.91800022e-01f, 1.63226556e-02f, -1.22229919e-01f, 4.06888276e-02f,
  -3.19079638e-01f, 2.01704264e-01f, -1.16600230e-01f, -6.94586039e-02f, -3.71445894e-01f, -4.61714834e-01f, 3.56599748e-01f, 4.01928633e-01f, 1.55051008e-01f, 5.27202964e-01f,
  3.93314436e-02f, 1.04337923e-01f, 1.76451609e-01f, -2.06687316e-01f, 2.08459765e-01f, 2.61735350e-01f, 1.20421879e-01f, -1.69073015e-01f, -1.03694193e-01f, -5.67493476e-02f,
  1.07930198e-01f, 1.80827379e-01f, 2.37774640e-01f, 1.93849549e-01f, -1.63726047e-01f, -3.50889340e-02f, -1.01764344e-01f, -1.27147272e-01f, 1.47506192e-01f, -3.43530834e-01f,
  1.90701127e-01f, 1.62295923e-02f, -8.38105232e-02f, 1.04587436e-01f, 1.13958597e-01f, 3.61951925e-02f, -3.11499685e-01f, 1.75797552e-01f, 5.03674895e-02f, 8.02724808e-02f,
  2.85748988e-02f, 1.56603292e-01f, -9.72137079e-02f, 8.56775269e-02f, -1.16635323e-01f, -1.16064750e-01f, 1.75357744e-01f, 1.32648304e-01f, -1.47486338e-03f, -1.23242803e-01f,
  1.14761181e-01f, 2.78573424e-01f, 7.11245462e-02f, 1.78180769e-01f, -2.82140136e-01f, -9.37454849e-02f, -1.40432827e-02f, 2.97137164e-02f, 9.98806804e-02f, -1.01282597e-01f,
  1.61631346e-01f, -2.56236911e-01f, 1.02127306e-01f, 8.02042186e-02f, -2.18532547e-01f, -7.83175752e-02f, -1.76375762e-01f, -6.01298623e-02f, 1.60746679e-01f, -1.85253993e-01f,
  2.41441593e-01f, 1.94886178e-01f, 3.08292747e-01f, -2.95510963e-02f, -1.90397084e-01f, -3.51985902e-01f, -5.07225022e-02f, -4.51989889e-01f, 2.69784719e-01f, 1.95701748e-01f,
  4.64619137e-02f, 2.65063089e-03f, 2.66418159e-02f, 5.56703769e-02f, 2.48580292e-01f, 1.48776889e-01f, 2.40486562e-01f, 6.35774657e-02f, 1.14935547e-01f, -1.84114784e-01f,
  -5.97677007e-02f, -1.62411675e-01f, -1.53910816e-01f, -1.45386845e-01f, -7.08940402e-02f, 3.50732297e-01f, 2.39569843e-01f, 1.24870941e-01f, -4.16959682e-03f, 6.03216887e-02f,
  -1.63522273e-01f, 2.10407868e-01f, -7.85286427e-02f, 3.10679376e-02f, -1.50630683e-01f, 1.50690198e-01f, -7.43384361e-02f, 1.57437786e-01f, 6.89698532e-02f, -1.04516976e-01f,
  1.33846000e-01f, 1.23134539e-01f, 4.70461920e-02f, -2.78041465e-03f, 5.14931679e-02f, 2.13392481e-01f, -2.59014219e-01f, 1.65518418e-01f, 7.96250701e-02f, 4.42675620e-01f,
  7.03622540e-03f, 2.32732221e-02f, 2.81128466e-01f, 2.18928665e-01f, 1.70031399e-01f, 9.82195735e-02f, -6.49814606e-02f, -5.52692190e-02f, -4.15735990e-01f, 9.39413905e-02f,
  7.41289780e-02f, 5.82179129e-02f, 1.01718865e-01f, -2.28564203e-01f, 9.02560502e-02f, 2.33530432e-01f, 2.44762287e-01f, 6.09216154e-01f, -6.97420910e-03f, 2.98088759e-01f,
  2.38247618e-01f, -3.52436662e-01f, -4.16856445e-02f, 3.30038071e-01f, -2.26223484e-01f, -2.27620587e-01f, 1.37047753e-01f, 1.41036138e-01f, 1.46309346e-01f, 7.00469092e-02f,
  2.09173918e-01f, -2.25458900e-03f, 2.00721383e-01f, 1.41989989e-02f, -2.14812413e-01f, -1.44909412e-01f, 2.85257727e-01f, -2.95203049e-02f, -1.95813477e-02f, -1.71035752e-02f,
  -1.23939104e-01f, 7.80315101e-02f, 1.18602410e-01f, 2.43471950e-01f, -1.65932536e-01f, 7.59009197e-02f, 3.96834454e-03f, -4.61707741e-01f, 4.50265743e-02f, -4.40669544e-02f,
  2.17346653e-01f, -7.77837113e-02f, -6.73223361e-02f, -1.60601567e-02f, -9.06351656e-02f, 2.40834400e-01f, 2.32802227e-01f, 3.10992748e-02f, 4.43117544e-02f, 2.52553150e-02f,
  -3.42921078e-01f, -1.73143849e-01f, -7.87670761e-02f, 6.34474009e-02f, 1.31382838e-01f, -1.73251793e-01f, -6.74065351e-02f, -2.99427778e-01f, -1.29307285e-01f, -2.19290987e-01f,
  -1.24976225e-01f, -1.92550421e-01f, 2.61234641e-01f, -1.91937432e-01f, 2.39172384e-01f, -1.04174614e-02f, 2.53897220e-01f, -1.82019118e-02f, 1.54058784e-01f, 2.35510409e-01f,
  -2.86747873e-01f, 3.17172669e-02f, -1.42216757e-01f, 9.66946706e-02f, 1.73361063e-01f, 2.15449810e-01f, 1.78887863e-02f, -9.12866592e-02f, -4.78673764e-02f, -1.25888780e-01f,
  7.09251314e-02f, 9.03967023e-02f, -1.94673598e-01f, 8.13466832e-02f, -9.30582453e-03f, 1.33786211e-02f, 3.60087343e-02f, -2.17819563e-03f, 6.13768511e-02f, 1.83733687e-01f,
  -2.45005667e-01f, -4.13457714e-02f, 1.46946639e-01f, 3.66632082e-02f, -2.24051595e-01f, -1.08466528e-01f, 2.58173291e-02f, -4.11564916e-01f, 3.03648263e-01f, -3.84512544e-01f,
  -7.38820285e-02f, -1.87191427e-01f, 2.06624880e-01f, 2.69639287e-02f, -5.80008030e-02f, 7.87652209e-02f, -7.15401322e-02f, -9.65657905e-02f, -2.61077993e-02f, -2.16516241e-01f,
  7.99828172e-02f, 1.77425027e-01f, -3.85656059e-01f, -8.64089653e-02f, 5.56691783e-03f, 2.76432276e-01f, -1.54754892e-01f, 1.02351703e-01f, 6.12283461e-02f, 1.06889196e-03f,
  1.86321750e-01f, 3.52136672e-01f, 7.58531764e-02f, 1.19446449e-01f, 7.22199976e-02f, 1.48528576e-01f, -2.75332123e-01f, -1.74652450e-02f, -6.88733160e-03f, 6.70655537e-03f,
  2.20026255e-01f, 3.36760014e-01f, -2.13184297e-01f, -4.24814403e-01f, 2.88590118e-02f, -3.19570810e-01f, 3.43000352e-01f, 2.32018739e-01f, -1.17257563e-02f, -9.31546614e-02f,
  1.05631510e-02f, 5.40323034e-02f, 2.98137553e-02f, 3.01568151e-01f, 3.48043926e-02f, -1.05113380e-01f, -6.96079805e-02f, 9.91798788e-02f, -1.25199720e-01f, -2.09840909e-02f,
  4.64551926e-01f, 1.37124192e-02f, -8.82453322e-02f, 1.66174054e-01f, -7.45798275e-02f, 3.34906846e-01f, 1.90983400e-01f, 1.20442867e-01f, 1.00938603e-02f, -9.15217027e-02f,
  -5.74911311e-02f, 2.26630360e-01f, -2.67507046e-01f, -4.58670035e-02f, 5.32519706e-02f, 1.08791828e-01f, -1.68929994e-01f, -3.79105061e-02f, -1.10449977e-01f, 1.18935809e-01f,
  -6.65305704e-02f, 1.09170929e-01f, -1.54945731e-01f, 2.37709209e-02f, -7.53865615e-02f, -3.62659208e-02f, 2.62390524e-01f, -7.01096654e-02f, -1.27786189e-01f, 1.53208345e-01f,
  -5.32975197e-02f, 1.31562352e-01f, 2.42510751e-01f, 3.26483399e-01f, 1.29561350e-01f, 3.97261351e-01f, 2.02566907e-01f, -1.42283395e-01f, -4.79994714e-02f, -3.25654596e-02f,
  -3.55339527e-01f, -2.50174880e-01f, 1.90383926e-01f, -1.86683014e-01f, 5.58546409e-02f, -1.37079991e-02f, 3.10134888e-03f, -1.19320946e-02f, 2.31084943e-01f, -1.79234743e-01f,
  5.64179420e-01f, -3.59855115e-01f, 1.68475866e-01f, -2.27868319e-01f, 1.38744295e-01f, 2.61328608e-01f, 6.96203858e-02f, 2.27341682e-01f, 2.59722888e-01f, -1.20475544e-02f,
  -1.83636639e-02f, -4.20164727e-02f, -1.54972170e-02f, -8.13899711e-02f, 3.65362376e-01f, -1.18381537e-01f, 8.25250074e-02f, -2.29241788e-01f, 2.00294971e-01f, 1.31202161e-01f,
  1.84571341e-01f, 5.68279289e-02f, 9.11476165e-02f, 7.94116110e-02f, 1.12346232e-01f, 2.42855757e-01f, -5.79906285e-01f, 7.40955919e-02f, -3.79724354e-02f, -6.31861715e-03f,
  -4.53279644e-01f, -1.79667808e-02f, -1.53833469e-02f, -5.40621541e-02f, -1.45394532e-02f, 4.45425548e-02f, -1.35007113e-01f, -1.10343918e-01f, -5.77589460e-02f, -1.10016905e-01f,
  1.50930032e-01f, 7.74074122e-02f, 6.80576498e-03f, -1.02450907e-01f, 1.17294624e-01f, -1.02857076e-01f, -4.76518273e-02f, -1.75991468e-02f, -1.74850076e-01f, 1.06526479e-01f,
  3.78809497e-02f, -1.01302929e-01f, 8.46167430e-02f, -9.18572545e-02f, -1.49828568e-01f, 1.26443774e-01f, 1.08978689e-01f, -1.59410462e-01f, 1.13882631e-01f, 6.90991506e-02f,
  -1.80344358e-02f, -1.87159210e-01f, -2.06106856e-01f, -3.05517703e-01f, -1.05162598e-01f, 7.88290128e-02f, -2.65089888e-02f, -4.91545312e-02f, 1.93921596e-01f, 1.29061684e-01f,
  -7.38614202e-02f, -1.09801963e-02f, 3.03217657e-02f, 2.07155824e-01f, 1.87450889e-02f, 1.21185623e-01f, 1.81516796e-01f, 5.93575314e-02f, 3.00251126e-01f, -2.57507414e-01f,
  -1.46679478e-02f, -7.52446204e-02f, -1.57256603e-01f, 1.78956717e-01f, -8.51202011e-02f, 1.39246941e-01f, -7.45920688e-02f, 1.27371430e-01f, -5.12721688e-02f, -1.33618340e-01f,
  1.97912939e-03f, -1.45062983e-01f, -2.05481648e-01f, 2.02877447e-01f, 1.18011162e-01f, 1.75286666e-01f, -1.79615933e-02f, -2.99264956e-02f, 2.14367341e-02f, 1.65009573e-01f,
  2.18978580e-02f, 1.73689216e-01f, -2.26456244e-02f, 7.82783478e-02f, 2.10484974e-02f, 4.77046706e-02f, -9.60571393e-02f, -4.33308363e-01f, -1.86994806e-01f, -1.93608597e-01f,
  -3.71263139e-02f, 2.48406708e-01f, 3.84348184e-02f, 1.61004756e-02f, -2.80896500e-02f, 2.10565478e-02f, -8.73359945e-03f, -1.92931041e-01f, 2.04792753e-01f, 6.21532872e-02f,
  2.10154459e-01f, -9.21501145e-02f, 3.94250117e-02f, 1.72132045e-01f, 1.47514254e-01f, -1.95735589e-01f, -8.33414868e-03f, -4.39963043e-01f, 3.30182403e-01f, 2.50777509e-02f,
  -2.38493145e-01f, -3.49777848e-01f, -2.83324085e-02f, 5.92281222e-02f, -6.00387715e-02f, -7.04388171e-02f, -7.82903358e-02f, 1.74776781e-02f, 1.43608466e-01f, 9.88803133e-02f,
  -2.13411406e-01f, 1.62727520e-01f, 3.58248740e-01f, 2.89515436e-01f, 4.80283797e-02f, -3.30586289e-03f, 1.03793912e-01f, -2.26614788e-01f, -4.54729609e-02f, 1.80081546e-01f,
  8.59571528e-03f, 6.99070171e-02f, -1.67842805e-01f, 1.19983055e-01f, -4.54811126e-01f, -9.56649194e-04f, -4.59616780e-01f, 1.14689566e-01f, 1.18756540e-01f, -1.80026203e-01f,
  1.34825453e-01f, 5.90461306e-02f, 7.56000578e-02f, -9.32664517e-03f, 1.34552956e-01f, 1.56329256e-02f, 8.96236971e-02f, -4.71316613e-02f, -1.05608627e-02f, 1.35464296e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  1.66620538e-02f, -7.53539950e-02f, 2.95890123e-02f, 7.72121102e-02f, -1.00489713e-01f, 6.91471696e-02f, 1.13617986e-01f, 8.54188353e-02f, 5.38306870e-02f, -7.00870454e-02f,
  2.01407317e-02f, 8.48720819e-02f, 2.12427393e-01f, 1.47825584e-01f, -5.48839234e-02f, -1.18804455e-01f, -2.10275128e-02f, 9.78832394e-02f, -4.35976312e-02f, 7.00883269e-02f,
  1.21463172e-01f, 1.56158954e-02f, 5.55287637e-02f, 4.94960956e-02f, 4.86185513e-02f, 1.15189165e-01f, 7.47453328e-03f, 5.33907264e-02f, -3.20797749e-02f, 1.44004405e-01f,
  9.12507772e-02f, -5.62003674e-03f, 1.36579707e-01f, 1.30299836e-01f, 2.16661423e-01f, 1.86498642e-01f, 8.74645859e-02f, -1.51238693e-02f, 1.20881177e-03f, -5.53682782e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -8.74351263e-02f, -1.29021913e-01f, -4.56576869e-02f, -7.15084970e-02f, -3.14187050e-01f, -1.39221117e-01f, 1.84143662e-01f, -2.74595991e-02f, 1.04853228e-01f, -1.00058027e-01f,
  -1.23205669e-01f, -9.38122123e-02f, 2.14085191e-01f, 1.28457814e-01f, 3.07319071e-02f, 1.24404959e-01f, 6.97347373e-02f, 9.07954723e-02f, 1.05364352e-01f, -1.70010939e-01f,
  -9.38771293e-02f, 7.20619783e-02f, -9.76767018e-02f, -9.95496213e-02f, 1.67091057e-01f, -9.51175019e-02f, -3.36946368e-01f, 2.09093257e-03f, -3.24589107e-03f, 1.81829929e-01f,
  5.76512776e-02f, -5.43147326e-02f, -2.46002734e-01f, -1.11015633e-01f, -7.01772049e-02f, -5.55309765e-02f, -1.55029818e-02f, -1.46846429e-01f, 7.28166327e-02f, -1.07842267e-01f,
  -1.62921891e-01f, -1.20036319e-01f, -1.62544265e-01f, -4.78214413e-01f, -2.48700567e-02f, -2.71777343e-03f, 2.04038024e-01f, 1.74159378e-01f, -6.93356395e-01f, -2.47747600e-01f,
  -3.07314813e-01f, -2.08718881e-01f, -1.41653627e-01f, -1.12111919e-01f, 6.86715841e-02f, -4.11500484e-01f, 7.13581741e-02f, 1.71822146e-01f, -1.61312684e-01f, -9.40201432e-02f,
  -4.15751874e-01f, -3.36531401e-01f, 1.96075346e-02f, 1.52052864e-01f, -1.89045236e-01f, 1.29089847e-01f, 2.08841637e-01f, -2.20591679e-01f, 1.97389945e-01f, -1.98708236e-01f,
  4.29609753e-02f, -1.94424227e-01f, 6.31918088e-02f, -1.28706053e-01f, 3.41299064e-02f, -7.04265460e-02f, -2.33853031e-02f, -3.11084598e-01f, -2.23705307e-01f, -2.99206734e-01f,
  1.78182647e-01f, 1.24713577e-01f, 1.54161036e-01f, 3.28279822e-03f, 2.76323378e-01f, 1.83291331e-01f, 1.08107917e-01f, 2.49535486e-01f, -7.96436295e-02f, -2.05473490e-02f,
  1.95289746e-01f, 9.27127004e-02f, -1.25857830e-01f, -1.25675902e-01f, 1.66086350e-02f, 3.48483860e-01f, 8.83850306e-02f, -5.19046001e-02f, -7.09029511e-02f, -3.97920907e-01f,
  -1.35682091e-01f, 7.18055516e-02f, -1.20209470e-01f, -2.02970058e-01f, 5.09919114e-02f, 1.13549814e-01f, -2.03054965e-01f, -3.54999959e-01f, 1.42416924e-01f, 1.12673976e-01f,
  1.13596790e-01f, 4.31433180e-03f, 1.32990912e-01f, 2.07752567e-02f, -9.60929170e-02f, -2.93136805e-01f, -8.82758126e-02f, -1.69337690e-01f, -1.49403319e-01f, -1.06663756e-01f,
  8.55958834e-02f, -8.41322094e-02f, 1.89048573e-01f, -1.58150196e-02f, -1.76399916e-01f, -2.09978789e-01f, -2.83997744e-01f, 6.78985491e-02f, 7.45162666e-02f, 9.22400057e-02f,
  -2.75973171e-01f, -2.31367141e-01f, -5.20873889e-02f, 4.92002934e-01f, -6.60734135e-04f, -2.27284998e-01f, 5.44476621e-02f, 1.93548739e-01f, 2.44482815e-01f, -1.87756084e-02f,
  2.11424544e-01f, -8.02257583e-02f, 8.91481265e-02f, 1.31186739e-01f, 2.66031604e-02f, -2.75151599e-02f, -1.17127277e-01f, 2.15421438e-01f, -3.35268646e-01f, -3.49537879e-01f,
  4.34846105e-03f, -2.61956781e-01f, -1.04006017e-02f, -4.85404134e-01f, 8.31656381e-02f, 1.74778238e-01f, -8.61595478e-03f, 6.17373921e-02f, -1.53171957e-01f, -1.85558632e-01f,
  -4.56532270e-01f, 6.62309006e-02f, -9.97280180e-02f, -1.14068061e-01f, 2.92095412e-02f, -6.97711408e-02f, -1.96327984e-01f, -1.29204452e-01f, -4.87916470e-01f, -3.89875233e-01f,
  3.72481793e-01f, -1.85254216e-01f, -2.29517087e-01f, 2.01529264e-01f, -3.36881774e-03f, -2.06427998e-03f, -4.33311433e-01f, 1.59555331e-01f, -2.97520131e-01f, -2.08225161e-01f,
  1.33805573e-01f, -3.54439199e-01f, -3.75619769e-01f, 3.69380997e-03f, 1.91164538e-01f, 1.55584797e-01f, 2.36538410e-01f, 1.28215060e-01f, -1.68684691e-01f, 2.18102425e-01f,
  -1.38405800e-01f, -3.80835831e-01f, 8.82594436e-02f, -1.02582194e-01f, 6.61458448e-02f, -4.96242493e-02f, -2.08605770e-02f, 2.07129791e-01f, -1.01111092e-01f, 2.59286296e-02f,
  -2.25419283e-01f, 4.42575589e-02f, 3.37970927e-02f, 4.22377847e-02f, 2.94641197e-01f, 3.10673565e-02f, -1.25972301e-01f, -2.29199808e-02f, -1.50809079e-01f, 1.37783408e-01f,
  1.48500815e-01f, -3.34433131e-02f, 9.64057148e-02f, -1.65369257e-01f, -2.53813323e-02f, 5.56680039e-02f, -3.14747870e-01f, 1.78546518e-01f, -4.34706509e-01f, -2.50136346e-01f,
  1.21047767e-02f, 3.60895880e-02f, 9.44545045e-02f, -4.86773282e-01f, 1.34432048e-01f, -5.42104095e-02f, -9.85985994e-02f, 1.86838508e-01f, -4.51518983e-01f, -1.85349301e-01f,
  1.28702655e-01f, -2.34673098e-01f, -4.24614586e-02f, -4.66709942e-01f, -1.98510453e-01f, 1.48729412e-02f, 8.95811543e-02f, 7.71922013e-03f, 7.67715275e-02f, 1.40660927e-01f,
  -4.98748600e-01f, -2.98956901e-01f, -1.88362449e-01f, -2.39632547e-01f, -3.76989782e-01f, -2.26593748e-01f, 6.51024655e-02f, 1.55109882e-01f, -9.57693458e-02f, 6.73825145e-02f,
  -2.82093972e-01f, -6.35910630e-01f, -1.54357962e-02f, -4.59655762e-01f, 6.30192235e-02f, -4.36477154e-01f, 3.58995534e-02f, 7.83006996e-02f, 1.38145164e-01f, -1.00715652e-01f,
  -8.32206979e-02f, -1.17269065e-02f, 1.45004272e-01f, 3.66115011e-02f, 9.42075849e-02f, -7.77748972e-02f, 1.17201731e-01f, -2.28372365e-01f, -1.80163413e-01f, -1.42283544e-01f,
  -1.53468937e-01f, 3.76857877e-01f, 1.51214510e-01f, 1.26275405e-01f, -3.82188976e-01f, -1.19451145e-02f, -7.56871700e-02f, -1.60636798e-01f, 2.29730949e-01f, -2.27784932e-01f,
  3.75512205e-02f, -2.79707402e-01f, -2.73101836e-01f, -3.25187385e-01f, -2.20748167e-02f, 1.20740876e-01f, 4.12904657e-02f, 4.89547737e-02f, -3.63125801e-01f, -7.06837028e-02f,
  2.18144935e-02f, 2.06573412e-01f, -7.72022083e-02f, 8.89076367e-02f, 9.18262114e-04f, -8.61251205e-02f, -2.01170415e-01f, -9.82220918e-02f, -3.53328317e-01f, 1.18778395e-02f,
  -1.11140519e-01f, -7.31350258e-02f, 1.13944598e-02f, 1.11837454e-01f, 1.34731367e-01f, -2.03335568e-01f, -6.40310496e-02f, 2.64987469e-01f, -3.84632200e-02f, 2.22367868e-02f,
  1.07456468e-01f, -1.02551721e-01f, 1.58717141e-01f, 1.63676053e-01f, -2.78149545e-01f, 3.28349173e-02f, -9.65375919e-03f, 2.44889662e-01f, 6.24503121e-02f, -1.42731583e-02f,
  4.99997549e-02f, 1.40082076e-01f, -1.35824624e-02f, 1.49023682e-01f, 2.24265471e-01f, 7.05597848e-02f, 2.63304226e-02f, 2.25618646e-01f, -1.36549070e-01f, -2.27186710e-01f,
  3.93978730e-02f, 1.16121573e-02f, -2.21036598e-01f, -1.02033108e-01f, 2.65375286e-01f, 9.13616493e-02f, 9.35448408e-02f, 7.79337659e-02f, -3.58171254e-01f, 3.07699889e-01f,
  -7.73829147e-02f, -1.51769057e-01f, -3.27924043e-02f, 9.51685309e-02f, -2.64863253e-01f, -3.06843936e-01f, 1.37321979e-01f, -3.59740704e-02f, 1.63847802e-03f, 1.12864166e-01f,
  1.69223428e-01f, -2.86346167e-01f, -2.03856215e-01f, 6.46409467e-02f, -1.34018892e-02f, -2.33467057e-01f, -4.03460450e-02f, -2.48069372e-02f, -2.22648427e-01f, -2.96235740e-01f,
  -2.33043700e-01f, -1.66063592e-01f, -1.31496221e-01f, -3.35791111e-01f, 2.27199540e-01f, -2.52339661e-01f, 1.41617164e-01f, 8.33744463e-03f, 2.50459667e-02f, 4.79363576e-02f,
  4.02357094e-02f, -2.59615898e-01f, -4.56627831e-02f, 1.76445842e-01f, 1.75329536e-01f, -2.96252549e-01f, -3.21412414e-01f, 8.21947400e-03f, -4.13315408e-02f, 1.00753777e-01f,
  2.84325391e-01f, 2.44812652e-01f, -9.97440070e-02f, 1.28813952e-01f, 2.87177302e-02f, 4.98902518e-03f, -1.43613797e-02f, 2.33529925e-01f, 1.09165676e-01f, -1.52180046e-01f,
  -8.60534757e-02f, 1.84771761e-01f, 2.67406166e-01f, 8.79800916e-02f, 2.33754233e-01f, 2.55359095e-02f, 3.80681485e-01f, 1.35486782e-01f, 2.77496517e-01f, 4.71500307e-01f,
  1.74096748e-01f, 1.04232751e-01f, 4.10633087e-02f, 6.21996559e-02f, -5.83388992e-02f, 1.66980982e-01f, 1.95953801e-01f, 1.16318792e-01f, 8.80019814e-02f, -4.67946559e-01f,
  1.61935925e-01f, -3.12927589e-02f, 2.18471587e-02f, -2.82447994e-01f, -2.31889650e-01f, 8.97946768e-03f, 4.38227132e-02f, -7.79758692e-02f, 9.85827297e-02f, -6.08914554e-01f,
  2.02128172e-01f, 2.77861595e-01f, 4.50465316e-03f, -1.28437534e-01f, -1.20550036e-01f, 6.98615685e-02f, 2.36806795e-01f, 7.00413734e-02f, -4.40340579e-01f, -1.51919825e-02f,
  -3.02121341e-01f, -5.31490028e-01f, 1.58693269e-02f, 2.63010293e-01f, 6.74769878e-02f, 6.93762749e-02f, 1.30293844e-02f, 1.51290089e-01f, -2.80162841e-01f, -1.00858696e-01f,
  -1.56899184e-01f, -2.33474076e-01f, 5.73201329e-02f, -1.83669835e-01f, 1.91887647e-01f, 1.33850411e-01f, 1.24451034e-01f, 1.24325968e-01f, -7.87213357e-05f, -1.25860468e-01f,
  1.86233461e-01f, -1.68432951e-01f, -2.53574103e-01f, -1.31910324e-01f, -5.10631353e-02f, 1.13918491e-01f, 2.31758535e-01f, -9.69941318e-02f, 1.84418410e-02f, -1.67445347e-01f,
  2.21267827e-02f, -6.55341893e-02f, -1.95849568e-01f, -4.60782275e-02f, 4.02432345e-02f, 1.47921219e-01f, -8.48929882e-02f, -1.26821455e-04f, -1.04771361e-01f, 1.54920921e-01f,
  1.90236121e-01f, -1.01960294e-01f, -2.57698268e-01f, -4.95313480e-02f, 4.49736826e-02f, -1.19395636e-01f, 6.44428954e-02f, 4.95112594e-03f, 3.60427871e-02f, 2.80358698e-02f,
  1.43041119e-01f, 1.45529136e-02f, 5.81746213e-02f, 3.08500249e-02f, -5.04202008e-01f, 7.68152475e-02f, 1.47092380e-02f, -3.60297039e-02f, 1.48109183e-01f, -2.03131005e-01f,
  -7.17937872e-02f, 8.21462646e-02f, -2.37762347e-01f, -1.39226601e-01f, -3.46519709e-01f, -7.34302849e-02f, 2.16246828e-01f, 2.20839217e-01f, -8.38167965e-02f, 1.48129389e-01f,
  2.94662416e-02f, -3.15407366e-01f, 1.01528279e-01f, 1.26207352e-01f, -2.74678886e-01f, -3.07697177e-01f, -1.54947102e-01f, 2.60123104e-01f, -2.10786119e-01f, -2.12691754e-01f,
  1.11405730e-01f, -1.90135632e-02f, 1.11449577e-01f, -2.69792169e-01f, 2.27266513e-02f, 4.60165441e-02f, 1.83655888e-01f, 3.03562470e-02f, 1.74627006e-01f, -1.46864861e-01f,
  -1.44509792e-01f, 4.71908748e-02f, -2.77132958e-01f, 2.34928146e-01f, -2.83975124e-01f, 2.95738220e-01f, -1.76802203e-01f, -3.42136443e-01f, 1.43772721e-01f, -5.01384959e-02f,
  1.64730281e-01f, -3.97921622e-01f, -1.78541631e-01f, 1.36076529e-02f, -5.85482791e-02f, 4.00296211e-01f, -7.27921128e-01f, 1.52984932e-01f, -1.00185618e-01f, 7.87418336e-02f,
  -8.37678909e-02f, -4.95290250e-01f, -4.97759044e-01f, 1.77965183e-02f, -1.38899293e-02f, 1.08441748e-01f, -4.70100343e-02f, -5.41197620e-02f, 8.62152800e-02f, 2.85228342e-01f,
  -1.14615649e-01f, -3.30332592e-02f, 3.60623896e-02f, -2.11620256e-01f, -1.29440784e-01f, -2.56601900e-01f, 1.15416255e-02f, -2.48639658e-01f, -4.16312218e-01f, -2.16421455e-01f,
  -1.37633353e-01f, -2.29504272e-01f, 2.82846659e-01f, -5.16989291e-01f, -1.98069692e-01f, 3.03305149e-01f, 1.54183850e-01f, 1.04487158e-01f, -4.30001825e-01f, -3.53743106e-01f,
  5.65965585e-02f, -1.25996605e-01f, 8.88733342e-02f, -4.70876664e-01f, 5.20366384e-03f, -2.94624090e-01f, -4.79975156e-02f, 2.19370082e-01f, -2.05767788e-02f, 1.36855558e-01f,
  1.51191831e-01f, -1.30181149e-01f, -1.63668752e-01f, -2.27436781e-01f, -3.34562004e-01f, -3.96311767e-02f, 2.53478903e-02f, 1.46671608e-01f, 1.65061831e-01f, 1.63102355e-02f,
  1.07726390e-02f, 1.30067721e-01f, -3.14670920e-01f, -1.79074541e-01f, 6.68413565e-02f, 1.40684888e-01f, 2.45021328e-01f, 9.25300643e-02f, 1.78641438e-01f, 6.81982934e-02f,
  -1.83142126e-01f, -4.81668502e-01f, 9.95886773e-02f, -3.11624885e-01f, -3.07985861e-02f, 5.70087731e-02f, -4.81360137e-01f, -1.71696723e-01f, 1.33424297e-01f, -1.46058887e-01f,
  2.59181149e-02f, 2.42604017e-02f, 8.95759165e-02f, -4.95274067e-01f, 1.82935223e-01f, -2.01085299e-01f, 3.12324520e-02f, 3.03226739e-01f, -1.00713477e-01f, 1.53952762e-01f,
  -4.12414163e-01f, 2.02826515e-01f, -1.11978754e-01f, -6.84387004e-03f, -6.30562082e-02f, -3.11365258e-02f, -5.40010154e-01f, -1.94117110e-02f, 1.58626080e-01f, -9.50761363e-02f,
  -4.05548364e-01f, 1.50270879e-01f, 2.71374583e-01f, -8.70784745e-02f, 8.82473066e-02f, -1.26138508e-01f, 2.81879585e-02f, 2.45310888e-02f, -1.47788199e-02f, -2.69935012e-01f,
  -1.25113890e-01f, -1.22772790e-01f, 7.77004212e-02f, -8.46829191e-02f, -1.91191107e-01f, 2.07977608e-01f, -1.30886808e-01f, 9.79932025e-02f, 4.38491628e-02f, 1.14188686e-01f,
  -6.08165190e-02f, -8.72915760e-02f, -2.62159735e-01f, 1.94774389e-01f, -6.87416941e-02f, -2.38290668e-01f, -2.27775867e-03f, 8.21194798e-02f, 2.37853825e-01f, -2.84893274e-01f,
  2.65411973e-01f, -1.84169859e-01f, -1.85144290e-01f, -3.31104517e-01f, -4.38254654e-01f, -1.34042919e-01f, -1.53579116e-01f, 1.48402512e-01f, -7.50649124e-02f, 7.20921233e-02f,
  8.84215012e-02f, -1.33618385e-01f, -2.33154178e-01f, 3.37599665e-02f, -2.30059251e-02f, 5.04509993e-02f, 2.59348661e-01f, 1.01720966e-01f, -1.28211230e-01f, 1.16230801e-01f,
  -4.75239158e-01f, -2.04182416e-01f, 2.73963422e-01f, -6.77161105e-03f, -9.47680101e-02f, 4.17312197e-02f, -1.85434461e-01f, 1.74177989e-01f, -2.69326478e-01f, 2.65217453e-01f,
  3.16446424e-02f, -1.53939594e-02f, -3.87463540e-01f, -3.62986654e-01f, 1.90895826e-01f, -1.56170577e-01f, -3.81280780e-01f, -4.97926146e-01f, -6.12547517e-01f, -6.82337761e-01f,
  1.62925169e-01f, -4.91719730e-02f, -2.33817205e-01f, -4.55785781e-01f, -1.25177160e-01f, -1.74724162e-01f, -3.91629972e-02f, -2.78365407e-02f, -2.57531255e-01f, 1.48653135e-01f,
  -1.55459037e-02f, 2.16173660e-02f, 1.96986735e-01f, -2.91459374e-02f, 9.87536237e-02f, -5.75960651e-02f, -2.08186701e-01f, 1.15772791e-01f, 3.25421333e-01f, -4.46469277e-01f,
  -2.55616784e-01f, -1.08924665e-01f, 1.41156837e-01f, 1.42664373e-01f, 1.27842873e-01f, -1.36130169e-01f, -3.11027497e-01f, 1.39449775e-01f, -6.15286864e-02f, 2.80315373e-02f,
  1.06434163e-03f, -3.22094560e-01f, -5.86678945e-02f, -1.42221972e-01f, -3.43963802e-01f, -4.67580967e-02f, 3.80205996e-02f, -8.57594684e-02f, 5.58431521e-02f, 7.39611983e-02f,
  -3.68100017e-01f, -4.42438900e-01f, -3.02825775e-03f, -2.10168198e-01f, 1.96929783e-01f, 1.52927101e-01f, -3.09541047e-01f, 7.82885216e-03f, 2.17477143e-01f, -2.87394077e-01f,
  -1.54278725e-01f, -2.31407553e-01f, -3.32017511e-01f, -1.97442994e-01f, -1.65081352e-01f, 2.20122546e-01f, -4.50358361e-01f, 2.54701167e-01f, -1.14220090e-01f, 7.01988116e-02f,
  1.91871017e-01f, 2.25306585e-01f, 2.28766680e-01f, -3.16381335e-01f, -1.27496555e-01f, -1.82240717e-02f, 1.07243508e-01f, -5.63188642e-03f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.96591929e-01f, 1.04349308e-01f, 3.71550024e-02f, -9.78385061e-02f, 3.81152034e-02f, 8.64626188e-03f, 6.40865341e-02f, 1.30186444e-02f, 5.81031404e-02f, -8.68573934e-02f,
  -5.54138469e-03f, -1.00834794e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    