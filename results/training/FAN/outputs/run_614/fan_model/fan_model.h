/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.93945438e-01f, -5.34806907e-01f, 2.61901140e-01f, 1.73717141e-01f, -2.44336408e-02f, 2.14582291e-02f, -2.11937129e-01f, -1.22264251e-01f, -3.58672789e-03f, -2.74267912e-01f,
  -2.81762302e-01f, -9.51697007e-02f, -6.34869561e-02f, 1.16526835e-01f, 1.64236456e-01f, -1.56634480e-01f, 1.34324849e-01f, 4.96731371e-01f, 4.33712035e-01f, 1.17654249e-01f,
  -6.38950840e-02f, 2.06115097e-01f, 4.01415497e-01f, 2.25683019e-01f, -1.79740697e-01f, 9.60000753e-02f, -4.89169396e-02f, 1.49764061e-01f, 1.94293913e-02f, 1.86788440e-01f,
  -2.31667124e-02f, -1.37670904e-01f, 1.66908249e-01f, 3.58423814e-02f, -2.15066634e-02f, 3.45859304e-02f, 3.79392803e-02f, 4.91508702e-03f, -3.77700776e-02f, 2.95419968e-03f,
  2.34181061e-02f, 7.58792460e-02f, 3.51995192e-02f, 8.60782489e-02f, 1.28842248e-02f, -1.58686154e-02f, 2.18793713e-02f, 3.15257087e-02f, 1.11264177e-01f, -1.60489604e-01f,
  -7.27245510e-02f, 9.48422551e-02f, 1.76513717e-02f, -6.59013167e-02f, -1.46595955e-01f, 1.70306787e-02f, -8.99544954e-02f, -5.54860719e-02f, -1.15976594e-02f, -1.88477151e-02f,
  1.09620305e-04f, -1.08683750e-01f, -4.00980785e-02f, -4.38422374e-02f, -2.41035372e-02f, -1.00184586e-02f, -3.05561498e-02f, -1.76983001e-03f, 3.84135060e-02f, 9.47253313e-03f,
  3.53022590e-02f, -1.11718588e-01f, -6.05980307e-02f, 1.20226806e-02f, 3.47064808e-02f, 4.33466919e-02f, 3.31956707e-02f, 2.61788312e-02f, 2.06019152e-02f, 7.09614083e-02f,
  -1.73084307e-02f, 2.81845257e-02f, -4.19151261e-02f, -2.10677111e-03f, 2.20861882e-02f, 3.10500246e-02f, -5.19441217e-02f, -3.52357626e-02f, 7.00414879e-03f, 1.63394734e-02f,
  -1.96995646e-01f, 1.33566260e-01f, -8.14721063e-02f, 6.73144460e-02f, -1.06560718e-02f, 5.78906909e-02f, 2.48737317e-02f, -6.86408728e-02f, -4.10448536e-02f, 3.34683843e-02f,
  -4.67757955e-02f, 2.17501931e-02f, 5.81622757e-02f, -3.54911163e-02f, 5.95671684e-02f, 1.16522843e-02f, -8.18007365e-02f, 1.46634765e-02f, -2.07351409e-02f, 5.41347191e-02f,
  -1.90281551e-02f, 6.12152927e-02f, -8.89338404e-02f, -1.29184723e-01f, -3.25520523e-02f, -9.83466953e-03f, -1.02319438e-02f, 5.10095544e-02f, 2.21659187e-02f, -2.21389800e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.32388246e+00f, -2.80370891e-01f, -6.93702996e-01f, 6.52559400e-02f, -2.84871429e-01f, -3.68566588e-02f, -2.03896493e-01f, -1.55237585e-01f, 1.29638106e-01f, -1.65242389e-01f,
  4.70717736e-02f, 3.98541987e-01f, 4.00479883e-01f, 8.04511011e-02f, 2.71285802e-01f, -2.20932677e-01f, -4.27838206e-01f, 1.54432371e-01f, 2.66554534e-01f, 1.43084377e-01f,
  -3.16749103e-02f, -5.44828922e-02f, 2.50058830e-01f, 1.70071065e-01f, -3.45381647e-01f, 1.49159640e-01f, -4.57780749e-01f, -3.28381509e-01f, -5.04815578e-02f, -4.01275486e-01f,
  1.44538119e-01f, -1.81521311e-01f, 1.21325538e-01f, 7.06794560e-02f, -1.27863154e-01f, 1.09271199e-01f, 9.31080654e-02f, -5.73072061e-02f, 9.15991664e-02f, -3.00511327e-02f,
  -5.52029498e-02f, -1.75528042e-02f, 1.65184420e-02f, -1.43787488e-01f, -1.62269264e-01f, -9.60829705e-02f, -2.04968169e-01f, 3.78689496e-03f, -1.61062051e-02f, -9.99854356e-02f,
  -9.06605050e-02f, -4.46692156e-03f, -1.58965483e-01f, -6.89689592e-02f, 3.60350274e-02f, -1.69226322e-02f, -2.92915463e-01f, -5.89422546e-02f, -6.55865744e-02f, -1.95678398e-01f,
  -3.07707973e-02f, 8.31557438e-02f, 1.72363460e-01f, 9.72537175e-02f, 9.33397114e-02f, 2.69647762e-02f, 1.09874956e-01f, 3.66791077e-02f, 2.59502605e-02f, -3.06302290e-02f,
  -8.65212157e-02f, 5.38734570e-02f, 5.78749739e-02f, -5.79742417e-02f, 7.10047334e-02f, -1.93322673e-02f, 4.99089099e-02f, -7.11646229e-02f, 5.71904927e-02f, -1.14764897e-02f,
  1.49411082e-01f, -4.61921878e-02f, -1.01757802e-01f, -5.28943900e-04f, -3.77315134e-02f, -6.98681995e-02f, -1.16766259e-01f, 5.18898070e-02f, 9.29357577e-03f, 1.09414775e-02f,
  1.96680710e-01f, 2.81921998e-02f, 1.42175570e-01f, 1.80980451e-02f, -1.15440823e-01f, -7.28937089e-02f, 3.26859914e-02f, 6.61456659e-02f, -3.31450589e-02f, -1.55207232e-01f,
  -9.88702476e-02f, 8.93193483e-02f, -1.25706419e-01f, -2.25022994e-02f, 1.35941148e-01f, 1.17780706e-02f, 7.06692487e-02f, 1.13878451e-01f, 1.81646440e-02f, -9.41663459e-02f,
  -4.27912660e-02f, 9.96894240e-02f, 2.25519747e-01f, 1.11450531e-01f, 1.41197443e-02f, 3.47651541e-01f, 1.04633812e-02f, -5.19054830e-02f, 1.69279709e-01f, 3.43272239e-02f,
  8.46886486e-02f, 1.74494132e-01f, 2.72937059e-01f, 3.79522562e-01f, 1.95082143e-01f, 1.68302596e-01f, 4.50150579e-01f, 1.08675011e-01f, -1.53965950e-01f, 1.15207747e-01f,
  1.83101848e-01f, -9.70064402e-02f, -1.16319768e-01f, -1.22253865e-01f, 1.28628537e-01f, 2.12755427e-01f, 1.83569610e-01f, 5.99608831e-02f, 3.20967101e-02f, 4.96815406e-02f,
  9.72559974e-02f, 5.53583652e-02f, -2.04850346e-01f, -1.46685094e-01f, -2.00256500e-02f, -2.91704834e-01f, 8.06332473e-03f, 1.09840795e-01f, 7.04374537e-02f, -1.14847450e-02f,
  1.07411765e-01f, 4.67142224e-01f, -1.06694639e-01f, -1.60278857e-01f, 5.09690642e-02f, -2.82456011e-01f, -1.42923445e-01f, -8.98898765e-02f, -9.12253037e-02f, -1.51376233e-01f,
  -1.78895630e-02f, -4.99400757e-02f, 1.68745652e-01f, 3.65523398e-02f, 1.36066198e-01f, 1.14428543e-01f, -6.36565033e-04f, 2.23280564e-01f, 8.82571638e-02f, 5.90531267e-02f,
  8.97693783e-02f, 6.11230433e-02f, 2.33941451e-01f, 1.36392370e-01f, 1.69594437e-01f, 1.80760603e-02f, 5.85815236e-02f, -6.44375235e-02f, 1.22855082e-01f, -3.73170376e-02f,
  4.55015562e-02f, 8.25407878e-02f, 8.54575187e-02f, -9.43635032e-02f, -5.09522110e-02f, -2.72137746e-02f, 1.06381908e-01f, 3.00217509e-01f, 5.75201437e-02f, -1.54955328e-01f,
  3.86044532e-02f, 1.85275197e-01f, -6.85852370e-04f, 1.69635147e-01f, -4.77439575e-02f, 1.50899515e-01f, -5.56244422e-03f, 4.98243570e-02f, 3.97871993e-02f, -4.16412540e-02f,
  1.20906241e-01f, 1.54608831e-01f, 1.78513105e-03f, 7.18622981e-03f, 1.51687572e-02f, 1.18934222e-01f, 6.85390159e-02f, 3.94477770e-02f, 3.90254557e-02f, -1.80182140e-02f,
  -3.36854815e-01f, 2.55389333e-01f, 5.34077510e-02f, -1.84307039e-01f, 8.20683166e-02f, -2.17501789e-01f, -1.10945076e-01f, -1.38888732e-01f, -1.06613196e-01f, 5.91649078e-02f,
  -2.65324861e-02f, -5.38061820e-02f, 1.72819942e-01f, -4.95515689e-02f, -7.62300938e-03f, -8.91555324e-02f, -1.11009285e-01f, 9.02769864e-02f, -1.41289219e-01f, -3.06288246e-02f,
  -7.66891381e-03f, -1.71758324e-01f, -1.59566343e-01f, -1.68578520e-01f, 4.27447818e-02f, -2.41698891e-01f, -8.49762633e-02f, -1.05990589e-01f, -8.38081390e-02f, -3.60491395e-01f,
  -6.56892240e-01f, 2.28905156e-01f, 1.84135526e-01f, -4.67086762e-01f, -1.50592372e-01f, -6.22454174e-02f, 5.52040100e-01f, -5.30175008e-02f, -4.24311787e-01f, 2.75628179e-01f,
  -6.26886040e-02f, -8.99118036e-02f, -1.29268870e-01f, -4.73136529e-02f, 5.91656715e-02f, 3.92652124e-01f, 1.72537435e-02f, -1.20248040e-02f, 2.38328844e-01f, 2.97175586e-01f,
  1.98032454e-01f, -7.93587230e-03f, -2.62549400e-01f, -1.80696964e-01f, -3.60496044e-02f, 5.61891571e-02f, -1.25369783e-02f, -3.75027835e-01f, -1.39875531e-01f, -1.65189266e-01f,
  2.06383407e-01f, -5.77330887e-01f, -2.56614834e-02f, -2.23867670e-01f, -4.66489680e-02f, 7.62362673e-04f, 2.01947480e-01f, -4.70522195e-02f, -7.23825842e-02f, -8.91581699e-02f,
  -3.40659708e-01f, -5.70415966e-02f, -1.46547958e-01f, -3.36982347e-02f, 8.66180882e-02f, -3.11305951e-02f, -4.36173268e-02f, -2.33888671e-01f, -2.58176625e-01f, 3.05384938e-02f,
  -4.17312495e-02f, -8.17699954e-02f, -1.42060697e-01f, -2.65195593e-02f, -2.88150877e-01f, -2.05726534e-01f, -5.13165910e-03f, -3.07676673e-01f, -1.70632243e-01f, 6.47640675e-02f,
  1.97183937e-02f, -4.70736437e-02f, 1.44273341e-01f, 2.33597592e-01f, 2.64088288e-02f, 1.78273525e-02f, 1.47341326e-01f, 1.67363405e-01f, 1.22672178e-01f, -1.74523089e-02f,
  6.31195009e-02f, 6.51214644e-02f, -5.90355741e-03f, 7.50165209e-02f, -3.06605268e-03f, -1.14057042e-01f, -2.41583716e-02f, 7.13219270e-02f, -1.87387258e-01f, -3.90648134e-02f,
  -5.47109656e-02f, -9.89982188e-02f, 9.47309472e-03f, -2.83161644e-02f, -1.10446557e-01f, -9.71168131e-02f, -8.94520879e-02f, -3.94020490e-02f, 4.83628735e-02f, 1.00023650e-01f,
  3.92670155e-01f, -2.40892589e-01f, 2.05610454e-01f, 8.20126981e-02f, -5.30225560e-02f, -9.30021554e-02f, -2.90162861e-02f, 2.09918264e-02f, -1.64474383e-01f, 9.19363499e-02f,
  -1.50192469e-01f, -1.05382055e-02f, 7.83554018e-02f, 8.46368074e-02f, 1.35217875e-01f, -9.81420744e-03f, -2.31571533e-02f, 8.23422670e-02f, -1.20352339e-02f, -6.24502562e-02f,
  3.58141512e-02f, 1.62400097e-01f, 3.07828844e-01f, 6.39348254e-02f, -4.79064584e-02f, 2.05766678e-01f, 1.99793994e-01f, 1.54281393e-01f, 4.34664376e-02f, 6.53099239e-01f,
  1.94743201e-01f, -7.92190850e-01f, 6.53750777e-01f, 3.44798923e-01f, 4.45256025e-01f, 3.57466161e-01f, 2.72782326e-01f, 1.78724661e-01f, 4.82179113e-02f, -1.01041064e-01f,
  -3.45654696e-01f, -3.99073899e-01f, -5.07567525e-01f, -3.08916599e-01f, -1.28856227e-01f, 2.67984092e-01f, 4.69085008e-01f, 3.61359328e-01f, 4.03944552e-01f, 3.37032005e-02f,
  -1.09222047e-01f, 1.35767803e-01f, -2.96960119e-02f, -3.12393755e-02f, 4.06765081e-02f, -1.12176687e-02f, 1.38439342e-01f, 1.66407675e-01f, -2.07567558e-01f, 1.16359755e-01f,
  -1.25350162e-01f, -4.61506993e-02f, 3.52819334e-04f, -2.29373008e-01f, -6.31343480e-03f, -1.03708118e-01f, -6.88716844e-02f, -3.08062807e-02f, -5.35415746e-02f, -3.47137786e-02f,
  1.28707990e-01f, 2.96118632e-02f, 6.94242343e-02f, -2.87263258e-03f, 6.29694983e-02f, -1.17124535e-01f, 1.17121805e-02f, -7.05191940e-02f, -2.14866386e-03f, -1.20607704e-01f,
  -2.30052665e-01f, -2.14329679e-02f, 5.12435623e-02f, -1.00860428e-02f, 1.03623390e-01f, 8.72250274e-02f, -1.33727133e-01f, -4.02056091e-02f, 8.17863271e-02f, -6.33632168e-02f,
  -5.51284775e-02f, -2.75211353e-02f, 8.27688649e-02f, -3.05677336e-02f, 2.65134848e-04f, -6.42025396e-02f, 8.88486393e-03f, 2.79729161e-02f, 3.14354971e-02f, -1.77242588e-02f,
  7.01520219e-03f, -5.76722771e-02f, -6.92115352e-02f, 6.35673031e-02f, -9.23650265e-02f, -1.00620598e-01f, 1.05692424e-01f, -6.22773683e-03f, -1.11489698e-01f, -1.61332190e-02f,
  1.65455192e-02f, 1.72385469e-01f, 5.35339117e-02f, -1.52810276e-01f, -1.13669097e-01f, -5.93783008e-03f, 2.89276196e-03f, -4.76298779e-02f, -4.40322682e-02f, -5.19686379e-02f,
  -1.35574281e-01f, -2.66339093e-01f, 7.48769846e-03f, -6.91981465e-02f, 2.49684423e-01f, -9.75957140e-02f, 1.86475255e-02f, -3.08280787e-03f, 6.62760064e-02f, 1.17984833e-02f,
  -1.75759532e-02f, 7.74045065e-02f, -6.87048510e-02f, -6.78899288e-02f, 2.77561128e-01f, 6.35889322e-02f, -2.40033031e-01f, 1.60987619e-02f, -8.85674208e-02f, -1.50992110e-01f,
  -1.49355680e-01f, 4.94807921e-02f, -1.34198125e-02f, 7.13833049e-02f, 7.32392743e-02f, 1.65937364e-01f, -1.60810631e-03f, 3.22308950e-02f, 1.92472816e-01f, -9.43334028e-02f,
  -4.40619498e-01f, -4.07110810e-01f, 7.53663123e-01f, -9.60397646e-02f, 9.94252563e-02f, 1.43596187e-01f, 3.02625686e-01f, 1.02148131e-01f, -2.63520479e-01f, -2.39501670e-02f,
  -1.37746692e-01f, -2.43315041e-01f, -3.44860047e-01f, -7.46878162e-02f, -8.59675463e-04f, 3.08489680e-01f, 3.33742380e-01f, 3.38246703e-01f, 2.92935818e-01f, 8.17733631e-02f,
  -1.11127228e-01f, -1.48907136e-02f, -1.41771257e-01f, -1.22032776e-01f, -1.51310503e-01f, -6.54844865e-02f, 9.95685160e-02f, 6.18835539e-02f, -2.57066756e-01f, 1.08999997e-01f,
  2.67026097e-01f, 7.19035044e-02f, 1.29543453e-01f, -2.87018031e-01f, -6.13326244e-02f, -1.28689498e-01f, 1.55420467e-01f, 7.52340630e-02f, -1.13770701e-01f, 1.08067118e-01f,
  1.54152578e-02f, 4.62783538e-02f, 7.10711032e-02f, -3.22180428e-02f, -1.20691672e-01f, -1.82220608e-01f, -1.53758019e-01f, 1.55231223e-01f, -1.07503189e-02f, -1.29576623e-01f,
  -2.64109313e-01f, -5.65761179e-02f, 5.62989041e-02f, -1.37220789e-02f, -1.02874655e-02f, -9.44633409e-03f, -7.85155967e-02f, -6.46348372e-02f, 3.06842085e-02f, -7.03462362e-02f,
  7.24022184e-03f, 4.89694327e-02f, -7.69586116e-02f, 1.38688028e-01f, -3.83171476e-02f, 4.57426272e-02f, 8.81913770e-03f, 1.20227709e-01f, 3.36935781e-02f, 6.66812062e-02f,
  -5.05204760e-02f, 9.84039605e-02f, 1.29278585e-01f, -6.01654872e-02f, -2.24790797e-01f, -5.30401096e-02f, 1.24262683e-01f, -4.96009104e-02f, 4.99765214e-04f, 2.66161151e-02f,
  -1.28164580e-02f, 1.37440324e-01f, -4.81014140e-02f, 4.47438732e-02f, 1.69849154e-02f, -6.08879812e-02f, -6.47521242e-02f, -2.67926715e-02f, 1.06437653e-01f, -4.75900732e-02f,
  8.47667381e-02f, -1.30887404e-02f, 9.59866568e-02f, 1.58573091e-01f, 2.46998444e-02f, -1.70101330e-01f, -9.84093845e-02f, -5.20481355e-03f, 4.01162989e-02f, 1.19865403e-01f,
  -8.72407574e-03f, 2.94234361e-02f, -3.12404446e-02f, -1.27802506e-01f, 4.84674685e-02f, -1.21847466e-01f, -9.33893099e-02f, 5.90890907e-02f, 9.12443325e-02f, 7.28708580e-02f,
  -8.49454850e-02f, -2.85733398e-02f, 1.56562582e-01f, 2.05696315e-01f, -7.81704262e-02f, 1.47515282e-01f, 5.01429252e-02f, 4.34961170e-02f, 1.17718041e-01f, 8.68352130e-02f,
  2.34302774e-01f, -5.33885479e-01f, -6.99230909e-01f, 8.27940404e-02f, -4.32233095e-01f, -1.14891633e-01f, -3.78347635e-01f, 8.42076838e-02f, 1.73840761e-01f, -5.59440374e-01f,
  -2.15345785e-01f, 2.10461453e-01f, -2.06803262e-01f, -1.85885653e-01f, -4.80125546e-02f, -6.76751256e-01f, -3.83395195e-01f, -1.95650563e-01f, 1.89152792e-01f, 3.47052693e-01f,
  3.42071988e-02f, 1.10668711e-01f, 1.91444188e-01f, 2.94729650e-01f, -2.58578658e-01f, -2.18173966e-01f, -6.10695481e-01f, -3.11826915e-01f, -2.95107454e-01f, -6.61575913e-01f,
  -5.29162884e-01f, -1.31974099e-02f, 1.47174492e-01f, 1.95957676e-01f, -3.38506192e-01f, 1.71479508e-01f, -1.40746012e-01f, -1.47415206e-01f, 1.04841381e-01f, -1.02491811e-01f,
  -2.51839142e-02f, -1.14360696e-03f, -2.28625927e-02f, 1.17005490e-01f, 7.79993609e-02f, -6.03823848e-02f, 3.08233555e-02f, -6.39421269e-02f, -1.30951181e-01f, -5.39153777e-02f,
  -1.26366109e-01f, -3.57484639e-01f, -1.90158680e-01f, 4.80994657e-02f, -1.13763057e-01f, -2.77712587e-02f, -2.63001144e-01f, -1.16903394e-01f, -3.30565870e-01f, -3.55439931e-01f,
  9.35176238e-02f, -8.43941420e-02f, -7.98818693e-02f, 4.84701693e-02f, -1.64193893e-03f, 1.51252598e-02f, -5.66411205e-02f, -1.23243146e-01f, 1.34066090e-01f, 1.73667222e-02f,
  -6.82379380e-02f, -9.65725780e-02f, 1.58817574e-01f, 1.88922964e-03f, -1.25310093e-01f, -2.68995034e-04f, 1.47774797e-02f, -1.50181144e-01f, -1.56575292e-01f, -7.33536854e-02f,
  -1.02558188e-01f, 8.02535042e-02f, -6.55400530e-02f, 8.94983113e-02f, -1.22878008e-01f, -7.15916918e-04f, 2.68081706e-02f, 2.28490252e-02f, 1.08779617e-01f, 1.53698668e-01f,
  9.34927389e-02f, -2.62874812e-01f, -6.59761801e-02f, 4.86562625e-02f, 1.17648371e-01f, -1.26455620e-01f, -3.66673432e-02f, 2.71143243e-02f, 1.20952532e-01f, 2.48412415e-02f,
  -6.08069561e-02f, 6.74442947e-02f, -1.45236477e-02f, 1.07427642e-01f, 3.21784988e-03f, 4.77061719e-02f, -1.45936003e-02f, -1.72801074e-02f, 6.87675327e-02f, -8.59094635e-02f,
  -4.73944433e-02f, -8.41264650e-02f, 8.80998597e-02f, 6.71577603e-02f, -2.71319095e-02f, 6.96405545e-02f, -1.28626123e-01f, -4.38992567e-02f, 1.43439963e-01f, 3.04984394e-02f,
  -7.38976121e-01f, -9.28819552e-02f, 3.75976056e-01f, -2.20873073e-01f, 1.51208133e-01f, 3.55232447e-01f, -6.23852201e-02f, 5.89721315e-02f, 9.67880432e-03f, -2.92267412e-01f,
  1.79435313e-02f, 2.55831853e-02f, 2.27630474e-02f, 9.09753330e-03f, -2.17725456e-01f, -5.90102188e-02f, -1.47928238e-01f, -1.50378346e-01f, 1.07346766e-01f, 1.41491875e-01f,
  -1.64916832e-02f, -3.08183670e-01f, -3.11284810e-01f, -2.43633613e-01f, -4.07337785e-01f, -3.07706475e-01f, -2.42374331e-01f, -2.43321866e-01f, -1.67926252e-01f, -5.37288487e-01f,
  -9.00519565e-02f, -1.00552598e-02f, 3.33775640e-01f, -2.60383815e-01f, 1.23363160e-01f, 5.11152819e-02f, -1.46217525e-01f, -8.44739750e-02f, 3.03515233e-02f, -9.38594788e-02f,
  -1.05362244e-01f, 1.73919648e-01f, -5.03714234e-02f, -1.12780081e-02f, -1.61617652e-01f, -1.11076720e-01f, 1.12408444e-01f, 1.87745884e-01f, 4.70553903e-04f, 1.49963334e-01f,
  -2.90567204e-02f, -2.32461706e-01f, -4.77868944e-01f, 2.02976540e-01f, 4.38330501e-01f, 1.74699381e-01f, 5.24594486e-02f, 3.75668854e-02f, 2.25089595e-01f, -5.75777054e-01f,
  -6.00878112e-02f, 1.92911416e-01f, 2.08081171e-01f, 7.64949843e-02f, 5.63001446e-02f, 3.44978496e-02f, 1.69228148e-02f, -1.22276127e-01f, 4.17812727e-02f, -1.02675833e-01f,
  9.05862600e-02f, 1.07012093e-01f, 7.65621960e-02f, -7.07726851e-02f, 1.83880161e-02f, 4.97198999e-02f, -1.28416523e-01f, -1.80641357e-02f, -1.19764976e-01f, -1.08423252e-02f,
  -1.34535879e-01f, -2.34528556e-02f, 8.94622430e-02f, -3.56231406e-02f, 3.71307284e-02f, -8.98901373e-02f, 5.16197942e-02f, 7.68224224e-02f, 5.87446764e-02f, 1.78067058e-01f,
  -1.81637079e-01f, 3.17687184e-01f, -2.18552589e-01f, 8.04745406e-02f, -2.66682088e-01f, 9.94727537e-02f, 8.09846818e-02f, 5.71089573e-02f, -8.16430748e-02f, -2.45180041e-01f,
  1.51589915e-01f, 8.80768429e-03f, 7.64814345e-03f, 2.04750240e-01f, -9.20300744e-03f, -6.05043247e-02f, -2.20169798e-01f, 1.95383485e-02f, -7.13782609e-02f, 4.82504554e-02f,
  -7.49236643e-02f, -3.09517771e-01f, -6.61764801e-01f, -1.71521664e-01f, -1.35209516e-01f, -4.34649676e-01f, -2.95994252e-01f, -3.09055209e-01f, -2.42284387e-01f, -5.05637228e-01f,
  -2.30691075e-01f, 3.29872817e-01f, 7.40089267e-02f, -1.40528604e-01f, 5.25148630e-01f, 2.34442130e-01f, 6.37398243e-01f, -6.88719526e-02f, -5.59855819e-01f, 4.81124036e-02f,
  2.38675416e-01f, -3.99798512e-01f, -2.91500390e-01f, -1.64948165e-01f, 1.35965779e-01f, 3.36430311e-01f, 2.73902535e-01f, -6.27782494e-02f, -3.44315052e-01f, -1.19676478e-01f,
  1.16116755e-01f, -3.88003290e-02f, -4.08673197e-01f, -2.21924350e-01f, -8.45964476e-02f, -3.90496701e-01f, -6.12807348e-02f, 1.01771221e-01f, 3.14662397e-01f, 1.44607469e-01f,
  -3.17353904e-01f, 2.03709334e-01f, 2.17206076e-01f, 1.83046982e-01f, 6.00149343e-03f, -4.54641879e-02f, 8.48437846e-03f, -8.76012892e-02f, -1.52540058e-01f, -2.04494819e-02f,
  2.03119237e-02f, 1.48023680e-01f, -4.42087911e-02f, 3.83694842e-02f, -3.14414203e-02f, 4.37963344e-02f, -1.12282209e-01f, 1.86968036e-02f, -1.23570919e-01f, -1.79157212e-01f,
  3.11066329e-01f, 2.65161186e-01f, -2.30240021e-02f, 5.73907681e-02f, -8.52425024e-02f, -8.29193220e-02f, 9.21574458e-02f, -2.51403838e-01f, -3.33541855e-02f, -2.57228702e-01f,
  2.44907334e-01f, 1.99966908e-01f, 1.52967930e-01f, -2.36517936e-02f, -5.67982625e-03f, 1.39869163e-02f, -1.24413148e-02f, -7.92806596e-02f, 7.87725374e-02f, -8.83427784e-02f,
  -4.94010374e-02f, 3.23540010e-02f, -5.38777485e-02f, -7.31536895e-02f, 2.83829570e-02f, -3.80324349e-02f, 1.87988088e-01f, 1.53663233e-02f, -9.93577912e-02f, -1.95858777e-01f,
  -1.28684521e-01f, 5.49802966e-02f, -1.58988968e-01f, -6.34986237e-02f, 6.91105053e-02f, 1.30628990e-02f, 6.94821402e-02f, 2.63670594e-01f, 4.59526405e-02f, 1.59269542e-01f,
  -8.72409940e-01f, 4.37670499e-01f, -3.37193608e-01f, 6.30902573e-02f, -7.19707161e-02f, 4.26528081e-02f, 9.25952569e-04f, 1.13846615e-01f, 1.09560639e-01f, 4.24154848e-02f,
  -1.00457878e-03f, 1.53757380e-02f, -4.73443307e-02f, -1.17877787e-02f, -5.71058579e-02f, -3.96115705e-02f, 1.42772496e-01f, 5.47488779e-02f, -1.84838064e-02f, -4.08561081e-02f,
  6.14956617e-02f, -3.39209735e-02f, -2.02127978e-01f, -1.43803284e-01f, -1.06856935e-01f, -6.55160397e-02f, -1.15669593e-01f, -1.82459101e-01f, -2.82010227e-01f, -3.35156441e-01f,
  5.99308193e-01f, 6.64164007e-01f, 3.79629642e-01f, 3.47064704e-01f, 2.66381323e-01f, 7.45182559e-02f, 3.86689156e-01f, 4.00042236e-02f, -2.69690573e-01f, 2.24437743e-01f,
  2.13462442e-01f, -8.86705592e-02f, -1.62809491e-01f, -1.22203521e-01f, 3.09256632e-02f, 2.27144033e-01f, 1.27761751e-01f, 7.70364031e-02f, -1.65965319e-01f, 9.07048583e-02f,
  2.09159195e-01f, 1.71394765e-01f, 1.63949564e-01f, 4.54030447e-02f, 4.12810922e-01f, -2.42394105e-01f, -4.16283607e-02f, 2.71161824e-01f, 6.77440539e-02f, 3.98781568e-01f,
  4.19277042e-01f, 4.07707274e-01f, -3.27407449e-01f, 1.96892433e-02f, 5.01646250e-02f, -2.06109732e-01f, -1.21041648e-01f, -9.40507874e-02f, -2.55448759e-01f, -9.64776129e-02f,
  1.95114061e-01f, 1.16366744e-02f, 1.00411765e-01f, -9.74969342e-02f, -7.04226457e-03f, -9.36805755e-02f, -1.76285803e-01f, 8.06706306e-03f, -1.99777707e-01f, -5.56329684e-03f,
  1.02632947e-01f, 2.54576445e-01f, 3.22837830e-02f, -3.57681900e-01f, -7.62354769e-03f, -1.25665024e-01f, 4.52689417e-02f, 5.02417870e-02f, -1.60696357e-01f, -1.02988355e-01f,
  -2.38558143e-01f, -6.13850951e-02f, 2.26133894e-02f, -1.19862147e-01f, -1.31971925e-01f, -1.01410337e-01f, 1.06624858e-02f, 6.52641356e-02f, -1.96771808e-02f, -2.45020017e-01f,
  -1.70157269e-01f, -9.38449171e-04f, 4.67372350e-02f, -9.59326923e-02f, 4.84989807e-02f, 1.19891584e-01f, -8.81085843e-02f, -8.50411728e-02f, -7.39679411e-02f, -1.21333942e-01f,
  -4.93656769e-02f, -3.47915366e-02f, -2.18870547e-02f, -4.78862859e-02f, -1.33953929e-01f, 1.88446417e-02f, -5.33747599e-02f, -1.31111428e-01f, -1.90835223e-01f, 7.79384933e-03f,
  -4.23526704e-01f, -3.04359972e-01f, -1.05306190e-02f, 1.46112546e-01f, 1.39013946e-01f, 2.38885935e-02f, 1.63226157e-01f, 1.13561787e-01f, 1.49368182e-01f, 7.62018785e-02f,
  2.43725926e-01f, 3.91516872e-02f, 3.31507549e-02f, -1.57256067e-01f, -1.86887145e-01f, -8.87348801e-02f, -5.17821647e-02f, -2.33798679e-02f, -1.24099851e-01f, 1.06586769e-01f,
  5.30800670e-02f, -2.05723092e-01f, -2.99336284e-01f, -2.05981493e-01f, -9.24152359e-02f, -2.57930875e-01f, -2.99474418e-01f, -1.71659738e-01f, -3.54456961e-01f, -4.74750042e-01f,
  -1.17738128e+00f, -2.60283738e-01f, -2.41604030e-01f, -2.80102432e-01f, 5.64483166e-01f, 2.23813757e-01f, 1.15548521e-01f, -4.32504058e-01f, -3.19501549e-01f, -2.86904965e-02f,
  2.03116760e-01f, 1.20397799e-01f, 7.04826340e-02f, 1.04368076e-01f, -1.36928529e-01f, 7.24222735e-02f, 4.12119538e-01f, -7.67098367e-02f, -1.94729567e-01f, 8.91721323e-02f,
  4.71386045e-01f, -2.19947509e-02f, -3.22676957e-01f, 5.29020503e-02f, 1.44251972e-01f, 1.15415059e-01f, -3.41171362e-02f, 8.35506022e-02f, 5.04504144e-01f, 4.99261290e-01f,
  -1.34523034e-01f, -4.45767522e-01f, 1.33016482e-01f, -7.62379728e-03f, 4.55890708e-02f, -4.15646911e-01f, -1.74746454e-01f, 9.35676508e-03f, -5.80902025e-02f, -5.18671237e-02f,
  3.34521443e-01f, -7.13137537e-02f, 3.26572955e-01f, -4.77306545e-02f, -1.91597849e-01f, -2.60095179e-01f, -2.38234758e-01f, -2.74287909e-01f, -3.72033298e-01f, -4.23781842e-01f,
  5.17443180e-01f, 4.76748347e-01f, -1.64286882e-01f, -3.12218070e-02f, -4.95399274e-02f, 2.58620441e-01f, -5.84354550e-02f, -2.05511764e-01f, -3.25770110e-01f, -5.99284232e-01f,
  -5.94506562e-02f, -6.03543445e-02f, -5.25566451e-02f, -1.96561083e-01f, 3.47565138e-03f, 1.29755199e-01f, 1.28619567e-01f, 2.40061924e-01f, 2.41570234e-01f, -1.78240344e-01f,
  -4.99299839e-02f, -5.00597507e-02f, -4.63179834e-02f, -1.63173944e-01f, 3.59328724e-02f, -7.53903911e-02f, -1.08561777e-02f, -4.25595120e-02f, 1.58264078e-02f, -1.33525897e-02f,
  1.27562851e-01f, 1.68375790e-01f, -2.56484985e-01f, 3.13688368e-02f, 1.41696865e-02f, -9.17918384e-02f, -5.68794720e-02f, -3.27393934e-02f, -3.01254749e-01f, -6.76781088e-02f,
  -6.55649185e-01f, 5.12285769e-01f, -1.60013914e-01f, -1.23547554e-01f, 8.58405381e-02f, 1.33785396e-03f, 1.56575754e-01f, 2.67668744e-03f, -6.56126663e-02f, -1.91178679e-01f,
  -1.93618536e-02f, -4.33847196e-02f, 7.31208026e-02f, 5.51935770e-02f, 1.88641511e-02f, 1.75901558e-02f, 3.99756767e-02f, 2.36692131e-02f, -3.98873650e-02f, -6.35601506e-02f,
  8.68618265e-02f, -1.43609956e-01f, -3.43746543e-01f, -2.81131238e-01f, -1.09468333e-01f, -1.92278817e-01f, -3.81498486e-02f, -1.65492892e-01f, -1.98797300e-01f, -5.64751804e-01f,
  1.45196274e-01f, -1.28963366e-01f, 5.45931399e-01f, 1.97235554e-01f, -3.75520140e-02f, -5.24211943e-01f, -1.02588964e+00f, -6.48859978e-01f, 7.23910704e-03f, -1.34108201e-01f,
  -1.89126313e-01f, 2.04640359e-01f, 3.01184684e-01f, 9.26899761e-02f, -4.00187761e-01f, -1.98946342e-01f, 2.92055488e-01f, 3.61000955e-01f, -3.91188189e-02f, -3.70071828e-01f,
  -2.26453736e-01f, 1.58279747e-01f, 4.25147563e-01f, -1.14511073e-01f, 7.70946816e-02f, -9.53029376e-03f, 2.46244982e-01f, 1.01683155e-01f, -1.19650111e-01f, 6.63526893e-01f,
  4.44385797e-01f, -5.87483048e-02f, -1.52801713e-02f, 9.88208354e-02f, 2.11028323e-01f, -7.79952034e-02f, 1.21006317e-01f, 2.46747151e-01f, 3.78254354e-02f, 1.18487395e-01f,
  5.73981702e-02f, 1.25875756e-01f, 1.64065018e-01f, -1.55436434e-02f, -1.00739442e-01f, -2.54326463e-01f, 9.77838039e-02f, 1.35353416e-01f, 1.57980695e-01f, -6.37012944e-02f,
  8.15457702e-02f, -4.39755805e-02f, 8.57310072e-02f, -3.18148702e-01f, -2.60918766e-01f, 2.56662637e-01f, -3.62595856e-01f, -2.61779758e-03f, -2.64391720e-01f, -8.01830813e-02f,
  -7.95442536e-02f, 1.77190825e-01f, 6.76194802e-02f, 9.91031751e-02f, -3.74324843e-02f, 1.53738009e-02f, 4.30282615e-02f, -1.53256590e-02f, -7.54500851e-02f, -9.84314159e-02f,
  5.08629624e-03f, 1.42193228e-01f, -2.16433574e-02f, 9.20765474e-02f, 5.20163327e-02f, 1.33815572e-01f, -9.23599750e-02f, -1.48271807e-02f, 6.98549598e-02f, -3.77471535e-03f,
  -1.91989746e-02f, -5.36529273e-02f, 5.28185219e-02f, -2.94387471e-02f, -1.06613547e-01f, 8.37066993e-02f, 4.21134047e-02f, -1.02658160e-01f, 1.28795952e-01f, 2.58922994e-01f,
  -1.42463252e-01f, -1.94705576e-02f, 1.59197599e-01f, -3.23480256e-02f, -6.85974658e-02f, -1.07051030e-01f, 1.25513729e-02f, -3.29870917e-02f, 1.34521455e-01f, -1.57243133e-01f,
  -2.22240120e-01f, 4.49921601e-02f, -1.29648983e-01f, -2.56142411e-02f, -6.08361773e-02f, 2.66363025e-02f, -2.16056895e-03f, -1.92355290e-02f, -2.02568658e-02f, 1.93723589e-02f,
  -5.75627163e-02f, -3.35623473e-01f, -3.36363524e-01f, -8.53473917e-02f, -1.99825600e-01f, -1.34455040e-01f, -2.52921700e-01f, -1.29751533e-01f, -3.41906041e-01f, -6.18276179e-01f,
  -4.09534007e-01f, -3.96202445e-01f, -1.65245742e-01f, 4.69212532e-01f, 5.64682245e-01f, 3.51563185e-01f, 1.96205929e-01f, 2.37066105e-01f, 2.63905942e-01f, 1.05047368e-01f,
  -7.32840076e-02f, 3.63381356e-01f, 3.43651056e-01f, 1.84004560e-01f, 7.05341548e-02f, 2.80830383e-01f, 4.02386159e-01f, 9.55485925e-02f, 1.55027255e-01f, -1.32852737e-02f,
  2.79690564e-01f, 1.64828941e-01f, -2.59586304e-01f, -2.04982366e-02f, -3.69816646e-02f, 3.00413758e-01f, 1.67379007e-01f, -8.68137106e-02f, 7.99832270e-02f, -1.55605108e-01f,
  -2.97736704e-01f, -3.01012486e-01f, 2.67391592e-01f, 1.30780831e-01f, -2.16180369e-01f, -1.22724786e-01f, -1.24406656e-02f, -1.81474969e-01f, -1.86247513e-01f, -6.43406808e-02f,
  -5.75598069e-02f, -1.57684177e-01f, 8.74426067e-02f, -1.40163168e-01f, 1.90067547e-03f, 2.65143556e-03f, -8.21888000e-02f, 6.28180131e-02f, 1.68034524e-01f, 3.64729129e-02f,
  6.62943646e-02f, 9.06014070e-03f, -3.53076458e-02f, 7.35008866e-02f, -9.54919383e-02f, 1.85067803e-01f, -1.94418430e-01f, -7.92551637e-02f, -1.62764303e-02f, -2.39332393e-01f,
  1.46048650e-01f, -4.25356664e-02f, -1.21008717e-02f, -1.07228626e-02f, -7.31835216e-02f, -1.21523244e-02f, -4.33873795e-02f, -1.14995740e-01f, 1.02126665e-01f, -2.56507516e-01f,
  1.45596921e-01f, 1.06882177e-01f, -1.81432553e-02f, 1.96233854e-01f, 5.54198362e-02f, 2.06619524e-03f, -8.91387314e-02f, 2.18470823e-02f, -5.54258674e-02f, 5.97457364e-02f,
  -1.26065567e-01f, -2.69183423e-02f, -3.66373621e-02f, -1.57453939e-01f, 1.68887079e-02f, -9.41312965e-03f, -3.24108154e-02f, -4.13798876e-02f, 7.42195174e-02f, 6.72474876e-02f,
  3.82260621e-01f, 1.23589940e-01f, 1.54909920e-02f, -5.56904227e-02f, -9.68176425e-02f, -1.71470076e-01f, 1.42542213e-01f, 2.84707472e-02f, -1.84555184e-02f, -1.63641218e-02f,
  -1.66531384e-01f, -8.19087029e-02f, -2.59091854e-02f, -1.34690240e-01f, -5.54990955e-02f, 5.15210093e-04f, -1.03387460e-01f, -2.34161653e-02f, 5.25274388e-02f, -1.23665586e-01f,
  -1.43093839e-01f, -7.58746713e-02f, 1.12364002e-01f, -7.92139734e-04f, 8.43722746e-02f, 1.94428846e-01f, -1.11432560e-01f, 1.33304661e-02f, -5.82589619e-02f, -1.98891580e-01f,
  8.76512825e-01f, -6.64634854e-02f, 1.26816243e-01f, 2.45679915e-01f, -2.73782760e-02f, 2.10351065e-01f, -2.03254167e-02f, -1.44685274e-02f, 9.95031595e-02f, 2.90727876e-02f,
  1.89572603e-01f, 2.41837099e-01f, 3.01238596e-01f, 1.31800219e-01f, 1.39526367e-01f, -6.05921820e-02f, -1.44685507e-01f, 1.53824449e-01f, 2.09005356e-01f, 7.16284215e-02f,
  -1.25866547e-01f, -7.67561272e-02f, 1.40861541e-01f, -8.20468441e-02f, -2.16776773e-01f, 1.09372705e-01f, 1.96527112e-02f, 2.15757755e-03f, -2.41686068e-02f, -3.30576211e-01f,
  2.85459787e-01f, 2.43299857e-01f, 2.82016158e-01f, 8.09089541e-02f, -1.35658756e-01f, 8.34921673e-02f, 5.48403710e-02f, -9.41977501e-02f, -1.34348333e-01f, -7.74642499e-03f,
  1.41438078e-02f, -1.13141760e-01f, -4.72884439e-02f, -3.87957767e-02f, -5.75484484e-02f, 4.24462892e-02f, -1.45946129e-03f, 8.26005191e-02f, 1.30139947e-01f, -7.70831108e-02f,
  -1.31501406e-01f, 3.92436944e-02f, 2.49675050e-01f, 1.25905216e-01f, -2.16623582e-02f, 1.81869000e-01f, 5.88991456e-02f, 2.31194831e-02f, 1.48537815e-01f, 7.17910081e-02f,
  3.79823744e-02f, 1.51004165e-01f, 4.09912840e-02f, 2.56879255e-02f, -1.63582414e-01f, -3.85453179e-02f, 4.35800441e-02f, 1.16571270e-01f, 7.66979530e-02f, -2.66011059e-01f,
  1.43591110e-02f, 1.46098062e-01f, 2.43160743e-02f, 1.37777388e-01f, 4.12018374e-02f, -8.65917355e-02f, -7.15158954e-02f, 1.52988583e-02f, -9.02879536e-02f, -3.32150571e-02f,
  -1.88618377e-02f, 7.31109306e-02f, -1.66196629e-01f, -1.38734311e-01f, 8.01026300e-02f, 7.65612200e-02f, -4.61240336e-02f, -2.76322793e-02f, -2.94633284e-02f, -7.74236172e-02f,
  -4.54959422e-02f, 4.52174097e-01f, 4.68684807e-02f, -1.03018947e-01f, 4.81656678e-02f, -1.09678924e-01f, 1.23900115e-01f, 2.19633710e-02f, -7.19429553e-02f, -1.11223169e-01f,
  2.18545040e-03f, -6.18902296e-02f, -6.95216358e-02f, -1.01022668e-01f, -1.08713783e-01f, -6.27948865e-02f, -1.77260265e-01f, 1.69215038e-01f, -1.74113903e-02f, -9.45904106e-02f,
  -1.99786052e-01f, 5.16385697e-02f, 1.95075855e-01f, 8.89964327e-02f, -1.27418339e-01f, 1.33374855e-01f, -8.99332315e-02f, -3.50618474e-02f, 1.69287533e-01f, -8.86945203e-02f,
  7.95604110e-01f, 5.41319072e-01f, 3.55045080e-01f, 2.29733303e-01f, 1.94203749e-01f, 1.94615602e-01f, 3.78695905e-01f, 1.50946215e-01f, -2.27705657e-01f, 1.14143759e-01f,
  1.59608856e-01f, -1.70507789e-01f, -2.08199337e-01f, -2.18896985e-01f, 1.03312105e-01f, 1.52467296e-01f, 8.93150568e-02f, 7.41260424e-02f, -1.37146236e-02f, 6.40707463e-02f,
  7.73132816e-02f, 5.94715662e-02f, 1.91510126e-01f, -2.65744198e-02f, 9.94156823e-02f, -3.83285493e-01f, 1.15624731e-02f, 1.64226502e-01f, 3.18444520e-02f, -7.83344638e-03f,
  2.05552056e-01f, 5.96620858e-01f, -2.38214910e-01f, -7.34349191e-02f, -3.35152745e-02f, -1.12115897e-01f, -1.46991745e-01f, -9.92260948e-02f, -1.14877500e-01f, -1.12402909e-01f,
  -5.02244271e-02f, -2.97810547e-02f, 2.28094831e-01f, 6.61017895e-02f, 8.78356397e-02f, -9.10141040e-03f, 1.31318916e-03f, 2.24790990e-01f, -3.73585522e-02f, 1.15271427e-01f,
  1.64135724e-01f, 1.87990144e-01f, 2.71276653e-01f, -2.46666055e-02f, 2.31099308e-01f, 3.05857137e-03f, 1.39777318e-01f, 7.33154789e-02f, 3.03110611e-02f, 8.24482441e-02f,
  1.47494406e-01f, 1.07236065e-01f, -2.50308923e-02f, 7.86089003e-02f, 1.24576099e-01f, 7.70319328e-02f, -2.83717625e-02f, 6.07448854e-02f, 4.36780155e-02f, 6.03704527e-02f,
  3.49019095e-02f, -8.03094078e-03f, 2.84389639e-03f, 4.31125576e-04f, -7.09637105e-02f, 6.05607443e-02f, -7.96908215e-02f, -9.50232521e-03f, 8.77119824e-02f, -7.94373602e-02f,
  -1.75261591e-02f, -2.97950916e-02f, -3.86469066e-02f, 4.65185307e-02f, -6.86207637e-02f, 4.61704172e-02f, -5.57308085e-02f, -3.16983485e-03f, 3.74385603e-02f, 4.46588621e-02f,
  -7.45404243e-01f, 1.74639057e-02f, 2.11107302e-02f, -1.30329937e-01f, 8.24159011e-03f, 1.31614609e-02f, 7.78174326e-02f, -3.47619057e-02f, -9.01916921e-02f, -7.38995373e-02f,
  3.29678692e-02f, -5.15329167e-02f, 1.84072778e-01f, 1.56795196e-02f, -9.04938430e-02f, -9.76091251e-02f, -9.40730423e-02f, -9.85223427e-02f, -1.53893277e-01f, -1.68656960e-01f,
  -9.64440480e-02f, -1.98828742e-01f, -3.53200793e-01f, -2.13081434e-01f, -4.34273742e-02f, -2.21182674e-01f, -2.75770724e-01f, -1.67416885e-01f, -1.92377403e-01f, -2.71656841e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.09316546e-01f, -6.23365641e-02f, 7.92787254e-01f, 1.55913249e-01f, 4.29494798e-01f, 3.46693277e-01f, 3.47427279e-01f, 5.12038589e-01f, 4.26303685e-01f, 8.41720641e-01f,
  2.63574123e-01f, 9.32796821e-02f, -3.74904066e-01f, 1.66418374e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -4.13245196e-03f, 1.98699698e-01f, -2.57383138e-01f, -2.22404927e-01f, 3.65264207e-01f, 1.86058372e-01f, 1.32341802e-01f, -2.77405649e-01f, -5.51463723e-01f, 4.01713848e-02f,
  1.72114037e-02f, -1.60660908e-01f, 2.90955871e-01f, -7.85121694e-02f, -1.93648338e-01f, 2.53548115e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.00964129e-01f, -3.30807239e-01f, -5.67299724e-02f, -2.79294819e-01f, 3.45630825e-01f, 1.06294956e-02f, 2.47400433e-01f, 2.05682293e-01f, 6.39244676e-01f, 5.42658329e-01f,
  -8.42738897e-02f, 8.52561593e-01f, -1.37282670e-01f, 3.95888835e-01f, -1.49820819e-01f, -6.94462359e-02f, -5.75407371e-02f, -9.19424474e-01f, -3.54307175e-01f, -2.78369993e-01f,
  5.11313140e-01f, -1.02501595e+00f, 2.05941778e-02f, 1.43824920e-01f, 4.86986041e-01f, 1.62489980e-01f, -2.44510859e-01f, 2.19485629e-02f, -5.03999114e-01f, -3.73904347e-01f,
  -6.00748956e-01f, -2.31500193e-01f, 6.85764194e-01f, -5.03335118e-01f, 6.26776695e-01f, -2.30621010e-01f, 1.24494238e-02f, -6.38515472e-01f, -3.46948236e-01f, 4.52320904e-01f,
  1.12026691e-01f, -6.70194924e-01f, -9.37115103e-02f, -3.82114649e-02f, -1.46031380e-01f, -2.29684904e-01f, -1.23415999e-01f, -6.83865845e-01f, 4.70038474e-01f, -1.91885173e-01f,
  7.27231145e-01f, 6.50042342e-03f, -2.27035806e-01f, -2.51009703e-01f, -7.14229822e-01f, 6.72563195e-01f, 1.02523088e-01f, -1.57262474e-01f, 1.80168748e-01f, -1.64748371e-01f,
  -3.98993641e-01f, 3.27861756e-01f, -1.11791357e-01f, 2.57741630e-01f, -1.55780548e-02f, -5.65531969e-01f, -2.65753895e-01f, -3.62341970e-01f, 6.11346364e-01f, -1.03430974e+00f,
  -1.46216303e-01f, -4.70536985e-02f, 4.17677790e-01f, 3.33083242e-01f, -2.87421763e-01f, 1.12754904e-01f, -1.12493610e+00f, -2.47903511e-01f, -4.35853630e-01f, -4.36414391e-01f,
  -3.26074623e-02f, -9.52850878e-02f, -4.30772960e-01f, -8.81881046e-04f, -1.36063546e-01f, -2.78792202e-01f, -4.11141932e-01f, 3.49341929e-01f, 5.77977121e-01f, 3.28623086e-01f,
  -1.46376610e-01f, 7.69242167e-01f, 5.83110988e-01f, 5.58563352e-01f, -5.86445034e-01f, -2.92534530e-01f, 6.73812032e-02f, -4.57742624e-02f, 1.56581044e-01f, 3.32216531e-01f,
  7.74253428e-01f, 1.89170286e-01f, 4.96365577e-01f, -4.89181280e-02f, 1.09523624e-01f, 4.64787781e-01f, -4.93739694e-01f, 4.00334924e-01f, -1.07127488e+00f, 5.84297299e-01f,
  -1.28363311e-01f, -3.39108914e-01f, 1.00919163e+00f, -2.81374931e-01f, 9.74461511e-02f, 4.47985202e-01f, -3.18645835e-01f, -1.22783802e-01f, -1.20588563e-01f, -2.04265937e-01f,
  -4.98759896e-02f, 5.78330040e-01f, 4.72366601e-01f, 5.87097526e-01f, 5.06119505e-02f, 2.77305525e-02f, -3.13844711e-01f, 3.61394018e-01f, 3.12112808e-01f, -6.11418784e-01f,
  4.25574511e-01f, -4.37455982e-01f, 7.78771996e-01f, -5.32973528e-01f, -2.49892384e-01f, 2.53564566e-01f, -3.92873660e-02f, 1.01932608e-01f, 8.94648023e-03f, 7.17611238e-02f,
  -8.38277280e-01f, 3.05894166e-01f, -2.03969538e-01f, -4.64753509e-02f, 4.87315118e-01f, 4.02800292e-01f, -2.66300470e-01f, 1.00083232e-01f, -2.39332557e-01f, -1.11618072e-01f,
  1.51767209e-02f, 2.90221930e-01f, 8.90846327e-02f, 3.41023505e-01f, 5.95444679e-01f, 6.06630325e-01f, 1.18535173e+00f, -3.13843250e-01f, -5.13845026e-01f, 3.97058487e-01f,
  7.29947925e-01f, 1.49803748e-02f, 1.80008918e-01f, 7.96531513e-02f, -2.72624373e-01f, -2.37055235e-02f, -1.93892255e-01f, 4.99228090e-01f, -1.27282552e-02f, 4.84620631e-01f,
  2.53098477e-02f, 4.66972947e-01f, -5.88001251e-01f, 1.31451115e-01f, 2.04515547e-01f, 3.45531136e-01f, 6.27528690e-03f, 1.53364697e-02f, 5.06116629e-01f, 2.44500607e-01f,
  -4.94531870e-01f, 2.11338652e-03f, 1.24697194e-01f, 3.04106653e-01f, -1.20461427e-01f, 2.42374372e-02f, 3.22867483e-01f, -3.75751376e-01f, -1.00757368e-01f, -3.01388800e-01f,
  6.01092428e-02f, 6.55834734e-01f, 7.69189820e-02f, -1.15454048e-01f, 6.60262764e-01f, 2.96369106e-01f, 7.54271388e-01f, 2.11277097e-01f, 7.85388291e-01f, 1.06660925e-01f,
  -1.19300537e-01f, 2.74378031e-01f, 1.54210374e-01f, -7.40522668e-02f, -5.33220649e-01f, 4.12582546e-01f, 7.63625801e-02f, 2.89933175e-01f, -3.11126977e-01f, 4.39066440e-02f,
  -4.43631858e-01f, -2.02866361e-01f, -3.41530353e-01f, -2.18270451e-01f, 4.35788900e-01f, 3.92019600e-01f, 6.96848214e-01f, -1.54119894e-01f, -1.32630691e-01f, -1.67107247e-02f,
  2.04050794e-01f, 3.78499717e-01f, 3.70020479e-01f, -6.10696375e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.58799446e-01f, 1.15756905e+00f, 7.86328092e-02f, 1.60953868e-02f, 9.29493606e-01f, 6.30119443e-01f, 2.27317244e-01f, 2.14718655e-02f, 4.83734429e-01f, 7.65428483e-01f,
  -3.42049934e-02f, 1.38132751e-01f, 2.97607742e-02f, 2.76077360e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.37075763e-02f, -2.85189658e-01f, -1.96784362e-01f, -1.38852507e-01f, -1.67136475e-01f, 1.92769304e-01f, -1.07401207e-01f, 1.49178118e-01f, -5.59239276e-02f, 2.65490562e-01f,
  1.86575040e-01f, 9.18136537e-02f, -1.36421353e-01f, 4.71649170e-02f, -1.45777300e-01f, -3.58957887e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.56467575e-01f, 1.67739958e-01f, -5.00519156e-01f, -1.11059821e+00f, -9.17961895e-01f, -4.27865833e-01f, -1.24802482e+00f, 3.46331537e-01f, -2.96734184e-01f, 3.32525671e-01f,
  -6.99272811e-01f, 8.64235342e-01f, 2.35584751e-02f, 9.32149962e-02f, -2.60333449e-01f, 5.80340698e-02f, -6.16658991e-03f, 9.33047116e-01f, 4.33464378e-01f, 2.98255354e-01f,
  -2.57803082e-01f, -2.94111609e-01f, 2.32834429e-01f, 3.20226252e-01f, 4.59380865e-01f, -1.30163774e-01f, 2.91451544e-01f, 4.49869126e-01f, -2.83943355e-01f, -2.29527012e-01f,
  3.67844850e-01f, 1.47928447e-01f, 4.55980539e-01f, -2.87106454e-01f, 4.25041378e-01f, -3.02838266e-01f, 4.05158699e-01f, 4.85940605e-01f, -2.43523657e-01f, -2.17310473e-01f,
  6.02696717e-01f, 3.51353198e-01f, 5.99983037e-01f, -3.13926637e-01f, 2.06374243e-01f, 1.82846814e-01f, 3.30162346e-01f, -3.09808940e-01f, 2.39020273e-01f, 1.13835908e-01f,
  4.24232185e-01f, 2.71582276e-01f, 1.85160190e-01f, 3.31954181e-01f, 1.77839637e-01f, 9.16776061e-01f, -5.67755759e-01f, -1.38224438e-01f, -2.08926395e-01f, 3.90439093e-01f,
  1.28401676e-02f, -8.39432657e-01f, -7.50848532e-01f, 4.15469795e-01f, -1.96247563e-01f, 3.69655758e-01f, -2.14179426e-01f, -2.89777398e-01f, 1.25277340e-02f, -2.41127253e-01f,
  -4.15511847e-01f, -1.30868450e-01f, -1.09440004e-02f, 6.57750010e-01f, -4.69257891e-01f, 4.02521282e-01f, 4.21594501e-01f, 2.83929884e-01f, -9.37034413e-02f, -8.60573292e-01f,
  7.37447441e-02f, -4.62673515e-01f, 1.85535192e-01f, -4.58187729e-01f, 4.80614901e-01f, 2.34349534e-01f, -1.76505476e-01f, -1.39603734e-01f, 2.20715806e-01f, 6.27415478e-02f,
  6.88966364e-02f, -1.42582744e-01f, 2.51480460e-01f, 4.42753553e-01f, 3.29052657e-02f, 2.60926604e-01f, 5.52803338e-01f, 4.56328243e-01f, -3.64209205e-01f, -8.74396503e-01f,
  -3.96789879e-01f, -4.95349973e-01f, -9.64907646e-01f, -8.27716708e-01f, 1.83962420e-01f, 3.06419998e-01f, -2.25509256e-01f, 4.46994781e-01f, 1.67832449e-01f, 4.37762499e-01f,
  3.63305032e-01f, -6.49694562e-01f, 1.21121466e+00f, 3.68386567e-01f, 5.40592253e-01f, 5.52197516e-01f, 6.76202253e-02f, 1.76695704e-01f, 9.88805592e-01f, 2.59708464e-01f,
  5.55830121e-01f, 7.26469681e-02f, 6.92422152e-01f, 9.55678448e-02f, 1.53078362e-01f, -5.74361920e-01f, -6.78867772e-02f, -3.15528333e-01f, 5.12425184e-01f, -9.38213170e-01f,
  4.05416228e-02f, 2.19740748e-01f, 7.68889844e-01f, 8.10338914e-01f, -2.70595551e-01f, -1.22836500e-01f, -4.89335001e-01f, -4.56438586e-03f, 1.00872748e-01f, 1.65393487e-01f,
  9.31051448e-02f, 4.26390350e-01f, -2.31674849e-03f, 4.95448336e-02f, -1.65306047e-01f, 5.61619513e-02f, 6.85979575e-02f, 8.84055272e-02f, 5.61158419e-01f, 2.70465523e-01f,
  1.20803855e-01f, -7.09397420e-02f, 4.26721454e-01f, 4.16180938e-01f, 3.37047011e-01f, 1.23101808e-01f, 2.21462354e-01f, 3.27693939e-01f, 4.00025368e-01f, -5.67272186e-01f,
  1.30136371e-01f, 6.36530936e-01f, 1.78910345e-01f, 4.42983210e-02f, -8.55678380e-01f, -9.54906881e-01f, -5.45499697e-02f, 1.75520793e-01f, 6.55714393e-01f, 3.96127224e-01f,
  -2.10952237e-01f, 6.86034143e-01f, 1.14798933e-01f, 8.91265944e-02f, -1.80159405e-01f, -4.30413127e-01f, 1.18232906e+00f, -3.36382091e-01f, 6.75471127e-01f, 8.88473511e-01f,
  2.03354210e-01f, 1.77144483e-01f, 8.26703250e-01f, 9.28707421e-01f, -7.76949376e-02f, 1.09342381e-01f, 5.56677997e-01f, 1.61198512e-01f, 3.20670992e-01f, -3.25784057e-01f,
  -2.66838580e-01f, 1.35805652e-01f, 2.10106578e-02f, -7.52104938e-01f, 1.97177321e-01f, -3.87906551e-01f, 2.37041757e-01f, 4.34734136e-01f, -1.21382937e-01f, 3.91767658e-02f,
  7.50905424e-02f, 3.46552789e-01f, 4.13130447e-02f, -1.94132626e-01f, 6.43972397e-01f, 1.24093778e-01f, 2.29281396e-01f, 2.72140689e-02f, 5.91534317e-01f, 4.17907447e-01f,
  2.00420856e-01f, 6.82291090e-01f, 1.17688403e-01f, 2.92711347e-01f, 9.02109027e-01f, 6.48893952e-01f, 6.81414008e-02f, 3.42790216e-01f, 3.27228665e-01f, -1.02190599e-01f,
  3.08052599e-01f, -5.33719301e-01f, -3.35978448e-01f, 4.10768747e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.24011195e-01f, 1.54085025e-01f, -2.60251760e-01f, 5.88959813e-01f, -6.15241155e-02f, -2.84278005e-01f, 6.50222123e-01f, 5.95787585e-01f, 6.33950710e-01f, -4.03990597e-01f,
  4.19679403e-01f, 5.74546397e-01f, -4.59328264e-01f, 5.35728455e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.35211164e-01f, 6.08513534e-01f, -2.95619577e-01f, -5.28848581e-02f, 3.19449037e-01f, 1.29395753e-01f, -4.15292799e-01f, 2.22171113e-01f, -4.38968748e-01f, 1.47640422e-01f,
  4.78411540e-02f, -2.31660679e-01f, 1.49503767e-01f, -1.02974184e-01f, -1.44743118e-02f, 6.51005134e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  3.74612063e-01f, 2.44306386e-01f, -2.49754384e-01f, -3.62630099e-01f, 3.13932657e-01f, 2.12382838e-01f, 1.91112787e-01f, 5.25756255e-02f, -1.14675246e-01f, 5.88800490e-01f,
  2.55753636e-01f, 3.44561279e-01f, 1.48232937e-01f, 6.95114195e-01f, 7.08890617e-01f, 4.98703599e-01f, 4.75969881e-01f, -5.73455393e-01f, -3.11703384e-01f, 2.46615410e-02f,
  1.53504834e-01f, -1.21859215e-01f, -3.50110024e-01f, -6.95864618e-01f, 2.64104992e-01f, 3.74449164e-01f, 2.40399599e-01f, -1.04768597e-01f, -5.15193522e-01f, 3.58228505e-01f,
  -4.95708883e-01f, 6.39126748e-02f, -1.47867918e-01f, 4.40959454e-01f, -2.44502611e-02f, -2.08277255e-01f, 5.09481668e-01f, -2.09244937e-01f, 4.44243044e-01f, 3.25084299e-01f,
  1.20129939e-02f, 2.36980990e-01f, 2.19790526e-02f, 1.89955205e-01f, 1.78483278e-01f, 2.09299237e-01f, 2.15312988e-01f, -5.90999648e-02f, 1.06122804e+00f, -4.73656476e-01f,
  4.51226741e-01f, -2.24750593e-01f, 2.89618313e-01f, -6.21752031e-02f, 1.02594227e-01f, 2.61128008e-01f, 6.06927216e-01f, 1.28236473e-01f, 8.54343712e-01f, 1.22524276e-01f,
  2.97252864e-01f, -1.68820806e-02f, -1.59237638e-01f, -4.55975741e-01f, 7.08799303e-01f, 8.86605442e-01f, 1.13174546e+00f, -5.27195185e-02f, -4.89225775e-01f, 5.98589480e-02f,
  5.16862452e-01f, -2.60352045e-01f, 4.32490259e-01f, -5.05730748e-01f, 4.70409870e-01f, -3.40693034e-02f, 5.36340952e-01f, 4.74162307e-03f, -2.79181123e-01f, -2.26955816e-01f,
  -6.42052114e-01f, 7.50633061e-01f, 3.59664887e-01f, 1.70524374e-01f, 2.66754299e-01f, -4.41436887e-01f, 2.38603815e-01f, 2.67345101e-01f, -2.67689992e-02f, -2.19690174e-01f,
  6.42875358e-02f, 3.87416750e-01f, 4.66366202e-01f, -1.57077268e-01f, 5.96311450e-01f, -1.53119862e-01f, 5.35050690e-01f, -4.67953771e-01f, 4.79228318e-01f, 6.08332694e-01f,
  -3.42604667e-01f, 6.78235292e-02f, -8.63660201e-02f, -7.50891507e-01f, 5.92712648e-02f, 1.86450005e-01f, -4.89072621e-01f, -4.16548461e-01f, 4.42943066e-01f, 2.78552711e-01f,
  -5.14074981e-01f, -1.24847535e-02f, 4.57169503e-01f, -9.33144450e-01f, -4.00056332e-01f, -5.23120999e-01f, 4.02209133e-01f, -3.63367498e-01f, -3.13450813e-01f, 2.17483953e-01f,
  -5.37737682e-02f, 2.40614846e-01f, 2.83134699e-01f, 2.58987755e-01f, -4.78172749e-01f, -1.35630012e-01f, 2.19537437e-01f, 1.45886615e-01f, -8.09017777e-01f, -9.66635644e-02f,
  2.09660918e-01f, -7.60575458e-02f, 4.83122110e-01f, -1.08210333e-01f, -2.75511801e-01f, 4.64483619e-01f, -5.77702105e-01f, 1.24627896e-01f, 1.79279059e-01f, 3.02951962e-01f,
  -2.30604172e-01f, 2.43018061e-01f, 8.04759115e-02f, 2.98315972e-01f, -4.42348987e-01f, 1.81699581e-02f, -1.08021803e-01f, 2.40844801e-01f, 4.94101554e-01f, 2.06608251e-01f,
  6.35364771e-01f, 3.40907574e-01f, 4.04939175e-01f, -1.86478615e-01f, 2.34644040e-01f, 3.97848010e-01f, 1.97165892e-01f, -1.77289117e-02f, 1.51216060e-01f, -1.94971427e-01f,
  -3.07432748e-02f, -7.48249948e-01f, -3.31296176e-01f, 3.18515211e-01f, 5.25450349e-01f, -7.95257688e-01f, -2.14971274e-01f, 7.94353057e-03f, 5.96778393e-01f, 2.80120552e-01f,
  -5.60057998e-01f, 4.92073387e-01f, 9.94793996e-02f, -1.76188856e-01f, -1.84944451e-01f, -2.01848820e-01f, 6.61514848e-02f, -2.45281741e-01f, -2.28757039e-01f, 5.87419093e-01f,
  -1.99087024e-01f, 1.69408724e-01f, -9.13985372e-01f, -5.42472005e-01f, -6.69128478e-01f, 6.21826291e-01f, -1.30993828e-01f, 2.51193754e-02f, -2.07590833e-01f, 4.07425076e-01f,
  -5.13007939e-01f, 4.66642022e-01f, 5.17436229e-02f, 1.61733076e-01f, 5.80379188e-01f, 5.49842656e-01f, 2.29222015e-01f, -5.41530371e-01f, 4.43337351e-01f, -4.68445271e-01f,
  3.06378335e-01f, 4.28215116e-01f, -8.64462793e-01f, 3.16757768e-01f, 6.36885405e-01f, -3.25696878e-02f, -2.83760428e-01f, 2.35868972e-02f, 2.25956976e-01f, -4.89900559e-02f,
  3.02758425e-01f, 2.58710563e-01f, -7.30979264e-01f, 1.13559711e+00f, -3.67251903e-01f, -5.26763618e-01f, -1.25129506e-01f, 3.47801208e-01f, 2.18934156e-02f, -7.90957630e-01f,
  6.14992008e-02f, 3.10422599e-01f, -1.38005152e-01f, 4.26904321e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  4.38282527e-02f, 5.64469099e-01f, -4.96809721e-01f, 7.10405111e-01f, 6.39194012e-01f, -1.93231836e-01f, 6.09958112e-01f, 4.09170449e-01f, -9.42416191e-02f, -1.39139563e-01f,
  2.76052833e-01f, 4.81053472e-01f, 1.19854800e-01f, 1.47331238e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.49535787e-01f, -1.05296850e+00f, 2.59247750e-01f, -1.62142470e-01f, 1.41935572e-02f, -5.91690242e-01f, -6.82601631e-01f, -5.91856539e-01f, -9.18280363e-01f, -1.82290331e-01f,
  2.88139433e-01f, -4.76943366e-02f, -5.50554156e-01f, 1.07060380e-01f, -6.58922911e-01f, 2.75743604e-01f, 3.01378090e-02f, 9.99042466e-02f, -2.93477587e-02f, -3.19632053e-01f,
  2.65765905e-01f, 2.27605075e-01f, -1.57364190e-01f, 1.45136163e-01f, -1.10993207e-01f, 4.61771160e-01f, 2.86490452e-02f, 1.98516548e-01f, 3.08563877e-02f, -1.21442926e+00f,
  -7.10315943e-01f, -1.83855798e-02f, 6.99691772e-01f, 3.59444648e-01f, -5.65393865e-01f, -1.14126909e+00f, -7.69578457e-01f, 8.25143829e-02f, 2.90074348e-02f, -6.28130913e-01f,
  6.17644787e-01f, -2.91264500e-03f, -3.56928229e-01f, -5.67414522e-01f, -4.33036268e-01f, 2.83232480e-01f, -1.54299557e-01f, 5.02351701e-01f, -5.30280709e-01f, -1.03901103e-01f,
  9.76216346e-02f, -8.81334171e-02f, -2.85885274e-01f, -1.21424568e+00f, -6.53272271e-01f, -4.40770686e-01f, 2.70775586e-01f, -4.77701575e-01f, -1.31775633e-01f, -9.04146910e-01f,
  -5.79044878e-01f, 9.73505080e-02f, 4.42237735e-01f, 2.25798160e-01f, 9.70529020e-02f, 1.20237005e+00f, -8.89151022e-02f, 3.47286433e-01f, -5.98089218e-01f, -8.33884299e-01f,
  -2.69774646e-01f, 4.11670446e-01f, 9.42776650e-02f, -2.27097794e-01f, -2.05840081e-01f, 5.03235757e-02f, -6.06320262e-01f, 2.13754535e-01f, -1.05838227e+00f, 4.71112132e-01f,
  -4.63888556e-01f, 6.56314790e-01f, 3.02590728e-01f, 5.29940426e-01f, 1.24384211e-02f, -2.71662381e-02f, -1.63270608e-01f, -5.02991557e-01f, -9.93701339e-01f, 3.99425179e-01f,
  -7.20195938e-04f, -3.35737348e-01f, 5.07459231e-02f, 2.66605113e-02f, -1.47018909e-01f, -4.90942806e-01f, -7.77222868e-03f, -3.14318299e-01f, -1.24823737e+00f, -1.57806873e-01f,
  -3.78901482e-01f, 4.73093688e-01f, 5.31452954e-01f, 1.00536734e-01f, 4.39377762e-02f, -4.52574948e-03f, -6.07333705e-02f, -1.05316147e-01f, -8.12657773e-01f, -6.45529270e-01f,
  3.04977030e-01f, -8.94412935e-01f, -3.71216163e-02f, -1.75587341e-01f, 1.00127561e-02f, -4.71917063e-01f, 1.92293376e-01f, -4.72232580e-01f, -1.05982788e-01f, 3.41150105e-01f,
  -3.51507068e-01f, -4.30222958e-01f, 1.15473792e-01f, 2.19088718e-01f, -8.43802616e-02f, 8.91393647e-02f, 7.10873604e-02f, -1.45306975e-01f, 2.25819483e-01f, 4.19465154e-02f,
  -6.81879997e-01f, -1.33451790e-01f, -2.28776947e-01f, 1.89842626e-01f, -5.63378572e-01f, -1.13446459e-01f, 2.47183025e-01f, -1.03267215e-01f, -5.63062191e-01f, 2.50557691e-01f,
  8.75997722e-01f, -1.41229555e-01f, 4.62734818e-01f, -6.37952685e-01f, -1.51236122e-02f, -3.92644256e-01f, -2.87966095e-02f, 3.67240489e-01f, -3.03722322e-01f, 6.57345802e-02f,
  2.95473605e-01f, -1.66467145e-01f, 2.19090268e-01f, -3.93898547e-01f, -6.61199868e-01f, 5.80354631e-02f, -2.30924413e-01f, -8.65802824e-01f, 1.91586494e-01f, 3.44969362e-01f,
  -3.08319479e-01f, 7.20914826e-02f, -3.86552483e-01f, 4.09968793e-01f, -8.87288302e-02f, -1.22314620e+00f, -3.29652466e-02f, -7.34973431e-01f, 6.04451820e-02f, -3.03932857e-02f,
  1.72743440e-01f, -5.43283582e-01f, 4.98447955e-01f, 4.12236750e-01f, 2.96256095e-01f, -6.08859181e-01f, -4.32638288e-01f, -4.32814568e-01f, -2.28575960e-01f, -7.11222768e-01f,
  1.08213589e-01f, 3.86216581e-01f, 3.15033674e-01f, 1.03240497e-01f, -1.09326100e+00f, -5.54515302e-01f, -8.69707227e-01f, 2.83085763e-01f, -4.78434749e-02f, -7.05788732e-02f,
  1.33762863e-02f, -9.57640946e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.38980597e-01f, -8.54542777e-02f, 3.75311464e-01f, -5.34850359e-01f, 4.17216718e-01f, 2.49770582e-01f, 2.71088719e-01f, -2.48428449e-01f, 2.10919362e-02f, -1.02013521e-01f,
  -4.71813560e-01f, -4.24137563e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    