/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.00483844e-01f, -5.37291169e-01f, 3.61622393e-01f, -1.04168467e-02f, -1.36127785e-01f, -1.74471155e-01f, -3.91907603e-01f, -3.86174738e-01f, -1.20129203e-02f, -2.71454364e-01f,
  -2.55056113e-01f, -1.66196506e-02f, 5.60950488e-02f, 1.13246422e-02f, -1.67315811e-01f, -5.38654346e-03f, 1.58216923e-01f, 3.40336710e-01f, 2.39408106e-01f, -6.36576042e-02f,
  -8.31743404e-02f, -3.99126532e-03f, 1.33218542e-01f, 1.31535023e-01f, -3.79785709e-02f, 6.40201047e-02f, 1.69374228e-01f, 7.63865537e-04f, -6.65990189e-02f, 2.10100457e-01f,
  3.66333455e-01f, -2.13370860e-01f, 9.05901566e-02f, -3.12195420e-02f, 9.74734053e-02f, 6.75881375e-03f, -5.63466027e-02f, 6.21952936e-02f, -6.25796989e-02f, -3.52999009e-02f,
  5.11301532e-02f, -6.42663613e-02f, 7.21985521e-03f, 3.06885913e-02f, -9.28690657e-02f, -4.06302586e-02f, -6.10154234e-02f, -1.97152141e-02f, 8.40576217e-02f, -3.68732661e-02f,
  -1.22313937e-02f, -7.34824017e-02f, 7.80290589e-02f, -5.20455316e-02f, 1.62573345e-02f, -1.30733633e-02f, 3.95671129e-02f, -7.22645549e-03f, -1.12884678e-01f, -5.41182570e-02f,
  -3.93394753e-02f, -1.10525191e-02f, -5.60984537e-02f, -5.58686219e-02f, -1.66346133e-02f, 9.19378269e-03f, -2.65524294e-02f, 2.89010685e-02f, 4.18564789e-02f, 3.89596894e-02f,
  -2.25175060e-02f, -1.09759495e-02f, 9.79268271e-03f, -1.76218692e-02f, 7.74238855e-02f, 9.05313902e-03f, 9.71618691e-04f, -2.60681883e-02f, 5.72850928e-02f, -3.75304297e-02f,
  8.72811601e-02f, 2.01315042e-02f, 6.94605932e-02f, -5.51599264e-02f, -6.18474698e-03f, -1.63122471e-02f, -2.85799615e-02f, -5.41340150e-02f, 1.27954269e-02f, 8.32711905e-03f,
  -4.24746424e-02f, -2.63561327e-02f, 3.39966975e-02f, -7.15858266e-02f, 6.25113696e-02f, 7.72731528e-02f, 3.65107656e-02f, 4.56224084e-02f, 7.77386203e-02f, 9.95391235e-03f,
  -2.54281070e-02f, 6.98824152e-02f, 5.13180532e-03f, -4.77509312e-02f, 1.00192919e-01f, 1.97212677e-02f, -1.59056395e-01f, -1.14252686e-03f, 5.55650480e-02f, 2.01986283e-02f,
  -4.65181954e-02f, 3.07245776e-02f, -1.67433657e-02f, 1.34796435e-02f, 4.53932071e-03f, 7.76694044e-02f, 7.63415396e-02f, 2.35873424e-02f, 2.31926925e-02f, 5.60749648e-03f,
  -2.81690776e-01f, -1.38738289e-01f, 3.04943860e-01f, -1.70852169e-01f, 5.43070957e-02f, 2.94671237e-01f, 1.19286135e-01f, 1.03612259e-01f, -7.43162865e-03f, -1.17277848e-02f,
  3.45053598e-02f, -3.03400569e-02f, -2.84063332e-02f, -1.12977169e-01f, -6.51384071e-02f, -8.50579068e-02f, -2.00569540e-01f, -4.98578362e-02f, -6.42070845e-02f, 3.06450110e-02f,
  -1.41637981e-01f, -1.51009008e-01f, -2.28893936e-01f, -2.21423090e-01f, -6.53964356e-02f, -8.85996670e-02f, -4.63263094e-02f, -2.77287886e-02f, -7.84666315e-02f, -2.27090508e-01f,
  3.00597072e-01f, 1.87737063e-01f, 3.13666207e-03f, -1.76925257e-01f, -2.45022662e-02f, -1.41388535e-01f, -5.15346304e-02f, 1.72336176e-02f, -6.70819879e-02f, -8.74785427e-03f,
  6.23726584e-02f, -7.71834999e-02f, -2.08044127e-02f, -5.43339923e-02f, 4.29598428e-03f, 6.39520027e-03f, -5.42371981e-02f, -1.13633424e-02f, 2.37965044e-02f, 1.20883010e-01f,
  -6.99483752e-02f, -4.15129028e-02f, 1.53965607e-01f, 7.49614239e-02f, 9.18134004e-02f, 5.68518741e-03f, 6.89107999e-02f, 1.48677304e-01f, 7.10410029e-02f, 3.44841108e-02f,
  -5.18558398e-02f, -3.87082691e-03f, 1.36821028e-02f, -2.76685730e-02f, -6.63268492e-02f, 3.43672298e-02f, -6.77663013e-02f, 1.41821299e-02f, -2.69326363e-02f, 8.56124908e-02f,
  7.59823772e-04f, 2.53959727e-02f, 4.29764651e-02f, -3.72586399e-02f, -5.74817806e-02f, -2.81045679e-02f, -2.63918433e-02f, -1.42903090e-01f, 8.99589434e-03f, -1.94558222e-02f,
  -2.17348672e-02f, 1.06073014e-01f, 4.79452014e-02f, 5.35644665e-02f, 5.61390743e-02f, 1.06440140e-02f, -1.06512435e-01f, -6.66024461e-02f, -4.84750979e-02f, -2.28929818e-02f,
  1.94399074e-01f, -2.11742218e-03f, -6.19103424e-02f, -9.24532861e-02f, 8.04613754e-02f, 8.48276988e-02f, 8.85223597e-02f, -3.53689454e-02f, -1.11005502e-02f, -3.07302568e-02f,
  1.45813460e-02f, 1.89543888e-02f, -1.62783042e-02f, -3.48105058e-02f, 2.76044887e-02f, -9.44354571e-03f, -1.17781892e-01f, -3.09724901e-02f, -2.31786594e-02f, 1.96843222e-02f,
  -8.29150304e-02f, 7.58308619e-02f, -1.64600741e-02f, 4.86986339e-02f, 6.26712665e-02f, -4.86313254e-02f, 1.26503762e-02f, 4.31413390e-02f, 7.92615935e-02f, -9.01479051e-02f,
  -5.28079212e-01f, 4.09527384e-02f, -3.34130615e-01f, 3.06012873e-02f, 3.14794153e-01f, 3.91876884e-02f, 1.56203613e-01f, -1.85087770e-02f, 3.27876210e-02f, 1.88492928e-02f,
  2.33046681e-01f, 2.50334322e-01f, 1.84643880e-01f, -3.67333591e-02f, -1.45541012e-01f, -1.42864943e-01f, -1.32868379e-01f, -3.87451768e-01f, -2.08934039e-01f, 1.00614093e-02f,
  1.09444238e-01f, -1.61824107e-01f, -2.33981743e-01f, -1.90545276e-01f, 1.91954840e-02f, 6.69951886e-02f, -1.71676680e-01f, -1.26855671e-01f, -3.80878374e-02f, -2.47769848e-01f,
  7.35965511e-03f, -2.48948202e-01f, 2.54804152e-03f, -9.52748880e-02f, 2.17200760e-02f, -2.04331458e-01f, -3.77197415e-02f, -2.31839344e-01f, -4.03739922e-02f, -5.10471128e-02f,
  1.43035874e-02f, -8.72213393e-04f, -2.26904382e-03f, 1.00572100e-02f, -1.25951141e-01f, -5.52739911e-02f, -1.35244250e-01f, -2.57632196e-01f, -1.86656654e-01f, -1.12770833e-01f,
  1.35110348e-01f, -5.08028902e-02f, -1.09999627e-02f, -1.12385452e-01f, -6.52840436e-02f, -9.64038745e-02f, -9.61330011e-02f, -6.33514300e-02f, -2.11515263e-01f, -2.53390491e-01f,
  -1.15189262e-01f, -9.36488621e-03f, 3.12031470e-02f, -2.95965318e-02f, 6.28820136e-02f, -1.39713753e-02f, 2.65069772e-02f, 4.96769994e-02f, 3.53023186e-02f, 9.82612182e-05f,
  -9.32923332e-03f, 7.15276077e-02f, -3.67496908e-02f, 3.79138738e-02f, 1.28317088e-01f, -1.43105062e-02f, 3.32307592e-02f, 2.57358346e-02f, 9.46159139e-02f, 4.21246290e-02f,
  3.95961553e-02f, 9.61179212e-02f, 2.06385665e-02f, 3.80260833e-02f, -5.89189529e-02f, 1.61101539e-02f, 4.11359742e-02f, 3.44656669e-02f, 7.80951679e-02f, 1.17975302e-01f,
  2.32704043e-01f, -7.56084397e-02f, -3.81511636e-03f, -4.53705862e-02f, 5.78389652e-02f, -6.61708862e-02f, 7.14826062e-02f, 2.22232658e-02f, 1.00324936e-01f, -7.53488392e-02f,
  2.61937361e-02f, -2.64632534e-02f, 3.35103832e-02f, -7.98735544e-02f, -3.19495127e-02f, -1.50345396e-02f, 3.74611542e-02f, 3.76628824e-02f, 6.82677776e-02f, -1.26454886e-02f,
  3.85244340e-02f, 4.14725300e-03f, -9.52992216e-02f, 6.70418330e-03f, -8.21441785e-03f, 5.80921164e-03f, -2.10235361e-02f, -3.95267680e-02f, -9.44161415e-02f, -1.35813117e-01f,
  2.88758934e-01f, -2.78170347e-01f, -1.67765155e-01f, 1.52858540e-01f, -2.52095610e-01f, -3.57175529e-01f, -3.71151805e-01f, -1.28233552e-01f, -1.27620613e-02f, -2.28676975e-01f,
  -2.71640629e-01f, -1.55561287e-02f, -2.10426506e-02f, -7.72328749e-02f, -1.17954858e-01f, -1.24961205e-01f, -1.55909732e-01f, 2.58047823e-02f, -2.14796662e-02f, -2.74940163e-01f,
  -8.04558322e-02f, 9.80167091e-02f, 1.45454094e-01f, 1.86457872e-01f, 6.43260926e-02f, 5.76544441e-02f, -8.76620561e-02f, -1.77306868e-02f, -2.23400056e-01f, -1.32746585e-02f,
  -2.35165313e-01f, -2.64033442e-03f, 1.76105425e-01f, 1.79603621e-01f, -3.11850365e-02f, 1.29633799e-01f, -6.59475178e-02f, 9.61913541e-02f, 1.38487816e-01f, 1.07654177e-01f,
  6.57558218e-02f, 8.40711519e-02f, 2.05028094e-02f, -4.44186032e-02f, 6.93019480e-02f, 9.00595859e-02f, 3.31642590e-02f, 1.40504092e-01f, 1.00729108e-01f, -2.89390031e-02f,
  -8.41375366e-02f, -6.79125935e-02f, 2.15239394e-02f, 3.59673984e-02f, 6.34968802e-02f, 1.05694450e-01f, 7.62133598e-02f, 9.97190177e-02f, 6.72893301e-02f, 1.88603759e-01f,
  -9.34894755e-02f, 2.40715151e-03f, -3.02564036e-02f, 1.60139035e-02f, 6.18929118e-02f, 6.87510222e-02f, 7.20918179e-02f, 4.16704416e-02f, 6.22874219e-03f, -3.60451937e-02f,
  -2.47484148e-02f, -8.49696100e-02f, -1.76316649e-02f, 2.06301501e-03f, 2.46108379e-02f, -2.95367732e-04f, -9.23287496e-02f, 5.32792211e-02f, 6.78576753e-02f, 3.94283198e-02f,
  2.23183408e-02f, -9.33300983e-03f, 6.23523742e-02f, 5.59796998e-03f, -1.14187330e-01f, -6.57868758e-02f, 6.16281778e-02f, -8.05063844e-02f, -5.97324893e-02f, 3.81369926e-02f,
  2.67683357e-01f, -1.17111444e-01f, 5.27047403e-02f, 1.61135301e-01f, 2.19681431e-02f, 7.29502663e-02f, -5.67137897e-02f, 1.63779721e-01f, 2.38262005e-02f, -9.61699486e-02f,
  -1.14145845e-01f, 1.30602894e-02f, 3.85802723e-02f, 7.70944506e-02f, -4.01942655e-02f, 3.75326760e-02f, 5.62807210e-02f, 1.84534732e-02f, 1.29237650e-02f, -4.15769108e-02f,
  -5.87115251e-02f, 7.81671330e-02f, 1.38761818e-01f, -8.30541179e-03f, 4.11794409e-02f, 8.74079689e-02f, -1.79355256e-02f, 2.25622747e-02f, -3.05504985e-02f, 8.61580893e-02f,
  4.15298671e-01f, -2.76128292e-01f, -2.51863867e-01f, 1.66030511e-01f, -4.92277555e-02f, -1.17525958e-01f, -4.15150821e-02f, 3.83336768e-02f, 1.11539938e-01f, -1.05094425e-02f,
  -1.30844221e-01f, 3.43604237e-02f, -8.40820670e-02f, 4.91196923e-02f, 8.23276176e-04f, -1.07656829e-01f, -1.72026724e-01f, -8.74952227e-02f, 2.62192458e-01f, 1.70687869e-01f,
  1.11105964e-01f, 2.19991788e-01f, 2.37676263e-01f, 1.35371074e-01f, 2.56528687e-02f, -3.25024389e-02f, -1.33246019e-01f, -9.06159058e-02f, -1.49743035e-01f, -1.56325430e-01f,
  2.36877948e-02f, -1.10354975e-01f, 4.66800295e-02f, 1.59781259e-02f, 4.22345195e-03f, 1.26669943e-01f, -1.82209145e-02f, 8.58809799e-02f, 7.14588836e-02f, 1.78148865e-03f,
  -6.09136783e-02f, 4.25304333e-03f, 3.11408509e-02f, 5.56487706e-04f, 1.08121544e-01f, 8.86514783e-02f, 3.77695933e-02f, 2.85688918e-02f, -1.27986073e-01f, 2.58561391e-02f,
  -1.89575292e-02f, 3.30040726e-04f, 1.05728945e-02f, -1.56259891e-02f, -2.44163908e-02f, -1.15213124e-02f, -4.58863638e-02f, 3.08450907e-02f, -1.38462096e-01f, 7.87269324e-02f,
  3.22287120e-02f, 1.10447435e-02f, 2.83808867e-03f, 2.10210681e-02f, 7.97241053e-04f, 4.88817282e-02f, -5.03966883e-02f, -8.30819160e-02f, 2.09728628e-02f, 3.28813158e-02f,
  -6.05933405e-02f, -1.05658742e-02f, 6.57153055e-02f, 1.84132140e-02f, -2.79831216e-02f, -5.46865053e-02f, -1.91847775e-02f, -4.76164445e-02f, -1.44572333e-01f, -2.97971023e-03f,
  -9.72864553e-02f, -1.46090150e-01f, -2.58515775e-02f, -3.56201679e-02f, -1.40414491e-01f, -5.63673265e-02f, 1.12747587e-02f, -3.21136378e-02f, -4.45362329e-02f, -2.94272061e-02f,
  3.06138277e-01f, -1.04899712e-01f, 8.51210132e-02f, -4.15266827e-02f, -7.40283430e-02f, -3.88807873e-03f, -7.41172731e-02f, 4.84781526e-02f, -6.85351640e-02f, -3.20307650e-02f,
  3.93914692e-02f, -3.25674415e-02f, -4.23717387e-02f, -1.77399963e-02f, 1.10005505e-01f, 1.18646407e-02f, -2.52966098e-02f, 9.88662709e-03f, -5.16337827e-02f, -5.06894067e-02f,
  2.64308928e-03f, 8.83908048e-02f, 9.74661931e-02f, 3.30652036e-02f, -3.67045542e-03f, 6.20880052e-02f, 1.24230042e-01f, 1.36967123e-01f, 7.92179350e-03f, 2.35166341e-01f,
  -3.10771018e-01f, -1.10777780e-01f, -2.63917357e-01f, -1.43251300e-01f, 8.41201097e-02f, 2.15724930e-01f, 2.14904204e-01f, 4.80952114e-02f, 3.80173735e-02f, -3.89100201e-02f,
  1.67092159e-01f, 2.21549943e-01f, 5.60001060e-02f, 5.00205122e-02f, 5.03983302e-03f, -2.57345229e-01f, -3.82562101e-01f, -2.49555901e-01f, 1.32394792e-03f, 1.07870027e-01f,
  -1.98038220e-02f, -1.76375285e-01f, -2.94205219e-01f, -1.90923229e-01f, -1.62490085e-01f, 1.92002915e-02f, -1.67134807e-01f, -1.11671887e-01f, -1.34540023e-02f, -1.97522044e-01f,
  7.85612222e-03f, -3.06347996e-01f, 1.54345796e-01f, 8.91089365e-02f, 7.44738579e-02f, -8.17263499e-02f, -2.42663939e-02f, -1.12293191e-01f, 9.78167634e-03f, -3.03310864e-02f,
  1.00444183e-02f, -9.84079763e-03f, -5.16528636e-02f, 2.62622368e-02f, -5.30521758e-02f, -6.40825480e-02f, -1.25810429e-01f, -2.05141500e-01f, -5.76997921e-02f, -1.02089047e-01f,
  -4.25034426e-02f, -1.07284062e-01f, -4.38722707e-02f, 4.96247783e-02f, 4.45713811e-02f, -8.09203610e-02f, 7.43262768e-02f, 1.37625951e-02f, 3.80898477e-03f, -1.49175212e-01f,
  8.05633813e-02f, 1.76650640e-02f, 2.79789548e-02f, -6.71698451e-02f, 8.39948356e-02f, 8.41298029e-02f, 3.50253582e-02f, -4.99051623e-02f, 3.26819122e-02f, 7.60352984e-02f,
  2.36483514e-02f, 1.03623457e-02f, -6.68342933e-02f, -5.41203357e-02f, -7.36659998e-03f, 2.16451585e-02f, -1.80423111e-02f, 4.29313481e-02f, -7.91249890e-03f, 8.32378922e-04f,
  1.59398429e-02f, 1.13917872e-01f, -1.67177487e-02f, -2.97086295e-02f, 4.40778024e-02f, -5.65951243e-02f, -4.81828190e-02f, 9.84298289e-02f, 4.71677408e-02f, 3.77536491e-02f,
  9.21693593e-02f, -1.64808873e-02f, -8.66645649e-02f, -9.20379832e-02f, -4.12672460e-02f, -6.08971156e-03f, -1.14984307e-02f, 3.48722078e-02f, -3.61211710e-02f, 2.52733920e-02f,
  2.31199176e-03f, 2.81125885e-02f, -4.03984226e-02f, 4.12983932e-02f, -5.95526025e-03f, 9.91471410e-02f, 1.44375786e-02f, -9.27142147e-03f, -3.79971750e-02f, 3.50950360e-02f,
  1.57619759e-01f, 3.60964537e-02f, 1.24568187e-01f, 5.64247482e-02f, 5.54789323e-03f, 1.22871809e-01f, 9.05142948e-02f, 9.00720432e-02f, -1.53796049e-02f, 6.48581535e-02f,
  1.53164438e-03f, -2.60601252e-01f, -3.18215013e-01f, -1.96831971e-01f, -1.89437702e-01f, 2.38539856e-02f, 6.14524782e-02f, 3.68169360e-02f, -4.81344350e-02f, -1.12339422e-01f,
  -1.58055779e-02f, 1.64980590e-01f, 1.84971154e-01f, 1.75398231e-01f, 2.30797470e-01f, -1.56637967e-01f, -2.28333190e-01f, -5.01074195e-02f, 1.07933685e-01f, -7.28534954e-03f,
  5.78153431e-02f, -6.04140721e-02f, -4.05571833e-02f, 4.65260111e-02f, -1.42153651e-01f, -4.55272198e-02f, -1.95241332e-01f, -1.58217847e-01f, -3.05950968e-03f, -3.31645519e-01f,
  -2.69736320e-01f, -2.86944658e-02f, 4.05527651e-02f, 1.36269793e-01f, -1.28024131e-01f, 1.27485450e-02f, -5.84222898e-02f, -3.96933109e-02f, 2.10157409e-02f, 3.70685942e-02f,
  -7.87480697e-02f, 1.42592732e-02f, 1.21965772e-03f, -1.25815511e-01f, 2.60892138e-02f, -2.34007649e-02f, 1.41857900e-02f, -4.39540623e-03f, 3.67678180e-02f, 3.77073735e-02f,
  -1.26316920e-01f, -8.43863860e-02f, -7.11074546e-02f, 3.33698951e-02f, -1.81375835e-02f, 4.52152863e-02f, -2.90827863e-02f, -4.02726755e-02f, 7.61903496e-03f, -2.31123000e-01f,
  -3.24022025e-02f, -1.40434150e-02f, -7.57624730e-02f, 7.56821781e-02f, 3.61357033e-02f, 1.50174545e-02f, -3.00981533e-02f, 4.03935425e-02f, 1.25205992e-02f, -4.62157317e-02f,
  1.14758490e-02f, 3.45525183e-02f, -1.35076614e-02f, 3.07052918e-02f, -9.43861082e-02f, -6.46104142e-02f, -5.29773422e-02f, -4.61330041e-02f, 1.90319605e-02f, 1.22976080e-01f,
  9.18805413e-03f, -1.59788504e-02f, -6.64067864e-02f, -7.49111474e-02f, 1.69256199e-02f, -2.06585173e-02f, -7.31119653e-04f, 4.27835323e-02f, 5.64256050e-02f, 2.76732948e-02f,
  -5.71371168e-02f, 2.11763144e-01f, -4.28860337e-02f, 9.28809941e-02f, -5.15004918e-02f, 4.20743190e-02f, -4.09525074e-02f, 5.88535378e-03f, 4.89551127e-02f, -6.48865625e-02f,
  7.76162231e-03f, 3.78409922e-02f, -8.51833895e-02f, 2.93864366e-02f, 4.55708764e-02f, 5.56127802e-02f, 2.08071098e-02f, -2.48531951e-03f, 6.38104975e-02f, -9.68993381e-02f,
  -3.14684063e-02f, 5.43780159e-03f, 1.21082515e-01f, 8.96627232e-02f, 1.17576763e-01f, 3.27797122e-02f, 7.67913312e-02f, 8.59604329e-02f, 6.32846132e-02f, -8.04788470e-02f,
  4.57397789e-01f, -4.24903393e-01f, -3.10414016e-01f, -2.11790860e-01f, -1.15214027e-01f, -2.68223695e-03f, 9.57897007e-02f, 6.82195835e-03f, -1.47816613e-01f, -1.33042350e-01f,
  -6.61955699e-02f, 2.86824703e-02f, -8.13424140e-02f, -8.84696022e-02f, 4.08163294e-02f, -2.79879600e-01f, -2.42333993e-01f, 2.33432092e-02f, 2.96831876e-01f, 2.24918321e-01f,
  -1.06178351e-01f, 3.72294746e-02f, 5.81448376e-02f, -2.07046214e-02f, -1.22017480e-01f, 1.31953962e-03f, -2.27864102e-01f, -1.35760888e-01f, -9.50868335e-03f, -2.10916355e-01f,
  5.14351316e-02f, 1.41487062e-01f, 6.44082949e-02f, -3.35174352e-02f, -4.35796715e-02f, -3.38683724e-02f, 2.66365968e-02f, -4.58609350e-02f, 2.08967440e-02f, 2.25890968e-02f,
  -1.82564985e-02f, -6.52111396e-02f, -7.68526224e-03f, -7.01975897e-02f, -3.66400518e-02f, 1.38835646e-02f, -1.01231232e-01f, -1.11844480e-01f, -1.41967475e-01f, -5.03441431e-02f,
  -7.54883140e-02f, 7.13464543e-02f, 7.08361417e-02f, -1.06362827e-01f, 3.02941725e-02f, -3.85135263e-02f, 5.06810732e-02f, 1.28327072e-01f, 2.79271435e-02f, 8.24685581e-03f,
  -7.44546577e-02f, 2.99885683e-03f, 7.02889711e-02f, 2.30869893e-02f, 1.26252204e-01f, -2.82347109e-02f, 1.00194484e-01f, 4.07303348e-02f, 7.24666119e-02f, 3.20139006e-02f,
  4.84106988e-02f, 5.31694628e-02f, 8.43551680e-02f, 7.71131292e-02f, -4.61581349e-02f, 1.09314658e-02f, 4.86804396e-02f, -4.35398482e-02f, 7.78736174e-02f, -2.87173316e-02f,
  1.17328018e-01f, 9.41252708e-02f, 5.40190004e-02f, 1.56529266e-02f, 5.19404300e-02f, 4.35458906e-02f, 4.18663099e-02f, 7.53582418e-02f, 8.06776285e-02f, 3.55877914e-02f,
  -6.15778528e-02f, -1.25415726e-02f, 2.56246165e-03f, 9.01845321e-02f, -4.04626988e-02f, -8.32827464e-02f, -8.93077701e-02f, -5.46049438e-02f, -7.66870799e-03f, 3.71465981e-02f,
  5.18301129e-03f, 7.51142949e-02f, -3.57708856e-02f, -1.32927015e-01f, -7.79891340e-03f, -5.26510775e-02f, -1.34426981e-01f, -3.16641666e-02f, 1.74093395e-02f, -1.33960232e-01f,
  -8.78770575e-02f, 6.26746565e-02f, 1.03353441e-01f, -7.36524817e-03f, 6.35524988e-02f, 1.47513136e-01f, -2.18297932e-02f, 4.36441973e-02f, 6.30484447e-02f, 1.92913488e-02f,
  -4.79844332e-01f, -1.29295945e-01f, 5.06546557e-01f, -4.65945601e-02f, 2.74716109e-01f, 2.27343842e-01f, 1.16130896e-01f, -1.94748029e-01f, -1.34281293e-01f, 1.49290245e-02f,
  -2.02824045e-02f, 7.68612185e-03f, 1.82319786e-02f, 4.95067053e-03f, 9.64376852e-02f, 1.62946746e-01f, 2.54842907e-01f, 2.87385672e-01f, 1.29178151e-01f, 5.54243959e-02f,
  1.27397090e-01f, 1.01975180e-01f, 1.25616238e-01f, 1.55949026e-01f, 4.22673039e-02f, 3.15953069e-03f, 2.34775230e-01f, 1.90675557e-01f, 1.91682354e-01f, 1.43451095e-01f,
  3.72801900e-01f, -1.06484920e-04f, 9.05345380e-02f, 4.71165683e-03f, 1.55721277e-01f, -6.69596484e-03f, 4.14187163e-02f, 1.07271478e-01f, 6.89184815e-02f, 6.24644868e-02f,
  1.46008432e-01f, -1.37998536e-02f, 1.40394717e-01f, 7.63532221e-02f, 1.54704992e-02f, 9.19769332e-02f, 3.13578621e-02f, 2.89824735e-02f, 1.47117540e-01f, 1.04496099e-01f,
  1.53820381e-01f, 1.38331816e-01f, 2.55067319e-01f, 5.24064004e-02f, 1.01969354e-01f, 1.29083559e-01f, 2.02336282e-01f, 3.91090550e-02f, 7.10720047e-02f, 3.36292535e-02f,
  -2.31036711e-02f, 1.25605315e-02f, -4.54816967e-02f, -7.69256502e-02f, -8.08018595e-02f, -9.98862460e-03f, 7.54507259e-03f, -6.26547188e-02f, -7.63864294e-02f, 4.38688509e-02f,
  -8.45074430e-02f, -5.42391576e-02f, -4.80829701e-02f, -1.40884211e-02f, -7.37273172e-02f, 3.79443988e-02f, 1.51935983e-02f, -4.18837555e-03f, 2.57214229e-03f, -7.09592104e-02f,
  -1.29049681e-02f, 1.49066346e-02f, 6.09481446e-02f, 7.34186396e-02f, -9.29466933e-02f, 6.43239841e-02f, -1.04652032e-01f, -1.47679299e-01f, -2.28471160e-02f, -4.34097201e-02f,
  8.85154530e-02f, 1.72027871e-01f, 1.64591544e-03f, -6.58936203e-02f, 9.04458910e-02f, 4.06313390e-02f, 2.32543852e-02f, 5.68796806e-02f, 2.90885605e-02f, 7.68714547e-02f,
  5.34024797e-02f, 3.20792496e-02f, 9.42377523e-02f, 7.20042214e-02f, 3.38284597e-02f, 8.77667069e-02f, 6.23207949e-02f, 5.38823567e-02f, 5.11248037e-02f, -1.44554647e-02f,
  1.29983043e-02f, 1.09975755e-01f, 1.56205028e-01f, 8.58565643e-02f, 1.73092913e-02f, 4.94814217e-02f, 1.22842588e-01f, 2.55250223e-02f, 1.45298362e-01f, 3.55349779e-02f,
  -4.33885276e-01f, -2.66836584e-01f, -1.48719788e-01f, 2.58994941e-02f, -1.04290418e-01f, -1.35112256e-01f, -2.48504981e-01f, -1.69759274e-01f, -1.04208961e-01f, -6.24464341e-02f,
  1.17268739e-02f, 1.52949423e-01f, 9.29231793e-02f, 1.24649167e-01f, -1.06431693e-01f, -1.91735923e-01f, 2.28490587e-02f, 8.48598778e-02f, 5.55967465e-02f, -6.10142797e-02f,
  1.93789899e-01f, 1.07258677e-01f, 8.40500370e-02f, 1.11438036e-02f, 1.04384124e-01f, 8.89460668e-02f, 1.01007737e-01f, 4.01489884e-02f, -1.29735004e-02f, 1.50862053e-01f,
  -1.00883774e-01f, -3.84123385e-01f, -1.00294137e-02f, -6.00575469e-02f, -5.87468594e-02f, -1.07767895e-01f, -8.71859491e-02f, 2.47037224e-02f, -2.84277722e-02f, -5.35977595e-02f,
  -8.73140991e-02f, -1.10791959e-01f, -9.29154977e-02f, 1.22403177e-02f, -2.12199241e-02f, -1.00690700e-01f, -6.14145733e-02f, -8.80359188e-02f, -4.74573821e-02f, -1.30042747e-01f,
  -4.84016165e-02f, -1.66606799e-01f, -1.81394815e-01f, -1.24771170e-01f, -8.72998685e-02f, -3.34315412e-02f, -1.26473561e-01f, -1.85922552e-02f, -5.04746661e-02f, -1.45470574e-01f,
  5.39806187e-02f, 6.19602911e-02f, 7.32065290e-02f, -1.11757396e-02f, 5.18956222e-02f, -1.58997420e-02f, 1.24002047e-01f, 8.47935304e-02f, -5.68802580e-02f, 3.54228616e-02f,
  -5.68711478e-03f, -5.59712164e-02f, 7.17623206e-03f, -5.74973896e-02f, 5.79786152e-02f, -2.16932744e-02f, 4.04136851e-02f, 7.00487122e-02f, -5.18441573e-02f, -5.33411279e-02f,
  -6.74972087e-02f, 4.46147285e-02f, 9.02647749e-02f, -1.11114811e-02f, -6.28262982e-02f, 2.80751456e-02f, -7.56655484e-02f, -6.02289103e-02f, 7.58865103e-02f, 1.58734098e-02f,
  1.01674549e-01f, -4.92938645e-02f, -1.18731834e-01f, -1.15271276e-02f, -1.35223716e-01f, -4.35505211e-02f, -1.08554468e-01f, -6.31337091e-02f, -1.88963890e-01f, -1.48924902e-01f,
  -9.80577916e-02f, -7.62779340e-02f, -1.31031737e-01f, 6.66560745e-03f, -1.63677245e-01f, -1.71152622e-01f, -1.91554911e-02f, -1.21606581e-01f, -7.22125769e-02f, -1.59272730e-01f,
  -2.08557118e-02f, -2.24826887e-01f, -3.03868949e-01f, -1.46004319e-01f, -1.01075500e-01f, -7.24447966e-02f, -1.63626209e-01f, -8.43333751e-02f, -2.04867497e-01f, -2.74292111e-01f,
  2.79120147e-01f, 4.02012855e-01f, 2.03433648e-01f, 1.99043438e-01f, 1.84387863e-01f, 1.64066389e-01f, 4.21289772e-01f, 1.28085986e-01f, 5.49786687e-02f, 2.79546559e-01f,
  -9.70037356e-02f, -2.36225843e-01f, -2.40488544e-01f, -1.91444829e-01f, 5.78545928e-02f, 3.01393330e-01f, 2.07447335e-01f, 9.04340148e-02f, 3.46153565e-02f, -3.19019407e-02f,
  5.39145432e-02f, 9.99890342e-02f, 2.53816210e-02f, 1.09851072e-02f, 6.36595413e-02f, -1.16532065e-01f, 3.02482881e-02f, 1.40157491e-01f, 1.38646066e-01f, 2.43261054e-01f,
  8.82937610e-02f, 1.57402843e-01f, 4.78739180e-02f, 5.97521141e-02f, 3.55135314e-02f, 8.09412822e-03f, 1.05267301e-01f, 6.79891482e-02f, 3.92873436e-02f, 1.26734689e-01f,
  -5.20968065e-02f, 1.05404131e-01f, -3.84874046e-02f, 7.99444597e-03f, -3.47821228e-03f, 7.19344541e-02f, 8.33322704e-02f, 2.67500561e-02f, -8.20358749e-03f, 1.50766745e-01f,
  1.02545090e-01f, 2.20016003e-01f, 6.63784519e-02f, 1.31249174e-01f, 9.52285305e-02f, -6.79727122e-02f, 1.37183085e-01f, 3.40625830e-02f, 7.74317980e-02f, 1.91241354e-01f,
  2.04937562e-01f, -6.77963942e-02f, -1.19600460e-01f, -1.18096195e-01f, -1.39090836e-01f, -1.94466382e-01f, -1.18045136e-01f, -1.76350251e-02f, -7.69084543e-02f, -1.14101462e-01f,
  -1.34497851e-01f, -8.24049041e-02f, -1.17110565e-01f, -6.41971827e-02f, -1.41780153e-01f, -4.37665656e-02f, 1.66683234e-02f, -1.30995780e-01f, -5.89959621e-02f, -7.59709030e-02f,
  -1.13020502e-01f, -8.54379609e-02f, -1.07477836e-01f, -1.81545883e-01f, -1.46163791e-01f, -1.11990124e-01f, -8.97019431e-02f, -1.32834420e-01f, -7.90741518e-02f, 2.73153372e-02f,
  -1.74157962e-01f, -1.15969561e-01f, 1.04663141e-01f, 3.45329493e-02f, 1.47396788e-01f, 8.90981704e-02f, 1.11031301e-01f, 3.58836912e-02f, -2.58130841e-02f, 7.50049055e-02f,
  4.89493534e-02f, 7.07223043e-02f, 6.63602054e-02f, 9.57921967e-02f, 5.74328452e-02f, 3.26064900e-02f, 1.59439519e-01f, 7.53662884e-02f, 5.92401344e-03f, 6.34633079e-02f,
  1.11188494e-01f, 1.64567336e-01f, 1.57163799e-01f, 6.33457750e-02f, 7.45460615e-02f, 1.14687935e-01f, 1.05613878e-03f, 1.27913922e-01f, 3.95819508e-02f, 2.38001302e-01f,
  7.25590885e-01f, 1.16851538e-01f, 1.05234630e-01f, 7.61560574e-02f, 5.31093031e-02f, 8.75720903e-02f, 1.72194242e-01f, 2.15368763e-01f, 1.70541525e-01f, 2.93534016e-03f,
  2.23390125e-02f, 4.30333167e-02f, 4.33759093e-02f, 2.45907959e-02f, 1.41775891e-01f, -8.05598646e-02f, -1.36841265e-02f, 6.63568079e-02f, 5.60223050e-02f, -1.16118722e-01f,
  -1.00941576e-01f, -2.17885412e-02f, 1.47801548e-01f, -3.78960408e-02f, -1.48412898e-01f, -4.16468196e-02f, 1.90070625e-02f, 4.71812747e-02f, -9.77467671e-02f, -1.68330431e-01f,
  -1.29501358e-01f, 2.82667935e-01f, -1.06306732e-01f, -7.91775584e-02f, -5.83372451e-03f, 7.26833194e-02f, 8.69728066e-03f, 3.07801701e-02f, 6.60470799e-02f, -6.85087517e-02f,
  4.66903148e-04f, -3.27035133e-03f, -8.02611336e-02f, 3.43823098e-02f, -6.08339123e-02f, -4.96973582e-02f, -8.37798323e-03f, 9.44015607e-02f, 3.59370746e-02f, -2.03334801e-02f,
  -9.81994197e-02f, -2.83961706e-02f, 9.93314683e-02f, -3.50297838e-02f, 5.61731048e-02f, 2.59530749e-02f, 7.03419670e-02f, 4.33753580e-02f, 1.82993207e-02f, 8.32773596e-02f,
  -3.80164087e-02f, 6.40205368e-02f, -3.03348750e-02f, -9.82650323e-04f, 6.20218851e-02f, -3.29553685e-03f, -1.37535492e-02f, -2.89477780e-02f, 5.79202920e-02f, -1.77408755e-02f,
  -9.07190070e-02f, 9.50990319e-02f, -4.53068949e-02f, 1.86310355e-02f, 1.52715882e-02f, -5.38230762e-02f, -5.79387918e-02f, 3.81906368e-02f, -9.09848586e-02f, -2.86780987e-02f,
  -2.49095224e-02f, 3.63094062e-02f, -3.37049104e-02f, -7.47604668e-02f, -5.15282378e-02f, 6.63576135e-03f, -6.25418499e-03f, 2.03202106e-02f, 1.71251941e-05f, 5.51986098e-02f,
  -6.43015355e-02f, 9.90319550e-02f, -6.37446567e-02f, -1.15202395e-02f, 4.03103381e-02f, 5.61901107e-02f, -2.94915084e-02f, -1.82685982e-02f, 4.62382585e-02f, -4.54659611e-02f,
  4.57777828e-02f, 3.92561667e-02f, -2.81005981e-03f, -9.95392725e-02f, 9.41554159e-02f, 5.05380519e-02f, -2.90376898e-02f, 6.96547851e-02f, -5.11692241e-02f, -5.14893122e-02f,
  7.13690296e-02f, 1.43232599e-01f, 1.10639736e-01f, 1.58465374e-02f, -1.52035523e-02f, 1.42627224e-01f, 3.52600473e-04f, 9.79440585e-02f, 2.02614263e-01f, 1.97962627e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.30640280e-01f, -6.23811066e-01f, -2.84002393e-01f, 4.25285995e-01f, -2.17702478e-01f, -4.31388497e-01f, -6.97387695e-01f, 2.76531316e-02f, 4.77169454e-01f, -5.61119676e-01f,
  -1.97218627e-01f, 4.66168791e-01f, 5.09271860e-01f, 3.21570992e-01f, 2.24283889e-01f, -5.87207556e-01f, -4.25168782e-01f, 1.31612226e-01f, 1.34909019e-01f, -3.47142220e-01f,
  -5.01314759e-01f, -5.04690558e-02f, 1.70514748e-01f, 3.43267135e-02f, -3.74308139e-01f, -9.22850072e-02f, -3.94822687e-01f, -2.83839941e-01f, -5.49681306e-01f, -6.96826220e-01f,
  -4.26128387e-01f, 3.41392718e-02f, -1.34945303e-01f, 1.82224244e-01f, -1.27190456e-01f, 7.35962689e-02f, -1.54678762e-01f, 5.22056855e-02f, -3.52459140e-02f, -1.22601941e-01f,
  -5.99688068e-02f, -3.62291634e-02f, 1.55771002e-01f, -1.39198765e-01f, -5.35308160e-02f, -1.31761990e-02f, -1.40019521e-01f, -6.44633695e-02f, 1.37272120e-01f, -3.48635882e-01f,
  -4.27357793e-01f, -4.11685467e-01f, -5.81004433e-02f, -1.87030718e-01f, 6.73641339e-02f, 3.32725197e-01f, -4.27452296e-01f, -2.06662089e-01f, -1.11951776e-01f, -4.81015146e-01f,
  -5.83883598e-02f, 5.65323457e-02f, -1.12618528e-01f, -5.81653696e-03f, -1.53397858e-01f, 6.30914792e-02f, 8.64545405e-02f, -2.64392674e-01f, -1.36121437e-01f, -2.14417174e-01f,
  -4.42966036e-02f, -3.09616067e-02f, 1.80666968e-01f, -1.40198067e-01f, -1.84014663e-01f, -1.37916043e-01f, -1.15775138e-01f, -1.14521332e-01f, -1.44863233e-01f, -3.62932757e-02f,
  8.89436230e-02f, -1.15622178e-01f, 1.60927787e-01f, 1.16916886e-02f, -7.00982511e-02f, 1.51930600e-01f, 1.01279542e-02f, -4.83849272e-02f, 1.79483637e-01f, -1.01380080e-01f,
  4.87779856e-01f, 2.11800579e-02f, 4.48350906e-02f, -6.64103925e-02f, -7.52071664e-02f, 1.03585057e-01f, -9.76421591e-03f, -1.94080882e-02f, 1.60497144e-01f, 3.42525840e-02f,
  -9.19660777e-02f, 1.22575715e-01f, 9.29565951e-02f, -1.82772055e-02f, -1.18487500e-01f, -5.98498657e-02f, -2.63257027e-01f, -7.92588443e-02f, -1.89771131e-01f, -1.76281691e-01f,
  -1.73886538e-01f, -9.78489444e-02f, 1.63256645e-01f, 2.99961362e-02f, -1.22119620e-01f, 1.24126367e-01f, -4.37731773e-01f, -3.47448558e-01f, 9.33923572e-02f, -4.17565167e-01f,
  -6.88696921e-01f, 4.72347289e-01f, 2.79047014e-03f, -4.67740804e-01f, 4.82827686e-02f, 3.49247575e-01f, 2.96134055e-01f, -1.00443652e-02f, -2.29703799e-01f, -9.15107876e-03f,
  -7.45292306e-02f, -2.76980311e-01f, -1.80364236e-01f, 1.47337884e-01f, 1.70556501e-01f, 5.25050163e-01f, 5.43948770e-01f, 2.02722728e-01f, -2.61580609e-02f, 1.66373089e-01f,
  1.92862660e-01f, -6.68968931e-02f, -2.98200160e-01f, -4.15907800e-02f, -7.42458999e-02f, 8.40309355e-03f, -6.93990588e-02f, -4.14223447e-02f, 4.11767095e-01f, 5.09938538e-01f,
  -3.17200392e-01f, -2.95711070e-01f, -7.16577396e-02f, -9.41159502e-02f, -8.87233540e-02f, 1.65392697e-01f, 1.77309617e-01f, -6.98177069e-02f, 5.76007850e-02f, -7.15720467e-03f,
  7.91335851e-02f, 1.91256762e-01f, -6.14305623e-02f, -8.62113386e-03f, -1.46906465e-01f, -2.06553981e-01f, 1.46143436e-02f, -1.36752101e-02f, -2.28601784e-01f, 1.37506183e-02f,
  5.65262437e-01f, -5.44169731e-02f, -4.47491258e-01f, 1.00646503e-02f, -4.83722389e-02f, -3.24821562e-01f, -2.23023921e-01f, -9.02015716e-03f, -1.82479724e-01f, -1.79557726e-01f,
  -3.12630013e-02f, -1.68309873e-03f, 1.33877724e-01f, 2.50979960e-02f, 5.96264713e-02f, -3.65168881e-03f, 1.30217269e-01f, 2.40180463e-01f, 1.25070766e-01f, -1.72221903e-02f,
  -7.18568489e-02f, -1.76401809e-01f, -1.21684805e-01f, -1.35847017e-01f, -8.78906250e-02f, -1.03566431e-01f, 1.04285538e-01f, 1.97771400e-01f, 4.89854850e-02f, 4.85950746e-02f,
  -6.28573745e-02f, 2.72611231e-02f, -8.68499354e-02f, -8.87241960e-03f, 1.40131190e-01f, -5.14666401e-02f, 5.34692816e-02f, -1.61889225e-01f, -1.92673668e-01f, -2.34698374e-02f,
  -5.13421118e-01f, 2.52214640e-01f, -1.68290183e-01f, 9.53792557e-02f, -1.21969581e-01f, -1.35926276e-01f, -1.99507754e-02f, -7.16008097e-02f, -1.22978814e-01f, -1.89657718e-01f,
  -1.09807089e-01f, -1.03503816e-01f, -2.38696054e-01f, 3.53494026e-02f, -2.03983262e-01f, -5.28069995e-02f, 2.57151216e-01f, 3.81224565e-02f, -4.18157354e-02f, -8.48687589e-02f,
  1.06999829e-01f, -1.88658908e-01f, -6.19552374e-01f, -2.28923008e-01f, -6.75162748e-02f, -6.13997281e-01f, -4.02786344e-01f, -3.23416680e-01f, -3.09501410e-01f, -2.73298442e-01f,
  5.19242167e-01f, 4.16358858e-01f, -4.90441799e-01f, 4.54678386e-01f, 1.34346187e-01f, -2.63472766e-01f, 6.79040141e-03f, 1.92098245e-01f, 3.60479623e-01f, 3.77361804e-01f,
  1.73791274e-01f, -3.95305961e-01f, -2.89896667e-01f, -4.48255152e-01f, -6.35638893e-01f, -1.48056597e-01f, -2.91835964e-01f, -8.49303782e-01f, -8.62338245e-01f, -3.44084114e-01f,
  1.46819070e-01f, 2.89792687e-01f, 1.87736526e-01f, -8.35937187e-02f, 2.29525998e-01f, -1.87557414e-01f, 1.71689585e-01f, 1.82162225e-01f, -1.76053077e-01f, -2.22147524e-01f,
  -3.27432483e-01f, 1.70896828e-01f, -1.60005689e-01f, 1.16669402e-01f, 1.40120625e-01f, -6.12514233e-03f, -8.23828802e-02f, -1.78753436e-02f, 1.96796373e-01f, 1.56305611e-01f,
  -1.22053372e-02f, 3.22677903e-02f, -8.62462297e-02f, -1.11706093e-01f, 1.61793351e-01f, -4.25659269e-02f, 2.35374063e-01f, -1.01890348e-01f, -8.77582207e-02f, -9.36906412e-03f,
  1.27460793e-01f, -1.35664821e-01f, -2.30763867e-01f, 1.01947479e-01f, -8.06896836e-02f, -3.40011895e-01f, 5.28254770e-02f, -1.02691263e-01f, -3.03385913e-01f, 2.39576459e-01f,
  -1.09697342e-01f, 8.47817436e-02f, 9.50787514e-02f, 2.07544371e-01f, 2.75359869e-01f, 6.55914471e-02f, 1.19792715e-01f, 7.23710191e-03f, -2.84594744e-02f, 7.91989267e-02f,
  8.38140845e-02f, 5.81561886e-02f, 3.79805197e-03f, 1.66230962e-01f, -2.98980530e-02f, -9.05457214e-02f, -3.26339416e-02f, 1.30184352e-01f, 2.77000107e-03f, 7.19973594e-02f,
  -6.29644617e-02f, -1.75543074e-02f, 1.23636045e-01f, 6.32681623e-02f, -6.87629869e-03f, 1.64746549e-02f, -3.30715962e-02f, -1.72433704e-02f, -2.61873826e-02f, -4.67078425e-02f,
  2.67357469e-01f, -3.27274114e-01f, 9.98125002e-02f, -1.23077877e-01f, -4.80746897e-03f, 9.61594954e-02f, 9.52898860e-02f, 6.13705032e-02f, 8.65318403e-02f, 3.19368616e-02f,
  -1.54231101e-01f, -6.32614121e-02f, 7.85720721e-02f, -3.16673890e-02f, -1.14141576e-01f, -8.73722285e-02f, 1.77104935e-01f, -6.11397922e-02f, 1.51857110e-02f, 1.85322762e-01f,
  2.71385401e-01f, 9.09216031e-02f, 1.21646840e-02f, -1.27276601e-02f, 4.23663296e-02f, -1.37089431e-01f, -1.63083032e-01f, -1.64762989e-03f, -2.97065705e-01f, 3.83554310e-01f,
  9.63856697e-01f, 7.44461343e-02f, -4.44731981e-01f, 6.50452137e-01f, -6.08338237e-01f, -5.54982841e-01f, -2.44599298e-01f, 3.20951879e-01f, 9.16778594e-02f, -2.57462025e-01f,
  -6.83202386e-01f, -6.88245237e-01f, -8.09488297e-01f, -4.66321081e-01f, -3.64504531e-02f, 1.05748951e-01f, 1.15085892e-01f, 1.67117551e-01f, 3.02417390e-02f, 8.81660953e-02f,
  -2.35702358e-02f, 5.50787449e-01f, 6.77599788e-01f, 4.44728851e-01f, 3.36100534e-02f, -1.55101344e-01f, -1.24455281e-01f, -1.02312908e-01f, -3.41596544e-01f, -1.95289567e-01f,
  -3.79111052e-01f, 2.19319791e-01f, -3.53730857e-01f, -8.99860412e-02f, -3.90403330e-01f, 1.40326813e-01f, -1.46908667e-02f, 5.60560636e-02f, -1.75427243e-01f, -2.20182598e-01f,
  -4.88930643e-01f, -2.14521185e-01f, -4.49647456e-01f, -2.09107101e-01f, 5.68506047e-02f, 5.82184875e-03f, 4.69592065e-01f, 3.46907467e-01f, 1.98982239e-01f, -1.66048944e-01f,
  -4.03222591e-01f, -2.50907093e-01f, -1.82337239e-01f, -5.75872585e-02f, 2.06858888e-02f, -2.65087783e-01f, -3.17304403e-01f, -2.09491923e-01f, -7.42629692e-02f, 3.37544978e-01f,
  2.64908560e-02f, -1.02858409e-01f, -7.70433620e-02f, -5.18970974e-02f, 1.94354773e-01f, -1.04145497e-01f, -9.17393714e-03f, 1.06740482e-01f, -1.62861094e-01f, 2.04441715e-02f,
  4.55572568e-02f, 1.41016215e-01f, -9.32786390e-02f, 1.02135509e-01f, -8.18750728e-03f, -8.75089318e-02f, -1.22354202e-01f, 2.59622365e-01f, 5.78455292e-02f, 1.83874100e-01f,
  3.90354320e-02f, -1.66378990e-01f, -1.27212971e-01f, 6.15778714e-02f, -6.92739571e-03f, -1.54233454e-02f, -1.22882240e-01f, -1.70492977e-02f, 1.66699007e-01f, -9.16841030e-02f,
  5.21488041e-02f, -3.77606690e-01f, -7.06548169e-02f, 9.39205587e-02f, -1.98948026e-01f, -2.30667859e-01f, -2.39011049e-01f, -2.42962502e-02f, -1.65141374e-01f, -6.16242029e-02f,
  -2.30126441e-01f, 1.44908831e-01f, -5.11440486e-02f, -1.73325807e-01f, -2.19411850e-02f, -1.42788123e-02f, 8.32263306e-02f, -1.61064431e-01f, -5.70396110e-02f, -9.48794857e-02f,
  1.85171679e-01f, 2.08738506e-01f, 1.25252053e-01f, -9.29110050e-02f, -1.67051852e-01f, -5.46857454e-02f, -1.67165563e-01f, -1.71246007e-02f, -1.14606701e-01f, 5.48491478e-01f,
  2.20904216e-01f, -4.91371229e-02f, 5.34225881e-01f, 1.02593422e-01f, -4.38270301e-01f, -5.38279772e-01f, -7.89928973e-01f, -3.83367300e-01f, 9.95339453e-02f, -7.14288233e-03f,
  -2.46704236e-01f, -1.40932620e-01f, 2.13852018e-01f, 8.18337128e-02f, -1.11226618e-01f, 1.45391002e-01f, 1.69432327e-01f, 3.04973632e-01f, -1.71277344e-01f, -4.39531147e-01f,
  -2.49771938e-01f, -4.94668260e-02f, 1.52536452e-01f, 1.84092328e-01f, 3.85031760e-01f, 1.02246530e-01f, 2.20536068e-01f, 1.62710503e-01f, 3.47119980e-02f, 6.08472764e-01f,
  6.26504123e-01f, 1.53183222e-01f, -1.31376788e-01f, 5.77768870e-02f, 1.35609508e-01f, 1.50968775e-01f, 3.40458415e-02f, 2.98635989e-01f, -1.19785070e-02f, 6.63301945e-02f,
  9.32075530e-02f, 2.14729793e-02f, 8.20389166e-02f, 7.16996714e-02f, -7.43121188e-03f, -7.29791597e-02f, 1.30636856e-01f, 1.82931479e-02f, 1.59226164e-01f, 1.28019318e-01f,
  -2.77460385e-02f, -1.50626168e-01f, -2.12106869e-01f, -1.79608971e-01f, 3.29267606e-02f, -7.50007033e-02f, -1.55188054e-01f, 8.41445699e-02f, -6.27807304e-02f, 2.18712628e-01f,
  -1.01741850e-01f, 1.27550513e-01f, 1.27505669e-02f, -6.39304072e-02f, -1.12192079e-01f, 2.61095688e-02f, 2.02898402e-02f, -1.05100222e-01f, -7.63755515e-02f, 4.91041765e-02f,
  6.02090172e-03f, -9.02873352e-02f, 3.16858403e-02f, 4.49813232e-02f, 1.81602195e-01f, 1.47823632e-01f, 4.04317826e-02f, 1.95179507e-02f, -6.22700416e-02f, 1.56935647e-01f,
  -4.62731570e-02f, 4.79685403e-02f, 1.67459100e-01f, 5.44125773e-02f, 3.69941667e-02f, 7.58358762e-02f, 1.41672745e-01f, 4.26904391e-03f, 4.99464050e-02f, 6.17432371e-02f,
  8.78643915e-02f, -3.90127242e-01f, 1.94875628e-01f, 1.51143044e-01f, 1.27452061e-01f, 2.05622092e-01f, 1.47721112e-01f, 2.11469084e-02f, 8.93440470e-02f, 8.79768357e-02f,
  -1.05360232e-01f, 7.49978945e-02f, 7.42652789e-02f, 4.28545177e-02f, -9.49990451e-02f, -3.08466814e-02f, -1.82647258e-02f, -3.90723981e-02f, 1.74273569e-02f, 9.38035697e-02f,
  2.61534043e-02f, -3.57024938e-01f, -3.99245918e-01f, -1.04073353e-01f, -3.79805341e-02f, -1.49796233e-01f, -2.04732195e-01f, -1.12388335e-01f, -2.66492903e-01f, -2.39111662e-01f,
  -4.54535782e-02f, 3.99143189e-01f, 5.19101858e-01f, 6.55835420e-02f, 4.97423291e-01f, 4.46078509e-01f, 3.26042950e-01f, -9.63058770e-02f, -2.84508884e-01f, 8.47676620e-02f,
  4.51937109e-01f, -9.91604477e-02f, -2.39515945e-01f, -4.76331174e-01f, -6.21250510e-01f, -2.29557216e-01f, -2.78229624e-01f, -4.12691712e-01f, -5.19893408e-01f, -3.78105074e-01f,
  -3.13128442e-01f, -2.28305265e-01f, -3.12359720e-01f, -2.28372231e-01f, 2.81859506e-02f, -5.13080508e-02f, 4.40911770e-01f, 2.42613196e-01f, 3.03031176e-01f, 6.96736723e-02f,
  8.18798020e-02f, 1.99146137e-01f, -2.29101628e-01f, -1.16743810e-01f, 2.00306237e-01f, -1.73061341e-01f, -6.54427484e-02f, -3.14034745e-02f, 5.86319678e-02f, -1.70529470e-01f,
  1.26321420e-01f, 3.42878699e-02f, 9.49514192e-03f, -4.59782071e-02f, -5.38860932e-02f, -1.46597520e-01f, -2.47984175e-02f, -2.51024336e-01f, -7.49675184e-02f, -5.60065731e-02f,
  2.99203657e-02f, 2.40543589e-01f, 1.49407446e-01f, -4.54134718e-02f, -4.37173061e-02f, -7.15565830e-02f, 1.20948285e-01f, 7.22118020e-02f, 7.95557648e-02f, -1.60204858e-01f,
  -1.81631535e-01f, -6.04420677e-02f, 2.12103277e-02f, -1.14307301e-02f, -9.05323848e-02f, 8.45189840e-02f, -3.57333347e-02f, -3.75176556e-02f, -3.96799333e-02f, -5.86336479e-02f,
  -4.94520888e-02f, 7.71787986e-02f, -1.03355370e-01f, -1.57519188e-02f, -8.68878812e-02f, 8.44838396e-02f, 6.72799721e-02f, -6.43864349e-02f, 1.72259554e-01f, 1.99647108e-03f,
  -1.71265155e-02f, -8.86112545e-03f, 1.91782210e-02f, -1.29326716e-01f, 9.50080436e-03f, 6.03079759e-02f, 1.65315270e-02f, -9.11639333e-02f, -6.16534017e-02f, 1.09154219e-02f,
  -2.14393407e-01f, 2.28811726e-01f, -1.76824808e-01f, -1.98990926e-01f, 1.50169477e-01f, 1.09189518e-01f, 2.34205499e-01f, 1.74613312e-01f, 2.00197056e-01f, -2.53380626e-01f,
  4.45340760e-02f, -7.36911297e-02f, 7.44979009e-02f, 5.60120447e-03f, -1.57994106e-01f, -1.83307081e-02f, -1.30749075e-02f, 5.20037003e-02f, 2.18392769e-03f, 1.09622933e-01f,
  -2.00205483e-02f, -1.93946332e-01f, -3.37399989e-01f, -3.57280225e-02f, -1.66342616e-01f, -2.79374063e-01f, -7.55393058e-02f, -3.43678636e-03f, 4.94193397e-02f, -2.99077630e-01f,
  -4.38370347e-01f, -3.85257870e-01f, 1.41160995e-01f, 3.68180066e-01f, 4.43011284e-01f, 2.96115696e-01f, 2.05631912e-01f, 1.41354024e-01f, 3.51248384e-01f, 1.35363594e-01f,
  -1.46273198e-02f, 1.71822324e-01f, 1.04170084e-01f, 1.23043224e-01f, 2.34931678e-01f, 2.66942263e-01f, 4.28791195e-01f, 1.61035702e-01f, 1.96175054e-01f, 1.26476109e-01f,
  2.41035298e-01f, 2.21640766e-02f, -1.01522632e-01f, 1.08178996e-01f, 1.37522265e-01f, 2.29906082e-01f, 1.59249038e-01f, 5.97000159e-02f, 8.72817263e-02f, 1.00922622e-01f,
  2.03386620e-02f, -2.27280051e-01f, 1.80953801e-01f, 3.70610058e-02f, -1.33974403e-01f, -2.40851268e-01f, -4.20250744e-02f, -6.90381154e-02f, -1.71781152e-01f, 1.04230456e-01f,
  -3.75022963e-02f, -6.34659901e-02f, -3.74745019e-02f, -1.58522844e-01f, -1.01649590e-01f, -1.39562473e-01f, -7.30394572e-02f, 8.75404254e-02f, 8.15502927e-02f, -6.35699257e-02f,
  -1.10879920e-01f, 9.89167914e-02f, 1.12952866e-01f, 1.39497727e-01f, 1.97283849e-01f, 9.47581977e-02f, -8.19131583e-02f, -6.65296540e-02f, 1.17223896e-01f, -1.15274685e-02f,
  1.16594084e-01f, -7.48815313e-02f, 2.23266929e-01f, 8.76489561e-03f, 2.60903826e-03f, -1.90128405e-02f, 1.70861900e-01f, 1.70147449e-01f, 1.79425731e-01f, 9.45362523e-02f,
  1.29955053e-01f, 2.72660762e-01f, 5.79272434e-02f, 1.01165392e-01f, 1.71732292e-01f, 9.54907089e-02f, -1.02924313e-02f, 1.39763104e-02f, 8.16621557e-02f, 1.08520292e-01f,
  1.18027419e-01f, 2.60527544e-02f, -2.45450839e-01f, 1.42883416e-02f, -7.17680305e-02f, 4.05838564e-02f, 1.26379132e-01f, -7.51041016e-03f, -1.31754754e-02f, -3.58762443e-02f,
  2.91414559e-01f, 3.65584403e-01f, 4.40967493e-02f, -1.25473976e-01f, -8.59741643e-02f, -2.65440732e-01f, 1.27098173e-01f, -1.72450155e-01f, -1.08999938e-01f, 1.35122929e-02f,
  -4.59664203e-02f, -1.76789537e-01f, 1.09493989e-03f, -7.17419013e-02f, -3.22503522e-02f, 1.55989351e-02f, -1.78399906e-01f, 1.24994978e-01f, 1.42321318e-01f, 2.00519804e-02f,
  -1.90822408e-02f, 1.30493492e-01f, 1.93022445e-01f, 2.10620165e-01f, 2.01152518e-01f, 9.15795714e-02f, -5.51155806e-02f, -3.71892601e-02f, 6.40814379e-02f, -5.54686645e-03f,
  6.85361743e-01f, -1.88003361e-01f, 3.75195756e-03f, 1.29806653e-01f, 1.76991731e-01f, -1.83682132e-03f, -1.82317361e-01f, -8.96282494e-02f, 1.30729690e-01f, 2.15170726e-01f,
  3.29561532e-01f, 3.93736035e-01f, 1.59619361e-01f, 2.09386587e-01f, 4.48175482e-02f, -1.12656973e-01f, -1.56538174e-01f, 9.75977704e-02f, 1.50318995e-01f, 1.42194331e-01f,
  1.67453781e-01f, -5.36310449e-02f, 1.70470312e-01f, 3.39939445e-02f, 5.33309840e-02f, 1.16292268e-01f, -7.40826949e-02f, 3.92174087e-02f, 1.16522819e-01f, -1.43786624e-01f,
  8.59216005e-02f, 7.94626623e-02f, 1.44189373e-01f, 1.12231202e-01f, -2.04390008e-02f, -6.82274401e-02f, -8.82399678e-02f, -1.44497484e-01f, 3.59658152e-02f, -8.27124268e-02f,
  3.22970487e-02f, 1.08332030e-01f, -6.20261803e-02f, -7.83297420e-02f, -5.56443632e-02f, 6.60578087e-02f, -7.93483630e-02f, -1.27750695e-01f, -2.72902306e-02f, -4.55519669e-02f,
  7.98690990e-02f, 1.48048460e-01f, 1.47369923e-04f, 2.73988284e-02f, 7.30397031e-02f, 9.91473421e-02f, 5.16261160e-02f, 9.75690857e-02f, -1.81595162e-02f, -3.53987813e-02f,
  1.58876255e-01f, 4.64534998e-01f, 4.13502336e-01f, 1.46108359e-01f, 2.23229513e-01f, 1.39869764e-01f, -8.48090425e-02f, -2.02857591e-02f, -2.34700460e-02f, 1.20692685e-01f,
  1.24830194e-02f, 1.15040965e-01f, -2.54848506e-03f, 2.15252116e-01f, 2.58499175e-01f, 1.32186174e-01f, 2.23557130e-01f, 1.83427110e-01f, 9.72056985e-02f, -2.74737808e-03f,
  4.45582010e-02f, -2.43404936e-02f, 6.77458942e-02f, -9.80952084e-02f, 9.50324237e-02f, 1.97708160e-01f, 1.22895084e-01f, 2.13879287e-01f, 2.64259309e-01f, 1.18297875e-01f,
  -2.40195215e-01f, 1.31205432e-02f, 1.26723275e-01f, -5.51651046e-02f, -9.02608335e-02f, 1.06125753e-02f, 4.34574299e-02f, -1.33835703e-01f, -2.30923012e-01f, -1.58723891e-01f,
  -1.30205423e-01f, 4.22849916e-02f, -6.29267693e-02f, -1.43687353e-01f, 2.67201774e-02f, 7.72721916e-02f, 3.82953249e-02f, -1.92154925e-02f, -9.72757414e-02f, -1.58517882e-01f,
  -3.17075886e-02f, -5.66056231e-04f, 1.26315728e-01f, 1.63879003e-02f, 9.79584060e-04f, 2.29329005e-01f, 4.33022268e-02f, 4.14412655e-02f, 8.38964060e-02f, -1.81342562e-04f,
  -1.68439358e-01f, 1.63112894e-01f, 3.47912908e-02f, -7.55771771e-02f, 4.04140502e-01f, 4.89067994e-02f, -4.61317450e-01f, -5.52643478e-01f, -2.12386847e-01f, -8.55796710e-02f,
  4.92284328e-01f, 1.75806805e-01f, -1.71355829e-01f, -2.21439719e-01f, -3.96006405e-01f, -3.53457570e-01f, -2.50753284e-01f, -2.72764266e-01f, -1.13351032e-01f, 2.72666514e-01f,
  1.84349090e-01f, -2.21834294e-02f, -2.92677097e-02f, -2.18696356e-01f, 6.73296768e-03f, -7.85038173e-02f, -1.89323142e-01f, 2.98998594e-01f, 1.07427187e-01f, 1.74609780e-01f,
  2.05272868e-01f, 2.13367149e-01f, -1.40054613e-01f, 3.12946916e-01f, 2.68189013e-01f, -3.42846811e-01f, -1.67321920e-01f, 1.02387657e-02f, -1.04086198e-01f, -7.10076988e-02f,
  3.67524981e-01f, 2.67998904e-01f, 1.25955895e-01f, -5.81253991e-02f, 8.28302205e-02f, -1.99138522e-01f, -1.05333030e-01f, -1.56209767e-01f, -4.23594922e-01f, 1.42158672e-01f,
  3.55119973e-01f, 4.81645077e-01f, 1.27974525e-01f, -2.78550237e-01f, -4.94685829e-01f, -2.66181558e-01f, -3.18608791e-01f, -2.92235196e-01f, -6.14872873e-01f, -6.30982399e-01f,
  2.87171453e-02f, 1.72491804e-01f, -1.41147738e-02f, -1.08733907e-01f, -2.63221323e-01f, -6.32792190e-02f, 2.83305142e-02f, 5.66080175e-02f, 1.26386821e-01f, -7.91418105e-02f,
  2.01440752e-01f, 1.99381441e-01f, 1.51548699e-01f, -7.19836727e-02f, -5.12509681e-02f, 1.32229403e-01f, 3.34337503e-02f, -1.75960898e-01f, -8.28172490e-02f, -9.65522453e-02f,
  1.33755673e-02f, 2.44205687e-02f, 5.25015183e-02f, -1.39028221e-01f, -1.17879339e-01f, -2.15284482e-01f, -4.50245701e-02f, -1.11934412e-02f, -2.83285957e-02f, -3.19289453e-02f,
  -3.46898496e-01f, 4.09890488e-02f, -3.39349508e-01f, 7.64572248e-02f, 9.04549882e-02f, 5.95584586e-02f, -2.89260428e-02f, 1.10118002e-01f, 1.11188903e-01f, -1.39967814e-01f,
  1.92004725e-01f, -9.85489562e-02f, -1.89600423e-01f, -6.06731698e-02f, 6.03525415e-02f, -6.82714209e-02f, 1.83548220e-02f, -2.21645348e-02f, -6.50292709e-02f, 4.49607857e-02f,
  -2.76948720e-01f, -3.75437915e-01f, -4.25495774e-01f, -4.51311082e-01f, -1.75438710e-02f, -3.43656391e-01f, -5.12093365e-01f, -4.20361012e-01f, -5.31638861e-01f, -7.48825371e-01f,
  6.90263808e-01f, -1.76165864e-01f, -9.41263556e-01f, 3.86021346e-01f, 1.94852315e-02f, -4.91336107e-01f, -6.65747881e-01f, -1.82100534e-01f, 4.45315808e-01f, -3.34029198e-02f,
  5.51153682e-02f, 2.78911144e-01f, -9.39284712e-02f, -3.87197375e-01f, -7.49986410e-01f, -7.98530757e-01f, -8.01977038e-01f, -7.78931320e-01f, -5.92568457e-01f, -2.58893520e-02f,
  4.16410536e-01f, 2.31570736e-01f, 2.63609532e-02f, -3.12450100e-02f, 3.25102001e-01f, 1.16628304e-01f, -1.67588457e-01f, -2.36989539e-02f, -3.96125197e-01f, -1.48304507e-01f,
  -6.11900270e-01f, -1.92906260e-01f, -2.92841256e-01f, 1.83485687e-01f, 4.36813235e-02f, 4.97834273e-02f, -9.86496210e-02f, -5.85851409e-02f, 6.62517920e-02f, -4.64624427e-02f,
  9.11448374e-02f, 8.82106647e-02f, 1.08295925e-01f, -4.24552858e-02f, -2.02676374e-02f, -1.73326597e-01f, -4.29017358e-02f, -2.26461992e-01f, -2.20547691e-01f, -1.40216142e-01f,
  3.65452953e-02f, -2.51867712e-01f, -4.38321680e-01f, -3.83002639e-01f, -4.11477715e-01f, -1.25369236e-01f, -2.37616718e-01f, -1.51252985e-01f, -4.80203152e-01f, 2.88866818e-01f,
  -8.67294073e-02f, 8.02570805e-02f, 5.72541691e-02f, 1.60669714e-01f, 2.07678452e-01f, 1.32632747e-01f, 3.46565023e-02f, 2.11578589e-02f, -1.98780484e-02f, 3.90766598e-02f,
  -6.94660470e-02f, -8.31002742e-02f, -1.76819250e-01f, -1.48748174e-01f, -1.19221963e-01f, -1.51716257e-02f, -9.04904082e-02f, -7.45148808e-02f, -1.26314610e-01f, 7.97186196e-02f,
  -1.10306905e-03f, 3.60513362e-03f, 9.25260484e-02f, 1.40196469e-04f, -1.97603032e-01f, -1.57674357e-01f, -8.56419429e-02f, -8.85257497e-02f, 4.99988757e-02f, -2.66974103e-02f,
  4.33272511e-01f, -5.14230609e-01f, 1.21090658e-01f, -2.10637733e-01f, -1.30325720e-01f, 9.76603404e-02f, 1.93471208e-01f, 4.49732430e-02f, 1.48955837e-01f, -8.44361354e-03f,
  -3.14657331e-01f, 5.35512455e-02f, 7.35940319e-03f, 3.30792926e-02f, -5.98978885e-02f, -5.00087142e-02f, 8.77563506e-02f, 2.41414197e-02f, -1.17977567e-01f, 2.62600422e-01f,
  1.22941425e-02f, -1.43237621e-01f, 8.16276595e-02f, 7.58742564e-04f, 7.39904121e-02f, -8.97312909e-02f, -7.71723613e-02f, 1.71926920e-04f, -2.90601313e-01f, 3.55155617e-01f,
  4.35866892e-01f, -8.83094072e-02f, -2.92084366e-02f, 2.46986166e-01f, -2.22039353e-02f, -1.41946107e-01f, -1.20084681e-01f, 3.09096593e-02f, 1.79686114e-01f, 1.94146469e-01f,
  2.79906932e-02f, 2.82363743e-01f, 2.88806289e-01f, 2.30843112e-01f, 6.17519543e-02f, 1.77343994e-01f, 1.57056764e-01f, 2.06888244e-01f, 1.44560978e-01f, 1.30943969e-01f,
  2.14814797e-01f, 4.56236340e-02f, 1.27008587e-01f, 1.67295247e-01f, 2.25262970e-01f, 1.60676122e-01f, 8.03725347e-02f, -2.50739716e-02f, 1.72964856e-01f, 2.68979043e-01f,
  2.42532879e-01f, 1.17819145e-01f, 6.20827591e-03f, 6.56954348e-02f, -1.29346058e-01f, -3.61699564e-03f, -3.98329645e-02f, -3.44555788e-02f, 4.71021514e-03f, -6.52253702e-02f,
  -9.67924856e-03f, 3.87622342e-02f, -4.83772494e-02f, 5.96818663e-02f, -4.30642478e-02f, -1.31784156e-01f, -1.26550347e-03f, 1.87357351e-01f, 2.39020046e-02f, -4.77035679e-02f,
  8.53905901e-02f, -7.23477975e-02f, -1.04457803e-01f, -1.41609982e-01f, 1.79268345e-02f, -3.93977463e-02f, -3.52998413e-02f, 8.42071548e-02f, -1.01752253e-02f, 2.54674684e-02f,
  2.78283030e-01f, 9.01120007e-02f, 1.27809554e-01f, 2.57804364e-01f, 3.65145594e-01f, 1.20334074e-01f, 3.44473608e-02f, 3.29882163e-03f, 1.96518943e-01f, 3.80476043e-02f,
  -5.33236526e-02f, 4.05888818e-02f, 3.85953225e-02f, 4.85563539e-02f, 1.83313154e-02f, -1.29470095e-01f, -1.35170490e-01f, -1.07094482e-01f, -1.20134056e-02f, 3.28050889e-02f,
  9.98378769e-02f, -7.46972933e-02f, 9.30879265e-03f, 8.37238207e-02f, -9.42690000e-02f, 7.79732913e-02f, 4.72685210e-02f, -1.71226233e-01f, -1.87437534e-01f, -2.01025996e-02f,
  -5.20214438e-01f, -2.22929731e-01f, 2.37939492e-01f, 3.45566534e-02f, -5.00518195e-02f, -6.73826039e-02f, 1.10456673e-03f, -3.23868245e-02f, -1.40257254e-01f, -6.96715117e-02f,
  -1.75584197e-01f, 9.50382426e-02f, -1.01416543e-01f, -1.29732573e-02f, -1.64512347e-03f, 3.68534513e-02f, 1.04808114e-01f, 8.86594353e-04f, -6.75475821e-02f, -8.74919891e-02f,
  -1.69733480e-01f, -2.01750591e-01f, -3.11119914e-01f, -1.60333604e-01f, 4.44328375e-02f, -1.13352947e-01f, -1.11062564e-01f, -1.12475671e-01f, -1.57205179e-01f, -1.96101800e-01f,
  -8.27965677e-01f, -3.47252667e-01f, -1.47517338e-01f, -6.70318067e-01f, 1.04129445e-02f, 1.88679859e-01f, 3.01056415e-01f, -8.09259340e-03f, -4.69533831e-01f, -3.00798506e-01f,
  7.02086464e-02f, -8.85849297e-02f, -2.96276480e-01f, 1.84819445e-01f, 4.21661288e-01f, 3.78553718e-02f, 1.40748292e-01f, 2.60803819e-01f, 4.58262920e-01f, 5.25344133e-01f,
  3.54669005e-01f, 5.48302233e-02f, 1.35907248e-01f, 1.62050843e-01f, -4.02657270e-01f, 4.28337492e-02f, -1.12239197e-01f, -4.54728380e-02f, 2.30643049e-01f, -4.83465940e-01f,
  -5.26073277e-01f, -5.76841176e-01f, 1.82658747e-01f, 1.30351141e-01f, 9.89401788e-02f, -1.84346765e-01f, 1.26988560e-01f, 6.42210171e-02f, 3.54556018e-03f, -2.24208206e-01f,
  -9.95413512e-02f, -3.20085627e-03f, -1.67680115e-01f, 1.90425217e-02f, -9.78980958e-02f, 7.47642145e-02f, 9.71588790e-02f, -5.38095310e-02f, -1.27440974e-01f, -3.84236798e-02f,
  3.69077712e-01f, -8.99198186e-03f, -3.69351000e-01f, 1.14728600e-01f, -3.25930953e-01f, -3.58131155e-02f, 1.52034238e-01f, -1.29318550e-01f, 1.36532649e-01f, -5.41248739e-01f,
  1.15165792e-01f, 7.03633949e-02f, -7.93818310e-02f, -7.55335614e-02f, -5.57450913e-02f, -1.39590472e-01f, 1.06877256e-02f, 5.24316877e-02f, -6.79965988e-02f, -1.22719757e-01f,
  -4.90382612e-02f, -2.47144774e-02f, -5.07930107e-02f, -1.34248763e-01f, 7.36452490e-02f, -9.01638865e-02f, -1.12768095e-02f, 1.50721639e-01f, 1.06951885e-01f, -5.36989653e-03f,
  -4.33268677e-03f, -1.41530722e-01f, -1.17857575e-01f, 1.43865738e-02f, -5.16640348e-03f, 2.06581369e-01f, -9.76899490e-02f, 2.82796081e-02f, -4.20669764e-02f, -1.38268312e-02f,
  -4.39656317e-01f, 7.08286881e-01f, -4.86281633e-01f, 2.11126767e-02f, -1.14009991e-01f, 9.50048715e-02f, -3.07105221e-02f, 1.50359720e-01f, -1.82813510e-01f, -1.05351336e-01f,
  6.70928057e-05f, -1.16467230e-01f, -1.46345988e-01f, 6.15437776e-02f, -6.13588057e-02f, -3.21903199e-01f, 2.90972721e-02f, -1.23636022e-01f, 3.67146060e-02f, 2.86362413e-02f,
  -2.44015247e-01f, 2.12419461e-02f, -6.05997980e-01f, -4.32479739e-01f, -3.67626458e-01f, -2.17229873e-01f, -1.76954955e-01f, -1.73430070e-01f, -4.77374978e-02f, -4.59716618e-01f,
  5.57214022e-01f, 1.77820802e-01f, 1.66827053e-01f, 1.36967957e-01f, 2.33535305e-01f, 1.96785107e-01f, 3.34048480e-01f, 2.59573728e-01f, 9.97245908e-02f, 1.12404101e-01f,
  3.90682518e-01f, 1.41336992e-01f, 2.53063262e-01f, 7.51878917e-02f, 2.10416794e-01f, -1.16885714e-01f, -1.43596947e-01f, -9.97110978e-02f, 2.27423236e-02f, 9.24430564e-02f,
  2.87872162e-02f, 1.02795690e-01f, 2.40231901e-01f, 8.59050080e-02f, -8.48272964e-02f, -3.67450081e-02f, 6.03556819e-02f, 8.59378949e-02f, 2.28652805e-02f, -5.16182601e-01f,
  -2.10643470e-01f, 2.66251892e-01f, -1.63694173e-01f, -9.01345685e-02f, 1.88969634e-02f, -1.17405606e-02f, 4.49185148e-02f, -3.33497375e-02f, 5.68267778e-02f, -1.79543093e-01f,
  -7.72507936e-02f, -2.57370174e-02f, 5.84166646e-02f, -1.23919332e-02f, 6.14101626e-02f, 6.42807409e-02f, -7.24953562e-02f, -1.24521218e-01f, -7.22006783e-02f, -1.04191013e-01f,
  -3.47374976e-02f, -3.27300206e-02f, -7.04189613e-02f, 3.21019664e-02f, 5.80283366e-02f, -9.51620564e-02f, 8.58853906e-02f, -7.43233636e-02f, 1.84359942e-02f, -3.72240879e-02f,
  -2.07101926e-01f, -8.75684246e-02f, -9.67438817e-02f, -7.88573995e-02f, -2.37442199e-02f, -1.32700309e-01f, -1.02669150e-01f, -6.39762804e-02f, -4.10919338e-02f, 6.80594752e-03f,
  -9.54450443e-02f, 1.09132603e-02f, -2.25459430e-02f, 3.99385467e-02f, -5.01221754e-02f, -6.36336058e-02f, -6.31803796e-02f, -4.89046946e-02f, 7.45024681e-02f, 8.73059034e-02f,
  -3.06218714e-02f, -1.91647753e-01f, -3.34097557e-02f, -1.49569541e-01f, -5.05579859e-02f, -3.28812897e-02f, -8.96921381e-02f, 1.03018224e-01f, 6.56351075e-02f, 5.09588644e-02f,
  -2.00298265e-01f, 4.79420274e-01f, -8.29908699e-02f, -2.07680151e-01f, -1.30993396e-01f, -1.40020996e-02f, 2.30803918e-02f, -7.13566020e-02f, -4.38396540e-03f, -1.12144873e-01f,
  3.98561954e-02f, -8.67882818e-02f, 5.72942477e-03f, -1.12995550e-01f, -1.59102470e-01f, -1.32543206e-01f, -1.54232010e-01f, -1.88081935e-01f, -1.05109021e-01f, -1.42102852e-01f,
  -6.97760656e-02f, -1.53343990e-01f, -5.12579866e-02f, -1.57402128e-01f, -1.70605540e-01f, -5.02429418e-02f, -6.40621409e-03f, -7.70528838e-02f, 6.25214502e-02f, -5.32141700e-03f,
  -5.56333601e-01f, 6.79270178e-02f, -6.44340813e-01f, -7.62700498e-01f, -7.66106904e-01f, -5.60761333e-01f, 9.59242433e-02f, -1.02716111e-01f, -2.83006549e-01f, -3.74215236e-03f,
  3.27398270e-01f, 3.69680852e-01f, 1.76391944e-01f, 2.66916633e-01f, 5.81653476e-01f, 2.29139805e-01f, -4.99936968e-01f, -4.43951696e-01f, -2.10605711e-01f, -2.41761982e-01f,
  -2.47618094e-01f, -5.98339796e-01f, -4.80353475e-01f, -2.85926044e-01f, -5.35061598e-01f, -4.34510797e-01f, -6.73414826e-01f, -6.72864974e-01f, -3.56984735e-01f, -6.56377196e-01f,
  2.15874985e-01f, -5.19820631e-01f, -1.99726541e-02f, 2.57769022e-02f, -3.35450828e-01f, -1.00137495e-01f, -1.07415855e-01f, -2.40560770e-01f, -9.93263498e-02f, -7.41797015e-02f,
  -1.69646949e-01f, -4.95385416e-02f, -1.20699756e-01f, -2.26561531e-01f, -3.50930661e-01f, -1.83485132e-02f, -1.37554988e-01f, -2.35055313e-01f, 7.41597116e-02f, 2.07216993e-01f,
  1.50183558e-01f, -1.99559368e-02f, 8.92066136e-02f, 1.05996333e-01f, -4.08303291e-02f, -1.10640809e-01f, -5.23932502e-02f, -1.85088202e-01f, -1.83362946e-01f, -5.15556335e-02f,
  -3.04437969e-02f, 1.21828400e-01f, -6.55426085e-02f, -1.07672401e-01f, 1.76044822e-01f, 1.45122379e-01f, -8.80032256e-02f, 4.70827287e-03f, 1.78725585e-01f, 1.98273242e-01f,
  2.13443972e-02f, 9.96604115e-02f, -8.71290918e-03f, 1.22109316e-01f, -4.16073687e-02f, -3.55243348e-02f, 1.45042613e-01f, 2.68647581e-01f, 7.04556108e-02f, 4.95477207e-02f,
  5.40497117e-02f, 8.50694627e-02f, -5.72736524e-02f, 1.32759690e-01f, 3.41616757e-02f, -1.23026453e-01f, -4.17428687e-02f, 1.43067211e-01f, 4.80039939e-02f, -5.23003489e-02f,
  2.67434597e-01f, 2.31187508e-01f, 3.01100194e-01f, 8.99010804e-03f, -2.71408796e-01f, -5.39999129e-03f, -3.29295285e-02f, -7.86959156e-02f, -1.49830669e-01f, -7.06340522e-02f,
  7.55499527e-02f, 1.15316339e-01f, 3.89027111e-02f, 6.43235072e-02f, -1.46172091e-01f, 8.27100575e-02f, 1.57661587e-01f, 6.14235327e-02f, 1.15777507e-01f, 2.96958499e-02f,
  1.57125086e-01f, 3.22252810e-01f, 3.55002075e-01f, 3.25982511e-01f, 7.52994642e-02f, 2.14994833e-01f, 1.97866902e-01f, 2.54739791e-01f, 3.97189200e-01f, 4.99134392e-01f,
  -9.49908614e-01f, -5.33714175e-01f, -1.97591707e-01f, -7.74504602e-01f, -3.61151874e-01f, -3.44362520e-02f, -7.95796216e-02f, 1.40086129e-01f, -3.27668607e-01f, -5.29786885e-01f,
  -3.77355337e-01f, -1.02119610e-01f, -4.45815653e-01f, 1.58269420e-01f, 3.23200822e-01f, -2.43817776e-01f, -3.25367868e-01f, 1.91719010e-01f, 7.36559808e-01f, 7.93039680e-01f,
  2.23523512e-01f, -8.13675970e-02f, 2.89303303e-01f, 2.82291085e-01f, -3.14909339e-01f, -1.34625480e-01f, -3.91307890e-01f, -1.59558505e-01f, 9.66298394e-03f, -6.89574003e-01f,
  -2.00567529e-01f, -2.39162341e-01f, 2.94499427e-01f, 9.74288285e-02f, -1.55717447e-01f, 5.05958013e-02f, 1.11010626e-01f, 6.41128141e-03f, -1.48658738e-01f, -7.77625889e-02f,
  -1.60206497e-01f, 2.21524626e-01f, 4.78265919e-02f, 1.00887744e-02f, -3.48083302e-02f, 1.70377806e-01f, 1.82014376e-01f, 2.09192052e-01f, -1.78639546e-01f, 2.14366019e-01f,
  -9.06258002e-02f, -3.26666087e-01f, -2.65622199e-01f, 2.21872866e-01f, 3.78776789e-01f, 7.38183409e-02f, 2.39098385e-01f, 4.28850591e-01f, 3.04417312e-01f, -4.20528531e-01f,
  -4.03191671e-02f, -1.23879137e-02f, 1.72603428e-01f, 1.64083436e-01f, 3.13033499e-02f, -4.90557440e-02f, -1.79841131e-01f, -3.13293189e-02f, 1.67166680e-01f, -1.97618697e-02f,
  6.97045699e-02f, -8.21630508e-02f, -8.24498478e-03f, -1.82743952e-01f, -5.25716543e-02f, -1.69131890e-01f, -1.45373821e-01f, 2.27429043e-03f, 6.81739161e-03f, -1.03748515e-01f,
  -1.20508261e-01f, -1.44424560e-02f, -1.24427184e-01f, 1.44419923e-01f, 5.19010350e-02f, 5.86118409e-03f, -1.30953103e-01f, 1.64364308e-01f, 5.40671609e-02f, 1.31954802e-02f,
  -3.03177774e-01f, 3.04888189e-01f, -5.84804714e-01f, 1.29347518e-01f, -1.08112164e-01f, 8.85343775e-02f, -2.67098695e-01f, 2.14236736e-01f, -2.25540489e-01f, 1.72696654e-02f,
  3.05739790e-01f, 5.00621973e-03f, -1.86387420e-01f, 2.19752923e-01f, 1.28328443e-01f, 5.48645072e-02f, 7.15506002e-02f, -2.86132723e-01f, -8.35921317e-02f, 6.46145865e-02f,
  -1.82861816e-02f, -3.19302857e-01f, -3.99778664e-01f, -3.12452674e-01f, -9.29374397e-02f, -7.69505501e-02f, -1.15026526e-01f, 1.15017608e-01f, -1.94924735e-02f, -5.18637717e-01f,
  7.71285832e-01f, -5.66836715e-01f, -1.17695153e-01f, 1.96554393e-01f, 2.14342196e-02f, 1.49170905e-01f, -2.15660810e-01f, 1.36806369e-01f, 2.74204254e-01f, 4.41249385e-02f,
  9.89453960e-03f, 1.72579035e-01f, 1.30221441e-01f, -9.41907801e-03f, -1.98292993e-02f, -1.53360844e-01f, -3.66231538e-02f, 1.13327928e-01f, 1.11088715e-01f, -1.10828802e-01f,
  -1.36717096e-01f, -1.84637353e-01f, 3.36593739e-03f, -2.10028458e-02f, -3.95246625e-01f, 2.39655208e-02f, -1.17556818e-01f, -2.75361389e-01f, -3.75701100e-01f, -3.46717983e-01f,
  -4.89575088e-01f, -2.01978713e-01f, 2.10252449e-01f, 7.37072825e-02f, -1.57685932e-02f, 2.17347234e-01f, 1.10437058e-01f, 1.70939028e-01f, 1.15716085e-01f, 2.30177175e-02f,
  -5.59105501e-02f, -7.89747387e-02f, -9.53777656e-02f, -8.29179212e-02f, -5.11716567e-02f, -6.49515614e-02f, -2.92752553e-02f, -8.45846627e-03f, 4.98174466e-02f, -5.35862707e-02f,
  -1.00287296e-01f, 1.41526200e-02f, 1.24644436e-01f, 1.26681402e-01f, 1.96319461e-01f, 2.26615176e-01f, -5.70680499e-02f, -5.12311533e-02f, 2.31368199e-01f, 2.56908119e-01f,
  1.70356095e-01f, 1.17985629e-01f, -8.47565979e-02f, -1.15102474e-02f, 8.05405080e-02f, 5.17977960e-02f, 3.87820154e-02f, -1.66496579e-02f, 6.98660240e-02f, 4.79585417e-02f,
  -4.10922393e-02f, -3.34453732e-02f, 2.60726772e-02f, 4.42189611e-02f, 1.42919384e-02f, -6.25513941e-02f, -8.51199552e-02f, -2.21460447e-01f, -9.77230370e-02f, -1.14674866e-01f,
  6.19995333e-02f, -5.24242148e-02f, -1.52817249e-01f, -1.37094706e-01f, -1.69208780e-01f, 9.29611363e-03f, -3.85304466e-02f, 7.30681121e-02f, 1.31975666e-01f, 1.48223013e-01f,
  -4.18463111e-01f, 8.70938152e-02f, 6.96787313e-02f, 1.39993047e-02f, -1.21336877e-01f, -6.80663958e-02f, -1.04269102e-01f, -1.46550983e-01f, -2.44819254e-01f, -4.88069654e-02f,
  -8.92175809e-02f, -6.75227791e-02f, -1.10008098e-01f, 2.07430050e-02f, 1.33053988e-01f, -6.62180455e-03f, 1.07258283e-01f, 8.28659087e-02f, 1.44515093e-02f, -6.33344927e-04f,
  -1.91024505e-02f, 2.39925146e-01f, 1.86179772e-01f, 2.51255065e-01f, 2.90176570e-01f, 3.41151506e-01f, 7.24489391e-02f, 5.42949513e-02f, 1.09219998e-01f, 2.09834144e-01f,
  1.12249351e+00f, -1.02984734e-01f, 2.96908408e-01f, -8.98750350e-02f, -6.93514466e-01f, -4.25653279e-01f, -3.80500704e-01f, -1.10031016e-01f, -1.06655317e-03f, -1.41620442e-01f,
  -2.28964880e-01f, 1.51195541e-01f, 2.76074439e-01f, 3.34075630e-01f, 3.88838619e-01f, 9.77947470e-03f, 3.06445025e-02f, 5.18778205e-01f, 2.74730235e-01f, -2.78794706e-01f,
  -3.34065020e-01f, 2.61011850e-02f, 4.27025735e-01f, 1.87976748e-01f, -3.25263202e-01f, -4.54105939e-05f, -2.61093844e-02f, -1.05530038e-01f, -1.99199975e-01f, -7.76671097e-02f,
  2.80780382e-02f, 4.25930992e-02f, -5.02525233e-02f, 5.53591885e-02f, 5.89675047e-02f, 9.81215388e-02f, 9.01803449e-02f, 2.03233540e-01f, -1.50550827e-02f, 1.47926575e-02f,
  -9.56152454e-02f, 4.82467376e-02f, 3.25473063e-02f, -4.80915308e-02f, -1.91157088e-02f, -6.93800226e-02f, 1.26336873e-01f, 3.53583723e-01f, 1.94380760e-01f, -4.01317999e-02f,
  -2.63795763e-01f, -2.65790999e-01f, -1.00695767e-01f, -9.53915119e-02f, 5.40101752e-02f, 1.01610027e-01f, -9.27371383e-02f, 4.35988270e-02f, 4.10035215e-02f, -4.62791063e-02f,
  -6.54553175e-02f, 7.95532316e-02f, -2.04023905e-03f, 6.31088391e-02f, 2.25432273e-02f, 4.24420573e-02f, 4.12553921e-03f, -9.40983519e-02f, 7.23924413e-02f, -6.02387823e-02f,
  1.66798886e-02f, 2.22539753e-02f, -3.51596298e-03f, 1.60220116e-02f, 3.17727588e-02f, 4.02624421e-02f, -1.45055279e-01f, -3.71667482e-02f, 3.41421664e-02f, 3.15571986e-02f,
  1.44538045e-01f, 6.59260526e-02f, 7.72146136e-02f, 1.25627831e-01f, -3.91306058e-02f, 6.95037395e-02f, 2.38994434e-02f, -9.29054543e-02f, -3.60668600e-02f, -5.85239045e-02f,
  -8.52956995e-03f, 2.18033165e-01f, -8.36061127e-03f, 1.43927515e-01f, -7.68457279e-02f, -9.23172161e-02f, 1.77844539e-02f, -5.91304861e-02f, -1.15916386e-01f, 3.61074060e-02f,
  -6.77401796e-02f, 1.61305457e-01f, 7.05062598e-02f, -2.81137228e-02f, -1.55325338e-01f, -1.86203390e-01f, -8.30280930e-02f, -6.11423329e-03f, 1.42720774e-01f, -8.64969566e-02f,
  5.14834188e-02f, -6.45062253e-02f, 1.14171710e-02f, -7.41946995e-02f, -1.50241360e-01f, 1.44584198e-02f, -1.09338827e-01f, -1.37758955e-01f, 6.64030015e-02f, -1.17916567e-02f,
  1.33643791e-01f, 8.42594579e-02f, 5.50371587e-01f, 3.11532438e-01f, 7.90341198e-02f, -3.74372274e-01f, -7.88477421e-01f, -3.96912485e-01f, 7.10136145e-02f, 1.10693857e-01f,
  -1.14350459e-02f, -2.14863017e-01f, 1.26262233e-02f, -2.77664155e-01f, -5.28399825e-01f, -1.35003522e-01f, 1.40112311e-01f, -1.75008923e-01f, -4.59593624e-01f, -6.86671495e-01f,
  -3.69790345e-01f, -9.49863121e-02f, 4.56229672e-02f, 4.07411307e-02f, 6.04576230e-01f, 1.00269064e-01f, 5.73549628e-01f, 4.11182016e-01f, 2.82917291e-01f, 6.27549767e-01f,
  2.67227501e-01f, 3.95834774e-01f, -3.85981888e-01f, -1.17534086e-01f, 1.31038949e-01f, -1.34080693e-01f, -1.73356146e-01f, 3.51271540e-01f, 6.63396064e-03f, 1.93429776e-02f,
  -2.09948067e-02f, -4.00818475e-02f, 2.10389402e-02f, -1.06521726e-01f, -1.70868799e-01f, -3.64896148e-01f, -5.48071004e-02f, -1.25186950e-01f, -1.25574753e-01f, -1.65776145e-02f,
  -4.04184371e-01f, -2.91626286e-02f, 3.36951464e-02f, -1.38145927e-02f, 3.47136892e-02f, -8.03607181e-02f, 1.87397227e-01f, 1.88958958e-01f, 9.81929526e-02f, 3.36444199e-01f,
  -7.48312399e-02f, -5.41616976e-03f, 4.74468544e-02f, 7.04454584e-03f, -1.02976613e-01f, 7.30612427e-02f, 9.91649255e-02f, -1.18789859e-01f, 1.03747323e-01f, -8.64636600e-02f,
  -3.78047191e-02f, -1.27666164e-02f, 3.54064140e-03f, 7.96743929e-02f, 8.09083357e-02f, 1.16175771e-01f, -1.21897526e-01f, 5.92413545e-03f, 2.61622220e-01f, 3.95272393e-03f,
  -7.96550885e-02f, 3.30240875e-02f, 1.13077283e-01f, -1.72516368e-02f, 2.06627399e-01f, 1.45445213e-01f, 7.25503489e-02f, -1.56113654e-02f, 1.37463314e-02f, 1.43581212e-01f,
  -3.48914742e-01f, -4.13807064e-01f, -1.85056210e-01f, -1.84228510e-01f, -3.61180604e-02f, 1.53506890e-01f, 1.52320325e-01f, -1.02823652e-01f, 1.39865607e-01f, -1.19849622e-01f,
  -1.84788108e-01f, -1.20869510e-01f, 1.36276037e-01f, -1.87983036e-01f, -3.40964109e-01f, -6.69357702e-02f, -2.06561044e-01f, -2.13548139e-01f, -2.94094592e-01f, -1.18958451e-01f,
  -2.44720995e-01f, -5.45411885e-01f, -3.61956865e-01f, -3.14777255e-01f, -1.04439452e-01f, -3.66392195e-01f, -9.51386988e-02f, -2.11881980e-01f, -3.64165723e-01f, -4.91377831e-01f,
  1.24948710e-01f, -1.81454137e-01f, -6.28310740e-01f, -3.28192562e-02f, 1.36204496e-01f, -3.18146557e-01f, -4.22488004e-01f, -3.14665914e-01f, 1.91692829e-01f, -2.19161317e-01f,
  1.31614134e-01f, 3.92731607e-01f, -2.36577004e-01f, -4.33665007e-01f, -7.81120837e-01f, -5.16315579e-01f, -6.82313681e-01f, -5.91895998e-01f, -2.25601956e-01f, 6.05602503e-01f,
  3.83341789e-01f, 1.93879545e-01f, -9.96606648e-02f, -3.12025938e-03f, 4.69078034e-01f, 7.14302361e-02f, -1.55142248e-01f, 2.39805877e-01f, -6.04918115e-02f, -2.09133737e-02f,
  2.22635642e-02f, 2.86192805e-01f, -2.44646426e-02f, 1.06519051e-01f, -1.03201374e-01f, -8.87353346e-02f, -6.47812635e-02f, -2.49329388e-01f, -2.06487656e-01f, -4.18020189e-02f,
  2.19619319e-01f, 1.07924797e-01f, -2.58155894e-02f, 2.25180849e-01f, 1.30837411e-01f, 7.53105953e-02f, -3.38551491e-01f, -3.42156798e-01f, -3.89551014e-01f, 1.04958005e-01f,
  1.84158549e-01f, 1.90912902e-01f, -3.87266755e-01f, -3.32649589e-01f, -2.32826602e-02f, -1.38783246e-01f, 3.58756690e-04f, 3.66706610e-01f, -4.72689569e-01f, -6.81963861e-02f,
  5.27878739e-02f, 5.63231809e-03f, -2.09893748e-01f, -2.42185891e-01f, -5.94963394e-02f, -6.79556106e-04f, 5.87350130e-02f, -7.22707156e-03f, -8.64068717e-02f, 2.88428068e-02f,
  -5.01856618e-02f, -1.28546074e-01f, 1.42471910e-01f, -3.14520560e-02f, 1.11286990e-01f, 1.08260270e-02f, 2.08167564e-02f, -1.36214733e-01f, -1.73665807e-01f, -3.29388119e-02f,
  -3.81372683e-02f, 1.30890834e-03f, 1.44032821e-01f, 2.01721396e-02f, -2.20785424e-01f, -7.59667903e-02f, 3.06470037e-01f, 1.05475880e-01f, 1.05824962e-01f, 1.70545831e-01f,
  3.39350253e-01f, -2.28625402e-01f, 7.71039948e-02f, -1.00736134e-01f, -9.54054147e-02f, -7.74883181e-02f, -1.21232821e-02f, -2.22582251e-01f, -6.07760921e-02f, -8.70773569e-03f,
  -7.47872591e-02f, -1.45262718e-01f, -8.61824229e-02f, -4.09853570e-02f, 1.00953214e-01f, -2.62263939e-02f, -3.56494188e-01f, -1.80919722e-01f, -1.72308981e-01f, 3.02118659e-01f,
  -3.90158445e-01f, -3.16541851e-01f, -4.01308566e-01f, -4.51912969e-01f, -8.53556767e-03f, -3.43294084e-01f, -2.11576656e-01f, 5.69692068e-02f, -5.05879283e-01f, -5.56089878e-01f,
  -3.37199450e-01f, 1.97292626e-01f, 1.88722029e-01f, 1.25837922e-01f, -1.21873049e-02f, -3.01588774e-01f, -3.48955929e-01f, -1.35455638e-01f, 2.36267708e-02f, 2.16340214e-01f,
  8.30571875e-02f, 1.58560440e-01f, 2.15177655e-01f, -9.57808364e-03f, -1.63960651e-01f, -8.92034322e-02f, 1.09869968e-02f, -1.82652742e-01f, -3.18317860e-01f, -3.57459366e-01f,
  -7.94389099e-02f, -3.28006484e-02f, -7.93783441e-02f, 9.44271870e-03f, 3.07764113e-01f, 2.64475226e-01f, 3.39720249e-01f, 1.04974784e-01f, 6.30344003e-02f, 3.84743959e-01f,
  4.61578310e-01f, -1.86283842e-01f, 1.03996210e-02f, -1.04891934e-01f, 1.27438828e-01f, -1.47426492e-02f, -5.26929200e-02f, 1.32940426e-01f, 7.77686834e-02f, 1.42529428e-01f,
  -1.12402616e-02f, 6.27547354e-02f, 6.22420162e-02f, 1.96744576e-01f, 5.28026707e-02f, 1.24518916e-01f, 2.25290451e-02f, 5.76340267e-03f, -4.07190919e-02f, 1.59228727e-01f,
  8.35562497e-03f, -1.25873834e-01f, -1.70651615e-01f, -2.34966308e-01f, -1.94485784e-01f, -1.34237647e-01f, 8.74268077e-03f, -5.64791486e-02f, -7.74689317e-02f, 7.32368752e-02f,
  -8.62868801e-02f, 7.71234259e-02f, -9.49005038e-02f, 1.11423004e-02f, -4.40673493e-02f, -1.48298731e-02f, 5.29024638e-02f, 4.60011326e-02f, -4.29718830e-02f, 2.32408941e-02f,
  8.23383257e-02f, 5.41754924e-02f, 2.90574878e-03f, -5.57451360e-02f, 5.67943342e-02f, 7.80653879e-02f, -7.32729733e-02f, 1.41906859e-02f, -6.22755289e-02f, 1.49509097e-02f,
  -1.73964366e-01f, 1.10714205e-01f, 2.22705439e-01f, 5.73051311e-02f, 4.11338061e-02f, -4.78205606e-02f, -2.99743991e-02f, -2.72487830e-02f, 8.38896036e-02f, 5.10492176e-02f,
  4.35640574e-01f, -4.30242270e-01f, 1.87920108e-01f, -8.04121792e-03f, 9.42947641e-02f, 1.13864020e-01f, -5.18221147e-02f, -3.83435003e-02f, 1.43341377e-01f, 1.94117315e-02f,
  -9.40060392e-02f, 4.39173952e-02f, 1.28612414e-01f, 1.43534392e-02f, 5.00702262e-02f, 1.66288875e-02f, -6.48138300e-02f, 1.47310942e-01f, -1.64169576e-02f, 2.08613738e-01f,
  1.03694290e-01f, 6.73792958e-02f, -2.85390504e-02f, 1.17661804e-01f, -6.65473342e-02f, -1.41483825e-02f, 2.33468354e-01f, 2.69864965e-02f, -1.85882766e-02f, 1.41623229e-01f,
  -9.72135723e-01f, 2.83070594e-01f, 9.82429758e-02f, -4.25523490e-01f, -1.30266011e-01f, -1.00601524e-01f, 3.32011692e-02f, -1.82622358e-01f, -1.56753272e-01f, 9.99669954e-02f,
  2.50631541e-01f, 8.59564096e-02f, 2.22200692e-01f, 2.41943687e-01f, 1.08022429e-01f, 3.39341521e-01f, 1.59934685e-01f, -2.54494995e-01f, -2.86966383e-01f, -1.70009866e-01f,
  2.08663866e-01f, -1.69455543e-01f, -4.25487339e-01f, -1.56342819e-01f, 2.66768664e-01f, 9.37569886e-02f, 2.10135370e-01f, 1.27046928e-01f, 3.41122657e-01f, 3.99274468e-01f,
  6.42339230e-01f, -2.97953248e-01f, -4.77658957e-02f, -1.58439517e-01f, -3.42427455e-02f, -1.20919116e-01f, -1.01244040e-01f, -1.65015265e-01f, -3.98152769e-02f, 4.12006350e-03f,
  -3.72629799e-02f, -1.84970093e-04f, -2.27981824e-02f, 1.22399954e-02f, -1.14662595e-01f, -1.12820804e-01f, -7.43964911e-02f, 6.90105651e-03f, 1.40205950e-01f, 2.22815156e-01f,
  2.55481720e-01f, 1.08484939e-01f, 3.07627637e-02f, 2.58110110e-02f, -9.67182815e-02f, -1.33992443e-02f, 9.62282196e-02f, -9.22482163e-02f, -2.62769610e-02f, -9.40845069e-03f,
  3.72406729e-02f, -1.25706755e-02f, -4.44238856e-02f, 2.13299915e-02f, -8.72436464e-02f, -7.62475282e-02f, -8.69261175e-02f, -3.92041281e-02f, -1.07677937e-01f, -1.25147641e-01f,
  3.65730072e-03f, 1.88604996e-01f, -1.29121644e-02f, 5.79468496e-02f, 2.88780537e-02f, 1.24811772e-02f, -1.07523158e-01f, -4.47875995e-04f, -9.42192078e-02f, -5.03845550e-02f,
  -7.81610422e-03f, -1.56459272e-01f, 3.64153571e-02f, 2.37535825e-03f, 8.96626636e-02f, -5.34145460e-02f, 1.66882407e-02f, 2.79412279e-03f, -1.06004924e-01f, 4.96083759e-02f,
  3.97193938e-01f, -1.45196944e-01f, 1.79453164e-01f, 2.83576567e-02f, -4.05422114e-02f, -7.92154372e-02f, 2.94055641e-02f, -3.58578265e-02f, 1.47186369e-02f, -9.30003822e-02f,
  -6.37910068e-02f, -1.60391763e-01f, 5.69201298e-02f, -3.71455923e-02f, -1.34864464e-01f, -1.02954611e-01f, 4.77080196e-02f, 1.88163333e-02f, 7.23378509e-02f, 5.33940084e-02f,
  3.63701545e-02f, -1.29955873e-01f, -1.56121524e-02f, -1.37141738e-02f, 5.46386689e-02f, -5.67050166e-02f, 1.41047150e-01f, 1.06461555e-01f, -2.68011075e-02f, -1.80253293e-04f,
  7.01195002e-01f, 6.38410330e-01f, 1.63921162e-01f, 2.47484371e-01f, 4.52839248e-02f, 2.23039359e-01f, 5.46531618e-01f, 4.00828809e-01f, 1.84586987e-01f, 1.92005917e-01f,
  1.58911735e-01f, 5.79138100e-02f, 2.25274280e-01f, 4.36137579e-02f, 2.75394380e-01f, 1.09450817e-01f, 8.88827741e-02f, -1.44935250e-02f, -2.96462304e-03f, 1.71137825e-02f,
  1.46599635e-01f, 1.70789689e-01f, 6.74661919e-02f, 4.06018123e-02f, 1.02018721e-01f, 1.48752099e-02f, 2.10076640e-03f, 5.28377816e-02f, 1.59284383e-01f, 1.01002485e-01f,
  -2.35041097e-01f, 1.81820825e-01f, -1.97615013e-01f, -1.22263320e-01f, -7.55841136e-02f, -1.22137859e-01f, -1.26625672e-01f, -1.12203889e-01f, -2.50495784e-02f, -1.19280003e-01f,
  -8.29303041e-02f, -5.97066805e-02f, -4.36798632e-02f, 1.99464429e-02f, -4.80295755e-02f, -1.51527643e-01f, -1.60471946e-02f, 8.47561434e-02f, 5.74823245e-02f, -2.91172620e-02f,
  6.82014376e-02f, 8.94653727e-04f, -4.54171859e-02f, -6.82775900e-02f, 1.34617954e-01f, -6.92144781e-02f, 3.20996940e-02f, -5.58851520e-03f, -9.76403505e-02f, 5.24316654e-02f,
  -3.30490693e-02f, 2.62346148e-01f, -4.27150577e-02f, -2.19179336e-02f, -7.89063573e-02f, -5.64079992e-02f, -1.14268661e-02f, 9.28352103e-02f, 8.45267326e-02f, 4.67932113e-02f,
  -7.72891864e-02f, -3.34852040e-02f, -1.07468732e-01f, -1.51201159e-01f, -1.09476842e-01f, 2.13560229e-03f, 7.61222839e-02f, -9.86806378e-02f, -1.10744789e-01f, -9.50443819e-02f,
  -6.80802613e-02f, -1.76816192e-02f, -1.73201069e-01f, -7.75967240e-02f, -2.13725969e-01f, -8.68532732e-02f, -1.42621890e-01f, -1.20143011e-01f, -3.53597291e-03f, 8.96044355e-03f,
  -6.73974678e-02f, -1.18994504e-01f, -4.86777164e-03f, 1.54638901e-01f, -1.42601272e-02f, 2.84182634e-02f, 8.23626146e-02f, -6.75607547e-02f, -4.03774306e-02f, -7.44096041e-02f,
  -6.47696406e-02f, 1.03727691e-01f, 8.68553743e-02f, 8.08087364e-02f, -1.07705384e-01f, -4.94465195e-02f, 9.77965593e-02f, 8.69543403e-02f, 3.01170740e-02f, -5.21445349e-02f,
  -5.41763082e-02f, -5.66510372e-02f, -8.12643543e-02f, -7.18739629e-02f, 1.94520298e-02f, -1.74090728e-01f, -7.72379935e-02f, -8.67446512e-02f, -1.21999145e-01f, -7.94782341e-02f,
  -5.51204562e-01f, 4.83613648e-02f, 2.56319702e-01f, -1.25140071e-01f, 2.77279973e-01f, 2.11334229e-01f, 3.79718810e-01f, 1.44042969e-01f, -1.31735504e-01f, -1.24379165e-01f,
  -7.62980878e-02f, -8.95865560e-02f, -1.82146206e-02f, -4.17144671e-02f, 1.07158139e-01f, 3.04494053e-01f, 2.40503445e-01f, 7.43022710e-02f, 5.34368940e-02f, 7.86966458e-02f,
  5.40349819e-02f, -5.03106266e-02f, -3.21575850e-01f, -3.48924333e-03f, -7.30073266e-03f, 2.04444960e-01f, 7.79788196e-02f, -2.12162696e-02f, 1.50395215e-01f, 8.29530731e-02f,
  1.51933640e-01f, -3.99560452e-01f, 1.84936766e-02f, -3.51185352e-01f, -1.17074423e-01f, -2.83143193e-01f, 7.31384353e-05f, -2.08360270e-01f, -1.69868365e-01f, 3.51338200e-02f,
  -1.75212011e-01f, -1.67442188e-01f, -6.18529692e-02f, 1.79916003e-03f, -3.52824442e-02f, -1.52492002e-01f, -2.28650436e-01f, -2.24331573e-01f, -7.04726651e-02f, -1.06063195e-01f,
  5.35375252e-02f, -1.34934559e-01f, 2.29189042e-02f, 5.21255136e-02f, -7.53949732e-02f, -5.67548648e-02f, -6.14198949e-03f, -1.30018651e-01f, -4.61442284e-02f, -1.57449752e-01f,
  -6.14670627e-02f, -9.64551885e-03f, -7.26786479e-02f, 6.27406687e-02f, -7.68814906e-02f, 7.77379200e-02f, 2.07625106e-01f, 1.45208076e-01f, 6.59229234e-02f, 1.64100960e-01f,
  1.19407289e-01f, -1.48261013e-03f, 1.72272608e-01f, 1.46616558e-02f, -1.01129770e-01f, 1.55775147e-02f, 7.09053278e-02f, -4.28405143e-02f, -1.00748472e-01f, 6.64876215e-03f,
  -5.66460602e-02f, 1.04917832e-01f, -3.29228304e-02f, 1.22260772e-01f, 1.33862058e-02f, -6.04060628e-02f, 5.83462454e-02f, 4.27341759e-02f, -6.06593974e-02f, -7.97621533e-03f,
  5.38622558e-01f, -1.45920739e-01f, 4.75382060e-02f, 1.21020246e-03f, -2.90776789e-02f, -1.50057420e-01f, 1.64789334e-02f, -4.24050055e-02f, 7.59964362e-02f, 5.42587005e-02f,
  2.95732636e-02f, 1.80122480e-02f, 1.55134186e-01f, 8.82169232e-02f, 1.66869491e-01f, 8.16180930e-02f, 5.63728362e-02f, 5.83117865e-02f, -7.74044022e-02f, -2.31623277e-02f,
  2.77993158e-02f, 2.41569355e-02f, 2.80002654e-01f, 2.34785363e-01f, 1.09645687e-01f, 1.33063376e-01f, 1.56635031e-01f, 2.35715151e-01f, 2.31646463e-01f, 2.02076152e-01f,
  -3.61109078e-01f, -5.08252621e-01f, 2.58748025e-01f, -5.61331622e-02f, 4.49972600e-01f, 5.31010985e-01f, 5.17259240e-01f, 2.11438507e-01f, 1.07259125e-01f, -2.24130839e-01f,
  -2.81804681e-01f, -1.81045249e-01f, -2.85055846e-01f, -9.75386724e-02f, 9.56144836e-03f, 2.62000650e-01f, 1.76595092e-01f, 2.00129956e-01f, 4.32046890e-01f, 4.74094033e-01f,
  7.57577270e-02f, -2.15176329e-01f, -4.11616385e-01f, -2.15835854e-01f, -3.75659794e-01f, -1.34205744e-01f, -2.73341149e-01f, -2.67062157e-01f, 2.16042735e-02f, -2.99515814e-01f,
  -1.50475234e-01f, -2.89041102e-01f, 1.92246109e-01f, -1.79389849e-01f, -2.19154030e-01f, -7.54704699e-02f, 2.53958795e-02f, -2.48707697e-01f, -2.08359566e-02f, -8.10017437e-02f,
  -1.78390369e-01f, -5.48873991e-02f, -2.39097662e-02f, -1.17755435e-01f, 3.72298472e-02f, -9.15533751e-02f, -2.92465866e-01f, -1.71926901e-01f, -6.34677187e-02f, -1.61337718e-01f,
  -1.79073423e-01f, 6.28263876e-03f, 4.58478089e-03f, 6.36053681e-02f, -5.76455109e-02f, 1.02701463e-01f, -1.67486653e-01f, 4.99112122e-02f, 2.44933050e-02f, -1.26188889e-01f,
  -1.73687190e-01f, -8.26177970e-02f, 7.21282437e-02f, -7.63523355e-02f, 1.18440472e-01f, 1.39709756e-01f, 4.13988456e-02f, 5.74566759e-02f, 5.42769022e-02f, -1.62620977e-01f,
  1.31882597e-02f, 1.13599770e-01f, 1.43307656e-01f, -4.75577302e-02f, -6.56608194e-02f, -4.77514714e-02f, 1.14438534e-01f, 1.96186993e-02f, -9.57983360e-02f, 2.10530311e-02f,
  -9.25919563e-02f, 1.76765081e-02f, -2.32342049e-03f, -1.04222238e-01f, -2.92674522e-04f, -4.40292098e-02f, 1.74757410e-02f, -1.66457534e-01f, -1.29737720e-01f, 3.78880166e-02f,
  -3.46892387e-01f, 1.27355739e-01f, -3.29531059e-02f, -1.67614311e-01f, -1.56216621e-02f, -1.65901437e-01f, -2.34502535e-02f, 3.49774659e-02f, 7.56545458e-03f, 1.06644578e-01f,
  5.05129658e-02f, 7.71112554e-03f, -6.78450614e-02f, -1.82845041e-01f, 1.62620023e-01f, 9.19959173e-02f, -1.65612087e-01f, -4.96742949e-02f, 3.28253657e-02f, -7.55786821e-02f,
  -2.04045460e-01f, 2.27003589e-01f, 1.99551538e-01f, 2.20604137e-01f, 8.62616524e-02f, 3.17881703e-01f, 5.51811680e-02f, 2.38820970e-01f, 2.08593354e-01f, 4.26033661e-02f,
  -4.47423369e-01f, -2.16932014e-01f, 3.78890008e-01f, -1.61749437e-01f, 2.58019179e-01f, 4.49355155e-01f, 4.18408155e-01f, 1.82561338e-01f, -4.64220829e-02f, 4.38972749e-02f,
  -4.97597635e-01f, -5.34849226e-01f, -3.89215946e-01f, -3.27339381e-01f, -2.58308835e-02f, 4.61195648e-01f, 4.13783759e-01f, 2.42248811e-02f, -6.21756129e-02f, -5.00575714e-02f,
  -4.50662635e-02f, -2.07539380e-01f, -3.90657604e-01f, -9.44256634e-02f, 5.32615371e-02f, 3.15680876e-02f, 1.78585365e-01f, -5.63395843e-02f, 7.80925304e-02f, 2.11410373e-01f,
  -3.95287484e-01f, -6.08196594e-02f, 5.56161515e-02f, -1.31675914e-01f, -1.76728874e-01f, -2.37921849e-01f, -2.80732196e-02f, -2.03410342e-01f, -1.89418226e-01f, 4.40249033e-02f,
  -1.03591196e-01f, -2.68689152e-02f, 7.01712398e-03f, 6.94763884e-02f, -6.40959591e-02f, 4.82997335e-02f, 2.81209359e-03f, -3.95869557e-03f, -1.18210651e-01f, 5.16286455e-02f,
  -8.31541717e-02f, 1.28849745e-01f, 4.68842648e-02f, 1.48763955e-01f, 1.03378981e-01f, -9.21613872e-02f, -1.22305207e-01f, -2.46497374e-02f, 6.47887811e-02f, 7.33244512e-03f,
  -6.70956299e-02f, 6.79060593e-02f, 1.02015249e-02f, -8.44178274e-02f, 2.56165322e-02f, 8.28818977e-02f, 6.36326820e-02f, -5.90333380e-02f, -1.48095260e-03f, -5.78971021e-02f,
  9.78197306e-02f, -3.62108462e-03f, -1.26684820e-02f, -7.94739798e-02f, -1.28539562e-01f, -5.50055206e-02f, 4.39773090e-02f, -1.78428605e-01f, -2.13541258e-02f, 6.91998303e-02f,
  -9.66731831e-02f, 1.87097862e-01f, -7.80812129e-02f, 9.24287289e-02f, 1.48132682e-01f, 1.20412663e-03f, 7.82627519e-03f, -3.32201682e-02f, 3.22114900e-02f, -5.49274683e-02f,
  -3.58817160e-01f, 6.00368120e-02f, -5.64206466e-02f, 3.40210646e-02f, -4.24704328e-02f, -9.72654745e-02f, -1.52255103e-01f, -6.09530471e-02f, 9.06352594e-04f, 5.48304208e-02f,
  -5.65103218e-02f, -1.09177217e-01f, -1.85167477e-01f, -2.72840969e-02f, 1.17664980e-02f, -1.00868549e-02f, -7.33979046e-02f, 1.47189125e-02f, 3.75047959e-02f, -1.09018153e-02f,
  9.12997574e-02f, 1.44484907e-01f, -1.25460327e-01f, -3.13090608e-02f, 1.35309070e-01f, -2.39825621e-02f, -8.21275190e-02f, -3.85790336e-04f, 7.97618181e-02f, 5.45618311e-03f,
  4.56948489e-01f, 2.81016529e-01f, 2.61066407e-01f, 2.19725102e-01f, 1.50961339e-01f, 1.44597471e-01f, 1.80659428e-01f, 4.04440649e-02f, 1.07703447e-01f, 2.23438337e-01f,
  1.63783744e-01f, 1.49708062e-01f, 9.70200747e-02f, 8.43822658e-02f, 1.84531316e-01f, 1.09206475e-01f, 1.28952309e-01f, 1.42871231e-01f, 1.30488276e-01f, 9.82022658e-02f,
  1.63999915e-01f, 8.56915116e-02f, 2.46975318e-01f, 2.00586393e-01f, 1.78956643e-01f, 1.53379440e-01f, 7.25624859e-02f, 2.59590931e-02f, 7.29435682e-02f, 1.27603769e-01f,
  -1.61232315e-02f, 7.88964853e-02f, -6.02334477e-02f, -1.04336329e-01f, -2.60928907e-02f, -8.38573575e-02f, -3.96134146e-02f, -3.30716893e-02f, 4.01541218e-03f, 1.53748365e-02f,
  -1.37094483e-01f, -4.98436764e-02f, 8.24165531e-03f, -6.99926615e-02f, -7.55662657e-03f, 1.20487222e-02f, 3.27377468e-02f, 2.24753283e-02f, -3.43585089e-02f, -1.21477149e-01f,
  9.05575324e-03f, -6.25590757e-02f, -9.92423110e-03f, -1.35945216e-01f, -1.03818523e-02f, -5.54826297e-02f, -2.26573683e-02f, -6.57435209e-02f, -1.03407517e-01f, 7.90670216e-02f,
  4.10150960e-02f, 4.62110564e-02f, -2.71230936e-02f, -6.46163151e-02f, 4.06836271e-02f, -2.81893089e-02f, -1.29147843e-01f, -5.53949513e-02f, 2.96057612e-02f, 5.28499298e-02f,
  5.40669188e-02f, 1.21810578e-01f, -2.19391122e-01f, 1.96698830e-01f, 1.02626912e-01f, -2.54794415e-02f, -1.46447897e-01f, -7.62705430e-02f, -1.72932949e-02f, -3.56401503e-02f,
  -1.96573492e-02f, -5.66765182e-02f, -2.85064019e-02f, -1.07461303e-01f, -1.31995410e-01f, -1.65393874e-01f, -4.50472645e-02f, 3.36298160e-02f, 2.42085174e-01f, 1.94827616e-01f,
  -2.18354553e-01f, -4.77474555e-03f, -9.66031197e-03f, -1.77207679e-01f, -1.31913096e-01f, -1.66334525e-01f, 2.24539842e-02f, -5.79425879e-02f, -1.11304112e-01f, -4.42988276e-02f,
  8.27904884e-03f, -1.25284865e-01f, -5.60034998e-02f, 5.30708879e-02f, -4.45674025e-02f, -1.89667150e-01f, -1.81116998e-01f, -1.61964849e-01f, -1.93891689e-01f, -1.02369308e-01f,
  -8.02468788e-03f, -2.07041875e-01f, -2.68039793e-01f, -1.86908051e-01f, -1.10147923e-01f, -2.05984965e-01f, -1.20700613e-01f, -2.16074362e-01f, -2.13559896e-01f, -1.99401259e-01f,
  -9.48203206e-01f, -2.97419369e-01f, 4.86039251e-01f, -6.52325571e-01f, -3.21954310e-01f, -7.95605630e-02f, -1.01160869e-01f, -5.80615282e-01f, -4.99360859e-01f, -1.45654246e-01f,
  -2.19889060e-01f, -4.80351448e-01f, -1.94553375e-01f, -3.07885975e-01f, -4.43040162e-01f, 1.58903867e-01f, 1.37805462e-01f, -3.19473445e-01f, -4.95483726e-01f, -5.92464030e-01f,
  -6.06331944e-01f, -7.07117617e-01f, -5.81275642e-01f, -3.65565836e-01f, -8.64652097e-02f, -2.88158387e-01f, -3.35310623e-02f, -3.18025410e-01f, -1.99019283e-01f, -4.59184833e-02f,
  4.71245319e-01f, -3.66429925e-01f, -1.56007126e-01f, -2.53981233e-01f, -4.95263226e-02f, -6.47601858e-02f, 5.93240792e-03f, -1.12072475e-01f, -1.02553122e-01f, -3.03165875e-02f,
  -2.02000558e-01f, -1.71613023e-01f, -4.75005060e-02f, 8.22960138e-02f, -4.71591949e-02f, -8.62535387e-02f, 1.91158836e-03f, -1.22988001e-01f, -6.60268143e-02f, 1.32966250e-01f,
  9.51613486e-02f, -8.74870420e-02f, 8.56536031e-02f, 1.11441687e-01f, -6.08848445e-02f, -8.16577394e-03f, 1.23488292e-01f, -5.77922650e-02f, 1.74406067e-01f, 1.76091090e-01f,
  9.24658552e-02f, 2.57341295e-01f, -5.54489233e-02f, -4.91446769e-03f, 6.46708012e-02f, 4.32821084e-03f, 1.31361708e-01f, 9.35756117e-02f, -1.00087419e-01f, -1.00857854e-01f,
  -1.34377405e-01f, -2.91723777e-02f, -1.02221161e-01f, -6.76943734e-02f, -1.12828739e-01f, -1.15883298e-01f, -2.06236634e-03f, -7.49354661e-02f, 3.86600122e-02f, -1.39371604e-01f,
  -2.98539907e-01f, -1.24524370e-01f, -5.90966456e-03f, -1.38150185e-01f, -9.40108225e-02f, -1.17012583e-01f, -1.26799690e-02f, -1.25323907e-01f, -7.96882659e-02f, -4.53245528e-02f,
  -2.99045593e-02f, -1.50326222e-01f, 5.97633421e-02f, -9.30860115e-04f, 1.21351853e-02f, 3.32142562e-02f, 5.17994203e-02f, -4.73905206e-02f, -1.70969609e-02f, -1.57517157e-02f,
  -9.64754261e-03f, 6.44567236e-02f, 2.07544994e-02f, 2.51856986e-02f, 9.68298316e-02f, -2.56967079e-02f, -4.60868478e-02f, 1.04992148e-02f, -1.96953560e-03f, 1.54693082e-01f,
  7.51970932e-02f, 1.24649771e-01f, 1.37094751e-01f, 2.82640904e-01f, 8.47507268e-02f, 9.74831507e-02f, 3.01684856e-01f, 2.23659158e-01f, 2.24077091e-01f, 3.90889615e-01f,
  7.25569651e-02f, -6.14091992e-01f, -6.46222353e-01f, -6.66473210e-01f, -7.02435195e-01f, -6.15030706e-01f, -8.78778696e-01f, -7.10457146e-01f, -3.35233241e-01f, -8.40997577e-01f,
  -4.86753345e-01f, 1.09488927e-01f, -2.38704428e-01f, -1.02736250e-01f, -1.44002751e-01f, -9.79462445e-01f, -6.80812120e-01f, -2.41801515e-01f, 3.68677676e-02f, -1.37682647e-01f,
  -3.59338611e-01f, -1.14299603e-01f, 1.97293431e-01f, -2.97630001e-02f, -6.22543037e-01f, -2.29484007e-01f, -6.19807959e-01f, -3.44983160e-01f, -2.85664856e-01f, -4.55078721e-01f,
  -6.89913154e-01f, -4.22416538e-01f, 4.89446856e-02f, 1.09210990e-01f, -1.92627668e-01f, 1.89557865e-01f, -2.12167129e-01f, 8.51459950e-02f, 2.68739194e-01f, -4.55749780e-01f,
  -4.77464385e-02f, 5.74247465e-02f, -3.82057950e-02f, -1.96308255e-01f, -2.81211704e-01f, -6.77047819e-02f, -1.86902374e-01f, 1.76992919e-02f, 9.41702910e-03f, -8.99018049e-02f,
  2.22533658e-01f, -4.54963446e-02f, -2.27716327e-01f, 6.13379991e-03f, -1.41830295e-01f, 8.55781138e-02f, -1.84054732e-01f, -1.55845106e-01f, 4.60342914e-02f, -4.87977147e-01f,
  1.29635036e-02f, -9.40326899e-02f, -2.88117319e-01f, 2.72306819e-02f, 6.50195554e-02f, 2.15105787e-01f, -1.18765607e-02f, -1.23913750e-01f, 1.63682863e-01f, 3.44392918e-02f,
  -2.11109035e-02f, -2.68101003e-02f, 3.26657221e-02f, -4.79556061e-02f, -3.72493416e-02f, -8.37458763e-03f, 2.00632773e-02f, -1.55156434e-01f, 4.82463017e-02f, 1.12676822e-01f,
  1.00621648e-01f, -1.20947985e-02f, -9.07793641e-03f, 2.35518143e-02f, -9.45479050e-02f, -1.45189553e-01f, 1.60822757e-02f, -1.17628798e-01f, -1.26743913e-01f, 8.95807818e-02f,
  -3.32745850e-01f, 2.34255075e-01f, -6.04650319e-01f, 8.98465887e-02f, -1.33632436e-01f, 1.30392849e-01f, -5.97994849e-02f, 4.57042269e-02f, 1.08104944e-01f, -3.96226048e-01f,
  -8.23711008e-02f, -1.93927750e-01f, -2.90414542e-01f, -5.67530002e-03f, 1.06931366e-01f, 3.81516553e-02f, 9.99561399e-02f, -1.70936793e-01f, 1.57884702e-01f, 1.38247564e-01f,
  3.55285890e-02f, -1.26519337e-01f, -1.55210197e-01f, -1.24822192e-01f, 1.53448790e-01f, -3.89477797e-02f, -3.48887086e-01f, -7.39063770e-02f, 5.35759777e-02f, -2.66600043e-01f,
  -6.75850749e-01f, 4.99080449e-01f, 4.71044391e-01f, -4.07711044e-02f, 1.83103979e-01f, 2.91458756e-01f, 4.07459587e-01f, 9.13054422e-02f, 1.56087419e-02f, 3.62521261e-01f,
  2.45926559e-01f, -3.05969685e-01f, 1.26975894e-01f, -3.53422202e-02f, -1.61089510e-01f, 4.83951271e-01f, 3.78095955e-01f, -2.23726928e-01f, -7.08520591e-01f, -7.17911780e-01f,
  -2.30513960e-01f, -3.43559653e-01f, -5.13355970e-01f, -3.08150679e-01f, 9.43345428e-02f, -3.19962688e-02f, 3.60232234e-01f, 1.25688538e-01f, 1.88908412e-03f, 2.40097940e-01f,
  3.94978486e-02f, 2.32228085e-01f, 4.40002605e-02f, -2.02740788e-01f, 9.40584540e-02f, -1.21297948e-01f, -5.50153553e-02f, -1.29847284e-02f, 6.60270751e-02f, 3.94415632e-02f,
  1.40500292e-01f, -8.86095092e-02f, 9.05268565e-02f, -2.96161999e-03f, -4.07357812e-02f, -6.90565929e-02f, -6.08114526e-02f, -3.18207949e-01f, -1.77001595e-01f, -1.62349790e-01f,
  1.22265490e-02f, -2.75315106e-01f, -1.00201387e-02f, 1.65459365e-01f, 5.64569458e-02f, -3.44048023e-01f, -3.54627743e-02f, -3.28173429e-01f, -2.71985412e-01f, -4.04955536e-01f,
  -1.42456114e-01f, 3.79787758e-02f, 2.38370337e-02f, 8.30489397e-02f, -8.61416832e-02f, 1.59540519e-01f, 7.55241811e-02f, -4.25299667e-02f, -3.63953896e-02f, -4.64836024e-02f,
  9.09704939e-02f, -1.08970076e-01f, -4.25106920e-02f, 9.03069004e-02f, -8.70098844e-02f, -1.06001105e-02f, -5.83279952e-02f, -1.64577700e-02f, 5.35104387e-02f, -6.44465089e-02f,
  -7.62971118e-02f, 5.80610447e-02f, -3.95342037e-02f, -1.69545189e-01f, 1.43123135e-01f, 1.33896098e-01f, -6.96271211e-02f, -1.56877577e-01f, -8.61453339e-02f, 3.09564639e-03f,
  -1.32421866e-01f, 2.23608196e-01f, -8.26424286e-02f, -1.19362980e-01f, 1.29214749e-01f, 8.37868080e-02f, 5.98329380e-02f, 1.21240355e-02f, 1.74859241e-02f, -7.95460045e-02f,
  -8.95974785e-02f, 6.28054934e-03f, 2.87905514e-01f, 6.23963922e-02f, -1.33766785e-01f, 7.43004754e-02f, -4.73936088e-02f, -6.83175325e-02f, -3.08950573e-01f, -1.22812897e-01f,
  1.44243762e-01f, -4.56182539e-01f, -4.48401511e-01f, 3.40875164e-02f, -3.00104052e-01f, -4.08640742e-01f, -2.10371554e-01f, -2.80390114e-01f, -2.61168510e-01f, -3.83751899e-01f,
  2.77028739e-01f, 2.45935619e-01f, -6.00140750e-01f, 1.22671135e-01f, 6.92374930e-02f, 6.33365065e-02f, 4.54976857e-01f, 3.20540845e-01f, 1.37410402e-01f, 2.10004717e-01f,
  -3.26501988e-02f, -8.55773166e-02f, -2.46482536e-01f, -1.68371156e-01f, -1.04526728e-01f, 5.63792475e-02f, -1.94907025e-01f, -4.17031139e-01f, 6.07394464e-02f, 2.63187855e-01f,
  3.97012562e-01f, 4.16934997e-01f, 1.97882116e-01f, -4.05853204e-02f, -4.19582836e-02f, 5.65248244e-02f, -2.91699208e-02f, -2.21710712e-01f, -1.58725306e-01f, -4.23302650e-01f,
  -3.76462311e-01f, -4.08315361e-01f, -1.23761177e-01f, -7.76868984e-02f, -1.01906151e-01f, 3.61230085e-03f, -9.98565555e-03f, -6.48536980e-02f, 1.43929839e-01f, 4.22602668e-02f,
  -8.05560201e-02f, -3.15864906e-02f, 6.92309299e-03f, 1.51841640e-01f, 1.84580252e-01f, -5.35444543e-02f, -1.57486796e-01f, -2.63340771e-01f, -1.76739231e-01f, -2.43081346e-01f,
  -1.78815037e-01f, -2.12560698e-01f, -3.00315201e-01f, -1.66452471e-02f, -1.48041412e-01f, -2.74644643e-01f, -1.18696325e-01f, -1.50114775e-01f, -1.58831745e-01f, -3.04996502e-02f,
  -4.28252630e-02f, 1.03898659e-01f, -6.25897869e-02f, 4.25712615e-02f, 2.45018110e-01f, -2.28855256e-02f, -5.35205286e-03f, 1.11922167e-01f, 6.99076429e-02f, 8.31212997e-02f,
  4.11835834e-02f, 1.78020597e-02f, 1.67467579e-01f, 1.63898274e-01f, 3.84808704e-02f, -2.91099809e-02f, 3.10797282e-02f, 1.07427172e-01f, 6.83785155e-02f, 8.01722482e-02f,
  2.00293377e-01f, 7.09592998e-02f, -8.46486073e-03f, 1.49935812e-01f, -4.46711145e-02f, -4.48637791e-02f, 1.22401044e-01f, 1.19942017e-01f, 5.04796281e-02f, -2.24980935e-02f,
  6.72471941e-01f, -1.36092573e-01f, 2.96821054e-02f, -3.87751348e-02f, -5.91743626e-02f, -1.71437949e-01f, 8.58534202e-02f, 8.68827756e-03f, 1.48737729e-02f, 1.55635267e-01f,
  1.01265505e-01f, 1.36845931e-01f, 1.55863911e-01f, 8.40625837e-02f, 1.74746588e-01f, 1.00695454e-01f, 5.99025562e-02f, 9.51797143e-03f, -1.64699163e-02f, -1.13301389e-01f,
  9.01200697e-02f, 1.08566828e-01f, 1.86896622e-01f, 8.08499530e-02f, 3.44124734e-02f, 4.55871224e-02f, 1.19786017e-01f, 1.54864207e-01f, -6.73507864e-04f, 5.50637126e-01f,
  2.62220979e-01f, 7.16038942e-01f, 3.87433559e-01f, -3.64372343e-01f, -3.20032239e-01f, 5.45217134e-02f, 5.10833800e-01f, 3.31298411e-01f, -1.74640298e-01f, 2.26788282e-01f,
  4.34598438e-02f, -4.64391559e-01f, -1.47645533e-01f, -1.49570942e-01f, 2.11725309e-01f, 3.16024721e-01f, -7.88984522e-02f, -7.62200775e-03f, -1.64003268e-01f, -3.24994057e-01f,
  -4.15668398e-01f, -1.31337857e-02f, -5.33290952e-02f, -3.04931309e-02f, 1.09086223e-01f, -3.76830518e-01f, 2.39290640e-01f, 1.38467044e-01f, 1.06694987e-02f, -6.86340183e-02f,
  3.80519539e-01f, 3.90808612e-01f, -4.34127688e-01f, -3.84761274e-01f, -9.62144695e-04f, 1.19731382e-01f, -1.07018938e-02f, 1.49012297e-01f, -1.01615570e-01f, 1.09970398e-01f,
  -1.65171120e-02f, 2.89485902e-02f, -2.02383706e-03f, -1.76799819e-02f, 1.11652330e-01f, -5.27659319e-02f, 1.30706951e-01f, 1.45036995e-01f, -1.76427374e-03f, 1.22105151e-01f,
  -2.55246401e-01f, -8.10836777e-02f, 1.72392592e-01f, 7.66820386e-02f, 1.20483518e-01f, -3.13651919e-01f, 2.26587713e-01f, 7.79582411e-02f, 4.65441495e-02f, 3.25211793e-01f,
  -6.04907461e-02f, 8.47251527e-03f, -1.74673963e-02f, 1.35883749e-01f, -9.25581623e-03f, -1.31805788e-03f, 2.93786731e-02f, 8.46714433e-03f, -3.25955707e-03f, 1.16704516e-01f,
  4.01165299e-02f, 1.65696338e-01f, 2.16395408e-01f, 9.71224234e-02f, -1.37686476e-01f, -5.93385026e-02f, 8.69479999e-02f, 1.28317494e-02f, 5.44936222e-04f, 1.40195098e-02f,
  -6.73435330e-02f, -2.31156475e-03f, -7.02723935e-02f, 1.48294836e-01f, -5.74038848e-02f, -7.34379888e-02f, -4.01298180e-02f, -2.69716755e-02f, 2.19204873e-02f, 4.68088575e-02f,
  -7.65729649e-03f, -1.84574619e-01f, 9.74187069e-03f, -1.17942281e-02f, 1.44203648e-01f, -8.49658623e-02f, -1.19586259e-01f, -9.76866484e-02f, -6.54311106e-02f, 4.58898433e-02f,
  -7.85479173e-02f, 3.77586149e-02f, 1.05297394e-01f, 1.04525089e-01f, -4.55361940e-02f, -1.35947406e-01f, -2.02046826e-01f, -3.50044854e-02f, -3.56814265e-02f, 5.12714051e-02f,
  -8.44503939e-02f, -1.65046573e-01f, -1.57472938e-01f, -1.86837055e-02f, 1.03799170e-02f, -4.88578171e-01f, 1.38618290e-01f, -9.07401890e-02f, 4.35329886e-04f, 7.49823302e-02f,
  -8.32958341e-01f, -2.74314940e-01f, 3.49113643e-01f, -1.91143136e-02f, 9.06115845e-02f, 9.65404212e-02f, -1.38210565e-01f, 1.29564509e-01f, 1.27844855e-01f, -5.13472557e-01f,
  -3.28456312e-01f, 2.10886925e-01f, 1.79786921e-01f, 1.35469899e-01f, -1.70490593e-01f, -4.40397739e-01f, -2.62627355e-03f, 1.87137082e-01f, 3.02081257e-01f, -6.95034787e-02f,
  -1.52877465e-01f, 2.47178711e-02f, 3.88702340e-02f, 1.46693394e-01f, -5.26991002e-02f, 1.22130036e-01f, -5.92066273e-02f, -1.70979500e-01f, -3.87048393e-01f, -3.18579674e-01f,
  -7.05681562e-01f, -2.36225605e-01f, 3.23385119e-01f, -5.98767698e-02f, 7.06820339e-02f, -2.21277416e-01f, -2.54479676e-01f, -1.80535857e-02f, -3.84528749e-02f, -1.44272923e-01f,
  -1.21274844e-01f, -1.01309242e-02f, 4.65513058e-02f, -5.06573580e-02f, -2.34428234e-02f, 1.09449938e-01f, 2.96010345e-01f, 2.06844017e-01f, 6.12365641e-02f, -1.41784698e-01f,
  -2.38033161e-01f, -1.64436981e-01f, 2.76001059e-02f, 2.17721120e-01f, 9.76352841e-02f, 3.19117516e-01f, -2.42803264e-02f, -8.88801217e-02f, -1.55766845e-01f, -7.44475365e-01f,
  -1.16201155e-02f, 7.98750296e-02f, 1.06789201e-01f, 2.32935190e-01f, -1.07618213e-01f, -1.25100508e-01f, 9.19588748e-03f, -1.07205480e-01f, -3.74114700e-02f, 9.23066065e-02f,
  2.12311357e-01f, -2.90788002e-02f, 2.20801294e-01f, -7.06817163e-03f, -4.11258750e-02f, 9.64123383e-02f, -1.24151306e-02f, 3.99977900e-02f, -5.66192716e-02f, -9.41042677e-02f,
  1.34228334e-01f, 4.78409790e-02f, 1.39334142e-01f, -6.58469228e-03f, -1.01148315e-01f, 2.60210149e-02f, -2.33144268e-01f, 9.96885523e-02f, 2.81933323e-02f, -1.51501492e-01f,
  -9.32815149e-02f, 7.75827318e-02f, -4.74693358e-01f, 7.91575015e-02f, -9.06148404e-02f, 5.89787550e-02f, -5.59572242e-02f, -1.27172908e-02f, 1.19460762e-01f, -1.86693937e-01f,
  -7.15522468e-02f, -1.54313326e-01f, -1.73685979e-02f, 1.69157416e-01f, -1.85015231e-01f, 4.91028540e-02f, -4.10136759e-01f, 5.66123351e-02f, 1.70959160e-01f, 1.40098259e-02f,
  -1.29260309e-02f, -2.78405398e-01f, -4.16853189e-01f, -1.69658095e-01f, -2.85526484e-01f, -2.05751747e-01f, -1.92312166e-01f, -1.46074951e-01f, -5.06430030e-01f, -7.92412579e-01f,
  7.94011354e-01f, -2.09251538e-01f, 2.18745619e-01f, 5.47440425e-02f, 1.33311033e-01f, 9.60373208e-02f, -1.43528908e-01f, -8.74002352e-02f, 9.72483959e-03f, 9.59278494e-02f,
  1.09573208e-01f, 2.89897859e-01f, 2.22851127e-01f, 9.97378305e-02f, 2.35930774e-02f, -1.20893449e-01f, -1.91322654e-01f, 1.91220880e-01f, 3.05077791e-01f, 1.11063242e-01f,
  -3.49053591e-02f, 1.64396986e-02f, 1.18052080e-01f, 9.03849378e-02f, -8.78033414e-02f, -4.11620596e-03f, -3.50686498e-02f, 1.29543826e-01f, 8.73523504e-02f, -2.20624134e-01f,
  2.19275966e-01f, 1.87418178e-01f, -3.82144786e-02f, 8.33664909e-02f, 4.30162996e-02f, -3.24124284e-02f, 2.69980412e-02f, 6.71920925e-03f, 2.03118045e-02f, -1.90238953e-01f,
  -9.62836668e-02f, -8.45464095e-02f, -2.27348208e-02f, -6.07357472e-02f, -5.45803048e-02f, -9.26278252e-03f, 1.58097781e-03f, 1.27286566e-02f, 7.08074346e-02f, 8.15239549e-03f,
  -7.39516392e-02f, 3.28508466e-02f, 4.60298136e-02f, -5.23586664e-03f, -6.63762838e-02f, 1.26152277e-01f, -8.64295755e-03f, -4.57208231e-02f, 6.08912930e-02f, -9.74932611e-02f,
  1.28754899e-01f, 2.01515004e-01f, 2.12053940e-01f, 3.76760922e-02f, 1.79065555e-01f, 6.13292567e-02f, -6.39385581e-02f, 1.54224001e-02f, 1.07637882e-01f, 3.43687795e-02f,
  7.71741383e-03f, 1.45159453e-01f, 3.87664661e-02f, 4.88937534e-02f, 1.29684627e-01f, 1.12221107e-01f, -5.80725484e-02f, -1.09141335e-01f, 1.16935417e-01f, 8.69330540e-02f,
  1.32888719e-01f, -7.75603503e-02f, 1.85698316e-01f, -1.01211846e-01f, 6.82838783e-02f, 1.20598614e-01f, 1.94342598e-01f, 6.58103824e-02f, 6.37117103e-02f, 4.35666628e-02f,
  -3.80444586e-01f, 4.39420700e-01f, 1.13232657e-01f, -3.10189929e-02f, 6.65716454e-02f, -1.15031146e-01f, -7.64971972e-02f, -1.25315532e-01f, -1.58262268e-01f, -2.70909786e-01f,
  -9.91537198e-02f, 2.04163231e-02f, -3.67089771e-02f, -1.31805152e-01f, 6.76115751e-02f, 5.59174493e-02f, 1.95694081e-02f, 5.07165417e-02f, -1.22324958e-01f, -9.03066993e-02f,
  -1.96801409e-01f, -2.32306495e-02f, 1.77149579e-01f, -5.94422705e-02f, -2.97932141e-02f, 1.69573009e-01f, 3.92697155e-02f, -6.35113418e-02f, 1.89837053e-01f, -1.87663987e-01f,
  7.66458064e-02f, -4.22363162e-01f, -1.47038966e-01f, 6.41890407e-01f, 4.54501927e-01f, -3.16481829e-01f, -6.32922947e-01f, -4.10642564e-01f, 1.72973752e-01f, 1.20844327e-01f,
  3.03480715e-01f, 5.78619480e-01f, 4.84926224e-01f, 2.50152171e-01f, -1.84485018e-01f, -2.48496249e-01f, 1.16833828e-01f, 1.75624564e-01f, -2.48876084e-02f, 3.13489400e-02f,
  3.40075195e-01f, 2.66492486e-01f, 1.79202870e-01f, -1.21896930e-01f, 2.74655491e-01f, 4.07433659e-01f, 7.46096894e-02f, 2.50418663e-01f, 4.62948978e-02f, 5.95157266e-01f,
  4.25170392e-01f, -4.22720134e-01f, -1.76947936e-01f, 2.86540538e-01f, 1.62273213e-01f, -2.65856564e-01f, -3.55040073e-01f, -2.91986436e-01f, -3.24946344e-01f, -1.40064925e-01f,
  1.32706180e-01f, -1.04683451e-01f, 1.56166464e-01f, -1.42493486e-01f, -2.49007329e-01f, -5.02535462e-01f, -4.09676224e-01f, -3.60962838e-01f, -4.16921765e-01f, -3.15981477e-01f,
  4.87907529e-01f, 1.14375770e-01f, -4.48858440e-01f, -4.80754286e-01f, -2.67828315e-01f, 2.86962390e-01f, -4.34212655e-01f, -1.89288944e-01f, -6.10993028e-01f, -1.87964648e-01f,
  -2.66176593e-02f, -1.25918850e-01f, -1.12593569e-01f, -2.71983352e-02f, 1.39384018e-02f, -1.28000937e-02f, 2.19405934e-01f, 1.31275505e-01f, -1.21970713e-01f, -1.90144345e-01f,
  -1.11097982e-02f, -1.06387906e-01f, -1.05535658e-03f, -7.33546987e-02f, -1.29552511e-02f, -2.45387927e-01f, -7.98148140e-02f, -1.68582156e-01f, -3.47616598e-02f, -5.81805743e-02f,
  1.48061365e-01f, -2.43759342e-02f, -1.58682466e-01f, -1.22266963e-01f, -5.24524376e-02f, -7.34778121e-02f, -6.49882331e-02f, -8.75010043e-02f, -1.23910345e-01f, -1.87993854e-01f,
  5.56415692e-02f, -1.58747181e-01f, 3.06168087e-02f, 1.53896838e-01f, -3.83054838e-02f, -6.42096624e-02f, 7.02356771e-02f, 9.16503966e-02f, 1.25806749e-01f, -6.53750747e-02f,
  -1.78229809e-01f, -1.12129048e-01f, -1.02739803e-01f, -1.93142757e-01f, -1.29630774e-01f, -9.46900919e-02f, 1.04788758e-01f, 2.20398247e-01f, -1.91902012e-01f, -1.23188771e-01f,
  1.16883196e-01f, -3.21316838e-01f, -2.67300218e-01f, -2.29861513e-01f, -9.32764784e-02f, 1.16501627e-02f, -3.83192450e-01f, -4.53756213e-01f, -6.04666948e-01f, -6.58718526e-01f,
  3.44148099e-01f, -6.69183314e-01f, -2.58041918e-01f, -1.92490771e-01f, -3.45208585e-01f, -2.57616132e-01f, -4.91973579e-01f, -1.10424466e-01f, -2.04116806e-01f, -2.96271443e-01f,
  -4.62194458e-02f, 4.54419404e-01f, 2.81535119e-01f, 2.84694076e-01f, 2.05407739e-01f, -5.03243268e-01f, -3.70599061e-01f, 2.95905739e-01f, 5.42903364e-01f, 6.91297874e-02f,
  -1.66795224e-01f, 3.39692496e-02f, 2.28401318e-01f, -7.84904063e-02f, -3.73412073e-01f, -3.53349783e-02f, -2.03310981e-01f, -2.33021349e-01f, -2.30492949e-01f, -3.96420300e-01f,
  3.07915509e-01f, 1.83611751e-01f, 2.39164233e-01f, 1.34931067e-02f, -3.16593051e-02f, 7.32683241e-02f, 4.94395792e-02f, -2.96945516e-02f, -9.70238671e-02f, -8.46230537e-02f,
  7.65326694e-02f, 7.62034655e-02f, 1.87107045e-02f, -9.18220496e-04f, -4.69196551e-02f, 1.08390734e-01f, 1.00620918e-01f, 5.66213578e-02f, -1.25392511e-01f, -7.41987154e-02f,
  -1.41375616e-01f, -5.84782325e-02f, 4.02628705e-02f, 9.59447958e-03f, 2.05716208e-01f, 1.69376522e-01f, 1.21879078e-01f, 1.01667307e-01f, 1.81961134e-01f, -1.75946236e-01f,
  -1.50596455e-01f, -3.39883529e-02f, 1.14709102e-01f, 1.19178414e-01f, 1.76591814e-01f, -1.27306003e-02f, -3.10320803e-03f, -4.12912369e-02f, 9.96172354e-02f, -5.95474895e-03f,
  -1.76109523e-01f, 1.74061544e-02f, 8.94484222e-02f, -5.60937915e-03f, -3.19606718e-03f, 1.41252056e-02f, 3.11012920e-02f, 7.08816499e-02f, 1.33974418e-01f, -1.16422646e-01f,
  1.13879606e-01f, -6.44669160e-02f, -1.43503726e-01f, 7.08538964e-02f, -1.09469019e-01f, 1.64709538e-02f, 7.28532895e-02f, 5.91859147e-02f, -3.26907635e-02f, -1.45583227e-01f,
  2.15829477e-01f, 3.57286185e-01f, 1.33762918e-02f, 1.09094590e-01f, -6.03043213e-02f, -5.95601425e-02f, 2.49192163e-01f, 3.77023872e-03f, -4.96789478e-02f, 3.87492105e-02f,
  7.14910701e-02f, 8.86601061e-02f, 9.31428224e-02f, -4.03264090e-02f, 4.95234393e-02f, 1.15280256e-01f, 2.65668072e-02f, 8.46443772e-02f, -9.03211534e-02f, -1.21697322e-01f,
  -3.08849394e-01f, 3.90600646e-04f, 1.48097605e-01f, 8.01082235e-04f, 2.14673486e-03f, 1.86369717e-01f, 8.54064599e-02f, 6.41573370e-02f, 1.71572968e-01f, -2.60598540e-01f,
  7.39160657e-01f, 3.99090290e-01f, 9.91195962e-02f, 5.62122054e-02f, -7.96493292e-02f, -1.36008952e-02f, 2.25632682e-01f, 1.40940323e-01f, -2.21575484e-01f, 7.82311261e-02f,
  -1.99996024e-01f, -4.14367974e-01f, -1.80530444e-01f, -5.52284867e-02f, 1.58487320e-01f, 1.21219531e-01f, 1.85281679e-01f, 1.55832812e-01f, 1.42185777e-01f, 8.44077170e-02f,
  1.93415973e-02f, 2.69082993e-01f, 3.01477820e-01f, 1.10737190e-01f, 1.28351778e-01f, -1.12583339e-01f, 1.05581023e-01f, 1.89367980e-01f, 9.38691497e-02f, 1.51009575e-01f,
  -5.59049509e-02f, 3.84759426e-01f, -2.32066378e-01f, -1.06502600e-01f, -1.53622767e-02f, 1.25690535e-01f, -4.73262630e-02f, -2.79346528e-03f, -5.14686964e-02f, 3.04271057e-02f,
  3.84554788e-02f, -2.47134771e-02f, 4.80512790e-02f, -9.52413455e-02f, -7.36271068e-02f, -1.34455869e-02f, -3.89004163e-02f, -2.91112857e-03f, -1.02011740e-01f, -1.30957186e-01f,
  -1.99503049e-01f, -1.53091669e-01f, -6.36335555e-03f, -3.23492318e-01f, -3.53379957e-02f, -3.09977204e-01f, -1.00475186e-02f, -6.92009777e-02f, -1.01814806e-01f, -8.14470723e-02f,
  -5.81196547e-01f, -1.29016250e-01f, -1.65053278e-01f, -1.52567804e-01f, -1.34789586e-01f, -6.81688488e-02f, -4.59732637e-02f, -3.54094952e-02f, -3.33813913e-02f, -4.01796624e-02f,
  -1.28729671e-01f, -2.58543700e-01f, -1.91929370e-01f, -1.39151216e-01f, -1.12848505e-01f, -9.75131467e-02f, 9.47069675e-02f, -6.85219616e-02f, -6.20289631e-02f, -2.90848259e-02f,
  -1.80760399e-02f, -7.43551971e-03f, -7.18917400e-02f, -1.09248027e-01f, -1.11510843e-01f, -1.70490012e-01f, -1.16717428e-01f, -2.04502657e-01f, -1.09373190e-01f, 1.18327871e-01f,
  -4.19724107e-01f, -2.31843904e-01f, 3.49027477e-02f, 3.39733779e-01f, 1.17864713e-01f, 1.42855003e-01f, 3.58684734e-02f, 9.27644223e-03f, 1.77899212e-01f, 1.80909574e-01f,
  1.87583759e-01f, 1.89098775e-01f, 2.28713736e-01f, 2.14307476e-02f, -5.87093644e-02f, -1.04941413e-01f, 1.01676974e-02f, 2.31143292e-02f, -9.37390886e-03f, -6.98937550e-02f,
  -5.55109531e-02f, -1.70046285e-01f, -2.69820154e-01f, -2.74964035e-01f, -1.02167301e-01f, -1.68771073e-01f, -1.55898884e-01f, -5.17284051e-02f, -8.82429034e-02f, -1.88898593e-01f,
  3.80758941e-01f, -1.95822224e-01f, -1.53151929e-01f, 4.29676443e-01f, 1.30404606e-01f, 1.72527060e-01f, 4.87446815e-01f, 2.71961421e-01f, 2.92357206e-01f, 3.50519568e-01f,
  -3.95817667e-01f, -8.49989533e-01f, -6.73158467e-01f, -5.78860164e-01f, -3.11797082e-01f, 5.14679611e-01f, 4.24817413e-01f, -1.64857730e-01f, -1.98115572e-01f, 9.16722268e-02f,
  7.00860992e-02f, 4.70997155e-01f, 2.41164267e-01f, -1.03324957e-01f, 1.70615062e-01f, -9.11350176e-02f, 2.00502813e-01f, -9.42510590e-02f, -2.23816782e-01f, -1.20741203e-01f,
  -7.38176471e-03f, -3.80401433e-01f, 3.72113241e-03f, -3.18975955e-01f, -6.08567148e-02f, 1.35358393e-01f, 1.87265068e-01f, -1.27947330e-01f, -3.84651572e-01f, 9.65981260e-02f,
  -3.10368687e-01f, -1.75681174e-01f, -4.72103268e-01f, -9.31402147e-02f, 9.25894678e-02f, -1.11613758e-02f, -6.71318397e-02f, -2.32745320e-01f, -2.59223372e-01f, -3.63923997e-01f,
  -3.88043195e-01f, -2.90369868e-01f, -2.34971747e-01f, -8.43322575e-02f, -4.22028244e-01f, -2.98314363e-01f, -2.20291302e-01f, -3.76806110e-01f, -3.76423389e-01f, 3.35576266e-01f,
  1.35843232e-01f, 8.26057717e-02f, -7.75005743e-02f, 1.12084523e-01f, 2.73611136e-02f, -7.92235509e-02f, -1.52174205e-01f, -5.44203520e-02f, -6.16420656e-02f, 8.48067403e-02f,
  -1.58721715e-01f, 1.75707504e-01f, 3.08275875e-02f, 5.76958209e-02f, -2.38698870e-01f, 3.45857702e-02f, 7.18099773e-02f, 1.41225740e-01f, -1.59729689e-01f, 1.80924311e-01f,
  -1.17079929e-01f, 1.25362845e-02f, 8.36977735e-03f, -9.50987190e-02f, 4.92589958e-02f, -8.54537562e-02f, 1.32922679e-01f, -1.26758799e-01f, 5.19764945e-02f, 4.23453115e-02f,
  5.39574027e-01f, -3.14103425e-01f, 3.03455114e-01f, -5.59935123e-02f, 1.23725556e-01f, -1.00383461e-01f, 3.92003208e-02f, 6.98760618e-03f, -1.71832725e-01f, -1.77557588e-01f,
  -3.03520471e-01f, -3.16228896e-01f, -1.53763339e-01f, 8.92153755e-02f, 1.89216137e-01f, 1.72118783e-01f, 4.69418578e-02f, -2.30635442e-02f, 1.07098155e-01f, 1.85864627e-01f,
  1.47975743e-01f, 1.81022257e-01f, 3.66575688e-01f, 2.11327344e-01f, 2.45077405e-02f, 2.68328339e-01f, 4.29427832e-01f, 2.27642342e-01f, 1.56677455e-01f, 7.63860524e-01f,
  -6.20512187e-01f, 5.42484045e-01f, -4.51415569e-01f, 2.64753047e-02f, -3.59457843e-02f, -1.86410636e-01f, 2.11381853e-01f, 2.28625655e-01f, 4.83919472e-01f, 4.32616860e-01f,
  1.69632673e-01f, -2.78163195e-01f, -8.65038559e-02f, -2.44044624e-02f, -1.74232423e-01f, 5.71092010e-01f, 5.72136641e-01f, -5.58793008e-01f, -8.92104447e-01f, -4.54406410e-01f,
  1.00565255e-01f, -3.46128434e-01f, -6.19185269e-01f, -3.59296620e-01f, 2.23561168e-01f, -4.01925407e-02f, 1.70949832e-01f, -2.69713283e-01f, -3.02136570e-01f, 1.51532173e-01f,
  -3.88869256e-01f, -2.23346308e-01f, -4.73328233e-02f, -1.43156484e-01f, -2.84079071e-02f, 6.98106771e-04f, -5.77804893e-02f, -9.64047313e-02f, 1.47571880e-03f, 2.28732362e-01f,
  -2.13068098e-01f, -6.69148471e-03f, -1.98603824e-01f, -4.69269529e-02f, -2.02469781e-01f, -2.75284350e-01f, -1.26718273e-02f, -3.05661947e-01f, -9.42638665e-02f, -3.32183808e-01f,
  2.18164057e-01f, -4.51497763e-01f, -6.66578650e-01f, -4.66441065e-02f, 1.23355389e-02f, -1.66135713e-01f, -3.66663635e-01f, -5.15573978e-01f, -5.83173573e-01f, -1.12957969e-01f,
  1.20083308e-02f, -6.28711060e-02f, 1.53322563e-01f, -8.49390849e-02f, 1.19980462e-01f, 2.16466948e-01f, 8.72054324e-02f, 1.27993152e-02f, 1.30375871e-03f, -2.20454872e-01f,
  -1.55406177e-01f, -1.72449902e-01f, -1.45610958e-01f, 9.47757531e-03f, -5.88545278e-02f, 1.33110173e-02f, 5.57868555e-03f, 2.54082263e-01f, -3.46727520e-02f, 4.48326804e-02f,
  -7.56253749e-02f, -4.27168934e-03f, 1.37512162e-01f, -1.01849079e-01f, 6.90884367e-02f, 1.69724047e-01f, 1.14869677e-01f, -9.68464240e-02f, 1.21422395e-01f, -7.59056723e-03f,
  -2.69239279e-03f, 8.52383748e-02f, 4.47990447e-02f, 3.72307450e-02f, -3.99260670e-02f, -2.16081552e-02f, 1.67160168e-01f, -3.87037285e-02f, -1.19043030e-01f, -1.74176678e-01f,
  -1.79105088e-01f, 4.33384031e-02f, 3.46814305e-01f, -2.24993244e-01f, -2.91853994e-01f, -1.10032402e-01f, 3.14062625e-01f, -2.21610218e-01f, -1.34755999e-01f, -1.37802195e-02f,
  2.61307657e-01f, -1.34913772e-01f, -2.76941776e-01f, -2.25709796e-01f, -3.64182629e-02f, -1.32410213e-01f, -3.21861148e-01f, -2.32407048e-01f, -3.85783106e-01f, 1.87240973e-01f,
  -4.46648628e-01f, 3.38286519e-01f, 2.60807753e-01f, -3.63762259e-01f, 7.26702511e-02f, 3.40422630e-01f, 4.91398007e-01f, 1.68853119e-01f, -1.48039937e-01f, 9.88394618e-02f,
  2.02412367e-01f, -5.03213823e-01f, -5.53267896e-01f, -3.19024742e-01f, -8.98524225e-02f, 1.01766460e-01f, -7.54296929e-02f, -4.15167898e-01f, -2.45288491e-01f, -8.06441437e-03f,
  -2.05329344e-01f, -3.22569698e-01f, -2.98256218e-01f, -3.03278446e-01f, -3.74834865e-01f, -5.72245657e-01f, -2.45198235e-01f, -1.59864679e-01f, 5.57191595e-02f, -4.90653753e-01f,
  1.10932037e-01f, 3.84655863e-01f, -1.40783772e-01f, -2.17852131e-01f, 5.32587618e-03f, -6.62394017e-02f, 7.09069744e-02f, 6.17108718e-02f, 9.66081470e-02f, 5.33798784e-02f,
  -2.00717896e-02f, -7.39426240e-02f, -1.13894269e-01f, -1.19683298e-03f, 1.73394844e-01f, 1.39800072e-01f, 1.88331634e-01f, 2.04466302e-02f, 5.76546378e-02f, 3.14151376e-01f,
  1.61548525e-01f, 1.86884210e-01f, 2.20940083e-01f, 2.36173227e-01f, 2.67869174e-01f, 2.33754981e-02f, 2.60522306e-01f, 1.43578857e-01f, 1.64738908e-01f, -1.28141850e-01f,
  1.12323605e-01f, -3.12090218e-02f, 4.96865027e-02f, 1.04853831e-01f, -3.49949859e-02f, 1.04807191e-01f, 2.47900337e-02f, -3.77006060e-03f, -9.60662887e-02f, -8.48620236e-02f,
  5.11797965e-02f, 1.43990964e-01f, 4.19413373e-02f, -4.36875969e-02f, -1.23686694e-01f, 7.15440586e-02f, 9.22635421e-02f, 7.87004754e-02f, 1.54620647e-01f, 5.51432669e-02f,
  -2.77206860e-02f, 9.62909758e-02f, 6.39293045e-02f, 8.57094303e-02f, 2.75936335e-01f, 1.91852152e-01f, 1.14624962e-01f, 5.94108999e-02f, -4.89401780e-02f, 9.28046852e-02f,
  -2.15165526e-01f, 1.95793808e-01f, -2.62744009e-01f, -1.11426584e-01f, 1.02432014e-03f, -2.30969004e-02f, 3.32527161e-02f, 2.70502213e-02f, 3.22879963e-02f, 1.33105278e-01f,
  1.93595618e-01f, 3.63366120e-02f, 1.46922633e-01f, 1.38284057e-01f, -1.26195729e-01f, 5.71954474e-02f, 4.84946854e-02f, -1.56162038e-01f, 1.50450826e-01f, 2.31580183e-01f,
  1.31001353e-01f, -1.80421825e-02f, -7.44402632e-02f, -5.65909967e-02f, 1.46492058e-02f, -2.54637539e-01f, -1.12888806e-01f, -7.60543123e-02f, -1.14203036e-01f, -2.97320455e-01f,
  3.60037118e-01f, -5.79664350e-01f, 4.72803295e-01f, 4.07097310e-01f, 5.57910316e-02f, 1.81764588e-01f, -1.84703603e-01f, 5.67905530e-02f, 2.38461077e-01f, -1.65649161e-01f,
  -3.14369440e-01f, 2.97616026e-03f, 6.05091490e-02f, 3.77324619e-03f, 9.17892158e-02f, 8.48813727e-02f, 3.17274213e-01f, 4.38922197e-01f, 3.95453006e-01f, -1.26136661e-01f,
  -1.51684716e-01f, 2.76480727e-02f, 1.66014925e-01f, 4.81868647e-02f, -2.01650962e-01f, 6.56150356e-02f, -5.61989136e-02f, -1.04935020e-01f, -2.90672719e-01f, 5.39512299e-02f,
  -3.59429896e-01f, -3.91071558e-01f, 1.71810806e-01f, -2.46730670e-01f, -2.07780331e-01f, -1.70404464e-01f, 5.62253455e-03f, -7.50806034e-02f, -1.72705222e-02f, -4.72669229e-02f,
  -1.30819276e-01f, -1.44217804e-01f, -3.38924117e-02f, -1.86319605e-01f, -7.17601702e-02f, -1.40823141e-01f, -9.96730030e-02f, -6.55693114e-02f, 2.32937839e-02f, -9.03485566e-02f,
  -1.44543573e-01f, -4.15040441e-02f, -1.20718707e-03f, 7.04139024e-02f, 1.05939418e-01f, 1.94282934e-01f, -2.10188285e-01f, -1.83804671e-03f, 4.42703739e-02f, -7.91096166e-02f,
  3.47031653e-02f, 9.20486227e-02f, -6.77722553e-03f, 1.10369287e-02f, 1.16378972e-02f, 1.38657510e-01f, -6.15098514e-04f, -7.86828622e-02f, 8.28173161e-02f, 2.10148469e-03f,
  -6.57560527e-02f, 1.50040030e-01f, 7.58407414e-02f, -1.38962075e-01f, 9.54196230e-03f, 2.83200908e-02f, 5.23623452e-02f, -1.26075774e-01f, -1.54153436e-01f, 6.75422698e-03f,
  4.49968688e-02f, 2.36936659e-02f, -9.87376496e-02f, -6.43267063e-03f, -1.75346494e-01f, 1.45129859e-02f, -9.90367159e-02f, -1.08981051e-01f, -9.45414528e-02f, -1.08905762e-01f,
  -5.52823842e-02f, 2.42069796e-01f, 1.51062950e-01f, -2.26736572e-02f, 1.75666139e-02f, -4.44625430e-02f, 5.21871038e-02f, 1.01052038e-02f, -1.31286636e-01f, 2.85210628e-02f,
  -1.52179748e-01f, 7.26231337e-02f, -8.16587582e-02f, 3.74829881e-02f, 1.51090011e-01f, 2.17447039e-02f, -2.83322275e-01f, 1.05864242e-01f, 5.60446754e-02f, -7.46225938e-02f,
  2.44661421e-02f, 2.93241572e-02f, 9.59074274e-02f, 1.86499849e-01f, 5.46481125e-02f, 2.74662673e-01f, 6.30508969e-03f, 5.36068305e-02f, 2.24545985e-01f, 1.21533521e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  5.49987555e-01f, 2.98525810e-01f, 5.72053790e-01f, 7.90145516e-01f, 7.16083229e-01f, 4.87538904e-01f, 3.62592310e-01f, 3.11827183e-01f, 2.67250597e-01f, 4.67003196e-01f,
  2.22793803e-01f, 3.44662786e-01f, 4.44911987e-01f, 6.40427589e-01f, 4.54404503e-01f, 4.95916098e-01f, 7.45673597e-01f, 4.74564016e-01f, 4.45971936e-02f, 4.93868232e-01f,
  8.23097646e-01f, 3.56514186e-01f, 6.67678893e-01f, 8.17817688e-01f, 8.51255298e-01f, 3.95297378e-01f, 6.32822454e-01f, 5.99504292e-01f, 1.39401555e-01f, 6.32783353e-01f,
  1.00456703e+00f, 2.95726925e-01f, 6.08639181e-01f, 4.20229971e-01f, 1.97513059e-01f, 4.14205462e-01f, 6.23475134e-01f, 4.27883238e-01f, 3.28903854e-01f, 6.14712596e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.29232302e-01f, -1.32759899e-01f, -2.13554814e-01f, -1.68404594e-01f, -1.76934674e-01f, -2.53418207e-01f, -4.58726406e-01f, 6.47020042e-02f, -2.17221931e-01f, -1.01693854e-01f,
  -2.30365798e-01f, -1.45798484e-02f, -1.86887830e-01f, 1.00158766e-01f, 9.60472971e-02f, 1.67342991e-01f, 2.91096210e-01f, 2.11810833e-03f, 2.14955911e-01f, 3.90751004e-01f,
  -1.27593085e-01f, 1.02392919e-01f, -2.17182375e-02f, -1.27993375e-01f, 2.61981428e-01f, -2.19319656e-01f, -4.47151884e-02f, 3.67929377e-02f, -5.69768667e-01f, -3.01154703e-01f,
  -5.59241533e-01f, -3.39140803e-01f, 1.66895732e-01f, 3.82408381e-01f, -1.46693587e-01f, 4.32218343e-01f, -1.34353146e-01f, -7.47470632e-02f, 6.55152261e-01f, 1.76158682e-01f,
  -5.95673025e-01f, -7.85721898e-01f, 3.54360044e-01f, -1.81146234e-01f, -6.49706185e-01f, -2.41169035e-01f, -7.40696132e-01f, 1.56138554e-01f, -4.34022218e-01f, -2.38925174e-01f,
  -4.45865840e-01f, 2.53963947e-01f, -1.03346717e+00f, 1.27806917e-01f, -5.60001612e-01f, 3.51620615e-01f, -3.41832936e-01f, -4.60838467e-01f, 4.78075802e-01f, -6.47625744e-01f,
  -6.00428998e-01f, -2.71614641e-01f, 2.71056980e-01f, -6.91706479e-01f, 1.50762916e-01f, 2.17604712e-01f, 4.78516929e-02f, -2.93088347e-01f, -4.81608249e-02f, 1.63907379e-01f,
  -3.09448540e-01f, -1.92341417e-01f, 1.66530326e-01f, 2.13890120e-01f, -7.93249682e-02f, -1.73815954e-02f, -2.41168305e-01f, 4.75863814e-02f, 2.91846573e-01f, -2.70271450e-02f,
  2.16599461e-02f, 2.36770555e-01f, 2.57273465e-01f, 1.95554540e-01f, -2.11321384e-01f, -2.93463856e-01f, -1.61870390e-01f, 2.40381226e-01f, 9.19619918e-01f, -8.73350441e-01f,
  -9.28647578e-01f, -2.56534487e-01f, -4.07373041e-01f, -3.58087048e-02f, 1.11598395e-01f, 3.23256493e-01f, -6.68062627e-01f, 3.75849530e-02f, 3.94320101e-01f, -7.87086010e-01f,
  2.07826644e-01f, 5.19406915e-01f, -4.32823449e-01f, 2.52864063e-01f, 6.63200498e-01f, -9.65985596e-01f, -9.20134902e-01f, -3.56024534e-01f, -3.71475250e-01f, 5.88127151e-02f,
  -2.45155513e-01f, -6.56286284e-05f, -6.12411141e-01f, 6.07323088e-02f, -3.61577183e-01f, 5.79318643e-01f, -2.07135811e-01f, -1.03033908e-01f, -9.62880433e-01f, -3.29592347e-01f,
  4.41261888e-01f, 3.54368299e-01f, 4.56764668e-01f, -9.59418640e-02f, -5.38672268e-01f, -1.33308160e+00f, -7.15995371e-01f, 3.42521101e-01f, -2.03396842e-01f, 2.04697177e-01f,
  2.50318706e-01f, 1.60927117e-01f, 1.65158510e-01f, 1.52675182e-01f, 7.19894990e-02f, 2.81476267e-02f, 7.71792457e-02f, -2.44216785e-01f, 5.67123480e-02f, -8.07933211e-02f,
  3.59513581e-01f, -2.41795644e-01f, -4.31951851e-01f, 2.27783129e-01f, -9.67923701e-02f, -1.07420348e-01f, 1.87893555e-01f, -1.81355193e-01f, 1.29887596e-01f, 3.91163558e-01f,
  -4.09203261e-01f, 2.84151384e-03f, 2.49647051e-01f, 1.65668204e-02f, -8.07185411e-01f, 1.58911213e-01f, 4.41887796e-01f, -2.32780948e-01f, -1.23086117e-01f, -7.11055025e-02f,
  -1.68731138e-01f, -8.00561607e-01f, -3.46143842e-01f, 8.06110024e-01f, -1.37742519e-01f, -1.11773252e+00f, 4.96901840e-01f, 7.48090297e-02f, 4.86679494e-01f, 7.90685713e-02f,
  -6.47058308e-01f, 3.65996473e-02f, -5.00254273e-01f, -5.10337949e-01f, -4.11098450e-02f, -1.77638546e-01f, -1.05181493e-01f, -2.85477221e-01f, -8.79425555e-02f, 3.12181056e-01f,
  -5.20899057e-01f, -7.17428148e-01f, -4.76741731e-01f, 7.76337922e-01f, 1.68043971e-01f, 1.34018555e-01f, 3.56640160e-01f, -1.85818493e-01f, -5.64180672e-01f, -4.61868674e-01f,
  -2.58859366e-01f, 2.36146808e-01f, -1.61706194e-01f, -1.17626972e-01f, -4.88472022e-02f, 8.51851627e-02f, -5.03181107e-02f, -2.40342066e-01f, -1.28479198e-01f, 4.06408653e-04f,
  6.14602491e-02f, -1.12282168e-02f, 6.54564500e-02f, -2.01164499e-01f, -2.77771205e-01f, 1.13986060e-01f, -8.20373592e-04f, -6.79830670e-01f, -4.90904808e-01f, 1.40301973e-01f,
  2.27793247e-01f, -1.79312259e-01f, -6.06623404e-02f, 6.47321418e-02f, -1.64490223e-01f, -1.24335222e-01f, -5.51441669e-01f, 6.00360215e-01f, -5.31699598e-01f, -1.23792624e+00f,
  -6.81167543e-01f, 2.96450675e-01f, -4.02536184e-01f, -1.11374609e-01f, 1.37511387e-01f, -7.43658662e-01f, -4.54338938e-01f, 5.68951607e-01f, -1.58602342e-01f, 3.45129311e-01f,
  3.27980369e-01f, -2.61010885e-01f, -8.34353328e-01f, -3.15396041e-01f, -2.52403796e-01f, -8.84966671e-01f, 3.77510250e-01f, -5.64950943e-01f, -6.77203462e-02f, 3.88659507e-01f,
  6.84760749e-01f, -3.55375141e-01f, 3.00867558e-01f, 6.11629859e-02f, 4.88221258e-01f, -3.26015711e-01f, 1.20753892e-01f, -1.34132519e-01f, -2.56839693e-01f, -9.47024047e-01f,
  -8.15792739e-01f, -5.33117652e-01f, -5.20788431e-01f, 3.55730474e-01f, 4.98577625e-01f, -3.74584228e-01f, -4.42687273e-02f, -4.86747250e-02f, -4.71576862e-02f, -4.23453748e-02f,
  9.45517514e-03f, 2.17636943e-01f, 2.35047027e-01f, 4.87713292e-02f, -5.64694544e-03f, 3.47938240e-02f, -2.84552276e-01f, -1.97368994e-01f, 2.21380591e-01f, 1.93686798e-01f,
  3.17565620e-01f, 3.78297985e-01f, -1.38737604e-01f, 3.33054245e-01f, -1.01294026e-01f, -3.45554650e-01f, -1.09112382e-01f, 1.36519432e-01f, -9.82297733e-02f, 8.66541639e-02f,
  1.94586664e-01f, -4.44382012e-01f, 3.52475435e-01f, -5.27269185e-01f, 3.23361397e-01f, 3.44783396e-01f, 8.04864690e-02f, -4.99093011e-02f, 3.22963558e-02f, 1.41535431e-01f,
  -1.54943824e-01f, -5.62779903e-01f, -1.11452967e-01f, -7.66738579e-02f, -4.52767342e-01f, 1.69572663e-02f, -5.77932954e-01f, 8.00141096e-01f, 9.91961733e-02f, 3.01408321e-01f,
  3.22007239e-02f, 1.55540273e-01f, -7.16905951e-01f, -9.27189231e-01f, -1.74117640e-01f, -7.22796381e-01f, 3.44733894e-01f, -4.38733958e-02f, 5.19110560e-01f, -7.15327621e-01f,
  2.47019425e-01f, 1.69007197e-01f, -3.22015166e-01f, -3.43162894e-01f, -4.81021911e-01f, -3.96161079e-01f, -3.40466499e-01f, 3.02085131e-01f, 1.71502046e-02f, -2.15871781e-01f,
  -1.74856428e-02f, 7.25861639e-02f, 1.67355359e-01f, -2.01836333e-01f, 4.31341045e-02f, -1.07619511e-02f, 3.09711546e-01f, 2.81086564e-01f, -2.03014612e-01f, 8.89716446e-02f,
  2.71227270e-01f, 2.57103164e-02f, -4.90956038e-01f, -3.31299096e-01f, 9.65878484e-04f, 1.42777711e-01f, 3.86000067e-01f, 9.32325795e-03f, 1.74254879e-01f, 1.16663966e-02f,
  -4.26296473e-01f, -7.67647028e-02f, 3.29101905e-02f, 1.71578348e-01f, -8.71714950e-02f, -4.02146697e-01f, 9.03218448e-01f, 7.76665151e-01f, -2.45121166e-01f, -8.43996704e-01f,
  -3.05763453e-01f, -1.81970999e-01f, -8.19549739e-01f, 5.60624003e-01f, -3.45915288e-01f, -1.53677091e-01f, 3.56206208e-01f, 1.65568575e-01f, -6.13421679e-01f, 2.75306582e-01f,
  -1.90746665e-01f, -8.14034820e-01f, -1.30727679e-01f, 2.73303926e-01f, -1.79270566e-01f, 4.31238860e-02f, -1.23544112e-01f, -5.24501264e-01f, -4.10255879e-01f, 3.79273295e-01f,
  4.93263192e-02f, -3.08740418e-02f, -5.70048869e-01f, 5.94254434e-01f, -6.67802691e-02f, -8.84548068e-01f, -4.61442590e-01f, -9.21391472e-02f, -6.81906044e-01f, 9.61197075e-03f,
  6.50139213e-01f, 5.12530267e-01f, -5.55291116e-01f, -2.66065061e-01f, 3.31560671e-02f, -1.40383869e-01f, -5.26256204e-01f, 2.49800295e-01f, -9.30639356e-02f, -4.07071292e-01f,
  -1.60716057e-01f, 1.51379585e-01f, 1.46294579e-01f, 1.83581412e-01f, -1.83243025e-02f, 1.20741613e-01f, 1.73305459e-02f, -1.79314092e-01f, -2.98769355e-01f, -4.17415472e-03f,
  -2.45780265e-03f, -3.57657745e-02f, -1.53861314e-01f, -7.81751052e-02f, -2.15639412e-01f, -1.06221266e-01f, 3.58156949e-01f, 4.14691083e-02f, -3.70414227e-01f, 7.10618049e-02f,
  -1.62168637e-01f, 9.91550565e-01f, 6.39824092e-01f, -8.04852486e-01f, -7.40514100e-01f, -1.58790514e-01f, -2.48943016e-01f, -1.04481673e+00f, 3.54964048e-01f, -8.73189151e-01f,
  -4.96066928e-01f, -3.96564096e-01f, -2.58744508e-01f, -3.29740904e-02f, 6.78827286e-01f, 4.55347300e-01f, -1.83738321e-01f, 4.07093875e-02f, -2.63361275e-01f, 2.05731913e-01f,
  -6.43459558e-01f, -5.48235893e-01f, -2.17421800e-01f, 1.97851017e-01f, -5.78769982e-01f, -6.46855354e-01f, -5.15898526e-01f, -6.20206475e-01f, 8.23762178e-01f, -3.44419301e-01f,
  -6.64703697e-02f, -1.20051190e-01f, -3.25836122e-01f, 4.47861940e-01f, -1.38755172e-01f, -2.06675276e-01f, -8.67416024e-01f, -2.44839475e-01f, -1.30026460e-01f, -1.59791589e-01f,
  -7.44988816e-03f, -1.97369918e-01f, -2.68898308e-01f, 8.58517066e-02f, -6.03201836e-02f, -4.34896082e-01f, -2.25645900e-01f, -3.12182814e-01f, -7.01962933e-02f, -1.11221530e-01f,
  -3.20460141e-01f, -7.54077211e-02f, 2.82926291e-01f, -1.83504865e-01f, -3.11450213e-01f, -1.23788796e-01f, -1.09722592e-01f, -1.01112261e-01f, -4.41224910e-02f, 1.28354147e-01f,
  6.07929900e-02f, -3.46911371e-01f, -4.60029215e-01f, 5.98846853e-01f, -1.58884257e-01f, -5.79701364e-01f, -4.29947495e-01f, -2.93917745e-01f, 4.40408409e-01f, -4.49686229e-01f,
  -1.98492125e-01f, -3.41250628e-01f, -9.71331261e-03f, 7.48841837e-02f, -3.89490753e-01f, -1.01316321e+00f, -2.61549592e-01f, -2.17581782e-02f, -4.23787117e-01f, -1.76001862e-01f,
  -6.01840913e-01f, -7.55929202e-02f, 3.61490369e-01f, -3.04319523e-02f, 4.80869114e-01f, -4.37864335e-04f, 4.73930627e-01f, -1.65736545e-02f, -3.68375540e-01f, -4.97043818e-01f,
  6.13142669e-01f, -6.41673654e-02f, -6.73932195e-01f, 4.91046846e-01f, -6.24842405e-01f, 1.74804643e-01f, -3.37770909e-01f, -3.53502035e-01f, -3.81499738e-01f, 5.45794129e-01f,
  -4.07131389e-02f, 7.24296421e-02f, 2.41147116e-01f, 4.78304103e-02f, 1.61621630e-01f, 8.35022032e-02f, 3.60110588e-02f, 1.23105466e-01f, 1.55554295e-01f, -1.06637917e-01f,
  -7.75772408e-02f, -1.33432165e-01f, -3.45926613e-01f, 3.87584162e-03f, 5.14527261e-01f, 1.88806489e-01f, -2.53293842e-01f, 1.21219225e-01f, 2.08601370e-01f, 4.09850217e-02f,
  -1.85772955e-01f, 1.85284019e-01f, 4.01122659e-01f, -1.70907646e-01f, 3.64675850e-01f, 2.51368880e-01f, -8.44481111e-01f, -1.14325233e-01f, -5.76819956e-01f, 4.87691253e-01f,
  -1.20391406e-01f, -2.24484622e-01f, 1.59044012e-01f, 1.26899734e-01f, -2.22014382e-01f, -5.84320843e-01f, -4.10035759e-01f, -3.26285988e-01f, -3.81394684e-01f, -8.92540574e-01f,
  -2.52708673e-01f, 3.85187604e-02f, -3.56434971e-01f, -2.50082970e-01f, -3.94700468e-01f, -3.05716217e-01f, -8.20071578e-01f, -3.31604660e-01f, 4.18065757e-01f, 8.09501767e-01f,
  7.04112172e-01f, -1.50299013e-01f, 2.75316089e-01f, -5.88249266e-01f, -9.36166272e-02f, 2.45550275e-01f, -2.98573881e-01f, -4.55166101e-01f, 1.34226754e-01f, -2.83904135e-01f,
  -1.99949279e-01f, 1.08651757e-01f, 8.85588884e-01f, -1.23798370e-01f, -3.45474601e-01f, 5.51586688e-01f, 7.38354325e-02f, -2.01765716e-01f, 4.20080096e-01f, 1.40933409e-01f,
  7.46417716e-02f, 1.12398967e-01f, -4.39822040e-02f, 2.72107292e-02f, 3.36221000e-03f, -1.35424197e-01f, 7.35030472e-02f, 1.41297236e-01f, 2.90059090e-01f, -1.85468018e-01f,
  -1.04363389e-01f, -7.97799323e-03f, -6.26042187e-02f, -2.22875729e-01f, -3.29375774e-01f, -2.21598923e-01f, 2.17280358e-01f, 3.55299830e-01f, -1.34020209e-01f, -3.79175007e-01f,
  -3.50980371e-01f, 6.11182377e-02f, 3.21935982e-01f, -6.24675870e-01f, 1.80090889e-01f, 3.36379826e-01f, -3.70336115e-01f, 4.29969668e-01f, 7.09905624e-01f, 7.32796073e-01f,
  8.80690441e-02f, -2.10429356e-01f, -4.65431154e-01f, -1.08008337e+00f, -9.87374842e-01f, -2.27950215e-01f, -4.32400465e-01f, 3.53755206e-01f, 5.71422637e-01f, 4.80744362e-01f,
  3.67337883e-01f, -2.84661084e-01f, -2.66704410e-01f, -5.39802313e-01f, -1.05812037e+00f, -6.55593574e-02f, -7.62854517e-01f, 5.51268049e-02f, -3.94141853e-01f, -5.22358119e-01f,
  -1.14086914e+00f, -4.93445367e-01f, 3.18219036e-01f, 6.33338332e-01f, -9.28515121e-02f, 1.15268506e-01f, -5.66933811e-01f, -2.31392190e-01f, -6.21135712e-01f, -4.45656836e-01f,
  7.56321400e-02f, -9.73205715e-02f, 7.87369013e-02f, 9.52538252e-02f, 1.90884143e-01f, -2.27678552e-01f, 2.60012865e-01f, 3.43661308e-02f, 7.45027512e-02f, 2.63624161e-01f,
  -3.21099013e-02f, 1.01962902e-01f, 3.21817994e-01f, 3.26863557e-01f, 4.84383672e-01f, -1.63136080e-01f, 2.18151644e-01f, 3.36259991e-01f, 1.35200799e-01f, -1.06403425e-01f,
  3.34468901e-01f, -2.11665761e-02f, -2.90754825e-01f, -2.83504218e-01f, -5.45367599e-01f, -2.81854123e-01f, -8.09701860e-01f, -6.79401278e-01f, 3.06748301e-02f, -4.68837649e-01f,
  -4.14021194e-01f, -2.33810544e-01f, -5.08180737e-01f, -1.71057805e-01f, -3.60680521e-01f, -1.89177424e-01f, -8.44987705e-02f, 5.46770930e-01f, 7.22040087e-02f, -9.26321685e-01f,
  -3.21855098e-01f, -6.21343732e-01f, -1.18304908e-01f, 1.74218148e-01f, 7.47464657e-01f, -3.23411852e-01f, 5.45153916e-01f, 2.04480022e-01f, -6.05203092e-01f, -2.90134370e-01f,
  5.72687864e-01f, -5.40087521e-01f, -2.67166942e-01f, 2.60095239e-01f, 5.02784908e-01f, -3.91825587e-01f, -2.05047503e-01f, -1.83661208e-01f, 1.33067504e-01f, -5.78750610e-01f,
  2.98011035e-01f, -2.96824217e-01f, -8.63266110e-01f, -2.73212969e-01f, -1.11828268e-01f, 7.60688707e-02f, 1.07437156e-01f, -2.01247394e-01f, -1.16692677e-01f, 2.12207839e-01f,
  -2.80032214e-02f, 2.71733999e-01f, 1.45991385e-01f, -2.55399913e-01f, -2.00864002e-01f, -1.33459017e-01f, -6.42814159e-01f, 2.77548581e-01f, -6.32298067e-02f, -2.04713330e-01f,
  -2.72212982e-01f, -1.32077247e-01f, -1.62082717e-01f, 9.20585021e-02f, 1.59567848e-01f, -3.77566308e-01f, 1.06677495e-01f, 3.53141129e-01f, -4.98081267e-01f, -3.21192741e-01f,
  3.55510533e-01f, -2.45548278e-01f, -1.00555158e+00f, 8.64792347e-01f, -3.31794232e-01f, 9.09312516e-02f, 3.53926837e-01f, -6.82866693e-01f, -3.64860058e-01f, -1.30773991e-01f,
  2.98825026e-01f, -5.08040071e-01f, -3.62965852e-01f, -7.04594553e-01f, -1.63250864e-01f, 1.62072599e-01f, -2.74311721e-01f, -4.85233814e-01f, -1.32155195e-01f, 4.14788485e-01f,
  -7.58672431e-02f, -2.36914530e-01f, 3.72188002e-01f, 1.30618839e-02f, -2.66017199e-01f, -4.57938164e-01f, 4.08920497e-01f, 7.43749663e-02f, 1.00968254e+00f, 9.41919722e-03f,
  3.89225334e-01f, -5.14878750e-01f, -1.87105253e-01f, 4.79023248e-01f, -3.73111039e-01f, -7.57979274e-01f, 6.86608493e-01f, -6.81054056e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.17025249e-01f, -4.96991724e-02f, 5.32550775e-02f, -1.09132662e-01f, 3.94876748e-02f, 1.25506282e-01f, -3.91380638e-02f, -2.26325262e-02f, -1.16258979e-01f, 2.64880732e-02f,
  -4.29451950e-02f, 3.96880554e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    