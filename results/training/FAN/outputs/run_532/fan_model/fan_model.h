/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.70471418e-01f, -5.03144741e-01f, 1.80918381e-01f, -1.60661742e-01f, 1.96154609e-01f, -2.48162020e-02f, -5.10301143e-02f, -2.13701352e-02f, -1.99178785e-01f, -3.33763897e-01f,
  -2.11468209e-02f, 1.26778726e-02f, -1.00256532e-01f, -2.78278917e-01f, 2.02262327e-02f, -2.68179595e-01f, -2.81147867e-01f, -8.76026601e-02f, -1.14812687e-01f, -2.77404487e-02f,
  3.42183374e-02f, -2.63707578e-01f, 3.18378918e-02f, -2.26896942e-01f, 6.82348087e-02f, 1.93331748e-01f, 1.09975114e-01f, 5.28487563e-02f, 4.50535119e-02f, -9.52894613e-03f,
  5.86808426e-03f, -5.48090003e-02f, 1.50780156e-01f, 6.98906556e-02f, 5.97974285e-02f, 1.30500957e-01f, 1.27676859e-01f, 4.08136956e-02f, 1.18289478e-01f, -4.68444545e-03f,
  3.89037132e-02f, 6.16853163e-02f, -3.62292752e-02f, -7.75304511e-02f, 1.49223134e-02f, 1.23853348e-02f, -5.15641533e-02f, 7.96920285e-02f, -1.84181444e-02f, 2.43930016e-02f,
  3.71689931e-03f, -8.08421988e-04f, 1.69010796e-02f, -6.41464591e-02f, 4.73847464e-02f, 4.76131514e-02f, 4.53707390e-03f, 1.27362728e-01f, -5.79752773e-02f, -1.83158517e-02f,
  2.76248669e-03f, 1.57869828e-03f, -2.57705264e-02f, -2.99123842e-02f, -7.32317045e-02f, -1.45422425e-02f, -9.28058028e-02f, 4.85031726e-03f, 1.09884823e-02f, -1.24586545e-01f,
  5.93207628e-02f, -1.04292892e-02f, -7.88693801e-02f, 3.08005605e-02f, 7.86459073e-03f, -2.29974911e-02f, 5.05291373e-02f, 7.35223442e-02f, 2.41620857e-02f, 3.57721373e-02f,
  -3.10638659e-02f, -4.62024566e-03f, 2.06631981e-03f, -8.77001788e-03f, -1.31311208e-01f, 4.88646775e-02f, 2.11808942e-02f, -6.04539961e-02f, 4.75657284e-02f, -2.42528431e-02f,
  -2.72077680e-01f, -2.52902448e-01f, -6.00690059e-02f, -2.99063493e-02f, -1.23809516e-01f, -6.96863160e-02f, -6.26485124e-02f, -1.98461302e-02f, -9.81635898e-02f, -1.55876251e-02f,
  1.27707705e-01f, 1.28117129e-02f, -5.39998785e-02f, 1.75021850e-02f, -2.38678101e-02f, 5.10088466e-02f, 5.63110113e-02f, -4.21437882e-02f, 8.00452381e-02f, 2.95294430e-02f,
  8.52125697e-03f, 4.20463718e-02f, -3.79504226e-02f, 2.85591464e-02f, 1.16709568e-01f, -1.80667546e-02f, 4.72908840e-02f, -2.99018119e-02f, -3.58971767e-02f, -6.30934313e-02f,
  -5.75832501e-02f, -1.86042830e-01f, -3.44320871e-02f, 2.16845125e-01f, 1.66879490e-01f, 5.17223962e-02f, -1.95837423e-01f, 1.55819714e-01f, -2.56977350e-01f, -3.06089967e-01f,
  2.19569039e-02f, -1.96496412e-01f, -2.30491444e-01f, 1.04066558e-01f, 1.38804823e-01f, -1.18195638e-01f, 2.42140904e-01f, 2.46718843e-02f, -4.95614596e-02f, 2.07768098e-01f,
  2.51532078e-01f, 2.29952067e-01f, 8.48266780e-02f, 2.28616551e-01f, 9.48291123e-02f, -3.43264528e-02f, 1.01920895e-01f, 1.74630620e-02f, 1.16143718e-01f, -7.18992427e-02f,
  7.69807473e-02f, 1.78440586e-02f, -1.82476500e-03f, -1.09119751e-01f, 6.81377277e-02f, -9.08823460e-02f, -2.43868344e-02f, -6.62711859e-02f, 4.65227291e-02f, -1.85384154e-02f,
  -1.05872281e-01f, 7.68734291e-02f, 1.06331564e-01f, -1.13511965e-01f, 9.43300314e-03f, 2.84071211e-02f, 4.19852473e-02f, -1.92820430e-02f, -3.51581238e-02f, -4.63556387e-02f,
  -3.93460467e-02f, 6.41016522e-03f, -3.91148031e-02f, -8.18711612e-03f, -7.66516477e-02f, -4.63305116e-02f, -1.04511399e-02f, -8.55668336e-02f, -3.62600461e-02f, 1.07911251e-01f,
  2.12572925e-02f, 6.43439591e-02f, -1.44678354e-03f, 5.47939613e-02f, -4.72590961e-02f, 2.59438939e-02f, 1.27214231e-02f, -1.50783071e-02f, 1.13040088e-02f, -1.00963125e-02f,
  7.23534776e-03f, -1.07491864e-02f, 8.63108039e-03f, 9.36097000e-03f, -6.07907176e-02f, -3.51391993e-02f, -3.71615440e-02f, 5.56890555e-02f, -3.77633683e-02f, 2.59508044e-02f,
  4.83743846e-02f, 3.99175100e-02f, -4.70660478e-02f, 1.72059257e-02f, -5.66413580e-03f, -7.32446611e-02f, -2.11020280e-02f, -8.75429586e-02f, 8.14071670e-02f, -1.62206367e-02f,
  1.08452529e-01f, 2.33641878e-01f, 5.98971024e-02f, 4.66539860e-02f, -6.32606773e-03f, 8.48030075e-02f, 7.89719075e-02f, -5.37815802e-02f, -5.01174014e-03f, 9.83193815e-02f,
  6.30622031e-03f, -8.76270160e-02f, 7.96229243e-02f, -5.32382131e-02f, 3.05633619e-02f, 2.90102456e-02f, 5.36748171e-02f, 4.68436442e-02f, 1.43814340e-01f, 1.04023106e-02f,
  1.20400593e-01f, 7.06725642e-02f, -6.16820194e-02f, 1.77596658e-02f, -3.29897292e-02f, -1.05743213e-02f, 3.75376828e-02f, -1.24123283e-01f, 7.03590214e-02f, 1.89659279e-02f,
  -1.29794642e-01f, -1.58266336e-01f, -1.64503083e-02f, 9.64934304e-02f, 2.36443475e-01f, 1.80532455e-01f, 1.33004814e-01f, 1.81070596e-01f, 1.65033489e-01f, -1.11296020e-01f,
  1.25757530e-01f, -1.42935261e-01f, -1.15678772e-01f, 2.66229838e-01f, -2.29663365e-02f, -8.70445818e-02f, 1.99407324e-01f, -8.23401287e-03f, 1.93707515e-02f, 5.07312082e-02f,
  9.76827219e-02f, 1.21496864e-01f, 6.55937567e-02f, -1.71636250e-02f, 1.37574956e-01f, -6.42784685e-02f, -7.61841238e-02f, -1.05899706e-01f, -3.59908119e-03f, 5.44882379e-02f,
  -2.62817331e-02f, -1.62560299e-01f, 1.93072692e-01f, -3.29869427e-02f, -2.54771747e-02f, -3.01914662e-02f, -9.38212276e-02f, -3.96666788e-02f, -1.27016287e-02f, -3.64528783e-02f,
  1.57114789e-02f, -2.22222097e-02f, 5.04409671e-02f, -1.17976293e-02f, -2.26024631e-02f, 4.00916897e-02f, -2.08852142e-02f, 1.77782238e-01f, 7.38849491e-02f, -6.56081317e-03f,
  3.06538101e-02f, 7.61022940e-02f, 1.20139629e-01f, 4.06712107e-02f, 4.31247428e-02f, 3.16004492e-02f, 3.10275443e-02f, -2.75964756e-02f, -4.76197675e-02f, 5.09531945e-02f,
  -1.95276048e-02f, -5.84013388e-02f, -1.31561477e-02f, -1.04516698e-02f, 7.16095278e-03f, 1.86202955e-02f, -6.36977106e-02f, -4.47624438e-02f, -3.87824476e-02f, -5.11911735e-02f,
  1.25362143e-01f, -1.58094149e-02f, 2.13676617e-02f, -8.90055113e-03f, -1.66548751e-02f, -2.94179358e-02f, -6.59270659e-02f, -4.98124920e-02f, 5.06432317e-02f, 1.97547674e-02f,
  2.03047059e-02f, -6.73221722e-02f, 5.35728177e-03f, -6.67996705e-02f, -4.60252017e-02f, 7.25937560e-02f, 2.25445665e-02f, 3.91123928e-02f, 3.38200592e-02f, -3.02841384e-02f,
  -1.46682501e-01f, -4.10778731e-01f, 6.33782744e-02f, -1.06938444e-01f, -8.22231919e-02f, 5.06808199e-02f, 3.23715899e-03f, 1.14777803e-01f, -8.70586634e-02f, -5.41307265e-03f,
  -3.11662443e-03f, 1.58935282e-02f, -1.73357092e-02f, -3.42407636e-02f, -7.41216168e-02f, 3.95728424e-02f, -6.82678074e-02f, -6.55909926e-02f, -4.88257036e-02f, 3.47981375e-04f,
  -6.95347488e-02f, -1.84791625e-01f, -2.42834706e-02f, 1.47758592e-02f, -2.98679322e-02f, -8.12612474e-02f, -8.13115239e-02f, 2.56750137e-02f, -1.12413734e-01f, -8.46879277e-03f,
  4.30685580e-01f, -7.84186423e-02f, 6.83035478e-02f, 2.52966464e-01f, 1.67097926e-01f, 2.70850271e-01f, 2.92617470e-01f, 4.40108106e-02f, -4.92203273e-02f, -1.69630244e-01f,
  -1.37655869e-01f, 2.45783657e-01f, -1.82597756e-01f, 1.55075818e-01f, 3.52409780e-01f, -1.65368617e-01f, 2.00939760e-01f, 1.47821486e-01f, -4.55870628e-02f, 1.14272900e-01f,
  1.03190117e-01f, 4.84624580e-02f, -6.68299049e-02f, -2.17543498e-01f, 2.24315882e-01f, -9.30183008e-02f, -1.45806506e-01f, -6.44190758e-02f, 6.29619211e-02f, 1.38747469e-01f,
  -2.88292132e-02f, -1.06315352e-01f, 6.26119077e-02f, -7.59019926e-02f, 2.77574193e-02f, 9.24550518e-02f, 9.85317454e-02f, 5.68167679e-02f, -1.82935246e-03f, 8.19099229e-03f,
  1.86420400e-02f, 2.42930949e-02f, 1.53735414e-01f, -2.06416026e-02f, 5.58008850e-02f, -4.58994210e-02f, -3.50158662e-02f, 3.25166248e-02f, 9.08871070e-02f, 3.96757796e-02f,
  4.08971235e-02f, 6.08062819e-02f, 5.35801984e-03f, -4.18285504e-02f, 1.04306247e-02f, -5.70624620e-02f, 3.13255675e-02f, 3.62482443e-02f, 7.28904456e-02f, 1.71020664e-02f,
  2.07279157e-02f, -2.89814789e-02f, 4.96213660e-02f, -4.52654846e-02f, 1.99152287e-02f, 9.69245955e-02f, 3.96345258e-02f, 4.96651866e-02f, -2.36981735e-02f, -3.21355499e-02f,
  5.31787425e-02f, 2.08506528e-02f, -4.89107706e-02f, -1.56970392e-03f, 3.09795141e-02f, 8.46413821e-02f, 1.60037782e-02f, -1.94067210e-02f, 1.52477577e-01f, 4.30833846e-02f,
  -1.17460035e-01f, 6.11722209e-02f, 1.38146549e-01f, -1.16425259e-02f, -3.97302397e-02f, -8.56203660e-02f, -4.95195910e-02f, -1.20755974e-02f, -8.43331218e-03f, 5.82175851e-02f,
  5.34919016e-02f, -2.21505947e-03f, -2.95253154e-02f, 3.28353159e-02f, 1.25889042e-02f, 1.25474378e-01f, 3.13419439e-02f, -2.45599486e-02f, -1.28324822e-01f, 2.74301018e-03f,
  4.02558558e-02f, 1.21173738e-02f, -3.85266878e-02f, -1.22258291e-02f, 4.01569791e-02f, -2.95808204e-02f, 2.03001108e-02f, -9.43785254e-03f, 6.01984896e-02f, 1.82882901e-02f,
  4.37033959e-02f, 7.16946945e-02f, 5.49553670e-02f, 7.87471831e-02f, 2.83842883e-03f, 5.84935546e-02f, 2.23737285e-02f, -3.76408063e-02f, -5.80734722e-02f, -1.81612407e-03f,
  5.36879189e-02f, 3.59314501e-01f, -2.39350230e-01f, -1.90680653e-01f, -1.54273719e-01f, 4.72142398e-02f, 8.97354409e-02f, 8.50772560e-02f, 8.43467116e-02f, 2.65204132e-01f,
  -1.76788066e-02f, 1.57558128e-01f, 1.34715945e-01f, 5.70270941e-02f, -2.47667342e-01f, 2.55940203e-02f, 1.88267902e-01f, 2.00525522e-01f, -1.81411639e-01f, -2.38736048e-02f,
  -1.81616113e-01f, 4.30586897e-02f, -2.60540187e-01f, -5.62634580e-02f, -6.63620457e-02f, -4.90993559e-02f, 4.17720377e-02f, -1.40987381e-01f, 5.11737987e-02f, -8.85707885e-03f,
  4.03058454e-02f, -8.19408447e-02f, -6.51532561e-02f, 2.47297920e-02f, 6.15467504e-02f, 5.64827137e-02f, 7.71604991e-03f, -1.05778910e-01f, -8.83073881e-02f, 4.83050644e-02f,
  3.97525989e-02f, 2.68197595e-03f, -2.63150390e-02f, -2.43113749e-02f, -4.20712419e-02f, -4.68528643e-02f, 8.06731582e-02f, 2.81167272e-02f, 9.31343436e-03f, -4.93264422e-02f,
  -6.83573931e-02f, 5.60600944e-02f, -4.19700071e-02f, 7.91545212e-02f, -1.01703569e-01f, -5.93931377e-02f, -4.16426063e-02f, -1.38896536e-02f, 1.14053115e-01f, -3.78244221e-02f,
  -1.48183674e-01f, -3.28354351e-02f, 2.53299139e-02f, 2.69140601e-02f, -1.40789070e-03f, -6.86424412e-03f, -9.40044876e-03f, 3.76490057e-02f, -6.33371295e-03f, 5.91575019e-02f,
  -4.38535176e-02f, 4.34205085e-02f, -2.07241606e-02f, 1.20518832e-02f, 6.82341531e-02f, 5.11091959e-04f, -3.88596617e-02f, 1.31298274e-01f, -5.09359054e-02f, -6.26198500e-02f,
  9.53937694e-03f, 2.52458290e-03f, 7.70554245e-02f, -1.40749663e-02f, 9.15329438e-03f, 6.58538146e-03f, 8.29951391e-02f, 7.96813518e-02f, 1.08184433e-03f, -1.12277560e-01f,
  3.16722393e-01f, 3.04093838e-01f, 1.61618032e-02f, 1.16395138e-01f, 3.72065268e-02f, 1.19538624e-02f, -8.17270726e-02f, 9.95549932e-02f, 1.01035461e-01f, -6.77186325e-02f,
  8.39636773e-02f, 3.09177097e-02f, -2.27392418e-03f, 2.93275993e-02f, 3.74896191e-02f, 3.20423245e-02f, 7.79424757e-02f, 1.36515975e-01f, 4.20669913e-02f, 5.10437004e-02f,
  8.93888921e-02f, -5.67500107e-02f, -2.60243174e-02f, -4.31837775e-02f, -2.30126139e-02f, -2.27515418e-02f, 5.36256395e-02f, -2.29430441e-02f, 8.87362752e-03f, 2.59438064e-02f,
  3.07006776e-01f, 2.34551117e-01f, 1.32639781e-01f, 4.79145408e-01f, -2.00975969e-01f, -1.10045493e-01f, 2.81147106e-04f, 1.47784010e-01f, 2.79788971e-01f, 2.72532608e-02f,
  -1.86383016e-02f, 2.12879740e-02f, -3.55366826e-01f, 2.68832773e-01f, 3.32038328e-02f, -1.61599983e-02f, 2.57069141e-01f, 1.46856412e-01f, -8.66321661e-03f, 1.62790313e-01f,
  1.95982382e-01f, 1.48035765e-01f, 1.45416945e-01f, -6.04086407e-02f, 2.16742411e-01f, 1.14810728e-01f, 1.80289820e-02f, -1.70933291e-01f, 1.55037120e-01f, -6.98411018e-02f,
  9.03173611e-02f, 2.09721103e-01f, -2.77468041e-02f, -6.53157150e-03f, 1.75419495e-01f, -3.25592570e-02f, -5.83753027e-02f, -1.21360220e-01f, -8.23543295e-02f, 1.23491153e-01f,
  -2.57915892e-02f, -8.53939727e-03f, 9.55814421e-02f, -3.09131090e-02f, 6.53061569e-02f, 1.12320989e-01f, -1.76389553e-02f, 6.85115606e-02f, 6.23574816e-02f, -2.11324189e-02f,
  1.25377879e-01f, 4.32821512e-02f, 9.03765112e-02f, 8.87032598e-02f, 5.09036779e-02f, -4.65140454e-02f, -3.70575413e-02f, 7.85760488e-03f, 8.06851834e-02f, 9.19108838e-02f,
  4.38415818e-02f, -4.56170067e-02f, 9.41142887e-02f, 2.77214008e-03f, 3.40916365e-02f, 4.59146313e-02f, -4.77079675e-02f, -1.02425283e-02f, 2.62214355e-02f, 9.36376378e-02f,
  3.52087505e-02f, 2.99031045e-02f, 6.32861704e-02f, 1.99519731e-02f, 1.08404376e-01f, 6.44131526e-02f, -8.22463930e-02f, -1.59705430e-02f, 1.62505820e-01f, 1.01790242e-02f,
  2.89644208e-03f, -5.38143627e-02f, 1.04830908e-02f, 2.03059297e-02f, 3.15107517e-02f, 2.42204834e-02f, 9.95117873e-02f, 4.70317975e-02f, -3.33747603e-02f, -8.21009353e-02f,
  1.76591352e-02f, 7.98606724e-02f, 2.07184888e-02f, -7.34967962e-02f, -1.10719360e-01f, -4.81664203e-02f, 4.51870449e-02f, 5.44290133e-02f, -2.53513549e-03f, -3.38474698e-02f,
  -2.16929689e-02f, 3.64797153e-02f, 4.43229489e-02f, -8.37475527e-03f, -1.18980799e-02f, -2.38240659e-02f, 4.73278947e-02f, -8.29553814e-04f, 3.34169939e-02f, 1.11789228e-02f,
  -9.95232388e-02f, -2.09304094e-02f, -5.83227389e-02f, 1.61975641e-02f, -4.14954275e-02f, 6.46334589e-02f, 7.11863814e-03f, 1.74433663e-02f, 4.04621754e-03f, 7.54260123e-02f,
  2.88071573e-01f, -1.89418659e-01f, -2.11400554e-01f, 1.39203161e-01f, 2.10692063e-01f, -3.41000497e-01f, -2.75200009e-01f, 1.34407267e-01f, 3.66134256e-01f, -2.23575294e-01f,
  4.66069542e-02f, -1.89607933e-01f, -7.53737688e-02f, -2.10644782e-01f, -2.67691612e-01f, -2.67190665e-01f, -1.25230759e-01f, -1.11615881e-01f, 1.70918956e-01f, 9.52567458e-02f,
  5.98395430e-02f, -1.23472633e-02f, -2.05668002e-01f, 1.33577690e-01f, -1.14203328e-02f, 1.67318165e-01f, 3.23731303e-02f, 3.01408283e-02f, -1.87525898e-01f, -1.05003566e-01f,
  -1.09586589e-01f, 1.22818574e-01f, -8.03773180e-02f, -7.38042295e-02f, 4.39644493e-02f, -4.73885052e-02f, -1.22204870e-01f, -5.39260134e-02f, 4.50387597e-02f, 1.22796018e-02f,
  -9.02845636e-02f, 2.35563684e-02f, 3.18796933e-02f, -6.36999831e-02f, 6.19960539e-02f, 4.19702865e-02f, -1.81314107e-02f, -5.79069331e-02f, -1.03607606e-02f, -7.61915073e-02f,
  4.24733898e-03f, -4.11926396e-02f, 1.01629443e-01f, -8.87361243e-02f, 4.88516726e-02f, 3.65927294e-02f, -1.31611735e-01f, -3.01609281e-02f, -9.46720243e-02f, 1.33627981e-01f,
  1.01745948e-01f, 7.09780306e-02f, -5.06724194e-02f, 3.24778096e-03f, 3.80475633e-02f, 5.54893538e-02f, -8.89598764e-03f, -2.04934310e-02f, 7.90042058e-03f, -2.58311499e-02f,
  7.48192295e-02f, 2.27411930e-03f, 2.98719518e-02f, -5.21154739e-02f, 6.74729645e-02f, 2.80296952e-02f, -1.26435133e-02f, 2.03072969e-02f, 8.99897367e-02f, 3.85145284e-02f,
  5.87189309e-02f, -2.13741437e-02f, -6.63802996e-02f, 4.58863657e-03f, -5.68605177e-02f, -3.56831402e-02f, 9.92565528e-02f, 3.39036211e-02f, -4.77693900e-02f, 1.34560373e-02f,
  -1.47543401e-01f, 9.83628109e-02f, 4.08700109e-02f, -6.95514455e-02f, -1.72425508e-02f, 6.55188039e-02f, 5.52840717e-03f, -7.66004343e-03f, 2.89355572e-02f, 8.21323469e-02f,
  5.69536760e-02f, -1.36488052e-02f, -2.35622469e-02f, 2.66338345e-02f, -8.00860524e-02f, -8.85978490e-02f, -4.85856980e-02f, 5.66465929e-02f, 1.87279675e-02f, 5.42337215e-03f,
  1.01526000e-03f, 1.97766200e-02f, -2.92499810e-02f, 1.04754657e-01f, -7.08249509e-02f, 2.71227304e-03f, 8.85326043e-02f, -3.56363356e-02f, -8.03975984e-02f, -7.32703730e-02f,
  3.22605848e-01f, -3.16296071e-02f, 3.17123234e-01f, 4.87706155e-01f, -1.11160830e-01f, -2.53119230e-01f, 8.68071839e-02f, -1.39619678e-01f, 2.22726241e-01f, -2.03353435e-01f,
  -1.00328334e-01f, 1.90026090e-01f, -2.65829176e-01f, 2.41862997e-01f, 1.34535700e-01f, -8.91087204e-02f, 1.72922134e-01f, 2.05432385e-01f, -5.92227690e-02f, 8.16247314e-02f,
  1.44990578e-01f, -1.55356824e-02f, 9.03131887e-02f, -2.00120881e-01f, 9.62482095e-02f, 1.75356671e-01f, -8.26863125e-02f, -5.36759160e-02f, 3.59124355e-02f, 1.50754917e-02f,
  1.03620328e-02f, 1.39276549e-01f, 1.16967745e-01f, 9.70262941e-03f, 8.99644569e-02f, -9.81817394e-02f, 2.68840175e-02f, -2.06206553e-02f, 1.02020152e-01f, 6.08281568e-02f,
  2.25453675e-02f, 1.41728548e-02f, 2.20779441e-02f, 4.07313071e-02f, -3.55072804e-02f, -1.71956476e-02f, 6.50020242e-02f, 1.45808561e-03f, 7.79899955e-03f, 1.45880692e-02f,
  2.15538014e-02f, 7.33699426e-02f, 1.95947662e-02f, 3.21407244e-02f, 3.37160341e-02f, 1.17787845e-01f, 2.86656730e-02f, 5.98645732e-02f, -1.14240581e-02f, 4.56155092e-02f,
  -1.23468051e-02f, -7.90182725e-02f, 1.11206835e-02f, 2.05266215e-02f, -2.35630590e-02f, -6.74771219e-02f, 2.14093067e-02f, -9.68980938e-02f, 4.27743383e-02f, -8.04672949e-03f,
  -1.30389389e-02f, 2.18691509e-02f, 6.76850788e-03f, 2.81824358e-02f, 7.44887888e-02f, 4.17942069e-02f, 3.00718136e-02f, -6.05118349e-02f, 4.67916951e-02f, -5.60969897e-02f,
  -3.06168199e-03f, 3.08373477e-02f, -2.83181784e-03f, -1.05465293e-01f, -1.15983181e-01f, 9.23338830e-02f, 1.99130792e-02f, 6.85489029e-02f, -2.00883299e-02f, -5.47715537e-02f,
  -3.54821049e-02f, 6.88246563e-02f, -7.68102184e-02f, -3.72375101e-02f, -4.22523282e-02f, -7.60454834e-02f, -4.48357612e-02f, 7.53949359e-02f, -4.37619798e-02f, -4.94508967e-02f,
  -6.37707347e-03f, -4.11503538e-02f, -2.09629964e-02f, -2.00832132e-02f, 4.73090298e-02f, -6.67354092e-02f, 3.77312303e-03f, -1.29241683e-02f, 8.83791149e-02f, -7.80386664e-03f,
  -1.16012348e-02f, -1.04999659e-03f, 7.64091089e-02f, -1.13138966e-01f, -1.76266767e-02f, -2.43164208e-02f, 4.48753573e-02f, -3.35532725e-02f, 1.63185019e-02f, -2.34286822e-02f,
  -4.56298321e-01f, 3.26485038e-01f, -1.07599422e-01f, -4.53980872e-03f, -1.54830918e-01f, 4.08396244e-01f, 2.27015361e-01f, 6.17766678e-02f, -2.35970765e-01f, 3.37871909e-01f,
  9.46587995e-02f, -1.42056033e-01f, 1.01330236e-01f, 2.75357276e-01f, 1.09287417e-02f, 1.34075522e-01f, 2.57040918e-01f, 1.61151946e-01f, -1.63983271e-01f, 5.91689087e-02f,
  -5.50699718e-02f, 2.52730578e-01f, 1.21092200e-01f, 9.90359932e-02f, 8.34274068e-02f, -9.32647139e-02f, 1.73839048e-01f, -8.38831812e-02f, 2.89358586e-01f, 2.67885737e-02f,
  5.47777489e-02f, -1.30015999e-01f, -5.86273819e-02f, -1.01381771e-01f, 9.25336629e-02f, -1.32205756e-02f, 6.89961687e-02f, -4.57527079e-02f, -7.19717070e-02f, -3.08011640e-02f,
  -3.49735878e-02f, -5.32483049e-02f, 3.29875723e-02f, -5.18673994e-02f, -3.66017111e-02f, -5.56968786e-02f, -1.28923869e-02f, 1.86241306e-02f, -5.38227260e-02f, 3.29311490e-02f,
  -1.79899372e-02f, 2.83450689e-02f, -3.97741348e-02f, 6.87765107e-02f, -2.02961545e-02f, -5.60741127e-02f, 1.64616369e-02f, 3.67146870e-03f, 6.83696568e-02f, 1.12544158e-02f,
  3.26641486e-03f, 8.76367837e-03f, -2.77564265e-02f, -6.69414503e-03f, -1.68928839e-02f, -1.35252178e-02f, 4.13050093e-02f, 4.15161662e-02f, -4.60913032e-02f, 6.55469149e-02f,
  -3.13626565e-02f, -7.04509467e-02f, -5.95682897e-02f, 5.17529994e-02f, 3.40424366e-02f, -4.31082211e-02f, 6.02910900e-03f, 4.18127850e-02f, -1.98302456e-04f, -1.11320307e-02f,
  -1.87342688e-02f, 2.44765950e-04f, 5.23273908e-02f, -6.35112217e-03f, 4.36647832e-02f, 2.62355972e-02f, 3.37729193e-02f, -1.13042509e-02f, -2.91763688e-03f, 2.90733818e-02f,
  2.35919967e-01f, 1.98135570e-01f, 1.40951937e-02f, 2.86099613e-02f, 2.68699359e-02f, -1.85275897e-02f, -2.75985580e-02f, -2.51678401e-03f, 8.26453045e-02f, -9.51025821e-03f,
  2.82147042e-02f, 2.30154097e-02f, 6.04286371e-03f, -1.94336586e-02f, -2.04166328e-03f, 5.23553714e-02f, 2.12598667e-02f, -9.09712445e-03f, 1.05296917e-01f, 1.28047364e-02f,
  3.31250057e-02f, -2.17095539e-02f, -9.69165470e-03f, -2.51277275e-02f, 4.02724482e-02f, 5.21899126e-02f, 5.13651036e-02f, -8.96620527e-02f, 2.83632241e-02f, 4.21503969e-02f,
  4.55803216e-01f, -1.68584943e-01f, -4.63376455e-02f, 1.47460282e-01f, -6.55348822e-02f, -4.03881460e-01f, -1.38742447e-01f, -5.50356843e-02f, 2.12866500e-01f, -1.33226782e-01f,
  -1.15631312e-01f, 2.93418467e-01f, 1.33586735e-01f, -2.78173327e-01f, -1.29767790e-01f, -1.79924846e-01f, -2.91739553e-01f, -4.45046611e-02f, 1.76407620e-01f, 1.30241647e-01f,
  6.16857857e-02f, -2.31627733e-01f, -9.52545255e-02f, -1.33135304e-01f, 2.49001440e-02f, 8.95516202e-02f, 8.14472511e-02f, 4.31645513e-02f, -1.24422133e-01f, -1.79210991e-01f,
  -4.62958366e-02f, 1.18548959e-01f, 1.85975637e-02f, -9.89576951e-02f, -1.07224405e-01f, 1.07383788e-01f, -8.28870386e-02f, -3.63838784e-02f, 4.05850336e-02f, -3.92237119e-02f,
  6.89775273e-02f, -2.89164521e-02f, -3.19693424e-02f, 1.07079156e-01f, -1.27740856e-02f, 1.94809809e-02f, -5.15549071e-02f, -7.83155337e-02f, 5.99318705e-02f, 7.32843131e-02f,
  7.47572482e-02f, -3.25103179e-02f, -6.92548379e-02f, -4.21986468e-02f, -5.84244132e-02f, -1.25895366e-01f, -1.42174482e-01f, -4.55517434e-02f, -8.90591592e-02f, 5.24416268e-02f,
  5.14392890e-02f, -8.52523372e-03f, 3.48908897e-03f, 3.01222932e-02f, -7.63380853e-03f, -4.62744236e-02f, -1.00009134e-02f, -5.62057495e-02f, 3.74088832e-03f, -2.61648502e-02f,
  -8.40672757e-03f, 6.15918003e-02f, -1.33282524e-02f, 1.06312139e-02f, 6.08551390e-02f, -1.49385752e-02f, -9.64793842e-03f, 9.77544934e-02f, 1.79535374e-02f, -1.69955213e-02f,
  6.83935285e-02f, -4.90027368e-02f, 6.88075200e-02f, -1.44506935e-02f, -8.88578966e-02f, -3.96956429e-02f, -2.58718729e-02f, -1.33122811e-02f, -4.39091295e-04f, -2.83076707e-03f,
  -1.58170745e-01f, 2.66635092e-03f, 2.07965486e-02f, -5.91901317e-02f, 2.12654304e-02f, 6.42888248e-02f, -7.02340454e-02f, 2.12065764e-02f, -5.17859161e-02f, 6.40129521e-02f,
  -3.97104993e-02f, 3.47961187e-02f, 9.81507171e-03f, 2.17893235e-02f, -3.76354083e-02f, -8.37919191e-02f, -2.03349888e-02f, 5.85541874e-02f, -2.52139363e-02f, -4.68662158e-02f,
  3.32687199e-02f, -1.00502849e-01f, 8.02596007e-03f, -1.21863514e-01f, -4.03292887e-02f, 5.98070063e-02f, 6.92446306e-02f, 6.93231225e-02f, -2.46198047e-02f, -5.54884747e-02f,
  2.74311036e-01f, -3.72697204e-01f, -1.35311130e-02f, -7.01469481e-02f, 3.08077097e-01f, -4.43567038e-02f, -2.23583847e-01f, -6.01075627e-02f, -1.98405951e-01f, -2.12769628e-01f,
  2.39862591e-01f, -2.77002543e-01f, -1.17184840e-01f, -1.55650198e-01f, 3.65570694e-01f, 1.08740456e-01f, -7.83626437e-02f, -1.62154123e-01f, -1.12444282e-01f, -4.29571569e-02f,
  1.33490473e-01f, 1.31791994e-01f, 6.23790771e-02f, 7.25943223e-02f, 1.71292618e-01f, -1.36779428e-01f, 4.89010960e-02f, -9.57805756e-03f, -1.42274812e-01f, 4.96465825e-02f,
  -5.34871370e-02f, 9.53890209e-04f, 1.52243450e-02f, -5.20081744e-02f, 1.06086865e-01f, 8.94365460e-02f, -1.10867016e-01f, 8.93596373e-03f, 3.64846503e-03f, -7.82301128e-02f,
  -3.04072089e-02f, -2.34195385e-02f, -5.78090772e-02f, -7.54026510e-03f, 1.68349873e-02f, -2.99913380e-02f, -7.16539249e-02f, -1.64920110e-02f, -1.70091867e-01f, 9.01870802e-02f,
  -1.35738123e-02f, 9.96839907e-03f, 1.35307610e-01f, -5.23519050e-03f, 1.05174035e-01f, 3.92045081e-02f, -4.06335369e-02f, -1.64190903e-02f, -4.80086952e-02f, 4.43111174e-02f,
  3.29757072e-02f, -2.65216008e-02f, -1.67886317e-02f, 5.13681443e-03f, -1.12311626e-02f, 2.45782286e-02f, -5.89963561e-03f, -2.34857332e-02f, -5.51587045e-02f, 3.50205600e-02f,
  2.57425644e-02f, -3.29566114e-02f, 2.22460623e-03f, -6.81724995e-02f, -1.60411675e-03f, -5.65238781e-02f, 7.31788129e-02f, -7.94245601e-02f, -5.60512543e-02f, -3.59372143e-03f,
  -8.67591947e-02f, -8.69051646e-03f, -1.40353352e-01f, -1.26783419e-02f, -5.82194291e-02f, 5.50589450e-02f, 1.98736321e-02f, -3.72919664e-02f, 1.20328385e-02f, -2.15987535e-03f,
  5.47908209e-02f, -1.88746601e-01f, -8.76770318e-02f, -5.70082366e-02f, -1.09476134e-01f, 3.46553996e-02f, 2.71933954e-02f, 3.68376151e-02f, -2.50792056e-02f, 2.30917335e-02f,
  6.06955625e-02f, -3.06956889e-03f, -2.33847424e-02f, 4.26779836e-02f, -3.83343659e-02f, 5.98032624e-02f, -9.16610286e-02f, -6.58257082e-02f, 6.14223965e-02f, -1.10758662e-01f,
  2.71825083e-02f, 2.05878858e-02f, -3.57235447e-02f, -1.63824558e-02f, -1.85760632e-02f, 7.16266707e-02f, -4.71382141e-02f, -5.86726107e-02f, 7.30231479e-02f, -9.41154212e-02f,
  -3.72028738e-01f, -9.64602008e-02f, -3.14329147e-01f, -1.64598227e-01f, 1.22291921e-02f, 1.41065776e-01f, 1.52391896e-01f, -1.34643530e-02f, -3.62588376e-01f, 1.80820689e-01f,
  1.87242523e-01f, -3.58026177e-01f, 1.95033535e-01f, 1.74956903e-01f, -2.35752046e-01f, 4.17805202e-02f, 1.36982262e-01f, 1.10105105e-01f, -1.54475838e-01f, -1.16386273e-05f,
  -1.14909060e-01f, 3.06528240e-01f, 8.85217488e-02f, 2.61901915e-01f, 7.61681572e-02f, -1.03224866e-01f, 2.30758101e-01f, 1.13258295e-01f, 2.50700593e-01f, -3.26704979e-02f,
  -3.02325771e-03f, -4.40808237e-02f, -4.75390293e-02f, -4.87509333e-02f, 5.95963597e-02f, 1.07327655e-01f, 5.42277023e-02f, 1.77792683e-02f, -3.10446154e-02f, 2.15042047e-02f,
  -5.94465844e-02f, -8.88765752e-02f, -3.65172625e-02f, -1.86946131e-02f, -4.46131043e-02f, -6.32617623e-02f, -4.43582498e-02f, 6.18901066e-02f, -5.61064146e-02f, -5.09072058e-02f,
  -6.10739216e-02f, -2.97205318e-02f, 9.05560236e-03f, 5.69821410e-02f, -1.03806354e-01f, -5.26025854e-02f, -2.85033695e-02f, 5.55137768e-02f, -6.18175454e-02f, -2.09456086e-02f,
  3.52882706e-02f, 3.23045929e-03f, 3.27522941e-02f, 5.61765619e-02f, -2.43927129e-02f, 5.35543635e-02f, 3.47314111e-04f, 4.63615507e-02f, -3.56635042e-02f, 2.72898283e-02f,
  -4.03460767e-03f, -5.30263223e-02f, 2.38046376e-03f, -1.94233134e-02f, 2.64506284e-02f, -1.99316535e-02f, -5.06031699e-02f, 3.30057181e-02f, -3.25462073e-02f, 4.73834276e-02f,
  1.09026255e-02f, 3.33500803e-02f, -3.55560966e-02f, 7.12082684e-02f, 5.96099049e-02f, -3.50615866e-02f, 3.81134194e-03f, -3.89958322e-02f, 4.53234799e-02f, 2.06136089e-02f,
  1.31270349e-01f, 1.49715506e-02f, -8.23352579e-03f, -1.69485603e-02f, 2.59661395e-02f, 3.79672553e-03f, -4.77562025e-02f, -5.31326234e-02f, -4.06846330e-02f, 7.69100990e-03f,
  5.35477661e-02f, 7.33835176e-02f, 5.54525889e-02f, -9.15492186e-04f, 7.10277706e-02f, 9.89356078e-03f, 4.40131277e-02f, -1.20988796e-02f, 8.69578198e-02f, 1.76020060e-02f,
  8.77635852e-02f, 2.03335471e-02f, -7.13045988e-03f, -2.57842075e-02f, 7.59916678e-02f, 2.53248010e-02f, -3.15400213e-02f, -8.93385783e-02f, 9.50271264e-02f, -3.62962820e-02f,
  2.90213197e-01f, -2.21719041e-01f, 3.26365381e-01f, 4.85324740e-01f, -1.91281900e-01f, -2.54496813e-01f, 2.22216263e-01f, -5.00038899e-02f, 2.50822395e-01f, -3.58131289e-01f,
  -1.22055516e-01f, 2.93526471e-01f, -5.37499972e-03f, -1.37435287e-01f, 2.32699454e-01f, 1.28487214e-01f, 4.53963969e-03f, 2.29596198e-02f, 1.23953767e-01f, 5.85909048e-03f,
  1.40643701e-01f, -2.47544363e-01f, 1.11960918e-01f, -3.30218017e-01f, -6.61084354e-02f, 1.54940739e-01f, -2.27753893e-01f, -9.27820578e-02f, -1.03241429e-01f, -1.25289798e-01f,
  8.41281042e-02f, 1.35112897e-01f, -2.93318927e-02f, 2.66911257e-02f, -4.27112915e-02f, -1.08997598e-01f, 2.05097049e-02f, 2.76345015e-02f, 4.35055979e-02f, 1.08313262e-02f,
  4.45572361e-02f, -4.33071703e-02f, 1.80268604e-02f, -7.83965290e-02f, 5.46363182e-03f, 7.34615400e-02f, -1.92455463e-02f, -9.20823310e-03f, 2.05536950e-02f, 5.08086197e-02f,
  8.02965686e-02f, 2.36634780e-02f, -1.86233837e-02f, -2.93552484e-02f, 1.17304221e-01f, 5.09030335e-02f, -3.89951915e-02f, 6.34754002e-02f, 1.44174304e-02f, -3.90382409e-02f,
  -1.75216720e-02f, 1.42562995e-02f, -1.90348420e-02f, -3.69888097e-02f, -2.22203676e-02f, 3.17114927e-02f, -6.20167367e-02f, -9.65952650e-02f, 1.52947083e-02f, -4.03301567e-02f,
  -4.97640073e-02f, 7.11988583e-02f, -7.92693570e-02f, -2.98648365e-02f, -1.23877990e-05f, -3.92499492e-02f, 5.49529009e-02f, -1.80625636e-02f, 7.06759766e-02f, -1.41382525e-02f,
  1.38660362e-02f, -5.63943051e-02f, 2.24489123e-02f, -4.46895324e-02f, 7.68727856e-04f, -1.98511500e-02f, -4.13555689e-02f, -3.22918943e-03f, 6.07424267e-02f, -1.55310491e-02f,
  1.74175501e-02f, -2.79379606e-01f, 9.14117694e-02f, -2.98331841e-03f, 7.99928233e-02f, -1.12062655e-01f, -5.28089367e-02f, -9.90298986e-02f, 3.92962359e-02f, -5.84025867e-02f,
  -4.27448042e-02f, 4.79534036e-03f, -1.74730755e-02f, 3.31340693e-02f, 2.62098443e-02f, -1.34478211e-01f, 3.87026705e-02f, -6.54856786e-02f, -2.41563711e-02f, -6.21622726e-02f,
  -5.83202243e-02f, -2.17646640e-02f, 1.34238536e-02f, 7.82377552e-03f, -3.62126566e-02f, -6.30467087e-02f, -3.45484726e-02f, -5.78159131e-02f, -4.32131849e-02f, 1.62857752e-02f,
  3.59920561e-02f, 2.97828853e-01f, 1.88096449e-01f, 1.13843661e-02f, -2.24953704e-02f, 1.03952363e-01f, 2.72101853e-02f, 1.05274394e-01f, 7.96233863e-02f, 8.46878663e-02f,
  -1.97544366e-01f, 2.87303746e-01f, -9.18813944e-02f, -1.30290642e-01f, -3.59834403e-01f, -1.66889861e-01f, -7.88298398e-02f, 8.58704299e-02f, 4.33074310e-02f, 7.90327564e-02f,
  3.05327456e-02f, -3.22297186e-01f, -5.85316904e-02f, 2.62027942e-02f, 7.55230263e-02f, 3.08512241e-01f, -2.90214360e-01f, 2.00798064e-01f, 2.95953602e-02f, -3.51428762e-02f,
  -3.73556465e-02f, 1.10949345e-01f, 9.32946801e-02f, 8.94328579e-02f, -3.86791416e-02f, 5.22340462e-02f, 3.45705412e-02f, 3.21250781e-02f, -2.52631959e-02f, 9.43219140e-02f,
  8.58706683e-02f, -3.42079327e-02f, 3.41377500e-03f, -7.10421279e-02f, 1.35071039e-01f, 8.46053064e-02f, 6.94521219e-02f, 7.27635715e-03f, 9.08168256e-02f, 1.01664867e-02f,
  2.02436112e-02f, 6.29016310e-02f, 4.08894569e-02f, -2.73566376e-02f, -1.74681768e-02f, 4.08528484e-02f, -3.02674733e-02f, -2.91628931e-02f, 9.85922515e-02f, -2.67856065e-02f,
  -3.83307375e-02f, -1.02217607e-01f, 3.07614245e-02f, 4.03308962e-03f, 6.02982864e-02f, -2.46701613e-02f, -5.85621931e-02f, 2.46250033e-02f, 6.00372888e-02f, -1.12563733e-03f,
  -2.92346254e-02f, 7.49769360e-02f, -2.19118148e-02f, -4.51047495e-02f, 1.99773349e-02f, 6.51239231e-02f, -7.27204699e-03f, -1.14273895e-02f, 6.41982183e-02f, 7.08698854e-03f,
  2.54806690e-02f, 4.50040884e-02f, 5.60272858e-02f, 5.71079273e-03f, -4.97121513e-02f, -3.49592008e-02f, 3.26700765e-03f, 2.69526131e-02f, 4.68834676e-02f, -4.89598587e-02f,
  4.48213750e-03f, 4.83132638e-02f, 2.79194023e-02f, 1.02325067e-01f, 3.86783667e-02f, -3.89480926e-02f, -2.65101679e-02f, 4.45764028e-02f, 2.74601970e-02f, -8.43551382e-02f,
  -5.11877313e-02f, -4.71797213e-02f, -1.47241689e-02f, 3.05020227e-03f, -4.36031520e-02f, -1.33020028e-01f, -3.26357856e-02f, 3.77255492e-03f, -5.59769720e-02f, 5.14382459e-02f,
  -4.15857323e-02f, -3.08220405e-02f, -1.93692278e-02f, -6.42939582e-02f, -3.79619002e-02f, 4.48098779e-02f, 3.89598720e-02f, 5.89408241e-02f, -5.61826713e-02f, -3.17291915e-02f,
  7.97565654e-02f, -1.82139874e-02f, 3.37079138e-01f, 1.74340323e-01f, -3.69399041e-01f, -1.74719300e-02f, 1.44502789e-01f, -1.30268827e-01f, 2.59937614e-01f, -1.36875480e-01f,
  -1.46835148e-01f, 1.79905787e-01f, 1.75279796e-01f, 5.13008274e-02f, 1.76084518e-01f, 2.44025439e-01f, 1.01416133e-01f, 3.99951404e-03f, 9.50122327e-02f, -2.10949630e-01f,
  1.44716442e-01f, -2.20385090e-01f, 2.08038524e-01f, -3.93016458e-01f, -7.40569159e-02f, -4.25509699e-02f, -1.30154431e-01f, -5.93717843e-02f, -1.90421224e-01f, -8.59081447e-02f,
  -6.23657405e-02f, 8.09727460e-02f, 2.34740926e-03f, 3.44398431e-02f, -1.44580388e-02f, 6.75859535e-03f, 1.32781528e-02f, 4.77084704e-02f, -3.93644767e-03f, 3.00493501e-02f,
  9.25783906e-03f, 7.92359840e-03f, -4.95143645e-02f, 4.45779227e-02f, 4.88287099e-02f, 2.46770903e-02f, 2.33875811e-02f, 1.22407256e-02f, 2.86605507e-02f, 1.43262774e-01f,
  1.11866407e-01f, 8.33581388e-02f, 1.05827965e-01f, -3.37592140e-02f, 6.65357634e-02f, -9.26923286e-03f, 5.39871827e-02f, 1.32492057e-03f, -1.70766190e-02f, -4.01956365e-02f,
  -2.56684925e-02f, -1.35499658e-02f, -4.04728092e-02f, 2.79443935e-02f, -4.58117798e-02f, 9.19908471e-03f, 2.15672031e-02f, -5.07548824e-02f, 2.08443664e-02f, -8.58712867e-02f,
  -7.86237344e-02f, 3.63154011e-03f, -2.83705052e-02f, 2.04959437e-02f, -1.35650048e-02f, 4.39063013e-02f, -2.93661263e-02f, -8.64792168e-02f, 8.67808890e-03f, -1.54305799e-02f,
  3.52029018e-02f, 6.73469389e-03f, -7.58799538e-02f, -2.50094905e-02f, 6.02420680e-02f, 4.05849144e-02f, 1.06375024e-01f, 1.16579875e-01f, 4.13584616e-03f, -5.68523630e-02f,
  -1.81895941e-01f, -2.02084288e-01f, -4.56157364e-02f, -1.00995556e-01f, -2.40685921e-02f, 6.93021296e-03f, 6.87996224e-02f, 6.67648995e-03f, 3.83190885e-02f, -7.37059191e-02f,
  -3.62991840e-02f, -5.61345019e-04f, -2.86600497e-02f, -2.48482805e-02f, -5.86345531e-02f, 3.46765295e-02f, -1.20109320e-02f, -3.25871296e-02f, -1.30988762e-01f, -1.15281686e-01f,
  -8.86952877e-02f, -9.69756171e-02f, 3.05874739e-02f, -9.73791555e-02f, -6.18299171e-02f, -2.93836705e-02f, -2.76534483e-02f, -1.70570321e-03f, -5.59287071e-02f, 3.90100554e-02f,
  -1.42402261e-01f, -2.27457210e-02f, -3.65008116e-01f, -2.18447894e-01f, -1.66652694e-01f, -1.83210131e-02f, -1.44686759e-01f, -8.83260369e-02f, -1.07152075e-01f, 1.34572566e-01f,
  -1.15733847e-01f, 4.50409763e-02f, 9.15937424e-02f, -1.58428669e-01f, -2.35950902e-01f, 3.17960419e-02f, -9.00988430e-02f, 1.44702986e-01f, -9.75821763e-02f, -5.88278547e-02f,
  -1.85142308e-01f, 1.31876811e-01f, -3.24488938e-01f, 9.17460173e-02f, -2.16581494e-01f, -1.05656579e-01f, 1.20703183e-01f, -9.39616561e-02f, 2.64465567e-02f, -7.96736404e-02f,
  -1.19404837e-01f, -3.13267969e-02f, -1.02571592e-01f, 1.07328407e-01f, -9.24282596e-02f, 7.98218027e-02f, -5.42111024e-02f, 6.53637573e-02f, -5.59296459e-02f, -7.06578940e-02f,
  1.15033858e-01f, 4.16190512e-02f, 1.03549153e-01f, 2.58826092e-02f, 5.73405847e-02f, -6.20613284e-02f, 6.50170771e-03f, -7.78450966e-02f, -7.54393190e-02f, -7.55286589e-02f,
  -1.05737820e-01f, 2.04753429e-02f, -1.45585656e-01f, 1.87801421e-01f, -3.13707925e-02f, -8.27295110e-02f, -5.40094897e-02f, -1.86219588e-02f, 2.27497108e-02f, -7.28861289e-03f,
  3.55875008e-02f, 9.54631865e-02f, -7.66047835e-02f, -1.06475823e-01f, -6.14582449e-02f, -9.00218710e-02f, 6.64719716e-02f, 4.35122551e-04f, -6.41048402e-02f, -5.08398674e-02f,
  -9.15640667e-02f, -8.29738379e-02f, 8.42411965e-02f, 6.95035607e-02f, -6.16179854e-02f, -3.58674861e-02f, 3.62816080e-02f, 1.69747565e-02f, -1.72312073e-02f, -3.09545882e-02f,
  -5.96774444e-02f, -4.45430875e-02f, 5.28015234e-02f, -4.79699858e-02f, -1.16338097e-01f, 2.23746616e-02f, 7.27059245e-02f, -1.22250736e-01f, -9.95211899e-02f, -1.88883841e-02f,
  -2.41710227e-02f, 1.27964810e-01f, -4.88740355e-02f, 1.01084337e-01f, 1.29115731e-01f, 9.55438912e-02f, 9.42789540e-02f, -4.03827280e-02f, -6.97942078e-02f, 3.25502753e-02f,
  9.42758173e-02f, -9.55833942e-02f, 1.14458188e-01f, 6.48962855e-02f, 3.69111225e-02f, -1.29194602e-01f, 1.93840742e-01f, 1.23941697e-01f, 8.37381706e-02f, 3.97936925e-02f,
  9.10393000e-02f, 2.21945234e-02f, 1.52380615e-01f, 9.31450166e-03f, 2.88905781e-02f, -3.47892530e-02f, 1.57270022e-02f, 2.25779712e-02f, 1.35968029e-01f, 3.63856144e-02f,
  -4.79176611e-01f, 9.19273049e-02f, -3.41957808e-01f, -4.89192083e-03f, -2.69874316e-02f, -2.08173946e-01f, -3.02554578e-01f, 1.27250552e-02f, -1.59108266e-01f, 3.92402411e-01f,
  2.66820282e-01f, -3.17188114e-01f, 1.02681935e-01f, 1.30003080e-01f, -1.57869831e-01f, 2.24678621e-01f, 5.66023886e-02f, 4.01290432e-02f, -1.48643538e-01f, -3.89948743e-03f,
  5.28533719e-02f, 3.44816208e-01f, -7.39749474e-03f, 1.06083706e-01f, -1.80236652e-01f, -1.14376158e-01f, 2.36965194e-01f, -8.48781839e-02f, 2.01550290e-01f, 1.60730425e-02f,
  -9.97104943e-02f, 7.26627856e-02f, -1.53532431e-01f, -9.14011002e-02f, 2.50302069e-02f, 1.56234717e-02f, 1.18019786e-02f, -4.79576811e-02f, -9.24324244e-02f, 1.24201421e-02f,
  -9.25525725e-02f, 1.29893180e-02f, 8.14097095e-03f, -2.46747714e-02f, -4.14865091e-02f, -7.17508197e-02f, -5.23388125e-02f, -4.13169824e-02f, -7.33878240e-02f, -3.48585807e-02f,
  -9.77213606e-02f, 3.60583365e-02f, -6.22068271e-02f, 9.06817499e-04f, 1.11931225e-03f, -3.45284529e-02f, 7.22336173e-02f, -8.26806054e-02f, 1.07993841e-01f, -3.63201015e-02f,
  6.77652508e-02f, -2.70066895e-02f, -5.87355457e-02f, 2.19570827e-02f, -1.14621773e-01f, 5.18342815e-02f, 5.21909352e-03f, 5.20690419e-02f, -6.38845488e-02f, 8.24214593e-02f,
  4.86812331e-02f, 2.47503072e-02f, 1.25429695e-02f, 2.23493855e-02f, 1.14265695e-01f, 7.07293767e-03f, 5.58559666e-04f, 5.30510433e-02f, 5.82624460e-03f, -8.68603587e-03f,
  -1.40168676e-02f, -3.92804444e-02f, 5.07414900e-02f, 7.76243350e-03f, 7.81626403e-02f, -3.82937938e-02f, 1.16940640e-01f, 1.96646657e-02f, 5.27818408e-03f, -3.88973951e-02f,
  1.38761446e-01f, 3.69717181e-01f, 2.67111976e-02f, 8.77498016e-02f, -9.75180790e-03f, 4.86642420e-02f, 6.71664858e-03f, -1.40590919e-02f, -2.16495730e-02f, 3.35219987e-02f,
  8.87607783e-02f, 3.93029526e-02f, 2.43189372e-02f, 1.26235625e-02f, 3.53026278e-02f, 1.05949529e-01f, 6.62984326e-02f, 2.08651349e-02f, 1.03761829e-01f, 9.65489000e-02f,
  1.07410148e-01f, 5.06648347e-02f, 2.82433140e-03f, 6.04643337e-02f, 5.90893067e-02f, 1.36532187e-02f, -1.63194947e-02f, -1.75850652e-02f, 4.60795425e-02f, -1.05822198e-02f,
  -1.08291037e-01f, 3.22335422e-01f, -1.64150465e-02f, 2.86369808e-02f, -2.27949589e-01f, 9.57043543e-02f, 1.12849712e-01f, -2.46854350e-02f, -8.26327130e-02f, 3.44765246e-01f,
  -7.51921758e-02f, -4.23224876e-03f, 6.79396419e-03f, 2.32056066e-01f, -1.90727264e-01f, 3.10185440e-02f, 3.33163083e-01f, 1.09492801e-01f, -4.04987819e-02f, 1.46782935e-01f,
  -8.90544653e-02f, 1.06618941e-01f, -1.02758721e-01f, 5.66601679e-02f, -1.24673340e-02f, 2.46083252e-02f, 5.77230155e-02f, -1.38968274e-01f, 1.77504063e-01f, -1.94752693e-01f,
  -1.31993825e-02f, -1.08821914e-02f, 7.76503235e-02f, -1.11336270e-02f, 4.67713624e-02f, -8.44524428e-02f, 8.27424414e-03f, 4.77430318e-03f, -9.98447761e-02f, -9.00402740e-02f,
  -1.45256249e-02f, -1.23205595e-01f, -7.35374168e-02f, -2.95928381e-02f, -2.71090046e-02f, -5.00410683e-02f, -4.66470420e-02f, 2.04728693e-02f, -2.23749839e-02f, -7.02054948e-02f,
  -8.76782313e-02f, -7.72803184e-03f, 2.98388656e-02f, -1.27533590e-02f, -1.45164728e-01f, -6.80107400e-02f, -3.94262299e-02f, 2.67641875e-03f, -1.63334049e-02f, -8.31211358e-03f,
  -1.69049222e-02f, -1.44398725e-02f, 8.42637420e-02f, -9.48554128e-02f, 7.41466060e-02f, -4.74221371e-02f, 9.61418599e-02f, -4.98253256e-02f, 5.95119186e-02f, 1.11538535e-02f,
  1.02201262e-02f, 4.93054884e-03f, -4.28505205e-02f, -6.66854344e-03f, 8.33175108e-02f, 1.40642803e-02f, 4.09989133e-02f, -7.35866046e-03f, -1.96575020e-02f, -3.49622257e-02f,
  5.85867539e-02f, -2.01771799e-02f, 1.15288727e-01f, -6.13874383e-02f, 3.02838478e-02f, 5.58265038e-02f, 7.83872306e-02f, 6.56276494e-02f, -4.02288139e-02f, -1.25076808e-02f,
  3.20798546e-01f, 3.48360717e-01f, -4.43786457e-02f, -2.94694845e-02f, 6.85248524e-02f, -2.09335182e-02f, 5.91474175e-02f, -9.12942737e-03f, 1.25850797e-01f, 6.54210001e-02f,
  -1.52175017e-02f, 8.52496251e-02f, 1.44498467e-01f, -7.10541848e-03f, 8.22568089e-02f, 1.89593229e-02f, 1.02244541e-01f, 9.49558094e-02f, 7.63599202e-02f, 3.27859670e-02f,
  4.46353741e-02f, 3.34878564e-02f, -1.30765885e-01f, -8.22851807e-02f, -1.65335461e-03f, -2.54774876e-02f, 8.65634065e-03f, -7.33904690e-02f, -1.81867257e-02f, 9.06795859e-02f,
  2.25218952e-01f, 6.17601015e-02f, -1.16553873e-01f, -8.15831646e-02f, 2.71221787e-01f, 1.68406144e-01f, 3.14783454e-01f, 1.08152919e-01f, 1.58786997e-01f, -8.92854631e-02f,
  2.35525012e-01f, -1.55389696e-01f, 2.76876301e-01f, -2.72330437e-02f, 1.67460009e-01f, 7.65576363e-02f, -1.17088728e-01f, -2.90786941e-02f, 4.70870696e-02f, 8.18835050e-02f,
  -1.19300764e-02f, 9.84264836e-02f, -7.76926726e-02f, 8.02133058e-04f, -1.76110920e-02f, -1.67080745e-01f, -1.54732868e-01f, 1.02886967e-01f, -3.08701307e-01f, 3.20793539e-02f,
  1.29464090e-01f, 1.18069611e-01f, -7.74945393e-02f, -1.17967427e-01f, -6.34715660e-03f, -7.68408850e-02f, 6.12133220e-02f, 1.47454068e-01f, 4.12670560e-02f, 8.48298967e-02f,
  1.84057467e-02f, 3.83826420e-02f, -6.57452866e-02f, 6.04739524e-02f, 8.95920098e-02f, 3.21165696e-02f, -6.95022717e-02f, -1.05750844e-01f, -1.40411044e-02f, -5.00845686e-02f,
  -3.10935546e-03f, 1.31510245e-02f, -9.67767909e-02f, -4.88460399e-02f, 2.88666300e-02f, 4.49160635e-02f, -1.75887957e-01f, -3.72826979e-02f, -2.19036024e-02f, 1.21787516e-02f,
  8.71292725e-02f, 2.61200294e-02f, -2.14574076e-02f, 5.39176399e-03f, 5.34897819e-02f, 7.00130984e-02f, -4.73760180e-02f, -1.88959006e-03f, -1.44735212e-02f, 6.63412064e-02f,
  -8.93595722e-03f, 5.70118465e-02f, -7.54793137e-02f, -6.78885588e-03f, -8.65601674e-02f, -2.57903915e-02f, 5.23728505e-03f, 4.78000976e-02f, -5.71159124e-02f, -1.13962941e-01f,
  1.47323236e-01f, 2.18146723e-02f, -4.80765961e-02f, -2.21407395e-02f, 1.97610911e-02f, 3.62123884e-02f, -7.33327642e-02f, -9.08292830e-02f, 3.74556743e-02f, 4.93029878e-02f,
  2.34795377e-01f, 2.63158344e-02f, 3.74227613e-02f, 6.37937933e-02f, -7.02804374e-03f, -7.00433180e-02f, -9.07121450e-02f, -8.35194811e-02f, 1.07552290e-01f, 2.57912893e-02f,
  -7.18631968e-02f, -2.74832267e-02f, 6.61377842e-03f, -5.95703684e-02f, -3.64995673e-02f, -3.27216350e-02f, -1.64138153e-02f, 5.52616902e-02f, 2.77093425e-02f, -4.50015776e-02f,
  3.30842612e-03f, 6.70216382e-02f, -2.47941725e-02f, -8.43125919e-04f, -9.90183908e-04f, -8.77877995e-02f, 4.58188169e-03f, -1.77492704e-02f, -1.75836142e-02f, -6.20572232e-02f,
  4.64882582e-01f, -3.66367340e-01f, -8.95856693e-03f, 2.88127691e-01f, -9.59617123e-02f, 9.30628404e-02f, 3.53933275e-01f, -2.17607558e-01f, 3.43093932e-01f, -2.37249568e-01f,
  -1.02095127e-01f, 1.63221776e-01f, 8.37416947e-02f, -3.24229710e-02f, 5.38971663e-01f, 2.20345452e-01f, 7.33217299e-02f, 1.26743972e-01f, 1.52185649e-01f, -6.48689792e-02f,
  1.37459025e-01f, -3.85397710e-02f, -6.73501194e-02f, -2.12160900e-01f, -1.15684196e-01f, -1.36722222e-01f, -1.34212688e-01f, -7.90842343e-03f, -2.70130634e-01f, 4.72949296e-02f,
  2.63652932e-02f, -2.47889794e-02f, -8.01506191e-02f, 1.26694301e-02f, -5.87069280e-02f, 2.20644958e-02f, 6.10315576e-02f, 8.24755654e-02f, 1.51952982e-01f, 2.19187867e-02f,
  2.33494025e-02f, 8.60075746e-03f, -2.49469131e-02f, 1.33762797e-02f, 1.18007977e-02f, -1.38411000e-02f, -3.86058033e-04f, -7.32857510e-02f, 6.90453453e-04f, 1.30476581e-03f,
  -8.59744940e-03f, 6.68703951e-03f, -5.71090821e-03f, 3.43880057e-02f, 3.42321657e-02f, 6.53181225e-02f, 8.18887725e-02f, -5.51426150e-02f, -3.64533179e-02f, 2.63275672e-03f,
  -1.24980258e-02f, 5.99983148e-02f, -1.85026433e-02f, -1.40120992e-02f, 4.93776798e-02f, -1.15427181e-01f, 6.68981895e-02f, -5.76347560e-02f, 6.49181232e-02f, -3.32529168e-03f,
  -3.16098258e-02f, 3.38124111e-02f, -5.00931405e-02f, -4.98349853e-02f, 2.03423575e-02f, 2.72276029e-02f, 3.17612253e-02f, -6.89708441e-02f, -4.36820695e-03f, -4.96867187e-02f,
  2.99980701e-03f, 7.08352029e-02f, -5.69457375e-03f, -3.71897384e-03f, -1.10306619e-02f, 1.67810339e-02f, -1.70100853e-02f, -7.81328604e-02f, -3.32741924e-02f, 3.49082947e-02f,
  -1.06881641e-01f, -5.33644110e-02f, 9.10293031e-03f, 6.78538606e-02f, 2.76073590e-02f, -7.65309259e-02f, -1.55383470e-02f, -1.88559368e-02f, 1.23357885e-02f, 1.11214286e-02f,
  -4.07613069e-02f, 5.08848056e-02f, -1.43576292e-02f, -2.54598577e-02f, 4.23894338e-02f, -6.11706264e-03f, 2.67827399e-02f, 9.17895362e-02f, -1.69700012e-03f, -2.86005456e-02f,
  -8.45871568e-02f, -1.36062899e-03f, 1.32414296e-01f, 5.98052889e-03f, -4.79975268e-02f, -4.27253311e-03f, -3.22648231e-03f, -1.21638961e-02f, -6.54149279e-02f, 2.21170522e-02f,
  -1.40463740e-01f, 3.33010703e-01f, -1.15467079e-01f, -1.78962469e-01f, 1.31410226e-01f, -1.70269370e-01f, -1.98197931e-01f, 1.78605244e-01f, -3.26122224e-01f, 2.74202049e-01f,
  8.02968293e-02f, 1.30037144e-01f, -1.82228252e-01f, 1.53286174e-01f, -3.98395985e-01f, -3.48224312e-01f, -5.84203638e-02f, -4.90804799e-02f, -1.03708267e-01f, 1.34176537e-01f,
  -1.03794143e-01f, 1.25706956e-01f, -2.49755550e-02f, 1.66208029e-01f, 1.40757352e-01f, 4.62286994e-02f, 6.06453717e-02f, 3.93579639e-02f, 2.63079375e-01f, 4.77270078e-04f,
  -5.92122711e-02f, 5.53173572e-02f, 1.28824888e-02f, -8.16973969e-02f, -3.04377191e-02f, 3.84427048e-02f, -5.30376993e-02f, 5.47598628e-03f, -9.01748091e-02f, 1.75147597e-02f,
  -5.56094050e-02f, 2.86236275e-02f, 3.82048562e-02f, -1.23162149e-02f, 6.87746331e-02f, -5.37681468e-02f, 1.66141652e-02f, -4.03601006e-02f, 2.80460138e-02f, 1.68530759e-03f,
  -7.13994727e-02f, 3.81028280e-02f, 3.90004888e-02f, -6.79347888e-02f, -7.64124542e-02f, -3.88999964e-04f, -2.32054237e-02f, -1.24662323e-02f, 6.33881614e-03f, 4.22430262e-02f,
  5.08699603e-02f, 7.05866562e-03f, -6.41429040e-04f, -7.87376165e-02f, 1.96207296e-02f, -9.03961540e-04f, 4.39734496e-02f, 3.87998596e-02f, 1.57544371e-02f, 2.19753794e-02f,
  -4.83041210e-03f, 2.38103718e-02f, 2.88796909e-02f, 4.50384319e-02f, 9.37921926e-03f, 1.56257506e-02f, -2.78993566e-02f, 7.80735165e-02f, -6.55847341e-02f, -2.55355798e-02f,
  -1.59429312e-02f, -4.71110456e-02f, 1.70540262e-03f, -7.80530507e-03f, -3.84601690e-02f, -3.60139012e-02f, 1.10359460e-01f, 5.67954704e-02f, 3.43312696e-03f, 1.06076607e-02f,
  2.66467175e-03f, 2.11737692e-01f, -5.18788844e-02f, 1.47183286e-02f, 1.88148394e-02f, 8.60389993e-02f, -5.36911897e-02f, 2.52670459e-02f, 3.92337283e-03f, 4.74202931e-02f,
  9.28480476e-02f, -5.06593324e-02f, 2.68519260e-02f, 1.61497090e-02f, -4.24639434e-02f, 4.26013991e-02f, -1.95764396e-02f, -3.00661824e-03f, 7.46123074e-03f, 8.01153481e-02f,
  8.08217153e-02f, 1.44222518e-02f, -4.54193167e-02f, 3.41230743e-02f, 8.32839757e-02f, -2.87390444e-02f, -4.18706164e-02f, -1.53443739e-02f, 4.46312688e-02f, -6.58664852e-02f,
  2.74649888e-01f, -1.07760772e-01f, 1.65476903e-01f, 1.36381313e-01f, 1.21629462e-01f, 1.97680488e-01f, 1.98912293e-01f, -9.49720815e-02f, -1.52755693e-01f, -4.63811532e-02f,
  -6.14192784e-02f, 4.49367389e-02f, -1.19547553e-01f, -5.10815196e-02f, -4.17091101e-02f, -2.07587659e-01f, 1.33563295e-01f, 1.23948269e-01f, -1.06471501e-01f, 2.06922770e-01f,
  -8.26229807e-03f, -8.56625363e-02f, -3.70120779e-02f, -1.92546502e-01f, 9.07984003e-02f, 1.08153364e-02f, -1.14196897e-01f, -1.17153004e-01f, 1.61674678e-01f, -7.63995349e-02f,
  1.31456420e-01f, -1.15268186e-01f, -7.21557625e-03f, 8.21039081e-02f, 9.66162160e-02f, 1.09144963e-01f, 3.22820097e-02f, -1.73599534e-02f, -1.94322877e-02f, 5.61568886e-02f,
  8.49912837e-02f, 8.18440318e-03f, -5.07391058e-02f, -6.72717616e-02f, -4.05937582e-02f, 3.06883529e-02f, 6.19822042e-03f, 4.62700352e-02f, -8.80357623e-03f, 7.81548545e-02f,
  1.08661577e-01f, 8.73528142e-03f, 1.58476159e-02f, -5.37832715e-02f, 3.87861580e-02f, 5.13598993e-02f, 6.73453882e-02f, 1.88972458e-01f, 9.87518113e-03f, -6.62814081e-02f,
  2.45903283e-02f, -8.71055052e-02f, 2.73489766e-02f, -1.06931321e-01f, -9.47165415e-02f, -1.09252036e-01f, -9.77600142e-02f, -1.06158137e-01f, 4.90172170e-02f, 3.18661332e-02f,
  1.11980336e-02f, -8.48402306e-02f, -4.98110950e-02f, 7.40673393e-02f, -2.89067216e-02f, 1.98425334e-02f, 7.97669813e-02f, 9.74653065e-02f, 1.04864031e-01f, -5.33905216e-02f,
  -1.70909777e-01f, -3.06240581e-02f, 3.38207893e-02f, -4.13545482e-02f, -4.79385890e-02f, -4.26146165e-02f, -3.13399062e-02f, -5.38627990e-02f, 7.44521394e-02f, -9.77612333e-04f,
  2.14752749e-01f, -8.74803141e-02f, -8.03916305e-02f, 1.03474833e-01f, -6.33841380e-02f, -8.92479718e-03f, -1.49773121e-01f, -6.18799105e-02f, 2.33766548e-02f, -4.30102050e-02f,
  1.19307101e-01f, 1.10984862e-01f, -3.24472599e-02f, 8.91285390e-02f, 1.70229431e-02f, 4.04706039e-02f, 1.70795634e-01f, 6.16172664e-02f, 3.69859114e-02f, 5.72973490e-02f,
  7.88697079e-02f, 1.21171586e-01f, -4.50336896e-02f, 4.27181944e-02f, 1.01600647e-01f, 3.61578427e-02f, 2.83422098e-02f, -7.34020630e-03f, -1.00106470e-01f, -1.99966673e-02f,
  4.68968414e-02f, -1.28612429e-01f, -3.15189183e-01f, -1.24020074e-02f, 7.85759911e-02f, 2.31799692e-01f, -5.20906784e-03f, 4.80523519e-02f, -2.68614024e-01f, 1.37479618e-01f,
  3.56227696e-01f, -4.16525215e-01f, 3.60053815e-02f, 2.57038981e-01f, 2.50983059e-01f, 8.14382434e-02f, 2.78455317e-01f, 8.93687382e-02f, -1.59908757e-01f, 4.02295962e-02f,
  -9.19405222e-02f, 3.66628379e-01f, -1.51142245e-02f, 8.27214308e-03f, 9.56602842e-02f, -2.85942733e-01f, 3.41573358e-01f, -1.39542967e-01f, 2.08028540e-01f, 1.81961097e-02f,
  2.52673682e-02f, 3.89272049e-02f, -7.90362209e-02f, -6.20686933e-02f, 6.45343885e-02f, 1.06335737e-01f, -7.35097975e-02f, -4.84351516e-02f, 3.11136357e-02f, 2.48934459e-02f,
  -6.03498742e-02f, 3.80286686e-02f, -4.00693268e-02f, 1.16266040e-02f, -5.56542762e-02f, -9.04999077e-02f, -1.36171589e-02f, -3.46431099e-02f, -8.36772770e-02f, -5.59853017e-02f,
  -5.88882715e-02f, 4.21391726e-02f, -2.57135499e-02f, 6.41185641e-02f, -8.42793286e-02f, -6.13906719e-02f, -9.48371664e-02f, -5.59780933e-02f, 6.84805634e-03f, -7.96272513e-03f,
  5.25575764e-02f, -1.08643129e-01f, -7.84799084e-02f, 3.02676689e-02f, 4.21599485e-03f, 3.01283132e-02f, -3.95539328e-02f, 6.75758794e-02f, -5.25197871e-02f, 9.17055681e-02f,
  6.49907738e-02f, -7.00703338e-02f, -3.24969739e-02f, 5.01967408e-02f, 2.87344195e-02f, -9.49169472e-02f, -1.26792923e-01f, 7.90100917e-02f, -3.67593095e-02f, -1.50421979e-02f,
  -1.78071018e-02f, -2.88579334e-02f, -7.32375458e-02f, 3.59477177e-02f, -1.29201887e-02f, -5.30830957e-03f, -1.33173866e-02f, -6.70914166e-03f, 1.93980057e-02f, 5.57719432e-02f,
  2.06813380e-01f, 1.29961491e-01f, -1.32436380e-01f, 2.62851231e-02f, 5.15115168e-03f, 2.25702394e-02f, -1.12999819e-01f, -4.64325845e-02f, 1.49815358e-04f, 1.81641616e-03f,
  -2.65981350e-03f, -3.72363403e-02f, 2.00475045e-02f, 4.61209975e-02f, 1.26645453e-02f, 5.09895943e-02f, -3.44631597e-02f, -2.30975654e-02f, 6.67625442e-02f, 6.87830299e-02f,
  4.59138229e-02f, 1.18833939e-02f, -3.57441455e-02f, -4.49533947e-02f, 2.15203129e-02f, 6.02986552e-02f, -7.90993348e-02f, -3.22431251e-02f, 1.34418502e-01f, -9.76038054e-02f,
  -5.22373840e-02f, -1.95458196e-02f, 2.74128348e-01f, 5.63900359e-02f, -2.74815131e-02f, -8.28022361e-02f, 3.52409557e-02f, -4.40784078e-03f, 3.32232833e-01f, -9.22729522e-02f,
  -2.54590034e-01f, 7.98247978e-02f, -4.53327671e-02f, -7.30482563e-02f, -2.26000413e-01f, -2.09662374e-02f, -1.93684161e-01f, -7.16284290e-02f, 1.64593756e-01f, 1.19547108e-02f,
  -1.52441375e-02f, -2.64584243e-01f, -8.87333378e-02f, -1.17894141e-02f, -4.87851091e-02f, -6.51786327e-02f, -2.50259131e-01f, 1.28213078e-01f, -1.42331362e-01f, -9.18514729e-02f,
  -1.35513216e-01f, -2.17311792e-02f, -7.29029998e-02f, -7.62744099e-02f, -7.40764588e-02f, 2.61582918e-02f, -3.62054482e-02f, 8.42786059e-02f, -7.54482229e-04f, 9.67697501e-02f,
  4.95292880e-02f, 2.71890685e-02f, -4.63421084e-02f, 4.81324494e-02f, 6.58857897e-02f, 5.34592867e-02f, 1.08957730e-01f, 2.85097640e-02f, 3.02266292e-02f, -4.19628210e-02f,
  7.01351389e-02f, -1.82482973e-02f, -5.96878678e-02f, -6.48152232e-02f, -1.38243482e-01f, 1.02661915e-01f, 9.17540193e-02f, -3.35664675e-02f, -2.08072364e-01f, 1.21145606e-01f,
  -5.26633486e-02f, 1.00722857e-01f, -3.61775160e-02f, 6.39288276e-02f, -7.80856013e-02f, -3.70921232e-02f, -2.19287854e-02f, -4.64233011e-02f, -1.59129128e-02f, -7.10418895e-02f,
  -4.57330011e-02f, 4.27139625e-02f, -2.56394316e-02f, 7.97490999e-02f, 1.43440748e-02f, 7.05136284e-02f, 3.33774015e-02f, -3.83168347e-02f, 5.65217249e-03f, 2.54752990e-02f,
  8.43110904e-02f, -1.32582821e-02f, -1.18356971e-02f, 3.01122554e-02f, -3.92640792e-02f, -1.60651263e-02f, 4.30074008e-03f, 8.22821036e-02f, -4.12356518e-02f, -9.53458920e-02f,
  -1.69307873e-01f, -1.01889729e-01f, -1.08294249e-01f, -1.48737673e-02f, -7.00501427e-02f, -1.21554062e-01f, 4.39726524e-02f, 1.94413140e-02f, -6.92092925e-02f, 2.37015150e-02f,
  -5.96268773e-02f, -5.19019477e-02f, -1.05813414e-01f, 7.26478770e-02f, -1.11744486e-01f, 7.21995234e-02f, -4.30285223e-02f, -6.39060289e-02f, -1.56208560e-01f, -9.30308253e-02f,
  -9.98809934e-02f, -7.52167627e-02f, 2.58209165e-02f, -4.75002266e-02f, -6.26848713e-02f, -1.16919048e-01f, -7.79042095e-02f, 3.88452709e-02f, 2.65334118e-02f, -1.00076534e-01f,
  3.09101284e-01f, -4.64217186e-01f, -3.45241934e-01f, 2.46911392e-01f, 2.36357659e-01f, 1.40551060e-01f, 2.35552311e-01f, -9.70087349e-02f, -1.90727338e-01f, 5.39562665e-04f,
  1.76532224e-01f, -1.38761669e-01f, -1.41325444e-01f, 1.47682279e-01f, 1.98383972e-01f, -2.22035885e-01f, 8.47664028e-02f, 1.12741761e-01f, -1.69333011e-01f, 2.06206799e-01f,
  1.14579313e-02f, 3.29112768e-01f, -1.05192915e-01f, 8.02123360e-03f, 2.22857088e-01f, -1.35554209e-01f, 3.55658680e-01f, -2.22941637e-01f, 1.00216240e-01f, -2.55957171e-02f,
  -3.56224254e-02f, -4.14601900e-02f, 1.04858226e-03f, -1.45114169e-01f, 1.19343482e-01f, 7.86407888e-02f, 9.60017592e-02f, 2.45148726e-02f, -5.50959557e-02f, 6.42832043e-03f,
  -2.06128079e-02f, 2.48652007e-02f, -7.25241154e-02f, -8.05344880e-02f, 4.13121581e-02f, -2.49919500e-02f, 5.79782994e-03f, -5.33831045e-02f, -4.43917438e-02f, -3.20576988e-02f,
  -3.64984684e-02f, -2.20969133e-02f, 1.24607638e-01f, -6.09442070e-02f, -7.50381425e-02f, -7.94958323e-02f, -6.16118275e-02f, -1.93320196e-02f, 1.23080760e-01f, 3.35088708e-02f,
  8.00483748e-02f, -3.72913182e-02f, -2.41927877e-02f, 5.73185757e-02f, -1.98364607e-03f, 4.22214009e-02f, 2.08634567e-02f, 6.67327195e-02f, -5.07551767e-02f, 9.06728432e-02f,
  2.25308612e-02f, 8.14798772e-02f, 5.54595254e-02f, 2.57817600e-02f, 7.13430792e-02f, 2.19328217e-02f, 1.12227730e-01f, -5.39695211e-02f, -1.16618568e-04f, 5.32270856e-02f,
  5.84932417e-03f, 1.77863538e-02f, -5.75440936e-02f, 3.76964957e-02f, -2.08518859e-02f, 1.53777348e-02f, -1.16697155e-01f, -6.46614730e-02f, 2.32804567e-02f, 9.94011313e-02f,
  -1.23926170e-01f, -2.29196236e-01f, -3.65825780e-02f, -3.59414853e-02f, 9.38448682e-03f, 2.62113251e-02f, -8.43550488e-02f, 9.83684510e-02f, -5.83657324e-02f, 4.00639046e-03f,
  2.07521636e-02f, 4.28244658e-02f, 8.82136598e-02f, 9.21621323e-02f, -2.19348632e-02f, -2.23257206e-02f, 2.40813438e-02f, -6.00095093e-02f, 4.34768535e-02f, 2.54539270e-02f,
  1.09143220e-01f, 1.24917887e-01f, 2.00773366e-02f, 1.36681631e-01f, 6.60808533e-02f, 6.26956075e-02f, 1.48103246e-02f, -7.63954967e-02f, -4.10037562e-02f, -5.50788194e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.44519138e-02f, -2.24979192e-01f, 3.26268315e-01f, 3.57527852e-01f, -4.61599827e-01f, 1.23750269e-01f, 5.52795172e-01f, -3.22917789e-01f, 2.62351006e-01f, -1.13071054e-01f,
  -2.37731099e-01f, 5.55737168e-02f, 1.43593669e-01f, 2.38407310e-02f, 4.27596331e-01f, 4.00633484e-01f, 1.33896306e-01f, 3.45530778e-01f, -6.41660998e-03f, -1.35390600e-03f,
  -1.50037959e-01f, -2.06370443e-01f, 1.52434269e-02f, -3.73868167e-01f, -3.17674935e-01f, -1.86209157e-01f, -9.38138142e-02f, 1.16483442e-01f, -2.35372335e-01f, 6.45266101e-02f,
  -1.98282033e-01f, -1.99236467e-01f, -5.72247170e-02f, -5.24187982e-02f, -1.35061830e-01f, 8.30586776e-02f, 1.98008537e-01f, 1.14960931e-01f, 1.91562995e-02f, -4.30825772e-03f,
  1.09635247e-02f, -6.45028427e-02f, -7.33726472e-02f, -2.93171853e-02f, -6.97782710e-02f, -1.20492287e-01f, -9.92991477e-02f, -5.03777713e-02f, -3.27247381e-02f, -1.56844426e-02f,
  -8.56638625e-02f, -1.42380327e-01f, -1.38050299e-02f, 5.69795407e-02f, -8.47181380e-02f, -5.77109978e-02f, 1.45706549e-01f, 9.28229168e-02f, -3.50246765e-02f, -6.26276759e-03f,
  -7.54675595e-04f, 8.64443555e-02f, -7.91743323e-02f, 3.24195139e-02f, -6.81955442e-02f, -2.80299000e-02f, 4.08439524e-03f, -9.03518349e-02f, 6.03290424e-02f, -1.16974920e-01f,
  1.87102892e-02f, -6.84031248e-02f, -2.52212919e-02f, -5.30854473e-03f, 4.80068959e-02f, 5.80292083e-02f, 7.58991018e-02f, -6.06955327e-02f, 6.62841052e-02f, -9.26102474e-02f,
  9.10932124e-02f, 6.90015107e-02f, -5.39039746e-02f, 2.64403317e-02f, 1.54306004e-02f, -8.50302130e-02f, -8.11985508e-02f, 2.71924566e-02f, 1.48388185e-02f, -5.02765588e-02f,
  4.20423970e-02f, 2.02362806e-01f, -1.25742853e-01f, -1.72093630e-01f, 1.38501853e-01f, -1.66697353e-01f, 1.05146110e-01f, -4.13809195e-02f, 5.86253665e-02f, 5.12365066e-02f,
  -1.91561460e-01f, 8.44752192e-02f, 1.52832828e-02f, 4.33195569e-03f, 4.48710248e-02f, -9.55961086e-03f, 1.45757094e-01f, -4.71372791e-02f, -1.82658527e-02f, -1.33921787e-01f,
  -8.85666534e-02f, 4.91113327e-02f, -6.52001277e-02f, -5.28853871e-02f, -4.70520332e-02f, -7.87078030e-03f, -5.92268957e-03f, 4.44560945e-02f, 6.76513612e-02f, 1.07998125e-01f,
  -8.88922140e-02f, -3.39738071e-01f, -2.67656952e-01f, -6.16039522e-02f, 1.06838673e-01f, 3.12371910e-01f, -2.99186409e-01f, 6.55489159e-04f, -3.33726794e-01f, -1.48388237e-01f,
  -5.25450427e-03f, -1.86017424e-01f, -3.52916211e-01f, 8.52614269e-02f, 2.31223822e-01f, -3.49131197e-01f, 1.36157602e-01f, 1.23058990e-01f, -1.30211234e-01f, 8.78084078e-02f,
  1.10413179e-01f, 2.08142802e-01f, -6.32036999e-02f, 4.04822022e-01f, 1.79503575e-01f, 2.45355129e-01f, 2.27814823e-01f, 2.06514165e-01f, 2.98774987e-01f, 2.56382227e-01f,
  2.96711288e-02f, -2.66676337e-01f, -1.77684072e-02f, -6.88338280e-03f, 1.30714118e-01f, 1.25335172e-01f, 4.47222292e-02f, 5.47123104e-02f, -2.85382080e-03f, -5.09632789e-02f,
  2.47206893e-02f, 1.64748549e-01f, -4.60067019e-02f, 4.14228477e-02f, 4.56102006e-02f, 1.45220850e-02f, -9.41941142e-03f, -8.22101682e-02f, 1.56485438e-02f, -1.31728351e-01f,
  -3.25170964e-01f, -2.63778400e-02f, -4.13933769e-02f, 8.34507495e-02f, -1.36914268e-01f, -4.11425978e-02f, 2.98766214e-02f, 1.28311038e-01f, -9.94723141e-02f, 5.68491966e-02f,
  8.94804224e-02f, 2.18200553e-02f, 5.11473827e-02f, -5.59939742e-02f, -4.24661972e-02f, -2.70243995e-02f, 7.09068254e-02f, 4.59084883e-02f, -2.67923493e-02f, 4.43907157e-02f,
  6.25089332e-02f, -3.50008681e-02f, -7.57100880e-02f, -4.65003848e-02f, -5.78901470e-02f, -3.35164368e-02f, -6.13020360e-02f, -3.32811736e-02f, -6.88918307e-02f, -8.74821618e-02f,
  -8.32122788e-02f, 2.90987492e-02f, 1.94538794e-02f, 1.37418834e-02f, -6.28004372e-02f, 5.56462863e-03f, -2.99352985e-02f, -8.79181921e-02f, -7.80491754e-02f, 3.82924154e-02f,
  -1.95301860e-03f, -4.50872332e-02f, -4.54962142e-02f, 3.33640650e-02f, -6.63487166e-02f, 1.27088696e-01f, -1.18506499e-01f, -1.10539436e-01f, 1.07335567e-01f, 1.15254596e-02f,
  7.27218688e-02f, 6.80378526e-02f, 1.07824922e-01f, 8.56285691e-02f, 9.19060111e-02f, -2.06328314e-02f, 4.33672555e-02f, 7.63431415e-02f, 8.69615152e-02f, 2.72198636e-02f,
  -4.44563702e-02f, 7.80878514e-02f, 3.17754410e-02f, 1.94104686e-02f, 5.91769777e-02f, 8.62684250e-02f, 3.55525932e-04f, 7.18183294e-02f, 2.69001350e-02f, -2.00723447e-02f,
  -2.48239368e-01f, 3.54020357e-01f, -1.60902664e-01f, 3.64324570e-01f, -9.66307744e-02f, 2.80833304e-01f, 5.24985969e-01f, 6.31902069e-02f, 3.99148971e-01f, 3.56957912e-01f,
  1.04205199e-01f, 1.31781725e-02f, -2.43267845e-02f, 3.08992922e-01f, -2.18849793e-01f, 2.87125915e-01f, 4.73932683e-01f, 3.53771299e-01f, 1.70354754e-01f, 1.78704292e-01f,
  1.16391443e-01f, 2.36607209e-01f, -3.37865263e-01f, -8.67748037e-02f, -1.74420234e-02f, -1.11014940e-01f, -1.63490579e-01f, -1.17402397e-01f, -2.08431914e-01f, -1.18174575e-01f,
  4.89322208e-02f, 1.96839631e-01f, -2.28021443e-01f, -2.83312891e-02f, 8.13358203e-02f, -4.31812778e-02f, 4.16874737e-02f, -6.29588291e-02f, -1.63268939e-01f, -6.03610314e-02f,
  1.55515805e-01f, -9.72242281e-02f, 7.37383068e-02f, -6.77742437e-02f, 4.44619469e-02f, -1.05534054e-01f, -7.56268054e-02f, 2.51758173e-02f, 9.86227766e-03f, -1.25165865e-01f,
  -9.40321535e-02f, 8.21700990e-02f, 3.11866645e-02f, 9.89978984e-02f, -1.33915141e-01f, -6.11185357e-02f, 3.88323180e-02f, 2.67111929e-03f, -8.11369419e-02f, -3.16625237e-02f,
  -6.97630793e-02f, 1.29107401e-01f, -2.77915616e-02f, -1.04397405e-02f, -7.92351142e-02f, 4.43817638e-02f, -6.82426935e-06f, 5.82541227e-02f, -1.53411450e-02f, -4.61273789e-02f,
  3.92578319e-02f, -7.12372810e-02f, 7.33451769e-02f, -3.00168581e-02f, 2.60223120e-01f, 5.57965711e-02f, -2.04861909e-02f, -2.37652268e-02f, 1.35737315e-01f, -1.60169348e-01f,
  -5.03456919e-03f, 4.87555414e-02f, -8.69368836e-02f, 4.27780859e-02f, 9.96759534e-03f, -9.21281129e-02f, 1.29608624e-02f, -8.79922360e-02f, -3.07251718e-02f, 9.72267017e-02f,
  2.25367546e-01f, 4.17725503e-01f, 1.08178280e-01f, -6.49323016e-02f, 3.93182077e-02f, -8.57407227e-02f, 1.07575461e-01f, -7.12814778e-02f, 3.92548181e-02f, -1.84657387e-02f,
  -4.84599657e-02f, 4.13715690e-02f, 1.01344660e-01f, -1.27231926e-01f, 7.94080086e-03f, 3.94772552e-02f, 2.14662999e-01f, 1.03547769e-02f, 1.03224628e-01f, -8.75695199e-02f,
  -1.03142075e-01f, 8.43348578e-02f, 1.16491280e-01f, 4.02515978e-02f, 7.83932731e-02f, 8.58154818e-02f, 6.80978149e-02f, -1.21683076e-01f, -1.34469038e-02f, 1.77383479e-02f,
  -1.87243178e-01f, 4.67740148e-01f, -9.64106247e-02f, -4.40447718e-01f, 8.18582252e-03f, 2.34293103e-01f, -3.99862319e-01f, 1.07521318e-01f, -2.48388246e-01f, -1.81670457e-01f,
  -3.15206587e-01f, -2.68893778e-01f, 7.54799321e-02f, -2.10978255e-01f, 1.30820125e-01f, 3.15769672e-01f, -2.32812718e-01f, -2.73672283e-01f, 1.95863917e-01f, -1.22766696e-01f,
  -3.64285856e-02f, -1.79516509e-01f, 8.24784338e-02f, 3.58747691e-01f, -2.44130284e-01f, 6.11908957e-02f, -1.07460432e-01f, 9.66528580e-02f, -1.77295774e-01f, 4.75018732e-02f,
  8.77749026e-02f, -2.18592659e-01f, -3.38987000e-02f, -2.40816846e-02f, 6.19135052e-02f, -1.75693408e-01f, -1.61131714e-02f, 4.48189676e-02f, -9.69532803e-02f, -4.15863022e-02f,
  -1.45320967e-01f, 8.86659138e-03f, -7.65002444e-02f, 4.96808290e-02f, -1.70297489e-01f, -8.87087062e-02f, 1.42910704e-01f, 4.99298237e-02f, 1.86487753e-02f, 1.70896485e-01f,
  1.27615230e-02f, -1.98692922e-02f, -9.79893431e-02f, 3.14413942e-03f, -6.29218901e-03f, -1.07809328e-01f, -1.06511302e-01f, -9.13020149e-02f, -6.28142525e-03f, -1.14117116e-01f,
  2.39018295e-02f, -4.62366715e-02f, 3.47270668e-02f, -2.24997085e-02f, 7.49138892e-02f, -1.80292614e-02f, -5.39265536e-02f, -3.53065804e-02f, 3.19015160e-02f, -5.96579798e-02f,
  -1.32707730e-01f, -5.94231533e-03f, -1.27529008e-02f, -8.69674981e-02f, 1.05575155e-02f, -7.80487359e-02f, 3.59696597e-02f, 9.88023430e-02f, -8.67454037e-02f, -5.64869009e-02f,
  8.23215209e-03f, 2.51336303e-02f, -4.12962735e-02f, 3.58742252e-02f, -8.96338001e-02f, -4.49734293e-02f, -3.05162221e-02f, -2.58252099e-02f, 1.60049736e-01f, 2.58115050e-03f,
  1.05786584e-02f, -1.90669368e-03f, -4.85627241e-02f, 3.88452597e-02f, -1.20040467e-02f, 3.05241607e-02f, 5.29828481e-02f, 6.00797832e-02f, 5.30700106e-03f, -7.71783218e-02f,
  -6.40176833e-02f, -2.11168811e-01f, 1.94782261e-02f, 9.36413407e-02f, 1.06785238e-01f, 7.64688626e-02f, -1.26417696e-01f, -5.65175861e-02f, -1.48678154e-01f, 2.53981189e-03f,
  7.56310299e-02f, -8.86764005e-02f, 5.77880815e-03f, -1.13710418e-01f, -4.91432101e-02f, -2.20332086e-01f, 6.54956102e-02f, 4.14457358e-02f, -4.09466214e-02f, -1.99608300e-02f,
  -3.61932546e-01f, -5.32053709e-02f, 9.51453894e-02f, 4.56578843e-03f, -2.38609482e-02f, -1.14865452e-01f, -4.26156586e-03f, 7.00945333e-02f, -2.84230113e-01f, 3.09015960e-01f,
  1.61962181e-01f, -3.73544872e-01f, 1.96818426e-01f, 5.00360504e-02f, -1.17341518e-01f, -7.28738308e-02f, 2.19260007e-01f, 1.14621058e-01f, -1.76082715e-01f, 2.67727762e-01f,
  1.28212217e-02f, -5.56720644e-02f, 2.43394971e-01f, 1.16207272e-01f, 8.28193203e-02f, 1.88962951e-01f, 5.01337707e-01f, -5.98994195e-02f, 1.81958288e-01f, -2.36500204e-01f,
  7.27485344e-02f, -1.14845626e-01f, 4.36487831e-02f, -4.79979515e-02f, 2.59560645e-01f, 5.89199811e-02f, 1.27510920e-01f, -6.68842793e-02f, -1.62383407e-01f, 1.03424676e-02f,
  -3.53895575e-02f, -4.68131118e-02f, -1.11050338e-01f, -1.88701063e-01f, -1.68522596e-01f, -2.61965953e-02f, -1.45336524e-01f, 9.15527344e-02f, -1.28641203e-01f, -1.04050800e-01f,
  -5.09564541e-02f, 1.57665506e-01f, -2.79484484e-02f, 4.45328914e-02f, -4.51146625e-02f, -1.31038442e-01f, 5.14579937e-02f, 1.26727179e-01f, -1.06096342e-01f, -1.97436325e-02f,
  -8.98410231e-02f, 1.40097439e-01f, -8.99886526e-03f, 6.42410144e-02f, 3.30882370e-02f, 1.33210616e-02f, -1.84605211e-01f, 1.88601241e-02f, -3.84039395e-02f, 4.37534750e-02f,
  2.95368899e-02f, -8.92027095e-02f, -1.26426145e-01f, 5.16255759e-02f, -2.72645000e-02f, 1.22656333e-04f, -4.54596654e-02f, 2.61546094e-02f, 1.66458696e-01f, 1.46914944e-02f,
  -5.23361154e-02f, -1.02391966e-01f, 1.15509048e-01f, -2.15380378e-02f, 3.45055945e-02f, 4.08656858e-02f, -1.23248622e-02f, -6.91810772e-02f, 9.21770930e-02f, -4.90938351e-02f,
  2.38487050e-01f, 2.40052924e-01f, -2.03050803e-02f, 2.52981135e-03f, 7.32572824e-02f, 1.49788260e-01f, 1.86282806e-02f, -3.28001045e-02f, 7.91624933e-02f, -9.52922255e-02f,
  2.00907260e-01f, 1.06944472e-01f, 8.98753628e-02f, 2.65516266e-02f, 3.85140106e-02f, 1.85912311e-01f, 1.47612281e-02f, -3.61578204e-02f, 1.30907759e-01f, 2.03490585e-01f,
  1.31910205e-01f, 8.85298252e-02f, -1.04415789e-02f, -8.53274837e-02f, 4.61586788e-02f, 1.43867746e-01f, -2.64561120e-02f, 8.71964321e-02f, 2.44572069e-02f, 7.89118558e-02f,
  -2.01104164e-01f, -2.34433636e-01f, -3.76453578e-01f, -3.46407980e-01f, 4.38054577e-02f, -4.15194064e-01f, -3.68279070e-01f, -1.63781345e-01f, 2.84100138e-02f, 7.95046762e-02f,
  -1.18564241e-01f, -4.23101820e-02f, 1.96725562e-01f, -3.98443162e-01f, -2.58056253e-01f, 6.45414460e-03f, -4.10206705e-01f, -2.51665443e-01f, -7.48845711e-02f, -2.10720599e-01f,
  -2.20955119e-01f, -2.12142467e-01f, -2.96002716e-01f, 1.72730729e-01f, -2.14591801e-01f, 5.29933944e-02f, 2.56277353e-01f, 1.98940828e-01f, -2.49276027e-01f, -1.50668100e-02f,
  -1.97181031e-01f, 3.45296552e-03f, -1.20216146e-01f, -3.06869112e-02f, -2.04382688e-02f, 7.54763884e-03f, -9.08941999e-02f, -5.02543636e-02f, -9.64431167e-02f, -7.34658539e-02f,
  1.96397617e-01f, 9.76579264e-02f, 4.75091785e-02f, 1.01831108e-01f, -4.76279929e-02f, -3.80431861e-02f, -1.11265145e-01f, -9.54251289e-02f, -3.26624140e-02f, -7.52786770e-02f,
  -1.33203000e-01f, -1.04188271e-01f, -2.47047432e-02f, 4.29102592e-03f, 1.92848705e-02f, 2.29455139e-02f, -5.61273098e-02f, 4.24044654e-02f, -6.75738901e-02f, -2.51356587e-02f,
  1.77402925e-02f, 7.63509702e-03f, -2.83905566e-02f, 9.08037871e-02f, -3.77675891e-02f, -4.38900478e-02f, 8.39334633e-03f, -4.19749059e-02f, -5.57333604e-03f, 4.70193736e-02f,
  9.53150354e-03f, 9.60754696e-03f, 8.29023644e-02f, -1.10692412e-01f, -1.01775274e-01f, 2.87386142e-02f, 7.16557801e-02f, -1.48262093e-02f, 3.13945562e-02f, 1.84262414e-02f,
  -5.02766808e-03f, -2.53792908e-02f, 1.32783344e-02f, 5.90428114e-02f, -7.14011863e-02f, 1.49983540e-01f, 5.55948578e-02f, -5.53223342e-02f, -3.99209596e-02f, 5.24280034e-02f,
  6.20507710e-02f, 1.20927095e-01f, 7.09175086e-03f, -1.57378055e-02f, 2.24735141e-02f, -9.26316157e-02f, -4.40884493e-02f, -1.02362372e-01f, -7.65818805e-02f, -3.84502932e-02f,
  -2.06033885e-02f, -2.49861204e-03f, 1.12143882e-01f, -5.86356185e-02f, 5.22737391e-02f, -1.12164877e-02f, 5.27354144e-02f, 1.32703975e-01f, 5.64290695e-02f, 5.70560023e-02f,
  1.33926332e-01f, 1.03065684e-01f, -1.29561285e-02f, 1.67683735e-02f, 1.05025247e-01f, -5.56531176e-02f, 1.43647596e-01f, -2.85492577e-02f, 1.14227138e-01f, 1.85251180e-02f,
  4.01061505e-01f, -2.36423120e-01f, -3.34841013e-01f, 3.12175155e-01f, 2.43700892e-01f, 4.88739520e-01f, 2.21827537e-01f, 2.62679100e-01f, 3.40379655e-01f, -6.37094527e-02f,
  1.51793569e-01f, -1.99137405e-01f, -2.78735369e-01f, 4.25667554e-01f, 3.44767392e-01f, -2.51326382e-01f, 3.04383188e-01f, 3.01290423e-01f, 1.04774110e-01f, 1.45576000e-01f,
  2.38984585e-01f, 4.04842198e-01f, -3.04692745e-01f, -4.42950167e-02f, 1.60843983e-01f, -1.77686155e-01f, -1.44914895e-01f, -3.36474091e-01f, 7.56367818e-02f, 1.18372561e-02f,
  5.73755354e-02f, 4.62141261e-02f, 9.48194042e-03f, -1.07982285e-01f, -4.54792380e-02f, -6.40738159e-02f, -3.17166559e-02f, -1.09604694e-01f, -4.87862591e-04f, -2.49315072e-02f,
  -1.11552678e-01f, 1.07926399e-01f, 1.28567457e-01f, -2.55333036e-02f, 1.03591206e-02f, -6.19461313e-02f, -1.61580078e-03f, -1.84046347e-02f, -1.09620072e-01f, -1.11956470e-01f,
  -1.29405662e-01f, -5.12503050e-02f, 3.48578952e-02f, -9.24966410e-02f, -4.76504527e-02f, 4.28458080e-02f, -1.20578423e-01f, -9.59557444e-02f, -8.72894228e-02f, 6.06710128e-02f,
  1.05907451e-02f, 4.84478362e-02f, 3.38656828e-02f, -5.38855791e-02f, 3.03292610e-02f, -1.53941591e-03f, 1.30992681e-01f, -7.08688051e-02f, 5.34324348e-02f, -1.14074033e-02f,
  -5.52993044e-02f, 1.31146878e-01f, 3.40548977e-02f, -1.77864339e-02f, 2.02907160e-01f, 1.18675210e-01f, -1.12807397e-02f, -1.34226587e-02f, 9.06952247e-02f, 4.45544869e-02f,
  1.31482035e-02f, -1.00997481e-02f, -2.67560733e-03f, -1.14866510e-01f, 3.19091417e-02f, -1.26449121e-02f, 9.79148448e-02f, 1.04654476e-01f, 2.66026091e-02f, 3.02268174e-02f,
  8.86757076e-02f, 3.98932360e-02f, -4.52194028e-02f, -3.38354781e-02f, -2.31970593e-01f, 1.03603661e-01f, -4.40577492e-02f, 9.48946401e-02f, -2.15614513e-02f, 1.54667040e-02f,
  1.35313869e-01f, 5.71578704e-02f, -3.64345834e-02f, 6.56444207e-02f, -2.58371774e-02f, 7.39538819e-02f, 3.68350297e-02f, -6.97816163e-02f, 1.06417323e-02f, 1.97913181e-02f,
  2.16367543e-02f, 3.54378037e-02f, -2.74543017e-02f, -8.12796038e-03f, 1.20233662e-01f, -6.92010596e-02f, 2.00391728e-02f, -2.90985871e-02f, -8.26360136e-02f, 2.49838224e-03f,
  6.59769177e-02f, 2.63645560e-01f, 3.45930904e-01f, 2.61997312e-01f, -3.51858348e-01f, -3.77634317e-02f, -1.36629164e-01f, -1.34989351e-01f, -1.41604066e-01f, -1.85502395e-01f,
  -5.50258160e-03f, 2.35248938e-01f, -4.96154338e-01f, 3.26288164e-01f, 3.25211585e-01f, -2.21746460e-01f, 3.56797993e-01f, 2.28820458e-01f, -7.48895928e-02f, 1.08938634e-01f,
  9.95743927e-03f, 1.07795503e-02f, 2.27747262e-01f, 2.20414728e-01f, 2.69218236e-01f, 3.44045699e-01f, 2.63686955e-01f, 1.24786772e-01f, 5.33851922e-01f, 1.78498626e-01f,
  7.16108689e-03f, 3.39858271e-02f, 4.88324985e-02f, 5.61663024e-02f, 4.43329290e-03f, 9.16953310e-02f, 1.25875831e-01f, 1.23613618e-01f, 3.67346616e-03f, 5.91804981e-02f,
  1.06823623e-01f, 5.05720749e-02f, 7.33460262e-02f, 3.55763324e-02f, 9.74047743e-03f, 8.08191895e-02f, -1.58406869e-02f, 3.69934291e-02f, 2.21557748e-02f, -9.91687179e-02f,
  3.48978378e-02f, -9.13856477e-02f, -4.30293679e-02f, 1.39700413e-01f, 5.93114272e-02f, 6.42049089e-02f, 1.47836536e-01f, 1.32124394e-01f, 1.69432729e-01f, 6.90978393e-02f,
  1.14039518e-01f, -1.31961718e-01f, -3.36267985e-02f, -2.20910497e-02f, 4.46334854e-02f, -3.31138894e-02f, -2.78131906e-02f, -4.12672162e-02f, 6.02964871e-02f, 1.21992216e-01f,
  -2.64786300e-03f, 6.41238093e-02f, -5.57503812e-02f, -4.10699360e-02f, 4.87778857e-02f, -5.57798985e-03f, 5.46227731e-02f, 8.61143172e-02f, 4.55254614e-02f, -7.36310473e-03f,
  -1.08077638e-01f, 3.27124335e-02f, -1.80743281e-02f, -6.30167499e-02f, -2.04495732e-02f, -4.97946367e-02f, 7.41563290e-02f, -2.72606150e-03f, -1.14241093e-01f, -1.29774258e-01f,
  1.34166822e-01f, 2.64560610e-01f, -7.08108917e-02f, 2.70441780e-03f, 8.58393237e-02f, 4.06830423e-02f, 1.53157348e-02f, 4.25846390e-02f, 2.25295424e-01f, 1.23042122e-01f,
  -6.81241229e-02f, 2.80579459e-02f, -4.38158102e-02f, -2.95091160e-02f, 1.29996866e-01f, 2.74329633e-02f, -5.20722754e-03f, -3.62451524e-02f, 3.82572711e-02f, 3.66947539e-02f,
  -3.39515656e-02f, -1.55096605e-01f, 1.51674211e-01f, -8.25724676e-02f, 3.09367813e-02f, 8.56813136e-03f, 1.20914048e-02f, 1.21945225e-01f, 1.72727592e-02f, 7.33292848e-02f,
  2.41869643e-01f, -7.28641450e-02f, -2.05936864e-01f, -1.21463418e-01f, -6.48698285e-02f, 1.49892166e-01f, 3.83437425e-01f, -1.62421376e-01f, -2.29236498e-01f, -3.56311421e-03f,
  2.36749411e-01f, -9.76510122e-02f, 3.73531371e-01f, 1.54401302e-01f, 1.93364888e-01f, 1.59642249e-01f, 1.50351733e-01f, -2.02867389e-02f, -2.54928619e-01f, 1.79696530e-01f,
  -7.02974051e-02f, 1.68379202e-01f, 2.60099620e-01f, -2.28164643e-01f, 2.38832161e-01f, -1.16681069e-01f, 3.27336878e-01f, 9.81629863e-02f, 6.01930358e-02f, 2.00566173e-01f,
  7.35535622e-02f, 9.53905433e-02f, -5.15000522e-02f, -1.44738883e-01f, 1.24637596e-01f, 1.12873383e-01f, 1.84302144e-02f, 1.78850919e-01f, -1.28738821e-01f, 7.96981230e-02f,
  1.09019674e-01f, -6.67466745e-02f, -8.47640932e-02f, 2.59894580e-02f, -1.54918954e-01f, -1.67991728e-01f, -2.15661868e-01f, 9.75689664e-03f, -1.54126078e-01f, 1.12096034e-01f,
  7.56770000e-02f, -9.37560275e-02f, 9.83019620e-02f, -9.82064903e-02f, 3.07760201e-02f, -3.35186236e-02f, -1.87980197e-02f, 8.46261308e-02f, -7.60106221e-02f, -6.90094894e-03f,
  1.17198624e-01f, 1.30771220e-01f, -4.38899398e-02f, -1.12567633e-01f, -5.29595576e-02f, -6.08141487e-03f, -6.57809824e-02f, 1.32943057e-02f, -6.71599954e-02f, 1.65773794e-01f,
  -9.26768482e-02f, -7.42749795e-02f, 1.85217857e-02f, 6.04788363e-02f, 7.08588436e-02f, 7.76979402e-02f, -2.52277013e-02f, 5.66516295e-02f, -1.44669581e-02f, -6.65766075e-02f,
  4.44401912e-02f, -3.41773704e-02f, 1.40226275e-01f, 8.86619240e-02f, 1.45998353e-03f, 1.31842971e-01f, -6.17641769e-03f, 9.94433686e-02f, -8.57642964e-02f, 6.66641518e-02f,
  1.04043461e-01f, 1.25613809e-01f, -1.77704915e-02f, -1.17056049e-01f, 9.13533121e-02f, 6.29126187e-03f, 3.98443975e-02f, -8.75643343e-02f, 1.66370664e-02f, 9.47456881e-02f,
  -5.76267205e-02f, -9.65259075e-02f, -1.14310816e-01f, -6.12486824e-02f, -5.37030725e-03f, 1.34991422e-01f, -1.17665410e-01f, -4.49113846e-02f, 1.16888441e-01f, -1.06952958e-01f,
  4.66544777e-02f, -3.70805226e-02f, 6.97247609e-02f, -1.06298365e-01f, -2.14978997e-02f, 1.67321131e-01f, -3.48295867e-02f, -1.20452261e-02f, -1.61235899e-01f, 3.31311040e-02f,
  -7.45751262e-01f, 3.18615943e-01f, 4.60343003e-01f, -3.80514145e-01f, -3.12828660e-01f, 4.11855996e-01f, 2.22390518e-01f, -3.06351408e-02f, -8.42211843e-02f, 1.98641136e-01f,
  -2.19235525e-01f, -5.50535508e-02f, 1.47743180e-01f, 1.30553260e-01f, -2.29875386e-01f, 2.70087391e-01f, 1.76548913e-01f, 3.44375670e-02f, 1.27406940e-01f, -3.57954353e-02f,
  -1.30537376e-01f, -2.47705668e-01f, 1.85944840e-01f, 4.40773293e-02f, 2.47132014e-02f, -1.17791168e-01f, -2.27280393e-01f, 8.07301402e-02f, 1.20876104e-01f, 5.18572815e-02f,
  -1.29616827e-01f, -3.20574939e-01f, 2.01829337e-02f, 1.46959245e-01f, 5.68262599e-02f, 3.75296772e-02f, 5.43670580e-02f, -3.95437963e-02f, -1.10703796e-01f, -9.53145772e-02f,
  -3.33062373e-02f, -5.30923195e-02f, -9.19874236e-02f, -2.41317414e-02f, 3.56967561e-02f, -2.24950872e-02f, 1.71620831e-01f, 9.28293616e-02f, -4.62498283e-03f, 8.42813328e-02f,
  8.84945914e-02f, 2.25910574e-01f, 1.66398317e-01f, 9.93607789e-02f, -5.83415814e-02f, 1.00169383e-01f, 7.21619055e-02f, 5.81078306e-02f, 6.22402281e-02f, 1.17688822e-02f,
  1.02499083e-01f, -9.23932791e-02f, -2.21795007e-03f, -8.74951556e-02f, -3.90318483e-02f, -1.07289150e-01f, 1.28132850e-02f, -1.47136047e-01f, -1.55229429e-02f, 7.07425773e-02f,
  -1.25322223e-01f, -2.28200350e-02f, -5.38066849e-02f, 8.27560723e-02f, -8.17295760e-02f, -9.59885642e-02f, 7.38656893e-02f, -3.66119593e-02f, 1.44310117e-01f, 1.15279004e-01f,
  -9.45803076e-02f, 6.60819635e-02f, -6.19771779e-02f, -7.69928610e-03f, 7.94532597e-02f, 6.61456510e-02f, 5.76566122e-02f, 3.13539505e-02f, 1.40283387e-02f, -7.39261732e-02f,
  -3.26555610e-01f, -3.18192214e-01f, 2.64022164e-02f, 3.35043743e-02f, 4.13555056e-02f, 2.10153218e-02f, 2.85204966e-02f, -6.14320114e-02f, -4.51890193e-02f, -3.63508500e-02f,
  -1.15243979e-02f, 1.04063883e-01f, 1.31539360e-01f, -4.90896143e-02f, 7.73699116e-03f, 5.50437830e-02f, -8.86263028e-02f, 2.37889942e-02f, -7.78173953e-02f, -3.86996754e-02f,
  -4.47773226e-02f, -6.59415200e-02f, -7.37214163e-02f, 1.12949638e-02f, 1.52752399e-02f, 6.45513786e-03f, -1.92847237e-01f, 7.96844214e-02f, -2.42601894e-02f, 1.36943832e-01f,
  -3.75557750e-01f, 1.14300223e-02f, -6.52408525e-02f, 1.12659976e-01f, -1.55556574e-01f, 3.90736550e-01f, 2.77397871e-01f, 1.33312002e-01f, 1.44370601e-01f, 2.90281117e-01f,
  2.81663895e-01f, -1.93842590e-01f, 2.62941360e-01f, 2.53858656e-01f, 1.89137608e-01f, 2.58238703e-01f, 2.59384006e-01f, 1.98572040e-01f, -1.28365248e-01f, -1.75513044e-01f,
  -1.03842601e-01f, 1.85736656e-01f, 2.17307866e-01f, -3.31956178e-01f, -2.81519257e-02f, -4.11207408e-01f, -6.05069275e-04f, -2.99073219e-01f, 7.81347007e-02f, -4.65806574e-03f,
  -1.13158174e-01f, -1.69366419e-01f, 4.96880524e-02f, 1.93707657e-03f, -2.30101757e-02f, -4.50245216e-02f, -2.79303212e-02f, -6.92735612e-02f, -1.10213161e-01f, -4.27507944e-02f,
  -1.06800064e-01f, -1.40218630e-01f, -4.88090031e-02f, -7.88451731e-02f, -1.17725529e-01f, 3.00392378e-02f, 9.34016779e-02f, 1.87384427e-01f, 1.04419552e-01f, 1.63855795e-02f,
  7.53676072e-02f, -4.09412757e-02f, 1.19789116e-01f, 1.98672041e-02f, 1.38857976e-01f, 1.06523767e-01f, 1.28632307e-01f, -2.42996346e-02f, 5.18835336e-02f, 4.28729020e-02f,
  5.57417944e-02f, -1.37250170e-01f, 9.44671407e-02f, -1.07793234e-01f, 9.68023166e-02f, 4.29111645e-02f, 3.72334123e-02f, 1.18683197e-01f, -3.62885818e-02f, 1.86319903e-01f,
  3.13698314e-02f, 2.79187690e-02f, 2.89843380e-02f, 1.20409556e-01f, -1.02932993e-02f, 1.25959013e-02f, -2.15377938e-03f, -7.29579106e-03f, 6.30160840e-03f, 6.44156113e-02f,
  1.15808612e-02f, 2.62318514e-02f, 7.89786205e-02f, -1.01353817e-01f, -5.85514046e-02f, -7.16354698e-02f, -2.53536459e-02f, 1.37590453e-01f, 1.15823425e-01f, -5.31859621e-02f,
  -5.99607490e-02f, -3.39555144e-01f, -4.33787294e-02f, -4.52454016e-02f, -1.11841939e-01f, -7.21543729e-02f, -3.53499688e-02f, -4.01380435e-02f, -3.25234011e-02f, 8.31895024e-02f,
  -8.37652907e-02f, -3.53593603e-02f, -1.23114936e-01f, -4.68366034e-02f, 2.38431692e-02f, 5.43634444e-02f, -1.37512833e-01f, 2.33225129e-03f, 1.27748474e-01f, -1.04431674e-01f,
  6.81724027e-02f, 3.30079533e-02f, 3.95605229e-02f, -7.67217018e-03f, -2.48873737e-02f, 6.57484680e-02f, -1.03719734e-01f, -7.15013444e-02f, -1.84732266e-02f, 1.21646628e-01f,
  5.98390065e-02f, 9.98920426e-02f, -3.65572751e-01f, -1.11965351e-01f, -2.40392849e-01f, 3.77639592e-01f, 4.07110184e-01f, -1.82614878e-01f, -1.33364633e-01f, 2.92658597e-01f,
  2.63241947e-01f, -1.72161385e-01f, 2.63197452e-01f, 2.79843152e-01f, -1.63448751e-02f, 2.64384419e-01f, 3.36432487e-01f, 2.16271356e-01f, -1.81225643e-01f, 4.58834842e-02f,
  -1.87470078e-01f, 3.49160284e-01f, -1.20547637e-01f, 1.98831614e-02f, 1.37418643e-01f, -2.42054105e-01f, -1.07134515e-02f, -2.99437732e-01f, -5.55486530e-02f, -9.70467478e-02f,
  7.43120015e-02f, -2.64586378e-02f, -6.93769604e-02f, -2.10170373e-02f, 1.09217718e-01f, -3.83809977e-03f, 7.60642290e-02f, -7.77218863e-02f, -1.09835401e-01f, -3.27133536e-02f,
  1.38458103e-01f, -6.72478303e-02f, 6.58758953e-02f, -1.85819119e-01f, -2.23367065e-02f, -8.93877074e-02f, -2.47966480e-02f, 1.86023079e-02f, -1.38823688e-01f, 8.11645947e-03f,
  -8.07043612e-02f, -2.13468466e-02f, 1.78746469e-02f, 1.05899908e-01f, -6.83464780e-02f, -3.74952815e-02f, 2.26716250e-02f, 3.07123475e-02f, -2.40338724e-02f, 2.27153879e-02f,
  -2.38019954e-02f, 2.84163672e-02f, 1.97212294e-01f, 6.81315139e-02f, -3.92607749e-02f, -1.45683214e-02f, 1.94114074e-02f, -1.64291374e-02f, -1.81242041e-02f, -1.76606106e-03f,
  -6.16149083e-02f, -7.32194781e-02f, 9.72645134e-02f, 9.67238694e-02f, -7.63328299e-02f, 5.30467853e-02f, 6.68273345e-02f, -1.10807002e-01f, 4.20077741e-02f, -8.36980529e-03f,
  2.36156955e-02f, 2.69558243e-02f, 7.02749118e-02f, -2.02265196e-02f, 4.79263999e-02f, 3.55345830e-02f, 6.44604862e-02f, 2.42102053e-02f, 5.95099898e-03f, 3.85275036e-02f,
  1.28310800e-01f, -3.95743828e-03f, 1.86435767e-02f, 3.55276503e-02f, -6.92460388e-02f, 1.16916791e-01f, -6.13444634e-02f, -5.83898276e-02f, -3.09649277e-02f, 1.34438258e-02f,
  3.17103378e-02f, 1.90171059e-02f, 1.52276680e-01f, -6.28446490e-02f, -5.14122583e-02f, 4.74146791e-02f, 1.60670087e-01f, -6.65189400e-02f, -3.89028005e-02f, -1.16548002e-01f,
  6.38035387e-02f, 1.41669542e-01f, -1.45179676e-02f, 1.05763860e-01f, -5.07667987e-03f, 4.81345877e-02f, 3.11170388e-02f, -4.05045738e-03f, 1.58823971e-02f, 2.05618218e-02f,
  -4.87089604e-01f, 3.67049426e-01f, -1.30181566e-01f, -2.21269608e-01f, 1.46559700e-01f, -2.37933323e-01f, -3.19602527e-02f, 1.19810931e-01f, -1.44938812e-01f, 3.97479653e-01f,
  -7.05854297e-02f, 3.98659892e-02f, -5.76581061e-02f, -2.08935067e-01f, -5.05216300e-01f, -2.82175958e-01f, -4.08583313e-01f, -1.82478845e-01f, -1.46551013e-01f, -1.05814457e-01f,
  -2.87941843e-01f, -1.98404819e-01f, -2.67129928e-01f, 2.02121437e-01f, 1.77263603e-01f, 1.33546308e-01f, -2.56116204e-02f, 2.64095098e-01f, 5.89722507e-02f, 4.96266352e-04f,
  7.03081721e-04f, 1.39656842e-01f, 1.32434949e-01f, 1.28701320e-02f, -7.66025037e-02f, 1.30918166e-02f, 2.87392922e-02f, -9.61269736e-02f, -4.67064977e-02f, -1.64166391e-01f,
  3.01386602e-02f, -8.43296126e-02f, -8.69887918e-02f, 6.05030358e-02f, 7.72442594e-02f, 6.34210855e-02f, 4.65800278e-02f, -6.52818941e-03f, 5.23201860e-02f, -2.42699124e-03f,
  -3.70804705e-02f, -1.78188104e-02f, -5.67506114e-03f, -8.25492591e-02f, -6.88204020e-02f, -4.99833189e-02f, -1.14121355e-01f, 3.56574692e-02f, -1.04428129e-02f, -9.07654315e-02f,
  -4.75913249e-02f, -8.64652991e-02f, 1.01136575e-02f, -2.46952586e-02f, 5.96308615e-03f, 2.39268620e-03f, -2.99533941e-02f, 3.95666845e-02f, 8.46965536e-02f, -3.87080642e-03f,
  7.61200953e-03f, -7.46200755e-02f, -2.06744438e-03f, -8.49804878e-02f, -6.42664358e-02f, 5.06869145e-02f, 5.81635162e-03f, 6.30169511e-02f, -1.90102175e-01f, 6.31673485e-02f,
  7.95583129e-02f, -3.59645411e-02f, 2.92928368e-02f, 5.46578094e-02f, -4.77837548e-02f, 3.87828313e-02f, 6.48562759e-02f, -7.41442083e-04f, 6.66604517e-03f, 1.29381837e-02f,
  -1.05065294e-01f, 6.90501407e-02f, 1.00797825e-01f, 1.62092894e-01f, -2.84283794e-02f, -3.52085126e-03f, 7.45845214e-02f, 9.44106281e-03f, 2.50720512e-02f, -3.37098576e-02f,
  -6.94957972e-02f, -4.03236672e-02f, -2.21770797e-02f, -1.64322108e-02f, -2.88721323e-02f, -1.02424078e-01f, 7.84254400e-04f, 5.63446954e-02f, -1.05073368e-02f, -5.36832400e-02f,
  9.85362101e-03f, -1.08735133e-02f, -5.84042072e-02f, 7.98636973e-02f, 3.90071012e-02f, 1.32768437e-01f, 1.34249613e-01f, 6.72968999e-02f, 5.67452312e-02f, 6.75949967e-04f,
  1.97293326e-01f, 2.94595927e-01f, 1.07355393e-01f, -2.80820727e-01f, -1.70431599e-01f, 1.13850301e-02f, -1.32918686e-01f, 1.39193371e-01f, -2.06094772e-01f, 1.21961400e-01f,
  1.70628086e-01f, -1.43348634e-01f, 2.63610065e-01f, 1.67926073e-01f, -3.70216779e-02f, 5.20876087e-02f, 2.77009606e-01f, 2.29324639e-01f, 2.32358146e-02f, 3.11466873e-01f,
  9.93301049e-02f, 1.33547917e-01f, 2.78011680e-01f, 3.44106466e-01f, 2.53787577e-01f, 2.43652061e-01f, 1.75244644e-01f, 1.40229106e-01f, 2.93349475e-01f, -5.55373728e-03f,
  1.27186477e-01f, 3.87581848e-02f, 7.19411224e-02f, -1.99999511e-02f, 2.17074323e-02f, -1.76769178e-02f, -1.21115506e-01f, 1.50485292e-01f, -4.30374499e-03f, 5.87082654e-03f,
  -7.92780817e-02f, -5.81015088e-02f, -1.48432227e-02f, -1.32337034e-01f, 1.00402668e-01f, -3.29380408e-02f, 1.19689174e-01f, 1.03115350e-01f, -5.31575345e-02f, 1.54727697e-01f,
  -4.92531573e-03f, 5.20544127e-02f, 1.48312803e-02f, -2.71752197e-02f, -1.77921310e-01f, -2.05348372e-01f, -1.49356917e-01f, 6.65170029e-02f, 3.78291830e-02f, -2.42122505e-02f,
  3.07705700e-02f, 3.21352929e-02f, 8.61745998e-02f, -6.29116818e-02f, -1.55280367e-01f, -4.57949787e-02f, 5.77049144e-02f, 9.52254534e-02f, -5.16453683e-02f, -2.01167062e-01f,
  2.00385954e-02f, -1.48184854e-03f, 6.39778737e-04f, -6.17554225e-03f, -3.47164124e-02f, -4.87204865e-02f, -4.27600704e-02f, -4.36367057e-02f, 2.54850257e-02f, -1.07277796e-01f,
  -6.04097694e-02f, -3.89287919e-02f, -1.46548390e-01f, 6.29169196e-02f, -3.10179181e-02f, -1.40313432e-01f, -7.18246074e-03f, -4.53130864e-02f, 1.21975720e-01f, 1.19034369e-02f,
  9.95633379e-02f, 1.55808136e-01f, -8.71620234e-03f, -1.04624890e-01f, 3.32981423e-02f, -5.95770637e-03f, -1.76955432e-01f, 8.31757188e-02f, 3.23173739e-02f, -6.51637539e-02f,
  -5.91063462e-02f, -4.76543233e-02f, 5.11691347e-02f, 2.16032546e-02f, 6.97090814e-04f, 1.10604661e-02f, 9.25698951e-02f, -2.21580952e-01f, -1.89604580e-01f, 4.99268956e-02f,
  -6.64180070e-02f, -2.76980065e-02f, -1.42361447e-01f, -7.70102888e-02f, -1.66933667e-02f, -1.64483696e-01f, -6.00134432e-02f, -1.01680728e-02f, 8.03670064e-02f, -8.20772126e-02f,
  -2.19361007e-01f, -3.25131953e-01f, 3.83640546e-03f, -3.09759438e-01f, 2.95265913e-01f, 1.56588390e-01f, 2.79100269e-01f, -1.37895957e-01f, -3.28610897e-01f, -1.54879406e-01f,
  4.09366190e-02f, -1.96098641e-01f, 3.04750174e-01f, -4.45165128e-01f, 1.85598046e-01f, -1.55996621e-01f, -3.25518996e-01f, -1.55672729e-01f, -2.54526854e-01f, -7.14966878e-02f,
  -1.36065096e-01f, -2.55915731e-01f, -5.59093617e-02f, -2.24537626e-01f, -2.14811474e-01f, -1.07335091e-01f, 1.39468476e-01f, 3.05413574e-01f, -1.29699454e-01f, 5.22047319e-02f,
  -1.63048759e-01f, -8.71136412e-02f, 8.69456157e-02f, -1.70284271e-01f, 1.29726008e-01f, 1.65348664e-01f, 8.62447694e-02f, 1.73105612e-01f, 6.12337254e-02f, -7.78561532e-02f,
  6.60490841e-02f, 3.37993004e-03f, -2.25831553e-01f, -1.73413905e-03f, -9.32835191e-02f, -3.20251286e-02f, 1.01604313e-02f, -1.79401301e-02f, 1.13578886e-02f, -5.79690300e-02f,
  3.66886742e-02f, -1.49706025e-02f, -1.24347761e-01f, -5.84403612e-02f, 5.46385907e-02f, -7.03861043e-02f, 4.00737785e-02f, 9.13972706e-02f, -7.43885711e-02f, 4.33660336e-02f,
  -3.96924559e-03f, 1.04502644e-02f, 1.64440572e-02f, -7.62656257e-02f, 8.83079367e-04f, -6.20794185e-02f, 6.47420213e-02f, 6.84087798e-02f, -3.58660743e-02f, 1.25616025e-02f,
  3.48170176e-02f, 6.52093291e-02f, -4.79574725e-02f, -2.56458055e-02f, 3.94289680e-02f, -4.40832414e-02f, 6.12057634e-02f, -4.94150519e-02f, 9.17810202e-02f, -1.67056918e-02f,
  -3.09577547e-02f, -9.91658196e-02f, 1.20161645e-01f, -9.04318392e-02f, 1.72435101e-02f, 1.09057903e-01f, -1.78539902e-02f, 1.05292890e-02f, -1.09837413e-01f, 7.10206293e-03f,
  9.52104330e-02f, -1.08111143e-01f, 2.96736360e-02f, -6.18697703e-02f, 1.12636209e-01f, 8.43161792e-02f, -1.62525937e-01f, -1.16866156e-01f, 2.49594040e-02f, 2.06211600e-02f,
  -2.42309812e-02f, 2.76849139e-02f, 1.12343030e-02f, 1.08988494e-01f, 7.85486475e-02f, 7.48168975e-02f, 4.15882245e-02f, 1.46341696e-01f, -1.44304475e-03f, -1.69494620e-03f,
  -4.61308062e-02f, -1.19684793e-01f, -8.74761939e-02f, -3.79703157e-02f, 6.30977154e-02f, 3.22716497e-02f, -1.76996309e-02f, 1.63477417e-02f, 6.42152280e-02f, -8.55759904e-02f,
  -2.21772134e-01f, -1.68212831e-01f, 1.62665229e-02f, 1.23399630e-01f, 2.01960087e-01f, -1.02212809e-01f, -4.14036274e-01f, 1.67466909e-01f, -1.03560068e-01f, -3.31690580e-01f,
  -1.41421705e-01f, -2.06114754e-01f, -2.24859893e-01f, 2.97403961e-01f, 2.27940336e-01f, -2.16236234e-01f, 4.33173090e-01f, 1.42723024e-01f, 2.29266554e-01f, 2.40538359e-01f,
  3.45748097e-01f, 3.32950264e-01f, 2.84098774e-01f, 3.93288463e-01f, 1.83471352e-01f, 1.44919857e-01f, 1.41912922e-01f, 8.86560306e-02f, 2.35361755e-01f, 1.94334164e-01f,
  -1.15005597e-01f, -4.42375466e-02f, 7.12566124e-03f, -1.21414252e-02f, -2.82194149e-02f, -1.15813397e-01f, -8.93863663e-02f, -6.60992190e-02f, 5.17355427e-02f, -4.87684570e-02f,
  -9.12545025e-02f, 1.37261450e-01f, 1.13406047e-01f, 5.72603603e-04f, -1.04858071e-01f, 7.87543356e-02f, 6.52073845e-02f, 3.20849977e-02f, -3.23523432e-02f, -2.04533362e-03f,
  3.83313522e-02f, 1.01586938e-01f, -1.09991774e-01f, 6.87559918e-02f, 6.71747476e-02f, 5.02957515e-02f, 4.50565442e-02f, -9.15179402e-02f, -2.53658816e-02f, 9.88384560e-02f,
  -9.94842574e-02f, 1.02373898e-01f, -6.52401149e-02f, -1.78645793e-02f, -3.20105031e-02f, 7.37318322e-02f, 1.22582605e-02f, -2.26178393e-02f, 7.10860500e-03f, 7.56785832e-03f,
  6.89248890e-02f, -1.28240250e-02f, 2.74059623e-02f, 6.81534410e-02f, 5.67369759e-02f, 9.35192183e-02f, -1.05968891e-02f, 4.96940129e-02f, 3.91804762e-02f, -2.92456299e-02f,
  -2.15384401e-02f, 4.66589928e-02f, 7.47270416e-03f, -2.99415342e-03f, 6.54408261e-02f, -5.47795370e-03f, -7.36741647e-02f, -9.28958878e-02f, -6.88062385e-02f, 1.32279634e-01f,
  -8.70629176e-02f, 8.30620229e-02f, 3.14729847e-02f, 1.38827590e-02f, 6.64314553e-02f, 3.51988375e-02f, 1.09783158e-01f, 3.00193820e-02f, 3.20743322e-02f, -3.04783601e-02f,
  -2.59493152e-03f, -2.53814980e-02f, -1.45138562e-01f, -2.13981532e-02f, 1.68749139e-01f, -8.63200277e-02f, 1.91367529e-02f, 2.47910414e-02f, 4.49543595e-02f, 1.84456334e-01f,
  9.33203921e-02f, -6.48132758e-03f, 5.19854687e-02f, 3.56258824e-02f, 4.53785583e-02f, -1.12037256e-01f, -1.17194444e-01f, 1.06694959e-01f, 4.35791239e-02f, 4.00273763e-02f,
  2.82145649e-01f, -4.39925969e-01f, -4.10091013e-01f, 8.24718922e-02f, 2.77549207e-01f, 3.54369968e-01f, 2.47380748e-01f, 4.14107032e-02f, -2.26025164e-01f, -4.16152328e-02f,
  4.36727554e-01f, 3.07123333e-01f, 1.51299126e-02f, 2.75503993e-01f, 4.20418888e-01f, -8.76732990e-02f, 6.83290586e-02f, 1.26148775e-01f, -1.88471869e-01f, -1.40361115e-01f,
  -1.19039170e-01f, 2.67445564e-01f, 3.60342092e-03f, -7.21175894e-02f, 2.48149350e-01f, -1.14565872e-01f, 1.86671898e-01f, 4.31859456e-02f, 2.15280086e-01f, 3.98521572e-01f,
  2.25978717e-01f, -2.43286014e-01f, -2.15480453e-03f, -1.12654284e-01f, -1.32796839e-02f, -5.45271523e-02f, -6.26323670e-02f, 2.21847102e-01f, 4.56419513e-02f, -8.92274529e-02f,
  1.54012829e-01f, -1.20642141e-01f, 6.61455244e-02f, 2.53618378e-02f, -1.69786975e-01f, 9.33805946e-03f, -8.12703837e-03f, 1.09837845e-01f, -2.06396446e-01f, -3.90262268e-02f,
  -9.51985940e-02f, 3.88699621e-02f, 6.52855113e-02f, 1.26240775e-01f, 3.61148156e-02f, -9.41934288e-02f, -7.24347234e-02f, -1.43062521e-03f, -1.03456169e-01f, -1.25312909e-01f,
  4.94866744e-02f, 1.03248199e-02f, -4.78717238e-02f, 7.25256652e-02f, -9.33402404e-02f, 3.10055865e-03f, -4.47216555e-02f, 5.98516874e-02f, 5.64201809e-02f, -1.19440645e-01f,
  -1.42224923e-01f, -9.47688594e-02f, 7.92435259e-02f, -5.77704720e-02f, -2.85634752e-02f, -1.27622783e-02f, 4.11398448e-02f, 7.67652467e-02f, -9.27463844e-02f, 5.04912771e-02f,
  -2.92336252e-02f, -6.00528903e-02f, -7.23329233e-03f, 3.63618247e-02f, 5.01548983e-02f, 6.63702860e-02f, 4.20972109e-02f, -1.38586447e-01f, 6.95484430e-02f, 3.37515250e-02f,
  -2.24194869e-01f, -4.35148865e-01f, -2.95629986e-02f, 5.97925186e-02f, -2.04950739e-02f, -4.93522771e-02f, 5.55523438e-03f, -3.38755511e-02f, -1.65219791e-02f, -1.71175614e-01f,
  -3.03986147e-02f, -3.99038903e-02f, -1.32593224e-02f, 3.32739688e-02f, 3.34840305e-02f, 8.04959759e-02f, 1.32964086e-03f, -7.18259485e-03f, 8.09896439e-02f, -2.40318011e-02f,
  -7.60794133e-02f, -1.18615814e-01f, 1.42252192e-01f, -6.88355640e-02f, 4.16296981e-02f, 6.71578869e-02f, 7.24826157e-02f, 8.25891122e-02f, 7.07882717e-02f, 6.34061247e-02f,
  -6.44341052e-01f, 4.32592213e-01f, -1.50440857e-01f, -1.96266577e-01f, 1.47355437e-01f, -2.11056724e-01f, 9.26345363e-02f, -4.25196365e-02f, -6.99603036e-02f, 1.94485307e-01f,
  2.45223090e-01f, 8.48526657e-02f, 2.66917139e-01f, 2.79016066e-02f, -2.56791562e-01f, -1.06839180e-01f, -1.95215136e-01f, -2.01637760e-01f, -6.94716796e-02f, -2.40886174e-02f,
  -1.60383523e-01f, 1.20789327e-01f, -1.68541059e-01f, 2.46013939e-01f, 6.78232461e-02f, -8.32589790e-02f, -2.73904968e-02f, 1.07668228e-01f, 1.44035339e-01f, 1.30833492e-01f,
  -2.39717469e-01f, -2.78020781e-02f, 6.84353262e-02f, -1.79668084e-01f, -1.52235478e-01f, -3.45767625e-02f, -1.16816722e-01f, 2.81198602e-02f, -1.11541659e-01f, -7.96881914e-02f,
  -2.28026584e-02f, 2.07853988e-02f, -6.03966750e-02f, 9.27265326e-04f, -7.43829273e-03f, 4.42471216e-03f, -1.34865902e-02f, 4.06946056e-02f, 6.27531409e-02f, -1.09056197e-01f,
  8.05584434e-03f, -1.61952712e-02f, -8.84021297e-02f, -8.43507499e-02f, 3.31372730e-02f, 6.48930371e-02f, -8.51740390e-02f, 6.93864003e-02f, -4.44132425e-02f, -1.80696808e-02f,
  2.27783881e-02f, -9.78096798e-02f, 9.32311341e-02f, -2.21189950e-02f, 1.14421584e-01f, 1.22975253e-01f, -2.52801813e-02f, 4.61513810e-02f, 1.07414015e-01f, 6.39275163e-02f,
  2.79100798e-02f, 8.63590017e-02f, 5.60284108e-02f, -2.07082734e-01f, -3.87892425e-02f, -1.01676486e-01f, 5.63743245e-03f, -4.45718598e-03f, 6.31080270e-02f, -1.30281761e-01f,
  -5.04062977e-03f, -4.57136184e-02f, 1.64351419e-01f, 1.75974611e-02f, -7.71486163e-02f, 3.53532322e-02f, 6.99487627e-02f, 6.85585942e-03f, 2.84921704e-03f, -2.33873986e-02f,
  -4.00172144e-01f, -2.07368702e-01f, -7.45081529e-02f, 5.56990430e-02f, 1.34283286e-02f, -4.59953435e-02f, -6.44135699e-02f, -2.73249317e-02f, -1.51265994e-01f, -1.37278840e-01f,
  -1.86652452e-01f, -1.16146520e-01f, -9.29748937e-02f, -3.55228484e-02f, -7.94341192e-02f, 1.85163468e-02f, 4.27425653e-02f, -7.57565303e-03f, -6.50333688e-02f, -9.73072127e-02f,
  -1.63152441e-02f, -1.98499206e-02f, -4.83605340e-02f, 7.80690610e-02f, -1.08344235e-01f, 1.09415911e-01f, -8.71021301e-02f, 4.48999368e-02f, -9.06086266e-02f, -3.03510111e-03f,
  -1.50902450e-01f, 2.31273592e-01f, -8.23743418e-02f, -1.71383560e-01f, 5.32564707e-02f, -1.76095665e-02f, -2.18049005e-01f, 1.48202777e-01f, 2.48689756e-01f, -1.26385853e-01f,
  -1.13320209e-01f, -1.46237999e-01f, 6.80122599e-02f, -1.47337526e-01f, -1.64344326e-01f, 1.20139703e-01f, -1.94849268e-01f, -1.78962067e-01f, 2.39884511e-01f, -1.79598659e-01f,
  -2.75249053e-02f, -3.96192580e-01f, -1.76522136e-01f, -2.87071526e-01f, -1.97332248e-01f, -1.10604176e-02f, -1.57918721e-01f, 1.82794016e-02f, -2.69371003e-01f, 3.49203460e-02f,
  6.42666817e-02f, 1.43176347e-01f, -9.58480537e-02f, -1.30294841e-02f, -4.15852331e-02f, 1.80731174e-02f, -5.54046370e-02f, -1.57986403e-01f, -2.94521879e-02f, -3.34539823e-02f,
  -1.76155537e-01f, -1.43630087e-01f, 5.37261553e-02f, -1.96525350e-01f, -1.17230892e-01f, -2.22779527e-01f, 5.46784746e-03f, 1.20041780e-02f, -2.71578152e-02f, -1.21987700e-01f,
  -2.14847594e-01f, 8.30899924e-03f, 1.38836503e-01f, -4.04449217e-02f, 4.32771556e-02f, -1.86051521e-02f, 1.08157314e-01f, 1.57001652e-02f, -1.38121590e-01f, 2.06723779e-01f,
  1.96015779e-02f, 9.56824943e-02f, -1.49616197e-01f, 4.14884202e-02f, -1.16893180e-01f, -2.37776991e-02f, -1.15009025e-02f, 9.46491584e-02f, 4.58701141e-02f, 8.49988032e-03f,
  1.21387579e-01f, 1.85216859e-01f, 4.44572568e-02f, -8.89623165e-02f, 7.38703236e-02f, -4.51641865e-02f, -1.47761554e-01f, 1.10829305e-02f, 6.49697632e-02f, -6.16965555e-02f,
  -1.85146943e-01f, -3.72607633e-02f, 5.73126972e-02f, 4.42018956e-02f, -3.16484198e-02f, 4.19212542e-02f, -9.84227434e-02f, -2.01608941e-01f, 3.01719550e-02f, 2.33102404e-02f,
  1.23796679e-01f, 9.34664086e-02f, 1.30953029e-01f, 7.17973337e-02f, 1.00430638e-01f, -2.68903486e-02f, -2.70267241e-02f, 3.20929289e-02f, 9.54236537e-02f, -9.11785737e-02f,
  -9.19091776e-02f, -6.36521056e-02f, 2.49149337e-01f, -5.27540557e-02f, -6.25912920e-02f, -1.79757193e-01f, 2.42643878e-02f, 2.26183742e-01f, 1.20505661e-01f, 5.03745079e-02f,
  -2.00013071e-01f, 2.96293441e-02f, 6.66131899e-02f, 1.32654915e-02f, -8.98437798e-02f, 3.45366867e-03f, -1.62373297e-02f, -1.13750346e-01f, 3.84941585e-02f, 1.89857185e-01f,
  -1.52702257e-01f, -3.74215484e-01f, -3.06230962e-01f, 2.24193692e-01f, 3.08745772e-01f, -4.85499352e-02f, -8.37687775e-02f, 1.50178775e-01f, 6.71065897e-02f, 2.91531365e-02f,
  -1.00630568e-02f, -3.27584594e-01f, -3.16645473e-01f, -2.51751244e-01f, -2.84989744e-01f, -3.55537772e-01f, -1.05298065e-01f, -1.94770873e-01f, -1.02095075e-01f, -1.27708450e-01f,
  -6.68361485e-02f, 9.96533930e-02f, -1.49704576e-01f, 3.29482406e-01f, 1.43501595e-01f, 2.04896495e-01f, 2.18711451e-01f, 1.87219426e-01f, 1.59104943e-01f, -6.36841357e-02f,
  -7.83016905e-02f, -1.29143253e-01f, -7.56041482e-02f, 7.77233690e-02f, 2.04136204e-02f, 9.69207138e-02f, 3.34662311e-02f, -4.74587865e-02f, 7.68177211e-02f, 6.22240119e-02f,
  -1.07239328e-01f, 1.02109067e-01f, 8.26227441e-02f, 1.33254260e-01f, 1.04880795e-01f, 8.32005441e-02f, -7.96409175e-02f, -1.16020463e-01f, 1.19047262e-01f, -1.67703763e-01f,
  -1.35758877e-01f, -6.62519261e-02f, -9.79068950e-02f, -3.15580592e-02f, -1.45690158e-01f, -1.38390094e-01f, 3.92532311e-02f, -1.55511662e-01f, 5.12217097e-02f, -1.04873076e-01f,
  -8.63835737e-02f, -7.01164231e-02f, -5.88127486e-02f, 6.16364703e-02f, 8.55752174e-03f, 1.25242963e-01f, 3.17243263e-02f, -1.95858944e-02f, 6.72002062e-02f, 2.47630775e-02f,
  1.67938605e-01f, 6.15181401e-02f, 1.32420570e-01f, 1.54492155e-01f, -6.89781755e-02f, -3.35476659e-02f, -4.54894453e-02f, 2.15663798e-02f, 4.71262261e-02f, 3.82993952e-04f,
  7.60481209e-02f, -1.16652613e-04f, -1.32006463e-02f, 6.77662194e-02f, -5.65505251e-02f, -4.50379476e-02f, 6.03590021e-03f, -5.62162027e-02f, -5.72549850e-02f, -1.19969090e-02f,
  4.70169522e-02f, -2.24148780e-01f, -5.56518696e-02f, 7.92865455e-02f, 6.03915472e-03f, 5.75170182e-02f, -1.26599088e-01f, 5.77641055e-02f, -3.20010707e-02f, -5.53927338e-03f,
  -8.68465975e-02f, 1.36445940e-01f, 3.58194187e-02f, 3.45256478e-02f, 5.18625490e-02f, -1.02331050e-01f, -7.94918612e-02f, 6.02265447e-02f, 6.11838475e-02f, -1.95244532e-02f,
  9.71430168e-03f, 9.00912657e-03f, 8.10889602e-02f, 2.40525883e-02f, 1.16166048e-01f, -5.04835360e-02f, -6.80714324e-02f, 3.19014937e-02f, 1.79327391e-02f, 5.25907837e-02f,
  -3.68307412e-01f, 2.79983461e-01f, -1.97790727e-01f, -1.75235868e-02f, 4.73422334e-02f, -6.77905083e-01f, -1.90414235e-01f, 1.75935134e-01f, 1.06378041e-01f, 1.59358710e-01f,
  1.74227208e-01f, -4.57812622e-02f, 3.44891667e-01f, -1.89790130e-01f, -3.21396321e-01f, -2.86027007e-02f, -3.61539751e-01f, -3.65651965e-01f, 6.75757527e-02f, -2.02836059e-02f,
  -3.87370959e-02f, 2.54629612e-01f, -1.12960957e-01f, 3.13628852e-01f, 8.25485401e-03f, 2.39758581e-01f, 3.20312709e-01f, 2.51225471e-01f, -2.15336531e-01f, 5.40453196e-02f,
  -1.91368282e-01f, 3.40491533e-01f, 1.26157299e-01f, -1.47319154e-03f, -9.38860476e-02f, -5.37567772e-03f, -1.40421554e-01f, 3.36170159e-02f, -8.24560411e-03f, 8.68221093e-03f,
  2.53948718e-02f, 8.88151601e-02f, -1.53547740e-02f, 1.31452233e-01f, 2.46503241e-02f, -3.08427904e-02f, 5.26440777e-02f, -1.87678948e-01f, 1.06570823e-02f, -1.48767784e-01f,
  2.36764755e-02f, -1.44196808e-01f, -4.23647463e-02f, 5.22775687e-02f, 5.63723929e-02f, -1.48467291e-02f, -1.84629098e-01f, -1.27372630e-02f, -1.26131549e-01f, -3.61212604e-02f,
  6.33555576e-02f, -1.12170629e-01f, 5.52571081e-02f, 1.33887321e-01f, -4.80538569e-02f, 8.14462975e-02f, 1.09341703e-01f, -1.62536781e-02f, -2.21674666e-02f, -8.98137242e-02f,
  -3.12328786e-02f, -6.14941586e-04f, 4.76684468e-03f, -2.08659433e-02f, -2.19065342e-02f, 1.53485179e-01f, -6.14439286e-02f, -5.93552366e-02f, -7.06413984e-02f, -8.07144046e-02f,
  1.19570039e-01f, -6.14980571e-02f, 9.89554971e-02f, -8.09700564e-02f, -1.19560190e-01f, 1.71029180e-01f, -2.81050261e-02f, -1.47943258e-01f, -3.44275609e-02f, -2.58019473e-02f,
  -3.04115936e-02f, 2.82360464e-01f, 1.57710999e-01f, 4.11146097e-02f, -4.83296514e-02f, -4.63401563e-02f, -1.00285418e-01f, 1.24597549e-02f, 1.30735978e-01f, -1.10080037e-02f,
  -7.47695193e-02f, 3.66995484e-02f, -8.43423828e-02f, 4.83732037e-02f, -1.05501553e-02f, 1.83818955e-02f, 8.64421427e-02f, 7.16699138e-02f, 1.02854483e-01f, 8.54660571e-03f,
  6.65796399e-02f, -1.83815304e-02f, 1.73745323e-02f, 1.10182464e-01f, -6.40659481e-02f, 9.16450024e-02f, -8.29760805e-02f, 4.03684042e-02f, -4.01265398e-02f, 3.54698710e-02f,
  2.02001065e-01f, 2.85969824e-01f, 1.14066683e-01f, 1.50397584e-01f, -1.32364497e-01f, 2.92562932e-01f, 9.43006873e-02f, 4.71129417e-02f, 3.83936524e-01f, 1.53399646e-01f,
  -2.25122184e-01f, 3.99764985e-01f, -8.74636695e-02f, -2.31685773e-01f, 2.14700371e-01f, 7.27520809e-02f, 1.50547892e-01f, 4.83038537e-02f, -2.44707102e-03f, 9.52930003e-02f,
  1.01810016e-01f, -7.54039735e-02f, -2.11431161e-01f, -4.20891261e-03f, -1.27543762e-01f, -1.80971801e-01f, -3.70155722e-01f, -1.40893519e-01f, -1.12947218e-01f, -7.07216114e-02f,
  -1.30811766e-01f, 4.07386124e-02f, -8.75439122e-02f, 2.54550925e-03f, -3.71129578e-03f, -1.17159151e-01f, -2.92550121e-02f, -7.78705999e-02f, -9.88362879e-02f, -7.21443743e-02f,
  1.83887020e-01f, 9.99657884e-02f, 1.01831138e-01f, -4.19465974e-02f, -6.88189715e-02f, -7.99101889e-02f, -3.19648460e-02f, -1.03811666e-01f, -4.05074097e-02f, 5.09961024e-02f,
  -7.59489909e-02f, 8.05557594e-02f, -6.51602373e-02f, -1.23643830e-01f, -8.37812722e-02f, -2.08398849e-02f, 1.08567052e-01f, 6.83758035e-03f, -7.86157027e-02f, 1.88595831e-01f,
  -1.14245703e-02f, -8.79558735e-03f, -1.81414746e-02f, 6.18077861e-03f, -6.05245419e-02f, -1.98177863e-02f, 6.58799931e-02f, 2.21658703e-02f, 4.52357270e-02f, 8.54299664e-02f,
  9.77775753e-02f, -4.67854030e-02f, 5.74265420e-02f, 6.24893233e-02f, -3.68961110e-03f, 8.22781995e-02f, 1.23518482e-02f, -7.89999664e-02f, 3.98655683e-02f, 1.80439755e-01f,
  -5.35970777e-02f, -5.36925942e-02f, -7.48795196e-02f, -5.68528846e-02f, 9.52757336e-03f, -1.15470523e-02f, 2.59497240e-02f, 2.20718551e-02f, -8.16113278e-02f, -3.61559428e-02f,
  1.46768689e-01f, 2.67423421e-01f, 1.38152717e-02f, 8.39189813e-03f, 6.25739545e-02f, 3.94071639e-02f, -3.29551585e-02f, -3.84200476e-02f, 1.18101291e-01f, 1.29435882e-01f,
  1.07047588e-01f, 1.12151772e-01f, 5.11236861e-02f, 1.81297734e-02f, 9.55147818e-02f, 1.11870959e-01f, 5.63466502e-03f, 2.52199639e-03f, 7.49262050e-02f, 1.23680495e-02f,
  7.12829549e-03f, 1.06666870e-01f, 1.88372862e-02f, 8.59838128e-02f, 1.18611567e-01f, -1.53484885e-02f, 1.63450897e-01f, -5.54522611e-02f, -4.18574773e-02f, 1.25588611e-01f,
  4.76919770e-01f, -4.76689905e-01f, -2.32032746e-01f, -9.35540083e-05f, 1.15020670e-01f, 1.46683887e-01f, 3.03459108e-01f, -3.02600175e-01f, -1.72805294e-01f, -2.64226437e-01f,
  3.24615724e-02f, 1.13425016e-01f, 4.65733139e-03f, 1.37282476e-01f, 5.75251400e-01f, 5.32433912e-02f, 6.61878809e-02f, 2.17478067e-01f, -4.56592813e-02f, -1.43341854e-01f,
  8.55679251e-03f, 1.17082767e-01f, -5.30971847e-02f, -2.40766615e-01f, 1.10722966e-01f, -3.23427200e-01f, 6.72865883e-02f, -3.36404480e-02f, 1.85699090e-02f, 2.65975267e-01f,
  -4.83701266e-02f, 5.98318093e-02f, 4.33427878e-02f, -4.54631299e-02f, -3.83323953e-02f, 7.41046891e-02f, 1.46944463e-01f, 2.02565283e-01f, 7.59453401e-02f, -5.53857647e-02f,
  -1.95034500e-02f, 3.09255943e-02f, -4.43222746e-02f, 7.08802193e-02f, 3.19846421e-02f, -1.80082232e-01f, -2.62741353e-02f, 3.45866717e-02f, -1.54995590e-01f, -1.46106314e-02f,
  -7.76382536e-03f, -2.01308541e-02f, 9.88907292e-02f, -9.67367515e-02f, -1.15789108e-01f, 5.93074337e-02f, -3.05854809e-02f, 7.70624727e-02f, -4.95401062e-02f, -2.97353324e-02f,
  -2.19241846e-02f, 9.17169526e-02f, -3.29005457e-02f, 6.61019236e-02f, 7.74560049e-02f, -5.20813316e-02f, 5.85000627e-02f, 4.20919992e-02f, 4.15286003e-03f, 1.56492181e-02f,
  8.01963359e-02f, 8.57644062e-03f, -3.96898277e-02f, 1.11122295e-01f, 9.51981023e-02f, -1.12340413e-02f, 1.38599619e-01f, 1.96490660e-02f, -1.77121967e-01f, -5.45118116e-02f,
  1.00888476e-01f, -3.08856517e-02f, -1.24321558e-01f, 1.03495484e-02f, 1.03848269e-02f, -6.10751472e-02f, 2.40714159e-02f, -2.44962536e-02f, -3.27341594e-02f, 1.61241367e-01f,
  -4.66529019e-02f, -3.24960738e-01f, -1.73618034e-01f, 8.56268033e-03f, -4.69544791e-02f, -5.75966910e-02f, 4.76399101e-02f, -5.43098040e-02f, 4.16520946e-02f, 5.37880920e-02f,
  -5.79910204e-02f, 2.89370231e-02f, -4.34341840e-03f, 1.90131809e-03f, 1.50190890e-01f, -2.08773896e-01f, -3.21262665e-02f, 3.39688696e-02f, -3.27301174e-02f, -5.47467247e-02f,
  -8.89875554e-03f, 7.86925778e-02f, 1.75541565e-01f, -1.52228735e-02f, -1.17652170e-01f, 1.22172289e-01f, -7.98380375e-02f, 8.33318532e-02f, -3.62336151e-02f, -6.73683584e-02f,
  -4.42161560e-01f, 1.74133599e-01f, 3.08325976e-01f, -3.62293124e-01f, 1.70957953e-01f, 5.77744126e-01f, 2.44524151e-01f, 1.17792189e-01f, -1.77689925e-01f, 9.94650647e-02f,
  2.09664837e-01f, -2.46629179e-01f, 1.56741560e-01f, 3.17584909e-02f, 4.50663626e-01f, 2.44918779e-01f, 8.84800330e-02f, -8.13698918e-02f, -1.10023022e-01f, -1.95333704e-01f,
  -1.01778127e-01f, -9.80052799e-02f, 1.67303964e-01f, -2.81903148e-01f, -4.99587767e-02f, -2.45548919e-01f, -1.53290868e-01f, 5.83780697e-03f, -9.86302644e-03f, 1.90109178e-01f,
  -3.85958292e-02f, -3.09145629e-01f, -8.67443830e-02f, 5.03019057e-02f, 1.17068156e-03f, -8.03698599e-02f, -6.37379661e-02f, 7.94061571e-02f, -2.82913838e-02f, -2.02587787e-02f,
  2.51684785e-02f, 3.79491821e-02f, -8.91078487e-02f, 1.54406624e-02f, -1.81644127e-01f, -2.16275603e-02f, 1.81330889e-01f, 1.07402213e-01f, 1.05731599e-01f, 1.14740148e-01f,
  1.54598147e-01f, 8.60959738e-02f, 1.81242581e-02f, -1.95423309e-02f, 7.67249092e-02f, 1.07126795e-01f, 6.17704615e-02f, 5.90609051e-02f, -2.05591246e-02f, 2.47060228e-02f,
  -2.43071288e-01f, -9.52423066e-02f, 1.35262832e-01f, -3.07859294e-02f, -1.35483849e-03f, 4.60027158e-02f, 1.16710328e-01f, 8.87639914e-03f, -7.69479275e-02f, 7.47895539e-02f,
  6.53919056e-02f, -7.60050565e-02f, -1.67597592e-01f, -2.47752760e-02f, 5.02943620e-02f, -6.33499771e-02f, 5.01233675e-02f, 4.37973253e-02f, 3.47250812e-02f, 1.09130755e-01f,
  5.49973473e-02f, 7.82666262e-03f, -7.61256665e-02f, -4.47475426e-02f, 1.16983145e-01f, 1.51237212e-02f, -1.44085705e-01f, 9.22890753e-02f, -7.88776129e-02f, 1.25963360e-01f,
  1.99105181e-02f, -2.98578173e-01f, 3.24851200e-02f, -1.25802830e-01f, -3.66177782e-02f, 4.43182774e-02f, -1.81059346e-01f, 1.14947781e-01f, 3.40078934e-03f, 1.97318010e-03f,
  2.74854683e-04f, -1.33312074e-02f, 7.87260979e-02f, -9.72109288e-03f, 3.31473537e-02f, 1.08665206e-01f, 5.34199476e-02f, -1.24333270e-01f, 1.11736409e-01f, 7.21175522e-02f,
  2.50916841e-04f, -1.20613560e-01f, -1.26238959e-02f, -7.08727911e-02f, -2.20427036e-01f, 1.51743338e-01f, -1.67650238e-01f, -6.84220791e-02f, 2.83428263e-02f, -8.54380950e-02f,
  3.83223593e-01f, 1.64937645e-01f, 1.47534117e-01f, 7.90260360e-02f, -7.77017176e-02f, -2.29126558e-01f, -5.58879115e-02f, -1.52174294e-01f, 1.99684054e-02f, -1.05208173e-01f,
  -3.70005637e-01f, 2.99195379e-01f, -1.38769466e-02f, -1.37185797e-01f, 1.74880065e-02f, -1.20603060e-02f, -4.24692817e-02f, 5.86719736e-02f, 2.43191514e-02f, -1.84829012e-01f,
  -1.40236050e-01f, -3.21892381e-01f, -3.96610126e-02f, -4.57018226e-01f, -1.26936674e-01f, 1.04875013e-01f, -2.72762954e-01f, -3.71084064e-02f, -6.87912256e-02f, -7.77695104e-02f,
  -5.72574418e-03f, -3.37798521e-03f, 1.11213490e-01f, 1.14340328e-01f, 6.45811781e-02f, -2.26337239e-02f, 6.54765218e-02f, -2.26827860e-02f, 1.25496984e-01f, 1.88693050e-02f,
  1.88200578e-01f, 7.27652907e-02f, -1.56216454e-02f, 1.14517231e-02f, 3.02470736e-02f, 7.48464242e-02f, 1.22204088e-01f, 1.28355309e-01f, -5.31766750e-03f, 1.16346627e-01f,
  1.70665175e-01f, 1.76628292e-01f, 1.48990944e-01f, 1.45147651e-01f, 3.23769785e-02f, 6.97829435e-03f, 9.63701159e-02f, 1.98016688e-01f, 3.61769274e-02f, 1.71309430e-02f,
  -1.39471501e-01f, 1.31351477e-03f, 2.74984781e-02f, 2.42540874e-02f, -1.55166313e-01f, -8.52573738e-02f, 3.97898294e-02f, -4.20155451e-02f, 4.70997058e-02f, 3.36721875e-02f,
  -1.25008980e-02f, 5.89214452e-02f, -1.06707104e-01f, -4.20146435e-03f, -7.08864778e-02f, 1.56138569e-01f, 1.03500672e-01f, 1.94508895e-01f, 8.11003074e-02f, -1.58374459e-02f,
  -6.82453215e-02f, -4.37755734e-02f, -5.57421986e-03f, 6.96410937e-03f, -3.04628648e-02f, 7.77146742e-02f, 4.39232141e-02f, 1.45626277e-01f, -3.27008478e-02f, -5.91014028e-02f,
  -1.31678239e-01f, -3.42382759e-01f, -6.61113560e-02f, 5.60251474e-02f, 5.39404824e-02f, -1.28611494e-02f, -5.86196184e-02f, -7.93286413e-02f, 8.90196264e-02f, -2.11474374e-01f,
  -5.77887241e-03f, 3.94291952e-02f, 7.23937228e-02f, 3.80815240e-03f, -1.04574487e-01f, -1.13001801e-02f, -5.57954833e-02f, 2.05082800e-02f, -4.53673340e-02f, 4.61498685e-02f,
  7.61251897e-02f, 4.16654684e-02f, -6.32101297e-02f, 5.25694601e-02f, 5.26616089e-02f, 3.06116659e-02f, 1.10651948e-01f, 5.82743213e-02f, 4.31853980e-02f, 1.05911493e-01f,
  2.63544768e-02f, -3.03508997e-01f, -1.43066980e-02f, 3.09979051e-01f, 2.56961972e-01f, -1.92696184e-01f, 9.96679142e-02f, 1.46067604e-01f, 1.63573548e-01f, -2.06503421e-01f,
  -5.89011088e-02f, -3.61526787e-01f, -3.80883396e-01f, -2.50651062e-01f, -2.56530434e-01f, -4.02529627e-01f, 1.44565836e-01f, -9.30381864e-02f, -3.13474424e-02f, 2.47793853e-01f,
  3.82420957e-01f, -3.61308120e-02f, -8.45309943e-02f, 1.33543521e-01f, 1.49297655e-01f, 3.15147847e-01f, 2.83214211e-01f, 1.18595228e-01f, 2.71302789e-01f, -1.09271236e-01f,
  -7.06962720e-02f, 1.27686253e-02f, 3.19810165e-03f, -8.60859454e-02f, 2.11215183e-01f, 7.86662474e-02f, 4.20893729e-02f, -1.48422748e-01f, 6.87225629e-03f, -6.93475176e-03f,
  7.71135883e-03f, -6.31685480e-02f, -6.27287775e-02f, -1.63712680e-01f, 5.08374274e-02f, -2.04688348e-02f, 3.01595181e-02f, 5.37153743e-02f, -1.12890184e-01f, 4.53032628e-02f,
  2.82184500e-02f, -8.85796994e-02f, -6.17455831e-03f, -9.39257629e-03f, 1.20011330e-01f, 1.03799224e-01f, 7.39595145e-02f, 1.13887429e-01f, 1.52818589e-02f, 1.60341755e-01f,
  3.95974331e-02f, 1.37228370e-01f, -7.28804544e-02f, -2.25652516e-01f, -1.13291489e-02f, -1.96616687e-02f, -5.83893619e-02f, -6.49336427e-02f, 6.36623353e-02f, -2.94605847e-02f,
  -2.77206842e-02f, 1.33060804e-02f, -9.43354815e-02f, 1.50425598e-01f, 8.14767033e-02f, -1.04765389e-02f, -6.10110387e-02f, 7.69992545e-03f, 1.35365590e-01f, 1.95574891e-02f,
  -1.10704586e-01f, 6.84990510e-02f, -7.39367530e-02f, 5.74100539e-02f, -1.97973967e-01f, 6.38857260e-02f, 4.74378131e-02f, -1.30205937e-02f, 5.09356223e-02f, -1.14112841e-02f,
  1.81893483e-02f, 1.42946109e-01f, 1.66594774e-01f, 7.24071935e-02f, -1.06771797e-04f, -1.52601957e-01f, -1.18974134e-01f, -9.12923440e-02f, 1.35213463e-02f, -1.71601072e-01f,
  1.86861023e-01f, 5.77223338e-02f, -1.06424712e-01f, -4.46068011e-02f, -6.89498633e-02f, 3.98273766e-02f, 4.22331914e-02f, 2.07892042e-02f, 3.12798284e-02f, 1.81444243e-01f,
  1.14807904e-01f, 1.40341252e-01f, 2.90872753e-02f, 2.46738359e-01f, -1.97429396e-02f, 1.01925090e-01f, 4.07032594e-02f, 1.60822898e-01f, -1.66018996e-02f, -1.10680006e-01f,
  -6.76969439e-02f, -2.27948517e-01f, 4.32316363e-01f, -2.57722169e-01f, 4.32076991e-01f, 5.77531278e-01f, 3.21617097e-01f, 4.24396917e-02f, 8.20862222e-03f, -3.84504110e-01f,
  -1.53534442e-01f, -1.25337556e-01f, 1.10658482e-01f, -3.02566886e-01f, 5.65047443e-01f, 1.86729044e-01f, -7.33013377e-02f, -2.10044205e-01f, 1.96217850e-01f, 4.38299924e-02f,
  1.65890992e-01f, -2.17910349e-01f, 2.44986162e-01f, -1.07376635e-01f, -6.38128072e-02f, -2.15166599e-01f, -3.40308070e-01f, 1.79533511e-01f, -4.17424351e-01f, 3.79001759e-02f,
  -4.13087718e-02f, -1.72732174e-01f, -5.55280298e-02f, -1.29305527e-01f, 1.04405824e-02f, 7.02784304e-03f, -8.05491135e-02f, 1.45657420e-01f, 6.07671030e-02f, 1.44527731e-02f,
  -9.32549760e-02f, 6.94502220e-02f, -1.02953523e-01f, -3.30194235e-02f, -8.01000744e-02f, -5.27826026e-02f, 1.87566936e-01f, 2.27451306e-02f, 5.98601848e-02f, 2.04323947e-01f,
  1.19385585e-01f, 6.55663759e-02f, 4.89451401e-02f, -4.63942513e-02f, 3.72340642e-02f, -1.55412242e-01f, 6.38748035e-02f, 1.61771104e-01f, 5.68554588e-02f, -1.07490256e-01f,
  -7.58035257e-02f, 5.00796288e-02f, 5.27580045e-02f, 5.46348952e-02f, 7.16582872e-05f, -1.08326443e-01f, -1.18937261e-01f, 3.04034241e-02f, 5.28089963e-02f, -2.25376785e-02f,
  -6.68068826e-02f, 4.49361687e-04f, 1.16421737e-01f, 6.15715459e-02f, -7.60387853e-02f, -9.22020227e-02f, -1.81414168e-02f, 4.58629057e-02f, 3.44727300e-02f, 5.10071986e-04f,
  2.16848236e-02f, -8.14055949e-02f, 8.51742625e-02f, -7.17608929e-02f, -6.66992441e-02f, 7.42008165e-02f, -8.60055983e-02f, 9.86164361e-02f, -4.57685404e-02f, -8.04519746e-03f,
  -1.38185471e-01f, -4.00139302e-01f, -2.09305584e-01f, -7.15280026e-02f, -1.35160476e-01f, -3.52922678e-02f, 1.02354974e-01f, -2.97101624e-02f, -2.93284580e-02f, 1.08052203e-02f,
  -1.08507752e-01f, -7.99110755e-02f, -2.29653362e-02f, 1.96792595e-02f, -4.22180705e-02f, 8.16147327e-02f, 3.02574448e-02f, -2.27815181e-01f, -6.15871511e-02f, -8.89963359e-02f,
  -1.48178473e-01f, 1.62257198e-02f, -1.31186042e-02f, -4.72025760e-02f, -5.09403832e-02f, -8.47409964e-02f, 5.37314378e-02f, -4.58941888e-03f, 1.06344663e-01f, 1.58122759e-02f,
  -3.18709649e-02f, 1.14547908e-02f, 8.78335908e-02f, 3.71734738e-01f, -2.39573330e-01f, -3.97260666e-01f, -2.45340675e-01f, -3.05180289e-02f, 1.30595239e-02f, -1.74987853e-01f,
  -2.27815971e-01f, 1.26588553e-01f, -2.12475032e-01f, 1.40613347e-01f, 4.11818326e-01f, 9.18071419e-02f, 1.46637961e-01f, -6.62236959e-02f, 1.54029042e-01f, -5.67545146e-02f,
  1.18745171e-01f, 2.78327614e-01f, 2.69570321e-01f, 1.58200592e-01f, -6.80010617e-02f, 1.67289332e-01f, 3.87330085e-01f, -4.55608591e-02f, 2.90458053e-01f, 4.77788374e-02f,
  -9.91456807e-02f, 1.54856905e-01f, -1.14901520e-01f, -2.87569650e-02f, 5.50183244e-02f, -1.90191045e-01f, -7.45950863e-02f, 3.28008123e-02f, -7.18399361e-02f, -5.87170608e-02f,
  9.31228325e-02f, 1.06804222e-01f, 1.39444903e-01f, 8.00804570e-02f, -1.00799486e-01f, 3.88203450e-02f, -1.51666272e-02f, -5.94065934e-02f, -1.16118848e-01f, -2.37642676e-02f,
  -6.53864369e-02f, -7.34724998e-02f, -1.53425820e-02f, 1.50738060e-01f, 1.20940648e-01f, -4.52482328e-03f, 8.13426822e-02f, 9.18328948e-03f, 1.80693924e-01f, 1.74741566e-01f,
  -3.71039361e-02f, -1.11984489e-02f, -2.55393367e-02f, -9.62153226e-02f, 5.60290776e-02f, -1.84875857e-02f, -3.45825590e-02f, 1.98806878e-02f, -1.86228715e-02f, -1.12239346e-01f,
  2.61903796e-02f, -8.69498327e-02f, -3.56346555e-02f, -9.29123387e-02f, 5.71902469e-02f, 1.09510347e-02f, -5.80215128e-03f, 8.85791555e-02f, 8.42787027e-02f, 4.55939062e-02f,
  -6.25525042e-02f, 2.28234753e-02f, -1.10970736e-01f, -1.18680663e-01f, -1.00577608e-01f, 1.47810141e-02f, 9.60910916e-02f, 8.19824357e-03f, -1.58170089e-02f, -5.16379401e-02f,
  1.36489064e-01f, 2.65642285e-01f, 5.26448749e-02f, -4.12102556e-03f, 8.42927843e-02f, 1.22435400e-02f, 7.47262537e-02f, 4.27342840e-02f, 2.30083853e-01f, -2.00140215e-02f,
  3.38682788e-04f, -1.39338240e-01f, 5.01277074e-02f, -4.39107977e-03f, 6.40723333e-02f, 4.91644368e-02f, 1.92096140e-02f, 1.16265103e-01f, 2.04027206e-01f, 8.75257254e-02f,
  -7.80165195e-02f, -3.60891521e-02f, 1.30282700e-01f, -3.43356282e-02f, -3.49459015e-02f, -4.29491000e-03f, -1.21774394e-02f, -7.05725104e-02f, 2.06673369e-01f, 6.58013299e-02f,
  -2.87977636e-01f, 9.38635319e-02f, -3.03736329e-01f, -4.91431169e-02f, -3.23359638e-01f, -3.28076184e-01f, -8.33476037e-02f, -2.41464287e-01f, 2.15074182e-01f, 3.85958016e-01f,
  1.29717037e-01f, -6.85260221e-02f, 2.97797680e-01f, -7.06356391e-02f, -2.92679220e-01f, 3.85523409e-01f, -1.95120081e-01f, 1.49373874e-01f, 1.05199270e-01f, -2.79017240e-01f,
  -1.13783658e-01f, -1.43144965e-01f, 2.63890289e-02f, -1.43560320e-01f, -4.01899576e-01f, -2.26841331e-01f, -8.94977674e-02f, -1.82585716e-01f, -1.51197389e-01f, -1.29087448e-01f,
  1.41459391e-01f, 8.02855939e-02f, -1.21262744e-02f, 1.52885923e-02f, -3.92377861e-02f, -6.00173092e-03f, -7.98252597e-02f, 2.18761358e-02f, 9.10107270e-02f, 3.09842583e-02f,
  6.25959560e-02f, -3.48516442e-02f, -2.60763280e-02f, -8.98674428e-02f, -3.89785655e-02f, 7.54244439e-03f, -3.34900059e-02f, 6.21209331e-02f, 9.51568410e-03f, -3.83555740e-02f,
  -3.07373889e-02f, 1.03233598e-01f, -1.84723437e-01f, 5.59709929e-02f, -7.30345324e-02f, 3.59830656e-03f, 2.61406768e-02f, -2.27860417e-02f, 2.68173423e-02f, -8.65358934e-02f,
  -1.59653977e-01f, 1.24471344e-01f, 8.03471580e-02f, 5.28182723e-02f, -2.05466207e-02f, -2.98192482e-02f, -4.18839641e-02f, -2.63289008e-02f, -7.30169341e-02f, -7.45373359e-03f,
  4.45881411e-02f, -9.01858322e-03f, 9.53227207e-02f, -9.03525390e-03f, -1.18856996e-01f, -1.33951241e-02f, -9.00929347e-02f, 9.59625617e-02f, -5.59217781e-02f, 4.04427433e-03f,
  -2.79555190e-02f, 3.31866555e-02f, 4.94594201e-02f, 5.42230010e-02f, -3.37920757e-03f, 3.43621522e-02f, -9.99556705e-02f, -3.63240577e-02f, 6.67556748e-02f, -2.21109211e-01f,
  1.15862556e-01f, -1.77166194e-01f, 5.17144017e-02f, 2.34292343e-01f, 7.34282210e-02f, -1.03578001e-01f, -3.42360768e-03f, -3.92567590e-02f, -8.65827575e-02f, -1.39470398e-01f,
  -8.52026641e-02f, 1.36115626e-01f, 3.70298699e-02f, 1.51150580e-02f, -1.14227450e-02f, -1.04263775e-01f, 4.96083908e-02f, 7.88725242e-02f, -3.29819769e-02f, -1.21379204e-01f,
  -7.22915232e-02f, 6.01282716e-02f, 6.71542361e-02f, 7.19919056e-02f, 1.26652673e-01f, 3.74213490e-03f, -7.94422403e-02f, 1.33084789e-01f, -4.45820205e-02f, -6.18208526e-03f,
  -7.50620961e-01f, 2.89212972e-01f, -3.12357634e-01f, -2.09993958e-01f, -1.21911705e-01f, -2.41967037e-01f, 9.45924520e-02f, 4.28318493e-02f, 8.40231031e-02f, 3.20059657e-01f,
  2.79617995e-01f, -1.23176947e-01f, 3.85897756e-01f, 1.94580987e-01f, -4.42410707e-01f, 3.29500973e-01f, -1.56160325e-01f, -7.28560658e-03f, 1.09034844e-01f, -1.60806492e-01f,
  -1.05711751e-01f, 1.63066685e-02f, -1.77142695e-01f, 1.32792979e-01f, -1.49056688e-01f, -1.70973912e-01f, -1.67691186e-01f, 8.06308538e-02f, -6.88145235e-02f, -4.35260125e-02f,
  -5.32541454e-01f, -3.58288288e-01f, -1.57697812e-01f, -2.42335856e-01f, -1.96239740e-01f, -4.71769646e-02f, -1.24704890e-01f, 4.42963578e-02f, -4.03642766e-02f, 1.37484185e-02f,
  -1.13924881e-02f, 8.28442425e-02f, 6.74576908e-02f, 2.25871935e-01f, -7.30244294e-02f, -9.63373110e-03f, -2.48213243e-02f, -6.08148798e-02f, -2.45524459e-02f, -1.62436459e-02f,
  4.93173599e-02f, 4.05311175e-02f, -1.16315879e-01f, -2.38118414e-02f, -1.43273756e-01f, -3.62397358e-02f, 2.13597231e-02f, -4.60589537e-03f, -1.74196318e-01f, -1.82842180e-01f,
  -2.51781987e-03f, -2.94927396e-02f, -4.47931997e-02f, -3.80637720e-02f, 1.22200064e-01f, 5.20753562e-02f, 1.71344802e-02f, -1.15760779e-02f, -1.52844470e-02f, -5.63087016e-02f,
  -1.70173943e-02f, -6.07613213e-02f, -1.13891341e-01f, -6.19527325e-02f, 4.02071401e-02f, 3.41638252e-02f, -1.15138069e-01f, -4.83799689e-02f, 8.01794454e-02f, -3.11480109e-02f,
  2.63239210e-03f, -3.45104970e-02f, 7.99594000e-02f, 9.33732688e-02f, 1.86271276e-02f, -7.32813310e-03f, 7.94294327e-02f, 2.36620270e-02f, 5.67266978e-02f, -7.25365579e-02f,
  -7.11566448e-01f, -5.72522938e-01f, -1.10715508e-01f, -5.91182187e-02f, -6.05689548e-02f, -2.99604516e-03f, 5.12237698e-02f, -9.37711298e-02f, -1.37183651e-01f, 8.85547623e-02f,
  -7.30170161e-02f, 1.07622112e-03f, -6.11636341e-02f, 1.33939773e-01f, 1.78557057e-02f, -4.30153236e-02f, -1.08160384e-01f, -5.44314533e-02f, -2.22681433e-01f, 8.88736639e-03f,
  -2.08925419e-02f, -2.43920144e-02f, -3.52128260e-02f, -2.15497497e-03f, 4.58761901e-02f, -1.06281057e-01f, -1.06576353e-01f, 1.05412595e-01f, -1.10694379e-01f, 9.35977325e-02f,
  1.80467516e-01f, -1.34995222e-01f, -3.28827053e-01f, 4.90322486e-02f, -3.49280871e-02f, 6.93800673e-02f, -1.63216472e-01f, -3.48676741e-01f, -1.35692462e-01f, 3.64312530e-02f,
  -1.37644604e-01f, 1.39845654e-01f, -3.64283144e-01f, 4.09261316e-01f, 1.66818753e-01f, -2.99004149e-02f, 2.74416029e-01f, 2.65052408e-01f, 1.28778234e-01f, -2.71838337e-01f,
  4.56943959e-02f, 1.83137119e-01f, -2.01011747e-01f, 1.80650130e-01f, 4.62016948e-02f, 5.93091957e-02f, 1.92653641e-01f, -8.66574980e-03f, 4.21580434e-01f, 3.73241603e-01f,
  1.19427323e-01f, -2.56684646e-02f, -4.60036509e-02f, 4.59052287e-02f, -1.36746734e-01f, -9.64268073e-02f, 1.49203613e-01f, 5.60835889e-03f, 1.31735550e-02f, 6.60868287e-02f,
  -9.10786763e-02f, 5.96568435e-02f, 1.36793733e-01f, 3.86692360e-02f, 2.81432681e-02f, 5.13333641e-02f, 6.21956959e-02f, -8.02758858e-02f, -9.36957300e-02f, -1.42318815e-01f,
  -1.77466616e-01f, -2.16296725e-02f, -3.22859250e-02f, 1.17443800e-01f, 7.72230104e-02f, 6.30299523e-02f, 1.61344126e-01f, 1.10840239e-02f, 1.62153125e-01f, 1.03457615e-01f,
  -4.37938310e-02f, 8.12081620e-02f, -8.41047093e-02f, -9.94975194e-02f, 1.77665856e-02f, 4.61173840e-02f, -1.51988398e-02f, 3.03082857e-02f, -3.33210230e-02f, -1.55867757e-02f,
  4.92977463e-02f, -4.48794104e-02f, -6.79258257e-02f, -2.67791282e-02f, 6.57436624e-02f, -3.73277776e-02f, -1.23571709e-01f, 7.63533190e-02f, -2.58795042e-02f, -2.01466277e-01f,
  1.66586768e-02f, 2.62970757e-02f, -7.53621906e-02f, -1.12234563e-01f, 9.89312232e-02f, -1.26841277e-01f, 8.39613453e-02f, 2.84361299e-02f, -1.76558703e-01f, -1.13851897e-01f,
  -3.78327183e-02f, 6.06241636e-02f, -8.01088437e-02f, 8.82026404e-02f, 4.92894202e-02f, 2.52177939e-02f, 7.64027908e-02f, 1.09817408e-01f, 3.92866693e-02f, -8.47337209e-03f,
  3.09668574e-03f, 8.00542831e-02f, 1.05586119e-01f, 3.45174223e-02f, -3.57766487e-02f, -1.59802526e-01f, 9.51691270e-02f, 4.65981476e-02f, 2.77078934e-02f, -1.02320671e-01f,
  5.22793084e-03f, -6.93003535e-02f, -1.00925872e-02f, -5.08928001e-02f, 7.12015033e-02f, 4.89726029e-02f, 1.31021542e-02f, 7.55245099e-03f, -1.76456477e-02f, 8.84930566e-02f,
  -1.44501433e-01f, 1.64686009e-01f, 3.76670323e-02f, -1.65932715e-01f, 2.83997804e-01f, 3.14187497e-01f, -1.70167387e-01f, 2.42453665e-01f, 1.16816685e-01f, -1.58314198e-01f,
  5.73999481e-04f, -3.10428143e-01f, 1.60366867e-03f, -7.70135671e-02f, 7.96963274e-03f, 1.96016114e-02f, -2.97744777e-02f, -1.79853827e-01f, 2.70793974e-01f, -1.36657596e-01f,
  2.41723526e-02f, -2.36444220e-01f, -3.73382196e-02f, 1.26443744e-01f, -5.83156161e-02f, -3.90746724e-03f, -2.36137494e-01f, -1.66651793e-02f, -2.53434390e-01f, 2.36560730e-03f,
  1.63032293e-01f, 1.55932993e-01f, 1.13475613e-01f, 1.47635072e-01f, 1.01827331e-01f, -1.51195884e-01f, -2.65950169e-02f, -3.60454223e-03f, 1.48970425e-01f, 1.61796823e-01f,
  -3.58248241e-02f, 4.92664380e-03f, -5.31494841e-02f, 4.20077443e-02f, 6.28865743e-03f, -7.67521411e-02f, 9.15964469e-02f, 1.12069018e-01f, -1.13600923e-03f, 1.08203195e-01f,
  5.08637168e-02f, 7.92906806e-02f, -1.79688272e-03f, -9.98465046e-02f, 6.36880286e-03f, 1.13140512e-02f, -1.40656069e-01f, -2.11580679e-01f, -8.84877890e-02f, -7.63759464e-02f,
  -7.27424324e-02f, 1.37811303e-01f, 2.24074069e-02f, -4.28734161e-02f, 1.77890360e-02f, 1.30568400e-01f, -2.46932004e-02f, 2.83368006e-02f, 1.16444662e-01f, 2.67822649e-02f,
  -1.34130061e-01f, -4.25651483e-02f, 8.74550194e-02f, 3.06817591e-02f, -1.43605284e-02f, 1.23447098e-01f, -4.67937775e-02f, -1.24574527e-01f, -1.18621215e-01f, 6.06602468e-02f,
  -1.11466184e-01f, 3.29286568e-02f, -1.50573882e-03f, -9.12683159e-02f, 3.23524848e-02f, 2.53513511e-02f, -6.32524714e-02f, 3.03067360e-02f, 1.05941378e-01f, -2.12406844e-01f,
  7.28529990e-02f, -9.60616097e-02f, 1.63726732e-01f, 1.08025819e-01f, 1.38820603e-01f, 3.54638696e-02f, 8.78374055e-02f, 8.00972506e-02f, 8.24546162e-03f, 1.17769234e-01f,
  -6.28687963e-02f, -6.33184686e-02f, 3.22057828e-02f, -1.23739734e-01f, -1.66755952e-02f, 1.63962841e-01f, -1.13641985e-01f, 2.18877662e-03f, -7.63211548e-02f, -7.37526417e-02f,
  -1.16675951e-01f, -7.19293207e-02f, -3.44677232e-02f, 1.35306209e-01f, -6.21159524e-02f, -2.52352059e-01f, 1.21813916e-01f, -2.20230259e-02f, -7.60520697e-02f, 2.09233258e-02f,
  -6.61736310e-01f, 6.81964517e-01f, 2.91220844e-01f, 2.26680145e-01f, -2.14696512e-01f, -2.00903356e-01f, 2.40952522e-01f, 1.41181350e-01f, 3.10912162e-01f, 4.10625339e-01f,
  -6.11005798e-02f, 3.93771350e-01f, 2.12199345e-01f, 2.45541871e-01f, -6.07916296e-01f, -1.15712814e-01f, -1.16948023e-01f, 1.86795965e-01f, 9.44073778e-03f, 1.24118682e-02f,
  -2.66033441e-01f, -2.64664829e-01f, -1.29997253e-01f, -1.30011454e-01f, 1.02595679e-01f, 1.74532309e-01f, -3.92086893e-01f, 3.00988071e-02f, -2.79590264e-02f, 1.59848742e-02f,
  -1.47193775e-01f, 4.80063371e-02f, 1.86010018e-01f, -1.14513122e-01f, -1.41362742e-01f, 2.58897971e-02f, -1.37605533e-01f, 1.23219530e-03f, 1.02195531e-01f, 2.34416351e-02f,
  1.28631443e-02f, -1.97223380e-01f, -1.14355814e-02f, 7.45092779e-02f, 1.25596285e-01f, 6.58338144e-02f, 1.56326666e-01f, -6.07260019e-02f, 1.94767579e-01f, -5.05564250e-02f,
  1.89047039e-01f, -4.33266489e-03f, 2.98082922e-03f, -5.49433865e-02f, -1.62174031e-01f, 1.54735222e-01f, -2.74284389e-02f, -6.37711138e-02f, -2.33109924e-03f, -1.04452990e-01f,
  -1.61859676e-01f, 2.90053096e-02f, 2.23381281e-01f, 2.76826881e-02f, 5.43848574e-02f, -3.71147804e-02f, 8.00303891e-02f, -1.07861333e-01f, -2.65373234e-02f, -1.64190531e-02f,
  -1.15887642e-01f, 1.19064681e-01f, -2.56501287e-02f, 8.38919058e-02f, 4.13368605e-02f, 1.51138440e-01f, -6.10633977e-02f, 2.93806847e-02f, -9.72631723e-02f, -1.21839799e-01f,
  -6.58759847e-02f, -1.11305311e-01f, -5.40750623e-02f, -8.92101675e-02f, -4.31567207e-02f, 1.36220339e-03f, -1.04799256e-01f, 8.92488658e-02f, -4.12092991e-02f, -1.53755814e-01f,
  -5.07137597e-01f, -5.43504715e-01f, 5.79145104e-02f, -1.01861015e-01f, 1.06486708e-01f, -5.58313094e-02f, -6.45956919e-02f, 2.68061180e-02f, -1.09933563e-01f, 9.19567514e-03f,
  7.81334862e-02f, 1.77113414e-01f, -2.16277003e-01f, 2.11156216e-02f, -1.07384913e-01f, -7.63061047e-02f, -2.19380222e-02f, 1.75785795e-02f, -1.52647868e-01f, -6.18082881e-02f,
  -5.41974306e-02f, -2.10628398e-02f, 1.68413687e-02f, -9.69877020e-02f, -8.01916644e-02f, -5.11795394e-02f, -2.99877599e-02f, 1.02911972e-01f, -1.06804989e-01f, -1.30440652e-01f,
  -4.08570528e-01f, -2.14232445e-01f, -4.53563988e-01f, -1.06818475e-01f, 9.26445797e-02f, 3.47453207e-01f, 1.45485550e-01f, -1.70286428e-02f, -3.40019584e-01f, 1.94132403e-01f,
  3.29162776e-01f, -3.80553663e-01f, -2.24083975e-01f, 2.06179380e-01f, 5.61656468e-02f, -3.50151919e-02f, 3.40730548e-01f, 2.01556310e-01f, -9.82436091e-02f, -1.85891911e-01f,
  -3.37166302e-02f, 3.07087243e-01f, -2.37853383e-03f, 2.44333163e-01f, 1.03358634e-01f, 3.80429663e-02f, 2.15757892e-01f, -2.17978537e-01f, 3.06542963e-01f, 1.48284882e-01f,
  -1.36273671e-02f, -3.50565344e-01f, -1.70738429e-01f, 3.68569754e-02f, 1.67120751e-02f, 7.47376531e-02f, 4.82952073e-02f, 2.27760803e-02f, -9.91114005e-02f, -2.06895135e-02f,
  -1.57547414e-01f, -6.13163263e-02f, -5.08091003e-02f, -5.68980258e-03f, 3.71403992e-02f, -7.20023066e-02f, -6.84458688e-02f, -1.91705432e-02f, 2.65304022e-03f, -1.54355094e-01f,
  -1.56361073e-01f, 3.55537124e-02f, 2.70322561e-01f, -2.41949614e-02f, -3.30321155e-02f, -8.60639848e-03f, 1.07249714e-01f, -3.76735884e-03f, 1.53194264e-01f, -4.17255238e-02f,
  -4.15529544e-03f, 6.65292796e-03f, -6.69437721e-02f, -5.26800789e-02f, -1.08826175e-01f, 8.82694498e-02f, 8.88396278e-02f, 2.97656246e-02f, -5.88922501e-02f, -8.62278491e-02f,
  -4.19751927e-02f, -1.20563194e-01f, -2.14240085e-02f, 1.09822758e-01f, 1.05426960e-01f, 6.36509508e-02f, 6.47186302e-03f, 4.14813776e-03f, -7.86432624e-02f, 5.12126237e-02f,
  -9.64630097e-02f, 3.08952644e-03f, -3.24859172e-02f, 5.68815283e-02f, 3.00647728e-02f, -1.04044832e-01f, -8.61058012e-03f, -1.03939816e-01f, 5.54630943e-02f, 3.11320350e-02f,
  2.39974372e-02f, -2.41262913e-01f, -6.93147853e-02f, -4.42399755e-02f, -4.00991924e-02f, -7.69971386e-02f, -6.93974271e-02f, 3.55199464e-02f, -7.44566172e-02f, -1.83803122e-02f,
  2.34510899e-02f, 1.10426404e-01f, 1.20745338e-01f, -4.59820814e-02f, 1.22642733e-01f, -6.67523071e-02f, 1.15929127e-01f, 2.94434726e-02f, 1.00388579e-01f, 1.07945350e-03f,
  -5.41813858e-02f, -1.19349897e-01f, 9.07821655e-02f, 3.31102759e-02f, 6.36253729e-02f, 1.04340263e-01f, 3.66968364e-02f, -8.41810778e-02f, 2.04018861e-01f, 2.99580442e-03f,
  -2.87587672e-01f, 1.31072775e-01f, -4.15583134e-01f, 2.30997458e-01f, -3.43719393e-01f, 3.92178267e-01f, 3.72050017e-01f, -1.07295059e-01f, 2.01745600e-01f, 3.80554527e-01f,
  1.20404793e-03f, 4.00580876e-02f, 8.37392807e-02f, 4.17832255e-01f, -3.07895225e-02f, 3.91888440e-01f, 4.12838101e-01f, 3.83334905e-01f, -4.12905589e-02f, 8.55545998e-02f,
  -1.57063324e-02f, 2.86808312e-01f, -8.94607827e-02f, -5.60068525e-02f, -8.45522732e-02f, -1.95151880e-01f, 1.51460022e-02f, -2.35487938e-01f, 2.92062052e-02f, -1.07473515e-01f,
  2.43250411e-02f, -2.06150338e-02f, -1.12306558e-01f, 2.82067284e-02f, -6.79267757e-03f, -5.73358908e-02f, 1.64181683e-02f, -1.32914156e-01f, -1.33798733e-01f, 2.39082742e-02f,
  7.39480481e-02f, -3.95913497e-02f, 8.22781175e-02f, -7.65305087e-02f, -3.13313678e-02f, -3.13408040e-02f, -9.22813341e-02f, -6.20180219e-02f, 9.13100913e-02f, -1.63101375e-01f,
  -3.70363556e-02f, -8.26070756e-02f, 2.83889007e-02f, 5.56307286e-02f, -1.22331204e-02f, 4.08510305e-02f, 5.81782945e-02f, -1.60754368e-01f, 4.64093536e-02f, 1.08927814e-02f,
  3.35503812e-03f, 5.31543158e-02f, 7.50329792e-02f, -5.57781942e-02f, -2.66370848e-02f, -1.18828975e-01f, 5.54324873e-02f, -8.68739933e-02f, -4.70237173e-02f, -1.04232756e-02f,
  -1.09651247e-02f, -2.51832698e-02f, 7.29229376e-02f, 2.18785517e-02f, 3.45959328e-02f, -3.09201293e-02f, -1.34635121e-01f, 7.87194818e-02f, 9.51968320e-03f, -1.32845538e-02f,
  4.70168367e-02f, 6.53972104e-02f, 1.41913518e-02f, -2.53147166e-02f, 6.21114522e-02f, -1.49313211e-01f, 7.95130432e-03f, -3.10751088e-02f, -4.56179492e-02f, -4.02064323e-02f,
  2.02005982e-01f, 3.30215514e-01f, 2.34536752e-02f, -3.70420665e-02f, 9.62732062e-02f, 1.80597091e-03f, 4.97876033e-02f, -6.58511296e-02f, 4.88756150e-02f, 2.51407623e-02f,
  -8.25781003e-02f, 6.98337182e-02f, 5.83456270e-02f, -1.88867375e-02f, -3.30492742e-02f, 2.44753212e-02f, 1.66199848e-01f, 3.34820934e-02f, 5.82583919e-02f, -7.51900300e-03f,
  2.16485430e-02f, 1.24493331e-01f, -6.98269978e-02f, -3.39965113e-02f, 5.62325530e-02f, -7.70260347e-03f, 6.34462759e-02f, -8.97330120e-02f, -8.25815201e-02f, 1.03478663e-01f,
  2.36024097e-01f, 7.81800523e-02f, 2.87555456e-01f, 2.49866992e-02f, -1.61644250e-01f, 1.73687398e-01f, 3.00832987e-01f, 7.15847909e-02f, 3.10770303e-01f, -1.02429442e-01f,
  -3.44600439e-01f, 3.58513534e-01f, 1.79384395e-01f, -3.36125195e-01f, 3.29712659e-01f, 1.52947932e-01f, 2.28055175e-02f, 7.32471496e-02f, 8.84580985e-02f, -1.28843725e-01f,
  -1.00818373e-01f, -2.78051317e-01f, -1.96267709e-01f, -2.11722478e-01f, -2.91118234e-01f, -1.50136724e-01f, -3.99322301e-01f, -2.82789599e-02f, -3.58282447e-01f, -1.26489010e-02f,
  2.13807896e-02f, -9.80161279e-02f, -3.34588848e-02f, 1.25188574e-01f, 6.19879253e-02f, -2.69619152e-02f, -9.70175266e-02f, 3.50542627e-02f, 5.49674407e-02f, 1.07119873e-01f,
  1.16769373e-01f, 1.38918543e-02f, 3.23755331e-02f, 1.86897758e-02f, -5.06961681e-02f, -1.52762011e-01f, -1.06518500e-01f, -4.92687784e-02f, 6.59929216e-02f, 9.52374265e-02f,
  1.78642079e-01f, 2.85386462e-02f, -6.66950271e-02f, -4.51407507e-02f, 3.45370136e-02f, 2.79847588e-02f, 1.18942238e-01f, -1.01724258e-02f, -2.88696475e-02f, 1.25308573e-01f,
  -9.49853659e-02f, -2.87276153e-02f, -6.42185211e-02f, -2.95894872e-02f, 2.39287708e-02f, -2.42743157e-02f, -2.19910964e-02f, -2.21123490e-02f, -1.39176091e-02f, -1.01193801e-01f,
  -1.11979619e-01f, -9.38999467e-04f, -1.51208527e-02f, 4.69368808e-02f, -9.32177678e-02f, 5.90358973e-02f, 3.45028080e-02f, 1.86366551e-02f, 4.69717011e-02f, 1.34389684e-01f,
  -1.25001863e-01f, 3.95487137e-02f, 8.03163946e-02f, -6.09609485e-02f, -4.47984710e-02f, -1.05037307e-02f, -6.37702346e-02f, 7.49244988e-02f, -2.16237940e-02f, 1.37802884e-01f,
  -2.00437307e-02f, 2.03588977e-01f, 9.16910078e-03f, 1.25481814e-01f, -1.77889932e-02f, 6.69250116e-02f, -4.62435372e-02f, 5.88341244e-02f, 1.25785723e-01f, -2.60776058e-02f,
  6.54707244e-03f, 8.13656598e-02f, -7.83073343e-03f, -5.16224746e-03f, 4.80007455e-02f, 1.06504567e-01f, 1.92957893e-02f, 1.48867160e-01f, 8.78386647e-02f, -7.71907866e-02f,
  3.77711840e-02f, -5.62925003e-02f, 2.00014710e-02f, -1.37551293e-01f, -7.86585733e-03f, -7.28188902e-02f, -2.43294314e-02f, 4.02058698e-02f, 1.01759233e-01f, -1.82378702e-02f,
  2.47460932e-01f, 1.93048313e-01f, -2.00575441e-01f, -3.31343919e-01f, -2.71840058e-02f, 4.66153443e-01f, 2.12642357e-01f, 4.70077284e-02f, -1.11893758e-01f, 2.08064735e-01f,
  9.61762518e-02f, -1.31163165e-01f, 9.28872079e-02f, 2.10075930e-01f, 1.80160642e-01f, 2.57003367e-01f, 2.55482435e-01f, 1.66935265e-01f, 1.23925261e-01f, 8.77196267e-02f,
  -8.13926943e-03f, 2.66473204e-01f, -2.15684921e-01f, 2.50408798e-01f, 2.53746450e-01f, -1.70326665e-01f, -2.90309638e-01f, -4.86205667e-02f, -1.11821033e-01f, 7.85523951e-02f,
  2.18707249e-02f, 3.37580182e-02f, 4.03163210e-02f, 3.53452750e-02f, 8.05495232e-02f, 5.24497330e-02f, -4.49116342e-02f, -1.92604177e-02f, -1.48724228e-01f, 3.53142358e-02f,
  -1.09966425e-02f, 6.77955821e-02f, 6.18726015e-02f, -3.48606985e-03f, 5.97065352e-02f, -1.39894053e-01f, -1.18479095e-01f, -1.09713845e-01f, -1.45232916e-01f, 2.71361824e-02f,
  -2.44914293e-02f, -5.66922203e-02f, -6.62001083e-03f, 4.97113680e-03f, 5.15981286e-04f, -6.23648502e-02f, -1.98378470e-02f, 4.41384129e-03f, 8.26793537e-02f, 2.34173033e-02f,
  6.54173568e-02f, 7.18409270e-02f, 3.50384153e-02f, 9.88889113e-02f, 3.22705097e-02f, 4.15066071e-02f, -5.44240624e-02f, -5.13576437e-04f, -7.66004696e-02f, 5.58140911e-02f,
  -1.32809773e-01f, -3.04559642e-03f, 6.00981452e-02f, 6.21071123e-02f, 4.92768511e-02f, 2.17432827e-02f, 8.89793634e-02f, -1.81230903e-02f, 4.60310094e-03f, -1.43844754e-01f,
  -4.89479825e-02f, 7.58428946e-02f, 6.00606650e-02f, -3.75964120e-02f, 5.28231859e-02f, -6.64967448e-02f, -3.60119753e-02f, 6.82919025e-02f, -1.15049958e-01f, -5.32845408e-02f,
  1.03303574e-01f, 2.78848916e-01f, 7.44551867e-02f, 1.90848634e-02f, 1.27342697e-02f, 1.35646775e-01f, 8.80107880e-02f, 1.30697787e-01f, 6.44544065e-02f, 1.49833083e-01f,
  -5.70039712e-02f, -6.74089640e-02f, -6.46354929e-02f, 3.08596268e-02f, -9.89667699e-02f, 6.19949773e-02f, -7.72333816e-02f, -7.62206363e-03f, -1.48152262e-01f, -3.78866978e-02f,
  -8.23117942e-02f, 1.20836915e-02f, -9.11770985e-02f, -4.64388765e-02f, -6.73958883e-02f, -7.36605525e-02f, 1.54483423e-01f, -8.48321766e-02f, -4.44936380e-02f, -9.51812714e-02f,
  8.27250909e-03f, -3.69199485e-01f, 1.71640635e-01f, 8.60227793e-02f, 1.72922671e-01f, 1.71205238e-01f, 2.91963160e-01f, -3.17511231e-01f, -4.30140048e-01f, -2.53287077e-01f,
  2.75696591e-02f, 2.37646133e-01f, -1.18097812e-01f, -1.82635844e-01f, 1.61408082e-01f, -3.90375733e-01f, -3.16634387e-01f, 1.06721312e-01f, -1.69996262e-01f, 3.67382057e-02f,
  -9.22003463e-02f, -3.13380688e-01f, 7.91816562e-02f, -1.46707475e-01f, 1.72608629e-01f, 1.35020062e-01f, 8.76187459e-02f, 1.38441518e-01f, 1.85749605e-01f, 8.31272900e-02f,
  4.57563363e-02f, -1.62141204e-01f, -3.40565629e-02f, -2.36593205e-02f, 1.48501210e-02f, 5.23053817e-02f, 2.66471982e-01f, 1.66910619e-01f, 2.57949680e-02f, -1.31558646e-02f,
  1.20745443e-01f, -4.62196320e-02f, -1.41139299e-01f, 3.39323394e-02f, -4.29238193e-02f, -6.64568171e-02f, -1.99252471e-01f, -4.19284776e-02f, -7.61309192e-02f, -5.19040562e-02f,
  -5.69964424e-02f, 5.02047427e-02f, -2.72630528e-02f, 1.10404223e-01f, 6.16485439e-02f, 7.43225403e-03f, -4.94853966e-02f, 1.29189715e-01f, -4.53681797e-02f, 6.06988370e-02f,
  -5.50718606e-03f, -6.51379675e-02f, -6.25913218e-02f, -1.53970560e-02f, 5.04057631e-02f, 6.38912320e-02f, 4.57575209e-02f, -4.01261002e-02f, 2.82985345e-02f, 8.05493519e-02f,
  4.64044698e-02f, 7.10642412e-02f, -1.59078345e-01f, -7.92592987e-02f, -5.34472540e-02f, -1.46997079e-01f, 1.28484726e-01f, 1.05196677e-01f, -2.82316450e-02f, -3.28276232e-02f,
  4.65529636e-02f, 1.81484699e-01f, 1.11071177e-01f, 5.25121652e-02f, -7.26717636e-02f, 2.68853009e-02f, -4.73180413e-02f, 2.59283110e-02f, -9.71112028e-02f, 2.88870521e-02f,
  -4.22588624e-02f, -1.88797146e-01f, -6.42985478e-02f, 2.94683836e-02f, -6.92747608e-02f, -4.74301949e-02f, 1.05952215e-03f, -1.10775806e-01f, 5.22777103e-02f, -6.17682114e-02f,
  1.19511701e-01f, 1.03815243e-01f, 5.50342835e-02f, -8.47301260e-03f, 6.62506148e-02f, -8.39522034e-02f, -5.28414082e-03f, 5.93756251e-02f, 1.15960002e-01f, 5.23600690e-02f,
  -5.38814850e-02f, 1.46569684e-02f, -1.98061801e-02f, -4.06150520e-02f, -1.07588567e-01f, 2.19492745e-02f, 8.62410590e-02f, -5.78271598e-02f, 1.03100270e-01f, -2.89367866e-02f,
  -2.15338826e-01f, -1.48738548e-01f, 4.34950978e-01f, 1.91035628e-01f, 3.71662319e-01f, -2.89813370e-01f, -3.50012928e-01f, 2.94528514e-01f, -2.80427914e-02f, -4.32051927e-01f,
  -3.42508182e-02f, -4.56418067e-01f, -5.13200462e-02f, 1.49761382e-02f, 7.80103058e-02f, 2.05614775e-01f, 1.19400369e-02f, -9.73237753e-02f, 2.15868667e-01f, 1.73036829e-01f,
  3.11117738e-01f, 3.25819343e-01f, 3.44290018e-01f, 3.61562163e-01f, 3.11016589e-01f, 8.94076470e-03f, -6.07780404e-02f, 2.60886550e-01f, -1.83822945e-01f, -1.22491904e-01f,
  -1.33464471e-01f, 2.26014137e-01f, -1.99283939e-02f, 1.01151511e-01f, 6.37712777e-02f, -1.19574904e-01f, -8.25688764e-02f, 3.12708803e-02f, 4.22356948e-02f, 3.30131464e-02f,
  2.07287185e-02f, 8.49922970e-02f, -1.41401246e-01f, 6.01571240e-02f, 2.35346090e-02f, 1.06241129e-01f, 4.61473837e-02f, 6.88514020e-03f, 3.32855582e-02f, -6.97798058e-02f,
  -1.40839512e-03f, -2.16505658e-02f, -5.78194559e-02f, -4.86752056e-02f, 1.05763108e-01f, -7.52145275e-02f, -2.84212688e-03f, -6.93861991e-02f, 8.25990364e-02f, -5.45874052e-02f,
  2.12965816e-01f, -9.91116092e-02f, 1.59823224e-02f, -7.38738403e-02f, -3.25313210e-02f, 6.74116984e-02f, -9.31566730e-02f, -8.77747685e-02f, 2.54574604e-02f, -2.36398615e-02f,
  4.84855287e-02f, -1.34315461e-01f, 1.34846866e-01f, 3.19840387e-02f, 1.45032164e-03f, 4.65241671e-02f, 6.53830171e-02f, 2.80835982e-02f, 1.60499483e-01f, 6.59249425e-02f,
  1.06735472e-02f, 3.92211974e-02f, 1.32692955e-03f, 1.44585252e-01f, -1.72753129e-02f, -8.65944177e-02f, 1.44384056e-01f, 1.03985555e-01f, 5.91007881e-02f, 8.78652260e-02f,
  -3.90729934e-01f, 1.78121980e-02f, -2.67675817e-02f, -1.05642252e-01f, 1.63013041e-02f, -6.34010136e-02f, 1.23607386e-02f, 4.36274260e-02f, -6.26963899e-02f, 7.77895525e-02f,
  -5.14712892e-02f, 1.11348167e-01f, -9.07905996e-02f, -3.81090753e-02f, 4.27460857e-02f, -6.69585541e-02f, 2.40170751e-02f, -9.27962661e-02f, 2.22438178e-03f, -2.57059298e-02f,
  7.83649981e-02f, 4.51322459e-03f, -7.35963285e-02f, -9.85391159e-03f, 3.65712456e-02f, -1.15000516e-01f, -8.58136117e-02f, 2.72591636e-02f, 5.11915702e-03f, -5.09217791e-02f,
  2.87637919e-01f, -3.35987359e-02f, 6.82237223e-02f, 2.07729325e-01f, 2.31091738e-01f, -3.76158208e-02f, 1.52056918e-01f, 1.71370715e-01f, 1.90222785e-02f, 1.47234917e-01f,
  -3.13085884e-01f, -1.39982834e-01f, -3.92264187e-01f, -3.36740911e-01f, -4.43957001e-01f, -4.33537096e-01f, -8.39004144e-02f, -2.29259923e-01f, -1.63715467e-01f, 2.14454941e-02f,
  -9.09247249e-02f, -2.55539179e-01f, 3.42058167e-02f, 1.36053324e-01f, 2.19266310e-01f, 3.66778731e-01f, 8.86870399e-02f, -9.20877646e-05f, 2.44564027e-01f, -1.48866281e-01f,
  -8.95631760e-02f, -1.10135227e-01f, 2.20436737e-01f, 5.26831544e-04f, 7.05500096e-02f, 1.20513238e-01f, 1.32774368e-01f, -6.97554052e-02f, -5.04107065e-02f, -5.29115014e-02f,
  2.57181767e-02f, -2.06684414e-03f, -1.12332381e-01f, -8.76423493e-02f, 1.96357325e-01f, 4.18004692e-02f, -5.13850227e-02f, 2.11625248e-01f, 7.57314917e-03f, -8.86567757e-02f,
  8.82139280e-02f, -1.26880249e-02f, 8.03239420e-02f, 3.67330201e-02f, 6.63054958e-02f, 1.74770989e-02f, 8.76443759e-02f, -4.99904640e-02f, 1.31875828e-01f, 8.59090686e-02f,
  -7.55981058e-02f, -3.14367674e-02f, -1.05138321e-03f, 1.33275300e-01f, -1.48341134e-01f, -3.16607878e-02f, -4.99852635e-02f, 6.96646888e-03f, 1.38527341e-02f, -3.24879996e-02f,
  -7.87454247e-02f, 9.35512334e-02f, -1.40135929e-01f, 7.44683295e-02f, 3.35121602e-02f, 1.61006272e-01f, -2.15438800e-03f, -1.58990130e-01f, 1.33178100e-01f, -9.49764904e-03f,
  8.46487805e-02f, -4.79575852e-03f, 2.19187746e-03f, 3.30461003e-02f, 3.59056182e-02f, -6.90217083e-03f, 1.82832740e-02f, 1.30091393e-02f, -3.49007808e-02f, -7.43537396e-02f,
  -6.37951791e-02f, -1.39103889e-01f, 3.40316147e-02f, -4.59157638e-02f, -1.38572484e-01f, -2.08531134e-02f, -6.05773665e-02f, 3.10853720e-02f, 2.51324009e-02f, 9.12447833e-03f,
  9.20076519e-02f, 1.04507089e-01f, 1.58972949e-01f, -1.44241631e-01f, -6.69587404e-02f, -4.57108952e-02f, 3.81478518e-02f, 5.63240238e-02f, 1.66828260e-01f, 3.51413228e-02f,
  1.79422185e-01f, -1.81933977e-02f, 1.22643761e-01f, 1.74579993e-01f, 1.26119815e-02f, -1.41239362e-02f, -1.14215445e-02f, 3.99616286e-02f, -5.43302633e-02f, -6.26992956e-02f,
  -6.75681606e-02f, 4.21588659e-01f, 2.14506492e-01f, -1.12443879e-01f, -3.52405757e-01f, -3.20459940e-02f, -1.50423408e-01f, 9.60380882e-02f, 1.46861166e-01f, 3.27094764e-01f,
  -2.28359610e-01f, 2.79305726e-01f, 1.91643611e-01f, 5.62208053e-03f, -3.54545087e-01f, -4.43625748e-02f, -9.52283889e-02f, 1.19637772e-01f, 1.25548482e-01f, -1.10461086e-01f,
  -2.40930662e-01f, -2.26069063e-01f, -2.55620301e-01f, -1.61985442e-01f, -2.12117314e-01f, 1.12877376e-01f, -3.82927060e-01f, -1.36587486e-01f, -1.08025961e-01f, -6.30315766e-02f,
  -6.68949410e-02f, 6.77327439e-02f, 9.80986953e-02f, 9.76500064e-02f, -6.53321762e-03f, 6.03982881e-02f, -1.15953118e-01f, -2.83884769e-03f, 9.15313046e-03f, 5.78083247e-02f,
  5.49572110e-02f, 4.07982543e-02f, 9.79739428e-02f, -4.69508804e-02f, 8.34931061e-02f, 1.56271204e-01f, -1.40180895e-02f, -7.50165025e-04f, 1.50065303e-01f, -7.42995217e-02f,
  2.51263380e-02f, 3.78199555e-02f, -1.06207013e-01f, -5.39985225e-02f, -1.39156133e-02f, 7.59600699e-02f, -1.90936550e-02f, -6.21952079e-02f, 2.44976375e-02f, -1.60905495e-02f,
  3.07158139e-02f, -1.30990315e-02f, -4.58781980e-02f, -4.42599729e-02f, -6.11691270e-03f, 1.03619928e-02f, 5.04235364e-02f, 4.10495745e-03f, 6.63777441e-02f, -6.70370907e-02f,
  -1.04741901e-01f, 3.93369421e-02f, -1.19826123e-02f, 1.05571888e-01f, -2.08958685e-02f, 4.31331582e-02f, -2.04734653e-02f, 4.10109609e-02f, 2.02360786e-02f, 4.55005020e-02f,
  1.03110053e-01f, 1.33300811e-01f, -2.91443523e-03f, -3.51282693e-02f, -3.25433537e-02f, -3.74818295e-02f, -2.42269747e-02f, -4.53113718e-03f, 1.00285158e-01f, -1.19461967e-02f,
  -1.42110407e-01f, -5.49654216e-02f, 9.03696641e-02f, 1.03673205e-01f, 3.99260484e-02f, 2.80718002e-02f, -6.60585240e-02f, -1.09699093e-01f, 4.77217883e-02f, -6.63426332e-03f,
  -1.26775697e-01f, -8.13151821e-02f, -7.47565702e-02f, -8.69169757e-02f, 8.83738473e-02f, -2.72022281e-02f, -3.99788991e-02f, 7.43593276e-02f, -1.17584981e-01f, 1.44051909e-01f,
  1.08188272e-01f, 6.60257638e-02f, -2.19678250e-03f, -4.81342450e-02f, 5.93680702e-02f, -4.87528816e-02f, -6.37812093e-02f, -1.66147370e-02f, -7.89591521e-02f, 7.17626661e-02f,
  -1.31676793e-01f, -7.90212080e-02f, -6.06200332e-03f, -5.11429012e-02f, 2.57252362e-02f, -9.24482346e-02f, -1.30582035e-01f, 2.58359350e-02f, -3.32695752e-01f, 5.16026132e-02f,
  -6.83678538e-02f, -9.96201783e-02f, 2.69103772e-03f, -2.31169388e-01f, -6.68225586e-02f, -2.98049718e-01f, 4.49025780e-02f, -3.60345952e-02f, -1.42683357e-01f, 3.15468758e-01f,
  -5.60224755e-03f, 4.46392894e-02f, 5.02370559e-02f, 1.31948963e-01f, 2.56428029e-02f, 1.44835874e-01f, 4.24465895e-01f, 1.25856334e-02f, 1.36629462e-01f, -1.44903824e-01f,
  -1.67401761e-01f, -1.01064816e-01f, -6.07126728e-02f, -2.65474301e-02f, 1.82409912e-01f, 1.63141191e-02f, 2.30289828e-02f, -1.15556285e-01f, 1.43190864e-02f, -7.04163164e-02f,
  1.17635630e-01f, -6.01029843e-02f, 1.22927753e-02f, -1.04529455e-01f, -9.71696749e-02f, 2.71710102e-02f, -8.50475058e-02f, -1.22046560e-01f, -1.26110867e-01f, 3.09611782e-02f,
  -7.73873366e-03f, 1.82033088e-02f, 8.09289142e-02f, 2.77574477e-03f, 7.87689760e-02f, 2.41420288e-02f, 9.30778459e-02f, 1.10319130e-01f, -8.38114321e-02f, 1.19563844e-02f,
  2.40565035e-02f, 1.20706178e-01f, -9.02526900e-02f, -1.62296161e-01f, -4.46012802e-02f, -1.49570382e-03f, -1.21350102e-01f, -1.21508598e-01f, -4.95044030e-02f, 9.19285603e-03f,
  1.65505484e-01f, 7.11074695e-02f, -1.47795767e-01f, 6.42761439e-02f, 1.43538013e-01f, -4.65607345e-02f, 3.15028317e-02f, 4.60314043e-02f, 6.15216903e-02f, 1.32984649e-02f,
  -1.48241207e-01f, 5.31349406e-02f, 4.98320013e-02f, 9.16374549e-02f, -1.46484315e-01f, 5.54305427e-02f, 8.63294378e-02f, 5.67541085e-03f, 4.14556749e-02f, 1.51783228e-01f,
  1.91014618e-01f, 2.65519857e-01f, 5.98966479e-02f, -2.76807044e-02f, 1.71370544e-02f, -1.13746272e-02f, -1.07686467e-01f, -1.88329741e-02f, 1.78147018e-01f, 4.62908391e-03f,
  2.11517215e-01f, 9.75537002e-02f, 1.82018489e-01f, 2.51646228e-02f, -3.37440744e-02f, 2.62939036e-01f, 1.34600386e-01f, 5.36392890e-02f, 1.58713311e-01f, 2.43454233e-01f,
  1.13062695e-01f, 1.36394694e-01f, -9.93032660e-03f, 8.28698650e-02f, 1.24875605e-01f, 3.57451253e-02f, 3.15209888e-02f, -3.37953679e-02f, -1.00862728e-02f, 6.41038595e-03f,
  -7.23491013e-01f, 3.84654522e-01f, -2.37724751e-01f, -2.40622446e-01f, 1.32128969e-01f, -1.79462433e-01f, -2.42021829e-02f, -1.44795746e-01f, -2.18245596e-01f, 3.17734748e-01f,
  2.11522222e-01f, -2.81372279e-01f, 3.07028770e-01f, -1.69658512e-01f, -4.42265391e-01f, 2.74976008e-02f, -1.38408706e-01f, -1.26351476e-01f, -1.78514533e-02f, -1.26490101e-01f,
  -2.04824567e-01f, 1.07466422e-01f, -1.46233901e-01f, 3.67647946e-01f, -1.36519998e-01f, -8.58597606e-02f, 1.48683235e-01f, 1.99468508e-01f, -5.61241768e-02f, 1.46375066e-02f,
  -3.40715408e-01f, -2.60556340e-01f, 1.12760039e-02f, -1.47829607e-01f, -1.69653744e-01f, -5.12153804e-02f, -3.32187638e-02f, 4.70030643e-02f, -3.30361649e-02f, -6.45262972e-02f,
  -3.13253701e-02f, -3.61295119e-02f, -8.95365551e-02f, 1.31468028e-01f, -1.95705816e-02f, -1.57086365e-02f, -4.08520624e-02f, -5.83295114e-02f, -4.92612785e-03f, -9.33784768e-02f,
  -6.89755231e-02f, -6.22942820e-02f, 2.58339904e-02f, -7.69055039e-02f, -7.20979040e-03f, 1.12937376e-01f, 2.46068481e-02f, -1.29473165e-01f, -1.46699026e-01f, -1.55946061e-01f,
  3.18859657e-03f, 1.34114325e-01f, 1.31523326e-01f, 6.22834377e-02f, -9.22640134e-03f, -2.97257602e-02f, 5.26859947e-02f, -7.93537721e-02f, 8.84342566e-02f, -6.08386565e-03f,
  -2.89070364e-02f, -1.16487242e-01f, 7.95517713e-02f, -3.59325297e-02f, 8.54669139e-02f, -6.08999953e-02f, 8.38418007e-02f, 1.53361987e-02f, 2.11945339e-03f, -5.72910532e-02f,
  -2.75216773e-02f, -5.96224442e-02f, -5.72645925e-02f, 1.32058756e-02f, 8.36272445e-03f, -1.24556832e-01f, 2.96675693e-03f, -6.86002299e-02f, -1.72296166e-02f, 4.08482067e-02f,
  -3.06199729e-01f, -3.04315448e-01f, 9.85804200e-02f, -3.22906934e-02f, 2.18811352e-02f, 1.61106866e-02f, 1.62225962e-02f, -6.43048510e-02f, -3.68282050e-02f, -3.32299583e-02f,
  -3.81989889e-02f, -1.93388201e-02f, -5.11046052e-02f, -1.24778420e-01f, -2.54831016e-02f, 3.32080871e-02f, 8.37663710e-02f, 3.50134969e-02f, -1.07864298e-01f, -6.67182952e-02f,
  7.29751140e-02f, 8.10697898e-02f, 7.19999671e-02f, 5.84078804e-02f, -5.44616207e-02f, -1.05885668e-02f, -4.58616950e-02f, -1.10626206e-01f, 5.70243970e-03f, 5.69558330e-02f,
  9.05333087e-02f, 7.85224661e-02f, -2.47556657e-01f, -2.35587999e-01f, 1.16510324e-01f, -1.85803652e-01f, -2.04410434e-01f, 1.70275569e-01f, -2.34913945e-01f, 2.86551654e-01f,
  9.77229029e-02f, -1.68158382e-01f, 6.02853775e-04f, -3.08187306e-01f, -3.35168898e-01f, -1.87074780e-01f, -2.44961306e-01f, -2.03262731e-01f, 3.32907960e-02f, 1.44031599e-01f,
  -8.31509456e-02f, 5.62927350e-02f, -3.43295395e-01f, 2.67089903e-01f, 2.07580373e-01f, 2.17033654e-01f, 2.58381069e-01f, 1.31860971e-01f, 1.54899940e-01f, 2.50288695e-02f,
  -1.67754013e-02f, -7.86567554e-02f, -1.04967669e-01f, -1.18242301e-01f, -2.23983475e-03f, 9.18336213e-02f, 9.07502696e-03f, -3.58109623e-02f, 5.04041091e-02f, -8.41831416e-03f,
  7.96420276e-02f, 1.38055637e-01f, 8.48812088e-02f, 7.58490562e-02f, 4.19564471e-02f, 1.40594482e-01f, 7.44996965e-02f, -3.65324840e-02f, 5.20562346e-04f, -9.16248858e-02f,
  -1.21569604e-01f, -9.75630805e-03f, 1.08529396e-01f, 6.13418072e-02f, -9.28314328e-02f, 1.30238414e-01f, 2.97101159e-02f, -2.65133809e-02f, 1.23505339e-01f, 2.01900415e-02f,
  1.77738026e-01f, 1.22393006e-02f, 7.05220029e-02f, -1.94421127e-01f, -1.40607115e-02f, 3.66951488e-02f, -1.34613393e-02f, 3.83788324e-03f, -4.10234593e-02f, 2.36580726e-02f,
  4.17842381e-02f, 3.84455286e-02f, 1.84408892e-02f, -3.59479524e-02f, 5.29981293e-02f, -9.37569514e-02f, -6.59179538e-02f, -2.56185830e-02f, -1.39113277e-01f, -1.15776673e-01f,
  4.79337536e-02f, 4.15771492e-02f, -5.55341765e-02f, 5.90320528e-02f, 1.53988237e-02f, -1.06879562e-01f, 3.98536585e-02f, -6.45965040e-02f, -2.37859935e-02f, -6.96479008e-02f,
  -3.80706899e-02f, 2.34145209e-01f, -6.57376498e-02f, 6.56812489e-02f, 3.44204307e-02f, 6.37206361e-02f, -1.47414338e-02f, 2.65440904e-02f, 3.15716267e-02f, 1.34077102e-01f,
  1.03589915e-01f, 4.72519323e-02f, 1.22313812e-01f, 7.90275633e-02f, 5.46266809e-02f, 7.93811753e-02f, 1.55297235e-01f, 7.25813955e-02f, 6.39113635e-02f, 2.60366835e-02f,
  5.73243909e-02f, 1.36196196e-01f, 7.59312417e-03f, -2.25523189e-02f, -4.99049714e-03f, 1.81460381e-01f, 1.76699743e-01f, -2.32804846e-02f, 3.08259856e-02f, -1.13184936e-01f,
  -3.88792902e-01f, 1.04737751e-01f, 2.13640049e-01f, -4.86239403e-01f, 3.18951190e-01f, 4.33745474e-01f, -1.92098901e-01f, 1.05237804e-01f, -3.19771111e-01f, 1.07740819e-01f,
  1.30169347e-01f, -3.44895065e-01f, -7.31469914e-02f, -2.58099854e-01f, -1.81041807e-01f, -1.23531036e-01f, -2.17435673e-01f, -1.98869139e-01f, -2.84939229e-01f, -2.18955085e-01f,
  -1.55412748e-01f, 8.88632834e-02f, -3.92735712e-02f, 1.62879348e-01f, 5.86306900e-02f, -1.14881741e-02f, 1.15080118e-01f, 1.05374575e-01f, 2.06295952e-01f, 1.60452083e-01f,
  -7.49794627e-03f, -1.03573024e-01f, -1.24416769e-01f, 1.10042490e-01f, -3.60613279e-02f, 5.06561920e-02f, 3.16224173e-02f, 2.90669501e-03f, 8.09988752e-02f, 2.92773880e-02f,
  1.35745883e-01f, 9.01918672e-03f, -7.74415955e-02f, -6.19044378e-02f, 3.26439962e-02f, 9.87088382e-02f, -9.28380992e-03f, 2.93246433e-02f, 2.24863011e-02f, -1.48886174e-01f,
  6.03769813e-03f, 2.33547807e-01f, -8.05331245e-02f, 1.55637413e-02f, -2.24994086e-02f, 1.97421275e-02f, -6.91061616e-02f, 1.02717988e-01f, -2.88918968e-02f, -4.51579206e-02f,
  8.54092240e-02f, -5.10956906e-02f, -7.89125171e-03f, -1.25944629e-01f, -5.76712340e-02f, 3.07664219e-02f, -1.47305891e-01f, -2.20808908e-02f, -3.03416941e-02f, 1.95888087e-01f,
  7.31016025e-02f, -1.10634930e-01f, -3.08757462e-02f, -8.43400881e-03f, -7.24571943e-02f, 2.15693675e-02f, 3.11832614e-02f, -5.23700602e-02f, 1.43879820e-02f, -4.62634154e-02f,
  -2.47318670e-02f, 6.23691652e-04f, 1.09729156e-01f, 6.09753579e-02f, 6.54446259e-02f, -5.36402725e-02f, 8.71403217e-02f, 1.29293099e-01f, 2.87704226e-02f, -2.63978653e-02f,
  3.22789885e-02f, -6.08854629e-02f, -9.27803963e-02f, 1.12304367e-01f, -2.23729517e-02f, 1.53951198e-02f, -6.24610111e-02f, 1.15044611e-02f, 3.43224108e-02f, -3.06372698e-02f,
  2.04800427e-01f, 4.43561524e-02f, -4.50126082e-03f, -8.90653133e-02f, 6.44761994e-02f, 3.88631560e-02f, -7.31068328e-02f, -2.59527620e-02f, 2.86243632e-02f, 1.55792356e-01f,
  1.22190177e-01f, 1.77271485e-01f, -9.07957926e-02f, -9.29811746e-02f, -1.92592498e-02f, 1.33272678e-01f, -5.71630849e-03f, -6.62398115e-02f, -3.56653482e-02f, 2.17333868e-01f,
  -5.70803404e-01f, -6.11787289e-02f, 3.01168233e-01f, -1.34276622e-03f, 4.91106473e-02f, 4.27892745e-01f, 2.11911127e-01f, -7.54728541e-02f, -2.51169980e-01f, -2.82525569e-01f,
  -2.36927614e-01f, 8.28426611e-03f, -1.33078694e-01f, 1.68265790e-01f, 4.22178954e-01f, 2.02156231e-01f, 1.13312803e-01f, -5.65260835e-02f, -4.59595770e-02f, -2.69699514e-01f,
  -4.80607525e-02f, -9.40613598e-02f, 3.30115795e-01f, -6.65867627e-02f, -7.47386068e-02f, -3.15496624e-02f, -1.04037501e-01f, 2.64614761e-01f, 3.28358471e-01f, 3.93436790e-01f,
  -2.50006080e-01f, -4.17160004e-01f, -2.74395317e-01f, -7.23213404e-02f, -6.89561591e-02f, -1.38603030e-02f, 7.76683316e-02f, 7.27277473e-02f, -7.80377910e-02f, -3.72829065e-02f,
  -7.33131692e-02f, 1.34887308e-01f, 4.23892541e-03f, -8.69553238e-02f, 2.79039126e-02f, 3.71385068e-02f, 4.38621156e-02f, 4.47851494e-02f, 6.57352656e-02f, 7.23678693e-02f,
  -3.75405885e-03f, 1.05871044e-01f, -6.15801476e-02f, 6.28440753e-02f, 8.17691386e-02f, 1.15759224e-02f, 8.47440362e-02f, 1.46938592e-01f, 5.91587350e-02f, 2.20177905e-03f,
  2.44111046e-02f, -3.03671993e-02f, -9.22928974e-02f, -1.50571585e-01f, -1.81197822e-02f, -3.86969117e-03f, -1.60957873e-02f, 2.10627876e-02f, 3.01028304e-02f, 3.42538245e-02f,
  3.61566036e-03f, 2.76125800e-02f, -5.64807840e-02f, -3.13668065e-02f, -6.31719381e-02f, -3.63554358e-02f, -4.60551828e-02f, -1.04595855e-01f, 1.39376789e-03f, -3.47082987e-02f,
  -4.45015542e-02f, 3.75646204e-02f, -6.08305447e-02f, 1.11063704e-01f, 4.41872217e-02f, -1.24408854e-02f, -1.79567143e-01f, 1.30188331e-01f, -7.84401670e-02f, 6.27135187e-02f,
  -4.88699555e-01f, -2.86011845e-01f, -1.64244577e-01f, -1.65271103e-01f, 4.60493341e-02f, -8.18932503e-02f, 1.63111892e-02f, -1.42729893e-01f, -1.01377934e-01f, -4.75534312e-02f,
  -1.12408675e-01f, -7.07587078e-02f, -1.49602488e-01f, 5.28978817e-02f, 4.53848168e-02f, -1.36077657e-01f, -3.31972318e-04f, -1.17069617e-01f, -1.34191647e-01f, -7.43547082e-02f,
  -1.96582496e-01f, -3.31311263e-02f, 1.06077805e-01f, 1.84527517e-03f, 1.91896390e-02f, -3.99203226e-02f, -7.49376193e-02f, 3.70201170e-02f, 4.31498699e-02f, 8.53732228e-02f,
  -2.07009196e-01f, 2.60616392e-01f, 2.87919670e-01f, 7.71148279e-02f, -2.97572225e-01f, -1.85335577e-01f, -2.46661767e-01f, 1.66165560e-01f, 1.10647634e-01f, 2.97471136e-02f,
  -1.18739456e-01f, 2.28801548e-01f, 1.76547110e-01f, -7.03164712e-02f, -1.28611609e-01f, -2.98882127e-01f, 3.58713195e-02f, -1.09560207e-01f, 1.61478490e-01f, 2.27334470e-01f,
  8.93154740e-02f, -2.27508411e-01f, 1.10812448e-02f, 1.86653491e-02f, 1.85608983e-01f, 3.01931947e-01f, 1.37506545e-01f, 1.15915567e-01f, 1.94927648e-01f, -4.82980087e-02f,
  -1.20044753e-01f, 8.54684412e-02f, 5.82060255e-02f, 9.38971713e-02f, 1.16068691e-01f, 4.99470830e-02f, 1.90722626e-02f, -9.85203236e-02f, 6.11869916e-02f, 7.77840167e-02f,
  4.63749235e-03f, -6.62252977e-02f, -9.16501507e-04f, -3.43653560e-02f, 3.31877097e-02f, -1.72798913e-02f, 8.11272189e-02f, 7.27676079e-02f, 4.65791412e-02f, 3.52427848e-02f,
  2.15442851e-03f, 2.07478583e-01f, 1.79963306e-01f, 1.80977106e-01f, 1.74571529e-01f, 4.78405878e-02f, -4.37059402e-02f, 1.56590194e-01f, 4.51859832e-02f, -5.95305339e-02f,
  7.32747316e-02f, 7.64950514e-02f, -4.95211445e-02f, -6.23867773e-02f, 3.39673683e-02f, -3.09378225e-02f, -6.40898943e-02f, -5.55816330e-02f, -1.56475659e-02f, -8.50494504e-02f,
  7.98001792e-03f, 1.37648776e-01f, -1.60392076e-01f, 7.97576532e-02f, -9.92873833e-02f, -1.26967996e-01f, -2.65742466e-02f, 3.35408598e-02f, 6.15254305e-02f, 3.76822092e-02f,
  -4.56644110e-02f, -1.09726168e-01f, -4.12857383e-02f, -1.33934885e-01f, -1.87417507e-01f, 2.44991370e-02f, 1.38146237e-01f, 4.33584228e-02f, 2.73138192e-02f, 2.79915214e-01f,
  8.23842734e-02f, 4.33919489e-01f, 1.16586365e-01f, -2.49638297e-02f, 8.56630132e-02f, 8.45869854e-02f, 1.31520808e-01f, 9.46102366e-02f, 1.13089465e-01f, 3.52059864e-02f,
  8.05745348e-02f, 7.25730583e-02f, 7.98708051e-02f, -1.26628339e-01f, -1.02178253e-01f, 1.14744000e-01f, 8.34763646e-02f, 1.71670467e-01f, 1.88066736e-01f, 9.07564536e-02f,
  1.66020572e-01f, -1.30974799e-02f, 2.08132192e-01f, 1.48237854e-01f, 5.33166602e-02f, 1.23935290e-01f, 9.48583633e-02f, 7.27131069e-02f, 2.29947478e-01f, 1.87650204e-01f,
  -2.38532554e-02f, 2.62543876e-02f, 4.51173276e-01f, 3.85578573e-02f, 3.57138634e-01f, 4.81371164e-01f, 2.97694772e-01f, 4.59700406e-01f, 6.00133479e-01f, -3.05570543e-01f,
  -2.44653821e-01f, -3.24811250e-01f, -8.28213170e-02f, -1.20387942e-01f, 3.11768949e-01f, 1.75165772e-01f, 7.08847567e-02f, -1.67494103e-01f, 3.65815699e-01f, -1.15837894e-01f,
  2.79170927e-03f, -2.90343344e-01f, -2.81599313e-01f, -2.06031248e-01f, -1.36473859e-02f, -6.91199824e-02f, -3.45184773e-01f, 1.64014697e-01f, -3.21204066e-01f, 1.08918056e-01f,
  6.04310594e-02f, 1.31738394e-01f, -6.23455904e-02f, 7.97076747e-02f, 2.57685184e-02f, -4.51627858e-02f, -5.44586591e-02f, 1.46414980e-03f, 1.63532957e-01f, -4.62640077e-02f,
  -1.61864161e-01f, -1.86092898e-01f, -4.55831811e-02f, 1.25927955e-01f, 2.20533505e-01f, 6.17290661e-02f, -1.19862985e-02f, 8.23480412e-02f, -5.74056879e-02f, 6.09598979e-02f,
  3.81060466e-02f, 2.20656004e-02f, 1.43491969e-01f, 4.22200970e-02f, 2.47382727e-02f, 1.04122065e-01f, 4.00828058e-03f, 1.93751790e-02f, 2.91969478e-02f, 1.24593616e-01f,
  4.50025462e-02f, 1.82291314e-01f, -6.06419556e-02f, 7.33851567e-02f, 2.70822551e-02f, 5.90842217e-02f, -5.31754717e-02f, -8.50159451e-02f, 2.78991251e-03f, -5.10911783e-03f,
  1.17010340e-01f, -2.86794640e-02f, 1.62841231e-01f, 1.04222849e-01f, -1.01380549e-01f, 1.96646061e-02f, -1.55498117e-01f, -5.00784516e-02f, -6.98718503e-02f, -1.35851633e-02f,
  -3.20733292e-03f, 6.20986633e-02f, -4.11279239e-02f, -1.19965486e-01f, 7.31937438e-02f, 2.82831509e-02f, -2.46347766e-02f, 3.84613918e-03f, -3.12849730e-02f, -7.95929432e-02f,
  8.22679475e-02f, 7.82689527e-02f, 3.90811265e-02f, -1.37038991e-01f, -3.18385125e-03f, -1.15671195e-01f, 1.91628191e-04f, 8.21007639e-02f, 8.51034075e-02f, 4.23429795e-02f,
  3.82576883e-02f, -1.81087002e-01f, -2.08876096e-02f, 3.22654098e-02f, 1.22173745e-02f, -4.73687798e-02f, -1.63512334e-01f, 2.94634756e-02f, 2.97876131e-02f, -1.30055577e-01f,
  -2.25398883e-01f, -6.98395446e-02f, 5.43401130e-02f, -1.50166988e-01f, -5.39709106e-02f, -1.15493767e-01f, -6.95959181e-02f, -2.47388985e-02f, -1.64926853e-02f, 1.76824126e-02f,
  -2.96742797e-01f, -8.98408443e-02f, 1.27216548e-01f, 2.08926201e-01f, -2.70962864e-01f, -3.27699900e-01f, -1.80559129e-01f, -3.13672633e-03f, -1.71741724e-01f, -9.56360549e-02f,
  9.83796343e-02f, -9.86018106e-02f, 1.35327622e-01f, 1.20779701e-01f, 1.07682973e-01f, -6.67746589e-02f, 2.55743533e-01f, 2.70013586e-02f, 1.02732830e-01f, 2.03906238e-01f,
  1.85814932e-01f, 2.04014674e-01f, 2.49136075e-01f, 1.96851492e-01f, 1.29196987e-01f, 2.55145520e-01f, 3.48248899e-01f, 1.08970605e-01f, 3.45447838e-01f, -8.87326226e-02f,
  -2.78351046e-02f, 7.27921128e-02f, 3.81797329e-02f, -6.09900318e-02f, 1.41840935e-01f, 2.40115039e-02f, -3.46144638e-03f, 9.67838168e-02f, -4.20394689e-02f, 4.14477065e-02f,
  -9.59836319e-03f, 9.01124701e-02f, 4.67426814e-02f, -8.76609236e-02f, -7.86169022e-02f, -2.75733396e-02f, -8.15997794e-02f, -5.03469184e-02f, -7.73255229e-02f, -5.03504910e-02f,
  -1.18279479e-01f, -4.84412126e-02f, 1.92509033e-02f, -5.06007150e-02f, 2.71917600e-02f, 7.73720890e-02f, 5.48887141e-02f, 1.81062408e-02f, -9.20582712e-02f, -1.14093855e-01f,
  -7.58515447e-02f, -1.22934058e-02f, 1.71365961e-02f, 2.58000176e-02f, -9.15070847e-02f, -2.62403954e-03f, -1.57296099e-02f, 6.38699383e-02f, -1.00819781e-01f, 1.05998389e-01f,
  -1.18811429e-02f, -3.22360620e-02f, -7.61674941e-02f, -6.71842098e-02f, -4.15684320e-02f, -4.23055515e-03f, -7.01168552e-02f, 6.83894157e-02f, 9.52250697e-03f, -7.26255216e-03f,
  -4.80138734e-02f, -5.90981590e-03f, -5.40972874e-02f, 7.20022917e-02f, -1.15875848e-01f, 2.50322055e-02f, 4.69683819e-02f, 4.31414647e-03f, 8.63459632e-02f, 6.28622323e-02f,
  1.62702411e-01f, 1.97546110e-01f, 1.49345681e-01f, -6.18617907e-02f, 2.44723447e-02f, 4.53873090e-02f, 1.03726000e-01f, 4.31682542e-02f, 7.61631653e-02f, -4.02186066e-02f,
  1.37180954e-01f, 1.10842764e-01f, 3.25687714e-02f, -5.55476062e-02f, 7.05360770e-02f, -1.68124109e-03f, 1.42395005e-01f, 1.48810014e-01f, -5.15613221e-02f, 1.39689684e-01f,
  4.85811867e-02f, -1.17215738e-01f, -1.05684534e-01f, -1.98132694e-02f, -1.16618548e-03f, 4.25454900e-02f, -1.36058271e-01f, -6.59570917e-02f, -4.71929163e-02f, 7.66457692e-02f,
  -3.97529751e-01f, -2.90451646e-01f, 3.20973516e-01f, 2.24780351e-01f, -2.57100850e-01f, -2.07789972e-01f, 3.10503423e-01f, -3.51900131e-01f, -3.20955515e-01f, -9.52925459e-02f,
  -3.19243670e-02f, 2.77078282e-02f, 1.72875360e-01f, 2.27977306e-01f, 3.36508214e-01f, 2.62317717e-01f, 1.60811409e-01f, -9.01533011e-03f, -1.31198810e-02f, -5.69915995e-02f,
  3.02524287e-02f, 1.09649323e-01f, 2.66141653e-01f, -2.49065816e-01f, -1.48310483e-01f, 1.07783869e-01f, 2.49656990e-01f, 2.04756647e-01f, 1.33375585e-01f, -7.97017068e-02f,
  -4.10674304e-01f, 4.10686769e-02f, 8.41833428e-02f, -1.75629314e-02f, -1.66794181e-01f, 3.82779911e-02f, 7.30260238e-02f, 2.54570037e-01f, 2.18760729e-01f, -7.10904300e-02f,
  6.18669949e-03f, -2.37512216e-01f, -5.90598173e-02f, 2.68886145e-02f, -7.79041499e-02f, -5.58340028e-02f, -5.77716567e-02f, -2.13104919e-01f, 9.35323089e-02f, -1.24261878e-01f,
  3.05826422e-02f, -3.36483680e-02f, -4.17973250e-02f, -8.76428094e-03f, 1.69056147e-01f, -4.64135222e-02f, 4.10711877e-02f, -3.97005305e-02f, -3.57346162e-02f, -1.80208296e-01f,
  4.26534079e-02f, 1.43669635e-01f, 4.98781092e-02f, -2.81761531e-02f, 5.26077859e-02f, -1.14034899e-02f, 1.05801992e-01f, -1.11633629e-01f, 3.80068533e-02f, 7.76055381e-02f,
  -5.40268086e-02f, 2.09448505e-02f, -1.18318625e-01f, -7.35210478e-02f, 1.73290055e-02f, 1.08273216e-01f, 1.44811183e-01f, -6.31335378e-02f, -2.01974511e-01f, 7.15771643e-03f,
  1.55019358e-01f, -7.18525499e-02f, -2.45071594e-02f, -1.29282817e-01f, -7.03128800e-02f, 1.12766497e-01f, -7.55416080e-02f, 1.11200754e-02f, 5.49231246e-02f, 1.16303101e-01f,
  -2.91054696e-01f, 2.38376215e-01f, -3.10084634e-02f, -3.04404765e-01f, 1.36126667e-01f, -7.96814188e-02f, -1.35029911e-03f, 2.33725719e-02f, 1.55117646e-01f, -5.74582480e-02f,
  -7.52145350e-02f, -2.08587814e-02f, -1.37413770e-01f, 1.61276814e-02f, -2.04951945e-03f, 9.48550850e-02f, 2.27479756e-01f, -4.62094210e-02f, -3.59920319e-04f, -1.10549539e-01f,
  -5.82825281e-02f, 3.52720767e-02f, 1.25315815e-01f, -2.18240604e-01f, 9.08174291e-02f, 5.58419973e-02f, -1.02622285e-01f, 2.54247375e-02f, -1.91442687e-02f, -5.86265977e-03f,
  5.67178607e-01f, 2.32525796e-01f, 2.07514524e-01f, 3.44304860e-01f, -1.38186544e-01f, -1.28984213e-01f, -1.71433970e-01f, 1.15051389e-01f, 3.27123590e-02f, -3.43460888e-02f,
  -1.32646993e-01f, 4.00890797e-01f, -3.97087842e-01f, 2.84442157e-01f, 2.27649838e-01f, -4.02162075e-01f, 4.51870292e-01f, 1.32600382e-01f, -1.39170811e-01f, 3.59194130e-01f,
  1.02871209e-01f, 1.55241251e-01f, 6.36076406e-02f, 1.61485314e-01f, 2.38373846e-01f, 1.72739401e-01f, -3.91391106e-02f, -3.81554872e-01f, 2.90901691e-01f, 2.95280647e-02f,
  9.49606672e-02f, 7.15029612e-02f, 5.93306869e-02f, 3.73200551e-02f, -4.31208089e-02f, 3.48665863e-02f, -6.77398369e-02f, -1.06639475e-01f, -3.68959494e-02f, 1.79292373e-02f,
  3.79222631e-02f, 7.60358870e-02f, 1.48365438e-01f, -4.89170328e-02f, 9.77842510e-02f, 1.92134112e-01f, 1.12103455e-01f, -6.44031838e-02f, 1.01938218e-01f, 7.13026151e-02f,
  1.36843979e-01f, 5.93174100e-02f, 5.03701493e-02f, 2.81330086e-02f, 7.48039363e-03f, 6.29786327e-02f, 5.23565672e-02f, -5.74980956e-03f, 2.68081799e-02f, 1.65997863e-01f,
  1.11812865e-02f, -5.35150878e-02f, -4.86781076e-02f, -1.90088172e-02f, 2.60053691e-03f, 1.75148528e-03f, -1.30158260e-01f, -6.29004091e-02f, -2.64991168e-02f, -8.13875943e-02f,
  -6.92947879e-02f, 1.08401507e-01f, -1.46827633e-02f, -8.86034817e-02f, 3.95629555e-02f, 5.72524630e-02f, -5.28251007e-03f, -6.35654330e-02f, 3.50585915e-02f, -4.71691564e-02f,
  -6.88943565e-02f, -5.99545613e-02f, 3.66419964e-02f, -1.01462901e-01f, 4.07728646e-03f, -5.99124208e-02f, -1.29195089e-02f, 1.06284581e-01f, -1.08532801e-01f, -4.51195426e-02f,
  -5.48801124e-02f, 9.96991619e-02f, -3.44619751e-02f, -9.20573324e-02f, -2.06894167e-02f, 6.53681979e-02f, 5.31312265e-02f, 1.22600622e-01f, 7.31604695e-02f, -7.93502852e-02f,
  1.01134874e-01f, -1.26147464e-01f, -9.17626843e-02f, 5.05608842e-02f, -8.55902582e-03f, 1.69125758e-02f, -8.45120102e-02f, -6.17555305e-02f, 7.67532587e-02f, 6.99060634e-02f,
  9.00767744e-02f, -1.01032212e-01f, 8.99202898e-02f, 1.50441716e-03f, 3.40153351e-02f, -9.78155732e-02f, 6.80566207e-02f, 4.14411835e-02f, 8.07316601e-02f, -2.87556574e-02f,
  2.19503075e-01f, -7.73918107e-02f, -3.69659275e-01f, -5.13544008e-02f, 5.46592735e-02f, 3.42487842e-01f, -2.92162374e-02f, -1.69780597e-01f, -2.13021427e-01f, 5.76408692e-02f,
  1.50857195e-01f, -2.36660302e-01f, -1.27700731e-01f, 4.22612786e-01f, 1.28891453e-01f, 1.28007680e-01f, 3.42378706e-01f, 2.02535272e-01f, 5.71896229e-03f, 1.06896097e-02f,
  2.40697898e-03f, 4.72435057e-01f, 2.85451803e-02f, 2.99792141e-01f, 2.99371034e-01f, -1.59104124e-01f, -1.86131328e-01f, -2.06679612e-01f, 2.40789324e-01f, 7.37458542e-02f,
  1.26757354e-01f, 3.63540128e-02f, -4.32154723e-02f, 1.39402896e-01f, 9.83755514e-02f, 1.54841378e-01f, -2.19739657e-02f, 4.38986458e-02f, 5.20967469e-02f, 4.43029627e-02f,
  -1.33289769e-01f, 4.91873287e-02f, 1.19185641e-01f, -1.15541657e-02f, -2.09596790e-02f, -3.69650088e-02f, -7.57350922e-02f, -2.05838028e-03f, -9.65041146e-02f, -3.38864066e-02f,
  -1.62644908e-02f, -8.72123390e-02f, -1.43757388e-01f, -1.07745320e-01f, -1.69907555e-01f, -7.98968226e-02f, -8.74196589e-02f, -2.10705668e-01f, -5.68888858e-02f, -8.56764466e-02f,
  -6.93162382e-02f, -7.15284646e-02f, 1.12609036e-01f, 6.40793964e-02f, 4.43003662e-02f, -1.13739418e-02f, 5.30239195e-02f, 3.71677727e-02f, -1.13009132e-01f, 1.06612546e-02f,
  6.49291798e-02f, 4.75605577e-02f, -5.90405650e-02f, 1.76749583e-02f, 5.59786931e-02f, -9.08999890e-02f, 1.59964085e-01f, -1.65537447e-02f, -2.46668831e-02f, 9.75073781e-03f,
  5.38448617e-03f, 7.64421225e-02f, 7.92503208e-02f, 4.79708463e-02f, 8.64143968e-02f, -1.10248253e-01f, 7.63086602e-02f, -2.93992087e-02f, -7.20487386e-02f, -7.78931007e-02f,
  4.06172797e-02f, -2.19393954e-01f, 2.03186702e-02f, 1.17285930e-01f, 9.05364156e-02f, 2.06045374e-01f, 1.11524291e-01f, 1.38815850e-01f, 1.57795429e-01f, 6.45169094e-02f,
  -7.58152828e-02f, -6.27333447e-02f, 3.83700952e-02f, 9.54735186e-03f, 2.56443070e-03f, 9.63654444e-02f, -1.21229947e-01f, -4.80683113e-04f, -1.16756059e-01f, -9.24535096e-02f,
  -9.39551294e-02f, 1.30970255e-01f, -5.95807917e-02f, 7.91187733e-02f, 5.42100109e-02f, -6.31601885e-02f, 5.23764407e-03f, -1.46554694e-01f, -3.29939909e-02f, 2.39159260e-02f,
  -3.69703859e-01f, -1.50722310e-01f, 1.70707121e-01f, 1.55466527e-01f, -5.22780359e-01f, -5.75811695e-03f, 2.89844543e-01f, -1.90367013e-01f, 1.11027204e-01f, 2.55101800e-01f,
  1.23335235e-01f, -2.15566844e-01f, 2.42777780e-01f, 6.31284863e-02f, 1.67345941e-01f, 4.65025812e-01f, 8.25124457e-02f, 1.36984453e-01f, -3.00998632e-02f, -1.93506535e-02f,
  9.88837183e-02f, -2.30958611e-01f, 8.00053477e-02f, -2.55136937e-01f, -4.38976556e-01f, -1.44208953e-01f, -1.14252605e-01f, -2.35298306e-01f, -3.18483740e-01f, -3.91284704e-01f,
  -2.64172703e-01f, -2.13463798e-01f, 1.59903727e-02f, 3.44640464e-02f, -1.47351235e-01f, -1.05828680e-01f, 6.29873276e-02f, -7.12406933e-02f, -8.10617208e-02f, 6.87837526e-02f,
  -1.77574269e-02f, -1.44106075e-01f, -1.18536003e-01f, 9.57553759e-02f, -1.75564110e-01f, -1.76405892e-01f, -1.52549341e-01f, -5.11975773e-03f, -4.18683998e-02f, -1.15887620e-01f,
  1.02818403e-02f, -3.61603983e-02f, 4.56642173e-03f, 8.40615332e-02f, -3.40345688e-02f, -2.18887068e-02f, -5.10649756e-03f, -3.14494446e-02f, -3.95029709e-02f, -1.50873885e-01f,
  1.27318352e-01f, 7.82669708e-02f, 4.50166315e-02f, -7.29758590e-02f, 9.23763737e-02f, -1.77896917e-02f, -1.86467655e-02f, 6.00480549e-02f, 7.54184090e-03f, -1.10970378e-01f,
  -6.48249015e-02f, -1.30953714e-01f, -4.43773083e-02f, -1.04217231e-02f, -5.95572740e-02f, 8.52171257e-02f, 1.23473138e-01f, -1.09887496e-01f, -8.22379068e-02f, 1.58644263e-02f,
  8.40755254e-02f, 8.01351443e-02f, 3.56937596e-03f, 7.79049918e-02f, 1.03480943e-01f, -1.02639914e-01f, 2.75860932e-02f, 8.25306252e-02f, -4.58031930e-02f, -6.86165914e-02f,
  -2.61006057e-01f, -7.77086020e-02f, -5.24092913e-02f, -7.34544992e-02f, 4.58091050e-02f, 2.21147742e-02f, -1.88087616e-02f, 6.38436973e-02f, -7.45818913e-02f, 5.96012250e-02f,
  -5.94424643e-03f, -6.73559457e-02f, -1.13895595e-01f, -3.84180173e-02f, 1.88418180e-02f, -1.65934954e-02f, -2.82347500e-02f, 7.80073032e-02f, -7.74372965e-02f, 3.29082757e-02f,
  7.02918097e-02f, 3.85448933e-02f, 9.57017466e-02f, -1.14103183e-01f, -3.36815640e-02f, -1.15468604e-02f, -2.76185069e-02f, 6.05368391e-02f, -2.19906673e-01f, 2.42493227e-02f,
  -4.81041759e-01f, -2.25454390e-01f, 5.88584580e-02f, -2.74758458e-01f, -2.42746443e-01f, -3.32212821e-02f, 3.86916906e-01f, -3.83504391e-01f, -3.03393006e-01f, 1.12335980e-01f,
  1.35378197e-01f, -2.21283644e-01f, 3.08981836e-01f, -2.63364285e-01f, 1.53558865e-01f, 3.22282553e-01f, 7.93175586e-03f, 1.83402643e-01f, -2.30406821e-01f, -2.04198897e-01f,
  -8.03130046e-02f, -2.17480808e-01f, 1.34271294e-01f, -3.61796767e-01f, -2.37610906e-01f, -2.82544017e-01f, 2.42341012e-02f, 3.37663740e-02f, -3.36558819e-01f, -1.32677898e-01f,
  -3.46506685e-01f, -2.90585816e-01f, 3.80246043e-02f, 7.94184878e-02f, -1.24960661e-01f, 2.18278728e-02f, 3.41806486e-02f, 4.85393554e-02f, 9.87069495e-03f, 6.38677552e-02f,
  8.30720291e-02f, -1.38048679e-01f, -2.05506966e-01f, 1.34246811e-01f, -1.31725609e-01f, -1.71362609e-01f, -1.17222518e-01f, 1.56376231e-02f, -1.58352792e-01f, -7.47551993e-02f,
  1.67834368e-02f, -1.89343113e-02f, -6.72307312e-02f, 5.82556352e-02f, -1.02305204e-01f, -5.82340918e-02f, 1.44736364e-01f, 1.43629074e-01f, -1.22739874e-01f, -1.61784202e-01f,
  -2.78876796e-02f, -1.26834949e-02f, -3.57527621e-02f, -1.77011471e-02f, -3.49908136e-03f, 5.07299453e-02f, 1.35046229e-01f, -2.93063186e-02f, 1.78766903e-02f, -1.64155867e-02f,
  1.33310817e-02f, 3.91651988e-02f, -1.18047498e-01f, 9.32981446e-02f, -7.75578395e-02f, 1.82249881e-02f, 1.18784077e-01f, -1.04680076e-01f, 2.55133770e-02f, -4.97429110e-02f,
  -6.50231466e-02f, 2.51097102e-02f, -1.03285713e-02f, 1.56129733e-01f, -4.02112454e-02f, -4.39249212e-03f, -5.46524115e-02f, -1.85622312e-02f, 4.58423831e-02f, 1.35865450e-01f,
  -1.80630863e-01f, -2.78315306e-01f, -4.54929732e-02f, 3.85709554e-02f, 7.62607083e-02f, 1.04782754e-03f, 4.42726538e-02f, -1.17820740e-01f, -1.18766405e-01f, 1.12022243e-01f,
  -8.30930620e-02f, -4.33210190e-03f, -6.15833141e-02f, 1.38772484e-02f, 4.63478304e-02f, 2.51659658e-02f, 6.29346073e-02f, 9.53199789e-02f, 1.51128396e-02f, -1.24110073e-01f,
  1.16732478e-01f, -2.76386142e-02f, 7.12206736e-02f, -6.40601739e-02f, 4.08153646e-02f, -8.42600316e-02f, -5.10574169e-02f, -1.04801282e-01f, 3.20633985e-02f, 5.06513789e-02f,
  -6.09602869e-01f, 5.97633600e-01f, 2.09996983e-01f, -4.65075940e-01f, 1.76557630e-01f, -1.38574287e-01f, -4.52229172e-01f, 1.64443150e-01f, -1.21308118e-01f, 1.92841776e-02f,
  -1.53911307e-01f, 1.48328677e-01f, 2.09383935e-01f, -1.83386177e-01f, -2.21263468e-01f, 7.65406564e-02f, -3.82626832e-01f, -1.72422007e-01f, -2.25116387e-02f, -3.13900173e-01f,
  -1.56911746e-01f, -2.23056704e-01f, -1.11489423e-01f, 3.49228948e-01f, -1.08680330e-01f, 4.18689139e-02f, -1.86916143e-01f, 3.21136385e-01f, -4.93365675e-02f, 1.00020863e-01f,
  -4.54707414e-01f, -2.87140548e-01f, -4.24915962e-02f, -4.17803414e-03f, -6.54749125e-02f, -6.35222197e-02f, 3.05434112e-02f, -6.27169684e-02f, -8.97173882e-02f, -1.50888944e-02f,
  8.43072087e-02f, 4.63206787e-03f, 4.86071333e-02f, 5.86208776e-02f, 6.16549421e-03f, 9.60394368e-02f, 8.75617284e-03f, 4.62426208e-02f, 1.44776732e-01f, 1.00787878e-01f,
  4.55475897e-02f, 7.49729425e-02f, -8.60645175e-02f, -2.59250253e-02f, 3.51562090e-02f, -5.89003339e-02f, -1.55210709e-02f, 5.77044822e-02f, -9.90658347e-03f, -2.46476522e-03f,
  -5.58071472e-02f, -1.65351987e-01f, -7.80639127e-02f, 5.37698381e-02f, -1.22308254e-01f, 1.30781636e-01f, -4.07123640e-02f, -2.50156410e-03f, 5.57103008e-02f, -9.99408364e-02f,
  -7.40558803e-02f, -9.77827422e-03f, -4.67717797e-02f, -5.81233278e-02f, -5.07114194e-02f, -1.53404400e-01f, -4.45619076e-02f, 9.03578550e-02f, 4.90132906e-02f, -4.84195799e-02f,
  -3.44611518e-02f, -1.93623323e-02f, 1.59697495e-02f, -5.01456612e-04f, -1.55731058e-02f, -4.52833287e-02f, 3.43786329e-02f, 6.72979951e-02f, -2.53491923e-02f, -9.31681171e-02f,
  -5.65224349e-01f, -4.80669945e-01f, -2.22337902e-01f, 6.18044809e-02f, 1.56845544e-02f, -1.09435707e-01f, -8.85031521e-02f, 7.69152641e-02f, -1.08305819e-01f, -1.71983093e-02f,
  7.30520952e-03f, 2.32556090e-03f, -1.21646821e-02f, -1.07219420e-01f, -9.48629975e-02f, -8.09934735e-02f, -1.95673108e-01f, -4.14488763e-02f, -1.00914694e-01f, -1.14792371e-02f,
  7.84784034e-02f, -3.10751535e-02f, 1.13892462e-02f, -4.93344478e-02f, -5.99749349e-02f, -1.08729508e-02f, -1.15484707e-01f, 8.13594311e-02f, -1.53231993e-03f, 3.80976610e-02f,
  -7.71199018e-02f, -3.24559897e-01f, 4.22556587e-02f, 2.48132661e-01f, 3.43933851e-02f, -3.52470338e-01f, -4.22795534e-01f, 6.41373172e-02f, -4.96954098e-02f, -2.04501182e-01f,
  -6.32377416e-02f, 2.98219267e-03f, -2.48787999e-01f, 1.50425166e-01f, 3.05104971e-01f, -9.20985341e-02f, 6.43990636e-02f, -7.19236061e-02f, 6.40657619e-02f, -3.94183658e-02f,
  2.81362236e-01f, 1.68268308e-01f, 2.83907890e-01f, 2.49160752e-01f, -4.57883701e-02f, 8.64862725e-02f, 3.37303162e-01f, -6.53281957e-02f, 2.17769861e-01f, 1.23314098e-01f,
  5.64048886e-02f, 7.31537789e-02f, 1.88628193e-02f, -3.60784940e-02f, 6.73894957e-02f, -9.03818384e-02f, 2.45594941e-02f, -1.17405392e-02f, -4.90379892e-02f, -9.54764802e-03f,
  8.53140745e-03f, 8.52179453e-02f, 1.58224538e-01f, 8.38192403e-02f, -9.51694883e-03f, -6.83575915e-03f, 8.87062959e-03f, 5.80652319e-02f, 2.30827834e-02f, -6.21801056e-03f,
  -5.30031286e-02f, 5.39795607e-02f, 1.12118609e-02f, 2.85945628e-02f, 3.06208315e-03f, -4.45306040e-02f, -1.24755148e-02f, 2.28820499e-02f, 3.03432904e-03f, 1.08466312e-01f,
  2.14381907e-02f, -2.20540841e-03f, -1.32856920e-01f, 2.55476162e-02f, -7.93875307e-02f, -1.21848099e-02f, 2.35075280e-02f, -5.56345768e-02f, -7.53190592e-02f, -1.07266933e-01f,
  2.41378844e-02f, 6.79173321e-02f, -5.53108379e-02f, -5.76444827e-02f, -4.61043417e-02f, 7.61032663e-03f, -2.10810220e-03f, -6.73923790e-02f, 3.78638469e-02f, -5.80043532e-02f,
  5.77968732e-02f, 2.95518851e-03f, 1.31409420e-02f, 2.53631156e-02f, 8.03574175e-03f, -9.67303067e-02f, -1.74741335e-02f, -1.37220845e-01f, -2.00145859e-02f, -4.15867046e-02f,
  3.49044502e-02f, 9.75554362e-02f, -1.24034649e-02f, 6.95206374e-02f, 8.79091397e-02f, -1.24828301e-01f, 2.37037241e-02f, 8.70047323e-03f, 1.58942875e-03f, -3.09706032e-02f,
  5.27181029e-02f, -4.84919772e-02f, 6.31600097e-02f, 2.49622148e-02f, 6.73804134e-02f, -2.31619272e-02f, 3.82279269e-02f, 3.93623039e-02f, 1.49148270e-01f, 7.26649985e-02f,
  5.74299023e-02f, -4.59587760e-02f, -8.65830295e-03f, -3.24157462e-03f, 5.14251739e-02f, 4.32295911e-02f, -7.54072741e-02f, 6.83632195e-02f, -1.32793272e-02f, 4.69952784e-02f,
  1.68055743e-01f, 3.21795344e-01f, 2.26550162e-01f, -1.34293929e-01f, 8.07690695e-02f, 6.95265457e-03f, -2.86041856e-01f, -6.94609284e-02f, -2.68937498e-01f, 3.01050991e-01f,
  -1.32794484e-01f, 1.80781662e-01f, -1.98446751e-01f, -2.99847573e-01f, -3.92167568e-01f, -4.46922123e-01f, -1.87473416e-01f, 6.26786798e-02f, -1.79658756e-01f, 9.06049088e-02f,
  -2.66150445e-01f, -4.72823709e-01f, -2.66243458e-01f, -1.45215809e-01f, 2.74484664e-01f, 2.97433674e-01f, -1.22461878e-01f, 6.48467895e-03f, 2.03030571e-01f, -1.49097979e-01f,
  -2.32349224e-02f, -1.45885035e-01f, 1.17920108e-01f, 5.77996746e-02f, -1.47704035e-02f, 2.04940051e-01f, 1.56853378e-01f, -1.93022683e-01f, -1.64307311e-01f, -8.30018371e-02f,
  1.13293387e-01f, -1.34367287e-01f, 2.93979421e-02f, -1.84800774e-01f, 1.34213626e-01f, -2.92968042e-02f, 9.07712802e-02f, 2.14038491e-01f, 8.35550427e-02f, -5.20759448e-02f,
  2.93012653e-02f, 9.93674770e-02f, 1.06070198e-01f, -3.18579748e-02f, -4.00965288e-02f, -7.26004094e-02f, -5.42459711e-02f, 7.88968131e-02f, 1.72150463e-01f, 5.62701337e-02f,
  2.74878531e-03f, 1.50494397e-01f, -2.48797499e-02f, -1.54776312e-02f, 1.45236989e-02f, -1.95757044e-03f, 4.86294590e-02f, -5.24624102e-02f, -1.64648332e-02f, -1.12146109e-01f,
  2.61951238e-02f, 1.63109340e-02f, -1.31609678e-01f, -9.32670906e-02f, 4.17718478e-02f, 5.86298741e-02f, 5.83363734e-02f, 2.00663023e-02f, -2.93837897e-02f, 2.31819749e-02f,
  -6.76602796e-02f, 4.68669087e-02f, -7.61826464e-04f, 3.34690474e-02f, -2.87605096e-02f, -1.18391678e-01f, -5.09032160e-02f, 5.57661243e-02f, 6.03981968e-03f, 3.62399854e-02f,
  6.48591518e-02f, -1.01707447e-02f, -7.87226707e-02f, -8.31200704e-02f, -4.48393524e-02f, 3.76532860e-02f, -7.41485925e-03f, -1.54152848e-02f, -7.78259411e-02f, -1.12996057e-01f,
  8.82651284e-03f, 3.56264412e-02f, 2.54206508e-01f, -1.27676697e-02f, -1.11721277e-01f, -1.94096304e-02f, -5.90454079e-02f, 1.71134435e-02f, 9.70383659e-02f, 6.30013868e-02f,
  1.60491347e-01f, 3.54319774e-02f, -6.54192641e-02f, -9.47913341e-03f, 9.24675390e-02f, 7.55160525e-02f, 4.01654840e-02f, -5.42924181e-02f, -7.46410042e-02f, 1.72108021e-02f,
  1.00146219e-01f, 1.54714042e-03f, -3.69570374e-01f, 2.91298866e-01f, 2.12776229e-01f, 4.92336243e-01f, 4.61817116e-01f, 1.73642680e-01f, 3.77037495e-01f, 1.28764331e-01f,
  2.78758943e-01f, -1.46068662e-01f, -1.63921043e-01f, 3.70575428e-01f, 1.92758694e-01f, 8.61713216e-02f, 3.82514536e-01f, 3.53474736e-01f, 1.80353001e-01f, 1.18852124e-01f,
  1.35991067e-01f, 3.68924260e-01f, -2.84131825e-01f, -7.75572732e-02f, -7.09204935e-03f, -1.02198221e-01f, -2.43899629e-01f, -2.43540883e-01f, 2.08523627e-02f, 1.84525043e-01f,
  -5.10201156e-02f, 1.89612489e-02f, -7.03862160e-02f, -2.29643360e-02f, 3.41616310e-02f, 4.08281498e-02f, -1.34628057e-01f, -1.33321673e-01f, -9.00889263e-02f, -4.58421148e-02f,
  -7.45209903e-02f, -7.09200725e-02f, 3.83205488e-02f, -3.04708406e-02f, 8.70306119e-02f, -8.73535052e-02f, -6.30195364e-02f, -5.23361526e-02f, 2.14464148e-03f, -6.18774146e-02f,
  -1.09080426e-01f, -3.02356873e-02f, -2.30381377e-02f, 8.50809216e-02f, -3.95344831e-02f, 1.25423029e-01f, -2.89404634e-02f, -1.90377515e-02f, 8.41362402e-02f, 3.99538986e-02f,
  1.14303835e-01f, 3.45440097e-02f, -1.00173250e-01f, -1.54283673e-01f, 2.29131002e-02f, -7.98050612e-02f, 9.89256520e-03f, -7.22800046e-02f, 2.29259208e-02f, 6.34867996e-02f,
  1.06450573e-01f, -5.04231267e-02f, 5.96243218e-02f, -8.53191409e-03f, 7.28009129e-03f, 1.19578511e-01f, -1.64858941e-02f, 1.25535339e-01f, 5.36356494e-02f, -6.12663738e-02f,
  -3.46097983e-02f, 1.35409936e-01f, -1.23464060e-03f, -5.95689751e-02f, 9.73615721e-02f, -1.34755954e-01f, 7.10417181e-02f, -4.22067307e-02f, -6.99619483e-03f, 5.48286662e-02f,
  8.10761079e-02f, 1.04931325e-01f, 1.69053320e-02f, 1.02840126e-01f, 3.18079442e-02f, 4.98436484e-03f, 1.74393877e-02f, 5.77470660e-02f, 1.12267807e-01f, 1.08282097e-01f,
  -7.83383101e-03f, -8.07415023e-02f, -1.07457833e-02f, -8.41978379e-03f, 2.84728874e-02f, 4.05844785e-02f, 8.66451487e-02f, 1.60279721e-01f, 1.97218746e-01f, -4.03429149e-03f,
  1.32049108e-02f, -1.51106976e-02f, -2.74613518e-02f, 6.29706085e-02f, 1.37137920e-01f, -1.05791189e-01f, 6.49142871e-03f, -3.96353714e-02f, 8.35823119e-02f, 5.16003091e-03f,
  5.46916425e-01f, -4.94121276e-02f, 2.68628836e-01f, 3.04418445e-01f, 1.33401617e-01f, 6.06567934e-02f, 2.14342177e-02f, 2.69306034e-01f, 2.48012751e-01f, -3.32034498e-01f,
  -1.28480688e-01f, 1.38150096e-01f, -4.22884256e-01f, 2.84523129e-01f, -4.59847040e-02f, -2.88684934e-01f, 3.68632108e-01f, 2.01632872e-01f, 1.79585833e-02f, 1.84997603e-01f,
  1.43104374e-01f, -5.13230264e-02f, -1.46721467e-01f, 6.80420548e-02f, 3.46629947e-01f, 3.30319613e-01f, -2.28271782e-01f, -2.02234566e-01f, 1.45812631e-01f, -4.65008095e-02f,
  8.35360494e-03f, 1.11654289e-01f, -3.82460766e-02f, -4.51146178e-02f, -5.79843298e-02f, -2.68630236e-02f, -8.32102448e-02f, -7.14581786e-03f, -6.90954775e-02f, -8.34601596e-02f,
  -2.01240167e-01f, -1.16344113e-02f, 6.70816377e-02f, 4.15066890e-02f, 8.00933912e-02f, 2.46484265e-01f, 1.37614906e-01f, -7.51965046e-02f, 1.12767257e-01f, 1.12284184e-01f,
  1.19783983e-01f, 1.40406743e-01f, 1.31749079e-01f, 1.62795540e-02f, -1.45033151e-01f, 5.87313902e-03f, 1.65968969e-01f, 3.57010998e-02f, 5.64102307e-02f, 1.98196411e-01f,
  -1.52443368e-02f, -2.77627796e-01f, -7.17229694e-02f, 3.81172225e-02f, 1.05390899e-01f, -1.04141198e-01f, 6.42963350e-02f, -3.68954167e-02f, 1.02359848e-03f, 1.65398587e-02f,
  2.30608433e-01f, 2.44918708e-02f, 3.44144851e-02f, 5.20113148e-02f, -1.06096104e-01f, 7.96458125e-02f, -6.37810528e-02f, 5.49994484e-02f, 8.87153391e-03f, 1.24711841e-01f,
  -3.68209742e-02f, -2.08821390e-02f, -3.96817550e-02f, -2.41614096e-02f, -8.04448351e-02f, -1.16520353e-01f, 1.08058462e-02f, 1.07912228e-01f, -7.74341226e-02f, -8.91803429e-02f,
  -3.23365808e-01f, -1.71208888e-01f, -1.05227657e-01f, -2.40389984e-02f, -1.63685933e-01f, 8.03402811e-02f, 1.15054414e-01f, 1.82015657e-01f, -4.85090092e-02f, -9.55197029e-03f,
  -6.47932440e-02f, 6.80196285e-02f, 1.27271414e-02f, 2.53320932e-02f, -4.64328341e-02f, 8.86115506e-02f, -2.25842278e-02f, -1.67077005e-01f, 1.14423716e-02f, -9.21525285e-02f,
  -4.40309308e-02f, -1.18490875e-01f, -4.87372540e-02f, 7.70139173e-02f, 1.32225296e-02f, -4.51388620e-02f, 1.35585412e-01f, 4.58464213e-03f, 9.98690072e-03f, -5.33790253e-02f,
  -7.34521925e-01f, 4.43092197e-01f, 3.96012396e-01f, -1.44317532e-02f, -1.26743510e-01f, -2.53467951e-02f, -1.99890018e-01f, 2.70100236e-01f, -1.04110807e-01f, 7.18048885e-02f,
  2.03967556e-01f, -2.45422013e-02f, 3.01326275e-01f, 2.68637359e-01f, -9.42163914e-02f, 3.63446414e-01f, -2.21004263e-02f, -2.47123428e-02f, 6.29078373e-02f, 4.61119637e-02f,
  -3.14013055e-03f, -9.41315107e-03f, 3.04112077e-01f, 2.28408679e-01f, -2.84310170e-02f, 4.00980599e-02f, 5.66689074e-02f, 2.61817813e-01f, -2.69879736e-02f, -5.55168688e-02f,
  -3.29314142e-01f, 1.22868098e-01f, -1.62170559e-01f, -6.19142354e-02f, -2.04804167e-01f, -1.08709931e-01f, -1.54326797e-01f, -8.30225423e-02f, 1.28607522e-03f, 3.31583619e-02f,
  -1.28369153e-01f, 1.25248000e-01f, -9.23573077e-02f, 3.83572690e-02f, -9.35879648e-02f, 7.63668790e-02f, 1.17636368e-01f, 5.47045954e-02f, -1.55638317e-02f, 6.38683438e-02f,
  1.28266037e-01f, 2.15951093e-02f, 3.21521200e-02f, 7.89918825e-02f, -2.40353327e-02f, -2.05201097e-02f, 4.67636921e-02f, 3.26000601e-02f, -6.07647412e-02f, 3.20476457e-03f,
  -3.26486044e-02f, -5.35422412e-04f, -7.24567473e-02f, 2.71820230e-03f, 3.26679088e-02f, 8.42300057e-02f, 1.67457201e-02f, -1.74390257e-03f, 1.58112403e-02f, -6.21087737e-02f,
  -7.24519193e-02f, 7.65110552e-02f, -6.32714406e-02f, -1.91328436e-01f, -9.56406593e-02f, -3.75759378e-02f, -3.38055268e-02f, -2.71362849e-02f, -5.41796908e-02f, -6.86550885e-02f,
  9.89500135e-02f, -2.68752985e-02f, 9.53252427e-03f, -1.15294702e-01f, -7.90464431e-02f, 2.18757112e-02f, 1.33420214e-01f, -2.51764935e-02f, -1.16170645e-01f, -9.04073641e-02f,
  -2.53958255e-01f, 1.91802591e-01f, -3.91578786e-02f, -1.74542591e-01f, -8.37839842e-02f, -7.64558166e-02f, 1.72185376e-02f, 8.00606702e-03f, -7.44235590e-02f, -1.97501630e-02f,
  -1.53495848e-01f, -1.33447453e-01f, -5.27632348e-02f, -1.06105879e-01f, 4.91478071e-02f, 3.77334058e-02f, -8.91105384e-02f, -1.53190587e-02f, 3.65735479e-02f, 6.97121024e-02f,
  1.08365841e-01f, 2.32806671e-02f, 2.27955561e-02f, -2.82593872e-02f, 2.05709282e-02f, 1.40038524e-02f, 7.36236870e-02f, 4.62163053e-03f, -1.47311613e-02f, 2.26592287e-01f,
  3.51338029e-01f, -1.88380584e-01f, 2.74901167e-02f, 3.33874166e-01f, 2.25840122e-01f, 1.74045973e-02f, -8.29510540e-02f, 2.37677857e-01f, 5.94952524e-01f, -1.37899265e-01f,
  -3.27213183e-02f, -2.56289750e-01f, -2.45666236e-01f, -2.28103235e-01f, -2.43515462e-01f, -1.39585972e-01f, 8.19587037e-02f, -8.46466981e-03f, 2.29499340e-01f, -1.39535852e-02f,
  1.37613237e-01f, -4.04505074e-01f, -2.95788765e-01f, -2.10640535e-01f, -8.15680549e-02f, 2.21528172e-01f, -9.37346891e-02f, -1.43652126e-01f, -7.08413050e-02f, -2.34827548e-01f,
  3.63077857e-02f, 1.03801399e-01f, -1.47393597e-02f, -1.97725266e-01f, 1.59085214e-01f, 7.05743860e-03f, 3.29400674e-02f, -1.19136602e-01f, -9.03098062e-02f, 1.02223024e-01f,
  1.23112433e-01f, -6.46785870e-02f, 9.29726064e-02f, -1.56426221e-01f, 1.62981842e-02f, 6.87556267e-02f, 9.49787647e-02f, 1.04835711e-01f, -2.53333598e-01f, -1.71700850e-01f,
  -1.71078876e-01f, 1.37192890e-01f, 2.38986626e-01f, 7.33216256e-02f, 8.95585418e-02f, 1.55887410e-01f, -4.72269505e-02f, -8.40639398e-02f, -7.03663332e-03f, 4.69617844e-02f,
  -5.53346127e-02f, -5.28494380e-02f, 2.29469594e-02f, -3.06588151e-02f, -8.26141238e-02f, 1.56511381e-01f, 7.77021572e-02f, 8.03327039e-02f, 2.49020070e-01f, -6.78133518e-02f,
  8.19034055e-02f, -5.92170954e-02f, 1.00952052e-01f, 3.51834856e-02f, -4.50239219e-02f, -1.43704757e-01f, -8.99952650e-02f, 2.75023371e-01f, 2.13750258e-01f, -2.01409966e-01f,
  -1.42966717e-01f, -1.98278055e-02f, -1.09568745e-01f, 1.14295490e-01f, -1.13493696e-01f, 1.85890853e-01f, 4.10108492e-02f, -6.79890951e-03f, 9.67802331e-02f, -1.03540115e-01f,
  9.19876620e-03f, -8.26057512e-03f, -1.03280015e-01f, 1.43521670e-02f, -5.67137636e-02f, -8.38589519e-02f, -9.19823498e-02f, 1.40919298e-01f, -1.91074282e-01f, 1.56733394e-01f,
  1.20443337e-01f, 9.60916951e-02f, 1.60256118e-01f, 9.49875042e-02f, 1.94750801e-02f, 1.56611260e-02f, 4.36425433e-02f, -7.57391239e-03f, -5.94835281e-02f, -5.96911348e-02f,
  -8.99027660e-02f, 1.23467483e-01f, -1.40070766e-01f, 3.44348662e-02f, 1.32791758e-01f, 9.48986560e-02f, 5.09971678e-02f, -5.06280176e-02f, -1.06961489e-01f, 7.80602470e-02f,
  4.26993489e-01f, -3.72360237e-02f, 1.45632952e-01f, -4.62511089e-03f, -2.10270941e-01f, -1.92853376e-01f, -3.34513009e-01f, -2.91989237e-01f, -3.70254703e-02f, -2.67366916e-01f,
  -2.20858082e-01f, -5.94394393e-02f, -1.86687604e-01f, -2.94007689e-01f, 2.22439356e-02f, -4.96352576e-02f, -1.65996984e-01f, -2.31328458e-01f, 1.96815893e-01f, -1.18314996e-01f,
  4.35037091e-02f, -4.55021769e-01f, -8.60361829e-02f, -4.59963918e-01f, -1.76500723e-01f, 1.29973471e-01f, 1.45360366e-01f, -2.63058305e-01f, -1.89633667e-01f, -1.52716845e-01f,
  -4.65912260e-02f, 6.68057501e-02f, 5.14813885e-02f, -1.00476306e-03f, -1.74882635e-02f, 9.21087191e-02f, 5.71384467e-03f, -8.69137868e-02f, -1.52525723e-01f, 8.13030228e-02f,
  4.32621576e-02f, 1.90956555e-02f, -9.73938480e-02f, -7.01894686e-02f, -2.29778979e-02f, -2.00921465e-02f, 8.09977353e-02f, 6.08006380e-02f, -2.00167075e-01f, 1.85311899e-01f,
  -1.07885212e-01f, -2.40549892e-02f, 1.04566365e-01f, -1.06760949e-01f, -7.05224946e-02f, -6.56733895e-03f, 2.03342475e-02f, -1.22203507e-01f, 1.08629651e-01f, 7.58483037e-02f,
  5.15652671e-02f, 2.61205751e-02f, -2.06350595e-01f, 1.49553118e-03f, -1.39423564e-01f, 1.58164635e-01f, 4.83682519e-03f, -2.65978463e-02f, 2.04562359e-02f, -5.95933897e-03f,
  -7.99535811e-02f, -3.48801613e-02f, -1.37092583e-02f, -5.95429502e-02f, 9.00162011e-03f, 1.16646379e-01f, 1.49393231e-02f, -1.79566480e-02f, -5.83816841e-02f, 8.93160775e-02f,
  1.65327899e-02f, -8.14177021e-02f, -1.60925642e-01f, 1.34187862e-02f, -1.49903856e-02f, 8.77747138e-04f, -9.20587406e-03f, 3.18025635e-03f, 2.08322797e-02f, -9.06341821e-02f,
  3.26894969e-02f, -1.37034997e-01f, 1.05978567e-02f, -1.09002955e-01f, 1.74989160e-02f, 7.91752115e-02f, -1.52422981e-02f, -1.49601132e-01f, -5.89559376e-02f, -1.40076801e-02f,
  -3.89655456e-02f, -7.65542015e-02f, 8.52166563e-02f, -5.06956279e-02f, -8.74874592e-02f, -3.96117382e-02f, -3.84978838e-02f, 4.92285416e-02f, -1.13281347e-02f, 7.98250213e-02f,
  -5.33300787e-02f, -9.14673787e-03f, 1.04152635e-01f, -1.65609986e-01f, -8.27722922e-02f, -5.57366647e-02f, -9.69515145e-02f, 7.95622095e-02f, 1.73811503e-02f, -3.97397839e-02f,
  3.10437769e-01f, -1.46942884e-01f, -3.69520813e-01f, -3.69157016e-01f, 1.73864365e-01f, 4.03701901e-01f, -1.26677856e-03f, -4.62961197e-02f, -2.61679351e-01f, 1.84100717e-01f,
  2.40915149e-01f, -6.83976114e-02f, 6.55327737e-02f, -1.01427943e-01f, 7.39351334e-03f, -2.38071740e-01f, 2.63748430e-02f, 4.96454500e-02f, -2.36487836e-01f, 2.83916414e-01f,
  1.64454225e-02f, 1.72478378e-01f, -2.63720274e-01f, 8.88108984e-02f, 2.96550453e-01f, 4.77448031e-02f, 1.88793570e-01f, 1.34186611e-01f, 1.89972430e-01f, -5.81257418e-02f,
  -1.92997586e-02f, -9.89900976e-02f, 2.10598651e-02f, -1.41636297e-01f, -8.23482946e-02f, 1.95091486e-01f, 2.77197361e-02f, -1.24490168e-02f, 4.72589321e-02f, -8.92139599e-02f,
  8.85526091e-02f, -3.78303714e-02f, -1.77856293e-02f, 4.63250354e-02f, 1.41051188e-01f, 3.12660029e-03f, 1.41212428e-02f, -4.76487949e-02f, -7.13341907e-02f, 8.34024400e-02f,
  -1.04042657e-01f, 5.87512031e-02f, 4.58872095e-02f, -1.63334310e-01f, -6.33803010e-02f, 1.87014081e-02f, 1.69296805e-02f, 1.41005635e-01f, -1.29120916e-01f, -3.46335582e-02f,
  6.86128885e-02f, 5.63875027e-02f, 9.33123454e-02f, -2.14270234e-01f, 2.52076965e-02f, -9.21847895e-02f, 2.42681075e-02f, -1.09051272e-01f, -2.87785977e-02f, -4.90578171e-03f,
  -3.27335410e-02f, 1.46553190e-02f, -8.27493891e-02f, -5.04135638e-02f, 1.00259967e-01f, 6.57528173e-03f, 2.13347860e-02f, 1.02595724e-01f, -2.38340552e-04f, -9.58386362e-02f,
  -1.38178244e-01f, -1.82245541e-02f, 1.50011733e-01f, 3.69477607e-02f, -6.65589571e-02f, -8.12203903e-03f, -1.94921121e-02f, 8.06361586e-02f, -1.47713512e-01f, -7.27314949e-02f,
  4.37957160e-02f, 1.89100593e-01f, 3.79465558e-02f, -9.79887769e-02f, -8.67330506e-02f, 8.74885470e-02f, -1.50751257e-02f, -1.37481615e-01f, 7.12080672e-02f, 1.25204533e-01f,
  4.50120717e-02f, -2.59718020e-03f, 2.42547080e-01f, -1.34472772e-01f, -2.62340695e-01f, 1.67911395e-01f, 5.85832968e-02f, 4.70086262e-02f, -4.81307134e-02f, 1.69581205e-01f,
  -2.54359599e-02f, 6.57755807e-02f, -1.39320493e-01f, -9.81934741e-02f, 8.71258602e-02f, 1.74259216e-01f, 2.53112197e-01f, 7.85477534e-02f, 6.25922307e-02f, -2.32532695e-01f,
  6.39666244e-02f, 3.79325360e-01f, -8.32994208e-02f, -2.11111903e-02f, -1.52728967e-02f, -5.45885742e-01f, -2.39761874e-01f, -1.03432618e-01f, 1.89217776e-02f, 1.86644807e-01f,
  -2.13660985e-01f, 5.04438281e-01f, 9.18937922e-02f, -1.93137139e-01f, -5.00240207e-01f, -2.79223174e-01f, -3.17183316e-01f, 7.06824437e-02f, 5.13933264e-02f, 2.38304827e-02f,
  -1.76202491e-01f, -2.41767183e-01f, -2.47531042e-01f, -1.34815261e-01f, -1.15974911e-01f, 1.61537424e-01f, -9.51889381e-02f, 2.14732606e-02f, -1.70867205e-01f, -1.34168029e-01f,
  -1.74061656e-01f, 1.44854143e-01f, 1.18344136e-01f, 1.04591232e-02f, -1.89549536e-01f, 5.76682091e-02f, -2.70253420e-02f, 6.03258470e-03f, -3.46363559e-02f, -4.81389724e-02f,
  1.30600423e-01f, -9.24663842e-02f, -6.35356084e-02f, -1.03475517e-02f, -5.05309179e-02f, 1.34258762e-01f, 2.99204164e-03f, -1.26248613e-01f, 1.76219106e-01f, 1.00767918e-01f,
  6.91006333e-02f, 2.06959825e-02f, 5.02494425e-02f, 9.14784297e-02f, -5.28985448e-02f, 5.51301800e-03f, -1.14863276e-01f, 5.29386401e-02f, 5.73231131e-02f, -1.16086170e-01f,
  6.73818439e-02f, 1.59678813e-02f, 8.17283243e-03f, -2.20240820e-02f, -4.05516177e-02f, 8.56128111e-02f, 2.12946143e-02f, 5.08563891e-02f, 1.20788306e-01f, -1.43138692e-02f,
  -7.69320652e-02f, 8.77801180e-02f, -2.17658863e-03f, -5.13092428e-02f, -6.88017234e-02f, 6.94636852e-02f, -9.60018858e-03f, 9.94126871e-02f, 4.47423793e-02f, -9.85247865e-02f,
  1.74745113e-01f, -1.25108659e-01f, 8.22243840e-02f, -9.17124655e-03f, -4.46825102e-02f, 5.60787767e-02f, -3.73959839e-02f, 1.02312222e-01f, 9.92814153e-02f, 2.80943757e-04f,
  -1.08159684e-01f, -5.00151403e-02f, 4.04694155e-02f, -7.42862816e-04f, -1.76919736e-02f, -5.66153936e-02f, 2.84233205e-02f, 7.54108652e-02f, -1.44819126e-01f, -9.29008126e-02f,
  1.29038217e-02f, -1.23717785e-02f, -1.63557276e-01f, -7.98980445e-02f, 2.52282210e-02f, -1.91469997e-01f, -6.67187870e-02f, -6.38473406e-02f, -4.02372964e-02f, 3.17901857e-02f,
  1.28122687e-01f, 1.97676092e-01f, 4.84582372e-02f, 2.24431865e-02f, 1.81935802e-01f, 1.93100870e-02f, 1.04950890e-01f, 1.07782178e-01f, 3.50790867e-03f, 8.48619267e-03f,
  -5.20148277e-01f, -8.39871541e-02f, 1.32953599e-01f, -4.27916408e-01f, -8.73315930e-02f, 3.81989896e-01f, 1.84977293e-01f, -1.87896594e-01f, -3.84097278e-01f, -1.90037102e-01f,
  -1.49927676e-01f, -1.63297608e-01f, 2.72607982e-01f, -3.75613868e-01f, 5.06804585e-01f, 2.39492327e-01f, -1.51297376e-01f, 1.16434703e-02f, -1.23092830e-01f, -1.31108493e-01f,
  -1.46310762e-01f, -2.74615943e-01f, 2.14924365e-01f, -1.12497203e-01f, -2.34237298e-01f, -1.73232377e-01f, -5.09266183e-02f, 5.38190790e-02f, -1.57217950e-01f, 3.63065936e-02f,
  -1.98866680e-01f, -3.53177994e-01f, -1.75297797e-01f, -6.25416040e-02f, -7.03485981e-02f, 4.88654673e-02f, 2.63280030e-02f, 1.36541709e-01f, -8.03168043e-02f, -9.63422209e-02f,
  5.49283475e-02f, -1.55897671e-02f, -8.56897309e-02f, -2.28505302e-02f, -5.10802455e-02f, -8.05648565e-02f, -1.64556894e-02f, -2.24338733e-02f, -6.47611842e-02f, 2.95760892e-02f,
  1.61846336e-02f, 1.72021091e-02f, -1.42781781e-02f, -1.04274869e-01f, -2.12580170e-02f, -8.14391077e-02f, -5.24892956e-02f, 2.48130616e-02f, -1.33227035e-02f, -4.87140045e-02f,
  1.48249030e-01f, 8.09397176e-03f, 1.43404296e-02f, -8.34907442e-02f, 4.09735553e-03f, -1.33136854e-01f, -2.44549382e-02f, 1.02164261e-01f, -1.57808303e-03f, 3.96669190e-03f,
  -3.15994546e-02f, -4.65419292e-02f, -1.57685027e-01f, 3.70406685e-03f, -3.16488510e-03f, -8.74130502e-02f, 1.66872684e-02f, -1.78216733e-02f, 1.57954022e-02f, 5.09442613e-02f,
  5.34950616e-03f, 4.12025787e-02f, -1.72196738e-02f, -3.84872966e-02f, 9.95946378e-02f, 9.57885012e-02f, -3.04078683e-02f, 8.36366042e-03f, -4.25062440e-02f, 8.61312225e-02f,
  -3.14122140e-02f, -1.65129378e-01f, 6.37861267e-02f, -8.62279311e-02f, -3.63025405e-02f, -4.98582758e-02f, 7.74526447e-02f, -4.13452983e-02f, -4.88402098e-02f, -9.84403417e-02f,
  7.05795214e-02f, 3.94848473e-02f, -1.10319480e-01f, 7.59274438e-02f, 6.65181652e-02f, 6.01835083e-03f, -6.42769411e-02f, -1.28072441e-01f, 5.12610823e-02f, 4.62735817e-02f,
  -9.55500603e-02f, -7.90466070e-02f, 1.78566650e-01f, -9.56765190e-03f, -3.72412354e-02f, 5.59020117e-02f, -1.91918522e-01f, 2.32958738e-02f, 6.51622787e-02f, 9.38960537e-03f,
  -4.61883813e-01f, -4.76817608e-01f, -1.75582081e-01f, 4.18696590e-02f, -1.90803066e-01f, -1.93793532e-02f, -1.80067897e-01f, -3.54781181e-01f, -1.61157846e-01f, -1.84541419e-01f,
  3.98200899e-02f, -4.17636111e-02f, -3.86685163e-01f, 1.41185865e-01f, 1.46124691e-01f, -2.58043349e-01f, 2.15926811e-01f, 2.58178473e-01f, -1.55017693e-02f, -2.34264135e-01f,
  -3.68547775e-02f, -8.05932842e-03f, 4.05073687e-02f, 1.84723154e-01f, -8.09799209e-02f, 1.32581756e-01f, 3.66058230e-01f, 1.97704181e-01f, 4.48153019e-01f, 1.96138903e-01f,
  -3.81850265e-02f, -2.79951870e-01f, -1.44528821e-01f, 2.57705320e-02f, -4.63162288e-02f, 2.54252642e-01f, 1.43999040e-01f, 1.69752762e-01f, 1.64149463e-01f, -7.87290744e-03f,
  6.52130917e-02f, 8.79556537e-02f, -6.83196215e-03f, 1.30388677e-01f, 7.74293113e-03f, 5.35038710e-02f, 3.33564132e-02f, -7.11312220e-02f, -1.14933752e-01f, -2.18036443e-01f,
  -1.95960492e-01f, -1.37922078e-01f, 3.99796814e-02f, 7.05471411e-02f, -2.38746200e-02f, -1.10206574e-01f, 1.23424269e-02f, -1.41416728e-01f, -4.13582008e-03f, -1.31036580e-01f,
  -1.11986056e-01f, -4.50311527e-02f, -7.70116299e-02f, 8.25044140e-02f, -1.28069967e-01f, 1.51538298e-01f, -1.19149976e-03f, -1.07459025e-02f, 5.70820533e-02f, -8.24245438e-02f,
  -2.91176755e-02f, 1.11480234e-02f, 2.20603973e-01f, 6.48563355e-02f, -1.35201171e-01f, -5.92444204e-02f, 6.70206696e-02f, -1.52001414e-03f, -5.95158860e-02f, 2.85596773e-02f,
  5.74860610e-02f, -4.19705138e-02f, -1.02210283e-01f, 1.91646442e-01f, -1.23928212e-01f, -6.20750785e-02f, -3.12063424e-03f, -2.88699586e-02f, 2.87641045e-02f, 1.27157137e-01f,
  -1.83052644e-02f, -1.84420466e-01f, 1.70924887e-02f, 6.20260425e-02f, -2.10717879e-02f, -5.71452007e-02f, -2.34351922e-02f, -1.76024332e-03f, 2.89222654e-02f, -1.56948864e-01f,
  1.15382798e-01f, 1.32691845e-01f, 5.60486168e-02f, 3.30503806e-02f, 1.45608932e-01f, -1.67221293e-01f, -9.60848387e-03f, 7.26276189e-02f, -2.32045148e-02f, 6.54184520e-02f,
  1.31004795e-01f, -1.22359931e-01f, 3.94394398e-02f, -2.36182678e-02f, 1.27399683e-01f, -5.90392724e-02f, -1.48965316e-02f, -1.58278883e-01f, 3.88380215e-02f, 3.27458419e-02f,
  -3.57849672e-02f, -1.60352483e-01f, 3.04616213e-01f, -2.14891717e-01f, 3.22246879e-01f, 5.18524349e-01f, 3.29866856e-01f, 7.22868592e-02f, -1.76054940e-01f, -2.93208659e-01f,
  -1.30496308e-01f, -2.42550578e-02f, 2.01813534e-01f, -2.64969707e-01f, 2.78823763e-01f, -3.90900820e-02f, -1.57265157e-01f, -3.62398624e-02f, 6.46543503e-02f, 2.10787356e-01f,
  3.99729125e-02f, -1.96568057e-01f, 4.43004929e-02f, -2.70489275e-01f, 3.97394896e-02f, -1.16036376e-02f, -1.21669792e-01f, 2.05203593e-01f, -2.60804385e-01f, 8.05173740e-02f,
  7.64171705e-02f, -1.10697821e-01f, 8.30081701e-02f, -6.24813437e-02f, 1.55557230e-01f, 1.00545324e-01f, 6.38854429e-02f, 9.03222635e-02f, 5.51562943e-02f, 3.06468513e-02f,
  -1.83473259e-01f, 7.38729397e-03f, -1.62372589e-01f, 3.09148841e-02f, 1.34378886e-02f, -8.42426494e-02f, 1.46253079e-01f, 7.21766204e-02f, 5.36191948e-02f, 1.35917410e-01f,
  2.06931919e-01f, -7.14716464e-02f, -1.12875894e-01f, -4.24543880e-02f, -5.41121922e-02f, -9.49902982e-02f, 4.03730646e-02f, 1.54190570e-01f, -4.57681045e-02f, 4.46149986e-03f,
  5.79498336e-02f, 1.87162608e-02f, 1.64120179e-02f, -4.55062129e-02f, 5.12829190e-03f, -7.44642839e-02f, 6.27423599e-02f, 1.15690781e-02f, 6.62539303e-02f, 5.31928241e-02f,
  -5.63437454e-02f, -7.76938647e-02f, 5.32802828e-02f, 4.20294814e-02f, 1.02855973e-02f, -1.48153514e-01f, 7.69317150e-02f, 7.85429776e-02f, 3.87654230e-02f, 3.98687646e-02f,
  -2.85186730e-02f, -6.13205098e-02f, 1.42081201e-01f, -3.39517258e-02f, -4.38654944e-02f, 3.41935195e-02f, -1.66076094e-01f, 4.77614328e-02f, -1.76558301e-01f, 1.38097093e-01f,
  7.60347173e-02f, -1.22645229e-01f, -2.23463140e-02f, -1.05411172e-01f, -4.03979421e-02f, -4.73506264e-02f, -1.40269822e-03f, -4.31948714e-02f, -1.16007484e-03f, -2.59258319e-02f,
  -9.14080143e-02f, -1.19953543e-01f, -2.52855346e-02f, 1.69670172e-02f, -3.26070301e-02f, -6.37930492e-03f, 4.38899137e-02f, 2.78386176e-02f, -1.29920198e-02f, -7.34162629e-02f,
  -8.49771947e-02f, -1.52430341e-01f, 2.89961454e-02f, -2.49736253e-02f, -9.41636264e-02f, -7.35904425e-02f, 7.47337788e-02f, -2.96229068e-02f, 1.60050213e-01f, -4.88728359e-02f,
  9.41734537e-02f, 2.99671471e-01f, -2.68770546e-01f, -4.32240427e-04f, 9.38790441e-02f, 4.98323023e-01f, 2.90098459e-01f, 1.49700679e-02f, 1.44862935e-01f, 3.11407179e-01f,
  -5.90447225e-02f, 1.57947645e-01f, -1.31043822e-01f, 2.64556766e-01f, 2.33027369e-01f, 1.30577505e-01f, 2.38180906e-01f, 2.99067229e-01f, -1.54970855e-01f, 1.78465605e-01f,
  4.81866449e-02f, 4.06367630e-01f, -2.13468090e-01f, -3.80039401e-02f, -6.24451451e-02f, -2.05297023e-01f, -1.87349930e-01f, -2.62709141e-01f, -5.15916832e-02f, 8.89717638e-02f,
  1.05363538e-03f, -6.48525655e-02f, -8.05855021e-02f, -3.41493599e-02f, -2.75335126e-02f, -1.35018332e-02f, -1.99172329e-02f, -5.29983602e-02f, -8.04608688e-02f, -1.03709169e-01f,
  1.06324919e-01f, -2.54920442e-02f, 9.56185311e-02f, 1.00567713e-02f, 4.33796681e-02f, -3.37175354e-02f, -7.38197342e-02f, -8.58317465e-02f, 1.27023598e-02f, -5.71811311e-02f,
  -1.50288846e-02f, -5.63840941e-02f, 1.85283402e-03f, 8.21430162e-02f, -7.05186576e-02f, 4.00734469e-02f, 2.98836287e-02f, -7.39995092e-02f, 1.26619250e-01f, 7.09441975e-02f,
  -2.58136131e-02f, 1.80028751e-01f, -5.70285767e-02f, -1.32656842e-01f, 3.00828218e-02f, -1.19520813e-01f, -3.19694728e-02f, -9.24083591e-02f, 4.24286872e-02f, 3.37825418e-02f,
  4.13549915e-02f, -2.27715094e-02f, 1.44561101e-03f, -3.96432728e-03f, -2.83531360e-02f, 2.00221092e-02f, -6.24752939e-02f, -1.82266869e-02f, -3.27018872e-02f, 2.94724461e-02f,
  -4.87689376e-02f, 3.71593684e-02f, -4.89695519e-02f, -1.57857150e-01f, 1.23089086e-03f, -1.25898318e-02f, 1.71181802e-02f, 1.76551548e-04f, -5.69551326e-02f, 6.63118362e-02f,
  1.73182562e-01f, 4.41704690e-01f, -1.00981347e-01f, -5.28875962e-02f, 9.95590687e-02f, 1.19095422e-01f, 1.06958665e-01f, 9.03563946e-02f, -9.69033164e-04f, 1.44771308e-01f,
  1.12805553e-01f, -1.00644447e-01f, -7.06141489e-03f, -7.91031644e-02f, 5.61456103e-03f, 9.86028612e-02f, 9.55682062e-03f, 5.02849594e-02f, 5.54873385e-02f, 9.43242311e-02f,
  6.28837710e-03f, 1.49408206e-01f, 1.08273789e-01f, 3.41876000e-02f, 6.40137196e-02f, 5.91413528e-02f, 1.42885476e-01f, -3.26389000e-02f, 3.65841202e-02f, -2.09616721e-02f,
  -5.45755148e-01f, 4.32971328e-01f, -2.44471923e-01f, 1.01323187e-01f, 4.29327786e-02f, -1.76468372e-01f, 1.84183225e-01f, 1.34171858e-01f, 1.55991510e-01f, 3.69790375e-01f,
  3.19191635e-01f, 1.42517865e-01f, 4.06527281e-01f, 4.54693079e-01f, -2.77261227e-01f, 3.77552688e-01f, 1.56545982e-01f, -4.10408825e-02f, 4.14186306e-02f, 2.09473863e-01f,
  -1.83904275e-01f, 4.87283915e-01f, 1.19194560e-01f, 1.71936840e-01f, -3.41912522e-03f, -1.97012752e-01f, 2.52079815e-01f, -6.14061691e-02f, 1.12696670e-01f, 5.20548038e-02f,
  3.66033278e-02f, 2.43858755e-01f, -2.62521077e-02f, -1.39302507e-01f, -2.17375010e-01f, -1.28564879e-01f, -1.90194786e-01f, -1.26812711e-01f, 5.20976894e-02f, 2.16051154e-02f,
  -5.84289730e-02f, -5.92634380e-02f, 1.22522134e-02f, 8.08130112e-03f, -1.30958930e-01f, 3.49066518e-02f, -4.03515548e-02f, -1.26417115e-01f, 8.05753097e-02f, -1.54868839e-03f,
  -6.49022385e-02f, -1.93741452e-02f, -5.23341410e-02f, 6.00809120e-02f, -1.86016764e-02f, 6.89113513e-02f, -8.02522227e-02f, -1.12254381e-01f, -3.73231880e-02f, 1.65443551e-02f,
  -1.26372594e-02f, -2.04293430e-02f, -3.64533626e-02f, 6.37768731e-02f, 1.10505246e-01f, -6.36268780e-02f, 8.65537971e-02f, 6.40445054e-02f, -5.48601262e-02f, 2.11726893e-02f,
  -3.02378479e-02f, 5.66280410e-02f, 1.02112398e-01f, -6.54621497e-02f, 6.34991601e-02f, -2.06352938e-02f, -7.53696039e-02f, 3.03246379e-02f, -7.63597637e-02f, -1.82884503e-02f,
  8.77692476e-02f, -2.36388873e-02f, 1.43639848e-01f, 2.67780237e-02f, 5.58489077e-02f, 6.48632199e-02f, 8.28810483e-02f, -1.77645385e-02f, 1.64728165e-02f, 8.51107854e-03f,
  2.54433095e-01f, 3.02300572e-01f, 6.72746375e-02f, 8.11134353e-02f, 5.74757122e-02f, 8.74825381e-03f, -2.35831533e-02f, -1.60514697e-01f, 7.42918476e-02f, -2.70312708e-02f,
  7.89418072e-03f, 3.81028056e-02f, -9.35920924e-02f, -4.90688952e-03f, -1.40774205e-01f, 8.26938376e-02f, 1.42400116e-01f, -2.15880517e-02f, -3.11916624e-03f, 3.98617014e-02f,
  8.09395760e-02f, -1.36898505e-02f, 5.43811396e-02f, 4.49274965e-02f, 9.86397937e-02f, -3.89219038e-02f, -8.77063498e-02f, -1.25230342e-01f, -1.41690625e-02f, -5.03516272e-02f,
  2.64294028e-01f, 2.92176396e-01f, 3.53260994e-01f, 2.50502408e-01f, 3.01316381e-01f, 2.86067754e-01f, -3.07002617e-03f, 2.80232072e-01f, 5.82882106e-01f, -7.49483183e-02f,
  -2.97575947e-02f, 8.69882628e-02f, -3.67219388e-01f, 2.38991454e-01f, -1.53120235e-01f, -1.78364784e-01f, 1.92086130e-01f, 6.45728335e-02f, -4.90439031e-03f, 9.19029489e-02f,
  -7.59911211e-03f, -3.76523405e-01f, -1.22331358e-01f, -3.16629231e-01f, 5.01517169e-02f, 9.60840955e-02f, -4.20352697e-01f, -2.13533282e-01f, -1.46040797e-01f, -1.00864574e-01f,
  1.09211477e-02f, 2.09808107e-02f, -5.49005829e-02f, -2.49558147e-02f, 7.01222122e-02f, 1.15504347e-01f, -1.05121888e-01f, -1.42588079e-01f, 9.45164561e-02f, 4.51104082e-02f,
  2.86287162e-02f, -9.30110216e-02f, -2.95364168e-02f, -5.88001572e-02f, 8.36948380e-02f, 1.03567980e-01f, -7.33040506e-03f, 1.68814480e-01f, 1.14528336e-01f, -1.71738770e-02f,
  2.84413159e-01f, 2.70921350e-01f, 1.83340088e-01f, 8.30457807e-02f, 1.14157073e-01f, 7.81156719e-02f, 6.90091029e-02f, 3.16130444e-02f, -8.14855397e-02f, 9.82304066e-02f,
  3.86363789e-02f, 3.49983424e-02f, -7.47690648e-02f, -1.32360160e-01f, 3.18040438e-02f, 9.73739102e-02f, -5.09699844e-02f, -1.47410929e-01f, -6.01106472e-02f, -2.25791633e-02f,
  -1.68308560e-02f, -1.11175794e-02f, 1.39226010e-02f, 1.36476874e-01f, 1.02542505e-01f, 4.77735773e-02f, -2.42501218e-02f, -2.51598540e-03f, 4.40473557e-02f, 1.46164782e-02f,
  -1.39812678e-02f, 1.19009174e-01f, -5.87698296e-02f, 1.06733795e-02f, 1.53440349e-02f, -3.83128412e-02f, 1.12576286e-04f, 1.02364704e-01f, 1.10706076e-01f, -1.51219189e-01f,
  7.83306733e-02f, -4.06030789e-02f, 3.29047046e-03f, -3.23108621e-02f, -6.25189245e-02f, -3.30427755e-03f, -1.29812852e-01f, 1.22233063e-01f, -3.37107778e-02f, -7.24260658e-02f,
  8.05613846e-02f, 1.01501778e-01f, -2.47676671e-02f, -3.90092432e-02f, -1.59074649e-01f, -1.52877063e-01f, -2.08275728e-02f, 3.56227458e-02f, 1.32743800e-02f, -1.30295800e-02f,
  2.12988093e-01f, -4.77004424e-02f, 4.46545072e-02f, 8.00183415e-02f, 1.36603385e-01f, -8.14251229e-03f, -3.33651304e-02f, 6.92445785e-02f, -2.84361374e-02f, 1.58797950e-03f,
  9.37266834e-03f, -1.70108676e-01f, -1.36305988e-01f, 2.33321875e-01f, 1.25210509e-01f, 1.93459745e-02f, 1.49778277e-02f, 2.64489621e-01f, 4.33309823e-01f, -5.75041361e-02f,
  2.04245429e-02f, -4.19079542e-01f, 7.92515650e-02f, -2.38778204e-01f, -2.16696486e-01f, -7.65078515e-02f, -6.98479936e-02f, -1.76104829e-01f, 1.63149074e-01f, -1.65434226e-01f,
  1.57090366e-01f, -2.18556613e-01f, -1.31543756e-01f, -1.08176835e-01f, -1.58135340e-01f, 1.20554939e-01f, -5.27821556e-02f, -1.34815976e-01f, -2.10356623e-01f, -1.66365847e-01f,
  5.70749445e-03f, 6.20023645e-02f, -2.60430668e-02f, -2.62661930e-03f, 1.88296586e-01f, -2.72485055e-02f, -1.59984633e-01f, -4.22224551e-02f, 1.40494332e-01f, 8.54526162e-02f,
  -1.53912753e-01f, -1.22088842e-01f, 4.15308634e-03f, -4.59269285e-02f, 1.94857299e-01f, 1.01162300e-01f, 1.37982145e-02f, 7.52880573e-02f, -1.10034794e-01f, -1.23118222e-01f,
  -8.49413797e-02f, 1.68860499e-02f, 1.47320867e-01f, -3.45508242e-03f, -3.95937935e-02f, 1.86942965e-01f, 4.22188900e-02f, -1.86128169e-01f, 1.17911279e-01f, -4.83752452e-02f,
  -8.58301520e-02f, 1.81405228e-02f, -5.99094220e-02f, 1.45787410e-02f, -1.82336643e-02f, 1.40551731e-01f, 7.01347291e-02f, 3.96270454e-02f, 1.65508717e-01f, -2.59933695e-02f,
  1.05416365e-01f, -5.80988154e-02f, 1.04651578e-01f, 3.13198529e-02f, 3.03881187e-02f, 2.68412083e-02f, -5.34875095e-02f, 8.70011374e-02f, 2.04739887e-02f, 7.67880902e-02f,
  -1.74607933e-01f, -9.31976289e-02f, 4.52633090e-02f, 1.34079143e-01f, 1.68255623e-02f, -5.20549193e-02f, -1.02675527e-01f, -2.22051213e-03f, 1.00775614e-01f, 3.26594189e-02f,
  7.61596560e-02f, 2.36831494e-02f, 1.18321128e-01f, -7.32553527e-02f, 5.60872667e-02f, -3.51419672e-02f, -1.05277752e-03f, -1.13760062e-01f, 5.61522022e-02f, 7.65887601e-03f,
  -9.88477319e-02f, -1.38722882e-01f, 7.08712777e-03f, -7.85469860e-02f, 9.92045701e-02f, 1.64528966e-01f, -6.12838306e-02f, 1.09851442e-01f, 7.97849968e-02f, -1.51052326e-01f,
  -2.38934532e-01f, 5.16763255e-02f, 4.47832011e-02f, 1.67603895e-01f, -4.25995737e-02f, -2.84182038e-02f, -4.99131754e-02f, 3.14650573e-02f, -6.18963018e-02f, 3.75310220e-02f,
  2.38717318e-01f, -7.15917885e-01f, -2.12074280e-01f, 2.47881144e-01f, 2.64455378e-01f, 1.36847869e-01f, 1.83602229e-01f, -1.17459267e-01f, 5.94656356e-02f, -3.09709191e-01f,
  2.70123690e-01f, -2.50900418e-01f, -1.92771628e-01f, 3.16252947e-01f, 3.13920856e-01f, -4.81578186e-02f, 1.95032790e-01f, 1.96306258e-01f, 1.88569780e-02f, -8.70879292e-02f,
  2.77995706e-01f, 2.22913861e-01f, 1.22281827e-01f, -2.88755596e-01f, 1.56722337e-01f, -1.41072690e-01f, 3.06796655e-02f, -3.02574992e-01f, 1.60230547e-01f, 7.85457268e-02f,
  -1.22172944e-01f, 7.66318366e-02f, 1.04140587e-01f, -1.54674545e-01f, -4.95025925e-02f, -9.04220492e-02f, -7.38111958e-02f, -4.76290435e-02f, 1.39663607e-01f, -4.82124649e-02f,
  -8.44177157e-02f, 1.02758572e-01f, 5.80116212e-02f, -4.13096137e-02f, 6.99787494e-03f, -2.89520863e-02f, 1.39808223e-01f, 7.05336481e-02f, 7.53583312e-02f, 2.97406428e-02f,
  -4.02128361e-02f, 4.24433425e-02f, 4.97216098e-02f, 4.53299992e-02f, 1.31368846e-01f, 4.21282202e-02f, 6.82912022e-02f, -2.70280428e-02f, -1.66698083e-01f, 7.39197433e-03f,
  2.62191538e-02f, -1.09108351e-02f, -4.40193787e-02f, 7.04056993e-02f, 1.53876273e-02f, 1.18862428e-01f, -1.30617172e-01f, 6.61597922e-02f, -1.02897763e-01f, -1.03448756e-01f,
  8.28233734e-02f, 3.07334252e-02f, -1.62582789e-02f, -6.44412264e-02f, 5.62177263e-02f, 6.04390875e-02f, 4.98084985e-02f, -2.57625468e-02f, 1.60016641e-02f, 1.79509252e-01f,
  -1.24726646e-01f, -6.23260401e-02f, 3.70467454e-02f, 4.68241721e-02f, -6.80953264e-02f, -1.24176480e-01f, -5.26003446e-03f, -2.98479549e-03f, -8.26293677e-02f, -1.66430615e-03f,
  -6.84720814e-01f, -5.74036956e-01f, -3.06628812e-02f, 6.71902671e-02f, -6.71527609e-02f, -1.01480722e-01f, 3.10694501e-02f, -4.40867357e-02f, -2.29783714e-01f, 8.38300586e-02f,
  -5.23399115e-02f, 2.08160747e-02f, -8.25975612e-02f, 3.41584645e-02f, -1.50917232e-01f, -3.25402990e-02f, -1.50850356e-01f, -2.82357186e-02f, -1.65628809e-02f, -5.49232773e-02f,
  -8.28582421e-02f, -2.09038402e-03f, -1.88999828e-02f, 2.01497767e-02f, 9.66588184e-02f, 4.51416755e-03f, -1.25718098e-02f, -1.46063104e-01f, 7.28731230e-02f, -1.06244043e-01f,
  4.88986641e-01f, -1.73664063e-01f, -2.83242702e-01f, 2.16724277e-01f, 1.92734584e-01f, -1.57505840e-01f, -2.27342054e-01f, 1.83206394e-01f, 6.71201050e-02f, -2.46618271e-01f,
  2.57560879e-01f, -1.71958223e-01f, -2.73687541e-01f, 3.33288461e-01f, 3.99938792e-01f, -4.30888273e-02f, 3.27387154e-01f, -4.02486660e-02f, 2.37447307e-01f, 2.84401327e-01f,
  1.84252247e-01f, 4.32208300e-01f, 1.53245270e-01f, 5.79265133e-02f, 1.85337186e-01f, 5.14833198e-04f, 2.40178585e-01f, -3.28591436e-01f, 6.81816265e-02f, -4.62777652e-02f,
  8.19243044e-02f, 2.39644617e-01f, 5.28701879e-02f, -1.64134219e-01f, 1.91726148e-01f, 1.06022187e-01f, -1.10206075e-01f, -1.11855164e-01f, -1.12968842e-02f, -1.33541659e-01f,
  -3.37649174e-02f, 3.36965546e-02f, -3.46733183e-02f, -1.11026339e-01f, 1.72860414e-01f, 1.95493344e-02f, 8.87182131e-02f, -5.02570979e-02f, -1.51379839e-01f, 2.31656525e-02f,
  1.84997879e-02f, -4.32624668e-02f, 8.71220082e-02f, -1.27720430e-01f, -4.11306322e-02f, -2.89860927e-03f, -7.76566789e-02f, -7.26370364e-02f, -2.99746953e-02f, 7.89698884e-02f,
  6.59619123e-02f, -1.25188529e-02f, 1.04751237e-01f, 7.59701803e-02f, 9.89123881e-02f, -8.13854784e-02f, -5.75233996e-02f, -1.31208107e-01f, -5.89630790e-02f, 1.12188384e-02f,
  4.10189517e-02f, 8.81053433e-02f, 6.09033667e-02f, -1.13245264e-01f, 7.14885592e-02f, 1.66080780e-02f, -7.35145211e-02f, -8.03998187e-02f, 5.21232076e-02f, -1.63110979e-02f,
  -1.85788106e-02f, 3.48894186e-02f, 7.22936764e-02f, -3.62721980e-02f, -7.48703023e-03f, -4.70400117e-02f, 3.26938145e-02f, -3.47539373e-02f, 6.99367747e-02f, -3.86744807e-03f,
  5.44180684e-02f, -2.42440663e-02f, -9.46159661e-02f, -8.65469594e-03f, -8.94995704e-02f, 1.96334630e-01f, 9.66220105e-04f, -9.47468206e-02f, -1.23655945e-01f, 6.57857060e-02f,
  -7.19799567e-03f, -9.27134454e-02f, -6.55209497e-02f, 1.16038218e-01f, -9.19435024e-02f, 9.29429084e-02f, -1.57576442e-01f, -5.22371270e-02f, -2.44335439e-02f, 6.18381090e-02f,
  -3.61442603e-02f, -2.60493103e-02f, 2.92031784e-02f, 4.80266735e-02f, -6.34011999e-02f, 1.60982050e-02f, 2.41356734e-02f, -1.52020040e-03f, 9.65122804e-02f, -1.40716091e-01f,
  -4.45959046e-02f, -2.44758859e-01f, 2.06839949e-01f, 4.89632040e-02f, -1.18854888e-01f, -2.81031966e-01f, 5.49501507e-03f, -1.29806101e-01f, -3.13989669e-01f, -3.62385541e-01f,
  -1.67303339e-01f, 2.72166848e-01f, 2.96490192e-01f, -3.23539943e-01f, 4.91006643e-01f, 3.12476844e-01f, -8.10977221e-02f, -4.49300781e-02f, 2.14276925e-01f, -3.92803103e-02f,
  2.24040866e-01f, -1.06856823e-01f, 4.28364038e-01f, -2.12860122e-01f, -1.28145561e-01f, 1.87058852e-03f, 2.18316317e-01f, 2.81627059e-01f, -1.54977515e-01f, 8.67010057e-02f,
  -2.96907693e-01f, -1.67416602e-01f, -9.26491991e-02f, -5.60020544e-02f, -1.04859933e-01f, -9.68287736e-02f, 1.39089674e-01f, 9.80640948e-02f, 5.27123027e-02f, 1.60406902e-01f,
  -8.44163448e-03f, 5.20189963e-02f, -6.12494797e-02f, 2.94985622e-02f, -1.34230047e-01f, -1.10768221e-01f, -3.90894040e-02f, -6.76683858e-02f, -1.04329968e-02f, 1.81997474e-03f,
  -9.52158240e-04f, 1.39059899e-02f, 9.87903588e-03f, 4.42784727e-02f, 1.08324386e-01f, -1.87143058e-01f, 1.35720456e-02f, 1.73642844e-01f, -8.32392182e-03f, -2.96798702e-02f,
  7.17516430e-03f, 6.46576285e-02f, 4.25204225e-02f, -3.27712372e-02f, 7.03840405e-02f, -5.12417927e-02f, -6.24964237e-02f, -2.45065633e-02f, 1.00436985e-01f, -4.35070433e-02f,
  -1.16628736e-01f, -2.43560318e-03f, -5.85175632e-03f, -7.39020109e-02f, 2.90858950e-02f, -5.01228869e-02f, 1.32695183e-01f, -2.01896280e-02f, -2.52600498e-02f, 4.15978581e-02f,
  -7.90411234e-02f, -5.41846007e-02f, -7.85335228e-02f, -2.39645820e-02f, -5.72700612e-02f, 1.60591245e-01f, -5.48226051e-02f, -7.53702074e-02f, 7.33166412e-02f, 2.39941850e-01f,
  -1.79398224e-01f, -2.17015017e-02f, -1.15314927e-02f, -1.18045948e-01f, -8.08982295e-04f, 7.63294175e-02f, -1.87656598e-03f, -6.98658302e-02f, -9.24958810e-02f, -2.92807482e-02f,
  -1.09688140e-01f, -3.12619172e-02f, 1.70300491e-02f, -5.99997304e-02f, 9.79099772e-04f, -7.52407759e-02f, 8.30772296e-02f, 1.47642912e-02f, 1.38739459e-02f, -7.54534826e-03f,
  6.88488185e-02f, -2.71188766e-02f, 6.52275383e-02f, -9.11918730e-02f, 5.23204394e-02f, 6.52907863e-02f, 5.36199026e-02f, -9.87144187e-02f, 4.30001831e-03f, -7.86125362e-02f,
  3.65822613e-01f, 7.92070031e-02f, -2.30698325e-02f, -5.67425042e-03f, -2.23322615e-01f, -5.88497400e-01f, -4.21366096e-01f, -2.65060574e-01f, -3.46155800e-02f, -8.44927952e-02f,
  -1.29673496e-01f, 2.94389963e-01f, 1.10624492e-01f, -2.44029239e-01f, -2.04403624e-01f, 1.23541817e-01f, -3.92694384e-01f, -2.19991282e-01f, -7.21153989e-03f, -6.55150563e-02f,
  2.27217190e-03f, -3.47668737e-01f, -4.10301723e-02f, -2.33267188e-01f, -1.82615161e-01f, 2.18719572e-01f, 1.11483447e-01f, 5.67819551e-02f, -2.11547256e-01f, -2.04988718e-02f,
  -9.80276614e-02f, 1.31269813e-01f, 1.80341490e-02f, 6.78292960e-02f, -1.21378474e-01f, 5.07624522e-02f, 3.11052017e-02f, 3.37352827e-02f, 7.16145113e-02f, -3.94507237e-02f,
  2.30706446e-02f, 9.49267745e-02f, -7.90439323e-02f, 1.14937834e-01f, 1.00960344e-01f, -8.69381987e-03f, 6.02709539e-02f, 3.86505313e-02f, 7.53444210e-02f, 1.64343059e-01f,
  1.48923360e-02f, 7.95266554e-02f, -5.85616864e-02f, 1.43901139e-01f, 1.18200116e-01f, -8.41745883e-02f, -7.83529431e-02f, 1.36695668e-01f, 1.96192302e-02f, 7.76242092e-02f,
  1.19575746e-01f, -6.16255291e-02f, -4.19841446e-02f, -1.93895698e-02f, -1.45952404e-01f, 3.99842560e-02f, 5.13967359e-03f, 2.27477867e-02f, 1.14301205e-01f, -8.80778418e-04f,
  -7.53120929e-02f, -5.80931306e-02f, -6.73106313e-02f, -3.67501341e-02f, -2.59177876e-03f, 1.50163755e-01f, -6.48547411e-02f, 7.46238837e-03f, -4.39963825e-02f, -1.71277262e-02f,
  1.68147907e-01f, -1.84781343e-01f, 8.38815644e-02f, 8.23998824e-02f, -1.00207262e-01f, 7.56470934e-02f, -7.91276172e-02f, 6.29207492e-02f, -1.01059094e-01f, -1.15173668e-01f,
  -1.23208851e-01f, -1.16245478e-01f, -4.09283675e-03f, -2.14159153e-02f, 2.19567083e-02f, -1.66204259e-01f, 3.01023368e-02f, -1.89360946e-01f, 8.11092407e-02f, -6.26403987e-02f,
  -1.14196576e-01f, 8.16789195e-02f, -1.19459912e-01f, 1.30591139e-01f, -5.34404181e-02f, -9.54682976e-02f, 2.01182999e-02f, 1.32643893e-01f, -6.29605725e-02f, 8.64299312e-02f,
  2.87714712e-02f, 9.68410820e-02f, 6.78578764e-02f, -4.76922765e-02f, 5.09610921e-02f, 2.30444036e-02f, 1.04233772e-02f, 1.31307626e-02f, 1.66838929e-01f, 4.06521596e-02f,
  -3.92966151e-01f, 3.52629274e-01f, 3.93789768e-01f, 1.90583363e-01f, -2.19341859e-01f, -2.39953369e-01f, -1.34635076e-01f, 6.55233860e-02f, -1.24496423e-01f, 3.18556100e-01f,
  7.24358484e-02f, -5.11821620e-02f, 2.18996689e-01f, 4.04652834e-01f, -4.14641112e-01f, 2.79790431e-01f, 2.13470519e-01f, 1.36676028e-01f, -1.19667597e-01f, 3.48493410e-03f,
  -1.84478462e-02f, -6.80063069e-02f, 3.05409849e-01f, 4.89247963e-03f, 1.83422714e-01f, 3.03613730e-02f, -3.57361957e-02f, -1.01732053e-01f, 2.26666436e-01f, -1.37588367e-01f,
  -3.51509042e-02f, -6.24422990e-02f, 1.63279384e-01f, -6.42829924e-04f, 1.21426083e-01f, 7.45435134e-02f, 9.38201398e-02f, -2.79099029e-02f, -1.25032142e-01f, -1.05101153e-01f,
  3.27963457e-02f, -2.96635516e-02f, 2.39065010e-02f, -8.60479325e-02f, -2.23663561e-02f, 8.61510560e-02f, 7.40257353e-02f, 1.29070863e-01f, -1.82516500e-02f, 1.74945608e-01f,
  1.32606581e-01f, 1.07277267e-01f, 1.31386608e-01f, 1.84982240e-01f, -4.66182269e-02f, -1.67994220e-02f, -1.35644404e-02f, 1.91533007e-02f, 3.48951332e-02f, 4.00378630e-02f,
  -1.10912383e-01f, 6.97812289e-02f, -3.85257639e-02f, 1.31775931e-01f, -1.29656017e-01f, 1.93667077e-02f, 2.62547284e-02f, -6.70811012e-02f, -1.57801865e-03f, -3.15127708e-02f,
  -4.28504646e-02f, 7.24140778e-02f, -1.30565956e-01f, 1.70228966e-02f, 2.64977962e-02f, -7.37952664e-02f, -8.37074667e-02f, -7.01275915e-02f, -3.91662829e-02f, -4.11113612e-02f,
  -1.80904660e-02f, -1.40304402e-01f, 3.61080505e-02f, 3.79192792e-02f, -6.31503090e-02f, -2.34396867e-02f, 3.31627205e-02f, 9.71755758e-02f, 2.53813341e-02f, -6.64081350e-02f,
  -2.72930324e-01f, -1.82455122e-01f, -2.95091495e-02f, -1.15910083e-01f, 1.21766410e-03f, 1.12756882e-02f, -3.37290652e-02f, 1.73580535e-02f, 5.35621680e-02f, -9.59075093e-02f,
  -1.42291188e-02f, 1.09211244e-01f, -7.15282112e-02f, -4.35624123e-02f, 5.12308776e-02f, -1.67676248e-02f, -1.00279227e-01f, -1.30323410e-01f, -1.01451539e-01f, -7.96321183e-02f,
  -5.98544404e-02f, -1.24979913e-01f, 1.15647130e-01f, -1.96609944e-02f, 4.60169874e-02f, -8.81714970e-02f, -6.78475797e-02f, 5.98691963e-02f, -4.45280746e-02f, 3.07373051e-02f,
  -2.57573053e-02f, 7.94956908e-02f, -1.11991867e-01f, -3.46314520e-01f, -1.39268756e-01f, -4.16300260e-02f, -2.45053187e-01f, 4.33463342e-02f, 2.04011828e-01f, 2.36692190e-01f,
  -2.81682730e-01f, 2.04036266e-01f, 1.48011461e-01f, -3.39422673e-01f, 1.08044595e-01f, 2.81214684e-01f, -2.49272779e-01f, -1.56178549e-01f, -2.95725074e-02f, -1.47270665e-01f,
  -1.06211774e-01f, -2.32915267e-01f, -1.95242688e-01f, -3.92201692e-02f, -3.98051918e-01f, -1.78275660e-01f, -5.24922274e-03f, -1.45585343e-01f, -2.87111431e-01f, -2.90127903e-01f,
  -7.99835622e-02f, -2.20895614e-02f, -1.57832175e-01f, 7.62883574e-02f, -1.06321149e-01f, -9.71829146e-03f, -8.79964009e-02f, 2.82305405e-02f, -8.25521350e-02f, 6.28190637e-02f,
  5.35536408e-02f, 1.16121165e-01f, 2.09365245e-02f, 2.66076811e-02f, -9.81637388e-02f, -5.71152642e-02f, 3.95568050e-02f, -1.44739673e-01f, 3.72815393e-02f, -1.79798782e-01f,
  -2.15902165e-01f, -7.85510615e-02f, -1.64591104e-01f, 1.15472727e-01f, -1.69960588e-01f, -4.67788875e-02f, 2.83041764e-02f, 5.04227914e-02f, 6.16564304e-02f, -3.18753496e-02f,
  -1.66843235e-02f, 1.21127591e-01f, 1.19980544e-01f, -2.74958648e-02f, -8.57792236e-03f, -7.24128485e-02f, -1.76125348e-01f, -1.07332412e-02f, -1.50471302e-02f, 1.12868045e-02f,
  5.46850376e-02f, -8.74844864e-02f, -1.25564514e-02f, -7.87961334e-02f, -5.01190275e-02f, 1.97119087e-01f, 6.78270161e-02f, 1.27101004e-01f, -1.85468153e-03f, -3.45034599e-02f,
  -4.22926694e-02f, -2.03845706e-02f, 9.59165543e-02f, -7.58574307e-02f, -1.17844038e-01f, -7.50796348e-02f, -6.65625781e-02f, -1.65837526e-01f, -7.21052885e-02f, -9.56323091e-03f,
  1.07389599e-01f, 2.06585929e-01f, -7.03507438e-02f, 6.99013919e-02f, 1.18621048e-02f, 6.64211288e-02f, -2.64708493e-02f, -1.24871477e-01f, 4.73554842e-02f, 9.36088711e-02f,
  -1.59345865e-02f, 1.98805109e-02f, -4.90291975e-02f, -8.45056176e-02f, 1.19761132e-01f, 1.28271356e-02f, 2.94782333e-02f, 1.25988290e-01f, -6.85936883e-02f, -2.01499816e-02f,
  -9.12060589e-02f, 1.32081673e-01f, 1.20818898e-01f, 9.71984714e-02f, 7.09479526e-02f, 2.19817180e-02f, 6.80008307e-02f, -2.98473611e-02f, -1.42981455e-01f, 9.44688618e-02f,
  -2.82628149e-01f, 5.12059927e-01f, 2.77310669e-01f, -1.59777373e-01f, -4.94137183e-02f, 4.93130982e-01f, 2.34023437e-01f, 1.86117321e-01f, 2.23746613e-01f, 2.05370277e-01f,
  -1.43832956e-02f, 9.33375284e-02f, 1.29535660e-01f, 7.48650357e-02f, -1.01728223e-01f, 1.95865050e-01f, 9.28271189e-02f, 1.18680812e-01f, 1.89699844e-01f, -3.77291627e-02f,
  -2.38643168e-03f, -7.28460252e-02f, -1.77148402e-01f, -3.43237929e-02f, -3.26534994e-02f, -8.67270529e-02f, -1.39889106e-01f, 1.25025317e-01f, 9.02359262e-02f, 1.73057407e-01f,
  6.17451556e-02f, -4.86134700e-02f, -1.28458425e-01f, 5.04245088e-02f, 6.46998957e-02f, -1.34210968e-02f, 8.97384733e-02f, 7.73956720e-03f, -1.08202636e-01f, -8.95034894e-03f,
  -3.20599042e-02f, -4.97982949e-02f, 3.33023146e-02f, 1.51209394e-02f, 1.84778031e-02f, 5.37062809e-02f, -4.97114705e-03f, -1.16325609e-01f, -2.05185506e-02f, 2.66411100e-02f,
  -1.00541851e-02f, -9.48895607e-03f, -1.50460809e-01f, 1.16474241e-01f, -6.29166663e-02f, 1.25229225e-01f, 8.33838433e-02f, 1.14767402e-02f, 2.96229646e-02f, 1.13101386e-01f,
  6.03142045e-02f, 1.44134477e-01f, 8.14803392e-02f, 5.17625324e-02f, 9.95745361e-02f, -3.53674069e-02f, -6.07501566e-02f, 2.99667809e-02f, -6.82514384e-02f, -1.55920222e-01f,
  -1.49988025e-01f, 1.89257767e-02f, -9.62072536e-02f, -9.83146578e-02f, 1.53078986e-02f, -1.95910111e-02f, -4.55618091e-02f, 2.20060372e-03f, -1.78559534e-02f, -1.61643565e-01f,
  5.66021204e-02f, 2.98777595e-02f, -5.44659272e-02f, -2.42339820e-02f, 2.72883326e-02f, -1.03168599e-02f, 8.64960849e-02f, -3.41475606e-02f, -1.50800878e-02f, -4.74093482e-02f,
  2.11243063e-01f, 2.56299973e-01f, -5.39329648e-02f, -2.75021736e-02f, 9.84987691e-02f, 7.49457479e-02f, -3.03496327e-02f, 9.25472844e-03f, 1.40094116e-01f, -4.64122230e-03f,
  -3.99492041e-04f, 1.17189527e-01f, -8.41571316e-02f, 1.08829848e-02f, 4.96939830e-02f, 1.45557523e-01f, -1.01209320e-02f, 3.21219396e-03f, 6.40446618e-02f, 9.40671563e-02f,
  -2.58214653e-01f, 1.88351180e-02f, -7.40963370e-02f, -2.16993671e-02f, 1.35226762e-02f, -1.44439667e-01f, -6.23962432e-02f, -1.40862223e-02f, -1.10159395e-02f, -4.45053028e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  3.71298075e-01f, 2.77240187e-01f, 2.84894109e-01f, 1.85879618e-01f, 2.72010118e-01f, 3.04952264e-01f, 2.95980632e-01f, 3.27674389e-01f, 2.54478395e-01f, 3.96794498e-01f,
  2.51306206e-01f, 1.66243583e-01f, 3.92428845e-01f, 2.04826921e-01f, 2.45339006e-01f, 2.14949936e-01f, 1.72238335e-01f, 2.72756100e-01f, 3.01519871e-01f, 3.47870946e-01f,
  1.46454141e-01f, 2.24084601e-01f, 2.62993574e-01f, 2.43793249e-01f, 3.57513040e-01f, 2.56720603e-01f, 2.83594072e-01f, 1.90069094e-01f, 1.70492247e-01f, 1.23521186e-01f,
  1.85284004e-01f, 2.93937027e-01f, 4.11547542e-01f, 2.57737279e-01f, 2.41537854e-01f, 3.76885116e-01f, 2.97094762e-01f, 3.12740892e-01f, 2.93079376e-01f, 3.97786885e-01f,
  3.32468331e-01f, 2.11478963e-01f, 2.36033291e-01f, 3.99511635e-01f, 4.38506097e-01f, 3.91632855e-01f, 3.14944983e-01f, 3.81565928e-01f, 1.33211568e-01f, 2.60905594e-01f,
  4.73644912e-01f, 1.84596851e-01f, 1.32989377e-01f, 3.20237726e-01f, 2.30121747e-01f, 4.14381921e-02f, 3.04203153e-01f, 3.49604517e-01f, 4.13466215e-01f, 3.78666341e-01f,
  1.47539407e-01f, 2.51321733e-01f, 1.74629688e-01f, 2.78710574e-01f, 3.02911103e-01f, 1.56917706e-01f, 4.92163122e-01f, 2.70421147e-01f, 4.37833279e-01f, 3.08184505e-01f,
  2.17731848e-01f, 2.23793402e-01f, 2.93520361e-01f, 3.07134330e-01f, 3.73545349e-01f, 4.46737677e-01f, 2.55705565e-01f, 3.42085540e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.01379269e-01f, -2.77318228e-02f, -1.61308590e-02f, -7.64651448e-02f, -8.39116722e-02f, -1.11824341e-01f, -2.81950533e-01f, 1.41009490e-03f, -3.23285520e-01f, -2.22931325e-01f,
  1.31651098e-02f, -2.82720029e-01f, -9.18402523e-02f, -1.23290643e-01f, -1.31316677e-01f, -2.58418024e-02f, -1.63742349e-01f, -1.30527481e-01f, -5.52726947e-02f, 1.80031210e-02f,
  2.79842298e-02f, -5.74408211e-02f, -1.34583920e-01f, 3.08692958e-02f, 1.09557651e-01f, -1.60460711e-01f, -2.26507828e-01f, 1.99870855e-01f, -2.55951285e-01f, 1.83766618e-01f,
  9.41646099e-02f, -2.14539558e-01f, -1.72012463e-01f, 2.13516146e-01f, -2.53857106e-01f, -2.69343376e-01f, 2.96892822e-01f, 6.58118771e-03f, -1.59151465e-01f, 2.15460822e-01f,
  3.56028154e-02f, 2.82510340e-01f, 1.93852946e-01f, -3.17606866e-01f, -1.52209431e-01f, -8.34055245e-02f, -1.64358709e-02f, 1.72490209e-01f, -2.64749043e-02f, 6.61624875e-03f,
  1.49821654e-01f, -4.92993772e-01f, 2.05250621e-01f, -2.84185112e-01f, 3.00340801e-01f, -3.38806123e-01f, -2.56287575e-01f, -2.89066374e-01f, 1.20435230e-01f, 2.70688206e-01f,
  3.41222644e-01f, 3.32849443e-01f, -1.52449906e-01f, 4.68227230e-02f, -2.65237719e-01f, -3.33358973e-01f, -8.44620168e-02f, 8.02385882e-02f, -1.24536462e-01f, -1.53820351e-01f,
  -8.75890851e-02f, -4.12121564e-01f, -2.25200385e-01f, 1.27031773e-01f, -1.15394928e-01f, -2.13045418e-01f, -4.92468864e-01f, -1.23325631e-01f, 4.04364854e-01f, 3.76048505e-01f,
  -4.87543531e-02f, -1.13214001e-01f, 2.39011958e-01f, 2.67723769e-01f, 2.93839335e-01f, -3.22752386e-01f, -6.59927577e-02f, -1.94837421e-01f, -4.60440099e-01f, -1.18042700e-01f,
  -4.41458151e-02f, -1.18865326e-01f, 1.92511648e-01f, -4.25195783e-01f, -1.26288205e-01f, 5.04604653e-02f, -3.94628525e-01f, -5.79477489e-01f, 1.21161349e-01f, 2.55836844e-01f,
  -4.89594847e-01f, 1.80682763e-01f, 3.71641248e-01f, 3.70971262e-01f, -2.37348035e-01f, -4.45815362e-02f, -1.64511293e-01f, -2.38757562e-02f, -4.09550339e-01f, 1.96221441e-01f,
  -1.93580538e-01f, -2.82363236e-01f, -3.88079852e-01f, -9.52889100e-02f, 1.78849064e-02f, 1.59056336e-01f, -4.28766161e-01f, -1.40175879e-01f, 2.80668855e-01f, -1.15426287e-01f,
  1.68108847e-02f, 1.76720858e-01f, -1.45813257e-01f, -2.04344943e-01f, -3.09270054e-01f, 3.67232472e-01f, -2.91860551e-01f, 7.10978433e-02f, -6.24279194e-02f, 1.37177572e-01f,
  -1.67970613e-01f, -7.74424374e-02f, 1.26308938e-02f, 1.65751055e-01f, -3.38684320e-02f, 9.44220349e-02f, -2.12500095e-01f, -1.25066876e-01f, -8.84009302e-02f, 4.57910560e-02f,
  6.99115321e-02f, 5.94655052e-02f, 7.31814951e-02f, 1.14872277e-01f, 3.75455916e-02f, 9.88128260e-02f, -3.50145716e-03f, 1.85755968e-01f, 1.57600909e-01f, 1.50485381e-01f,
  -4.46403503e-01f, -2.75718063e-01f, -1.83820635e-01f, -2.68273592e-01f, 2.07906723e-01f, 1.24585472e-01f, 1.80411056e-01f, 5.05961716e-01f, 2.92288721e-01f, -1.81690410e-01f,
  -1.00273877e-01f, 2.33011916e-01f, -1.82266608e-01f, 1.96772560e-01f, 3.27248871e-01f, -4.19593185e-01f, -2.41673112e-01f, -4.79421407e-01f, 7.55950809e-02f, 2.23911047e-01f,
  2.50992835e-01f, 4.72936243e-01f, -1.31606068e-02f, 2.62062758e-01f, 1.70828104e-01f, 3.35260332e-01f, -2.75096953e-01f, 4.61992979e-01f, -3.87047231e-01f, 2.44939923e-02f,
  9.05974805e-02f, 6.62525594e-02f, -1.52598873e-01f, -1.42180458e-01f, 3.96805406e-01f, -1.47563946e-02f, 3.18373144e-01f, -4.21603233e-01f, 1.86329842e-01f, 2.98164189e-01f,
  -2.15451434e-01f, 2.02225819e-01f, -1.59720868e-01f, -9.02200267e-02f, 3.29353273e-01f, -6.52034059e-02f, -4.47505057e-01f, -2.52851844e-01f, -2.82592803e-01f, 6.77411631e-02f,
  2.34820679e-01f, 1.87021092e-01f, -1.86698064e-01f, -3.33280772e-01f, -1.88273177e-01f, -1.10882625e-01f, -3.93208086e-01f, -4.19872642e-01f, 1.35946780e-01f, -1.20274432e-01f,
  -4.46135789e-01f, 2.05512449e-01f, 1.81794181e-01f, -2.02002913e-01f, 3.37838322e-01f, -1.87397957e-01f, -3.89107555e-01f, -2.38099322e-01f, -3.63050073e-01f, -5.34232631e-02f,
  -4.09438193e-01f, 1.76553458e-01f, -1.81436923e-03f, -2.95152098e-01f, -3.17438662e-01f, -2.33282223e-01f, -1.33562922e-01f, -5.75103223e-01f, 1.66319251e-01f, 3.50226462e-01f,
  -5.49345136e-01f, -4.59024101e-01f, -2.48552948e-01f, -2.33697563e-01f, -9.87578463e-03f, 3.19708228e-01f, -4.35738228e-02f, -2.90411144e-01f, -1.64984286e-01f, 1.24085650e-01f,
  4.47404087e-01f, -3.66938531e-01f, -1.99867710e-01f, -3.86573613e-01f, -7.48932408e-03f, 3.55331659e-01f, 2.47266158e-01f, -8.04696977e-02f, -3.22918713e-01f, -6.01504482e-02f,
  2.40310296e-01f, -3.91705185e-01f, 3.74617837e-02f, -4.23426069e-02f, -2.53037453e-01f, 1.03116319e-01f, 5.56554683e-02f, -2.57915139e-01f, -7.52637461e-02f, -5.15555367e-02f,
  -1.32296756e-01f, 2.58002970e-02f, -8.21160302e-02f, -9.91616771e-02f, 2.49039624e-02f, -3.37033197e-02f, -9.72568765e-02f, 4.29590605e-02f, 6.86733723e-02f, -5.45490608e-02f,
  -8.28850642e-02f, 5.97153381e-02f, 1.27236813e-01f, -1.21171540e-02f, -1.05727710e-01f, -1.22270346e-01f, -6.16204441e-02f, -1.11878872e-01f, -6.92729652e-02f, -1.09543419e-03f,
  -2.18243942e-01f, 2.48435706e-01f, 1.71074718e-01f, 1.79418474e-01f, 1.45751357e-01f, -2.83975184e-01f, 2.54394971e-02f, 6.85487827e-03f, 5.13858758e-02f, -1.04819413e-03f,
  -2.31543049e-01f, 7.53029436e-02f, 1.60009146e-01f, -1.00878917e-01f, -3.67989652e-02f, -2.07887203e-01f, 3.90373990e-02f, -3.97456959e-02f, -2.46464893e-01f, -3.72127801e-01f,
  4.70188335e-02f, 6.82236850e-02f, -7.35487267e-02f, 1.49762824e-01f, -1.61881849e-01f, 9.42944512e-02f, -6.18433133e-02f, 3.83146018e-01f, -4.50812846e-01f, -1.64119169e-01f,
  -2.27245167e-01f, -2.21494630e-01f, 2.51681179e-01f, 2.09641054e-01f, -3.90186965e-01f, -2.38980517e-01f, -1.09791517e-01f, -3.59859884e-01f, -4.84568998e-03f, -2.08834738e-01f,
  -3.93085688e-01f, 3.42028558e-01f, 2.78977215e-01f, -1.09200805e-01f, -2.44254738e-01f, 2.78304994e-01f, -2.97319949e-01f, -3.14772397e-01f, 2.42237225e-01f, -3.37129444e-01f,
  -3.10089320e-01f, 1.74392611e-01f, -2.88118720e-01f, 1.45358354e-01f, -1.57580525e-01f, -2.23464251e-01f, 3.83523196e-01f, -1.05043337e-01f, -2.84965485e-01f, 3.21792424e-01f,
  -1.13268569e-01f, -3.07040989e-01f, -2.89315671e-01f, 1.83865175e-01f, -2.15125382e-02f, 3.58613245e-02f, -1.79871485e-01f, -1.30164742e-01f, -1.25976488e-01f, -2.15570256e-02f,
  1.26810685e-01f, 2.97423691e-01f, -3.20011377e-01f, -4.15082127e-01f, 7.15728179e-02f, -8.24809913e-03f, 2.20113888e-01f, 2.54703999e-01f, -1.07876308e-01f, -2.77479857e-01f,
  -1.71569943e-01f, 3.49970907e-01f, -2.54157931e-01f, 8.53797197e-02f, 2.27912754e-01f, -3.32307696e-01f, -1.74586609e-01f, -2.62423813e-01f, -2.42935792e-01f, -1.36009932e-01f,
  -1.22142710e-01f, 5.29725432e-01f, -3.87904942e-01f, -1.09265879e-01f, -4.56930548e-01f, -3.30462039e-01f, -2.52664089e-01f, 3.37482333e-01f, 9.92534459e-02f, -1.25639856e-01f,
  -3.88357073e-01f, -3.43896925e-01f, -1.19272925e-01f, -4.00915623e-01f, 9.91350561e-02f, -1.24761939e-01f, 2.29069963e-03f, -2.92698532e-01f, 2.75261179e-02f, -1.89142361e-01f,
  -4.30389605e-02f, -8.71855617e-02f, 4.61752862e-02f, 8.39671120e-02f, -2.19777226e-01f, 1.61886722e-01f, 1.05297947e-02f, -1.65218964e-01f, 8.52068588e-02f, 5.75699843e-02f,
  -4.84199822e-02f, 1.02180198e-01f, 2.17143428e-02f, -5.94505444e-02f, -6.26728460e-02f, -7.38967117e-03f, -2.05797285e-01f, -1.05569638e-01f, -9.02034864e-02f, -2.72620648e-01f,
  -9.45386216e-02f, -1.42219691e-02f, -1.86957434e-01f, -2.31705178e-02f, -1.41976774e-01f, 2.50612915e-01f, 2.43409239e-02f, -3.14840257e-01f, 2.44609386e-01f, -6.21792190e-02f,
  1.92489028e-01f, -2.62967288e-01f, 1.04303367e-01f, -3.91614765e-01f, 2.59125948e-01f, 2.13727658e-03f, -1.68994814e-01f, 1.55564576e-01f, -9.65196118e-02f, 3.31148297e-01f,
  -4.22058851e-01f, -1.59805939e-01f, 2.54138589e-01f, -2.44985491e-01f, -4.22425658e-01f, -4.47156578e-01f, -2.28984491e-03f, 1.20484024e-01f, -3.78810823e-01f, 2.75742471e-01f,
  -1.92298278e-01f, -2.70447910e-01f, -2.74380952e-01f, -2.56550144e-02f, -5.17098486e-01f, -3.98374200e-01f, 3.63760650e-01f, -1.15360856e-01f, 4.12541330e-02f, -2.38179833e-01f,
  -2.44904440e-02f, 4.12089080e-01f, 7.50778764e-02f, 9.22095925e-02f, 5.04021585e-01f, -2.46251613e-01f, -1.43516853e-01f, -3.03314984e-01f, -4.01975781e-01f, -2.54420370e-01f,
  -3.62348974e-01f, -1.29686043e-01f, 1.65493861e-01f, 4.46141958e-01f, -3.11696649e-01f, 1.02416009e-01f, 3.37219954e-01f, -3.90015721e-01f, -1.92950368e-01f, -2.58281440e-01f,
  -1.57716915e-01f, -3.64727587e-01f, 2.88818568e-01f, -1.78588092e-01f, 2.32970417e-01f, -2.48950630e-01f, 3.67890954e-01f, 1.48155659e-01f, 1.40556470e-01f, -4.24754828e-01f,
  3.18937637e-02f, -1.49503738e-01f, -3.59222621e-01f, 7.65338540e-02f, -3.64014536e-01f, -1.65463418e-01f, -3.11632872e-01f, 1.38130197e-02f, 3.61986369e-01f, -6.72612851e-03f,
  -1.03009626e-01f, -2.23683551e-01f, -1.87249795e-01f, 2.53935456e-01f, -1.74803734e-01f, -5.19791305e-01f, -2.53177673e-01f, 3.42822641e-01f, -2.85646379e-01f, -2.44684085e-01f,
  -1.55157492e-01f, -3.26264024e-01f, 3.31663072e-01f, -5.43790102e-01f, 9.81693808e-03f, -1.08267173e-01f, -2.39680991e-01f, -4.10386473e-01f, 1.04932606e-01f, 2.78518964e-02f,
  7.67519474e-02f, 7.68529028e-02f, 4.70689349e-02f, -1.04596779e-01f, 9.21333730e-02f, 2.99690008e-01f, -2.18437053e-02f, 6.04815073e-02f, 1.39097825e-01f, 8.72244835e-02f,
  1.02898404e-01f, -5.50263636e-02f, 9.65519473e-02f, 1.74642410e-02f, 2.17086121e-01f, 1.09441534e-01f, 1.15595520e-01f, 1.47164047e-01f, 2.46829838e-01f, 3.31355967e-02f,
  8.93371329e-02f, 2.82795370e-01f, 2.92822510e-01f, 7.62343332e-02f, 1.74892336e-01f, -5.56829572e-02f, -9.85633284e-02f, -2.11086035e-01f, 1.23164980e-02f, 1.29835889e-01f,
  -3.28965247e-01f, -2.91818202e-01f, -3.25656861e-01f, -3.60065013e-01f, -3.66203785e-01f, 1.86851963e-01f, -5.00513554e-01f, 9.52165648e-02f, 5.82195707e-02f, -2.29911894e-01f,
  1.19843051e-01f, 1.67886227e-01f, -2.44917452e-01f, -1.45343602e-01f, -1.32395074e-01f, -9.79538038e-02f, -3.18697512e-01f, -8.02969560e-02f, -8.09029043e-02f, -1.60199851e-01f,
  1.68088555e-01f, -4.37892973e-01f, -3.59699905e-01f, 6.38151355e-03f, -4.19247001e-01f, 4.45634365e-01f, 8.45271274e-02f, -2.79443175e-01f, -5.78630269e-01f, -1.25339046e-01f,
  -1.23781107e-01f, 3.87993187e-01f, 2.66126990e-02f, -2.37163857e-01f, -1.02809072e-01f, 2.20326111e-01f, 4.16581007e-03f, 1.63965732e-01f, -3.23611319e-01f, 5.66055328e-02f,
  1.11118183e-01f, -4.32242692e-01f, -3.54762673e-01f, -8.04408416e-02f, -5.68219721e-01f, 4.36936259e-01f, -4.74405251e-02f, -3.40291798e-01f, 3.79275858e-01f, -1.34681344e-01f,
  -9.61388797e-02f, 1.21125288e-01f, -3.37790221e-01f, 3.96361589e-01f, 8.03993717e-02f, 2.67684273e-02f, -5.43593884e-01f, 4.40899320e-02f, 1.12408087e-01f, -1.85907006e-01f,
  3.26360583e-01f, -1.90408453e-01f, -1.06946900e-02f, -5.31738214e-02f, 3.33138593e-02f, -3.81756157e-01f, 3.27010512e-01f, 4.05320942e-01f, 8.53638425e-02f, 2.90420711e-01f,
  7.52147362e-02f, -1.16329305e-01f, -3.91718030e-01f, 9.31813121e-02f, -1.48330718e-01f, 1.31567556e-03f, 3.20222497e-01f, -9.35427248e-02f, -2.82716565e-02f, -4.53263849e-01f,
  -1.80929020e-01f, 3.41121495e-01f, -1.90369397e-01f, 1.22631770e-02f, -6.29587173e-02f, -3.28502327e-01f, 3.29195142e-01f, -8.26137513e-02f, 2.64974624e-01f, -4.00578380e-01f,
  -1.95065111e-01f, 1.19624823e-01f, -7.82488659e-03f, -2.60428727e-01f, 2.15446427e-02f, 8.06305334e-02f, -4.65089321e-01f, 1.30337849e-01f, 1.36469826e-02f, 2.15697408e-01f,
  -1.59552805e-02f, 1.68540508e-01f, 8.88365433e-02f, 2.11360201e-01f, 1.12411968e-01f, 2.46350169e-02f, 1.04664071e-02f, 4.80056256e-02f, 3.61533821e-01f, 5.95072061e-02f,
  1.57479476e-03f, 1.42749205e-01f, 1.87917799e-01f, 1.72366142e-01f, 7.44549781e-02f, -2.43235566e-02f, 3.67402196e-01f, 1.12194464e-01f, -4.56401296e-02f, -4.70811501e-02f,
  1.22890532e-01f, 1.02876211e-02f, 4.25763905e-01f, 1.18391030e-01f, 1.94763586e-01f, -4.10250962e-01f, -9.33869854e-02f, -1.55422747e-01f, 2.56068021e-01f, 2.97395527e-01f,
  8.62933695e-02f, -2.23290501e-03f, 1.61127597e-01f, 3.23668540e-01f, -5.63452877e-02f, -4.27517146e-01f, -3.28270286e-01f, 2.60569572e-01f, 1.31373078e-01f, 1.87074512e-01f,
  1.55818641e-01f, -1.12973556e-01f, 2.86569655e-01f, 1.90906674e-01f, 4.52775180e-01f, -3.23142231e-01f, 3.16886082e-02f, -6.73687644e-03f, 2.09495440e-01f, -4.39430594e-01f,
  3.75155836e-01f, -2.48773172e-01f, 3.64550740e-01f, -9.89777148e-02f, -3.44676435e-01f, -1.26154959e-01f, -1.29431374e-02f, 2.66795754e-01f, -1.80625379e-01f, -1.80537142e-02f,
  -5.46942391e-02f, 6.42571971e-02f, -5.52150548e-01f, -4.48195308e-01f, -4.41807717e-01f, -7.17406198e-02f, -5.16191721e-01f, -4.80922461e-01f, 2.11087823e-01f, -1.24965057e-01f,
  -1.58337027e-01f, 4.31043923e-01f, -2.65084684e-01f, -1.57673538e-01f, -4.77667525e-02f, 7.77851865e-02f, -8.18131864e-02f, 2.02913567e-01f, 8.22052434e-02f, -5.02418838e-02f,
  2.06761390e-01f, 7.15663880e-02f, -1.44482387e-04f, -3.75517488e-01f, 3.09864432e-01f, 3.54259461e-01f, 1.46921635e-01f, -1.50747180e-01f, -4.47611153e-01f, -2.72702247e-01f,
  1.39357358e-01f, 3.22845241e-04f, -2.92720407e-01f, -2.38698363e-01f, -5.18744767e-01f, 9.06210579e-03f, 2.09984824e-01f, 3.23059261e-01f, -1.36594296e-01f, 7.45343789e-02f,
  5.10126539e-02f, -1.06079496e-01f, 2.09104106e-01f, 1.91190559e-02f, -4.61221814e-01f, -2.90861219e-01f, -3.09909493e-01f, 2.19653398e-01f, 7.39246830e-02f, -8.30499604e-02f,
  5.53549081e-02f, -4.10873950e-01f, -1.80934146e-01f, -1.35210320e-01f, -7.65653234e-03f, -1.76732421e-01f, 1.63654785e-03f, 3.17241460e-01f, -4.93949056e-02f, 2.04255447e-01f,
  1.49701610e-01f, -6.75610781e-01f, -3.73614579e-01f, -3.00110281e-01f, -2.42808789e-01f, -4.02118444e-01f, 3.13916951e-01f, 4.01996553e-01f, 8.02400485e-02f, 1.65894657e-01f,
  -1.46639183e-01f, 7.11323917e-02f, -1.98207106e-02f, 1.22167259e-01f, -2.13871244e-02f, -4.44987565e-02f, -6.33127466e-02f, 1.85119167e-01f, 5.13152778e-02f, -1.07170612e-01f,
  -1.34509698e-01f, 1.56430438e-01f, 4.52882275e-02f, -1.55926868e-01f, -1.26133591e-01f, 1.73750166e-02f, 1.02202952e-01f, -3.69636714e-02f, -4.80207093e-02f, -9.41817299e-04f,
  1.03075895e-02f, -3.20568085e-02f, 1.30570576e-01f, 2.80179441e-01f, 1.30809188e-01f, 3.06845516e-01f, 1.23980485e-01f, -3.96847665e-01f, 3.36224616e-01f, 4.51200277e-01f,
  2.02551067e-01f, -4.73690748e-01f, 2.57059544e-01f, 3.48505616e-01f, -1.82486430e-01f, 1.92799792e-01f, 5.58914989e-02f, 1.82383046e-01f, -3.87814164e-01f, -2.53363937e-01f,
  -4.01335210e-01f, 1.80036277e-01f, 3.00799042e-01f, -2.93961346e-01f, 1.12309538e-01f, -1.25431910e-01f, 3.55749547e-01f, 3.14739019e-01f, -3.46946977e-02f, -1.58384562e-01f,
  -2.48105843e-02f, -1.44708946e-01f, -1.21988252e-01f, -2.40619645e-01f, 3.41476291e-01f, -5.32253981e-01f, -1.83129251e-01f, -4.31912959e-01f, 6.39448762e-02f, -1.35192066e-01f,
  -2.48657897e-01f, -1.80904612e-01f, -1.95020542e-01f, 3.68880201e-03f, -1.25841722e-01f, -3.16918075e-01f, 8.51588249e-02f, 2.45653287e-01f, 1.06357187e-01f, 2.38466002e-02f,
  4.27999534e-02f, -1.84147805e-01f, 5.61023429e-02f, 3.60792309e-01f, 2.14400530e-01f, -1.94998622e-01f, -1.23971917e-01f, -1.09389558e-01f, -3.27781647e-01f, 3.02944779e-01f,
  -1.87996164e-01f, -1.38092026e-01f, -2.20803306e-01f, 2.49336846e-02f, -1.78954959e-01f, -1.31740570e-01f, 3.53515416e-01f, 3.37501019e-01f, -4.37308222e-01f, -1.90110937e-01f,
  -1.96264863e-01f, -5.12306094e-02f, -1.97347701e-01f, -1.00762121e-01f, -2.70515651e-01f, 3.53077054e-01f, -2.03793719e-01f, -2.88778901e-01f, 1.30824834e-01f, 3.49555463e-02f,
  -4.47415188e-02f, -3.63345653e-01f, -2.67582953e-01f, 2.10098494e-02f, -3.47066581e-01f, 1.30976424e-01f, 3.73606205e-01f, -5.06054461e-01f, 4.90875840e-01f, 7.67356381e-02f,
  -2.34307751e-01f, -3.66298676e-01f, -5.88696241e-01f, -4.52742189e-01f, 1.06799074e-01f, -1.59510136e-01f, -5.02067626e-01f, 3.95027727e-01f, 4.21528041e-01f, 4.12362099e-01f,
  3.38271916e-01f, -2.03064367e-01f, -1.95292726e-01f, -2.59917349e-01f, -4.68982369e-01f, -4.30162251e-01f, -5.66068031e-02f, -1.89872205e-01f, -4.16326672e-02f, -1.05385467e-01f,
  4.14359383e-02f, -1.40021583e-02f, -3.87338996e-02f, -1.69513956e-01f, -3.15681875e-01f, -2.97285199e-01f, 1.43768927e-02f, -1.55315354e-01f, 5.78716882e-02f, -1.71121433e-02f,
  -2.92096119e-02f, -1.70243412e-01f, 2.43348759e-02f, -1.83490440e-01f, -9.10156816e-02f, 1.00230947e-02f, -1.49843127e-01f, -5.19988835e-02f, 6.01541586e-02f, 6.53804690e-02f,
  5.96420728e-02f, 1.12625863e-02f, -2.11184457e-01f, -3.21835339e-01f, -2.10029960e-01f, 4.51091724e-03f, -9.02762637e-03f, 5.35620749e-02f, 2.58061234e-02f, -1.30018130e-01f,
  1.96826771e-01f, 2.70240605e-01f, -2.45315969e-01f, 1.52074099e-01f, -2.76342928e-01f, 1.84254095e-01f, 2.44495958e-01f, 1.52191818e-01f, -2.01134816e-01f, -2.30168566e-01f,
  1.86861947e-01f, -1.30056515e-01f, -2.51428187e-01f, -1.18495367e-01f, -7.09472820e-02f, -1.74767777e-01f, -1.23618655e-01f, -9.61092487e-02f, -3.65269721e-01f, 2.31796890e-01f,
  -2.20767602e-01f, 2.88632721e-01f, -1.90186948e-01f, -1.99951395e-01f, -2.15425789e-01f, -3.29208553e-01f, -2.31833696e-01f, -1.48891300e-01f, -2.30845779e-01f, -2.67834336e-01f,
  2.19999447e-01f, -1.69031113e-01f, -4.00452390e-02f, -1.91076949e-01f, 2.40063831e-01f, -1.93943024e-01f, 3.36871371e-02f, 5.00127338e-02f, 2.78580021e-02f, 7.61578698e-03f,
  2.55735755e-01f, -8.53162184e-02f, -1.03704184e-02f, 2.19605595e-01f, 3.03818971e-01f, 1.13664404e-01f, 1.82290643e-01f, 8.97694901e-02f, -4.25914139e-01f, -1.48011923e-01f,
  -8.73434171e-02f, 1.10367522e-01f, -2.39990890e-01f, -2.08263263e-01f, -1.40097231e-01f, -2.86601007e-01f, 7.83663392e-02f, -1.02568030e-01f, -2.98399255e-02f, -3.12066991e-02f,
  -6.86016306e-02f, -2.88739920e-01f, -2.12248713e-01f, -3.17856111e-02f, -6.64762780e-02f, -1.58726066e-01f, -1.20491773e-01f, -3.07632029e-01f, 1.38874337e-01f, 2.36168221e-01f,
  1.69799417e-01f, 2.31262505e-01f, -1.44931927e-01f, -2.52177119e-01f, -1.71429604e-01f, -2.75985539e-01f, 9.15529802e-02f, 3.29255462e-01f, -2.34164745e-01f, 2.75394559e-01f,
  2.71121979e-01f, 1.50824279e-01f, -1.66858688e-01f, -1.31174833e-01f, -1.89165190e-01f, -3.15777272e-01f, 1.91067159e-01f, -9.81184989e-02f, 7.16161057e-02f, 3.08524996e-01f,
  3.07368666e-01f, -2.29063213e-01f, 3.32501590e-01f, -1.38449818e-01f, -7.42539018e-02f, -1.74523726e-01f, -6.31984835e-03f, 1.02146290e-01f, 3.52642685e-02f, -3.02069396e-01f,
  -5.09380288e-02f, -1.07760936e-01f, 3.33981700e-02f, 5.28208837e-02f, -2.73750369e-02f, 6.18873499e-02f, -9.19077620e-02f, -2.99497209e-02f, -4.55180630e-02f, -6.60744607e-02f,
  -1.29808605e-01f, -1.34130552e-01f, 1.67512074e-02f, -2.59922650e-02f, -8.87069404e-02f, -1.03084743e-01f, 2.89964825e-02f, -1.33111075e-01f, 9.62276906e-02f, -1.86258510e-01f,
  2.43779585e-01f, -1.62081629e-01f, -1.74002666e-02f, -1.06170349e-01f, 2.33434811e-01f, 1.21698409e-01f, 3.03962946e-01f, 1.47087678e-01f, 1.56516373e-01f, -2.15930305e-02f,
  3.54021229e-02f, 5.43369874e-02f, -6.06831163e-02f, 8.84167477e-02f, -1.57053649e-01f, 1.98704407e-01f, 1.41237319e-01f, -2.28482708e-01f, -1.37420118e-01f, 1.85812652e-01f,
  -1.77658543e-01f, 1.80761620e-01f, -2.36591458e-01f, -8.82464871e-02f, -1.02969654e-01f, -3.90074514e-02f, -4.30483073e-02f, -5.61974831e-02f, 2.31801227e-01f, -1.66833818e-01f,
  -9.52921584e-02f, 3.51439595e-01f, 1.12643048e-01f, -2.90506780e-01f, -9.16045383e-02f, -3.19697708e-01f, -2.77669817e-01f, 1.78521335e-01f, -2.62286156e-01f, 2.82732308e-01f,
  -2.85136580e-01f, -1.10410579e-01f, -6.00774884e-02f, -1.88151121e-01f, 2.00315744e-01f, -7.58848935e-02f, -4.61778820e-01f, -1.64494187e-01f, -3.05691928e-01f, 1.90694481e-01f,
  -1.85854316e-01f, 4.42985445e-01f, -2.73207307e-01f, -2.19083950e-01f, -2.00925395e-01f, -2.56947577e-01f, -2.38819569e-01f, -3.36658657e-01f, -1.36008248e-01f, -1.97571456e-01f,
  -2.99449861e-01f, -2.25346521e-01f, 2.87390888e-01f, -2.29383603e-01f, -1.23571247e-01f, 2.65710086e-01f, -2.82006443e-01f, 3.23731080e-02f, -3.27055633e-01f, -1.69382036e-01f,
  3.25691164e-01f, -3.07875872e-01f, 3.24773312e-01f, 3.75160873e-01f, 3.06489825e-01f, -2.75262237e-01f, 1.07214212e-01f, -2.03076184e-01f, -2.07408533e-01f, 3.42512220e-01f,
  -2.89676279e-01f, -2.96678871e-01f, 2.29584891e-02f, 3.05118173e-01f, -4.21546772e-02f, 1.26001284e-01f, -2.46656910e-01f, -7.89967850e-02f, -3.08131337e-01f, 3.09566781e-02f,
  -1.45836756e-01f, -6.45053983e-02f, 1.99122638e-01f, 7.02485035e-04f, -7.46798292e-02f, -2.03288510e-01f, 2.45091096e-01f, 2.28787929e-01f, 2.40144245e-02f, 2.09981561e-01f,
  -2.50039250e-01f, -2.45155618e-01f, -7.57311210e-02f, 1.30380243e-01f, 2.06569940e-01f, -1.34826833e-02f, -8.67274627e-02f, 4.22046259e-02f, 3.51043642e-02f, 2.12986648e-01f,
  1.21909738e-01f, 2.35494927e-01f, -3.00777685e-02f, 1.32917613e-01f, -1.16608061e-01f, -1.72557943e-02f, 4.83230911e-02f, 1.98416375e-02f, -8.73106420e-02f, 1.08367326e-02f,
  -1.10374605e-02f, -2.40391955e-01f, -1.35914937e-01f, 6.50135353e-02f, 2.20356788e-02f, 1.10675819e-01f, 1.04636736e-01f, 4.14913356e-01f, -1.39259443e-01f, 6.73865061e-03f,
  2.57955223e-01f, -2.38601178e-01f, -3.74953598e-01f, -2.91885793e-01f, 1.76572442e-01f, -1.33207187e-01f, 1.00328118e-01f, 2.61560708e-01f, -1.00641899e-01f, 1.90523043e-01f,
  -7.96430409e-02f, 2.78948128e-01f, -8.26624557e-02f, -3.31289530e-01f, -2.51133978e-01f, 2.74943918e-01f, 3.30681890e-01f, -2.86542773e-01f, 2.37076044e-01f, -3.48087773e-02f,
  -1.35673538e-01f, 2.44859084e-01f, 3.38182092e-01f, -5.30218668e-02f, -4.41773027e-01f, -4.64318454e-01f, -1.64833695e-01f, 1.32376188e-02f, -3.05376351e-01f, -7.63243586e-02f,
  3.59550834e-01f, -6.45713927e-03f, 5.34846224e-02f, -3.91923673e-02f, -3.08463395e-01f, -9.22351331e-02f, 4.65315789e-01f, -3.40557665e-01f, 4.04111773e-01f, -1.26518443e-01f,
  -2.95713067e-01f, -2.47045740e-01f, -2.46192530e-01f, -1.72920853e-01f, 4.26587909e-01f, 2.74952114e-01f, 1.86438039e-01f, -4.24531758e-01f, 3.60272706e-01f, -1.41436234e-01f,
  -2.61859268e-01f, -2.97483027e-01f, -1.71646804e-01f, -3.04160178e-01f, -2.79819459e-01f, -9.25436690e-02f, -3.61980945e-01f, 1.96134984e-01f, -1.16987474e-01f, 4.53044146e-01f,
  -1.71736553e-01f, -3.76308203e-01f, -2.88064599e-01f, -1.02658838e-01f, -4.16910440e-01f, -2.43222862e-01f, -5.19645493e-03f, 2.70542294e-01f, -1.50894687e-01f, -3.10830679e-02f,
  -7.05596283e-02f, 4.04948145e-01f, -4.65026587e-01f, -1.40472695e-01f, 1.53068677e-01f, 4.25216943e-01f, -4.61395800e-01f, -2.00139835e-01f, -1.38657600e-01f, -3.23465854e-01f,
  -2.85907060e-01f, -2.77435184e-01f, -5.39280772e-01f, -4.18333374e-02f, 1.26200616e-01f, -5.34241386e-02f, 3.77657652e-01f, 1.27424121e-01f, 3.88800561e-01f, -2.75174916e-01f,
  -2.89688498e-01f, -4.13054228e-01f, -3.28454584e-01f, 1.60976112e-01f, -3.33581716e-01f, 4.25866336e-01f, 6.41730130e-02f, -3.82226080e-01f, -2.50943720e-01f, -1.24609694e-01f,
  -5.43732084e-02f, 2.77664840e-01f, 9.73387733e-02f, 1.22375362e-01f, 1.53825805e-01f, 6.26284350e-03f, 1.02348374e-02f, -4.88634184e-02f, 1.05305582e-01f, 4.75170203e-02f,
  6.50835931e-02f, -1.25702575e-01f, -1.91379860e-01f, 1.32963270e-01f, -2.20625415e-01f, -6.20632991e-02f, 5.11511462e-03f, -3.80062759e-02f, 1.86582908e-01f, -1.63823009e-01f,
  -2.56175324e-02f, 5.11381179e-02f, 8.19731355e-02f, 1.40885323e-01f, 1.40419081e-01f, 2.72226959e-01f, 2.48533949e-01f, -3.24819863e-01f, -3.16746593e-01f, 2.25662798e-01f,
  -2.35537946e-01f, 2.28134662e-01f, -3.53681117e-01f, 2.07496524e-01f, -3.25585566e-02f, 1.34725511e-01f, 3.04811388e-01f, -2.44808242e-01f, 1.00543089e-01f, -2.92418271e-01f,
  1.24266103e-01f, 3.26969087e-01f, 1.51781157e-01f, -2.25969821e-01f, -2.62986928e-01f, 2.69403577e-01f, 2.96840847e-01f, 1.63665533e-01f, -3.07566851e-01f, 2.96525180e-01f,
  -1.55689776e-01f, 2.32235402e-01f, -1.35005976e-03f, -8.15001428e-02f, 3.56823146e-01f, 2.75873065e-01f, -1.88114986e-01f, -1.51737943e-01f, -3.75352590e-03f, -1.39141440e-01f,
  -1.75245985e-01f, -4.56727073e-02f, 2.40229383e-01f, 2.91913636e-02f, 3.39721024e-01f, -2.60435492e-01f, -1.99632272e-01f, -1.64869912e-02f, 1.04476362e-01f, 2.90277749e-01f,
  -1.08594811e-02f, -1.01987325e-01f, -2.56435066e-01f, -3.02426130e-01f, -9.96175185e-02f, 3.51160794e-01f, -1.85058817e-01f, -3.23161662e-01f, -2.64716685e-01f, -4.21445400e-01f,
  -1.79743186e-01f, -8.69704261e-02f, -4.78592038e-01f, 2.60027200e-01f, 5.63907139e-02f, -3.77134323e-01f, -2.69753814e-01f, 2.03604087e-01f, -3.34771991e-01f, 3.46491724e-01f,
  -2.08117694e-01f, 4.13718283e-01f, 1.56576440e-01f, 3.39698225e-01f, 3.00292492e-01f, -4.19528067e-01f, 1.98769256e-01f, -1.47105634e-01f, 8.68185386e-02f, -2.66082644e-01f,
  -3.57352793e-01f, -3.82536322e-01f, -1.73504487e-01f, -1.30201904e-02f, -9.04644877e-02f, -1.36242643e-01f, 3.32249343e-01f, -5.17796911e-02f, -3.24941248e-01f, -3.74037594e-01f,
  1.97231054e-01f, -1.01497183e-02f, 3.65361810e-01f, 4.86764871e-03f, -2.08281968e-02f, 2.86051631e-01f, 1.18248269e-01f, -2.23339852e-02f, -2.61302322e-01f, 3.08869854e-02f,
  1.31752908e-01f, -3.50070596e-01f, -2.99136639e-01f, -2.25925192e-01f, -1.94587007e-01f, -2.19714731e-01f, 2.72703003e-02f, -1.64417386e-01f, 3.80231603e-03f, -1.46034239e-02f,
  1.62446678e-01f, 4.07644315e-03f, 3.86680774e-02f, 8.27700645e-02f, 1.59093395e-01f, -2.40235254e-02f, 1.11598529e-01f, 7.34585747e-02f, 2.62888372e-02f, -1.19898692e-01f,
  6.49374258e-03f, -3.27868909e-01f, 1.62468404e-01f, 1.53108001e-01f, -1.32387727e-01f, 1.13479905e-01f, -5.25922589e-02f, 1.42386422e-01f, 7.80243129e-02f, 1.98613629e-02f,
  -2.31640637e-01f, 9.13052857e-02f, 2.19925661e-02f, 1.82682157e-01f, -2.02841312e-01f, -4.78277095e-02f, 1.90943971e-01f, 9.68034416e-02f, 3.39755863e-01f, -1.09758206e-01f,
  3.33516359e-01f, -5.66910282e-02f, 2.47484326e-01f, -3.68119031e-01f, -2.06824884e-01f, 2.91867524e-01f, 2.74101675e-01f, 2.89793432e-01f, -1.65430427e-01f, -3.63799870e-01f,
  7.79919997e-02f, -3.60615075e-01f, -1.59502417e-01f, 3.26697290e-01f, 3.06384712e-01f, -2.81908989e-01f, 2.48367444e-01f, -1.93677232e-01f, -2.67964184e-01f, -2.28470460e-01f,
  -1.10348456e-01f, -2.93594867e-01f, -4.96811308e-02f, -3.14060539e-01f, -2.32618988e-01f, 2.30448902e-01f, -1.96700841e-01f, 1.41979814e-01f, -3.87614608e-01f, -3.72559965e-01f,
  1.34468436e-01f, 1.75556526e-01f, -3.73894155e-01f, -2.97112674e-01f, -3.91915962e-02f, -3.61668169e-02f, 1.58166990e-03f, -1.74137890e-01f, -2.07586855e-01f, 1.61345109e-01f,
  -3.52249235e-01f, -3.61913115e-01f, 4.19509590e-01f, -5.07776588e-02f, -2.65995711e-01f, -3.10905010e-01f, -5.07291332e-02f, -3.20146114e-01f, -7.98436254e-02f, -1.03751130e-01f,
  4.13432747e-01f, -1.52870879e-01f, -3.61015826e-01f, 9.71364677e-02f, -2.67863005e-01f, 2.01102614e-01f, -3.03524017e-01f, 3.31694812e-01f, 3.08407694e-01f, -1.22994855e-01f,
  -3.28013718e-01f, -1.55231180e-02f, -1.60660282e-01f, -4.46261913e-02f, 2.30336383e-01f, -1.94317296e-01f, -1.65013194e-01f, -1.67277366e-01f, 3.45549554e-01f, -7.87912607e-02f,
  -1.88227072e-01f, -2.43966430e-01f, 1.11308619e-01f, -2.08149597e-01f, 3.50478709e-01f, -4.08405483e-01f, 3.81199151e-01f, -7.63152465e-02f, 1.13455094e-01f, 1.48755237e-01f,
  -2.65175607e-02f, 3.94722819e-01f, -3.47204417e-01f, 1.34446956e-02f, 1.09045180e-02f, -2.30108470e-01f, -1.64847642e-01f, 3.34376395e-01f, -2.98997313e-01f, -3.06415260e-01f,
  -3.14985156e-01f, -2.99957931e-01f, 2.28226691e-01f, 3.80160630e-01f, -1.81054130e-01f, 5.84936067e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.63211462e-02f, 9.02019814e-02f, 1.70886447e-03f, 4.64560427e-02f, -4.58066724e-02f, -1.27385268e-02f, -9.17629711e-03f, -9.49928463e-02f, -6.59101270e-03f, 1.48420976e-02f,
  -6.78624213e-02f, 3.06522287e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    