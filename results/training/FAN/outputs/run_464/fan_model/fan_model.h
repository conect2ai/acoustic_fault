/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.27092314e-01f, 3.74904484e-01f, -2.23886855e-02f, 9.21014845e-02f, -1.78468585e-01f, -4.00918117e-03f, 5.95694631e-02f, 6.30168542e-02f, 4.80649844e-02f, 2.21985132e-01f,
  1.26641784e-02f, 1.66646263e-03f, 1.53685883e-01f, 3.74519303e-02f, -3.34320031e-02f, 2.22889394e-01f, 1.49165159e-02f, 1.03705816e-01f, 8.14761668e-02f, 1.10621460e-01f,
  6.07504882e-02f, 1.41819179e-01f, 9.12905782e-02f, 8.82543176e-02f, -1.00001274e-02f, 4.49802987e-02f, -8.74297470e-02f, 3.19418982e-02f, -5.99449826e-03f, -7.55338697e-03f,
  -1.15042021e-02f, 1.93316098e-02f, -1.86435565e-01f, -3.34163569e-02f, -7.81629160e-02f, -5.87268546e-02f, 4.73886728e-03f, -7.49722049e-02f, -8.93768296e-02f, -2.59595104e-02f,
  4.25657704e-02f, 1.41753545e-02f, 6.18528202e-03f, -4.97937649e-02f, -2.79037729e-02f, -2.60515194e-02f, 1.04662692e-02f, -2.37683784e-02f, 8.83419886e-02f, 4.20270711e-02f,
  6.24036454e-02f, -4.21800241e-02f, -3.52567881e-02f, 2.96135545e-02f, -5.31315096e-02f, -5.60573712e-02f, 2.50519719e-02f, -1.28830867e-02f, -9.64062940e-03f, -1.33082485e-02f,
  5.10000773e-02f, 4.89188060e-02f, 5.89365959e-02f, -7.76027283e-03f, 4.48613614e-02f, 1.73301976e-02f, 2.76864809e-03f, -3.02446876e-02f, -2.24646665e-02f, 3.32669064e-04f,
  -5.01115508e-02f, -5.64780273e-02f, 1.59600703e-03f, -6.38852045e-02f, 9.94565664e-04f, -1.53474221e-02f, -1.84920374e-02f, 1.57748144e-02f, 1.22252824e-02f, -3.20718214e-02f,
  8.32784362e-03f, 5.62433861e-02f, 1.75669286e-02f, -3.04854773e-02f, 1.73704457e-02f, -6.08161278e-03f, -6.05777791e-03f, 2.11724862e-02f, 1.62775405e-02f, 2.28144061e-02f,
  1.70042709e-01f, 2.68486053e-01f, 4.06527296e-02f, 2.36451905e-02f, 3.21650654e-02f, -1.88813973e-02f, -2.25785449e-02f, 3.11492272e-02f, 7.35735372e-02f, 5.63382469e-02f,
  -3.40952352e-02f, -2.33478677e-02f, -1.17454561e-03f, -2.03681067e-02f, 3.40333581e-02f, 5.04182428e-02f, 5.62889054e-02f, 8.61723721e-02f, -1.09331287e-01f, 7.39983916e-02f,
  -1.83152203e-02f, 7.00853541e-02f, 2.37528849e-02f, 4.24920321e-02f, -1.68480705e-02f, -1.62581019e-02f, -7.99191371e-02f, 4.92914729e-02f, 5.86792314e-03f, 4.59253490e-02f,
  2.66737062e-02f, 1.49026260e-01f, -1.73483729e-01f, 2.77905852e-01f, 6.15547262e-02f, -1.99624151e-01f, -7.51494095e-02f, 6.49950802e-02f, 1.47146523e-01f, 5.70178702e-02f,
  3.09091937e-02f, 3.13595310e-02f, -1.76179886e-01f, -4.00231332e-02f, -3.40082586e-01f, -2.37006560e-01f, -1.23220980e-01f, 6.99767694e-02f, -7.03925118e-02f, 1.74545184e-01f,
  -4.52587530e-02f, 5.20390272e-02f, -2.80434281e-01f, 6.36730269e-02f, -8.09587911e-02f, 8.89051259e-02f, -1.79743450e-02f, 8.02393481e-02f, -7.59287626e-02f, -3.85862077e-03f,
  -2.12604538e-01f, 1.46785706e-01f, 2.06429344e-02f, 1.46130687e-02f, -6.28319383e-02f, 1.40670710e-03f, -1.46085303e-02f, -6.02034666e-02f, 1.92962997e-02f, -3.37396897e-02f,
  -2.30567288e-02f, -1.15411371e-01f, -1.84952340e-03f, -7.11679310e-02f, 6.97759390e-02f, -5.28898314e-02f, -8.59574080e-02f, -6.44946843e-02f, 2.16826727e-03f, -9.52323005e-02f,
  -8.93473178e-02f, -9.16044265e-02f, 4.45625652e-03f, -4.37389649e-02f, -4.40937616e-02f, 6.29310906e-02f, -8.95393193e-02f, -2.01163758e-02f, -9.18143392e-02f, 6.68136999e-02f,
  -2.53214091e-02f, 8.90334696e-02f, 6.58856556e-02f, 1.17554842e-02f, 2.64206287e-02f, 6.62006363e-02f, 2.48602536e-02f, -6.44777119e-02f, 6.36800006e-02f, -2.51138676e-03f,
  2.24782955e-02f, 7.44841434e-03f, 4.49282639e-02f, -7.52384141e-02f, 1.12074599e-01f, 3.87213789e-02f, -1.07178055e-02f, -3.39270681e-02f, -2.02339422e-02f, -8.80607143e-02f,
  2.82653384e-02f, 1.62164737e-02f, -8.23967811e-03f, -3.00768926e-03f, 8.25812146e-02f, -5.76777011e-02f, 5.50312037e-03f, -3.30596268e-02f, 2.46637594e-02f, -2.25840807e-02f,
  2.03286260e-01f, 1.77212641e-01f, -1.13868881e-02f, -4.80335765e-03f, -1.57730673e-02f, 2.56536715e-02f, 8.11493769e-02f, -5.91185465e-02f, 4.02677022e-02f, 1.52048352e-03f,
  4.22431044e-02f, 2.09989697e-02f, -1.83120798e-02f, -1.37544675e-02f, -1.80645883e-02f, -1.48308314e-02f, 1.35583848e-01f, 3.64793390e-02f, 2.54994892e-02f, -2.28564665e-02f,
  1.14879385e-02f, 2.49350742e-02f, 3.33555117e-02f, -4.42810319e-02f, -4.48373333e-02f, 3.17544676e-02f, 2.31308639e-02f, 1.77883655e-02f, -3.72600928e-02f, -3.25270779e-02f,
  3.39782625e-01f, 1.53856948e-02f, 2.91001022e-01f, 2.26000622e-01f, -1.21278211e-01f, -2.50266701e-01f, -4.50974591e-02f, 3.31155770e-03f, 7.77395964e-02f, -1.11594595e-01f,
  2.69616265e-02f, -1.26975104e-02f, 6.04025349e-02f, -9.08009633e-02f, 1.25330552e-01f, 8.79059732e-02f, 1.03653753e-02f, -2.23631114e-02f, 1.04887493e-01f, -2.41398569e-02f,
  4.11413535e-02f, -1.14771768e-01f, 2.19683245e-01f, -9.14264023e-02f, 2.08211318e-02f, 1.12936264e-02f, -4.74168845e-02f, -1.09720938e-02f, 2.97332439e-03f, -7.36615341e-03f,
  9.06953588e-02f, 1.66589413e-02f, -8.95221438e-03f, 3.97280864e-02f, -1.91634577e-02f, -6.94840476e-02f, 9.25099291e-03f, 2.53564194e-02f, 7.11097196e-02f, 4.31397147e-02f,
  -1.22107379e-01f, -4.78003472e-02f, -1.05654314e-01f, -4.78359461e-02f, -1.43245785e-02f, 1.01939350e-01f, 5.07518053e-02f, 5.41529059e-02f, 4.48285751e-02f, 3.91883291e-02f,
  4.17420715e-02f, 3.25152352e-02f, 3.84788364e-02f, -3.85559946e-02f, 8.15011561e-03f, 6.29611686e-02f, 3.97769921e-03f, -3.65232080e-02f, -1.92847326e-02f, 4.14154027e-03f,
  -4.31820471e-03f, -8.20830390e-02f, 7.53505602e-02f, -4.76313978e-02f, 5.03768735e-02f, 5.66804260e-02f, -1.71646420e-02f, -4.02691625e-02f, -9.59570520e-03f, -1.58453081e-03f,
  1.00967549e-02f, 4.98871729e-02f, 5.46059618e-03f, 2.06359494e-02f, -1.48425736e-02f, 2.27473285e-02f, -1.13225551e-02f, 7.25885294e-03f, -2.03219615e-02f, -1.99027937e-02f,
  8.80867690e-02f, -1.69317424e-02f, 3.20968628e-02f, -7.00856000e-02f, -1.24277715e-02f, 2.49286275e-02f, -3.99396345e-02f, 7.47371092e-02f, -4.44304682e-02f, 1.01531707e-02f,
  -1.62571847e-01f, -1.91815913e-01f, -2.98359524e-02f, -9.82500147e-03f, -5.94909005e-02f, 1.57016758e-02f, 5.13998978e-03f, -7.67758414e-02f, 4.01089489e-02f, -4.89947684e-02f,
  -6.40454963e-02f, 1.65479630e-02f, -2.80787284e-03f, 6.75559193e-02f, 2.39849160e-03f, 1.44128148e-02f, -3.55457440e-02f, 7.39658251e-02f, -1.36061743e-01f, 1.48672797e-02f,
  -7.01713040e-02f, -3.54711488e-02f, -2.20589116e-02f, 8.12845957e-03f, -1.26364142e-01f, -2.59621069e-02f, -9.28082317e-02f, 1.21336274e-01f, -5.07243797e-02f, -3.04641984e-02f,
  -2.72693306e-01f, -1.29907027e-01f, 1.76781397e-02f, -2.81558633e-01f, -4.37216498e-02f, -8.01158249e-02f, 8.65712911e-02f, -2.42304489e-01f, -2.47576907e-01f, -1.60247255e-02f,
  6.98430315e-02f, 8.66727829e-02f, 1.23241194e-01f, -2.14136094e-02f, 1.75668746e-01f, 1.18951268e-01f, -1.78156286e-01f, -1.18266746e-01f, -1.34490207e-01f, -1.43566951e-01f,
  -9.44396928e-02f, 1.28472652e-02f, 1.68021917e-01f, -6.20571151e-02f, -7.80800208e-02f, -1.16870753e-01f, 1.56746864e-01f, 1.22423619e-01f, 2.92670205e-02f, 1.16901174e-01f,
  -7.47825056e-02f, -1.03779905e-01f, 3.06585096e-02f, -3.62163037e-03f, -9.06022713e-02f, 1.62703190e-02f, 5.24123646e-02f, 8.12265351e-02f, 3.44431512e-02f, -1.02303788e-01f,
  1.12075128e-01f, -2.48616049e-03f, -8.96232948e-02f, -7.67633505e-03f, -2.44560298e-02f, -1.16687521e-01f, 2.57307254e-02f, -7.24138552e-03f, 2.82850093e-03f, 6.87572509e-02f,
  6.44141436e-02f, 6.21788390e-02f, -1.93377361e-02f, -5.19196726e-02f, -5.49185695e-03f, -3.83687019e-03f, 4.29151244e-02f, 1.06845185e-01f, 2.95943525e-02f, -7.46791959e-02f,
  -5.73515929e-02f, 6.35169744e-02f, -3.80342789e-02f, -8.36373493e-03f, -1.64430812e-02f, 1.84549578e-02f, 4.39603440e-02f, 1.79189462e-02f, 5.98915573e-03f, 4.83851805e-02f,
  -3.92377749e-02f, 2.39500217e-02f, -3.29933465e-02f, -2.43675473e-04f, -5.98122068e-02f, 5.21906978e-03f, -3.24619412e-02f, 2.99790259e-02f, -2.64049098e-02f, 7.01463968e-02f,
  -1.39810992e-02f, 6.83071837e-02f, 3.89636010e-02f, 5.95814772e-02f, 1.90647338e-02f, 5.97785078e-02f, -7.38414675e-02f, 4.54260372e-02f, 8.34263712e-02f, -3.31482477e-02f,
  -2.98561245e-01f, -2.90622771e-01f, -8.47397894e-02f, -7.82340243e-02f, -2.31410749e-03f, -8.63989517e-02f, -5.97158968e-02f, -1.91544369e-02f, -7.55221248e-02f, -4.88635004e-02f,
  1.57367892e-03f, 1.00718057e-02f, -7.72456601e-02f, -2.12873146e-02f, 7.09369183e-02f, -8.56615882e-03f, 5.15623353e-02f, -4.09816876e-02f, -6.94769714e-03f, -1.05069708e-02f,
  -2.90942844e-02f, -4.11977172e-02f, 3.40104140e-02f, -1.44936725e-01f, 4.52113934e-02f, 6.92798123e-02f, -1.01690523e-01f, -9.05123074e-03f, -3.28736268e-02f, 9.89799760e-03f,
  4.06582206e-01f, -1.41934216e-01f, 5.90895452e-02f, 2.20206395e-01f, 9.11327153e-02f, -8.86495560e-02f, 5.52955344e-02f, -1.97098609e-02f, 2.55841408e-02f, -1.35818824e-01f,
  1.23529203e-01f, -1.35965627e-02f, 2.31769644e-02f, 3.22259180e-02f, 2.33804435e-01f, -8.10818076e-02f, 6.31203502e-02f, 2.74767373e-02f, 2.86944751e-02f, -1.79543458e-02f,
  4.71440107e-02f, 1.04408041e-01f, -1.80201344e-02f, -1.70634568e-01f, -3.63287106e-02f, -1.97520275e-02f, -1.09893829e-02f, -3.54051292e-02f, -1.42871514e-02f, -4.26662713e-03f,
  6.77245185e-02f, -3.43037732e-02f, 5.29447645e-02f, -1.12208903e-01f, -6.21532537e-02f, -6.17741384e-02f, -6.41384348e-02f, -9.47437808e-03f, 5.77766041e-04f, 2.16008313e-02f,
  3.33985835e-02f, -2.80717053e-02f, -1.89214433e-03f, 6.54751137e-02f, 1.92293059e-02f, -2.05690097e-02f, -9.30129457e-03f, -1.80319715e-02f, -3.16681638e-02f, -5.50270304e-02f,
  6.17104257e-03f, -3.91166471e-03f, 5.87992882e-03f, -9.94525328e-02f, 1.29022393e-02f, 2.17159651e-02f, -9.67956632e-02f, 9.35082883e-03f, 1.66404434e-02f, -8.09076279e-02f,
  -2.19078399e-02f, -5.59892766e-02f, -1.76112559e-02f, 1.13444999e-02f, -1.22957928e-02f, -3.61910090e-03f, 4.34312187e-02f, -9.96366516e-03f, 7.49833286e-02f, -2.01407988e-02f,
  2.43635103e-02f, 4.13191542e-02f, -1.34275379e-02f, -2.38857232e-02f, 6.63158624e-03f, -1.11933388e-02f, 3.56510617e-02f, -5.30789904e-02f, -2.04391163e-02f, 3.30284312e-02f,
  -9.39985272e-04f, 1.81066897e-03f, -3.49083506e-02f, 2.98267901e-02f, -1.48082414e-04f, 4.47105616e-02f, 6.63334923e-03f, -4.37108660e-03f, 6.50806203e-02f, 3.49323102e-03f,
  -1.81390002e-01f, -6.74531236e-02f, -3.78959142e-02f, 7.72320330e-02f, 5.72087467e-02f, 3.82911810e-03f, -4.27429518e-03f, 2.73871627e-02f, -5.42410091e-02f, 2.49730796e-02f,
  -4.80005965e-02f, 1.17748557e-02f, -5.96783683e-02f, 3.30325309e-03f, -5.86830592e-03f, -2.63678804e-02f, -3.61407697e-02f, -5.57129979e-02f, 4.90687750e-02f, -2.84430105e-02f,
  7.35966628e-03f, -4.82200738e-03f, -5.44677489e-02f, 3.95802073e-02f, 3.45971733e-02f, 2.39308421e-02f, -8.22487101e-03f, -2.69942936e-02f, -2.01794226e-02f, 1.73455756e-02f,
  -3.91467065e-02f, -2.23591462e-01f, -2.18306422e-01f, 3.31698246e-02f, 8.70298594e-02f, -1.09569006e-01f, 1.26923248e-01f, -2.56045777e-02f, -1.55528054e-01f, 6.84490055e-02f,
  9.29639414e-02f, -2.59849548e-01f, -4.27066125e-02f, -9.52991694e-02f, 2.45436579e-01f, -1.93076253e-01f, -1.83198471e-02f, -3.56717110e-02f, -1.14934295e-01f, 8.04861560e-02f,
  -6.43276349e-02f, 1.11802332e-01f, -6.37298375e-02f, 5.55030219e-02f, -2.69161235e-03f, -8.08232501e-02f, 3.59894395e-01f, 6.04269700e-03f, 9.05266479e-02f, 2.43624928e-03f,
  5.08541875e-02f, -1.20265201e-01f, -6.97622001e-02f, -8.71341228e-02f, 4.26644161e-02f, 1.33334566e-02f, 5.55871353e-02f, 1.97101501e-03f, 6.25817776e-02f, 6.91218441e-03f,
  -2.79473793e-02f, 2.25642119e-02f, -3.37729454e-02f, -1.56341400e-02f, -7.46417940e-02f, -3.36023457e-02f, -8.41281116e-02f, -1.77570824e-02f, 2.09191833e-02f, -1.15936138e-01f,
  -2.23828494e-04f, -1.23866044e-01f, 4.18572426e-02f, 8.58725421e-03f, -4.94118519e-02f, 3.80107173e-04f, -8.88037086e-02f, 3.30331028e-02f, 6.17340580e-02f, -3.85056883e-02f,
  -9.90490094e-02f, -3.91355939e-02f, -5.11094518e-02f, 1.19593926e-02f, 5.03799471e-04f, 8.52205455e-02f, -3.04495320e-02f, 1.23946697e-01f, -8.01120419e-03f, 4.75372337e-02f,
  9.05981362e-02f, 2.92752758e-02f, -1.71004776e-02f, -7.01853707e-02f, -5.41599169e-02f, 8.07855930e-03f, 2.52438933e-02f, 1.37573685e-02f, -2.35919897e-02f, 3.78273334e-03f,
  5.38148433e-02f, 2.18629390e-02f, 2.11355351e-02f, 1.02128964e-02f, -2.45686173e-02f, -5.66441864e-02f, 9.05738969e-04f, -7.50725791e-02f, 8.72601755e-03f, 2.44565234e-02f,
  2.05696180e-01f, 1.46939963e-01f, 5.65117821e-02f, -7.77893094e-03f, 1.15894480e-02f, 7.65309576e-03f, -1.01144172e-01f, -4.64962497e-02f, -8.43597427e-02f, 3.54286879e-02f,
  1.59045123e-02f, 3.05734649e-02f, 6.05018698e-02f, -3.15045044e-02f, 4.43176962e-02f, 7.41995813e-04f, 6.73564672e-02f, 5.64251728e-02f, 1.30376950e-01f, 4.00856547e-02f,
  8.68240520e-02f, 6.40914515e-02f, 4.39000428e-02f, 3.46859656e-02f, 3.19663063e-02f, -1.38621815e-02f, 1.00999372e-02f, -9.68992561e-02f, 4.07627609e-04f, -1.92299858e-02f,
  -2.77482063e-01f, -2.39148065e-01f, 2.26333708e-01f, -1.02105550e-01f, -1.62268318e-02f, 5.08815050e-02f, 2.08395422e-01f, -9.01735425e-02f, -9.07164663e-02f, -2.00593814e-01f,
  -6.18335791e-02f, 6.07078243e-03f, 4.77452297e-03f, -1.55174136e-01f, 7.81052634e-02f, -1.14093043e-01f, -2.43534088e-01f, -1.48590520e-01f, -1.92239328e-04f, -6.08910955e-02f,
  -1.96858663e-02f, -8.40244666e-02f, 2.25933254e-01f, 3.92422490e-02f, -2.41052676e-02f, 7.74808973e-02f, 8.58904421e-03f, 1.38807818e-01f, -4.16116528e-02f, 4.83017825e-02f,
  1.97674893e-02f, -1.40989712e-02f, 1.18202083e-02f, -5.70318438e-02f, 3.52340192e-02f, -3.25305983e-02f, 5.86714707e-02f, 1.42639309e-01f, 3.70849110e-02f, -4.77498733e-02f,
  3.28320004e-02f, -3.81321087e-02f, -1.62546225e-02f, 1.16126053e-02f, -4.40602977e-04f, 2.04199832e-03f, -6.65231049e-02f, 1.67357083e-02f, -8.16187449e-03f, 7.37572908e-02f,
  -6.10330775e-02f, 3.17398869e-02f, -1.20580597e-02f, 2.01651752e-02f, 1.05778567e-01f, -9.25778132e-03f, -4.73719127e-02f, 1.49191558e-01f, -3.72575745e-02f, 3.83870117e-02f,
  4.07788530e-02f, -9.38106235e-03f, -8.32638703e-03f, -4.09660265e-02f, 2.04561669e-02f, -6.23783059e-02f, -6.37757629e-02f, 4.57511693e-02f, -3.34181413e-02f, -3.46176550e-02f,
  4.96498607e-02f, -7.93041140e-02f, -9.88000818e-03f, -5.68128973e-02f, 5.09510860e-02f, -3.75979058e-02f, 9.29859206e-02f, -8.67237076e-02f, -1.08430302e-02f, -6.69944659e-02f,
  -1.36761786e-02f, 1.52356271e-02f, -7.43151829e-03f, 1.22419670e-02f, 3.69466990e-02f, -3.79100954e-03f, 5.26531562e-02f, -4.76512834e-02f, -1.02609536e-02f, 5.42688966e-02f,
  -3.57903689e-01f, -2.59829581e-01f, 2.24972200e-02f, 3.96002224e-03f, -4.53053880e-03f, -4.95387241e-02f, 4.34360169e-02f, -3.12891230e-02f, -6.44786283e-02f, 1.99405593e-03f,
  6.83542807e-03f, -8.62592980e-02f, 2.81427037e-02f, 2.27636687e-04f, 6.98051006e-02f, -1.69671681e-02f, 9.61688906e-03f, -7.22806081e-02f, -5.53191900e-02f, -1.87113285e-02f,
  -7.52845407e-02f, -4.72338125e-02f, 6.16345219e-02f, -2.34279223e-02f, -5.83725832e-02f, -2.66477689e-02f, -1.00083556e-02f, 5.30131608e-02f, -6.64178003e-03f, 2.41562128e-02f,
  -3.41450214e-01f, -2.86197178e-02f, 1.63439829e-02f, -1.52100146e-01f, -1.03450648e-01f, -8.60828087e-02f, -1.23364232e-01f, -2.64708009e-02f, -3.20113242e-01f, 1.25093967e-01f,
  5.24314456e-02f, -1.15060816e-02f, 1.01556204e-01f, -9.79903489e-02f, -2.84845531e-01f, -2.21176483e-02f, -1.73354208e-01f, -2.57746316e-03f, -6.91259280e-02f, -2.00318824e-02f,
  -5.23091964e-02f, -9.64193121e-02f, 5.74342534e-02f, 9.07823741e-02f, 3.96985523e-02f, 9.79171172e-02f, 1.94623008e-01f, 8.76219571e-02f, 3.37970667e-02f, -1.08598927e-02f,
  -2.10589860e-02f, 1.27480607e-02f, -1.78097207e-02f, 1.47691350e-02f, 1.48828151e-02f, 8.98322389e-02f, 2.66929846e-02f, -1.19081764e-02f, -7.15080053e-02f, 4.63973470e-02f,
  4.82013449e-02f, -3.72631773e-02f, -9.46760625e-02f, 1.85624529e-02f, -7.93854147e-02f, -7.45783225e-02f, -6.16429895e-02f, 3.99594987e-03f, 8.93027242e-03f, -1.54947415e-02f,
  -3.97460768e-03f, -2.56695729e-02f, 4.82323654e-02f, -1.49649684e-03f, 3.08880359e-02f, -2.10309196e-02f, -2.12341268e-02f, 3.18531916e-02f, 3.57404463e-02f, -8.70654956e-02f,
  -8.74751527e-03f, -2.41514854e-02f, -1.08351531e-02f, 1.57088749e-02f, -2.33286824e-02f, 6.32587774e-03f, -6.72989478e-03f, 3.96755412e-02f, -3.12070921e-02f, -1.34407002e-02f,
  -2.38730479e-02f, 4.63620089e-02f, 1.02432363e-03f, -5.24532422e-02f, -3.47691514e-02f, 5.99139258e-02f, 7.99206197e-02f, -2.35915836e-03f, -1.63502395e-02f, -3.52894254e-02f,
  2.28446927e-02f, -1.72750484e-02f, -1.02101667e-02f, 1.03613690e-01f, -2.05663014e-02f, -1.01297135e-02f, -7.33912596e-03f, 2.71572731e-02f, 3.64660881e-02f, 5.19369356e-02f,
  5.70922298e-03f, 3.01102605e-02f, -6.03119517e-03f, -7.30940849e-02f, 7.29968846e-02f, 2.57952698e-02f, -4.36197296e-02f, -2.50098538e-02f, 4.82277274e-02f, 1.86742190e-02f,
  -1.25550758e-02f, 5.72006451e-03f, 5.92424683e-02f, 6.26805052e-03f, -3.05726528e-02f, 4.98256199e-02f, 3.16657163e-02f, 6.41702535e-03f, 1.83200967e-02f, 3.98011617e-02f,
  6.72675967e-02f, -5.49167469e-02f, -2.77963877e-02f, 2.87088081e-02f, -1.37030138e-02f, 2.65678596e-02f, -8.96211434e-03f, -3.64720039e-02f, 3.91512252e-02f, -4.35967371e-03f,
  -3.07333410e-01f, 1.27376482e-01f, 1.79488078e-01f, 1.15805939e-01f, 4.72627170e-02f, 2.77524769e-01f, 3.79530221e-01f, 2.37575937e-02f, -8.61938752e-04f, 6.99710473e-02f,
  1.22548096e-01f, -6.42425716e-02f, -3.01279090e-02f, 3.06625336e-01f, 2.32757088e-02f, -4.80549969e-02f, 2.64039218e-01f, 1.51701972e-01f, -2.11909860e-02f, -3.73704545e-02f,
  9.98221245e-03f, 1.68082029e-01f, 1.21742167e-01f, -1.00208402e-01f, 9.40214247e-02f, 7.40277115e-03f, -1.11795582e-01f, -1.13235369e-01f, 4.20430712e-02f, 1.08327679e-01f,
  -3.92657258e-02f, -2.28073269e-01f, 1.05151027e-01f, -6.29216954e-02f, 4.40617688e-02f, 3.91754881e-02f, 1.24313822e-02f, -2.28672940e-02f, 4.05436307e-02f, 7.26149604e-02f,
  3.43615301e-02f, -4.92203832e-02f, 5.52311689e-02f, -4.36238647e-02f, 6.32292926e-02f, 6.65531680e-02f, 9.21076983e-02f, 3.47729065e-02f, 1.21024542e-03f, -7.63104996e-03f,
  3.10273971e-02f, 2.62941867e-02f, 2.35965513e-02f, -2.97492906e-03f, 2.80380715e-02f, -8.90985224e-03f, -9.50670335e-03f, -7.17466995e-02f, 2.54466059e-03f, 6.91871643e-02f,
  -4.14321460e-02f, -9.92564857e-02f, 6.21612556e-02f, -2.69822553e-02f, -4.63148020e-02f, -6.73637986e-02f, -6.43304922e-03f, -1.06333099e-01f, 2.10213866e-02f, -8.08031932e-02f,
  8.41217022e-03f, 2.30837483e-02f, -5.81752807e-02f, 2.10186522e-02f, 3.78324604e-03f, -3.17917243e-02f, -4.10554111e-02f, -8.50712974e-03f, 3.99621129e-02f, -1.54824648e-02f,
  -5.57909198e-02f, -2.18958426e-02f, 2.18832176e-02f, -1.08732041e-02f, -4.86291666e-03f, -2.85032261e-02f, 3.38862091e-02f, -3.99462283e-02f, 1.99586395e-02f, 1.52820256e-03f,
  -1.93023998e-02f, -2.51016021e-01f, 3.82907912e-02f, 1.19426049e-01f, -4.42128256e-02f, 6.38800114e-02f, -3.54029723e-02f, 6.76790178e-02f, -6.08744882e-02f, 2.36953218e-02f,
  -2.09666453e-02f, 1.56974383e-02f, -8.24070945e-02f, 3.60809965e-04f, -8.33751485e-02f, 5.86777776e-02f, -8.03760588e-02f, -4.27581929e-02f, 4.89767157e-02f, 4.32475768e-02f,
  7.03731831e-03f, 5.72978612e-03f, 8.71168263e-03f, -5.48204640e-03f, -5.92518365e-03f, 6.92044944e-02f, 9.87771060e-03f, -2.75983997e-02f, 7.29952976e-02f, 6.08428791e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.87410966e-01f, 4.44674969e-01f, 2.52233326e-01f, 3.13118160e-01f, -1.42047331e-01f, -2.75210351e-01f, -2.36872703e-01f, 1.19667135e-01f, -4.67769019e-02f, 5.27815297e-02f,
  -4.80200760e-02f, 4.72089499e-01f, 7.99920782e-02f, 3.32735747e-01f, 4.26516384e-02f, 3.74331027e-02f, 2.81929880e-01f, 1.46123897e-02f, 6.99142143e-02f, 2.82428592e-01f,
  1.16963632e-01f, 3.62803298e-03f, 2.51268566e-01f, 4.54651155e-02f, 1.19489565e-01f, 1.18253767e-01f, 1.82036355e-01f, -3.49957054e-03f, 1.63794398e-01f, 4.94102500e-02f,
  3.07246912e-02f, 2.00344667e-01f, 3.20411101e-02f, 1.33487685e-02f, 6.60945028e-02f, -4.06637453e-02f, -1.56348087e-02f, -7.62823746e-02f, -1.45921260e-01f, 1.56662345e-01f,
  7.02941651e-03f, 8.67592767e-02f, 5.47067868e-03f, 2.44159605e-02f, -3.38287465e-02f, -7.52942115e-02f, 9.85390246e-02f, 5.39477505e-02f, 4.23346348e-02f, 1.18203945e-01f,
  5.50408177e-02f, 4.97150794e-02f, -1.37686189e-02f, 4.02175672e-02f, 1.16579212e-01f, 4.71422523e-02f, 1.90277379e-02f, 8.12950283e-02f, 4.45519388e-02f, -3.31545174e-02f,
  2.63366625e-02f, -5.18176369e-02f, -1.67509522e-02f, -9.36511010e-02f, 5.65758161e-02f, -1.68437883e-02f, 7.83870742e-02f, 4.28952351e-02f, -5.69981476e-03f, -4.97166347e-03f,
  9.14232992e-03f, 1.12789854e-01f, 4.42063324e-02f, 3.88493054e-02f, 1.34386182e-01f, -2.53242608e-02f, -9.45224892e-03f, -6.20470755e-02f, 4.27864194e-02f, 1.51915830e-02f,
  -3.96571793e-02f, -1.43662225e-02f, 2.93759573e-02f, -5.10643423e-02f, -1.03782386e-01f, -9.26381499e-02f, 1.38240829e-01f, 7.73838907e-02f, -7.56971911e-02f, 2.83072311e-02f,
  2.19206303e-01f, 3.36952865e-01f, 2.48681251e-02f, -6.63750544e-02f, -4.70140427e-02f, 1.79239325e-02f, -5.14292940e-02f, 1.48522779e-01f, 1.31077439e-01f, 1.26717100e-02f,
  7.59126097e-02f, -9.60449576e-02f, -1.22984136e-02f, -1.16868690e-02f, 5.33673959e-03f, 3.67390104e-02f, 3.12425829e-02f, -6.89911321e-02f, 5.93069233e-02f, 1.29102349e-01f,
  -3.48249637e-02f, 1.10429786e-01f, 3.38917924e-03f, -5.37041426e-02f, -7.15652555e-02f, 2.73724645e-02f, 4.48276056e-03f, -4.70172949e-02f, 1.63722485e-02f, 7.16976598e-02f,
  1.88885123e-01f, 2.21164361e-01f, 7.53518939e-02f, -5.48619516e-02f, 2.35546418e-02f, -3.41927081e-01f, -2.27921784e-01f, 4.27435189e-02f, -3.09151441e-01f, 1.46788463e-01f,
  -7.13531896e-02f, 6.23445064e-02f, -1.50898457e-01f, -3.34802240e-01f, -5.12675107e-01f, -4.84381467e-01f, -1.64591163e-01f, -6.55709431e-02f, -2.27133155e-01f, 2.07825989e-01f,
  -8.54934603e-02f, -1.05700471e-01f, 7.85815623e-03f, 1.72928542e-01f, 1.68559894e-01f, 2.99407423e-01f, 3.14727098e-01f, 2.32815817e-02f, 3.07378143e-01f, -1.16022602e-01f,
  -1.60842240e-01f, -1.07043967e-01f, 5.19046448e-02f, -1.51013598e-01f, 5.38658537e-02f, 7.59161189e-02f, 1.16026804e-01f, -6.19436316e-02f, -6.96409792e-02f, -6.91481978e-02f,
  7.12251663e-02f, -5.81444465e-02f, -9.54089910e-02f, -2.62429528e-02f, 1.83338821e-02f, -9.18321963e-03f, 1.23870738e-01f, 1.10528199e-02f, -6.00020923e-02f, -7.41274748e-03f,
  7.85622820e-02f, -9.92815662e-03f, 9.57594067e-02f, 1.10555157e-01f, 1.68395936e-02f, -7.04255980e-03f, 1.85897816e-02f, 1.36858687e-01f, 8.45611282e-03f, -3.44181210e-02f,
  1.13368491e-02f, -4.38918844e-02f, -2.30130572e-02f, -1.06061250e-01f, -4.47570570e-02f, 1.14777396e-02f, -1.14640079e-01f, 2.38663573e-02f, -5.78169487e-02f, 2.92902496e-02f,
  1.17821276e-01f, 3.42751760e-03f, -1.49577498e-01f, 4.35107574e-02f, 1.67357689e-03f, -4.91238870e-02f, 5.01541644e-02f, 5.24575114e-02f, -1.83245782e-02f, -5.89970453e-03f,
  -8.68923590e-02f, 1.83259137e-02f, 2.97110621e-02f, 2.92140972e-02f, -1.64596140e-01f, 1.34970933e-01f, -3.61301331e-03f, -2.69995984e-02f, 7.35331550e-02f, 3.66820134e-02f,
  -3.93686593e-02f, 7.60005489e-02f, 3.46248858e-02f, 6.26674816e-02f, -4.72984798e-02f, -4.70956378e-02f, -1.16231531e-01f, 4.00528014e-02f, 1.17669038e-01f, -5.87196015e-02f,
  3.67895737e-02f, 7.34993666e-02f, 9.69377086e-02f, 8.03954974e-02f, 1.51563808e-02f, 8.45615845e-03f, -4.70092185e-02f, 1.14902474e-01f, 6.39663711e-02f, 9.19703022e-03f,
  6.88918531e-02f, 5.13348542e-02f, -1.02951176e-01f, 8.48776624e-02f, 8.18042383e-02f, 7.95934200e-02f, 2.96463389e-02f, 1.70756839e-02f, -4.59800102e-02f, -7.34335333e-02f,
  3.37639272e-01f, 2.87506841e-02f, 1.56048015e-01f, 3.86185765e-01f, -2.28416249e-01f, -4.37008083e-01f, -5.26236355e-01f, -1.38818789e-02f, -1.86273262e-01f, -2.24933490e-01f,
  -4.64093592e-03f, 6.05599070e-03f, -3.27649474e-01f, 2.40490794e-01f, 2.64906287e-01f, -2.35861346e-01f, 1.51609063e-01f, 3.38419825e-02f, -7.61013478e-02f, 5.04415333e-02f,
  1.73397988e-01f, 1.74079776e-01f, 3.89878988e-01f, 3.68683010e-01f, 1.25498027e-01f, 3.87341738e-01f, 2.70054966e-01f, 1.46356553e-01f, 4.10761476e-01f, 1.80760086e-01f,
  -5.68215549e-02f, 4.74419259e-02f, 7.86745399e-02f, 5.84816337e-02f, -2.06184238e-02f, 1.29356161e-02f, -8.97475779e-02f, -8.61965586e-03f, 1.74366329e-02f, -3.75507623e-02f,
  -5.24535701e-02f, 1.55082077e-01f, 5.93023114e-02f, 2.97065079e-02f, -5.58281317e-02f, 3.59100364e-02f, -7.27659790e-04f, -4.17526551e-02f, -4.70075533e-02f, 4.17335890e-02f,
  -8.48878548e-02f, -2.65503060e-02f, -6.80140108e-02f, 8.81529525e-02f, 3.30747291e-02f, -1.03088394e-02f, 2.06506010e-02f, -7.01150149e-02f, 1.35393310e-02f, 3.68259735e-02f,
  1.01352762e-02f, -6.98928954e-03f, -1.26136132e-02f, 7.77280182e-02f, -6.69477833e-03f, -2.56857295e-02f, -3.07499822e-02f, -6.09290116e-02f, 3.75988632e-02f, -6.76496103e-02f,
  7.00817928e-02f, 3.76883931e-02f, -8.96257628e-03f, -1.47077709e-01f, -5.15404232e-02f, -7.97211006e-02f, -1.78990737e-02f, 3.17009613e-02f, 6.03688248e-02f, -3.68707580e-04f,
  -5.91966957e-02f, 5.46645299e-02f, -6.19808733e-02f, 1.13293612e-02f, 4.09108847e-02f, -5.21247424e-02f, 4.31552269e-02f, -3.94738726e-02f, 1.11526623e-03f, -2.33449619e-02f,
  -1.32076636e-01f, 4.66330126e-02f, 2.25757752e-02f, 7.03244582e-02f, -2.70960163e-02f, -9.66684073e-02f, 1.16190426e-01f, 4.15626988e-02f, 8.68689641e-02f, 1.84310116e-02f,
  4.38857153e-02f, 7.17170909e-03f, -1.47463709e-01f, 1.10250913e-01f, 7.22266510e-02f, -1.99286174e-02f, 5.41079007e-02f, 8.96825269e-03f, 3.19566503e-02f, 5.25670275e-02f,
  6.56856000e-02f, -2.20966652e-01f, 7.00437576e-02f, -2.38034539e-02f, 4.60240152e-03f, -6.54582754e-02f, -5.91835529e-02f, -1.64067501e-03f, 4.89059873e-02f, 5.68165481e-02f,
  -2.36083940e-02f, 4.90613431e-02f, -1.16200902e-01f, 3.32570672e-02f, -4.64643911e-02f, -4.14112478e-01f, -2.63464630e-01f, -4.83839102e-02f, 1.74892515e-01f, 2.38662094e-01f,
  -3.91927212e-02f, 1.28951609e-01f, -7.19033480e-02f, -1.54359281e-01f, -2.42180049e-01f, -1.34450763e-01f, -2.86819577e-01f, 2.01497227e-02f, 3.38144638e-02f, -2.56719887e-01f,
  -1.41810641e-01f, -2.03582034e-01f, -2.36602247e-01f, -1.60958976e-01f, -1.84014156e-01f, 1.07593529e-01f, -7.72502944e-02f, 3.42657305e-02f, 1.61103811e-02f, 1.31052136e-01f,
  5.36853112e-02f, 2.56386012e-01f, 5.12326658e-02f, 3.60865444e-02f, -1.05025046e-01f, 4.27394025e-02f, -8.51566121e-02f, 5.87897897e-02f, 7.25200400e-02f, 7.14352280e-02f,
  7.76068540e-03f, -4.18233834e-02f, 2.56218724e-02f, 3.37720402e-02f, -1.02592614e-02f, 3.56942005e-02f, -6.48830086e-02f, -6.08775765e-02f, 7.70719573e-02f, 1.46489758e-02f,
  4.58519943e-02f, 6.41222596e-02f, -6.78490177e-02f, 4.08984609e-02f, -2.98395697e-02f, 1.88820474e-02f, 5.71903177e-02f, -5.24966570e-04f, 5.19417413e-02f, -8.89550149e-03f,
  -5.01027144e-02f, -4.43465598e-02f, -5.21482155e-02f, 3.98349054e-02f, 1.91488285e-02f, 2.17512380e-02f, 5.66170476e-02f, 8.17327276e-02f, -7.65708089e-02f, -6.33677393e-02f,
  -2.60162689e-02f, -5.56932064e-03f, 2.77977530e-02f, -1.36941060e-01f, -1.75985038e-01f, 6.91365898e-02f, -6.17650449e-02f, 8.46631154e-02f, -3.02161109e-02f, -4.90188822e-02f,
  7.79653639e-02f, -9.64087844e-02f, 1.21457083e-02f, 1.93855874e-02f, 1.35235675e-02f, 1.94214396e-02f, -2.67758826e-03f, 2.41391733e-02f, 2.18491945e-02f, -8.16141665e-02f,
  7.43169487e-02f, 1.32616565e-01f, 7.42352009e-02f, 6.92937300e-02f, 3.21531110e-02f, -1.33985296e-01f, -4.69722971e-02f, -6.40590861e-02f, 1.40760038e-02f, -9.55175981e-02f,
  -1.14060165e-02f, -1.33903846e-01f, -1.10471047e-01f, 2.12009065e-02f, -9.79768950e-03f, -3.51380161e-03f, -1.22421896e-02f, 3.09290588e-02f, 3.85937467e-02f, 7.88882375e-02f,
  2.63099652e-02f, 6.15762807e-02f, 2.09978539e-02f, 1.14070430e-01f, 5.48195690e-02f, -1.06031038e-02f, 8.77307951e-02f, 1.15215920e-01f, -1.11075394e-01f, 1.61254834e-02f,
  2.06130117e-01f, 1.59816012e-01f, -1.22192413e-01f, -4.34767902e-02f, -2.70890862e-01f, -3.19713742e-01f, -2.89714903e-01f, -9.73371565e-02f, -1.95833147e-02f, 3.21051955e-01f,
  -2.07612827e-01f, 3.73578489e-01f, 5.26084788e-02f, -1.19562343e-01f, -5.21862805e-01f, -2.28782743e-01f, -3.55822921e-01f, -3.04396898e-02f, -1.12129137e-01f, -3.18323597e-02f,
  -1.63007587e-01f, -3.21084291e-01f, -3.98424208e-01f, 1.99243575e-02f, -7.14526549e-02f, 1.05114229e-01f, -8.13360140e-02f, -1.15375184e-01f, 2.01892138e-01f, -9.32484940e-02f,
  -7.98236579e-02f, 1.71679258e-01f, 8.40238705e-02f, 1.27548292e-01f, -7.51273558e-02f, 3.32954414e-02f, 1.98542718e-02f, 7.50602083e-03f, -8.26499388e-02f, 6.94004148e-02f,
  6.80099353e-02f, 1.18035696e-01f, 6.10531829e-02f, 1.07467175e-02f, 7.71903768e-02f, 1.34524703e-01f, 3.16585749e-02f, 3.53726223e-02f, 9.79692712e-02f, -4.27719839e-02f,
  -2.76348125e-02f, -4.03457209e-02f, 5.63524924e-02f, 6.90616667e-02f, -6.37350082e-02f, 2.82245944e-03f, 9.75825414e-02f, -2.03039292e-02f, 1.10765412e-01f, -3.99371749e-03f,
  8.01875517e-02f, -5.43750711e-02f, -3.32900621e-02f, 9.40195695e-02f, -6.73766408e-05f, -5.21716289e-02f, -9.31439623e-02f, -4.56084833e-02f, 1.30539507e-01f, -6.34566993e-02f,
  6.85223471e-03f, 7.11047724e-02f, -7.90779665e-03f, 8.90445933e-02f, -3.27724703e-02f, -8.30006748e-02f, 2.37652790e-02f, 7.86275119e-02f, -9.93521214e-02f, 5.47613017e-02f,
  1.93764456e-02f, 4.35909536e-03f, 1.22145228e-01f, -4.54672799e-02f, -1.22004025e-01f, 6.60906136e-02f, 8.16073194e-02f, -7.71206170e-02f, -6.35932237e-02f, -7.48915672e-02f,
  -1.24369994e-01f, -1.22591890e-02f, -1.50220226e-02f, 1.11875452e-01f, 5.35771176e-02f, -4.33243923e-02f, -3.80563326e-02f, 8.61302614e-02f, -3.69110294e-02f, 1.01528183e-01f,
  4.68211882e-02f, -6.93133920e-02f, -5.23206452e-03f, 5.56076504e-02f, -6.92704227e-03f, -3.92500795e-02f, -7.51781836e-02f, -2.81895790e-02f, 2.39475332e-02f, 5.82844280e-02f,
  4.52439040e-02f, 1.47016793e-02f, -1.16736190e-02f, -8.18049684e-02f, 2.69208960e-02f, 1.97933875e-02f, 3.46150361e-02f, -1.75041407e-02f, -6.62945851e-04f, -8.24690685e-02f,
  -1.90072507e-01f, 1.23598501e-01f, -2.69734591e-01f, -1.49045601e-01f, -1.19127922e-01f, -4.40435320e-01f, -3.23698521e-01f, -1.26960799e-01f, -6.95581138e-02f, 3.04631311e-02f,
  -1.83050781e-01f, 5.72291762e-02f, 6.22328483e-02f, -6.96631670e-02f, -1.81038696e-02f, 1.02886967e-01f, -2.86832571e-01f, -2.41984233e-01f, 9.99231637e-02f, -1.76884949e-01f,
  -8.22781101e-02f, -1.29580215e-01f, -1.67115584e-01f, 7.51674175e-02f, -2.28033602e-01f, -1.90384348e-03f, 3.86814512e-02f, -6.44601434e-02f, -5.46051003e-02f, -2.84665916e-02f,
  -1.85609713e-01f, -1.97969005e-01f, -1.75534144e-01f, -1.17183059e-01f, -2.61229545e-01f, -1.59280792e-01f, -1.20750353e-01f, -6.47318140e-02f, 7.47549161e-02f, 4.19767871e-02f,
  5.67267351e-02f, -2.19239313e-02f, 2.27447841e-02f, 8.48476365e-02f, -7.65493289e-02f, 6.24605268e-02f, -1.42120086e-02f, -1.24327019e-01f, -1.12961940e-01f, -4.20794040e-02f,
  6.35892898e-02f, -4.85355482e-02f, -9.05808657e-02f, 1.13697827e-01f, -3.73671986e-02f, -7.49417767e-02f, -3.09813861e-03f, -2.88148858e-02f, -7.81644434e-02f, 4.27695643e-03f,
  -1.56387672e-01f, -5.78381866e-03f, -4.49379124e-02f, -1.86395384e-02f, 5.67695592e-03f, 3.25014815e-02f, 7.97291566e-03f, 5.24788126e-02f, 1.11886069e-01f, 8.28084275e-02f,
  3.04132160e-02f, 1.94569770e-02f, 2.03560246e-03f, -1.18276551e-01f, -4.68728133e-02f, -2.97327470e-02f, -4.67905402e-02f, 3.60804424e-02f, 1.78138018e-02f, 1.67113561e-02f,
  -8.24127644e-02f, -2.39283051e-02f, 3.61651368e-02f, -1.04059756e-01f, -5.31238429e-02f, -5.75987529e-03f, 1.09005705e-01f, 3.84404324e-02f, -1.01806052e-01f, -3.52858491e-02f,
  -1.77779242e-01f, -3.43561888e-01f, -7.73550197e-02f, 7.19881197e-03f, 6.58140033e-02f, -2.92797718e-04f, -8.54898542e-02f, 1.07714921e-01f, -2.29828246e-02f, -3.84435058e-02f,
  -4.24752235e-02f, 3.95228714e-02f, 2.20039790e-03f, -1.49988113e-02f, 1.17019854e-01f, -3.57682537e-03f, -3.86279933e-02f, 8.16971585e-02f, -1.31180048e-01f, -3.04686725e-02f,
  -4.79408838e-02f, 2.57259589e-02f, 3.41034681e-02f, -1.51984449e-02f, -9.28721800e-02f, 2.12967042e-02f, -1.42465830e-02f, -7.41034746e-02f, -1.03556663e-01f, -4.43661548e-02f,
  1.59308270e-01f, -1.15185574e-01f, -2.31496945e-01f, -2.86083017e-02f, 2.80526057e-02f, 2.88020432e-01f, 3.25298011e-01f, -3.25198442e-01f, -3.88839006e-01f, 8.63599032e-02f,
  2.99549758e-01f, 1.80372790e-01f, 2.21511886e-01f, 3.20553631e-01f, 3.04718316e-01f, 9.26707238e-02f, 1.38024271e-01f, 1.98073357e-01f, -1.75039187e-01f, 9.80338976e-02f,
  -9.88398343e-02f, 4.25246149e-01f, 6.18632399e-02f, 2.11492181e-02f, 2.24206105e-01f, -2.53662050e-01f, -4.81016971e-02f, 6.34507984e-02f, -2.32329331e-02f, 1.91633984e-01f,
  1.28147632e-01f, 4.70534153e-02f, 2.44230833e-02f, -2.68269074e-03f, 9.73019749e-03f, 6.49290308e-02f, 1.61886320e-01f, 1.75169691e-01f, -7.83692151e-02f, -1.49729606e-02f,
  -2.36885305e-02f, 3.15242261e-02f, -1.03444189e-01f, -1.17547950e-02f, -7.65539035e-02f, -9.99504551e-02f, -8.27017277e-02f, -1.54596074e-02f, -7.68851414e-02f, 1.12896807e-01f,
  -3.97944413e-02f, -2.20806319e-02f, -1.12599529e-01f, -2.40414627e-02f, -4.48437743e-02f, -7.68047497e-02f, -7.54972696e-02f, 6.55448958e-02f, -9.07733366e-02f, -9.75141004e-02f,
  2.23811367e-03f, -4.57641184e-02f, 3.62083577e-02f, 8.93017426e-02f, 4.24281843e-02f, 1.14901952e-01f, -5.89352250e-02f, 9.47478563e-02f, -1.05555914e-01f, 7.88648948e-02f,
  -7.85850435e-02f, 2.68670600e-02f, 5.76921143e-02f, -1.06220946e-01f, 1.53470904e-01f, -4.62020002e-03f, 1.53039005e-02f, -3.22736334e-03f, -1.29027870e-02f, -5.94113246e-02f,
  4.67570201e-02f, -8.91093239e-02f, 9.32846144e-02f, -6.01797663e-02f, 4.87324130e-03f, -3.24546406e-03f, 2.74148304e-03f, 1.49025666e-02f, -2.96308026e-02f, 3.55660915e-02f,
  7.10166097e-02f, -1.10971615e-01f, -3.48053128e-02f, -7.77828787e-03f, -1.60648581e-02f, 7.43313804e-02f, -6.72811568e-02f, -3.39187793e-02f, -3.77161540e-02f, 6.43869936e-02f,
  1.12777739e-03f, -6.78334013e-02f, -1.58489384e-02f, 5.66825122e-02f, -1.01027407e-01f, -7.25789666e-02f, 5.42020798e-02f, -5.70966676e-02f, -5.48961610e-02f, -8.92982036e-02f,
  8.12590774e-03f, -1.08732609e-02f, 6.54455200e-02f, -2.73603480e-02f, -5.60684921e-03f, 7.29025016e-03f, -3.43461372e-02f, -3.60493101e-02f, -1.28777782e-02f, -7.50885829e-02f,
  5.07142186e-01f, 2.15649068e-01f, 3.65448713e-01f, 5.05070746e-01f, -5.26067577e-02f, -3.23358744e-01f, -1.31441772e-01f, 1.42337665e-01f, 2.35656649e-01f, -4.32934761e-02f,
  -7.88927898e-02f, 3.41452926e-01f, -2.21334577e-01f, 3.23514909e-01f, -1.31500632e-01f, -3.04397762e-01f, 1.68573096e-01f, 7.25409463e-02f, -1.47395730e-02f, 1.47695959e-01f,
  1.74608842e-01f, -1.86304793e-01f, 2.35798180e-01f, 1.65842529e-02f, 2.17110574e-01f, 3.02488357e-01f, -5.32548912e-02f, -1.93341509e-01f, 1.21257238e-01f, -1.86593577e-01f,
  2.09843926e-02f, 7.32531250e-02f, 1.31003827e-01f, -2.11008582e-02f, -2.42750850e-02f, 3.91068794e-02f, 1.53910054e-03f, -8.21525380e-02f, -2.27587186e-02f, -4.48839739e-02f,
  7.06759244e-02f, -3.62585522e-02f, 8.74639601e-02f, -6.06597811e-02f, -1.04003148e-02f, 1.01391494e-01f, 1.39621971e-02f, 8.69737267e-02f, 6.73648044e-02f, -1.91947389e-02f,
  1.57476231e-01f, 4.52219732e-02f, 6.58849180e-02f, -1.56039476e-01f, 8.84097815e-02f, -2.61404905e-02f, -6.55285567e-02f, 4.24929671e-02f, 9.96383056e-02f, 1.22096455e-02f,
  -1.25864565e-01f, -1.15996063e-01f, -1.95277892e-02f, 1.06501706e-01f, -4.65116231e-03f, 7.98975863e-03f, -9.77493897e-02f, -3.45265009e-02f, -2.73871738e-02f, -6.11320771e-02f,
  2.30481848e-02f, 2.78325416e-02f, 1.60046108e-02f, 4.91368249e-02f, -1.92792136e-02f, 1.22590698e-01f, 4.13411595e-02f, -1.01360470e-01f, 8.44001845e-02f, 2.31309365e-02f,
  -5.15263230e-02f, -1.26018539e-01f, 3.47342230e-02f, 3.38345431e-02f, -6.29775152e-02f, -7.77175501e-02f, 5.63791133e-02f, 8.31247196e-02f, 6.91189244e-02f, -8.17661136e-02f,
  -3.02679569e-01f, -1.68580696e-01f, 4.16318234e-03f, -9.75237936e-02f, -9.64128005e-04f, 4.12160829e-02f, -4.82444167e-02f, 7.58212954e-02f, -1.38242841e-01f, -5.98494969e-02f,
  -5.37255146e-02f, -1.13568167e-04f, -1.23049773e-01f, -6.50984049e-02f, -4.44741882e-02f, -5.93624450e-02f, 6.24231212e-02f, -6.58465698e-02f, 2.37612799e-02f, 8.85461047e-02f,
  1.22223549e-01f, -6.60369247e-02f, 2.12365761e-02f, 7.32759684e-02f, 5.68694137e-02f, -8.43075067e-02f, 6.64913207e-02f, 3.92771475e-02f, -2.44057756e-02f, -1.97071116e-02f,
  -3.35994899e-01f, 2.58570969e-01f, -2.48369470e-01f, -4.49432075e-01f, 8.06854963e-02f, -2.32712284e-01f, -2.96992391e-01f, 3.72670852e-02f, -2.36066401e-01f, 5.25145344e-02f,
  5.05149774e-02f, -1.85337141e-01f, 2.15209246e-01f, -1.03990696e-01f, -4.45542336e-01f, 8.35295692e-02f, -3.07421774e-01f, -2.16772512e-01f, 1.18760895e-02f, -1.43417031e-01f,
  -3.09108552e-02f, 8.39378908e-02f, 6.91516176e-02f, 4.32128876e-01f, 4.21789885e-02f, -1.42766414e-02f, -1.14130266e-01f, 1.94137484e-01f, -6.31308779e-02f, 5.26575334e-02f,
  1.23149168e-03f, -2.23879330e-03f, 8.61375704e-02f, -2.83447299e-02f, 7.69493124e-03f, -5.24112135e-02f, -4.29565273e-02f, -6.99247941e-02f, 1.40128611e-02f, -1.23556666e-02f,
  -2.37862878e-02f, 4.91689332e-02f, -6.27818108e-02f, 8.53427276e-02f, 4.10232134e-02f, -1.72435809e-02f, 4.55021523e-02f, 1.56404767e-02f, 6.30870834e-02f, -6.39629960e-02f,
  3.60351577e-02f, -4.76258211e-02f, -1.45998120e-01f, -1.25288889e-01f, -4.17719968e-03f, 6.95536733e-02f, -2.28318587e-01f, -2.14387500e-03f, -7.12400153e-02f, -1.08726382e-01f,
  1.80900155e-03f, -7.37047717e-02f, -1.23248454e-02f, 6.05012923e-02f, 2.87846960e-02f, 1.87929142e-02f, 5.97261358e-03f, -3.70849818e-02f, -5.16107641e-02f, 3.53115313e-02f,
  -2.93677170e-02f, -7.96381682e-02f, -6.89813169e-03f, -2.68386956e-02f, -2.65691336e-03f, -8.14927444e-02f, 6.10962324e-02f, -3.77392024e-02f, -1.40142664e-01f, -6.07605167e-02f,
  6.20259121e-02f, -8.92069936e-02f, 1.49854168e-03f, -1.74431000e-02f, 1.64159164e-02f, -4.24680812e-03f, 1.46487672e-02f, -1.24001000e-02f, 1.79132614e-02f, -3.62776592e-02f,
  -4.89165932e-02f, -6.95708096e-02f, 1.11449756e-01f, 5.36896661e-02f, 5.12922555e-02f, -2.86319144e-02f, -4.30164523e-02f, -7.20192641e-02f, -1.80012047e-01f, -5.15702926e-02f,
  -1.16621383e-01f, 5.08304976e-04f, -1.83953851e-01f, 3.80599778e-03f, 8.27560434e-04f, -1.54873878e-01f, -7.78145716e-02f, -6.93685263e-02f, -1.25600114e-01f, -1.79057904e-02f,
  6.32310808e-02f, 7.50233606e-02f, 2.21162625e-02f, 2.57549714e-02f, 1.32844439e-02f, -1.61863998e-01f, -1.04553051e-01f, 2.54966766e-02f, 6.68760911e-02f, -7.17167649e-03f,
  2.54200220e-01f, -5.54336682e-02f, -4.02363330e-01f, -1.08428737e-02f, 1.90845802e-01f, 3.85283493e-02f, -1.98884636e-01f, 1.66022703e-01f, -9.05535668e-02f, 2.40096927e-01f,
  2.22669482e-01f, -8.73894244e-03f, -1.70128495e-01f, 3.34277272e-01f, 1.44942224e-01f, -2.05908462e-01f, 1.54893652e-01f, 4.15752381e-02f, -1.53638482e-01f, 1.86925605e-01f,
  9.57756117e-02f, 3.46730083e-01f, 2.75231842e-02f, 3.23118210e-01f, 2.22290441e-01f, 7.22201820e-03f, 2.37479940e-01f, -8.96140337e-02f, 3.01613688e-01f, 1.18954629e-01f,
  -9.07530710e-02f, -6.37186095e-02f, -8.86472985e-02f, -4.11087945e-02f, 9.76745039e-03f, -4.73295860e-02f, -8.74398947e-02f, -5.24056330e-02f, -8.29721894e-03f, -2.46761218e-02f,
  -6.75875172e-02f, -1.09140892e-02f, -2.77664922e-02f, 8.38887785e-03f, -1.50292823e-02f, 5.29200658e-02f, -1.05329655e-01f, -1.01806885e-02f, -1.47350179e-02f, 7.08417222e-02f,
  -7.14220405e-02f, -2.70859171e-02f, -3.22094257e-03f, -1.18214138e-01f, 4.56515923e-02f, 5.74852005e-02f, -3.69203128e-02f, -2.33160984e-02f, -6.85091456e-03f, 8.11672360e-02f,
  2.11822335e-02f, 5.97046539e-02f, 1.13510936e-02f, -5.16048633e-02f, -5.16262911e-02f, -5.13954163e-02f, -3.69892009e-02f, -4.97594625e-02f, -9.79139954e-02f, -1.94481984e-02f,
  2.17754096e-02f, -8.35350975e-02f, 5.74832074e-02f, -3.47626433e-02f, 1.34381661e-02f, 1.40680492e-01f, 4.33687791e-02f, 6.21063821e-02f, -8.24781731e-02f, -1.88539841e-03f,
  1.50417527e-02f, -4.51314375e-02f, -4.08734567e-02f, -1.89918466e-02f, 9.10572261e-02f, 2.50601172e-02f, 1.44130915e-01f, 2.29587499e-03f, -7.38877878e-02f, -4.02993411e-02f,
  1.23315163e-01f, 1.94152087e-01f, -2.07606284e-03f, 3.91705185e-02f, -7.55451918e-02f, 3.57406102e-02f, 4.09061275e-02f, 6.83503896e-02f, -6.09166287e-02f, -1.93987060e-02f,
  2.21023317e-02f, -9.82156545e-02f, 2.01601777e-02f, -2.03300826e-02f, 8.61575305e-02f, 8.19367096e-02f, 7.92077705e-02f, -4.49604075e-03f, -3.43636200e-02f, 2.13369168e-02f,
  1.04800992e-01f, -4.68817614e-02f, 2.55272966e-02f, -1.09778203e-01f, 5.12042418e-02f, -8.52607638e-02f, -6.12086914e-02f, 4.87767570e-02f, -6.83615636e-03f, -4.31875028e-02f,
  -1.92726757e-02f, -1.05090603e-01f, -3.03258449e-01f, -1.59935430e-01f, -4.10345078e-01f, -3.65684062e-01f, -2.80474991e-01f, -2.65402496e-01f, -2.35886201e-01f, 4.90204729e-02f,
  -8.53023678e-02f, -2.03770980e-01f, 1.54029310e-01f, -7.38147870e-02f, 1.75522551e-01f, 3.50824952e-01f, -4.41975333e-02f, -1.04049162e-03f, 1.16572499e-01f, -9.40507352e-02f,
  4.34548855e-02f, -6.37403429e-02f, 1.15279116e-01f, -6.01601079e-02f, -2.01880962e-01f, 6.81522638e-02f, 1.26760095e-01f, -2.71014541e-01f, -1.42450288e-01f, -2.40449309e-01f,
  -4.90068048e-02f, -1.31033123e-01f, -8.08233842e-02f, -2.61589158e-02f, -1.96074490e-02f, -5.15963137e-03f, 4.80959704e-03f, 2.32913606e-02f, -8.34380910e-02f, -9.59893763e-02f,
  -9.09484029e-02f, -5.15640154e-03f, -1.03915706e-01f, -5.61570711e-02f, -2.07847469e-02f, -1.74780592e-01f, 5.03303222e-02f, -2.76450459e-02f, 1.68979855e-03f, 9.34382603e-02f,
  -8.08807090e-02f, 6.83747977e-02f, 3.81667726e-02f, 1.71217173e-01f, 2.19056662e-02f, -1.06029660e-01f, 8.33433308e-03f, 3.66006792e-02f, -3.20528187e-02f, -1.44651562e-01f,
  -5.27726300e-02f, 2.15947554e-02f, 9.03751776e-02f, -7.23066181e-02f, 3.31046581e-02f, 7.20618293e-02f, -7.24699274e-02f, 1.11151107e-01f, -1.93275406e-03f, 4.53488529e-02f,
  -3.60768586e-02f, 9.37551353e-03f, -5.07802181e-02f, 8.79568011e-02f, 1.12249821e-01f, -2.76959036e-02f, 8.99648070e-02f, -2.91503444e-02f, -6.84916973e-02f, -6.92204339e-03f,
  1.34150416e-01f, -7.37014711e-02f, 3.51998061e-02f, -3.06722969e-02f, 7.84734078e-03f, 6.62920401e-02f, -3.85536440e-02f, 8.12676474e-02f, -8.16456228e-03f, -7.17432424e-02f,
  -1.46740735e-01f, -1.69991672e-01f, 1.75280329e-02f, -1.75278708e-02f, -2.57361191e-03f, -6.57747686e-02f, 3.79637070e-03f, -3.79333198e-02f, -6.45297905e-03f, -8.05960298e-02f,
  -1.25791088e-01f, 8.99466574e-02f, -1.15071177e-01f, -2.19558887e-02f, 2.20129676e-02f, -7.19059631e-02f, 7.67749548e-02f, -7.63002560e-02f, 1.88569948e-02f, -6.69434890e-02f,
  8.00514743e-02f, -2.87879519e-02f, 1.26432985e-01f, -1.38274189e-02f, 5.78710847e-02f, 9.69326720e-02f, -6.68318272e-02f, -1.20632745e-01f, -1.18075900e-01f, 1.19051319e-02f,
  1.75632372e-01f, -1.48763180e-01f, -2.28209004e-01f, -1.69188753e-01f, -2.31595606e-01f, -2.17312530e-01f, -1.55130580e-01f, -2.45848507e-01f, 1.68795995e-02f, 5.53116612e-02f,
  -1.49156094e-01f, 5.27700186e-02f, 2.91880995e-01f, -2.60383278e-01f, 1.57418460e-01f, 2.93037891e-01f, -1.46985471e-01f, 3.72732319e-02f, 1.86261926e-02f, -1.34715736e-01f,
  7.31686428e-02f, -1.66304335e-01f, -1.05717070e-01f, -2.44687542e-01f, -3.92652810e-01f, -1.00764073e-01f, 7.86371380e-02f, -1.72673360e-01f, -2.11947203e-01f, -1.86461195e-01f,
  3.80687229e-02f, -5.97887039e-02f, 7.98259396e-03f, -2.94559728e-02f, 1.30374832e-02f, 7.79624470e-03f, 6.09266907e-02f, -1.26856014e-01f, -1.31672192e-02f, 4.46680114e-02f,
  1.07578635e-01f, -8.35789964e-02f, 9.86096486e-02f, 9.49201956e-02f, -2.22773459e-02f, -3.74458134e-02f, -2.22416408e-02f, 3.96609455e-02f, -1.79162361e-02f, 9.43581946e-03f,
  3.81303066e-03f, -4.74475399e-02f, -1.69921726e-01f, 6.04417436e-02f, -4.71669994e-02f, -1.07751988e-01f, -2.01358404e-02f, 9.87682343e-02f, 7.80062303e-02f, 1.29871830e-01f,
  1.55343607e-01f, 2.65896767e-02f, 1.55722618e-03f, 2.51737982e-02f, -1.09054290e-01f, -8.04288983e-02f, -2.28646323e-02f, -6.71402663e-02f, 1.12397289e-02f, -2.40380988e-02f,
  -3.70910875e-02f, -1.34274721e-01f, 9.29789711e-03f, 4.38643582e-02f, 9.38104913e-02f, 5.98716252e-02f, -2.70827506e-02f, 1.04457131e-02f, -1.86581716e-01f, 2.96975747e-02f,
  -1.30925430e-02f, 5.27369455e-02f, -4.22687680e-02f, 9.46405381e-02f, -2.19094083e-02f, -3.73277105e-02f, -1.36742055e-01f, 3.09259212e-03f, -1.67067185e-01f, 1.03859827e-01f,
  -2.13150531e-02f, -7.11956844e-02f, 8.29355791e-03f, -1.70081109e-02f, 3.14907683e-03f, 8.67973194e-02f, 5.84378280e-02f, 5.41512184e-02f, -1.29104793e-01f, -1.36294216e-02f,
  1.09660305e-01f, 2.90414579e-02f, 5.84853962e-02f, -2.59997491e-02f, -9.37861651e-02f, -1.06514819e-01f, 2.19577737e-02f, -5.82927605e-03f, -1.04960062e-01f, 8.73452500e-02f,
  -1.22508198e-01f, 9.64139868e-03f, 2.89232209e-02f, 2.00716257e-02f, 9.23935175e-02f, 4.75659780e-02f, 6.47243485e-02f, 7.60988891e-02f, 1.63189411e-01f, -1.68375745e-02f,
  3.24806720e-01f, -2.32224226e-01f, -3.49600673e-01f, 7.96034373e-03f, 1.63851097e-01f, 1.30847633e-01f, -1.36523947e-01f, 6.87003955e-02f, -2.75505811e-01f, 2.65405513e-02f,
  8.62002298e-02f, -1.90241337e-01f, -2.76626736e-01f, 1.74957424e-01f, 3.63445841e-02f, -4.22959775e-01f, 7.65811950e-02f, 6.01256685e-03f, -1.83131784e-01f, -1.05739959e-01f,
  3.91829610e-02f, 4.93873924e-01f, -1.41459197e-01f, 3.93566281e-01f, 1.79246649e-01f, 1.07433639e-01f, 2.40175307e-01f, -1.80307955e-01f, 3.35507542e-01f, 1.70479253e-01f,
  8.99559408e-02f, -9.04298797e-02f, -5.81446923e-02f, 8.17546062e-03f, 7.60219023e-02f, 6.34454563e-03f, -2.56574713e-03f, 1.40282465e-02f, -1.01722311e-02f, -3.97824682e-02f,
  3.45806368e-02f, 1.99448299e-02f, 1.34330913e-01f, 5.12869619e-02f, 8.57497156e-02f, 2.32276809e-03f, -1.47325359e-02f, -1.21475562e-01f, -7.40180090e-02f, -1.72740836e-02f,
  -1.53315246e-01f, 7.58648813e-02f, -4.74646389e-02f, 6.87305331e-02f, -1.08813070e-01f, 1.02654502e-01f, -2.07624957e-02f, -4.69031520e-02f, 1.42624853e-02f, 3.96399945e-02f,
  1.34986237e-01f, 4.34196880e-03f, 8.97399113e-02f, 2.11191811e-02f, 8.43979716e-02f, 9.89767909e-02f, 9.60681885e-02f, 4.58807163e-02f, 1.40455002e-02f, -4.57997173e-02f,
  -2.90408880e-02f, 7.20691606e-02f, -4.87159938e-03f, 2.03867350e-02f, 3.88779342e-02f, -7.12573379e-02f, -2.19236389e-02f, -4.66279201e-02f, -1.20225810e-01f, 3.76213193e-02f,
  -8.73447508e-02f, 4.36263019e-03f, -3.56488824e-02f, 5.24626523e-02f, -2.69381385e-02f, -6.04192447e-03f, 6.04440197e-02f, -4.76629920e-02f, -4.15871963e-02f, 1.69586074e-02f,
  5.86846583e-02f, 1.53059708e-02f, -1.08565167e-01f, 2.92242039e-02f, -2.36382969e-02f, 2.87456773e-02f, -3.01912669e-02f, 6.06138483e-02f, -4.67008067e-06f, 2.26770882e-02f,
  1.07095599e-01f, 2.18751375e-03f, 1.38529181e-01f, -3.52409901e-03f, 6.82174116e-02f, -8.28159135e-03f, -2.79540080e-03f, 4.42984141e-02f, -2.80061271e-03f, 1.26311019e-01f,
  9.13500227e-03f, 8.16986486e-02f, 3.11815981e-02f, 1.08568743e-01f, 8.03898722e-02f, -3.51694152e-02f, 1.46620348e-01f, 8.89903866e-03f, 2.93531846e-02f, -4.58156504e-02f,
  -5.20098209e-01f, 2.21302852e-01f, -1.39692307e-01f, 2.84852535e-01f, -3.06569368e-01f, 1.36653632e-01f, 3.60400438e-01f, -5.66742308e-02f, 1.95746332e-01f, 4.53004956e-01f,
  2.78110921e-01f, -6.88172579e-02f, 1.93804339e-01f, 4.23404843e-01f, -1.25978142e-01f, 2.55967349e-01f, 2.06341639e-01f, 1.33227974e-01f, -3.76671180e-02f, -2.35712957e-02f,
  -1.02214880e-01f, 1.62549794e-01f, 3.82481143e-02f, -3.60308662e-02f, -4.51082736e-02f, -7.25525245e-02f, 2.43939776e-02f, -1.05815060e-01f, 2.09108457e-01f, -1.10415146e-01f,
  -1.20304614e-01f, -1.52040392e-01f, -1.01113297e-01f, 6.35980070e-02f, -1.22054733e-01f, -2.65130308e-02f, -9.96019319e-03f, -6.98747635e-02f, 2.83595715e-02f, 5.98132471e-03f,
  -6.25589415e-02f, -1.58852860e-01f, 5.79692684e-02f, -8.56403820e-03f, 5.27134389e-02f, 8.38792790e-03f, -6.83367029e-02f, -1.42373042e-02f, -2.16143988e-02f, -1.36039302e-01f,
  5.79285286e-02f, 6.25377372e-02f, 7.00123459e-02f, 3.17131467e-02f, -1.15014136e-01f, 9.85566303e-02f, 3.15258540e-02f, 3.72939706e-02f, -4.16916609e-02f, -3.27055976e-02f,
  -1.37398606e-02f, -1.22224376e-01f, -3.79097946e-02f, 1.83632579e-02f, -2.72552092e-02f, -8.55607465e-02f, 1.24824345e-01f, -3.65839037e-03f, -3.45820971e-02f, 4.22705524e-02f,
  5.25237471e-02f, 1.46119697e-02f, -3.45767364e-02f, 8.26296061e-02f, 5.90099348e-03f, 9.83028635e-02f, 6.30536675e-02f, -1.17894225e-01f, 6.10086769e-02f, 3.48895155e-02f,
  -2.00381316e-03f, -2.38551572e-02f, 2.83857118e-02f, 8.73956159e-02f, 2.45356467e-03f, -2.60009919e-03f, 9.80912074e-02f, -5.04262261e-02f, 8.23025629e-02f, -7.20483139e-02f,
  5.59108742e-02f, 1.26499653e-01f, -3.14980224e-02f, -4.54376787e-02f, 5.38210571e-02f, -1.35148019e-01f, 7.78023377e-02f, -9.78635997e-02f, 9.53688622e-02f, -7.85217527e-03f,
  -1.14652505e-02f, 4.95940410e-02f, -6.55474961e-02f, 2.53560469e-02f, 3.99215929e-02f, 6.16315007e-02f, 2.52353936e-03f, 2.60474775e-02f, 1.86800417e-02f, -1.07467376e-01f,
  -1.58806089e-02f, -1.00163080e-01f, -1.40678242e-01f, -3.83139625e-02f, 2.95987669e-02f, -1.55039048e-02f, -1.49342082e-02f, -2.67996686e-04f, -3.34493071e-02f, 1.91745011e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.89204380e-01f, 1.19372435e-01f, -1.81964889e-01f, 5.01989909e-02f, 3.05814713e-01f, 1.26185445e-02f, 1.78162068e-01f, 1.46896169e-01f, 3.32164437e-01f, 1.23030052e-01f,
  2.67899353e-02f, 1.13751695e-01f, -1.97902024e-02f, 7.08868206e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.06306079e-02f, -7.21999779e-02f, -1.41000882e-01f, -6.79501370e-02f, -9.06632096e-02f, -1.74594950e-02f, 9.48581472e-02f, 9.95300859e-02f, -3.90485913e-01f, 5.04923224e-01f,
  2.70562410e-01f, -2.19644085e-01f, -1.06563710e-01f, -8.63605365e-02f, -1.82488352e-01f, -3.47999245e-01f, -1.08856060e-01f, 1.05385788e-01f, 2.22160473e-01f, -1.44511268e-01f,
  -3.46026644e-02f, -2.95322258e-02f, 1.38266698e-01f, 1.28321558e-01f, -1.60790280e-01f, 1.24269776e-01f, 5.66009022e-02f, -1.04883432e-01f, 2.68661201e-01f, -2.08232496e-02f,
  -2.37819701e-01f, 3.15954447e-01f, -6.15024157e-02f, 1.67612776e-01f, 3.59653622e-01f, 2.38260746e-01f, 2.44567856e-01f, 1.34806648e-01f, 1.15501314e-01f, 3.58834714e-01f,
  -2.43228137e-01f, 3.53847779e-02f, -1.93322688e-01f, -3.36284526e-02f, 2.99049348e-01f, -2.76782393e-01f, -3.53156567e-01f, 3.09296697e-01f, 3.64995092e-01f, 4.95789200e-02f,
  2.20031396e-01f, -1.58386305e-01f, -1.85854301e-01f, 4.38316278e-02f, 6.23250902e-02f, 9.85430628e-02f, -7.00187683e-02f, 2.82768160e-02f, -1.79622695e-02f, -2.08311945e-01f,
  1.33171588e-01f, 1.23058632e-01f, -1.56671807e-01f, 1.75816044e-01f, 1.07531630e-01f, -4.63722125e-02f, -3.53863209e-01f, 6.45445436e-02f, -5.65939844e-02f, 1.53165068e-02f,
  7.94416517e-02f, -2.16108039e-01f, 8.39879289e-02f, 2.70800024e-01f, 2.74775084e-02f, -2.73171544e-01f, 1.55018196e-02f, -1.20895371e-01f, 4.69453752e-01f, -1.82589456e-01f,
  -7.08615780e-02f, -2.75678128e-01f, 1.06063843e-01f, 1.62467301e-01f, 2.05688581e-01f, -2.76988149e-01f, -1.26856968e-01f, -4.11357820e-01f, 7.46474713e-02f, -2.19538212e-01f,
  -4.87753190e-02f, 2.21961603e-01f, 5.87966926e-02f, 2.11687870e-02f, 1.86810151e-01f, 3.87020350e-01f, -7.43339136e-02f, 1.41779795e-01f, 1.21941730e-01f, -2.22898751e-01f,
  -3.17596621e-03f, -4.09728661e-02f, -3.87401246e-02f, 3.36745791e-02f, -7.00415820e-02f, -9.25525352e-02f, -4.54512715e-01f, 1.26444118e-03f, 1.90426186e-01f, -7.69905373e-02f,
  -2.84089297e-01f, 1.57822564e-01f, -3.73336852e-01f, 4.74141955e-01f, -2.21124649e-01f, -3.30815732e-01f, 1.81611866e-01f, 1.15539804e-02f, -2.90837586e-01f, 2.36251101e-01f,
  2.77329355e-01f, -1.38794214e-01f, -2.72190958e-01f, 1.77325320e-03f, 1.43297553e-01f, 2.03205153e-01f, 2.05335796e-01f, 9.10540894e-02f, -1.83655307e-01f, 1.52542159e-01f,
  1.73469678e-01f, 1.44319266e-01f, -1.59973219e-01f, -1.30599469e-01f, 1.77528001e-02f, 8.79781917e-02f, 3.99838120e-01f, -2.31407329e-01f, -9.91813019e-02f, 2.71816343e-01f,
  -7.77447149e-02f, 9.13793296e-02f, -7.35048354e-02f, 1.05095066e-01f, -2.07216948e-01f, -1.82156339e-02f, 2.20468462e-01f, 7.11421818e-02f, 4.21487451e-01f, -2.73046255e-01f,
  -1.00621819e-01f, -4.51792590e-02f, -1.45604521e-01f, 3.21934462e-01f, -2.47418359e-01f, -2.03117162e-01f, 2.26406623e-02f, -2.61839628e-01f, -3.70074920e-02f, 4.13866341e-02f,
  -7.43391588e-02f, -2.46379152e-01f, 1.21867068e-01f, -2.61201233e-01f, -1.52007699e-01f, -7.65425265e-02f, 4.09620516e-02f, 2.11250961e-01f, 4.17248100e-01f, -4.37722951e-01f,
  -2.88653523e-01f, 1.81561172e-01f, 1.60516486e-01f, 1.98098078e-01f, -4.00757164e-01f, 3.27773064e-01f, 6.54629990e-02f, 1.72577590e-01f, -1.72839165e-01f, -2.15212509e-01f,
  -3.26736309e-02f, -1.43797293e-01f, 8.45332667e-02f, -2.25850329e-01f, -2.79509090e-02f, 2.99089968e-01f, 2.28785165e-02f, -4.71650273e-01f, -4.86946590e-02f, -6.83149472e-02f,
  -3.07641566e-01f, -7.51666501e-02f, 1.75428569e-01f, 9.91071463e-02f, 2.10619178e-02f, -2.04849541e-01f, -3.93274948e-02f, -2.16303468e-02f, -2.65424937e-01f, 2.98713148e-01f,
  1.79234847e-01f, 1.26262799e-01f, -2.99056143e-01f, 2.60986555e-02f, 6.03104942e-02f, 1.70524538e-01f, -1.44352689e-01f, 5.38810119e-02f, -3.28599811e-01f, -5.58894314e-03f,
  1.80639014e-01f, 1.42113522e-01f, 2.68535018e-01f, -2.09561229e-01f, 2.78980341e-02f, -2.79542327e-01f, 2.42738292e-01f, -5.13233170e-02f, -1.86909556e-01f, 1.79957718e-01f,
  -2.54447699e-01f, -8.68108645e-02f, 9.42291766e-02f, -2.19500870e-01f, 2.28807449e-01f, -1.66976810e-01f, 2.22512603e-01f, 6.89739222e-03f, 1.95460871e-01f, 3.06523025e-01f,
  -2.18383566e-01f, 1.77740321e-01f, -1.27903372e-01f, 2.10768189e-02f, -1.59315422e-01f, -1.14572398e-01f, 3.30852032e-01f, -9.87366661e-02f, 3.70027125e-01f, 2.35476270e-01f,
  3.73537749e-01f, -2.48502959e-02f, -1.38099059e-01f, -6.46902323e-02f, -2.91094184e-01f, -4.03116411e-03f, -7.73426495e-04f, 1.63549021e-01f, 2.09539384e-01f, -3.55511397e-01f,
  3.74918252e-01f, -3.59925888e-02f, 3.71497124e-01f, 6.69331625e-02f, 5.32524437e-02f, -3.70662846e-02f, -1.10015366e-02f, -1.11244217e-01f, -2.96814203e-01f, -6.67013526e-02f,
  -1.16252400e-01f, 9.53995213e-02f, -2.16264933e-01f, 1.20621182e-01f, -3.32098573e-01f, -2.26368219e-01f, -3.12644601e-01f, 2.62321383e-01f, 3.62306058e-01f, 3.65273446e-01f,
  4.36526000e-01f, -1.62715271e-01f, -2.48268191e-02f, -3.61699834e-02f, 2.53573477e-01f, -6.49762303e-02f, 2.68547505e-01f, -1.99133053e-01f, -4.00519997e-01f, -1.80814385e-01f,
  3.46941978e-01f, 2.81691570e-02f, -2.40976393e-01f, 2.84664065e-01f, 1.52400464e-01f, 1.05217740e-01f, 1.86756924e-01f, 1.56654045e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -7.14893267e-02f, 4.59059954e-01f, 3.38771462e-01f, 1.44446015e-01f, 4.22609180e-01f, 1.18782371e-01f, -1.03596725e-01f, 2.98024356e-01f, -4.96072233e-01f, 5.17807066e-01f,
  -1.09403543e-01f, -1.67911127e-01f, -8.54179934e-02f, -2.85203934e-01f, 4.92219068e-03f, -1.51111737e-01f, -5.47262020e-02f, 3.33885729e-01f, 8.59800801e-02f, -1.98924020e-01f,
  -2.79084831e-01f, 1.37297153e-01f, -1.35157004e-01f, 2.45537505e-01f, 3.06614786e-01f, -4.09708649e-01f, -2.66217232e-01f, -6.43228740e-02f, 5.30956149e-01f, 3.52463245e-01f,
  4.76544909e-02f, 6.42266750e-01f, 4.03832465e-01f, 2.73065716e-01f, 2.65703231e-01f, 1.45262033e-01f, 4.80979741e-01f, 2.88384110e-01f, 7.32424632e-02f, 1.19440258e-01f,
  -9.29432642e-03f, 6.81520700e-01f, 3.25458258e-01f, -5.34287274e-01f, -4.11659062e-01f, -3.66969615e-01f, 5.07916749e-01f, -6.32452786e-01f, 6.75712759e-03f, 1.42038926e-01f,
  2.58083820e-01f, 1.10403791e-01f, -4.17704493e-01f, -1.05665639e-01f, 2.51853913e-01f, -6.55982420e-02f, 3.74494523e-01f, -5.21165133e-01f, 1.50550781e-02f, 1.73987210e-01f,
  2.02972963e-01f, 2.56153643e-01f, 1.61952451e-01f, 5.90301752e-01f, 3.09735090e-01f, 4.42481220e-01f, 4.42602366e-01f, 2.40148112e-01f, 5.87503850e-01f, 1.10670365e-01f,
  4.10094529e-01f, 1.63045198e-01f, 3.26034069e-01f, -1.30885169e-01f, 4.15934384e-01f, -2.83124834e-01f, -3.98918182e-01f, -1.56992018e-01f, -1.71226233e-01f, 8.13290998e-02f,
  4.99453396e-02f, -1.04266539e-01f, 8.12480524e-02f, 2.90865839e-01f, -2.92723566e-01f, 3.28777522e-01f, 5.47425330e-01f, 2.79129863e-01f, -4.09636199e-01f, 3.40294421e-01f,
  3.89746368e-01f, -2.93460488e-01f, 1.04952335e-01f, 1.60854846e-01f, -3.20857227e-01f, -2.22623870e-01f, 5.17020762e-01f, 6.89566061e-02f, 5.25303721e-01f, 4.48414356e-01f,
  4.65655744e-01f, 2.77982056e-01f, 3.62334698e-01f, 3.44833612e-01f, 2.10165754e-01f, 1.29149854e-01f, 1.49028450e-01f, -3.06537420e-01f, 1.24181673e-01f, -7.86221266e-01f,
  -2.08045393e-01f, 6.59333169e-02f, 7.45423555e-01f, -1.53682351e-01f, 3.55058201e-02f, 5.99825799e-01f, -6.04256876e-02f, 3.89758557e-01f, 5.26922882e-01f, 3.48559588e-01f,
  9.07789022e-02f, -1.01814885e-02f, 8.53636146e-01f, 2.61514723e-01f, 2.84626812e-01f, -2.93785855e-02f, 1.10047627e-02f, 1.62652299e-01f, 1.01147510e-01f, -1.39990091e-01f,
  4.36325938e-01f, -9.34443772e-02f, 3.45060885e-01f, 2.93004662e-01f, 3.94369885e-02f, 1.17979303e-01f, 3.67765903e-01f, 5.42384565e-01f, 1.93442121e-01f, -2.97569841e-01f,
  -1.03601635e-01f, -4.42145556e-01f, -5.92710555e-01f, 3.81368876e-01f, -5.07301539e-02f, 1.42069429e-01f, 5.23844846e-02f, -5.67247093e-01f, -1.85160972e-02f, 3.15956414e-01f,
  1.77144244e-01f, 2.90613562e-01f, 2.54043974e-02f, -8.25077742e-02f, 4.57969815e-01f, -4.11341667e-01f, -2.92894214e-01f, -4.98008370e-01f, -3.69652897e-01f, -1.18390936e-02f,
  8.09348896e-02f, -4.37886687e-03f, 3.64284396e-01f, 2.34017119e-01f, 1.65702805e-01f, 2.97256827e-01f, 1.21848114e-01f, 1.84397176e-01f, -3.42682779e-01f, 4.94766027e-01f,
  1.49084032e-01f, -2.39618689e-01f, 2.73285389e-01f, -1.29534334e-01f, -1.89001083e-01f, -6.99217245e-02f, 3.52221370e-01f, 2.08788868e-02f, -1.58250049e-01f, -3.74515235e-01f,
  -5.60810342e-02f, 1.45328820e-01f, 2.41615534e-01f, 3.92215967e-01f, -2.50869058e-02f, -2.35334679e-01f, 3.21825415e-01f, 1.22891866e-01f, 4.57978457e-01f, 2.00512946e-01f,
  -7.05145076e-02f, 4.08690393e-01f, 2.58231491e-01f, -2.11372316e-01f, 2.42571801e-01f, 4.22861688e-02f, 1.47170380e-01f, 2.62830228e-01f, 2.39158675e-01f, 2.71124721e-01f,
  -1.85400769e-01f, 1.75579354e-01f, -1.23558909e-01f, 2.13215381e-01f, 4.31273282e-01f, -2.89140314e-01f, -6.21884763e-01f, 1.98648319e-01f, 3.09622139e-01f, 9.56306532e-02f,
  -5.63669726e-02f, 2.23393962e-02f, -1.27547503e-01f, 3.37560385e-01f, 5.00384927e-01f, 6.48453116e-01f, -6.47296831e-02f, 4.36043203e-01f, 4.97417241e-01f, -4.26830389e-02f,
  1.29267678e-01f, 1.72845274e-03f, -3.33994418e-01f, -1.26626277e-02f, 4.82595235e-01f, 4.36483085e-01f, 2.93805778e-01f, 2.25767389e-01f, 3.19416523e-01f, 4.31834787e-01f,
  1.35215893e-01f, 3.06104869e-01f, 5.56807399e-01f, -4.38696086e-01f, -3.04307610e-01f, 2.16792881e-01f, -4.69066314e-02f, 5.50848484e-01f, 1.70317665e-01f, 2.01417878e-01f,
  -7.53227949e-01f, 3.23584348e-01f, -1.35153085e-01f, 9.35622752e-02f, 5.88799417e-01f, -2.26522714e-01f, -1.22640781e-01f, -3.46155733e-01f, 3.75947654e-01f, 1.93852484e-01f,
  -8.37059841e-02f, 3.63293946e-01f, -1.54811740e-01f, -5.51388897e-02f, 4.84117001e-01f, -2.40465119e-01f, 3.39472324e-01f, 2.78927118e-01f, 4.66823131e-01f, -9.28800479e-02f,
  3.74311060e-01f, 5.22900403e-01f, -2.34340951e-01f, 4.90153313e-01f, -1.99191213e-01f, 3.80646288e-01f, -5.66877246e-01f, 6.28126636e-02f, 4.12689805e-01f, 3.06079686e-01f,
  -8.17188341e-03f, -2.20796376e-01f, -1.45803779e-01f, 2.06148788e-01f, 1.54625252e-01f, -2.71190196e-01f, 2.78193474e-01f, 5.60469739e-02f, 3.25139686e-02f, 3.76949683e-02f,
  3.11091870e-01f, -2.48851225e-01f, -2.37867385e-01f, 3.06203753e-01f, 4.56925243e-01f, 5.82245946e-01f, 3.27243239e-01f, 4.42376137e-01f, 3.09997380e-01f, 3.09894770e-01f,
  4.50500771e-02f, 2.64154583e-01f, 4.38368499e-01f, 1.72832534e-02f, 2.71406502e-01f, 2.45633066e-01f, -3.64162214e-02f, 3.59086633e-01f, 5.60139231e-02f, 3.66513640e-01f,
  -5.56758225e-01f, 8.11949596e-02f, -6.28461599e-01f, -2.48619467e-01f, -2.93321103e-01f, -1.99969783e-01f, 6.93719566e-01f, 1.00296058e-01f, 4.36154664e-01f, 3.15099418e-01f,
  3.34642202e-01f, 2.01164022e-01f, -2.74734527e-01f, 3.89427781e-01f, -2.47543797e-01f, -1.15929075e-01f, 2.60925412e-01f, 6.01003528e-01f, -4.27948594e-01f, -4.01866473e-02f,
  1.36651297e-03f, 3.78743559e-02f, 5.04518092e-01f, 2.11039558e-01f, 3.67136329e-01f, 2.56050020e-01f, -9.95996818e-02f, 4.07666117e-01f, 2.73464750e-02f, 2.47062549e-01f,
  -4.57919538e-01f, -2.75761615e-02f, 4.61619467e-01f, -2.18923330e-01f, -1.11499138e-01f, 3.51023704e-01f, 3.38604271e-01f, 3.02296877e-01f, 1.62943080e-01f, -4.61832762e-01f,
  -2.79541999e-01f, 5.42955026e-02f, -2.06431255e-01f, 1.34009957e-01f, 1.92731127e-01f, -4.34973747e-01f, 2.45199233e-01f, -1.43971160e-01f, 3.25066805e-01f, -9.72785950e-02f,
  -1.66847095e-01f, 1.20638974e-01f, 3.10212344e-01f, 1.76938236e-01f, 4.12349701e-01f, 4.42125499e-01f, 2.95460284e-01f, 4.46231067e-02f, 5.10731161e-01f, 1.69121265e-01f,
  5.72971642e-01f, -1.63331583e-01f, 1.11867441e-02f, 1.30507603e-01f, -3.09698075e-01f, 2.82320589e-01f, -2.91895241e-01f, -1.99703127e-01f, -5.08790672e-01f, 1.87257186e-01f,
  1.11090690e-01f, 3.02523494e-01f, 9.91774425e-02f, 1.37043044e-01f, 2.30150357e-01f, -2.51114309e-01f, -7.90668949e-02f, 5.46141803e-01f, 1.97007015e-01f, 4.16893475e-02f,
  -3.37376118e-01f, -2.85972357e-02f, 5.80151938e-02f, -7.84331411e-02f, 1.10344872e-01f, 1.44370764e-01f, 5.61257601e-01f, 3.21326070e-02f, 3.70794594e-01f, 4.86923695e-01f,
  2.04404622e-01f, 4.21889782e-01f, 5.42119205e-01f, 5.88204376e-02f, -4.09031659e-01f, 1.35264486e-01f, 2.19281942e-01f, -1.37759656e-01f, -4.80803192e-01f, 4.62844253e-01f,
  -2.23815843e-01f, 2.82727242e-01f, -1.99966595e-01f, -7.76126504e-01f, -2.36526042e-01f, -1.15522426e-02f, -3.60050261e-01f, -7.34960735e-02f, 4.83609103e-02f, 1.16239518e-01f,
  1.28886685e-01f, -3.52634072e-01f, 7.29392422e-03f, -1.63253888e-01f, -3.82679522e-01f, 1.24070011e-01f, 3.82710069e-01f, 3.27290744e-01f, -1.01987973e-01f, 8.15865099e-02f,
  3.07252765e-01f, -3.11294422e-02f, 1.63061544e-01f, 2.95753419e-01f, -2.42442936e-01f, 5.46386659e-01f, 2.81328321e-01f, -1.63647652e-01f, -4.02724028e-01f, -1.39570743e-01f,
  2.89376557e-01f, -3.65240782e-01f, 9.20129642e-02f, -3.89784783e-01f, 6.26770198e-01f, 3.03685784e-01f, 2.17593625e-01f, -1.15918279e-01f, 1.40544832e-01f, 1.07976615e-01f,
  1.63797051e-01f, 2.71867126e-01f, 5.49427420e-02f, 3.31770778e-01f, 3.68376881e-01f, 2.82868356e-01f, -6.80655465e-02f, 1.72130018e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.48284584e-01f, 1.87893689e-01f, 4.48492587e-01f, 4.42507058e-01f, 1.59778252e-01f, -3.49569321e-02f, 5.96203431e-02f, 5.80895782e-01f, 3.83490145e-01f, 1.13658145e-01f,
  1.71382561e-01f, 3.32919091e-01f, 2.31437951e-01f, 2.43360430e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.47241536e-02f, -2.79136360e-01f, 1.94635205e-02f, 2.41629168e-01f, -3.02795470e-02f, -1.78537577e-01f, 1.60602838e-01f, 1.96036976e-02f, 8.67038220e-02f, 1.17793001e-01f,
  -5.64156659e-02f, -2.14228779e-01f, 3.04848738e-02f, 7.83673152e-02f, 8.99046659e-02f, -1.93344638e-01f, 2.56289631e-01f, -2.10166678e-01f, 1.28552064e-01f, -1.35809733e-02f,
  1.15452245e-01f, -5.95321842e-02f, 3.66336197e-01f, 1.94185168e-01f, -2.77523920e-02f, -1.43960178e-01f, 6.34183660e-02f, -5.67599535e-02f, 2.81507224e-01f, -2.74866939e-01f,
  2.44330347e-01f, 2.11013263e-04f, -3.58168408e-02f, 1.27686352e-01f, -9.93303582e-03f, -1.11027341e-03f, 2.47963563e-01f, -1.97891891e-01f, -2.29438260e-01f, 9.71653685e-02f,
  -2.28499204e-01f, 1.79110110e-01f, 1.83344111e-01f, 3.25738005e-02f, -1.05583705e-01f, -9.58519056e-02f, -2.04124209e-02f, 4.14300561e-01f, -2.28207320e-01f, 4.44414578e-02f,
  3.44029628e-02f, 6.21825457e-02f, -1.27422065e-01f, -9.63379666e-02f, -2.12459907e-01f, -3.17547023e-01f, 2.25517116e-02f, 7.82167017e-02f, 1.81164160e-01f, 3.64323258e-01f,
  -1.26183733e-01f, -1.00107238e-01f, -1.11001335e-01f, 3.33783664e-02f, 5.03467284e-02f, 2.69229144e-01f, -5.27179465e-02f, -1.26386449e-01f, 9.56488699e-02f, -1.50604453e-02f,
  1.49488926e-01f, 5.32152541e-02f, -8.37013200e-02f, -4.21644598e-02f, 5.14400750e-02f, 1.80640355e-01f, -3.03697400e-02f, -1.56208590e-01f, -2.65358537e-01f, 2.61148393e-01f,
  -3.01114112e-01f, 1.09083049e-01f, -9.77651253e-02f, 1.31925121e-01f, -2.79619724e-01f, -1.29007071e-01f, -9.56571922e-02f, -1.52265429e-01f, -7.11674541e-02f, 1.83766395e-01f,
  2.47735810e-02f, 1.02610648e-01f, -2.51142889e-01f, 2.76959628e-01f, -1.35510653e-01f, 1.96840823e-01f, -2.54982561e-01f, 2.34131932e-01f, -3.48148271e-02f, -2.13323712e-01f,
  7.68966693e-03f, 1.40070785e-02f, 2.37926841e-02f, -2.42781676e-02f, -1.13268420e-01f, -3.98718178e-01f, -2.38949396e-02f, 3.18280220e-01f, 1.26629919e-01f, 1.02153674e-01f,
  1.62099540e-01f, 2.67047822e-01f, 1.32717192e-01f, 4.20794874e-01f, 4.36340980e-02f, -1.47434711e-01f, -1.14469685e-01f, 9.66865644e-02f, -2.07958713e-01f, -1.69785842e-01f,
  -9.01033357e-02f, 2.29967594e-01f, -5.55760264e-02f, -3.22991423e-02f, -5.33761643e-02f, 1.09624334e-01f, -1.09409839e-01f, -8.66003633e-02f, -6.58501089e-02f, 2.95576513e-01f,
  1.61492288e-01f, -3.30652416e-01f, 4.93554398e-02f, 1.26707837e-01f, -2.74113612e-03f, 4.92496677e-02f, 6.16159886e-02f, -1.35834247e-01f, 8.22139233e-02f, 4.39231306e-01f,
  7.89258350e-03f, 1.84584744e-02f, -1.34250045e-01f, -6.71481788e-02f, -1.93519518e-01f, -3.07972208e-02f, -2.24124879e-01f, 1.00274421e-01f, -4.02533673e-02f, 1.06746204e-01f,
  -4.53923762e-01f, -1.10918187e-01f, -2.74779081e-01f, 2.75121927e-01f, -1.91078618e-01f, 8.50607827e-02f, -2.03247070e-01f, 6.71739802e-02f, -3.25443923e-01f, -5.36797568e-02f,
  -1.29464716e-01f, -2.72187889e-01f, -7.32594579e-02f, 8.60575065e-02f, -1.19812809e-01f, -7.86940232e-02f, -2.83948153e-01f, -1.47062659e-01f, -1.53007314e-01f, -3.15030031e-02f,
  -1.56338498e-01f, -1.74780432e-02f, 1.48148000e-01f, 3.05121448e-02f, 6.63107485e-02f, 2.60930091e-01f, 1.54747948e-01f, 4.06516522e-01f, 1.72132134e-01f, 5.48524670e-02f,
  -2.07602993e-01f, -1.17362529e-01f, 1.87590066e-02f, -1.59756467e-01f, -5.29371127e-02f, -2.21181419e-02f, 3.14682484e-01f, 2.34553386e-02f, 2.82053441e-01f, -2.61971116e-01f,
  3.92724341e-03f, -1.47316987e-02f, -1.64317206e-01f, -4.24011827e-01f, -1.66627929e-01f, -1.11871175e-01f, -2.04941794e-01f, -1.47554174e-01f, 3.12245023e-02f, -2.48454899e-01f,
  -1.75803632e-01f, -8.45904723e-02f, 5.75113855e-02f, -4.22298580e-01f, 8.25228542e-02f, -1.33278206e-01f, 4.09727395e-01f, -4.86484505e-02f, 1.64697737e-01f, -6.42207563e-02f,
  1.79747656e-01f, 4.22949195e-02f, 3.89465131e-02f, 1.97919887e-02f, 1.05867535e-01f, 1.06518321e-01f, 2.65339077e-01f, -3.13231677e-01f, 2.23172624e-02f, -3.29443030e-02f,
  5.83946742e-02f, -2.44100362e-01f, -2.65780278e-02f, -5.59757128e-02f, 1.11159012e-02f, -1.46887541e-01f, -4.75694165e-02f, 2.34926771e-02f, 1.54077128e-01f, 1.62474856e-01f,
  -1.04416631e-01f, -1.63017455e-02f, -2.49994293e-01f, 2.57463362e-02f, -1.19879477e-01f, -8.75272006e-02f, 2.41210356e-01f, 2.75326163e-01f, 8.31383541e-02f, 2.81857729e-01f,
  -1.95231482e-01f, 1.52123719e-01f, -1.88814048e-02f, -2.35944897e-01f, -9.04888436e-02f, -7.10333735e-02f, -4.28417265e-01f, -2.06477374e-01f, 1.33596152e-01f, 1.02234259e-01f,
  2.02699512e-01f, -6.52808324e-02f, -4.05556038e-02f, 1.90360546e-01f, -9.92964134e-02f, 1.13299519e-01f, -1.99037537e-01f, -1.66237041e-01f, -1.14691801e-01f, -2.47058243e-01f,
  -7.00368509e-02f, -2.72067219e-01f, -2.38596559e-01f, 1.22686096e-01f, -2.11769789e-01f, -3.02280039e-01f, -1.91066489e-01f, 8.69119987e-02f, 2.63881236e-01f, -2.85901815e-01f,
  -1.37620464e-01f, 8.52378309e-02f, 4.37349230e-01f, 4.26312417e-01f, 5.54394498e-02f, -2.02546827e-02f, 1.37236506e-01f, 3.91581915e-02f, -3.28890055e-01f, -4.07044180e-02f,
  -1.99311841e-02f, 1.36365183e-02f, 1.86544359e-01f, -3.16997200e-01f, 3.01808149e-01f, -1.52985871e-01f, -1.91248804e-01f, -1.39643043e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.01207539e-01f, 1.93508014e-01f, 2.84078628e-01f, 1.05001785e-01f, 3.04779738e-01f, 1.32522697e-03f, 1.04397558e-01f, 9.33607221e-02f, 1.40908688e-01f, 6.22975588e-01f,
  2.73823351e-01f, 3.64376605e-01f, -5.18550456e-01f, -5.47837794e-01f, -3.80634934e-01f, -5.49521029e-01f, 4.85525802e-02f, -5.81612766e-01f, 5.75386226e-01f, 6.42222583e-01f,
  3.98496836e-01f, 6.09397769e-01f, 4.70138550e-01f, 5.15020013e-01f, 2.84373879e-01f, -2.20610633e-01f, 9.16051045e-02f, 2.63533015e-02f, 2.91363031e-01f, 5.59958108e-02f,
  -2.20443290e-02f, 3.70699197e-01f, -1.35394424e-01f, -9.29654390e-02f, 1.95133924e-01f, 1.20637566e-01f, 9.13159326e-02f, -1.41901538e-01f, -3.47554624e-01f, 9.77994725e-02f,
  -3.13376456e-01f, -1.83222175e-01f, -7.98009261e-02f, -3.90972011e-02f, 4.45878118e-01f, -7.05072880e-02f, -4.62719090e-02f, 4.43163067e-01f, 5.21990180e-01f, 5.85381925e-01f,
  1.28840089e-01f, 2.51897454e-01f, -3.27956319e-01f, 2.60457397e-01f, 6.26893461e-01f, 1.92550018e-01f, 3.55736524e-01f, 4.76240039e-01f, 5.77188015e-01f, -4.47457343e-01f,
  6.64638937e-01f, 4.76179682e-02f, 2.17535138e-01f, -2.06975624e-01f, 1.60904735e-01f, 2.09876940e-01f, -3.38144377e-02f, -1.71449453e-01f, 3.32833737e-01f, -4.63065386e-01f,
  2.78880537e-01f, 2.01987639e-01f, 2.73841530e-01f, -1.10178828e-01f, 3.86594236e-02f, 8.22454929e-01f, -2.33859509e-01f, -2.79317558e-01f, -2.82821506e-01f, 2.67774761e-01f,
  -1.04394607e-01f, -3.48837763e-01f, 4.24873084e-01f, 6.29128098e-01f, 4.32994246e-01f, 2.96040833e-01f, -6.75331473e-01f, -8.08653235e-02f, -3.54510427e-01f, -5.01933843e-02f,
  4.44123745e-01f, 3.78609508e-01f, -1.41793802e-01f, 8.62123445e-02f, -5.57054937e-01f, 6.65847063e-01f, 5.33533134e-02f, -3.63034129e-01f, 5.74578121e-02f, 5.55661559e-01f,
  3.96618426e-01f, -4.07523103e-02f, 2.53642976e-01f, 2.91911244e-01f, 3.12930375e-01f, 3.77251565e-01f, 6.34648800e-02f, -9.56201255e-02f, 5.94895661e-01f, -2.96665311e-01f,
  -2.00673893e-01f, 3.04801196e-01f, 3.04936618e-01f, -1.06198199e-01f, 7.05915272e-01f, 5.28134525e-01f, -1.55537814e-01f, -1.55447841e-01f, 1.40515445e-02f, 3.17617655e-01f,
  -1.33960739e-01f, 3.33840437e-02f, 7.16379881e-01f, 3.28265548e-01f, 3.47822338e-01f, -2.62654245e-01f, 4.84411448e-01f, 5.76792210e-02f, 2.46913046e-01f, -2.31159106e-01f,
  -1.73797488e-01f, 3.94276828e-02f, 1.08390860e-02f, 2.14613870e-01f, 1.11383758e-01f, 1.23625528e-03f, 4.04947624e-02f, -7.33708501e-01f, -7.34928949e-03f, -1.04998720e+00f,
  1.68530405e-01f, 1.22836962e-01f, 8.82718384e-01f, -1.17459722e-01f, 2.50111938e-01f, 5.09435311e-02f, -1.75972655e-01f, -4.72712129e-01f, 3.87545288e-01f, 3.99294674e-01f,
  2.18007177e-01f, 2.65546143e-01f, 7.50177383e-01f, 1.86474770e-02f, -3.29963006e-02f, 1.48453742e-01f, 3.66638750e-01f, 2.24769756e-01f, 3.31716806e-01f, -4.58494395e-01f,
  1.36442214e-01f, 4.71605361e-01f, 4.51943099e-01f, 2.04836559e-02f, 4.75808024e-01f, 1.78323805e-01f, 3.70804876e-01f, 1.09273039e-01f, -3.44259199e-03f, -3.11065972e-01f,
  3.27167332e-01f, -2.58482516e-01f, -3.43540698e-01f, -3.21145862e-01f, 3.93623799e-01f, -2.80247420e-01f, 5.68803191e-01f, 6.74260035e-03f, -3.56639206e-01f, 3.92292112e-01f,
  4.40208793e-01f, 2.53894538e-01f, 6.86190486e-01f, 7.78598487e-02f, 2.42563546e-01f, 8.95504206e-02f, -2.30150059e-01f, -2.54562885e-01f, 1.92017913e-01f, 3.56634438e-01f,
  3.98168951e-01f, -2.47172639e-01f, 1.39108881e-01f, -6.15832508e-01f, -3.00543308e-01f, 2.15198189e-01f, -4.13121015e-01f, 7.88204968e-02f, -2.17157975e-02f, -9.29558426e-02f,
  5.19228214e-03f, 5.44886470e-01f, 1.51870281e-01f, -5.79113483e-01f, 1.67381782e-02f, 2.21519470e-01f, 1.24258287e-01f, 1.07254386e-01f, -2.52836347e-01f, -8.26827511e-02f,
  6.98721781e-02f, -2.28486642e-01f, 3.16620260e-01f, 3.22977960e-01f, 3.99163038e-01f, 2.69535929e-01f, 7.48525798e-01f, -3.62741917e-01f, 3.56326759e-01f, 6.66591406e-01f,
  4.10464346e-01f, -3.12746242e-02f, -1.46285286e-02f, 2.10097045e-01f, 9.26200151e-02f, 6.02564692e-01f, 1.41134262e-01f, 1.54955387e-01f, 2.26083640e-02f, -2.11751029e-01f,
  1.26245499e-01f, 4.15716916e-01f, 1.62451208e-01f, -7.49687493e-01f, -2.64232486e-01f, 6.14615321e-01f, 3.84849787e-01f, -2.22406015e-02f, -2.76202470e-01f, 5.14312744e-01f,
  1.66063145e-01f, 7.04031825e-01f, -1.45376414e-01f, 2.23690838e-01f, -2.47715204e-03f, 3.26683074e-01f, -7.89240360e-01f, -3.89134735e-01f, -4.23084676e-01f, 7.74916053e-01f,
  5.13756931e-01f, -3.77660953e-02f, -6.22977652e-02f, 2.14634418e-01f, 7.23526115e-03f, 3.22259188e-01f, 4.21352506e-01f, 1.09355539e-01f, 3.15417171e-01f, 4.68182832e-01f,
  4.43076789e-01f, 4.82194871e-01f, 6.46268845e-01f, 3.39214861e-01f, 3.82656723e-01f, -1.03994191e-01f, 3.05380911e-01f, -5.48176706e-01f, 2.20863953e-01f, 4.37126189e-01f,
  5.24070203e-01f, 5.85656352e-02f, -3.10093284e-01f, -6.63367569e-01f, 2.44172718e-02f, -1.04031943e-01f, 4.23694968e-01f, -4.39018533e-02f, 6.59161210e-01f, -2.75762528e-01f,
  -8.62024650e-02f, 2.28140905e-01f, -1.68866977e-01f, 9.95436981e-02f, 1.97601750e-01f, 5.93056560e-01f, 6.00406647e-01f, -4.69608933e-01f, 2.85393000e-01f, 2.13148117e-01f,
  1.54762432e-01f, 3.49321067e-01f, -5.37581071e-02f, 2.98620880e-01f, 2.14196160e-01f, 3.22289765e-01f, 1.04533479e-01f, -8.49541351e-02f, -8.43197778e-02f, 3.30795278e-03f,
  -1.91237077e-01f, 5.27395308e-01f, 1.03787504e-01f, 5.11399150e-01f, -7.06629992e-01f, 3.50639343e-01f, -9.82736647e-02f, 2.46330008e-01f, 1.26274422e-01f, -2.61634558e-01f,
  -4.02870595e-01f, -3.24984431e-01f, -2.69816309e-01f, 6.13127708e-01f, 4.17620897e-01f, 7.24597633e-01f, -4.99705702e-01f, 5.88174462e-01f, 1.09417075e-02f, 5.03481090e-01f,
  4.14416380e-02f, 6.66266531e-02f, 4.96867925e-01f, 4.47814256e-01f, 4.03267473e-01f, 5.30316889e-01f, 5.81327200e-01f, 4.10260618e-01f, 2.06910253e-01f, -4.18012917e-01f,
  4.61469106e-02f, -3.81131917e-01f, 6.25413775e-01f, 5.97905219e-01f, 5.25407255e-01f, 4.48518753e-01f, -2.93895483e-01f, -3.73293012e-01f, -1.99792266e-01f, -3.85115892e-01f,
  1.98147163e-01f, 1.92524549e-02f, 3.31365079e-01f, -1.88559949e-01f, 1.86730027e-02f, 6.38210952e-01f, 1.30770266e-01f, 1.55409649e-01f, 1.29585177e-01f, 4.42132145e-01f,
  6.76400840e-01f, -5.46311021e-01f, -7.14975297e-02f, -6.14431977e-01f, 5.90570122e-02f, 2.28904203e-01f, 3.29060256e-01f, 1.09533846e-01f, 1.99779570e-01f, -4.20035981e-02f,
  3.40567887e-01f, 2.88431168e-01f, 3.41639876e-01f, -2.79544175e-01f, 5.47132790e-01f, 2.77518183e-01f, 3.53690296e-01f, -1.05986334e-01f, 4.70613390e-01f, 5.05332708e-01f,
  6.85264230e-01f, 2.97462672e-01f, -1.45231500e-01f, 5.40025868e-02f, -1.13496944e-01f, 3.74068022e-01f, 2.17680484e-01f, -2.29498222e-01f, 7.15518832e-01f, 9.03434232e-02f,
  6.20726943e-01f, -4.15248483e-01f, 5.17971933e-01f, 1.20054081e-01f, 2.15463787e-01f, -2.32526839e-01f, 1.08811527e-01f, 1.00681715e-01f, 3.04024398e-01f, -2.99670547e-01f,
  3.87721449e-01f, -1.10653594e-01f, -8.22322629e-03f, -4.59260702e-01f, 2.03931078e-01f, 2.25398242e-01f, 3.47920060e-01f, -1.56378850e-01f, 4.20757234e-01f, 4.31426227e-01f,
  8.73624444e-01f, 2.99438238e-01f, 3.15526158e-01f, 2.68582195e-01f, -4.36519831e-01f, 2.86590755e-01f, -3.39830481e-02f, 5.88387512e-02f, -3.15608650e-01f, -9.34670344e-02f,
  3.72390896e-01f, -2.08373711e-01f, 8.14500213e-01f, -3.21036577e-01f, 5.11479855e-01f, 7.06325322e-02f, 4.42606837e-01f, 7.84595087e-02f, -6.83788657e-02f, -1.25678405e-01f,
  1.75416514e-01f, 1.86527967e-02f, 2.20311463e-01f, -9.12588909e-02f, -4.61605117e-02f, -4.12757732e-02f, 4.02434111e-01f, -4.67141360e-01f, -4.63007629e-01f, -3.54284495e-01f,
  -1.75294906e-01f, -1.73080666e-03f, -2.63062537e-01f, -6.36692941e-01f, -2.71634817e-01f, 1.00553624e-01f, 8.40099335e-01f, 6.20864689e-01f, 2.74641693e-01f, 1.05587073e-01f,
  7.25792468e-01f, -1.76505819e-01f, -2.06378981e-01f, 7.49250948e-01f, -3.06809038e-01f, 4.21092331e-01f, -2.49538958e-01f, 5.66165864e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  3.02705616e-01f, 2.36576766e-01f, 9.82598290e-02f, -9.76045057e-02f, 5.11111245e-02f, 3.48106742e-01f, -1.60872452e-02f, 3.63128304e-01f, 2.94306457e-01f, 8.10102820e-02f,
  3.07036966e-01f, 3.31970155e-01f, 1.46765560e-01f, 1.61008790e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.94824779e-01f, 1.23639092e-01f, 2.48353183e-01f, 3.90266143e-02f, -2.92859077e-01f, -1.40514642e-01f, 2.49335617e-01f, 3.82299838e-03f, 1.48947593e-02f, 1.51017755e-01f,
  -4.15792167e-01f, -4.05556411e-01f, -1.96031004e-01f, -1.90387413e-01f, 2.39305481e-01f, 3.61566514e-01f, -2.64735132e-01f, 2.00346127e-01f, 2.14210704e-01f, 1.10682070e-01f,
  1.21356258e-02f, 3.34810585e-01f, -1.76913053e-01f, -1.54692829e-01f, 1.05020013e-02f, -3.78305703e-01f, -4.89354849e-01f, -6.34072363e-01f, -5.83322644e-01f, 5.62297642e-01f,
  4.63698030e-01f, -5.15459180e-01f, 3.12349766e-01f, -1.40111253e-01f, -4.05381918e-01f, 3.14961463e-01f, 4.03763801e-01f, 1.16315179e-01f, 4.74044681e-02f, 2.01619208e-01f,
  2.93377757e-01f, -2.71702260e-02f, 4.03697371e-01f, 3.64114821e-01f, 1.50206551e-01f, -1.54432371e-01f, 4.35673654e-01f, -2.83348411e-01f, 8.81394185e-03f, 3.04291040e-01f,
  -5.25240637e-02f, 2.67882556e-01f, 2.76265323e-01f, 3.61064583e-01f, -2.36943573e-01f, -3.35425377e-01f, -5.14359057e-01f, 2.94424444e-01f, -5.58785379e-01f, 1.41845211e-01f,
  -6.52844310e-01f, 2.13732906e-02f, 3.77673358e-01f, -3.00958484e-01f, -3.72208297e-01f, 5.66553213e-02f, -4.06920582e-01f, -4.52377111e-01f, -4.27526325e-01f, 2.74973154e-01f,
  -1.89755976e-01f, -4.08308595e-01f, 2.25188047e-01f, -3.15578550e-01f, 3.91541064e-01f, 1.68519929e-01f, 1.74750030e-01f, 2.17256278e-01f, 1.84046879e-01f, 2.77833790e-01f,
  2.85614878e-01f, 3.32783848e-01f, -4.63916391e-01f, 5.82010508e-01f, -1.20991878e-01f, -1.50320619e-01f, -7.72413015e-01f, -4.39673811e-01f, -4.85212803e-01f, 4.76914078e-01f,
  -2.88398892e-01f, 3.10206562e-01f, 4.26364481e-01f, -4.26215440e-01f, -4.11957234e-01f, -6.15624309e-01f, 2.24597976e-02f, -1.98238149e-01f, -7.64454305e-02f, -3.91131520e-01f,
  -2.21932620e-01f, -1.38338596e-01f, -1.61188856e-01f, -3.10421437e-01f, -1.53549586e-03f, 2.87478030e-01f, 1.31032005e-01f, -1.85168624e-01f, -1.47731826e-01f, -4.41278100e-01f,
  -1.24957241e-01f, 4.45547521e-01f, 1.84453011e-01f, -1.22645885e-01f, 2.95116842e-01f, 1.74028575e-01f, -3.73790979e-01f, -4.75790441e-01f, 2.67719239e-01f, 3.91791642e-01f,
  3.22146237e-01f, -7.29178846e-01f, -2.64302641e-01f, -5.69762468e-01f, -7.82091141e-01f, -2.47311249e-01f, -5.25070369e-01f, 2.45617405e-01f, -2.31048346e-01f, -1.81060418e-01f,
  -2.30150148e-01f, 1.42046943e-01f, -1.37767941e-01f, 8.84588733e-02f, 2.43799791e-01f, 3.05357785e-03f, 5.83887659e-02f, 2.26474851e-01f, -4.68471885e-01f, -5.47123611e-01f,
  -3.53633791e-01f, 2.44406750e-03f, -7.13155568e-02f, 2.91414142e-01f, -5.18440723e-01f, -2.07377896e-01f, -1.21188492e-01f, 1.09654099e-01f, -4.15981889e-01f, 7.52853826e-02f,
  4.94147241e-01f, 1.47601619e-01f, 2.26879478e-01f, -5.89321733e-01f, 3.82828832e-01f, -6.75567687e-01f, 3.00776750e-01f, 1.22461766e-01f, 2.50966907e-01f, -8.39699432e-02f,
  1.83311746e-01f, 1.15590282e-01f, 4.45436567e-01f, -3.67657207e-02f, 2.95886517e-01f, 3.26082855e-01f, 2.47796392e-03f, 6.70866817e-02f, -6.26353443e-01f, 4.61222827e-01f,
  1.64399326e-01f, 2.52090365e-01f, -4.71023113e-01f, -5.92023790e-01f, -5.28612614e-01f, -2.36956283e-01f, -4.32867497e-01f, -2.80494213e-01f, 2.47566745e-01f, -1.89065710e-01f,
  1.95896298e-01f, 3.33915085e-01f, -7.00836241e-01f, 6.06112555e-02f, -1.04893886e-01f, -2.77289480e-01f, 3.38273972e-01f, 8.17072615e-02f, 2.34053254e-01f, 1.08147509e-01f,
  -2.04652041e-01f, 1.90079119e-02f, 2.16269940e-01f, 1.31805226e-01f, 1.97284684e-01f, 2.86216617e-01f, 1.61560446e-01f, -4.00258824e-02f, -4.55172628e-01f, 2.49394745e-01f,
  -3.49226117e-01f, -4.56207603e-01f, -2.81835228e-01f, 3.22226107e-01f, 5.21874428e-01f, 2.46682003e-01f, -5.51625252e-01f, -1.35171399e-01f, 4.79027718e-01f, -2.31721476e-01f,
  -6.13240600e-01f, -3.27842712e-01f, -5.56047738e-01f, -3.58685166e-01f, 2.94911623e-01f, 2.08078429e-01f, -4.12747324e-01f, 2.20083386e-01f, 4.98469830e-01f, 4.16607469e-01f,
  5.39613962e-01f, -4.91460234e-01f, -7.23563075e-01f, -2.78197348e-01f, -2.15837687e-01f, 9.96598750e-02f, -1.28912896e-01f, -2.60529399e-01f, -1.13480307e-01f, 9.86879244e-02f,
  -9.58131254e-02f, -1.08370200e-01f, -2.98426440e-03f, 1.47868186e-01f, 6.05502166e-02f, -8.45895484e-02f, -2.54457165e-02f, 8.42633173e-02f, 3.06709185e-02f, -2.05104426e-03f,
  -9.46909040e-02f, 2.52636343e-01f, -8.71654041e-03f, -2.28243157e-01f, 1.29928961e-01f, 2.90220141e-01f, 3.22283149e-01f, -6.08755052e-01f, 4.58835602e-01f, -4.33007360e-01f,
  -5.65838397e-01f, -2.27989405e-01f, -4.61889058e-01f, 2.74954766e-01f, -4.09387976e-01f, 1.62236571e-01f, -1.58928558e-01f, -7.69954249e-02f, -2.66494185e-01f, 7.18811676e-02f,
  5.12620620e-02f, 2.07394242e-01f, -2.55153507e-01f, 8.00821334e-02f, -3.65269244e-01f, -8.38288516e-02f, 2.60953844e-01f, -4.13353257e-02f, 2.06713557e-01f, 1.55212298e-01f,
  -9.51266810e-02f, -8.97527114e-02f, 1.84633598e-01f, -3.23950984e-02f, -2.21347034e-01f, -5.83067656e-01f, 3.37608576e-01f, -3.25495839e-01f, -3.98379117e-01f, -7.54040778e-01f,
  2.91068941e-01f, 2.48161182e-01f, -3.98069799e-01f, 4.95747000e-01f, -4.63022321e-01f, -2.49740735e-01f, -2.23005190e-01f, 2.55132169e-01f, 2.58718908e-01f, 2.83904940e-01f,
  3.74935955e-01f, 1.44112229e-01f, 1.06455766e-01f, 1.12120479e-01f, 2.47014225e-01f, 1.07191436e-01f, 2.86036462e-01f, 3.20912421e-01f, -9.63867735e-03f, -2.77041376e-01f,
  5.72461903e-01f, -4.84680265e-01f, 5.84594607e-01f, -2.89297014e-01f, 2.43847996e-01f, 4.13650453e-01f, -7.44532406e-01f, 3.37880999e-01f, -2.77914912e-01f, 1.82569772e-02f,
  2.95983374e-01f, 3.05350035e-01f, -2.82780588e-01f, 2.01651663e-01f, 1.10758588e-01f, -2.30225682e-01f, 3.00247937e-01f, 3.83634418e-01f, 4.13936287e-01f, -5.85052311e-01f,
  2.40754172e-01f, 1.83989912e-01f, 3.93276542e-01f, 1.91988051e-01f, -2.84594148e-02f, -3.65860432e-01f, 3.22582483e-01f, -2.17548296e-01f, 5.36276937e-01f, -6.35933280e-02f,
  -4.07803774e-01f, -1.03645464e-02f, -7.06182644e-02f, 5.87465823e-01f, -9.40401554e-02f, -3.20242226e-01f, -4.85791057e-01f, 8.15100968e-02f, 3.19144100e-01f, -4.08749670e-01f,
  5.14600158e-01f, -4.35694695e-01f, -2.16613591e-01f, 4.15416390e-01f, -4.61283952e-01f, 2.53347993e-01f, -1.63599029e-01f, -4.64412212e-01f, -4.44475770e-01f, -5.53455949e-01f,
  1.56091643e-03f, 2.62338787e-01f, -3.50080617e-02f, 9.40600261e-02f, 4.68849763e-02f, 1.43890142e-01f, 1.88570321e-01f, -1.76051810e-01f, 2.72187829e-01f, 1.99155286e-01f,
  -3.45745087e-01f, -3.37822258e-01f, 3.02648455e-01f, 1.68958649e-01f, -2.74980552e-02f, 6.51087053e-03f, 2.78619140e-01f, -1.61849722e-01f, 2.02429786e-01f, 1.40001655e-01f,
  -1.63115650e-01f, -6.67555749e-01f, 6.87981173e-02f, -6.64970160e-01f, 3.09523642e-01f, -4.71275002e-02f, 3.38025123e-01f, -7.01333106e-01f, 1.80153906e-01f, 1.95446610e-01f,
  1.00935854e-01f, -3.83715093e-01f, -2.39107758e-02f, 3.78618777e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.64620027e-02f, 2.74237432e-02f, 1.11059457e-01f, 2.89888792e-02f, -8.87457728e-02f, 1.36651203e-01f, -8.23850483e-02f, -1.06467590e-01f, -1.27759233e-01f, -3.87120806e-02f,
  2.62307853e-01f, -1.42929897e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    