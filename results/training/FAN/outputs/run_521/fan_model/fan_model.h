/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.23638195e-01f, 1.11269228e-01f, 4.38144878e-02f, -1.26174957e-01f, -7.53041804e-02f, 1.53982462e-02f, -8.08619037e-02f, -1.01069305e-02f, 8.82674828e-02f, 2.60401964e-02f,
  -1.54050132e-02f, -3.11516989e-02f, 3.27177234e-02f, 5.64057380e-02f, -1.49465457e-01f, 1.29856467e-01f, -7.79034346e-02f, 1.24886241e-02f, 5.71463183e-02f, -1.99508011e-01f,
  -5.45930769e-03f, -4.88807335e-02f, 2.50635948e-02f, -5.34231262e-03f, -1.21113092e-01f, -7.23447651e-02f, -6.26890659e-02f, 3.90312858e-02f, -9.09087285e-02f, 9.11650062e-02f,
  -4.27228808e-02f, 7.95413833e-03f, 5.47454692e-02f, 5.30093908e-02f, -3.62791047e-02f, 4.45392057e-02f, 2.42117215e-02f, -1.18761687e-02f, -4.29724231e-02f, 3.30720171e-02f,
  -6.73843026e-02f, 1.17579754e-02f, -4.81757969e-02f, 6.57955706e-02f, 4.93068397e-02f, -6.31923974e-02f, -2.72865640e-03f, -9.81808873e-04f, 2.11142804e-02f, -1.18061621e-02f,
  4.90239784e-02f, -1.42738419e-02f, 6.73779100e-02f, 3.59997600e-02f, 1.61369368e-02f, 3.76159400e-02f, -9.32879094e-03f, -1.09837234e-01f, 4.85213473e-02f, -3.23489718e-02f,
  -7.19292238e-02f, -2.54692268e-02f, -1.19413557e-02f, -1.58827286e-02f, -2.32021455e-02f, 1.76526839e-03f, 4.07186784e-02f, -4.57932204e-02f, -5.06573096e-02f, -1.25021805e-04f,
  1.04502996e-03f, 3.54315639e-02f, 2.35794522e-02f, 6.19294262e-03f, -4.40018438e-02f, 7.16161430e-02f, -6.00324497e-02f, 3.08058821e-02f, -3.64330783e-02f, 1.44088501e-02f,
  2.21363641e-02f, 1.47604471e-04f, -2.38577351e-02f, -7.96469452e-04f, 4.86812508e-03f, 8.88231769e-03f, 8.79537500e-03f, 7.79569000e-02f, -2.13273428e-02f, -6.19445071e-02f,
  -4.34124991e-02f, -7.05922768e-02f, -2.82900482e-02f, -5.57443425e-02f, 4.09015268e-02f, -6.41812012e-02f, 1.43555984e-01f, -2.33449657e-02f, 1.01797119e-01f, 1.21461763e-03f,
  -8.85269716e-02f, 5.02946600e-03f, 1.64487120e-02f, -6.65546507e-02f, 2.01553106e-02f, -2.18462404e-02f, -1.03422195e-01f, -8.63806754e-02f, -9.08422098e-02f, -3.85684036e-02f,
  -7.67377838e-02f, -3.20111699e-02f, 4.89169993e-02f, -3.77961360e-02f, -7.14585767e-04f, -2.14086846e-02f, -8.39994103e-02f, -1.58787500e-02f, 7.20236450e-02f, 5.09433961e-03f,
  5.06283641e-02f, -2.97383010e-01f, 1.32926758e-02f, -1.00332096e-01f, -3.02913338e-02f, -4.24967296e-02f, 5.93629014e-03f, -1.14125483e-01f, -1.76191315e-01f, -1.00783341e-01f,
  8.00628029e-03f, -4.26026322e-02f, -2.23217383e-02f, -1.61912367e-01f, 1.28885299e-01f, -4.25192788e-02f, -1.80670083e-01f, -9.71790180e-02f, -1.38046208e-03f, -7.33468607e-02f,
  -7.53819570e-02f, 1.31851463e-02f, -6.43919334e-02f, -4.35709059e-02f, -6.30639941e-02f, -6.90575689e-02f, 1.54575974e-01f, 8.11697617e-02f, 2.07600016e-02f, 3.95384394e-02f,
  -1.15560368e-02f, -1.05861515e-01f, -7.87533633e-03f, 3.15650217e-02f, 3.77804227e-02f, 8.39583948e-02f, 2.84465905e-02f, 5.88104911e-02f, 4.18752469e-02f, -3.02755646e-02f,
  7.81401694e-02f, -6.11294359e-02f, 2.36575697e-02f, 4.47988175e-02f, -2.23904252e-02f, -2.83824913e-02f, 6.23938479e-02f, -6.37323856e-02f, -8.98479745e-02f, 1.75732058e-02f,
  -2.56182291e-02f, -1.36533566e-02f, -8.23432803e-02f, -2.46731061e-02f, -3.16144489e-02f, 2.39966204e-03f, -7.23304674e-02f, -3.00383149e-03f, 9.53485072e-02f, 1.62053797e-02f,
  -4.90767919e-02f, 3.99407409e-02f, 4.73909965e-03f, 1.36600016e-02f, -5.56919537e-02f, -2.98734680e-02f, -1.19209085e-02f, 9.65294149e-03f, 5.92278428e-02f, -2.63577886e-02f,
  -1.14016060e-03f, -5.60583398e-02f, 6.30404335e-03f, -3.69825587e-02f, 1.72210969e-02f, -3.44539173e-02f, -3.12259365e-02f, 2.67118234e-02f, 6.24345765e-02f, 6.33941637e-03f,
  -3.15398872e-02f, -6.16055354e-02f, -7.18662189e-03f, -1.33508826e-02f, -6.20273035e-03f, 2.37658080e-02f, 5.94432205e-02f, -2.86743678e-02f, 7.25017041e-02f, 8.12006965e-02f,
  -4.14556526e-02f, -9.92924720e-02f, 3.89408693e-02f, 6.39171433e-03f, -1.77832153e-02f, 2.61106584e-02f, 2.23977193e-02f, -1.18859001e-02f, -3.91744971e-02f, -2.71551814e-02f,
  5.98059632e-02f, -8.73436779e-03f, 6.20142668e-02f, 1.89732146e-02f, -2.61640772e-02f, -9.27625224e-03f, -1.19093880e-02f, 4.33269925e-02f, 5.05825616e-02f, 1.84840132e-02f,
  6.73046559e-02f, 2.53565758e-02f, -1.99541189e-02f, -6.74197152e-02f, -2.18664687e-02f, -4.96589094e-02f, -7.76643679e-02f, 7.99496025e-02f, -7.91947171e-02f, -1.20576816e-02f,
  -2.68266827e-01f, -1.35521740e-01f, -1.04102232e-01f, -2.44939655e-01f, 1.49211898e-01f, -3.52041684e-02f, 2.99893389e-03f, -2.15046965e-02f, -1.01918623e-01f, -9.91637185e-02f,
  6.00695461e-02f, -1.47692129e-01f, 7.73689570e-03f, -1.12955146e-01f, 1.53354272e-01f, 4.42180224e-02f, -4.82734031e-04f, 3.55012119e-02f, 5.23838066e-02f, -6.86915368e-02f,
  -9.26218834e-03f, 4.80531529e-02f, 1.16341062e-01f, 1.50712684e-01f, 1.67331379e-02f, -6.92331642e-02f, 7.93866739e-02f, 1.35521770e-01f, 8.34954381e-02f, 1.09557092e-01f,
  6.73834980e-02f, -1.09966457e-01f, -4.01058421e-02f, -4.87241074e-02f, 8.02592784e-02f, -2.93314792e-02f, 8.28545094e-02f, 6.92269728e-02f, 2.67926902e-02f, -1.26058208e-02f,
  -5.39384177e-03f, 8.66862983e-02f, 3.36763524e-02f, -4.27481495e-02f, 1.06252376e-02f, -1.79708637e-02f, 2.10178993e-03f, 3.08397110e-03f, 3.10936365e-02f, -1.60714537e-02f,
  -1.82145480e-02f, 3.90174948e-02f, -5.69392601e-03f, 1.08579800e-01f, -7.56514221e-02f, -8.11724812e-02f, 2.87115220e-02f, 3.06360926e-02f, 9.39914733e-02f, -5.16617224e-02f,
  -1.80304796e-02f, 1.25005944e-02f, 4.17973846e-02f, 5.17492602e-03f, 9.66427941e-03f, 9.64055210e-03f, 6.54400364e-02f, -1.84574202e-02f, -9.94934961e-02f, 2.10231077e-03f,
  -9.05355066e-03f, -2.18243562e-02f, -1.08904494e-02f, -3.19072157e-02f, -3.37529555e-02f, -3.87393311e-02f, 9.81160030e-02f, -7.01878816e-02f, -6.11021370e-02f, 3.37203182e-02f,
  4.25344370e-02f, -2.40317956e-02f, 4.33733314e-03f, 2.10243072e-02f, -1.10021178e-02f, 1.99120305e-02f, 3.63722146e-02f, -3.52674723e-02f, 2.53931135e-02f, 7.95269161e-02f,
  7.71893654e-03f, -2.38527618e-02f, 2.78266128e-02f, 5.58419432e-03f, 1.06997965e-02f, -1.26723880e-02f, 1.75761562e-02f, -3.37918662e-02f, 9.14736278e-03f, 5.66334389e-02f,
  4.52577285e-02f, 2.07548514e-02f, -4.67597358e-02f, 1.63601488e-02f, 2.11191792e-02f, 5.46328761e-02f, -2.71837935e-02f, -4.27859090e-03f, -1.57596115e-02f, 8.46488774e-02f,
  8.77533108e-02f, 4.59018834e-02f, 1.80442408e-02f, 3.65115032e-02f, -2.32195146e-02f, 6.37409166e-02f, 1.00675197e-02f, -5.65260164e-02f, -5.18902671e-03f, 3.88489328e-02f,
  -1.29703283e-01f, 1.32925227e-01f, -2.94884667e-02f, 7.17404531e-03f, 1.36267856e-01f, 2.34576240e-01f, 1.70985505e-01f, 1.10158183e-01f, 6.30515665e-02f, 8.75340104e-02f,
  -5.58947818e-03f, -1.12972081e-01f, -3.02307010e-02f, 7.46809915e-02f, -2.36687586e-01f, -2.01271288e-02f, 5.50168492e-02f, 2.92459354e-02f, -7.16129988e-02f, 9.74640921e-02f,
  -5.97068556e-02f, 1.37282923e-01f, -9.45051610e-02f, 1.26689717e-01f, 2.85170916e-02f, -4.91705239e-02f, -4.81225029e-02f, -4.50165048e-02f, 1.07214347e-01f, 8.64656270e-03f,
  3.47163752e-02f, 6.07762672e-02f, -1.01030450e-02f, 1.86528526e-02f, 1.88167747e-02f, 9.54629183e-02f, -8.15331042e-02f, -7.83489794e-02f, -4.05161455e-02f, 1.78664960e-02f,
  -2.00432772e-03f, -6.81118891e-02f, -8.06832500e-03f, 4.74904180e-02f, 4.49269190e-02f, 6.65291473e-02f, -1.05132572e-02f, -4.92738653e-03f, 8.24009106e-02f, -1.21322162e-02f,
  9.72239375e-02f, 7.85768107e-02f, -3.60837281e-02f, -5.48190214e-02f, 5.68206050e-02f, -4.08300124e-02f, 5.93853109e-02f, 8.00501779e-02f, 7.29315951e-02f, -7.37662800e-03f,
  4.37629633e-02f, -1.03534542e-01f, 6.16289955e-03f, -6.55100495e-02f, 2.08820291e-02f, -3.04270480e-02f, -9.24858898e-02f, -2.55629104e-02f, -7.64705539e-02f, 7.94062912e-02f,
  -5.68093546e-02f, -1.59615725e-02f, -1.61364395e-02f, 4.90904553e-03f, 1.93907935e-02f, -5.22267679e-03f, -1.64842256e-03f, -3.79879610e-03f, 5.40694110e-02f, -1.99453402e-02f,
  -2.71980222e-02f, -6.31337166e-02f, 2.68218331e-02f, -4.23876829e-02f, -7.62468800e-02f, 1.15413349e-02f, 9.05626863e-02f, -1.69663746e-02f, 1.19371423e-02f, 7.41023105e-03f,
  2.38214396e-02f, 9.25196800e-03f, 4.89609428e-02f, -7.64004799e-05f, 2.09159367e-02f, 4.61245701e-02f, 5.01581132e-02f, -3.31138037e-02f, -1.82703268e-02f, -2.91342512e-02f,
  5.88777587e-02f, -5.28500341e-02f, 4.39485256e-03f, 4.53126319e-02f, -3.20843719e-02f, 1.32629499e-01f, -9.25805420e-02f, 1.88206807e-02f, 1.51616037e-02f, 2.58388128e-02f,
  -2.08882242e-02f, 1.98455025e-02f, -6.63586799e-03f, 8.57319981e-02f, 2.91348472e-02f, -2.84404662e-02f, 2.38454267e-02f, 1.62550211e-02f, -7.06689656e-02f, 4.41195667e-02f,
  -1.25079200e-01f, -2.17518866e-01f, 1.65183529e-01f, -1.12590343e-01f, 1.62633713e-02f, -1.03718266e-01f, -8.27070996e-02f, -2.66777407e-02f, -3.60629559e-02f, -2.67723620e-01f,
  -4.39933240e-02f, 1.77035242e-01f, 3.91653851e-02f, -1.22252531e-01f, 2.20599815e-01f, 6.36654124e-02f, -1.63170010e-01f, -4.62682620e-02f, -9.41597950e-03f, 6.78230301e-02f,
  1.10586509e-01f, -1.62654549e-01f, 3.67422914e-03f, -5.79352155e-02f, -9.33258096e-04f, 7.82765970e-02f, -5.91763407e-02f, 5.76934852e-02f, -6.33472502e-02f, 8.75201002e-02f,
  -2.87152026e-02f, -1.32928103e-01f, -7.41379634e-02f, 1.05046853e-02f, -5.26800286e-03f, 4.05940898e-02f, 6.50804564e-02f, 1.18874639e-01f, -7.85973445e-02f, 3.34486552e-02f,
  8.27878863e-02f, 5.94276264e-02f, 3.09083294e-02f, 1.06086368e-02f, -6.50738552e-02f, 1.97669081e-02f, 1.38909109e-02f, -7.59388227e-03f, 6.38300851e-02f, 4.04366888e-02f,
  -7.82074593e-03f, -5.03720269e-02f, -4.68450747e-02f, -3.32419463e-02f, 4.54164967e-02f, -1.08873069e-01f, -1.07066473e-02f, 1.47271901e-01f, -1.61040965e-02f, -3.50856893e-02f,
  1.00499831e-01f, 5.67529984e-02f, 5.08115850e-02f, -3.45578045e-02f, -1.87125970e-02f, -3.11006308e-02f, -8.21341425e-02f, 5.33290021e-02f, -7.26634711e-02f, 1.75902750e-02f,
  9.18903097e-04f, 4.90082577e-02f, 3.72372046e-02f, -3.36564742e-02f, -5.48727475e-02f, 4.06359918e-02f, 3.27142775e-02f, 3.76343653e-02f, -4.24236096e-02f, -4.96730432e-02f,
  -5.90909496e-02f, 3.70356767e-03f, -3.87279280e-02f, 1.45754814e-02f, -2.91552767e-02f, 4.97670136e-02f, -3.34099643e-02f, 8.88555404e-03f, 6.31342223e-03f, 1.07738459e-02f,
  -2.64512897e-01f, -1.16380960e-01f, -8.24798048e-02f, -7.10948706e-02f, -3.30218188e-02f, 5.23616821e-02f, 6.70230091e-02f, 7.37133026e-02f, -8.83249938e-03f, -2.10130643e-02f,
  -5.80654033e-02f, -2.54446249e-02f, 1.43945152e-02f, -3.42937447e-02f, -6.04415052e-02f, -2.32889242e-02f, -4.49408069e-02f, -2.50273142e-02f, -1.04682468e-01f, 2.51857266e-02f,
  -8.44636485e-02f, 2.99346615e-02f, 3.69071178e-02f, -4.59456854e-02f, 2.75628772e-02f, 1.88246667e-02f, 5.96715137e-02f, -2.54077092e-02f, 6.34402856e-02f, -1.94928646e-02f,
  -1.64681613e-01f, 1.32068500e-01f, 4.26485501e-02f, -9.03166533e-02f, -1.77967921e-01f, 1.73669249e-01f, 2.26004869e-02f, -3.17476727e-02f, 9.53895152e-02f, 1.00423574e-01f,
  -4.21207361e-02f, -3.01421359e-02f, 1.11449854e-02f, 4.06271145e-02f, 1.14404745e-01f, 1.24014154e-01f, -4.41101380e-04f, 4.43705805e-02f, -3.57911885e-02f, -1.08883269e-01f,
  5.55068664e-02f, 7.90840983e-02f, 1.33351251e-01f, -8.24044570e-02f, -7.65322372e-02f, -8.33818093e-02f, -1.95513461e-02f, -4.75268550e-02f, -6.07864186e-03f, 4.52959053e-02f,
  -1.33864716e-01f, -4.98234555e-02f, -6.93633109e-02f, 5.60167618e-03f, 1.72653422e-02f, -2.57509965e-02f, -5.89008220e-02f, 4.23165374e-02f, 4.31735702e-02f, 2.40808702e-03f,
  2.56709047e-02f, -2.36529298e-02f, -5.59631130e-03f, -2.69974787e-02f, -1.28834536e-02f, -8.05484504e-02f, 1.09757856e-02f, -5.94588034e-02f, -6.40586615e-02f, 4.08933125e-02f,
  -5.90147302e-02f, -3.16291153e-02f, -2.83595026e-02f, 6.35338873e-02f, 2.52254717e-02f, -1.78633966e-02f, 4.23644483e-02f, 1.77037548e-02f, 4.63232771e-02f, 5.52767795e-03f,
  3.42851207e-02f, -1.40917413e-02f, 7.59392278e-03f, 1.91609655e-02f, -3.18295173e-02f, -7.14817608e-04f, -3.07880808e-02f, 6.21694364e-02f, 3.92278172e-02f, -3.99968661e-02f,
  -1.18981995e-01f, -1.19890630e-01f, -2.98655108e-02f, 1.22415964e-02f, 5.34384213e-02f, -1.54294306e-02f, -1.12018948e-02f, -2.80761588e-02f, -9.41772759e-03f, -3.87067385e-02f,
  1.10736897e-03f, 8.63252021e-03f, -9.71420482e-03f, -6.17402792e-02f, 7.02037588e-02f, 5.79291163e-03f, -1.07527738e-02f, -1.38719450e-03f, -2.80369613e-02f, -1.70314349e-02f,
  -7.07227364e-02f, -1.26861274e-01f, -3.08307586e-03f, -1.21469609e-01f, 2.43470892e-02f, 8.03100467e-02f, 1.67282652e-02f, 5.27134724e-02f, 1.15288906e-01f, -1.34306848e-02f,
  2.12752093e-02f, -9.69017576e-03f, 1.40799619e-02f, 4.27557901e-02f, 3.27076726e-02f, 4.12982218e-02f, 1.39757805e-02f, 8.05869401e-02f, -5.06999008e-02f, -6.93120584e-02f,
  -3.25317346e-02f, -1.93836391e-02f, 2.14820020e-02f, 4.95565776e-03f, 2.25208960e-02f, -5.49726672e-02f, -2.92466506e-02f, 6.72248611e-03f, 1.94831975e-02f, 3.36806662e-02f,
  1.96964353e-01f, -1.76868401e-02f, -2.09995601e-02f, -1.23531058e-01f, 5.38153760e-02f, 2.37532750e-01f, 9.34852660e-02f, 5.76248728e-02f, 1.70795500e-01f, 2.56919637e-02f,
  -9.18561518e-02f, 4.07900289e-02f, -1.54204637e-01f, -8.09159279e-02f, -1.32118640e-02f, -2.61024432e-03f, 9.54580680e-02f, 2.10235137e-02f, 1.46123946e-01f, -9.16838460e-03f,
  1.13999024e-02f, -7.84229413e-02f, -1.02280095e-01f, 1.27225053e-02f, 9.64269713e-02f, 3.57629685e-03f, -1.61217377e-01f, -2.77814325e-02f, 4.84079961e-03f, 7.13954419e-02f,
  -4.46472056e-02f, 3.90971117e-02f, 3.00876275e-02f, 3.04707401e-02f, 9.65279806e-03f, -5.52972779e-02f, 7.83262309e-03f, -3.21123190e-02f, 9.63735394e-03f, 6.60637766e-02f,
  7.60294916e-03f, -2.52676159e-02f, -1.52098862e-02f, 1.16994865e-02f, 3.75097990e-02f, -6.34376705e-02f, -2.21631099e-02f, 3.88304554e-02f, -4.19621058e-02f, -2.65639229e-03f,
  -1.74623560e-02f, 3.20585398e-03f, 3.01791076e-02f, -5.70283867e-02f, 4.28947769e-02f, 2.72473483e-03f, -1.16873551e-02f, 1.57020837e-02f, 3.32054496e-02f, 5.22744767e-02f,
  1.50951063e-02f, -2.18785238e-02f, -4.07869890e-02f, -1.62382945e-02f, -3.26041318e-02f, -5.12242205e-02f, 6.17035152e-03f, -1.34752899e-01f, -1.68014523e-02f, -4.14598919e-02f,
  5.42534096e-03f, 2.59645022e-02f, -5.45784906e-02f, 1.23267621e-02f, -5.21260127e-02f, 2.89535546e-03f, -2.33411556e-03f, -9.29995906e-03f, 8.95018631e-04f, 9.79110785e-03f,
  7.69528821e-02f, 5.23725040e-02f, -6.16549589e-02f, 6.06970163e-03f, 1.97290331e-02f, 4.64544725e-03f, -5.14096618e-02f, 6.57989457e-02f, -5.80530427e-02f, -4.42264900e-02f,
  5.76021001e-02f, -8.43068808e-02f, -4.03958447e-02f, 8.43467265e-02f, 3.46644968e-02f, 8.23251083e-02f, -5.28760776e-02f, 2.00693253e-02f, 1.80717073e-02f, 1.23302275e-02f,
  -1.43855661e-02f, 7.85636231e-02f, 3.04817874e-02f, -1.41393803e-02f, 7.80279413e-02f, 3.02725681e-03f, -8.71039033e-02f, -3.86529532e-03f, -7.50682205e-02f, -4.62029427e-02f,
  -2.22600680e-02f, 3.67127992e-02f, -5.54112121e-02f, 3.70437950e-02f, -9.70485657e-02f, -2.20799539e-02f, 7.98404440e-02f, 8.31815973e-02f, -5.11954613e-02f, 1.00754360e-02f,
  -8.23290199e-02f, 2.83630282e-01f, 8.19498971e-02f, 2.55936354e-01f, -2.43596882e-02f, 1.38115734e-01f, 8.61557052e-02f, 7.48786107e-02f, 1.40918463e-01f, 9.06521156e-02f,
  -2.70110499e-02f, 7.39533529e-02f, -1.01653170e-02f, 6.43795207e-02f, -5.11752106e-02f, 9.66402069e-02f, 1.29154220e-01f, 2.51837242e-02f, 5.98070286e-02f, 9.74949226e-02f,
  -4.23035659e-02f, 4.20841351e-02f, -2.22339258e-02f, 1.43207638e-02f, -5.73447812e-03f, 1.48289707e-02f, -1.20012209e-01f, 5.72886653e-02f, 3.11283283e-02f, 7.59903761e-03f,
  6.05316311e-02f, -1.13185115e-01f, -8.50661322e-02f, -1.07390635e-01f, -3.10569722e-02f, -8.26624855e-02f, -2.26265956e-02f, 2.02638446e-03f, -7.60286599e-02f, -5.97776398e-02f,
  -7.17757223e-03f, -7.86215346e-03f, 3.27609442e-02f, 3.61381583e-02f, 1.80447865e-02f, 4.53245342e-02f, -5.65588363e-02f, 3.52956839e-02f, 2.86185388e-02f, -1.03078270e-02f,
  4.71752770e-02f, 6.42018914e-02f, 4.13695611e-02f, 9.50849429e-02f, 1.95301846e-02f, 5.50791174e-02f, 1.92642286e-02f, 5.36828190e-02f, 4.83616218e-02f, 9.81451049e-02f,
  3.11556738e-02f, -1.62835196e-02f, 1.19050834e-02f, -3.44325118e-02f, -6.30174764e-03f, 1.59381721e-02f, -2.10481714e-02f, -5.16305193e-02f, -1.62443835e-02f, -1.91216208e-02f,
  -2.68517230e-02f, 3.52790840e-02f, 1.81282833e-02f, -1.64432041e-02f, 2.97415163e-02f, 5.38882725e-02f, -8.49238560e-02f, -3.22344862e-02f, -2.84030084e-02f, 7.63050513e-03f,
  -5.33387810e-02f, -2.03330666e-02f, 2.09614802e-02f, -7.47991279e-02f, 4.35896218e-02f, -8.19200464e-03f, 9.54171494e-02f, 2.93927770e-02f, 2.83111688e-02f, 2.16543805e-02f,
  -4.37164605e-02f, 5.60625158e-02f, -3.17830853e-02f, -2.95589305e-02f, 5.33361360e-03f, -4.37479205e-02f, 1.00134432e-01f, -1.13769295e-02f, -7.87780806e-03f, -5.01768999e-02f,
  2.20464356e-02f, -5.60084991e-02f, -5.17348237e-02f, -8.34110100e-03f, 7.41424561e-02f, -4.16528992e-02f, 5.59120029e-02f, 7.66480267e-02f, -4.47033569e-02f, 3.10701486e-02f,
  1.46495895e-02f, -6.85924590e-02f, 3.40700522e-02f, -7.61319697e-02f, -3.29940617e-02f, -5.26670069e-02f, -2.19117496e-02f, -4.92770784e-02f, -1.75894257e-02f, -5.24970368e-02f,
  -3.74287635e-01f, 1.91939369e-01f, 1.20775901e-01f, -1.46292709e-02f, -1.61939561e-02f, 1.71269029e-02f, 9.96441673e-03f, 4.08528000e-02f, -1.61943808e-02f, 1.58019438e-01f,
  -4.50477898e-02f, -8.51334631e-02f, 8.68121535e-02f, 6.24722689e-02f, -1.27383098e-01f, 1.73665285e-02f, -5.12593426e-02f, -2.70049069e-02f, 2.68756822e-02f, -7.38367718e-03f,
  -6.94237873e-02f, 4.04032022e-02f, -2.56317556e-02f, 7.07414076e-02f, 9.15274117e-03f, -2.74151075e-03f, 2.24553631e-03f, 9.38498154e-02f, 6.05450124e-02f, -4.33682613e-02f,
  -3.86311337e-02f, 2.81302240e-02f, 3.31607759e-02f, -5.22432197e-03f, -2.71719843e-02f, 2.62218923e-03f, 1.67028047e-02f, 6.91187847e-03f, 7.15218782e-02f, 2.17811379e-04f,
  7.35285983e-04f, -6.04912750e-02f, 2.62421723e-02f, -8.48004371e-02f, 1.99725367e-02f, 7.26814568e-03f, 7.98125565e-02f, -8.14226493e-02f, -4.13523102e-03f, 1.48576172e-02f,
  8.21244940e-02f, -1.17005873e-02f, -1.86655279e-02f, -3.49889509e-03f, 1.95582304e-02f, 6.55592233e-02f, -4.51932475e-02f, 9.48143564e-03f, 1.73339136e-02f, -4.27034870e-02f,
  -7.30352476e-02f, 5.14033027e-02f, 7.95484856e-02f, 3.06739938e-02f, 2.05810666e-02f, -2.22632419e-02f, -2.69640442e-02f, -1.14171077e-02f, -4.49276976e-02f, 2.57224981e-02f,
  -1.73101798e-02f, 7.20091909e-02f, 3.79941277e-02f, 3.40104476e-02f, -4.15007845e-02f, -1.70852300e-02f, -3.35406065e-02f, 6.33602366e-02f, 1.96805019e-02f, -2.90761273e-02f,
  -4.84600244e-03f, -7.50197191e-03f, 6.83975667e-02f, 3.40491310e-02f, -4.27654712e-03f, -2.35039578e-03f, 1.48955723e-02f, 2.95831114e-02f, -2.24347301e-02f, -5.17626405e-02f,
  7.63917342e-02f, 4.69366722e-02f, -1.60568487e-02f, 2.90060956e-02f, 1.95423942e-02f, -2.38325354e-02f, -2.18564421e-02f, -4.55927715e-04f, -2.67265290e-02f, -6.51499480e-02f,
  -3.41134635e-03f, 6.03856258e-02f, -4.06543650e-02f, -2.07941458e-02f, 3.45203490e-03f, 8.02687630e-02f, 8.69108662e-02f, -4.70599532e-02f, 2.53188144e-02f, 7.61700794e-02f,
  9.32432618e-03f, 4.70540822e-02f, -5.83028793e-02f, -4.46013138e-02f, -4.48530875e-02f, -5.35175465e-02f, 1.86408814e-02f, -1.67729948e-02f, -6.86944276e-02f, 8.39467347e-02f,
  1.47566393e-01f, -2.00296775e-01f, -2.61511058e-02f, 4.27770428e-02f, 1.36215240e-01f, 1.24420695e-01f, 5.48665188e-02f, 1.23740751e-02f, 7.43957832e-02f, -1.75625503e-01f,
  -8.91984925e-02f, -4.08818424e-02f, -1.20673992e-01f, 3.51835266e-02f, 2.61404276e-01f, 8.09129514e-03f, 7.84771442e-02f, -5.55342622e-02f, 5.84240668e-02f, -3.29745971e-02f,
  -1.04516689e-02f, -7.79165234e-03f, 1.58521384e-01f, -5.98392934e-02f, -9.99821816e-03f, -8.34951550e-02f, 2.05147006e-02f, 4.36680764e-02f, -1.86550356e-02f, -7.35676941e-03f,
  -1.46481879e-02f, -5.49678318e-02f, -4.50561047e-02f, 7.58951157e-02f, -3.54187228e-02f, -1.58934202e-02f, -4.08987030e-02f, 7.90005997e-02f, 3.85738015e-02f, 1.89497992e-02f,
  -1.58161148e-02f, 8.23839828e-02f, -2.70868521e-02f, -4.01663408e-03f, 1.34305023e-02f, 3.63745689e-02f, -3.27197798e-02f, -3.13261300e-02f, -6.98104640e-03f, -1.56553066e-03f,
  1.61056034e-02f, 3.56425010e-02f, -2.42178491e-03f, -6.85943142e-02f, 4.79570590e-02f, 3.54923420e-02f, -1.31931184e-02f, 1.00348601e-02f, -3.51241753e-02f, -3.59750502e-02f,
  4.07913886e-02f, -5.38175786e-03f, -1.33163668e-02f, -3.61836962e-02f, -5.56730777e-02f, 5.58551289e-02f, -9.14810449e-02f, -6.08361997e-02f, -7.38903880e-02f, -6.94930740e-03f,
  -2.85887010e-02f, -6.43830374e-03f, -9.33328047e-02f, 1.20935058e-02f, -3.70762534e-02f, -3.53899375e-02f, -7.99883343e-03f, 4.78076003e-03f, 1.58681963e-02f, -4.51369062e-02f,
  -2.68527530e-02f, 2.83482876e-02f, -2.05605407e-03f, 2.00652163e-02f, 7.28315040e-02f, 1.29312556e-02f, 4.44458658e-03f, -4.67135571e-02f, -2.16936320e-02f, -1.56520326e-02f,
  -8.86982158e-02f, -1.26450017e-01f, -1.08198766e-02f, -3.02232131e-02f, -1.74391381e-02f, -8.62006750e-03f, 3.40770856e-02f, 8.88626873e-02f, 3.22251767e-02f, 6.20107874e-02f,
  -1.26920864e-02f, 2.11685821e-02f, -2.75072157e-02f, 5.24296127e-02f, 5.99984825e-02f, 5.77862896e-02f, 1.80975944e-02f, 2.77058408e-02f, -1.08241234e-02f, -1.54847503e-02f,
  2.91131213e-02f, -5.26923593e-03f, 1.16396425e-02f, -2.63728909e-02f, 2.46460177e-03f, -5.18300459e-02f, 2.53675766e-02f, 2.55014040e-02f, 3.99613380e-02f, -7.13245943e-03f,
  1.58661455e-01f, -1.62560850e-01f, -1.11137778e-01f, 9.63966474e-02f, -6.51765196e-03f, 4.00536247e-02f, 8.15884769e-02f, -1.03387512e-01f, -2.22462486e-03f, 7.89341237e-03f,
  2.07673952e-01f, -4.16389294e-03f, -4.40607555e-02f, 1.57214731e-01f, 2.37330526e-01f, 6.85571283e-02f, 1.51851282e-01f, 1.71721242e-02f, -8.85312166e-03f, -3.31345247e-03f,
  1.31363854e-01f, 4.83087301e-02f, 6.36879280e-02f, -8.33732560e-02f, -1.67895794e-01f, -1.23695113e-01f, 1.25268951e-01f, -6.44076243e-02f, 6.93522543e-02f, 9.54958946e-02f,
  7.78258741e-02f, -1.30008489e-01f, -5.71356826e-02f, -1.86640155e-02f, 4.08254117e-02f, 2.29111053e-02f, 4.15507816e-02f, 6.71819076e-02f, 1.90808475e-02f, -7.45563880e-02f,
  -2.91014127e-02f, -4.13329266e-02f, -2.33964790e-02f, 3.42555530e-02f, -2.35260595e-02f, -8.50733742e-02f, -3.88400778e-02f, -4.12918292e-02f, -1.12149492e-02f, -8.25414583e-02f,
  -4.62878197e-02f, -1.27246112e-01f, -1.51934335e-02f, -7.70823583e-02f, 6.63986951e-02f, 1.63732097e-02f, -2.97305454e-02f, 2.49850582e-02f, -8.84752125e-02f, -5.59465922e-02f,
  -1.59161184e-02f, -5.81937954e-02f, 2.95403153e-02f, 3.40664503e-03f, 8.32070876e-03f, -2.32049040e-02f, -3.58764194e-02f, 1.03742577e-01f, -6.26268089e-02f, 6.72490075e-02f,
  3.45523586e-03f, 7.96300620e-02f, 5.55320606e-02f, -8.49820822e-02f, 3.59688401e-02f, 2.67712586e-03f, 3.97276320e-02f, -6.42441064e-02f, -1.09261842e-02f, 6.51777536e-02f,
  1.03133529e-01f, -1.25343902e-02f, 2.93662753e-02f, -5.40816179e-03f, 7.62765706e-02f, -6.88748285e-02f, -6.20532446e-02f, 1.57520063e-02f, 4.58512381e-02f, 4.15538736e-02f,
  1.03823446e-01f, 1.36890650e-01f, -3.79524082e-02f, -1.65632740e-02f, 3.06712780e-02f, -2.78466530e-02f, 2.30267476e-02f, -1.86473653e-02f, 6.00931654e-03f, -1.67609174e-02f,
  -1.02450579e-01f, -2.44702194e-02f, -4.12499644e-02f, -2.06087083e-02f, -3.50210518e-02f, 9.11912844e-02f, 3.13074477e-02f, 1.13266427e-03f, 9.15652961e-02f, -2.35682703e-03f,
  -5.36502711e-02f, -6.29210845e-02f, 7.52478316e-02f, -1.01975620e-01f, -8.83670822e-02f, -2.86334381e-02f, -1.36504043e-02f, -4.91876528e-02f, 2.47726310e-02f, 4.15958129e-02f,
  -3.04515332e-01f, -1.95100456e-01f, -9.88725349e-02f, -2.69456983e-01f, 7.85905793e-02f, -1.02394978e-02f, -5.33611961e-02f, -3.97807211e-02f, -1.08879559e-01f, 1.78441796e-02f,
  1.41486287e-01f, -1.64944902e-01f, 7.55089056e-03f, -4.05540084e-03f, -3.40390727e-02f, -7.40474984e-02f, -1.17599946e-02f, -4.69285436e-02f, 3.05168470e-03f, -1.09508790e-01f,
  -3.01363394e-02f, 4.89938557e-02f, 3.30566727e-02f, 1.45004079e-01f, -1.21400297e-01f, -5.40196002e-02f, 1.49291977e-01f, 5.84727973e-02f, 4.42660190e-02f, 4.06925380e-02f,
  -8.48577265e-03f, -2.13885114e-01f, -2.77872721e-04f, -2.24688184e-03f, -7.58524612e-02f, 3.19885351e-02f, -5.29445186e-02f, 7.15946928e-02f, -3.26363221e-02f, -3.16628069e-02f,
  7.08825281e-03f, -4.00817534e-03f, 4.52421606e-02f, -2.09155343e-02f, -2.43791547e-02f, 4.81013656e-02f, 1.31745515e-02f, -9.42556188e-03f, -1.76521614e-02f, 4.62461002e-02f,
  -2.50138696e-02f, 4.83394340e-02f, 3.75699848e-02f, 1.53715685e-02f, 4.95002680e-02f, 2.92138997e-02f, 5.72597869e-02f, 5.25494060e-03f, -5.50210848e-02f, -4.77411337e-02f,
  -4.03951369e-02f, 5.82495220e-02f, 2.97581293e-02f, 5.65609634e-02f, -5.73719293e-02f, 6.86639994e-02f, -1.05227344e-02f, 3.52525003e-02f, 2.01688707e-03f, -4.53136675e-03f,
  -3.37570868e-02f, 1.28035224e-03f, 1.47279045e-02f, -5.72459213e-02f, -1.12014404e-02f, -7.06527084e-02f, 3.23629715e-02f, -2.24003736e-02f, 1.08275851e-02f, 3.26464325e-02f,
  -4.93746325e-02f, 2.00604890e-02f, -5.50003275e-02f, 2.40657069e-02f, -3.57956886e-02f, 5.09453304e-02f, -2.95133628e-02f, -5.99654056e-02f, -1.07246460e-02f, 5.52405193e-02f,
  -7.98826367e-02f, -1.33118868e-01f, -2.61352360e-02f, -9.62578878e-02f, 3.93658392e-02f, -5.23240678e-02f, 3.08940876e-02f, 3.05377524e-02f, -5.45103438e-02f, -1.64075196e-02f,
  -3.21756043e-02f, 1.95307117e-02f, -5.22244163e-02f, 4.59039286e-02f, 3.62332352e-02f, 1.11079095e-02f, -3.94333526e-02f, 3.03937625e-02f, -3.09708267e-02f, -1.31683303e-02f,
  4.94014882e-02f, -6.67120591e-02f, 6.55713491e-03f, 7.72228017e-02f, -3.41021568e-02f, -3.29680555e-02f, -4.63111550e-02f, -4.59732413e-02f, 5.70987947e-02f, -4.86773513e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.96137562e-01f, 2.70787358e-01f, 2.04077125e-01f, 1.78234801e-01f, -4.31128815e-02f, -1.23605207e-01f, -7.69610628e-02f, 1.21811286e-01f, -7.64127672e-02f, 7.99863786e-02f,
  -7.49064684e-02f, 2.25191280e-01f, -1.22437964e-03f, 2.35666987e-02f, -9.41277742e-02f, -5.99274449e-02f, 2.54242737e-02f, -3.56932357e-02f, -8.82848874e-02f, 1.71603397e-01f,
  5.31842075e-02f, -6.30107746e-02f, 1.06359214e-01f, -3.19083557e-02f, 1.60608843e-01f, 5.11790216e-02f, 1.77659635e-02f, -1.03706047e-02f, 1.17565738e-02f, -1.21552236e-01f,
  1.39895827e-02f, 3.23261209e-02f, -2.31122989e-02f, 8.18893686e-02f, 5.08923382e-02f, 4.87872250e-02f, 6.40728623e-02f, 1.15821594e-02f, -5.63366339e-02f, 5.82393333e-02f,
  2.55523361e-02f, 6.81372881e-02f, -4.85089347e-02f, 1.66340154e-02f, 2.76281908e-02f, 8.52082819e-02f, 1.28379047e-01f, 8.27638060e-02f, -2.57146731e-02f, 1.02227375e-01f,
  6.35472909e-02f, 1.15965068e-01f, -1.00741191e-02f, -2.58222986e-02f, 6.58891499e-02f, 7.34110130e-03f, 2.98747793e-02f, -4.48777378e-02f, -4.02330682e-02f, 2.39969920e-02f,
  9.33204312e-03f, 4.51054536e-02f, -5.32422289e-02f, -2.74994764e-02f, 5.76415993e-02f, 7.29962364e-02f, -4.98122759e-02f, -9.83333215e-02f, -7.81314000e-02f, -9.28087533e-02f,
  -1.32293299e-01f, -4.95008752e-02f, -1.28004169e-02f, -5.56198135e-02f, 4.74434942e-02f, 5.60784973e-02f, 2.49839332e-02f, 4.80594486e-02f, -2.61366665e-02f, 8.26349184e-02f,
  5.49925352e-03f, -4.46986780e-02f, -4.00708579e-02f, 2.35211644e-02f, -1.51072308e-01f, 1.81090627e-02f, 7.07554296e-02f, 1.17775016e-01f, -1.08133957e-01f, -1.20246008e-01f,
  4.64593545e-02f, 2.09043846e-02f, -9.30723399e-02f, -6.49390295e-02f, 2.42396388e-02f, -6.62978962e-02f, 9.87114534e-02f, 7.97822922e-02f, 1.75499786e-02f, -7.16822371e-02f,
  -5.06530218e-02f, -1.03309803e-01f, 3.50130796e-02f, 3.67018841e-02f, -1.15798600e-02f, -1.20164923e-01f, -4.97748144e-02f, 7.88443983e-02f, -1.56613942e-02f, 9.43091139e-02f,
  7.44319931e-02f, 3.64244357e-02f, -3.91885005e-02f, 4.87254709e-02f, -4.49639335e-02f, -1.64737534e-02f, -7.00806528e-02f, -2.10496895e-02f, -5.54424385e-03f, -1.96420252e-02f,
  1.49309576e-01f, -9.05515477e-02f, -8.97112712e-02f, 2.23045684e-02f, -2.22688615e-02f, 1.01760112e-01f, 1.74281403e-01f, -1.90340459e-01f, -1.39274329e-01f, -3.57492827e-02f,
  3.25395241e-02f, -2.42700800e-02f, 1.14504121e-01f, 5.47310598e-02f, 2.59838223e-01f, 5.37118204e-02f, -3.58604901e-02f, 1.09023049e-01f, -1.05766878e-01f, -1.02359354e-01f,
  -3.33304890e-02f, 1.19184226e-01f, 1.59951691e-02f, -7.53944889e-02f, 6.28027394e-02f, -2.05164894e-01f, -2.52298750e-02f, -8.45752209e-02f, 8.51424858e-02f, 1.38548404e-01f,
  1.71248540e-02f, 2.81116576e-03f, -1.33316480e-02f, -6.27595857e-02f, -1.61547512e-02f, 6.47111312e-02f, 2.86089033e-02f, 4.81096329e-04f, -5.25288433e-02f, -9.62787494e-02f,
  2.76713166e-02f, 3.82544920e-02f, 1.21784709e-01f, -1.82859618e-02f, 2.41693035e-02f, -5.17247654e-02f, 7.96143338e-03f, 4.37001279e-03f, -1.00428611e-02f, 3.45518664e-02f,
  -5.61247952e-03f, -2.37784069e-02f, -2.94203889e-02f, 3.40363360e-03f, -3.71892564e-02f, 3.78848203e-02f, 3.92064452e-02f, 7.03870133e-02f, 8.27909037e-02f, 3.89564522e-02f,
  -5.30769257e-03f, -2.17616744e-02f, -3.83408405e-02f, 2.03127135e-03f, -2.32220199e-02f, 5.18809035e-02f, -5.33922091e-02f, 2.59188563e-02f, 7.05447700e-03f, 8.03879946e-02f,
  -1.01363519e-02f, 6.42131343e-02f, -5.25328182e-02f, -2.71635670e-02f, 1.25716925e-01f, -5.84156513e-02f, -5.85710071e-02f, 8.07366669e-02f, -9.79537889e-03f, 2.20704321e-02f,
  -4.09167930e-02f, 3.15462947e-02f, 1.16984643e-01f, -6.95687979e-02f, 4.94749472e-02f, -6.97718933e-02f, -3.41119952e-02f, -7.88957328e-02f, 2.43392307e-02f, -9.79667380e-02f,
  -2.21086238e-02f, -8.32605585e-02f, -3.35453488e-02f, -7.87651073e-03f, 9.91567895e-02f, -2.98418589e-02f, -4.24067192e-02f, 2.50107441e-02f, 1.95805747e-02f, 5.40893599e-02f,
  8.38138908e-03f, -2.56940257e-02f, -7.00672567e-02f, -7.72519186e-02f, 3.89270633e-02f, -1.30774491e-02f, 8.40342864e-02f, -6.88391924e-02f, 5.48650697e-02f, 4.82650734e-02f,
  -5.36598824e-02f, 3.48142684e-02f, 5.57570904e-02f, 9.73719358e-02f, 4.62888964e-02f, -3.27676237e-02f, 8.56887102e-02f, -4.98464182e-02f, 6.95890114e-02f, 2.40857825e-02f,
  -2.98802368e-02f, -2.15756685e-01f, -2.47701123e-01f, -1.47855744e-01f, 1.53795213e-01f, -2.60647595e-01f, -2.92492300e-01f, -1.29491789e-02f, 1.94958188e-02f, 3.49883698e-02f,
  -1.46292403e-01f, -1.81563962e-02f, -2.26603895e-01f, -1.48276165e-01f, 2.36275699e-02f, -1.40563279e-01f, 7.51311257e-02f, -2.64058299e-02f, -8.68161544e-02f, -3.92165296e-02f,
  -3.40852179e-02f, 1.19671844e-01f, -1.27715513e-01f, 1.07157260e-01f, -2.39959452e-02f, 4.76769693e-02f, 2.59419382e-01f, -1.02778852e-01f, 1.28710821e-01f, -8.08692785e-05f,
  4.94349785e-02f, -8.39513075e-03f, -1.33940995e-01f, 6.61260216e-03f, 2.65543535e-02f, 2.28752065e-02f, 4.13384326e-02f, -5.05639687e-02f, -7.68134966e-02f, -4.81813885e-02f,
  1.98782552e-02f, 3.07380296e-02f, -8.24050326e-03f, -4.64854762e-02f, -1.50019526e-02f, -5.09440340e-02f, -7.22092763e-02f, 1.11535944e-01f, -6.72592819e-02f, -4.29545902e-02f,
  -7.22925588e-02f, 1.67444482e-01f, 7.24728331e-02f, 9.71261412e-02f, -7.05852956e-02f, 5.38068311e-03f, -5.45853712e-02f, -6.75110295e-02f, 6.58356175e-02f, 3.36099043e-02f,
  3.48939896e-02f, 7.62154236e-02f, -6.88850582e-02f, 1.88482497e-02f, 1.58514660e-02f, -3.76396477e-02f, -1.32864313e-02f, -6.28487989e-02f, -9.58567858e-02f, -6.89888299e-02f,
  -1.37656815e-02f, -8.95810351e-02f, 8.61831382e-02f, -1.35895750e-02f, 3.45478654e-02f, -4.05112617e-02f, 2.19628885e-02f, -3.04195192e-02f, 3.80415656e-02f, 2.39050873e-02f,
  -4.72877547e-02f, 1.48329837e-02f, 7.01760054e-02f, 2.17320211e-02f, -4.76622880e-02f, 2.43362896e-02f, 3.88492048e-02f, -1.01190023e-01f, -2.70861387e-02f, -5.50934784e-02f,
  8.15192088e-02f, 1.38463024e-02f, 2.84992401e-02f, 2.48555616e-02f, -1.06043756e-01f, 4.16556746e-02f, 4.72004712e-02f, -5.07264072e-03f, 4.95431535e-02f, 9.38400626e-03f,
  -1.76296234e-02f, 1.01036720e-01f, 1.86537668e-01f, -3.19653600e-02f, -3.83654721e-02f, -1.47541342e-02f, 4.31584800e-03f, 9.23864394e-02f, 6.40830249e-02f, 1.17115669e-01f,
  -9.97342053e-04f, 2.35032775e-02f, 8.58629420e-02f, -6.31073341e-02f, 1.27719373e-01f, 3.42255421e-02f, 1.22830682e-01f, -5.50355129e-02f, 5.79953305e-02f, -1.29110822e-02f,
  -1.74192145e-01f, -1.35709554e-01f, -6.36051446e-02f, -1.38545707e-01f, 1.26221284e-01f, -1.53944001e-01f, -3.43011059e-02f, -1.03683978e-01f, -1.06194712e-01f, 3.27666965e-03f,
  8.43822062e-02f, -5.78134507e-02f, 2.29817368e-02f, -2.48325989e-01f, 1.08665517e-02f, -2.96271387e-02f, -1.60704315e-01f, -7.86341634e-03f, -9.79333073e-02f, -1.86005067e-02f,
  -1.70416683e-01f, -1.47205532e-01f, -7.55095296e-03f, 1.41054997e-02f, -7.93597102e-02f, -1.60326257e-01f, 1.08742982e-01f, 1.69704974e-01f, -1.46502480e-01f, 1.69013701e-02f,
  -1.02671497e-01f, 7.13845296e-03f, -7.12031126e-02f, -3.44668627e-02f, -8.19428191e-02f, -4.59279530e-02f, 1.07987234e-02f, 1.42148092e-01f, -2.24208497e-02f, -9.37413797e-02f,
  5.48333907e-03f, 9.47846565e-03f, -2.98063252e-02f, -5.14760390e-02f, 1.13807293e-02f, -1.09197490e-01f, 6.65023131e-03f, -6.88455254e-02f, -1.31137252e-01f, 4.56292480e-02f,
  7.41745085e-02f, -1.03974618e-01f, 3.94969471e-02f, -4.54215445e-02f, 5.14822118e-02f, -9.17479843e-02f, -1.19706281e-01f, -4.90373522e-02f, 6.26033396e-02f, 5.66151440e-02f,
  -2.67443266e-02f, -7.46251345e-02f, -5.97926378e-02f, 1.39178876e-02f, 1.08385228e-01f, 1.52543234e-03f, 2.56749503e-02f, 1.73503339e-01f, -8.01002830e-02f, -4.63973591e-03f,
  -1.08054861e-01f, 3.74914780e-02f, -1.01705350e-01f, -4.55656946e-02f, 4.47641425e-02f, -1.36593878e-02f, -9.81110334e-02f, 1.72516733e-01f, -9.67924744e-02f, -6.46810085e-02f,
  7.59471953e-02f, 1.12890892e-01f, 1.02367125e-01f, -9.20789763e-02f, -8.40431228e-02f, -1.56657975e-02f, 4.46732864e-02f, -4.88280207e-02f, 5.17517254e-02f, 2.31748819e-02f,
  2.81409230e-02f, 3.90323363e-02f, 2.87218336e-02f, 9.20766890e-02f, -1.56917442e-02f, 1.79553237e-02f, 4.00916897e-02f, -2.28144340e-02f, 1.18861925e-02f, -1.72172673e-02f,
  2.64962204e-02f, -6.70074672e-02f, 6.27831668e-02f, -1.01078175e-01f, 5.41488044e-02f, -4.00206409e-02f, 4.16752435e-02f, -4.22460884e-02f, 4.73377965e-02f, 7.21683800e-02f,
  5.51261716e-02f, -3.21744056e-03f, 2.53788438e-02f, -8.95805135e-02f, -8.62677302e-03f, 1.00932391e-02f, -1.10149428e-01f, 3.58050242e-02f, -3.08707282e-02f, -2.40390026e-03f,
  4.78938855e-02f, 2.06357360e-01f, 1.66190371e-01f, 1.64066866e-01f, 3.19818817e-02f, -2.22508550e-01f, -1.58743128e-01f, 1.97294593e-01f, 6.41664118e-02f, -8.55589285e-02f,
  5.29867038e-02f, 1.46696940e-01f, 3.98146398e-02f, 1.05603911e-01f, -9.35723037e-02f, -4.64952104e-02f, 5.05305268e-02f, -5.02883121e-02f, 5.32143898e-02f, 4.83100340e-02f,
  1.06286325e-01f, 2.47656438e-03f, 8.55417624e-02f, 1.25817759e-02f, 1.05977893e-01f, 9.81357470e-02f, 1.72364026e-01f, -6.96574599e-02f, 8.96857530e-02f, -1.36336729e-01f,
  8.63296352e-03f, 1.08032495e-01f, -9.10943549e-04f, -1.26197770e-01f, -4.10183147e-02f, -5.73343597e-02f, -1.23355389e-02f, 2.95770844e-03f, -2.14246903e-02f, 3.10751088e-02f,
  4.76935245e-02f, -8.60383138e-02f, -4.58691195e-02f, -3.34428214e-02f, 1.24222571e-02f, -8.98660719e-02f, 1.53905064e-01f, 2.33655721e-02f, -5.22207208e-02f, 2.50491477e-03f,
  4.58951816e-02f, -5.71586490e-02f, 2.82308906e-02f, -1.50895091e-02f, 3.04227024e-02f, -4.52966914e-02f, -6.63361996e-02f, 6.10572696e-02f, 2.45205760e-02f, -6.72458038e-02f,
  -6.22758195e-02f, -2.16755290e-02f, 6.50875494e-02f, -5.01160845e-02f, 3.05077937e-02f, 1.37253469e-02f, 3.99747714e-02f, 1.99606027e-02f, -9.09128711e-02f, -5.10830171e-02f,
  4.50227484e-02f, -1.69355348e-02f, 6.83978200e-02f, 5.84822334e-02f, 6.31627440e-02f, 1.92354005e-02f, 4.30368539e-03f, 3.73665318e-02f, -4.03688895e-03f, 1.14333697e-01f,
  -3.80681339e-03f, 4.21940535e-02f, -2.69106477e-02f, -2.31133569e-02f, -6.78169727e-02f, 1.96868163e-02f, 1.08594649e-01f, 3.26700844e-02f, 1.74928568e-02f, -3.26177888e-02f,
  7.09037781e-02f, 1.64518416e-01f, 5.44040240e-02f, -7.99154788e-02f, -1.42508090e-01f, -5.67194447e-02f, -2.92067025e-02f, 7.11818486e-02f, 3.76829617e-02f, 6.11204095e-02f,
  5.10973521e-02f, -3.76673304e-02f, 7.50612468e-02f, 5.40715344e-02f, -7.98556581e-02f, 5.33834286e-02f, -3.01413182e-02f, -3.93218547e-03f, 6.37190863e-02f, 4.58457358e-02f,
  1.65493816e-01f, -9.62214544e-03f, -3.01185250e-02f, -6.74192682e-02f, 3.31924744e-02f, -3.14309411e-02f, 2.91834585e-02f, -2.99313441e-02f, 9.47093070e-02f, 8.71038623e-03f,
  -1.90177232e-01f, -7.87316710e-02f, -4.43182774e-02f, -9.72434655e-02f, 1.49356723e-01f, -1.17918819e-01f, 4.05768305e-02f, 1.15870945e-01f, -8.29743445e-02f, 4.93298918e-02f,
  3.26167457e-02f, -6.83793575e-02f, 2.80261096e-02f, -3.29288036e-01f, -3.04006904e-01f, -2.19220340e-01f, -1.93539709e-01f, -1.98224485e-01f, -1.96438193e-01f, 1.43787652e-01f,
  2.48656608e-02f, -6.68044016e-02f, -7.12016299e-02f, 1.12585343e-01f, 3.63516994e-02f, 1.98512107e-01f, 1.74838319e-01f, 1.33681193e-01f, 1.02520511e-01f, -2.39053909e-02f,
  4.87884553e-03f, 1.98744964e-02f, 5.47625907e-02f, -1.32675664e-02f, 2.99405474e-02f, 1.04416810e-01f, 3.34886871e-02f, 8.06864649e-02f, 1.43274516e-01f, 3.20631056e-03f,
  -9.31285769e-02f, 4.54098508e-02f, -8.95752311e-02f, -3.21814045e-02f, 7.68808872e-02f, -6.69378340e-02f, -9.65286046e-03f, -2.95599457e-02f, 1.88534241e-02f, -2.15310425e-01f,
  1.01027153e-02f, -3.56529392e-02f, -3.37887183e-02f, -4.86217849e-02f, 3.11938878e-02f, -1.88343506e-02f, -1.55719267e-02f, 8.12456831e-02f, 2.83901729e-02f, -1.21876374e-02f,
  2.41535436e-02f, -7.97351897e-02f, -8.65618065e-02f, -7.69643635e-02f, -6.72849193e-02f, 2.04221327e-02f, -1.65849164e-01f, -2.07714234e-02f, 2.83266213e-02f, 5.85865453e-02f,
  7.91358426e-02f, -3.66971153e-03f, 2.01380849e-02f, 1.11731090e-01f, 1.00248165e-01f, 3.04186959e-02f, 9.53758508e-02f, 9.35503840e-03f, -1.16118463e-02f, 8.32206160e-02f,
  -5.69003373e-02f, 6.74864161e-04f, -2.33603436e-02f, 3.38600576e-02f, -7.10063940e-03f, -1.36990717e-03f, -4.07905690e-02f, 5.77068254e-02f, -2.20260303e-02f, -5.64911775e-02f,
  8.62760395e-02f, 3.99364419e-02f, 1.48409489e-03f, 6.00336269e-02f, -3.12014837e-02f, -2.58287694e-02f, -7.01528639e-02f, 4.90462990e-04f, 8.38452764e-03f, -9.37635303e-02f,
  1.35352388e-01f, 6.15129992e-02f, -3.50410715e-02f, 3.24696340e-02f, 4.08649519e-02f, -4.54294235e-02f, 9.88046080e-02f, 5.87839708e-02f, 1.07303582e-01f, -1.93127990e-02f,
  -2.67313290e-02f, -3.93624082e-02f, -4.08598687e-03f, -8.47733230e-04f, -2.42589973e-02f, -7.94480368e-02f, 5.43224066e-02f, 8.71803686e-02f, -8.25634673e-02f, -2.60565635e-02f,
  6.16133623e-02f, -2.50422899e-02f, -1.67060673e-01f, -5.43253906e-02f, 7.90511817e-03f, 2.45361447e-01f, 1.79769397e-01f, -4.91409898e-02f, -1.56539634e-01f, 2.03432478e-02f,
  1.21761762e-01f, 5.56720495e-02f, -6.30344972e-02f, 2.77733356e-01f, 2.39943534e-01f, -5.82930669e-02f, 1.88258544e-01f, 9.12280455e-02f, -1.46837786e-01f, 1.44090075e-02f,
  -2.13615671e-02f, 2.98935831e-01f, -1.37902603e-01f, -1.55072641e-02f, 1.16460457e-01f, -2.22384721e-01f, 6.31127134e-02f, -1.03562891e-01f, 7.04049841e-02f, 2.11319864e-01f,
  1.22707663e-02f, -2.91870311e-02f, 3.61095294e-02f, -1.21280570e-02f, 4.17955667e-02f, -5.02731046e-03f, 3.34948376e-02f, 5.98360263e-02f, -9.89799798e-02f, 2.53882762e-02f,
  -3.04888245e-02f, -3.62823308e-02f, 4.79416065e-02f, 5.61365187e-02f, 3.49971578e-02f, -1.22086644e-01f, 5.41523397e-02f, -3.72428969e-02f, -4.79004420e-02f, -1.73456706e-02f,
  5.27741504e-04f, -3.03243417e-02f, -5.56856059e-02f, -5.39748557e-02f, -7.88005069e-02f, 8.78513604e-02f, -6.57038689e-02f, 9.99661352e-05f, 4.12880704e-02f, -1.61303375e-02f,
  3.52969281e-02f, 2.36721523e-02f, -7.16201868e-03f, 5.80655746e-02f, -3.60970572e-02f, 2.59119384e-02f, -7.58839026e-03f, -4.35835123e-02f, 8.35729018e-03f, -4.07503992e-02f,
  2.98506133e-02f, 5.74162267e-02f, 3.21052261e-02f, -4.22162749e-02f, -2.97563467e-02f, 4.89137024e-02f, 4.21994785e-03f, 4.92473915e-02f, -6.89691156e-02f, -9.49002877e-02f,
  -5.81066385e-02f, 7.32105374e-02f, 9.16832220e-03f, 4.26512659e-02f, -4.35827374e-02f, -6.91707656e-02f, 4.73096408e-02f, 8.95088259e-03f, -6.96564913e-02f, 4.15830798e-02f,
  1.06203377e-01f, 6.68127015e-02f, -1.14103332e-01f, -1.28735481e-02f, -1.07078038e-01f, 9.45840850e-02f, 7.29977712e-02f, -4.92547378e-02f, -6.62648976e-02f, -8.73368513e-03f,
  -3.55443079e-03f, 5.07120602e-02f, 3.66981737e-02f, 5.22818267e-02f, -3.48208249e-02f, -3.34789255e-03f, -6.13965727e-02f, -4.81024683e-02f, -4.08737659e-02f, -4.46632393e-02f,
  -1.75231770e-02f, 5.89083470e-02f, -6.34590685e-02f, 1.69160701e-02f, -6.94560865e-03f, 6.65352447e-03f, -2.29246262e-02f, -7.62613341e-02f, 4.21530120e-02f, -5.75470626e-02f,
  1.32386729e-01f, 3.71890292e-02f, -7.74890259e-02f, -5.56912981e-02f, -2.90546962e-03f, 2.44981106e-02f, -1.16975624e-02f, 1.19520985e-01f, -1.34641126e-01f, 4.24414836e-02f,
  4.99557666e-02f, -7.42532238e-02f, -2.02523425e-01f, -3.72786517e-03f, -4.17106412e-03f, -2.36240640e-01f, 2.23055005e-01f, -7.22142914e-03f, -8.44254568e-02f, 1.87066257e-01f,
  -6.80646999e-03f, 9.51468721e-02f, 3.01173367e-02f, 1.78197384e-01f, 1.03594765e-01f, -6.66714087e-03f, 2.71971524e-01f, -7.25972429e-02f, 2.11331651e-01f, 5.93660139e-02f,
  9.81116667e-03f, -4.08395678e-02f, 5.20201921e-02f, -7.72564188e-02f, -7.22327009e-02f, 8.11468363e-02f, 6.38433322e-02f, 6.65685609e-02f, 5.15625142e-02f, -4.19084653e-02f,
  -1.12710409e-02f, 8.18274617e-02f, 5.77179007e-02f, -1.34238914e-01f, 7.05379844e-02f, 1.70523860e-02f, -7.21065253e-02f, -1.09757654e-01f, -2.79116840e-03f, 8.99649749e-04f,
  -6.61416277e-02f, 1.93716245e-04f, 5.85724004e-02f, -2.12352332e-02f, -9.39224139e-02f, -1.43164853e-02f, 6.58517554e-02f, -4.15073000e-02f, 1.13366842e-02f, 3.50718163e-02f,
  5.45109250e-02f, 9.84060019e-02f, 1.19508527e-01f, 4.48106341e-02f, -4.38379571e-02f, -3.93745452e-02f, -1.51082752e-02f, -3.89224477e-02f, -2.24031471e-02f, 1.31264236e-02f,
  -1.19850794e-02f, 6.52864873e-02f, -2.69317087e-02f, 1.13872357e-01f, 5.83059750e-02f, 4.76735979e-02f, 1.82566866e-02f, 3.97944674e-02f, -4.48136702e-02f, -7.56576508e-02f,
  -2.46706866e-02f, -1.74380299e-02f, -3.70069705e-02f, 7.61521012e-02f, -9.14185718e-02f, -3.02677508e-02f, 6.40089810e-02f, 6.84949681e-02f, -5.01023717e-02f, 1.00721665e-01f,
  1.20769039e-01f, 1.03298753e-01f, -1.50634805e-02f, 6.14532866e-02f, -3.97773087e-02f, -1.52650932e-02f, -5.80346249e-02f, 8.64903778e-02f, 3.58896703e-02f, 7.01266387e-03f,
  1.18646726e-01f, 6.82884380e-02f, 9.21059698e-02f, -3.66482623e-02f, -4.71107624e-02f, 4.47321795e-02f, -7.04994425e-02f, -6.48267269e-02f, -8.84524826e-03f, -5.48477508e-02f,
  6.38362467e-02f, 1.07232764e-01f, -9.01518688e-02f, -7.79687390e-02f, -3.82245220e-02f, 4.83356193e-02f, 5.26525266e-02f, -5.00544123e-02f, 5.55009879e-02f, 4.27801125e-02f,
  4.00560141e-01f, -3.74601856e-02f, -1.27966292e-02f, 2.93935746e-01f, 4.31179404e-02f, 7.95431659e-02f, -7.27339014e-02f, 1.17409989e-01f, 3.08955401e-01f, -1.81085110e-01f,
  -1.08721266e-02f, -1.39215663e-01f, -1.35703191e-01f, 1.66834161e-01f, 6.03026152e-02f, -2.40913909e-02f, 5.64188547e-02f, -7.41329715e-02f, 8.73895511e-02f, -6.38879091e-02f,
  1.97859421e-01f, 1.94496855e-01f, -1.22416481e-01f, 3.69301178e-02f, 3.18277888e-02f, 1.09079041e-01f, -3.89573090e-02f, -2.16719225e-01f, 2.57711429e-02f, 9.67537332e-03f,
  -6.63495064e-02f, -2.98301354e-02f, 6.74587041e-02f, 5.46997525e-02f, -7.10735917e-02f, -3.57669182e-02f, -9.60978493e-02f, -3.06406077e-02f, 1.36455428e-03f, -5.58622964e-02f,
  4.33274433e-02f, -5.75656071e-02f, 7.62357637e-02f, -2.53407601e-02f, 1.05163362e-02f, 3.21257254e-03f, 7.90171474e-02f, -5.48228212e-02f, -7.84891322e-02f, 8.55003856e-03f,
  -2.21402943e-02f, -8.56092572e-02f, -5.61105013e-02f, 1.29537554e-02f, 7.87601713e-03f, 3.21164355e-02f, -4.57311682e-02f, -3.69179696e-02f, 8.88703689e-02f, 1.11250570e-02f,
  -4.56506610e-02f, 2.96574626e-02f, 5.63749410e-02f, 6.56157956e-02f, 1.06464028e-02f, 1.67923805e-03f, 8.97398517e-02f, -5.82255563e-03f, 8.52911025e-02f, -8.46896600e-03f,
  5.02437279e-02f, 1.86144337e-02f, 1.28455728e-01f, -5.41751720e-02f, 5.96672818e-02f, -7.69552290e-02f, 1.80899035e-02f, 5.56095429e-02f, 7.38536194e-03f, 5.75377094e-03f,
  -2.50522029e-02f, -2.79126712e-03f, -8.49599317e-02f, -9.54047814e-02f, -1.47321876e-02f, -7.45754763e-02f, -1.32776247e-02f, -1.25235664e-02f, -5.14923744e-02f, -7.97354206e-02f,
  2.67879404e-02f, 3.10559738e-02f, -5.14149815e-02f, 5.43623120e-02f, -1.15263596e-01f, 6.71342313e-02f, -2.11643595e-02f, 6.62971064e-02f, 3.14869992e-02f, 3.95527184e-02f,
  -1.10678196e-01f, 1.72457211e-02f, -7.31228516e-02f, 6.49237409e-02f, 5.57653280e-03f, -3.83426584e-02f, 3.35719064e-02f, 6.56497627e-02f, -2.82029398e-02f, -3.15641914e-03f,
  -9.54776555e-02f, -7.46718422e-02f, 4.71387932e-04f, -6.60177618e-02f, 9.59374458e-02f, -3.36276069e-02f, -3.17735523e-02f, -2.23450232e-02f, -3.66764888e-02f, 2.43851934e-02f,
  4.52004373e-02f, 2.88736105e-01f, 1.55277163e-01f, 2.95319468e-01f, -1.09168351e-01f, -2.75101066e-01f, -1.27071902e-01f, 1.70410927e-02f, -1.29703023e-02f, -6.92719594e-02f,
  -1.31453369e-02f, 2.05186486e-01f, -1.22524269e-01f, 1.59867685e-02f, 9.42635760e-02f, -2.03412268e-02f, 8.64849687e-02f, -2.84729106e-03f, 1.24418095e-01f, 9.05638486e-02f,
  5.52316681e-02f, 8.95688660e-04f, 1.90552175e-01f, 8.54786113e-02f, -9.72806662e-02f, 1.03085771e-01f, 2.38746479e-01f, 1.02530122e-01f, 1.40749225e-02f, 4.01066914e-02f,
  -1.73671275e-01f, -4.17968119e-03f, -6.67826738e-03f, -6.19405881e-02f, -8.66550207e-02f, -1.16705924e-01f, -7.34585747e-02f, -5.62364608e-02f, 3.35829444e-02f, -1.26297325e-01f,
  -1.51746333e-01f, -4.44510765e-02f, -4.37719859e-02f, -1.14603803e-01f, 5.70282480e-03f, -3.51974852e-02f, -3.61338928e-02f, -2.05559283e-02f, 4.47098501e-02f, -7.91395903e-02f,
  9.04916301e-02f, -2.80624684e-02f, -2.41424348e-02f, -7.51798525e-02f, -2.25047041e-02f, 6.31310567e-02f, -1.74766015e-02f, -7.32611120e-02f, -1.86402928e-02f, -1.44621395e-02f,
  -2.76517309e-02f, -6.28509149e-02f, 7.81618617e-03f, 1.29525317e-02f, -1.31281195e-04f, -5.78221157e-02f, 2.55516618e-02f, 3.75198871e-02f, -4.26624231e-02f, 3.53329964e-02f,
  -7.78615251e-02f, 4.96428125e-02f, -3.11817136e-02f, 1.73765272e-02f, 4.87958230e-02f, 1.85142700e-02f, 4.62781936e-02f, 1.57844555e-02f, -3.21292765e-02f, 2.46042777e-02f,
  6.19238243e-04f, -3.94628718e-02f, 7.59888440e-02f, -1.16078146e-02f, 3.00184768e-02f, -8.54516178e-02f, -5.73018612e-03f, 9.41934902e-03f, 5.56383133e-02f, -5.31010851e-02f,
  1.21322656e-02f, 2.35417351e-01f, 7.35208243e-02f, -7.57149905e-02f, -4.27121371e-02f, 3.36819887e-02f, 9.19478887e-04f, -2.05913801e-02f, 2.29104366e-02f, 7.56635368e-02f,
  -2.70734318e-02f, -1.61542483e-02f, 5.45836017e-02f, -2.91876085e-02f, 1.69889107e-02f, -7.19116777e-02f, -2.22982243e-02f, -3.58030498e-02f, 1.95504595e-02f, -1.90011393e-02f,
  6.33486584e-02f, -4.58746105e-02f, -1.68644134e-02f, 2.09597275e-02f, 3.52607146e-02f, -1.23317920e-01f, -1.30903730e-02f, 9.67079774e-02f, -1.14665246e-02f, 7.61856958e-02f,
  -7.87461996e-02f, 9.17586684e-02f, -1.06035531e-01f, 2.60273255e-02f, -4.64228690e-02f, 4.13359031e-02f, 1.12361766e-01f, -3.52922864e-02f, -1.29835963e-01f, 2.38287255e-01f,
  1.98962286e-01f, -9.21197757e-02f, 1.31085262e-01f, 3.61263543e-01f, -6.89608827e-02f, 1.48488268e-01f, 2.23606601e-01f, 9.76141691e-02f, -1.15797132e-01f, 9.12476704e-02f,
  -6.02430776e-02f, 2.11458430e-01f, 1.09375522e-01f, 4.02609743e-02f, 2.34049410e-02f, -2.44332552e-02f, 9.43453610e-02f, -2.31699180e-03f, 1.29195899e-01f, 1.33715756e-02f,
  1.07113495e-01f, 9.78854075e-02f, -2.53982353e-03f, 2.73851193e-02f, 3.21267135e-02f, 8.48271847e-02f, 7.26882815e-02f, -6.89710081e-02f, 5.06639816e-02f, -2.96367481e-02f,
  2.55982708e-02f, -3.35646421e-02f, -5.17539605e-02f, 7.91196376e-02f, 2.73485836e-02f, 1.74976978e-02f, -8.53303820e-02f, -8.21104050e-02f, -4.43457440e-02f, 4.74161617e-02f,
  1.00285038e-02f, -2.06078775e-02f, 2.74386760e-02f, -1.68180820e-02f, -8.67495462e-02f, 7.82535225e-02f, -9.95283052e-02f, -6.35391921e-02f, -1.14863306e-01f, -1.29581273e-01f,
  9.69717205e-02f, 1.55820884e-03f, -7.09482804e-02f, 4.59665954e-02f, -7.02917203e-02f, 2.01600287e-02f, -5.36242165e-02f, 1.17036819e-01f, -9.83960405e-02f, 1.32266313e-01f,
  4.42195721e-02f, 5.22301942e-02f, 4.26294431e-02f, 5.80971204e-02f, 2.06391085e-02f, 3.87639478e-02f, 5.09503521e-02f, 1.25010656e-02f, -6.61814678e-03f, -5.01022115e-02f,
  3.06210443e-02f, -2.83502713e-02f, -5.32874875e-02f, 2.62301583e-02f, -4.19767834e-02f, -2.16802787e-02f, 2.37421854e-03f, 4.15251963e-02f, -2.54672603e-03f, -3.68270986e-02f,
  6.16211742e-02f, 6.55225217e-02f, -3.01416013e-02f, 4.27205488e-02f, -3.21378447e-02f, -5.62499203e-02f, -5.79034090e-02f, 4.32233177e-02f, -5.78943118e-02f, 3.20052579e-02f,
  3.86718214e-02f, 3.25598270e-02f, 2.70974915e-02f, 1.08843088e-01f, -5.52069768e-02f, 7.44708627e-02f, 1.53660566e-01f, -5.94227435e-03f, -5.03870025e-02f, -1.07987732e-01f,
  -2.83952188e-02f, 8.73917015e-05f, -1.00421704e-01f, -1.05893716e-01f, -3.88692915e-02f, -6.73558265e-02f, -1.29694253e-01f, -9.99528468e-02f, 2.53462419e-02f, -8.41238573e-02f,
  -1.83878988e-01f, -9.26583037e-02f, -2.26265535e-01f, -1.79294243e-01f, 7.72981420e-02f, -1.10209830e-01f, -1.71017364e-01f, 5.47518060e-02f, 8.82981643e-02f, 6.57916889e-02f,
  -1.26865104e-01f, -1.28677502e-01f, 4.20675799e-02f, -3.65693420e-01f, -3.31820101e-01f, -1.72688901e-01f, -2.64071047e-01f, -1.08532071e-01f, 8.87037888e-02f, -1.09348092e-02f,
  -7.67199621e-02f, -2.06942797e-01f, -2.33747631e-01f, 1.19816743e-01f, -6.92427084e-02f, 7.89091140e-02f, 3.92204896e-02f, 5.08424379e-02f, -9.24091600e-03f, -5.32082990e-02f,
  -8.74381065e-02f, 2.18127668e-02f, 4.28974889e-02f, -5.17188385e-02f, -5.36164865e-02f, 8.45792796e-03f, -3.32274809e-02f, -6.02115970e-03f, 2.15751734e-02f, -4.39458666e-03f,
  -1.08921163e-01f, -6.59535378e-02f, 5.67897223e-03f, -6.08163103e-02f, -1.01079054e-01f, 1.11813165e-01f, 5.50820082e-02f, -3.49259190e-02f, 9.80893746e-02f, 2.46080942e-02f,
  -1.12631097e-01f, 2.85598896e-02f, -4.58203591e-02f, 4.83324938e-02f, 7.08231628e-02f, 2.35144906e-02f, -7.75402831e-03f, 2.00647600e-02f, -5.85870408e-02f, 3.76409404e-02f,
  -2.49820501e-02f, 5.37971184e-02f, 9.43603069e-02f, -3.24169931e-04f, 8.60012025e-02f, 7.37928674e-02f, -9.74739641e-02f, 9.53971520e-02f, 1.52693680e-02f, -7.34668225e-02f,
  6.52094139e-03f, -5.88629954e-02f, 2.05028411e-02f, 2.96173878e-02f, -5.69846071e-02f, 8.44820887e-02f, -2.11607963e-02f, -5.98011389e-02f, -8.36812854e-02f, 3.47036906e-02f,
  6.27433881e-02f, -3.91857401e-02f, 1.13106216e-06f, -2.91593857e-02f, 1.54669369e-02f, -3.73342223e-02f, -5.10937087e-02f, 7.79225677e-03f, -3.96031998e-02f, 7.49972975e-03f,
  5.64624257e-02f, 1.50615469e-01f, 5.72747700e-02f, -1.39965806e-02f, 5.91966398e-02f, 2.09008344e-02f, -2.30697989e-02f, -7.12407827e-02f, -5.22024855e-02f, 6.20508380e-02f,
  -1.07342089e-02f, -7.15077966e-02f, -6.44260421e-02f, -4.83033024e-02f, 2.71568857e-02f, 7.64878700e-03f, -2.90566832e-02f, -6.04338804e-03f, -3.53042893e-02f, 3.80038545e-02f,
  8.77240822e-02f, 1.10519521e-01f, -3.50696743e-02f, 1.17122745e-02f, -1.12615097e-02f, 3.01814638e-02f, 9.55780149e-02f, 3.34576555e-02f, -3.63496877e-02f, -7.83711970e-02f,
  6.85282499e-02f, 1.77137405e-02f, 1.58556029e-01f, 2.19816610e-01f, -2.11257301e-02f, -2.45655745e-01f, -3.03780973e-01f, 1.21770427e-01f, -5.03138080e-02f, -1.51846334e-01f,
  -6.63433149e-02f, 6.49114028e-02f, -2.27033034e-01f, 4.70313653e-02f, 1.63903847e-01f, -1.67820066e-01f, 4.72685732e-02f, -1.11459754e-02f, 9.47869122e-02f, 1.78648904e-01f,
  1.90368459e-01f, 5.55304624e-02f, 1.04611583e-01f, 6.82770982e-02f, 1.48372287e-02f, 8.33663866e-02f, 2.43669599e-01f, 2.56787091e-02f, 1.66088790e-01f, -8.39057378e-03f,
  -1.46090806e-01f, 7.53773302e-02f, -4.16960977e-02f, -7.23110884e-02f, 7.46309608e-02f, -1.11786788e-02f, 1.26395011e-02f, 8.64446629e-03f, 8.87147188e-02f, -3.98029126e-02f,
  -6.26487732e-02f, 6.83724508e-02f, 2.34303921e-02f, -7.13495985e-02f, 1.11214314e-02f, 1.28778130e-01f, -4.00021896e-02f, 3.94709263e-04f, 6.38030991e-02f, -4.40792404e-02f,
  6.21271133e-02f, 4.90829833e-02f, 1.04677472e-02f, -2.54638828e-02f, 1.83162704e-01f, 4.57682833e-02f, 6.41865581e-02f, 4.09922823e-02f, -7.97175523e-03f, 6.65907487e-02f,
  -6.13626428e-02f, 3.62921879e-02f, 3.93711105e-02f, -1.77480150e-02f, -4.90062907e-02f, 5.41863292e-02f, -3.97039279e-02f, 2.14155577e-02f, 3.15029211e-02f, -6.85116556e-03f,
  -3.46183069e-02f, 4.13322672e-02f, -2.40999106e-02f, -7.91738108e-02f, 7.14146346e-02f, -6.91087097e-02f, -7.24834651e-02f, 2.02948991e-02f, -1.08559588e-02f, -3.14796753e-02f,
  1.39376307e-02f, -4.51552980e-02f, -2.68347878e-02f, -1.00804798e-01f, 4.48949412e-02f, -8.04188254e-04f, -4.81130257e-02f, 3.92978378e-02f, 1.19648181e-01f, 5.01381569e-02f,
  -9.74466503e-02f, 1.08711161e-01f, -1.87158678e-02f, -2.52435245e-02f, 4.48228493e-02f, -9.39237699e-03f, 7.27517381e-02f, 1.06790168e-02f, -3.70394848e-02f, -6.95583299e-02f,
  3.01175676e-02f, 4.52871658e-02f, 2.00673677e-02f, 3.61738279e-02f, 1.82753615e-02f, -1.48977991e-02f, 3.39040048e-02f, -8.93172324e-02f, -2.15210835e-03f, 4.60489690e-02f,
  -2.29598284e-02f, -5.00774607e-02f, 9.36979502e-02f, 2.72220317e-02f, -1.06599974e-03f, -5.04816771e-02f, -5.45124989e-03f, -9.58458632e-02f, -3.80420908e-02f, -4.87662740e-02f,
  1.79561406e-01f, -1.20606996e-01f, -2.65457749e-01f, -1.36962608e-02f, 1.05694979e-01f, 2.58998442e-02f, -1.67131975e-01f, 9.95584205e-02f, -6.06070347e-02f, -7.47662038e-02f,
  1.38251111e-01f, -9.89419818e-02f, -7.13093653e-02f, 1.13618553e-01f, 2.11283714e-01f, -1.11699246e-01f, 9.42401588e-02f, 1.65574495e-02f, -9.06511955e-03f, 7.18510374e-02f,
  9.77936760e-02f, 1.35884851e-01f, -2.21677646e-02f, 1.11960426e-01f, 9.92510840e-02f, 3.09392530e-02f, 1.78889841e-01f, -1.13895699e-01f, 1.92985713e-01f, 1.04903668e-01f,
  -8.96849260e-02f, 1.67041887e-02f, -8.41899887e-02f, -3.31086069e-02f, -1.64284613e-02f, -7.99476579e-02f, -1.62307128e-01f, -6.15068562e-02f, -5.43413162e-02f, 6.21333420e-02f,
  -1.20069146e-01f, 9.19551626e-02f, 2.24770121e-02f, 1.73815538e-03f, -6.56539723e-02f, 1.29809618e-01f, 7.58415088e-02f, 9.43859592e-02f, -1.06818378e-01f, -1.60363186e-02f,
  -6.72896653e-02f, -3.98356542e-02f, 6.34369627e-02f, -5.05632609e-02f, -3.91203240e-02f, -4.51950654e-02f, 2.19941027e-02f, 1.13472361e-02f, -9.19596180e-02f, 1.21936209e-01f,
  -4.14962620e-02f, 1.23627055e-02f, -5.91928363e-02f, 9.89971012e-02f, 5.36379516e-02f, -9.85250175e-02f, -1.36092585e-02f, 3.28227356e-02f, -1.35612577e-01f, 8.14993605e-02f,
  -6.93454081e-03f, -1.15342401e-02f, -2.73608826e-02f, 6.63201287e-02f, -3.39783840e-02f, 1.31268427e-02f, -1.88115221e-02f, -5.66101149e-02f, -4.75761853e-02f, 4.81276736e-02f,
  -1.07355304e-02f, -3.14566381e-02f, -3.95828709e-02f, 2.68179458e-03f, -1.00265518e-02f, 4.50055934e-02f, 2.34084558e-02f, 6.68893754e-02f, -6.61688969e-02f, -8.79674312e-03f,
  8.97394195e-02f, 5.20741530e-02f, -6.00460805e-02f, -2.67097093e-02f, -4.01578471e-02f, 2.00996827e-02f, -4.90738265e-03f, 1.82191562e-02f, 2.52682511e-02f, -1.41453492e-02f,
  1.12757526e-01f, -6.85974881e-02f, 1.48969432e-02f, 6.37915209e-02f, -2.15848349e-02f, 1.41362354e-01f, 8.29108730e-02f, 2.74154288e-03f, 7.52961123e-03f, 6.58103749e-02f,
  6.89910948e-02f, -5.40352380e-03f, 4.76438813e-02f, 9.77822766e-02f, 1.04321770e-01f, -7.76332691e-02f, -3.63656767e-02f, 9.04902965e-02f, -2.70149093e-02f, -2.50917766e-02f,
  2.52340347e-01f, -7.03013092e-02f, -2.14599267e-01f, 4.17206585e-02f, 1.77181274e-01f, 8.59352723e-02f, -3.93873826e-02f, -5.60599891e-03f, -1.24337450e-01f, 6.73846528e-02f,
  -8.34623724e-03f, -1.58207357e-01f, -1.73317090e-01f, 1.33918319e-02f, 3.64941023e-02f, -2.41893053e-01f, 1.48051709e-01f, 2.63341074e-03f, -7.40759894e-02f, 6.96061999e-02f,
  -4.80675139e-02f, 2.18938023e-01f, -1.27162963e-01f, 2.07612321e-01f, 2.11480752e-01f, 4.88116480e-02f, 1.70749664e-01f, -1.17193565e-01f, 1.11930303e-01f, 2.33449973e-02f,
  -3.23621780e-02f, -4.35099788e-02f, -3.63154449e-02f, -4.93453965e-02f, 9.41742510e-02f, 1.77627653e-01f, 8.88805017e-02f, 6.25736341e-02f, 6.89746870e-04f, -1.36038899e-01f,
  3.33444704e-03f, 1.20086700e-01f, -5.10050282e-02f, -1.05162099e-01f, 1.07361227e-01f, -5.98357134e-02f, -1.14751965e-01f, 3.66853029e-02f, -5.53988516e-02f, -4.63172682e-02f,
  2.19586547e-02f, -1.06495127e-01f, -9.04091634e-03f, 3.68369557e-02f, -5.22272587e-02f, -3.36188599e-02f, -8.22661743e-02f, -6.53122291e-02f, 5.53813651e-02f, -2.47460268e-02f,
  6.44152388e-02f, -2.72542294e-02f, 5.86827621e-02f, 3.43131199e-02f, -3.10568418e-02f, 3.43230478e-02f, 5.63368239e-02f, -6.74712881e-02f, 4.32724394e-02f, -5.73671907e-02f,
  1.54857319e-02f, -5.09906597e-02f, 6.04871996e-02f, 2.60347445e-02f, 2.46784301e-04f, 7.67009854e-02f, -8.94702822e-02f, 3.56938988e-02f, -6.92326725e-02f, -8.01003501e-02f,
  3.54578979e-02f, 8.64884779e-02f, 4.48593963e-03f, -3.31099629e-02f, 1.52637064e-02f, -1.08874708e-01f, 1.03460409e-01f, -1.34094313e-01f, 3.33524719e-02f, 4.78821546e-02f,
  -4.21006978e-02f, 8.51648487e-03f, -4.79259557e-04f, -6.74546063e-02f, -5.85462749e-02f, 2.46048216e-02f, 8.79425183e-02f, 7.02668428e-02f, -1.65638104e-02f, -1.10547923e-01f,
  -1.87426545e-02f, 1.90389119e-02f, -3.43004689e-02f, -4.64852080e-02f, 7.36047626e-02f, -4.13134769e-02f, -4.88712825e-02f, -1.86553616e-02f, 1.01577818e-01f, -9.23350006e-02f,
  1.05997153e-01f, -8.34186971e-02f, 8.37289840e-02f, -3.43361534e-02f, 9.14368704e-02f, -4.65214588e-02f, 8.45396593e-02f, -5.29644899e-02f, 1.46100037e-02f, -7.44091570e-02f,
  6.66835085e-02f, -1.10425420e-01f, -1.83015704e-01f, 4.32545058e-02f, -1.75145045e-02f, 1.05609260e-01f, -7.84623027e-02f, 9.40973163e-02f, -1.30579770e-01f, 3.51820923e-02f,
  1.63633496e-01f, -6.90938532e-02f, -3.34347948e-03f, 1.93348706e-01f, 5.86315989e-02f, -2.78988760e-02f, 2.12356210e-01f, 5.45728914e-02f, 1.65039878e-02f, 1.05158985e-01f,
  1.53484628e-01f, 2.40708649e-01f, -6.93163425e-02f, 1.74960896e-01f, -1.62697639e-02f, 8.43094960e-02f, 5.48073202e-02f, -1.34148505e-02f, 1.98963821e-01f, 7.96753466e-02f,
  7.41003752e-02f, 4.25147228e-02f, -6.66053295e-02f, -2.16527749e-02f, 1.67625800e-01f, 1.34319076e-02f, 4.07780074e-02f, 2.88160853e-02f, -5.08060977e-02f, 1.23659097e-01f,
  -4.50410042e-03f, 2.84351152e-03f, 7.74496645e-02f, 1.46369739e-02f, -5.10088913e-02f, 3.71059999e-02f, -8.74147490e-02f, -2.75679491e-02f, 7.66576082e-02f, -7.53947198e-02f,
  -2.36941408e-02f, 7.50063732e-02f, -1.52032468e-02f, -1.12334937e-02f, 2.17276462e-03f, -1.42726079e-02f, 4.29517925e-02f, 2.22166795e-02f, 6.85009882e-02f, 6.53899908e-02f,
  1.91103425e-02f, 9.60296616e-02f, 6.44286424e-02f, -1.34947777e-01f, 2.38694660e-02f, -2.39238329e-02f, -4.21256796e-02f, 5.02729155e-02f, 4.88919578e-02f, 9.91044864e-02f,
  7.86171407e-02f, -2.80031282e-02f, 4.70349342e-02f, 2.20425632e-02f, 6.00358583e-02f, 4.37261164e-02f, 5.86847821e-03f, 2.73821279e-02f, -1.08966127e-01f, 4.07168269e-02f,
  -1.51249897e-02f, -4.53813300e-02f, 7.72485957e-02f, 2.93467920e-02f, 4.55749370e-02f, -1.04265906e-01f, 1.53059334e-01f, -6.68002367e-02f, -9.35994610e-02f, 9.22509748e-03f,
  5.91011979e-02f, 1.65633649e-01f, -3.29641476e-02f, -7.00115710e-02f, 2.30646227e-02f, 4.68793809e-02f, 4.27032895e-02f, -3.00070904e-02f, 4.27196920e-02f, -2.36897338e-02f,
  1.04146838e-01f, -1.82528440e-02f, 9.85117704e-02f, 1.07648514e-01f, 1.01341560e-01f, -2.97320373e-02f, 7.94151798e-03f, 5.30433059e-02f, 4.11510579e-02f, 1.23707950e-01f,
  -1.06673911e-02f, -4.35869358e-02f, 2.02419385e-02f, 2.45343614e-02f, -2.68549863e-02f, 3.85618545e-02f, 2.92806830e-02f, 1.40937939e-02f, 5.78294285e-02f, -5.72314449e-02f,
  2.59617895e-01f, -3.18741500e-01f, 1.47390351e-01f, 1.01750202e-01f, 2.81418055e-01f, 1.49864599e-01f, 2.55035013e-01f, -8.90979990e-02f, 1.67738963e-02f, -1.88691020e-01f,
  -4.71226573e-02f, -8.24524537e-02f, -9.87780243e-02f, -6.69266135e-02f, 2.24598199e-01f, -9.94202048e-02f, -1.11328997e-03f, -7.19478875e-02f, -8.16212781e-03f, 7.97923952e-02f,
  1.04037307e-01f, 1.36134684e-01f, 5.19879162e-02f, -1.06289178e-01f, 1.31579265e-01f, 6.59827888e-02f, -2.18276288e-02f, 1.35542333e-01f, 3.93265970e-02f, 1.40875846e-01f,
  -3.09189851e-03f, -7.34691098e-02f, 1.78447086e-02f, -5.37995435e-02f, 1.19321868e-02f, -6.01548180e-02f, 1.33836372e-02f, 9.13634971e-02f, 8.33252221e-02f, -5.87954819e-02f,
  -5.26439846e-02f, -5.85385896e-02f, 7.27216201e-03f, 5.98654896e-03f, 5.00236303e-02f, 1.06692500e-01f, 1.09267153e-01f, 3.06085292e-02f, -2.39333622e-02f, 2.00603269e-02f,
  -1.81451906e-02f, -4.51151431e-02f, 1.13924727e-01f, 1.75009221e-02f, -2.94828154e-02f, 2.42542755e-02f, -8.92421082e-02f, 2.49804035e-02f, 3.42469215e-02f, 3.83680686e-02f,
  -6.81623444e-02f, -2.30781417e-02f, -5.52315116e-02f, 1.21700369e-01f, 8.05622265e-02f, 1.04049414e-01f, -2.53694039e-02f, -9.96041298e-03f, -6.39521629e-02f, -2.47505791e-02f,
  9.48804691e-02f, -2.02323571e-02f, 4.42348458e-02f, 1.80349741e-02f, 5.28258160e-02f, -6.88612578e-04f, 4.12069447e-02f, 2.55025961e-02f, -1.92434397e-02f, -4.71555330e-02f,
  -6.07329570e-02f, -4.94968370e-02f, 3.64001095e-02f, -3.57833579e-02f, -5.20018525e-02f, -5.66540472e-02f, -1.36756524e-02f, 1.80042945e-02f, -4.53271344e-02f, -2.83317696e-02f,
  -7.74907544e-02f, -2.49576062e-01f, 6.25627786e-02f, -9.61939618e-02f, -8.79330039e-02f, -1.44958824e-01f, 1.70023721e-02f, -8.26995298e-02f, -3.59420828e-03f, -1.24615300e-02f,
  1.70619730e-02f, 5.88664189e-02f, -6.35999888e-02f, -2.74227597e-02f, -7.51178377e-05f, -4.13594581e-02f, -7.60972723e-02f, -7.17377737e-02f, -7.53831584e-03f, -4.09687981e-02f,
  8.91200304e-02f, -6.74371347e-02f, 1.31974533e-01f, 4.67186384e-02f, 3.59000708e-03f, -5.60218878e-02f, 4.23398465e-02f, 8.54572356e-02f, -7.24680647e-02f, 7.12121576e-02f,
  2.70116091e-01f, -1.96779981e-01f, -3.61424014e-02f, 1.44231720e-02f, 1.89713120e-01f, 2.21553311e-01f, 1.35955662e-01f, 3.56976427e-02f, -1.06999008e-02f, -2.15984747e-01f,
  1.27469599e-01f, 1.09965272e-01f, -1.33334324e-01f, 1.61339819e-01f, 2.91631758e-01f, -1.21374995e-01f, 3.86989787e-02f, 3.80830420e-03f, -3.02051324e-02f, 4.21469733e-02f,
  1.12549238e-01f, 8.53983834e-02f, 5.75630777e-02f, -7.02691153e-02f, 4.38322872e-02f, -1.55933231e-01f, -1.19066507e-01f, 7.34430254e-02f, 7.31417611e-02f, 6.59061670e-02f,
  1.25668868e-01f, -3.13798152e-02f, 9.04373452e-02f, -3.24066505e-02f, -1.11048207e-01f, -3.26437429e-02f, 1.74243934e-02f, -3.81118096e-02f, 1.22821078e-01f, -7.22797662e-02f,
  -2.89474856e-02f, 3.84574011e-02f, 1.72616616e-02f, -2.44220048e-02f, 7.27674291e-02f, -1.42523069e-02f, 9.34734661e-03f, -1.08049966e-01f, 3.46071534e-02f, -1.88928340e-02f,
  4.60307151e-02f, -5.37683628e-02f, -7.04596490e-02f, -5.10985404e-02f, -1.09447921e-02f, 6.43538535e-02f, -2.76025385e-02f, -9.14981812e-02f, 1.12241365e-01f, -5.82991540e-02f,
  9.92487967e-02f, 1.59413852e-02f, 4.67178151e-02f, -4.09943350e-02f, -3.06826588e-02f, 3.28888674e-03f, 1.94813050e-02f, -2.14363448e-02f, -6.54488578e-02f, -4.24609222e-02f,
  -6.23126701e-02f, 4.98197936e-02f, -9.92419943e-02f, 6.41334504e-02f, -4.47188094e-02f, 8.35571997e-03f, -5.45399189e-02f, -4.81566861e-02f, -1.28715783e-01f, 7.32725859e-02f,
  -1.87971573e-02f, 4.75286506e-02f, -4.58983816e-02f, -9.64270681e-02f, 1.14651639e-02f, 4.48821597e-02f, 2.12632641e-02f, 8.49123579e-03f, -7.77546363e-03f, -7.74557516e-02f,
  -3.96567620e-02f, -2.30441421e-01f, 1.44987050e-02f, 1.03059389e-01f, -7.28976876e-02f, 7.41463760e-03f, -4.96770302e-03f, 9.06652287e-02f, -9.65673402e-02f, -2.35058758e-02f,
  4.33138683e-02f, -5.60239702e-02f, 1.53350383e-02f, 1.01534031e-01f, 8.06223080e-02f, -6.15691356e-02f, 1.01133063e-02f, 1.54791735e-02f, -7.92716444e-02f, 4.04997207e-02f,
  -1.04220279e-01f, 2.51855180e-02f, 6.37308806e-02f, -4.77348305e-02f, -8.39529112e-02f, -6.98591024e-02f, -3.81946787e-02f, 2.18820963e-02f, 1.82558615e-02f, -8.98021311e-02f,
  3.41001712e-03f, -7.53269792e-02f, -8.14318806e-02f, -6.97334111e-02f, -1.03283294e-01f, 2.36645676e-02f, -1.37488216e-01f, -3.96274254e-02f, -1.73550285e-03f, -1.71653464e-01f,
  -1.54182136e-01f, 4.09839628e-03f, -2.74636243e-02f, -5.32547049e-02f, 2.08387956e-01f, 1.15472488e-01f, -1.71110988e-01f, 2.27707550e-02f, -3.24476026e-02f, -5.15425652e-02f,
  3.87580767e-02f, -6.55819997e-02f, -1.73743255e-03f, 1.17742931e-02f, -4.02935334e-02f, -8.92780349e-02f, -7.93212578e-02f, -1.35988563e-01f, -1.89005017e-01f, -8.06119069e-02f,
  -1.34531200e-01f, -1.71373710e-01f, -3.84594500e-02f, -1.36261299e-01f, -8.72225612e-02f, -8.86358097e-02f, -1.32845476e-01f, -8.58386829e-02f, 9.07937996e-03f, 6.31149784e-02f,
  -6.28580824e-02f, -3.53528932e-02f, -6.76883981e-02f, 5.25915623e-02f, -7.74890557e-02f, -8.52641091e-02f, 6.39576837e-02f, -5.34657203e-02f, -5.42812003e-03f, 1.89584401e-02f,
  9.42547917e-02f, -9.26345140e-02f, -5.62008396e-02f, -5.74095454e-03f, 6.06538132e-02f, -9.36731324e-02f, 1.71070881e-02f, 1.04551144e-01f, -2.04458609e-02f, -2.27367915e-02f,
  1.53919369e-01f, 9.64281186e-02f, -6.37020841e-02f, 7.30399368e-03f, -8.99351984e-02f, -4.38183509e-02f, -9.71340458e-04f, 5.90393059e-02f, -3.75866853e-02f, 1.11648217e-02f,
  -3.54356207e-02f, -1.01532154e-01f, 8.74062106e-02f, 5.63610271e-02f, -1.98866799e-02f, -9.39906389e-02f, -1.99457966e-02f, -3.83787462e-03f, 2.53958832e-02f, -8.15825015e-02f,
  3.42070237e-02f, 3.24641727e-02f, -7.82392472e-02f, -1.89996492e-02f, -7.50248283e-02f, -1.06751954e-03f, 7.74909975e-03f, 9.33194980e-02f, -1.95002761e-02f, -3.81861031e-02f,
  -3.63103807e-01f, -1.85392603e-01f, -1.20621540e-01f, -2.19571069e-01f, -7.92872235e-02f, -7.74233863e-02f, -2.40513794e-02f, 1.02290086e-01f, -1.50330082e-01f, 4.83629666e-02f,
  -3.70010063e-02f, 2.92596277e-02f, -6.05003014e-02f, 4.30337936e-02f, -1.75144207e-02f, 3.80758420e-02f, -6.70587197e-02f, -7.03181028e-02f, -6.06602710e-03f, -8.26617926e-02f,
  -2.07011532e-02f, 2.25986559e-02f, 7.95865953e-02f, -3.43474783e-02f, 4.22971807e-02f, -9.18616951e-02f, 7.70529360e-02f, 3.99759188e-02f, -9.18379705e-03f, -5.07518835e-02f,
  1.09373495e-01f, -2.40638375e-01f, 1.94661900e-01f, 9.35196579e-02f, 2.86864519e-01f, 2.38240853e-01f, 2.64578611e-01f, 1.57466888e-01f, 1.25820577e-01f, -1.90950617e-01f,
  -2.07549214e-01f, -8.68431479e-02f, -4.05315831e-02f, -1.02592736e-01f, 9.62038413e-02f, 1.79823712e-02f, 1.07715026e-01f, -2.49330737e-02f, 1.07245363e-01f, 4.00693230e-02f,
  1.55719653e-01f, 4.77452129e-02f, 4.81207035e-02f, -9.24364999e-02f, -1.46171702e-02f, 2.01224685e-02f, -1.16704725e-01f, 1.30324915e-01f, -1.21101215e-01f, 7.27332458e-02f,
  7.11573958e-02f, 2.46599466e-02f, -4.92810607e-02f, 1.81134734e-02f, 2.09990684e-02f, -1.00456133e-01f, 2.64023505e-02f, 2.37186514e-02f, 1.92795973e-02f, 6.25266358e-02f,
  -4.01859395e-02f, -3.94201800e-02f, 6.80862665e-02f, -1.19448444e-02f, 1.07149683e-01f, 1.25363644e-03f, 7.05480427e-02f, -6.16371557e-02f, 6.66499371e-03f, 3.13760675e-02f,
  -7.26956204e-02f, -7.72482529e-02f, 3.75209339e-02f, -1.12042306e-02f, 7.01484159e-02f, 3.72859165e-02f, -6.34999434e-03f, -7.82635063e-02f, -8.74840748e-03f, 8.21123198e-02f,
  -4.99356762e-02f, 5.01981974e-02f, -1.88748874e-02f, 7.39869177e-02f, 3.60832587e-02f, -4.65485714e-02f, -6.32815287e-02f, 3.93696539e-02f, -2.36785952e-02f, -8.13283995e-02f,
  -9.78063419e-02f, -7.06803948e-02f, 1.09426805e-03f, -2.24296227e-02f, -5.99937327e-02f, -5.61824813e-02f, 4.30339947e-02f, 5.03362063e-03f, -1.23241037e-01f, -6.22635148e-02f,
  -6.85483962e-03f, 2.20646616e-02f, -6.39029965e-02f, 2.65365709e-02f, -2.69391760e-02f, 7.61133730e-02f, -5.31525128e-02f, -4.39969562e-02f, -3.05676088e-02f, -5.04527660e-03f,
  -5.53079732e-02f, -9.42406282e-02f, -2.36513671e-02f, -1.42949283e-01f, -4.40630093e-02f, -8.06770101e-02f, 3.68459597e-02f, -3.79729830e-02f, -2.45459210e-02f, 4.67699431e-02f,
  -2.95780543e-02f, 4.19975026e-03f, -4.91252579e-02f, 6.68510348e-02f, -8.10773969e-02f, -4.06209119e-02f, -6.44665062e-02f, -1.04710925e-02f, -8.86334851e-02f, -8.91274735e-02f,
  -6.11839443e-02f, 3.06301713e-02f, -2.43017562e-02f, -4.36249971e-02f, -1.57111511e-01f, -9.39068198e-02f, 1.30557586e-02f, -5.77604175e-02f, 3.18268612e-02f, -3.72488908e-02f,
  1.44656450e-01f, 2.47177869e-01f, 2.16584712e-01f, 2.01105103e-01f, -8.55377987e-02f, -1.29657909e-01f, -1.71521261e-01f, 5.03226556e-02f, 1.67494848e-01f, -9.50045232e-03f,
  -6.09711446e-02f, 1.62792593e-01f, -1.76911429e-01f, 1.64409071e-01f, -2.46883154e-01f, -2.08470985e-01f, -7.63932317e-02f, -8.32174439e-03f, 1.11934030e-02f, 1.05260164e-01f,
  -8.37361068e-02f, -1.58198923e-01f, -1.34378046e-01f, -4.16602567e-02f, 5.97552955e-02f, 5.99962771e-02f, -1.96062893e-01f, 3.56228389e-02f, 1.06418274e-01f, 6.04141839e-02f,
  5.83441034e-02f, -1.81175545e-02f, 2.06485540e-01f, 1.35911137e-01f, 2.29691844e-02f, 3.88874821e-02f, -3.70108932e-02f, 2.00662538e-02f, 9.68566462e-02f, -3.01452680e-03f,
  -5.06318128e-03f, -6.88365176e-02f, 3.11854165e-02f, -5.46610653e-02f, 8.06764960e-02f, 1.26500502e-02f, 7.54275247e-02f, 8.25028867e-02f, 8.51103216e-02f, 9.81135070e-02f,
  3.48702185e-02f, 6.76934868e-02f, 4.09251936e-02f, -2.34779846e-02f, 4.99812234e-03f, 6.07048394e-03f, 1.97291188e-02f, 5.19201905e-02f, 8.04098919e-02f, -3.00485287e-02f,
  -1.07310511e-01f, 1.20416842e-01f, 7.34792799e-02f, 1.42636463e-01f, -6.11540070e-03f, 2.08457578e-02f, -6.64550513e-02f, 1.01797879e-02f, 3.64228934e-02f, 3.76080163e-02f,
  -7.07310289e-02f, 2.95299813e-02f, 2.40269341e-02f, -7.02413470e-02f, -9.64892004e-03f, 1.95222832e-02f, -4.85258065e-02f, -7.60831907e-02f, 3.86475958e-02f, 2.60421000e-02f,
  -6.76363558e-02f, -1.11827739e-02f, 5.80428652e-02f, -5.69746569e-02f, -3.77328368e-03f, 1.34611214e-02f, 7.74516091e-02f, 7.16706142e-02f, -8.01649410e-03f, -1.06337795e-03f,
  -4.18624580e-02f, 4.16533323e-03f, 1.21926777e-02f, -5.64700812e-02f, 3.48816179e-02f, -5.93065917e-02f, -8.32088068e-02f, 1.23694614e-01f, -8.87775198e-02f, -7.61524588e-02f,
  5.90817109e-02f, 5.74478135e-02f, -2.11064629e-02f, 7.39989057e-02f, -1.08023427e-01f, -3.24524790e-02f, 6.16417117e-02f, -2.03984883e-02f, 6.54264092e-02f, -1.63073651e-02f,
  -3.13459039e-02f, -7.53789395e-02f, 4.81038801e-02f, -5.51724769e-02f, -2.39618719e-02f, 8.55357572e-03f, 4.61062044e-02f, -1.70443915e-02f, 3.42642069e-02f, -1.64145082e-02f,
  2.62614191e-01f, -1.90481111e-01f, 3.71837690e-02f, 8.95989537e-02f, 9.29538459e-02f, 1.14409022e-01f, 1.71195641e-01f, -1.26265526e-01f, 4.92150150e-02f, -1.44920200e-01f,
  -3.51445228e-02f, -4.71290611e-02f, 1.22886613e-01f, -4.95229028e-02f, 1.66429117e-01f, 1.34266941e-02f, -5.74603258e-03f, -9.05457363e-02f, -4.93744239e-02f, 1.75151732e-02f,
  -7.28927180e-02f, -1.09934241e-01f, -4.95695435e-02f, -3.61998677e-02f, 7.02793105e-03f, -8.77319574e-02f, 1.09669445e-02f, 5.46543440e-03f, -1.27581224e-01f, 3.30388919e-02f,
  5.94372563e-02f, 2.45259907e-02f, -3.23840370e-03f, -1.18236586e-01f, 8.68032575e-02f, 3.97206172e-02f, -6.42431825e-02f, 4.34608459e-02f, 8.46047699e-02f, 2.21974347e-02f,
  -1.17735781e-01f, -3.26146111e-02f, 8.19110894e-04f, -1.80368498e-02f, -1.51187496e-03f, -5.23774438e-02f, 6.27295375e-02f, 1.84387434e-02f, -1.70476317e-01f, 3.35829072e-02f,
  5.87742701e-02f, 9.41651165e-02f, -3.61122400e-03f, 1.42141813e-02f, 5.97552173e-02f, -4.51323092e-02f, -8.15636292e-02f, 9.94130597e-02f, 6.39631003e-02f, -6.19353987e-02f,
  -1.06495738e-01f, -2.21859217e-02f, 8.79438892e-02f, -1.55332629e-02f, 3.17372233e-02f, -1.08980350e-02f, 1.55259399e-02f, 5.40081924e-03f, -3.74311469e-02f, 6.24449626e-02f,
  4.80106510e-02f, 9.28693935e-02f, 7.30115622e-02f, -2.63519422e-03f, 1.67904161e-02f, -1.19423583e-01f, 3.49054821e-02f, 4.45954986e-02f, 2.89868265e-02f, 3.89340222e-02f,
  -4.25000340e-02f, -1.15166064e-02f, 1.04208410e-01f, -1.11848954e-03f, 8.26539099e-02f, -8.75386596e-03f, 8.36527534e-03f, -3.95717137e-02f, -9.54182446e-02f, -1.07867992e-03f,
  -3.98516282e-02f, -7.30769411e-02f, -4.65896428e-02f, -1.11520961e-02f, -9.07175764e-02f, 5.19244224e-02f, 9.98441204e-02f, 1.86244193e-02f, -9.12030935e-02f, 6.55484647e-02f,
  -1.45416455e-02f, 7.52122849e-02f, -1.53849516e-02f, 7.70196840e-02f, -1.23149343e-02f, 7.58298673e-03f, -5.73612228e-02f, -2.16866154e-02f, -6.59129322e-02f, -2.48369072e-02f,
  -5.27562313e-02f, 1.04258850e-01f, 6.00999556e-02f, 4.31081355e-02f, -6.78875204e-03f, 1.55355558e-01f, -1.14519931e-02f, -1.75378509e-02f, 9.64681059e-02f, -5.26592061e-02f,
  2.63213307e-01f, -3.79966088e-02f, 1.17050752e-01f, -3.80207561e-02f, -8.87371674e-02f, 8.64456892e-02f, -1.20850671e-02f, -6.65835887e-02f, 2.24953175e-01f, -2.02268004e-01f,
  -1.34720942e-02f, 2.39494383e-01f, 1.51712656e-01f, -8.98769870e-02f, 3.49776089e-01f, 1.79855749e-01f, -7.93871209e-02f, -1.27054304e-01f, 5.21105863e-02f, 3.43567925e-03f,
  -6.10036440e-02f, -2.97505915e-01f, -4.83684689e-02f, -2.43760645e-01f, -2.48906568e-01f, -1.69288576e-01f, -9.88459960e-02f, 6.16751760e-02f, -2.35818192e-01f, 1.60858147e-02f,
  -2.10686214e-02f, 8.93935002e-03f, 8.28857124e-02f, 4.89412621e-02f, -8.81801099e-02f, 1.86087471e-02f, 5.53254783e-02f, 1.40150577e-01f, 4.24270220e-02f, -3.35910879e-02f,
  2.09312886e-02f, -9.32524726e-03f, -8.14705119e-02f, -1.61534897e-03f, 1.17965192e-01f, -3.49372625e-02f, -4.85594533e-02f, -1.54930493e-02f, 8.34273025e-02f, -2.73943413e-02f,
  6.23192154e-02f, 7.30458945e-02f, 5.52535653e-02f, 8.10466185e-02f, 2.06207968e-02f, 5.33945225e-02f, 6.44258037e-02f, 1.13182485e-01f, -1.09342812e-02f, 1.43526062e-01f,
  1.80637427e-02f, 1.11283854e-01f, -7.63642937e-02f, -2.26758271e-02f, -6.87752292e-02f, -9.77949873e-02f, -4.98931110e-02f, -8.89250264e-03f, -3.53859961e-02f, 3.60987224e-02f,
  5.87126501e-02f, 2.21009436e-03f, 8.09838772e-02f, 5.72102005e-03f, 3.86218689e-02f, 3.03280558e-02f, -1.57969799e-02f, 2.05906834e-02f, 8.47900510e-02f, 1.40763864e-01f,
  -4.26860200e-03f, 1.04823418e-01f, -1.20387256e-01f, 2.53323298e-02f, -2.62453109e-02f, 1.04174636e-01f, -7.93648437e-02f, -3.38690430e-02f, 9.03407410e-02f, 7.91750029e-02f,
  6.98230974e-03f, -7.44931027e-02f, 5.21026663e-02f, 6.14722297e-02f, -4.59850915e-02f, -3.20886634e-02f, 1.13863714e-01f, -8.35791007e-02f, -2.65669776e-03f, -1.25859780e-02f,
  -7.17743067e-04f, -3.59149016e-02f, 6.83634952e-02f, -2.72279792e-02f, 4.25645933e-02f, 2.81687770e-02f, -5.68716414e-03f, 5.47026657e-02f, 5.45384102e-02f, -1.01644248e-02f,
  1.06015764e-02f, 2.83838604e-02f, 1.61444470e-02f, 6.77477866e-02f, -8.71788859e-02f, 3.99945937e-02f, 6.91682473e-03f, -7.56120533e-02f, -7.59214163e-02f, -4.58940528e-02f,
  1.16056792e-01f, -2.74609447e-01f, -1.27298832e-01f, -1.10600285e-01f, -6.49153367e-02f, -1.10687673e-01f, -9.33809951e-02f, -2.22978830e-01f, -8.65977034e-02f, -1.15540072e-01f,
  8.27611331e-03f, 2.47097276e-02f, 1.01426929e-01f, -1.38685033e-01f, 2.03799009e-01f, 7.05314204e-02f, -1.36906117e-01f, 2.76302127e-03f, 3.07066385e-02f, -5.38603030e-02f,
  -6.68697571e-03f, -1.50427461e-01f, -2.43534781e-02f, -2.16402933e-01f, -1.86513960e-01f, -3.10239755e-02f, 3.61939520e-02f, -1.00634582e-01f, -7.61537924e-02f, -2.37215124e-02f,
  -1.48916738e-02f, -6.46843687e-02f, -8.78267065e-02f, -1.26329800e-02f, -3.64601351e-02f, 2.99666054e-03f, 5.14751822e-02f, 1.87606812e-01f, 1.44444583e-02f, 5.14331982e-02f,
  3.16846767e-03f, -3.12275370e-03f, -1.36673912e-01f, -1.66980326e-02f, -4.75261398e-02f, -9.71881822e-02f, -8.68993066e-03f, 1.34531826e-01f, 1.06113842e-02f, 5.58341742e-02f,
  -8.08415562e-03f, 1.95309892e-02f, 2.42653526e-02f, -8.00789893e-02f, 8.06782544e-02f, -5.39979897e-02f, 5.08408211e-02f, 4.65811305e-02f, 3.00831087e-02f, -2.75957566e-02f,
  -1.79532189e-02f, 7.79607426e-03f, 8.93550292e-02f, -4.67671081e-02f, -2.11321153e-02f, -7.68103898e-02f, -5.80727719e-02f, -4.88513848e-03f, 4.35237698e-02f, 5.08142002e-02f,
  -6.80122450e-02f, 9.49328393e-03f, 4.73418944e-02f, 8.76056924e-02f, -6.63939416e-02f, 6.78586948e-04f, -5.50183505e-02f, 1.51226418e-02f, 5.38838748e-03f, 3.95560116e-02f,
  2.55835317e-02f, 3.34368050e-02f, -6.80441707e-02f, -1.01646418e-02f, 4.22663018e-02f, 8.36840644e-02f, -1.15353903e-02f, -8.52863789e-02f, -1.21917827e-02f, 2.01059114e-02f,
  1.60760786e-02f, -1.25730485e-01f, -1.61304288e-02f, 2.20897794e-02f, 1.10670939e-01f, -8.57887268e-02f, -8.35804921e-03f, -9.73185375e-02f, 4.52247187e-02f, 5.24687096e-02f,
  6.65579066e-02f, -8.78601987e-03f, -9.85299796e-02f, 4.99771722e-02f, 3.55636515e-02f, -7.74609521e-02f, 1.07385010e-01f, 6.21959940e-02f, -1.61818564e-02f, -1.13563500e-01f,
  -3.08681391e-02f, -5.94757199e-02f, 2.69782338e-02f, -1.27544746e-01f, 1.16777085e-02f, 5.62481880e-02f, -1.13422237e-02f, -7.56922290e-02f, 3.75184342e-02f, 6.33534715e-02f,
  -1.56628620e-02f, 1.41356304e-01f, 6.99636564e-02f, 1.71828851e-01f, -1.18763551e-01f, -3.89968842e-01f, -2.22084999e-01f, -7.47017190e-02f, 3.18523645e-02f, -7.52289295e-02f,
  -2.20594227e-01f, 2.74881512e-01f, -2.16448173e-01f, 1.02813229e-01f, -8.61132517e-02f, 1.39107049e-01f, -2.98403408e-02f, -6.76864833e-02f, 1.54339343e-01f, -7.48331398e-02f,
  3.03545296e-02f, -2.95553729e-02f, 8.82945880e-02f, -8.76370072e-02f, 5.97220985e-03f, 9.39697847e-02f, 2.10917190e-01f, -1.18683778e-01f, -5.50359115e-02f, 3.66354547e-02f,
  -3.65307368e-02f, -6.76632896e-02f, 6.45796675e-03f, 6.41989335e-02f, -1.37931734e-01f, -1.47871822e-01f, 3.49678076e-03f, 1.37169063e-01f, 7.17327073e-02f, -4.83835004e-02f,
  1.18765816e-01f, 9.23598558e-03f, -8.03199317e-03f, 8.03778768e-02f, 2.51654573e-02f, 4.49474528e-02f, -9.10298154e-02f, 1.31352797e-01f, 9.86594614e-03f, 1.91199780e-02f,
  -3.45501453e-02f, -1.84258316e-02f, -7.71870688e-02f, 7.63845593e-02f, -2.74731331e-02f, -4.01611999e-02f, 1.39543852e-02f, 7.10323453e-02f, 1.21580280e-01f, 8.59720558e-02f,
  -5.03235050e-02f, 4.45838608e-02f, -1.30046504e-02f, 2.20597181e-02f, -3.95664051e-02f, 1.04872426e-02f, -6.44748360e-02f, -7.09487721e-02f, 1.76086966e-02f, 3.35012213e-03f,
  -2.90664416e-02f, 8.36239755e-02f, 3.52371782e-02f, 5.13637140e-02f, -1.58718247e-02f, -5.10041304e-02f, 5.45753315e-02f, -4.98017222e-02f, -5.24414293e-02f, -3.48927379e-02f,
  4.28429432e-02f, 2.40094569e-02f, 7.57771730e-02f, -5.73065057e-02f, -2.97035202e-02f, 9.07592401e-02f, 2.86015235e-02f, -1.13156978e-02f, 9.08793136e-02f, 8.53328686e-03f,
  -3.39241140e-02f, 5.79528846e-02f, 9.92773920e-02f, 2.73152888e-02f, 3.55388261e-02f, -8.34999308e-02f, 9.30945575e-02f, -4.11433838e-02f, 3.55704241e-02f, -2.31140503e-03f,
  -7.40521103e-02f, 8.71637687e-02f, 1.09898731e-01f, 3.32318023e-02f, 2.42775697e-02f, 3.33163291e-02f, -3.88114639e-02f, 1.46524042e-01f, -5.97046763e-02f, 4.91663627e-02f,
  -1.23197161e-01f, 2.43821871e-02f, -5.20053729e-02f, 3.30126192e-03f, 2.13162508e-02f, -3.96885574e-02f, -5.45747625e-03f, 1.14545636e-01f, 8.39052126e-02f, -9.91357397e-03f,
  -1.71012506e-01f, -1.46627337e-01f, -2.25927845e-01f, -5.45546189e-02f, 1.64665252e-01f, -5.42835966e-02f, -1.25626341e-01f, 7.10330978e-02f, -9.51383486e-02f, 2.71847541e-03f,
  9.15840790e-02f, -2.20208332e-01f, -1.40257910e-01f, -1.73633963e-01f, -2.60888696e-01f, -2.46192902e-01f, -1.63806185e-01f, -2.17178956e-01f, -1.28270149e-01f, 5.33409591e-04f,
  -1.08237870e-01f, 1.09352112e-01f, -2.17281803e-01f, 7.33958259e-02f, 2.52487529e-02f, 5.31887300e-02f, 2.03585923e-01f, 1.69538930e-01f, 1.21811077e-01f, 3.59870270e-02f,
  -1.23678863e-01f, -4.64828983e-02f, -3.42599228e-02f, -6.14064671e-02f, 8.67882818e-02f, 1.13107458e-01f, 1.04018338e-01f, 2.79283104e-03f, 7.16311042e-04f, -7.59619921e-02f,
  3.09979189e-02f, -8.13221261e-02f, -7.76713043e-02f, 6.14050329e-02f, 2.15394106e-02f, 6.05890341e-02f, -4.31243293e-02f, 7.45042041e-02f, -3.79297845e-02f, -1.88998759e-01f,
  -6.28051162e-02f, -5.55595532e-02f, 8.29444677e-02f, -3.23152244e-02f, -5.36034033e-02f, 4.29498143e-02f, -6.28350228e-02f, 1.01616783e-02f, 1.95721872e-02f, -6.66384771e-02f,
  4.70315702e-02f, -4.89861937e-03f, -9.61774141e-02f, 8.24820250e-02f, 6.48865709e-03f, -3.05909999e-02f, 1.21924402e-02f, 1.86520144e-02f, 1.30477743e-02f, 7.29430169e-02f,
  -1.68924369e-02f, 9.68738720e-02f, -3.22185047e-02f, -5.48437722e-02f, 3.87741625e-02f, 5.24405530e-03f, 4.47295681e-02f, -2.17429716e-02f, -1.48939323e-02f, -2.86332052e-02f,
  1.61648653e-02f, -4.70307656e-02f, -5.31837456e-02f, 5.85691072e-02f, 9.62510705e-03f, 2.95497272e-02f, -3.06495801e-02f, 7.67002106e-02f, 1.40122855e-02f, 3.14020179e-03f,
  1.98673620e-03f, 7.51938717e-03f, 2.12102942e-02f, 6.88090399e-02f, 5.58297224e-02f, 2.36751679e-02f, -6.66229501e-02f, 1.81427412e-02f, -7.60956928e-02f, -1.91600863e-02f,
  -1.45991435e-02f, 9.13060009e-02f, 9.47269127e-02f, 4.76790331e-02f, 7.12195262e-02f, 9.37684160e-03f, 2.29602214e-02f, 1.14553556e-01f, 1.19725488e-01f, -9.35010985e-02f,
  3.62660848e-02f, -5.94523130e-03f, 7.53776208e-02f, 4.11911309e-02f, -3.86929996e-02f, 1.27485633e-01f, -1.42858713e-03f, -4.89421189e-02f, 7.74993673e-02f, -2.30550654e-02f,
  -2.24583358e-01f, 2.16436818e-01f, 5.51612210e-03f, -1.81833059e-01f, 7.74442926e-02f, -1.77160978e-01f, -1.87963992e-01f, 1.33933946e-01f, 7.75236562e-02f, 9.84758437e-02f,
  -3.36108473e-03f, 1.85233019e-02f, 1.50030613e-01f, -9.74808633e-02f, -1.91914201e-01f, 5.84749412e-03f, -2.86372334e-01f, -1.98431939e-01f, 3.77925783e-02f, -1.28767163e-01f,
  -1.90028280e-01f, -1.08349644e-01f, -1.60656691e-01f, 1.10770941e-01f, -7.81332254e-02f, -3.92520940e-03f, -2.09725708e-01f, 3.27385217e-02f, -1.04347900e-01f, 1.02344267e-01f,
  -1.93579212e-01f, 3.27877365e-02f, 2.70588361e-02f, 8.22600052e-02f, 8.33232608e-03f, -7.16512576e-02f, -1.21671885e-01f, -6.16289526e-02f, 2.46172640e-02f, 7.27518834e-03f,
  -3.87335680e-02f, 4.08689119e-02f, -1.38768051e-02f, -2.78462470e-02f, 1.00552075e-01f, 1.03011578e-01f, -2.83397734e-03f, 5.50861657e-02f, -3.68546173e-02f, 4.53610569e-02f,
  8.98679942e-02f, 7.77494982e-02f, -9.17436406e-02f, -1.01279780e-01f, -1.11537360e-01f, 5.32576293e-02f, -1.06446266e-01f, -7.01525435e-02f, -2.32490879e-02f, 4.09591645e-02f,
  1.34398013e-01f, -1.12407558e-01f, -3.08683999e-02f, 1.22030400e-01f, -4.81937267e-02f, 3.82462479e-02f, -8.10658783e-02f, -7.91865736e-02f, 2.41085701e-03f, -4.17758562e-02f,
  -2.33529117e-02f, -2.67548002e-02f, 4.08935174e-02f, -3.95531356e-02f, -6.78161830e-02f, 2.90188193e-02f, -1.04494438e-01f, -7.19143301e-02f, 2.76688300e-02f, 5.32473177e-02f,
  2.64473185e-02f, -9.00955796e-02f, 7.73827359e-02f, -8.50933865e-02f, 1.17204450e-01f, -4.11342569e-02f, -2.60297880e-02f, -1.56645887e-02f, 4.25664894e-03f, -1.44965231e-01f,
  -3.63747388e-01f, -2.39234298e-01f, -3.99952158e-02f, 1.74802970e-02f, -5.36491070e-03f, -8.21490213e-02f, -1.37624383e-01f, 4.31358293e-02f, -8.41478333e-02f, 6.54067285e-03f,
  -9.29641426e-02f, -3.66616733e-02f, -8.59730393e-02f, 3.99670340e-02f, -1.44446958e-02f, -1.17812753e-01f, -1.11773893e-01f, 8.33967817e-04f, -1.08159341e-01f, -3.59455869e-02f,
  -7.41635785e-02f, -5.01713827e-02f, 4.63134497e-02f, 1.49045754e-02f, -1.17191471e-01f, -2.81023644e-02f, -1.13231130e-01f, -5.71870655e-02f, -7.96602592e-02f, -3.96994390e-02f,
  5.14236838e-02f, 6.28135651e-02f, -6.24680333e-03f, 1.82994694e-01f, 4.98605371e-02f, -1.00039326e-01f, -2.04708055e-01f, 1.50512099e-01f, -2.21925035e-01f, -9.31539685e-02f,
  9.33297947e-02f, -2.97739413e-02f, -7.06684822e-03f, 1.06621541e-01f, 4.35372591e-02f, -1.22039981e-01f, 1.03271957e-02f, 7.00199790e-03f, 5.10795927e-03f, 1.72718436e-01f,
  8.81426558e-02f, 1.57566994e-01f, 2.39035841e-02f, 1.33221239e-01f, -4.16561477e-02f, 1.52601495e-01f, 1.33135021e-01f, 6.14605732e-02f, 8.16345364e-02f, 4.41821590e-02f,
  -6.90060779e-02f, 8.60437751e-02f, -4.49442193e-02f, -1.08563833e-01f, 9.60821658e-02f, 2.02307533e-02f, 7.48622417e-02f, -1.30109340e-01f, 5.26532717e-02f, 1.04156025e-01f,
  -1.64611544e-02f, 5.21721318e-02f, -6.31329268e-02f, -5.35216480e-02f, -8.33004117e-02f, -2.58600935e-02f, 6.12204373e-02f, 5.75696230e-02f, -7.71322101e-02f, -2.23835204e-02f,
  6.82895109e-02f, -3.10749542e-02f, -6.03185110e-02f, 5.67383468e-02f, 5.02825379e-02f, 4.56312597e-02f, 2.44565476e-02f, 6.59987852e-02f, -3.10353823e-02f, -6.72577834e-03f,
  7.92621747e-02f, -8.76843929e-02f, -3.78074385e-02f, -9.53820199e-02f, 2.35568676e-02f, -2.94014756e-02f, -4.11266871e-02f, 2.98396125e-02f, -6.31984547e-02f, -2.93648317e-02f,
  -3.56964138e-03f, -2.32138671e-02f, -9.82451141e-02f, 3.85705121e-02f, 7.42751881e-02f, -5.96923707e-03f, -3.11506931e-02f, 1.50738776e-01f, 5.41440770e-02f, 6.67288005e-02f,
  -6.54034838e-02f, 9.36609209e-02f, -1.48180686e-02f, -2.13368628e-02f, -2.38447413e-02f, 4.17094827e-02f, -3.60467285e-02f, -5.20146377e-02f, -8.83773640e-02f, -4.23761159e-02f,
  1.81271844e-02f, 1.21778004e-01f, 3.55801880e-02f, -6.84771240e-02f, -7.35903950e-03f, 7.79844224e-02f, -4.33581397e-02f, 6.64674565e-02f, 9.60100591e-02f, -3.62538313e-03f,
  1.04735777e-01f, 1.53809376e-02f, 7.40998089e-02f, -1.86045822e-02f, -1.50390761e-02f, -1.17788492e-02f, 2.96590533e-02f, 4.48320918e-02f, 2.31766999e-02f, 3.92217934e-02f,
  4.60692495e-02f, -1.20759336e-02f, -7.87142739e-02f, 5.46246171e-02f, 3.05531584e-02f, 1.34115934e-01f, 7.68127143e-02f, 8.56977478e-02f, -5.13618179e-02f, -6.93017170e-02f,
  2.83188075e-02f, -2.06827089e-01f, -2.37454414e-01f, 1.23330556e-01f, 1.94649518e-01f, 1.11254081e-02f, -7.02420920e-02f, 5.79220764e-02f, -8.96747038e-02f, -4.39037709e-03f,
  1.62972584e-01f, 1.73583105e-02f, -1.16869286e-01f, 1.46163478e-01f, 2.00556785e-01f, -1.76437467e-01f, 1.31889939e-01f, 1.17039688e-01f, -8.88843089e-02f, 8.23542029e-02f,
  2.74994001e-02f, 2.09791765e-01f, 1.85419749e-02f, 1.20655395e-01f, 9.81884450e-02f, 2.51748860e-02f, 1.63443267e-01f, -1.06430247e-01f, 1.61055014e-01f, 9.90663171e-02f,
  -8.61300435e-03f, -5.79391643e-02f, 1.94746442e-02f, -8.78126174e-02f, 6.64856955e-02f, -8.95671844e-02f, -1.11111976e-01f, -5.78334667e-02f, -5.50162904e-02f, -8.16359557e-03f,
  -2.57352907e-02f, -4.35151197e-02f, 6.52401000e-02f, -5.92113659e-02f, 3.72257158e-02f, -2.78643928e-02f, 7.76754366e-03f, -4.13450822e-02f, -1.75734963e-02f, 7.57003948e-02f,
  -1.02892660e-01f, 7.15927333e-02f, -6.74695987e-03f, 1.00486365e-03f, 2.05891789e-03f, 5.95823266e-02f, -1.43587636e-02f, -3.50505896e-02f, 7.87658989e-02f, 5.34886867e-02f,
  -1.53397005e-02f, -4.25923243e-02f, -9.57212038e-03f, 8.22935253e-03f, -5.84272183e-02f, 8.64882320e-02f, 6.44216081e-03f, 1.02970451e-01f, 2.74114404e-02f, -3.23658176e-02f,
  5.29467799e-02f, 6.25158548e-02f, 1.76235996e-02f, 2.57129669e-02f, 3.36383767e-02f, 1.62947290e-02f, 5.63304909e-02f, 1.37678217e-02f, 5.59004210e-02f, 4.46788371e-02f,
  -8.12927634e-02f, 1.08102724e-01f, -3.31389420e-02f, -1.58704165e-02f, 4.67672683e-02f, -4.10333052e-02f, 4.96343151e-02f, 1.42822480e-02f, -2.34707594e-02f, -1.52688939e-02f,
  5.00912257e-02f, -3.06193456e-02f, -5.05278399e-03f, 3.26500908e-02f, 2.20045820e-02f, 1.00303672e-01f, -4.85931709e-02f, 4.69045863e-02f, 2.23707687e-03f, -2.50147972e-02f,
  -3.65935937e-02f, -2.34286487e-02f, -2.94260383e-02f, 2.91898530e-02f, -2.87942383e-02f, -4.88682725e-02f, -3.67857865e-03f, 1.09299906e-02f, 5.62262535e-02f, 6.14614114e-02f,
  1.39912060e-02f, -3.53683978e-02f, -3.83882076e-02f, 1.79799609e-02f, 7.57563859e-02f, 1.89890061e-02f, -7.60370046e-02f, -9.28692594e-02f, 6.99097887e-02f, -1.05646336e-02f,
  7.62279630e-02f, 4.17580903e-02f, 1.86682671e-01f, -2.01647095e-02f, -1.01861171e-01f, -1.62116691e-01f, -6.11011721e-02f, 8.92116427e-02f, 9.31163039e-03f, 2.07938030e-01f,
  -3.10108867e-02f, 1.53407842e-01f, -5.47812618e-02f, 8.58533606e-02f, -2.53338605e-01f, -1.90250143e-01f, -9.46420059e-02f, 2.34673470e-02f, -2.36985132e-01f, 1.34444386e-01f,
  -1.00230373e-01f, -1.53958768e-01f, -4.55780961e-02f, -3.39022110e-04f, 1.15597136e-02f, 1.95172355e-01f, 3.62291024e-03f, -1.08582703e-02f, 8.01298320e-02f, -1.08059153e-01f,
  8.36720914e-02f, 1.31273806e-01f, 1.68766543e-01f, 1.09452344e-02f, 8.58079419e-02f, 4.00016718e-02f, 8.27790946e-02f, -7.24233538e-02f, 3.15244459e-02f, -6.09288849e-02f,
  -2.23100055e-02f, -2.21589934e-02f, 1.76606688e-03f, -6.79205135e-02f, 1.04123265e-01f, 1.25870615e-01f, -2.49333791e-02f, -2.02715471e-02f, 2.76292302e-02f, 1.16554694e-02f,
  1.07632019e-01f, 4.90288325e-02f, 9.79057625e-02f, -4.79214359e-03f, -5.53840436e-02f, -1.34215616e-02f, 2.65761167e-02f, 7.84048736e-02f, 4.30532619e-02f, -1.02389559e-01f,
  5.39335459e-02f, -7.93946236e-02f, -4.64853132e-03f, 7.90544376e-02f, -6.38408884e-02f, -4.01782282e-02f, -1.30032785e-02f, 3.29825915e-02f, -5.46023846e-02f, 5.92155382e-02f,
  3.31332088e-02f, 3.80950533e-02f, -9.04200077e-02f, 7.06852302e-02f, -5.52909151e-02f, 6.35694936e-02f, 2.56504081e-02f, 3.49486992e-02f, 5.70357144e-02f, 3.37383919e-03f,
  3.09521426e-02f, 1.01472121e-02f, 4.48701121e-02f, -4.49680649e-02f, -2.27868892e-02f, -4.89643812e-02f, -9.91215929e-02f, -2.37191003e-02f, -1.34315137e-02f, 4.12167311e-02f,
  -1.87501218e-02f, -5.40573557e-04f, 1.27985343e-01f, 6.18558004e-02f, 5.62703796e-02f, 2.49923137e-03f, 4.95540760e-02f, 1.38799652e-01f, -8.80435780e-02f, 5.21092005e-02f,
  9.58558246e-02f, 4.17400002e-02f, -2.92038010e-03f, -9.17562395e-02f, -1.13297207e-02f, 6.13752492e-02f, -3.52823623e-02f, -3.95052601e-03f, 1.27999872e-01f, -5.19244447e-02f,
  6.64823428e-02f, -9.82108433e-03f, 2.14403402e-02f, 1.88865047e-02f, -3.81578244e-02f, 5.37730306e-02f, 7.71296993e-02f, 1.31406859e-01f, 4.40032966e-03f, -8.69477913e-02f,
  -3.57819870e-02f, 9.31768119e-02f, -5.04296981e-02f, 5.75868823e-02f, -5.58646172e-02f, 3.03364277e-01f, 3.57235014e-01f, 1.29970029e-01f, 2.71609783e-01f, 3.09092820e-01f,
  9.56510156e-02f, 3.87315378e-02f, 1.00777917e-01f, 1.29247814e-01f, -6.33180812e-02f, 2.28047624e-01f, 2.57325083e-01f, 1.91830799e-01f, -5.48287630e-02f, 1.43261468e-02f,
  -5.79393953e-02f, 9.69758555e-02f, -1.12613626e-01f, -1.85474962e-01f, -1.38841987e-01f, -1.31557465e-01f, -5.40334508e-02f, -1.49790064e-01f, -1.08690940e-01f, -1.82353482e-02f,
  7.85008594e-02f, 7.00721517e-02f, -2.75692884e-02f, 3.73404734e-02f, -5.62937520e-02f, -3.85598019e-02f, 4.42269556e-02f, 3.48893888e-02f, -8.65410790e-02f, 4.18784991e-02f,
  1.77959409e-02f, -2.01231409e-02f, 1.18338078e-01f, -4.58338857e-02f, 5.70883937e-02f, 6.75006909e-03f, 2.12151930e-02f, 1.09425168e-02f, -2.93210018e-02f, -3.84176597e-02f,
  5.67463897e-02f, -1.15994975e-01f, 4.31227945e-02f, -1.88541878e-02f, -1.21377394e-01f, 4.08881437e-03f, 1.19953677e-01f, 1.43003361e-02f, 3.73658724e-02f, 5.32962121e-02f,
  -6.68082461e-02f, -3.17503698e-02f, 1.01553604e-01f, -2.30580233e-02f, -3.04642674e-02f, -1.14354782e-01f, 3.30517516e-02f, 1.33373206e-02f, -2.81813554e-02f, 3.46722715e-02f,
  -1.88926980e-02f, -2.00496186e-02f, -1.12836892e-02f, 5.92950098e-02f, 4.40910049e-02f, -4.83360551e-02f, -1.55150304e-02f, 5.01619605e-03f, 8.61007124e-02f, -5.99516593e-02f,
  -3.52963097e-02f, 3.12725897e-03f, -2.09163465e-02f, -4.86969613e-02f, -1.43525479e-02f, 8.62625148e-03f, -3.06122191e-02f, -4.17914465e-02f, -4.09651734e-03f, -5.37113892e-03f,
  8.07523504e-02f, 1.64479055e-02f, 7.48918727e-02f, -1.97416842e-02f, -7.98078552e-02f, 6.33552670e-02f, -1.63697135e-02f, 1.12620406e-01f, 1.47899054e-03f, 1.02876816e-02f,
  5.73780201e-02f, 5.50469160e-02f, -1.78613756e-02f, -1.25371531e-01f, -4.66552675e-02f, 9.37901512e-02f, -4.00738977e-02f, 1.01143653e-02f, 1.51277436e-02f, -8.63917544e-03f,
  -5.58110923e-02f, 1.20318858e-02f, -2.68158745e-02f, 2.97007523e-02f, -5.52152880e-02f, 4.05476093e-02f, -1.07613392e-02f, -6.10856861e-02f, -5.90648167e-02f, 7.37618953e-02f,
  -6.75156489e-02f, -9.09584686e-02f, -2.07464084e-01f, -1.78017691e-01f, 1.25869559e-02f, -2.25078523e-01f, -2.58589327e-01f, -1.20085165e-01f, 6.41270205e-02f, 1.13198876e-01f,
  -1.17459968e-02f, 1.07265664e-02f, 6.79819733e-02f, -1.64781883e-01f, -1.09618358e-01f, 2.33230338e-01f, -1.35048106e-01f, -8.10079351e-02f, 1.64463557e-02f, -8.44871551e-02f,
  -5.94829619e-02f, -2.76930220e-02f, -9.68137607e-02f, -1.50268808e-01f, -2.33883515e-01f, -3.25051360e-02f, 1.05502546e-01f, -1.33962065e-01f, -1.35941744e-01f, -4.29459056e-03f,
  -7.01546371e-02f, 9.91326049e-02f, 5.10561988e-02f, -6.08244985e-02f, -2.77982093e-02f, -9.55205485e-02f, -5.44295125e-02f, -3.06534749e-02f, 7.93948118e-03f, 5.47325797e-02f,
  7.26447329e-02f, -4.75489534e-03f, -1.78322896e-01f, 5.68908267e-02f, 6.56867996e-02f, 2.85023693e-02f, -1.10441469e-01f, 1.11013964e-01f, -7.41058066e-02f, -5.73400818e-02f,
  -9.56741944e-02f, -4.95091043e-02f, -8.29703212e-02f, 6.52390942e-02f, -6.47948533e-02f, -2.62274710e-03f, -7.73729896e-03f, 7.23552480e-02f, -7.43681490e-02f, -6.73990324e-02f,
  -5.26942387e-02f, 9.45142657e-03f, 3.91061418e-02f, -1.21502466e-02f, -4.91792150e-02f, 3.65826674e-02f, -5.03240079e-02f, 1.47995669e-02f, 8.65906198e-03f, 3.26657556e-02f,
  7.08757341e-02f, 3.54107283e-02f, 8.16699266e-02f, 2.17325147e-02f, 4.15259525e-02f, 5.05837835e-02f, 2.07130797e-02f, 2.37068255e-02f, -8.25470611e-02f, -2.78716125e-02f,
  -6.62056878e-02f, -2.12304182e-02f, -1.88143812e-02f, 9.93440151e-02f, -4.32422087e-02f, -2.81273983e-02f, 6.36684671e-02f, 7.87295550e-02f, -5.24589382e-02f, -5.36526702e-02f,
  -1.48497904e-02f, -8.09107944e-02f, -5.46239363e-03f, -5.20374738e-02f, -2.44196914e-02f, 2.37077661e-02f, 1.77750411e-03f, 5.95538830e-03f, 1.14919849e-01f, -1.00608416e-01f,
  -3.68405841e-02f, 8.17225128e-02f, -4.13293093e-02f, 1.56051293e-02f, -3.53827402e-02f, -6.74796700e-02f, 5.12858443e-02f, -3.67804221e-03f, 5.52327186e-02f, -1.26820266e-01f,
  -8.45858231e-02f, -2.38868427e-02f, 3.37916464e-02f, -2.54177079e-02f, 6.26259595e-02f, -2.44626384e-02f, -2.95716505e-02f, -1.03483059e-01f, 7.85066709e-02f, 4.82264459e-02f,
  2.56238580e-01f, 1.62481651e-01f, -1.36856660e-01f, 1.17826961e-01f, 9.70057249e-02f, 4.78150360e-02f, 5.11464886e-02f, 1.22325927e-01f, 1.85725093e-01f, 1.13406070e-02f,
  -2.81322934e-03f, 5.94287105e-02f, -1.02109753e-01f, -1.91932749e-02f, -1.02794863e-01f, -9.70670208e-02f, 5.64699061e-02f, 1.58021241e-01f, -4.55472358e-02f, 1.31057635e-01f,
  -8.09058640e-03f, 4.17908840e-02f, -2.22682774e-01f, -7.51206204e-02f, 1.27691075e-01f, 9.78089049e-02f, -3.75022590e-02f, -1.19903415e-01f, 8.09696540e-02f, -6.30463436e-02f,
  -3.39996703e-02f, 4.60900702e-02f, 1.28123805e-01f, -1.55430734e-02f, 5.35670444e-02f, 4.48036529e-02f, -2.89014541e-02f, -1.00073300e-01f, -1.25242174e-01f, 7.64203146e-02f,
  -1.92596149e-02f, -7.51761347e-02f, -8.27454552e-02f, 6.34541288e-02f, 7.50254467e-02f, -4.40094620e-02f, 2.50907987e-02f, -5.90558015e-02f, -5.78787783e-03f, 4.02899906e-02f,
  -7.04467893e-02f, 3.88951115e-02f, 5.50159700e-02f, -1.52534604e-01f, -4.90519702e-02f, -2.48515010e-02f, -6.10326938e-02f, -4.61543463e-02f, 1.19712651e-02f, 1.13735422e-01f,
  1.01751864e-01f, 2.29112338e-02f, 1.25408871e-02f, 1.00205250e-01f, 2.27641668e-02f, 3.35570946e-02f, -4.14155163e-02f, -7.98434317e-02f, -3.53161506e-02f, -2.64349189e-02f,
  3.11802682e-02f, -2.25358573e-03f, 1.05472073e-01f, 1.18347041e-01f, 5.82345538e-02f, -5.37804775e-02f, 3.36299390e-02f, 5.88713214e-03f, 3.34005691e-02f, 1.98998535e-03f,
  -1.87107995e-02f, -5.15486114e-02f, 1.01283185e-01f, 9.19673741e-02f, -6.26560003e-02f, -3.61488871e-02f, 7.56075531e-02f, -1.05468325e-01f, -8.62660035e-02f, -6.70057908e-02f,
  1.48798540e-01f, -4.25734892e-02f, -4.21695001e-02f, -9.55226570e-02f, -2.22667661e-02f, 6.05135178e-03f, -7.77521431e-02f, -4.21822853e-02f, 4.47982028e-02f, 1.21607408e-01f,
  -5.99083453e-02f, -6.38000518e-02f, 7.73500651e-03f, -3.23450975e-02f, -4.04431373e-02f, 7.06251636e-02f, -3.45069654e-02f, -7.23069757e-02f, 5.44733666e-02f, 2.68556047e-02f,
  1.21696088e-02f, 9.98161212e-02f, 1.25397497e-03f, 3.05004623e-02f, -6.29212707e-02f, -7.61754811e-02f, 1.77741144e-02f, -2.59007849e-02f, -1.06532052e-02f, -1.82567891e-02f,
  1.49635613e-01f, 1.63386797e-03f, -1.67905048e-01f, 8.91505405e-02f, 4.34734784e-02f, -5.32914028e-02f, -1.00431144e-01f, 1.36580765e-01f, -2.08651647e-01f, 5.72395399e-02f,
  1.12021737e-01f, -1.17223904e-01f, -1.78531986e-02f, 6.10173382e-02f, -7.10147843e-02f, -7.84609690e-02f, 2.88871732e-02f, 8.92380327e-02f, -1.41454011e-01f, 9.30592939e-02f,
  1.93185788e-02f, 4.80410941e-02f, -4.89795469e-02f, 9.26377103e-02f, -4.77542654e-02f, 1.52873039e-01f, 5.19050509e-02f, 2.42046360e-02f, 2.12790832e-01f, 2.39471700e-02f,
  -4.78363968e-02f, 1.17491018e-02f, 1.20588699e-02f, 4.40430939e-02f, 1.31729797e-01f, 9.17400345e-02f, 9.27363895e-03f, -1.19669445e-01f, -2.97019165e-03f, 4.70908768e-02f,
  1.04700558e-01f, -5.20064831e-02f, -8.17984045e-02f, -1.96277145e-02f, 1.22125018e-02f, -7.35819936e-02f, -9.14654061e-02f, 1.50224324e-02f, -4.88149524e-02f, 4.01043743e-02f,
  -5.32639474e-02f, -1.01478904e-01f, 8.26854259e-02f, -2.93822903e-02f, -2.38598008e-02f, -2.54361778e-02f, -7.54441228e-03f, -1.29635647e-01f, 9.48620960e-02f, -4.75458950e-02f,
  1.12193272e-01f, 8.33920166e-02f, -1.13772741e-02f, -2.88166106e-02f, -3.99899334e-02f, -6.23720959e-02f, 5.99365607e-02f, 2.36609788e-03f, -8.09032321e-02f, -7.73998909e-03f,
  6.50436208e-02f, 2.90876925e-02f, -5.21075586e-03f, -4.28967737e-02f, 6.28133565e-02f, -2.30457634e-02f, 9.68320221e-02f, 5.30402735e-02f, -2.42364146e-02f, -2.09817272e-02f,
  6.95934370e-02f, 3.22678383e-03f, -6.67395964e-02f, 1.77074924e-01f, 1.37677073e-01f, 5.07704765e-02f, 2.46658549e-02f, 3.57614271e-02f, 5.88543415e-02f, -3.45358551e-02f,
  8.78512859e-02f, 4.36804816e-02f, 3.77339423e-02f, -8.92679989e-02f, -4.11521569e-02f, 3.40434611e-02f, -7.19341170e-03f, 4.89850566e-02f, 7.06884637e-02f, 1.24550955e-02f,
  1.42556727e-01f, -4.72047441e-02f, 3.21138166e-02f, 6.80449512e-03f, -4.06672768e-02f, -2.99345497e-02f, 1.03263766e-01f, -7.72814173e-03f, 3.33076641e-02f, 8.45512450e-02f,
  1.31844684e-01f, 4.37058276e-03f, 8.87300894e-02f, -1.01418369e-01f, 5.48633654e-03f, -6.07688837e-02f, 7.98780248e-02f, -3.56130861e-02f, 4.02115174e-02f, -4.41172682e-02f,
  3.48872066e-01f, -1.48167908e-01f, 9.92517322e-02f, 1.45465776e-01f, 2.04018146e-01f, -3.02302800e-02f, 5.21977432e-02f, 7.91349821e-03f, 3.65625232e-01f, -1.48175895e-01f,
  -9.01077017e-02f, -1.59869865e-01f, -1.99745551e-01f, -4.94305640e-02f, 1.39199883e-01f, -2.09271256e-02f, 6.70317840e-03f, -4.68378328e-02f, 1.22411780e-01f, -1.54366523e-01f,
  3.16245831e-03f, -1.55922145e-01f, 6.12255326e-03f, 5.31915911e-02f, 5.11273667e-02f, 1.07065342e-01f, -1.21333964e-01f, -1.05117634e-01f, -1.98340312e-01f, 1.72125939e-02f,
  1.51035726e-01f, 7.83141609e-03f, -5.93995024e-03f, -1.31951645e-01f, 9.43848640e-02f, 9.02306475e-03f, -6.07191660e-02f, -8.90777912e-03f, 3.41573991e-02f, -7.97496587e-02f,
  -4.39160429e-02f, -6.84762597e-02f, -8.27057064e-02f, -2.67647710e-02f, -3.47972214e-02f, 5.76471575e-02f, 1.06892295e-01f, -7.66609749e-03f, 3.93563695e-02f, -3.14725214e-03f,
  8.98756236e-02f, -7.59820566e-02f, -6.66585639e-02f, -6.34633973e-02f, -1.64128523e-02f, 5.99244982e-02f, 8.18364546e-02f, -9.87488404e-02f, -8.72423723e-02f, 1.07662126e-01f,
  -6.83723912e-02f, -6.78893030e-02f, -3.26666944e-02f, -6.81293830e-02f, -4.97004353e-02f, 7.93422572e-04f, -3.84337865e-02f, -3.32334191e-02f, 9.97541323e-02f, 4.03844081e-02f,
  1.81315560e-02f, -1.02684302e-02f, 1.27870087e-02f, 2.68138275e-02f, 4.06922214e-02f, 1.33246616e-01f, -4.51429784e-02f, -6.94840727e-03f, 5.63898087e-02f, 1.13102801e-01f,
  -1.77896675e-02f, -6.57492876e-03f, -4.09201114e-03f, 1.06292121e-01f, 8.09394270e-02f, -6.39383718e-02f, -9.09637567e-03f, -5.00246277e-03f, 2.34276690e-02f, -1.15213998e-01f,
  -3.47099453e-02f, -3.54920253e-02f, -8.83586556e-02f, -2.78706718e-02f, 7.61163980e-02f, 2.92114634e-02f, -9.45321172e-02f, -7.60424808e-02f, 2.65212879e-02f, -3.64441350e-02f,
  -1.03173018e-01f, 5.51149622e-02f, -4.23182622e-02f, 5.32818921e-02f, -1.21271778e-02f, 9.63546187e-02f, -6.31266534e-02f, -1.15901176e-02f, 6.00205101e-02f, -1.81530908e-01f,
  -2.30228025e-02f, -1.05894491e-01f, 3.01354732e-02f, 9.86010358e-02f, 4.53375764e-02f, -9.12717357e-03f, -3.43061537e-02f, -1.09158657e-01f, -4.34962697e-02f, 2.08746325e-02f,
  -1.49951383e-01f, -7.26466030e-02f, -9.46390480e-02f, -1.77697763e-01f, -2.22486913e-01f, -1.40230060e-01f, 2.18898412e-02f, -1.70660734e-01f, 3.83508019e-02f, 4.60160822e-02f,
  6.24303557e-02f, 1.43621303e-02f, 2.10604057e-01f, 2.24063732e-02f, 1.05723493e-01f, 2.84243613e-01f, -1.27483085e-01f, -6.18740283e-02f, -6.41035736e-02f, -1.50929019e-01f,
  -1.06746435e-01f, -1.38559833e-01f, 2.92402245e-02f, -1.61154568e-01f, -1.04804084e-01f, -1.28354803e-01f, -9.65027837e-04f, -9.38066244e-02f, -1.35379761e-01f, -9.41663235e-02f,
  -1.49503760e-02f, -5.98075353e-02f, -6.91045970e-02f, -9.32365209e-02f, -1.10712253e-01f, -2.44786683e-02f, -8.27287212e-02f, -8.40558298e-03f, -1.69757996e-02f, -2.65847985e-02f,
  -8.53363946e-02f, -1.16204256e-02f, -7.82517418e-02f, 5.35632251e-03f, 5.51452674e-03f, -1.84363779e-02f, -1.88590176e-02f, -3.95365767e-02f, 1.42538827e-02f, 2.28651203e-02f,
  -7.81032890e-02f, 3.30212489e-02f, 4.14038263e-02f, 7.87037537e-02f, 4.75718938e-02f, -4.34079245e-02f, -3.55565995e-02f, 8.75643978e-04f, -2.09036488e-02f, -8.58409256e-02f,
  -6.48165271e-02f, 3.71911339e-02f, -1.23132445e-01f, 9.73870326e-03f, -6.26268312e-02f, 8.43345299e-02f, -7.80270100e-02f, 1.82369445e-02f, -1.52822323e-02f, 9.13403556e-02f,
  -6.88258410e-02f, -3.54415402e-02f, -4.66225967e-02f, 1.65132917e-02f, 3.22537534e-02f, 1.61279589e-02f, 6.75392970e-02f, 1.25040263e-02f, 8.45969561e-03f, 5.00164703e-02f,
  -9.93840117e-03f, -2.86738798e-02f, 2.48515569e-02f, 3.77703458e-02f, -1.03457928e-01f, 7.39242435e-02f, -7.26003423e-02f, 1.99938789e-02f, -3.73688415e-02f, -1.42247071e-02f,
  7.35183293e-03f, -1.76650777e-01f, -4.04655710e-02f, 1.71491969e-02f, -6.88525066e-02f, -6.84822425e-02f, -8.85702390e-03f, -1.37620807e-01f, -1.02667317e-01f, -9.28734690e-02f,
  -4.11391705e-02f, 4.73792963e-02f, -3.45084667e-02f, -6.46786615e-02f, 6.36215061e-02f, 7.99933635e-03f, 2.10967604e-02f, -6.21807240e-02f, 2.82067731e-02f, 1.40157025e-02f,
  -4.96925004e-02f, -7.45392963e-02f, 5.26523329e-02f, -2.94451006e-02f, 6.17904179e-02f, 3.62814707e-03f, -5.31148948e-02f, 9.78843495e-02f, -5.48243113e-02f, -4.04421315e-02f,
  1.58053130e-01f, 5.49814329e-02f, -8.04612879e-03f, 1.26753762e-01f, 9.00358632e-02f, 1.36714518e-01f, 9.17846411e-02f, 6.68089986e-02f, 3.12847376e-01f, -9.51265767e-02f,
  -2.21283175e-02f, 4.61007245e-02f, -4.06111144e-02f, -2.10692678e-02f, 9.04116854e-02f, 4.48445491e-02f, 1.46460682e-01f, -2.28210241e-02f, 8.86693746e-02f, 8.08958560e-02f,
  1.08956538e-01f, -9.65734497e-02f, -2.60470122e-01f, -1.86095595e-01f, -1.29692718e-01f, -1.17823020e-01f, -2.44535387e-01f, -5.12190424e-02f, -9.80473161e-02f, 2.83957794e-02f,
  1.35142192e-01f, 1.00070469e-01f, -9.03833136e-02f, -3.44032943e-02f, -1.95503719e-02f, 2.11257432e-02f, -1.06851585e-01f, -1.72222499e-02f, 7.30850399e-02f, 2.80381106e-02f,
  2.49819458e-02f, 1.97552005e-03f, 1.51372952e-02f, -7.14862272e-02f, 1.00129686e-01f, 2.12304872e-02f, -9.09307692e-03f, 5.93405776e-02f, 2.34666206e-02f, 5.51686510e-02f,
  7.21716955e-02f, 7.01684728e-02f, 1.17068943e-02f, 8.93848669e-03f, 6.95836991e-02f, 9.98126268e-02f, -8.21976271e-03f, -3.69942263e-02f, 1.47196678e-02f, 4.83045317e-02f,
  -2.57046074e-02f, 1.13714710e-01f, 6.15443662e-02f, 8.33825034e-05f, -1.90649442e-02f, -4.21268418e-02f, -2.03821808e-02f, -4.22236230e-03f, 1.24295190e-01f, 6.84951851e-03f,
  7.54629150e-02f, 1.23541012e-01f, 1.35847688e-01f, 1.13341786e-01f, 4.28589843e-02f, 2.21789815e-02f, -8.52980316e-02f, 4.62662503e-02f, 5.01276851e-02f, 1.57644078e-02f,
  -2.11689062e-02f, -5.68030886e-02f, -1.05644509e-01f, -1.63907692e-01f, -9.53672007e-02f, 7.36939395e-03f, 1.06368465e-02f, -5.61463535e-02f, -4.13129739e-02f, -7.71785039e-04f,
  5.23620769e-02f, 6.01665042e-02f, 2.50283219e-02f, 3.72489803e-02f, -9.14017931e-02f, -2.40277648e-02f, 2.22220905e-02f, 7.83523023e-02f, 1.54376160e-02f, 1.42164305e-02f,
  1.07563026e-01f, -5.79079753e-03f, 3.03564873e-02f, 1.00558447e-02f, 5.54608321e-03f, 7.24887569e-03f, -1.13014057e-02f, 1.01427026e-01f, -1.07022319e-02f, 2.66135484e-02f,
  6.38645887e-02f, 8.14425275e-02f, 8.19231868e-02f, 3.10091674e-02f, 5.68646826e-02f, -7.05612376e-02f, 6.99058101e-02f, -6.47682548e-02f, -8.21577013e-02f, -2.83962563e-02f,
  1.12622477e-01f, 1.38948277e-01f, -1.30103394e-01f, 1.35650605e-01f, -2.04543263e-01f, -9.83011276e-02f, 6.09672479e-02f, -2.03965977e-02f, -1.12050280e-01f, 1.85445487e-01f,
  3.40867713e-02f, 2.11350042e-02f, 1.61478594e-01f, 2.95319557e-01f, -7.10583106e-02f, 1.50501668e-01f, 2.09623903e-01f, 1.14460915e-01f, 2.62346845e-02f, 1.25293955e-01f,
  7.83578455e-02f, 2.26465017e-01f, 1.65784240e-01f, 4.38806191e-02f, 1.52795181e-01f, -5.31696454e-02f, 1.50884718e-01f, -2.13113595e-02f, 3.16103473e-02f, -2.12992951e-02f,
  4.75852080e-02f, 9.08248425e-02f, 1.25604412e-02f, -9.92793217e-02f, 7.22092539e-02f, -5.79932742e-02f, -6.04398027e-02f, 6.06648810e-02f, -2.23060790e-02f, -1.52481832e-02f,
  -2.20951065e-02f, -6.21405058e-02f, -2.57113427e-02f, -1.27357468e-01f, -9.68518183e-02f, -2.78234836e-02f, -6.79350123e-02f, -4.07230332e-02f, 8.14948755e-04f, -6.67361319e-02f,
  1.37596112e-02f, 6.50093518e-03f, 6.44690692e-02f, -9.85557330e-04f, 4.41206060e-02f, -1.19466484e-02f, -9.56993625e-02f, -5.40950224e-02f, 3.25526223e-02f, -1.06837023e-02f,
  1.27320349e-01f, 1.90713741e-02f, -1.37767950e-02f, 1.23206656e-02f, 2.42998544e-02f, 4.79323193e-02f, -3.50970402e-02f, 2.87225768e-02f, -5.30966297e-02f, 8.56531113e-02f,
  7.06014261e-02f, 2.91755926e-02f, 1.65520038e-03f, -4.97059748e-02f, -6.74370825e-02f, -4.16135490e-02f, -3.07043120e-02f, 8.64184201e-02f, -5.91440797e-02f, 1.79672539e-02f,
  2.61253286e-02f, -4.46652211e-02f, -4.96952608e-02f, -7.45840464e-03f, -1.66765042e-03f, -1.36017790e-02f, 3.46666463e-02f, -3.65459509e-02f, -4.14125100e-02f, -6.72443584e-02f,
  1.12489119e-01f, 4.27044220e-02f, 2.89228391e-02f, -2.13755928e-02f, -5.57551049e-02f, 4.30910476e-02f, 6.02332763e-02f, 3.38618681e-02f, -1.55199906e-02f, 7.30080456e-02f,
  -8.98001269e-02f, -8.00340399e-02f, 8.85348693e-02f, 9.45143849e-02f, -2.38341689e-02f, 1.00709215e-01f, 1.62415728e-02f, 3.81032005e-03f, 8.65078792e-02f, -3.38071287e-02f,
  5.84047064e-02f, -3.29701602e-02f, 8.20081607e-02f, 1.29527450e-02f, 7.73373758e-03f, 5.87765910e-02f, -8.20935667e-02f, 4.49040569e-02f, -4.30031754e-02f, 1.42686293e-02f,
  4.74409014e-02f, -5.34348488e-02f, 6.15901724e-02f, -1.09465390e-01f, -4.52773161e-02f, 9.16860625e-02f, 3.21028054e-01f, -1.24486931e-01f, -1.02683090e-01f, -1.66675195e-01f,
  6.16235323e-02f, 3.15492898e-02f, 1.97243497e-01f, -4.05783691e-02f, 3.48492503e-01f, 1.66859001e-01f, 8.43985006e-03f, 5.98848909e-02f, -3.66081409e-02f, -7.10550696e-02f,
  1.62480958e-02f, -4.14423756e-02f, 3.31677496e-02f, -2.32129067e-01f, -4.48471792e-02f, -1.50270447e-01f, -9.25856754e-02f, 1.11956380e-01f, -1.23652369e-01f, 3.95406112e-02f,
  1.01498365e-01f, 7.91975334e-02f, 4.86319996e-02f, 4.39153872e-02f, 1.14541024e-01f, -2.43141502e-03f, 6.23171404e-02f, 5.90190217e-02f, 7.53130987e-02f, 7.16427863e-02f,
  -2.52265502e-02f, 4.72338311e-02f, -1.36944950e-01f, -2.93348096e-02f, -1.02872156e-01f, -7.04924688e-02f, -5.75638711e-02f, 1.05896316e-01f, -5.72670624e-02f, 6.77037686e-02f,
  4.55726963e-03f, 7.41090402e-02f, -3.84836011e-02f, -7.62932152e-02f, -6.88909590e-02f, 6.95943236e-02f, 1.26879036e-01f, 1.04972459e-01f, -2.07887851e-02f, 1.50015140e-02f,
  -1.23010628e-01f, -7.22484291e-02f, 8.22429359e-02f, 4.69329134e-02f, 1.46727765e-03f, -1.07301243e-01f, -1.99397653e-02f, 3.65744717e-02f, -4.01253328e-02f, -5.10205179e-02f,
  -5.22726914e-03f, -4.21581417e-02f, 3.77300233e-02f, 3.95035408e-02f, -2.30087526e-02f, -3.44996415e-02f, 9.85451192e-02f, -1.04217835e-01f, -5.95693253e-02f, 5.37723266e-02f,
  2.95765754e-02f, 4.51905504e-02f, -9.83295068e-02f, 4.19466868e-02f, 2.31253039e-02f, 1.19001064e-02f, -4.05487679e-02f, 3.52943130e-03f, 7.00295269e-02f, 4.78394330e-02f,
  5.93585409e-02f, -3.31283025e-02f, 4.74273786e-02f, -8.60315468e-03f, 6.23116642e-02f, 7.27444664e-02f, -1.41713880e-02f, -3.95663418e-02f, -2.15195548e-02f, -2.81476676e-02f,
  -3.40143405e-02f, -1.56051619e-02f, 1.80289187e-02f, -2.99246106e-02f, -3.61453705e-02f, -8.64504948e-02f, 1.58195831e-02f, -6.07844181e-02f, -2.99315508e-02f, -3.37999016e-02f,
  2.17180941e-02f, 4.16851975e-03f, -6.19029328e-02f, -1.46716191e-02f, -9.98965949e-02f, 9.58456621e-02f, -4.99396808e-02f, -7.09279627e-02f, -3.68698360e-03f, -2.32463088e-02f,
  2.45212391e-01f, -9.26030874e-02f, 9.16297268e-03f, 1.94932178e-01f, 1.52079850e-01f, 1.30952805e-01f, 1.49447694e-01f, 6.72490299e-02f, 3.66878122e-01f, -1.57188818e-01f,
  1.05815902e-01f, -3.10858525e-02f, -8.40126872e-02f, 1.35607511e-01f, 7.42597282e-02f, -5.01071755e-03f, 1.08450033e-01f, 5.39408438e-02f, 2.05551479e-02f, 1.45325959e-01f,
  9.18217823e-02f, 5.58242388e-02f, -1.30781829e-01f, -2.01943368e-01f, -1.55237475e-02f, -1.98187873e-01f, -1.84398621e-01f, -1.79720789e-01f, -4.95544896e-02f, 2.34119259e-02f,
  1.33489057e-01f, 1.01996079e-01f, -1.61401592e-02f, -8.61689448e-02f, 1.55328168e-03f, 3.38339619e-02f, -2.00858042e-02f, -1.15454063e-01f, 7.84593672e-02f, -5.08407168e-02f,
  5.70505820e-02f, 1.00546330e-02f, 1.34032458e-01f, -3.81447300e-02f, 1.09990805e-01f, 1.28462734e-02f, 5.68688754e-03f, 4.31782519e-03f, -7.13108629e-02f, -5.74656762e-02f,
  -6.28681481e-02f, -1.85801350e-02f, 2.04921085e-02f, -1.26247898e-01f, -8.41042995e-02f, -2.68832427e-02f, 1.38234179e-02f, 3.34081589e-03f, 4.02216204e-02f, -3.87570113e-02f,
  -8.66780132e-02f, -8.47925767e-02f, -7.70653188e-02f, -1.61893517e-02f, 4.43533957e-02f, -3.05319298e-02f, 7.66453370e-02f, 4.36369292e-02f, 4.39293310e-02f, 7.83254653e-02f,
  9.02961791e-02f, -1.97508261e-02f, 2.88707931e-02f, -4.44487110e-02f, 6.01419955e-02f, 4.20119949e-02f, -3.32039839e-04f, 2.20391843e-02f, -6.77881762e-02f, -6.45144433e-02f,
  6.68090954e-02f, -5.86588569e-02f, -2.42627673e-02f, -9.51974764e-02f, -7.31393248e-02f, 1.20051570e-01f, 5.07852063e-02f, 8.78329054e-02f, 2.11361740e-02f, 1.96558684e-02f,
  -6.67290241e-02f, -5.65232411e-02f, -6.12134188e-02f, -5.46144471e-02f, -2.26228088e-02f, -7.21545815e-02f, 7.29138479e-02f, 7.46428668e-02f, -4.08918746e-02f, 6.09105937e-02f,
  -9.42434520e-02f, 2.39711888e-02f, -6.80763647e-02f, -1.91673860e-02f, -4.51784395e-02f, 2.69193035e-02f, 9.20969807e-03f, -1.21224910e-01f, 3.18543799e-02f, -2.58816928e-02f,
  -3.60613503e-02f, 1.77477822e-02f, -5.50825261e-02f, 5.74189238e-03f, -7.60712149e-03f, -1.43094555e-01f, -4.98527251e-02f, 7.00407894e-03f, -2.68009845e-02f, -1.22873850e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -3.29708494e-02f, 1.83848497e-02f, 1.30716965e-01f, 2.09847555e-01f, -8.07244517e-03f, 1.17843695e-01f, 1.50384367e-01f, 4.14746180e-02f, 6.99534044e-02f, 1.56881854e-01f,
  2.30677560e-01f, 3.29283774e-02f, 8.00342262e-02f, 8.26979652e-02f, 1.64162248e-01f, 1.43338650e-01f, 9.77242589e-02f, 4.45266403e-02f, 1.64185926e-01f, 1.21378563e-01f,
  -9.66865942e-03f, 5.01647331e-02f, 2.77147949e-01f, 2.06742398e-02f, 2.21924365e-01f, 1.78449512e-01f, 1.55773848e-01f, -1.31023210e-02f, 2.81182006e-02f, -2.56042704e-02f,
  3.01260501e-02f, -1.27209630e-02f, 2.14541316e-01f, 1.46291822e-01f, 1.66273713e-01f, 7.10130408e-02f, -3.42664905e-02f, 8.47932100e-02f, 3.89922336e-02f, 1.17949039e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.16749190e-02f, -6.91339225e-02f, -3.54644172e-02f, 1.09421998e-01f, -9.01524629e-03f, -1.12453811e-01f, 2.49055531e-02f, -9.50922072e-02f, 3.39091904e-02f, 1.17003746e-01f,
  7.56869242e-02f, -5.98052144e-02f, 1.19837232e-01f, -1.35468915e-01f, -5.79278730e-02f, -1.95575982e-01f, 1.81529671e-01f, 1.83042318e-01f, 8.86389464e-02f, 1.10174127e-01f,
  5.31417467e-02f, -1.03001110e-01f, -9.64622051e-02f, -1.67688370e-01f, 1.21700153e-01f, -8.43008384e-02f, -1.30018100e-01f, -8.94469172e-02f, 1.21524267e-01f, 3.07589322e-02f,
  -1.88040584e-01f, -7.14560896e-02f, 1.94244653e-01f, 3.10141683e-01f, 1.92395747e-02f, -7.67339021e-02f, 1.43037409e-01f, -2.13639170e-01f, -1.81240112e-01f, 7.99529329e-02f,
  -2.23883659e-01f, -2.65321642e-01f, 2.53589123e-01f, 1.10388346e-01f, 1.77948087e-01f, -1.88148573e-01f, 1.50115982e-01f, -1.60426199e-01f, 3.08497071e-01f, -1.54430822e-01f,
  2.40611807e-01f, -3.97963338e-02f, -2.13520870e-01f, 1.17021138e-02f, -6.05380237e-02f, 4.59060855e-02f, -7.63111711e-02f, -1.36297286e-01f, 3.17327008e-02f, 1.32072642e-01f,
  -2.15308182e-03f, 8.24531391e-02f, -4.98249568e-02f, -1.08825471e-02f, -3.36525626e-02f, 7.26007745e-02f, 5.10917343e-02f, -1.46036558e-02f, -8.19042698e-02f, -4.21126187e-02f,
  7.09179416e-02f, -1.40218616e-01f, -3.24023962e-02f, -2.07786947e-01f, 9.45318192e-02f, -7.06630051e-02f, 7.35070482e-02f, 1.34662926e-01f, 9.34532657e-02f, 1.37630463e-01f,
  6.52383640e-02f, -5.49170971e-02f, -6.39403760e-02f, -1.94045216e-01f, 1.95135754e-02f, 9.63262618e-02f, -2.98105204e-03f, 1.61589235e-01f, -1.87992945e-01f, -2.33312007e-02f,
  -6.06437251e-02f, 1.34282097e-01f, -2.02137884e-03f, 8.36228952e-02f, 2.79758871e-02f, -1.45865723e-01f, -2.17062294e-01f, -2.91208085e-02f, -9.98788103e-02f, 2.59488970e-01f,
  -1.40741929e-01f, -1.19328685e-01f, -1.38438985e-01f, -1.08912839e-02f, 1.10307217e-01f, -1.40637279e-01f, 4.90641072e-02f, 5.40561378e-02f, -7.76148811e-02f, 3.49316858e-02f,
  1.62215903e-02f, 7.71287978e-02f, -5.14491796e-02f, 7.50802457e-02f, 1.42424434e-01f, -1.31154969e-01f, -1.21276006e-01f, 3.92348766e-02f, -1.96995124e-01f, 7.46012628e-02f,
  5.24275564e-03f, 2.14748960e-02f, 6.57220930e-02f, 4.75125797e-02f, -6.78560277e-03f, -7.92468414e-02f, 5.60320430e-02f, -8.07043761e-02f, 1.91748235e-02f, -4.48284633e-02f,
  8.25461745e-02f, -9.45350602e-02f, 8.58572721e-02f, -7.11295381e-02f, -1.58347651e-01f, 7.96027407e-02f, -4.93663549e-02f, -3.32297981e-02f, -1.82370350e-01f, -5.26944362e-02f,
  -1.27035469e-01f, -9.25425664e-02f, 5.33668287e-02f, -6.75174370e-02f, -1.58874571e-01f, 6.22520484e-02f, -1.17278574e-02f, 3.57481688e-02f, -3.85883935e-02f, -5.80782779e-02f,
  1.42707646e-01f, -2.01589063e-01f, 1.70214549e-01f, 1.39943346e-01f, 4.11097370e-02f, -2.06878975e-01f, 5.51072918e-02f, -5.10943867e-02f, 8.75086188e-02f, 1.57878637e-01f,
  1.16169497e-01f, 1.31471679e-01f, -5.04637398e-02f, 2.91249789e-02f, 9.05951411e-02f, 1.57418102e-01f, -1.46696134e-03f, 1.76239163e-01f, -5.76590449e-02f, -1.04375124e-01f,
  -5.92969684e-03f, -1.94524258e-01f, 1.30162269e-01f, -4.38677482e-02f, -4.46817502e-02f, -1.25005357e-02f, 2.25392394e-02f, -2.82276273e-02f, -1.49403393e-01f, 5.17059974e-02f,
  1.21745087e-01f, 7.85744097e-03f, 1.78167522e-02f, -5.50905056e-03f, 1.61901072e-01f, 1.15872793e-01f, -4.27536760e-03f, -4.92308922e-02f, 2.47510314e-01f, 6.56582341e-02f,
  -1.11284740e-01f, 5.73735759e-02f, -5.51745482e-02f, -2.92016827e-02f, 9.57567394e-02f, -1.27270594e-01f, 2.39700358e-02f, 9.88319814e-02f, -1.25876702e-02f, -5.73537573e-02f,
  -3.70766595e-02f, -3.64756808e-02f, 6.15607686e-02f, 4.37116735e-02f, -1.68119997e-01f, 1.85957864e-01f, 1.13153629e-01f, -7.53445178e-02f, 2.42911577e-01f, 7.20920116e-02f,
  5.63187301e-02f, -2.22688854e-01f, -8.77676606e-02f, 4.10513915e-02f, 1.20037109e-01f, -3.01089063e-02f, -8.48372355e-02f, -7.14284927e-03f, 7.36314282e-02f, 1.04592610e-02f,
  -4.38924916e-02f, 8.73392150e-02f, -6.21687435e-02f, -1.01912320e-02f, 4.05925959e-02f, -1.25936791e-01f, -4.68984470e-02f, 5.37003092e-02f, 8.07625055e-02f, 1.12416312e-01f,
  -1.28788173e-01f, -3.11025977e-02f, 2.52174139e-01f, 1.04740866e-01f, 4.75732125e-02f, 1.12046905e-01f, -1.68358028e-01f, 7.32907578e-02f, 2.41500497e-01f, 1.58575282e-01f,
  1.29429158e-02f, -3.36112864e-02f, -7.35068470e-02f, 1.48766469e-02f, 9.76269245e-02f, -1.18722692e-01f, -1.19836330e-01f, -3.93790975e-02f, -6.74187914e-02f, -6.10945523e-02f,
  6.66295886e-02f, 5.55268079e-02f, 7.23572671e-02f, -6.44474104e-02f, 3.07326484e-02f, 1.60219446e-02f, -6.02777041e-02f, 1.15157209e-01f, -3.46647650e-02f, -9.55921561e-02f,
  1.21608712e-01f, 1.10942304e-01f, 1.94622934e-01f, 8.27459767e-02f, -9.22999233e-02f, -4.94743995e-02f, -1.25086308e-01f, 1.97137911e-02f, -6.60123164e-03f, 2.07997516e-01f,
  7.99204707e-02f, -9.00478736e-02f, 1.45537153e-01f, -2.14924244e-03f, 1.37971804e-01f, -1.30113170e-01f, -1.43098965e-01f, 4.52800319e-02f, -5.96955419e-03f, 7.99698457e-02f,
  -1.56530991e-01f, -1.13134034e-01f, 1.61001757e-01f, 6.27589375e-02f, -1.37711570e-01f, 1.69871122e-01f, 4.43572132e-03f, -2.86148172e-02f, -3.94494720e-02f, -8.37321952e-02f,
  -1.36414245e-01f, 1.21879652e-01f, -7.44400769e-02f, -2.55362540e-02f, 9.07956064e-02f, -1.36259897e-02f, 2.17776254e-01f, 2.74075329e-01f, 2.12790910e-02f, 1.08725622e-01f,
  -1.01973740e-02f, 1.27480224e-01f, 6.13004416e-02f, 1.28659472e-01f, -6.49691280e-03f, 1.88061893e-01f, 1.57641977e-01f, -8.99027064e-02f, 8.92806649e-02f, -2.93849614e-02f,
  -5.52796982e-02f, 7.27847172e-03f, -3.84238213e-02f, -1.15057439e-01f, -2.35336814e-02f, -3.51441540e-02f, 1.93481483e-02f, -2.36967832e-01f, -6.42893761e-02f, 6.52400330e-02f,
  -3.82383652e-02f, -1.33356661e-01f, -5.50395511e-02f, -4.06556912e-02f, -2.11979330e-01f, -6.15910068e-02f, 3.18893977e-02f, -3.27626355e-02f, -1.06012203e-01f, 5.57279065e-02f,
  -4.75233868e-02f, 2.07533110e-02f, 8.50621834e-02f, 7.90202171e-02f, 5.97967207e-02f, 4.74695601e-02f, -2.75369197e-01f, 1.93052560e-01f, 1.12050876e-01f, 1.63102835e-01f,
  1.75999343e-01f, -1.18122526e-01f, -6.52723759e-02f, -9.37067494e-02f, -3.02659851e-02f, -1.27515662e-02f, -3.05918939e-02f, -4.29460453e-03f, -1.04640059e-01f, -1.78095251e-01f,
  1.85232013e-01f, 1.38656467e-01f, -8.24519247e-02f, -2.30685607e-01f, 1.32431030e-01f, -1.85532004e-01f, -3.04749578e-01f, -1.28744811e-01f, 1.27462959e-02f, 1.66807160e-01f,
  -2.27473915e-01f, 2.16110013e-02f, -3.21966112e-02f, -2.05470055e-01f, -2.97863428e-02f, -8.98535624e-02f, 1.08436517e-01f, 4.20413427e-02f, 3.53407972e-02f, -1.53449222e-01f,
  7.10630044e-02f, -1.08615942e-01f, 3.77966389e-02f, 4.42302972e-02f, 2.61288077e-01f, 1.52730957e-01f, 2.29547787e-02f, 1.21275187e-01f, -7.08766729e-02f, 2.21192032e-01f,
  9.99191180e-02f, 1.03016064e-01f, 2.27677915e-03f, -1.06673706e-02f, -4.23111729e-02f, -3.09361815e-02f, -2.24298611e-02f, 2.01920852e-01f, -3.23297568e-02f, 4.50068302e-02f,
  9.90702063e-02f, -1.43432477e-02f, 9.36141163e-02f, 5.08008115e-02f, 1.12455145e-01f, 1.23910487e-01f, 2.27427527e-01f, -3.88783179e-02f, -2.09475502e-01f, -2.46271603e-02f,
  3.05738002e-01f, 6.73482418e-02f, 4.89731841e-02f, 1.23369344e-01f, 7.78539013e-03f, 1.10223489e-02f, -1.36499122e-01f, -4.33523320e-02f, 1.23004280e-02f, 3.83561552e-02f,
  -4.36177254e-02f, 1.47082835e-01f, -1.41243845e-01f, 5.14265485e-02f, -1.93751663e-01f, -1.01886824e-01f, -7.32171908e-02f, -1.11515149e-02f, 4.81486060e-02f, -1.30801633e-01f,
  -9.62689891e-02f, -2.97255367e-01f, -1.87957078e-01f, -1.41415104e-01f, 1.50386229e-01f, -4.86582592e-02f, 3.14495027e-01f, 4.38392982e-02f, 2.26149663e-01f, -6.42349869e-02f,
  1.75784826e-01f, 4.96193394e-02f, 1.40073031e-01f, -1.95747107e-01f, 1.36705905e-01f, -1.58741042e-01f, -9.04623270e-02f, 7.76135474e-02f, 3.81254777e-02f, 8.00819770e-02f,
  -6.88632801e-02f, -1.21539541e-01f, 1.49510577e-01f, 2.46203646e-01f, -9.53840986e-02f, 3.75408642e-02f, 1.06604755e-01f, -7.84201771e-02f, 1.90915074e-02f, 7.39296246e-03f,
  1.21105261e-01f, 1.01102479e-01f, 8.70801285e-02f, -1.90239232e-02f, -9.00774449e-02f, 6.19334467e-02f, 8.55475962e-02f, -4.80702370e-02f, -1.86147057e-02f, 1.62547119e-02f,
  4.63248193e-02f, -1.91151932e-01f, -7.49215782e-02f, -7.29300722e-04f, -7.71082193e-02f, 1.30098671e-01f, -1.20918818e-01f, 1.01973459e-01f, 2.08240878e-02f, -7.39389732e-02f,
  7.21081719e-02f, -1.32439837e-01f, 1.17194943e-01f, 1.44865783e-02f, -5.80595545e-02f, 3.19159962e-02f, 9.63708460e-02f, -4.87146825e-02f, 1.65050566e-01f, 3.79424542e-03f,
  -4.90559870e-03f, 1.38062052e-03f, 6.73618466e-02f, -2.64386386e-01f, 1.01282462e-01f, -2.53295954e-02f, 3.64634618e-02f, -3.89080122e-03f, -7.77825192e-02f, -1.87013775e-01f,
  -1.81969866e-01f, -1.98163018e-01f, 1.49742756e-02f, -8.16157386e-02f, -1.57616735e-01f, 8.35504662e-03f, 1.86354622e-01f, -8.51539597e-02f, -8.62327144e-02f, 3.80745456e-02f,
  -8.99807923e-03f, 1.44133627e-01f, 2.03912824e-01f, 1.74289003e-01f, -3.04714423e-02f, 1.94183037e-01f, -1.20338440e-01f, 1.18875980e-01f, -7.20381588e-02f, 1.56439885e-01f,
  -9.96080041e-02f, -9.29302573e-02f, 5.22986576e-02f, 7.62500837e-02f, 1.47907183e-01f, -6.17225096e-02f, -1.61136524e-03f, -6.72430098e-02f, -8.65516737e-02f, -2.73322221e-02f,
  -1.02075048e-01f, 4.41018865e-02f, 4.40431871e-02f, 1.01052076e-01f, 1.21019945e-01f, 1.14246570e-01f, 2.45556056e-01f, -5.64917214e-02f, -7.19111562e-02f, 1.60506338e-01f,
  -1.69829473e-01f, -1.29705518e-01f, 5.84864244e-02f, -7.60575086e-02f, 9.90581438e-02f, 2.60175467e-01f, -9.06524584e-02f, 1.03047661e-01f, 1.44192111e-02f, 2.17144191e-01f,
  9.35022458e-02f, -7.08826678e-03f, 1.46380058e-02f, -5.81339970e-02f, -1.24324948e-01f, -2.09251679e-02f, 2.39297569e-01f, 8.10298249e-02f, 1.59166381e-01f, 8.40833262e-02f,
  -3.31531353e-02f, 8.57759118e-02f, -9.02987346e-02f, -8.44561774e-03f, 1.05011180e-01f, -7.41246119e-02f, -5.76748773e-02f, -1.22014187e-01f, -1.30207300e-01f, 1.46944560e-02f,
  6.47766292e-02f, 1.91493466e-01f, 5.43440953e-02f, 7.53076449e-02f, 1.26989096e-01f, -3.44330370e-02f, -1.13486581e-01f, -3.19572836e-02f, -7.74455294e-02f, -3.53510529e-02f,
  -3.69432062e-04f, 1.33158982e-01f, -1.99994147e-01f, 1.00170702e-01f, 1.17370151e-01f, 2.95857986e-04f, 9.10319313e-02f, 9.93822329e-03f, 6.56396896e-02f, -5.23454808e-02f,
  1.61238775e-01f, 1.42583549e-01f, 7.72704780e-02f, 6.57159612e-02f, 4.64547286e-03f, 1.02374382e-01f, 1.44642845e-01f, 1.04726575e-01f, -1.99041709e-01f, -1.30069390e-01f,
  -2.33854175e-01f, -5.59208170e-02f, -1.67649314e-01f, -1.43958330e-01f, 3.21673937e-02f, 7.83275291e-02f, -1.88044935e-01f, -5.35335112e-03f, 1.62684709e-01f, -1.88663110e-01f,
  2.13643417e-01f, 3.59102264e-02f, -2.43084338e-02f, -1.80514514e-01f, 1.11001164e-01f, -1.54782936e-01f, 1.18893221e-01f, 1.17376648e-01f, 2.07987964e-01f, 3.63956168e-02f,
  6.39675930e-02f, -1.94790930e-01f, 1.11469217e-01f, -4.12496086e-03f, 1.98977277e-01f, -1.22834116e-01f, 7.44318292e-02f, 6.23282511e-04f, -9.12342146e-02f, 1.63959861e-02f,
  5.54961488e-02f, 1.35045081e-01f, 1.90950245e-01f, -1.28345359e-02f, 7.90201575e-02f, -6.84539378e-02f, -1.07687242e-01f, -5.04820868e-02f, 1.10745043e-01f, 2.27104127e-02f,
  4.78689969e-02f, -3.07935104e-02f, 7.13306144e-02f, -4.66391370e-02f, 2.59945780e-01f, 1.46238685e-01f, 3.82429846e-02f, 4.17290302e-03f, -5.32080419e-02f, 1.54410437e-01f,
  -2.47951783e-03f, 1.45938516e-01f, -7.00495839e-02f, 8.12179223e-03f, 1.01787351e-01f, 1.16538770e-01f, -1.43986911e-01f, -9.11205634e-02f, 8.56602415e-02f, -1.63476467e-02f,
  -1.65925801e-01f, -1.55648351e-01f, -3.19947898e-02f, -6.94312751e-02f, 1.38955889e-02f, -2.36246586e-01f, 2.34038651e-01f, -1.05035014e-01f, 3.73802111e-02f, -5.54790162e-02f,
  -8.83485526e-02f, -5.46789616e-02f, -3.35735232e-02f, 8.69380161e-02f, 1.12891309e-01f, -2.02270657e-01f, 7.86200762e-02f, 9.21381712e-02f, 1.82566047e-01f, 2.41109118e-01f,
  -1.97381303e-01f, -6.27104044e-02f, 1.16599835e-01f, 1.48722231e-01f, -1.10832021e-01f, 1.61303535e-01f, 2.57614672e-01f, -9.99489427e-03f, 2.14870600e-03f, -2.49804184e-02f,
  1.83902234e-02f, 9.87435058e-02f, 3.71831506e-02f, -8.72044787e-02f, 2.16648191e-01f, -2.06401378e-01f, 5.18542183e-05f, -1.51642695e-01f, 8.50811675e-02f, 1.04486279e-01f,
  1.04444891e-01f, 1.51853532e-01f, 2.74039712e-02f, 1.82133302e-01f, -3.01578403e-01f, 1.13541164e-01f, -7.50673339e-02f, -8.91468897e-02f, 5.77528728e-03f, -2.43725061e-01f,
  -1.21070668e-02f, -1.45916611e-01f, -2.56921887e-01f, -7.81203955e-02f, -1.43246632e-02f, 1.16771601e-01f, 8.63921791e-02f, 1.48293108e-01f, 1.09778970e-01f, -7.63118267e-02f,
  -5.32141216e-02f, 3.25748064e-02f, 6.74149534e-03f, -1.82628091e-02f, 1.63078755e-02f, -6.48851767e-02f, 1.43123135e-01f, 1.08450139e-02f, -2.97396095e-03f, 8.48726332e-02f,
  -5.40156588e-02f, 2.61621594e-01f, 5.70641942e-02f, 1.59208491e-01f, 1.59028113e-01f, -1.08548865e-01f, -1.41697809e-01f, -9.81684923e-02f, 1.63209558e-01f, -1.33386537e-01f,
  -8.21057111e-02f, -4.98813391e-02f, 1.16285466e-01f, -5.37881218e-02f, -1.18600782e-02f, -1.05243899e-01f, 1.59321576e-02f, 1.88171461e-01f, 1.26416132e-01f, -1.63835153e-01f,
  1.54524326e-01f, -1.85282100e-02f, -1.81252956e-01f, -3.02793831e-02f, -2.04850703e-01f, -2.36544177e-01f, 3.22547369e-02f, 5.14149293e-02f, 1.23754241e-01f, -1.01772018e-01f,
  -4.11511213e-02f, -2.69534409e-01f, -1.84367932e-02f, -7.68932626e-02f, 2.61706859e-01f, -6.69826521e-03f, -1.67445719e-01f, 1.40406713e-01f, 1.01191573e-01f, -7.10712420e-03f,
  1.05893984e-01f, 1.31359035e-02f, -1.15643896e-01f, -6.99790195e-02f, 3.31469346e-03f, 1.26084030e-01f, -8.52900222e-02f, -5.25877364e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.57749164e-02f, -1.45305231e-01f, 1.69911131e-01f, 5.87357357e-02f, -1.22790188e-01f, 5.44711724e-02f, 7.05016330e-02f, 2.72307619e-02f, 2.02673278e-03f, -5.01071699e-02f,
  -1.03347907e-02f, 1.33656994e-01f, 2.46541530e-01f, 1.18776634e-01f, -3.01104621e-03f, 2.32363641e-02f, -1.03318617e-01f, 1.92827970e-01f, -1.41081944e-01f, -5.06286584e-02f,
  1.26303714e-02f, -4.89852875e-02f, 9.63468924e-02f, 1.41016304e-01f, -1.33907363e-01f, 6.34461176e-03f, 1.59247696e-01f, 1.86868876e-01f, -1.06667213e-01f, -2.26473704e-01f,
  -3.16951871e-02f, -2.44158462e-01f, -1.16405739e-02f, 5.15456274e-02f, 1.08299479e-01f, 1.69970199e-01f, -1.04573540e-01f, -1.20849282e-01f, -2.33074129e-01f, 1.20567298e-02f,
  -2.30451929e-03f, -3.35236788e-02f, 1.54412508e-01f, -5.04006036e-02f, -1.83795974e-01f, 1.71750933e-02f, 1.48023088e-02f, 1.08100601e-01f, 1.97599143e-01f, 1.87963732e-02f,
  1.22289874e-01f, -1.81856930e-01f, -8.46379250e-03f, -4.80443351e-02f, -2.38125194e-02f, 2.16112673e-01f, -4.61842567e-02f, -2.12503463e-01f, 1.21983223e-01f, 1.88743666e-01f,
  1.16150482e-02f, 9.73316282e-02f, -1.10421047e-01f, -1.23929344e-01f, 1.81750618e-02f, 1.53829336e-01f, 1.58442650e-02f, 1.51486859e-01f, -4.45296727e-02f, 5.87499551e-02f,
  2.34820902e-01f, 1.66024014e-01f, 2.03604549e-01f, 5.63370697e-02f, -2.56562955e-03f, 2.07273692e-01f, -1.95234403e-01f, 2.96571932e-04f, 1.68533310e-01f, -7.97263533e-02f,
  -2.26210468e-02f, 1.23432546e-03f, -5.11460640e-02f, -1.50058448e-01f, -1.89752117e-01f, 6.93617538e-02f, 1.48536280e-01f, -6.55354634e-02f, 3.05634830e-02f, 1.44400075e-01f,
  1.44507691e-01f, 5.69685698e-02f, -8.46176967e-02f, -1.47115469e-01f, 2.38970384e-01f, 1.07746325e-01f, 1.75054565e-01f, -1.21161282e-01f, 6.56027794e-02f, -1.31572351e-01f,
  -1.37610920e-02f, 1.82952851e-01f, 2.04622880e-01f, -4.75188009e-02f, 2.73025960e-01f, 2.18458921e-01f, 1.37419358e-01f, 1.08926617e-01f, -1.70378238e-01f, 4.99930605e-02f,
  1.45604327e-01f, -2.68075000e-02f, 9.42842141e-02f, 5.52575924e-02f, -1.44980088e-01f, -1.53359789e-02f, 1.97653189e-01f, -1.74933568e-01f, -3.11747915e-03f, -8.69103298e-02f,
  -5.68150841e-02f, 1.03848755e-01f, 1.46895796e-01f, 1.79174915e-01f, -4.64262255e-02f, 7.84472227e-02f, -5.85134095e-03f, 1.38170302e-01f, 2.43185118e-01f, 1.20265409e-01f,
  3.31584029e-02f, 2.81331718e-01f, 3.01993847e-01f, 1.04805745e-01f, 2.12575436e-01f, 7.29506388e-02f, 1.22614332e-01f, 1.58951864e-01f, 1.17154688e-01f, 1.24107964e-01f,
  -2.41252318e-01f, -1.86365843e-01f, -2.63326287e-01f, 1.16266586e-01f, -1.63582981e-01f, -1.89258859e-01f, 2.62846857e-01f, 4.47633304e-03f, -2.08761975e-01f, 1.78707674e-01f,
  -5.02205379e-02f, -9.35536399e-02f, 1.16149411e-01f, 1.90915465e-01f, 1.42440543e-01f, -4.29694690e-02f, 3.12135052e-02f, -1.07457079e-01f, -1.58126410e-02f, 1.55159503e-01f,
  2.52955705e-01f, -9.33691338e-02f, 5.20819463e-02f, -8.48403499e-02f, 1.09164901e-01f, 2.74142951e-01f, 3.32002282e-01f, 4.11226451e-02f, 1.97566986e-01f, 2.27976322e-01f,
  2.08169192e-01f, 5.09199314e-02f, 1.67297944e-01f, 2.17583224e-01f, 2.32529998e-01f, -9.22727659e-02f, -4.44065332e-02f, 1.68733701e-01f, -6.61933646e-02f, 5.21132164e-02f,
  1.90282226e-01f, -1.37992069e-01f, 3.18431780e-02f, -1.34234026e-01f, 1.65973738e-01f, -1.00329265e-01f, 3.55940312e-01f, -1.85839996e-01f, 3.02441359e-01f, -4.55563003e-03f,
  9.28032328e-04f, 2.52375126e-01f, 6.07979819e-02f, 2.46289313e-01f, 1.51727751e-01f, 2.96842843e-01f, 2.95977473e-01f, 2.88141102e-01f, 1.20514907e-01f, 2.72261113e-01f,
  2.28843749e-01f, 8.84224027e-02f, 1.44157723e-01f, 6.12458065e-02f, 3.37872356e-02f, -4.67214733e-02f, -1.87658325e-01f, 7.56763071e-02f, 1.87039346e-01f, -1.08933210e-01f,
  6.11375831e-02f, -7.43310675e-02f, -1.22238109e-02f, -9.41766128e-02f, -2.03044817e-01f, 2.39686258e-02f, 2.05995411e-01f, -1.46766677e-02f, 1.23535238e-01f, 3.48411757e-03f,
  1.32475644e-01f, 1.76083341e-01f, 3.56362201e-02f, 1.32872746e-03f, 1.29611894e-01f, 7.16205239e-02f, -1.24818362e-01f, 1.98709637e-01f, 2.40363553e-01f, 2.45180335e-02f,
  5.34224324e-02f, -5.86742125e-02f, 2.11046245e-02f, -1.79619268e-01f, -9.57211033e-02f, -4.99081500e-02f, 2.02706277e-01f, -1.14223205e-01f, -1.74040515e-02f, -2.13687226e-01f,
  9.75437686e-02f, 2.31431633e-01f, 3.54456971e-03f, 1.89126953e-01f, 1.12288363e-01f, 2.43183896e-01f, -2.17768937e-01f, -2.29466148e-03f, 2.65160471e-01f, 1.42036811e-01f,
  7.31656924e-02f, -2.67861158e-01f, 1.59641448e-02f, 1.03158049e-01f, -2.24022031e-01f, -1.05075970e-01f, 2.92881224e-02f, 8.78779665e-02f, 8.35668892e-02f, 1.61266506e-01f,
  5.46161532e-02f, 6.20411942e-03f, 6.01740107e-02f, 1.91248447e-01f, -1.12367431e-02f, -7.30780810e-02f, 3.28907482e-02f, 4.04727459e-02f, -1.70355543e-01f, 1.98993161e-01f,
  1.80673599e-01f, 1.10868014e-01f, 2.76120510e-02f, -7.25673065e-02f, 8.45728740e-02f, -6.53173849e-02f, 1.57285500e-02f, 1.48870602e-01f, -1.25974836e-02f, 1.39950976e-01f,
  -4.24410924e-02f, 1.09829366e-01f, 1.28740951e-01f, 1.22977436e-01f, -1.59207478e-01f, 2.13502109e-01f, 1.48494482e-01f, 8.63711834e-02f, 1.71964131e-02f, -1.84484974e-01f,
  8.04875642e-02f, 2.13281084e-02f, 4.48616035e-02f, 1.35410830e-01f, 1.23485021e-01f, 1.24290206e-01f, 2.97352314e-01f, 1.52090624e-01f, -1.47594079e-01f, 1.41499445e-01f,
  -1.77331656e-01f, -7.26945652e-03f, 1.23293418e-03f, 4.03314345e-02f, -8.66156220e-02f, 1.43455997e-01f, -2.90255368e-01f, 3.62053476e-02f, 3.88117731e-02f, 2.48300680e-03f,
  -1.55604646e-01f, -2.42413089e-01f, -6.23593107e-02f, 9.50851291e-02f, 7.53146783e-02f, -7.08339661e-02f, -6.90295622e-02f, -2.27795169e-01f, 8.73765722e-02f, 1.29790589e-01f,
  -9.64593813e-02f, -8.14601406e-02f, -3.40645649e-02f, 3.11360490e-02f, 9.85953137e-02f, 7.50674605e-02f, -6.79535195e-02f, 2.52913916e-03f, -7.93569386e-02f, -6.51326030e-02f,
  -4.86787409e-02f, -2.54563633e-02f, -8.93853903e-02f, 5.05481251e-02f, 1.20199159e-01f, -2.66992390e-01f, 4.18651141e-02f, -1.31074980e-01f, -1.88548565e-01f, -3.85802314e-02f,
  -2.48919893e-02f, 1.22967869e-01f, 1.11804791e-01f, 6.88634664e-02f, 1.50817275e-01f, -2.05142424e-01f, 3.68043222e-02f, -1.11306291e-02f, 7.59034082e-02f, 1.25829324e-01f,
  -2.12162957e-01f, 1.53801199e-02f, 2.00838685e-01f, 3.59829396e-01f, -5.42381704e-02f, -3.80037278e-02f, 3.67123067e-01f, 1.80259243e-01f, 2.22545099e-02f, 1.38421794e-02f,
  -7.85591677e-02f, -1.75644204e-01f, -1.35482684e-01f, -2.17656583e-01f, -1.61985874e-01f, -6.42197728e-02f, -9.47832763e-02f, -1.01736382e-01f, 1.35890409e-01f, -4.39704880e-02f,
  -1.71655670e-01f, 2.28200376e-01f, 7.72421509e-02f, 3.23240459e-02f, -2.66863495e-01f, -2.65898779e-02f, -5.83496541e-02f, -7.05649983e-03f, -3.31047401e-02f, -2.20362358e-02f,
  -1.89858645e-01f, 2.69103926e-02f, -1.05173349e-01f, -1.50772557e-01f, 7.94313923e-02f, 2.34718174e-01f, 1.19021460e-01f, 1.60962522e-01f, 2.06468493e-01f, 2.09237814e-01f,
  -5.09454384e-02f, 1.36468962e-01f, 2.12571204e-01f, 2.66539693e-01f, -3.27609964e-02f, 2.09273607e-01f, -1.42479941e-01f, -1.14257991e-01f, -1.11783318e-01f, 2.61614863e-02f,
  -1.63149208e-01f, -1.67158782e-01f, 4.39059660e-02f, 2.59199858e-01f, -1.03401534e-01f, -1.33844256e-01f, -1.40750706e-01f, -2.36061335e-01f, 1.59185886e-01f, 1.61385864e-01f,
  1.21363275e-01f, -7.51183704e-02f, 8.19858834e-02f, 6.89385384e-02f, 1.69732034e-01f, 1.80982605e-01f, 1.55446827e-01f, 2.54152387e-01f, 4.48539145e-02f, -6.22541923e-03f,
  1.27779156e-01f, 5.69653548e-02f, 1.90862224e-01f, 1.67666852e-01f, -5.20400256e-02f, 1.19640142e-01f, -7.03199208e-02f, -1.25861943e-01f, 1.58173546e-01f, 8.98928754e-03f,
  1.15821287e-01f, 6.62153820e-04f, 2.22369388e-01f, 3.49554569e-02f, 3.66858467e-02f, 1.18212461e-01f, 1.88878611e-01f, 2.15205699e-01f, -6.49050400e-02f, -4.41988632e-02f,
  1.88935012e-01f, 2.08478078e-01f, -2.79359780e-02f, -1.77373990e-01f, 1.65611342e-01f, 1.35072529e-01f, -2.43514869e-02f, 3.65307331e-02f, 1.09748475e-01f, 4.05790880e-02f,
  -1.02288481e-02f, 2.79814750e-01f, 2.60445088e-01f, -3.23239788e-02f, -2.50553116e-02f, 7.53121376e-02f, 1.44816861e-01f, 1.43245697e-01f, 1.20460028e-02f, -5.50408708e-03f,
  1.82200044e-01f, -1.53007925e-01f, -8.03658739e-02f, 1.37020648e-01f, 6.32713502e-03f, 1.02989107e-01f, 2.15995491e-01f, 1.62020698e-01f, -6.87230239e-03f, 5.71207032e-02f,
  -2.80425817e-01f, -7.25343898e-02f, 2.01802313e-01f, -1.37631651e-02f, -2.21016034e-01f, -4.13454771e-02f, -1.65520296e-01f, -5.59332371e-02f, -1.26936033e-01f, -8.24650079e-02f,
  2.92871073e-02f, 4.67276461e-02f, -3.47742029e-02f, -1.46516711e-01f, 3.06435153e-02f, -7.68119693e-02f, -1.43194139e-01f, -7.84994513e-02f, -3.15926434e-03f, 7.58234262e-02f,
  -2.18893662e-02f, 2.05657169e-01f, 1.17477193e-01f, -1.02925539e-01f, 2.23999873e-01f, -1.96987510e-01f, 9.06649157e-02f, -1.49787188e-01f, 1.26930580e-01f, -1.61566436e-01f,
  -1.74591765e-01f, 1.96868315e-01f, 1.18742526e-01f, -6.43253550e-02f, 5.82861751e-02f, 1.20991357e-01f, 7.35133290e-02f, -2.03859657e-02f, 1.22401208e-01f, 4.36602607e-02f,
  -6.87880740e-02f, 1.22746155e-01f, 3.46115977e-02f, 1.28934994e-01f, 7.42712691e-02f, 3.05964053e-02f, 3.39066447e-03f, -2.81024980e-03f, -1.97031889e-02f, 5.59395030e-02f,
  1.57566071e-01f, 2.77141016e-02f, 5.98832853e-02f, 4.80537623e-04f, 3.06506038e-01f, 2.86002755e-02f, 9.94497091e-02f, 1.28473982e-01f, 1.32573709e-01f, 2.24588051e-01f,
  -1.71784773e-01f, -8.73239636e-02f, 1.20497346e-01f, -5.52387238e-02f, 1.70874614e-02f, 1.49621099e-01f, -2.49814428e-02f, 4.32744203e-03f, 4.99164313e-02f, 1.04233914e-03f,
  3.66245210e-02f, -6.17614314e-02f, -1.41600415e-01f, 2.34810840e-02f, -2.32347280e-01f, -1.95850015e-01f, 3.49403918e-02f, 5.31681031e-02f, -8.34177062e-02f, 7.21643940e-02f,
  -6.69757873e-02f, 1.21182047e-01f, -1.75602838e-01f, -1.79974809e-01f, 2.50301421e-01f, 9.30410344e-03f, 3.92219685e-02f, 9.21161920e-02f, 3.47439805e-03f, 2.14839503e-01f,
  9.56118980e-04f, -3.46531197e-02f, 2.00999647e-01f, -7.95307308e-02f, -1.23003796e-01f, -7.49943331e-02f, -2.14376543e-02f, 2.62952775e-01f, 8.46911874e-03f, 7.54269361e-02f,
  7.79289901e-02f, 2.11706072e-01f, 1.00066110e-01f, 1.22216366e-01f, 1.67585477e-01f, -1.91564754e-01f, -1.12726010e-01f, -5.85349686e-02f, 8.94551072e-03f, -6.03681169e-02f,
  1.59838367e-02f, -1.99907888e-02f, -7.32736140e-02f, -7.84141570e-02f, -1.26368567e-01f, 4.83018793e-02f, -9.00944620e-02f, -1.31826997e-01f, -1.79662496e-01f, 1.07091498e-02f,
  2.09790424e-01f, -1.57625020e-01f, -4.38661389e-02f, -6.96677016e-03f, 1.36399837e-02f, -1.07282205e-02f, -1.35076806e-01f, 1.75175041e-01f, 1.04513623e-01f, 1.26589045e-01f,
  -1.02120927e-02f, -4.71122935e-02f, 3.73058021e-02f, -1.13878533e-01f, 2.92302892e-02f, 4.86220606e-02f, 1.44748509e-01f, 2.49167569e-02f, 2.10402325e-01f, -2.32647527e-02f,
  -1.28945947e-01f, 1.34431710e-02f, 3.07718962e-01f, 7.53468126e-02f, 1.26917213e-01f, 3.80281955e-02f, 2.34311476e-01f, 2.22562805e-01f, -1.71713486e-01f, -5.71069196e-02f,
  3.75888161e-02f, -1.51284412e-01f, -1.78497702e-01f, -2.35109478e-02f, 1.01276807e-01f, 2.05020294e-01f, -4.09801491e-02f, 2.87800562e-02f, 1.18230313e-01f, -4.19381931e-02f,
  -2.45317772e-01f, -1.58053637e-01f, -1.17418878e-01f, -5.42270243e-02f, -5.66140153e-02f, -1.95202634e-01f, -1.29438281e-01f, -1.70087919e-01f, -8.19588602e-02f, -7.23022893e-02f,
  -3.48796360e-02f, -5.67512438e-02f, -7.57276267e-02f, -1.23927601e-01f, -7.99686685e-02f, -2.88475323e-02f, -2.69962400e-02f, -6.49107844e-02f, -5.89054488e-02f, -2.07989231e-01f,
  -6.98002726e-02f, 1.01507679e-02f, 5.91299906e-02f, 5.10419346e-02f, 1.25645503e-01f, -8.62700045e-02f, 2.70572990e-01f, 2.06951976e-01f, 5.24332523e-02f, -6.68369904e-02f,
  -6.26637861e-02f, -5.43112420e-02f, -6.47181943e-02f, 2.13325694e-01f, -6.33089393e-02f, 8.64617750e-02f, -1.92560554e-01f, 6.58721179e-02f, -7.25714415e-02f, 1.50209051e-02f,
  -8.29315484e-02f, -1.56217460e-02f, -9.23036188e-02f, -3.12157795e-02f, 6.79248944e-02f, 1.28806764e-02f, -1.66175142e-02f, -3.21013182e-02f, -1.60805508e-01f, -4.70858701e-02f,
  1.27535194e-01f, 1.42017141e-01f, -8.32163990e-02f, 1.31475836e-01f, -7.09702894e-02f, -9.69685987e-02f, -1.21724106e-01f, 3.50641869e-02f, -6.69550225e-02f, -3.35295536e-02f,
  -8.79596546e-02f, -9.25359037e-03f, -1.48480535e-01f, 1.21190786e-01f, -5.11336178e-02f, -4.04998921e-02f, 1.05538800e-01f, 1.50330542e-02f, 2.93605290e-02f, -1.56757236e-01f,
  -6.12758622e-02f, 8.52982104e-02f, 2.99407929e-01f, 1.83542352e-02f, 4.19648848e-02f, 3.66617218e-02f, 1.99570686e-01f, 1.42537445e-01f, -1.64827574e-02f, 1.80705652e-01f,
  9.35876891e-02f, 6.99426085e-02f, 4.63176221e-02f, -7.11856857e-02f, 1.78924622e-03f, 5.49224615e-02f, 3.03635132e-02f, 1.14969742e-02f, 5.70881069e-02f, 2.31480841e-02f,
  7.15067312e-02f, -1.65219352e-01f, -2.41211839e-02f, -1.98617563e-01f, 1.94661036e-01f, 1.63640790e-02f, -1.75945342e-01f, 1.39146015e-01f, -1.10539747e-02f, -2.13486046e-01f,
  1.74997211e-01f, 2.80163050e-01f, 1.11940823e-01f, 1.86656699e-01f, -6.82579279e-02f, -1.22068606e-01f, -1.20528430e-01f, 5.20185046e-02f, -1.22639649e-01f, 2.38914743e-01f,
  7.92356655e-02f, 8.44568666e-03f, -5.51274978e-02f, 7.63782337e-02f, -1.10262528e-01f, -1.94524109e-01f, 2.21516088e-01f, -4.56983075e-02f, -1.14405066e-01f, -2.01111525e-01f,
  -3.43742669e-02f, 1.00450374e-01f, 4.98566590e-02f, 1.98586315e-01f, 1.45313859e-01f, 6.83840588e-02f, 3.52939069e-02f, 9.98240188e-02f, -1.19212165e-01f, 2.60851204e-01f,
  -6.34902343e-02f, 1.98639304e-04f, -3.35300341e-02f, 1.49037361e-01f, -1.77034363e-02f, -1.18429743e-01f, -2.57808745e-01f, -2.44281188e-01f, 4.19612974e-03f, 4.62859273e-02f,
  9.47677623e-03f, 1.56848371e-01f, 6.85022771e-02f, -1.44379251e-02f, 1.10166326e-01f, 1.78793669e-01f, 7.52691478e-02f, 7.55516514e-02f, 1.30813718e-01f, 2.08066329e-01f,
  -1.39267102e-01f, 2.76728660e-01f, 1.99663043e-01f, -5.95273040e-02f, 1.68436781e-01f, 1.08411886e-01f, -3.32035385e-02f, -1.95741728e-01f, -1.74281493e-01f, 4.94474918e-02f,
  -5.73894829e-02f, 1.36160538e-01f, -1.01780355e-01f, -4.22224626e-02f, -7.96451271e-02f, 2.25090124e-02f, 5.51289245e-02f, 1.04754835e-01f, -6.55300766e-02f, 6.39928728e-02f,
  -9.83177871e-02f, -8.70764479e-02f, 1.55859971e-02f, 5.77130541e-02f, 7.35358447e-02f, -1.14808880e-01f, -6.10342585e-02f, -9.71557125e-02f, 3.07461917e-01f, 1.99725524e-01f,
  2.03984693e-01f, 6.97243512e-02f, -1.67013273e-01f, 3.87706347e-02f, 2.05337569e-01f, 1.90090492e-01f, -9.74262729e-02f, 4.75016423e-02f, 7.60145783e-02f, 2.55168118e-02f,
  -2.97159571e-02f, -5.50887436e-02f, -2.22199619e-01f, -5.32934181e-02f, -4.16476652e-02f, 1.06215496e-02f, 7.15272799e-02f, 7.29029402e-02f, 1.03952877e-01f, -6.85678869e-02f,
  2.81902432e-01f, 1.53086483e-01f, 2.73736477e-01f, 2.31002927e-01f, 3.17250527e-02f, 9.90897939e-02f, 1.60098955e-01f, 3.97175103e-02f, 2.60425694e-02f, 1.57711029e-01f,
  1.46959469e-01f, 1.06587283e-01f, -2.63692699e-02f, 1.43030182e-01f, -6.16033413e-02f, -5.19308522e-02f, -2.00058490e-01f, -6.70314059e-02f, 2.72957655e-03f, -1.74035177e-01f,
  -8.58997405e-02f, 4.81123552e-02f, 1.45399868e-01f, -2.46190652e-01f, -2.37904310e-01f, -9.36943144e-02f, 2.07465887e-01f, -2.17066571e-01f, 5.82409687e-02f, 1.58140630e-01f,
  2.05902979e-01f, 1.52977154e-01f, -9.99625400e-02f, 1.09469563e-01f, -1.01694651e-01f, 2.73965865e-01f, 9.74237993e-02f, 1.61707327e-01f, 1.87914878e-01f, 8.46823454e-02f,
  1.80168495e-01f, -5.21675460e-02f, -1.67435221e-02f, -2.00426817e-01f, -1.23733960e-01f, -1.10531703e-01f, 1.41467899e-01f, -1.75925672e-01f, 2.76561510e-02f, -1.00888871e-01f,
  2.67953128e-01f, 2.43609369e-01f, 2.02687532e-01f, 9.72071812e-02f, -9.06827077e-02f, 5.84194213e-02f, -1.30976260e-01f, 7.09129572e-02f, 6.67888522e-02f, 8.62018541e-02f,
  2.68622357e-02f, -1.70251518e-01f, -1.69140384e-01f, -5.27573153e-02f, -2.09898278e-01f, -9.48541448e-04f, 7.88568333e-02f, 1.17179513e-01f, 9.15418640e-02f, 2.16175571e-01f,
  1.14066549e-01f, 8.16173404e-02f, 2.92660624e-01f, 2.56007880e-01f, 2.01155782e-01f, -3.49364914e-02f, 1.27574846e-01f, 1.77037776e-01f, 3.03441808e-02f, 1.30743787e-01f,
  3.11914444e-01f, 1.51813790e-01f, 2.49324441e-01f, -1.20808050e-01f, -3.97616513e-02f, -2.09947646e-01f, -4.58415486e-02f, 1.16110377e-01f, -9.01694521e-02f, 3.12451720e-01f,
  -1.41915694e-01f, 4.00806703e-02f, 2.23873496e-01f, 1.89675987e-01f, -7.42450058e-02f, 1.47452265e-01f, -1.54557332e-01f, 1.47969529e-01f, -4.76883091e-02f, 6.73491368e-03f,
  -3.29104364e-02f, 2.09562331e-01f, 1.63385391e-01f, 4.91444953e-02f, 1.01537280e-01f, 6.29100725e-02f, 5.90060130e-02f, 7.03740716e-02f, 6.96234331e-02f, 8.22286680e-02f,
  -2.85180099e-02f, -7.60600790e-02f, -2.17625890e-02f, 2.11405475e-03f, 2.72404402e-02f, 1.01956211e-01f, 2.37826943e-01f, 3.62953097e-02f, 9.66975167e-02f, 2.48691849e-02f,
  -2.99375206e-01f, 3.90837193e-02f, 2.99810525e-02f, 4.21019979e-02f, 1.56224057e-01f, 8.57271701e-02f, 3.55793685e-02f, -2.71983504e-01f, -3.90306786e-02f, -1.12267524e-01f,
  1.34816080e-01f, 1.10252209e-01f, 1.75840288e-01f, -3.83479372e-02f, -1.16492972e-01f, -4.74875160e-02f, 8.65396708e-02f, 8.51095617e-02f, -5.58911376e-02f, 1.86211228e-01f,
  1.53808191e-01f, 2.32758388e-01f, 5.75857563e-03f, 1.45128161e-01f, 4.13872451e-02f, -2.18753256e-02f, -5.95902372e-03f, 2.67439276e-01f, -6.48409426e-02f, 4.94917631e-02f,
  4.82241772e-02f, 1.77112594e-01f, 1.24727795e-02f, 1.24644741e-01f, -1.06616996e-01f, 1.43677384e-01f, -7.01206103e-02f, -5.72488196e-02f, -2.53548652e-01f, -2.65361637e-01f,
  -1.14605471e-01f, -1.88051149e-01f, -1.25627667e-01f, 9.35489461e-02f, -4.93472395e-03f, 3.16097052e-03f, -1.86429605e-01f, -4.09046002e-02f, -2.43127480e-01f, -1.18398465e-01f,
  7.93104097e-02f, 4.30545509e-02f, 1.38322011e-01f, -1.60082447e-04f, -1.84467986e-01f, -3.62660252e-02f, -2.72902679e-02f, 1.53292671e-01f, 1.62700623e-01f, -1.13759980e-01f,
  -1.17690638e-01f, -1.89365834e-01f, -1.57885656e-01f, -3.77534702e-02f, 1.49784788e-01f, 4.73195165e-02f, -2.80828267e-01f, -1.96490481e-01f, 8.39594156e-02f, 1.14239603e-01f,
  -9.04568285e-02f, -7.18321884e-03f, 2.33320951e-01f, -2.03338742e-01f, -5.83588369e-02f, -8.43095779e-02f, -9.81032662e-03f, -6.62294701e-02f, -6.82506384e-03f, 1.64637640e-01f,
  1.81805119e-01f, -2.87154336e-02f, 1.00851327e-01f, 1.15374856e-01f, -4.76252362e-02f, -6.38889298e-02f, -1.80847645e-01f, 1.62540495e-01f, 1.40141413e-01f, 8.12645361e-04f,
  9.49079767e-02f, -1.53067391e-02f, 8.37182999e-02f, -9.76822749e-02f, -6.15099333e-02f, 8.20685178e-02f, 3.48695479e-02f, 1.22549020e-01f, 3.05353552e-02f, 9.44098160e-02f,
  2.83608943e-01f, 5.44142872e-02f, -2.01220140e-02f, -5.80321625e-02f, 2.07629934e-01f, -2.10835487e-02f, -2.94681843e-02f, 1.78420972e-02f, -1.89566296e-02f, 1.26610979e-01f,
  2.99574398e-02f, -4.90948372e-03f, 2.23297048e-02f, 7.91698843e-02f, 5.62526584e-02f, 1.53477550e-01f, 2.74037942e-02f, 7.97167867e-02f, -7.53901005e-02f, -8.55567902e-02f,
  6.29240051e-02f, 1.86771959e-01f, 1.68199167e-01f, 2.19386831e-01f, -1.03015944e-01f, 1.89531982e-01f, 2.23410010e-01f, -1.35313302e-01f, -1.94323882e-01f, 1.27883330e-01f,
  -1.25333210e-02f, 1.12178020e-01f, -8.61258209e-02f, 1.32106692e-01f, -1.10250197e-01f, -1.33726582e-01f, 1.42090499e-01f, -2.06650682e-02f, 2.15750076e-02f, 1.22433633e-01f,
  2.86951989e-01f, 2.25150988e-01f, 3.96747179e-02f, 2.25593016e-01f, 1.24512821e-01f, 7.14014098e-02f, 1.81921706e-01f, 1.71522453e-01f, 3.03446382e-01f, 1.39987931e-01f,
  -4.99085896e-02f, 1.18522331e-01f, 1.96855310e-02f, 1.05201073e-01f, -1.83882326e-01f, -1.27834484e-01f, 1.25285298e-01f, -3.90057899e-02f, -1.11583754e-01f, 2.01687999e-02f,
  1.13863364e-01f, -2.16410860e-01f, -1.40554205e-01f, 1.69849709e-01f, 5.56419278e-03f, 9.39373858e-03f, -1.47833273e-01f, -1.07705079e-01f, 6.53292146e-03f, -6.92012301e-03f,
  -7.93425143e-02f, -5.92667311e-02f, 6.39934987e-02f, -1.26093581e-01f, -2.10363135e-01f, -1.06049730e-02f, 1.34039193e-01f, 9.57952067e-02f, 1.17744990e-01f, 5.84282875e-02f,
  -3.40160504e-02f, 1.10739872e-01f, -2.36388445e-01f, 2.40650743e-01f, 1.34041131e-01f, 1.28787398e-01f, -2.16038555e-01f, 5.88683262e-02f, 2.17179116e-02f, 1.48721626e-02f,
  -2.94661447e-02f, 7.63661601e-03f, 3.17793727e-01f, -6.28687814e-02f, 9.16486979e-02f, 1.02533087e-01f, 1.80688292e-01f, 2.15624467e-01f, 7.39873201e-02f, -9.48986504e-03f,
  2.74447858e-01f, 1.50082842e-01f, 1.13512732e-01f, 1.19376428e-01f, 6.23943731e-02f, 1.37503043e-01f, 4.36809957e-02f, -4.40170392e-02f, 1.66695848e-01f, 3.99786280e-03f,
  -1.97241958e-02f, 3.93850952e-02f, 7.67143816e-02f, 1.53238863e-01f, 1.36637375e-01f, 2.23732322e-01f, 1.09349780e-01f, -1.85689360e-01f, 1.93010911e-01f, 5.34965470e-02f,
  -3.74691896e-02f, -1.95805073e-01f, -1.40960321e-01f, 1.10297330e-01f, -4.97965924e-02f, 1.31371588e-01f, -1.13255136e-01f, -4.40186784e-02f, 2.72352070e-01f, 4.42807265e-02f,
  -4.51435708e-03f, 6.19094037e-02f, -1.26580223e-02f, 1.13293253e-01f, -1.20188944e-01f, 6.71367049e-02f, -1.15673773e-01f, 7.14099482e-02f, 2.43147761e-01f, 1.01670638e-01f,
  -3.71997543e-02f, 6.51657209e-02f, 1.34977430e-01f, 1.93952471e-01f, 1.87194183e-01f, -7.74789676e-02f, -1.52480960e-01f, 6.71132579e-02f, 2.37218097e-01f, 6.21968135e-02f,
  2.02147931e-01f, -4.44713607e-02f, 1.33095771e-01f, 4.07150872e-02f, 2.21210405e-01f, -1.81343794e-01f, -2.54854411e-01f, 1.45018369e-01f, -2.17463806e-01f, -1.37189582e-01f,
  1.05940498e-01f, 1.90272242e-01f, -9.34791714e-02f, -3.33878286e-02f, 3.28981578e-02f, -1.28019020e-01f, 1.13202319e-01f, 1.83091387e-01f, 1.99255064e-01f, 2.72754490e-01f,
  2.37019926e-01f, 7.00100660e-02f, 2.51033545e-01f, 1.32684141e-01f, 8.33823457e-02f, 8.26312155e-02f, 6.21804409e-02f, 1.54260322e-01f, 3.33072275e-01f, 1.17140040e-01f,
  2.05555484e-01f, 1.97168738e-01f, 1.52408302e-01f, 1.23593174e-02f, -3.56443524e-02f, -1.71358138e-01f, 2.16118738e-01f, -2.20811695e-01f, -1.71033949e-01f, 1.31282285e-01f,
  6.40371814e-02f, -2.04594079e-02f, 1.50105789e-01f, 1.25323370e-01f, 9.51304939e-03f, 1.85487986e-01f, -2.07656816e-01f, -8.40476975e-02f, -1.68150455e-01f, 1.31136164e-01f,
  1.85528621e-01f, 1.92756459e-01f, -8.55502263e-02f, 1.39558325e-02f, -6.63266107e-02f, 1.27479762e-01f, -1.67422369e-01f, -2.41869062e-01f, 2.45278716e-01f, -1.55179262e-01f,
  2.14983955e-01f, -6.03987090e-02f, 5.64766005e-02f, 2.52759159e-02f, 1.11967146e-01f, 2.35263675e-01f, 1.81280538e-01f, -6.59197792e-02f, -6.91432431e-02f, 1.81259185e-01f,
  8.93238990e-04f, 9.69081596e-02f, 9.82362032e-02f, 4.45224345e-02f, -1.48042947e-01f, 4.98757744e-03f, -7.93416873e-02f, -7.28444802e-03f, -3.72083150e-02f, -2.64196515e-01f,
  1.46604087e-02f, 2.51180790e-02f, -2.60148551e-02f, 1.27582118e-01f, 1.31834909e-01f, 2.45739490e-01f, 1.83141112e-01f, 1.42017171e-01f, 2.09800340e-02f, 1.04243010e-01f,
  3.25407647e-02f, 6.03029551e-03f, 6.96416274e-02f, 1.09976918e-01f, 1.74809471e-02f, -6.45470545e-02f, -1.00353397e-01f, -7.02976435e-02f, -4.44413684e-02f, 1.05887465e-02f,
  2.33319491e-01f, -4.83859405e-02f, -8.49473029e-02f, 1.46820813e-01f, 6.83922321e-02f, -1.77700847e-01f, -2.72453986e-02f, 4.53940779e-02f, 1.65400311e-01f, 2.48887092e-01f,
  1.01145077e-02f, 1.27217382e-01f, -1.36768669e-01f, 2.38444492e-01f, 1.16033278e-01f, 5.95488660e-02f, 1.71067804e-01f, -6.57380000e-03f, 4.58704568e-02f, 1.19880088e-01f,
  -2.59035062e-02f, -2.73665339e-01f, 6.61762524e-03f, -1.58901036e-01f, 1.79445967e-01f, -3.05261780e-02f, -7.83641934e-02f, -1.51411697e-01f, 3.61903347e-02f, 2.69606590e-01f,
  6.68286756e-02f, 2.07423165e-01f, 1.14129158e-02f, 5.72711751e-02f, -4.74225916e-02f, 1.15681469e-01f, 5.73059581e-02f, 2.07151100e-02f, -1.92501798e-01f, -4.83643413e-02f,
  -1.09094195e-01f, 6.93968534e-02f, -2.35438570e-01f, -1.67498112e-01f, 1.79159030e-01f, 6.36722296e-02f, 2.96795815e-01f, 9.98306498e-02f, 1.10578634e-01f, 1.47078246e-01f,
  1.09248489e-01f, 1.61052495e-01f, 1.95814759e-01f, 1.13534033e-01f, 1.01965182e-01f, 2.42096692e-01f, 6.44117668e-02f, -6.66226223e-02f, -9.97392982e-02f, -1.44867778e-01f,
  -2.81123072e-01f, 9.33182240e-02f, -8.02030265e-02f, 2.28193238e-01f, -2.27816105e-02f, 1.24896385e-01f, 3.09055388e-01f, -1.14124574e-01f, -1.20597869e-01f, 1.57115951e-01f,
  3.70725505e-02f, 1.25895455e-01f, 1.69494879e-02f, -2.21653670e-01f, 2.40236104e-01f, 7.70930527e-03f, 1.62376836e-02f, 2.08213732e-01f, 2.20548615e-01f, -2.84169793e-01f,
  1.65372845e-02f, 1.81304246e-01f, 1.49303377e-01f, 1.69929489e-01f, 4.87553254e-02f, -2.40298081e-02f, -8.48128125e-02f, 3.05491518e-02f, -2.43294030e-01f, 4.43531014e-02f,
  2.17411578e-01f, 2.15848446e-01f, 2.07044452e-01f, -1.02643691e-01f, -1.61662012e-01f, 9.39709768e-02f, 2.13521093e-01f, -2.24506229e-01f, 2.37812579e-01f, 1.15699418e-01f,
  3.91661711e-02f, 9.80294421e-02f, -1.31423771e-01f, 1.47663265e-01f, -1.96511820e-02f, 2.69469500e-01f, 1.63109124e-01f, 2.50700772e-01f, 4.16170657e-02f, 7.98120275e-02f,
  7.25790784e-02f, 1.34258628e-01f, 5.89597784e-02f, 2.08497956e-01f, 2.33796403e-01f, 2.79632211e-01f, 6.68954849e-02f, 9.85408276e-02f, 1.90887433e-02f, 2.43257597e-01f,
  -2.34775692e-01f, 1.35853201e-01f, 1.51930347e-01f, 1.08359829e-01f, -8.40541199e-02f, -2.45677412e-01f, 6.91873953e-02f, -1.22598141e-01f, -2.46821314e-01f, 1.50707558e-01f,
  1.36838108e-02f, 2.10304394e-01f, -1.97835639e-01f, -6.65321499e-02f, 1.45285174e-01f, 9.95676890e-02f, 7.73951113e-02f, 2.77963310e-01f, -3.82397361e-02f, 6.72434494e-02f,
  1.49429709e-01f, -3.09713576e-02f, 1.01505317e-01f, 2.40495354e-02f, 1.40419260e-01f, 2.42462680e-01f, 2.91394204e-01f, 1.42021447e-01f, 2.29655802e-01f, 1.95223674e-01f,
  9.20697674e-02f, 1.72993436e-01f, -1.37343537e-02f, 4.12369482e-02f, -4.53060929e-04f, 9.52247307e-02f, -1.25218807e-02f, 1.78645849e-01f, -9.46316496e-02f, 1.01219483e-01f,
  7.00045004e-02f, -8.98646638e-02f, -6.03896193e-02f, -1.32317066e-01f, 1.81356326e-01f, 9.19151828e-02f, 2.08549544e-01f, -1.56649679e-01f, -7.49430135e-02f, -2.10993644e-02f,
  -4.98468243e-02f, 2.39776999e-01f, 1.22108020e-01f, 2.02539042e-01f, 6.92396536e-02f, 1.21231876e-01f, 1.90258533e-01f, 1.84451893e-01f, 1.03174143e-01f, 2.23197341e-02f,
  2.01473966e-01f, 1.69855103e-01f, 2.18329445e-01f, 4.63514253e-02f, 3.11604977e-01f, 2.39391495e-02f, 5.25051281e-02f, 2.15313837e-01f, 2.00110108e-01f, 3.75781208e-01f,
  -3.62261832e-02f, 2.42197871e-01f, 2.17176557e-01f, 1.67847589e-01f, -2.18318984e-01f, 1.61534548e-01f, 9.97824073e-02f, 9.35140811e-03f, -2.70185262e-01f, 5.47266640e-02f,
  -2.11231560e-01f, -1.42319307e-01f, 9.37029868e-02f, -2.21748188e-01f, -1.07580014e-01f, 1.49584010e-01f, 1.41148016e-01f, 4.50711399e-02f, -1.61522761e-01f, -2.50226229e-01f,
  -9.53945816e-02f, 1.93017768e-03f, 1.63438559e-01f, 5.10379076e-02f, 1.95006773e-01f, 2.74918526e-01f, 4.85897213e-02f, 5.32970428e-02f, 4.03669886e-02f, -1.88135371e-01f,
  -5.36413938e-02f, -1.63688987e-01f, 3.11145186e-01f, -6.79589137e-02f, -2.87509769e-01f, -6.25608638e-02f, 8.48729238e-02f, -1.75367564e-01f, -7.61827156e-02f, -1.84172660e-01f,
  1.85114648e-02f, -6.32788092e-02f, -9.86232236e-02f, 9.07996595e-02f, 1.09613433e-01f, -1.72963515e-01f, 7.25226402e-02f, 1.22947535e-02f, 9.36672371e-03f, 1.84424922e-01f,
  -3.91731299e-02f, 3.11410353e-02f, 1.38257280e-01f, 1.81034841e-02f, 2.82380637e-02f, 1.31200671e-01f, 9.44486335e-02f, 6.01162761e-02f, 2.07556009e-01f, -6.14920147e-02f,
  7.39423856e-02f, 5.94811141e-02f, 1.88286230e-01f, 1.66005224e-01f, 7.05322772e-02f, 2.15048082e-02f, 1.22648433e-01f, 8.84973034e-02f, -2.73926556e-01f, 4.56191860e-02f,
  -1.41171128e-01f, 2.45896894e-02f, -1.41863510e-01f, 8.96034017e-02f, -1.50258869e-01f, -1.23629738e-02f, -8.72659162e-02f, -2.35931665e-01f, -1.25131100e-01f, 9.50805023e-02f,
  3.86668630e-02f, 7.69130215e-02f, -2.53480789e-03f, -4.58900630e-02f, -2.43105292e-01f, -1.21007055e-01f, 1.33402988e-01f, 8.53030458e-02f, 2.44400457e-01f, 9.75197330e-02f,
  -5.19881584e-02f, 7.33389109e-02f, -3.54652926e-02f, 8.80575702e-02f, 8.36079419e-02f, -5.46047501e-02f, 1.87716812e-01f, -1.45789355e-01f, 1.56188766e-02f, -1.06256485e-01f,
  -1.06197469e-01f, 7.76531920e-02f, -8.86286646e-02f, -3.26944478e-02f, 1.18166834e-01f, -1.66131817e-02f, -1.61297202e-01f, -1.26365632e-01f, 1.01487361e-01f, -1.39793888e-01f,
  2.06685126e-01f, 8.03349242e-02f, 2.53638685e-01f, -1.83276343e-03f, 7.72060975e-02f, 1.50023997e-01f, 2.45526582e-01f, 1.69631690e-01f, 1.01278581e-01f, 1.31016195e-01f,
  1.15235522e-01f, 2.19710737e-01f, -1.78646483e-02f, 2.39372432e-01f, 2.75371969e-01f, 1.73572078e-01f, 7.82014802e-02f, -1.06552310e-01f, 3.91213372e-02f, -1.16363429e-01f,
  -1.04130633e-01f, 1.74673460e-02f, -6.27907217e-02f, 5.10128289e-02f, -1.40699059e-01f, -1.33156506e-02f, 3.40777934e-02f, 1.14613086e-01f, -8.10905695e-02f, 1.74312696e-01f,
  1.66322023e-01f, 7.21024424e-02f, -1.60468630e-02f, -1.62499681e-01f, 1.30047157e-01f, 2.22900093e-01f, -4.77009788e-02f, 5.69050312e-02f, 9.34174508e-02f, 8.30117613e-02f,
  5.00406288e-02f, 1.51603539e-02f, -3.19940560e-02f, 7.69804716e-02f, -1.31465688e-01f, 1.27093270e-01f, 1.09602027e-01f, 1.38193384e-01f, -1.02947950e-01f, 2.74747699e-01f,
  1.18866846e-01f, 6.75560161e-02f, 2.01921299e-01f, -3.71467955e-02f, -1.48014188e-01f, 1.30316213e-01f, 4.23238687e-02f, -8.31173435e-02f, -9.91664734e-03f, 1.01415068e-01f,
  -9.72114950e-02f, -1.73071712e-01f, 2.32759397e-02f, -1.00730043e-02f, 1.55289993e-01f, 1.43153042e-01f, 1.39469981e-01f, 1.79811761e-01f, 6.83594495e-02f, 1.09572485e-01f,
  1.75787359e-01f, 2.22466499e-01f, 6.63620047e-03f, 2.00471040e-02f, 1.07629105e-01f, 1.65426031e-01f, 1.93776742e-01f, -5.38639314e-02f, 1.46539102e-03f, -5.41679449e-02f,
  3.29822391e-01f, 9.30260047e-02f, 2.21096307e-01f, 1.64289758e-01f, 9.12960395e-02f, 2.50372440e-01f, -9.28826332e-02f, -9.32310373e-02f, 5.26935086e-02f, -9.77400988e-02f,
  -1.51324853e-01f, 4.66007106e-02f, -1.57108024e-01f, -4.90549132e-02f, 1.52853392e-02f, -2.40458131e-01f, -4.44564149e-02f, 6.62563443e-02f, -1.18515708e-01f, -2.68845931e-02f,
  4.05969098e-02f, -3.19069862e-01f, -1.39694214e-01f, -1.71050924e-04f, 7.40717575e-02f, 1.62908942e-01f, 1.26295671e-01f, 3.23630214e-01f, 1.67373404e-01f, 3.58778462e-02f,
  1.67403415e-01f, 7.86458775e-02f, 1.11255661e-01f, -7.66253611e-03f, 7.07026273e-02f, -1.83828875e-01f, -1.40619367e-01f, 3.57090384e-02f, -1.31122544e-01f, -1.32720070e-02f,
  -1.21149473e-01f, -1.60551310e-01f, 6.97808415e-02f, 1.42585963e-01f, 4.07842956e-02f, -1.25746867e-02f, 2.27768406e-01f, 7.08719194e-02f, 8.49668905e-02f, -1.49586231e-01f,
  -1.49686178e-02f, -2.13357180e-01f, -1.94242105e-01f, -9.42610502e-02f, -5.82917891e-02f, -1.31154075e-01f, -9.86083150e-02f, 1.92502458e-02f, 1.46188766e-01f, 2.52636187e-02f,
  -9.31399539e-02f, 2.56213367e-01f, -2.34265556e-03f, -2.57512212e-01f, 1.00789748e-01f, 1.03516184e-01f, -1.31146327e-01f, -2.83380926e-01f, -1.84963763e-01f, 1.02748983e-01f,
  -3.14446092e-02f, -6.21204190e-02f, 7.00194091e-02f, 2.30853222e-02f, 2.33271882e-01f, 1.17347054e-01f, 1.33327814e-02f, -1.10347390e-01f, -1.18538924e-01f, -9.13726464e-02f,
  -1.95038646e-01f, 5.45859002e-02f, -2.40852550e-01f, 2.58157730e-01f, -3.07850447e-02f, -3.79604511e-02f, -2.07248837e-01f, 1.07877232e-01f, -6.84262067e-02f, -2.13764966e-01f,
  2.22403854e-01f, -2.62076110e-02f, -1.09786116e-01f, 3.23467441e-02f, 1.90128043e-01f, 2.12838888e-01f, 1.33501932e-01f, -1.82882249e-01f, 4.53004465e-02f, 2.95631879e-04f,
  -6.35625944e-02f, -1.59543101e-02f, 4.51300330e-02f, 2.13903412e-01f, 5.89631237e-02f, -1.04635924e-01f, 1.37337774e-01f, 1.91477224e-01f, 5.04994094e-02f, 3.12766135e-02f,
  6.57899678e-02f, -9.68297385e-03f, 1.70523271e-01f, 9.23758075e-02f, 3.10453232e-02f, 6.60784170e-02f, 2.86415196e-03f, 2.03441769e-01f, 5.58123179e-02f, 1.90648764e-01f,
  -4.00459692e-02f, 4.44023721e-02f, -4.75401850e-03f, 1.42944455e-01f, -9.78333503e-02f, 1.87059909e-01f, -8.42628106e-02f, -4.44512106e-02f, 2.44955525e-01f, -1.76713169e-01f,
  -6.46627545e-02f, -5.08530363e-02f, -2.12179139e-01f, 1.86275810e-01f, 1.82818919e-01f, -2.75924206e-01f, -1.45061761e-01f, 1.98387370e-01f, -1.46801397e-01f, 1.22469045e-01f,
  -2.02866524e-01f, -8.15097764e-02f, 5.70819490e-02f, -6.25712276e-02f, 1.59060769e-02f, 5.04056066e-02f, 4.42839377e-02f, -2.19147667e-01f, 6.51795268e-02f, -5.70869260e-02f,
  -7.00121522e-02f, -6.63146302e-02f, 1.95752725e-01f, 2.89305598e-01f, 6.94512650e-02f, 1.72145471e-01f, -2.07231864e-01f, 1.84572816e-01f, 2.37345502e-01f, 1.12566240e-01f,
  -1.08655110e-01f, -1.13936566e-01f, -5.72800264e-02f, -2.58207936e-02f, -1.02037892e-01f, -1.15510553e-01f, 7.59902894e-02f, -3.69681753e-02f, 7.58167729e-02f, -6.80972636e-02f,
  -7.34239537e-03f, 2.77606142e-03f, 1.39993906e-01f, -2.39861943e-02f, 1.60987183e-01f, 7.12498650e-02f, 5.67105301e-02f, -2.04042867e-02f, 5.75572811e-02f, 4.24596779e-02f,
  4.19299379e-02f, -2.83611063e-02f, 1.13361813e-01f, 1.03879552e-02f, 2.14705437e-01f, 3.30138542e-02f, 2.31311321e-01f, 7.91534707e-02f, -1.20599270e-02f, 5.92033155e-02f,
  -2.41360068e-01f, -2.85940301e-02f, 7.30568692e-02f, 3.16078030e-02f, 1.30423695e-01f, 1.85776100e-01f, -3.18060182e-02f, 9.95619074e-02f, 2.27049906e-02f, -3.45680773e-01f,
  -1.39900610e-01f, -1.15409188e-01f, -1.34505540e-01f, -5.78210279e-02f, -1.30285591e-01f, 6.45742863e-02f, -1.25098184e-01f, -2.88623273e-02f, 9.75833982e-02f, -2.56068837e-02f,
  -2.05400422e-01f, 2.56158728e-02f, 8.32892582e-02f, -7.72083551e-02f, -3.54628041e-02f, -1.44305721e-01f, 1.38241068e-01f, -4.71914262e-02f, 2.19151154e-01f, 2.76794165e-01f,
  5.98492026e-02f, 2.53389686e-01f, 2.40088925e-01f, 5.62296212e-02f, -1.20130010e-01f, -1.44665793e-01f, -7.50861689e-03f, -1.46166191e-01f, -1.85392603e-01f, 1.92258358e-02f,
  1.26940578e-01f, -7.20421746e-02f, -5.06260898e-03f, -3.60669941e-02f, 3.71410847e-01f, -9.76033211e-02f, 2.92611927e-01f, -1.75152078e-01f, 1.34372383e-01f, 1.74447834e-01f,
  7.71465898e-02f, 1.61486953e-01f, 1.12114167e-02f, 1.34662658e-01f, 1.65577754e-01f, 9.45310891e-02f, -2.32699304e-03f, 1.34339660e-01f, 2.31438398e-01f, 6.76258728e-02f,
  1.14350691e-01f, -3.82882506e-02f, -9.31975320e-02f, -9.40504372e-02f, -1.19423166e-01f, -1.44455200e-02f, 1.17598057e-01f, -1.26370072e-01f, 2.10094377e-01f, 2.57004738e-01f,
  -2.01211721e-01f, 1.58814341e-01f, -1.56172484e-01f, -3.00310075e-01f, 2.83299200e-02f, -1.52980596e-01f, -7.17595685e-03f, -2.41455451e-01f, 2.50666905e-02f, 4.39977385e-02f,
  -2.93923438e-01f, -1.06473863e-01f, 2.88317174e-01f, -8.11148584e-02f, -9.43224877e-02f, 5.85706495e-02f, 2.55336557e-02f, -1.27580762e-01f, -9.62990597e-02f, -1.18750744e-01f,
  8.28161761e-02f, -1.05791446e-02f, 1.86130509e-01f, 2.53242344e-01f, 1.90024644e-01f, 8.29948261e-02f, 8.32998902e-02f, -1.35916382e-01f, 3.68420519e-02f, -3.46721485e-02f,
  9.10361260e-02f, -6.14464022e-02f, -9.35518667e-02f, 1.51596919e-01f, 1.80733904e-01f, 1.46348705e-03f, 2.29271233e-01f, -9.79222059e-02f, 3.41734260e-01f, -8.44463408e-02f,
  2.09061503e-01f, -1.48621067e-01f, -4.48748516e-03f, 2.39127502e-01f, 1.02386400e-01f, 6.92766020e-03f, 7.97585994e-02f, -1.17013581e-01f, -1.10468410e-01f, 5.36914282e-02f,
  1.47910595e-01f, 1.01922423e-01f, -9.06874835e-02f, -1.06208269e-02f, -7.65790790e-02f, 2.54376996e-02f, 1.38644934e-01f, 6.89448789e-02f, -4.94275019e-02f, -3.60952578e-02f,
  8.60645697e-02f, 2.16901228e-01f, -6.20888546e-02f, -2.54411623e-02f, 8.58737305e-02f, -1.25742421e-01f, 7.81765953e-02f, 1.61436364e-01f, -8.40466172e-02f, 7.89717063e-02f,
  1.86362714e-01f, 1.98160782e-01f, -2.10976601e-02f, 7.68762361e-03f, -6.57765493e-02f, 7.89585412e-02f, -4.53334022e-03f, 4.75089438e-02f, 2.38429755e-01f, 1.87496543e-01f,
  1.29941791e-01f, -2.42559277e-02f, -3.06122661e-01f, -3.25109139e-02f, 6.26466721e-02f, -5.80822751e-02f, 4.09045815e-02f, -1.85317565e-02f, -1.73478082e-01f, -7.02566877e-02f,
  -2.35922518e-03f, 1.50234383e-02f, 9.19229537e-02f, -1.33163691e-01f, 2.86807120e-01f, -5.59083074e-02f, 1.58176601e-01f, 6.47084340e-02f, 8.61944407e-02f, 2.65803605e-01f,
  -1.26423776e-01f, 9.93894860e-02f, -1.03887111e-01f, 1.37003019e-01f, -1.49414405e-01f, 1.10604828e-02f, 1.65002689e-01f, 6.55974150e-02f, 2.85526663e-02f, 1.97955117e-01f,
  -7.19657615e-02f, 1.89011559e-01f, 7.74077028e-02f, 1.13302432e-01f, 2.12115750e-01f, 1.41294107e-01f, 3.32769044e-02f, 3.34042870e-02f, -2.90395468e-02f, 3.47258933e-02f,
  -2.10383952e-01f, -1.24342397e-01f, -6.09293692e-02f, 8.42800736e-02f, 1.58750415e-01f, -1.19878337e-01f, 1.87357172e-01f, -3.36725749e-02f, -8.77476633e-02f, -4.83949296e-02f,
  -1.33753195e-01f, -1.83882192e-01f, 7.48095512e-02f, -4.75649983e-02f, -8.07555690e-02f, -1.36694714e-01f, 5.92335220e-03f, 8.50163847e-02f, -2.67319888e-01f, -1.04906492e-01f,
  9.99651477e-02f, -4.02452471e-03f, -1.16654702e-01f, 2.03581885e-01f, 8.51586461e-02f, -3.11296675e-02f, 9.20672268e-02f, -1.91852659e-01f, 8.98607746e-02f, -3.53218173e-03f,
  2.29967758e-01f, 1.29783779e-01f, 3.08991700e-01f, 5.84475100e-02f, 1.24397315e-01f, -1.03818335e-01f, -1.28091589e-01f, 2.45125398e-01f, 2.51029789e-01f, -1.75326750e-01f,
  -2.29317360e-02f, 1.72995880e-01f, -7.67262802e-02f, -1.36389434e-01f, 1.99781716e-01f, 9.35575515e-02f, 2.47828126e-01f, -2.05257833e-01f, -2.39312719e-03f, -3.58393532e-03f,
  -1.70699537e-01f, 1.95024282e-01f, 1.12891376e-01f, 1.89971194e-01f, 3.11034858e-01f, 1.77848935e-01f, 2.29609743e-01f, 9.70638916e-02f, 1.96618140e-01f, 1.55158445e-01f,
  1.74081758e-01f, 3.89765590e-01f, 1.89488202e-01f, 2.36064449e-01f, 2.24571094e-01f, -1.77467778e-01f, 1.83071226e-01f, 1.87984973e-01f, -1.40767351e-01f, 9.93348435e-02f,
  1.21969119e-01f, 2.96682864e-01f, 2.06587777e-01f, -4.06177016e-03f, 8.09499696e-02f, -6.60173222e-02f, 2.01764986e-01f, 1.20833188e-01f, -5.18796444e-02f, 1.54362589e-01f,
  3.74359749e-02f, -2.20217839e-01f, 1.38776854e-01f, 1.46513715e-01f, -6.61744326e-02f, -8.92690010e-03f, 2.52201110e-01f, -1.99443102e-01f, -1.87036201e-01f, 1.46606624e-01f,
  -4.65050247e-03f, 2.38920540e-01f, -9.01482627e-02f, 1.26656041e-01f, 4.28319685e-02f, 1.71979189e-01f, -4.73693684e-02f, 1.79151580e-01f, 1.65387943e-01f, -7.41594806e-02f,
  -1.02939487e-01f, -2.02352792e-01f, 6.84183240e-02f, 2.06561118e-01f, 1.00213513e-02f, 1.41605809e-01f, 2.77091056e-01f, 3.26875299e-02f, 1.34472907e-01f, 7.35335276e-02f,
  5.96012250e-02f, 8.19536373e-02f, 1.69743419e-01f, 1.77961424e-01f, 2.56486982e-01f, -5.65739386e-02f, 3.60766216e-03f, -1.11578293e-01f, 1.86585397e-01f, -2.32092831e-02f,
  -6.95515051e-02f, 9.46060047e-02f, -6.08887300e-02f, 6.68344437e-04f, 1.53008625e-01f, 2.08148044e-02f, 4.97902110e-02f, -1.66325141e-02f, -1.07718177e-01f, 2.69048125e-01f,
  1.68710530e-01f, -2.00117782e-01f, 2.77949810e-01f, 3.99118988e-03f, -1.38956338e-01f, -2.21598521e-01f, -2.45953962e-01f, -1.81894153e-02f, 2.08207607e-01f, 8.95648205e-04f,
  -1.42530233e-01f, 1.06111899e-01f, 1.71920836e-01f, 9.90396086e-03f, -6.60583526e-02f, -2.96625923e-02f, 4.20013070e-02f, -1.45539224e-01f, -2.95595713e-02f, 5.70207611e-02f,
  -1.10185288e-01f, 1.21221565e-01f, -6.27564779e-03f, 1.28183126e-01f, -1.75822303e-01f, -3.66384275e-02f, 3.74438753e-03f, 7.07097631e-03f, 1.52745575e-01f, 3.39246802e-02f,
  -2.13450521e-01f, 1.10898949e-01f, 2.27200463e-01f, 2.36441284e-01f, 2.00702026e-01f, -1.29465953e-01f, -3.06085944e-02f, 9.97615047e-03f, 1.10728510e-01f, -2.37103045e-01f,
  -1.53237447e-01f, 1.55817404e-01f, -4.32290807e-02f, -1.07980855e-01f, 6.94985166e-02f, -1.05048567e-02f, -5.44090569e-02f, -7.75090009e-02f, -1.86486300e-02f, -7.66960531e-02f,
  1.24248266e-01f, 6.71001598e-02f, 2.50827312e-01f, 2.26516515e-01f, 1.31920278e-01f, 1.27743170e-01f, 2.64745921e-01f, 2.01443300e-01f, 1.33982763e-01f, 1.28516227e-01f,
  6.80505335e-02f, 9.46039930e-02f, 6.74062073e-02f, 4.03596908e-02f, 2.83078521e-01f, -2.53457520e-02f, 1.06270835e-01f, 9.07497257e-02f, -4.96228822e-02f, 7.89293274e-02f,
  8.57962444e-02f, -4.01260471e-03f, 8.53019878e-02f, 1.19084865e-01f, -7.06436262e-02f, 1.53379723e-01f, -1.92801625e-01f, 2.12381229e-01f, -1.57316446e-01f, -5.46436049e-02f,
  -3.35265882e-02f, -1.51714459e-01f, -3.20773154e-01f, -7.22709224e-02f, 1.01027600e-01f, -1.95321858e-01f, -1.61319822e-01f, -1.44772515e-01f, -3.12794983e-01f, -2.44219378e-02f,
  4.02207188e-02f, -6.55556917e-02f, 1.66012868e-01f, 7.85434172e-02f, -1.50523841e-01f, 1.15819490e-02f, 6.34466559e-02f, 1.92731872e-01f, 1.28083065e-01f, -2.10536689e-01f,
  -3.10381912e-02f, -2.01004878e-01f, -1.80480719e-01f, -1.12837978e-01f, 1.42365128e-01f, 1.70553699e-02f, -3.47634614e-01f, -7.43414741e-03f, 1.59660559e-02f, 2.74465531e-01f,
  -2.31915489e-01f, 6.06981590e-02f, 2.30799854e-01f, -4.95570265e-02f, 4.41632606e-02f, -6.09600656e-02f, 1.22320205e-01f, -5.37267625e-02f, -1.51533008e-01f, -3.80890854e-02f,
  1.07206978e-01f, 2.28416082e-02f, 9.30599272e-02f, -9.02359709e-02f, 2.78783459e-02f, -6.66491222e-03f, 2.60917753e-01f, 1.20208286e-01f, 1.59976147e-02f, 1.46317631e-01f,
  1.92811042e-01f, 2.04365820e-01f, 2.32420396e-02f, -1.23923227e-01f, -1.27126891e-02f, 2.92861871e-02f, 1.00711063e-02f, 1.18570812e-01f, -1.06341474e-01f, 8.79211202e-02f,
  8.51269215e-02f, 1.02902450e-01f, 3.77196004e-03f, 1.57631144e-01f, 3.60124670e-02f, -2.23495532e-02f, -1.96484160e-02f, -5.69979511e-02f, 1.60970554e-01f, 2.97291934e-01f,
  2.66836863e-02f, -9.39823240e-02f, -5.94274066e-02f, 1.17628545e-01f, -4.66098785e-02f, -1.94520637e-01f, -6.03540707e-03f, -5.31379506e-02f, -2.84942187e-04f, -1.07664600e-01f,
  -2.71888357e-02f, 1.59016564e-01f, -3.10681723e-02f, 6.80335164e-02f, 2.90572494e-01f, -3.78991254e-02f, 3.51827890e-02f, -8.59389976e-02f, 1.18627854e-01f, 1.79371223e-01f,
  -1.51453629e-01f, 4.33658510e-02f, -8.38214755e-02f, 1.83453426e-01f, 1.14964927e-02f, 1.22277755e-02f, 5.50021455e-02f, -7.22229332e-02f, 1.17892884e-01f, 1.67639181e-01f,
  3.32581736e-02f, 1.19708724e-01f, 3.08968946e-02f, 2.03474119e-01f, 5.56578711e-02f, 1.65362000e-01f, 9.88719612e-02f, 6.42680526e-02f, 3.86565588e-02f, -5.26964739e-02f,
  1.77388132e-01f, -3.19325589e-02f, -2.88192444e-02f, 1.97849318e-01f, 2.05147296e-01f, -1.76518202e-01f, 5.30941077e-02f, 4.16153111e-03f, 1.04629643e-01f, -2.44361326e-01f,
  -2.97578871e-01f, 2.04499457e-02f, 1.47569761e-01f, -2.73204923e-01f, -9.01928470e-02f, 2.10471079e-01f, 7.09153563e-02f, 1.88564748e-01f, -2.61501908e-01f, 3.53047252e-02f,
  -2.04558209e-01f, -1.63976386e-01f, 4.84732650e-02f, 2.40078226e-01f, -6.39541894e-02f, -1.94696471e-01f, -8.54038261e-03f, -7.67703578e-02f, -1.05628535e-01f, -4.11646329e-02f,
  -9.56111867e-03f, 4.44943318e-03f, 1.44741699e-01f, -7.45612755e-02f, -1.32565245e-01f, -4.97941710e-02f, 1.11631788e-01f, 1.60914257e-01f, 3.52683038e-01f, -1.10499673e-01f,
  -9.05566588e-02f, 8.21092278e-02f, -2.40898296e-01f, 2.22726002e-01f, 2.35359117e-01f, 3.10731288e-02f, -1.67082220e-01f, 3.83895189e-02f, -5.45248911e-02f, -2.56033897e-01f,
  -2.06929520e-01f, -1.33458704e-01f, 1.92743585e-01f, -6.63161557e-03f, 1.93423375e-01f, 1.25187591e-01f, 2.70026978e-02f, 1.40440941e-01f, 1.33704934e-02f, 5.78567348e-02f,
  4.26889099e-02f, 1.21776536e-01f, -1.47743281e-02f, 1.68016627e-01f, 1.24840923e-01f, -6.00450579e-03f, 6.89032376e-02f, 1.68232456e-01f, -2.70405591e-01f, -3.16146649e-02f,
  2.62259357e-02f, 3.46890204e-02f, 2.38379657e-01f, -2.45969012e-01f, 9.25941244e-02f, 1.46176025e-01f, -4.11633253e-02f, 9.12180021e-02f, 2.08678514e-01f, 8.76040012e-02f,
  2.01511890e-01f, 2.52781957e-01f, 1.08498782e-01f, 4.25806493e-02f, -1.41873769e-02f, 9.09236968e-02f, 9.41782445e-02f, 1.59744665e-01f, -1.01358937e-02f, 2.24712178e-01f,
  1.34252369e-01f, 1.14622369e-01f, -1.50869548e-01f, -1.60275385e-01f, -1.33803681e-01f, -2.39624307e-01f, -9.79436189e-02f, -1.03226572e-01f, -2.95903862e-01f, 1.21268235e-01f,
  -3.69411297e-02f, 1.04669206e-01f, 3.52977552e-02f, 8.07650238e-02f, 1.39163554e-01f, -6.30819872e-02f, 4.95803952e-02f, 3.86045128e-02f, 1.87879145e-01f, 1.98394671e-01f,
  -1.75911799e-01f, 6.24858141e-02f, -2.05014303e-01f, -1.04029151e-02f, -7.55574852e-02f, -2.37507168e-02f, 2.50430163e-02f, 2.90988237e-02f, 1.55765802e-01f, -3.78307998e-02f,
  1.26336992e-01f, 1.78833231e-01f, 1.86869800e-01f, -4.07474674e-02f, 1.73017845e-01f, 2.70102173e-01f, 2.38580659e-01f, 1.48417369e-01f, 3.18826705e-01f, -1.04115866e-01f,
  1.76945895e-01f, 2.80278414e-01f, -3.69298130e-01f, 1.65957853e-01f, -4.51783941e-04f, 2.25890845e-01f, 1.32142141e-01f, -1.32007018e-01f, 2.41360396e-01f, 8.29617679e-02f,
  -7.15277717e-03f, 1.26285598e-01f, 1.62437543e-01f, 1.60925031e-01f, 5.48875332e-02f, -2.44666785e-01f, 2.96177566e-01f, 1.06633186e-01f, -1.33242205e-01f, -2.09666654e-01f,
  1.33607745e-01f, 3.58578488e-02f, -2.73625433e-01f, 5.29935397e-03f, 1.26984328e-01f, 2.72525221e-01f, -3.11356485e-01f, -1.44050911e-01f, 9.65470150e-02f, -1.66532695e-01f,
  -1.12757571e-01f, -1.68884080e-02f, 8.02681502e-03f, 2.21164301e-01f, 7.08371103e-02f, -1.93607330e-01f, -7.68824443e-02f, 3.17731984e-02f, 5.25841117e-02f, -2.56842785e-02f,
  4.03088450e-01f, 2.45685861e-01f, 1.11736894e-01f, 1.55783907e-01f, -4.73054014e-02f, 3.11883509e-01f, -9.23893526e-02f, 2.42965296e-01f, 1.55014232e-01f, 5.42961434e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -3.89017835e-02f, 4.68977727e-02f, 2.11377382e-01f, 2.70931005e-01f, 2.83716004e-02f, -9.35682654e-03f, 6.51685447e-02f, 1.87761217e-01f, 1.17055126e-01f, -1.84264824e-01f,
  6.30018348e-03f, 6.68529496e-02f, 9.32153910e-02f, 2.22296700e-01f, 7.75074661e-02f, 1.41783088e-01f, 1.07083865e-01f, 6.01628758e-02f, 1.51669696e-01f, 8.21568593e-02f,
  2.10788175e-01f, 4.60660867e-02f, 2.21111178e-02f, 6.44253865e-02f, 7.53073534e-03f, 2.19094709e-01f, 2.69866437e-01f, -1.28541425e-01f, 5.82492426e-02f, 2.16142341e-01f,
  1.23708390e-01f, -6.50471868e-03f, 1.13207296e-01f, 1.68015927e-01f, 6.77888319e-02f, 2.65294909e-02f, 1.32410929e-01f, 3.71175073e-02f, 5.53723425e-02f, 1.50380358e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.39480188e-01f, -6.91071376e-02f, 1.06990956e-01f, 7.58161619e-02f, -9.10114422e-02f, 5.20741865e-02f, -1.96490139e-02f, 6.31650463e-02f, -1.82271115e-02f, -1.60346538e-01f,
  -7.14534223e-02f, 9.92906652e-03f, -7.39913583e-02f, -5.37265837e-02f, 1.75265923e-01f, -4.74190824e-02f, 3.50187346e-02f, -1.32374093e-01f, -7.62251467e-02f, -2.95867082e-02f,
  -2.36882076e-01f, 2.32811227e-01f, 1.20959006e-01f, 2.91264057e-02f, -1.11666106e-01f, -4.10838462e-02f, 1.57123029e-01f, 2.14897562e-02f, 4.92781028e-02f, 1.57134458e-01f,
  1.58574477e-01f, -3.00833769e-03f, -1.55279577e-01f, -4.32887934e-02f, -1.30091950e-01f, -1.31565168e-01f, -5.34723373e-03f, 5.99300079e-02f, 6.26967624e-02f, 6.23768121e-02f,
  -7.90444165e-02f, 6.16503470e-02f, -3.64775658e-02f, -8.02954808e-02f, -2.21175258e-03f, -5.27190492e-02f, 2.53921449e-02f, -1.55874744e-01f, -1.21911190e-01f, 6.59716874e-02f,
  4.84716799e-03f, -5.00940979e-02f, 1.73167527e-01f, 8.44940692e-02f, 9.62877497e-02f, -1.08030513e-01f, 2.13228427e-02f, 8.26680958e-02f, -1.58339456e-01f, -8.64328817e-02f,
  -1.90079451e-01f, -1.48963451e-01f, -1.68782562e-01f, -5.12284860e-02f, -1.22348247e-02f, -1.14990622e-01f, -7.45801702e-02f, -7.19208717e-02f, -9.31449682e-02f, 8.77410546e-02f,
  -1.68442488e-01f, 9.88767892e-02f, -3.56869847e-02f, -2.11459816e-01f, -3.14019099e-02f, -6.19859658e-02f, -1.12591172e-02f, -1.55907780e-01f, 2.03228936e-01f, 4.29901779e-02f,
  -6.12032898e-02f, 3.52407508e-02f, -1.94484502e-01f, 4.22190949e-02f, -1.90104276e-01f, 2.66159680e-02f, -1.27713546e-01f, -8.46978948e-02f, -2.03889132e-01f, 1.56094387e-01f,
  1.47635236e-01f, -7.04261363e-02f, -7.11759180e-03f, 5.50731048e-02f, 5.63683063e-02f, 1.11156471e-01f, -8.11049491e-02f, 1.35645032e-01f, -2.18599260e-01f, -1.39988288e-01f,
  -1.05706707e-01f, -8.05060640e-02f, -2.31114263e-03f, -9.27914158e-02f, 1.28551945e-01f, -7.89712444e-02f, 3.78214791e-02f, -1.75803348e-01f, -3.95066999e-02f, 2.25566745e-01f,
  5.92955090e-02f, 3.63617837e-02f, -1.56703666e-01f, -1.01464011e-01f, -4.76889312e-02f, -1.43355772e-01f, 2.39650190e-01f, 2.02583820e-02f, -1.07486593e-02f, -1.80567697e-01f,
  1.81114018e-01f, -9.12795663e-02f, 4.80974019e-02f, -1.48230240e-01f, -1.47777036e-01f, -7.95724615e-02f, -1.49992064e-01f, -1.30372524e-01f, 1.54456511e-01f, -1.45153794e-02f,
  -9.85782668e-02f, 2.72693392e-02f, 2.18692292e-02f, -1.10048838e-01f, 1.35933205e-01f, -3.43314260e-02f, 6.53696284e-02f, -2.29755044e-02f, 1.58589289e-01f, -2.40794793e-02f,
  2.68771440e-01f, 1.28884539e-01f, -1.48533344e-01f, 6.30663782e-02f, -6.40937984e-02f, -5.08059375e-02f, 1.37679219e-01f, -1.21252432e-01f, -1.58885121e-01f, -6.54395893e-02f,
  -3.26787345e-02f, -6.01738095e-02f, -8.77691340e-03f, -8.54133889e-02f, -4.10995595e-02f, 1.60217639e-02f, -1.61426738e-01f, -9.63841453e-02f, 2.33188854e-03f, 1.51498526e-01f,
  9.15656537e-02f, -1.56128243e-01f, 1.27551273e-01f, 3.70599218e-02f, 1.59664407e-01f, -1.54100493e-01f, -1.68659329e-01f, 5.48592843e-02f, -1.42206457e-02f, -6.96032196e-02f,
  5.49769066e-02f, -8.48575681e-02f, -1.48364320e-01f, 4.61537689e-02f, -7.68105164e-02f, 1.01634087e-02f, 1.22992173e-02f, -1.36896819e-02f, 2.08237693e-01f, 1.34397864e-01f,
  1.87980995e-01f, 2.54953980e-01f, 1.06335811e-01f, 1.52762290e-02f, 6.82316497e-02f, -3.48279178e-02f, 5.01294471e-02f, 8.83259922e-02f, 5.63890263e-02f, -1.10471860e-01f,
  -1.07230254e-01f, -7.94623792e-02f, 1.35786623e-01f, -8.69925097e-02f, 5.98617718e-02f, -6.08967319e-02f, -5.87167405e-02f, -4.72564064e-03f, 3.21290866e-02f, 3.01352912e-03f,
  -1.47372141e-01f, -4.78254482e-02f, 6.79714829e-02f, 1.01823889e-01f, 1.70872748e-01f, -1.45314306e-01f, 9.04832110e-02f, -3.67819183e-02f, -1.19180918e-01f, -2.40335003e-01f,
  7.40693212e-02f, -1.53255716e-01f, -1.18190505e-01f, 7.29307607e-02f, 1.71636999e-01f, 3.67879793e-02f, -1.97991788e-01f, -7.04866275e-02f, 5.10450117e-02f, 6.82127550e-02f,
  -1.76968277e-01f, 2.08511919e-01f, 5.39769717e-02f, 9.52257216e-02f, 4.46808375e-02f, 5.94075434e-02f, -9.41474177e-03f, 1.89529303e-02f, -2.91192457e-02f, 1.72232032e-01f,
  4.34641615e-02f, -1.93941523e-03f, -9.85469446e-02f, -8.59363303e-02f, 4.06187773e-02f, -6.73526525e-02f, 6.09803759e-02f, 7.89431389e-03f, -4.41745408e-02f, -2.22776625e-02f,
  -1.28839582e-01f, 7.57574476e-03f, -1.25420680e-02f, 5.07462360e-02f, -9.93291736e-02f, 9.60127637e-02f, 1.70633331e-01f, -1.27944171e-01f, 1.52862579e-01f, -1.77646175e-01f,
  -1.22198924e-01f, -5.30745685e-02f, -8.93012732e-02f, -8.44193622e-02f, -1.64751798e-01f, -1.87529266e-01f, -1.29136115e-01f, -8.12045559e-02f, 3.56498323e-02f, 1.61117148e-02f,
  -7.52343312e-02f, -9.07690600e-02f, -7.95872957e-02f, 2.88324468e-02f, -4.52466495e-02f, -5.25476225e-02f, -1.10680200e-02f, -7.46584088e-02f, -2.03040347e-01f, 1.82900503e-02f,
  -2.01123897e-02f, 3.95744108e-02f, 1.08754672e-01f, -1.11377858e-01f, -8.28528851e-02f, -2.38291249e-01f, -1.34009153e-01f, 7.46528879e-02f, 3.53443846e-02f, -2.05465734e-01f,
  -1.27593931e-02f, -1.25364484e-02f, 2.02653125e-01f, -8.18746239e-02f, 1.13678865e-01f, -1.01371050e-01f, -1.62798166e-01f, -1.78606018e-01f, -9.26986039e-02f, 9.83184725e-02f,
  -2.80599948e-02f, 6.46904251e-03f, 1.31363228e-01f, -4.22867127e-02f, -3.51413749e-02f, -8.44820440e-02f, -1.55910747e-02f, 1.96678430e-01f, -4.17475924e-02f, -1.11340366e-01f,
  4.25030924e-02f, 5.05808331e-02f, 1.23886973e-01f, -1.88935682e-01f, 2.80588362e-02f, 4.38152738e-02f, -6.67851642e-02f, -1.22172475e-01f, 2.29610845e-01f, 2.05756668e-02f,
  9.96370148e-03f, -1.38713583e-01f, -2.91982107e-02f, -1.27131134e-01f, 2.47396678e-02f, -5.54504320e-02f, -4.42117900e-02f, -1.36066496e-01f, 6.08252250e-02f, -2.18908153e-02f,
  5.46361133e-02f, -3.53667177e-02f, -8.22310597e-02f, 7.12474138e-02f, -1.24705061e-01f, -1.33395225e-01f, 4.77229729e-02f, -1.44694075e-01f, -1.96692180e-02f, -9.38003883e-02f,
  -9.88156125e-02f, -1.17551468e-01f, 7.93050081e-02f, -4.14710306e-02f, 1.42458797e-01f, -1.77542895e-01f, -1.77242070e-01f, 1.82899371e-01f, -8.78855214e-02f, 1.17824920e-01f,
  4.26235497e-02f, 2.51329616e-02f, -3.53027843e-02f, 7.46915489e-03f, 1.04172099e-02f, 1.49918899e-01f, 1.01514794e-01f, -1.25419900e-01f, -4.28969562e-02f, 1.64631069e-01f,
  -3.44621809e-03f, -9.96566713e-02f, -9.72054675e-02f, 8.08668211e-02f, 2.12509055e-02f, -1.35535970e-01f, -1.92299649e-01f, -5.85229471e-02f, -8.22006762e-02f, 6.97267056e-02f,
  -1.47812843e-01f, -3.13320905e-02f, -2.27190480e-02f, -7.27321431e-02f, 1.49888009e-01f, 1.68963924e-01f, 2.53627189e-02f, 9.25480351e-02f, -6.07552566e-02f, -1.33675233e-01f,
  -3.49890590e-02f, -1.35171697e-01f, -7.97410607e-02f, -4.59055379e-02f, -8.84016007e-02f, -6.57006875e-02f, -1.05341531e-01f, 2.42782962e-02f, 1.34801408e-02f, -1.96268745e-02f,
  -9.74482149e-02f, -1.00324176e-01f, 9.34873223e-02f, 1.13003030e-01f, -4.85543311e-02f, 1.19064413e-01f, -7.18851537e-02f, 1.41533956e-01f, 1.55699730e-01f, 1.13791656e-02f,
  1.31027684e-01f, -3.95912528e-02f, -1.08167261e-01f, 3.14109549e-02f, 2.60072015e-02f, 1.28723949e-01f, -8.59232154e-03f, -1.89714596e-01f, 1.81284342e-02f, -2.69018225e-02f,
  -1.25345528e-01f, 2.10529447e-01f, 5.54468110e-02f, 4.43540774e-02f, -1.74218759e-01f, 2.94816177e-02f, -2.70401798e-02f, 1.64431423e-01f, -9.75465104e-02f, -2.61502434e-02f,
  2.22153142e-01f, -1.90515518e-02f, -1.99395835e-01f, -1.14154555e-01f, 1.58170909e-01f, 1.01209924e-01f, 2.46143043e-02f, -1.28170148e-01f, -4.45823092e-03f, -9.10901353e-02f,
  -9.30352136e-02f, 2.33235043e-02f, -1.44958258e-01f, -6.67169765e-02f, -1.76891252e-01f, -3.37376259e-02f, -1.04674250e-01f, -4.50671203e-02f, -7.52359033e-02f, -7.98678398e-02f,
  2.14392375e-02f, -1.20168187e-01f, -9.70587283e-02f, 3.78384292e-02f, 9.02713537e-02f, 4.96298969e-02f, -1.24079108e-01f, 2.46920083e-02f, 1.23232931e-01f, -1.98602512e-01f,
  -6.32637590e-02f, 1.43321157e-01f, -1.79925606e-01f, -2.02993453e-02f, -6.11362932e-03f, -8.19018632e-02f, -8.02023336e-02f, 1.65112317e-02f, 9.52318218e-03f, 9.68021452e-02f,
  4.83471230e-02f, 1.84033722e-01f, 9.35577229e-02f, 2.72155497e-02f, 2.32846335e-01f, -1.04396641e-01f, 2.48067044e-02f, 8.91826078e-02f, 6.04698807e-02f, -2.81271599e-02f,
  2.23223045e-01f, -5.46248481e-02f, 1.12246804e-01f, -1.43637344e-01f, -1.62085235e-01f, -1.09964073e-01f, 1.03191152e-01f, 1.98580414e-01f, 9.73908827e-02f, -1.91193055e-02f,
  7.56886527e-02f, 1.14017271e-01f, -6.03811927e-02f, -1.40427291e-01f, -7.65336081e-02f, 7.35422149e-02f, -3.20917442e-02f, 8.20575655e-02f, -9.17523056e-02f, 1.86549604e-01f,
  6.53546676e-02f, -9.40854326e-02f, -2.16530561e-02f, 3.14377667e-03f, -1.35860443e-02f, 1.67507082e-01f, -3.08208130e-02f, 2.98957210e-02f, -1.58752382e-01f, 4.72230837e-03f,
  -2.04067260e-01f, 1.17377423e-01f, 1.12133555e-01f, 1.08091824e-01f, 8.42974037e-02f, 6.01456948e-02f, -6.12876657e-03f, -4.77426732e-03f, -6.58530518e-02f, -1.80803150e-01f,
  -1.32812932e-01f, 5.52319922e-02f, 1.77103668e-01f, 2.54476629e-02f, 1.31960124e-01f, -7.82138184e-02f, -6.17560707e-02f, -8.70221481e-02f, 2.40253881e-02f, 1.79943964e-02f,
  9.77758020e-02f, 9.86708999e-02f, 1.13856673e-01f, 3.73301730e-02f, 1.07292481e-01f, -7.72094280e-02f, 1.50310069e-01f, 3.01261712e-02f, 1.40698060e-01f, 8.00914597e-03f,
  2.41714567e-02f, 9.17241424e-02f, 1.06202587e-01f, 4.58936058e-02f, 2.09333807e-01f, 1.99813638e-02f, 1.95390638e-03f, 2.10232377e-01f, 1.49169743e-01f, -1.43289208e-01f,
  2.35466912e-01f, -4.50294577e-02f, 1.97487995e-02f, 2.87837675e-03f, 1.00294076e-01f, -5.26916981e-02f, 8.65043029e-02f, -7.19647259e-02f, 1.33844092e-01f, 1.06065184e-01f,
  5.50165065e-02f, -2.19387427e-01f, -1.02444097e-01f, 2.47687902e-02f, 1.33681307e-02f, -4.70914207e-02f, -1.81040149e-02f, 1.13142088e-01f, 3.32942680e-02f, 9.91523340e-02f,
  1.80601239e-01f, -7.07523257e-04f, 1.55483205e-02f, -1.07477061e-01f, 1.20631017e-01f, 3.07062641e-02f, -5.50655164e-02f, -1.43155292e-01f, -7.76812807e-02f, -1.95801500e-02f,
  3.42582278e-02f, -3.68386321e-02f, 1.10806841e-02f, 8.64158617e-04f, 1.74795419e-01f, 1.81762293e-01f, 2.08198592e-01f, -9.70995203e-02f, 2.51559138e-01f, -1.10732310e-01f,
  1.04028217e-01f, -8.93320888e-02f, 3.23895589e-02f, 2.24589527e-01f, -1.14937097e-01f, -7.53529146e-02f, -6.91847038e-03f, -6.82499260e-03f, -5.54310940e-02f, -8.14204738e-02f,
  -8.23163167e-02f, 3.40739153e-02f, 4.82746847e-02f, 7.61332586e-02f, 5.50655276e-03f, -8.51945281e-02f, 5.51967062e-02f, -7.68882558e-02f, 8.10255855e-02f, 1.02547221e-01f,
  1.51134446e-01f, -4.78169322e-02f, 7.52256662e-02f, -5.08998260e-02f, 4.56304289e-02f, 1.25496108e-02f, -2.56069377e-02f, -4.30317111e-02f, 2.49296054e-01f, -1.56072956e-02f,
  1.08512409e-01f, 3.95457968e-02f, -1.45379482e-02f, 4.74625081e-02f, 8.46416354e-02f, 2.28754833e-01f, 1.19835071e-01f, -2.87009068e-02f, 7.04037398e-02f, 2.12162867e-01f,
  1.44684941e-01f, 1.26365855e-01f, 1.33667532e-02f, 1.51905611e-01f, 1.72722310e-01f, 4.23291251e-02f, 4.34470847e-02f, -1.23735368e-01f, 1.95065722e-01f, 1.13122486e-01f,
  2.57649738e-02f, -8.19548666e-02f, 1.24494009e-01f, -1.24529153e-01f, 2.14436767e-03f, -9.82381925e-02f, -7.66957598e-03f, 1.21303163e-01f, -1.93222955e-01f, -1.44997790e-01f,
  7.69200474e-02f, -7.58936554e-02f, 2.45458156e-01f, -1.79821402e-01f, 2.42947452e-02f, -1.84416085e-01f, 4.96962434e-03f, 1.95146456e-01f, -9.03208256e-02f, -2.15600401e-01f,
  1.34454384e-01f, 5.14447689e-02f, -2.86171269e-02f, -5.70721440e-02f, 8.47368035e-03f, 1.17904909e-01f, 1.31237522e-01f, 2.32479125e-02f, -1.01274662e-02f, -4.00638916e-02f,
  -5.07992730e-02f, -9.62552950e-02f, 2.57622927e-01f, 1.18393838e-01f, -1.73529714e-01f, 4.94529344e-02f, -4.06732336e-02f, 9.69016738e-03f, 1.57340065e-01f, -3.72185521e-02f,
  -9.88070816e-02f, 6.54640868e-02f, -8.29285681e-02f, 1.09795965e-01f, -3.07292156e-02f, -1.01291373e-01f, 9.62573290e-02f, -7.55054429e-02f, -1.29072145e-01f, -4.78055254e-02f,
  -6.53561652e-02f, 2.17941299e-01f, 4.62961160e-02f, -1.43888041e-01f, -8.01277757e-02f, 1.50935715e-02f, 1.41078651e-01f, -6.58529624e-02f, 1.23299971e-01f, 1.34694621e-01f,
  -9.29450691e-02f, 7.22395256e-02f, -2.83437576e-02f, 2.15131808e-02f, -1.65424317e-01f, -1.46698579e-01f, 5.61189763e-02f, 6.28703237e-02f, 1.18262127e-01f, -9.95423496e-02f,
  1.33045549e-02f, 4.37403470e-02f, 1.16721645e-01f, 1.68817267e-01f, 1.35422841e-01f, -2.88692154e-02f, -2.50735171e-02f, -9.55172554e-02f, 1.49168253e-01f, 1.17083259e-01f,
  1.24938183e-01f, 5.98569512e-02f, -1.28617838e-01f, 7.60369822e-02f, 7.08529651e-02f, 9.69993621e-02f, -1.62621494e-02f, 9.69298109e-02f, 8.22567865e-02f, -1.01767279e-01f,
  -9.98941660e-02f, -1.31722633e-02f, -4.64219972e-02f, 1.13070600e-01f, 1.16437927e-01f, 1.40427068e-01f, 2.03834057e-01f, -1.72348022e-01f, -5.33832284e-03f, -8.47831592e-02f,
  -1.13165133e-01f, 2.04816774e-01f, 1.73824102e-01f, 1.76595300e-01f, -6.81008324e-02f, -8.85693505e-02f, -6.20187819e-02f, 2.32932448e-01f, -1.72068134e-01f, 1.07275449e-01f,
  -2.60846745e-02f, -5.82918972e-02f, 2.71911491e-02f, 5.65499924e-02f, 1.77527480e-02f, 1.65288806e-01f, 1.15659833e-01f, 1.21726982e-01f, 2.17625927e-02f, -1.28719285e-01f,
  -4.71141040e-02f, 1.04966283e-01f, -9.77401957e-02f, 1.07485332e-01f, -8.64121690e-02f, -1.54035106e-01f, -1.50225118e-01f, 5.81113808e-02f, -2.59578507e-02f, -3.15673538e-02f,
  6.00959174e-03f, 7.39125013e-02f, 5.00384346e-02f, -1.32869720e-01f, 9.68032852e-02f, 1.15766615e-01f, -3.88961174e-02f, -6.54123649e-02f, 7.82162175e-02f, -3.32301892e-02f,
  -8.48965570e-02f, -1.24575160e-02f, -1.46215215e-01f, -3.29502076e-02f, -5.89004979e-02f, -4.17921096e-02f, -4.65527587e-02f, 5.53415455e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.48025721e-01f, 9.59005207e-02f, 3.23737115e-02f, 2.54304498e-01f, 1.55577362e-01f, 2.06803247e-01f, -1.84041597e-02f, 1.01344712e-01f, 2.70106822e-01f, 1.93688318e-01f,
  9.98980328e-02f, 2.25111425e-01f, -1.25349816e-02f, -5.72610600e-03f, -9.40566361e-02f, -2.89258733e-02f, -7.28741884e-02f, 3.12813073e-01f, 1.52429298e-01f, -5.84993623e-02f,
  9.46873277e-02f, 2.09516019e-01f, -4.37355816e-01f, 1.09374188e-01f, 1.74668860e-02f, 2.45608017e-01f, 1.70577824e-01f, -1.26750961e-01f, 6.48702681e-02f, -2.68665433e-01f,
  -7.32239336e-02f, 2.72946566e-01f, 1.77957136e-02f, -1.19168721e-01f, 1.41748134e-02f, -2.91085362e-01f, 2.05538750e-01f, -1.23771586e-01f, 1.12423323e-01f, 3.94846618e-01f,
  -2.14734636e-02f, 3.14106137e-01f, -8.19285810e-02f, -3.53658274e-02f, -1.09191447e-01f, 1.07213557e-01f, 1.55521527e-01f, 3.87597919e-01f, 1.45412266e-01f, 7.95385838e-02f,
  1.89077154e-01f, -2.16102391e-01f, 1.56166211e-01f, 1.25458375e-01f, 9.22651291e-02f, -1.48898959e-01f, -1.62070855e-01f, 3.60731840e-01f, -5.92235737e-02f, 2.16423467e-01f,
  -1.04860604e-01f, -2.52663046e-01f, -7.09919631e-02f, 2.26964116e-01f, 2.22183615e-01f, 1.87450245e-01f, 8.86375681e-02f, 1.12079561e-01f, 6.00361153e-02f, 2.24264711e-03f,
  1.36832714e-01f, 6.09565228e-02f, 1.40951991e-01f, 1.69127192e-02f, 2.63554186e-01f, 1.80697471e-01f, -3.33384760e-02f, 9.90682244e-02f, -1.60153180e-01f, 2.36380130e-01f,
  2.49737069e-01f, -2.44384483e-01f, 1.18619308e-01f, -2.29591668e-01f, -2.73630410e-01f, 1.23315446e-01f, -3.28672789e-02f, -1.84648305e-01f, -2.30298489e-01f, 1.36605904e-01f,
  1.57815635e-01f, 1.48902863e-01f, 2.33396873e-01f, -2.09154248e-01f, 7.95903280e-02f, 6.55927807e-02f, 5.42488007e-04f, 3.00465599e-02f, -6.10411540e-02f, -6.92932606e-02f,
  2.37570569e-01f, -6.30487204e-02f, 1.75056785e-01f, -5.33442758e-02f, -4.49087210e-02f, 2.11478963e-01f, 2.73006260e-02f, 1.80021152e-02f, -1.16680957e-01f, 4.56545986e-02f,
  4.79154028e-02f, 8.41677785e-02f, -6.61006570e-02f, 1.46934306e-02f, 2.32996091e-01f, -3.15740854e-01f, 2.31774434e-01f, 3.40565175e-01f, 2.07920805e-01f, -1.74942702e-01f,
  2.27439612e-01f, 1.12575024e-01f, 4.83020581e-02f, 1.07952259e-01f, -2.90035009e-01f, -1.03540933e-02f, -1.49638787e-01f, -1.39698848e-01f, 2.44793937e-01f, 2.17573032e-01f,
  1.55608609e-01f, 2.28762403e-01f, 2.36860111e-01f, 4.61046994e-02f, 1.25400603e-01f, 1.11896224e-01f, 4.77120094e-02f, -6.54430985e-02f, 2.88033009e-01f, 6.25268295e-02f,
  -1.21300988e-01f, 4.37445492e-02f, -1.25354216e-01f, 2.25799203e-01f, 1.23787925e-01f, -1.57715268e-02f, 8.21813047e-02f, -8.44591185e-02f, -2.73222327e-01f, 1.16019957e-01f,
  -1.27468169e-01f, -2.26011872e-02f, -8.58475417e-02f, 2.03402191e-01f, 2.86370933e-01f, -1.37207592e-02f, 1.67611241e-01f, -1.92688987e-01f, -1.27757527e-02f, 2.40620062e-01f,
  2.00956836e-02f, -8.18912759e-02f, 4.98672090e-02f, -7.43459910e-02f, 2.76459873e-01f, -9.96837318e-02f, 1.55343413e-01f, -2.42658649e-02f, 6.41824082e-02f, 2.66198277e-01f,
  2.20589176e-01f, -4.64606173e-02f, -1.23458818e-01f, 2.24500988e-02f, 2.68332928e-01f, 2.26548299e-01f, 2.17319861e-01f, 4.08650897e-02f, 2.11318523e-01f, 6.05981015e-02f,
  7.83964470e-02f, 1.58877328e-01f, 3.01319927e-01f, -2.59928763e-01f, 1.88764393e-01f, 6.26393110e-02f, 1.23125196e-01f, -1.35727162e-02f, 1.82149466e-02f, 1.40084736e-02f,
  -1.28639355e-01f, 5.54356351e-03f, 9.08950642e-02f, 6.35818988e-02f, 6.93611428e-02f, 4.80095409e-02f, -1.38410544e-02f, 1.19701223e-02f, 1.46972060e-01f, -7.99948629e-03f,
  1.23268165e-01f, 5.77631220e-02f, -1.83607619e-02f, 1.38523027e-01f, -2.03827456e-01f, -1.21919923e-02f, 2.51514465e-02f, -5.74333407e-02f, 1.03642143e-01f, -2.12190747e-01f,
  -2.84695685e-01f, 1.11111462e-01f, 1.53186560e-01f, -9.85841453e-02f, 2.41225157e-02f, -1.84754089e-01f, -6.85266256e-02f, -4.97697964e-02f, 3.43054323e-03f, 1.41949086e-02f,
  6.75626919e-02f, 2.59744734e-01f, 2.34314017e-02f, -2.56657690e-01f, 5.58374189e-02f, 6.22657165e-02f, -4.45184149e-02f, 5.66504449e-02f, -2.93206871e-02f, 1.13367006e-01f,
  1.28544569e-01f, -1.92230254e-01f, 1.96363345e-01f, -1.97173450e-02f, 1.54321343e-01f, 1.20588891e-01f, 1.25505850e-01f, -4.18910906e-02f, 2.54286736e-01f, -1.74444452e-01f,
  -1.07864454e-01f, 1.88091040e-01f, -1.21359378e-01f, -1.99922979e-01f, -2.00410277e-01f, -2.61033207e-01f, -1.06820837e-01f, 2.62628607e-02f, -8.56907759e-03f, -3.10813840e-02f,
  7.76747093e-02f, -1.15160674e-01f, 9.74757150e-02f, 9.52163264e-02f, 1.18543856e-01f, -2.80777756e-02f, -3.85835283e-02f, 2.66639870e-02f, 4.38962579e-02f, -1.17240101e-01f,
  -1.15901768e-01f, -8.64044577e-02f, -1.98922902e-02f, -8.01985990e-03f, 6.27129301e-02f, 3.27197388e-02f, 1.97919220e-01f, 1.47374749e-01f, -3.45241159e-01f, 1.45334139e-01f,
  -1.17045447e-01f, 2.30972722e-01f, 3.62680048e-01f, -2.66014457e-01f, -1.05852902e-01f, -2.44939417e-01f, 9.63345096e-02f, -1.07532971e-01f, 5.40525317e-02f, -2.84040868e-01f,
  -9.43428427e-02f, 1.49404615e-01f, 1.99613959e-01f, -3.57359499e-02f, 8.42136815e-02f, 7.80816888e-03f, 8.42625052e-02f, -2.96015721e-02f, 1.73277613e-02f, 6.68272972e-02f,
  -1.00996189e-01f, 2.20831797e-01f, 2.56049037e-01f, -4.34061214e-02f, 2.04757214e-01f, -1.29448518e-01f, 5.14148176e-02f, 5.29309064e-02f, 1.85222730e-01f, 9.19052362e-02f,
  3.67763378e-02f, -1.64368208e-02f, 1.36166736e-01f, -1.91743135e-01f, -2.49658078e-02f, 2.34491661e-01f, 1.04506537e-01f, 1.32066637e-01f, 1.13272853e-01f, -2.70007886e-02f,
  1.58175200e-01f, -1.35458738e-01f, 1.29001215e-01f, -1.28942896e-02f, 2.32683927e-01f, -4.37003896e-02f, -1.24383971e-01f, 9.76904016e-03f, -9.36215669e-02f, -2.24703833e-01f,
  -1.09837502e-02f, -7.61327669e-02f, 7.34021664e-02f, -4.22882847e-02f, -1.01483896e-01f, 6.58566803e-02f, 1.37368232e-01f, 4.49569076e-02f, 1.00351244e-01f, 5.54784387e-02f,
  1.35296375e-01f, 3.97266299e-02f, -8.71127564e-03f, -2.04100952e-01f, 2.40007013e-01f, 1.57241181e-01f, -6.04367703e-02f, -2.80036330e-01f, -3.13611448e-01f, 1.12494364e-01f,
  1.18294947e-01f, -6.41895533e-02f, 2.51132518e-01f, -1.00568943e-01f, -8.61184821e-02f, 4.74501699e-02f, -7.93614686e-02f, 7.78901428e-02f, 1.63766086e-01f, 2.66544789e-01f,
  -1.32884234e-02f, -2.66526550e-01f, -1.13577597e-01f, 1.61284894e-01f, -3.69708836e-02f, -3.22464257e-02f, 1.63647622e-01f, 6.91568851e-02f, 2.26545781e-01f, 5.20565957e-02f,
  2.13874161e-01f, -9.71853212e-02f, 2.14135736e-01f, -5.41354679e-02f, 1.72608033e-01f, 5.57864830e-02f, 1.03971832e-01f, -2.33903319e-01f, -1.89888045e-01f, -8.85799974e-02f,
  -1.03305019e-01f, 5.57072572e-02f, 9.85295549e-02f, -5.15613370e-02f, -1.41429901e-01f, 1.11753449e-01f, -4.47476059e-02f, 7.57399946e-02f, 2.52885222e-01f, 1.86836012e-02f,
  2.29072347e-02f, -1.08028971e-01f, 1.85617968e-01f, 7.23110978e-03f, 2.44792178e-03f, 9.27410424e-02f, 1.07927896e-01f, 1.67217255e-01f, 2.22833022e-01f, 2.31522679e-01f,
  9.76208001e-02f, 1.84871182e-01f, 1.24548554e-01f, 2.07727402e-02f, 1.38240471e-01f, 1.30232692e-01f, 1.91690043e-01f, -2.18072101e-01f, 6.99568763e-02f, -3.52169760e-02f,
  1.72171786e-01f, -1.96488172e-01f, 1.67910457e-01f, -2.00670138e-01f, -2.26776898e-01f, -2.09541861e-02f, 1.80817008e-01f, -3.61828506e-02f, -3.24185163e-01f, 1.22983463e-01f,
  2.66955823e-01f, 2.47279122e-01f, 6.48479462e-02f, -1.06665470e-01f, 1.66294307e-01f, 2.08429396e-01f, -7.08967745e-02f, -1.70006171e-01f, -1.74553439e-01f, -4.36991863e-02f,
  -8.52821022e-02f, 1.14118811e-02f, 3.28260437e-02f, -1.25031695e-01f, -4.61412333e-02f, -1.90376416e-02f, -9.27329808e-02f, -5.62080480e-02f, 9.23938230e-02f, -1.38721824e-01f,
  1.66970000e-01f, 1.35795757e-01f, 8.13989863e-02f, 5.19931363e-03f, 2.29857549e-01f, -1.30999699e-01f, -3.64037454e-02f, 2.30558023e-01f, 3.42979759e-01f, -2.20311984e-01f,
  2.43758276e-01f, 1.76760197e-01f, -4.05592844e-02f, -2.92384885e-02f, -2.05254167e-01f, 5.22313453e-02f, -7.66444877e-02f, 2.95163617e-02f, 2.09526807e-01f, -5.83159700e-02f,
  -7.83778578e-02f, 1.68813124e-01f, 5.43749817e-02f, 8.23572874e-02f, -6.59711510e-02f, -4.40686345e-02f, 6.25925213e-02f, 1.72001749e-01f, 5.69020696e-02f, -5.68199269e-02f,
  2.54286557e-01f, -1.27351418e-01f, -8.32823217e-02f, -1.47079945e-01f, 4.83038686e-02f, -2.46921167e-01f, 3.20179939e-01f, 1.74296722e-01f, 8.11168477e-02f, -1.61364555e-01f,
  2.93388635e-01f, 1.01321682e-01f, -1.50202200e-01f, -1.58275843e-01f, 5.18582538e-02f, 1.77509144e-01f, -3.48802060e-02f, -1.80119351e-02f, 1.36687234e-01f, 1.35089770e-01f,
  9.40892845e-02f, -2.19736904e-01f, -1.33479387e-02f, 1.14254326e-01f, -3.90508324e-02f, 2.65252769e-01f, 4.43541743e-02f, -9.38350856e-02f, -9.49327499e-02f, -2.08440736e-01f,
  6.19962588e-02f, 2.41625041e-01f, 1.26844093e-01f, -2.19237834e-01f, -8.06414634e-02f, 2.61845887e-01f, 1.41700983e-01f, -8.79843310e-02f, 1.92721322e-01f, -3.05770457e-01f,
  4.98193093e-02f, -1.17139950e-01f, 7.09749386e-02f, 1.09103233e-01f, 1.23423561e-01f, 2.02659652e-01f, -1.58489093e-01f, 6.55176193e-02f, 3.37064788e-02f, 1.36621580e-01f,
  -6.83094859e-02f, -9.51483101e-02f, 6.18956424e-02f, -2.52665207e-02f, -8.15235823e-02f, 1.66254148e-01f, -4.22339141e-02f, -5.96945770e-02f, 1.33141026e-01f, -3.98214459e-02f,
  1.20556138e-01f, 1.54232070e-01f, 1.43194534e-02f, 1.55019477e-01f, -2.21572474e-01f, -1.92113027e-01f, 2.14457288e-01f, -2.21587509e-01f, -1.02445535e-01f, 1.50380889e-02f,
  -2.06703216e-01f, 1.59680828e-01f, 2.08774731e-01f, 1.25126436e-01f, -3.94458324e-02f, 8.47950056e-02f, -5.62328808e-02f, 2.99604796e-02f, 2.10820019e-01f, 1.37658477e-01f,
  1.07751116e-01f, 2.61607707e-01f, 1.71796530e-01f, -1.93177179e-01f, -1.77340582e-01f, -1.36486674e-02f, 1.88861247e-02f, 7.52888396e-02f, 2.86936034e-02f, 2.08665013e-01f,
  1.88038781e-01f, -6.67349494e-04f, 2.07100302e-01f, -1.10753596e-01f, 3.57478447e-02f, 1.29394948e-01f, 1.89341545e-01f, 1.49546251e-01f, 4.30168547e-02f, -1.12106800e-01f,
  -2.05013782e-01f, -1.79271866e-02f, -2.50014216e-01f, -1.60566494e-01f, -2.33837031e-02f, -3.14532161e-01f, -2.82340616e-01f, 1.19873874e-01f, -1.09403625e-01f, 1.07463896e-01f,
  -1.12498716e-01f, -6.12449497e-02f, -3.26965116e-02f, -3.35252360e-02f, 2.84905016e-01f, 2.29333580e-01f, 1.21406116e-01f, 2.86921114e-01f, 9.49505940e-02f, 2.93623179e-01f,
  2.62226671e-01f, 1.92929909e-01f, 1.58203587e-01f, 2.18443498e-01f, 2.48790964e-01f, 3.39985132e-01f, 2.32743815e-01f, 1.56212628e-01f, 1.00589231e-01f, 4.18983167e-03f,
  -2.25582287e-01f, -2.59331375e-01f, -1.29160330e-01f, 4.68656383e-02f, 2.37516865e-01f, 1.56845033e-01f, 4.73051667e-02f, -1.67186812e-01f, 1.36025259e-02f, 1.01565138e-01f,
  -1.42416298e-01f, -3.92412879e-02f, -5.16562015e-02f, 2.45103225e-01f, 1.77979574e-01f, -2.37039268e-01f, 9.84306857e-02f, 1.13146454e-01f, 6.32419437e-02f, -2.46691272e-01f,
  1.48841470e-01f, 2.00953800e-02f, -2.14043465e-02f, 7.43471086e-02f, 1.46197200e-01f, 6.79543242e-02f, 8.68764222e-02f, 1.03474751e-01f, -9.45577249e-02f, 1.80029914e-01f,
  2.44180635e-01f, -1.56416729e-01f, 1.23580687e-01f, 2.66643047e-01f, 1.19683705e-01f, -4.56034625e-03f, -3.10045518e-02f, -3.09203178e-01f, -2.43184641e-01f, -9.98040959e-02f,
  2.15932410e-02f, 1.74560502e-01f, -7.86566827e-03f, 2.93147340e-02f, -1.21712200e-01f, 2.45979145e-01f, 1.20168678e-01f, 2.97966450e-01f, 2.20761627e-01f, 2.05353528e-01f,
  -1.92244519e-02f, -6.73523266e-03f, -2.81587020e-02f, 3.14016305e-02f, -5.50076365e-02f, -7.60596693e-02f, 9.56252217e-02f, 7.06707016e-02f, 1.28851935e-01f, 2.01014522e-02f,
  1.46056533e-01f, 7.98461027e-03f, -2.74301738e-01f, -2.13558540e-01f, 1.09886594e-01f, 1.62762284e-01f, 1.50478914e-01f, -3.85039747e-02f, -1.23288162e-01f, 5.32128699e-02f,
  1.14097208e-01f, 2.49856606e-01f, 1.35585785e-01f, -2.38153413e-01f, -1.95641249e-01f, 2.72719353e-01f, 8.42430294e-02f, 1.61582068e-01f, 1.59116104e-01f, 1.13966256e-01f,
  1.92726642e-01f, -1.42362177e-01f, -1.97260439e-01f, 7.00407773e-02f, -1.03134938e-01f, 9.45820659e-02f, 3.40570100e-02f, 1.80638254e-01f, 5.77576756e-02f, -1.38041660e-01f,
  1.04163989e-01f, -4.12973091e-02f, 1.48111477e-01f, -5.73098399e-02f, 2.07494751e-01f, 2.17682093e-01f, 1.53713942e-01f, -3.51929292e-02f, -2.38011017e-01f, 8.37948248e-02f,
  -1.11169167e-01f, -1.20669253e-01f, 6.18885756e-02f, -1.53428361e-01f, -1.48780316e-01f, -2.22389787e-01f, -1.73594430e-01f, -4.20034453e-02f, 9.87322703e-02f, -1.78797394e-01f,
  -1.70164764e-01f, -1.18398696e-01f, 1.33087859e-01f, 1.27366260e-02f, -4.29508649e-02f, -5.59549555e-02f, 1.78219169e-01f, 1.13494873e-01f, 1.16222417e-02f, 9.69802290e-02f,
  3.20458375e-02f, 6.95062280e-02f, 1.71416059e-01f, 1.74448490e-01f, 1.11431628e-02f, -4.01171017e-03f, -8.23604316e-02f, 8.78100395e-02f, 3.82716395e-02f, -1.35196090e-01f,
  1.30045325e-01f, -3.01828772e-01f, -1.45347014e-01f, 1.84624959e-02f, 2.03107759e-01f, -7.26841167e-02f, 1.55154318e-01f, 1.99531883e-01f, -5.17253578e-02f, -2.14088976e-01f,
  -6.85238745e-03f, 2.46525973e-01f, 6.86518028e-02f, 5.87532260e-02f, 9.68476683e-02f, 1.79326367e-02f, -3.04222535e-02f, -9.41345245e-02f, -3.21711786e-03f, 2.79642016e-01f,
  -6.26082867e-02f, 2.99624711e-01f, 1.09248489e-01f, -2.34330982e-01f, -3.60196233e-02f, -5.62806316e-02f, 1.20904157e-02f, 2.52364367e-01f, 2.95414031e-01f, -2.47787490e-01f,
  1.69946551e-01f, -1.29828706e-01f, -1.58789456e-02f, 2.11749271e-01f, -1.42758399e-01f, -2.36878887e-01f, -2.07921103e-01f, -1.67471424e-01f, -9.92763862e-02f, -5.69748692e-02f,
  2.29474068e-01f, -9.78676677e-02f, -1.32226124e-01f, -7.87753314e-02f, 3.65433209e-02f, 3.00988227e-01f, 2.16744497e-01f, -6.97730407e-02f, 1.21466145e-02f, 1.52713791e-01f,
  -1.17674388e-01f, -1.37641042e-01f, 5.33941872e-02f, 4.21115831e-02f, 7.22748563e-02f, 1.46982521e-01f, 4.62564491e-02f, 2.66540915e-01f, 1.80611208e-01f, 1.01634003e-01f,
  -4.70336229e-02f, 7.21329153e-02f, -1.27271771e-01f, 1.83309391e-01f, 1.72475412e-01f, -8.22834522e-02f, 5.98059930e-02f, -1.23331778e-01f, 1.58487126e-01f, -3.64505649e-02f,
  -6.61210567e-02f, -2.40094945e-01f, 8.73971209e-02f, 2.02358589e-01f, 2.09293030e-02f, -7.50880912e-02f, 2.33351707e-01f, 3.75177860e-02f, -5.34690805e-02f, -8.24634433e-02f,
  8.51593390e-02f, 1.63596089e-03f, 1.05343521e-01f, 1.45394564e-01f, 2.44437262e-01f, -1.24217615e-01f, 1.21003047e-01f, 2.25114360e-01f, 2.26995945e-01f, 2.74204947e-02f,
  2.87394702e-01f, -3.22684310e-02f, -9.06806216e-02f, 1.26648664e-01f, 7.12931454e-02f, 7.68679157e-02f, 2.58301914e-01f, 1.76209286e-02f, 7.47612566e-02f, 6.91287816e-02f,
  1.39873073e-01f, -1.22602187e-01f, -4.77191992e-02f, 1.64940029e-01f, -4.46613394e-02f, -1.18510261e-01f, 2.05382198e-01f, 8.97722393e-02f, 9.71281677e-02f, -1.47985712e-01f,
  -1.57047451e-01f, -6.76903203e-02f, -1.13224022e-01f, -1.54919907e-01f, 8.93599913e-02f, 1.90559909e-01f, -6.74120560e-02f, 1.17803395e-01f, -8.14679042e-02f, 1.55654512e-02f,
  5.63934185e-02f, 4.69790399e-02f, 4.11662385e-02f, 1.57624725e-02f, -6.89810216e-02f, -1.36302456e-01f, 2.84585506e-01f, 1.09735139e-01f, 5.43140769e-02f, -7.16375560e-02f,
  -3.12144041e-01f, 4.95198742e-03f, 2.05661207e-01f, 3.08786985e-02f, 1.23229519e-01f, -2.23824918e-01f, 3.01146004e-02f, 9.48162004e-02f, 1.46126688e-01f, 1.06517322e-01f,
  1.29755974e-01f, 2.56817907e-01f, 4.79654521e-02f, -2.05365136e-01f, -1.15321046e-02f, 1.06917784e-01f, -1.50132522e-01f, 1.67182952e-01f, -1.08857977e-03f, 1.56734779e-01f,
  1.63752064e-01f, -2.02502698e-01f, 2.58025587e-01f, 9.56657808e-04f, 1.63784593e-01f, 6.41790032e-02f, 6.18559346e-02f, 1.77905157e-01f, 6.59519359e-02f, -2.30364725e-01f,
  -8.82816017e-02f, 1.91623211e-01f, -2.49924093e-01f, 7.79957995e-02f, -1.04679197e-01f, -1.21770233e-01f, -2.79852182e-01f, 7.76317343e-02f, -9.48415920e-02f, 2.81141382e-02f,
  1.46069065e-01f, -1.22817434e-01f, 7.36307725e-02f, -8.36453512e-02f, 1.51353523e-01f, 2.26829454e-01f, 1.07729407e-02f, 1.51284456e-01f, 1.86453924e-01f, 2.60119081e-01f,
  5.39086722e-02f, 7.32574426e-03f, 1.68832436e-01f, 1.98213607e-01f, 1.61335215e-01f, 6.92631081e-02f, 2.33238116e-01f, 6.43880293e-02f, -1.38015077e-01f, -8.57347175e-02f,
  2.14072347e-01f, -2.04680506e-02f, 2.22535625e-01f, -2.57410347e-01f, -3.48910332e-01f, -5.20345569e-02f, 9.98965725e-02f, 7.87866488e-02f, 1.34736106e-01f, -1.92240998e-01f,
  -9.43598300e-02f, 8.33293423e-03f, 2.98021138e-01f, 1.82198763e-01f, 7.63252079e-02f, -4.10192367e-03f, 2.11592376e-01f, 2.66319662e-02f, -1.44954920e-01f, -1.10370688e-01f,
  -1.04182944e-01f, 1.17835589e-01f, -8.23025256e-02f, 9.43340710e-04f, 5.23854829e-02f, -1.16851151e-01f, -5.58261201e-02f, 3.04405577e-03f, 1.04521457e-02f, 3.75163257e-02f,
  7.00906962e-02f, 2.34154426e-03f, 3.09901118e-01f, -1.33009985e-01f, -2.22369447e-01f, 7.55669251e-02f, -5.23897931e-02f, -2.66878754e-01f, -7.36132413e-02f, -7.48915896e-02f,
  1.96740344e-01f, -1.88198015e-01f, 1.48697093e-01f, 1.30677661e-02f, -1.07174464e-01f, -1.56239152e-01f, -1.03709146e-01f, 5.57074382e-04f, 2.21322238e-01f, -7.85990506e-02f,
  2.09428057e-01f, 1.14323340e-01f, 1.87200859e-01f, 1.11707911e-01f, 5.24222292e-02f, 1.59798831e-01f, 2.97939014e-02f, 1.20929599e-01f, 1.47734016e-01f, -3.60663645e-02f,
  1.61793679e-01f, 1.58698827e-01f, 3.23653311e-01f, -2.58210242e-01f, 6.94104135e-02f, 1.87144652e-01f, -1.80309534e-01f, 1.06396951e-01f, 1.67140141e-01f, 1.45676941e-01f,
  -3.32787156e-01f, 1.10062204e-01f, -2.17885271e-01f, 2.07951516e-01f, -5.51108569e-02f, -7.48821646e-02f, 1.89466789e-01f, 1.68658599e-01f, -1.98603496e-01f, -2.21255437e-01f,
  1.59171566e-01f, 9.98474360e-02f, 5.37878163e-02f, -3.08457613e-02f, -2.12148428e-01f, -1.67826235e-01f, -3.38173211e-02f, 8.38237405e-02f, -1.95420980e-01f, 9.26847830e-02f,
  -6.49673343e-02f, 1.90471262e-01f, -1.93684816e-01f, -1.20659932e-01f, -5.49702495e-02f, 1.96138807e-02f, 4.69605718e-03f, 1.62813142e-01f, -6.83702826e-02f, -1.73832849e-02f,
  3.13153341e-02f, -1.10596120e-01f, 5.34681082e-02f, 1.72993138e-01f, 3.55402619e-01f, -1.68268025e-01f, 8.99835601e-02f, 6.38381317e-02f, -1.34526566e-01f, 8.41493234e-02f,
  -2.28347450e-01f, -1.61287650e-01f, -1.72355697e-01f, -1.50533766e-02f, 4.75736260e-02f, 1.44230917e-01f, 8.23370144e-02f, 1.13769926e-01f, 1.73620418e-01f, 1.90890729e-01f,
  4.07815091e-02f, 4.35538031e-02f, 2.07150012e-01f, 1.16611138e-01f, 1.54109865e-01f, 9.90905240e-02f, 3.23519051e-01f, 1.76428258e-01f, -1.92802295e-01f, -8.28817487e-02f,
  -2.89682597e-02f, 5.02327792e-02f, 2.02103123e-01f, 1.26193523e-01f, 2.41932529e-03f, -1.83448702e-01f, 1.03224434e-01f, 3.44608605e-01f, 1.15054481e-01f, -5.05963564e-02f,
  6.01814538e-02f, 1.26326889e-01f, -5.99230900e-02f, 2.38533225e-02f, 2.06594422e-01f, 1.48018703e-01f, 3.38598639e-01f, -2.32267603e-01f, 2.39301305e-02f, 1.04506969e-01f,
  7.06526777e-03f, 2.35781893e-01f, 6.50630966e-02f, 8.74622762e-02f, 1.01577677e-01f, 6.37736842e-02f, 2.90175915e-01f, 3.57110173e-01f, 2.17068225e-01f, -2.05942560e-02f,
  -1.29119545e-01f, 1.46537632e-01f, 2.49580845e-01f, -4.71338304e-03f, 3.20484266e-02f, 1.24600232e-01f, -2.09344640e-01f, 1.08480006e-01f, 1.89268127e-01f, 1.38637587e-01f,
  2.17905082e-02f, 6.75273314e-02f, 1.39183015e-01f, 7.17000589e-02f, 3.64027679e-01f, 1.34700209e-01f, 6.42846450e-02f, 5.42959794e-02f, 1.52318463e-01f, 1.46693885e-01f,
  2.20109582e-01f, 2.65253425e-01f, 1.10116892e-01f, 1.55904070e-01f, 9.21895169e-03f, 1.79958642e-01f, 8.40816796e-02f, 7.18468502e-02f, 2.38045871e-01f, 2.19170377e-01f,
  1.00140683e-01f, -1.47995166e-02f, -1.28647685e-01f, -7.50834793e-02f, 1.40516624e-01f, 9.31669865e-03f, 9.35749710e-02f, -8.79645124e-02f, -2.70554572e-01f, -1.13199882e-01f,
  5.45856580e-02f, 1.21596992e-01f, -1.79561079e-01f, 1.02331592e-02f, 1.29545659e-01f, 3.18503559e-01f, -8.35922509e-02f, -1.39194727e-01f, 4.57602590e-02f, 1.15598448e-01f,
  -2.24466398e-02f, -1.61783561e-01f, -3.68711688e-02f, 1.29961714e-01f, -1.61833595e-02f, 2.43803591e-01f, 2.34844938e-01f, -2.42986575e-01f, -1.33063242e-01f, 5.83756389e-03f,
  -1.43479228e-01f, 2.13968709e-01f, 1.94963172e-01f, -6.47758096e-02f, 1.02675810e-01f, 6.09151013e-02f, 6.95112022e-03f, 1.12613305e-01f, -7.74059221e-02f, -2.68350184e-01f,
  -9.58353132e-02f, 2.31244862e-01f, 3.76157671e-01f, -2.56866902e-01f, 3.91752213e-01f, 9.71918181e-03f, -2.92016178e-01f, -1.56404451e-01f, 2.93887146e-02f, 3.73517603e-01f,
  1.41430907e-02f, -3.57692689e-02f, 1.33537054e-01f, -1.76163297e-02f, 9.07465965e-02f, -1.87259734e-01f, -4.32131216e-02f, 6.75979210e-03f, 1.08387463e-01f, -5.98118715e-02f,
  5.18790185e-02f, -8.28422531e-02f, -6.43840507e-02f, -1.28994673e-01f, -6.24501519e-02f, 7.52893612e-02f, -1.68048829e-01f, -6.44932166e-02f, 5.12993969e-02f, 7.98319373e-03f,
  -7.14598224e-02f, -1.09074913e-01f, 1.46134347e-01f, -1.53482437e-01f, 7.98861384e-02f, -1.98723376e-01f, 2.87324190e-01f, 1.45470902e-01f, -8.42325538e-02f, 1.26462117e-01f,
  6.18372299e-02f, -3.57639566e-02f, -6.85520247e-02f, -1.77036852e-01f, 2.29045227e-01f, -3.49295847e-02f, -1.89778477e-01f, 2.58310348e-01f, 3.51428688e-02f, 1.42257825e-01f,
  9.38847587e-02f, -6.09729290e-02f, 2.95265857e-02f, -4.61500250e-02f, 2.76005268e-01f, 2.69924492e-01f, 1.28804445e-01f, 4.21653092e-02f, 1.68227121e-01f, -9.38997194e-02f,
  1.90075547e-01f, 2.03418747e-01f, 1.99245334e-01f, 2.20190942e-01f, 1.56808458e-02f, 1.17511228e-01f, 3.99090908e-03f, 2.73623645e-01f, 8.70713964e-02f, 4.09654193e-02f,
  2.86349714e-01f, -2.32061911e-02f, 2.93082684e-01f, 2.25999296e-01f, 1.25943318e-01f, 3.37035814e-03f, -9.82525200e-03f, 5.13461083e-02f, 5.25430739e-02f, -9.36267078e-02f,
  1.68234948e-02f, 7.36848712e-02f, 1.23872384e-02f, -6.39419332e-02f, -8.09229016e-02f, -1.50719017e-01f, -3.13718878e-02f, 8.42263270e-03f, 6.54002279e-02f, 2.51903862e-01f,
  -1.00266509e-01f, -2.01025307e-01f, 1.36553630e-01f, -6.87664049e-03f, 8.53477269e-02f, -6.50231466e-02f, 9.02206004e-02f, -6.53761476e-02f, 2.35282004e-01f, 1.20257415e-01f,
  2.15665951e-01f, -4.99083474e-02f, -2.68722355e-01f, -1.58432815e-02f, -1.40211970e-01f, -1.23935461e-01f, -1.28013372e-01f, -1.21400826e-01f, -7.51869660e-03f, -7.63206407e-02f,
  -1.70889065e-01f, 3.15844595e-01f, 1.04473568e-01f, 1.71383202e-01f, 1.78172573e-01f, -1.72792077e-01f, 1.09859116e-01f, -6.00817986e-03f, 7.72720724e-02f, 1.15788110e-01f,
  2.96194106e-02f, -1.63812831e-01f, 1.53760919e-02f, 1.39093429e-01f, -6.87337806e-03f, 1.47739530e-01f, -9.93880183e-02f, 1.79304462e-02f, -9.34263468e-02f, -5.79604656e-02f,
  -1.76615082e-02f, 1.38229042e-01f, 2.40721963e-02f, -1.63665816e-01f, 1.59970790e-01f, -1.09684924e-02f, 2.97040850e-01f, 2.31207192e-01f, 2.43430018e-01f, -7.41128251e-02f,
  4.12621386e-02f, 1.84426323e-01f, -5.27039580e-02f, -2.35092901e-02f, 8.01820531e-02f, 1.72717065e-01f, 2.74955761e-02f, 5.94582707e-02f, 3.96843329e-02f, 3.24622989e-01f,
  4.58698235e-02f, 8.56453702e-02f, -8.35616663e-02f, 2.77794123e-01f, -2.47189239e-01f, 4.26367410e-02f, 8.19249172e-03f, 1.81684136e-01f, 1.69731304e-01f, -6.16163574e-02f,
  1.23836346e-01f, -1.13143869e-01f, -2.43815511e-01f, -3.99150290e-02f, 3.12849700e-01f, -1.00192167e-01f, -2.13694677e-01f, -9.58668292e-02f, -2.89552435e-02f, -8.20145160e-02f,
  -1.25820428e-01f, 2.40602717e-02f, 1.61852807e-01f, -1.56683430e-01f, 4.37937602e-02f, 9.58253220e-02f, 2.23234713e-01f, 5.48380762e-02f, 2.29599655e-01f, 1.31790012e-01f,
  5.90573512e-02f, 1.73236683e-01f, 1.83581218e-01f, 2.01044992e-01f, 1.84339043e-02f, 7.56322294e-02f, -2.54873801e-02f, 3.26400548e-01f, 1.38854504e-01f, 1.25004798e-01f,
  2.49867678e-01f, 2.05558419e-01f, 2.24594157e-02f, 1.71252385e-01f, -7.36238062e-02f, 2.50415742e-01f, -1.32844985e-01f, 1.45280540e-01f, 2.03721195e-01f, 3.26467395e-01f,
  2.76996613e-01f, -3.85929458e-02f, -6.09138310e-02f, 1.99870378e-01f, 2.68503670e-02f, -6.63107336e-02f, 3.62465307e-02f, 1.52934045e-02f, -2.59396471e-02f, 2.76622009e-02f,
  -4.51503741e-03f, 4.86773215e-02f, -1.49914473e-02f, -4.18635793e-02f, 9.66885313e-02f, 6.54900894e-02f, 1.74315557e-01f, 1.23471941e-03f, 1.31645814e-01f, 1.61349699e-01f,
  -7.80894607e-02f, -3.16957593e-01f, -2.60767639e-01f, 1.21124581e-01f, 2.39049777e-01f, -4.42457683e-02f, 2.89789826e-01f, 9.87068005e-03f, -4.86912802e-02f, 1.56176463e-01f,
  -5.95123209e-02f, 1.01656929e-01f, -9.52156484e-02f, 3.79220963e-01f, 7.93124214e-02f, -2.93957382e-01f, -1.04636848e-01f, 3.00129950e-01f, 7.98306763e-02f, 2.13401064e-01f,
  2.28456222e-02f, 5.07265776e-02f, 1.71031162e-01f, 4.10407595e-02f, 1.82682291e-01f, -2.22835779e-01f, 2.83179462e-01f, 3.65061988e-03f, 2.31668994e-01f, -2.54640100e-03f,
  1.86057597e-01f, -2.52738178e-01f, 7.97403604e-02f, -1.48083726e-02f, -1.74863502e-01f, -1.67288315e-02f, 2.28723865e-02f, -1.58662826e-01f, 2.66242512e-02f, 1.74178749e-01f,
  -1.04652748e-01f, 2.12468579e-02f, 1.37241974e-01f, 4.45230305e-02f, 8.53942614e-03f, -7.14531764e-02f, 1.38362199e-01f, -1.02207825e-01f, 1.89917699e-01f, -4.68833884e-03f,
  1.26306742e-01f, 1.15166888e-01f, 1.30166963e-01f, -1.92567427e-02f, 1.73120081e-01f, -4.44965065e-02f, -7.33545646e-02f, 1.57531817e-02f, -1.25265925e-03f, 8.28187913e-02f,
  1.56766817e-01f, -8.47593695e-03f, -1.77824702e-02f, -2.40147367e-01f, -1.29887924e-01f, -2.55358759e-02f, 1.09419666e-01f, 2.05910698e-01f, 1.05592929e-01f, -6.60690144e-02f,
  3.24525237e-01f, 2.44017661e-01f, -6.63957968e-02f, -1.54046699e-01f, -3.00926901e-02f, 1.82594776e-01f, -2.16526762e-01f, 2.94134934e-02f, 2.24794716e-01f, 2.10571900e-01f,
  -2.73097139e-02f, -1.36016756e-01f, -7.44751841e-02f, 1.93587646e-01f, 6.09032214e-02f, 1.78181097e-01f, 1.00964770e-01f, -4.39964309e-02f, -1.47594390e-02f, -1.31634399e-01f,
  5.40411808e-02f, 2.20319211e-01f, 6.86992854e-02f, -5.68305105e-02f, -1.17418647e-01f, 1.17143415e-01f, -6.27779448e-03f, 6.75006211e-03f, 1.80589274e-01f, -2.88341373e-01f,
  2.33806744e-02f, -5.85262105e-02f, -5.49195670e-02f, -6.42274544e-02f, 7.58090988e-02f, 3.25728692e-02f, -1.22545578e-01f, 6.62657470e-02f, -4.51268628e-02f, 1.55870229e-01f,
  1.93387449e-01f, 2.61160973e-02f, -4.14389968e-02f, -3.87485661e-02f, 1.31225005e-01f, 1.27121061e-01f, 5.96642792e-02f, 1.39243618e-01f, 5.51425554e-02f, 7.20988810e-02f,
  5.33723384e-02f, -1.98073521e-01f, -4.89000091e-03f, 2.85277013e-02f, -2.14597479e-01f, -2.72646874e-01f, 1.17380626e-01f, -3.71204317e-02f, -1.14283942e-01f, 1.17548771e-01f,
  -2.40840778e-01f, -1.25435321e-03f, -5.19090407e-02f, 2.78236479e-01f, -1.69478685e-01f, 2.08952483e-02f, -9.86499637e-02f, 2.26223573e-01f, 1.07563742e-01f, 7.09841773e-02f,
  2.96722036e-02f, 4.18978669e-02f, 7.90379196e-02f, -1.09133862e-01f, 5.49450479e-02f, -1.53728783e-01f, -2.19915807e-01f, -1.25065014e-01f, -7.51818111e-03f, 1.65118739e-01f,
  -3.44615132e-02f, -1.20404519e-01f, 1.51180718e-02f, 2.29905158e-01f, -1.59371898e-01f, 1.13465497e-02f, 9.80712324e-02f, 2.49501422e-01f, 2.18896151e-01f, -4.52973545e-02f,
  -1.99738100e-01f, 6.99170008e-02f, -1.34008110e-01f, -2.44997591e-01f, -2.66782157e-02f, 9.10167396e-02f, 1.11881830e-01f, -1.87410221e-01f, -1.05618358e-01f, 1.29615903e-01f,
  -1.50185496e-01f, -1.33603081e-01f, -1.22400582e-01f, -1.77765742e-01f, 1.90391690e-01f, 2.42553532e-01f, 1.26261160e-01f, 2.07674131e-02f, 7.33618885e-02f, 7.29145557e-02f,
  1.33055463e-01f, 1.17370829e-01f, 8.30149129e-02f, 1.60112798e-01f, -4.98305336e-02f, -8.08382258e-02f, 1.63473740e-01f, 1.16814055e-01f, -2.83746868e-01f, -1.56753317e-01f,
  -1.04055926e-01f, 1.50506496e-01f, 1.84606567e-01f, -1.27381369e-01f, -6.08252510e-02f, -3.12194955e-02f, -1.75666973e-01f, 1.88821420e-01f, 3.15262638e-02f, -2.10876077e-01f,
  -2.47041509e-01f, 2.40269646e-01f, 2.89607763e-01f, 1.62158951e-01f, 1.91019163e-01f, 1.66249126e-02f, 1.38325095e-01f, -1.35608867e-01f, -2.59869337e-01f, 6.73251450e-02f,
  -1.32336572e-01f, -1.50861576e-01f, 2.35763267e-01f, 1.60966367e-01f, 1.07973561e-01f, -3.50232013e-02f, 9.41788554e-02f, 1.74904168e-01f, -7.78280199e-02f, 5.66515736e-02f,
  1.32612273e-01f, 2.04821810e-01f, 2.49871403e-01f, -2.08359823e-01f, -1.87563971e-01f, 1.80571511e-01f, 3.03828972e-03f, -8.95171911e-02f, 3.05970818e-01f, 8.15178677e-02f,
  1.07147433e-01f, -2.94111252e-01f, -3.60166058e-02f, 1.22065619e-01f, 1.40690893e-01f, 6.11894093e-02f, -2.97641128e-01f, -1.18876986e-01f, -4.51512542e-03f, -1.13412619e-01f,
  4.09197696e-02f, 2.01037690e-01f, 1.44821182e-01f, 9.58422869e-02f, 1.38140142e-01f, 2.22569674e-01f, 4.28078435e-02f, 2.08370879e-01f, 1.65300354e-01f, 2.37336740e-01f,
  7.83946738e-02f, 3.39592360e-02f, -1.04145564e-01f, 2.26794735e-01f, -2.36185193e-01f, 7.22340718e-02f, 2.65272945e-01f, -1.83367312e-01f, 2.14859650e-01f, -2.20344737e-01f,
  2.27346063e-01f, -2.94717491e-01f, 9.48346928e-02f, 5.96802728e-03f, -6.82191551e-02f, 4.75640595e-03f, 9.12848394e-03f, 2.14160264e-01f, 1.41559735e-01f, -2.08955184e-01f,
  -4.67693768e-02f, 4.80116233e-02f, -1.13360574e-02f, -1.48480490e-01f, 1.49977371e-01f, 1.85631290e-01f, 1.83199614e-01f, 2.47438818e-01f, 3.14241469e-01f, -1.81776732e-01f,
  2.48530731e-02f, -8.81189108e-02f, 8.69430453e-02f, 2.64163345e-01f, 1.57678083e-01f, -2.27823988e-01f, 2.91469902e-01f, 1.78183481e-01f, 1.51190400e-01f, 2.88320363e-01f,
  1.48973987e-01f, -3.09933156e-01f, -4.02127765e-02f, 2.78717671e-02f, 2.87377127e-02f, -8.00415799e-02f, 1.82907566e-01f, 7.37249553e-02f, -5.41527234e-02f, -7.53308833e-02f,
  1.50380984e-01f, 2.11323217e-01f, 2.53035650e-02f, -2.49593660e-01f, -1.17787406e-01f, 4.91720699e-02f, 2.55775191e-02f, 4.38102521e-02f, 1.14786476e-01f, 7.20417723e-02f,
  1.19089320e-01f, 1.20080896e-01f, -3.11472937e-02f, -9.65175927e-02f, -1.92633271e-02f, 5.19802384e-02f, -2.83343434e-01f, -2.17119500e-01f, 1.17178194e-01f, -7.44124576e-02f,
  1.39450416e-01f, 1.60406083e-01f, -2.20385000e-01f, 1.09163560e-01f, -7.45910928e-02f, 2.95520462e-02f, 2.80134529e-02f, -2.68879831e-02f, -2.22905859e-01f, 1.31269498e-02f,
  1.79340824e-01f, 9.17280391e-02f, 2.19279140e-01f, -1.05046585e-01f, 1.78201884e-01f, 1.01024834e-02f, -4.17607911e-02f, 4.90364283e-02f, -4.32646498e-02f, -3.70571241e-02f,
  -1.05512008e-01f, 7.74557441e-02f, 7.55954385e-02f, -3.08683097e-01f, 1.45184636e-01f, 1.55789137e-01f, 3.40535976e-02f, -9.44034979e-02f, 4.98222411e-02f, 7.11152628e-02f,
  2.59794384e-01f, -1.15249559e-01f, -2.13318288e-01f, 2.24486440e-01f, -1.27171904e-01f, -3.52541432e-02f, 1.31388336e-01f, 1.60866771e-02f, 2.67659444e-02f, -2.06167459e-01f,
  6.67211786e-02f, 5.63373230e-02f, -2.07930431e-01f, -1.52226478e-01f, -2.09480181e-01f, -6.49169311e-02f, 9.85016301e-02f, 3.38316485e-02f, 1.41764979e-03f, 1.90416172e-01f,
  1.72151178e-01f, -1.31864727e-01f, -2.65799928e-02f, 8.69531631e-02f, 1.26512900e-01f, -1.11066196e-02f, 3.00399773e-02f, 1.23652987e-01f, 1.41691238e-01f, -9.08270925e-02f,
  -3.18123341e-01f, 1.86370201e-02f, -2.78299570e-01f, 2.13195145e-01f, 1.18886389e-01f, -2.42950499e-01f, 7.14797378e-02f, -7.16941804e-02f, 1.51690781e-01f, 1.25497624e-01f,
  -1.89586088e-01f, -1.23197041e-01f, 9.22700798e-04f, 2.33403042e-01f, -2.99818181e-02f, 9.46299136e-02f, 1.41231656e-01f, -1.42770231e-01f, -1.08790874e-01f, -2.02791438e-01f,
  -2.33158078e-02f, 1.92815159e-02f, 6.13066815e-02f, 3.52444611e-02f, 2.65988231e-01f, -1.78562608e-02f, 5.17380200e-02f, 2.21162885e-01f, 2.72352323e-02f, 7.14872479e-02f,
  2.00235918e-01f, -7.43333697e-02f, -3.81256752e-02f, 1.94624871e-01f, 2.80464500e-01f, 4.77840900e-02f, 9.54701081e-02f, 2.51586109e-01f, 2.09601715e-01f, 5.13889901e-02f,
  1.40120029e-01f, 3.68188545e-02f, 5.14629334e-02f, -6.88872337e-02f, 5.63201196e-02f, -3.22025940e-02f, 8.67942125e-02f, 2.99572140e-01f, -2.94402568e-03f, -1.97857141e-01f,
  -7.64759928e-02f, -4.75901365e-02f, 6.35138750e-02f, 1.61156729e-01f, 1.79099157e-01f, 1.36518747e-01f, 5.99894933e-02f, 8.10687467e-02f, 1.49898097e-01f, -1.69588123e-02f,
  7.59125650e-02f, 2.41619512e-01f, 2.03373417e-01f, 1.16135590e-02f, 2.53548115e-01f, -1.56322360e-01f, 5.23876809e-02f, -1.96689725e-01f, -1.77775919e-01f, -3.17164510e-02f,
  3.08326066e-01f, 2.35289279e-02f, -7.23141059e-02f, 5.62261157e-02f, 3.32747251e-02f, 2.89071172e-01f, 6.17866740e-02f, -1.83862135e-01f, -8.77560675e-02f, 8.24849755e-02f,
  -2.26094186e-01f, -2.19934471e-02f, 2.26828769e-01f, 2.95335621e-01f, 2.02930227e-01f, -1.84672073e-01f, 7.22342450e-03f, 1.49219975e-01f, -1.74209811e-02f, 2.92219490e-01f,
  1.05158545e-01f, -1.04439914e-01f, -1.36979699e-01f, 3.83018539e-03f, 3.64248753e-02f, 1.54019937e-01f, 2.08175510e-01f, 4.98306416e-02f, -5.26795425e-02f, 2.69992888e-01f,
  -5.39495051e-03f, 1.23165347e-01f, 1.21141456e-01f, -1.77503273e-01f, 1.57755036e-02f, -3.17674540e-02f, 8.60610902e-02f, -3.46526392e-02f, 1.31918803e-01f, 3.71529236e-02f,
  -1.83148786e-01f, 8.78560469e-02f, -2.91852280e-03f, 2.78445661e-01f, 1.73086137e-01f, 5.96895404e-02f, 3.64920907e-02f, 3.41547020e-02f, 1.00577287e-01f, 4.49485593e-02f,
  2.03561723e-01f, 3.91073823e-02f, 5.05571179e-02f, -9.79900733e-02f, -4.75625210e-02f, -1.48771837e-01f, -2.28436086e-02f, 3.84948216e-02f, 1.52578309e-01f, -3.54582548e-01f,
  2.61628032e-01f, -2.17217460e-01f, -1.93294287e-01f, 1.74226925e-01f, 8.32860544e-02f, 1.29155710e-01f, -4.00711372e-02f, 3.56975764e-01f, -4.15043905e-02f, 2.69678663e-02f,
  -9.07344744e-02f, 1.36245057e-01f, 9.90410596e-02f, 9.24013481e-02f, 2.89761163e-02f, 4.62225871e-03f, 2.22998932e-01f, 1.03233896e-01f, -7.61637092e-02f, -3.74718290e-03f,
  -1.22432120e-01f, -1.28396794e-01f, -2.09926248e-01f, 1.32353440e-01f, -2.16798007e-01f, -9.86096356e-03f, -2.44684406e-02f, 2.14907452e-01f, -2.75964811e-02f, -4.11801338e-02f,
  -1.61661729e-02f, 2.60090142e-01f, 1.31537944e-01f, -7.16302963e-03f, -1.19136758e-01f, -9.01588723e-02f, 6.54845461e-02f, -1.41158700e-01f, 2.07027361e-01f, 9.80240405e-02f,
  1.05582446e-01f, -8.89165029e-02f, -2.28063926e-01f, 2.40149543e-01f, -3.16988640e-02f, 1.34756804e-01f, -2.41655722e-01f, -9.94175822e-02f, 1.01390421e-01f, 1.28964975e-01f,
  1.75590977e-01f, 3.04981396e-02f, 4.86874357e-02f, 1.29488066e-01f, 3.30066495e-02f, 9.06550661e-02f, 5.28304279e-02f, 2.19658166e-01f, 1.69004768e-01f, 1.59607261e-01f,
  2.38921925e-01f, 1.01801313e-01f, -3.33439223e-02f, -1.03901215e-02f, -4.41683568e-02f, 2.13536844e-01f, 1.32378578e-01f, -1.93901747e-01f, 1.59995377e-01f, -2.18600363e-01f,
  -2.25034341e-01f, 5.37484698e-03f, -1.07151791e-01f, -1.46655411e-01f, -2.10545242e-01f, 2.32430890e-01f, 3.07312608e-01f, 1.92561671e-02f, 2.23040268e-01f, -1.33542120e-01f,
  1.12489775e-01f, 1.24464534e-01f, -7.17614442e-02f, -7.83438683e-02f, 1.35242462e-01f, 6.78592920e-03f, 2.09008247e-01f, -2.02591643e-02f, 2.18926638e-01f, 4.19491157e-02f,
  5.27575389e-02f, 2.08829999e-01f, 1.83465317e-01f, -2.25426760e-02f, -8.73797908e-02f, -1.19464062e-01f, 5.79210706e-02f, 2.93607622e-01f, 2.18958989e-01f, 5.31963110e-02f,
  2.22160667e-01f, -1.64313853e-01f, 2.39420190e-01f, 2.98017472e-01f, 2.81735003e-01f, -9.72780213e-02f, 2.20351055e-01f, -8.06691870e-03f, -4.04763743e-02f, 4.60113361e-02f,
  -7.09452555e-02f, -2.50956672e-03f, -2.68432498e-01f, -1.46922871e-01f, 1.76299632e-01f, 3.05824801e-02f, -1.36177475e-02f, 1.17090292e-01f, 1.47531942e-01f, 1.08740672e-01f,
  1.80061594e-01f, 4.76850830e-02f, 2.05935314e-01f, 1.78267822e-01f, 1.76704362e-01f, 1.46095321e-01f, 1.68777391e-01f, 3.24152298e-02f, -6.79993927e-02f, -1.25157461e-01f,
  -1.13959588e-01f, 1.24732956e-01f, 1.44657567e-01f, 2.47241661e-01f, 2.77076125e-01f, -5.63837178e-02f, -2.54875869e-01f, 2.36174002e-01f, 3.41036946e-01f, -1.00320116e-01f,
  -1.00562528e-01f, -9.01359469e-02f, -8.47498775e-02f, -1.29857704e-01f, -6.31133541e-02f, 1.28939316e-01f, 3.16190541e-01f, -2.24145651e-02f, -7.93651193e-02f, 1.14708304e-01f,
  1.04501851e-01f, -5.97535111e-02f, 7.35570416e-02f, 2.85259843e-01f, 4.28593345e-02f, 4.89952378e-02f, 2.15699747e-01f, 2.88800895e-01f, 9.25241932e-02f, 1.52588621e-01f,
  -1.63808450e-01f, 1.59765869e-01f, 9.64457318e-02f, 1.22441657e-01f, 2.47174576e-01f, 8.26482996e-02f, -1.60731927e-01f, -3.93297523e-02f, 2.06888244e-02f, 2.11347580e-01f,
  2.43094005e-03f, 2.01908320e-01f, 3.38149332e-02f, 2.69507796e-01f, 3.34705025e-01f, 3.31679806e-02f, 6.86628073e-02f, 3.02593023e-01f, 1.65772498e-01f, 1.71486989e-01f,
  1.70198277e-01f, 2.53555298e-01f, 5.86981960e-02f, 2.00571358e-01f, 9.43246335e-02f, 4.80714776e-02f, 1.05958223e-01f, 1.17205389e-01f, -3.28476317e-02f, 1.61283925e-01f,
  2.85893947e-01f, -1.49719834e-01f, 4.65529710e-02f, -1.63651600e-01f, -1.57774568e-01f, 2.87128866e-01f, 2.40716115e-01f, 2.18734086e-01f, -9.52732340e-02f, 1.88578874e-01f,
  -1.33021221e-01f, 2.80745268e-01f, -5.60923330e-02f, 1.14100598e-01f, 1.10746786e-01f, -2.40832791e-02f, -1.57909974e-01f, -1.64829180e-01f, 1.64675102e-01f, 2.92967767e-01f,
  1.50214493e-01f, -5.00878729e-02f, -1.15837112e-01f, -2.46421263e-01f, -1.32665619e-01f, 6.25634268e-02f, -2.22894326e-01f, 1.26398519e-01f, -1.41971409e-01f, 1.52934730e-01f,
  3.44727235e-03f, -1.13070915e-02f, -1.08488649e-01f, 2.70082384e-01f, -2.02044785e-01f, 7.73467943e-02f, 1.20320812e-01f, -3.36108496e-03f, 1.21284239e-01f, -8.17755759e-02f,
  5.73028624e-02f, 6.02792725e-02f, 9.40551907e-02f, -4.20738086e-02f, -1.95878744e-01f, 1.50591478e-01f, -4.12850343e-02f, 1.64972678e-01f, -6.32859021e-02f, -1.31645843e-01f,
  -3.20664719e-02f, 2.31126264e-01f, -5.57433479e-02f, -6.75944164e-02f, 2.10222408e-01f, 5.36942519e-02f, 1.25489503e-01f, -2.87600644e-02f, -7.62911513e-02f, 1.04356654e-01f,
  7.59278610e-02f, -2.12710515e-01f, 2.11014412e-02f, 1.53921872e-01f, -9.30900648e-02f, -1.00478373e-01f, 9.91043076e-02f, 6.26269057e-02f, 2.41656259e-01f, 3.34361643e-02f,
  -9.19090956e-02f, -6.46946058e-02f, -1.94723189e-01f, 1.32787630e-01f, -8.40061232e-02f, -1.99113473e-01f, -1.48956543e-02f, 3.01852286e-01f, 3.07753831e-01f, 1.94785018e-02f,
  1.92720845e-01f, -1.81645513e-01f, 1.29971234e-02f, 5.48443086e-02f, -5.55932596e-02f, 8.34413916e-02f, -2.32093394e-01f, 7.59492144e-02f, 9.62146521e-02f, 1.94056481e-02f,
  -2.05250345e-02f, -1.38871036e-02f, 2.66474038e-01f, 1.26975849e-01f, 2.32332364e-01f, -5.84612973e-02f, -7.50501603e-02f, 1.78629264e-01f, 2.17900813e-01f, 1.31275058e-01f,
  -7.08952174e-02f, 2.20133588e-01f, 5.91736250e-02f, 1.32672936e-01f, 1.63627431e-01f, 2.10427985e-01f, 1.33664608e-01f, -8.81705955e-02f, -4.20265645e-02f, 8.15252587e-02f,
  1.63956374e-01f, 1.07162356e-01f, -5.28515726e-02f, -1.83360070e-01f, -6.94238171e-02f, 3.52150276e-02f, 6.05013035e-02f, -2.17192713e-02f, 6.37858361e-02f, 1.14604108e-01f,
  3.23389210e-02f, -1.65966954e-02f, 1.12360738e-01f, 8.80476087e-02f, -4.60145026e-02f, -1.15312323e-01f, -1.12713777e-01f, 7.60536939e-02f, 2.95203418e-01f, -2.06842989e-01f,
  1.46174818e-01f, -1.12324439e-01f, -2.16496646e-01f, 1.63985372e-01f, 3.69080342e-02f, 1.72683477e-01f, -8.80445316e-02f, 2.59095162e-01f, 1.71465382e-01f, 2.85149753e-01f,
  -8.43462348e-02f, -2.71024406e-02f, 1.21029153e-01f, 1.28455177e-01f, -1.90564737e-01f, 3.78546305e-02f, 1.54237479e-01f, 1.84266374e-01f, 8.38894770e-02f, -1.35652125e-01f,
  -5.72916381e-02f, -5.22164665e-02f, -7.54192546e-02f, 8.75436440e-02f, -1.37500569e-01f, -6.07032850e-02f, -1.81978554e-01f, 8.08280036e-02f, 5.70505075e-02f, 6.84565231e-02f,
  2.41126582e-01f, 2.48598590e-01f, -1.04798926e-02f, -8.68878067e-02f, 3.66417840e-02f, -1.10275142e-01f, 1.50046470e-02f, -1.54166371e-01f, 1.31407548e-02f, -2.39898991e-02f,
  1.99151561e-01f, 1.63585573e-01f, 5.51401153e-02f, 9.93473157e-02f, 2.38036979e-02f, 1.77777499e-01f, 6.09435290e-02f, 7.70955980e-02f, 4.95349988e-02f, 2.74037048e-02f,
  1.34009376e-01f, 1.44809678e-01f, -4.90832999e-02f, -2.59801615e-02f, -6.27949238e-02f, 1.76624000e-01f, -1.20658455e-02f, 1.56620026e-01f, 1.71598420e-01f, 2.55800039e-01f,
  1.90866932e-01f, -1.58230998e-02f, -1.65270925e-01f, 1.68310061e-01f, -1.90484077e-01f, 1.09264076e-01f, 3.07870358e-02f, -1.17716476e-01f, 9.84295309e-02f, -1.08556896e-01f,
  2.02521905e-01f, -7.41788000e-02f, 4.44830507e-02f, -1.50345474e-01f, 7.39180222e-02f, 1.07738964e-01f, -1.23214920e-03f, -8.19280222e-02f, 3.52360047e-02f, 1.02324247e-01f,
  -1.55149043e-01f, -1.00398004e-01f, 9.57540348e-02f, -1.63421795e-01f, 9.75752473e-02f, 1.25052840e-01f, 2.23537996e-01f, 1.34700462e-02f, 2.69469887e-01f, 3.12361091e-01f,
  1.30013004e-01f, 1.17383979e-01f, 6.53272197e-02f, 2.93851733e-01f, 2.38808058e-02f, 4.56972979e-02f, 1.69908881e-01f, 1.36769935e-01f, 7.63814375e-02f, 2.48260617e-01f,
  1.09029785e-01f, 1.47502735e-01f, 1.81887105e-01f, -6.65738434e-02f, -8.22236463e-02f, 2.74208218e-01f, -1.63779125e-01f, 8.88722166e-02f, 1.26734599e-01f, 2.68999696e-01f,
  2.76403248e-01f, 1.96332961e-01f, 9.20462981e-02f, 1.18264280e-01f, 1.40389010e-01f, 1.02557018e-02f, 1.72710903e-02f, 1.49688914e-01f, 1.03138670e-01f, 2.03811795e-01f,
  1.27487406e-01f, -1.36061301e-02f, -1.70432981e-02f, 4.08798270e-02f, 1.07562549e-01f, 5.47254048e-02f, 3.15838605e-01f, -1.37425512e-01f, -1.22661270e-01f, -2.78062463e-01f,
  -4.80735376e-02f, -2.99166925e-02f, 3.68902653e-01f, 1.57881305e-01f, 4.61503072e-03f, -5.41137606e-02f, 1.80603266e-01f, 2.62951821e-01f, -1.11662351e-01f, -1.39135033e-01f,
  -2.19859928e-02f, 2.20795438e-01f, -1.84002295e-01f, -1.18168548e-01f, 5.72949350e-02f, 1.18515573e-01f, 8.37481692e-02f, -2.05709428e-01f, 7.15917768e-03f, 2.32343171e-02f,
  7.69117177e-02f, 2.04084337e-01f, -5.72078861e-02f, -7.62262568e-02f, -1.08113572e-01f, -5.21335714e-02f, -4.24711592e-02f, 2.19359592e-01f, 1.45971403e-01f, -1.18389353e-01f,
  -4.84480895e-02f, 2.48344034e-01f, 1.46413147e-01f, -4.43223789e-02f, 2.45533884e-01f, -2.33106583e-01f, -1.15063243e-01f, 6.20334074e-02f, 1.26166299e-01f, 9.48186219e-02f,
  5.92555106e-02f, 1.16443478e-01f, -1.06866196e-01f, 1.16244733e-01f, -4.55678329e-02f, 7.52967745e-02f, 1.90913938e-02f, -5.81115624e-03f, -6.27354756e-02f, -1.12564132e-01f,
  3.28833684e-02f, -1.50398806e-01f, -1.50874719e-01f, -1.37859806e-01f, -1.45403653e-01f, 4.03676294e-02f, 1.18955232e-01f, 2.90255770e-02f, 7.95529112e-02f, 2.92704981e-02f,
  1.92677185e-01f, 7.13200793e-02f, 7.59724826e-02f, -8.48576277e-02f, 5.14843734e-03f, 2.01705813e-01f, 1.43543527e-01f, 7.00658560e-02f, 1.70223564e-01f, -4.15507592e-02f,
  -8.47169012e-02f, 8.29947963e-02f, 1.94037661e-01f, 1.07307106e-01f, -3.78918760e-02f, -1.82945281e-01f, -1.02913633e-01f, -2.65197363e-03f, -1.54783115e-01f, -5.63444532e-02f,
  1.96555719e-01f, -2.85123140e-02f, -1.06847376e-01f, 2.32275948e-01f, 1.89065441e-01f, -4.94265836e-03f, 2.32109293e-01f, 2.14266405e-01f, 8.09444189e-02f, -9.60257426e-02f,
  2.68100560e-01f, 2.37779096e-01f, -7.91008919e-02f, -6.14286074e-03f, 6.97463751e-03f, 5.74423708e-02f, 2.68317282e-01f, 1.65121630e-01f, 1.27231017e-01f, 3.46256971e-01f,
  -4.62046377e-02f, 3.25114988e-02f, -1.02049902e-01f, 3.33845675e-01f, -4.27724980e-03f, 5.84772266e-02f, 3.03538620e-01f, 9.37292129e-02f, 1.02008656e-01f, 1.21521540e-01f,
  -9.71249072e-04f, 2.20129937e-01f, 9.18884426e-02f, 1.91251207e-02f, -2.44649518e-02f, 1.42950013e-01f, 5.83060198e-02f, 1.48844570e-01f, 3.45415697e-02f, 1.18492045e-01f,
  2.12920845e-01f, 2.47064084e-01f, -1.51792184e-01f, 6.56182617e-02f, -2.42509991e-01f, -1.69157058e-01f, 1.45126684e-02f, 5.25559299e-02f, -1.87413946e-01f, 2.66101599e-01f,
  -1.98276341e-01f, 1.54260069e-01f, 2.83043951e-01f, 2.99359053e-01f, -2.95921773e-01f, -1.05826944e-01f, 2.40791708e-01f, 9.49064121e-02f, -3.05924285e-03f, 3.99280302e-02f,
  1.88387454e-01f, 5.45586757e-02f, 2.09113479e-01f, -1.16378956e-01f, 1.96656808e-01f, -2.15429321e-01f, -2.11862266e-01f, 5.81837334e-02f, 6.97058812e-02f, -5.14190383e-02f,
  9.08413306e-02f, 2.61126697e-01f, 2.33804718e-01f, 1.46469042e-01f, 1.19934857e-01f, 1.22164771e-01f, 5.40574640e-02f, 3.02602917e-01f, -3.36593464e-02f, 1.45982623e-01f,
  -8.80959406e-02f, 2.29059279e-01f, 3.85749154e-02f, -7.40732551e-02f, -7.23253638e-02f, -1.32299379e-01f, -1.93355396e-01f, 2.65864134e-01f, -3.39381784e-01f, 3.19152951e-01f,
  1.17448494e-01f, 2.71530092e-01f, 2.57092208e-01f, -2.42409930e-01f, 2.55935967e-01f, 2.75600493e-01f, 7.55664334e-02f, -4.43000682e-02f, 4.58606258e-02f, 1.80149615e-01f,
  -2.04236154e-02f, -1.16547048e-02f, 3.53314877e-02f, -3.34582664e-02f, 5.39852977e-02f, -1.05593398e-01f, 1.38265833e-01f, 7.02409968e-02f, 3.30389619e-01f, -1.84226274e-01f,
  1.72687605e-01f, -1.28233120e-01f, -1.16270095e-01f, -3.20148349e-01f, 8.17132518e-02f, 4.93463278e-02f, -3.36433239e-02f, 1.39393166e-01f, 1.26484677e-01f, 2.33454660e-01f,
  -2.60869682e-01f, -4.23909053e-02f, 2.01366752e-01f, 2.22062662e-01f, -1.71588093e-01f, 9.38615575e-02f, 1.65415257e-01f, 6.78751990e-02f, -1.04899645e-01f, -6.71799928e-02f,
  -2.02015728e-01f, 5.54552115e-02f, 8.19129273e-02f, 2.46548519e-01f, 5.08671030e-02f, -1.46600202e-01f, -2.36631677e-01f, -1.05305269e-01f, -6.81792200e-02f, 1.79253280e-01f,
  4.81358804e-02f, 5.02177253e-02f, 1.19732842e-01f, -1.19204670e-01f, -1.34635821e-01f, 4.84013967e-02f, 1.53211132e-01f, -9.07348618e-02f, 6.66743144e-02f, 2.09175035e-01f,
  1.83634445e-01f, -5.99468872e-02f, 1.66538209e-01f, 1.31117657e-01f, -1.30767465e-01f, -1.74892202e-01f, -2.04587862e-01f, 1.58241317e-01f, -1.39384806e-01f, -1.70860112e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  7.81834573e-02f, -3.06819286e-02f, 1.47056609e-01f, 9.83236283e-02f, -8.84183273e-02f, 3.27586033e-03f, 7.50769302e-02f, 7.73479268e-02f, 1.54317394e-01f, 2.13040948e-01f,
  -4.93921004e-02f, 1.16382897e-01f, -2.13964488e-02f, 2.80043930e-02f, 5.52418530e-02f, 5.83336167e-02f, 2.35962287e-01f, 1.48020938e-01f, 1.04829557e-01f, -6.37818277e-02f,
  1.97764024e-01f, -7.12302253e-02f, 1.01909272e-01f, 1.59146756e-01f, -7.56441429e-02f, 1.94978461e-01f, 1.10914186e-01f, 6.81112036e-02f, 1.42724156e-01f, 2.09076300e-01f,
  -1.16234627e-02f, 2.32134461e-01f, 7.80073553e-02f, 1.29633900e-02f, 2.01852456e-01f, 5.21447733e-02f, 7.07397331e-03f, -7.87713155e-02f, 4.54056673e-02f, 3.60863023e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.04473002e-01f, -6.98561668e-02f, 6.56094626e-02f, 5.37120104e-02f, -4.76106219e-02f, -8.49730521e-02f, 9.33165699e-02f, 1.20352447e-01f, -1.06373712e-01f, 8.34939703e-02f,
  9.89042297e-02f, 9.03542489e-02f, -5.51457182e-02f, -1.75561383e-02f, -3.10191722e-03f, 1.57004550e-01f, -3.61111164e-02f, 1.40979439e-01f, 1.85803309e-01f, 1.61133707e-01f,
  -6.77092075e-02f, -2.39690207e-02f, 5.41794747e-02f, 8.28430206e-02f, -9.00053754e-02f, -1.48272533e-02f, 5.40407095e-03f, -6.12660944e-02f, 3.30918878e-02f, -3.74891199e-02f,
  -2.87329834e-02f, 1.06382765e-01f, -5.22799231e-03f, -5.98268174e-02f, -4.00779471e-02f, 1.31653771e-01f, -1.04349725e-01f, -3.83820944e-02f, 1.27335981e-01f, 7.89024904e-02f,
  1.53562471e-01f, -8.97597522e-03f, -6.32714108e-02f, -6.85850605e-02f, -1.81632806e-02f, 1.26188006e-02f, 5.46123311e-02f, 8.76630172e-02f, 1.04958445e-01f, -1.29631326e-01f,
  -6.31974339e-02f, 1.84112205e-03f, -4.36482802e-02f, -2.11207848e-02f, 6.72941580e-02f, -7.16006160e-02f, -4.86061089e-02f, -8.13649073e-02f, -2.43822597e-02f, 6.55444115e-02f,
  8.76928419e-02f, 1.52160646e-02f, -1.55213356e-01f, 1.67835802e-01f, 1.79516748e-01f, 1.29072860e-01f, 1.27034277e-01f, 4.05879915e-02f, 2.48487126e-02f, 1.16271719e-01f,
  9.43804979e-02f, -9.35455561e-02f, -3.83248627e-02f, -8.67907181e-02f, 1.19180582e-01f, 7.78122395e-02f, -3.17153037e-02f, -3.45538482e-02f, -7.08335489e-02f, 1.25283829e-03f,
  -2.34148856e-02f, -2.37831548e-02f, 2.79976055e-02f, -1.33567065e-01f, -1.24533828e-02f, -2.03742892e-01f, -1.51279837e-01f, -4.02833074e-02f, -6.85422588e-03f, -4.58741561e-02f,
  -1.26551002e-01f, 1.05605356e-01f, -5.19929081e-02f, 6.25312235e-03f, -6.10815920e-02f, -8.75478387e-02f, 1.82801411e-01f, 1.29997835e-01f, 7.67225847e-02f, 9.75956693e-02f,
  4.51184660e-02f, -8.07206426e-03f, 8.48563462e-02f, -1.30643053e-02f, -1.33525461e-01f, -2.77042249e-03f, 1.12562537e-01f, -3.37346867e-02f, 1.46515639e-02f, -1.18692659e-01f,
  -1.44086748e-01f, 1.00101367e-01f, 8.79998505e-02f, -1.17062837e-01f, 1.03732318e-01f, 1.25439882e-01f, 2.88398024e-02f, 7.21486583e-02f, -9.49723050e-02f, 7.96259195e-02f,
  -1.04313388e-01f, -5.68446610e-03f, 8.59605381e-04f, 4.02920730e-02f, -1.12416469e-01f, -7.50579610e-02f, 1.54860690e-01f, -1.47170037e-01f, 1.64367370e-02f, -5.96255250e-03f,
  1.03494935e-01f, -9.38921496e-02f, -2.62114499e-02f, 3.16300010e-03f, 7.80946091e-02f, 6.43864721e-02f, -1.03596300e-01f, -3.68931033e-02f, -5.64507616e-04f, 1.09717973e-01f,
  -1.61377296e-01f, -1.96356788e-01f, -6.62028491e-02f, -1.20542713e-01f, 4.47765589e-02f, -6.20345213e-02f, 1.22516314e-02f, -7.26477727e-02f, -1.54542282e-01f, -7.68499300e-02f,
  -4.79847826e-02f, -1.57617733e-01f, 6.22698292e-02f, 1.12375338e-02f, -1.85790751e-02f, 1.28096431e-01f, -6.52652681e-02f, 1.09254904e-01f, -1.65625922e-02f, -1.15813553e-01f,
  3.35562825e-02f, 1.48918126e-02f, 1.09082684e-02f, 1.63615406e-01f, 9.35268849e-02f, -1.79120321e-02f, 4.88377251e-02f, -1.24661244e-01f, 5.67569509e-02f, -4.43753488e-02f,
  1.94378775e-02f, -2.18279511e-01f, 1.12886995e-01f, -1.84957892e-01f, 5.29804491e-02f, -8.26211125e-02f, 1.26197547e-01f, 1.41594127e-01f, -3.34813744e-02f, 8.65003765e-02f,
  -1.59626320e-01f, -1.51264384e-01f, -1.66939840e-01f, 9.09251794e-02f, 3.30088064e-02f, -4.46586758e-02f, -1.23864055e-01f, 9.66746137e-02f, 4.41527925e-02f, -1.41384542e-01f,
  1.28293857e-01f, -1.94401413e-01f, 7.23541453e-02f, -1.23314925e-01f, -1.54342430e-04f, 1.41584530e-01f, 1.60878628e-01f, 1.57655239e-01f, 6.06449097e-02f, 1.53776735e-01f,
  -5.73413968e-02f, 1.00484334e-01f, 1.27279937e-01f, 1.39729485e-01f, 8.44761431e-02f, -2.02545062e-01f, 1.75319836e-01f, -5.15057668e-02f, 1.63067579e-02f, -9.83823314e-02f,
  1.34349659e-01f, 1.53434083e-01f, 1.37853641e-02f, -3.30941491e-02f, 3.32300738e-02f, 7.35315084e-02f, 5.72309643e-02f, 1.34746432e-01f, -5.54041304e-02f, 6.82338849e-02f,
  -1.10363342e-01f, -1.73122622e-02f, 9.47441980e-02f, 8.75978246e-02f, -6.32817373e-02f, 1.40660822e-01f, -9.50613022e-02f, -6.22550473e-02f, -7.66678900e-02f, -6.07036091e-02f,
  3.30317505e-02f, 1.33255064e-01f, -2.56132744e-02f, 1.75397053e-01f, -9.81757790e-02f, 1.54933795e-01f, 1.13537811e-01f, -9.88293812e-02f, -8.16807076e-02f, 4.93737943e-02f,
  -7.23669603e-02f, 2.80783940e-02f, 6.90260604e-02f, 3.54561955e-02f, 8.79534520e-04f, -7.88251311e-02f, 2.68669575e-02f, 6.65499344e-02f, 7.70301521e-02f, 2.38726661e-02f,
  -1.43897068e-02f, -5.98607846e-02f, -3.52789015e-02f, -1.20362408e-01f, -3.34779844e-02f, -1.10110097e-01f, -1.55592337e-03f, -7.84893930e-02f, -2.41924915e-02f, 9.79918540e-02f,
  6.90951645e-02f, -2.05346569e-02f, 5.63447773e-02f, -3.08807921e-02f, 5.74179068e-02f, 4.50087562e-02f, 3.22823636e-02f, 7.81098008e-02f, 7.08587319e-02f, 1.05001302e-02f,
  8.01994279e-02f, -9.69048217e-02f, 1.42815992e-01f, 5.50611839e-02f, 5.47395460e-03f, -9.26939100e-02f, 8.44620615e-02f, -1.43626705e-01f, 1.31593868e-01f, 2.77504548e-02f,
  1.27411233e-02f, -3.31007466e-02f, 2.09046349e-01f, -9.80906859e-02f, -5.54374270e-02f, 7.05540832e-03f, -3.51928431e-03f, -1.22033834e-01f, -9.88129750e-02f, -1.00098886e-01f,
  -5.09704165e-02f, -1.40333459e-01f, -7.75272027e-02f, 1.09010726e-01f, 2.94042360e-02f, 7.34103024e-02f, -8.71566311e-03f, 2.12034974e-02f, 1.44647419e-01f, -7.50365406e-02f,
  1.34401008e-01f, -6.86241239e-02f, -1.36554241e-01f, 1.38849497e-01f, 5.17741665e-02f, -1.37586504e-01f, -2.62647215e-02f, -9.52117667e-02f, -1.02429777e-01f, 9.21793580e-02f,
  2.03042720e-02f, -5.86644076e-02f, -5.38948141e-02f, -7.98562393e-02f, -3.25310156e-02f, 5.79975434e-02f, -5.86895868e-02f, 1.26821518e-01f, 4.33200300e-02f, 9.40964520e-02f,
  -3.39673012e-02f, -2.65272371e-02f, -6.85963035e-02f, -9.07037705e-02f, 3.18319015e-02f, 5.78871593e-02f, 7.56158633e-03f, 1.06934994e-01f, -4.03248481e-02f, 6.17193505e-02f,
  1.32067561e-01f, 1.45999014e-01f, 1.64195169e-02f, -8.82440731e-02f, 4.05392274e-02f, -4.68339324e-02f, -1.76033720e-01f, -7.52698183e-02f, -8.05023462e-02f, -6.29792437e-02f,
  8.54506716e-02f, -9.05985311e-02f, 3.50620337e-02f, 1.83299839e-01f, -4.27072030e-03f, -1.54280066e-01f, -7.80024976e-02f, -1.48998097e-01f, -1.39012247e-01f, 4.12882343e-02f,
  9.44015309e-02f, 1.09285235e-01f, 2.01856643e-02f, 4.38540578e-02f, -1.02456361e-01f, -2.27030478e-02f, 3.45095247e-02f, -1.93731979e-01f, -9.46201906e-02f, -4.33439016e-02f,
  1.64277509e-01f, 1.20489607e-02f, 3.52142937e-02f, 4.56558019e-02f, 1.33096911e-02f, -1.57142684e-01f, 1.45427093e-01f, -3.52710336e-02f, -1.32844433e-01f, 1.75094400e-02f,
  -5.18473163e-02f, 2.58883815e-02f, -7.92819858e-02f, -6.25905991e-02f, 7.26681128e-02f, -1.12413771e-01f, -9.03150886e-02f, -5.25749512e-02f, -6.90250024e-02f, 2.64856033e-02f,
  1.55934125e-01f, 8.23952481e-02f, -7.37073943e-02f, 3.18239480e-02f, -1.10675991e-01f, 7.91607425e-02f, -3.51470448e-02f, 1.73811764e-02f, -8.53311121e-02f, -2.05280259e-02f,
  -2.14093905e-02f, 7.54850730e-02f, -1.34637028e-01f, 8.53342563e-02f, 1.11322701e-01f, 2.88643576e-02f, -1.83208823e-01f, 1.54586639e-02f, 8.71793702e-02f, 6.13146015e-02f,
  -1.28165707e-01f, -5.91455027e-02f, -2.62235291e-04f, -1.03723668e-01f, 1.07538231e-01f, -9.82908532e-02f, 2.87003517e-02f, 8.25617090e-02f, 1.41708881e-01f, 7.32325995e-03f,
  -1.00891046e-01f, -1.24505952e-01f, -1.36575490e-01f, -8.81371498e-02f, 1.07857220e-01f, 1.73807725e-01f, -8.96256641e-02f, 1.01145126e-01f, -9.83539000e-02f, -4.23015933e-03f,
  -4.01605368e-02f, 6.90529644e-02f, -1.08883627e-01f, -1.27434403e-01f, 1.48160178e-02f, -7.27594867e-02f, -9.99821648e-02f, -5.82646765e-02f, -4.44618501e-02f, -8.83208662e-02f,
  1.20759488e-03f, -5.04619405e-02f, -8.10258016e-02f, 1.33638173e-01f, 4.53976654e-02f, 1.18221976e-02f, 4.69698124e-02f, -3.35657224e-02f, 8.52962509e-02f, 6.79939836e-02f,
  1.18421070e-01f, -2.80301496e-02f, -1.69730019e-02f, -5.29758260e-02f, 1.98066942e-02f, 5.32679148e-02f, 9.89112332e-02f, -6.15207404e-02f, -5.54922782e-02f, -4.57753316e-02f,
  9.05164182e-02f, -2.11724583e-02f, -1.21786878e-01f, 8.20933282e-02f, 1.28730416e-01f, -1.75623465e-02f, 4.10934500e-02f, -3.65601331e-02f, -1.08070359e-01f, -4.99456488e-02f,
  -4.75292020e-02f, -1.45121366e-01f, -5.62052466e-02f, 7.46837556e-02f, 2.98267528e-02f, -3.84688042e-02f, -1.22474372e-01f, -7.69810230e-02f, -6.74851995e-04f, 9.57595408e-02f,
  -4.80026901e-02f, 1.18717238e-01f, -8.25079009e-02f, -1.74853820e-02f, -6.60526454e-02f, 3.59711163e-02f, -6.33343011e-02f, -9.41300914e-02f, -1.02106638e-01f, 9.27855372e-02f,
  1.18318565e-01f, 1.84323906e-03f, 1.20268241e-02f, 1.21207096e-01f, -1.58152029e-01f, -4.00913171e-02f, -1.28986791e-01f, -9.83216166e-02f, 1.66776292e-02f, -1.15307294e-01f,
  -2.02366076e-02f, -2.94751767e-02f, -1.05048843e-01f, 9.92799103e-02f, 9.54084024e-02f, -9.85641703e-02f, 8.89789388e-02f, 9.39933807e-02f, 3.88813987e-02f, 1.10627703e-01f,
  1.24037690e-01f, 8.95088613e-02f, -2.59194691e-02f, -4.73250113e-02f, -1.21005856e-01f, -1.53643548e-01f, 1.24036014e-01f, -3.86971608e-03f, 2.14181006e-01f, -1.01533294e-01f,
  -2.36619338e-02f, 5.83248138e-02f, -1.36672989e-01f, -9.58078355e-02f, 8.51935744e-02f, 3.92235741e-02f, -1.23929180e-01f, 5.13055883e-02f, -9.96694565e-02f, -3.05739325e-02f,
  -9.03646797e-02f, -2.06752750e-03f, -9.79077071e-02f, 4.67959717e-02f, -5.07859215e-02f, -5.13578169e-02f, 1.29705131e-01f, 1.91319153e-01f, -2.10580211e-02f, 1.16463192e-01f,
  -6.10597432e-02f, 1.28361002e-01f, 1.32029802e-01f, 2.45868966e-01f, 1.09184280e-01f, -8.96577463e-02f, -1.31187856e-01f, 2.34513804e-02f, -9.07387808e-02f, 3.48329754e-03f,
  -6.61701933e-02f, 1.70164540e-01f, 1.72175243e-01f, -1.34694111e-02f, 2.67915428e-02f, -3.43676209e-02f, 1.14493631e-02f, 8.79341643e-03f, -1.24626875e-01f, 5.02647199e-02f,
  -4.83837128e-02f, 9.28918272e-02f, 1.46868944e-01f, -4.27176198e-03f, 1.21970162e-01f, 4.89719026e-02f, -1.17890023e-01f, 1.73369139e-01f, -1.24445580e-01f, -1.55043378e-01f,
  -8.81303847e-02f, 2.77670156e-02f, -2.78415275e-03f, 4.04255651e-02f, 5.38128093e-02f, -4.63064313e-02f, 1.42103255e-01f, -1.23393512e-03f, -2.78842803e-02f, 3.82698737e-02f,
  1.48268536e-01f, 2.85295993e-02f, -1.54546993e-02f, 1.20214239e-01f, -1.84518516e-01f, 4.21432108e-02f, 1.11502767e-01f, 2.29540952e-02f, -5.81733026e-02f, -8.66843387e-02f,
  -6.47454038e-02f, 8.74206200e-02f, 8.79443586e-02f, 1.05967529e-01f, -1.03044607e-01f, 2.72521377e-02f, 1.21456131e-01f, 1.70184055e-03f, 9.62079540e-02f, -1.30755007e-01f,
  -1.08288892e-01f, -8.11812356e-02f, 1.87105849e-01f, -1.43802851e-01f, -6.24444447e-02f, -1.32791936e-01f, 4.53061834e-02f, 6.14010021e-02f, -8.39353651e-02f, -2.46104542e-02f,
  -7.94643629e-03f, 1.65222287e-01f, -8.95840675e-02f, -5.95662333e-02f, 7.37231821e-02f, -1.06414810e-01f, -1.65512215e-03f, -1.37388734e-02f, -5.60338348e-02f, 1.35824934e-01f,
  -1.09079391e-01f, 1.82835698e-01f, -9.57071111e-02f, -1.92129642e-01f, 4.00886163e-02f, -7.26797879e-02f, -9.40050930e-02f, 9.46337283e-02f, 1.97670273e-02f, 9.58126560e-02f,
  -1.17494211e-01f, -1.38298735e-01f, 1.51416669e-02f, 3.10429409e-02f, 1.48849845e-01f, 1.17811322e-01f, -1.75701063e-02f, 2.75961906e-02f, -8.23162049e-02f, -5.14668562e-02f,
  -9.12295841e-03f, 2.55047046e-02f, -2.59019844e-02f, -4.58920635e-02f, 4.39540409e-02f, 6.07274957e-02f, 5.65134622e-02f, -1.81997810e-02f, 8.42508581e-03f, -6.15845732e-02f,
  -9.12506878e-02f, 5.99712469e-02f, 1.63263537e-03f, 3.71867195e-02f, 8.01599324e-02f, -8.52302909e-02f, -1.10528141e-01f, -1.11694984e-01f, -5.93251772e-02f, 2.71229837e-02f,
  6.85419589e-02f, -1.02861091e-01f, 3.41909379e-02f, 3.93015333e-02f, 6.18856726e-03f, -3.01013682e-02f, 1.43678468e-02f, -1.02444300e-02f, -1.50677755e-01f, -1.10735103e-01f,
  -1.96196958e-01f, -5.25969155e-02f, -2.06531212e-01f, -7.35044703e-02f, -8.25815722e-02f, 2.61162557e-02f, -7.27982521e-02f, 1.19504064e-01f, 1.54909454e-02f, 5.24629727e-02f,
  -1.55327216e-01f, 5.95853887e-02f, 9.51684192e-02f, -1.08476244e-01f, 1.60937414e-01f, 1.78729162e-01f, 9.45046172e-02f, 1.40564069e-01f, -3.41968685e-02f, 3.18731144e-02f,
  -1.09198935e-01f, -6.05459400e-02f, 7.04446733e-02f, -1.30260587e-01f, 6.17833100e-02f, 3.84567236e-03f, -9.66259986e-02f, -1.85893364e-02f, 6.95911422e-02f, -9.45310593e-02f,
  2.40146481e-02f, 6.54143617e-02f, -6.05259240e-02f, 3.72304651e-03f, -2.11504772e-02f, -2.21967734e-02f, -1.60890952e-01f, 6.86779572e-03f, -2.46365368e-02f, 1.03880025e-01f,
  -1.46439061e-01f, -2.59183832e-02f, 1.78662345e-01f, -5.97991012e-02f, -5.90441115e-02f, 1.00818597e-01f, 1.07433222e-01f, 7.40429610e-02f, -8.90366137e-02f, 6.37693107e-02f,
  5.06820604e-02f, 7.06945062e-02f, -3.45267244e-02f, -2.38486174e-02f, -9.73292589e-02f, 4.96698171e-02f, 5.17913178e-02f, 1.94164235e-02f, 8.59029740e-02f, -2.21093111e-02f,
  -1.80942640e-02f, -1.36649787e-01f, 1.07552327e-01f, -4.77460325e-02f, 2.28672056e-03f, -3.53665799e-02f, -3.24240653e-03f, 6.23449013e-02f, -1.12522349e-01f, 1.28204942e-01f,
  1.02693155e-01f, -1.00373417e-01f, 1.69181023e-02f, -9.91084725e-02f, 1.00207373e-01f, -6.41597994e-03f, 5.40549867e-02f, 3.90626080e-02f, -3.48312072e-02f, -8.82642791e-02f,
  4.34278185e-03f, -1.11681014e-01f, -1.04926378e-01f, 1.16506495e-01f, -7.75167532e-03f, 4.35175784e-02f, 2.57262271e-02f, -5.97265363e-02f, -1.01578698e-01f, -1.27799734e-01f,
  -1.29286587e-01f, 4.61891154e-03f, 7.41815642e-02f, 7.40535855e-02f, 1.06121585e-01f, -1.35765761e-01f, 5.91652319e-02f, -1.67688970e-02f, 1.17998473e-01f, 1.68439921e-03f,
  2.53594257e-02f, -4.19712886e-02f, 3.19970287e-02f, -1.58266425e-01f, -1.06103420e-01f, -4.48488118e-03f, 6.26415014e-02f, 5.12823984e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.01340651e-02f, -5.95222116e-02f, 2.53509223e-01f, -9.37976837e-02f, -7.04288706e-02f, 6.82418887e-03f, 6.42276742e-03f, -4.53564413e-02f, -3.27327251e-02f, 1.78812265e-01f,
  1.36190310e-01f, 2.42472403e-02f, -2.03178987e-01f, -1.29044548e-01f, -2.03657132e-02f, -6.58789724e-02f, -5.84745519e-02f, -6.68121427e-02f, 7.56194964e-02f, 1.76136598e-01f,
  1.53233232e-02f, -1.65725406e-02f, 7.59200230e-02f, 2.36141056e-01f, 1.16666622e-01f, 3.01499404e-02f, -4.87574935e-02f, -2.84564979e-02f, -3.04258168e-01f, -3.35254192e-01f,
  1.20114926e-02f, 8.70664939e-02f, -1.60828561e-01f, 8.60631838e-02f, -3.08004588e-01f, -2.98558287e-02f, -7.22397193e-02f, -2.10896447e-01f, -4.86536101e-02f, 1.80233434e-01f,
  7.89058283e-02f, 1.36316150e-01f, 1.36481121e-01f, 1.20578250e-02f, 2.27966487e-01f, -3.54053527e-02f, 8.00940916e-02f, 3.71312462e-02f, -1.91784486e-01f, 1.89966127e-01f,
  -1.93503499e-01f, 2.35633850e-02f, 8.95484164e-02f, 1.05633050e-01f, 9.36228409e-02f, 2.48480275e-01f, 1.95152268e-01f, -1.48778558e-01f, 9.50301513e-02f, -4.36468720e-02f,
  3.38029593e-01f, 2.09989734e-02f, -6.85403645e-02f, -1.16195390e-02f, 1.12073094e-01f, -6.31302074e-02f, 4.90409881e-02f, -4.29132814e-03f, 1.91855580e-01f, 1.11846998e-01f,
  2.43329853e-02f, -3.16857523e-03f, -1.90973617e-02f, 8.22620541e-02f, 1.53794870e-01f, -7.29890913e-02f, 3.22574414e-02f, -2.40757942e-01f, -1.79478675e-01f, 2.89346054e-02f,
  -2.79672921e-01f, 1.52475163e-01f, 1.36261597e-01f, 1.24193653e-01f, -1.45746052e-01f, 5.56160137e-02f, -8.46484154e-02f, 1.19350024e-01f, 1.51050329e-01f, -1.12649649e-01f,
  -2.37110187e-03f, 1.16589487e-01f, -1.22834839e-01f, 1.02302872e-01f, 3.73320505e-02f, -5.22235557e-02f, 2.25846171e-01f, -1.42556685e-03f, 9.43439677e-02f, 7.97110051e-02f,
  -1.37576044e-01f, 1.03164524e-01f, 1.32713586e-01f, 4.19084616e-02f, 1.13453805e-01f, 1.80323064e-01f, 9.28940177e-02f, -1.82253376e-01f, -7.39385560e-02f, 1.29258990e-01f,
  1.25434116e-01f, 1.94238871e-01f, 1.06088415e-01f, -1.22070275e-01f, 1.76027596e-01f, -1.01284198e-01f, 1.70995161e-01f, 1.59078315e-01f, -5.34444079e-02f, 1.42839655e-01f,
  2.17206299e-01f, -2.08388939e-02f, 1.40716746e-01f, 8.14801827e-02f, 4.88691516e-02f, -6.84630275e-02f, 9.08846557e-02f, 2.42763571e-02f, 1.02104038e-01f, -9.72619578e-02f,
  -6.67378381e-02f, 1.73829034e-01f, -3.67139988e-02f, -3.58618163e-02f, 1.68603778e-01f, 1.23732969e-01f, -8.65653008e-02f, 2.77862579e-01f, 1.03588238e-01f, -5.89970835e-02f,
  -2.84638762e-01f, -6.60673827e-02f, 4.23629582e-03f, -2.51000375e-01f, -2.91492697e-02f, -2.56046295e-01f, -1.94482535e-01f, 4.09598798e-02f, 2.70784587e-01f, 2.21204668e-01f,
  -1.01876937e-01f, -1.15572073e-01f, -1.07964233e-01f, 9.49129015e-02f, 3.77960764e-02f, 2.71024406e-01f, 2.39333674e-01f, 4.05227542e-02f, 1.97401792e-01f, 2.74155676e-01f,
  6.18928708e-02f, 2.05077529e-01f, 1.14806280e-01f, 1.21490419e-01f, 2.13297665e-01f, 2.53021121e-01f, 9.13157165e-02f, -9.60125551e-02f, 2.27864116e-01f, 1.14174508e-01f,
  1.02159284e-01f, 8.55309218e-02f, 8.67347866e-02f, 1.25909179e-01f, 5.89491390e-02f, -1.14321843e-01f, -5.18509559e-02f, 2.72361785e-01f, 1.22035071e-01f, 4.07808758e-02f,
  9.38803405e-02f, -2.40955696e-01f, 2.16939554e-01f, -5.03309034e-02f, -1.99193209e-01f, -7.16845095e-02f, -2.56588876e-01f, 2.19562590e-01f, 1.39600560e-01f, 3.07053346e-02f,
  -8.17858800e-02f, 3.20083424e-02f, -2.69146681e-01f, 5.40071055e-02f, 4.76420820e-02f, -7.55055100e-02f, -2.97941804e-01f, -8.55449289e-02f, -1.84283614e-01f, -1.58027694e-01f,
  -2.19990611e-02f, -1.53292000e-01f, 1.37889579e-01f, -1.31564796e-01f, -1.49615854e-01f, 1.25412017e-01f, -4.60112989e-02f, 4.59647417e-04f, -1.28664032e-01f, 1.75951079e-01f,
  -9.16374996e-02f, -1.65336967e-01f, -4.33573462e-02f, 2.20765904e-01f, 1.40946642e-01f, -6.54177889e-02f, -1.02490619e-01f, -2.37043217e-01f, -1.14047609e-01f, -1.00714616e-01f,
  -1.13919094e-01f, -1.50867864e-01f, -1.74155802e-01f, 1.36312649e-01f, 7.33831525e-02f, -5.14984727e-02f, -3.50849956e-01f, 1.75017100e-02f, 1.33429736e-01f, 2.02709064e-02f,
  -1.40252486e-01f, -9.60618034e-02f, 2.41518170e-01f, -1.46461129e-01f, 2.27270067e-01f, 3.27382505e-01f, 2.55368739e-01f, -9.59088951e-02f, 1.60728440e-01f, -7.37480670e-02f,
  -2.77863026e-01f, 9.05669108e-02f, -2.08896413e-01f, -1.79815083e-03f, 2.08001792e-01f, 2.21705750e-01f, -2.20676780e-01f, 9.39532295e-02f, 3.17388959e-02f, 2.32240707e-02f,
  2.27472410e-01f, 1.34695157e-01f, 3.93114276e-02f, 1.98607922e-01f, 1.39036506e-01f, 5.63449524e-02f, 9.42364484e-02f, 9.88775864e-03f, 1.05408639e-01f, 8.02643131e-03f,
  2.01660823e-02f, 1.54027507e-01f, 1.49940372e-01f, 7.20146522e-02f, 1.88875511e-01f, 1.60751209e-01f, 1.06032463e-02f, 4.79139909e-02f, -1.20141000e-01f, -1.34251595e-01f,
  2.86157817e-01f, -2.06601292e-01f, -1.83290303e-01f, -1.09917417e-01f, 7.47130886e-02f, 6.23628199e-02f, 1.34767309e-01f, -3.16929549e-01f, 6.19636588e-02f, 2.06462413e-01f,
  2.32065201e-01f, 2.00618178e-01f, 1.13410197e-01f, -1.60642043e-01f, 1.02886194e-02f, -1.74209084e-02f, 1.26808390e-01f, 2.37041037e-03f, -1.37523279e-01f, 6.35351017e-02f,
  4.05669883e-02f, -2.57537037e-01f, 2.97300756e-01f, -1.92316383e-01f, -1.71446782e-02f, 1.61505461e-01f, 1.10975895e-02f, -1.17199257e-01f, -8.11352730e-02f, -2.27063507e-01f,
  1.08878605e-01f, 2.92819296e-03f, -7.84920007e-02f, 5.61855324e-02f, 1.04462020e-01f, 5.09859174e-02f, -1.59105331e-01f, 2.50682056e-01f, -1.28960267e-01f, 1.15058392e-01f,
  2.67378926e-01f, 2.43536100e-01f, 2.90499508e-01f, 1.87500641e-01f, 1.10080592e-01f, 9.66124460e-02f, 5.59968017e-02f, 5.62088145e-03f, 1.15210295e-01f, -5.38517796e-02f,
  1.22865893e-01f, -5.09018153e-02f, -3.51034701e-02f, -1.48559779e-01f, -5.43737784e-02f, 1.30694374e-01f, 8.03748369e-02f, 3.60694304e-02f, -4.55111861e-02f, 1.17622344e-02f,
  6.26481622e-02f, 1.80141494e-01f, 8.84506106e-02f, 4.61585447e-02f, -2.51168877e-01f, 1.38549089e-01f, -8.74441266e-02f, 8.64718258e-02f, 1.64518073e-01f, 2.14542020e-02f,
  -2.61803627e-01f, -3.17455381e-02f, 1.35982828e-02f, 1.14788420e-01f, 1.34054586e-01f, -2.05804095e-01f, -5.09035848e-02f, 4.37188186e-02f, -2.49397710e-01f, -1.86744079e-01f,
  -2.06912048e-02f, 2.27145374e-01f, 1.79268628e-01f, 1.88558161e-01f, 1.34944752e-01f, 2.06723943e-01f, -1.26178190e-01f, 6.13995455e-02f, -1.98877491e-02f, 1.27213404e-01f,
  8.31706077e-02f, 6.37221383e-03f, 1.02675520e-02f, -9.50839072e-02f, 7.54397456e-03f, -1.35138705e-01f, 2.66681135e-01f, 8.43978077e-02f, -9.50913727e-02f, 2.51477603e-02f,
  1.09083615e-01f, -1.66323826e-01f, 2.03742415e-01f, 2.35660523e-01f, -2.00611934e-01f, 2.36541450e-01f, 8.75010490e-02f, -1.51525997e-02f, 2.50589371e-01f, -2.95809936e-02f,
  2.34358370e-01f, 1.94197483e-02f, 2.13886738e-01f, 9.92486924e-02f, 1.32907797e-02f, -3.20752114e-02f, -4.11105156e-02f, -8.65049064e-02f, 2.05169320e-01f, -5.61568327e-03f,
  -7.07674623e-02f, 1.43442377e-01f, 1.42628282e-01f, -5.71305864e-02f, 9.01187584e-02f, -7.33193979e-02f, 2.63714850e-01f, 7.53216073e-02f, -2.62062609e-01f, 3.06804897e-03f,
  1.99100554e-01f, 1.42200649e-01f, -1.88664291e-02f, -1.12970777e-01f, -2.17555270e-01f, -1.00591846e-01f, -1.39302745e-01f, -2.21657738e-01f, 2.69581117e-02f, -1.37741547e-02f,
  -8.11115131e-02f, 2.52298921e-01f, 4.44388762e-02f, 2.73472458e-01f, 9.84771028e-02f, -1.21741690e-01f, 2.19734877e-01f, 6.38904944e-02f, 1.75512359e-01f, 2.11214483e-01f,
  1.27178863e-01f, 2.79289722e-01f, 9.10544991e-02f, -1.18247040e-01f, -3.61947604e-02f, -1.16958559e-01f, -9.20063406e-02f, 3.57307047e-02f, -4.17771973e-02f, 1.62383884e-01f,
  4.66210917e-02f, 2.02243060e-01f, 1.14057846e-01f, -9.00884867e-02f, 1.81860611e-01f, 7.51201734e-02f, -1.21255197e-01f, 1.43492714e-01f, 3.41846459e-02f, -8.20330828e-02f,
  -2.37611365e-02f, -3.52528924e-03f, 9.76551138e-03f, -5.86157013e-03f, -1.45610005e-01f, -2.94993132e-01f, 1.42650887e-01f, 1.55704498e-01f, 1.35348558e-01f, -6.64979815e-02f,
  3.43077891e-02f, 2.08824058e-03f, 1.95476208e-02f, 1.70123372e-02f, 3.79315801e-02f, 5.06269261e-02f, 1.30925879e-01f, 7.53811672e-02f, -7.32075348e-02f, -4.17132005e-02f,
  1.78662166e-01f, -2.37515658e-01f, 2.82977283e-01f, 4.30587539e-03f, -1.33599281e-01f, -9.27328765e-02f, 1.42149150e-01f, 9.74962264e-02f, 2.74929971e-01f, -2.59948410e-02f,
  9.40537006e-02f, 2.35722065e-01f, 2.44464204e-01f, 2.00133979e-01f, 1.99134454e-01f, -2.38606632e-01f, 6.08035959e-02f, 5.18589579e-02f, 1.49447992e-01f, 2.50424426e-02f,
  -1.05564438e-01f, 1.18223600e-01f, -2.99347453e-02f, -2.41998985e-01f, 2.56598145e-01f, -2.15082780e-01f, -1.88038182e-02f, 2.01450542e-01f, -1.95182562e-02f, 8.13306198e-02f,
  -1.14958726e-01f, -3.01514059e-01f, 2.28786357e-02f, -1.40850216e-01f, 5.26084863e-02f, -1.02913864e-01f, 8.48948732e-02f, 8.85682330e-02f, -1.02877915e-01f, 2.98116326e-01f,
  9.86287519e-02f, 7.32810609e-03f, 2.15435565e-01f, 2.60281507e-02f, 1.59011692e-01f, 5.97598888e-02f, -5.03167510e-02f, 1.01696633e-01f, 1.59273461e-01f, -2.57170767e-01f,
  -6.39874041e-02f, 1.71400636e-01f, -2.71193078e-03f, -9.14048627e-02f, 8.02881867e-02f, -5.18631563e-02f, 5.14122732e-02f, -1.13098025e-02f, -7.67373573e-03f, 8.83364454e-02f,
  -7.01199025e-02f, 9.66875255e-02f, 3.95474546e-02f, -9.35132951e-02f, 4.49733436e-02f, -5.84339239e-02f, -1.60726339e-01f, 2.69243747e-01f, 2.54341345e-02f, -1.30484462e-01f,
  1.34731695e-01f, 1.54564366e-01f, -5.52989484e-04f, 1.03636406e-01f, -1.10132806e-01f, -1.73096702e-01f, -2.07439929e-01f, 5.91154769e-02f, 2.06219475e-03f, 1.91434518e-01f,
  1.01717085e-01f, -1.02962174e-01f, 7.68433958e-02f, 2.39894375e-01f, 1.79312095e-01f, 1.26339778e-01f, 6.83638593e-03f, 2.89551437e-01f, -6.01326004e-02f, 8.75124559e-02f,
  1.06658593e-01f, -1.02221482e-01f, 1.74417030e-02f, 2.42992774e-01f, 1.24436721e-01f, 2.55490810e-01f, -7.95316622e-02f, 1.01403229e-01f, 2.61990041e-01f, 2.93836724e-02f,
  8.25087801e-02f, 2.64375061e-01f, 8.35109055e-02f, -1.15479333e-02f, 1.73726752e-01f, 3.99854587e-04f, 1.43503487e-01f, -1.09519966e-01f, -1.39760286e-01f, -6.23947196e-02f,
  2.00625673e-01f, 2.15852726e-02f, 2.57422626e-01f, -1.81064308e-01f, -1.71012301e-02f, 2.06984505e-01f, -4.54390757e-02f, -2.90571928e-01f, 5.90318777e-02f, 1.70123771e-01f,
  2.09323522e-02f, -6.25623241e-02f, 8.97587314e-02f, 8.07952881e-02f, -4.43441793e-02f, 2.39128739e-01f, 1.58998117e-01f, 3.81040806e-03f, -9.33861658e-02f, -1.06161170e-01f,
  9.05456543e-02f, 5.65294810e-02f, -2.01288566e-01f, -2.24343792e-01f, 2.43314147e-01f, 1.38236731e-01f, 7.57637694e-02f, 1.65946454e-01f, 9.85439494e-02f, 1.80751104e-02f,
  2.70340797e-02f, 4.80459519e-02f, 1.84016809e-01f, 7.10832924e-02f, 1.05881676e-01f, -3.11213046e-01f, 2.92548299e-01f, 3.14208806e-01f, -1.71539754e-01f, 2.40122154e-01f,
  -1.01611666e-01f, 2.33197659e-01f, -8.45437497e-03f, -2.28192121e-01f, 2.40470707e-01f, 1.42674983e-01f, 1.83986261e-01f, 3.23629111e-01f, -8.94434899e-02f, 3.07861958e-02f,
  1.48426546e-02f, -2.46676490e-01f, 1.87772602e-01f, -1.79842159e-01f, -8.82133916e-02f, 1.64618254e-01f, 1.01706900e-01f, -6.89390749e-02f, 2.56722182e-01f, -2.35933825e-01f,
  9.04503837e-02f, 3.01581938e-02f, 6.20933808e-02f, 9.06604691e-05f, 7.22454116e-02f, -1.06535375e-01f, 2.53317982e-01f, -2.33859614e-01f, -2.47754917e-01f, 2.39864960e-01f,
  -3.56246121e-02f, 1.83682233e-01f, 1.36533286e-02f, 2.53022969e-01f, 1.06539398e-01f, 2.00599488e-02f, -9.48610455e-02f, 6.11957721e-02f, 6.00056611e-02f, 3.83551940e-02f,
  -1.06587701e-01f, -2.81872135e-02f, 2.54857540e-01f, 1.22798763e-01f, 1.71776444e-01f, -1.88667715e-01f, -6.44029751e-02f, -1.56804949e-01f, 1.76002551e-02f, 8.58972073e-02f,
  2.21452922e-01f, -2.15270653e-01f, 1.95949852e-01f, -5.22848368e-02f, 4.02938686e-02f, 2.94319332e-01f, 1.89543024e-01f, -3.12964320e-02f, 7.05741793e-02f, -2.03339323e-01f,
  2.06547558e-01f, 1.75213926e-02f, -2.95183063e-01f, 4.72544134e-03f, -1.43797278e-01f, -8.78477171e-02f, 1.13271601e-01f, -3.41186374e-01f, -1.90930143e-01f, 2.29748130e-01f,
  -8.44480377e-03f, 1.33288577e-01f, 9.43862423e-02f, 3.36993076e-02f, 1.96078509e-01f, -1.32476032e-01f, -1.34564459e-01f, -7.82972649e-02f, 9.74225327e-02f, 1.62971783e-02f,
  -1.17472939e-01f, 6.02933504e-02f, 7.23900720e-02f, -7.02206790e-03f, 2.02120230e-01f, 1.09101877e-01f, 1.35412604e-01f, 1.91679284e-01f, -2.22269911e-02f, 1.32813573e-01f,
  6.90333694e-02f, 1.16774645e-02f, -1.46867678e-01f, -5.86025715e-02f, -1.20964319e-01f, 1.81678589e-02f, -5.24026230e-02f, 1.95388775e-02f, 5.57920560e-02f, 4.27739136e-02f,
  2.71696988e-02f, 1.18832842e-01f, -1.01623505e-01f, -4.82102223e-02f, 9.01408270e-02f, 2.28454843e-02f, 9.80455056e-03f, 3.01545076e-02f, -2.92058468e-01f, -1.96301136e-02f,
  9.74218249e-02f, 2.54179925e-01f, 6.39655367e-02f, 2.06931122e-02f, -3.58820595e-02f, 1.55218542e-01f, -2.32223213e-01f, -1.12801366e-01f, -1.25375818e-02f, -1.02063328e-01f,
  -1.88379921e-02f, 1.45025671e-01f, 1.16176948e-01f, 1.46644816e-01f, -4.34923880e-02f, -5.42067401e-02f, 2.69187033e-01f, 4.99771833e-02f, 1.82082251e-01f, 1.74337588e-02f,
  3.92023474e-02f, 3.01557362e-01f, 2.21365497e-01f, -1.24221787e-01f, -1.12491071e-01f, -3.75507176e-02f, 8.42580497e-02f, 5.22483587e-02f, -2.03542501e-01f, 2.57209867e-01f,
  -7.90932924e-02f, 1.29991621e-01f, 1.64584592e-01f, -6.83604404e-02f, 2.95650750e-01f, 9.02575403e-02f, -1.56400964e-01f, 1.44351840e-01f, -1.99566379e-01f, -1.71135500e-01f,
  4.33893465e-02f, 1.72580123e-01f, 1.54503688e-01f, 5.44514507e-02f, -8.47894177e-02f, 2.57144533e-02f, 8.49569142e-02f, 2.84337234e-02f, 1.87672004e-01f, -6.25125691e-02f,
  1.37169957e-01f, 1.03607267e-01f, 5.96001893e-02f, 1.56989709e-01f, -6.02203161e-02f, 1.06584705e-01f, 1.77331477e-01f, -4.79517356e-02f, 5.82051612e-02f, 5.40002175e-02f,
  -3.01145352e-02f, -1.41055658e-01f, -3.79978726e-03f, -2.01975450e-01f, -1.50268272e-01f, 1.90213963e-01f, 1.84301347e-01f, 2.37839565e-01f, -1.33936718e-01f, -2.93735504e-01f,
  9.49077830e-02f, 2.22986490e-01f, 3.02729994e-01f, -1.25622228e-01f, -4.84369509e-03f, -2.18573809e-01f, -2.73136616e-01f, -4.10479717e-02f, 1.23687379e-01f, 4.30079922e-02f,
  6.57992586e-02f, 1.91536441e-01f, 8.38928521e-02f, -2.83600181e-01f, -6.72715306e-02f, -1.90688372e-02f, 2.80969013e-02f, -1.34644751e-02f, -2.05126498e-03f, 5.95408008e-02f,
  -1.98939994e-01f, -1.45719126e-01f, 5.06141596e-02f, -1.97956964e-01f, 1.25267267e-01f, 5.74740060e-02f, -1.01711132e-01f, -1.98005922e-02f, 5.10684811e-02f, -7.86649436e-02f,
  8.22003633e-02f, 2.33905450e-01f, -1.29351810e-01f, 1.10383146e-01f, 3.08430880e-01f, 1.78917288e-03f, 1.09812476e-01f, 9.11904946e-02f, 1.25889510e-01f, -2.95414086e-02f,
  3.36253911e-01f, -1.50887325e-01f, -2.18975432e-02f, -2.06829444e-01f, 3.51636903e-03f, 1.24772295e-01f, 1.24328911e-01f, 2.95130778e-02f, 1.66175321e-01f, 4.96409601e-03f,
  2.38692649e-02f, 1.21561788e-01f, 7.29531702e-03f, -2.05761357e-03f, -1.81442499e-01f, -2.19361380e-01f, -4.30562496e-02f, -1.40262708e-01f, -2.41538033e-01f, -1.63014591e-01f,
  -1.72954351e-01f, 2.40112379e-01f, 1.31908193e-01f, 1.64745852e-01f, -3.70696397e-03f, -1.70406431e-01f, -2.82829143e-02f, -1.39037624e-01f, -1.83051489e-02f, 1.54203430e-01f,
  7.30560422e-02f, -1.10736303e-01f, 2.29027942e-02f, 8.78820494e-02f, 3.22885513e-02f, 2.82037884e-01f, -2.02555075e-01f, 2.16610342e-01f, -4.40444238e-02f, 2.12421361e-02f,
  9.85783637e-02f, -8.42917860e-02f, 2.65495569e-01f, 1.61193788e-01f, 2.40242124e-01f, 3.35352540e-01f, 8.39266479e-02f, -1.88511815e-02f, 2.72784885e-02f, -1.09419182e-01f,
  -1.41255364e-01f, 2.25178093e-01f, -7.03907311e-02f, 8.13889578e-02f, 1.80649355e-01f, -1.89988196e-01f, -1.58345640e-01f, 1.78514734e-01f, -6.19566143e-02f, -2.06453338e-01f,
  -8.43615085e-02f, 1.31643057e-01f, 2.05110759e-02f, 2.00468779e-01f, 3.02882884e-02f, 2.27487721e-02f, -1.66316494e-01f, 2.23980248e-01f, 5.47977500e-02f, -4.06727456e-02f,
  -1.95702136e-01f, -1.56617612e-01f, -8.45723692e-03f, -1.80704445e-01f, -1.86773077e-01f, 9.74267423e-02f, -6.85873181e-02f, 1.02229975e-01f, 4.34659421e-02f, 1.47578642e-01f,
  -2.29759768e-01f, 2.66254991e-01f, 5.37415855e-02f, 9.81531665e-02f, -6.29115552e-02f, -4.54647280e-02f, -7.75772473e-03f, 2.42177725e-01f, 1.81849748e-02f, 1.26913890e-01f,
  -2.31200665e-01f, -1.26851156e-01f, -1.73248962e-01f, 1.33522063e-01f, 7.08266050e-02f, -5.82930073e-02f, 9.02096927e-02f, 2.14948714e-01f, -2.06254087e-02f, 5.59377111e-02f,
  1.06724523e-01f, 6.97060078e-02f, 1.66275371e-02f, -1.62077341e-02f, 9.61953849e-02f, 2.66674291e-02f, 1.76961049e-01f, 8.57918262e-02f, 6.36106133e-02f, 4.71927300e-02f,
  -1.93880752e-01f, 7.88834542e-02f, 2.48180121e-01f, -6.05720803e-02f, 6.18976988e-02f, -8.94464180e-02f, -6.89265877e-02f, -3.02698910e-01f, 2.19825268e-01f, 2.81771384e-02f,
  -1.10917605e-01f, -5.20944363e-03f, -1.14056900e-01f, -1.37158722e-01f, 3.12768161e-01f, -1.64316460e-01f, 2.54353672e-01f, 2.97382474e-02f, -1.12920016e-01f, 1.45568743e-01f,
  -1.15486030e-02f, -5.20605557e-02f, 5.84033616e-02f, 6.43433556e-02f, 3.67071666e-02f, 8.49558339e-02f, 8.27664584e-02f, 1.66134596e-01f, 6.12489730e-02f, 2.40584493e-01f,
  -3.54052633e-02f, 7.83570707e-02f, 1.07153036e-01f, -2.69058179e-02f, 1.95638448e-01f, 1.80345938e-01f, -2.18801349e-01f, -1.00529656e-01f, 1.61547914e-01f, 1.67777836e-01f,
  3.04510519e-02f, -1.60881326e-01f, 5.78404521e-04f, 8.71005207e-02f, 1.50959551e-01f, 9.89699066e-02f, 4.02997360e-02f, -1.97157130e-01f, -3.23367417e-02f, -9.79817584e-02f,
  2.05697820e-01f, -7.90406615e-02f, -1.09871663e-01f, 8.35886523e-02f, -1.58436820e-01f, -2.38777876e-01f, -2.33054325e-01f, -4.10217904e-02f, 2.24550784e-01f, 7.38396868e-02f,
  1.57375857e-01f, 2.84765601e-01f, -5.61514050e-02f, -1.27848729e-01f, -2.84493621e-02f, -1.74203098e-01f, -5.23633473e-02f, 1.84348240e-01f, 1.14367254e-01f, 5.49002849e-02f,
  9.07691866e-02f, -1.47573411e-01f, 5.24762310e-02f, 3.87178324e-02f, 1.42785907e-01f, 9.65684727e-02f, 1.40354499e-01f, -5.04331663e-02f, 1.44365892e-01f, -1.57042801e-01f,
  3.03059071e-02f, -5.68660349e-02f, -1.89158469e-01f, 1.67928383e-01f, -8.90638754e-02f, 1.30517349e-01f, 2.55432278e-02f, 1.16377480e-01f, 4.98526879e-02f, 5.41403070e-02f,
  -6.50477409e-02f, 6.04175031e-02f, 1.23506643e-01f, 1.04486778e-01f, 8.53875577e-02f, 1.49656415e-01f, 1.52830496e-01f, 1.19915251e-02f, 2.61199147e-01f, 2.76943352e-02f,
  1.40402475e-02f, -2.32095554e-01f, 1.21486619e-01f, 6.89355582e-02f, 2.96479285e-01f, -1.11014478e-01f, 1.48762435e-01f, 2.57192880e-01f, 2.39043254e-02f, 1.01830274e-01f,
  1.80275649e-01f, -2.09506556e-01f, -1.24512903e-01f, -2.22336411e-01f, 9.20709446e-02f, 1.11849546e-01f, -2.19528854e-01f, 4.21456136e-02f, -3.08370173e-01f, 8.49741176e-02f,
  -3.28079201e-02f, -3.51199925e-01f, -5.16218431e-02f, 2.32742444e-01f, 4.84108776e-02f, 2.23663852e-01f, -4.93016839e-02f, 7.43523613e-02f, -2.39715260e-02f, -4.55789044e-02f,
  7.52654597e-02f, -1.25631273e-01f, 9.73168702e-04f, 1.79910898e-01f, -6.76903129e-02f, -6.68598413e-02f, 2.74137855e-01f, 1.04096539e-01f, 2.14003518e-01f, 2.94686034e-02f,
  1.41569361e-01f, 3.49431224e-02f, 1.85660243e-01f, -7.47802481e-02f, 2.71215796e-01f, -5.87332509e-02f, -1.51216179e-01f, 2.46828884e-01f, 8.11588615e-02f, -2.63810549e-02f,
  1.79448679e-01f, 2.76725627e-02f, 3.03720925e-02f, 1.58432111e-01f, 3.41236778e-02f, 2.42620200e-01f, 9.14306566e-02f, 7.18900114e-02f, 6.35792091e-02f, 1.75410852e-01f,
  -2.15642862e-02f, -1.18382042e-02f, 3.05517353e-02f, -1.81445554e-02f, -1.97822630e-01f, 1.60382576e-02f, 3.28227013e-01f, 2.33159989e-01f, -3.19201201e-02f, -2.65906721e-01f,
  1.37721375e-01f, 2.84941673e-01f, 2.51194209e-01f, 9.32972282e-02f, 1.32471561e-01f, -1.52457416e-01f, -2.21749529e-01f, 2.95929555e-02f, 1.97448209e-01f, 7.14422613e-02f,
  1.60248622e-01f, 2.59350777e-01f, -8.12761039e-02f, -2.56548047e-01f, -8.85020196e-02f, 5.78985624e-02f, -2.93466728e-02f, 3.03915948e-01f, 1.29491627e-01f, 5.06415078e-03f,
  -2.45426983e-01f, -2.73782164e-01f, -1.52921025e-02f, -1.67765990e-01f, 5.24961613e-02f, 1.89232647e-01f, 2.14469694e-02f, -8.76634344e-02f, 1.84525438e-02f, -5.50658628e-02f,
  2.17529446e-01f, 1.48948297e-01f, -2.13656351e-02f, 1.56274483e-01f, 1.71774432e-01f, -1.31055579e-01f, 1.00307867e-01f, -1.38338968e-01f, 8.98366570e-02f, -4.68258224e-02f,
  8.89406800e-02f, 1.59465507e-01f, 1.14824370e-01f, 1.41152844e-01f, 1.35645211e-01f, 9.71336663e-02f, 6.00114390e-02f, 1.70193370e-02f, 1.21468246e-01f, 1.53292745e-01f,
  1.96597233e-01f, 1.75385207e-01f, 8.67555961e-02f, 6.70413449e-02f, 6.03808202e-02f, 6.49591610e-02f, 1.30173638e-01f, 3.07273190e-03f, -2.01564401e-01f, -1.99465960e-01f,
  4.41996306e-02f, -5.29608801e-02f, 1.06361516e-01f, -9.11797062e-02f, 9.94597524e-02f, 1.97297126e-01f, 8.81399214e-02f, 1.02304436e-01f, 8.14904869e-02f, -1.55266136e-01f,
  -2.35141724e-01f, -1.98103096e-02f, 1.69811189e-01f, 1.97797880e-01f, -1.84654016e-02f, 3.72168422e-02f, -2.46948272e-01f, -1.94670539e-02f, -2.29654089e-02f, -1.06127866e-01f,
  1.54042253e-02f, 5.14643863e-02f, 1.60852745e-01f, 6.72771260e-02f, -1.39126098e-02f, -1.83469057e-02f, 1.01565503e-01f, -6.45420253e-02f, 1.98673472e-01f, -1.53061718e-01f,
  -8.42744261e-02f, 3.01420130e-03f, 6.38001636e-02f, -1.62124783e-01f, 1.32629931e-01f, -5.83066419e-02f, 1.66130796e-01f, -8.60306770e-02f, -1.15510318e-02f, -7.83870295e-02f,
  -5.29949442e-02f, 1.14594996e-01f, 2.40889266e-01f, -7.85031468e-02f, -2.12328508e-02f, 2.92111468e-02f, 2.02817786e-02f, 7.88919702e-02f, -7.24339858e-02f, 9.01941285e-02f,
  1.40066296e-02f, 8.17854032e-02f, -8.23734328e-02f, 5.52434847e-02f, 6.96959049e-02f, -1.41295046e-01f, 9.55578238e-02f, 6.40017241e-02f, 2.48830810e-01f, 2.61759341e-01f,
  -2.27503516e-02f, -6.47578090e-02f, 1.43143415e-01f, -2.95954780e-03f, -4.71075028e-02f, -1.62554771e-01f, -1.00331165e-01f, -2.41156608e-01f, -6.14489354e-02f, -1.48207143e-01f,
  2.53136545e-01f, 3.12934637e-01f, 2.20482364e-01f, 6.99695721e-02f, 2.84102798e-01f, 1.99512392e-02f, 4.22316007e-02f, -3.18211079e-01f, -5.63126989e-02f, 5.88870719e-02f,
  2.52395689e-01f, -1.48227885e-01f, 2.70363778e-01f, 1.02447728e-02f, 8.62544626e-02f, 7.47061297e-02f, -1.92597419e-01f, 5.19712977e-02f, -7.62042254e-02f, -9.63622108e-02f,
  -4.99385335e-02f, -1.53890908e-01f, -3.04632634e-01f, 2.85421401e-01f, 6.19121268e-02f, -8.16490650e-02f, 2.40380824e-01f, 2.84033775e-01f, -2.54735589e-01f, 2.25182578e-01f,
  2.36014411e-01f, -1.21439539e-01f, 2.75084004e-02f, 2.85528779e-01f, -8.52499604e-02f, -1.57891475e-02f, -3.22581530e-01f, -1.41640872e-01f, 2.56889630e-02f, -8.72310847e-02f,
  7.46023580e-02f, 1.92646816e-01f, -6.52614906e-02f, -2.51724422e-02f, 7.13882446e-02f, 1.81043431e-01f, 2.00759666e-03f, -3.71106938e-02f, 2.17078567e-01f, -6.75371364e-02f,
  7.18672872e-02f, 9.14426148e-02f, 7.34872669e-02f, -1.24424271e-01f, 1.24015823e-01f, 2.60345280e-01f, -9.71896797e-02f, -3.71891186e-02f, 3.79643105e-02f, 2.66903192e-02f,
  2.35901847e-01f, 1.88740604e-02f, 2.31772825e-01f, 1.85682118e-01f, 5.57560846e-02f, 4.70060818e-02f, 6.38414640e-03f, -9.70653370e-02f, -3.22921395e-01f, -7.42537975e-02f,
  1.03344858e-01f, 5.64207770e-02f, -3.04053947e-02f, 4.20406237e-02f, -3.56257558e-02f, -3.80995199e-02f, -6.63697198e-02f, -5.75843714e-02f, -5.47096394e-02f, 2.26117685e-01f,
  1.98516324e-01f, 2.01955251e-02f, -6.84992969e-02f, -6.19028322e-02f, -7.59449676e-02f, -4.73484099e-02f, 1.74646214e-01f, -9.57181156e-02f, -1.10163905e-01f, -9.70634297e-02f,
  -1.27497703e-01f, -1.98303714e-01f, 6.81791455e-02f, 6.91400245e-02f, -5.00986166e-02f, 9.96963009e-02f, 2.79756486e-01f, 1.07435822e-01f, 2.49784350e-01f, -2.20118463e-01f,
  1.46805406e-01f, -3.14984769e-02f, -8.34611580e-02f, 1.68659762e-01f, -2.48607337e-01f, 2.33174339e-02f, -1.64120309e-02f, -1.36530682e-01f, -3.90262865e-02f, -9.43118557e-02f,
  6.54737756e-04f, 8.48797262e-02f, -1.02532953e-01f, 3.55252884e-02f, 4.68463264e-02f, 5.50802276e-02f, 1.57950312e-01f, 2.06442609e-01f, 5.60968406e-02f, -1.93603113e-01f,
  1.34272590e-01f, 1.80474460e-01f, 5.27168624e-02f, -1.95998132e-01f, -7.14228451e-02f, 2.41618436e-02f, 6.93697184e-02f, -1.09402515e-01f, 1.83612108e-01f, 8.25304985e-02f,
  2.05938786e-01f, -4.25033644e-03f, 1.15652844e-01f, -1.34953856e-01f, 4.90606464e-02f, -2.99413234e-01f, 7.35508800e-02f, -1.55372679e-01f, 1.03475377e-02f, -6.92444071e-02f,
  -6.56918809e-02f, 1.52615219e-01f, 6.23136796e-02f, 4.00651731e-02f, -3.28413472e-02f, 1.31751344e-01f, 1.82796150e-01f, -7.78136402e-02f, -1.14490971e-01f, 7.90351257e-03f,
  -3.09850842e-01f, 2.01996550e-01f, 7.31461346e-02f, -1.35598004e-01f, 1.81845203e-01f, 3.99852656e-02f, -1.70903578e-01f, 1.51641935e-01f, 1.78091660e-01f, 1.34305274e-02f,
  -2.15348937e-02f, 2.75963008e-01f, 8.75463486e-02f, -4.59174700e-02f, -2.72415757e-01f, 2.49489293e-01f, 1.02725610e-01f, -8.08006525e-02f, 2.10277230e-01f, 7.67239258e-02f,
  -4.16396419e-03f, 1.56421468e-01f, 1.10942475e-01f, 1.90103024e-01f, -9.93659422e-02f, -4.31033513e-05f, 2.12517843e-01f, 5.27330041e-02f, -2.72318907e-03f, -2.99895294e-02f,
  8.29192325e-02f, -1.42814979e-01f, 1.99860126e-01f, -4.63687330e-02f, -1.95534512e-01f, 7.01077729e-02f, 7.34644309e-02f, 1.96173504e-01f, 1.08572260e-01f, -8.20094422e-02f,
  -3.97477373e-02f, 1.49111494e-01f, 9.43430439e-02f, -4.87252846e-02f, -2.20958218e-02f, 9.16142203e-03f, -2.20825717e-01f, -8.71605873e-02f, -5.54843515e-04f, -4.77902405e-02f,
  3.33869793e-02f, 1.49282426e-01f, -6.20352663e-02f, 5.16825281e-02f, 1.59636661e-02f, -5.55363707e-02f, -5.76317916e-03f, 3.73169705e-02f, 1.78928703e-01f, -8.15220177e-02f,
  -9.24418643e-02f, -1.36408791e-01f, 5.70492670e-02f, -1.23238444e-01f, 1.77173674e-01f, -7.37130418e-02f, 1.53472036e-01f, -8.19509253e-02f, 2.27195807e-02f, 8.77678320e-02f,
  2.47175634e-01f, 1.31823838e-01f, -2.58100145e-02f, 1.74240947e-01f, 1.15433387e-01f, -1.08650193e-01f, 2.11331412e-01f, 1.38587803e-01f, 8.80961418e-02f, -1.41495064e-01f,
  2.13078916e-01f, 7.02414438e-02f, 8.41446817e-02f, 1.97896853e-01f, 4.28464729e-03f, -2.40237787e-02f, 1.22198530e-01f, -8.94494280e-02f, 1.05769141e-02f, -4.70479354e-02f,
  -1.10520057e-01f, -1.32564843e-01f, -1.93207040e-02f, 1.49705876e-02f, -1.29502892e-01f, -1.35887638e-02f, 1.01098895e-01f, -2.11457849e-01f, -1.25913963e-01f, 3.32465433e-02f,
  -6.59126276e-03f, 6.85605705e-02f, -6.03058599e-02f, -2.07877323e-01f, 4.56414968e-02f, 7.77516067e-02f, 2.05001026e-01f, -1.04464717e-01f, -4.77644950e-02f, -3.60989384e-02f,
  -7.97012672e-02f, -2.38551479e-02f, -9.29696932e-02f, -2.45590255e-01f, 6.98987618e-02f, 1.04115553e-01f, -6.12374283e-02f, -2.60430276e-01f, 4.96918261e-02f, 1.23239700e-02f,
  -1.97532102e-01f, 1.38339162e-01f, 1.19868204e-01f, -7.19154999e-02f, 1.28657177e-01f, -6.51776269e-02f, 2.30634674e-01f, -1.62041634e-01f, -3.22159566e-02f, 1.46453053e-01f,
  8.54938775e-02f, -1.71363965e-01f, 1.54741528e-02f, 2.53193855e-01f, -1.29002566e-02f, 2.23173901e-01f, -4.88359481e-02f, 5.96123450e-02f, 2.14465454e-01f, 8.87516513e-02f,
  2.07681134e-01f, 2.14060172e-01f, -2.49678232e-02f, 2.98379272e-01f, 2.08192706e-01f, -7.56604895e-02f, 7.54391104e-02f, -2.99083404e-02f, -1.19954020e-01f, -1.85484067e-01f,
  -3.84392962e-02f, -8.90240222e-02f, -1.05015710e-01f, 1.26510896e-02f, 1.01292044e-01f, -9.62463841e-02f, -2.60598585e-02f, -1.51338473e-01f, 2.22412199e-02f, -3.05157695e-02f,
  -4.50446010e-02f, -2.71028101e-01f, 1.29216686e-01f, -1.36193708e-01f, -2.67404467e-01f, -3.11237335e-01f, 1.24179170e-01f, 1.36449546e-01f, -3.42523493e-02f, -7.34266266e-02f,
  -7.90349916e-02f, -2.88717989e-02f, 3.58704999e-02f, 2.38778874e-01f, 1.19992584e-01f, 1.79528564e-01f, -7.97677115e-02f, -2.34812140e-01f, 8.09590295e-02f, -1.02274738e-01f,
  3.17228109e-01f, 7.24933371e-02f, 3.02618980e-01f, 3.38124245e-01f, 1.97900921e-01f, -1.29769474e-01f, 6.49456903e-02f, -2.05335453e-01f, 2.37166315e-01f, -1.48181617e-01f,
  1.18017070e-01f, 2.01447427e-01f, -2.32071891e-01f, 1.38106793e-01f, 2.22554952e-01f, 7.22043663e-02f, -3.62642971e-03f, 2.58265376e-01f, -6.34873435e-02f, -1.07654639e-01f,
  1.09954089e-01f, 1.26279965e-01f, -5.87431230e-02f, 1.60394371e-01f, -3.00341755e-01f, 1.62005231e-01f, -5.58879711e-02f, 2.12778285e-01f, 1.17377952e-01f, -1.63606510e-01f,
  -4.64632213e-02f, -2.44771197e-01f, 5.91385318e-03f, 1.51125669e-01f, 5.33346497e-02f, 3.97823602e-02f, 8.75318646e-02f, 7.80348256e-02f, 1.12640776e-01f, 3.45249362e-02f,
  -8.12639594e-02f, 3.45442519e-02f, 5.59193753e-02f, -6.75625205e-02f, -1.87280521e-01f, 1.98347539e-01f, -1.75268538e-02f, 6.68048509e-04f, -3.41325738e-02f, 1.82992086e-01f,
  7.22472295e-02f, 3.53657633e-01f, -7.97526240e-02f, -6.72922060e-02f, -1.04255460e-01f, 2.41734255e-02f, 1.22345574e-01f, 2.09250152e-01f, 1.34914756e-01f, 2.54489213e-01f,
  1.98112160e-01f, 4.32035252e-02f, 1.94159940e-01f, 1.44459710e-01f, 1.76715955e-01f, 3.13494802e-01f, 4.38236780e-02f, 1.92036480e-01f, 2.52380222e-01f, -6.08720444e-02f,
  1.32062092e-01f, 2.88473397e-01f, 1.47301868e-01f, 5.16178384e-02f, -1.37370348e-01f, 3.53212059e-01f, 2.15278760e-01f, 5.46491556e-02f, 1.30172208e-01f, 2.74047107e-01f,
  4.21411060e-02f, 1.49144023e-03f, -1.71045661e-02f, 2.89527308e-02f, 2.25618053e-02f, -4.14925739e-02f, -2.98121423e-01f, 1.49510708e-02f, 1.53781166e-02f, 1.74494669e-01f,
  1.44372806e-01f, -3.96450572e-02f, -1.44013226e-01f, 2.31459334e-01f, -4.10428829e-02f, -9.18566063e-02f, 3.60663161e-02f, 1.17823645e-01f, 1.26329824e-01f, -3.76734603e-03f,
  -1.73708831e-03f, 6.00217432e-02f, -1.52349016e-02f, 5.49683869e-02f, 8.06849375e-02f, 1.07006393e-02f, 1.09503031e-01f, -1.17167898e-01f, -1.53571507e-02f, 2.04729006e-01f,
  -1.63194492e-01f, 1.26394480e-01f, -6.10906221e-02f, 6.98881149e-02f, 1.56718448e-01f, 1.25084534e-01f, -1.57303009e-02f, -2.71493178e-02f, -1.12521708e-01f, -1.25145474e-02f,
  -1.72139883e-01f, -4.59240936e-02f, -1.41537324e-01f, 1.13876715e-01f, 1.54885530e-01f, 3.13634276e-01f, 1.28177211e-01f, 1.54336423e-01f, -9.69553366e-02f, 5.12187928e-03f,
  3.94720212e-02f, -4.49354202e-02f, 6.54062703e-02f, 8.38804469e-02f, 2.72282153e-01f, 9.45621952e-02f, 2.25701239e-02f, 1.27061486e-01f, -7.97278583e-02f, 7.74061456e-02f,
  2.70923167e-01f, -5.84598556e-02f, -2.80585736e-02f, 1.40119210e-01f, 2.60058567e-02f, -2.08369389e-01f, 2.72196740e-01f, 1.44983798e-01f, -4.79706712e-02f, 5.86761981e-02f,
  6.58384711e-02f, -1.18952051e-01f, 2.64505953e-01f, -1.33992091e-01f, 1.42503664e-01f, -1.28118798e-01f, -3.84106562e-02f, 2.84916788e-01f, 4.27635796e-02f, 1.60373390e-01f,
  1.52780682e-01f, 3.69772054e-02f, 2.07488060e-01f, 1.76286221e-01f, -6.74786791e-02f, 1.47197217e-01f, -3.18228565e-02f, 3.49491499e-02f, 6.67766854e-02f, 8.50271732e-02f,
  3.22709791e-02f, -8.25851932e-02f, 7.53877386e-02f, -3.15657705e-02f, -1.50623083e-01f, 1.38013527e-01f, 3.41873646e-01f, 2.90029675e-01f, 4.26324308e-02f, -2.67203093e-01f,
  -3.29519026e-02f, 9.55832675e-02f, 1.25407413e-01f, 7.84437358e-02f, 2.51104236e-01f, -1.66144490e-01f, -1.48068815e-01f, -1.86921239e-01f, 1.43282354e-01f, 6.70268536e-02f,
  -2.77217552e-02f, -2.26375507e-03f, 9.57018957e-02f, -1.70357853e-01f, -1.54620081e-01f, -3.41171250e-02f, 7.24441856e-02f, 1.68829560e-01f, 9.48874652e-02f, 2.07879007e-01f,
  -1.99148804e-01f, -8.53866637e-02f, -5.04634678e-02f, -1.42445236e-01f, -9.68122929e-02f, 2.19622910e-01f, 9.51326415e-02f, -2.87036777e-01f, 8.07664618e-02f, 2.80303955e-02f,
  2.65137672e-01f, 3.21709901e-01f, 5.05419150e-02f, 8.60645846e-02f, 3.02323669e-01f, 4.01683450e-02f, 3.28847498e-01f, -4.60727550e-02f, 4.92698215e-02f, -2.03997299e-01f,
  2.00559143e-02f, 2.19857305e-01f, 7.24468604e-02f, -1.93863869e-01f, -2.36822870e-02f, 1.67938203e-01f, -6.67600567e-03f, 2.71788449e-03f, 1.35013849e-01f, 8.69887993e-02f,
  9.80762988e-02f, 1.89571112e-01f, 7.65716061e-02f, 1.03097796e-01f, -2.34436989e-01f, -2.43337035e-01f, 4.56748717e-02f, -2.00756431e-01f, -1.15945287e-01f, -2.31962711e-01f,
  -5.22014908e-02f, 1.50169820e-01f, 2.32498154e-01f, -1.42355442e-01f, 1.29870862e-01f, -1.95688963e-01f, 2.12720200e-01f, 2.17835650e-01f, 1.70495719e-01f, 1.13324359e-01f,
  1.83130488e-01f, -8.44081864e-02f, -1.46420613e-01f, -1.02262251e-01f, 6.45172000e-02f, 1.54407829e-01f, -1.87934235e-01f, 2.98839249e-02f, 1.98381439e-01f, 3.91603224e-02f,
  3.72955948e-02f, -1.85202807e-01f, 1.55727088e-03f, 8.77062790e-03f, 5.90445921e-02f, 1.59794167e-02f, 2.85443276e-01f, 1.54437788e-03f, -7.59178102e-02f, -9.69618335e-02f,
  1.15443522e-03f, 3.57457876e-01f, -2.60772500e-02f, 2.29351684e-01f, -2.66104825e-02f, -2.27977127e-01f, 1.44363940e-01f, 1.63620144e-01f, -1.31715871e-02f, -5.30640259e-02f,
  -8.06824565e-02f, 3.36373866e-01f, -8.01018924e-02f, 3.78645472e-02f, 2.04911053e-01f, -1.13020979e-01f, -5.23562133e-02f, -1.59082472e-01f, 5.12079429e-03f, 6.18855283e-02f,
  -4.16169539e-02f, -1.17096342e-01f, 2.26105526e-01f, 6.02071211e-02f, -1.32979220e-02f, 2.37479210e-01f, 3.15889642e-02f, 7.83337131e-02f, -2.14256257e-01f, -2.14210562e-02f,
  1.17467612e-01f, -1.74448296e-01f, -1.40864430e-02f, -6.63752407e-02f, -2.13815883e-01f, -1.09141938e-01f, 1.26809001e-01f, -5.08426726e-02f, 4.19558436e-02f, -5.17194755e-02f,
  3.88847813e-02f, -2.36918516e-02f, 1.31828561e-01f, 1.98898334e-02f, 2.27907375e-01f, 1.72338054e-01f, 4.92027812e-02f, 2.05938771e-01f, 9.58559811e-02f, -3.85630168e-02f,
  -6.09619580e-02f, 1.68769822e-01f, 2.01854378e-01f, 2.06002846e-01f, 7.21394271e-02f, -2.60063633e-02f, 8.62538293e-02f, 1.51458114e-01f, 2.62594908e-01f, 4.52987514e-02f,
  1.86321542e-01f, 9.52129066e-02f, 3.16322558e-02f, -1.65664971e-01f, 3.89781073e-02f, 1.86807826e-01f, -1.33263260e-01f, -1.09613948e-02f, -1.03505403e-02f, -1.81808561e-01f,
  1.44662455e-01f, 4.54362109e-02f, -2.60633796e-01f, 6.38696775e-02f, -1.69062153e-01f, 2.52073616e-01f, 6.91952035e-02f, 1.98099911e-01f, -3.00285649e-02f, -7.88245872e-02f,
  -6.79701492e-02f, -2.14935780e-01f, 2.47908533e-01f, -3.96209583e-02f, -1.11592218e-01f, 9.79567394e-02f, 1.05201453e-01f, 5.13900593e-02f, -1.42419085e-01f, 2.92422086e-01f,
  4.89847176e-02f, 2.03854814e-01f, -3.89369845e-01f, -1.08468466e-01f, 1.54854059e-01f, -1.94351114e-02f, -2.48986229e-01f, 5.96527942e-02f, -8.12163502e-02f, 5.68489656e-02f,
  -5.50183021e-02f, -1.36349753e-01f, 6.15537390e-02f, 1.14790581e-01f, 1.60600320e-02f, -1.21842392e-01f, 1.50496244e-01f, 5.23026520e-03f, 2.62925811e-02f, -1.79434363e-02f,
  -3.44495550e-02f, 2.41789505e-01f, 4.74750996e-02f, 2.00779930e-01f, -1.15280382e-01f, -1.10003762e-01f, 1.40511528e-01f, -3.50382738e-02f, -1.59576997e-01f, -1.62494645e-01f,
  6.13853820e-02f, -8.32047984e-02f, 2.45937966e-02f, -3.14964652e-02f, 1.30354643e-01f, 3.12777571e-02f, 1.23456396e-01f, -2.22951159e-01f, -2.67688364e-01f, 1.49653241e-01f,
  -2.04390153e-01f, -7.63546452e-02f, 1.70351133e-01f, 1.41564256e-03f, -1.17928028e-01f, 2.42989689e-01f, -3.48427296e-02f, -6.21524677e-02f, 5.18725924e-02f, 1.29211277e-01f,
  1.67116448e-01f, 2.60131925e-01f, 2.21235886e-01f, 4.15433533e-02f, 4.13445197e-02f, 5.85470255e-03f, -9.30707604e-02f, 1.16923235e-01f, 1.73908621e-01f, 9.48708504e-02f,
  -9.98584032e-02f, -1.52991235e-01f, -5.98370880e-02f, 8.08138307e-03f, 6.16322011e-02f, 8.31614286e-02f, 2.77477741e-01f, 5.51160090e-02f, -1.62164703e-01f, 1.90046594e-01f,
  -1.55230656e-01f, 1.50370583e-01f, 8.04597437e-02f, 1.10967807e-01f, -4.00066823e-02f, 1.63319841e-01f, -1.08287938e-01f, -6.70478344e-02f, -2.62385070e-01f, 5.19868806e-02f,
  -1.15026005e-01f, 6.17685951e-02f, 9.92030278e-02f, 2.29557455e-01f, 1.98443472e-01f, 1.03259251e-01f, 1.65328190e-01f, 1.17220618e-01f, 1.88714430e-01f, 1.26293510e-01f,
  -9.55770761e-02f, 2.38257647e-01f, 1.49797313e-02f, -3.28022726e-02f, 1.38016418e-01f, 1.67891309e-01f, 1.23673037e-01f, -7.39814937e-02f, -2.42600456e-01f, 1.99555457e-01f,
  2.12609380e-01f, 4.33668830e-02f, 7.00185299e-02f, 3.13897729e-02f, 7.56736994e-02f, -1.69973210e-01f, 1.56545535e-01f, 1.24317460e-01f, -7.83133432e-02f, -2.25272372e-01f,
  6.66297823e-02f, -1.04365293e-02f, 1.68960229e-01f, -5.77430502e-02f, -6.01651445e-02f, -1.76433250e-01f, 5.45768589e-02f, 2.81617135e-01f, -8.82002860e-02f, 4.02835011e-02f,
  -4.11898531e-02f, 1.62087440e-01f, 1.25826776e-01f, 1.58876851e-01f, 4.81944159e-02f, 1.78697258e-01f, 8.66712108e-02f, -5.07109659e-03f, -1.06995940e-01f, 1.45159379e-01f,
  2.45501474e-01f, 1.44344702e-01f, -1.15558408e-01f, 7.22196922e-02f, -6.82030767e-02f, 2.24644348e-01f, 1.23994455e-01f, 2.15186894e-01f, -1.62242964e-01f, -3.03635951e-02f,
  -1.90475896e-01f, 8.63055363e-02f, -6.42134845e-02f, -3.51027143e-03f, 1.38446875e-02f, 1.91022173e-01f, -5.55532165e-02f, 8.63106400e-02f, 1.42673582e-01f, -1.73265263e-02f,
  1.55664861e-01f, 3.91946882e-02f, 2.70896852e-01f, 4.55353893e-02f, -1.78560063e-01f, 1.80653647e-01f, 2.77804315e-01f, 1.66748598e-01f, -5.78777976e-02f, -4.63901348e-02f,
  -9.42507610e-02f, -8.63863900e-02f, -2.16537565e-01f, 2.93598890e-01f, 1.30345430e-02f, 3.04615706e-01f, 8.53304937e-02f, -5.85730858e-02f, 2.06421450e-01f, 6.72407215e-03f,
  1.28582701e-01f, 2.09699675e-01f, 1.85851231e-02f, -9.14171562e-02f, 1.49878338e-01f, 1.43002406e-01f, 1.24579065e-01f, -3.54399495e-02f, -2.69104186e-02f, -1.71496734e-01f,
  2.48453528e-01f, 8.33963305e-02f, -9.51308664e-03f, 1.00231700e-01f, 1.21764950e-01f, -9.15435255e-02f, -4.26722690e-02f, 5.76044023e-02f, 7.75802806e-02f, 1.51584689e-02f,
  5.93545660e-02f, 2.25106291e-02f, 3.51306833e-02f, 9.61742923e-02f, 1.10778935e-01f, -1.37877725e-02f, -3.97599339e-02f, 6.39114976e-02f, 7.13910675e-03f, 6.91460744e-02f,
  2.06077009e-01f, 6.48887381e-02f, -2.59367406e-01f, 3.73580456e-02f, -1.70695186e-02f, 1.64035529e-01f, -3.93690392e-02f, -1.24380775e-01f, -1.01266205e-01f, -1.36887446e-01f,
  -2.20127791e-01f, 1.22224890e-01f, 6.06451258e-02f, 2.19941258e-01f, 2.30859861e-01f, 1.05241279e-03f, 1.78207070e-01f, -5.04803509e-02f, -1.25266463e-01f, 1.18179992e-01f,
  -3.55593562e-02f, 8.92339647e-02f, 3.67097892e-02f, 6.43823296e-02f, -4.56040092e-02f, -6.01689331e-02f, -1.71891361e-01f, 1.12575769e-01f, 3.36302668e-02f, 1.28374174e-01f,
  -5.14561236e-02f, -1.36937112e-01f, 1.87562108e-01f, -1.61335021e-01f, 6.73972070e-02f, 2.69604951e-01f, -1.88074738e-01f, 1.65588751e-01f, 1.67087480e-01f, 1.34290412e-01f,
  2.98391759e-01f, -1.60125405e-01f, 1.62099659e-01f, -1.33716866e-01f, 3.12709473e-02f, 2.37760842e-01f, 8.72811154e-02f, 7.58677647e-02f, -6.03450090e-02f, -1.66302603e-02f,
  -1.24005854e-01f, -5.61287394e-03f, 1.64975166e-01f, 1.58271030e-01f, 7.40229040e-02f, 8.78101587e-02f, -6.65024668e-02f, 8.08789432e-02f, 5.15690595e-02f, -8.37292671e-02f,
  2.48933583e-01f, -1.63542017e-01f, 1.06159091e-01f, -2.98128366e-01f, -4.03380692e-02f, 1.05133103e-02f, 1.98356271e-01f, -1.16117820e-01f, 1.75734609e-01f, -1.33585438e-01f,
  2.03183532e-01f, 2.91247785e-01f, 2.74469793e-01f, -4.78441343e-02f, 1.78315356e-01f, -4.07047421e-02f, 2.33109817e-01f, 3.53298616e-03f, -1.32312626e-01f, 1.04464829e-01f,
  -1.36373192e-02f, -3.58392186e-02f, 1.10464826e-01f, -1.35756209e-01f, 1.64917290e-01f, 7.22946739e-03f, 3.93860973e-02f, 6.85872138e-02f, 1.73141044e-02f, -1.84934512e-01f,
  -4.44349796e-02f, -1.79856017e-01f, -1.50128424e-01f, -3.06830853e-02f, 2.36369744e-01f, 3.40394616e-01f, 1.09190807e-01f, 3.05111259e-01f, 9.22429934e-02f, -8.30557197e-02f,
  3.21083724e-01f, -1.64990321e-01f, -1.04378082e-01f, 1.38240620e-01f, -1.48468614e-01f, 1.21356405e-01f, -2.63876598e-02f, -1.86197937e-01f, -9.50039178e-02f, 1.44683868e-01f,
  -1.07308216e-01f, -3.33463699e-02f, 7.52536580e-02f, 1.60047442e-01f, -1.26718193e-01f, 1.09564960e-01f, 1.10665979e-02f, -2.85336170e-02f, -2.87193190e-02f, 1.41261611e-02f,
  1.24769613e-01f, -2.49645486e-02f, 2.23804072e-01f, -7.19383657e-02f, 1.60608396e-01f, 1.85009107e-01f, 9.69613940e-02f, -1.60569221e-01f, 7.25517273e-02f, -4.37115319e-02f,
  9.76973623e-02f, 1.44939676e-01f, 1.74328521e-01f, 7.77370706e-02f, 2.25357786e-02f, 3.21032614e-01f, 2.06665859e-01f, -6.65897802e-02f, 1.31463021e-01f, -5.92759922e-02f,
  3.18865299e-01f, 2.13792652e-01f, -1.24715686e-01f, 8.22772011e-02f, 8.97502229e-02f, 1.42305106e-01f, -1.53273884e-02f, -1.87485084e-01f, 1.56178832e-01f, 2.65417085e-03f,
  -6.83553368e-02f, 1.31931007e-01f, 7.30545307e-03f, -5.21753728e-03f, -6.18788712e-02f, -7.67337903e-02f, 1.93420008e-01f, -5.73888309e-02f, 2.16921762e-01f, 2.57315606e-01f,
  1.10132119e-03f, 2.97499627e-01f, -9.02782567e-03f, 1.17748253e-01f, 2.41471633e-01f, -2.28411287e-01f, -4.49369662e-02f, 1.35247737e-01f, 1.52371349e-02f, 1.87679365e-01f,
  1.93604186e-01f, -1.01529032e-01f, -2.32176229e-01f, 3.00652802e-01f, -6.35058880e-02f, -1.99542627e-01f, -3.37592065e-02f, 2.76478343e-02f, 7.75242522e-02f, -1.89060532e-02f,
  1.66788056e-01f, -9.40555558e-02f, -9.72824991e-02f, 7.09909722e-02f, 3.42701981e-03f, 2.11985558e-02f, -2.94366568e-01f, -1.95100054e-01f, -1.33071363e-01f, -9.37043056e-02f,
  -2.66970724e-01f, 1.53744653e-01f, -3.68538611e-02f, 2.50397861e-01f, -1.73187047e-01f, 1.57396048e-01f, -1.46106705e-01f, -1.86233789e-01f, -7.92415217e-02f, -1.67531639e-01f,
  -1.08739451e-01f, 1.05717629e-01f, 7.05798343e-02f, 1.52674608e-03f, -2.29549393e-01f, 9.60639641e-02f, 1.60076335e-01f, 1.86682209e-01f, -1.37256786e-01f, 1.71267778e-01f,
  -8.33753124e-03f, 1.41501084e-01f, 1.07979693e-01f, -1.44771993e-01f, 2.68941075e-01f, 1.33947209e-01f, 2.61135131e-01f, 1.98428407e-01f, 1.37637168e-01f, 1.59647062e-01f,
  2.89741278e-01f, 1.01226524e-01f, -1.83936372e-01f, 2.52326757e-01f, -1.29440919e-01f, -1.41315848e-01f, 2.13337511e-01f, -5.94495684e-02f, -1.76501572e-01f, 2.83015162e-01f,
  -5.59569299e-02f, -1.49658442e-01f, 8.52617547e-02f, 2.10783392e-01f, 1.48218617e-01f, 3.30633014e-01f, 1.82543129e-01f, -1.30295921e-02f, 1.82123795e-01f, -1.42229861e-02f,
  4.96968180e-02f, 1.66234210e-01f, 2.12325007e-01f, -9.77287740e-02f, -1.22108180e-02f, 1.74456879e-01f, 7.24883452e-02f, 2.55270630e-01f, 7.02227429e-02f, 1.58106744e-01f,
  9.13538877e-03f, -1.81002721e-01f, 1.66508228e-01f, -8.70447978e-02f, -4.42336611e-02f, -9.33236927e-02f, -2.09467530e-01f, -9.62719545e-02f, 2.56046861e-01f, -7.69152343e-02f,
  1.96413174e-02f, 8.71613845e-02f, 2.88868189e-01f, 1.36640146e-01f, 1.47559270e-01f, -5.25796674e-02f, 1.35291785e-01f, 2.44284824e-01f, -9.73101929e-02f, 3.00216209e-02f,
  -1.03184462e-01f, 1.09530315e-01f, 8.28176085e-03f, -1.58275142e-01f, 2.29327455e-01f, 7.87564069e-02f, -1.13848194e-01f, -9.29525197e-02f, 2.02746868e-01f, -1.17971793e-01f,
  6.77468209e-03f, -2.95560330e-01f, 3.15117627e-01f, 1.04760334e-01f, -2.23881200e-01f, -1.40499026e-01f, -3.03954016e-02f, 3.50904604e-03f, 4.73264046e-03f, 1.55544072e-01f,
  5.31190597e-02f, -1.30383119e-01f, 2.47389227e-01f, 1.33302122e-01f, 1.37478083e-01f, 7.84804747e-02f, -6.41356334e-02f, 2.88882732e-01f, -1.09448887e-01f, 2.06957087e-01f,
  1.54277965e-01f, -5.60045801e-02f, -1.74960364e-02f, 1.64346427e-01f, 1.18837431e-01f, -2.59057004e-02f, 8.82430822e-02f, -1.36861330e-04f, 5.09503223e-02f, -9.69720036e-02f,
  1.25610113e-01f, -1.40677124e-01f, 1.42509401e-01f, 2.74378713e-02f, -5.21678738e-02f, -1.69764042e-01f, 1.39841154e-01f, -4.61061746e-02f, -4.91689667e-02f, -8.29720050e-02f,
  -9.90981981e-02f, 1.27429843e-01f, 8.23408216e-02f, -2.82910615e-01f, 2.44074687e-01f, -6.03715219e-02f, 1.91299349e-01f, 9.13495645e-02f, 1.34320974e-01f, -1.96669444e-01f,
  -1.41322706e-03f, -7.90258963e-03f, -1.04038090e-01f, -4.01300006e-02f, -1.11366488e-01f, 1.38310134e-01f, -2.84313988e-02f, -1.94331929e-01f, 3.98078375e-02f, -1.45943522e-01f,
  -1.45673230e-01f, 5.46630658e-02f, 2.05831140e-01f, -9.32968929e-02f, 2.68695354e-01f, -1.61171611e-03f, 3.26262444e-01f, -1.00778446e-01f, -4.85566631e-02f, -1.53805703e-01f,
  -9.55076888e-02f, 3.40922512e-02f, -9.94398594e-02f, 1.32140055e-01f, 1.03666395e-01f, -2.50635445e-02f, -1.66135412e-02f, 2.04390198e-01f, 2.18907908e-01f, 5.54486178e-02f,
  1.04913153e-01f, 1.43357947e-01f, 7.77576119e-02f, 1.22720726e-01f, 1.74621612e-01f, -2.58606017e-01f, 6.33200184e-02f, -3.28475684e-02f, -1.13041736e-01f, 1.41874880e-01f,
  1.01495221e-01f, 2.41045537e-03f, -3.73761319e-02f, 1.56468913e-01f, -1.28712118e-01f, -1.09282881e-01f, 5.65629862e-02f, 1.31038979e-01f, 2.63342023e-01f, 2.19665065e-01f,
  -1.75113305e-01f, 6.61801398e-02f, 2.28811428e-01f, 3.93186510e-02f, 2.42892906e-01f, -6.42683282e-02f, -2.85543427e-02f, -8.19417089e-02f, -1.06724642e-01f, -1.51747644e-01f,
  1.58148348e-01f, 8.30626711e-02f, 2.13718593e-01f, -3.66921835e-02f, -3.57485712e-02f, -1.21820219e-01f, 2.95330882e-01f, -1.96232915e-01f, 1.13614999e-01f, -5.49441651e-02f,
  1.75307378e-01f, -2.95114238e-02f, -1.10674851e-01f, 3.03771161e-02f, 2.51051992e-01f, 2.30542809e-01f, 2.82350485e-03f, 9.82402489e-02f, 2.85817180e-02f, 1.31856665e-01f,
  -6.83911294e-02f, -2.06748933e-01f, -1.00011073e-01f, 7.97833130e-02f, 1.44577309e-01f, 1.01755716e-01f, 2.90386975e-01f, -1.53280586e-01f, 3.84590328e-02f, 1.39004827e-01f,
  -6.05043909e-03f, -1.32853702e-01f, 7.97405168e-02f, 1.69734374e-01f, -1.37705943e-02f, -1.61434516e-01f, -6.91209137e-02f, -3.09082747e-01f, 7.86270797e-02f, 8.75267163e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -7.49746244e-03f, -5.62609695e-02f, 1.71708882e-01f, -7.61609152e-02f, 2.00947300e-01f, 1.71152413e-01f, 1.22259147e-01f, 6.25886917e-02f, -7.11762859e-03f, 1.01042725e-01f,
  -2.56080814e-02f, 1.15378417e-01f, 1.78688988e-02f, 9.29154009e-02f, -1.40028158e-02f, 1.23100027e-01f, -3.01475879e-02f, -3.83089064e-03f, 5.00892475e-02f, -5.21449670e-02f,
  1.26785636e-01f, 1.07297443e-01f, -1.27340341e-02f, 4.57832925e-02f, 1.17976718e-01f, 1.44783258e-02f, -2.50968654e-02f, -1.13942251e-02f, 1.28617421e-01f, 5.79932481e-02f,
  1.23669304e-01f, 9.00105387e-02f, -4.58082892e-02f, 2.88509671e-02f, 1.16438463e-01f, 1.71762586e-01f, 4.23476063e-02f, 3.54193114e-02f, 1.50774360e-01f, 1.15547605e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.13839932e-01f, -1.41148061e-01f, 6.47103488e-02f, -7.69523680e-02f, 1.26038507e-01f, -6.57854080e-02f, -1.09090097e-01f, 1.45547807e-01f, -1.07343465e-01f, 1.37393951e-01f,
  6.46727458e-02f, -5.30515201e-02f, 2.36562658e-02f, 1.02278151e-01f, 3.55243348e-02f, 1.97814181e-01f, -4.36474057e-03f, -6.65585995e-02f, 2.15662748e-01f, -1.44592121e-01f,
  -1.48322061e-01f, -5.12641929e-02f, -2.22310439e-01f, -3.20536159e-02f, 1.14886053e-01f, 1.27025560e-01f, -3.70532244e-01f, 1.56936407e-01f, 1.15483478e-01f, 2.08662122e-01f,
  -1.75328836e-01f, -1.25274826e-02f, -1.85234070e-01f, -1.15850717e-01f, -2.21497595e-01f, -1.30835012e-01f, 2.03065425e-01f, 2.34673433e-02f, -1.47826940e-01f, -3.78317907e-02f,
  -8.66895914e-02f, 1.18400067e-01f, -1.58346668e-01f, -1.22962222e-01f, 6.11289851e-02f, -1.49580434e-01f, 1.74708888e-01f, 2.27734953e-01f, -9.99981463e-02f, -4.02067602e-01f,
  -5.64836375e-02f, 5.23366081e-03f, 1.01212882e-01f, -2.17555851e-01f, 1.77224994e-01f, -1.92468926e-01f, -2.77252402e-02f, 1.04965404e-01f, -2.56347686e-01f, -4.19885993e-01f,
  1.81870431e-01f, -5.26322648e-02f, 1.96029365e-01f, -1.66928098e-01f, 3.53638716e-02f, -8.05235207e-02f, 1.46374568e-01f, 2.51628608e-02f, 1.07843928e-01f, -1.01896629e-01f,
  1.63298979e-01f, -1.23739235e-01f, -2.01390058e-01f, -4.88225967e-02f, 1.37092948e-01f, -1.05422527e-01f, 2.46316362e-02f, 6.07949030e-03f, -2.50506569e-02f, 6.66793436e-02f,
  1.52103901e-01f, 6.36674762e-02f, -1.50320396e-01f, -1.16947979e-01f, -1.23585038e-01f, -2.49216314e-02f, 2.53490746e-01f, 1.83943793e-01f, -2.88752496e-01f, 6.08714633e-02f,
  -1.61461681e-01f, -1.74983576e-01f, -1.47401616e-02f, 1.71651483e-01f, 1.93994194e-01f, -1.30082369e-01f, 3.36293853e-03f, -2.27688938e-01f, -7.00333193e-02f, 2.12825581e-01f,
  2.00764537e-01f, -2.22028583e-01f, -2.58109987e-01f, 7.98371509e-02f, -2.55562842e-01f, 7.83800334e-02f, -9.06063467e-02f, 1.31073818e-01f, -2.44353965e-01f, 2.24025488e-01f,
  -9.77797061e-02f, 1.25882611e-01f, -4.25448418e-02f, -1.69774041e-01f, -1.66104570e-01f, 1.29963562e-01f, -1.71797872e-01f, -2.66717494e-01f, -1.90449789e-01f, -2.08133459e-02f,
  1.82170138e-01f, 1.63668245e-01f, -1.16669208e-01f, -2.41847068e-01f, -9.75218415e-02f, -1.05434179e-01f, -1.14232443e-01f, 2.33479187e-01f, -1.16692647e-01f, -1.14410445e-01f,
  4.23723310e-02f, -1.97685156e-02f, 1.23242788e-01f, 1.28950635e-02f, -1.53380454e-01f, 6.24920689e-02f, 3.34262960e-02f, -4.61835936e-02f, -7.01860487e-02f, 5.93947358e-02f,
  -1.41588196e-01f, 5.38941436e-02f, 1.49851009e-01f, -1.30472943e-01f, 5.42395078e-02f, -1.28808573e-01f, 1.00649027e-02f, -2.78498121e-02f, -1.19331494e-01f, -1.46809146e-02f,
  1.46415636e-01f, 1.27699301e-01f, -7.13365301e-02f, -8.92645493e-02f, 1.05580352e-01f, 9.43412781e-02f, -2.59472877e-02f, -3.08153212e-01f, 1.76551700e-01f, -1.21222278e-02f,
  8.07391293e-03f, -2.53341049e-01f, -2.65629798e-01f, 1.58936992e-01f, -5.59616573e-02f, -1.19224809e-01f, 4.44369344e-03f, -1.41719252e-01f, -2.14556098e-01f, -3.35028768e-01f,
  -1.73614714e-02f, 1.96021065e-01f, -3.91382352e-02f, 1.03182465e-01f, -2.56221890e-01f, -2.42156640e-01f, 2.04514742e-01f, 1.53407559e-01f, -1.15418583e-01f, -2.21558541e-01f,
  -2.96575949e-02f, 1.15186483e-01f, -2.17577815e-01f, 1.04867099e-02f, 1.00708589e-01f, -1.81580842e-01f, 1.06327169e-01f, 7.11390078e-02f, -2.40290895e-01f, -1.96611136e-02f,
  -2.36082077e-01f, 6.55707493e-02f, 6.22244226e-03f, 2.34697610e-02f, 1.22054093e-01f, 8.81614685e-02f, -1.32779300e-01f, 5.78764640e-02f, -4.62057581e-03f, -1.13016292e-01f,
  -7.53644630e-02f, -4.48283404e-02f, 6.79137558e-02f, -1.35756591e-02f, 9.23002511e-03f, -6.43442422e-02f, 1.42075881e-01f, 8.08762535e-02f, -3.94117273e-02f, 2.73120373e-01f,
  2.19248533e-01f, 1.17569104e-01f, -3.88423838e-02f, 9.34325010e-02f, -2.52071083e-01f, -1.81737036e-01f, 2.32788607e-01f, -9.89454836e-02f, 1.19351432e-01f, 2.50628144e-01f,
  -2.94113636e-01f, 1.13793433e-01f, -2.62628406e-01f, -3.06528777e-01f, 1.63548350e-01f, 1.49565399e-01f, -8.95487517e-03f, -2.62039453e-01f, -2.79663146e-01f, 2.01960981e-01f,
  1.09197356e-01f, -1.45643756e-01f, 7.65913576e-02f, -2.65796185e-01f, 1.26470268e-01f, -1.22734070e-01f, -1.32518575e-01f, -4.45298553e-02f, -2.04270259e-02f, -2.19282627e-01f,
  -1.94448397e-01f, 3.08297779e-02f, 1.43885523e-01f, -3.43427688e-01f, 1.52006969e-02f, 1.56421646e-01f, 8.52785185e-02f, -1.02032937e-01f, -2.90622354e-01f, -6.15747310e-02f,
  -1.41728938e-01f, -4.26819138e-02f, 2.27766007e-01f, -2.00501159e-01f, 4.04312313e-02f, -2.67691553e-01f, 1.09616049e-01f, -8.81626979e-02f, -5.03267394e-03f, -4.53488417e-02f,
  1.24431662e-01f, 8.96176994e-02f, -5.46109937e-02f, 4.91422154e-02f, 7.78587908e-02f, 1.29757643e-01f, 2.28393991e-02f, 1.82909533e-01f, 1.46155870e-02f, -6.11080900e-02f,
  5.54212593e-02f, 6.96140304e-02f, -1.25099197e-01f, 1.38530806e-01f, 1.28588080e-01f, -1.44304901e-01f, 1.27836186e-02f, 3.82330194e-02f, 5.32175638e-02f, 1.23683400e-01f,
  1.64517507e-01f, -6.31378815e-02f, 1.96443588e-01f, -1.83893487e-01f, 1.02365702e-01f, -3.67901027e-02f, 1.49353212e-02f, 8.74483511e-02f, -5.80981374e-02f, 2.24454507e-01f,
  2.16937810e-02f, 2.67730672e-02f, 7.22746104e-02f, 9.76008698e-02f, -2.82364786e-01f, 1.08839564e-01f, 5.27127534e-02f, 9.41957235e-02f, 1.85618594e-01f, -1.64617255e-01f,
  -4.68113348e-02f, -3.54553640e-01f, -8.56102556e-02f, -9.79842469e-02f, -1.05151244e-01f, -6.21822849e-02f, 2.72607338e-02f, -1.53699771e-01f, 1.73815727e-01f, 2.05446437e-01f,
  2.42208287e-01f, -3.00495058e-01f, -1.74039915e-01f, -6.54499978e-02f, 1.47074580e-01f, -5.38425669e-02f, 4.06944901e-02f, 1.30009010e-01f, 3.02630533e-02f, -1.83469385e-01f,
  1.50055230e-01f, 1.71030164e-02f, 1.80892460e-02f, -1.08710244e-01f, 2.96675395e-02f, -1.13421261e-01f, 8.70318264e-02f, -9.27884430e-02f, 2.19498962e-01f, 1.24532767e-01f,
  -8.61431137e-02f, -1.87448084e-01f, 7.46125430e-02f, 3.15128192e-02f, -1.38483927e-01f, -2.93044467e-03f, 1.76459402e-01f, -1.79884776e-01f, 4.14317884e-02f, -1.70607135e-01f,
  -5.94489239e-02f, -9.34421271e-02f, 3.45665663e-02f, 1.77238405e-01f, 8.92594457e-02f, 2.07333453e-02f, -4.11610186e-01f, -1.94531053e-01f, 1.57256335e-01f, -9.57199708e-02f,
  -5.69505207e-02f, 6.92206621e-02f, -1.41041771e-01f, 4.25767377e-02f, 1.80097029e-01f, -9.82646942e-02f, 1.55234307e-01f, -2.60266900e-01f, -2.42588505e-01f, 2.29418755e-01f,
  1.68237209e-01f, 1.42501354e-01f, 1.81833044e-01f, -2.69041229e-02f, 2.99208015e-01f, -1.05657168e-01f, 1.92173496e-01f, -9.29247297e-04f, -2.59023398e-01f, -2.46326223e-01f,
  5.95118739e-02f, 1.45097524e-01f, -6.73865974e-02f, -2.91171372e-01f, -2.52887547e-01f, -1.11510642e-02f, 7.51844272e-02f, 3.50395241e-03f, -5.80877066e-02f, -7.00955540e-02f,
  -3.11020523e-01f, 2.37694271e-02f, 1.15533493e-01f, 2.61410940e-02f, 1.28633752e-01f, -4.10919599e-02f, 2.01907028e-02f, -1.18054099e-01f, 2.27989759e-02f, -2.80729029e-02f,
  6.38053417e-02f, 6.62842765e-02f, 1.13994353e-01f, -3.92870940e-02f, -2.67922543e-02f, -1.40889034e-01f, 2.06902355e-01f, -6.18387051e-02f, -2.94940770e-01f, 9.13996547e-02f,
  -3.45329009e-02f, -5.80861792e-02f, -1.42652780e-01f, -6.59784898e-02f, 3.82030010e-02f, 1.54899225e-01f, -1.61802739e-01f, -6.51912093e-02f, -8.23176801e-02f, -1.89422101e-01f,
  -3.07256039e-02f, 2.77122725e-02f, 6.68217838e-02f, -3.18292499e-01f, -1.35149747e-01f, 5.27128875e-02f, 1.06161036e-01f, 1.84416130e-01f, 7.60966316e-02f, -7.51373991e-02f,
  -3.24456841e-01f, -9.81272683e-02f, -1.28937215e-01f, 2.13035747e-01f, 6.68279454e-02f, 3.33878174e-02f, -8.69535953e-02f, 5.10327928e-02f, -1.71317607e-01f, 1.65846899e-01f,
  -2.90138632e-01f, -1.19206339e-01f, -2.21253470e-01f, 1.01716526e-01f, -2.54166126e-01f, 7.50712305e-02f, 2.70331409e-02f, -4.66800015e-03f, -2.33466670e-01f, -1.79598749e-01f,
  -2.46826280e-02f, -2.42718548e-01f, 2.18706086e-01f, 2.18246832e-01f, -1.09136224e-01f, -1.00808010e-01f, -7.26746842e-02f, 1.34441495e-01f, -6.07278496e-02f, 9.73775983e-02f,
  -5.29031493e-02f, 9.02816877e-02f, -1.62147716e-01f, 9.68011394e-02f, 7.96935111e-02f, -1.58188716e-01f, 8.02107453e-02f, -7.62361884e-02f, -5.50882295e-02f, 5.51638268e-02f,
  -9.28481296e-02f, -1.24268502e-01f, 1.17700949e-01f, -2.47336462e-01f, 1.05676893e-02f, 3.32748368e-02f, 5.36531545e-02f, -1.40240341e-01f, 8.97801146e-02f, -2.34191939e-01f,
  2.09299609e-01f, -8.10631141e-02f, 1.59207787e-02f, -6.61949366e-02f, 1.24667287e-01f, 2.70757705e-01f, 1.64678693e-02f, -2.00578883e-01f, -1.74974814e-01f, -1.62736863e-01f,
  -9.15622935e-02f, -1.33868471e-01f, -4.98867035e-02f, 7.31932074e-02f, -1.19890809e-01f, 1.26886100e-01f, 8.80595576e-03f, -1.99685708e-01f, -2.09397450e-01f, -2.01525450e-01f,
  -1.77235201e-01f, -8.84098783e-02f, -3.24387215e-02f, 1.77505627e-01f, -2.14385584e-01f, 1.53625473e-01f, 1.97158903e-01f, -4.36301753e-02f, -2.29929835e-01f, -1.97447821e-01f,
  6.55677915e-02f, 2.04031512e-01f, 1.76523194e-01f, -1.60613880e-01f, -1.51750922e-01f, -7.31723234e-02f, -1.15293026e-01f, -2.82841116e-01f, 1.93177789e-01f, 1.38338566e-01f,
  1.62518471e-01f, -1.66425556e-01f, -1.72852471e-01f, -7.06724301e-02f, 5.49348183e-02f, -1.08565271e-01f, 9.98545513e-02f, 3.05630974e-02f, -1.34411082e-01f, -1.37070522e-01f,
  2.88109723e-02f, 8.45187977e-02f, 1.28718808e-01f, -3.69111486e-02f, 1.65129989e-01f, 7.89903924e-02f, -2.56573051e-01f, -2.06799805e-01f, -2.52641171e-01f, -1.24526732e-01f,
  -1.12886414e-01f, 6.98221028e-02f, 1.09184660e-01f, -2.68251002e-01f, -4.77801263e-03f, -1.41911134e-01f, -8.23640451e-02f, 1.15242518e-01f, -3.07711028e-02f, -6.08085766e-02f,
  -1.64572716e-01f, 1.68225944e-01f, 1.60853148e-01f, -1.48091286e-01f, 1.38041705e-01f, -2.32744709e-01f, -1.27908111e-01f, 1.82703331e-01f, -1.16294384e-01f, -1.98736206e-01f,
  1.93268895e-01f, -1.25695825e-01f, -1.80948243e-01f, -5.10596484e-02f, -1.25350460e-01f, -2.26854473e-01f, 8.13348740e-02f, -2.41737708e-01f, -1.37571404e-02f, -4.22463678e-02f,
  -3.11097242e-02f, 1.16412841e-01f, 1.95808783e-01f, -4.67350818e-02f, -2.49812052e-01f, -1.03811100e-01f, 2.71812920e-02f, 2.02989742e-01f, 2.22713888e-01f, 2.30490893e-01f,
  -3.68995517e-01f, -8.61740634e-02f, 1.58103168e-01f, -2.18134522e-01f, -2.38501534e-01f, -9.15243700e-02f, -1.20360158e-01f, 6.66276142e-02f, -3.51371393e-02f, 7.81769156e-02f,
  6.25869771e-03f, -1.54531822e-01f, 4.85385545e-02f, 9.97248814e-02f, -1.02922104e-01f, -8.24821815e-02f, 1.55059800e-01f, -2.46407744e-02f, -1.13265119e-01f, 1.14230126e-01f,
  5.57439327e-02f, 8.48836899e-02f, 2.49916241e-02f, -1.13594189e-01f, 4.78903912e-02f, 3.73112201e-03f, -1.84695661e-01f, 1.30031645e-01f, 2.12256193e-01f, 1.96111649e-01f,
  -3.68969254e-02f, -3.51734936e-01f, 5.43197209e-04f, -2.02587694e-01f, 1.34634227e-01f, -2.30727807e-01f, -5.87348826e-02f, 1.36092186e-01f, -3.37153792e-01f, -2.62903184e-01f,
  1.85535818e-01f, -1.90461904e-01f, -1.70370534e-01f, -2.70231813e-01f, -1.04277074e-01f, -1.95276961e-01f, -5.21101803e-02f, -1.92032725e-01f, -6.43772818e-03f, 1.09431028e-01f,
  -1.87407494e-01f, -1.71852503e-02f, 3.43671106e-02f, 1.71284333e-01f, 1.34764910e-01f, -1.93254560e-01f, -1.30040757e-02f, -1.08063661e-01f, 1.78137869e-01f, 6.47738352e-02f,
  -1.59035265e-01f, -1.28031343e-01f, -3.09648126e-01f, -5.89169189e-02f, 2.41705537e-01f, 1.27764151e-01f, -2.27427930e-01f, 9.37774852e-02f, 2.38430008e-01f, -9.72488448e-02f,
  3.52707990e-02f, -1.13768116e-01f, -7.80830681e-02f, 1.64998174e-01f, -6.58824369e-02f, 9.65813920e-02f, -4.78131920e-02f, 1.20167397e-02f, 2.55024657e-02f, -1.01302721e-01f,
  5.58062345e-02f, -4.83657755e-02f, 1.28304120e-02f, 3.76176648e-02f, 1.17507592e-01f, 1.18781857e-01f, -7.05722049e-02f, -2.12674990e-01f, -2.30229288e-01f, 2.05052078e-01f,
  -2.58092266e-02f, 2.14941904e-01f, 1.15722977e-01f, 7.32027413e-03f, -1.96869254e-01f, 1.18987389e-01f, 1.99557036e-01f, -3.14743459e-01f, -2.26947278e-01f, -3.23092714e-02f,
  4.85265628e-02f, -1.47586301e-01f, 1.91827506e-01f, 8.10188279e-02f, -2.12135524e-01f, 1.76614802e-02f, -1.85776472e-01f, 2.42760941e-01f, -1.57133788e-01f, -1.02878414e-01f,
  -2.02009976e-01f, -2.23403439e-01f, -6.82684034e-02f, -2.00883180e-01f, -2.03166753e-01f, -2.91114271e-01f, 7.12340325e-02f, -1.46166116e-01f, 8.89162496e-02f, 1.98344082e-01f,
  2.90205628e-02f, -2.75435477e-01f, 1.36923060e-01f, 3.69201042e-02f, -1.90945342e-01f, 1.39388740e-01f, -2.51186620e-02f, -2.00433239e-01f, 9.32959095e-03f, 4.63942476e-02f,
  1.87045187e-01f, -5.26403971e-02f, -1.21893778e-01f, -6.51107430e-02f, -1.87842473e-01f, 4.45747115e-02f, -2.82411203e-02f, 5.56143038e-02f, -5.79389073e-02f, 9.19288695e-02f,
  -7.17143044e-02f, -1.94160882e-02f, 7.74489390e-03f, -2.73559224e-02f, 1.45358015e-02f, -8.51522982e-02f, 2.74675041e-02f, -2.51997225e-02f, -1.95408061e-01f, 3.45187411e-02f,
  -2.19366476e-01f, 7.46116191e-02f, 1.76859021e-01f, 7.71875829e-02f, 1.67510539e-01f, 7.90221989e-02f, -1.16365455e-01f, 1.46631720e-02f, 1.51329920e-01f, 5.34865968e-02f,
  7.98676815e-03f, 3.23844030e-02f, -1.27646536e-01f, 1.26028240e-01f, -1.52221590e-01f, 8.41836631e-02f, 1.43671975e-01f, 1.98577046e-01f, -1.53912857e-01f, -1.30769297e-01f,
  -5.50354645e-02f, -6.23202808e-02f, 2.07020372e-01f, 3.90316024e-02f, 1.89306647e-01f, 1.98299810e-02f, 1.02712534e-01f, -2.28754193e-01f, 2.27220640e-01f, -1.91985086e-01f,
  -3.95949138e-03f, -2.82577664e-01f, -6.46861047e-02f, -2.53718589e-02f, 1.34203181e-01f, -4.50808816e-02f, -2.38638461e-01f, -1.72279581e-01f, 4.58192863e-02f, 1.30067497e-01f,
  -1.36734620e-01f, 1.33534595e-01f, 4.95856954e-03f, 1.93898037e-01f, -1.15539476e-01f, -3.10015798e-01f, -1.24849312e-01f, -6.12427071e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.14528702e-02f, -1.03623092e-01f, 7.43078589e-02f, -4.26417217e-03f, -7.05656223e-03f, -6.76883385e-02f, 2.99706124e-03f, 3.89388390e-02f, 1.78844552e-03f, 3.44546996e-02f,
  -7.97223300e-02f, 4.70672996e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    