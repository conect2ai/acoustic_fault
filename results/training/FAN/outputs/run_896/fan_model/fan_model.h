/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.40383583e-01f, -3.29087190e-02f, 9.81887653e-02f, 4.20804203e-01f, 3.56751829e-01f, 1.08067155e-01f, 9.71975923e-02f, -4.71110195e-02f, 1.68115273e-01f, 1.70494527e-01f,
  3.14685144e-02f, 3.18652578e-03f, -2.88266456e-03f, -1.21618267e-02f, -9.69807655e-02f, 8.25713649e-02f, 2.09780753e-01f, 4.88542095e-02f, 3.95625643e-02f, 6.59441808e-03f,
  4.91916947e-02f, 1.67666718e-01f, 1.80725485e-01f, 2.69674119e-02f, 1.28298074e-01f, 6.93465322e-02f, 2.07730848e-02f, 4.06641588e-02f, -1.25271156e-01f, 1.33840457e-01f,
  -6.41387329e-02f, -1.47040077e-02f, 1.53824687e-02f, 7.79033750e-02f, 4.90517952e-02f, 5.82942404e-02f, 7.26226419e-02f, -1.36100287e-02f, -8.22765380e-02f, -3.01436689e-02f,
  -3.11378445e-02f, 3.49634029e-02f, -1.88365616e-02f, -2.16436200e-02f, 7.84604400e-02f, -1.54848932e-03f, 2.22484097e-02f, -4.42351475e-02f, 1.99816213e-03f, -3.13663706e-02f,
  2.49903798e-02f, -1.41845569e-02f, -1.17805511e-01f, -6.88822791e-02f, -1.07005104e-01f, -8.31743628e-02f, -1.43785015e-01f, -4.72788475e-02f, -1.34057537e-01f, -7.91557413e-03f,
  -3.85945030e-02f, -7.18758404e-02f, 3.19623537e-02f, 8.74046236e-03f, -4.69574630e-02f, 2.27851085e-02f, -4.99228090e-02f, 1.94860175e-02f, 4.09595184e-02f, 5.92775084e-02f,
  9.77593008e-03f, 2.49139071e-02f, 1.51054515e-02f, 3.27795162e-03f, 3.10129523e-02f, 1.26878589e-01f, 6.69831131e-03f, 2.58716252e-02f, -1.09527275e-01f, 1.89674757e-02f,
  -1.99452788e-02f, 1.47487279e-02f, -5.93134854e-03f, -1.23925701e-01f, 5.78092672e-02f, 7.99773354e-03f, 1.03818933e-02f, -3.30004320e-02f, 2.77952012e-02f, 2.93028541e-02f,
  2.17539328e-03f, 5.10498695e-02f, 8.78029168e-02f, -6.24788925e-02f, -2.81961299e-02f, -1.20066749e-02f, 1.07401103e-01f, -1.63627759e-01f, 4.05324250e-02f, 1.29697295e-02f,
  -2.36518867e-02f, 9.25335009e-03f, -1.81417596e-02f, -1.60661489e-02f, -3.57298963e-02f, 5.77458739e-02f, 1.76761020e-02f, -1.45616028e-02f, -5.18597662e-02f, -1.10714100e-01f,
  -3.05625740e-02f, 7.14580491e-02f, -1.31295705e-02f, -5.33887856e-02f, -7.45323999e-03f, 1.04826540e-01f, -1.70999542e-01f, -3.97093818e-02f, -9.89125445e-02f, 1.81565550e-03f,
  1.19471624e-01f, 2.19678432e-01f, 3.83357443e-02f, 1.32915005e-01f, 7.67706111e-02f, 9.13809985e-03f, 1.02540649e-01f, -7.11809099e-02f, 5.74148856e-02f, 9.53324661e-02f,
  7.34647885e-02f, -1.17101036e-01f, -8.80156830e-02f, -4.24415022e-02f, -1.00629918e-01f, -8.07722379e-03f, -5.32235354e-02f, -1.37304723e-01f, -1.53663948e-01f, -1.91750005e-01f,
  4.09740917e-02f, 2.93459259e-02f, -4.97267507e-02f, -1.17086060e-01f, 1.31585807e-01f, -8.62891898e-02f, 9.34906974e-02f, 7.06811696e-02f, -1.04558107e-03f, -3.26177701e-02f,
  -2.09612232e-02f, 1.38237134e-01f, -4.90099974e-02f, 5.46393804e-02f, 2.88655274e-02f, 3.40968673e-03f, -2.59951577e-02f, -1.80628970e-02f, 9.56730079e-03f, -6.67120218e-02f,
  6.96060285e-02f, -7.41890520e-02f, 6.47523031e-02f, -3.65555063e-02f, 3.90844345e-02f, 6.66752160e-02f, -2.56247204e-02f, 4.82301740e-03f, 1.89340524e-02f, 1.23704202e-03f,
  4.51229773e-02f, 7.80954435e-02f, -9.38549358e-03f, 5.87366819e-02f, -8.13883170e-02f, -1.12661356e-02f, -5.86926192e-02f, -4.85222116e-02f, -1.35516375e-01f, -2.03706697e-02f,
  -4.93350327e-02f, -2.82598957e-02f, 1.16714612e-02f, 1.74940508e-02f, -4.61151041e-02f, -3.59956883e-02f, -2.08843965e-02f, -5.02384901e-02f, -6.53978735e-02f, 4.46443334e-02f,
  -5.54413050e-02f, 4.63814065e-02f, 4.57580723e-02f, -3.66121270e-02f, -4.94391806e-02f, 9.56595410e-03f, 5.86828403e-03f, -6.18252046e-02f, -9.47613195e-02f, 6.24297298e-02f,
  3.99681516e-02f, -8.98753759e-03f, 9.59615186e-02f, 4.81807888e-02f, 5.71390726e-02f, -3.62149416e-03f, -2.16206368e-02f, 3.50540206e-02f, -3.14079449e-02f, 1.93638857e-02f,
  9.06718969e-02f, -2.49382500e-02f, 1.95128229e-02f, -5.50495870e-02f, -5.05991019e-02f, 4.88052666e-02f, 5.82310520e-02f, 3.65230218e-02f, 1.99426175e-03f, 1.19136982e-02f,
  1.08727813e-02f, 7.84855336e-02f, -2.70593576e-02f, -2.88369739e-03f, -5.28211780e-02f, -6.13862611e-02f, 7.49525940e-03f, -4.74448726e-02f, -4.33368683e-02f, 2.88108941e-02f,
  7.88453966e-02f, 4.62288260e-02f, -2.57467832e-02f, -6.81159436e-05f, 5.27467243e-02f, -5.38141541e-02f, -6.30619302e-02f, -2.13532448e-02f, -9.30599570e-02f, 4.63230796e-02f,
  -1.36573881e-01f, 2.24576462e-02f, 3.93334746e-01f, 3.62503366e-03f, 9.64932740e-02f, -5.55969067e-02f, -1.80828214e-01f, -2.62552351e-02f, -1.33595720e-01f, 5.82528710e-02f,
  1.51720941e-01f, 3.20942365e-02f, -5.04446216e-02f, -3.24880704e-02f, -1.10289827e-02f, -1.40150160e-01f, -4.49659452e-02f, 9.53327268e-02f, -9.76533666e-02f, -3.29307131e-02f,
  -1.65274039e-01f, 6.12257421e-02f, 1.36974780e-02f, 9.14008692e-02f, 4.19574976e-02f, -1.64295226e-01f, 3.65827382e-02f, 1.22929767e-01f, 9.06007513e-02f, 1.33935407e-01f,
  1.73926145e-01f, 2.92743862e-01f, -1.04595304e-01f, -4.61805053e-03f, 1.43290505e-01f, 1.07640522e-02f, 5.31618930e-02f, 1.05680086e-01f, -4.70736623e-02f, 5.81968129e-02f,
  7.68839046e-02f, 4.07876447e-02f, 3.79725471e-02f, 5.70494272e-02f, 4.74650003e-02f, 5.46935983e-02f, 8.24076608e-02f, 6.21608235e-02f, 9.76777747e-02f, 5.44603169e-02f,
  1.17435165e-01f, 1.28571853e-01f, 9.21308100e-02f, 1.05873264e-01f, 1.48170218e-02f, 1.40227200e-02f, 3.78383808e-02f, 1.69868678e-01f, 4.42784168e-02f, -1.03244312e-01f,
  -8.38732943e-02f, 4.66049500e-02f, 3.71248871e-02f, 8.41676738e-05f, -1.87041640e-01f, 3.08069028e-02f, 1.74672641e-02f, -2.38460377e-02f, -8.84177716e-05f, 3.75787378e-03f,
  -1.18429959e-02f, -2.11400297e-02f, 2.06064545e-02f, 5.14430813e-02f, -4.75124270e-02f, 1.15667924e-01f, -3.79561889e-03f, -5.72074503e-02f, 8.90380740e-02f, -1.12186089e-01f,
  2.26756018e-02f, 6.41273037e-02f, 8.34942888e-03f, 5.79981226e-03f, 9.59378481e-02f, 8.20699036e-02f, -2.05308516e-02f, -8.56454112e-03f, 3.66191417e-02f, 1.02614332e-03f,
  -2.65985787e-01f, 1.88069642e-01f, -1.91978067e-01f, -1.14846043e-01f, -3.48938331e-02f, -2.80028116e-02f, -1.09323272e-02f, -1.59423966e-02f, 1.03966638e-01f, -4.21076342e-02f,
  3.07096187e-02f, -5.70594557e-02f, 2.46486031e-02f, -2.22716425e-02f, -1.37380347e-01f, -4.03429046e-02f, -1.53451055e-01f, -1.36467829e-01f, -2.38565113e-02f, -1.43872462e-02f,
  -1.27849907e-01f, -1.52726680e-01f, -3.61756831e-01f, -1.92797139e-01f, -7.25227743e-02f, -2.37993568e-01f, -1.53879166e-01f, -1.52611658e-01f, -2.27998599e-01f, -5.87811410e-01f,
  -2.07016736e-01f, 9.66800973e-02f, 2.08937258e-01f, -5.99767417e-02f, 2.49782249e-01f, 4.26304579e-01f, 4.53434259e-01f, 4.33855057e-02f, -8.36416706e-02f, 1.09793589e-01f,
  2.28345506e-02f, -1.04441524e-01f, -5.71457632e-02f, -7.29799643e-02f, -2.66818739e-02f, 1.97971031e-01f, 6.23233579e-02f, -9.18635130e-02f, 2.13081464e-02f, 1.61414474e-01f,
  1.10319287e-01f, -8.93225670e-02f, -1.06826484e-01f, -7.67485201e-02f, 2.07806863e-02f, -2.33335458e-02f, 2.43380386e-02f, -4.93449997e-03f, 8.19195434e-02f, 2.07552519e-02f,
  3.26859593e-01f, 9.76744667e-02f, -2.49807704e-02f, -1.54841542e-01f, 1.85092725e-02f, -1.29772844e-02f, -1.53629333e-02f, -8.51086751e-02f, -8.79828036e-02f, 7.06222490e-04f,
  -5.88811897e-02f, -1.11823291e-01f, 4.47580069e-02f, 1.02098065e-03f, 3.62152904e-02f, 9.71589703e-03f, -8.30496997e-02f, -5.67511432e-02f, -2.93706395e-02f, 3.73819061e-02f,
  5.13100773e-02f, 8.04948211e-02f, 1.03727609e-01f, -4.74238675e-03f, -2.19766572e-02f, -2.05622241e-02f, 8.08644444e-02f, -7.40922093e-02f, 2.72404663e-02f, -8.66120234e-02f,
  -4.05465113e-03f, 5.03351055e-02f, 7.33670965e-02f, -3.23464139e-03f, -4.40083928e-02f, 2.81877723e-02f, -5.86242648e-03f, -4.81014699e-02f, 6.06777593e-02f, 2.75292788e-02f,
  -5.48817553e-02f, 4.27269191e-02f, 5.24716265e-02f, -6.99471608e-02f, 2.83811335e-02f, 3.82563621e-02f, 5.96213862e-02f, -3.26869264e-02f, -6.13949560e-02f, -1.07730627e-01f,
  -8.68790038e-03f, 9.84343514e-03f, 4.07437608e-03f, 6.65236115e-02f, -2.10882351e-02f, -2.20837742e-02f, 8.34117979e-02f, 2.06024013e-02f, -1.02772005e-02f, -3.28499824e-02f,
  -2.33814605e-02f, -1.20728754e-03f, -7.38127008e-02f, -1.24745376e-01f, 1.04595006e-01f, -7.34025463e-02f, 3.56736816e-02f, -9.13752466e-02f, 2.86709908e-02f, -7.51770567e-03f,
  1.05844833e-01f, 7.59834275e-02f, -2.03886814e-02f, 5.63722290e-02f, 2.69745253e-02f, 3.38253826e-02f, 7.84954755e-04f, 4.83525693e-02f, -2.16447562e-02f, -3.97089757e-02f,
  -2.40948629e-02f, -8.97127297e-03f, -5.77444695e-02f, -2.78441329e-02f, 9.85799357e-02f, -1.13707380e-02f, 1.50806695e-01f, -5.06772893e-03f, 1.00453354e-01f, -1.00223698e-01f,
  -1.26645789e-01f, 1.79438934e-01f, -1.19769745e-01f, 1.28054574e-01f, -4.97237034e-02f, 1.00273816e-02f, 4.71937731e-02f, 9.89789963e-02f, 6.33050203e-02f, 1.39860706e-02f,
  6.72149062e-02f, -6.16359748e-02f, -1.35053977e-01f, -7.17530400e-02f, -1.16844766e-01f, -1.07518725e-01f, -1.57559156e-01f, -1.92790359e-01f, -2.70569623e-01f, 5.48402639e-03f,
  1.06299289e-01f, 8.84269848e-02f, -4.55673449e-02f, -2.37784162e-02f, 4.88837548e-02f, -1.50653329e-02f, -4.38954383e-02f, -5.95299900e-03f, 6.37469888e-02f, 1.39538214e-01f,
  -2.56365543e-04f, 4.57385406e-02f, -6.22208677e-02f, -1.28886672e-02f, -3.73782851e-02f, -6.67850077e-02f, -2.05669217e-02f, 1.65256485e-02f, 1.96266919e-02f, 3.00141592e-02f,
  -7.00494945e-02f, -3.32321450e-02f, 9.03792493e-03f, -6.22083060e-02f, 2.27600615e-02f, -4.18433733e-03f, 1.34485558e-01f, -1.92641430e-02f, -1.03492327e-02f, 4.51917313e-02f,
  4.70513478e-02f, 7.46651739e-02f, 6.15196638e-02f, -3.99932377e-02f, 3.78570682e-03f, 1.32334151e-03f, 6.75470335e-03f, 2.41663624e-02f, 4.18268740e-02f, 9.36064646e-02f,
  -5.29403053e-03f, 1.47887785e-02f, 1.65135285e-03f, 2.62227971e-02f, -3.63761894e-02f, -6.84206858e-02f, -9.52943577e-04f, -4.84969094e-03f, -1.56733219e-03f, 7.49015361e-02f,
  5.58799729e-02f, 5.51744513e-02f, 2.93575991e-02f, 5.32722985e-03f, -3.78847420e-02f, 1.82560533e-02f, 3.35016125e-03f, 4.78984192e-02f, -2.04799436e-02f, -7.41249695e-02f,
  -6.59546033e-02f, -6.50460944e-02f, 3.76976468e-03f, 4.48847301e-02f, -1.28722461e-02f, -1.89473853e-02f, 6.13674335e-02f, -2.14671958e-02f, -2.47685723e-02f, 3.90458815e-02f,
  8.28022063e-02f, -4.87039387e-02f, 6.13846350e-03f, -1.32114097e-01f, 1.78183373e-02f, 3.26909423e-02f, 6.41582608e-02f, 1.94711071e-02f, -2.78802402e-02f, 3.06397248e-02f,
  -4.29074392e-02f, -1.85163133e-02f, 8.45159516e-02f, 8.86320546e-02f, -1.72916390e-02f, 7.54132941e-02f, 8.12223461e-03f, -4.75474522e-02f, 7.01599270e-02f, 1.69922948e-01f,
  1.07421808e-01f, -5.20552509e-02f, -1.15678802e-01f, -7.66372159e-02f, 4.19826880e-02f, -1.21964023e-01f, -1.62084401e-02f, -6.81231171e-02f, -2.06229851e-01f, -9.43128206e-03f,
  -1.18351109e-01f, -4.12912369e-02f, -2.15143070e-01f, -1.11646429e-01f, -6.10865913e-02f, 2.69116350e-02f, -1.34175375e-01f, -5.78480326e-02f, -1.48701053e-02f, -5.88781647e-02f,
  4.68002111e-02f, 1.14188895e-01f, 8.65954161e-02f, 5.96656017e-02f, 5.99312875e-03f, 6.16395511e-02f, 1.12073027e-01f, -7.86410049e-02f, -4.81096730e-02f, 3.07758767e-02f,
  2.70458609e-02f, -1.64751619e-01f, -2.62616631e-02f, 4.73503955e-03f, -1.89529173e-02f, 3.80202159e-02f, -4.51694988e-02f, 1.71581227e-02f, 6.18277602e-02f, 1.92594025e-02f,
  -2.84050077e-01f, -1.40928715e-01f, 2.42522210e-02f, 7.80095235e-02f, -2.69540567e-02f, -8.96470025e-02f, -7.23464713e-02f, 2.63699777e-02f, 7.48499483e-02f, -1.34370557e-03f,
  -1.09266238e-02f, 1.03474483e-01f, -1.26836840e-02f, -4.76416387e-02f, -7.27883354e-02f, -4.23903912e-02f, 1.83698144e-02f, -2.22559236e-02f, 4.28312533e-02f, -1.91613641e-02f,
  4.86535318e-02f, 8.02512318e-02f, -1.17059685e-01f, -7.82081261e-02f, 6.22541904e-02f, 3.51400748e-02f, 2.00791210e-02f, -4.53316420e-02f, 3.24111953e-02f, -4.68204543e-02f,
  5.53577095e-02f, -4.05996330e-02f, -3.46232690e-02f, -5.65030463e-02f, 3.69241349e-02f, 3.58064547e-02f, -3.38141993e-02f, -3.47125493e-02f, 2.23193280e-02f, -4.59618960e-03f,
  6.00709729e-02f, -8.14223886e-02f, 1.15269525e-02f, -4.52300683e-02f, 4.35032062e-02f, 2.71185301e-02f, 1.47889284e-02f, 4.00433838e-02f, -9.85199306e-03f, 1.18389735e-02f,
  -9.30516236e-03f, 2.51606796e-02f, 3.27358060e-02f, -5.41263819e-03f, 3.47034186e-02f, -1.67163610e-02f, 6.75031915e-02f, 1.62483007e-02f, 4.76583987e-02f, -2.92364450e-04f,
  -1.25553772e-01f, 1.76882342e-01f, -1.40219450e-01f, 3.89635935e-02f, 1.91979669e-02f, 2.44923308e-02f, -4.75554317e-02f, 4.10730392e-02f, -3.89930494e-02f, -9.67761502e-02f,
  -7.64643820e-03f, -2.94230762e-03f, 6.48997352e-02f, 5.59634268e-02f, 9.46504548e-02f, -2.53863744e-02f, 6.57253787e-02f, 7.68480869e-03f, 8.02776888e-02f, -7.11061433e-02f,
  1.98861887e-03f, -1.81974079e-02f, -2.13965885e-02f, -2.72303075e-02f, 1.72050502e-02f, -9.42949485e-03f, -2.65085809e-02f, -3.21783982e-02f, -1.07085608e-01f, -1.24615587e-01f,
  1.55465558e-01f, 1.87468633e-01f, 6.11836724e-02f, -1.37763601e-02f, -1.70932308e-01f, -2.65253671e-02f, 1.87098071e-01f, 6.06337227e-02f, 1.25512481e-02f, 9.16570723e-02f,
  9.89368260e-02f, 6.19857982e-02f, 8.37396905e-02f, 7.43669793e-02f, 2.78294176e-01f, 3.29114348e-01f, 1.54306248e-01f, 1.70503497e-01f, -5.97142652e-02f, -2.36253869e-02f,
  -8.24118480e-02f, -4.02731188e-02f, 1.06841110e-01f, 4.12901230e-02f, -1.67562842e-01f, -1.07937783e-01f, 2.15385072e-02f, -3.01132258e-02f, -2.73554176e-02f, -1.08044252e-01f,
  4.49151024e-02f, -5.40335514e-02f, -4.46294929e-04f, 6.54939562e-02f, -3.98923503e-03f, -1.61249470e-02f, -1.60394069e-02f, -4.22102399e-02f, -8.60712677e-02f, 6.33427035e-03f,
  -2.70834584e-02f, -5.37073575e-02f, -1.10280119e-01f, -4.07067575e-02f, -2.52662599e-02f, -1.02982987e-02f, 1.26080096e-01f, 1.19318195e-01f, 9.71851274e-02f, -6.27454370e-03f,
  -8.75595957e-02f, 8.58263671e-02f, 6.83778450e-02f, 4.38863561e-02f, 1.09211236e-01f, 3.25256027e-02f, -6.60272986e-02f, -1.52309105e-01f, -3.92980576e-02f, -3.74533795e-02f,
  8.76787454e-02f, 1.41479718e-02f, -8.55856389e-03f, -1.17397716e-03f, 4.54137698e-02f, -6.07655291e-03f, -7.43650794e-02f, -2.54787481e-03f, 2.61558071e-02f, -1.42279100e-02f,
  2.47988645e-02f, -1.03393653e-02f, 1.95358992e-02f, 5.99935055e-02f, -6.79867296e-03f, -7.29026319e-03f, -6.99207485e-02f, 1.08459532e-01f, 5.73923700e-02f, -3.88985639e-03f,
  1.49871921e-02f, -4.36344966e-02f, 1.49988430e-02f, -1.02947541e-01f, 4.71777357e-02f, 5.39944023e-02f, -4.99854125e-02f, 1.63936093e-02f, 5.56902699e-02f, -4.08249795e-02f,
  4.96235751e-02f, -7.68786808e-03f, 3.93562578e-02f, 9.99419540e-02f, -5.21381907e-02f, 2.96959747e-02f, 3.18620726e-02f, -5.08057512e-02f, -6.25489280e-02f, -4.37159935e-04f,
  1.07166350e-01f, 5.94916269e-02f, -2.50149425e-02f, 1.52193727e-02f, 7.77493260e-05f, 1.64008997e-02f, 1.17844425e-01f, -1.24173053e-01f, 6.83674440e-02f, 2.64010988e-02f,
  1.53121024e-01f, 1.96387470e-01f, 4.57409918e-02f, 1.17993891e-01f, 5.58665358e-02f, 6.60649240e-02f, -1.14203496e-02f, -2.46818643e-03f, 8.49715844e-02f, 2.27552935e-01f,
  -1.39156088e-01f, -2.74571151e-01f, -1.49597406e-01f, -1.56306610e-01f, -1.36372715e-01f, 9.11008269e-02f, 3.14966962e-02f, 7.87076205e-02f, 3.32361981e-02f, -1.16537564e-01f,
  -6.37132525e-02f, 1.22044675e-01f, 3.95166315e-02f, 5.04957810e-02f, 1.29527688e-01f, -1.19933300e-01f, -1.16209991e-01f, -6.82466477e-02f, 1.44216403e-01f, 2.12886199e-01f,
  1.51625872e-02f, -4.17236313e-02f, -6.04788251e-02f, 6.98960945e-02f, -1.44436345e-01f, -7.44720325e-02f, -1.28817171e-01f, -8.17284882e-02f, -1.46867232e-02f, -3.23583275e-01f,
  -2.76167780e-01f, -1.09632693e-01f, 9.78975594e-02f, 5.91716953e-02f, -8.09289590e-02f, 8.86551291e-02f, -4.27526869e-02f, -2.89618950e-02f, 5.45318723e-02f, -8.41885656e-02f,
  -1.13066196e-01f, -2.59514675e-02f, -4.47824076e-02f, -1.19974546e-01f, -5.37699945e-02f, 1.63185596e-02f, 1.76743511e-02f, 1.95539296e-02f, 1.13446124e-01f, 3.41844745e-02f,
  -8.72362256e-02f, -1.89324282e-02f, -1.96256191e-02f, 1.04805917e-01f, 1.31632641e-01f, 2.77051665e-02f, -3.23765352e-03f, 2.08030790e-02f, 3.59937698e-02f, -1.74598932e-01f,
  1.90003775e-02f, 5.53186536e-02f, 6.12422600e-02f, -1.35363790e-03f, 1.80923901e-02f, -1.42499553e-02f, -9.29822847e-02f, -2.65241899e-02f, -2.83162501e-02f, 6.40189648e-02f,
  3.93312164e-02f, 6.67554066e-02f, -1.07392641e-02f, 8.54521319e-02f, -6.53256774e-02f, -1.25951752e-01f, 2.38883719e-02f, 3.19238864e-02f, -5.31269517e-03f, -1.26899667e-02f,
  1.69071518e-05f, 2.91784722e-02f, -8.65851790e-02f, 3.56246568e-02f, 9.67942327e-02f, 4.67321947e-02f, 3.09225991e-02f, 3.20450473e-03f, -2.91944649e-02f, -1.15675688e-01f,
  -6.32980019e-02f, 1.72604606e-01f, -2.20346078e-02f, -2.44966745e-02f, -8.95204768e-02f, -4.43959907e-02f, -6.15555346e-02f, -9.71578881e-02f, -8.89004767e-03f, -3.58153880e-02f,
  6.58171996e-02f, -1.96183324e-02f, -7.30056688e-02f, 6.77645206e-02f, -1.60101708e-02f, -5.56530943e-03f, -5.01004187e-03f, 1.23953223e-02f, -3.59421782e-03f, -8.66156351e-03f,
  4.27474733e-03f, 2.53567528e-02f, 9.21909064e-02f, -1.86771136e-02f, 4.13812473e-02f, 5.74645251e-02f, 3.27161215e-02f, 3.65905873e-02f, 5.19832969e-02f, -2.87092682e-02f,
  -4.40019310e-01f, 1.00187697e-01f, -1.66693330e-01f, -2.55694110e-02f, 1.27268791e-01f, 1.58280089e-01f, 2.35340521e-02f, 1.44647673e-01f, 7.43035460e-03f, -2.16773129e-03f,
  9.42080840e-02f, 1.64362162e-01f, 1.59645438e-01f, 1.11066148e-01f, -7.00675547e-02f, -7.36905783e-02f, -4.03461568e-02f, -1.87292621e-01f, -3.58798318e-02f, 2.47378260e-01f,
  2.22098693e-01f, -6.62115589e-02f, -1.82063237e-01f, -1.39678475e-02f, 5.04875220e-02f, 8.92689154e-02f, 4.62643690e-02f, -4.01948318e-02f, 5.06455870e-03f, 1.39383730e-02f,
  1.35507300e-01f, -7.56660402e-02f, 2.06569899e-02f, -2.37971358e-02f, -1.75289973e-03f, -1.52535707e-01f, -3.94504331e-02f, -5.05523756e-02f, 5.66592673e-03f, -2.20044833e-02f,
  -1.77628789e-02f, -3.96292470e-02f, 4.80539538e-02f, 2.30333041e-02f, -5.40568270e-02f, -7.78433979e-02f, -3.07730716e-02f, -8.82558152e-02f, -1.08481474e-01f, 3.96817625e-02f,
  7.31531233e-02f, -3.96717638e-02f, -8.95725489e-02f, 4.59885821e-02f, -4.20424230e-02f, -6.27480894e-02f, 6.42466918e-02f, 2.56074443e-02f, -4.81294293e-04f, -5.89151829e-02f,
  -5.64905927e-02f, -3.47993374e-02f, 2.13012192e-02f, 2.29072347e-02f, -5.62014207e-02f, 3.11794248e-03f, 3.17249708e-02f, 3.28615457e-02f, -6.00358546e-02f, -8.39679316e-03f,
  9.07223555e-04f, 3.21220942e-02f, 4.86481842e-03f, 1.69724822e-02f, 1.72052998e-02f, -5.41018322e-03f, 8.91060662e-03f, 7.44394735e-02f, -1.83328893e-02f, -2.06852499e-02f,
  4.47090855e-03f, -5.81823401e-02f, -5.16721420e-03f, -5.93530620e-03f, 4.06710841e-02f, -2.18002591e-02f, -1.72643922e-02f, 2.42301039e-02f, 1.90124046e-02f, -3.53774265e-03f,
  1.53021723e-01f, -1.27316013e-01f, -7.90706202e-02f, -2.32747272e-02f, -2.98289545e-02f, -4.21415605e-02f, 8.93455446e-02f, -3.52097116e-02f, 2.47291755e-02f, 6.42646998e-02f,
  1.02687061e-01f, -3.21088061e-02f, -6.42559156e-02f, 3.82414944e-02f, -3.46343704e-02f, 1.08832438e-02f, 1.97527893e-02f, -1.13549218e-01f, 7.51632825e-03f, 1.21469654e-01f,
  -5.68248099e-03f, -6.35221675e-02f, -7.50088394e-02f, -8.03241879e-03f, -3.14922724e-03f, 7.56420940e-03f, 2.19033360e-02f, 6.20532632e-02f, 1.61866471e-02f, -1.86262780e-03f,
  -1.34366214e-01f, 1.82156060e-02f, 7.14854971e-02f, 8.97376835e-02f, -8.40516612e-02f, -2.46980757e-01f, -2.39766479e-01f, -1.88605130e-01f, -2.68665049e-03f, -1.20018706e-01f,
  -3.36015746e-02f, 4.30782214e-02f, -4.16140780e-02f, 3.90951987e-03f, -1.02052435e-01f, 7.80056044e-02f, 8.57674330e-02f, 8.66198316e-02f, -4.26037312e-02f, -8.21793675e-02f,
  1.04711451e-01f, 1.16682932e-01f, 7.89556429e-02f, -2.72752848e-02f, 6.87557533e-02f, 7.26210512e-03f, 9.29052103e-03f, 1.35330036e-01f, -5.29528037e-02f, 4.44653481e-01f,
  1.50771484e-01f, -8.41927901e-02f, -7.43122920e-02f, 6.32425919e-02f, -2.35010386e-02f, 4.73335618e-03f, 2.99125500e-02f, 9.93175730e-02f, 4.80555743e-02f, 1.00068733e-01f,
  -3.87000968e-03f, 3.23481718e-03f, 2.45336965e-02f, 7.76204318e-02f, -9.92735773e-02f, -2.06039734e-02f, 1.25089064e-02f, 4.74363118e-02f, 1.34718651e-02f, 1.42055778e-02f,
  -1.21733472e-02f, 1.05324939e-01f, 2.75388546e-02f, -1.05673812e-01f, -1.17326528e-01f, 4.21239510e-02f, -1.14850856e-01f, -2.27071438e-02f, -1.04227021e-01f, -1.01099955e-02f,
  1.81080513e-02f, 5.20880744e-02f, 3.24826501e-02f, -4.71664555e-02f, 6.03141114e-02f, -2.20828913e-02f, -2.11691372e-02f, -5.02729230e-02f, 3.54559757e-02f, -8.31258968e-02f,
  -2.24602744e-02f, 8.39357004e-02f, -9.46410671e-02f, -2.62832958e-02f, -8.80194977e-02f, -5.33127002e-02f, 3.85942832e-02f, 2.47239284e-02f, 5.03028259e-02f, 2.83014588e-02f,
  4.66414727e-02f, -1.80326942e-02f, 6.69518113e-02f, 2.40198411e-02f, 2.07922123e-02f, -2.69921939e-03f, 3.99962924e-02f, 7.23649422e-03f, -9.66742411e-02f, -4.81029674e-02f,
  -1.87423319e-01f, -1.70387536e-01f, 1.20171912e-01f, 1.96654368e-02f, 1.05889412e-02f, 7.69855315e-03f, 5.91348596e-02f, -1.83396619e-02f, 5.74109592e-02f, -7.28333145e-02f,
  -7.99743608e-02f, -3.69506963e-02f, 2.11373568e-02f, 2.98166648e-02f, -4.29131277e-02f, 3.32156150e-03f, 2.37109475e-02f, 8.47740844e-03f, -1.10359695e-02f, 8.28079041e-03f,
  5.03080850e-03f, -2.27254760e-02f, -7.65657201e-02f, -9.31771398e-02f, -7.00742472e-03f, -8.56018718e-03f, -6.78261817e-02f, -1.03719860e-01f, -2.03953817e-01f, -1.96317703e-01f,
  -2.03633308e-01f, -1.03058554e-01f, -7.68469367e-03f, -1.18211016e-01f, 8.57769176e-02f, 1.10465206e-01f, 6.64753094e-02f, 5.67248985e-02f, 6.68370202e-02f, -1.06370002e-01f,
  -3.94186787e-02f, 1.30585030e-01f, -7.80905923e-03f, 7.16773048e-02f, 8.68029073e-02f, 3.04784179e-02f, -1.42249599e-01f, 8.59329477e-02f, 2.48277977e-01f, 9.88701805e-02f,
  3.56528386e-02f, -1.56782582e-01f, -1.29087105e-01f, 6.09044917e-02f, -1.33152097e-01f, 5.44946305e-02f, -1.26320690e-01f, -2.15887040e-01f, 2.98664793e-02f, -2.35596359e-01f,
  -2.14258462e-01f, -1.54794022e-01f, 1.03027672e-01f, -5.28893583e-02f, -1.52168393e-01f, 8.56607035e-02f, 3.13332602e-02f, -1.42560333e-01f, -1.19956350e-03f, 5.78925535e-02f,
  -3.34499143e-02f, -5.21773621e-02f, 4.16344777e-02f, 1.49873638e-04f, -1.02086902e-01f, -8.56856406e-02f, -4.99507040e-02f, 2.57091429e-02f, 6.65390771e-03f, -6.92587867e-02f,
  -1.11562666e-02f, -6.26071244e-02f, -1.33060306e-01f, -9.13736746e-02f, -1.97668280e-02f, -1.41290892e-02f, -1.06822275e-01f, -1.10922508e-01f, -3.70256640e-02f, -1.97894797e-01f,
  9.62562636e-02f, 8.46544374e-03f, -8.86486620e-02f, -5.14615923e-02f, -8.06001946e-04f, 2.32109558e-02f, -8.14344212e-02f, -4.52546328e-02f, 6.22981042e-02f, -2.03270726e-02f,
  4.38389778e-02f, 3.64852026e-02f, -4.59017232e-02f, -2.80849002e-02f, -3.16766649e-02f, -1.01622120e-01f, 6.77712960e-03f, -2.59461086e-02f, -2.73406953e-02f, -1.88322440e-02f,
  4.05337922e-02f, 4.39614803e-03f, 4.96964855e-03f, 3.16978805e-02f, -3.53003629e-02f, -2.49205325e-02f, 9.99505967e-02f, 8.77626911e-02f, -1.59698296e-02f, 7.80463964e-02f,
  5.14538996e-02f, 5.53078204e-02f, 1.83313880e-02f, -1.15344804e-02f, 2.20254622e-02f, 3.81477214e-02f, 2.69464012e-02f, 9.75157786e-03f, 1.21389460e-02f, 6.29161224e-02f,
  7.21760914e-02f, 5.13250679e-02f, 1.17610358e-01f, 1.47579210e-02f, 8.24645683e-02f, 2.41225790e-02f, 6.64014462e-03f, 2.18296498e-02f, 4.98521291e-02f, -4.89848480e-02f,
  9.86462235e-02f, 2.43626325e-03f, 1.06152020e-01f, 2.05455590e-02f, -2.06292514e-02f, 7.40882531e-02f, -5.19804321e-02f, 4.68706675e-02f, -1.67917293e-02f, 1.85493026e-02f,
  1.86432362e-01f, 2.56396055e-01f, -7.04156980e-02f, 8.64503533e-02f, -1.61887348e-01f, -1.70490414e-01f, 3.20073850e-02f, -6.19382523e-02f, 1.54160574e-01f, 1.68191493e-01f,
  -8.81134812e-03f, -2.73573287e-02f, -1.20890625e-01f, -1.61347091e-01f, -1.25448823e-01f, 7.92065784e-02f, 2.71186344e-02f, -1.09704345e-01f, -4.36089516e-01f, -7.48434439e-02f,
  5.11239767e-02f, 1.06739625e-01f, 1.94111347e-01f, -2.78633321e-03f, 1.45773485e-01f, -9.31146666e-02f, 8.69890004e-02f, 2.53763348e-01f, -5.45223318e-02f, 2.99664229e-01f,
  5.97079322e-02f, 1.41462803e-01f, -9.56699252e-02f, -1.25329308e-02f, -4.46168333e-03f, 7.63842762e-02f, -6.22204766e-02f, -3.60881090e-02f, 7.65977288e-03f, 4.82969359e-02f,
  1.10859200e-02f, -7.01827835e-03f, 5.45812286e-02f, -4.12116684e-02f, 8.18318948e-02f, -4.00642864e-03f, 5.79777360e-02f, 6.41761944e-02f, 6.05548844e-02f, 3.18100490e-02f,
  -1.66154653e-02f, 7.69851636e-03f, 3.91038246e-02f, 3.89515124e-02f, 4.96502966e-04f, -3.98013927e-02f, 7.54752457e-02f, 1.27004832e-01f, -6.40221089e-02f, 2.34716207e-01f,
  1.56398136e-02f, 3.17012966e-02f, -4.61576022e-02f, 8.60881247e-03f, 3.98156941e-02f, 1.19388178e-02f, -5.70491217e-02f, 2.18821783e-02f, -2.66098771e-02f, 8.26396495e-02f,
  -5.94456587e-03f, -7.46880285e-03f, -3.65730226e-02f, 5.70664778e-02f, -1.11398203e-02f, 9.35155302e-02f, -4.03210521e-02f, 4.84366566e-02f, -6.28582165e-02f, 3.75073701e-02f,
  -5.99156059e-02f, 7.04675447e-03f, 5.31432293e-02f, -3.56195355e-03f, 3.50227207e-02f, -3.54922339e-02f, -7.89494370e-04f, -3.33216265e-02f, -5.82472468e-03f, -6.44192621e-02f,
  1.08148634e-01f, -1.80011734e-01f, 3.46911661e-02f, -1.48203820e-02f, -2.11249907e-02f, 2.14723200e-02f, 5.44577874e-02f, 1.41817592e-02f, -1.10041359e-02f, 4.98609878e-02f,
  1.98664833e-02f, 3.48854475e-02f, 3.92314680e-02f, 5.45508740e-03f, 1.19090891e-02f, -3.43204625e-02f, 8.51959586e-02f, -1.54557442e-02f, -1.12694271e-01f, 2.88108066e-02f,
  1.03421681e-01f, -5.50498255e-02f, -1.07339814e-01f, -8.71008784e-02f, -2.60245544e-03f, -2.33705133e-01f, -8.77688006e-02f, -4.76883836e-02f, -2.11104646e-01f, -4.18540835e-02f,
  1.04763158e-01f, 3.16950865e-02f, 2.02673882e-01f, 2.65425622e-01f, 3.61295193e-01f, 2.32563227e-01f, 2.46770218e-01f, 7.51018226e-02f, 4.02254537e-02f, 7.95657039e-02f,
  4.07989649e-03f, -1.56076252e-01f, -1.64293185e-01f, -1.39487505e-01f, -2.54315529e-02f, -2.80651972e-02f, 1.79746494e-01f, 4.68851477e-02f, 5.40250819e-03f, 1.39856622e-01f,
  -7.09664822e-02f, 1.44431561e-01f, 9.32891071e-02f, -9.69896689e-02f, 1.00173935e-01f, -7.55509436e-02f, 5.66899916e-03f, -2.60355491e-02f, -7.72883929e-03f, 3.68541107e-02f,
  -1.78878874e-01f, 2.34705016e-01f, 5.79126477e-02f, -3.68669741e-02f, 2.60137022e-02f, -8.95436630e-02f, 1.06154419e-02f, -5.43079637e-02f, 4.54072980e-03f, 4.40391153e-02f,
  9.82631892e-02f, -4.94594127e-02f, 1.55362738e-02f, 8.51606112e-03f, 5.93934767e-02f, -5.46899252e-03f, -6.24909736e-02f, -5.09023927e-02f, -7.37139359e-02f, 2.86455844e-02f,
  8.28541145e-02f, 1.07164301e-01f, 1.54842526e-01f, -1.32109635e-02f, 5.91862798e-02f, 7.25870356e-02f, 1.12295911e-01f, 3.34593467e-02f, 7.05261528e-02f, -1.15455620e-01f,
  4.99555543e-02f, -1.12862671e-02f, -7.82679170e-02f, -4.42405194e-02f, 8.96728132e-03f, -3.53400484e-02f, 4.23817942e-03f, -4.88258824e-02f, 1.77890609e-03f, -5.46021871e-02f,
  -5.89643866e-02f, 2.11195201e-02f, -2.34396644e-02f, 1.51720280e-02f, -1.75195131e-02f, 1.06986672e-01f, -7.69984443e-04f, -2.74493005e-02f, 3.38360760e-03f, 8.72596130e-02f,
  -3.72612439e-02f, -1.87911727e-02f, 6.64865449e-02f, -9.46596786e-02f, -2.05566786e-04f, 5.63165359e-02f, -7.44602233e-02f, 1.72907654e-02f, -4.64411592e-03f, 5.53118400e-02f,
  -1.69196442e-01f, 5.41039631e-02f, -6.93606436e-02f, -1.88607797e-02f, -9.48565379e-02f, -1.01385757e-01f, 4.57238369e-02f, 1.52885318e-02f, -3.36482748e-02f, -2.99661160e-02f,
  9.23079997e-02f, -4.29601185e-02f, -4.06878665e-02f, 3.51002961e-02f, 4.62513678e-02f, 1.71594080e-02f, -1.03636265e-01f, 5.96947782e-02f, -3.19486707e-02f, 4.96916845e-02f,
  -6.28159195e-02f, -3.21930572e-02f, 3.38776642e-03f, 8.43317211e-02f, -3.45939100e-02f, -4.46571559e-02f, 4.71986597e-03f, 5.96860014e-02f, 2.40176711e-02f, -1.36934757e-01f,
  1.40357818e-02f, -5.61917666e-03f, -4.53162231e-02f, -6.17145225e-02f, 7.34406384e-03f, -7.99844489e-02f, -2.27132753e-01f, -6.99927658e-02f, 2.39623226e-02f, -5.57492897e-02f,
  3.36540816e-03f, 2.21509084e-01f, 7.13044330e-02f, 4.00326364e-02f, 2.05944735e-03f, -1.69292316e-01f, -2.45406047e-01f, -5.24560064e-02f, 1.43250987e-01f, 5.82270026e-02f,
  6.62703142e-02f, 9.21037123e-02f, 5.88139798e-03f, 1.05208009e-01f, -5.03448071e-03f, 5.21768592e-02f, -6.98436126e-02f, -9.67140272e-02f, 4.96860174e-03f, -1.88484192e-01f,
  8.24713632e-02f, 1.69452488e-01f, 1.31947566e-02f, -4.47294600e-02f, 7.22153038e-02f, -3.30877341e-02f, 7.54596945e-03f, -3.37637379e-03f, -3.14146839e-02f, -3.74779664e-02f,
  5.46508562e-03f, 1.04734739e-02f, 3.10473666e-02f, 3.35129313e-02f, 4.63598147e-02f, 3.51713859e-02f, 2.38279924e-02f, 3.56912264e-03f, -7.87508413e-02f, -3.06580700e-02f,
  1.00637544e-02f, 9.62391570e-02f, -1.67778432e-02f, -4.34415340e-02f, -6.66791797e-02f, 5.21502420e-02f, 9.05522481e-02f, 1.06367819e-01f, 2.56709456e-02f, 9.48083475e-02f,
  9.43754613e-03f, -2.62687821e-02f, -5.36156334e-02f, 4.26236875e-02f, -1.67154763e-02f, 1.98605359e-02f, -5.29486947e-02f, -3.33488472e-02f, 7.14213178e-02f, -3.60792018e-02f,
  2.50209030e-02f, -1.27261383e-02f, 4.47951443e-02f, -8.26601833e-02f, 2.83005238e-02f, 7.51525909e-02f, 1.11228190e-01f, -4.49107699e-02f, -2.85017658e-02f, -1.51724070e-02f,
  6.02222309e-02f, -5.27831912e-02f, 9.10825953e-02f, -6.55026268e-03f, -4.15835418e-02f, -3.17519717e-02f, -8.10217112e-02f, 5.32620735e-02f, -8.32762569e-02f, -5.27104586e-02f,
  1.07760094e-01f, 1.39544472e-01f, -1.59755833e-02f, 3.96610610e-02f, -3.83908637e-02f, 8.27286541e-02f, 6.92761242e-02f, 7.89143667e-02f, -7.87736177e-02f, 8.12941696e-03f,
  7.43692443e-02f, -3.95923629e-02f, -8.25480223e-02f, -2.17398517e-02f, 3.16360034e-02f, -9.59936436e-03f, 3.28518748e-02f, 1.79505418e-03f, 3.49389762e-02f, -5.03914766e-02f,
  -1.30234748e-01f, 3.66557091e-02f, 4.44543883e-02f, 1.71757024e-02f, 7.57120475e-02f, 3.02054565e-02f, 8.30456167e-02f, -4.94715609e-02f, 6.62542358e-02f, -1.40913883e-02f,
  5.21586061e-01f, -1.25847906e-02f, 2.07800403e-01f, 1.15383297e-01f, -1.23114780e-01f, -1.17697325e-02f, -3.75144929e-02f, 3.56364213e-02f, 2.43623443e-02f, 5.31027876e-02f,
  -2.53222138e-02f, 7.92847499e-02f, 9.78261307e-02f, 4.31050807e-02f, 1.56935588e-01f, -6.82341009e-02f, -4.96438071e-02f, 6.70909360e-02f, 1.89518839e-01f, 2.61202157e-02f,
  -1.80050105e-01f, -9.89180245e-03f, 6.98719248e-02f, -5.34738749e-02f, -1.64906666e-01f, -6.97932253e-03f, -2.99954079e-02f, -4.91862819e-02f, -1.47129610e-01f, -3.63940030e-01f,
  9.32418481e-02f, 2.28769660e-01f, 4.98765483e-02f, 1.03202902e-01f, -2.48711780e-02f, 6.93530813e-02f, 9.45324600e-02f, 8.55943635e-02f, 1.44678548e-01f, 4.21983600e-02f,
  -3.46139446e-02f, 4.68006022e-02f, -6.38085417e-03f, -6.86607808e-02f, 7.35078007e-02f, 2.66721472e-03f, -5.19354008e-02f, 2.23469287e-02f, -2.76508555e-02f, -8.17677751e-03f,
  -1.57891378e-01f, -7.63114244e-02f, 1.67362288e-01f, -1.86654720e-02f, 3.63096669e-02f, 8.72546956e-02f, -6.92216307e-02f, 2.32257936e-02f, 1.11970298e-01f, -2.72886064e-02f,
  -1.64086848e-01f, 3.44443843e-02f, -2.04846058e-02f, -4.23721131e-03f, 1.37624396e-02f, 5.63245546e-03f, -8.07246640e-02f, -3.53066586e-02f, 7.25208549e-03f, 1.40084829e-02f,
  -1.40578104e-02f, 2.71279402e-02f, 2.44536344e-02f, 2.71750465e-02f, -9.96887386e-02f, 5.85106090e-02f, -7.26541728e-02f, 5.86227253e-02f, -3.90608273e-02f, 1.02864467e-01f,
  -3.69625501e-02f, 9.32788402e-02f, 7.73947462e-02f, -5.01960553e-02f, -3.08547989e-02f, 1.91134133e-03f, -2.30397354e-03f, -1.10539664e-02f, -5.34035526e-02f, -5.60291065e-03f,
  1.48834229e-01f, 1.23166129e-01f, -2.23995000e-02f, 7.10897893e-02f, -1.75426994e-02f, -3.60345580e-02f, 4.78376076e-02f, -1.47683816e-02f, 2.60488261e-02f, 1.90544762e-02f,
  1.00059539e-01f, 7.87494630e-02f, 7.40267336e-02f, -8.19044113e-02f, 4.99216188e-03f, 1.05221182e-01f, -1.01074904e-01f, 4.89237271e-02f, -5.52392006e-02f, -7.07639158e-02f,
  -9.65233967e-02f, 2.06383038e-02f, 1.60764784e-01f, 2.49161329e-02f, 6.55135466e-03f, 1.20073063e-02f, 9.62209925e-02f, -3.67543064e-02f, 1.82503715e-01f, 2.91002914e-02f,
  -1.71945319e-01f, -1.12629622e-01f, -8.74082372e-02f, 1.17353536e-02f, -1.03050396e-01f, -1.15505926e-01f, -3.24859113e-01f, -7.85670504e-02f, 1.04452543e-01f, 6.86812624e-02f,
  8.18931460e-02f, 1.86289176e-01f, 1.82378471e-01f, 7.98348263e-02f, 4.07957099e-02f, -1.15903169e-01f, -3.64442170e-02f, 6.19132407e-02f, -7.93938860e-02f, -2.04350520e-02f,
  8.53712261e-02f, 2.45829299e-02f, -3.43620181e-02f, 3.50435339e-02f, -7.39704818e-03f, 3.96006070e-02f, -1.33914769e-01f, -1.69585291e-02f, 8.14538673e-02f, -8.04104470e-03f,
  1.25756517e-01f, -1.03345178e-02f, 1.26947179e-01f, 1.06684007e-01f, -8.02655518e-03f, 8.00994877e-03f, -8.62741694e-02f, -1.16323777e-01f, 2.64005526e-03f, -8.89892578e-02f,
  6.80582151e-02f, 3.47649283e-03f, -6.61387993e-03f, -8.20191354e-02f, 1.88922323e-02f, -7.92819634e-02f, -6.81746602e-02f, -4.71870154e-02f, 7.23534301e-02f, -3.40341255e-02f,
  -7.88051449e-03f, 3.99130657e-02f, -1.79435853e-02f, 3.85502689e-02f, 8.83201510e-03f, 1.14914067e-01f, 1.26766562e-02f, 1.19363293e-01f, 8.54873583e-02f, -7.21767470e-02f,
  -1.32108023e-02f, -3.11416443e-02f, 3.58327031e-02f, 6.21410273e-03f, 3.28717520e-03f, -4.60021049e-02f, 1.09104194e-01f, -1.25967767e-02f, 6.01710603e-02f, -4.70450483e-02f,
  -2.12091673e-02f, 4.76029702e-02f, 2.02458072e-02f, 1.55744553e-02f, 2.62212269e-02f, -3.87802459e-02f, -5.75466044e-02f, -8.62561241e-02f, 7.21955970e-02f, -3.00684273e-02f,
  2.34723110e-02f, -6.93373829e-02f, 1.87079515e-02f, -1.07722888e-02f, -2.31505595e-02f, -3.15009877e-02f, 3.60304229e-02f, -2.22786609e-02f, 4.37365239e-03f, 7.77987391e-02f,
  1.56670213e-01f, 6.06997162e-02f, 6.19521812e-02f, -2.27697659e-02f, 6.65510222e-02f, 7.26432055e-02f, 5.64669371e-02f, 2.49721576e-02f, 4.58690152e-02f, 1.30239353e-02f,
  -1.38326278e-02f, -1.53199686e-02f, -6.12183064e-02f, -1.42634781e-02f, -3.31846671e-03f, -4.75208536e-02f, -3.91514674e-02f, 5.94316870e-02f, -4.00825851e-02f, 5.12515148e-03f,
  -3.11474968e-02f, -1.00068599e-01f, -1.91514641e-02f, -7.09130093e-02f, 5.94535917e-02f, 3.59218828e-02f, -1.75493490e-02f, -5.20490743e-02f, 1.28405597e-02f, -1.66423976e-01f,
  -7.46371374e-02f, -1.76522091e-01f, 2.82389373e-01f, -1.87332034e-01f, -3.29269134e-02f, -2.21987208e-03f, 1.70288995e-01f, -8.04158002e-02f, -2.42633447e-01f, 2.17621308e-02f,
  -1.76604480e-01f, -1.48459196e-01f, -3.71633880e-02f, 7.33737871e-02f, 1.15557186e-01f, 1.07729465e-01f, 2.93613970e-01f, 2.35532135e-01f, 1.69355404e-02f, -1.49894223e-01f,
  -1.59115512e-02f, -1.31260296e-02f, 4.37765233e-02f, -1.25849605e-01f, -7.83461779e-02f, -4.03253809e-02f, 1.00632474e-01f, 3.79326828e-02f, -5.20846546e-02f, -3.67875770e-02f,
  1.41719595e-01f, -8.85048211e-02f, 7.36551583e-02f, -3.84658650e-02f, -2.65068710e-02f, 8.90375450e-02f, -6.62962943e-02f, 1.23729557e-01f, -6.43059984e-02f, -6.25985041e-02f,
  -9.28975735e-03f, -9.46882740e-02f, -1.71077577e-03f, -3.24266218e-02f, -5.38196862e-02f, 2.31116228e-02f, 8.43313634e-02f, 1.09027140e-01f, 1.13788493e-01f, 3.61193158e-02f,
  1.68894064e-02f, -3.57722007e-02f, -8.95477384e-02f, -4.05698009e-02f, -2.13221973e-03f, -1.67418029e-02f, -7.94130266e-02f, -5.41965328e-02f, 1.94960088e-02f, -3.23863328e-02f,
  3.51898186e-02f, -5.74069172e-02f, -1.40611706e-02f, 1.78943090e-02f, -4.29432094e-02f, 8.18091538e-03f, -7.89831951e-02f, 4.77084555e-02f, -3.41422074e-02f, -2.87285112e-02f,
  4.62856553e-02f, -3.20604304e-03f, -2.21080352e-02f, 4.86045703e-02f, 3.42775024e-02f, 9.08405613e-03f, -6.18088804e-03f, -1.37092164e-02f, -3.62268873e-02f, -1.28124533e-02f,
  -2.81566288e-02f, -4.85980920e-02f, 3.26748937e-02f, -2.82527395e-02f, 8.08274075e-02f, 6.56165257e-02f, 6.20385893e-02f, -8.03386867e-02f, 2.42546108e-02f, 2.96896212e-02f,
  -8.25558305e-02f, 1.34328410e-01f, 3.92436795e-02f, -4.89645489e-02f, 5.60726672e-02f, -3.15881968e-02f, 6.29506633e-02f, 9.48631614e-02f, 2.03078147e-02f, -2.87016332e-02f,
  -5.66619001e-02f, 4.26193513e-02f, 2.33637746e-02f, -3.51215200e-03f, 1.00514917e-02f, -5.73807396e-02f, -7.40830377e-02f, 2.17698254e-02f, 1.39086526e-02f, 2.49896664e-02f,
  1.23600597e-02f, 4.14491221e-02f, -6.19249092e-03f, 2.75110342e-02f, -7.00944886e-02f, 2.80949362e-02f, 6.97111338e-02f, 4.28050645e-02f, 7.40297791e-03f, 9.04220343e-03f,
  -3.69288921e-01f, 3.00673153e-02f, -1.91600323e-01f, -2.23529339e-01f, -2.44135916e-01f, -1.81938857e-01f, -8.69881809e-02f, -6.76096976e-02f, -1.14986971e-01f, 1.21795133e-01f,
  1.45200476e-01f, 3.13421004e-02f, -7.05479160e-02f, -2.27207877e-02f, -1.38220981e-01f, -1.00463830e-01f, -1.22319371e-01f, -2.93922007e-01f, -3.30929846e-01f, -1.73340067e-01f,
  -6.25093952e-02f, -2.49565840e-01f, -2.54670292e-01f, -1.78049449e-02f, -2.57399539e-03f, -7.18722567e-02f, -1.20958006e-02f, -7.74160773e-02f, 4.66664769e-02f, -1.33243680e-01f,
  -7.89996535e-02f, -4.84171957e-02f, -9.89792496e-02f, -5.12994863e-02f, 7.64364097e-03f, 6.45200685e-02f, 5.59956469e-02f, -1.24384694e-01f, 3.21902521e-02f, 6.38161451e-02f,
  3.58599558e-04f, 1.03906363e-01f, 1.85902871e-03f, -8.06949288e-03f, 2.67683621e-02f, -1.46491483e-01f, 7.35788122e-02f, -8.39621127e-02f, -6.84456527e-02f, 4.37221155e-02f,
  6.41484261e-02f, 3.90854515e-02f, -6.46953732e-02f, -2.47824974e-02f, -6.28074110e-02f, -2.54207868e-02f, 3.11513916e-02f, -9.10243317e-02f, -7.83293173e-02f, 6.11050501e-02f,
  4.48136255e-02f, -7.47231394e-03f, -3.56396921e-02f, -2.08182111e-02f, 3.21377032e-02f, 1.03028387e-01f, 4.12156573e-03f, 2.83307559e-03f, -4.72992994e-02f, 2.78327335e-02f,
  1.31540019e-02f, 3.55947367e-03f, 2.83273179e-02f, 2.51407102e-02f, 8.72108620e-03f, 1.06148962e-02f, -1.09637501e-02f, 7.43031278e-02f, 1.96622722e-02f, 5.18903807e-02f,
  -3.29218134e-02f, -3.08137853e-02f, -4.38653603e-02f, 5.13636135e-03f, -2.05469690e-02f, -3.01636457e-02f, -5.56208147e-03f, 4.68045026e-02f, -5.10840975e-02f, -1.97350252e-02f,
  1.72163919e-02f, -7.15788007e-02f, 5.12910634e-02f, 1.26038799e-02f, -1.10925943e-01f, 3.24558131e-02f, 6.57449067e-02f, 3.46498303e-02f, 7.07069486e-02f, 5.20818457e-02f,
  8.79920349e-02f, 3.53868231e-02f, 1.48017863e-02f, 5.81588931e-02f, -7.52508342e-02f, -4.38370593e-02f, 6.03271946e-02f, -5.77705130e-02f, -1.25816427e-02f, 3.85964699e-02f,
  9.86613631e-02f, -6.27345592e-02f, 6.33212775e-02f, 3.97634134e-02f, 4.40340228e-02f, -8.08683783e-02f, 7.19865263e-02f, 4.78632003e-03f, -1.44809177e-02f, 8.39612931e-02f,
  4.61161256e-01f, 8.74657705e-02f, 1.56192452e-01f, -8.76502469e-02f, 1.03866085e-01f, 5.77915758e-02f, 1.65240869e-01f, 6.16241880e-02f, -5.74551299e-02f, 7.45489746e-02f,
  -1.46695688e-01f, -2.70099789e-01f, -2.87051857e-01f, -1.14117898e-01f, -4.40205820e-02f, 1.05840065e-01f, 8.00087601e-02f, 4.66329372e-03f, -6.08294159e-02f, 2.17924304e-02f,
  -1.51742026e-01f, 1.82224467e-01f, 6.52741715e-02f, 9.11656842e-02f, 4.65872400e-02f, -1.47745177e-01f, 4.18804996e-02f, 1.33534998e-01f, -8.44556615e-02f, -3.34538519e-02f,
  -1.40388504e-01f, 2.50465751e-01f, -1.56747609e-01f, -7.28672296e-02f, -3.66150066e-02f, 1.16864098e-02f, -1.61636323e-02f, 3.29209231e-02f, -1.28311692e-02f, 1.05133623e-01f,
  -4.32162918e-02f, 1.88113600e-02f, 4.51632105e-02f, 5.05218543e-02f, 5.90038598e-02f, 8.00881013e-02f, 4.18069437e-02f, 1.40752420e-01f, 7.14229643e-02f, 2.18102196e-03f,
  -1.19197130e-01f, 1.64396726e-02f, 1.85647607e-01f, -2.73191668e-02f, -4.24490422e-02f, 1.12383561e-02f, 4.91165295e-02f, 8.09424222e-02f, 8.03360529e-03f, -2.02036183e-02f,
  -7.67013505e-02f, -5.85775487e-02f, -6.40152209e-03f, -5.92020415e-02f, 9.67487991e-02f, 8.71459924e-05f, 1.36465055e-03f, 4.36104760e-02f, -1.11136604e-02f, 4.43838127e-02f,
  -7.27718696e-02f, 7.27298111e-02f, 2.20025517e-02f, 1.15979090e-02f, -9.64957029e-02f, 7.53205642e-02f, -3.52473296e-02f, 2.72886530e-02f, 3.84395681e-02f, -1.49892448e-02f,
  -2.79947557e-03f, -6.07547499e-02f, 7.99338240e-03f, -1.13214955e-01f, -1.71518903e-02f, -1.55612314e-02f, -4.85159978e-02f, 7.80643150e-03f, -3.80451903e-02f, 9.49079394e-02f,
  -1.80846497e-01f, 4.66603972e-02f, -1.60433933e-01f, 6.20265007e-02f, 1.14028327e-01f, -2.29792856e-02f, -7.47754499e-02f, -4.93810773e-02f, -3.43493349e-03f, 9.55290645e-02f,
  6.01793677e-02f, -3.14042531e-02f, -8.66317302e-02f, -8.99174623e-03f, 1.67078543e-02f, -2.47943532e-02f, -4.62273555e-03f, -3.99308912e-02f, -3.35647725e-02f, -3.05058789e-02f,
  5.24825882e-03f, 1.38372900e-02f, 2.78698355e-02f, 3.66705358e-02f, 3.55166644e-02f, -1.14318907e-01f, -3.41591574e-02f, 3.19283195e-02f, 4.13335934e-02f, -4.44493555e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.97361213e-01f, 5.02273589e-02f, -2.69032223e-03f, 2.38426905e-02f, 1.30606949e-01f, 2.91361034e-01f, 2.80684054e-01f, 1.54725716e-01f, -2.19436698e-02f, -2.11325083e-02f,
  -6.77912235e-02f, -3.21408510e-02f, 3.54836397e-02f, 1.06390983e-01f, 8.03306103e-02f, 1.43078253e-01f, 1.84107974e-01f, -8.68293643e-02f, -6.92815110e-02f, -3.64207523e-03f,
  4.51953039e-02f, -3.17396708e-02f, -2.13518679e-01f, -3.15466113e-02f, 1.00526318e-01f, 7.62493014e-02f, -3.77069786e-02f, 3.75200026e-02f, 7.34076649e-02f, 1.64044220e-02f,
  -8.85860026e-02f, -1.26924992e-01f, 8.24467912e-02f, 2.74954289e-02f, 1.07984906e-02f, -7.21134394e-02f, -8.44638050e-02f, -9.39477757e-02f, -7.79012814e-02f, 4.88506779e-02f,
  -4.86271009e-02f, -1.36485487e-01f, 2.12573097e-03f, 1.66511554e-02f, -4.31293584e-02f, -8.56226310e-03f, -3.87520678e-02f, -4.18127477e-02f, 4.81270552e-02f, -1.92447158e-03f,
  1.58195049e-01f, -5.74566089e-02f, -4.78830971e-02f, 3.05049978e-02f, 1.76175579e-01f, 3.44302729e-02f, -8.33199397e-02f, -3.38806771e-02f, -3.24328542e-02f, -1.06500268e-01f,
  -1.27093773e-03f, 6.27541393e-02f, 7.28257522e-02f, 4.66056801e-02f, -3.80214937e-02f, -4.12912890e-02f, 1.12871207e-01f, -2.40975507e-02f, 4.55199890e-02f, -4.28546108e-02f,
  3.91814951e-03f, 4.42198031e-02f, -5.01199625e-03f, 7.60265514e-02f, 1.97726414e-02f, 3.58321667e-02f, 1.02871843e-01f, 1.36951786e-02f, -3.80977895e-03f, -8.84364471e-02f,
  -9.58783999e-02f, -3.62583101e-02f, -8.01621154e-02f, -3.09919845e-02f, 1.97039358e-02f, 1.44839277e-02f, -2.62388550e-02f, -3.33922394e-02f, -6.30928054e-02f, -2.94945110e-02f,
  -2.00212169e-02f, 1.16957389e-02f, 3.96496542e-02f, -1.64434817e-02f, -7.18754670e-03f, -1.10593967e-01f, -9.34934430e-03f, -2.45822016e-02f, 3.20804305e-02f, 3.50680239e-02f,
  1.12410849e-02f, -2.77882852e-02f, -8.43034834e-02f, -1.44790178e-02f, -1.96717046e-02f, -4.39621322e-02f, 2.25754958e-02f, 9.67435762e-02f, -6.71360344e-02f, 1.19906172e-01f,
  1.61312699e-01f, 1.49448896e-02f, 1.99631490e-02f, 1.30790904e-01f, 6.94319904e-02f, -5.58550470e-02f, 6.52433783e-02f, -2.73728408e-02f, -6.62748516e-02f, -8.91224965e-02f,
  3.55978310e-02f, 7.53443986e-02f, -1.29357368e-01f, 1.09396353e-01f, 4.73201759e-02f, 1.93129014e-02f, -9.64282677e-02f, -8.24722499e-02f, 2.66202521e-02f, -3.66144627e-02f,
  1.53429613e-01f, 4.87879477e-03f, -2.30877921e-02f, -1.99008337e-03f, -8.75706598e-02f, -1.35294244e-01f, -8.49767327e-02f, -1.78937033e-01f, -1.06039047e-01f, 3.27160694e-02f,
  -4.12787870e-02f, -4.96874116e-02f, -7.30441660e-02f, 7.08294809e-02f, 7.62061253e-02f, 1.24067433e-01f, -4.44205888e-02f, 1.27884030e-01f, 1.35132059e-01f, 2.14795157e-01f,
  -1.54499039e-02f, -3.81290726e-02f, -5.22074178e-02f, 1.14965670e-01f, -4.92766174e-03f, 4.94596884e-02f, 7.14741647e-02f, -3.23322676e-02f, -3.62050310e-02f, 4.58405726e-03f,
  6.56375708e-03f, -3.70283686e-02f, 3.51138189e-02f, 9.26988199e-02f, -5.88211827e-02f, -7.20689595e-02f, -8.34830180e-02f, -1.75268315e-02f, -8.77243746e-03f, 6.24688109e-03f,
  -9.24395118e-03f, 2.19645929e-02f, -5.45387343e-02f, -4.01518904e-02f, 2.20243633e-03f, 2.60771960e-02f, -9.14279372e-03f, -1.49815222e-02f, 2.04557814e-02f, 1.18389554e-01f,
  -6.45731091e-02f, 1.02385981e-02f, 5.79701271e-03f, -4.59669419e-02f, 1.98141746e-02f, 6.50618896e-02f, 7.84381852e-02f, 7.10268319e-03f, 6.11675382e-02f, -6.09863028e-02f,
  -5.15609458e-02f, 3.03137824e-02f, -6.90664500e-02f, -7.71789253e-02f, -3.52900028e-02f, -4.08252329e-02f, -2.20930837e-02f, -4.98236939e-02f, -6.20486028e-02f, -3.58589068e-02f,
  -8.14263336e-03f, 4.85911444e-02f, 1.42073054e-02f, 1.15443701e-02f, -1.56052283e-03f, 5.21860607e-02f, 4.73524705e-02f, -4.54406142e-02f, -7.80555531e-02f, 1.79733150e-02f,
  4.86873016e-02f, -1.18825853e-01f, -7.64062405e-02f, -2.35856473e-02f, 6.98356852e-02f, 4.63332236e-02f, 1.21365696e-01f, -8.34491290e-03f, -5.51188737e-02f, -6.09886274e-02f,
  1.04315892e-01f, -2.83022989e-02f, 5.56345657e-02f, 8.13053548e-02f, -6.68552816e-02f, -2.43141335e-02f, -1.32610807e-02f, -1.92894097e-02f, -1.07335284e-01f, -1.77711770e-02f,
  -4.49797139e-02f, -6.87919790e-03f, -4.00280952e-02f, -2.76482366e-02f, -6.68687746e-02f, -6.78275675e-02f, -4.03262451e-02f, -2.28075422e-02f, -3.20693082e-03f, -1.05077900e-01f,
  -3.01958323e-02f, 3.33906226e-02f, 1.06404357e-01f, 3.67317572e-02f, -2.88073383e-02f, 3.52211744e-02f, -4.23328057e-02f, 3.71604483e-03f, 1.06231431e-02f, -7.81594813e-02f,
  -7.03981593e-02f, -1.42648593e-01f, -9.36295614e-02f, -3.28571163e-02f, -6.86496422e-02f, -8.23461413e-02f, 6.91668242e-02f, 4.13999334e-02f, -6.60402477e-02f, -4.97978181e-02f,
  6.41832426e-02f, -7.97465369e-02f, -1.92185715e-02f, -8.81995782e-02f, 2.86483299e-02f, 3.75302285e-02f, 8.42713490e-02f, 6.72054589e-02f, -8.37461501e-02f, -3.14501785e-02f,
  4.73520607e-02f, 2.69959141e-02f, 2.77559757e-02f, -8.96338671e-02f, 6.37639910e-02f, -9.80126555e-04f, -1.73462220e-02f, -8.43768120e-02f, -1.09647803e-01f, -3.59267667e-02f,
  -9.97011811e-02f, -4.60307859e-02f, -4.81539369e-02f, -1.03812277e-01f, -7.39601478e-02f, -1.44450879e-02f, 2.20967475e-02f, 4.80592325e-02f, 5.57524636e-02f, 9.26702842e-03f,
  4.17361520e-02f, -4.05655988e-02f, -4.72562462e-02f, -7.09567368e-02f, 2.16768831e-02f, -4.02872488e-02f, 6.94090128e-02f, -4.10322063e-02f, -3.74078564e-02f, 5.69038354e-02f,
  7.80425174e-03f, -4.93653305e-02f, -4.24455181e-02f, 3.65826711e-02f, -1.01593025e-02f, -3.50791365e-02f, 4.68631350e-02f, -3.40198800e-02f, -3.40717286e-02f, -2.12175678e-02f,
  -6.02455251e-02f, -5.55983484e-02f, -4.60660085e-02f, -1.84241589e-02f, 4.85754125e-02f, 2.31747571e-02f, -5.85993193e-02f, -5.38646206e-02f, 7.73349479e-02f, 1.84332933e-02f,
  7.49220923e-02f, 1.88460816e-02f, 4.30257209e-02f, 4.40276042e-02f, 4.20610011e-02f, -8.27300251e-02f, 8.77472907e-02f, 6.69039041e-02f, -3.20930555e-02f, 7.08421767e-02f,
  -6.57280162e-02f, 4.47477363e-02f, -9.42815840e-02f, -5.84208593e-02f, -7.73126930e-02f, -1.75302327e-02f, -8.32520146e-03f, -6.86074719e-02f, -1.00816153e-01f, 3.06904987e-02f,
  -4.17160243e-02f, -8.12498108e-02f, 3.17524895e-02f, 1.35208424e-02f, 1.87498443e-02f, -4.43773158e-02f, 1.48002915e-02f, -1.11320671e-02f, 6.85958490e-02f, 2.99479570e-02f,
  2.60081459e-02f, 6.35166466e-02f, 4.27253954e-02f, -3.30302343e-02f, -5.57153262e-02f, 9.47607961e-03f, 7.63494149e-03f, -1.04252912e-01f, 4.29922203e-03f, 5.46196662e-02f,
  -2.08770499e-01f, -7.97341913e-02f, -1.60300121e-01f, -1.75157469e-02f, 3.21426466e-02f, 8.83437246e-02f, 3.92753817e-02f, 7.96695203e-02f, 1.30776986e-02f, 2.47205142e-02f,
  7.20675960e-02f, 1.81939397e-02f, -8.96701366e-02f, 1.26321867e-01f, -7.93106183e-02f, -1.11953259e-01f, -1.50558412e-01f, -1.68333538e-02f, -3.83636951e-02f, 2.07812190e-01f,
  9.08632427e-02f, -2.81821527e-02f, -6.50687218e-02f, -7.97491893e-02f, -1.06515668e-01f, 6.32246360e-02f, -1.58956721e-01f, 1.69329159e-02f, -2.90446412e-02f, -1.79114081e-02f,
  -8.79809186e-02f, 2.93392930e-02f, 1.36115775e-03f, 7.13336989e-02f, -8.01277161e-02f, -7.94954598e-02f, 2.81583276e-02f, -7.05047175e-02f, 7.27420580e-03f, 6.40281439e-02f,
  -3.08523793e-02f, 7.89513811e-03f, -6.74221814e-02f, 7.07178712e-02f, 3.48141417e-03f, 7.13838562e-02f, -8.53882432e-02f, 2.01733764e-02f, -2.04373524e-02f, 4.26113121e-02f,
  8.27893242e-02f, -1.18423803e-02f, -4.67160083e-02f, -8.30722228e-02f, -5.51733710e-02f, -1.05326362e-01f, -1.11588299e-01f, -8.84914249e-02f, -1.35044843e-01f, -3.59566361e-02f,
  -4.04298790e-02f, -8.06715861e-02f, -2.88115535e-02f, 7.99312368e-02f, -5.31392545e-02f, 1.65463649e-02f, 2.07478292e-02f, 1.95666905e-02f, -4.13329042e-02f, -1.11337136e-02f,
  3.80346831e-03f, 2.11263299e-02f, 9.76730213e-02f, 1.01869022e-02f, -6.31075948e-02f, 6.99996427e-02f, 5.31171747e-02f, -7.96906948e-02f, 5.23700528e-02f, 1.02194902e-02f,
  -1.13727264e-01f, -8.14030170e-02f, -7.80534297e-02f, 3.45111862e-02f, -7.26905167e-02f, -3.28309722e-02f, -8.53056088e-02f, -7.51746744e-02f, -3.43220644e-02f, -8.75981897e-02f,
  -2.03986794e-01f, 1.25671133e-01f, 3.42537500e-02f, 4.47549969e-02f, -2.36520581e-02f, 3.14263552e-02f, 3.57356258e-02f, -5.63097000e-02f, 4.52341847e-02f, 1.46993268e-02f,
  1.73514485e-02f, -2.23085210e-02f, -1.08743735e-01f, -7.58199096e-02f, -3.52402590e-02f, -3.47825363e-02f, -2.56495196e-02f, 6.60892799e-02f, -9.28246379e-02f, 1.30586876e-02f,
  -2.63424646e-02f, -1.71090215e-02f, -5.51894084e-02f, -8.08910728e-02f, 2.68547665e-02f, -3.35645042e-02f, -1.45611256e-01f, -7.05618411e-02f, -1.66147262e-01f, -2.20211685e-01f,
  1.79164708e-02f, -8.93759653e-02f, 5.84065635e-03f, 1.45500109e-01f, -6.69980720e-02f, -2.35286862e-01f, -2.95911610e-01f, -1.39596790e-01f, 6.31709546e-02f, -7.56040514e-02f,
  5.08322380e-03f, -1.00597925e-02f, 3.03018130e-02f, 4.72831316e-02f, -2.10209280e-01f, -1.15449399e-01f, -1.93744197e-01f, -8.02942365e-02f, -1.35576889e-01f, -5.23145776e-03f,
  -5.74776530e-02f, 9.86851677e-02f, 1.33237196e-02f, -6.03847876e-02f, 1.11322954e-01f, 5.93612008e-02f, 8.29992592e-02f, 1.23168774e-01f, -3.83458822e-03f, 7.33043700e-02f,
  2.00081728e-02f, 1.08932350e-02f, 2.09335070e-02f, -7.55978897e-02f, -3.82531919e-02f, -1.15394190e-01f, -1.20962202e-03f, 5.50292991e-02f, -9.71387401e-02f, 5.48144504e-02f,
  9.38566774e-03f, -2.64992268e-04f, -5.22502698e-02f, -1.47279548e-02f, -9.52080861e-02f, -5.41618690e-02f, -1.22412026e-01f, -1.81785077e-02f, -2.30387766e-02f, -1.10604733e-01f,
  -8.21405202e-02f, -2.74357088e-02f, -4.35964949e-02f, -2.20988840e-02f, -1.22498740e-02f, -8.06712508e-02f, -9.85895619e-02f, -4.92273904e-02f, -8.91255140e-02f, 9.92896222e-03f,
  3.92498150e-02f, 3.76688056e-02f, 8.28238204e-03f, 3.14195342e-02f, -3.34456228e-02f, 3.66903469e-02f, 5.51835559e-02f, -1.06951408e-02f, -2.98229195e-02f, -1.17506254e-02f,
  -3.99042889e-02f, -7.81778768e-02f, 1.32674892e-02f, 8.33664909e-02f, 4.53163572e-02f, 5.91688417e-02f, -2.23641060e-02f, -6.00833222e-02f, 1.62911192e-02f, -6.06786385e-02f,
  2.54870160e-03f, 1.62452292e-02f, -6.31221682e-02f, 4.01492156e-02f, -8.08032975e-02f, 7.92794451e-02f, 1.66280270e-02f, -1.86008774e-02f, -8.92645270e-02f, -1.89417298e-03f,
  1.87318787e-01f, -8.27752501e-02f, -3.51820812e-02f, -1.21816676e-02f, 4.19537015e-02f, -2.47787479e-02f, -5.13865687e-02f, 1.32451132e-02f, 4.96333614e-02f, -6.10201284e-02f,
  -7.04899877e-02f, 2.60412283e-02f, -6.52618110e-02f, 3.20459977e-02f, -8.77356678e-02f, -2.65825316e-02f, -1.25571981e-01f, -8.80710855e-02f, -6.33102432e-02f, 1.88623276e-02f,
  -1.15802415e-01f, -1.18210360e-01f, -1.49022546e-02f, -6.79569039e-03f, 4.38054986e-02f, -1.10810012e-01f, -1.02061152e-01f, -7.73768947e-02f, -1.21623598e-01f, -7.98398852e-02f,
  5.37613081e-03f, 7.02091828e-02f, -6.56073913e-02f, 2.06735749e-02f, 1.15047626e-01f, 1.34356603e-01f, 8.82547796e-02f, 1.40146419e-01f, 6.42102063e-02f, 5.82266934e-02f,
  6.52524969e-03f, 4.64493856e-02f, -1.13182282e-02f, 3.75365056e-02f, 3.27656940e-02f, 1.93958357e-01f, 4.68734652e-02f, 1.51177794e-01f, 4.99109924e-02f, 2.17651539e-02f,
  -4.52363631e-03f, -7.70564303e-02f, 6.69975281e-02f, 8.10062140e-02f, 7.28450716e-02f, -1.09204464e-02f, 3.61619256e-02f, 4.51826267e-02f, -1.88095141e-02f, 5.77431060e-02f,
  -8.23939592e-02f, 2.72033308e-02f, -4.31109816e-02f, -5.29179312e-02f, 7.55880028e-02f, 5.17706387e-02f, 6.02643937e-02f, 2.98229251e-02f, -1.03748627e-01f, -7.28864297e-02f,
  4.36338410e-02f, -1.58946570e-02f, -2.54582055e-02f, 4.09702808e-02f, -5.44507280e-02f, 1.63773727e-02f, 4.66080084e-02f, 7.22317919e-02f, 8.68726447e-02f, -9.02100503e-02f,
  2.98207924e-02f, -6.81994110e-02f, -1.03806019e-01f, 5.01534343e-02f, 1.30655646e-01f, -2.17341166e-02f, -5.96479587e-02f, 5.81620410e-02f, -3.89842317e-02f, 2.62326710e-02f,
  5.27449436e-02f, -4.54938188e-02f, -6.25367165e-02f, 2.81458944e-02f, 3.51195806e-03f, -7.53718391e-02f, 4.29320410e-02f, 8.99485406e-03f, 6.50233701e-02f, 1.73321483e-03f,
  1.86179392e-02f, 5.52118905e-02f, 5.48066869e-02f, -8.41187984e-02f, -7.78821334e-02f, -4.90621291e-02f, -3.08165606e-02f, -6.12501912e-02f, 5.40580153e-02f, -3.59381479e-03f,
  5.97825348e-02f, 5.10470755e-02f, -8.26854259e-02f, 9.55045819e-02f, -7.63788223e-02f, 1.23659112e-02f, 1.66688152e-02f, -7.02917427e-02f, -2.40890551e-02f, 3.77110615e-02f,
  1.04938438e-02f, -7.35379755e-02f, 7.15696886e-02f, 1.01406917e-01f, -3.64941210e-02f, 6.46197004e-03f, 3.74252684e-02f, 3.87360854e-03f, 6.03128634e-02f, -2.28730384e-02f,
  -2.70000249e-02f, 4.69194613e-02f, 7.62937069e-02f, -5.03998250e-02f, -2.70191841e-02f, 4.58861068e-02f, -2.22069211e-02f, 8.73471051e-02f, 8.73372406e-02f, -9.18350145e-02f,
  4.44831979e-03f, -3.71125266e-02f, 4.42844406e-02f, 1.87809928e-03f, 8.68347101e-03f, -1.01688378e-01f, -1.32813558e-01f, 4.24140412e-03f, -8.32384005e-02f, -6.95207641e-02f,
  1.06050812e-01f, 5.78454696e-02f, -8.57463256e-02f, 2.05103010e-02f, -2.19333805e-02f, 1.15153477e-01f, 2.14676503e-02f, 1.20213769e-01f, -4.94244648e-03f, 1.36744946e-01f,
  1.29080445e-01f, 6.54835999e-02f, 8.16413537e-02f, 1.65171415e-01f, -2.10039876e-02f, 7.84467999e-03f, 2.29116548e-02f, 6.72127903e-02f, 9.12956148e-02f, 6.19109608e-02f,
  1.03260845e-01f, 2.75317077e-02f, 2.31504403e-02f, -3.17244790e-02f, 1.03413440e-01f, -1.23823769e-02f, 5.94893880e-02f, 6.25554398e-02f, -2.10010521e-02f, 7.66139701e-02f,
  1.15356676e-01f, 9.81383622e-02f, -1.57227833e-02f, -1.74887218e-02f, 9.53205079e-02f, -1.20626958e-02f, -7.61540309e-02f, 3.76122370e-02f, 1.61189381e-02f, 6.08765967e-02f,
  8.57272744e-02f, 8.56945291e-02f, 5.82227260e-02f, 2.02112272e-02f, 9.77331959e-03f, -8.53279233e-03f, -5.75305521e-02f, 9.94065544e-04f, 6.46871477e-02f, -6.26329258e-02f,
  5.00192344e-02f, -2.39841081e-02f, -6.75181299e-02f, -2.91769411e-02f, 8.14906042e-03f, 1.01590753e-01f, 7.68831447e-02f, -4.35535870e-02f, 3.01496983e-02f, -1.97975244e-02f,
  8.79255682e-02f, -7.54123135e-03f, -2.10136902e-02f, -2.58759242e-02f, 9.52971876e-02f, 1.22004999e-02f, 7.78515264e-02f, 1.90009549e-02f, 5.05409315e-02f, 2.86231712e-02f,
  -1.66994035e-02f, 1.08424574e-01f, 3.76047194e-02f, 5.25775962e-02f, -3.67231444e-02f, -6.15531690e-02f, -6.26657829e-02f, 6.18740823e-03f, 6.13236018e-02f, 1.23555595e-02f,
  -1.06655424e-02f, 4.57588732e-02f, -6.74917623e-02f, -6.79206923e-02f, -4.29370999e-02f, 7.90383965e-02f, -7.32830912e-02f, 3.07831392e-02f, -6.41744509e-02f, 8.76233950e-02f,
  -3.30899679e-03f, -1.16331864e-03f, 7.70760924e-02f, -8.32303055e-03f, -2.66551715e-03f, 3.93886492e-03f, 7.19832703e-02f, -2.88414676e-02f, -4.55866903e-02f, -8.64219591e-02f,
  -6.61354512e-02f, -1.56120153e-03f, 2.49420200e-02f, -2.87612788e-02f, 2.13027298e-02f, 7.86788836e-02f, 3.67024392e-02f, 1.69964526e-02f, 2.37401333e-02f, 7.25673139e-02f,
  -1.37587506e-02f, -5.67896888e-02f, -6.57856241e-02f, -4.30259667e-03f, -3.60893249e-03f, -4.40634787e-02f, 5.64511530e-02f, 2.84234323e-02f, -1.77808404e-02f, -1.11439943e-01f,
  1.26002818e-01f, 8.81006122e-02f, -1.68448612e-02f, 1.44163132e-01f, -1.44626414e-02f, 1.25695709e-02f, -4.01667459e-03f, -2.89706457e-02f, 4.94253496e-03f, 3.74182276e-02f,
  4.54893373e-02f, 4.57444191e-02f, -5.84307611e-02f, 2.59282794e-02f, 1.24476748e-02f, -1.38895372e-02f, 2.49810610e-02f, -1.41327893e-02f, -5.88853545e-02f, -9.34608579e-02f,
  1.81522202e-02f, 6.89367279e-02f, -4.30514067e-02f, -7.31650963e-02f, 1.16255181e-02f, 2.77458131e-03f, -8.79839733e-02f, -7.97016248e-02f, 5.98259158e-02f, -1.20046414e-01f,
  3.27364542e-02f, 1.07834198e-01f, -1.09660007e-01f, 4.77316696e-03f, 4.04438898e-02f, 9.87013504e-02f, -4.44109999e-02f, -5.82267083e-02f, 7.21568614e-02f, -1.98539905e-02f,
  6.89377561e-02f, 6.98749721e-02f, 4.13704291e-02f, -5.07300720e-02f, -3.57081951e-03f, -8.74816105e-02f, 1.17961559e-02f, 4.31252085e-02f, 2.56739892e-02f, 6.27278984e-02f,
  -6.96786046e-02f, -3.35762813e-03f, -1.09314853e-02f, 1.84376929e-02f, -1.59818474e-02f, -7.47213215e-02f, 1.06650256e-02f, -1.03730047e-02f, 6.32306933e-02f, 1.63171794e-02f,
  4.57021445e-02f, -8.45356211e-02f, -7.88126513e-02f, -1.52863124e-02f, 3.31288502e-02f, -6.56854808e-02f, -2.80435327e-02f, 5.23754656e-02f, -8.61220062e-02f, -1.14835612e-02f,
  8.93807337e-02f, 2.62726806e-02f, 3.75364311e-02f, -5.52076995e-02f, 5.21105267e-02f, -1.92685984e-02f, -4.21194956e-02f, -2.01333389e-02f, -7.40539432e-02f, -1.92637276e-02f,
  -6.16544373e-02f, 3.34998854e-02f, 7.00117424e-02f, 5.15583605e-02f, 2.86463983e-02f, 6.31802827e-02f, -1.55120194e-02f, -6.73879981e-02f, 6.00119121e-02f, -3.33507136e-02f,
  -5.29914126e-02f, 1.85032785e-02f, -3.31754722e-02f, 2.24276241e-02f, 3.72762829e-02f, -2.01560138e-03f, 8.28176290e-02f, -3.75439823e-02f, 7.08986595e-02f, 3.23539763e-03f,
  -5.58160059e-02f, -2.09800210e-02f, -3.93028632e-02f, 3.65367383e-02f, -3.94080356e-02f, 5.12716398e-02f, -5.24329990e-02f, 9.85118896e-02f, 8.32018629e-03f, -3.02810501e-02f,
  -5.31015620e-02f, -4.69819009e-02f, 1.01637624e-01f, 5.76966852e-02f, -7.63083249e-02f, 7.41370246e-02f, 1.84115134e-02f, -1.42947841e-03f, -6.32123426e-02f, -4.65897471e-02f,
  -5.20183071e-02f, -6.14634119e-02f, -3.37160341e-02f, 6.96465671e-02f, -4.15920792e-03f, -1.01943754e-01f, -7.25200847e-02f, -5.65106496e-02f, -1.45666394e-03f, 1.94902420e-02f,
  2.02842355e-02f, 1.19816735e-01f, -5.60956895e-02f, 7.62470439e-02f, 5.04450982e-05f, 2.32590865e-02f, 1.24082165e-02f, -1.21159159e-01f, -7.50164464e-02f, -2.47287638e-02f,
  -4.00174223e-02f, -5.78812771e-02f, 2.28268113e-02f, 7.90946707e-02f, -4.05149348e-02f, 6.92499727e-02f, 1.36546670e-02f, 9.62488577e-02f, 8.04787576e-02f, 1.21839873e-01f,
  1.30522922e-01f, 9.63173658e-02f, 4.47831564e-02f, 1.48925325e-02f, -7.45802522e-02f, -4.79272455e-02f, -1.76667552e-02f, -1.15829986e-02f, 6.91591576e-02f, -2.74721291e-02f,
  -5.77448681e-02f, -4.70221303e-02f, 7.08393054e-03f, 1.76195893e-02f, -2.38564182e-02f, -5.16932458e-02f, -3.72203365e-02f, 3.52507047e-02f, -2.08831728e-02f, -2.57705953e-02f,
  9.69443843e-02f, 2.46882848e-02f, 3.93806472e-02f, 6.05680272e-02f, 2.14074012e-02f, 1.10621512e-01f, 1.07962109e-01f, 4.39471118e-02f, 9.62042436e-02f, -4.97824289e-02f,
  -5.17214946e-02f, 1.50915692e-02f, 1.06322788e-01f, -1.51908752e-02f, -2.01545712e-02f, -2.04027500e-02f, -7.49709159e-02f, -4.71135639e-02f, 5.01245409e-02f, -7.14796931e-02f,
  6.11961372e-02f, 6.77976459e-02f, -6.84001669e-02f, -6.13601357e-02f, 1.35904988e-02f, 2.79559530e-02f, -6.29765466e-02f, -7.79488450e-03f, 5.51543757e-02f, 1.04281552e-01f,
  -2.41634641e-02f, 5.51121421e-02f, -8.27985480e-02f, 6.10806756e-02f, 1.31887704e-01f, 9.71101522e-02f, 2.43495665e-02f, 1.15011603e-01f, 7.67736733e-02f, -4.82414337e-03f,
  -6.93950355e-02f, 8.58765561e-03f, -2.55623944e-02f, 7.78034478e-02f, -3.29451449e-02f, -7.57730827e-02f, 1.02038316e-01f, 1.28908409e-02f, 8.55292678e-02f, 7.72782341e-02f,
  -9.47970524e-03f, -1.93650872e-02f, 1.87936109e-02f, 7.61706149e-03f, 6.87931627e-02f, -4.05838573e-03f, 1.32317003e-02f, 5.90045303e-02f, -3.25785540e-02f, 9.23314914e-02f,
  6.77189231e-02f, -3.61953839e-03f, -7.19347689e-03f, 5.80808967e-02f, 5.95276840e-02f, -1.23947300e-02f, -5.85332476e-02f, 2.98848040e-02f, 6.87104166e-02f, -9.52126905e-02f,
  1.21314354e-01f, -4.60472330e-02f, -7.62441754e-02f, 8.32222849e-02f, -4.39319685e-02f, -1.58196073e-02f, 6.40635332e-03f, 1.35797203e-01f, 7.60793462e-02f, -3.23092267e-02f,
  3.73428613e-02f, -6.90625235e-02f, -5.73837273e-02f, -2.69865282e-02f, -5.25821969e-02f, -1.23934858e-01f, -1.71725750e-01f, -1.79315135e-01f, -1.30294636e-01f, -8.26856047e-02f,
  -1.18729211e-01f, -3.52259949e-02f, 2.23658048e-02f, 1.18787609e-01f, 5.86320367e-03f, -7.80084403e-03f, 6.36168346e-02f, -6.69012964e-02f, -2.99786236e-02f, -8.06041881e-02f,
  -1.64653704e-01f, 8.91590938e-02f, -4.71705273e-02f, -7.23125711e-02f, 4.77372073e-02f, 5.06188348e-03f, -1.45406332e-02f, 7.04943016e-02f, 1.39580339e-01f, 8.77325516e-03f,
  1.87827423e-02f, 1.07694961e-01f, 7.74841756e-02f, 8.64315107e-02f, 4.48588468e-03f, -7.90370442e-03f, -2.95178778e-02f, -4.91637588e-02f, -7.71640092e-02f, -1.74326692e-02f,
  -3.85797732e-02f, -9.81466174e-02f, -2.81489156e-02f, 3.93010601e-02f, 5.85567616e-02f, -1.78112108e-02f, 4.92897965e-02f, -1.34702101e-02f, 1.31829707e-02f, 1.11983985e-01f,
  5.15476475e-03f, 6.99065179e-02f, -7.46380910e-02f, 1.14528332e-02f, -5.18680885e-02f, 9.46032554e-02f, 7.11063072e-02f, 1.02319308e-01f, 1.08345546e-01f, 1.20982051e-01f,
  -1.85799934e-02f, -6.05497696e-02f, -6.99221715e-02f, 1.00541890e-01f, 1.06251292e-01f, 6.93800598e-02f, 5.39516360e-02f, 6.24194276e-03f, -6.86622504e-03f, 3.31246573e-03f,
  1.38266245e-02f, 7.60186315e-02f, 5.15967607e-02f, -1.28952879e-02f, -1.80404596e-02f, -4.91551496e-02f, 3.94365564e-02f, -6.68647587e-02f, 1.05946690e-01f, -3.47824302e-04f,
  9.87967476e-02f, -4.17465828e-02f, 4.78005484e-02f, 1.18854009e-02f, 3.39922793e-02f, 5.74326981e-03f, 7.82656968e-02f, 7.99479634e-02f, 1.11198105e-01f, 1.66173074e-02f,
  3.28840651e-02f, 1.07036911e-01f, 1.29952803e-01f, 3.17589357e-03f, 8.79205763e-02f, 4.07667570e-02f, 8.45334530e-02f, -4.21305932e-02f, -5.13323843e-02f, 5.97457290e-02f,
  3.50942090e-02f, 4.09652628e-02f, -5.13246395e-02f, -7.72875994e-02f, 1.59329623e-02f, -3.94709706e-02f, -7.21086934e-02f, 8.43959823e-02f, -5.16051203e-02f, 6.17965451e-03f,
  -1.01383878e-02f, 7.19897673e-02f, -5.51180132e-02f, -1.69631485e-02f, -2.02055126e-02f, 6.85418248e-02f, -6.80133253e-02f, 1.00425102e-01f, 6.99412376e-02f, 1.20044306e-01f,
  -3.35541666e-02f, 4.95250262e-02f, -3.72712016e-02f, 4.94752042e-02f, 6.02985509e-02f, -7.40478337e-02f, -1.54939555e-02f, -3.57455015e-02f, -6.07713908e-02f, 3.04691065e-02f,
  4.76327874e-02f, -7.30346888e-02f, -4.66237478e-02f, -2.33323779e-02f, 6.85384423e-02f, -8.64449218e-02f, -9.28400010e-02f, -3.87806483e-02f, -8.67962837e-02f, -4.85628890e-03f,
  -6.01083115e-02f, 3.70500870e-02f, -9.44826156e-02f, -7.84332678e-02f, 7.77599365e-02f, 7.24988952e-02f, 3.10147312e-02f, -1.52880996e-02f, 4.64331768e-02f, 3.26321274e-02f,
  -8.84073898e-02f, -7.88469464e-02f, 2.89707463e-02f, 3.61235850e-02f, -1.65274031e-02f, -9.54377130e-02f, 1.79724507e-02f, 2.09850185e-02f, -3.52311805e-02f, 3.08235325e-02f,
  8.36981535e-02f, -8.10139403e-02f, 4.87025501e-03f, -3.63455564e-02f, -3.65696624e-02f, 7.02692047e-02f, -3.09601426e-02f, -9.30908248e-02f, -4.33039069e-02f, 4.12496030e-02f,
  -4.47464846e-02f, 8.69632140e-02f, 4.29901630e-02f, -7.47045726e-02f, 4.17842567e-02f, -4.45949771e-02f, -4.92169559e-02f, -1.02696896e-01f, -5.76126426e-02f, -5.34747206e-02f,
  -3.97587055e-03f, 7.20835477e-02f, -5.98905049e-02f, 3.80868502e-02f, 7.41019025e-02f, 7.83500448e-02f, -9.06740129e-02f, -4.81612757e-02f, 8.80651921e-03f, -8.67251903e-02f,
  -1.27733825e-02f, -1.05938941e-01f, -3.86219732e-02f, -7.20223635e-02f, -9.34566781e-02f, -6.25045039e-03f, 3.91925722e-02f, -8.87589380e-02f, 7.95572773e-02f, -8.05880800e-02f,
  -2.50867922e-02f, -7.77747855e-02f, 3.93652581e-02f, -1.63022224e-02f, 6.71584904e-02f, -5.83952479e-02f, -5.14068864e-02f, 3.33398506e-02f, 1.97307393e-02f, 4.67963777e-02f,
  1.08065177e-02f, -9.85451788e-02f, 4.00356539e-02f, -9.79473591e-02f, 6.99314428e-03f, -2.22146884e-02f, -5.30411005e-02f, -5.22634648e-02f, -4.81185317e-03f, -5.72294230e-04f,
  -2.98909470e-02f, -4.35625985e-02f, 2.25622728e-02f, -4.43177894e-02f, -1.65880006e-02f, -6.19508997e-02f, -7.92645290e-02f, -3.28782052e-02f, -1.85725857e-02f, 2.38426980e-02f,
  9.25783440e-02f, 9.24934670e-02f, 5.05298413e-02f, -2.22728383e-02f, 1.62115455e-01f, 4.20662090e-02f, 6.72391653e-02f, 1.33432001e-01f, 9.46375802e-02f, -7.91607797e-03f,
  -3.68845910e-02f, -3.16086821e-02f, -1.76983816e-03f, -6.68598786e-02f, 5.88311628e-03f, 2.35317424e-02f, 3.80223170e-02f, 1.03206001e-02f, 1.12018615e-01f, -5.70498966e-02f,
  7.11427033e-02f, -4.08911668e-02f, -7.00663701e-02f, -5.84847964e-02f, 2.13110708e-02f, -1.30422255e-02f, -5.31988703e-02f, -7.12116137e-02f, 9.15733352e-02f, -6.84727505e-02f,
  -8.27240720e-02f, 1.65819731e-02f, 1.21144079e-01f, -8.05902332e-02f, 1.02981277e-01f, -7.17058629e-02f, -3.77658047e-02f, -6.19874708e-02f, 7.71325529e-02f, -5.58002889e-02f,
  5.46181910e-02f, 6.00111671e-02f, 9.19313915e-03f, -6.90527335e-02f, -1.10104971e-03f, 9.61754844e-02f, 4.01592590e-02f, 9.35638025e-02f, -7.35944435e-02f, -5.58666885e-03f,
  -7.51285553e-02f, 1.35188460e-01f, -4.15943228e-02f, 6.88598007e-02f, -3.51879969e-02f, -4.39290367e-02f, -3.02717220e-02f, 3.99539061e-02f, 5.66675365e-02f, -6.00099787e-02f,
  -8.50532576e-02f, -5.28169498e-02f, 4.68206257e-02f, 1.26606633e-03f, -4.24150489e-02f, 4.12484966e-02f, 2.42970195e-02f, 6.63757324e-03f, 5.70936427e-02f, 6.48766160e-02f,
  2.00222768e-02f, -1.06089348e-02f, 2.82099806e-02f, 5.49442731e-02f, 8.11366662e-02f, 7.11496025e-02f, -1.84314772e-02f, 5.90499565e-02f, -8.74860503e-04f, -8.10873210e-02f,
  -5.09617291e-02f, -1.90042034e-02f, -3.97953056e-02f, -1.58791114e-02f, 5.27055822e-02f, 7.07763387e-03f, -8.80936757e-02f, 1.76915117e-02f, 3.33202370e-02f, 3.73241231e-02f,
  -7.91534036e-02f, 9.40534100e-02f, -7.09449574e-02f, -3.76170613e-02f, -1.53658707e-02f, 2.78346855e-02f, 5.61959594e-02f, -7.52165020e-02f, -1.34095168e-02f, 6.93207374e-03f,
  2.48882473e-02f, -8.60630069e-03f, 8.74008611e-02f, 6.54758289e-02f, 1.00924477e-01f, -4.85779904e-02f, -9.03329104e-02f, 6.49580881e-02f, -5.46077937e-02f, 1.57052875e-02f,
  -2.84153800e-02f, 8.06988552e-02f, 1.02817737e-01f, 6.32348582e-02f, -5.40020205e-02f, 7.82079250e-02f, -1.02976998e-02f, -5.91977537e-02f, 8.69321972e-02f, 6.76141530e-02f,
  -3.18908721e-01f, 6.12036139e-02f, -1.70842074e-02f, -7.77923092e-02f, 9.71639976e-02f, 7.80002996e-02f, 1.84472531e-01f, -2.08721776e-02f, -8.22285265e-02f, 8.31182450e-02f,
  1.78634701e-03f, -8.28007385e-02f, -1.02896476e-02f, -3.72518995e-03f, -8.50555394e-03f, 1.23551458e-01f, 1.15756020e-01f, 6.82808533e-02f, -8.43854025e-02f, 6.42689094e-02f,
  9.31156576e-02f, -1.60658464e-01f, -1.23168878e-01f, -1.01054087e-01f, 5.09684049e-02f, -6.71728179e-02f, -5.25725633e-02f, -4.97381762e-02f, 5.31792901e-02f, 2.47450128e-01f,
  -2.69050170e-02f, -5.95137514e-02f, -1.21733457e-01f, 2.21969057e-02f, -1.51818544e-02f, 4.04556282e-02f, 8.30944628e-02f, -6.25385717e-02f, -3.32319736e-02f, 3.72231156e-02f,
  -2.68797874e-02f, 6.89282864e-02f, 1.05318548e-02f, 1.95668880e-02f, 3.02346814e-02f, 5.29872179e-02f, -1.39330834e-01f, -1.99119076e-02f, -1.26956969e-01f, -1.27415694e-02f,
  1.76784232e-01f, 2.43361071e-02f, -1.67445898e-01f, 5.54698799e-03f, -8.62114653e-02f, -1.37440264e-01f, -6.45558685e-02f, -5.57289124e-02f, -8.39444697e-02f, -6.83352798e-02f,
  4.00935300e-02f, -6.54583797e-02f, -1.03220187e-01f, 6.40172046e-04f, 8.82201344e-02f, -2.63387784e-02f, 9.50753838e-02f, 7.26412758e-02f, 3.55023704e-02f, 5.79813905e-02f,
  1.16785085e-02f, -6.63046762e-02f, -4.81673628e-02f, -7.84336999e-02f, 2.83875689e-02f, -2.28191074e-02f, -1.66871846e-02f, 7.72293881e-02f, -2.02498101e-02f, 1.61566795e-03f,
  6.33118525e-02f, 2.25214809e-02f, -5.85327782e-02f, 1.13596447e-01f, 1.05884515e-01f, -5.61978184e-02f, -5.35585098e-02f, -9.38729849e-03f, -1.08822644e-01f, 3.39343511e-02f,
  -2.74012834e-01f, 1.15799755e-02f, 3.01375729e-03f, -7.00128153e-02f, -6.37395829e-02f, -3.98368778e-04f, -6.62785023e-02f, -4.06204984e-02f, 2.67638639e-02f, -8.14474747e-02f,
  5.16603105e-02f, 1.57276485e-02f, -9.29298401e-02f, 3.88135761e-02f, -1.00361884e-01f, -1.15667302e-02f, -8.49509016e-02f, 2.32988130e-02f, 6.69771479e-03f, -9.85256210e-02f,
  -4.61633019e-02f, -1.18218571e-01f, -1.58718958e-01f, -1.49483263e-01f, 2.10642262e-04f, -1.80181950e-01f, -1.86939895e-01f, -1.07322298e-01f, -1.93820029e-01f, -1.38833135e-01f,
  7.39682093e-02f, 9.94930626e-04f, -9.75358635e-02f, 2.49886233e-02f, 1.05994456e-02f, -9.36165154e-02f, 2.50545535e-02f, 1.16041243e-01f, -5.32962047e-02f, 1.46247605e-02f,
  7.43244588e-02f, -1.21524883e-02f, 1.46300914e-02f, -9.09771249e-02f, -3.89945731e-02f, -1.22262493e-01f, -1.48165554e-01f, 2.98041422e-02f, 2.11504344e-02f, -2.92678401e-02f,
  -6.60381988e-02f, -8.31939057e-02f, 2.57677082e-02f, 6.27975613e-02f, -1.28097218e-02f, -2.81848595e-03f, -7.71660954e-02f, -1.67470705e-02f, -5.91702238e-02f, -1.32743895e-01f,
  -1.67512611e-01f, -3.45927812e-02f, -4.18749601e-02f, 3.41044962e-02f, 7.71607310e-02f, -3.40510234e-02f, 3.36153731e-02f, 4.89139408e-02f, 3.05258241e-02f, -6.78602532e-02f,
  1.47740077e-02f, 9.52519402e-02f, 7.00510964e-02f, 8.55840296e-02f, 9.75134224e-02f, -4.61201072e-02f, 6.92630932e-02f, 4.16121520e-02f, 1.05326883e-01f, 1.45327263e-02f,
  -3.54819410e-02f, 2.77953409e-02f, 1.07546270e-01f, -5.22021130e-02f, -3.37443389e-02f, -7.42667262e-03f, 2.90538110e-02f, 1.03989638e-01f, 1.03676662e-01f, -5.24706356e-02f,
  -1.11716606e-01f, -3.86251248e-02f, 3.37592103e-02f, 7.30201378e-02f, 5.04710935e-02f, -1.62327271e-02f, -2.00417750e-02f, -4.63153189e-03f, 5.14237434e-02f, -6.36711111e-03f,
  -1.48200439e-02f, -5.97798489e-02f, -6.44385144e-02f, 1.24591226e-02f, 7.71906180e-03f, -5.93869388e-02f, -2.58682370e-02f, -7.46838003e-02f, -4.93857786e-02f, -5.07086851e-02f,
  -2.66216863e-02f, 3.92952897e-02f, -4.34552506e-03f, 3.86445038e-03f, -6.52017444e-02f, 5.83874714e-03f, 5.98142296e-02f, -3.68508860e-03f, -3.37307192e-02f, 7.37542063e-02f,
  2.81305388e-02f, 5.71903661e-02f, 4.38208506e-02f, -5.17135747e-02f, 6.90276325e-02f, 3.95917334e-02f, 6.88459873e-02f, 1.06861018e-01f, -4.47250009e-02f, -9.21016186e-02f,
  -2.99141463e-02f, -8.22122861e-03f, -9.05269161e-02f, -7.46061429e-02f, -7.77585059e-02f, 9.43713076e-03f, 7.38924518e-02f, -2.76560765e-02f, 3.47846420e-03f, -4.52103019e-02f,
  -1.40990177e-02f, 4.05027904e-02f, 9.25159380e-02f, -3.01438309e-02f, 2.32758261e-02f, 2.68948171e-02f, -1.01017147e-01f, 2.71798521e-02f, 3.02894004e-02f, 6.00167587e-02f,
  -5.98160848e-02f, -7.13542402e-02f, 7.83651620e-02f, -3.50650251e-02f, 2.28083059e-02f, -5.93079962e-02f, -2.19810829e-02f, 3.72705795e-02f, 2.35951096e-02f, -6.12186529e-02f,
  -7.63136223e-02f, 7.72946328e-02f, 1.08323015e-01f, 6.87985346e-02f, 9.54798162e-02f, 8.01756606e-03f, 9.78951603e-02f, 3.17031480e-02f, -3.13753448e-02f, 4.84116785e-02f,
  8.51037651e-02f, 2.43218616e-02f, 7.47907460e-02f, 6.52543828e-02f, 2.31452268e-02f, -6.10082410e-02f, 5.07825799e-03f, -6.17662184e-02f, -2.96522491e-02f, 1.47885427e-01f,
  7.62224868e-02f, -1.18997909e-01f, -1.79805830e-02f, 4.44245972e-02f, 3.89039069e-02f, -8.02194178e-02f, -5.54597378e-02f, -2.56894175e-02f, 4.58783507e-02f, 4.77975011e-02f,
  -2.26291362e-02f, 4.42871936e-02f, 3.93550992e-02f, -5.73361777e-02f, -2.54734363e-02f, -1.23099871e-02f, -5.90249635e-02f, -1.58964787e-02f, -6.60697045e-03f, 7.77349472e-02f,
  3.50249372e-02f, 8.50469843e-02f, 5.92892990e-02f, -4.38101916e-03f, -6.45269826e-02f, -6.00050353e-02f, 6.76155165e-02f, -3.84084582e-02f, -3.49133983e-02f, -3.65464836e-02f,
  6.43395931e-02f, -3.11980862e-02f, 2.55409591e-02f, 8.44630674e-02f, 2.57145893e-02f, 1.05328344e-01f, -1.65558718e-02f, -6.53014034e-02f, -6.73847273e-02f, 7.42472783e-02f,
  1.72368158e-02f, -5.51836565e-04f, 6.06017374e-02f, -8.18538144e-02f, 1.39439022e-02f, -6.19469173e-02f, 4.09138156e-03f, 2.94949161e-03f, -4.85239998e-02f, -7.13805258e-02f,
  -3.51187810e-02f, -5.60072549e-02f, -5.06472588e-02f, -5.92382140e-02f, 8.24217051e-02f, 5.00505529e-02f, -2.53357049e-02f, 7.18855262e-02f, 8.33777934e-02f, -5.56187555e-02f,
  5.43850735e-02f, -3.65742184e-02f, 5.46799153e-02f, 4.07978147e-02f, 6.33639768e-02f, -6.07756861e-02f, -1.94895472e-02f, 7.79065304e-03f, -1.26593495e-02f, -9.17907432e-02f,
  4.82739620e-02f, 7.55064189e-02f, 7.28028715e-02f, -4.09728065e-02f, -9.58233923e-02f, -2.30658688e-02f, -6.12222180e-02f, -5.49714901e-02f, 2.61165667e-02f, -1.70517117e-02f,
  3.70228924e-02f, -9.90737602e-02f, 2.30378211e-02f, -9.95315611e-04f, 3.28085721e-02f, 2.00329702e-02f, 2.50648614e-02f, -1.28852911e-02f, -1.05748512e-01f, -7.13702291e-02f,
  -1.08895406e-01f, -9.14482102e-02f, -1.89891711e-01f, -8.15764889e-02f, -7.67288581e-02f, -9.93647799e-03f, -1.12176403e-01f, 6.99653178e-02f, 1.18728075e-03f, -6.97780475e-02f,
  6.11487813e-02f, 6.51795864e-02f, -8.48243758e-02f, -3.09579391e-02f, 4.86414842e-02f, -1.92568153e-01f, -1.51497155e-01f, -6.70039952e-02f, 6.25595674e-02f, 3.72106880e-02f,
  1.21805102e-01f, -1.22237608e-01f, -8.06023479e-02f, -3.87546234e-02f, 6.96994439e-02f, -3.14232707e-02f, -1.76381439e-01f, 8.89490265e-03f, -4.70112590e-03f, -1.84490144e-01f,
  -8.74013007e-02f, 3.55618857e-02f, -4.98865545e-02f, 6.02546334e-02f, -2.35825274e-02f, -2.10717954e-02f, 7.05004930e-02f, -3.55228223e-02f, -3.83638330e-02f, -6.58896714e-02f,
  6.47712722e-02f, -6.76402077e-03f, 5.35815358e-02f, -4.91891205e-02f, -8.24790150e-02f, 3.08773946e-02f, 3.46768238e-02f, -3.45329307e-02f, -1.96953807e-02f, -1.48433251e-02f,
  1.02291619e-02f, 1.03944257e-01f, -7.69908540e-04f, 9.29211006e-02f, -2.75850259e-02f, 8.44382867e-02f, 1.16161466e-01f, 1.26062155e-01f, 2.61318957e-04f, 2.53216606e-02f,
  4.62243974e-04f, 7.66794905e-02f, 1.83330923e-02f, -3.85082662e-02f, 7.84586594e-02f, 7.95967132e-03f, -5.59048308e-03f, 4.50388044e-02f, 6.54365569e-02f, -5.95340542e-02f,
  -5.30780032e-02f, 1.81429442e-02f, 3.81105095e-02f, 1.75595302e-02f, 5.59640005e-02f, 5.71398623e-02f, -3.81532162e-02f, -5.99804036e-02f, -2.98785605e-02f, 1.62319411e-02f,
  7.91241240e-04f, -3.06929927e-03f, -3.28889526e-02f, 4.59519736e-02f, 4.90154363e-02f, -1.73097979e-02f, 4.79126163e-02f, -3.77313495e-02f, -1.04070213e-02f, -4.50664870e-02f,
  -3.74024510e-02f, 5.52151212e-03f, -3.30127738e-02f, 1.21028796e-01f, -1.44933639e-02f, -1.96687561e-02f, -3.22521180e-02f, 3.11470125e-02f, 2.23061834e-02f, 2.66602617e-02f,
  3.12538557e-02f, 3.45003717e-02f, -7.52944797e-02f, 4.93471958e-02f, 3.50049920e-02f, 4.97156456e-02f, -7.72502199e-02f, -9.54864100e-02f, 7.44104162e-02f, -4.75848727e-02f,
  5.46505786e-02f, -8.55894536e-02f, 5.65019175e-02f, 7.15516321e-03f, 1.93638913e-02f, -1.85668562e-02f, 1.77155547e-02f, 9.17109624e-02f, 2.18246896e-02f, -1.08410656e-01f,
  -2.02393472e-01f, -1.05479345e-01f, -8.27765167e-02f, -2.33734548e-02f, 4.87874746e-02f, 3.27957422e-02f, -9.57036763e-02f, -4.74676602e-02f, -3.42738256e-02f, -3.31394114e-02f,
  -1.83619950e-02f, 4.56011184e-02f, -6.80906326e-02f, -2.76059750e-02f, -2.22620983e-02f, -6.53490201e-02f, -2.45293975e-02f, -1.24398004e-02f, -7.87499696e-02f, 8.67308229e-02f,
  1.01345025e-01f, -6.94316328e-02f, -1.45774735e-02f, -1.81249399e-02f, -3.24856974e-02f, -6.88412040e-02f, -1.89211890e-01f, 4.49538883e-03f, -4.23694439e-02f, -3.90063263e-02f,
  -2.92840898e-02f, 5.40376790e-02f, 1.04208492e-01f, 2.19726339e-02f, -7.85505623e-02f, 6.51138322e-03f, 1.74680667e-04f, -1.42843928e-02f, 3.06661390e-02f, -4.83393148e-02f,
  6.74237460e-02f, 7.83019811e-02f, -6.75536320e-02f, 5.66149727e-02f, -1.58554502e-02f, 7.47894272e-02f, 7.68013299e-02f, 6.45878986e-02f, -7.41313919e-02f, 6.08499385e-02f,
  -7.15355277e-02f, -1.03790484e-01f, -8.17893818e-02f, 5.05239423e-03f, 4.64483313e-02f, -9.30681378e-02f, 2.43285112e-03f, 1.45038264e-03f, -9.52869952e-02f, -1.58484781e-03f,
  8.81918073e-02f, 1.10304356e-01f, -2.97351629e-02f, -9.04386956e-03f, 3.74182053e-02f, -5.90530224e-02f, 2.76675969e-02f, 6.29815012e-02f, 7.34507665e-02f, 7.17964619e-02f,
  5.35629168e-02f, 7.31812865e-02f, 4.09625769e-02f, 4.57171304e-03f, 5.73610254e-02f, 1.36936503e-02f, 4.36496846e-02f, -6.87772706e-02f, 1.56998970e-02f, 6.46844581e-02f,
  -1.56490225e-02f, 6.22280389e-02f, 1.07364811e-01f, 3.54562700e-02f, -2.99003161e-02f, 3.48726287e-02f, 8.20808336e-02f, 1.00687340e-01f, 3.50968502e-02f, 9.32161734e-02f,
  -4.79528978e-02f, 3.50491628e-02f, -4.30428889e-03f, -9.13198143e-02f, 7.13998899e-02f, 5.66803217e-02f, -4.81938049e-02f, -1.59510039e-02f, 9.84190330e-02f, -9.76889655e-02f,
  1.82762332e-02f, 1.09192012e-02f, -7.99869150e-02f, -2.29546912e-02f, -1.44865615e-02f, -4.64775227e-02f, -4.10339870e-02f, -9.95653421e-02f, 6.42433539e-02f, 2.67450716e-02f,
  8.30858573e-03f, -1.11473285e-01f, -4.41506281e-02f, -5.72820678e-02f, -1.02843314e-01f, -3.80185172e-02f, -1.46278217e-01f, -7.07601905e-02f, -1.08621478e-01f, -1.21047281e-01f,
  1.19694442e-01f, 2.75564939e-03f, 1.17577918e-01f, -2.78924350e-02f, 1.15465978e-02f, -1.66923016e-01f, -1.34942338e-01f, -2.14955974e-02f, -5.52863218e-02f, -4.50984947e-02f,
  -7.64091760e-02f, 1.05524600e-01f, 1.06859297e-01f, 1.39638871e-01f, 7.15935528e-02f, -7.77805317e-03f, 7.39312991e-02f, 6.27303049e-02f, 9.32267532e-02f, 8.99490027e-04f,
  6.19649962e-02f, 5.30291684e-02f, 9.58429947e-02f, 6.75925845e-03f, 4.19619828e-02f, -8.38682149e-03f, 8.00443366e-02f, 1.04790116e-02f, 5.82029633e-02f, 2.33741730e-01f,
  1.58110689e-02f, -1.46761313e-02f, 5.12391999e-02f, 8.13551992e-02f, -1.26678115e-02f, -6.73003495e-02f, 2.73147430e-02f, 5.75659843e-03f, -7.07642883e-02f, 2.87490692e-02f,
  4.96351421e-02f, 6.48336783e-02f, -9.29651689e-03f, -4.03127447e-02f, -5.08747296e-04f, 1.14302030e-02f, 5.05829528e-02f, -3.63200009e-02f, -8.04520398e-02f, 4.21071127e-02f,
  1.76706221e-02f, 5.68762682e-02f, -7.21755847e-02f, -7.73106068e-02f, 4.95164841e-02f, 5.47036016e-03f, -6.22908175e-02f, 1.10534735e-01f, 8.11426342e-02f, -4.55972664e-02f,
  -1.03978746e-01f, -3.09316795e-02f, -7.95097277e-02f, -2.05520354e-02f, -8.47235844e-02f, -3.15963328e-02f, -6.16544262e-02f, 2.57547330e-02f, -2.59997267e-02f, -6.68410882e-02f,
  1.30282883e-02f, 9.05757304e-03f, 7.20320791e-02f, 1.78532172e-02f, -1.44936899e-02f, 4.16936986e-02f, 2.91609522e-02f, -7.29656890e-02f, 3.88283208e-02f, 6.49065152e-02f,
  -5.37393987e-02f, 4.97857556e-02f, -2.26066783e-02f, -3.68857794e-02f, 1.29281208e-02f, -3.87137234e-02f, 6.53484911e-02f, 2.91838832e-02f, -1.45900100e-02f, -9.71369147e-02f,
  3.02285887e-03f, -5.79050928e-02f, 1.15085125e-01f, 1.10700335e-02f, 1.36243045e-01f, 1.01963744e-01f, -3.95817831e-02f, 9.28045884e-02f, 6.74681291e-02f, 5.33727184e-02f,
  1.05670959e-01f, -4.66013215e-02f, -4.83716801e-02f, -3.71121615e-02f, 7.15866908e-02f, -2.05094311e-02f, -9.83698759e-03f, -2.97594792e-03f, -5.23485802e-03f, -6.57044947e-02f,
  7.69724771e-02f, -6.31217733e-02f, -5.03245108e-02f, -1.06177479e-01f, 2.44905520e-02f, 3.87380482e-03f, -1.24501353e-02f, 2.78939959e-03f, -7.02368990e-02f, -1.13452896e-01f,
  -1.64973959e-01f, 6.73808679e-02f, 6.43724576e-02f, 1.68424137e-02f, -3.35211456e-02f, -1.56986807e-02f, 2.22839620e-02f, 6.66599050e-02f, 2.72628665e-02f, -3.78707275e-02f,
  7.92131945e-02f, -5.01865484e-02f, 6.37507066e-02f, 5.66482656e-02f, 2.85713542e-02f, 7.29071572e-02f, -6.10171668e-02f, -7.47047141e-02f, -4.37836535e-02f, 6.38183504e-02f,
  -4.15722989e-02f, -3.60734090e-02f, 2.25152485e-02f, -9.34430137e-02f, 2.95440964e-02f, -5.67171536e-02f, -4.27534655e-02f, 5.42930178e-02f, -2.88822595e-02f, -4.38899137e-02f,
  1.76990509e-01f, -8.78728926e-02f, 2.29651202e-02f, 4.85041150e-04f, -2.83437297e-02f, -1.08994246e-01f, -1.40187843e-02f, 5.21744043e-03f, -6.29110932e-02f, 5.81709519e-02f,
  5.91036938e-02f, 4.75087054e-02f, 3.13999392e-02f, 8.45747348e-03f, 5.98741472e-02f, 8.99204239e-02f, -5.77826099e-03f, -2.35073194e-02f, 9.67949629e-02f, -2.72251423e-02f,
  5.74530214e-02f, 1.26260361e-02f, 2.77119782e-02f, 7.04604462e-02f, 7.29151741e-02f, 8.71656016e-02f, 5.40367253e-02f, 4.79446026e-03f, 4.82654758e-02f, -2.16583768e-03f,
  3.48990560e-02f, -1.28692454e-02f, 7.29663000e-02f, -5.35309054e-02f, -5.48324138e-02f, -4.04568836e-02f, -5.20624034e-02f, 6.55996427e-02f, -6.30042329e-02f, -8.61371905e-02f,
  1.02986395e-01f, 5.97166941e-02f, -6.03400879e-02f, -6.45859614e-02f, -2.44518332e-02f, 3.98516133e-02f, -7.25275204e-02f, 1.11850441e-01f, -5.77126071e-02f, 9.04467627e-02f,
  -2.27730088e-02f, 5.02486005e-02f, 3.62688452e-02f, 7.71233290e-02f, -1.91462003e-02f, -3.77674252e-02f, -4.21260335e-02f, 2.48512463e-03f, -5.94810881e-02f, -5.32470047e-02f,
  8.76160488e-02f, -1.03607208e-01f, 1.21860830e-02f, -4.06850204e-02f, -5.15273623e-02f, 5.77747449e-02f, -7.04286844e-02f, -7.97562418e-04f, -4.98671317e-03f, 8.79585370e-02f,
  8.67340639e-02f, -8.22062120e-02f, 5.98715134e-02f, 2.55622379e-02f, 6.44265935e-02f, -1.95867922e-02f, -4.60281558e-02f, 7.26492330e-02f, 2.36515924e-02f, 3.50161456e-02f,
  5.80164194e-02f, 6.36008233e-02f, 4.35232790e-03f, 1.46311987e-02f, -6.95539191e-02f, 1.58439837e-02f, 7.45780692e-02f, 9.77534056e-02f, -2.27162638e-03f, 1.10024378e-01f,
  -2.20499620e-01f, -4.81032655e-02f, -1.15797725e-02f, -1.31531879e-01f, -5.07691316e-02f, 6.73034415e-02f, 1.37112409e-01f, 3.82805988e-02f, -1.28208980e-01f, -7.25273862e-02f,
  6.93553016e-02f, 4.95941602e-02f, 1.43273491e-02f, -1.17936935e-02f, 4.68917862e-02f, 2.83065103e-02f, -7.17652589e-02f, 8.21600333e-02f, 1.79483384e-01f, 1.12440512e-01f,
  5.31735271e-02f, -7.86288008e-02f, -3.41902189e-02f, -6.25669062e-02f, -3.77207659e-02f, 1.56429306e-01f, -6.34154528e-02f, -6.56817853e-02f, -1.62605047e-02f, -9.89388791e-04f,
  3.88935655e-01f, -1.66303113e-01f, 3.33132930e-02f, -1.09314747e-01f, 1.94590297e-02f, -5.55811562e-02f, -2.32628565e-02f, 4.82821427e-02f, -1.38245635e-02f, 9.55851004e-02f,
  3.52572389e-02f, -5.34858480e-02f, 1.39899813e-02f, -6.72710165e-02f, 1.10062808e-01f, 7.54502937e-02f, -8.80001187e-02f, -8.01299959e-02f, -2.77553480e-02f, 1.02212660e-01f,
  7.05092251e-02f, -2.84832194e-02f, 5.22734858e-02f, 7.95551762e-02f, 1.78994834e-02f, -2.39346344e-02f, 6.93927258e-02f, -4.47073281e-02f, -4.61733325e-05f, 9.74117666e-02f,
  -7.20975474e-02f, 8.29853341e-02f, -1.27386954e-02f, -1.12163071e-02f, 1.08855709e-01f, 8.89113769e-02f, -4.69389483e-02f, 1.67521447e-01f, -1.61994882e-02f, 1.39205739e-01f,
  -7.86856636e-02f, -3.14812660e-02f, 7.18093896e-03f, 5.23842126e-02f, 7.33567402e-02f, -1.75644271e-02f, -8.60547796e-02f, 3.01002581e-02f, 3.05375066e-02f, -3.34079228e-02f,
  -4.82683852e-02f, -4.81882803e-02f, 4.91021872e-02f, 5.78391068e-02f, -1.04461543e-01f, -5.17279990e-02f, -6.71858490e-02f, -7.04944283e-02f, 5.44787981e-02f, -2.72957720e-02f,
  1.38743997e-01f, -2.04445675e-01f, -4.39123027e-02f, 8.85287207e-03f, -1.20802922e-02f, -1.43125197e-02f, -1.15404548e-02f, -1.07427528e-02f, -4.67585884e-02f, -4.40532565e-02f,
  7.80274114e-03f, 1.62693625e-03f, 5.42898849e-02f, 3.01710349e-02f, 4.86861877e-02f, -3.13096195e-02f, -5.61569221e-02f, 9.99906734e-02f, -7.42220581e-02f, 2.92852782e-02f,
  -1.18389577e-01f, 1.09481663e-01f, 4.69892062e-02f, 1.22778930e-01f, 8.75569582e-02f, 6.29780069e-02f, 1.89479873e-01f, 4.55915183e-02f, 4.85161915e-02f, 1.75435171e-01f,
  7.73941725e-02f, 7.47627094e-02f, 1.49445394e-02f, -4.58612852e-02f, -1.09967537e-01f, -9.18934047e-02f, -7.19521642e-02f, -5.41658364e-02f, 1.21531053e-03f, -4.79028448e-02f,
  2.48507056e-02f, 1.16214968e-01f, 1.29658103e-01f, 4.18878831e-02f, 5.83108887e-02f, -8.92995223e-02f, -7.13891163e-02f, 1.11741200e-01f, 3.25331129e-02f, 4.70558228e-03f,
  4.94788475e-02f, 1.41695037e-01f, 1.69028267e-01f, 4.64297906e-02f, -1.37069589e-02f, -3.49007025e-02f, -3.03121936e-02f, 1.36275738e-01f, 8.04987550e-02f, 2.58772485e-02f,
  -4.01158743e-02f, 7.92520959e-03f, -9.71125141e-02f, 6.15752749e-02f, 2.56183166e-02f, 1.30310254e-02f, -9.40932855e-02f, -1.94172990e-02f, 8.56248662e-02f, 9.28629115e-02f,
  -8.87733512e-03f, 4.19364423e-02f, -1.39855845e-02f, -1.02588916e-02f, -7.21179601e-03f, -7.81421810e-02f, 6.98869899e-02f, 7.98691064e-02f, 3.68146300e-02f, -4.89107557e-02f,
  1.48443095e-02f, 6.60105944e-02f, 3.73753496e-02f, 4.63631526e-02f, -9.74819437e-02f, -1.14740944e-03f, 2.21368764e-02f, 3.02006789e-02f, 4.31572720e-02f, 7.94164166e-02f,
  -8.72416887e-03f, 2.97017838e-03f, 2.41919197e-02f, 8.45747069e-02f, 6.13896362e-02f, -6.91895634e-02f, 5.01836687e-02f, -3.91158760e-02f, -8.32517818e-02f, 6.69551268e-02f,
  4.44212817e-02f, 6.20439574e-02f, -2.83816140e-02f, 1.53625151e-02f, -8.01636204e-02f, -5.78080602e-02f, 5.60737215e-04f, 7.38014951e-02f, 5.10022752e-02f, 2.79826187e-02f,
  5.70615986e-03f, 4.97849211e-02f, 2.25505959e-02f, -6.73954561e-02f, 2.57955380e-02f, -1.34609705e-02f, -2.64179166e-02f, -1.59424730e-02f, 2.58817337e-02f, -1.73353907e-02f,
  -1.06145233e-01f, -4.32508625e-03f, 5.30508272e-02f, 4.79551330e-02f, -5.14688790e-02f, -3.30183581e-02f, 1.45532656e-02f, -5.66247944e-03f, -5.52783571e-02f, 3.41535993e-02f,
  3.67463976e-02f, -4.10604924e-02f, -2.87761409e-02f, 3.18980552e-02f, -5.01586869e-02f, 8.40605497e-02f, -4.43389639e-02f, -1.59541592e-02f, 4.27160524e-02f, 2.58360757e-03f,
  -7.06482828e-02f, -1.15691215e-01f, -1.38098123e-02f, 2.84171253e-02f, -4.67836261e-02f, 2.95252632e-02f, -4.63349856e-02f, -2.37613488e-02f, -3.35610509e-02f, 6.73822761e-02f,
  -1.82876617e-01f, -2.16037080e-01f, -1.76122084e-01f, -9.51467827e-02f, 3.68435942e-02f, 3.27799357e-02f, -1.82126880e-01f, 6.45282269e-02f, 6.44805506e-02f, -2.35495940e-01f,
  -3.76348123e-02f, 8.23005661e-02f, -6.07940853e-02f, 4.39794883e-02f, -1.15714975e-01f, -2.74639785e-01f, -1.86582983e-01f, -7.21938312e-02f, 1.83393344e-01f, 2.82142937e-01f,
  -7.59493234e-03f, -8.52733999e-02f, 2.19381675e-02f, 1.39989361e-01f, -1.01415262e-01f, -4.28522304e-02f, -1.81639448e-01f, -1.43287271e-01f, -7.50253722e-02f, -2.90741146e-01f,
  -2.28095993e-01f, -7.50279473e-03f, 4.16977108e-02f, 2.33023074e-02f, -4.48290147e-02f, 7.00047165e-02f, -1.60790025e-03f, -2.57361103e-02f, -2.17977669e-02f, 6.99166954e-02f,
  -1.51471496e-02f, 2.73436327e-02f, 7.65583590e-02f, 7.41846114e-02f, 8.66373535e-03f, 6.23653345e-02f, 1.28344253e-01f, 5.44024631e-02f, 4.97186743e-02f, 9.20533761e-02f,
  -7.39414664e-03f, 9.57106501e-02f, 2.20735800e-02f, 5.72668202e-02f, 1.06705867e-01f, -8.38582125e-03f, 3.10111009e-02f, 5.57106882e-02f, -7.27604926e-02f, -2.16875583e-01f,
  1.09139197e-02f, -2.07616761e-02f, -6.70840219e-02f, 2.89041530e-02f, 3.99831757e-02f, 3.55668478e-02f, -4.24847566e-02f, -1.01932883e-01f, 6.21398240e-02f, -1.73953734e-02f,
  7.69865662e-02f, -5.68554923e-02f, -1.89154688e-02f, -1.93591155e-02f, -8.79215542e-03f, -4.93036248e-02f, -4.84303720e-02f, -8.06931872e-03f, -6.85688704e-02f, 5.17551228e-02f,
  5.03400229e-02f, -1.34073058e-02f, -2.61200755e-03f, -2.01604906e-02f, 2.54428815e-02f, 3.59959416e-02f, -6.77184612e-02f, 3.14432234e-02f, 4.85135466e-02f, 1.81024559e-02f,
  -6.19487204e-02f, -6.75989687e-02f, -1.63924500e-01f, -3.65311243e-02f, -6.58785626e-02f, 6.47359639e-02f, -5.44125922e-02f, 5.95500402e-04f, -9.76458937e-03f, -3.65105607e-02f,
  1.07210450e-01f, -1.20266248e-02f, 2.81294845e-02f, 2.57535353e-02f, 4.59289998e-02f, -6.36510924e-02f, 1.33246053e-02f, -7.37892613e-02f, 1.32625446e-01f, 6.63010851e-02f,
  4.98389415e-02f, 7.89558068e-02f, 5.79732005e-03f, -1.82408448e-02f, 1.43909222e-02f, 6.68993045e-04f, -1.64721251e-01f, -9.84844342e-02f, -1.55977175e-01f, -2.49014437e-01f,
  3.88774797e-02f, 1.05898723e-01f, 3.44499014e-02f, 1.30988121e-01f, 8.13394263e-02f, -6.73443675e-02f, 4.40516174e-02f, -4.42594253e-02f, 5.69257699e-02f, -2.37957761e-02f,
  7.71936700e-02f, 8.47732350e-02f, 5.07076196e-02f, 1.06307633e-01f, -3.85332517e-02f, 6.92941174e-02f, -1.28325010e-02f, 2.65520308e-02f, 8.17704424e-02f, -6.31098971e-02f,
  1.28269747e-01f, 6.86088204e-02f, -9.71469209e-02f, 1.31121604e-02f, 1.34059250e-01f, 7.03190416e-02f, 8.99610817e-02f, -2.70061977e-02f, -3.54291722e-02f, 1.68912306e-01f,
  3.27066779e-02f, -2.33025104e-03f, -8.07773396e-02f, 6.94251657e-02f, 8.64222199e-02f, -2.43691951e-02f, -8.20370913e-02f, -1.08238034e-01f, 7.61373416e-02f, -4.49261479e-02f,
  5.46157546e-02f, -1.03244754e-02f, -6.78391568e-03f, -9.64428559e-02f, 3.30359302e-02f, -8.01746249e-02f, -3.80846485e-02f, 5.21331728e-02f, -4.90379483e-02f, -7.60738775e-02f,
  -3.68087506e-03f, 3.69105190e-02f, 5.96948317e-04f, 5.32283261e-02f, 3.19522433e-02f, 4.19701859e-02f, -3.45778577e-02f, 3.85805517e-02f, -5.87032065e-02f, -1.76876523e-02f,
  4.57883179e-02f, 8.95755887e-02f, 4.10095751e-02f, 9.15249286e-04f, -1.64209772e-02f, 1.44902822e-02f, -1.29137449e-02f, 6.91229254e-02f, 5.40361591e-02f, -6.01841956e-02f,
  -7.53821433e-02f, 2.04492752e-02f, -9.79491696e-02f, 8.65785703e-02f, 7.10119307e-02f, 8.33152384e-02f, -7.06645846e-02f, 9.00516212e-02f, -8.14323202e-02f, 3.52899195e-03f,
  -8.23693424e-02f, -1.03342175e-01f, 2.28683800e-02f, 1.19672678e-02f, -6.09856425e-03f, 1.07197985e-01f, 4.98505495e-02f, 3.22205387e-02f, -8.51366967e-02f, 1.23922192e-02f,
  -8.53642300e-02f, 4.81310859e-02f, -2.80718002e-02f, -1.58031154e-02f, 1.39994882e-02f, 7.30529204e-02f, 4.91880514e-02f, 3.71630304e-02f, -7.65708834e-02f, 6.33781077e-04f,
  1.06199216e-02f, 1.54613312e-02f, -7.06756487e-02f, -6.01416640e-02f, 4.47856002e-02f, 1.87341124e-02f, -4.12884019e-02f, 3.40595916e-02f, -6.54207692e-02f, 5.78039698e-02f,
  -8.67417082e-02f, -9.16038156e-02f, -1.22576803e-02f, 3.60688902e-02f, 1.55649651e-02f, 1.89947337e-02f, -4.23590057e-02f, -4.94816788e-02f, -8.87590200e-02f, 4.19100095e-03f,
  1.52326167e-01f, -1.20454952e-01f, 5.90821579e-02f, 7.56108835e-02f, -4.39701714e-02f, -3.91144492e-02f, 1.55111810e-03f, -3.76336090e-02f, 1.78359505e-02f, 5.53634502e-02f,
  3.36452983e-02f, 9.66451014e-04f, 1.11484202e-02f, 5.84151521e-02f, 1.08379662e-01f, 8.37257579e-02f, -2.36930549e-02f, 1.94837764e-01f, 9.67129245e-02f, 8.00484046e-02f,
  -2.67655887e-02f, 8.53759721e-02f, 1.69837307e-02f, 4.71644364e-02f, 2.45961230e-02f, 2.68078651e-02f, -6.16540201e-02f, -3.31678577e-02f, -8.25080182e-03f, -3.80051956e-02f,
  3.77698578e-02f, 4.75198627e-02f, 9.74638611e-02f, 1.07899040e-01f, -6.58185184e-02f, 7.57590234e-02f, 7.55481198e-02f, -3.40923592e-02f, 4.39057574e-02f, -1.07553519e-01f,
  -1.31250396e-02f, 7.53647368e-03f, 1.51407169e-02f, -2.48933751e-02f, -1.17582092e-02f, 2.41626846e-03f, -5.15927933e-02f, 4.28907238e-02f, 8.20748433e-02f, 4.52483147e-02f,
  -2.05193460e-02f, 2.82887798e-02f, -7.02269450e-02f, -4.56415713e-02f, -3.80725088e-03f, 6.83006495e-02f, -3.35604958e-02f, -2.27659512e-02f, 3.60473022e-02f, -5.01562878e-02f,
  6.03993945e-02f, 3.86549942e-02f, 5.77314720e-02f, 7.29357377e-02f, 6.62551895e-02f, 6.69218600e-02f, -5.14806844e-02f, 5.44263385e-02f, 3.38253640e-02f, -3.52210142e-02f,
  7.49859288e-02f, -1.53433997e-02f, 1.86527874e-02f, -1.67436358e-02f, -1.20702554e-02f, 3.22198942e-02f, 1.07270079e-02f, -9.73344743e-02f, -1.29505545e-02f, 6.54211715e-02f,
  -1.77775007e-02f, -2.73264460e-02f, 1.07648959e-02f, 4.06367369e-02f, 6.76841140e-02f, -1.99635755e-02f, -1.65458880e-02f, -9.59196407e-03f, -5.36799766e-02f, -4.00816500e-02f,
  -9.15632695e-02f, 8.36537555e-02f, -5.97157888e-03f, 1.06972940e-02f, -2.87221223e-02f, 5.10059483e-02f, 2.90942229e-02f, -8.54201764e-02f, -4.70089093e-02f, -5.02880700e-02f,
  -9.68840793e-02f, -2.90048737e-02f, -4.36474830e-02f, -1.09991012e-02f, 2.10267305e-02f, 2.69236173e-02f, 3.90033051e-02f, 5.18261343e-02f, 8.38014483e-02f, 4.83387746e-02f,
  3.65725309e-02f, 3.31420451e-02f, 1.35841563e-01f, 4.50902283e-02f, 8.48916639e-03f, 1.57922864e-01f, 8.48102346e-02f, -4.27562417e-03f, 2.20274739e-02f, 8.89434963e-02f,
  -1.51167348e-01f, -1.48963615e-01f, -1.52106360e-01f, -1.91372097e-03f, 2.06262264e-02f, 5.85549437e-02f, -6.10020533e-02f, 2.53904872e-02f, 4.43224348e-02f, -8.03841278e-02f,
  4.80491407e-02f, 1.47313684e-01f, -6.72013909e-02f, 1.01964902e-02f, -5.40915057e-02f, -1.00895859e-01f, -1.51008874e-01f, -8.14774483e-02f, -5.28937206e-02f, 8.87105614e-03f,
  -2.06858199e-02f, 5.73269986e-02f, -7.27631850e-04f, 3.67041826e-02f, 4.85662976e-03f, 4.53800373e-02f, 1.58437085e-03f, 8.37392136e-02f, -7.57402182e-02f, -6.52617812e-02f,
  -7.57015357e-03f, 4.43301648e-02f, -1.28834713e-02f, 7.83897564e-02f, 7.40010142e-02f, 5.99568039e-02f, 3.97486351e-02f, 7.13889627e-03f, -5.44696227e-02f, 3.23610045e-02f,
  -6.09269850e-02f, -3.49910632e-02f, 5.46522886e-02f, -4.85876836e-02f, 4.00806889e-02f, -7.03645637e-03f, 4.25986061e-03f, -9.25245434e-02f, 1.57130323e-02f, 4.50189784e-02f,
  6.06490225e-02f, -6.76864162e-02f, -9.48781148e-02f, 4.91720363e-02f, 5.17546050e-02f, 4.67186123e-02f, -7.28208870e-02f, -2.95113074e-03f, -2.38681678e-02f, 2.21021450e-03f,
  -3.29271494e-03f, -5.78787848e-02f, 3.69148292e-02f, -9.16193239e-03f, -8.54423568e-02f, 5.46152666e-02f, -6.61030412e-02f, 1.22722965e-02f, -4.84311357e-02f, -9.00287554e-02f,
  3.04822512e-02f, -1.21694356e-02f, 7.16206506e-02f, -2.36682501e-03f, -3.09625976e-02f, -4.70281988e-02f, -3.20041813e-02f, -2.09874772e-02f, 1.75885260e-02f, 3.89870964e-02f,
  4.28199619e-02f, 2.39836313e-02f, -6.59595728e-02f, 3.51091586e-02f, -4.01194356e-02f, -8.46187174e-02f, -9.53372642e-02f, -3.68820168e-02f, 1.93882769e-03f, 4.32472005e-02f,
  -2.77657397e-02f, -1.52605057e-01f, -9.45312716e-03f, 1.86256482e-03f, 4.01335582e-02f, -7.03937411e-02f, 1.80316204e-03f, -8.11800882e-02f, -3.42701911e-03f, 3.50310504e-02f,
  -3.69100668e-03f, 9.79234502e-02f, -2.81498618e-02f, 2.96023395e-02f, -1.03840949e-02f, 2.09103618e-02f, -1.39601165e-02f, 9.58819222e-03f, -1.02142274e-01f, 3.18893343e-02f,
  1.46553181e-02f, -1.55137122e-01f, -3.59542146e-02f, -4.38840613e-02f, -3.24471369e-02f, -4.71711718e-02f, -6.03926592e-02f, -8.51277411e-02f, -1.57368612e-02f, -1.30362347e-01f,
  6.75163120e-02f, -7.75688812e-02f, 3.27471481e-03f, 1.59686640e-01f, 1.50716186e-01f, 4.27246690e-02f, -1.03446618e-01f, 7.16174841e-02f, 1.41068950e-01f, 5.65499328e-02f,
  1.06593512e-01f, 1.20635927e-01f, 8.55018795e-02f, -1.74415261e-02f, -6.50169179e-02f, -1.21303253e-01f, -1.82360634e-01f, -1.71715349e-01f, -8.30283612e-02f, -9.31924731e-02f,
  -1.54197933e-02f, 2.41389647e-02f, -6.46796450e-02f, 5.45801595e-02f, 3.38791125e-03f, 4.97669578e-02f, -5.61752319e-02f, 7.49287531e-02f, -1.23828337e-01f, -8.04569051e-02f,
  5.10299131e-02f, 5.51509522e-02f, -3.36780660e-02f, -2.44424436e-02f, 8.62162784e-02f, 1.98432934e-02f, -2.79564839e-02f, -5.15288822e-02f, 2.72795428e-02f, -1.76964775e-02f,
  4.44760621e-02f, -7.07491189e-02f, -1.90052800e-02f, -7.38121793e-02f, -9.81555320e-03f, 7.34852627e-02f, -9.41144451e-02f, -5.20896390e-02f, -5.08621521e-02f, -7.54578561e-02f,
  1.56700741e-02f, 4.63692993e-02f, -8.89188722e-02f, -4.10177968e-02f, -7.56198773e-03f, -6.82779327e-02f, 5.48647344e-02f, 3.04791126e-02f, -9.36084986e-03f, -1.16181307e-01f,
  2.09867638e-02f, -6.34799078e-02f, -1.33171584e-03f, 1.64194871e-02f, 1.23371929e-03f, -1.86154153e-02f, -8.29519704e-02f, -3.47721502e-02f, 6.57693818e-02f, -4.70400639e-02f,
  -1.25674736e-02f, 2.59767938e-02f, -3.85331027e-02f, -5.47731435e-03f, 1.28615968e-04f, 6.04827069e-02f, 6.81581721e-02f, 6.80454373e-02f, -8.91147107e-02f, 3.89468390e-03f,
  2.01729164e-02f, -6.84428262e-03f, 3.65323224e-03f, 1.66141260e-02f, 2.24391241e-02f, -1.55554498e-02f, 9.04619247e-02f, 6.64742813e-02f, 6.34750426e-02f, 8.35703015e-02f,
  1.56054422e-01f, -7.25851059e-02f, -3.59390564e-02f, 8.47279206e-02f, -9.84977372e-03f, 1.82880852e-02f, 1.35843027e-02f, -3.85014573e-03f, 5.68459332e-02f, -1.03036381e-01f,
  4.29667197e-02f, -2.33622864e-02f, 8.22588243e-03f, -1.11184642e-01f, -5.13395146e-02f, -7.19012022e-02f, -4.77035902e-02f, -5.83246462e-02f, -8.69523510e-02f, 9.10597220e-02f,
  4.24792767e-02f, -1.13052011e-01f, 3.77480909e-02f, -1.10407338e-01f, -1.65163390e-02f, -8.36492479e-02f, -1.14383630e-01f, 8.03977158e-03f, 2.17859987e-02f, -1.20954394e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.32600901e-02f, -3.85090895e-02f, 1.09054008e-02f, 1.30819127e-01f, 8.91148746e-02f, -4.89085577e-02f, -4.08787243e-02f, 3.30546498e-03f, -4.41103876e-02f, 2.48158947e-02f,
  -3.52025405e-02f, 6.84880316e-02f, 1.28054440e-01f, 4.64438461e-02f, 2.17514466e-02f, 1.30345345e-01f, -2.94064861e-02f, -4.42359969e-03f, -1.30384052e-02f, 1.34933377e-02f,
  5.72107844e-02f, 2.91213375e-02f, -5.09105027e-02f, 1.45624196e-02f, -2.69778930e-02f, 1.97693631e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.10184692e-01f, 7.08020329e-02f, 1.35620505e-01f, 9.53547060e-02f, 4.84356619e-02f, -5.41157015e-02f, -7.99451321e-02f, -5.72044440e-02f, 1.24410905e-01f, -7.36663193e-02f,
  -6.04328997e-02f, -2.48388015e-02f, 2.95460582e-01f, 9.12102461e-02f, -1.15213796e-01f, 7.55330101e-02f, 2.92062983e-02f, -7.97864944e-02f, 2.52370715e-01f, 6.65921019e-03f,
  -2.04820827e-01f, 2.71431029e-01f, -1.46288231e-01f, -1.73880607e-01f, 8.94299522e-02f, -1.28067523e-01f, 1.16785899e-01f, -1.88368857e-01f, 1.48963392e-01f, -6.69179857e-02f,
  -9.97354463e-02f, 7.99189880e-02f, 3.52939479e-02f, 2.49576401e-02f, 1.49413645e-01f, 1.97092280e-01f, -8.95074159e-02f, -8.07055980e-02f, -1.94445800e-03f, -7.64531866e-02f,
  2.67828368e-02f, 7.81495403e-03f, 1.13922916e-01f, 5.05231582e-02f, 7.52244964e-02f, 3.17063779e-02f, 1.23841591e-01f, -4.98907343e-02f, -7.80257285e-02f, -1.16234325e-01f,
  8.01644772e-02f, -8.48836638e-03f, 1.26055688e-01f, -4.04864363e-03f, 1.41649753e-01f, 5.15516400e-02f, -4.40127216e-02f, -1.72170609e-01f, -7.13596791e-02f, -9.58967675e-03f,
  -3.34061794e-02f, 1.60177559e-01f, -4.68000248e-02f, -1.07978053e-01f, 6.66402057e-02f, 1.37947857e-01f, 1.49206100e-02f, 9.79679152e-02f, 2.26744395e-02f, -2.77003478e-02f,
  2.30642721e-01f, -7.37390742e-02f, -3.76610793e-02f, 9.51175988e-02f, 8.86615962e-02f, -7.88080469e-02f, -1.32200569e-01f, 5.16020181e-03f, 4.61289212e-02f, 5.75808734e-02f,
  -4.77649011e-02f, -5.48937172e-02f, -5.12961484e-02f, -6.27871901e-02f, -1.09012172e-01f, 1.78899944e-01f, -4.97012548e-02f, -3.91317792e-02f, 4.50690091e-02f, 1.32713661e-01f,
  -5.91414459e-02f, -2.73301274e-01f, 2.51438320e-02f, -1.09188505e-01f, -3.00235907e-03f, 6.75328746e-02f, -4.64895107e-02f, 8.90400708e-02f, -1.14561073e-01f, 1.90954849e-01f,
  -1.99992672e-01f, 1.54957756e-01f, -1.25289023e-01f, -6.51865825e-02f, 8.28517005e-02f, -1.45340502e-01f, -9.54794586e-02f, 9.50816199e-02f, -5.30195702e-03f, 3.05617843e-02f,
  2.90993694e-02f, -1.46843940e-01f, -1.42366424e-01f, 1.36840120e-01f, -6.69371784e-02f, 9.37070027e-02f, 3.13852448e-03f, -2.72195712e-02f, -5.74095063e-02f, 1.40074166e-02f,
  5.48178405e-02f, -1.28061831e-01f, 7.87462220e-02f, 4.91511375e-02f, -1.15072936e-01f, 1.24947354e-01f, -3.69829386e-02f, -5.75812683e-02f, -6.90225512e-02f, 5.06649986e-02f,
  6.25794008e-02f, 2.68119145e-02f, -6.56117946e-02f, -2.63152160e-02f, -1.40969828e-01f, -4.58039838e-04f, 1.38757825e-01f, 1.60349254e-02f, 2.79572438e-02f, -1.31675750e-01f,
  6.97846413e-02f, -3.13098133e-02f, 4.52747121e-02f, 1.22523308e-01f, 7.87338987e-02f, 6.13730177e-02f, 1.64758280e-01f, 5.80369085e-02f, -1.26174524e-01f, -4.73662801e-02f,
  8.65284353e-02f, -1.97432101e-01f, 9.49272588e-02f, -1.52629793e-01f, 2.17218101e-02f, -1.49412781e-01f, 9.13966075e-03f, 6.54002354e-02f, -1.77783564e-01f, -3.83668579e-02f,
  1.15912169e-01f, 1.94927678e-01f, 1.55854777e-01f, 7.08217695e-02f, 3.70617807e-02f, -5.27919531e-02f, -5.76306209e-02f, -2.79576313e-02f, -7.24253580e-02f, -1.29392771e-02f,
  -5.82877658e-02f, -5.90354986e-02f, -5.89570589e-02f, 1.67227294e-02f, 1.49842843e-01f, 3.32897045e-02f, -1.28969193e-01f, -4.98573808e-03f, -4.27621091e-03f, -5.96850133e-03f,
  5.42662814e-02f, 8.82074386e-02f, 2.91463342e-02f, 6.22190628e-03f, 4.81275879e-02f, 3.03486083e-02f, 1.37653887e-01f, 1.86945423e-01f, 9.85435918e-02f, 1.59739137e-01f,
  -8.43756944e-02f, 1.40312901e-02f, 2.29920194e-01f, -7.67184049e-02f, -2.26062033e-02f, -1.13185115e-01f, -1.00963190e-01f, 5.79552539e-02f, -7.58130178e-02f, 1.07206581e-02f,
  -9.24551114e-03f, -7.75510222e-02f, 1.18868507e-01f, -4.69999798e-02f, -4.33101058e-02f, -8.34194869e-02f, -7.59857297e-02f, -4.08332311e-02f, -1.17127330e-03f, 2.03127209e-02f,
  -2.36126959e-01f, 2.27770388e-01f, 2.44925961e-01f, 3.54952097e-01f, 1.91713989e-01f, 2.05782592e-01f, 5.91778532e-02f, -6.11174367e-02f, -1.89161271e-01f, -2.98084132e-02f,
  2.15197161e-01f, -3.34012508e-01f, 3.23609501e-01f, 2.60784030e-01f, -8.36504903e-03f, -1.77185535e-02f, -2.19759434e-01f, 1.64489076e-02f, -1.32374123e-01f, 1.74032882e-01f,
  2.35924214e-01f, 1.84349239e-01f, 3.01958993e-03f, 9.77222901e-03f, -7.58089125e-02f, 4.87513989e-02f, -2.40113810e-02f, 1.01561792e-01f, -3.62989889e-03f, 1.35290295e-01f,
  9.41279065e-03f, 7.60606816e-03f, 1.01578332e-01f, -5.66280447e-02f, 4.55524847e-02f, -9.24722701e-02f, -6.91998079e-02f, -6.95950165e-02f, -3.13814431e-02f, -7.32636154e-02f,
  6.73221126e-02f, -2.10473225e-01f, 1.29769355e-01f, -3.93176079e-02f, 8.21377859e-02f, 8.04727003e-02f, -6.29073307e-02f, -4.60526496e-02f, -1.62433863e-01f, 1.00977734e-01f,
  1.29789010e-01f, -1.11975148e-01f, -1.04476675e-01f, 2.43031308e-01f, -1.88198939e-01f, 8.28425437e-02f, 4.53473888e-02f, 1.55267432e-01f, -1.64004415e-01f, -8.45898464e-02f,
  2.93698758e-01f, -1.00741729e-01f, -6.74338415e-02f, -5.56390695e-02f, -2.13740736e-01f, -2.37748817e-01f, 1.07671984e-01f, -1.10033341e-01f, 1.10680379e-01f, -1.14060706e-02f,
  -1.76328480e-01f, 4.21057679e-02f, -1.26872584e-01f, 1.38390809e-01f, -5.94750643e-02f, 9.21731815e-03f, 7.57079795e-02f, -6.00984618e-02f, 1.18990973e-01f, 7.89358560e-03f,
  2.17119735e-02f, 1.26709774e-01f, 4.34292145e-02f, -5.81305921e-02f, -2.21177772e-01f, 5.76224469e-04f, 8.19714814e-02f, -2.13575184e-01f, 1.58433959e-01f, -1.29951522e-01f,
  -5.56843355e-02f, -1.95047017e-02f, -9.14713517e-02f, 1.07835397e-01f, 2.95681879e-02f, -1.24778561e-01f, -2.83521086e-01f, -7.76144564e-02f, -9.59491953e-02f, -8.15972760e-02f,
  -1.54422984e-01f, -3.32339928e-02f, 1.27377361e-01f, 1.71172500e-01f, 5.13169505e-02f, -2.15988960e-02f, -3.28347832e-02f, -1.42003000e-01f, -9.61809456e-02f, 1.62881333e-02f,
  -7.14720488e-02f, -1.03968037e-02f, 2.18837366e-01f, 7.82833546e-02f, 6.02863580e-02f, 5.98697886e-02f, -2.36519217e-01f, 2.24390440e-02f, 1.26807407e-01f, -1.28096566e-01f,
  -2.20858436e-02f, 4.96221744e-02f, 3.09666872e-01f, -2.22509168e-02f, -1.53640494e-01f, 4.45931070e-02f, -9.72277001e-02f, 1.33105174e-01f, 1.72767743e-01f, -1.49338961e-01f,
  1.64172370e-02f, 2.33040497e-01f, -1.21041320e-01f, 5.67218475e-02f, 1.93707153e-01f, -8.28630254e-02f, 3.16261239e-02f, 7.83411190e-02f, 1.31622523e-01f, 1.80280134e-02f,
  -6.53053448e-02f, -2.58650328e-03f, 1.11805260e-01f, -1.94789246e-01f, 2.96052545e-01f, 9.48523879e-02f, -7.94093385e-02f, -5.99140152e-02f, -3.57662775e-02f, 1.04276590e-01f,
  -5.55287004e-02f, 9.29644257e-02f, 4.81413268e-02f, -1.40769491e-02f, -2.41787229e-02f, -5.54291122e-02f, 1.36248872e-01f, -1.13381572e-01f, 1.08093336e-01f, 3.10632195e-02f,
  1.94633052e-01f, 8.56235216e-04f, 9.59300101e-02f, -6.09489297e-03f, 7.06524849e-02f, 1.57039404e-01f, 3.95669155e-02f, -2.04159841e-01f, 3.76672447e-02f, 2.41997391e-01f,
  -3.31345536e-02f, 7.68832415e-02f, 9.53939483e-02f, -3.88348065e-02f, 1.83038130e-01f, -1.08886369e-01f, -1.38438240e-01f, -2.42253765e-02f, -6.84275404e-02f, -1.77669436e-01f,
  -5.32233939e-02f, 3.23523022e-02f, 1.52469240e-02f, -2.39463910e-01f, 3.53987934e-03f, -1.19005442e-01f, -1.10212654e-01f, 8.00435897e-03f, -1.59933478e-01f, -1.60399258e-01f,
  -1.84797477e-02f, -2.15469524e-02f, -5.15291393e-02f, 3.38701934e-01f, 1.46843031e-01f, 2.84048259e-01f, 2.87177950e-01f, 1.62044019e-01f, -1.38356388e-01f, -1.28802340e-02f,
  -3.36045474e-01f, 5.04513197e-02f, 2.30677456e-01f, -2.95945913e-01f, 2.38162756e-01f, 2.17987701e-01f, -1.86428383e-01f, -1.66692212e-01f, -3.04736737e-02f, 6.66317046e-02f,
  -2.62788445e-01f, -6.00539446e-02f, 1.24478146e-01f, 6.56748340e-02f, -8.59022513e-02f, 4.94819395e-02f, -7.32280836e-02f, 1.04970954e-01f, 1.55776739e-03f, 3.82675529e-02f,
  1.20466553e-01f, -1.34633437e-01f, -3.16762514e-02f, -1.71127468e-01f, 1.67528659e-01f, -2.32222944e-01f, 9.04796869e-02f, -1.38794661e-01f, -4.04715575e-02f, 1.50201455e-01f,
  -8.20192508e-04f, -8.39681402e-02f, -7.65639991e-02f, -2.79345721e-01f, 2.04755485e-01f, -7.27331936e-02f, 1.17645524e-01f, -5.27068973e-02f, 2.00201347e-02f, -6.56282976e-02f,
  -1.53958648e-01f, -2.09968127e-02f, 2.40176991e-02f, 5.11905961e-02f, 2.85060942e-01f, 2.92416066e-01f, -1.25866041e-01f, 1.84379876e-01f, 1.53666213e-01f, -8.74206349e-02f,
  -1.42465413e-01f, -1.67525142e-01f, 7.76152238e-02f, 1.34967312e-01f, -6.67696297e-02f, -8.59087855e-02f, 6.54379353e-02f, 1.31048951e-02f, -7.51850978e-02f, -2.06874236e-01f,
  2.20408082e-01f, -1.30240306e-01f, 9.18876082e-02f, -8.28092173e-02f, 1.49277315e-01f, -2.35268567e-02f, -7.53089264e-02f, 2.48650387e-01f, -2.65098661e-01f, -1.26676068e-01f,
  -1.29009023e-01f, 4.70946776e-03f, -1.87732503e-01f, 2.31389806e-01f, -2.71380663e-01f, 2.42333463e-03f, 1.18995264e-01f, -1.96253225e-01f, -1.88778248e-02f, -7.53499866e-02f,
  -7.52850845e-02f, -1.32476628e-01f, -1.54335245e-01f, -2.18004994e-02f, -1.37920499e-01f, -1.17147572e-01f, -6.20980524e-02f, 2.02480871e-02f, 1.53042063e-01f, 2.56520603e-02f,
  1.42941019e-02f, -1.18464485e-01f, -3.06672435e-02f, -4.47766520e-02f, -8.08498915e-03f, 1.40087783e-01f, -1.92666069e-01f, -1.52350485e-01f, -1.23561099e-01f, 5.28708734e-02f,
  -1.46776319e-01f, -1.71415254e-01f, -1.13510594e-01f, -6.30362034e-02f, -3.93509120e-03f, 1.01805821e-01f, 1.37807103e-02f, -1.33330049e-02f, -2.16868520e-01f, -1.76401474e-02f,
  -9.46289524e-02f, 7.02002943e-02f, -1.22535445e-01f, -7.62591660e-02f, 1.78230867e-01f, -1.36526093e-01f, -7.66067877e-02f, -1.20744787e-01f, -2.61887666e-02f, 5.57392277e-02f,
  9.72916037e-02f, 1.12542331e-01f, 1.11013420e-01f, 9.52465683e-02f, 1.68109357e-01f, -2.74852179e-02f, 1.73673928e-01f, -1.89474255e-01f, 6.23122081e-02f, 2.73128331e-01f,
  -7.51457736e-02f, 1.63898349e-01f, -9.44971144e-02f, 1.40801996e-01f, 7.22415373e-02f, -1.63554937e-01f, 1.45608978e-02f, -7.68942311e-02f, 2.07153875e-02f, -1.31745324e-01f,
  2.35447064e-01f, 1.44521251e-01f, 6.69736788e-02f, 2.42673114e-01f, -2.14838579e-01f, -1.17122710e-01f, 5.10975234e-02f, -7.52647966e-02f, 1.10306494e-01f, -1.26435116e-01f,
  -3.95190250e-03f, 8.58344808e-02f, 2.46721536e-01f, 3.76939997e-02f, -7.82049745e-02f, 1.08319707e-01f, 1.27698749e-01f, 4.82174419e-02f, 1.39764532e-01f, -1.05204977e-01f,
  -1.42785951e-01f, 2.21166655e-01f, 7.77789727e-02f, -5.68303578e-02f, 3.75942066e-02f, 1.23421222e-01f, 1.69771805e-01f, 1.99828949e-02f, -5.59299625e-02f, 2.51973480e-01f,
  -1.23001792e-01f, 2.42973249e-02f, -1.47533298e-01f, -1.74140707e-01f, 1.59815684e-01f, -2.44625568e-01f, -5.56147993e-02f, -1.12879083e-01f, 2.30905160e-01f, 1.47430494e-01f,
  1.70584515e-01f, 8.57288837e-02f, -3.58224101e-02f, 2.55548917e-02f, 1.55387208e-01f, 6.85051316e-03f, -2.96020769e-02f, 2.30937898e-01f, -3.42969537e-01f, 9.41874683e-02f,
  8.54957383e-03f, 9.14564282e-02f, -6.20540604e-02f, -1.91803247e-01f, 2.46457100e-01f, -2.27487549e-01f, 3.04911762e-01f, -1.50654078e-01f, -1.90449208e-02f, -2.02982411e-01f,
  -1.60872322e-02f, 8.87084976e-02f, 9.98665914e-02f, -1.47681922e-01f, -1.88684896e-01f, -1.95641499e-02f, 2.57817637e-02f, 2.51272488e-02f, 6.93647563e-02f, 5.36957160e-02f,
  -5.61702363e-02f, -1.32628322e-01f, 4.00148220e-02f, -8.06884170e-02f, 1.34426728e-01f, -1.90110311e-01f, -1.35770962e-01f, -8.81573856e-02f, 1.02779694e-01f, -6.93194494e-02f,
  6.08121976e-02f, 1.98857442e-01f, -1.60555229e-01f, -2.80239016e-01f, 2.13555217e-01f, 4.21249159e-02f, 1.21676281e-01f, -1.27295732e-01f, -5.13846753e-04f, -1.65412694e-01f,
  -1.15529983e-03f, 7.97105804e-02f, 1.71052963e-02f, 5.72705502e-03f, 3.48392837e-02f, -1.16070352e-01f, 7.11803362e-02f, -2.10788846e-01f, 8.45334828e-02f, -3.84085886e-02f,
  -1.46322213e-02f, -6.50155842e-02f, 3.29975374e-02f, -1.44530758e-01f, -2.79213965e-01f, 2.55731381e-02f, 8.18069279e-03f, 6.59985607e-03f, 2.07754314e-01f, 1.40287012e-01f,
  -6.04051463e-02f, -7.32094124e-02f, 8.79674181e-02f, -2.32599035e-01f, -1.54850511e-02f, -1.57245800e-01f, -1.02606490e-02f, -5.00044413e-02f, -1.12970732e-01f, 6.80406392e-02f,
  -1.72097579e-01f, -9.19351205e-02f, 1.14500090e-01f, 2.84642130e-02f, 1.71205744e-01f, 4.83138449e-02f, 5.30772917e-02f, -2.14726821e-01f, 2.06639871e-01f, 3.78154479e-02f,
  -9.44596231e-02f, 1.52440771e-01f, -3.71613540e-03f, 1.81661565e-02f, 6.18411899e-02f, -3.34391184e-02f, -1.87833738e-02f, -1.36781499e-01f, -1.47463217e-01f, -9.84730348e-02f,
  1.57753944e-01f, 3.43583561e-02f, 9.63440351e-03f, 3.06457616e-02f, -1.32448925e-02f, 2.83862893e-02f, -8.93252622e-03f, -1.55803224e-04f, 9.87469628e-02f, 1.40291780e-01f,
  1.43133968e-01f, 3.01150628e-03f, 1.39553919e-02f, -1.42276272e-01f, -9.91294011e-02f, 4.13175151e-02f, -1.56969190e-01f, 1.46745920e-01f, -4.58414257e-02f, -1.61480889e-01f,
  1.39908940e-01f, 1.37931734e-01f, 2.11421214e-02f, -3.84072028e-02f, -1.66102387e-02f, -5.60784191e-02f, 3.86651345e-02f, -6.29280284e-02f, 3.52399610e-02f, 3.28775793e-02f,
  4.17808332e-02f, 3.74100469e-02f, -7.02842698e-02f, 4.20570141e-03f, -1.62500545e-01f, -1.38818949e-01f, 2.14110047e-01f, -1.42195195e-01f, -2.89477445e-02f, 1.34969234e-01f,
  7.94523582e-02f, 1.39393806e-01f, 1.72519870e-02f, 2.22636268e-01f, -7.32281283e-02f, -1.19110439e-02f, -8.22737291e-02f, -6.23788722e-02f, -8.98384601e-02f, 1.16429463e-01f,
  3.47100049e-02f, -1.28577361e-02f, 1.43500850e-01f, -1.43856183e-01f, 1.25873119e-01f, -7.66347870e-02f, -2.44420886e-01f, 4.79873344e-02f, -1.34381488e-01f, -5.66015318e-02f,
  -5.21415472e-02f, -3.94651704e-02f, -1.09235264e-01f, 4.49916311e-02f, 1.96123436e-01f, -1.35428444e-01f, -9.66917444e-03f, 2.56347079e-02f, -4.28973734e-02f, 3.72974132e-03f,
  7.05714300e-02f, 2.48565469e-02f, -1.25125006e-01f, -1.24550842e-01f, -5.10084778e-02f, 1.01171657e-01f, -8.98322612e-02f, -2.15733960e-01f, 1.64977372e-01f, -3.65855321e-02f,
  -1.14053756e-01f, 8.75741709e-03f, 6.75183833e-02f, -1.21102288e-01f, -3.03821452e-02f, -6.71093240e-02f, -5.57735078e-02f, -1.73308730e-01f, -1.16804123e-01f, -6.19881414e-02f,
  -1.34189650e-01f, -3.58769633e-02f, 1.31050302e-02f, -1.35679036e-01f, 4.55657672e-03f, 5.38415723e-02f, -2.46009156e-01f, 1.16017081e-01f, 1.34436682e-01f, 3.65442991e-01f,
  2.04635173e-01f, 1.80225968e-01f, -1.55186906e-01f, 1.02990121e-01f, -1.97677687e-01f, -4.27794084e-02f, 1.98343575e-01f, -7.57118165e-02f, 2.37932310e-01f, 3.23428690e-01f,
  -1.73317790e-01f, -1.59348086e-01f, -1.93648830e-01f, 1.29699528e-01f, -2.09245235e-01f, 2.37662941e-01f, 7.87773579e-02f, 7.03535974e-02f, 1.61974028e-01f, -9.82157364e-02f,
  -1.38125950e-02f, 1.28552631e-01f, -9.91741642e-02f, -8.62181094e-03f, 2.97042094e-02f, 5.24139404e-02f, -7.47921586e-04f, 1.10937536e-01f, 1.69071823e-01f, -1.75591875e-02f,
  -1.24663718e-01f, -7.43937790e-02f, 5.03335148e-02f, 2.25586053e-02f, -6.96527213e-02f, -1.21226482e-01f, -9.98695120e-02f, -1.80928677e-01f, -3.82569768e-02f, -1.30972013e-01f,
  -9.95897874e-02f, -5.76015040e-02f, 4.26132977e-02f, 1.19631872e-01f, -1.66959316e-02f, 2.67794523e-02f, 9.22776237e-02f, 5.81363402e-02f, 4.77555431e-02f, 1.40524417e-01f,
  7.18293246e-04f, -6.08165488e-02f, 2.71567758e-02f, -1.00664265e-01f, 3.17607000e-02f, 1.24184676e-01f, 1.49648711e-01f, -6.45001307e-02f, 2.06963897e-01f, 3.42852548e-02f,
  5.99662624e-02f, -1.41926028e-03f, -8.95743817e-02f, -7.53844082e-02f, 1.10867597e-01f, -1.93727031e-01f, -3.65460515e-02f, 2.01150119e-01f, -1.10947080e-01f, -7.71195740e-02f,
  2.92630289e-02f, -5.30044548e-02f, 9.97513011e-02f, -1.11305468e-01f, -1.63947836e-01f, 7.82628655e-02f, -8.55717883e-02f, 2.20221773e-01f, -1.68043405e-01f, -4.43728603e-02f,
  -1.01278752e-01f, -5.02346121e-02f, 1.07221782e-01f, 2.07523052e-02f, 1.08110972e-01f, 1.17389604e-01f, 6.32275417e-02f, -8.53649378e-02f, -6.96424246e-02f, -1.45920217e-01f,
  -6.08343482e-02f, -5.57386726e-02f, 1.22595176e-01f, -1.09226450e-01f, -1.62658170e-02f, -1.03539437e-01f, 4.79065813e-02f, 1.59112796e-01f, -6.22043125e-02f, 8.08697343e-02f,
  -3.88956144e-02f, -2.15021431e-01f, 8.58035125e-03f, 1.15278408e-01f, -1.40760630e-01f, -1.29486904e-01f, -1.62870865e-02f, -5.53333573e-03f, -5.67434728e-02f, -4.14723717e-02f,
  7.83133656e-02f, -1.20622786e-02f, 2.53044292e-02f, -2.47322321e-01f, -8.93141180e-02f, 8.30360726e-02f, -6.68422505e-02f, 6.90083280e-02f, 1.74424648e-01f, 2.29660589e-02f,
  -1.12687275e-01f, -6.40856475e-02f, 8.52807313e-02f, 1.97622016e-01f, 2.31387004e-01f, -2.15866014e-01f, -1.64034292e-01f, -2.11188376e-01f, -2.24380627e-01f, -7.61094838e-02f,
  -6.21853769e-02f, -8.09752345e-02f, 8.32439810e-02f, 8.96145925e-02f, -2.82773465e-01f, 2.84048617e-01f, -3.55848759e-01f, -1.68632776e-01f, 6.04292005e-02f, 2.24311233e-01f,
  -8.55824500e-02f, -6.50012493e-02f, 1.23153679e-01f, -3.35097648e-02f, -1.39578525e-03f, -1.24119118e-01f, -9.13473498e-03f, 1.24601439e-01f, -1.17505796e-01f, -1.55189425e-01f,
  -1.81874871e-01f, -1.13178208e-01f, -5.69046251e-02f, 1.79969728e-01f, 6.82786107e-03f, -6.59239963e-02f, -9.28279534e-02f, 7.00041279e-02f, -1.54934093e-01f, 1.28587171e-01f,
  2.83841789e-02f, -7.24468902e-02f, -1.44576982e-01f, -1.00229479e-01f, -5.22207357e-02f, 2.81309187e-01f, -8.09487030e-02f, -4.04220894e-02f, -4.43078130e-02f, -1.30867407e-01f,
  -1.41237780e-01f, 1.14575177e-01f, 2.40672217e-03f, -1.95013694e-02f, -1.24387145e-02f, 1.09957896e-01f, 2.51703292e-01f, 1.81425646e-01f, -8.74471739e-02f, 2.43683130e-01f,
  9.48078781e-02f, -9.74334925e-02f, -2.58723408e-01f, -1.47725001e-01f, -8.59015286e-02f, -2.69789584e-02f, 1.08842924e-01f, 1.76691771e-01f, -1.81144968e-01f, 1.24929145e-01f,
  8.27701166e-02f, -2.62203395e-01f, 1.22769900e-01f, -1.38526753e-01f, -1.00139357e-01f, 1.55051470e-01f, -5.64539060e-02f, -1.85582891e-01f, -1.59041062e-01f, 5.53508401e-02f,
  -2.13403344e-01f, -6.90694451e-02f, -8.38415548e-02f, 2.13988632e-01f, -1.96630016e-01f, 1.27369687e-01f, -9.73424166e-02f, 1.30018666e-01f, -7.46871382e-02f, -1.77771300e-01f,
  9.35270414e-02f, 6.44206703e-02f, -1.95060894e-01f, 1.51123732e-01f, 4.72062863e-02f, 1.11195073e-01f, -1.15279682e-01f, -8.25708583e-02f, 1.10674702e-01f, 1.26613513e-01f,
  2.34837886e-02f, 7.84181356e-02f, 4.55330275e-02f, 1.16095059e-02f, -8.98905993e-02f, -1.39907792e-01f, -1.51663860e-02f, 1.68993428e-01f, 2.69970372e-02f, -1.92650780e-01f,
  4.40412853e-03f, 4.05279398e-02f, -7.46257156e-02f, -1.22287892e-01f, -1.38740703e-01f, 2.46168356e-02f, 1.53023571e-01f, -1.07811555e-01f, -2.07636375e-02f, -1.38077646e-01f,
  -1.00051418e-01f, -4.11676802e-02f, 2.05869786e-02f, -5.56986220e-02f, 6.83625862e-02f, 2.40851194e-02f, -7.49428757e-03f, -1.61373913e-01f, -9.57224295e-02f, 4.10314910e-02f,
  -1.81907471e-02f, 7.08933547e-02f, 1.33529767e-01f, 4.70446572e-02f, -2.44754776e-01f, -2.86266118e-01f, 7.26599097e-02f, -1.32073745e-01f, 2.20175982e-01f, -1.77381754e-01f,
  1.04072161e-01f, 1.99391618e-01f, -8.55790377e-02f, 3.32949966e-01f, -3.20087582e-01f, -1.01986758e-01f, 8.69425386e-02f, -8.39632973e-02f, -1.53913330e-02f, 1.12654887e-01f,
  -1.56462103e-01f, -2.64285892e-01f, 2.28195995e-01f, -9.75566208e-02f, -1.43121973e-01f, 1.43086314e-01f, -1.92293450e-01f, 3.23922224e-02f, -1.05367795e-01f, -6.80047572e-02f,
  1.25859957e-03f, -1.26688182e-01f, 5.38028032e-02f, 1.36130586e-01f, -3.17440331e-02f, -3.89407612e-02f, 1.05309896e-01f, 5.27213467e-03f, 1.42938867e-01f, -7.21196532e-02f,
  -1.06581494e-01f, 8.87952596e-02f, -1.20219864e-01f, 2.19062775e-01f, 4.87523191e-02f, 1.55279949e-01f, 1.36399597e-01f, 7.97211826e-02f, -3.27529036e-03f, -6.02257391e-03f,
  6.65323883e-02f, -7.71014914e-02f, 5.39406203e-02f, 8.67742300e-02f, -9.73168761e-02f, -2.25625098e-01f, 8.02275166e-02f, -7.19007999e-02f, -7.74957985e-02f, -7.19516203e-02f,
  -8.95574130e-03f, 2.97336839e-02f, -6.63110912e-02f, -9.03289914e-02f, -6.46491870e-02f, -7.31032714e-02f, 2.94421148e-03f, 1.10036239e-01f, -7.97748268e-02f, 1.96242154e-01f,
  -2.85497785e-01f, 9.84869450e-02f, 1.34724170e-01f, 1.98852494e-02f, -2.91855279e-02f, -1.74363434e-01f, 2.04248235e-01f, -8.93477723e-02f, 2.29658186e-01f, -1.82920869e-03f,
  1.25272991e-02f, -1.86534449e-02f, 1.75126433e-01f, -2.16199696e-01f, 7.68901780e-02f, -1.61108240e-01f, -1.09249480e-01f, -2.30710972e-02f, 3.29465009e-02f, -2.60347184e-02f,
  1.31380722e-01f, -3.99969630e-02f, 1.67895690e-01f, 1.36887923e-01f, 7.10402429e-02f, 6.88304901e-02f, -7.41875842e-02f, -3.15028727e-02f, -6.48626834e-02f, 5.01161404e-02f,
  -7.77695924e-02f, 1.28654778e-01f, 1.12375945e-01f, 1.87380120e-01f, 4.85516861e-02f, -2.13681400e-01f, 3.78998704e-02f, 2.67358255e-02f, -2.14761756e-02f, 2.23020511e-03f,
  -2.11613141e-02f, -3.66487280e-02f, 1.95565801e-02f, 3.34610641e-02f, 7.73936734e-02f, -1.73775047e-01f, -3.69958691e-02f, 7.93586969e-02f, -5.77643588e-02f, -6.97869286e-02f,
  4.45996076e-02f, -9.24920067e-02f, 9.33381915e-02f, 1.20079473e-01f, 3.33212572e-03f, -4.71191369e-02f, 4.91850916e-03f, 1.14350980e-02f, -1.34317398e-01f, -5.53857945e-02f,
  -1.00943647e-01f, -1.55005276e-01f, 6.42594546e-02f, -1.24897182e-01f, -8.97201803e-03f, 1.77436993e-02f, -2.96864100e-02f, 9.21743140e-02f, -1.61161631e-01f, 6.68768361e-02f,
  -5.19549102e-03f, -1.14846602e-02f, 8.32340866e-02f, 7.16257095e-02f, 1.80662587e-01f, -7.40916431e-02f, 8.56913030e-02f, -2.08706170e-01f, 2.56523579e-01f, -1.42387271e-01f,
  -1.05136342e-01f, 1.63862750e-01f, -4.92631383e-02f, -4.77342792e-02f, 1.31380945e-01f, -5.84217794e-02f, -7.20660761e-02f, -1.01505838e-01f, 1.03732854e-01f, 2.23577932e-01f,
  1.05314389e-01f, -9.91508961e-02f, -2.31739938e-01f, 6.67627752e-02f, 4.05129343e-02f, 4.43269238e-02f, 5.47537522e-04f, -1.16090916e-01f, -1.15126744e-01f, 4.30502780e-02f,
  -2.41685174e-02f, 1.41475290e-01f, -1.14379987e-01f, -1.80585757e-01f, 1.38390809e-01f, 1.04222246e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.33484353e-02f, 2.54875217e-02f, 1.98176235e-01f, 1.12918541e-01f, 1.18137397e-01f, 8.29215124e-02f, 1.52942359e-01f, -8.94922763e-02f, 1.18526788e-02f, -5.68799898e-02f,
  1.41343907e-01f, 2.53334530e-02f, 5.57217572e-04f, -1.24193721e-01f, -1.90449357e-01f, 4.32188511e-02f, -1.38979182e-02f, 4.74142209e-02f, 7.73106664e-02f, 1.25664979e-01f,
  5.86734302e-02f, 1.95705816e-01f, 1.69953838e-01f, 7.99585432e-02f, 1.74131975e-01f, 3.48418467e-02f, 2.92246491e-02f, 2.02572688e-01f, 4.96391915e-02f, -9.61018577e-02f,
  -1.63176119e-01f, 2.36460343e-02f, -3.96225490e-02f, -2.23776087e-01f, 3.65285389e-02f, 9.36419442e-02f, -1.49537727e-01f, -1.72188774e-01f, 3.50530297e-01f, 4.78950068e-02f,
  3.51896100e-02f, 1.36633664e-01f, 2.82502105e-03f, 1.06207944e-01f, -8.16086233e-02f, 1.63859483e-02f, -5.95347025e-02f, -1.73607051e-01f, 1.07953869e-01f, -2.90768649e-02f,
  3.26947361e-01f, -6.62207603e-02f, 1.25066563e-01f, 9.35403779e-02f, -5.59093580e-02f, -1.36298880e-01f, 1.04551554e-01f, 1.34580210e-01f, 1.24674700e-02f, 1.24368757e-01f,
  -4.17468622e-02f, 4.20087315e-02f, -7.68975616e-02f, -5.32820933e-02f, 1.37694284e-01f, 2.13203393e-02f, 5.21718822e-02f, -1.34064734e-01f, -4.23214249e-02f, 1.21087857e-01f,
  9.74958688e-02f, 1.13534644e-01f, 1.17169030e-01f, -3.86452600e-02f, 1.26708478e-01f, 1.42943636e-01f, -4.28400375e-02f, -3.79473381e-02f, 5.65990880e-02f, 1.26144737e-01f,
  -2.87058968e-02f, 1.63240265e-02f, 3.57654281e-02f, 2.97042336e-02f, 1.43695086e-01f, 9.87380892e-02f, 6.44370019e-02f, -2.94671226e-02f, 3.64997759e-02f, -1.59078762e-02f,
  -1.60035312e-01f, 7.64780641e-02f, -7.88472593e-04f, -8.10892209e-02f, 6.33206889e-02f, 1.87728986e-01f, -8.82738009e-02f, 1.95951965e-02f, -5.99459372e-02f, -2.42083110e-02f,
  -6.84281066e-02f, 1.36595875e-01f, 1.41989872e-01f, 2.01290715e-02f, 7.58922547e-02f, 8.31038207e-02f, 9.22762416e-03f, -1.45212570e-02f, -9.42765325e-02f, 1.82167813e-02f,
  -7.18696192e-02f, 1.05900340e-01f, 4.66161408e-02f, -8.10209662e-02f, 1.55674353e-01f, 3.59316909e-04f, 1.54579114e-02f, 7.54604191e-02f, 2.26487909e-02f, -5.30802161e-02f,
  3.63964401e-02f, 9.11451206e-02f, 3.11402865e-02f, -1.08293779e-01f, 8.17096084e-02f, -8.72920379e-02f, 3.28149013e-02f, 1.37669176e-01f, 1.39811680e-01f, 7.53467828e-02f,
  -3.40533443e-02f, -1.05175674e-01f, 2.09400989e-02f, 9.47011709e-02f, 2.17232212e-01f, 1.94214359e-01f, -5.25812395e-02f, 7.44687095e-02f, -5.33144642e-03f, 1.30355462e-01f,
  1.23648923e-02f, 1.22942135e-01f, 1.91135973e-01f, 2.06692833e-02f, 3.70785035e-02f, -2.15435419e-02f, 2.19529960e-02f, 1.50337651e-01f, -5.74966446e-02f, -1.69801831e-01f,
  6.97515309e-02f, -9.09962431e-02f, -6.17113560e-02f, 1.04038946e-01f, -1.60675719e-01f, -1.65026560e-01f, -6.07379340e-02f, -1.19088823e-02f, 1.44149199e-01f, 1.51481658e-01f,
  -8.84721950e-02f, 1.04314461e-01f, -2.44444817e-01f, -1.59785654e-02f, -1.90904498e-01f, 2.71894932e-01f, 9.87927988e-02f, 1.27191376e-02f, 8.81769955e-02f, -2.49402821e-02f,
  -2.73837447e-02f, 3.52571043e-03f, 1.99990310e-02f, -1.23217575e-01f, 6.00198423e-03f, 8.59522894e-02f, 5.49629144e-03f, 6.16639033e-02f, -1.02371529e-01f, -4.20946591e-02f,
  1.39769735e-02f, -1.12046801e-01f, -1.16317272e-01f, 5.77996369e-04f, 1.10855728e-01f, 1.92189068e-01f, 6.52009696e-02f, -1.47807494e-01f, -1.03964090e-01f, 1.12145461e-01f,
  -1.01996856e-02f, -2.00214442e-02f, -4.91768084e-02f, -6.45598024e-02f, 8.29745457e-02f, 1.30066246e-01f, 1.22833066e-01f, 1.68527827e-01f, -6.49734959e-03f, -2.11570747e-02f,
  -2.15913206e-02f, -5.04038716e-03f, 6.61986545e-02f, 1.28174916e-01f, -5.49589433e-02f, -5.52482670e-03f, 1.58240199e-01f, 4.74912748e-02f, -2.02367827e-02f, 1.28027141e-01f,
  1.55847803e-01f, 2.46109068e-02f, -3.94794159e-02f, 1.43012464e-01f, 1.18665501e-01f, 1.55953988e-01f, 1.32492222e-02f, -1.70352533e-01f, -8.66604969e-02f, 2.46206552e-01f,
  -3.01919621e-03f, 9.39082503e-02f, -2.41521597e-02f, -8.22359324e-02f, -1.49569726e-02f, 3.56927812e-02f, 5.82294576e-02f, -3.10995579e-01f, 2.39344344e-01f, -1.68735579e-01f,
  -6.50503635e-02f, 4.47045006e-02f, -4.27455492e-02f, 1.36505365e-01f, 2.30423599e-01f, -6.96416497e-02f, 1.11136533e-01f, 8.97782892e-02f, 1.28773525e-01f, -1.71878636e-02f,
  -6.24579974e-02f, -3.08384057e-02f, 7.69377276e-02f, -1.15555869e-02f, 7.03489706e-02f, 1.26601994e-01f, 1.41280919e-01f, -7.36048594e-02f, 1.79393604e-01f, 3.03170849e-02f,
  -1.80822350e-02f, 3.48128974e-01f, -8.69808346e-02f, -1.69694155e-01f, 1.90190151e-01f, 1.69284925e-01f, 1.17080599e-01f, 1.60749513e-03f, 1.22906499e-01f, -5.70905358e-02f,
  7.46714994e-02f, 2.04811413e-02f, -2.17543002e-02f, -3.23052704e-02f, 5.40275872e-02f, 3.93152051e-03f, -8.84840339e-02f, 9.19805989e-02f, 1.59358919e-01f, -7.24862888e-02f,
  7.54677951e-02f, 1.08088508e-01f, -6.02958798e-02f, -9.58941206e-02f, -2.84873899e-02f, 1.84511080e-01f, -2.21514851e-02f, 1.67285204e-01f, -7.95839056e-02f, -3.33942398e-02f,
  9.61214155e-02f, 6.40287250e-02f, -9.16763246e-02f, -3.09237745e-02f, 1.88383475e-01f, -1.17529377e-01f, -9.33362171e-02f, 4.52219024e-02f, -1.30342990e-01f, -2.02339794e-03f,
  9.94900912e-02f, 1.28119469e-01f, -3.68824564e-02f, -1.02302693e-01f, 3.17135416e-02f, 4.85275462e-02f, 1.23864122e-01f, -4.11427282e-02f, -1.28923301e-02f, 5.83267510e-02f,
  5.66333495e-02f, -6.24560602e-02f, 3.36263180e-02f, 1.46970188e-03f, -8.80890712e-02f, -6.99891895e-02f, 9.14991349e-02f, -1.13000534e-01f, 1.26530945e-01f, 4.65902649e-02f,
  -3.65246199e-02f, 1.55648187e-01f, -6.31392002e-02f, 3.79331820e-02f, 6.77091852e-02f, 4.17113602e-02f, -4.76981513e-02f, 8.22957531e-02f, -9.27907135e-03f, -1.31142989e-01f,
  -9.44450423e-02f, 9.54795107e-02f, 1.28496110e-01f, -5.93251176e-02f, -1.00422531e-01f, 1.93036199e-02f, 2.21590437e-02f, 1.23684779e-01f, 3.09503060e-02f, -3.33738290e-02f,
  4.43545543e-02f, -1.32644316e-02f, 1.69224516e-02f, 6.60538822e-02f, -8.12111571e-02f, -2.01430041e-02f, -6.72301129e-02f, -1.45281464e-01f, -5.68613596e-02f, 2.25940384e-02f,
  3.49544734e-02f, 6.08871644e-03f, -1.29242525e-01f, 6.88152295e-03f, 2.60898266e-02f, 1.52891465e-02f, -3.46454121e-02f, -1.32235616e-01f, 5.61795011e-02f, -7.79287145e-02f,
  -3.21253166e-02f, 9.64328200e-02f, -5.35533316e-02f, -1.07120655e-01f, 5.30839190e-02f, -8.93703476e-02f, 1.90506801e-02f, 2.44810171e-02f, 9.84141231e-02f, 5.38680993e-04f,
  4.88354489e-02f, 6.69469999e-04f, -8.48778114e-02f, 4.37871851e-02f, 1.33880883e-01f, -8.83678645e-02f, -1.06446669e-01f, -7.07131401e-02f, 5.51523082e-03f, -8.56457725e-02f,
  -1.31173581e-02f, -5.13132960e-02f, -4.07132134e-02f, 2.78310589e-02f, 1.87466647e-02f, 9.81378462e-03f, 9.54810232e-02f, -7.82189965e-02f, 5.27527668e-02f, -1.10256717e-01f,
  -2.40776036e-02f, 1.94209702e-02f, 3.01354062e-02f, 8.48291963e-02f, -4.15786915e-02f, 1.68173686e-01f, 2.72771120e-01f, 2.64549881e-01f, 1.54942259e-01f, 2.64092028e-01f,
  -1.59204692e-01f, -1.35798752e-01f, 2.13683173e-01f, -1.84425837e-04f, 1.06388271e-01f, 1.83622628e-01f, 2.41284937e-01f, 8.50108787e-02f, -2.55720392e-02f, 2.36300394e-01f,
  8.75452906e-02f, 1.76479951e-01f, 2.75512934e-01f, 5.58132567e-02f, -1.24754481e-01f, 3.27720672e-01f, 1.04757451e-01f, 2.27943569e-01f, 2.24578723e-01f, -7.08393753e-02f,
  1.10810645e-01f, 2.88075507e-01f, 1.59489103e-02f, 1.36222646e-01f, 3.83284478e-03f, 2.41725659e-03f, 1.41163349e-01f, -2.25620523e-01f, 8.83988738e-02f, -1.21621229e-01f,
  2.08157882e-01f, -2.82420725e-01f, 3.21616186e-03f, 1.43402696e-01f, 8.36049095e-02f, 2.99313873e-01f, 7.24390075e-02f, -1.21632501e-01f, -1.27116153e-02f, -7.58025646e-02f,
  7.60266781e-02f, -6.57327846e-02f, 1.87542215e-02f, -7.34518170e-02f, 1.92736879e-01f, -5.52183948e-02f, 8.07869136e-02f, 2.32772633e-01f, 1.96039721e-01f, 1.15404524e-01f,
  1.52999088e-01f, 3.09723802e-02f, -4.74668369e-02f, 2.00410321e-01f, 8.41235220e-02f, -1.18254423e-02f, 1.91993669e-01f, 2.84838006e-02f, 2.66623553e-02f, 1.09190181e-01f,
  -5.84102757e-02f, 1.49159759e-01f, 2.01814435e-02f, 3.36965476e-03f, 1.15823388e-01f, -1.27564952e-01f, 1.19219854e-01f, -1.15022548e-01f, 1.41292652e-02f, -8.64065737e-02f,
  4.08397838e-02f, -6.61448538e-02f, 9.19436663e-02f, 8.14338103e-02f, 8.05051774e-02f, 1.81370098e-02f, -7.33396932e-02f, 3.27635696e-03f, 6.64030015e-02f, 8.48586485e-02f,
  -1.54397162e-02f, -1.54076703e-02f, 6.69256225e-02f, 1.27444178e-01f, -1.67885572e-01f, -1.35838807e-01f, 1.52717978e-01f, -1.28693819e-01f, 1.84948161e-01f, 1.49351612e-01f,
  3.81760336e-02f, -7.28202164e-02f, 1.39581058e-02f, -8.43917355e-02f, -1.69718668e-01f, 6.31079078e-02f, -9.39299613e-02f, 1.01331081e-02f, -4.01931815e-02f, -9.76383090e-02f,
  -5.33216484e-02f, 7.39035383e-02f, 2.61390880e-02f, -7.86194205e-02f, 1.27161488e-01f, -6.80696336e-04f, 3.69622139e-03f, -4.63331630e-03f, 1.45194262e-01f, -8.06040019e-02f,
  1.07725328e-02f, 4.76932153e-02f, 2.41876561e-02f, 2.34426139e-03f, -1.30125225e-01f, -9.24746320e-02f, -3.63832265e-02f, -1.10164970e-01f, -1.68774351e-02f, -1.79130621e-02f,
  7.34981820e-02f, -1.03511654e-01f, 1.79280937e-01f, 1.72345564e-01f, -5.09830415e-02f, -4.24817130e-02f, 5.69690950e-02f, -5.02261259e-02f, 2.73243725e-01f, 3.09865456e-03f,
  1.41701683e-01f, 3.40838395e-02f, 1.54020488e-01f, -3.77947092e-02f, -2.33199988e-02f, 1.40227959e-01f, -4.00122926e-02f, 1.04548119e-01f, 9.63370278e-02f, 5.03046140e-02f,
  1.48204625e-01f, -2.83601452e-02f, -4.16676849e-02f, 2.84811053e-02f, 7.68542439e-02f, -1.31190017e-01f, 1.07707664e-01f, -3.40902596e-03f, -1.56770404e-02f, -1.39281765e-01f,
  6.47716001e-02f, 4.86476207e-03f, -1.72829673e-01f, 1.46802694e-01f, -3.21985371e-02f, 1.10913731e-01f, 7.19524473e-02f, 1.26136735e-01f, -1.06053859e-01f, -7.85544235e-03f,
  1.34214088e-01f, -3.28533277e-02f, -2.66158599e-02f, -4.06735577e-02f, -1.24491893e-01f, 1.38997898e-01f, 4.40024175e-02f, -7.88783431e-02f, 1.14823274e-01f, -1.31893337e-01f,
  2.13561505e-02f, -5.50781079e-02f, 3.74757908e-02f, 1.65130906e-02f, -6.10022135e-02f, 4.12376486e-02f, -7.63878152e-02f, -9.32880789e-02f, -1.72429569e-02f, -8.91262889e-02f,
  1.74210798e-02f, -4.88702208e-02f, -1.09046079e-01f, -8.12325180e-02f, 5.94301261e-02f, -1.33159295e-01f, -7.61826485e-02f, -2.93705687e-02f, 8.99574757e-02f, 6.39503300e-02f,
  -1.16371505e-01f, -1.20707534e-01f, -4.44895439e-02f, 8.85618627e-02f, -1.00652784e-01f, -8.25779978e-03f, -5.37410043e-02f, 5.94410226e-02f, -5.13865128e-02f, -9.50719044e-02f,
  -1.02233946e-01f, 9.24840495e-02f, 4.71568964e-02f, 8.37439150e-02f, 1.38242498e-01f, -8.55627656e-02f, 9.67355072e-03f, -2.93359607e-02f, -9.09261312e-03f, -4.00222465e-02f,
  1.51658393e-02f, -7.16525540e-02f, -8.20931345e-02f, -3.37925032e-02f, 1.15093775e-01f, -1.05090797e-01f, 4.05286774e-02f, 1.04990482e-01f, -3.75772491e-02f, -7.73407444e-02f,
  -3.89718935e-02f, -6.40381947e-02f, -1.76567566e-02f, -1.09945625e-01f, 1.09244429e-01f, 9.22693387e-02f, -1.08506083e-01f, 6.52313456e-02f, 2.18119323e-02f, 7.29335472e-02f,
  -2.38367310e-03f, -1.19690657e-01f, -8.34745914e-02f, -6.54626489e-02f, -2.28435900e-02f, -2.15602014e-02f, 1.06788404e-01f, -6.24617329e-03f, 1.02917604e-01f, -1.02700911e-01f,
  3.38736363e-02f, -8.48324522e-02f, -5.72867133e-02f, 1.16460687e-02f, 6.76218793e-02f, -1.16060197e-01f, 1.23064205e-01f, 1.23438135e-01f, -1.16683051e-01f, -1.88440587e-02f,
  8.54303613e-02f, 1.53310910e-01f, -2.67864689e-02f, -3.60065959e-02f, 1.08643472e-01f, 2.76454408e-02f, 2.05977917e-01f, 1.07265025e-01f, -7.50182718e-02f, -3.86050753e-02f,
  8.84110704e-02f, -8.47739913e-03f, 4.98106703e-02f, 2.89900564e-02f, 1.33110881e-01f, -6.55757636e-02f, 5.52031957e-02f, 1.14744022e-01f, 1.24060668e-01f, 6.88007846e-02f,
  5.33301532e-02f, 5.67332879e-02f, 9.18319449e-02f, 1.42539725e-01f, -6.98778778e-02f, 6.97479844e-02f, -1.64261878e-01f, -1.77709356e-01f, 1.04596011e-01f, -2.33109087e-01f,
  2.31119603e-01f, 1.31642759e-01f, -1.07582517e-01f, -3.21091339e-02f, 8.74872059e-02f, -6.78817928e-02f, -5.89021575e-03f, 1.43433183e-01f, 7.13169575e-02f, 1.08259343e-01f,
  -7.86508247e-03f, -1.13926016e-01f, -7.91050345e-02f, -1.28508341e-02f, -7.56150037e-02f, -1.31614178e-01f, 1.91282183e-02f, -1.57858923e-01f, -7.18078092e-02f, -1.41354829e-01f,
  1.68917373e-01f, -1.35831594e-01f, -3.50188930e-03f, -1.57367103e-02f, 1.04727343e-01f, -1.93324557e-03f, -1.26318380e-01f, 1.62276924e-02f, -4.88922074e-02f, -8.07324797e-03f,
  7.42804185e-02f, -2.69830637e-02f, 9.93422717e-02f, -1.03269316e-01f, 8.29315409e-02f, -5.74540952e-03f, 1.04995087e-01f, 3.69800255e-02f, 1.11334734e-01f, -1.68693997e-02f,
  1.84300333e-01f, -5.77020608e-02f, 7.99579993e-02f, 1.24400012e-01f, -7.36753270e-02f, -6.87247291e-02f, -3.44180912e-02f, 2.34537590e-02f, -1.68905839e-01f, 1.65466100e-01f,
  1.14620425e-01f, 1.29086494e-01f, 1.07107133e-01f, -2.94482522e-02f, -7.31819719e-02f, 4.40409733e-03f, 1.55321792e-01f, -1.36070058e-01f, -1.12763442e-01f, -6.27797991e-02f,
  -6.50713220e-02f, 7.90086167e-04f, 1.13968328e-02f, -7.00027775e-03f, -5.10288775e-02f, 1.20369852e-01f, 8.03853273e-02f, 1.01100177e-01f, -8.30256343e-02f, -3.49994339e-02f,
  -1.98098227e-01f, -5.69999628e-02f, 1.71777099e-01f, -1.38057947e-01f, -4.35645394e-02f, 1.10720627e-01f, 1.12179164e-02f, 6.15328662e-02f, 5.73722459e-03f, 7.14969561e-02f,
  7.21534640e-02f, 6.51812926e-02f, -8.61281753e-02f, -1.05044782e-01f, 1.54370055e-01f, -1.03927396e-01f, -6.34415075e-02f, 1.64691340e-02f, -6.74730465e-02f, 7.00362921e-02f,
  -8.20869058e-02f, 4.37408574e-02f, -4.78785522e-02f, -1.16766050e-01f, 8.12496170e-02f, 1.04878858e-01f, 9.26872641e-02f, -5.31774312e-02f, -3.89766730e-02f, -3.61645781e-02f,
  8.39497522e-03f, 8.25337991e-02f, 6.13358170e-02f, 6.79415539e-02f, -9.25505459e-02f, 9.57561657e-02f, -8.99728760e-02f, 4.40597609e-02f, 5.32686859e-02f, -7.67835304e-02f,
  -3.34103256e-02f, 5.56456298e-02f, -4.95231040e-02f, -4.85515743e-02f, 6.39844686e-03f, -4.24103439e-02f, 2.37057321e-02f, 1.03617415e-01f, 8.14778358e-02f, -3.68704535e-02f,
  1.23100445e-01f, 8.62623230e-02f, 3.73885445e-02f, -5.67283370e-02f, -3.18741426e-02f, 1.13344543e-01f, 9.73417684e-02f, -4.43916209e-02f, 6.82100728e-02f, 1.36802634e-02f,
  1.06721543e-01f, 1.27227083e-01f, 9.15229768e-02f, -6.85113156e-03f, 3.88106927e-02f, 4.48660403e-02f, -1.69143137e-02f, 2.21748967e-02f, -1.28257036e-01f, -9.70155597e-02f,
  -8.62044618e-02f, 9.39411223e-02f, -1.02436659e-03f, 1.25250086e-01f, -3.73016745e-02f, -9.01060104e-02f, 7.65485317e-02f, 1.29929036e-01f, -1.02176160e-01f, -1.65318027e-02f,
  -4.17266861e-02f, -1.09169587e-01f, -8.63794610e-02f, -5.11621013e-02f, -2.74291262e-02f, -5.53968027e-02f, -1.14096448e-01f, -3.12569775e-02f, -5.48898568e-03f, 7.07715973e-02f,
  -1.22094572e-01f, -1.01570636e-02f, 1.96322829e-01f, 8.72247219e-02f, 6.80044442e-02f, 4.06003781e-02f, 4.92394157e-02f, 6.39601424e-02f, 1.26171052e-01f, 2.15673462e-01f,
  7.32970759e-02f, 2.59844456e-02f, 1.92617983e-01f, 5.84537983e-02f, 1.69730514e-01f, 2.55827367e-01f, 3.06840986e-01f, 4.63812575e-02f, -8.42662249e-03f, 9.13397074e-02f,
  1.74689312e-02f, 4.67368104e-02f, 1.17518604e-01f, 1.38355628e-01f, -2.69019037e-01f, 1.62113711e-01f, 1.12269334e-01f, -9.36351810e-03f, 1.65410385e-01f, -5.06230257e-02f,
  -5.11823408e-03f, -5.46974503e-02f, 1.08417697e-01f, -1.40521660e-01f, -4.42956686e-02f, -1.08167537e-01f, -1.08226359e-01f, -5.20136720e-03f, 7.68262893e-02f, -1.28759205e-01f,
  -1.15155704e-01f, 2.79364213e-02f, 1.29975989e-01f, -5.92337511e-02f, 2.38847837e-01f, 7.37398788e-02f, 6.36030361e-02f, 6.31440803e-02f, -1.18306570e-01f, 1.56822532e-01f,
  1.38946041e-01f, -1.06859813e-02f, -4.11563180e-02f, 9.75499377e-02f, 3.82278077e-02f, -6.03466034e-02f, 9.73080471e-02f, -6.88694715e-02f, 5.13450243e-02f, -7.64860511e-02f,
  3.27980220e-02f, 9.07944292e-02f, 7.14694932e-02f, 7.31971934e-02f, 1.13227867e-01f, 1.09843053e-01f, 3.25470604e-02f, 7.37613300e-03f, 3.77886556e-02f, 3.57804485e-02f,
  6.61157444e-02f, 3.05203740e-02f, 1.85859390e-02f, 8.19681585e-02f, 1.46536663e-01f, 2.34800577e-01f, 1.73037603e-01f, 1.90209433e-01f, 1.73967145e-02f, 9.40535665e-02f,
  2.18747482e-01f, 1.05861157e-01f, 1.39514565e-01f, -5.54236993e-02f, 1.48767993e-01f, 4.26586941e-02f, 2.74172463e-02f, -1.45311758e-01f, 4.61900234e-02f, 2.17400670e-01f,
  4.11663502e-02f, 5.56370430e-02f, 1.12694673e-01f, 8.51049274e-02f, -1.80330411e-01f, 1.98677089e-02f, 8.51634219e-02f, 4.99221347e-02f, 1.00688808e-01f, -3.40071209e-02f,
  6.48683384e-02f, -1.15896679e-01f, 1.87027425e-01f, 1.22686010e-02f, -6.42628819e-02f, -6.63023368e-02f, 4.04809341e-02f, 8.30152780e-02f, 1.54336393e-02f, -1.13661580e-01f,
  -2.06890125e-02f, 1.29514679e-01f, -4.14644405e-02f, 1.68533653e-01f, 7.81567693e-02f, -6.25165626e-02f, 3.51517126e-02f, 1.43233523e-01f, 4.42495048e-02f, 6.52925149e-02f,
  1.41630977e-01f, -2.71531958e-02f, -6.67527169e-02f, 2.95425244e-02f, -1.11263976e-01f, 2.63597608e-01f, -1.17847525e-01f, -3.08183506e-02f, 2.60633733e-02f, -4.92321514e-02f,
  4.44683544e-02f, -7.28929415e-02f, -2.01231614e-02f, 7.77148232e-02f, -1.08855240e-01f, -1.15009047e-01f, 5.34019545e-02f, -8.49640835e-03f, -4.23367657e-02f, -7.95767084e-02f,
  -9.27096903e-02f, 7.17332512e-02f, -1.33427391e-02f, -6.60687089e-02f, 2.24100742e-02f, -9.08600092e-02f, 7.10154790e-03f, 4.43195850e-02f, 4.46532406e-02f, -4.76695634e-02f,
  1.31462235e-02f, 4.17620130e-02f, 1.22438654e-01f, 1.04700707e-01f, 6.60568476e-02f, 8.13202932e-02f, -5.78527227e-02f, 1.33945718e-01f, -1.11375235e-01f, -8.23410302e-02f,
  -1.40973896e-01f, 1.78561267e-02f, -8.45269859e-02f, -1.73710398e-02f, -2.18513906e-02f, 3.71869691e-02f, 1.24454252e-01f, -9.00897160e-02f, 1.11591779e-01f, 1.97795816e-02f,
  3.43121812e-02f, 7.67331719e-02f, 1.29752802e-02f, -1.23025931e-01f, -1.29427567e-01f, -4.32225317e-02f, 1.06553383e-01f, -3.16915975e-04f, 5.83518185e-02f, -7.51854107e-02f,
  -6.32481873e-02f, 1.78846251e-02f, 2.29543354e-02f, -1.11679258e-02f, 1.66351385e-02f, 1.22235399e-02f, 8.35217088e-02f, 2.69893231e-03f, 7.50215352e-02f, -9.35522765e-02f,
  -9.00883526e-02f, 5.31431399e-02f, 6.16805255e-02f, -6.08966164e-02f, 1.05338730e-01f, -1.24772325e-01f, -1.20442495e-01f, 7.88730606e-02f, 7.76278526e-02f, -1.69222914e-02f,
  -1.02252081e-01f, 1.06035724e-01f, -7.30121210e-02f, -7.89156035e-02f, 9.19364113e-03f, -8.47001821e-02f, 2.77906042e-02f, -3.58482003e-02f, -1.05642535e-01f, -3.75081711e-02f,
  -5.98689318e-02f, -7.98115414e-03f, -4.44386899e-02f, 9.59273428e-02f, 1.30401433e-01f, 2.97619998e-02f, -3.20954733e-02f, 1.99184101e-02f, 2.44027842e-03f, 6.43431693e-02f,
  -1.20809548e-01f, 6.51544482e-02f, -5.40614054e-02f, 2.62818206e-02f, 5.15981615e-02f, 8.84507969e-02f, -8.45697243e-03f, 3.13442014e-02f, 7.67442435e-02f, 4.58131125e-03f,
  6.44305348e-02f, -8.12129453e-02f, -3.42760608e-02f, 2.79609747e-02f, 9.43495855e-02f, 2.72850525e-02f, -4.70151380e-02f, -8.76660571e-02f, -1.08628850e-02f, 1.05006531e-01f,
  9.20355394e-02f, 5.27521558e-02f, 1.19328298e-01f, 7.77686015e-02f, -1.12626560e-01f, -5.32791130e-02f, -8.71911347e-02f, 9.04810578e-02f, 1.11653887e-01f, -9.90694314e-02f,
  -5.61560653e-02f, -3.48884091e-02f, -4.14510481e-02f, -1.26174651e-02f, 8.67967233e-02f, 7.28504434e-02f, 3.05528007e-02f, 8.53574648e-02f, 1.17306061e-01f, -1.82127599e-02f,
  1.05967693e-01f, 7.61323497e-02f, 2.75197383e-02f, -6.08202778e-02f, -2.55367849e-02f, 2.38847663e-03f, -1.80355110e-03f, -1.04525298e-01f, -1.36507437e-01f, 4.09332067e-02f,
  -4.14539576e-02f, 1.22862861e-01f, -7.03985915e-02f, 7.30036432e-03f, -1.38320312e-01f, 1.11345887e-01f, 6.09278902e-02f, 5.28253382e-03f, -1.10663585e-01f, -2.72715054e-02f,
  7.93139860e-02f, -4.52067479e-02f, -2.56925449e-02f, 2.64522154e-02f, 1.80960409e-02f, 5.43469042e-02f, -1.04041258e-02f, 6.98013380e-02f, -7.79173821e-02f, 3.23770009e-02f,
  -3.80560756e-03f, -1.35330399e-02f, -2.72809677e-02f, -1.75594047e-01f, 1.02512345e-01f, 1.11607946e-01f, 3.30449529e-02f, 5.64435758e-02f, -1.28592148e-01f, 1.36838272e-01f,
  1.08201005e-01f, -1.12445414e-01f, -1.06234044e-01f, 1.91784482e-02f, 7.51416534e-02f, 1.63703766e-02f, -1.02708243e-01f, -6.35034740e-02f, 8.08378756e-02f, 6.48333058e-02f,
  -9.87556055e-02f, -2.53363680e-02f, 1.16013112e-02f, -4.90761250e-02f, -5.29674180e-02f, -3.00105773e-02f, 1.88896731e-02f, 1.20050393e-01f, 3.19373682e-02f, -5.36765158e-02f,
  1.89883187e-02f, 3.40910070e-02f, -6.95858374e-02f, 1.35118604e-01f, -5.60575165e-02f, -8.66531767e-03f, -4.34235111e-02f, 1.23611219e-01f, 5.72860800e-03f, -1.22583218e-01f,
  1.18733026e-01f, -4.89055216e-02f, 1.30739853e-01f, 3.17888660e-03f, 2.31687240e-02f, -9.28723738e-02f, 3.03929858e-02f, 6.08290508e-02f, -8.03749710e-02f, 5.87596856e-02f,
  -2.10315175e-02f, 8.41012038e-03f, -3.27933095e-02f, 2.44418960e-02f, -3.73947471e-02f, -1.06717028e-01f, 9.10736769e-02f, 7.16634048e-03f, 7.35591799e-02f, 5.28199486e-02f,
  4.24448587e-02f, -1.01503611e-01f, 1.65891618e-01f, 3.77497897e-02f, -1.10897079e-01f, 8.74501094e-02f, 1.51797995e-01f, -1.47551551e-01f, -7.23358765e-02f, -4.48665731e-02f,
  -1.22998074e-01f, 1.40178248e-01f, 9.49286669e-02f, -1.71915926e-02f, 1.21776082e-01f, 2.42161751e-03f, -3.11380010e-02f, -1.90459024e-02f, 1.41255885e-01f, 2.51554288e-02f,
  5.16546071e-02f, 4.81719006e-04f, 2.73441430e-02f, 5.99971674e-02f, -3.95537168e-02f, 2.83265244e-02f, -1.84464473e-02f, 1.16373271e-01f, 5.22788502e-02f, -9.63904615e-03f,
  1.26678213e-01f, 1.33928493e-01f, 5.23518026e-02f, -6.04091510e-05f, 7.05758706e-02f, 3.64503786e-02f, -5.09927347e-02f, 8.28572214e-02f, 1.23774812e-01f, 1.30230635e-02f,
  1.95178747e-01f, 8.52044765e-03f, 1.41634956e-01f, 2.02786818e-01f, -1.17546089e-01f, 1.30982518e-01f, 8.50768834e-02f, 8.17540139e-02f, -1.09263323e-01f, 1.81137898e-03f,
  2.35421151e-01f, 4.20318805e-02f, 3.35698202e-02f, 1.34751853e-02f, -3.19413953e-02f, -2.20902696e-01f, -1.03387564e-01f, -1.97687522e-01f, 1.52690023e-01f, 1.53081045e-01f,
  -1.59967214e-01f, 7.54068941e-02f, -3.56856249e-02f, 2.39720017e-01f, -5.43688536e-02f, 9.57020298e-02f, -9.17643607e-02f, -7.53013697e-03f, -5.66270538e-02f, -1.12364888e-01f,
  -4.05718610e-02f, 5.54907881e-03f, 9.91401151e-02f, -1.84141770e-01f, -3.28573696e-02f, 3.27147543e-02f, 5.68302646e-02f, 1.04514649e-02f, -7.06262738e-02f, -9.62166861e-02f,
  -4.70584892e-02f, -1.60473436e-01f, 9.23239887e-02f, -6.93461522e-02f, 6.20538816e-02f, -1.95349157e-02f, -8.26962069e-02f, 2.36208700e-02f, -4.02571149e-02f, 1.04874343e-01f,
  4.11010087e-02f, -1.34295806e-01f, 1.67627469e-01f, 3.30831289e-01f, -1.32200256e-01f, -8.09832737e-02f, 5.16716652e-02f, -5.37970066e-02f, 1.38623983e-01f, -4.11043242e-02f,
  -1.23819813e-01f, -1.80798080e-02f, 2.03045622e-01f, -2.00793874e-02f, -6.44730553e-02f, 1.47518679e-01f, -1.79169506e-01f, -1.53765708e-01f, 1.41279204e-02f, 9.92367491e-02f,
  7.31099024e-02f, 1.01082705e-01f, 1.60274222e-01f, 7.36464933e-02f, 1.21284081e-02f, 1.98772311e-01f, -7.90484622e-02f, -1.09836878e-02f, -6.43637544e-03f, -1.48442358e-01f,
  -6.03406094e-02f, -1.31915644e-01f, -8.83371904e-02f, 1.03876032e-02f, -1.06536686e-01f, -3.98156419e-02f, 7.78763667e-02f, 8.18813220e-02f, -1.13100506e-01f, -3.24835777e-02f,
  -1.96043298e-01f, -2.02111244e-01f, 2.39708990e-01f, 1.81609452e-01f, -3.51708569e-02f, -1.88992918e-01f, 1.95355222e-01f, -1.11658685e-01f, 7.18738511e-02f, 4.41944636e-02f,
  3.38660330e-02f, 1.45054176e-01f, -4.75369729e-02f, -2.83725597e-02f, 1.67951807e-01f, 1.92513168e-02f, 2.95348000e-02f, 9.21682164e-04f, -2.98482701e-02f, -9.81836170e-02f,
  -2.13622935e-02f, 7.11806491e-02f, 1.45118777e-02f, 1.53123021e-01f, 8.56084377e-02f, 3.29615697e-02f, -1.41380960e-02f, 1.29419848e-01f, 1.15841851e-01f, 1.81682229e-01f,
  5.82793579e-02f, 1.40988767e-01f, -7.33727589e-02f, 3.43345255e-02f, -6.79675490e-02f, 9.34289098e-02f, 3.33324336e-02f, -2.33340245e-02f, 2.23276149e-02f, 1.15342923e-02f,
  2.15608943e-02f, -3.62701416e-02f, -7.80062824e-02f, -8.17866102e-02f, 5.31569235e-02f, 8.42824206e-02f, 3.16314325e-02f, 3.08869835e-02f, -1.97248489e-01f, -3.60990092e-02f,
  7.67484829e-02f, -8.89540389e-02f, 1.59573272e-01f, -1.28984004e-02f, -1.03310592e-01f, 9.28427354e-02f, 9.79209021e-02f, 8.01913142e-02f, 1.65416256e-01f, 7.61814117e-02f,
  3.35186757e-02f, -4.75811511e-02f, 5.83676174e-02f, 2.49569230e-02f, -2.04994082e-02f, 9.91431996e-02f, -1.36008501e-01f, 2.41500810e-02f, 1.38009265e-01f, 1.76856257e-02f,
  -1.60509780e-01f, -1.54511640e-02f, 1.99188933e-01f, 3.55747296e-03f, -8.57453197e-02f, 1.03023455e-01f, 1.69530604e-02f, 1.18860848e-01f, 9.29577351e-02f, 1.59797147e-02f,
  9.51669887e-02f, -1.29053235e-01f, 6.73822612e-02f, -3.28801833e-02f, 1.05968907e-01f, 4.48376201e-02f, 1.19352683e-01f, -1.05328910e-01f, 1.15577161e-01f, 8.23234841e-02f,
  2.76499763e-02f, 1.05341680e-01f, -5.91960400e-02f, -3.69708799e-02f, 5.32804802e-03f, -6.06644489e-02f, -3.93551178e-02f, -1.07990569e-02f, 2.28774950e-01f, 7.62051120e-02f,
  2.09356453e-02f, 1.21214204e-01f, 1.58472836e-01f, 1.55162841e-01f, 1.70452565e-01f, 8.84369016e-02f, -7.84200337e-03f, 1.27867103e-01f, 1.62084937e-01f, 1.51177198e-01f,
  1.95155486e-01f, 1.40706956e-01f, 1.23474248e-01f, 6.28075749e-02f, 8.40666592e-02f, -1.26302019e-02f, 2.89353281e-02f, 7.95554444e-02f, -5.90452887e-02f, 3.51982713e-02f,
  -1.72358170e-01f, -6.26550466e-02f, 1.03077993e-01f, -1.48480562e-02f, 3.65610085e-02f, -1.96388394e-01f, 7.80355036e-02f, -3.91019136e-02f, 6.43509999e-02f, -5.06393723e-02f,
  -1.16237566e-01f, -1.24159470e-01f, 3.23914550e-02f, 1.36670470e-01f, -8.31209198e-02f, 1.43053904e-01f, -8.87246877e-02f, -2.69087311e-02f, -2.18084585e-02f, -3.26139219e-02f,
  1.30129419e-02f, -1.12264298e-01f, -3.15328268e-03f, -3.14932782e-03f, -4.80196141e-02f, 3.35953012e-02f, -6.76940084e-02f, -7.82254562e-02f, 1.26422122e-01f, -2.27060448e-02f,
  4.27919887e-02f, -1.08556874e-01f, 4.36591683e-03f, 1.86013103e-01f, 8.39082226e-02f, 7.92235881e-03f, 9.79902893e-02f, 1.26188129e-01f, -7.86807984e-02f, 1.05798207e-01f,
  -2.42224950e-02f, -1.60395265e-01f, 1.46443143e-01f, 1.05324812e-01f, -1.38241455e-01f, 5.40313050e-02f, 1.33341178e-01f, 1.94796920e-01f, 7.48599023e-02f, 1.16685048e-01f,
  9.63522717e-02f, 2.58452501e-02f, 1.24589927e-01f, 8.32864344e-02f, 1.04847409e-01f, 1.36890680e-01f, 1.53203785e-01f, 1.77724257e-01f, 1.76211163e-01f, 2.97238976e-02f,
  5.05964383e-02f, 7.46569782e-02f, -4.66117002e-02f, 1.83113202e-01f, -5.12669347e-02f, -2.92254165e-02f, -1.32786244e-01f, -3.77481394e-02f, -1.48013026e-01f, -2.82284394e-02f,
  1.13492556e-01f, -2.82656610e-01f, 2.74278909e-01f, 1.41108200e-01f, -7.77811706e-02f, -1.37340367e-01f, -3.34610492e-02f, 1.13708489e-01f, -1.58327341e-01f, 1.62817150e-01f,
  -1.43637270e-01f, 2.14817841e-02f, 1.05546921e-01f, 1.39255822e-03f, 2.29693383e-01f, -1.00659579e-01f, -7.13461339e-02f, -5.62304072e-02f, 3.26330550e-02f, 5.28933629e-02f,
  3.24754417e-02f, 7.60657415e-02f, 1.91303808e-02f, 1.17765233e-01f, 1.18977152e-01f, -8.49779248e-02f, 5.49611598e-02f, -1.45122204e-02f, 7.58368801e-03f, -1.60058260e-01f,
  2.26075966e-02f, -4.50536907e-02f, 4.00145985e-02f, -1.04441009e-01f, -4.54080552e-02f, 4.78326865e-02f, -1.15004189e-01f, 6.19459227e-02f, -3.98404598e-02f, 1.30922288e-01f,
  -4.23558876e-02f, 7.22244754e-02f, -7.83907995e-02f, 3.32727730e-02f, 3.99296246e-02f, 8.28032866e-02f, 6.37380406e-02f, 1.43484637e-01f, 1.28948718e-01f, 6.33958727e-02f,
  1.35495484e-01f, -7.40709379e-02f, -9.18156356e-02f, -5.27560562e-02f, -1.66367050e-02f, -7.15219975e-02f, 3.46374400e-02f, -4.93987910e-02f, -6.55409470e-02f, 1.67035654e-01f,
  9.88015234e-02f, -6.58275187e-02f, -4.24438789e-02f, 2.05038741e-01f, -1.21612616e-01f, 1.19681224e-01f, 2.13461109e-02f, -1.14521511e-01f, 9.56530645e-02f, 4.26113084e-02f,
  3.12857777e-02f, -2.15855315e-01f, 2.11986601e-01f, 9.81717035e-02f, 4.54330854e-02f, 2.69954521e-02f, 5.01295887e-02f, 1.13495193e-01f, 1.86863065e-01f, -1.28386110e-01f,
  -6.39034212e-02f, -1.12806156e-01f, -4.21679355e-02f, -2.46529803e-02f, 7.76624158e-02f, -8.74725655e-02f, -7.53866658e-02f, 1.14960514e-01f, 8.63069221e-02f, -1.87431253e-03f,
  1.47303060e-01f, -7.73725063e-02f, 5.96118905e-02f, -6.15447946e-02f, -1.31510738e-02f, 9.94313434e-02f, 5.64770773e-03f, -1.16855569e-01f, 1.14897840e-01f, 1.57329924e-02f,
  -8.14462230e-02f, 1.81436062e-01f, 9.46273562e-03f, 1.69967696e-01f, -3.73199768e-02f, -1.51897473e-02f, 1.40181646e-01f, 2.29724750e-01f, -4.46355948e-03f, 2.61757746e-02f,
  1.16767073e-02f, 4.96157147e-02f, -8.77898128e-04f, 1.21013388e-01f, 1.81708023e-01f, 6.94049001e-02f, -3.48859355e-02f, -2.47432925e-02f, 5.17061129e-02f, -4.30249572e-02f,
  5.98491542e-03f, -1.40127435e-01f, 1.62629023e-01f, 4.53283116e-02f, -9.37640667e-02f, -3.58636230e-02f, 9.62533727e-02f, -6.36046529e-02f, -1.29334986e-01f, 1.68759212e-01f,
  -2.26156101e-01f, -1.49994716e-01f, -6.02625171e-03f, -9.35480669e-02f, -1.05720848e-01f, 2.23982587e-01f, -8.36059079e-02f, -5.61002232e-02f, 1.55178323e-01f, -6.18342720e-02f,
  -6.50475696e-02f, 4.94428873e-02f, -1.05035953e-01f, 5.45296147e-02f, -1.09903896e-02f, -5.98636549e-03f, -7.72737861e-02f, -1.52256057e-01f, -1.38150439e-01f, -3.93624231e-02f,
  -1.53660018e-03f, -1.04374960e-01f, -1.91292595e-02f, -3.68824676e-02f, 1.27965778e-01f, -1.69766397e-04f, 1.48506220e-02f, 5.90853579e-02f, -3.01212166e-03f, -8.81082192e-02f,
  7.43544772e-02f, -4.50856984e-02f, 2.97260974e-02f, -5.57830334e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.19759813e-01f, 1.25203878e-02f, 1.85645193e-01f, 1.89024791e-01f, 4.67537716e-02f, 1.07509375e-01f, 6.20081164e-02f, -1.42529185e-04f, 1.74248978e-01f, -1.13599887e-02f,
  -2.01667892e-03f, 5.52556813e-02f, -1.04273342e-01f, 5.19682877e-02f, 6.99894801e-02f, 3.21339257e-02f, -6.30141795e-02f, -9.85804126e-02f, -5.53516857e-02f, 5.81769571e-02f,
  1.32004470e-01f, 2.08167154e-02f, -4.69083112e-04f, 2.05521360e-01f, 1.29504666e-01f, -1.95153076e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.57455623e-02f, -1.24812834e-02f, -1.42734170e-01f, -1.93010777e-01f, -1.28286958e-01f, 1.16271362e-01f, 1.78296819e-01f, -1.13898866e-01f, -1.15351215e-01f, 1.43717825e-01f,
  -1.33254424e-01f, 2.13969890e-02f, -2.88580626e-01f, 9.82431322e-02f, -1.85659826e-01f, -4.68799211e-02f, -1.35437876e-01f, -1.57576248e-01f, -1.29337549e-01f, -1.30009890e-01f,
  8.40756744e-02f, 1.05152920e-01f, 4.36966047e-02f, 1.61828056e-01f, -2.09864944e-01f, 1.95761576e-01f, 3.40649217e-01f, -1.16810985e-01f, -4.62037474e-01f, 1.62322223e-01f,
  3.65959704e-02f, 1.57350659e-01f, 1.04247592e-01f, -8.12343508e-02f, 4.07921493e-01f, 6.52269796e-02f, -2.54739195e-01f, -9.21866372e-02f, -3.11823022e-02f, 2.81751249e-02f,
  1.00232787e-01f, -1.27113033e-02f, -1.54087603e-01f, -1.78503641e-03f, -3.31256926e-01f, -8.60224888e-02f, 1.67036369e-01f, 4.68693413e-02f, -1.35486927e-02f, 1.48225069e-01f,
  1.36067241e-01f, -1.81853026e-01f, 7.79481605e-02f, -4.32646014e-02f, 1.11024022e-01f, 4.67042215e-02f, -1.00975841e-01f, 1.27510533e-01f, -6.69348910e-02f, 2.59908307e-02f,
  -6.86760545e-02f, -1.48934588e-01f, -2.13249903e-02f, 4.23614681e-02f, 2.22803935e-01f, 8.95549953e-02f, 4.12005968e-02f, -6.76036328e-02f, 3.27271149e-02f, -9.42807868e-02f,
  1.49201574e-02f, -5.26420400e-03f, 1.67928994e-01f, 1.79676473e-01f, 3.41964290e-02f, -6.11849688e-02f, 4.63542603e-02f, 7.22484365e-02f, 1.10362619e-01f, -1.00670420e-01f,
  1.56316638e-01f, 5.64766787e-02f, 1.07590156e-02f, -1.49048746e-01f, -2.11482793e-01f, 6.91623613e-02f, -2.46848881e-01f, 1.84855774e-01f, -1.42290145e-01f, -3.72657508e-01f,
  3.09548080e-02f, 1.02805369e-01f, -2.68500149e-01f, 3.85597423e-02f, 1.00046277e-01f, -6.04603179e-02f, 7.27790454e-03f, 1.39414802e-01f, 8.67295712e-02f, 1.20808713e-01f,
  -1.49355739e-01f, 1.94519207e-01f, -1.02550440e-01f, -1.43533677e-03f, -7.37184891e-03f, 1.01704784e-01f, -1.77279368e-01f, -9.28179175e-02f, 1.19589858e-01f, -1.63619712e-01f,
  -1.21288456e-01f, 7.14939237e-02f, -1.40804946e-01f, -1.69357851e-01f, 1.35574406e-02f, -5.49321137e-02f, 2.28317231e-01f, -9.84603167e-03f, -7.34898001e-02f, 7.62282461e-02f,
  -4.27718200e-02f, 1.24451593e-01f, 2.11474717e-01f, -3.40353251e-02f, -3.71302664e-02f, -6.98370114e-02f, 1.14264742e-01f, 1.36823222e-01f, 1.51488120e-02f, 2.45490693e-03f,
  1.31813467e-01f, 2.87271947e-01f, 2.23501727e-01f, -8.21739957e-02f, -1.09397754e-01f, -9.96076167e-02f, 4.00941335e-02f, 6.09035380e-02f, -1.08355023e-01f, -1.35327041e-01f,
  1.96491972e-01f, -1.20947331e-01f, 2.82235481e-02f, -1.25790775e-01f, 7.73292333e-02f, 7.64080212e-02f, -5.41159734e-02f, 6.51780143e-02f, -3.37105580e-02f, 9.26478021e-03f,
  -2.20293507e-01f, 1.70169160e-01f, -5.03183948e-03f, -3.47516447e-01f, -1.34410039e-01f, -2.90095285e-02f, 1.65632889e-01f, -2.45771691e-01f, -2.03075364e-01f, -3.41690257e-02f,
  -9.58396867e-02f, 2.27376327e-01f, -1.54322222e-01f, -6.84041753e-02f, 1.15990803e-01f, 1.78065076e-01f, -1.32851198e-01f, -2.48236042e-02f, -1.34357139e-01f, -6.25774711e-02f,
  -2.04539802e-02f, -5.51001988e-02f, 1.34301186e-01f, 4.42224033e-02f, 4.56298366e-02f, -1.24628581e-02f, -1.39317170e-01f, -1.69790283e-01f, 9.27506387e-02f, 2.15398416e-01f,
  1.99589521e-01f, -1.10838674e-01f, -5.96926957e-02f, 7.07032457e-02f, -5.05703241e-02f, -1.72854796e-01f, -5.71733620e-03f, -1.28452793e-01f, 8.09328035e-02f, -1.63013488e-02f,
  1.87876113e-02f, -8.48366693e-02f, 6.54198751e-02f, -8.91241878e-02f, -4.14280221e-02f, -7.60188326e-02f, -1.21627599e-02f, 7.29366392e-02f, -4.51594628e-02f, 5.68016060e-02f,
  5.04425466e-02f, -1.03987664e-01f, -1.03191555e-01f, 1.09564468e-01f, -1.10521957e-01f, -6.96552917e-02f, 7.60713071e-02f, 7.30376393e-02f, 2.25242078e-01f, 1.06704630e-01f,
  -8.16447586e-02f, 6.25443682e-02f, -2.51635648e-02f, 1.39944628e-01f, -2.46506110e-01f, 1.31566659e-01f, -1.94135487e-01f, -7.12611750e-02f, 3.29867661e-01f, -2.18453646e-01f,
  -3.21956910e-02f, -2.63809655e-02f, 1.44398779e-01f, -1.97902322e-01f, 2.05626935e-01f, 1.82784617e-01f, 2.74844646e-01f, 3.07711363e-02f, -2.27141678e-01f, -1.63869455e-01f,
  -1.34361103e-01f, -7.86753371e-02f, -2.04953868e-02f, -2.44028956e-01f, 5.17171994e-03f, 5.84376752e-02f, -1.84041381e-01f, -8.00189301e-02f, 1.04034401e-01f, 6.76725656e-02f,
  -1.59026533e-01f, 8.16029534e-02f, 9.19495597e-02f, 1.13390297e-01f, 1.97352264e-02f, -6.92018941e-02f, 6.55041495e-03f, -1.09476328e-01f, -4.98092324e-02f, -8.75412673e-02f,
  -1.02996498e-01f, -5.84814325e-02f, 7.58815408e-02f, -9.83217582e-02f, 7.29941530e-03f, 1.70693815e-01f, 5.64650781e-02f, 4.83374260e-02f, 1.30982414e-01f, -2.27892015e-04f,
  3.12212063e-03f, 5.13000377e-02f, 1.69811755e-01f, -1.53107658e-01f, 4.21111509e-02f, -1.38927653e-01f, 1.43686473e-01f, -1.15112461e-01f, 1.14265524e-01f, -2.45343186e-02f,
  2.62737960e-01f, 4.64582480e-02f, -1.97856903e-01f, -9.21554267e-02f, 3.45039112e-03f, -1.63957074e-01f, 1.74304113e-01f, -1.74456581e-01f, 2.18847245e-01f, 2.23450869e-01f,
  -2.37549037e-01f, -1.73132997e-02f, 3.47928819e-03f, -2.27725133e-01f, 7.82857463e-02f, -2.41925150e-01f, 7.63412416e-02f, 2.19282895e-01f, 1.16640717e-01f, -1.28267705e-01f,
  -1.54186040e-02f, -2.31376395e-01f, -1.43728312e-02f, 1.15058295e-01f, -1.43525243e-01f, 8.22167695e-02f, 1.87805921e-01f, -2.45891176e-02f, 8.92983899e-02f, -8.43358636e-02f,
  -1.33596018e-01f, -2.06541326e-02f, 4.00546566e-03f, -1.28737554e-01f, 2.38280758e-01f, -8.23446289e-02f, 1.15656652e-01f, 2.81788837e-02f, -1.22740693e-01f, 8.15473199e-02f,
  -1.10528365e-01f, -9.00552794e-02f, -1.09039791e-01f, 1.35543615e-01f, -7.51780942e-02f, -1.67575270e-01f, 4.94165439e-03f, 2.20926866e-01f, -2.45850999e-02f, 1.08311012e-01f,
  -2.08066165e-01f, -7.66351745e-02f, 9.36431959e-02f, 2.30009153e-01f, 1.37738228e-01f, -1.19858265e-01f, -3.30029279e-02f, -6.38063774e-02f, 9.90199596e-02f, -6.42088205e-02f,
  -8.69728178e-02f, 5.46612255e-02f, 2.77561069e-01f, 2.62798872e-02f, 1.63912162e-01f, 4.83443402e-02f, 1.13397352e-01f, 4.68915589e-02f, 1.19600696e-02f, 1.34606689e-01f,
  -5.69826737e-03f, 7.28786513e-02f, -2.21986383e-01f, 1.09799467e-01f, 1.86428934e-01f, -4.19150025e-01f, -2.18382940e-01f, 3.14186439e-02f, 2.99717695e-01f, -1.13030136e-01f,
  1.28309447e-02f, -2.91858166e-01f, -1.08443862e-02f, 1.16683831e-02f, -3.49756151e-01f, -9.39292908e-02f, 1.09382197e-01f, -9.76807997e-02f, 4.78863046e-02f, 7.79601336e-02f,
  -1.67684987e-01f, 1.69227412e-03f, -1.27617996e-02f, 7.64746293e-02f, 1.39085710e-01f, 5.73720075e-02f, -1.55747652e-01f, 3.36633506e-03f, 9.90747567e-03f, -1.90269381e-01f,
  -4.91353795e-02f, 4.47264351e-02f, -9.48322751e-03f, -5.71223013e-02f, 1.10086255e-01f, 3.04798484e-02f, 4.16663475e-02f, 1.83196682e-02f, -5.02696522e-02f, -7.34788924e-02f,
  1.29558727e-01f, 1.33130819e-01f, 1.07056856e-01f, -4.22719792e-02f, -3.30573544e-02f, -8.05812925e-02f, -2.42013801e-02f, -1.64054707e-01f, -8.81267413e-02f, 1.52154550e-01f,
  -5.63368239e-02f, -6.17957562e-02f, 4.61395420e-02f, -5.45545630e-02f, 3.44182854e-03f, -3.62436734e-02f, -1.51685834e-01f, -5.16869985e-02f, -1.57278866e-01f, -1.31452337e-01f,
  -2.65157402e-01f, 1.53105631e-01f, -1.47691563e-01f, 1.48651237e-02f, -9.79185551e-02f, -1.55390814e-01f, 2.34698981e-01f, -2.63339460e-01f, 9.09478497e-03f, 4.37632620e-01f,
  -2.42572606e-01f, 1.33451253e-01f, -6.17763028e-02f, 1.69469133e-01f, -2.20814630e-01f, 3.06286603e-01f, -1.77316785e-01f, -2.56354809e-01f, -1.30676270e-01f, 5.21553904e-02f,
  1.56495616e-01f, 1.33385941e-01f, 1.19440474e-01f, 1.84907913e-01f, -2.90087461e-02f, -3.10117621e-02f, 1.04069658e-01f, 2.26976741e-02f, 2.42345128e-02f, 1.52439848e-01f,
  6.97904304e-02f, 2.81763598e-02f, -3.32616121e-02f, -2.91503649e-02f, 9.64529589e-02f, -1.51509754e-02f, 7.50447288e-02f, -1.84980482e-02f, -1.12897612e-01f, 8.48165080e-02f,
  1.90750808e-01f, -2.45816931e-01f, 9.95758995e-02f, 4.50609773e-02f, -1.22988530e-01f, 1.85377998e-04f, 1.12756096e-01f, -1.99394256e-01f, 7.91259781e-02f, 1.19866528e-01f,
  -6.18994012e-02f, -1.26485720e-01f, -5.74497208e-02f, 8.86419863e-02f, 1.11708149e-01f, -1.82295740e-02f, 4.11775000e-02f, 1.67008653e-01f, -9.63657424e-02f, 7.02442452e-02f,
  -7.21200258e-02f, 2.23212197e-01f, 6.35796264e-02f, -7.95487314e-02f, 2.06148982e-01f, 1.58987399e-02f, 6.42998368e-02f, 1.13931462e-01f, -9.23062488e-02f, 1.25268131e-01f,
  -4.13416736e-02f, -1.03851803e-01f, 1.03442192e-01f, -1.27696395e-02f, -2.00957768e-02f, 3.32217604e-01f, -1.37813032e-01f, 1.54217109e-01f, -4.14066948e-02f, -4.99219969e-02f,
  4.71906140e-02f, 7.49651790e-02f, -1.14775598e-01f, 2.11441338e-01f, -1.37634501e-01f, 1.30948737e-01f, 2.32815742e-01f, 1.79588467e-01f, -2.22966939e-01f, 1.03249028e-01f,
  -1.45559479e-02f, -8.74716602e-03f, 2.54467338e-01f, -4.55171168e-02f, 1.08584249e-02f, 2.30817925e-02f, 6.74101934e-02f, 1.25987396e-01f, 3.88304070e-02f, -1.24668330e-01f,
  -1.14477448e-01f, -7.51661211e-02f, 2.93972902e-02f, -8.91134068e-02f, -8.74311477e-02f, -3.35066579e-02f, 2.52528042e-02f, 1.49645120e-01f, -1.29461765e-01f, -1.02404512e-01f,
  4.07425966e-03f, 1.13897678e-03f, -1.22474305e-01f, -5.95146604e-02f, 9.70490724e-02f, 6.75636232e-02f, -1.15315475e-01f, 1.64929463e-03f, 1.30931810e-01f, -1.09007016e-01f,
  1.09531701e-01f, 1.50510475e-01f, 6.77671209e-02f, 1.40156478e-01f, 1.54072672e-01f, 1.15260728e-01f, 1.72895804e-01f, 1.77252948e-01f, 2.50723481e-01f, -1.06118701e-01f,
  4.07518670e-02f, -7.16694593e-02f, 6.55082613e-02f, 4.45144996e-02f, -2.40536049e-01f, -4.07959186e-02f, -9.72906798e-02f, -1.85036942e-01f, 4.37337548e-01f, 1.46714449e-01f,
  -2.19740167e-01f, -3.14276777e-02f, 2.44917810e-01f, -2.44891822e-01f, 5.40134311e-02f, 1.54809326e-01f, 5.57885244e-02f, 2.46694759e-01f, -1.32036671e-01f, -5.86325629e-03f,
  2.26180673e-01f, -8.35093483e-02f, 1.44397793e-02f, -2.09980384e-01f, 4.37193252e-02f, -8.52795094e-02f, -5.34178168e-02f, -3.42350975e-02f, 1.90170184e-01f, 9.97805372e-02f,
  -3.95020843e-03f, 4.56812931e-03f, -1.01924680e-01f, -1.12676978e-01f, 9.25870463e-02f, 5.14165834e-02f, 9.00947377e-02f, -4.04581148e-03f, -1.59632608e-01f, 2.02179566e-01f,
  3.78072262e-02f, 1.21746473e-02f, 1.25794560e-01f, -7.45550469e-02f, -9.43919122e-02f, 1.92689970e-01f, 1.61100715e-01f, 3.48508582e-02f, 1.58136249e-01f, 3.84703614e-02f,
  -5.46618700e-02f, 1.39218345e-01f, 9.59290490e-02f, -1.54606968e-01f, 1.66883454e-01f, 1.61356449e-01f, 3.61138061e-02f, 2.83691548e-02f, -6.12065271e-02f, 5.54306321e-02f,
  1.17893331e-01f, 1.62317246e-01f, 1.82441965e-01f, -1.24181084e-01f, 1.69422571e-02f, -1.14665158e-01f, 2.18531061e-02f, -1.36257142e-01f, 3.38836201e-03f, -5.29285632e-02f,
  -7.46854246e-02f, 2.11334512e-01f, 1.91317961e-01f, -1.84539676e-01f, -1.85820773e-01f, 1.42082244e-01f, 1.29973248e-01f, 2.09001467e-01f, 1.43297389e-01f, -1.61637858e-01f,
  1.88222408e-01f, 4.38170247e-02f, 1.88486353e-02f, -8.85196328e-02f, 1.83580860e-01f, 1.42322108e-01f, 1.81547016e-01f, -2.21488193e-01f, 8.65361243e-02f, 1.36923999e-01f,
  -3.11334431e-01f, 5.58263771e-02f, 9.37186331e-02f, -5.68135194e-02f, 5.85703626e-02f, 1.05937749e-01f, 8.26930553e-02f, -1.60062954e-01f, -1.49084151e-01f, 2.58361977e-02f,
  5.68650402e-02f, -1.33939892e-01f, 1.08417742e-01f, -9.47769731e-03f, -4.88407277e-02f, 6.13445677e-02f, -9.00499746e-02f, 1.50579348e-01f, -1.26846060e-01f, 3.78277414e-02f,
  1.27348140e-01f, -2.41762586e-02f, 3.04767266e-02f, 3.31153977e-03f, -3.07096932e-02f, 1.60289537e-02f, 1.17136687e-02f, -1.14379480e-01f, 7.83918500e-02f, 5.94522804e-02f,
  7.56899863e-02f, -1.46931544e-01f, -1.80663392e-01f, -9.58099738e-02f, -1.89477298e-02f, -1.67118594e-01f, -1.25766188e-01f, -9.68551710e-02f, -1.85271248e-01f, -2.04267383e-01f,
  -1.84814721e-01f, 7.75827616e-02f, -1.28466720e-02f, 2.70252764e-01f, -1.78330824e-01f, -6.53801337e-02f, -2.52154112e-01f, -1.51496306e-01f, -1.05814964e-01f, 3.78678180e-03f,
  -1.28953293e-01f, -1.92332223e-01f, -1.70504749e-01f, 1.05900146e-01f, -4.36648540e-02f, 2.46654004e-02f, 3.00535783e-02f, 2.97529101e-01f, -1.56832412e-01f, -6.28079996e-02f,
  3.78212109e-02f, 1.53336823e-01f, -1.50594279e-01f, 7.61433563e-04f, 8.17115232e-02f, -1.07000895e-01f, -1.95639774e-01f, 1.16705103e-02f, -3.05512212e-02f, -1.49773121e-01f,
  1.33025169e-01f, 6.22485578e-02f, 2.30756715e-01f, -1.44283874e-02f, 1.38138428e-01f, 7.50999302e-02f, 3.63177881e-02f, 1.54189065e-01f, 2.11471185e-01f, -1.62036479e-01f,
  -1.16015553e-01f, -8.54479298e-02f, 3.22828582e-03f, 1.87450852e-02f, 1.45096332e-01f, -1.14275785e-02f, 3.71816568e-02f, 1.48512807e-03f, 6.59475401e-02f, -8.94405879e-04f,
  5.79215512e-02f, -3.16300355e-02f, 1.35979846e-01f, 1.80441290e-01f, -7.40295351e-02f, -7.86073580e-02f, -6.24337094e-03f, 1.76701322e-01f, 3.08592469e-01f, -1.25996798e-01f,
  3.07895422e-01f, -1.56257953e-02f, 4.98690866e-02f, -1.50699332e-01f, -1.59477487e-01f, -1.36552155e-01f, -1.77044079e-01f, 2.45429114e-01f, -1.93621233e-01f, -4.78517145e-01f,
  2.51546085e-01f, 4.67743687e-02f, -7.10291369e-03f, -5.43285981e-02f, 6.81132823e-02f, -2.03543916e-01f, 1.08102135e-01f, 6.83082715e-02f, 1.33353785e-01f, -5.04172184e-02f,
  -2.28723317e-01f, 5.34457751e-02f, -9.75046009e-02f, 7.48782903e-02f, 1.03355281e-01f, -2.02122256e-02f, 9.78531968e-03f, 5.91481142e-02f, -1.71648309e-01f, -1.52236849e-01f,
  -7.07719028e-02f, 5.26370257e-02f, -9.35972258e-02f, -5.37758768e-02f, 6.16708621e-02f, 1.00011587e-01f, 3.72608528e-02f, -4.52254824e-02f, 1.16558641e-01f, 5.76138645e-02f,
  -1.49014354e-01f, 2.91105658e-01f, -1.15450889e-01f, -1.28141046e-01f, 8.10654536e-02f, -1.54274702e-01f, 7.58442208e-02f, 1.52757332e-01f, -8.94710794e-02f, -2.25638505e-02f,
  1.64558068e-01f, 1.69964507e-01f, 1.54954910e-01f, 5.32014742e-02f, 1.60069600e-01f, 1.29727662e-01f, -1.76852167e-01f, -1.64496034e-01f, 6.82740211e-02f, 2.73469128e-02f,
  2.43019208e-01f, 5.95596097e-02f, -1.24788582e-01f, 2.55753994e-01f, -9.29372609e-02f, 9.92956534e-02f, 1.20261855e-01f, 2.28916988e-01f, 1.52424067e-01f, 2.14495286e-02f,
  -4.59458530e-02f, -2.78288811e-01f, 2.32675541e-02f, 2.03821093e-01f, -8.41563288e-03f, -3.42389420e-02f, 1.68863028e-01f, 1.01953901e-01f, 9.67489704e-02f, 5.17667830e-02f,
  2.44505942e-01f, -6.82375133e-02f, -1.76394090e-01f, 1.81466769e-02f, 3.97398286e-02f, -2.90126741e-01f, 7.49970227e-02f, -1.48771226e-01f, 4.12449706e-03f, -2.11574435e-01f,
  1.45505175e-01f, 4.36760411e-02f, 4.87450622e-02f, 1.39556959e-01f, 2.20784485e-01f, 1.27621859e-01f, 9.98061448e-02f, 1.16747014e-01f, -1.39685676e-01f, -2.32693870e-02f,
  -1.61776587e-01f, -7.86224529e-02f, -1.08747236e-01f, 1.95979998e-02f, 6.32772520e-02f, -2.38198936e-01f, -2.06127554e-01f, 6.95971176e-02f, 2.37953559e-01f, 2.28354372e-02f,
  -1.59899592e-01f, 1.49816356e-03f, 1.05171882e-01f, 2.21685902e-03f, -9.64247808e-02f, 8.76941010e-02f, -3.81250633e-03f, -1.35933042e-01f, -1.63091615e-01f, -1.20344885e-01f,
  -1.46996960e-01f, -8.81790370e-02f, 1.06742598e-01f, -7.29939155e-03f, -1.34255037e-01f, -1.82619795e-01f, -1.71669006e-01f, -1.53845102e-01f, -1.32779464e-01f, -2.50611752e-02f,
  1.35900453e-02f, 2.26068441e-02f, -1.66877955e-01f, -4.08208892e-02f, -1.35147676e-01f, -8.24632421e-02f, 1.05774820e-01f, 1.22741312e-01f, -7.47141689e-02f, 8.53725746e-02f,
  -2.10934058e-02f, 1.01954341e-01f, 6.33979440e-02f, -8.31849931e-04f, -5.20730466e-02f, 1.96440712e-01f, -2.19535664e-01f, 4.88650054e-02f, -3.40323932e-02f, 4.23919922e-03f,
  -6.90582022e-02f, -1.40186772e-01f, -8.72585177e-03f, 1.18991591e-01f, -2.02527996e-02f, -1.50970630e-02f, 1.94080457e-01f, 1.09682336e-01f, -1.98617905e-01f, 9.85197276e-02f,
  2.44961027e-02f, -1.27805963e-01f, -1.03339165e-01f, -1.24715328e-01f, 6.50519356e-02f, 1.25101328e-01f, -2.31691133e-02f, 1.02079630e-01f, 1.37237340e-01f, 1.22613102e-01f,
  2.31525779e-01f, -6.19493537e-02f, -1.58260122e-01f, -1.94081530e-01f, 2.07663700e-01f, -6.10695407e-02f, -2.02202201e-02f, 1.01020359e-01f, 8.06457475e-02f, -8.74537751e-02f,
  9.46104005e-02f, -1.73376482e-02f, 7.54454583e-02f, 1.04686841e-01f, -8.49870890e-02f, 8.32392201e-02f, 5.54714501e-02f, 1.93818048e-01f, -4.05870751e-02f, 1.46544233e-01f,
  1.32230520e-01f, 2.14330152e-01f, 8.96826014e-02f, 2.14442853e-02f, 1.16303846e-01f, 5.11260219e-02f, 2.37977237e-01f, -8.53314847e-02f, 1.78019464e-01f, 6.89463764e-02f,
  -1.16340324e-01f, 1.46814778e-01f, 1.41515687e-01f, -1.06448464e-01f, -1.66385964e-01f, -1.51649825e-02f, -2.78493501e-02f, 1.66227549e-01f, 2.43971854e-01f, -1.32696792e-01f,
  3.14615518e-01f, -8.33732113e-02f, -1.52028864e-02f, -2.16289893e-01f, -8.00862387e-02f, 1.62794977e-01f, 1.41511947e-01f, -2.16830850e-01f, 1.16993645e-02f, 6.65996373e-02f,
  -3.16826284e-01f, 1.56759813e-01f, -2.44010035e-02f, -9.19209197e-02f, 2.46801451e-02f, 1.17817998e-01f, -2.87873019e-02f, -4.02109176e-02f, 6.21194541e-02f, -1.35667384e-01f,
  6.53875470e-02f, -9.76520330e-02f, -7.00938702e-02f, -1.12650350e-01f, -2.12085694e-01f, 6.16262890e-02f, 7.48061612e-02f, 5.15064672e-02f, -9.16873887e-02f, 2.03824900e-02f,
  1.25465214e-01f, 6.74290881e-02f, 6.24150410e-02f, -2.59529650e-01f, -2.09038183e-01f, -5.49801625e-03f, -4.52844240e-02f, -3.44430730e-02f, 1.23557933e-02f, -7.23870024e-02f,
  4.72539291e-02f, 6.41730800e-02f, -1.30747575e-02f, 2.96980590e-02f, -2.12161049e-01f, 1.32332623e-01f, -1.53821543e-01f, -1.69879720e-01f, -5.01148589e-03f, -1.81242317e-01f,
  -1.47639289e-01f, 4.77108499e-03f, 3.63321044e-02f, -1.78968593e-01f, -2.82537509e-02f, 2.31847480e-01f, -5.76234646e-02f, 2.56137848e-01f, -3.00611645e-01f, 2.46310025e-01f,
  2.05044106e-01f, 1.18662044e-01f, -9.59775224e-02f, -1.30997226e-01f, -3.02473619e-03f, 1.07683152e-01f, -2.04545483e-01f, -9.33949575e-02f, 1.59514681e-01f, 3.33940312e-02f,
  -1.74123213e-01f, 1.36276186e-01f, 1.95970368e-02f, -5.95706441e-02f, 1.94898233e-01f, 1.02890588e-01f, 9.74821150e-02f, -2.83752028e-02f, -4.98818047e-02f, 1.14697754e-01f,
  -4.32242416e-02f, -2.73447484e-01f, 6.67598145e-03f, -2.61482839e-02f, -9.38958768e-03f, 1.04195617e-01f, 4.27360879e-03f, 8.88987724e-03f, 5.35352416e-02f, 5.30338101e-02f,
  -5.89981787e-02f, -2.03129396e-01f, 3.75203639e-02f, -5.74414022e-02f, 1.40397325e-01f, 1.61965452e-02f, 1.42044723e-02f, -1.95830807e-01f, -1.29876092e-01f, 3.20028095e-03f,
  1.92696638e-02f, -1.38688102e-01f, 1.40308579e-02f, 5.11978976e-02f, -1.01063140e-01f, 4.39804569e-02f, -8.27129409e-02f, 1.81980114e-02f, -1.01496302e-01f, 4.79736365e-02f,
  3.00080329e-02f, -1.26392320e-01f, 9.72868353e-02f, -2.60209322e-01f, -2.60712784e-02f, -1.23480625e-01f, 6.82684779e-02f, 1.28890332e-02f, -2.96356142e-01f, -7.07820281e-02f,
  3.65981400e-01f, 1.11010991e-01f, -3.21732104e-01f, -9.65508372e-02f, 2.45060712e-01f, -9.10625979e-03f, -1.15072034e-01f, 7.17651993e-02f, 3.31496030e-01f, 2.50849605e-01f,
  -2.93894529e-01f, -1.05216756e-01f, 6.85671493e-02f, 1.42571613e-01f, 1.53348997e-01f, -5.09705506e-02f, -1.16784371e-01f, -1.22535162e-01f, -1.32327035e-01f, -6.22839145e-02f,
  1.00704558e-01f, 1.67017821e-02f, 2.60614436e-02f, 3.62026431e-02f, -2.03710515e-02f, -9.34034288e-02f, 4.54068668e-02f, 6.85911328e-02f, 1.07829593e-01f, -5.26362956e-02f,
  -1.33678272e-01f, 2.73054719e-01f, 8.09499472e-02f, -1.24748245e-01f, -1.92946076e-01f, 7.70897511e-03f, -3.87557298e-02f, 1.71968997e-01f, -1.60162613e-01f, 1.04725942e-01f,
  -1.78067043e-01f, -8.26682448e-02f, -1.32723629e-01f, -6.66040033e-02f, 2.42441110e-02f, 5.36816716e-02f, -7.79362321e-02f, -6.52653202e-02f, 6.83430806e-02f, 4.28268537e-02f,
  1.25243543e-02f, 8.43201578e-02f, -2.20390648e-01f, 6.77241907e-02f, -5.77869033e-03f, -9.73438174e-02f, 8.15576613e-02f, 2.03643665e-01f, -1.97472274e-01f, 2.10594326e-01f,
  4.69113737e-02f, -2.85496294e-01f, 3.41326386e-01f, 2.67395288e-01f, -2.43463926e-02f, 2.64011830e-01f, 5.36510684e-02f, 3.34871262e-01f, -8.19015428e-02f, 8.80623609e-02f,
  -2.13074878e-01f, -1.46278709e-01f, 2.75561716e-02f, 2.61866271e-01f, -4.59512956e-02f, -7.04680309e-02f, 1.73403323e-01f, 7.69615769e-02f, -1.43738970e-01f, 8.98865461e-02f,
  4.29603644e-03f, -1.02881117e-04f, 2.36295000e-01f, -1.25381768e-01f, 2.85791624e-02f, 6.53162673e-02f, 9.53458063e-03f, -1.96464639e-02f, 7.23764077e-02f, -1.33290157e-01f,
  -1.00036301e-01f, -9.62120369e-02f, 9.04915631e-02f, -6.52443916e-02f, -1.95419062e-02f, -3.31555754e-02f, -4.85447748e-03f, 1.57951653e-01f, -6.15722984e-02f, -9.99900401e-02f,
  -6.05014861e-02f, -3.26601043e-02f, -7.63151869e-02f, -7.52436668e-02f, -1.71943396e-01f, -4.35064062e-02f, -4.28743921e-02f, 8.37603807e-02f, -2.35682651e-02f, -1.66028857e-01f,
  -5.86707368e-02f, -5.30269593e-02f, -3.75861377e-02f, -1.28817752e-01f, -8.50834772e-02f, -1.71724483e-01f, -9.27761793e-02f, -2.36557409e-01f, -5.22664599e-02f, -1.22671619e-01f,
  -1.57787576e-01f, 6.84653074e-02f, -8.11860859e-02f, 2.82816272e-02f, 8.03946257e-02f, -4.57109185e-03f, -2.93883793e-02f, 6.64721876e-02f, -3.25147033e-01f, 1.35719672e-01f,
  -8.41272324e-02f, 5.58036268e-02f, -2.26492539e-01f, 5.19402549e-02f, -2.67802000e-01f, -8.12893081e-03f, 5.30590229e-02f, -1.51688427e-01f, 1.79574251e-01f, 1.74488515e-01f,
  2.96464618e-02f, -1.04656868e-01f, -9.30193067e-02f, 2.41849974e-01f, -6.17099442e-02f, -3.32223065e-02f, 1.26009941e-01f, 4.25532945e-02f, -1.10306293e-01f, 1.23586580e-02f,
  -8.62089396e-02f, 3.45422924e-02f, -4.51653711e-02f, -1.34225309e-01f, 1.55287227e-02f, -1.11422658e-01f, -4.84527014e-02f, -1.94757525e-02f, -2.71124803e-02f, 7.33993948e-02f,
  2.81792164e-01f, 6.88970601e-03f, -1.97812721e-01f, -1.05572008e-01f, 1.14458144e-01f, -5.56906424e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.96395975e-02f, -8.73347297e-02f, 2.02479824e-01f, 8.40662420e-02f, 1.69341236e-01f, -1.61486324e-02f, 4.35613282e-02f, 2.25831807e-01f, 1.05604902e-01f, -7.02237198e-03f,
  1.81910652e-03f, 1.52207389e-01f, -1.26418974e-02f, 3.02228276e-02f, 9.51807387e-03f, 4.16547880e-02f, -7.43535161e-02f, 1.32170096e-01f, 9.23841074e-02f, -3.42954067e-03f,
  5.03466614e-02f, -5.13517819e-02f, -2.58162227e-02f, -6.55514449e-02f, 3.54446135e-02f, -2.02488631e-01f, -1.82714671e-01f, -6.90140501e-02f, 2.94655651e-01f, -2.19048873e-01f,
  -2.11790487e-01f, 1.16003063e-02f, -3.83934900e-02f, -1.09881543e-01f, -9.77403149e-02f, -2.01988325e-01f, 7.65132755e-02f, -6.31230772e-02f, -2.14003339e-01f, 4.85769212e-02f,
  6.02032349e-04f, -8.58216882e-02f, -6.14621257e-03f, -2.61747092e-02f, -3.36097926e-02f, -1.37625309e-02f, 4.94174734e-02f, -1.16949439e-01f, 1.06508628e-01f, 6.25820458e-02f,
  -1.07567281e-01f, 1.55822262e-01f, 9.34624225e-02f, 4.62624952e-02f, -1.13015719e-01f, 9.72166955e-02f, -1.32770920e-02f, -5.70282228e-02f, -7.64992908e-02f, 4.07935902e-02f,
  1.91186070e-01f, 2.09863037e-01f, 3.95980440e-02f, 5.30989431e-02f, 1.89301550e-01f, 1.31558143e-02f, 1.24441259e-01f, -9.64585617e-02f, 1.84472203e-01f, 1.77960038e-01f,
  -4.40622270e-02f, -2.51124501e-02f, 2.18513668e-01f, 7.95674324e-02f, 1.68327868e-01f, -4.95069101e-02f, -2.46355706e-03f, -7.03833392e-03f, 6.01714142e-02f, 1.37015628e-02f,
  2.59952620e-02f, -1.47846602e-02f, 7.49910995e-02f, -4.30873968e-03f, -2.09765732e-02f, 5.70674278e-02f, 1.80121794e-01f, 1.05577834e-01f, -8.51594284e-03f, 1.83886468e-01f,
  -2.40676641e-01f, -1.57973900e-01f, 1.52612239e-01f, -1.82368353e-01f, -2.44947728e-02f, 4.92806844e-02f, -5.38074551e-03f, -1.60307154e-01f, -1.04318745e-01f, -2.72983223e-01f,
  1.91813558e-01f, 1.52838588e-01f, -6.31816834e-02f, 4.02681231e-02f, 1.16605006e-01f, 1.51284754e-01f, -9.59725603e-02f, 1.31305382e-01f, 6.87927604e-02f, 3.36120650e-02f,
  -1.11168824e-01f, 3.10125090e-02f, -2.51959893e-03f, -2.26546880e-02f, 8.85840207e-02f, 2.29623482e-01f, 1.40741333e-01f, -1.01324283e-01f, 5.97401746e-02f, 5.50979450e-02f,
  1.22081362e-01f, -1.10036395e-01f, -2.47665234e-02f, -1.05658069e-01f, 1.45604312e-01f, 1.54237270e-01f, 4.19976227e-02f, -2.00709611e-01f, 1.94709942e-01f, 9.75334421e-02f,
  1.56698585e-01f, -1.09508380e-01f, 1.65782973e-01f, 2.19309051e-02f, 2.15267204e-02f, 4.69186492e-02f, 1.46941423e-01f, 1.86140478e-01f, 9.55972762e-04f, 4.93638366e-02f,
  -8.85836966e-03f, 1.05730250e-01f, -3.52106877e-02f, -1.25111520e-01f, -8.74903947e-02f, -2.37286761e-02f, 1.48227572e-01f, -3.96102481e-03f, 1.84041768e-01f, -6.93257079e-02f,
  -2.84942891e-02f, -5.52873351e-02f, -1.23885006e-01f, 1.57876268e-01f, 6.46658227e-05f, -9.14556012e-02f, -1.41133890e-01f, -1.67305116e-02f, -9.35462415e-02f, 1.24959335e-01f,
  -4.27145138e-02f, -1.24523908e-01f, 1.28290400e-01f, -4.68444601e-02f, -1.81452129e-02f, -1.10708885e-01f, -5.13442270e-02f, 3.91200127e-04f, 9.42536369e-02f, -8.71123597e-02f,
  -8.08922797e-02f, -7.50764385e-02f, -1.21393889e-01f, 6.92046713e-04f, 1.46805868e-02f, -4.20755781e-02f, 8.05866048e-02f, 4.68573384e-02f, 1.07673988e-01f, 9.71780121e-02f,
  1.50527269e-01f, -5.34994863e-02f, 4.94244099e-02f, 9.04947072e-02f, -9.93758887e-02f, 4.64454256e-02f, 3.04142274e-02f, 4.74368297e-02f, -9.23320092e-03f, 1.53038427e-01f,
  -2.76898816e-02f, -1.20778508e-01f, 9.76579934e-02f, 1.99596155e-02f, 2.13012639e-02f, 5.01275100e-02f, -4.71158437e-02f, -4.00784798e-02f, -3.09646670e-02f, 2.04455890e-02f,
  -5.71728796e-02f, 6.08706735e-02f, 1.24319509e-01f, 2.79992409e-02f, -1.71932608e-01f, -1.07055880e-01f, -1.49339989e-01f, 1.19346179e-01f, -4.28524055e-02f, -7.34376833e-02f,
  9.37059149e-02f, -1.38531299e-02f, -2.59126611e-02f, -8.46722350e-02f, 3.57006676e-02f, 9.98166576e-02f, 1.48339912e-01f, -5.36387637e-02f, -6.13840111e-02f, 1.04425959e-01f,
  -6.42196015e-02f, 1.54830039e-01f, 4.80716489e-02f, 2.90662572e-02f, 3.48806754e-02f, 1.52794093e-01f, 3.11257523e-02f, 7.32977688e-02f, 4.95854318e-02f, 1.44930437e-01f,
  1.15254335e-01f, -6.70830086e-02f, 3.26237418e-02f, 1.90553859e-01f, -8.67741182e-02f, -1.11307591e-01f, 2.92343944e-01f, -2.82016546e-02f, -3.16419788e-02f, -1.00584283e-01f,
  -2.55489014e-02f, 6.93358332e-02f, -9.48071629e-02f, -5.38425008e-03f, 1.25859138e-02f, 6.59249276e-02f, -1.08153716e-01f, 8.96439403e-02f, 1.24673918e-01f, 5.58644719e-02f,
  1.14052199e-01f, -8.30625072e-02f, 4.38341573e-02f, -9.57088098e-02f, -3.90779153e-02f, 1.25543341e-01f, -8.51314589e-02f, 1.35900110e-01f, 1.33865759e-01f, 8.60597044e-02f,
  -1.55727103e-01f, -9.99756455e-02f, 8.98671970e-02f, 6.30965037e-03f, -1.13218501e-01f, -1.53941050e-01f, 5.90506494e-02f, 1.37836352e-01f, 1.83394954e-01f, 9.63653550e-02f,
  -1.07884280e-01f, 3.30003910e-02f, 1.42778918e-01f, 1.45949215e-01f, 2.31212154e-02f, 1.54581681e-01f, 5.15481196e-02f, -3.34895253e-02f, 1.01409413e-01f, -2.14599758e-01f,
  1.04315542e-01f, -2.57632844e-02f, 8.03451315e-02f, 1.36990234e-01f, 1.83086827e-01f, 1.64571837e-01f, 5.14650382e-02f, 1.22167952e-01f, 9.13765952e-02f, -4.48400453e-02f,
  -2.05478564e-01f, 4.07483317e-02f, -3.01197041e-02f, -1.28530741e-01f, 3.09665233e-01f, 1.63296103e-01f, -1.14990927e-01f, -3.74802910e-02f, 7.43475109e-02f, 8.51652995e-02f,
  3.44246715e-01f, 4.07329760e-02f, -4.20133024e-02f, -3.12588713e-03f, 1.56356677e-01f, -4.29263674e-02f, -7.35097528e-02f, 7.62887150e-02f, -2.37226766e-02f, -6.98292106e-02f,
  5.03713228e-02f, 5.75530753e-02f, -1.11140283e-02f, -4.20567580e-02f, -5.83159663e-02f, 1.05030704e-02f, 9.52914804e-02f, 2.27093161e-03f, -1.16537318e-01f, 8.06877539e-02f,
  1.05787642e-01f, -9.10140276e-02f, 4.15730476e-02f, -2.71794684e-02f, 7.75500834e-02f, -7.14134350e-02f, -3.13190831e-04f, 4.37449478e-02f, 1.20956637e-01f, -7.84314349e-02f,
  -1.08670525e-01f, -5.25287576e-02f, -1.05370753e-01f, -7.25209415e-02f, -8.20669234e-02f, 3.67196999e-03f, 6.81744516e-02f, 7.15033561e-02f, -1.05283193e-01f, -1.50588085e-03f,
  -4.64146361e-02f, 1.31539911e-01f, -8.64317939e-02f, -1.20381095e-01f, -1.08712651e-01f, 5.97838350e-02f, 2.90900264e-02f, 1.11900359e-01f, 2.66394708e-02f, -5.87234534e-02f,
  -1.35480702e-01f, 1.42734637e-02f, -4.86148745e-02f, 1.20254412e-01f, 9.34329107e-02f, -7.94798881e-02f, -5.19403704e-02f, 9.71061513e-02f, 1.13320298e-01f, -2.94889808e-02f,
  1.34475399e-02f, 2.34178659e-02f, 1.05592534e-01f, 7.82100260e-02f, -9.67741013e-02f, 9.12861228e-02f, -4.45366651e-02f, -1.08334146e-01f, 2.15929653e-02f, 2.64992919e-02f,
  1.27245160e-02f, -1.00918502e-01f, 3.26355547e-02f, 6.77847043e-02f, -9.16985273e-02f, 8.21214765e-02f, 1.04131900e-01f, -1.26961291e-01f, -2.84231864e-02f, 6.08738102e-02f,
  9.93652940e-02f, -8.34506899e-02f, 7.96322525e-03f, -1.23150043e-01f, -1.02161504e-01f, 3.66429542e-03f, 1.00566559e-02f, 1.17675863e-01f, -4.84305024e-02f, 5.53860180e-02f,
  1.29676446e-01f, -1.54144112e-02f, -9.62611958e-02f, 1.42136551e-02f, 4.75116782e-02f, -3.50631811e-02f, 1.08140580e-01f, -4.55462653e-03f, 6.48078769e-02f, -1.41285554e-01f,
  -9.27464366e-02f, 7.31276125e-02f, -1.10857300e-01f, -2.91990582e-02f, -1.24767676e-01f, -2.34548673e-02f, -5.86995967e-02f, 3.37525420e-02f, 3.25381048e-02f, 1.18950777e-01f,
  -6.31587207e-03f, -3.09109576e-02f, -2.37906445e-03f, 1.35398611e-01f, -1.25929460e-01f, 3.37851350e-03f, 9.56288874e-02f, -2.93137203e-03f, -1.30628362e-01f, -1.45227797e-02f,
  -6.17779195e-02f, 1.16941370e-01f, 9.80058983e-02f, 8.16265717e-02f, 7.43743181e-02f, -1.10554315e-01f, 6.88819587e-02f, 5.38812168e-02f, 2.68201511e-02f, 2.50699818e-02f,
  9.34775267e-03f, -5.26780747e-02f, 8.21394920e-02f, 5.97869679e-02f, 3.70196104e-02f, 7.04222098e-02f, -1.00742698e-01f, 9.55410525e-02f, -9.78841558e-02f, -2.84772515e-02f,
  6.45200955e-03f, -2.30411906e-02f, -2.54064631e-02f, -4.57640253e-02f, 1.65179353e-02f, -1.95539668e-02f, -4.62795794e-02f, -1.43111320e-02f, 7.68130198e-02f, 8.70764777e-02f,
  2.50031892e-02f, -4.65869084e-02f, -1.03000969e-01f, 5.32698818e-02f, 5.39801195e-02f, -6.35403916e-02f, -3.30380723e-02f, 4.74110171e-02f, -4.84420434e-02f, -2.03703740e-03f,
  -7.76034966e-02f, -1.08398885e-01f, -5.07541634e-02f, 7.88059384e-02f, 1.31776538e-02f, -2.96498798e-02f, 6.55509830e-02f, 5.61049730e-02f, 1.01077139e-01f, -9.13650617e-02f,
  -5.12388833e-02f, 3.33018638e-02f, 5.32834865e-02f, -1.38872573e-02f, -4.94517758e-02f, -1.18579634e-01f, -7.96400830e-02f, -9.79004726e-02f, 1.29398573e-02f, 7.80056715e-02f,
  3.80070135e-02f, 1.05580995e-02f, 3.51331872e-03f, 6.68822974e-02f, 2.86205336e-02f, -4.25827913e-02f, -9.72277895e-02f, 4.56858799e-03f, 3.26620564e-02f, 1.00409254e-01f,
  1.03647396e-01f, -2.92632114e-02f, -9.63581055e-02f, -8.51230472e-02f, 2.85762306e-02f, 5.46509437e-02f, 1.28433421e-01f, -6.94336444e-02f, 9.21037942e-02f, 1.77346319e-02f,
  8.86605829e-02f, 3.46727259e-02f, 4.59601842e-02f, -9.57946777e-02f, 4.11795340e-02f, -7.60817602e-02f, 1.08934101e-02f, -1.00042909e-01f, -7.82112479e-02f, -3.69759537e-02f,
  -2.15968527e-02f, -9.26206037e-02f, 7.59529173e-02f, 7.10947113e-03f, 8.04665983e-02f, -3.03319898e-02f, 1.10555701e-02f, 1.11764133e-01f, -4.71201204e-02f, -8.58017504e-02f,
  2.70985868e-02f, 1.27425939e-01f, -4.90595326e-02f, 3.17867026e-02f, -8.52252468e-02f, -3.73190157e-02f, -2.16324180e-01f, 1.49035817e-02f, 1.07373632e-01f, -4.23798971e-02f,
  1.85247455e-02f, 6.45729154e-02f, -4.53339145e-02f, 1.37528390e-01f, -5.66412099e-02f, 6.66011870e-02f, 1.17678948e-01f, 1.36605486e-01f, -1.34382293e-01f, -1.41370058e-01f,
  -2.76173390e-02f, 2.95282044e-02f, -1.08091734e-01f, -1.49021551e-01f, 4.98192459e-02f, 1.39884681e-01f, 1.22462638e-01f, 4.78511862e-02f, 4.27020108e-03f, 1.49521783e-01f,
  1.23371016e-02f, -5.09664882e-03f, -9.68279615e-02f, 1.28758535e-01f, -4.69151251e-02f, 2.89877411e-02f, 1.35708004e-01f, -6.82184175e-02f, -6.96835993e-03f, 3.64384279e-02f,
  -1.18658714e-01f, -7.30891600e-02f, -2.80497056e-02f, -7.28132725e-02f, 5.05480506e-02f, -1.03916094e-01f, 8.63943025e-02f, -3.92054059e-02f, 4.92968187e-02f, 3.16634513e-02f,
  1.98157147e-01f, -7.85967335e-02f, 4.13360447e-02f, -1.29397005e-01f, -4.90776673e-02f, 1.06144883e-02f, -1.72865167e-02f, -1.70220695e-02f, 8.05498213e-02f, 1.13088079e-01f,
  1.37308344e-01f, -1.22265607e-01f, -1.47757128e-01f, 5.09666838e-02f, 1.76626071e-02f, -2.95451712e-02f, 9.05359089e-02f, 1.00717256e-02f, 1.14823811e-01f, 8.74651596e-02f,
  -4.90183309e-02f, -1.08834900e-01f, 1.46387383e-01f, -3.98901012e-03f, 4.80884649e-02f, 2.45149627e-01f, 3.43569927e-02f, 1.62417993e-01f, -1.08110299e-02f, -9.32588577e-02f,
  3.44479203e-01f, -2.50233293e-01f, -1.81937262e-01f, 2.92061269e-01f, 2.10882932e-01f, -1.10836484e-01f, -2.22836390e-01f, -2.17452824e-01f, -4.59867902e-02f, 2.26339936e-01f,
  -3.75403702e-01f, 3.14006172e-02f, 9.56520587e-02f, -8.49152803e-02f, -5.47077209e-02f, -4.46738154e-02f, -1.94222584e-01f, 2.76046693e-01f, -6.23559020e-02f, -6.35389537e-02f,
  4.39366698e-01f, -1.10432971e-02f, -3.75543945e-02f, 3.90549749e-02f, -1.38764933e-01f, -1.99387711e-03f, -8.94426182e-02f, 2.73947388e-01f, 2.51784027e-01f, -4.25152592e-02f,
  1.09821372e-01f, 8.68573859e-02f, -2.23188773e-02f, 3.90051417e-02f, 5.34251891e-02f, 4.58272062e-02f, 9.97056141e-02f, 1.06167756e-01f, 1.06847510e-01f, -5.76606132e-02f,
  8.39818642e-02f, 3.13393325e-02f, 4.14795503e-02f, -1.18689500e-01f, -3.92668881e-02f, 1.12890996e-01f, -1.55989319e-01f, 3.24844681e-02f, 1.02908965e-02f, -3.70950326e-02f,
  -9.58950669e-02f, -4.93254215e-02f, 7.73664042e-02f, 5.48786521e-02f, -6.81551546e-02f, 5.91567829e-02f, 1.39416844e-01f, 1.61717743e-01f, -2.27288473e-02f, 1.38600990e-01f,
  -3.72510552e-02f, -6.38804957e-02f, 6.95357621e-02f, -8.99588913e-02f, 1.24072649e-01f, 1.14397503e-01f, 1.40015548e-02f, -5.33106774e-02f, 5.22280857e-02f, 1.33135110e-01f,
  8.42582807e-03f, 5.84568791e-02f, -7.55972192e-02f, 9.67926458e-02f, 5.18801063e-02f, -4.11408804e-02f, 6.07345961e-02f, 9.40939039e-02f, -1.18462052e-02f, 8.99588391e-02f,
  7.84131587e-02f, -5.80550469e-02f, 6.24729395e-02f, 6.73483238e-02f, -8.49535838e-02f, -1.13423705e-01f, 3.59382592e-02f, 1.14537545e-01f, -4.86465506e-02f, -6.74395636e-02f,
  -6.04292713e-02f, -5.59964553e-02f, -1.06624186e-01f, -6.59035891e-02f, 3.66086587e-02f, -5.10805808e-02f, -7.25342408e-02f, 9.78502408e-02f, 1.16160929e-01f, 1.26576960e-01f,
  -7.82645196e-02f, 4.42335717e-02f, 7.23458901e-02f, -6.20144941e-02f, -9.13245529e-02f, 1.49117885e-02f, 1.07521750e-01f, 1.47060558e-01f, 1.33410424e-01f, -5.73185347e-02f,
  2.17520207e-01f, 5.03656939e-02f, 5.88409454e-02f, -1.09770119e-01f, 1.33523971e-01f, 1.02434248e-01f, 8.40833038e-02f, -4.10157554e-02f, 7.85514936e-02f, 2.13281646e-01f,
  -4.29561734e-02f, 1.62406579e-01f, 7.04747885e-02f, 9.93500650e-02f, 7.76022673e-02f, 5.82670011e-02f, 1.72120020e-01f, -2.69738555e-01f, 2.33616263e-01f, 1.80969641e-01f,
  -5.46281934e-02f, -3.35175432e-02f, 1.88629821e-01f, 1.65104538e-01f, 8.56511816e-02f, 1.04112983e-01f, 8.17167014e-02f, -1.96943656e-01f, 3.25861108e-03f, 5.32423183e-02f,
  4.85767797e-02f, -1.93764672e-01f, 2.20671073e-01f, 7.24879503e-02f, 1.04769111e-01f, 4.40927222e-02f, 7.68850222e-02f, -5.97520024e-02f, 1.69790879e-01f, 2.00817391e-01f,
  2.31067136e-01f, 1.17637344e-01f, 1.33358225e-01f, -2.09807251e-02f, -6.96494058e-02f, -6.01302162e-02f, -8.89159888e-02f, -7.49643892e-02f, -1.32561162e-01f, 5.51240332e-02f,
  3.88113223e-02f, -5.38624339e-02f, -1.05570205e-01f, 1.24912113e-01f, 1.70859694e-01f, 1.98206902e-01f, -1.24750741e-01f, -1.38676651e-02f, 6.50873706e-02f, 1.95290029e-01f,
  1.01407565e-01f, 5.87542392e-02f, 5.08383326e-02f, 1.33057907e-01f, -3.10117990e-01f, 2.96650261e-01f, 2.10841838e-02f, 3.08294773e-01f, 1.86238170e-01f, 1.21983029e-01f,
  -8.18867385e-02f, 2.00297549e-01f, 2.50181198e-01f, 4.91813235e-02f, 2.42456451e-01f, 2.22182721e-01f, 1.17289968e-01f, -5.26644737e-02f, -1.50934458e-01f, -1.71520427e-01f,
  -3.42885733e-01f, 1.49490625e-01f, 1.27137944e-01f, -2.16530845e-01f, -1.16401082e-02f, 1.71024472e-01f, 1.07005060e-01f, -9.88386050e-02f, -3.67690274e-03f, -3.56433868e-01f,
  -1.75718680e-01f, 1.71757787e-01f, -6.79023489e-02f, 2.02006638e-01f, -2.51967251e-01f, 1.20612726e-01f, 8.85110348e-02f, 4.26206663e-02f, -3.86646129e-02f, 2.39706174e-01f,
  -1.65333480e-01f, 8.54563117e-02f, 2.63541192e-01f, -1.63310438e-01f, -1.73712209e-01f, -4.91413400e-02f, -1.37840822e-01f, -1.61589712e-01f, -4.51297835e-02f, 1.80194363e-01f,
  1.84007481e-01f, 6.56044693e-04f, -6.25094473e-02f, -8.47202614e-02f, -1.17778242e-01f, 2.83430725e-01f, 1.19333178e-01f, 1.01289034e-01f, -2.60840729e-02f, -1.89096719e-01f,
  3.02877903e-01f, 8.43708664e-02f, 1.30870476e-01f, -1.68251470e-02f, -3.73400077e-02f, 1.72785923e-01f, -5.96248358e-02f, -3.54756787e-02f, -1.01855814e-01f, -7.17967451e-02f,
  5.08804768e-02f, -8.52476433e-02f, 1.21460788e-01f, -1.32037833e-01f, 7.39578307e-02f, 1.14812337e-01f, 2.15120450e-01f, -1.26893729e-01f, 1.81126878e-01f, 1.07004046e-01f,
  1.04906499e-01f, -4.98804357e-03f, -2.51468688e-01f, -1.66649878e-01f, 7.87100941e-02f, 1.17141847e-02f, 1.10502526e-01f, -2.10511401e-01f, -2.66049832e-01f, 6.86481521e-02f,
  2.63909418e-02f, 6.30308539e-02f, -9.69168842e-02f, -1.56115338e-01f, -1.01785235e-01f, -1.04890659e-01f, -1.88219458e-01f, 6.57799393e-02f, 1.50998205e-01f, 9.46886465e-02f,
  -7.23516792e-02f, -2.68581584e-02f, 1.31477248e-02f, 3.02910417e-01f, 1.19725950e-01f, -2.03611255e-02f, 2.79987246e-01f, -6.62013888e-02f, -3.03774606e-02f, -8.39325115e-02f,
  -8.10869485e-02f, -5.26415836e-03f, 6.52261451e-03f, 1.67509168e-01f, 1.04220793e-01f, -7.02821463e-02f, -7.21996576e-02f, -3.75740789e-02f, 1.37277022e-01f, 1.25695422e-01f,
  -6.79415390e-02f, -5.09237312e-02f, 7.49716582e-03f, 1.64952353e-01f, 1.66490972e-01f, -1.16010591e-01f, 5.46109825e-02f, 1.37002900e-01f, 3.42533700e-02f, 1.04236435e-02f,
  -9.28273275e-02f, 6.23678602e-02f, 1.35487586e-01f, 2.34976616e-02f, 6.90679401e-02f, -7.70574063e-02f, 4.70207557e-02f, 8.03182200e-02f, 1.90925434e-01f, -5.19055426e-02f,
  2.12921966e-02f, 1.36344612e-01f, 1.86465770e-01f, -1.11340590e-01f, -8.77744984e-03f, 1.90972641e-01f, 3.10728722e-03f, 1.76839411e-01f, -1.81956097e-01f, 5.33953793e-02f,
  1.27976060e-01f, -2.35291738e-02f, 2.54945666e-01f, 5.31046838e-02f, -1.83063775e-01f, 1.95796356e-01f, 1.24789633e-01f, -3.91350873e-02f, 1.71866134e-01f, -1.80756599e-02f,
  9.22588482e-02f, 1.91964105e-01f, -7.23690540e-02f, -1.59224629e-01f, 3.08384467e-02f, 7.68428762e-03f, 2.25355923e-01f, 2.75001470e-02f, -2.45678518e-03f, 1.13820367e-01f,
  1.00587055e-01f, 5.03180288e-02f, 9.90702659e-02f, -5.36912829e-02f, 6.02031648e-02f, 1.98256716e-01f, 7.36971125e-02f, 1.41102932e-02f, 6.67669252e-02f, 2.11049952e-02f,
  -1.30104885e-01f, -1.37621269e-01f, 8.98087546e-02f, 1.15896232e-01f, -9.02350694e-02f, 1.37455970e-01f, 1.04650877e-01f, 1.36224821e-01f, -6.48961440e-02f, 1.47284836e-01f,
  9.80795324e-02f, 3.27642523e-02f, 2.80412231e-02f, -1.15233257e-01f, 6.64286502e-03f, 1.56649426e-01f, -1.05299437e-02f, 6.99709309e-03f, -8.19533542e-02f, 1.14566721e-01f,
  3.82008143e-02f, 1.48852453e-01f, -9.88362357e-02f, -2.71367538e-03f, -1.22492597e-01f, 2.14256763e-01f, 9.44805965e-02f, 1.70613334e-01f, 9.64242686e-03f, 1.53743505e-01f,
  7.16930777e-02f, 1.37217030e-01f, -1.58627704e-01f, -1.78836837e-01f, 6.80897683e-02f, -1.48947671e-01f, 2.54948996e-02f, 9.19058323e-02f, -8.49654973e-02f, 1.81419164e-01f,
  4.12716344e-02f, -9.04261768e-02f, -3.07656638e-02f, 2.65326142e-01f, 7.85982013e-02f, 1.88218594e-01f, -4.23085056e-02f, 3.44819501e-02f, 1.09129891e-01f, -1.20771185e-01f,
  -9.49022695e-02f, -1.06969520e-01f, 1.18489243e-01f, 2.81969961e-02f, 1.93606243e-01f, -1.28737967e-02f, 1.05960876e-01f, -3.16438801e-03f, -1.20287128e-01f, 9.35268998e-02f,
  -9.04279053e-02f, 5.25817946e-02f, 2.36917928e-01f, 1.05109379e-01f, -4.94479202e-02f, 1.89739652e-02f, -1.32208630e-01f, 4.27206047e-02f, 1.74041107e-01f, -5.97173572e-02f,
  -3.76688177e-03f, -1.74813226e-01f, -3.38607579e-02f, 1.47046402e-01f, -1.38401449e-01f, 1.46684378e-01f, -3.80407684e-02f, -1.17845096e-01f, 1.90545484e-01f, 1.29413515e-01f,
  -1.12651356e-01f, 8.50188062e-02f, 4.92496490e-02f, 1.52197890e-02f, 6.47014380e-02f, 2.23079458e-01f, -1.20240800e-01f, 3.53295654e-02f, -1.05779082e-01f, 7.93318301e-02f,
  1.11958541e-01f, 1.78235292e-01f, 1.27005532e-01f, 2.47010678e-01f, 1.66772440e-01f, 1.66237071e-01f, -1.75232917e-01f, -4.24774587e-02f, 1.47611499e-01f, 1.26956552e-02f,
  2.08057999e-03f, -6.93342462e-02f, 2.39445381e-02f, 1.99208811e-01f, 5.25308959e-03f, -1.00899555e-01f, -4.58505414e-02f, -7.35978782e-02f, 1.27653077e-01f, 1.61019683e-01f,
  9.21474695e-02f, -1.45019189e-01f, -1.11576602e-01f, -1.19184271e-01f, -1.10280430e-02f, -1.26857668e-01f, -2.09982228e-02f, -5.64136729e-02f, 4.82333684e-03f, 7.29930103e-02f,
  2.82925870e-02f, 7.47415647e-02f, -3.69478092e-02f, 6.29774407e-02f, 9.96524394e-02f, 1.17524356e-01f, -6.42366111e-02f, -1.18036695e-01f, -1.43287033e-01f, -9.13210586e-02f,
  9.76877138e-02f, -1.87601253e-01f, 2.53978640e-01f, 5.89086786e-02f, 4.00357842e-02f, 3.31570655e-02f, -9.91647691e-02f, 2.04354823e-02f, -4.44053151e-02f, 1.29658848e-01f,
  -6.97255060e-02f, -1.05886564e-01f, -6.91278204e-02f, 9.97640379e-03f, -1.80415083e-02f, 4.87341769e-02f, 9.87960100e-02f, 8.23265091e-02f, 3.25595178e-02f, -1.11798525e-01f,
  7.35815987e-02f, -4.40318920e-02f, -4.54725847e-02f, -1.12600110e-01f, -8.44044089e-02f, -1.06420204e-01f, 7.59189501e-02f, 9.67759639e-02f, -8.51838663e-02f, -8.76978040e-02f,
  9.06789973e-02f, -8.56639445e-02f, -1.74882170e-02f, -6.79121539e-02f, 6.27987608e-02f, -1.17085166e-01f, -1.07784932e-02f, 2.91365534e-02f, 1.36642888e-01f, -1.97641086e-02f,
  8.64311457e-02f, -2.97227949e-02f, 3.76054682e-02f, 2.93826144e-02f, -6.11581616e-02f, -5.24375634e-03f, -8.90154466e-02f, -1.07614927e-01f, -7.87621662e-02f, -5.93500510e-02f,
  7.97443017e-02f, -7.64629245e-02f, -1.12043291e-01f, -9.17573273e-02f, 9.11030471e-02f, -3.76714431e-02f, 3.75891030e-02f, 6.06546514e-02f, -8.14592689e-02f, -6.74994960e-02f,
  -2.63175815e-02f, -1.05562761e-01f, 4.09423225e-02f, 6.19357750e-02f, 7.56391138e-02f, -8.31439123e-02f, 8.73260796e-02f, 1.33261397e-01f, 5.56787215e-02f, 4.78982320e-03f,
  -5.79806194e-02f, -8.71708989e-02f, 8.05427879e-02f, 1.07073940e-01f, 1.40132129e-01f, 1.65544763e-01f, 1.91462159e-01f, -5.33055514e-02f, -4.03110385e-02f, -1.38980851e-01f,
  9.99857634e-02f, 2.79717017e-02f, 1.54192656e-01f, 4.57183383e-02f, 1.34931490e-01f, 7.49635771e-02f, 3.20673026e-02f, -1.31232338e-02f, 5.41036278e-02f, -1.07014164e-01f,
  -6.61899745e-02f, 1.28865063e-01f, 1.47936344e-01f, 2.09282994e-01f, -4.38846610e-02f, -6.73338920e-02f, -1.63518250e-01f, -1.45088872e-02f, 2.15448648e-01f, -1.17559239e-01f,
  -1.09888054e-01f, -8.05625618e-02f, 1.37162000e-01f, -2.27446314e-02f, 3.38578559e-02f, 6.94306791e-02f, 2.30553389e-01f, -7.21936300e-02f, -1.92068577e-01f, -1.46294817e-01f,
  -1.07469909e-01f, 1.32191041e-02f, 8.71776864e-02f, -7.87890628e-02f, 1.06771730e-01f, 3.60602215e-02f, -1.25659168e-01f, 8.51843879e-03f, 3.53980474e-02f, -8.87599960e-02f,
  -1.63038149e-01f, -1.47965718e-02f, -1.21227719e-01f, -1.08163111e-01f, -5.18004782e-02f, 9.17332619e-03f, -4.48983721e-02f, 2.07844991e-02f, 2.94389343e-03f, -7.91453049e-02f,
  5.97664565e-02f, -1.11058906e-01f, 1.16904872e-02f, -1.21485658e-01f, -4.53706421e-02f, 1.74622521e-01f, 1.94855273e-01f, -4.70623374e-02f, 2.15830594e-01f, -7.75233284e-02f,
  1.60041675e-01f, 2.04093575e-01f, -9.84570533e-02f, 7.52289519e-02f, 1.45771027e-01f, -1.21487807e-02f, -5.09220734e-02f, 8.48390833e-02f, 2.15167496e-02f, 1.17042623e-01f,
  -6.61927760e-02f, 1.73325762e-01f, -9.82770417e-03f, 2.26642251e-01f, 1.63081512e-01f, -8.84322077e-02f, 5.38445218e-03f, -7.27814203e-03f, 2.08356738e-01f, -5.03881127e-02f,
  -1.55334294e-01f, 1.29709601e-01f, -1.87878646e-02f, -2.09013447e-01f, 7.89154023e-02f, 5.13056107e-02f, -1.05847329e-01f, 1.89299494e-01f, 1.58892363e-01f, -1.32432655e-01f,
  1.19045436e-01f, -2.47718707e-01f, 1.02086656e-01f, -9.17013362e-03f, 9.00286809e-02f, 8.76785070e-02f, 1.20163105e-01f, 1.23586699e-01f, -8.54094252e-02f, -5.67850322e-02f,
  1.85317472e-02f, 1.50715098e-01f, 1.11482024e-01f, 1.06404349e-01f, 1.46746531e-01f, 4.88926098e-02f, 7.82669708e-02f, -1.55961616e-02f, 1.40903279e-01f, -5.27230650e-02f,
  5.56266457e-02f, 1.05954684e-01f, 6.71234801e-02f, -4.73391563e-02f, -1.47735268e-01f, -6.26142174e-02f, 6.45607561e-02f, 1.34459123e-01f, -4.82675247e-02f, -1.23090088e-01f,
  -4.63967137e-02f, 1.14789389e-01f, 1.38267167e-02f, -9.96660739e-02f, -1.10613331e-01f, 7.97552466e-02f, -1.07338555e-01f, 1.59428433e-01f, -1.17013557e-02f, 2.68968493e-02f,
  6.66381791e-02f, 1.74083665e-01f, -2.74248961e-02f, 5.92972748e-02f, -7.73341358e-02f, -2.52638664e-02f, 1.28170535e-01f, 1.17628992e-01f, 1.19094756e-02f, -1.16877042e-01f,
  -1.70013413e-01f, -8.06747749e-02f, 2.66588759e-02f, 9.61487144e-02f, 1.74037404e-02f, 2.85705645e-02f, -6.27811551e-02f, -2.44504791e-02f, -9.52719375e-02f, 6.66212873e-04f,
  9.95764956e-02f, -1.07073255e-01f, 1.27692157e-02f, -3.80516313e-02f, 6.95815682e-02f, 8.13173726e-02f, -8.72364864e-02f, 8.51115361e-02f, 1.47182480e-01f, -8.88929516e-03f,
  -1.41251951e-01f, -9.13848449e-03f, 3.19365896e-02f, -5.15688360e-02f, 9.40789527e-04f, -9.27040279e-02f, 6.33993447e-02f, 1.14478357e-01f, -5.81256039e-02f, 1.40349656e-01f,
  -3.89107317e-02f, -7.41829053e-02f, 9.18910801e-02f, 2.49880310e-02f, 7.80509338e-02f, -1.11469859e-02f, -3.45681123e-02f, 1.59377486e-01f, 1.73128322e-01f, -1.66898761e-02f,
  -5.96712083e-02f, 4.19711582e-02f, -4.93213050e-02f, 1.05964996e-01f, 1.63536847e-01f, -3.62385251e-02f, 5.17782010e-03f, -3.42111290e-02f, 9.14484188e-02f, 1.21970184e-01f,
  -3.68717872e-02f, 2.01725096e-01f, 8.23119879e-02f, 1.77058920e-01f, 6.04427941e-02f, 1.55399919e-01f, -4.25593741e-02f, 2.94880886e-02f, -2.16991439e-01f, 9.11539868e-02f,
  -8.89732540e-02f, 2.03604981e-01f, 8.68972484e-03f, 1.41592532e-01f, 9.95556787e-02f, 1.54738603e-02f, -8.99237841e-02f, -7.02854246e-02f, -3.44370529e-02f, -5.07913418e-02f,
  1.14933997e-01f, 4.77509908e-02f, 7.54005602e-03f, 1.07712239e-01f, -1.11325525e-01f, -1.50015086e-01f, -1.28390551e-01f, 2.28209257e-01f, 4.79034334e-02f, 9.58535373e-02f,
  -4.82483990e-02f, -1.49499983e-01f, 1.62230097e-02f, -1.07825361e-01f, 1.47117088e-02f, 1.40489414e-01f, 1.22836404e-01f, 8.41651633e-02f, -9.18861292e-03f, -3.97560745e-02f,
  1.26227466e-02f, -3.41953561e-02f, -1.28090009e-01f, -2.07036827e-02f, 6.00398108e-02f, 2.94240867e-03f, 1.17001146e-01f, 4.89441752e-02f, 2.27065682e-02f, 3.16578150e-02f,
  5.74802794e-02f, -1.76668897e-01f, -6.83835009e-03f, -2.72572916e-02f, 1.44327894e-01f, -7.01666176e-02f, 3.87597829e-02f, -1.02669440e-01f, -1.12796515e-01f, -2.11538952e-02f,
  2.06312835e-02f, -6.65832460e-02f, -3.54692340e-02f, -7.01294318e-02f, 5.72143979e-02f, -3.40848719e-03f, 1.36864647e-01f, -1.37046218e-01f, 7.80017152e-02f, -8.37367699e-02f,
  4.72923256e-02f, 5.16526923e-02f, -8.29412118e-02f, 8.70327502e-02f, 3.01345810e-02f, -2.66388878e-02f, 1.46289334e-01f, 1.48200512e-01f, 1.52114093e-01f, 1.02051929e-01f,
  1.01231173e-01f, -5.15814424e-02f, -5.65166809e-02f, -3.06082740e-02f, -1.12674750e-01f, -1.09404527e-01f, 1.70053661e-01f, -2.93367095e-02f, -1.33993283e-01f, 3.87953706e-02f,
  9.10011232e-02f, -1.05593078e-01f, -1.65677175e-01f, -1.90571204e-01f, -5.22875302e-02f, -3.82576697e-02f, -3.50818457e-03f, 6.97787255e-02f, -6.15529642e-02f, -8.47817808e-02f,
  6.28184900e-02f, 8.88485834e-03f, 5.43427616e-02f, 1.52189344e-01f, -5.63102923e-02f, -1.18881099e-01f, 1.06696293e-01f, -1.19539443e-02f, -3.44419368e-02f, 4.86381054e-02f,
  7.31407432e-03f, -7.98561275e-02f, 6.47116676e-02f, 1.27694393e-02f, 1.08871947e-03f, 5.74884824e-02f, -8.71784538e-02f, -3.25609557e-02f, 1.83791667e-02f, 4.11087647e-02f,
  -5.38058951e-02f, -1.05909273e-01f, -9.79120135e-02f, 3.37013192e-02f, 9.26992018e-03f, 7.63122290e-02f, -3.46799567e-02f, -8.82782266e-02f, -4.38889489e-03f, -1.36170968e-01f,
  7.79370219e-02f, -9.42488685e-02f, -1.22071197e-02f, -8.67552236e-02f, 6.23014569e-02f, 1.15670636e-01f, -4.75790203e-02f, -4.10667621e-03f, -1.06048800e-01f, 5.22130355e-02f,
  -2.60461122e-02f, -3.30371931e-02f, 3.45911905e-02f, 6.25889823e-02f, 1.88620359e-01f, -1.39363587e-01f, -9.29974690e-02f, 8.35646167e-02f, 4.82262224e-02f, 1.34475917e-01f,
  1.07168883e-01f, 2.86701936e-02f, 5.42904213e-02f, 7.34165981e-02f, 8.59593600e-02f, -1.42035782e-01f, 5.43020517e-02f, -1.30323455e-01f, -4.91498634e-02f, -1.03166781e-01f,
  -3.92080732e-02f, 6.14456870e-02f, 2.14386415e-02f, 2.83740237e-02f, -1.08952120e-01f, -2.15490088e-02f, -8.23574420e-03f, -7.32385030e-04f, 1.14590541e-01f, 5.48125133e-02f,
  1.24951750e-02f, -8.23736489e-02f, 3.60084400e-02f, 1.23085730e-01f, 9.83761624e-02f, 1.88969839e-02f, 3.71610895e-02f, -8.47380161e-02f, 7.01817945e-02f, -5.78259453e-02f,
  -9.00988802e-02f, -4.91552167e-02f, 4.02972326e-02f, 9.84244570e-02f, 9.99208819e-03f, 3.28110009e-02f, 6.80726347e-03f, 1.39667511e-01f, -2.25279406e-02f, 8.12602118e-02f,
  -4.47064918e-03f, 1.93506200e-02f, -6.13861484e-03f, 7.00532869e-02f, -1.24547984e-02f, 1.01087531e-02f, -2.76085325e-02f, -2.92283874e-02f, 5.09063341e-02f, -8.53882134e-02f,
  9.13197920e-02f, -9.49338824e-02f, 4.91628833e-02f, 6.58164546e-02f, 4.60274890e-02f, -1.17515258e-01f, 1.51560709e-01f, -9.39816162e-02f, -1.24967042e-02f, -1.85283541e-03f,
  -2.01866180e-01f, -1.76311895e-01f, 8.59794766e-02f, -1.15886882e-01f, -1.38256744e-01f, -1.25964254e-01f, 1.50846913e-01f, 6.90838248e-02f, 1.42365798e-01f, 3.21973115e-03f,
  7.35997781e-02f, 2.79962141e-02f, -8.10546502e-02f, -9.96669754e-02f, -2.72600278e-02f, 1.35700867e-01f, 4.38266695e-02f, 5.68008460e-02f, -1.53387472e-01f, 9.10369605e-02f,
  6.37317821e-02f, -3.75768542e-02f, 1.13400191e-01f, -1.91390179e-02f, 5.76678291e-02f, -1.26761377e-01f, -9.66399536e-02f, -8.89391676e-02f, -3.19698676e-02f, -9.78509113e-02f,
  -3.93212438e-02f, -1.05690062e-01f, -1.32177532e-01f, 5.65709546e-02f, -6.34881631e-02f, -4.15882766e-02f, -5.17698377e-02f, 1.19781837e-01f, -1.03075191e-01f, -2.16824439e-04f,
  7.22583309e-02f, -1.47275329e-02f, 1.76558062e-01f, 2.36755181e-02f, 1.40029207e-01f, -1.66183077e-02f, 1.04947843e-01f, 1.56150028e-01f, 6.92350268e-02f, 6.78457543e-02f,
  1.35085953e-03f, 1.56705320e-01f, 9.15158987e-02f, 3.92901152e-02f, 1.64233938e-01f, 1.01923779e-01f, 3.99038605e-02f, 1.42058739e-02f, 7.04069273e-04f, -1.38971023e-02f,
  1.29540354e-01f, 4.74014953e-02f, 7.05394801e-03f, -7.57760406e-02f, 1.84015732e-03f, -2.27985188e-01f, 4.30800878e-02f, -2.21131444e-01f, 1.22049846e-01f, -1.06776595e-01f,
  -5.75284697e-02f, -7.37043172e-02f, -9.72865988e-03f, -5.12087122e-02f, 8.83420277e-03f, -2.74710804e-01f, -3.71691287e-02f, 5.46067953e-02f, -1.74158335e-01f, 1.29281133e-01f,
  2.57013500e-01f, -7.44642317e-02f, -9.47067142e-03f, -1.18308619e-01f, -1.25833258e-01f, -9.28778276e-02f, 1.23516887e-01f, -1.50340244e-01f, 3.84411663e-02f, -1.59117654e-01f,
  -7.06526414e-02f, 2.16217801e-01f, 4.20545302e-02f, -1.40369713e-01f, 3.30947228e-02f, -1.23358928e-01f, 5.84082901e-02f, -8.55541229e-02f, -4.06193286e-02f, -1.73702747e-01f,
  1.51864097e-01f, 2.44333282e-01f, 8.49818885e-02f, -1.13990739e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.86928958e-01f, 1.12720303e-01f, -5.69118299e-02f, -8.90907720e-02f, 1.15574285e-01f, -3.44055220e-02f, -3.30612585e-02f, -1.11623503e-01f, -1.10858222e-02f, 1.36582270e-01f,
  5.51308244e-02f, 1.77204922e-01f, 6.53962120e-02f, 9.62427706e-02f, 6.35889247e-02f, 1.56059265e-01f, 1.33376837e-01f, -6.12533092e-02f, -9.32000985e-04f, 3.76222171e-02f,
  1.57442957e-01f, -2.81652119e-02f, 1.48414060e-01f, -7.23113641e-02f, 8.15078542e-02f, 2.09710956e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.05898121e-01f, -1.13837220e-01f, -1.74168676e-01f, -3.02659124e-01f, -2.56459385e-01f, 7.83909708e-02f, -6.87133297e-02f, 3.79774570e-02f, 3.86034814e-03f, -1.01841182e-01f,
  -4.43123698e-01f, 1.63896382e-02f, -1.00144759e-01f, -4.19082582e-01f, -2.34975830e-01f, 4.29963768e-02f, -5.81384860e-02f, -1.92866609e-01f, -3.17150235e-01f, -2.26382166e-01f,
  7.83047080e-02f, 1.61303893e-01f, -1.84832633e-01f, -1.83456138e-01f, 1.41990095e-01f, 5.06150246e-01f, 1.52191624e-01f, -3.09161991e-01f, -3.14681344e-02f, 2.49014556e-01f,
  -3.34291250e-01f, -3.96956950e-01f, 1.92972794e-01f, 1.66099742e-01f, 2.12585047e-01f, -7.85682797e-02f, 1.52153879e-01f, 5.12143254e-01f, -1.05805673e-01f, 3.73831242e-02f,
  4.77454858e-03f, 3.25636655e-01f, -1.10176891e-01f, 5.24420440e-02f, 7.67153502e-02f, 1.02626413e-01f, 2.17623293e-01f, 4.04004276e-01f, 1.84471458e-02f, -2.88167775e-01f,
  2.25580469e-01f, 1.75018862e-01f, -2.13938028e-01f, 2.58212507e-01f, -3.52350324e-02f, 8.35399628e-02f, -1.42967934e-02f, -9.80078802e-02f, 8.92861113e-02f, 2.07570031e-01f,
  -1.40482306e-01f, 8.99770185e-02f, -7.10428730e-02f, -9.34975296e-02f, 6.24666810e-01f, 7.89569393e-02f, 9.07199830e-02f, 1.56100005e-01f, -2.16534436e-02f, 3.03980589e-01f,
  2.80862361e-01f, 4.71573696e-02f, -9.44689754e-03f, 2.09225208e-01f, 2.47133330e-01f, 4.29460615e-01f, 2.75380552e-01f, 1.29695401e-01f, 1.30059347e-01f, 4.50775951e-01f,
  5.47571719e-01f, 3.44754487e-01f, 6.44662827e-02f, 9.77680311e-02f, 2.97610730e-01f, -1.75723523e-01f, 5.41438580e-01f, -5.33463717e-01f, -2.68208474e-01f, -3.38805169e-01f,
  2.65912682e-01f, 3.82182598e-01f, 8.65996480e-02f, -1.36600718e-01f, 2.58668005e-01f, 7.40515143e-02f, -8.13669115e-02f, 6.98844641e-02f, 2.41931248e-02f, 1.63138166e-01f,
  2.33884901e-01f, -5.36771268e-02f, -1.19591825e-01f, -4.49073240e-02f, 6.64841309e-02f, -7.48761147e-02f, -1.87725484e-01f, 1.08040974e-01f, -2.91714203e-02f, 8.28178674e-02f,
  2.40311816e-01f, -1.81223080e-01f, 1.84722438e-01f, -1.01658262e-01f, -8.83711316e-03f, -3.40470165e-01f, 5.06604873e-02f, 3.93761396e-01f, 5.34535289e-01f, 1.59346566e-01f,
  1.91609845e-01f, 4.64837626e-02f, 1.63679630e-01f, 3.15931827e-01f, -2.97773741e-02f, -1.56610146e-01f, -1.29209220e-01f, -1.40116751e-01f, -3.74714017e-01f, 5.13879061e-01f,
  -8.66247863e-02f, 1.44293293e-01f, 2.35333458e-01f, -4.17937160e-01f, -2.26250634e-01f, 1.01510324e-01f, 1.31888509e-01f, 3.13105375e-01f, -9.25121680e-02f, 4.24714386e-01f,
  -2.85061568e-01f, -3.97555493e-02f, 3.74228805e-01f, -2.59254038e-01f, -3.40074897e-01f, 9.67870057e-02f, -2.81189650e-01f, 4.68819588e-02f, -8.71232972e-02f, 3.48570198e-01f,
  1.65333953e-02f, -8.43204707e-02f, 5.55327460e-02f, -3.70258540e-01f, -1.06958374e-01f, 2.92464644e-01f, -4.31371838e-01f, -3.31158906e-01f, 1.32512540e-01f, 4.49693233e-01f,
  -2.27867872e-01f, 1.57536343e-02f, -3.09015810e-01f, -4.37914908e-01f, -1.09243304e-01f, -6.39614388e-02f, 2.59317428e-01f, -2.74804354e-01f, -1.93984970e-01f, 7.10822293e-04f,
  1.33021504e-01f, 6.01971857e-02f, 1.82790812e-02f, -1.79350115e-02f, -1.14218071e-01f, 3.13254863e-01f, -1.16431108e-02f, 1.60228640e-01f, -8.33053589e-02f, -2.47131437e-02f,
  6.82429075e-02f, 9.48530734e-02f, 2.31769010e-01f, -6.93333894e-02f, -1.34914279e-01f, -1.67492241e-01f, -1.42181471e-01f, 6.44363165e-02f, 9.82804224e-02f, -1.16988540e-01f,
  -1.22735063e-02f, 2.35261053e-01f, -3.78087729e-01f, -7.25925192e-02f, 1.22766815e-01f, 1.17291652e-01f, -1.65607587e-01f, -2.93964833e-01f, -1.32348984e-01f, -4.15891320e-01f,
  -2.05742657e-01f, -2.23784164e-01f, 3.02498639e-01f, 6.32731915e-02f, 3.29247028e-01f, 2.82770991e-02f, -5.23358360e-02f, 1.79184780e-01f, 2.23780215e-01f, -2.55628347e-01f,
  1.81149989e-01f, -9.94426683e-02f, 2.10343674e-01f, 1.75245494e-01f, -9.71348360e-02f, -1.83988914e-01f, 2.17457175e-01f, -1.78645939e-01f, -8.33545476e-02f, 2.93425381e-01f,
  -2.99401045e-01f, -1.39643386e-01f, 4.32667993e-02f, 2.44443342e-01f, 2.76785016e-01f, -3.86967719e-01f, 3.44622970e-01f, -9.56762210e-02f, 3.07204843e-01f, -1.77886024e-01f,
  -1.40651017e-02f, -4.30509150e-01f, -1.70705184e-01f, 1.38751745e-01f, 2.08783999e-01f, -5.01758978e-02f, -1.08760938e-01f, 3.48836072e-02f, -1.95458412e-01f, 2.99065709e-01f,
  -1.00079656e-01f, -3.25082205e-02f, 3.96445215e-01f, 6.77561108e-03f, 5.77743500e-02f, 3.15050006e-01f, -1.34764180e-01f, 3.24082784e-02f, -1.03333212e-01f, -2.46288702e-01f,
  1.29071996e-01f, 1.41396478e-01f, -4.43758219e-02f, 2.59912871e-02f, -4.98627722e-02f, -2.55935282e-01f, -5.99129982e-02f, -3.76855507e-02f, -3.81390631e-01f, -7.07782581e-02f,
  1.94268718e-01f, -5.16384304e-01f, 2.75057524e-01f, -4.11307104e-02f, 1.55164436e-01f, -1.29092410e-01f, 3.83406803e-02f, 6.87868074e-02f, 1.68232545e-01f, 2.74450839e-01f,
  -2.10374385e-01f, -1.21395729e-01f, -3.59001696e-01f, 1.25705913e-01f, 2.85466880e-01f, 1.84054941e-01f, 8.86641368e-02f, 6.88230917e-02f, -3.15654397e-01f, -3.27891141e-01f,
  3.21924151e-03f, -5.73547706e-02f, -1.68283917e-02f, -1.66916087e-01f, -2.43421435e-01f, 4.67936963e-01f, 2.62970895e-01f, -3.69446427e-01f, 2.36372337e-01f, -3.04669499e-01f,
  -4.18401122e-01f, -1.92392930e-01f, -1.57734394e-01f, 3.09360951e-01f, 1.56974465e-01f, 2.28780568e-01f, -1.05291009e-01f, -8.09281394e-02f, -2.07307577e-01f, -8.15291852e-02f,
  -8.12308788e-02f, -2.35380288e-02f, -9.95245054e-02f, 3.26903224e-01f, -4.38272059e-02f, -2.98342615e-01f, 3.73990059e-01f, 4.98977751e-01f, -1.59362048e-01f, -2.99074590e-01f,
  -1.98827326e-01f, -5.31030819e-03f, 2.75769848e-02f, -1.68629572e-01f, -5.52191213e-02f, -1.27917379e-01f, -7.06687644e-02f, -8.34652558e-02f, 3.08858939e-02f, 1.07577071e-01f,
  -1.54814571e-02f, -8.23197048e-03f, -2.54891396e-01f, 1.43884078e-01f, 2.58111984e-01f, 1.19735353e-01f, -9.27228183e-02f, 1.90762445e-01f, -1.72574539e-02f, 2.45167077e-01f,
  1.33259386e-01f, -1.31680474e-01f, 4.97831494e-01f, 1.78137749e-01f, 1.83092594e-01f, -9.20912027e-02f, 4.50603217e-01f, -3.18256587e-01f, -2.40528822e-01f, -5.62182307e-01f,
  3.72085482e-01f, 4.99468595e-01f, 2.63452888e-01f, 4.20813709e-02f, 4.16227311e-01f, -2.46814802e-01f, -2.15917319e-01f, 2.43497431e-01f, -1.21313855e-01f, 1.61191493e-01f,
  4.63916600e-01f, 6.74036890e-02f, -5.53037412e-02f, -3.10241077e-02f, -2.43710712e-01f, 3.90268564e-02f, -3.99450511e-01f, -1.65742427e-01f, 2.16090187e-01f, 1.88584715e-01f,
  -1.84652079e-02f, -1.26234606e-01f, -1.65607274e-01f, -5.92421032e-02f, -4.67589870e-02f, 1.03946596e-01f, -1.07382081e-01f, -1.39396731e-02f, 5.17960601e-02f, -3.60545427e-01f,
  4.84692901e-01f, 3.65952477e-02f, -2.19130203e-01f, -1.58175435e-02f, -1.17096744e-01f, 4.71637920e-02f, -9.26460326e-02f, 2.56921142e-01f, -8.90371203e-03f, 1.60079658e-01f,
  -1.27826452e-01f, -8.93256813e-02f, 4.85088564e-02f, 3.43976825e-01f, -2.16425449e-01f, -2.96739548e-01f, 1.45476311e-01f, -6.11420423e-02f, -1.83590293e-01f, 2.57675111e-01f,
  1.43967774e-02f, -5.55220880e-02f, 6.97439462e-02f, 1.05219886e-01f, -2.93210864e-01f, -3.75976712e-01f, -3.44370812e-01f, 3.09218317e-02f, -2.58924037e-01f, -5.98892309e-02f,
  -2.93616831e-01f, 1.03463143e-01f, 2.70405319e-03f, -4.21763957e-01f, -9.95950773e-02f, -3.71852696e-01f, -1.22616164e-01f, 3.77691239e-01f, 7.15088546e-02f, 1.48861289e-01f,
  -4.28385615e-01f, -4.06545311e-01f, 2.45389089e-01f, -1.59281000e-01f, -4.11795706e-01f, -1.90132558e-01f, -6.57295110e-03f, 3.20345730e-01f, -1.44491121e-01f, -4.91732001e-01f,
  -1.65073693e-01f, -2.37242263e-02f, 2.71246940e-01f, 2.79607743e-01f, -9.48230177e-03f, -1.00357950e-01f, 1.62803829e-02f, 5.68664819e-02f, -2.64309496e-02f, 1.48534670e-01f,
  -1.52698368e-01f, -4.00885344e-01f, -1.34009486e-02f, 3.86344701e-01f, -3.81590515e-01f, -3.04698110e-01f, -2.24120226e-02f, -1.89737409e-01f, 2.52616480e-02f, 1.04000084e-02f,
  -1.49453714e-01f, 2.67498642e-01f, -1.13308817e-01f, 1.86142456e-02f, 2.03102902e-01f, 1.01404577e-01f, -8.71556625e-02f, 9.26268548e-02f, 2.23675311e-01f, 1.26440287e-01f,
  -3.61221671e-01f, 3.19897346e-02f, 1.89234540e-01f, 1.93795264e-01f, -4.86040898e-02f, -2.65203536e-01f, -3.67545187e-02f, -2.96063840e-01f, -3.91676158e-01f, 6.14627302e-02f,
  -1.91618517e-01f, -7.68430680e-02f, -9.83965117e-04f, -8.19125623e-02f, 1.71871543e-01f, -2.69789755e-01f, -1.42467335e-01f, 8.74802545e-02f, -3.61737102e-01f, -4.61773962e-01f,
  -2.42679015e-01f, -2.91756094e-01f, -5.02880692e-01f, 3.82168621e-01f, 2.95005023e-01f, 1.58785462e-01f, 2.39897236e-01f, -2.16968507e-01f, -2.65774488e-01f, 2.77425677e-01f,
  -1.05254799e-01f, 1.85531154e-01f, 4.22262609e-01f, 1.16132013e-01f, 4.61232603e-01f, 2.63492297e-02f, -3.47798228e-01f, -1.52244374e-01f, -8.85796025e-02f, 4.60491590e-02f,
  3.82672936e-01f, -1.71128847e-02f, 2.67404094e-02f, 3.54208983e-02f, -1.23080015e-01f, -2.40817502e-01f, 2.33636081e-01f, 3.73328328e-01f, 6.11339957e-02f, 3.52654420e-02f,
  2.54148096e-01f, -6.55237064e-02f, -7.19164163e-02f, 3.05706803e-02f, -1.98999688e-01f, 1.79025218e-01f, 1.63737804e-01f, -7.22791329e-02f, -2.03088433e-01f, 6.77305982e-02f,
  -1.08377486e-01f, -3.22185278e-01f, 2.25150317e-01f, 1.76971659e-01f, 2.15277970e-01f, -3.65124047e-02f, -1.63506702e-01f, 1.12750001e-01f, -3.29002231e-01f, 1.82615891e-01f,
  -4.38505888e-01f, -3.12420070e-01f, 8.77040625e-02f, -1.53096378e-01f, 2.20420316e-01f, -7.50501007e-02f, -1.98806882e-01f, 2.72465311e-03f, -6.86782449e-02f, -2.56131470e-01f,
  -2.60332257e-01f, 4.10830796e-01f, 4.09621209e-01f, -3.93201970e-02f, 2.97061503e-01f, 4.32604402e-01f, -1.02208920e-01f, -1.95337415e-01f, -2.21614972e-01f, 2.51773775e-01f,
  3.36294174e-01f, -2.39337519e-01f, 3.34434360e-01f, 3.04751724e-01f, -2.23938435e-01f, 3.61417830e-01f, -2.77017355e-01f, 5.23580015e-01f, -2.60498911e-01f, -7.04789758e-02f,
  -2.30213463e-01f, -8.73068720e-02f, 1.37337968e-01f, -1.14267483e-01f, -7.18872026e-02f, -8.55174661e-02f, 6.72133937e-02f, -4.49274108e-02f, -1.80323333e-01f, -3.09740752e-01f,
  -1.27002507e-01f, -2.13608313e-02f, -4.62166518e-01f, -3.65246981e-02f, 3.82176340e-01f, -3.82972620e-02f, -1.54574484e-01f, 1.03083245e-01f, 4.63693768e-01f, -9.19588730e-02f,
  -1.20693758e-01f, -1.07846253e-01f, -1.08979970e-01f, -1.01228356e-02f, 2.44479075e-01f, 2.27793068e-01f, -3.28324616e-01f, 2.04064071e-01f, 1.14238188e-01f, -5.11376262e-01f,
  2.35022023e-01f, -1.89738169e-01f, 2.27883026e-01f, 2.70307213e-02f, 1.29205987e-01f, 2.27329835e-01f, 9.60650593e-02f, -5.02063408e-02f, -2.30509266e-01f, 2.69974738e-01f,
  3.97189558e-01f, 8.21996555e-02f, -4.91634756e-01f, 7.07896501e-02f, 2.85987228e-01f, 2.06246555e-01f, -4.42641020e-01f, 1.80360749e-01f, -2.16914535e-01f, 2.58243233e-01f,
  1.82218105e-01f, 2.04309940e-01f, 2.29423329e-01f, -4.53970939e-01f, -5.30848540e-02f, -1.73325419e-01f, -4.03990626e-01f, 2.85006583e-01f, 2.36797216e-03f, -1.37334734e-01f,
  1.72713846e-01f, -1.39979333e-01f, 4.06969815e-01f, -6.85804412e-02f, 4.55864221e-02f, 2.92040437e-01f, -9.72949527e-03f, 2.83029508e-02f, 2.83700347e-01f, -6.49971664e-02f,
  1.09010004e-01f, 2.99073663e-02f, -1.94677282e-02f, 2.95101166e-01f, -1.69660170e-02f, 1.60851404e-01f, -4.29499358e-01f, 3.10128123e-01f, -1.55150965e-01f, -2.04716220e-01f,
  -6.40814528e-02f, 3.35327946e-02f, -2.92226560e-02f, 1.21399425e-01f, 4.14156988e-02f, -1.92537889e-01f, 2.07753867e-01f, 1.66437000e-01f, -1.73863620e-01f, -3.86243612e-02f,
  1.62445441e-01f, -5.36130428e-01f, 2.39812836e-01f, -1.69517174e-02f, 2.44042680e-01f, 3.69663760e-02f, -3.29380453e-01f, 1.49920648e-02f, -4.43867326e-01f, 2.53754467e-01f,
  4.90419567e-02f, -3.99784058e-01f, -1.23952478e-01f, 1.99676916e-01f, 2.12568238e-01f, 4.05176636e-03f, -3.37356359e-01f, -1.73925667e-03f, 7.00203981e-03f, 3.40851337e-01f,
  9.74215101e-03f, -2.40255594e-01f, 3.01408738e-01f, 9.41451639e-02f, -1.05963588e-01f, -1.06297331e-02f, 1.95505932e-01f, 1.71524793e-01f, 6.81918785e-02f, 4.77487653e-01f,
  1.62501469e-01f, -5.52074850e-01f, 1.19524665e-01f, -1.58984154e-01f, 2.51741052e-01f, 3.97710443e-01f, -2.77253866e-01f, 5.00753429e-03f, -2.81252563e-01f, -3.86837497e-02f,
  -1.39929041e-01f, 1.97016373e-01f, -1.38447508e-01f, -5.98007999e-02f, -1.68992076e-02f, 9.11889598e-02f, 9.78911072e-02f, -3.48255724e-01f, -3.59736476e-03f, -2.64940351e-01f,
  4.49395835e-01f, 9.68837067e-02f, 1.48525760e-01f, 1.30112484e-01f, -1.26903892e-01f, 2.53743101e-02f, -2.77497843e-02f, -9.77646634e-02f, 3.42934161e-01f, -2.14275301e-01f,
  -1.96641311e-02f, -1.51661381e-01f, 1.22942843e-01f, -2.33035311e-01f, 3.81564289e-01f, 4.26217377e-01f, 8.21938813e-02f, 7.93614089e-02f, -2.96960711e-01f, -1.79013871e-02f,
  3.15677881e-01f, 2.13064536e-01f, 4.72178996e-01f, -2.71329116e-02f, 2.70353779e-02f, 4.79572743e-01f, 2.29985550e-01f, -2.90917128e-01f, -4.43990827e-01f, 4.06172089e-02f,
  3.32334399e-01f, -8.89242962e-02f, -5.72070479e-02f, 2.52076328e-01f, -2.86833346e-01f, -3.13591599e-01f, -1.35429412e-01f, 3.58207166e-01f, -3.56826007e-01f, -1.77428257e-02f,
  -1.56214401e-01f, -2.16595992e-01f, 2.70860761e-01f, -2.38702610e-01f, -1.00799613e-01f, 4.41230267e-01f, -1.22052349e-01f, 1.37547106e-01f, -1.63373037e-03f, 1.94037840e-01f,
  -4.21825767e-01f, 2.16446840e-03f, 1.88903674e-01f, 2.65426308e-01f, 3.62829536e-01f, -2.08509546e-02f, -2.18150392e-01f, 3.21476907e-02f, -8.29000622e-02f, 1.29328206e-01f,
  -8.41790661e-02f, -3.34695846e-01f, 3.08168493e-02f, 1.99325085e-02f, -3.63191605e-01f, -1.30887464e-01f, -2.98892736e-01f, -1.98193744e-01f, -1.44439697e-01f, -1.16352320e-01f,
  -1.15452245e-01f, 4.24837142e-01f, 2.65505649e-02f, -1.46381510e-02f, 2.96266377e-02f, 8.88923183e-02f, 1.68425858e-01f, 2.58664370e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.99495109e-03f, 2.29405150e-01f, -6.30266443e-02f, -7.19305649e-02f, -1.01309001e-01f, 9.93730649e-02f, -2.70449966e-02f, 1.29047006e-01f, 1.55092970e-01f, -3.99506241e-02f,
  6.87489137e-02f, -7.06564337e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    