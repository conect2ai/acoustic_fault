/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.90861464e-01f, -6.87292591e-02f, -2.73530215e-01f, 7.47727230e-02f, 5.78794675e-03f, -2.14557037e-01f, -1.52298510e-01f, 5.43740280e-02f, -1.43705726e-01f, 6.78369626e-02f,
  1.00226253e-01f, -9.05963182e-02f, -6.63120821e-02f, 1.07101664e-01f, 5.57571203e-02f, 3.07474639e-02f, 1.31187618e-01f, 3.08712386e-02f, -2.88206972e-02f, 1.43920332e-01f,
  -3.58118080e-02f, 1.92674622e-01f, 8.97738710e-02f, 1.34798765e-01f, 2.49586478e-02f, -2.65197139e-02f, 1.87627494e-01f, -4.05971743e-02f, 9.96667519e-02f, 1.05527900e-02f,
  -3.27877253e-02f, -8.47687870e-02f, 2.22413205e-02f, -9.73113533e-03f, -1.14511065e-02f, -4.93934676e-02f, -3.09588406e-02f, 7.36814830e-03f, -6.65550400e-03f, -4.67076562e-02f,
  -1.98123744e-03f, 9.70720965e-03f, -3.52562405e-02f, 5.07734902e-03f, -4.29101288e-02f, -3.16818804e-02f, -2.80434731e-02f, -3.17135043e-02f, -3.03468537e-02f, -5.48705831e-02f,
  -5.05758189e-02f, 1.50898406e-02f, 3.91206332e-03f, -5.81254996e-03f, -9.68660414e-03f, 2.10654773e-02f, -5.22325076e-02f, -2.10199803e-02f, -6.04537167e-02f, -5.78618236e-02f,
  -1.09669976e-02f, -4.50155549e-02f, 2.04899795e-02f, -1.75098889e-02f, 1.58129651e-02f, 2.64412016e-02f, -1.38637889e-02f, 5.18404692e-02f, -3.89040145e-03f, 5.33934012e-02f,
  3.68158184e-02f, -3.10649071e-02f, -1.67052355e-02f, -5.16791008e-02f, -6.19067904e-03f, -6.67008245e-03f, -2.47511789e-02f, 9.65045113e-03f, -4.97525232e-03f, -3.58233415e-03f,
  -2.04262938e-02f, 2.14247848e-03f, 2.27681436e-02f, 2.34164465e-02f, 3.51505056e-02f, -6.79273577e-03f, 4.33224952e-03f, -3.97696383e-02f, -9.54406615e-03f, -1.17831156e-02f,
  9.44356918e-02f, 1.29214510e-01f, -1.47483284e-02f, -4.82376106e-02f, 2.70584524e-02f, 1.25356829e-02f, 1.30160023e-02f, 1.99353322e-02f, -6.03519054e-03f, -1.49366288e-02f,
  -6.34503458e-03f, -5.63180912e-03f, 2.23861355e-02f, 2.14717910e-02f, 8.33071396e-03f, 4.20261435e-02f, 4.41851467e-02f, 1.69217847e-02f, 2.90418081e-02f, 1.26969814e-02f,
  6.29894435e-02f, -3.03226225e-02f, -1.12009477e-02f, 1.75505392e-02f, 1.06116263e-02f, 4.34681866e-03f, -1.53738800e-02f, -4.42358069e-02f, 7.66711533e-02f, -2.79024225e-02f,
  -7.69086421e-01f, -3.56278747e-01f, -2.03397930e-01f, -6.96748421e-02f, -1.39593244e-01f, 2.00191755e-02f, -1.15276881e-01f, -9.68788415e-02f, -1.22850500e-01f, -1.95884585e-01f,
  -1.01636603e-01f, -9.93287414e-02f, -1.89075574e-01f, -1.14830434e-01f, -4.90505844e-02f, -2.23102555e-01f, -4.06459235e-02f, -6.26377314e-02f, -1.21423416e-01f, -9.34347212e-02f,
  2.70823967e-02f, -1.94581628e-01f, -1.02464296e-01f, 3.25099304e-02f, 8.31769407e-03f, -5.83961122e-02f, -5.50055020e-02f, -4.82550189e-02f, 5.93479536e-03f, -8.81562661e-03f,
  7.12824427e-03f, -5.47470041e-02f, -3.21111642e-02f, 3.93376164e-02f, -2.58340146e-02f, 8.57254397e-03f, 5.60287163e-02f, 3.26126292e-02f, 8.04163143e-03f, -4.91351709e-02f,
  -2.94909067e-03f, 6.03241138e-02f, -4.63653319e-02f, -1.15679586e-02f, -1.69101600e-02f, -6.23596180e-03f, 8.78050178e-02f, -1.91532429e-02f, -1.19152351e-03f, -3.14175449e-02f,
  -4.45668139e-02f, -5.96241131e-02f, -1.87190864e-02f, -8.47057998e-03f, -1.57424975e-02f, 1.69123281e-02f, 4.01270650e-02f, -5.13588116e-02f, -3.79328392e-02f, -7.13662580e-02f,
  2.62812395e-02f, 1.23237194e-02f, 3.41620594e-02f, 7.30699971e-02f, 1.31698633e-02f, 6.64427057e-02f, 6.62266985e-02f, 3.63746807e-02f, 1.26317302e-02f, -4.34731431e-02f,
  7.02926666e-02f, 3.13581228e-02f, 4.26461324e-02f, -1.88356321e-02f, 4.90231402e-02f, 3.89877963e-03f, -2.67677251e-02f, -1.99044663e-02f, 1.83363780e-02f, -4.36995700e-02f,
  1.08486405e-02f, -7.11979568e-02f, -1.35780533e-03f, -3.57541069e-02f, 4.26074490e-02f, -2.15936620e-02f, 4.82026637e-02f, 2.47345027e-03f, 3.35663818e-02f, 9.42608621e-03f,
  -3.75820808e-02f, -1.22150682e-01f, 1.42248161e-02f, 3.21332775e-02f, 2.62274072e-02f, 2.17682347e-02f, -5.21766245e-02f, -5.66558838e-02f, 1.85729675e-02f, -3.06335092e-03f,
  2.14360710e-02f, 5.08592911e-02f, -2.83824094e-02f, 5.45812733e-02f, 4.17584740e-02f, -4.84836027e-02f, -9.57494378e-02f, 8.23349208e-02f, 6.35733977e-02f, 1.22749032e-02f,
  -7.31208641e-03f, -2.48619094e-02f, 1.68193821e-02f, 7.88846537e-02f, 4.57129553e-02f, -2.10227980e-03f, 1.47936344e-02f, 9.07146707e-02f, 2.92444229e-03f, 3.41377817e-02f,
  4.42186922e-01f, 2.07487289e-02f, -1.50655553e-01f, 2.90864557e-01f, 4.63920869e-02f, -1.32167991e-03f, -2.20094681e-01f, 6.10930175e-02f, 7.97848478e-02f, -1.28640980e-01f,
  -6.36103153e-02f, 1.71544358e-01f, -1.57515332e-01f, 1.63201362e-01f, 1.63566068e-01f, 8.15747380e-02f, 7.01733530e-02f, 2.95402817e-02f, 4.53807525e-02f, -4.15450595e-02f,
  1.35370875e-02f, 2.50293072e-02f, 3.55484262e-02f, 6.60262182e-02f, -5.61320633e-02f, -9.94177163e-02f, 3.85339488e-03f, -8.96662176e-02f, 1.45387322e-01f, 8.60447586e-02f,
  -2.65023038e-02f, -3.52440104e-02f, -2.08083987e-02f, 3.49083208e-02f, -3.74350548e-02f, -8.63814279e-02f, -1.82687379e-02f, 3.52265090e-02f, 5.53414673e-02f, -2.94212215e-02f,
  -1.13159837e-02f, 5.60973994e-02f, -5.78444861e-02f, -3.63581330e-02f, -8.39880183e-02f, 3.37208770e-02f, 7.34730139e-02f, -1.67294405e-02f, -3.30680683e-02f, -6.36623055e-02f,
  -3.59537862e-02f, 9.60288662e-03f, 2.04142928e-02f, 3.09411027e-02f, -2.06450094e-02f, -2.48316256e-03f, -1.94839761e-02f, -7.70432130e-02f, -1.02550611e-02f, -4.23060246e-02f,
  1.05946267e-03f, -4.17978950e-02f, -7.06903310e-03f, 4.41029407e-02f, -4.84184548e-02f, 2.86105126e-02f, 2.25616097e-02f, 4.24236357e-02f, -1.21808723e-02f, -6.75939349e-03f,
  2.09368411e-02f, 5.22618629e-02f, 2.96934918e-02f, 7.30177900e-03f, 1.58710331e-02f, -2.12063733e-03f, 8.19858070e-03f, -5.75435460e-02f, -3.46441492e-02f, -2.32411455e-02f,
  -1.00073181e-02f, 4.49212408e-03f, -3.94829512e-02f, -3.21881138e-02f, 7.24139158e-03f, 1.21279536e-02f, 6.24258146e-02f, 1.05556613e-02f, -1.08515266e-02f, -2.73250113e-03f,
  -3.81814167e-02f, -8.29350203e-02f, 5.76478371e-04f, 6.69172918e-03f, -4.22689617e-02f, 8.01641196e-02f, 9.51538980e-03f, -3.19615155e-02f, -3.33711766e-02f, -2.02222485e-02f,
  -4.01899964e-02f, -5.43861352e-02f, -4.50749270e-04f, 3.55754755e-02f, 7.30224401e-02f, -7.87595659e-02f, -7.62117356e-02f, 1.38256559e-02f, 3.22725549e-02f, 9.66524482e-02f,
  3.72565025e-03f, -1.27546135e-02f, 3.10204905e-02f, -1.85115065e-03f, 1.18248872e-02f, -6.01749904e-02f, -5.06204143e-02f, 4.58849408e-02f, -6.62741513e-05f, 1.01895202e-02f,
  -5.75709939e-01f, -1.87812120e-01f, -1.69709548e-01f, -2.45287433e-01f, -1.35149539e-01f, 8.55399948e-03f, -9.80335474e-02f, 4.06325646e-02f, -2.81055458e-02f, -5.16271815e-02f,
  2.62223720e-03f, -5.86680397e-02f, 5.13670594e-02f, 4.77856444e-03f, 8.07401463e-02f, 1.72629073e-01f, -6.69152066e-02f, -5.27303480e-02f, 1.06409699e-01f, -5.19542694e-02f,
  -6.45940518e-03f, -2.15813611e-02f, -6.43369183e-02f, -3.70143056e-02f, -1.74422905e-01f, -2.96404939e-02f, 5.06822839e-02f, 2.91434973e-02f, 3.65324095e-02f, 8.83059502e-02f,
  1.25117436e-01f, -3.25367637e-02f, -3.59282792e-02f, -1.25668934e-02f, -6.41416088e-02f, -8.79683271e-02f, -1.80692307e-03f, -2.90391333e-02f, 3.47370207e-02f, 8.00073668e-02f,
  -2.81418692e-02f, -2.86809094e-02f, 3.46658640e-02f, 7.87024349e-02f, -1.22242477e-02f, -4.15259451e-02f, -3.48611586e-02f, -4.90584150e-02f, -5.64163877e-03f, -2.59827506e-02f,
  -4.87921536e-02f, 1.02812788e-02f, -8.37481841e-02f, 1.48158045e-02f, -4.06683510e-04f, -5.52190701e-04f, 6.29422080e-04f, 2.93365791e-02f, 3.52265760e-02f, -1.00060005e-03f,
  -8.98214523e-04f, 2.90289875e-02f, -1.08166356e-02f, -9.72819631e-04f, -7.55620599e-02f, -2.23003738e-02f, 4.82400432e-02f, -5.19969761e-02f, 5.85849062e-02f, -6.02030456e-02f,
  1.43312290e-03f, 2.50853971e-02f, -4.66406085e-02f, 1.54241649e-02f, -1.76337883e-02f, 6.98122382e-03f, 2.48280242e-02f, 6.76593333e-02f, -6.83551803e-02f, 6.33419584e-03f,
  1.51930209e-02f, 3.51391025e-02f, 5.34878224e-02f, 6.83063716e-02f, 2.37687007e-02f, 4.46572304e-02f, -1.80019159e-02f, -1.70061998e-02f, 2.08217930e-02f, 5.34970015e-02f,
  -4.63120155e-02f, 8.69842470e-02f, 7.55131012e-03f, -7.31844902e-02f, 9.94682312e-03f, -2.48113666e-02f, 4.47595818e-03f, -3.26229259e-03f, -5.65623157e-02f, -3.19638178e-02f,
  -5.84390052e-02f, -2.91992053e-02f, -1.06282998e-02f, -1.12457490e-02f, -1.31651396e-02f, -7.52557740e-02f, 3.09235528e-02f, -1.92290545e-02f, -5.46529442e-02f, 9.31539536e-02f,
  -4.29393612e-02f, -3.05777043e-02f, -5.31065799e-02f, -1.23389438e-01f, 3.47611755e-02f, -1.30467443e-02f, -3.60708088e-02f, 2.87510306e-02f, -8.00887414e-04f, 6.24218993e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.59281325e-02f, -1.98631231e-02f, 2.56021887e-01f, 3.84759188e-01f, -1.35937944e-01f, -4.03543204e-01f, -4.13836449e-01f, 7.65944794e-02f, 9.90184606e-04f, -3.32433552e-01f,
  -1.26779154e-01f, 1.74562305e-01f, -4.46345329e-01f, 6.34668395e-02f, 7.60827586e-03f, -3.07927072e-01f, 4.04354669e-02f, 1.07806148e-02f, -6.69114292e-02f, 1.19712770e-01f,
  2.53573388e-01f, -1.23975173e-01f, 2.19962850e-01f, 2.75056809e-02f, 1.07638910e-01f, 3.90217930e-01f, 5.67068830e-02f, -5.03997728e-02f, 2.33499125e-01f, -5.48812859e-02f,
  -1.19079560e-01f, 1.52733356e-01f, 1.47642627e-01f, -1.04526892e-01f, -3.52325365e-02f, -1.75707489e-02f, -7.85195548e-03f, -8.74312669e-02f, 4.49323989e-02f, 1.67190528e-03f,
  -1.95060447e-02f, 2.95510702e-02f, 2.77758520e-02f, -1.80522949e-02f, 4.86162826e-02f, 5.05537875e-02f, 1.03011891e-01f, 7.08572473e-03f, 3.38223390e-02f, 6.09829724e-02f,
  1.15826381e-02f, -1.57388626e-03f, -3.11169457e-02f, -3.90771516e-02f, 1.96054205e-02f, 2.53453329e-02f, 4.11600061e-02f, 7.03870803e-02f, 6.06995858e-02f, 7.76450559e-02f,
  -5.99312074e-02f, -8.89060721e-02f, -5.31892851e-02f, 1.25678396e-02f, 2.37175007e-03f, -2.67156977e-02f, 1.50441835e-02f, -9.18521658e-02f, 1.39555298e-02f, 1.26014985e-02f,
  5.53585775e-02f, 4.18740250e-02f, -4.79897335e-02f, -7.43059441e-02f, -1.44553855e-02f, 2.00777072e-02f, 1.84658803e-02f, -1.94970518e-02f, -9.86457244e-03f, 2.20516436e-02f,
  -1.11909546e-01f, -3.12149171e-02f, -2.17885319e-02f, 3.34332809e-02f, -2.17655338e-02f, 2.16687135e-02f, -7.20249042e-02f, -4.18723598e-02f, -1.05826547e-02f, 2.24077539e-03f,
  -2.53677130e-01f, -1.48180857e-01f, 3.80961709e-02f, 2.97546722e-02f, 1.17541067e-01f, -6.44849334e-03f, -3.73521373e-02f, 4.80429977e-02f, -2.80012209e-02f, -4.78084907e-02f,
  4.66600917e-02f, 5.63156698e-03f, -3.25994715e-02f, 2.44375691e-02f, -4.31197509e-02f, -8.12270418e-02f, -4.67585549e-02f, -8.94520245e-03f, 7.68738193e-03f, 4.64066789e-02f,
  5.42326272e-02f, -9.03447047e-02f, 6.59508482e-02f, -4.11762148e-02f, 7.20680654e-02f, -1.67840067e-02f, 7.42439926e-02f, 1.59550551e-02f, -1.44370529e-03f, -1.10817872e-01f,
  -2.77853817e-01f, -2.27847904e-01f, -1.59238011e-01f, 6.57193735e-02f, -4.21635993e-02f, -8.31605867e-02f, -5.35218120e-02f, -1.39967680e-01f, -9.41355824e-02f, 6.67998195e-02f,
  -1.74366292e-02f, -5.10660261e-02f, -1.01626091e-01f, -5.67207523e-02f, -1.54308930e-01f, -1.31236553e-01f, 2.10187305e-03f, -1.21898063e-01f, -2.66317837e-02f, -4.64642383e-02f,
  -1.25823304e-01f, 4.17056456e-02f, -9.03946012e-02f, -1.54486336e-02f, 1.75701044e-02f, 1.36749417e-01f, 5.33270165e-02f, 2.28831749e-02f, 1.73769016e-02f, 4.60919403e-02f,
  -1.25139788e-01f, 6.01723008e-02f, -3.08501571e-02f, -1.24478802e-01f, 4.38395478e-02f, 4.68160696e-02f, 1.05176978e-01f, -4.04117629e-03f, -3.09578311e-02f, -5.74545711e-02f,
  3.76969799e-02f, -1.02150977e-01f, 3.75653021e-02f, -8.14400911e-02f, -6.65359125e-02f, 6.49838299e-02f, 4.98936977e-04f, -2.34857332e-02f, -8.40211287e-02f, 4.45633903e-02f,
  3.88214886e-02f, 5.20080402e-02f, -4.63212095e-03f, 7.73567334e-02f, -1.00985701e-04f, -1.48534048e-02f, -3.70466858e-02f, -2.96632890e-02f, 5.50739169e-02f, 1.64104372e-01f,
  1.64574683e-02f, 8.83849189e-02f, -9.47085768e-02f, -5.56373857e-02f, -3.40084769e-02f, -9.78048798e-03f, -8.73697624e-02f, -7.21663535e-02f, -1.81237515e-02f, 3.49503756e-02f,
  -1.14344038e-01f, 1.69408899e-02f, -2.56132539e-02f, 6.56654313e-02f, 1.15593150e-01f, 1.70000903e-02f, -1.63267627e-02f, -1.21308438e-01f, -2.19948012e-02f, -3.93771939e-02f,
  -3.03495526e-02f, 3.80781405e-02f, -1.31412640e-01f, -1.04269750e-01f, -1.13477595e-01f, -4.32173675e-03f, -1.09968800e-02f, 3.65307070e-02f, 8.59353319e-03f, 3.42541933e-03f,
  -6.15633279e-02f, -8.72378573e-02f, -8.31605773e-03f, 4.24181484e-03f, -5.54942945e-03f, 2.94463653e-02f, 5.55453449e-02f, -3.54164280e-02f, -1.03859454e-01f, -2.24268492e-02f,
  -6.46494329e-02f, -1.18895480e-03f, -3.95240933e-02f, -3.72769497e-02f, 3.19425911e-02f, 6.97999150e-02f, 2.17122976e-02f, -2.08042050e-03f, 5.53475171e-02f, -2.71813553e-02f,
  3.99609432e-02f, -4.52807202e-04f, 1.07359678e-01f, -1.80328395e-02f, -1.61772908e-03f, 5.72180413e-02f, 2.36861650e-02f, -3.33920829e-02f, -3.94259989e-02f, -1.22082070e-01f,
  -4.85388190e-01f, -1.14322029e-01f, -2.27536604e-01f, -3.61940145e-01f, 4.66752276e-02f, -4.74699378e-01f, -4.34565991e-01f, -6.96042031e-02f, 1.96699664e-01f, -1.43717498e-01f,
  -1.14088073e-01f, 2.23848503e-03f, 9.20273066e-02f, -2.60980576e-01f, -1.87941603e-02f, 8.08345526e-02f, -3.83911520e-01f, -2.86637396e-01f, 1.51939079e-01f, -2.92484343e-01f,
  -1.36772528e-01f, -2.06535518e-01f, -1.95682555e-01f, 4.65833619e-02f, -2.97770768e-01f, 1.27712702e-02f, -1.40067533e-01f, 8.67069140e-02f, -2.19447955e-01f, 8.47394094e-02f,
  7.85309151e-02f, 1.71200439e-01f, -1.15320317e-01f, 5.30342311e-02f, -1.96184337e-01f, -5.63693978e-02f, -1.30259365e-01f, -2.32026298e-02f, 1.13044176e-02f, 4.94014705e-03f,
  -3.78176197e-02f, 6.52331188e-02f, -7.49868387e-03f, 6.09326065e-02f, -3.73634435e-02f, 6.47351146e-02f, 1.57635082e-02f, 2.28510257e-02f, -7.53758699e-02f, 3.73976268e-02f,
  -8.58022925e-03f, 2.13751197e-02f, -9.60332677e-02f, -3.88860032e-02f, 7.54831657e-02f, 7.98658505e-02f, -1.70494951e-02f, -2.79396232e-02f, -1.30320797e-02f, -3.62796523e-02f,
  -1.00639733e-02f, -2.21149828e-02f, -7.21114278e-02f, 5.14243245e-02f, -6.33928645e-03f, 9.16817114e-02f, -3.61731425e-02f, 1.98745709e-02f, 3.64954136e-02f, -7.51268957e-03f,
  -4.81931753e-02f, -1.47873521e-04f, -2.01537050e-02f, -4.86794021e-03f, -9.19715315e-02f, -7.99089763e-03f, -3.85068431e-02f, -2.85511557e-02f, -1.99820641e-02f, 1.43118128e-02f,
  2.76830886e-02f, -8.89429182e-04f, 4.42578718e-02f, -2.49465983e-02f, 4.72353362e-02f, 3.35491225e-02f, 3.44370045e-02f, 1.74000151e-02f, -4.11208533e-02f, -3.73778492e-02f,
  -2.45179102e-01f, -3.54424864e-01f, 5.04842028e-02f, -3.07502616e-02f, 5.01457714e-02f, -8.20244998e-02f, 7.89220387e-04f, 3.01470179e-02f, -3.09392419e-02f, 2.08607111e-02f,
  -6.53031841e-02f, -8.10953304e-02f, -5.02101555e-02f, -4.33179364e-02f, -1.18683500e-03f, -1.16265928e-02f, -7.73382485e-02f, -8.41967538e-02f, -6.42469227e-02f, -3.52519602e-02f,
  3.67295295e-02f, 5.48577458e-02f, 1.31335989e-01f, -1.29299480e-02f, -9.09301117e-02f, -1.45205408e-01f, -4.31337729e-02f, 1.42261609e-02f, -4.76256758e-02f, 3.66285481e-02f,
  3.45140472e-02f, -3.14200193e-01f, -7.41723180e-02f, -2.51502898e-02f, 5.64311892e-02f, -1.60387382e-01f, -5.66736162e-02f, -4.42930967e-01f, -5.88854291e-02f, -1.27880201e-01f,
  -1.91094533e-01f, 3.23343784e-01f, 1.04567632e-01f, -2.32882991e-01f, 4.84667391e-01f, 1.90836161e-01f, -3.25078607e-01f, -8.73387530e-02f, -1.08500272e-01f, -3.02950382e-01f,
  -2.79672500e-02f, -2.38984466e-01f, 1.01869196e-01f, -3.15290540e-01f, -9.35993716e-02f, -8.62516463e-02f, 2.19495386e-01f, -5.18794954e-02f, -1.73357189e-01f, 3.76854499e-04f,
  7.61536583e-02f, 1.10970758e-01f, -8.12183917e-02f, 2.41015814e-02f, -4.68475074e-02f, -6.35722429e-02f, -5.70248663e-02f, 1.33139715e-01f, 7.98685104e-02f, -4.62322719e-02f,
  4.83279005e-02f, -4.98339832e-02f, -5.67390919e-02f, -1.56144018e-03f, -9.57902074e-02f, -1.87673606e-02f, 6.09836504e-02f, -4.49421182e-02f, -6.89465329e-02f, 1.02179190e-02f,
  -6.03078119e-02f, 3.30575891e-02f, -7.05268383e-02f, -2.84372922e-02f, -1.68404896e-02f, -6.60297349e-02f, 8.03641677e-02f, 9.83051136e-02f, -3.08463965e-02f, -2.83043012e-02f,
  1.84080619e-02f, -1.52888726e-02f, 3.17473151e-02f, 6.43823817e-02f, 2.16743164e-03f, -2.18223874e-02f, -2.11230293e-02f, -7.15994388e-02f, 3.91080678e-02f, -5.56801036e-02f,
  7.74447471e-02f, 3.26231383e-02f, 2.79699937e-02f, 2.95384079e-02f, -1.81592684e-02f, 4.96993326e-02f, 9.81723666e-02f, 3.56361689e-03f, -1.03022069e-01f, 8.53708908e-02f,
  -5.24788275e-02f, -2.65205540e-02f, 7.89461583e-02f, -3.01238708e-02f, -6.76450208e-02f, 1.23182230e-01f, 2.03077048e-02f, 2.50471439e-02f, 8.46787915e-03f, 2.46295705e-02f,
  -3.68334167e-02f, 2.61927918e-02f, -2.41169482e-02f, 2.25769375e-02f, 1.24521386e-02f, 2.75783520e-02f, -9.12707485e-03f, -7.05589205e-02f, -2.84784455e-02f, 2.74192784e-02f,
  -3.56423929e-02f, 7.13451281e-02f, -8.16055387e-02f, -4.72407863e-02f, 2.05638856e-02f, -6.56211525e-02f, -2.43397709e-02f, 6.73244381e-03f, -5.55838309e-02f, -1.24488838e-01f,
  1.94041505e-02f, -4.83920751e-03f, 1.19708061e-01f, -8.77673738e-03f, -3.28233186e-03f, 5.03803790e-02f, 6.13041185e-02f, -1.05024362e-02f, 6.68791868e-03f, -5.32114767e-02f,
  -7.17215389e-02f, -2.26210579e-02f, -3.49564999e-02f, -9.09430906e-02f, 3.82374190e-02f, -2.41229571e-02f, -6.04889281e-02f, 8.19155574e-02f, 1.06822858e-02f, -1.50410933e-02f,
  -3.77692580e-02f, 8.02622288e-02f, 5.90951229e-03f, -3.07123754e-02f, -9.19723064e-02f, -1.32376641e-01f, -7.77766854e-02f, -3.83752920e-02f, 1.78356189e-02f, 9.24560651e-02f,
  6.68975189e-02f, -1.41851455e-02f, -2.35836972e-02f, -5.08708097e-02f, -8.58287588e-02f, -3.29706222e-02f, -9.14668366e-02f, 1.21568233e-01f, -1.40708193e-01f, 4.99426061e-03f,
  -2.42518038e-02f, -2.07327735e-02f, 9.15583819e-02f, 4.63995636e-02f, -7.42593110e-02f, -1.02723986e-02f, -6.02209801e-03f, 9.14140642e-02f, -1.70446690e-02f, 9.40739177e-03f,
  7.11779147e-02f, 9.64714866e-03f, -5.43940216e-02f, -4.77182008e-02f, 1.90769620e-02f, 4.78967167e-02f, -6.63906634e-02f, 4.84753214e-02f, 3.66870761e-02f, 1.47347957e-01f,
  1.11348033e-01f, 3.78908925e-02f, -5.71080782e-02f, -1.29677597e-02f, 1.72286835e-02f, 3.37634049e-02f, -4.62419204e-02f, -4.45811152e-02f, -4.92634438e-02f, -1.29488613e-02f,
  4.54720482e-02f, -1.14513738e-02f, -7.94313103e-02f, -5.15686236e-02f, -7.41899991e-03f, -4.44105864e-02f, 7.01114312e-02f, -6.62791803e-02f, 5.72978370e-02f, 8.67516845e-02f,
  -7.29357749e-02f, -1.97662059e-02f, 5.27876895e-04f, -5.07650375e-02f, -7.17538875e-03f, -8.37256666e-03f, -3.03197391e-02f, -5.42702079e-02f, 1.79207530e-02f, 1.81461293e-02f,
  -5.70611656e-02f, -4.75159734e-02f, 6.04028143e-02f, 7.38446414e-02f, 2.66948976e-02f, 8.00241309e-04f, -3.36680636e-02f, 2.30914950e-02f, 7.22839832e-02f, -3.71360555e-02f,
  1.02865584e-02f, 3.32764350e-03f, 6.50482848e-02f, -1.53383482e-02f, 2.09446959e-02f, -7.14962557e-02f, 2.70214491e-02f, 7.14447349e-02f, -5.02574630e-02f, -2.83162314e-02f,
  4.24280055e-02f, 6.86472878e-02f, -5.88298365e-02f, 3.73234749e-02f, 1.10577773e-02f, 9.42806229e-02f, 2.94381604e-02f, -2.43193675e-02f, -4.45213169e-02f, 1.08380876e-02f,
  1.39150408e-03f, 5.08967303e-02f, -6.73725680e-02f, 1.23189352e-01f, 1.00351728e-01f, 6.84061125e-02f, 3.27363126e-02f, -1.05854720e-02f, 2.30492540e-02f, 1.18517783e-02f,
  -1.56905487e-01f, -2.37200454e-01f, 3.44065756e-01f, -4.39300656e-01f, 3.70556936e-02f, 2.06326634e-01f, 1.18170738e-01f, -1.30848646e-01f, -3.94412249e-01f, -3.42461497e-01f,
  -9.02431384e-02f, 2.66970228e-02f, 1.50621429e-01f, -2.59215474e-01f, 3.02783132e-01f, 2.18196586e-01f, -1.83050185e-01f, -6.88993260e-02f, 1.34240508e-01f, -3.60303721e-03f,
  6.91124275e-02f, -1.60425499e-01f, 2.49622926e-01f, 9.56961140e-03f, 6.45226836e-02f, -4.79208529e-02f, -1.00639388e-01f, 2.73093343e-01f, -2.32297480e-02f, 9.34234187e-02f,
  9.23813414e-03f, -9.95228514e-02f, -1.53071228e-02f, -4.38507237e-02f, 2.20431890e-02f, -9.36221890e-03f, 7.35358372e-02f, 9.58945826e-02f, -2.36863978e-02f, -3.13190147e-02f,
  -6.48698118e-03f, 1.91490371e-02f, -7.25789517e-02f, -4.06990871e-02f, -1.05505921e-02f, -1.01231091e-01f, 5.77656180e-02f, 1.94914304e-02f, 5.99081367e-02f, 1.07698895e-01f,
  6.86465129e-02f, -5.07708415e-02f, -9.66816326e-04f, -5.06862029e-02f, 4.38717864e-02f, -1.49016097e-01f, -1.75494887e-02f, 5.12902923e-02f, -6.37358725e-02f, -1.21163376e-01f,
  -7.41732121e-02f, -1.01745101e-02f, 4.98917699e-02f, -9.17267203e-02f, 3.31811234e-02f, -1.15975149e-01f, -1.29583478e-03f, 7.72414282e-02f, -2.32584719e-02f, -2.41836421e-02f,
  -1.99938305e-02f, -2.26202440e-02f, -8.68668631e-02f, -6.68923706e-02f, -5.63263632e-02f, -8.03429782e-02f, 4.51429598e-02f, 2.72718761e-02f, -5.59836999e-03f, -2.02362668e-02f,
  4.67750616e-03f, 1.81359146e-02f, 4.15889360e-03f, 1.38389254e-02f, 3.22330669e-02f, 3.23896259e-02f, -8.13837424e-02f, -5.34124337e-02f, 1.08884968e-01f, 8.05263594e-02f,
  5.58658615e-02f, -1.74593285e-01f, 6.40037209e-02f, -4.22645845e-02f, 3.48996520e-02f, -1.48373693e-02f, 9.73501895e-03f, -2.69618258e-03f, -7.91682228e-02f, -2.99099106e-02f,
  -9.58006084e-02f, -7.42813125e-02f, -2.00567506e-02f, 5.66304103e-02f, 4.09801267e-02f, -3.07930671e-02f, 6.80387840e-02f, 2.72316989e-02f, 3.60167772e-02f, 2.44331509e-02f,
  4.86543663e-02f, -2.73162946e-02f, 2.35063350e-03f, -2.92000175e-02f, -4.02011685e-02f, 1.20160179e-02f, -9.77853164e-02f, -1.95284169e-02f, 7.07596242e-02f, -5.17051369e-02f,
  -1.36130199e-01f, 1.57700956e-01f, -2.68676300e-02f, -1.10267855e-01f, 1.66279793e-01f, 9.87314619e-04f, -3.06631736e-02f, 2.84086596e-02f, -1.31593123e-01f, 4.44492176e-02f,
  -1.68521643e-01f, -1.10786237e-01f, -1.37263928e-02f, -1.78028703e-01f, -4.45310891e-01f, -2.57358700e-01f, -2.98865765e-01f, -4.59953956e-02f, -1.43687278e-01f, 6.58830032e-02f,
  -2.24104106e-01f, -1.22934813e-02f, -1.18294060e-01f, 1.11545131e-01f, 1.20559849e-01f, -4.41966520e-04f, 1.09221727e-01f, 1.17941566e-01f, -4.93358895e-02f, -8.01102519e-02f,
  1.21594042e-01f, 1.08711265e-01f, 4.15266827e-02f, 6.46771714e-02f, -3.85820009e-02f, 9.43469815e-03f, 9.53923166e-02f, 4.89185005e-02f, -5.86430840e-02f, -4.62452769e-02f,
  3.19802165e-02f, 7.98960391e-04f, -8.19853544e-02f, 2.44176458e-03f, 8.94648582e-02f, 2.18773615e-02f, -9.44420602e-03f, 1.08419787e-02f, 3.86036113e-02f, -4.68574949e-02f,
  -6.44164160e-02f, 8.82670190e-03f, 9.98018682e-03f, -1.86204817e-02f, -3.67092304e-02f, -5.89989536e-02f, -3.75868864e-02f, 1.98116270e-03f, -9.36132222e-02f, -8.45106319e-02f,
  7.86732957e-02f, 2.81509967e-03f, 4.16351818e-02f, -1.15111256e-02f, 4.66004051e-02f, 1.26680648e-02f, 5.04919514e-02f, 6.51657283e-02f, -4.26319912e-02f, 9.73718613e-03f,
  -6.37616292e-02f, -3.28644807e-03f, 6.80299252e-02f, -2.56088544e-02f, -2.39043664e-02f, -2.47452166e-02f, -1.14008859e-02f, 1.29196895e-02f, 3.33114457e-03f, -3.96143496e-02f,
  6.53232485e-02f, -5.82005642e-02f, -8.30205623e-04f, -5.32323448e-03f, -3.14057176e-03f, -1.29955038e-02f, 4.15203199e-02f, 4.31036241e-02f, 2.53079971e-03f, -5.69174364e-02f,
  8.93124416e-02f, 2.21452434e-02f, -1.08526446e-01f, 5.04105575e-02f, -2.46139895e-02f, 7.13861408e-03f, -5.08529507e-02f, -2.32097916e-02f, 4.45276648e-02f, -2.07151268e-02f,
  -9.72622633e-03f, 2.86516920e-02f, -7.94649776e-03f, 5.48226647e-02f, -5.64316921e-02f, -4.22661528e-02f, 7.91764911e-03f, 1.06900632e-01f, 3.85085829e-02f, 3.31777409e-02f,
  8.21926296e-02f, 1.07187184e-03f, -3.75814550e-02f, 5.15369847e-02f, -4.71326858e-02f, 4.96825278e-02f, -1.73525792e-02f, -3.35895829e-02f, 1.23846799e-03f, 4.43519540e-02f,
  2.47026011e-01f, -3.29469949e-01f, -7.98404440e-02f, 1.54238090e-01f, 3.45623732e-01f, -1.80071983e-02f, 2.22127631e-01f, 1.05202727e-01f, 4.16989088e-01f, -3.22187722e-01f,
  -5.31449392e-02f, -2.08846986e-01f, 5.24072200e-02f, -9.51627269e-02f, 3.08856536e-02f, 3.01130787e-02f, 1.68167979e-01f, 6.71938062e-02f, 1.67159855e-01f, 5.10636680e-02f,
  4.97394204e-02f, -1.22274822e-02f, -1.12072028e-01f, -8.62683356e-02f, 2.09274851e-02f, 4.24387865e-02f, -1.73797496e-02f, -2.36425512e-02f, -1.78662390e-01f, 2.53296439e-02f,
  -1.08697891e-01f, 9.75846723e-02f, -2.00999323e-02f, -9.25094485e-02f, -5.24899252e-02f, -7.85168633e-02f, -2.28217971e-02f, -9.72771570e-02f, 2.10277475e-02f, -3.57459970e-02f,
  -2.18484402e-02f, -2.29129791e-02f, -1.77215710e-02f, 4.76091914e-02f, 5.65720499e-02f, -3.41014229e-02f, 2.24250313e-02f, -8.38625655e-02f, 1.65800396e-02f, -3.13432179e-02f,
  -7.03411847e-02f, -2.65441705e-02f, -4.21402976e-02f, -4.58318442e-02f, -1.24978255e-02f, 7.47055709e-02f, -1.33201145e-02f, -2.10329965e-02f, -1.33404694e-02f, -1.91084482e-02f,
  -6.65951446e-02f, 2.83889715e-02f, -4.43451144e-02f, 3.23714800e-02f, -2.67150276e-03f, 5.54361120e-02f, 1.46193672e-02f, 6.72148308e-03f, 4.32273671e-02f, -2.14549657e-02f,
  7.79384598e-02f, 2.87010260e-02f, -9.77453589e-03f, -2.10406780e-02f, 1.74212586e-02f, -1.75680183e-02f, 1.51262747e-03f, -8.85666348e-03f, 1.93214435e-02f, -4.53133360e-02f,
  5.28684072e-03f, 6.04440458e-02f, -4.23900969e-02f, -2.06579398e-02f, 2.65847314e-02f, 3.89335938e-02f, -3.30190100e-02f, -3.46449614e-02f, 1.85111295e-02f, 7.89339095e-03f,
  -1.20936716e-02f, -1.57833812e-04f, -1.06130494e-02f, -4.62770723e-02f, 1.86200906e-02f, -8.28855764e-03f, 4.67072017e-02f, -4.14849333e-02f, -2.97772381e-02f, -7.80969858e-03f,
  -4.61710282e-02f, 1.61420275e-02f, -8.04783851e-02f, 3.98484478e-03f, -8.62638578e-02f, -3.79587226e-02f, -1.02055436e-02f, 1.05616480e-01f, -1.49774412e-02f, -4.02383227e-03f,
  1.87306404e-02f, -7.80319422e-02f, 9.49185528e-03f, -2.22238563e-02f, 3.44719924e-02f, -7.36107156e-02f, -1.45261278e-02f, 6.13005422e-02f, -2.44893525e-02f, -2.35675815e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.41973296e-01f, -1.56049784e-02f, -1.52974948e-01f, -2.51054168e-01f, -1.63468719e-02f, -5.80556653e-02f, 1.39412031e-01f, 2.34356131e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.17995568e-01f, 3.91683429e-01f, 2.34085813e-01f, -2.84128278e-01f, -7.86996961e-01f, -1.78413540e-01f, -6.29709065e-02f, -1.75145388e-01f, -7.65647143e-02f, -1.51937410e-01f,
  8.81018937e-02f, 2.23319337e-01f, 2.83994585e-01f, -9.26725268e-02f, -2.76879311e-01f, 4.17613178e-01f, -8.74062479e-02f, -2.05678776e-01f, -7.10181296e-02f, 3.17842811e-01f,
  1.07847191e-01f, -6.47834018e-02f, 1.30560532e-01f, -1.83702692e-01f, 4.00886908e-02f, -1.12679824e-01f, -2.97113240e-01f, 1.21261619e-01f, -1.20533660e-01f, -2.34661683e-01f,
  2.00257421e-01f, -2.09356293e-01f, -2.67004877e-01f, 7.56675005e-02f, 5.91548145e-01f, 1.89679444e-01f, -5.89308977e-01f, -6.42790973e-01f, 1.50500789e-01f, -4.90024239e-01f,
  -1.76382363e-01f, -4.88373101e-01f, -2.39372119e-01f, 4.43537720e-02f, -4.71330211e-02f, 2.41136298e-01f, -1.57836869e-01f, -8.07467625e-02f, 2.08236706e-02f, -1.12737395e-01f,
  7.34618381e-02f, -1.86728224e-01f, 9.67370346e-03f, -1.24309801e-01f, 2.29149997e-01f, -1.17228664e-02f, -3.70654091e-02f, 7.26869777e-02f, -4.00350899e-01f, 2.43715137e-01f,
  1.72406677e-02f, -1.74673438e-01f, -1.60903707e-01f, 2.44289115e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.39427751e-01f, 2.18755648e-01f, 3.40142548e-01f, 4.96908158e-01f, -2.00261161e-01f, 2.62273163e-01f, 6.65497333e-02f, 1.00209653e-01f, -2.03714713e-01f, 1.35687038e-01f,
  4.30592328e-01f, 5.23288429e-01f, -1.06169984e-01f, 3.51873726e-01f, -3.73855501e-01f, 3.64975393e-01f, -1.44954279e-01f, 8.25386643e-02f, -1.05115995e-01f, 6.82342574e-02f,
  -2.94504374e-01f, 1.24389902e-01f, -5.79602048e-02f, 1.95207536e-01f, 1.91256955e-01f, -9.72893834e-02f, -1.51052982e-01f, -2.66513899e-02f, -5.10064960e-02f, -2.03650698e-01f,
  2.58139074e-01f, 2.27836907e-01f, 2.29224954e-02f, 1.09246902e-01f, -1.74377903e-01f, 3.35319042e-01f, 9.03271735e-02f, 3.53071570e-01f, 2.95005757e-02f, 1.71480298e-01f,
  3.69657993e-01f, 2.04037517e-01f, 6.91359639e-01f, 4.31603312e-01f, -1.51303103e-02f, -2.28279397e-01f, 2.73573041e-01f, -2.15720639e-01f, 4.27518576e-01f, -1.16234394e-02f,
  9.61611327e-03f, -9.88575518e-02f, 1.16543040e-01f, 2.00529739e-01f, -4.92591500e-01f, 5.03442436e-03f, -2.26725321e-02f, 4.99303788e-02f, 1.85106620e-01f, -1.75969720e-01f,
  9.87965465e-02f, 8.79568234e-02f, 4.11526471e-01f, 2.06121519e-01f, 5.42769372e-01f, 3.14537883e-01f, 2.06629246e-01f, 4.38325256e-01f, -1.58789977e-01f, 1.84813946e-01f,
  -2.00086102e-01f, 2.30364963e-01f, -2.71852076e-01f, -2.12944448e-01f, 6.80235505e-01f, 7.91921020e-01f, -2.26068962e-02f, 5.83587289e-01f, -2.25254059e-01f, -3.36683318e-02f,
  -3.48610491e-01f, -7.96159133e-02f, -6.62664175e-02f, 7.18823597e-02f, -2.51252323e-01f, -3.62893373e-01f, 5.14830709e-01f, -2.35520914e-01f, 8.23014736e-01f, -2.32740119e-03f,
  -1.51990682e-01f, -1.13660462e-01f, 2.50425965e-01f, -2.02065751e-01f, 2.14082345e-01f, -1.98837981e-01f, 1.81126013e-01f, 4.65217382e-01f, 1.87897280e-01f, 5.77892140e-02f,
  -3.01608175e-01f, -1.40514839e-02f, 5.39297581e-01f, -7.15866461e-02f, 6.48699522e-01f, -2.40752492e-02f, -1.99973434e-01f, -1.99033737e-01f, -8.83518308e-02f, -4.46341991e-01f,
  -3.05067319e-02f, 6.37560427e-01f, 4.45882566e-02f, -1.36349857e-01f, -1.94934994e-01f, 9.09742564e-02f, -4.34376560e-02f, -9.19841528e-02f, 1.76034197e-01f, 1.85273811e-01f,
  2.21204370e-01f, 8.96141753e-02f, -5.20249493e-02f, 4.49446365e-02f, -5.45447916e-02f, -2.00396419e-01f, 1.61687255e-01f, 1.16974115e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.86172873e-01f, 1.31357968e-01f, -1.94375917e-01f, 2.71847516e-01f, -1.79690309e-02f, 3.84547859e-01f, 4.65520829e-01f, -2.37345994e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.46184325e-01f, 1.03103511e-01f, 2.25044712e-01f, -6.90810606e-02f, -4.97883260e-02f, -3.87203097e-02f, -1.02790073e-01f, -4.64784533e-01f, -1.01457439e-01f, -2.22637922e-01f,
  -9.89510566e-02f, 1.94863796e-01f, 2.90250540e-01f, -5.10312140e-01f, -3.35486710e-01f, -4.44958396e-02f, 2.82918423e-01f, -7.58881047e-02f, 1.94098309e-01f, -1.77761257e-01f,
  -3.75310034e-01f, -1.59499809e-01f, -2.69030422e-01f, -2.79815465e-01f, -2.86429226e-01f, -1.05598100e-01f, 1.58880606e-01f, -3.07040960e-02f, -5.10174155e-01f, 4.62023467e-01f,
  2.42220551e-01f, 9.25207883e-02f, -2.42974296e-01f, 3.28355916e-02f, 2.40886495e-01f, 4.08611089e-01f, 4.42147940e-01f, -1.14265271e-01f, 5.13893843e-01f, 2.14655120e-02f,
  4.09214497e-02f, 2.52369549e-02f, -2.24282786e-01f, 2.47764662e-01f, -2.76634574e-01f, -1.93448350e-01f, 1.55128643e-01f, -6.02753200e-02f, 3.26627463e-01f, -7.79278437e-03f,
  -2.86265552e-01f, -2.89679924e-03f, -2.46645167e-01f, -3.81082632e-02f, -3.34252566e-01f, -1.94498911e-01f, 2.64349729e-01f, -1.85319841e-01f, 2.59838343e-01f, -1.52102932e-02f,
  2.84390122e-01f, -1.70785606e-01f, 4.82586119e-03f, -8.37995037e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.30606347e-01f, -2.65277252e-02f, -4.21107374e-02f, -4.08164077e-02f, 1.72223389e-01f, 2.09658325e-01f, -6.57228986e-03f, 7.73656368e-02f, -1.36076927e-01f, 5.62975369e-02f,
  2.75927901e-01f, -1.32105336e-01f, 3.20453286e-01f, 1.18988037e-01f, 7.84960538e-02f, 2.03916207e-01f, 7.76225090e-01f, 3.23921025e-01f, 3.52204263e-01f, 1.25486359e-01f,
  -3.07166487e-01f, -9.60512087e-02f, -6.86283648e-01f, -4.35416758e-01f, 5.01688600e-01f, 6.99339435e-02f, 5.99684834e-01f, 4.65614259e-01f, 8.29582274e-01f, -2.01918289e-01f,
  -1.20953538e-01f, -1.62326112e-01f, -3.49688567e-02f, 4.30464119e-01f, 6.24136217e-02f, 6.51824415e-01f, 9.62647125e-02f, 1.24347098e-01f, -9.08074826e-02f, 3.02781463e-01f,
  -4.39800248e-02f, 1.02459468e-01f, -1.06482975e-01f, -1.58380494e-01f, -2.63060004e-01f, 6.30372047e-01f, 1.03585005e+00f, -1.43503100e-02f, -1.83780670e-01f, 1.25431251e-02f,
  -2.19447643e-01f, 1.35144696e-01f, 4.82162535e-01f, -3.52432370e-01f, 4.27506089e-01f, -1.42038977e-02f, 6.08970761e-01f, -5.13886027e-02f, 4.66467857e-01f, -8.87153521e-02f,
  8.64760995e-01f, -2.12673426e-01f, -1.10900573e-01f, -2.50029027e-01f, -1.52975395e-01f, -9.43589807e-02f, 2.72181747e-03f, -1.25201419e-01f, -2.74438858e-01f, 3.03700026e-02f,
  3.36832330e-02f, -1.32609308e-01f, -2.01000959e-01f, 9.35756266e-02f, 2.96585374e-02f, 1.10976495e-01f, -1.98618129e-01f, 3.24955374e-01f, 3.60987961e-01f, -2.29996089e-02f,
  -3.57227445e-01f, -7.14418069e-02f, -4.30137627e-02f, -4.55631837e-02f, 3.97652000e-01f, 1.66620910e-02f, 8.54651034e-02f, 1.38493374e-01f, 1.90474868e-01f, -7.59872943e-02f,
  -1.40633717e-01f, -6.78489283e-02f, 2.38770336e-01f, -1.03273377e-01f, 3.49093020e-01f, 2.00961009e-01f, -3.00016642e-01f, 3.75082314e-01f, 4.61118668e-01f, 1.19309597e-01f,
  6.63381219e-01f, -4.00745690e-01f, 3.75500649e-01f, 2.42443770e-01f, 2.86668837e-01f, 2.49037236e-01f, -4.72636849e-01f, 3.40128928e-01f, 1.56605020e-01f, -1.94858953e-01f,
  4.50339913e-01f, -2.74917513e-01f, 3.22720855e-02f, 2.22540900e-01f, 6.05820537e-01f, 2.95973092e-01f, 3.72537076e-01f, 1.50038943e-01f, 6.62162483e-01f, -8.51883367e-02f,
  4.81024384e-01f, -2.28240967e-01f, -3.34717840e-01f, -3.43665779e-01f, 5.44080913e-01f, 7.62300491e-02f, 1.15158446e-01f, -9.37434286e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.16389278e-02f, 2.90476710e-01f, 5.41106820e-01f, 1.12066068e-01f, -1.06907330e-01f, 2.04679295e-01f, 5.94266839e-02f, 4.46911156e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.27429575e-01f, -3.16290371e-03f, 2.11653680e-01f, -6.60662800e-02f, -5.43311052e-02f, 2.82286495e-01f, -4.43909973e-01f, 5.22140741e-01f, -2.23325789e-01f, 4.05740589e-01f,
  5.15694059e-02f, -5.23935296e-02f, 1.63318276e-01f, -3.50797772e-02f, -3.91735077e-01f, -6.37532532e-01f, -4.03439254e-01f, 5.01437187e-01f, -1.97307896e-02f, 2.93437004e-01f,
  -4.80960198e-02f, 3.51532012e-01f, 1.47709161e-01f, -1.16517141e-01f, 9.29450914e-02f, -1.91984639e-01f, 1.86057299e-01f, -2.50556022e-01f, 3.54814120e-02f, -1.51317701e-01f,
  -1.98733993e-02f, 3.08524251e-01f, 2.72900146e-02f, 3.68957281e-01f, -2.04083964e-01f, 9.89554897e-02f, -1.13162629e-01f, -3.98242742e-01f, 5.92328012e-01f, -2.34936729e-01f,
  -2.86744446e-01f, -3.97266597e-01f, 5.23810424e-02f, 8.93117189e-02f, 7.73439929e-02f, 1.67177171e-01f, 4.67164189e-01f, 3.51833820e-01f, -1.53360097e-02f, 2.11821184e-01f,
  -5.07809818e-01f, -9.60724503e-02f, -1.19396992e-01f, -5.03513932e-01f, 2.57584304e-01f, -4.47444588e-01f, 4.33370434e-02f, -5.07093608e-01f, 1.60107613e-02f, 2.99226671e-01f,
  -1.18216269e-01f, 2.91163504e-01f, 3.71941835e-01f, 5.23183525e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.86378235e-01f, 1.00877985e-01f, -4.10047859e-01f, -3.17146331e-01f, -5.04916728e-01f, -3.18747431e-01f, 9.80041027e-02f, -2.54337281e-01f, 1.15889899e-01f, -2.59849101e-01f,
  5.96062958e-01f, 4.12739605e-01f, -6.73300698e-02f, 4.72848922e-01f, 7.58671045e-01f, 2.91185230e-01f, 9.75394174e-02f, 2.37942070e-01f, 5.99741563e-02f, 1.75387353e-01f,
  -4.50335354e-01f, 2.38864422e-01f, 3.28211665e-01f, -2.17442349e-01f, 1.08175151e-01f, -1.26154095e-01f, 8.86023104e-01f, -2.05574065e-01f, 5.77456057e-02f, 5.18750399e-02f,
  5.08983135e-01f, 2.83168375e-01f, -1.86387315e-01f, -3.44711959e-01f, -3.91518086e-01f, -6.62991941e-01f, 2.32298523e-01f, -1.00314863e-01f, -3.96782488e-01f, -7.59742409e-02f,
  5.11705466e-02f, 5.44062436e-01f, -4.06803787e-01f, 7.38711953e-01f, -1.14599451e-01f, 2.23313957e-01f, -2.24328771e-01f, 1.30610719e-01f, -1.09841682e-01f, -1.39541551e-01f,
  -1.18668661e-01f, -1.30162895e-01f, 2.33130068e-01f, -1.31503679e-02f, -3.06584626e-01f, 1.59300506e-01f, -5.39301299e-02f, 4.80689049e-01f, -4.17663395e-01f, 2.97006875e-01f,
  -2.41572469e-01f, -2.11972892e-01f, -1.31346919e-02f, -1.48109779e-01f, 5.58969021e-01f, 5.54545224e-01f, 2.16982320e-01f, 2.35076070e-01f, 8.04871500e-01f, -7.41066635e-01f,
  2.20545247e-01f, 4.15986151e-01f, -1.30152762e-01f, 8.54273677e-01f, -5.61870515e-01f, 5.91490686e-01f, -2.63424814e-01f, -1.83273271e-01f, 3.79007578e-01f, 6.25811875e-01f,
  1.57785729e-01f, 9.52349603e-01f, 6.63662076e-01f, 5.01111269e-01f, 6.97906137e-01f, -1.19410850e-01f, -3.17825556e-01f, 6.68750882e-01f, -6.57596365e-02f, 1.00897264e+00f,
  2.62340128e-01f, -4.69239652e-01f, -3.19011539e-01f, -3.49889934e-01f, -1.49109021e-01f, -4.37725663e-01f, -1.64588802e-02f, -1.56852826e-01f, -3.09995741e-01f, -4.29918796e-01f,
  -5.55322086e-03f, -2.32808843e-01f, 4.16778624e-02f, -2.72698730e-01f, 3.26571256e-01f, 4.34640706e-01f, -3.20421487e-01f, 6.55427277e-01f, 1.83631495e-01f, -9.83934477e-02f,
  -2.68687069e-01f, 1.17653161e-01f, 7.74406016e-01f, -3.99084479e-01f, 4.82058853e-01f, 2.40139812e-01f, -4.05283898e-01f, 5.11178374e-01f, -4.05399725e-02f, -3.10029954e-01f,
  4.03912243e-04f, 1.81958914e-01f, 7.59143889e-01f, 6.71468452e-02f, 2.93328583e-01f, -2.67822981e-01f, -4.21655446e-01f, 3.69861335e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  9.34095979e-02f, 1.43569380e-01f, 1.59476623e-02f, -2.17621267e-01f, 4.76246804e-01f, 4.21157390e-01f, 1.02089462e-05f, 2.55206168e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  1.10154581e+00f, 2.51113802e-01f, 1.07457972e+00f, 7.47579575e-01f, 3.70354146e-01f, 3.72015417e-01f, -3.21190804e-01f, -6.60129607e-01f, -6.06117666e-01f, -2.74338633e-01f,
  -5.23701191e-01f, -2.04923198e-01f, 6.15311742e-01f, 7.23288476e-01f, -3.08255136e-01f, -2.23605320e-01f, 2.84623384e-01f, 2.27030039e-01f, 1.47268623e-01f, 5.78804135e-01f,
  -1.16664886e+00f, 2.60141820e-01f, 1.09043753e+00f, 1.11606967e+00f, -3.14554840e-01f, 2.92278856e-01f, -1.79639727e-01f, -2.90425807e-01f, 2.55071729e-01f, 2.06472397e-01f,
  -6.44930899e-02f, 3.71191740e-01f, 4.34420593e-02f, 4.56422746e-01f, 6.28875911e-01f, 1.43483266e-01f, 1.23317003e+00f, 2.76798233e-02f, -6.73153102e-01f, -1.03945470e+00f,
  -2.23858342e-01f, 2.74859935e-01f, -1.07283644e-01f, -3.30366820e-01f, -6.37437046e-01f, 5.65459192e-01f, -3.64165664e-01f, 5.43313861e-01f, -7.80714571e-01f, -4.95923907e-01f,
  -8.11202347e-01f, -4.07081038e-01f, 2.09123790e-01f, -4.63326365e-01f, -1.97066307e-01f, -5.95995307e-01f, -2.91025311e-01f, -3.01454097e-01f, 7.18678474e-01f, 6.32123649e-01f,
  6.02466054e-02f, 3.69766921e-01f, 2.10053310e-01f, -5.52373827e-01f, 6.76992774e-01f, 1.76024511e-01f, 8.33973944e-01f, 8.09976578e-01f, 9.65208933e-02f, -5.07674277e-01f,
  -2.27824703e-01f, 2.62451954e-02f, -1.49779260e-01f, -3.15283000e-01f, 2.70096183e-01f, 1.82818949e-01f, 8.56889486e-01f, 3.19590978e-02f, 4.91299890e-02f, -7.57406592e-01f,
  -5.87981462e-01f, 5.23183227e-01f, -6.44699931e-01f, -9.08581197e-01f, -4.63190407e-01f, -1.67227790e-01f, 1.95942521e-01f, 6.23626225e-02f, 3.71074975e-01f, 2.47915566e-01f,
  -4.83603984e-01f, 3.50660062e-03f, 4.44084138e-01f, -4.18712378e-01f, -2.19649851e-01f, 1.33805536e-02f, -4.36371326e-01f, -3.32437187e-01f, -3.25005144e-01f, -4.96958971e-01f,
  -1.74316317e-01f, 2.72571832e-01f, -7.14332461e-02f, -3.42758656e-01f, 1.08907461e+00f, 4.84009624e-01f, -2.22034425e-01f, -2.85040867e-02f, -8.01865101e-01f, -4.20173883e-01f,
  -1.58833154e-02f, -5.98569870e-01f, -3.40945572e-01f, -7.04141080e-01f, -5.49683213e-01f, 3.97218525e-01f, 1.57537311e-01f, 5.04446216e-02f, -4.90418881e-01f, 2.00935990e-01f,
  -1.21142641e-01f, -3.67114097e-01f, 7.77495682e-01f, 3.46815854e-01f, 8.65951255e-02f, -5.85234046e-01f, 7.46482253e-01f, 1.79296672e-01f, 1.16127372e+00f, -1.21956386e-01f,
  9.87008691e-01f, 1.20682180e+00f, -2.50412822e-01f, 5.04312098e-01f, 5.28115928e-01f, -1.33199826e-01f, -3.77597101e-02f, 3.92112166e-01f, -1.30854830e-01f, -2.40165386e-02f,
  -8.39802265e-01f, -5.48579156e-01f, -3.11348587e-01f, 8.15258324e-01f, -4.09181893e-01f, -7.76201412e-02f, -2.57504731e-01f, -7.46252775e-01f, -3.84914905e-01f, -5.24083257e-01f,
  6.28251910e-01f, 3.66704464e-01f, 2.01923609e-01f, -4.09448713e-01f, 5.06313503e-01f, -5.08991107e-02f, 5.80183446e-01f, -8.94635856e-01f, 2.20034868e-01f, 1.84668660e-01f,
  -4.58274812e-01f, -1.38109783e-02f, -2.14856014e-01f, -5.23433924e-01f, 8.25456262e-01f, -4.70154762e-01f, -1.18741143e+00f, -1.03750765e-01f, -1.75078079e-01f, -4.60308224e-01f,
  -2.49032199e-01f, -1.48636699e-02f, 1.97831124e-01f, 1.12906027e+00f, -5.16030312e-01f, -3.04089338e-01f, -1.80341154e-01f, -2.56931216e-01f, -7.31925726e-01f, -3.56323361e-01f,
  -9.98559833e-01f, 3.52748275e-01f, 9.40207422e-01f, 1.21110952e+00f, 4.39241022e-01f, 5.40543139e-01f, -1.67972207e-01f, 8.07196721e-02f, -8.77510190e-01f, -6.86703146e-01f,
  -1.12338461e-01f, 3.13206226e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.39582202e-01f, 6.12641931e-01f, -4.26844731e-02f, -3.65136862e-01f, -2.63896137e-01f, 2.11271524e-01f, -2.47437462e-01f, -4.53440547e-01f, 2.98750047e-02f, 1.84890261e-04f,
  -1.40382096e-01f, -1.95824057e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    