/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.81729484e-01f, 1.74138427e-01f, -1.16464673e-02f, 3.67420584e-01f, -7.44084716e-02f, -7.06197321e-02f, 1.38110429e-01f, 6.27070963e-02f, 1.53430998e-01f, 2.08511367e-01f,
  -2.28835925e-01f, -2.89249361e-01f, 3.96120660e-02f, -1.94302484e-01f, -9.97984335e-02f, 3.01480442e-01f, 4.22213137e-01f, 9.27318484e-02f, -1.96954474e-01f, -4.10305589e-01f,
  -1.43192217e-01f, 1.73277661e-01f, -3.54895778e-02f, -2.60551032e-02f, 1.97435528e-01f, 2.19191983e-01f, 3.28584045e-01f, 1.38710886e-01f, -3.39209467e-01f, 6.12376630e-01f,
  -2.28811186e-02f, 2.99316403e-02f, -1.09468080e-01f, 1.06619215e-02f, -1.03932723e-01f, 1.07372090e-01f, -4.64304499e-02f, 1.15976222e-01f, -8.00741240e-02f, -1.05225397e-02f,
  -4.33606543e-02f, -1.91217110e-01f, 5.94938099e-02f, -1.49618927e-02f, 5.12766913e-02f, -2.40915595e-03f, 8.75922218e-02f, 1.93901062e-02f, 1.31148010e-01f, -1.26956701e-01f,
  -1.00496687e-01f, -9.10071060e-02f, -6.39685197e-03f, 3.97161674e-03f, 1.85984336e-02f, -7.46994419e-03f, -5.13955206e-02f, 3.25104222e-02f, -1.12330131e-02f, 3.29140782e-01f,
  1.04871551e-02f, -2.39390135e-02f, -2.68433634e-02f, -4.94921580e-02f, 3.42524946e-02f, 7.33078178e-03f, 7.78089687e-02f, -5.25436625e-02f, -1.52554018e-02f, -2.94465981e-02f,
  4.40357700e-02f, -2.29898319e-02f, -2.76686102e-02f, 3.80571224e-02f, 1.35971641e-03f, 3.38162631e-02f, -1.20284772e-02f, 5.57991937e-02f, -2.65798178e-02f, -2.18510759e-04f,
  -1.21455491e-02f, 3.66286263e-02f, 6.41391799e-02f, -8.75214264e-02f, 6.82249665e-02f, -2.49615312e-02f, -2.51982957e-02f, -5.25727160e-02f, -5.49382009e-02f, -7.84049481e-02f,
  1.91071257e-01f, -6.74858391e-02f, 1.36931077e-01f, 3.82409319e-02f, -3.34920525e-03f, -1.44572183e-02f, 1.01603709e-01f, -7.36754313e-02f, -3.57866883e-02f, 2.43880637e-02f,
  -2.35440228e-02f, 2.72524636e-02f, 4.53457758e-02f, -3.35589685e-02f, -8.60274583e-02f, 2.13019419e-02f, -1.08837381e-01f, 5.35892062e-02f, -3.12333344e-03f, 6.12783013e-03f,
  1.17144868e-01f, 4.19242308e-02f, 5.84448166e-02f, 1.32981941e-01f, 6.74643666e-02f, 9.86802503e-02f, 9.96151119e-02f, 1.92476716e-02f, 1.39228432e-02f, 2.70455092e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.48171166e-01f, 1.13784492e-01f, -6.85603991e-02f, -3.06941215e-02f, -1.92616768e-02f, -5.87268807e-02f, -4.01236042e-02f, -5.57308900e-04f, 1.04164414e-01f, 7.73056448e-02f,
  6.18997961e-02f, -2.83318870e-02f, 7.14164004e-02f, 9.70681459e-02f, -9.86021608e-02f, -2.77320767e-04f, -2.34834105e-02f, -3.92135754e-02f, -1.23017445e-01f, 2.13487130e-02f,
  -4.22545373e-02f, 1.11120529e-02f, -5.71166798e-02f, 7.78038725e-02f, 6.99606165e-02f, 1.62337124e-01f, 5.72969504e-02f, -3.98323424e-02f, 8.07712227e-02f, 3.91909368e-02f,
  -6.54574335e-02f, -2.09250953e-02f, -3.19432393e-02f, 1.23947076e-01f, 8.06247592e-02f, 7.46261105e-02f, -4.75722924e-03f, -3.19813378e-02f, 7.73471445e-02f, -2.04900908e-03f,
  6.45264238e-02f, 3.97358425e-02f, -5.67594878e-02f, 7.32295541e-03f, -8.30470119e-04f, -6.55561360e-03f, -1.75547078e-02f, 5.61060570e-02f, 1.41085342e-01f, 1.22331679e-01f,
  9.37389731e-02f, 1.36529863e-01f, 6.93749413e-02f, 1.72484830e-01f, 8.96455497e-02f, 6.23215623e-02f, 8.09295252e-02f, 5.44208437e-02f, 1.84820175e-01f, 1.23326957e-01f,
  6.46496518e-03f, -9.80640724e-02f, -5.45410961e-02f, -6.05450645e-02f, -2.27676798e-02f, -8.33588317e-02f, -4.39222977e-02f, -6.37703165e-02f, -3.39942165e-02f, -6.63625747e-02f,
  2.60136444e-02f, 3.53273302e-02f, -5.49596995e-02f, -7.04227537e-02f, 5.73624261e-02f, 1.93126537e-02f, -7.07269758e-02f, 5.92255369e-02f, -3.16202231e-02f, 2.92378087e-02f,
  -1.59531813e-02f, 1.40092205e-02f, 9.24471207e-03f, -2.80016437e-02f, 7.15233386e-02f, 8.15810114e-02f, -4.62707840e-02f, 3.32399905e-02f, 8.77167378e-03f, -9.15199239e-03f,
  9.58148837e-02f, -5.96660823e-02f, 5.12147043e-03f, 4.49755043e-02f, 3.14732343e-02f, 1.02008134e-01f, -5.16900094e-03f, 3.41990478e-02f, 3.08984742e-02f, 7.99909160e-02f,
  8.39391649e-02f, -6.64978176e-02f, -8.46426003e-03f, 1.78412662e-03f, -1.04210265e-01f, 1.20117087e-02f, 3.66815291e-02f, 2.86333412e-02f, 8.28051567e-02f, 1.85881391e-01f,
  9.56857651e-02f, 5.90450056e-02f, 2.81526260e-02f, 1.08776912e-01f, 1.35760337e-01f, 1.33269176e-01f, 4.80831154e-02f, 6.67613298e-02f, 5.15484922e-02f, 1.15199052e-01f,
  1.33636504e-01f, 1.15252905e-01f, -1.54377729e-01f, 2.37682804e-01f, -2.46978477e-01f, -5.03237784e-01f, -5.24060249e-01f, -1.56221583e-01f, -5.65445013e-02f, 1.18110605e-01f,
  -1.01199977e-01f, -6.70243055e-02f, -6.03560656e-02f, 6.18679682e-03f, -1.62338346e-01f, -8.68055969e-02f, 1.50213003e-01f, 2.06919760e-02f, -2.29622141e-01f, -1.48264781e-01f,
  1.49788290e-01f, 1.92762628e-01f, -3.28461006e-02f, 8.59206170e-03f, 3.72067481e-01f, 3.51786730e-03f, 1.78559199e-02f, 1.40731171e-01f, -2.72093471e-02f, 7.22316980e-01f,
  1.46636680e-01f, 2.07285523e-01f, -1.53764755e-01f, 9.76510346e-03f, 1.18032083e-01f, 1.08376406e-01f, 4.49597312e-04f, 1.38257027e-01f, -5.65194860e-02f, 5.64267002e-02f,
  3.99892814e-02f, 9.77838188e-02f, 8.70692208e-02f, 5.18199103e-03f, -3.65951024e-02f, -8.30123574e-02f, 6.40453100e-02f, 1.26524806e-01f, -3.44074368e-02f, 1.56653747e-02f,
  2.00523391e-01f, 2.24113390e-02f, -2.14136317e-01f, -1.37589335e-01f, -1.49985880e-03f, -6.84012175e-02f, -1.65704340e-01f, 4.21171561e-02f, -1.95906356e-01f, 2.49832764e-01f,
  -1.77028794e-02f, 7.53335506e-02f, -1.51265028e-03f, 7.10835680e-02f, 1.68870613e-02f, -6.93142787e-02f, 3.86115238e-02f, -5.71157448e-02f, -9.34868082e-02f, 8.94710049e-02f,
  -6.80513531e-02f, -4.01923656e-02f, 4.03309613e-02f, -6.49458990e-02f, -5.88164516e-02f, 5.71872331e-02f, 5.03135473e-02f, -5.11723831e-02f, -7.09246984e-03f, 8.23002383e-02f,
  -1.97195075e-02f, -6.47098273e-02f, 7.82220140e-02f, 8.07153732e-02f, 1.28272370e-01f, -3.04980185e-02f, 2.49195360e-02f, 9.55171790e-03f, 2.47476101e-02f, -1.69547945e-02f,
  -4.03585890e-03f, -4.59661067e-01f, 8.61100256e-02f, 1.55124649e-01f, 5.36084287e-02f, 6.83588488e-03f, 4.76914160e-02f, 2.00406704e-02f, 1.89897008e-02f, -5.73084364e-03f,
  -9.25021246e-02f, -6.75794110e-02f, -5.26423508e-04f, -1.06103055e-01f, -6.05911762e-02f, -1.06983602e-01f, 2.19521113e-02f, -1.02880538e-01f, -4.85818274e-02f, 6.15155175e-02f,
  3.77588756e-02f, -2.35456884e-01f, -2.51150727e-01f, -1.15696900e-01f, -3.86130475e-02f, -2.53470659e-01f, -2.07688108e-01f, -1.17797211e-01f, -4.22816008e-01f, -2.31988743e-01f,
  1.92563534e-01f, -1.69503763e-01f, 3.43993157e-01f, -1.68474216e-03f, 9.96525884e-02f, 2.64896393e-01f, 1.63481057e-01f, 1.14951111e-01f, 1.03792064e-01f, 2.28790846e-02f,
  -1.14293352e-01f, -2.38521367e-01f, -1.83499441e-01f, -5.82422800e-02f, -9.48764756e-02f, 1.92102324e-02f, 1.49618044e-01f, 1.17120437e-01f, 7.45146796e-02f, 1.57826811e-01f,
  -3.26735787e-02f, 4.99471314e-02f, 1.32823095e-01f, 1.39017522e-01f, 3.58658880e-02f, 4.38879170e-02f, -1.60702113e-02f, 1.31684020e-01f, 7.50462785e-02f, -6.84020342e-04f,
  1.06025122e-01f, 3.75781208e-02f, 1.76883824e-02f, -5.05444854e-02f, 3.63933779e-02f, 7.57057220e-02f, -8.85247253e-03f, -5.84539548e-02f, -1.06244003e-02f, -9.39544942e-03f,
  -8.30742568e-02f, 6.67801872e-02f, -1.67577900e-02f, 4.06049155e-02f, 1.35171846e-01f, -5.32160588e-02f, 1.38436267e-02f, -6.82141408e-02f, 5.12206368e-02f, -9.35920924e-02f,
  -1.44174427e-01f, 1.51277492e-02f, 8.16292614e-02f, -1.11566469e-01f, 2.47567426e-02f, 6.37466684e-02f, 1.39288809e-02f, -4.75299284e-02f, 2.50693243e-02f, 1.74088180e-02f,
  -7.34076882e-03f, -4.58166003e-02f, -1.37332371e-02f, -8.62086490e-02f, -5.37226498e-02f, -2.63926778e-02f, 5.98981753e-02f, -4.08685580e-03f, -5.65898269e-02f, -9.71867004e-04f,
  -9.24789980e-02f, -1.23003200e-02f, 4.02005538e-02f, -7.60452375e-02f, 2.09173281e-02f, -2.72874255e-03f, -2.19001938e-02f, -5.71556948e-02f, -5.13728634e-02f, 2.95741707e-02f,
  3.19850519e-02f, 7.47802332e-02f, 5.64585626e-02f, -6.71700761e-02f, 8.59737676e-03f, 2.28952914e-02f, 2.10052971e-02f, -8.65445137e-02f, 1.72794089e-02f, 1.42820477e-02f,
  3.88939083e-02f, -3.43201198e-02f, 9.20957327e-02f, -1.04593366e-01f, 3.66339348e-02f, 1.11670699e-02f, 2.49008313e-02f, -3.92806018e-03f, 8.96667223e-03f, 1.28909171e-01f,
  -4.02041487e-02f, 4.66535147e-03f, -1.55360438e-02f, 1.45001579e-02f, 1.09975398e-01f, 5.53057864e-02f, -8.20065364e-02f, 2.22269092e-02f, 2.40539219e-02f, 4.72792760e-02f,
  -3.67326029e-02f, 6.88764220e-03f, 1.22101724e-01f, 9.76940617e-02f, 5.30694947e-02f, 1.40401460e-02f, 8.61335322e-02f, 5.01818210e-02f, 1.12750001e-01f, -5.22982283e-03f,
  4.43930149e-01f, 1.74172632e-02f, 3.80620539e-01f, -4.77311462e-02f, -2.08687242e-02f, -1.03357509e-01f, -9.87247452e-02f, -9.31393057e-02f, -1.67842850e-01f, -5.12163667e-03f,
  1.21673755e-01f, 1.89997852e-02f, -6.87011629e-02f, -1.23677298e-01f, 7.79811218e-02f, -6.70314059e-02f, 4.29499485e-02f, 1.92009121e-01f, -4.30640355e-02f, -2.16367796e-01f,
  -1.82997033e-01f, 1.48151547e-01f, 3.02878767e-01f, -2.00529306e-04f, -1.39777750e-01f, -4.00124751e-02f, 1.88363925e-01f, 1.21124715e-01f, -3.47422883e-02f, 7.46716112e-02f,
  1.53274000e-01f, 2.70907879e-01f, -1.59363210e-01f, 1.28829256e-01f, 1.97910339e-01f, -7.89262652e-02f, -8.15420821e-02f, 1.25678554e-01f, 5.48051558e-02f, -5.46988659e-02f,
  1.02143608e-01f, 6.35061339e-02f, 1.84526239e-02f, -2.08282806e-02f, -3.16663622e-03f, -1.22188002e-01f, 2.47742143e-03f, 6.71324432e-02f, -1.97566226e-02f, -5.08160144e-03f,
  -4.45298441e-02f, 1.05555296e-01f, 9.38153118e-02f, -1.40589669e-01f, 2.65947860e-02f, 1.33662820e-01f, 1.49794668e-01f, -5.14220186e-02f, -4.91201924e-03f, -1.13946825e-01f,
  -7.54833445e-02f, 9.53063369e-02f, -2.77881920e-02f, -2.66037732e-02f, -2.51838975e-02f, -5.90242632e-02f, 5.41928085e-03f, 5.17443940e-02f, -2.47387663e-02f, 2.95895431e-03f,
  -7.74491355e-02f, -8.03458765e-02f, -2.22364068e-02f, -3.45158353e-02f, 3.87026899e-04f, 8.13109241e-03f, 8.50782171e-03f, 2.86487564e-02f, 1.15171522e-01f, -8.16415064e-03f,
  4.11991030e-03f, 4.70672585e-02f, 7.68176913e-02f, -1.14208516e-02f, -3.53618488e-02f, 9.69964489e-02f, -8.83508027e-02f, -7.80844912e-02f, 1.06464978e-02f, 6.36772485e-03f,
  -2.98998982e-01f, 2.49013737e-01f, -1.68994844e-01f, 9.30821348e-04f, 6.86107501e-02f, 6.30764663e-02f, 1.21676521e-02f, 3.80554684e-02f, 7.59670809e-02f, 9.65621602e-03f,
  3.61489505e-02f, 1.72930136e-02f, 5.67059107e-02f, -4.41929922e-02f, -1.42338276e-01f, -3.38052176e-02f, -3.05774752e-02f, -2.52557024e-02f, -2.21584924e-02f, 2.44710408e-03f,
  -8.00498873e-02f, -1.83247656e-01f, -1.75258577e-01f, -1.26554400e-01f, -1.59671783e-01f, -4.30767052e-02f, -1.18789352e-01f, -1.19391076e-01f, -7.56340325e-02f, -3.94204557e-01f,
  -3.69373672e-02f, 2.37298876e-01f, -1.36366216e-02f, -3.21002789e-02f, -1.72895640e-01f, -2.67060667e-01f, -1.73773900e-01f, -1.03615619e-01f, -1.32151470e-01f, -3.00562512e-02f,
  -6.58986217e-04f, -2.60202345e-02f, 1.63116436e-02f, 7.51532352e-05f, -1.99815989e-01f, -1.65719301e-01f, -1.44673467e-01f, -1.50835201e-01f, -2.51374334e-01f, -4.57312971e-01f,
  -1.44093871e-01f, -6.49676695e-02f, 2.61093620e-02f, -1.57043919e-01f, -1.36924267e-01f, 4.75762039e-03f, -9.98476520e-03f, -6.52167797e-02f, -1.17286757e-01f, 8.23134184e-02f,
  -1.58543378e-01f, -1.38498455e-01f, -1.23096630e-01f, 6.63423864e-03f, 4.42458801e-02f, 3.85229178e-02f, 1.05162375e-02f, -1.07728140e-02f, 9.68072191e-02f, 1.24226324e-01f,
  -9.69902799e-03f, 3.73569466e-02f, -6.12516142e-02f, -7.83120021e-02f, -2.34179087e-02f, -1.28383815e-01f, 2.56324820e-02f, 1.06860027e-02f, -5.25821112e-02f, -7.48665854e-02f,
  -8.88782665e-02f, 1.57701354e-02f, -6.44064173e-02f, -7.98411444e-02f, -1.57516643e-01f, -1.04014985e-01f, -8.45467374e-02f, -9.44512412e-02f, -8.25932920e-02f, 3.67957354e-02f,
  -1.98682435e-02f, 2.61618700e-02f, -1.00919440e-01f, -6.88495263e-02f, -3.18404585e-02f, 9.37584415e-02f, -2.17345008e-03f, 8.03492889e-02f, 3.81248817e-02f, 8.25789198e-03f,
  1.88451353e-02f, 8.75536818e-03f, 8.49585384e-02f, -4.92865629e-02f, 1.40614938e-02f, -4.89326287e-03f, 2.03856509e-02f, -4.46734317e-02f, -2.60781515e-02f, 2.66065653e-02f,
  -7.35708624e-02f, 1.36380736e-02f, -1.21275056e-02f, -4.13825288e-02f, -9.35707837e-02f, -1.41031062e-02f, -2.45552342e-02f, 9.87993255e-02f, 4.92497534e-02f, 7.06337858e-03f,
  1.46028012e-01f, 1.21247461e-02f, 8.87510777e-02f, 1.23686483e-02f, 5.41122146e-02f, 6.31040707e-02f, 1.19599380e-01f, 8.97780433e-02f, 4.14403342e-03f, 3.43520455e-02f,
  -7.75269717e-02f, 4.26697880e-02f, 1.79263167e-02f, 2.60454584e-02f, -6.01072051e-02f, -8.00974369e-02f, 1.05488375e-01f, 9.62340906e-02f, -4.36076559e-02f, -3.24679837e-02f,
  -4.86361645e-02f, 9.48373824e-02f, 6.51893690e-02f, 7.88860172e-02f, 7.75607245e-04f, 4.22467291e-02f, 7.21640736e-02f, 6.66475073e-02f, -5.21550477e-02f, 3.45203221e-01f,
  6.21288121e-01f, 4.32770878e-01f, 2.48091325e-01f, 2.01724544e-01f, 2.73874581e-01f, 2.11940616e-01f, 3.96683812e-01f, 6.16192352e-03f, -1.02094725e-01f, 1.35385692e-01f,
  1.62084594e-01f, -3.21996436e-02f, -4.37722635e-03f, -6.73326552e-02f, 1.13722481e-01f, 1.03235148e-01f, 9.92166772e-02f, 7.85655081e-02f, 5.82125830e-03f, 1.09721974e-01f,
  1.11699946e-01f, 1.31422862e-01f, -6.09472767e-03f, -4.44990285e-02f, 1.95022330e-01f, -8.45928416e-02f, 2.47655641e-02f, 1.60049766e-01f, 1.85669765e-01f, 3.98445576e-01f,
  2.47162744e-01f, 3.97326052e-01f, -2.21175298e-01f, -6.32054061e-02f, -8.19809083e-03f, -1.47453919e-01f, -8.35588388e-03f, -7.82615691e-02f, -5.52194454e-02f, -9.99521911e-02f,
  1.22366652e-01f, -2.07615774e-02f, 1.25419095e-01f, 5.34162000e-02f, 5.72957173e-02f, 4.73567192e-03f, 8.03901907e-03f, -4.88732867e-02f, -6.07953593e-02f, -4.63608913e-02f,
  1.03698276e-01f, 6.87084422e-02f, 1.78107858e-01f, -1.08908556e-01f, -1.23537146e-02f, -5.35378046e-02f, 5.86940981e-02f, 9.48032141e-02f, -1.39496893e-01f, 1.22910462e-01f,
  -9.70100090e-02f, 4.32942137e-02f, 4.23369370e-02f, 5.89166880e-02f, -1.36739071e-02f, 4.46228161e-02f, -5.59515357e-02f, 3.46233770e-02f, 5.69199771e-02f, -1.45523045e-02f,
  -7.51141133e-03f, 5.91433831e-02f, -1.91498119e-02f, 1.73922547e-03f, -3.02105118e-02f, 1.69291273e-02f, -2.33440921e-02f, 4.02949238e-03f, 6.05336251e-03f, -9.69138816e-02f,
  -7.20241899e-03f, 1.37346266e-02f, 2.72344844e-03f, -1.22183980e-02f, -3.84541303e-02f, -2.64937989e-02f, 8.88976902e-02f, 5.46171442e-02f, -5.12846336e-02f, -5.65908998e-02f,
  -2.84170121e-01f, -2.82667667e-01f, 2.48728972e-02f, -9.02290344e-02f, -9.27853491e-03f, -1.69688508e-01f, 3.48964967e-02f, -1.25460699e-01f, 2.42364593e-02f, 1.69102252e-02f,
  4.03771587e-02f, 1.23576328e-01f, -3.79387871e-04f, -4.43907920e-03f, -1.00773998e-01f, -6.62066191e-02f, -1.76578835e-02f, -2.30873888e-03f, -1.31196037e-01f, -3.51308100e-02f,
  -3.41244303e-02f, -1.46473423e-01f, -1.69627875e-01f, -1.23756811e-01f, -5.61575666e-02f, -2.36333847e-01f, -1.75626203e-01f, -3.90901454e-02f, -1.89986646e-01f, -3.29404205e-01f,
  2.77163118e-01f, -2.75264561e-01f, -9.18996930e-02f, 1.64310023e-01f, 5.52929193e-03f, -1.36397734e-01f, -2.20762506e-01f, -6.41004220e-02f, 7.64375702e-02f, -4.19504158e-02f,
  -1.00061558e-01f, -1.10009044e-01f, -4.49106023e-02f, -2.83915456e-02f, -7.14895427e-02f, -1.02002285e-01f, -1.94875479e-01f, -1.16923220e-01f, -6.58217818e-02f, -5.64392284e-02f,
  -6.54183999e-02f, -4.36635278e-02f, 6.07136562e-02f, -8.01289231e-02f, -1.26708731e-01f, 1.69370528e-02f, -1.34963468e-01f, -1.80201024e-01f, -2.21224770e-01f, -1.19182535e-01f,
  2.00972352e-02f, -1.38171747e-01f, 9.88546982e-02f, -8.51197094e-02f, -1.39275501e-02f, -7.72352964e-02f, 5.63932769e-03f, 3.91082577e-02f, 3.98708656e-02f, -6.25912249e-02f,
  3.92466486e-02f, -8.32305998e-02f, -4.51701544e-02f, 5.66796102e-02f, 6.86776862e-02f, 1.84215903e-02f, -1.90334376e-02f, 3.79484780e-02f, -7.46159852e-02f, -1.08741961e-01f,
  -4.10260372e-02f, -9.72878486e-02f, 1.28371000e-01f, -4.18392336e-03f, 7.27549382e-03f, -9.77653079e-03f, -4.65317853e-02f, 2.63588186e-02f, -1.78618878e-02f, 1.85562953e-01f,
  5.13592996e-02f, -3.02649383e-02f, -2.86110165e-03f, 1.84591915e-02f, 4.06740531e-02f, -3.45586392e-04f, -1.89452199e-03f, 3.48718166e-02f, 5.99658266e-02f, -3.69951478e-03f,
  4.40610535e-02f, 4.04394269e-02f, -8.48272219e-02f, 2.05949172e-02f, -6.45281076e-02f, -3.24865021e-02f, -4.11283262e-02f, 6.47540092e-02f, 9.08939354e-03f, -3.95087153e-02f,
  -5.79562271e-03f, 3.04941349e-02f, -8.58548749e-03f, -6.49283975e-02f, -1.60079181e-01f, 3.18715125e-02f, -9.04647559e-02f, 5.17091192e-02f, 1.89518481e-02f, -1.70541913e-04f,
  2.16966853e-01f, -1.55647233e-01f, 6.72575608e-02f, 6.99738460e-03f, 5.92338517e-02f, -1.15980610e-01f, -4.51060385e-02f, -1.72615871e-02f, 3.29450145e-02f, 9.92532372e-02f,
  -9.34416503e-02f, 2.93605938e-03f, 1.90806924e-03f, 8.82112887e-03f, 3.50151844e-02f, 1.07852690e-01f, -2.23445222e-02f, 6.15109131e-02f, -1.46835908e-01f, -6.14619581e-03f,
  3.86263989e-02f, 1.30192190e-01f, 2.01922297e-01f, 1.35054156e-01f, 2.83299442e-02f, 1.24872468e-01f, 1.34981036e-01f, 4.38329875e-02f, 6.53093755e-02f, 3.96829635e-01f,
  -4.73058462e-01f, -2.77678166e-02f, -4.19965714e-01f, 1.03793003e-01f, 2.22748309e-01f, 8.79797563e-02f, 8.75180885e-02f, 1.41407892e-01f, 1.74096838e-01f, 1.33484647e-01f,
  7.59083331e-02f, 2.81653374e-01f, 1.10836342e-01f, 6.47753850e-02f, 6.95744082e-02f, 1.51623666e-01f, 1.76083520e-01f, -1.52444571e-01f, -1.33219972e-01f, 9.38006267e-02f,
  3.59612435e-01f, -1.67993233e-02f, -5.36524169e-02f, 1.16839238e-01f, 2.97085643e-01f, 2.69010454e-01f, 1.25032216e-01f, 3.68328877e-02f, 1.14444949e-01f, 2.52780855e-01f,
  -2.56766647e-01f, -2.01716363e-01f, -1.66489881e-05f, 1.03163615e-01f, -1.81480888e-02f, -4.02214266e-02f, 2.57710833e-03f, -7.39826113e-02f, 5.45559153e-02f, 4.33171866e-03f,
  1.53308576e-02f, 7.79852569e-02f, 9.38050970e-02f, 1.20844590e-02f, -4.19392958e-02f, -3.88784111e-02f, -8.24290514e-02f, -1.25165761e-01f, -6.06128909e-02f, 3.18372659e-02f,
  1.86068639e-01f, 7.84999430e-02f, -1.54252380e-01f, 1.50634730e-02f, -8.93144161e-02f, 3.37622240e-02f, -6.73209876e-02f, 1.48614785e-02f, -2.10694179e-01f, -8.11418239e-03f,
  6.93286806e-02f, -8.22015107e-02f, -9.98064056e-02f, 1.76545642e-02f, 1.16915524e-01f, 2.40948573e-02f, 6.21148571e-02f, 2.59764306e-02f, 9.88044813e-02f, -5.40807843e-02f,
  -6.31321147e-02f, -4.13124114e-02f, 1.06693814e-02f, 7.94943795e-02f, 1.57347322e-01f, 2.92122643e-02f, 9.17301141e-03f, -2.85854656e-02f, 1.04371265e-01f, -1.46345690e-01f,
  -4.93443348e-02f, 4.03196737e-02f, -1.55918365e-02f, 6.21510372e-02f, 6.13711122e-03f, -3.75901163e-02f, 4.94853854e-02f, -1.45509746e-02f, -6.14500368e-06f, 4.28998843e-02f,
  -1.24607645e-02f, -4.74528894e-02f, 1.24235749e-01f, -1.39206961e-01f, -1.75771639e-02f, -1.15322217e-01f, 6.20391183e-02f, -1.08396292e-01f, -2.19362061e-02f, -9.63172615e-02f,
  -3.52063738e-02f, -2.89790202e-02f, 1.62091255e-02f, -1.11476935e-01f, -1.27131343e-01f, -3.29901613e-02f, 9.25949402e-03f, -1.67714059e-03f, -2.72283703e-02f, -9.51939896e-02f,
  3.11807580e-02f, 3.01717203e-02f, -1.58646435e-01f, -1.88624874e-01f, 2.01876834e-02f, -5.70001677e-02f, -7.90166929e-02f, -9.27047208e-02f, -1.48850977e-01f, -1.14888951e-01f,
  5.77995539e-01f, -8.57074410e-02f, 1.39932767e-01f, -6.53334484e-02f, -4.28967699e-02f, 8.15515816e-02f, 2.11133249e-02f, 1.84535552e-02f, -9.57462750e-03f, -2.58169491e-02f,
  1.08400680e-01f, 1.78392082e-01f, 1.04067840e-01f, 1.27675161e-01f, 1.21863537e-01f, -4.64127809e-02f, -1.54312402e-01f, -8.34330218e-04f, 8.62412229e-02f, 1.17176715e-02f,
  -4.18536142e-02f, -1.72395125e-01f, 8.94593969e-02f, 2.07532677e-04f, -1.58356860e-01f, -4.90137376e-02f, -9.65145379e-02f, -4.68173027e-02f, 4.95529063e-02f, -2.64701813e-01f,
  1.80229500e-01f, 1.59634620e-01f, 1.73164323e-01f, 1.73575326e-03f, 1.13098370e-02f, 6.58009900e-03f, 2.17965357e-02f, -2.41395235e-02f, -3.47079262e-02f, -6.23028167e-02f,
  5.84518984e-02f, -1.12424910e-01f, 5.22488132e-02f, -3.34535986e-02f, -1.76444296e-02f, 7.93694854e-02f, 2.25086361e-02f, 1.61159411e-01f, 2.59812064e-02f, 9.11519006e-02f,
  -9.41418391e-03f, 7.60973543e-02f, 1.11115370e-02f, 6.56651035e-02f, 8.17110538e-02f, 7.54952952e-02f, -2.49660661e-04f, 1.64952967e-03f, 2.06087187e-01f, 3.46048027e-02f,
  -3.90629210e-02f, 8.40948448e-02f, -4.92871413e-03f, -1.32474765e-01f, 4.10636049e-03f, 5.56448251e-02f, 3.09352968e-02f, -1.42503139e-02f, -3.23201157e-02f, -4.34935167e-02f,
  -1.90664213e-02f, -1.90575572e-03f, 3.13351378e-02f, 3.15251313e-02f, 3.51591781e-02f, -3.49885635e-02f, 5.60168661e-02f, -8.77549276e-02f, 3.31670307e-02f, -2.17002397e-03f,
  2.39992049e-02f, 8.25298112e-03f, 1.97270699e-02f, -6.88460246e-02f, 4.33290899e-02f, 6.53996915e-02f, -4.28879187e-02f, 2.86894641e-03f, -5.08198738e-02f, 2.63634957e-02f,
  -2.29780570e-01f, 3.09624135e-01f, -1.54010653e-02f, 4.21036966e-03f, 1.16427885e-02f, 1.18252914e-02f, 7.63281882e-02f, -4.98475470e-02f, 1.48838051e-02f, -4.00909558e-02f,
  3.08391545e-02f, 1.24731353e-02f, -2.94500962e-02f, -2.62833834e-02f, -3.69703025e-02f, -3.01970402e-03f, -8.54953006e-02f, 3.70528661e-02f, 8.01611394e-02f, -8.21391121e-02f,
  -1.38112172e-01f, 6.23530746e-02f, 2.10268646e-02f, 1.40560642e-01f, 1.27540648e-01f, 9.56280380e-02f, -4.23595905e-02f, 3.13523132e-03f, 1.63720921e-01f, -1.61653861e-01f,
  9.49272513e-01f, -5.65986454e-01f, -5.22383571e-01f, -9.61644016e-03f, -2.11688623e-01f, -6.15384802e-02f, -2.69467562e-01f, -5.89747839e-02f, 1.84036791e-01f, -2.88711488e-01f,
  -2.29658335e-01f, 1.34742662e-01f, -3.08335777e-02f, 7.11401775e-02f, 7.19146058e-02f, -2.56696522e-01f, -1.77660540e-01f, 5.47244772e-02f, 3.94587100e-01f, 1.19405210e-01f,
  1.14963027e-02f, 8.84636566e-02f, 2.69837320e-01f, 4.63191010e-02f, -8.94619077e-02f, 1.19445473e-02f, -3.65280718e-01f, -2.15007767e-01f, -2.46563926e-01f, -4.39090312e-01f,
  -2.34345376e-01f, -2.07307398e-01f, 6.49517775e-02f, 1.05967827e-01f, -1.53565109e-01f, 1.28960639e-01f, -7.43598491e-02f, 4.93961619e-03f, 5.43887801e-02f, -2.71653906e-02f,
  -1.13605469e-01f, 4.66158204e-02f, 4.33234088e-02f, -1.03736863e-01f, 3.34992772e-03f, -1.60390735e-02f, -5.05810641e-02f, -3.58757190e-02f, 1.09260790e-02f, -1.24919385e-01f,
  -1.70405135e-01f, -4.53342274e-02f, 1.77949015e-02f, -1.59170628e-01f, -4.50574271e-02f, 1.31753936e-01f, -1.63355425e-01f, -3.86489294e-02f, -7.07898929e-04f, -1.52281567e-01f,
  -1.05258152e-01f, -2.87353266e-02f, 2.11476199e-02f, 2.17294060e-02f, 8.42430517e-02f, 4.93619638e-03f, 9.57027543e-03f, -5.40889949e-02f, 6.85562268e-02f, -4.21938300e-02f,
  -4.62870393e-03f, -4.83374447e-02f, 5.41953146e-02f, -5.97190149e-02f, -2.03356165e-02f, -8.82931333e-03f, 3.98458019e-02f, -4.41921167e-02f, 2.46602972e-03f, 5.08147553e-02f,
  -2.63656154e-02f, 5.56573123e-02f, -2.39694468e-03f, 1.75603759e-02f, -5.09128012e-02f, -1.04137726e-01f, 3.66157107e-03f, -2.22021360e-02f, 8.66005942e-02f, 9.64992642e-02f,
  9.80263278e-02f, -3.59813236e-02f, 2.89289048e-03f, 1.07540399e-01f, -1.19636627e-02f, -4.90671350e-03f, -8.67568189e-04f, 7.21351951e-02f, -3.96119431e-02f, 5.42068519e-02f,
  -6.56916276e-02f, 1.08245343e-01f, -6.65204823e-02f, -1.10524967e-02f, 3.35611142e-02f, -1.84290111e-02f, 7.39361867e-02f, 6.70832247e-02f, 5.05116098e-02f, -3.83964218e-02f,
  -4.56899926e-02f, 9.29304063e-02f, 2.24299476e-01f, 9.92804468e-02f, 2.06456278e-02f, 2.59878427e-01f, 5.00105657e-02f, 6.23343745e-03f, 2.15968013e-01f, 4.23443280e-02f,
  -1.17804363e-01f, 2.17477046e-02f, -1.24452688e-01f, -4.24150713e-02f, -4.18417379e-02f, -1.86268017e-01f, -2.61382371e-01f, -3.27490836e-01f, -5.42206839e-02f, 1.28232792e-01f,
  4.15732265e-01f, 5.32760918e-01f, 4.14814770e-01f, 2.04274058e-01f, -8.73913709e-03f, -2.04039723e-01f, -3.28535318e-01f, -7.00143874e-02f, 1.03739515e-01f, 5.03888354e-02f,
  1.79730192e-01f, 5.73413894e-02f, 4.35984368e-03f, -4.16273624e-02f, 8.77249837e-02f, 2.55038291e-01f, 9.63925645e-02f, 1.12020850e-01f, 1.30054444e-01f, -2.42925044e-02f,
  5.59882700e-01f, -2.16034368e-01f, 5.41504286e-03f, 8.76087919e-02f, 4.28660251e-02f, -1.70989811e-01f, -2.55566053e-02f, -1.86986059e-01f, -1.85037196e-01f, -2.28148550e-01f,
  1.83985732e-03f, -9.27514732e-02f, -4.20499705e-02f, 1.02420300e-01f, -1.28141358e-01f, -8.51076022e-02f, -1.63166687e-01f, -2.09439531e-01f, -5.62354028e-02f, -1.30667970e-01f,
  7.44864866e-02f, -8.76698196e-02f, -8.92095417e-02f, -4.53975759e-02f, -3.83124426e-02f, -6.96779042e-03f, -5.22944219e-02f, -1.91096827e-01f, -2.59722136e-02f, -1.19153038e-01f,
  4.16251831e-02f, -7.30296299e-02f, 7.84528852e-02f, 5.89603633e-02f, 6.91657439e-02f, -6.57793507e-02f, 3.44948955e-02f, -1.59406115e-03f, -6.66851103e-02f, 2.27821339e-02f,
  5.40820882e-02f, -6.92789629e-02f, 4.89346832e-02f, -8.37558061e-02f, 9.22953784e-02f, -1.31780609e-01f, -5.18349782e-02f, -1.90209653e-02f, -3.75270508e-02f, 9.45305079e-03f,
  1.18655249e-01f, -1.56712532e-02f, 4.24392819e-02f, -3.18154581e-02f, -6.68627396e-02f, 4.97492924e-02f, -4.01642621e-02f, -1.92556810e-02f, -1.15514891e-02f, -1.19473681e-01f,
  3.20361257e-01f, -9.19385627e-02f, 1.31910875e-01f, -6.93435874e-03f, -1.02423012e-01f, 4.17967141e-02f, 5.36071621e-02f, -3.64232473e-02f, 6.92891255e-02f, 9.30514839e-03f,
  6.39269873e-02f, -7.31504662e-03f, 1.14889599e-01f, 9.10081994e-03f, 7.48885125e-02f, -3.13047110e-03f, -7.46674314e-02f, 1.06495664e-01f, -3.95118296e-02f, -1.37238815e-01f,
  -2.85383742e-02f, -1.44130476e-02f, 2.14157134e-01f, 1.38138071e-01f, -1.70344952e-03f, 1.32919908e-01f, 2.25862801e-01f, 5.29306531e-02f, 1.14160955e-01f, 2.71854192e-01f,
  -5.24186254e-01f, -2.51653194e-01f, -4.68916714e-01f, -2.17330247e-01f, -2.41447002e-01f, -1.90010726e-01f, -1.31448507e-01f, 1.58184655e-02f, 2.78492793e-02f, -1.88576132e-01f,
  -3.09219528e-02f, -8.15171152e-02f, -2.66222805e-01f, -1.98571891e-01f, -1.42841205e-01f, -2.92144060e-01f, -4.19714391e-01f, -3.42084944e-01f, -2.68882722e-01f, -3.29048596e-02f,
  -1.71559319e-01f, -2.64343441e-01f, -3.28060746e-01f, -2.84962784e-02f, -1.58187822e-02f, -4.10061236e-03f, -2.00889349e-01f, -2.10089982e-01f, 2.43728096e-03f, -1.66493759e-01f,
  -2.84473479e-01f, -6.63337810e-03f, -6.48994446e-02f, -1.40061202e-02f, -3.76611687e-02f, 2.29589958e-02f, -7.42405877e-02f, -7.48219937e-02f, -1.04474304e-02f, -7.86068588e-02f,
  -5.69701418e-02f, -8.66653100e-02f, -8.21033567e-02f, -1.40259946e-02f, -1.37956440e-01f, -1.07258685e-01f, 2.03214735e-02f, -1.54023170e-01f, -8.70447308e-02f, 3.96776050e-02f,
  -8.46929625e-02f, -1.40597209e-01f, -4.61523198e-02f, 1.16627730e-01f, 9.46619883e-02f, -8.42738152e-02f, 5.51333576e-02f, 6.74163923e-02f, -1.38508650e-02f, 1.32799432e-01f,
  4.99797426e-02f, -1.70058571e-02f, -4.70818840e-02f, -1.66877117e-02f, 4.52582724e-02f, -1.19124148e-02f, 1.53184878e-02f, -4.98145372e-02f, -1.45283714e-03f, -5.71060292e-02f,
  -6.54899655e-03f, 2.44455002e-02f, -2.23667789e-02f, -6.89880252e-02f, -3.71619724e-02f, -2.19870284e-02f, 4.57341522e-02f, 2.59995740e-02f, 2.82704402e-02f, -2.27176398e-03f,
  -9.42776725e-02f, 7.12661371e-02f, 3.11023537e-02f, 5.41125387e-02f, 4.54408675e-02f, -4.64726724e-02f, 2.22785398e-02f, 1.07825965e-01f, -3.74845900e-02f, -1.18896263e-02f,
  2.24058237e-02f, -9.36732627e-03f, -7.19374716e-02f, 9.99167189e-02f, -7.81420171e-02f, 8.65710005e-02f, -1.81761030e-02f, 8.46221745e-02f, -6.62553385e-02f, 3.23676527e-03f,
  1.04203681e-02f, -3.27133797e-02f, -1.75213128e-01f, 1.92387588e-02f, -1.20437071e-01f, -4.82079163e-02f, 3.54965702e-02f, -8.41747671e-02f, 2.71433382e-03f, 7.77081177e-02f,
  2.80073583e-02f, 2.03204658e-02f, -9.24681500e-02f, -8.69355723e-02f, 3.23721115e-03f, -1.59431100e-01f, -2.98169889e-02f, 1.54544003e-02f, -8.92588943e-02f, -3.60314958e-02f,
  2.00269163e-01f, -1.68082252e-01f, 6.65107444e-02f, 6.93644062e-02f, 2.20803678e-01f, 2.81846792e-01f, 2.94949204e-01f, 1.67134643e-01f, 6.98142722e-02f, -4.99832295e-02f,
  4.67999838e-03f, 9.66930315e-02f, 8.10946301e-02f, 7.38814250e-02f, 1.09558813e-01f, 4.77557518e-02f, 1.73886582e-01f, -1.30592026e-02f, 9.90176499e-02f, 1.13587871e-01f,
  6.28870651e-02f, -1.36043057e-01f, -1.43937243e-03f, -5.20632565e-02f, -6.29172698e-02f, -1.69563666e-02f, -1.00985780e-01f, -1.25245392e-01f, -1.08971879e-01f, -9.98451263e-02f,
  -3.98748033e-02f, 5.90795726e-02f, 7.69801885e-02f, -4.50814106e-02f, -5.87475151e-02f, 2.13317368e-02f, 3.01829148e-02f, -1.26375064e-01f, 1.51150292e-02f, -1.12829804e-01f,
  -1.61206964e-02f, -1.03416324e-01f, 1.03493564e-01f, -1.48520306e-01f, -8.70375559e-02f, -1.08751580e-01f, -1.07891612e-01f, 1.73225608e-02f, -4.03999956e-03f, 2.48118620e-02f,
  3.08084451e-02f, 3.06937899e-02f, -2.43437719e-02f, -1.18157240e-02f, -1.56577248e-02f, 5.39977066e-02f, -1.58376470e-02f, -9.13344100e-02f, 8.27221491e-04f, -5.60361110e-02f,
  1.37831196e-01f, 9.69699100e-02f, 5.42181544e-02f, 2.37195119e-02f, -7.91651011e-02f, -2.33790707e-02f, -7.86110479e-03f, -4.19774093e-02f, -4.71164752e-03f, 7.73664191e-02f,
  -2.09826119e-02f, -5.70990182e-02f, 2.01451732e-03f, -1.64190736e-02f, -7.21933991e-02f, -6.61022738e-02f, 1.34884417e-02f, -8.91092941e-02f, -6.87559843e-02f, -1.84059255e-02f,
  -5.70934154e-02f, 1.93472877e-02f, -3.00219413e-02f, -5.05499169e-02f, 8.27971846e-03f, -2.67558675e-02f, 7.20464438e-02f, -4.04157192e-02f, 8.19469839e-02f, 7.36518726e-02f,
  -5.99105991e-02f, 1.53101578e-01f, 6.15051016e-02f, 1.29009560e-02f, 1.92275662e-02f, -3.17065008e-02f, -3.82858701e-02f, 2.95628998e-02f, -4.49802019e-02f, 3.01362555e-02f,
  4.89207450e-03f, 3.99004370e-02f, 9.39787086e-03f, -1.13325894e-01f, 1.07801154e-01f, 6.87184697e-03f, -7.53169879e-02f, 1.02566786e-01f, -2.34519411e-02f, -1.15311623e-01f,
  -1.02208473e-01f, 9.12850499e-02f, 3.72558795e-02f, 4.00536358e-02f, 1.25896990e-01f, 8.76439586e-02f, 9.23813581e-02f, -5.19446842e-02f, 1.10603653e-01f, -3.53976227e-02f,
  1.03373341e-02f, -1.17144726e-01f, 2.66258568e-01f, 5.23304455e-02f, -2.07464933e-01f, -3.55817586e-01f, -2.40002498e-01f, -1.22597814e-01f, -2.81710383e-02f, -2.72430331e-02f,
  -2.51518995e-01f, -1.86147973e-01f, 8.69116373e-03f, 5.06526083e-02f, 2.55713891e-02f, -4.70229574e-02f, 1.74182147e-01f, 3.00032705e-01f, 2.16227561e-01f, -1.56627372e-01f,
  -6.74600527e-02f, 1.91733733e-01f, 2.66712129e-01f, 6.33135065e-02f, -7.53795728e-02f, 8.87232944e-02f, 2.48654187e-01f, 1.84770022e-02f, -7.76964128e-02f, 2.02951971e-02f,
  4.73443680e-02f, -1.23383075e-01f, 4.11799997e-02f, -8.68359730e-02f, -8.79024491e-02f, -1.64661203e-02f, -7.64082372e-02f, 1.17002033e-01f, -1.51973218e-01f, 4.99500008e-03f,
  -1.35021821e-01f, -3.75719368e-02f, -1.12074032e-01f, -6.85619265e-02f, 2.87615433e-02f, -6.75419718e-02f, 1.73728526e-01f, 1.71814173e-01f, 9.23072994e-02f, -1.41202033e-01f,
  -9.08508152e-02f, -1.07186496e-01f, -6.22765487e-03f, 1.49962939e-02f, -2.46693417e-02f, -4.53948490e-02f, 8.25560689e-02f, -4.26818058e-02f, 1.02722887e-02f, 4.45257947e-02f,
  4.68883216e-02f, -2.79520135e-02f, 7.05391727e-03f, 7.84684252e-03f, 1.72778666e-02f, 1.39401807e-02f, 1.67559348e-02f, -6.27934840e-03f, 6.50405372e-03f, 1.65239852e-02f,
  6.08966425e-02f, -8.42193794e-03f, 5.88099808e-02f, -3.39264721e-02f, 3.24139334e-02f, 9.45274308e-02f, -3.06127016e-02f, 3.97202894e-02f, -7.49809202e-03f, 2.53997967e-02f,
  -6.59279451e-02f, 8.82906690e-02f, 1.98369771e-02f, 3.30968499e-02f, 5.34318388e-02f, 5.22159189e-02f, 3.46902944e-03f, 8.42285454e-02f, -2.10074745e-02f, 1.87198501e-02f,
  5.65985031e-02f, 1.02475129e-01f, -8.53373036e-02f, -3.31832818e-03f, -5.79224005e-02f, 1.88133202e-03f, -1.43636242e-01f, 8.28286931e-02f, -1.20050780e-01f, -8.90707746e-02f,
  -1.46006629e-01f, -3.65571701e-03f, -6.11845031e-02f, -6.01112060e-02f, -8.65183547e-02f, -7.99582526e-02f, -5.07503264e-02f, 3.23031060e-02f, 1.98104559e-03f, 3.44782546e-02f,
  -7.98919499e-02f, -1.15707545e-02f, -4.40354347e-02f, -1.59640498e-02f, -2.36158706e-02f, -1.46779254e-01f, 6.52506948e-02f, 6.96806461e-02f, -3.16677243e-02f, 1.31453797e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -3.18519324e-02f, 4.20208871e-01f, 2.83178948e-02f, 5.41304588e-01f, 5.26707053e-01f, 2.66843110e-01f, 4.09311026e-01f, 2.09959596e-01f, 1.14224792e-01f, 2.93963909e-01f,
  3.51440340e-01f, 6.02355003e-01f, 1.53328240e-01f, 3.12188745e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.89873222e-02f, 5.76761186e-01f, -2.03482568e-01f, 3.52454782e-01f, 1.07693270e-01f, -2.98959970e-01f, -1.35767594e-01f, 1.60234850e-02f, 2.40037218e-01f, -1.88777506e-01f,
  -3.38899828e-02f, 6.01064265e-01f, -5.43758646e-02f, -1.66441441e-01f, 1.88691214e-01f, -4.47333008e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.32290047e-01f, 1.15133077e-01f, -2.47392774e-01f, 5.22324920e-01f, 2.12183967e-02f, 1.93599910e-02f, 3.25579435e-01f, 1.47745922e-01f, 2.72092372e-01f, -1.38497680e-01f,
  2.65411418e-02f, -3.44321609e-01f, -2.45630458e-01f, 7.61036724e-02f, -1.63227424e-01f, 3.12224388e-01f, -4.78587560e-02f, -2.02537045e-01f, 2.28857771e-01f, 1.37195811e-01f,
  -5.69354743e-02f, 3.23772758e-01f, -1.15390979e-01f, -2.13888779e-01f, -7.03611374e-02f, -2.30493784e-01f, 2.20151022e-01f, -1.04311913e-01f, 4.73012999e-02f, -1.29049256e-01f,
  -1.01894094e-02f, 3.77143651e-01f, -9.75384787e-02f, -3.15703422e-01f, -3.54646631e-02f, 9.62875709e-02f, -1.57318413e-01f, 1.60577014e-01f, 6.56929314e-01f, -4.16422218e-01f,
  2.85280406e-01f, 8.67122114e-02f, -2.25080460e-01f, 9.81194898e-02f, -6.42728731e-02f, 1.03762174e+00f, -3.96166816e-02f, 2.26046994e-01f, 2.09511414e-01f, 5.18996656e-01f,
  -1.51065424e-01f, 1.00989079e+00f, -1.69872239e-01f, 2.21511960e-01f, 7.29229599e-02f, 1.43758699e-01f, 3.58741283e-01f, 3.97479683e-01f, -3.47686350e-01f, -8.11052173e-02f,
  -2.72946805e-01f, 5.25451005e-02f, -2.44777232e-01f, -6.93752989e-03f, -1.67017043e-01f, 3.22076291e-01f, -2.97041833e-01f, -1.67465270e-01f, 3.50377679e-01f, -3.08853388e-01f,
  -8.93266872e-02f, -3.32873836e-02f, 4.74711448e-01f, 5.60866520e-02f, -7.26779625e-02f, 7.00630128e-01f, -1.86784610e-01f, 4.31214422e-01f, 2.09476396e-01f, -7.36055747e-02f,
  9.31639493e-01f, -3.07362199e-01f, -1.12782717e-01f, 4.60665375e-01f, -3.48028511e-01f, 5.53034663e-01f, 4.69764680e-01f, -3.28222036e-01f, 5.21302819e-01f, 2.93860789e-02f,
  -3.75450581e-01f, -3.11092764e-01f, 1.08481455e+00f, 6.57867938e-02f, -4.67342138e-01f, 2.90893316e-01f, -4.98874754e-01f, -4.48012911e-02f, 1.21262729e-01f, -2.01147020e-01f,
  2.03237832e-01f, 7.36953784e-03f, -1.01594552e-01f, -7.57309794e-02f, 1.00906059e-01f, 1.24837123e-01f, 2.40548313e-01f, 7.61666670e-02f, -3.29573274e-01f, 5.58726370e-01f,
  -1.33271694e-01f, 9.04019326e-02f, 8.24578166e-01f, 2.31858134e-01f, -7.24708512e-02f, 3.99456859e-01f, 7.73946047e-02f, 2.02561960e-01f, 5.56807101e-01f, 5.14200389e-01f,
  3.00115943e-01f, 9.75001696e-03f, -1.66246653e-01f, 6.62241638e-01f, 5.81380785e-01f, -1.33497596e-01f, 3.19901183e-02f, -1.12456549e-02f, 7.03307092e-01f, -2.57593304e-01f,
  -5.62522888e-01f, -2.71923423e-01f, 2.11985648e-01f, 8.92970860e-01f, 8.27339217e-02f, 8.71667385e-01f, 3.69401991e-01f, -5.81012726e-01f, 6.62556648e-01f, 1.00271273e+00f,
  7.31671602e-02f, -1.79205567e-01f, 1.49567202e-01f, 3.26440752e-01f, -5.50828874e-02f, -1.52666211e-01f, -1.36019513e-01f, -5.14733829e-02f, -3.87190908e-01f, -4.27780539e-01f,
  3.41499686e-01f, 5.75536013e-01f, 1.81351498e-01f, 7.51593053e-01f, 3.89787674e-01f, 5.66829026e-01f, 7.22481608e-01f, 6.82523310e-01f, 3.89877796e-01f, -4.53907013e-01f,
  -1.16792805e-01f, 5.35108685e-01f, -1.00100502e-01f, 1.49554923e-01f, 1.82919383e-01f, -1.53116599e-01f, -1.52759433e-01f, -1.24793597e-01f, 1.39169723e-01f, 5.51342487e-01f,
  -2.06344426e-01f, 5.27089357e-01f, 1.40731603e-01f, 5.50409406e-02f, 3.17356586e-01f, 5.24690390e-01f, 4.64900304e-03f, 2.32643396e-01f, 3.73660885e-02f, 7.26355970e-01f,
  1.29323646e-01f, 8.29105526e-02f, -2.13622764e-01f, 7.64026761e-01f, -1.36806548e-01f, 4.36875373e-01f, -3.80065665e-02f, 1.21688783e-01f, 1.84812501e-01f, -1.05838560e-01f,
  8.78350139e-02f, -4.07399923e-01f, 3.29829514e-01f, 1.70619488e-01f, -1.29874542e-01f, 6.25477552e-01f, -1.82562903e-01f, 3.21944863e-01f, 3.46604109e-01f, 3.68987352e-01f,
  -1.69352502e-01f, 2.96814948e-01f, -2.36199677e-01f, -5.14959134e-02f, -2.95356482e-01f, 3.23432870e-02f, 2.61851281e-01f, -6.15598485e-02f, -3.06039035e-01f, 4.25624251e-01f,
  -2.77539521e-01f, 3.75056297e-01f, 3.70117843e-01f, -3.04971207e-02f, -1.34424657e-01f, 2.85423577e-01f, 3.72835845e-01f, -2.33734637e-01f, -1.04133181e-01f, 1.67222664e-01f,
  -3.27189296e-01f, -4.63706911e-01f, 5.78943975e-02f, 4.24880683e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -3.53016937e-03f, -1.16245307e-01f, 7.95310259e-01f, 2.01930225e-01f, 4.10957128e-01f, 7.28654712e-02f, 2.84627765e-01f, 2.03650370e-01f, 1.66763276e-01f, 9.79824066e-02f,
  3.80396098e-01f, 1.52359888e-01f, 3.11835915e-01f, 4.31160688e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.34941000e-01f, -1.39826983e-01f, 3.26560020e-01f, 2.38625601e-01f, -2.52053030e-02f, -2.03389674e-01f, -2.91094661e-01f, -1.31747052e-01f, 1.38327880e-02f, 3.79063226e-02f,
  7.53064036e-01f, -1.65301263e-01f, -2.12690026e-01f, 1.08598195e-01f, -2.82856543e-02f, -1.08914226e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.86598819e-01f, 1.69553488e-01f, 3.53964306e-02f, -4.33613025e-02f, -4.36759628e-02f, -2.65147865e-01f, -2.09348515e-01f, 1.22321212e+00f, -5.89125931e-01f, 9.76427138e-01f,
  5.98558426e-01f, 2.80263394e-01f, -1.33679537e-02f, -4.36349094e-01f, -1.74583286e-01f, -4.63522077e-01f, -4.52718399e-02f, -1.54229492e-01f, 6.24739267e-02f, -1.04827739e-01f,
  -5.34623384e-01f, 3.29436004e-01f, -1.36466295e-01f, -1.07699603e-01f, 2.73880102e-02f, 2.22325876e-01f, 1.05350286e-01f, 4.39889342e-01f, -2.87478268e-01f, 7.73617506e-01f,
  4.35231239e-01f, 1.33495107e-01f, 5.19854367e-01f, -5.69305718e-01f, 2.47175545e-01f, -1.17271446e-01f, 1.24104059e+00f, 1.36376172e-02f, -1.03686340e-01f, 1.04286456e+00f,
  3.20957862e-02f, 1.23358086e-01f, -6.36030436e-01f, 3.30562055e-01f, -5.14317974e-02f, -1.63642943e-01f, 3.44313651e-01f, -4.01385754e-01f, 4.62361962e-01f, 2.09618852e-01f,
  2.84392923e-01f, 2.20340312e-01f, -7.99910501e-02f, 4.37042825e-02f, -7.64481127e-02f, 4.71831441e-01f, -4.25101459e-01f, 6.20200574e-01f, 9.13745761e-01f, 7.19047263e-02f,
  -5.98539039e-02f, 5.54283895e-02f, 2.72581547e-01f, -2.41254598e-01f, 1.88169912e-01f, -3.25754434e-01f, -3.35757732e-02f, 8.82714763e-02f, -5.62088750e-02f, 4.29495633e-01f,
  -2.62336046e-01f, -1.28420517e-02f, -7.55059486e-03f, 6.41143648e-03f, 1.67451575e-01f, -2.27246463e-01f, 2.84382671e-01f, 1.70443133e-01f, 3.67136955e-01f, 1.42609999e-01f,
  2.64072180e-01f, 2.30839983e-01f, -3.69073600e-01f, -3.23781520e-01f, 5.55803716e-01f, -3.66274834e-01f, 6.47199869e-01f, -6.54916346e-01f, 3.79746139e-01f, 2.45135531e-01f,
  3.82420309e-02f, 1.12705827e+00f, 3.61776948e-01f, 3.65436554e-01f, 7.69492285e-03f, -3.17620337e-01f, -1.19801335e-01f, -2.73301423e-01f, -1.43059552e-01f, 1.47984559e-02f,
  -1.51635483e-01f, -1.17062710e-01f, 1.19979702e-01f, -1.69775486e-01f, 3.64111811e-01f, 8.03524703e-02f, 4.89291310e-01f, 3.46235521e-02f, 6.59353361e-02f, 3.54956202e-02f,
  3.50580155e-03f, -3.01783115e-01f, -9.64454934e-02f, 4.82895374e-01f, 4.77544069e-01f, -1.30517825e-01f, 2.67246455e-01f, 7.86992669e-01f, 3.40591908e-01f, -2.44363859e-01f,
  8.66849944e-02f, 3.41565967e-01f, -6.30896091e-01f, -2.28937715e-01f, 5.84557593e-01f, 3.28500122e-01f, 2.79869020e-01f, 4.33032751e-01f, -5.48523627e-02f, 6.30894601e-02f,
  -1.11400858e-01f, -2.33740687e-01f, 1.17025867e-01f, -1.40818590e-02f, -1.56114370e-01f, -8.56375173e-02f, 1.06475949e-01f, 4.53163981e-02f, -1.68465361e-01f, -2.44938865e-01f,
  -1.48611873e-01f, 2.63728462e-02f, 1.69862062e-01f, 1.89420417e-01f, 2.59425435e-02f, 4.73337881e-02f, -2.15799864e-02f, -2.96507001e-01f, -3.95081073e-01f, 3.49761963e-01f,
  -3.16714942e-01f, 1.30336225e-01f, -1.18296653e-01f, 4.29876626e-01f, 2.06956670e-01f, 1.75341114e-01f, -4.30103391e-01f, 5.99225700e-01f, 1.92973465e-01f, -1.39147043e-01f,
  1.08496398e-01f, 3.86419624e-01f, -2.34591439e-01f, -1.87830001e-01f, 3.71521443e-01f, 5.54298498e-02f, 4.77573484e-01f, -2.63013214e-01f, -1.11040682e-01f, 1.47288904e-01f,
  -4.21304762e-01f, 1.09411740e+00f, 5.14044642e-01f, 7.16105923e-02f, -1.55249208e-01f, -6.58270419e-02f, 2.27899879e-01f, 4.47425663e-01f, -2.74246596e-02f, -1.83934588e-02f,
  -5.64398728e-02f, -1.24006286e-01f, 6.02320313e-01f, -4.88707125e-01f, -1.18774973e-01f, 4.65843916e-01f, 1.28546405e+00f, -2.40629017e-01f, 4.50126171e-01f, -8.79655704e-02f,
  1.77099988e-01f, 6.30421281e-01f, -8.47451612e-02f, 6.14522874e-01f, 2.05496699e-01f, 1.68430328e-01f, -1.10460453e-01f, 4.33877110e-01f, 3.58582139e-01f, 3.55751961e-01f,
  -4.34920425e-04f, 2.87049949e-01f, 3.53985280e-02f, 1.39623359e-01f, 3.64972889e-01f, 1.47692263e-02f, -2.14701816e-01f, 1.08519755e-01f, 9.12632942e-02f, -6.68411329e-02f,
  2.24677891e-01f, 1.61684573e-01f, -2.58024812e-01f, 7.43934810e-01f, 3.63995321e-02f, 3.07340056e-01f, -1.32273510e-01f, 5.13039708e-01f, -2.10772306e-01f, -3.02067757e-01f,
  4.05436248e-01f, 4.35446680e-01f, 6.96674764e-01f, 5.52180827e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -8.81521925e-02f, -2.39501625e-01f, 5.26323974e-01f, 9.26978439e-02f, -8.60433578e-02f, -7.54838251e-03f, -2.90007293e-01f, 4.16795552e-01f, -2.30529904e-01f, 9.21212807e-02f,
  4.28872973e-01f, 1.31257653e-01f, -3.70350510e-01f, 2.18962684e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.68766439e-01f, -1.93985656e-01f, -4.57898587e-01f, -5.36841393e-01f, -1.48044869e-01f, -5.29407024e-01f, 3.50249819e-02f, 7.88983881e-01f, 1.71476435e-02f, 2.81564415e-01f,
  -2.46301040e-01f, -4.59012091e-01f, 7.50550151e-01f, -1.46355718e-01f, 2.32909128e-01f, -4.82902050e-01f, -3.27145368e-01f, 1.96322232e-01f, 3.55145633e-01f, 2.64632016e-01f,
  -3.62505585e-01f, 3.76987785e-01f, -8.46329704e-02f, 7.64835000e-01f, 4.54106599e-01f, -7.32772171e-01f, 1.51748881e-01f, 4.16683629e-02f, 9.02998820e-02f, 3.43151748e-01f,
  -1.51454985e-01f, -9.49887753e-01f, 1.14526659e-01f, 7.79877543e-01f, 6.07048929e-01f, -6.07174754e-01f, 3.09136540e-01f, 4.49445575e-01f, 2.57160872e-01f, -8.13239753e-01f,
  2.02237412e-01f, 6.93084151e-02f, -6.40243962e-02f, -3.83930653e-01f, -7.26143777e-01f, 3.57217133e-01f, -1.18373975e-01f, 2.95801073e-01f, 2.96117514e-01f, -8.70490849e-01f,
  -1.06875753e+00f, -2.86301583e-01f, 9.02731240e-01f, -8.89800251e-01f, -2.85549872e-02f, 4.14264411e-01f, -1.25438228e-01f, -1.70197189e-01f, 7.25135729e-02f, -3.71783674e-01f,
  4.92022723e-01f, -5.83953440e-01f, -8.78969550e-01f, -2.06152186e-01f, -1.33527055e-01f, -6.90447927e-01f, -2.25102752e-01f, 1.97046101e-01f, 1.05430949e+00f, -1.55525908e-01f,
  -1.12754114e-01f, -3.15065086e-02f, 2.64488101e-01f, 2.77732581e-01f, 1.42731845e-01f, -3.48623395e-02f, -1.49054065e-01f, -3.96326274e-01f, -8.14926699e-02f, -8.66492391e-02f,
  5.57041824e-01f, -2.90314138e-01f, 2.78065711e-01f, -9.36733112e-02f, -3.29563245e-02f, 2.17223465e-01f, -3.14760923e-01f, 1.89793319e-01f, -1.13022774e-01f, 4.64471430e-01f,
  7.26518109e-02f, -1.66700840e-01f, 2.71100134e-01f, 1.93991914e-01f, -7.73696825e-02f, 5.49832061e-02f, -4.64716762e-01f, -4.50492315e-02f, -5.79491496e-01f, 4.64044392e-01f,
  -8.35482717e-01f, 2.32771058e-02f, 3.61055464e-01f, -7.49534726e-01f, -2.47200593e-01f, 5.39866686e-01f, -2.13367984e-01f, 1.81943640e-01f, -5.97735345e-01f, 3.24380845e-01f,
  3.24279547e-01f, 6.16916478e-01f, -1.97258703e-02f, 1.45700902e-01f, -5.72558761e-01f, 3.08961928e-01f, -6.35291263e-02f, -3.90964389e-01f, 1.73266709e-01f, 2.74808824e-01f,
  -3.23426574e-01f, 5.89209616e-01f, -8.20397865e-03f, -2.39734296e-02f, 5.81656516e-01f, -2.51037002e-01f, -9.60097834e-03f, 4.85312581e-01f, 5.81437945e-01f, 3.94903570e-01f,
  -3.55251491e-01f, -1.75270140e-01f, -1.02107322e+00f, -1.17777810e-01f, -2.23139867e-01f, 1.18490554e-01f, -9.03654844e-02f, 3.10628176e-01f, -1.64971873e-01f, -2.54551768e-01f,
  3.15367818e-01f, 1.16058016e+00f, 6.84906095e-02f, -8.71751904e-02f, -6.37379289e-02f, 5.23073375e-01f, 2.31814697e-01f, 5.27384341e-01f, 1.53164014e-01f, 3.55873138e-01f,
  -9.32625607e-02f, -5.39728224e-01f, -8.49438235e-02f, 3.18736225e-01f, -3.37854922e-02f, 6.27859533e-01f, -2.65355736e-01f, -6.30619884e-01f, -3.70138604e-03f, 4.85628277e-01f,
  1.43371612e-01f, -2.09059045e-01f, 1.13409412e+00f, -2.31046617e-01f, 4.33092773e-01f, 1.18340112e-01f, -4.93658036e-01f, -5.89149237e-01f, 4.35890071e-02f, -6.72326863e-01f,
  -2.13654265e-01f, -1.08859040e-01f, 1.62544444e-01f, -5.25094986e-01f, 9.51017290e-02f, -2.89604485e-01f, -3.48655075e-01f, -1.36735559e-01f, 1.79456789e-02f, 4.78644222e-01f,
  -6.14023745e-01f, 4.94579077e-01f, 3.27219581e-03f, -4.09550875e-01f, 2.75746942e-01f, -6.23548150e-01f, 1.47680640e-01f, 5.72144806e-01f, -4.84074533e-01f, 6.73409104e-01f,
  -5.15547991e-01f, 6.28210977e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -8.82031545e-02f, -3.54642391e-01f, 4.31032479e-01f, 6.16944730e-01f, -1.09140068e-01f, 4.04820472e-01f, -1.28004342e-01f, -5.31874716e-01f, 2.82925814e-01f, -3.82379770e-01f,
  -3.53890091e-01f, 8.90810192e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    