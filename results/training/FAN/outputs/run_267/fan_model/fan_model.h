/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36970508e-01f, -2.18703061e-01f, -2.29501769e-01f, 2.42416486e-01f, -3.82253453e-02f, 8.91588163e-03f, 3.17524910e-01f, 6.89463597e-03f, 2.13247791e-01f, -3.42288613e-02f,
  2.72142023e-01f, -5.06354459e-02f, 6.47413135e-02f, 2.68729836e-01f, 4.75950420e-01f, 1.72000319e-01f, 4.16955531e-01f, 8.06452930e-02f, 1.12126790e-01f, -2.03287881e-03f,
  1.06848449e-01f, 2.39487529e-01f, 1.06825940e-01f, -2.25084722e-02f, -5.66135049e-02f, -9.90272164e-02f, -2.35167649e-02f, -1.34504542e-01f, -1.44753633e-02f, 2.86659785e-02f,
  2.24946588e-02f, -6.23235777e-02f, -5.52323125e-02f, -9.47149172e-02f, -3.24294977e-02f, -8.15867484e-02f, -5.43018170e-02f, -1.79296453e-02f, 3.67521644e-02f, 1.94290671e-02f,
  -5.50788082e-02f, 2.93806866e-02f, 6.56046346e-02f, -4.58224379e-02f, -2.05469113e-02f, -4.75343242e-02f, -1.59064550e-02f, -3.45360786e-02f, -8.11407052e-04f, 3.41508016e-02f,
  6.15143031e-02f, -4.42887023e-02f, 2.95794737e-02f, 3.99513207e-02f, -6.55023661e-03f, -1.02581000e-02f, -9.92960297e-03f, -5.80456555e-02f, -5.91559475e-03f, 4.20069620e-02f,
  3.98693271e-02f, 2.69879717e-02f, -1.15442583e-02f, 5.15159555e-02f, -3.71293984e-02f, 1.54393818e-02f, 2.73813773e-02f, 4.28948738e-02f, 2.70564165e-02f, 4.20604087e-02f,
  5.81780225e-02f, 6.90870173e-03f, 1.02222022e-02f, -4.92346250e-02f, 5.44132525e-03f, -3.82931530e-02f, -4.19400254e-04f, -2.83573492e-04f, 2.40445007e-02f, 5.50882593e-02f,
  1.43485246e-02f, 1.62577406e-02f, 2.90634166e-02f, -3.78464162e-02f, 1.36850933e-02f, -2.00647153e-02f, -4.71665431e-03f, -1.59468260e-02f, -3.36941816e-02f, -1.49763497e-02f,
  -4.45267223e-02f, -1.95131581e-02f, 8.40239525e-02f, 3.79744060e-02f, 2.97713466e-02f, -2.72799656e-02f, 6.68591931e-02f, 4.99930866e-02f, -2.07485314e-02f, -2.21230742e-02f,
  -6.73551187e-02f, -4.87520806e-02f, -8.17046016e-02f, 5.39616216e-03f, -5.62547985e-03f, 5.18287160e-02f, 2.04040762e-02f, -5.51193878e-02f, 1.42544108e-02f, 4.11759270e-03f,
  -6.39276356e-02f, 4.37696166e-02f, 3.25774476e-02f, -5.93321212e-02f, 2.01532412e-02f, -2.97923144e-02f, -1.21361753e-02f, -7.66823115e-03f, 3.46702561e-02f, 1.23393368e-02f,
  3.27128977e-01f, -2.54800856e-01f, 1.57505516e-02f, 5.22891767e-02f, 2.78361499e-01f, 9.62619856e-02f, 2.32552528e-01f, 2.70241089e-02f, -1.00253999e-01f, -2.25975156e-01f,
  1.35063827e-01f, -5.65165021e-02f, -3.52837406e-02f, 3.69548070e-04f, 2.07394153e-01f, -1.36030510e-01f, 5.80447689e-02f, -9.49573070e-02f, -5.36154322e-02f, -1.32218853e-03f,
  1.22737307e-02f, 8.79060030e-02f, 1.00245729e-01f, 2.45290305e-02f, 8.00885409e-02f, -1.00756027e-01f, 9.46411639e-02f, 2.77122296e-02f, -7.63660446e-02f, -2.14561038e-02f,
  -9.87902377e-03f, -6.28714487e-02f, 8.50375462e-03f, -8.14624056e-02f, 7.52626285e-02f, -5.16251801e-03f, 1.89834125e-02f, 4.05836701e-02f, 8.72932002e-02f, -4.03442569e-02f,
  -6.93637803e-02f, 1.09185195e-02f, -4.73730303e-02f, -1.88024640e-02f, 5.39124869e-02f, -2.09513698e-02f, 4.23660651e-02f, 2.36206315e-02f, -4.06942554e-02f, 5.46804778e-02f,
  8.56081862e-03f, 2.28005042e-03f, 3.35121788e-02f, -3.26085128e-02f, 8.96392167e-02f, 3.31315696e-02f, -2.95586102e-02f, 5.19218072e-02f, -6.59054592e-02f, 1.20260548e-02f,
  -3.17712873e-02f, -2.38281153e-02f, 4.98180045e-03f, 4.16201539e-02f, -9.35967825e-03f, 3.91911976e-02f, -8.71683843e-03f, -4.22418006e-02f, 3.20692100e-02f, 3.63177396e-02f,
  4.67997529e-02f, 3.23986337e-02f, -9.12354421e-03f, 5.35146445e-02f, 3.37082474e-03f, 4.16516624e-02f, 4.73829322e-02f, 1.27714239e-02f, 6.99120089e-02f, 3.98393273e-02f,
  -2.51457039e-02f, -5.60109457e-03f, 4.37062010e-02f, 2.88716331e-02f, -2.20114943e-02f, 8.61935616e-02f, -6.89185783e-02f, 3.29067186e-02f, 6.45161280e-03f, 1.67773180e-02f,
  -1.13392785e-01f, -2.24299610e-01f, -2.68258639e-02f, 8.55278894e-02f, -7.48353675e-02f, 1.63901951e-02f, -8.07912052e-02f, 1.63151249e-02f, -8.12325403e-02f, -1.66841540e-02f,
  2.42039878e-02f, -1.25393723e-04f, -7.07226107e-03f, 1.06731094e-01f, -3.49853337e-02f, -1.85135081e-02f, -1.74196605e-02f, -1.01572443e-02f, -5.77631630e-02f, -3.67049761e-02f,
  -2.44328082e-02f, 2.51492225e-02f, -3.90454405e-03f, 7.21890405e-02f, -2.80447379e-02f, 2.37273928e-02f, -3.38815637e-02f, -3.87871154e-02f, -1.92549564e-02f, -7.55598992e-02f,
  -2.22844601e-01f, 1.83530241e-01f, 4.35635000e-02f, -1.81843817e-01f, -1.82238333e-02f, 2.97564249e-02f, -2.79890716e-01f, 8.34250674e-02f, -3.36635828e-01f, 8.55160505e-02f,
  7.95621797e-02f, 5.43391258e-02f, 4.52483781e-02f, 1.17591202e-01f, -2.32946694e-01f, -1.82678819e-01f, -9.61994007e-03f, 9.32632759e-03f, -5.80537356e-02f, 1.35971665e-01f,
  -7.69212563e-03f, 2.79273260e-02f, 1.27052441e-01f, 1.66064486e-01f, 1.85945868e-01f, 1.80315617e-02f, -7.11864606e-02f, 2.43070144e-02f, 1.68312550e-01f, -3.93528538e-03f,
  1.15838684e-01f, 3.22828442e-02f, 1.64892241e-01f, 5.16300872e-02f, -8.63281414e-02f, -1.13178473e-02f, 7.96977058e-03f, -4.19134088e-02f, 6.77675148e-03f, -3.47178318e-02f,
  -4.65987921e-02f, -4.13613133e-02f, -5.48777916e-02f, -1.40777174e-02f, 3.43539342e-02f, 3.16252410e-02f, 8.20861831e-02f, 1.01397149e-02f, -2.16797665e-02f, 1.03908680e-01f,
  8.01495686e-02f, 1.25895604e-01f, -1.27516119e-02f, -3.95001173e-02f, -1.04184169e-02f, -7.98077881e-03f, -5.43574579e-02f, 4.52440791e-02f, 4.80747968e-02f, -9.00446773e-02f,
  2.66599040e-02f, -9.60741937e-02f, -8.94255750e-03f, 3.62092219e-02f, 4.71963212e-02f, 9.34856385e-03f, -7.58219277e-04f, 5.36853820e-02f, -8.54080170e-02f, -9.30530950e-03f,
  1.24546457e-02f, 1.88609045e-02f, -9.06344410e-03f, -5.88427372e-02f, 4.30154391e-02f, -5.14146611e-02f, -1.98379140e-02f, 3.65354400e-03f, -7.10986182e-02f, 1.22261932e-02f,
  -6.11667335e-02f, 2.34113075e-02f, 2.17627566e-02f, -2.42146123e-02f, 1.82279572e-02f, -7.84302875e-02f, 6.49766028e-02f, 6.36388361e-02f, -1.13864038e-02f, 3.15001011e-02f,
  -6.47980422e-02f, -8.21609646e-02f, 1.00025041e-02f, -2.23832913e-02f, 2.73640491e-02f, 6.39139265e-02f, 6.83956267e-03f, 2.76451223e-02f, -4.28206623e-02f, 2.87189949e-02f,
  -3.18024643e-02f, -3.56172360e-02f, 1.03057874e-02f, -1.67744439e-02f, -3.92421596e-02f, -5.07156700e-02f, -7.11112767e-02f, -1.71708874e-02f, -3.22883725e-02f, 9.76287201e-02f,
  -9.89547651e-03f, -6.11634888e-02f, -3.76410894e-02f, -2.46053040e-02f, 1.86664574e-02f, -3.61798443e-02f, 5.51614910e-03f, -1.16377836e-02f, 2.20791325e-02f, 2.32213195e-02f,
  -2.47788116e-01f, -1.27581162e-02f, -2.11947680e-01f, -2.45144159e-01f, -1.06431901e-01f, 2.33450606e-01f, 8.45873579e-02f, -1.60987541e-01f, -3.24656039e-01f, 2.15282395e-01f,
  1.69389918e-02f, 6.70720041e-02f, -1.44388368e-02f, 1.03995621e-01f, -1.89637579e-02f, 9.00055468e-02f, 6.24817237e-02f, 5.92793226e-02f, -2.17237636e-01f, -3.25502791e-02f,
  -1.33698016e-01f, 8.42436254e-02f, -1.29364757e-02f, -1.08892387e-02f, 2.49848887e-02f, -1.13865905e-01f, -1.64547488e-02f, -2.75174920e-02f, 9.55726765e-03f, 9.34117436e-02f,
  7.75569454e-02f, -6.39287680e-02f, -1.24965556e-01f, 8.00475478e-02f, 9.98697150e-03f, 4.38836925e-02f, 9.34202820e-02f, 8.88835564e-02f, -8.37414246e-03f, -1.99635755e-02f,
  3.83748375e-02f, 4.67504673e-02f, -4.49986905e-02f, -3.90080288e-02f, -6.77485764e-03f, 8.21334030e-03f, -9.57223773e-03f, -2.46641436e-03f, -5.12178913e-02f, 2.93717999e-02f,
  -5.85007928e-02f, 2.65929922e-02f, 1.12113673e-02f, 5.99339791e-02f, -3.58399488e-02f, -4.67097498e-02f, 1.65636558e-02f, -3.48404162e-02f, -4.39912677e-02f, -5.98359704e-02f,
  1.04217686e-01f, -2.35273950e-02f, 3.35872583e-02f, -5.36691360e-02f, -8.94432329e-03f, -6.93827495e-02f, 6.56431615e-02f, 2.97975428e-02f, 5.87188639e-02f, -4.46850322e-02f,
  -2.34569740e-02f, 5.63110178e-03f, -2.64914241e-02f, 1.74732134e-02f, -1.36727495e-02f, 4.39211074e-03f, -2.41399556e-02f, -4.61566746e-02f, -5.57319901e-04f, -3.93904597e-02f,
  -9.36759636e-03f, 4.45568608e-03f, 4.97315405e-03f, -2.04304326e-02f, -9.43909772e-03f, 1.43289976e-02f, 2.10723523e-02f, -2.63806134e-02f, -2.16531735e-02f, 2.67213341e-02f,
  8.19334686e-02f, 7.30452314e-02f, 1.08078243e-02f, 4.45858650e-02f, -2.62518115e-02f, 6.06887527e-02f, 1.07295271e-02f, -2.59850919e-03f, 2.34552138e-02f, -3.76000777e-02f,
  4.28964011e-02f, 9.42079537e-03f, 7.59686949e-03f, 3.74581665e-02f, -9.27642360e-03f, -2.39164215e-02f, 4.62587439e-02f, 4.13829945e-02f, 3.72485407e-02f, 2.45988928e-02f,
  7.24419206e-02f, -3.14907059e-02f, 3.59720625e-02f, -3.98451611e-02f, -1.36186732e-02f, 6.71748212e-03f, -4.03757244e-02f, 3.41026932e-02f, -1.27588762e-02f, 3.31735015e-02f,
  -1.52730763e-01f, -1.43616917e-02f, 3.49570513e-02f, -1.86800852e-01f, -7.61241978e-03f, 2.11186171e-01f, 2.48355180e-01f, -2.10988671e-01f, 8.16013217e-02f, -6.73770159e-02f,
  -2.62186304e-02f, 6.11926941e-03f, 2.02960983e-01f, -6.34400100e-02f, 3.39538842e-01f, 2.87278086e-01f, 3.24468613e-02f, -2.11109291e-03f, 8.39625206e-03f, -1.42874509e-01f,
  -5.52209914e-02f, 1.07840978e-01f, 1.62911400e-01f, -2.39406154e-02f, -2.30141748e-02f, -2.30954871e-01f, -1.06982626e-01f, 1.09012291e-01f, -1.64503038e-01f, 1.21722721e-01f,
  4.91695702e-02f, 1.85251869e-02f, -1.88632365e-02f, -2.13728342e-02f, 3.84124964e-02f, -2.54343404e-03f, -7.26421922e-03f, 2.28256267e-02f, 2.98379604e-02f, 7.35630020e-02f,
  -5.50450459e-02f, -5.55051304e-02f, -8.71895105e-02f, 2.59023421e-02f, -1.69374533e-02f, 2.16816142e-02f, 2.77174963e-03f, -2.60472242e-02f, -3.87923084e-02f, 4.64396253e-02f,
  1.51897129e-02f, -4.52682422e-03f, -1.32977545e-01f, -1.70556940e-02f, 2.05770731e-02f, 3.65442708e-02f, 1.32766860e-02f, -1.12441350e-02f, -4.73292619e-02f, -5.57443686e-02f,
  -3.30588743e-02f, -1.41348913e-02f, 7.54799768e-02f, -5.47158299e-03f, 7.02125356e-02f, -5.45719527e-02f, 6.28760755e-02f, 1.96073987e-02f, 9.58614275e-02f, 9.92107950e-03f,
  1.61240771e-02f, -1.61488727e-02f, 2.15297285e-02f, -1.08364923e-02f, -4.96014804e-02f, -3.05396151e-02f, 1.71506424e-02f, -1.55185368e-02f, -1.30321924e-02f, 1.87032595e-02f,
  1.02332318e-02f, 2.02606227e-02f, 5.52027412e-02f, -5.73444217e-02f, 4.03680503e-02f, 7.18219653e-02f, -8.04603621e-02f, 4.51814458e-02f, 4.87741716e-02f, 4.28749844e-02f,
  1.03571750e-01f, 8.68146680e-03f, 2.21633129e-02f, -2.72609144e-02f, 1.15743436e-01f, 7.43967146e-02f, 7.95077384e-02f, 4.38629836e-03f, 5.42641841e-02f, 2.94055324e-03f,
  -9.24934372e-02f, -3.01073641e-02f, 1.63794290e-02f, 2.56980136e-02f, -2.83169206e-02f, 3.92903090e-02f, -2.43554302e-02f, 3.95668596e-02f, -2.45579076e-03f, -7.83994049e-02f,
  -8.10595080e-02f, 1.90353245e-02f, 6.49917275e-02f, -8.54565427e-02f, -2.15369835e-02f, 3.37061696e-02f, 2.58425940e-02f, -5.54384515e-02f, 1.67617537e-02f, -7.42989220e-03f,
  7.06249893e-01f, 1.00733275e-02f, 1.74456108e-02f, 7.88941309e-02f, 2.53469571e-02f, -8.30452219e-02f, -2.88681574e-02f, 3.65646370e-02f, 8.87282118e-02f, -7.14513734e-02f,
  -7.48337060e-03f, 3.17055918e-02f, -1.09429955e-01f, 1.43387198e-01f, 1.59521624e-01f, -3.21241096e-02f, 1.38325363e-01f, 5.01632169e-02f, 6.00425117e-02f, -1.59777924e-02f,
  5.94597049e-02f, -1.32328225e-02f, 4.55468521e-02f, -5.20604402e-02f, 5.90071939e-02f, -9.23625454e-02f, -1.90350592e-01f, -7.68725649e-02f, 6.28933907e-02f, 4.00379114e-02f,
  1.07879922e-01f, -7.79297724e-02f, -6.46407576e-03f, -8.24403912e-02f, -5.90961054e-02f, -3.63802090e-02f, -1.41947530e-02f, -1.45085528e-02f, -1.84407309e-02f, 2.65400782e-02f,
  1.17491297e-02f, -2.41368660e-04f, -2.00327556e-03f, 1.51116466e-02f, 3.68511938e-02f, 8.44220538e-03f, 1.21767039e-03f, 1.22846412e-02f, -1.29743619e-02f, 7.37089291e-02f,
  -1.05050653e-02f, 1.28889466e-02f, -1.84830576e-02f, -5.84038198e-02f, -6.87447283e-03f, -3.47103067e-02f, -3.17696035e-02f, -7.30470717e-02f, 6.73381891e-03f, 2.46553048e-02f,
  -6.94979867e-03f, -1.70473661e-02f, -4.40813377e-02f, -3.34358849e-02f, 4.88329791e-02f, -7.37737566e-02f, 2.00526956e-02f, -4.25517820e-02f, 3.58813554e-02f, -5.58043271e-03f,
  -2.48759463e-02f, -7.72071397e-03f, 9.60334912e-02f, -2.92090792e-02f, -2.85955216e-03f, 2.95989197e-02f, 1.01299267e-02f, -3.66806500e-02f, -9.67191532e-03f, 2.53624246e-02f,
  1.16751678e-02f, 2.83112675e-02f, -5.66301048e-02f, -4.17713374e-02f, 7.95084424e-03f, 7.01334700e-03f, -1.46804785e-03f, 3.21523473e-03f, 3.08645726e-03f, -7.72574823e-03f,
  -1.72387764e-01f, -7.23909959e-02f, -2.47392617e-02f, 3.89886908e-02f, -4.41966020e-02f, 6.00541905e-02f, 6.80734962e-02f, -2.26156577e-03f, -4.03708890e-02f, -1.76684689e-02f,
  -6.17525987e-02f, -2.42642425e-02f, 1.65271806e-03f, 2.65471302e-02f, 3.95857617e-02f, -1.54411350e-03f, -1.91420112e-02f, -5.26597351e-03f, 3.78542170e-02f, 1.83018832e-03f,
  -1.40071651e-02f, -4.64782678e-02f, 3.92773561e-02f, -5.02656363e-02f, -1.13917757e-02f, -7.55940154e-02f, -2.34779138e-02f, 4.73784059e-02f, 3.08963880e-02f, -7.84788746e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.32008791e-01f, 1.19586989e-01f, 1.89696446e-01f, 1.70810282e-01f, -1.70483831e-02f, -1.49107903e-01f, -7.88797364e-02f, 8.00155625e-02f, 5.45607731e-02f, -2.48912908e-02f,
  6.69369474e-02f, 4.16390970e-02f, 1.79497913e-01f, 7.80751035e-02f, 2.48291805e-01f, 5.43964803e-02f, 1.09935381e-01f, -7.93035626e-02f, 9.43074897e-02f, 2.34459490e-01f,
  2.56315380e-01f, 1.57465413e-01f, 2.22430244e-01f, 6.04383228e-03f, -7.13554546e-02f, 1.25139236e-01f, 1.27777800e-01f, 3.78460363e-02f, 1.28368437e-02f, 5.50385937e-02f,
  -1.98359787e-01f, 3.64753231e-02f, -4.92571369e-02f, -5.80922253e-02f, 6.84291944e-02f, -9.84646529e-02f, -1.75099750e-03f, -1.78404327e-03f, -2.96773762e-02f, -2.63198558e-02f,
  -1.76300257e-02f, -2.33968180e-02f, 7.31729642e-02f, 2.72214189e-02f, -8.27674940e-02f, -2.51010563e-02f, -1.23972958e-02f, -1.87170468e-02f, -8.42194408e-02f, -9.08032507e-02f,
  4.10249904e-02f, -4.89753447e-02f, -1.29396236e-02f, -1.42814964e-01f, -4.62287292e-02f, -1.77559871e-02f, 9.33232345e-03f, 1.51500311e-02f, 1.26973800e-02f, -5.95615339e-03f,
  -9.23826322e-02f, 2.61629075e-02f, 1.57847479e-02f, -1.06497509e-02f, 6.05977885e-02f, 4.17803712e-02f, 9.13469642e-02f, 6.06371276e-02f, 4.23969626e-02f, 2.13114768e-02f,
  6.82364590e-03f, 8.59148502e-02f, 2.36693546e-02f, -3.75465825e-02f, 6.72177076e-02f, -8.33552629e-02f, -3.80997136e-02f, -6.76639378e-02f, 6.99904561e-02f, 2.21199486e-02f,
  -5.06945439e-02f, 5.29339239e-02f, 3.74268554e-02f, -4.35516983e-02f, -6.47640303e-02f, 2.47558393e-02f, 4.16296441e-03f, 3.32636610e-02f, -4.86266203e-02f, 1.25592217e-01f,
  2.27905754e-02f, 2.98245907e-01f, 5.93497679e-02f, -7.62769431e-02f, 1.85488525e-03f, -1.97282503e-03f, 3.23963538e-02f, 5.06957322e-02f, 5.82423210e-02f, 6.75678626e-02f,
  -7.03308508e-02f, 3.19076097e-03f, 3.99512239e-02f, 2.06241640e-03f, 1.94957107e-02f, 1.66967753e-02f, 2.00532321e-02f, 3.58575843e-02f, 9.91205946e-02f, 1.05749555e-01f,
  -4.65097092e-02f, -9.25109088e-02f, 2.79658996e-02f, -2.85890922e-02f, -4.58848588e-02f, 2.10323408e-02f, -1.02740387e-02f, -3.49953808e-02f, -1.81206334e-02f, 2.01731082e-02f,
  2.52207160e-01f, 1.91175163e-01f, 1.66493446e-01f, 1.68708086e-01f, -1.37311026e-01f, -2.49698356e-01f, -8.97512361e-02f, 3.45154956e-04f, -1.70049623e-01f, 1.39267165e-02f,
  1.89154949e-02f, 2.21541282e-02f, 2.43579336e-02f, 4.04983871e-02f, -2.47711223e-03f, -4.63373261e-03f, 1.44411430e-01f, 3.42697129e-02f, -3.96631146e-03f, 1.76514119e-01f,
  -1.84058156e-02f, -2.85970997e-02f, 1.64986670e-01f, 1.42385438e-01f, 8.98078233e-02f, 1.43243805e-01f, 1.96409032e-01f, 1.28378160e-02f, 3.12463194e-02f, -2.91958600e-02f,
  -1.30352974e-01f, -1.12024665e-01f, 3.47819626e-02f, -1.32156480e-02f, 1.13974877e-01f, 2.46604928e-03f, -6.67112740e-03f, 2.38648672e-02f, 1.12548480e-02f, 4.18674238e-02f,
  1.18378690e-02f, 6.52221143e-02f, -4.83967690e-03f, -4.36375663e-02f, -3.80554646e-02f, -1.99591201e-02f, -2.84096096e-02f, -1.92279406e-02f, 2.49775667e-02f, 5.99663556e-02f,
  7.03023514e-03f, -7.76105700e-03f, 4.07473277e-03f, 7.23233372e-02f, 3.42206694e-02f, 2.50839014e-02f, -3.56933624e-02f, 2.46163215e-02f, -3.67142223e-02f, -4.72499467e-02f,
  1.10897265e-01f, 1.35253817e-02f, 4.21872139e-02f, -6.80549443e-02f, 2.16452871e-03f, -5.70526198e-02f, -6.27482729e-03f, -6.01776764e-02f, -7.52476277e-03f, -3.52845788e-02f,
  2.54487824e-02f, 1.22719444e-02f, -1.02260306e-01f, -5.44676334e-02f, 8.35244358e-03f, -9.05904770e-02f, 2.63993591e-02f, 3.86477597e-02f, 4.17873114e-02f, -1.95794273e-02f,
  -2.88780238e-02f, 8.60106349e-02f, 8.10148492e-02f, 5.72787859e-02f, 1.92327835e-02f, 8.12613312e-03f, 4.00969647e-02f, 4.94047031e-02f, 8.11082777e-03f, 3.10855284e-02f,
  4.66286428e-02f, 2.56838650e-01f, 4.12556790e-02f, -1.06429078e-01f, -2.07966957e-02f, -2.07909998e-02f, -4.27663252e-02f, 1.62602086e-02f, 9.18079764e-02f, 3.39022838e-04f,
  -5.29792085e-02f, -4.77680527e-02f, -3.01704798e-02f, -8.56175087e-04f, -2.16962714e-02f, 7.63091445e-02f, -3.99109758e-02f, -2.07872447e-02f, -1.99831035e-02f, 1.26756169e-02f,
  7.48094078e-03f, -3.90593000e-02f, 9.92890075e-03f, 4.25536418e-03f, -6.21332927e-03f, 5.28907068e-02f, -1.44300787e-02f, 2.78871693e-02f, 5.83178140e-02f, 6.40489459e-02f,
  -1.77517399e-01f, 1.52385637e-01f, -1.52076945e-01f, 8.21631867e-04f, -8.30322355e-02f, -9.46576074e-02f, -1.44799829e-01f, 3.44919264e-02f, -2.46555638e-02f, 6.47530779e-02f,
  7.56933019e-02f, -2.04178654e-02f, 1.39070928e-01f, -7.17524514e-02f, -1.15825702e-02f, 5.53488955e-02f, -8.47368240e-02f, -1.17015630e-01f, -4.53964211e-02f, -1.60413776e-02f,
  -4.81632957e-03f, -1.14195511e-01f, -1.19298898e-01f, -5.63378334e-02f, -2.70127684e-01f, -3.46041508e-02f, -4.72174883e-02f, -1.23429760e-01f, -1.13024466e-01f, 2.79182866e-02f,
  -1.09268375e-01f, -6.05965517e-02f, -1.01120427e-01f, -5.71133532e-02f, -8.92426968e-02f, 1.35021433e-02f, -1.49317819e-03f, 6.18689060e-02f, 3.33034731e-02f, -5.13282605e-02f,
  4.16484438e-02f, 4.29579280e-02f, 3.22619788e-02f, 1.07433371e-01f, 6.47331327e-02f, 3.98515863e-03f, -1.95071138e-02f, -1.12475298e-01f, 2.93171518e-02f, -2.29212325e-02f,
  9.64041613e-03f, -8.90959054e-02f, -1.02079429e-01f, 1.16737455e-01f, -4.79675308e-02f, -8.38985369e-02f, 4.92536314e-02f, -1.52537329e-02f, 4.22858596e-02f, 2.23498922e-02f,
  -2.09945552e-02f, 4.15583737e-02f, -1.66520812e-02f, 3.42110842e-02f, 5.01797386e-02f, 1.27902096e-02f, 3.35739879e-03f, -4.52979766e-02f, -6.79124072e-02f, -7.75411204e-02f,
  -6.59692883e-02f, 6.65085204e-03f, 5.45038376e-03f, -8.76263604e-02f, -3.56410705e-02f, 3.75802331e-02f, -2.81088576e-02f, -1.05682546e-02f, 8.13911930e-02f, -6.69385493e-02f,
  -8.71755183e-03f, 2.92761922e-02f, -1.17945587e-02f, 5.78128286e-02f, 1.34184374e-03f, 3.24004106e-02f, -1.47779919e-02f, -1.85697097e-02f, -1.07376482e-02f, -6.29228801e-02f,
  2.38288231e-02f, -7.72656500e-02f, -8.65384415e-02f, -1.18787788e-01f, -9.44062546e-02f, 3.29294279e-02f, 3.31428982e-02f, -6.67910799e-02f, 6.44401181e-03f, 3.21113542e-02f,
  -2.63051670e-02f, -5.83232045e-02f, -6.39241785e-02f, 3.51002961e-02f, 1.02079675e-01f, 2.45274063e-02f, -3.90156209e-02f, 4.27283868e-02f, -1.74171403e-02f, 7.51668364e-02f,
  -5.29231643e-03f, 8.51365272e-03f, 1.08446106e-02f, -8.93607289e-02f, -4.95587252e-02f, -7.00218827e-02f, -4.37558740e-02f, 1.19615532e-02f, -4.42960188e-02f, -7.21301809e-02f,
  -1.35426253e-01f, -1.90056831e-01f, -4.32307601e-01f, -1.25062391e-01f, 1.67729740e-03f, 1.00125991e-01f, -7.48242587e-02f, -7.94141069e-02f, -3.00652295e-01f, 2.56250054e-01f,
  2.02549756e-01f, -2.90498495e-01f, -1.23588607e-01f, 1.89305305e-01f, -6.67827800e-02f, -4.36249152e-02f, 1.78998232e-01f, 7.80977160e-02f, -1.44873843e-01f, 1.42584639e-02f,
  -2.36103032e-02f, 3.62313300e-01f, -1.29336521e-01f, 2.05192640e-01f, 1.51791200e-02f, -4.95536402e-02f, 2.30799839e-01f, -5.86740002e-02f, 2.76518553e-01f, 7.73399174e-02f,
  8.73852670e-02f, -9.51352045e-02f, -1.08410351e-01f, -5.50961904e-02f, 5.66094294e-02f, 4.79110777e-02f, 4.17900942e-02f, -5.84720750e-04f, -1.11906916e-01f, -3.56261544e-02f,
  -1.25644151e-02f, -5.10985330e-02f, 8.90977606e-02f, -4.78013568e-02f, 2.50950418e-02f, 1.07356720e-02f, -2.47070473e-02f, -8.61593485e-02f, -1.14299305e-01f, -1.48033038e-01f,
  -1.13151118e-01f, -5.48524559e-02f, -6.20879218e-05f, -2.10180413e-02f, -1.02751166e-01f, 2.78871879e-02f, 5.33826686e-02f, -6.63155392e-02f, 4.57356237e-02f, 6.06627949e-03f,
  5.17768785e-02f, 4.65717390e-02f, -2.76567321e-02f, 2.35653669e-02f, -4.76094335e-02f, -1.24857982e-03f, -1.62386727e-02f, 7.25826109e-03f, -6.42437041e-02f, -3.74248647e-03f,
  2.83021759e-02f, 9.72644705e-03f, 3.39880511e-02f, 5.02315126e-02f, 1.57058872e-02f, -5.22500016e-02f, 3.16195302e-02f, 2.54122112e-02f, 2.08442658e-03f, 3.09151243e-02f,
  -5.07234409e-02f, -1.85021211e-03f, 3.42252618e-03f, 4.80442196e-02f, 7.72301406e-02f, -8.24389979e-02f, 9.81657505e-02f, 2.57702381e-03f, 1.48128411e-02f, -1.93071812e-02f,
  4.62235883e-02f, 6.45577461e-02f, 3.83238830e-02f, -4.25972380e-02f, 1.08337449e-02f, 5.95209189e-02f, -5.75875416e-02f, 2.02876236e-02f, 3.79105844e-02f, 2.61760131e-02f,
  8.83862227e-02f, 2.68202014e-02f, 5.10841794e-02f, 2.78528742e-02f, -5.70387430e-02f, 8.96702856e-02f, 6.87523931e-02f, -2.39679646e-02f, 3.51536162e-02f, 3.66197266e-02f,
  6.15705959e-02f, 3.70994844e-02f, -2.33934969e-02f, -6.17843717e-02f, 1.03944629e-01f, 6.78569078e-03f, -4.20704558e-02f, 4.37726779e-03f, -3.94951832e-03f, -2.26327870e-02f,
  -2.16791198e-01f, -8.20390284e-02f, 2.50550974e-02f, -6.53178319e-02f, -9.53444391e-02f, 1.20275058e-01f, -9.25203133e-03f, -4.93926369e-03f, -1.38943955e-01f, 6.85784146e-02f,
  1.30167648e-01f, -8.99881646e-02f, 8.19964781e-02f, 9.85585004e-02f, 3.41615975e-02f, 2.74089817e-02f, 3.10840420e-02f, 5.95645942e-02f, 5.15903011e-02f, -2.48945989e-02f,
  -5.45383543e-02f, -9.26694497e-02f, 6.89317584e-02f, -1.89222358e-02f, 3.64747550e-03f, -2.65307818e-02f, 1.07275531e-01f, 6.75113797e-02f, 2.12471504e-02f, 4.43735905e-02f,
  -3.39205787e-02f, 7.46777700e-03f, -4.10442315e-02f, -9.67399031e-02f, 8.03921148e-02f, -1.19921041e-03f, 7.51876384e-02f, -5.55814942e-03f, 3.03183775e-02f, -1.35751662e-03f,
  3.25539112e-02f, 3.99059653e-02f, -1.17799165e-02f, 7.64720291e-02f, 3.38760577e-02f, -1.67941372e-03f, -6.07255427e-03f, -3.61061804e-02f, -1.03553059e-02f, 7.45107010e-02f,
  -6.90844208e-02f, -7.12907463e-02f, -6.85840053e-03f, 8.34751576e-02f, 6.28291443e-02f, 5.82650416e-02f, -5.69513328e-02f, 3.47780585e-02f, -4.13662456e-02f, 5.99107482e-02f,
  -5.07879853e-02f, -3.42511721e-02f, -8.62496719e-02f, -1.03022508e-01f, -2.08101794e-02f, -2.78713331e-02f, 3.99230681e-02f, 1.08506270e-02f, -1.47169018e-02f, -5.56085221e-02f,
  -2.57621780e-02f, -4.25513461e-02f, -4.85023968e-02f, -6.84031248e-02f, -5.47639392e-02f, 6.82153041e-03f, 8.54382478e-03f, -4.41688392e-03f, -5.74910305e-02f, 4.81930710e-02f,
  -7.63874277e-02f, 5.53410053e-02f, -3.23256440e-02f, 3.73488814e-02f, 5.23379887e-04f, 6.69127256e-02f, -8.47647991e-03f, 2.47043651e-02f, 1.19529672e-01f, 1.94955077e-02f,
  -8.05687532e-02f, -1.68444768e-01f, -3.06112617e-02f, 1.77543275e-02f, -7.58718774e-02f, 6.42462745e-02f, -8.46595466e-02f, -7.97438994e-02f, 3.00355889e-02f, -1.00033367e-02f,
  7.73259923e-02f, 5.02820686e-02f, -9.90110040e-02f, 6.48863241e-02f, 6.32796735e-02f, 4.31980565e-02f, -4.12056297e-02f, -3.75091732e-02f, 3.21210101e-02f, -2.26992927e-02f,
  5.64952716e-02f, 6.19940162e-02f, 6.62239268e-02f, -1.09255137e-02f, -7.07170814e-02f, -4.89452779e-02f, -1.08138956e-01f, -1.46359410e-02f, -4.83429097e-02f, -4.61468548e-02f,
  -1.96983293e-01f, 1.03306780e-02f, -2.54808933e-01f, -9.32301730e-02f, -2.31426567e-01f, -2.23913919e-02f, -1.73944216e-02f, -2.94099655e-02f, -8.29065815e-02f, 1.69418618e-01f,
  1.03906788e-01f, -1.13258444e-01f, 1.17064960e-01f, 1.14689305e-01f, -5.79872131e-02f, 2.26345316e-01f, -1.26196668e-02f, 3.90836000e-02f, -1.29997050e-02f, 3.13407443e-02f,
  -2.59446856e-02f, 4.29771356e-02f, 7.44568110e-02f, 9.20979753e-02f, -1.20115407e-01f, -8.43440071e-02f, 8.26549307e-02f, -3.97427082e-02f, 8.01133290e-02f, -1.73429370e-01f,
  -1.04798339e-01f, -2.06364408e-01f, -4.02522348e-02f, 1.43914260e-02f, -3.51489522e-02f, -1.47555594e-03f, -1.98986176e-02f, 3.13719139e-02f, -6.70441538e-02f, 5.32577420e-03f,
  2.40875408e-02f, 1.06745504e-03f, 1.55667914e-02f, -9.17880759e-02f, 1.85624585e-02f, -1.19291864e-01f, -2.23647077e-02f, 5.11537530e-02f, 1.64077319e-02f, -1.86122954e-02f,
  -2.57507078e-02f, -1.26842419e-02f, -1.57829616e-02f, -4.14670818e-03f, -8.16581398e-02f, 4.55201343e-02f, -2.85012517e-02f, -1.78260375e-02f, -8.18236396e-02f, -1.14588112e-01f,
  3.80858816e-02f, 7.51083298e-03f, -6.22091815e-02f, 2.82130092e-02f, -5.51261120e-02f, -4.95545529e-02f, -3.20679434e-02f, -8.24096352e-02f, -2.22168230e-02f, 2.97034010e-02f,
  9.35750175e-03f, 1.42402453e-02f, -2.86768726e-03f, 1.07703537e-01f, 5.38389459e-02f, 9.34691355e-02f, 5.58086261e-02f, -2.08250619e-02f, -5.09909838e-02f, -1.47423975e-03f,
  2.19904818e-02f, 2.58198176e-02f, -6.73575625e-02f, 3.91380787e-02f, -3.89701687e-02f, 4.75330185e-03f, -3.17528211e-02f, 4.11066413e-02f, 7.15247914e-02f, 1.95035767e-02f,
  -1.38714552e-01f, -2.17185184e-01f, -2.90028248e-02f, -5.89074604e-02f, 2.59702969e-02f, -6.06371835e-02f, 2.50740331e-02f, -4.04956490e-02f, -4.17595841e-02f, -1.11532599e-01f,
  4.57451902e-02f, -7.50676617e-02f, -3.21616828e-02f, 7.34263286e-02f, -3.49506512e-02f, -6.96023107e-02f, -3.73723730e-02f, -1.00080319e-01f, -9.04674269e-03f, 7.34257838e-03f,
  -6.10970818e-02f, -4.18462083e-02f, 5.88044003e-02f, 4.15704846e-02f, 7.89128318e-02f, 1.64759532e-02f, -9.59351193e-03f, 4.60725464e-02f, -1.95585098e-02f, 6.86083455e-03f,
  -2.36239545e-02f, -3.63504030e-02f, 1.00391090e-01f, 2.56288461e-02f, 5.54521680e-02f, -9.31424126e-02f, -7.31444955e-02f, 7.90021196e-02f, 1.32671550e-01f, 1.96770784e-02f,
  5.24302153e-03f, -3.57468650e-02f, 5.22993766e-02f, -1.77855954e-01f, -1.33905113e-01f, -1.05889440e-01f, -1.81174964e-01f, -1.42902866e-01f, 5.05142622e-02f, -3.87878008e-02f,
  -1.13538764e-01f, -1.24219030e-01f, -1.45689189e-01f, 6.78420514e-02f, -6.18400238e-02f, -4.31672484e-02f, -4.91740145e-02f, -6.19392805e-02f, -5.24835587e-02f, -1.19714715e-01f,
  3.61892320e-02f, 4.20712344e-02f, -8.49155188e-02f, 7.83463717e-02f, 4.46906127e-02f, -3.44819687e-02f, -6.82562441e-02f, -3.67561430e-02f, 3.69819999e-02f, 9.91583392e-02f,
  -3.23085971e-02f, -1.09417003e-03f, 5.35777248e-02f, 2.16095131e-02f, -2.26934999e-02f, 8.59740898e-02f, -2.99274526e-03f, 6.86143115e-02f, -5.62908761e-02f, 5.46521470e-02f,
  9.63732749e-02f, 8.33786651e-02f, 9.98035446e-02f, -8.92341956e-02f, 1.36916647e-02f, 5.67101277e-02f, -5.35148568e-02f, -9.80984122e-02f, 6.70558065e-02f, -6.02916479e-02f,
  2.78256740e-02f, -3.21261100e-02f, -4.16074842e-02f, -7.56713599e-02f, 5.51735284e-03f, 3.79657326e-03f, 1.75608564e-02f, 3.78479585e-02f, -5.11957929e-02f, 2.67272443e-02f,
  -6.56789765e-02f, -9.10756588e-02f, 2.83993501e-02f, -6.91846609e-02f, 5.22072017e-02f, 7.76942074e-02f, -3.34959035e-03f, -1.03955185e-02f, 6.91825077e-02f, 8.99630657e-04f,
  1.92768481e-02f, 5.35295345e-02f, 2.22681593e-02f, -7.76248379e-03f, -1.13313003e-02f, 9.08838809e-02f, -2.02927012e-02f, -1.26009258e-02f, 4.81926799e-02f, -3.60088460e-02f,
  6.30928501e-02f, 4.82722335e-02f, 5.12580723e-02f, -9.25466418e-03f, 5.29032052e-02f, 5.89500740e-02f, 7.86149816e-04f, 7.61891773e-04f, -5.85707948e-02f, -6.07941449e-02f,
  -1.18725233e-01f, -2.86378991e-02f, 7.83193931e-02f, -6.17182255e-02f, 4.97290529e-02f, -1.07512318e-01f, 5.70971556e-02f, 8.10235515e-02f, 1.81602594e-02f, -5.24465777e-02f,
  1.67613141e-02f, -3.34940571e-03f, -1.78901590e-02f, 4.04604897e-02f, -7.56503865e-02f, -3.20655317e-03f, 2.57529672e-02f, -1.69140529e-02f, 5.03620282e-02f, 4.58654501e-02f,
  2.10884158e-02f, 3.18646401e-01f, -3.95641625e-02f, 7.87616149e-02f, -1.64942890e-01f, -6.73178360e-02f, -7.10356310e-02f, 4.32687141e-02f, -3.02084666e-02f, 2.94690039e-02f,
  7.97911286e-02f, 1.30410090e-01f, 5.37578911e-02f, 2.17470638e-02f, -6.33583125e-03f, -5.45711331e-02f, 8.38357285e-02f, 9.17233676e-02f, -1.07032299e-01f, 1.90789461e-01f,
  -3.63696250e-03f, 7.72554576e-02f, 1.77147374e-01f, 1.45035684e-01f, 1.01985626e-01f, 1.40088007e-01f, 2.60275036e-01f, 4.88116369e-02f, 1.41687602e-01f, -1.61322746e-02f,
  -2.83220299e-02f, 4.74621318e-02f, 1.31105045e-02f, -7.38471448e-02f, 6.18011169e-02f, -3.33169363e-02f, -8.70902762e-02f, 5.50747244e-03f, -5.15037850e-02f, -5.69635769e-03f,
  -2.73419507e-02f, 5.87053224e-02f, 1.09087033e-02f, -3.01174503e-02f, -7.41226673e-02f, 8.74055624e-02f, -1.98538415e-02f, 2.34933775e-02f, -9.24521498e-03f, -2.38244701e-02f,
  -8.55921861e-03f, 7.60074630e-02f, -4.19170149e-02f, 8.70435238e-02f, 6.72537163e-02f, 1.00423247e-02f, 4.80652042e-02f, 1.20538145e-01f, -7.59048834e-02f, 7.70739838e-02f,
  1.16141923e-01f, 3.91756035e-02f, -1.05711579e-01f, 1.24866543e-02f, 2.65468657e-02f, -1.18133035e-02f, 7.97897801e-02f, -1.86290722e-02f, -4.13628248e-03f, 1.02725010e-02f,
  2.43997909e-02f, -5.49865365e-02f, -5.96129633e-02f, 6.98822662e-02f, -6.15767762e-03f, -8.53447150e-03f, -5.31903468e-03f, -1.18453344e-02f, 5.30469529e-02f, 2.39530895e-02f,
  -1.64390784e-02f, -2.85584982e-02f, 2.59804353e-02f, -6.32639751e-02f, -3.26077044e-02f, -1.76024456e-02f, 4.61011790e-02f, -5.02780192e-02f, 6.25347421e-02f, 2.17873976e-02f,
  6.91242665e-02f, 2.17822060e-01f, 8.75086617e-03f, -5.15407063e-02f, 1.43679027e-02f, -2.19392348e-02f, -1.07209412e-02f, 8.81688073e-02f, 3.75524126e-02f, 1.00675151e-02f,
  1.20592147e-01f, 2.06181314e-02f, -5.37438132e-02f, 2.94665918e-02f, 1.02294475e-01f, -3.07798130e-03f, -1.62571110e-02f, 5.11994995e-02f, 1.15976028e-01f, 2.87272595e-03f,
  7.21535236e-02f, 1.62830781e-02f, 1.93114802e-02f, 8.16799179e-02f, 3.99227738e-02f, -6.88787922e-02f, 7.10779354e-02f, -5.18820025e-02f, 8.94779190e-02f, -6.15743175e-02f,
  -1.23038128e-01f, -3.38199995e-02f, 3.34642939e-02f, -1.62222549e-01f, 2.51228549e-02f, 8.16629454e-02f, -5.54130180e-03f, 1.35965496e-01f, -9.26353335e-02f, -1.53601319e-01f,
  -4.35556322e-02f, -1.12985715e-01f, 9.03753638e-02f, -1.65568277e-01f, 1.64244354e-01f, 3.16514224e-02f, -6.27836511e-02f, -1.38047665e-01f, 1.23685353e-01f, -2.14075055e-02f,
  -2.29477510e-02f, -1.22563437e-01f, -4.37444774e-03f, 8.73000547e-02f, -6.79111853e-02f, -4.13222685e-02f, -1.07917644e-01f, 1.51923463e-01f, -1.12218689e-02f, 6.19210824e-02f,
  -7.18998015e-02f, -2.10188046e-01f, -9.74685401e-02f, -7.23172575e-02f, -6.23801723e-02f, -1.17612913e-01f, 3.92045546e-03f, 3.93710993e-02f, -8.11373368e-02f, -3.22218016e-02f,
  -6.01575188e-02f, 2.52079554e-02f, 1.53577409e-03f, 8.68879706e-02f, 8.72817487e-02f, -6.17106259e-03f, 2.96449065e-02f, 7.40021989e-02f, 2.02466883e-02f, 3.49653363e-02f,
  5.16582914e-02f, 2.52963994e-02f, -2.34642215e-02f, -5.15059344e-02f, 4.85777967e-02f, 3.31013724e-02f, -7.41032213e-02f, 1.01108722e-01f, -6.21795245e-02f, -1.56630352e-02f,
  8.78164992e-02f, 5.76315895e-02f, -7.82884099e-03f, 1.09965354e-01f, 4.40342026e-03f, 1.34098176e-02f, -5.18275648e-02f, 6.77353423e-03f, -6.04519621e-02f, 8.06549639e-02f,
  1.68840252e-02f, -1.40548214e-01f, -5.94430007e-02f, 4.67507690e-02f, 6.99692890e-02f, -7.41647780e-02f, 1.98899508e-02f, 3.92496772e-02f, 1.03097335e-01f, 1.12617873e-01f,
  -5.44658527e-02f, -5.70336170e-02f, -1.13105386e-01f, -9.96997058e-02f, -1.71733703e-02f, -4.54919636e-02f, -5.95354475e-02f, 2.41169948e-02f, -5.64981140e-02f, 7.24583194e-02f,
  -1.28080562e-01f, -2.66046613e-01f, -1.26987442e-01f, -1.57007083e-01f, -5.70712201e-02f, -8.39612186e-02f, -1.53463287e-02f, -5.06322756e-02f, 1.43987229e-02f, -7.09436983e-02f,
  -4.19459902e-02f, -6.08505011e-02f, -8.48909691e-02f, -5.78146614e-03f, 1.41639905e-02f, -2.67108958e-02f, 6.42008409e-02f, -4.92813475e-02f, -9.31877457e-03f, 5.06473407e-02f,
  1.28438324e-02f, -7.39530101e-02f, 8.01303089e-02f, -4.97579277e-02f, -9.68715847e-02f, -4.11768332e-02f, 1.24032125e-02f, -6.50594905e-02f, -1.41340811e-02f, -4.00486439e-02f,
  -1.93383351e-01f, -3.02071750e-01f, -2.72028029e-01f, 1.00990757e-02f, 2.22467616e-01f, 1.14959270e-01f, -2.14559764e-01f, 3.48899588e-02f, -1.35565028e-01f, -1.30155295e-01f,
  6.02484494e-03f, -2.14967713e-01f, -3.37095618e-01f, -1.12009920e-01f, 1.26383141e-01f, -1.85470939e-01f, 1.10771716e-01f, 6.22044206e-02f, -1.39167398e-01f, -2.06853915e-02f,
  6.75733164e-02f, 2.04350755e-01f, -1.22621991e-01f, 1.95323735e-01f, -5.80464490e-02f, 1.08632393e-01f, 2.81810552e-01f, 1.80951767e-02f, 1.71158955e-01f, 1.77522793e-01f,
  -1.30441682e-02f, -1.28516376e-01f, -1.74281392e-02f, -1.76676866e-02f, 6.30557463e-02f, 3.69581617e-02f, -1.41248703e-02f, 3.96150956e-03f, 3.77015024e-02f, -3.24867889e-02f,
  -8.72848704e-02f, 1.56097477e-02f, -4.94788215e-03f, 1.85391773e-02f, -1.21432077e-02f, 1.02194257e-01f, 1.35971056e-02f, 2.79944073e-02f, 9.77310166e-03f, -8.34114403e-02f,
  -1.64992109e-01f, 7.09631434e-03f, -1.45627335e-02f, 4.66345809e-02f, -9.04967934e-02f, 3.49914562e-03f, 3.98023101e-03f, -1.06356129e-01f, 9.12441537e-02f, -4.92613092e-02f,
  3.94688360e-02f, 1.60985515e-02f, -2.04810239e-02f, 1.97044890e-02f, -1.87765434e-02f, 5.87351359e-02f, 8.92119035e-02f, 3.03218700e-02f, 3.06735057e-02f, -3.96197056e-03f,
  9.30028036e-02f, -2.02920474e-02f, -1.21955825e-02f, 3.90490703e-02f, -7.14923139e-04f, 8.57266132e-04f, 4.20195609e-02f, -4.95893508e-02f, 8.73326231e-03f, -5.70158660e-02f,
  2.82793678e-02f, 4.37601991e-02f, -5.47945453e-03f, -1.54434377e-03f, 4.30108160e-02f, -1.81580279e-02f, 4.36034147e-03f, -6.21506274e-02f, -3.08336485e-02f, 7.51981884e-02f,
  8.14464837e-02f, -2.82114819e-02f, -7.71433115e-02f, -1.27510149e-02f, 1.53185455e-02f, 6.82254955e-02f, 2.54626442e-02f, -2.25915257e-02f, -7.01955333e-03f, -5.97913703e-03f,
  1.05825782e-01f, 1.19954601e-01f, 2.69610411e-03f, 5.07102907e-02f, 9.17556211e-02f, -6.25630990e-02f, -3.23312916e-02f, 8.79052952e-02f, 6.78485930e-02f, -3.67755443e-03f,
  2.72917114e-02f, -5.02037555e-02f, 1.15015224e-01f, 4.35734130e-02f, 5.27131669e-02f, 4.13110256e-02f, 1.12851284e-01f, 1.00087531e-01f, -4.87379320e-02f, 9.92844719e-03f,
  -1.84725165e-01f, -2.45722439e-02f, -1.18037112e-01f, -1.89924866e-01f, 5.91227114e-02f, 3.39962393e-02f, -1.11806251e-01f, -6.37315288e-02f, -1.67183489e-01f, 7.01534227e-02f,
  3.32831102e-03f, -7.69401565e-02f, -7.04043582e-02f, -1.22991316e-01f, -2.01027587e-01f, -2.11694121e-01f, -3.67956772e-03f, -1.53623879e-01f, -1.32534742e-01f, -3.36918011e-02f,
  -9.91123170e-02f, -7.26357251e-02f, -5.03633469e-02f, 1.26397789e-01f, 1.05645083e-01f, 1.37812555e-01f, 1.60358757e-01f, 5.47028780e-02f, 7.78592080e-02f, 1.71381682e-02f,
  -1.89415306e-01f, -1.57786049e-02f, 2.41554249e-02f, -8.34233388e-02f, 7.82316402e-02f, 1.38419464e-01f, 5.67712002e-02f, -7.94785470e-02f, -2.85077933e-02f, 5.54831140e-02f,
  7.13929534e-02f, 2.62347404e-02f, -4.21720222e-02f, -1.03477035e-02f, -3.53268757e-02f, -1.89748071e-02f, -4.26900685e-02f, 1.83126554e-02f, 7.76460841e-02f, -4.77513969e-02f,
  4.02395949e-02f, 1.03597857e-01f, 8.30366164e-02f, 2.19711848e-02f, 1.04438849e-02f, 4.06465819e-03f, 4.42205183e-02f, -8.35382671e-04f, 1.15818627e-01f, -6.64088726e-02f,
  3.33463810e-02f, 1.91539507e-02f, -6.27006264e-03f, -4.80897874e-02f, -3.27615961e-02f, -1.49865989e-02f, -5.82651831e-02f, 3.12724672e-02f, 5.82171418e-02f, 4.02700864e-02f,
  6.21240921e-02f, -6.12304173e-02f, -8.34336802e-02f, -9.13033634e-02f, -4.38463548e-03f, 2.90238988e-02f, -9.41798929e-03f, 4.44688881e-03f, -7.40610063e-02f, 1.62897278e-02f,
  4.66797836e-02f, -6.60774261e-02f, 1.37051828e-02f, -2.70686243e-02f, 1.03282705e-02f, 2.73822504e-03f, -9.14182961e-02f, 2.10690126e-03f, 2.44602998e-04f, 6.45961659e-03f,
  2.34236382e-02f, 5.99796399e-02f, -5.30711561e-02f, 4.07052785e-02f, 8.20451230e-02f, 6.41925111e-02f, 3.18292119e-02f, -5.44545688e-02f, 2.75337063e-02f, -8.15413222e-02f,
  7.35786557e-02f, 8.27784464e-02f, 6.86987713e-02f, -2.59128623e-02f, -3.88920004e-03f, -5.00334874e-02f, -7.27636274e-03f, 2.37297174e-03f, 1.67542726e-01f, -1.07882116e-02f,
  6.52254224e-02f, 2.90973019e-02f, 1.70931465e-03f, -3.92192416e-02f, 7.89544210e-02f, 2.52796430e-02f, 6.31359294e-02f, -7.14086965e-02f, 4.42429706e-02f, 4.68392037e-02f,
  -2.42208645e-01f, 1.67202398e-01f, 6.42868504e-02f, -1.66733507e-02f, 4.72448654e-02f, 1.65178671e-01f, 1.50704816e-01f, 1.03852242e-01f, 3.43768485e-02f, 1.38760701e-01f,
  4.97751310e-02f, 4.23387960e-02f, 5.96119910e-02f, 1.00290570e-02f, 1.51102200e-01f, 1.21482322e-02f, 1.38475254e-01f, 4.64000180e-02f, 7.88352713e-02f, 5.34315705e-02f,
  -8.02404508e-02f, 5.87257333e-02f, -7.72702396e-02f, -9.78592038e-02f, -7.35694319e-02f, -1.57733992e-01f, -7.76507184e-02f, -2.60039959e-02f, -1.95157137e-02f, 4.68508005e-02f,
  9.16308910e-02f, -6.90490305e-02f, -3.65686268e-02f, 4.22563143e-02f, -4.66231816e-02f, -6.49817288e-03f, -5.61017729e-02f, -4.18487228e-02f, -2.15742756e-02f, 2.14161687e-02f,
  5.72760813e-02f, -4.75534536e-02f, 8.80631059e-02f, -1.42983543e-02f, 2.58767419e-02f, -8.33628848e-02f, -6.09476790e-02f, -4.99901064e-02f, 8.76786280e-03f, 4.57610749e-02f,
  6.25875965e-02f, 5.08213341e-02f, -3.66511047e-02f, -1.35323685e-02f, -1.04426323e-02f, 6.86552078e-02f, -2.13459786e-03f, 6.03461266e-02f, -8.35267128e-04f, 1.02123886e-01f,
  -3.30033265e-02f, 1.43653695e-02f, -2.04079654e-02f, 5.56314364e-03f, -6.50301874e-02f, -1.16158566e-02f, 6.64491439e-03f, -6.62004948e-02f, -1.91978328e-02f, -6.00117445e-02f,
  -3.48825753e-02f, -6.69511035e-02f, -3.10768578e-02f, 4.78680655e-02f, 5.80176376e-02f, 7.44651109e-02f, 3.85153182e-02f, 5.58294281e-02f, 2.65650228e-02f, 1.60222705e-02f,
  5.72679751e-02f, -3.30286734e-02f, -3.52861919e-02f, 6.65512905e-02f, 3.91887240e-02f, -3.20989196e-03f, -9.28840041e-02f, -3.74180311e-03f, -7.78089557e-03f, 8.81401971e-02f,
  1.20783009e-01f, 7.13226646e-02f, -9.95096099e-03f, 6.51690597e-03f, -3.16878930e-02f, -2.37250850e-02f, 2.95365206e-03f, 4.41702642e-02f, 1.32073492e-01f, 6.83715916e-04f,
  -3.74595239e-03f, -7.01145008e-02f, 6.13497421e-02f, -1.50363622e-02f, -5.93052879e-02f, 6.08362034e-02f, 1.43320095e-02f, 7.71560296e-02f, 2.08123829e-02f, 4.85250689e-02f,
  -8.78043324e-02f, -2.17966046e-02f, 9.05235782e-02f, 5.15329652e-02f, -2.29893588e-02f, -4.96461615e-02f, -7.65708089e-03f, 3.00553907e-02f, 7.46668279e-02f, -6.21883459e-02f,
  -6.19161427e-01f, 2.52412170e-01f, -1.59248278e-01f, -3.06231171e-01f, 4.95641157e-02f, -1.71094641e-01f, -7.33768120e-02f, -7.98619527e-04f, -9.83628780e-02f, 1.09136455e-01f,
  1.21443078e-01f, -2.21539289e-01f, 1.76171988e-01f, 8.01954642e-02f, -3.95738512e-01f, 1.16903596e-01f, -7.08564520e-02f, -1.14644907e-01f, 4.78565171e-02f, -4.53886464e-02f,
  -1.13011472e-01f, 1.79876313e-01f, -6.71805739e-02f, 2.55993128e-01f, -1.34227604e-01f, -4.03827615e-02f, -5.47441281e-02f, 1.98147044e-01f, -1.22272000e-01f, -3.03776953e-02f,
  -3.68393958e-02f, -6.15116172e-02f, -2.87389811e-02f, -1.55154094e-01f, -1.45807639e-01f, -1.27729267e-01f, -8.24593380e-02f, 4.91946861e-02f, -6.85520023e-02f, -1.02758184e-02f,
  4.97748889e-03f, -2.57186666e-02f, -9.13994089e-02f, 4.25281972e-02f, -8.65146965e-02f, 2.98445262e-02f, 2.39793379e-02f, -1.21672386e-02f, -1.79235190e-02f, 2.45369803e-02f,
  3.91247571e-02f, -5.62513508e-02f, -3.47948484e-02f, -6.23063482e-02f, 3.55766825e-02f, -4.11926862e-03f, -4.52413550e-03f, 1.50277223e-02f, -9.53188464e-02f, -5.58123849e-02f,
  -3.83518450e-02f, -1.09350290e-02f, 5.85221201e-02f, 3.25737707e-02f, 3.06640249e-02f, 4.30445597e-02f, 1.17684277e-02f, 1.40153582e-03f, 2.83772945e-02f, 6.68032914e-02f,
  -6.70346394e-02f, 4.78184074e-02f, 4.23104577e-02f, 2.26608608e-02f, -6.28240705e-02f, -2.67451052e-02f, -3.67734283e-02f, -3.80292302e-03f, 4.16153371e-02f, -1.64771583e-02f,
  4.63917442e-02f, -1.71339568e-02f, 6.36236221e-02f, 3.21702920e-02f, 4.40600961e-02f, 4.38828170e-02f, 1.22950235e-02f, 7.32017979e-02f, -3.36567126e-02f, -2.78847087e-02f,
  -2.58108437e-01f, -1.14224873e-01f, -7.70440698e-03f, -1.01345137e-03f, -6.63174316e-02f, 1.83220077e-02f, 4.82683210e-03f, 4.64461837e-03f, -7.61213750e-02f, -3.17986198e-02f,
  -1.45974010e-01f, -3.00508877e-03f, -9.69941467e-02f, 8.15972239e-02f, 6.06364422e-02f, 5.26766591e-02f, 4.07027751e-02f, 4.94851246e-02f, -4.52290801e-03f, -7.97778517e-02f,
  -1.15431912e-01f, -1.98387355e-02f, -1.05867758e-02f, 4.87689227e-02f, -2.04197448e-02f, -4.06615622e-02f, -6.84275627e-02f, -3.90641801e-02f, 1.31989419e-02f, -1.42865404e-02f,
  -7.46069625e-02f, -2.66910732e-01f, 2.43545264e-01f, -2.26030603e-01f, 1.35472968e-01f, 2.34299406e-01f, 2.39383057e-01f, -1.73171520e-01f, -3.41480255e-01f, -2.96609253e-01f,
  -8.61756057e-02f, -6.33396506e-02f, 2.15643346e-01f, -2.11202219e-01f, 4.50660557e-01f, 1.69020548e-01f, -8.79485607e-02f, -1.53868854e-01f, -2.56805271e-02f, -7.21471980e-02f,
  2.74646133e-02f, -2.03061789e-01f, 2.43209153e-01f, -1.59421191e-01f, -7.56521672e-02f, -9.47110057e-02f, -2.32560616e-02f, 1.97247103e-01f, -3.80713716e-02f, 8.66109282e-02f,
  -1.83735356e-01f, -2.26947218e-01f, 6.46667322e-03f, -4.04445305e-02f, -5.95932081e-02f, 1.40172197e-02f, -2.91507505e-02f, 1.58837244e-01f, -3.50036807e-02f, -1.59417000e-02f,
  6.48859814e-02f, -2.67815292e-02f, -6.87069353e-03f, -4.29731496e-02f, -3.32470760e-02f, -3.27086039e-02f, 2.23194482e-03f, 1.53436875e-02f, -3.40327062e-02f, 4.94651049e-02f,
  7.05271959e-02f, -5.51321879e-02f, -9.73806344e-03f, -4.99291569e-02f, -1.45231010e-02f, -6.08207062e-02f, 2.08442081e-02f, 7.07323924e-02f, 4.18010578e-02f, -1.01191916e-01f,
  -5.04557323e-03f, 5.25588505e-02f, -4.48066033e-02f, -3.79397087e-02f, -3.24079394e-02f, -3.39830779e-02f, -4.21241410e-02f, -2.61928942e-02f, 3.12595698e-03f, -1.27074216e-02f,
  -2.59277178e-03f, -2.39607003e-02f, -1.02285165e-02f, 6.63483841e-03f, -1.01983063e-01f, -1.10707819e-01f, -3.13081010e-03f, 2.47000400e-02f, -3.33017036e-02f, -4.51367758e-02f,
  1.59667321e-02f, 2.28951722e-02f, 2.99576018e-02f, 6.64468780e-02f, 1.76594574e-02f, 8.56999829e-02f, -1.11328261e-02f, 1.39396545e-02f, 4.87414654e-03f, -8.13197903e-03f,
  -2.50521660e-01f, -2.83158094e-01f, -2.43951064e-02f, -1.13421544e-01f, -1.88990142e-02f, -3.22108865e-02f, 3.81170698e-02f, -5.48271928e-03f, -8.27928334e-02f, -4.10928652e-02f,
  -8.85609314e-02f, 4.07357663e-02f, 9.45887819e-04f, -3.54095884e-02f, -1.46130081e-02f, -8.06392208e-02f, -7.49501139e-02f, -5.91213070e-02f, -5.81981204e-02f, -3.81316021e-02f,
  5.35812182e-03f, 3.50860730e-02f, 2.42947023e-02f, 2.64253262e-02f, 2.61867810e-02f, -2.17981450e-02f, -1.35442510e-03f, -2.64091534e-03f, 9.96357352e-02f, 3.74132134e-02f,
  -1.32484064e-01f, 2.95410901e-02f, 1.18186720e-01f, -1.53702483e-01f, 2.48202449e-03f, -1.12270691e-01f, -1.84514642e-01f, 7.99145997e-02f, 2.16935351e-02f, -1.14699781e-01f,
  -1.20370775e-01f, 1.72900736e-01f, 1.26666278e-01f, -1.03953138e-01f, 2.29097083e-02f, 2.91992500e-02f, -5.48395775e-02f, -4.70699221e-02f, -1.71637852e-02f, -3.31483595e-02f,
  -8.89702141e-02f, -2.22386047e-01f, -4.65124324e-02f, -5.59809767e-02f, -1.23548299e-01f, -6.50086626e-02f, -2.05757620e-04f, 6.61550909e-02f, -4.64685336e-02f, -2.06470527e-02f,
  7.42080212e-02f, -2.56792288e-02f, 1.22017018e-01f, 5.88502996e-02f, 4.80069220e-02f, -3.51194069e-02f, -2.41928529e-02f, 7.54768401e-02f, -6.54374659e-02f, -4.62551825e-02f,
  -1.17465584e-02f, -2.35307794e-02f, -5.29158413e-02f, -7.69583210e-02f, -7.60977622e-03f, 3.38908508e-02f, -6.37835683e-03f, 5.75875491e-02f, 5.39592206e-02f, -1.94301251e-02f,
  -4.08185162e-02f, 9.50850621e-02f, -1.05033025e-01f, -6.05796129e-02f, -5.06075807e-02f, 6.31066561e-02f, -8.60231370e-02f, -7.05157220e-02f, 2.85332743e-02f, 4.00441103e-02f,
  -1.88916214e-02f, -2.78170481e-02f, -3.21112759e-02f, -8.48146752e-02f, 7.29704201e-02f, -2.52664573e-02f, -3.03218737e-02f, -7.75634870e-02f, -4.70260344e-02f, -2.60514207e-02f,
  6.82401434e-02f, 1.05246678e-01f, 2.96639781e-02f, -7.56121725e-02f, 3.57158743e-02f, 6.44993910e-04f, 4.71735559e-02f, 3.37255597e-02f, -8.33098739e-02f, 6.32593557e-02f,
  -5.25567681e-02f, 1.04316408e-02f, -2.76448745e-02f, -3.35723124e-02f, 7.71742873e-03f, -8.70147534e-03f, -2.58853957e-02f, 6.36537969e-02f, 8.88994783e-02f, -3.75301279e-02f,
  7.10587353e-02f, -1.67484552e-01f, 1.02318496e-01f, 3.31385585e-04f, -1.99831743e-02f, -1.11135608e-02f, -7.74650425e-02f, 5.74642271e-02f, 3.86796668e-02f, 2.93703489e-02f,
  -3.53136472e-02f, -7.04159513e-02f, 6.33560587e-04f, 9.92994905e-02f, 2.03100517e-02f, -2.89829113e-02f, -1.81446094e-02f, -6.06365502e-02f, -9.01289750e-03f, 6.66561117e-03f,
  8.56154040e-02f, 2.52481699e-02f, -3.22821923e-02f, 8.70429352e-03f, -6.10281825e-02f, -7.49519244e-02f, 3.00873723e-02f, 9.89070237e-02f, 2.64083240e-02f, -4.88736667e-02f,
  -3.91399302e-02f, 7.79673383e-02f, 6.57239482e-02f, 1.46839082e-01f, -1.80049852e-01f, -3.00400913e-01f, -3.69604111e-01f, -5.78161934e-03f, -8.44312273e-03f, -1.25533164e-01f,
  -1.13129035e-01f, 2.23164260e-01f, -1.09180346e-01f, 1.55624915e-02f, -9.15288255e-02f, -1.44514933e-01f, -3.72588038e-02f, -4.31009792e-02f, -1.67363125e-03f, -2.70296969e-02f,
  1.80602014e-01f, -5.80469668e-02f, 1.54491708e-01f, 1.89087018e-01f, 1.10464200e-01f, 1.35784268e-01f, 1.39734283e-01f, 8.00568331e-03f, 1.44920170e-01f, 1.51176587e-01f,
  -1.19494990e-01f, 2.94183120e-02f, -3.98090284e-04f, 1.18131302e-01f, -1.21254757e-01f, -3.18625830e-02f, 1.97450873e-02f, 7.05264807e-02f, 3.69779542e-02f, -9.48285218e-03f,
  -4.71786642e-03f, 6.71689734e-02f, 6.74196705e-02f, -4.64266837e-02f, 7.01879412e-02f, -1.40153570e-02f, 1.17992610e-01f, 7.47643486e-02f, 7.06894994e-02f, -1.20093133e-02f,
  -1.21124173e-02f, -8.43374617e-03f, -1.47393076e-02f, 1.05727643e-01f, 1.22061878e-01f, -4.36416715e-02f, -1.05750998e-02f, 6.87894924e-03f, -6.20508231e-02f, 3.16558778e-02f,
  -3.57350744e-02f, -4.61481102e-02f, 4.88474630e-02f, -3.23947743e-02f, 3.87797207e-02f, 2.25342773e-02f, -2.89057232e-02f, -2.41748858e-02f, 7.88834989e-02f, -1.31252632e-01f,
  2.21444983e-02f, 6.12540506e-02f, 3.32061909e-02f, 2.75333934e-02f, -4.40825969e-02f, -4.04157192e-02f, -1.86045002e-02f, 1.28398882e-03f, -3.10055930e-02f, 9.23501626e-02f,
  -5.23773432e-02f, -2.29125135e-02f, -8.01011547e-03f, 1.10039683e-02f, -4.39733863e-02f, 6.77783927e-03f, 4.19147722e-02f, 3.08568105e-02f, 6.54174536e-02f, -5.56842536e-02f,
  6.44691512e-02f, -2.52700821e-02f, -1.74228922e-02f, 1.01265505e-01f, 1.13908388e-02f, -5.65585792e-02f, -2.74121743e-02f, 6.10660315e-02f, 7.59333745e-02f, -1.00975670e-03f,
  8.01829547e-02f, -3.98750342e-02f, -3.37111838e-02f, 9.58090946e-02f, 8.15344527e-02f, -2.40802225e-02f, 5.30926920e-02f, 8.77363384e-02f, -2.92333663e-02f, 5.75607382e-02f,
  5.76229505e-02f, -1.71885416e-02f, -1.00365402e-02f, 6.74314797e-02f, -1.90324057e-02f, -8.38197768e-02f, -1.31283496e-02f, 1.44800926e-02f, -4.36877310e-02f, -1.23627996e-02f,
  -2.16307119e-01f, -1.64376631e-01f, -3.08415979e-01f, -3.59024704e-02f, 9.31448191e-02f, -9.98967141e-02f, -1.33995309e-01f, -3.06056105e-02f, -1.62137330e-01f, -1.39888480e-01f,
  2.66473973e-03f, -8.05020407e-02f, -1.00660101e-01f, -1.92700059e-03f, 2.30133552e-02f, -1.03851058e-01f, -6.89853802e-02f, -3.67178656e-02f, 5.28550670e-02f, 5.21752285e-03f,
  7.90913925e-02f, 6.79869726e-02f, -1.49258912e-01f, 2.66129434e-01f, -9.99598727e-02f, 3.28977667e-02f, 1.04923777e-01f, 5.65724522e-02f, 1.09449081e-01f, 1.82472959e-01f,
  -1.08889140e-01f, -1.37089238e-01f, -2.38641482e-02f, -4.76501025e-02f, 2.85860822e-02f, -6.90602213e-02f, 1.82062611e-02f, 8.42002928e-02f, 2.81610247e-02f, -8.28693211e-02f,
  -6.82675764e-02f, -1.53060798e-02f, 1.16966814e-01f, -4.67309840e-02f, 2.81387847e-02f, -5.72134135e-03f, -5.01538403e-02f, -9.49520767e-02f, 2.50314903e-02f, 3.97889242e-02f,
  -2.45967302e-02f, -7.01830313e-02f, -5.19063547e-02f, -2.87717581e-02f, 1.65189188e-02f, 1.70724895e-02f, -3.71972322e-02f, 1.53094595e-02f, 4.02502604e-02f, 3.17642204e-02f,
  1.03280097e-01f, 4.20944542e-02f, -2.46360083e-03f, 1.20712481e-02f, 2.29297318e-02f, 5.79764731e-02f, 8.18522722e-02f, 4.52987067e-02f, 5.06649204e-02f, -5.53204827e-02f,
  8.80648568e-03f, 8.01256765e-03f, 1.53575297e-02f, 1.19807757e-02f, 4.74955253e-02f, 3.10489088e-02f, 1.09335538e-02f, -2.14253590e-02f, 2.92615313e-02f, -2.24080663e-02f,
  -5.33945858e-02f, 1.89255308e-02f, 2.90741920e-02f, -4.18521668e-04f, -4.11677780e-03f, 3.39890011e-02f, -2.29466613e-02f, -4.69741113e-02f, 1.25265038e-02f, 1.51388356e-02f,
  -1.38958439e-01f, -1.21152177e-01f, -3.35157998e-02f, 8.76467768e-03f, 3.84354144e-02f, -4.02874723e-02f, 5.92053421e-02f, -4.50724475e-02f, -3.50494906e-02f, 2.76744686e-04f,
  5.44005167e-03f, 2.73089558e-02f, -1.55441463e-02f, -1.87451914e-02f, -2.90358011e-02f, -9.49284881e-02f, -2.09232438e-02f, -7.77134672e-02f, -1.73472501e-02f, 1.17318012e-01f,
  -9.45285056e-03f, 1.61998756e-02f, 4.90270592e-02f, 9.99360606e-02f, -1.30307414e-02f, -3.60165052e-02f, 2.16259696e-02f, 9.77394730e-02f, 1.02330767e-01f, 5.88530004e-02f,
  1.88448709e-02f, 1.11613773e-01f, -1.54682979e-01f, 7.51806274e-02f, -1.21890895e-01f, 1.66341811e-01f, 6.56512454e-02f, 4.69492225e-04f, 6.47177780e-03f, 1.52778283e-01f,
  1.26270473e-01f, -8.41889903e-02f, -2.43775994e-02f, 1.87102303e-01f, 1.32501632e-01f, 4.47754860e-02f, 1.68359399e-01f, 1.49509579e-01f, -7.82486200e-02f, -5.50611913e-02f,
  5.61196245e-02f, 8.09829757e-02f, -3.15277427e-02f, 4.63257497e-03f, -9.79143567e-03f, -4.38271947e-02f, 8.19424838e-02f, -1.13996170e-01f, 7.29196966e-02f, 3.01830843e-03f,
  8.68650973e-02f, -4.55364920e-02f, 5.81833534e-02f, -1.14763260e-01f, -6.21602871e-03f, -2.84268893e-02f, -6.98548108e-02f, 2.72490364e-02f, -6.00110441e-02f, -6.05798438e-02f,
  2.47612800e-02f, -1.36756841e-02f, 9.40563381e-02f, -7.23242909e-02f, -7.34306648e-02f, -6.34310469e-02f, -7.72801861e-02f, -9.54708457e-02f, -6.34362698e-02f, -3.76699567e-02f,
  -2.11691074e-02f, 3.38207595e-02f, 5.10129258e-02f, 2.29470432e-02f, 4.11724299e-02f, 1.86251570e-02f, -4.83023673e-02f, -2.12587528e-02f, 2.35365285e-03f, 2.47805212e-02f,
  1.37985814e-02f, 4.77626398e-02f, -3.66250984e-02f, -5.99143729e-02f, 7.71239549e-02f, -4.70156111e-02f, 8.56344178e-02f, -3.43194045e-02f, -6.38492927e-02f, 6.60044849e-02f,
  -9.39361565e-03f, -1.10982601e-02f, 4.33850624e-02f, -2.10661963e-02f, 7.16476813e-02f, -5.59815355e-02f, -4.70567346e-02f, 9.54824388e-02f, -3.70069779e-02f, -2.70315781e-02f,
  6.13279454e-02f, 7.09397718e-02f, 1.16401546e-01f, 3.69045362e-02f, 6.38612881e-02f, -2.63155103e-02f, 5.92796654e-02f, -2.74180174e-02f, -5.65598868e-02f, -4.92161103e-02f,
  8.23886227e-03f, 1.95951909e-02f, -4.16671298e-02f, -2.60106362e-02f, 6.56884834e-02f, -9.25325416e-03f, 5.51448576e-02f, -3.15605514e-02f, -3.51635851e-02f, 4.68318649e-02f,
  -1.18651427e-02f, -5.26021048e-02f, 3.72851491e-02f, -7.94803500e-02f, 6.41768798e-02f, -1.89134981e-02f, 3.70252356e-02f, 3.05238571e-02f, 9.45603773e-02f, 4.32809535e-03f,
  -9.57094505e-03f, 6.76954165e-04f, -3.94533239e-02f, 6.13746643e-02f, 1.51492544e-02f, -8.19454938e-02f, 1.11483643e-02f, -1.05113968e-01f, 7.53665641e-02f, -6.48681745e-02f,
  -3.32686231e-02f, 1.46734267e-01f, -3.14554349e-02f, -8.30111839e-03f, 1.29467949e-01f, 1.28237322e-01f, 6.04370460e-02f, -3.03179845e-02f, 5.31479008e-02f, 5.72876446e-02f,
  2.67630611e-02f, 2.77099535e-02f, 1.04356468e-01f, 1.80450287e-02f, 6.00657985e-02f, 6.85888603e-02f, 4.26162295e-02f, 1.11347929e-01f, -3.11972424e-02f, 8.86652321e-02f,
  4.22947854e-03f, -2.33812779e-02f, 6.80275960e-03f, -1.44902151e-03f, -1.21168036e-03f, -6.34997189e-02f, -9.67538357e-02f, -8.61099660e-02f, 8.75526574e-03f, -8.60100389e-02f,
  7.00803357e-04f, -7.03739151e-02f, -5.58827072e-03f, -5.10191619e-02f, 5.19542508e-02f, 2.47342642e-02f, 7.34747127e-02f, -1.01301260e-01f, 6.60489686e-03f, -6.34325147e-02f,
  9.33529511e-02f, -1.86459105e-02f, -8.58317018e-02f, 9.46466345e-03f, -6.89636618e-02f, -6.90102056e-02f, -5.53681888e-02f, 1.01570226e-01f, 3.89682390e-02f, 3.38404886e-02f,
  6.60241907e-03f, 7.79710859e-02f, -4.98943217e-02f, 1.83465835e-02f, -1.05575129e-01f, 8.85719713e-03f, -4.90667438e-03f, 5.43160029e-02f, 5.00364415e-02f, 9.95374843e-02f,
  -9.20000374e-02f, 7.26723596e-02f, 5.43831624e-02f, -1.04578577e-01f, 5.72183616e-02f, -1.25939539e-02f, 5.51877450e-03f, 3.35941985e-02f, -4.32083793e-02f, -4.48310673e-02f,
  -9.93327349e-02f, -2.72769909e-02f, -1.06464341e-01f, -4.11433838e-02f, 4.31556255e-02f, 6.60975054e-02f, -9.13887098e-02f, -6.47093728e-02f, -1.15858596e-02f, 2.42019501e-02f,
  8.36217478e-02f, 4.10027467e-02f, -4.28683683e-02f, 4.86526676e-02f, 3.52420770e-02f, -5.20423390e-02f, -7.04723736e-03f, -8.03140085e-03f, 6.65872619e-02f, 3.00581828e-02f,
  7.84158334e-02f, -1.66171882e-02f, -8.36106688e-02f, -2.78971717e-02f, 6.23839684e-02f, 3.08911838e-02f, -9.84394550e-02f, -3.90610658e-02f, -2.70361155e-02f, 2.20112503e-02f,
  -5.35535961e-02f, 9.04903561e-02f, -6.44281060e-02f, -6.53492585e-02f, 7.95186460e-02f, -6.04227372e-02f, -8.21824670e-02f, 7.61126867e-03f, 6.80535734e-02f, -2.53335685e-02f,
  1.26921367e-02f, -4.87384051e-02f, -4.92010564e-02f, 3.22897211e-02f, -2.16036309e-02f, -7.48051852e-02f, -3.02563105e-02f, 5.58980480e-02f, 5.50008677e-02f, 5.75739257e-02f,
  7.58404955e-02f, -7.46676922e-02f, -2.27587476e-01f, -7.99812824e-02f, -1.45274490e-01f, -3.67000788e-01f, -3.23689163e-01f, -2.55349874e-01f, -6.63419347e-03f, -1.00379080e-01f,
  -1.20636210e-01f, 1.20833740e-01f, 5.19934706e-02f, -1.70513168e-01f, 2.73365468e-01f, 1.34279579e-01f, -2.79893607e-01f, -1.14165030e-01f, -7.77869970e-02f, -2.41198704e-01f,
  -2.88724247e-02f, -1.44757882e-01f, 4.89342259e-04f, -1.53482780e-01f, -1.47650182e-01f, -1.37628261e-02f, 1.70962527e-01f, -1.60030454e-01f, -1.91499636e-01f, 9.44753271e-03f,
  -6.04076535e-02f, 2.55612936e-02f, -2.47795833e-03f, -3.48798148e-02f, 2.11660270e-04f, 2.31145900e-02f, -4.37337253e-03f, 7.45676607e-02f, -1.47812506e-02f, -1.47775542e-02f,
  -3.35388258e-02f, 6.13382794e-02f, 1.67291220e-02f, 9.31918770e-02f, -5.14569879e-02f, -1.78064834e-02f, 2.49364804e-02f, -6.83620647e-02f, -5.07164607e-03f, -2.18242388e-02f,
  -3.87007408e-02f, 1.68505460e-02f, -3.06455195e-02f, 9.31419656e-02f, -6.48794835e-03f, -1.21906497e-01f, 7.23605305e-02f, 9.51992571e-02f, 3.44224758e-02f, 1.85593858e-03f,
  2.17792094e-02f, -5.19320695e-03f, 2.93906238e-02f, -1.02566928e-01f, -2.98851524e-02f, 2.49046832e-02f, 1.00014126e-02f, 6.21028505e-02f, -1.58606488e-02f, -1.08640110e-02f,
  -3.86213101e-02f, 3.30483466e-02f, 2.79448219e-02f, -3.72273698e-02f, -5.15010543e-02f, -6.49227947e-02f, 2.31303051e-02f, -3.41921523e-02f, -4.46653850e-02f, -1.30214235e-02f,
  1.86081585e-02f, 5.24524860e-02f, 4.51785438e-02f, -3.51316929e-02f, -7.18719065e-02f, 5.75687848e-02f, 4.66565974e-02f, 3.17669213e-02f, 4.09940667e-02f, 2.88543720e-02f,
  -9.96549875e-02f, -3.85153480e-02f, -3.38172540e-02f, 1.11884503e-02f, 3.34722474e-02f, -2.30084825e-02f, -4.34447639e-02f, -4.63549308e-02f, -8.66065398e-02f, 3.46307666e-03f,
  -7.05140755e-02f, 7.82202184e-02f, -1.15024708e-02f, -3.97599041e-02f, -1.49842380e-02f, 3.54823805e-02f, -1.43398633e-02f, 6.87112957e-02f, -3.40021737e-02f, -3.95514034e-02f,
  2.68386095e-03f, 1.86267830e-02f, 5.90956397e-02f, -1.12637570e-02f, 3.03220712e-02f, -2.24080551e-02f, 8.38700309e-02f, -4.80313739e-03f, 7.61822937e-03f, 1.05514983e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -2.73186387e-03f, -5.54441065e-02f, -1.28860082e-02f, 3.81518304e-01f, 2.30641216e-02f, 8.30674767e-02f, 1.40846059e-01f, 4.34695259e-02f, 1.31805673e-01f, 1.64804772e-01f,
  1.12715952e-01f, 3.82052660e-02f, 2.45132193e-01f, 3.00143421e-01f, 2.19111487e-01f, 3.54344696e-01f, 1.94708288e-01f, 3.25682536e-02f, 2.08156109e-02f, -7.49460459e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.22131608e-01f, 1.53147867e-02f, 2.94953108e-01f, 2.13251770e-01f, 6.80734366e-02f, -1.18661992e-01f, -3.90345693e-01f, 1.81963637e-01f, 3.04761171e-01f, 1.92259520e-01f,
  -1.52017653e-01f, -1.85840979e-01f, -3.45419198e-02f, -2.21608266e-01f, -2.03976914e-01f, 3.35040867e-01f, 1.23713456e-01f, -5.49047627e-03f, -1.04502188e-02f, -1.17868327e-01f,
  1.73314750e-01f, 2.19021261e-01f, 1.99635960e-02f, 9.61800218e-02f, 3.05815071e-01f, 9.25851017e-02f, -6.34934008e-03f, 3.56406756e-02f, 2.95687824e-01f, 1.41348317e-01f,
  -9.12870746e-03f, -2.61009157e-01f, 2.53475845e-01f, -4.04948592e-02f, -2.74034083e-01f, 1.42632574e-01f, -1.42041653e-01f, 2.11443201e-01f, 8.20527449e-02f, -5.08261144e-01f,
  -1.96266800e-01f, 1.04046807e-01f, 3.04253280e-01f, -2.91298926e-01f, -1.92651689e-01f, -1.37843519e-01f, 2.87876815e-01f, -1.18049450e-01f, 1.47913933e-01f, 3.47208768e-01f,
  -3.22397426e-02f, -7.05719879e-03f, -8.28038454e-02f, -1.75151229e-01f, -2.26166859e-01f, -7.96429813e-02f, -9.63919163e-02f, -1.04290120e-01f, 8.83799978e-03f, -1.05758674e-01f,
  1.22463135e-02f, -1.28623173e-01f, -1.65388063e-01f, 2.92718232e-01f, 2.07702280e-03f, -7.88556561e-02f, -2.03835964e-02f, 2.83018574e-02f, 1.40359834e-01f, -1.13185577e-01f,
  5.42659648e-02f, -6.05512619e-01f, -1.96569368e-01f, 1.04905963e-01f, 6.19515851e-02f, -2.95382142e-01f, -2.10918814e-01f, -1.64879426e-01f, 1.47369727e-01f, 1.19227907e-02f,
  -1.38032049e-01f, 2.33769119e-01f, 8.01592320e-02f, -1.46351576e-01f, -1.49612194e-02f, -1.06991015e-01f, -2.22635880e-01f, 1.88784927e-01f, 2.53215373e-01f, -3.25528324e-01f,
  -3.15632634e-02f, 1.40734226e-03f, -7.94252232e-02f, 1.68403566e-01f, -1.55244321e-01f, 2.50084281e-01f, -1.53134093e-01f, -1.06860109e-01f, 5.27227931e-02f, 1.21806793e-01f,
  4.09761108e-02f, -2.65699834e-01f, -7.59257004e-02f, 8.81066695e-02f, -2.90525351e-02f, 1.51809931e-01f, -8.33825693e-02f, -1.09914929e-01f, -1.85533434e-01f, -3.14586371e-01f,
  -5.87072223e-02f, 1.76521733e-01f, 7.87133351e-02f, 1.49772996e-02f, -4.74807695e-02f, -2.18454570e-01f, 1.12133808e-01f, 3.26929152e-01f, 6.00303598e-02f, -1.19629584e-01f,
  1.09439462e-01f, -5.00007905e-02f, -1.03849731e-01f, -5.01364879e-02f, 1.19241685e-01f, 2.07753479e-01f, -1.89508632e-01f, 1.54258236e-01f, -3.79976332e-02f, 2.05662385e-01f,
  -4.67715897e-02f, -4.90524955e-02f, -2.47600898e-01f, -1.70437872e-01f, -4.86316383e-01f, -1.26052782e-01f, 3.57431829e-01f, 2.13470191e-01f, -5.10839038e-02f, -3.51048857e-01f,
  -1.30002409e-01f, -1.58682555e-01f, 7.17398226e-02f, -8.80540535e-03f, 2.16778085e-01f, 1.26294434e-01f, -2.66318265e-02f, 8.76375809e-02f, 1.02984212e-01f, -2.30531216e-01f,
  -2.09821318e-03f, -1.31921023e-01f, 1.27481446e-01f, 2.81448960e-01f, -1.03256419e-01f, -7.04969391e-02f, 5.94689883e-02f, -4.71206829e-02f, 8.72673094e-02f, 1.67878211e-01f,
  1.67697966e-01f, -6.86125308e-02f, -3.23434561e-01f, 1.13711491e-01f, -2.60382503e-01f, 4.68474962e-02f, -6.30963594e-02f, -2.17232227e-01f, -8.31661448e-02f, 3.24071646e-01f,
  1.35426685e-01f, -5.10487109e-02f, -2.00816751e-01f, -2.02220425e-01f, 2.80989967e-02f, -2.56936967e-01f, 1.84594586e-01f, 1.88200518e-01f, -1.75620094e-01f, -2.09191918e-01f,
  1.67598546e-01f, -2.19813839e-01f, 1.21922037e-02f, -6.95487484e-02f, 1.58303097e-01f, 2.46668503e-01f, -2.12893803e-02f, 1.22662142e-01f, -2.20013484e-02f, 1.59338657e-02f,
  -2.61173062e-02f, 3.53618413e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.62940338e-01f, 1.92447960e-01f, -8.74476805e-02f, 1.22376889e-01f, 1.61438480e-01f, 2.69548357e-01f, 2.47903749e-01f, -4.93583977e-01f, -1.68719068e-01f, -1.78138256e-01f,
  2.36932799e-01f, -2.29441419e-01f, 1.64929166e-01f, 1.44615946e-02f, 2.88375109e-01f, -1.43768992e-02f, 2.06681099e-02f, 1.04560368e-01f, 1.05883531e-01f, 1.13540918e-01f,
  1.82960525e-01f, -7.97118098e-02f, -2.33786795e-02f, 1.99249178e-01f, 2.75969177e-01f, -1.10859424e-01f, 2.37848535e-01f, 2.10360885e-01f, 1.24779873e-01f, 8.78807753e-02f,
  1.77009910e-01f, 7.73656070e-02f, -7.50335380e-02f, 2.14161828e-01f, 1.84481427e-01f, -6.97674155e-02f, -3.50628188e-03f, 2.59554625e-01f, 1.62290230e-01f, 2.74135858e-01f,
  -1.84406444e-01f, 2.42279008e-01f, 1.98642369e-02f, -3.60181183e-02f, 1.50806112e-02f, -1.59102961e-01f, -1.45749912e-01f, 8.44313726e-02f, 1.71779200e-01f, 7.48139480e-03f,
  -1.84027448e-01f, -1.51023448e-01f, 1.16783064e-02f, 1.72890350e-01f, -1.29097998e-01f, -4.99000959e-02f, 1.61221996e-01f, 1.83402643e-01f, -7.01295165e-03f, -2.11939499e-01f,
  2.78724765e-04f, 2.14246914e-01f, 1.34230211e-01f, -1.71175972e-01f, 4.91652757e-01f, 2.20803499e-01f, 8.62834379e-02f, 2.79680729e-01f, 1.11397542e-01f, 3.86187971e-01f,
  4.71058458e-01f, -1.61228925e-01f, -7.00105205e-02f, 4.77005601e-01f, 5.34756422e-01f, -2.45621547e-01f, 3.40694450e-02f, -1.17371567e-01f, 3.02110434e-01f, 1.35062680e-01f,
  -1.55189596e-02f, 2.22719803e-01f, -1.46221325e-01f, -4.78433631e-02f, 2.60779947e-01f, -2.65684277e-01f, -1.13708191e-01f, 3.11650783e-01f, 1.68516278e-01f, 2.63511211e-01f,
  8.45998675e-02f, -2.98291177e-01f, -1.41505942e-01f, 2.07815662e-01f, 2.61838377e-01f, 1.27421925e-02f, 5.41877985e-01f, 1.07682191e-01f, -2.66591776e-02f, 3.92344445e-01f,
  6.71143085e-02f, 5.97416162e-01f, -9.78700891e-02f, -2.03753382e-01f, -3.56415838e-01f, -2.19003946e-01f, 3.62930626e-01f, 5.33893257e-02f, 1.60238251e-01f, -5.62940501e-02f,
  7.94756413e-02f, -4.61060762e-01f, 1.11100106e-02f, -1.00739494e-01f, 2.54903704e-01f, -1.26871020e-01f, 2.76848823e-01f, -1.42334461e-01f, -1.74728185e-01f, 1.48313225e-03f,
  -2.46111855e-01f, 5.41980803e-01f, 4.22504038e-01f, 2.84504622e-01f, 8.17983318e-03f, -9.63268578e-02f, 1.01487851e-02f, 4.60113376e-01f, 1.77098319e-01f, 2.97767431e-01f,
  2.96533972e-01f, -7.14992061e-02f, 3.01388860e-01f, 8.15032050e-02f, 3.86787653e-01f, -3.48565638e-01f, -1.30321890e-01f, 2.94956237e-01f, 1.56624794e-01f, -7.65519589e-02f,
  -7.35158101e-02f, 2.19617397e-01f, -3.36435921e-02f, 3.96190047e-01f, 1.48693413e-01f, 2.20276982e-01f, 5.70338368e-02f, 2.41436049e-01f, -1.37138173e-01f, -1.38662234e-01f,
  -1.03491448e-01f, 3.58300731e-02f, 2.16350660e-01f, -1.85762480e-01f, -1.97703615e-01f, -5.29864766e-02f, -1.81231722e-01f, 2.99701184e-01f, 7.54638687e-02f, 1.89908035e-02f,
  3.56089137e-02f, 1.21227026e-01f, 2.05542758e-01f, 2.10997909e-01f, -6.24815822e-02f, -1.34269208e-01f, -2.20295504e-01f, 1.30549639e-01f, 1.60543382e-01f, 1.80322319e-01f,
  -3.38500999e-02f, 5.16912527e-02f, -8.83064121e-02f, -1.71453897e-02f, -4.13166266e-03f, 4.88221765e-01f, -7.02069234e-03f, 1.83570653e-01f, -5.54102696e-02f, 1.29561082e-01f,
  -9.31851286e-03f, 4.90424603e-01f, 3.39670360e-01f, 1.31241724e-01f, 1.10707849e-01f, 1.57872379e-01f, 3.62419039e-02f, 1.90451965e-01f, 3.79069448e-01f, 1.60256535e-01f,
  1.19569510e-01f, -9.10291597e-02f, -1.06875204e-01f, -4.96802293e-02f, 6.48601970e-04f, 1.78718671e-01f, -1.49872005e-01f, 2.05796033e-01f, 1.87295396e-02f, 2.64996171e-01f,
  -7.89784268e-02f, 9.84333381e-02f, 1.12586372e-01f, 8.56208652e-02f, -7.27403015e-02f, -5.33743016e-02f, -3.42583694e-02f, -1.79675683e-01f, -1.31421447e-01f, -8.13537017e-02f,
  -1.00585617e-01f, -1.70202807e-01f, 5.00534922e-02f, -8.59639943e-02f, 9.50794965e-02f, -3.02264504e-02f, -4.96388674e-02f, 3.02728325e-01f, -4.54778895e-02f, -6.56988472e-02f,
  -1.54367194e-01f, 8.84281695e-02f, 1.04698222e-02f, 3.24683301e-02f, 1.90351054e-01f, -5.17196693e-02f, -1.08715706e-01f, -6.07904382e-02f, -1.41424894e-01f, -4.76185977e-02f,
  -2.68480219e-02f, 1.77363772e-02f, 1.05960853e-01f, 5.26880696e-02f, -9.05960128e-02f, 1.55807748e-01f, 3.23388904e-01f, 1.54483005e-01f, -9.17469189e-02f, -6.75612390e-02f,
  1.15154147e-01f, -1.72885507e-01f, -1.77479640e-01f, 2.73785919e-01f, 9.10188183e-02f, -5.68254143e-02f, 1.33833021e-01f, 9.28043481e-03f, -5.14833741e-02f, -1.64084837e-01f,
  9.69688147e-02f, 3.39199007e-01f, 6.64631044e-03f, 1.01136938e-01f, -1.82299837e-01f, 1.55535012e-01f, 1.76430777e-01f, 2.42543131e-01f, 1.70132846e-01f, 4.16359812e-01f,
  -2.09057555e-02f, 9.14466158e-02f, -4.43310648e-01f, -1.15238786e-01f, 2.95190632e-01f, 4.78427522e-02f, 3.13049674e-01f, -2.96108633e-01f, 2.55531771e-03f, -1.04071848e-01f,
  3.30841430e-02f, -1.11298956e-01f, 2.29612544e-01f, -2.11846624e-02f, 1.69833496e-01f, -8.74283314e-02f, 3.28145444e-01f, -8.15358609e-02f, -2.47818939e-02f, 6.33643493e-02f,
  3.56914788e-01f, 4.94779944e-01f, 2.43677095e-01f, 1.36392549e-01f, 8.32916051e-03f, -2.16825262e-01f, 2.38099769e-02f, -2.19155386e-01f, -7.81362057e-02f, -1.79796800e-01f,
  -8.20633620e-02f, -1.31300408e-02f, -8.11851956e-03f, 9.52556506e-02f, -7.93004334e-02f, -1.03321910e-01f, 1.80144273e-02f, -7.37915784e-02f, -2.98851803e-02f, 2.87082735e-02f,
  7.53850192e-02f, -1.54488936e-01f, 1.73832886e-02f, -1.54502392e-01f, -4.71249484e-02f, 4.57048938e-02f, 1.35783061e-01f, -1.44262493e-01f, 5.75819463e-02f, 9.96004716e-02f,
  7.61252195e-02f, -4.88709621e-02f, -1.69476271e-02f, -7.55046606e-02f, 1.45290582e-03f, 1.14146605e-01f, -1.76550463e-01f, -1.48487166e-01f, 3.84714268e-02f, 1.04493007e-01f,
  -1.09291151e-01f, 1.68667838e-01f, 1.08679041e-01f, 3.48370165e-01f, 3.12657267e-01f, -8.52310881e-02f, -4.99157071e-01f, -4.39488620e-01f, 2.34947458e-01f, -3.91704515e-02f,
  -2.09617093e-02f, -2.37225562e-01f, -2.54227310e-01f, -1.99915886e-01f, 1.23467989e-01f, -2.44911574e-02f, -7.92589411e-02f, 5.82539439e-02f, 1.78416893e-01f, 6.18448621e-03f,
  2.38553420e-01f, -4.89813872e-02f, 2.13030368e-01f, -2.23751873e-01f, 5.97874343e-01f, 1.91254150e-02f, 1.96630150e-01f, 3.54607016e-01f, 2.57992744e-01f, -1.67042598e-01f,
  -8.00171271e-02f, 1.51195630e-01f, 2.29302347e-01f, -1.75389320e-01f, -5.73555194e-02f, -6.47551939e-02f, 7.26324469e-02f, 2.17634141e-01f, -8.08154345e-02f, 3.16095471e-01f,
  -3.09531689e-01f, -3.32388908e-01f, 4.10392471e-02f, 3.21101427e-01f, -1.45739421e-01f, -2.07374334e-01f, -3.48031297e-02f, 2.02400610e-01f, -4.98984866e-02f, 4.52225655e-02f,
  1.53550267e-01f, -2.38814592e-01f, 1.70373276e-01f, 4.19357508e-01f, -9.46412235e-02f, -1.81748867e-01f, -1.60785511e-01f, 2.11254179e-01f, -6.02245629e-02f, 2.58800417e-01f,
  3.36808205e-01f, -1.37190267e-01f, 5.90841994e-02f, 2.68698245e-01f, 1.12965509e-01f, 3.64340581e-02f, -9.91684105e-03f, 1.77613378e-01f, -1.64252205e-03f, 3.09379250e-01f,
  -2.08656117e-02f, 1.24609232e-01f, 9.41224545e-02f, -1.70348540e-01f, 4.84548276e-03f, 2.26391956e-01f, 1.47436202e-01f, 1.29037455e-01f, -8.47681537e-02f, -1.84960708e-01f,
  1.40766293e-01f, -6.10940792e-02f, -5.68122901e-02f, 1.06051221e-01f, 2.04496399e-01f, -9.66746956e-02f, -1.27271116e-02f, -5.52434959e-02f, 5.09396121e-02f, 3.07813466e-01f,
  2.34028533e-01f, 6.21246919e-02f, -1.21988319e-01f, -1.97045267e-01f, 8.33012164e-02f, 1.47938460e-01f, -1.49649501e-01f, 5.24479933e-02f, -2.90219951e-02f, -4.88768518e-02f,
  -1.40328541e-01f, -1.09887451e-01f, 7.55950902e-03f, 2.66835187e-03f, -6.16949350e-02f, 4.46748547e-02f, -7.03282878e-02f, 1.47996664e-01f, 2.91308630e-02f, 8.48088190e-02f,
  -1.11581497e-01f, 2.70441681e-01f, 1.18999593e-01f, -1.47356674e-01f, 1.71358928e-01f, -1.62260309e-01f, -6.39251918e-02f, 2.71720231e-01f, 2.32602984e-01f, -1.18066937e-01f,
  6.82126060e-02f, -1.37500316e-01f, 7.48837218e-02f, 5.86425401e-02f, 5.12693450e-02f, -7.78282993e-03f, -4.90309298e-02f, 2.95381695e-02f, -1.87562220e-02f, 4.16740775e-02f,
  -1.06525853e-01f, 4.91916090e-02f, -8.56178552e-02f, 4.88444827e-02f, -1.26137018e-01f, 6.16898760e-02f, -1.04583561e-01f, 7.16087595e-02f, 2.60845274e-02f, -3.39184292e-02f,
  -1.12231359e-01f, -6.77077398e-02f, 1.44870818e-01f, -9.59701464e-02f, 6.69920072e-02f, 5.43774292e-02f, 9.34694987e-03f, -2.37633977e-02f, 4.87143844e-02f, -3.72893289e-02f,
  4.23589647e-02f, -2.47301813e-02f, -2.01937631e-01f, 2.63002098e-01f, -5.56274243e-02f, 1.06798522e-01f, 6.29284307e-02f, -7.09587932e-02f, -1.39920354e-01f, 9.04446766e-02f,
  -8.15401077e-02f, 1.01981737e-01f, 2.41234198e-01f, 2.73137569e-01f, 5.67341782e-02f, -7.82692283e-02f, -3.29240620e-01f, -3.53535324e-01f, 1.70746133e-01f, -1.10366337e-01f,
  -9.22784209e-04f, -2.22679332e-01f, -2.14482173e-01f, -1.19239360e-01f, 1.19118905e-03f, 2.80562103e-01f, 3.68643999e-02f, 2.14020014e-01f, 2.03817397e-01f, 1.36403874e-01f,
  -1.23926066e-02f, 1.46736261e-02f, 1.83182061e-01f, -1.04855776e-01f, 5.39305270e-01f, -2.74013299e-02f, 1.46867260e-01f, 5.26080392e-02f, 2.60133117e-01f, -9.68165919e-02f,
  3.99223194e-02f, -1.31175756e-01f, 1.08053192e-01f, -1.07050408e-02f, 2.55436540e-01f, 2.73354203e-01f, 1.85281456e-01f, 2.86000460e-01f, -1.18306957e-01f, 2.96888854e-02f,
  2.62134701e-01f, -1.52398825e-01f, -3.12736005e-01f, 3.32333535e-01f, 3.57991457e-01f, 2.36866087e-01f, 9.36650559e-02f, 1.46373242e-01f, -1.39703602e-01f, 1.45153608e-02f,
  8.41610879e-02f, 3.53504360e-01f, -2.05228731e-01f, 1.31240234e-01f, 3.28546137e-01f, -9.21934098e-02f, -1.67930990e-01f, -1.99187472e-01f, -1.83577314e-02f, 4.69111860e-01f,
  3.24331336e-02f, -2.22170781e-02f, -6.13203980e-02f, -1.46146417e-01f, 6.37856824e-03f, 2.88127754e-02f, -2.11422712e-01f, 8.03956166e-02f, 1.45684347e-01f, -1.82378471e-01f,
  -2.47864500e-02f, -6.88557550e-02f, 1.43327996e-01f, 1.71772465e-01f, 1.37044221e-01f, -2.39740610e-01f, 9.86093655e-02f, 1.26505196e-01f, 9.69850719e-02f, -1.39837101e-01f,
  1.03023157e-01f, -1.14458762e-01f, 1.62917212e-01f, -5.72335571e-02f, 1.62310302e-01f, 1.20813653e-01f, 1.44624069e-01f, -5.87015934e-02f, -1.07413225e-01f, 4.75592390e-02f,
  -1.16974354e-01f, 3.43335979e-02f, -1.45319387e-01f, -4.34370078e-02f, -3.61868702e-02f, -1.11270882e-01f, 2.26094425e-01f, 1.26483753e-01f, 2.11729050e-01f, -4.77365451e-03f,
  1.31380215e-01f, -5.08031659e-02f, 1.48946434e-01f, 2.24289224e-01f, -1.51310205e-01f, -8.00155774e-02f, -9.73512530e-02f, 1.09698690e-01f, 3.23339880e-01f, 2.45082714e-02f,
  -1.27834067e-01f, 1.09368991e-02f, -8.35828558e-02f, -1.65829167e-01f, -7.90480152e-02f, 1.04350954e-01f, 1.53375983e-01f, 9.13447235e-03f, -1.35051385e-01f, 1.27054140e-01f,
  -4.60578613e-02f, 1.40262827e-01f, -1.28603742e-01f, 1.42590374e-01f, 6.24603815e-02f, 1.40175477e-01f, -5.06553426e-02f, 1.01062037e-01f, 1.76172182e-02f, 2.71308661e-01f,
  1.09184571e-01f, 2.72105262e-02f, 1.74771547e-01f, 2.21380323e-01f, 2.99080074e-01f, -1.81004241e-01f, 1.32524550e-01f, 2.40063682e-01f, 2.34650388e-01f, -2.02584311e-01f,
  -1.58409163e-01f, -1.84193015e-01f, 7.35373199e-02f, 2.61281222e-01f, 3.71989012e-02f, 2.58104116e-01f, -3.58058475e-02f, 1.14242651e-01f, -1.12368919e-01f, 1.11950807e-01f,
  7.37143382e-02f, 2.39154011e-01f, -5.24017774e-03f, -1.43334106e-01f, -1.04456209e-01f, -5.05816229e-02f, -1.48559004e-01f, -3.91234457e-02f, 1.50058150e-01f, -5.68847395e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.18639737e-01f, 2.62381345e-01f, 4.46062803e-01f, 4.54803437e-01f, 1.91330612e-01f, 2.58474033e-02f, 6.14951663e-02f, 1.28201589e-01f, 1.16940858e-02f, -1.97986752e-01f,
  2.76651800e-01f, 2.19322532e-01f, 2.77766675e-01f, -1.34155368e-02f, 1.85857743e-01f, 1.59224898e-01f, 1.06789134e-01f, 8.12180266e-02f, 1.98387921e-01f, 1.16018228e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.86633095e-01f, -3.28750342e-01f, -2.32837051e-01f, -1.26295537e-01f, -2.31203854e-01f, -2.48638853e-01f, -3.84462953e-01f, 3.45017202e-03f, 3.19463760e-02f, -2.89779931e-01f,
  -3.11416030e-01f, -7.10279271e-02f, 3.47577453e-01f, -3.16412598e-01f, -3.02227318e-01f, 2.44745180e-01f, -1.40106499e-01f, -1.51586145e-01f, -1.50813013e-01f, -2.88313744e-03f,
  -3.49977911e-01f, 4.78987247e-02f, -5.37121370e-02f, 9.89156216e-02f, 4.89575751e-02f, -5.46351890e-04f, -5.34335375e-02f, 6.77948892e-02f, 1.80731773e-01f, 7.59118274e-02f,
  -1.56254947e-01f, -1.59495622e-01f, -2.85673559e-01f, 2.11348742e-01f, -1.20338224e-01f, -1.98850751e-01f, 7.80844539e-02f, 6.88634068e-02f, 3.27011168e-01f, -2.59089649e-01f,
  -4.05361801e-01f, 1.29599154e-01f, 1.59756929e-01f, -1.66464835e-01f, -1.55965626e-01f, 1.57818452e-01f, -2.62232840e-01f, -1.77874684e-01f, -3.18688065e-01f, 1.86675742e-01f,
  1.52915297e-02f, 1.14916138e-01f, 3.42030168e-01f, -1.00651786e-01f, 7.15236589e-02f, -1.55807942e-01f, 1.88616142e-01f, 1.88285470e-01f, -7.58184791e-02f, 1.68124259e-01f,
  8.20492879e-02f, 2.89066252e-03f, -2.85471231e-02f, -1.73672512e-01f, -1.12086564e-01f, 1.86759084e-02f, 1.18133714e-02f, 4.83766943e-02f, -3.23469341e-02f, -3.95016558e-02f,
  -2.07183078e-01f, -3.73732001e-01f, -3.42104316e-01f, 1.15570612e-01f, -5.07325172e-01f, -3.07324767e-01f, 7.66891092e-02f, 6.39000759e-02f, -1.90426156e-01f, 3.49961892e-02f,
  9.20475498e-02f, 7.87721798e-02f, 8.51709396e-02f, 1.61577716e-01f, -3.82424384e-01f, -1.71605244e-01f, -2.30455711e-01f, 1.06307253e-01f, -1.50801957e-01f, -1.93506922e-03f,
  -1.45708978e-01f, -1.23461798e-01f, 1.44600302e-01f, -2.15221211e-01f, 2.64447868e-01f, -1.60053104e-01f, -3.31835181e-01f, -3.81561182e-02f, -1.52519032e-01f, -3.23004946e-02f,
  1.63070127e-01f, 1.68664213e-02f, 2.94982612e-01f, -1.83464587e-01f, -1.17958657e-01f, 1.51430160e-01f, 3.32389981e-01f, 2.48718962e-01f, -2.56206006e-01f, -9.79273543e-02f,
  -3.24254513e-01f, 1.19618915e-01f, -3.14114034e-01f, 1.74798459e-01f, 7.30712339e-02f, -1.30108446e-02f, 2.11817473e-01f, 7.87937641e-02f, 3.37714344e-01f, -1.84182134e-02f,
  8.64811838e-02f, 1.97922617e-01f, 6.16656132e-02f, 2.63319165e-01f, 9.74113792e-02f, -1.72892764e-01f, -1.96710467e-01f, -2.98199356e-01f, 2.51223017e-02f, -5.62688671e-02f,
  -8.55582487e-03f, 5.15432209e-02f, -1.03386596e-01f, -5.50219007e-02f, 4.24498618e-02f, -5.33810377e-01f, -4.44456637e-01f, -2.91315675e-01f, -4.48755413e-01f, -3.85653675e-01f,
  -2.35599816e-01f, 1.76897720e-02f, 5.32007813e-02f, -2.87316054e-01f, 5.99635988e-02f, -7.67008886e-02f, 1.51721500e-02f, 2.14539617e-01f, -2.52990872e-01f, 9.08335447e-02f,
  -2.77640540e-02f, 9.99949127e-02f, 1.83709413e-01f, -8.79586935e-02f, -1.32714927e-01f, -2.22075328e-01f, 2.97599286e-01f, -2.33545387e-03f, 2.47843474e-01f, -1.69351324e-01f,
  8.39931741e-02f, -1.12031668e-01f, -1.38421208e-01f, -6.45508468e-02f, -1.77858382e-01f, -2.32815549e-01f, -3.67670029e-01f, 1.14939794e-01f, -1.53586447e-01f, -2.22808287e-01f,
  -1.23637043e-01f, 2.05213398e-01f, 1.48371994e-01f, -9.46111307e-02f, 2.66647577e-01f, 3.88691545e-01f, 2.01692387e-01f, -7.77527839e-02f, -3.98156680e-02f, -2.42653470e-02f,
  -2.51640063e-02f, 1.14345104e-01f, -2.86122859e-01f, -2.01458126e-01f, 1.00663699e-01f, -9.46797580e-02f, 1.78731024e-01f, -2.98126847e-01f, 6.78443089e-02f, 7.66094550e-02f,
  1.38587698e-01f, 4.05050665e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.72301447e-01f, 4.02678847e-01f, 2.21909463e-01f, 2.17172980e-01f, 3.28143656e-01f, 4.63433355e-01f, 5.26408777e-02f, -1.60623893e-01f, -4.08251971e-01f, -5.38745284e-01f,
  -3.08090299e-01f, -6.10601380e-02f, 2.55338792e-02f, 6.50592819e-02f, 7.74158537e-01f, 2.04615384e-01f, 2.39249229e-01f, -2.27331758e-01f, 7.85363466e-02f, -1.11228764e-01f,
  1.83223203e-01f, -7.98358545e-02f, -4.21705097e-01f, -3.46938699e-01f, 1.99959025e-01f, 7.84311257e-03f, -7.39640445e-02f, -2.33361602e-01f, 2.68704027e-01f, -4.79245260e-02f,
  2.88606614e-01f, 1.34917647e-01f, 2.56077796e-01f, 5.02206683e-02f, -3.04067433e-01f, 2.55209208e-01f, 1.51631102e-01f, 7.29405954e-02f, -8.44962671e-02f, 3.18355739e-01f,
  -1.01098549e-02f, 7.02938288e-02f, -1.76865935e-01f, 3.25224847e-01f, 1.62599176e-01f, 2.87240893e-01f, 3.36217284e-01f, 2.31132850e-01f, 2.56824791e-01f, -2.11067706e-01f,
  2.20314652e-01f, -1.55809596e-01f, -1.14181682e-01f, -1.04431041e-01f, -2.43791327e-01f, 3.09838384e-01f, 1.45863697e-01f, -2.76923385e-02f, 1.82727069e-01f, -4.24842872e-02f,
  -2.49369040e-01f, -5.44095412e-02f, -4.61817160e-02f, -2.94078980e-02f, 2.20755249e-01f, 2.76522100e-01f, 2.74092337e-04f, 3.19780409e-01f, 2.90700924e-02f, 1.12333924e-01f,
  1.61666751e-01f, -1.71809122e-01f, -4.14460093e-01f, -1.79915011e-01f, 3.80633958e-02f, 8.86284113e-02f, -2.66109556e-01f, 2.18933254e-01f, 7.20565487e-03f, 3.83192599e-01f,
  -2.03082025e-01f, -9.82982591e-02f, 1.90068185e-01f, -7.35947564e-02f, 2.33077258e-01f, 9.70692635e-02f, -1.18555106e-01f, 2.56279677e-01f, 2.37441182e-01f, -1.38632685e-01f,
  1.73979133e-01f, -2.01083571e-01f, -3.94714698e-02f, -1.53712735e-01f, -3.22842821e-02f, -2.05861032e-01f, 3.60959977e-01f, -2.53487788e-02f, 2.15073809e-01f, 3.43693078e-01f,
  2.39893407e-01f, -5.21714389e-02f, 8.77613127e-02f, -4.64353323e-01f, -2.56412834e-01f, -1.88409775e-01f, -2.63078749e-01f, -1.69647008e-01f, 2.66340524e-01f, -1.24373607e-01f,
  2.25313082e-02f, 4.06172901e-01f, -1.63340792e-01f, 5.31910080e-03f, -7.63040222e-03f, 2.76368558e-01f, -7.33971298e-02f, -1.25068158e-01f, -4.54185791e-02f, 4.05020356e-01f,
  3.63813847e-01f, 6.30500764e-02f, -4.94983084e-02f, -1.10330589e-01f, 4.67867076e-01f, -2.06793770e-01f, 3.46916765e-01f, -2.83865750e-01f, -1.09174073e-01f, 5.25911078e-02f,
  -1.22606203e-01f, 1.32246196e-01f, 1.43714279e-01f, 9.54833701e-02f, -9.33391880e-03f, 2.90922910e-01f, 4.08143520e-01f, 1.47033647e-01f, -6.36590198e-02f, 1.28738701e-01f,
  1.89137444e-01f, -1.78879932e-01f, -9.15374421e-03f, -7.61780608e-03f, -3.81714180e-02f, -3.20605338e-02f, -3.74801420e-02f, 2.14053262e-02f, 2.23348498e-01f, 2.77108476e-02f,
  2.30698183e-01f, 6.12319149e-02f, 5.16586937e-02f, -1.65526465e-01f, -6.24212734e-02f, 9.37894434e-02f, -4.38884571e-02f, -5.29698655e-02f, 1.41025949e-02f, 3.82021368e-02f,
  -3.71767320e-02f, 1.58789814e-01f, -1.19676225e-01f, 4.22812179e-02f, -1.67910159e-01f, -1.33671537e-02f, 1.53831050e-01f, -2.20210180e-01f, 1.07915774e-01f, 1.73014477e-01f,
  -1.17434330e-01f, -2.33323067e-01f, -2.01810338e-02f, 4.28539775e-02f, 1.02441400e-01f, 3.26936059e-02f, -2.07710359e-02f, -8.16337857e-03f, -3.04671526e-02f, 2.51490660e-02f,
  9.06799138e-02f, 1.34692594e-01f, 1.86967775e-01f, -1.45641854e-02f, 6.44348338e-02f, 5.80193475e-02f, -1.98524207e-01f, -5.58735952e-02f, -1.25214413e-01f, -1.43663539e-02f,
  1.83757525e-02f, -1.57765299e-01f, 1.29304886e-01f, 2.15227127e-01f, 3.82376552e-01f, 3.64465773e-01f, 2.75534779e-01f, 1.68305606e-01f, 2.35817701e-01f, -2.09562078e-01f,
  1.39762163e-01f, 1.80425450e-01f, 1.89245060e-01f, -3.52972120e-01f, 2.09646747e-01f, 2.71074057e-01f, 2.36815289e-01f, -4.99138862e-01f, 5.58210731e-01f, 3.08753431e-01f,
  -2.40846261e-01f, -1.96692571e-01f, -4.11402695e-02f, -7.71176517e-02f, 1.88673615e-01f, -2.25836352e-01f, -6.75268397e-02f, 9.27044451e-02f, -9.92145240e-02f, 1.85733661e-01f,
  -6.74207136e-02f, 7.64710084e-02f, 9.00028273e-02f, 4.09930050e-01f, 2.36506704e-02f, -4.54741605e-02f, -1.33777261e-01f, 6.40535355e-02f, 1.59286007e-01f, 4.73630019e-02f,
  2.26038620e-01f, 1.62985936e-01f, 3.43570352e-01f, -1.62221536e-01f, 2.21713871e-01f, 1.48768231e-01f, 3.93611938e-01f, 1.38904760e-02f, 2.65702605e-01f, -1.42737683e-02f,
  2.97384501e-01f, -1.17063537e-01f, -1.45024329e-01f, -1.54796302e-01f, 4.84754220e-02f, 6.27378300e-02f, 3.50730956e-01f, -4.76630926e-02f, -8.23138878e-02f, -1.58804938e-01f,
  -8.24299306e-02f, 1.84617653e-01f, -8.06553364e-02f, 1.70616165e-01f, -4.14972752e-02f, 9.00634006e-02f, 2.71653503e-01f, 8.88614357e-02f, 2.76513342e-02f, 2.47662842e-01f,
  2.14879394e-01f, 1.55519232e-01f, 9.51463655e-02f, 1.25157252e-01f, 3.05593401e-01f, 1.68579623e-01f, -7.34691545e-02f, -1.10785857e-01f, -4.07893248e-02f, 2.37935334e-01f,
  2.61468321e-01f, -2.41407961e-01f, 3.57517451e-01f, -1.40064359e-01f, -5.62235862e-02f, -1.30814955e-01f, -8.00520480e-02f, 1.14590071e-01f, 1.20217778e-01f, -1.56718761e-01f,
  -1.69276295e-03f, -1.84684902e-01f, -1.08555391e-01f, 1.38844147e-01f, 1.25358701e-01f, -6.30917773e-02f, -2.04936638e-01f, 2.30522960e-01f, -4.34086509e-02f, 1.14387676e-01f,
  -4.64556217e-02f, 1.87078431e-01f, 1.49574816e-01f, 2.59663254e-01f, 3.40645999e-01f, -2.44460419e-01f, 2.96374708e-01f, -1.23661853e-01f, 8.60459954e-02f, -1.06331475e-01f,
  1.24215588e-01f, -1.45911321e-01f, -2.10462555e-01f, -9.06879678e-02f, 4.04050201e-02f, -8.22194442e-02f, -9.01766047e-02f, 1.40728995e-01f, 5.11335254e-01f, -6.71482533e-02f,
  6.69342458e-01f, -1.89709932e-01f, -4.49458100e-02f, 2.81814802e-02f, -5.84391877e-02f, 6.02774680e-01f, 1.58237919e-01f, 1.11571059e-01f, -1.78662807e-01f, -1.63563594e-01f,
  1.34254694e-01f, -4.51656841e-02f, 2.75411755e-01f, 2.28622049e-01f, 2.27025941e-01f, -4.21006531e-02f, 1.79460898e-01f, 5.06353438e-01f, 5.65328777e-01f, 1.33672938e-01f,
  5.55692613e-02f, 2.16319636e-01f, 3.83113503e-01f, -6.26113862e-02f, 6.80018902e-01f, 2.17677459e-01f, 2.46185437e-01f, 1.04490682e-01f, -4.49143052e-02f, 4.49920706e-02f,
  2.48371094e-01f, -7.24969581e-02f, 5.34695536e-02f, -2.09220424e-01f, -1.00185266e-02f, -1.81505710e-01f, 1.53312713e-01f, 7.97810256e-02f, -1.57173395e-01f, -5.41442595e-02f,
  -1.85486659e-01f, 1.65059745e-01f, -7.21383840e-02f, -1.49408042e-01f, 2.68053580e-02f, 6.48449436e-02f, 8.68698508e-02f, 1.68584913e-01f, 1.42321482e-01f, -7.49716014e-02f,
  1.17355697e-01f, 1.10167786e-01f, -1.07965417e-01f, 1.18823282e-01f, -9.19762552e-02f, 1.48890555e-01f, 3.53303663e-02f, -9.23590884e-02f, -5.20766266e-02f, -1.01217002e-01f,
  -1.40039390e-03f, 1.12275168e-01f, -4.91151325e-02f, 8.82089958e-02f, -3.76357064e-02f, -8.94853622e-02f, 6.77625164e-02f, 7.85440281e-02f, 1.96598377e-03f, 1.80137962e-01f,
  2.69542653e-02f, -9.13132951e-02f, -7.41404071e-02f, 1.39371306e-01f, 1.66407377e-01f, -2.19261590e-02f, -5.95170557e-02f, -5.84394224e-02f, 1.02705084e-01f, -1.72901243e-01f,
  -1.20943017e-01f, 8.28181580e-02f, 9.45268795e-02f, 1.34489276e-02f, 1.65142938e-01f, 9.58062783e-02f, -6.52005747e-02f, -2.09979966e-01f, -4.29906696e-02f, 2.73670852e-01f,
  9.13160294e-02f, -1.35086715e-01f, -1.60027683e-01f, 4.52719703e-02f, -6.36342987e-02f, 1.62945196e-01f, 3.14553559e-01f, 2.92867795e-02f, 3.32892314e-02f, 1.43074334e-01f,
  -2.90479306e-02f, 6.58394918e-02f, 1.62307322e-01f, 2.26228088e-02f, -9.31877270e-02f, -4.66772206e-02f, 3.24860334e-01f, -1.81591451e-01f, 6.08748524e-03f, 2.66167708e-02f,
  -5.47196111e-03f, -1.45128518e-01f, -2.73763686e-01f, 2.10789680e-01f, 2.86670178e-01f, -3.67980570e-01f, -1.15138136e-01f, -1.92103282e-01f, 2.30874911e-01f, -2.32409850e-01f,
  7.20196813e-02f, 5.49643457e-01f, 1.68091476e-01f, -9.99869257e-02f, -1.70035716e-02f, 2.17939228e-01f, -1.90565467e-01f, -1.38465837e-01f, -1.12683615e-02f, 1.33009166e-01f,
  1.74505219e-01f, 7.16182813e-02f, -1.29470691e-01f, -1.36529461e-01f, 2.66781420e-01f, 1.43726468e-01f, 4.28307913e-02f, -1.51782960e-01f, 3.47867534e-02f, 2.99746208e-02f,
  1.03886137e-02f, 1.37041360e-01f, 4.49582040e-02f, 1.29442126e-01f, 1.85745060e-02f, -6.29872410e-03f, -1.70148790e-01f, 2.00590193e-01f, 1.07690118e-01f, 5.92210032e-02f,
  1.02246247e-01f, -7.97452703e-02f, -8.64119232e-02f, -8.09324160e-02f, -1.15421072e-01f, 2.11163625e-01f, 1.34906337e-01f, -4.12661582e-02f, -2.58476455e-02f, -1.74434692e-01f,
  8.18164572e-02f, 6.31030053e-02f, -6.05288409e-02f, 5.29988296e-02f, 1.28820434e-01f, -8.47617164e-02f, -8.69740024e-02f, 1.47770673e-01f, -2.81405775e-03f, -7.65468404e-02f,
  3.03391069e-01f, -3.93156335e-02f, 2.04621345e-01f, 2.58634835e-01f, -2.45074686e-02f, 2.20531896e-01f, -2.49520108e-01f, 3.86446267e-01f, 1.30027384e-01f, -4.63204831e-02f,
  -6.23622872e-02f, 1.58571839e-01f, 1.69576526e-01f, 5.55635951e-02f, 5.35222292e-01f, 7.36480236e-01f, -1.75737217e-01f, -1.85974911e-01f, -5.65332994e-02f, -6.38176277e-02f,
  2.64457583e-01f, -5.94862066e-02f, 8.32658932e-02f, 1.63372651e-01f, 1.90657452e-01f, 1.09055648e-02f, 4.94094491e-02f, -2.89567709e-01f, -3.18363130e-01f, 1.89522490e-01f,
  1.92657813e-01f, 9.77098793e-02f, -7.59051293e-02f, 7.81439766e-02f, -8.25917646e-02f, 7.25109652e-02f, 1.59938410e-01f, -9.34964865e-02f, 2.79781278e-02f, -2.02378511e-01f,
  -3.54885049e-02f, -2.98749477e-01f, 2.10955158e-01f, 9.16411355e-02f, 1.66576188e-02f, -1.03284717e-01f, -7.23265707e-02f, 1.62956670e-01f, 1.43004134e-01f, 1.86459988e-01f,
  1.33177474e-01f, 3.61654073e-01f, 3.90266292e-02f, -1.42026708e-01f, -8.17883760e-02f, -2.80860543e-01f, 1.31237522e-01f, -6.50815144e-02f, -3.08318846e-02f, -7.74779171e-02f,
  4.74268794e-01f, -5.83392717e-02f, -1.32700903e-02f, 6.33752048e-02f, -1.76971629e-01f, 2.81248659e-01f, 4.99897934e-02f, -6.33278191e-02f, 1.28515005e-01f, 5.01581170e-02f,
  3.03683102e-01f, 1.72805890e-01f, -2.32840732e-01f, 1.28073782e-01f, 5.13337255e-01f, 3.08143616e-01f, 1.06576413e-01f, -1.75279289e-01f, 2.16330230e-01f, 4.68315661e-01f,
  -7.56658390e-02f, 2.40386128e-01f, 4.69528697e-02f, -8.25183168e-02f, 4.76600677e-01f, 5.02545685e-02f, 4.88711655e-01f, -7.79216364e-02f, 2.79028535e-01f, -1.94447607e-01f,
  1.42232969e-01f, 2.48394623e-01f, -1.39972433e-01f, 1.07207946e-01f, -1.59599498e-01f, -4.98213619e-02f, 8.16376209e-02f, -6.10649586e-02f, 2.92752862e-01f, 3.22081625e-01f,
  6.99991956e-02f, 2.45832577e-01f, 3.43756825e-01f, -5.06822586e-01f, -5.08903265e-01f, 3.55423599e-01f, -3.53985518e-01f, -3.31046283e-01f, -2.12223306e-01f, 2.22538356e-02f,
  -2.48405531e-01f, -1.86289340e-01f, -3.63399722e-02f, 5.06080508e-01f, 5.43456376e-02f, -2.15964198e-01f, -5.69903255e-02f, 1.67625453e-02f, -1.07538819e-01f, 4.72536564e-01f,
  6.48813546e-02f, 3.72582376e-02f, 2.50786617e-02f, 9.13753733e-02f, 2.67588019e-01f, 5.80234230e-02f, -1.64271165e-02f, 9.26834643e-02f, -9.98020545e-02f, 1.70019403e-01f,
  -8.69640112e-02f, 1.61646619e-01f, -1.83100365e-02f, 2.32753620e-01f, 1.21261694e-01f, -2.48657092e-01f, 9.56839100e-02f, 2.79716343e-01f, -3.45747918e-02f, -3.03870857e-01f,
  -8.02473798e-02f, 1.07354037e-01f, -3.96384187e-02f, -3.69053006e-01f, 1.35936916e-01f, 4.75343198e-01f, -1.15393676e-01f, -8.28278735e-02f, -1.68524072e-01f, 2.40641516e-02f,
  3.36069226e-01f, 1.46835998e-01f, -2.09572822e-01f, 2.56345361e-01f, -1.62979633e-01f, 2.67598003e-01f, 2.51495898e-01f, -8.43460858e-02f, -3.43966410e-02f, 1.14250436e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  4.09634888e-01f, 2.85248220e-01f, 2.05969512e-01f, 1.98881224e-01f, 7.05821216e-02f, 3.39079909e-02f, 1.40535429e-01f, 1.09307945e-03f, 8.64989217e-03f, 2.30108678e-01f,
  2.71550804e-01f, 8.44074711e-02f, 2.12542549e-01f, 2.49751762e-01f, 2.78982446e-02f, 3.36415134e-02f, 1.54153317e-01f, 2.01076478e-01f, 3.34144890e-01f, 1.82761550e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.54710966e-01f, -2.66397804e-01f, -2.81382501e-01f, -2.02388987e-01f, -4.47663784e-01f, 1.08784668e-01f, 3.80745590e-01f, -4.22635704e-01f, -5.77791274e-01f, -2.63906360e-01f,
  -5.33668876e-01f, 3.59065528e-03f, -5.93810752e-02f, 3.94902617e-01f, -1.68548480e-01f, -5.54849386e-01f, 1.63278610e-01f, -1.48648366e-01f, 5.31349242e-01f, 5.38989723e-01f,
  5.39932251e-01f, -1.50808811e-01f, 3.58343482e-01f, 8.90730917e-02f, 9.42517910e-03f, -2.07777649e-01f, 6.46452159e-02f, -1.59089968e-01f, -9.22219530e-02f, -1.07954092e-01f,
  -3.37771326e-01f, -5.03245480e-02f, -4.61351126e-01f, 1.69360623e-01f, 5.11445463e-01f, -3.75446007e-02f, 4.92154986e-01f, 3.02434206e-01f, -2.57418394e-01f, -2.70807087e-01f,
  2.10596412e-01f, -4.24178809e-01f, 4.25603420e-01f, -2.09604114e-01f, 4.14218098e-01f, -1.41420007e-01f, -8.89232978e-02f, -9.50865149e-02f, -9.68434215e-02f, 1.12781085e-01f,
  7.61632442e-01f, -1.19665086e-01f, 4.80385780e-01f, -2.48228297e-01f, 1.69594660e-01f, 1.26767993e-01f, -1.41613930e-01f, -2.61931658e-01f, 9.19268932e-03f, -2.93721855e-01f,
  -8.62257257e-02f, -6.16802990e-01f, 1.74275771e-01f, 2.16465130e-01f, 3.09065208e-02f, -5.93751483e-02f, -4.74927992e-01f, -1.58057034e-01f, -9.73838866e-02f, 3.45280133e-02f,
  -2.27195602e-02f, 2.63967276e-01f, 6.93527520e-01f, 2.20891684e-01f, 6.67159975e-01f, -3.93978834e-01f, -4.04683232e-01f, -2.53987879e-01f, -1.27591342e-01f, 4.61902350e-01f,
  -1.01678669e-01f, -1.07075926e-02f, -6.94213482e-03f, -1.49254784e-01f, -1.06408246e-01f, -1.60679325e-01f, -4.23953205e-01f, -6.93065673e-02f, -1.14379808e-01f, -2.73069590e-01f,
  2.04783767e-01f, -4.46535885e-01f, -1.64176553e-01f, -3.68578851e-01f, 8.30750227e-01f, 5.25027514e-01f, -2.01380923e-02f, 3.75645831e-02f, -4.51038420e-01f, -1.97159365e-01f,
  -4.37599301e-01f, -3.18757474e-01f, 6.80623949e-02f, 2.25881740e-01f, -6.87429160e-02f, 1.13627158e-01f, -2.56906956e-01f, -4.04217154e-01f, -7.59240091e-01f, -1.18126556e-01f,
  -2.07810193e-01f, -3.29123318e-01f, 4.20270264e-01f, 2.05156967e-01f, -1.10081276e-02f, 3.83820772e-01f, 9.16633084e-02f, 7.19109833e-01f, 2.26170093e-01f, -2.41110753e-02f,
  4.01192494e-02f, -1.83149070e-01f, 3.36139500e-02f, -2.54263341e-01f, -1.43878564e-01f, 2.41095886e-01f, -5.81216633e-01f, 1.71417266e-01f, -5.26932478e-01f, 2.48402029e-01f,
  -5.69822788e-01f, 2.93790787e-01f, -2.93524742e-01f, 1.97850615e-01f, 1.03743702e-01f, 3.03246886e-01f, -3.23193431e-01f, 2.20319599e-01f, -4.06567305e-01f, 2.73139812e-02f,
  2.10066158e-02f, -2.82975405e-01f, 6.00952692e-02f, -1.53964624e-01f, 3.73148173e-02f, -7.15617537e-02f, -1.06565587e-01f, 1.69568285e-01f, -8.79459158e-02f, 1.28700718e-01f,
  4.56526697e-01f, -1.92806631e-01f, -2.28996798e-01f, -3.31412554e-01f, 5.68104312e-02f, 4.54172283e-01f, -3.00294627e-02f, 6.37832105e-01f, -1.56639829e-01f, -4.97940123e-01f,
  2.46548563e-01f, -5.59978366e-01f, 9.43728760e-02f, -6.52492940e-01f, -2.07213182e-02f, -4.01057750e-01f, -2.44499847e-01f, -2.88629234e-01f, -1.59219414e-01f, -3.17853749e-01f,
  -3.36244673e-01f, 3.78291994e-01f, 5.89115202e-01f, 1.90398604e-01f, -3.08074206e-01f, -2.34423786e-01f, 7.01588318e-02f, -1.42672598e-01f, -8.93602148e-02f, 1.55672401e-01f,
  9.13613364e-02f, -4.36263472e-01f, 4.81810361e-01f, -1.43963546e-02f, -3.12302019e-02f, 4.46547627e-01f, -1.34168059e-01f, 5.07143080e-01f, -1.18411854e-01f, -4.12067324e-01f,
  -3.20906758e-01f, -3.30245972e-01f, 6.65784299e-01f, 1.96991742e-01f, -2.15630736e-02f, 2.52187550e-01f, -5.26718842e-03f, 3.69558424e-01f, -2.68809702e-02f, -1.85433701e-01f,
  5.71070075e-01f, -4.01885122e-01f, 7.09832311e-01f, 1.58921361e-01f, 4.42756474e-01f, 2.49783278e-01f, 5.61506450e-01f, 4.24252003e-01f, -2.44062990e-01f, 1.73593089e-01f,
  -1.62341997e-01f, -3.33140284e-01f, -7.15458170e-02f, -3.21810871e-01f, -6.65995896e-01f, -8.73883292e-02f, -2.11415738e-01f, 1.61263883e-01f, -9.14769098e-02f, 1.77725822e-01f,
  -3.75830323e-01f, -3.91451955e-01f, 3.74443859e-01f, -3.03206176e-01f, 4.79152113e-01f, -4.68006492e-01f, -1.23545222e-01f, 6.49160445e-02f, -3.05139780e-01f, -2.59703517e-01f,
  6.76891267e-01f, -4.31972086e-01f, 1.94896162e-01f, -9.64388624e-02f, -2.43192539e-01f, 2.50708073e-01f, -7.73058712e-01f, 2.07630619e-01f, -1.26213714e-01f, 1.55234322e-01f,
  2.57412285e-01f, -1.02793410e-01f, -4.76282567e-01f, 1.74791262e-01f, -1.10264607e-01f, -1.57089099e-01f, 4.10880089e-01f, 1.24157057e-03f, 3.78661603e-01f, 4.94144768e-01f,
  7.31667653e-02f, 5.68762302e-01f, -7.05331713e-02f, 2.30792835e-01f, -1.87154099e-01f, -1.50460061e-02f, 3.01760018e-01f, -6.02892637e-02f, -4.31323409e-01f, 2.09439620e-01f,
  -6.75681233e-01f, -8.46076980e-02f, 6.83893144e-01f, 4.78341356e-02f, 4.99254018e-01f, -1.24970675e-01f, 1.86500743e-01f, 4.14305747e-01f, 3.71562004e-01f, -3.25312734e-01f,
  -1.66208282e-01f, 5.36987543e-01f, -1.53331667e-01f, -5.04151247e-02f, -8.49479139e-02f, -1.16438724e-01f, -3.04768980e-01f, 1.28447354e-01f, -5.11442780e-01f, -1.46749064e-01f,
  -4.71164361e-02f, 4.07817304e-01f, -2.32473165e-01f, -5.37043750e-01f, 5.27406037e-01f, -9.94801298e-02f, -1.03961065e-01f, -2.83847265e-02f, -4.37717378e-01f, 1.04414128e-01f,
  2.57860839e-01f, 3.01669538e-01f, 3.32731515e-01f, -3.59662861e-01f, -3.03878158e-01f, -1.02833202e-02f, -3.38229060e-01f, -1.20057128e-01f, -1.76028356e-01f, 3.13793808e-01f,
  5.23061454e-01f, 5.81573308e-01f, 5.66894591e-01f, -2.49093436e-02f, -2.66572118e-01f, -6.57235608e-02f, -5.59150577e-01f, -2.81652868e-01f, -2.47248515e-01f, -4.77566242e-01f,
  -9.17826872e-03f, -8.60789195e-02f, -4.60149273e-02f, -2.03559145e-01f, 1.16650984e-01f, 3.10690105e-01f, 1.20432056e-01f, 2.61689067e-01f, -2.98077196e-01f, -3.58321160e-01f,
  -2.37251505e-01f, -2.05101907e-01f, 3.13241273e-01f, -3.24707657e-01f, 3.85919899e-01f, -3.91319633e-01f, -3.54983568e-01f, 4.00007337e-01f, -1.74922690e-01f, 5.19331813e-01f,
  -4.84070659e-01f, -4.78504121e-01f, -5.08667290e-01f, -3.11290652e-01f, -2.71623522e-01f, -4.47976202e-01f, -1.37690797e-01f, -1.09633543e-02f, 5.94115853e-01f, -6.74378946e-02f,
  -1.09390132e-01f, 3.97773921e-01f, -2.57785439e-01f, 4.90592532e-02f, -1.43578872e-01f, -2.33145878e-01f, 7.85196200e-02f, -3.06399524e-01f, 2.28908658e-02f, 1.73350856e-01f,
  4.42735583e-01f, 3.66304398e-01f, 1.83432236e-01f, 2.09981278e-01f, 7.10454583e-01f, 3.25522631e-01f, 7.07343221e-01f, 3.65953058e-01f, -1.48653015e-01f, 3.79180700e-01f,
  -3.09350103e-01f, 8.68121624e-01f, 3.18671197e-01f, -3.65369320e-01f, 2.23745719e-01f, -3.58697116e-01f, 2.61959016e-01f, 4.18362021e-01f, 6.82783499e-02f, -1.98602304e-01f,
  -6.93137869e-02f, -2.67114080e-02f, 1.58543512e-01f, 3.89394611e-01f, -2.27885351e-01f, -3.32802273e-02f, 2.68496484e-01f, 7.82355368e-02f, 5.04897200e-02f, -2.59761661e-01f,
  1.99245080e-01f, 1.73087507e-01f, 3.11269872e-02f, -2.00077876e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.91957444e-01f, 5.81662022e-02f, 1.09615944e-01f, -1.71492681e-01f, -6.14736192e-02f, 2.02316530e-02f, -3.18809226e-02f, -1.09825293e-02f, -3.98270562e-02f, -1.84247389e-01f,
  1.04692444e-01f, 1.48564085e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    