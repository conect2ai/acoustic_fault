/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.62822330e-01f, -3.35363746e-01f, 2.88685590e-01f, 1.32098094e-01f, 2.85990722e-02f, 1.67163402e-01f, 8.44378024e-03f, 1.07119456e-01f, 4.23268676e-02f, -5.24789840e-02f,
  -6.22020885e-02f, -6.06979206e-02f, 4.89686951e-02f, 8.81663188e-02f, 1.90256342e-01f, 3.67641859e-02f, -1.77597590e-02f, 1.25391215e-01f, 2.30449557e-01f, -5.55470260e-03f,
  -3.08479220e-01f, -9.00790244e-02f, 1.61672816e-01f, -7.80744106e-02f, -2.33585492e-01f, -3.67902629e-02f, 3.70710939e-02f, -4.50375006e-02f, -1.43783942e-01f, -3.65488172e-01f,
  7.25654885e-02f, -1.46851027e-02f, 6.31565750e-02f, 4.17547077e-02f, 7.34774619e-02f, 1.39370533e-02f, 8.66221860e-02f, 5.52236363e-02f, 8.56753141e-02f, 2.45647244e-02f,
  1.19585320e-02f, 2.22607926e-02f, -1.41332147e-03f, -3.88148241e-02f, 5.71179315e-02f, 5.90670668e-02f, 9.76712108e-02f, 2.20785942e-02f, 8.58105645e-02f, -6.76370636e-02f,
  -1.97513908e-01f, -1.00181282e-01f, 2.24885538e-01f, 3.48220356e-02f, 1.07652828e-01f, 6.88245073e-02f, 5.45852371e-02f, 5.89386076e-02f, 1.90781295e-01f, -3.60967405e-02f,
  -7.11271018e-02f, -8.25349167e-02f, -9.93544310e-02f, -1.03294849e-01f, -1.01127170e-01f, -1.02024868e-01f, -3.40180844e-02f, -1.05232760e-01f, -1.28181919e-01f, -7.59651586e-02f,
  -8.40342790e-02f, -2.97431368e-02f, -1.18713453e-01f, -1.54612418e-02f, -1.09539360e-01f, -1.63314138e-02f, -1.12155434e-02f, -7.25336745e-02f, -7.36659616e-02f, -9.59235132e-02f,
  -1.18176453e-01f, -7.73647428e-02f, -5.26176877e-02f, -1.72467917e-01f, -3.93228754e-02f, -3.65455598e-02f, -6.99320883e-02f, -1.23227000e-01f, -7.96333700e-02f, -1.03776656e-01f,
  1.80669338e-01f, 3.80933672e-01f, 5.72143272e-02f, -7.80537277e-02f, 1.78162493e-02f, 4.01637070e-02f, -1.61452182e-02f, -8.99837911e-03f, 6.02153223e-03f, 3.03593036e-02f,
  3.95085569e-03f, 9.41221416e-02f, 2.64059007e-02f, -1.94010194e-02f, 2.87511628e-02f, -7.08618527e-03f, 3.53677256e-04f, 1.35489658e-01f, 7.58680999e-02f, 4.52391338e-03f,
  2.19220091e-02f, 1.84582010e-01f, 2.05727100e-01f, 1.05386533e-01f, -4.98715881e-03f, 2.74914891e-01f, 1.18243359e-01f, 1.05938874e-01f, 3.57217491e-01f, 7.30720758e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.22657478e+00f, -5.69436774e-02f, 2.55770564e-01f, 1.57225996e-01f, -3.40165704e-01f, -4.99608427e-01f, -6.17892325e-01f, -3.19882423e-01f, -1.36984512e-01f, -4.77947630e-02f,
  2.03748584e-01f, 3.19182098e-01f, 2.48302847e-01f, 2.31089145e-01f, 2.03491434e-01f, -1.17236242e-01f, -7.93972537e-02f, 4.56430078e-01f, 3.41657549e-01f, -3.08681764e-02f,
  -1.63565502e-01f, 1.34283781e-01f, 3.72740358e-01f, 9.40641388e-02f, 1.98883694e-02f, 7.53617585e-02f, 1.08088769e-01f, 2.05658555e-01f, 1.98267758e-01f, 2.17115372e-01f,
  5.23048401e-01f, 7.30486333e-01f, -1.31233677e-01f, 1.64108098e-01f, 1.99840918e-01f, 1.59299627e-01f, 3.89262438e-02f, -2.56910846e-02f, -1.18313313e-01f, -6.78196251e-02f,
  5.32331578e-02f, -3.49128828e-03f, -1.09291393e-02f, -5.29983304e-02f, -6.50450438e-02f, 1.94868688e-02f, 7.75257722e-02f, 4.61199693e-02f, -8.87708142e-02f, 2.98336558e-02f,
  -1.63571566e-01f, 4.31470200e-02f, -5.68603985e-02f, -1.81446910e-01f, -7.02795684e-02f, 1.29392043e-01f, -6.13174923e-02f, 1.69893950e-01f, 1.73067674e-01f, 1.05944067e-01f,
  1.32045686e-01f, 2.39245385e-01f, 2.22927094e-01f, -3.14445309e-02f, 2.40319711e-03f, 5.03950231e-02f, 4.20488566e-02f, -1.34788379e-01f, 2.46072978e-01f, 5.87792583e-02f,
  -9.30396244e-02f, 8.12651776e-03f, -2.22425222e-01f, -7.45248571e-02f, 2.07738638e-01f, 8.76372531e-02f, -1.93105698e-01f, -1.35866597e-01f, -8.47769994e-03f, -1.85042098e-02f,
  1.42585024e-01f, 6.35725707e-02f, 2.44295806e-01f, 4.80711199e-02f, -1.12556860e-01f, 1.92424636e-02f, -3.80451456e-02f, -1.92736119e-01f, 7.00277910e-02f, 8.09556395e-02f,
  -5.42152524e-01f, 3.89442027e-01f, 4.44724262e-02f, -2.31227223e-02f, 8.63662586e-02f, 1.07911855e-01f, 2.69470979e-02f, -1.76668749e-03f, -8.47035199e-02f, -2.75967252e-02f,
  -1.26412839e-01f, 1.06132068e-01f, -6.54971302e-02f, -3.69586982e-02f, -4.70456434e-03f, -7.40231154e-03f, -9.19937864e-02f, -3.31493914e-02f, -1.17651671e-01f, -1.00126855e-01f,
  -2.35461190e-01f, -2.80536950e-01f, -2.39620954e-01f, -2.46390074e-01f, -2.25979090e-01f, -6.18820451e-02f, -1.45597681e-01f, -1.52261451e-01f, -9.30985287e-02f, -3.17627907e-01f,
  2.36479908e-01f, -1.33854542e-02f, 7.59065151e-02f, 4.37304795e-01f, 6.72658801e-01f, 5.59132636e-01f, 8.19189847e-01f, 5.47890365e-01f, 3.11929524e-01f, 1.64877802e-01f,
  -5.23427784e-01f, -1.03607559e+00f, -8.64462078e-01f, -7.24409819e-01f, -4.20249879e-01f, 4.00283158e-01f, 5.11637390e-01f, -1.16878532e-01f, -2.63694584e-01f, 5.78287914e-02f,
  1.52918220e-01f, 5.14021158e-01f, -2.37910617e-02f, -5.24904430e-02f, 2.30142280e-01f, -1.24056362e-01f, 4.13436055e-01f, 8.70796591e-02f, -1.82983026e-01f, -1.65954292e-01f,
  -6.77156150e-01f, 1.54767722e-01f, -9.00335319e-04f, -7.79903978e-02f, -1.53601408e-01f, -1.43352821e-01f, 5.00972942e-02f, -2.52320200e-01f, -1.64352670e-01f, 8.11839998e-02f,
  -3.21782798e-01f, -1.43206477e-01f, -3.74186814e-01f, -2.75238603e-01f, 1.44925386e-01f, -1.71574533e-01f, -2.48191550e-01f, -2.60979414e-01f, -4.85715181e-01f, -4.22031999e-01f,
  -4.88976747e-01f, 7.18021020e-02f, 4.78187725e-02f, 1.49035707e-01f, -2.05364391e-01f, -2.84043700e-01f, -1.65819749e-01f, -3.07841271e-01f, -3.82987171e-01f, -9.55070257e-02f,
  1.31507099e-01f, -4.18853275e-02f, 1.23767942e-01f, 3.95500660e-02f, 1.35427769e-02f, -8.16766471e-02f, -1.53234124e-01f, 2.97048856e-02f, 7.46295750e-02f, 1.37106165e-01f,
  -2.46188298e-01f, -1.54898306e-02f, -6.12803958e-02f, 9.12011340e-02f, -3.86918150e-02f, -4.93333265e-02f, 2.00756431e-01f, -6.93716481e-02f, -7.35385939e-02f, 2.44459659e-01f,
  -6.33481741e-02f, 1.29231274e-01f, -4.66615483e-02f, -2.17099294e-01f, 8.54260921e-02f, -9.61108357e-02f, 1.25707760e-01f, -2.57779241e-01f, -6.10165261e-02f, 2.18678817e-01f,
  2.05616467e-02f, -1.18581047e-02f, -1.08957393e-02f, -1.74061298e-01f, 1.02247559e-01f, -8.95349160e-02f, 1.93212450e-01f, 2.82116979e-02f, 1.89067665e-02f, -1.48453027e-01f,
  -5.98762669e-02f, -1.55421793e-01f, -2.23705783e-01f, 1.52981773e-01f, -3.22896428e-02f, 1.42539695e-01f, -6.86198175e-02f, 3.84701751e-02f, -1.03472263e-01f, 1.78163499e-01f,
  1.94654822e-01f, 4.61214840e-01f, 1.57182947e-01f, 1.96008116e-01f, 4.75097559e-02f, 3.04505408e-01f, 1.13080747e-01f, 6.32503107e-02f, 3.75877842e-02f, 9.15338159e-01f,
  -9.09681320e-01f, -5.45766532e-01f, -7.39824697e-02f, -6.66758060e-01f, 3.18006873e-01f, -1.98533103e-01f, -7.27031052e-01f, -5.99908829e-01f, 6.02610298e-02f, -3.83420527e-01f,
  3.69992733e-01f, 4.06452984e-01f, -6.76473826e-02f, -2.90689636e-02f, -1.01235008e+00f, -7.40960181e-01f, -7.70331442e-01f, -6.52798533e-01f, -1.84060454e-01f, 2.60131627e-01f,
  4.60464209e-01f, -1.09953217e-01f, -3.24769408e-01f, -9.09526870e-02f, 2.00601071e-01f, 2.88026065e-01f, 9.27217975e-02f, 1.62685931e-01f, 2.29764670e-01f, 1.01447478e-01f,
  -3.85376900e-01f, -6.93393469e-01f, 8.18276107e-02f, 3.08107555e-01f, 1.02956563e-01f, -1.27235398e-01f, -1.00522801e-01f, -8.70516617e-03f, 4.52966273e-01f, -1.78219902e-03f,
  1.18663602e-01f, 2.94304579e-01f, 8.73416066e-02f, -7.78211933e-03f, -2.83167571e-01f, -2.10010052e-01f, -3.19541246e-01f, -3.59555453e-01f, -3.16937834e-01f, 2.19309717e-01f,
  6.37356341e-01f, 7.88630843e-02f, -6.40822291e-01f, -1.15023337e-01f, -3.76381427e-01f, -1.51932210e-01f, 1.01686873e-01f, 1.21683650e-01f, -3.99918616e-01f, -5.06095350e-01f,
  2.17051685e-01f, 1.03274971e-01f, -5.13297878e-03f, -1.50344476e-01f, -1.45491555e-01f, 3.06836367e-02f, -1.82828665e-01f, -3.91381122e-02f, 3.26536857e-02f, -1.56473160e-01f,
  -1.12481497e-01f, 2.97654374e-03f, -1.38965264e-01f, 6.48777634e-02f, 7.13128820e-02f, -1.60544872e-01f, 1.10583223e-01f, -4.97966595e-02f, 4.73437831e-02f, -1.40079871e-01f,
  -1.47111788e-01f, -1.10482320e-01f, 6.43223748e-02f, -1.53581113e-01f, -1.81805771e-02f, -6.35968447e-02f, 1.21184990e-01f, 5.54174706e-02f, -5.04821427e-02f, 5.12714051e-02f,
  -4.85605597e-01f, 1.44492269e-01f, -2.64702767e-01f, -1.93103507e-01f, -1.05770886e-01f, 3.18926334e-01f, 1.80141941e-01f, -1.56474765e-02f, -2.73451637e-02f, -6.49283975e-02f,
  3.05559170e-02f, -2.04447791e-01f, -2.00723305e-01f, 1.02834679e-01f, -3.51834595e-02f, -1.60704777e-01f, -2.33550429e-01f, -3.47653888e-02f, -1.99079722e-01f, 2.67556697e-01f,
  -2.68803313e-02f, -5.63463032e-01f, -7.56499767e-01f, -4.02760088e-01f, -3.37648243e-01f, -4.75088567e-01f, -2.77957499e-01f, -3.56248528e-01f, -5.37473142e-01f, -9.40983891e-01f,
  -4.18301135e-01f, 8.03827345e-01f, 7.82724321e-01f, -1.06040263e+00f, 6.28806502e-02f, 7.97775924e-01f, 9.93039250e-01f, 3.82306248e-01f, -3.24897021e-01f, 1.70132712e-01f,
  8.31489325e-01f, -2.75813758e-01f, -2.86476016e-01f, -3.16909313e-01f, -1.40783444e-01f, -4.41827439e-02f, -7.27146447e-01f, -5.08086085e-01f, -2.12909818e-01f, 1.51012540e-01f,
  -1.96004599e-01f, -3.12884986e-01f, -3.36637288e-01f, -4.46122438e-01f, -6.03339612e-01f, -6.70424521e-01f, 3.20955887e-02f, -1.23204887e-01f, 1.16041943e-01f, -1.20502627e+00f,
  -2.58088931e-02f, 6.95643723e-01f, -8.92460421e-02f, -3.37368190e-01f, -1.41044155e-01f, -1.97171122e-01f, -4.02031466e-02f, -1.73516035e-01f, 2.89862044e-02f, -3.93942073e-02f,
  -8.48493129e-02f, 6.28333986e-02f, -4.96587902e-02f, 8.67539421e-02f, 4.05002594e-01f, -5.47741279e-02f, 2.80081332e-01f, 4.94229160e-02f, 1.17719956e-02f, 5.04172504e-01f,
  -1.92395419e-01f, 5.28665632e-03f, 2.56368756e-01f, 3.86742920e-01f, 3.65980536e-01f, -1.37860700e-01f, 5.52857995e-01f, -8.80914107e-02f, 2.00395077e-01f, -8.51180792e-01f,
  -2.49416068e-01f, -1.43278018e-02f, 1.81356490e-01f, 4.08724695e-02f, -1.80223286e-01f, 1.32691175e-01f, -9.36551914e-02f, -5.76223359e-02f, 7.97595456e-02f, -8.26755837e-02f,
  9.83015969e-02f, 2.38523051e-01f, 1.31349251e-01f, -8.05443972e-02f, -3.35815817e-01f, -1.78727254e-01f, -1.08881004e-01f, -9.25382897e-02f, 7.41541907e-02f, -4.55991700e-02f,
  -1.54631376e-01f, -1.78365782e-02f, 9.22059491e-02f, -1.01310603e-01f, 1.42281905e-01f, -2.05814451e-01f, 2.05011904e-01f, 1.96230978e-01f, 4.49641421e-02f, 2.26894483e-01f,
  -4.89159524e-01f, 6.56519353e-01f, -6.90460205e-01f, -1.22131653e-01f, -3.04495282e-02f, -9.03371871e-02f, -1.73378408e-01f, 2.95950264e-01f, 6.59080222e-02f, -6.72932789e-02f,
  3.27252150e-01f, 3.68117578e-02f, 3.34919542e-01f, 7.70395249e-02f, 1.12497412e-01f, -2.34100848e-01f, -9.32687595e-02f, -1.77230656e-01f, -2.02813849e-01f, 1.46098882e-01f,
  -2.08114147e-01f, -3.46935809e-01f, -5.69760203e-01f, -1.60680294e-01f, -1.51661217e-01f, -6.11643255e-01f, -2.83733875e-01f, -4.20840681e-01f, -2.63586044e-01f, -1.09463453e+00f,
  -9.72311139e-01f, -5.45308925e-02f, -4.08104956e-01f, 7.98560679e-02f, 5.21457493e-01f, 3.59998345e-01f, 2.09540114e-01f, 3.36091034e-02f, 1.54111281e-01f, 2.48232141e-01f,
  1.50555402e-01f, 4.65357333e-01f, 4.56892043e-01f, 3.52282405e-01f, -6.47833273e-02f, 3.71738404e-01f, 3.02235574e-01f, -8.91450569e-02f, -1.09827779e-01f, 1.89470708e-01f,
  5.76449811e-01f, 1.55076742e-01f, -2.66173154e-01f, -1.01417050e-01f, 3.84392232e-01f, 5.16945541e-01f, 1.05966315e-01f, 1.11550100e-01f, 4.35719192e-01f, 4.52258527e-01f,
  5.36741793e-01f, -6.22773588e-01f, 1.22155964e-01f, 1.02724828e-01f, -1.93786681e-01f, -3.62809062e-01f, -6.90566674e-02f, -3.97893131e-01f, -4.00407575e-02f, 5.45188934e-02f,
  -5.84773086e-02f, -1.74921915e-01f, -7.06319287e-02f, -8.06948990e-02f, -1.79985195e-01f, -2.39275500e-01f, -2.94900149e-01f, -4.07594442e-01f, -1.68849200e-01f, -6.50919005e-02f,
  3.21512401e-01f, -3.00635938e-02f, -2.24437207e-01f, -6.32569417e-02f, -1.82103395e-01f, 2.40295172e-01f, -2.86168426e-01f, -1.96342349e-01f, -3.58005881e-01f, -2.16980606e-01f,
  2.06812009e-01f, -2.80295759e-02f, -8.35743099e-02f, -9.72269475e-02f, 9.75965932e-02f, 1.64627746e-01f, 7.12946281e-02f, 1.29910290e-01f, 9.61390883e-02f, -4.01374027e-02f,
  -3.48192942e-03f, 5.69985155e-03f, -7.68799782e-02f, -9.04582739e-02f, 1.49629444e-01f, 6.49485886e-02f, -8.18526596e-02f, -7.34992921e-02f, -1.74336210e-01f, -9.32940394e-02f,
  6.47515655e-02f, -1.40457734e-01f, -1.76142350e-01f, -1.20546997e-01f, 5.22316173e-02f, -1.49311841e-01f, 4.83129472e-02f, -1.98290478e-02f, -2.38929279e-02f, 4.96646352e-02f,
  7.89787054e-01f, -8.55717212e-02f, 2.28491396e-01f, -1.24541052e-01f, 1.85331404e-02f, -2.02561349e-01f, 4.03008647e-02f, -1.15516938e-01f, 3.52734630e-03f, 1.13223389e-01f,
  -1.28506839e-01f, -2.89902002e-01f, 3.91253941e-02f, -9.97702777e-02f, -4.77423146e-02f, -7.95027390e-02f, -3.04739550e-03f, 1.00139797e-01f, 2.80236509e-02f, -1.52493417e-01f,
  8.17079619e-02f, 2.68798694e-02f, 9.41164866e-02f, 1.52522281e-01f, 1.03899032e-01f, 4.16785210e-01f, -4.12658602e-02f, 3.64305731e-03f, -9.08908546e-02f, 7.24543259e-02f,
  8.32533017e-02f, -8.32324743e-01f, 1.23317039e+00f, -6.91487670e-01f, -6.86440706e-01f, -1.34789273e-01f, -4.04049784e-01f, -2.37728536e-01f, -5.38819075e-01f, -4.18787718e-01f,
  -5.57931423e-01f, -6.36725649e-02f, 1.91329733e-01f, 2.70898014e-01f, 3.90418351e-01f, -1.47598227e-02f, 1.49868742e-01f, 8.71356964e-01f, 9.77329969e-01f, -5.86887039e-02f,
  -5.97758532e-01f, -6.94704130e-02f, 3.36387664e-01f, 1.82112142e-01f, -5.95141590e-01f, -3.50993723e-02f, -8.16929266e-02f, -1.84797913e-01f, -2.51423180e-01f, -2.37664521e-01f,
  6.29840493e-01f, -2.86087215e-01f, 2.13861585e-01f, -3.56513143e-01f, -2.39609584e-01f, -9.90917999e-03f, 7.63174593e-02f, 9.62647125e-02f, -1.54241219e-01f, -6.60870150e-02f,
  -1.20958313e-01f, -8.20883140e-02f, 2.30344664e-02f, -6.56810217e-03f, -2.03686468e-02f, 5.04845940e-02f, 2.28145327e-02f, 1.81667209e-01f, -2.87014749e-02f, -1.42511353e-01f,
  -4.27223444e-01f, -2.37779200e-01f, 1.25716880e-01f, 5.77048063e-02f, 1.97795369e-02f, 5.16374633e-02f, -8.24457556e-02f, -6.72171712e-02f, 6.79452792e-02f, -1.13480456e-01f,
  2.45496631e-01f, -1.15985228e-02f, -1.68650389e-01f, 5.12522385e-02f, -8.70595351e-02f, 3.56011502e-02f, -8.90693367e-02f, 1.32606020e-02f, 7.66885132e-02f, 1.48465946e-01f,
  -1.20834544e-01f, -5.50709292e-02f, 1.22439936e-02f, -7.27152601e-02f, -4.23841327e-02f, -8.96297544e-02f, 4.25251052e-02f, -1.02195747e-01f, -1.41283885e-01f, -1.21165007e-01f,
  -2.05119029e-02f, -1.87895242e-02f, -1.10764615e-01f, 6.67626560e-02f, -1.92632720e-01f, 4.04359438e-02f, -2.60765571e-02f, 1.56654883e-02f, 3.11791804e-02f, -1.32952765e-01f,
  -8.74285400e-02f, -2.62903832e-02f, 1.52159063e-02f, 6.36173040e-02f, -1.71779320e-01f, -1.95840091e-01f, -4.75771837e-02f, -4.93080094e-02f, -5.70793040e-02f, 5.69471009e-02f,
  6.60568699e-02f, 1.74396768e-01f, 4.30014506e-02f, -5.67605570e-02f, 1.25278264e-01f, 1.03996523e-01f, -3.06063205e-01f, -3.47259492e-02f, -1.57656521e-01f, -1.24479376e-01f,
  -1.80278882e-01f, 6.16193190e-02f, 3.26530099e-01f, 1.31844610e-01f, -6.50146157e-02f, 2.82878816e-01f, 3.38136554e-01f, 7.75872692e-02f, 3.14258635e-01f, 4.81159389e-02f,
  -1.47582364e+00f, 3.41950983e-01f, 5.13316035e-01f, -1.01238310e+00f, -5.30297339e-01f, -1.89216137e-01f, 1.00899808e-01f, -3.44991386e-01f, -2.62418151e-01f, 4.78432000e-01f,
  9.40938815e-02f, -5.05596638e-01f, -1.37210395e-02f, -4.35429037e-01f, -4.77306157e-01f, 6.67137921e-01f, 1.97330385e-01f, -4.56150532e-01f, -1.10137987e+00f, -1.02553344e+00f,
  -6.73384428e-01f, -9.72197056e-01f, -1.04092944e+00f, -4.79884267e-01f, -1.16208054e-01f, -3.64236146e-01f, 2.26717100e-01f, -4.84349549e-01f, -5.44433556e-02f, 2.27396265e-02f,
  5.39260447e-01f, -5.04749775e-01f, -2.27120697e-01f, -5.54670572e-01f, -9.57684219e-02f, 4.39942395e-03f, -2.71609247e-01f, -1.70792371e-01f, 5.39869443e-02f, 9.42828432e-02f,
  -3.59095410e-02f, -3.40698689e-01f, -3.85110408e-01f, -1.45215839e-01f, -3.07083488e-01f, -2.02395599e-02f, -1.33958414e-01f, -2.21568853e-01f, -6.91799745e-02f, 2.97250152e-01f,
  1.98094174e-01f, 1.33350044e-01f, 3.24718565e-01f, 2.15153590e-01f, 7.60095417e-02f, -6.64286762e-02f, 1.89570084e-01f, 6.66132644e-02f, 1.34318754e-01f, 4.59398568e-01f,
  8.33054930e-02f, 3.39365423e-01f, -4.79284264e-02f, -2.33651385e-01f, -5.61854094e-02f, 3.88626419e-02f, 1.10540865e-02f, -4.88491543e-02f, -1.56889468e-01f, -2.61048251e-03f,
  -4.66280691e-02f, 2.16228321e-01f, 3.47629264e-02f, -3.14787449e-03f, -2.26243101e-02f, 2.90768500e-02f, 1.30011648e-01f, 1.65383518e-01f, 1.52001411e-01f, -1.05672851e-01f,
  -1.69717580e-01f, -5.08288629e-02f, -2.61328481e-02f, 6.96627870e-02f, 1.65479600e-01f, 1.05010062e-01f, 6.10695779e-03f, 2.01948024e-02f, -1.98335886e-01f, -2.46495351e-01f,
  -1.12365894e-01f, -2.88942575e-01f, 2.93048084e-01f, -1.72204882e-01f, 1.70862898e-01f, 1.04393438e-01f, 1.23628199e-01f, 1.40883578e-02f, -7.28349537e-02f, -1.78240731e-01f,
  -3.03372592e-01f, -6.10154644e-02f, 9.12349597e-02f, 8.82790610e-03f, -1.92580566e-01f, 5.87401167e-02f, -3.07793799e-03f, -1.54008642e-01f, 3.12354695e-02f, 8.37815031e-02f,
  2.94437259e-01f, 2.89060712e-01f, 4.11290437e-01f, 4.01447803e-01f, 1.53367266e-01f, 9.23282579e-02f, 2.74699688e-01f, 1.55775622e-01f, 2.13259459e-01f, 3.10946375e-01f,
  1.15699446e+00f, -1.29387069e+00f, -3.97713035e-01f, 7.54911005e-02f, -9.29602683e-02f, -7.12727308e-02f, -6.56374931e-01f, 1.13074392e-01f, 2.84828097e-01f, -6.60647810e-01f,
  -2.18510255e-01f, 6.22461736e-01f, 3.53959769e-01f, 4.25359339e-01f, 3.58714521e-01f, -9.43271101e-01f, -5.91057062e-01f, 4.67043817e-01f, 1.11365044e+00f, 5.95741868e-01f,
  -1.48125151e-02f, 1.31517798e-01f, 5.35321832e-01f, 1.42633602e-01f, -7.00163960e-01f, 5.23637161e-02f, -7.31111288e-01f, -3.91238540e-01f, -5.70473194e-01f, -1.04911995e+00f,
  -1.37931466e-01f, -3.67220461e-01f, 3.31621230e-01f, 1.34156493e-03f, -1.34463832e-01f, -2.23666690e-02f, -1.95961148e-02f, -1.38913453e-01f, -3.70449834e-02f, -2.31167629e-01f,
  2.64727771e-02f, -5.05146496e-02f, -4.22796467e-03f, -1.20343745e-01f, -6.90886453e-02f, 7.33870268e-02f, -8.53384435e-02f, 7.05713853e-02f, 1.03116948e-02f, -2.83762008e-01f,
  -3.36921215e-01f, -1.78765655e-01f, -3.86212729e-02f, -3.90273966e-02f, -9.87974033e-02f, 4.19179767e-01f, -2.06263527e-01f, -2.54432503e-02f, 5.51877841e-02f, -6.53109372e-01f,
  -7.51748383e-02f, 1.29549921e-01f, 8.18745866e-02f, -2.97144819e-02f, -4.20583077e-02f, -1.84172280e-02f, -1.49384603e-01f, -8.46770704e-02f, 3.85569432e-03f, -6.81475326e-02f,
  -2.26341233e-01f, -2.47066095e-02f, 7.53731653e-02f, -1.44039199e-01f, 2.00244021e-02f, -9.38779935e-02f, 8.96628127e-02f, -4.11301889e-02f, -1.67758092e-02f, 1.01701051e-01f,
  2.07108870e-01f, 5.41132726e-02f, -1.27320783e-02f, 1.65506095e-01f, -8.04202035e-02f, 5.18330969e-02f, 1.14220187e-01f, 8.47544298e-02f, 1.05299175e-01f, 4.09898125e-02f,
  3.08952898e-01f, 4.21840787e-01f, -1.79211929e-01f, 1.17551222e-01f, -2.55743805e-02f, -4.37016189e-02f, -6.57924935e-02f, 5.38400710e-02f, -1.05928481e-01f, 1.01088904e-01f,
  1.20422719e-02f, 1.32542625e-02f, -1.79297850e-01f, 5.10934666e-02f, 1.67217985e-01f, 7.94213936e-02f, -1.63758382e-01f, 1.23339474e-01f, 7.86028504e-02f, -1.39158303e-02f,
  -3.89209203e-02f, 7.09200352e-02f, 2.37987429e-01f, 1.27470031e-01f, 6.76748231e-02f, 4.76514965e-01f, -9.12916213e-02f, 2.34499946e-02f, 4.09624904e-01f, -1.97441444e-01f,
  1.37389290e+00f, -2.68361390e-01f, -1.54389262e+00f, 1.56183869e-01f, -6.82410538e-01f, -7.71500945e-01f, -6.44234776e-01f, 1.23919189e-01f, 4.50865537e-01f, -1.86238438e-01f,
  -1.44026503e-01f, 4.90048453e-02f, -5.64554036e-01f, -4.72004086e-01f, -1.73701644e-01f, -7.37506092e-01f, -8.59216392e-01f, -7.99003601e-01f, -3.62510592e-01f, 2.85198808e-01f,
  2.51994580e-01f, 1.98300377e-01f, 2.03329816e-01f, 5.01224399e-02f, -1.86117351e-01f, -2.74115890e-01f, -8.15962136e-01f, -5.40076792e-01f, -6.13500416e-01f, -8.73322606e-01f,
  -1.02478707e+00f, -3.26443613e-01f, -2.11520568e-01f, 2.49955848e-01f, -3.51803899e-01f, 9.20379683e-02f, -1.31811798e-01f, -7.62242917e-03f, 2.78628796e-01f, -6.33679181e-02f,
  -2.64853179e-01f, 5.01376353e-02f, -9.79643390e-02f, -3.99466604e-01f, 7.03270137e-02f, 1.97767377e-01f, 2.18184963e-01f, -1.79658905e-01f, -3.40855271e-01f, -1.76771209e-01f,
  2.13581607e-01f, -6.14986658e-01f, -7.11824775e-01f, -5.09664277e-03f, -3.20788115e-01f, -3.85270774e-01f, -4.28839833e-01f, -3.46982330e-01f, -6.09579265e-01f, -1.63546763e-02f,
  2.13151768e-01f, -6.87386915e-02f, -2.16644574e-02f, 9.54149440e-02f, 3.71236235e-01f, 4.33804728e-02f, -2.93881185e-02f, 4.20595296e-02f, 8.79540965e-02f, 2.03866791e-02f,
  -4.61868756e-02f, -3.48173752e-02f, 4.63100299e-02f, -9.87927988e-02f, -2.98325330e-01f, -2.62206525e-01f, 1.48840109e-02f, 2.34557372e-02f, -4.49306425e-03f, -2.20935270e-02f,
  -1.53239533e-01f, -4.39046063e-02f, -6.37859032e-02f, 1.58977583e-01f, -2.81795382e-01f, -8.83435681e-02f, -7.26108328e-02f, 1.33720219e-01f, 2.76881248e-01f, -2.11839601e-01f,
  1.09304421e-01f, -1.65116236e-01f, -5.71760014e-02f, 4.09505442e-02f, -2.83534646e-01f, -1.71547815e-01f, -7.27180541e-02f, 1.91474065e-01f, -1.28786817e-01f, -8.78599286e-02f,
  -3.01806271e-01f, 2.98399359e-01f, -2.38375366e-01f, 7.87962042e-03f, 7.36862496e-02f, 9.18330438e-03f, 2.93653071e-01f, -4.49040830e-01f, -1.66618913e-01f, 4.13902476e-02f,
  2.57819295e-01f, 1.28224626e-01f, 2.95391470e-01f, -1.10146269e-01f, 6.61451817e-02f, 7.36235231e-02f, -3.82507503e-01f, -9.84501094e-02f, -1.49025619e-01f, 6.53988659e-01f,
  1.05730641e+00f, 7.33387947e-01f, 5.21570086e-01f, 6.43926859e-01f, 2.81659931e-01f, 1.89994708e-01f, 3.65348160e-01f, -1.36031443e-02f, -9.66776013e-02f, 2.72761315e-01f,
  1.16167083e-01f, 2.77840570e-02f, 5.88824563e-02f, 1.95338558e-02f, 1.04530863e-01f, 1.56584769e-01f, 3.61565612e-02f, 1.56609833e-01f, -3.64688598e-02f, 1.68705046e-01f,
  2.27495596e-01f, 1.34244516e-01f, 9.55520645e-02f, 1.10314265e-01f, 2.96846539e-01f, 3.17583047e-02f, 1.25074834e-01f, 3.97506803e-01f, 3.04919004e-01f, 5.90239167e-01f,
  3.45658928e-01f, 4.85847801e-01f, -6.08878136e-01f, -2.27030098e-01f, -8.83003045e-03f, -1.94331586e-01f, -5.14542200e-02f, -1.57478482e-01f, -1.28804550e-01f, -1.92093134e-01f,
  -4.48020473e-02f, -1.24127850e-01f, 6.55062869e-02f, 1.35338875e-02f, -9.40768495e-02f, -1.66226789e-01f, -1.87227771e-01f, -4.53604525e-03f, -1.11016616e-01f, -5.04424144e-03f,
  1.17101669e-01f, 1.31522864e-01f, 8.47708583e-02f, -2.46869504e-01f, 1.06129736e-01f, -1.50574788e-01f, 6.80156425e-02f, -6.96374243e-03f, -1.10725500e-01f, 9.09603685e-02f,
  -2.14599937e-01f, 8.51494670e-02f, 2.26430088e-01f, 6.19014427e-02f, 6.92867041e-02f, -8.72298181e-02f, 1.74958408e-02f, 5.00087291e-02f, 8.85241628e-02f, -5.16774878e-02f,
  -2.64714807e-01f, -6.94778981e-03f, -1.21561930e-01f, -8.88789520e-02f, -1.70793101e-01f, 8.97942409e-02f, 1.17277078e-01f, -9.18577984e-03f, 2.62875599e-03f, -1.80143997e-01f,
  2.05791757e-01f, -1.81892529e-01f, -1.79358944e-01f, -3.39081436e-02f, -2.89034635e-01f, -1.68277130e-01f, -1.27656594e-01f, -2.45887712e-02f, -1.34179652e-01f, -1.71078801e-01f,
  -6.19169116e-01f, -5.41402817e-01f, -8.92694816e-02f, -5.70834987e-02f, 1.95954859e-01f, -7.30426759e-02f, 9.98862907e-02f, -1.34931624e-01f, 4.71588671e-02f, 1.82988923e-02f,
  1.12520017e-01f, 2.05036830e-02f, 3.14793810e-02f, -7.73706213e-02f, -1.73261777e-01f, -2.50341862e-01f, -1.40314447e-02f, 1.03332829e-02f, -2.27848157e-01f, 3.33596542e-02f,
  -1.62724823e-01f, -2.12945938e-01f, -1.63704649e-01f, -2.47186199e-01f, -1.78903669e-01f, -4.29178357e-01f, -3.52785200e-01f, -1.93538472e-01f, -4.64179397e-01f, -4.44954425e-01f,
  -1.00026798e+00f, 3.55863273e-01f, 2.57867575e-01f, -4.96171683e-01f, -4.60619181e-01f, -1.40473455e-01f, 1.72319993e-01f, -7.29729757e-02f, -3.73616308e-01f, -1.80418208e-01f,
  -4.84314740e-01f, -2.90394902e-01f, -5.64029664e-02f, 1.97783545e-01f, 3.68851334e-01f, 6.24609947e-01f, 6.90167665e-01f, 6.16903126e-01f, 3.89553304e-03f, -2.26372749e-01f,
  8.79642367e-02f, -7.65419826e-02f, 5.18006757e-02f, 2.64936149e-01f, 2.28091888e-02f, 3.33412811e-02f, 2.52062142e-01f, -1.51978493e-01f, 2.64788836e-01f, 6.32315636e-01f,
  -4.78169709e-01f, -1.42641202e-01f, -1.60282835e-01f, -2.43006259e-01f, 4.77872603e-03f, -7.44718593e-04f, 9.55567732e-02f, 9.09943357e-02f, 8.47138837e-02f, 1.94806397e-01f,
  -2.43263513e-01f, -2.95840371e-02f, -3.31331044e-01f, 3.96670066e-02f, -2.09111929e-01f, -2.56001770e-01f, 3.11669171e-01f, 4.97303158e-01f, 2.91468531e-01f, 2.16211751e-03f,
  6.20206520e-02f, -5.14371336e-01f, -4.80401218e-01f, 6.19339682e-02f, 2.20242336e-01f, 8.74908045e-02f, -3.21215652e-02f, 9.67457145e-02f, 1.38945475e-01f, -2.43805364e-01f,
  -1.35987595e-01f, 1.19133703e-01f, 1.03755482e-01f, 3.53867374e-02f, 5.74870780e-02f, -1.48827545e-02f, 1.88295618e-01f, 2.91729476e-02f, 1.14329465e-01f, -6.78734928e-02f,
  1.32005051e-01f, -1.77208707e-01f, 3.15843113e-02f, -1.39413849e-01f, 1.34435680e-03f, -6.01363108e-02f, -4.82931361e-03f, 1.24474458e-01f, 5.57108931e-02f, 1.39816031e-01f,
  -3.69959436e-02f, 9.41088274e-02f, 2.11044382e-02f, 2.77132243e-01f, 1.31879061e-01f, 2.31966600e-01f, -2.01150879e-01f, -1.75315514e-01f, -2.34506279e-01f, -4.89178598e-02f,
  -7.19301581e-01f, 5.40834308e-01f, -4.78748560e-01f, 1.85579315e-01f, -1.82082266e-01f, -7.43895024e-02f, -9.87157971e-03f, -1.10162720e-01f, -1.77325860e-01f, 6.21196721e-03f,
  -2.40882695e-01f, -3.30240577e-02f, 4.06866260e-02f, 1.82340160e-01f, -8.63142461e-02f, -2.32745945e-01f, -2.13363320e-02f, -2.21545368e-01f, 4.77233902e-02f, -7.32892826e-02f,
  -3.10320035e-03f, -4.97793674e-01f, -9.06477153e-01f, -3.18686396e-01f, -5.02973557e-01f, -5.53554893e-01f, -2.37859324e-01f, -4.85020161e-01f, -5.35612941e-01f, -6.51885211e-01f,
  9.26088810e-01f, -4.61414605e-01f, -3.58622074e-01f, 2.63843954e-01f, -7.57635161e-02f, 3.13626304e-02f, -3.86597849e-02f, 1.48522422e-01f, 2.82488257e-01f, 1.19861541e-02f,
  -5.44442888e-03f, 2.03441709e-01f, 1.57357514e-01f, 4.85744067e-02f, 2.28930622e-01f, -1.05672181e-01f, 7.60123953e-02f, 1.28284618e-01f, 1.48111105e-01f, -7.65276048e-03f,
  7.85691838e-04f, 4.86299135e-02f, 6.80619180e-02f, 3.10597885e-02f, -2.62784332e-01f, 2.49867328e-02f, -1.47003233e-01f, -1.54433146e-01f, -3.16176564e-01f, -4.89607155e-01f,
  -9.25250590e-01f, -1.27730787e-01f, 2.74260253e-01f, 1.84420943e-02f, -1.02443323e-01f, 3.84408608e-03f, 3.82409878e-02f, 2.48347595e-02f, 1.89641602e-02f, -8.39810073e-02f,
  -1.45626187e-01f, -8.56522396e-02f, -9.26409811e-02f, -1.77630395e-01f, -1.43169001e-01f, -7.14479014e-02f, 5.39568886e-02f, 7.14573339e-02f, 8.29135180e-02f, -2.91341804e-02f,
  -1.71134382e-01f, 7.45601356e-02f, 7.33611034e-03f, 1.63353801e-01f, 1.13553643e-01f, 1.29149497e-01f, -1.74731240e-01f, -1.31159462e-02f, 1.30694613e-01f, 2.22504929e-01f,
  5.11263609e-02f, -4.62616934e-03f, 1.16978347e-01f, 1.34603590e-01f, 1.45070270e-01f, 1.44803092e-01f, 9.17831510e-02f, 8.37916881e-03f, 2.73698151e-01f, 6.32127225e-02f,
  -5.72463088e-02f, 9.97335240e-02f, 3.68186049e-02f, 1.95574865e-01f, -3.25719528e-02f, -1.34892434e-01f, -9.52542797e-02f, -1.49421260e-01f, -2.68666819e-02f, 4.72124964e-02f,
  1.13372067e-02f, 1.31087461e-02f, -1.51369855e-01f, -1.98959023e-01f, -1.99875683e-01f, -7.79765174e-02f, 2.52449103e-02f, -1.28637999e-01f, -5.54055013e-02f, -1.66426990e-02f,
  -2.86436349e-01f, 2.25909740e-01f, 1.21472649e-01f, -5.83865773e-03f, -1.05315693e-01f, -9.95577052e-02f, -1.42741506e-03f, -2.03436762e-02f, -2.21830204e-01f, -1.32525235e-01f,
  -2.02957734e-01f, -3.43536399e-02f, -2.77074397e-01f, -3.63085233e-02f, 1.30233973e-01f, -8.15968290e-02f, -1.61399674e-02f, 1.59166120e-02f, -8.98663551e-02f, -2.98581719e-01f,
  -7.62750059e-02f, 2.58855641e-01f, 1.98692709e-01f, 2.51610905e-01f, 1.75903857e-01f, 2.85506248e-01f, 4.84615080e-02f, -4.50952947e-02f, 1.97473913e-01f, 4.02667552e-01f,
  9.82577682e-01f, 1.05927718e+00f, -4.32721704e-01f, 3.38511579e-02f, -9.57017481e-01f, -6.59695864e-01f, 2.28654429e-01f, 3.45728517e-01f, -1.36004090e-01f, 1.49596646e-01f,
  -1.14069916e-01f, -5.13706282e-02f, 2.60627389e-01f, -1.70499589e-02f, 3.30230743e-01f, 2.15512097e-01f, -1.99117199e-01f, -1.48663949e-02f, -1.54586226e-01f, -2.72818774e-01f,
  9.79713276e-02f, 3.09375256e-01f, 4.36708987e-01f, 1.75962850e-01f, -3.95992547e-02f, -1.67707205e-01f, 8.03340320e-03f, -2.19472781e-01f, -3.17777276e-01f, -2.06733435e-01f,
  8.20871070e-02f, -6.04878999e-02f, -2.58121759e-01f, -1.54186532e-01f, -1.47552323e-02f, 3.78867328e-01f, 2.07122311e-01f, 1.87358946e-01f, 1.18502140e-01f, 2.05821708e-01f,
  -2.65992045e-01f, -8.96143168e-02f, -1.20423883e-01f, 9.01275277e-02f, 1.13792919e-01f, 7.08045959e-02f, 9.75880623e-02f, 6.33176342e-02f, 1.96235389e-01f, 6.38147295e-02f,
  -1.57104343e-01f, -5.44424891e-01f, -3.22893232e-01f, -2.08269686e-01f, -2.07675546e-01f, -4.17714626e-01f, -1.42189130e-01f, -2.39306912e-01f, -2.61855990e-01f, 3.13233197e-01f,
  7.74459019e-02f, 1.64799213e-01f, -2.06485063e-01f, -6.31316751e-02f, 5.48314378e-02f, -3.06425411e-02f, -3.49590294e-02f, 4.84958477e-02f, -1.11428551e-01f, 7.80925751e-02f,
  -4.07022312e-02f, -1.47632807e-01f, -3.40862945e-02f, 1.19457230e-01f, -4.19625686e-03f, -1.40305474e-01f, -1.25015244e-01f, 1.07099218e-02f, -1.20799214e-01f, 7.06928074e-02f,
  -2.40508467e-02f, -9.81255546e-02f, 4.14903201e-02f, 7.50244260e-02f, -2.18791261e-01f, 4.35674712e-02f, -6.35723770e-02f, 3.02544814e-02f, 1.58139393e-01f, 8.38746578e-02f,
  5.29970229e-01f, -6.84425950e-01f, 2.25333259e-01f, 9.90816113e-03f, -1.02835044e-01f, 1.77047569e-02f, -1.67648479e-01f, -2.29266509e-01f, -2.58607585e-02f, 9.50554460e-02f,
  -6.87274560e-02f, 1.57336429e-01f, 5.50143681e-02f, 4.04873639e-02f, -9.62324813e-02f, -1.67825416e-01f, 1.22707877e-02f, -1.00927189e-01f, -6.30207956e-02f, 4.55951765e-02f,
  1.38670221e-01f, 6.71531036e-02f, 1.98594823e-01f, 6.78087473e-02f, -2.03158334e-02f, -3.41602154e-02f, 2.30734348e-01f, 2.51580849e-02f, 4.72311042e-02f, 6.58787251e-01f,
  3.41708153e-01f, -1.30082173e-02f, 2.52842963e-01f, 5.30361056e-01f, 1.78015515e-01f, -7.28105307e-01f, -1.41799235e+00f, -5.83935082e-01f, 5.87589860e-01f, 7.11806566e-02f,
  1.00089669e-01f, 3.86973262e-01f, 4.85343575e-01f, -1.10280126e-01f, -9.04776931e-01f, -5.20612836e-01f, -1.38845474e-01f, -3.18496495e-01f, -5.01081824e-01f, -6.31221175e-01f,
  -2.65863180e-01f, 2.70288885e-01f, 1.06538445e-01f, -3.77187170e-02f, 6.38789475e-01f, 4.66606587e-01f, 7.10967660e-01f, 6.00173593e-01f, -1.85168892e-01f, 4.43795502e-01f,
  3.48386407e-01f, 2.65921861e-01f, -4.10658956e-01f, 1.92744613e-01f, 3.94698024e-01f, -2.71812290e-01f, -1.86764508e-01f, 4.10420746e-01f, -1.31467283e-01f, -2.93243602e-02f,
  3.58639210e-01f, -7.99286440e-02f, 2.83479631e-01f, 7.64469355e-02f, 1.03173263e-01f, -4.18797165e-01f, 2.73506134e-03f, -2.39484459e-01f, 1.09349226e-03f, -1.69969290e-01f,
  -2.62337685e-01f, 2.28872709e-02f, -1.56284362e-01f, -4.02418226e-01f, -1.21776156e-01f, 1.21333776e-02f, -2.07959905e-01f, -2.22864538e-01f, -2.06842139e-01f, 2.97551334e-01f,
  -1.79260120e-01f, 7.31049180e-02f, -3.69824395e-02f, 8.99158716e-02f, -1.46676600e-01f, 1.54969439e-01f, 1.92588493e-01f, -9.83239189e-02f, -3.46549973e-02f, -1.87571477e-02f,
  -8.96302685e-02f, 3.22698280e-02f, 7.83585981e-02f, -7.74091296e-03f, 1.65449604e-02f, -4.24857363e-02f, -2.08801195e-01f, -1.58552498e-01f, -6.23451695e-02f, 7.22761974e-02f,
  4.46800655e-03f, -9.01009664e-02f, 3.38371366e-01f, -1.40437931e-01f, 4.71487129e-03f, -8.40503499e-02f, -2.95256991e-02f, -3.27489413e-02f, 6.28465489e-02f, 1.03447594e-01f,
  3.26583922e-01f, -3.21587920e-01f, 1.03403851e-01f, -2.17095986e-01f, -4.05883156e-02f, 6.87630195e-03f, 2.18434274e-01f, -1.15080416e-01f, 2.54349947e-01f, -9.22721252e-02f,
  -2.09909990e-01f, -1.49626374e-01f, 3.63640457e-01f, -9.54741463e-02f, -1.77199677e-01f, -1.28977790e-01f, -4.30765264e-02f, -1.17490001e-01f, -3.36596102e-01f, 2.35416368e-02f,
  3.11423745e-02f, -6.33171737e-01f, -4.20126617e-01f, -2.89116412e-01f, 2.72582352e-01f, -2.26982877e-01f, -1.99407160e-01f, -3.96816730e-01f, -6.63667142e-01f, -3.33041519e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.25995016e+00f, 1.11326170e+00f, 3.38972330e-01f, 7.82434821e-01f, 8.99582744e-01f, 1.62333083e+00f, 1.01505184e+00f, 8.75985622e-01f, 5.87699294e-01f, 5.99115908e-01f,
  1.16001022e+00f, 7.20962644e-01f, 1.27681768e+00f, 9.76908743e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.56735972e-01f, 9.80410650e-02f, -1.11027789e+00f, -1.07271695e+00f, 5.14999866e-01f, 2.33509704e-01f, -6.82599247e-01f, -8.11306059e-01f, -9.75373149e-01f, 7.94102073e-01f,
  7.38518536e-01f, -5.75440586e-01f, -7.12867498e-01f, 1.05941899e-01f, -8.44235063e-01f, -6.43158913e-01f, -1.32003367e-01f, 3.35733205e-01f, 5.70029259e-01f, -1.60470176e+00f,
  -6.00733399e-01f, -1.36009324e+00f, 1.50697470e-01f, 8.50908086e-02f, -4.23877656e-01f, 1.24089539e+00f, 3.67181152e-01f, 4.54775274e-01f, -1.37184465e+00f, 7.26389885e-01f,
  -2.62261868e-01f, -1.02522695e+00f, 1.00441329e-01f, 4.49688375e-01f, 6.08628571e-01f, -9.04944122e-01f, 1.84720963e-01f, -4.10070360e-01f, -7.98210859e-01f, 8.82011652e-01f,
  -1.11321819e+00f, 5.98897457e-01f, -1.13076794e+00f, -1.38116956e+00f, 1.07622862e+00f, -2.42798448e-01f, -4.90645677e-01f, -1.56180374e-03f, -3.63182873e-02f, -1.80459693e-01f,
  -8.85465562e-01f, -1.18129604e-01f, 3.21181953e-01f, 8.41879129e-01f, -3.06334019e-01f, -3.91817331e-01f, 1.01158392e+00f, -1.36057937e+00f, -5.53999066e-01f, -1.08428907e+00f,
  6.92869604e-01f, -2.28621870e-01f, -1.85662401e+00f, -1.89556146e+00f, -1.29365891e-01f, -5.90012334e-02f, -1.59557045e-01f, -4.98522371e-01f, 2.55045205e-01f, 1.81483775e-01f,
  -1.07763004e+00f, -1.07133043e+00f, 7.60364890e-01f, -1.03437948e+00f, -3.17595631e-01f, -1.27685285e+00f, -4.69542533e-01f, 5.08864224e-02f, -2.02994153e-01f, 1.28650343e+00f,
  2.93848634e-01f, 2.90071547e-01f, -4.97359574e-01f, 5.74581206e-01f, -7.19941258e-01f, -1.02221620e+00f, 2.16310307e-01f, -1.62571061e+00f, 3.20876157e-03f, -2.01087862e-01f,
  8.79769623e-01f, -3.18120182e-01f, -5.39753556e-01f, 1.21239163e-01f, 9.83702719e-01f, 8.04193094e-02f, 3.10417295e-01f, -2.28284538e-01f, 2.27271914e-01f, -7.70178974e-01f,
  -1.11594069e+00f, -1.12706161e+00f, -1.21359098e+00f, 4.26415235e-01f, -9.78120744e-01f, -1.48905492e+00f, -1.17006576e+00f, 2.46005848e-01f, 8.63602698e-01f, -1.16658652e+00f,
  1.19472134e+00f, 1.45867690e-01f, -5.76811612e-01f, -3.01184028e-01f, -1.20725679e+00f, 1.65506825e-01f, -2.45375242e-02f, -7.48803377e-01f, 9.34757650e-01f, -7.04110086e-01f,
  -6.91115558e-01f, -1.35327792e+00f, -6.88617706e-01f, -1.07065886e-01f, 9.58909512e-01f, -1.24099426e-01f, -4.88756597e-01f, -6.95131838e-01f, -2.16196224e-01f, 4.25248027e-01f,
  -8.08445871e-01f, 1.54416883e+00f, -6.86503887e-01f, -1.09598541e+00f, 3.52582261e-02f, 9.39000010e-01f, -5.80588281e-01f, 2.45488241e-01f, -1.16675830e+00f, -1.90673172e-01f,
  -4.15105760e-01f, 1.05348095e-01f, -1.35941505e+00f, -8.65505934e-01f, -5.22779882e-01f, -4.18783784e-01f, 5.18303990e-01f, -1.15697336e+00f, 7.72676945e-01f, -1.19419968e+00f,
  3.44998121e-01f, -1.08093548e+00f, -1.36944699e+00f, -8.34011316e-01f, 8.82750005e-02f, -2.13438813e-02f, -4.81030941e-01f, -1.47682309e+00f, -1.11262846e+00f, 1.08724737e+00f,
  2.70518154e-01f, -9.64669883e-02f, -1.32672811e+00f, -8.28362465e-01f, -7.19760776e-01f, 1.20929927e-02f, 5.40648699e-01f, 1.05740499e+00f, 5.21169543e-01f, -1.03435263e-01f,
  -1.22025836e+00f, -5.21223783e-01f, -6.92546844e-01f, -1.19712591e+00f, 2.68626601e-01f, -3.08393897e-03f, 1.74053207e-01f, 6.26001537e-01f, 1.68254763e-01f, 4.88480449e-01f,
  -7.31122851e-01f, 1.47917175e+00f, -6.30251288e-01f, -9.73772585e-01f, -4.77669656e-01f, -6.01677656e-01f, -7.57303476e-01f, 7.33835995e-01f, -7.45370328e-01f, -1.16239083e+00f,
  -1.16004005e-01f, -8.48881423e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  5.70552766e-01f, -7.57499456e-01f, 2.23148912e-01f, -6.88514948e-01f, 5.68714559e-01f, -4.31415349e-01f, 8.97956714e-02f, -1.03150204e-01f, -2.07725279e-02f, 3.61073822e-01f,
  -1.15024281e+00f, 3.01790714e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    