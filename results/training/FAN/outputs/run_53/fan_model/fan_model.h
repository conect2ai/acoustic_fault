/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.60223246e-02f, 1.50049537e-01f, 4.40601885e-01f, 2.11897552e-01f, -2.79164582e-01f, -1.68851376e-01f, 8.36487263e-02f, -3.24709207e-01f, -1.63010806e-01f, -4.00941074e-01f,
  -9.59662423e-02f, 2.89777040e-01f, 3.91664207e-02f, -2.97818035e-01f, 3.09238613e-01f, -4.71131913e-02f, -1.41734809e-01f, 2.23745257e-02f, 6.38125911e-02f, 1.33302078e-01f,
  -1.56879142e-01f, -3.54763448e-01f, 7.23512322e-02f, -2.81681299e-01f, -1.46399394e-01f, 2.76410550e-01f, 1.05889454e-01f, 1.25377223e-01f, -1.50042688e-02f, -2.92187277e-03f,
  -1.76550865e-01f, -3.67965214e-02f, -8.20261315e-02f, 2.49229185e-02f, 4.29658853e-02f, -3.75857800e-02f, 4.05053124e-02f, 1.73850372e-01f, 6.11081868e-02f, 1.08934835e-01f,
  -2.70806625e-02f, -6.99642450e-02f, -3.71832703e-03f, -4.08509299e-02f, -1.26119718e-01f, 3.64449061e-02f, -6.99705333e-02f, 1.83863085e-05f, -7.64586776e-02f, 7.09777232e-03f,
  2.91955117e-02f, -5.19717298e-02f, 1.44537687e-02f, 2.12342486e-01f, 1.11321799e-01f, -6.10468052e-02f, 8.22986662e-02f, 2.02097297e-01f, 7.75409564e-02f, -4.01758887e-02f,
  -1.50130406e-01f, -2.45503765e-02f, 9.99221392e-03f, -9.74414423e-02f, 4.05508392e-02f, -5.61579391e-02f, -7.22247139e-02f, -1.28934994e-01f, 9.88266394e-02f, 1.07277632e-02f,
  -3.09619661e-02f, 2.50700507e-02f, -1.54118627e-01f, -8.79689213e-03f, -9.59710553e-02f, -1.83318064e-01f, 1.24107495e-01f, 6.17706589e-02f, 6.74805939e-02f, -1.19313642e-01f,
  1.74106527e-02f, 2.03472581e-02f, 1.02854729e-01f, -5.53111061e-02f, -5.67295477e-02f, 7.53652900e-02f, -2.98634589e-01f, 4.23441641e-02f, -1.67740017e-01f, 1.16727389e-01f,
  1.68110788e-01f, 1.43296465e-01f, 2.34059915e-02f, -9.35223177e-02f, 6.65649697e-02f, -7.16759339e-02f, 2.80687772e-02f, -1.87350381e-02f, 1.60452545e-01f, -1.17203452e-01f,
  -3.64788100e-02f, -6.24739788e-02f, 1.21167131e-01f, -1.46350330e-02f, 1.20678373e-01f, -1.77392215e-02f, -5.24507761e-02f, 4.36236802e-03f, 2.15285290e-02f, 2.68158149e-02f,
  3.20683457e-02f, 6.38883114e-02f, 6.37592981e-03f, -2.38842815e-02f, -4.67198789e-02f, 8.49212110e-02f, 8.81510004e-02f, 5.87646402e-02f, 1.98110007e-02f, -3.66829830e-04f,
  -5.48938453e-01f, 4.69760716e-01f, -1.75032616e-01f, -5.39832413e-01f, 2.97691524e-01f, 3.41051072e-01f, -3.43010157e-01f, 2.46787697e-01f, -3.89529139e-01f, 2.93522745e-01f,
  2.02004433e-01f, -2.63139248e-01f, -5.16546182e-02f, 2.73631990e-01f, -1.02309190e-01f, -1.69905037e-01f, -6.45162389e-02f, -1.31510571e-01f, -1.35035560e-01f, 1.12408981e-01f,
  -1.74847752e-01f, 3.00424516e-01f, -4.25621979e-02f, 3.34300548e-01f, 1.62704259e-01f, -1.88641638e-01f, 1.74282581e-01f, -3.89145650e-02f, 2.21993431e-01f, 7.25612417e-02f,
  -2.16930714e-02f, -7.44498335e-03f, -2.44155619e-02f, -1.77813116e-02f, 3.18292081e-02f, 1.76987294e-02f, -8.12950432e-02f, -2.59837974e-02f, -1.07663594e-01f, -1.25110805e-01f,
  -5.71666770e-02f, 9.80261993e-03f, -3.17030512e-02f, -5.37522733e-02f, 6.40317351e-02f, -1.99538022e-02f, 1.59226861e-02f, 4.41246480e-03f, 4.22300026e-03f, 2.56988835e-02f,
  -3.21723409e-02f, -2.34518070e-02f, 4.92297895e-02f, -3.97763737e-02f, -5.06659523e-02f, -1.02260180e-01f, 1.61299910e-02f, -6.92023188e-02f, -1.55407833e-02f, 6.20364547e-02f,
  9.68500599e-03f, -6.54850388e-03f, 9.65568470e-04f, 3.75129580e-02f, -8.52737296e-03f, -1.21816285e-02f, 1.93030946e-02f, 5.93363121e-02f, -1.29475430e-01f, 1.21506028e-01f,
  -2.98162196e-02f, -3.85032408e-02f, 4.77095228e-03f, 1.31623019e-02f, -3.46143567e-03f, -5.80865405e-02f, -3.01940870e-02f, 7.86056146e-02f, -8.18533823e-02f, 2.15417333e-02f,
  -3.74179706e-02f, 3.07703158e-04f, -9.32093989e-03f, -2.50853170e-02f, 3.29215527e-02f, -7.09575973e-03f, 4.20684367e-02f, 1.76125988e-02f, -1.00105545e-02f, 3.99053320e-02f,
  1.31615654e-01f, 2.27878347e-01f, -5.49391396e-02f, 2.14128271e-02f, 5.38824778e-03f, 8.89255852e-02f, -5.56694530e-02f, 2.96713226e-02f, 3.65827642e-02f, 1.36452377e-01f,
  2.01105438e-02f, -2.06913743e-02f, -1.12561947e-02f, 1.71089862e-02f, -1.06207579e-02f, 1.35695636e-01f, -7.92258978e-03f, -5.66262901e-02f, -5.52436011e-03f, 5.87359481e-02f,
  1.04314730e-01f, -2.28803977e-02f, -8.11290815e-02f, 8.55032131e-02f, 7.56828189e-02f, 7.71055594e-02f, 3.69663984e-02f, -4.21337485e-02f, 5.81611544e-02f, -3.53512429e-02f,
  -6.32442415e-01f, -1.58537835e-01f, -3.27760220e-01f, -1.97283179e-01f, -2.04756819e-02f, 4.37176615e-01f, 3.14824671e-01f, -3.50565054e-02f, -2.31969357e-01f, 3.64781797e-01f,
  2.33633026e-01f, -2.62585729e-01f, 7.00184852e-02f, 3.11133415e-01f, 2.71972537e-01f, 1.84876204e-01f, 2.46547058e-01f, 7.79911727e-02f, -1.54868379e-01f, -1.43215790e-01f,
  -6.76284507e-02f, 2.35818654e-01f, 1.22914657e-01f, -7.31731206e-02f, -1.35431767e-01f, -1.61425516e-01f, 1.64137363e-01f, -8.96682292e-02f, 1.27703339e-01f, 1.15514338e-01f,
  -7.46766254e-02f, -3.53729337e-01f, -8.84726793e-02f, -5.33004105e-02f, 4.13030013e-02f, -1.06054498e-02f, 1.03150398e-01f, -1.01597924e-02f, -3.47546255e-03f, 5.93440142e-03f,
  -1.85362604e-02f, -7.96070844e-02f, -9.79797170e-03f, 7.79080689e-02f, 8.94867331e-02f, -1.62925851e-02f, -5.89661673e-02f, 2.99284458e-02f, -1.88671246e-01f, -8.49713683e-02f,
  -4.95723858e-02f, 9.07566547e-02f, 7.09778816e-02f, 1.54481485e-01f, 9.67228692e-03f, -1.60534848e-02f, -2.57295724e-02f, 4.34001647e-02f, 1.20347597e-01f, -1.46703377e-01f,
  2.14436743e-03f, -6.33985549e-02f, 3.77657600e-02f, 5.92065454e-02f, 2.35755108e-02f, -5.55295199e-02f, 7.20444322e-02f, -2.65797041e-03f, 4.22597900e-02f, -1.50396861e-02f,
  1.20423488e-01f, -8.35734010e-02f, 1.26457065e-02f, 3.29693519e-02f, -7.07308436e-03f, 4.53669280e-02f, 2.41017481e-03f, -8.15910846e-03f, 1.63987633e-02f, -1.18841128e-02f,
  -5.26865311e-02f, 1.00658044e-01f, -2.35746447e-02f, 3.73575985e-02f, 1.30006537e-01f, 2.95651555e-02f, 6.44268421e-03f, 2.91631538e-02f, -2.02875063e-02f, -4.70338985e-02f,
  7.23698959e-02f, -4.05734889e-02f, 1.35246962e-02f, 4.96353246e-02f, -6.64552748e-02f, 5.42399064e-02f, -7.13369474e-02f, -6.90067783e-02f, 2.70814588e-03f, 9.12612211e-03f,
  -6.92812901e-04f, 2.94271242e-02f, 3.85181755e-02f, -4.59371321e-03f, -5.45191839e-02f, 2.95399083e-03f, 5.50716482e-02f, 5.43526076e-02f, 1.39668167e-01f, 6.41190633e-02f,
  4.72233035e-02f, 2.91439686e-02f, -4.12460901e-02f, -1.02506122e-02f, -2.82460414e-02f, 6.32645562e-02f, -8.69834870e-02f, -5.26586697e-02f, 2.13233437e-02f, 1.08091682e-02f,
  -5.38348019e-01f, -3.26770954e-02f, -5.95394485e-02f, 1.64390236e-01f, -2.66918927e-01f, -4.42923218e-01f, -2.16394797e-01f, -1.13378182e-01f, -1.66827634e-01f, -3.49695869e-02f,
  -1.35996714e-01f, -1.34158716e-01f, -1.04841150e-01f, 1.86346203e-01f, -4.49180342e-02f, -2.73601171e-02f, 5.71485311e-02f, -1.85738668e-01f, 4.75272425e-02f, -1.49238423e-01f,
  1.14749178e-01f, 3.22076753e-02f, 1.28959417e-01f, -1.38884615e-02f, -2.54634738e-01f, 2.57945396e-02f, -6.21208455e-03f, 7.74372891e-02f, 9.51061025e-02f, -6.50857016e-02f,
  -9.67883617e-02f, 6.49901107e-02f, -1.10553339e-01f, 1.28192613e-02f, -6.30862117e-02f, -1.29717896e-02f, -1.11003324e-01f, -2.41466258e-02f, 1.09680422e-01f, -4.59521152e-02f,
  -2.50214841e-02f, 3.10207326e-02f, 2.63527725e-02f, 1.95988584e-02f, -1.49267748e-01f, -7.63442591e-02f, -2.69428175e-02f, 1.01731317e-02f, -4.23733564e-03f, -8.31827114e-04f,
  6.64575249e-02f, 7.59003833e-02f, 5.56917638e-02f, -5.03773317e-02f, -3.94519269e-02f, -5.31588607e-02f, 4.02004458e-02f, -4.25381251e-02f, -1.42594606e-01f, -7.64146447e-02f,
  1.86892040e-02f, 2.94065550e-02f, 1.50299503e-03f, -3.92004056e-03f, -8.11833516e-02f, -6.34995922e-02f, 1.14264330e-02f, 1.25187719e-02f, -2.11980641e-02f, -7.20486417e-02f,
  -7.49892592e-02f, -5.52097335e-02f, 5.68683520e-02f, 1.06096333e-02f, 5.49962856e-02f, -5.75853139e-03f, 1.65778883e-02f, -6.80382326e-02f, -7.23790228e-02f, -1.52584407e-02f,
  2.54716743e-02f, -2.10914724e-02f, 5.27189439e-03f, -9.68845934e-03f, -1.10879522e-02f, 2.59720348e-03f, 7.64437346e-03f, 3.20734493e-02f, -7.47187063e-02f, -9.74984989e-02f,
  -2.93605089e-01f, -1.33544415e-01f, 3.42220888e-02f, -2.67775673e-02f, -7.38216788e-02f, -2.76208036e-02f, 1.27661929e-01f, -4.10054661e-02f, -6.40708506e-02f, -6.24312907e-02f,
  3.31204981e-02f, -6.04034960e-02f, 3.26931733e-03f, -1.27714977e-01f, 3.30505483e-02f, -1.17996847e-02f, 2.48125438e-02f, -1.44517288e-01f, -1.42639488e-01f, -5.15992604e-02f,
  -5.95790036e-02f, 2.98127625e-03f, 4.09074128e-02f, -8.68470594e-02f, -7.24064112e-02f, -1.00567453e-02f, -3.98478955e-02f, 7.12154433e-02f, 6.03107810e-02f, 2.64330357e-02f,
  4.99183595e-01f, -1.06210127e-01f, 2.46384084e-01f, 5.79075694e-01f, -8.65032673e-02f, 7.77757242e-02f, 2.59156048e-01f, 5.96109927e-02f, 3.04534674e-01f, -2.02525720e-01f,
  5.31914737e-03f, 5.41282445e-02f, -2.75770277e-01f, 2.15230152e-01f, 3.12203467e-01f, -2.40999311e-01f, 4.32732046e-01f, 1.72158390e-01f, -8.84138271e-02f, 3.74425612e-02f,
  1.66115597e-01f, 7.30518997e-02f, 1.67719036e-01f, -1.41011655e-01f, 8.27258974e-02f, 5.46698533e-02f, -4.97684777e-02f, -8.37899819e-02f, 1.19493306e-01f, -7.62346908e-02f,
  8.67611468e-02f, -1.02895923e-01f, 3.83801125e-02f, -1.81385241e-02f, -4.70007071e-03f, -3.98101099e-02f, 3.81085873e-02f, -2.33578105e-02f, 5.77420443e-02f, 2.87151604e-04f,
  1.86384209e-02f, -3.31504047e-02f, 1.78713072e-02f, 2.93646567e-02f, 7.57046714e-02f, 3.58134471e-02f, 3.90995517e-02f, 1.30597847e-02f, -5.68794943e-02f, -2.30921339e-02f,
  -2.39437595e-02f, 2.60484833e-02f, 1.25662446e-01f, -5.62280603e-02f, 5.15556373e-02f, 1.99759789e-02f, 5.00525087e-02f, -1.70311145e-02f, -2.13820003e-02f, 3.73296835e-03f,
  -1.06404334e-01f, -2.61890556e-04f, 2.06671674e-02f, 3.86624001e-02f, 2.19339021e-02f, -1.39222760e-02f, 1.81692559e-02f, -6.12683259e-02f, 1.99425388e-02f, -4.70067486e-02f,
  9.40657184e-02f, 2.67472398e-02f, 6.21064520e-03f, 2.55563110e-02f, 3.17874178e-02f, 3.49692032e-02f, 4.40561324e-02f, -1.04453087e-01f, 6.52019382e-02f, 1.98637992e-02f,
  -3.11834365e-02f, 2.66770255e-02f, 1.48913534e-02f, -6.27783462e-02f, 1.12659363e-02f, 1.44547625e-02f, -2.96009183e-02f, 8.12759344e-03f, 3.61542515e-02f, 1.10604756e-01f,
  -8.25684741e-02f, -7.61647597e-02f, -4.37679328e-02f, 1.77359767e-02f, -8.20794888e-03f, 1.12532098e-02f, 2.26872396e-02f, 2.58755982e-02f, 1.96681432e-02f, 1.76994875e-02f,
  -1.40109500e-02f, 5.30306511e-02f, -7.59926066e-02f, -3.91614325e-02f, 6.67544305e-02f, -6.33386970e-02f, 8.21398664e-03f, 1.92690026e-02f, 3.82675566e-02f, -1.23986071e-02f,
  1.11240568e-02f, -5.43839112e-02f, 6.76347921e-03f, 4.86756006e-04f, -6.05002381e-02f, -4.86052744e-02f, 2.89766602e-02f, 5.69479652e-02f, -6.83500394e-02f, 2.34480146e-02f,
  -3.11677366e-01f, 3.79406095e-01f, -2.10066680e-02f, -3.44585031e-01f, -9.42581706e-03f, 1.03734173e-01f, 2.90435344e-01f, 1.31944433e-01f, -3.88250411e-01f, 3.91716033e-01f,
  2.07742542e-01f, -1.05209574e-01f, 2.66220301e-01f, 2.89873600e-01f, -2.90058851e-01f, 1.84317023e-01f, -1.07466087e-01f, 4.11590636e-02f, -1.47039548e-01f, 1.85026437e-01f,
  -2.21355655e-03f, 1.92036822e-01f, 2.06284657e-01f, -2.47132629e-02f, 9.62126181e-02f, -1.20009102e-01f, -1.30271278e-02f, -6.01058193e-02f, 2.93914694e-02f, -9.97570306e-02f,
  6.61978796e-02f, 8.73532668e-02f, 8.60162303e-02f, 2.82006059e-02f, -1.10695546e-03f, 7.32184872e-02f, -2.39568595e-02f, -1.42311109e-02f, -1.77456737e-01f, 1.45282280e-02f,
  1.33500233e-01f, -8.60616714e-02f, -7.85550326e-02f, -1.28763020e-01f, -1.10023826e-01f, -8.15505683e-02f, -8.41401517e-02f, 7.36696720e-02f, -4.11465056e-02f, 3.01032867e-02f,
  8.92450809e-02f, 6.79239705e-02f, 1.87747017e-03f, -1.03221856e-01f, -4.47665788e-02f, -7.92746469e-02f, -3.16564590e-02f, -3.95859964e-02f, -4.53188494e-02f, -1.83417380e-01f,
  -5.04713447e-04f, 9.23616346e-03f, 9.39584523e-03f, 1.03504583e-02f, -4.55772988e-02f, 6.85426369e-02f, -1.46839634e-01f, 1.01855673e-01f, -9.05990824e-02f, 4.12572473e-02f,
  -4.28325422e-02f, -7.24195223e-03f, -4.76941243e-02f, -4.10106219e-02f, 4.50551659e-02f, 2.24329308e-02f, 2.48894952e-02f, -7.31749460e-02f, 6.37078807e-02f, 2.54646055e-02f,
  1.28512129e-01f, -7.24219456e-02f, 1.21032594e-04f, 3.81881148e-02f, -3.52690592e-02f, -5.42526208e-02f, 6.05236143e-02f, 4.95336317e-02f, -1.09794009e-02f, -1.89079773e-02f,
  -2.87783593e-02f, -2.29674485e-02f, 4.88600507e-02f, -1.50546832e-02f, 1.23531569e-03f, 1.00417517e-01f, -5.40356040e-02f, -5.87412193e-02f, -1.16943143e-01f, 3.44471931e-02f,
  4.36853468e-02f, 8.27090535e-03f, 9.70575586e-02f, -1.41407317e-02f, -1.64178461e-02f, 1.18413687e-01f, 1.33664403e-02f, 2.33515985e-02f, -6.21934831e-02f, -3.47392969e-02f,
  2.73549575e-02f, -2.67993659e-02f, 4.24240623e-03f, 9.70936641e-02f, 6.00697137e-02f, 4.42724600e-02f, -7.11782128e-02f, -6.71372190e-02f, -2.57915854e-02f, 3.22698988e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.21632028e-01f, -4.99751329e-01f, -3.33710015e-01f, 4.32697833e-02f, 3.62291127e-01f, 4.21154946e-01f, 4.71476793e-01f, -2.29619443e-01f, -5.81658483e-01f, -3.59712332e-01f,
  3.72687340e-01f, -2.81491391e-02f, -1.56658364e-03f, 2.60197163e-01f, 8.08310390e-01f, -5.10671660e-02f, 1.29169285e-01f, 2.77089328e-01f, -1.85371116e-01f, 4.86313365e-03f,
  -4.82094996e-02f, 4.63762850e-01f, -3.32559012e-02f, -2.93338805e-01f, 4.47259456e-01f, -3.08321863e-01f, -2.53153238e-02f, -9.53199808e-03f, 8.29012990e-02f, 3.43381822e-01f,
  1.15489632e-01f, -2.12125763e-01f, -1.40736904e-02f, -3.76346707e-02f, -5.64600118e-02f, 1.08459815e-01f, 2.13637412e-01f, 2.54821450e-01f, 1.37572512e-01f, -2.36614421e-02f,
  1.25767231e-01f, 7.48598948e-02f, -2.48163082e-02f, 8.76887888e-02f, 2.08925419e-02f, -1.37708277e-01f, -1.28295749e-01f, -1.05181076e-01f, -1.16432071e-01f, 2.83096619e-02f,
  -8.19568560e-02f, 1.23436283e-02f, 1.62440650e-02f, -3.47007811e-02f, -5.14152050e-02f, 3.64109613e-02f, -1.43441213e-02f, 8.30475092e-02f, 9.38754454e-02f, -5.26560172e-02f,
  6.43707886e-02f, 8.56224671e-02f, -1.77593678e-02f, -2.73079947e-02f, 2.97532557e-03f, -1.62551720e-02f, 1.22711860e-01f, 8.98271948e-02f, -1.78727806e-02f, 3.33829522e-02f,
  2.92100813e-02f, -2.88578169e-03f, -8.98574665e-02f, 2.34078262e-02f, 5.30843958e-02f, 7.25450972e-03f, 1.46240413e-01f, 6.39406294e-02f, -1.23887047e-01f, 3.34660336e-03f,
  7.36330152e-02f, 7.43177393e-03f, -8.16307738e-02f, 9.10155550e-02f, 7.54812658e-02f, -6.55891150e-02f, -1.62912175e-01f, -6.17737211e-02f, -1.61327019e-01f, 1.90398574e-01f,
  -1.78773403e-01f, -4.57704425e-01f, -2.36787885e-01f, 1.59222763e-02f, -2.77003180e-02f, 1.56629514e-02f, -6.25577867e-02f, -1.37401536e-01f, -3.21578719e-02f, -8.46327096e-02f,
  -4.84473854e-02f, 2.45781504e-02f, -5.87916486e-02f, 2.61609592e-02f, 2.88100652e-02f, -2.19364673e-01f, 7.91513920e-02f, 9.72283818e-03f, 8.27422589e-02f, -5.00650778e-02f,
  -1.33248623e-02f, 8.26951414e-02f, 1.76813245e-01f, -5.41676022e-02f, -8.32090527e-02f, 1.06930263e-01f, -9.94692296e-02f, -6.16827495e-02f, 1.57265037e-01f, -2.88008340e-02f,
  3.01113874e-01f, 6.26636147e-01f, -2.24967033e-01f, 4.74952817e-01f, -4.33889717e-01f, 3.15767050e-01f, 5.41395187e-01f, -1.57283455e-01f, -1.29897511e-02f, 6.39153123e-01f,
  3.12012225e-01f, 1.50710583e-01f, 3.92927051e-01f, 7.58868873e-01f, 1.32250637e-01f, 4.78436828e-01f, 6.63532078e-01f, 4.20231998e-01f, -3.30808848e-01f, 4.53838885e-01f,
  -1.64332625e-03f, 5.28168082e-01f, 2.18645632e-01f, -2.24412948e-01f, 2.97272652e-01f, -3.20166051e-01f, -1.83649143e-04f, -4.39123780e-01f, 6.24661259e-02f, -9.79318321e-02f,
  9.21583250e-02f, 2.16739908e-01f, 1.67128965e-02f, -2.03805175e-02f, 8.96791369e-02f, -2.16816962e-02f, -4.36744057e-02f, 5.49064809e-03f, -1.50787055e-01f, -4.96002138e-02f,
  1.80931970e-01f, -1.03494257e-01f, -1.73730124e-03f, -9.06450227e-02f, -4.81149405e-02f, -1.04023956e-01f, -2.38647349e-02f, -3.67082767e-02f, -7.03411400e-02f, 2.17541590e-01f,
  1.12850524e-01f, 8.84826109e-02f, 1.33114755e-01f, 6.52021691e-02f, -2.35069469e-02f, -1.19082339e-01f, 2.55234726e-02f, -1.67564172e-02f, -3.59249488e-02f, -8.07567313e-03f,
  3.59235555e-02f, 8.24501514e-02f, 1.31215259e-01f, -3.95943150e-02f, -5.62977977e-02f, -2.54811607e-02f, 9.45619792e-02f, -2.40587424e-02f, -7.56912082e-02f, 1.22303106e-01f,
  -1.28268450e-01f, 4.65122238e-02f, 7.27641061e-02f, 1.06266312e-01f, 1.17092483e-01f, 1.38644546e-01f, -7.56281912e-02f, -5.70035502e-02f, 7.94259831e-02f, -1.64536670e-01f,
  -5.10459021e-02f, -5.21725124e-05f, 3.35527807e-02f, 1.13129960e-02f, 6.77394122e-02f, -2.15183534e-02f, 9.62281600e-02f, 4.76316959e-02f, 3.25116934e-03f, -1.20968625e-01f,
  8.24313834e-02f, 3.44241321e-01f, 8.38339254e-02f, -3.94213125e-02f, -5.59499338e-02f, 9.82101411e-02f, 9.43337530e-02f, 7.05863684e-02f, -7.02900887e-02f, 3.92774642e-02f,
  6.72690943e-02f, -4.52360846e-02f, -7.56478682e-02f, -6.06057309e-02f, -8.10308680e-02f, 1.38908640e-01f, 2.28323266e-01f, -1.16083220e-01f, 3.53298802e-03f, -7.88854249e-03f,
  1.57598108e-02f, 5.10682538e-02f, 9.72071886e-02f, -7.49192983e-02f, 1.13371857e-01f, 3.62216309e-02f, -1.15389369e-01f, -5.52215874e-02f, 2.42496934e-03f, 2.27042623e-02f,
  2.22947463e-01f, 6.38752222e-01f, 5.97767055e-01f, -3.31380278e-01f, -2.79567122e-01f, -8.36082026e-02f, -4.16759968e-01f, -4.78633866e-02f, -1.44585878e-01f, -2.42563263e-02f,
  -3.19936663e-01f, 4.79207575e-01f, -1.79702848e-01f, -8.52468908e-02f, -3.82525742e-01f, -1.30808875e-01f, -1.75289035e-01f, -1.16288766e-01f, 7.46929720e-02f, -2.02418059e-01f,
  -2.76975304e-01f, -6.81069255e-01f, -2.12953594e-02f, -4.69287664e-01f, 9.26998630e-02f, 2.92080879e-01f, -3.86177808e-01f, -2.16645986e-01f, 7.05120787e-02f, -3.13550909e-03f,
  7.78139904e-02f, -7.00723156e-02f, 2.12486550e-01f, 9.11219940e-02f, -8.86169747e-02f, 1.78719070e-02f, 6.37892485e-02f, -1.49188161e-01f, -1.14308879e-01f, 9.66719761e-02f,
  1.20728858e-01f, 9.67947990e-02f, -9.60229635e-02f, -3.24779376e-02f, -1.05549702e-02f, 1.70698017e-01f, 1.45674318e-01f, 2.24408045e-01f, 1.08122744e-01f, 2.88174093e-01f,
  1.22917429e-01f, 2.95855463e-01f, 1.31924734e-01f, 1.06476601e-02f, -8.24230909e-02f, 2.97438782e-02f, 4.40244228e-02f, 2.53256381e-01f, 1.61951870e-01f, 1.14761174e-01f,
  -3.33835967e-02f, -1.13725208e-01f, -2.89875641e-02f, 1.31895125e-01f, -1.85918137e-01f, 5.22712246e-02f, -6.36703223e-02f, -7.99501780e-03f, -2.82852426e-02f, -9.08956379e-02f,
  -9.20584351e-02f, 1.79295808e-01f, -1.10505395e-01f, -7.40493909e-02f, -8.13206192e-03f, 1.26295999e-01f, -1.06180576e-03f, 4.52592522e-02f, -4.50806059e-02f, 7.57579058e-02f,
  -7.32279122e-02f, -8.26128051e-02f, -1.01386547e-01f, 3.74478921e-02f, -4.76186350e-02f, 5.22811376e-02f, 1.80741027e-02f, 1.72613651e-01f, -4.01063226e-02f, -1.39868364e-01f,
  -2.31236860e-01f, -4.96896029e-01f, -1.56287655e-01f, 1.08155804e-02f, 1.17049343e-03f, 4.01652828e-02f, -8.54438990e-02f, 6.19199723e-02f, -9.57405344e-02f, -1.88853130e-01f,
  -2.90253549e-03f, -4.38511511e-03f, -8.21100548e-02f, 1.10283956e-01f, -6.85554966e-02f, -4.91907671e-02f, -2.51841664e-01f, -1.66414797e-01f, -1.86635122e-01f, 7.52862021e-02f,
  -3.38269658e-02f, -6.69379979e-02f, -1.51961567e-02f, -1.41323268e-01f, -8.65145847e-02f, -1.40754133e-02f, -6.48744851e-02f, 7.29233623e-02f, -1.06724828e-01f, 2.08782647e-02f,
  8.12144637e-01f, -4.92563993e-01f, -1.04891822e-01f, 3.27467099e-02f, 3.80469710e-01f, 4.00649816e-01f, 4.08119440e-01f, -3.24625187e-02f, 7.18288869e-02f, -4.33283389e-01f,
  -3.96905802e-02f, -2.31372237e-01f, -9.02411789e-02f, 5.58729731e-02f, 4.54723865e-01f, -1.37266636e-01f, 1.28489360e-01f, -1.13516487e-01f, 9.90642756e-02f, 1.70932874e-01f,
  1.81189910e-01f, 1.86025277e-01f, 3.16338167e-02f, -2.31185332e-01f, 3.45298529e-01f, -1.63461059e-01f, -3.38566095e-01f, -7.97953084e-02f, -4.07246321e-01f, 1.15171462e-01f,
  1.49827033e-01f, 8.17607269e-02f, 1.40540838e-01f, -5.55378273e-02f, -4.13828827e-02f, 1.11931868e-01f, -1.91138461e-01f, 4.07439061e-02f, 6.46960139e-02f, -8.20316598e-02f,
  -2.87971497e-01f, -1.68994635e-01f, -1.33051962e-01f, 6.35390282e-02f, 8.85555074e-02f, 2.43771374e-02f, -1.34071428e-02f, 2.43662987e-02f, -1.42502457e-01f, 4.60805595e-02f,
  1.82178482e-01f, -1.62737966e-02f, 1.76109582e-01f, -1.77168697e-01f, -1.66972522e-02f, -5.72159514e-02f, -8.32457021e-02f, -4.73553911e-02f, -1.42429039e-01f, 6.36985432e-03f,
  -1.22433053e-02f, -1.21112112e-02f, 1.12849586e-01f, 8.58370066e-02f, 1.78011388e-01f, 6.26346916e-02f, 9.06897262e-02f, -3.53288911e-02f, -3.10995486e-02f, 2.34141247e-03f,
  2.25253962e-02f, 1.06312580e-01f, 2.70431824e-02f, 3.33868824e-02f, 3.70106846e-02f, 2.63070874e-02f, 2.51454655e-02f, -1.19738564e-01f, 2.49319058e-02f, -9.47311707e-03f,
  -8.22419673e-02f, -3.14991847e-02f, 1.19686082e-01f, -1.38911828e-01f, -1.72398966e-02f, 9.25417766e-02f, -5.06697781e-02f, 9.73928794e-02f, -2.15029269e-02f, 8.01391713e-03f,
  -1.44853473e-01f, -3.20076734e-01f, -7.37358769e-03f, -1.35899454e-01f, -2.40883932e-01f, 9.36718807e-02f, -1.02527693e-01f, 6.02198727e-02f, -1.25641257e-01f, 7.25573376e-02f,
  -1.18185051e-01f, -1.16697364e-01f, -7.07489029e-02f, 4.72731777e-02f, -1.92238912e-01f, 1.40100554e-01f, -2.88476169e-01f, -1.47909358e-01f, -1.82842851e-01f, -1.30386472e-01f,
  -1.38849691e-01f, -3.33007351e-02f, 4.01120819e-03f, 4.51453403e-02f, -1.40119657e-01f, -1.53276965e-01f, 1.12235859e-01f, -8.25294629e-02f, -2.34852415e-02f, -1.35926515e-01f,
  -5.18677115e-01f, -4.97844040e-01f, -2.75855511e-01f, 3.70624781e-01f, 1.08768746e-01f, 3.17775816e-01f, -6.84011802e-02f, 7.48586059e-02f, 1.74387768e-01f, 4.84749936e-02f,
  1.81576893e-01f, -5.09196341e-01f, -5.61101973e-01f, 4.97157007e-01f, -1.58774227e-01f, -4.01161909e-02f, 6.58734322e-01f, 2.84486175e-01f, 6.44506365e-02f, -1.87114015e-01f,
  -2.84659192e-02f, 2.74557948e-01f, -4.20458674e-01f, 1.29248708e-01f, -4.47384156e-02f, -7.09042400e-02f, -8.36108625e-02f, -4.38193113e-01f, 2.54589260e-01f, 1.87450975e-01f,
  -7.25099631e-03f, -1.78389564e-01f, -2.35761702e-02f, 1.13041457e-02f, 3.29097291e-03f, -4.54375260e-02f, -5.12413159e-02f, -1.57051772e-01f, -1.81662813e-01f, -3.99088152e-02f,
  -1.34233460e-01f, -2.12161019e-02f, 2.27104768e-01f, -1.02539912e-01f, 3.39603750e-03f, 1.03165796e-02f, 3.54126878e-02f, -4.12010550e-02f, -1.10527081e-02f, -1.90020487e-01f,
  -1.17406167e-01f, 8.61893669e-02f, 1.94527179e-01f, 2.13371858e-01f, -5.93918748e-02f, 7.67133683e-02f, 9.47309807e-02f, -1.05150327e-01f, 7.74999335e-02f, 1.52959734e-01f,
  -5.66347782e-03f, -1.16559446e-01f, -1.90766260e-01f, -9.20685604e-02f, 5.83198406e-02f, 1.26201615e-01f, 6.33393228e-02f, 4.03808989e-02f, -3.26082967e-02f, 9.08228979e-02f,
  1.61213577e-01f, -1.45546600e-01f, 1.76989794e-01f, 2.17969120e-02f, 8.33853260e-02f, 2.09931195e-01f, -3.74411419e-02f, 1.14861511e-01f, 1.18656509e-01f, -1.91027462e-03f,
  -5.52868210e-02f, 5.69252558e-02f, -4.21497561e-02f, 1.66936927e-02f, 5.79003990e-02f, -2.24718586e-01f, 9.70609114e-02f, 1.02485545e-01f, -6.89233840e-02f, -3.43832839e-03f,
  -1.31722420e-01f, -1.81936011e-01f, -1.13581315e-01f, 1.49265945e-01f, -7.83002451e-02f, 6.52619302e-02f, -9.66739189e-03f, 1.07916914e-01f, -5.32574616e-02f, 2.62486916e-02f,
  6.05223961e-02f, -1.06804185e-01f, -1.50179071e-02f, 1.39124483e-01f, 6.24352284e-02f, -9.72164348e-02f, -7.00356159e-03f, 4.14633937e-03f, 1.95298582e-01f, 1.82852224e-02f,
  -1.41616881e-01f, -3.49679030e-02f, -5.18331910e-03f, 6.74290434e-02f, 2.37722665e-01f, -8.21636394e-02f, -1.45779885e-02f, -1.11910939e-01f, 3.35571505e-02f, 9.74535719e-02f,
  -2.60264546e-01f, 6.20446026e-01f, 1.38008952e-01f, 9.45185404e-03f, -7.79921263e-02f, -4.45816636e-01f, -2.07312226e-01f, -4.55195196e-02f, -1.39220819e-01f, 4.56289470e-01f,
  -2.74529815e-01f, 3.81240487e-01f, -3.80585402e-01f, -1.04688965e-01f, -9.97740030e-01f, -7.19226718e-01f, -2.93739945e-01f, -8.50903243e-02f, -3.04356426e-01f, 2.60905206e-01f,
  -2.96117157e-01f, -2.93369144e-01f, -3.01955193e-01f, 1.48287952e-01f, 4.32272583e-01f, 5.67157686e-01f, 1.10858977e-01f, 1.81721732e-01f, 5.76842487e-01f, -6.82450319e-03f,
  -1.66192397e-01f, -9.24329758e-02f, 1.73810557e-01f, -4.58375886e-02f, 3.37188691e-02f, 1.20407060e-01f, 1.95666909e-01f, -5.85368127e-02f, -8.32468495e-02f, -3.78301181e-02f,
  1.22719184e-01f, -9.33060646e-02f, 1.62814498e-01f, -6.29969984e-02f, 1.27318799e-01f, 8.36145207e-02f, 1.51667625e-01f, 1.09579071e-01f, 7.23123327e-02f, -7.06568733e-02f,
  6.80429637e-02f, 7.84800202e-02f, 1.19691469e-01f, 9.76672471e-02f, 4.66504134e-02f, 1.86143927e-02f, -2.18178481e-02f, 8.39822143e-02f, 1.38258323e-01f, 5.96333705e-02f,
  -9.20220688e-02f, 1.10874940e-02f, -2.33403523e-03f, -6.04019426e-02f, -9.08529684e-02f, 1.84364356e-02f, 2.41773363e-04f, 2.65628025e-02f, 5.81223071e-02f, 4.86371368e-02f,
  1.93447601e-02f, 1.02321640e-01f, 4.23135236e-02f, 1.21528380e-01f, -7.68948020e-03f, 5.80305494e-02f, 2.64215618e-02f, 5.60097434e-02f, 3.51521485e-02f, 4.26732972e-02f,
  -3.61697413e-02f, 2.69696116e-02f, 1.23977341e-01f, -4.99835983e-02f, -1.71158284e-01f, 1.67382155e-02f, 1.70188278e-01f, 2.50188727e-02f, -4.67673205e-02f, 2.39352938e-02f,
  1.29819168e-02f, 3.26056391e-01f, 1.17607683e-01f, 6.58028424e-02f, -1.10064773e-02f, 7.18696862e-02f, -8.39308947e-02f, 1.50060570e-02f, -3.95572893e-02f, 8.90600588e-03f,
  -1.64270662e-02f, 4.37762253e-02f, 8.56888890e-02f, -9.23859179e-02f, -3.73929031e-02f, -1.14400536e-01f, -5.25679206e-03f, 8.33593085e-02f, 1.05594225e-01f, 1.57876182e-02f,
  2.03260720e-01f, 6.21587075e-02f, -4.55913320e-02f, -3.90453427e-03f, 4.28891182e-02f, -1.34747252e-02f, -1.21195810e-02f, -3.23485620e-02f, 6.02213629e-02f, 5.62621430e-02f,
  -7.04556882e-01f, 2.64191218e-02f, -7.97473371e-01f, -2.81997204e-01f, -2.79385746e-01f, -3.83681238e-01f, 5.24314977e-02f, -2.19184831e-01f, -2.41692290e-01f, 6.43534958e-01f,
  4.95062947e-01f, -5.10779023e-01f, 5.54188848e-01f, -9.66445543e-03f, -8.43544245e-01f, 2.60699570e-01f, -1.20766200e-01f, 7.80205578e-02f, -2.01671839e-01f, -1.84987739e-01f,
  -3.37980956e-01f, 1.89474732e-01f, -2.06513613e-01f, 2.33290613e-01f, -4.34393771e-02f, -1.24762595e-01f, 2.97151566e-01f, 1.47547945e-02f, 6.39475212e-02f, -2.37985730e-01f,
  8.26477632e-02f, 1.47454202e-01f, -1.12357527e-01f, -1.34771559e-02f, -1.36251431e-02f, 1.33716121e-01f, -1.85091961e-02f, -6.76577911e-02f, -7.60087278e-03f, -9.35404599e-02f,
  3.85589944e-03f, -4.83788550e-02f, -1.00522801e-01f, -6.54060394e-02f, 4.40020906e-03f, -3.47705334e-02f, -1.08636819e-01f, -3.05557773e-02f, -8.99931695e-03f, -8.05626214e-02f,
  -5.63518442e-02f, 2.82630278e-03f, -1.08948108e-02f, 3.67381088e-02f, -1.94271907e-01f, -6.03047013e-02f, -1.63291376e-02f, -1.01869114e-01f, -5.39333969e-02f, -2.03238547e-01f,
  -6.28034920e-02f, 1.13023430e-01f, 6.30769134e-02f, 1.66260630e-01f, -9.61295366e-02f, 1.64975211e-01f, 8.52155611e-02f, 1.52400900e-02f, -7.66234696e-02f, 3.10569368e-02f,
  1.50700249e-02f, -5.52808307e-02f, 6.71917945e-02f, 3.29549387e-02f, 8.90050025e-04f, 2.48750821e-05f, 1.15538267e-02f, -5.76580968e-03f, -6.04386628e-02f, -1.99893657e-02f,
  1.71883464e-01f, -4.34611775e-02f, 2.15415396e-02f, 2.36145437e-01f, 6.71526641e-02f, -1.29580349e-01f, -7.88301043e-03f, 2.23743152e-02f, 1.30577162e-01f, -1.99438948e-02f,
  7.51409382e-02f, -1.37602478e-01f, 9.28511843e-03f, -2.46732924e-02f, 4.99306247e-02f, -9.09714848e-02f, -2.74963770e-02f, -2.21335277e-01f, -8.08248669e-02f, -3.04619316e-02f,
  -1.07186258e-01f, 1.16885342e-01f, 3.48342434e-02f, 2.06123572e-02f, -1.28993377e-01f, -2.86475252e-02f, 1.47618055e-01f, 1.35632129e-02f, -8.80486816e-02f, -2.39599925e-02f,
  6.16896190e-02f, 2.61915270e-02f, -3.76224071e-02f, 1.09336101e-01f, -5.89971691e-02f, 1.97717324e-01f, -9.97406915e-02f, -4.93571162e-03f, -2.37179212e-02f, 1.42838275e-02f,
  6.81060612e-01f, -2.03438237e-01f, 5.57647049e-01f, 5.26302516e-01f, 2.42374226e-01f, 3.75876427e-01f, 5.35261929e-01f, 1.42192915e-01f, 7.79990971e-01f, -3.75229836e-01f,
  -3.76697809e-01f, 2.31223136e-01f, -2.00151250e-01f, -2.59782612e-01f, 6.06129877e-02f, 3.98745760e-02f, 1.59648210e-01f, 9.62294340e-02f, 2.01320052e-01f, 1.78773522e-01f,
  2.65806437e-01f, -4.42816436e-01f, -2.64533252e-01f, -5.10792792e-01f, -4.33410443e-02f, -6.79781288e-02f, -5.82945883e-01f, -9.92560536e-02f, -5.22489369e-01f, -9.72679779e-02f,
  -1.57036081e-01f, 7.00157583e-02f, -1.47295207e-01f, -1.10426940e-01f, 9.21720490e-02f, 1.14460021e-01f, -9.25555229e-02f, -6.07513413e-02f, 1.20023087e-01f, 1.09726852e-02f,
  1.04938895e-01f, 2.87373527e-03f, -2.14909222e-02f, 3.90542150e-02f, 1.76424965e-01f, 2.53469441e-02f, 5.60978800e-02f, 1.26178907e-02f, 2.00886223e-02f, 1.28399238e-01f,
  1.72441810e-01f, 1.31912187e-01f, 4.30738032e-02f, -8.29557404e-02f, 1.46043915e-02f, -5.71011528e-02f, 5.41225038e-02f, 9.40934792e-02f, 1.05115818e-02f, 1.18266724e-01f,
  4.65822220e-02f, 4.74089719e-02f, -6.60824999e-02f, -9.64455009e-02f, -5.74863441e-02f, 2.24251300e-02f, 5.48366457e-02f, -1.62815318e-01f, 6.89723715e-02f, -2.42320430e-02f,
  -1.19447643e-02f, -1.20151609e-01f, 1.00017332e-01f, 3.93391699e-02f, 4.55406308e-03f, 1.86785012e-01f, -4.41666134e-02f, 3.42603177e-02f, 3.77938971e-02f, 3.95310894e-02f,
  1.96019560e-02f, 1.58292577e-02f, -3.80604714e-02f, 1.46699429e-01f, 2.86680609e-02f, -4.32151072e-02f, -8.82432088e-02f, 1.47343501e-01f, 2.30709836e-02f, -3.03084496e-02f,
  -2.35561326e-01f, -1.83993429e-01f, -1.88795447e-01f, -1.73278257e-01f, -4.78222594e-02f, -1.09539561e-01f, 3.41735594e-02f, -2.52080224e-02f, 5.67148775e-02f, -5.19775935e-02f,
  -5.67209274e-02f, -3.57983224e-02f, 4.65825871e-02f, -1.09779751e-02f, -9.78561640e-02f, -1.00235820e-01f, 5.32806441e-02f, -1.20957434e-01f, -7.06972480e-02f, -1.43912077e-01f,
  -4.63044681e-02f, -1.14244193e-01f, 5.99019416e-03f, 1.15349460e-02f, -1.02934703e-01f, -1.50895104e-01f, 7.21412823e-02f, -3.91205493e-03f, -3.83469351e-02f, 5.59490882e-02f,
  8.19483399e-02f, 4.46201295e-01f, -3.16059053e-01f, -5.50516769e-02f, -3.01282465e-01f, -5.49874961e-01f, -3.24642062e-01f, -1.58936530e-01f, 3.74957591e-01f, 4.07957941e-01f,
  -2.24045888e-01f, 6.39890373e-01f, 3.27003092e-01f, -2.04578698e-01f, -4.84620988e-01f, 2.02987105e-01f, -5.88426411e-01f, -6.92638755e-02f, 2.67254043e-04f, -1.48534641e-01f,
  -1.73348114e-01f, -2.71615177e-01f, -3.43205571e-01f, -5.64645939e-02f, -4.69740659e-01f, -3.38039063e-02f, -3.16402614e-01f, 7.28784187e-04f, -4.63798314e-01f, -1.84222788e-01f,
  -1.20867103e-01f, 3.02508086e-01f, 4.42443714e-02f, 1.42844655e-02f, -3.23441505e-01f, -9.30405408e-02f, -2.48641849e-01f, -4.24043834e-02f, 1.30503401e-01f, -2.43240353e-02f,
  2.18016356e-01f, 7.34498054e-02f, 6.01427294e-02f, 1.65491894e-01f, 1.37796015e-01f, 5.34885600e-02f, -7.50059783e-02f, -2.63664752e-01f, 1.16472632e-01f, 3.97859737e-02f,
  2.78747473e-02f, -1.26917243e-01f, -1.45763204e-01f, 4.32310663e-02f, -1.57970473e-01f, -9.37175974e-02f, -1.10467114e-01f, -3.33310291e-02f, -4.17669713e-02f, -1.09807216e-01f,
  6.04147166e-02f, -1.09541625e-01f, -2.79355422e-03f, 1.92406829e-02f, 6.93229660e-02f, -6.94139451e-02f, 1.35399014e-01f, -3.76280695e-02f, 4.45816144e-02f, 8.77868161e-02f,
  -4.72537577e-02f, 2.61928421e-02f, 4.29863594e-02f, -8.49751681e-02f, -1.23850554e-02f, 9.94414687e-02f, -9.16675031e-02f, 1.16492160e-01f, -9.85648409e-02f, -1.41663074e-01f,
  1.07834466e-01f, -1.34951621e-01f, 1.40493259e-01f, -9.67317671e-02f, -1.14857614e-01f, 2.54335441e-02f, -5.87672926e-02f, 5.40100113e-02f, -1.11270778e-01f, -7.21488744e-02f,
  -4.26891744e-01f, -1.81835875e-01f, 1.74664855e-01f, 1.85919344e-01f, 6.34954870e-02f, -1.76111441e-02f, -6.67808577e-02f, -2.22912561e-02f, -9.52262357e-02f, -9.51610729e-02f,
  -9.00192633e-02f, 6.17834069e-02f, -2.71616310e-01f, -3.73421721e-02f, 9.67868716e-02f, -1.58761010e-01f, -1.46005508e-02f, -2.52433177e-02f, -2.69228280e-01f, -6.04529046e-02f,
  3.17553096e-02f, 9.59304422e-02f, 1.01425715e-01f, -8.59381184e-02f, 9.21971202e-02f, -4.70988033e-03f, 1.28544271e-01f, 5.65615185e-02f, -1.18501723e-01f, -8.27801898e-02f,
  -5.82239032e-01f, 6.25288844e-01f, -4.46956754e-01f, 2.34660640e-01f, -9.62541252e-02f, 2.44002342e-01f, 5.72821021e-01f, 2.96495914e-01f, 5.85615277e-01f, 4.29515183e-01f,
  2.70733356e-01f, 2.62432396e-01f, 2.38131434e-01f, 3.53147954e-01f, -2.63081759e-01f, 3.28501076e-01f, 2.44557574e-01f, 2.70695448e-01f, 3.17765892e-01f, 1.85137670e-02f,
  -1.66280791e-01f, 4.64248598e-01f, -2.97495991e-01f, 1.16461039e-01f, -1.33252025e-01f, -1.73927575e-01f, -2.72264868e-01f, 7.08325729e-02f, -1.39437705e-01f, 2.13620022e-01f,
  3.48877540e-04f, 3.25393379e-01f, -2.58310109e-01f, 1.17594553e-02f, -1.37471735e-01f, -1.35360152e-01f, -7.30111524e-02f, -9.64290649e-02f, -4.53907624e-02f, 8.00664723e-02f,
  4.23140340e-02f, 4.22290005e-02f, 1.41026914e-01f, 1.00821152e-01f, 2.42027696e-02f, -4.18377742e-02f, -1.60672590e-01f, -1.66234881e-01f, 5.43635450e-02f, -1.24921992e-01f,
  -1.73223987e-01f, -1.94100887e-01f, -1.34450734e-01f, 7.21017122e-02f, -9.39393193e-02f, 1.42664015e-01f, 6.19386807e-02f, -4.60303687e-02f, -3.63677442e-02f, 1.53098240e-01f,
  -2.47676708e-02f, 1.18942060e-01f, 1.81328058e-02f, -3.50100584e-02f, -2.15610564e-02f, -4.17905934e-02f, -4.45674807e-02f, -2.38538766e-03f, -9.32918582e-03f, -5.34889214e-02f,
  -3.21588814e-02f, -2.07620417e-03f, 7.28542656e-02f, -6.00421354e-02f, 1.99110821e-01f, -1.33087942e-02f, -9.97827128e-02f, 2.09643483e-01f, 3.82332434e-03f, -6.15904555e-02f,
  2.16413319e-01f, -2.53491998e-02f, 5.18654622e-02f, -5.93345016e-02f, 6.31429404e-02f, 3.49635929e-02f, 1.20629042e-01f, -1.63387612e-01f, -1.13730974e-01f, -8.43366012e-02f,
  3.45376074e-01f, 7.31926739e-01f, 4.85547744e-02f, 8.27823654e-02f, 1.60374958e-02f, -5.48874624e-02f, 5.63804582e-02f, -7.68801942e-02f, 2.43938804e-01f, 8.45132768e-02f,
  -1.10585308e-02f, 2.40230039e-02f, -9.92341265e-02f, -4.03682217e-02f, -3.98529842e-02f, 1.31479234e-01f, 1.24541976e-01f, 1.53731212e-01f, 9.56086814e-02f, -4.27897945e-02f,
  -1.84544697e-01f, 1.76724181e-01f, -1.25465140e-01f, -1.41885981e-03f, -9.82586369e-02f, -5.08894771e-02f, 8.94898474e-02f, -3.68405543e-02f, -1.28938511e-01f, 1.02858454e-01f,
  5.59606493e-01f, 1.38524510e-02f, -5.75950861e-01f, -1.91202760e-01f, -3.54529887e-01f, 1.48373991e-01f, -2.82769114e-01f, -2.14811668e-01f, 3.25030029e-01f, 2.07282141e-01f,
  -3.27479005e-01f, 1.57613710e-01f, -1.09611437e-01f, -1.81073055e-01f, 3.55549216e-01f, 4.36163485e-01f, 2.61811644e-01f, 1.56675681e-01f, 8.75285789e-02f, -3.48149911e-02f,
  2.47054864e-02f, -5.65811582e-02f, -6.57934010e-01f, -3.42662811e-01f, -3.71074975e-01f, -3.44935149e-01f, -2.09387243e-01f, -5.26269555e-01f, -3.07770193e-01f, -6.22558743e-02f,
  -1.36932313e-01f, 2.79690549e-02f, -1.74195126e-01f, 2.73732338e-02f, -5.02337608e-03f, 2.03968100e-02f, -7.28844181e-02f, -5.44756949e-02f, -1.68952182e-01f, 2.44060382e-02f,
  1.47675008e-01f, 5.14896922e-02f, 1.88472003e-01f, -5.60113937e-02f, -1.13301992e-01f, -1.13871947e-01f, -2.13514678e-02f, 1.67451035e-02f, -1.83044359e-01f, -9.24955159e-02f,
  -2.79916786e-02f, 9.60235074e-02f, 8.98870230e-02f, 1.53183565e-01f, -3.84997018e-02f, -5.16237877e-02f, 2.35870499e-02f, -1.06727391e-01f, 1.74707517e-01f, 1.09492823e-01f,
  6.62059337e-02f, 1.79568425e-01f, 7.17354119e-02f, -1.28343999e-01f, 1.19990716e-02f, -1.06024198e-01f, -2.36816127e-02f, -3.07401940e-02f, 4.72319573e-02f, -5.55797368e-02f,
  -1.79061405e-02f, -1.57844022e-01f, -2.97983624e-02f, 7.08815381e-02f, 8.55748430e-02f, 5.30883223e-02f, -2.53422372e-02f, -3.57319266e-02f, 8.90460089e-02f, 4.64990316e-03f,
  -1.59215137e-01f, 1.32318422e-01f, -7.98615590e-02f, -6.20659627e-02f, -8.26275051e-02f, -8.60714093e-02f, 1.21699572e-01f, -1.17505491e-01f, -4.54793870e-02f, 2.59100758e-02f,
  9.28398371e-02f, 3.41396660e-01f, -6.05773740e-03f, 1.44249164e-02f, -7.17577115e-02f, 1.33106366e-01f, 3.13764848e-02f, 6.90255910e-02f, -9.56686120e-03f, 1.76004365e-01f,
  7.83490986e-02f, -7.24779218e-02f, 1.68929234e-01f, -1.10092364e-01f, -1.76596921e-02f, 1.02196686e-01f, 1.05504625e-01f, 2.37735175e-02f, 8.48349109e-02f, -5.45171313e-02f,
  9.03896149e-03f, 2.17476174e-01f, 1.69514760e-01f, 1.08894445e-01f, 1.67530447e-01f, 7.42598027e-02f, 1.68419361e-01f, -7.23364875e-02f, 6.60125464e-02f, 6.14158772e-02f,
  5.57678223e-01f, -4.03911471e-01f, -2.30608240e-01f, 5.10312498e-01f, 5.80476165e-01f, -8.19708630e-02f, -3.80537689e-01f, 4.72655088e-01f, 1.74339652e-01f, -3.67971063e-01f,
  3.90067786e-01f, -3.17404658e-01f, -3.58871818e-01f, 5.42152107e-01f, 5.52215338e-01f, -3.14756989e-01f, 5.01841784e-01f, 1.24011658e-01f, 4.51114327e-02f, 3.87653917e-01f,
  5.31331360e-01f, 5.70909679e-01f, 3.30794632e-01f, 4.09198970e-01f, 3.66492450e-01f, 6.76382408e-02f, 2.04169959e-01f, -4.14619893e-01f, 1.97971269e-01f, 3.95067185e-02f,
  -1.99323744e-02f, 3.05505574e-01f, -9.17620119e-03f, -1.22455403e-01f, 1.18328318e-01f, -8.00709724e-02f, -1.41092211e-01f, -1.41760945e-01f, 2.01996602e-02f, -8.66801199e-03f,
  -1.97584346e-01f, 2.19071120e-01f, 1.53347865e-01f, -6.96922392e-02f, 4.52285260e-02f, 1.36356592e-01f, 1.80608362e-01f, -7.36797694e-03f, 1.21621583e-02f, 1.21875979e-01f,
  6.28096387e-02f, 2.66925339e-02f, 6.04224689e-02f, 3.39922607e-02f, 3.33987549e-02f, 4.29582372e-02f, -8.42384920e-02f, -1.88535422e-01f, -2.16422603e-02f, 1.44627929e-01f,
  1.50352001e-01f, -1.80468515e-01f, -9.02035087e-03f, -2.71216650e-02f, -8.38451833e-02f, 1.49613782e-03f, -3.72068249e-02f, -2.30171643e-02f, -1.06567107e-01f, 7.75096798e-03f,
  6.68738261e-02f, 5.47326952e-02f, 1.00261301e-01f, 3.14264894e-02f, 7.81887770e-02f, 4.31050546e-02f, -1.85870957e-02f, 8.12045410e-02f, 6.80463240e-02f, 4.47316244e-02f,
  1.60767254e-03f, 1.02058955e-01f, -4.76474576e-02f, 3.63496989e-02f, -4.19445001e-02f, 4.81545273e-03f, 2.42744163e-02f, 5.65324165e-02f, -5.01427688e-02f, 7.21938834e-02f,
  -1.13661520e-01f, 2.03499608e-02f, -1.34745717e-01f, 4.30205390e-02f, -1.66068330e-01f, 1.09470479e-01f, 2.46688575e-02f, 2.21814036e-01f, -7.41717964e-02f, 7.36956596e-02f,
  6.52545616e-02f, 4.35029753e-02f, 6.10932068e-04f, 1.63113967e-01f, -4.46614698e-02f, 4.47248630e-02f, -9.63238999e-02f, -1.38040319e-01f, 1.28154889e-01f, 5.20270914e-02f,
  1.82018336e-02f, 5.09477779e-02f, -1.44454136e-01f, 7.07157850e-02f, 1.71426952e-01f, -4.56294939e-02f, 2.64926953e-03f, 9.88325011e-03f, 7.92399198e-02f, 3.25719616e-03f,
  7.30023980e-02f, -6.77962676e-02f, -7.52310008e-02f, 1.14295945e-01f, -2.82655172e-02f, -6.53552890e-01f, -4.69351530e-01f, 1.82394743e-01f, -1.66215315e-01f, -1.61131676e-02f,
  5.47702387e-02f, -3.11080635e-01f, 2.42456466e-01f, -5.97085118e-01f, -3.76209617e-02f, -2.65075475e-01f, -3.06260318e-01f, -4.61064130e-01f, -1.35819510e-01f, 2.88056225e-01f,
  2.11624354e-01f, -2.56501704e-01f, 1.83541045e-01f, 9.00575072e-02f, -1.54253989e-01f, 4.58568722e-01f, 6.42798662e-01f, 1.24922298e-01f, 5.08393086e-02f, -2.72394836e-01f,
  -3.03596199e-01f, -6.45692497e-02f, -3.63374613e-02f, -2.13468835e-01f, 2.62118280e-01f, 6.27012402e-02f, 4.37709913e-02f, -9.31805670e-02f, 6.76711963e-04f, -5.66448784e-04f,
  4.51087430e-02f, 2.80899890e-02f, -8.83115530e-02f, -1.39805704e-01f, -5.54350652e-02f, -3.16997543e-02f, -1.44144759e-01f, -8.16321522e-02f, -8.35818797e-02f, -1.30953938e-02f,
  7.21395761e-03f, 3.23716737e-02f, 9.47165713e-02f, 5.78767806e-02f, 2.04396248e-01f, -2.57010804e-03f, -4.85289656e-02f, 1.55744433e-01f, -4.49588597e-02f, 1.40016139e-01f,
  1.30514681e-01f, 5.75415120e-02f, -9.13109183e-02f, -1.59790754e-01f, -4.51107398e-02f, -4.22860719e-02f, -9.69803035e-02f, -6.10165074e-02f, -1.92739681e-04f, 1.99087914e-02f,
  2.30576266e-02f, 2.09776368e-02f, -1.29076958e-01f, 5.53871207e-02f, 1.89095989e-01f, -3.78361456e-02f, 7.03553250e-03f, -5.21952212e-02f, 1.50471002e-01f, 5.34321647e-03f,
  -1.06525071e-01f, 1.91007718e-03f, 2.91378349e-02f, 9.66713112e-03f, -1.62774339e-01f, 2.35456213e-01f, 9.48953256e-02f, -8.46970305e-02f, 2.65061483e-03f, 1.12794288e-01f,
  1.25786543e-01f, 4.51746255e-01f, 3.31882574e-02f, -1.24690525e-01f, -7.98423886e-02f, -8.26531649e-02f, -1.44369751e-01f, -8.54119211e-02f, 1.97287396e-01f, -3.71155515e-02f,
  2.33663306e-01f, 4.02652994e-02f, 3.11783813e-02f, -1.66653432e-02f, -4.97423522e-02f, 1.75008819e-01f, 1.48327768e-01f, 7.37998933e-02f, 2.00071529e-01f, 3.06939840e-01f,
  2.19952717e-01f, 7.95439854e-02f, 7.43711442e-02f, 2.54176967e-02f, 7.85974115e-02f, 1.09691456e-01f, 5.92958927e-02f, 3.64026204e-02f, 3.32060494e-02f, 4.86729890e-02f,
  4.77210060e-02f, -5.85549712e-01f, -5.63723683e-01f, -4.94476438e-01f, 5.92451453e-01f, 8.59553993e-01f, -6.52817860e-02f, -4.23402898e-02f, -6.93100750e-01f, 1.92300275e-01f,
  3.07690203e-01f, -2.96982557e-01f, -3.39576036e-01f, -1.94023341e-01f, 9.37616229e-02f, -4.33837414e-01f, 1.02481611e-01f, 9.21647698e-02f, -3.76413286e-01f, 1.37282789e-01f,
  -3.97376865e-02f, 3.50016356e-01f, -3.39248776e-01f, 3.58936578e-01f, 2.23832071e-01f, -9.34922881e-03f, 3.64720225e-01f, 1.53256208e-01f, 4.41945106e-01f, 1.61948025e-01f,
  6.26889430e-03f, -2.51509041e-01f, -1.51450470e-01f, -3.30685563e-02f, 2.20342293e-01f, 2.55814761e-01f, 2.15766639e-01f, 7.12731257e-02f, -7.46132955e-02f, -1.10357419e-01f,
  1.12785198e-01f, -7.01054977e-03f, -5.18862382e-02f, -2.93858889e-02f, 7.81589597e-02f, -4.96960469e-02f, -1.63800001e-01f, -1.28760993e-01f, -2.40153700e-01f, -4.66559194e-02f,
  -2.12235555e-01f, -3.24568413e-02f, 1.74512900e-02f, -1.33332327e-01f, -1.13971390e-01f, -6.97584227e-02f, 1.15611721e-02f, 1.80966079e-01f, -4.35529724e-02f, 3.77438590e-02f,
  1.17576271e-01f, 1.03458799e-01f, 1.05639137e-01f, -1.24993004e-01f, -6.89542592e-02f, -3.25276516e-02f, 3.04582156e-02f, -1.97230186e-02f, -1.16590627e-01f, 2.85860039e-02f,
  -4.59319167e-02f, -2.80121583e-02f, 6.87719788e-03f, 9.16428864e-02f, 8.36313218e-02f, -7.33864307e-02f, 1.46907568e-02f, 1.18033409e-01f, -3.53197344e-02f, -1.37696952e-01f,
  -1.63524538e-01f, 1.75361950e-02f, 1.75595969e-01f, -4.61216755e-02f, -6.20181002e-02f, 1.08911887e-01f, 5.66841438e-02f, -5.36717335e-03f, -1.15173355e-01f, 1.14973187e-01f,
  1.12762958e-01f, 1.16707958e-01f, -9.68883336e-02f, 6.50304779e-02f, -1.62808403e-01f, 5.43689691e-02f, -1.35384455e-01f, -4.70423698e-02f, 1.21799424e-01f, -4.29463089e-02f,
  3.02141428e-01f, 6.11624904e-02f, 2.67415822e-01f, -1.05488285e-01f, 3.07817850e-02f, 2.07207084e-01f, 1.31534725e-01f, 9.04220119e-02f, 1.54012386e-02f, 1.75316408e-01f,
  -4.26303968e-03f, 1.11463435e-01f, -1.46793485e-01f, 1.72112789e-02f, 9.49474573e-02f, 4.78284061e-02f, 1.23511449e-01f, 1.22145690e-01f, 2.37285625e-02f, -7.61792287e-02f,
  -1.21012166e-01f, -9.70938146e-01f, -1.06083065e-01f, 2.47201338e-01f, -1.51702523e-01f, -3.23487133e-01f, 2.70768970e-01f, -4.58316922e-01f, -8.54330882e-02f, -3.96687031e-01f,
  5.86133115e-02f, -1.25854939e-01f, 1.34945229e-01f, -2.18524989e-02f, 6.36654437e-01f, 3.09046596e-01f, -5.47476262e-02f, 2.02080324e-01f, -1.26976601e-03f, -3.82708013e-01f,
  4.53265570e-02f, -1.01246968e-01f, 2.78544813e-01f, -5.69157481e-01f, -2.79672414e-01f, -1.42540827e-01f, 2.99272358e-01f, -1.18382655e-01f, -1.46874607e-01f, 2.16434970e-01f,
  -3.35307211e-01f, -3.55228066e-01f, -6.55835792e-02f, -3.20508480e-02f, -1.11908682e-01f, 3.13618057e-03f, 1.07125774e-01f, 2.61361301e-01f, 9.06009674e-02f, 1.39427641e-02f,
  3.79616320e-02f, -9.62208584e-02f, -7.17166960e-02f, 5.23580387e-02f, -2.26506934e-01f, -1.51409417e-01f, -7.10888803e-02f, 6.21222779e-02f, -1.46974728e-01f, 9.05381441e-02f,
  -4.65753712e-02f, -7.37977028e-02f, -3.21589261e-02f, 6.03114627e-02f, 1.02260120e-01f, -2.81542819e-02f, 7.98889250e-02f, 1.16840623e-01f, -7.06949681e-02f, -7.29057938e-04f,
  -5.47285303e-02f, 1.56064238e-02f, -5.76773882e-02f, -5.54583333e-02f, -4.94481158e-03f, 3.32475975e-02f, -9.14969668e-02f, 2.05293804e-01f, 5.07374518e-02f, -9.29524079e-02f,
  -7.28083998e-02f, 3.09813377e-02f, -1.11171506e-01f, 4.96250764e-03f, 7.35687539e-02f, 2.90522631e-02f, 8.53568986e-02f, -4.79034819e-02f, -4.31325398e-02f, 8.83018449e-02f,
  -2.15564854e-02f, -4.49676365e-02f, -2.87229661e-02f, 4.69214208e-02f, -6.36381879e-02f, 1.70478627e-01f, -1.15693929e-02f, -1.10465378e-01f, 6.87889531e-02f, 4.54947203e-02f,
  -8.56469810e-01f, -7.82755971e-01f, -2.59300228e-02f, -6.60507679e-02f, 2.39487598e-03f, -9.25061330e-02f, 1.07359886e-03f, -7.49018937e-02f, -1.75568670e-01f, -2.65705008e-02f,
  -9.88641605e-02f, 7.33275265e-02f, -1.72095567e-01f, 2.14456748e-02f, 3.45396325e-02f, -8.00746456e-02f, -6.10561930e-02f, 2.55855415e-02f, 2.70809815e-03f, -9.84300822e-02f,
  -2.42520291e-02f, -4.63819765e-02f, 8.02908987e-02f, -5.93720935e-04f, 7.91079849e-02f, -1.74919143e-02f, -1.18847936e-01f, -9.47640315e-02f, 2.33517215e-02f, -1.61080323e-02f,
  3.94612163e-01f, 1.86329931e-01f, 9.79507491e-02f, 3.44892412e-01f, 3.50782007e-01f, 1.03313133e-01f, 1.61522597e-01f, 5.47288120e-01f, 7.99363077e-01f, -1.12650618e-01f,
  -1.56207606e-01f, -3.77437085e-01f, -2.49103054e-01f, -4.17375341e-02f, -5.74598253e-01f, -3.64477575e-01f, -1.60430163e-01f, -2.44125202e-01f, 3.63625169e-01f, 6.11959733e-02f,
  -3.56522053e-02f, -4.05258089e-01f, -3.12577963e-01f, -7.22151026e-02f, 3.47456306e-01f, 3.20755661e-01f, -3.70866567e-01f, 4.08461988e-02f, -2.99337924e-01f, -2.43948743e-01f,
  1.44309491e-01f, 1.92309633e-01f, 2.02111006e-01f, 9.15881246e-02f, 2.30838180e-01f, -5.52920401e-02f, -1.57710910e-02f, -1.83647245e-01f, 6.65621907e-02f, 5.98889329e-02f,
  1.49539514e-02f, -1.51896492e-01f, -1.88368276e-01f, -1.75535262e-01f, 2.92869031e-01f, 6.11204207e-02f, 1.52996734e-01f, 3.25198650e-01f, -1.05019659e-01f, 1.11318156e-02f,
  -1.36434613e-02f, 3.21460515e-02f, 2.49697909e-01f, -1.30979672e-01f, 6.00851886e-02f, 2.43655965e-01f, -1.01466276e-01f, -2.40188792e-01f, 5.61093800e-02f, 1.94499809e-02f,
  -7.85377622e-02f, 6.81597441e-02f, -3.43891606e-02f, 1.03395544e-01f, 4.40164004e-03f, 1.08596988e-01f, -5.89843057e-02f, -6.16952293e-02f, 7.39513934e-02f, 1.54556930e-02f,
  1.00103654e-01f, 1.52777269e-01f, 1.52909309e-01f, 6.99696615e-02f, -2.13949978e-02f, 7.25714341e-02f, -2.69013137e-01f, -9.31988284e-02f, 1.19802199e-01f, 1.42775640e-01f,
  -1.80019643e-02f, 2.39645652e-02f, -1.48645028e-01f, -2.75074225e-02f, -9.73051786e-02f, 6.83185831e-02f, -3.76568362e-03f, -3.50201018e-02f, 1.61645681e-01f, -2.54227608e-01f,
  4.75271186e-03f, -3.28985065e-01f, 1.24761268e-01f, 6.34843409e-02f, -2.18228642e-02f, -1.82482362e-01f, 3.76259983e-02f, 3.40529457e-02f, -6.63149878e-02f, 3.36135477e-02f,
  6.15217350e-02f, 7.72030875e-02f, -8.26233700e-02f, -6.39735013e-02f, 1.09937033e-02f, -4.78085279e-02f, -2.05639079e-01f, 9.50320214e-02f, -7.43890032e-02f, -3.41347158e-02f,
  -1.67504698e-01f, 4.14190516e-02f, -1.02526262e-01f, 1.90136522e-01f, -2.75865160e-02f, 4.66539636e-02f, 7.14620668e-03f, -1.96404550e-02f, -1.98957250e-01f, -5.26953079e-02f,
  -1.14670265e+00f, 5.88414848e-01f, -2.26425007e-02f, -5.00312448e-01f, 1.97344512e-01f, -1.23763286e-01f, -1.54662877e-01f, 2.05435921e-02f, -4.53195088e-02f, 3.72217074e-02f,
  1.20349526e-01f, -1.68170437e-01f, 4.89065498e-01f, -1.36335582e-01f, -2.96290129e-01f, 3.90093684e-01f, -5.43974578e-01f, -5.43427765e-01f, 9.31772813e-02f, -2.79690444e-01f,
  -1.91142187e-01f, 9.89545230e-03f, -4.08195518e-02f, 3.19037735e-01f, -8.62035900e-02f, -1.60787448e-01f, -1.98271617e-01f, 4.73592192e-01f, -2.01668739e-01f, 2.99223542e-01f,
  -4.94109482e-01f, -4.45027977e-01f, -3.50750238e-01f, -3.49038631e-01f, -2.60786116e-01f, -1.05775706e-01f, -2.10584968e-01f, 1.83106095e-01f, 1.27406465e-03f, 1.82291772e-02f,
  9.44733899e-03f, 4.52634357e-02f, 6.69772271e-03f, 1.35691449e-01f, -5.89849912e-02f, -3.53295952e-02f, 1.06185496e-01f, -7.43064284e-02f, 9.23966616e-02f, 5.62693961e-02f,
  1.69082716e-01f, 5.83152007e-03f, -1.44224957e-01f, -2.27655023e-02f, 5.06183133e-02f, 4.28316668e-02f, -3.78920734e-02f, 3.95032167e-02f, -1.66572228e-01f, -9.98248681e-02f,
  -5.20045571e-02f, -9.36652869e-02f, 5.39393723e-02f, -3.81246880e-02f, 4.95400466e-02f, 4.78307568e-02f, 6.89620152e-03f, -3.80240493e-02f, -3.55302654e-02f, -9.90912691e-03f,
  -6.50471076e-02f, -1.02934599e-01f, -1.11555038e-02f, -1.33494452e-01f, -4.42073420e-02f, -8.95400196e-02f, -1.71664990e-02f, -1.95252262e-02f, 1.66221836e-03f, -1.79548532e-01f,
  -4.76268940e-02f, 8.48734230e-02f, 2.93756258e-02f, -5.80162276e-03f, -6.55184910e-02f, 6.72621876e-02f, 1.94529071e-03f, 1.65579133e-02f, -3.61252725e-02f, 7.72276521e-02f,
  -8.14512849e-01f, -6.18117809e-01f, -8.54780972e-02f, -1.19385839e-01f, -2.01669037e-01f, -1.24957204e-01f, -1.46732172e-02f, 1.89845618e-02f, -2.34051466e-01f, -4.25609238e-02f,
  -9.29698348e-02f, -1.22465022e-01f, -5.66926599e-02f, 2.80208513e-03f, 2.33012456e-02f, 6.60149902e-02f, -3.22341621e-02f, -8.70891735e-02f, -2.01934084e-01f, -1.35339782e-01f,
  -6.61701337e-02f, -2.37607341e-02f, 7.06753358e-02f, -7.04231113e-02f, -1.15600556e-01f, -1.15016498e-01f, -1.61094129e-01f, 6.51443601e-02f, -2.52212230e-02f, 1.19782381e-01f,
  -1.00912631e+00f, 5.45350850e-01f, 6.09817684e-01f, -1.35114804e-01f, -3.68918300e-01f, 7.86297083e-01f, 2.79938489e-01f, 1.61065608e-01f, 8.26077610e-02f, 3.55391473e-01f,
  3.22731286e-02f, -3.67971435e-02f, 2.28124768e-01f, 4.09860134e-01f, 3.78837615e-01f, 5.42565703e-01f, 3.36017758e-01f, 2.22009361e-01f, -5.63043840e-02f, -4.30382676e-02f,
  -2.44382527e-02f, -4.32902686e-02f, 4.45233315e-01f, -8.11873935e-03f, -3.52121890e-02f, -2.06759870e-01f, -1.83997601e-01f, -6.28438368e-02f, 1.28851235e-01f, -3.51480804e-02f,
  -3.29788536e-01f, -3.46442401e-01f, -1.50190592e-01f, 8.61017480e-02f, -3.70765068e-02f, -4.52091619e-02f, -6.43662736e-02f, -2.81526498e-03f, -1.70089960e-01f, -1.72382202e-02f,
  -1.53882146e-01f, -3.43892314e-02f, -1.21463038e-01f, -6.80398867e-02f, -6.28104955e-02f, -3.88728380e-02f, 1.03739299e-01f, 1.12253681e-01f, 1.05263226e-01f, 1.26822323e-01f,
  2.17055067e-01f, 2.54985392e-01f, 3.63976359e-02f, 2.09788904e-01f, -4.54708636e-02f, -1.92746259e-02f, 1.20909937e-01f, -3.49450707e-02f, 6.59514591e-02f, 1.06256217e-01f,
  8.73249471e-02f, -1.87912434e-02f, 6.37916699e-02f, 9.95720085e-03f, 5.60487695e-02f, 2.45819818e-02f, -3.11410110e-02f, -1.03235304e-01f, -7.10758120e-02f, 7.73675293e-02f,
  -4.42307703e-02f, -8.66235793e-03f, -8.82069692e-02f, 1.32897004e-01f, -1.27624258e-01f, -7.28621036e-02f, -4.50362116e-02f, -7.11520016e-02f, 8.11920837e-02f, 3.77366692e-02f,
  2.77972966e-02f, 1.21272340e-01f, 3.74857709e-02f, -1.33039877e-01f, -3.54366228e-02f, 5.46436384e-02f, -4.61354777e-02f, 9.30826068e-02f, -6.69995248e-02f, -1.00481443e-01f,
  7.09385052e-02f, 8.33270997e-02f, -7.11452141e-02f, -8.68318677e-02f, 5.77789061e-02f, 1.78568605e-02f, -1.20180734e-02f, 4.97542247e-02f, 1.46463960e-01f, -8.47773068e-03f,
  -6.02516532e-02f, 3.15989405e-02f, -4.92069200e-02f, -1.59102723e-01f, 8.58472809e-02f, 1.32591888e-01f, -6.37361854e-02f, -1.03155285e-01f, -9.08000395e-02f, -3.12772989e-02f,
  -5.52058741e-02f, -1.21886887e-01f, 1.51953027e-01f, 2.98205260e-02f, -9.31199789e-02f, -4.05409299e-02f, -1.26372054e-01f, -7.36702979e-02f, -3.34041715e-02f, 1.31147340e-01f,
  3.22754234e-02f, -2.81342678e-02f, -1.15678139e-01f, -9.05482396e-02f, -1.88153148e-01f, -3.80128294e-01f, -6.45346701e-01f, 7.91188180e-02f, -4.41772461e-01f, -4.07721937e-01f,
  -1.59632534e-01f, -1.10298194e-01f, -4.13459718e-01f, 2.66438454e-01f, 5.89605689e-01f, -6.36174157e-03f, 4.68471289e-01f, 8.75080004e-02f, 3.70653749e-01f, 3.71342838e-01f,
  4.46350992e-01f, 5.55464149e-01f, 5.60845137e-01f, 5.67949891e-01f, 1.52749836e-01f, 3.29681605e-01f, 4.74622697e-01f, 1.17438011e-01f, 3.66786212e-01f, 1.16065130e-01f,
  5.28235286e-02f, 1.84535190e-01f, 9.36608315e-02f, -1.05731532e-01f, 1.19719520e-01f, -1.94000185e-01f, -5.49935214e-02f, -2.11396515e-01f, -2.28557605e-02f, -6.63532391e-02f,
  -1.71300709e-01f, 1.33095399e-01f, 4.32876758e-02f, -3.20076346e-02f, -1.80878609e-01f, -1.22341663e-01f, 6.32219091e-02f, -8.59877467e-02f, -9.73620191e-02f, -3.68667357e-02f,
  -1.60679445e-01f, -1.10720694e-01f, -4.68248427e-02f, 9.43990331e-03f, -1.69815198e-01f, -9.06464383e-02f, -6.63714036e-02f, -1.03665195e-01f, -5.01863062e-02f, -2.44162660e-02f,
  7.86103085e-02f, -5.24492003e-02f, 2.60840300e-02f, -4.04125787e-02f, 8.03467706e-02f, 9.91210192e-02f, -5.94667830e-02f, 3.19397710e-02f, 1.97989978e-02f, 2.14389302e-02f,
  -9.55947340e-02f, 3.19671445e-02f, 7.04135140e-03f, -1.54343635e-01f, 4.87649031e-02f, 5.36461845e-02f, -4.53283116e-02f, -1.72212708e-03f, -1.34280652e-01f, -8.03447142e-03f,
  -1.73805989e-02f, -2.59471312e-02f, 7.05581009e-02f, 5.62252626e-02f, -6.98123639e-03f, -1.06330879e-01f, -2.75369976e-02f, -1.36840761e-01f, 1.04316674e-01f, 5.17407991e-02f,
  2.14430675e-01f, 3.25637966e-01f, 2.16624551e-02f, 1.58105267e-03f, 1.06468506e-01f, 1.11360230e-01f, 1.04963228e-01f, 7.13455975e-02f, 5.69861233e-02f, 6.54676855e-02f,
  3.10638081e-03f, -1.24475054e-01f, 2.19226326e-03f, -1.08103147e-02f, 1.34848848e-01f, -8.37159529e-03f, -1.72772948e-02f, -6.84495792e-02f, -7.73427039e-02f, 2.85270631e-01f,
  -3.59584354e-02f, -1.12521730e-01f, 1.99776385e-02f, -1.71932764e-02f, 7.67839840e-03f, -8.93933699e-02f, 2.79378667e-02f, -5.49757518e-02f, 7.23039433e-02f, 2.87743099e-02f,
  -7.94310093e-01f, 4.95054051e-02f, 5.67558408e-01f, -6.24477923e-01f, -8.29038471e-02f, 5.79350471e-01f, 3.78957808e-01f, -1.65291294e-01f, -2.66649067e-01f, -3.12876552e-01f,
  -3.31648946e-01f, -1.25680730e-01f, 4.93249953e-01f, -4.20382947e-01f, 8.11579227e-01f, 5.63023448e-01f, 9.03821066e-02f, 9.56016127e-03f, -2.92456690e-02f, -2.90927887e-01f,
  -2.15997279e-01f, -4.13812160e-01f, 3.02641094e-01f, -2.97207713e-01f, -2.88246840e-01f, -2.51392215e-01f, -2.94454306e-01f, 1.95582822e-01f, -3.01203012e-01f, 4.97182682e-02f,
  -1.19922586e-01f, -3.83180678e-01f, 2.36931946e-02f, 3.32645535e-01f, -7.80177563e-02f, 9.81038716e-03f, 1.00856028e-01f, 3.15474182e-01f, -4.02133373e-05f, -2.73913890e-02f,
  -4.25060876e-02f, -4.46623303e-02f, -2.53994703e-01f, 1.00218721e-01f, -9.50620472e-02f, -9.88448039e-02f, 7.06810951e-02f, -8.32445621e-02f, -6.58602105e-04f, 1.35391071e-01f,
  1.30617823e-02f, 2.05542427e-02f, -3.81115861e-02f, -4.92013209e-02f, 1.07227817e-01f, 1.44328699e-02f, 5.02989925e-02f, 4.18922827e-02f, -3.07070930e-02f, -1.97926551e-01f,
  1.01190858e-01f, 1.08763188e-01f, 3.27551514e-02f, -9.37972739e-02f, -9.08501148e-02f, -2.38163471e-01f, 5.18581308e-02f, -3.49182189e-02f, -3.46539617e-02f, -6.20534159e-02f,
  -1.31694004e-01f, -4.20814380e-02f, -2.85595451e-02f, 7.42042437e-02f, -1.52497366e-01f, -6.09950982e-02f, 1.49635807e-01f, -1.09881103e-01f, -4.60554548e-02f, -3.40863094e-02f,
  -7.89443403e-02f, 7.03973770e-02f, -2.03007292e-02f, 4.68940139e-02f, 1.06893077e-01f, 1.15483105e-01f, -7.20619857e-02f, 1.37505913e-02f, 3.71759050e-02f, 1.19425848e-01f,
  5.20683452e-02f, -8.34441409e-02f, 1.68735385e-02f, 4.20863042e-03f, 6.51206598e-02f, 9.49098170e-02f, 7.45784268e-02f, -1.12630717e-01f, -2.70478483e-02f, 1.75760388e-02f,
  2.52077822e-03f, -4.90399823e-02f, -2.47649755e-02f, 5.47327893e-03f, 3.94021645e-02f, 4.93334830e-02f, -1.86403468e-02f, 1.38497157e-02f, -5.18391328e-03f, -1.35640725e-02f,
  -1.01624690e-01f, 3.29170413e-02f, 7.16592669e-02f, -2.24157974e-01f, -3.05430535e-02f, -1.69062614e-01f, -6.50522038e-02f, 7.75616691e-02f, 6.42885268e-02f, 2.66297590e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.93763000e-01f, 6.56737447e-01f, 4.59521919e-01f, 6.26146019e-01f, 5.95122397e-01f, 8.18290412e-01f, 5.09640574e-01f, 7.86081910e-01f, 3.70125860e-01f, 6.34143472e-01f,
  6.20898366e-01f, 4.37596709e-01f, 5.17059207e-01f, 6.47993326e-01f, 6.25121891e-01f, 6.75527751e-01f, 4.17055786e-01f, 6.48796856e-01f, 4.57027555e-01f, 7.84518659e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.33523673e-01f, -9.32115410e-03f, -7.30516911e-01f, -1.68639004e-01f, 1.39053389e-01f, -8.26888204e-01f, -3.94027740e-01f, 1.42776206e-01f, -2.07162946e-01f, 6.78377092e-01f,
  -6.50589690e-02f, 2.76668221e-01f, -5.41338742e-01f, 6.43341839e-01f, -3.94538492e-01f, -7.70773232e-01f, 5.25109231e-01f, -4.43405122e-01f, 9.43190932e-01f, -6.57367945e-01f,
  -2.38267988e-01f, 3.12291056e-01f, -2.90281951e-01f, -8.74404490e-01f, -5.53603351e-01f, -3.88747722e-01f, 5.04600942e-01f, -4.84011203e-01f, -1.36734456e-01f, 6.18683279e-01f,
  -2.94480056e-01f, -6.76890984e-02f, -8.54937062e-02f, -6.10665202e-01f, -6.50186241e-01f, -4.49044794e-01f, 4.08032447e-01f, 3.82176757e-01f, -8.07949722e-01f, 7.09622622e-01f,
  4.83738333e-01f, -8.01166296e-01f, 9.43219215e-02f, 6.59537971e-01f, 6.75361216e-01f, 6.33853912e-01f, -1.20840967e-01f, 4.68507767e-01f, 1.59296691e-01f, -8.28660488e-01f,
  -3.09814036e-01f, -7.34651506e-01f, -5.34135342e-01f, 3.67862076e-01f, 2.94446021e-01f, 3.14431846e-01f, -2.93081641e-01f, 4.94415909e-01f, -9.39682007e-01f, -7.88839698e-01f,
  -7.82832980e-01f, 3.28442268e-02f, -5.28318174e-02f, -9.20038700e-01f, -1.23798467e-01f, 4.81188037e-02f, 5.93060851e-02f, 3.58477060e-04f, -5.42198181e-01f, -3.06846678e-01f,
  -4.20133829e-01f, 1.76872194e-01f, 3.46361101e-01f, 4.12579507e-01f, 3.26194614e-01f, -5.17258167e-01f, 4.80467051e-01f, -8.98078024e-01f, -2.79072404e-01f, -8.85919854e-02f,
  7.76814699e-01f, 2.30796665e-01f, -6.94796383e-01f, -7.72204161e-01f, -2.54690021e-01f, -7.67418444e-01f, -5.09707570e-01f, 6.43524349e-01f, -6.42376482e-01f, 5.73799193e-01f,
  3.94232690e-01f, -1.35246068e-01f, -2.33119145e-01f, -5.19021928e-01f, 4.11111265e-01f, -4.93450969e-01f, 3.57442759e-02f, -4.21528555e-02f, -1.10233568e-01f, -1.64448202e-01f,
  -5.05383193e-01f, -8.12345371e-02f, -3.50101352e-01f, 3.33756208e-01f, -5.49097359e-01f, 3.11942488e-01f, -2.01977760e-01f, 3.09196174e-01f, -2.33494982e-01f, -4.12068695e-01f,
  -2.84115851e-01f, -2.09716916e-01f, -4.58451986e-01f, 3.01798642e-01f, 5.69257617e-01f, -8.04790139e-01f, 7.36016870e-01f, 5.62870443e-01f, -7.98096240e-01f, -2.01097354e-01f,
  -2.43204877e-01f, -7.26296723e-01f, -5.19175529e-01f, 2.70270795e-01f, 9.41617906e-01f, -8.94721806e-01f, -6.19217873e-01f, -3.89044821e-01f, 3.63595009e-01f, 2.08646879e-01f,
  4.10908103e-01f, -1.36360377e-01f, 4.35500234e-01f, 2.16096818e-01f, 1.94072947e-01f, 6.60263836e-01f, 5.64650118e-01f, 4.59723592e-01f, -1.00166225e+00f, 6.95281804e-01f,
  -6.18440211e-01f, -9.19562995e-01f, 5.16941845e-01f, 6.51142746e-02f, -1.01878352e-01f, -5.99848926e-01f, -3.56979877e-01f, -9.73304361e-02f, -4.25643593e-01f, -5.45051455e-01f,
  -4.38298672e-01f, -1.38389587e-01f, -6.04845822e-01f, 2.10088287e-02f, -3.74570310e-01f, 2.14156955e-01f, 7.42876470e-01f, 8.21375072e-01f, 6.49017751e-01f, 8.39831769e-01f,
  2.12102905e-01f, 6.00414813e-01f, 6.64535642e-01f, 1.45410612e-01f, 2.34199151e-01f, -1.39289591e-02f, 6.67459786e-01f, -8.97101343e-01f, 4.80815947e-01f, -6.82902515e-01f,
  5.09954751e-01f, -6.58459067e-01f, -5.62541664e-01f, 3.73851001e-01f, -7.07642913e-01f, -3.21035713e-01f, 7.23103136e-02f, -2.49474034e-01f, -6.94129169e-01f, 5.04272938e-01f,
  1.57722756e-01f, 7.82498956e-01f, 7.26621747e-01f, -8.63867104e-01f, -4.21555638e-01f, -6.36278808e-01f, -7.75059760e-01f, 9.28835422e-02f, -6.97015643e-01f, 3.66523236e-01f,
  -2.48350486e-01f, 4.06023592e-01f, 4.16315049e-02f, -3.03163528e-01f, -2.20578630e-02f, 1.06929861e-01f, -4.97512132e-01f, -3.59427661e-01f, -5.52457631e-01f, -2.65859872e-01f,
  -6.93466783e-01f, -3.16349775e-01f, 2.15486556e-01f, -1.33727863e-01f, -2.25619096e-02f, -1.15577340e-01f, -4.48646754e-01f, 7.58619726e-01f, 2.51715809e-01f, -7.67453551e-01f,
  -9.39595178e-02f, 7.68390238e-01f, -6.49473608e-01f, -7.55682290e-01f, 2.48482618e-02f, 6.67899847e-01f, 1.84393048e-01f, -7.73714960e-01f, 5.94496205e-02f, 8.92570138e-01f,
  -5.43437362e-01f, -7.26300180e-01f, -6.15722775e-01f, -6.99566841e-01f, 5.45193888e-02f, -3.39118779e-01f, -7.45175853e-02f, -1.77918434e-01f, -3.14559847e-01f, -2.75602818e-01f,
  8.06900486e-02f, -4.85885859e-01f, -1.58252269e-01f, 1.27230778e-01f, -1.15446448e-01f, -5.91730237e-01f, -5.83869815e-01f, -5.50466776e-01f, 4.21814144e-01f, -2.99735278e-01f,
  -2.60248214e-01f, -8.06070983e-01f, 1.46974295e-01f, -1.29392624e-01f, 5.77549756e-01f, -5.11876941e-01f, 6.83827698e-01f, -2.60826856e-01f, 3.28005403e-01f, -2.40616307e-01f,
  5.44501066e-01f, -2.75786728e-01f, 1.30266309e-01f, -5.12339294e-01f, 1.79494023e-01f, 2.18503714e-01f, -7.73633271e-02f, 1.09876260e-01f, -1.28170371e-01f, 6.38246313e-02f,
  -7.12613808e-03f, 1.66701108e-01f, 4.80073750e-01f, 7.21503124e-02f, -3.82072300e-01f, 4.03233141e-01f, 5.08640945e-01f, -9.74974930e-02f, -6.32344961e-01f, 2.81358510e-01f,
  -4.52848643e-01f, -5.92765927e-01f, -4.70075041e-01f, 2.75950849e-01f, -8.11223388e-01f, -3.95702392e-01f, -4.60747063e-01f, -4.61611003e-02f, -2.99912781e-01f, 6.13186061e-01f,
  8.24919283e-01f, -5.86937785e-01f, -1.64305925e-01f, -4.74478215e-01f, -3.55334103e-01f, 7.85768554e-02f, 6.80441856e-01f, -4.32409972e-01f, -2.85875559e-01f, -3.36023837e-01f,
  3.30310315e-01f, 2.02378020e-01f, 3.25379997e-01f, 2.86755979e-01f, 3.73762757e-01f, -5.46084404e-01f, 1.98557004e-01f, -1.99872956e-01f, 4.91440028e-01f, -8.69737417e-02f,
  8.41549218e-01f, -2.67403245e-01f, -3.02235186e-01f, 4.77289051e-01f, -1.01762092e+00f, -2.87019998e-01f, -2.84554899e-01f, 1.90661475e-01f, -2.17928320e-01f, -6.81775272e-01f,
  -5.98761261e-01f, -6.09215975e-01f, -8.65839608e-03f, 1.77709639e-01f, 9.36938524e-01f, -9.65973377e-01f, -2.32989788e-01f, -2.74053752e-01f, -7.17992961e-01f, 6.84078276e-01f,
  2.52647977e-02f, -3.04761529e-01f, 3.23266953e-01f, 2.20313728e-01f, -7.90409744e-02f, 8.06223303e-02f, -3.01281619e-03f, 5.05976260e-01f, 1.92715451e-01f, -4.57007557e-01f,
  -5.68050861e-01f, 2.26313204e-01f, -2.56894022e-01f, -7.04358757e-01f, -5.50808668e-01f, -6.78474188e-01f, 4.32223827e-01f, 6.27403677e-01f, 5.10274351e-01f, -3.03630948e-01f,
  -7.35556424e-01f, -4.84614074e-01f, 4.79963310e-02f, -7.50599205e-01f, 7.99603999e-01f, 9.65674996e-01f, -2.50193775e-01f, 2.43163511e-01f, -4.84565586e-01f, -4.39058483e-01f,
  -4.82047945e-01f, -3.43381196e-01f, -1.30720124e-01f, 5.54044880e-02f, -2.70609915e-01f, 6.53272271e-02f, 2.81957179e-01f, 1.08690962e-01f, 2.69786596e-01f, -4.24833566e-01f,
  -4.67535257e-01f, -1.12446308e-01f, 3.38184893e-01f, -5.75497374e-03f, -2.72433460e-01f, 3.51773649e-02f, 9.63621199e-01f, -1.37256280e-01f, -3.89419138e-01f, 9.24418271e-01f,
  -6.41665280e-01f, 3.20649892e-01f, 3.07287514e-01f, -5.12458563e-01f, -3.42124701e-01f, -4.04928863e-01f, -2.30919167e-01f, -5.20078599e-01f, -5.18128872e-01f, 3.08622926e-01f,
  -6.94577873e-01f, -4.13934328e-02f, -4.81455505e-01f, -5.25451958e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.23537101e-01f, 6.82385825e-03f, -1.49638593e-01f, -9.35939401e-02f, 2.34289631e-01f, 1.65069804e-01f, 4.85308021e-02f, -2.79591292e-01f, -1.27660379e-01f, 3.98544334e-02f,
  9.57148820e-02f, 6.29584640e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    