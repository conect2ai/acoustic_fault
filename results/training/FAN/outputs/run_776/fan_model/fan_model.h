/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.21556857e-01f, -1.81412593e-01f, -2.09634751e-01f, -2.18256503e-01f, 1.20501436e-01f, 3.88339847e-01f, 4.20685410e-01f, 2.51854420e-01f, 6.05930854e-03f, -9.51034874e-02f,
  8.94247293e-02f, -4.65328768e-02f, -1.10899158e-01f, 1.21508338e-01f, 2.01821819e-01f, 1.43276766e-01f, -7.64961988e-02f, -2.08582222e-01f, 1.37343228e-01f, 2.64567226e-01f,
  1.80438906e-01f, -1.52239844e-01f, -1.90195531e-01f, -9.42862406e-03f, -2.09335849e-01f, 8.21231008e-02f, -1.69174105e-01f, -2.53880262e-01f, 1.48290411e-01f, -5.00815868e-01f,
  -3.57876986e-01f, -2.26822495e-01f, 2.10719019e-01f, 3.56820151e-02f, -2.81201247e-02f, -6.42112941e-02f, 1.01252578e-01f, -1.53646737e-01f, 5.28434254e-02f, -9.10032913e-03f,
  -3.25082578e-02f, -6.07056394e-02f, -3.20582977e-03f, 5.93283121e-03f, -1.08189702e-01f, 1.88313285e-03f, -5.82689904e-02f, 2.06940584e-02f, 5.32929376e-02f, -1.43364510e-02f,
  -7.04989582e-02f, -6.86463118e-02f, -3.79993618e-02f, 1.74793139e-01f, 2.02992618e-01f, 6.98040724e-02f, 3.33208703e-02f, -1.37124991e-03f, 2.04234913e-01f, -1.25165135e-01f,
  5.52053638e-02f, -8.76374729e-03f, 3.86955775e-02f, -1.68743059e-02f, 7.26252282e-03f, 8.00770596e-02f, -5.11474386e-02f, 3.52169201e-02f, 7.18069598e-02f, -3.78537104e-02f,
  6.88092113e-02f, -1.04467180e-02f, 1.54051203e-02f, -2.90962588e-02f, -4.00089733e-02f, -7.03333784e-03f, -8.75917263e-03f, -4.89816675e-03f, 2.74001248e-03f, -1.20345904e-02f,
  -1.25539545e-02f, 4.18495834e-02f, -7.44663477e-02f, 2.53155846e-02f, 3.19732241e-02f, -2.75549162e-02f, 6.91396696e-03f, 2.47284751e-02f, -2.98726726e-02f, -3.60035487e-02f,
  -4.90705147e-02f, 2.83895701e-01f, -1.75144181e-01f, -1.16105890e-02f, -4.44195569e-02f, -2.49968166e-03f, -6.30813390e-02f, 2.75116451e-02f, -7.44129270e-02f, 9.80388932e-03f,
  6.92624152e-02f, -5.12750968e-02f, -4.68369685e-02f, 4.06650119e-02f, 1.48866400e-02f, 2.09564827e-02f, 4.79219630e-02f, -8.90303552e-02f, 5.05481996e-02f, -7.40853623e-02f,
  -3.56175900e-02f, 3.31953205e-02f, 6.71768142e-03f, 7.63092786e-02f, -5.28376065e-02f, 6.28302768e-02f, -3.20343040e-02f, -8.44094306e-02f, 1.28538027e-01f, 5.58851510e-02f,
  -1.53274670e-01f, 8.88988897e-02f, 3.85570109e-01f, -7.23951608e-02f, 4.77695204e-02f, 2.63536245e-01f, 3.66150677e-01f, 9.24277678e-02f, -1.10637203e-01f, 1.22304503e-02f,
  -2.68541545e-01f, -3.46975356e-01f, -2.65103817e-01f, -1.22877702e-01f, 1.72215864e-01f, 4.59862858e-01f, 5.53738296e-01f, 2.55641490e-01f, 1.29513234e-01f, 1.38400689e-01f,
  8.65886062e-02f, -2.96915397e-02f, -8.80835950e-02f, 6.48744032e-02f, -5.99080026e-02f, -2.78679639e-01f, -9.90259498e-02f, -1.55191287e-01f, 7.68224197e-03f, 2.52918273e-01f,
  -1.50570840e-01f, 4.25784551e-02f, 7.17647523e-02f, -3.34940627e-02f, -7.42720515e-02f, 8.35423321e-02f, -3.66548449e-02f, 7.89493546e-02f, -3.59882787e-02f, 1.88197214e-02f,
  -7.63303787e-02f, -5.49470186e-02f, 3.12581807e-02f, -5.11256643e-02f, -3.33355814e-02f, -5.36065437e-02f, 8.48008469e-02f, 1.12588152e-01f, 1.64489336e-02f, 1.81886666e-02f,
  -8.03960562e-02f, 1.12279527e-01f, 9.08562392e-02f, 5.21717705e-02f, 9.39951017e-02f, 8.66244584e-02f, 3.83854704e-03f, -3.33755314e-02f, 9.89592746e-02f, -5.38081378e-02f,
  1.44888004e-02f, 8.47783685e-03f, 9.66991205e-03f, -3.28410156e-02f, -7.20816180e-02f, -7.86338151e-02f, 5.82695007e-02f, -5.76690696e-02f, -2.77753044e-02f, -2.39070449e-02f,
  -7.37463299e-04f, 9.12053883e-03f, 2.07796022e-02f, -2.27213418e-03f, 8.79161060e-04f, 1.67545658e-02f, 7.54276440e-02f, -3.67021114e-02f, -3.45595144e-02f, 3.07116774e-03f,
  -5.93971983e-02f, -9.42976680e-03f, -3.01122852e-02f, 2.73075569e-02f, 7.11551607e-02f, 4.05581146e-02f, 2.67293956e-02f, -5.81393838e-02f, -5.24430946e-02f, 2.96886116e-02f,
  -3.55905235e-01f, 1.78485319e-01f, -1.38164476e-01f, 4.40033823e-02f, 2.20889840e-02f, -5.35695143e-02f, -3.83102782e-02f, 1.39086042e-02f, -4.14205790e-02f, -1.00979991e-02f,
  1.19397053e-02f, -4.00933932e-04f, -9.27847717e-03f, -3.79373133e-02f, 1.91950630e-02f, -4.61491989e-03f, 2.32666209e-02f, -4.21933942e-02f, 6.10473827e-02f, -8.57131556e-02f,
  -1.24973161e-02f, 7.30022974e-03f, -1.70885175e-01f, -1.18494749e-01f, 3.12849842e-02f, -2.94408790e-04f, -9.36017260e-02f, -1.14041734e-02f, 7.88385123e-02f, -1.12981595e-01f,
  -1.71336159e-01f, 3.90690923e-01f, -9.47671309e-02f, -4.69477512e-02f, 2.93435961e-01f, 9.56719890e-02f, 1.90390900e-01f, -1.59251392e-02f, -1.25589892e-01f, 8.59766230e-02f,
  4.19258280e-03f, -1.93309948e-01f, -2.63465524e-01f, -2.61754960e-01f, -1.66739404e-01f, 3.19797657e-02f, 1.33265927e-01f, -1.41608790e-01f, -2.31686041e-01f, 6.45043328e-02f,
  2.44062170e-01f, 3.11284095e-01f, -2.05807853e-02f, -2.48558410e-02f, -2.03663437e-03f, -9.88851115e-02f, -8.55896845e-02f, 1.46362439e-01f, -2.15462013e-03f, 1.82087183e-01f,
  -2.73275495e-01f, 1.43830001e-01f, -1.63826212e-01f, 9.33448374e-02f, 7.96931013e-02f, -7.66699538e-02f, -6.44934997e-02f, -7.19928443e-02f, 1.68928094e-02f, -1.03705347e-01f,
  4.07934608e-03f, 1.23964310e-01f, 1.25203684e-01f, 3.78862582e-02f, 3.16266343e-02f, -7.38339350e-02f, 5.77668250e-02f, -3.57485227e-02f, -9.87673253e-02f, -1.46418186e-02f,
  1.94077015e-01f, 1.24037333e-01f, -3.71844471e-02f, 6.06526136e-02f, -1.28024861e-01f, 2.81250216e-02f, 5.06749600e-02f, -1.30713984e-01f, -1.27406076e-01f, -7.50288218e-02f,
  2.22639646e-02f, -1.96153708e-02f, -1.65655464e-02f, 7.37944916e-02f, 5.55299688e-03f, -1.31212855e-02f, -1.67034622e-02f, -3.98449972e-02f, 6.52098060e-02f, 7.88632706e-02f,
  -7.44621232e-02f, 3.13446335e-02f, 3.91601659e-02f, -9.77079794e-02f, -6.71185553e-02f, 3.20674777e-02f, -4.01609316e-02f, 1.07571678e-02f, -5.23193553e-02f, -1.92267522e-02f,
  -1.45824691e-02f, -8.05746466e-02f, -1.59672722e-02f, 3.25522833e-02f, 2.55272761e-02f, -3.74044701e-02f, -1.06905717e-02f, 4.65507545e-02f, -3.29244658e-02f, 7.18293572e-03f,
  -2.28597388e-01f, -3.43169714e-03f, -1.94209918e-01f, -8.35225284e-02f, -5.98857217e-02f, 8.44689086e-03f, -1.36040654e-02f, -6.70660660e-03f, 4.27891910e-02f, -1.36138247e-02f,
  2.07220428e-02f, -5.16722053e-02f, -2.86051463e-02f, 6.69657737e-02f, 2.62838565e-02f, -6.16290718e-02f, 1.34005085e-01f, -9.14268866e-02f, 9.21784863e-02f, 1.04913890e-01f,
  -3.62183861e-02f, -9.05023962e-02f, -1.64270386e-01f, -1.87382713e-01f, -2.01059449e-02f, -2.35418051e-01f, -1.37248099e-01f, -1.50725991e-01f, -3.27182055e-01f, -2.03211099e-01f,
  1.64105430e-01f, 2.85354972e-01f, -5.04431188e-01f, 3.07095647e-01f, -2.80830085e-01f, -4.40622061e-01f, -4.30505186e-01f, -1.54832214e-01f, 2.00742796e-01f, 1.20071687e-01f,
  -5.12046553e-02f, 1.69993103e-01f, 1.08611591e-01f, 1.22554049e-01f, 1.14061302e-02f, 4.24230844e-02f, 6.59692138e-02f, -8.72183889e-02f, -3.17269176e-01f, -2.44454384e-01f,
  3.18770409e-01f, 1.73185036e-01f, 6.00775108e-02f, 1.84782386e-01f, 1.80235118e-01f, 2.68622428e-01f, -6.68147486e-03f, -3.67629528e-03f, 1.00273021e-01f, 6.62607789e-01f,
  -2.79888511e-01f, -8.94872025e-02f, -5.36314584e-02f, 1.59703612e-01f, -1.08506188e-01f, 4.13530469e-02f, 2.77614389e-02f, 2.04968476e-03f, 4.59136367e-02f, 6.71536773e-02f,
  3.84312798e-03f, -6.05763635e-03f, 2.62273848e-02f, 8.69686157e-02f, -2.61657853e-02f, -1.05047815e-01f, -1.26901731e-01f, -3.82584371e-02f, 6.96097687e-02f, -1.17145739e-01f,
  6.91121668e-02f, -4.25971299e-02f, -3.11371654e-01f, -7.76157156e-03f, -1.67719170e-01f, -5.93732446e-02f, -1.53962776e-01f, -2.77941413e-02f, -1.28845051e-01f, 3.28526765e-01f,
  3.00197229e-02f, 2.74089370e-02f, -5.43690547e-02f, -4.60813195e-03f, 1.42753506e-02f, -2.19279132e-03f, 2.37648655e-02f, -1.07804239e-02f, 1.04849478e-02f, -2.93775946e-02f,
  -1.81872901e-02f, 2.01221672e-04f, 5.49492277e-02f, 4.96702231e-02f, 1.30506590e-01f, -2.31899973e-02f, 8.22694448e-04f, 7.25032240e-02f, -7.21118692e-03f, -2.78712739e-03f,
  -1.83458664e-02f, -3.30650955e-02f, 5.02732024e-02f, 2.90797371e-02f, 2.18840595e-02f, -2.18300242e-02f, 4.04747911e-02f, -1.13576641e-02f, -6.95481077e-02f, 3.02483141e-03f,
  2.10056081e-01f, -8.46818835e-02f, 2.12863222e-01f, -1.06786206e-01f, 7.09515214e-02f, -4.40831743e-02f, 5.17804287e-02f, 9.35006738e-02f, -3.40207480e-02f, 3.04664373e-02f,
  -7.67419934e-02f, -4.98963483e-02f, -8.86181369e-03f, -6.40780060e-03f, -1.83407236e-02f, -1.25429193e-02f, 8.73492360e-02f, 5.89176603e-02f, 5.54174036e-02f, 2.28948463e-02f,
  2.67005898e-02f, 9.21251345e-03f, 4.55758944e-02f, 2.15598382e-02f, 6.67217895e-02f, 3.32507342e-02f, -1.08596362e-01f, -5.96875921e-02f, -1.19906053e-01f, 2.85854965e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.56816286e-01f, -1.93302497e-01f, -3.11967164e-01f, -1.54344887e-01f, -8.43699127e-02f, -9.59221944e-02f, -2.10408121e-01f, -3.16695571e-02f, 1.49027035e-01f, -1.44459251e-02f,
  -1.10782571e-01f, -1.55663505e-01f, -3.16071361e-01f, -2.71955967e-01f, -4.36828762e-01f, -3.72183055e-01f, -3.16292495e-01f, -4.41535175e-01f, -3.91035646e-01f, -9.63180885e-02f,
  -7.81125054e-02f, -2.83774585e-01f, -3.33539575e-01f, -4.91945259e-02f, -7.72182271e-03f, -2.40969449e-01f, -1.78694427e-01f, -2.79703557e-01f, -2.42379650e-01f, -1.42621443e-01f,
  -1.59501389e-01f, -4.51037213e-02f, -4.62999381e-02f, -5.03077209e-02f, 4.92136404e-02f, 1.83939114e-02f, -4.20977771e-02f, 2.12554559e-02f, 1.10437870e-02f, -8.03800672e-02f,
  -5.23393415e-03f, 9.96628255e-02f, 1.28941583e-02f, 6.36739507e-02f, -9.56180692e-02f, -8.93042386e-02f, -1.32362440e-01f, -2.12987095e-01f, -1.03269301e-01f, 9.93136093e-02f,
  -3.40124629e-02f, -2.61002243e-01f, -3.07481319e-01f, -8.97391140e-02f, -2.82719120e-04f, -2.11025983e-01f, -8.55427459e-02f, -1.10276997e-01f, -2.47652635e-01f, -1.89211160e-01f,
  1.22427098e-01f, 4.10941169e-02f, -4.45682630e-02f, 2.96582491e-03f, 2.16028672e-02f, 2.64158156e-02f, 1.49480477e-02f, -5.23189045e-02f, -3.30392495e-02f, 5.48866624e-03f,
  -1.51335797e-03f, 7.40646496e-02f, 7.18896389e-02f, -5.55255972e-02f, -1.11992015e-02f, 4.41817334e-03f, -7.64902458e-02f, -4.80317883e-02f, -5.81144728e-02f, 6.43970026e-03f,
  -9.38557982e-02f, -1.63496565e-02f, -3.90318781e-02f, -7.22184405e-03f, -1.29564330e-01f, 1.32702598e-02f, -3.18046771e-02f, 7.04461113e-02f, 6.91263378e-02f, 7.17386007e-02f,
  -1.00680910e-01f, -1.82317302e-01f, -6.32472113e-02f, -1.20948501e-01f, -2.08888091e-02f, 3.60280536e-02f, 5.70826558e-03f, -1.72420871e-02f, 2.32295897e-02f, -1.70985498e-02f,
  -7.81782940e-02f, -4.13009264e-02f, -1.28801122e-01f, 2.75680479e-02f, -4.90882583e-02f, -5.14729731e-02f, 1.00068226e-02f, -2.76797265e-01f, -1.93706840e-01f, 1.28301606e-01f,
  -4.20353897e-02f, -2.62443960e-01f, -4.76171851e-01f, -2.33056664e-01f, -1.86544031e-01f, -4.26500559e-01f, -3.36530089e-01f, -2.34221488e-01f, -3.32433075e-01f, -1.79768473e-01f,
  -2.86271125e-01f, 2.65991151e-01f, -2.36333683e-01f, 3.58245254e-01f, 4.74725276e-01f, 2.26254165e-01f, 1.85230389e-01f, -2.09436342e-01f, 8.06146339e-02f, 2.23966643e-01f,
  2.61837453e-01f, 1.74823761e-01f, -9.81865171e-03f, -1.14607796e-01f, -1.82507604e-01f, 1.01457164e-01f, 1.17752671e-01f, -1.80791780e-01f, -2.26064637e-01f, 1.21451914e-01f,
  4.08393174e-01f, 1.10293955e-01f, -2.62426466e-01f, -4.75393571e-02f, 4.72370893e-01f, 2.24985495e-01f, -1.03562608e-01f, 1.45716503e-01f, 1.53650835e-01f, 6.08474553e-01f,
  2.07117468e-01f, -6.35579601e-02f, -2.14774087e-01f, 3.98685709e-02f, 1.01546340e-01f, -1.91451758e-01f, 3.20601463e-02f, -2.16814756e-01f, -8.23625550e-03f, -9.34671015e-02f,
  1.43987015e-01f, 7.12645380e-03f, 2.18817830e-01f, -4.26413566e-02f, -1.37000203e-01f, -9.38164219e-02f, -1.92276552e-01f, -2.97657639e-01f, -2.79248774e-01f, 1.30608501e-02f,
  4.57486033e-01f, 2.11998343e-01f, -9.70669761e-02f, -2.97243923e-01f, -2.03681260e-01f, -1.74355414e-02f, -6.94752261e-02f, -6.49893433e-02f, -4.32978094e-01f, -1.76631734e-01f,
  5.89477345e-02f, -1.27750477e-02f, -4.06030379e-03f, 8.17345455e-02f, 4.33094949e-02f, 5.36869466e-02f, 3.95126976e-02f, 9.53791067e-02f, -2.84129791e-02f, 2.11502910e-02f,
  -1.13618746e-02f, -4.12117988e-02f, -6.53435141e-02f, -2.90628467e-02f, 7.23675266e-02f, 4.15492840e-02f, 2.92279050e-02f, -2.32563131e-02f, -5.67526780e-02f, -7.06637204e-02f,
  4.49805260e-02f, -1.77485812e-02f, -5.96493110e-02f, 1.96830034e-02f, 2.48949248e-02f, 2.16617454e-02f, 2.11723149e-02f, -2.29534861e-02f, -4.75705676e-02f, 3.79705466e-02f,
  -2.30984375e-01f, -4.34556067e-01f, 4.60938215e-02f, -1.34414416e-02f, 6.65400028e-02f, -2.94294041e-02f, 7.79557005e-02f, -5.37970737e-02f, 3.07467040e-02f, -4.43822816e-02f,
  -7.73998955e-03f, -6.78341985e-02f, -3.95965651e-02f, -4.64340262e-02f, -3.92615870e-02f, -1.32010981e-01f, -6.27590483e-03f, -2.44500656e-02f, -2.15236813e-01f, -5.69272824e-02f,
  -3.56151722e-03f, -1.20010667e-01f, -2.44178295e-01f, -2.26530612e-01f, -5.01071177e-02f, -2.09370464e-01f, -2.16646507e-01f, -2.70327359e-01f, -4.36361939e-01f, -3.72418046e-01f,
  7.89254487e-01f, 5.65341651e-01f, 4.47009146e-01f, 1.56243861e-01f, -1.78572401e-01f, 7.20724463e-02f, 3.95428061e-01f, 2.67388046e-01f, 5.69989346e-02f, 2.73755610e-01f,
  9.72440913e-02f, -5.94706461e-02f, 5.13354130e-02f, 2.05224261e-01f, 2.24626929e-01f, 1.60127282e-01f, -2.21252963e-02f, 1.76420122e-01f, 1.86830506e-01f, 3.38186137e-02f,
  -7.09614009e-02f, -9.72357616e-02f, 7.54973888e-02f, 1.26602113e-01f, -6.99640587e-02f, -1.43469349e-01f, 8.85939822e-02f, 7.70820081e-02f, -1.60130188e-02f, 1.00954190e-01f,
  2.25015268e-01f, 6.06865704e-01f, -1.67540789e-01f, -2.84718513e-01f, -1.47755280e-01f, 9.91686583e-02f, 3.47427763e-02f, -4.40529697e-02f, -1.32780641e-01f, -4.13629599e-02f,
  -2.45365217e-01f, 1.00790765e-02f, -7.67575428e-02f, -7.11392760e-02f, -1.19088860e-02f, 1.57743180e-03f, -2.08833050e-02f, 2.21800029e-01f, 5.23442775e-02f, 3.26945856e-02f,
  -1.24274760e-01f, -1.12171613e-01f, -2.94121634e-02f, 2.40287371e-03f, 1.00346744e-01f, -1.74604729e-01f, 4.52078208e-02f, 8.83003622e-02f, 1.17325313e-01f, 1.38439730e-01f,
  2.27019377e-02f, 7.96883926e-02f, 2.60442048e-02f, 6.20744750e-02f, 5.74209839e-02f, -3.65441339e-03f, 2.04523671e-02f, -3.44925411e-02f, 4.03273478e-02f, 1.50704561e-02f,
  6.70272708e-02f, 2.92009842e-02f, 6.00376651e-02f, 8.02890807e-02f, -6.40791208e-02f, -1.62691399e-02f, -7.08873719e-02f, -2.16304101e-02f, 3.92883047e-02f, -9.71369818e-02f,
  9.41613317e-02f, -2.08789188e-05f, -7.18907490e-02f, 1.43062696e-01f, 2.84621939e-02f, 9.37950313e-02f, -4.65471521e-02f, -1.00385342e-02f, 5.27992030e-04f, -8.59855562e-02f,
  -4.06974137e-01f, -2.14158401e-01f, 1.05408102e-01f, 7.86310956e-02f, -9.92465615e-02f, -3.18637528e-02f, 1.02961920e-01f, -3.60096619e-02f, -1.12094752e-01f, 1.20825388e-01f,
  -4.51997854e-02f, 8.31536427e-02f, 1.40649527e-01f, -5.52789792e-02f, -1.17569081e-01f, -6.54655322e-02f, -1.41028166e-01f, -9.89563763e-02f, -1.15644000e-01f, -4.70359065e-02f,
  -1.61557212e-01f, -1.21449746e-01f, -8.45719054e-02f, -2.15553969e-01f, -1.12253450e-01f, -2.09714130e-01f, -1.23384647e-01f, -1.66589737e-01f, -1.12016931e-01f, 3.61267701e-02f,
  9.46818113e-01f, -5.71113944e-01f, -1.01580429e+00f, 1.08251497e-02f, -2.27178708e-01f, -1.09368183e-01f, -1.47646368e-01f, 2.25691512e-01f, 8.00006762e-02f, -2.30020419e-01f,
  7.61875212e-02f, 3.69266838e-01f, 1.38930991e-01f, 7.93181583e-02f, 2.76070476e-01f, -4.51224655e-01f, -5.14995992e-01f, -1.43253282e-01f, 2.15445980e-01f, 3.43397588e-01f,
  5.80015145e-02f, 3.03417761e-02f, 1.23453990e-01f, -9.41846892e-03f, -2.43633837e-01f, -1.57811955e-01f, -6.30960166e-01f, -2.97052592e-01f, -3.28334033e-01f, -5.15289903e-01f,
  -5.25699854e-01f, -9.44728870e-03f, 1.59876540e-01f, 1.17752515e-01f, -3.17051500e-01f, 1.13369517e-01f, -1.75180268e-02f, -1.68165386e-01f, 1.57415345e-02f, -1.82209060e-01f,
  -9.64127332e-02f, 1.08391792e-01f, -5.06523550e-02f, -4.28039469e-02f, 7.32642040e-02f, 9.12026539e-02f, -1.94692954e-01f, -1.44081011e-01f, -3.29832919e-02f, -1.75225064e-01f,
  -8.73048976e-02f, 2.02880874e-02f, -3.28985564e-02f, 1.22818155e-02f, -1.13486364e-01f, -1.54610013e-03f, -2.15675846e-01f, -2.82731652e-02f, -1.48832062e-02f, -1.81573361e-01f,
  -7.76485428e-02f, -9.19077918e-02f, 4.49399911e-02f, -9.93581023e-03f, 9.56688747e-02f, -6.11922182e-02f, -3.31643410e-02f, 8.61873571e-03f, 1.69680696e-02f, -1.13342796e-02f,
  -6.04402553e-03f, -2.83243563e-02f, -4.45389673e-02f, -5.73730767e-02f, -8.69513154e-02f, -7.64225349e-02f, 2.92132087e-02f, -5.23348004e-02f, 2.76511014e-02f, 2.95910109e-02f,
  5.73073216e-02f, 4.91760895e-02f, -1.10527903e-01f, 3.51352319e-02f, -8.02279189e-02f, -4.75243703e-02f, 1.01269484e-02f, 1.03534400e-01f, 8.76629800e-02f, 6.60855100e-02f,
  1.85294822e-01f, 8.91891941e-02f, 4.57733311e-02f, 2.11241528e-01f, -1.20593958e-01f, -1.27155751e-01f, -5.55406287e-02f, -5.52360192e-02f, -4.32133637e-02f, 3.65564749e-02f,
  2.42139194e-02f, 8.48393068e-02f, -1.23330228e-01f, 2.72274297e-02f, 7.45467395e-02f, 1.25681102e-01f, 4.11622301e-02f, 3.58823724e-02f, 8.48218277e-02f, -8.53465274e-02f,
  -6.57639578e-02f, 2.64040023e-01f, 4.22009766e-01f, 1.69307441e-02f, 1.06975511e-01f, 2.63278782e-01f, 5.20531870e-02f, 5.34209087e-02f, 1.63602144e-01f, 1.21127091e-01f,
  -3.08871657e-01f, -1.04823492e-01f, -3.72769982e-02f, -3.34094949e-02f, 2.99229741e-01f, 5.65546870e-01f, 5.85005879e-01f, 2.39208415e-01f, 2.18574442e-02f, 1.54621705e-01f,
  -2.51574636e-01f, -2.83938348e-01f, -4.04196262e-01f, -3.19790572e-01f, -6.60166740e-02f, 2.73096114e-01f, 3.76097411e-01f, 5.58930188e-02f, 1.22044325e-01f, 2.49438792e-01f,
  1.32356480e-01f, 1.48673244e-02f, -3.00076008e-01f, -8.09058324e-02f, -5.04150316e-02f, -7.92280808e-02f, -8.75702426e-02f, -1.52106225e-01f, -1.64025560e-01f, -1.85036153e-01f,
  1.46720678e-01f, -5.54659426e-01f, 5.19744419e-02f, -2.35333353e-01f, -1.43195659e-01f, -7.84807876e-02f, 1.54497489e-01f, -1.44497856e-01f, -1.36780575e-01f, 5.48371710e-02f,
  -2.74199665e-01f, -5.92596903e-02f, -2.40468323e-01f, -9.88410693e-03f, 7.94665888e-02f, 9.89095867e-03f, -1.78157985e-01f, -3.65893096e-01f, -2.62268156e-01f, -1.48801163e-01f,
  -1.35490075e-01f, -1.41809523e-01f, -1.66927218e-01f, -6.51148632e-02f, -2.88683265e-01f, -2.20233276e-01f, -1.81210771e-01f, -2.70306230e-01f, -2.37013191e-01f, -7.06839887e-03f,
  1.29461840e-01f, -6.47232160e-02f, -4.44534533e-02f, 1.94529798e-02f, 1.22241110e-01f, -2.85786614e-02f, 7.50725269e-02f, 2.37885360e-02f, 4.98080701e-02f, 3.84696610e-02f,
  -3.81720774e-02f, -2.36425716e-02f, -1.83565021e-02f, 4.38730977e-02f, -4.92762290e-02f, -9.95965376e-02f, -4.67282051e-04f, 6.05455674e-02f, -3.42310369e-02f, -1.09040365e-02f,
  -7.80205801e-02f, -5.89452907e-02f, -1.02870809e-02f, 6.89670723e-03f, -8.10900778e-02f, -1.50394766e-02f, -2.06849743e-02f, -5.57507500e-02f, -4.67980001e-03f, -5.31983860e-02f,
  3.13641667e-01f, -3.17672402e-01f, 1.37805939e-01f, -6.53742403e-02f, -2.32827477e-02f, -8.15767869e-02f, -6.21530339e-02f, -1.27889052e-01f, -1.08247243e-01f, 9.54836905e-02f,
  -1.16433658e-01f, 9.94745921e-03f, -4.64586504e-02f, 1.76869854e-02f, 1.77784801e-01f, 1.04877435e-01f, 3.69357988e-02f, 6.33425862e-02f, -7.62799904e-02f, 5.76063357e-02f,
  1.35553300e-01f, 4.05119061e-01f, 4.72550392e-01f, 2.11077586e-01f, -6.22485541e-02f, 2.50257313e-01f, 2.28506073e-01f, 1.79112867e-01f, 2.37407014e-01f, 9.24402654e-01f,
  -1.00376964e+00f, 2.83592194e-01f, 1.22721560e-01f, -6.70446515e-01f, -2.01651052e-01f, 1.38572156e-01f, 2.50184834e-01f, 7.17501566e-02f, -1.71828270e-01f, 1.06462622e-02f,
  1.75274223e-01f, -4.90307473e-02f, -6.97098076e-02f, 8.95715579e-02f, 1.88138798e-01f, 2.51039505e-01f, -3.08459578e-03f, -1.62819445e-01f, -1.49135634e-01f, -8.70211869e-02f,
  -2.32287958e-01f, -4.72990513e-01f, -4.24354255e-01f, -2.77969480e-01f, -1.06851548e-01f, -1.54790387e-01f, 3.65829319e-02f, -6.61616102e-02f, 1.86686233e-01f, 1.51939034e-01f,
  5.45570195e-01f, -5.54116182e-02f, -7.06506334e-03f, -2.03297123e-01f, -9.45391804e-02f, -3.73971760e-02f, 4.13921960e-02f, -1.35538891e-01f, -1.21995382e-01f, 1.15948133e-02f,
  -2.95611713e-02f, -8.05403590e-02f, -9.86997336e-02f, -6.27517626e-02f, -1.79089289e-02f, 4.68798019e-02f, -1.32899895e-01f, -1.29403114e-01f, -5.81561141e-02f, 1.30790636e-01f,
  2.11599514e-01f, 1.54991634e-02f, -4.17172052e-02f, 1.27113581e-01f, 1.24582879e-01f, -3.08771003e-02f, 1.38263732e-01f, 6.82869777e-02f, 9.09252167e-02f, 5.20172603e-02f,
  -7.80563504e-02f, 7.70349056e-02f, 4.53367047e-02f, -7.05846399e-02f, -2.09837430e-03f, -1.00954575e-02f, 1.55353844e-02f, 2.88717337e-02f, -6.74562603e-02f, 1.31771527e-03f,
  -8.49830173e-03f, 6.81562200e-02f, 1.44710077e-03f, -8.96825269e-02f, 2.98896804e-02f, -4.72498272e-04f, -1.48305390e-02f, 5.17455004e-02f, 7.02145100e-02f, -3.07540614e-02f,
  -8.01242515e-02f, 2.81124748e-02f, -8.53344202e-02f, 8.00617859e-02f, 3.04003954e-02f, -5.95951006e-02f, -2.24609654e-02f, 7.10883886e-02f, -9.60242748e-02f, -8.03286135e-02f,
  -1.12650648e-01f, -3.73950507e-03f, 1.14706866e-01f, 1.93808135e-02f, -1.02554463e-01f, -6.86094016e-02f, 3.21208462e-02f, -6.51957244e-02f, -1.05224200e-01f, -1.38593512e-02f,
  6.08856529e-02f, -4.63687852e-02f, 1.49415536e-02f, 6.84441179e-02f, -1.30239338e-01f, 3.78289656e-03f, -2.60180840e-03f, -9.73279700e-02f, 9.58936885e-02f, 5.45559712e-02f,
  -1.59242153e-02f, -4.61024269e-02f, -5.56298345e-02f, 1.33263931e-01f, 7.42651597e-02f, -3.52678411e-02f, 2.03162938e-01f, 2.89045852e-02f, 7.11941794e-02f, -3.62832844e-02f,
  4.10647720e-01f, 5.73487997e-01f, -3.35276276e-01f, 1.36880204e-01f, -2.58908093e-01f, -2.49769539e-01f, 2.30412021e-01f, 2.67770052e-01f, 2.68586874e-01f, 1.51355058e-01f,
  -1.93352327e-01f, -2.15555117e-01f, -1.43332839e-01f, -1.68984890e-01f, 5.42234294e-02f, 2.49879211e-01f, 1.74578533e-01f, -1.03081271e-01f, -3.89537036e-01f, -2.24551037e-02f,
  9.05775055e-02f, 2.04172265e-02f, -5.41730076e-02f, 6.82145357e-02f, 8.88100713e-02f, -1.33020937e-01f, 3.89628671e-02f, -1.45691484e-01f, -6.28610104e-02f, 3.00927997e-01f,
  -3.80800128e-01f, 8.85728821e-02f, -2.57666409e-01f, -2.72472166e-02f, -3.48185956e-01f, 4.08407338e-02f, -1.63571928e-02f, 3.09912656e-02f, -7.04408661e-02f, 1.31459355e-01f,
  -1.83242694e-01f, 2.92927306e-03f, -5.52178249e-02f, -5.75685501e-02f, -7.57337660e-02f, 1.57694693e-03f, 1.35602310e-01f, 9.44165960e-02f, -1.18209235e-01f, -1.05342962e-01f,
  -4.97378930e-02f, -2.16916084e-01f, -2.01459944e-01f, -7.09497789e-03f, -1.13465048e-01f, -1.99872851e-01f, 9.20492969e-03f, -4.63347472e-02f, -4.18170169e-02f, 3.06200445e-01f,
  -2.59950347e-02f, -6.38551190e-02f, -1.99538358e-02f, 5.27169965e-02f, 7.19379038e-02f, -6.51175454e-02f, -2.48711873e-02f, -4.33328785e-02f, 3.71147431e-02f, 3.51549871e-02f,
  -3.51991206e-02f, -1.09445294e-02f, -5.72602414e-02f, 3.56769748e-02f, -3.38101201e-02f, 1.60840768e-02f, 3.59103903e-02f, 9.15668234e-02f, -1.79830361e-02f, -4.29108404e-02f,
  6.26146644e-02f, -1.41452381e-03f, 1.10033881e-02f, 1.47639764e-02f, -6.57433877e-03f, 2.75186356e-02f, 5.75982407e-02f, -1.94404591e-02f, -1.04118250e-02f, 5.24464361e-02f,
  1.11758292e-01f, -5.72050929e-01f, 7.73343518e-02f, 1.00651592e-01f, 1.53055496e-03f, -1.66108552e-02f, -1.03322625e-01f, 3.40826549e-02f, -4.64875251e-02f, 2.30641086e-02f,
  -5.85676879e-02f, -1.64599754e-02f, -4.41318564e-02f, 3.03653087e-02f, -1.13036402e-01f, -3.10101490e-02f, 1.43732011e-01f, -7.77115747e-02f, -8.50768164e-02f, 1.93126872e-02f,
  1.65340602e-01f, 1.21203609e-01f, -4.95296419e-02f, 7.41087273e-02f, 4.57022749e-02f, -2.00249106e-01f, -2.41265912e-02f, 9.35877860e-02f, -5.77089004e-02f, 4.47586626e-01f,
  1.17285490e-01f, 3.47243369e-01f, 4.56269801e-01f, -9.57410410e-02f, 3.56439024e-01f, 4.40327704e-01f, 4.87920761e-01f, 1.70718223e-01f, -1.31801829e-01f, 1.92989513e-01f,
  1.28831670e-01f, -3.87396216e-01f, -2.91906357e-01f, -3.43024492e-01f, -2.10431665e-01f, -2.49981955e-02f, -1.99030410e-03f, -2.83383310e-01f, -2.72704065e-01f, -2.43777707e-01f,
  -1.84718758e-01f, -2.34357521e-01f, -1.93747431e-01f, -2.47644022e-01f, -1.55126035e-01f, -1.03714526e-01f, 1.75858244e-01f, 8.04141834e-02f, 6.11440875e-02f, -8.17952529e-02f,
  -4.67665941e-02f, 4.92124557e-01f, -2.53214508e-01f, -1.96069449e-01f, 8.62379223e-02f, -1.37795553e-01f, 6.86995983e-02f, -4.39040698e-02f, 8.61069784e-02f, -4.92120460e-02f,
  -4.36359569e-02f, -1.22520916e-01f, -1.39899664e-02f, 2.74744816e-03f, 2.76972204e-02f, 1.18775919e-01f, -3.61551307e-02f, -1.42315060e-01f, -1.12893701e-01f, 3.55678936e-03f,
  -1.18274897e-01f, 1.68847963e-01f, 2.06910402e-01f, 4.79137748e-02f, 4.32841256e-02f, 5.41033223e-03f, 1.46859378e-01f, 7.13890865e-02f, 1.03371143e-01f, -1.11423135e-01f,
  -6.47405013e-02f, -3.07142995e-02f, 6.95548877e-02f, -9.06235501e-02f, 1.25277042e-03f, -1.95073523e-02f, -5.67766391e-02f, -6.57817209e-03f, -5.91722913e-02f, -3.07242218e-02f,
  9.52656344e-02f, 7.07328469e-02f, 1.60048455e-02f, -2.95578316e-02f, -1.11357952e-02f, 5.87413199e-02f, 1.07228011e-02f, 4.63157566e-03f, 5.78482375e-02f, 1.13919064e-01f,
  2.44739521e-02f, 5.73853441e-02f, 7.36143291e-02f, -3.32804099e-02f, 5.03712371e-02f, 7.71995336e-02f, 1.57227106e-02f, 3.71456444e-02f, -1.34499902e-02f, 8.34540278e-02f,
  -3.93483698e-01f, 2.36394957e-01f, -1.20289676e-01f, -1.89496979e-01f, 1.55344188e-01f, 3.36996233e-03f, 1.21707460e-02f, -3.05087138e-02f, 7.90601298e-02f, 3.19039896e-02f,
  1.37845129e-01f, -3.83408181e-03f, 9.96759906e-02f, 1.45680662e-02f, 1.98605340e-02f, 4.41005919e-03f, -3.85540575e-02f, 1.75704546e-02f, -1.97971351e-02f, 3.46014509e-03f,
  3.45331356e-02f, 4.16137539e-02f, -6.01902232e-02f, -1.10763259e-01f, -3.44815920e-03f, -1.04411468e-01f, 7.51723945e-02f, 2.95707341e-02f, -3.06043997e-02f, -1.21581592e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.79109120e-01f, 1.93970427e-01f, 1.84755012e-01f, 3.06742936e-02f, 9.85295892e-01f, 4.16936547e-01f, 3.83258313e-01f, 5.23666739e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -3.39500844e-01f, -3.98711354e-01f, -2.50782515e-03f, -6.24908686e-01f, 5.38626969e-01f, 8.86818171e-02f, 1.51096494e-03f, -2.76755154e-01f, 7.59019494e-01f, -3.23704958e-01f,
  -2.40691498e-01f, 1.07566631e+00f, -5.39614081e-01f, -4.22264278e-01f, -1.39498413e-01f, -5.85838675e-01f, 2.12705463e-01f, -1.09522857e-01f, -5.13684690e-01f, 4.33418274e-01f,
  8.27868104e-01f, -2.84277648e-01f, -9.15869117e-01f, 2.49487996e-01f, -5.09929121e-01f, -3.29848565e-02f, 1.03820610e+00f, 1.56970215e+00f, -2.82147110e-01f, -3.42017651e-01f,
  -5.17609060e-01f, -4.06955361e-01f, 1.00409949e+00f, 1.23922729e+00f, 1.26074409e+00f, 1.08133626e+00f, -4.89361763e-01f, 5.03887773e-01f, 1.04405098e-01f, 2.00377181e-01f,
  1.81545407e-01f, -5.25943458e-01f, -4.31937426e-01f, -4.12407070e-01f, -7.31728196e-01f, -4.75051761e-01f, -6.24576449e-01f, -3.05554420e-01f, -6.18658721e-01f, 3.98552716e-01f,
  5.68190403e-02f, -5.32600582e-01f, 9.93329763e-01f, 8.19854081e-01f, 3.62907648e-01f, -2.00947419e-01f, 5.70644200e-01f, -2.78066188e-01f, -3.25203627e-01f, -6.28643274e-01f,
  1.19465500e-01f, 9.69896078e-01f, 1.89612228e-02f, 4.06181127e-01f, 3.17891687e-01f, -5.24149239e-01f, -1.32561818e-01f, 5.39409323e-03f, -9.48432207e-01f, -9.10327792e-01f,
  -3.88840139e-01f, -2.62261391e-01f, 9.36322033e-01f, -3.80645484e-01f, 2.02049147e-02f, -7.61239469e-01f, -7.16774583e-01f, 3.65397453e-01f, 3.60960513e-01f, 2.24433318e-01f,
  3.09825391e-01f, 5.07014012e-03f, 4.91903424e-01f, -1.42576784e-01f, 3.76252443e-01f, -9.00639594e-01f, -1.85930267e-01f, 9.88470018e-01f, 1.21579230e-01f, -2.99882233e-01f,
  -1.59583732e-01f, 4.99730617e-01f, 7.34695375e-01f, -6.12588525e-01f, 1.01485276e+00f, -3.07386488e-01f, -7.45799780e-01f, 1.90930843e-01f, 3.68034810e-01f, 1.50379345e-01f,
  -9.51841116e-01f, 8.14838469e-01f, 5.30677795e-01f, 8.31053019e-01f, -8.83877575e-01f, -7.05163851e-02f, 7.36705422e-01f, -7.39070475e-02f, -6.01497293e-01f, 4.04322296e-02f,
  7.44243503e-01f, -3.65220666e-01f, -8.21325630e-02f, -9.12667930e-01f, -4.36339766e-01f, -1.36264682e-01f, 1.16712093e+00f, 4.75486398e-01f, 3.01745236e-01f, 3.32609117e-01f,
  -5.18817663e-01f, 1.14561629e+00f, -3.19980472e-01f, -2.16303632e-01f, 4.54364777e-01f, 1.08287103e-01f, 3.81231636e-01f, -3.95206690e-01f, -1.01785280e-01f, 3.63629401e-01f,
  2.33054563e-01f, -5.40644936e-02f, 4.58304554e-01f, 7.80718863e-01f, -4.52160746e-01f, -6.53403580e-01f, -6.91343129e-01f, -2.36220896e-01f, -2.08348438e-01f, -2.06326768e-01f,
  1.44509828e+00f, -9.03195620e-01f, 1.02381669e-01f, 2.52970397e-01f, -6.44024014e-01f, 4.18383330e-01f, -1.14503745e-02f, -3.78756702e-01f, -1.12968600e+00f, -7.36368537e-01f,
  5.47241509e-01f, 7.66363978e-01f, 1.15050487e-01f, 1.31800818e+00f, -5.82840383e-01f, -5.19670472e-02f, -4.51784998e-01f, -2.37538606e-01f, -3.56962234e-01f, -8.83877948e-02f,
  2.00281292e-01f, -5.90465009e-01f, -4.44297165e-01f, 9.16731954e-02f, -2.74776101e-01f, -7.84497559e-01f, -5.46415746e-01f, -7.03194976e-01f, -2.72281617e-01f, -3.48053694e-01f,
  -1.56222403e-01f, -6.25010550e-01f, 9.52891886e-01f, 7.28877366e-01f, -2.45102391e-01f, -4.39616382e-01f, 3.66446793e-01f, 7.69537985e-02f, -2.69492328e-01f, -1.70614526e-01f,
  2.88991600e-01f, 6.26755774e-01f, 5.25012553e-01f, -1.14622772e+00f, -5.55448890e-01f, 1.80571541e-01f, 4.77450281e-01f, -2.30945200e-01f, -4.48816806e-01f, -2.53187064e-02f,
  -2.59940535e-01f, 1.15715420e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.70900917e-01f, 1.40394226e-01f, 6.42999351e-01f, -4.50052738e-01f, -1.33779064e-01f, 2.79453218e-01f, -8.32048878e-02f, -2.96860039e-01f, -1.61236316e-01f, -1.58993274e-01f,
  -1.26791643e-02f, 8.85271430e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    