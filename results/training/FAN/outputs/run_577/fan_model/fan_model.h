/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.19528731e-02f, -6.84868619e-02f, 3.23252916e-01f, -1.08543731e-01f, 4.15934809e-02f, 3.70593220e-02f, -1.30561322e-01f, 8.29451904e-03f, -1.42444804e-01f, -1.64564282e-01f,
  4.47768092e-01f, 3.16433161e-01f, 2.96012491e-01f, 1.55614451e-01f, 8.43232423e-02f, -2.30579078e-01f, -2.74302930e-01f, -5.62439151e-02f, 1.70433223e-01f, -1.09018765e-01f,
  -2.80142009e-01f, -1.31722376e-01f, 3.95522900e-02f, -6.93648830e-02f, -4.96435761e-01f, -1.94232702e-01f, -3.41705605e-02f, -1.05746733e-02f, -7.55714625e-02f, -6.82474136e-01f,
  1.32346705e-01f, 1.26522854e-01f, 2.55760029e-02f, 4.09088470e-02f, 7.30931684e-02f, -1.17773890e-01f, -5.25593646e-02f, 7.44481236e-02f, 1.34361824e-02f, -1.05273575e-01f,
  1.54293282e-02f, 2.19197683e-02f, -1.51782539e-02f, -1.58387683e-02f, 1.03864577e-02f, -7.23649412e-02f, -8.41188896e-03f, 1.02333091e-01f, 8.23237747e-02f, -2.72067264e-02f,
  -2.88215242e-02f, 6.21001199e-02f, 1.75201222e-01f, 2.21898928e-02f, 1.08214833e-01f, 6.41106218e-02f, 7.83113390e-02f, -5.22992015e-02f, 1.22196421e-01f, -3.70197386e-01f,
  5.57032861e-02f, 1.90454125e-02f, -2.21708212e-02f, -1.58547182e-02f, -4.82825609e-03f, 1.42904371e-01f, -2.79297605e-02f, 7.59394281e-03f, -7.72724897e-02f, 1.08832563e-03f,
  9.35231298e-02f, -9.80004203e-03f, 6.88418001e-02f, -9.80523676e-02f, -4.55243066e-02f, 1.25931893e-02f, -1.37504473e-01f, 5.99287357e-03f, 1.17048390e-01f, -5.15669025e-03f,
  1.14819452e-01f, 1.42171746e-02f, 1.06480733e-01f, -6.92583472e-02f, 8.72848630e-02f, 2.77873669e-02f, -2.50763074e-03f, -4.24288819e-03f, 9.73298177e-02f, 6.96724802e-02f,
  1.94652025e-02f, 2.57806718e-01f, -2.62535095e-01f, 7.83646926e-02f, -7.76050463e-02f, 6.70621693e-02f, -9.77048557e-03f, 2.14773882e-02f, 6.10240595e-03f, 2.79915519e-02f,
  8.01531896e-02f, -9.89379957e-02f, 1.44643728e-02f, -4.45823446e-02f, -5.72856665e-02f, 2.52415370e-02f, 3.64056714e-02f, -7.81937316e-02f, -9.33137815e-03f, -4.97202501e-02f,
  2.45346650e-02f, -5.06876372e-02f, -6.00303821e-02f, -6.90864772e-02f, -3.48983929e-02f, -1.79198906e-02f, -1.00015767e-01f, -1.30181104e-01f, -4.43130210e-02f, -4.08393770e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.61129463e+00f, 3.84519666e-01f, 4.15600419e-01f, -7.86634326e-01f, 5.00853062e-01f, 7.37551987e-01f, 1.01096487e+00f, 6.53144643e-02f, -5.47162116e-01f, -1.28394380e-01f,
  3.01549328e-03f, -5.13036132e-01f, -3.12563509e-01f, -5.58727868e-02f, 3.07490706e-01f, 7.51803637e-01f, 6.69484377e-01f, 1.09573223e-01f, -4.42825556e-02f, 3.65538895e-02f,
  3.63679677e-01f, -2.58849442e-01f, -5.02404630e-01f, -1.60368845e-01f, -1.63762897e-01f, -8.74762535e-02f, -5.60266105e-03f, -1.42164156e-01f, 3.88868302e-01f, -1.13812663e-01f,
  -5.44589341e-01f, -3.26038003e-01f, 2.65959769e-01f, -1.48100093e-01f, -5.31814285e-02f, -4.49319124e-01f, -8.13960209e-02f, -3.17562550e-01f, 6.08082488e-02f, -1.20475963e-01f,
  -2.56418139e-01f, -1.15567222e-01f, -1.51104793e-01f, -6.51767990e-03f, -2.72804826e-01f, -3.81143726e-02f, -9.26238447e-02f, -1.95968330e-01f, -2.52696067e-01f, -5.71050420e-02f,
  4.69916224e-01f, 2.38441750e-01f, 9.00927782e-02f, 3.42519909e-01f, 7.71160126e-02f, 1.15257002e-01f, 1.62343711e-01f, -2.45421663e-01f, 9.22159851e-02f, -7.00603247e-01f,
  8.65089148e-02f, -8.14211182e-03f, 2.40597837e-02f, -2.07560956e-02f, 9.19419229e-02f, 8.92533585e-02f, -9.66988355e-02f, 1.53925389e-01f, 1.85734674e-01f, -6.25521839e-02f,
  5.22758439e-02f, 1.89450942e-02f, 9.19539109e-02f, -2.69140929e-01f, -1.25970483e-01f, -1.14082347e-03f, 1.74307093e-01f, -3.68429497e-02f, -2.53356702e-04f, -7.28165135e-02f,
  -1.10474251e-01f, 1.12859733e-01f, -1.79261640e-01f, 8.90941396e-02f, 1.56033054e-01f, -1.54761076e-02f, 8.12828820e-03f, -1.43754706e-01f, -1.44761786e-01f, 2.02635616e-01f,
  -8.15479219e-01f, 9.74377096e-01f, -6.71155930e-01f, 7.39846099e-03f, -1.88848332e-01f, -1.73925124e-02f, -1.06192015e-01f, -3.25107947e-02f, -1.11238554e-01f, -2.20846802e-01f,
  1.47859752e-01f, -1.17850073e-01f, -1.51852310e-01f, 1.29505351e-01f, 3.43921292e-03f, -1.87140137e-01f, 1.87562019e-01f, -3.38385925e-02f, 2.40885749e-01f, -1.71369299e-01f,
  2.45699733e-01f, 5.52971736e-02f, -3.81763428e-01f, -1.28905445e-01f, -7.01775104e-02f, -3.14815752e-02f, -4.64849696e-02f, -9.14650634e-02f, 5.50141558e-02f, -3.42063636e-01f,
  -3.01086307e-01f, -4.24690038e-01f, -1.00365806e+00f, -1.19752014e+00f, -8.34397972e-01f, -3.13678116e-01f, -1.83831349e-01f, 2.60650064e-03f, -5.16110063e-01f, -6.34652853e-01f,
  1.38978705e-01f, 8.78308296e-01f, 3.93650770e-01f, 5.68920493e-01f, 9.65139031e-01f, -6.39765739e-01f, -9.40475464e-01f, 1.25025019e-01f, 8.39072347e-01f, 6.71123445e-01f,
  4.88546282e-01f, -2.77902961e-01f, -2.67852191e-02f, 6.93638846e-02f, -4.95958775e-01f, 9.37977806e-02f, -8.78184557e-01f, -5.85652411e-01f, 2.53578778e-02f, -1.06845343e+00f,
  4.61947560e-01f, -3.59219968e-01f, 2.47652289e-02f, 9.72160622e-02f, -3.54313642e-01f, 1.16073221e-01f, 5.29605225e-02f, -2.90238470e-01f, -7.99396560e-02f, -1.85086146e-01f,
  -2.45306611e-01f, 3.99213172e-02f, -7.05775023e-02f, 6.19450994e-02f, -2.43031397e-01f, 4.63823369e-03f, -2.17260927e-01f, -1.96745947e-01f, -2.17653230e-01f, -6.52175164e-03f,
  5.26076779e-02f, -6.94545507e-02f, -1.51799589e-01f, 6.07183110e-03f, 1.26082480e-01f, -7.83498213e-02f, -2.81320773e-02f, 6.05277605e-02f, -1.13478214e-01f, -5.12940407e-01f,
  -2.84437746e-01f, -9.46106091e-02f, -8.99304077e-02f, -2.75911819e-02f, 2.83454936e-02f, 9.05623436e-02f, -1.65407255e-01f, 2.36760527e-02f, -9.88735184e-02f, 2.89109759e-02f,
  1.08403735e-01f, -1.17780939e-01f, 6.80343434e-02f, -7.69750029e-02f, -1.44296914e-01f, -7.88883120e-02f, 1.29895657e-01f, 2.55391240e-01f, -2.79136188e-03f, -2.78816164e-01f,
  3.34928092e-03f, -1.12017579e-01f, -1.94907218e-01f, 3.67147438e-02f, 9.32431594e-02f, 8.01398009e-02f, 6.35050684e-02f, 2.28721753e-01f, 1.92452833e-01f, -1.12525448e-01f,
  4.16723609e-01f, 6.86754063e-02f, -5.48393372e-03f, 8.06023628e-02f, -3.27705652e-01f, -6.95696324e-02f, -1.66830778e-01f, -3.56971920e-02f, -2.53599063e-02f, 1.42950848e-01f,
  1.20422520e-01f, 1.59843206e-01f, -1.71934113e-01f, -3.38015966e-02f, -2.30502442e-01f, -6.53166920e-02f, 7.87007734e-02f, 1.13748245e-01f, 7.32058138e-02f, -7.34937489e-02f,
  -2.82374948e-01f, 6.22620583e-02f, 3.32975328e-01f, 2.28968441e-01f, 2.57461518e-03f, 2.59064823e-01f, 1.25664607e-01f, 2.03755111e-01f, 3.05122614e-01f, 1.47400666e-02f,
  4.06633794e-01f, -5.11923909e-01f, 7.90135741e-01f, 3.38105232e-01f, -3.15999448e-01f, -9.65160012e-01f, -1.51664793e+00f, -6.55457199e-01f, -4.87554669e-02f, -6.02110207e-01f,
  -2.91644573e-01f, 1.39643669e-01f, 1.74714565e-01f, 7.12998435e-02f, -3.46066147e-01f, -7.97763884e-01f, -4.66073900e-02f, 4.98618841e-01f, 2.79398233e-01f, -2.69723564e-01f,
  -4.72250462e-01f, 3.28680426e-01f, 7.36442327e-01f, 4.15652275e-01f, 2.98410177e-01f, -2.16204822e-02f, 4.70786721e-01f, 5.77676952e-01f, -1.92433715e-01f, 2.05328181e-01f,
  3.07907730e-01f, 4.40512538e-01f, -2.77373314e-01f, 1.82363033e-01f, 3.25856209e-01f, -2.14392632e-01f, -2.56600022e-01f, 5.37527502e-01f, -4.14533280e-02f, -2.09369976e-02f,
  9.51374695e-02f, 1.07043892e-01f, 1.56362038e-02f, -2.41271377e-01f, -1.30413368e-01f, -2.27380469e-01f, 2.94862121e-01f, 3.38391095e-01f, 2.46573433e-01f, 4.07311805e-02f,
  -3.84682804e-01f, 2.42904365e-01f, 1.59724966e-01f, -2.76691943e-01f, -4.59752493e-02f, 9.73848775e-02f, 9.82538611e-02f, 1.18843541e-01f, -1.44677728e-01f, 7.49668777e-02f,
  -1.59345288e-02f, 1.58571571e-01f, -1.36398107e-01f, 5.25496043e-02f, -2.79770702e-01f, 1.56102721e-02f, 1.12830125e-01f, -4.88466993e-02f, 1.01047056e-02f, -8.73279795e-02f,
  -3.69140208e-02f, -1.11316048e-01f, 2.07417920e-01f, 3.11478004e-02f, 5.29106781e-02f, 1.63633376e-01f, -3.16040739e-02f, 1.11553930e-01f, 3.27330858e-01f, 1.84445046e-02f,
  -2.26183012e-02f, -1.27621055e-01f, 7.44472295e-02f, -9.24383923e-02f, -7.66268149e-02f, 1.17784470e-01f, -1.31574214e-01f, 1.66413952e-02f, 9.78529453e-02f, -1.33346338e-02f,
  -2.03429252e-01f, -1.11571983e-01f, -3.09700996e-01f, 7.49083906e-02f, -6.35920987e-02f, 1.14769392e-01f, -5.19535430e-02f, 7.22035207e-03f, 2.36054137e-01f, 1.68729778e-02f,
  -1.81964168e-03f, -1.83609933e-01f, 1.40067451e-02f, -1.41301244e-01f, -2.87655354e-01f, -2.27132782e-01f, -3.88739288e-01f, -3.02926838e-01f, -2.57943958e-01f, -2.04786494e-01f,
  -3.24623793e-01f, -4.62792903e-01f, -5.77720165e-01f, -5.50392628e-01f, -2.18230888e-01f, -5.19306302e-01f, -3.50503355e-01f, -4.93602812e-01f, -9.24870968e-01f, -1.21453619e+00f,
  5.87630868e-01f, 6.04524255e-01f, -1.23658109e+00f, 1.72394946e-01f, -8.89440715e-01f, -7.51218498e-01f, 1.46393299e-01f, 2.55255967e-01f, 1.24683701e-01f, 5.88580251e-01f,
  2.53079295e-01f, -1.18011922e-01f, 5.83611652e-02f, -2.95668095e-01f, 1.16638325e-01f, 9.83903483e-02f, -3.97412598e-01f, -8.69795978e-01f, -1.05246663e+00f, -7.29052603e-01f,
  -2.65112638e-01f, -1.44125566e-01f, 4.41747205e-03f, -1.12975493e-01f, -4.22670245e-02f, -4.45656478e-01f, 4.30091694e-02f, -2.53986448e-01f, -4.52700794e-01f, -3.40376645e-01f,
  -2.99878329e-01f, -1.65798470e-01f, -3.35495055e-01f, -8.31752736e-03f, 5.65167814e-02f, -5.60392141e-02f, -9.24218446e-02f, -1.01139061e-02f, 7.76538849e-02f, 3.44652496e-02f,
  -1.65302038e-01f, -2.08870515e-01f, -1.28898785e-01f, -2.78494060e-01f, -3.05933863e-01f, -1.78068295e-01f, 1.02124870e-01f, -1.78970069e-01f, -2.48648673e-01f, -2.76266903e-01f,
  -1.48357138e-01f, -7.36599267e-01f, -3.10056239e-01f, 4.96920273e-02f, -2.64822662e-01f, -5.53862274e-01f, -2.27222592e-01f, -3.20704371e-01f, -3.89179766e-01f, 5.71574271e-01f,
  3.00403386e-01f, 2.70180821e-01f, 1.52573779e-01f, 2.13770002e-01f, 3.47901732e-01f, -1.46224245e-01f, 7.37533122e-02f, 8.80309120e-02f, 8.11863784e-03f, 1.98404163e-01f,
  -1.43646613e-01f, 1.71069324e-01f, 5.49145527e-02f, 2.04970956e-01f, -6.84617832e-02f, -6.53734058e-02f, 8.09016302e-02f, 2.63061196e-01f, 6.37653545e-02f, 6.43721148e-02f,
  -1.50573075e-01f, -1.58152759e-01f, -2.78332114e-01f, 1.03662685e-01f, -2.34414339e-01f, 6.21904358e-02f, -5.29677421e-02f, 1.07399179e-02f, 6.94715558e-03f, -1.91290036e-01f,
  5.47481120e-01f, 4.22684997e-02f, 4.11268294e-01f, -8.00105184e-03f, -7.74282888e-02f, -2.22383708e-01f, 2.97792047e-01f, 1.44061878e-01f, -6.02916069e-02f, 1.03484064e-01f,
  -1.13308027e-01f, 9.28598791e-02f, -1.19361512e-01f, -9.68479142e-02f, -1.24872670e-01f, -1.98373303e-01f, 3.32126677e-01f, -1.52368888e-01f, -1.76537484e-01f, -1.56192053e-02f,
  1.40319586e-01f, 1.91904187e-01f, 4.95866656e-01f, 2.29899094e-01f, 8.25783461e-02f, -1.45345405e-02f, 1.52283609e-01f, 1.55092672e-01f, 3.49808112e-02f, 1.06035590e+00f,
  5.56846261e-01f, -3.93708766e-01f, 7.65456557e-02f, 4.03820693e-01f, 2.42295414e-01f, 1.82814330e-01f, -3.92443910e-02f, -7.38530159e-02f, 1.97340604e-02f, 9.04226899e-02f,
  1.54258907e-02f, 2.38232717e-01f, 2.89029598e-01f, 1.30152982e-02f, 1.07187964e-01f, 5.86959533e-02f, 4.36085500e-02f, 1.02588966e-01f, 2.21725002e-01f, -6.63806945e-02f,
  -9.77557376e-02f, -1.11783281e-01f, -5.12812994e-02f, -1.40116617e-01f, -1.66501731e-01f, 2.38757461e-01f, -1.93681419e-01f, -1.90133110e-01f, -2.85866946e-01f, -1.93916261e-01f,
  7.95510318e-03f, -4.87716556e-01f, 1.27275139e-01f, -1.43514216e-01f, -1.40612870e-01f, 8.41745213e-02f, 1.67970404e-01f, -1.22041836e-01f, -9.10198595e-03f, -2.79781017e-02f,
  -1.65340126e-01f, -1.12543032e-01f, -5.37938699e-02f, -1.64302006e-01f, -5.62231801e-02f, -4.29671891e-02f, -2.05465421e-01f, -1.61548987e-01f, -9.20490995e-02f, -9.66412649e-02f,
  -2.56949276e-01f, -1.39212310e-01f, 1.18619204e-01f, 1.06831968e-01f, 1.44364592e-02f, 1.23963483e-01f, -2.21167877e-01f, -1.55640677e-01f, -1.10396184e-01f, 3.40521261e-02f,
  5.27373254e-02f, 1.42285466e-01f, -9.20589492e-02f, -2.61263438e-02f, 1.41315803e-01f, 1.09009363e-01f, 4.47930992e-02f, 1.48516875e-02f, -9.11051407e-02f, -2.75696442e-02f,
  -9.24728252e-03f, 6.11906834e-02f, -1.15155049e-01f, 1.73706084e-01f, 1.08601600e-01f, -3.58483195e-02f, 3.45891081e-02f, -1.15749910e-01f, 2.73822807e-02f, 1.21476278e-01f,
  5.89504763e-02f, -7.81894475e-02f, -1.66352674e-01f, -1.38566956e-01f, -1.61241263e-01f, -4.76643331e-02f, 1.08249910e-01f, -1.04507180e-02f, 1.72549143e-01f, 3.56220342e-02f,
  2.87096143e-01f, 3.36466357e-02f, 2.38890111e-01f, -1.06418602e-01f, -1.34061605e-01f, -1.81566656e-01f, -4.19588685e-02f, -1.80819973e-01f, -1.91717133e-01f, 3.40723209e-02f,
  -1.39124885e-01f, -2.78779231e-02f, 3.10562719e-02f, -3.39657953e-03f, 2.14230329e-01f, 4.45495769e-02f, -1.65280715e-01f, 2.08584927e-02f, -1.00196943e-01f, -2.02046648e-01f,
  -7.63262734e-02f, 2.06444889e-01f, 4.36769277e-01f, 2.84225017e-01f, 1.43307552e-01f, 3.82056952e-01f, 3.00382197e-01f, 5.89085557e-02f, 1.49265006e-01f, 4.84764427e-01f,
  2.44953483e-02f, 2.35063925e-01f, -6.81894898e-01f, 7.22628772e-01f, 2.45808624e-02f, -9.31789577e-01f, -9.30380285e-01f, -5.38876772e-01f, 4.46904123e-01f, 1.12370521e-01f,
  -1.40139446e-01f, 1.44154027e-01f, 2.73728967e-01f, 6.27041142e-03f, -6.49273217e-01f, -9.23098400e-02f, 5.13629258e-01f, -1.79408789e-01f, -6.87005281e-01f, -4.88895953e-01f,
  4.61390793e-01f, 4.88600582e-01f, 2.91646183e-01f, -9.33624059e-02f, 5.98503113e-01f, 4.30596322e-01f, 4.27482605e-01f, 3.57423604e-01f, -1.18609659e-01f, 7.16381788e-01f,
  -1.66303158e-01f, -4.65397298e-01f, -1.83168039e-01f, 3.05369824e-01f, 3.63328755e-02f, -1.70470551e-01f, -2.86254495e-01f, 1.26363453e-03f, -2.42653191e-01f, -1.17604874e-01f,
  9.06239823e-02f, -2.79599220e-01f, -6.65360764e-02f, 5.95259517e-02f, -1.12493239e-01f, -3.86324167e-01f, 1.02574006e-01f, -4.50811267e-01f, -2.44155407e-01f, -4.57257450e-01f,
  2.64283150e-01f, -2.26892203e-01f, -7.40205586e-01f, -3.49861234e-01f, -5.59209824e-01f, -4.39311750e-02f, -5.14635444e-01f, -2.73942530e-01f, -6.75744832e-01f, -2.87326947e-02f,
  -3.18096280e-01f, -1.85616732e-01f, -1.39087111e-01f, 1.54685363e-01f, 1.11031853e-01f, 2.06584726e-02f, 7.20002949e-02f, 1.09971330e-01f, 8.50647092e-02f, 1.22834772e-01f,
  -1.48625046e-01f, -6.28449693e-02f, -1.22592501e-01f, -3.35156471e-01f, -3.67903113e-02f, -1.41880125e-01f, -2.42632300e-01f, 1.85884118e-01f, -4.26153429e-02f, -1.26724213e-01f,
  -1.06219463e-01f, -1.05314620e-01f, 1.31968126e-01f, -5.68504445e-02f, 1.79005370e-01f, 9.01898220e-02f, 6.80157095e-02f, -7.96877518e-02f, 1.36428148e-01f, 5.49968742e-02f,
  6.51338816e-01f, -4.57654685e-01f, 2.77506262e-01f, -2.46928170e-01f, -1.91927841e-03f, 1.92644801e-02f, 1.48136169e-01f, -1.66267350e-01f, 7.49400863e-03f, -2.00636923e-01f,
  -2.43019268e-01f, -2.97464907e-01f, 6.99586049e-02f, 1.36374205e-01f, -2.55988151e-01f, 1.66532934e-01f, 2.31373742e-01f, 5.78505592e-03f, -1.22771204e-01f, 2.05577895e-01f,
  4.84327078e-01f, -1.31573483e-01f, -1.30121708e-01f, -2.01320518e-02f, 4.83135991e-02f, 7.74450973e-02f, -2.11029336e-01f, -4.63909619e-02f, -6.39665782e-01f, 1.22166157e-01f,
  5.71669638e-01f, -7.23920584e-01f, -1.19649899e+00f, -2.19990134e-01f, -2.19272897e-01f, -2.90393591e-01f, -6.84115469e-01f, -3.11445862e-01f, 2.23253101e-01f, -5.56392372e-01f,
  -5.34697846e-02f, 5.01833797e-01f, -4.99257952e-01f, -3.84402305e-01f, -7.77226746e-01f, -1.38198662e+00f, -1.22767365e+00f, -8.02717507e-01f, -7.66590163e-02f, 4.52054679e-01f,
  4.55297172e-01f, 1.86927333e-01f, 1.56427905e-01f, -6.10123985e-02f, -3.37878615e-01f, -5.34973852e-02f, -8.09785128e-01f, -3.99867117e-01f, -4.31206852e-01f, -7.61088490e-01f,
  -8.07649612e-01f, -2.54143834e-01f, 2.91877806e-01f, 2.69955963e-01f, -8.19974989e-02f, 2.40007132e-01f, -2.09083557e-02f, -1.59002662e-01f, 3.69489670e-01f, -3.29063058e-01f,
  1.38603553e-01f, 1.53224722e-01f, 5.44119067e-02f, 1.22850582e-01f, 3.96723524e-02f, -1.42920747e-01f, -1.83344826e-01f, -3.03604871e-01f, -5.68676770e-01f, -1.09020628e-01f,
  3.48750018e-02f, -1.10579841e-01f, -7.76328623e-01f, -4.19279248e-01f, -5.48481405e-01f, 3.99755780e-03f, -3.75498325e-01f, -1.52550787e-01f, -5.77780426e-01f, -8.47003937e-01f,
  2.00563297e-01f, -1.05138265e-01f, 6.74035400e-02f, 8.87809843e-02f, 1.45172223e-01f, 4.38891910e-02f, -1.90180525e-01f, -2.84385413e-01f, -4.09016572e-03f, -9.47058871e-02f,
  -6.80158883e-02f, -4.67305519e-02f, 7.84687400e-02f, -2.45258808e-01f, -1.82986274e-01f, 3.41873281e-02f, 1.59120504e-02f, -1.45260841e-01f, -2.43573889e-01f, -1.34708500e-02f,
  -8.49311613e-03f, 4.35925461e-02f, -1.78480953e-01f, 8.28569084e-02f, -1.76900163e-01f, -3.62254918e-01f, 1.63402095e-01f, 1.28249541e-01f, -6.26835898e-02f, 1.42292455e-01f,
  -3.56668741e-01f, -2.00737789e-01f, -8.16091597e-02f, 6.73368871e-02f, -1.90696537e-01f, -9.43163410e-02f, -7.13599771e-02f, -5.89782000e-03f, 1.00673921e-01f, 4.66868691e-02f,
  -1.11746006e-01f, -3.33683789e-02f, -3.12444210e-01f, 1.81809992e-01f, 4.26867977e-02f, -1.26379952e-02f, -7.89518654e-02f, -1.66371688e-01f, -1.57620877e-01f, 1.05690658e-01f,
  -2.44256437e-01f, -3.49560350e-01f, -2.62092829e-01f, -3.73042196e-01f, -3.47968675e-02f, -3.09524629e-02f, -4.70778137e-01f, -2.53169388e-01f, -3.37135106e-01f, -6.45067573e-01f,
  -8.50161090e-02f, -1.00220092e-01f, 1.44678935e-01f, 3.17769498e-01f, -3.35738599e-01f, -3.73565912e-01f, -4.43761766e-01f, -1.70658633e-01f, 1.75410748e-01f, -3.08116227e-02f,
  -1.81830317e-01f, 1.55635789e-01f, 1.71187758e-01f, 3.27978820e-01f, 3.12024713e-01f, 3.53675663e-01f, 5.30414641e-01f, 6.15413487e-01f, 3.04942876e-01f, 1.72148183e-01f,
  2.47075483e-01f, 1.87803805e-01f, 2.47219071e-01f, 3.09678674e-01f, 2.89091706e-01f, 3.59639108e-01f, 9.87327844e-02f, 2.17581719e-01f, 1.84872270e-01f, 7.86350429e-01f,
  5.28081954e-01f, -3.91752332e-01f, -3.94211803e-03f, 1.58967879e-02f, -1.26894206e-01f, -4.84512672e-02f, -7.73770288e-02f, -5.80016263e-02f, -2.93638617e-01f, -5.77480756e-02f,
  -8.98279548e-02f, -9.12779793e-02f, -6.31927373e-03f, -2.27947906e-01f, -1.75328359e-01f, -2.28203401e-01f, 1.06464803e-01f, 2.55004734e-01f, 2.51431942e-01f, -6.21341169e-02f,
  3.42406556e-02f, -1.12743683e-01f, -2.37650335e-01f, -1.30596414e-01f, 1.34982392e-01f, 9.19727683e-02f, -1.47965625e-01f, -4.03551944e-02f, -1.51065499e-01f, 1.22392010e-02f,
  3.75331879e-01f, 9.15201083e-02f, 1.31919086e-01f, 1.38235455e-02f, 1.82829604e-01f, 9.72528681e-02f, 1.41750416e-02f, 1.09151648e-02f, 1.99616238e-01f, 1.19426258e-01f,
  1.07204519e-01f, 1.93794042e-01f, -6.65880833e-03f, -8.66279826e-02f, 5.03797010e-02f, 4.39336635e-02f, -1.23348325e-01f, -1.49911135e-01f, -1.38048768e-01f, -1.44643709e-01f,
  4.98107038e-02f, 5.62802851e-02f, -3.03751320e-01f, 1.31965235e-01f, -1.70330852e-01f, 5.55935986e-02f, 5.60359797e-04f, -1.63407743e-01f, -1.53538302e-01f, -5.74601553e-02f,
  -1.48000777e-01f, -2.18319893e-01f, 2.81748086e-01f, 1.57167375e-01f, 8.44699144e-02f, -4.93283719e-02f, 8.95257294e-02f, -8.34274963e-02f, -1.40284196e-01f, -4.13347408e-03f,
  -2.11191505e-01f, -1.25954058e-02f, -1.96090378e-02f, 3.88470665e-02f, -1.17356636e-01f, -2.64763445e-01f, -6.87531531e-02f, 4.56185117e-02f, 7.93464761e-03f, -1.08186372e-01f,
  -7.70806372e-02f, -1.93308085e-01f, -2.20006347e-01f, -9.56975222e-02f, 1.30138844e-01f, -9.16149691e-02f, -1.56633049e-01f, -6.57473430e-02f, -1.45882338e-01f, -1.80547893e-01f,
  -1.72553909e+00f, 1.38893232e-01f, 2.87457347e-01f, -1.00110376e+00f, -3.38370472e-01f, 3.07554025e-02f, -1.21603832e-02f, 8.97386894e-02f, -2.23826751e-01f, 2.33852729e-01f,
  2.38515019e-01f, -2.27660209e-01f, 9.73880589e-02f, 4.28388221e-03f, -3.05578232e-01f, 1.71179458e-01f, -3.76014084e-01f, -7.85550296e-01f, -6.28786862e-01f, -4.22401652e-02f,
  -2.76285797e-01f, -7.64736950e-01f, -8.81098628e-01f, -3.37346852e-01f, 1.92202926e-01f, -3.00422367e-02f, 3.22041184e-01f, -3.87889862e-01f, -1.53693527e-01f, -2.98585922e-01f,
  6.72499776e-01f, -6.23080552e-01f, 3.34824234e-01f, -6.82908952e-01f, 3.85697603e-01f, -1.39103472e-01f, 1.63949914e-02f, 5.20960949e-02f, -5.95842749e-02f, 2.78342497e-02f,
  -5.19930184e-01f, -5.23814037e-02f, -3.58915001e-01f, 5.57562374e-02f, 1.15961887e-01f, -8.72859824e-03f, -8.57658386e-02f, -1.72465160e-01f, 8.98019299e-02f, 5.02203465e-01f,
  -1.00276046e-01f, -6.59129381e-01f, -2.79928982e-01f, 2.48442486e-01f, 4.24308062e-01f, -3.98109794e-01f, 5.06421626e-01f, 1.34347230e-01f, 1.67781129e-01f, 1.18152805e-01f,
  2.48811767e-02f, 1.98016346e-01f, 4.59354259e-02f, -1.55788302e-01f, -1.84103549e-02f, -1.36013210e-01f, -9.22558010e-02f, -9.64939892e-02f, 1.10643551e-01f, 1.26764506e-01f,
  9.85677093e-02f, 4.38854806e-02f, 1.35446146e-01f, -3.93403657e-02f, 2.90003549e-02f, -2.57234514e-01f, -9.41135138e-02f, 3.73578697e-01f, 3.14212106e-02f, -2.37152070e-01f,
  -1.18310206e-01f, -5.88185787e-02f, -1.73549671e-02f, 2.03875691e-01f, -2.47585997e-02f, 7.61992764e-03f, 6.55765682e-02f, -1.57893419e-01f, -7.07667843e-02f, -1.69255942e-01f,
  3.58311564e-01f, -4.07181263e-01f, 7.38158496e-03f, -2.47785076e-01f, -1.72809124e-01f, 1.80167884e-01f, -1.33135840e-01f, -1.31059662e-01f, -1.41262382e-01f, -1.32507056e-01f,
  -8.16099346e-02f, 3.88251245e-02f, 1.13564216e-01f, 3.08581322e-01f, 1.84849903e-01f, 1.12195559e-01f, -2.43403718e-01f, -2.73600072e-01f, -9.09637287e-02f, 1.15005501e-01f,
  -5.45044476e-03f, -4.09649163e-01f, -5.93821466e-01f, -2.98692589e-03f, 1.93678468e-01f, -4.47568864e-01f, 1.70687318e-01f, 1.09699443e-01f, -2.59490669e-01f, 5.00139520e-02f,
  4.56814915e-01f, -5.58692515e-01f, 8.41014981e-01f, 4.00129668e-02f, 5.80658495e-01f, 6.06755912e-01f, 2.40323201e-01f, -9.31643993e-02f, -1.59679532e-01f, -6.18856959e-02f,
  1.50912430e-03f, -9.15621296e-02f, -1.64328933e-01f, -2.55417347e-01f, -1.22618936e-01f, 4.23879689e-03f, -1.84611380e-02f, 2.51660168e-01f, 6.66712880e-01f, 4.35858667e-01f,
  -1.96953952e-01f, 7.05275834e-02f, 2.65985467e-02f, -1.20612718e-01f, -7.91789815e-02f, 1.52867794e-01f, 1.86108723e-02f, 5.44580258e-02f, -1.36862909e-02f, -3.81635696e-01f,
  6.19263887e-01f, -2.88770169e-01f, -3.60006727e-02f, -2.95006365e-01f, 1.12098664e-01f, -2.12075502e-01f, -3.70072275e-02f, -9.38988030e-02f, -2.41672397e-01f, -9.26777497e-02f,
  1.97764430e-02f, -1.46070167e-01f, 2.13853028e-02f, -1.97640479e-01f, 8.18526894e-02f, 7.54019096e-02f, -2.98879772e-01f, -3.14457357e-01f, -2.69901484e-01f, -5.76478615e-02f,
  -3.65124464e-01f, 1.17891856e-01f, 3.48138958e-01f, 2.34639328e-02f, -1.42137527e-01f, 1.45139443e-02f, 8.84350110e-03f, -7.81215280e-02f, 6.98425323e-02f, -1.26255259e-01f,
  -6.72451109e-02f, 1.86913773e-01f, -4.53263074e-02f, 1.66630838e-02f, -2.24388614e-02f, -1.33376643e-01f, 6.71503395e-02f, 1.31827638e-01f, 5.62922955e-02f, 1.24689341e-01f,
  -4.19979021e-02f, -3.80811915e-02f, 3.08963034e-04f, -5.41411899e-02f, -1.00759402e-01f, -2.41610408e-03f, 4.81668860e-02f, -1.06833912e-01f, 7.47935548e-02f, 6.00062013e-02f,
  8.73216093e-02f, -3.99441160e-02f, -8.95042792e-02f, -1.35074511e-01f, -2.22114816e-01f, -1.58895366e-02f, -1.02815390e-01f, -8.05604160e-02f, -1.10121397e-02f, -1.13526262e-01f,
  -4.94413637e-02f, -1.87319562e-01f, 1.30004697e-02f, -1.78590432e-01f, -3.53611000e-02f, -2.74486274e-01f, -1.07310377e-01f, -1.50245935e-01f, -1.08418100e-01f, -9.80257019e-02f,
  6.11771690e-03f, -1.00496061e-01f, -1.18523918e-01f, -1.03407428e-01f, 1.73989192e-01f, 2.36021485e-02f, -7.36783817e-02f, 1.08171530e-01f, -2.00943232e-01f, -6.47127181e-02f,
  -2.49667093e-01f, 1.55589640e-01f, 3.88375789e-01f, 1.61502481e-01f, -1.57847837e-01f, 2.67862469e-01f, 2.38975793e-01f, 2.12411791e-01f, 2.70557433e-01f, 1.50926277e-01f,
  1.48031783e+00f, 1.30086690e-01f, 5.64224720e-01f, -5.84637262e-02f, -7.65140176e-01f, -7.60394111e-02f, 4.91854459e-01f, 5.50302625e-01f, -1.39359711e-02f, -7.29007274e-02f,
  -9.41170871e-01f, -9.26893830e-01f, -5.46361446e-01f, -4.56230968e-01f, 2.01093420e-01f, 3.45288664e-01f, 3.90610993e-01f, 6.67806208e-01f, 3.77350837e-01f, -1.45673305e-01f,
  -3.95316511e-01f, 3.61121595e-01f, 7.38226056e-01f, 1.89523876e-01f, -1.27781153e-01f, -3.25300872e-01f, 2.22999558e-01f, -4.10165414e-02f, -2.94535130e-01f, 1.79410391e-02f,
  -4.07009721e-01f, 3.81704479e-01f, -1.34823546e-01f, -2.60023355e-01f, -2.65325576e-01f, 2.78155535e-01f, 5.52411526e-02f, 1.23506188e-01f, 5.09255845e-03f, 3.88616696e-02f,
  -4.01337892e-01f, -1.16803005e-01f, -3.13033760e-01f, -3.10066380e-02f, 3.33108380e-02f, -3.49288099e-02f, 2.18354270e-01f, 2.72263169e-01f, 1.24386977e-03f, -9.91363674e-02f,
  -6.59171402e-01f, -2.88633108e-01f, 5.42498641e-02f, -3.22321728e-02f, 1.04083456e-02f, -1.46042898e-01f, 4.72281640e-03f, -1.05865784e-01f, 8.13170709e-03f, 1.91640392e-01f,
  -7.71747008e-02f, -5.55053465e-02f, -7.43905976e-02f, 1.80619694e-02f, 1.37681384e-02f, -1.12865277e-01f, -1.73693657e-01f, -1.25613421e-01f, -1.83420312e-02f, 6.25849366e-02f,
  -8.81578773e-02f, -7.07974732e-02f, -1.62987150e-02f, -5.69275357e-02f, -2.55607039e-01f, -1.09307952e-02f, 2.66431225e-03f, 5.38830459e-02f, -4.08184230e-02f, 1.21177815e-01f,
  -1.75378069e-01f, 4.72048894e-02f, 2.11341400e-02f, 1.34118134e-02f, 6.30068630e-02f, -2.58152504e-02f, -1.85357444e-02f, -2.12086558e-01f, 1.23044200e-01f, 2.57984456e-02f,
  -2.07221303e-02f, -1.95952237e-01f, -5.85131012e-02f, 1.25728205e-01f, -3.60474102e-02f, -1.02492616e-01f, -1.77116007e-01f, -1.29519925e-01f, -1.48814291e-01f, 1.30734727e-01f,
  -3.51256803e-02f, -6.95682094e-02f, -1.15092203e-01f, 7.12580979e-02f, -1.59458034e-02f, -3.27497050e-02f, -3.39180231e-01f, -1.97019637e-01f, -5.34315445e-02f, -2.32660454e-02f,
  -9.82592329e-02f, 2.10124448e-01f, 6.98718503e-02f, -1.69856101e-02f, -2.48044252e-01f, -8.47691223e-02f, -1.71873979e-02f, 1.04824472e-02f, 2.00440630e-01f, 4.96225685e-01f,
  2.39937734e-02f, 7.40246594e-01f, 1.00787902e+00f, -1.67558402e-01f, 1.09257791e-02f, -2.80932784e-01f, -2.63883919e-01f, -6.58608019e-01f, -2.64398396e-01f, 5.05778074e-01f,
  6.60762787e-01f, -3.42921495e-01f, -1.30123362e-01f, -3.65048766e-01f, -7.18109727e-01f, 1.80982158e-01f, 1.22471035e-01f, -5.30133426e-01f, -1.16273224e+00f, -9.24034178e-01f,
  -7.95046031e-01f, -7.09402323e-01f, -5.35538077e-01f, -4.24103141e-01f, 4.28994268e-01f, -2.33641356e-01f, 6.25968933e-01f, 2.56367415e-01f, 4.26503927e-01f, 7.18890190e-01f,
  8.09812129e-01f, 8.92974019e-01f, -6.14769280e-01f, -7.23300129e-02f, 2.91623086e-01f, 9.54277348e-03f, -9.17663574e-02f, -2.17478275e-01f, 3.81794311e-02f, 4.49606888e-02f,
  2.22444050e-02f, 1.56350419e-01f, -3.52351852e-02f, -1.61640302e-04f, -2.12373644e-01f, -2.34485403e-01f, -3.56356651e-02f, -2.65538394e-01f, -8.89147669e-02f, 2.62988061e-01f,
  -9.76544991e-02f, 2.33363509e-01f, 3.31500083e-01f, -6.42758906e-02f, -1.86405972e-01f, -2.45883167e-01f, 2.87691802e-01f, 1.08857326e-01f, 2.68752664e-01f, 4.44935352e-01f,
  -1.37449592e-01f, 8.06752145e-02f, 1.81057960e-01f, 2.08185852e-01f, -1.97768360e-01f, 3.23355384e-02f, 6.68627024e-02f, -3.57680731e-02f, -2.85705537e-01f, -1.61881128e-03f,
  -1.93831977e-02f, 1.39773518e-01f, -1.05989009e-01f, 1.10002823e-01f, 1.16277166e-01f, 1.05731830e-01f, 1.40152378e-02f, 4.79678847e-02f, 8.58653039e-02f, -1.08657731e-02f,
  -1.67856112e-01f, -9.52562764e-02f, 3.06144170e-02f, -1.25484675e-01f, 3.45046163e-01f, 1.57901779e-01f, 7.38879815e-02f, -5.21963201e-02f, -1.42494664e-01f, 1.88898370e-01f,
  -6.57171130e-01f, -4.47363630e-02f, 3.93129617e-01f, -9.87741426e-02f, 4.07104008e-03f, 1.96359366e-01f, 2.67502576e-01f, 6.71219826e-02f, 2.21479341e-01f, -7.88340066e-03f,
  2.70843282e-02f, -1.20513260e-01f, 1.96864441e-01f, -1.19180642e-01f, -4.07699466e-01f, -7.98001438e-02f, -4.53736037e-02f, -4.47627418e-02f, -1.74785480e-01f, 8.18223655e-02f,
  -1.36940315e-01f, -4.61114585e-01f, -6.55738354e-01f, -4.14993972e-01f, -1.09759241e-01f, -4.49922651e-01f, -1.68841511e-01f, -2.57449120e-01f, -2.71492392e-01f, -4.98226821e-01f,
  1.02333736e+00f, 8.57029200e-01f, 2.28681743e-01f, 6.17526472e-01f, 4.59853888e-01f, 3.59736115e-01f, 5.03006160e-01f, 1.79439768e-01f, 3.41447326e-03f, 2.85055995e-01f,
  4.90506619e-01f, 2.51556247e-01f, -1.59741081e-02f, -3.64063657e-03f, -8.66704360e-02f, -7.43078738e-02f, -6.12798408e-02f, -3.01452011e-01f, -2.41023943e-01f, 1.14013039e-01f,
  3.69087130e-01f, 2.76007950e-01f, 1.25458196e-01f, -2.03485154e-02f, 3.70710254e-01f, -7.37184612e-03f, 1.78462192e-01f, 4.86552864e-01f, 4.85919744e-01f, 2.31351599e-01f,
  -8.76446217e-02f, 5.89248598e-01f, -5.55626869e-01f, -1.38625801e-01f, 6.83024824e-02f, -3.98213625e-01f, -1.66248232e-01f, -2.93762803e-01f, -2.94200424e-02f, -1.93727121e-01f,
  2.71665156e-02f, -2.94654798e-02f, 1.29292473e-01f, -1.56731457e-02f, 7.65860975e-02f, -1.05705217e-01f, -1.15869090e-01f, -1.63953766e-01f, -1.35258600e-01f, -1.18426844e-01f,
  2.20206216e-01f, 3.84682089e-01f, 1.02895506e-01f, 9.74999554e-03f, 8.03165138e-02f, -1.03818789e-01f, 1.27970308e-01f, 9.22316238e-02f, -5.99941909e-02f, 2.77935360e-02f,
  -2.55664121e-02f, 2.53549755e-01f, 1.43859133e-01f, -7.68892840e-02f, -5.08561954e-02f, -1.15108304e-01f, -1.01822205e-01f, 8.76227170e-02f, 1.01841494e-01f, -4.64863516e-02f,
  -9.86256078e-02f, -1.11862138e-01f, -1.05284020e-01f, 1.66353136e-02f, 4.70814928e-02f, 1.57839850e-01f, -4.28338721e-02f, 1.49724633e-01f, 1.42580390e-01f, -2.47861743e-01f,
  3.45903337e-02f, -2.39632592e-01f, -1.32024899e-01f, -8.08973536e-02f, -1.51652902e-01f, -6.92015067e-02f, -1.02117419e-01f, 1.00411125e-01f, 1.31644890e-01f, 5.68109937e-02f,
  -5.06484747e-01f, 3.70806865e-02f, -2.10471809e-01f, -5.71949668e-02f, 1.19332545e-01f, -5.53921051e-02f, 2.50633687e-01f, -6.60402104e-02f, 5.41403666e-02f, -1.03985794e-01f,
  2.59006005e-02f, -1.01008035e-01f, 1.17721260e-01f, -2.24194452e-01f, -2.23108962e-01f, -1.04684822e-01f, -1.57603566e-02f, -1.20874807e-01f, -2.22408310e-01f, -1.80796921e-01f,
  -1.89081073e-01f, -2.44973928e-01f, -2.06558540e-01f, -2.09604010e-01f, -7.24709854e-02f, -3.42328817e-01f, -2.49902472e-01f, -3.23368698e-01f, -2.29228705e-01f, -4.12778676e-01f,
  1.25701594e+00f, -8.17664981e-01f, 1.48785815e-01f, 4.64097783e-02f, -3.63655299e-01f, -1.79102436e-01f, -4.77661759e-01f, -7.40318298e-02f, 6.37129247e-02f, -2.51691908e-01f,
  -3.92898768e-02f, 3.76856863e-01f, 3.62986863e-01f, 2.56521642e-01f, 3.46920848e-01f, -4.07206327e-01f, -2.47878358e-01f, 5.44831097e-01f, 6.87369406e-01f, 7.96028227e-02f,
  -2.33066946e-01f, -1.19666971e-01f, 3.46131146e-01f, 9.92915556e-02f, -3.88973683e-01f, 1.04288712e-01f, -1.58465773e-01f, -1.23353213e-01f, -2.02533334e-01f, -4.71482009e-01f,
  -1.77641004e-01f, 1.11265533e-01f, 2.49214426e-01f, 2.39742957e-02f, -6.41380763e-03f, 3.86595428e-02f, 5.18737175e-02f, -7.24172667e-02f, -1.41949847e-01f, -1.50038987e-01f,
  -1.67670548e-02f, 7.15744495e-03f, 3.30072679e-02f, -1.35529682e-01f, -5.09946793e-02f, -2.48047337e-03f, 7.45509937e-02f, 6.50853813e-02f, -1.16856480e-02f, -6.15399033e-02f,
  -2.63622999e-01f, -1.41333148e-01f, -1.21188976e-01f, 1.22084767e-01f, 1.90911576e-01f, 2.08769858e-01f, 2.60251779e-02f, 1.79379091e-01f, 2.52951384e-01f, -1.06238887e-01f,
  1.00876495e-01f, 4.89396192e-02f, 2.00182855e-01f, 1.33062854e-01f, 1.39797796e-02f, -2.60786042e-02f, -6.67994618e-02f, -1.92904063e-02f, 2.18600392e-01f, 3.68325645e-03f,
  -1.44484445e-01f, 6.82745948e-02f, 1.06824320e-02f, 5.12598082e-03f, 3.16846110e-02f, -5.46940155e-02f, -6.35617971e-02f, -8.68020132e-02f, 1.39719367e-01f, -1.36137351e-01f,
  1.13367230e-01f, -6.78993622e-03f, -1.93341430e-02f, 3.57047133e-02f, -5.12886904e-02f, -1.97775941e-02f, -2.31636036e-02f, 6.42219931e-02f, -1.46078199e-01f, -1.84005827e-01f,
  -4.69417632e-01f, 5.26823878e-01f, 7.95403903e-04f, 1.46341667e-01f, -3.40114385e-02f, -2.14543995e-02f, 1.52752578e-01f, -9.45120454e-02f, -2.09032148e-01f, -1.54872432e-01f,
  -1.90673862e-02f, 8.06968436e-02f, -1.24253158e-03f, 3.26282494e-02f, 1.23064004e-01f, 1.36318266e-01f, -3.91511880e-02f, 5.18269762e-02f, -3.19405319e-03f, -2.14150310e-01f,
  -1.94941789e-01f, -7.84871355e-02f, 5.31516373e-02f, -2.56068408e-02f, 4.57734279e-02f, 1.93109632e-01f, -9.14634094e-02f, 2.40778569e-02f, 1.22170143e-01f, -2.63441056e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.55562973e+00f, 5.02973139e-01f, 7.39593148e-01f, 7.91895390e-01f, 1.10254490e+00f, 1.27062619e+00f, 8.42641294e-01f, 6.70558214e-01f, 8.53296816e-01f, 1.12138927e+00f,
  1.58947194e+00f, 7.62379706e-01f, 7.72470593e-01f, 5.41789412e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -2.97956228e-01f, -3.64264436e-02f, -5.20462573e-01f, 5.07992744e-01f, -3.82643975e-02f, -2.40997836e-01f, -1.61523998e+00f, -6.95558846e-01f, 8.16509366e-01f, -5.23230314e-01f,
  2.42303908e-02f, -9.90689695e-02f, -1.06016791e+00f, -1.30429602e+00f, -3.96712720e-01f, 7.11665571e-01f, -2.59230614e-01f, 3.97163600e-01f, -1.22845542e+00f, 1.19467950e+00f,
  -8.16278040e-01f, 2.67228056e-02f, 3.86284977e-01f, -7.07998991e-01f, 4.35728729e-01f, 1.84590802e-01f, -1.99782741e+00f, 1.49807066e-01f, -2.43550524e-01f, -3.92816007e-01f,
  4.94779706e-01f, 1.03647029e+00f, -9.84249823e-03f, 2.40624875e-01f, 6.34501755e-01f, -5.96746445e-01f, 1.27154088e+00f, -1.10489464e+00f, -6.99006081e-01f, 1.78057581e-01f,
  -2.56475627e-01f, -1.21411934e-01f, -7.91607797e-02f, -8.21973234e-02f, 2.59119958e-01f, -1.11239707e+00f, -1.59756052e+00f, 7.83972323e-01f, -1.28567323e-01f, -1.03983223e-01f,
  1.60669053e+00f, 2.07701311e-01f, -8.84820580e-01f, -4.50830191e-01f, -6.67669833e-01f, -1.84361804e+00f, -1.24951400e-01f, -1.12456417e+00f, 6.46216094e-01f, -6.84271038e-01f,
  -8.00525606e-01f, 5.23645222e-01f, -1.12650442e+00f, -1.53377688e+00f, -2.73866028e-01f, 4.48326856e-01f, -1.15205562e+00f, -8.58060896e-01f, 3.89655203e-01f, 4.24983166e-02f,
  -3.47770900e-01f, 6.06123433e-02f, -4.17445041e-02f, -7.52215564e-01f, 5.43467700e-01f, -4.62388992e-01f, -6.63938761e-01f, 8.27535748e-01f, -3.55841845e-01f, -7.23626256e-01f,
  4.62471932e-01f, -5.57508051e-01f, -8.58006895e-01f, -4.66280937e-01f, -1.36643088e+00f, 1.25855303e+00f, 3.59825283e-01f, 9.29392993e-01f, 9.15925857e-03f, -4.28236872e-01f,
  -4.36316907e-01f, -7.10090339e-01f, 5.97878218e-01f, -1.27930605e+00f, 2.19363376e-01f, -1.45611870e+00f, 2.24989783e-02f, -5.46718359e-01f, -1.56727624e+00f, -9.03430998e-01f,
  4.69967604e-01f, -4.97827649e-01f, -1.11037672e+00f, -2.11094230e-01f, -1.60550916e+00f, 4.90223020e-01f, -8.14904749e-01f, -9.43886399e-01f, 1.21755862e+00f, 3.68104577e-01f,
  -7.01488853e-02f, 1.44247577e-01f, -3.04340452e-01f, -1.69960111e-01f, 1.27722275e+00f, -1.24924004e+00f, -1.29396343e+00f, -6.62636697e-01f, 2.86209226e-01f, 5.67486644e-01f,
  -6.67644620e-01f, 5.02244413e-01f, -2.71212339e-01f, -1.05407262e+00f, -8.10056746e-01f, -3.55927736e-01f, -2.04601157e-02f, -1.09879911e+00f, -1.23857476e-01f, -5.60563684e-01f,
  4.80457157e-01f, -1.02076614e+00f, -7.24829972e-01f, -8.24254572e-01f, 4.24811155e-01f, -2.97877491e-01f, -6.85286224e-01f, -3.71444345e-01f, -6.93157315e-01f, 1.34483385e+00f,
  8.12105417e-01f, -1.33618343e+00f, -9.30247128e-01f, -1.76011130e-01f, 4.27157968e-01f, -5.86051822e-01f, -7.09529877e-01f, -1.21382546e+00f, 5.13498306e-01f, -8.51141036e-01f,
  -7.13328719e-01f, 8.94857883e-01f, 3.88862491e-01f, 5.11879362e-02f, -1.34253776e+00f, 1.79015040e-01f, -2.00122619e+00f, 9.20568407e-01f, 1.00502811e-01f, -6.41719043e-01f,
  7.76202753e-02f, -3.06426823e-01f, -3.44894826e-01f, 1.01209736e+00f, -5.79794526e-01f, 3.40639442e-01f, -1.47999197e-01f, -2.13108808e-01f, -1.52677500e+00f, -1.61595210e-01f,
  8.12537611e-01f, 8.89139235e-01f, -9.64341581e-01f, -3.13677669e-01f, -6.20819330e-01f, -1.35556006e+00f, 4.06928122e-01f, 7.68704176e-01f, 4.64693636e-01f, -7.98755810e-02f,
  -2.74744064e-01f, -2.14585230e-01f, -1.42153311e+00f, -1.30584061e+00f, -4.47799504e-01f, -9.83203709e-01f, -5.51547468e-01f, 4.95300710e-01f, 5.03688097e-01f, 5.12323022e-01f,
  9.52530801e-01f, -6.30223155e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.69701830e-01f, -1.26570570e+00f, -2.28407368e-01f, -7.15435565e-01f, 9.04693007e-01f, 5.61104596e-01f, 1.29402310e-01f, 4.61548418e-01f, -3.18814188e-01f, 1.60492778e-01f,
  -1.24333775e+00f, 8.66772681e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    