/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.58368814e-01f, -1.21775828e-01f, -2.93736130e-01f, -1.53001308e-01f, 3.30211848e-01f, 3.27416182e-01f, 6.03296496e-02f, 1.87925085e-01f, 2.97486663e-01f, 2.45297626e-02f,
  1.26667559e-01f, -2.08429307e-01f, 9.24024917e-03f, 2.68753339e-02f, 8.24718252e-02f, 1.89189762e-01f, 3.22441049e-02f, 2.04121694e-02f, 1.92155644e-01f, -3.33968177e-02f,
  1.64640490e-02f, 1.92469984e-01f, -5.57493232e-02f, 1.14825256e-01f, -8.88715461e-02f, -1.65840626e-01f, -1.46362260e-01f, 2.65742037e-02f, -1.40769914e-01f, 8.26999247e-02f,
  -2.75154747e-02f, 5.17281741e-02f, -7.02243224e-02f, 2.83834096e-02f, -1.20866969e-01f, -8.83080810e-02f, -2.25111190e-02f, -2.19587144e-02f, 5.12162037e-02f, 3.84218767e-02f,
  -5.45288995e-03f, 1.54482294e-02f, 3.27687860e-02f, 1.23303741e-01f, 5.82584105e-02f, -8.48936439e-02f, -1.79917421e-02f, -2.53077559e-02f, -1.33985309e-02f, 2.64697447e-02f,
  -3.55161540e-02f, -4.39424589e-02f, 8.93065357e-04f, 1.67846903e-02f, -4.99993041e-02f, 4.33385223e-02f, 4.29861434e-03f, -1.02846824e-01f, -4.50958591e-03f, 3.50921713e-02f,
  -2.25857813e-02f, 9.57721621e-02f, -1.83677468e-02f, 3.40703838e-02f, -6.96366951e-02f, -1.24150105e-02f, 2.23190393e-02f, -4.75696381e-03f, -4.12917025e-02f, 5.28293103e-03f,
  -5.50911762e-03f, 3.84582095e-02f, 5.49272485e-02f, 3.09584904e-02f, 5.31169586e-02f, 5.27976230e-02f, 3.52869183e-02f, -1.51834637e-03f, 4.58803661e-02f, -9.32828803e-03f,
  6.80110678e-02f, -5.32969786e-03f, -2.99063921e-02f, -6.11398034e-02f, 8.72337595e-02f, -6.10071458e-02f, 2.78237965e-02f, -2.47795694e-02f, -2.47876719e-02f, 1.71455387e-02f,
  3.89071144e-02f, -4.74765450e-02f, 5.30227972e-03f, -1.81374345e-02f, 4.93486375e-02f, 1.67695656e-02f, 3.59782539e-02f, 3.79157700e-02f, -8.30955431e-03f, -6.15020003e-03f,
  5.70030287e-02f, -1.75653417e-02f, -4.55706604e-02f, -2.13318393e-02f, -2.61897035e-02f, 3.31509821e-02f, -1.05501032e-02f, 4.04910650e-03f, 3.78429331e-02f, -4.36927304e-02f,
  -8.69346634e-02f, -5.58602111e-03f, -2.40099449e-02f, -4.64327484e-02f, 1.58439260e-02f, -8.53805766e-02f, -1.96465617e-03f, 1.83274248e-03f, 1.06742885e-02f, -6.80449838e-03f,
  -4.77616161e-01f, 1.08230330e-01f, -2.57237881e-01f, -2.47182935e-01f, -5.98125271e-02f, -2.36132324e-01f, -1.01702332e-01f, -6.84681907e-02f, -2.33920321e-01f, -1.06528111e-01f,
  3.41847166e-02f, -9.91139263e-02f, 4.60451320e-02f, -8.52308497e-02f, 4.30379238e-04f, 1.13545060e-01f, -1.21257044e-01f, -7.47287497e-02f, 6.88527524e-02f, -5.63687421e-02f,
  7.49948155e-03f, 2.64050849e-02f, -1.08361423e-01f, 1.07774816e-01f, -1.38994187e-01f, 7.81869702e-03f, 1.66362859e-02f, 1.03217244e-01f, -2.80335266e-02f, 6.64629191e-02f,
  -1.01946354e-01f, -1.07875317e-01f, -2.37208437e-02f, -9.95293483e-02f, 3.86595749e-03f, 1.25290081e-02f, -4.28222902e-02f, 6.97007477e-02f, -5.92933558e-02f, 5.28353266e-02f,
  -5.33217192e-03f, -6.95999339e-02f, -3.77241038e-02f, 1.83493402e-02f, -4.13086303e-02f, 1.49509786e-02f, 3.36543145e-03f, -6.99953139e-02f, -5.22172377e-02f, 2.71279598e-03f,
  2.07991023e-02f, 8.97696766e-04f, -5.55448011e-02f, -3.02422494e-02f, -4.51792404e-02f, -2.99309511e-02f, -6.93800822e-02f, 3.14818472e-02f, 3.94053347e-02f, -1.27108157e-01f,
  1.17187612e-01f, -1.25820175e-01f, 2.21306458e-02f, -1.82520859e-02f, -2.78491266e-02f, -1.71854366e-02f, -1.49584077e-02f, 2.88747554e-03f, -6.39706030e-02f, -5.17106242e-02f,
  -4.78833281e-02f, -4.95548360e-02f, 3.53516005e-02f, -8.19428563e-02f, -1.12370774e-02f, -6.18864149e-02f, -7.84613378e-03f, -2.11227071e-02f, -1.98493171e-02f, -4.77038398e-02f,
  4.31014970e-02f, -4.04146425e-02f, -4.21905098e-03f, -1.99138355e-02f, 2.22776774e-02f, -3.12191006e-02f, -8.71480815e-03f, -4.34972066e-03f, 7.66065577e-03f, -2.74557108e-03f,
  -1.64926142e-01f, -7.40028545e-02f, 1.61885805e-02f, 1.37900067e-02f, 1.96423233e-02f, 7.02349003e-03f, -4.06645983e-02f, -4.41025058e-03f, 5.06230332e-02f, -2.36126613e-02f,
  -1.00611607e-02f, -4.68983538e-02f, 4.42373706e-03f, -2.97970995e-02f, 8.02335143e-02f, -7.79849887e-02f, -3.56156267e-02f, -2.82107163e-02f, 8.01941752e-02f, 8.43029190e-03f,
  -9.08864103e-03f, 6.64983839e-02f, 1.78034585e-02f, -2.79344283e-02f, 2.62938794e-02f, 2.87662148e-02f, 4.00202647e-02f, 2.44270843e-02f, 5.69285266e-02f, 8.22695903e-03f,
  5.55590391e-01f, -7.64634386e-02f, -6.01202026e-02f, 2.67937928e-01f, 2.72975147e-01f, 1.86580807e-01f, 4.10964563e-02f, 9.11429971e-02f, 1.55810565e-01f, -1.97035581e-01f,
  1.41834915e-01f, -1.04343340e-01f, -2.63703793e-01f, 1.72879454e-02f, 3.59209359e-01f, -9.81802642e-02f, 1.14827350e-01f, -3.20743173e-02f, 6.17794506e-02f, 3.72395925e-02f,
  1.23901002e-01f, 8.23702663e-02f, -7.13478923e-02f, -3.30245309e-02f, 3.96538004e-02f, -9.05529968e-03f, 3.76138911e-02f, -6.14421032e-02f, 5.20534702e-02f, 3.52127850e-02f,
  4.68401611e-02f, -4.59262133e-02f, -5.81462048e-02f, -1.38807654e-01f, 1.00586422e-01f, 1.54248076e-02f, -3.32496874e-02f, -1.89423002e-02f, 1.70724411e-02f, 1.17183607e-02f,
  1.20539879e-02f, -1.98081974e-02f, -2.75279507e-02f, -8.01612157e-03f, 4.35912199e-02f, 1.37936203e-02f, -2.39817053e-02f, 5.02541773e-02f, -7.78168514e-02f, -4.42769788e-02f,
  -3.99536081e-02f, 1.27510251e-02f, 4.43857238e-02f, -2.92493068e-02f, 1.68295801e-02f, 3.12564448e-02f, 7.46504311e-03f, -5.79579137e-02f, 3.64715084e-02f, 7.05616251e-02f,
  2.77650151e-02f, -6.43672422e-02f, -2.84167584e-02f, -4.66340184e-02f, 2.83152852e-02f, -6.25577522e-03f, -2.68814135e-02f, -4.59070578e-02f, -2.73130089e-02f, 1.24733839e-02f,
  4.76847365e-02f, -1.28585901e-02f, -6.14030287e-03f, -4.96548787e-02f, -9.80642159e-03f, -7.39428168e-03f, 1.34673249e-02f, -3.88532728e-02f, 6.82674209e-03f, 5.52834710e-03f,
  -3.81093659e-02f, -5.31651601e-02f, -4.84258588e-03f, 5.26876887e-03f, -6.16373494e-03f, 9.23283957e-03f, -2.67909337e-02f, -3.87308490e-03f, 4.89732474e-02f, 6.19497448e-02f,
  3.68860215e-02f, -7.98432436e-03f, -2.38053757e-03f, 1.66892894e-02f, -6.01662546e-02f, -1.61218252e-02f, -2.89536361e-03f, 2.59159617e-02f, 1.82094891e-02f, 3.09596155e-02f,
  -3.40202288e-03f, -7.35256355e-03f, -1.78020410e-02f, -6.49352884e-03f, -3.10243312e-02f, 1.39618956e-03f, -4.01179073e-03f, 1.59710809e-03f, 7.13664591e-02f, 2.06722878e-02f,
  -3.23165655e-02f, 2.79983599e-03f, -3.35818790e-02f, -5.85791562e-03f, 3.86700332e-02f, -2.01872829e-02f, 4.57014255e-02f, 4.79378691e-03f, -4.19842191e-02f, -4.71019484e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.09442809e-01f, -7.15367496e-02f, -2.84660518e-01f, -1.59162074e-01f, 7.80656934e-02f, -4.44960624e-01f, -2.41363242e-01f, -3.44955064e-02f, 2.30239242e-01f, 2.11344525e-01f,
  1.60399839e-01f, -2.76019797e-02f, 2.83778518e-01f, -2.02269375e-01f, -2.32169956e-01f, -1.30216917e-02f, -4.64774013e-01f, -1.92671508e-01f, -8.51149391e-03f, -1.48989499e-01f,
  -1.23869166e-01f, -2.87172329e-02f, -1.10487521e-01f, 6.98446259e-02f, -1.79279372e-01f, 1.00823149e-01f, 1.78933084e-01f, 7.37317428e-02f, -1.86944872e-01f, -2.94649992e-02f,
  7.56221563e-02f, 1.83306783e-01f, -8.53293017e-02f, -8.62096399e-02f, -4.41937149e-02f, 5.45331370e-03f, -6.40057772e-02f, 6.37093633e-02f, 2.06766576e-02f, -1.59311603e-04f,
  -1.02881473e-02f, 9.21518877e-02f, -2.96668671e-02f, -3.24021727e-02f, -8.58031288e-02f, -2.09399369e-02f, -3.27778570e-02f, 8.73971656e-02f, 7.79555663e-02f, -2.23410219e-01f,
  -8.80162567e-02f, -6.77997768e-02f, -1.36830613e-01f, 7.20641911e-02f, -8.45912620e-02f, 7.97437131e-02f, -3.96000706e-02f, -2.73810029e-02f, -1.88773312e-02f, 2.27739122e-02f,
  -9.95801464e-02f, -1.15274437e-01f, -1.10652223e-01f, 6.38548508e-02f, 2.67307311e-02f, 7.54701123e-02f, -1.01874039e-01f, 2.29522269e-02f, -1.47346258e-01f, -2.33154576e-02f,
  4.72035967e-02f, 1.71719212e-02f, -4.75520231e-02f, -2.15539068e-01f, -9.24737006e-02f, 6.88231513e-02f, -3.15914117e-03f, 1.12236246e-01f, -1.51464492e-01f, -2.23043337e-02f,
  1.14066310e-01f, -2.26940755e-02f, 4.44138460e-02f, 8.78939629e-02f, 1.82156153e-02f, -1.42293740e-02f, -1.01766035e-01f, -5.59907965e-02f, 4.64247428e-02f, 2.70811450e-02f,
  3.58038954e-02f, 8.22820067e-02f, 8.85916501e-02f, 1.13110408e-01f, 5.40915728e-02f, -7.60229006e-02f, -3.22646201e-02f, -1.53908938e-01f, 2.70340368e-02f, -6.47861287e-02f,
  -1.24830112e-01f, -3.34679410e-02f, -1.24135502e-01f, -2.35275943e-02f, -1.55558567e-02f, -7.35018551e-02f, 1.00904156e-03f, 7.26082548e-02f, -1.21604919e-01f, -9.97958612e-03f,
  -4.31891531e-02f, -9.31091979e-03f, 3.21287885e-02f, 1.66840628e-02f, -8.18243548e-02f, -7.60523695e-03f, -6.44930974e-02f, -5.25267087e-02f, -8.89102668e-02f, 1.82109773e-02f,
  2.46256944e-02f, 7.68417776e-01f, 2.27780357e-01f, 5.94803751e-01f, -2.58749068e-01f, -6.80748820e-02f, 1.08783223e-01f, 1.78093746e-01f, 2.77359486e-01f, 3.24601471e-01f,
  9.41830799e-02f, 1.94865957e-01f, 1.30988911e-01f, 3.70887280e-01f, 4.08442803e-02f, 2.68039197e-01f, 3.84528011e-01f, 1.10377364e-01f, 4.64770533e-02f, 4.79368195e-02f,
  1.81253627e-01f, 1.35853663e-01f, 1.41888812e-01f, -4.54846658e-02f, 2.78881891e-03f, 1.43782705e-01f, 1.19786695e-01f, -1.49710536e-01f, 1.08596668e-01f, -8.16644449e-03f,
  -1.46616980e-01f, -1.59720629e-02f, -2.27552820e-02f, -6.57889247e-02f, -1.38706621e-02f, -8.99206176e-02f, -2.97962502e-02f, -4.02366556e-02f, -6.21330924e-02f, 2.88115889e-02f,
  -1.21151786e-02f, -9.08889696e-02f, 1.97775513e-02f, -8.39319639e-03f, -8.43345374e-02f, 1.87278427e-02f, -5.58560900e-02f, -6.54070973e-02f, 3.53097096e-02f, -7.62524828e-02f,
  2.12007295e-02f, -2.48829275e-02f, 4.03950363e-02f, 1.52880833e-01f, 5.49201779e-02f, 3.58373895e-02f, 6.47523180e-02f, -3.15949768e-02f, 5.16756028e-02f, 5.19557185e-02f,
  -6.38786424e-03f, -5.62775740e-03f, -3.67704779e-02f, -1.39768302e-01f, 6.24318570e-02f, -5.28402627e-02f, 5.55218086e-02f, -6.69381320e-02f, 5.93479909e-02f, 5.95712326e-02f,
  3.82984988e-02f, 6.33647144e-02f, -4.04191352e-02f, -6.74064904e-02f, 9.64976996e-02f, 1.40205631e-03f, 7.69295841e-02f, 8.45815092e-02f, 1.80200469e-02f, 3.51904519e-03f,
  3.60566042e-02f, 8.52336735e-02f, 2.02162769e-02f, -2.97248438e-02f, -1.42319780e-02f, -6.40094571e-04f, 8.23557936e-03f, 7.49645680e-02f, -1.64062884e-02f, 2.15014871e-02f,
  2.43432209e-01f, 5.95180154e-01f, 1.67206768e-02f, -6.45848587e-02f, 8.72968957e-02f, -3.54391299e-02f, 1.15523927e-01f, 2.60475148e-02f, 1.63018465e-01f, 5.31070046e-02f,
  -6.87542036e-02f, 7.88997710e-02f, -4.42026183e-03f, -2.95009948e-02f, 2.04156730e-02f, 1.00939624e-01f, -8.80366017e-04f, 1.41064584e-01f, 1.12016469e-01f, 5.80431856e-02f,
  -1.61842704e-01f, 4.29637963e-03f, -8.33934266e-03f, -8.59988555e-02f, 3.41423005e-02f, 3.71195152e-02f, 9.71482974e-03f, -7.65350759e-02f, -5.78173660e-02f, 1.25315070e-01f,
  -1.91377223e-01f, -2.69149303e-01f, -1.46504208e-01f, -1.58821866e-01f, -6.11801818e-02f, -2.23070532e-01f, -1.02610253e-01f, -1.74514234e-01f, -9.51152816e-02f, -6.91533089e-02f,
  -5.23413345e-03f, 2.02951595e-01f, -1.21990452e-02f, -7.49109164e-02f, 4.63999957e-01f, 2.84545362e-01f, -1.19871445e-01f, 1.22296713e-01f, 1.37301072e-01f, -1.87303871e-01f,
  1.15665913e-01f, -1.04412109e-01f, -5.98966330e-02f, -2.65140027e-01f, -2.74325937e-01f, -1.91980541e-01f, 1.40725672e-01f, -2.11367518e-01f, -4.21066489e-03f, 1.08763985e-02f,
  -2.04365090e-01f, -4.52893712e-02f, -1.81680486e-01f, -8.99604410e-02f, -2.99437996e-02f, -5.17660603e-02f, 1.89177647e-01f, 3.13162655e-02f, 4.59557623e-02f, -1.51239205e-02f,
  -1.83150601e-02f, -9.75966603e-02f, 3.14982980e-02f, -8.13741460e-02f, 2.39052009e-02f, 4.09657583e-02f, 5.52154034e-02f, -3.55112292e-02f, -1.43680826e-01f, 1.05399489e-01f,
  -3.65207791e-02f, 1.95280239e-02f, -1.08939216e-01f, 5.85830472e-02f, 4.21863571e-02f, -1.21452004e-01f, 1.41179906e-02f, -8.72097388e-02f, -2.34423317e-02f, -1.09961584e-01f,
  5.44699021e-02f, 2.00233497e-02f, 7.21988007e-02f, -2.01458149e-02f, -4.84916456e-02f, -3.33034061e-02f, -3.81519832e-02f, 2.89910156e-02f, -4.72331867e-02f, -1.38559472e-02f,
  -6.07311213e-03f, -3.84840369e-02f, 1.00908145e-01f, 1.39081538e-01f, -3.55021767e-02f, 2.81833690e-02f, 4.24155816e-02f, -4.98031862e-02f, 1.16499595e-01f, 3.91473696e-02f,
  9.25758332e-02f, 6.84506297e-02f, -5.43595329e-02f, -3.10194585e-02f, -1.57527968e-01f, 7.07906857e-02f, -5.45501113e-02f, -6.72034398e-02f, -3.11230421e-02f, -3.92480334e-03f,
  -3.37749541e-01f, -2.38582477e-01f, -2.31373794e-02f, -1.12382688e-01f, -2.74335444e-02f, -1.80035625e-02f, 1.30771056e-01f, -3.02878134e-02f, -4.45513949e-02f, 4.06291895e-02f,
  8.35609138e-02f, 1.04351128e-02f, 8.30437231e-04f, 7.71065522e-03f, -9.85147525e-03f, -1.76027436e-02f, 1.11720487e-02f, -8.60624835e-02f, -4.96225730e-02f, -7.13122413e-02f,
  -9.19914097e-02f, 7.22213537e-02f, 1.01717431e-02f, -9.77109447e-02f, 1.01002119e-01f, -8.59741122e-04f, 5.42317592e-02f, 4.57961857e-02f, 1.70529615e-02f, 6.94938526e-02f,
  -5.58029890e-01f, 2.25791946e-01f, -4.52462524e-01f, 1.32009760e-01f, -1.18893228e-01f, 4.16410267e-01f, 1.86744496e-01f, -3.70968990e-02f, -2.79208660e-01f, 4.38190788e-01f,
  3.45754623e-01f, -1.54851511e-01f, 2.20187962e-01f, 3.39728117e-01f, -3.03502847e-02f, 2.32542962e-01f, 1.81407854e-01f, 1.14182532e-01f, -1.58652589e-01f, -5.46121262e-02f,
  -9.76172835e-02f, 3.50708276e-01f, 1.37117237e-01f, 4.39499915e-02f, 1.09080337e-02f, -1.19149908e-01f, 3.66227180e-01f, -3.44896130e-02f, 1.71702176e-01f, 8.32390338e-02f,
  9.82607231e-02f, -1.53048798e-01f, -4.28550392e-02f, -1.12079151e-01f, -1.24285743e-01f, -3.85740101e-02f, 5.55373132e-02f, -5.13143726e-02f, -7.60954842e-02f, -6.82056919e-02f,
  2.60274317e-02f, -3.14667560e-02f, 3.37727321e-03f, -8.68391991e-02f, -1.16067238e-01f, 2.94405930e-02f, -4.87294458e-02f, -1.38423396e-02f, -2.15694420e-02f, -4.31537516e-02f,
  6.88666403e-02f, 1.27874585e-02f, 3.06320935e-02f, -5.53382002e-02f, -3.41726057e-02f, -2.57793516e-02f, 1.13106491e-02f, 4.30814251e-02f, 7.27231577e-02f, -7.87889734e-02f,
  -8.90624523e-02f, -4.52508740e-02f, 3.73831913e-02f, 4.34595533e-02f, -1.42440861e-02f, -1.27260268e-01f, 1.19577944e-01f, 4.26603332e-02f, -1.04069738e-02f, 3.18270326e-02f,
  4.53630509e-03f, -4.08463776e-02f, -7.39006773e-02f, 3.99942212e-02f, -1.06746659e-01f, 1.15062372e-04f, -2.28365767e-03f, 4.38431948e-02f, 2.46366337e-02f, 5.12827113e-02f,
  -1.11792721e-02f, -1.27327994e-01f, 5.03488109e-02f, 1.04858615e-01f, -1.45534053e-03f, 9.87954624e-03f, -7.49390619e-03f, -4.31081839e-02f, -6.19422309e-02f, 3.10265105e-02f,
  9.63020548e-02f, -6.23218492e-02f, 6.79603741e-02f, 3.53672653e-02f, 3.16971466e-02f, 8.76786634e-02f, -3.23575661e-02f, -1.10509090e-01f, -3.71392444e-02f, -2.00898647e-02f,
  3.61214858e-04f, 6.88475743e-02f, 1.78829394e-02f, -3.59426625e-02f, 2.58552562e-02f, 2.32116859e-02f, -1.75217888e-03f, -4.56781685e-02f, 7.89608341e-03f, -5.51844425e-02f,
  4.97197583e-02f, -4.63165268e-02f, -1.13034360e-01f, -8.53698608e-03f, -6.34342153e-03f, 9.33967531e-03f, -6.79586753e-02f, -4.01618984e-03f, 1.55210774e-02f, 1.15937376e-02f,
  3.76552910e-01f, 2.11071253e-01f, -3.27703357e-01f, -6.41555861e-02f, -2.63929516e-01f, 3.92072171e-01f, 2.90547490e-01f, -1.32866442e-01f, -1.24196514e-01f, 3.06693226e-01f,
  1.12745270e-01f, 4.74789366e-02f, 2.65446752e-01f, 1.55102089e-01f, 1.48985386e-01f, 2.95738697e-01f, 2.54713297e-01f, 2.55004764e-01f, -8.08772072e-02f, 1.84556186e-01f,
  -3.86155993e-02f, 3.24512959e-01f, -1.97936356e-01f, -1.39121979e-01f, -9.86634195e-02f, -2.76805937e-01f, -4.91433195e-04f, -2.56839365e-01f, 1.27956783e-02f, -3.65369744e-03f,
  1.07819788e-01f, 1.33693159e-01f, -1.51059583e-01f, -3.58218215e-02f, 1.55911133e-01f, 7.25609511e-02f, 3.85400243e-02f, -7.87924603e-03f, -6.03563786e-02f, 1.11081235e-01f,
  8.17163363e-02f, -5.25717530e-03f, 1.32115737e-01f, -6.26206584e-03f, -8.17296803e-02f, -1.30133793e-01f, -9.09739360e-03f, -1.09602302e-01f, -4.53802459e-05f, 3.40427905e-02f,
  -1.17361218e-01f, -5.47721889e-03f, -9.54305977e-02f, 2.84271743e-02f, -1.17389560e-01f, -6.79828925e-03f, -5.62279895e-02f, -3.79482992e-02f, 4.30428684e-02f, -2.75087375e-02f,
  7.26911649e-02f, 1.45484284e-02f, -6.66189287e-03f, -2.34275814e-02f, -1.81539059e-02f, 1.18086515e-02f, -8.69409442e-02f, -1.84943853e-03f, -1.19527318e-01f, -3.17835733e-02f,
  -4.71930355e-02f, -1.02862023e-01f, 2.98996791e-02f, -1.52362110e-02f, 1.57690197e-02f, 4.25048135e-02f, -4.55061495e-02f, -3.47420834e-02f, -3.13010952e-03f, -6.13863617e-02f,
  7.33975843e-02f, 5.60869873e-02f, -4.04479131e-02f, 1.52442651e-02f, -4.82185744e-04f, -7.62535408e-02f, 6.75902069e-02f, 1.25534984e-03f, -4.59955446e-02f, -7.27831721e-02f,
  1.46418914e-01f, 2.42862061e-01f, -3.86247382e-04f, 5.41303232e-02f, -4.53519374e-02f, -1.58409253e-02f, 5.66090606e-02f, -8.12255219e-03f, 2.03223918e-02f, 2.16281954e-02f,
  5.63426726e-02f, -8.96337628e-02f, -1.65724251e-02f, 1.79319538e-03f, -6.45122305e-03f, -1.58521142e-02f, 1.16770104e-01f, -1.39318947e-02f, -1.24844769e-02f, 5.38723497e-03f,
  2.66548824e-02f, 2.20480207e-02f, -3.50372531e-02f, -6.83789849e-02f, 4.98719551e-02f, 2.04295795e-02f, 4.74281982e-02f, -3.54990102e-02f, 5.53962104e-02f, 3.55047472e-02f,
  -2.32936040e-01f, -5.30166209e-01f, -7.53375888e-02f, -1.22402124e-01f, 1.64013073e-01f, 1.76345885e-01f, 3.66420895e-01f, -3.85909259e-01f, -5.04733741e-01f, -6.79856613e-02f,
  1.60588756e-01f, -1.38785496e-01f, 2.13112444e-01f, -3.39855611e-01f, 2.47471571e-01f, 1.64964283e-03f, -1.85081586e-01f, 1.93540052e-01f, -2.05503300e-01f, 1.54990599e-01f,
  7.04611763e-02f, -1.24435283e-01f, 2.03213975e-01f, -1.72192052e-01f, -1.61966700e-02f, -4.56509255e-02f, 3.33632350e-01f, 3.25342745e-01f, 3.48565541e-02f, 9.52526033e-02f,
  -6.69017583e-02f, -2.15131804e-01f, -9.38369855e-02f, -1.44874781e-01f, -1.14427553e-02f, 7.81178847e-02f, 1.66625351e-01f, 2.10233539e-01f, 1.25669781e-02f, 6.99397996e-02f,
  1.22200865e-02f, 5.46469614e-02f, -6.82836995e-02f, 9.32339951e-02f, -1.10565051e-01f, -1.01499692e-01f, -1.49691850e-01f, -1.10768430e-01f, -2.48679630e-02f, -3.41410972e-02f,
  -1.07707404e-01f, -1.24054052e-01f, -7.29099736e-02f, -2.92294864e-02f, 3.25457230e-02f, -1.00831136e-01f, 6.84892433e-03f, 1.16326213e-01f, -3.07478085e-02f, -5.83545631e-03f,
  1.63462516e-02f, -6.27383217e-02f, 2.05177553e-02f, -8.72289166e-02f, -2.27546208e-02f, -1.21163063e-01f, -4.27450947e-02f, 4.64849994e-02f, 4.18230938e-03f, -8.27028081e-02f,
  -3.62052247e-02f, -2.92422133e-03f, -3.19229178e-02f, -1.01323068e-01f, 6.35298714e-02f, -8.12099781e-03f, 4.34598885e-02f, 1.20057529e-02f, 3.55063326e-04f, -1.27170697e-01f,
  1.20401932e-02f, -2.79710982e-02f, 6.28271252e-02f, 7.48946816e-02f, -5.62841594e-02f, 1.90827046e-02f, -2.02005710e-02f, -3.33938263e-02f, 7.19228834e-02f, 1.17452249e-01f,
  8.77053440e-02f, 5.34817204e-02f, -5.02606109e-02f, -4.33766581e-02f, -2.04139925e-03f, -1.14828311e-01f, -1.46292999e-01f, -1.09337009e-01f, 1.04825184e-01f, -6.85215443e-02f,
  8.28327015e-02f, -3.92123647e-02f, -7.96331912e-02f, 2.21793484e-02f, 1.73260812e-02f, 4.13919194e-03f, 1.12513155e-01f, 6.28754050e-02f, 1.36258211e-02f, -1.27739822e-02f,
  2.88816784e-02f, 1.00953482e-01f, 8.43991898e-03f, 3.00277919e-02f, -9.33517963e-02f, 3.81397232e-02f, -1.10875590e-04f, -4.44588661e-02f, 5.36728743e-03f, 4.67167050e-03f,
  -7.12370813e-01f, -1.42131984e-01f, -8.19947496e-02f, -3.50290388e-01f, -3.85748632e-02f, -1.36009410e-01f, -1.37462631e-01f, -4.98847030e-02f, -2.41492406e-01f, 2.20193461e-01f,
  9.74164978e-02f, -3.99990708e-01f, -5.69037572e-02f, -3.61964226e-01f, -4.33599770e-01f, -3.11016232e-01f, -1.67117119e-01f, -1.27758875e-01f, -1.97459251e-01f, -3.02568940e-03f,
  -9.97596756e-02f, 4.20363024e-02f, -2.23317504e-01f, 2.84818828e-01f, -4.66555692e-02f, 1.37071922e-01f, 3.37022394e-01f, 1.69984266e-01f, 7.93684945e-02f, -9.79851633e-02f,
  -7.55303875e-02f, -8.71310756e-02f, 2.64874604e-02f, -5.91466501e-02f, 1.82792023e-02f, 9.64221731e-02f, 1.10714519e-02f, -2.61760429e-02f, -9.58216656e-03f, 2.59416383e-02f,
  -1.41332876e-02f, 8.57559443e-02f, -2.50692684e-02f, 1.91213824e-02f, -8.23327973e-02f, -2.82722209e-02f, -1.09723508e-01f, -1.69669986e-02f, 2.72906329e-02f, -1.35585412e-01f,
  -1.27618283e-01f, 5.23655601e-02f, -5.07431012e-03f, 1.04180634e-01f, -1.41368271e-03f, 5.20772673e-03f, 4.74528084e-03f, 4.65193242e-02f, 2.79885195e-02f, -1.49522359e-02f,
  -1.03812329e-01f, 8.47165808e-02f, 4.41935472e-02f, -1.03833921e-01f, 6.84853736e-03f, -1.18479878e-03f, -3.13010439e-02f, -2.86936983e-02f, -7.17645464e-03f, 1.00801982e-01f,
  -1.00891218e-02f, -2.00332496e-02f, -3.57365385e-02f, 1.05679631e-01f, -5.24423309e-02f, 2.52664797e-02f, 8.54626391e-03f, -1.54855298e-02f, -5.45729883e-02f, 8.20044577e-02f,
  -7.08667338e-02f, -1.34123534e-01f, 3.61886574e-03f, 3.01800594e-02f, 2.59427298e-02f, 5.98104224e-02f, 5.48414066e-02f, 1.06175981e-01f, -9.29547772e-02f, 5.53354807e-02f,
  5.01075387e-02f, 2.80669987e-01f, 1.02301855e-02f, 7.60084987e-02f, 9.70038921e-02f, 1.93499262e-03f, 7.24053681e-02f, -6.08753078e-02f, -1.42031819e-01f, 3.78778391e-03f,
  1.64096251e-01f, 1.37437120e-01f, 1.62901953e-01f, -5.68033680e-02f, 5.40371910e-02f, 3.11684050e-02f, 5.49212731e-02f, 1.70985579e-01f, 2.42365990e-03f, 1.80633917e-01f,
  7.18889236e-02f, 6.68671057e-02f, 1.81042906e-02f, 6.69139996e-02f, 8.04002136e-02f, -1.23922871e-02f, 8.46118778e-02f, -1.20588355e-01f, 6.06114082e-02f, 4.59822267e-02f,
  -1.06584299e+00f, -4.22394164e-02f, -2.27797180e-01f, 1.95623398e-01f, 9.70196873e-02f, 4.06738162e-01f, 1.08734705e-01f, 3.01459950e-04f, 1.26788309e-02f, 1.49714276e-01f,
  -1.33805117e-02f, -1.26976237e-01f, -1.20216712e-01f, 2.52908319e-01f, -5.95661104e-02f, 1.34535715e-01f, 1.97334602e-01f, 9.60516650e-03f, 5.39552942e-02f, -9.88842621e-02f,
  5.24959154e-02f, 1.59541726e-01f, 1.38726726e-01f, 2.76297987e-01f, 6.76866807e-03f, -6.16393946e-02f, -7.41399378e-02f, 6.92711920e-02f, 1.70675963e-01f, 7.56463930e-02f,
  -2.45545909e-01f, -1.40525132e-01f, -2.60830820e-02f, -7.65229389e-02f, -4.56128940e-02f, -6.40605241e-02f, 6.91565573e-02f, -2.76192613e-02f, -6.22093193e-02f, 8.14583302e-02f,
  -1.08590826e-01f, -5.83653077e-02f, 4.85070571e-02f, 6.32139668e-02f, -1.01558939e-01f, -7.04950914e-02f, -3.47844698e-02f, 5.45667037e-02f, 2.00555325e-02f, 2.65086349e-02f,
  -7.79115409e-02f, 1.04137724e-02f, 1.80014856e-02f, 1.21463776e-01f, 1.13168694e-01f, 2.47486192e-03f, 1.02043398e-01f, -5.48335537e-02f, -2.54595391e-02f, 4.86281700e-02f,
  -6.25475869e-02f, 6.40603853e-03f, -8.81918743e-02f, -1.77682891e-01f, -1.70725435e-02f, -2.76119378e-03f, -4.30465378e-02f, -2.93539166e-02f, 4.36310805e-02f, 3.13470662e-02f,
  1.51025981e-01f, 4.65361550e-02f, 2.59232298e-02f, -4.72219940e-03f, 1.18001789e-01f, 4.24580351e-02f, -1.08832857e-02f, 2.58749388e-02f, 6.08095899e-02f, 4.02828027e-03f,
  -3.29201743e-02f, 1.27234431e-02f, 1.37774467e-01f, 3.46990712e-02f, -5.07146828e-02f, 7.43016694e-03f, 1.48657793e-02f, -1.68478284e-02f, 9.26902294e-02f, 2.74528693e-02f,
  -5.93712628e-01f, -3.20410490e-01f, -2.45505329e-02f, -1.86178721e-02f, 6.36482015e-02f, 3.90800014e-02f, -1.68034248e-02f, 3.51307467e-02f, 6.43997937e-02f, 8.11129902e-03f,
  2.59724706e-02f, 1.04294993e-01f, -1.00296065e-01f, 6.49983436e-02f, 7.38088461e-03f, 6.96409494e-02f, -4.49933559e-02f, 7.62584880e-02f, 4.57573086e-02f, -2.93229683e-03f,
  -5.37090609e-03f, -1.40315024e-02f, 2.06398871e-02f, -1.55403325e-02f, 3.58576402e-02f, -5.58399372e-02f, -1.36148289e-01f, 4.41854224e-02f, -1.55614959e-02f, 4.37886417e-02f,
  9.06018093e-02f, -2.60064334e-01f, 9.94042903e-02f, 4.00960863e-01f, -1.34496689e-01f, -2.89627552e-01f, -4.61313844e-01f, -8.21026042e-02f, -4.13752288e-01f, -3.90596330e-01f,
  1.15168624e-01f, -1.71089798e-01f, -2.91809022e-01f, 3.99495959e-01f, 7.89251745e-01f, -1.89850613e-01f, 2.54228473e-01f, 1.09783271e-02f, -3.36995050e-02f, 2.19926700e-01f,
  2.52779901e-01f, 5.34096718e-01f, 3.64012986e-01f, 3.45757872e-01f, 2.48615921e-01f, 1.78803235e-01f, 6.03393137e-01f, 5.81348129e-02f, 3.89634222e-01f, 1.07970580e-01f,
  6.00900948e-02f, 1.15743414e-01f, -3.27405781e-02f, 3.51268165e-02f, 5.67659289e-02f, 2.06917319e-02f, 5.69800194e-03f, 1.63282856e-01f, 1.01174414e-02f, 1.63566973e-02f,
  -8.32833722e-02f, 4.40424681e-02f, 6.18568920e-02f, 3.60858925e-02f, -4.37214188e-02f, -1.72172189e-02f, -7.95264542e-02f, -2.04256222e-01f, -1.24853447e-01f, -4.31794859e-03f,
  -7.35770911e-02f, 8.87662470e-02f, 1.42284520e-02f, -1.91570949e-02f, -2.96341572e-02f, -6.23977967e-02f, -1.23509564e-01f, -8.47289786e-02f, 2.39509791e-02f, -1.41061973e-02f,
  2.49676108e-02f, 4.10038196e-02f, -3.71499583e-02f, 8.72090310e-02f, 1.32176951e-02f, 5.56349866e-02f, 1.03452042e-01f, -5.38620427e-02f, -5.08879088e-02f, -3.41171515e-03f,
  -3.34451236e-02f, 1.06461704e-01f, -6.43086503e-04f, 8.53129756e-03f, 1.31955277e-02f, -1.53241064e-02f, 1.50844008e-01f, -8.09101164e-02f, -1.38976440e-01f, -8.40668827e-02f,
  1.11258939e-01f, 7.64950961e-02f, -4.14526165e-02f, 7.61962906e-02f, 1.12209292e-02f, 3.57863270e-02f, 7.33869597e-02f, -6.58224225e-02f, -4.76266490e-03f, 5.89892566e-02f,
  -9.37791541e-02f, 1.79288805e-01f, -3.61090526e-02f, 2.86665391e-02f, -6.46486133e-02f, -2.32091378e-02f, 1.18869722e-01f, -3.54183614e-02f, 7.64622241e-02f, -4.22231443e-02f,
  1.27838761e-01f, -1.09521626e-02f, -1.34178419e-02f, 7.04272985e-02f, 1.76021919e-01f, -3.29048513e-03f, 8.40944946e-02f, 6.67268261e-02f, 5.62572517e-02f, 9.08818170e-02f,
  7.42830113e-02f, -3.95987229e-03f, 3.62894163e-02f, 2.09144223e-03f, -8.06772709e-02f, 3.20731513e-02f, -1.37924459e-02f, -8.07573497e-02f, 4.77077905e-03f, 4.45731580e-02f,
  -2.51333743e-01f, -3.17344129e-01f, 7.14491829e-02f, -3.83247733e-01f, 3.20650674e-02f, -8.15951228e-02f, -1.66175798e-01f, -2.19288498e-01f, -1.73526451e-01f, -2.64152795e-01f,
  -5.29521741e-02f, 5.91446981e-02f, 3.96774322e-01f, -4.94923532e-01f, 5.61593354e-01f, 4.32180077e-01f, -2.83371747e-01f, -1.23741098e-01f, 6.71226345e-03f, -2.52274603e-01f,
  -5.63118234e-02f, -3.33363891e-01f, 2.04691842e-01f, -2.64132351e-01f, -3.59595031e-01f, -3.13781083e-01f, 1.96763948e-01f, 4.29354161e-02f, -3.27082664e-01f, 1.19809650e-01f,
  2.92450353e-03f, -8.20293054e-02f, -6.65734708e-02f, 8.80649015e-02f, -5.26628383e-02f, 9.57870204e-03f, -8.32113698e-02f, 7.65663162e-02f, -3.51435691e-02f, -2.81272773e-02f,
  2.27350034e-02f, 1.57691449e-01f, -1.04619302e-01f, 4.90357615e-02f, -1.51817679e-01f, -5.47473282e-02f, 8.17580149e-02f, 6.49820417e-02f, -9.61270556e-03f, 1.22690592e-02f,
  1.41905099e-02f, -3.38592306e-02f, -2.87593417e-02f, 6.50841147e-02f, -5.21677919e-02f, -2.91643590e-02f, 2.18065106e-03f, 2.75611077e-02f, 7.20961392e-02f, -5.48471138e-02f,
  -8.34347308e-02f, -4.75749858e-02f, 1.15107223e-01f, 2.67886501e-02f, -1.09920584e-01f, 6.14968985e-02f, 3.33935674e-03f, 2.72075646e-03f, -1.22542279e-02f, -4.70308810e-02f,
  -1.11129386e-02f, -3.50679308e-02f, -8.09155777e-02f, -4.73297987e-04f, -7.25138783e-02f, -3.32717672e-02f, -8.10992718e-03f, -4.82901707e-02f, -1.06764607e-01f, 1.15996338e-02f,
  1.47446794e-02f, -4.27387990e-02f, 2.05742978e-02f, 9.75479409e-02f, 1.04368478e-01f, 1.27756419e-02f, 1.26698509e-01f, 1.48856550e-01f, -9.00278464e-02f, -2.65850499e-03f,
  -6.36769179e-03f, -2.67949700e-02f, -6.09715618e-02f, -1.10012768e-02f, 1.14621639e-01f, -3.47714461e-02f, -2.80512720e-02f, -2.90336348e-02f, -1.28081795e-02f, -1.01900816e-01f,
  -5.85965849e-02f, -8.40014145e-02f, -4.25605997e-02f, -3.36531363e-02f, 1.36196532e-03f, -9.76010188e-02f, -5.88556230e-02f, 4.59698066e-02f, -4.51744534e-02f, 3.21741775e-02f,
  1.31495878e-01f, -3.84054333e-02f, 3.82948928e-02f, -8.87054056e-02f, -3.20986696e-02f, 2.97930017e-02f, -1.37554416e-02f, 7.58213848e-02f, 3.72796170e-02f, 4.56743464e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -9.54884011e-03f, 1.65214688e-01f, 3.10005456e-01f, 4.98500019e-02f, 2.71988034e-01f, 2.15743873e-02f, 2.43556648e-01f, 3.93832505e-01f, 2.38150015e-01f, 4.69727963e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.42744884e-01f, 2.33974308e-01f, 4.51215684e-01f, -2.36357883e-01f, 1.34443924e-01f, -2.84302592e-01f, -3.46603751e-01f, 3.87851268e-01f, 1.85899943e-01f, -4.38720942e-01f,
  -3.10438812e-01f, 2.93706954e-01f, 1.43280491e-01f, -2.28302687e-01f, 1.70515459e-02f, 3.25916350e-01f, -5.54538667e-01f, 1.80071950e-01f, 4.27619547e-01f, -3.35249335e-01f,
  1.14558265e-01f, -1.65345654e-01f, -1.89219192e-01f, 6.22758508e-01f, -3.71168524e-01f, 4.51675862e-01f, 3.14243764e-01f, 2.25483160e-02f, -6.48265630e-02f, -2.66346425e-01f,
  -1.27398178e-01f, 1.79832101e-01f, 2.12305322e-01f, 1.38630673e-01f, -1.11045122e-01f, 4.52081144e-01f, 1.01995124e-02f, 5.09082317e-01f, -2.62735069e-01f, -2.12638468e-01f,
  -3.34223628e-01f, 3.02830726e-01f, 2.72938341e-01f, -2.13194415e-01f, -1.12622164e-01f, 1.70549244e-01f, 1.22238196e-01f, -2.93090880e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.93874437e-01f, -1.79643575e-02f, 1.59084037e-01f, -5.92698157e-02f, 3.32137734e-01f, 3.86939086e-02f, 4.19704825e-01f, -5.05228877e-01f, 3.69043052e-01f, -3.69960219e-01f,
  7.99160600e-02f, -2.10414082e-01f, -1.48512766e-01f, 4.58822221e-01f, 4.67725366e-01f, 7.37981498e-01f, 3.34131092e-01f, 7.55874366e-02f, 7.22021461e-02f, 5.33024609e-01f,
  7.86570251e-01f, -5.18617153e-01f, 3.11425507e-01f, -4.68495995e-01f, -3.78636599e-01f, 2.04582334e-01f, -3.23171556e-01f, 5.97307719e-02f, 6.36531711e-01f, 3.50766361e-01f,
  -8.72190520e-02f, -5.22166565e-02f, 8.39862823e-02f, -3.43423694e-01f, 6.32803887e-02f, 1.33963153e-01f, 1.63728476e-01f, -4.12640482e-01f, 6.31688476e-01f, -1.10301830e-01f,
  -3.27013880e-01f, -2.10919246e-01f, -3.56427766e-02f, 2.07918435e-02f, 5.15441000e-01f, -5.46062402e-02f, -2.45322689e-01f, 1.42474724e-02f, 3.17696363e-01f, 3.39376628e-01f,
  2.15424709e-02f, 1.30658299e-02f, 8.57618004e-02f, 6.45826533e-02f, -7.09160173e-04f, 1.93379849e-01f, -1.97673991e-01f, 6.91647708e-01f, 4.78629380e-01f, -2.95878351e-01f,
  -8.34468305e-02f, 4.34744060e-01f, 5.96989214e-01f, -1.47919178e-01f, 1.51357427e-01f, 5.16100168e-01f, 4.15858835e-01f, 5.83142519e-01f, -5.31493068e-01f, 3.04211140e-01f,
  6.00318238e-03f, 4.27904844e-01f, 3.74937057e-02f, 9.84158646e-03f, 7.61371911e-01f, -2.20664486e-01f, -3.53305429e-01f, 1.32634521e-01f, -2.67517298e-01f, 3.98270518e-01f,
  1.62942976e-01f, 7.80952513e-01f, 1.13925660e+00f, 7.08374381e-02f, 1.36037245e-01f, -3.42063814e-01f, -3.44441086e-01f, 8.10060620e-01f, 2.99577981e-01f, 4.25150961e-01f,
  2.81659514e-01f, 5.99724770e-01f, 4.90718603e-01f, 5.54531634e-01f, 3.95634025e-01f, 5.02247155e-01f, 6.83868408e-01f, 2.12165460e-01f, -1.05650142e-01f, 5.72559178e-01f,
  4.90710318e-01f, -7.20182240e-01f, 2.13099241e-01f, -5.22306822e-02f, 3.75958443e-01f, 3.38995546e-01f, -5.82746556e-03f, -4.69983935e-01f, 1.45574108e-01f, 7.31770039e-01f,
  7.66255781e-02f, 3.23479325e-01f, 2.24673495e-01f, -4.42092240e-01f, -4.37436402e-01f, -1.51498979e-02f, 4.38163310e-01f, -1.85347497e-01f, 4.07914013e-01f, -1.90803602e-01f,
  3.50728542e-01f, -5.58479540e-02f, 8.13005194e-02f, -4.62728739e-01f, -2.64887977e-02f, -2.05459788e-01f, -1.70862094e-01f, 6.08554602e-01f, 4.32703733e-01f, 7.09351718e-01f,
  3.59948128e-01f, 4.63865101e-02f, -1.28671765e-01f, 9.87695396e-01f, -4.66458797e-01f, 5.07866442e-01f, 3.08539152e-01f, 1.89307585e-01f, 1.66522399e-01f, 1.67862236e-01f,
  -1.47496149e-01f, 3.92664909e-01f, 9.31970954e-01f, 7.90254712e-01f, 3.73759389e-01f, 1.40128627e-01f, 5.50473273e-01f, -1.58961385e-01f, 3.97708654e-01f, -3.24593633e-01f,
  1.46945372e-01f, -5.76229692e-01f, 3.67488652e-01f, 5.06895445e-02f, -2.10658833e-01f, 7.33880162e-01f, 5.23858547e-01f, 1.36146054e-01f, -3.72409038e-02f, 4.24649566e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  7.73021132e-02f, 1.67779803e-01f, 2.31997848e-01f, -2.12775409e-01f, 6.20556891e-01f, 1.07498682e+00f, 1.81445569e-01f, 2.85103828e-01f, 5.70539832e-01f, 2.45691121e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.93673670e-01f, 7.30465353e-02f, 1.88314915e-01f, 5.53794026e-01f, -6.06813669e-01f, -2.46004283e-01f, 3.72013338e-02f, 4.67384547e-01f, 4.87480491e-01f, -3.07830479e-02f,
  -7.09057748e-02f, 4.81384667e-03f, -3.28187853e-01f, 5.81657887e-02f, 6.74854666e-02f, 1.31457582e-01f, -2.48356704e-02f, -2.41675228e-01f, 2.42958948e-01f, 3.00714582e-01f,
  -4.06339675e-01f, -4.92046773e-01f, -6.70718122e-03f, -1.43889889e-01f, -3.04771602e-01f, 7.09687266e-03f, -5.15330553e-01f, 5.17025925e-02f, -1.47468209e-01f, -2.32055008e-01f,
  3.16480219e-01f, 2.53269285e-01f, 1.34696022e-01f, 3.20718028e-02f, 6.90070465e-02f, 3.75979543e-01f, -6.27902031e-01f, 1.84942499e-01f, 5.72695881e-02f, 2.36678466e-01f,
  3.94723207e-01f, -2.86863297e-01f, -3.22748512e-01f, -1.72982872e-01f, -3.14259008e-02f, 1.20981723e-01f, 2.07213655e-01f, 2.73139864e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.73375323e-01f, -2.88751751e-01f, -5.43599069e-01f, 3.86831850e-01f, -5.39528668e-01f, -2.90371090e-01f, 7.62872934e-01f, -4.72521871e-01f, -7.75188059e-02f, 9.41175520e-02f,
  -6.34275451e-02f, -5.94742931e-02f, 3.17110866e-01f, 3.71464580e-01f, 3.72875959e-01f, 7.01401949e-01f, 1.08234420e-01f, -2.01604247e-01f, -2.47799575e-01f, -6.25938833e-01f,
  -4.41013396e-01f, 7.18248546e-01f, 3.95947337e-01f, 7.53370225e-02f, -1.63730726e-01f, 6.74673796e-01f, 1.25045348e-02f, 4.51089233e-01f, 8.62901568e-01f, 6.39942288e-01f,
  6.80299580e-01f, -2.98536897e-01f, 6.19461179e-01f, 4.60411817e-01f, 3.95049781e-01f, 3.81141692e-01f, -6.84543280e-04f, -5.64091206e-01f, 5.87224849e-02f, 6.11427367e-01f,
  2.52609342e-01f, -4.69109446e-01f, -3.71543258e-01f, 2.82181650e-01f, 4.45752442e-01f, -2.84207135e-01f, -7.90190324e-02f, 6.77408814e-01f, -3.03274661e-01f, -2.32690319e-01f,
  -5.94432771e-01f, 3.68966043e-01f, -9.25378650e-02f, -1.35586247e-01f, 6.82087839e-01f, 5.56712151e-02f, 2.65877604e-01f, -1.27267793e-01f, 1.42644539e-01f, -2.31828436e-01f,
  4.21805918e-01f, 7.52401114e-01f, 4.63852240e-03f, 4.31435227e-01f, 5.35342932e-01f, 3.00209641e-01f, 7.83625662e-01f, 1.09332108e+00f, 3.42092991e-01f, -8.29792321e-01f,
  -3.56488526e-01f, 3.56682539e-01f, 1.19058840e-01f, -4.21615332e-01f, -2.10509017e-01f, 6.71321452e-01f, -3.53541583e-01f, -8.13765526e-01f, 1.49510875e-01f, 6.13110006e-01f,
  7.39116371e-01f, 6.68127984e-02f, -2.82955438e-01f, -1.08397639e+00f, -1.15831161e+00f, 6.83447897e-01f, 4.58852172e-01f, -6.80105314e-02f, -2.95872483e-02f, 1.03510749e-02f,
  -2.08726361e-01f, -1.25038385e-01f, 4.65910614e-01f, 2.87619263e-01f, 5.50927758e-01f, -3.24418396e-02f, 1.85871229e-01f, 2.44561121e-01f, 4.87678200e-02f, -4.72806655e-02f,
  5.28100789e-01f, 1.80527195e-01f, -3.26745510e-01f, -1.24514163e+00f, -4.95922238e-01f, 1.89039916e-01f, 6.14012957e-01f, 3.34488571e-01f, -4.58217502e-01f, -6.29615843e-01f,
  8.92132819e-01f, -3.33539605e-01f, 8.86104345e-01f, 2.92288005e-01f, 1.07253933e+00f, -1.52056456e-01f, -3.41176055e-02f, 1.52427331e-01f, 8.43815729e-02f, 3.24565530e-01f,
  6.72738373e-01f, -3.48717898e-01f, 7.95321345e-01f, 3.12077314e-01f, 4.64645624e-01f, 2.27493629e-01f, -2.97964960e-01f, 4.83616665e-02f, 3.32434960e-02f, 5.73768318e-01f,
  7.38537729e-01f, 9.42292631e-01f, 5.27477145e-01f, -3.46904069e-01f, 4.11880553e-01f, -3.42534065e-01f, -4.54731792e-01f, 1.56469136e-01f, 5.07854640e-01f, 7.35648036e-01f,
  -9.86125544e-02f, -7.22741336e-02f, 8.16976488e-01f, 5.16355932e-01f, 1.58611864e-01f, 1.62943244e-01f, 3.42606932e-01f, -2.20638141e-01f, -8.38793278e-01f, 1.25665382e-01f,
  1.19132886e-03f, 9.22871470e-01f, 4.05224293e-01f, 7.49955252e-02f, -4.51872200e-01f, 4.37124401e-01f, 9.99589026e-01f, -3.76026854e-02f, -1.58473834e-01f, 7.76007414e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -3.10003251e-01f, 3.58541250e-01f, 3.44516963e-01f, -1.88391656e-01f, 5.10942161e-01f, 7.43078172e-01f, 6.33427620e-01f, 9.73494411e-01f, 3.72180700e-01f, 1.17260842e-02f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -3.00237220e-02f, 1.15509681e-01f, 1.29215300e-01f, 1.59178242e-01f, 3.42557341e-01f, -2.22683057e-01f, 1.15558550e-01f, -3.21311682e-01f, 3.31440791e-02f, 9.23530087e-02f,
  2.94806719e-01f, 1.79008290e-01f, 4.91771586e-02f, 2.15032116e-01f, -2.38517508e-01f, 1.16687544e-01f, 2.94333041e-01f, 2.28646070e-01f, 1.12891905e-02f, 7.65566379e-02f,
  1.15041837e-01f, -1.49565414e-01f, -1.36392251e-01f, -3.21019650e-01f, 1.08818397e-01f, -1.67253658e-01f, -1.94588546e-02f, 1.73545890e-02f, -4.85705696e-02f, 3.57084036e-01f,
  1.50888175e-01f, 6.64395988e-02f, -2.46337637e-01f, -3.28051634e-02f, 1.06806890e-03f, 2.55755842e-01f, 2.75478810e-01f, 2.91405976e-01f, 1.43128067e-01f, 1.33952349e-01f,
  -1.29244134e-01f, 1.54726744e-01f, 1.39232188e-01f, 3.35634857e-01f, -1.18347228e-01f, -2.08884433e-01f, -3.42373997e-01f, 1.65785924e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.17479455e-01f, 5.57755470e-01f, 2.40551621e-01f, 3.65511000e-01f, -4.20116663e-01f, 1.04512349e-01f, 6.29574656e-01f, 6.45015419e-01f, -5.16454428e-02f, 5.88047266e-01f,
  -5.21145105e-01f, 5.81325769e-01f, -1.95229754e-01f, 7.90507555e-01f, -2.39637285e-01f, 1.34419531e-01f, 8.09978768e-02f, 3.83771598e-01f, 7.18899131e-01f, 7.65554428e-01f,
  5.55523694e-01f, 6.53670371e-01f, -2.10681841e-01f, 3.92657071e-01f, 4.66649145e-01f, -2.26254970e-01f, 1.45473555e-01f, 1.03354466e+00f, -7.11933196e-01f, 3.85875523e-01f,
  -7.87793249e-02f, 6.37222171e-01f, -5.27749658e-01f, 1.81409821e-01f, -1.16948403e-01f, -1.39891446e-01f, 4.76555824e-01f, 4.75618765e-02f, 6.48594260e-01f, -4.29505646e-01f,
  6.29597664e-01f, 5.29617310e-01f, 4.78031576e-01f, -1.07788511e-01f, -5.21443635e-02f, 5.96694529e-01f, 2.42092803e-01f, 7.12740183e-01f, 2.59646952e-01f, -5.70394993e-01f,
  3.57456923e-01f, 2.34900992e-02f, 3.99371535e-01f, 2.17109054e-01f, 5.68359613e-01f, 7.22149193e-01f, -3.66622925e-01f, -6.68117583e-01f, -5.84462993e-02f, 6.59694374e-01f,
  9.27709222e-01f, -4.44462419e-01f, 7.55372345e-01f, 1.83568463e-01f, -1.72651529e-01f, 8.09309542e-01f, 3.58554751e-01f, 2.33262539e-01f, -1.00057699e-01f, 6.42651856e-01f,
  -2.21366718e-01f, 4.22220826e-01f, 3.11639577e-01f, 3.60683352e-01f, -4.00945723e-01f, 1.08470213e+00f, 1.40816599e-01f, 2.98245940e-02f, -3.68210822e-01f, 8.15248489e-02f,
  -2.29283810e-01f, -5.29413104e-01f, 2.50889689e-01f, 5.57059407e-01f, 7.99939454e-01f, 7.23214373e-02f, 6.75698817e-01f, 7.46727705e-01f, -1.46399096e-01f, 5.17641366e-01f,
  -1.07455909e-01f, 5.50597429e-01f, -2.47593746e-01f, -5.03726304e-01f, 4.03037846e-01f, 2.18123719e-01f, -4.04826850e-02f, 2.93360621e-01f, -9.23648417e-01f, -7.81109452e-01f,
  -8.47802103e-01f, -7.28044748e-01f, -3.91847104e-01f, 6.52674675e-01f, -7.40014017e-01f, -5.52134871e-01f, -6.68661118e-01f, -5.83345652e-01f, 5.99469066e-01f, 2.14497283e-01f,
  6.24429166e-01f, -1.37032986e-01f, 6.14902496e-01f, 1.15959370e+00f, 5.59534095e-02f, -6.90154910e-01f, -3.86844188e-01f, -4.01630908e-01f, -9.25399601e-01f, -3.41806747e-02f,
  -3.83075237e-01f, -9.52961504e-01f, 4.25508283e-02f, 4.82570916e-01f, 6.42940760e-01f, 7.99901068e-01f, 7.79851079e-02f, -3.53721708e-01f, 9.04308558e-01f, 5.61721742e-01f,
  9.04620886e-01f, 8.73931527e-01f, 7.00562239e-01f, -1.85948119e-01f, -2.66610384e-01f, -6.26006484e-01f, 4.89908785e-01f, -1.27853706e-01f, 9.98047411e-01f, -6.51966751e-01f,
  2.99339622e-01f, 4.87564325e-01f, 9.44622934e-01f, -2.91787721e-02f, -5.41963995e-01f, 1.06306426e-01f, -6.45667493e-01f, -2.53772497e-01f, -5.70897043e-01f, 2.58950531e-01f,
  -5.93119800e-01f, 3.40851814e-01f, 4.58065212e-01f, -3.39772552e-01f, 4.21584815e-01f, -2.81593740e-01f, -5.67990541e-01f, 4.85838175e-01f, -1.01153515e-01f, 1.09422731e+00f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  5.15216768e-01f, 2.95158356e-01f, 2.57528257e-02f, -1.34050772e-01f, 5.00779867e-01f, -9.97210573e-03f, 1.36887655e-01f, 6.86160505e-01f, 5.39903641e-01f, 2.81871650e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -3.44925672e-01f, -6.76626787e-02f, 4.10322934e-01f, -2.19319880e-01f, -3.28882039e-01f, -4.45791364e-01f, 3.41119975e-01f, -2.73269057e-01f, -3.00750323e-02f, 1.37863070e-01f,
  -1.24239817e-01f, -1.22986466e-01f, 3.96874338e-01f, -3.94435942e-01f, -9.79593515e-01f, 7.23681688e-01f, -5.39216697e-01f, 2.73029029e-01f, -5.87419748e-01f, -6.25905991e-02f,
  -6.44454062e-01f, -1.98556453e-01f, -2.35854805e-01f, -8.44238222e-01f, -9.33425188e-01f, 1.86530739e-01f, 4.01822716e-01f, -1.56506360e-01f, 4.99748141e-01f, 5.05846977e-01f,
  -7.82957733e-01f, -7.24052668e-01f, -4.36363012e-01f, -1.07367054e-01f, 1.30302668e-01f, -2.23293260e-01f, -3.06965649e-01f, 3.96830857e-01f, -2.65587628e-01f, 4.33700144e-01f,
  -5.08791327e-01f, 3.70791256e-01f, -6.35989802e-03f, 4.08530205e-01f, -3.60162050e-01f, -4.74719226e-01f, -5.98910749e-01f, -2.69783139e-01f, -3.30859452e-01f, 2.28597019e-02f,
  -2.35268548e-01f, 1.08953610e-01f, 3.59705269e-01f, 6.57177448e-01f, 2.57971168e-01f, 2.41678983e-01f, 3.96379381e-01f, -1.27243209e+00f, 5.32951355e-01f, -2.56415159e-01f,
  -3.97202283e-01f, -7.85046279e-01f, -8.27405751e-01f, 5.02770841e-01f, 4.61882770e-01f, 1.07585475e-01f, 4.76343602e-01f, 5.08960366e-01f, 5.21434247e-01f, 4.24444564e-02f,
  3.00105512e-01f, 3.69821697e-01f, -8.76376405e-02f, -5.28089285e-01f, 2.01373905e-01f, 2.31313601e-01f, -4.36926574e-01f, -4.27105725e-01f, 3.17906559e-01f, 1.31687522e-01f,
  8.74476582e-02f, 8.47009942e-02f, 1.98821798e-01f, -9.61754024e-01f, 7.28828609e-01f, 5.27800262e-01f, -1.00006185e-01f, -7.06944287e-01f, -3.62299830e-01f, 1.37491509e-01f,
  -8.69103193e-01f, -9.54819977e-01f, 4.97534901e-01f, 5.84478736e-01f, 5.26376143e-02f, 4.76210862e-02f, 3.85966420e-01f, 6.62060082e-01f, 7.03628480e-01f, -2.21043915e-01f,
  4.76093948e-01f, -3.81524503e-01f, 4.29373384e-01f, 3.25733423e-01f, -5.74071109e-01f, -4.13846374e-02f, 7.09315121e-01f, -4.00694162e-01f, -3.54139835e-01f, 6.48070514e-01f,
  -5.23364916e-02f, -8.71620715e-01f, -3.80205303e-01f, 1.55716315e-02f, 2.46147048e-02f, 1.18003488e-01f, -2.54137099e-01f, -4.72568767e-03f, 4.13376570e-01f, -9.88015719e-03f,
  3.79231066e-01f, -4.24516529e-01f, 2.50260174e-01f, 5.18149257e-01f, -5.19724488e-01f, -5.44974804e-01f, -8.40993822e-01f, -6.52656436e-01f, -3.14700991e-01f, 2.43932575e-01f,
  -4.45212722e-01f, -6.09573238e-02f, -5.30220509e-01f, 3.34444284e-01f, -4.56909627e-01f, -7.47973740e-01f, -7.99592495e-01f, 4.91215587e-01f, -8.21566105e-01f, 2.95121938e-01f,
  -2.86016576e-02f, -5.12669861e-01f, 3.37174833e-01f, -5.35609722e-01f, 3.89630616e-01f, 1.29455328e-01f, 1.16334632e-01f, 1.89770851e-02f, 1.47999555e-01f, -3.52043450e-01f,
  -6.00578308e-01f, -1.12672105e-01f, 3.24901044e-01f, 3.37286144e-01f, -3.97445828e-01f, 1.99624017e-01f, -6.16896272e-01f, -8.69382441e-01f, 4.04113621e-01f, -6.51791334e-01f,
  -5.17096877e-01f, -3.45403880e-01f, 2.45276973e-01f, 2.48001888e-01f, -5.07736683e-01f, 3.53577703e-01f, -8.58181000e-01f, 2.43941873e-01f, 4.89106715e-01f, -7.95096695e-01f,
  -5.61470985e-01f, -1.93087474e-01f, -3.05350780e-01f, -7.95034766e-01f, 1.48155540e-01f, 5.98483980e-01f, 2.23484680e-01f, -3.46621163e-02f, -8.24462235e-01f, 7.08273768e-01f,
  7.36016273e-01f, -5.24521649e-01f, -1.06809163e+00f, -4.17670131e-01f, 5.24466574e-01f, -4.42632586e-01f, -3.43180507e-01f, -1.16496658e+00f, -1.77370667e-01f, 3.36824596e-01f,
  7.37025738e-01f, -4.64545071e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.30118504e-01f, 1.83927417e-01f, -1.88349977e-01f, -8.73084441e-02f, -5.49829602e-02f, -1.28757045e-01f, 6.70268852e-03f, -1.37666136e-01f, -1.87887982e-01f, -1.47234321e-01f,
  -5.23263812e-02f, 8.06415305e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    