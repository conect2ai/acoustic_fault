/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.21629512e-01f, -6.39348254e-02f, 8.30757022e-02f, -4.55907993e-02f, -7.87858944e-03f, 2.09596217e-01f, 1.35151431e-01f, 8.68520066e-02f, -1.10214800e-01f, -1.32853657e-01f,
  -6.35989383e-02f, -1.65063918e-01f, -1.31289020e-01f, -3.90212983e-02f, 2.31755257e-01f, 8.33267570e-02f, -5.77202253e-02f, 1.49588704e-01f, 2.76233584e-01f, 7.97293335e-02f,
  -9.72376540e-02f, -3.26729007e-02f, 1.07929632e-01f, -1.65232643e-02f, -3.69945392e-02f, -5.86724058e-02f, -8.57942700e-02f, 7.78573081e-02f, -3.71750072e-02f, -1.55912742e-01f,
  6.83769956e-02f, 1.66490078e-01f, -1.61019694e-02f, -1.60881691e-02f, -2.06001066e-02f, 1.98663827e-02f, 2.74850801e-02f, -7.06346408e-02f, -9.62845534e-02f, 8.43041018e-03f,
  1.91654228e-02f, 2.09327973e-02f, -1.56499632e-02f, -3.34929191e-02f, -1.07323732e-02f, 1.55921340e-01f, 2.68218247e-03f, 4.66480106e-02f, 9.30052474e-02f, 1.56535935e-02f,
  -1.58379495e-01f, 9.27109867e-02f, 1.69113711e-01f, 3.52452286e-02f, 2.03903262e-02f, 4.75234203e-02f, 5.09644859e-02f, 3.71044315e-02f, 1.45444438e-01f, 5.67926429e-02f,
  8.20220821e-03f, 8.08684230e-02f, 4.08722945e-02f, -1.21375537e-02f, 3.04372003e-03f, -4.32980433e-02f, -2.22736970e-02f, 3.51473875e-02f, -6.66674972e-02f, -2.79796496e-02f,
  -8.29768553e-02f, 6.15009433e-03f, 4.94982786e-02f, 3.90776023e-02f, -9.75412503e-02f, 4.44343388e-02f, 7.00796917e-02f, -2.63537071e-03f, -7.72614405e-02f, 4.99768518e-02f,
  3.67515981e-02f, -1.35875549e-02f, -1.41510814e-01f, -6.13426305e-02f, 5.30454703e-02f, 3.13206911e-02f, 2.31696833e-02f, 1.11539019e-02f, -2.29404550e-02f, 1.01190627e-01f,
  -2.52755404e-01f, -9.90381688e-02f, 1.31730393e-01f, 4.45786193e-02f, 8.25119168e-02f, -2.30103079e-02f, -1.17007941e-01f, 2.69828904e-02f, -4.02347110e-02f, -4.03889790e-02f,
  9.29944590e-02f, 9.57837701e-02f, 1.19507173e-02f, -4.37590741e-02f, 7.00937882e-02f, 2.92059965e-02f, 1.21697839e-02f, 7.75545910e-02f, -2.05525104e-02f, -2.27300059e-02f,
  -8.37353095e-02f, 1.03394590e-01f, 1.50290221e-01f, 7.70728961e-02f, 2.29605455e-02f, 1.64527029e-01f, 2.27022599e-02f, 5.69002554e-02f, 1.98173136e-01f, 1.43570021e-01f,
  -5.26121914e-01f, 4.42071632e-02f, -1.02674782e-01f, -2.28554964e-01f, -1.73797444e-01f, 4.57474180e-02f, -1.30475283e-01f, 1.49928376e-01f, -1.71816312e-02f, -2.35802844e-01f,
  -1.50039896e-01f, -1.69484824e-01f, -9.59062278e-02f, -3.50974388e-02f, 3.56186815e-02f, -2.11831525e-01f, -1.40928015e-01f, -2.03337464e-02f, 4.23221998e-02f, 8.17065984e-02f,
  -3.97663713e-02f, -2.83608809e-02f, 3.55434120e-02f, 1.75797150e-01f, -1.32609263e-01f, -1.17858313e-02f, -1.17758468e-01f, -1.24783386e-02f, 1.62430272e-01f, -6.36575669e-02f,
  -2.76906520e-01f, -4.14627325e-03f, -2.31862050e-02f, -2.72818767e-02f, -4.74112369e-02f, 1.10290326e-01f, 4.28003334e-02f, 1.61273092e-01f, 1.42800316e-01f, 3.32654826e-02f,
  6.95209503e-02f, 4.61411066e-02f, 9.62385237e-02f, 5.68101332e-02f, 3.71164978e-02f, 7.62670562e-02f, 9.74638388e-02f, -5.50767127e-03f, 7.47004803e-03f, 6.97368905e-02f,
  7.29158614e-03f, -3.16977799e-02f, 2.75209211e-02f, -5.36542805e-03f, 1.60317330e-04f, -1.12512045e-01f, 7.57705793e-02f, 1.90668434e-01f, 1.30082130e-01f, 1.17941536e-01f,
  -1.56278268e-01f, -1.32479146e-01f, 2.64998749e-02f, 5.64306751e-02f, -2.21464671e-02f, 7.11940154e-02f, -4.09244448e-02f, -8.70754644e-02f, -2.70115118e-02f, 1.93391949e-01f,
  1.83460861e-02f, -1.46397471e-01f, 6.10145442e-02f, -6.54208064e-02f, -7.17796525e-03f, 1.40771538e-01f, 1.65358540e-02f, 6.27743229e-02f, 3.68311480e-02f, 6.64552823e-02f,
  3.55515466e-03f, 8.89661908e-02f, 7.50174979e-04f, 1.31894410e-01f, -7.31481612e-02f, -9.05150920e-02f, 2.40274705e-03f, 5.05790636e-02f, -6.77194726e-03f, 6.24005981e-02f,
  8.20351671e-03f, 7.18362676e-03f, -1.15249611e-01f, 3.50946002e-02f, 1.32365540e-01f, 1.91093469e-03f, -1.22982286e-01f, 2.04125661e-02f, -1.20363653e-01f, -3.99467051e-02f,
  -9.92343109e-03f, -2.40521301e-02f, -6.68872297e-02f, 4.47777472e-02f, -4.23474051e-02f, 2.46837735e-02f, -8.87460168e-03f, -6.17268756e-02f, 1.21249273e-01f, 3.01761590e-02f,
  -2.36888682e-05f, 6.88505471e-02f, 3.75236124e-02f, 7.77901849e-03f, 6.54709116e-02f, -1.38392806e-01f, 2.70451475e-02f, -4.01804633e-02f, 4.30986285e-02f, -1.20746993e-01f,
  -5.25762141e-02f, 6.95663020e-02f, 1.25245765e-01f, -8.99224356e-02f, -7.99620971e-02f, 1.09746456e-01f, 3.06198984e-01f, 1.62885979e-01f, -8.82302001e-02f, 2.87274309e-02f,
  2.37139594e-02f, -3.06716800e-01f, -3.19983572e-01f, -9.99192894e-02f, 6.75940216e-02f, 6.98631406e-02f, 1.99048780e-02f, -2.07856819e-01f, -2.24011093e-01f, -1.84903815e-01f,
  -2.08742827e-01f, -3.54587644e-01f, -2.86443770e-01f, -1.90907210e-01f, -2.66756058e-01f, -3.74130875e-01f, 9.10384208e-03f, 1.31570876e-01f, -8.74548126e-03f, -1.80071265e-01f,
  -1.06199108e-01f, 1.66027978e-01f, -8.72836933e-02f, -2.95649003e-02f, -8.10983554e-02f, -5.77951111e-02f, -6.89525530e-02f, -2.27410402e-02f, -6.33473918e-02f, -8.56901780e-02f,
  -8.28517154e-02f, -1.28605261e-01f, -1.47010744e-01f, -2.61411257e-02f, -7.46268332e-02f, 4.47718278e-02f, 4.96288277e-02f, -7.19939098e-02f, -5.56307770e-02f, 7.31219770e-03f,
  2.04340722e-02f, 6.39923885e-02f, -3.36924046e-02f, 6.22741552e-03f, 7.06420466e-02f, -9.19656754e-02f, -3.96145023e-02f, 8.20166394e-02f, -1.43217053e-02f, 6.90720901e-02f,
  1.11966901e-01f, -2.31273454e-02f, -8.09123218e-02f, 5.42907901e-02f, -7.09693208e-02f, 1.82220936e-02f, -2.53737867e-02f, 5.26113771e-02f, 9.47314128e-03f, 1.82984851e-03f,
  -4.34234142e-02f, -6.37879670e-02f, 1.78407393e-02f, -8.14826638e-02f, -1.34082690e-01f, -4.82043847e-02f, 1.56786069e-02f, -5.95453531e-02f, -4.85012941e-02f, 5.00720888e-02f,
  -5.36050461e-02f, -3.89937051e-02f, -9.41241011e-02f, -8.49912316e-02f, -7.44313076e-02f, 6.00206666e-03f, 2.35847253e-02f, -7.66497329e-02f, -5.12447357e-02f, 5.56429327e-02f,
  -1.75283819e-01f, 2.72978730e-02f, -4.51831110e-02f, 3.19884717e-02f, -1.05916008e-01f, -3.66128795e-02f, -2.52431259e-02f, -9.60401669e-02f, -4.43737395e-02f, -5.81418164e-02f,
  -5.53777367e-02f, -1.97760031e-01f, -5.45199998e-02f, -1.52102057e-02f, -5.00056259e-02f, -1.03579469e-01f, 9.76783875e-03f, -1.30228594e-01f, -9.44633558e-02f, 2.52404287e-02f,
  1.67945419e-02f, 7.70215541e-02f, -1.09851539e-01f, -3.55175394e-03f, -2.76966859e-02f, -2.11891949e-01f, -1.01118729e-01f, -4.39359865e-04f, 4.38728184e-02f, -1.70819864e-01f,
  -6.07688308e-01f, 3.08426112e-01f, 9.55381319e-02f, -4.57822710e-01f, -4.77816490e-03f, 1.86060846e-01f, 6.28105998e-01f, 1.53816506e-01f, -1.83832422e-01f, 1.89461067e-01f,
  -5.95184900e-02f, -2.12741524e-01f, -2.14353964e-01f, -5.12025431e-02f, 1.40013799e-01f, 4.48609352e-01f, 2.67152339e-01f, -5.79788089e-02f, -5.41775040e-02f, -3.46495863e-03f,
  2.31943727e-01f, -1.48506105e-01f, -3.67836922e-01f, -1.32088780e-01f, 6.17430657e-02f, -7.38944113e-02f, 3.71128246e-02f, -1.09811284e-01f, 8.59637111e-02f, 6.18060715e-02f,
  -2.27470621e-02f, -9.38853845e-02f, 5.78058064e-02f, -1.52135745e-01f, -4.18610536e-02f, 2.39263121e-02f, 1.30294919e-01f, -3.98552008e-02f, -8.10415018e-03f, -6.80334913e-03f,
  -1.68090492e-01f, -2.74238717e-02f, -1.10310771e-01f, 3.83947454e-02f, -2.66859252e-02f, -2.94954311e-02f, 2.78305281e-02f, 2.79327109e-02f, -5.11742979e-02f, 8.47833827e-02f,
  -5.56071382e-03f, -9.96213127e-03f, -5.76144941e-02f, 7.00728297e-02f, 9.02367011e-02f, -7.20067769e-02f, -8.51014331e-02f, -1.19061723e-01f, -9.75432768e-02f, -2.31666900e-02f,
  -1.04511641e-02f, -6.45407438e-02f, 4.51770537e-02f, -9.66374821e-04f, 5.86137399e-02f, 1.61320437e-02f, 6.05882481e-02f, 2.68536191e-02f, 6.42862124e-03f, -4.71044965e-02f,
  1.19439596e-02f, 3.71639617e-02f, -4.50202152e-02f, 3.97316460e-03f, -8.53304844e-03f, 1.16595440e-02f, 5.88876009e-02f, -1.60448458e-02f, 2.49063484e-02f, -1.48364101e-02f,
  -3.32462341e-02f, -4.21897955e-02f, 4.04562764e-02f, 6.96702451e-02f, 7.67537877e-02f, -6.33831788e-03f, -8.64248574e-02f, 1.01476744e-01f, 1.51850702e-03f, 4.23205048e-02f,
  3.63064930e-02f, 1.34162888e-01f, 2.18940377e-02f, 2.75804866e-02f, 1.94916073e-02f, -4.28202562e-02f, -6.23739436e-02f, -3.84504274e-02f, -5.51505340e-03f, 1.99569352e-02f,
  -3.01922541e-02f, 1.70410816e-02f, 8.09025578e-03f, 4.58038785e-03f, -3.37358676e-02f, -5.58849238e-02f, -1.95549112e-02f, -4.02782597e-02f, 2.18864605e-02f, -3.93651053e-02f,
  1.07428044e-01f, 8.97684842e-02f, -3.86096798e-02f, 6.90696985e-02f, -8.37794766e-02f, 5.92692569e-02f, 7.99097717e-02f, 3.39890346e-02f, 6.98166192e-02f, 3.07088852e-01f,
  2.06256449e-01f, 3.44650954e-01f, 5.71577474e-02f, 1.85938507e-01f, -2.79812422e-03f, -2.86788829e-02f, 2.43765384e-01f, 1.21124215e-01f, 1.07056916e-01f, 6.19938709e-02f,
  -1.99477121e-01f, -3.99807125e-01f, -2.05152169e-01f, -1.94089442e-01f, 1.36005104e-01f, 3.99360389e-01f, 3.58036011e-01f, -7.25057349e-02f, -2.23697782e-01f, -2.94411957e-01f,
  -1.12730205e-01f, 7.63083473e-02f, 7.74409473e-02f, 9.53380913e-02f, 2.07508877e-01f, -1.32621735e-01f, 2.00712293e-01f, 2.33573057e-02f, -9.17172804e-02f, -2.36379472e-03f,
  -4.11302030e-01f, 8.54322612e-02f, -3.43673676e-02f, 4.11456898e-02f, -2.57093180e-02f, 8.88493732e-02f, -2.60457285e-02f, 5.18063679e-02f, 2.53376253e-02f, 4.94988635e-02f,
  2.38346886e-02f, -6.30899072e-02f, 5.56726605e-02f, -3.26542519e-02f, 1.03468187e-01f, -3.47013623e-02f, 1.47462383e-01f, 1.03945822e-01f, 4.47620600e-02f, -1.34967193e-02f,
  -4.24114289e-03f, -9.70158130e-02f, -8.14279467e-02f, 1.31459720e-03f, -6.81906268e-02f, -2.16453075e-01f, -3.13719660e-02f, 4.15584408e-02f, 2.52479874e-02f, 1.40465051e-01f,
  2.40931399e-02f, 5.87589256e-02f, -4.87719513e-02f, -2.48959083e-02f, 5.00828587e-03f, -1.70456301e-02f, -1.36022478e-01f, -4.32046242e-02f, -5.90534993e-02f, -8.39123428e-02f,
  -4.22765091e-02f, 8.80979598e-02f, 3.22717093e-02f, 8.77643079e-02f, -4.47958447e-02f, 1.90899130e-02f, -3.46975662e-02f, 3.39395590e-02f, 3.20534445e-02f, -2.53169443e-02f,
  -2.16508098e-02f, -3.76326740e-02f, 4.33367789e-02f, 2.87652202e-02f, -1.85295697e-02f, -3.49712595e-02f, -1.21314544e-02f, -1.25847226e-02f, 3.78023945e-02f, 2.52476521e-02f,
  2.06011869e-02f, -7.03089824e-03f, -3.27653140e-02f, -2.43579149e-02f, -2.39167064e-02f, 5.20689711e-02f, -2.85002822e-03f, 2.35078344e-03f, -3.35450447e-03f, 3.17922086e-02f,
  6.88699931e-02f, 1.05149858e-02f, -1.94799099e-02f, 2.08323952e-02f, 1.94065683e-02f, 4.35725711e-02f, 5.41426167e-02f, -4.13968712e-02f, 5.29039763e-02f, -9.54049919e-03f,
  1.78248808e-01f, -5.34913549e-03f, -5.79290651e-02f, -8.84521380e-02f, -1.37889711e-02f, -1.50846794e-01f, -9.02344435e-02f, -5.84451072e-02f, -7.99892545e-02f, 2.04842001e-01f,
  1.57005772e-01f, -1.54888816e-02f, -4.01456319e-02f, 2.10097596e-01f, -2.01999992e-02f, -1.20160103e-01f, -1.52942151e-01f, -1.57998651e-01f, -1.01402931e-01f, -1.12781189e-01f,
  -1.47334337e-01f, 4.24593091e-02f, 1.59101173e-01f, -6.53167665e-02f, 5.64074069e-02f, 1.28222868e-01f, 2.75994956e-01f, 2.56455213e-01f, 2.12718859e-01f, 2.89016496e-02f,
  4.46327403e-02f, 2.97829837e-01f, 3.35225835e-02f, 2.30821893e-02f, 1.26588881e-01f, 9.50073227e-02f, 4.77772877e-02f, 1.12808354e-01f, -2.01696530e-01f, 2.08547160e-01f,
  9.63042751e-02f, -4.36453484e-02f, -7.58463740e-02f, 6.05799034e-02f, -1.98449288e-02f, -1.05378486e-01f, -2.60062423e-02f, 8.10179189e-02f, -7.59231076e-02f, -6.60893368e-03f,
  -4.98744249e-02f, -3.32267694e-02f, 3.93388532e-02f, 3.33900191e-02f, 7.06743300e-02f, -6.59709573e-02f, -5.33047393e-02f, 5.04648387e-02f, -3.75789590e-02f, -1.89430639e-02f,
  -9.15276706e-02f, -1.70607105e-01f, -5.06835580e-02f, -8.83214176e-02f, -7.55712017e-02f, 4.09069180e-04f, -8.36364701e-02f, -1.15657285e-01f, -1.52019382e-01f, 2.91966461e-02f,
  -4.26977277e-02f, 1.00213056e-02f, 1.08497310e-02f, 4.02823649e-03f, -4.30236869e-02f, -4.60485630e-02f, 2.65707839e-02f, 4.78167050e-02f, 3.23929749e-02f, 2.95074489e-02f,
  3.16337720e-02f, -5.90903237e-02f, -7.11088581e-03f, 6.69889227e-02f, 9.70385130e-03f, 1.08383618e-01f, 3.28655466e-02f, 2.34469939e-02f, 2.29475182e-02f, -9.20202732e-02f,
  -1.65227428e-02f, -1.85450390e-02f, 2.31304765e-02f, 5.73599711e-02f, -1.17950507e-01f, -2.72985585e-02f, 1.21802343e-02f, 4.76311632e-02f, 5.17451502e-02f, 5.23784682e-02f,
  2.15950295e-01f, -1.81917578e-01f, 4.47307043e-02f, 1.05285250e-01f, 3.85084338e-02f, -7.74767324e-02f, -1.02692330e-02f, 3.07572428e-02f, 4.39998657e-02f, -7.21364282e-03f,
  -1.07225992e-01f, 2.27063522e-02f, 4.53425236e-02f, -5.08368015e-02f, 9.22752172e-02f, 3.08910757e-03f, 9.54604819e-02f, 1.42047321e-02f, -1.28215566e-01f, -6.67165294e-02f,
  -9.15175900e-02f, -3.47337611e-02f, 1.90898776e-01f, 7.37130344e-02f, 9.39152837e-02f, 1.61943063e-01f, 1.08412392e-01f, -7.74730986e-04f, 8.61587655e-03f, 1.23268813e-01f,
  -3.85901451e-01f, 2.18379110e-01f, -3.29629600e-01f, -7.02901706e-02f, 2.19628170e-01f, 3.95528711e-02f, -6.66831853e-03f, 8.01835302e-03f, 3.48115079e-02f, 1.77055404e-01f,
  8.58802497e-02f, 1.84346154e-01f, -7.81108290e-02f, 8.81947130e-02f, -2.03669146e-01f, 1.93122461e-01f, 1.07824877e-01f, -2.26054117e-01f, -3.83949548e-01f, 1.50472090e-01f,
  4.05864477e-01f, 9.23385546e-02f, -3.22295934e-01f, -7.57909119e-02f, 3.41662437e-01f, 1.04393676e-01f, 1.56729873e-02f, 1.77757472e-01f, 2.81441659e-01f, 5.07003784e-01f,
  -4.62395549e-02f, 1.22288994e-01f, -9.98733416e-02f, 1.27621144e-01f, 2.88901068e-02f, 9.87739339e-02f, 5.52965738e-02f, 2.05842201e-02f, 1.09564416e-01f, 1.35553762e-01f,
  1.49728104e-01f, 1.55354753e-01f, 3.97216007e-02f, 1.88988969e-01f, 9.48788747e-02f, 1.08226158e-01f, 1.31243438e-01f, -6.65391013e-02f, -6.01587445e-02f, 9.10179466e-02f,
  3.46577406e-01f, 2.24662364e-01f, 4.08841595e-02f, 2.70025861e-02f, 3.35186608e-02f, -1.20475646e-02f, 4.11747321e-02f, 2.54312545e-01f, 1.00317309e-02f, 2.87771523e-01f,
  2.24909466e-02f, 2.62956228e-03f, -2.48455741e-02f, -1.65364519e-02f, -2.20318642e-02f, 1.82060171e-02f, -4.35580201e-02f, -5.39022172e-03f, -6.03157170e-02f, -6.18915223e-02f,
  -3.83160543e-03f, -9.40700993e-02f, -2.44297832e-02f, -4.31118570e-02f, -2.14163028e-02f, 2.09275987e-02f, 4.30719345e-04f, -2.10105907e-02f, 2.81794313e-02f, -2.28701737e-02f,
  -4.69034724e-02f, -5.33280484e-02f, -4.66704592e-02f, 3.98700610e-02f, 7.35588446e-02f, -1.96985016e-03f, -1.47821230e-03f, -3.10305990e-02f, -8.23994540e-03f, -1.27264927e-03f,
  -2.06545442e-01f, -1.65029481e-01f, 1.27166277e-03f, 8.90529528e-02f, 1.22852929e-01f, 1.02210812e-01f, 2.82473732e-02f, -1.29996622e-02f, 2.07169279e-02f, -4.26572934e-02f,
  4.31457534e-02f, -4.66964543e-02f, 2.68642269e-02f, 4.34060544e-02f, 1.35182226e-02f, 6.65481165e-02f, 1.49141327e-01f, 3.23544745e-03f, -4.87858709e-03f, 9.42077860e-02f,
  1.87904551e-03f, -5.98498061e-02f, -3.41836922e-02f, -6.39536455e-02f, 6.84206635e-02f, -3.66892219e-02f, 1.49390532e-03f, 7.34612122e-02f, -1.95038408e-01f, -1.04188055e-01f,
  1.41233653e-01f, -1.10849962e-01f, 1.21788047e-01f, 6.04675338e-02f, 2.52727836e-01f, 7.93228000e-02f, 7.70791471e-02f, -1.59868106e-01f, -1.95841223e-01f, 1.39755026e-01f,
  2.09368318e-01f, 1.74241383e-02f, 1.36690708e-02f, -2.55328510e-02f, -1.04277544e-02f, -9.52547640e-02f, 8.26812387e-02f, 4.91290390e-02f, 1.91212073e-01f, 3.33062768e-01f,
  1.56978384e-01f, -1.61743313e-02f, -6.72343597e-02f, -4.82866541e-03f, 1.99097708e-01f, 7.41551146e-02f, -1.48175150e-01f, -3.97806652e-02f, 1.00107580e-01f, 2.56191880e-01f,
  5.55325709e-02f, 5.73874302e-02f, 6.61723465e-02f, -6.04354590e-03f, 1.03272744e-01f, -7.56299570e-02f, -4.77407835e-02f, -7.77456388e-02f, -3.94592881e-02f, -1.30645245e-01f,
  1.13012725e-02f, 5.52111268e-02f, -3.18001881e-02f, 5.25484905e-02f, 4.68217861e-03f, -5.07677495e-02f, -7.74180666e-02f, -4.10722457e-02f, -8.03641155e-02f, -6.80305110e-03f,
  4.42943573e-02f, 4.18029241e-02f, -4.46672179e-02f, -1.41277939e-01f, -4.90221456e-02f, 3.61500047e-02f, 6.70907423e-02f, -5.80483600e-02f, -4.08675857e-02f, -6.78569525e-02f,
  6.45921603e-02f, -4.52762954e-02f, 3.69938393e-03f, 8.54399502e-02f, 1.29756154e-02f, -6.09820783e-02f, 3.10718939e-02f, 1.36943127e-03f, -6.33454248e-02f, -1.49703184e-02f,
  -4.54111621e-02f, 4.52623516e-02f, -6.83090091e-02f, -1.88369025e-02f, -2.80800294e-02f, 4.98856790e-02f, 8.55878182e-03f, 3.77505943e-02f, 3.78415100e-02f, -1.09620191e-01f,
  2.75072362e-02f, -8.80709849e-03f, -4.04632688e-02f, 2.21031867e-02f, 7.65370280e-02f, 7.84558728e-02f, -1.62393712e-02f, 4.85099107e-02f, 5.29797003e-03f, 2.73812711e-02f,
  -3.92028362e-01f, -4.18662876e-02f, 5.70597462e-02f, -3.01606208e-02f, -3.80591415e-02f, -9.82646793e-02f, 3.64536978e-02f, 1.09810056e-02f, -2.87276022e-02f, -9.14950371e-02f,
  -1.29436767e-02f, -7.31178327e-03f, -7.59308264e-02f, 3.59533727e-02f, -5.11128791e-02f, 6.25268295e-02f, -7.45085552e-02f, 1.29098564e-01f, -9.10416152e-03f, -3.46599296e-02f,
  -1.49184644e-01f, -7.47947395e-02f, 6.18079044e-02f, 2.84849070e-02f, -1.45214414e-02f, 1.21738128e-01f, -1.14127368e-01f, -1.30520929e-02f, -1.27501696e-01f, -1.66190371e-01f,
  3.62762511e-01f, 2.28523519e-02f, -6.03658222e-02f, 4.21449682e-03f, -2.42533043e-01f, -2.27096796e-01f, -3.02192986e-01f, -1.33656226e-02f, -2.91817896e-02f, -4.97292541e-02f,
  2.63609886e-01f, 1.06559664e-01f, 2.24063873e-01f, 2.34125197e-01f, 2.80037016e-01f, -2.30334133e-01f, -2.19193429e-01f, 1.53964370e-01f, 2.99388468e-02f, 1.70258805e-02f,
  -1.64109111e-01f, -4.56549190e-02f, 2.95815051e-01f, 1.40841872e-01f, -1.32998332e-01f, 3.43608186e-02f, 9.41210240e-02f, 8.03615376e-02f, 5.72959110e-02f, -9.52158570e-02f,
  1.67480439e-01f, 1.98038071e-01f, 8.79179984e-02f, 1.03338286e-01f, 1.06089316e-01f, 1.18049011e-01f, 1.72387697e-02f, 1.71938524e-01f, 1.40180051e-01f, -8.57961085e-03f,
  1.20949090e-01f, 9.51343775e-02f, 1.74176261e-01f, 1.10006489e-01f, 4.43654396e-02f, 6.66803271e-02f, 7.62571096e-02f, 2.68660754e-01f, 1.65577963e-01f, 1.43479809e-01f,
  3.61216068e-02f, 6.29744530e-02f, 1.45981461e-01f, 8.97012949e-02f, 1.42909333e-01f, 1.20310038e-01f, 6.03194572e-02f, 7.20402971e-02f, 3.16633046e-01f, 7.16067031e-02f,
  -8.10876638e-02f, -4.43778420e-03f, 3.63484435e-02f, 2.71619763e-02f, -8.24414492e-02f, -8.59385636e-03f, -4.06372882e-02f, 1.78838018e-02f, -5.11027537e-02f, -1.08619682e-01f,
  1.25917301e-01f, -6.18577413e-02f, -1.93713792e-02f, 4.84803170e-02f, 3.86930071e-02f, 3.06870081e-02f, -8.23789835e-03f, 6.46535605e-02f, 1.31554559e-01f, -6.27093669e-03f,
  -1.30780172e-02f, 2.86972709e-03f, -5.55237718e-02f, -3.16571854e-02f, 6.46275431e-02f, 3.65122445e-02f, -6.52602464e-02f, 6.45780787e-02f, 6.40711114e-02f, -2.38400903e-02f,
  -1.06986407e-02f, 2.85563856e-01f, 8.81935507e-02f, 8.96948129e-02f, 1.42938700e-02f, 6.84801191e-02f, 7.69806281e-02f, 8.18117186e-02f, 9.22398642e-02f, 3.37259844e-02f,
  4.77729067e-02f, 7.73442313e-02f, 5.23813665e-02f, 5.39536215e-03f, 5.80219179e-03f, 2.44402494e-02f, -6.83689583e-03f, 2.69981828e-02f, -4.21770290e-03f, -5.69372326e-02f,
  -3.43548171e-02f, -1.76570415e-01f, -1.97237059e-01f, 3.50881368e-02f, -1.69255324e-02f, -2.49337740e-02f, -6.34922311e-02f, -1.11828156e-01f, 2.65272073e-02f, -1.49693400e-01f,
  -4.88175929e-01f, 4.52826284e-02f, -2.42228165e-01f, -1.23702504e-01f, -3.07197660e-01f, -2.44509876e-01f, -3.70437324e-01f, -7.62761710e-03f, 1.20546490e-01f, -1.78587198e-01f,
  -7.91436359e-02f, 4.46719192e-02f, -3.79728004e-02f, 1.26576707e-01f, -2.02210736e-03f, -3.93360332e-02f, -1.42321706e-01f, 2.88385972e-02f, -2.22799107e-01f, -1.48952380e-01f,
  -1.06518403e-01f, -2.39273887e-02f, 9.87092406e-02f, 1.95745066e-01f, -1.39552191e-01f, 4.12731059e-02f, -6.89429492e-02f, -1.02786124e-02f, -1.18860923e-01f, -9.93379429e-02f,
  -6.65091649e-02f, -1.08025908e-01f, -2.15646205e-03f, -3.36423144e-02f, -5.98087274e-02f, 1.47152022e-01f, -1.13683380e-02f, 1.79644167e-01f, 1.48155868e-01f, 2.25348640e-02f,
  9.00661722e-02f, 2.70115901e-02f, 4.50771898e-02f, 1.05395816e-01f, 1.68245081e-02f, 4.85346913e-02f, 5.41180782e-02f, 1.65340528e-02f, 3.47704403e-02f, 4.83531784e-03f,
  -1.03330784e-01f, -2.16561362e-01f, -3.05546746e-02f, 1.12760469e-01f, -2.92161340e-03f, -8.44035447e-02f, 2.78225983e-03f, 6.33930266e-02f, 3.34470719e-02f, 1.37948364e-01f,
  4.69266474e-02f, 3.16867195e-02f, 2.42408328e-02f, 1.36521515e-02f, -3.50262672e-02f, 1.46882460e-01f, -5.66776097e-02f, -6.58746660e-02f, -2.41261777e-02f, -6.80405721e-02f,
  -4.90703806e-02f, -2.09546201e-02f, -5.14737889e-02f, 3.79633233e-02f, 5.56975491e-02f, -9.53805968e-02f, -4.47093397e-02f, 4.98867817e-02f, -1.48265976e-02f, 1.12058222e-02f,
  -4.66548540e-02f, 4.32291515e-02f, 3.20200697e-02f, 6.82236478e-02f, -2.92183086e-02f, -7.50102252e-02f, -5.60520105e-02f, -4.99131754e-02f, -2.84507480e-02f, -4.47809063e-02f,
  2.09970802e-01f, -7.28617087e-02f, 2.32933145e-02f, 8.39522704e-02f, -3.41615342e-02f, 3.80782671e-02f, -3.40338871e-02f, 8.60252157e-02f, -2.74506249e-02f, -5.69274314e-02f,
  -5.79668880e-02f, 3.42117138e-02f, 5.23690842e-02f, 1.62426084e-02f, -2.41080821e-02f, -4.52090949e-02f, 2.68071629e-02f, -6.10850304e-02f, 8.14683456e-03f, 1.62753016e-02f,
  6.48351759e-02f, 4.66902666e-02f, -2.44011022e-02f, -8.71860981e-02f, 5.63799450e-03f, -7.14083090e-02f, 6.69355989e-02f, -7.98902288e-03f, 1.02315871e-02f, 5.78753799e-02f,
  1.86140701e-01f, -9.38501209e-02f, -4.72270489e-01f, -6.66569080e-03f, -9.75149348e-02f, 1.80297986e-01f, -2.13813096e-01f, -2.01037563e-02f, 6.83673099e-02f, -1.51393563e-01f,
  1.90780967e-01f, 3.26923341e-01f, 1.02761433e-01f, 1.02941185e-01f, -2.84950947e-04f, -3.40683669e-01f, -2.91211218e-01f, -1.90406337e-01f, 3.43546532e-02f, 1.10584319e-01f,
  5.74802235e-02f, -9.90523621e-02f, 1.99329555e-01f, 1.09207802e-01f, -1.87425166e-02f, 1.91074647e-02f, -7.05776140e-02f, 1.19563788e-01f, 8.16157609e-02f, -1.49537817e-01f,
  -1.21072836e-01f, -3.65887322e-02f, -2.21222965e-03f, 1.50749832e-01f, 9.87563189e-03f, -1.65047511e-01f, -1.50835454e-01f, -9.77830868e-03f, 5.60592860e-02f, 4.41223010e-02f,
  4.15476263e-02f, 2.57512815e-02f, -3.25048268e-02f, -2.03450434e-02f, -1.43236378e-02f, -3.87381539e-02f, 5.89214778e-03f, -4.06836420e-02f, 5.13517633e-02f, -3.11104208e-02f,
  5.41057810e-02f, 1.30841315e-01f, -2.83595677e-02f, 5.60241975e-02f, 1.45497071e-02f, 3.22321542e-02f, 3.70745137e-02f, 5.06321937e-02f, 5.00668623e-02f, 2.59445347e-02f,
  9.40684378e-02f, -9.90752205e-02f, -9.73933041e-02f, 1.04877923e-03f, -8.00482871e-04f, -4.08630557e-02f, -4.71827947e-02f, -4.20722701e-02f, 9.62073952e-02f, -9.86144394e-02f,
  1.38958365e-01f, -2.48542950e-02f, 6.22047596e-02f, -8.23265593e-03f, -1.95644796e-02f, 1.52967228e-02f, 2.64752079e-02f, -9.29457415e-03f, 1.05982736e-01f, -6.83107227e-02f,
  9.63812470e-02f, 5.85828461e-02f, 1.39471376e-02f, 1.05215795e-01f, -1.75381284e-02f, -7.31149167e-02f, 1.54050961e-02f, -1.31009854e-02f, 4.72368561e-02f, 4.67979498e-02f,
  -4.18297276e-02f, 2.40520127e-02f, -1.28079683e-01f, 2.16796063e-02f, 3.08417790e-02f, 7.68788978e-02f, -2.96438988e-02f, 8.53983089e-02f, 1.15513109e-01f, 2.79630050e-02f,
  7.68774599e-02f, 3.83432657e-02f, 6.26360998e-02f, -1.72599349e-02f, -1.09180231e-02f, 5.78540713e-02f, 1.61690161e-01f, 5.99448420e-02f, 7.51995817e-02f, -1.68111790e-02f,
  2.33661607e-02f, -2.67624892e-02f, 1.49585903e-02f, -3.53939682e-02f, 6.68529794e-02f, -8.43045041e-02f, -1.48077652e-01f, -3.32330936e-04f, 3.03347521e-02f, -1.51558653e-01f,
  -7.47290254e-02f, 2.77448267e-01f, -1.98505558e-02f, 6.78055584e-02f, -2.04808339e-02f, -2.32487828e-01f, -3.33972514e-01f, -8.90418515e-02f, 8.09067488e-03f, -1.42866060e-01f,
  -2.02443406e-01f, -3.34601663e-02f, 1.35787845e-01f, 2.01359600e-01f, 3.53679098e-02f, 1.70389526e-02f, 2.66237527e-01f, 2.08480403e-01f, 4.46745747e-04f, -5.96106723e-02f,
  1.73071757e-01f, 9.55708846e-02f, 2.56326586e-01f, 2.78400332e-01f, 2.22495273e-01f, 5.10555878e-02f, -3.25710326e-02f, 1.94916949e-01f, 1.87713802e-01f, 4.73858446e-01f,
  -6.12500571e-02f, 9.40584168e-02f, 1.06851608e-01f, 1.74044192e-01f, 3.22830975e-02f, 8.54786262e-02f, 3.73661891e-02f, 1.14159249e-01f, 1.09179750e-01f, 1.02878101e-01f,
  1.28641039e-01f, 8.27585757e-02f, 1.56628326e-01f, 1.06093206e-01f, 8.39242414e-02f, 1.06709033e-01f, 1.81977689e-01f, 2.60176986e-01f, 1.88035607e-01f, 1.40044555e-01f,
  2.32134148e-01f, 7.73763135e-02f, 3.41439364e-03f, 6.27191588e-02f, 1.99635312e-01f, 1.73066512e-01f, 8.05212371e-03f, 2.36149386e-01f, 3.35234068e-02f, 6.79047108e-02f,
  4.24597859e-02f, -1.52423941e-02f, -4.01341766e-02f, -6.62534758e-02f, -9.54187661e-02f, -6.27791733e-02f, -9.52517893e-03f, -3.20293149e-03f, -5.84809072e-02f, -6.31371811e-02f,
  -7.66063407e-02f, -1.14544764e-01f, -8.87240097e-02f, -3.58531252e-02f, -8.01305249e-02f, -8.10742304e-02f, -6.16002828e-02f, -3.49575616e-02f, -8.41587409e-02f, -8.52789506e-02f,
  1.88202243e-02f, -1.13405049e-01f, -8.27711001e-02f, -2.00301688e-02f, 2.63559981e-03f, -2.79174261e-02f, -4.78196181e-02f, -3.81619260e-02f, -4.43748720e-02f, -1.36566665e-02f,
  -1.37364879e-01f, 1.48625836e-01f, 9.68660265e-02f, 4.83992361e-02f, 3.00048874e-03f, 6.93616495e-02f, 7.61476830e-02f, 1.34369284e-01f, 8.77953693e-02f, 6.51233420e-02f,
  2.07584500e-02f, 3.71736400e-02f, 3.23824324e-02f, 2.05180747e-03f, -3.72062735e-02f, -1.15878722e-02f, -1.81771461e-02f, 5.71491942e-02f, 9.11968946e-02f, 2.83206534e-02f,
  9.85802710e-02f, -9.38786715e-02f, -1.24335483e-01f, -3.53148729e-02f, -3.92975509e-02f, -8.52278545e-02f, -9.28458497e-02f, -6.06895145e-03f, -1.19406939e-01f, -2.21951336e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.66590571e-01f, 4.00121182e-01f, 7.46259764e-02f, -6.56132326e-02f, -1.65515795e-01f, 8.06117617e-03f, 5.06604731e-01f, 2.44405136e-01f, -1.74434662e-01f, 1.02416106e-01f,
  -9.16308612e-02f, -4.80696797e-01f, -3.49047571e-01f, -2.82740980e-01f, 6.95823506e-03f, 1.82650775e-01f, 1.23985171e-01f, 2.48459075e-02f, -1.95469245e-01f, -1.45571262e-01f,
  -2.88996458e-01f, 2.09058121e-01f, 2.30810106e-01f, 3.06963585e-02f, 1.78958047e-02f, -3.54732215e-01f, 2.57787973e-01f, 1.68881431e-01f, -1.91068396e-01f, -1.69739872e-01f,
  1.03960544e-01f, 3.49132091e-01f, -5.58877707e-01f, -2.68748492e-01f, -1.62559617e-02f, 6.88180029e-02f, 8.78129825e-02f, 1.61839709e-01f, 8.62413496e-02f, 5.95045649e-02f,
  -6.89876825e-02f, 2.51013339e-02f, -2.83400342e-02f, 2.22887099e-02f, 1.41941905e-01f, 4.65836283e-03f, 1.89152136e-01f, 1.94175199e-01f, 7.13549182e-02f, 6.98793679e-02f,
  -2.04001710e-01f, 3.77529599e-02f, 6.33574724e-02f, -8.41676071e-02f, 4.23684381e-02f, -3.63625228e-01f, 2.42167395e-02f, -5.14968261e-02f, -1.52491167e-01f, 2.16909703e-02f,
  -4.98401634e-02f, -4.60836738e-02f, -1.13891438e-01f, 3.91722322e-02f, 1.59058437e-01f, -5.94492629e-02f, 4.17641290e-02f, 2.32626945e-02f, -3.48582193e-02f, 1.23884022e-01f,
  5.95164374e-02f, 3.74504216e-02f, 1.11180797e-01f, 4.21264656e-02f, -1.79219171e-02f, -5.20877950e-02f, -1.58271473e-02f, -9.36985947e-03f, -6.04950599e-02f, 1.25340030e-01f,
  2.41836477e-02f, -3.17915305e-02f, 8.50438774e-02f, -3.06513738e-02f, -2.91234627e-02f, -6.01287708e-02f, 1.49835404e-02f, -2.15812214e-02f, -2.25987881e-02f, 1.11242890e-01f,
  7.09203035e-02f, -3.15234989e-01f, -5.95916174e-02f, 2.67519858e-02f, 1.05888486e-01f, 1.56664308e-02f, -5.68646714e-02f, -1.02007605e-01f, 4.10439707e-02f, 3.89459729e-02f,
  -9.13616195e-02f, 1.28535479e-01f, 2.12269381e-01f, 6.99577630e-02f, -1.18461186e-02f, -8.36032033e-02f, 8.07672590e-02f, -6.30513951e-02f, -5.18293306e-02f, 1.28187109e-02f,
  2.94536706e-02f, -7.91838989e-02f, 2.94748787e-02f, -8.07110742e-02f, 6.07832037e-02f, -3.30067784e-01f, 3.67713273e-02f, -7.02476734e-03f, -7.18572065e-02f, 8.60511959e-02f,
  5.71726441e-01f, -6.47408143e-02f, -8.97088408e-01f, 1.00529224e-01f, -2.15930328e-01f, -1.74079686e-01f, -6.92346506e-03f, 3.64731997e-01f, 2.19599739e-01f, -2.91573126e-02f,
  1.41590893e-01f, 3.07463795e-01f, 2.31110379e-01f, 1.42369583e-01f, 1.66162759e-01f, -2.53665388e-01f, -3.82142037e-01f, -2.57663786e-01f, 1.15508951e-01f, 1.35493055e-01f,
  6.75332174e-02f, 5.89915775e-02f, 2.48058751e-01f, 1.66211218e-01f, -3.12750280e-01f, -9.58016329e-03f, -3.55877519e-01f, -3.34575117e-01f, -2.09966928e-01f, -8.62246871e-01f,
  -4.25289124e-01f, -1.11081958e-01f, 1.83941871e-01f, 1.36074752e-01f, -1.38447404e-01f, 1.51503235e-01f, 1.62309319e-01f, 4.47695181e-02f, 1.54439002e-01f, -1.01326418e-03f,
  -5.78155667e-02f, 1.51406199e-01f, 4.50380147e-02f, 5.57180382e-02f, -1.50550604e-01f, 2.53512822e-02f, 1.07464336e-01f, 5.08063547e-02f, -1.24165237e-01f, -5.03910929e-02f,
  1.30342797e-03f, -1.41169906e-01f, -1.04171030e-01f, 3.54976915e-02f, 1.29908785e-01f, -7.82193914e-02f, -2.30217930e-02f, -1.45130306e-01f, -1.26028612e-01f, -1.27581730e-01f,
  1.73474513e-02f, -6.10039271e-02f, -3.98080945e-02f, 9.38314199e-02f, 1.45841956e-01f, -8.06472600e-02f, -1.88814789e-01f, -4.24828678e-02f, 2.78448686e-02f, -9.74177662e-03f,
  1.79449730e-02f, 6.93234475e-03f, 6.31131530e-02f, -6.68663681e-02f, 6.79586977e-02f, -9.38328803e-02f, -9.95661020e-02f, -3.98677103e-02f, -2.10753512e-02f, 1.83284268e-01f,
  8.47940966e-02f, -2.63693407e-02f, -1.19655900e-01f, 4.49699908e-03f, -1.02220275e-01f, 8.33849609e-02f, -1.42977700e-01f, 1.41357943e-01f, 5.10426946e-02f, -3.63810244e-03f,
  2.81304508e-01f, 9.78116617e-02f, -8.28340556e-03f, 2.84349434e-02f, -1.72371745e-01f, -5.58476597e-02f, -7.23339468e-02f, -1.17890343e-01f, -1.02083035e-01f, -2.09870990e-02f,
  3.88169140e-02f, -5.06154187e-02f, -5.59177585e-02f, -4.08482477e-02f, -5.37121994e-03f, 4.18423675e-02f, 3.48043852e-02f, -1.43157952e-02f, -3.52801643e-02f, 6.30125552e-02f,
  1.38011396e-01f, 1.85777381e-01f, 1.56765968e-01f, 1.67271316e-01f, -2.94052176e-02f, 1.02748200e-01f, -3.35242413e-03f, -8.09349790e-02f, 2.95919199e-02f, 2.41191566e-01f,
  -2.38809928e-01f, -1.56044409e-01f, -1.69978421e-02f, -1.11893982e-01f, -1.54608050e-02f, 3.09472561e-01f, 1.31957969e-02f, 2.65299052e-01f, 1.07249662e-01f, -1.78520501e-01f,
  1.80240460e-02f, -6.84825704e-02f, -1.56066194e-01f, 5.06780222e-02f, -7.58779198e-02f, -3.08572799e-01f, -3.57281655e-01f, -2.02563092e-01f, 3.15740645e-01f, 4.05749887e-01f,
  2.12477803e-01f, -1.49835601e-01f, -5.39236292e-02f, 8.94978046e-02f, -3.10819119e-01f, -2.27821484e-01f, -5.10775447e-01f, -3.33364427e-01f, -1.34546697e-01f, -7.16490686e-01f,
  -1.00590788e-01f, 2.16684908e-01f, -1.00571878e-01f, -1.72409594e-01f, -2.05465749e-01f, 2.39646714e-03f, 9.86477807e-02f, -2.12478876e-01f, -1.06412224e-01f, 5.92791513e-02f,
  -1.49708167e-01f, 7.45302364e-02f, -6.41193613e-02f, 4.97127436e-02f, 1.77622035e-01f, 1.10173844e-01f, 8.29120204e-02f, 1.75899602e-02f, -2.10778922e-01f, -1.73764363e-01f,
  -1.77043736e-01f, -3.20345283e-01f, -2.39713088e-01f, 1.43843312e-02f, 3.53254415e-02f, -1.32638693e-01f, -6.83585033e-02f, -5.15232682e-02f, -2.05800936e-01f, -5.40578365e-01f,
  -1.31922485e-02f, 4.86436337e-02f, 4.21867520e-02f, -2.29233671e-02f, 3.26136164e-02f, -2.91192979e-02f, 9.04228073e-03f, 5.32709621e-02f, 4.51991521e-02f, -4.40638103e-02f,
  8.23895186e-02f, 6.29295558e-02f, 1.33155018e-01f, 6.32297760e-03f, -5.93629992e-03f, -1.08405434e-01f, -3.41040455e-03f, -1.05739750e-01f, -1.02768630e-01f, -4.66924980e-02f,
  -9.04733166e-02f, -1.22349553e-01f, -1.21934349e-02f, -2.37742215e-02f, -8.20981897e-03f, -4.24227528e-02f, -2.30877977e-02f, 6.51464760e-02f, -2.44081840e-02f, 2.79854208e-01f,
  -5.25515564e-02f, 1.34677723e-01f, -1.43103108e-01f, -1.57167744e-02f, -2.55825575e-02f, -1.09015107e-01f, -1.41578972e-01f, -1.16983037e-02f, 1.06820352e-02f, 1.26430104e-02f,
  -5.73042668e-02f, 1.59782562e-02f, 7.28703439e-02f, 2.61893719e-02f, 1.73220634e-01f, 2.93941163e-02f, -1.44156426e-01f, -3.08647633e-01f, -4.59241010e-02f, 6.36051521e-02f,
  -1.81980848e-01f, -2.01639310e-01f, -1.46327004e-01f, -1.20993271e-01f, -8.01672563e-02f, 1.27891842e-02f, -1.96601413e-02f, -1.80105120e-01f, -2.36215934e-01f, -3.73575896e-01f,
  5.11331737e-01f, 3.56202781e-01f, 1.40984386e-01f, 3.33030701e-01f, 3.76022190e-01f, -9.89296287e-02f, -2.19222963e-01f, -3.94510239e-01f, 1.11249261e-01f, 1.17798090e-01f,
  3.17235887e-01f, 4.83893417e-03f, -6.97510839e-02f, -2.63917595e-01f, -5.08464098e-01f, -2.96698958e-01f, -3.73829663e-01f, -4.54112798e-01f, -6.03388965e-01f, -2.50575066e-01f,
  -1.33651510e-01f, -1.97619535e-02f, -9.11541432e-02f, -2.73318976e-01f, 3.68930250e-01f, -6.98112464e-03f, 1.35526344e-01f, 3.85020345e-01f, 5.53057976e-02f, 2.63228655e-01f,
  2.73419917e-01f, 1.34989977e-01f, -2.20212579e-01f, 1.57960013e-01f, 2.55015075e-01f, -1.21225595e-01f, -5.84380850e-02f, -2.16469001e-02f, 8.11540484e-02f, -1.06383130e-01f,
  1.96629301e-01f, 1.41571909e-01f, 1.78758338e-01f, -4.52510975e-02f, 7.59863257e-02f, -5.03215007e-02f, -1.46261856e-01f, -2.76435494e-01f, -1.23317376e-01f, 1.08338326e-01f,
  1.03310011e-01f, 1.73282653e-01f, 2.61915982e-01f, -1.74130946e-01f, -9.73112360e-02f, 5.86879216e-02f, 2.25327522e-01f, 9.72100124e-02f, -1.51208565e-01f, 2.17749640e-01f,
  -7.95713887e-02f, 6.41813204e-02f, 7.51719996e-02f, 7.13490173e-02f, -1.14985351e-02f, -1.03016486e-02f, 6.43200753e-03f, -4.93660979e-02f, -1.04075067e-01f, -1.92735493e-02f,
  -7.63757247e-03f, 2.19156556e-02f, -1.67703748e-01f, 2.09605545e-02f, -3.93398404e-02f, 1.17675424e-01f, 5.59853427e-02f, -6.19186424e-02f, -1.53080411e-02f, 6.78823292e-02f,
  -8.09722468e-02f, 3.70700806e-02f, 1.16899297e-01f, -9.90090743e-02f, -2.76468378e-02f, -2.25208537e-03f, -4.68065180e-02f, 5.13360314e-02f, 4.78236005e-02f, -1.68792512e-02f,
  1.05636783e-01f, -2.68680900e-01f, 9.08596069e-02f, -1.03904709e-01f, 4.06522006e-02f, 1.47576705e-01f, 1.44902706e-01f, 1.47202192e-02f, 1.35393471e-01f, -8.63889307e-02f,
  -1.13332029e-02f, -2.14599699e-01f, 4.11148518e-02f, -8.12824294e-02f, -2.18069479e-01f, -3.43583822e-02f, -2.92535629e-02f, 9.09861270e-03f, -1.97184384e-01f, 1.94253281e-01f,
  1.40709020e-02f, -2.25003421e-01f, -3.43725115e-01f, -2.17914656e-01f, -1.95804741e-02f, -2.38595888e-01f, -9.08381045e-02f, -2.30455142e-03f, -1.56851903e-01f, -1.58419102e-01f,
  7.19625533e-01f, -3.05795789e-01f, 3.66864145e-01f, 2.26504430e-01f, 1.39722034e-01f, 3.05591792e-01f, 2.73839861e-01f, -1.94581226e-02f, 1.21163751e-03f, 4.67237122e-02f,
  3.46665159e-02f, -1.18265696e-01f, -1.81475252e-01f, -2.07005702e-02f, 3.13633354e-03f, -1.47925049e-01f, -9.51347277e-02f, 2.04356909e-01f, 1.90025657e-01f, -1.46324700e-02f,
  -2.01431915e-01f, -1.87440038e-01f, -9.21806172e-02f, -1.97457924e-01f, -2.08170563e-01f, -8.31515044e-02f, -1.38371632e-01f, -1.06943689e-01f, -2.17792407e-01f, -2.48360023e-01f,
  1.74021900e-01f, 2.96349138e-01f, 1.75557077e-01f, 8.93410072e-02f, 8.41183290e-02f, -1.22771282e-02f, 8.89146477e-02f, 6.79393634e-02f, 6.91857189e-02f, 1.38181925e-01f,
  9.43787843e-02f, 2.38470547e-02f, -3.54241729e-02f, 8.03348888e-03f, 2.08894193e-01f, 1.36721849e-01f, 4.03989339e-03f, 6.34050071e-02f, 4.54546213e-02f, -9.40342806e-03f,
  -7.80931041e-02f, 9.73859802e-02f, 1.22107968e-01f, -2.64759921e-02f, -3.08262333e-02f, 2.65858322e-02f, 1.51838465e-02f, 5.76287359e-02f, 7.83736184e-02f, -1.87812292e-03f,
  -1.61606416e-01f, -9.60924253e-02f, 8.54981169e-02f, -4.19720896e-02f, -7.08393902e-02f, -1.02128252e-01f, 1.29958875e-02f, 5.22278287e-02f, -8.71407241e-02f, -1.84810191e-01f,
  -2.87179649e-02f, 3.92128825e-02f, -3.08024697e-02f, -4.57702875e-02f, -2.92136776e-03f, 1.30438795e-02f, 7.56707489e-02f, 5.83429746e-02f, -7.67464982e-03f, 2.51259152e-02f,
  1.48750432e-02f, -1.12471119e-01f, -1.73151597e-01f, -6.73996583e-02f, -3.11456695e-02f, 1.69758752e-01f, -2.55918261e-02f, -8.75019431e-02f, -1.61090255e-01f, -1.44420862e-01f,
  -5.76622486e-02f, 2.61678874e-01f, 4.78625223e-02f, -3.53826880e-02f, 1.29031569e-01f, -1.48836687e-01f, 1.34993298e-02f, 4.15170342e-02f, 1.54401764e-01f, 1.55655265e-01f,
  1.00774847e-01f, -2.23082956e-02f, -6.44695759e-02f, -7.62774125e-02f, 1.40489787e-01f, 8.24083909e-02f, -4.47197072e-03f, 1.33937836e-01f, 6.47674426e-02f, 4.80564758e-02f,
  -1.61785260e-01f, 1.23993896e-01f, 2.12002441e-01f, 2.07769275e-02f, -1.50227398e-01f, 9.54037011e-02f, -2.23539881e-02f, 7.19141960e-02f, 1.60934851e-01f, -1.40332714e-01f,
  8.58905017e-01f, 2.66442686e-01f, 3.63767296e-01f, 3.91879380e-01f, 3.51076543e-01f, 4.88477379e-01f, 4.88998860e-01f, 3.66978049e-01f, 8.41518864e-02f, 1.04354158e-01f,
  3.01803023e-01f, -1.84568446e-02f, -3.79941687e-02f, -1.61045104e-01f, 3.76373436e-03f, -8.82034600e-02f, -1.06950656e-01f, 3.81534919e-02f, 1.43775299e-01f, 2.27731884e-01f,
  -1.56880319e-01f, 8.00402742e-03f, 8.83956552e-02f, -3.26752081e-03f, -8.52633640e-02f, -1.16612203e-01f, -7.30930492e-02f, 7.07836300e-02f, -3.67538966e-02f, -5.33813655e-01f,
  -4.34787646e-02f, 3.55892479e-01f, -5.58176562e-02f, -1.21515870e-01f, -4.78324145e-02f, -2.14387134e-01f, 2.03072708e-02f, -4.87949066e-02f, -6.87722713e-02f, -9.90718976e-02f,
  -9.13114473e-02f, -6.25854358e-02f, -2.61156037e-02f, -1.49229154e-01f, 7.83875212e-03f, 1.72813591e-02f, -1.83620691e-01f, 2.48798095e-02f, -9.77778137e-02f, -5.86030744e-02f,
  -2.79606227e-02f, 1.08279869e-01f, 2.55593061e-01f, 1.10263892e-01f, -4.68848506e-03f, 1.30561560e-01f, 7.85957873e-02f, 7.36209676e-02f, 1.51049837e-01f, -1.33553967e-02f,
  1.73921749e-01f, 2.61153638e-01f, 8.98904577e-02f, 3.83223444e-02f, -4.84884307e-02f, -4.21675155e-03f, -1.12030163e-01f, 1.46428244e-02f, 1.70115501e-01f, 1.90500282e-02f,
  6.64009154e-03f, 3.82064213e-03f, 2.87100095e-02f, 7.16491193e-02f, -3.31376754e-02f, 2.10521296e-02f, -5.65029010e-02f, -1.71952636e-03f, 1.19581530e-02f, -1.49695545e-01f,
  -7.11695477e-02f, -1.91264115e-02f, -4.52984646e-02f, -9.92430151e-02f, -9.40572843e-03f, 2.66968831e-02f, -5.46955541e-02f, 8.71215481e-03f, 7.99864978e-02f, 1.59134597e-01f,
  -4.50119823e-01f, 2.84396291e-01f, -1.23794094e-01f, -1.00910738e-01f, -9.46158916e-02f, -5.46228811e-02f, 1.40495926e-01f, -7.40404055e-02f, -1.25876307e-01f, -2.09612250e-02f,
  1.20373301e-01f, 2.84955204e-02f, 9.13707167e-02f, 3.92235778e-02f, -3.58692221e-02f, -3.30923265e-03f, -8.30240175e-02f, -3.78897339e-02f, 1.64094586e-02f, -9.64753479e-02f,
  -5.58162779e-02f, 3.62861641e-02f, 2.06679359e-01f, 1.50823846e-01f, -1.81550179e-02f, -5.37187187e-03f, 6.11745231e-02f, 6.42340183e-02f, 9.05490890e-02f, 1.48457848e-02f,
  -7.95943677e-01f, 3.78450453e-01f, -3.41136128e-01f, -2.97907293e-01f, -1.63389385e-01f, 1.17513826e-02f, 3.75258267e-01f, 1.29721060e-01f, -2.04747334e-01f, 2.32927471e-01f,
  8.94961208e-02f, -3.40495706e-02f, -1.39626905e-01f, 2.12383512e-02f, 1.75586040e-03f, 2.14842305e-01f, -1.42474249e-01f, -2.78300315e-01f, -1.07656352e-01f, 1.00327946e-01f,
  1.24231435e-01f, -1.57231037e-02f, -2.73448944e-01f, -1.49301827e-01f, -1.18630566e-01f, 5.67115545e-02f, -1.10310018e-01f, -1.59477532e-01f, 7.85188079e-02f, -2.28540972e-01f,
  1.38646498e-01f, -3.45212609e-01f, 2.90585961e-03f, -1.63805336e-01f, 5.10579385e-02f, -1.10264689e-01f, -4.90237698e-02f, -9.52999070e-02f, 1.03101194e-01f, 1.08327851e-01f,
  -2.46416237e-02f, -8.72469842e-02f, -1.06390238e-01f, 7.62944017e-03f, 2.71570850e-02f, -1.14615589e-01f, -1.13570787e-01f, -1.71335891e-01f, -1.17233783e-01f, 1.01857789e-01f,
  1.74250707e-01f, -1.52988955e-01f, -1.72026962e-01f, 6.18706942e-02f, -5.14357351e-02f, -1.36848152e-01f, 6.76347390e-02f, 4.47684713e-02f, 1.19634792e-01f, 2.51061618e-01f,
  8.48276466e-02f, 1.16841897e-01f, -1.14835002e-01f, 9.01071727e-02f, 2.96575075e-04f, -2.71287318e-02f, -5.49004413e-02f, 1.30391181e-01f, 4.04814035e-02f, -1.31533474e-01f,
  8.86468962e-02f, 1.30639169e-02f, -1.59837380e-02f, 4.22805808e-02f, -2.63373032e-02f, -9.96401086e-02f, -8.99308324e-02f, 9.73401293e-02f, 8.82181746e-04f, -7.96972737e-02f,
  -7.61152133e-02f, -5.08183688e-02f, 1.96898580e-02f, -4.60626222e-02f, -1.13806240e-01f, -4.15654108e-02f, -5.19209281e-02f, -1.60939265e-02f, 3.49781252e-02f, -1.09020397e-01f,
  2.95030385e-01f, -3.00310612e-01f, -8.93975347e-02f, -5.27063161e-02f, 1.94264129e-02f, -3.40287089e-02f, -2.86474898e-02f, 6.45280182e-02f, 1.20344914e-01f, 1.01556912e-01f,
  1.17454991e-01f, 1.76224947e-01f, 3.77227962e-02f, 4.88009714e-02f, 1.27106369e-01f, 6.66446909e-02f, 5.06948940e-02f, -1.44963311e-02f, 4.28574020e-03f, 1.02410324e-01f,
  1.50535107e-01f, 1.40613198e-01f, 1.46149039e-01f, 1.32723704e-01f, 1.33678988e-01f, -3.04746383e-04f, 9.45197716e-02f, 6.43686503e-02f, 6.66023269e-02f, 4.38251734e-01f,
  7.59320021e-01f, -2.56365955e-01f, -5.77768266e-01f, 2.09607512e-01f, -1.73924342e-01f, 6.05467968e-02f, -5.60290478e-02f, 1.14950858e-01f, 1.36992484e-01f, -2.16292888e-01f,
  -2.29473680e-01f, -1.35743603e-01f, -1.12577267e-01f, -1.61765575e-01f, -1.28184548e-02f, -9.88518447e-02f, -1.31796882e-01f, -7.93409646e-02f, 3.37839484e-01f, 1.53408408e-01f,
  1.54792488e-01f, 2.27188975e-01f, 2.82985628e-01f, 1.49801716e-01f, -3.16965640e-01f, 2.41240449e-02f, -3.31343949e-01f, -3.92327845e-01f, -2.19255641e-01f, -6.17908120e-01f,
  -3.42071652e-02f, -2.47191653e-01f, -1.40983760e-01f, -2.41445750e-02f, -1.51745394e-01f, 1.53400684e-02f, -9.14831161e-02f, -6.41070083e-02f, -3.52003276e-02f, -3.66645418e-02f,
  -2.41652712e-01f, 4.15163822e-02f, 1.55485906e-02f, -2.36539566e-03f, 2.14073509e-01f, 9.12928209e-02f, -2.57836524e-02f, -2.19357073e-01f, -1.21233687e-01f, -3.59454900e-02f,
  -8.34998861e-02f, -1.93992957e-01f, -7.94565082e-02f, -1.56024173e-01f, -1.79257855e-01f, -1.23595960e-01f, -3.52882475e-01f, -2.28355125e-01f, -1.23569816e-01f, -5.38507327e-02f,
  -5.02839014e-02f, -3.25438939e-02f, 8.40829536e-02f, 2.82099731e-02f, 6.78196996e-02f, 6.06286936e-02f, 1.21686786e-01f, 1.01674564e-01f, -2.10808087e-02f, -6.92588463e-02f,
  4.65310644e-03f, -9.59276408e-02f, -8.22169557e-02f, -5.65422587e-02f, -6.77026287e-02f, 1.57758482e-02f, 2.96866475e-03f, -2.41290294e-02f, -1.24325149e-01f, 7.55502880e-02f,
  7.05171889e-03f, -5.67420982e-02f, -5.12436591e-02f, -5.57036325e-02f, -9.69644487e-02f, -1.54391721e-01f, 6.11059144e-02f, 2.35397667e-02f, 6.90524876e-02f, 6.30934909e-02f,
  3.74395728e-01f, -1.90590829e-01f, 1.00709595e-01f, -5.07741831e-02f, 5.36603779e-02f, -4.06753905e-02f, -2.45098434e-02f, -6.02913089e-02f, -1.19489636e-02f, 1.13372877e-01f,
  -2.18586251e-03f, -5.98849729e-04f, -6.89239129e-02f, -8.74478146e-02f, 1.20899782e-01f, 1.08544096e-01f, -6.51095733e-02f, 5.23479842e-02f, 4.75968681e-02f, 9.22726374e-03f,
  -1.05100637e-02f, 2.35417262e-01f, 2.51121551e-01f, 7.86223263e-02f, 1.28088519e-01f, 2.34156892e-01f, 1.07042097e-01f, 1.50526628e-01f, 1.86804488e-01f, 3.72759640e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.55531085e-01f, 1.69474229e-01f, 2.65726984e-01f, 3.10042590e-01f, -4.91756201e-02f, 1.61550850e-01f, 1.57676160e-01f, 3.53650242e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.13193910e-02f, 2.83998810e-02f, 1.76418107e-02f, -3.19042742e-01f, 5.74426875e-02f, -1.46705166e-01f, 1.45817772e-01f, -3.97189483e-02f, -5.06573804e-02f, 1.85534537e-01f,
  3.36046703e-03f, -1.83097765e-01f, -1.69554457e-01f, -1.26920819e-01f, -1.28943250e-01f, 1.46584004e-01f, -2.93330587e-02f, 1.63837180e-01f, 5.93021624e-02f, 1.19484447e-01f,
  -1.27144262e-01f, -1.04602978e-01f, -1.72352165e-01f, 1.43655673e-01f, -7.26866629e-03f, 1.23255335e-01f, -6.85585141e-02f, -8.50918237e-03f, 6.37113079e-02f, -2.17557907e-01f,
  3.36596668e-01f, -3.49384606e-01f, 1.37378722e-01f, -9.67841074e-02f, -4.44327779e-02f, 1.56436145e-01f, -1.40571639e-01f, 1.62060231e-01f, 2.09233891e-02f, 1.34865776e-01f,
  5.07077873e-02f, -1.18822366e-01f, -9.79714021e-02f, 4.79842052e-02f, 2.31414497e-01f, 4.10213992e-02f, -1.18196428e-01f, -2.94392020e-01f, -2.06898332e-01f, 4.86711338e-02f,
  -2.51195312e-01f, 1.19280834e-02f, 3.08194220e-01f, -4.37445864e-02f, 7.78797120e-02f, -4.69761714e-02f, -2.43746936e-01f, 4.24114972e-01f, 4.76297596e-03f, -2.31683597e-01f,
  -1.61077961e-01f, -1.73936859e-01f, -6.23860210e-02f, 2.50591874e-01f, 2.49654397e-01f, -3.13385040e-01f, 1.34678017e-02f, -2.19769225e-01f, 6.61219060e-02f, -1.74375981e-01f,
  -1.25819817e-01f, -3.67616192e-02f, 5.07511199e-02f, 1.66553125e-01f, -4.04928885e-02f, -1.36467675e-02f, 7.85600245e-02f, 1.05871603e-01f, -1.69532478e-01f, 2.76110675e-02f,
  3.26046124e-02f, -3.16742212e-02f, 1.91428453e-01f, 1.60852507e-01f, 5.83487302e-02f, -4.87704240e-02f, 1.71251565e-01f, 1.15925986e-02f, -4.79914516e-01f, 2.98532009e-01f,
  1.68874130e-01f, -3.40105444e-01f, -9.80370212e-03f, 2.06989065e-01f, -1.30554184e-01f, -9.60085988e-02f, -6.19754521e-03f, 4.77137417e-02f, -3.09278760e-02f, 2.45183572e-01f,
  1.76286876e-01f, -4.45403419e-02f, -2.81424243e-02f, -1.78159356e-01f, 2.91488886e-01f, -3.46045084e-02f, 2.34399915e-01f, 2.02267859e-02f, 1.54193759e-01f, -1.21569321e-01f,
  2.68603414e-02f, -2.78422594e-01f, -1.67438269e-01f, -1.50583804e-01f, -5.17519452e-02f, 1.37270633e-02f, 1.28424495e-01f, 8.25197548e-02f, 1.53900504e-01f, 1.78972688e-02f,
  -4.13437009e-01f, 9.81701631e-03f, -2.86416635e-02f, 5.00057004e-02f, -9.58419889e-02f, -2.19162241e-01f, -1.75846025e-01f, 6.80088401e-02f, -3.12607810e-02f, -2.28858411e-01f,
  -7.48669878e-02f, -9.06733274e-02f, 2.12195933e-01f, -1.55763909e-01f, -2.44076237e-01f, -1.68154195e-01f, 1.35520011e-01f, -8.45853984e-02f, 1.12060765e-02f, 7.67228985e-03f,
  5.09264246e-02f, 2.11775884e-01f, -1.27492890e-01f, -4.61575419e-01f, -2.81723112e-01f, -1.33673176e-01f, -1.50973424e-01f, 4.76077013e-03f, 4.98305187e-02f, 9.36823711e-02f,
  2.18020514e-01f, 4.25276570e-02f, -4.90767449e-01f, -1.76689550e-01f, 3.88273835e-01f, 2.34578982e-01f, 4.31422032e-02f, -1.76995903e-01f, -2.75215507e-01f, -6.67030662e-02f,
  -7.07431957e-02f, -1.76211640e-01f, -1.68814957e-01f, -1.46877587e-01f, -1.26886815e-01f, -3.88512276e-02f, 5.56013212e-02f, -1.20261894e-03f, -1.08144872e-01f, -5.53011596e-02f,
  -1.19507164e-01f, 2.70894729e-02f, -9.22429413e-02f, 1.38588741e-01f, -4.07231601e-05f, 1.38954028e-01f, -6.61025569e-02f, -1.06249526e-01f, 2.78901249e-01f, -1.35317728e-01f,
  -3.46586466e-01f, -3.33366077e-03f, 7.46542886e-02f, -3.56816016e-02f, -4.85166572e-02f, -2.67850518e-01f, 1.61758557e-01f, 3.30316335e-01f, -3.16934049e-01f, -5.98716438e-02f,
  1.99627534e-01f, 6.67575970e-02f, -2.72907883e-01f, -4.27932441e-02f, -1.69198185e-01f, 1.91564471e-01f, 1.93620443e-01f, 7.96713531e-02f, 7.38479495e-02f, -5.86065985e-02f,
  -4.69846353e-02f, -4.07271534e-02f, 6.07896298e-02f, 6.61532804e-02f, 1.75907433e-01f, -1.79282743e-02f, 1.93452120e-01f, -1.48315072e-01f, -6.17682897e-02f, -1.03951916e-01f,
  -1.31625548e-01f, -1.22131571e-01f, 1.20351138e-02f, 1.74448997e-01f, 9.64784473e-02f, -3.32020193e-01f, 2.36627460e-01f, 2.20138699e-01f, -1.84239939e-01f, 2.95175165e-01f,
  1.78983539e-01f, 1.60509214e-01f, -3.80018294e-01f, 4.00463790e-01f, 1.67969093e-01f, -3.69911075e-01f, 8.00286829e-02f, -4.28376310e-02f, 1.00546911e-01f, -4.18845564e-02f,
  1.12147234e-01f, 1.53045565e-01f, 1.30833730e-01f, 3.45737115e-02f, -2.68686917e-02f, 7.17431605e-02f, 2.50368655e-01f, 2.69901723e-01f, 1.90597221e-01f, 9.09723192e-02f,
  1.13329090e-01f, -9.78166759e-02f, -1.69636354e-01f, -2.96959519e-01f, 3.84466082e-01f, 2.67584622e-01f, 1.37327895e-01f, 3.54577638e-02f, -1.68117270e-01f, 6.08666897e-01f,
  3.03472281e-01f, -2.96890855e-01f, -1.35817349e-01f, 3.40549760e-02f, 1.02053568e-01f, -1.76047891e-01f, -1.26602799e-01f, 2.33261138e-01f, 4.77065193e-03f, -1.86331913e-01f,
  -5.08517586e-02f, -1.55705377e-01f, 2.50301901e-02f, 7.63803720e-02f, -1.40000314e-01f, 5.24012782e-02f, 7.69524649e-02f, -1.89041108e-01f, 4.34742644e-02f, 1.07267492e-01f,
  -1.53802663e-01f, 4.34183180e-01f, -2.30629817e-02f, 2.73979276e-01f, 7.72380643e-03f, 1.24859646e-01f, -1.81829646e-01f, -1.28139734e-01f, -2.16398060e-01f, -7.24821240e-02f,
  -9.14575532e-02f, -4.02884483e-01f, 5.04380800e-02f, -8.99147391e-02f, -1.57446340e-01f, -1.71876058e-01f, -2.15081945e-02f, -1.62100211e-01f, -1.49346069e-01f, -5.18510230e-02f,
  -1.91320926e-01f, -9.30360779e-02f, 8.57345536e-02f, -7.15802843e-03f, -8.21968839e-02f, -4.38858792e-02f, -2.05201679e-03f, 3.08434218e-02f, -1.08943824e-02f, 6.38746247e-02f,
  -3.59724090e-02f, 6.78612143e-02f, 1.47078604e-01f, 1.61462706e-02f, -1.05440870e-01f, -8.98435488e-02f, 4.82232943e-02f, 5.76802529e-02f, -1.11312993e-01f, 4.34527583e-02f,
  5.49541041e-02f, 1.55632183e-01f, -1.09298244e-01f, -6.42008521e-03f, 2.17150718e-01f, 1.92875296e-01f, -1.69866756e-01f, 1.87987685e-01f, -1.48808658e-01f, -2.63475478e-01f,
  7.16230050e-02f, -1.68985039e-01f, 2.22873598e-01f, -1.69298798e-01f, 2.04478145e-01f, -1.90137535e-01f, -1.67978585e-01f, 1.03964947e-01f, 9.53540206e-02f, 6.88522309e-02f,
  -2.66160257e-02f, -8.90678614e-02f, -1.03118531e-01f, 3.12207311e-01f, -1.07074082e-02f, -3.11805103e-02f, -2.13982433e-01f, -3.95101085e-02f, -6.83915168e-02f, 9.83023494e-02f,
  1.57585829e-01f, 1.18925655e-02f, 1.38742745e-01f, 1.61091566e-01f, -1.12555318e-01f, -9.28011909e-03f, 3.44239503e-01f, 3.17885205e-02f, -4.06708904e-02f, -2.64465153e-01f,
  -3.23308885e-01f, -3.60464334e-01f, -5.44722099e-03f, 1.28879219e-01f, -2.06721630e-02f, 1.48649644e-02f, 4.44537997e-02f, -7.76001066e-02f, -2.35054493e-02f, 2.06721202e-02f,
  1.22086614e-01f, 6.43982813e-02f, 2.76591897e-01f, -9.51736197e-02f, -2.01734275e-01f, 1.03183854e-02f, -3.78809385e-02f, 2.29631051e-01f, 3.09770852e-01f, -7.47699151e-03f,
  6.64357468e-02f, 5.46475612e-02f, -2.55941711e-02f, -5.67506030e-02f, -8.96111131e-02f, 5.69142960e-02f, 1.06924862e-01f, -4.27477092e-01f, 2.75475025e-01f, 5.13910115e-01f,
  1.08776793e-01f, -1.62951633e-01f, -9.01696235e-02f, -6.65692091e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -5.04540354e-02f, 3.14047158e-01f, -3.44500653e-02f, 2.40203515e-01f, 3.62841450e-02f, -1.42446458e-01f, 4.44518715e-01f, -2.37478808e-01f, 1.80698097e-01f, -1.29422814e-01f,
  3.67954820e-01f, -1.26404375e-01f, 1.38479292e-01f, -1.77824080e-01f, 3.90227377e-01f, -1.44976959e-01f, 1.51553735e-01f, -1.97158232e-01f, 1.17180131e-01f, 8.13295227e-03f,
  7.47396231e-01f, -4.99025732e-02f, -3.73665318e-02f, 1.41231924e-01f, 7.42462873e-01f, -3.99883777e-01f, 1.51848346e-01f, 6.74787223e-01f, -1.74395051e-02f, -1.05234347e-01f,
  -2.78410733e-01f, -6.82917655e-01f, -7.31071411e-03f, -6.55200005e-01f, -1.61079094e-01f, 4.30778384e-01f, 4.80979204e-01f, 9.14753526e-02f, 8.14215392e-02f, -1.10889830e-01f,
  2.07064614e-01f, -3.34217608e-01f, -3.82297277e-01f, 2.06103235e-01f, 1.57836825e-01f, 3.64898406e-02f, 2.28148788e-01f, -5.68515837e-01f, -3.86328548e-01f, -4.06039327e-01f,
  2.83356518e-01f, -2.20712900e-01f, -2.12336928e-01f, -1.37608349e-01f, 6.47577703e-01f, -5.51333651e-03f, -1.16038814e-01f, 3.77179384e-01f, 3.85784566e-01f, 6.99231207e-01f,
  -1.52282968e-01f, -3.50871086e-02f, 9.78291258e-02f, 9.66972709e-02f, 6.51220083e-02f, -2.64142334e-01f, -2.06182133e-02f, 3.06379749e-03f, 3.95696461e-02f, -6.61286861e-02f,
  2.07049504e-01f, -2.16987245e-02f, -5.88463917e-02f, -2.76398771e-02f, -1.21933438e-01f, 2.38485783e-01f, 1.81793258e-01f, -1.19377680e-01f, -1.10634804e-01f, -1.43091949e-02f,
  9.55591053e-02f, -3.37246396e-02f, 3.25375497e-02f, 8.81791189e-02f, 1.81751907e-01f, -2.79625237e-01f, -6.22224137e-02f, -3.24851982e-02f, -8.69114995e-02f, 1.46677092e-01f,
  3.95593718e-02f, 4.74810302e-02f, 3.21720362e-01f, 1.44224226e-01f, -1.00380138e-01f, -6.02152646e-01f, 5.53380907e-01f, -7.49042556e-02f, -1.07064545e-02f, 1.23276174e-01f,
  4.84589666e-01f, 6.60841465e-02f, 5.47698438e-01f, 3.10977608e-01f, 5.88933706e-01f, -2.40289178e-02f, 3.62313300e-01f, 2.83787549e-01f, -3.33261967e-01f, 2.22165585e-01f,
  9.21014324e-02f, 2.47716412e-01f, 3.51017296e-01f, -1.43002123e-01f, 4.59557911e-03f, -3.14266264e-01f, -2.44300857e-01f, 3.74997944e-01f, 2.27358341e-01f, -1.29891947e-01f,
  4.32765126e-01f, 3.87823373e-01f, 5.06457746e-01f, -6.16670325e-02f, -7.52523363e-01f, -6.00289345e-01f, 6.60664678e-01f, 1.47810549e-01f, -3.12713534e-01f, 1.47706583e-01f,
  1.65359020e-01f, -2.29950443e-01f, 1.25522241e-02f, -2.97234487e-03f, 7.06589967e-02f, 1.98415592e-01f, -8.23953599e-02f, 4.68638651e-02f, 1.21410303e-01f, -1.11360654e-01f,
  2.07239062e-01f, -6.47621334e-01f, -2.40483880e-02f, 9.37748477e-02f, 2.47789279e-01f, 4.37818259e-01f, 5.19665003e-01f, 5.12928784e-01f, -5.53834915e-01f, -5.99899888e-01f,
  -5.18012345e-01f, 2.46064782e-01f, 6.02402985e-01f, -4.57666516e-01f, -4.03580964e-01f, 4.08837825e-01f, -1.03253044e-01f, -8.38168412e-02f, -2.68739909e-01f, 2.83922106e-02f,
  -4.65811882e-03f, -2.79881626e-01f, -6.87035471e-02f, 1.43445015e-01f, 1.36797518e-01f, 4.07814085e-02f, 3.08275577e-02f, 4.26216573e-02f, 1.74615636e-01f, -6.59854487e-02f,
  2.15177596e-01f, 1.49982691e-01f, 1.26267403e-01f, -2.12342173e-01f, 1.78317204e-01f, -1.04280993e-01f, -3.15476388e-01f, -1.70541659e-01f, 2.94149131e-01f, -1.71248913e-01f,
  2.30367053e-02f, -4.99804951e-02f, 3.92907448e-02f, -1.20631762e-01f, 4.07489896e-01f, -1.17730603e-01f, 3.45043063e-01f, 7.67075956e-01f, -7.97713101e-02f, 2.97326237e-01f,
  -4.19603825e-01f, -4.84657288e-01f, 6.46881908e-02f, 2.85893083e-01f, 2.50468820e-01f, 4.07621741e-01f, 2.17660785e-01f, 2.19911724e-01f, 2.29277238e-01f, -1.36253424e-02f,
  1.74755111e-01f, -6.71841279e-02f, 3.22844803e-01f, 1.63994402e-01f, 3.32580000e-01f, -1.03969999e-01f, 6.13053553e-02f, -3.38512093e-01f, 2.72864193e-01f, -1.35441244e-01f,
  -2.92030364e-01f, -1.70148015e-01f, 1.80854201e-01f, -1.29300468e-02f, -1.69748351e-01f, -3.29809666e-01f, 4.65346724e-01f, 4.25395191e-01f, -8.62167776e-02f, 5.44778742e-02f,
  -2.89614070e-02f, 4.90412652e-01f, -2.12812304e-01f, 5.10048866e-01f, 2.43538637e-02f, -1.08451009e-01f, 1.98454231e-01f, 1.40715063e-01f, 2.00473610e-02f, 4.47285064e-02f,
  -9.44622532e-02f, -1.02705821e-01f, 1.84815541e-01f, -1.62572041e-01f, 5.77827469e-02f, 1.40708536e-01f, 2.20120490e-01f, 2.18884632e-01f, -5.22881187e-02f, -4.97340113e-01f,
  -3.01282316e-01f, 1.25550032e-01f, 5.33612631e-02f, 3.64813507e-02f, 2.54689574e-01f, 2.35179156e-01f, 2.79791713e-01f, -7.61667639e-02f, -4.69681919e-01f, 2.39481069e-02f,
  3.19818020e-01f, 1.71154246e-01f, 3.12341213e-01f, 7.61945099e-02f, -3.19764942e-01f, 1.05899259e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.95822352e-01f, 3.14534187e-01f, -1.54443845e-01f, 4.69826043e-01f, 1.88117236e-01f, 3.65885764e-01f, 2.66418159e-02f, 1.16078816e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.24016263e-01f, -1.28193037e-03f, 5.38395569e-02f, 3.18085104e-01f, 1.76928461e-01f, 9.29425135e-02f, -1.01196297e-01f, 3.53832692e-02f, 9.98358130e-02f, 3.63804772e-02f,
  4.36043024e-01f, 1.64484799e-01f, -3.07776779e-02f, -1.69423193e-01f, -3.79291326e-01f, -2.87024885e-01f, 3.09232414e-01f, -5.47284007e-01f, 1.19182833e-01f, -2.79402733e-01f,
  -3.68200928e-01f, 1.04678705e-01f, -1.90383643e-01f, 5.59382558e-01f, 3.59919339e-01f, -1.56969711e-01f, 1.23959415e-01f, -3.03397715e-01f, 4.03530091e-01f, -2.57983804e-01f,
  2.08825454e-01f, 2.95417458e-01f, 5.95111586e-02f, -2.70450320e-02f, 2.12381259e-01f, 4.01925072e-02f, 9.91153568e-02f, 1.64949119e-01f, -2.93322075e-02f, -1.49401471e-01f,
  -1.12236671e-01f, -5.66168189e-01f, -5.20724833e-01f, 2.61426479e-01f, -1.11043677e-02f, -4.32533503e-01f, 6.77086711e-02f, -5.35666525e-01f, -3.14379245e-01f, -2.28691369e-01f,
  -2.78084069e-01f, -4.42466170e-01f, 2.26240590e-01f, -1.34293333e-01f, -2.37920895e-01f, -2.74077356e-01f, -2.29534537e-01f, -4.10212502e-02f, 2.28164513e-02f, -4.04017083e-02f,
  3.69183600e-01f, -1.67114586e-01f, 3.36336702e-01f, -6.14274386e-03f, -2.09458083e-01f, 1.41377360e-01f, 9.82949361e-02f, -3.53019476e-01f, -3.21927428e-01f, 2.49364451e-01f,
  1.29158258e-01f, 9.84480828e-02f, -3.27719063e-01f, -1.40301332e-01f, -6.74064755e-01f, 2.72302441e-02f, 6.53592590e-03f, 1.00249074e-01f, -3.53424191e-01f, -3.95935774e-01f,
  -2.99652576e-01f, -2.85134315e-01f, -1.54280663e-02f, -2.07768515e-01f, -4.37640548e-02f, 2.55649269e-01f, 7.11343214e-02f, -5.65761447e-01f, -2.60709524e-01f, 2.43916698e-02f,
  -2.16790363e-01f, 2.64402200e-03f, 2.26021320e-01f, -3.26174855e-01f, -1.02433555e-01f, -1.67810053e-01f, -1.73716336e-01f, -3.94750014e-02f, -7.45464442e-03f, -6.89434290e-01f,
  3.08255523e-01f, -8.16193670e-02f, -3.35848451e-01f, 1.29673973e-01f, -3.18974346e-01f, -1.15204342e-01f, -1.19022734e-03f, 1.24151304e-01f, -3.92651975e-01f, -1.86432600e-02f,
  -5.93554437e-01f, 2.33440250e-01f, 3.48529518e-01f, -7.13751987e-02f, 2.04877153e-01f, -6.36043772e-02f, -4.07527477e-01f, 1.89739600e-01f, 6.25087991e-02f, 2.75904715e-01f,
  1.57990053e-01f, 1.99846327e-01f, -1.61198705e-01f, -3.52737248e-01f, 8.89467821e-02f, 1.40971273e-01f, -2.21896973e-02f, -1.71761438e-01f, 2.68817455e-01f, -3.35927218e-01f,
  3.38784829e-02f, 6.75440952e-02f, 4.26850021e-01f, -3.32961291e-01f, -1.08294394e-02f, 5.79497404e-02f, -8.78696609e-03f, 3.06719631e-01f, 2.47328177e-01f, 4.46478985e-02f,
  1.52294040e-01f, 7.07855150e-02f, -2.95892954e-01f, 2.98438013e-01f, 1.48483768e-01f, -5.26251197e-01f, 1.33481130e-01f, -1.97622508e-01f, 4.55083773e-02f, -3.41284931e-01f,
  1.60801753e-01f, 6.82396054e-01f, 3.72745931e-01f, -3.15456063e-01f, 4.74694818e-02f, -2.11523339e-01f, 2.69820720e-01f, 1.01647682e-01f, 6.56137764e-02f, 1.64891779e-01f,
  4.18272287e-01f, 5.00642598e-01f, -9.01117474e-02f, 4.81988229e-02f, -1.48365095e-01f, -1.73901804e-02f, -4.93055955e-02f, 6.49882630e-02f, 3.59650135e-01f, 2.51102239e-01f,
  -1.28764778e-01f, -7.71558508e-02f, -2.67306834e-01f, 3.90965015e-01f, 4.13055755e-02f, 1.51833028e-01f, -1.69625521e-01f, -7.62826055e-02f, -1.93798333e-01f, 1.39767140e-01f,
  3.79014075e-01f, -3.88892919e-01f, -7.82352537e-02f, -8.77690762e-02f, 4.91457075e-01f, -3.34867984e-01f, -8.30416307e-02f, 1.18928425e-01f, 8.84463415e-02f, -1.59772620e-01f,
  1.97955176e-01f, -4.34564382e-01f, -3.23600829e-01f, 3.28133225e-01f, -5.74987866e-02f, -1.28803700e-01f, 5.74896932e-02f, -2.01790839e-01f, -5.12018465e-02f, -1.48950577e-01f,
  2.75899500e-01f, -1.16170704e-01f, 2.82273382e-01f, 3.34459469e-02f, -9.85459983e-02f, -4.52533990e-01f, -3.07948768e-01f, 1.37497082e-01f, 3.73392761e-01f, -7.08464012e-02f,
  3.53200108e-01f, -5.71941733e-02f, -2.67432004e-01f, 2.53663480e-01f, 6.04217313e-02f, 2.09091201e-01f, 3.67337465e-01f, 1.58655524e-01f, 6.39976338e-02f, -3.29152554e-01f,
  6.97152764e-02f, -1.21067047e-01f, -1.18973486e-01f, 1.39364824e-01f, 3.41164678e-01f, 2.67461628e-01f, -1.57485053e-01f, 3.25958617e-02f, -2.37584129e-01f, 4.22804534e-01f,
  -2.08730116e-01f, 2.64714330e-01f, 4.09361750e-01f, -2.22271040e-01f, -1.79483995e-01f, 8.57955124e-03f, -8.19900408e-02f, 3.71681809e-01f, -5.60105622e-01f, -3.24661583e-01f,
  -1.94674537e-01f, -1.10812169e-02f, 2.73645073e-01f, -1.10259265e-01f, 8.65323991e-02f, -3.08962822e-01f, -3.74689132e-01f, 3.19457836e-02f, 3.11117563e-02f, -2.26497471e-01f,
  -1.21852227e-01f, -1.90798953e-01f, -4.50540334e-02f, -5.54791093e-02f, 3.60272884e-01f, -1.29291534e-01f, -3.20359655e-02f, -1.10330597e-01f, 4.92361262e-02f, 3.68519537e-02f,
  3.53224665e-01f, -1.29655972e-01f, -9.51244459e-02f, 6.21635802e-02f, 3.49744111e-01f, 2.75285989e-01f, 1.65732577e-01f, -5.36363870e-02f, 1.10724360e-01f, 1.65704265e-02f,
  2.84674048e-01f, 3.22511613e-01f, 3.67746770e-01f, 3.12867045e-01f, -1.17301561e-01f, -6.07275404e-02f, 2.48158082e-01f, 4.45653707e-01f, 4.35993940e-01f, 4.00295258e-01f,
  4.54932153e-01f, -1.06931150e-01f, -3.71330231e-01f, -1.48056611e-01f, 1.73746943e-01f, 3.51026446e-01f, 2.81296596e-02f, -2.05090329e-01f, 8.38508159e-02f, 5.79590142e-01f,
  -3.56848650e-02f, 1.87302575e-01f, -4.24527451e-02f, -2.33169645e-01f, 1.06776312e-01f, 6.88791694e-03f, 2.71527052e-01f, -3.51591289e-01f, 1.38878539e-01f, 9.08802077e-03f,
  2.01667204e-01f, -2.34851405e-01f, -3.13187659e-01f, -1.13360949e-01f, -8.43783394e-02f, -2.01925054e-01f, -1.39820591e-01f, -3.41240823e-01f, 5.01197875e-02f, -1.94736704e-01f,
  -7.37706870e-02f, 3.07826787e-01f, 5.08308932e-02f, -1.77437469e-01f, 7.27175921e-03f, -3.51618797e-01f, 3.06235909e-01f, -2.50053257e-01f, 7.07570687e-02f, 1.36142656e-01f,
  -1.74306825e-01f, -4.01252568e-01f, -2.16348067e-01f, -3.47699940e-01f, 1.36504993e-01f, -2.58138388e-01f, -1.02774680e-01f, -6.71268851e-02f, -1.94523185e-01f, 3.58009577e-01f,
  1.95718445e-02f, 1.49473593e-01f, -1.38410136e-01f, -1.39233947e-01f, 1.25960991e-01f, 2.65101492e-01f, 3.65959167e-01f, 3.09858713e-02f, -3.11597064e-03f, 1.35898545e-01f,
  -3.66522878e-01f, 2.94595301e-01f, 1.68079063e-01f, 5.03584087e-01f, 1.83603391e-01f, 2.17136428e-01f, -1.20338410e-01f, -1.28921829e-02f, -2.39838079e-01f, 4.43575919e-01f,
  -1.01003908e-01f, 2.96405971e-01f, -4.79617435e-03f, -1.31073907e-01f, 8.07987601e-02f, 4.93061878e-02f, 5.55603690e-02f, -8.79403576e-02f, -1.12151563e-01f, 4.02329832e-01f,
  -3.05011332e-01f, 1.26318529e-01f, 7.66904503e-02f, 6.43899515e-02f, -5.08787870e-01f, 3.43930990e-01f, 1.34349585e-01f, 3.58083159e-01f, 1.54514164e-01f, -3.94566566e-01f,
  4.32754934e-01f, 1.51596650e-01f, -1.64162695e-01f, -7.73578733e-02f, 1.65235654e-01f, 3.35232466e-02f, -2.86589265e-02f, 3.90890837e-02f, 1.88137323e-01f, -7.86623731e-02f,
  -1.06735311e-01f, -9.57225561e-02f, 4.12658572e-01f, 2.06715390e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.75989765e-01f, 9.64182258e-01f, -4.61902842e-02f, 3.31780463e-02f, 1.44639611e-01f, 2.64606267e-01f, 6.29607201e-01f, -2.14935467e-01f, 7.10885167e-01f, 6.75876718e-03f,
  3.13252985e-01f, 1.54375225e-01f, 1.83061033e-01f, 1.07288152e-01f, -1.98189035e-01f, 7.13608563e-01f, 5.74062109e-01f, 2.58238494e-01f, 1.19226664e-01f, -1.29844248e-01f,
  -6.53420866e-01f, 7.78129771e-02f, 5.56115925e-01f, 3.69011937e-03f, 5.21735966e-01f, 7.76811004e-01f, -3.86044979e-01f, 4.55155671e-01f, 5.86900115e-02f, 5.78861713e-01f,
  -5.53970695e-01f, -1.64590165e-01f, 9.02385041e-02f, 4.48834449e-02f, -2.40132406e-01f, 2.92024940e-01f, 1.37981638e-01f, 9.28616710e-03f, -6.50923371e-01f, -6.13340996e-02f,
  -2.55811661e-01f, 7.61892676e-01f, -2.31198579e-01f, -3.19207102e-01f, -4.65734452e-01f, -6.44242913e-02f, 3.38244438e-02f, -1.14696518e-01f, -1.49391651e-01f, -7.00846672e-01f,
  9.36102629e-01f, -1.78047448e-01f, -6.69954360e-01f, -1.91557571e-01f, -6.10699892e-01f, -3.80492389e-01f, 2.99997419e-01f, 2.50963092e-01f, -3.31350446e-01f, 2.57976800e-02f,
  6.25081599e-01f, 3.13038558e-01f, 7.09662616e-01f, -3.54548961e-01f, -6.51734293e-01f, -3.52918118e-01f, 1.41416714e-01f, 1.38820214e-02f, -8.17741975e-02f, 2.68149614e-01f,
  -4.49714959e-01f, 2.54617989e-01f, -6.58482492e-01f, 7.39313722e-01f, 1.14847548e-01f, -6.18003658e-04f, -9.00208354e-01f, -2.57672489e-01f, 8.31820667e-02f, -4.58894819e-02f,
  -5.41194342e-02f, -6.43542767e-01f, 6.62547886e-01f, 1.12861119e-01f, -7.59805620e-01f, 2.59449452e-01f, -4.10120726e-01f, -3.14040542e-01f, 1.85807496e-01f, 5.21366715e-01f,
  7.08390325e-02f, 5.72228804e-02f, 2.03028649e-01f, 4.02705550e-01f, 4.02518094e-01f, 2.43446946e-01f, 7.01674700e-01f, 5.68847835e-01f, 3.98284286e-01f, 6.11627579e-01f,
  3.41307282e-01f, 4.21799213e-01f, 6.17056608e-01f, 3.93506169e-01f, 7.96458066e-01f, 2.25158587e-01f, -2.68417448e-01f, -3.11475750e-02f, 5.13824880e-01f, 4.94709462e-01f,
  -6.93742394e-01f, -4.01295990e-01f, -3.71654779e-01f, -2.96554297e-01f, -6.75575674e-01f, -3.39679003e-01f, 5.42983055e-01f, -8.41655612e-01f, 1.58658192e-01f, 9.03874561e-02f,
  4.83173504e-02f, -7.24583507e-01f, -3.30088824e-01f, 4.85993832e-01f, 2.06854761e-01f, -2.90779620e-01f, 1.58586338e-01f, -1.55408174e-01f, 4.61961865e-01f, 2.29290813e-01f,
  3.57265383e-01f, 2.00102270e-01f, 3.06313306e-01f, 1.48777338e-02f, 2.38284156e-01f, 7.86715969e-02f, 5.12079895e-01f, 5.76601550e-02f, 2.93962181e-01f, 2.64673561e-01f,
  4.29213703e-01f, -9.90414500e-01f, -6.70980990e-01f, -5.99365413e-01f, -5.67675471e-01f, 1.86464489e-01f, -9.30615515e-02f, -4.71157968e-01f, -3.06269795e-01f, -5.41174471e-01f,
  -4.25169885e-01f, 7.83588588e-01f, 8.75498474e-01f, 1.37931377e-01f, -2.50136077e-01f, 2.48549040e-02f, 6.91943884e-01f, 6.71471119e-01f, -1.09782681e-01f, 2.82406900e-02f,
  -4.09905165e-02f, -3.17210317e-01f, 5.44717908e-01f, 2.48784311e-02f, 1.66388050e-01f, 5.25679052e-01f, 2.78665036e-01f, -4.71638888e-01f, 1.49092108e-01f, 4.97644633e-01f,
  2.99511075e-01f, 1.26374483e-01f, 3.76983911e-01f, -5.45066655e-01f, 9.25044477e-01f, -1.71689704e-01f, 1.85040131e-01f, 5.77381909e-01f, -7.66417980e-01f, -3.01438749e-01f,
  -1.30015478e-01f, 6.30536020e-01f, 3.50255519e-01f, 1.30170435e-01f, -5.69694415e-02f, 7.45272338e-01f, -2.95074880e-01f, 2.03598753e-01f, 3.44139963e-01f, 4.06185210e-01f,
  -8.00149858e-01f, 1.01564504e-01f, -4.50186849e-01f, -6.94597960e-01f, 2.13132188e-01f, 1.12358376e-01f, 4.44887906e-01f, -1.11254662e-01f, -1.69991955e-01f, 4.15980406e-02f,
  -3.81311089e-01f, 2.01992571e-01f, 4.78106946e-01f, -3.55694219e-02f, -1.15088820e-01f, -3.80783737e-01f, 8.26080024e-01f, 1.77477762e-01f, 9.50259939e-02f, -4.92186099e-01f,
  -1.97919160e-02f, 7.34680817e-02f, 9.90105048e-02f, -2.43320726e-02f, 1.96218695e-02f, -6.92067817e-02f, -7.38195002e-01f, 1.01869047e-01f, 6.86850697e-02f, -1.88359827e-01f,
  -9.86891016e-02f, 2.07355872e-01f, 2.22479358e-01f, 1.92767724e-01f, -5.83089143e-02f, -1.58923864e-02f, -7.88188353e-02f, 1.87872380e-01f, 1.03540853e-01f, 3.51396322e-01f,
  2.56497949e-01f, 2.11710379e-01f, 1.47367287e-02f, 2.45245844e-01f, -3.41752358e-02f, 1.61211029e-01f, -2.69218802e-01f, 5.72135627e-01f, -2.77192593e-01f, -1.05527215e-01f,
  -1.00791501e-02f, -2.09278136e-01f, -1.57681987e-01f, 1.10261846e+00f, -7.74668381e-02f, 1.20458677e-01f, 8.54406580e-02f, 7.02863410e-02f, 5.47105297e-02f, 2.73865372e-01f,
  1.82132185e-01f, 1.03922713e+00f, -9.28441584e-01f, -1.26598105e-01f, -3.75397094e-02f, 9.02179033e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.41653770e-01f, -4.94532008e-03f, -1.57375410e-02f, 4.85608101e-01f, 4.44549531e-01f, 3.69475931e-01f, -1.47224545e-01f, 3.32625121e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -1.92773417e-01f, 4.55310941e-01f, 2.59631634e-01f, -5.39652288e-01f, -6.23099625e-01f, -5.59510648e-01f, -3.70900452e-01f, -8.61762822e-01f, 1.62070617e-01f, -2.80128241e-01f,
  -1.99536636e-01f, 1.70082133e-02f, -5.34543574e-01f, -5.97428262e-01f, 2.27132276e-01f, -2.10754685e-02f, 8.48923028e-02f, -5.01793563e-01f, -2.61491716e-01f, -2.82382071e-02f,
  -4.60947812e-01f, 5.13496518e-01f, 4.06859457e-01f, 1.43110557e-02f, 2.17587247e-01f, -1.97977617e-01f, 1.50460973e-01f, -6.95603549e-01f, -1.19480038e+00f, 4.45136249e-01f,
  -5.71910329e-02f, 5.00906184e-02f, 1.70337066e-01f, 2.83926249e-01f, -3.58901024e-01f, 3.77706170e-01f, 2.78195977e-01f, 4.04074550e-01f, 1.40271246e-01f, 1.74419552e-01f,
  3.52231771e-01f, -7.30082020e-02f, 8.22575614e-02f, -4.05967385e-01f, 6.28888786e-01f, 3.75160924e-03f, -6.16578877e-01f, -1.04922645e-01f, 3.57051909e-01f, -4.85292643e-01f,
  -5.21377087e-01f, -3.30736041e-01f, -5.87758720e-01f, -6.36394858e-01f, 7.50606716e-01f, -3.29483896e-01f, -5.81164837e-01f, 1.76523238e-01f, 3.87969762e-01f, -1.04558003e+00f,
  -4.21996355e-01f, -5.07810652e-01f, 6.37423754e-01f, -1.88156173e-01f, 1.24731548e-01f, -1.85209915e-01f, -2.62080878e-01f, 1.35161847e-01f, -4.89340007e-01f, -2.31217682e-01f,
  5.03070652e-01f, 2.24324390e-01f, 1.06839426e-01f, 3.61957222e-01f, 4.59905207e-01f, -1.35233346e-02f, 7.97606289e-01f, -6.62773252e-01f, -4.96358842e-01f, -3.56690824e-01f,
  9.09828663e-01f, 1.64729625e-01f, -4.74697948e-02f, -8.94247815e-02f, 6.62433743e-01f, -2.58841157e-01f, 4.80317026e-01f, 7.70332277e-01f, 9.69678387e-02f, -6.50740862e-01f,
  -5.11512637e-01f, 6.63286686e-01f, -4.99837190e-01f, -6.00592673e-01f, 1.74205735e-01f, 3.16542596e-01f, -6.33203745e-01f, 2.94546098e-01f, -2.31954858e-01f, -7.58842468e-01f,
  2.03143075e-01f, 4.15223598e-01f, -4.93354201e-01f, -6.38595343e-01f, -3.04451942e-01f, -7.66866386e-01f, 3.83911878e-01f, -2.47984827e-02f, -5.94891906e-01f, -3.42234075e-01f,
  2.99767733e-01f, 9.53339934e-02f, -4.00999576e-01f, 2.29580253e-01f, -5.51102459e-01f, -4.45162952e-01f, 2.86443591e-01f, -6.80606663e-01f, 2.97459215e-01f, -1.07659638e+00f,
  3.51708174e-01f, -9.07167196e-01f, -9.29698467e-01f, 6.75648171e-03f, -2.64376793e-02f, 5.05989671e-01f, -9.93350089e-01f, 7.42135569e-02f, 5.85434318e-01f, -6.65632427e-01f,
  -1.54635087e-01f, 4.23247069e-01f, 4.08193618e-01f, 4.65017468e-01f, 6.88719332e-01f, 7.12552071e-01f, 3.53306442e-01f, -4.35661882e-01f, -2.23932922e-01f, 6.18534505e-01f,
  -1.76077798e-01f, 3.99627060e-01f, 8.82819831e-01f, 6.91652477e-01f, -7.09651172e-01f, -3.39692235e-01f, 1.91572845e-01f, -2.18150854e-01f, 4.49734122e-01f, -3.12894702e-01f,
  -3.55379581e-01f, 4.23866630e-01f, 3.59645605e-01f, -3.14275950e-01f, 1.03623524e-01f, -5.97799897e-01f, -4.97110821e-02f, -7.59542808e-02f, 6.48708269e-02f, 1.47305682e-01f,
  3.39350164e-01f, 3.25582325e-01f, 6.05715752e-01f, -5.47591001e-02f, 1.54080898e-01f, -1.09487727e-01f, -7.45760500e-01f, 2.44020864e-01f, -6.62413061e-01f, 6.31078333e-02f,
  2.21093923e-01f, -3.21162909e-01f, -4.80896682e-01f, 5.32793164e-01f, 2.68925671e-02f, -3.55721325e-01f, -8.76293957e-01f, 3.11070353e-01f, 4.00885165e-01f, 2.08084300e-01f,
  6.07390562e-03f, -2.70162046e-01f, -7.66854405e-01f, 5.10824978e-01f, -2.62669265e-01f, 2.92132556e-01f, 2.78667718e-01f, -8.09669942e-02f, -8.63949001e-01f, -8.21370244e-01f,
  -3.40876132e-01f, 2.06675202e-01f, -3.01225752e-01f, 6.39257729e-01f, -2.22106203e-01f, 2.48555452e-01f, -3.03813636e-01f, -7.28736639e-01f, -3.04419138e-02f, -2.44722575e-01f,
  -1.61826238e-01f, -7.19443500e-01f, 3.23868066e-01f, 4.52032954e-01f, -6.01350069e-01f, 6.70845509e-01f, -2.52074093e-01f, 4.94601466e-02f, -4.55654860e-02f, -3.82079244e-01f,
  5.33844948e-01f, 2.69645721e-01f, 4.06151712e-01f, 4.38272864e-01f, -4.41037089e-01f, -2.03986943e-01f, -1.29711986e-01f, -7.15088695e-02f, -2.40349203e-01f, 2.94900894e-01f,
  4.46011901e-01f, -7.14807570e-01f, 1.86832890e-01f, -6.11718416e-01f, 1.06515065e-01f, -4.41860825e-01f, 3.63274634e-01f, -1.53121531e-01f, 2.43213400e-01f, 4.48605984e-01f,
  3.62468183e-01f, 5.07806301e-01f, -6.82545677e-02f, 4.09528762e-01f, 2.58267466e-02f, -2.33648106e-01f, 7.89916337e-01f, 6.07856750e-01f, -1.25011029e-02f, -5.82914114e-01f,
  6.12531602e-01f, -3.15598100e-01f, -6.18956268e-01f, -6.09891079e-02f, 4.16375279e-01f, 6.94266677e-01f, -6.97704792e-01f, -4.44790393e-01f, -9.73501742e-01f, -7.98587620e-01f,
  -3.01665634e-01f, 3.99598539e-01f, 4.82355386e-01f, 7.32627988e-01f, 1.95305452e-01f, -4.65912521e-01f, -8.65210667e-02f, -7.53199995e-01f, -4.27318271e-03f, 5.52745700e-01f,
  7.90000558e-01f, -8.23976249e-02f, 3.98048609e-01f, -7.13835955e-01f, -1.05864562e-01f, 2.07850039e-01f, -4.85626042e-01f, 7.82130212e-02f, 8.06927204e-01f, -3.50341797e-02f,
  9.59320128e-01f, 4.58419621e-01f, 4.29023743e-01f, 7.89215267e-01f, -8.79985169e-02f, -6.19523227e-02f, -9.20673490e-01f, 8.20419490e-01f, -2.08616644e-01f, 5.66218436e-01f,
  -1.24974203e+00f, 4.33308631e-01f, 3.25145572e-02f, 3.56889158e-01f, -1.80834487e-01f, -6.31957412e-01f, -1.30855188e-01f, -9.26291704e-01f, -6.18068337e-01f, 1.02968462e-01f,
  -4.45358083e-02f, 2.87470043e-01f, -5.19233525e-01f, 4.86902177e-01f, -3.02696705e-01f, 4.61978793e-01f, -2.91559815e-01f, 6.06365800e-01f, -1.91435739e-02f, 5.37957668e-01f,
  3.96056920e-01f, -6.53924286e-01f, -1.75757408e-01f, 4.90899622e-01f, 5.42450368e-01f, 3.62414092e-01f, 6.65924609e-01f, -6.92209542e-01f, 2.46986300e-01f, 2.00501800e-01f,
  8.76899898e-01f, -1.18826162e-02f, 5.30287683e-01f, -1.70132250e-01f, -2.13477775e-01f, -2.60249287e-01f, 1.76513106e-01f, 5.09733081e-01f, -1.68048918e-01f, -1.21902859e+00f,
  2.49168068e-01f, 3.56901824e-01f, 5.02289295e-01f, -6.78842783e-01f, -4.93636802e-02f, -3.36960614e-01f, -7.83519089e-01f, -9.85877961e-02f, -1.28299296e-01f, 4.62499291e-01f,
  -6.80397451e-01f, 1.67100996e-01f, -9.06460464e-01f, 3.81845176e-01f, 4.27376121e-01f, -2.98875500e-03f, -7.36996114e-01f, 3.88400227e-01f, -2.84208328e-01f, 8.13444614e-01f,
  -1.03730595e+00f, -5.15190303e-01f, -4.29039180e-01f, -5.26100874e-01f, -8.03067088e-02f, -8.54028642e-01f, -1.06634355e+00f, 7.50862241e-01f, -4.06489009e-03f, -9.05159295e-01f,
  -5.64463913e-01f, 1.45923585e-01f, -9.30834264e-02f, 1.96669549e-01f, -2.35018525e-02f, -5.09187341e-01f, -8.12925160e-01f, -2.35712528e-01f, -3.49522568e-02f, -2.97726512e-01f,
  3.32489461e-01f, 2.48720482e-01f, 8.61216933e-02f, -4.05579239e-01f, -2.13704243e-01f, 1.99907377e-01f, -4.26216185e-01f, 6.11453772e-01f, 1.59670219e-01f, 2.04904377e-01f,
  3.21895689e-01f, 3.28776836e-01f, 1.61515728e-01f, -3.84663045e-01f, 8.72867763e-01f, 4.38774675e-01f, -7.70750105e-01f, 4.02945518e-01f, 3.51761073e-01f, -1.13372445e+00f,
  2.90271491e-01f, -5.53211153e-01f, -7.35580504e-01f, -9.36806262e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.22422951e-01f, -1.26806423e-01f, 2.52210908e-02f, -1.57802448e-01f, 8.86211544e-02f, -2.04970292e-03f, -1.82343705e-04f, 1.16406709e-01f, 3.08745474e-01f, -5.07809548e-03f,
  2.70165242e-02f, -3.01759869e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    