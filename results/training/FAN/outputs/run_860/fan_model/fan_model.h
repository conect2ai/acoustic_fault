/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.71398538e-01f, -3.05590838e-01f, 2.18838193e-02f, 8.06707591e-02f, -1.89718798e-01f, -1.31246494e-02f, -3.10068756e-01f, -1.68153450e-01f, 4.06297073e-02f, -1.25737697e-01f,
  -2.03588933e-01f, 9.13510472e-03f, -4.51337397e-02f, -1.25411507e-02f, 1.13350533e-01f, -1.15244627e-01f, -3.60949077e-02f, 1.69297963e-01f, 4.08605784e-01f, -2.48665791e-02f,
  -7.39043131e-02f, 1.15038320e-01f, 1.23568289e-01f, 1.22453101e-01f, -8.29259530e-02f, 1.72078341e-01f, -4.32047546e-02f, 4.42318013e-03f, -1.43709749e-01f, -9.99649614e-02f,
  1.10753551e-01f, -2.07200930e-01f, 1.33783862e-01f, 6.26162440e-03f, 5.78587577e-02f, 6.38689622e-02f, 3.42544131e-02f, -1.10781854e-02f, 1.21286716e-02f, -1.87023506e-02f,
  -7.23114684e-02f, -4.61055264e-02f, -4.08511050e-02f, -2.38511860e-02f, 3.07002403e-02f, -1.88750532e-02f, 5.26921637e-02f, 5.19751757e-02f, 3.25117186e-02f, -9.85248387e-02f,
  -6.26588389e-02f, -5.83089367e-02f, -1.18042223e-01f, -2.35080253e-02f, -7.12067261e-02f, 1.12975731e-01f, -1.80959832e-02f, 5.49020283e-02f, 1.04068004e-01f, -1.96852945e-02f,
  2.99017336e-02f, 3.59609351e-02f, 3.48173156e-02f, -4.39411076e-03f, 6.79708421e-02f, 4.43329960e-02f, 5.34738936e-02f, 3.90421860e-02f, -5.11319712e-02f, 3.44939204e-03f,
  -4.64906842e-02f, -8.66417494e-03f, -2.64805201e-02f, 1.08283320e-02f, -3.81248668e-02f, -4.78775240e-02f, -9.94919986e-03f, -6.70808703e-02f, -1.61672737e-02f, -3.53970975e-02f,
  2.05494817e-02f, -5.31289428e-02f, 5.61255775e-03f, 9.83290188e-03f, -3.73676158e-02f, 7.66877457e-02f, 3.23888473e-02f, -9.76881757e-02f, -5.64458407e-03f, 5.53925382e-03f,
  1.16726920e-01f, -7.39190215e-03f, -1.34677235e-02f, -2.49458905e-02f, 5.64770885e-02f, 5.60447946e-02f, -9.43050534e-02f, -3.21741030e-02f, 8.70303903e-03f, 1.96844973e-02f,
  1.07185021e-02f, 1.27971079e-02f, -3.29994150e-02f, 3.78576256e-02f, 4.46092822e-02f, 6.51910231e-02f, -1.03856169e-01f, 8.89644772e-02f, 3.17894202e-03f, 7.02315345e-02f,
  -7.91743770e-02f, 6.52509108e-02f, 6.60429150e-02f, -5.37793338e-02f, 8.96946434e-03f, 1.05928145e-01f, -1.40156914e-02f, 6.58975914e-02f, 1.34459063e-01f, 2.66336706e-02f,
  -6.55288622e-02f, 8.68908241e-02f, 1.84979483e-01f, 2.12354213e-01f, 2.94986695e-01f, 3.15023333e-01f, 3.55462432e-01f, 1.64163224e-02f, 3.88346873e-02f, 5.25152944e-02f,
  4.62314971e-02f, -1.39844850e-01f, -2.58975953e-01f, -2.43929058e-01f, -1.20030545e-01f, 1.62480861e-01f, 1.60882950e-01f, -7.71441534e-02f, -1.69086367e-01f, 3.08763925e-02f,
  7.92787150e-02f, -9.74886492e-02f, -1.12644181e-01f, -1.08091079e-01f, 1.59186915e-01f, -9.13365930e-02f, 1.09884851e-01f, -4.91826348e-02f, -4.47207652e-02f, 7.59364739e-02f,
  4.48588543e-02f, 5.95388375e-02f, 9.22441669e-03f, -7.08938390e-02f, 1.13556430e-01f, -1.95239615e-02f, 3.17841545e-02f, -1.10370152e-01f, 1.38400700e-02f, 5.67319840e-02f,
  6.90524802e-02f, -3.50492597e-02f, -6.54707551e-02f, -3.85883413e-02f, 7.36569911e-02f, -1.84901580e-02f, -2.80302148e-02f, -7.22383289e-03f, 4.22605313e-02f, 2.68458854e-02f,
  1.60759427e-02f, 4.83774804e-02f, 1.68656148e-02f, 1.84423290e-02f, -1.61565635e-02f, -5.93209676e-02f, 4.86481413e-02f, -1.38198594e-02f, 1.82879791e-02f, -2.93383636e-02f,
  -1.95141658e-02f, 8.77002999e-02f, 2.82080546e-02f, -4.27363627e-02f, -1.43301478e-02f, 1.42039251e-04f, 7.14606270e-02f, 1.24317436e-02f, -9.83430818e-03f, -5.94996922e-02f,
  -1.75195299e-02f, 1.33792013e-02f, 5.78834265e-02f, 3.84641476e-02f, -1.94745790e-02f, -3.20546404e-02f, 4.77853827e-02f, -4.33069505e-02f, -7.43913883e-03f, -1.04933485e-01f,
  -5.71966879e-02f, 1.51830548e-02f, -9.98524651e-02f, 3.40162404e-02f, -1.00585248e-03f, 5.54145388e-02f, 8.18046108e-02f, -4.76434678e-02f, 9.33161099e-03f, -1.66687109e-02f,
  -2.66289134e-02f, -6.81136549e-02f, 3.32761221e-02f, -6.59781173e-02f, 7.98540190e-03f, -6.75046593e-02f, 2.54479405e-02f, -5.99960759e-02f, 2.95039620e-02f, -1.90739054e-02f,
  -1.25130937e-02f, -3.46663296e-02f, -2.58118678e-02f, 1.33243483e-02f, 8.15280750e-02f, 3.64953913e-02f, 1.41298899e-03f, -6.08928269e-03f, -4.79911976e-02f, 4.28990871e-02f,
  -8.39424878e-02f, 8.37649126e-03f, 1.43119670e-03f, -3.57384258e-03f, 5.85192069e-02f, 9.76995006e-02f, 1.93966851e-02f, 1.32239118e-01f, 2.04736157e-03f, -2.21395586e-02f,
  -3.12380400e-03f, 1.06553264e-01f, -4.25628386e-02f, 3.22238319e-02f, -1.27888680e-01f, -2.95045525e-01f, -2.48891711e-01f, -1.21855356e-01f, -4.24040668e-02f, 2.07587443e-02f,
  4.95695658e-02f, 6.08318821e-02f, 6.45534918e-02f, 9.89038646e-02f, -5.54164387e-02f, 3.61169390e-02f, 2.47019697e-02f, -7.94687048e-02f, -1.76455319e-01f, -5.37736453e-02f,
  5.07330596e-02f, 1.26995668e-01f, 1.47614717e-01f, 1.13691762e-02f, 1.29516527e-01f, -2.76640225e-02f, 1.30366355e-01f, 7.73214772e-02f, 8.45749602e-02f, 2.48541236e-01f,
  4.74646762e-02f, 1.25479534e-01f, 2.54312549e-02f, 1.10465802e-01f, 9.07932757e-04f, 1.95885040e-02f, -1.32054090e-01f, 1.49140656e-01f, -1.15268700e-01f, -8.37644748e-03f,
  6.24376126e-02f, 9.19996668e-03f, -1.16933007e-02f, 6.82156235e-02f, 5.83701245e-02f, 7.76876584e-02f, 1.71375737e-01f, 1.03878580e-01f, 2.24867761e-02f, 1.15546688e-01f,
  3.98860313e-02f, 2.70124041e-02f, -7.48250857e-02f, -6.96557835e-02f, -3.70170027e-02f, 1.19253568e-01f, 5.62670343e-02f, 1.00013204e-01f, 3.82915623e-02f, 1.77019164e-01f,
  -7.43565988e-03f, -1.95616111e-02f, -1.75053102e-03f, 4.81859073e-02f, -3.34320590e-03f, 1.20997503e-02f, -1.48451542e-02f, -5.56074679e-02f, -9.46033746e-03f, -1.63906775e-02f,
  1.23341912e-02f, 5.01330383e-03f, 1.74175464e-02f, 3.46329324e-02f, 1.19943162e-02f, 8.88082385e-02f, -8.56843144e-02f, 3.08237486e-02f, 8.76858551e-03f, 1.88954063e-02f,
  -9.50112641e-02f, -4.90533933e-02f, -3.79798673e-02f, -6.68779984e-02f, 2.73674894e-02f, 3.77892866e-03f, 6.04099222e-02f, 3.96211967e-02f, 2.08352767e-02f, 3.16512276e-04f,
  1.55943155e-01f, 1.05449306e-02f, 5.62515669e-02f, 8.82518943e-03f, -6.99481070e-02f, 3.36148101e-03f, -3.48553210e-02f, -4.31700759e-02f, -6.13947250e-02f, -8.02635252e-02f,
  -1.00984655e-01f, 3.18837240e-02f, 6.19839728e-02f, 1.37893751e-01f, -6.82472065e-03f, -1.67995170e-02f, 1.81235112e-02f, -8.38007703e-02f, 1.02159955e-01f, -3.17120999e-02f,
  -4.99173962e-02f, -1.05132766e-01f, -2.32042023e-03f, -9.85507071e-02f, -1.09470144e-01f, -3.35761048e-02f, -6.53221905e-02f, -1.06921300e-01f, -7.79823586e-02f, -1.44329846e-01f,
  -2.40254939e-01f, 1.05583370e-02f, 2.08332837e-01f, -1.07276067e-01f, 1.68000709e-03f, -2.24779546e-01f, -1.92503661e-01f, -4.01076049e-01f, -2.93621361e-01f, -3.57591435e-02f,
  -4.90061333e-03f, 2.77897976e-02f, 3.52333370e-03f, 1.78336382e-01f, -3.82587779e-03f, 8.56043100e-02f, 3.15644681e-01f, 4.10361558e-01f, 2.31707133e-02f, -1.30688101e-01f,
  1.30619004e-01f, 5.83787337e-02f, 5.37843890e-02f, 7.59613421e-03f, -4.22865450e-02f, -1.40410706e-01f, -5.34535125e-02f, 5.29309139e-02f, 6.96546808e-02f, 5.09739697e-01f,
  1.27244562e-01f, -7.96990842e-02f, -1.03994301e-02f, 1.21886916e-02f, 1.84665602e-02f, -2.04440877e-02f, 4.82505113e-02f, 3.63890454e-02f, -2.54098028e-02f, 3.31660211e-02f,
  1.42604291e-01f, 3.38300653e-02f, 8.83875713e-02f, 6.48548007e-02f, 1.86751708e-02f, 8.33872985e-03f, 3.50516737e-02f, 2.05010995e-02f, -1.50372577e-03f, -6.73412904e-02f,
  1.03223473e-01f, 1.63417637e-01f, 3.47382016e-02f, 2.48646587e-02f, -8.31612572e-02f, 4.20429148e-02f, -2.95072030e-02f, -4.73187082e-02f, 3.44252475e-02f, -1.25347912e-01f,
  -5.61797284e-02f, 2.12445222e-02f, -3.53590548e-02f, 5.89125454e-02f, -2.64133308e-02f, -4.45012338e-02f, 9.13603753e-02f, -5.59583828e-02f, 9.38182697e-03f, -1.19978015e-03f,
  6.94029452e-03f, 2.01101750e-02f, 4.40614745e-02f, -2.95011625e-02f, 1.98568739e-02f, -5.18030347e-03f, -3.22539918e-02f, -5.74873947e-03f, 2.64737941e-02f, -4.75698989e-03f,
  -5.81178181e-02f, 2.29315720e-02f, -1.72285996e-02f, 7.85452873e-02f, 1.46980248e-02f, 4.23889533e-02f, -2.76017142e-03f, 3.66357528e-02f, -1.07775681e-01f, 4.51153331e-02f,
  -2.22822174e-01f, 1.89332619e-01f, -8.79134312e-02f, -7.10631534e-02f, -5.39704822e-02f, -1.07740566e-01f, -9.34227929e-03f, -5.77503182e-02f, 9.43651944e-02f, -4.32149880e-03f,
  -5.04067279e-02f, -3.64137925e-02f, 3.61560211e-02f, -5.13319187e-02f, 6.06831396e-03f, -5.24893701e-02f, -6.54554367e-02f, 1.73313972e-02f, 1.74304526e-02f, -8.58507305e-02f,
  -9.75572169e-02f, -5.53369895e-02f, -2.17488065e-01f, -1.54110901e-02f, -4.34588548e-03f, -1.64090380e-01f, -4.11933511e-02f, -5.48951700e-02f, -2.14832991e-01f, -3.59860331e-01f,
  -2.52664596e-01f, -8.81044865e-02f, -1.62110507e-01f, -1.33612249e-02f, -1.08352378e-01f, -2.08709523e-01f, -3.01066965e-01f, -8.48541632e-02f, 6.65851682e-02f, -7.94747323e-02f,
  2.32208893e-02f, 2.83217281e-01f, 1.67888343e-01f, 2.13235557e-01f, -2.34738272e-02f, -3.33101377e-02f, -3.37610915e-02f, 1.77869834e-02f, 4.54179198e-02f, -7.84256384e-02f,
  1.13346530e-02f, -9.30530652e-02f, -3.09059732e-02f, -1.01800018e-03f, 2.85604913e-02f, 1.57334864e-01f, -8.71051196e-03f, 1.89371430e-03f, -2.84534204e-03f, 1.13643393e-01f,
  -3.84220891e-02f, -1.29621327e-01f, 9.77236703e-02f, 1.07111245e-01f, 1.49719976e-02f, -3.29386629e-02f, 7.68971220e-02f, -7.55639598e-02f, 5.85934408e-02f, 6.46004220e-03f,
  5.60113043e-02f, -4.95211640e-03f, -3.90085066e-03f, -2.95593925e-02f, -4.43080664e-02f, -1.93888918e-02f, -2.63557993e-02f, -1.60048343e-02f, 2.86023691e-02f, -9.23793018e-02f,
  8.24698731e-02f, -9.79321450e-02f, -1.26425698e-01f, 8.92069340e-02f, -7.28235915e-02f, 9.12514329e-02f, -7.07867369e-02f, -7.87456632e-02f, -3.57556320e-03f, -1.00843072e-01f,
  -6.39613252e-03f, -6.06017560e-02f, 5.26131084e-03f, -8.79880488e-02f, 4.55446262e-03f, 2.10928381e-03f, -7.26413913e-03f, 3.08344141e-02f, -1.00615863e-02f, 2.80589052e-02f,
  6.71118870e-02f, -5.44914193e-02f, -3.47019769e-02f, 1.97682995e-02f, 3.13023571e-03f, -1.78236663e-02f, 4.86118868e-02f, -1.96327046e-02f, 2.48918645e-02f, -1.58725139e-02f,
  8.52530077e-02f, -1.00216627e-01f, 3.63952406e-02f, -5.40878624e-02f, 4.18485850e-02f, -4.14488418e-03f, 5.15019055e-03f, 1.39943883e-02f, 4.62540537e-02f, -6.40519708e-02f,
  1.09339707e-01f, 1.01258099e-01f, 5.62752336e-02f, -2.95039192e-02f, -2.95305271e-02f, 1.09191038e-01f, 2.80675497e-02f, 3.60596329e-02f, 1.85503140e-02f, 5.18060625e-02f,
  -1.26136746e-02f, -1.08372709e-02f, -7.08156824e-02f, -2.33351495e-02f, -1.50867980e-02f, 5.24096340e-02f, 9.02923122e-02f, -1.56332050e-02f, -1.14506921e-02f, -2.16040984e-02f,
  -2.17613876e-02f, -1.24978170e-01f, -9.36075225e-02f, 1.59082841e-02f, 3.25101875e-02f, -2.13694647e-02f, -8.06947052e-02f, -2.87385401e-03f, -3.93056450e-03f, -1.34837762e-01f,
  -7.88058281e-01f, 4.71146703e-02f, -5.39263263e-02f, -8.33946094e-03f, 1.97788864e-01f, 1.65379688e-01f, -2.38866918e-02f, 6.90048262e-02f, 8.01580176e-02f, 5.29833026e-02f,
  2.71402836e-01f, 2.16306180e-01f, 1.52814128e-02f, 7.13862255e-02f, -1.19541712e-01f, -7.20184818e-02f, -9.00927708e-02f, -2.45660499e-01f, -2.16605976e-01f, 1.47636682e-01f,
  7.41624236e-02f, -1.30882546e-01f, -2.41184220e-01f, -3.05141732e-02f, 6.22016424e-03f, 1.09620787e-01f, 1.47861410e-02f, 5.25158122e-02f, 1.01765499e-01f, -7.59729594e-02f,
  1.08794831e-01f, 1.02511607e-01f, 5.76414838e-02f, 1.10851280e-01f, 1.35101408e-01f, -6.43379241e-02f, 3.81520204e-02f, -2.00095065e-02f, -1.49922222e-02f, 1.79828592e-02f,
  7.90171921e-02f, 4.14694697e-02f, -4.02249210e-03f, 7.19747469e-02f, -7.74142072e-02f, -5.72182909e-02f, -1.17429338e-01f, -6.43742010e-02f, -8.24777558e-02f, 2.17196122e-02f,
  4.94473577e-02f, 1.11581579e-01f, -2.13937797e-02f, -5.30860387e-02f, -8.71082917e-02f, 2.74768043e-02f, 1.04498155e-01f, -2.95852637e-03f, 2.41606925e-02f, -7.51917437e-02f,
  3.76440063e-02f, 1.88137516e-02f, 1.84105560e-02f, -6.66254610e-02f, -3.15367505e-02f, 1.86200552e-02f, -1.95481796e-02f, -1.90508347e-02f, 9.66750737e-03f, -6.51604235e-02f,
  -4.40597087e-02f, 1.14961844e-02f, -1.32474517e-02f, -8.78494680e-02f, -1.87420957e-02f, 3.54129262e-02f, -6.10733917e-03f, 2.73042843e-02f, -3.31675336e-02f, 1.51240956e-02f,
  -2.27867998e-02f, 1.84259098e-03f, 3.79605927e-02f, 6.98318332e-02f, -4.90851887e-03f, -1.06786238e-02f, -5.18604890e-02f, 8.85669701e-03f, 8.34190100e-03f, 1.04244828e-01f,
  -5.40190302e-02f, 5.24087483e-03f, -7.87565410e-02f, -4.18369280e-04f, -4.25378792e-04f, 6.40397072e-02f, -2.97268778e-02f, -3.29339281e-02f, -1.44165186e-02f, 3.90106067e-03f,
  -7.41876196e-03f, -4.53442596e-02f, -3.71309705e-02f, 8.70203227e-02f, 6.16206080e-02f, 1.65650708e-04f, 2.13914923e-02f, -2.13290174e-02f, 5.01163006e-02f, 4.89773415e-02f,
  -6.96311891e-02f, -1.09520830e-01f, -1.38118967e-01f, -5.91271594e-02f, 7.56958947e-02f, -1.88725311e-02f, -1.20764196e-01f, -3.41399461e-02f, -1.34684876e-01f, -2.08667561e-01f,
  -2.93365628e-01f, -6.77154958e-02f, -3.11442912e-01f, -4.64137018e-01f, -3.16518277e-01f, 1.02777705e-02f, 6.41112328e-02f, -1.06231451e-01f, -3.11250929e-02f, -2.91751958e-02f,
  1.66592607e-03f, 7.19232857e-03f, 7.25203082e-02f, 7.42138326e-02f, 1.18048869e-01f, -8.48029032e-02f, -1.44565478e-01f, 4.23941463e-02f, -3.73695642e-02f, -9.45700333e-02f,
  -1.21242270e-01f, -2.67069340e-01f, -1.82370454e-01f, -7.26567209e-02f, -3.51293504e-01f, 3.74912098e-02f, 3.55454348e-02f, -2.03646049e-01f, 5.07565290e-02f, -4.20498013e-01f,
  -6.73799142e-02f, -2.28335142e-01f, 4.13054377e-02f, -5.78630306e-02f, -2.68276855e-02f, 6.71833679e-02f, -6.20888360e-02f, -3.13589573e-02f, 1.00588925e-01f, -3.12126372e-02f,
  -1.22618839e-01f, -1.22730313e-02f, -1.13008909e-01f, 1.96463838e-02f, -1.84843186e-02f, -7.92176276e-02f, 3.50617394e-02f, -5.50533347e-02f, 2.29996331e-02f, -6.42986521e-02f,
  -4.10299264e-02f, -1.25042126e-01f, -2.13484094e-01f, 1.93709675e-02f, 2.80122645e-02f, 4.30927388e-02f, -6.46243319e-02f, -8.15108493e-02f, 8.23967531e-02f, -3.65509256e-03f,
  1.65035296e-02f, 2.46995725e-02f, 7.79853538e-02f, 4.53189909e-02f, 1.95619296e-02f, 7.51062110e-02f, -6.30254149e-02f, 2.39145011e-02f, 3.48291956e-02f, -2.40764450e-02f,
  6.97036162e-02f, -6.76978705e-03f, -8.15827120e-03f, 2.95017827e-02f, 1.18757095e-02f, -8.05782750e-02f, -1.48892235e-02f, -3.87541093e-02f, 2.10192371e-02f, 4.76832353e-02f,
  -8.11283570e-03f, -1.71750169e-02f, -7.92173743e-02f, -5.13611920e-02f, 3.41832042e-02f, -1.03952467e-01f, 7.20301643e-03f, 1.66194364e-02f, -9.19388700e-03f, 1.16271935e-02f,
  9.53555387e-03f, 1.04354009e-01f, -4.30227444e-02f, 1.06036827e-01f, 1.71616394e-02f, 1.40749887e-01f, -9.39257350e-03f, 8.33305940e-02f, -2.75548697e-02f, -2.01244466e-02f,
  -2.07407586e-02f, 1.26450788e-02f, 4.09030123e-03f, 2.18259282e-02f, -6.26055896e-03f, 2.07858272e-02f, 5.55348992e-02f, 1.88058764e-02f, 9.83043835e-02f, 1.40913665e-01f,
  3.95942144e-02f, 1.29689366e-01f, 9.60123017e-02f, 5.96196391e-02f, -2.25621779e-02f, 7.52663612e-02f, 7.95858502e-02f, 4.16931883e-02f, 1.98313937e-01f, 2.34382436e-01f,
  -3.93790305e-01f, 3.54751199e-01f, -1.17566243e-01f, -5.90404160e-02f, 9.86948330e-03f, -3.47801447e-02f, 2.85651740e-02f, -1.64950788e-02f, 6.82700947e-02f, 1.41372755e-01f,
  1.18845239e-01f, -6.75008669e-02f, -4.14893739e-02f, -1.43968770e-02f, -2.04192176e-01f, 2.01611727e-01f, 9.71142501e-02f, -8.64125416e-02f, -3.87862772e-01f, -7.99408704e-02f,
  5.45368381e-02f, -3.95050012e-02f, -1.41947657e-01f, -1.92186862e-01f, 2.70526320e-01f, -1.19184613e-01f, 1.45917460e-01f, -5.93397766e-02f, 1.41825631e-01f, 3.48092467e-01f,
  3.16904336e-02f, 3.99754569e-03f, -3.77264768e-02f, -7.00455308e-02f, -6.21448271e-03f, -9.60615054e-02f, 2.96415035e-02f, -6.12095892e-02f, 6.87157586e-02f, -2.15081442e-02f,
  -5.44064194e-02f, 3.79934385e-02f, -9.56076235e-02f, -8.28749463e-02f, 4.36649211e-02f, -8.67532566e-02f, -9.25142244e-02f, -8.20636973e-02f, -5.07265106e-02f, -2.54961811e-02f,
  8.38706717e-02f, 4.36848924e-02f, 4.55436744e-02f, 2.84220092e-02f, -1.19907800e-02f, -5.56965061e-02f, -4.23970371e-02f, 1.72567163e-02f, -5.39714694e-02f, 1.20457776e-01f,
  2.70744264e-02f, 9.80549678e-03f, -1.35438731e-02f, -3.10940249e-03f, 2.42211297e-02f, 5.08789197e-02f, 1.37415333e-02f, 4.31059636e-02f, -2.30878908e-02f, 3.43406834e-02f,
  7.66559616e-02f, -3.94461490e-02f, 2.32882909e-02f, -4.97804023e-02f, 4.92088310e-02f, -6.79991767e-02f, -2.91631278e-02f, -7.74460360e-02f, -7.14043081e-02f, 7.39476010e-02f,
  7.59196952e-02f, -5.51804490e-02f, 6.30387291e-02f, -3.51698510e-02f, 3.36782709e-02f, -6.22101761e-02f, -4.57483232e-02f, -4.23034132e-02f, 2.95718070e-02f, 9.37015004e-03f,
  4.85722534e-02f, -1.81963906e-01f, 1.00106232e-01f, -1.23903304e-02f, 6.67987624e-03f, 8.66955891e-02f, 7.00837225e-02f, 2.98244916e-02f, 2.84086615e-02f, 5.47074042e-02f,
  -1.07712252e-02f, -7.31764883e-02f, 2.92611644e-02f, 1.20739071e-02f, -6.05119281e-02f, 3.62732932e-02f, 6.17079921e-02f, -3.23058926e-02f, -1.72260646e-02f, 1.11521579e-01f,
  5.09933382e-02f, 9.66830775e-02f, -4.17384543e-02f, 1.94905978e-02f, -2.01552734e-02f, -4.16037813e-02f, -4.00182679e-02f, 4.23659496e-02f, -9.90718007e-02f, 5.01117371e-02f,
  7.21771643e-02f, 1.46607354e-01f, 8.99356529e-02f, -2.51346022e-01f, -1.05521321e-01f, -8.00042897e-02f, 2.49482557e-01f, -5.99599741e-02f, -2.68704981e-01f, 1.27884403e-01f,
  -1.19049214e-02f, -1.40864283e-01f, -9.22083855e-02f, 1.90792475e-02f, 1.09803021e-01f, 2.77186148e-02f, -4.11061160e-02f, 4.78996895e-02f, -2.07173228e-01f, -5.18820016e-03f,
  -9.57310125e-02f, -1.41613754e-02f, -7.78795406e-03f, -1.69127032e-01f, 3.18730660e-02f, -3.90229039e-02f, 3.85962427e-02f, 7.63774738e-02f, 7.97480121e-02f, 1.77273586e-01f,
  2.46346444e-01f, 1.88786373e-01f, -9.55584124e-02f, -2.32853964e-02f, 8.18319097e-02f, -6.22475632e-02f, 2.73054447e-02f, 3.37919197e-03f, -1.20391259e-02f, 4.79601882e-02f,
  -4.30492386e-02f, -4.48523201e-02f, -1.42906770e-01f, -4.93112579e-02f, 2.53002029e-02f, -1.33761289e-02f, -3.00026555e-02f, 1.05448598e-02f, -4.56517600e-02f, 7.66367838e-02f,
  -1.03473896e-03f, -1.50981341e-02f, 1.41953349e-01f, 7.35409036e-02f, 6.68814108e-02f, -1.35969102e-01f, 1.41299531e-01f, 4.58039492e-02f, 6.26788735e-02f, 1.55940890e-01f,
  2.43308898e-02f, 5.94435865e-03f, 6.45046979e-02f, 3.02695502e-02f, 2.59176176e-03f, 3.82020436e-02f, -6.88212216e-02f, 7.59055540e-02f, 5.55087999e-02f, -1.96974035e-02f,
  5.36890142e-03f, 2.42921803e-02f, -6.90519139e-02f, 3.38767394e-02f, -8.84548873e-02f, -9.41851288e-02f, 8.64281692e-03f, -1.30830035e-02f, 4.85389084e-02f, -1.36708558e-01f,
  5.00984257e-03f, -6.49321526e-02f, 1.77250672e-02f, 6.09611422e-02f, -1.45099629e-02f, -2.18169149e-02f, -9.26661342e-02f, 2.72915531e-02f, -1.47588858e-02f, -1.15273781e-01f,
  -1.29002959e-01f, -7.08202971e-03f, -2.80167442e-02f, 2.03571077e-02f, -3.57075669e-02f, -1.36082936e-02f, 3.89945209e-02f, -7.04521686e-02f, 1.28681418e-02f, 3.59190442e-02f,
  8.64101723e-02f, 3.37228738e-02f, -2.33342182e-02f, 4.03802097e-02f, 2.03377977e-02f, 1.36018787e-02f, -1.67889036e-02f, -4.88879010e-02f, -2.93834582e-02f, -2.20453907e-02f,
  -1.00748455e-02f, -5.58985844e-02f, -3.94342951e-02f, -3.08323856e-02f, 7.33273253e-02f, -1.16433538e-01f, -4.52196300e-02f, 4.39851312e-03f, -1.73157938e-02f, -9.34150666e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.04111212e-01f, 9.50578321e-03f, -6.34431690e-02f, -5.01421019e-02f, -1.29545987e-01f, -1.18334666e-01f, -1.89910233e-01f, -5.65718822e-02f, -8.72913748e-02f, -2.04334721e-01f,
  -1.48818654e-03f, -5.92190493e-03f, -4.28656116e-02f, -9.48196575e-02f, -1.05033264e-01f, -1.85456440e-01f, -2.20817804e-01f, -9.23385248e-02f, -9.74979997e-02f, -5.46681024e-02f,
  -7.85511434e-02f, 6.83866516e-02f, 1.54140440e-03f, 1.31342784e-01f, 1.00108840e-01f, 1.71539113e-01f, 1.40437588e-01f, 9.69684497e-02f, 1.11988768e-01f, -8.31217244e-02f,
  -1.33556128e-01f, -5.62796295e-02f, -1.31709769e-01f, -5.92980161e-02f, 6.03919365e-02f, -3.04124579e-02f, -7.84360468e-02f, 4.18075174e-02f, 6.23064004e-02f, 8.44106078e-02f,
  5.55437542e-02f, -6.21571802e-02f, -7.92359412e-02f, 1.05857380e-01f, -4.57586395e-03f, 2.80516502e-03f, 1.40739620e-01f, 1.04245720e-02f, 1.22081032e-02f, 6.68171719e-02f,
  -5.25563248e-02f, -9.65608656e-03f, -1.74452402e-02f, 1.59379378e-01f, 9.11590308e-02f, -1.97589993e-02f, 1.83075622e-01f, 4.69743609e-02f, 1.09615058e-01f, 2.38862276e-01f,
  3.83432098e-02f, -5.32921739e-02f, -1.51919108e-02f, 1.36046171e-01f, -6.65580621e-03f, -2.40784399e-02f, 4.24564406e-02f, 1.01487450e-02f, 8.99235383e-02f, -4.15576883e-02f,
  2.24222057e-02f, -9.38500017e-02f, 4.32405360e-02f, 2.42062677e-02f, -2.39634234e-03f, -8.09090361e-02f, 3.01342532e-02f, -3.88602689e-02f, -2.74688806e-02f, -5.46323918e-02f,
  -2.00721435e-02f, 3.61453220e-02f, -7.72414263e-03f, 1.03014007e-01f, -3.48245353e-02f, 9.09842178e-02f, -3.20749730e-02f, -1.00120105e-01f, 3.92703107e-03f, -1.32815629e-01f,
  1.27079010e-01f, -1.33193180e-01f, -9.70709845e-02f, 4.74302359e-02f, 4.27322648e-02f, 6.56989291e-02f, -2.28908807e-02f, 1.33449840e-03f, 7.73092583e-02f, 2.72909235e-02f,
  3.52843404e-02f, -2.09639873e-02f, 2.62208004e-02f, -2.85119154e-02f, -3.81724015e-02f, -4.80960272e-02f, 3.00984886e-02f, 1.37918442e-01f, 1.50534352e-02f, -2.71770917e-02f,
  1.72069073e-02f, -5.11289127e-02f, -5.51455282e-02f, -2.14282908e-02f, 5.72689772e-02f, -7.49440938e-02f, -1.87929459e-02f, 1.35834545e-01f, 4.42872867e-02f, 3.10820155e-02f,
  -1.16472088e-01f, 1.29771218e-01f, 6.11474998e-02f, -1.14897281e-01f, -1.07091814e-02f, -1.02756463e-01f, -4.45236079e-02f, 3.99507629e-03f, -9.36487466e-02f, 3.94427143e-02f,
  6.43035769e-02f, 1.51360128e-02f, 1.22175328e-01f, 1.15600556e-01f, 6.30410612e-02f, 6.14160951e-03f, -1.00199625e-01f, -7.37901405e-02f, 9.10869166e-02f, 1.63330901e-02f,
  4.62202206e-02f, 5.01121692e-02f, -1.10017531e-01f, 7.05531910e-02f, -1.03523582e-01f, -3.60539630e-02f, -8.95640403e-02f, 9.98141710e-03f, -1.68966521e-02f, -1.28831238e-01f,
  2.19776750e-01f, -1.59447696e-02f, 6.58953786e-02f, 4.25889492e-02f, 1.13040589e-01f, 5.73663451e-02f, 8.61309990e-02f, -3.82258184e-03f, -4.12196368e-02f, 6.44492581e-02f,
  9.89460722e-02f, -5.62708941e-04f, -5.88751398e-02f, 9.88845080e-02f, -6.28752678e-05f, 1.51201980e-02f, 2.96384189e-02f, -1.37512293e-02f, -9.17637870e-02f, 1.08784273e-01f,
  8.65891874e-02f, -4.69331369e-02f, 7.42401928e-02f, 8.27666670e-02f, 5.03996611e-02f, -4.16509844e-02f, 1.21168204e-01f, -8.54879320e-02f, 1.72325072e-03f, -9.12443623e-02f,
  1.93472169e-02f, 8.90849438e-03f, -1.20119248e-02f, -1.08860629e-02f, 5.56549132e-02f, 6.64843991e-02f, -3.59875970e-02f, -9.20893904e-03f, 5.84188849e-02f, -2.30272356e-02f,
  2.13410538e-02f, 2.95386650e-02f, 7.96976015e-02f, -1.12007847e-02f, 4.19808887e-02f, -5.63033037e-02f, -3.61472741e-02f, 6.38899282e-02f, -5.22290869e-03f, -7.94591904e-02f,
  -4.25318368e-02f, -8.77679884e-02f, -3.81972007e-02f, -1.57126319e-02f, 4.24148589e-02f, -7.75552392e-02f, -3.20338737e-03f, -2.08406206e-02f, 8.23125020e-02f, 2.08239034e-02f,
  1.62479460e-01f, -4.02919911e-02f, -1.65554360e-04f, -2.64926571e-02f, -4.68729772e-02f, -6.80740103e-02f, 2.26841699e-02f, 5.26551623e-03f, -2.70153638e-02f, -3.76803875e-02f,
  5.65312132e-02f, 9.69271809e-02f, -1.62932128e-02f, 1.96655598e-02f, 1.16441406e-01f, -2.31406614e-02f, -5.31423390e-02f, 2.57990370e-03f, 1.14160134e-02f, 9.55245644e-02f,
  7.47779980e-02f, 5.46590723e-02f, -9.23370477e-03f, 4.54211496e-02f, 4.30908725e-02f, 4.98803705e-02f, 7.95566514e-02f, 6.58131316e-02f, 4.78982255e-02f, 1.50816903e-01f,
  -9.02171507e-02f, -3.82691808e-02f, -4.44188947e-04f, -7.30276853e-02f, -3.85823883e-02f, -1.09468531e-02f, -1.59731023e-02f, -3.48755009e-02f, -1.19496927e-01f, -4.60351817e-02f,
  6.53980300e-02f, -9.28005725e-02f, -8.94260406e-02f, -1.00316340e-02f, 8.92843455e-02f, -6.93620369e-02f, -3.25934328e-02f, -8.68922174e-02f, 4.01454270e-02f, -1.38675245e-02f,
  -5.41669726e-02f, -8.95942450e-02f, -1.27317950e-01f, 4.37040292e-02f, -7.71315545e-02f, -3.88191044e-02f, 7.18024224e-02f, 2.08224542e-02f, 7.93373305e-03f, -1.13645857e-02f,
  2.07410187e-01f, 2.43634414e-02f, 5.74394725e-02f, 5.99704422e-02f, -9.30239037e-02f, 7.65133500e-02f, 6.06255271e-02f, -1.02443919e-01f, -7.93190673e-02f, 9.20756236e-02f,
  -1.03707656e-01f, -2.71733906e-02f, 3.57273258e-02f, -2.86360225e-03f, 3.48351747e-02f, 4.13468815e-02f, 4.10516895e-02f, -6.44990876e-02f, -2.43097208e-02f, 9.44567397e-02f,
  -7.38137886e-02f, 6.00787513e-02f, 1.86609402e-02f, 5.25888465e-02f, 1.66196059e-02f, -1.30909653e-02f, 3.20295580e-02f, -1.86532624e-02f, 9.09802094e-02f, 8.43074247e-02f,
  -3.78407575e-02f, -1.50427064e-02f, -1.22050494e-02f, -6.96015581e-02f, -8.59449580e-02f, 6.46561831e-02f, -1.13581959e-02f, 1.85266826e-02f, -6.15802407e-02f, -4.38422821e-02f,
  -2.60319375e-02f, 1.38324285e-02f, 5.04785106e-02f, 7.43907839e-02f, 6.71958625e-02f, -2.24359501e-02f, -9.02906731e-02f, 6.48597851e-02f, 3.13234553e-02f, 2.03222893e-02f,
  -9.58150998e-02f, 2.03888305e-02f, 6.82496279e-02f, -7.35132247e-02f, -3.41178961e-02f, 5.32480627e-02f, -4.63689007e-02f, -2.28106994e-02f, -1.99363311e-03f, -9.36835259e-02f,
  8.38811845e-02f, 3.71674374e-02f, 4.41839024e-02f, -5.90757914e-02f, 4.62578684e-02f, -4.74059992e-02f, -5.23354858e-02f, 4.01364155e-02f, 4.23800536e-02f, 1.02868201e-02f,
  7.44532123e-02f, 5.68570644e-02f, -1.02011599e-02f, -7.02909008e-02f, 7.65113235e-02f, -5.90990707e-02f, 1.04110437e-02f, 8.31575040e-03f, 8.06345642e-02f, 7.89372325e-02f,
  7.99085647e-02f, -5.44694215e-02f, -1.75647307e-02f, 8.00015703e-02f, -8.45726877e-02f, 7.78207332e-02f, -2.12928858e-02f, -5.50501794e-02f, 1.08183816e-01f, 7.32176229e-02f,
  -3.22089195e-01f, -9.03034359e-02f, -2.27587633e-02f, -9.26396460e-04f, -1.40686482e-02f, 1.72849186e-02f, -3.07083521e-02f, 7.89282769e-02f, -6.20270669e-02f, 4.46877070e-02f,
  -4.38502394e-02f, 9.00742561e-02f, 4.91058417e-02f, 1.55597106e-02f, 2.07856018e-02f, 2.41419617e-02f, 1.87437460e-01f, 1.21256784e-01f, 5.88197596e-02f, 3.62306647e-02f,
  6.18658215e-02f, -4.17078733e-02f, -1.45426914e-01f, -5.04326634e-03f, 1.28690585e-01f, 1.32345483e-01f, 2.47376487e-02f, 6.97183385e-02f, -7.60383904e-02f, 2.25580558e-01f,
  -1.73241436e-01f, -1.64132297e-01f, -4.53865575e-03f, 1.56978928e-02f, -4.25951630e-02f, -2.49234680e-02f, -1.80788189e-02f, 6.91182688e-02f, -6.14905655e-02f, 4.79098260e-02f,
  6.72031194e-02f, 2.09696256e-02f, 8.39849114e-02f, -1.28101306e-02f, -3.17904688e-02f, -3.70730683e-02f, -1.11170180e-01f, -4.46994267e-02f, -6.37486130e-02f, -6.34930432e-02f,
  1.70493200e-02f, -5.06718494e-02f, -1.18829913e-01f, -2.49166097e-02f, -7.69665241e-02f, 6.94142655e-02f, -6.27809837e-02f, -6.80730352e-03f, -1.11675695e-01f, -2.04733456e-03f,
  7.39923045e-02f, -4.12711874e-03f, 2.25744173e-02f, -4.79594506e-02f, -3.75033207e-02f, 3.81876826e-02f, 6.18283972e-02f, 4.79692779e-02f, 7.01641887e-02f, 8.81200656e-02f,
  -6.66657090e-02f, -4.40916903e-02f, 5.70986010e-02f, 1.91143285e-02f, -2.25468017e-02f, 6.23906590e-02f, -8.69564861e-02f, 3.74450833e-02f, -7.88516700e-02f, -4.56546247e-02f,
  -5.31884097e-03f, -7.18644336e-02f, 3.04682227e-03f, 5.15057631e-02f, -2.19585914e-02f, -7.69306868e-02f, 5.00137955e-02f, -1.62988156e-02f, 3.72945964e-02f, -1.04626447e-01f,
  -7.98272267e-02f, -2.45035309e-02f, -2.47153640e-02f, 3.51461992e-02f, 1.34486286e-02f, -2.25543212e-02f, -1.05755836e-01f, 7.89159164e-02f, -4.22748178e-02f, -3.20924781e-02f,
  -1.20733254e-01f, 1.27799725e-02f, -1.97937042e-02f, -7.41372211e-03f, 4.43050452e-02f, -1.11522473e-01f, -5.17829321e-02f, 9.41023510e-03f, -1.42730903e-02f, -8.38060901e-02f,
  2.55294759e-02f, -2.66698701e-03f, -8.67417082e-02f, -7.77860964e-03f, -8.34328383e-02f, -2.21903995e-02f, -6.11340255e-02f, -8.90480876e-02f, -1.25821754e-01f, -1.48081034e-01f,
  -3.15291315e-01f, 6.78210752e-03f, -8.68758336e-02f, 7.96274468e-02f, 9.31930393e-02f, 1.48040161e-01f, 9.01759490e-02f, 2.01809540e-01f, 3.62879299e-02f, -6.28946275e-02f,
  -1.72534540e-01f, 5.80362119e-02f, -2.23975368e-02f, 8.65716338e-02f, 1.29777163e-01f, 1.37570292e-01f, 2.23757714e-01f, -4.91885357e-02f, -1.12315230e-02f, -2.38968767e-02f,
  1.16275005e-01f, 5.55721857e-02f, -1.98172212e-01f, 9.43803862e-02f, 9.79886875e-02f, -3.84023078e-02f, 5.95311001e-02f, 1.27336588e-02f, -1.34753004e-01f, 2.13425756e-01f,
  -9.44430307e-02f, -9.80954096e-02f, -1.29838260e-02f, -8.66210610e-02f, 3.92528586e-02f, -4.69831824e-02f, -2.37107817e-02f, -5.71223944e-02f, 6.18312508e-02f, -3.24759483e-02f,
  -5.63006736e-02f, -9.81541499e-02f, 5.76131679e-02f, 1.34477606e-02f, -1.12412028e-01f, -3.63207385e-02f, 2.75095031e-02f, -6.72881817e-03f, -1.41543988e-02f, 1.54902542e-03f,
  9.08258110e-02f, -3.85452583e-02f, -7.20272809e-02f, -2.62924600e-02f, -8.09969008e-03f, 3.76602709e-02f, -6.04966953e-02f, -1.03722014e-04f, -9.01413113e-02f, 6.10775985e-02f,
  -3.00555825e-02f, 8.32520425e-03f, 2.02910532e-03f, 5.80111220e-02f, 8.77527446e-02f, 8.81342292e-02f, -6.20770268e-03f, 4.86270599e-02f, -2.91824359e-02f, -5.49017005e-02f,
  -3.81614901e-02f, -1.09300073e-02f, 9.73701105e-02f, 2.39972193e-02f, -4.98618931e-02f, 1.98460035e-02f, 2.03683600e-02f, 4.88089547e-02f, 5.34567907e-02f, -9.20403749e-03f,
  -1.88283436e-02f, -8.13392550e-03f, -9.43266451e-02f, 4.54745516e-02f, -6.22517653e-02f, 1.14693437e-02f, -4.46545705e-02f, -5.30299619e-02f, 2.56063286e-02f, 2.34691184e-02f,
  1.22377723e-01f, -1.29086062e-01f, -2.53967214e-02f, 4.37244065e-02f, -7.19519407e-02f, -6.80030882e-02f, -1.24018036e-01f, -3.89939025e-02f, -2.58289203e-02f, -5.80744781e-02f,
  -8.02734271e-02f, 5.29108085e-02f, -7.52883330e-02f, 4.51910086e-02f, -7.81576559e-02f, 3.49860499e-03f, -6.99312165e-02f, -3.58157493e-02f, -8.31375942e-02f, -5.79180494e-02f,
  -5.42797633e-02f, -2.67442539e-02f, -4.81261238e-02f, 4.77282256e-02f, -4.82611060e-02f, -1.33705795e-01f, -6.47142977e-02f, -9.55505818e-02f, -9.84656364e-02f, 3.47081460e-02f,
  1.44793138e-01f, 1.93452790e-01f, -3.71405184e-02f, 2.05418896e-02f, -3.84573154e-02f, -1.27455845e-01f, 4.23484074e-04f, 8.35954398e-02f, -2.29238216e-02f, -3.80598418e-02f,
  3.84496944e-03f, 6.09922856e-02f, 1.16916530e-01f, 2.51450352e-02f, 1.37739912e-01f, -1.45767508e-02f, -1.74555779e-02f, 1.48174331e-01f, 8.50689784e-02f, -2.76825055e-02f,
  9.32284072e-02f, 1.97224766e-02f, 6.32225424e-02f, 8.61907750e-02f, 1.30419046e-01f, -8.06608573e-02f, 3.17393132e-02f, 4.74193729e-02f, 6.32978696e-03f, 2.51785308e-01f,
  6.02038018e-02f, 1.54817522e-01f, -1.49071053e-01f, 1.48476809e-01f, 7.77005851e-02f, 1.28999844e-01f, 7.07320496e-02f, 3.02279852e-02f, 5.30742593e-02f, -5.04005188e-03f,
  8.14416409e-02f, 1.47665748e-02f, -2.90133674e-02f, 4.71855514e-02f, 6.34134263e-02f, -8.08007736e-03f, 1.02544017e-01f, 1.49233416e-01f, 8.75441656e-02f, 1.21229440e-01f,
  3.30972932e-02f, 5.96874580e-03f, -1.63674671e-02f, 5.59970587e-02f, 1.06906131e-01f, 3.52823213e-02f, 1.20363377e-01f, 1.75080419e-01f, 2.21491866e-02f, 7.05445260e-02f,
  7.49988854e-03f, -1.24721982e-01f, 5.00999130e-02f, -6.16001226e-02f, 1.72767509e-02f, -1.28761292e-01f, -2.28796154e-02f, -3.17732133e-02f, -3.00599094e-02f, -8.82071182e-02f,
  5.36960065e-02f, -8.52931440e-02f, -1.21159088e-02f, 3.76792923e-02f, -1.43962562e-01f, 5.53096607e-02f, 6.09907731e-02f, -3.20644826e-02f, -6.36887848e-02f, 7.98415840e-02f,
  6.67089224e-02f, -2.22312305e-02f, 6.28727376e-02f, 4.23479937e-02f, 3.43396962e-02f, -2.90257242e-02f, 5.55680599e-04f, 6.31744266e-02f, 1.12549653e-02f, 8.52463841e-02f,
  -1.39308110e-01f, -1.15798891e-01f, 5.11435210e-05f, 1.51892960e-01f, 5.50087392e-02f, 8.61654654e-02f, 1.39564797e-02f, 2.11952366e-02f, -1.75806377e-02f, 7.36601278e-02f,
  1.06710948e-01f, 8.47213492e-02f, 2.58056819e-02f, -2.50748955e-02f, -4.19671787e-03f, -1.82070285e-02f, 1.21079627e-02f, 5.00948392e-02f, 6.78845420e-02f, 8.45145807e-02f,
  3.36488113e-02f, -1.24012217e-01f, -1.22095622e-01f, 1.24916928e-02f, 4.19387184e-02f, -6.05140030e-02f, -8.91084373e-02f, -1.37140248e-02f, 8.34861863e-03f, -1.06713332e-01f,
  -2.21776605e-01f, 7.92910578e-04f, 3.70325260e-02f, 2.08648831e-01f, 6.26422986e-02f, 1.94842711e-01f, 2.17420802e-01f, 1.36518627e-01f, 4.85807434e-02f, 1.19189173e-01f,
  6.34833202e-02f, 5.02798446e-02f, 9.10274610e-02f, 2.47261934e-02f, 1.02150999e-01f, 1.38982564e-01f, 1.98370740e-01f, -1.35632101e-02f, -6.14912761e-03f, 3.50006372e-02f,
  8.51187557e-02f, 2.74411403e-02f, -1.56457260e-01f, 5.27660698e-02f, 3.75945568e-02f, 9.26812291e-02f, 9.46734324e-02f, -7.08035519e-03f, -9.95975882e-02f, 5.18892594e-02f,
  -2.53795564e-01f, -1.46861151e-01f, 1.47633448e-01f, 3.53002585e-02f, 5.27068451e-02f, -1.12065472e-01f, 1.90601628e-02f, -5.01307994e-02f, -8.99995342e-02f, -1.86089277e-02f,
  2.95186136e-02f, -5.33057414e-02f, 6.90498799e-02f, -3.90234068e-02f, -7.59662017e-02f, -1.41977789e-02f, -1.50645839e-03f, 4.56243977e-02f, 1.23267928e-02f, -3.44765522e-02f,
  8.62523019e-02f, -2.52027400e-02f, -5.63239194e-02f, 1.18470848e-01f, 3.99082936e-02f, -6.03768192e-02f, -8.61560628e-02f, 3.46222110e-02f, 3.83090749e-02f, 4.80347611e-02f,
  7.90301412e-02f, -3.10200751e-02f, 5.02723232e-02f, -1.25373658e-02f, 5.68083897e-02f, -3.04882322e-02f, -2.69564651e-02f, 5.36962338e-02f, 1.74314994e-02f, 6.23707436e-02f,
  6.67761341e-02f, -3.48213100e-04f, -2.27597430e-02f, 3.63955945e-02f, -4.45532985e-03f, -2.32006833e-02f, 5.90978330e-03f, 1.31459832e-02f, 3.67893912e-02f, -8.41505826e-02f,
  1.40378922e-02f, -2.99625960e-03f, 3.66439745e-02f, 3.46680433e-02f, 5.53922588e-03f, 3.47299762e-02f, -6.27192631e-02f, 3.47606875e-02f, -3.32244076e-02f, -3.46834287e-02f,
  1.91219896e-02f, -5.28115742e-02f, 8.91407877e-02f, -5.72691411e-02f, 4.67555262e-02f, 3.11744027e-02f, 2.46179961e-02f, -4.74925116e-02f, -2.18624920e-02f, -4.40221019e-02f,
  -1.37112092e-03f, -8.92910957e-02f, -4.08517830e-02f, -1.40252132e-02f, 6.70105368e-02f, 5.23861237e-02f, -5.58712445e-02f, -1.34251276e-02f, 5.52077666e-02f, 4.70600761e-02f,
  5.60554750e-02f, -2.74083260e-02f, -9.79405344e-02f, 3.16849425e-02f, 3.99144292e-02f, -5.95414527e-02f, -7.08404556e-02f, -2.31909566e-02f, 8.15561600e-03f, 1.11854021e-02f,
  1.43569529e-01f, 6.61122659e-03f, 1.80482179e-01f, -7.43508041e-02f, -3.46031561e-02f, 1.75113790e-02f, 1.72116697e-01f, 5.72447255e-02f, -1.22467324e-01f, 1.02617238e-02f,
  1.12832107e-01f, 1.83965817e-01f, 1.93342015e-01f, 1.58662781e-01f, 1.21684380e-01f, 9.58049446e-02f, 1.79865863e-02f, -1.08098583e-02f, 1.87480047e-01f, 1.57988936e-01f,
  -1.07630022e-01f, 5.03450446e-02f, 4.00502458e-02f, -1.12815797e-01f, -4.38983366e-02f, 1.29354000e-01f, 1.54272774e-02f, -9.45528299e-02f, 9.24828351e-02f, -1.28650606e-01f,
  3.17803800e-01f, 2.89830100e-02f, -4.06139158e-02f, -6.71317428e-02f, 1.96997952e-02f, -1.06792515e-02f, 7.32517466e-02f, -1.54385909e-01f, 2.49036364e-02f, 5.87887317e-02f,
  5.34234382e-02f, -4.76322547e-02f, -8.81205723e-02f, -1.04033463e-01f, -7.61781111e-02f, 1.25596281e-02f, -7.68367723e-02f, -1.28087327e-01f, -5.19095315e-03f, -6.75221458e-02f,
  -2.19090376e-02f, -1.88045427e-02f, 1.19371213e-01f, 3.96495722e-02f, -1.00829855e-01f, 3.96070033e-02f, 1.49492258e-02f, -1.38317402e-02f, -1.27360756e-02f, -5.55097237e-02f,
  7.04659447e-02f, 4.98334840e-02f, 5.62097803e-02f, 8.84502428e-04f, 7.96614960e-02f, 3.04737780e-03f, 3.83939110e-02f, 5.53386509e-02f, 6.53625876e-02f, -7.23712966e-02f,
  6.44489378e-02f, 3.16782445e-02f, 1.89067628e-02f, 6.93460777e-02f, 2.00166437e-03f, -9.11555141e-02f, -5.74032702e-02f, -7.65975788e-02f, -2.39869729e-02f, 7.21423421e-03f,
  -5.20355590e-02f, -5.20777442e-02f, -8.86305887e-03f, 1.01567330e-02f, -1.06847810e-03f, -8.82831365e-02f, -3.45320106e-02f, -3.25831189e-03f, 3.66817340e-02f, 3.46275680e-02f,
  5.68817742e-02f, 2.72925217e-02f, 1.25569105e-01f, -6.14933334e-02f, -1.06544591e-01f, 6.32754415e-02f, 8.59313011e-02f, 2.95811123e-03f, -1.43035665e-01f, 2.88148616e-02f,
  -3.85244600e-02f, -6.92672506e-02f, -3.51016968e-02f, -2.30484903e-02f, 7.58889318e-02f, 8.00533369e-02f, -1.14823110e-01f, -2.49813627e-02f, -8.55146870e-02f, -6.02146760e-02f,
  -3.98206450e-02f, 4.08766419e-02f, 6.45507798e-02f, 8.46252143e-02f, -2.82854363e-02f, 7.70880580e-02f, 6.64569512e-02f, 6.21335134e-02f, 1.34771526e-01f, 1.07859090e-01f,
  -3.89600605e-01f, 1.14182629e-01f, 5.86994179e-02f, -1.46019250e-01f, -1.02368683e-01f, -3.74972112e-02f, 6.11720234e-02f, -1.53122783e-01f, -2.51780242e-01f, 5.92245124e-02f,
  6.76757544e-02f, 1.01434223e-01f, 9.37753469e-02f, 1.93909407e-01f, 8.50058571e-02f, 1.87388547e-02f, -1.15146972e-01f, -4.48423252e-02f, -3.13135749e-03f, 5.37389517e-02f,
  1.31338090e-01f, -2.86378972e-02f, 3.46458405e-02f, 3.22296806e-02f, -2.66718380e-02f, 1.24180235e-01f, 5.73857920e-03f, -5.36550619e-02f, 9.95237753e-02f, 3.61405499e-02f,
  5.01712441e-01f, -2.29623333e-01f, -4.68792729e-02f, -8.75107422e-02f, -2.74406392e-02f, -1.15386181e-01f, -4.72289622e-02f, -1.21330181e-02f, -1.11064494e-01f, -2.96535511e-02f,
  -1.14413621e-02f, -9.01220366e-03f, 1.99725721e-02f, 1.14532709e-02f, -4.99946214e-02f, -4.14490104e-02f, -2.62112822e-02f, -7.46955723e-02f, -6.71297014e-02f, -3.58964019e-02f,
  1.19168041e-02f, -1.53844267e-01f, -9.68696922e-03f, 8.44954699e-02f, -1.55514246e-02f, -2.33460143e-02f, 1.19113155e-01f, -8.40651318e-02f, 1.43585401e-02f, 4.16879356e-02f,
  -4.04448733e-02f, 1.12219490e-02f, -4.68546040e-02f, -6.64057806e-02f, 1.35512883e-02f, 4.05285954e-02f, 2.64806170e-02f, 1.09950319e-01f, -3.31638195e-02f, 6.51907027e-02f,
  -2.12417543e-02f, 7.98436254e-03f, -3.59115563e-02f, 2.37236489e-02f, 3.05322610e-04f, -1.82700418e-02f, 5.44377901e-02f, 8.40631649e-02f, -3.58473733e-02f, -8.09245929e-02f,
  6.09052777e-02f, -8.47688876e-03f, -3.95158585e-03f, 3.50418799e-02f, -3.34019251e-02f, -7.53384605e-02f, -2.72265403e-04f, 6.59855232e-02f, -9.91227478e-02f, -6.08380772e-02f,
  2.35670730e-01f, -1.87026650e-01f, 7.40217716e-02f, -1.72235593e-02f, -2.86531076e-02f, -3.14521231e-02f, -1.28773898e-02f, 2.81236582e-02f, -6.67860871e-03f, 5.29138446e-02f,
  3.75606976e-02f, -3.57712768e-02f, 3.10219750e-02f, 9.87933297e-03f, 3.59558826e-03f, 1.24819033e-01f, -1.61705185e-02f, 8.06262866e-02f, -6.64305538e-02f, -1.11190945e-01f,
  -8.82524475e-02f, 3.92963961e-02f, 1.85768560e-01f, 1.15352191e-01f, 2.85525341e-03f, -1.31826075e-02f, 1.64881483e-01f, 1.76888391e-01f, 3.84003222e-02f, 2.06702471e-01f,
  8.10579434e-02f, -1.61950424e-01f, -4.13752496e-02f, 8.67630094e-02f, -1.34290799e-01f, -1.35242399e-02f, -9.65231061e-02f, 8.64873454e-03f, 8.68928805e-02f, -7.82277808e-02f,
  -8.18372369e-02f, 1.59257744e-02f, 1.40023246e-01f, 5.72715476e-02f, 1.84045300e-01f, 5.78665584e-02f, 7.02846497e-02f, 5.99034503e-02f, -3.73516395e-03f, 2.83588022e-02f,
  -1.35506224e-02f, -6.88375309e-02f, 1.98310055e-02f, -5.56164011e-02f, 6.84728324e-02f, 7.77683556e-02f, -8.36787093e-03f, -1.12888329e-01f, 7.31287478e-03f, 1.04297414e-01f,
  3.74002904e-02f, 7.91347548e-02f, 8.26984048e-02f, 1.92825403e-02f, -1.28250137e-01f, 4.67579886e-02f, -1.01059809e-01f, 6.98671341e-02f, 4.14956249e-02f, 4.67224978e-03f,
  -1.15683936e-01f, -8.23256522e-02f, 1.09714992e-01f, -3.67067643e-02f, 3.72753739e-02f, -4.20118608e-02f, -1.60551164e-02f, 1.24332011e-01f, 1.21064246e-01f, -5.89534529e-02f,
  5.14692329e-02f, -5.86442202e-02f, -2.94110831e-02f, 3.41697782e-02f, 1.22676797e-01f, 6.77829459e-02f, -1.18433952e-01f, 3.37677523e-02f, 4.98870574e-03f, 4.82489355e-02f,
  -3.14782076e-02f, 5.95367253e-02f, -4.85500135e-02f, -3.28765530e-03f, -9.63488594e-02f, -2.82932017e-02f, 9.02134255e-02f, -8.07587504e-02f, -2.71214936e-02f, -1.66831449e-01f,
  -5.59989884e-02f, 5.07193357e-02f, 1.29965007e-01f, -3.98350284e-02f, 2.51765568e-02f, -6.04388164e-03f, -3.18091922e-02f, -1.46071568e-01f, 2.91567426e-02f, 2.13961992e-02f,
  4.97757010e-02f, 5.05708456e-02f, -2.35761106e-02f, -4.28816639e-02f, 5.19918725e-02f, 9.47208703e-02f, -1.05280310e-01f, -1.81620270e-02f, -3.89486626e-02f, -1.55091453e-02f,
  -4.49931361e-02f, 1.05281390e-01f, 1.54639155e-01f, 3.77326868e-02f, 6.34660944e-02f, 2.66963169e-02f, 4.68745083e-02f, 9.27230436e-03f, 5.88636585e-02f, 1.65992845e-02f,
  1.35611966e-02f, -4.07426469e-02f, -4.23843190e-02f, 5.35543524e-02f, -7.38986651e-04f, 5.37073426e-02f, -3.60417925e-02f, 1.13262340e-01f, 6.00519143e-02f, 1.29207484e-02f,
  -5.37140593e-02f, 5.28561585e-02f, 5.27474582e-02f, 5.60751222e-02f, -1.57999508e-02f, 9.93099064e-02f, -9.55262333e-02f, -4.20051888e-02f, -5.39370850e-02f, -6.54656142e-02f,
  1.28908068e-01f, -2.01408640e-01f, 2.06543788e-01f, 3.00023258e-02f, 1.27279252e-01f, 3.35813053e-02f, -1.20670535e-02f, -8.38784203e-02f, 3.75067778e-02f, -4.98959832e-02f,
  5.86605482e-02f, 9.47968364e-02f, 1.19724937e-01f, 1.22914366e-01f, -1.35989729e-02f, -3.28646675e-02f, -7.68572837e-02f, 5.76740168e-02f, 2.17302397e-01f, 1.27632827e-01f,
  -1.01731889e-01f, -5.36640408e-04f, 7.15421140e-02f, 6.09145947e-02f, -1.77272215e-01f, 8.78992453e-02f, 2.65982393e-02f, -7.67291263e-02f, -5.16011380e-03f, -2.26028547e-01f,
  1.06482759e-01f, -3.06515228e-02f, 1.44764066e-01f, -6.45116996e-03f, -4.79682162e-02f, 3.98549400e-02f, -5.45687266e-02f, 5.94111942e-02f, 3.63914408e-02f, -5.38899936e-02f,
  1.13407053e-01f, 6.52717799e-02f, -8.46881419e-02f, -2.48092096e-02f, -4.66997037e-03f, 5.55021018e-02f, -5.41043915e-02f, 1.01445047e-02f, -6.90195709e-02f, 9.10880417e-02f,
  -6.24294393e-02f, -9.13461857e-03f, 9.48163643e-02f, -7.54616335e-02f, 5.74174114e-02f, 3.75316688e-03f, -4.11173813e-02f, -4.47083451e-02f, 9.59379133e-03f, -7.54886940e-02f,
  5.66357262e-02f, 1.22933241e-03f, -3.11669949e-02f, -5.92760667e-02f, 1.98145714e-02f, 2.44197752e-02f, 7.23886192e-02f, 5.23914136e-02f, 3.57683189e-02f, 3.10113803e-02f,
  6.05990142e-02f, 3.86474530e-05f, 5.77724501e-02f, -4.46931534e-02f, -8.44620466e-02f, 1.46471737e-02f, -8.39098450e-03f, -3.45816277e-02f, -4.32028733e-02f, -3.41349654e-02f,
  5.09328917e-02f, -7.16910064e-02f, -8.54463130e-02f, -3.95902023e-02f, -1.09512217e-01f, -4.14675213e-02f, 4.30918522e-02f, -6.32978836e-03f, 9.01547968e-02f, 7.29745328e-02f,
  3.74707952e-02f, 6.57687709e-02f, 1.39033690e-01f, 2.38942970e-02f, -6.33366853e-02f, -6.82443753e-03f, 9.85474885e-02f, 8.82539898e-02f, -1.78704932e-02f, -4.09256183e-02f,
  -1.43260118e-02f, 1.46167189e-01f, -1.65792853e-02f, -1.10490896e-01f, 8.32450464e-02f, -6.67839870e-02f, -4.03389223e-02f, 1.14900582e-01f, -8.41863081e-02f, 1.00544319e-01f,
  1.87842045e-02f, 8.56422856e-02f, 9.12569240e-02f, 7.39692748e-02f, 7.78670087e-02f, 1.89836606e-01f, -7.25863688e-03f, -3.13752256e-02f, 7.35166296e-02f, 7.59198284e-03f,
  -5.64920120e-02f, -1.95177123e-01f, -1.28628090e-01f, 1.69838265e-01f, -1.50268346e-01f, -2.89137773e-02f, -2.29392365e-01f, 8.44373778e-02f, 2.15242460e-01f, -1.19054511e-01f,
  -8.06592479e-02f, 1.03265755e-01f, -2.73667388e-02f, -1.34241777e-02f, 1.38475373e-02f, -2.38118753e-01f, -1.32830337e-01f, -1.13912001e-01f, 7.77681991e-02f, 9.54344496e-02f,
  -9.11889747e-02f, 8.88791382e-02f, -5.82552105e-02f, -1.50672505e-02f, -1.60288617e-01f, -9.39586088e-02f, -1.81392401e-01f, -1.91355690e-01f, -1.81172773e-01f, -4.40707028e-01f,
  -2.63140023e-01f, 1.90232411e-01f, 5.26221655e-02f, -1.43639641e-02f, -1.71865225e-01f, -4.71742311e-03f, 3.40393186e-02f, -6.62578270e-02f, 6.41542152e-02f, -3.07213832e-02f,
  -4.88164611e-02f, 2.06152350e-02f, 1.96635835e-02f, -1.26543595e-02f, 7.02628568e-02f, 9.77565651e-04f, 2.61384845e-02f, 7.29483645e-03f, -2.31127813e-02f, -5.01165688e-02f,
  1.74904559e-02f, -6.42100275e-02f, -4.44238670e-02f, -1.15686050e-02f, -1.04721040e-02f, -4.47578914e-02f, -3.11684031e-02f, -3.62612829e-02f, -1.37731940e-01f, -2.58692145e-01f,
  -8.63339603e-02f, 5.83136082e-02f, -3.18769813e-02f, 7.37732872e-02f, -3.16933393e-02f, 4.59593274e-02f, -5.42913526e-02f, -4.52930927e-02f, 2.72575188e-02f, 1.70748830e-02f,
  -7.90437311e-03f, 3.90814878e-02f, 6.97278753e-02f, 3.72360609e-02f, -5.86821958e-02f, -9.33388472e-02f, -1.20401243e-02f, -8.89006928e-02f, 3.34328264e-02f, -2.46199276e-02f,
  -4.80588488e-02f, -4.17087004e-02f, -4.18845154e-02f, 9.10903513e-02f, 2.58080736e-02f, -5.20650782e-02f, -2.36859713e-02f, 7.45648816e-02f, 5.70288897e-02f, -2.70977654e-02f,
  -7.41902739e-02f, 2.50198487e-02f, 3.98403034e-02f, 3.47375660e-03f, -1.93731510e-03f, 1.15084061e-02f, -8.09957162e-02f, -4.20953743e-02f, 2.70747710e-02f, -3.63423750e-02f,
  1.12082791e-02f, -3.93191390e-02f, -4.86572012e-02f, -4.24139537e-02f, 5.75720966e-02f, 2.63316724e-02f, -1.11509494e-01f, -1.15516856e-01f, 2.65942868e-02f, 3.11713666e-02f,
  -4.84297201e-02f, 3.02662291e-02f, 1.22843720e-02f, -6.46213219e-02f, 9.16793360e-04f, -1.31522596e-01f, -4.99722511e-02f, -4.21994962e-02f, -1.64003357e-01f, -2.12725118e-01f,
  -1.31735191e-01f, -3.60888951e-02f, -4.98661213e-02f, -3.07640005e-02f, 9.75011960e-02f, -4.54833061e-02f, -1.50572062e-01f, -3.88989709e-02f, 2.61360928e-02f, -6.84630200e-02f,
  -5.16963899e-02f, -4.17130366e-02f, 2.75690127e-02f, -6.67152032e-02f, -2.36657426e-01f, 5.14002144e-02f, 4.06782748e-03f, -1.27057552e-01f, -2.24360242e-01f, 2.20702160e-02f,
  -7.20796436e-02f, -1.69910952e-01f, -1.72131266e-02f, -2.36008372e-02f, 9.72162411e-02f, -2.75102141e-03f, 7.47959912e-02f, 7.80190453e-02f, -6.89178472e-03f, 9.70247835e-02f,
  1.30571097e-01f, 5.60766272e-02f, -5.49538881e-02f, -1.03779174e-01f, -5.69511130e-02f, 1.97043791e-02f, -1.82528365e-02f, 3.03710643e-02f, 9.17692706e-02f, -1.44584142e-02f,
  -7.83435851e-02f, -4.28955667e-02f, -4.21650987e-03f, -1.26008168e-01f, -1.51429564e-01f, -6.78227320e-02f, -1.87247545e-02f, -2.99344435e-02f, -8.23303983e-02f, -2.69641783e-02f,
  -2.37372499e-02f, -6.96237162e-02f, -1.46444604e-01f, -2.28653140e-02f, -2.14807596e-02f, -5.93342260e-02f, -1.06529847e-01f, 4.62882444e-02f, 6.91726292e-03f, -8.19109231e-02f,
  2.69538537e-02f, 1.67673677e-02f, 4.20607952e-03f, -2.05872580e-03f, -4.43418175e-02f, -1.55187128e-02f, 7.02474713e-02f, 1.26060862e-02f, -1.25958677e-02f, -7.88427591e-02f,
  -7.74373487e-03f, 5.38529083e-02f, 4.91351672e-02f, 1.04171671e-01f, -2.40146648e-02f, 1.47457523e-02f, -2.70632226e-02f, 7.36926217e-03f, 5.67579046e-02f, -3.41744237e-02f,
  1.68392155e-02f, 6.14424199e-02f, -5.09690121e-02f, -6.14009351e-02f, 1.48422876e-02f, 5.04095480e-03f, -5.32623753e-03f, -2.35116817e-02f, -4.14743759e-02f, 3.66395265e-02f,
  -1.89749524e-01f, 1.44186122e-02f, 5.43530099e-02f, -4.58911397e-02f, 9.62339044e-02f, 6.16150722e-02f, 5.37934713e-02f, 6.23821355e-02f, 6.91432357e-02f, -1.40203893e-01f,
  1.81695838e-02f, 6.03545224e-03f, -6.25151247e-02f, -1.49544641e-01f, -1.20665707e-01f, -9.38136578e-02f, -2.11002707e-01f, -8.61383006e-02f, -9.46313739e-02f, -4.29356135e-02f,
  -1.35902390e-01f, -1.67932689e-01f, -7.55516663e-02f, -1.07660823e-01f, 5.47847971e-02f, -1.12426996e-01f, -9.22794789e-02f, -9.57684219e-02f, -1.20784573e-01f, -1.73293024e-01f,
  3.10049295e-01f, 7.28604272e-02f, -5.08311391e-03f, 4.93297651e-02f, 6.54178113e-03f, -7.89724663e-02f, -9.04445723e-02f, -4.87244017e-02f, 3.10958084e-02f, 4.01436649e-02f,
  -4.69780080e-02f, 1.57835837e-02f, 7.21796881e-03f, 4.29798104e-02f, 1.30855009e-01f, -1.06521603e-02f, 1.55519336e-01f, 1.81663156e-01f, 8.86156857e-02f, 1.46345407e-01f,
  3.94676737e-02f, 1.58653744e-02f, 1.59010723e-01f, 1.45270318e-01f, 1.20235167e-01f, -5.84422536e-02f, 3.52728739e-02f, 1.52854696e-01f, 3.57145979e-03f, 2.99199224e-01f,
  1.23420045e-01f, -2.62123551e-02f, -1.10758334e-01f, -8.41066614e-02f, -7.12082386e-02f, 4.57295552e-02f, -4.66284994e-03f, 6.55733794e-02f, -1.17634058e-01f, 8.79962966e-02f,
  -4.35662083e-03f, -8.11781809e-02f, -7.46413097e-02f, 4.42655459e-02f, 4.99753430e-02f, -8.33575707e-03f, 9.69854742e-02f, 1.22711375e-01f, -3.84692289e-02f, 9.91812348e-03f,
  -5.16608581e-02f, -8.01605210e-02f, 5.88612184e-02f, -1.01257257e-01f, 5.66973351e-02f, 4.79675122e-02f, -1.20188463e-02f, 5.38611077e-02f, 3.09154335e-02f, 1.65502176e-01f,
  7.08719790e-02f, -1.43707674e-02f, 4.66630347e-02f, -6.65455416e-04f, -1.06477430e-02f, 6.76128827e-03f, 5.19258343e-02f, 3.40940394e-02f, 1.10810570e-01f, 1.05852284e-01f,
  -4.37073549e-03f, -9.50683001e-03f, -4.26460244e-02f, -2.82491576e-02f, -2.00398397e-02f, 2.22220160e-02f, 4.23627049e-02f, 1.14892282e-01f, -4.32493873e-02f, 1.02305803e-02f,
  2.85997558e-02f, -3.65918055e-02f, 5.64138591e-03f, 3.40906009e-02f, 4.84683886e-02f, -4.76477481e-02f, 5.55051155e-02f, -1.00063952e-02f, -4.25712951e-02f, 7.08345249e-02f,
  5.53085357e-02f, -1.18070751e-01f, -7.86874443e-03f, -2.03668661e-02f, -1.76593363e-02f, -3.21695879e-02f, -7.36610498e-03f, 4.49724309e-02f, -1.63652133e-02f, -7.12133721e-02f,
  -2.98907366e-02f, -4.70552295e-02f, -5.94560690e-02f, -5.79159297e-02f, -5.17662987e-02f, 2.55682748e-02f, -1.15166135e-01f, -2.71653407e-03f, -4.59988192e-02f, 1.93101019e-02f,
  -5.95483044e-03f, -6.02570847e-02f, -9.33829173e-02f, -3.62640731e-02f, 1.00564454e-02f, 1.49240158e-02f, 9.59651470e-02f, -4.33275811e-02f, 8.71077180e-03f, -9.03788954e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.25890654e-02f, -7.27056935e-02f, -6.02849796e-02f, 3.20433266e-02f, -6.63494095e-02f, 1.46006227e-01f, -3.78770195e-02f, 1.46757394e-01f, -2.33541578e-02f, 1.57269731e-01f,
  2.01585323e-01f, -7.91304838e-03f, -2.32457127e-02f, -6.64301729e-03f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.69887453e-01f, 2.80431181e-01f, -2.93156393e-02f, 5.87847866e-02f, 4.61138003e-02f, 1.44862458e-01f, 6.53951988e-02f, 2.46388033e-01f, 1.40495315e-01f, -2.22352594e-01f,
  2.38094985e-01f, 2.20693409e-01f, 3.08669303e-02f, -2.89235085e-01f, 1.31952062e-01f, 2.26662174e-01f, 4.46845889e-01f, 6.12641871e-02f, -5.36421686e-02f, -1.71926245e-01f,
  1.29917040e-01f, -2.55851597e-01f, -2.86486179e-01f, 3.18077773e-01f, -2.67059505e-01f, 1.96546063e-01f, -1.45955784e-02f, -5.03614806e-02f, -1.96258128e-01f, -1.70918763e-01f,
  2.08520636e-01f, 2.66854405e-01f, 1.25360429e-01f, -5.56998998e-02f, -7.59528428e-02f, -4.92502116e-02f, 2.76147258e-02f, 1.97933272e-01f, 6.64081350e-02f, -1.86875165e-02f,
  1.36954496e-02f, -2.01824084e-01f, 6.41576201e-02f, 2.21987143e-01f, -3.98583598e-02f, 8.65618736e-02f, 4.32760686e-01f, 2.81185865e-01f, 3.18198621e-01f, -1.40367389e-01f,
  2.40092829e-01f, 5.96950874e-02f, 7.83124641e-02f, -2.25375984e-02f, -5.93171455e-02f, -1.12642758e-01f, -1.28453821e-01f, 5.55988662e-02f, 2.79987335e-01f, -1.49968639e-01f,
  4.12224745e-03f, -1.01710990e-01f, 1.91422030e-01f, -1.54653341e-01f, 1.38927707e-02f, -1.38522372e-01f, 6.96522370e-02f, -2.29856223e-01f, 2.12857779e-02f, -3.03998083e-01f,
  -1.13927834e-01f, -2.70276487e-01f, 2.81031169e-02f, -3.38061750e-02f, -2.60155052e-01f, 1.57435343e-01f, 4.47927743e-01f, 4.42171782e-01f, 2.92969435e-01f, 6.12139553e-02f,
  9.52943712e-02f, 1.02718450e-01f, 1.18243963e-01f, -1.15381896e-01f, -5.55146718e-03f, 2.91909724e-01f, 8.79504830e-02f, 2.72035360e-01f, 6.06063232e-02f, -2.04957038e-01f,
  -2.45900184e-01f, 1.85583964e-01f, -2.47830242e-01f, 1.09569751e-01f, 2.46826172e-01f, 1.67098418e-01f, -2.07508028e-01f, 2.10928872e-01f, 1.69321477e-01f, 2.07525879e-01f,
  -6.63776547e-02f, -1.31017283e-01f, -3.55693102e-01f, 1.42841591e-02f, 8.55749175e-02f, -4.90440041e-01f, 3.75593513e-01f, 2.72443295e-01f, 4.80350047e-01f, -3.30327153e-01f,
  1.75733879e-01f, -2.53061324e-01f, 4.45279747e-01f, 4.59656596e-01f, -2.37152159e-01f, 1.41528994e-01f, 2.10432768e-01f, -1.18062884e-01f, 9.49178785e-02f, 3.48390698e-01f,
  -1.76273346e-01f, -2.44775474e-01f, -3.30282049e-03f, -1.16812989e-01f, -3.33754957e-01f, -2.41753414e-01f, 2.48878360e-01f, 4.57417034e-02f, -1.23745322e-01f, -4.63867113e-02f,
  7.24448040e-02f, 2.31530011e-01f, -1.60840243e-01f, 1.25008643e-01f, -3.29453140e-01f, 6.63945749e-02f, -1.16476119e-01f, 2.18240142e-01f, 1.87430650e-01f, 4.27827239e-02f,
  -9.39589888e-02f, -2.44542480e-01f, -4.14654940e-01f, 1.23726381e-02f, -1.72545195e-01f, 2.16946915e-01f, -2.81708956e-01f, -1.54180586e-01f, 1.19779214e-01f, -5.49222976e-02f,
  9.80971232e-02f, 2.44613618e-01f, -5.53787462e-02f, -5.03463522e-02f, -2.84715414e-01f, -9.91204306e-02f, 1.41060859e-01f, 2.70714071e-02f, -1.46791548e-01f, -4.51978017e-03f,
  3.12018357e-02f, 6.37152866e-02f, 4.18792851e-02f, -1.53641760e-01f, -5.33771887e-02f, -1.88071340e-01f, 1.69902533e-01f, -7.21928030e-02f, -3.42573784e-02f, -3.26484531e-01f,
  6.29048347e-02f, 7.87045583e-02f, -9.74231958e-02f, -2.11879402e-01f, 3.12042624e-01f, 3.31407160e-01f, 2.98372030e-01f, 2.04422668e-01f, 2.42333114e-01f, 1.57502905e-01f,
  1.39452472e-01f, -1.57486022e-01f, -1.48823470e-01f, -1.48838582e-02f, -9.03511718e-02f, -1.09876454e-01f, 1.81313202e-01f, -1.98756635e-01f, -2.07268566e-01f, 2.25542381e-01f,
  1.34786755e-01f, -2.36623988e-01f, 4.34476584e-02f, 1.46425366e-01f, 8.98738205e-02f, -1.68329049e-02f, -1.67445883e-01f, 2.01134354e-01f, -6.87437281e-02f, -6.14076927e-02f,
  -2.90263444e-02f, -7.11994395e-02f, 1.02271788e-01f, -9.26198736e-02f, -4.47976559e-01f, -2.07258672e-01f, 1.60298198e-02f, 1.81374416e-01f, -2.51903206e-01f, -4.48512891e-03f,
  1.00806728e-01f, -1.91939585e-02f, 8.30653217e-03f, -1.72231525e-01f, -2.51826465e-01f, -9.92547199e-02f, -1.79709613e-01f, 2.80508757e-01f, -1.33714557e-01f, -2.14177743e-01f,
  1.82787120e-01f, 1.00934155e-01f, 4.26413082e-02f, -1.70062661e-01f, 1.65495828e-01f, -6.23676814e-02f, 3.76373902e-02f, 1.22465335e-01f, -3.98059599e-02f, -1.80557400e-01f,
  1.20052911e-01f, -6.44331947e-02f, 1.09783024e-01f, -2.69724309e-01f, 1.61088407e-02f, 1.10852465e-01f, -1.60433918e-01f, 1.86506227e-01f, 1.71488866e-01f, 2.31509224e-01f,
  2.19015047e-01f, 5.85170053e-02f, -1.31555781e-01f, 1.11044168e-01f, -1.06016777e-01f, 3.50704677e-02f, -8.81180763e-02f, 1.22363605e-01f, 1.41645148e-02f, -2.12917626e-01f,
  -2.83431619e-01f, 7.10342228e-02f, -1.77851886e-01f, 2.40692765e-01f, 2.14599371e-01f, -1.96582913e-01f, -2.82754283e-02f, -2.69387424e-01f, 1.98046807e-02f, 1.92936927e-01f,
  8.36074278e-02f, 3.28833200e-02f, -1.31260782e-01f, -9.71211568e-02f, 4.36451472e-03f, -2.88344435e-02f, 2.01475799e-01f, -4.54796433e-01f, 4.15372327e-02f, 8.71244632e-03f,
  8.56543928e-02f, -3.56684811e-02f, -7.20852315e-02f, -1.44889414e-01f, 4.07403614e-03f, 2.86381274e-01f, 1.40709430e-01f, 1.35685876e-02f, 1.59007847e-01f, -1.86318364e-02f,
  2.13590249e-01f, 1.08724982e-01f, 1.25021622e-01f, -1.04940765e-01f, 3.44907194e-02f, 9.04781520e-02f, -2.31933832e-01f, -3.17438215e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.72723560e-02f, 1.71839535e-01f, -7.79618025e-02f, 1.78749278e-01f, 1.23648584e-01f, 6.61361739e-02f, -2.01954156e-01f, 7.98145309e-02f, 1.04063183e-01f, 9.47894379e-02f,
  -2.68212527e-01f, -7.91646838e-02f, 1.11413747e-01f, 7.48940036e-02f, -3.25617075e-01f, 6.53829873e-02f, -2.12484911e-01f, 1.11668728e-01f, -9.45295691e-02f, -2.40071639e-01f,
  6.69251978e-02f, -1.57449588e-01f, 1.67571425e-01f, 7.58036897e-02f, -3.21129113e-02f, 2.42106393e-02f, -2.92099178e-01f, 1.50889769e-01f, -1.67684048e-01f, 2.81793743e-01f,
  -9.91944820e-02f, 2.52987951e-01f, 1.83692053e-01f, 3.79104286e-01f, 7.33964518e-02f, -1.59783810e-01f, 2.36316621e-01f, 2.25810051e-01f, 1.98634062e-02f, 1.08293936e-01f,
  3.45513523e-01f, 1.56394869e-01f, -1.30461395e-01f, 2.67217964e-01f, 4.46442783e-01f, 4.15263921e-01f, 4.97152023e-02f, -1.92382872e-01f, 3.23812872e-01f, -9.95582640e-02f,
  1.83672085e-01f, 1.34688094e-01f, 1.76648602e-01f, 3.58563542e-01f, 2.38774791e-01f, 7.67165422e-02f, 3.99681889e-02f, -1.16524100e-01f, -1.26913965e-01f, 2.90948134e-02f,
  5.09801954e-02f, 1.55877665e-01f, 2.93272108e-01f, -7.37549141e-02f, 2.56890841e-02f, 2.55189277e-02f, 1.90999851e-01f, 1.70940384e-02f, 1.59449831e-01f, 1.13291420e-01f,
  -4.49139588e-02f, -7.10466132e-02f, 1.07619315e-02f, 1.12065382e-01f, -1.93796575e-01f, -2.49559343e-01f, -2.94577926e-02f, 4.36706133e-02f, 4.54738811e-02f, 1.57911181e-02f,
  -9.66723561e-02f, 4.98233363e-02f, 9.33018327e-02f, 2.26168465e-02f, 1.82869673e-01f, -1.41774684e-01f, 4.75289207e-03f, -2.73307174e-01f, -8.21469054e-02f, 1.20139837e-01f,
  3.73857021e-01f, -6.46479651e-02f, -3.12652029e-02f, -2.14560866e-01f, -8.81459936e-02f, -1.81446835e-01f, 2.07294703e-01f, 2.29886279e-01f, 6.95889443e-02f, -2.08538562e-01f,
  1.29863128e-01f, 4.11870470e-03f, 1.91359445e-01f, 1.56439617e-01f, 5.50934225e-02f, 5.34810424e-02f, -1.07793644e-01f, 3.82574886e-01f, -2.67444551e-01f, 1.23080447e-01f,
  2.03852490e-01f, 3.60515863e-02f, -5.89417964e-02f, -3.00345182e-01f, 2.13284820e-01f, -1.10901088e-01f, -1.70623079e-01f, 1.75411776e-02f, -3.46596166e-02f, 8.73070434e-02f,
  -6.94696903e-02f, -1.32286012e-01f, -2.71241307e-01f, -1.91427723e-01f, 3.92274298e-02f, 5.54224551e-01f, 4.58043441e-02f, -7.52378106e-02f, -9.34659839e-02f, -1.38900548e-01f,
  -1.04690127e-01f, -2.05803346e-02f, -2.63688415e-02f, -9.04304162e-02f, -1.46647200e-01f, 1.24114431e-01f, 1.98981538e-02f, 2.35704497e-01f, 5.40145822e-02f, -5.93342483e-02f,
  -1.54671803e-01f, 9.88281369e-02f, -1.79655343e-01f, 5.84765002e-02f, 2.40406301e-02f, 1.13163874e-01f, -5.55239432e-02f, 2.36615166e-02f, 1.62734076e-01f, -1.27530545e-01f,
  -1.65274397e-01f, -1.30136177e-01f, -1.58152506e-01f, 3.73963565e-02f, 7.75130093e-02f, 2.13918775e-01f, 2.48326406e-01f, -4.60977107e-02f, -6.17049597e-02f, -4.35867086e-02f,
  7.73141384e-02f, -7.41978064e-02f, 1.32871225e-01f, -9.72912908e-02f, -3.72503176e-02f, -7.88113028e-02f, -6.70477897e-02f, -1.36478975e-01f, -6.66679293e-02f, -6.75064996e-02f,
  2.09464267e-01f, -1.72096863e-01f, -1.24937594e-02f, 6.46775812e-02f, 8.95709917e-02f, -5.62282763e-02f, 5.54746613e-02f, -4.00499478e-02f, -5.51684573e-02f, 6.63084611e-02f,
  -8.21116045e-02f, 1.14238031e-01f, 1.57230437e-01f, 5.45482896e-02f, 4.68319766e-02f, 5.65551333e-02f, 1.36164948e-01f, -1.26061395e-01f, -1.07491270e-01f, -1.82011023e-01f,
  4.07381020e-02f, 3.31161991e-02f, 8.68504122e-02f, 9.20788385e-03f, 2.52806544e-01f, -1.72256734e-02f, 1.34429216e-01f, 9.40669402e-02f, -2.98007548e-01f, -1.01543106e-01f,
  -1.18169993e-01f, 1.28916189e-01f, -3.31199080e-01f, -1.12525031e-01f, -1.02426350e-01f, 2.39053771e-01f, 6.16134703e-02f, -5.88742457e-02f, -3.08553100e-01f, -1.97426513e-01f,
  -1.39569461e-01f, -8.59573707e-02f, -1.28101686e-03f, 1.17962100e-02f, -1.76103607e-01f, 6.13069953e-03f, 1.15592591e-01f, 3.37824076e-02f, -9.41542014e-02f, 2.07861990e-01f,
  1.54495507e-01f, 3.66436243e-02f, 9.64178368e-02f, 7.54602998e-02f, -2.04028375e-02f, 6.66003674e-02f, 1.25570083e-02f, 5.61549515e-02f, 1.61358163e-01f, 1.05286404e-01f,
  -7.05149099e-02f, 1.40695885e-01f, -8.71061906e-02f, 1.18208140e-01f, -7.86752477e-02f, -2.84844935e-01f, -1.96420863e-01f, 8.29555318e-02f, -2.11142749e-01f, -5.56692742e-02f,
  1.58038303e-01f, -1.75103724e-01f, -1.49357930e-01f, -1.00437410e-01f, 5.73750623e-02f, 2.10610777e-01f, 3.41810882e-01f, -2.66492158e-01f, 2.22463816e-01f, -1.43953055e-01f,
  6.11978695e-02f, 1.03701338e-01f, -1.59537885e-02f, 6.46193558e-03f, -1.26505613e-01f, 8.57606456e-02f, 2.01438665e-01f, 2.99810827e-01f, -5.75197600e-02f, 1.32940337e-01f,
  1.19762339e-01f, -1.02043867e-01f, -1.95067003e-01f, 1.44293174e-01f, 1.40387610e-01f, 1.13918245e-01f, -1.97460711e-01f, 3.96622568e-01f, 4.54752743e-01f, -6.07297160e-02f,
  6.83218092e-02f, -1.52229220e-01f, 1.74400900e-02f, 2.33608052e-01f, -7.96376318e-02f, -3.30945626e-02f, 3.06655224e-02f, 1.71985835e-01f, 1.39277652e-01f, 1.60372242e-01f,
  -2.72397518e-01f, -2.06881035e-02f, 2.17580870e-02f, 9.59709510e-02f, -1.25893414e-01f, 1.32961437e-01f, 1.96444988e-02f, 2.37848654e-01f, -7.49845579e-02f, -1.66017741e-01f,
  1.36103287e-01f, -9.46720541e-02f, -1.59595236e-01f, 2.94187292e-02f, 1.84542798e-02f, -1.00849152e-01f, 7.52812102e-02f, -1.83566868e-01f, -6.76753521e-02f, 9.11046863e-02f,
  -1.72812853e-03f, 4.12651859e-02f, -1.23980984e-01f, -4.59076092e-02f, -1.13257006e-01f, 3.79842403e-03f, -1.19044036e-01f, -9.40207392e-02f, 2.60653999e-02f, -1.24167696e-01f,
  -2.08243895e-02f, -9.08516273e-02f, -1.71813697e-01f, 1.45015093e-02f, 6.11590454e-03f, -1.45187348e-01f, -6.23404980e-02f, -3.79916504e-02f, -1.35505617e-01f, -8.53609815e-02f,
  1.35465398e-01f, 1.25625134e-02f, 1.57680213e-01f, 3.37196589e-02f, -8.94707534e-03f, 2.16908246e-01f, -1.43737271e-01f, 1.26628265e-01f, -4.09080982e-02f, 1.58106878e-01f,
  -7.59180784e-02f, -1.13865659e-01f, -1.82422400e-01f, 1.55833587e-01f, 2.38603294e-01f, 1.71262830e-01f, -6.20848760e-02f, 1.62936717e-01f, -1.04439929e-01f, 1.85318738e-01f,
  -1.11536317e-01f, 2.36467514e-02f, 7.90636465e-02f, -1.17222391e-01f, -1.67434402e-02f, 3.50262314e-01f, 4.09045577e-01f, 1.15585901e-01f, 2.28036761e-01f, -1.39885202e-01f,
  -2.07189530e-01f, -4.94371401e-03f, 2.54355639e-01f, -1.04648709e-01f, 2.73940295e-01f, 3.43050122e-01f, 2.61235058e-01f, 2.51067162e-01f, -1.92163736e-02f, 3.28721702e-02f,
  6.48438483e-02f, 2.44019583e-01f, -2.63384908e-01f, -9.73415449e-02f, 9.94303226e-02f, 1.04277387e-01f, 6.52227774e-02f, -4.64822799e-02f, -2.90237039e-01f, -2.45716143e-02f,
  1.65256336e-01f, 1.07947163e-01f, 6.49675280e-02f, 5.57751767e-02f, 2.07288507e-02f, 2.16211319e-01f, 2.01113552e-01f, 2.78498352e-01f, 4.48597372e-02f, 3.06080669e-01f,
  2.55600274e-01f, 2.56457269e-01f, 7.48101547e-02f, -1.09977527e-02f, 1.25691399e-01f, 1.11281667e-02f, 4.96191457e-02f, 3.98119166e-03f, -9.51806605e-02f, 1.82583585e-01f,
  8.33705589e-02f, -6.52663037e-02f, 1.53101310e-01f, 2.63879541e-02f, 9.56160855e-03f, -2.43083369e-02f, -1.16929382e-01f, -1.01077721e-01f, -1.45376474e-01f, -8.50410610e-02f,
  9.50899422e-02f, 1.45988271e-01f, 1.72692552e-01f, 1.23832569e-01f, -1.32650957e-02f, -9.43003818e-02f, -3.41323391e-02f, -6.62090257e-03f, -1.46614343e-01f, -1.66503489e-01f,
  -1.33479208e-01f, 7.52605423e-02f, 1.49112493e-01f, -1.81295723e-01f, -5.48343360e-02f, 1.14378393e-01f, 4.94699091e-01f, 1.92996547e-01f, 3.27339709e-01f, 2.14403272e-01f,
  3.03347737e-01f, 1.58395812e-01f, 1.09567501e-01f, 4.77291234e-02f, 2.75877684e-01f, 1.06146373e-01f, -3.87264043e-01f, 7.21029714e-02f, -2.93949127e-01f, 2.39130795e-01f,
  4.70615864e-01f, 2.78358966e-01f, -1.36300102e-01f, -2.92350471e-01f, 4.65181947e-01f, 2.26487234e-01f, 1.12733632e-01f, -5.75768538e-02f, 1.06161632e-01f, 5.17201936e-03f,
  1.99550539e-02f, 4.69976142e-02f, 1.37985289e-01f, -1.28857404e-01f, -3.55152488e-02f, 4.82063890e-01f, 5.64362332e-02f, -1.08106025e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.48330003e-01f, 1.81059808e-01f, 2.17226729e-01f, 2.55870908e-01f, 1.68359563e-01f, -1.16732351e-01f, 4.02689017e-02f, -3.30347978e-02f, 2.22157449e-01f, 4.78716493e-02f,
  -9.77508426e-02f, 6.90041855e-02f, -6.63124621e-02f, 2.83679277e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.24913819e-01f, -6.72619045e-02f, 1.65622860e-01f, 1.32183418e-01f, -1.39975801e-01f, -1.62115097e-01f, 1.90526649e-01f, -2.25681022e-01f, -3.16175073e-02f, -1.18184611e-01f,
  1.99363649e-01f, 2.74011672e-01f, 9.47690010e-02f, -1.72894388e-01f, 6.20881207e-02f, 4.86721843e-02f, -1.72826260e-01f, -1.92883536e-01f, -1.37806952e-01f, 1.33570880e-01f,
  2.37551648e-02f, -5.94379269e-02f, 3.81554216e-02f, -1.74552232e-01f, 2.10689798e-01f, -2.06186086e-01f, 2.15452075e-01f, -2.11799145e-03f, -3.40569541e-02f, 4.67769839e-02f,
  -1.42687827e-01f, 2.90173978e-01f, -1.31306961e-01f, 2.98958540e-01f, 2.05613434e-01f, -1.73657328e-01f, -9.70942676e-02f, 2.04591081e-01f, 2.20874920e-01f, -1.12527758e-01f,
  1.19015120e-01f, 4.32518959e-01f, 5.21378517e-02f, 1.84334964e-01f, 5.76019108e-01f, 2.13074520e-01f, -1.48165554e-01f, -1.84249520e-01f, 1.31680472e-02f, -8.85747001e-02f,
  2.72405613e-02f, -1.32548613e-02f, -3.04572165e-01f, -1.31046146e-01f, -2.03481078e-01f, 3.04350387e-02f, -2.34652296e-01f, -2.32051343e-01f, 1.63874015e-01f, -7.13682175e-02f,
  -1.54192403e-01f, -8.46257806e-02f, 2.07050592e-01f, -3.40766549e-01f, 1.09074593e-01f, 7.98729435e-02f, -1.38543785e-01f, -1.52632613e-02f, -1.79549232e-01f, -1.85301229e-01f,
  8.57486576e-02f, 5.36229350e-02f, 1.74646646e-01f, -3.82239282e-01f, 1.21909492e-01f, 5.70281968e-02f, -2.71573305e-01f, 1.63426029e-03f, 3.11058369e-02f, 8.67562443e-02f,
  1.25261977e-01f, 4.21153635e-01f, -2.22516477e-01f, -2.88191512e-02f, 2.67865092e-01f, -1.23459168e-01f, 5.34125268e-02f, -3.94765958e-02f, -1.71911512e-02f, -6.54079318e-02f,
  -2.19353527e-01f, 1.51814476e-01f, 3.30432683e-01f, 2.91823715e-01f, -1.38608232e-01f, 2.21729577e-01f, -4.57566902e-02f, -1.36229455e-01f, 1.18098602e-01f, 1.42285600e-01f,
  2.00248837e-01f, -4.08183113e-02f, -9.47766006e-02f, -1.02926023e-01f, -1.99503019e-01f, 1.79294810e-01f, 1.22713126e-01f, 3.13031197e-01f, 1.17679752e-01f, -1.78520884e-02f,
  1.86702102e-01f, -2.01690435e-01f, 8.87949467e-02f, -2.35591888e-01f, 1.43422723e-01f, 2.25255221e-01f, -9.57595855e-02f, 2.90152550e-01f, -3.95084508e-02f, 1.17358468e-01f,
  4.78751864e-03f, -1.82033166e-01f, 3.33322972e-01f, 3.93946543e-02f, -9.08370968e-03f, 4.66250703e-02f, -1.21704437e-01f, 2.28494450e-01f, 3.32253426e-01f, 1.78344786e-01f,
  -1.72345396e-02f, -1.50388079e-02f, -1.63571946e-02f, 7.24855810e-02f, -8.45792592e-02f, 1.70457214e-01f, 2.04278365e-01f, -4.36990082e-01f, -1.85380563e-01f, -2.23523051e-01f,
  -4.12727773e-01f, -6.65331585e-03f, -2.76157465e-02f, 7.82300457e-02f, -1.67994589e-01f, 2.69700557e-01f, 1.08983696e-01f, -5.20745441e-02f, 1.42132923e-01f, -8.55167508e-02f,
  2.19306387e-02f, 1.87811032e-01f, -1.65702537e-01f, 2.02970177e-01f, -1.34264916e-01f, 7.08786771e-02f, 9.19138920e-03f, 9.33230966e-02f, 3.73413004e-02f, 3.90092656e-02f,
  1.85292900e-01f, 1.12124041e-01f, 2.08673365e-02f, 2.50929594e-01f, 2.21017703e-01f, -2.52942219e-02f, -8.34760722e-04f, -1.28906295e-01f, 5.29200621e-02f, 2.42261440e-02f,
  1.98301286e-01f, -1.53044343e-01f, 8.10460374e-02f, -3.04607391e-01f, 1.56007543e-01f, 3.80965061e-02f, 1.46958888e-01f, 1.62104920e-01f, -1.86959788e-01f, 1.06914781e-01f,
  1.72969535e-01f, -1.68234289e-01f, 4.12074998e-02f, 1.58861086e-01f, -6.85361400e-02f, 1.94667459e-01f, 2.73205191e-02f, 6.36123493e-02f, 1.43048763e-01f, -1.61379755e-01f,
  8.28560218e-02f, -1.22387834e-01f, -6.26885220e-02f, 7.49274939e-02f, -2.08897889e-01f, 2.59757698e-01f, 2.07731828e-01f, 2.80594319e-01f, -8.70122667e-03f, 4.25289851e-03f,
  2.35165805e-01f, 2.93710709e-01f, 2.52316624e-01f, -1.37570724e-01f, 3.05087596e-01f, -1.76599711e-01f, 7.57405683e-02f, 8.88590515e-03f, -1.60278961e-01f, 2.13971570e-01f,
  -3.83290529e-01f, 1.14138186e-01f, 1.85165167e-01f, -2.66481906e-01f, -1.59137815e-01f, 1.78100303e-01f, -2.13067234e-01f, 2.03575552e-01f, -2.34028429e-01f, 4.69481722e-02f,
  2.52044082e-01f, -8.19881484e-02f, -2.64219902e-02f, 7.96163678e-02f, -9.99900848e-02f, -3.84619653e-01f, 1.83090789e-03f, 1.95318773e-01f, -1.65752441e-01f, -3.49374354e-01f,
  1.39987662e-01f, -2.62847245e-01f, -1.36606440e-01f, -2.27294743e-01f, 1.84986845e-01f, -1.84754327e-01f, -3.33075821e-01f, -2.87246734e-01f, 4.87948768e-02f, 8.34079385e-02f,
  -9.45885852e-02f, 1.75754890e-01f, -4.03105058e-02f, -7.95847699e-02f, 2.28275806e-02f, 2.21291095e-01f, -1.18547253e-01f, -2.24945936e-02f, 3.34407181e-01f, 8.66672471e-02f,
  -3.49403799e-01f, 5.59822209e-02f, 1.70805976e-01f, 8.79075676e-02f, 5.28875478e-02f, 3.11801910e-01f, -8.72607064e-03f, -1.10743061e-01f, 1.64640978e-01f, -2.14373022e-02f,
  6.91158921e-02f, 2.42242292e-01f, 2.97661543e-01f, 2.15129435e-01f, 6.46896660e-02f, 1.66003808e-01f, -2.34536961e-01f, -2.66679555e-01f, -2.13486012e-02f, 7.68251047e-02f,
  3.47180441e-02f, 8.11193362e-02f, 2.35985015e-02f, -1.01680001e-02f, 9.65299532e-02f, -3.08897942e-01f, 1.11697040e-01f, -1.21459052e-01f, -2.95132473e-02f, -6.86629936e-02f,
  -1.63373381e-01f, -1.97844580e-01f, 2.05877542e-01f, 1.21342018e-01f, 3.12804319e-02f, 1.85441524e-01f, 2.24926189e-01f, -1.16736412e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.41514018e-01f, -2.92652976e-02f, -9.90682766e-02f, 4.39393930e-02f, -5.71837723e-02f, 2.55490467e-02f, 1.95742160e-01f, -1.14774756e-01f, 2.04782840e-02f, 3.34356129e-01f,
  2.28251487e-01f, -2.18180165e-01f, 3.19786698e-01f, 4.28318232e-02f, 2.50770569e-01f, 4.47459854e-02f, -4.30898964e-02f, -3.20211202e-02f, -1.26245141e-01f, 5.53660318e-02f,
  2.15137854e-01f, 3.78464088e-02f, -2.13846359e-02f, 8.74036178e-02f, -4.95210625e-02f, -2.27690354e-01f, 1.06552951e-01f, -1.13941366e-02f, 2.66078770e-01f, 2.79867768e-01f,
  9.02141631e-02f, 1.64670914e-01f, 2.70292703e-02f, -8.72774497e-02f, -1.25429928e-01f, 5.15720993e-02f, 9.46254954e-02f, 1.19267635e-01f, -1.60697266e-01f, -1.22388145e-02f,
  1.46634221e-01f, 5.70762306e-02f, -1.68954641e-01f, 2.01836988e-01f, 1.20914191e-01f, -3.01345205e-03f, 2.82400306e-02f, -1.97128743e-01f, -4.75846641e-02f, 1.27061382e-01f,
  -7.85775706e-02f, 7.63544589e-02f, 8.46846551e-02f, 8.45122486e-02f, -1.39393911e-01f, -9.08201188e-02f, -4.57034148e-02f, -8.16903189e-02f, 1.16634397e-02f, 3.32857482e-02f,
  -3.25643457e-02f, -1.47590593e-01f, -5.34928311e-03f, -6.16051517e-02f, 2.99897045e-02f, -3.74381244e-02f, 7.66050741e-02f, 4.40624952e-02f, -4.57244832e-03f, -1.89768270e-01f,
  -9.72699225e-02f, -1.10692136e-01f, -1.56170418e-02f, 1.59106582e-01f, -7.93183520e-02f, -7.60166794e-02f, -1.94220960e-01f, -5.39761707e-02f, 3.86765860e-02f, 1.09664619e-01f,
  2.53857970e-01f, -1.05878145e-01f, 2.71153147e-03f, -4.62055951e-02f, -1.11907952e-01f, 8.15729946e-02f, -1.47998989e-01f, -1.00254536e-01f, 2.17036847e-02f, 1.29465431e-01f,
  9.60869193e-02f, 1.09176651e-01f, -1.50642842e-01f, -1.30047696e-02f, 4.31861319e-02f, 3.24109048e-01f, 3.21762681e-01f, 3.33349079e-01f, 1.89541966e-01f, -9.36979353e-02f,
  1.86196059e-01f, 2.46980458e-01f, -1.70336291e-01f, -3.60076665e-03f, 2.78148592e-01f, -2.52921879e-01f, -6.96571842e-02f, 2.37819970e-01f, -8.01121145e-02f, 2.19906673e-01f,
  -2.16568112e-01f, -2.91103162e-02f, 4.23987210e-02f, 2.47092888e-01f, 2.75071442e-01f, 2.36801535e-01f, 7.84875751e-02f, -1.50925606e-01f, 1.79705858e-01f, 9.17923599e-02f,
  -3.37972641e-02f, 2.74859309e-01f, 9.29365307e-02f, -1.52427629e-01f, -9.22046006e-02f, 1.17741875e-01f, 1.04169756e-01f, 4.05577086e-02f, 4.59291339e-02f, -1.61082149e-01f,
  1.62572354e-01f, 1.94013968e-01f, 3.26380022e-02f, 2.02785119e-01f, 3.40613991e-01f, -6.78397417e-02f, 2.48928294e-01f, 2.56652564e-01f, 2.47383699e-01f, -1.02750205e-01f,
  9.87615958e-02f, -1.87373385e-01f, 3.45784158e-01f, 2.24020332e-01f, 7.47941062e-02f, 1.86323062e-01f, 6.10717721e-02f, 5.88183617e-03f, 1.42421052e-01f, -1.75215200e-01f,
  -1.93858802e-01f, -1.02504127e-01f, -1.23792142e-01f, -7.10502788e-02f, 1.23537496e-01f, -1.55830503e-01f, 2.72756428e-01f, 5.62498420e-02f, 4.03805859e-02f, 2.18824133e-01f,
  1.78127542e-01f, -8.55738111e-03f, -2.40568258e-02f, 1.41860902e-01f, -1.66638389e-01f, 1.50923267e-01f, -1.38299197e-01f, -1.45162553e-01f, 6.90847859e-02f, -8.59276354e-02f,
  6.50990009e-02f, -9.97416526e-02f, -9.32235494e-02f, -2.74913199e-02f, 4.99569215e-02f, 9.06390976e-03f, 3.88426799e-03f, 1.58046931e-01f, -1.25547945e-01f, -4.27051075e-02f,
  9.24721882e-02f, -9.46260691e-02f, 6.08525760e-02f, -6.70513287e-02f, -4.81601283e-02f, -1.23831995e-01f, 5.48550300e-02f, -3.37189324e-02f, -8.25968906e-02f, -2.74931844e-02f,
  -1.30979002e-01f, -7.54633965e-03f, -5.80604747e-02f, -6.19955398e-02f, 3.16528492e-02f, 1.58764914e-01f, -1.92767940e-02f, 1.24930307e-01f, -2.76083231e-01f, -9.52901691e-03f,
  1.17868312e-01f, -2.68725604e-01f, 1.01030737e-01f, 5.94952516e-02f, -4.27820757e-02f, -1.54448152e-01f, -1.88004881e-01f, -2.67802000e-01f, 1.35463417e-01f, 2.44505122e-01f,
  5.28656356e-02f, 3.37443650e-01f, -3.68655287e-02f, -1.35776982e-01f, 6.45383149e-02f, 5.20952493e-02f, -6.92700222e-02f, 3.17700915e-02f, 1.26781568e-01f, 8.68559107e-02f,
  -1.73442215e-01f, 1.55344769e-01f, 9.24310908e-02f, -3.75543162e-02f, 1.64060026e-01f, -8.59543979e-02f, 2.83241421e-01f, 2.76775032e-01f, 2.56651014e-01f, -1.70202166e-01f,
  3.56447399e-01f, 3.00724208e-02f, 3.02358091e-01f, 1.20707624e-01f, 4.65514392e-01f, -5.86103573e-02f, -1.95657283e-01f, -4.26230967e-01f, 3.55646551e-01f, 2.18950391e-01f,
  4.13735241e-01f, -1.98331073e-01f, 2.55494453e-02f, 3.79548252e-01f, -2.39224017e-01f, 6.12262011e-01f, -1.12150824e-02f, -1.70904607e-01f, 1.62749484e-01f, -5.88460453e-02f,
  -7.76405185e-02f, 5.11343125e-03f, -6.24601357e-02f, 1.02577783e-01f, -5.26251830e-02f, 6.57222331e-01f, 3.75562198e-02f, -1.23108789e-01f, 6.27041981e-02f, 2.86444843e-01f,
  -9.12951380e-02f, 2.08136290e-01f, 2.67080665e-01f, 1.04333624e-01f, -7.36563141e-03f, 3.21261287e-01f, 1.34109333e-01f, -1.34452596e-01f, -7.42006451e-02f, 3.32716480e-02f,
  1.64330259e-01f, -1.90302089e-01f, -1.66127771e-01f, -2.35614955e-01f, -6.04760237e-02f, 2.55985737e-01f, 1.37650937e-01f, 1.00688143e-02f, 9.27250832e-02f, -1.46312043e-01f,
  -2.07103446e-01f, -1.98440045e-01f, -4.86906916e-02f, -1.10287070e-01f, 1.14120781e-01f, 2.12142661e-01f, 2.18185022e-01f, 3.02990109e-01f, 8.06714669e-02f, -5.68353347e-02f,
  2.65465200e-01f, 2.89168805e-01f, -6.33512670e-03f, 1.76207814e-02f, 1.18134052e-01f, -1.46028586e-02f, 1.39579996e-01f, 1.76565528e-01f, 1.43751293e-01f, 1.98330209e-01f,
  -2.57107645e-01f, -2.10574955e-01f, 1.98028788e-01f, -3.38986665e-02f, 1.83262974e-01f, -3.42882365e-01f, 1.86581656e-01f, 2.51769602e-01f, -4.66598496e-02f, 4.34453517e-01f,
  -9.25814509e-02f, 1.20729255e-02f, 9.42991674e-02f, 1.23466672e-02f, 1.38298467e-01f, -1.42826885e-01f, -2.64793992e-01f, -5.41097857e-03f, -1.51213994e-02f, 2.18334645e-01f,
  6.28616108e-05f, 1.46052912e-01f, -5.55822365e-02f, -5.37225232e-02f, 9.99016091e-02f, 8.69719386e-02f, -2.02234611e-01f, 2.15355337e-01f, -1.64530665e-01f, -1.42676249e-01f,
  -1.43328071e-01f, 1.70485396e-02f, -1.32836804e-01f, 1.89803019e-01f, -2.71454871e-01f, -2.29639649e-01f, 1.76356081e-02f, 1.75076976e-01f, 1.80914670e-01f, 2.33851716e-01f,
  -1.17040932e-01f, -1.51609510e-01f, 2.00772896e-01f, -1.38829067e-01f, 2.00736240e-01f, 6.64968416e-02f, 1.09225288e-01f, -1.77254543e-01f, -1.17009683e-02f, 3.38814110e-01f,
  -1.35189787e-01f, 1.56095494e-02f, 2.95351952e-01f, -5.95480055e-02f, 3.36028337e-01f, -2.22376227e-01f, -1.61071327e-02f, 2.12684020e-01f, 2.29638577e-01f, 2.98319727e-01f,
  2.73668319e-01f, -2.34437317e-01f, 6.32769689e-02f, -4.55776244e-01f, -6.87854767e-01f, 2.90135056e-01f, 1.10173173e-01f, 2.42120892e-01f, -1.06243744e-01f, 2.57132739e-01f,
  1.77811265e-01f, -3.26521039e-01f, 2.42753908e-01f, 2.28555784e-01f, -1.35966480e-01f, 1.46149069e-01f, 2.55666047e-01f, -6.77994872e-03f, -1.76599950e-01f, 1.43129423e-01f,
  2.85261095e-01f, 5.61239481e-01f, -4.95837070e-02f, 6.15537524e-01f, -6.77439794e-02f, 1.03725806e-01f, -5.67526780e-02f, 9.45599303e-02f, -3.92694920e-02f, -3.20652574e-02f,
  6.41471744e-02f, -7.54678901e-03f, 1.27395555e-01f, 4.87758406e-02f, 3.35770220e-01f, 1.66402563e-01f, -3.88924964e-02f, -1.28582925e-01f, 1.16073534e-01f, 4.68682647e-02f,
  6.51734769e-02f, -9.64761674e-02f, -2.40825832e-01f, 2.46537566e-01f, -7.70813450e-02f, 2.04558969e-01f, -1.55387953e-01f, -6.24169409e-02f, -1.22125372e-01f, -1.44470409e-01f,
  1.87416539e-01f, 4.35519330e-02f, -4.71263379e-02f, -1.10127732e-01f, -1.16920218e-01f, 2.81341493e-01f, 2.56290227e-01f, 1.38116285e-01f, 2.72902250e-01f, -2.40172520e-02f,
  2.24987909e-01f, 3.34243387e-01f, -3.41625549e-02f, 1.65315777e-01f, 2.99754232e-01f, -7.11639225e-02f, -2.37277865e-01f, 3.39088649e-01f, 3.77178788e-01f, 6.14770763e-02f,
  -4.22820330e-01f, -3.27417105e-01f, -1.14781540e-02f, 8.75945911e-02f, 1.16634607e-01f, 4.92052734e-01f, -3.63441519e-02f, -6.34047538e-02f, 7.90932216e-03f, -1.05835713e-01f,
  1.08607747e-01f, -5.97552769e-02f, 4.27168489e-01f, -1.35775000e-01f, 9.75163057e-02f, 4.48230356e-01f, -1.35912701e-01f, -8.81354511e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.92419395e-01f, -1.25195354e-01f, -1.62354633e-01f, 3.25216055e-01f, 2.67360300e-01f, -1.58000350e-01f, -2.14436669e-02f, 1.17448278e-01f, -5.90446778e-02f, 2.20823899e-01f,
  1.33843347e-01f, 1.90626696e-01f, 2.42272481e-01f, 2.29660243e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  2.44364683e-02f, 2.79034317e-01f, -5.92910834e-02f, -1.83976337e-01f, -5.02982140e-02f, 9.69780516e-03f, 9.30239707e-02f, 6.38803979e-03f, 5.23860790e-02f, 2.35464629e-02f,
  6.46741241e-02f, 5.52440947e-03f, -8.18515643e-02f, 1.70472264e-01f, 1.87592164e-01f, 1.86294734e-01f, -4.23894823e-01f, -1.01665623e-01f, -3.29784483e-01f, 1.91593349e-01f,
  -6.72733262e-02f, 2.55187094e-01f, -2.49275669e-01f, -7.64048025e-02f, 2.39351224e-02f, -3.27468097e-01f, 4.64663692e-02f, -1.58838797e-02f, 1.32008836e-01f, -3.49031419e-01f,
  -1.56304538e-01f, 3.19033831e-01f, -1.64167002e-01f, -1.45775959e-01f, 4.24844697e-02f, -8.52124840e-02f, -2.71720499e-01f, 1.45876929e-01f, 5.99364005e-02f, 1.66917890e-01f,
  1.99637726e-01f, 2.08786260e-02f, -5.66825211e-01f, 1.06009200e-01f, -1.86631665e-01f, -1.70696318e-01f, 8.56575072e-02f, 1.60403535e-01f, 4.06933278e-01f, -9.68808234e-02f,
  5.83352894e-02f, -1.64611980e-01f, 1.77556723e-01f, -2.63606925e-02f, 1.57470740e-02f, 8.27814937e-02f, -1.78620964e-01f, 3.88417244e-01f, -1.14492573e-01f, 1.11418329e-01f,
  -2.34264791e-01f, 1.91055954e-01f, 5.87573685e-02f, -4.38874602e-01f, -7.90726840e-02f, -5.61275959e-01f, -4.21856344e-01f, 8.12883526e-02f, -8.49277005e-02f, -3.16109329e-01f,
  -3.79951745e-02f, -5.73857352e-02f, -1.05282404e-01f, -5.07121384e-02f, -3.25531393e-01f, 1.84697941e-01f, -3.75935614e-01f, 1.11111522e-01f, -3.39186400e-01f, -2.44806305e-01f,
  4.68286097e-01f, 1.34936050e-01f, 2.45230034e-01f, -5.60960062e-02f, -9.59670693e-02f, -5.71139418e-02f, -1.24527507e-01f, -7.05221843e-04f, -1.24067709e-01f, 6.46117181e-02f,
  2.30301499e-01f, -1.78291991e-01f, 1.27676139e-02f, 4.64096993e-01f, -8.33055004e-02f, -1.42001539e-01f, -7.88916275e-02f, -2.14849085e-01f, -2.15129226e-01f, 1.49331121e-02f,
  1.04940072e-01f, -1.94636285e-01f, -2.37220954e-02f, -2.58654237e-01f, -2.79075857e-02f, -1.33146167e-01f, 1.63760856e-01f, 1.10220641e-01f, 5.72986379e-02f, -1.29835770e-01f,
  1.88542362e-02f, -2.40140289e-01f, 1.73719749e-01f, 3.55670601e-03f, 3.16572666e-01f, -1.44825786e-01f, 2.24835485e-01f, -1.95043772e-01f, 3.35064054e-01f, 2.97264159e-02f,
  -1.72004223e-01f, 2.18577787e-01f, -1.09418705e-01f, -1.46272913e-01f, -2.28667438e-01f, 2.53588408e-01f, -8.12495276e-02f, -1.12326778e-01f, -8.96634981e-02f, -1.62302241e-01f,
  -3.47829849e-01f, -8.85373820e-03f, -3.72304469e-02f, -1.60453022e-01f, -4.21852507e-02f, -9.31161791e-02f, 3.11388001e-02f, 1.49613291e-01f, -4.34570253e-01f, -1.50825977e-01f,
  -1.03679202e-01f, -5.22989370e-02f, -3.10277969e-01f, -2.90942073e-01f, 3.98758471e-01f, 4.96887267e-02f, 7.27460533e-02f, -1.80887997e-01f, 8.67500610e-04f, -2.36914784e-01f,
  8.98385495e-02f, 1.54462621e-01f, -1.44550472e-01f, 2.15908721e-01f, 3.26169580e-01f, -5.03044762e-02f, 1.97048515e-01f, 1.06684491e-01f, -1.23403437e-01f, -5.14260046e-02f,
  -2.07658827e-01f, 1.48326248e-01f, -1.13278404e-01f, -6.34745732e-02f, -2.37833604e-01f, -1.84493214e-01f, -2.19321772e-01f, -1.35469601e-01f, -3.11454441e-02f, -9.28366035e-02f,
  -3.32387775e-01f, -1.13727227e-01f, 1.56205699e-01f, -2.30026662e-01f, 9.63627547e-02f, 3.05890262e-01f, 2.32928902e-01f, 5.28562665e-02f, 2.86941439e-01f, -5.72028197e-02f,
  1.23883657e-01f, -2.71458894e-01f, 1.08365685e-01f, 1.68495655e-01f, -1.84725881e-01f, 1.67904243e-01f, 1.94713265e-01f, 1.54956385e-01f, -3.15679848e-01f, -1.10427573e-01f,
  1.81521878e-01f, -3.50075930e-01f, 1.47119462e-01f, 1.96782619e-01f, -2.72050407e-02f, 6.97639063e-02f, 5.09876087e-02f, 1.44801186e-02f, -7.47080594e-02f, -1.07380934e-01f,
  1.63440034e-01f, -1.88344195e-01f, 2.73590512e-03f, 2.06948757e-01f, 1.11983784e-01f, 1.79256514e-01f, -1.07513234e-01f, 1.03223875e-01f, -2.32825786e-01f, -1.87516317e-01f,
  -1.86704267e-02f, -1.00508466e-01f, -1.00749724e-01f, 9.05139074e-02f, -1.04643263e-01f, -1.93509031e-02f, 2.32815519e-01f, -2.17553005e-01f, -2.71082401e-01f, 9.87180695e-02f,
  1.39563426e-01f, -3.80261481e-01f, 1.04621686e-01f, 5.61449081e-02f, -1.09512687e-01f, -1.30354296e-02f, -1.31390378e-01f, 1.49419039e-01f, 4.14324366e-02f, 8.02237019e-02f,
  -3.35399657e-02f, -2.68370092e-01f, -1.13479272e-01f, -6.45362288e-02f, 2.52961606e-01f, 2.06355572e-01f, 2.91933566e-02f, 6.73416182e-02f, -6.15261383e-02f, -1.20928049e-01f,
  -3.12770426e-01f, 6.98454008e-02f, 3.87515165e-02f, -1.06788754e-01f, -4.45997007e-02f, 3.44970167e-01f, -2.19412640e-01f, -1.69716492e-01f, 9.36724395e-02f, -3.65565151e-01f,
  -1.89773262e-01f, -2.15044230e-01f, 3.21091712e-01f, 8.77406225e-02f, -2.39229634e-01f, 3.60634863e-01f, 4.51419391e-02f, -4.19573439e-03f, 2.70760376e-02f, 1.25184074e-01f,
  2.22567499e-01f, -4.36614491e-02f, -1.43041939e-01f, -8.13402310e-02f, 2.30584025e-01f, 6.19612038e-02f, 3.09357047e-01f, -6.44287243e-02f, 2.68003643e-01f, -2.13694751e-01f,
  9.61244181e-02f, 3.67250323e-01f, -2.71865278e-01f, 1.47876302e-02f, 2.13912129e-01f, -1.50786256e-02f, -4.29760776e-02f, -2.79362619e-01f, 2.94456273e-01f, -7.39598423e-02f,
  1.41716063e-01f, -1.46765923e-02f, 2.95814961e-01f, -1.56204626e-01f, -2.91983366e-01f, -2.92360544e-01f, 1.76907346e-01f, 1.38675734e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.58067418e-02f, 4.91015911e-02f, -1.54531851e-01f, -1.02275558e-01f, -5.27337156e-02f, 3.32274474e-02f, -7.32267946e-02f, -3.71075422e-02f, 8.64484236e-02f, -1.48075759e-01f,
  1.32785246e-01f, -2.19826609e-01f, -7.18587427e-04f, -1.01055600e-01f, 1.31450638e-01f, 1.92010775e-01f, -1.93960309e-01f, -1.24117896e-01f, 1.76119819e-01f, 8.16567913e-02f,
  -1.19260065e-01f, -1.39464349e-01f, -4.99780290e-02f, 4.57206974e-03f, 6.53714463e-02f, 2.59812057e-01f, 1.49922445e-01f, -1.52529811e-03f, -1.13177940e-01f, 1.10279076e-01f,
  4.82511073e-02f, 8.85499343e-02f, 1.21716417e-01f, -1.48152113e-01f, -1.19470663e-01f, -3.85363437e-02f, 1.16075374e-01f, 3.54129896e-02f, 7.78746605e-02f, -7.28755025e-03f,
  5.82293347e-02f, 2.79006422e-01f, -3.37826550e-01f, 2.93143183e-01f, 2.44374856e-01f, 1.97970495e-01f, -6.10127747e-02f, -3.74395072e-01f, 1.81952029e-01f, 1.57429520e-02f,
  -2.61917293e-01f, -3.71931633e-03f, 9.83358845e-02f, 1.41801640e-01f, -4.88386154e-02f, -3.74324769e-02f, 6.72722831e-02f, 2.43561551e-01f, -1.73922926e-01f, 3.32567990e-01f,
  3.67512442e-02f, 4.05598491e-01f, 1.39194340e-01f, 2.42606699e-01f, 3.39759886e-02f, -3.72261070e-02f, -4.93005104e-02f, -1.73195019e-01f, 2.35832389e-02f, 1.37655631e-01f,
  8.50835294e-02f, 8.85070488e-02f, 1.81996465e-01f, 2.69331813e-01f, 2.42649108e-01f, -2.12596193e-01f, 1.11930393e-01f, -4.29508686e-01f, -6.85928836e-02f, 9.58159864e-02f,
  5.56784682e-02f, 1.38877094e-01f, 1.63052589e-01f, -6.41738847e-02f, -5.40455952e-02f, 1.02653816e-01f, 2.68951178e-01f, -1.52444869e-01f, -1.28288418e-01f, 2.59164989e-01f,
  -1.31828440e-02f, 2.68534362e-01f, -1.92170590e-02f, -2.63750255e-01f, 1.98637158e-01f, 3.08687061e-01f, 4.31888402e-01f, -1.90938674e-02f, 1.11690894e-01f, 2.73733467e-01f,
  2.82821894e-01f, 3.08230519e-01f, 1.30837992e-01f, -1.80867240e-01f, -5.36809526e-02f, -2.93270916e-01f, 4.70082641e-01f, -3.82648259e-01f, -1.66875089e-03f, -1.28712162e-01f,
  -2.88858742e-01f, -1.63249299e-01f, -3.04008693e-01f, 5.46485841e-01f, 1.67565480e-01f, -1.05013572e-01f, 8.22583120e-03f, 9.54751000e-02f, 5.51529452e-02f, -9.28139389e-02f,
  -2.79167622e-01f, -2.96450943e-01f, 2.28328239e-02f, -9.54735652e-02f, 1.01942606e-02f, 1.85989197e-02f, -2.44837388e-01f, 3.46953422e-01f, 1.08540647e-01f, -2.91168779e-01f,
  -9.46913138e-02f, 2.83397764e-01f, 1.29461750e-01f, 1.06910378e-01f, -2.76713908e-01f, 4.66613509e-02f, -1.43164890e-02f, 8.37788507e-02f, -1.25595197e-01f, 2.87630409e-01f,
  -2.28365839e-01f, 3.47808272e-01f, 1.17185980e-01f, 1.16358347e-01f, 3.48509490e-01f, 1.70621872e-01f, 6.29658997e-02f, -1.33372456e-01f, 2.82356720e-02f, 1.79639105e-02f,
  3.38367909e-01f, -1.73528641e-02f, -1.54340580e-01f, 1.15398839e-01f, 1.10108443e-01f, -1.24909833e-01f, -2.83050179e-01f, 6.24193907e-01f, 1.66240558e-01f, -3.58174860e-01f,
  4.79096055e-01f, 7.92333335e-02f, 5.01957476e-01f, 5.52696586e-01f, 2.04781353e-01f, 1.19096018e-01f, 4.29533005e-01f, 1.84431821e-01f, 1.73114687e-01f, -3.91614437e-01f,
  -3.34938526e-01f, 1.11904860e-01f, -4.56408441e-01f, 6.43387794e-01f, -2.98686847e-02f, 2.90836096e-01f, -4.96235080e-02f, 1.41043320e-01f, -1.53210863e-01f, -1.23239055e-01f,
  -2.47922093e-01f, 4.15037334e-01f, 1.07065022e-01f, 8.96827728e-02f, 9.98488143e-02f, -2.04225063e-01f, -1.83794394e-01f, -2.64670819e-01f, 9.50030833e-02f, 7.30392158e-01f,
  -2.86983848e-01f, 2.82518208e-01f, 1.68664172e-01f, 2.11099297e-01f, 2.22557142e-01f, -4.99341860e-02f, 2.33460397e-01f, 2.40631625e-01f, 1.85129717e-01f, 1.26148373e-01f,
  1.66588560e-01f, -1.30861118e-01f, 4.93496880e-02f, -1.59188852e-01f, 1.52885944e-01f, 5.25874607e-02f, 4.41385470e-02f, 1.15740776e-01f, -2.27167502e-01f, -1.59659371e-01f,
  -2.39424124e-01f, 7.24449009e-02f, -1.57333881e-01f, 3.73859376e-01f, 7.47694448e-03f, 1.23721778e-01f, 2.08654150e-01f, -7.85696879e-02f, -1.12288900e-01f, -1.47346660e-01f,
  2.66395360e-01f, -2.88262069e-01f, -7.61435134e-03f, 4.97896075e-01f, 2.00536311e-01f, -1.67944714e-01f, -2.53422886e-01f, 4.76523652e-04f, -6.81798682e-02f, 1.30168872e-03f,
  1.82765380e-01f, -1.57916948e-01f, 1.69305965e-01f, 4.34437208e-02f, 2.28746995e-01f, -2.33510032e-01f, 2.61623919e-01f, -5.14101312e-02f, -2.12436274e-01f, -3.22660744e-01f,
  -8.81631374e-02f, 1.81565613e-01f, 1.22462295e-01f, 8.03486258e-02f, -7.05877170e-02f, 5.32913487e-03f, 1.01855859e-01f, -5.98800629e-02f, 1.44213252e-02f, -2.26129487e-01f,
  2.02537268e-01f, 1.48227274e-01f, 3.97388488e-02f, -6.69822395e-02f, -1.67949304e-01f, 2.68508703e-01f, 1.06943101e-02f, -3.01300343e-02f, 1.35455638e-01f, 3.44329141e-02f,
  1.70660838e-01f, -3.31749506e-02f, 5.84368296e-02f, 5.26276156e-02f, -9.75998342e-02f, 1.35150149e-01f, 3.68279457e-01f, -3.36060785e-02f, 1.34550810e-01f, -2.63098508e-01f,
  1.79790743e-02f, 9.25311372e-02f, 2.62110867e-02f, 2.72442251e-01f, 1.97981194e-01f, 2.07948638e-03f, -1.51623368e-01f, 3.96194831e-02f, -4.14686166e-02f, -6.82800356e-03f,
  -1.60817802e-01f, 1.15806893e-01f, -9.14357305e-02f, -4.82931286e-02f, -1.29084885e-01f, -7.59688839e-02f, 4.26188409e-02f, 2.21018165e-01f, 3.66783142e-02f, 1.31041437e-01f,
  2.59714425e-01f, 1.79423809e-01f, 4.30131331e-02f, 7.43345395e-02f, 1.49476295e-02f, 3.42110902e-01f, 1.38439819e-01f, 1.73982054e-01f, -5.32297015e-01f, -3.55899334e-02f,
  3.80592555e-01f, 7.64856488e-02f, -7.12845623e-02f, -1.07494228e-01f, 4.98747587e-01f, -3.79330143e-02f, -1.90873891e-01f, -1.81452155e-01f, 2.33664483e-01f, -3.91714536e-02f,
  7.19244927e-02f, -1.51385278e-01f, -8.95690396e-02f, 6.35297537e-01f, 5.18426336e-02f, 2.13348657e-01f, -7.63423294e-02f, 3.89329612e-01f, -3.18979770e-02f, -7.68485442e-02f,
  -1.77787453e-01f, -2.41824910e-01f, -1.10716388e-01f, -3.52157921e-01f, 1.66993767e-01f, -4.81776297e-02f, 2.61460356e-02f, -2.08866537e-01f, 2.26639658e-01f, 1.90354913e-01f,
  1.47332385e-01f, -5.89285605e-02f, 1.22954279e-01f, -2.30947629e-01f, -1.47725925e-01f, -3.39265972e-01f, 1.92501903e-01f, -1.43495560e-01f, -2.31810644e-01f, 1.30876943e-01f,
  1.44740328e-01f, 1.28811926e-01f, -1.20644756e-01f, -6.57546669e-02f, 1.94421813e-01f, 5.45469403e-01f, -1.13041680e-02f, 2.74487346e-01f, -2.18304247e-02f, 1.32007167e-01f,
  2.38458633e-01f, 2.48112440e-01f, -1.73946425e-01f, 3.33414584e-01f, 8.07222575e-02f, -2.60154694e-01f, 7.07518682e-02f, 1.98368669e-01f, 4.86108288e-02f, 1.61464348e-01f,
  2.18203679e-01f, 1.14049591e-01f, -2.11329875e-03f, -1.31533042e-01f, 1.83071524e-01f, -1.72843084e-01f, 3.47003222e-01f, 8.71334821e-02f, -1.90297812e-01f, -2.70799607e-01f,
  1.22718506e-01f, 1.71860799e-01f, -7.84404501e-02f, 7.83256367e-02f, 3.42458665e-01f, -6.88979551e-02f, -7.48537034e-02f, 3.85125279e-01f, 6.66174712e-03f, 4.81365714e-03f,
  1.18990801e-01f, -3.00898761e-01f, 2.00222939e-01f, 1.92315325e-01f, 2.31446147e-01f, -6.10657409e-02f, -1.09111950e-01f, 2.66634971e-01f, -3.79853919e-02f, 1.42466590e-01f,
  -5.60568012e-02f, 3.01971603e-02f, -8.52218494e-02f, 8.35925415e-02f, -9.95669588e-02f, 1.20575622e-01f, 9.33170393e-02f, 4.25505906e-01f, 1.97937563e-01f, 1.72866121e-01f,
  2.31535137e-01f, 2.43343428e-01f, -3.99197973e-02f, -1.79723531e-01f, -8.93115923e-02f, 2.03102931e-01f, 2.87149072e-01f, -6.94159791e-02f, -1.00192919e-01f, -2.38240492e-02f,
  2.39946544e-01f, -1.29840046e-01f, -7.17197508e-02f, 4.29101169e-01f, -5.61105348e-02f, -1.55477732e-01f, 3.54805440e-02f, 5.44783592e-01f, 4.31539267e-01f, 3.04494910e-02f,
  1.87673330e-01f, 6.80971593e-02f, 4.08786505e-01f, 4.92182016e-01f, 2.08976761e-01f, -1.41380861e-01f, -1.32918328e-01f, -1.28920913e-01f, 1.70900822e-01f, -3.72761101e-01f,
  1.74651206e-01f, 3.23655933e-01f, -1.22078143e-01f, 2.04581410e-01f, 8.74664709e-02f, -1.04129143e-01f, 8.60679224e-02f, -1.54948905e-01f, 1.81806728e-01f, 3.19140740e-02f,
  -1.33892372e-01f, 6.64431930e-01f, 3.14717591e-01f, 5.10690212e-01f, -2.50153154e-01f, -1.24589324e-01f, 2.50128508e-01f, -1.37072340e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -1.39338616e-02f, -2.53827535e-02f, 1.67672113e-01f, 4.16489750e-01f, -1.68205127e-02f, 4.48821902e-01f, 1.90788954e-02f, -6.80143535e-02f, 1.38416037e-01f, 1.65191695e-01f,
  6.94310144e-02f, -7.91723654e-02f, 2.44617403e-01f, 2.55260080e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.36003131e-02f, -2.93199927e-01f, -6.03433013e-01f, -3.20509285e-01f, -4.26257402e-01f, 1.92560658e-01f, -1.38791531e-01f, -4.20404561e-02f, -3.17987740e-01f, -1.18033895e-02f,
  -1.34524167e-01f, 4.30819601e-01f, 8.10135305e-02f, 2.51854658e-01f, 2.42711470e-01f, 2.59392243e-02f, -8.68155509e-02f, -4.21177506e-01f, -6.21173391e-03f, 5.19501984e-01f,
  -9.10164937e-02f, -3.56581450e-01f, 1.63664877e-01f, -5.18006086e-01f, -1.63459748e-01f, -7.07804505e-03f, -1.83402583e-01f, 3.06196630e-01f, 6.49839580e-01f, -1.19236581e-01f,
  -1.82569265e-01f, -5.44109829e-02f, -2.56869614e-01f, -1.38738662e-01f, -5.99736929e-01f, 2.01682419e-01f, -1.88496083e-01f, -3.35015148e-01f, -9.71847698e-02f, 9.54084769e-02f,
  -4.25457954e-01f, -3.33407164e-01f, 9.42739248e-02f, 1.78817242e-01f, 3.09465200e-01f, 2.79027283e-01f, -2.36851960e-01f, -6.35361001e-02f, 1.05404228e-01f, -3.37678462e-01f,
  -2.10140094e-01f, 5.07901073e-01f, -2.83010274e-01f, -5.76333813e-02f, 1.86911449e-01f, 4.79732275e-01f, -1.89417869e-01f, 8.22298154e-02f, -1.55036300e-02f, 2.78359503e-01f,
  -2.26796731e-01f, -3.34545940e-01f, 1.59834400e-01f, -6.45966887e-01f, 3.36024791e-01f, 1.04485416e+00f, 3.86824101e-01f, 1.11718088e-01f, 3.69699001e-01f, 2.68984288e-01f,
  1.29485950e-01f, 6.34920478e-01f, 1.98324442e-01f, -3.85714591e-01f, 1.24550812e-01f, -5.08661270e-01f, -3.10567915e-01f, 1.93874881e-01f, -2.06003025e-01f, -1.25335991e-01f,
  -4.05428886e-01f, 4.31799330e-02f, -2.46004596e-01f, 3.70917350e-01f, 7.38089625e-03f, -2.37403363e-01f, -4.01257604e-01f, -1.00389354e-01f, 6.13077544e-02f, -8.62825662e-02f,
  3.70104983e-02f, 4.83525932e-01f, 1.30896404e-01f, -4.57746983e-02f, 1.92579266e-03f, 2.89489269e-01f, -3.74882311e-01f, -3.04008633e-01f, 1.79006830e-01f, 2.32019648e-01f,
  3.99184227e-01f, 3.96919519e-01f, 2.18601540e-01f, -6.48713589e-01f, 1.27500659e-02f, -5.28087854e-01f, 9.50847685e-01f, -1.44693002e-01f, 2.28769854e-01f, -3.19418237e-02f,
  4.85257298e-01f, -3.14359903e-01f, -4.00233179e-01f, 3.67980748e-01f, 1.87982584e-03f, -8.46743733e-02f, 3.82834613e-01f, -3.58256429e-01f, -3.26775879e-01f, -4.30197388e-01f,
  -2.24192575e-01f, -2.53907919e-01f, 2.45115295e-01f, 2.30576769e-01f, -1.64805606e-01f, 5.46970963e-01f, -1.55325800e-01f, 5.86287379e-01f, -4.04407084e-01f, -3.32097828e-01f,
  6.65603995e-01f, 1.09847328e-02f, -3.78702611e-01f, -7.23336697e-01f, -6.63265353e-03f, -1.11157551e-01f, 8.11780542e-02f, 3.44763219e-01f, -1.16615109e-01f, 3.97386014e-01f,
  1.86202630e-01f, 2.31437907e-01f, 3.92468423e-01f, 1.03122016e-04f, 1.72291011e-01f, 1.70103997e-01f, 2.17931852e-01f, -9.93969738e-02f, 1.05481952e-01f, -1.90313309e-01f,
  -2.52205729e-01f, -5.75064182e-01f, -3.09985429e-01f, 1.29187360e-01f, -3.76208685e-02f, 2.93476164e-01f, 2.85265863e-01f, 2.43414864e-01f, -3.56011659e-01f, 6.40387177e-01f,
  -2.42387816e-01f, -3.29843432e-01f, 1.43624201e-01f, 2.13929281e-01f, 2.01038852e-01f, 5.11990488e-01f, 6.85368404e-02f, -8.51079598e-02f, 3.01771402e-01f, -3.92851055e-01f,
  2.92425036e-01f, 8.91194403e-01f, 2.65875399e-01f, 1.16442509e-01f, 1.20734379e-01f, -1.75680980e-01f, -5.71337461e-01f, -2.65291333e-01f, 7.13351890e-02f, 4.48190048e-02f,
  -2.46260285e-01f, -1.60335451e-01f, 1.03487879e-01f, 2.14546159e-01f, -1.51158705e-01f, -1.72802702e-01f, -1.20584741e-01f, 4.55949843e-01f, -2.42012873e-01f, -2.30944201e-01f,
  1.74951211e-01f, 6.25694811e-01f, 2.61284169e-02f, -2.08548233e-01f, 3.09775397e-02f, 9.97551531e-02f, 1.02684975e-01f, -2.79736251e-01f, 2.05708176e-01f, -2.88438559e-01f,
  6.66116923e-02f, 2.71309674e-01f, -3.35615844e-01f, -5.34548998e-01f, -9.30464044e-02f, -2.43359990e-02f, -1.77181304e-01f, 2.41447181e-01f, 5.14589846e-01f, 9.97124389e-02f,
  3.86212766e-02f, -5.65853044e-02f, 2.57724941e-01f, 6.64210379e-01f, -2.11289912e-01f, -5.28104007e-01f, 2.06328809e-01f, 6.11421883e-01f, 2.54163951e-01f, -4.67506051e-01f,
  1.58353850e-01f, -7.40886256e-02f, -1.86618522e-01f, -5.79085708e-01f, -2.00275093e-01f, 6.36910871e-02f, -3.95048827e-01f, -3.47011775e-01f, -5.14629185e-01f, -4.70463961e-01f,
  -3.00464630e-01f, -1.70218930e-01f, 9.53984540e-03f, 2.58962095e-01f, -2.37905115e-01f, -1.04727916e-01f, -4.90846578e-03f, -4.51836079e-01f, -1.49410635e-01f, 3.41320664e-01f,
  7.42725059e-02f, 5.47976382e-02f, 1.18722513e-01f, 5.02055474e-02f, -2.08999991e-01f, -1.50149941e-01f, -2.25484699e-01f, 5.36262393e-01f, 6.82783604e-01f, -2.65652955e-01f,
  -2.02791199e-01f, -3.13907176e-01f, -4.03655656e-02f, 2.35176295e-01f, -3.91846783e-02f, -2.74053276e-01f, 6.34257376e-01f, 4.45615709e-01f, 3.69183868e-01f, 2.58010119e-01f,
  3.18608642e-01f, 1.21219223e-02f, 2.10138202e-01f, 3.72973353e-01f, -1.48949280e-01f, 1.17840953e-01f, 5.12842238e-01f, 7.52970755e-01f, -3.61157030e-01f, -1.87038556e-02f,
  -4.83210951e-01f, 1.52560389e-02f, -6.33593723e-02f, -6.44992769e-01f, 1.45591184e-01f, -3.33872557e-01f, -4.06018317e-01f, 8.89803916e-02f, 1.27515167e-01f, 8.58194113e-01f,
  2.13914714e-03f, -2.19417155e-01f, -1.28350481e-01f, -3.59853238e-01f, -2.97447592e-01f, 4.21328358e-02f, 2.66492128e-01f, -9.19786394e-02f, 7.96413496e-02f, 3.74765366e-01f,
  -3.37088376e-01f, 1.06573224e-01f, 2.01763541e-01f, 2.67190725e-01f, 4.32702191e-02f, 6.19341016e-01f, -2.54640341e-01f, -1.88683867e-02f, -5.75713575e-01f, -4.04995501e-01f,
  -2.62939453e-01f, -4.41791385e-01f, -2.89624572e-01f, 1.42944559e-01f, 1.92358121e-02f, 3.58764261e-01f, 2.88436860e-01f, -9.81606469e-02f, 4.54095960e-01f, -3.68373021e-02f,
  -1.80425197e-01f, -5.22166014e-01f, 2.89296180e-01f, -1.45546778e-03f, 2.41598055e-01f, -4.23321128e-01f, 1.88094467e-01f, 4.06198829e-01f, -3.50019813e-01f, 3.78768206e-01f,
  -1.45646721e-01f, -4.75849450e-01f, -5.05813062e-01f, -3.41407895e-01f, -3.81299317e-01f, -1.24919057e-01f, -2.39984035e-01f, -1.42413333e-01f, 2.07026992e-02f, 1.97584093e-01f,
  2.98619360e-01f, 2.99983304e-02f, 2.04431519e-01f, 2.26387724e-01f, 5.00609159e-01f, -1.12989739e-01f, -5.48319757e-01f, 5.58587134e-01f, 8.20524767e-02f, -2.11239420e-02f,
  -8.43811929e-02f, -3.93337935e-01f, 8.73908520e-01f, -2.60268956e-01f, -1.93628371e-01f, 8.15858841e-02f, 1.24292180e-03f, 1.15209267e-01f, -1.75911129e-01f, 4.66791093e-02f,
  5.26690125e-01f, -1.38458848e-01f, 5.10923326e-01f, -3.61377820e-02f, 5.12026250e-01f, 4.33339834e-01f, 3.70996557e-02f, -1.20994009e-01f, 9.61725116e-02f, 2.31508821e-01f,
  7.61381313e-02f, -1.32779121e-01f, -6.42672300e-01f, -5.92384398e-01f, 1.53274924e-01f, -3.62315297e-01f, -2.55828798e-01f, -6.94628134e-02f, 5.75094581e-01f, 2.97878236e-01f,
  -4.51095924e-02f, -4.61703867e-01f, -9.12289917e-02f, 8.90671015e-01f, -1.33192390e-01f, 4.45851535e-01f, -1.03896596e-02f, -6.46153912e-02f, 2.28081495e-01f, -3.75188857e-01f,
  -5.01075506e-01f, -3.10031086e-01f, -6.37315512e-02f, 3.58283408e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.68535018e-01f, 8.67244825e-02f, -7.00258017e-02f, -6.54311925e-02f, -1.45399803e-02f, -9.88523886e-02f, 1.43848717e-01f, 1.63528681e-01f, -6.85639232e-02f, 1.19515486e-01f,
  -6.86686113e-02f, 8.05591717e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    