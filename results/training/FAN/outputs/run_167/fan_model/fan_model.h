/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.19441969e-02f, -2.81486213e-01f, -1.86983168e-01f, 3.56732368e-01f, 2.87487991e-02f, -8.04981440e-02f, 1.78882480e-01f, -1.18083857e-01f, 2.04907775e-01f, 1.21049784e-01f,
  3.07672977e-01f, -8.13496336e-02f, 1.22803319e-02f, 2.80576319e-01f, 9.38083157e-02f, 7.82894865e-02f, 1.91460028e-01f, 8.75325948e-02f, -4.58819047e-02f, 6.01256005e-02f,
  -5.59487864e-02f, 2.27424964e-01f, 5.87276630e-02f, -1.15305647e-01f, -5.67658767e-02f, -1.78097218e-01f, 6.88918531e-02f, -1.40780613e-01f, 3.32589373e-02f, 4.72789146e-02f,
  1.38532072e-01f, 6.12925626e-02f, -1.15490571e-01f, 4.19533886e-02f, 5.14434092e-02f, -1.06788367e-01f, -3.95074636e-02f, 2.07917262e-02f, -5.08523509e-02f, 4.43033986e-02f,
  2.44701914e-02f, -5.42124659e-02f, 6.35720193e-02f, -5.09921126e-02f, -6.70020804e-02f, 1.08057391e-02f, 2.40649488e-02f, 5.08058667e-02f, -2.48553092e-03f, -8.59573185e-02f,
  4.00464498e-02f, -2.65421476e-02f, -3.82163227e-02f, 2.14518588e-02f, 3.09681688e-02f, 4.76382524e-02f, -4.22386676e-02f, -6.53244928e-02f, -5.61567992e-02f, -1.80390216e-02f,
  -8.42935294e-02f, -8.18752721e-02f, -3.45980972e-02f, -4.22513969e-02f, -1.32343292e-01f, -1.28342593e-02f, 3.64891924e-02f, 3.87962721e-02f, -3.71370162e-03f, 5.10936789e-02f,
  -1.68433110e-03f, 1.71137264e-03f, 5.64475246e-02f, 8.04401413e-02f, 3.80826183e-02f, -3.89364175e-03f, 2.67405119e-02f, -3.41858566e-02f, 5.39695397e-02f, 2.64300080e-03f,
  7.41889626e-02f, 6.34724870e-02f, 1.64404362e-02f, 8.77514258e-02f, -2.25059805e-03f, 3.00982352e-02f, -2.23626141e-02f, 7.91024789e-03f, 2.50173770e-02f, 4.95644344e-04f,
  -5.72883151e-02f, -1.87382147e-01f, 6.21283986e-02f, 1.48473065e-02f, 3.71111184e-02f, -2.59495061e-02f, 2.18184814e-02f, 2.77687628e-02f, 3.72117236e-02f, -2.70175412e-02f,
  -2.00692751e-02f, 1.66107866e-03f, 3.25434804e-02f, 3.43506522e-02f, -9.83374268e-02f, 2.43453961e-03f, 1.42195933e-02f, 7.46692717e-02f, 6.22775666e-02f, -1.02954365e-01f,
  -3.39898393e-02f, 7.88249299e-02f, -8.36756006e-02f, 1.92763470e-02f, -3.21380347e-02f, 4.99409586e-02f, -9.03669447e-02f, 6.68087825e-02f, -6.26905188e-02f, 8.33290964e-02f,
  7.25205317e-02f, 3.35739069e-02f, -9.53228846e-02f, 8.51202458e-02f, 5.78531735e-02f, 3.84652108e-01f, 3.32407624e-01f, -2.13613342e-02f, 3.13276388e-02f, 1.96480766e-01f,
  2.02024668e-01f, 9.40908566e-02f, 1.79921091e-02f, 3.07542086e-01f, 4.30878699e-02f, 8.12075958e-02f, 2.77598977e-01f, 2.63214260e-01f, 2.15034932e-02f, 6.64144605e-02f,
  -9.16823074e-02f, 1.60495371e-01f, -5.48761375e-02f, -4.59280796e-02f, 8.18132237e-02f, -1.21600725e-01f, -1.03381775e-01f, -1.27890438e-01f, 4.98434380e-02f, 2.37790551e-02f,
  5.29665537e-02f, -1.05528787e-01f, -4.41443510e-02f, -7.20294118e-02f, 7.36819133e-02f, 4.26017493e-02f, 2.42153201e-02f, -1.86261479e-02f, -9.88915339e-02f, -1.71743836e-02f,
  -1.73592865e-02f, 5.01627028e-02f, 5.69142066e-02f, 1.19999014e-02f, 5.59687763e-02f, -3.37954573e-02f, -7.11971298e-02f, -2.90929824e-02f, 2.36130375e-02f, -6.97752386e-02f,
  4.82619219e-02f, -7.25700483e-02f, -1.57630965e-02f, -4.76748571e-02f, 7.79217705e-02f, 1.91674326e-02f, 7.84228295e-02f, 8.44377056e-02f, 2.99398229e-02f, 7.15089869e-03f,
  -9.38447285e-03f, 8.64695087e-02f, 7.38012493e-02f, 1.80899724e-02f, -9.96275153e-03f, -2.17464212e-02f, 5.90301938e-02f, 3.68543155e-02f, -5.09460531e-02f, 4.67815176e-02f,
  -1.90575328e-02f, 1.45554161e-02f, 2.79181283e-02f, 4.99897040e-02f, 6.62601963e-02f, 1.94068588e-02f, -5.65545261e-03f, 1.62077285e-02f, 2.45847739e-02f, 1.01900637e-01f,
  -2.15111347e-03f, 8.74365717e-02f, 5.92789911e-02f, -5.67718036e-02f, -5.85498400e-02f, -4.72851060e-02f, 3.92949954e-02f, -1.53219691e-02f, -9.26219895e-02f, 6.23439029e-02f,
  9.32357237e-02f, -5.13370894e-02f, 7.32680634e-02f, 2.17298567e-02f, 3.60481367e-02f, 6.79097399e-02f, 4.32163440e-02f, -8.04723520e-03f, -2.45883297e-02f, -5.13543338e-02f,
  -4.18699831e-02f, -1.25099160e-02f, -4.10024226e-02f, 2.05562003e-02f, -8.43328312e-02f, 3.01204380e-02f, 1.59991346e-02f, -3.25834602e-02f, -2.68030819e-02f, -3.43603790e-02f,
  -2.55993358e-03f, 7.23680779e-02f, -6.11577742e-02f, 4.98144142e-02f, 4.41094637e-02f, -1.63737871e-03f, 6.37775287e-02f, 4.79856022e-02f, -4.11044732e-02f, 5.12561351e-02f,
  -1.00606438e-02f, 3.70258689e-02f, 4.94223274e-03f, -2.01596897e-02f, -1.84069380e-01f, 3.23385417e-01f, 3.12269479e-01f, -1.07580610e-02f, 1.71034098e-01f, 2.50676095e-01f,
  7.57684112e-02f, 3.78768966e-02f, 1.19255446e-01f, 1.25775382e-01f, 1.02710269e-01f, 1.11154459e-01f, 7.66075775e-02f, 6.06979877e-02f, -7.17385709e-02f, 7.80767389e-03f,
  -1.35963723e-01f, 1.39078479e-02f, 2.53609233e-02f, -2.25896001e-01f, -4.88740839e-02f, -1.15073495e-01f, -3.13321054e-02f, -3.69710587e-02f, 2.68959999e-02f, 8.82856026e-02f,
  6.77826405e-02f, -5.04108928e-02f, -6.09709583e-02f, 1.10425763e-01f, -2.08189934e-02f, 7.12955445e-02f, 1.19991399e-01f, 7.23427609e-02f, -2.33502835e-02f, -9.18864831e-02f,
  7.14286119e-02f, -6.71971217e-02f, -1.98094677e-02f, 6.16062321e-02f, -6.21284172e-02f, -2.37864647e-02f, -5.13564125e-02f, 6.68029860e-02f, -1.01535112e-01f, -9.09713060e-02f,
  -2.80610826e-02f, 2.40444988e-02f, 4.76508029e-02f, 7.98427127e-03f, 8.83390829e-02f, 7.67328292e-02f, -9.26756300e-03f, 1.15480788e-01f, -1.20807625e-02f, -1.35333493e-01f,
  -5.18498309e-02f, -1.85326915e-02f, -2.27985736e-02f, -4.21573184e-02f, -5.82596986e-03f, 1.76758282e-02f, 9.25557166e-02f, 4.59273905e-02f, -2.41595730e-02f, -8.65434036e-02f,
  -1.73648633e-02f, -8.25204700e-03f, -7.61962906e-02f, 2.71840356e-02f, 3.24162133e-02f, 1.14656664e-01f, -3.70511636e-02f, -8.14963356e-02f, -1.42615726e-02f, -5.73807247e-02f,
  2.34452598e-02f, 1.13931723e-01f, 2.65322570e-02f, -1.52221452e-02f, 1.00123482e-02f, 4.74925041e-02f, -3.73029709e-02f, 2.87370365e-02f, 3.89197804e-02f, -1.48346191e-02f,
  8.08619410e-02f, -8.90952162e-03f, 2.21951697e-02f, 9.40304026e-02f, -5.96545041e-02f, 4.16231193e-02f, 1.63769510e-05f, 8.80167261e-02f, 1.21932067e-01f, -2.54364628e-02f,
  5.68458438e-02f, 3.90072167e-02f, -6.27531856e-02f, 1.24489091e-01f, 1.07263625e-01f, 7.32966661e-02f, 5.92882410e-02f, 1.18292794e-01f, -5.35436571e-02f, 3.24701406e-02f,
  -7.76145756e-02f, -1.22200117e-01f, 3.62222530e-02f, -5.81957176e-02f, 3.05101071e-02f, 8.25525522e-02f, -8.78137946e-02f, 1.18771985e-01f, -1.11133665e-01f, -8.98478776e-02f,
  1.78924620e-01f, -2.02424243e-01f, -1.41632766e-01f, 2.54458547e-01f, -3.13586034e-02f, -5.92490062e-02f, -3.91487405e-02f, 3.74470018e-02f, 2.01979861e-01f, -1.06664322e-01f,
  1.15049638e-01f, -1.24904819e-01f, -1.72303766e-01f, 2.57768631e-01f, 3.15441817e-01f, 2.83355620e-02f, 2.59765863e-01f, 7.31123686e-02f, 2.84154285e-02f, 1.48096785e-01f,
  5.99557869e-02f, 1.74228489e-01f, -8.68408009e-02f, -1.13562979e-01f, -2.12619081e-01f, -5.05289249e-02f, 2.05846936e-01f, -2.78798550e-01f, 3.17151248e-02f, -7.28546605e-02f,
  4.37871628e-02f, 7.27535598e-03f, -5.38463183e-02f, -1.11679457e-01f, 2.57747248e-02f, -1.90252494e-02f, 4.96810907e-03f, -1.17269896e-01f, 4.23561521e-02f, -6.06839806e-02f,
  -2.31308341e-02f, 3.02299988e-02f, 2.55768653e-02f, -1.37348205e-01f, -6.14410229e-02f, -9.80581418e-02f, -1.21540740e-01f, -7.25198612e-02f, -3.98928598e-02f, -1.30147068e-03f,
  -1.36694917e-02f, -8.25542212e-02f, 8.25580582e-02f, -9.81219020e-03f, 2.91200802e-02f, -4.71754186e-02f, -5.22019854e-03f, 1.59164960e-03f, -7.21042929e-03f, 2.49829497e-02f,
  4.76681218e-02f, 1.71078548e-01f, -1.04701694e-03f, -1.37725137e-02f, 1.76075753e-02f, 2.10539307e-02f, 7.42738992e-02f, -2.60961056e-02f, -4.05841842e-02f, 7.33928755e-02f,
  3.89190651e-02f, 1.39097897e-02f, -7.00739445e-03f, -2.83522252e-02f, 5.04083596e-02f, -6.59715086e-02f, -5.17198965e-02f, -8.36687461e-02f, 3.26788016e-02f, 3.34376097e-02f,
  -1.26926880e-02f, 5.55362999e-02f, -1.39289387e-02f, -3.97511460e-02f, 3.91677842e-02f, -3.09968200e-02f, -4.81689386e-02f, -9.18001607e-02f, -3.24811116e-02f, -3.73986065e-02f,
  1.77757248e-01f, 1.53792024e-01f, 5.88751137e-02f, 2.50142813e-03f, 6.28672615e-02f, -1.77163035e-02f, 5.21658845e-02f, -4.04801629e-02f, -7.12023005e-02f, 2.12610178e-02f,
  -5.88666822e-04f, 7.45435879e-02f, -1.64665449e-02f, -1.12340041e-02f, 2.88945772e-02f, 3.22727710e-02f, 4.09373222e-03f, 4.35246229e-02f, 1.80160522e-01f, 8.82416666e-02f,
  4.49652784e-03f, 3.91027564e-03f, -5.32326140e-02f, -7.04684928e-02f, 3.70225981e-02f, 1.38091492e-02f, 3.46293598e-02f, -2.81902403e-02f, -5.79021908e-02f, 2.46720426e-02f,
  -2.69115299e-01f, 2.22591877e-01f, -9.58839655e-02f, 2.48478800e-02f, -1.98255748e-01f, -2.03335688e-01f, -1.54938579e-01f, -8.11896920e-02f, 2.26862237e-01f, 1.80928901e-01f,
  -1.22192595e-02f, -1.75249249e-01f, 1.53717682e-01f, 8.30299258e-02f, -1.88624591e-01f, 2.16636583e-01f, 1.03556007e-01f, 5.28712459e-02f, 1.14492029e-02f, -1.25268862e-01f,
  -1.83101624e-01f, 1.11179883e-02f, -2.04324275e-01f, 9.46427230e-04f, -2.18668684e-01f, -8.08516890e-02f, 8.74061808e-02f, -9.87529010e-02f, -1.41955420e-01f, -1.40606072e-02f,
  -2.58187149e-02f, 8.35948735e-02f, -1.09594138e-02f, 7.47944266e-02f, -6.65559098e-02f, -8.17613527e-02f, 3.20514999e-02f, -1.69429760e-02f, -1.84875593e-01f, 6.96044136e-03f,
  6.91213273e-03f, -8.13886151e-02f, 7.94615075e-02f, 8.27879012e-02f, 1.94348991e-02f, -1.67050455e-02f, -5.88565841e-02f, -3.75763513e-02f, -7.43710399e-02f, -2.45760620e-01f,
  -1.09718934e-01f, -6.71127886e-02f, 1.32162683e-02f, 1.52372783e-02f, 5.50401583e-02f, 1.37264691e-02f, -1.64550543e-02f, -2.10512623e-01f, 9.45051238e-02f, -2.94197462e-02f,
  -1.28315210e-01f, 2.93366285e-03f, 3.88076864e-02f, 3.46119963e-02f, 6.26400521e-04f, 5.72771616e-02f, 1.96289301e-01f, 6.26063123e-02f, 5.72131425e-02f, 6.79349601e-02f,
  -6.35196343e-02f, -2.71055736e-02f, 1.40878996e-02f, 8.82463083e-02f, 5.01182005e-02f, 1.45112306e-01f, 2.44280025e-02f, 5.80524141e-03f, -4.77144904e-02f, -3.45442700e-03f,
  1.25043556e-01f, -3.16898047e-04f, 3.82368104e-03f, 6.91524372e-02f, 5.17035797e-02f, -8.46945420e-02f, 8.98668990e-02f, 5.97434826e-02f, 3.55585758e-03f, 2.12730351e-03f,
  1.68642119e-01f, 3.08724046e-01f, 7.11631030e-02f, -3.58622819e-02f, 1.44203082e-01f, 2.21225433e-02f, 1.94804817e-01f, 9.14974660e-02f, 4.43800678e-03f, 2.13624705e-02f,
  -1.00181185e-01f, 7.87781831e-03f, 4.85026538e-02f, -1.02900462e-02f, 5.14822602e-02f, 6.22450598e-02f, -4.19622846e-02f, 2.22708378e-02f, 1.60660762e-02f, -6.16782382e-02f,
  -1.38101950e-02f, -2.76966896e-02f, 4.12535407e-02f, -5.84427603e-02f, 6.46337494e-02f, 7.46064261e-02f, -4.46497928e-03f, -4.95672226e-02f, -2.11538877e-02f, 2.07604598e-02f,
  -2.06268862e-01f, 1.41165495e-01f, -3.17622125e-01f, -5.35595156e-02f, -1.76745430e-01f, -1.08972996e-01f, -2.49632448e-01f, -2.77436562e-02f, -3.31577569e-01f, 8.55912417e-02f,
  4.83264700e-02f, -2.34421566e-01f, -4.52829599e-02f, 1.54787391e-01f, -2.90711999e-01f, -5.23790680e-02f, 1.35569617e-01f, 1.67756245e-01f, -3.31785269e-02f, 1.68769866e-01f,
  4.63566044e-03f, 1.59669593e-01f, -9.37723275e-03f, 1.43586159e-01f, 1.53751254e-01f, 1.72267586e-01f, 2.11997062e-01f, -1.45489201e-02f, 2.50352055e-01f, -7.03730136e-02f,
  7.51188919e-02f, 2.41177212e-02f, 6.13600248e-03f, 2.10755877e-02f, 2.24246364e-02f, 5.43083288e-02f, 3.85888740e-02f, 5.95125891e-02f, 7.35526718e-03f, 3.28915101e-03f,
  2.91092056e-05f, 2.53586564e-02f, 3.50369886e-02f, -1.16680518e-01f, 5.37716821e-02f, -8.06814209e-02f, -7.18144774e-02f, -3.53738666e-02f, -2.55546793e-02f, -3.48135903e-02f,
  -1.34889916e-01f, 9.52006355e-02f, 2.29869299e-02f, 5.63053191e-02f, -9.55664460e-03f, -2.10981518e-02f, 4.07032706e-02f, -8.49600211e-02f, 4.07424085e-02f, 2.85511464e-02f,
  -2.03000978e-02f, 1.12384424e-01f, 5.21979295e-02f, 5.41573353e-02f, -6.17455728e-02f, -2.31189523e-02f, 6.64324835e-02f, -2.44601481e-02f, -1.86072309e-02f, 1.81794874e-02f,
  8.95116925e-02f, -2.32517649e-03f, 1.46292988e-02f, -2.49316879e-02f, 1.47575485e-02f, -5.11148460e-02f, -1.37344256e-01f, 4.54458632e-02f, -7.48456195e-02f, -6.16127476e-02f,
  -2.88787447e-02f, -4.85725552e-02f, -1.12918876e-02f, 1.59346536e-01f, 3.67302932e-02f, -7.21813440e-02f, 2.55191624e-02f, -5.19610494e-02f, 2.74622124e-02f, -2.59264540e-02f,
  2.33757004e-01f, 2.34660357e-01f, -5.12023792e-02f, 4.58573028e-02f, 7.38594541e-03f, -1.39343785e-02f, -1.10908272e-02f, 4.15607244e-02f, 1.88762993e-02f, 3.89967784e-02f,
  2.63970974e-03f, 9.69845206e-02f, 6.92081228e-02f, -2.23782882e-02f, 4.53924611e-02f, -6.42971247e-02f, 7.10674003e-03f, 6.04752125e-03f, -4.43501398e-02f, -8.10402539e-03f,
  -3.87413129e-02f, -3.76499887e-03f, 2.11111400e-02f, -5.42986318e-02f, 7.72095248e-02f, 1.22282125e-01f, 9.11790412e-03f, -6.29324913e-02f, 1.34161696e-01f, 1.65185891e-02f,
  4.42843825e-01f, -2.82391340e-01f, -2.96017885e-01f, 6.47975355e-02f, 1.79284848e-02f, -4.89834026e-02f, 6.14170618e-02f, -8.61815587e-02f, 5.32146133e-02f, -1.07627688e-02f,
  -6.09168932e-02f, 1.23107217e-01f, -1.73501268e-01f, -2.47675739e-02f, -1.53528214e-01f, -1.51243359e-01f, 2.13283449e-02f, 1.08916767e-01f, -6.87421337e-02f, 3.72812487e-02f,
  -1.00271441e-01f, 6.38377108e-03f, -2.35081390e-01f, -8.44988748e-02f, 2.85328403e-02f, 1.33163631e-02f, 3.45823728e-02f, -6.21509664e-02f, 8.79252180e-02f, 3.40354927e-02f,
  -4.29639500e-03f, -4.56744432e-02f, -4.59267087e-02f, -4.65150783e-03f, -6.65386394e-02f, 5.77197783e-02f, 6.72792792e-02f, 7.45421648e-02f, -2.85121314e-02f, 5.19990698e-02f,
  5.29982597e-02f, 3.43921371e-02f, 2.85093449e-02f, -7.85739943e-02f, 7.33273849e-02f, -2.04361062e-02f, -1.01755165e-01f, 8.21258500e-03f, -1.96426287e-02f, -8.05887673e-03f,
  -2.69663334e-02f, -1.40759759e-02f, 7.20085576e-02f, 3.65652479e-02f, -3.69982817e-03f, -1.23283705e-02f, -4.19229046e-02f, 5.31990193e-02f, 7.41104931e-02f, 9.12056494e-05f,
  1.04190009e-02f, -2.14013904e-02f, 2.99442280e-03f, -1.39950833e-03f, -2.43438445e-02f, -7.04924092e-02f, 4.94270287e-02f, 2.91067231e-02f, 7.82008320e-02f, 1.52741596e-02f,
  -1.90477762e-02f, 6.78759515e-02f, 6.26774784e-03f, -1.29101602e-02f, 2.23885216e-02f, 7.29465066e-03f, 1.36282360e-02f, -5.86798787e-02f, 6.67042332e-03f, -7.98573196e-02f,
  -8.25495273e-03f, -2.01318786e-02f, 1.50587754e-02f, 6.04091436e-02f, -5.63333696e-03f, 4.03045490e-03f, 1.08358543e-02f, -5.26267998e-02f, -1.83280166e-02f, 1.60075687e-02f,
  5.80924563e-03f, -1.26033157e-01f, -4.31902036e-02f, 6.58778250e-02f, -8.16096365e-02f, -4.85424045e-03f, -9.86205637e-02f, 6.56242203e-03f, -4.26417515e-02f, -8.99988506e-03f,
  1.17204282e-02f, 6.80545866e-02f, 1.84297338e-02f, -2.64553330e-03f, -1.94359059e-03f, -5.38833216e-02f, -1.35301296e-02f, 1.79960635e-02f, 6.95317984e-02f, -2.80418508e-02f,
  4.39639352e-02f, 1.03885353e-01f, 1.58483628e-02f, 4.07976098e-02f, 3.85195464e-02f, 1.76673103e-02f, -6.11314215e-02f, 5.63067496e-02f, 1.82588156e-02f, 4.89402376e-02f,
  2.38687411e-01f, -3.95263806e-02f, 1.21399112e-01f, 1.20148309e-01f, 1.83164462e-01f, 1.09957419e-01f, 1.07728109e-01f, 1.56405687e-01f, 1.78265661e-01f, -1.43094018e-01f,
  -1.29736597e-02f, -1.06775977e-01f, -1.37924239e-01f, 7.81488884e-03f, 1.44982100e-01f, 5.19493558e-02f, 6.74944147e-02f, -1.15486033e-01f, 1.41660169e-01f, -7.37852789e-03f,
  1.11871429e-01f, 6.10116795e-02f, 1.91549957e-01f, 9.17423740e-02f, 4.48329374e-02f, -2.70775566e-03f, -1.20053314e-01f, -3.52300564e-03f, -1.36139408e-01f, 1.01420045e-01f,
  -1.32149607e-01f, -1.13546019e-02f, 5.82244992e-02f, -8.07902813e-02f, -5.06361872e-02f, -3.45272920e-03f, -1.02753147e-01f, 4.52710316e-02f, -4.45379876e-02f, -4.34860326e-02f,
  1.74913425e-02f, -7.70001262e-02f, 5.85074350e-02f, 1.48886042e-02f, -1.59515981e-02f, 9.74404800e-04f, 1.30836591e-01f, -6.29157107e-03f, 6.77256361e-02f, 7.36903921e-02f,
  4.61837426e-02f, -4.24781144e-02f, -1.76084880e-02f, 2.75417771e-02f, 3.74247953e-02f, 1.15843035e-01f, -2.46029198e-02f, -8.33370090e-02f, -6.94019422e-02f, -1.22577744e-02f,
  6.05160482e-02f, -9.94463358e-03f, -3.21671995e-03f, -1.40723228e-01f, -3.80364358e-02f, -1.28461653e-02f, -9.57188010e-02f, -8.67581666e-02f, -1.00360187e-02f, -1.35233968e-01f,
  -1.11398496e-01f, 1.20370258e-02f, -7.71890730e-02f, -5.88172451e-02f, -5.96929565e-02f, 6.19211793e-02f, -3.43170166e-02f, -3.75795960e-02f, 7.36318529e-02f, -2.63333153e-02f,
  3.27001438e-02f, -3.06288619e-03f, 6.55150190e-02f, 2.18065437e-02f, -2.39477567e-02f, -6.99828044e-02f, 1.30386176e-02f, 3.52460518e-02f, 3.36222798e-02f, -8.65477547e-02f,
  -3.07288110e-01f, -2.24778518e-01f, -2.93782018e-02f, -1.19918726e-01f, -9.61205661e-02f, -3.12650651e-02f, -2.16567976e-04f, 6.48330376e-02f, -1.11675933e-01f, 7.73264840e-02f,
  3.15302052e-02f, -6.37220517e-02f, -6.24804683e-02f, -4.78231069e-03f, -2.87361369e-02f, 1.17552020e-02f, 6.02585599e-02f, -1.85543075e-02f, -5.41734025e-02f, -3.37546617e-02f,
  3.60743701e-02f, -2.30160415e-01f, 3.17042097e-02f, 4.93992679e-02f, -1.81794669e-02f, 2.15244442e-02f, -7.71533027e-02f, -1.53105669e-02f, -5.75065091e-02f, -5.96956760e-02f,
  -4.76266071e-02f, 1.90166116e-01f, -2.44719341e-01f, -2.49777790e-02f, -7.17196688e-02f, 3.87066118e-02f, -7.59117082e-02f, -3.27730551e-02f, -1.51461167e-02f, 1.58219844e-01f,
  1.22190051e-01f, -6.30436912e-02f, -5.97153837e-03f, 1.37658566e-01f, -1.36140645e-01f, -3.39108184e-02f, 7.68017098e-02f, 2.73756757e-02f, -4.48420271e-02f, 2.10800663e-01f,
  6.08408786e-02f, 2.52303988e-01f, -1.01868957e-01f, 1.25013381e-01f, 1.57848835e-01f, 9.90597531e-03f, 3.87971215e-02f, -3.51658911e-02f, 6.34795427e-02f, -4.01234180e-02f,
  1.64263740e-01f, -6.25540689e-02f, 9.51368883e-02f, -4.56853630e-03f, 9.63284075e-02f, -3.82920466e-02f, 4.70333770e-02f, -1.03240654e-01f, -6.43449649e-03f, -4.61991057e-02f,
  -1.80171393e-02f, 4.35562953e-02f, -3.45736146e-02f, 1.15981093e-02f, 1.08651213e-01f, -5.30493483e-02f, -1.21238552e-01f, -8.90742335e-03f, 2.56093238e-02f, -5.96119948e-02f,
  -2.40113232e-02f, -1.40992319e-02f, 5.48927188e-02f, -4.21997197e-02f, -2.51824819e-02f, -3.11847404e-02f, -2.51475200e-02f, -5.38509302e-02f, 1.02102500e-03f, 4.59293202e-02f,
  -2.73468122e-02f, 1.08161502e-01f, -8.27153996e-02f, 1.41553506e-01f, -1.39102563e-02f, 1.59855112e-02f, 7.46440217e-02f, -3.62039246e-02f, 1.89812388e-02f, 1.01774268e-01f,
  2.29065269e-02f, 1.54027264e-04f, 3.28757763e-02f, 5.44294752e-02f, 8.83705467e-02f, -2.92940158e-02f, -2.21277867e-02f, -5.26577421e-02f, -6.76393583e-02f, -1.48587697e-03f,
  -8.77207741e-02f, 5.12352958e-03f, -4.86958213e-02f, -9.33121666e-02f, 6.98662698e-02f, 4.90461439e-02f, 1.73561275e-02f, -5.65225855e-02f, -3.39407437e-02f, -4.69875894e-02f,
  2.51136571e-01f, 1.49064541e-01f, 9.66600180e-02f, 1.03478864e-01f, 9.57688838e-02f, 4.26514558e-02f, 1.81513131e-02f, -3.67993712e-02f, 9.74774361e-03f, -2.77143363e-02f,
  2.06742678e-02f, 6.54939264e-02f, 2.54756194e-02f, 6.86038956e-02f, 2.74249148e-02f, 1.57243852e-02f, -9.13083106e-02f, 4.69765849e-02f, 6.10502213e-02f, 8.26776326e-02f,
  -2.43614390e-02f, 7.27665424e-02f, -1.26515150e-01f, -1.94932930e-02f, 7.57166417e-04f, -1.35179528e-03f, -1.76746715e-02f, 3.05009950e-02f, -2.91872676e-02f, 7.27138072e-02f,
  4.29852307e-02f, -2.15755254e-01f, 1.80590898e-01f, 1.64598197e-01f, 5.90603240e-02f, -2.64009207e-01f, 5.60786687e-02f, -1.09875361e-02f, 1.31643102e-01f, -9.09975991e-02f,
  3.46512347e-02f, 8.82029384e-02f, -9.36827287e-02f, -1.63566358e-02f, -1.14488699e-01f, -1.47937953e-01f, -1.09606855e-01f, 2.21909266e-02f, 2.78237220e-02f, -1.23323292e-01f,
  -3.91470827e-02f, -8.00987780e-02f, -1.26416951e-01f, 1.01204947e-01f, -1.64698079e-01f, 1.62352845e-01f, -1.67082831e-01f, 6.24063723e-02f, 2.97521874e-02f, -2.23582759e-02f,
  -1.30186945e-01f, 2.21903875e-01f, -1.20911367e-01f, -7.31015056e-02f, -6.54334947e-02f, -1.66345965e-02f, -7.90337771e-02f, -1.00858640e-02f, 8.34693983e-02f, 1.22296847e-01f,
  -8.94396082e-02f, 2.45614201e-02f, -3.17053758e-02f, 2.10165232e-01f, -3.41204330e-02f, 1.41058475e-01f, 6.90350458e-02f, 4.69265431e-02f, 1.40665034e-02f, 4.17107940e-02f,
  -8.74556527e-02f, -7.37356991e-02f, -1.29319608e-01f, -1.09611049e-01f, -1.09591499e-01f, -1.98331755e-02f, 6.70565292e-02f, 9.65575594e-03f, -1.11445338e-02f, 2.73556598e-02f,
  -5.25806099e-02f, 3.43269892e-02f, 9.86231118e-02f, 2.58525833e-02f, 1.24911813e-03f, 2.36472338e-02f, -1.07668452e-01f, -2.08287667e-02f, 1.04265055e-02f, -7.48614371e-02f,
  -6.98472187e-02f, -7.77318701e-02f, 2.84960363e-02f, 1.66835985e-03f, 1.64631996e-02f, -1.90463010e-02f, 6.95358366e-02f, 1.46734864e-01f, -8.19677934e-02f, 2.79852026e-03f,
  1.39962062e-01f, 5.11769615e-02f, -1.59516484e-01f, -5.49185984e-02f, -9.27210897e-02f, 1.46892667e-02f, 1.28297051e-02f, -1.94961112e-02f, -3.08410674e-02f, -6.14729747e-02f,
  -3.04310858e-01f, -8.53542835e-02f, -1.03270337e-01f, -7.75577202e-02f, -2.12367214e-02f, -7.24741817e-02f, 2.20820203e-01f, -6.80500269e-02f, -2.06830148e-02f, -1.93514228e-02f,
  2.35426500e-02f, -2.47528609e-02f, -1.03745349e-01f, 9.08977911e-02f, -1.38482273e-01f, 2.37263516e-02f, 1.06422650e-02f, -8.59929156e-03f, -1.34590402e-01f, 5.41064469e-03f,
  -1.06795222e-01f, 5.49567305e-02f, -2.79094297e-02f, -8.31058770e-02f, -2.25596260e-02f, -1.36587411e-01f, 1.26561433e-01f, 1.16401576e-01f, 4.90056798e-02f, 1.94196068e-02f,
  -3.46537173e-01f, -1.33691102e-01f, -4.09263559e-02f, 1.49449021e-01f, -1.79582983e-01f, -2.17796654e-01f, -1.31982204e-03f, -8.15590471e-02f, 1.22092083e-01f, 9.78499949e-02f,
  -9.95453224e-02f, -1.83478624e-01f, 8.90489444e-02f, 6.31118715e-02f, -1.66992605e-01f, 1.36787191e-01f, 4.69024926e-02f, -8.01383778e-02f, 6.04760982e-02f, -1.17731825e-01f,
  -3.40252146e-02f, -2.47354507e-02f, 7.90742114e-02f, 3.85640226e-02f, -7.72642270e-02f, 9.18782753e-05f, -3.74242105e-02f, 5.68715781e-02f, -1.41369877e-02f, 3.83769870e-02f,
  3.41708511e-02f, 9.02053490e-02f, 1.51777700e-01f, 6.01532534e-02f, -8.17530528e-02f, -5.59569262e-02f, 1.05776526e-01f, -6.29034862e-02f, 4.31354940e-02f, -2.54235929e-03f,
  -1.11514973e-02f, -4.75907885e-02f, 6.59176335e-02f, 2.29674485e-02f, -5.26181348e-02f, 1.02853820e-01f, 3.16498888e-04f, 1.24015249e-01f, 4.52574752e-02f, -5.73421828e-02f,
  -5.28836623e-02f, 1.01798102e-02f, -6.33721007e-04f, -4.92843576e-02f, -1.19565465e-01f, -4.19669710e-02f, 1.91599410e-02f, -8.46344307e-02f, -4.87336405e-02f, 3.23473178e-02f,
  -5.79023585e-02f, -7.32927769e-02f, -7.50798434e-02f, -2.87833847e-02f, -6.30049556e-02f, -4.45779366e-03f, 4.52430099e-02f, 7.59638613e-03f, 3.56115252e-02f, -6.32322282e-02f,
  -5.58196530e-02f, 4.76152077e-02f, 4.78119999e-02f, -7.97172636e-03f, 2.50362381e-02f, 8.30432847e-02f, -8.05736482e-02f, 1.25947585e-02f, 1.77479256e-02f, 6.87400177e-02f,
  2.03989089e-01f, -2.46303957e-02f, -8.33895057e-02f, 1.27594382e-01f, 1.02686286e-01f, -1.80028960e-01f, -1.23268403e-02f, 2.74507925e-02f, 1.06058670e-02f, 5.87496683e-02f,
  -3.56234089e-02f, -1.02852628e-01f, 7.87046105e-02f, 6.07511364e-02f, 1.17807366e-01f, 5.45030599e-03f, 2.23993421e-01f, -1.77706070e-02f, -2.81522702e-02f, -3.66631113e-02f,
  -1.39410600e-01f, 1.28142759e-01f, 1.06911715e-02f, 2.69486289e-02f, 2.48375852e-02f, -5.39329574e-02f, 1.98955983e-02f, 9.35105607e-02f, 1.32199135e-02f, -1.08124614e-01f,
  -6.27324432e-02f, -1.26695484e-01f, 3.57746519e-02f, 4.86890711e-02f, -9.34358314e-02f, -7.73508251e-02f, -1.15212621e-02f, -2.35388149e-02f, -2.74934452e-02f, 8.07848349e-02f,
  -2.11113930e-01f, 1.39686346e-01f, -1.14917777e-01f, -4.34900671e-02f, 6.03753002e-03f, 1.63109690e-01f, 1.07947998e-01f, 2.19997197e-01f, 3.09691168e-02f, 2.16984659e-01f,
  1.85839579e-01f, -1.32232487e-01f, 2.42982224e-01f, 2.42344737e-01f, 8.85681883e-02f, 2.45088920e-01f, -2.19777822e-02f, 2.26097293e-02f, 4.65028100e-02f, 1.87912416e-02f,
  4.22997475e-02f, 2.79796720e-01f, 1.04017749e-01f, 1.32227391e-01f, -1.04508281e-01f, -1.76214516e-01f, -3.81391980e-02f, 4.44095396e-03f, -3.19747962e-02f, 7.19272047e-02f,
  2.50976365e-02f, 3.96490023e-02f, -2.14178599e-02f, 4.16115895e-02f, 8.98428783e-02f, -9.14783031e-02f, -8.87938589e-02f, 2.87547354e-02f, -1.39131919e-01f, 1.79016590e-02f,
  1.50324972e-02f, 2.68658018e-03f, 1.31419957e-01f, 9.78647768e-02f, -2.46379320e-02f, -6.15004897e-02f, 3.99679877e-02f, -3.52287255e-02f, 7.34009892e-02f, 3.12764421e-02f,
  -3.98738645e-02f, 1.50477495e-02f, -1.28369600e-01f, -1.22383041e-02f, 3.44833992e-02f, -2.98707262e-02f, -8.50195289e-02f, -1.85047865e-01f, -4.89702746e-02f, -3.99718732e-02f,
  4.29601222e-03f, -5.97440638e-02f, -3.93303968e-02f, -9.97000560e-02f, -6.44036978e-02f, 7.24787265e-03f, 1.02093935e-01f, 7.18757436e-02f, 7.15031549e-02f, -3.81554104e-02f,
  -1.91398356e-02f, -1.91731695e-02f, 5.92298992e-02f, -9.09990892e-02f, -1.18857650e-02f, 1.00149959e-01f, 2.67975368e-02f, 4.93485704e-02f, -3.29166331e-04f, -1.40017346e-01f,
  -6.14102045e-03f, -3.27168629e-02f, 7.63895810e-02f, 9.57397744e-03f, 9.67609417e-03f, -1.60415675e-02f, -3.47835943e-02f, 3.27511430e-02f, 1.12724505e-01f, 3.14827487e-02f,
  7.31100813e-02f, 2.24480312e-02f, 1.81186199e-02f, 4.38591689e-02f, 2.55065244e-02f, 3.82042713e-02f, 1.01602562e-01f, -4.46656300e-03f, 3.95113416e-02f, 9.47188437e-02f,
  -1.41888529e-01f, 1.69037692e-02f, -3.80510651e-02f, -6.10066541e-02f, -2.75199581e-02f, 1.07646249e-01f, -2.16542613e-02f, -2.43191477e-02f, -4.78525413e-03f, -3.22807543e-02f,
  -5.01564033e-02f, 6.92831650e-02f, -2.25378014e-03f, 2.83075534e-02f, 2.46694032e-02f, -1.26276374e-01f, -3.71644162e-02f, -3.09652258e-02f, -9.01693776e-02f, -4.60618474e-02f,
  -3.61191630e-01f, -2.47293606e-01f, 3.92525531e-02f, -1.68397903e-01f, 3.13560516e-02f, 1.33901462e-01f, 4.67277989e-02f, -1.46387354e-01f, -3.02850544e-01f, -1.53588757e-01f,
  -1.51323736e-01f, -8.31765980e-02f, 5.17979488e-02f, -2.06056722e-02f, 2.86130786e-01f, 2.33542934e-01f, 3.72208506e-02f, -1.36593536e-01f, 9.97359827e-02f, -7.29708448e-02f,
  5.98936565e-02f, -8.44079349e-03f, 2.71274894e-01f, 4.55835685e-02f, 1.88134471e-03f, -1.09642774e-01f, 6.93866014e-02f, 1.17705822e-01f, 1.48044443e-02f, 1.03778742e-01f,
  -1.20364413e-01f, -2.13007882e-01f, 5.29173464e-02f, 5.30039854e-02f, 2.83221919e-02f, 8.31082240e-02f, 2.04143375e-01f, 9.12935734e-02f, 2.22526640e-02f, -1.89847220e-03f,
  -2.75818016e-02f, -1.61011130e-01f, -6.76166788e-02f, -4.95487638e-03f, -7.58202299e-02f, 8.25662445e-03f, 5.01405336e-02f, 4.63992357e-02f, -4.13046703e-02f, 8.53400901e-02f,
  3.07284333e-02f, 1.93353817e-02f, 1.67807341e-02f, 5.45598567e-02f, 5.79024963e-02f, -9.92155522e-02f, 1.01413436e-01f, 1.07615046e-01f, -2.06646286e-02f, 2.88111344e-02f,
  6.62187189e-02f, 5.23998402e-02f, 6.45970702e-02f, -6.87260702e-02f, -1.99529305e-02f, -2.71135271e-02f, -3.35716605e-02f, 6.92851990e-02f, 1.96023230e-02f, -4.55936678e-02f,
  -3.14619094e-02f, -1.18123733e-01f, 4.47025448e-02f, 1.14488397e-02f, -6.78097131e-03f, 4.85109957e-03f, -8.24919622e-03f, -2.49344893e-02f, -2.45154910e-02f, 4.26380411e-02f,
  3.36125717e-02f, -2.38666721e-02f, -2.75484528e-02f, 3.13682333e-02f, -4.59884442e-02f, -8.15105438e-02f, -7.42467418e-02f, -1.69909094e-02f, -8.78119469e-03f, 1.45325392e-01f,
  -2.10631907e-01f, -4.45593856e-02f, 2.74903979e-02f, -7.89921954e-02f, -1.76635815e-03f, 1.03011869e-01f, 1.61693081e-01f, -7.36670988e-03f, 4.49691713e-02f, 6.90956712e-02f,
  5.09558283e-02f, -1.63016953e-02f, -5.48182838e-02f, -1.16586514e-01f, 1.90181397e-02f, -7.02177286e-02f, 2.88690701e-02f, -6.68189721e-03f, 5.47822155e-02f, -8.50917585e-03f,
  -1.73781672e-03f, -1.19602330e-01f, 2.13260069e-01f, 5.06934598e-02f, 1.10797442e-01f, -8.88096839e-02f, 2.86665969e-02f, -4.52373698e-02f, 5.63126914e-02f, 5.88110648e-03f,
  -1.50455507e-02f, -2.19941333e-01f, 8.32714066e-02f, 2.04944294e-02f, 3.66503224e-02f, 2.18107417e-01f, 3.12913842e-02f, 1.83801427e-02f, -1.21302903e-02f, -2.48537645e-01f,
  6.90592378e-02f, -1.19691841e-01f, 1.89097092e-01f, -5.63008375e-02f, 3.09569508e-01f, 2.90622711e-01f, -1.10824950e-01f, 9.41830222e-03f, 2.28785761e-02f, -2.49905661e-01f,
  -3.85582745e-02f, -5.86301535e-02f, 1.47089943e-01f, -1.47541657e-01f, -1.33166820e-01f, -1.30687043e-01f, -6.87287226e-02f, 1.17711298e-01f, -1.48793638e-01f, 1.43526167e-01f,
  -3.78340967e-02f, 9.70131066e-03f, 5.47623187e-02f, 6.19306602e-02f, -8.63722898e-03f, -9.46949199e-02f, -1.30013004e-02f, 1.79459840e-01f, 2.70468630e-02f, -1.91609003e-02f,
  -5.08029237e-02f, -2.66853254e-02f, 7.26318434e-02f, 1.23169273e-01f, -3.68294530e-02f, -2.76975613e-02f, 9.91717950e-02f, 4.63486090e-02f, -6.22712299e-02f, 8.80842879e-02f,
  2.63622291e-02f, 4.65251133e-02f, -1.83172673e-01f, -4.64643501e-02f, 4.85185208e-03f, -6.13042293e-03f, -9.06459615e-02f, -3.45960036e-02f, -5.58930635e-02f, -3.89407985e-02f,
  -1.15711518e-01f, -1.52146325e-01f, -4.94803349e-03f, -7.21716061e-02f, 3.87103334e-02f, 7.20896348e-02f, 9.31541872e-05f, -1.77017506e-02f, 4.98290583e-02f, -3.60568687e-02f,
  8.58012307e-03f, 3.72718349e-02f, 2.98725758e-02f, 9.25721787e-03f, -3.56889926e-02f, -6.56795204e-02f, -4.55284026e-03f, 7.01187551e-02f, 5.73329218e-02f, 8.27235058e-02f,
  2.48313937e-02f, -3.55867110e-02f, 5.44372275e-02f, 3.44040170e-02f, 2.68841423e-02f, -5.72858341e-02f, -3.38812917e-03f, 1.71242021e-02f, -8.43356270e-03f, 4.36069667e-02f,
  -4.31985632e-02f, -2.25708216e-01f, -4.58362438e-02f, -6.45682868e-03f, 3.49450074e-02f, -1.80275738e-02f, -8.49156827e-02f, 3.33718732e-02f, -5.24749234e-03f, -1.88405123e-02f,
  -1.93348616e-01f, -8.86349380e-02f, -7.54724964e-02f, -7.80619727e-03f, -3.25670913e-02f, -2.25634873e-02f, 4.66100080e-03f, -3.35459132e-04f, -9.02641714e-02f, -3.60547341e-02f,
  -1.15469061e-02f, -6.83374554e-02f, -7.10266232e-02f, -2.90410500e-02f, -5.13770878e-02f, 2.38923877e-02f, -1.09736718e-01f, -3.31815332e-02f, 4.28536683e-02f, 2.97480524e-02f,
  2.72756070e-01f, -1.40734702e-01f, -3.09014976e-01f, 2.00461283e-01f, 3.21945548e-02f, 8.71668831e-02f, 1.81799918e-01f, 4.16097417e-02f, 1.99707240e-01f, 1.75842226e-01f,
  9.16964263e-02f, -1.21557564e-01f, -2.26454213e-01f, 1.34992689e-01f, -6.31358251e-02f, -1.72320679e-01f, 2.04158619e-01f, 8.82320479e-02f, 2.05138996e-02f, 2.99232211e-02f,
  -1.66195594e-02f, 1.47498131e-01f, -2.60976434e-01f, 9.17480737e-02f, -2.20045745e-02f, -6.77270768e-03f, 1.08918780e-02f, -1.67464763e-01f, 1.77249774e-01f, -2.66075693e-02f,
  1.90452151e-02f, 1.35584489e-01f, -1.35175018e-02f, -1.07990891e-01f, 7.55905509e-02f, 4.71380912e-02f, -4.08027843e-02f, -5.15442677e-02f, -6.88630417e-02f, 1.34777725e-01f,
  -1.87160391e-02f, 8.60908628e-02f, 3.49722579e-02f, -3.87211293e-02f, -3.89157943e-02f, 9.68720485e-03f, -5.28306477e-02f, -3.46419923e-02f, 3.77761051e-02f, -7.30278790e-02f,
  -3.72889116e-02f, -4.65880446e-02f, -3.06099243e-02f, 8.27097818e-02f, -2.60822102e-02f, 7.93356225e-02f, 7.84891751e-03f, 5.90059673e-03f, 1.05070129e-01f, 7.78188035e-02f,
  1.13475733e-01f, -4.59379144e-02f, -1.02414437e-01f, 1.45816579e-02f, 7.45537877e-02f, -6.00746414e-03f, -2.97548994e-02f, -6.21798262e-03f, -2.74053197e-02f, 4.14913110e-02f,
  5.15137166e-02f, -7.90038705e-03f, -2.88102776e-02f, 2.74452996e-02f, 3.57998423e-02f, 9.65829473e-03f, -1.00747123e-01f, 3.07855681e-02f, -2.68882364e-02f, -7.38630742e-02f,
  9.88407433e-03f, -7.03548342e-02f, 1.88545622e-02f, 8.66083521e-03f, -2.37901490e-02f, -2.81850398e-02f, -1.27719631e-02f, -5.39679565e-02f, 2.10874435e-02f, -2.31774691e-02f,
  4.75363173e-02f, 1.44209653e-01f, -7.69589748e-03f, 8.78778696e-02f, -2.04892252e-02f, 1.95143260e-02f, -2.37965118e-02f, -3.13422233e-02f, 3.93696614e-02f, 5.95483407e-02f,
  -3.10030431e-02f, -6.10927120e-02f, 8.58056769e-02f, 9.53135937e-02f, 2.81141065e-02f, -4.83246520e-02f, -2.51926910e-02f, 6.10468024e-03f, 3.19484435e-02f, 5.17127402e-02f,
  7.28135034e-02f, 8.89134333e-02f, -2.75996160e-02f, 5.25503792e-02f, 7.89516494e-02f, 1.71766020e-02f, -4.64039035e-02f, 1.42964022e-02f, -3.49059552e-02f, -9.20368917e-03f,
  -5.67167044e-01f, 1.09346271e-01f, 2.98591107e-02f, -1.95893779e-01f, 3.80224884e-02f, 1.62510574e-01f, 6.61993213e-03f, 8.39152858e-02f, -4.74997498e-02f, 1.06809288e-01f,
  1.54912649e-02f, -1.18512139e-01f, 1.47476301e-01f, -5.61718792e-02f, -1.92093790e-01f, 1.14612736e-01f, -1.38929382e-01f, -8.14280510e-02f, -7.01236129e-02f, -2.11381346e-01f,
  -5.91927692e-02f, -2.06341460e-01f, -7.23952502e-02f, -4.64767925e-02f, -1.68574080e-01f, -1.08299553e-01f, -1.87278003e-01f, -1.97689757e-02f, -1.24020360e-01f, 6.50182664e-02f,
  -8.67607817e-02f, -2.13661082e-02f, -3.14478786e-03f, 2.81544179e-02f, -2.36781463e-02f, 3.88441682e-02f, -2.43590940e-02f, 2.25289837e-02f, -7.12651163e-02f, -6.35759607e-02f,
  -2.96511557e-02f, -8.86450335e-02f, 1.77647341e-02f, 7.48817325e-02f, 3.79396603e-02f, 2.61726491e-02f, 1.58878386e-01f, 2.30026115e-02f, 6.71593845e-02f, 2.63398904e-02f,
  7.86381662e-02f, -2.92119402e-02f, -9.54829827e-02f, -1.63674336e-02f, 5.36063202e-02f, 7.29519874e-02f, -1.18504399e-02f, -1.54053345e-02f, 1.22705800e-02f, -9.52738710e-03f,
  -1.03018545e-01f, -4.35619466e-02f, 6.15849234e-02f, -3.00580207e-02f, 1.16093839e-02f, 1.45449964e-02f, 1.67332273e-02f, 5.13621084e-02f, -6.57416210e-02f, -1.33505203e-02f,
  -5.83879203e-02f, -5.89771383e-02f, 4.31600921e-02f, 5.91307096e-02f, -1.02133356e-01f, 1.45330012e-03f, -3.72995809e-02f, 4.14724015e-02f, -1.50299752e-02f, -4.38149367e-03f,
  3.33924033e-02f, 3.84661183e-02f, 4.17322442e-02f, -1.69765726e-02f, 4.03022654e-02f, 1.49175674e-02f, -3.33972238e-02f, 6.17123954e-02f, 1.64104551e-02f, -5.90164550e-02f,
  -1.82536855e-01f, -1.31182715e-01f, 1.27471518e-02f, 1.33964315e-03f, 6.72883615e-02f, 4.15374152e-03f, -4.59960848e-02f, 6.45564049e-02f, -6.85358420e-02f, 2.26490200e-03f,
  -2.04271898e-02f, -7.15622231e-02f, -1.14433065e-01f, 3.29636186e-02f, 2.79919375e-02f, 2.25240202e-03f, 2.06033755e-02f, -2.66449414e-02f, -7.15184957e-02f, -7.35354051e-02f,
  -2.56338418e-02f, -2.04779238e-01f, 8.52653664e-03f, -1.77899115e-02f, -1.22193880e-02f, -2.71347277e-02f, -8.08578953e-02f, 3.57322842e-02f, -2.38773823e-02f, -5.93713485e-02f,
  1.92741737e-01f, -2.77438134e-01f, -2.90915936e-01f, 2.14620605e-02f, 2.63532642e-02f, 2.39264712e-01f, 2.58705199e-01f, -1.73356950e-01f, -9.07200351e-02f, 1.30361125e-01f,
  1.99449033e-01f, -9.95410606e-02f, -3.32710668e-02f, 4.82895039e-02f, 1.61564946e-01f, -4.29159291e-02f, 1.28843859e-01f, 9.52741131e-02f, -1.47122338e-01f, 2.53336295e-03f,
  -6.29742816e-02f, 2.21688822e-01f, -1.66586071e-01f, -8.99534971e-02f, 2.73019690e-02f, -5.39230146e-02f, 1.62304029e-01f, -4.92068902e-02f, -2.85258386e-02f, 4.15969566e-02f,
  6.69553056e-02f, -1.31139696e-01f, -1.34282246e-01f, -8.37117732e-02f, -5.20109292e-03f, 5.27119748e-02f, 1.14855473e-03f, 1.03988640e-01f, -1.86424982e-02f, -8.99965875e-03f,
  1.82327442e-02f, 1.13191970e-01f, 4.90102172e-02f, -6.03045784e-02f, 5.72079606e-02f, -7.74964094e-02f, -1.58070281e-01f, -1.13727279e-01f, -6.76688999e-02f, 1.75347403e-02f,
  -5.03434800e-02f, -1.18112080e-02f, 7.99571946e-02f, 7.14367256e-02f, -1.42539926e-02f, -2.18259897e-02f, 9.81407706e-03f, 9.53405201e-02f, 9.59650427e-02f, 1.41019411e-02f,
  1.42271817e-01f, 6.50587454e-02f, -5.16953953e-02f, 3.50145943e-04f, -9.68577042e-02f, -3.40151265e-02f, 1.09742165e-01f, 9.39716622e-02f, -4.01099101e-02f, 3.27412337e-02f,
  -3.13141234e-02f, -8.12948868e-02f, -1.21061197e-02f, 1.68771716e-03f, 6.95943367e-03f, -5.65453395e-02f, 6.85356259e-02f, -6.65824562e-02f, -5.63195311e-02f, -1.38173150e-02f,
  8.17976221e-02f, -2.86109949e-04f, -2.29144599e-02f, 5.14644757e-02f, 6.65245652e-02f, 6.84129831e-04f, 2.45717559e-02f, -7.10109249e-02f, -6.89848065e-02f, 9.66681018e-02f,
  1.44664198e-01f, -9.35632084e-03f, -4.86294776e-02f, 3.98082174e-02f, -6.98620453e-02f, 4.98883007e-03f, -3.88170369e-02f, 9.86539759e-04f, 8.96079931e-03f, -1.95932314e-02f,
  6.64519072e-02f, 2.20105648e-02f, 2.34041773e-02f, 4.21975143e-02f, -2.25466527e-02f, -5.02866842e-02f, 2.48390026e-02f, 2.17615422e-02f, 2.93214265e-02f, 1.32439183e-02f,
  8.53105336e-02f, 1.39827756e-02f, 5.22710644e-02f, -4.75345813e-02f, 7.73338825e-02f, 1.13103256e-01f, 1.13213286e-02f, 6.57541351e-03f, 7.04006329e-02f, 2.05570851e-02f,
  -3.92961770e-01f, -3.41212936e-02f, -1.72278032e-01f, -3.37516904e-01f, 1.12835474e-01f, 1.48995623e-01f, 4.48072068e-02f, -5.83803207e-02f, 7.75047345e-04f, 5.44588082e-02f,
  5.76338209e-02f, -2.90769428e-01f, 2.66162544e-01f, -2.55402029e-01f, -5.44481315e-02f, 1.54087856e-01f, -1.54862612e-01f, -1.37416765e-01f, 1.96645595e-02f, -9.11605582e-02f,
  -8.01826864e-02f, -9.10550356e-03f, -9.58460346e-02f, 3.12877260e-02f, -2.19717637e-01f, -1.30664736e-01f, -3.98773253e-02f, 4.33743708e-02f, -2.09997922e-01f, -6.24853605e-03f,
  4.56049629e-02f, -7.70852342e-02f, -1.76809337e-02f, -4.37662862e-02f, 1.56313665e-02f, 5.42163216e-02f, -2.89320238e-02f, -2.25050990e-02f, -2.64858641e-02f, -5.63333258e-02f,
  2.55073663e-02f, -7.71094561e-02f, 5.44542447e-02f, 1.02893494e-01f, -7.08689913e-02f, -9.34722498e-02f, 1.62086375e-02f, -2.84085497e-02f, -1.75723955e-02f, 1.55232288e-02f,
  1.11651737e-02f, -1.98806282e-02f, -5.84131964e-02f, -4.80610318e-02f, 3.72271538e-02f, -1.00270230e-02f, -2.31249575e-02f, -1.44730238e-02f, -5.56619950e-02f, -3.11197173e-02f,
  3.14211920e-02f, -1.31289167e-02f, -6.74744621e-02f, -2.73472238e-02f, 6.12701252e-02f, -1.02435416e-02f, 2.25246861e-03f, 2.44017635e-02f, -6.78152442e-02f, -5.21003939e-02f,
  2.62279473e-02f, -1.01224989e-01f, -1.74225662e-02f, -1.23743545e-02f, -5.19714020e-02f, 5.27248643e-02f, -1.26327937e-02f, -2.75088544e-03f, 1.13025894e-02f, 1.05184754e-02f,
  1.23422416e-02f, 1.63447484e-02f, 1.69130228e-02f, 2.52156984e-02f, 9.70605686e-02f, -6.90019056e-02f, -5.29819094e-02f, 3.72863468e-03f, 1.74183603e-02f, 1.03821710e-01f,
  6.73400471e-03f, -1.61371678e-01f, 9.59136412e-02f, -1.44039273e-01f, 1.73493370e-03f, 4.17737700e-02f, 1.45963924e-02f, 9.71479248e-03f, -4.69986722e-02f, -4.48888615e-02f,
  -6.02130443e-02f, -4.52368371e-02f, -5.05926125e-02f, 2.37401314e-02f, 1.19060390e-02f, 1.67825036e-02f, 4.84440401e-02f, 6.41684560e-03f, -1.20712696e-02f, -2.15898566e-02f,
  -5.00140972e-02f, -3.35329995e-02f, 6.36252537e-02f, 9.57105532e-02f, -3.54726389e-02f, -4.47775722e-02f, 5.27519956e-02f, -2.61747930e-02f, -1.54367611e-02f, -9.32228565e-02f,
  2.35933885e-01f, -2.85513848e-01f, -2.61297345e-01f, 2.40583554e-01f, 1.03473984e-01f, 1.50165081e-01f, 5.99579550e-02f, -1.28904089e-01f, 8.03485792e-03f, -7.25031570e-02f,
  3.21752541e-02f, -1.69858173e-01f, -2.01487467e-01f, 1.88091353e-01f, 1.67491078e-01f, -3.07259150e-02f, 3.26906711e-01f, 9.11239833e-02f, 1.03507690e-01f, -4.71706837e-02f,
  6.44297004e-02f, 1.71052068e-01f, -1.50580332e-01f, -6.40239492e-02f, 2.53071319e-02f, -1.02340922e-01f, -4.02659411e-03f, -1.78647086e-01f, 1.32361025e-01f, 1.68146305e-02f,
  1.42612737e-02f, -9.66748297e-02f, -1.24144875e-01f, -4.15624753e-02f, -2.87517514e-02f, 2.40104049e-02f, -8.55238438e-02f, 1.45234680e-02f, -4.73748930e-02f, 3.12089156e-02f,
  -7.27544278e-02f, -4.70564142e-03f, 3.58676761e-02f, -3.13881226e-02f, 3.38087715e-02f, -1.25311511e-02f, -3.61773148e-02f, -2.33784085e-03f, -6.41185464e-03f, 6.38438296e-03f,
  -9.25922245e-02f, 2.66553182e-03f, 9.88936052e-02f, 2.43997723e-02f, -3.98128405e-02f, -1.90464146e-02f, 1.40445689e-02f, -6.67034611e-02f, 2.32381076e-02f, -6.98835775e-02f,
  1.28157670e-02f, -2.69921925e-02f, -9.20336992e-02f, 4.62538451e-02f, 3.56328003e-02f, 7.15568438e-02f, 5.62388003e-02f, 4.84853238e-02f, 3.11321374e-02f, 1.66827068e-01f,
  5.85785098e-02f, -4.51202877e-02f, 7.77543634e-02f, 9.08994302e-03f, 1.22420698e-01f, 2.58431975e-02f, -3.09500191e-02f, 4.19355929e-02f, -8.57656822e-03f, 7.64268190e-02f,
  -3.42903845e-02f, 1.89742129e-02f, -9.40564834e-03f, 3.10602542e-02f, -3.00130397e-02f, -4.51506376e-02f, -7.21351057e-02f, 2.33661756e-02f, -3.78610045e-02f, 1.05019612e-02f,
  -1.67247038e-02f, -1.70388445e-01f, -8.71057883e-02f, 1.03158327e-02f, -1.02493063e-01f, 4.53762598e-02f, 8.31109956e-02f, -7.12038903e-03f, 4.57021222e-03f, 1.57500338e-02f,
  6.02327436e-02f, -4.79712747e-02f, -1.45582221e-02f, 1.01455025e-01f, -3.42394821e-02f, -5.03336489e-02f, -1.33146927e-01f, 9.74781513e-02f, -2.96853501e-02f, 2.31980477e-02f,
  -4.18475866e-02f, 5.71579188e-02f, 4.00629966e-03f, -1.05725080e-02f, 1.36098489e-01f, 3.76547761e-02f, -4.02036570e-02f, -1.70823336e-02f, 3.70651786e-03f, -1.95917506e-02f,
  -4.36540455e-01f, -4.75732237e-02f, -4.18215841e-02f, -2.91491151e-01f, -7.86034688e-02f, -1.32952064e-01f, -6.67097718e-02f, -1.35512412e-01f, -1.27716139e-01f, 1.26116782e-01f,
  -9.05182883e-02f, -9.39173326e-02f, 1.14214994e-01f, -2.43563563e-01f, -2.96886593e-01f, -2.93483734e-02f, -2.62048215e-01f, -8.67806524e-02f, -7.25260302e-02f, -9.20536146e-02f,
  -1.80614293e-01f, -2.28943333e-01f, -8.54049623e-02f, -5.89742847e-02f, -1.47389829e-01f, 7.50808325e-03f, 1.43547863e-01f, 8.21952522e-02f, -3.38095278e-02f, -4.91487645e-02f,
  -2.37670131e-02f, 2.59370487e-02f, -4.91771325e-02f, 7.87378699e-02f, -1.35583458e-02f, 1.42164946e-01f, 9.93411243e-02f, -2.28912625e-02f, 4.42186706e-02f, -2.77737007e-02f,
  5.95054924e-02f, -1.94206033e-02f, -1.94346737e-02f, -3.86733674e-02f, -9.02040005e-02f, -5.14351912e-02f, -3.11963204e-02f, -1.08733356e-01f, -4.69672866e-02f, 3.92316245e-02f,
  2.38365494e-02f, 3.48346606e-02f, -6.18262105e-02f, -5.59830293e-02f, 1.94618106e-02f, -2.59524514e-03f, 6.51933923e-02f, 1.96083840e-02f, -3.26161310e-02f, -4.87845056e-02f,
  8.11274275e-02f, 6.77087456e-02f, 7.77948201e-02f, -1.51783032e-02f, -1.48501126e-02f, 1.85392648e-02f, 2.27978569e-03f, -7.09164962e-02f, -1.02541469e-01f, 1.27498824e-02f,
  5.83440848e-02f, -1.30036980e-01f, -2.75022350e-02f, -1.10751847e-02f, -1.18520996e-02f, -9.72576737e-02f, -6.02036342e-02f, 6.68067709e-02f, -5.61736897e-03f, -3.15702036e-02f,
  9.49611664e-02f, 6.15902767e-02f, 4.22928892e-02f, 2.69850213e-02f, 2.39299722e-02f, 8.12300295e-02f, 3.06847300e-02f, -1.52313951e-02f, 4.72434163e-02f, 7.19479769e-02f,
  3.59362848e-02f, 6.54070526e-02f, 3.83415110e-02f, -1.15045789e-03f, 2.94814557e-02f, -4.83095124e-02f, -1.16924234e-01f, -8.76906514e-02f, -5.64739257e-02f, -5.19657098e-02f,
  9.79660228e-02f, 7.24067986e-02f, 1.54016793e-01f, -1.36580244e-01f, 6.14156667e-03f, 3.03039309e-02f, 5.11963777e-02f, 2.50814836e-02f, 3.31346765e-02f, -9.28565860e-03f,
  7.77101815e-02f, 1.20203920e-01f, -2.44762078e-02f, 2.07236856e-02f, 4.88842651e-02f, 9.19474810e-02f, 3.20882001e-03f, -1.03993816e-02f, -3.05746011e-02f, 4.16353205e-03f,
  6.46314994e-02f, -1.24863200e-01f, 1.35446057e-01f, -1.36165366e-01f, -4.69273664e-02f, 1.05869658e-01f, 1.87874079e-01f, -1.46706209e-01f, -1.38222247e-01f, 6.46140650e-02f,
  8.30339119e-02f, 1.51546687e-01f, 1.53122559e-01f, -5.54219112e-02f, 1.58785567e-01f, -5.92080876e-02f, 1.07050754e-01f, 1.53740048e-01f, -2.64515072e-01f, 2.40660217e-02f,
  -1.55149341e-01f, -1.98118553e-01f, 1.01955995e-01f, -1.72958925e-01f, 1.42699152e-01f, -7.25787207e-02f, 6.96982145e-02f, -6.91260323e-02f, 4.03144285e-02f, -3.49182403e-03f,
  -9.18790512e-03f, -1.39547884e-01f, -7.72855617e-03f, -5.68008944e-02f, 9.20988992e-02f, 4.88851219e-02f, 7.44988248e-02f, 1.78773496e-02f, -5.69542358e-03f, 1.22221904e-02f,
  1.03765570e-01f, 2.23913118e-02f, -8.67416486e-02f, -3.18898931e-02f, -1.00902263e-02f, -3.62784937e-02f, -1.27277479e-01f, -2.24050246e-02f, 2.06541196e-02f, 1.13417059e-02f,
  6.47751391e-02f, 1.42250568e-01f, 7.90059790e-02f, -3.64097059e-02f, 6.60197297e-03f, -3.59674990e-02f, 5.12963012e-02f, 4.04100381e-02f, 7.43337497e-02f, 1.24093909e-02f,
  -3.56494524e-02f, -1.04343547e-02f, 3.26383929e-03f, 3.29296403e-02f, -2.25783102e-02f, 7.71334842e-02f, 2.48422157e-02f, 1.92697346e-02f, 2.40430771e-03f, 4.03697826e-02f,
  -3.20584816e-03f, 2.55462509e-02f, -6.74765110e-02f, 3.95116918e-02f, 2.78064255e-02f, -3.10876016e-02f, 2.48717777e-02f, 4.58677672e-02f, -1.33194149e-01f, 2.26531327e-02f,
  7.34474137e-03f, 3.67352515e-02f, -3.55043150e-02f, -1.39742056e-02f, 7.84590691e-02f, 7.65298456e-02f, -2.82177664e-02f, -1.69262409e-01f, -3.07402927e-02f, 1.27690479e-01f,
  5.27561754e-02f, -5.20023964e-02f, -5.74167147e-02f, -5.38920015e-02f, 3.65303680e-02f, 2.47729961e-02f, -2.44447533e-02f, 4.99184057e-03f, 3.31391022e-02f, -1.59021839e-02f,
  5.68607002e-02f, -7.31800031e-03f, 8.52761939e-02f, -4.02770936e-02f, -5.52134253e-02f, -7.04234019e-02f, 2.98145805e-02f, -1.19416885e-01f, 1.44108206e-01f, -5.64367138e-02f,
  8.95605311e-02f, 6.39364198e-02f, -8.76072049e-03f, -5.56495450e-02f, 3.94641459e-02f, 7.73491934e-02f, 7.98399933e-03f, 1.11645050e-02f, -1.14433089e-04f, 3.16841118e-02f,
  -2.08838210e-01f, -1.25322163e-01f, -2.33794332e-01f, 5.02559356e-02f, 1.75906524e-01f, -4.36971709e-02f, -1.41149759e-01f, 1.00260302e-01f, 3.88917290e-02f, 1.57049999e-01f,
  1.39678836e-01f, -2.34853938e-01f, -2.02066213e-01f, 1.81077257e-01f, -1.63306832e-01f, -2.16352150e-01f, 1.22475892e-01f, 6.42991066e-02f, 1.01925045e-01f, 5.73328286e-02f,
  -4.94895242e-02f, 2.43516684e-01f, -2.37695858e-01f, 2.65571922e-01f, 1.39514711e-02f, 7.98133165e-02f, 7.82582387e-02f, -4.45902087e-02f, 2.58970112e-01f, -7.22118616e-02f,
  -2.60119177e-02f, -3.63805033e-02f, -1.32151470e-01f, -6.75302446e-02f, -1.66147761e-02f, -1.22675393e-02f, -1.53035805e-01f, -5.88102676e-02f, -9.12346467e-02f, 2.51416676e-02f,
  -1.42888322e-01f, -5.51677402e-03f, 7.79768303e-02f, -4.89712059e-02f, 3.02445181e-02f, -1.01493523e-01f, -4.51934971e-02f, -6.56336248e-02f, 6.17921725e-02f, -8.30183104e-02f,
  3.67200561e-02f, -1.86511851e-03f, 4.72701387e-03f, -4.11646347e-03f, 1.42504632e-01f, 5.09820171e-02f, -4.76008467e-03f, -7.26543665e-02f, 6.74370006e-02f, 3.07434034e-02f,
  -1.27932448e-02f, -2.96071987e-03f, 9.28642787e-03f, 1.05179690e-01f, 4.28905115e-02f, 1.20865740e-01f, 8.22711736e-02f, 4.79400419e-02f, -1.08219229e-01f, 1.11278586e-01f,
  5.41793853e-02f, -5.28663844e-02f, 4.07883488e-02f, 8.15424472e-02f, -2.67469548e-02f, -2.10278034e-02f, -5.09188809e-02f, 9.10045654e-02f, 8.62046108e-02f, -5.34810610e-02f,
  -7.83490092e-02f, -2.16428414e-02f, 6.20991690e-03f, -3.67444120e-02f, -8.47695395e-02f, 4.29404564e-02f, 1.08174585e-01f, 1.89585779e-02f, -1.75061449e-02f, -7.45120794e-02f,
  -5.48291169e-02f, 1.33012729e-02f, 4.00017835e-02f, 4.99107502e-02f, -5.04656732e-02f, -5.37067838e-03f, -1.43772647e-01f, 9.17379484e-02f, -7.84225091e-02f, -5.04795015e-02f,
  3.48568186e-02f, -4.38696099e-03f, 6.30416572e-02f, 1.23694286e-01f, -1.03358915e-02f, 6.38367534e-02f, -3.86343785e-02f, 1.60359982e-02f, -4.35002409e-02f, 3.82736363e-02f,
  5.46318199e-03f, 6.43163472e-02f, -9.85722989e-02f, 3.88346538e-02f, 1.41431704e-01f, 1.47696868e-01f, 7.10206525e-03f, -7.65884444e-02f, -2.14582328e-02f, 1.44864917e-02f,
  -1.63059682e-01f, 2.43778527e-02f, 1.71272345e-02f, -1.61843479e-01f, -2.12868601e-01f, 3.31145823e-02f, 4.16943841e-02f, -1.26548812e-01f, -2.08670184e-01f, 5.62008210e-02f,
  4.81517203e-02f, 4.12526466e-02f, 2.05046549e-01f, 4.42595147e-02f, 3.05373102e-01f, 2.78348535e-01f, 1.09247074e-01f, 6.47671744e-02f, -7.25626945e-02f, -1.58283785e-02f,
  -9.75770503e-03f, -3.27817090e-02f, 1.90980971e-01f, -1.47146881e-01f, -8.49424675e-02f, -1.90780580e-01f, -3.40029337e-02f, -1.37006655e-01f, -1.03596941e-01f, -8.37411880e-02f,
  2.49576587e-02f, -1.40264720e-01f, 1.01192575e-02f, -8.37129205e-02f, 5.02067991e-02f, 9.34560373e-02f, 1.43071907e-02f, -2.58855242e-02f, 3.10651809e-02f, 3.23283710e-02f,
  6.71648011e-02f, 2.96381731e-02f, -5.75503074e-02f, 3.25435810e-02f, 3.54987830e-02f, -8.64560083e-02f, -5.36583103e-02f, 2.97848973e-02f, -1.68950530e-03f, -8.72228816e-02f,
  4.90261018e-02f, -4.36389893e-02f, -7.11757690e-03f, 2.02827696e-02f, 4.34380472e-02f, -1.41788855e-01f, 1.11169368e-02f, -1.48880696e-02f, 6.10226244e-02f, 1.44106662e-02f,
  3.79910395e-02f, 2.18806360e-02f, 1.14362814e-01f, -1.68195833e-02f, -1.12034328e-01f, -9.40451175e-02f, -1.05250999e-01f, 1.79519746e-02f, -6.13558851e-02f, -3.60273682e-02f,
  2.13238150e-02f, -4.73565944e-02f, -5.07582575e-02f, 4.11783308e-02f, -4.83352551e-03f, -4.07337621e-02f, 6.85571656e-02f, -3.18102092e-02f, -1.00757517e-01f, -5.78598445e-03f,
  2.59273108e-02f, 3.57162394e-02f, 8.85160342e-02f, 1.16802668e-02f, 9.30708125e-02f, -4.53281924e-02f, -4.64253947e-02f, -5.71589619e-02f, 2.45461543e-03f, 8.30246881e-02f,
  1.06684938e-01f, 3.73612018e-03f, -5.42724691e-03f, -4.43836721e-03f, -2.64821928e-02f, 1.24300495e-01f, -2.33395174e-02f, 4.17865552e-02f, 8.61211792e-02f, -1.69761628e-02f,
  -4.08505052e-02f, -5.21819703e-02f, -1.09269973e-02f, -4.35231328e-02f, 4.23799828e-02f, 5.99553324e-02f, 5.51483482e-02f, -1.41818849e-02f, -8.35927762e-03f, -5.48327044e-02f,
  4.66230623e-02f, 1.00924991e-01f, -5.30568361e-02f, -4.00658548e-02f, 5.39063849e-02f, -8.07323009e-02f, -2.26712581e-02f, -9.65650529e-02f, 5.57690449e-02f, 8.46367478e-02f,
  4.04968262e-01f, 1.18416443e-01f, 1.96355343e-01f, 9.93001759e-02f, 1.07690811e-01f, 2.55657703e-01f, -4.68128873e-03f, 2.62092054e-01f, 2.93028444e-01f, -7.56762773e-02f,
  -1.51277762e-02f, 7.40529150e-02f, -8.54412168e-02f, 4.93327305e-02f, 1.23917803e-01f, -4.51070853e-02f, 1.61288589e-01f, 8.01315308e-02f, 3.42425108e-02f, 1.67565078e-01f,
  8.06535557e-02f, -3.03720534e-02f, -4.38385783e-03f, -1.48541974e-02f, 2.33684912e-01f, 5.80280311e-02f, -7.14060217e-02f, -1.18815161e-01f, 6.29869774e-02f, -1.41353933e-02f,
  1.10633224e-01f, 5.49905971e-02f, 7.06249177e-02f, 7.75335431e-02f, 5.26156500e-02f, -2.24381573e-02f, -4.30387557e-02f, 2.10526981e-03f, -5.41090854e-02f, -1.04059349e-03f,
  -7.95823112e-02f, 1.17217980e-01f, -2.22264174e-02f, -6.77260086e-02f, 1.06904544e-01f, 3.77767123e-02f, 9.83920228e-03f, 6.96996450e-02f, 4.54548858e-02f, -2.51244735e-02f,
  -6.02531433e-03f, 6.65749609e-02f, 2.87015643e-02f, 7.10335672e-02f, 3.89391407e-02f, -3.53391059e-02f, 7.98100419e-03f, 4.39973660e-02f, 5.57547286e-02f, 9.09227654e-02f,
  4.92174961e-02f, 8.75869691e-02f, -3.04309223e-02f, 1.18028283e-01f, 1.72357447e-03f, -1.47704652e-03f, 4.50500241e-03f, -5.69366999e-02f, -1.07139973e-02f, 8.94864202e-02f,
  8.54785815e-02f, 1.78606696e-02f, 4.99144904e-02f, -2.61138603e-02f, -8.43930021e-02f, 2.39333380e-02f, -6.54154867e-02f, 6.78253546e-02f, 8.81064031e-03f, -5.84140569e-02f,
  3.26233893e-03f, -7.01174606e-03f, -1.41813187e-03f, -1.74559746e-03f, 5.08642942e-02f, -6.31280020e-02f, 8.52550194e-02f, 1.25943050e-02f, -3.62306982e-02f, -1.09523311e-01f,
  2.10561395e-01f, 7.90278539e-02f, -8.25738311e-02f, 1.18485205e-01f, -3.26386541e-02f, 4.30002548e-02f, -2.02902649e-02f, 3.14416252e-02f, 2.71131378e-02f, 3.74149084e-02f,
  -8.89629126e-03f, 6.03935169e-03f, 1.00808799e-01f, 3.72104459e-02f, 5.83929792e-02f, 4.55220565e-02f, -9.12701264e-02f, 6.38144538e-02f, 6.25114515e-02f, 1.30827688e-02f,
  3.68522829e-03f, 1.30373705e-02f, -1.47107750e-01f, 2.90576834e-02f, -2.28375960e-02f, -5.33355549e-02f, 5.03296182e-02f, 2.60550994e-03f, -5.37747219e-02f, 6.41720071e-02f,
  6.32729650e-01f, -1.70862615e-01f, 1.37371808e-01f, -3.21081616e-02f, -7.62552917e-02f, 7.29394555e-02f, 6.33651018e-02f, 4.14805412e-02f, 3.22312355e-01f, -2.18989730e-01f,
  -1.33517712e-01f, 8.20616493e-04f, -1.27372205e-01f, -1.36041582e-01f, 3.03295076e-01f, 1.86667554e-02f, 1.81520596e-01f, -6.71560764e-02f, 1.08645121e-02f, -8.74512196e-02f,
  5.60749918e-02f, -1.95488036e-01f, -1.43959552e-01f, -1.92220896e-01f, 3.81497256e-02f, 2.45966557e-02f, -6.01763763e-02f, -7.68809170e-02f, -2.00531855e-01f, 1.20635601e-02f,
  4.25605364e-02f, -5.69118448e-02f, -5.12719005e-02f, 9.74823907e-02f, 3.29490788e-02f, -2.92579853e-03f, -6.18843548e-02f, 4.83950675e-02f, 1.78779531e-02f, -5.39964400e-02f,
  -2.93405131e-02f, 9.19804424e-02f, -3.23750116e-02f, 7.50255510e-02f, 3.77123803e-02f, 9.76652801e-02f, -4.13011052e-02f, 3.09103150e-02f, 2.98700929e-02f, 3.64662185e-02f,
  6.66986182e-02f, -4.62995507e-02f, 9.15812254e-02f, 2.56716646e-02f, 3.56320031e-02f, -4.09516040e-03f, -3.29148285e-02f, 4.55333740e-02f, -5.92530034e-02f, 7.62499571e-02f,
  4.61179391e-02f, 1.69246309e-02f, -4.96639870e-02f, -1.34734362e-02f, -3.13594751e-02f, 3.33034783e-03f, -7.83395767e-02f, -8.93426836e-02f, 1.04439601e-01f, -4.22964431e-02f,
  1.00875385e-02f, -1.10146832e-02f, 3.77809373e-03f, -6.64571598e-02f, 7.44749559e-03f, 1.65076461e-02f, -1.04984716e-02f, -4.97469008e-02f, -4.50733351e-03f, -2.99651511e-02f,
  4.49790508e-02f, 1.40888186e-03f, 3.81559059e-02f, -5.22182174e-02f, 3.15426439e-02f, -1.62147768e-02f, 5.34257181e-02f, -4.71367352e-02f, -1.28795370e-01f, -3.82841639e-02f,
  -4.55783308e-02f, -8.71842355e-02f, -3.53196673e-02f, 1.15577551e-02f, -6.09273352e-02f, -5.27042262e-02f, -3.54576716e-03f, 1.23200074e-01f, 3.25270407e-02f, 5.29064564e-03f,
  3.01829446e-02f, -3.94615754e-02f, 7.49295428e-02f, -2.90139783e-02f, 8.00148398e-02f, -9.00160987e-03f, -3.91788073e-02f, -6.90844748e-03f, -2.76882220e-02f, -1.04811259e-01f,
  -6.44560903e-02f, 1.08269714e-01f, 3.43490727e-02f, -1.81725398e-02f, 6.22526705e-02f, -4.49036211e-02f, 5.51035255e-02f, -6.29798975e-03f, -7.20061138e-02f, 9.54044312e-02f,
  -7.96788260e-02f, 1.55232161e-01f, -2.50054616e-02f, -1.22284651e-01f, -1.10524416e-01f, 9.63968113e-02f, 9.09268633e-02f, 1.33603275e-01f, 1.31646574e-01f, 3.24952789e-02f,
  3.50955948e-02f, -3.04769725e-01f, 1.84795514e-01f, -4.34199907e-02f, -3.00859064e-02f, 2.61162221e-01f, -8.66436064e-02f, -1.12044707e-01f, 1.32282928e-01f, -9.83019248e-02f,
  1.03417210e-01f, 4.63991836e-02f, 1.24798089e-01f, 2.98143681e-02f, -3.16473357e-02f, -4.82207537e-02f, -1.39241815e-01f, 2.54462147e-03f, -2.04372942e-01f, -8.53645653e-02f,
  -3.56004387e-03f, 1.62889525e-01f, 4.00517834e-03f, 6.65896758e-03f, 1.28269821e-01f, -1.00078046e-01f, -8.73192176e-02f, -5.51839583e-02f, -3.38626429e-02f, 1.26433954e-01f,
  5.43506350e-03f, -1.00205079e-01f, 5.90090491e-02f, -3.33892629e-02f, 5.17004309e-03f, -1.80478040e-02f, 2.51840614e-02f, 2.31775437e-02f, 1.86969936e-02f, -9.39805526e-03f,
  2.42597517e-02f, 2.55210958e-02f, -4.76536006e-02f, -2.85028433e-03f, 1.13450335e-02f, 1.28159747e-01f, -5.23710996e-02f, -8.89526680e-02f, 4.66509536e-02f, 1.84019636e-02f,
  2.85600778e-02f, -1.95328030e-03f, 5.87558746e-02f, -1.03888251e-01f, 4.38996032e-02f, -7.46414140e-02f, -1.25665084e-01f, -2.42190119e-02f, 5.92333488e-02f, -2.40869243e-02f,
  -8.11109990e-02f, -2.96935476e-02f, -7.45102996e-03f, -8.10661837e-02f, -3.08701443e-03f, -1.75560936e-02f, -8.86407793e-02f, -8.54342431e-02f, 4.65358868e-02f, -1.00838713e-01f,
  -5.15003204e-02f, -5.46435528e-02f, -2.76041087e-02f, 3.94040830e-02f, 6.32301122e-02f, 1.15263583e-02f, -6.99320808e-03f, 3.74892727e-02f, 1.03560477e-01f, -8.97104144e-02f,
  6.35512322e-02f, 2.01466352e-01f, 1.05428204e-01f, -1.03200622e-01f, -1.02718268e-03f, -4.53977548e-02f, 5.50063774e-02f, 9.53574944e-03f, 3.30168158e-02f, 3.23015414e-02f,
  -3.70682366e-02f, -9.42573044e-03f, -6.17258996e-02f, -1.32089397e-02f, -3.09493206e-03f, 2.71666292e-02f, 1.64304394e-04f, -5.35334041e-03f, 4.08541746e-02f, -5.41471802e-02f,
  -5.04149459e-02f, -3.52915376e-02f, -5.51569462e-03f, 8.11329857e-02f, -7.78513402e-02f, -1.11798150e-03f, -4.78653200e-02f, -3.89716402e-02f, 2.74255313e-02f, -5.10705970e-02f,
  1.68362021e-01f, -1.99413702e-01f, 1.41666874e-01f, 4.00049612e-02f, 9.58315060e-02f, 2.40357816e-01f, 2.11701706e-01f, -2.94068158e-02f, 4.41728570e-02f, -2.26288795e-01f,
  -3.97439785e-02f, -2.05447394e-02f, -4.06756205e-03f, -4.20737918e-03f, 3.06238055e-01f, -1.78407934e-02f, 2.36761838e-01f, 3.85712795e-02f, -2.32311338e-02f, -1.05484053e-02f,
  -2.21093055e-02f, -2.20684800e-02f, 1.57384276e-01f, -7.34703289e-03f, 1.21490918e-01f, -2.11323891e-02f, 5.53331859e-02f, 7.45075569e-02f, 5.06685898e-02f, 7.59107918e-02f,
  -4.03002203e-02f, -1.41922012e-01f, -9.07392204e-02f, 4.07876223e-02f, 7.51385316e-02f, 8.27573910e-02f, 2.70596165e-02f, 1.11520208e-01f, 1.12025023e-01f, 7.83861428e-02f,
  -4.32577071e-04f, 8.48924592e-02f, -8.81981701e-02f, 7.78958201e-02f, 5.46445660e-02f, -3.91211594e-03f, -5.23097292e-02f, -1.05819730e-02f, -2.23340485e-02f, -2.91777905e-02f,
  3.03411763e-02f, -5.54580651e-02f, 1.35905251e-01f, -7.30684474e-02f, 3.55898924e-02f, 2.87687518e-02f, -2.37964895e-02f, 1.45299723e-02f, -6.84390515e-02f, 1.14427498e-02f,
  2.30718069e-02f, -4.79471795e-02f, -1.87423080e-02f, -2.62913257e-02f, 4.52882387e-02f, 2.72889771e-02f, 3.68053429e-02f, -1.56469326e-02f, 2.84374808e-03f, 1.09499041e-02f,
  -4.70755156e-03f, 3.76365632e-02f, 8.10349584e-02f, -2.89904568e-02f, 7.52165273e-04f, -4.79226261e-02f, 4.76961769e-02f, -4.38636541e-02f, -1.02421511e-02f, 3.89818810e-02f,
  -5.08404803e-03f, 7.19332546e-02f, 3.60731967e-02f, -9.89775732e-03f, 4.45875712e-02f, 7.26375356e-02f, 3.22712660e-02f, -2.10193521e-03f, -6.23038113e-02f, 1.30157858e-01f,
  2.46890932e-02f, -1.55238271e-01f, -9.73786265e-02f, -2.49253586e-03f, 2.69894637e-02f, 2.91339997e-02f, 3.18198651e-02f, 1.17556408e-01f, 3.61489728e-02f, 4.05981541e-02f,
  5.66244274e-02f, 1.57593470e-02f, -2.52767038e-02f, 4.62226868e-02f, 7.71471858e-02f, -2.36221608e-02f, -9.57425870e-03f, -1.61596090e-02f, 4.98274975e-02f, -8.76939669e-02f,
  2.52119377e-02f, 3.78814824e-02f, 5.72885992e-03f, 2.54663229e-02f, -3.23322117e-02f, -6.32614568e-02f, -1.80934407e-02f, -1.22084282e-01f, -5.95280062e-03f, 6.08658865e-02f,
  -6.19432107e-02f, -1.42645594e-02f, 6.95045665e-02f, 7.27733001e-02f, -1.51299806e-02f, -1.91249385e-01f, -1.63954183e-01f, 1.07460588e-01f, -2.36918837e-01f, -1.33663371e-01f,
  -1.00868091e-01f, -2.22047478e-01f, -1.02158517e-01f, -2.47693256e-01f, -3.24449003e-01f, -2.39883393e-01f, -1.82465494e-01f, -2.00132772e-01f, -3.21483612e-02f, -1.37156844e-02f,
  -6.35168776e-02f, -1.23321906e-01f, 6.17520064e-02f, 1.88157052e-01f, 1.96594283e-01f, 2.60371119e-01f, 2.77625769e-01f, 1.10667527e-01f, 1.84331432e-01f, -3.51257809e-03f,
  -3.37761901e-02f, -1.76442266e-01f, 8.92252196e-03f, -2.93711536e-02f, -6.80095926e-02f, 1.71878040e-02f, -1.25354916e-01f, 8.94419178e-02f, -8.22725594e-02f, 5.66132460e-03f,
  -8.29373822e-02f, -9.94276777e-02f, -4.32091616e-02f, 2.90948786e-02f, 4.82563227e-02f, 3.96875292e-02f, -1.48563124e-02f, -2.91537074e-03f, 1.51053183e-02f, 8.36519226e-02f,
  6.13635816e-02f, 5.76754734e-02f, 1.96816754e-02f, 1.17168808e-02f, -1.90350823e-02f, -8.48117545e-02f, 7.25626424e-02f, -3.05126105e-02f, 5.31194173e-02f, -8.45369026e-02f,
  -1.06373459e-01f, -7.84982294e-02f, 9.77620855e-02f, 7.72825554e-02f, 9.45863426e-02f, 8.39443803e-02f, -4.90722246e-02f, 3.35969105e-02f, 7.09751993e-03f, 3.03384885e-02f,
  1.08030207e-01f, -3.83650064e-02f, -7.16121495e-02f, -6.50339872e-02f, 1.62078943e-02f, 7.98584446e-02f, -9.23212692e-02f, 1.70573667e-01f, 9.02036428e-02f, 7.18840435e-02f,
  -9.07309204e-02f, -5.65472320e-02f, 9.83189046e-02f, 5.92909455e-02f, 3.66571955e-02f, 6.78060576e-03f, -5.00293896e-02f, 6.07011281e-02f, -7.66843557e-03f, 9.94097665e-02f,
  -8.60048234e-02f, -1.04674153e-01f, -5.00450423e-03f, 1.74629278e-02f, -1.68561727e-01f, 4.82730381e-02f, -1.43966854e-01f, 9.91461519e-03f, -7.24735111e-02f, 1.13298022e-03f,
  -4.72793765e-02f, 2.83877812e-02f, -7.84465671e-02f, 4.01718058e-02f, -1.40017793e-01f, -1.56981144e-02f, -5.49837165e-02f, 1.56103075e-02f, -8.89462531e-02f, 1.18009578e-02f,
  1.83822215e-02f, -1.13633640e-01f, -4.82838601e-02f, 1.27032958e-02f, 1.59353107e-01f, -4.49080835e-04f, 8.18475429e-03f, -9.43353400e-02f, 8.62072185e-02f, -1.36974335e-01f,
  -1.32542446e-01f, 2.75202572e-01f, -1.43048137e-01f, -1.13589741e-01f, 6.86361967e-03f, -9.37831700e-02f, -7.69703910e-02f, 1.58570215e-01f, 1.36830300e-01f, 9.55596343e-02f,
  -1.85762020e-03f, -1.36761084e-01f, 1.68450385e-01f, -2.15733156e-01f, -1.38149396e-01f, 7.59231746e-02f, -1.70870855e-01f, -1.28308594e-01f, 1.24458686e-01f, 3.30532975e-02f,
  1.17592655e-01f, 2.97889970e-02f, -1.08989082e-01f, 1.75695106e-01f, -6.77406862e-02f, 9.96806994e-02f, 9.41791385e-03f, 2.04599857e-01f, -1.37221247e-01f, -2.30209045e-02f,
  -3.29655595e-02f, 3.25659961e-02f, -6.68629408e-02f, 1.25271738e-01f, 3.32941413e-02f, -3.25752571e-02f, 6.54236302e-02f, 7.98793957e-02f, 7.75291100e-02f, 8.07654113e-02f,
  8.61194730e-02f, -7.24568069e-02f, 1.42011680e-02f, 1.70562446e-01f, 2.14936920e-02f, -7.99154192e-02f, -1.29790669e-02f, -8.28016475e-02f, 8.13210905e-02f, -5.95422052e-02f,
  -1.08147718e-01f, -7.05980137e-02f, -1.33061856e-01f, -4.30124160e-03f, -5.29498570e-02f, 2.04741713e-02f, -1.17348909e-01f, -9.03177708e-02f, -1.66196935e-02f, -1.11028247e-01f,
  1.27671689e-01f, -2.84547508e-02f, -5.85645363e-02f, 5.83746359e-02f, 1.01583071e-01f, 4.36780266e-02f, 1.39369126e-02f, -4.83757481e-02f, 2.35441662e-02f, -1.01397708e-01f,
  -1.24636693e-02f, -1.67686939e-02f, -8.24933425e-02f, -1.35303408e-01f, -9.57372040e-02f, -3.23234312e-02f, -1.49091845e-02f, -3.47611979e-02f, -2.92863715e-02f, -1.09294236e-01f,
  8.25428218e-02f, -3.08233276e-02f, 1.82694085e-02f, 5.26855662e-02f, -9.25154891e-03f, 1.17357567e-01f, 1.08224256e-02f, 4.18753475e-02f, -1.43142864e-02f, 6.58741314e-03f,
  1.24705881e-01f, 2.11243421e-01f, 1.32894926e-02f, -1.42480843e-02f, 2.29625218e-02f, 4.92641181e-02f, 8.60202014e-02f, 9.28099826e-02f, 1.00438312e-01f, 1.05153948e-01f,
  2.10062452e-02f, -5.50375134e-03f, 7.32809305e-02f, -2.89536105e-03f, 3.56638692e-02f, -2.19347849e-02f, -2.36040819e-03f, 9.37579647e-02f, -1.97345093e-02f, -2.96487496e-03f,
  -3.83989662e-02f, -6.46020053e-03f, -8.28184932e-02f, -4.23814803e-02f, -8.90166615e-04f, 4.87081371e-02f, -3.65791097e-02f, -3.61026525e-02f, -5.43462411e-02f, -2.80413944e-02f,
  -4.03897941e-01f, 2.17259482e-01f, 2.59022862e-01f, -1.91836078e-02f, -2.48921037e-01f, -1.81733578e-01f, -7.59258792e-02f, -2.11847574e-01f, -1.95473477e-01f, 2.17365354e-01f,
  -5.66155724e-02f, 2.40020886e-01f, 1.85820729e-01f, -1.08541295e-01f, -2.97218561e-01f, 7.00061172e-02f, -1.16381487e-02f, 8.93357173e-02f, 4.12713066e-02f, 4.48826887e-02f,
  -6.82904869e-02f, -3.00823241e-01f, 5.34875318e-02f, -3.25746275e-02f, 4.46399152e-02f, 2.00697303e-01f, 1.00276902e-01f, 1.92171618e-01f, 8.15415233e-02f, -2.98126359e-02f,
  -1.17366619e-01f, -1.02295473e-01f, -4.83782329e-02f, -9.66387093e-02f, 2.71686353e-02f, 3.32528651e-02f, 6.51192740e-02f, 6.05430380e-02f, 4.97655105e-03f, -4.50654961e-02f,
  1.50269628e-01f, 2.58946065e-02f, -7.46131986e-02f, 1.08219532e-03f, -5.79346642e-02f, -5.20531125e-02f, -5.47275320e-02f, -5.97530641e-02f, -2.00842265e-02f, -2.43392922e-02f,
  3.71252298e-02f, 9.08416361e-02f, -4.90654595e-02f, -2.84361579e-02f, 5.07887155e-02f, 1.05189960e-02f, 7.39898831e-02f, 5.04762381e-02f, -3.56239118e-02f, 1.09872194e-02f,
  -8.16096831e-03f, 8.91606044e-03f, -2.91283382e-03f, 2.31697429e-02f, 2.73946114e-02f, 2.23210771e-02f, -2.07013730e-03f, -3.54843587e-03f, -3.51058878e-02f, 4.52137589e-02f,
  1.01365834e-01f, 2.07242649e-02f, -9.64906439e-02f, 3.13500911e-02f, 5.00005856e-02f, -4.15403284e-02f, -2.13042051e-02f, 6.82517737e-02f, 1.28283259e-02f, -1.82839278e-02f,
  1.16683543e-02f, -2.19780803e-02f, 5.01030050e-02f, 4.28341962e-02f, -2.57818680e-02f, 1.95275359e-02f, -1.37638696e-03f, -3.54678486e-04f, 7.96233211e-03f, 9.47312103e-04f,
  4.83446784e-04f, 1.11987412e-01f, -1.71570748e-03f, -2.91648563e-02f, 1.00032883e-02f, 6.83563799e-02f, -5.95132858e-02f, -8.89260545e-02f, 2.43653841e-02f, -2.21870132e-02f,
  6.44608140e-02f, 1.65285930e-01f, -6.45078570e-02f, -3.45503464e-02f, 1.83870755e-02f, -5.45132235e-02f, 4.90495376e-02f, -2.78633181e-02f, -1.27108414e-02f, 1.45456502e-02f,
  6.30877316e-02f, 6.98198900e-02f, -2.77064629e-02f, -1.53667582e-02f, 4.39032987e-02f, 6.31299689e-02f, 3.01743671e-02f, 3.53475548e-02f, 9.17290524e-03f, 4.55230027e-02f,
  2.29906887e-01f, -4.51973349e-01f, -2.22068146e-01f, 6.76858937e-03f, 2.75857508e-01f, 2.64217138e-01f, 1.60530612e-01f, -1.23917433e-02f, -1.53617099e-01f, -2.95729250e-01f,
  1.19812742e-01f, -1.37984484e-01f, -2.08142877e-01f, -4.75925617e-02f, 2.22535282e-01f, -2.23032027e-01f, -2.71838512e-02f, -1.35805249e-01f, -1.05544209e-01f, -5.38567081e-02f,
  9.23507586e-02f, 1.09458998e-01f, -5.11559509e-02f, -4.17591818e-02f, -5.24518378e-02f, -8.22686404e-02f, 7.64606073e-02f, 6.67473115e-03f, 9.70425829e-02f, 1.03719793e-01f,
  7.33576110e-03f, -1.05748504e-01f, -7.84002617e-02f, -1.97781879e-03f, 3.88752930e-02f, 8.28882586e-03f, -4.37031202e-02f, -6.16594683e-03f, 6.14782423e-02f, 5.20372652e-02f,
  -3.76668293e-03f, -6.73055351e-02f, -5.76184914e-02f, 6.49326667e-02f, -2.95994952e-02f, -7.12414235e-02f, -9.80477314e-04f, 5.04145510e-02f, -1.96460802e-02f, -5.55200055e-02f,
  -7.59430081e-02f, -9.90857035e-02f, 6.12181500e-02f, -4.44025621e-02f, -4.92031360e-03f, -3.42435390e-02f, -4.91081998e-02f, -8.04507583e-02f, -3.39839458e-02f, -1.41425375e-02f,
  -1.51810395e-02f, -4.71633114e-02f, -6.44945204e-02f, 3.15471850e-02f, 3.00103761e-02f, 7.30304047e-02f, 1.20190099e-01f, 6.81606540e-03f, -4.83355634e-02f, 7.95857906e-02f,
  -2.34101620e-02f, 5.27333058e-02f, 9.29139033e-02f, 4.17021662e-03f, 1.76871773e-02f, -1.73641299e-03f, -5.66715142e-03f, -7.36834109e-02f, -2.84079146e-02f, 6.73483759e-02f,
  -5.58233559e-02f, 3.55643779e-02f, 1.99259724e-02f, 3.90973873e-02f, 1.10157378e-01f, -4.82944101e-02f, -4.46496420e-02f, -7.45881796e-02f, -2.06323639e-02f, 8.33518920e-04f,
  1.63617302e-02f, -1.47982478e-01f, -4.50726561e-02f, -8.16968549e-03f, -5.83871342e-02f, 6.29658327e-02f, -3.18220668e-02f, -1.40390545e-02f, -5.68359159e-02f, 1.04538193e-02f,
  6.93173185e-02f, -1.02479152e-01f, 6.37758970e-02f, 2.26951800e-02f, 7.33595863e-02f, -9.42684151e-03f, 2.28889547e-02f, 7.37188151e-03f, 4.33482714e-02f, -7.60247279e-03f,
  -3.71993659e-03f, -2.30536219e-02f, 4.67051845e-03f, -6.24187477e-02f, -2.89908778e-02f, 1.31981680e-02f, 9.74593535e-02f, -7.89831206e-02f, 6.83817342e-02f, -8.24847743e-02f,
  -4.27566290e-01f, 3.31755370e-01f, 5.54311574e-02f, -9.49819535e-02f, -1.73952617e-02f, 2.58004040e-01f, -8.21395665e-02f, 1.47300601e-01f, -1.88701779e-01f, 2.64952093e-01f,
  2.02888861e-01f, -1.43369377e-01f, 2.23303512e-01f, 2.64258891e-01f, -5.65700419e-02f, 9.71860513e-02f, 7.88864866e-02f, -6.65789247e-02f, 3.30502279e-02f, 9.53152776e-02f,
  8.33378918e-03f, 1.35257289e-01f, 1.35399327e-01f, 2.05455422e-01f, 3.19143534e-02f, -6.43405691e-03f, -3.57273370e-02f, -2.25157794e-02f, 7.90941939e-02f, 6.70157671e-02f,
  8.72422680e-02f, -7.22154882e-03f, -1.92900784e-02f, 4.25615720e-02f, 1.04594730e-01f, 3.72227747e-03f, 1.01835668e-01f, -1.35697260e-01f, -1.02128245e-01f, 5.13203889e-02f,
  9.50292964e-03f, 2.95807663e-02f, 2.31387205e-02f, -3.59903984e-02f, 6.07349561e-04f, 9.32127819e-04f, 8.22691470e-02f, 4.02478240e-02f, -1.76905729e-02f, -7.24928081e-03f,
  6.35684514e-03f, 2.02320181e-02f, -5.46453260e-02f, 1.46421036e-02f, 9.09795333e-03f, -3.42552923e-02f, 1.71962902e-02f, -4.47978638e-02f, 7.79241547e-02f, -2.67658513e-02f,
  9.73428693e-03f, 1.10224197e-02f, 5.12000024e-02f, 3.56340967e-02f, -2.69805416e-02f, -1.79405662e-03f, -3.59954089e-02f, 3.09964586e-02f, -2.93313507e-02f, -9.74463392e-03f,
  -6.09466955e-02f, -4.97741066e-02f, -5.23977680e-03f, 2.18282305e-02f, 7.14698434e-02f, 3.64400968e-02f, -6.34086281e-02f, 1.83200762e-02f, -1.39001086e-02f, -2.95313615e-02f,
  -8.80937576e-02f, -6.66055679e-02f, -4.01003286e-04f, -1.55274989e-02f, 8.01128894e-02f, -6.64619952e-02f, -3.01973410e-02f, 1.24492683e-01f, 4.29241871e-03f, 5.62210344e-02f,
  1.00770541e-01f, 2.08324015e-01f, 2.36914377e-03f, 6.27502948e-02f, -1.86574124e-02f, 2.43286192e-02f, 6.91742972e-02f, -3.78367044e-02f, -1.54718095e-02f, 1.29139990e-01f,
  -3.18948813e-02f, 1.34997172e-02f, -4.56062928e-02f, 3.22970301e-02f, 4.54285517e-02f, 8.46638903e-02f, -1.40609508e-02f, -1.06250299e-02f, -1.21253751e-01f, 6.00134693e-02f,
  -1.03895422e-02f, -1.11866124e-01f, 4.37853932e-02f, 3.05708367e-02f, 4.23349366e-02f, 2.79540122e-02f, -5.84992282e-02f, -6.74832612e-02f, 2.55349521e-02f, -4.55222465e-02f,
  -2.87527800e-01f, 3.66912872e-01f, -2.31713787e-01f, -8.46288400e-04f, 1.59727987e-02f, 1.60387650e-01f, -2.68420263e-05f, 1.15966104e-01f, -6.68017939e-02f, 1.52185589e-01f,
  2.24668738e-02f, -6.59776777e-02f, -1.21679388e-01f, 2.52576113e-01f, 4.54249308e-02f, -3.73184234e-02f, 2.34092608e-01f, 3.55710164e-02f, 5.30017577e-02f, 8.97766873e-02f,
  -4.09972854e-02f, 2.03512579e-01f, -1.14243545e-01f, 1.67345837e-01f, 1.39275163e-01f, -2.91010961e-02f, 1.22421898e-01f, -3.18680368e-02f, 1.13679260e-01f, 6.67850301e-02f,
  -7.12235421e-02f, -1.34539902e-01f, -1.13248430e-01f, -2.45103523e-01f, -7.69690201e-02f, -4.08415161e-02f, -8.98248181e-02f, 2.30518319e-02f, -2.39581093e-02f, -6.96688369e-02f,
  -8.71703178e-02f, 5.72546795e-02f, -7.66523648e-03f, 3.49795185e-02f, 5.32459803e-02f, -1.42490100e-02f, 3.07929385e-02f, -1.91228874e-02f, 1.43054789e-02f, 2.60495488e-02f,
  2.72560818e-03f, 5.36492653e-02f, -2.25788094e-02f, 6.25865310e-02f, 3.12322900e-02f, 7.43762851e-02f, 1.06944740e-02f, 7.86315873e-02f, -3.01589898e-04f, 3.83915268e-02f,
  5.05312756e-02f, -1.18560895e-01f, 6.02413993e-03f, -6.27378523e-02f, -6.11324853e-04f, -7.96742961e-02f, 4.86944802e-02f, 4.07219939e-02f, 3.22306342e-02f, 4.40167710e-02f,
  -1.46266729e-01f, -6.68115839e-02f, 1.49200231e-01f, -3.31728496e-02f, 9.82436687e-02f, -1.51525319e-01f, 1.58783398e-03f, -8.54580700e-02f, -2.82383673e-02f, -5.99283054e-02f,
  -2.52777785e-02f, -3.26582766e-03f, -2.42201686e-02f, -7.48819038e-02f, 5.76241836e-02f, 2.93233842e-02f, 2.94370614e-02f, -1.04828537e-01f, 3.35900784e-02f, 1.53957317e-02f,
  1.87219679e-01f, 2.23125815e-01f, -1.24054268e-01f, -4.65957299e-02f, -1.19936250e-01f, -4.06842194e-02f, -5.58865815e-02f, -8.97125062e-03f, 4.62754071e-02f, -3.75740826e-02f,
  -5.79899643e-03f, -9.09592882e-02f, 1.38909239e-02f, 6.91067874e-02f, -3.30172591e-02f, -4.17296477e-02f, 9.59702879e-02f, 8.59736502e-02f, 5.20341620e-02f, 6.55457675e-02f,
  4.44850288e-02f, 1.02950610e-01f, -5.71175478e-02f, 7.67763034e-02f, -3.20992544e-02f, 1.84421055e-02f, 6.35840073e-02f, 1.97757338e-03f, 2.95683909e-02f, 3.85823175e-02f,
  2.50707865e-01f, -2.07238212e-01f, 7.13957399e-02f, -2.07229733e-01f, 4.26007397e-02f, 2.69337863e-01f, 1.41798884e-01f, -4.68166135e-02f, 1.97410613e-01f, -6.17735051e-02f,
  -4.69821617e-02f, -8.32158625e-02f, 1.60927713e-01f, -2.88688064e-01f, 4.53817219e-01f, 1.43057272e-01f, 6.25532568e-02f, -6.02476969e-02f, 1.36577770e-01f, -5.44201918e-02f,
  5.13066798e-02f, -1.06442831e-01f, -1.22944929e-03f, -3.49348262e-02f, -6.51685596e-02f, -8.38208869e-02f, -1.14564605e-01f, 3.12586240e-02f, -2.59881884e-01f, -3.18509527e-02f,
  -9.92488191e-02f, -1.29249692e-01f, -7.92597830e-02f, 1.19647635e-02f, 6.65677935e-02f, 8.85900259e-02f, -8.42088312e-02f, 8.64082873e-02f, 1.87208876e-02f, 3.58581319e-02f,
  1.62375346e-02f, 9.55972299e-02f, -5.37040234e-02f, 1.24932513e-01f, -7.46482685e-02f, -3.18916291e-02f, 3.73791414e-03f, 5.47255091e-02f, -7.79153705e-02f, -4.59599346e-02f,
  2.17145476e-02f, -5.78839295e-02f, 2.46094633e-02f, -6.66059330e-02f, 4.91633713e-02f, 1.21369008e-02f, 4.59933728e-02f, 4.62344475e-02f, -6.69132471e-02f, 4.11417224e-02f,
  -8.48034397e-02f, 6.83139265e-02f, 9.95132979e-03f, -8.56844410e-02f, 4.97952029e-02f, -6.13504723e-02f, -6.96900487e-03f, 1.93237383e-02f, 4.46184911e-02f, -2.88514588e-02f,
  -9.10215080e-03f, -2.04796866e-02f, -5.11200279e-02f, -7.84804858e-03f, 6.67907521e-02f, 2.52196919e-02f, -3.17646973e-02f, -9.03626829e-02f, -3.15192863e-02f, 3.12750563e-02f,
  4.63270699e-04f, 1.26264945e-01f, 5.40661737e-02f, -5.65973930e-02f, 5.21694161e-02f, -5.45351068e-03f, 3.61419059e-02f, -6.11184239e-02f, -2.36897618e-02f, 3.43886428e-02f,
  -7.02335080e-03f, 7.59569034e-02f, -2.61479244e-02f, -5.75231239e-02f, 1.17814522e-02f, 1.74420588e-02f, 3.62289771e-02f, 5.04094996e-02f, 4.40232009e-02f, 4.13109502e-03f,
  -7.99170975e-03f, -2.48062257e-02f, 6.14361092e-02f, -8.41222852e-02f, 5.95265243e-04f, 1.18347760e-02f, 7.99249113e-02f, -6.86408877e-02f, -2.54282844e-03f, -6.90346435e-02f,
  1.80102047e-02f, 1.05213359e-01f, 1.15582813e-02f, -6.49833260e-03f, -1.65248793e-02f, -1.35309761e-02f, 1.21782064e-01f, -1.17187038e-01f, -6.17926754e-02f, 2.71732006e-02f,
  -2.56717861e-01f, 1.19648129e-01f, -1.84436768e-01f, -2.02006266e-01f, -4.64352295e-02f, 1.12247251e-01f, -9.77950916e-02f, 3.00832205e-02f, 1.33616373e-01f, 2.70889878e-01f,
  -6.15750216e-02f, -6.26264364e-02f, -5.13718538e-02f, -3.62615809e-02f, 1.97135195e-01f, 1.14147209e-01f, 1.24228589e-01f, -9.89316404e-02f, 4.04238775e-02f, 9.44343582e-02f,
  7.09782774e-03f, 1.57319456e-01f, -1.68138012e-01f, 1.01551473e-01f, -1.35604620e-01f, -1.17326796e-01f, 9.93787497e-02f, -3.92709076e-02f, -2.00132001e-02f, -3.56700793e-02f,
  -1.14143535e-01f, 3.56695950e-02f, -1.00115292e-01f, 1.68775339e-04f, 4.87721860e-02f, 8.87466446e-02f, 3.47849205e-02f, 7.35400394e-02f, -5.59109487e-02f, 8.45231637e-02f,
  1.34346168e-02f, 7.91160390e-02f, 7.48061314e-02f, 6.77891970e-02f, -7.84687027e-02f, -6.35569692e-02f, -7.03484416e-02f, -1.89142212e-01f, 2.74378955e-02f, -1.13460207e-02f,
  -8.03299993e-02f, -9.15986821e-02f, 8.11377317e-02f, 9.14661735e-02f, -2.86513809e-02f, 5.18819802e-02f, 7.17769265e-02f, 6.78497404e-02f, 4.34553288e-02f, 7.14754388e-02f,
  5.06225862e-02f, 1.04978256e-01f, -2.37401817e-02f, -5.00689894e-02f, -2.94261090e-02f, -5.00764512e-03f, 1.15279006e-02f, 8.95750709e-03f, -4.13594116e-03f, 2.90898290e-02f,
  -2.78582349e-02f, -3.05036362e-02f, -5.00182174e-02f, -9.04026553e-02f, -1.19435424e-02f, -4.78059314e-02f, -8.29641446e-02f, -3.20021622e-02f, -1.88139137e-02f, -1.39970317e-01f,
  -1.17112793e-01f, 3.29350680e-02f, 8.79183039e-03f, 8.04588012e-03f, 1.69320591e-02f, 6.78130309e-04f, -2.79278727e-03f, -8.05714913e-03f, -2.43210699e-02f, 1.81156714e-02f,
  1.64926082e-01f, 4.85759765e-01f, 2.49002185e-02f, -5.60588948e-02f, 1.17193259e-01f, 3.66816148e-02f, 8.10913220e-02f, 1.45087793e-01f, 5.85020483e-02f, 1.43213525e-01f,
  5.02141528e-02f, -8.94077793e-02f, 8.83710086e-02f, 6.94980323e-02f, -9.26267356e-02f, 9.14513767e-02f, 4.75462377e-02f, 1.57516692e-02f, 1.42261788e-01f, 2.59349160e-02f,
  9.44147483e-02f, 1.47811621e-01f, 3.07264680e-04f, -2.78277546e-02f, 1.34343952e-02f, -4.36987355e-02f, 2.35239379e-02f, 8.70120451e-02f, -8.08045361e-03f, 2.99762245e-02f,
  -3.43666822e-01f, 1.01884276e-01f, -6.11904748e-02f, -2.55238116e-01f, -1.00683914e-02f, 3.12180780e-02f, 9.07860771e-02f, -1.27999991e-01f, -8.25133696e-02f, 6.00400567e-02f,
  -7.41195604e-02f, 6.74879476e-02f, 1.83053568e-01f, -1.42185271e-01f, -1.68014333e-01f, 1.52144775e-01f, -1.30172119e-01f, 7.52455071e-02f, -8.95052403e-03f, -4.14121822e-02f,
  3.34760360e-02f, -7.45844766e-02f, 3.00511047e-02f, -7.59515017e-02f, -1.79370984e-01f, -1.30043298e-01f, -1.16815373e-01f, 1.83172710e-02f, -1.56937063e-01f, -9.11766738e-02f,
  -1.76243167e-02f, -1.29623175e-01f, -3.27029154e-02f, -5.97816817e-02f, -1.99761912e-02f, 1.88157298e-02f, 6.29705563e-02f, -1.64427888e-02f, 1.52653428e-02f, -2.96618734e-02f,
  1.41932696e-01f, -8.38160142e-02f, -5.42766266e-02f, 4.13430929e-02f, 1.86422057e-02f, -9.81114507e-02f, 8.85348860e-03f, 4.25063744e-02f, -2.97078434e-02f, -1.08458819e-02f,
  1.83446296e-02f, 2.57331063e-04f, -8.18695035e-03f, -3.30349281e-02f, -6.61017373e-02f, -1.25035197e-01f, 4.63272743e-02f, -3.89499739e-02f, -4.28232364e-02f, -7.42105618e-02f,
  -1.00234725e-01f, 6.24464750e-02f, -5.77187985e-02f, 2.56887469e-02f, -7.63644129e-02f, 8.20152368e-03f, 5.84060252e-02f, -2.60413811e-03f, 8.92652292e-03f, -6.94988370e-02f,
  -3.31191905e-02f, 2.11336128e-02f, -2.95053776e-02f, 1.80994123e-01f, -1.24046975e-03f, -1.48503333e-02f, 4.58573624e-02f, -3.09640337e-02f, 7.70075172e-02f, -5.58959544e-02f,
  -3.81997041e-02f, -4.70095724e-02f, 1.63242146e-02f, 4.85670171e-04f, -2.97280196e-02f, 4.14007232e-02f, -4.54660598e-03f, 5.02301008e-02f, -4.43749540e-02f, 1.15962448e-02f,
  -6.71240091e-02f, -3.30528527e-01f, -1.33889481e-01f, -1.11801922e-01f, -1.17933955e-02f, 3.29219624e-02f, 8.84249285e-02f, -7.78044062e-03f, -7.94293061e-02f, 5.63206561e-02f,
  9.94974375e-03f, -1.66035052e-02f, -3.50204781e-02f, 1.26647903e-02f, 5.17328493e-02f, -2.94426158e-02f, 4.21628766e-02f, -9.86696333e-02f, -1.08795688e-01f, 1.03075653e-02f,
  -2.27620210e-02f, -2.63975151e-02f, 1.82796794e-04f, 4.73932456e-03f, -8.31221640e-02f, -5.86386658e-02f, -4.60977852e-02f, 2.58607231e-02f, 3.46254259e-02f, 1.51975583e-02f,
  7.93115348e-02f, -6.01080246e-04f, 1.18202761e-01f, -5.28607070e-02f, -2.90765047e-01f, 3.11630219e-01f, 2.50512540e-01f, -6.67408779e-02f, -4.21779754e-04f, 2.65474264e-02f,
  -1.20212592e-01f, 1.79440409e-01f, 7.74606913e-02f, -1.35414675e-01f, -1.06060170e-01f, 2.94147572e-03f, -1.62499472e-01f, 1.38742343e-01f, -1.62080787e-02f, -1.01380751e-01f,
  -2.97119468e-01f, -3.09004247e-01f, -1.44868046e-01f, -3.24073672e-01f, -1.39052451e-01f, 5.91569282e-02f, -1.31070778e-01f, -5.04958183e-02f, -6.11724844e-03f, 9.79525894e-02f,
  2.85368599e-02f, 3.95952947e-02f, 3.78552787e-02f, 1.08886041e-01f, -2.90556289e-02f, 1.92044154e-02f, 8.04247409e-02f, -1.70218144e-02f, -2.98731569e-02f, 1.12302557e-01f,
  1.30066555e-02f, 5.00709973e-02f, 5.63514866e-02f, 1.05477080e-01f, -5.43613881e-02f, -9.95613448e-03f, 2.57628206e-02f, 7.09874257e-02f, -2.01047976e-02f, -1.40520120e-02f,
  -1.53092563e-01f, 2.02135649e-02f, -4.01152819e-02f, 9.28879306e-02f, -1.09202936e-02f, 1.04357824e-02f, 3.11583676e-03f, -2.76035140e-03f, 5.93543425e-02f, -1.13282591e-01f,
  -6.86974591e-03f, -3.11794095e-02f, -3.46945152e-02f, 5.47583774e-03f, 1.50775425e-02f, -2.90584215e-03f, 7.92526975e-02f, 5.80786690e-02f, 3.25870365e-02f, -1.26440287e-01f,
  -5.33086360e-02f, 4.70721796e-02f, -1.57466158e-02f, 1.49917984e-02f, -8.28770325e-02f, 7.11974576e-02f, -6.33679554e-02f, 7.49408081e-02f, -3.29062203e-03f, -8.30461234e-02f,
  -3.54359113e-02f, -4.91149947e-02f, 5.92370629e-02f, -1.11477971e-01f, -8.17173049e-02f, 4.43606712e-02f, -1.29294570e-03f, 1.21141411e-01f, 2.92291027e-02f, 7.54286395e-03f,
  3.92926745e-02f, 2.24371930e-03f, 1.28093801e-04f, 2.61331499e-02f, -3.73859657e-03f, -7.93920457e-02f, -4.97333407e-02f, -5.34972809e-02f, 4.58444543e-02f, 9.73654538e-03f,
  -6.06379583e-02f, 1.54889598e-02f, 5.89888282e-02f, 7.66700953e-02f, 1.33299865e-02f, 9.16648365e-04f, 2.25805305e-02f, -4.66677360e-02f, -8.62828791e-02f, 1.15288600e-01f,
  -9.23142582e-02f, -4.31965925e-02f, 5.98616851e-03f, -1.18400820e-01f, -9.40712541e-02f, -3.44134532e-02f, -2.81488374e-02f, 9.01880711e-02f, -4.85870708e-03f, -5.37144616e-02f,
  1.05687559e-01f, 1.23925097e-01f, 3.98012459e-01f, 1.31168207e-02f, 1.99608833e-01f, 3.03575516e-01f, 1.50515512e-01f, 1.63831964e-01f, 2.32692897e-01f, -2.58620113e-01f,
  -2.15679944e-01f, 1.26309022e-01f, -2.46640667e-02f, -9.29200053e-02f, 1.17328614e-01f, 5.90865314e-02f, 4.61730473e-02f, 2.19654664e-02f, 1.16826549e-01f, -1.19434764e-04f,
  -1.99248102e-02f, -1.49915606e-01f, 1.25266900e-02f, -1.54353213e-02f, 1.15266576e-01f, 2.93316436e-03f, -2.86284894e-01f, 1.90702289e-01f, -1.91909641e-01f, -3.29043008e-02f,
  -1.03488034e-02f, -9.45974737e-02f, -1.39684901e-01f, -5.83168701e-04f, -1.53448284e-02f, -1.28872871e-01f, -7.51635805e-02f, 2.84022167e-02f, 3.06594726e-02f, 6.01660907e-02f,
  -2.92997770e-02f, 9.35330093e-02f, -5.65816611e-02f, 3.29039320e-02f, 9.45715457e-02f, 9.46703851e-02f, 6.97181001e-02f, 2.26940084e-02f, -4.50617969e-02f, 1.00051112e-01f,
  1.59827307e-01f, 1.51259452e-01f, 8.04611146e-02f, 1.39050007e-01f, 8.56746454e-03f, 4.12786119e-02f, -3.21974009e-02f, 1.41675785e-01f, 8.90447199e-02f, 4.30367813e-02f,
  -5.06202364e-03f, 6.76795393e-02f, -2.03093085e-02f, -3.78855057e-02f, -1.78180786e-03f, -7.49855563e-02f, -7.51403347e-02f, -8.80777463e-02f, 9.90634933e-02f, -3.37857939e-02f,
  -9.07187387e-02f, 1.92867089e-02f, 3.11796125e-02f, 9.06400755e-02f, -8.77141133e-02f, -8.38923380e-02f, 1.07724788e-02f, 4.18162718e-02f, 2.34778486e-02f, 8.70280713e-03f,
  -1.07971407e-01f, -1.98695175e-02f, -1.00879639e-01f, -1.97435729e-02f, 3.67749333e-02f, -6.65965304e-02f, -1.41195972e-02f, -1.66765749e-02f, -6.10702895e-02f, -1.01922348e-01f,
  -3.29655670e-02f, -1.22351348e-01f, -1.34583831e-01f, -8.84870440e-02f, -3.21789421e-02f, -1.33726567e-01f, 1.28594205e-01f, 4.89677712e-02f, 2.14368124e-02f, -1.10654540e-01f,
  -7.54507780e-02f, -8.12814906e-02f, -9.30643931e-04f, 9.61313471e-02f, 3.17620374e-02f, -2.83287298e-02f, -5.75583950e-02f, -5.44192046e-02f, -1.50156273e-02f, -3.25934701e-02f,
  1.39293233e-02f, 7.39698112e-02f, 4.69311252e-02f, 3.16310115e-02f, -3.91539186e-02f, -9.08177495e-02f, 7.94545282e-03f, 1.97942611e-02f, 3.21547948e-02f, 3.51563916e-02f,
  -3.99169356e-01f, -8.37846845e-02f, -4.52555157e-02f, -2.51832485e-01f, 1.74632981e-01f, 7.88337290e-02f, -9.88811851e-02f, 6.73313886e-02f, -3.06071311e-01f, 4.04910594e-02f,
  1.70126006e-01f, -3.15868288e-01f, -5.57083003e-02f, 2.96614300e-02f, -2.05178246e-01f, -1.60764948e-01f, -1.61360994e-01f, -9.35806558e-02f, -3.16822939e-02f, -4.60004769e-02f,
  -2.10448336e-02f, 6.20860718e-02f, 7.01084081e-03f, 1.42940775e-01f, 6.26735762e-02f, 1.21304244e-02f, 7.07214847e-02f, 6.73435330e-02f, 6.04991578e-02f, 3.11182830e-02f,
  3.29741836e-02f, -7.90565982e-02f, 9.73087624e-02f, -1.10328104e-02f, -5.13131171e-02f, 1.09319892e-02f, 4.43145968e-02f, -4.64239381e-02f, 2.41391137e-02f, -3.48387919e-02f,
  -1.49441445e-02f, -1.11727409e-01f, 2.10775845e-02f, -3.20600346e-02f, -4.96416679e-03f, 1.80465765e-02f, 1.38016731e-01f, 1.08928435e-01f, 1.24915708e-02f, -1.03988592e-02f,
  -1.19910454e-02f, -9.17570665e-03f, -1.48098301e-02f, -1.96806744e-01f, -4.90592495e-02f, 2.98550986e-02f, -3.93286794e-02f, -4.75421874e-03f, -4.80696782e-02f, -7.86457658e-02f,
  -5.56106493e-02f, -4.40913811e-02f, -1.15680844e-02f, 7.21886083e-02f, 4.73095141e-02f, 7.72598386e-02f, 3.57833989e-02f, 7.80285671e-02f, -6.19792715e-02f, -5.74286617e-02f,
  1.05599519e-02f, -1.18270971e-01f, 5.27093234e-03f, -1.51804299e-03f, -4.30261306e-02f, -3.49765792e-02f, -7.69615779e-03f, -9.29884240e-03f, 2.67600100e-02f, 2.51667723e-02f,
  3.10162399e-02f, -3.30114029e-02f, -5.05451020e-03f, 5.76350875e-02f, 5.02690300e-02f, -2.82283202e-02f, 3.11932825e-02f, 6.97140768e-02f, 6.46303892e-02f, 6.44838810e-02f,
  -4.13216427e-02f, -2.54315048e-01f, 5.16395159e-02f, -7.81686530e-02f, -1.31316362e-02f, 1.97464731e-02f, 1.16350991e-03f, -9.68000963e-02f, -4.41160016e-02f, -3.68240625e-02f,
  5.03259245e-04f, 4.68841381e-02f, -1.08054712e-01f, -4.44787182e-02f, -8.76901764e-03f, -4.56811860e-02f, -5.41548477e-03f, -5.06708445e-03f, -3.00714057e-02f, -4.38055471e-02f,
  1.49813071e-02f, -1.51235729e-01f, -3.01980618e-02f, 6.16317615e-03f, -2.27976646e-02f, -1.70757473e-02f, -6.02002209e-03f, -1.01980440e-01f, -1.11473352e-02f, -9.47055221e-02f,
  -4.54743326e-01f, 4.06236500e-01f, -8.26152563e-02f, -1.33971661e-01f, -1.20918779e-02f, -5.20560481e-02f, -3.73123623e-02f, 5.20782836e-04f, -1.21271670e-01f, 2.46366173e-01f,
  -8.50028247e-02f, -1.14266209e-01f, 1.57454550e-01f, 8.67334902e-02f, -1.16672486e-01f, 2.94307005e-02f, -3.41664627e-02f, -1.04781501e-01f, -5.77379949e-02f, -1.85782999e-01f,
  -1.98189750e-01f, -2.71442458e-02f, -2.07838818e-01f, 6.44072816e-02f, -3.32746580e-02f, -6.61741942e-02f, -2.95733400e-02f, 1.49572920e-03f, -3.27309519e-02f, -2.60595791e-02f,
  -4.34391089e-02f, -3.22098657e-02f, -5.93922660e-02f, -5.78525960e-02f, -7.92835951e-02f, -1.05107486e-01f, 7.11652860e-02f, -6.43781796e-02f, -9.83997658e-02f, -1.21548876e-01f,
  -6.40577376e-02f, -6.49498925e-02f, 7.29750544e-02f, -4.88137715e-02f, 4.95727407e-03f, 6.73624948e-02f, 7.80224130e-02f, -4.82312366e-02f, -5.44261280e-03f, 4.09203880e-02f,
  8.61186236e-02f, 1.03090361e-01f, -2.67415866e-02f, 5.06293727e-04f, 4.70289262e-03f, -1.66856721e-02f, -2.45815869e-02f, 3.15273404e-02f, 2.74894647e-02f, -3.85567099e-02f,
  -3.41652124e-03f, -1.12166293e-02f, 8.78209528e-03f, 3.66973579e-02f, 1.09488349e-02f, -7.63393044e-02f, 9.76889282e-02f, 7.09796324e-02f, 6.12136349e-02f, 4.14156578e-02f,
  -6.78422824e-02f, -2.32533794e-02f, 5.97659051e-02f, 3.43089700e-02f, -3.62683237e-02f, -1.60194084e-01f, -7.99184889e-02f, 3.37845199e-02f, 6.29682187e-03f, -4.30751257e-02f,
  6.94806725e-02f, -1.51228467e-02f, 8.53498206e-02f, 2.23697061e-04f, -8.86006281e-02f, 4.12216261e-02f, 2.67033335e-02f, 6.98494986e-02f, -6.65928749e-03f, 8.38864297e-02f,
  5.62292859e-02f, 9.27171707e-02f, -6.30206093e-02f, -3.22345458e-02f, -9.95298941e-03f, -6.63743839e-02f, 3.86401713e-02f, -3.03893834e-02f, -4.77569960e-02f, -7.73886666e-02f,
  -1.39667988e-01f, -5.11858799e-02f, 7.44101927e-02f, -5.75988106e-02f, -1.07088843e-02f, 1.59650091e-02f, 4.86742742e-02f, -1.43561969e-02f, -2.33680010e-02f, -8.38729590e-02f,
  4.77191582e-02f, 4.22506519e-02f, 1.25517353e-01f, 5.21110892e-02f, -1.91197023e-02f, 8.69593248e-02f, 6.75601559e-03f, 1.21728711e-01f, 3.02121546e-02f, 2.73806211e-02f,
  -3.76756221e-01f, -1.30113035e-01f, -1.91385493e-01f, -2.17623055e-01f, -5.18834293e-02f, 1.49520919e-01f, 1.33111045e-01f, -1.37547061e-01f, -2.14003623e-01f, 1.03939526e-01f,
  1.66518733e-01f, -2.20075205e-01f, 1.39689565e-01f, 3.08281509e-04f, 2.15928946e-02f, 2.24319801e-01f, -1.10753931e-01f, -2.01475993e-02f, -1.50512055e-01f, -4.61457893e-02f,
  -8.37656260e-02f, 1.12399571e-01f, 4.95163277e-02f, -1.34141073e-01f, -7.82455876e-02f, -1.64203867e-01f, 6.87426627e-02f, 1.85003579e-01f, -4.71376488e-03f, 5.53380735e-02f,
  9.42905918e-02f, 4.81199585e-02f, -7.08350912e-02f, 7.19002634e-02f, 1.80184431e-02f, 3.79951261e-02f, 3.68004553e-02f, 7.62991682e-02f, 5.61463274e-03f, 6.31953850e-02f,
  2.08842326e-02f, -1.48050557e-03f, 1.11260593e-01f, 5.22950366e-02f, -3.90437804e-02f, 3.91419940e-02f, -4.74605598e-02f, -1.23865448e-01f, -5.30998893e-02f, 3.58337648e-02f,
  -4.03845534e-02f, -2.82649565e-02f, 1.35252196e-02f, 1.47704870e-01f, 6.03268035e-02f, -7.79965147e-02f, 3.66391055e-02f, 1.55536719e-02f, 7.12811276e-02f, -7.64740482e-02f,
  8.74148402e-03f, -1.89212486e-02f, 4.78808321e-02f, -6.36480078e-02f, -3.92960235e-02f, 2.92394869e-03f, -2.45180670e-02f, -3.23540205e-03f, -1.12488389e-01f, -7.95202795e-03f,
  4.01100926e-02f, -2.98097413e-02f, 9.43706259e-02f, -5.11463210e-02f, -5.68943135e-02f, 4.73687127e-02f, 7.40900785e-02f, -6.20183768e-03f, -1.95313357e-02f, -1.37719214e-01f,
  -4.41299751e-02f, -1.96580235e-02f, -4.10190746e-02f, 3.88700068e-02f, 1.69077933e-01f, -1.22159664e-02f, -8.92640948e-02f, 3.76509130e-02f, 6.46080077e-02f, 1.70371495e-02f,
  -2.69941762e-02f, -8.19035545e-02f, 3.71366404e-02f, 5.66807389e-02f, 2.40302552e-02f, -3.04576270e-02f, 2.86929142e-02f, -8.39094445e-02f, -4.61042635e-02f, -1.34791164e-02f,
  6.74650725e-03f, 4.76418734e-02f, -1.36625730e-02f, -2.67813150e-02f, -8.85913745e-02f, 4.68982587e-04f, 3.54860313e-02f, -1.28962044e-02f, -6.68079704e-02f, -2.06724051e-02f,
  -4.34227698e-02f, 7.78238177e-02f, 1.09137192e-01f, 9.95050296e-02f, 4.34766561e-02f, 6.23579845e-02f, -8.18983987e-02f, -7.45346323e-02f, -3.92756276e-02f, -2.92730350e-02f,
  -5.15910268e-01f, 5.70864752e-02f, -1.75606739e-02f, 8.09033364e-02f, -1.50564998e-01f, -1.23211173e-02f, 7.77115822e-02f, 6.09657122e-03f, -1.03141554e-01f, 1.08308226e-01f,
  1.37519822e-01f, 8.01579803e-02f, 1.41511494e-02f, 2.18552068e-01f, 1.01627856e-01f, 1.40486598e-01f, -5.99181803e-04f, 1.61363602e-01f, 6.36887029e-02f, -1.02393940e-01f,
  -7.70155489e-02f, 4.86387648e-02f, 2.11352751e-01f, -8.88688788e-02f, -7.69531280e-02f, -6.67533502e-02f, 1.13684878e-01f, 6.64901547e-03f, 2.26262227e-01f, 2.08461046e-01f,
  -6.57165125e-02f, -1.93675458e-01f, -9.31588039e-02f, -6.44302508e-03f, 7.31045306e-02f, -4.18737344e-02f, 8.22815374e-02f, 4.06469926e-02f, -4.67203110e-02f, -2.05891859e-02f,
  1.07141815e-01f, -6.87047392e-02f, 1.28170088e-01f, 6.11988977e-02f, -1.68656349e-01f, -8.31255317e-02f, 3.08608301e-02f, -6.87096920e-03f, -4.13026884e-02f, -4.91231009e-02f,
  5.32243215e-02f, 5.08374795e-02f, -3.45537998e-02f, 3.07305437e-02f, 8.72066915e-02f, -2.74248254e-02f, -1.46126105e-02f, -1.03424348e-01f, -8.78629088e-02f, -7.99567178e-02f,
  -2.87227314e-02f, 1.16206825e-01f, -2.14510653e-02f, 3.02310437e-02f, -1.10710323e-01f, 8.56645852e-02f, 9.77418870e-02f, 6.49968609e-02f, -2.74090399e-03f, -7.50049076e-04f,
  2.98170261e-02f, 2.41542011e-02f, -4.60454375e-02f, 2.59877071e-02f, 7.26772845e-02f, 5.72151206e-02f, -4.15160395e-02f, 7.25211948e-02f, -8.82953778e-03f, 1.14850504e-02f,
  1.64077654e-02f, 3.62123549e-02f, 3.44232246e-02f, 2.14555915e-02f, 1.16270473e-02f, -2.38462482e-02f, -2.91998256e-02f, -5.21484762e-02f, 6.51102662e-02f, 3.08895372e-02f,
  -1.96305424e-01f, -2.13576108e-01f, 2.98209786e-02f, 1.08594168e-02f, 1.70351565e-02f, -3.56958655e-04f, 2.54982896e-02f, -8.79848190e-03f, -7.02712610e-02f, -5.27371168e-02f,
  -1.97732318e-02f, 5.01159392e-02f, -7.11060464e-02f, -4.20526601e-02f, 4.89839800e-02f, 1.35752670e-02f, 7.73597881e-03f, -8.09393004e-02f, -2.52370592e-02f, 6.76545799e-02f,
  -1.52136227e-02f, 1.51825957e-02f, 6.97445944e-02f, 4.62437570e-02f, -4.16843705e-02f, 8.08796659e-02f, -1.37592435e-01f, 4.05773669e-02f, -5.31698838e-02f, 9.08308942e-03f,
  -1.78551450e-01f, -4.46053147e-02f, -9.59495008e-02f, 7.11621419e-02f, 1.18820695e-02f, 1.56620771e-01f, 2.64260243e-03f, 1.38837636e-01f, 1.15017965e-01f, 1.15927763e-01f,
  2.05996096e-01f, -2.55365968e-01f, -7.49366283e-02f, 1.85985088e-01f, -1.04901269e-01f, 4.12132442e-02f, 1.98614135e-01f, 1.45045161e-01f, -1.18434560e-02f, -1.23453224e-02f,
  -1.15803532e-01f, 1.90550596e-01f, -7.11577907e-02f, 5.95771819e-02f, 6.57683238e-02f, 2.93058604e-02f, -2.59776358e-02f, -2.90983707e-01f, 9.25102010e-02f, -4.60757874e-02f,
  -3.69875096e-02f, -3.38352583e-02f, -1.49829127e-02f, -1.22495510e-01f, -4.44806181e-02f, -8.21867958e-02f, -5.70201948e-02f, -1.13679640e-01f, -1.23489015e-01f, -7.07059801e-02f,
  -1.00221969e-01f, -4.31443565e-02f, 2.30033230e-02f, -7.25278333e-02f, -4.95381951e-02f, 6.34528026e-02f, 7.66311586e-02f, 9.85751003e-02f, 9.26213041e-02f, -7.37045109e-02f,
  9.11381990e-02f, -2.27089711e-02f, 1.83020934e-01f, 1.22518353e-02f, 1.14776798e-01f, 4.95332666e-02f, -2.81943846e-02f, -4.33161259e-02f, 4.11450267e-02f, 1.12258226e-01f,
  -3.62545252e-02f, -5.41202687e-02f, -4.94690947e-02f, -4.65270318e-02f, -9.84579399e-02f, -4.65311334e-02f, 4.79788668e-02f, -7.20101669e-02f, 2.87839361e-02f, 6.85977861e-02f,
  7.91341066e-02f, -5.84981628e-02f, 2.73740627e-02f, 1.94640644e-03f, 8.45942423e-02f, -3.02882176e-02f, -8.08321312e-02f, 6.97290972e-02f, 8.79517645e-02f, 4.95978929e-02f,
  -5.11331670e-02f, 8.67961266e-04f, -7.89036136e-03f, -1.28135376e-03f, -6.47142380e-02f, -2.27536317e-02f, 1.41012236e-01f, 6.77322373e-02f, 9.29643959e-03f, 6.69093728e-02f,
  5.68091832e-02f, -4.72497381e-02f, -2.12165602e-02f, 2.90696118e-02f, -8.84965509e-02f, -8.50511566e-02f, -5.03581800e-02f, 2.80591920e-02f, -5.71352318e-02f, -1.42512083e-01f,
  3.10399965e-03f, 3.09313443e-02f, -5.61793819e-02f, 3.62740718e-02f, -8.43417272e-02f, 3.31791788e-02f, 1.19265607e-02f, 8.10063034e-02f, 8.91163796e-02f, -1.53836114e-02f,
  3.35290954e-02f, 2.30429396e-02f, 1.12196188e-02f, 4.16628644e-02f, 1.02485456e-01f, 3.66850421e-02f, -6.66638389e-02f, 1.40249450e-02f, 1.09313242e-02f, 2.97432020e-02f,
  1.36263415e-01f, -8.38117227e-02f, 5.43057732e-02f, -8.36920068e-02f, 1.88307598e-01f, 5.99290729e-02f, -1.12918466e-02f, 1.67547703e-01f, 1.71332192e-02f, 8.60397294e-02f,
  5.73042780e-02f, -1.80352048e-03f, 2.42041089e-02f, -1.31155983e-01f, -1.14909269e-01f, -1.46935746e-01f, -1.07142664e-01f, -3.29976194e-02f, -1.21912971e-01f, 3.20004262e-02f,
  -1.31892143e-02f, -1.30635068e-01f, -9.41846054e-03f, -1.17167002e-02f, 1.54990554e-01f, -3.45105156e-02f, 6.77830204e-02f, 7.23495781e-02f, -7.59027675e-02f, 6.55217692e-02f,
  6.09114245e-02f, 1.19964004e-01f, 1.14379689e-01f, 2.14736909e-02f, 9.11029428e-02f, 3.38140540e-02f, 1.62885219e-01f, -4.33900319e-02f, -1.14442252e-01f, -5.72963953e-02f,
  3.44179496e-02f, -6.70674630e-03f, 1.79453660e-02f, -1.51297316e-01f, 5.88521622e-02f, 2.61177942e-02f, -1.39814033e-03f, 1.06311105e-02f, 3.57070006e-02f, -2.02529859e-02f,
  4.00863551e-02f, 6.04252107e-02f, 6.74346760e-02f, 8.15799739e-03f, 7.31952935e-02f, -7.40020052e-02f, -5.77673577e-02f, 1.81778744e-02f, 3.65467966e-02f, -2.85215676e-02f,
  1.32923856e-01f, -8.69240388e-02f, -8.72015730e-02f, -3.01741380e-02f, -5.76176941e-02f, 1.59182668e-01f, 3.53277624e-02f, 1.26153663e-01f, -2.18133144e-02f, 3.19181159e-02f,
  5.77495694e-02f, -9.26811248e-03f, 4.18102778e-02f, -1.83788449e-01f, -1.37923732e-01f, 1.33979008e-01f, -6.56784177e-02f, -9.59975868e-02f, 7.38624036e-02f, -1.48061067e-01f,
  -1.52874380e-01f, -6.52502179e-02f, 1.47154585e-01f, 7.24679083e-02f, -5.20025101e-03f, -1.39493302e-01f, -2.78363526e-02f, 1.84235215e-01f, 3.61430435e-03f, 1.04336232e-01f,
  1.38657048e-01f, 9.20724124e-02f, 8.25745687e-02f, 9.82764959e-02f, 2.92723216e-02f, 1.73826944e-02f, -4.65016626e-02f, -1.58460457e-02f, -3.15627418e-02f, 5.60766049e-02f,
  -4.83921431e-02f, 8.73081908e-02f, 2.25783549e-02f, -9.63059217e-02f, 2.09087767e-02f, -6.72145039e-02f, -8.93223733e-02f, -3.82881309e-03f, 1.86475843e-01f, 1.25086587e-02f,
  1.30657688e-01f, 5.75166121e-02f, 6.12478964e-02f, 4.76596467e-02f, 1.35931432e-01f, 1.29169561e-02f, 1.39448158e-02f, -1.82461720e-02f, -1.17750548e-01f, -3.71834859e-02f,
  -6.03177026e-02f, 3.18249613e-01f, 1.07128359e-01f, -6.32448941e-02f, -3.75695854e-01f, -1.92660898e-01f, -1.61560953e-01f, -1.22747369e-01f, 1.39325172e-01f, 1.31283447e-01f,
  -2.30665684e-01f, 1.68721408e-01f, -1.63334720e-02f, -9.87978354e-02f, -2.69009650e-01f, 1.20312572e-01f, -7.56258518e-03f, 3.39064859e-02f, 6.29472136e-02f, -5.56646101e-03f,
  -7.02863261e-02f, -2.36025110e-01f, -1.46561548e-01f, -3.73857003e-03f, -8.74546170e-02f, 9.06861871e-02f, -5.74066080e-02f, 2.26000678e-02f, -3.19510922e-02f, -9.97910947e-02f,
  -8.60699341e-02f, 6.56314343e-02f, 3.44829075e-02f, 7.16177607e-03f, 8.29806027e-04f, -3.05559058e-02f, 1.30377650e-01f, -1.26217812e-01f, 2.59031709e-02f, -3.36733423e-02f,
  1.05911814e-01f, 8.88239443e-02f, -3.59434299e-02f, -1.05355904e-02f, -7.43554765e-03f, -1.60690732e-02f, -7.76941255e-02f, -1.03886925e-01f, 4.86219414e-02f, -1.09951407e-01f,
  -1.18629903e-01f, 1.83486678e-02f, -4.14628275e-02f, 4.19182330e-02f, -6.57264590e-02f, -1.00535015e-03f, -2.92350091e-02f, -3.31175439e-02f, -4.13089767e-02f, 6.30223602e-02f,
  -5.70192784e-02f, 2.32981406e-02f, -7.37245679e-02f, -3.28343175e-02f, -1.05240941e-01f, -4.87667546e-02f, -1.72528122e-02f, -3.43885203e-03f, 5.49267717e-02f, -5.93125150e-02f,
  5.54824509e-02f, 6.90047815e-02f, 2.45783404e-02f, -3.60572450e-02f, -4.75791879e-02f, 4.85969745e-02f, 1.24579063e-02f, -3.98908556e-03f, -3.53674665e-02f, -8.61836374e-02f,
  1.74463112e-02f, -2.57730428e-02f, -4.76711169e-02f, 3.97540294e-02f, 3.03927902e-02f, -7.69081563e-02f, 1.29838794e-01f, -1.79060586e-02f, -2.10293643e-02f, -1.10828802e-02f,
  4.52124104e-02f, 3.41614366e-01f, 1.00724967e-02f, -6.67489171e-02f, 2.33248979e-01f, 6.98948419e-03f, 1.02079563e-01f, -6.30865917e-02f, 1.41443107e-02f, 4.77154963e-02f,
  -7.57351667e-02f, 2.76061371e-02f, 1.93531252e-02f, -3.62319089e-02f, -3.48258093e-02f, 1.65141113e-02f, 3.86377722e-02f, -2.48217341e-02f, -1.77043937e-02f, 7.97239244e-02f,
  -9.26111937e-02f, -7.18538016e-02f, -1.04851061e-02f, -3.00481208e-02f, -3.69779207e-02f, -5.55505697e-03f, 1.40934335e-02f, 3.83099467e-02f, 2.94080265e-02f, 1.19817115e-01f,
  1.92133754e-01f, 1.13159902e-01f, -1.21871591e-01f, 1.81351081e-01f, -3.66757251e-02f, 5.07281721e-02f, 7.03586033e-03f, 1.81023017e-01f, 1.87353536e-01f, 1.01374999e-01f,
  1.03851154e-01f, -7.74658173e-02f, -1.71384245e-01f, 2.38709986e-01f, -2.06543207e-01f, -3.51033472e-02f, 1.42115578e-01f, 1.65052935e-01f, -3.16257924e-02f, 2.39828825e-01f,
  -2.72979792e-02f, 1.05745725e-01f, -7.89332092e-02f, 8.69075879e-02f, 1.29773051e-01f, 3.86156961e-02f, -1.22600853e-01f, -1.72410876e-01f, 7.82924145e-02f, -1.25239149e-01f,
  4.64586094e-02f, 1.02360569e-01f, -8.55369493e-03f, -4.30454463e-02f, 7.29278177e-02f, -4.71904948e-02f, -4.99116941e-05f, -1.82372764e-01f, 8.00033193e-03f, 1.34230228e-02f,
  -9.76156257e-03f, 1.01909257e-01f, -2.17064656e-02f, -7.09925219e-02f, 6.22411519e-02f, 2.98732705e-02f, -2.33902242e-02f, -2.71618571e-02f, 9.38429013e-02f, -4.16808203e-02f,
  -3.22340205e-02f, 8.99790898e-02f, 1.56943761e-02f, 8.91526416e-02f, 5.61611652e-02f, 5.03843725e-02f, -5.24517186e-02f, -4.86064404e-02f, 2.42357841e-03f, 2.40361374e-02f,
  1.11440524e-01f, 3.73539142e-02f, 3.75210159e-02f, -8.12008679e-02f, 1.38729876e-02f, -3.02616842e-02f, 1.69716384e-02f, -1.75308218e-04f, -2.44445615e-02f, -2.42161080e-02f,
  4.55352440e-02f, -3.58043518e-03f, 8.20326805e-02f, 5.12809455e-02f, 7.33315870e-02f, -9.43017099e-03f, -4.02795747e-02f, -4.55537699e-02f, -2.62319669e-02f, -4.41680476e-02f,
  -7.14700446e-02f, 3.51705588e-02f, -3.78245562e-02f, 3.51774581e-02f, 7.45143462e-03f, -6.72046244e-02f, -4.14763056e-02f, -2.87755970e-02f, -7.08191982e-03f, -4.38955165e-02f,
  1.23020813e-01f, 4.37455624e-02f, 8.87923762e-02f, 2.12442596e-02f, -9.92614254e-02f, 3.21665034e-02f, -4.31369580e-02f, -2.10138354e-02f, 5.48083633e-02f, 3.06082740e-02f,
  -3.34377028e-02f, 7.99271185e-03f, 2.38660574e-02f, 6.35061935e-02f, -8.17137435e-02f, -4.50330460e-03f, 4.50556492e-03f, -2.93411571e-03f, 8.42354372e-02f, -1.34668285e-02f,
  -7.97604769e-03f, 2.60024909e-02f, -1.52888924e-01f, 9.24225338e-03f, 3.22850943e-02f, -5.85341528e-02f, -6.15584925e-02f, 1.20276734e-02f, -2.87186913e-02f, -5.82356332e-03f,
  -2.48613477e-01f, 1.90512821e-01f, -2.98421353e-01f, -9.73802209e-02f, 4.97348271e-02f, 3.16599995e-01f, 1.23630501e-01f, 1.83969960e-02f, 1.85922757e-02f, 1.67983681e-01f,
  9.11071599e-02f, 1.15300212e-02f, -4.27878201e-02f, 1.87213913e-01f, -3.13393548e-02f, -2.50024442e-02f, 4.16901968e-02f, 1.02876157e-01f, -4.14484143e-02f, 2.29943581e-02f,
  -1.23894475e-01f, 1.95477813e-01f, -2.07199872e-01f, 9.60171670e-02f, -7.63594592e-03f, -2.22594198e-02f, -1.06942989e-02f, -7.05281720e-02f, 5.46215288e-02f, 2.76746023e-02f,
  -6.10360429e-02f, -1.65494382e-01f, -1.27325714e-01f, -1.35003343e-01f, -1.16731264e-01f, -9.22964513e-02f, -3.53406183e-02f, -1.26278996e-01f, -3.44960988e-02f, 1.88447740e-02f,
  -3.77038270e-02f, 4.68957834e-02f, -1.61513723e-02f, -3.57231461e-02f, 6.43813163e-02f, 8.74774903e-03f, -3.14845070e-02f, -2.72224494e-03f, 1.01450533e-01f, -5.85818812e-02f,
  8.88999701e-02f, 2.46019065e-02f, 1.90237947e-02f, 4.50348072e-02f, -5.41380048e-03f, 9.77445170e-02f, 3.37012671e-03f, 7.35143498e-02f, 8.24559256e-02f, 6.69775456e-02f,
  8.54196548e-02f, 4.77514826e-02f, -2.47273780e-02f, -5.01680151e-02f, -2.33596973e-02f, -5.05774468e-02f, 5.48749566e-02f, -6.24937750e-03f, -5.41638546e-02f, 6.94565475e-02f,
  3.60414130e-03f, -5.11942469e-02f, 7.06862425e-03f, 1.45848999e-02f, -3.53480317e-02f, -1.01934396e-01f, -9.47350338e-02f, -1.40324952e-02f, -2.06130072e-02f, 1.39607047e-03f,
  -9.84303057e-02f, 8.50350857e-02f, -2.06070449e-02f, -7.60645494e-02f, 6.19677715e-02f, 6.76824376e-02f, 2.48266272e-02f, 6.24634884e-02f, -3.37000936e-02f, 5.07582445e-03f,
  2.31697306e-01f, -6.41832920e-03f, -9.83068347e-02f, 5.81341935e-03f, -9.94264334e-02f, -8.56696069e-02f, -6.20391406e-02f, 1.91659294e-02f, 1.99457910e-02f, -3.74991447e-02f,
  -1.13699667e-01f, -4.73558940e-02f, 1.27516359e-01f, 8.30463544e-02f, 7.81887770e-02f, 2.52223760e-03f, 2.75691338e-02f, 2.53904089e-02f, 1.41572312e-01f, -4.66708764e-02f,
  1.77782811e-02f, 8.63206312e-02f, -1.03179216e-01f, -3.58518399e-02f, 6.66918885e-03f, 1.06571347e-01f, 7.26254191e-03f, 8.66436511e-02f, 2.90686227e-02f, 4.81910072e-03f,
  3.74746732e-02f, 1.06007814e-01f, 2.23218858e-01f, 3.72046418e-02f, -9.24789608e-02f, 1.76195055e-01f, 2.33053163e-01f, -8.41653571e-02f, 1.80979103e-01f, 1.49774633e-03f,
  -1.39228515e-02f, 2.32803673e-01f, 1.62242308e-01f, 1.35159448e-01f, 1.75165609e-01f, 1.78330973e-01f, 1.07259326e-01f, 1.00948706e-01f, 3.01947221e-02f, -3.35967727e-02f,
  -9.29048508e-02f, -1.13760151e-01f, 2.49650061e-01f, -2.13799223e-01f, -8.48111361e-02f, -1.17448442e-01f, -2.46418566e-01f, -4.58375774e-02f, -2.12223396e-01f, 3.10307499e-02f,
  5.69196977e-02f, 6.90976083e-02f, 5.89089245e-02f, 1.10226376e-02f, 3.34478840e-02f, -5.24271326e-03f, -2.16355156e-02f, 9.15018246e-02f, -2.15436444e-02f, -1.42006914e-03f,
  8.02247077e-02f, 4.88239452e-02f, -1.21533722e-02f, 6.10214733e-02f, 4.02280167e-02f, -8.89928266e-02f, 8.45527649e-02f, 5.40459454e-02f, 5.08111529e-03f, 4.06318568e-02f,
  5.68361096e-02f, 5.99927604e-02f, -9.80102941e-02f, -2.75778417e-02f, 5.33800125e-02f, 1.11031286e-01f, -6.35788068e-02f, 4.18305881e-02f, -8.66296887e-02f, -6.85261041e-02f,
  -8.74448344e-02f, -1.25698954e-01f, -2.85861287e-02f, -1.06605120e-01f, 7.15067377e-03f, -2.31688172e-02f, 4.45267186e-02f, 7.29200765e-02f, 6.75523505e-02f, -5.67493355e-03f,
  -3.35085429e-02f, 1.59024615e-02f, -4.76242676e-02f, -4.58685905e-02f, -1.11108059e-02f, 6.72781691e-02f, 4.07659262e-02f, -1.10107928e-03f, -1.21851861e-02f, 2.66885422e-02f,
  4.27401625e-02f, 1.45206666e-02f, 2.95665134e-02f, -6.50043488e-02f, 9.72757954e-03f, -8.27856809e-02f, -9.62824896e-02f, 6.09239601e-02f, 2.98847649e-02f, 1.35189667e-02f,
  -4.59341481e-02f, -8.58458951e-02f, 4.81617078e-03f, 7.35449642e-02f, -9.15335986e-05f, -1.27485078e-02f, 6.06780201e-02f, 6.15073778e-02f, -3.54970284e-02f, -2.55352035e-02f,
  -3.48865092e-02f, 1.90989859e-02f, -8.98479819e-02f, -5.97833171e-02f, -3.59469689e-02f, 5.10770045e-02f, 2.89217122e-02f, -6.55364245e-02f, -8.26991647e-02f, -4.61463816e-02f,
  -5.28437458e-02f, 7.30620371e-03f, 1.29347751e-02f, 2.00727601e-02f, -6.99598193e-02f, 2.15956825e-04f, -1.46890935e-02f, 1.73646212e-02f, -1.21486142e-01f, -2.47941017e-02f,
  -1.05521213e-02f, -7.88177326e-02f, -8.58206078e-02f, 4.23684120e-02f, -1.75476924e-01f, 1.70769513e-01f, 1.91454276e-01f, -1.84609830e-01f, -2.07664296e-01f, 1.22912183e-01f,
  -2.16133837e-02f, -9.67087410e-03f, -5.71095161e-02f, 7.26609528e-02f, 1.86867550e-01f, -2.53943745e-02f, 2.26793423e-01f, 1.16101861e-01f, -1.69206917e-01f, 1.65596217e-01f,
  -1.29136458e-01f, 1.15690440e-01f, -3.18287760e-02f, 4.91490886e-02f, 1.90993816e-01f, -4.14604880e-02f, 2.61442721e-01f, -7.95142278e-02f, 2.20464066e-01f, 1.79713796e-04f,
  9.06514674e-02f, -1.07810400e-01f, -9.47619379e-02f, -3.53244841e-02f, 1.80251189e-02f, -1.69153865e-02f, 3.44235450e-02f, -4.25663888e-02f, -3.81562226e-02f, -1.57914668e-01f,
  -8.27816874e-03f, -1.34955551e-02f, -1.68143073e-03f, -6.78965077e-02f, -3.36899981e-02f, -6.91845343e-02f, -3.74618210e-02f, -2.91764010e-02f, -1.45508334e-01f, -5.40457619e-03f,
  -6.34473860e-02f, -1.27516493e-01f, 2.72885598e-02f, 4.56825085e-02f, -1.34889577e-02f, 4.32362072e-02f, 8.29346031e-02f, 6.14226088e-02f, 2.00364217e-02f, -6.29728846e-03f,
  -3.23821232e-02f, -4.20280173e-02f, -3.09371222e-02f, 8.78182054e-02f, 4.70027477e-02f, 1.22114699e-02f, 1.57591235e-02f, -3.20925824e-02f, 5.13397157e-04f, 5.56197464e-02f,
  2.19654366e-02f, 9.22026299e-03f, -9.50159431e-02f, -5.45403995e-02f, 2.64412910e-02f, -3.05100847e-02f, 9.77830961e-02f, 1.69692896e-02f, -1.07026231e-02f, -2.76082680e-02f,
  2.70896330e-02f, 8.07990432e-02f, 5.66950142e-02f, -1.04023190e-02f, -5.95899113e-03f, 6.08346611e-02f, -6.14847206e-02f, -3.00448779e-02f, -8.31874534e-02f, 2.30415966e-02f,
  3.05741459e-01f, 3.13429683e-01f, -3.49676386e-02f, 5.37545234e-02f, 1.90827996e-02f, -4.41619940e-02f, -6.68657050e-02f, -8.57841447e-02f, 8.91562402e-02f, -1.11412339e-01f,
  -4.11720537e-02f, -1.68534275e-02f, 1.33478135e-01f, -1.58540830e-02f, 7.33365268e-02f, 2.54691131e-02f, 1.51008680e-01f, 4.96887863e-02f, 1.12430647e-01f, 1.93387531e-02f,
  3.24328430e-02f, 1.23451345e-01f, -2.91428789e-02f, 5.79644286e-04f, 4.01267316e-03f, 6.61308616e-02f, -1.65526150e-03f, -1.14568718e-01f, 2.65049487e-02f, 3.12072206e-02f,
  -1.12519361e-01f, -2.83168465e-01f, 1.84657335e-01f, -4.74048220e-02f, 4.93231695e-03f, -2.09560730e-02f, 5.13181537e-02f, -2.00220510e-01f, -6.55730069e-03f, -1.00650094e-01f,
  4.47417460e-02f, -5.38350120e-02f, 1.38578519e-01f, -1.48092628e-01f, 3.19575191e-01f, 2.19954774e-01f, 6.06051721e-02f, -3.56712602e-02f, 2.72148959e-02f, -1.66718796e-01f,
  1.00027494e-01f, -1.28500974e-02f, 2.67910957e-01f, -2.27508545e-02f, -9.12706628e-02f, 1.22578982e-02f, 6.03209287e-02f, 5.80702834e-02f, -1.71324704e-02f, -2.23834477e-02f,
  -7.82064199e-02f, -1.07631259e-01f, -1.05620854e-01f, 1.33090559e-02f, 3.27383634e-03f, 7.71213025e-02f, 3.75919801e-04f, 1.37075990e-01f, 1.14518628e-01f, 4.91899215e-02f,
  8.41423795e-02f, -1.23197092e-02f, -3.82286757e-02f, 3.34828272e-02f, -1.09462380e-01f, -5.41583337e-02f, -8.19342136e-02f, -1.17432281e-01f, 3.23601142e-02f, -1.44227818e-02f,
  -3.05747427e-02f, 1.05406530e-02f, -1.84803996e-02f, -5.83495945e-02f, 1.05096765e-01f, 4.05588606e-03f, 1.46272600e-01f, 9.51857790e-02f, -6.27831519e-02f, 3.63952182e-02f,
  7.16634765e-02f, 8.18370134e-02f, 3.47111151e-02f, -4.29671220e-02f, -1.35460660e-01f, -2.59002186e-02f, -1.17819041e-01f, -2.62159258e-02f, -7.93894008e-02f, 7.86734298e-02f,
  2.57162154e-02f, -1.22493334e-01f, -6.08488321e-02f, -6.86105639e-02f, 8.91470071e-03f, -7.01228455e-02f, -1.49640283e-02f, -1.29551351e-01f, -2.29085293e-02f, 2.19676420e-02f,
  1.77363437e-02f, 3.92669365e-02f, -6.77539483e-02f, 3.04967705e-02f, 1.12908192e-01f, 2.40635183e-02f, -8.36917106e-03f, -1.58165425e-01f, 1.67682637e-02f, 1.32899731e-01f,
  -1.16818115e-01f, -1.44698009e-01f, 4.35038544e-02f, -8.97593722e-02f, 1.53537225e-02f, -4.16106544e-02f, 1.97926834e-01f, 8.42215046e-02f, 1.67458951e-02f, 2.03940794e-02f,
  5.00353910e-02f, -7.91582093e-02f, -1.86077971e-02f, -4.45472971e-02f, 1.95161961e-02f, 2.76021920e-02f, 2.89233550e-02f, 7.67121138e-03f, 8.58332682e-03f, -1.14380501e-01f,
  2.57222019e-02f, 1.47635192e-01f, -2.17913054e-02f, 2.85262596e-02f, 2.26550866e-02f, -8.96142647e-02f, -1.58026125e-02f, 3.03251501e-02f, 3.78895178e-03f, 9.97401103e-02f,
  4.42556113e-01f, 1.14985302e-01f, 6.33435175e-02f, 2.43734688e-01f, -6.12709252e-03f, -1.20465711e-01f, -5.21233678e-02f, 1.44983530e-01f, 2.71142125e-01f, 6.85960352e-02f,
  -2.21394807e-01f, 8.37987810e-02f, -6.55032545e-02f, -1.03213809e-01f, -2.10908562e-01f, -5.11084795e-02f, -1.19472481e-02f, 6.67723864e-02f, 2.20693275e-01f, 1.19053759e-01f,
  2.13498008e-02f, -4.30188701e-02f, -1.07227325e-01f, -7.32165724e-02f, 1.76615044e-02f, 4.68412368e-03f, -2.58146256e-01f, -1.10607684e-01f, -2.65228242e-01f, -2.68888801e-01f,
  -6.91025406e-02f, 1.08074673e-01f, -1.34257078e-02f, -2.10323017e-02f, -2.18161251e-02f, -3.42565551e-02f, -8.09504464e-02f, -1.54752046e-01f, -8.52460414e-02f, -5.58571257e-02f,
  7.15230927e-02f, -9.20926705e-02f, -1.35092449e-03f, -3.08374353e-02f, 4.59644906e-02f, -6.53607538e-04f, 1.39008500e-02f, 1.35622546e-02f, -2.73582246e-02f, 8.56302530e-02f,
  7.38922730e-02f, 4.73084897e-02f, 6.04909770e-02f, 2.86770910e-02f, 1.37378544e-01f, 1.33129815e-02f, 2.26949509e-02f, -6.29197583e-02f, -6.55069156e-03f, 7.31145218e-02f,
  1.99687313e-02f, -2.66867820e-02f, -1.01345554e-01f, 4.91411574e-02f, 3.03935967e-02f, 3.94015312e-02f, 9.55830365e-02f, -1.04774974e-01f, -7.12386295e-02f, -1.55376634e-02f,
  -3.15416697e-03f, 6.66027889e-02f, -1.92412622e-02f, -2.48950142e-02f, 1.10196853e-02f, 1.19504765e-01f, -2.29438711e-02f, -1.05857916e-01f, 5.69928810e-02f, -1.42595004e-02f,
  2.14033294e-02f, -8.64207372e-02f, 3.69641595e-02f, -4.92852050e-05f, -5.06590791e-02f, -6.31413758e-02f, -2.73257978e-02f, -4.65086363e-02f, -1.73879266e-02f, -5.31932414e-02f,
  6.62153289e-02f, 2.19487175e-02f, 3.29718217e-02f, -5.82652502e-02f, 3.09418608e-02f, 7.14287162e-02f, -3.75661552e-02f, 6.80514574e-02f, 2.30325945e-02f, 4.71817926e-02f,
  6.45218566e-02f, -2.38702744e-02f, 5.35469502e-02f, -3.48022096e-02f, -1.82960145e-02f, 9.16659236e-02f, -1.28371373e-01f, 3.89275812e-02f, 2.93817129e-02f, 5.88480607e-02f,
  -5.59919626e-02f, 5.67054600e-02f, -3.94269489e-02f, -5.95621653e-02f, 1.60122946e-01f, -8.22282881e-02f, 1.13120191e-02f, -2.29392736e-03f, -7.03787133e-02f, -3.39841619e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.33723214e-02f, -1.51522771e-01f, -1.80747077e-01f, -1.23534568e-01f, 1.61911957e-02f, 1.39363751e-01f, 6.32517552e-03f, -2.71222293e-02f, -2.49798313e-01f, 1.33628264e-01f,
  1.93111524e-02f, -1.32062823e-01f, -8.11685026e-02f, 5.53968884e-02f, -4.65735085e-02f, -1.92979649e-01f, 8.01519752e-02f, -3.13531868e-02f, -1.27785429e-01f, 2.35222116e-01f,
  -4.68883030e-02f, 1.44375786e-01f, -1.84541252e-02f, 1.60497203e-01f, 9.82254669e-02f, 2.32768059e-02f, 2.46668532e-01f, 7.56475329e-02f, 2.59044886e-01f, -1.45491445e-02f,
  1.00647256e-01f, -1.45571399e-02f, -1.04138320e-02f, -4.51057665e-02f, 1.62863478e-01f, 1.83649570e-01f, 1.32024258e-01f, -5.50230555e-02f, -9.08423739e-04f, 1.09784929e-02f,
  9.69415531e-03f, 7.55493902e-03f, -1.15081474e-01f, -9.41297878e-03f, 2.14711279e-02f, 4.52058129e-02f, 2.53404379e-02f, -4.45891693e-02f, 7.94302523e-02f, 4.86599952e-02f,
  -3.77961174e-02f, -3.85385891e-03f, -2.83385180e-02f, -4.46966030e-02f, -5.56913428e-02f, 1.24580124e-02f, 1.32902339e-01f, 1.73217103e-01f, -3.74791436e-02f, -2.01635621e-03f,
  1.59733966e-01f, 1.89911481e-02f, 6.38809428e-02f, -4.62630466e-02f, -1.54872076e-03f, 1.08969910e-02f, -6.23979233e-02f, 2.54936349e-02f, -4.25541624e-02f, 1.30314916e-01f,
  1.52909616e-02f, 2.94437539e-02f, 7.27130249e-02f, 8.58454406e-02f, 3.45829614e-02f, -3.73836905e-02f, -4.95347455e-02f, 1.36198057e-02f, 3.85179408e-02f, -8.20450038e-02f,
  -5.49952686e-02f, 8.25726688e-02f, 9.36131403e-02f, 5.19173704e-02f, 6.96505187e-03f, 1.19301818e-01f, 2.57253321e-03f, 5.10918163e-02f, -2.88880803e-02f, -9.73040313e-02f,
  1.37981474e-01f, 7.43714124e-02f, -9.53276816e-04f, -8.40530172e-02f, -2.43218895e-02f, 1.11880369e-01f, -7.30113164e-02f, -7.42878988e-02f, 2.16874424e-02f, 7.81615749e-02f,
  2.43822768e-01f, -5.92843331e-02f, -5.37508950e-02f, 8.87458250e-02f, -5.01973331e-02f, 1.03356622e-01f, 1.82834826e-02f, -7.43155833e-03f, 6.96745515e-02f, 1.11255348e-01f,
  6.27110004e-02f, 1.27378643e-01f, -1.17723592e-01f, -2.03287348e-01f, -5.79595193e-03f, 9.44661498e-02f, 7.41361454e-02f, 1.23737745e-01f, -8.26577321e-02f, -8.51536635e-03f,
  -3.83847535e-01f, 1.36731863e-01f, -1.21850558e-01f, 1.92643031e-01f, -4.59781379e-01f, 9.08260494e-02f, 3.96204591e-01f, -1.32498771e-01f, 7.20722675e-02f, 4.09285754e-01f,
  1.86473757e-01f, -8.96705836e-02f, 1.90255433e-01f, 3.15988570e-01f, -1.78643018e-01f, 3.30179900e-01f, 2.74756014e-01f, 2.16964319e-01f, -9.18838009e-02f, 5.77873737e-02f,
  -1.06754906e-01f, 8.39240849e-02f, 1.88112840e-01f, -1.71346560e-01f, -2.33254269e-01f, -2.15674385e-01f, -5.98887689e-02f, -2.33503982e-01f, -5.71951196e-02f, -2.55356491e-01f,
  -2.23886847e-01f, -1.08801432e-01f, -4.67987591e-03f, -7.33893886e-02f, 6.11925125e-03f, -7.71282762e-02f, -6.03786036e-02f, -3.15052494e-02f, -7.48726055e-02f, -1.98347867e-02f,
  3.43550891e-02f, -1.35746896e-01f, 4.18879353e-02f, -6.22509979e-03f, -8.95668268e-02f, -4.37491834e-02f, -1.21779535e-02f, 3.05707697e-02f, 6.22289889e-02f, -4.25700285e-02f,
  -6.53748661e-02f, -4.65323068e-02f, 6.21110685e-02f, 8.98741111e-02f, -6.79796264e-02f, 1.19385039e-02f, 6.31569028e-02f, -1.02027617e-01f, -5.37726060e-02f, -3.01340297e-02f,
  -5.72244637e-03f, -9.57298279e-02f, -2.94963717e-02f, -8.23590085e-02f, 7.05277314e-03f, -4.71424535e-02f, 1.47689670e-01f, 4.86991666e-02f, 6.07620738e-02f, -2.26766616e-03f,
  -4.72612865e-02f, -7.51462355e-02f, -3.84512395e-02f, 1.43078417e-01f, 1.69980470e-02f, 1.00279734e-01f, 7.68326968e-02f, -1.49651140e-01f, 4.19542603e-02f, -4.96380255e-02f,
  1.10075049e-01f, 2.82281227e-02f, -2.08463147e-02f, 6.54708594e-02f, 4.33364064e-02f, 6.61747903e-02f, 3.69979218e-02f, 5.66533394e-02f, 1.11972116e-01f, -8.53923187e-02f,
  -1.16134644e-01f, -6.03539050e-02f, 5.32996580e-02f, -8.91693085e-02f, 1.05553977e-02f, -3.56632657e-02f, 2.51685064e-02f, -4.00936343e-02f, -3.32269073e-02f, 5.00185601e-02f,
  5.64459711e-03f, 4.99329716e-02f, -1.08239613e-01f, 9.05556306e-02f, 1.63092725e-02f, 3.84298414e-02f, 1.18577741e-01f, 2.80684941e-02f, 9.07584727e-02f, 1.11201322e-02f,
  3.35742980e-02f, 2.20596464e-03f, -6.64779618e-02f, -1.07717840e-02f, -2.41581649e-02f, 1.74310207e-02f, -1.07479908e-01f, -3.29224169e-02f, -1.62524775e-01f, 3.37142088e-02f,
  -3.32035989e-01f, 5.19671798e-01f, 4.64108475e-02f, 9.02151093e-02f, -9.49327927e-03f, 2.80007422e-01f, 1.87448755e-01f, 1.20684862e-01f, -1.32478639e-01f, 1.65495396e-01f,
  8.92981887e-02f, 8.09301212e-02f, 6.95946962e-02f, 2.83173531e-01f, -1.36062980e-01f, 8.67737457e-02f, 6.53343424e-02f, 1.07500680e-01f, -1.01310901e-01f, -3.06974398e-03f,
  -7.54632652e-02f, 6.11001402e-02f, 3.84862572e-02f, -1.45537451e-01f, -5.55236749e-02f, -1.86766922e-01f, -1.41620114e-01f, -2.47764945e-01f, 8.99808556e-02f, 6.21182360e-02f,
  1.18847005e-01f, 4.85674329e-02f, 4.42386828e-02f, 4.76403534e-03f, 4.85064238e-02f, -9.61851254e-02f, 1.59673840e-02f, -9.20448676e-02f, -4.32329103e-02f, 4.54039797e-02f,
  8.39913785e-02f, 1.93466013e-03f, 1.57610521e-01f, -1.17609352e-01f, -5.48378937e-02f, 1.69051550e-02f, 1.62261456e-01f, 8.43515992e-02f, 4.11638841e-02f, 6.17071334e-03f,
  8.22920278e-02f, -7.41021475e-03f, -1.12507083e-01f, 1.00570749e-02f, -3.71408393e-03f, -1.54455118e-02f, 2.91967820e-02f, -5.62500432e-02f, 1.60400718e-01f, -2.12436542e-03f,
  -5.70483804e-02f, -3.36570442e-02f, 1.08404495e-01f, 9.87382792e-03f, -1.28753856e-01f, -1.46476775e-01f, -9.83451530e-02f, 5.70699982e-02f, -8.60251039e-02f, -1.12577274e-01f,
  2.87062041e-02f, 6.01402782e-02f, -7.58085176e-02f, 9.09545943e-02f, 6.56110868e-02f, -3.59416334e-03f, -8.39774907e-02f, 6.59945682e-02f, -4.51398519e-04f, -1.42782331e-02f,
  -6.08496889e-02f, -6.40243813e-02f, 1.55633707e-02f, 3.43163311e-02f, 5.94792813e-02f, -1.84343886e-02f, -2.35250425e-02f, 4.26406339e-02f, 1.02141693e-01f, 3.73330452e-02f,
  1.61568388e-01f, 5.09752966e-02f, 4.94440459e-02f, 6.42296821e-02f, -5.38326576e-02f, -2.91548651e-02f, -4.31233235e-02f, -3.49723175e-02f, -2.77402382e-02f, 1.69530679e-02f,
  8.76652543e-04f, 7.07684681e-02f, -9.34603438e-03f, -3.40266004e-02f, -8.14231187e-02f, 1.36114895e-01f, 1.41052390e-02f, -6.60787448e-02f, -5.26835620e-02f, -2.57867388e-02f,
  -2.14570072e-02f, -5.95803522e-02f, -1.01547107e-01f, 1.03760790e-02f, -1.43445970e-03f, 5.23467511e-02f, -9.78702307e-02f, 1.77120101e-02f, 1.24070041e-01f, -6.18885681e-02f,
  -1.24629281e-01f, -2.42361799e-01f, 3.01283240e-01f, -6.03864007e-02f, 1.88447032e-02f, -7.32865036e-02f, 1.58127055e-01f, -2.12180197e-01f, -4.40348417e-01f, -3.39354426e-01f,
  2.72588059e-02f, 1.60261959e-01f, 3.27548653e-01f, -1.69134006e-01f, 4.12698001e-01f, 6.46286681e-02f, -1.26971200e-01f, -2.45130062e-02f, -6.35631243e-03f, 1.87794007e-02f,
  -8.62920564e-03f, -1.02947690e-01f, 3.37523669e-01f, -1.30530775e-01f, -1.54499221e-03f, -9.81995836e-02f, 2.62529086e-02f, 2.10267901e-01f, -9.79981720e-02f, 1.66277424e-01f,
  -1.21020250e-01f, -1.18138939e-01f, -6.09937087e-02f, -5.59873879e-02f, -8.24088678e-02f, -1.91475861e-02f, -2.21221391e-02f, 8.57439935e-02f, 8.96220952e-02f, 6.64038863e-03f,
  -2.64014099e-02f, -2.52687652e-03f, -1.43567428e-01f, 9.98558402e-02f, -5.28753065e-02f, -6.84389248e-02f, -2.10626237e-02f, -1.77906342e-02f, 1.27995918e-02f, 7.79115930e-02f,
  1.20394863e-01f, 4.98266593e-02f, 1.50000751e-02f, -1.11891136e-01f, 1.46482151e-03f, -1.08760744e-01f, -8.89241416e-03f, 8.76983553e-02f, -1.12379165e-02f, -2.30354313e-02f,
  2.55366322e-03f, -6.70714257e-03f, -6.28313236e-03f, -7.87664950e-02f, -6.76881406e-04f, -7.25868046e-02f, -5.86594380e-02f, 2.38172431e-02f, 6.83067366e-02f, -4.97568324e-02f,
  -1.03823170e-01f, 8.65424890e-03f, -9.89063457e-02f, 4.34040017e-02f, 4.39045345e-03f, -1.12164415e-01f, 1.62328586e-01f, -8.92063323e-03f, -1.29765660e-01f, 2.17196159e-02f,
  -1.93034168e-02f, 5.56756742e-02f, -2.24969629e-02f, -6.06657267e-02f, -2.04479154e-02f, 1.09751828e-01f, -1.00463629e-02f, -6.56213239e-02f, 7.84256533e-02f, 1.54911727e-01f,
  -1.60430148e-01f, -1.06255963e-01f, -1.04228131e-01f, -6.44898787e-02f, -4.12181765e-02f, -7.99777731e-02f, -2.37248354e-02f, -1.20529354e-01f, -2.98282150e-02f, 1.13647394e-02f,
  -5.14611118e-02f, -1.97488666e-02f, -6.16585203e-02f, -6.16062135e-02f, 6.39613569e-02f, -1.14549242e-01f, 9.54078659e-02f, -1.11933991e-01f, 1.72192324e-02f, -1.11423753e-01f,
  -3.64025012e-02f, -1.41872978e-02f, 5.56044653e-02f, -7.44048879e-02f, -3.96436676e-02f, 4.19347547e-02f, -6.76784245e-03f, -6.78439736e-02f, 1.45139843e-01f, -5.52695952e-02f,
  3.31798419e-02f, -1.85622230e-01f, 9.06949956e-03f, 3.05940449e-01f, -1.47231501e-02f, -2.94163585e-01f, -2.78477043e-01f, 1.86454251e-01f, -1.10915199e-01f, -1.19001634e-01f,
  6.76147044e-02f, 2.06328798e-02f, -2.16577530e-01f, 2.28589371e-01f, 3.93199831e-01f, -2.24663481e-01f, 3.35340679e-01f, 4.30496261e-02f, 5.62820397e-02f, 1.38338402e-01f,
  2.41973504e-01f, 2.89570421e-01f, 2.86290318e-01f, 3.44284594e-01f, -1.14132818e-02f, 1.63625762e-01f, 2.67871588e-01f, 2.71153282e-02f, 3.31889987e-01f, 1.36667356e-01f,
  6.01715557e-02f, 2.87964512e-02f, -9.23793390e-02f, -6.76461160e-02f, 8.37479904e-02f, -2.77246833e-02f, -3.79186571e-02f, 1.45684555e-01f, 7.64588788e-02f, 1.36459190e-02f,
  5.90453297e-02f, 3.15172449e-02f, 1.30801842e-01f, 4.56235632e-02f, 6.49639871e-03f, -1.67278554e-02f, -3.71827036e-02f, 1.64646860e-02f, -6.15067687e-03f, 2.46316493e-02f,
  -9.26625356e-02f, -8.42737556e-02f, -3.52899209e-02f, 5.30057438e-02f, 1.34923369e-01f, -9.53571126e-03f, -6.52523115e-02f, -1.67958364e-02f, -7.52439201e-02f, 2.76949815e-02f,
  8.42438638e-02f, -1.50376752e-01f, -2.01663733e-01f, -1.12922922e-01f, 5.37594073e-02f, 8.46402496e-02f, 9.02529955e-02f, 3.20363641e-02f, -4.23695669e-02f, 1.03524156e-01f,
  7.35768303e-02f, 4.04728092e-02f, -5.49333299e-06f, -9.52250287e-02f, 8.48417450e-03f, 5.80177531e-02f, -5.34677552e-03f, 2.38237791e-02f, 6.25071451e-02f, -4.72807419e-03f,
  2.70320382e-02f, 7.18912855e-03f, 1.56106697e-02f, 8.12313557e-02f, 6.07037768e-02f, 3.35195735e-02f, -5.22907525e-02f, 7.31738582e-02f, -5.29224426e-02f, -4.01642865e-05f,
  4.45583723e-02f, 1.29044965e-01f, 5.51441610e-02f, 9.04135779e-02f, 1.28479246e-02f, 3.69452164e-02f, 6.25307634e-02f, 2.11607844e-01f, 8.20611566e-02f, 2.48037130e-02f,
  1.91278592e-01f, -4.16241437e-02f, -1.70207601e-02f, 9.67336446e-02f, 4.75923233e-02f, 7.77799031e-03f, 3.70914117e-02f, 1.19460449e-01f, 7.29155391e-02f, 9.54221413e-02f,
  6.84435666e-02f, -3.63692455e-02f, 1.28466617e-02f, -2.55825687e-02f, 1.14260010e-01f, -6.33080304e-02f, -1.01975620e-01f, -9.09864455e-02f, 5.29873222e-02f, 6.46443963e-02f,
  -1.40814036e-01f, 2.16351748e-01f, 1.31633833e-01f, -1.36395231e-01f, 1.09470867e-01f, -1.42427400e-01f, -6.89300820e-02f, 2.05467597e-01f, 8.09845924e-02f, 1.11631729e-01f,
  5.88460788e-02f, -3.57997492e-02f, 1.42653957e-01f, -1.76245049e-02f, -2.43489489e-01f, -1.15650691e-01f, -3.81191462e-01f, -2.51006842e-01f, -6.83076829e-02f, -1.77177355e-01f,
  -8.08283985e-02f, -1.90529883e-01f, -2.09211987e-02f, -1.93047859e-02f, -5.16905859e-02f, 9.50416923e-02f, -1.55836076e-01f, 8.62696692e-02f, -1.60319254e-01f, -2.48485859e-02f,
  1.46889076e-01f, 1.96268409e-01f, 1.11836769e-01f, 8.61396864e-02f, 1.39446883e-02f, -6.15785979e-02f, -5.28455339e-02f, -1.17483763e-02f, -1.39252201e-03f, -5.56799173e-02f,
  7.03979805e-02f, -5.12574390e-02f, -1.86155066e-02f, 5.60000241e-02f, 8.55333433e-02f, -2.72485288e-03f, 1.02723300e-01f, 7.40514621e-02f, 8.02456588e-02f, -3.81425284e-02f,
  -6.65143430e-02f, 1.03655078e-01f, -9.02692750e-02f, -4.76712501e-03f, -2.19457373e-02f, 1.29372388e-01f, -1.37356862e-01f, -2.07543224e-01f, -1.29687088e-02f, -4.69142646e-02f,
  -4.98446487e-02f, -1.19165204e-01f, -1.28766716e-01f, 8.24966505e-02f, -3.03488821e-02f, 4.57804091e-02f, -5.82376793e-02f, -3.92967388e-02f, -8.55762139e-03f, 7.15928748e-02f,
  3.06589268e-02f, 1.01739235e-01f, 2.18341481e-02f, -1.38800442e-01f, -6.99636191e-02f, 3.23795117e-02f, -5.82221486e-02f, 4.39255834e-02f, -5.55100814e-02f, -1.16103582e-01f,
  2.16850750e-02f, -5.20276576e-02f, -4.74646538e-02f, -2.58450862e-02f, 3.81977707e-02f, 2.04399717e-03f, -5.93362493e-05f, -4.81764524e-04f, 6.50320277e-02f, -7.68431276e-02f,
  -3.62543389e-02f, -9.60251838e-02f, 1.85211092e-01f, 1.31034732e-01f, -2.68780976e-03f, -4.53579649e-02f, -3.46981250e-02f, -9.56054628e-02f, 4.44767103e-02f, -4.41863686e-02f,
  -4.59845737e-02f, 2.80600768e-02f, -6.50176033e-02f, -6.50955811e-02f, 5.14954189e-03f, 1.66907869e-02f, 8.99215601e-03f, 3.01288888e-02f, 2.30571702e-02f, -9.68197733e-02f,
  -3.97255383e-02f, -4.20662723e-02f, 3.19953710e-02f, 8.11042497e-04f, -8.91839191e-02f, 2.05100942e-02f, -2.78927758e-02f, 2.24417020e-02f, -9.06753838e-02f, -3.96105833e-02f,
  -3.12017202e-01f, 3.58408839e-01f, 2.77624488e-01f, -1.52144253e-01f, -1.46924367e-03f, -8.66470262e-02f, -1.07383341e-01f, 1.38263538e-01f, 1.44676387e-01f, 2.29928896e-01f,
  1.04004726e-01f, 1.30797952e-01f, 8.08944702e-02f, -2.10610628e-02f, -2.91869581e-01f, -7.32767358e-02f, -2.21553206e-01f, -1.35128330e-02f, -5.02116680e-02f, -2.07492843e-01f,
  -5.89930899e-02f, -2.16131091e-01f, -6.16604201e-02f, -3.09281107e-02f, 5.67692928e-02f, 1.17604874e-01f, -1.88825667e-01f, 7.15784729e-02f, -3.19190882e-02f, 7.39207342e-02f,
  -1.43373027e-01f, 6.72637895e-02f, 6.44051656e-02f, 1.27524853e-01f, -4.31381464e-02f, -1.42223192e-02f, 2.57484782e-02f, -3.64341401e-02f, -2.51147952e-02f, 4.75021265e-02f,
  7.88564086e-02f, 1.00929104e-01f, -1.21986801e-02f, 7.29490891e-02f, 7.15732947e-02f, 1.25228599e-01f, -2.09453329e-02f, -3.50594223e-02f, 1.33774608e-01f, 1.50414735e-01f,
  -2.68193241e-03f, 1.41776323e-01f, -7.29716793e-02f, -3.91275398e-02f, 1.87396556e-02f, 1.01788692e-01f, -4.56869751e-02f, -5.42729981e-02f, 1.80104803e-02f, 2.31580492e-02f,
  4.21184599e-02f, -1.18218742e-01f, -8.15932378e-02f, 7.23709688e-02f, -2.60083526e-02f, 7.43626654e-02f, -2.69899461e-02f, -1.06381863e-01f, -4.93902192e-02f, -2.16944609e-02f,
  -2.72029955e-02f, -3.37528028e-02f, 3.04963533e-03f, -8.38177949e-02f, -6.48080409e-02f, 4.10994031e-02f, 4.01648367e-03f, 3.31017487e-02f, -4.05468121e-02f, -2.30789501e-02f,
  2.22710613e-02f, -1.87309813e-02f, -4.51916121e-02f, -5.91003485e-02f, 7.84893110e-02f, -1.82521511e-02f, -4.10098098e-02f, 1.16748273e-01f, 4.11761515e-02f, -1.70781180e-01f,
  -2.96990693e-01f, -2.35585511e-01f, 7.49906227e-02f, 1.49905801e-01f, 6.86176494e-02f, 5.46939373e-02f, -5.49115799e-02f, -5.07205054e-02f, -8.50333571e-02f, 3.89729738e-02f,
  -4.80457395e-02f, -9.97805269e-04f, -6.95502460e-02f, -2.80032530e-02f, 3.17212492e-02f, 1.69237275e-02f, -1.05725698e-01f, -1.21417627e-01f, -5.01346737e-02f, 4.72240709e-02f,
  -2.44040992e-02f, -2.37861369e-02f, 3.76180038e-02f, 5.90633079e-02f, -4.25282903e-02f, -4.34599370e-02f, -8.59008059e-02f, 1.10792674e-01f, -8.74653682e-02f, -6.69969618e-02f,
  -4.56971377e-01f, 1.98758036e-01f, -2.34360263e-01f, -5.51483221e-02f, 3.90203185e-02f, -4.65449840e-01f, -1.16375946e-01f, -7.38499861e-04f, 1.53597102e-01f, 2.61838257e-01f,
  3.97749580e-02f, 1.32752180e-01f, 1.39607430e-01f, -5.18586263e-02f, -3.58373791e-01f, 2.96332892e-02f, -3.19924623e-01f, -7.47924000e-02f, -3.29662114e-02f, -4.31788266e-02f,
  -6.46485090e-02f, 9.45544764e-02f, -1.32564828e-01f, 1.27188236e-01f, -1.71035796e-01f, 5.46744419e-03f, 4.33478542e-02f, 1.74897611e-01f, -2.39242539e-01f, 4.22015600e-02f,
  -1.43918440e-01f, 2.05280632e-01f, 2.13135779e-02f, -2.79837335e-03f, -1.81252569e-01f, -7.85453916e-02f, -7.08427280e-02f, 3.57767902e-02f, 5.83467148e-02f, -7.10119754e-02f,
  1.04537241e-01f, -3.77474278e-02f, -1.71023160e-02f, 8.14156383e-02f, -2.18082219e-03f, -1.75982770e-02f, -1.27412193e-02f, -1.35860279e-01f, 3.62819135e-02f, -6.79632798e-02f,
  -5.58211990e-02f, -1.98922735e-02f, -1.48751080e-01f, 3.75259598e-03f, -9.22029242e-02f, 3.71048525e-02f, -8.02881122e-02f, -9.31734964e-02f, -7.76461288e-02f, -8.06593075e-02f,
  -8.38150159e-02f, -7.76882023e-02f, 1.06382020e-01f, -1.04439352e-02f, 9.78682190e-03f, 4.83578420e-04f, 1.31634455e-02f, 7.28904903e-02f, 3.99885960e-02f, -6.34583598e-03f,
  -5.69140688e-02f, 3.19880024e-02f, 1.68713108e-02f, -8.76210481e-02f, -9.16725397e-02f, 3.03943101e-02f, 1.76357422e-02f, 1.69696677e-02f, -1.61994889e-01f, -2.20170524e-02f,
  1.53435558e-01f, -2.20695958e-02f, 2.04497427e-02f, -1.11630186e-01f, -4.50982898e-02f, -3.52675505e-02f, -1.03446208e-01f, -7.92489853e-03f, 1.97896548e-02f, -5.19046187e-02f,
  -2.44913250e-01f, 6.21742941e-02f, 2.60909032e-02f, 3.30228247e-02f, -4.62016985e-02f, -1.54275764e-02f, 2.89671663e-02f, -9.54473913e-02f, -2.40894370e-02f, 1.18039725e-02f,
  1.45240789e-02f, 7.73282647e-02f, -1.61891147e-01f, 3.79755683e-02f, -7.76640475e-02f, -1.71303493e-03f, 4.55888361e-02f, -8.78390390e-03f, -3.55757736e-02f, -3.85413021e-02f,
  1.22090168e-02f, 8.35769065e-03f, 2.33981796e-02f, 1.58931352e-02f, -1.76541097e-02f, -1.80950612e-02f, 3.73557322e-02f, 3.56670134e-02f, -2.62209047e-02f, -1.95312761e-02f,
  -3.90001714e-01f, 2.82870829e-01f, 1.64453447e-01f, -2.22044498e-01f, 3.82667258e-02f, -1.22193694e-01f, -6.72661141e-02f, 1.71857979e-02f, 8.32813978e-03f, 4.84048277e-02f,
  -1.92847252e-02f, 4.33134548e-02f, 2.18870461e-01f, -8.42135251e-02f, -1.46227524e-01f, 4.14380804e-02f, -1.33478835e-01f, -1.56533316e-01f, -2.56776996e-02f, -1.52827337e-01f,
  2.43949238e-03f, -1.35445550e-01f, -7.65905306e-02f, 7.36075193e-02f, -7.88796321e-02f, -6.22862317e-02f, -1.95615157e-01f, 1.34642467e-01f, -8.05833265e-02f, 5.86277395e-02f,
  -2.77740419e-01f, -1.27719179e-01f, -1.22414678e-01f, -1.14429118e-02f, -1.27649531e-01f, -9.06461105e-02f, -1.79727450e-02f, -7.40270391e-02f, -5.21401465e-02f, 2.42301635e-03f,
  -1.13477353e-02f, -7.01146200e-02f, 5.74549995e-02f, 5.00278659e-02f, -3.85950841e-02f, 3.13007981e-02f, 6.83293119e-02f, 2.15489529e-02f, 1.80269741e-02f, 9.04228836e-02f,
  1.30300388e-01f, 1.20791737e-02f, -1.16139203e-01f, -5.63311465e-02f, -4.97547276e-02f, -6.34510862e-03f, 1.70706250e-02f, -4.80778981e-03f, -2.91736145e-02f, -2.18744446e-02f,
  -3.21069807e-02f, -4.59113270e-02f, 1.25858188e-02f, -2.16636416e-02f, 1.50554441e-02f, 1.18185319e-01f, 5.34289218e-02f, 1.22848805e-03f, 5.16063720e-03f, -8.36862549e-02f,
  -8.62892419e-02f, -1.00825928e-01f, -4.26370092e-02f, -8.21447596e-02f, 6.33988855e-03f, 5.82315363e-02f, -6.58756867e-02f, -3.08794044e-02f, 3.81865017e-02f, -9.33988690e-02f,
  -3.13803107e-02f, -3.98408584e-02f, -2.33794074e-03f, -2.28581876e-02f, -3.55150811e-02f, 3.13307997e-03f, 4.24426608e-02f, 6.65968880e-02f, -1.53743010e-02f, -5.03203049e-02f,
  -4.16705966e-01f, -2.18095586e-01f, -2.13171422e-01f, -1.07364371e-01f, -8.15450698e-02f, -4.63276617e-02f, -4.38958108e-02f, -4.89658304e-02f, -1.90750584e-02f, -8.43879767e-03f,
  2.89134104e-02f, -9.00718048e-02f, -2.08718237e-02f, -8.56350660e-02f, 1.91430952e-02f, -4.30112854e-02f, -5.71958795e-02f, 1.00398678e-02f, -8.89297947e-02f, 3.89738865e-02f,
  4.04062681e-02f, -4.87134159e-02f, 1.50462165e-02f, -3.29654589e-02f, -1.10120639e-01f, -6.31924346e-02f, 7.01940060e-02f, 7.41045997e-02f, 4.31893533e-03f, -1.29336026e-02f,
  1.23048522e-01f, 2.98854262e-01f, 1.01876341e-01f, 1.53949067e-01f, -2.45774955e-01f, -5.80546856e-02f, -2.55030505e-02f, -7.64366016e-02f, 7.38850376e-03f, 1.30573511e-01f,
  -1.50817737e-01f, 3.90181422e-01f, -6.30962104e-02f, 5.96504211e-02f, -2.69294381e-01f, -1.99399695e-01f, -1.08953834e-01f, 1.38655320e-01f, -7.04250038e-02f, -1.91234499e-02f,
  -1.12264745e-01f, -2.53400564e-01f, -5.89633696e-02f, -1.42788559e-01f, 7.92753026e-02f, 1.42481282e-01f, -1.73899531e-01f, -7.13186488e-02f, 1.41342282e-01f, 2.34499145e-02f,
  1.12166617e-03f, 7.68471882e-02f, 1.34125099e-01f, 5.40195182e-02f, -6.05476052e-02f, -5.01949154e-02f, 3.09186969e-02f, -5.55781163e-02f, 1.96633190e-02f, 4.25310619e-02f,
  9.99168530e-02f, 5.44580668e-02f, 7.22970068e-02f, -6.00565858e-02f, 2.96536013e-02f, 7.26488307e-02f, 4.58259247e-02f, -1.47043718e-02f, 7.23002404e-02f, 8.14075544e-02f,
  6.65780827e-02f, 1.19953156e-01f, -3.83615084e-02f, 1.25191599e-01f, 2.21440624e-02f, -3.34544084e-03f, 2.53901146e-02f, 1.24933617e-02f, 1.66231781e-01f, 5.50582446e-02f,
  -1.45990729e-01f, -9.49835852e-02f, -5.72627485e-02f, -5.00808470e-02f, -5.11868745e-02f, 5.52757317e-03f, 6.26908317e-02f, 2.49336939e-02f, 9.59300697e-02f, -6.01680279e-02f,
  6.44194940e-03f, 1.31911218e-01f, -5.43987565e-02f, 8.81517492e-03f, -7.81520829e-02f, 2.43063848e-02f, -9.03715566e-03f, 6.82152435e-02f, 3.55139710e-02f, 3.86332795e-02f,
  -8.18653852e-02f, -1.02567106e-01f, 8.84297937e-02f, 3.34263556e-02f, -1.86929293e-02f, 3.58268479e-03f, -2.88102292e-02f, 1.92758050e-02f, -6.61047525e-04f, -1.31242394e-01f,
  -2.38948185e-02f, -8.36450681e-02f, 7.17481598e-03f, 1.40307739e-01f, -5.20677045e-02f, -4.45375256e-02f, -9.07969773e-02f, 6.03153855e-02f, 8.51939525e-03f, -4.15234007e-02f,
  -9.35018659e-02f, 1.43024728e-01f, 3.51848118e-02f, -8.47002305e-03f, 3.59963290e-02f, -1.66741572e-02f, -3.43061499e-02f, -9.84473005e-02f, -4.87458780e-02f, 8.15179646e-02f,
  -3.41686048e-02f, -7.79153705e-02f, 1.74486209e-02f, 8.73674974e-02f, 2.76558474e-02f, -1.75183043e-02f, -3.43117006e-02f, 1.14857927e-01f, 1.09977368e-02f, 5.90731483e-03f,
  1.04614057e-01f, -1.11564964e-01f, -2.86690950e-01f, 7.67506659e-02f, 2.24642977e-02f, 1.50824413e-01f, 1.05559990e-01f, 4.60116472e-03f, -3.47460844e-02f, 8.43292922e-02f,
  3.48321021e-01f, -1.23723969e-01f, -8.04902688e-02f, 2.99316674e-01f, 1.55447736e-01f, -4.39052582e-02f, 2.20960513e-01f, 1.58137649e-01f, -2.42085401e-02f, 1.27071187e-01f,
  6.57654330e-02f, 2.80374110e-01f, -3.32330354e-02f, 1.01181507e-01f, 6.04029372e-02f, -1.06978923e-01f, 1.46554634e-01f, -1.68767780e-01f, 1.82394579e-01f, -4.23627421e-02f,
  9.18235406e-02f, 3.14124152e-02f, -1.09934986e-01f, -4.98024598e-02f, 2.03593895e-02f, -1.46964947e-02f, 5.27883358e-02f, -1.30851552e-01f, -2.13881452e-02f, -3.81460227e-02f,
  -4.67285626e-02f, -8.62642601e-02f, -4.96697277e-02f, -1.20912813e-01f, -1.68477243e-03f, -1.39578078e-02f, -2.45035123e-02f, 2.23038550e-02f, 2.46735942e-03f, -6.80726720e-03f,
  5.07974590e-04f, 2.22783047e-03f, 1.84347220e-02f, -4.32290994e-02f, -3.88174318e-03f, -7.21750930e-02f, -1.71547700e-02f, -3.81763879e-04f, -1.28898211e-02f, -7.72116706e-02f,
  -2.16131322e-02f, -5.83919622e-02f, 7.16071427e-02f, 1.16729476e-01f, -8.82905200e-02f, -1.15195047e-02f, 3.12741697e-02f, 7.09283799e-02f, -5.27017117e-02f, 1.23917334e-01f,
  6.02672622e-02f, -1.36253862e-02f, 7.33240023e-02f, 1.01774178e-01f, -6.82582054e-03f, -3.39243747e-02f, 6.65077940e-02f, -4.70935553e-02f, -7.54897250e-03f, 7.27427453e-02f,
  2.93048937e-02f, 5.21649569e-02f, 2.50840187e-02f, 1.74227450e-02f, 1.72990914e-02f, -8.11718777e-03f, -2.61558276e-02f, 3.45802382e-02f, -2.68607102e-02f, -7.92984478e-03f,
  7.19497353e-02f, -5.86604662e-02f, 5.88048287e-02f, -7.58131966e-02f, -2.78663784e-02f, 6.06261268e-02f, 9.61935893e-03f, -3.44692208e-02f, 2.67368257e-02f, -2.48603076e-02f,
  6.10963181e-02f, -3.35469842e-02f, -1.06913991e-01f, -4.24619913e-02f, -5.14728092e-02f, -3.60576957e-02f, -7.32206553e-02f, 7.70170195e-03f, 5.03971949e-02f, -3.87868285e-02f,
  3.16379890e-02f, -2.20971368e-02f, 1.20449741e-03f, -9.06806290e-02f, -4.67407480e-02f, 2.30407430e-04f, -4.53308858e-02f, 7.10832030e-02f, 4.67756763e-03f, 3.88047360e-02f,
  2.19838709e-01f, -1.99819207e-01f, 4.68823127e-02f, 3.81638557e-01f, -4.61888015e-02f, -3.14610861e-02f, 1.41030908e-01f, -8.55480060e-02f, 4.88194555e-01f, -2.23249182e-01f,
  8.99274647e-02f, -1.28148988e-01f, 2.39945520e-02f, 5.41290874e-03f, 7.42055997e-02f, 2.73079902e-01f, 1.99612036e-01f, 1.78227440e-01f, 2.47929424e-01f, 7.60995224e-02f,
  4.37425543e-03f, -7.02998340e-02f, -2.25717917e-01f, -3.99860352e-01f, -3.28007698e-01f, -1.61875755e-01f, -2.37285644e-01f, -4.23070751e-02f, -2.91829884e-01f, -5.15497252e-02f,
  9.55185518e-02f, 8.48239884e-02f, -7.53508136e-02f, 3.52026522e-02f, -3.39092687e-02f, -1.15523085e-01f, -1.56806499e-01f, -2.33332487e-03f, 1.48003235e-01f, -3.23038921e-02f,
  5.40531240e-02f, 2.24888064e-02f, 6.99107125e-02f, -2.33310107e-02f, -9.50492639e-03f, -6.74248440e-03f, 8.29862580e-02f, 2.97307260e-02f, -4.65681180e-02f, -8.15880895e-02f,
  1.74324755e-02f, 7.24800676e-02f, 1.10010974e-01f, -1.89592142e-03f, 7.56992996e-02f, 9.10777226e-02f, -2.45109592e-02f, -5.01445383e-02f, 5.88936061e-02f, -5.04460856e-02f,
  -1.18060485e-01f, 9.65441018e-03f, -1.74058124e-01f, -8.88340548e-02f, 6.56917468e-02f, 6.39511943e-02f, -7.27093313e-03f, 3.70748108e-03f, 1.47077277e-01f, 1.03676796e-01f,
  4.13205707e-03f, 1.53068686e-02f, 9.89299342e-02f, 3.31290923e-02f, -1.55540258e-02f, -6.64854571e-02f, -3.58141363e-02f, -2.83955969e-02f, 1.18624516e-01f, -1.51567832e-02f,
  -3.90725996e-04f, 1.35538489e-01f, -8.55010375e-03f, -1.05283059e-01f, -3.96923795e-02f, 5.09948619e-02f, -3.16757187e-02f, -6.01100884e-02f, 1.12087801e-01f, -3.60285002e-03f,
  1.07523918e-01f, -8.54619890e-02f, 1.88869070e-02f, 1.06097177e-01f, -1.89834908e-02f, -9.45278704e-02f, -2.60606874e-02f, -3.62838842e-02f, -1.94844394e-03f, -4.26825769e-02f,
  -5.98611012e-02f, 2.79762149e-02f, 1.10933185e-01f, 1.73832532e-02f, 2.38029305e-02f, -1.94743752e-01f, 9.14468318e-02f, 1.18890807e-01f, -1.77933574e-02f, 2.92970166e-02f,
  5.20681366e-02f, 1.25374466e-01f, -4.32128422e-02f, -8.46389085e-02f, 2.35390030e-02f, 8.30402225e-03f, -4.49230112e-02f, 4.85219769e-02f, 1.39231049e-02f, 1.10017605e-01f,
  -9.06429440e-02f, -6.54769018e-02f, -1.14430092e-01f, -7.49301910e-02f, 5.70603125e-02f, 7.04838857e-02f, -5.86896613e-02f, -1.13566928e-01f, -2.13323593e-01f, 1.51868135e-01f,
  -1.71898261e-01f, -9.01247934e-02f, -2.67383009e-01f, -1.79162294e-01f, -3.86599064e-01f, -3.69384527e-01f, -6.61289394e-02f, -3.74240577e-02f, -1.71694070e-01f, -1.82641875e-02f,
  -1.02601446e-01f, -9.63957384e-02f, -2.16073647e-01f, 1.23797335e-01f, 1.42310396e-01f, 2.35473529e-01f, 2.09568039e-01f, 3.63905355e-02f, 2.22872287e-01f, 1.50499316e-02f,
  -2.24240683e-02f, -1.94696561e-01f, 4.47436422e-02f, -1.26693631e-03f, -5.97241148e-03f, 1.42967999e-01f, 1.29348531e-01f, -5.13733886e-02f, 1.31005840e-02f, -4.16278914e-02f,
  7.70451948e-02f, 2.29074396e-02f, -8.35786909e-02f, -8.03081617e-02f, 1.05399534e-01f, -3.66104729e-02f, -5.38277961e-02f, 6.04111589e-02f, -3.62857967e-03f, -1.50545210e-01f,
  -2.04497129e-02f, 7.00310199e-03f, 8.04797336e-02f, 5.43504879e-02f, 8.22239462e-03f, -1.67283025e-02f, 7.07388893e-02f, 1.20436139e-01f, 7.88674951e-02f, 1.02641303e-02f,
  2.03201845e-02f, 9.73095894e-02f, 2.09562499e-02f, 1.53836636e-02f, -9.25478786e-02f, -3.36133130e-02f, -2.66042594e-02f, 1.84463169e-02f, -7.94275478e-03f, -5.44387512e-02f,
  1.51742427e-02f, -2.80090310e-02f, 4.42971140e-02f, 5.56111299e-02f, -1.00706867e-03f, -8.63279924e-02f, 2.73017585e-02f, 7.77258398e-03f, 1.95555706e-02f, 1.20635722e-02f,
  -3.60830724e-02f, 6.44549578e-02f, -8.23651999e-03f, 7.37838149e-02f, -2.45208591e-02f, 4.77776863e-02f, 5.80838136e-02f, -6.49664998e-02f, -4.56166547e-03f, 7.65499026e-02f,
  5.66259548e-02f, 3.99776921e-02f, -6.83779493e-02f, -3.14383358e-02f, 2.55608205e-02f, 2.04879995e-02f, -2.72570234e-02f, 1.59204006e-02f, 1.29292738e-02f, -5.36751840e-03f,
  1.10710196e-01f, 1.45063087e-01f, 1.35632023e-01f, 9.23220627e-03f, 4.82524969e-02f, -5.62298633e-02f, 2.40074638e-02f, 1.09037280e-01f, 1.19859971e-01f, 1.07795149e-01f,
  3.06754299e-02f, 8.42572898e-02f, -5.24909422e-02f, 8.93223973e-04f, 1.28156453e-01f, 3.92865203e-02f, 3.43325362e-02f, 4.15552258e-02f, 6.12318218e-02f, 7.50793740e-02f,
  5.94184585e-02f, -1.86092839e-01f, -2.06469670e-01f, -1.14724375e-01f, -7.14406520e-02f, -3.49266946e-01f, -3.04168075e-01f, -2.18163326e-01f, 5.78827709e-02f, -1.19863778e-01f,
  -1.59308329e-01f, 1.74360365e-01f, 1.64788529e-01f, -2.88566828e-01f, 2.70281225e-01f, 3.35360885e-01f, -2.50505239e-01f, -9.83968601e-02f, -1.00526530e-02f, -1.39699608e-01f,
  -3.27740125e-02f, -1.03386104e-01f, -3.11138853e-02f, -2.03788042e-01f, -2.52775431e-01f, -2.31748104e-01f, 5.62281385e-02f, -2.19578534e-01f, -2.32449874e-01f, -6.61415383e-02f,
  -3.33313607e-02f, 1.73219107e-02f, 9.17505380e-03f, -2.70956140e-02f, -7.54503533e-02f, -7.61892647e-02f, -1.01968348e-01f, -6.77814241e-04f, 4.53653000e-02f, -7.30370954e-02f,
  -1.90729983e-02f, 1.26694858e-01f, 3.03678438e-02f, 7.25307167e-02f, -6.35431632e-02f, -9.30062830e-02f, 1.76472049e-02f, -5.01605757e-02f, 7.13686943e-02f, -1.02343626e-01f,
  -4.09087986e-02f, 6.92285644e-03f, -5.57046756e-02f, 1.86635301e-01f, 1.18081253e-02f, -9.48187802e-03f, -5.66384383e-02f, -2.54976507e-02f, -6.97791483e-03f, 5.55258133e-02f,
  -6.80290088e-02f, -5.60394824e-02f, -4.50818725e-02f, -1.04262657e-01f, -2.07259320e-03f, 6.74072839e-03f, -2.11900822e-03f, 4.00049612e-02f, -2.61353645e-02f, -3.91423590e-02f,
  5.25167733e-02f, 1.61500778e-02f, -9.42181870e-02f, -6.50193915e-02f, -1.16364658e-01f, 1.11106515e-01f, 5.15704602e-02f, -3.87866497e-02f, -3.04601695e-02f, -9.45375115e-02f,
  1.17208771e-02f, -7.55769834e-02f, 7.34757632e-02f, 2.32178885e-02f, -1.35476828e-01f, 7.30981231e-02f, -3.38297896e-02f, 8.89466889e-03f, 1.31598730e-02f, -3.21949534e-02f,
  -1.56773953e-03f, -1.18346885e-01f, -1.41655980e-02f, 4.36622091e-02f, 1.22402951e-01f, -6.69970587e-02f, -1.04939744e-01f, -6.63814321e-02f, 9.45620425e-03f, -6.75158575e-02f,
  -1.91633299e-01f, 1.09843165e-01f, 6.18689470e-02f, -5.27886823e-02f, 8.54170322e-02f, -2.61139758e-02f, -4.19103391e-02f, -3.96473799e-03f, 4.85753827e-02f, 1.65633429e-02f,
  3.37271281e-02f, 8.91395137e-02f, 3.44872549e-02f, 8.45896602e-02f, -2.10660324e-02f, 1.15868472e-03f, 9.30698141e-02f, 3.19735333e-02f, 1.75394677e-02f, 7.22954199e-02f,
  -3.27947401e-02f, 1.35071874e-02f, -1.46672323e-01f, -7.33049586e-02f, -1.99686810e-01f, 9.99083221e-02f, 1.74888685e-01f, -1.92900255e-01f, -3.09749395e-01f, 1.99039448e-02f,
  2.94032898e-02f, -9.39566493e-02f, 2.32022420e-01f, 1.98794305e-01f, 4.99356836e-02f, 2.62451261e-01f, 9.68648493e-02f, 1.53155521e-01f, -9.97620001e-02f, 1.10666439e-01f,
  1.36886444e-02f, 2.48566642e-01f, 3.06442469e-01f, -2.25519501e-02f, -1.89442672e-02f, -1.55079782e-01f, 7.98328780e-03f, -8.71861428e-02f, -8.65621194e-02f, -1.74627509e-02f,
  6.09269217e-02f, 3.71966064e-02f, 4.19874899e-02f, 1.22213168e-02f, 3.12198661e-02f, -7.59000033e-02f, 3.80459577e-02f, -4.29390036e-02f, -5.20610474e-02f, -1.53569330e-03f,
  4.50073220e-02f, -6.60261139e-02f, 4.74674143e-02f, -8.03136826e-02f, -1.14610180e-01f, -1.29430309e-01f, -3.86062334e-03f, 1.60997994e-02f, 2.09952034e-02f, 3.22469734e-02f,
  9.59416106e-03f, 8.47595856e-02f, -6.08794466e-02f, 4.32213098e-02f, -5.22467541e-03f, 3.17747407e-02f, 2.53531542e-02f, -8.20871145e-02f, 7.34617487e-02f, -1.50040060e-01f,
  1.21673737e-02f, 2.38358695e-02f, 6.04065098e-02f, -4.16256413e-02f, -5.97602092e-02f, -1.80132315e-02f, 1.06109318e-03f, 1.08819060e-01f, -1.59351081e-01f, 7.76730478e-02f,
  6.94463309e-03f, -8.70207231e-03f, -3.12320935e-03f, -2.39826944e-02f, -1.31409779e-01f, 7.45585784e-02f, 6.97908551e-02f, -3.81852537e-02f, 1.94090530e-02f, -7.63788894e-02f,
  8.34100693e-03f, -2.03558374e-02f, -6.86508312e-04f, 7.91168883e-02f, 1.52410090e-01f, -6.42723665e-02f, -5.08742742e-02f, -2.19476148e-02f, 8.54208693e-02f, 5.38759157e-02f,
  -1.17306141e-02f, -9.68149677e-02f, -8.39344785e-02f, -8.04230291e-03f, 2.90656253e-03f, -5.64848706e-02f, -2.49467772e-02f, -8.16542655e-02f, -2.49234829e-02f, -3.91111197e-03f,
  -1.04117312e-01f, 2.33631232e-03f, -2.81017963e-02f, -2.15852354e-02f, -1.97667658e-01f, -2.01373678e-02f, 6.99882209e-02f, 2.83191577e-02f, -2.78210975e-02f, 3.30125578e-02f,
  -5.42430300e-03f, 6.54537827e-02f, -2.57074069e-02f, 9.21175480e-02f, -8.19615051e-02f, 1.00834742e-02f, -1.38596475e-01f, -4.31620665e-02f, 7.59797543e-02f, -1.44738734e-01f,
  -1.60945371e-01f, 1.06740482e-01f, -1.97724164e-01f, -1.94372386e-02f, -5.24709933e-02f, -3.52614015e-01f, -2.15183049e-01f, -3.04666348e-02f, 2.01402843e-01f, 2.00117812e-01f,
  -1.38960123e-01f, 2.13026166e-01f, 1.57688126e-01f, -1.24524876e-01f, -1.54680416e-01f, 1.24904685e-01f, -2.94209272e-01f, -8.85529071e-02f, 2.63442323e-02f, -1.93524286e-01f,
  -5.83514618e-03f, -9.44155902e-02f, -6.95779026e-02f, -7.56846145e-02f, -1.62578985e-01f, 1.25899445e-02f, -8.99583623e-02f, -4.86777984e-02f, -1.80512279e-01f, -2.08406895e-02f,
  -1.72162414e-01f, 1.30776078e-01f, 3.44813839e-02f, 1.61553803e-03f, -1.16635598e-01f, -6.10874034e-02f, -1.12331480e-01f, -2.02110559e-02f, 1.33005837e-02f, -3.40150595e-02f,
  1.24558784e-01f, -1.14885755e-01f, 3.39459814e-02f, 3.23550403e-02f, 1.59574524e-02f, 1.28715662e-02f, 6.29982874e-02f, -1.50438160e-01f, 1.58765689e-02f, 7.79277226e-03f,
  -5.55435903e-02f, 9.44107100e-02f, -2.91591752e-02f, -1.36008998e-02f, -5.84918335e-02f, 4.82147522e-02f, -9.60549116e-02f, -1.33234411e-01f, -8.46881717e-02f, -6.97882622e-02f,
  6.40502200e-02f, -4.84997295e-02f, 1.69002786e-02f, 5.87667078e-02f, -4.32092436e-02f, -6.32433966e-02f, 3.86349559e-02f, -4.98954579e-02f, 4.85455580e-02f, 6.81884438e-02f,
  -4.37755585e-02f, -1.97470095e-02f, -2.28287801e-02f, -5.00979647e-02f, -4.66703922e-02f, 1.65385976e-01f, 1.23931440e-02f, 1.25593347e-02f, -3.11890468e-02f, -2.20388360e-03f,
  7.95543939e-02f, -7.13066012e-02f, 8.51572398e-03f, -4.16299328e-02f, -5.88786677e-02f, 8.28041881e-02f, -5.26664071e-02f, 1.12086885e-01f, 4.16917279e-02f, -5.91777414e-02f,
  -2.03425452e-01f, -8.84201378e-02f, 4.66014743e-02f, 1.02253705e-02f, 7.82192871e-02f, -1.36388829e-02f, -1.60948876e-02f, -2.73077432e-02f, -2.92392187e-02f, -7.66544864e-02f,
  2.86333803e-02f, -4.41761576e-02f, -1.02472737e-01f, -1.52606759e-02f, 4.81276177e-02f, -3.54185738e-02f, 3.91507745e-02f, 3.84379714e-03f, -1.89971104e-01f, -4.00821157e-02f,
  -5.80790341e-02f, 3.21125537e-02f, 1.25979662e-01f, 1.14555053e-01f, -3.67566273e-02f, -2.31361520e-02f, -1.44350547e-02f, 5.52582070e-02f, -4.48359586e-02f, -1.00797176e-01f,
  7.01878741e-02f, 2.42245212e-01f, 1.82164967e-01f, 3.68173689e-01f, 1.05901919e-01f, 2.05452561e-01f, 2.66961813e-01f, 2.27628589e-01f, 5.62059164e-01f, 3.64184082e-02f,
  -1.60193384e-01f, 1.64536670e-01f, -1.94249243e-01f, 8.88673589e-02f, 2.24485435e-02f, 1.08834967e-01f, 2.46974707e-01f, 1.61675319e-01f, 2.88048059e-01f, 4.03442122e-02f,
  1.58668220e-01f, -7.23503977e-02f, -2.76607573e-01f, -1.63652554e-01f, -1.98357582e-01f, 3.90246278e-03f, -3.15647840e-01f, -1.15104048e-02f, -1.46159291e-01f, -4.32112329e-02f,
  -5.21298312e-02f, 1.44851103e-01f, -1.49550542e-01f, 8.80898088e-02f, 4.11098916e-03f, -2.78689731e-02f, -1.03455745e-02f, 3.39934342e-02f, 4.59476039e-02f, 1.38184689e-02f,
  2.25963984e-02f, -2.60144006e-02f, -1.46292914e-02f, -6.70985971e-03f, 2.21238993e-02f, -1.26744937e-02f, -2.24830806e-02f, -1.08838407e-02f, 2.24293228e-02f, -3.67226452e-02f,
  -8.34900141e-02f, -1.74951404e-02f, 6.61413651e-03f, 1.07832849e-01f, -2.27324869e-02f, 7.99170956e-02f, 1.34008467e-01f, 3.07335258e-02f, -3.22467461e-02f, 1.08939581e-01f,
  2.32150462e-02f, 5.59758395e-02f, -9.31565538e-02f, -3.96040678e-02f, 2.17879303e-02f, 3.93315777e-02f, 4.87614758e-02f, 3.04136239e-02f, 6.84466735e-02f, -8.99929106e-02f,
  3.95602323e-02f, 5.74071556e-02f, 2.07437053e-02f, -6.70694187e-02f, 8.06252137e-02f, 8.41090903e-02f, 5.02299704e-02f, 8.40876177e-02f, 1.36771441e-01f, -8.97239745e-02f,
  5.28608002e-02f, -2.56398395e-02f, -1.21365234e-01f, -2.03618556e-02f, -3.50524075e-02f, -2.60604136e-02f, -7.11087957e-02f, -4.69082035e-02f, -4.78385948e-03f, -2.13408303e-02f,
  1.89350829e-01f, 3.93691301e-01f, 1.00197978e-02f, -3.14911385e-03f, 3.77650931e-02f, -5.80443367e-02f, 9.69824195e-02f, 9.73518714e-02f, 2.02411667e-01f, 6.08520806e-02f,
  7.24245608e-02f, 4.67036106e-02f, 7.69445747e-02f, -6.38858089e-03f, -1.01447916e-02f, -3.25257033e-02f, 2.30140518e-02f, 1.26234904e-01f, 6.47743940e-02f, -2.93715410e-02f,
  -1.28445625e-01f, 1.66197047e-01f, 1.01315817e-02f, 3.15268636e-02f, -2.72410009e-02f, 1.55903958e-02f, 6.81713223e-02f, 4.53459248e-02f, -3.70978303e-02f, 7.09471926e-02f,
  -3.98719549e-01f, 2.63145000e-01f, -2.48920128e-01f, -1.83133423e-01f, -1.65638104e-02f, -2.25912899e-01f, -1.88043669e-01f, 1.88110471e-02f, 2.04509852e-04f, -1.81475654e-02f,
  -7.17497915e-02f, 1.84960943e-02f, 1.46551669e-01f, -1.27396673e-01f, -1.94635853e-01f, 1.55284777e-01f, -2.09748879e-01f, -1.47188574e-01f, 2.16286749e-01f, -1.66075617e-01f,
  3.87170389e-02f, -3.84032056e-02f, -8.30802545e-02f, 8.72155651e-02f, -2.00424924e-01f, 7.79801700e-03f, -1.02887392e-01f, 5.00261560e-02f, -1.74530685e-01f, 1.13606989e-01f,
  -1.18448906e-01f, -5.83934449e-02f, 1.54793297e-03f, -5.74423186e-02f, -1.86044320e-01f, -3.46339867e-02f, -1.25113785e-01f, 2.69582327e-02f, -7.17979819e-02f, -2.46860813e-02f,
  8.95282254e-02f, 5.81348911e-02f, 3.21395695e-02f, 1.54000014e-01f, 3.72663438e-02f, 2.24165358e-02f, 7.07273856e-02f, -4.17516986e-03f, 1.26751408e-03f, -2.84796469e-02f,
  -1.13403341e-02f, 1.91928577e-02f, -1.12069406e-01f, -4.50736210e-02f, 8.59153178e-03f, -7.19506443e-02f, -3.04933153e-02f, -6.91397637e-02f, -1.68163013e-02f, -8.05645883e-02f,
  -3.20355669e-02f, -7.11668730e-02f, -2.95642335e-02f, -3.44829969e-02f, 4.85544503e-02f, -2.03802809e-03f, -5.29413931e-02f, 1.19172689e-02f, -9.16056149e-03f, -4.86208834e-02f,
  9.21668112e-03f, -7.70928571e-03f, 7.67889246e-03f, -2.24027447e-02f, -1.14888034e-03f, 4.16737050e-03f, -2.54449062e-02f, 4.27074684e-03f, 5.12780510e-02f, -1.05128018e-02f,
  -6.66630315e-03f, -7.77878836e-02f, 7.91037306e-02f, 4.09514233e-02f, -1.06096221e-02f, -3.97943519e-02f, 2.76362058e-02f, 4.89768796e-02f, -8.74385610e-03f, -1.00064054e-01f,
  -2.13636398e-01f, -3.30171227e-01f, -1.43955871e-02f, -2.68843155e-02f, -7.72376209e-02f, 2.03780476e-02f, 5.00591323e-02f, -6.92252908e-03f, -1.46028578e-01f, -4.19384018e-02f,
  -8.07539374e-02f, -5.10188006e-02f, -7.04979375e-02f, 1.70327667e-02f, 9.74999217e-04f, -5.80451116e-02f, -4.47872281e-02f, 4.57084887e-02f, -1.77666709e-01f, 7.04817995e-02f,
  1.29021043e-02f, -3.46753597e-02f, -1.49605656e-02f, 4.95176576e-02f, -6.51132315e-02f, -6.83505014e-02f, -5.86349107e-02f, 7.04908744e-02f, -3.55360322e-02f, -5.72656095e-02f,
  3.00039887e-01f, -2.95225561e-01f, 7.81615302e-02f, 2.44426280e-01f, 2.04149902e-01f, -2.38393888e-01f, -1.35947419e-02f, 5.81896789e-02f, 1.64459214e-01f, -1.49872452e-01f,
  3.12911742e-03f, 2.74283513e-02f, -8.09268877e-02f, -1.06943734e-01f, 9.97648165e-02f, 4.49908450e-02f, -1.40143901e-01f, -1.17060944e-01f, 1.26723617e-01f, -3.27351168e-02f,
  9.83794779e-02f, -7.47902915e-02f, -8.53443146e-02f, -2.29610786e-01f, -1.38333082e-01f, -9.82500762e-02f, -3.11653297e-02f, -3.40994895e-02f, -8.43113512e-02f, -1.84042193e-02f,
  1.10166951e-03f, 1.14797868e-01f, -1.05719775e-01f, -4.97268839e-03f, -1.41431898e-01f, -2.64938697e-02f, -1.15167297e-01f, -1.06643299e-02f, -7.52935559e-02f, -1.66978780e-02f,
  -9.55068693e-03f, -2.75848079e-02f, 1.01150237e-02f, -2.96986029e-02f, -1.02607079e-01f, 3.59630734e-02f, 1.17909871e-01f, 7.38277333e-03f, -2.49003973e-02f, 1.37811154e-01f,
  1.96774267e-02f, 8.52375403e-02f, 1.19190529e-01f, -2.85694711e-02f, -2.57697292e-02f, 9.59805846e-02f, -4.07445692e-02f, -6.39352649e-02f, 9.40905232e-03f, -1.17301382e-03f,
  -1.10913076e-01f, -4.81512360e-02f, 1.98474880e-02f, -1.89909190e-02f, 1.52186342e-02f, 1.25991806e-01f, 3.31536084e-02f, -1.08669850e-03f, -4.71782982e-02f, 8.88444260e-02f,
  -1.25645027e-02f, -2.07456425e-02f, -8.25545788e-02f, -2.66685598e-02f, -6.83363676e-02f, 5.34216911e-02f, -3.19397002e-02f, 8.82975757e-02f, 4.67487350e-02f, 2.40742485e-03f,
  2.47460920e-02f, -4.62377965e-02f, 1.20317347e-01f, 1.00790009e-01f, -4.55226041e-02f, 1.33585576e-02f, 8.21481086e-03f, 7.17542740e-03f, 6.97673038e-02f, -1.02476276e-01f,
  -2.57772535e-01f, -2.96149075e-01f, -8.33438337e-02f, 6.81998953e-02f, -1.61444455e-01f, -3.94967347e-02f, -3.86205874e-02f, -1.75116789e-02f, -1.96715459e-01f, 3.34025617e-03f,
  -3.83303240e-02f, -4.40753885e-02f, -1.63043421e-02f, 3.36372219e-02f, -1.54581532e-01f, 1.99924968e-02f, -7.57486671e-02f, -7.60706291e-02f, -1.15164414e-01f, 2.15639714e-02f,
  -1.29907625e-02f, -1.87805644e-03f, -3.22735645e-02f, 1.13096554e-02f, 7.54068606e-03f, 5.31952493e-02f, 6.10907413e-02f, -7.97746107e-02f, -3.38831767e-02f, -1.01062190e-02f,
  3.66751194e-01f, 2.49494940e-01f, 4.72498506e-01f, 4.94961470e-01f, -1.57543316e-01f, -4.19111580e-01f, -2.07285494e-01f, 7.72925019e-02f, 8.73607025e-02f, -1.12981208e-01f,
  -6.25146404e-02f, 3.14572692e-01f, -2.75364012e-01f, 2.79870003e-01f, -2.97364108e-02f, -2.27509156e-01f, 1.10214897e-01f, 1.11587517e-01f, -7.07874820e-02f, 1.06396504e-01f,
  1.80688173e-01f, -4.89300080e-02f, 2.52297491e-01f, 2.23243870e-02f, 2.16407612e-01f, 1.86239243e-01f, 9.00019780e-02f, -8.93665627e-02f, 1.89838499e-01f, -1.91644475e-01f,
  -1.08821265e-01f, 1.05749920e-01f, 1.71866998e-01f, -6.07263437e-03f, -1.46865789e-02f, -1.28183261e-01f, 9.92377382e-03f, -1.58131123e-01f, 5.91342300e-02f, -1.68089643e-02f,
  -2.33935731e-04f, -9.45444629e-02f, 2.15857215e-02f, -3.44764702e-02f, -1.09556783e-02f, 1.80908576e-01f, 4.36558165e-02f, -3.74753512e-02f, 1.37951002e-02f, 1.08473815e-01f,
  8.81989449e-02f, 5.35976700e-03f, -8.14168528e-03f, 1.29782520e-02f, 4.62439917e-02f, -3.67328897e-02f, 6.98180497e-03f, 2.00691167e-02f, 7.73504749e-02f, 9.30465013e-02f,
  -3.84700298e-03f, 5.96817629e-03f, 6.34723082e-02f, 7.18833059e-02f, -4.69073281e-02f, -3.11714467e-02f, -1.16362283e-02f, 6.93256035e-03f, -7.22298995e-02f, -5.43952174e-02f,
  -5.52390218e-02f, 6.58083037e-02f, -7.50832865e-03f, -7.25710765e-03f, 5.25646359e-02f, 4.80060168e-02f, 2.39093024e-02f, -6.37818351e-02f, 5.94984852e-02f, 2.04650685e-01f,
  1.03205852e-01f, -1.21645950e-01f, 3.72681534e-03f, 1.60836857e-02f, -3.57617028e-02f, 5.06803347e-03f, 4.59438376e-02f, 6.21805340e-03f, 1.39020029e-02f, 2.21892223e-02f,
  -1.89252242e-01f, 9.22670811e-02f, -3.82291898e-02f, -1.42925605e-01f, -7.51462355e-02f, 5.67772798e-03f, 6.43572351e-03f, -3.44856270e-02f, 1.06922751e-02f, -1.29908901e-02f,
  -6.66803680e-03f, -1.14804367e-02f, -1.22761182e-01f, -2.04118304e-02f, -1.10369585e-02f, 6.95064887e-02f, -1.10670389e-03f, -7.28154555e-02f, -1.37016967e-01f, 1.03850635e-02f,
  2.36223172e-02f, -1.20347835e-01f, 1.57066919e-02f, 4.05104272e-02f, -1.54247610e-02f, 1.54053355e-02f, 2.78114378e-02f, 3.16831432e-02f, -2.24835258e-02f, -5.50191887e-02f,
  3.69778365e-01f, 2.88695812e-01f, 1.93972707e-01f, 2.18607858e-01f, -1.15233049e-01f, -3.65727060e-02f, 7.71681254e-04f, -1.12172253e-02f, 2.74412692e-01f, -1.43296029e-02f,
  -1.87465757e-01f, 4.26502556e-01f, -1.10775918e-01f, 2.13096455e-01f, -2.45392665e-01f, -1.51597843e-01f, 6.52920306e-02f, 1.63513020e-01f, 1.19850161e-02f, 2.08682418e-01f,
  1.15711465e-01f, -1.22846693e-01f, -1.02969132e-01f, -1.52657926e-01f, 1.49741650e-01f, 7.80371353e-02f, -2.95769513e-01f, -1.24634668e-01f, 5.46084717e-02f, -1.76998317e-01f,
  1.80228502e-02f, 3.76172885e-02f, 8.59279335e-02f, 2.76073162e-03f, -4.69858535e-02f, 4.94024418e-02f, 5.21017574e-02f, -3.82138379e-02f, -4.17403765e-02f, -2.83740629e-02f,
  6.40853569e-02f, 9.38972831e-03f, -3.29512060e-02f, -1.21904656e-01f, 7.25718290e-02f, 4.63322457e-03f, 3.95537168e-02f, 9.54288766e-02f, 2.78104190e-02f, 7.45513737e-02f,
  7.40976706e-02f, 1.26421437e-01f, -1.60488747e-02f, -1.86242834e-02f, 5.18571883e-02f, -5.78227751e-02f, 3.21989022e-02f, 4.38699313e-02f, -7.35989248e-04f, 6.94791302e-02f,
  3.28630693e-02f, 1.46455960e-02f, 1.32799884e-02f, -4.00679745e-02f, 2.18318626e-02f, -8.67779087e-03f, 1.00541480e-01f, -3.37866321e-03f, 7.49353319e-02f, -2.12255642e-02f,
  -5.13767526e-02f, 5.52818701e-02f, 2.61582769e-02f, 3.26887406e-02f, 1.07951999e-01f, 8.74372125e-02f, 2.89770346e-02f, -7.73901641e-02f, -1.02852266e-02f, 5.37147075e-02f,
  -6.87405914e-02f, -4.57424447e-02f, 2.52822228e-02f, -5.57783851e-03f, -9.86534283e-02f, 2.13634782e-02f, 3.03487889e-02f, 4.91223484e-02f, 8.89945589e-03f, -6.92090765e-02f,
  -4.18918347e-03f, -2.78959274e-02f, 3.26762497e-02f, 3.90200093e-02f, -1.63286533e-02f, 4.44710553e-02f, 6.43166304e-02f, 1.35569712e-02f, 4.46729216e-04f, -6.84543625e-02f,
  2.48293784e-02f, 4.95313369e-02f, -4.17015702e-02f, -8.08623582e-02f, -6.73285173e-03f, -4.22648527e-02f, -1.59332845e-02f, 1.46756750e-02f, -1.01218335e-01f, 2.23442372e-02f,
  2.39699632e-02f, -3.58155072e-02f, 3.28067541e-02f, -3.56593952e-02f, 7.47360513e-02f, -3.51470076e-02f, 1.45438630e-02f, 2.80221421e-02f, -3.20053995e-02f, -4.00708690e-02f,
  -4.48635608e-01f, -4.98086303e-01f, 1.24181181e-01f, -1.21676892e-01f, 2.85451800e-01f, 8.63383710e-02f, -2.64928609e-01f, 1.72451809e-02f, -2.23102033e-01f, -4.04012740e-01f,
  -1.97288513e-01f, -2.15754732e-01f, -2.33828485e-01f, 5.26589639e-02f, 2.34010905e-01f, 1.12271674e-01f, 2.75758296e-01f, 1.14562407e-01f, 2.55136877e-01f, -5.50063327e-02f,
  2.18178928e-01f, 2.44508922e-01f, 1.65738195e-01f, 3.70045006e-01f, 3.53845768e-02f, 4.09582816e-02f, -1.07940063e-01f, -8.63722339e-03f, 2.15979800e-01f, 4.08548005e-02f,
  -6.52716588e-03f, -1.54206827e-01f, 1.15767373e-02f, 5.06722815e-02f, 7.49362409e-02f, -8.36545154e-02f, -8.12886953e-02f, -8.82008020e-03f, 6.01193905e-02f, 3.83424647e-02f,
  -3.00968233e-02f, 3.79704423e-02f, 9.79145169e-02f, 4.92169932e-02f, -5.43464236e-02f, 8.86332169e-02f, -9.95820947e-03f, 3.14130150e-02f, 2.72866599e-02f, 7.82152452e-03f,
  -3.46155651e-02f, 6.31453320e-02f, -1.09114153e-02f, 3.95740122e-02f, 4.91968542e-02f, -6.94499537e-02f, 1.08067229e-01f, -2.17120945e-02f, 6.08229898e-02f, 1.04893647e-01f,
  3.89277264e-02f, 1.27938226e-01f, -6.55341670e-02f, 5.91016710e-02f, 7.82005042e-02f, -6.28493354e-02f, -3.35374996e-02f, 7.64931506e-03f, -2.05676202e-02f, -1.04432128e-01f,
  1.17254309e-01f, -1.52107865e-01f, 5.42864278e-02f, 3.20412628e-02f, -2.26701284e-03f, -7.43679255e-02f, 2.65517104e-02f, 9.19433609e-02f, 1.23680346e-01f, 7.95277506e-02f,
  -2.04115268e-02f, 5.32067120e-02f, -2.24243328e-02f, 8.44436288e-02f, 5.58753051e-02f, -1.01336010e-01f, 4.86469045e-02f, -1.52130108e-02f, -1.61719978e-01f, 3.87799293e-02f,
  -4.03321832e-01f, -2.96021432e-01f, 6.73646620e-03f, 1.34709850e-02f, 7.27377608e-02f, -4.43296321e-03f, 3.93395536e-02f, 1.09821796e-01f, -2.24470515e-02f, -2.90415213e-02f,
  -1.96157042e-02f, 1.48474444e-02f, -2.12964918e-02f, 5.29432409e-02f, 8.59143659e-02f, -2.09302623e-02f, -1.59378380e-01f, -7.49395117e-02f, -5.51901273e-02f, -1.43429674e-02f,
  -4.88150492e-02f, -3.48303579e-02f, 3.16938534e-02f, 1.34603024e-01f, 6.36843890e-02f, -1.59609661e-01f, 2.11721100e-02f, -7.19931424e-02f, 6.85582459e-02f, 1.19334303e-01f,
  4.98586008e-03f, -6.42563701e-02f, -8.47838670e-02f, 1.36421084e-01f, -1.08457536e-01f, -3.65692884e-01f, -4.20593172e-01f, 2.07134262e-02f, -8.61675516e-02f, -1.58859715e-01f,
  7.97030050e-03f, 2.57110167e-02f, 5.91316856e-02f, 1.15618236e-01f, 2.17391983e-01f, 2.16964200e-01f, 9.45406631e-02f, -1.59292519e-02f, 1.42655239e-01f, 1.03679061e-01f,
  2.17664242e-01f, 1.66641161e-01f, 3.71852100e-01f, 9.33566168e-02f, -4.44612131e-02f, 1.04085587e-01f, 1.81284979e-01f, -5.30141778e-02f, 8.49997178e-02f, 8.39829221e-02f,
  -4.63007241e-02f, 9.43420231e-02f, -6.80405572e-02f, -5.60353771e-02f, 9.56469327e-02f, -1.10056944e-01f, -5.50701469e-02f, -2.29195468e-02f, 8.58370308e-03f, -4.41937186e-02f,
  -3.10922172e-02f, 7.46812671e-02f, -1.17505984e-02f, 1.72060415e-01f, -1.45315111e-01f, -1.34369016e-01f, 1.21502660e-01f, 6.15867004e-02f, -6.31765500e-02f, 1.89402886e-02f,
  -4.52436805e-02f, -3.08896974e-02f, -7.46416003e-02f, 1.10093623e-01f, 5.98166175e-02f, 9.84467100e-03f, 2.77141808e-03f, -8.82730484e-02f, -5.02002835e-02f, 5.74875772e-02f,
  7.36600012e-02f, 5.66971349e-03f, -7.60117397e-02f, -8.41630995e-02f, -6.70616981e-03f, 3.44138891e-02f, 3.91446166e-02f, 8.55826288e-02f, 4.66877259e-02f, -9.09053236e-02f,
  -4.62069102e-02f, -1.07282035e-01f, -6.25570342e-02f, 2.62783165e-03f, 9.35778674e-03f, 6.94265738e-02f, -3.23218592e-02f, 1.76336057e-02f, -2.37949397e-02f, 3.66894677e-02f,
  7.12793320e-02f, 2.84047127e-02f, -4.08862568e-02f, 5.62383197e-02f, -7.84570053e-02f, 4.71562613e-03f, 1.29006235e-02f, 1.04615912e-02f, -3.90936509e-02f, -3.12651992e-02f,
  5.14210463e-02f, 2.85137445e-01f, -3.03228591e-02f, -1.16764784e-01f, -2.59858053e-02f, -1.57052744e-02f, -6.43060729e-02f, -2.66315993e-02f, 7.20358118e-02f, -4.08773385e-02f,
  5.51224104e-04f, 1.29277799e-02f, 4.89511117e-02f, 1.09557919e-01f, 2.41231527e-02f, -6.35063797e-02f, 1.22646779e-01f, 5.95696494e-02f, 1.86194424e-02f, 1.11917004e-01f,
  1.73721388e-02f, -9.36346874e-02f, -1.89175513e-02f, 1.48731722e-02f, -4.23383452e-02f, -5.46422834e-03f, 2.27229074e-02f, -9.27891061e-02f, 5.32490984e-02f, 6.91393986e-02f,
  2.32030064e-01f, -1.63982399e-02f, -3.08821052e-01f, -2.64238995e-02f, -6.19589575e-02f, 1.03820801e-01f, -9.17676021e-04f, -6.61025420e-02f, -1.57740906e-01f, 1.09250367e-01f,
  1.13850802e-01f, -1.51305795e-02f, -1.47685394e-01f, 2.44706586e-01f, 2.59596616e-01f, -7.25262612e-02f, 2.58147359e-01f, 5.89793287e-02f, -1.37418553e-01f, 1.24668784e-01f,
  8.04836974e-02f, 3.24355215e-01f, 1.02225104e-02f, 1.65283293e-01f, 2.16116622e-01f, -7.53080770e-02f, 2.01547474e-01f, -1.65988892e-01f, 1.93663344e-01f, 7.56267384e-02f,
  9.47614387e-02f, -3.04277316e-02f, -1.61193497e-02f, -4.73199040e-02f, 1.29853589e-02f, 8.39858428e-02f, 1.29399255e-01f, 4.59995829e-02f, -1.49783432e-01f, -9.52175036e-02f,
  3.61747257e-02f, -4.92031798e-02f, 7.21220672e-03f, -4.50938083e-02f, 2.43831463e-02f, -5.57050332e-02f, -9.73416939e-02f, -9.64296311e-02f, -5.05882911e-02f, 1.14508368e-01f,
  -9.43259969e-02f, -4.67859618e-02f, -5.44779338e-02f, -3.08286436e-02f, -6.46653250e-02f, -2.13789940e-02f, 3.42039280e-02f, 8.49048719e-02f, -1.01268347e-02f, 2.62779929e-02f,
  -2.44546812e-02f, 7.35072047e-02f, 3.56801301e-02f, 8.06744620e-02f, -3.62413675e-02f, -6.79392666e-02f, -3.35173006e-03f, -1.32802865e-02f, -5.40246591e-02f, 1.10212386e-01f,
  -4.41708639e-02f, -5.30344024e-02f, 5.88607825e-02f, 7.97198564e-02f, 1.30575985e-01f, 5.81867732e-02f, 6.33973181e-02f, -8.15268680e-02f, -1.73271611e-01f, -1.13520473e-01f,
  2.27443650e-02f, -2.35707257e-02f, 1.10649737e-02f, 3.11798919e-02f, 5.35461083e-02f, 2.33333651e-02f, -1.04055125e-02f, 7.61255175e-02f, -1.20254450e-01f, 9.13610123e-03f,
  5.09042814e-02f, 1.20964684e-01f, -4.42777351e-02f, -2.86876056e-02f, -4.92467172e-02f, 3.31287310e-02f, 1.13256089e-01f, 1.17985420e-01f, 2.96747666e-02f, -2.10247114e-02f,
  9.65290815e-02f, -6.22239187e-02f, -2.31609633e-03f, -1.90897416e-02f, -3.79873551e-02f, -6.28865585e-02f, 8.58769380e-03f, -1.06999628e-01f, 2.14114524e-02f, 5.53719886e-02f,
  -1.20312143e-02f, -6.57810867e-02f, 2.97406558e-02f, -1.52955920e-01f, -5.44495462e-03f, -1.59751289e-02f, -3.97251872e-03f, 6.89712306e-03f, 3.06147318e-02f, -2.21796967e-02f,
  -8.84023979e-02f, 2.96279066e-03f, -7.51537979e-02f, -8.68580192e-02f, 9.15405899e-02f, 4.73418795e-02f, -6.35650307e-02f, 1.07541345e-02f, -1.88609436e-01f, 7.55824745e-02f,
  4.27557826e-02f, -1.49039865e-01f, -4.39220807e-03f, -2.56096840e-01f, -2.43340477e-01f, -2.85420984e-01f, -1.10049725e-01f, -7.54983127e-02f, -1.30724534e-01f, 1.84841052e-01f,
  4.37728949e-02f, -3.61178666e-02f, -8.17789957e-02f, 8.30351859e-02f, 2.92615220e-02f, 2.46619508e-01f, 2.62254089e-01f, 1.14310786e-01f, 2.00854376e-01f, -1.70208201e-01f,
  -2.61078700e-02f, -6.99845105e-02f, 1.39364377e-02f, -1.51619866e-01f, 1.01965986e-01f, 6.17700517e-02f, 3.61849628e-02f, -6.63037151e-02f, 6.08746409e-02f, -3.97512540e-02f,
  -3.36046107e-02f, 3.41387801e-02f, -1.15658373e-01f, -3.66556570e-02f, 7.16831908e-03f, 3.83471343e-04f, -7.69415423e-02f, -5.02943546e-02f, -2.40232367e-02f, -4.39863093e-02f,
  1.52203860e-02f, -8.79595336e-03f, 8.04405734e-02f, 5.57993259e-03f, 5.82935773e-02f, 1.83786172e-03f, 1.11425683e-01f, 1.91285267e-01f, -5.91593646e-02f, 1.22215815e-01f,
  7.52334371e-02f, 1.52742013e-01f, 4.01103869e-02f, -7.62008727e-02f, 1.72013883e-02f, 6.56755036e-03f, -2.61749290e-02f, 7.23382272e-03f, 1.91705823e-02f, 3.45783606e-02f,
  5.08105084e-02f, -5.83357923e-03f, -8.63311440e-02f, 6.50206283e-02f, 1.00508049e-01f, -1.21442392e-01f, 2.92936582e-02f, 7.00405333e-03f, 2.80979928e-02f, 8.20848532e-03f,
  -1.08563840e-01f, -2.49984283e-02f, -2.33029394e-04f, -3.06822471e-02f, -1.31072521e-01f, 1.86895013e-01f, 1.15114115e-02f, -6.76307306e-02f, -3.50162499e-02f, -4.66575101e-02f,
  8.59892517e-02f, 2.42021874e-01f, 4.62977625e-02f, -8.63523111e-02f, -2.64885779e-02f, 1.55182779e-02f, -1.29034027e-01f, -3.96492109e-02f, -9.67289889e-05f, 6.97522163e-02f,
  1.85845122e-01f, 8.91526043e-02f, 5.19581288e-02f, 6.12892695e-02f, -5.20053916e-02f, 7.80639425e-02f, 1.20689841e-02f, -1.01040648e-02f, -3.66932750e-02f, 6.36253878e-02f,
  1.07144177e-01f, 7.47084245e-02f, -8.81047249e-02f, -2.71988977e-02f, 1.12055153e-01f, 1.14189722e-01f, 3.53775918e-02f, 1.00939192e-01f, 8.11146945e-02f, 5.24570942e-02f,
  3.12725544e-01f, -3.11994493e-01f, -1.33233443e-01f, 1.34015426e-01f, 2.70239592e-01f, -3.56857516e-02f, 2.03047574e-01f, 1.29807398e-01f, 2.21750677e-01f, -5.43656237e-02f,
  -1.37113065e-01f, -3.88860583e-01f, -3.84961039e-01f, -1.69631138e-01f, -7.95221329e-02f, -3.44586372e-01f, 3.04853357e-02f, -2.58637458e-01f, -1.62668563e-02f, -1.01869136e-01f,
  5.69228604e-02f, 9.26882699e-02f, 2.25493498e-02f, 2.39024282e-01f, 1.75097898e-01f, 2.23946989e-01f, 1.71349809e-01f, 5.22726886e-02f, 7.29417726e-02f, -2.59404406e-02f,
  4.28176261e-02f, -6.44982606e-02f, 9.72432643e-02f, -1.15273971e-04f, 4.68617082e-02f, 9.75010991e-02f, -1.09021030e-02f, 4.62589599e-02f, 4.10046056e-02f, -1.32935802e-02f,
  -2.94047873e-02f, -2.36877184e-02f, -7.06633031e-02f, -3.10779940e-02f, 1.05859257e-01f, 9.74441171e-02f, -6.87084049e-02f, 8.86927247e-02f, 6.97994009e-02f, -1.11018986e-01f,
  4.24601026e-02f, -1.53262421e-01f, 6.42282218e-02f, -2.71832906e-02f, -4.22493517e-02f, 8.06577504e-02f, 5.87785579e-02f, -4.83644418e-02f, 7.26695498e-03f, 9.82071757e-02f,
  -9.66841262e-03f, 1.74258444e-02f, 5.08232825e-02f, 2.49220822e-02f, 3.21139172e-02f, 9.57504064e-02f, -3.77171347e-03f, -6.88239783e-02f, -1.65878423e-02f, 8.17997009e-02f,
  7.60266138e-03f, -1.38506265e-02f, -7.08824545e-02f, -1.48017728e-03f, 7.50417262e-02f, 3.76069732e-02f, -1.21440785e-02f, -1.62547186e-01f, 8.18295181e-02f, 8.36163573e-03f,
  2.91571580e-02f, 3.49733271e-02f, -4.95754331e-02f, 1.21324420e-01f, -2.40188185e-02f, 4.49251197e-02f, -7.80096501e-02f, -6.01094104e-02f, 4.89205681e-02f, -4.71796934e-03f,
  -6.68499246e-02f, -1.55540645e-01f, -1.42069617e-02f, -7.03993291e-02f, -9.90846679e-02f, 1.36264721e-02f, -2.55117528e-02f, -2.72982232e-02f, -1.41996639e-02f, -8.53449106e-02f,
  1.05686665e-01f, 3.61781716e-02f, 4.69132960e-02f, -5.65442704e-02f, -5.16832666e-03f, -4.07538516e-03f, -3.86746861e-02f, 1.93421543e-01f, 7.63523653e-02f, -1.05503693e-01f,
  9.24863815e-02f, -3.02868932e-02f, 3.44262202e-03f, 1.00317687e-01f, 2.02543084e-02f, 3.64870876e-02f, -3.55305038e-02f, -6.15781471e-02f, -1.12194866e-01f, -4.68762545e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.13594331e-01f, 4.57602330e-02f, 1.44713417e-01f, 1.15350604e-01f, 1.40273899e-01f, 1.06929384e-01f, 1.15836762e-01f, 1.41721502e-01f, 2.03029439e-01f, 7.21405968e-02f,
  1.70775592e-01f, 1.00905217e-01f, 1.55041277e-01f, 2.59116921e-03f, 6.58657923e-02f, 1.00860909e-01f, 7.60276690e-02f, 1.56752497e-01f, 1.42421588e-01f, 1.91977680e-01f,
  1.41845480e-01f, 1.86290994e-01f, 1.21125527e-01f, 1.31719500e-01f, 1.26958832e-01f, 1.52717963e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -5.12084551e-02f, -4.65653315e-02f, 8.13294277e-02f, 3.33002815e-03f, 8.62758309e-02f, 7.28842542e-02f, -2.46221628e-02f, 9.58673283e-02f, -3.17727998e-02f, -7.03138486e-02f,
  1.36000896e-02f, -7.19503537e-02f, -8.11617002e-02f, 6.06896915e-02f, -1.63403004e-02f, 2.42728386e-02f, -1.31221682e-01f, -1.71179678e-02f, -1.07186381e-02f, -9.41177681e-02f,
  2.54184082e-02f, 6.77524973e-03f, 5.93825430e-02f, -1.06203035e-02f, 4.07579541e-02f, 9.25132856e-02f, 3.53690377e-03f, 7.49194399e-02f, 8.61656591e-02f, 3.21089942e-03f,
  5.06032258e-02f, 7.30953366e-02f, -9.87532586e-02f, 3.18687744e-02f, -8.77343938e-02f, 8.99384096e-02f, 3.90671846e-03f, -3.21007632e-02f, 1.05583267e-02f, 2.55264100e-02f,
  7.53626451e-02f, 1.08748861e-01f, 3.52422744e-02f, -7.09088370e-02f, 4.35706750e-02f, -6.28638035e-03f, -7.21407607e-02f, 4.74079587e-02f, -2.64217872e-02f, -2.98022442e-02f,
  -5.27455695e-02f, -2.38745660e-01f, -1.21618405e-01f, -1.21105932e-01f, -1.14022695e-01f, -1.00926481e-01f, 2.77713332e-02f, -4.91984151e-02f, -1.04885072e-01f, 1.07564606e-01f,
  -1.07902020e-01f, -1.67700544e-01f, -1.64592154e-02f, -1.14809513e-01f, -9.02606174e-02f, -8.02414566e-02f, 5.15661836e-02f, -1.67986810e-01f, 6.06955737e-02f, -1.18965052e-01f,
  -1.65601298e-02f, 7.18919048e-03f, 1.10768393e-01f, 4.71533947e-02f, 8.50240588e-02f, -7.58248940e-02f, -6.14900142e-03f, -8.87179598e-02f, 1.73157543e-01f, -2.04860009e-02f,
  -1.21875796e-02f, 4.41383086e-02f, 1.11553855e-01f, 7.86469951e-02f, -3.03514749e-02f, 8.31389651e-02f, 4.01881263e-02f, -5.02330959e-02f, 2.18054838e-02f, 8.77560824e-02f,
  1.03281379e-01f, -4.64366116e-02f, -5.20082340e-02f, 4.03671563e-02f, 9.65960994e-02f, 5.75757287e-02f, 9.20122489e-02f, 1.09974846e-01f, -1.00236654e-01f, -5.02084531e-02f,
  -1.43976644e-01f, 3.35495472e-02f, 8.59433413e-02f, -2.49759719e-01f, 2.51445472e-02f, -1.37305325e-02f, -7.99911562e-04f, 4.97395284e-02f, 8.95056725e-02f, 2.04561874e-02f,
  1.11196928e-01f, 2.96298321e-02f, 3.15623060e-02f, -2.25482777e-01f, 1.55250385e-01f, -3.27535048e-02f, -5.40451482e-02f, 2.53804820e-03f, -4.41858023e-02f, 8.59550312e-02f,
  -6.78754076e-02f, 7.26502463e-02f, 2.43270490e-02f, -2.12037917e-02f, 7.00021312e-02f, 1.18166119e-01f, 2.42145121e-01f, -1.14967808e-01f, -3.77807207e-03f, 1.06457017e-01f,
  3.12815718e-02f, -7.11438358e-02f, 4.19085361e-02f, -7.78053235e-03f, -2.19042250e-03f, 2.85481736e-02f, -4.33269516e-02f, -9.64815356e-03f, 8.93525705e-02f, 6.48313388e-02f,
  -8.11886266e-02f, -7.20656514e-02f, 2.82680448e-02f, -2.26560961e-02f, 3.48088406e-02f, -5.14735766e-02f, -2.15619095e-02f, -4.06748019e-02f, -9.35655087e-03f, 6.22960925e-02f,
  -6.47738995e-03f, -6.56066462e-02f, 6.69424534e-02f, -1.89743806e-02f, -5.20127304e-02f, 1.32861078e-01f, 7.33707249e-02f, 7.34870732e-02f, 1.15136942e-02f, -1.53593086e-02f,
  1.52644245e-02f, -1.47633022e-02f, -4.20588665e-02f, 4.35956987e-03f, -6.33300096e-02f, -3.15123424e-02f, 1.89872328e-02f, 1.10468536e-03f, -1.39260013e-02f, -1.05288075e-02f,
  9.94563103e-02f, 1.07123947e-03f, 3.62586007e-02f, -1.40175344e-02f, 6.83336258e-02f, 5.56875579e-02f, -3.55517492e-04f, -2.16380432e-02f, -5.05822040e-02f, -9.83198062e-02f,
  4.11952063e-02f, -3.39892693e-02f, -1.40940115e-01f, -3.73223796e-02f, -9.68384072e-02f, 3.11976131e-02f, 4.28835489e-02f, -1.43760741e-01f, 1.09724835e-01f, 6.03991933e-02f,
  -1.23019986e-01f, 6.28994703e-02f, 6.33148700e-02f, -1.43046409e-01f, -1.31524261e-02f, -1.28499165e-01f, -8.48723575e-03f, -1.22655846e-01f, 6.15282953e-02f, 4.87502404e-02f,
  -5.56858219e-02f, -1.81466490e-02f, 8.33491534e-02f, 1.10274889e-01f, -1.00549962e-02f, -4.59496491e-02f, 4.00828943e-02f, -3.94178554e-03f, 9.13284048e-02f, -1.69365369e-02f,
  -1.09419949e-01f, -8.79041776e-02f, 6.21333197e-02f, -9.72832204e-05f, 5.83520941e-02f, 4.78536785e-02f, 5.52542023e-02f, 2.85588112e-02f, -7.51956403e-02f, -6.72201812e-02f,
  -7.60458708e-02f, -2.90742982e-02f, -8.76369104e-02f, 3.23264301e-02f, -7.57594407e-02f, -9.62069109e-02f, 4.27675620e-02f, -1.58054411e-01f, 9.58094001e-02f, 4.32597250e-02f,
  -1.68123305e-01f, -1.83338508e-01f, -3.90246958e-02f, 9.48968753e-02f, -8.60345811e-02f, 1.25106692e-01f, 1.51728660e-01f, 5.71585894e-02f, 1.63649678e-01f, 1.27910033e-01f,
  -1.64672121e-01f, 6.52805343e-03f, -1.24389939e-02f, 4.42966912e-03f, -9.94064137e-02f, 9.52551290e-02f, -2.56315172e-02f, 1.55939341e-01f, 3.63977347e-03f, 3.01409001e-03f,
  6.94516078e-02f, 9.05550271e-02f, -1.76207006e-01f, -1.53857663e-01f, -4.35767099e-02f, -5.82691841e-02f, 3.23372297e-02f, 3.65089625e-02f, -9.05760750e-02f, 9.94176492e-02f,
  -1.01825893e-02f, -6.54832795e-02f, 8.91674310e-02f, -4.34797034e-02f, -6.38658330e-02f, 3.94334877e-03f, 6.82718977e-02f, 2.42145527e-02f, 5.10326587e-02f, 5.20503521e-02f,
  1.30514745e-02f, -1.28352093e-02f, 5.41702509e-02f, 1.11224040e-01f, 5.83345108e-02f, 9.27087143e-02f, 1.78598985e-02f, 1.63084529e-02f, -1.54195447e-02f, 4.63559926e-02f,
  3.10112257e-02f, 4.15329188e-02f, -3.42175104e-02f, 3.65163274e-02f, 6.89565167e-02f, 6.22566380e-02f, 4.27705757e-02f, 2.70359451e-03f, 5.57141677e-02f, 1.31937936e-02f,
  1.74120128e-01f, -7.47165531e-02f, 5.29592708e-02f, 3.13282125e-02f, 5.46407141e-02f, -4.95429561e-02f, 1.23570999e-02f, -1.66845024e-02f, -2.97813155e-02f, 6.75491095e-02f,
  -1.00790113e-02f, 3.04368641e-02f, -7.68228173e-02f, -4.30016443e-02f, 5.20791952e-03f, 1.30183585e-02f, 1.16765350e-01f, 2.55197957e-02f, 1.14778318e-01f, 1.99943766e-01f,
  3.72030474e-02f, -2.97145136e-02f, -2.88804434e-02f, -2.66129375e-02f, 6.71302006e-02f, -3.11779734e-02f, -7.79374242e-02f, 4.32778671e-02f, 7.71401227e-02f, 4.91330102e-02f,
  1.14456773e-01f, 5.47926500e-02f, -1.44754434e-02f, 5.09039611e-02f, 8.45244825e-02f, 6.88581616e-02f, -3.16533446e-02f, 2.34112609e-02f, -9.05161425e-02f, 8.93941373e-02f,
  3.48705649e-02f, 1.08944677e-01f, 1.51950374e-01f, 1.08114354e-01f, -1.80550173e-01f, 4.98101972e-02f, -8.51690918e-02f, 3.53309251e-02f, 2.19524466e-03f, -5.53795546e-02f,
  1.71499476e-01f, -4.25248258e-02f, 5.40101416e-02f, 9.57265720e-02f, 8.98676887e-02f, -5.94883785e-02f, -7.83287883e-02f, 5.98689653e-02f, 2.44700816e-02f, 7.55404867e-03f,
  3.47389653e-02f, -4.82434779e-02f, 1.21052582e-02f, 6.59878692e-03f, 1.89237267e-01f, 1.44672319e-01f, 7.91857764e-02f, 2.09520515e-02f, 7.51845399e-03f, 2.69867659e-01f,
  5.28849512e-02f, 6.94770217e-02f, -1.21240154e-01f, -9.24068317e-02f, -4.17288765e-02f, -1.10289007e-01f, -5.48817106e-02f, -8.83068070e-02f, 5.21862321e-02f, 1.05484426e-01f,
  -1.10325433e-01f, -4.42743450e-02f, 1.66607365e-01f, -4.37274240e-02f, 8.82860050e-02f, -7.34770596e-02f, 4.17092554e-02f, -2.06313804e-01f, -6.82784244e-02f, -2.69197784e-02f,
  -3.83324176e-03f, 1.18446844e-02f, -1.22280873e-01f, 1.99118368e-02f, 5.96171729e-02f, 4.18687947e-02f, 8.97660479e-03f, 1.11580007e-02f, 1.61355361e-02f, 6.17004745e-02f,
  2.08323486e-02f, -4.33125347e-03f, 1.04030240e-02f, -9.77123715e-03f, 9.45174508e-03f, 8.69937092e-02f, -2.24492494e-02f, 6.27387967e-03f, 3.88449915e-02f, 2.92902738e-02f,
  3.15807685e-02f, -7.55456910e-02f, -4.02365886e-02f, -4.87881526e-02f, 7.77531788e-03f, -4.51597236e-02f, -1.65713038e-02f, -1.64229088e-02f, 5.19425832e-02f, -4.24766093e-02f,
  -2.22671349e-02f, 3.03075388e-02f, -4.61579263e-02f, 5.66139109e-02f, 2.95519251e-02f, 1.86948273e-02f, -4.67627123e-03f, -3.72543447e-02f, 3.69403400e-02f, -1.13927843e-02f,
  1.14159826e-02f, -1.98102556e-02f, 3.56742591e-02f, -1.29675698e-02f, -4.50063078e-03f, -3.73671167e-02f, 3.36800739e-02f, -3.76816913e-02f, 2.33089682e-04f, -1.35304481e-02f,
  4.50764410e-02f, 5.29718921e-02f, -2.75652967e-02f, -4.43072654e-02f, -5.91592379e-02f, -7.22179264e-02f, -1.19981490e-01f, -1.32771730e-01f, -1.31892383e-01f, 3.30671854e-02f,
  2.58434191e-02f, 1.02250829e-01f, -7.93656632e-02f, -1.77239664e-02f, 1.78976193e-01f, 3.03874724e-02f, -8.33815038e-02f, 8.42595026e-02f, -3.67535539e-02f, -4.84170578e-02f,
  5.56352139e-02f, -6.02382272e-02f, 4.14532572e-02f, -1.00767419e-01f, 1.53252900e-01f, -4.74999361e-02f, 7.13822395e-02f, -4.98061292e-02f, -5.57196252e-02f, -6.53200690e-03f,
  -4.67282943e-02f, -9.30041969e-02f, 5.73275611e-02f, 4.75117676e-02f, 9.01793987e-02f, 1.64133981e-02f, -1.16672546e-01f, -1.56090148e-02f, 4.02876697e-02f, 1.04355715e-01f,
  6.11274429e-02f, -4.58880281e-03f, -9.03102458e-02f, 6.24912456e-02f, -4.28141980e-03f, -4.65391465e-02f, -4.45407815e-02f, -6.13570847e-02f, -4.74161096e-03f, 5.10972887e-02f,
  -9.15575102e-02f, -5.34383431e-02f, -1.65510625e-01f, -1.54509321e-01f, 5.88932186e-02f, 7.39026302e-03f, -3.47628482e-02f, -1.51024669e-01f, -1.52676553e-01f, 1.78017188e-02f,
  -1.19150598e-02f, 1.63952813e-01f, 7.20022619e-02f, 1.71784282e-01f, 1.29152596e-01f, 3.47849727e-02f, -8.35543051e-02f, -3.31264436e-02f, 6.95828646e-02f, 1.91269860e-01f,
  -8.21555629e-02f, 9.05202404e-02f, -8.82612467e-02f, 1.72956765e-01f, 2.55692727e-03f, -5.10643683e-02f, -7.49156848e-02f, 1.83967456e-01f, 3.64096649e-02f, -1.18118577e-01f,
  7.55367279e-02f, 2.77161468e-02f, 1.38388053e-02f, -7.56199891e-03f, 5.97312255e-03f, -2.31087133e-02f, 2.53934693e-02f, 4.33639102e-02f, -7.53374919e-02f, -2.06593145e-02f,
  -1.26452986e-02f, -6.09720349e-02f, 2.12700032e-02f, 1.89025886e-02f, -1.71641130e-02f, -6.95399940e-03f, 5.38041629e-03f, -1.11128099e-01f, -2.93043405e-02f, -8.91359225e-02f,
  -4.73369062e-02f, -4.78155874e-02f, -5.64819463e-02f, 4.32189219e-02f, -8.37496221e-02f, 7.40584335e-04f, 2.05183476e-02f, 1.99304745e-02f, -7.65521228e-02f, 6.04278892e-02f,
  4.92318459e-02f, 5.28928638e-03f, -3.20814848e-02f, 6.81867376e-02f, -7.09768981e-02f, 7.92392623e-03f, 6.13935152e-03f, -3.67231779e-02f, -2.95800585e-02f, -1.03525808e-02f,
  9.35744308e-03f, -6.45157993e-02f, -6.19040690e-02f, -3.25094424e-02f, 4.67083491e-02f, -8.27328265e-02f, -6.52298853e-02f, -5.97563796e-02f, 3.17406543e-02f, 4.84454744e-02f,
  -4.52148952e-02f, -4.43979613e-02f, -2.81952918e-02f, -1.10368192e-01f, -1.97432160e-01f, -1.40612975e-01f, -8.63710344e-02f, 6.19794056e-02f, 5.73574118e-02f, 2.05966793e-02f,
  -3.77658568e-03f, -2.42468920e-02f, 1.09366864e-01f, 2.61349082e-02f, -3.08138877e-02f, 8.26731846e-02f, -2.79133879e-02f, -1.68172941e-02f, 9.47109982e-03f, -1.20130964e-01f,
  7.73823038e-02f, -9.65052098e-02f, 1.14475906e-01f, -1.29304916e-01f, 4.98793609e-02f, -4.57858853e-02f, -7.09406883e-02f, -6.62521571e-02f, 4.59893271e-02f, -9.40004885e-02f,
  1.44282460e-01f, 1.20447367e-01f, 1.24976963e-01f, 8.73753801e-04f, -4.51390445e-02f, -1.74972173e-02f, -3.65677923e-02f, 1.26619473e-01f, 6.01163600e-03f, -7.82081038e-02f,
  -1.02132581e-01f, 1.08955160e-01f, 4.63830717e-02f, -6.12312183e-03f, -5.55421561e-02f, -5.49538806e-02f, 3.72870751e-02f, 5.74068539e-03f, -1.41562134e-01f, -2.83568073e-02f,
  -1.83243543e-01f, -1.09596968e-01f, -8.68117157e-03f, -2.52089202e-02f, -2.44413335e-02f, -1.05872869e-01f, -1.59859985e-01f, -3.53352912e-02f, 1.32161111e-01f, 1.12772539e-01f,
  4.81744856e-02f, 1.20958246e-01f, 1.09522209e-01f, -6.76082298e-02f, -1.80914089e-01f, -2.32808664e-01f, 5.22321649e-02f, 4.37708087e-02f, -1.03462130e-01f, 9.92580205e-02f,
  -1.34753436e-01f, 1.31933615e-01f, -1.16348505e-01f, 3.31229866e-02f, -1.92077875e-01f, 1.02376707e-01f, 7.90978521e-02f, -8.08914602e-02f, 1.07035361e-01f, 1.79979384e-01f,
  -4.50071730e-02f, -6.99635968e-02f, -8.34733620e-02f, 5.49005270e-02f, -1.74516886e-02f, -3.63499187e-02f, -6.37857467e-02f, 5.92285162e-03f, 2.07335930e-02f, -3.47448420e-03f,
  -4.87471893e-02f, 3.05585191e-02f, -5.08549064e-02f, 4.51876521e-02f, -7.17052594e-02f, 2.50877370e-03f, -3.07625625e-02f, -2.58594844e-02f, -4.55940999e-02f, -1.17496341e-01f,
  3.42472233e-02f, -2.06439923e-02f, 3.58365402e-02f, -6.26306459e-02f, -2.90738214e-02f, -4.80690002e-02f, -6.41715378e-02f, 1.33244380e-01f, -7.10025579e-02f, 5.68284355e-02f,
  4.17301320e-02f, -3.11721973e-02f, -4.84973527e-02f, -4.79794592e-02f, 8.61918852e-02f, 3.26622128e-02f, -2.96745989e-02f, -2.25062035e-02f, 3.16752344e-02f, -5.21437675e-02f,
  4.80885757e-03f, -1.00949086e-01f, -3.47643718e-02f, -1.12927049e-01f, 5.00623789e-03f, -1.33996215e-02f, -4.12671119e-02f, 1.66728497e-02f, 2.36119051e-02f, -6.64063916e-02f,
  4.06135470e-02f, 2.83484403e-02f, -8.77225026e-02f, -4.31152061e-02f, -4.16949652e-02f, 1.18543744e-01f, 1.26100928e-01f, -4.28259932e-02f, -1.10784009e-01f, 3.16228159e-02f,
  4.95388471e-02f, 8.73118266e-02f, 2.54853480e-02f, 1.73364863e-01f, 2.27748808e-02f, -1.03469580e-01f, 1.74340621e-01f, -3.09797432e-02f, 1.87344536e-01f, -1.02066137e-01f,
  1.95621431e-01f, -5.11317402e-02f, 4.17400114e-02f, 6.51024505e-02f, -1.58132985e-01f, -1.84160873e-01f, 8.32978114e-02f, -8.96276906e-02f, -5.26758470e-02f, 8.76467973e-02f,
  1.38261437e-01f, -5.91766089e-02f, 9.66693740e-03f, 8.21225718e-02f, 3.91061464e-03f, 9.59855914e-02f, 1.88404337e-01f, -6.94253221e-02f, -1.12699747e-01f, 1.83463871e-01f,
  1.04709886e-01f, 6.00031205e-02f, 1.86174568e-02f, -1.55560784e-02f, -5.76806925e-02f, 3.10130790e-02f, -8.14965516e-02f, 5.14187813e-02f, -1.02396727e-01f, -1.11123540e-01f,
  5.79834431e-02f, -5.62921315e-02f, 2.14155205e-02f, 6.48576468e-02f, 1.79246068e-02f, 2.49435436e-02f, -1.47600427e-01f, 1.07360534e-01f, 7.62985274e-02f, 1.76620096e-01f,
  1.02684736e-01f, -5.19014001e-02f, -3.61107439e-02f, -5.34429774e-02f, 6.01214869e-03f, 5.58841676e-02f, 3.37573402e-02f, 3.65313254e-02f, -1.65039480e-01f, 1.59987882e-01f,
  -2.22944841e-02f, -2.18497425e-01f, -1.60791397e-01f, 1.18580043e-01f, -1.39617892e-02f, -1.27546132e-01f, 4.94088717e-02f, -5.67488037e-02f, -4.60950620e-02f, 4.04304685e-03f,
  5.18945344e-02f, -1.26151713e-02f, 3.90328690e-02f, -4.35615592e-02f, -1.64371915e-02f, -6.01174384e-02f, -6.53336123e-02f, -1.30287204e-02f, -5.75785488e-02f, -4.75087017e-02f,
  1.28569201e-01f, -2.53958721e-02f, -5.82272047e-03f, 7.28316456e-02f, 2.85022091e-02f, 1.02563009e-01f, 5.81833571e-02f, 6.67258818e-03f, 3.18296701e-02f, 1.04977973e-01f,
  -1.16276126e-02f, 4.41127568e-02f, -4.80311923e-02f, 4.36665528e-02f, 5.33759594e-02f, -1.40139699e-01f, 3.54545005e-02f, -9.21543390e-02f, 3.93407717e-02f, 2.30968166e-02f,
  2.53162123e-02f, 8.73528272e-02f, -8.13137516e-02f, 1.07432887e-01f, 3.81725654e-02f, -3.13407928e-02f, 3.16363275e-02f, 5.52721806e-02f, 7.06949923e-03f, 1.36585757e-01f,
  1.71323847e-02f, -1.46122230e-02f, -3.94732617e-02f, -1.63644496e-02f, -3.27708982e-02f, -3.50884208e-03f, 5.72960339e-02f, 1.19892182e-02f, -7.27754980e-02f, -7.85762966e-02f,
  3.47488048e-03f, -7.08414987e-02f, 8.44081864e-02f, -8.73086154e-02f, -3.72233838e-02f, 1.30326226e-01f, 2.14220560e-03f, 8.13612416e-02f, -8.57888237e-02f, -1.71427488e-01f,
  -2.61144899e-02f, -2.21950203e-01f, -1.44077361e-01f, 1.68855488e-01f, -8.20414051e-02f, 9.25379246e-02f, -4.86548394e-02f, 9.84279960e-02f, -9.27563757e-02f, -3.99788581e-02f,
  3.51992026e-02f, -9.74159464e-02f, 1.72821447e-01f, 7.69980624e-02f, 2.68287901e-02f, -5.32854125e-02f, 5.66635095e-02f, 4.85307686e-02f, -1.05096936e-01f, 4.94778007e-02f,
  -4.32881117e-02f, -7.92452767e-02f, 1.51816066e-02f, -3.98611911e-02f, -7.39302412e-02f, 2.32237745e-02f, 7.91026056e-02f, -9.41651836e-02f, -7.79384971e-02f, -8.99852663e-02f,
  -1.13628693e-01f, 3.55169736e-02f, 1.14472307e-01f, -8.29396769e-03f, 1.32012680e-01f, 1.74779911e-02f, 8.50733183e-03f, 7.41409585e-02f, -1.54776096e-01f, 1.29291356e-01f,
  5.08056805e-02f, -1.00039370e-01f, -2.62198411e-02f, -1.92963883e-01f, -1.12790845e-01f, -1.04381010e-01f, -1.23111703e-01f, -9.32747275e-02f, -1.88747689e-01f, 1.43774254e-02f,
  1.06144287e-02f, -1.07306005e-05f, 7.45724142e-02f, -1.98966209e-02f, -3.58895101e-02f, -8.72217044e-02f, 1.46883994e-01f, -1.31249905e-01f, 6.78792074e-02f, 9.41292718e-02f,
  1.41646370e-01f, -2.04737663e-01f, -4.18930799e-02f, 6.30529672e-02f, 8.96738619e-02f, 1.28181219e-01f, 1.48139978e-02f, 5.43914130e-03f, -3.48807685e-02f, -1.27592292e-02f,
  2.05565784e-02f, -7.87623376e-02f, -1.15394257e-01f, 1.24867178e-01f, -6.08988339e-03f, 2.92263497e-02f, 7.88526610e-02f, 2.49133874e-02f, -1.82556838e-01f, 1.67217124e-02f,
  -4.43418026e-02f, -2.46518880e-01f, -1.11299172e-01f, 8.94025527e-03f, -3.15798707e-02f, 1.29309939e-02f, -2.19127648e-02f, -3.79844643e-02f, 9.41073671e-02f, 4.45754686e-03f,
  4.18488570e-02f, 3.33998054e-02f, -1.13079101e-02f, 2.17298403e-01f, 1.10365495e-01f, 1.08445965e-01f, 1.88880172e-02f, -1.66724827e-02f, -6.60981014e-02f, -9.68863536e-03f,
  7.52361491e-02f, -4.41830494e-02f, 3.67100653e-03f, 5.33898473e-02f, 1.10874593e-01f, -1.14102885e-01f, 7.02682883e-02f, -7.72092193e-02f, 2.76742298e-02f, -6.46848138e-03f,
  4.43141647e-02f, 1.06442226e-02f, -1.06674016e-01f, 7.33606741e-02f, -2.58014593e-02f, -5.10918163e-03f, 4.84296754e-02f, -5.63345887e-02f, -6.48330972e-02f, -6.49349764e-02f,
  -8.89797285e-02f, -5.15468381e-02f, 1.40500348e-03f, -1.42388627e-01f, 2.66662091e-02f, -1.43758301e-02f, -1.08463123e-01f, -3.35394777e-02f, 4.63273153e-02f, 1.59719437e-01f,
  1.49420798e-01f, -1.93199262e-01f, 2.03266107e-02f, -8.25848505e-02f, 7.61959031e-02f, -1.70437265e-02f, -1.38860624e-02f, 1.30294040e-01f, -3.36727947e-02f, 1.42893776e-01f,
  3.38072423e-03f, -2.58250237e-02f, 1.95911136e-02f, 1.40960321e-01f, -7.01423734e-02f, -5.09390235e-02f, -3.54463831e-02f, 5.13184629e-02f, 1.01705901e-01f, 1.38274089e-01f,
  4.07996885e-02f, -6.28414527e-02f, -2.74195336e-03f, -3.79572585e-02f, -1.91575587e-02f, 8.23917016e-02f, 2.72878576e-02f, 5.86563349e-02f, 3.24439742e-02f, 9.87355858e-02f,
  1.92134492e-02f, -7.79578462e-02f, -7.65558928e-02f, 4.26113643e-02f, 7.24207759e-02f, 4.96701151e-02f, 4.77280505e-02f, -9.24485102e-02f, 5.30141853e-02f, -1.59003511e-02f,
  1.07194632e-01f, 1.34295374e-01f, 1.33998692e-01f, 3.51168662e-02f, 1.05367236e-01f, -1.77571878e-01f, 1.15994900e-01f, -1.57507077e-01f, 6.73830956e-02f, -1.76491156e-01f,
  -8.26904178e-02f, -1.10592991e-01f, 8.19203705e-02f, -1.97241038e-01f, -1.72055662e-01f, -1.18161747e-02f, -8.71358365e-02f, -4.28793160e-03f, -8.08329284e-02f, 2.34886378e-01f,
  8.68212208e-02f, 1.05855636e-01f, -4.97139581e-02f, -1.32982329e-01f, 5.43942377e-02f, 5.59679829e-02f, 6.43474087e-02f, 6.29738644e-02f, 7.16144219e-02f, 4.34150137e-02f,
  1.86183248e-02f, -2.57424135e-02f, 4.64760698e-02f, 6.20036013e-02f, -3.98447104e-02f, 1.94496587e-02f, 1.11200832e-01f, 3.47130708e-02f, 7.97996148e-02f, 9.44686383e-02f,
  8.74653831e-02f, 6.81589022e-02f, -2.29799338e-02f, -1.49067361e-02f, 2.39720736e-02f, 6.31547123e-02f, -2.37939842e-02f, 6.92369640e-02f, -2.78364923e-02f, -2.10769922e-02f,
  4.71630991e-02f, -7.77823851e-02f, -6.60937920e-04f, -7.89255425e-02f, 4.93636467e-02f, 9.26673859e-02f, 6.11829795e-02f, 3.08116730e-02f, -1.25232739e-02f, 1.27514163e-02f,
  8.91747419e-03f, -8.14380795e-02f, -6.97627440e-02f, 2.57731285e-02f, -7.86247663e-03f, 9.78002176e-02f, 2.53588464e-02f, -1.30429659e-02f, -1.94175784e-02f, 1.56522077e-02f,
  4.06724513e-02f, -6.09654188e-02f, 1.52036073e-02f, 6.45482913e-02f, 1.88763032e-03f, -1.02619939e-01f, 1.76253840e-02f, -9.73358229e-02f, 2.91312151e-02f, -9.06929225e-02f,
  3.41888331e-02f, 6.17695451e-02f, 1.67444663e-03f, -1.25765856e-02f, -2.53752749e-02f, -2.84272842e-02f, -8.12424123e-02f, 7.54412124e-03f, -5.95258400e-02f, 1.82837054e-01f,
  -1.08932689e-01f, 4.99144420e-02f, 1.48061961e-02f, 6.96949884e-02f, 4.85057419e-04f, -9.48374197e-02f, 9.65943411e-02f, -6.30959645e-02f, 1.09745413e-01f, 1.38313249e-01f,
  2.23566461e-02f, 1.37486374e-02f, 7.23785087e-02f, 5.54595627e-02f, -9.51462910e-02f, 1.08437769e-01f, -2.19874512e-02f, 5.16995788e-02f, 4.65348884e-02f, 1.36655778e-01f,
  -3.23587880e-02f, -2.66465768e-02f, 7.96087980e-02f, -2.17214860e-02f, -1.79066248e-02f, -5.75186945e-02f, -1.45321071e-01f, 3.40536907e-02f, 9.03192759e-02f, -3.18325050e-02f,
  -7.23404903e-03f, 9.68749896e-02f, -4.45479900e-02f, 5.49974516e-02f, -2.83547137e-02f, 2.77697295e-03f, 6.36383072e-02f, -1.53757185e-01f, -1.31986409e-01f, -1.86696246e-01f,
  3.56079303e-02f, -8.30476806e-02f, -1.72006309e-01f, -1.19848669e-01f, -1.18193291e-01f, -3.46315578e-02f, -8.32581241e-03f, 1.46751879e-02f, 1.12935387e-01f, -8.26821700e-02f,
  -5.97452782e-02f, -7.50207528e-02f, 1.57532603e-01f, -8.45571831e-02f, -1.43283140e-02f, -2.13868935e-02f, -3.59495282e-02f, 8.83223210e-03f, -2.96211652e-02f, 1.39435446e-02f,
  6.15311936e-02f, 1.22719064e-01f, -5.09147197e-02f, -1.38099030e-01f, -7.79808909e-02f, -2.90424973e-02f, -8.39780718e-02f, 5.48007246e-03f, -1.62739437e-02f, 1.50337033e-02f,
  6.25414178e-02f, -5.44962212e-02f, -3.74419689e-02f, 3.94975953e-03f, -6.10608980e-02f, 1.01760052e-01f, -1.39776781e-01f, -2.15032790e-02f, -1.33663595e-01f, 1.34366462e-02f,
  -1.35625705e-01f, -3.86431143e-02f, -2.13907640e-02f, -5.54114506e-02f, -6.08271323e-02f, -1.28543228e-01f, -8.38526990e-03f, -7.11002350e-02f, -6.48645833e-02f, 9.45860520e-02f,
  -6.76163062e-02f, -5.77202393e-03f, -4.61634696e-02f, -4.63012755e-02f, -1.02991149e-01f, 1.81720387e-02f, 8.81006792e-02f, -5.71275922e-03f, -1.06578190e-02f, 7.08182529e-02f,
  4.57724966e-02f, -2.64858324e-02f, 6.40053749e-02f, -1.67419687e-01f, -1.21253125e-01f, -8.89337957e-02f, 2.31311731e-02f, -4.91824858e-02f, -1.01933628e-01f, 7.47201517e-02f,
  -3.77569087e-02f, -6.18145317e-02f, 8.77171457e-02f, 6.60116374e-02f, 4.97106276e-02f, 1.00864686e-01f, 6.27108514e-02f, 7.18997940e-02f, 6.04680851e-02f, -4.49243523e-02f,
  -3.25524360e-02f, 8.07213485e-02f, -2.44456623e-02f, 2.33514365e-02f, 1.03957370e-01f, 5.48989400e-02f, 5.28896637e-02f, 7.75595754e-03f, 1.29676133e-01f, 7.11192489e-02f,
  6.08584099e-02f, 7.81692192e-02f, 2.56079193e-02f, 2.29597669e-02f, 7.08122402e-02f, 7.61408731e-02f, -9.55946371e-02f, -1.59934342e-01f, 8.70476535e-04f, -1.33351963e-02f,
  -1.75411269e-01f, 3.73680480e-02f, -7.06936978e-03f, 5.76182306e-02f, 1.31532192e-01f, 1.56466842e-01f, -4.75901663e-02f, 1.00619763e-01f, 1.12038404e-02f, -3.87259945e-02f,
  -5.40566221e-02f, 6.31852299e-02f, 9.18569416e-02f, 6.01333305e-02f, 1.72453612e-01f, 5.57447188e-02f, -9.16674808e-02f, -7.80014880e-03f, 3.55697758e-02f, 1.46949127e-01f,
  1.08591355e-02f, 5.21564595e-02f, 6.28636926e-02f, -5.24474680e-02f, 6.82291389e-02f, 1.33421227e-01f, 1.19134746e-01f, -8.26489776e-02f, 5.46238236e-02f, 8.13500211e-02f,
  3.11789140e-02f, 1.16672151e-01f, 5.73791377e-02f, -7.78550655e-02f, 7.95821548e-02f, -1.52479649e-01f, -5.60327545e-02f, 8.10941309e-02f, 1.35509059e-01f, 5.35724163e-02f,
  -1.15905896e-01f, 8.02752823e-02f, -1.05584353e-01f, -2.55246431e-01f, -2.10218310e-01f, 2.67338157e-01f, 7.57087395e-02f, 1.45545542e-01f, -8.19229633e-02f, -5.97005151e-02f,
  -5.42699248e-02f, -3.94626074e-02f, -3.60287838e-02f, 3.50006260e-02f, -7.02659488e-02f, -1.23626947e-01f, 1.54691413e-02f, -8.64824653e-02f, -1.67988986e-02f, 7.30867609e-02f,
  2.83096824e-02f, -4.18725051e-02f, 9.39419791e-02f, -2.52279565e-02f, -4.47074026e-02f, -2.32353457e-04f, -1.13805085e-02f, 7.33519271e-02f, 4.50191740e-03f, 4.61471118e-02f,
  -2.53638141e-02f, -5.98839112e-02f, -1.83475707e-02f, 7.09911957e-02f, 1.90771166e-02f, -6.65724352e-02f, 7.05143586e-02f, 2.84909247e-03f, 1.29489042e-02f, -4.76808213e-02f,
  -9.58004072e-02f, -7.97780007e-02f, 2.93832123e-02f, 1.11650657e-02f, 2.76907105e-02f, 3.70937586e-02f, 8.51768404e-02f, -1.84042826e-02f, 4.13366109e-02f, -1.65984947e-02f,
  1.26523562e-02f, -7.43763968e-02f, -1.13606572e-01f, 8.07164982e-02f, -5.15882857e-03f, 4.55470802e-03f, -5.32899760e-02f, -2.65647154e-02f, 2.24858131e-02f, 4.42843735e-02f,
  -4.63901600e-03f, 1.29473686e-01f, 6.93057105e-02f, 1.51329547e-01f, 5.82401454e-02f, -7.02067241e-02f, -7.75368214e-02f, 3.24187763e-02f, 4.00129780e-02f, -5.74789234e-02f,
  -6.34953380e-02f, -1.67301968e-02f, 5.43517247e-02f, 9.63251479e-03f, 1.50207326e-01f, 5.93963079e-02f, -6.88245818e-02f, 1.42913491e-01f, 3.59243192e-02f, 1.46932408e-01f,
  -9.53474864e-02f, 1.29188150e-02f, 7.12628989e-03f, -3.43710780e-02f, -2.34944001e-02f, 1.01989567e-01f, -2.95980275e-03f, 1.30582348e-01f, -1.12593241e-01f, -9.12068412e-02f,
  -2.31567174e-01f, 1.73664168e-01f, -3.68439816e-02f, -8.46567824e-02f, 8.72831568e-02f, -1.45257339e-01f, -3.83072309e-02f, 2.18822248e-02f, 2.72690933e-02f, -3.48437689e-02f,
  -7.87164643e-02f, 6.79220110e-02f, 7.28600174e-02f, 1.34008536e-02f, 6.63048849e-02f, -1.26922086e-01f, -5.35240360e-02f, -8.26435164e-02f, 1.07894115e-01f, 1.33731425e-01f,
  1.65649448e-02f, -5.27118482e-02f, 2.77886745e-02f, 9.57481116e-02f, 6.00363538e-02f, 1.69216413e-02f, -1.60189290e-02f, -1.14016280e-01f, -9.47698802e-02f, -2.18043000e-01f,
  -1.31163090e-01f, -7.02020749e-02f, 1.02334626e-01f, 1.40008301e-01f, -2.69915760e-02f, 2.06603128e-02f, 8.24883878e-02f, -9.84149873e-02f, -4.76459228e-02f, -1.38448104e-01f,
  1.02529787e-01f, -1.27974659e-01f, -3.21642980e-02f, -5.54233454e-02f, -5.87164983e-02f, 6.06748909e-02f, -6.59031644e-02f, 1.25270411e-01f, 6.07470842e-03f, 5.78289526e-03f,
  -7.19143078e-02f, -1.25120033e-03f, -5.33503033e-02f, -5.01337312e-02f, -2.73725688e-02f, -2.52064224e-02f, 1.14740506e-02f, 1.43909436e-02f, 2.77927052e-02f, 1.95286479e-02f,
  -8.08682665e-02f, -6.88778013e-02f, -1.68567942e-03f, 1.58276204e-02f, 5.34686632e-03f, -1.34656224e-02f, -5.68125136e-02f, -1.13441907e-02f, -2.81228479e-02f, -6.78624734e-02f,
  2.72090118e-02f, 3.04011349e-02f, -3.14982794e-02f, -1.64665766e-02f, -8.38042125e-02f, 1.44625813e-01f, -3.06312367e-02f, 9.16926488e-02f, -2.09253654e-02f, -7.95298368e-02f,
  -2.35224143e-02f, -2.95525175e-02f, 4.48252186e-02f, -2.36264318e-02f, 2.22297683e-02f, 9.08037007e-04f, -1.91651080e-02f, -2.54597571e-02f, -1.30216759e-02f, -8.38877484e-02f,
  -6.02731779e-02f, 1.12209877e-03f, -1.95830315e-02f, -5.12862056e-02f, -1.87233952e-03f, -1.40756806e-02f, -4.25626943e-03f, -4.46748957e-02f, 4.74197231e-02f, 1.62508525e-02f,
  1.24591414e-03f, -3.26370597e-02f, -7.46064335e-02f, 6.99929893e-02f, 8.66361149e-03f, -5.59617244e-02f, -2.61479486e-02f, -3.47008407e-02f, 4.95017171e-02f, 6.74605742e-02f,
  -1.51257534e-02f, 1.68653324e-01f, 8.32534805e-02f, -2.16342404e-01f, 8.73799473e-02f, 2.51933336e-02f, 1.19161218e-01f, -5.12703061e-02f, 1.44580573e-01f, 9.20224860e-02f,
  -2.55747605e-02f, 6.84252381e-02f, -1.47221848e-01f, -1.10005967e-01f, 2.58911327e-02f, -6.76920041e-02f, -1.29586875e-01f, -1.04562417e-02f, 1.05488062e-01f, -1.72340609e-02f,
  -5.84247150e-02f, -4.75649424e-02f, 7.26203844e-02f, 7.93967396e-03f, 9.25768092e-02f, -4.81668413e-02f, -4.87607755e-02f, 1.38193026e-01f, 4.91952226e-02f, 5.84638454e-02f,
  2.72970255e-02f, -2.84243114e-02f, -4.49006930e-02f, -5.50147742e-02f, -1.09575488e-01f, -1.39710838e-02f, -2.74967216e-02f, -1.06116943e-01f, 1.22774586e-01f, -3.82569730e-02f,
  -6.40476644e-02f, 7.24040940e-02f, -4.43364084e-02f, 2.03756183e-01f, -1.97707057e-01f, 9.99897644e-02f, 9.52636600e-02f, 1.49861544e-01f, 1.52805448e-01f, -1.01520285e-01f,
  -5.78375021e-03f, 2.28715986e-02f, 3.78028350e-03f, 3.52632031e-02f, -1.81144604e-03f, 7.79648423e-02f, -2.81374305e-01f, 1.29810721e-01f, 2.77007334e-02f, -2.20219091e-01f,
  -1.62013248e-01f, 8.08138400e-02f, -8.46009254e-02f, -1.19015545e-01f, 1.70749594e-02f, -5.97120337e-02f, -1.93612520e-02f, -2.13191770e-02f, 4.27161418e-02f, 1.99762434e-02f,
  1.50618432e-02f, -7.94923231e-02f, 8.52582529e-02f, -1.16640283e-02f, 3.22985798e-02f, 1.03315830e-01f, 3.81777361e-02f, 3.29392031e-02f, 1.56064913e-01f, -4.21785899e-02f,
  1.29593655e-01f, 2.80781239e-02f, 1.10539101e-01f, -4.35126573e-03f, 9.06569511e-02f, 3.63302114e-03f, 5.56240883e-03f, 3.46202813e-02f, 2.85725426e-02f, 8.26854408e-02f,
  -1.00657064e-03f, -2.66509969e-02f, -1.40144350e-02f, -7.48234168e-02f, -3.54422182e-02f, -6.47389293e-02f, -3.39963473e-02f, -7.55836815e-03f, -1.66428537e-04f, 6.78378996e-03f,
  7.15117343e-03f, 5.58579303e-02f, 6.59255534e-02f, -1.34398062e-02f, -4.38937731e-02f, -4.04387861e-02f, 4.31726174e-03f, 2.78098392e-03f, 1.78519804e-02f, 7.58060664e-02f,
  -4.85157482e-02f, 9.35043488e-03f, 3.11779603e-02f, -6.33690581e-02f, 1.96564347e-02f, -2.58865096e-02f, -1.78988706e-02f, 3.76244746e-02f, -1.16376147e-01f, -1.45850688e-01f,
  1.36668265e-01f, -3.54170427e-02f, -1.06180813e-02f, 4.83857095e-02f, -3.96279804e-02f, -4.33955193e-02f, -2.94937938e-03f, -1.56768262e-02f, -1.60415284e-02f, 2.14813165e-02f,
  7.83565629e-04f, 8.47593546e-02f, -1.27721533e-01f, 9.39121395e-02f, 8.65722261e-03f, 3.99473570e-02f, 5.29877655e-02f, -4.95898761e-02f, 3.51966433e-02f, -4.99833934e-02f,
  -9.81601607e-03f, 1.45052046e-01f, 1.90964844e-02f, 2.99279522e-02f, 9.82571766e-02f, 1.61350369e-02f, -1.09521016e-01f, 1.12678051e-01f, -1.21396944e-01f, -8.77315700e-02f,
  2.09881309e-02f, 5.28047979e-02f, -1.22449130e-01f, -8.51534158e-02f, -8.87952745e-02f, -6.83148503e-02f, -6.87136352e-02f, -1.11426665e-02f, -5.82708679e-02f, -9.47897658e-02f,
  1.28314108e-01f, -6.11249581e-02f, -1.67937055e-01f, -1.67752653e-01f, -1.08193062e-01f, 5.42671569e-02f, 4.59862873e-03f, -1.93371717e-02f, 3.11547611e-02f, -1.43527925e-01f,
  -1.78326577e-01f, 6.21097237e-02f, 1.79750100e-01f, -5.66173010e-02f, -1.96772844e-01f, -7.27076679e-02f, -9.03179646e-02f, -1.30935043e-01f, -3.27345282e-02f, 2.23902360e-01f,
  1.07305966e-01f, 9.94818732e-02f, -1.54819772e-01f, -3.66566814e-02f, 7.03633949e-02f, -4.72971164e-02f, 1.11959904e-01f, 6.35991395e-02f, -1.11005999e-01f, -9.49013084e-02f,
  9.41871554e-02f, -9.55413282e-02f, 1.12641349e-01f, 1.37572780e-01f, 5.73913828e-02f, -2.81024817e-02f, -7.03464542e-03f, 4.38726097e-02f, -5.31067699e-03f, 9.18281972e-02f,
  -1.95974149e-02f, 6.72806352e-02f, -8.47900100e-03f, 5.72704151e-02f, -4.43230988e-03f, -5.45413755e-02f, 1.09418944e-01f, -1.02181621e-01f, 9.64582041e-02f, 1.20228752e-01f,
  -5.45506366e-02f, -1.04974374e-01f, 1.20418631e-01f, -1.08056977e-01f, 2.49924771e-02f, 4.37220782e-02f, 2.87093818e-02f, 1.00232353e-02f, 1.90375559e-02f, 2.05508899e-02f,
  -4.46986221e-02f, -1.05792753e-01f, 1.98125355e-02f, -3.31189074e-02f, 5.47796786e-02f, 5.96975014e-02f, -2.11165147e-03f, -9.15584788e-02f, -6.52933046e-02f, 8.19182023e-03f,
  4.75931764e-02f, -3.37268156e-03f, -7.99454451e-02f, 1.71818674e-01f, -1.41217727e-02f, 1.24476157e-01f, 2.51727495e-02f, 3.02686468e-02f, 4.07185331e-02f, 3.43960226e-02f,
  1.39592960e-01f, -8.28820392e-02f, -2.72684153e-02f, -8.87733176e-02f, -1.16303824e-01f, -1.97630003e-01f, -2.31597237e-02f, -1.10079870e-01f, 7.64652789e-02f, 1.14731871e-01f,
  1.09697603e-01f, 6.44476786e-02f, -1.03140168e-01f, 2.55556889e-02f, -8.67084563e-02f, -2.24901482e-01f, -5.62821366e-02f, -1.03156433e-01f, -1.24565095e-01f, 2.14309338e-02f,
  -4.60441746e-02f, 4.10619229e-02f, -1.85229834e-02f, -1.00406721e-01f, 8.41641426e-02f, -1.09885238e-01f, 5.13528064e-02f, -2.30898969e-02f, -1.54903503e-02f, -6.36313285e-04f,
  -9.03150365e-02f, -1.53988302e-01f, 1.02403201e-01f, 8.60274285e-02f, 1.06354333e-01f, -9.96059328e-02f, 8.17069260e-04f, 1.39517695e-01f, -4.78540361e-02f, 2.09308773e-01f,
  5.24419434e-02f, 3.35363708e-02f, -8.02572351e-03f, -9.72684324e-02f, 7.88052902e-02f, -3.22385877e-02f, -1.12030469e-01f, -1.12275138e-01f, 6.16706442e-03f, 1.37175053e-01f,
  -4.15804833e-02f, 8.13983530e-02f, -1.10151097e-01f, 7.69264475e-02f, -1.11268826e-01f, 5.18587604e-02f, 3.34212743e-02f, -1.22384161e-01f, -1.35587528e-01f, -6.96199611e-02f,
  1.15761184e-03f, -8.03227723e-02f, -8.11423808e-02f, 8.39495361e-02f, -5.91563880e-02f, 4.31363769e-02f, -1.81192026e-01f, -1.06730655e-01f, 1.11169793e-01f, 1.60390913e-01f,
  -1.10159434e-01f, 8.00783038e-02f, 1.12818502e-01f, 4.95459028e-02f, -6.80008978e-02f, 5.65422736e-02f, 6.92793354e-02f, -2.24049509e-01f, 3.22834887e-02f, -4.16837968e-02f,
  1.18447855e-01f, -1.54187724e-01f, 3.32886763e-02f, -2.49391533e-02f, -7.26797655e-02f, 7.27421492e-02f, -3.59608643e-02f, -9.24913287e-02f, -1.44933034e-02f, 2.59088315e-02f,
  1.07427901e-02f, 1.15731627e-01f, 3.80912498e-02f, 3.61112319e-02f, -2.13471018e-02f, -8.63849446e-02f, 9.73468795e-02f, -9.87843201e-02f, 1.07680112e-02f, -5.12369685e-02f,
  9.96761620e-02f, 7.64197530e-03f, -6.79460391e-02f, -1.22642405e-01f, 4.55239825e-02f, 8.19464922e-02f, 3.29630710e-02f, -4.29865271e-02f, -7.58540779e-02f, -2.54475158e-02f,
  -3.12030129e-02f, -1.52779426e-02f, -2.96858754e-02f, -1.37673141e-02f, -4.44750823e-02f, -1.16233796e-01f, 4.46287878e-02f, -6.03175955e-03f, 4.51801382e-02f, -3.48995673e-03f,
  -2.22594831e-02f, -5.53491488e-02f, 2.42861477e-03f, -6.42222688e-02f, 1.43436075e-03f, 1.25750750e-01f, 1.02975285e-02f, -5.78273945e-02f, 5.37600704e-02f, -1.44304991e-01f,
  -5.79627380e-02f, -1.00171551e-01f, -4.58809137e-02f, 4.12349552e-02f, -1.23816662e-01f, -1.50091648e-01f, -1.72126223e-03f, -8.95247329e-03f, 2.73558702e-02f, 1.59384422e-02f,
  -5.73588535e-02f, -2.14857366e-02f, -3.52205820e-02f, -5.59349433e-02f, -2.98634004e-02f, 1.37718633e-01f, 8.35956186e-02f, -8.35443065e-02f, -1.56582862e-01f, 5.96739836e-02f,
  2.22452935e-02f, 4.95698079e-02f, 1.48303621e-02f, -2.40136851e-02f, -1.35940053e-02f, 6.40498474e-02f, -1.45555049e-01f, 6.33679107e-02f, -1.53666630e-01f, 7.26650506e-02f,
  4.40885164e-02f, -3.81756797e-02f, 1.60508044e-02f, 8.81083682e-02f, -1.31074652e-01f, -2.32309159e-02f, 2.70432271e-02f, 2.45649628e-02f, -5.38379773e-02f, -6.12908080e-02f,
  -1.71487153e-01f, -2.43813191e-02f, 8.40315595e-03f, -8.67762510e-03f, 2.82389224e-02f, -1.46325409e-01f, 6.20536357e-02f, -6.37398288e-02f, -1.83824435e-01f, -1.29419476e-01f,
  -7.60294199e-02f, 1.10093683e-01f, 1.12922698e-01f, -9.03648436e-02f, 4.82770540e-02f, -7.90917650e-02f, -2.04740688e-01f, 1.41084641e-01f, 1.96074754e-01f, -9.45408866e-02f,
  -9.80476737e-02f, -1.06963024e-01f, -2.22338140e-02f, -1.47313565e-01f, -3.54280323e-02f, 3.90863530e-02f, 4.14413996e-02f, 1.75636485e-01f, -4.67094034e-02f, 2.69481372e-02f,
  -7.73286596e-02f, -5.05520999e-02f, 5.43006137e-02f, 1.51673481e-02f, -5.09181023e-02f, 3.12056225e-02f, 5.94071336e-02f, 2.13424526e-02f, 1.52342552e-02f, -4.13762070e-02f,
  1.52232358e-02f, 8.01602658e-03f, -9.89095587e-03f, -4.03481200e-02f, 2.61633191e-02f, -1.41960651e-01f, -2.76718382e-02f, 4.79870252e-02f, 6.20349590e-03f, 6.68917075e-02f,
  -2.33026911e-02f, 5.72495386e-02f, -1.10870838e-01f, 3.28121660e-03f, -8.09188709e-02f, -1.21105015e-01f, -3.61805223e-02f, -9.76860616e-03f, -1.17266281e-02f, 3.24402936e-03f,
  -9.89702437e-03f, -8.18781778e-02f, 6.21812344e-02f, -4.41312836e-03f, -1.06656156e-03f, 3.91687490e-02f, 3.19292955e-02f, 6.63406625e-02f, 4.98703355e-03f, 6.34114025e-03f,
  -3.20443511e-02f, 5.74558005e-02f, -9.48300511e-02f, -4.27443087e-02f, 6.02463000e-02f, -5.01055941e-02f, 1.38010094e-02f, -3.99981737e-02f, 7.31563717e-02f, -9.49034095e-02f,
  7.10995495e-02f, -6.50601387e-02f, -3.91799025e-02f, 4.57170866e-02f, 3.73092107e-02f, -1.85986366e-02f, -2.50333436e-02f, -1.81083533e-03f, -6.09809011e-02f, -6.28994256e-02f,
  -5.01328409e-02f, -8.75280201e-02f, -1.11487225e-01f, -6.22814372e-02f, -1.34217009e-01f, -1.05802901e-01f, 9.39426422e-02f, -3.53121087e-02f, 1.97172873e-02f, 4.05572029e-03f,
  -1.52562514e-01f, 2.65912293e-03f, -4.59260978e-02f, 6.27212003e-02f, 1.33826241e-01f, -7.07866997e-02f, 3.88039909e-02f, -5.56922741e-02f, 4.06202450e-02f, -5.90503449e-03f,
  5.70470979e-03f, 1.26564885e-02f, 1.41924828e-01f, 6.47306815e-02f, -6.40164092e-02f, -7.62089118e-02f, -4.42352984e-03f, 7.14875236e-02f, 4.65851836e-02f, 3.54691781e-02f,
  3.07239185e-04f, 7.38215670e-02f, 9.62055940e-03f, 1.33664206e-01f, -1.45804510e-03f, -4.00242284e-02f, -4.55414653e-02f, -1.16974358e-02f, -5.37070781e-02f, 8.93677324e-02f,
  2.97213085e-02f, 3.36891524e-02f, 7.07830936e-02f, -4.84138206e-02f, 6.66519329e-02f, -1.38006464e-01f, -8.71766061e-02f, -1.17546562e-02f, -5.21612130e-02f, 1.10593447e-02f,
  1.45045221e-02f, -4.20317724e-02f, 1.08610809e-01f, -5.80179133e-02f, 2.86689028e-02f, 1.16990022e-01f, 1.14187613e-01f, -3.12579758e-02f, 1.09781222e-02f, -5.85823841e-02f,
  3.37422006e-02f, -9.41490382e-02f, 1.45003591e-02f, -5.84328324e-02f, 3.27123143e-02f, 1.35682616e-03f, -6.41144533e-03f, -4.55297567e-02f, -1.17194757e-01f, 4.25835922e-02f,
  4.25606482e-02f, -8.34105015e-02f, -5.54040223e-02f, 2.00392291e-01f, 1.37840081e-02f, 4.29805033e-02f, 6.01802506e-02f, -5.11330590e-02f, 2.82925311e-02f, -2.21471451e-02f,
  -3.36430781e-02f, -4.36316011e-03f, -4.42433320e-02f, -4.09533270e-02f, -4.59069312e-02f, 4.41437034e-04f, -7.38517195e-03f, -5.48927672e-02f, 5.03135696e-02f, 7.66066927e-03f,
  -9.03788209e-02f, 1.27791110e-02f, -5.73454946e-02f, -9.28707346e-02f, -7.02751428e-02f, -5.48838936e-02f, -1.64158642e-02f, -4.73170914e-03f, -7.86067098e-02f, -2.68606804e-02f,
  -2.03921944e-02f, -4.62998860e-02f, -5.53210974e-02f, -2.90197972e-02f, -1.14023313e-01f, 7.33370110e-02f, 2.07599346e-03f, 7.64668211e-02f, -1.38548412e-03f, -7.69697726e-02f,
  -3.81009802e-02f, -1.04896463e-01f, 1.99692436e-02f, -6.92790076e-02f, -3.11127882e-02f, -2.21394803e-02f, 3.46913449e-02f, -6.45117275e-03f, -3.45561430e-02f, -3.44912335e-02f,
  -1.09113250e-02f, 2.38075573e-02f, -3.87041532e-02f, -5.34833707e-02f, -4.43891846e-02f, 2.09797025e-02f, -8.78488719e-02f, -5.52622937e-02f, 3.15348953e-02f, -1.46738691e-02f,
  -2.87970789e-02f, 1.61296111e-02f, -6.49788231e-02f, 7.05551729e-02f, -6.67263865e-02f, -4.38996218e-02f, -1.37062818e-02f, 5.50958328e-03f, 9.68407914e-02f, -6.55493047e-03f,
  5.96376322e-02f, 6.44202158e-02f, 8.92955735e-02f, -1.51561037e-01f, 6.41458929e-02f, -6.02176636e-02f, 6.40511587e-02f, -8.24809298e-02f, 2.61322744e-02f, 4.77673905e-03f,
  -4.82361130e-02f, 8.12289119e-02f, -6.28965581e-03f, -4.52025495e-02f, -7.25460798e-03f, -3.46376114e-02f, -7.12844208e-02f, 5.14832735e-02f, 7.40188584e-02f, -9.01835561e-02f,
  -2.08754856e-02f, 1.76776275e-02f, 8.25278759e-02f, 1.72951147e-02f, 6.58755600e-02f, -4.10345495e-02f, -4.34488989e-02f, 2.49958113e-02f, 9.81444195e-02f, -2.05240194e-02f,
  3.82609554e-02f, -2.47847885e-02f, -7.12068677e-02f, 9.33068432e-03f, -9.83168408e-02f, 1.29078107e-04f, -1.60839409e-02f, -1.02870941e-01f, 1.12076104e-01f, 1.00699002e-02f,
  -7.30854571e-02f, 2.18815785e-02f, -1.03383496e-01f, 1.74937889e-01f, -7.66063407e-02f, 3.42146084e-02f, 9.57690328e-02f, 1.74453065e-01f, 1.17397569e-01f, -6.87221587e-02f,
  -4.71769460e-02f, -7.20124170e-02f, -1.58231810e-01f, 1.66493624e-01f, 1.65403597e-02f, 1.38036847e-01f, -1.53349444e-01f, 1.35367528e-01f, 1.82678513e-02f, -9.32145938e-02f,
  -1.16057694e-01f, 9.71618369e-02f, 7.17002675e-02f, -3.27935331e-02f, -1.01151362e-01f, -1.27958864e-01f, 5.90599664e-02f, 4.38759699e-02f, -4.35646214e-02f, 1.50334891e-02f,
  4.14743200e-02f, 6.05327077e-02f, -6.52693361e-02f, 2.53551695e-02f, 1.17992684e-02f, -8.17190856e-02f, 2.15621442e-02f, -2.11464651e-02f, -5.79626821e-02f, 3.04218326e-02f,
  -4.40705232e-02f, 4.94314283e-02f, -9.88760404e-03f, 3.38831693e-02f, 1.73605010e-02f, -2.30191555e-02f, 2.47627459e-02f, 3.13624404e-02f, -1.10362712e-02f, -3.38867754e-02f,
  -5.60215563e-02f, 4.22149003e-02f, -6.35760278e-02f, 1.65765643e-01f, -1.49569110e-04f, 8.25097188e-02f, 7.19128996e-02f, -2.22248305e-02f, 1.65510755e-02f, -7.82040181e-04f,
  -5.22518577e-03f, -7.08996784e-03f, 3.15409675e-02f, -3.77438497e-03f, -2.06456091e-02f, 8.93811323e-03f, -3.29236723e-02f, -2.43473388e-02f, 3.33280005e-02f, -1.06754720e-01f,
  1.95133276e-02f, -1.03973113e-02f, -1.51188010e-02f, 2.81261168e-02f, 4.19322997e-02f, -1.19502107e-02f, 2.57766824e-02f, -7.06752166e-02f, 6.79943040e-02f, 5.80621809e-02f,
  -1.33896485e-01f, 2.86300760e-02f, 1.56799797e-02f, -9.05720219e-02f, -5.27900569e-02f, 1.01155572e-01f, 1.00091081e-02f, 3.77296330e-03f, 2.50294525e-02f, -1.24186405e-03f,
  -1.00531951e-01f, -1.02838308e-01f, 1.79528370e-01f, -7.56167993e-02f, 1.21293090e-01f, -1.12155795e-01f, 1.03436090e-01f, -2.35924665e-02f, -4.31290865e-02f, -3.68583314e-02f,
  -4.68680188e-02f, -1.88971862e-01f, 7.99482986e-02f, -8.48824233e-02f, -8.38032439e-02f, 5.42023443e-02f, 1.30205631e-01f, -1.85668781e-01f, 7.00787306e-02f, 1.12064369e-01f,
  -5.60077392e-02f, 6.30401447e-02f, 1.31521478e-01f, 3.99885848e-02f, 1.48352981e-03f, 8.43110085e-02f, 6.85099661e-02f, 4.54366719e-03f, 2.84091812e-02f, 5.34017906e-02f,
  -6.35554269e-02f, 3.75618599e-02f, 7.40591511e-02f, 1.41456410e-01f, -2.23197369e-03f, -8.64767581e-02f, -2.32136603e-02f, 5.02551012e-02f, 1.99436229e-02f, 9.55088735e-02f,
  1.11207753e-01f, 1.98131241e-03f, -1.90441743e-01f, 1.14469789e-01f, 1.54017061e-01f, 1.79648116e-01f, 1.16153203e-01f, 6.56670779e-02f, -9.51941218e-03f, -1.79229647e-01f,
  -1.10899098e-02f, -9.17162970e-02f, 7.17447996e-02f, 6.02668934e-02f, -4.62175906e-02f, 1.03221305e-01f, -1.01943970e-01f, -8.36764947e-02f, 7.78844580e-02f, 4.45598774e-02f,
  -6.05862960e-02f, -4.17523086e-02f, 5.27661294e-02f, -8.95031393e-02f, -4.46535721e-02f, -1.28842577e-01f, -7.90388063e-02f, 6.56956807e-02f, 5.01388498e-02f, 5.94008565e-02f,
  -7.85196759e-03f, 5.37526421e-02f, 5.30181862e-02f, 5.09529822e-02f, -4.85568419e-02f, 1.87561791e-02f, 6.21890202e-02f, 5.08454144e-02f, 8.80300254e-03f, -5.42355701e-02f,
  -2.90345103e-02f, -5.79329431e-02f, 2.62002461e-02f, -3.92668769e-02f, 2.73608025e-02f, -1.54330647e-02f, -1.39471013e-02f, 1.67651772e-02f, 5.03830053e-02f, 3.46772745e-02f,
  6.87814057e-02f, -6.39053136e-02f, -2.49119587e-02f, -7.35301003e-02f, 6.95263082e-03f, 3.38300876e-02f, -1.07743457e-01f, 3.53650190e-02f, 2.49007419e-02f, 1.86760239e-02f,
  3.17318551e-02f, 5.91733530e-02f, 7.42103308e-02f, 2.09877305e-02f, 3.89242731e-02f, 1.81362336e-03f, -1.00698344e-01f, -4.06680554e-02f, 2.53257100e-02f, -3.57168689e-02f,
  -5.98318614e-02f, -4.51874323e-02f, 1.42457550e-02f, -9.97027308e-02f, 6.25464097e-02f, 2.33431775e-02f, -1.16725281e-01f, -4.39360589e-02f, 1.38207063e-01f, 1.88770015e-02f,
  1.61652923e-01f, -3.65040009e-03f, -1.09865353e-01f, 1.17555670e-01f, -1.97199002e-01f, -5.48117459e-02f, 1.06280580e-01f, -2.78972723e-02f, -5.81361353e-02f, 9.83372778e-02f,
  -4.33911942e-03f, 9.62369367e-02f, 3.46404426e-02f, 3.79576460e-02f, -6.94073969e-03f, -4.06974033e-02f, 1.29961893e-01f, 3.51146087e-02f, -6.90419078e-02f, -1.41036570e-01f,
  4.54534180e-02f, -6.32165223e-02f, -4.46474040e-03f, 4.63717990e-03f, 2.10602190e-02f, 6.14722371e-02f, 1.59175500e-01f, 1.29303455e-01f, -1.12394162e-01f, 6.98134378e-02f,
  -2.42609177e-02f, -2.40081921e-02f, -9.51117724e-02f, 4.37413044e-02f, 9.07135084e-02f, 1.39644787e-01f, 9.29630548e-02f, 3.55232097e-02f, 8.03694203e-02f, -2.59958999e-03f,
  3.88022661e-02f, 8.11349377e-02f, -1.26057729e-01f, 1.44822568e-01f, -1.32181540e-01f, -1.02394991e-01f, 2.23278895e-01f, 7.48194978e-02f, 8.12089816e-02f, -6.77503720e-02f,
  1.18155845e-01f, -1.28808916e-01f, -1.58412114e-01f, -6.55713975e-02f, -1.22760214e-01f, -9.41010267e-02f, 1.07458681e-01f, -1.88908070e-01f, 8.92493427e-02f, 3.26429717e-02f,
  1.16866156e-01f, -7.84020796e-02f, -1.00021683e-01f, -8.84211063e-02f, -1.02066189e-01f, 1.96433291e-02f, -8.33036602e-02f, -5.95275238e-02f, 2.00703681e-01f, 2.40308359e-01f,
  9.40189734e-02f, -2.25349665e-02f, 1.78312580e-03f, 3.68236937e-02f, 5.81576079e-02f, -1.43789053e-01f, 5.80621623e-02f, 4.66374867e-02f, -6.59501255e-02f, 5.03608659e-02f,
  2.83574015e-02f, -3.35980803e-02f, 1.65384244e-02f, 3.13154832e-02f, -8.93132612e-02f, 2.50334628e-02f, -1.12238880e-02f, -9.44381878e-02f, -5.52417152e-02f, -7.53196999e-02f,
  -1.66334644e-01f, -5.29373810e-02f, -9.09908034e-04f, 4.07462530e-02f, 1.91437062e-02f, -1.72229931e-02f, -7.62530323e-03f, 8.71050358e-03f, 7.48658776e-02f, -2.67526712e-02f,
  -6.90303072e-02f, -1.03093319e-01f, -2.51562726e-02f, 7.35036805e-02f, -1.81159824e-02f, 7.59018585e-02f, 2.00594105e-02f, 1.76658314e-02f, -7.51255229e-02f, -2.15102378e-02f,
  8.35130587e-02f, -1.51037171e-01f, 5.30414842e-02f, 6.56220391e-02f, 1.37740880e-01f, -5.87124713e-02f, 5.17544746e-02f, 6.34714514e-02f, 1.53973559e-02f, 1.07732557e-01f,
  -5.54483533e-02f, -7.66895059e-03f, -5.21957316e-02f, -2.66880579e-02f, -1.17157474e-01f, -1.98004112e-01f, -1.15579709e-01f, -1.23704053e-01f, 8.59939903e-02f, 3.36244516e-02f,
  3.80614661e-02f, 4.65496667e-02f, 1.78234473e-01f, 7.43435472e-02f, -2.37582270e-02f, -8.76835138e-02f, -1.82111096e-02f, 9.02137160e-03f, 4.12931331e-02f, -1.62475049e-01f,
  -1.16567425e-02f, 6.34659687e-03f, -7.93095902e-02f, -1.34891504e-02f, 1.42793894e-01f, -1.28333224e-02f, 8.69958028e-02f, -4.36494723e-02f, -6.41644001e-02f, -4.43594418e-02f,
  1.12842686e-01f, -3.24997380e-02f, -3.75735350e-02f, 9.46614444e-02f, -5.17168194e-02f, -1.00764893e-02f, -8.23201910e-02f, -9.06248093e-02f, -9.27625969e-02f, -1.06295824e-01f,
  -5.02560325e-02f, 9.34270471e-02f, -5.48811220e-02f, -5.91598302e-02f, -8.33277851e-02f, 1.92364857e-01f, 5.65001182e-02f, -1.35228895e-02f, 1.41723037e-01f, -7.33137876e-03f,
  -1.22191645e-01f, -1.97065607e-01f, -4.79987413e-02f, 5.84949329e-02f, -2.32694224e-02f, -1.93675965e-01f, -1.69153046e-02f, -6.65765256e-02f, 4.97343950e-02f, 1.58440366e-01f,
  1.54277056e-01f, 6.58342391e-02f, 1.12375796e-01f, 2.79123448e-02f, 1.23607786e-02f, 1.85330585e-02f, 1.99748147e-02f, -1.30432770e-01f, -6.68352097e-02f, -1.47945900e-02f,
  -1.31174237e-01f, 9.18730870e-02f, 5.25942780e-02f, 9.81556252e-02f, 8.57753009e-02f, 2.70629764e-01f, 2.36326586e-02f, 3.73560637e-02f, 1.77827049e-02f, 4.78778556e-02f,
  3.46359611e-02f, -1.21173952e-02f, 2.42948942e-02f, 1.05059609e-01f, 3.33486870e-02f, 7.00640725e-03f, 4.78381850e-02f, 3.36644314e-02f, -2.05441248e-02f, 8.72947052e-02f,
  4.05007899e-02f, -4.00754958e-02f, 2.22311467e-02f, -4.49733958e-02f, 4.41032946e-02f, 1.31520033e-02f, 1.01719545e-02f, -6.23664781e-02f, 1.43560767e-01f, 3.04949246e-02f,
  -9.41706263e-03f, 1.18482588e-02f, -1.28411790e-02f, -5.30905128e-02f, 1.21946987e-02f, 5.43158278e-02f, -3.51873524e-02f, -6.01939522e-02f, 4.37177606e-02f, 1.46880737e-02f,
  4.96503636e-02f, 4.27097194e-02f, -2.83919461e-02f, -4.86949086e-02f, -1.47900656e-01f, -7.18592992e-03f, 2.66006943e-02f, -1.77992019e-03f, -2.28724331e-02f, 9.33021680e-02f,
  -9.84324887e-02f, 6.65590316e-02f, 2.50195842e-02f, 6.16306663e-02f, -4.75085899e-02f, 4.12233323e-02f, 6.27767965e-02f, -5.28070480e-02f, 1.77549049e-02f, -4.72344793e-02f,
  -6.96419105e-02f, -1.21723302e-01f, -3.37742013e-03f, -4.70770581e-04f, 4.39974070e-02f, -1.66370794e-02f, 1.75727112e-03f, 1.02635948e-02f, -9.52229202e-02f, 2.40522586e-02f,
  -1.54600620e-01f, -1.46089941e-01f, -4.20871899e-02f, -5.93288466e-02f, -4.11906689e-02f, 4.22928557e-02f, -1.14017621e-01f, 1.85666513e-02f, -8.26895833e-02f, -3.63211334e-02f,
  3.76138501e-02f, 2.63469964e-02f, -8.83867592e-02f, -9.63788386e-03f, 4.66809534e-02f, 4.97874394e-02f, -6.94216415e-02f, 1.27493059e-02f, 1.16951123e-01f, 4.17690910e-02f,
  8.49105641e-02f, -6.25757724e-02f, -4.80913185e-03f, 5.01706451e-02f, -2.61642262e-02f, 6.96584433e-02f, -5.56439608e-02f, 1.43927142e-01f, 8.17653015e-02f, -1.23533227e-01f,
  -1.61960535e-02f, -3.34059186e-02f, -4.40350547e-02f, -1.20008521e-01f, 9.16450024e-02f, 1.12498790e-01f, -1.48602463e-02f, 3.06353997e-02f, 3.17814499e-02f, 1.83906272e-01f,
  -1.22322887e-01f, -1.06024705e-02f, 1.78177450e-02f, -1.05249390e-01f, -5.58089698e-03f, 5.93359619e-02f, 3.81430201e-02f, -1.22121185e-01f, -1.15167171e-01f, -1.52328640e-01f,
  -1.15410596e-01f, 6.86339810e-02f, -1.38287291e-01f, -3.57951112e-02f, 3.43542770e-02f, -2.74840742e-02f, -6.26463443e-02f, -8.10657814e-02f, 1.98871255e-01f, -1.48012102e-01f,
  -1.03009805e-01f, 1.35328382e-01f, 1.19028859e-01f, -3.32095057e-01f, 2.35388260e-02f, -3.36619988e-02f, 9.07898620e-02f, -1.74259171e-01f, 9.04657319e-02f, 1.42324448e-01f,
  9.57613112e-04f, -1.80660505e-02f, 2.54105758e-02f, -6.43844754e-02f, -3.28147560e-02f, 1.27856452e-02f, -2.16847770e-02f, 1.12194531e-02f, 6.94096386e-02f, 6.31852821e-02f,
  -2.20197309e-02f, -6.42526448e-02f, 6.50879592e-02f, 2.35964470e-02f, 1.85708225e-01f, -8.68562330e-03f, 1.60696402e-01f, 3.73850949e-02f, 3.73504534e-02f, 3.73050794e-02f,
  1.33732809e-02f, 4.63031307e-02f, -5.37560619e-02f, -8.97313282e-03f, -2.18231715e-02f, -2.62780767e-02f, -8.00189376e-02f, 2.78798174e-02f, 9.92051437e-02f, -4.04981300e-02f,
  5.41701540e-02f, -5.10422466e-03f, -1.04565686e-02f, -2.91005652e-02f, -9.74490792e-02f, -1.06848650e-01f, 4.32888791e-02f, -2.86464635e-02f, 6.15540296e-02f, 8.58111456e-02f,
  4.76912484e-02f, 2.76529081e-02f, -3.52823995e-02f, 2.20508352e-02f, 4.65740897e-02f, 7.74779618e-02f, 6.31592944e-02f, -2.28579044e-02f, -5.13736345e-02f, -1.40077382e-01f,
  4.51360550e-03f, -2.56515332e-02f, -1.65869683e-01f, -1.27411604e-01f, -1.14739470e-01f, -6.87113926e-02f, 5.16827255e-02f, -3.30272596e-03f, 9.03995987e-03f, -5.95910437e-02f,
  -8.63288417e-02f, 6.30651265e-02f, -6.74169511e-02f, -2.02822257e-02f, -2.62463782e-02f, -1.06387630e-01f, -1.22647703e-01f, -7.64643028e-02f, -3.78602594e-02f, 1.35131069e-02f,
  -1.25128254e-01f, -1.74309174e-03f, 1.74451470e-02f, 1.24193028e-01f, 7.55478740e-02f, 3.97234261e-02f, 4.28268593e-03f, 1.09525593e-02f, -1.47057343e-02f, -4.32483703e-02f,
  -7.79639408e-02f, -8.59147459e-02f, 1.22353673e-01f, -1.57350264e-02f, -2.61332579e-02f, 6.34820387e-03f, 1.70989856e-01f, -5.32479770e-02f, -1.64202899e-01f, -6.82951957e-02f,
  -9.03001204e-02f, -7.32468516e-02f, 1.73291992e-02f, 1.35074817e-02f, -5.90744354e-02f, -1.06492937e-01f, 8.01356975e-03f, -1.81261599e-01f, 8.44009370e-02f, 2.85238046e-02f,
  2.54772324e-02f, -1.61556959e-01f, -5.47440387e-02f, 1.28413543e-01f, -7.27984086e-02f, 8.11605621e-03f, -7.54952244e-03f, -2.54313797e-01f, -4.61527221e-02f, 1.15042202e-01f,
  -7.07850084e-02f, 1.41243175e-01f, -6.07611164e-02f, 9.48271155e-02f, 1.80724785e-02f, -9.77258161e-02f, 5.67838848e-02f, -9.89362076e-02f, -6.23002509e-03f, 1.44220397e-01f,
  1.12875432e-01f, -1.16650611e-01f, 6.10680766e-02f, -5.35802692e-02f, 1.50719685e-02f, 4.30199504e-02f, 1.37229552e-02f, 2.77790576e-02f, 4.33918759e-02f, 2.47174632e-02f,
  -5.48914522e-02f, -6.57363422e-03f, 1.44684808e-02f, 8.92038494e-02f, 3.75292525e-02f, 2.66737137e-02f, 8.58655423e-02f, -1.74391251e-02f, 1.96392518e-02f, -1.80966035e-03f,
  -4.80678231e-02f, 1.32444456e-01f, -9.83804837e-02f, -2.48947348e-02f, 1.11944452e-01f, 8.08804855e-03f, -5.05488515e-02f, -6.79618446e-03f, -4.25812900e-02f, 6.45138845e-02f,
  -4.10160646e-02f, 1.34824380e-01f, -5.27637228e-02f, 1.55771434e-01f, 1.35231735e-02f, 3.15270089e-02f, -2.69606756e-03f, -6.19472656e-03f, -2.55274307e-02f, -8.88916552e-02f,
  -6.23526871e-02f, 5.54009117e-02f, 1.76674500e-01f, 4.40824479e-02f, -1.96388960e-02f, 5.08484170e-02f, -4.08962294e-02f, -2.13939361e-02f, -4.24727015e-02f, 3.48571911e-02f,
  5.28882397e-03f, -2.28534322e-02f, 8.46950039e-02f, -3.32387872e-02f, 1.07248249e-02f, -7.21073598e-02f, 2.38017906e-02f, 4.81680706e-02f, 3.83044183e-02f, 1.75646804e-02f,
  1.43402978e-03f, 2.18881238e-02f, 1.28317308e-02f, 3.91472541e-02f, -1.02551997e-01f, 9.75445956e-02f, -2.16970537e-02f, -1.41691342e-01f, 6.01723325e-03f, -4.33580503e-02f,
  1.87058207e-02f, -7.62409046e-02f, 4.98563498e-02f, 1.59777597e-01f, 7.82098342e-03f, -4.35245633e-02f, -2.35211700e-02f, 1.64792970e-01f, -7.91563541e-02f, 3.10516544e-02f,
  -1.01362735e-01f, -1.73260093e-01f, -1.58113807e-01f, -9.62242112e-02f, -9.40194502e-02f, -9.85965803e-02f, 8.47314224e-02f, -7.11313915e-03f, -3.21832597e-02f, -7.27838501e-02f,
  -1.24279872e-01f, -7.32946619e-02f, 9.26602855e-02f, 6.43615052e-02f, -5.46166599e-02f, -1.04173295e-01f, 4.92419191e-02f, 5.05006015e-02f, 5.02001159e-02f, -5.27731292e-02f,
  3.91563885e-02f, -4.47032154e-02f, -1.43740932e-02f, -6.93797646e-03f, 1.03787472e-02f, 3.40900794e-02f, -6.87933192e-02f, -7.21599683e-02f, 2.68696584e-02f, 8.71680900e-02f,
  3.67611870e-02f, 2.63561785e-01f, -5.89704141e-02f, -6.06772229e-02f, 4.44050543e-02f, 1.49679467e-01f, -9.11580399e-03f, 7.31046423e-02f, -1.22271180e-02f, -1.54744998e-01f,
  5.65112978e-02f, 1.01263128e-01f, 8.08629915e-02f, 1.02758221e-01f, -1.76918313e-01f, -5.90549633e-02f, -6.57480955e-02f, -1.35549018e-02f, -2.01757578e-03f, -1.81427047e-01f,
  -7.14374334e-02f, 1.17043108e-02f, 4.22083326e-02f, -1.47768468e-01f, -9.60723124e-03f, 1.42441262e-02f, 6.14530919e-03f, 2.79300474e-02f, 4.87516075e-02f, -6.99864551e-02f,
  4.97390702e-02f, 4.26142337e-03f, -4.60350998e-02f, 7.84698129e-03f, -2.11248174e-02f, -4.64082174e-02f, 1.63864400e-02f, -1.21591818e-02f, 4.26829932e-03f, -2.10818294e-02f,
  2.62729153e-02f, 6.62192842e-03f, 1.16522253e-01f, 3.06897480e-02f, 3.09681110e-02f, 2.98801735e-02f, 6.16380312e-02f, 3.94702144e-02f, 3.35786268e-02f, 8.09342638e-02f,
  4.11623269e-02f, -6.51794448e-02f, 1.15575626e-01f, -1.27353787e-01f, 7.92889111e-03f, -4.29335050e-02f, -3.06049045e-02f, 2.91635748e-02f, -5.69131337e-02f, 1.47127314e-02f,
  2.29004622e-02f, 4.47489321e-03f, 7.30965212e-02f, 1.94998644e-02f, 2.39740927e-02f, 7.83677474e-02f, 3.94656174e-02f, 1.07448928e-01f, -5.44566475e-02f, -6.02986570e-03f,
  -6.92334250e-02f, -1.34049878e-02f, -4.48774286e-02f, 1.53878797e-02f, 1.91767979e-02f, -1.10695483e-02f, 4.65137921e-02f, 8.28439072e-02f, 5.30847609e-02f, -1.53545916e-01f,
  -1.19689196e-01f, 1.73924249e-02f, 1.14098676e-01f, -1.41800018e-02f, -1.00833960e-01f, -1.46548614e-01f, 6.72229528e-02f, -1.32694155e-01f, 7.44862035e-02f, 4.28162562e-03f,
  -1.89291134e-01f, 7.59721994e-02f, -1.39013365e-01f, 1.19586378e-01f, -1.86350465e-01f, 5.77437431e-02f, -8.77294019e-02f, 5.10940887e-02f, 1.29361182e-01f, 1.83846459e-01f,
  6.20864658e-03f, 1.11753136e-01f, -4.05017333e-03f, 1.21144885e-02f, -1.63571626e-01f, 1.14278950e-01f, -3.78815159e-02f, -9.34029967e-02f, 1.22610569e-01f, -1.39298037e-01f,
  -8.30432698e-02f, -2.46773288e-02f, 9.93916467e-02f, -1.32449254e-01f, -1.05187394e-01f, -6.49726018e-02f, -9.95837003e-02f, -1.00003127e-02f, 9.10331607e-02f, -1.18328311e-01f,
  7.66157284e-02f, -5.12944721e-02f, 1.46941692e-01f, 1.03585616e-01f, -5.31467050e-02f, 1.85521301e-02f, 2.01831385e-02f, -5.33196852e-02f, 9.81569570e-03f, 6.83707744e-02f,
  -1.99767202e-02f, -1.82825759e-01f, -1.00253969e-01f, -1.99416384e-01f, -1.20000392e-01f, -1.75334997e-02f, 2.91832518e-02f, 9.69505236e-02f, -1.07551239e-01f, 1.55583313e-02f,
  3.81767340e-02f, -1.02964729e-01f, 1.09807558e-01f, -1.47646517e-01f, 1.17327444e-01f, 8.15209895e-02f, 8.37308541e-02f, -2.61462063e-01f, 2.35419981e-02f, 1.00423664e-01f,
  -1.01149708e-01f, -2.60012783e-03f, -7.07227271e-03f, -7.34853745e-02f, 4.51635867e-02f, 8.61587003e-02f, -2.42573805e-02f, 8.94970894e-02f, 7.68704265e-02f, 2.06547417e-02f,
  4.73214127e-02f, 1.30969351e-02f, -1.70368105e-02f, -5.35062961e-02f, 9.95042250e-02f, 2.37682182e-02f, -3.04640993e-03f, 8.04988891e-02f, 3.70628275e-02f, -7.85357133e-02f,
  2.52899062e-02f, 3.60854669e-03f, 7.08553940e-03f, 9.04590189e-02f, -3.09577566e-02f, -7.67579451e-02f, 9.27349083e-06f, -2.49790084e-02f, 9.58951935e-03f, -1.71340093e-01f,
  -6.66113719e-02f, -1.62858292e-02f, 1.14657067e-01f, 1.48717323e-02f, -1.90509222e-02f, -7.74529856e-03f, -1.63666420e-02f, -2.37771627e-02f, 7.92228803e-02f, -2.47967485e-02f,
  -9.97868329e-02f, 1.39866844e-01f, -5.30098714e-02f, 6.69862777e-02f, -4.58383001e-02f, 9.01278853e-03f, 2.36270316e-02f, 4.52139787e-02f, 4.33927141e-02f, -3.44470628e-02f,
  -1.93778016e-02f, 7.41288858e-03f, -9.83268302e-03f, 2.31685359e-02f, -1.78424350e-03f, 4.44954298e-02f, 2.20173270e-01f, 1.84608564e-01f, 6.18869103e-02f, 3.64678875e-02f,
  -1.29169315e-01f, 8.89632851e-02f, -9.66951326e-02f, -1.47809321e-02f, 8.71557817e-02f, -1.69613436e-01f, -1.36125073e-01f, 1.97989821e-01f, -2.80195009e-02f, -1.19582741e-02f,
  -8.95239487e-02f, -5.41040413e-02f, 3.47552262e-02f, -1.11779988e-01f, 7.80519918e-02f, -6.21785820e-02f, -1.03583550e-02f, -1.13882631e-01f, 2.50805933e-02f, -1.79135114e-01f,
  2.33328063e-03f, 9.09908786e-02f, 5.34920581e-02f, -1.86457247e-01f, 7.28954449e-02f, 6.93483129e-02f, -1.10532239e-01f, 1.74487919e-01f, 8.31826183e-05f, 1.99841671e-02f,
  -2.93479357e-02f, -1.74997851e-01f, 9.40688550e-02f, -1.17882658e-02f, -5.23767099e-02f, -5.01098707e-02f, 2.04619672e-03f, 5.99658117e-02f, 8.91127735e-02f, 3.69161293e-02f,
  -1.13877609e-01f, 8.37910324e-02f, -1.24440745e-01f, 7.78276920e-02f, 5.57136126e-02f, 1.19561136e-01f, 5.83491959e-02f, -1.62785441e-01f, 5.40450849e-02f, -2.12048013e-02f,
  -1.24648891e-01f, 1.67764306e-01f, -1.22130200e-01f, 3.97054404e-02f, 2.17002761e-02f, 9.50228497e-02f, 5.43020070e-02f, 4.08946648e-02f, -7.63315633e-02f, 9.99116227e-02f,
  2.46441156e-01f, -4.25319783e-02f, -2.01840643e-02f, 6.96929097e-02f, 4.12022211e-02f, -2.52207637e-01f, 5.37408292e-02f, 5.80245331e-02f, 1.16632000e-01f, -1.36823803e-01f,
  2.33852840e-03f, -2.17927415e-02f, 6.52084202e-02f, -4.91894111e-02f, 7.58535117e-02f, -1.56780165e-02f, -2.99130268e-02f, -7.45906159e-02f, -2.03180383e-03f, -5.91767728e-02f,
  -5.58307208e-02f, 5.99255189e-02f, 5.31365052e-02f, 5.44997975e-02f, -9.36292112e-02f, -6.47638738e-02f, -4.15965728e-02f, 1.00575402e-01f, -1.19165353e-01f, 2.04890855e-02f,
  3.58784348e-02f, -4.37598974e-02f, 4.73700874e-02f, 6.81303069e-02f, -6.16064183e-02f, 1.72291044e-02f, 4.39708158e-02f, -1.34965265e-03f, 1.99328996e-02f, -3.56149860e-02f,
  -7.35101402e-02f, 1.03715941e-01f, 3.34981456e-02f, 4.41244729e-02f, 3.72423381e-02f, 4.04643901e-02f, 4.75135520e-02f, -7.70187005e-02f, 2.02147868e-02f, -4.05113250e-02f,
  1.40671462e-01f, 1.18262973e-02f, 9.47845057e-02f, -3.43914665e-02f, 4.14267601e-03f, 8.30181465e-02f, -2.75972057e-02f, 1.67338010e-02f, -2.71435231e-02f, 9.77190882e-02f,
  1.50562208e-02f, -2.75277738e-02f, -2.75603328e-02f, -4.10650335e-02f, -5.56414686e-02f, -1.24069378e-01f, -3.21227387e-02f, -4.25692387e-02f, 6.07261658e-02f, 2.65617520e-02f,
  -5.46664223e-02f, -3.97821777e-02f, 6.97438344e-02f, -5.16713485e-02f, 9.86249298e-02f, 8.98227319e-02f, -1.67493825e-03f, 2.65368391e-02f, 1.21963575e-01f, 1.45773858e-01f,
  -6.87530637e-02f, -7.61642829e-02f, 7.04007968e-02f, -7.49011412e-02f, 1.12495802e-01f, 4.13372107e-02f, 1.05144158e-01f, 5.47917672e-02f, 2.35226434e-02f, 3.57475542e-02f,
  -2.07423896e-01f, 2.10007638e-01f, 9.35389008e-03f, 4.75944802e-02f, 3.66608314e-02f, 1.36721777e-02f, -7.51518756e-02f, -3.39349471e-02f, 4.28617746e-02f, 9.55384299e-02f,
  6.73256768e-03f, 4.28154022e-02f, -6.18639328e-02f, 1.17691539e-01f, 1.30411133e-01f, -1.81035753e-02f, 6.65905327e-02f, 8.14260691e-02f, -1.91438403e-02f, 5.24611622e-02f,
  -9.24186185e-02f, 6.81929383e-03f, 6.78824782e-02f, -1.72107652e-01f, -9.35007334e-02f, -1.34254873e-01f, 8.11535195e-02f, -1.83428507e-02f, -2.48009954e-02f, -8.98028910e-02f,
  -1.57556478e-02f, -1.23963609e-01f, 8.07860717e-02f, -9.85650346e-02f, 2.82156188e-02f, -1.33417800e-01f, -4.84019332e-02f, -1.30612880e-01f, -3.19246948e-02f, -6.73029646e-02f,
  3.52306925e-02f, -1.60105869e-01f, -4.01018672e-02f, 1.51590168e-01f, -1.85061023e-02f, 8.07001144e-02f, 3.46518531e-02f, 1.99073941e-01f, 2.31590718e-02f, 1.26997633e-02f,
  2.22826786e-02f, 4.05963808e-02f, -2.62915995e-02f, -2.89755948e-02f, -2.14691721e-02f, -1.35157444e-02f, -8.50985292e-03f, 5.87356277e-02f, 2.94343755e-02f, -3.05653252e-02f,
  -1.19952008e-01f, 3.00180130e-02f, -1.21402994e-01f, -4.95774634e-02f, -8.07673186e-02f, 3.63423862e-03f, -7.07429945e-02f, -2.99704112e-02f, -5.66721521e-03f, -3.21234316e-02f,
  -7.38893822e-03f, -6.15150407e-02f, 3.55685176e-03f, -3.89302522e-02f, 1.27141178e-02f, 7.93587342e-02f, 7.13685155e-02f, 6.58383220e-02f, -1.00899898e-01f, -9.63309407e-03f,
  1.55569594e-02f, -1.03172697e-01f, 1.06490754e-01f, -3.96494418e-02f, 3.54227424e-02f, -3.05887200e-02f, -3.88976522e-02f, -6.14210702e-02f, 4.12901975e-02f, -1.12898402e-01f,
  -8.56228322e-02f, -1.06718019e-02f, -2.19706446e-03f, -5.43227606e-02f, -1.03007525e-01f, -5.86863980e-03f, -6.35890290e-02f, -3.66941728e-02f, 1.18725393e-02f, -4.34312895e-02f,
  8.13557059e-02f, 1.13726877e-01f, 5.44703752e-02f, -2.70046014e-02f, -3.88072021e-02f, -5.04341498e-02f, -1.92824248e-02f, -4.71474528e-02f, -1.50705189e-01f, -3.96576114e-02f,
  3.44182067e-02f, 1.11984134e-01f, 1.60543814e-01f, 2.11374718e-03f, -4.37103063e-02f, 1.28426775e-01f, 8.51806253e-03f, 9.56579670e-02f, -1.40100857e-02f, 1.07168987e-01f,
  -6.05596155e-02f, 8.00376534e-02f, -5.75752147e-02f, 4.90547344e-02f, 2.57504117e-02f, 8.23213831e-02f, -1.21075630e-01f, 1.58683341e-02f, -1.06077366e-01f, 7.15087578e-02f,
  5.56454845e-02f, 1.09781355e-01f, 9.55137163e-02f, 3.96671705e-02f, -1.83896907e-02f, 1.33223683e-01f, 3.89356539e-02f, -7.58251995e-02f, 5.54242730e-02f, 8.47488940e-02f,
  9.00700241e-02f, 1.28943939e-02f, 2.05391143e-02f, -1.48402797e-02f, -3.78603116e-02f, 1.35381550e-01f, 1.22973658e-01f, 1.83715686e-01f, 9.71519276e-02f, -1.25155285e-01f,
  5.78268319e-02f, 1.88098215e-02f, 2.83944439e-02f, -1.20448358e-02f, 1.22586206e-01f, -1.18202709e-01f, -1.39551016e-03f, -1.99999467e-01f, -6.05283491e-02f, -9.23524052e-02f,
  -4.88687456e-02f, -1.53935388e-01f, -4.51744944e-02f, 8.96337256e-03f, 8.75196084e-02f, -1.08647853e-01f, -1.51706599e-02f, -9.02912915e-02f, -1.44756079e-01f, -2.00131536e-01f,
  -9.05531570e-02f, 1.36566743e-01f, 2.98495870e-03f, 1.03764251e-01f, -1.05161712e-01f, -5.10607138e-02f, -4.01496179e-02f, -4.51436937e-02f, -1.34259045e-01f, 7.22637326e-02f,
  -1.28611639e-01f, -7.99256265e-02f, 3.06292973e-03f, -5.10350689e-02f, -5.36408313e-02f, -9.65868123e-03f, 3.47068645e-02f, -5.84463961e-02f, -5.60668632e-02f, -8.58679712e-02f,
  1.13951378e-02f, 1.12625711e-01f, 3.52265276e-02f, 5.08514047e-02f, -1.57846399e-02f, -1.00451345e-02f, -3.42407189e-02f, -3.77633460e-02f, -3.34309526e-02f, -8.52281153e-02f,
  -6.96646944e-02f, -4.71341424e-02f, -5.81721105e-02f, -5.48943728e-02f, -1.12709182e-03f, 5.31577915e-02f, -7.86548555e-02f, -1.55945197e-01f, 9.38922516e-04f, -1.18911996e-01f,
  -6.07693009e-03f, -2.44139452e-02f, -5.46594858e-02f, 3.37952934e-02f, -6.27201200e-02f, 4.39519212e-02f, -5.57563901e-02f, -1.50418341e-01f, -1.26926735e-01f, 1.69340540e-02f,
  8.04465916e-03f, -9.88057107e-02f, -9.31034796e-03f, -1.05010875e-01f, 6.72576874e-02f, -3.03068422e-02f, 5.97439706e-02f, 1.78932369e-01f, 1.42496064e-01f, 1.38357639e-01f,
  1.08814351e-01f, 1.03201345e-01f, -1.08046368e-01f, 2.92726085e-02f, 1.50778303e-02f, -1.20829046e-01f, 1.16073303e-02f, 6.74817860e-02f, 6.33381680e-02f, 9.10353661e-02f,
  5.64552993e-02f, -8.52716342e-02f, -1.86515190e-02f, 1.44860372e-01f, -7.82964453e-02f, 1.06262945e-01f, 3.98169532e-02f, 9.79803801e-02f, -1.64230868e-01f, 9.23646241e-02f,
  -9.66581851e-02f, 2.53454000e-02f, -5.26685230e-02f, 1.10990927e-01f, -2.24402919e-01f, 9.27814841e-03f, 5.22951223e-03f, -6.60332590e-02f, -2.18210891e-02f, -2.89554633e-02f,
  1.02045171e-01f, 1.97825339e-02f, 4.84877750e-02f, 1.48091450e-01f, 5.50914463e-03f, -1.07123733e-01f, -2.27710139e-03f, 5.27762882e-02f, 1.32732436e-01f, -1.96780428e-01f,
  -1.71937823e-01f, 1.40769016e-02f, -1.62532777e-01f, -3.54630724e-02f, 8.18994418e-02f, 1.79626923e-02f, 1.79391563e-01f, -8.50703865e-02f, -9.11094695e-02f, 1.98765501e-01f,
  3.04821581e-02f, 9.76810232e-02f, 1.34881726e-02f, -5.89507595e-02f, -6.45620525e-02f, 1.12451809e-02f, -3.68047506e-02f, -3.78179178e-02f, -1.09152924e-02f, 2.26270601e-01f,
  -1.45418435e-01f, 1.82342499e-01f, 7.24402294e-02f, 8.93637612e-02f, 6.52370453e-02f, -1.28495097e-02f, 5.97691797e-02f, -1.55766279e-01f, -1.30734310e-01f, -8.29990879e-02f,
  5.34275249e-02f, -5.06433137e-02f, -1.90920696e-01f, -1.62557870e-01f, -9.54070129e-03f, -6.49735034e-02f, -7.86949322e-03f, -6.90289140e-02f, -1.77241843e-02f, 2.34239474e-02f,
  3.24689932e-02f, -2.79681012e-03f, 2.96862535e-02f, -6.26844466e-02f, -2.68631987e-02f, -2.10079961e-02f, -4.29371409e-02f, 8.24548602e-02f, -8.67028683e-02f, 8.69743712e-03f,
  -4.32722345e-02f, -2.69506872e-02f, -9.07263532e-02f, 2.46866941e-02f, -7.52103422e-03f, -4.43456508e-02f, -5.21509722e-02f, -5.33199571e-02f, 3.71802715e-03f, 3.81715335e-02f,
  2.20836909e-03f, 9.76831242e-02f, -7.59972855e-02f, 5.60371093e-02f, 1.68597065e-02f, -8.30911249e-02f, 1.03725912e-02f, 9.39501636e-03f, 5.08059077e-02f, -4.80895787e-02f,
  1.64391547e-02f, -2.58196797e-02f, 1.83409750e-02f, -1.63642783e-02f, 4.83958274e-02f, -3.16462107e-02f, -8.60992819e-02f, -1.55811757e-01f, 4.36071791e-02f, 4.78947302e-03f,
  -2.44087949e-02f, 4.67319787e-02f, 1.08151464e-02f, -3.65839638e-02f, 2.11779848e-02f, 5.49520440e-02f, 2.10578963e-02f, 4.31219488e-02f, 2.31380258e-02f, 8.83789435e-02f,
  1.19252868e-01f, -8.04815590e-02f, -7.71763772e-02f, 1.97346181e-01f, -1.64946467e-02f, 7.23305121e-02f, 6.78464845e-02f, -3.24848853e-02f, -7.64061362e-02f, 1.71713997e-02f,
  1.74530759e-01f, -2.99124722e-03f, 1.26769960e-01f, -4.55684960e-02f, 1.15454465e-01f, -6.39538607e-03f, 1.87243670e-02f, 9.10935123e-05f, -8.44308063e-02f, -2.42941976e-01f,
  9.41069052e-02f, -1.06324859e-01f, -1.51376754e-01f, 4.30247076e-02f, 1.16285682e-01f, -5.84697314e-02f, 1.49397716e-01f, 1.20187856e-01f, -9.30222347e-02f, 6.95170835e-02f,
  6.15661517e-02f, -2.40556207e-02f, -6.17591552e-02f, 9.04479399e-02f, 6.65220022e-02f, 9.97868106e-02f, 8.92076083e-03f, 8.21156800e-02f, -1.43361026e-02f, 6.99171796e-02f,
  1.41656667e-01f, 8.60312134e-02f, -7.89115205e-02f, -2.99866311e-02f, -4.90158610e-03f, -2.26866063e-02f, 4.96993549e-02f, 1.71282515e-01f, 1.77368060e-01f, -7.57777095e-02f,
  -5.30335680e-02f, 9.09843594e-02f, 5.79803884e-02f, 2.08095700e-01f, -1.66785698e-02f, 6.51069777e-03f, 7.27093518e-02f, -1.11725807e-01f, 4.44491543e-02f, -6.47206232e-02f,
  8.63699913e-02f, 1.68685149e-02f, -7.00714588e-02f, 3.14175971e-02f, -1.48147881e-01f, -1.75464913e-01f, -3.84938084e-02f, 3.95441864e-04f, -5.67164347e-02f, 3.34514342e-02f,
  5.62017858e-02f, -7.12224022e-02f, -1.40275247e-02f, 5.07976711e-02f, -4.17870358e-02f, -1.03829883e-01f, 7.69150211e-03f, -1.10638179e-01f, -1.81831252e-02f, 6.92735836e-02f,
  -3.98262888e-02f, 1.01215355e-01f, 6.71805162e-03f, 6.63651451e-02f, -5.49223833e-02f, -1.51650831e-01f, 9.13628787e-02f, -1.09512016e-01f, -1.45039605e-02f, -1.69729348e-02f,
  8.24306384e-02f, 4.24773060e-02f, -2.68677715e-02f, -4.31832997e-03f, 7.97640681e-02f, 5.15051298e-02f, -2.43616197e-03f, 3.67262624e-02f, 1.85130239e-02f, -7.89435282e-02f,
  3.68791004e-03f, -1.38004884e-01f, -6.58271462e-02f, -3.09295729e-02f, -2.22115573e-02f, 1.89465620e-02f, -4.46261838e-02f, 4.59266044e-02f, -6.43243268e-02f, -9.66223795e-03f,
  6.42615110e-02f, -5.93975224e-02f, -1.63659174e-02f, 3.20740277e-03f, 6.56218156e-02f, 1.37750193e-01f, -1.29293380e-02f, 3.92125025e-02f, 7.20899701e-02f, -7.12146908e-02f,
  1.55127859e-02f, -2.59122532e-02f, -9.20631289e-02f, 2.28284299e-02f, -5.76556735e-02f, -1.15439042e-01f, -9.31995139e-02f, -5.70135489e-02f, 7.43616596e-02f, -9.95625928e-03f,
  6.47696331e-02f, -8.76977891e-02f, -1.54649329e-04f, 3.93506512e-02f, -5.78069501e-02f, -1.64664611e-02f, 4.67762947e-02f, -6.93800002e-02f, -7.65410364e-02f, -7.50694722e-02f,
  -5.31844385e-02f, -1.61634083e-03f, -1.44337341e-01f, -2.30706661e-04f, 1.73351523e-02f, 7.15914089e-03f, -2.22029760e-02f, 4.61485200e-02f, -1.54597104e-01f, 5.30406386e-02f,
  2.06135362e-01f, -1.26590878e-01f, -1.95770729e-02f, 3.02467197e-02f, -6.87137023e-02f, -1.07430138e-01f, -9.02317017e-02f, -2.51481712e-01f, -9.05470699e-02f, -6.36142939e-02f,
  -8.32360983e-02f, 2.45880950e-02f, -7.07826465e-02f, -6.68671206e-02f, -4.91143391e-03f, -6.39543757e-02f, 8.34959894e-02f, -1.00647561e-01f, -3.00420984e-03f, -2.27057800e-01f,
  -1.15911243e-02f, -4.94726337e-02f, 3.74266645e-03f, 5.48113175e-02f, 9.45280120e-03f, -1.24686033e-01f, -1.04135290e-01f, 1.47569627e-01f, 9.13137570e-02f, -1.62273515e-02f,
  5.08823469e-02f, -1.42913908e-01f, -1.37949251e-02f, 7.22101033e-02f, 3.21600251e-02f, 1.67402532e-02f, 1.77030650e-03f, -1.13599688e-01f, -1.02763632e-02f, -8.12694654e-02f,
  -1.11401074e-01f, -1.11132801e-01f, 9.28097665e-02f, 2.78306037e-01f, 7.19355717e-02f, -1.85518711e-05f, 3.24165598e-02f, -6.76900819e-02f, -2.16545276e-02f, 7.48659223e-02f,
  -3.38783860e-02f, 5.20994365e-02f, -4.40074615e-02f, -4.68950868e-02f, -1.02220245e-01f, 1.20926090e-02f, -4.13322356e-03f, 1.88096296e-02f, 3.81933562e-02f, 9.02422816e-02f,
  -1.59367863e-02f, 5.92943542e-02f, 4.69776336e-04f, -4.15786654e-02f, -2.62306724e-02f, -2.72944272e-02f, 6.17192090e-02f, -3.13084796e-02f, -1.31026417e-01f, 8.84246733e-03f,
  -2.03188905e-03f, -4.62366035e-03f, -5.33308052e-02f, -6.94668153e-04f, 1.52463969e-02f, -8.72841552e-02f, -5.45922332e-02f, 1.82736572e-02f, -1.13497078e-01f, 3.37750763e-02f,
  -9.37455222e-02f, -4.25234027e-02f, 3.70560288e-02f, 2.13912968e-02f, 4.24842685e-02f, -2.57889125e-02f, -1.32881822e-02f, 1.81352906e-02f, 1.64575167e-02f, -3.30949016e-02f,
  -9.50532779e-03f, -1.34994879e-01f, -5.67641370e-02f, -5.96698858e-02f, 4.63789068e-02f, -5.15702367e-02f, 9.66565609e-02f, 2.03243675e-04f, 9.04443860e-02f, 7.51533732e-03f,
  -4.81138043e-02f, 1.57636866e-01f, -4.76511428e-03f, -9.03308466e-02f, -4.17625047e-02f, 8.77680629e-02f, 1.07727937e-01f, 7.03780279e-02f, -1.20630600e-02f, -3.73299420e-02f,
  1.25017315e-01f, 1.97713792e-01f, -6.50160685e-02f, 9.48643759e-02f, -2.42176298e-02f, 2.29490530e-02f, 1.28064081e-01f, 6.02445798e-03f, 3.12265344e-02f, -2.57067736e-02f,
  8.08082148e-02f, -5.48687913e-02f, 8.16305205e-02f, -4.74353544e-02f, -1.86224565e-01f, -1.07608721e-01f, -1.28344223e-01f, -3.20057608e-02f, -1.49335423e-02f, -7.38347694e-02f,
  8.65833238e-02f, -1.53597305e-03f, -7.56864399e-02f, -5.73737361e-02f, -1.50986791e-01f, -9.99199674e-02f, 2.34594736e-02f, -3.40160616e-02f, -1.64935052e-01f, 7.83618018e-02f,
  -2.01512258e-02f, 2.92763580e-02f, 1.09225184e-01f, -1.70493927e-02f, -6.98151663e-02f, -1.26990555e-02f, -8.48121420e-02f, -9.12794322e-02f, -1.07359499e-01f, -9.04382020e-02f,
  1.00479305e-01f, -5.03302850e-02f, -5.57615198e-02f, 1.10922754e-01f, -6.22101873e-02f, 7.91346356e-02f, 5.35339266e-02f, 9.76693928e-02f, 3.84217314e-02f, 1.84090152e-01f,
  3.96031179e-02f, 6.25453750e-03f, -2.45571826e-02f, 7.04039782e-02f, 1.04230978e-01f, -1.86045747e-02f, -2.61352248e-02f, 7.12690279e-02f, -1.55359894e-01f, 3.53366472e-02f,
  3.21603306e-02f, 1.48592796e-02f, -5.84297590e-02f, 2.29266763e-01f, -7.12416992e-02f, -1.15324087e-01f, 3.06056291e-02f, 1.81306191e-02f, -6.23983424e-03f, -3.59333344e-02f,
  -5.29156365e-02f, 5.28859608e-02f, 4.55480777e-02f, -3.80902253e-02f, -3.89780737e-02f, 4.95859273e-02f, 4.84986603e-02f, 6.36127591e-02f, -3.02732103e-02f, -6.09772801e-02f,
  2.14279797e-02f, 2.42421012e-02f, -4.09274809e-02f, -6.82772696e-02f, -2.22812463e-02f, -4.15447094e-02f, 4.92868945e-02f, -7.16163730e-03f, -1.38281519e-02f, 1.81632340e-02f,
  5.34080043e-02f, -3.12619023e-02f, -3.26666012e-02f, 2.24228930e-02f, 5.30702770e-02f, 8.19279030e-02f, 1.18747890e-01f, 5.09171234e-03f, 9.59614441e-02f, -3.17669623e-02f,
  -2.89346501e-02f, -1.29739083e-02f, 2.91108359e-02f, -7.67452084e-03f, 8.19564834e-02f, -1.06463265e-02f, -5.66819422e-02f, -2.01065633e-02f, -2.08961796e-02f, -2.65969150e-02f,
  -9.39562824e-03f, -4.34868336e-02f, 3.51252779e-02f, 4.08851802e-02f, -8.13537911e-02f, -3.20725888e-02f, -1.26192914e-02f, -5.84752038e-02f, 4.99628372e-02f, -1.12632059e-01f,
  -3.54124457e-02f, 7.86463823e-03f, 4.78821993e-02f, 1.68708488e-02f, 1.25340760e-01f, -1.84392452e-01f, -6.38757199e-02f, 1.21401206e-01f, -2.84807116e-01f, -9.46764946e-02f,
  1.11689083e-01f, 2.92217303e-02f, -8.25162977e-03f, -7.53097907e-02f, 8.71320292e-02f, 2.60398933e-03f, 1.38113678e-01f, -8.09059963e-02f, 9.27597359e-02f, 5.75737432e-02f,
  1.96430720e-02f, 7.39554465e-02f, -7.33195469e-02f, -1.85577020e-01f, 1.14603229e-01f, -2.66380440e-02f, 1.10210269e-03f, 8.82345513e-02f, 1.37233362e-01f, -8.66800994e-02f,
  2.67442882e-01f, 2.25734919e-01f, -3.67320366e-02f, 1.09425962e-01f, 2.26850454e-02f, -2.34895572e-02f, -2.86669116e-02f, 6.17387481e-02f, 1.27727389e-01f, 1.07529864e-01f,
  4.46089432e-02f, -2.89627630e-03f, 7.93334618e-02f, 4.93758954e-02f, 7.19951391e-02f, 1.05392195e-01f, 1.87663914e-04f, 2.01968417e-01f, -9.12232697e-02f, -1.15059748e-01f,
  1.44424886e-01f, 1.43989667e-01f, 1.34893790e-01f, 1.89904927e-03f, 2.62040570e-02f, -9.75206867e-02f, -3.23619507e-02f, -6.98099509e-02f, -3.51578295e-02f, -9.34154317e-02f,
  1.36670470e-02f, -2.59953022e-01f, 1.11790346e-02f, -1.93167195e-01f, 6.61965311e-02f, -1.54477075e-01f, -2.49298420e-02f, -5.80987595e-02f, -2.05351830e-01f, -6.86844289e-02f,
  -7.71853998e-02f, -8.99571180e-02f, 8.03681314e-02f, 9.44544971e-02f, 1.06284775e-01f, -1.47232115e-01f, 9.21078026e-02f, 6.87456578e-02f, -4.34164181e-02f, 2.72592772e-02f,
  1.56984143e-02f, 3.23456675e-02f, -1.69100836e-02f, 1.42689586e-01f, 4.34523784e-02f, 1.28014863e-01f, 9.83542055e-02f, 2.58052535e-02f, -8.50227550e-02f, 5.86921209e-03f,
  5.31376302e-02f, -9.00149345e-02f, 3.55020277e-02f, 3.00751105e-02f, 9.21922550e-02f, 9.52669457e-02f, 3.98098491e-02f, -8.02620277e-02f, 2.01409068e-02f, -2.18521152e-02f,
  8.27700198e-02f, -8.07112306e-02f, -1.19414954e-02f, -2.41357426e-04f, -2.97685224e-03f, 8.13437104e-02f, -4.31266800e-02f, 8.41351599e-02f, 3.07144616e-02f, -2.03705635e-02f,
  5.70260324e-02f, -8.00370425e-02f, -3.64021026e-02f, 3.90874259e-02f, 1.93216112e-02f, -2.45594829e-02f, -5.96034117e-02f, -4.97911684e-02f, 1.64544284e-02f, 1.04606196e-01f,
  -3.40497270e-02f, 7.79794902e-02f, -8.38428270e-03f, -9.75739956e-03f, -3.92060727e-02f, -7.50958249e-02f, -1.88434403e-02f, -2.34074388e-02f, 1.32404044e-01f, 9.49162617e-02f,
  2.87716277e-02f, 4.58321758e-02f, -2.59624925e-02f, -1.29296347e-01f, 1.09742142e-01f, -8.13233256e-02f, -6.79044425e-02f, -3.62627138e-03f, 4.75440733e-02f, 1.21392459e-01f,
  1.13912575e-01f, -8.58314037e-02f, -9.33972523e-02f, 4.03453782e-02f, -5.24954386e-02f, -1.73791416e-03f, -1.88308656e-02f, 9.64118987e-02f, -9.28359255e-02f, 1.25471145e-01f,
  6.21919939e-03f, 1.03989169e-01f, -8.38063061e-02f, 1.35331184e-01f, -7.65611529e-02f, -9.37597156e-02f, -9.39882640e-03f, -5.18858768e-02f, 2.98872851e-02f, 4.36805300e-02f,
  2.19125580e-02f, -1.84206944e-02f, -8.47415328e-02f, 1.10499956e-01f, 8.83845389e-02f, -1.38981894e-01f, -7.02161063e-03f, 5.45052886e-02f, 1.03471257e-01f, -8.75865147e-02f,
  -9.89210308e-02f, 1.19208517e-02f, -4.74947644e-03f, 2.22115759e-02f, 2.31242001e-01f, 1.86015025e-01f, 1.08298466e-01f, -1.18463740e-01f, 2.41698138e-02f, 8.15485641e-02f,
  1.50048643e-01f, 1.37654439e-01f, 2.17537731e-01f, -8.11703429e-02f, 3.95486271e-03f, -1.98707327e-01f, -4.53116931e-02f, 1.07640222e-01f, -8.37406144e-03f, 2.90947612e-02f,
  -4.33310680e-02f, 1.67878941e-02f, 1.01456493e-01f, -8.77717212e-02f, 1.31049842e-01f, -1.33960813e-01f, -6.95554614e-02f, 1.36034951e-01f, 7.76379183e-02f, 3.80594917e-02f,
  2.54926085e-02f, 1.75516620e-01f, -1.32619664e-01f, -1.62155807e-01f, 3.15891504e-02f, 2.01549456e-02f, 1.14504844e-02f, -1.97538547e-02f, -2.49750726e-03f, 2.47509242e-03f,
  -1.77561585e-02f, 4.67692800e-02f, 4.47116941e-02f, -3.34236510e-02f, 7.20660836e-02f, 7.76918754e-02f, -3.67006175e-02f, -2.81379670e-02f, 6.50426671e-02f, -1.24321260e-01f,
  1.70807671e-02f, -5.59010766e-02f, -2.13396512e-02f, -4.20682430e-02f, -2.70378869e-03f, -1.86055414e-02f, 1.90562736e-02f, 1.69919077e-02f, 1.80546697e-02f, -3.14603597e-02f,
  -2.41104607e-02f, 7.81828836e-02f, -5.96819958e-03f, 3.71962562e-02f, 3.16326283e-02f, 9.68400687e-02f, 8.75695050e-03f, -9.52038448e-03f, 9.71478149e-02f, 1.35357762e-02f,
  -3.40957455e-02f, 5.25217801e-02f, 6.55584037e-03f, -1.29254088e-01f, 6.46749958e-02f, -6.30434528e-02f, 7.09816590e-02f, -2.96307914e-02f, 1.49931032e-02f, 3.12006436e-02f,
  2.85693619e-04f, 1.84874125e-02f, -4.15002636e-04f, -3.20250206e-02f, -1.22440513e-02f, 4.02611261e-03f, -1.48361772e-01f, -1.89037457e-01f, -3.51694785e-02f, 2.32938677e-02f,
  3.63780968e-02f, -1.84180830e-02f, -6.70617148e-02f, -1.42498799e-02f, 7.31471255e-02f, 4.96485718e-02f, -2.29137167e-02f, 1.44589499e-01f, 1.49044879e-02f, -7.25220516e-02f,
  -4.09469125e-04f, -5.10839149e-02f, 1.12071261e-01f, -3.99719141e-02f, 1.05816327e-01f, 9.70678031e-03f, 5.87444045e-02f, 2.91672219e-02f, -1.03913836e-01f, -2.78420690e-02f,
  -1.99469142e-02f, -2.29384769e-02f, 5.46292029e-02f, 6.31911010e-02f, 4.45116833e-02f, 6.67325780e-02f, -7.18595088e-02f, -1.06575741e-02f, 4.67422605e-02f, 6.02628700e-02f,
  -3.02100293e-02f, -1.02025501e-01f, -1.23712204e-01f, 8.87377486e-02f, 3.12707275e-02f, 2.36517452e-02f, -1.41361328e-02f, -3.24111618e-02f, 4.38364856e-02f, 8.45692959e-03f,
  -1.23352624e-01f, -4.30501774e-02f, -1.44415066e-01f, -9.52435657e-02f, 7.34612718e-02f, -6.47273064e-02f, -7.38054374e-03f, -1.07418358e-01f, -1.54015526e-01f, 1.02065079e-01f,
  1.36226565e-01f, 8.77930149e-02f, 7.01036751e-02f, 1.38333708e-01f, 1.28463432e-01f, -1.56398907e-01f, -4.00979929e-02f, -3.06509510e-02f, 7.46698752e-02f, 6.73414022e-02f,
  -9.01658610e-02f, 3.77267040e-02f, -1.56243831e-01f, 1.39156774e-01f, -3.76834720e-02f, -6.29861876e-02f, -1.27564266e-01f, 2.08083108e-01f, 6.33906052e-02f, -4.27409559e-02f,
  1.13787495e-01f, 7.81902522e-02f, 6.91690892e-02f, 9.28654522e-02f, -1.58583090e-01f, 7.05730468e-02f, 2.61159111e-02f, -6.02721348e-02f, -6.55687079e-02f, -3.23596736e-03f,
  -4.64094542e-02f, 4.90365475e-02f, 4.90465872e-02f, 1.04260378e-01f, 9.01937543e-04f, -1.10891601e-02f, 1.08789772e-01f, -1.38264969e-01f, 1.92582533e-02f, -8.62566940e-03f,
  1.13043785e-01f, 5.86053506e-02f, 1.67442802e-02f, 9.14048776e-03f, 1.54337520e-03f, 1.93608515e-02f, -2.35364586e-03f, -1.47912011e-01f, 1.22617569e-03f, 2.64581274e-02f,
  -1.86514370e-02f, 7.37116262e-02f, -6.44525792e-03f, 1.24557177e-02f, 1.82463173e-02f, -5.82803506e-03f, 8.53415430e-02f, 1.02855619e-02f, -1.36317521e-01f, 1.92735791e-02f,
  -7.72798574e-03f, -7.91909099e-02f, 1.21588735e-02f, -3.68251838e-02f, 2.59570312e-02f, 9.88152549e-02f, -1.51254646e-02f, 2.41402797e-02f, -1.54978754e-02f, -2.67527532e-02f,
  -1.22297381e-03f, 4.55776937e-02f, 5.18940315e-02f, 3.87128592e-02f, 9.74507187e-04f, 2.41149999e-02f, 8.46160389e-03f, 2.78442521e-02f, -4.75734286e-02f, -9.63465795e-02f,
  1.51765540e-01f, -2.16643766e-01f, 1.50162950e-02f, 8.43612999e-02f, 3.05674784e-02f, 2.43024379e-01f, 1.28780276e-01f, -5.18484414e-02f, -3.80252600e-02f, -5.72724678e-02f,
  6.07701130e-02f, -1.62988678e-02f, -5.04150651e-02f, -6.65008798e-02f, -4.85498160e-02f, 9.24912691e-02f, -1.28072230e-02f, 1.54297352e-01f, 9.95005444e-02f, 1.62204802e-01f,
  -6.85370043e-02f, -6.22363091e-02f, -6.47835284e-02f, -3.19407992e-02f, -9.43110809e-02f, -2.51434860e-03f, 1.89089060e-01f, 2.88983565e-02f, -4.09852527e-02f, -6.14100695e-02f,
  5.03036305e-02f, -5.36301322e-02f, -6.11078516e-02f, -6.49781376e-02f, 1.16696455e-01f, 7.16953352e-02f, -1.27610177e-01f, -5.90948611e-02f, -1.59090772e-01f, -6.20718300e-02f,
  1.41290098e-01f, -2.29880065e-02f, 2.21754625e-01f, 4.31162529e-02f, -7.06417412e-02f, 7.46349767e-02f, -6.05614595e-02f, 6.83577880e-02f, 1.18515328e-01f, 2.98451958e-03f,
  -2.23204643e-02f, -1.85662434e-01f, 7.55335093e-02f, -8.00944567e-02f, 9.98231210e-03f, 1.60177335e-01f, -1.44960150e-01f, 5.15412502e-02f, -3.21517475e-02f, -4.73982915e-02f,
  1.25788137e-01f, -4.62843254e-02f, 1.02251366e-01f, 2.20983531e-02f, -1.03456199e-01f, 1.47072703e-01f, 9.15775821e-02f, -6.44700006e-02f, -9.85529795e-02f, -1.26153920e-02f,
  5.30588068e-02f, -7.61009082e-02f, -1.05082184e-01f, 1.44587800e-01f, -8.12335238e-02f, -7.25520328e-02f, 5.73699214e-02f, -1.39964893e-02f, 2.69776080e-02f, -7.16666179e-03f,
  1.55817741e-03f, -5.00162318e-02f, -2.81473761e-03f, 7.88301900e-02f, 1.24802021e-02f, -1.64955370e-02f, 1.58067066e-02f, 1.37578726e-01f, 8.68097618e-02f, 4.91514951e-02f,
  1.69636197e-02f, -1.95545852e-02f, -3.15199383e-02f, -2.93930694e-02f, 1.12559255e-02f, 2.62409206e-02f, 9.24161077e-02f, 1.29749909e-01f, 1.59108132e-01f, 1.51656508e-01f,
  5.19948453e-02f, -1.34288326e-01f, 5.34614827e-03f, -9.07117352e-02f, 7.64065534e-02f, 6.13420978e-02f, 6.88599572e-02f, 7.60284960e-02f, 4.45727073e-02f, 4.63069677e-02f,
  5.64370379e-02f, -5.13380021e-02f, -1.28302902e-01f, 1.32422999e-01f, 1.30373193e-03f, -8.23088363e-03f, -1.22453190e-01f, 3.13010137e-03f, -5.53659303e-03f, 4.09948863e-02f,
  1.64477155e-01f, 2.60433871e-02f, 8.74057263e-02f, 1.39274105e-01f, 6.18145764e-02f, 5.76598756e-02f, -5.10066822e-02f, -1.16748251e-01f, -2.30103415e-02f, -2.82178223e-02f,
  -3.18320394e-02f, -2.29920875e-02f, 1.21583186e-01f, 5.23051172e-02f, 1.39306262e-01f, -1.25367194e-01f, 2.13556234e-02f, 8.76259878e-02f, 6.10374585e-02f, 7.24626109e-02f,
  4.35728021e-03f, 8.59263241e-02f, -1.51873723e-01f, 1.73368290e-01f, 4.13620099e-03f, 3.65535840e-02f, 1.43827766e-01f, 7.39167482e-02f, -1.18780263e-01f, 6.55428469e-02f,
  -1.03229731e-01f, 3.28368582e-02f, 2.41771545e-02f, 3.15879546e-02f, 1.90792426e-01f, -3.00554838e-02f, 1.35661662e-01f, 6.41858503e-02f, 4.38734666e-02f, -2.35550664e-02f,
  8.72909725e-02f, 5.41724972e-02f, 1.73500236e-02f, 5.49679101e-02f, -5.48295081e-02f, -4.41323034e-02f, -9.58468020e-03f, 4.81820330e-02f, 1.61554024e-01f, 1.32343560e-01f,
  8.13413858e-02f, 1.94762014e-02f, -9.99358203e-03f, 2.57344604e-01f, 7.58922547e-02f, 1.42590806e-01f, -1.71643406e-01f, -9.49413255e-02f, -7.70411864e-02f, -9.57767367e-02f,
  -2.94360388e-02f, -2.46761233e-01f, 7.29282871e-02f, 3.10302246e-02f, -1.21527486e-01f, 1.24852039e-01f, 5.66342250e-02f, -2.22829524e-02f, -3.78631800e-02f, -3.62979285e-02f,
  3.60577703e-02f, -1.75775185e-01f, -1.09991178e-01f, -8.62294063e-02f, 3.60299088e-02f, -1.76259764e-02f, -7.42942467e-02f, -3.82249393e-02f, -5.67939356e-02f, -5.63463429e-03f,
  -5.49707515e-03f, 3.96268852e-02f, -1.43636549e-02f, -3.61782834e-02f, 4.35956568e-02f, -1.77607499e-02f, 2.25472469e-02f, 1.30407616e-01f, -1.25980722e-02f, -5.39076068e-02f,
  -7.37197045e-03f, 2.93754879e-03f, -6.79927021e-02f, 2.37432215e-02f, -4.14189824e-04f, 1.38123073e-02f, -1.33836316e-02f, 2.88347490e-02f, 1.53330909e-02f, -4.10723761e-02f,
  6.70718774e-02f, 5.71714230e-02f, -1.44323297e-02f, -5.06012002e-03f, -2.05531269e-02f, 1.84256788e-02f, -8.66003707e-02f, -8.72332230e-02f, -6.12299331e-02f, -2.31164563e-02f,
  -4.11390439e-02f, 2.70297546e-02f, 7.49263689e-02f, 1.48474351e-02f, 2.90886573e-02f, 5.42838462e-02f, 5.12783751e-02f, -6.93817064e-02f, 2.60817558e-02f, -8.37012380e-02f,
  -6.29994497e-02f, -4.56931293e-02f, 3.68693582e-04f, 2.57855318e-02f, 2.23114230e-02f, -2.29612868e-02f, 4.94820699e-02f, -9.41430330e-02f, 2.48153781e-04f, 3.70455571e-02f,
  -3.58832665e-02f, -8.17298591e-02f, -2.74438970e-02f, -1.01854853e-01f, 1.32970735e-01f, 1.60895940e-03f, 1.09709650e-02f, 3.86171564e-02f, -1.92934275e-01f, -2.36080196e-02f,
  -1.00640208e-02f, 3.03475130e-02f, 8.79936963e-02f, 3.56764644e-02f, 4.02478389e-02f, 1.45631939e-01f, 7.57998377e-02f, 7.55802095e-02f, -4.66137044e-02f, 1.17929960e-02f,
  9.91934985e-02f, 5.96087724e-02f, -1.84963077e-01f, -1.42240033e-01f, -2.33478229e-02f, 1.54414345e-02f, -2.03635711e-02f, -6.47225156e-02f, -7.54159912e-02f, 1.74243003e-01f,
  7.87781328e-02f, 6.61199763e-02f, -9.20782834e-02f, -7.59393424e-02f, 1.41871674e-02f, -8.07125047e-02f, -6.91177994e-02f, 1.22096583e-01f, -2.21243519e-02f, 1.36874005e-01f,
  1.92559749e-01f, 6.68372363e-02f, 1.07521951e-01f, -1.67206034e-01f, -8.13424513e-02f, -9.61667150e-02f, -3.94342169e-02f, 7.83748552e-02f, -9.11666546e-03f, -1.27409235e-01f,
  2.36930236e-01f, 1.26360640e-01f, 3.40400860e-02f, 1.56641439e-01f, 1.69144094e-01f, -1.05378360e-01f, -1.09504446e-01f, -7.86491185e-02f, -7.95587897e-02f, -1.15120746e-01f,
  1.42371207e-01f, 4.85932827e-02f, 1.30816013e-01f, 1.64868385e-02f, 1.70883268e-01f, -8.65442678e-02f, -1.86159149e-01f, -8.55150968e-02f, 2.42451243e-02f, -1.04311481e-01f,
  -1.04615748e-01f, 2.07474515e-01f, 1.01587281e-01f, 1.22376233e-01f, 6.69201687e-02f, 5.50052524e-02f, 3.99994701e-02f, 1.52544575e-02f, -3.68942097e-02f, 6.07691705e-02f,
  5.15299886e-02f, -7.60625070e-03f, 6.91644149e-03f, -2.16754712e-02f, -8.40925649e-02f, -1.04596235e-01f, 8.14251527e-02f, 5.43363169e-02f, -1.13690913e-01f, 8.56490526e-03f,
  -8.04833043e-03f, -7.45580392e-03f, -2.01962832e-02f, -6.47209808e-02f, 7.82174468e-02f, -1.23424977e-02f, -4.17015292e-02f, -1.30393240e-03f, -9.19254124e-03f, -1.71276517e-02f,
  5.92695251e-02f, -6.94038812e-03f, -5.11217527e-02f, 7.74352625e-02f, 8.58514681e-02f, 1.13793053e-01f, 8.52621868e-02f, 4.35735844e-03f, -3.10609117e-02f, -7.24586397e-02f,
  9.00055282e-03f, 2.26090960e-02f, -6.34082928e-02f, -1.49082877e-02f, 1.42857581e-02f, 6.90904856e-02f, -4.59441766e-02f, 3.60743031e-02f, 9.67870932e-03f, 4.02526371e-02f,
  2.47198809e-03f, 1.54408701e-02f, -4.74576950e-02f, 6.36814311e-02f, -7.74042085e-02f, -3.46141122e-02f, 1.82611849e-02f, -4.90051433e-02f, 7.31754154e-02f, 8.83750021e-02f,
  9.64780897e-03f, 8.29780102e-02f, -1.18729584e-01f, -1.85322203e-02f, 1.54734543e-02f, -4.01309021e-02f, 1.15755238e-01f, -8.00241455e-02f, 1.51647329e-02f, 1.71837155e-02f,
  8.70914832e-02f, -1.11663811e-01f, -2.38829423e-02f, -4.29258831e-02f, -1.84308309e-02f, -8.67346451e-02f, 2.54234169e-02f, 6.56174570e-02f, -1.47703767e-01f, 4.02538367e-02f,
  5.66858053e-02f, 9.00657177e-02f, -4.83946204e-02f, -1.85926761e-02f, -8.53605196e-02f, 1.97390951e-02f, 5.18186837e-02f, -1.44253582e-01f, -5.55273965e-02f, -6.81491056e-03f,
  1.47064805e-01f, 1.23646129e-02f, 1.88722927e-02f, 7.30473027e-02f, 8.65539908e-02f, -1.38274550e-01f, 2.85166893e-02f, -7.72987157e-02f, -5.06156571e-02f, -3.94514203e-02f,
  -1.04968280e-01f, 3.22550870e-02f, -8.85712802e-02f, 7.48862624e-02f, 1.06463261e-01f, -9.10931900e-02f, 1.15463018e-01f, 5.99609502e-02f, -1.18174553e-01f, -8.20669383e-02f,
  -1.60646904e-02f, 8.56231600e-02f, -2.02413388e-02f, 5.63834198e-02f, 1.30975664e-01f, 7.26024583e-02f, 1.25357300e-01f, 3.45973969e-02f, -1.35447636e-01f, -6.94062188e-02f,
  -1.45616189e-01f, 7.83212557e-02f, -6.09522909e-02f, 1.40261620e-01f, 1.26552105e-01f, 9.26845521e-02f, -2.97531243e-02f, -4.18792292e-02f, 1.54775437e-02f, -6.55651465e-02f,
  -2.93351039e-02f, -1.24770857e-01f, -1.27415240e-01f, -1.34740502e-01f, -2.01051757e-02f, -4.01868932e-02f, 3.78692076e-02f, -6.72900304e-02f, -6.53851544e-03f, -3.75940576e-02f,
  1.06023744e-01f, -1.29373604e-02f, 3.87234055e-02f, 7.64392316e-02f, -7.12255239e-02f, 5.61625771e-02f, 1.38538435e-01f, -2.68742088e-02f, 7.77856782e-02f, 1.66998692e-02f,
  6.41596690e-02f, -4.30354215e-02f, -4.71411943e-02f, -5.74738570e-02f, 7.21127167e-02f, -4.96732118e-03f, -5.58864733e-04f, 2.40090173e-02f, 1.54188648e-02f, -3.55169661e-02f,
  2.30516512e-02f, -9.32178870e-02f, -5.81985377e-02f, -4.26230952e-02f, -3.79925370e-02f, 1.24580292e-02f, -5.12781069e-02f, 4.36173230e-02f, -1.56442123e-03f, 2.68353615e-02f,
  4.10170816e-02f, 1.11789890e-02f, -5.54801635e-02f, -2.09291615e-02f, 2.80013792e-02f, 5.94707206e-02f, 2.54799565e-03f, -1.51752038e-02f, -9.52622574e-03f, -2.27671023e-02f,
  4.83932681e-02f, -5.71911409e-02f, -3.77151445e-02f, 4.97119501e-02f, -3.72240692e-03f, 4.30033021e-02f, -1.10403188e-01f, -1.43311471e-01f, 1.39523447e-01f, 1.06113423e-02f,
  3.22338268e-02f, 8.30030963e-02f, -2.37934999e-02f, -2.80314730e-03f, -3.50463353e-02f, 8.17453489e-03f, -7.75925592e-02f, -5.94110647e-03f, -3.82140204e-02f, 1.92090422e-01f,
  -1.30367219e-01f, 5.68397380e-02f, -4.52479310e-02f, 1.22265570e-01f, 1.30934911e-02f, -1.16272636e-01f, 1.31378427e-01f, -3.42234708e-02f, -3.31350230e-02f, 4.39384207e-02f,
  9.99855064e-03f, 4.72941920e-02f, 1.19511299e-01f, 2.50939000e-02f, -1.20454051e-01f, 1.83986828e-01f, -6.70085251e-02f, -5.11704497e-02f, -4.02215822e-03f, 7.06544369e-02f,
  -1.08096555e-01f, -4.32239324e-02f, -1.00785017e-01f, 1.24626430e-02f, -8.57804250e-03f, 1.61851607e-02f, -3.41641903e-02f, -3.50441523e-02f, 7.16254860e-02f, -6.82916632e-03f,
  -1.27595589e-01f, -6.95551783e-02f, -1.24061294e-01f, 2.93706879e-02f, 1.14807943e-02f, -8.52341056e-02f, 7.35670999e-02f, -2.42705896e-01f, -2.32652977e-01f, -8.62758830e-02f,
  1.94829538e-01f, -9.60593298e-02f, -1.97591156e-01f, -5.00444435e-02f, -7.85545632e-02f, -1.29925519e-01f, 2.62388829e-02f, 1.02666378e-01f, 1.18112303e-01f, 9.58160609e-02f,
  -1.48066908e-01f, -1.25271734e-02f, 3.30368057e-02f, 2.50730459e-02f, 9.51535702e-02f, 8.73618526e-04f, -1.36298820e-01f, 1.67920012e-02f, 1.12534903e-01f, -7.91506609e-04f,
  1.34178787e-01f, 1.63609847e-01f, 3.95268016e-02f, 5.03074452e-02f, 1.03972651e-01f, 7.14270249e-02f, 8.71057659e-02f, -1.81674454e-02f, 1.52235422e-02f, -1.36473626e-01f,
  -7.99930096e-02f, -3.43599468e-02f, -1.78609032e-03f, 3.52859008e-03f, 1.01173431e-01f, 5.69041120e-03f, 6.27012085e-03f, 1.03983425e-01f, -1.24293217e-03f, 1.17050841e-01f,
  3.21051180e-02f, 3.68105173e-02f, 4.75706346e-02f, 3.51506956e-02f, 2.44449601e-02f, 6.53199181e-02f, 1.33530553e-02f, 4.58329096e-02f, 6.14506900e-02f, 7.58873951e-03f,
  4.93613854e-02f, -2.65472289e-02f, 6.83648810e-02f, 1.60203949e-02f, 5.51239885e-02f, 3.39152641e-04f, -1.24481050e-02f, 3.73941846e-02f, 7.64441788e-02f, -3.32121439e-02f,
  -3.68897058e-03f, 2.88147014e-02f, 2.11815070e-02f, 7.21014664e-02f, 5.36743253e-02f, 3.61641087e-02f, -4.03392911e-02f, 1.17106875e-02f, -4.75331284e-02f, -3.88006791e-02f,
  -4.80078794e-02f, 9.57394838e-02f, -3.19289253e-03f, -1.32800922e-01f, 3.76966335e-02f, 4.93410304e-02f, -3.49119008e-02f, -1.34490952e-01f, -9.92028266e-02f, 1.29032480e-02f,
  1.60026103e-02f, 4.24113981e-02f, -1.04225904e-01f, -2.02926025e-01f, 7.18882233e-02f, -4.33519259e-02f, 3.69090624e-02f, 4.10383567e-02f, -1.11947574e-01f, 5.35702072e-02f,
  9.41542834e-02f, 7.35696480e-02f, -1.47468988e-02f, -2.77919378e-02f, -1.14856362e-02f, -5.02060950e-02f, 1.31424978e-01f, 7.66823143e-02f, 1.35056704e-01f, 3.22270393e-02f,
  -3.55070867e-02f, 1.08973250e-01f, -1.45326465e-01f, 1.04556181e-01f, -6.54308731e-03f, 4.13166778e-03f, 1.95932448e-01f, 8.43956396e-02f, -3.21669653e-02f, 2.66190153e-02f,
  1.53668329e-01f, -3.96986008e-02f, -2.39592027e-02f, -2.19599530e-02f, -1.54116988e-01f, -2.35167183e-02f, 1.33128002e-01f, -2.43678205e-02f, 2.93266848e-02f, 1.31273225e-01f,
  3.12303118e-02f, 1.22805186e-01f, -1.19713113e-01f, -5.53591410e-03f, 1.15023544e-02f, -1.03645682e-01f, -5.24885245e-02f, -8.02501068e-02f, -1.45360604e-01f, -9.95110795e-02f,
  -1.07535198e-01f, -1.57207578e-01f, -4.68040593e-02f, -1.04575522e-01f, -5.78230843e-02f, -7.21621364e-02f, -1.59765743e-02f, -8.01437646e-02f, -2.84623299e-02f, -1.30252615e-01f,
  1.29524097e-01f, -1.08817287e-01f, -3.14087458e-02f, -2.19862595e-01f, -3.47974934e-02f, -2.24710613e-01f, -4.45537381e-02f, 2.92411689e-02f, 4.96330708e-02f, 8.34640935e-02f,
  -4.34062071e-02f, -1.51529834e-01f, -5.66200502e-02f, 5.00218235e-02f, -6.87138140e-02f, 6.67566247e-03f, -6.01841174e-02f, 4.42737043e-02f, 6.34566471e-02f, -7.94470832e-02f,
  -2.95608793e-03f, -2.17030216e-02f, 9.49023117e-04f, 6.32165372e-02f, -5.76900505e-02f, -2.31160526e-03f, -9.29610431e-02f, -6.41507432e-02f, -7.16528669e-02f, -6.56180978e-02f,
  -2.63860449e-02f, -4.70177233e-02f, 3.06445099e-02f, -6.54123947e-02f, 1.52439970e-04f, 6.56285286e-02f, 1.06800832e-02f, 1.03315920e-01f, 2.90404111e-02f, 4.50699031e-02f,
  5.29211499e-02f, -5.39762639e-02f, -1.20104223e-01f, -4.33387496e-02f, 3.23970616e-02f, 3.77216041e-02f, 5.26880985e-03f, 4.48640361e-02f, -1.16306618e-02f, 3.42977047e-02f,
  2.84230094e-02f, -9.81671140e-02f, -1.26908541e-01f, -5.92382625e-02f, -2.74651796e-02f, -5.44145852e-02f, -6.56346083e-02f, 9.18342359e-03f, -3.20882611e-02f, -5.86317293e-02f,
  2.53062826e-02f, -3.86182382e-03f, -1.63636375e-02f, -9.05809458e-03f, 9.03670192e-02f, 1.25568971e-01f, 1.08802631e-01f, -7.20956475e-02f, -1.18597530e-01f, 1.64065778e-01f,
  -1.37475044e-01f, -4.18743230e-02f, 9.67025906e-02f, -3.21254618e-02f, -2.10428406e-02f, 4.28149709e-03f, 7.84297064e-02f, 2.68349461e-02f, 1.03165552e-01f, 2.00405270e-02f,
  1.08085781e-01f, -3.58060040e-02f, 1.27405420e-01f, 3.43355611e-02f, -1.09962381e-01f, -2.92585909e-01f, 7.28881732e-02f, -8.88616517e-02f, -7.60839134e-02f, 6.69812113e-02f,
  4.63093482e-02f, 7.56094381e-02f, 1.68913037e-01f, 2.24145040e-01f, -8.49801376e-02f, 1.71707556e-01f, 1.49967540e-02f, -4.48558368e-02f, -6.64975643e-02f, 9.09372047e-02f,
  1.53121203e-01f, 1.03424802e-01f, 1.20024338e-01f, 1.35893710e-02f, -4.90599275e-02f, -3.23039778e-02f, -6.94617582e-03f, 1.66836098e-01f, -1.39661133e-01f, 8.60576555e-02f,
  -6.82857409e-02f, -1.20322451e-01f, 1.37192234e-01f, 1.87905282e-02f, 9.99645218e-02f, -8.00716206e-02f, 2.91296858e-02f, 1.90221164e-02f, -4.38439064e-02f, 1.11342050e-01f,
  3.63670774e-02f, -1.27651885e-01f, 3.78075466e-02f, -2.29946464e-01f, 2.99474858e-02f, 6.52747527e-02f, 1.25929013e-01f, 4.34995331e-02f, -7.63416067e-02f, 9.47475210e-02f,
  -1.43222213e-01f, -1.85985625e-01f, -1.88246652e-01f, 1.05886139e-01f, 1.45717785e-01f, 1.68488830e-01f, 1.00269169e-01f, -1.00756451e-01f, -5.97481802e-03f, 1.80366971e-02f,
  1.22266062e-01f, 1.04835387e-02f, -3.61333713e-02f, 1.54928584e-02f, 2.51917485e-02f, -1.12491949e-02f, 2.55078077e-02f, 3.93751897e-02f, -2.59197429e-02f, -5.82116209e-02f,
  5.15640788e-02f, -8.07373747e-02f, 7.42386580e-02f, 1.55224845e-01f, 3.51755507e-02f, 4.65869009e-02f, 4.45535183e-02f, -7.27907429e-03f, 5.70232328e-03f, 1.55282803e-02f,
  -2.65214546e-03f, 7.37315118e-02f, 4.77724075e-02f, -2.83463597e-02f, 4.01503667e-02f, -1.16369881e-01f, -3.71330865e-02f, -1.29574016e-01f, -8.98414254e-02f, 6.02341555e-02f,
  5.19863851e-02f, 2.46701222e-02f, -6.65058047e-02f, 4.79555614e-02f, 7.22189397e-02f, 3.43070179e-02f, -9.92000569e-03f, 1.92996804e-02f, 1.61114205e-02f, 3.10240835e-02f,
  7.34649897e-02f, 4.15927954e-02f, -4.32449393e-02f, -4.33633775e-02f, 5.29413112e-02f, -8.35069567e-02f, -8.33447371e-03f, 1.49811450e-02f, -7.57455379e-02f, 5.21764904e-03f,
  -2.08234284e-02f, -1.06872924e-01f, -1.82296950e-02f, -1.16633892e-01f, -2.65847538e-02f, 2.18254209e-01f, -1.25716906e-02f, -1.00133277e-01f, 3.67699675e-02f, -1.90235600e-02f,
  -1.32409841e-01f, -8.34400728e-02f, 3.11564282e-02f, 4.13731821e-02f, -1.52385101e-01f, 1.16188109e-01f, -8.25710595e-02f, 7.54174516e-02f, -1.79277286e-02f, -1.34465415e-02f,
  8.20377991e-02f, -7.70515129e-02f, 2.26583350e-02f, 1.01819068e-01f, -1.26356244e-01f, 4.53571156e-02f, 1.13550633e-01f, -9.67293605e-02f, -1.00780144e-01f, 1.22159809e-01f,
  -1.43771157e-01f, -1.71462715e-01f, -1.09357592e-02f, -1.28752366e-01f, -2.64436882e-02f, 2.63632350e-02f, -2.63605751e-02f, -3.36402953e-02f, -1.22387454e-01f, -4.59003188e-02f,
  -5.36074229e-02f, -6.08258434e-02f, 8.41413513e-02f, -4.48971838e-02f, -5.52569255e-02f, -9.93675739e-02f, -3.83307636e-02f, -7.92620052e-03f, -3.28381360e-02f, 5.57727627e-02f,
  -5.49287647e-02f, -2.16560617e-01f, -1.68531880e-01f, 5.63643128e-03f, -7.44691566e-02f, -5.99462539e-02f, -4.98598292e-02f, -8.78322050e-02f, -4.63560186e-02f, 7.62470737e-02f,
  1.56901870e-03f, 9.55990702e-02f, 1.46407142e-01f, 1.07279852e-01f, -9.58873853e-02f, 2.24075597e-02f, -3.33823562e-02f, -2.88033783e-02f, 1.31427065e-01f, 6.87810481e-02f,
  7.85294622e-02f, -2.89910678e-02f, -1.06730402e-01f, -8.81017447e-02f, 2.47221608e-02f, 1.19218193e-01f, 3.22718732e-02f, 3.51609774e-02f, 4.48346185e-03f, 1.92023560e-01f,
  2.42520627e-02f, -6.76277354e-02f, -3.21823582e-02f, -9.65012796e-03f, 1.35679794e-02f, 3.20924968e-02f, 4.13640030e-02f, -2.43453272e-02f, 2.62478571e-02f, 2.48693563e-02f,
  -4.90710065e-02f, 5.41733764e-02f, -2.21216027e-02f, 7.37413764e-02f, 5.63941449e-02f, -2.61369906e-03f, -1.89555064e-02f, -4.31382284e-03f, 5.35221351e-03f, -6.48881402e-03f,
  -3.53275519e-03f, 6.38984069e-02f, -1.24506950e-02f, 1.15988217e-01f, 1.26711130e-01f, 6.84038103e-02f, 5.77467643e-02f, 2.35995632e-02f, 3.90266906e-03f, 2.75090877e-02f,
  1.00772239e-01f, -2.21557375e-02f, 1.67898759e-01f, -2.14021020e-02f, 1.92615483e-02f, 5.90027198e-02f, 7.82658905e-02f, -8.02233219e-02f, -4.38257456e-02f, -1.36881005e-02f,
  4.05942276e-02f, -1.60162132e-02f, -3.55590060e-02f, -3.88135165e-02f, 6.19345382e-02f, -7.16116503e-02f, 1.03439979e-01f, -6.18203841e-02f, 4.18936126e-02f, 9.63018835e-02f,
  -7.28696864e-03f, -1.41978245e-02f, 3.39964987e-03f, -8.12678859e-02f, -1.13022484e-01f, 7.98445288e-03f, -3.15061867e-01f, -7.52349496e-02f, 7.16960728e-02f, 1.07007869e-01f,
  8.26200545e-02f, -5.15057966e-02f, 2.62463447e-02f, 1.20736957e-01f, 1.54845610e-01f, 6.67552724e-02f, 1.22755013e-01f, 1.12443261e-01f, -4.70626540e-02f, 3.88542786e-02f,
  -6.14069551e-02f, -3.17494348e-02f, 1.53882280e-01f, 1.80757698e-02f, -1.42850280e-01f, 5.97814955e-02f, -4.03669626e-02f, 5.01986109e-02f, 1.55429929e-01f, 1.61013573e-01f,
  1.44902796e-01f, 1.23447187e-01f, 5.06064296e-02f, 1.00326411e-01f, 3.31115797e-02f, 1.52319018e-02f, 1.38046861e-01f, 1.08343326e-01f, 6.69716522e-02f, -3.51488851e-02f,
  5.35480268e-02f, 1.08369542e-02f, -2.71205641e-02f, 1.58765703e-01f, 1.17815606e-01f, 2.32474640e-01f, 1.96590722e-02f, -8.83326679e-02f, 1.17072865e-01f, 1.07234895e-01f,
  9.10109207e-02f, 9.09896716e-02f, -1.71594173e-02f, -1.07844926e-01f, -8.32063556e-02f, -1.59189016e-01f, -8.23842734e-02f, -1.15840822e-01f, 2.20131222e-02f, -1.53289676e-01f,
  4.16261815e-02f, -9.41639543e-02f, 9.50829685e-02f, -1.39402822e-01f, 5.96451201e-03f, -1.24241479e-01f, -1.57502934e-01f, -2.51028687e-01f, -6.59910664e-02f, -7.29133934e-02f,
  4.78391387e-02f, 6.66135997e-02f, 3.42940204e-02f, -5.75782843e-02f, -9.00550634e-02f, 6.21636659e-02f, -2.00099833e-02f, -5.16455285e-02f, -1.31763175e-01f, -7.88997263e-02f,
  -5.67572899e-02f, 1.25554457e-01f, 5.26073687e-02f, 1.59727529e-01f, 3.38320881e-02f, -3.56100104e-03f, -9.43137258e-02f, -7.79429525e-02f, 5.11963926e-02f, -4.03958838e-03f,
  -2.82421708e-02f, -7.99782723e-02f, -2.42313277e-02f, 4.09454182e-02f, -3.90444770e-02f, -4.72732261e-02f, -1.25037841e-02f, 1.62746496e-02f, 1.03679439e-02f, -4.73564416e-02f,
  -4.94882911e-02f, 3.60927917e-02f, 3.02034821e-02f, -6.51335195e-02f, -9.38156247e-02f, -5.05393110e-02f, 4.22448590e-02f, -3.91442403e-02f, -5.79657443e-02f, 3.11223604e-02f,
  1.86025668e-02f, 1.07648969e-02f, 7.94611201e-02f, -4.07027379e-02f, -5.51313795e-02f, -8.46595839e-02f, -6.57142177e-02f, 3.79459001e-02f, 3.60537916e-02f, -7.07757175e-02f,
  2.61810683e-02f, -7.83249736e-02f, 1.12383537e-01f, -1.48445427e-01f, -7.76622444e-02f, 1.61673173e-01f, -2.06634384e-02f, -6.05531260e-02f, -7.30215237e-02f, -1.03084771e-02f,
  1.95999309e-01f, 8.23885426e-02f, 4.73356731e-02f, -4.76644561e-02f, 4.16699126e-02f, 6.04042374e-02f, -9.45398957e-02f, -2.76270732e-02f, -3.04199979e-02f, -2.18928326e-02f,
  4.34454642e-02f, 3.76006924e-02f, -4.94493954e-02f, -4.59827669e-02f, -4.47638109e-02f, 8.54494721e-02f, 6.68102950e-02f, 1.53837390e-02f, -1.57206669e-01f, -7.63329044e-02f,
  -1.14770681e-01f, -3.14543536e-03f, 3.78466435e-02f, -2.11853758e-01f, 1.21008135e-01f, -2.44449191e-02f, -7.37142488e-02f, -8.15590620e-02f, -2.31280923e-01f, -2.08798841e-01f,
  1.36660470e-03f, -4.37905937e-02f, -1.42325342e-01f, 1.58041604e-02f, -4.23259065e-02f, 1.05555356e-02f, 8.91880020e-02f, 2.01734584e-02f, -6.22569323e-02f, -3.83320265e-02f,
  -1.43081276e-02f, -2.03712747e-01f, -2.04334762e-02f, 4.75566462e-02f, 1.21113293e-01f, -2.59235445e-02f, 4.96822819e-02f, 2.07600191e-01f, 3.51843461e-02f, 1.93730578e-01f,
  6.32986277e-02f, -2.66990457e-02f, 4.66810465e-02f, -3.60424966e-02f, 2.50404875e-04f, 1.19312704e-01f, 2.49054153e-02f, 2.48365439e-02f, 9.20749307e-02f, -3.42890806e-02f,
  8.60040113e-02f, -8.54743645e-03f, -2.37405658e-01f, -1.10801451e-01f, 3.82331163e-02f, 2.05872178e-01f, 4.58603837e-02f, 2.26473156e-02f, -2.70073600e-02f, 5.88879921e-03f,
  1.67338792e-02f, -8.96904990e-02f, 2.77093556e-02f, 2.39007529e-02f, 3.46568637e-02f, 2.63831988e-02f, 4.82654236e-02f, -1.07097596e-01f, -8.01530760e-03f, 9.90630239e-02f,
  -2.14014798e-02f, 1.35782689e-01f, 1.35310180e-03f, -8.58257234e-04f, -6.21116459e-02f, -4.27633151e-02f, 1.77300368e-02f, -1.65148526e-02f, -7.68294781e-02f, 2.21051760e-02f,
  1.81909818e-02f, 6.34404719e-02f, 4.35573893e-04f, -4.52137031e-02f, 1.46430850e-01f, 5.19003943e-02f, 2.78130881e-02f, 6.85848519e-02f, 8.13148990e-02f, 1.20480470e-01f,
  5.84087893e-02f, 3.27044278e-02f, -4.59719263e-02f, 6.71703592e-02f, -3.37527730e-02f, 5.12344576e-02f, 2.10769325e-02f, -1.53961126e-02f, 7.62382597e-02f, -2.27742363e-02f,
  9.47184339e-02f, -2.84771137e-02f, 4.32797633e-02f, 6.97441995e-02f, 2.89129727e-02f, 1.05721779e-01f, -4.67128530e-02f, 5.68177830e-03f, -1.43116033e-02f, -7.25545064e-02f,
  5.44270210e-04f, -2.38637868e-02f, -4.12708372e-02f, -1.24922417e-01f, -6.12398386e-02f, -3.91885154e-02f, -8.60178396e-02f, -1.98951170e-01f, 1.76585950e-02f, -5.84393665e-02f,
  -1.38168549e-02f, 2.36115344e-02f, -2.48217314e-01f, -1.75329655e-01f, -2.98677310e-02f, -2.38574278e-02f, 5.72524965e-02f, -1.12004839e-01f, -1.07734893e-02f, 6.13418734e-03f,
  1.10106647e-03f, -7.16731278e-03f, -6.30661845e-03f, 1.01788573e-01f, -3.88968573e-03f, 1.83838829e-02f, 7.67185166e-02f, -4.27880734e-02f, 1.35105625e-02f, -1.59977227e-02f,
  6.13092035e-02f, -7.59316906e-02f, -6.22867793e-03f, 1.58126771e-01f, 1.26595750e-01f, 4.59767990e-02f, -3.58971544e-02f, -7.24626780e-02f, -7.77797475e-02f, -1.69401150e-02f,
  3.36637311e-02f, 5.97937107e-02f, 5.49010485e-02f, 7.38977417e-02f, -4.90572341e-02f, 2.39815488e-02f, 2.15320021e-01f, -7.15870038e-02f, 7.25621432e-02f, 1.32659888e-02f,
  2.53835600e-02f, 6.86632991e-02f, -1.66014820e-01f, -7.46336877e-02f, 1.68839902e-01f, -1.17402732e-01f, 1.56287968e-01f, 1.36949942e-01f, 7.47894570e-02f, -3.14150564e-02f,
  3.56744602e-02f, -2.21291423e-01f, -3.18797342e-02f, -1.86906790e-03f, 5.56125166e-03f, -1.68866947e-01f, 7.95069486e-02f, -1.49305880e-01f, 1.99631676e-02f, -1.36968300e-01f,
  -1.47377208e-01f, -1.43036053e-01f, -3.26354033e-03f, 3.12226657e-02f, 8.39573964e-02f, -8.90997574e-02f, 1.91902518e-02f, 1.42721593e-01f, 1.13643885e-01f, -9.61691979e-03f,
  -5.30777946e-02f, -6.49789721e-02f, 3.72594073e-02f, -2.98202522e-02f, -1.16028339e-02f, -5.01212813e-02f, 1.40350629e-02f, -1.33999987e-02f, 6.23597316e-02f, 6.75132200e-02f,
  -3.50876537e-04f, -1.45052178e-02f, 2.97254436e-02f, -3.09414305e-02f, 1.46981850e-02f, 3.13120931e-02f, -1.91114228e-02f, -2.24923864e-02f, -8.58872682e-02f, -7.73595786e-03f,
  -1.55959511e-02f, 1.25628114e-02f, 3.63818817e-02f, 5.43228127e-02f, 2.79539246e-02f, 3.62980156e-03f, 1.71869062e-02f, -1.12135643e-02f, -1.13630190e-01f, -9.90848392e-02f,
  -6.37438670e-02f, -2.90363133e-02f, 1.60420453e-03f, 4.73561957e-02f, -2.81757582e-03f, 1.27112598e-03f, 6.99318945e-02f, -3.55398143e-03f, 5.50151132e-02f, -5.68082109e-02f,
  9.99957137e-03f, -8.07824954e-02f, -8.08625966e-02f, -5.02210110e-02f, -2.02959217e-02f, 2.74115102e-03f, 2.33834367e-02f, -4.45415527e-02f, 2.35054046e-02f, -8.91892985e-03f,
  -2.33440008e-02f, 1.35847973e-02f, -1.02683038e-01f, -1.10159613e-01f, 1.49721550e-02f, -1.54516418e-02f, 1.35475487e-01f, 4.62986752e-02f, -2.41341237e-02f, 9.83698443e-02f,
  -1.12108752e-01f, 3.12183797e-02f, -2.76346058e-02f, 9.04953631e-04f, -8.65553319e-02f, 1.56725243e-01f, 5.46080656e-02f, 1.05677232e-01f, 2.72103101e-02f, 9.72208679e-02f,
  2.03480907e-02f, -8.78965482e-02f, 1.99809551e-01f, -1.72293708e-02f, -1.08210795e-01f, -1.31493852e-01f, 3.93357426e-02f, -3.48675400e-02f, 4.57422696e-02f, -2.38804203e-02f,
  -7.60741681e-02f, 1.74612492e-01f, 7.57823735e-02f, 7.42024034e-02f, -1.25070989e-01f, -4.36772518e-02f, -5.26394099e-02f, -5.39446361e-02f, -8.30894485e-02f, 1.18128881e-01f,
  -2.49664485e-02f, 7.49064013e-02f, 7.14479908e-02f, 5.31045422e-02f, 7.74853379e-02f, -9.03856531e-02f, 5.83676249e-02f, -4.33300100e-02f, -1.39798269e-01f, 3.93072739e-02f,
  -1.21264890e-01f, -1.12624280e-01f, 2.24261090e-01f, 4.33908850e-02f, 2.85157245e-02f, -6.85300380e-02f, 7.78142363e-02f, -7.28274509e-02f, -1.74484506e-01f, -7.93497041e-02f,
  -1.12033881e-01f, -6.68083802e-02f, 8.62206519e-02f, 2.78970059e-02f, 1.22543223e-01f, -4.93635423e-02f, 1.25366896e-01f, -1.37516141e-01f, -1.53187975e-01f, -6.58539385e-02f,
  6.67120097e-03f, -3.23511101e-02f, -7.33554810e-02f, 4.88936231e-02f, 1.27018794e-01f, 1.37775749e-01f, 1.16556317e-01f, 8.56873319e-02f, -6.52906448e-02f, -4.22924608e-02f,
  2.76603829e-02f, -1.32243801e-03f, -5.25419414e-03f, -4.97078001e-02f, 2.73662452e-02f, -9.36703011e-02f, -1.28985746e-02f, 1.15488674e-02f, -3.48948427e-02f, -8.98918733e-02f,
  7.46045113e-02f, -1.45066821e-04f, -2.99104340e-02f, 6.60165027e-02f, 2.97683906e-02f, 9.73559022e-02f, 1.73223426e-03f, 1.69857014e-02f, -1.47903608e-02f, -3.86350565e-02f,
  1.23592913e-02f, 3.26536894e-02f, 1.71694551e-02f, 2.18078289e-02f, 4.40843850e-02f, -6.96722120e-02f, 5.55009618e-02f, -1.46417215e-01f, -1.97017509e-02f, -1.78931449e-02f,
  1.38964541e-02f, -1.13719050e-02f, -3.01175285e-02f, 5.52314483e-02f, -1.57391336e-02f, 4.00228007e-03f, 7.18889982e-02f, 4.66003828e-02f, -1.34610746e-04f, 1.88528895e-02f,
  -8.88281241e-02f, 8.61278027e-02f, 1.88051630e-02f, -5.88554218e-02f, -5.19751422e-02f, -6.12410381e-02f, -1.96154919e-02f, 3.49617936e-02f, -3.55954878e-02f, 1.25276342e-01f,
  1.35836869e-01f, 1.04046531e-01f, 6.31220192e-02f, -9.59792957e-02f, -9.77605134e-02f, 4.82602082e-02f, 1.02808684e-01f, -1.88914705e-02f, -9.97896716e-02f, -6.04349039e-02f,
  2.75408626e-02f, -9.93592069e-02f, 5.82777672e-02f, 1.48196161e-01f, -8.78008306e-02f, 1.44785896e-01f, -8.22533071e-02f, 1.63259059e-01f, -1.96501806e-01f, 3.91190685e-02f,
  -8.95549171e-03f, -9.04197711e-03f, 4.65030372e-02f, 1.04422070e-01f, -3.59680802e-02f, 1.49218798e-01f, -6.60455823e-02f, -6.42077178e-02f, -1.74073473e-01f, 7.25955665e-02f,
  -1.05472412e-02f, -6.58101663e-02f, 4.15153466e-02f, -1.58257186e-01f, -1.07851520e-01f, 1.26014184e-02f, 5.01147434e-02f, -8.15443322e-02f, -1.11300051e-01f, -2.87868623e-02f,
  4.68800254e-02f, 2.35851612e-02f, 3.87742147e-02f, -9.48901400e-02f, 1.00313060e-01f, -1.63534447e-03f, 1.16117731e-01f, 1.12345599e-01f, -8.57790858e-02f, 2.90764812e-02f,
  2.48507690e-02f, 2.91320235e-02f, 1.11786410e-01f, -1.21332161e-01f, -8.79386254e-03f, -1.34341687e-01f, -8.69702548e-02f, -2.14804471e-01f, -1.53957173e-01f, 3.10923662e-02f,
  7.05722645e-02f, 1.62765026e-01f, -3.45661305e-02f, -1.95515454e-02f, 5.31411432e-02f, -6.46820366e-02f, 1.15846500e-01f, -1.76432848e-01f, 7.83373937e-02f, -5.13562374e-02f,
  9.45870131e-02f, -1.29299700e-01f, -8.14991593e-02f, 1.37253910e-01f, -1.16931528e-01f, 1.15060098e-01f, -9.70045943e-03f, -1.91685352e-02f, -2.54736701e-03f, 4.66421917e-02f,
  9.92681384e-02f, 1.43346386e-02f, 6.00166582e-02f, -7.89107755e-02f, -1.30304554e-02f, 1.24489404e-02f, 1.44249504e-03f, -3.23212184e-02f, 1.43679470e-01f, 6.25920594e-02f,
  1.75284743e-02f, 8.08229372e-02f, 1.01686167e-02f, 1.83611751e-01f, -2.88551878e-02f, 3.62729095e-02f, 5.97184226e-02f, 8.83009657e-02f, 1.67465992e-02f, 3.15563604e-02f,
  -1.97149441e-02f, -1.38061987e-02f, 9.71680284e-02f, 1.04565383e-03f, 7.39396885e-02f, 2.64674537e-02f, 1.19884327e-01f, 6.03146441e-02f, 6.86884578e-03f, 1.36123627e-01f,
  4.48010974e-02f, 3.59436013e-02f, 6.14270084e-02f, -4.51390035e-02f, -3.94650586e-02f, 6.45092800e-02f, 9.33867879e-03f, 1.00308008e-01f, 3.45422067e-02f, 3.78611460e-02f,
  5.83869964e-02f, 8.54627863e-02f, 2.38393750e-02f, 6.80262148e-02f, -1.29801803e-03f, 1.67837098e-01f, 7.60862008e-02f, -2.62819789e-02f, 7.80686662e-02f, 1.17182426e-01f,
  4.62570926e-03f, 5.73418941e-03f, -6.67201504e-02f, -9.83777270e-02f, 4.77514863e-02f, -9.39932466e-03f, -1.43559381e-01f, -4.04959880e-02f, 4.97777946e-02f, -3.97781692e-02f,
  -1.29394718e-02f, 1.67152032e-01f, -2.49899942e-02f, -4.12330702e-02f, 7.29981959e-02f, 2.34940723e-02f, 1.25923380e-02f, -9.54283178e-02f, 6.41678125e-02f, -3.00723761e-02f,
  1.42535105e-01f, 3.60785201e-02f, 2.34488398e-01f, -1.74013078e-02f, -3.55950370e-02f, 9.44260731e-02f, -2.61708032e-02f, -3.50659899e-02f, 1.21121146e-01f, 6.54428005e-02f,
  9.50028896e-02f, 7.56621882e-02f, 2.67137866e-02f, 4.22790833e-02f, 6.58471063e-02f, 6.95786849e-02f, -5.71308732e-02f, 3.44893150e-02f, -4.43990827e-02f, 5.17906025e-02f,
  6.12447853e-04f, -9.26223234e-04f, 8.74437988e-02f, 7.72819445e-02f, 4.64033782e-02f, 7.01043233e-02f, -5.39914705e-02f, 7.43015409e-02f, -3.21081802e-02f, 5.32840490e-02f,
  1.36652336e-01f, -2.43949741e-01f, -1.55133516e-01f, 2.77765449e-02f, -4.89433147e-02f, -7.38551095e-02f, -2.02230457e-02f, -4.37595230e-03f, -3.03706247e-02f, 8.42424575e-03f,
  -4.51899879e-02f, -1.91198677e-01f, 1.48559827e-02f, -1.10372506e-01f, 1.88121378e-01f, -2.75284778e-02f, -4.45574196e-03f, -1.42822981e-01f, 2.28911415e-02f, -6.84996620e-02f,
  -6.22531213e-02f, -8.71886760e-02f, 2.30814982e-03f, 1.03410937e-01f, 1.75237693e-02f, 6.15619309e-02f, -3.28917317e-02f, 6.70781285e-02f, 5.06574893e-03f, -8.57673809e-02f,
  6.32109046e-02f, -1.42909288e-02f, -8.06705058e-02f, -5.97889349e-02f, 3.47017609e-02f, 2.56918394e-03f, 2.67346781e-02f, 1.55991558e-02f, -4.11177613e-02f, -4.76128198e-02f,
  7.20824301e-02f, 1.74274430e-01f, -4.85618562e-02f, 1.07137479e-01f, 1.82097126e-02f, -3.23750600e-02f, 4.11110483e-02f, 2.23345542e-03f, 6.20690286e-02f, -3.29386555e-02f,
  1.06441416e-02f, 3.39874551e-02f, 5.45890555e-02f, 3.63435894e-02f, 3.46361548e-02f, 3.97500955e-02f, 1.37012713e-02f, 1.40607923e-01f, 1.51213601e-01f, -5.43179736e-02f,
  1.46928814e-03f, 1.27670262e-02f, 1.53288022e-02f, -1.44224474e-02f, 1.15925744e-01f, 5.24058901e-02f, 7.31190443e-02f, 1.34754917e-02f, -5.24255307e-03f, 4.85036746e-02f,
  -6.02109097e-02f, 8.54648277e-03f, -5.74994348e-02f, 9.07118171e-02f, 1.50398731e-01f, 9.33623165e-02f, 1.71401709e-01f, 1.71573371e-01f, 1.10506631e-01f, -5.94737753e-02f,
  -1.03240035e-01f, -3.05676498e-02f, 1.22140273e-01f, -2.48608924e-02f, -4.83617857e-02f, 1.53098172e-02f, 1.26132458e-01f, 8.12973678e-02f, 1.88353643e-01f, 1.37304991e-01f,
  -2.42151432e-02f, 1.04307905e-01f, 9.93973389e-02f, 1.15378387e-01f, -9.36322436e-02f, 3.68329547e-02f, 1.09526124e-02f, 2.95357350e-02f, 8.33375752e-02f, 1.69542342e-01f,
  1.24768004e-01f, 1.77406371e-01f, -1.67088464e-01f, 2.51878295e-02f, -1.72931045e-01f, 1.21210799e-01f, 4.95413207e-02f, -4.49123699e-03f, 1.80363700e-01f, -2.15887148e-02f,
  -4.33305576e-02f, 5.65460399e-02f, 1.78859532e-01f, -3.98195647e-02f, -1.05842687e-01f, 5.10698892e-02f, 5.06099723e-02f, 8.05302486e-02f, 1.21195661e-02f, -1.31046087e-01f,
  6.20777979e-02f, 7.93696195e-02f, 2.00092047e-01f, 5.67446128e-02f, 1.10387817e-01f, 1.56572368e-02f, -6.52746558e-02f, 1.74582794e-01f, 1.08672932e-01f, -1.75150149e-02f,
  -2.06493586e-02f, -5.53748943e-02f, -3.94900143e-02f, -1.15912490e-01f, -6.10730797e-02f, -1.00794710e-01f, 1.57185599e-01f, 1.80227771e-01f, -1.69709042e-01f, -8.62384960e-02f,
  9.62581709e-02f, -8.16178843e-02f, 1.46202952e-01f, -4.02409956e-02f, 5.11754118e-02f, -2.36350954e-01f, -3.38460431e-02f, 8.83925185e-02f, -1.10133633e-01f, 7.31014311e-02f,
  -1.68557838e-01f, 4.50022817e-02f, 3.70670557e-02f, -4.02789116e-02f, -1.11671194e-01f, 1.06116466e-01f, -5.94339594e-02f, -2.02006456e-02f, -6.61621452e-05f, -6.35035411e-02f,
  -1.00690871e-01f, 2.50168126e-02f, -1.46658560e-02f, -7.15560615e-02f, 5.87971136e-03f, -9.26463902e-02f, 1.02156289e-01f, 8.02230611e-02f, 6.78524449e-02f, 3.65467146e-02f,
  1.08734697e-01f, 2.92386394e-02f, -5.96617907e-02f, 2.71497555e-02f, -1.03350528e-01f, 1.58520043e-02f, -4.95736115e-02f, -4.16567177e-02f, -8.52641314e-02f, -3.70738022e-02f,
  2.43327599e-02f, 9.76366177e-02f, 1.18558323e-02f, -1.38046816e-01f, 4.80465293e-02f, -9.97989625e-02f, 1.84064247e-02f, -1.13681033e-02f, -5.51429857e-03f, -3.82517502e-02f,
  -1.05246916e-01f, 6.58061132e-02f, -4.01009209e-02f, -7.84726813e-02f, -4.05459069e-02f, 7.11065382e-02f, -9.23843607e-02f, -3.64014432e-02f, -4.47240844e-02f, -5.65599576e-02f,
  -1.63908340e-02f, 2.28982549e-02f, 9.99502465e-03f, 1.25783384e-01f, 9.33145583e-02f, 1.64754406e-01f, 6.72751442e-02f, 1.67773496e-02f, -3.74976769e-02f, -7.01983273e-02f,
  7.58701861e-02f, -1.06881455e-01f, 1.17181018e-01f, -7.60613894e-03f, -9.74182598e-03f, 9.26072150e-02f, 5.48962317e-02f, 7.24523375e-03f, -7.33307302e-02f, 4.81125601e-02f,
  -6.79842383e-02f, 7.34352171e-02f, 3.88663188e-02f, -1.26846060e-02f, -8.63415077e-02f, 1.10268351e-02f, 2.49854699e-02f, 1.25585273e-01f, 3.13198492e-02f, 9.68596712e-02f,
  -8.07040557e-02f, 4.22941339e-05f, 3.72421443e-02f, -1.31905094e-01f, -1.44262582e-01f, -1.08362123e-01f, 1.75038338e-01f, -2.45722681e-02f, 5.56552298e-02f, 6.20369688e-02f,
  1.16288014e-01f, -1.00922182e-01f, -5.74276932e-02f, -8.27997848e-02f, 1.98684335e-02f, -4.37957942e-02f, -1.49707749e-01f, 9.65088792e-03f, -8.25516805e-02f, 2.47174241e-02f,
  8.23599026e-02f, 6.92219473e-03f, 1.69959009e-01f, 8.44046697e-02f, -1.71874344e-01f, 1.81566805e-01f, -9.36546102e-02f, 2.01680120e-02f, -1.01870291e-01f, -1.06704555e-01f,
  -6.92891851e-02f, -6.55981600e-02f, 5.18620992e-03f, -6.48832619e-02f, -6.75793514e-02f, 1.45610705e-01f, -1.38844341e-01f, 1.86839551e-01f, -5.78779262e-03f, 7.58815780e-02f,
  1.40634075e-01f, -1.78530030e-02f, 1.02181360e-01f, -8.52596834e-02f, -7.37791732e-02f, -6.22878112e-02f, 3.19598652e-02f, -1.22771189e-01f, -1.35099262e-01f, -3.82546633e-02f,
  2.90148500e-02f, -1.00715840e-02f, 1.80176403e-02f, 9.81582887e-03f, 4.64590043e-02f, 4.12112214e-02f, 4.92981337e-02f, -2.89987936e-03f, 6.65903315e-02f, 4.06923890e-02f,
  -3.71016003e-03f, 6.23634122e-02f, 1.26553133e-01f, -8.67474300e-04f, 7.41505101e-02f, 2.14313883e-02f, 3.06848809e-02f, 5.05864155e-03f, 3.22993472e-02f, 3.44312266e-02f,
  4.20339219e-02f, 6.22300841e-02f, 9.78767499e-03f, 3.93775525e-03f, -1.48276482e-02f, -3.68938893e-02f, 5.40625304e-02f, -1.50803715e-01f, -5.95517792e-02f, -8.98829773e-02f,
  -2.48976471e-03f, 8.47179145e-02f, 6.06508702e-02f, 2.23332457e-02f, -3.97834135e-03f, -3.39641944e-02f, 7.08359620e-03f, -2.88815354e-03f, -5.35306036e-02f, -7.58600608e-03f,
  4.29533161e-02f, 9.63043347e-02f, 9.39865410e-02f, 8.99953651e-04f, 4.36783545e-02f, 2.70681791e-02f, 8.31048340e-02f, -7.52330348e-02f, 3.22970971e-02f, 9.65969414e-02f,
  -5.00692315e-02f, 2.60339621e-02f, -4.37514894e-02f, -4.71529439e-02f, 8.62521753e-02f, 4.36154194e-03f, 2.26932559e-02f, 5.55854067e-02f, -2.40931008e-03f, 3.92610058e-02f,
  4.71088476e-03f, -5.87482983e-03f, -1.81987379e-02f, -6.29974976e-02f, -7.94069692e-02f, 2.25311220e-01f, -7.01881871e-02f, 6.04488002e-03f, -4.50277440e-02f, 3.13252546e-02f,
  -2.36338545e-02f, -1.35571986e-01f, 7.00231418e-02f, -8.71646330e-02f, 3.53538096e-02f, 7.49562979e-02f, 7.72484438e-03f, 2.80811694e-02f, 1.39191210e-01f, 4.45572957e-02f,
  -9.32966918e-02f, 1.07874513e-01f, -8.07282794e-03f, 3.08615534e-04f, -6.02074564e-02f, 5.17824329e-02f, -1.41474470e-01f, -3.61607820e-02f, -5.79210138e-03f, -3.68862674e-02f,
  -6.30643889e-02f, -4.18355735e-03f, -7.78892711e-02f, 7.83151109e-03f, 9.62932408e-02f, 3.09466310e-02f, -1.53078791e-02f, -1.35852657e-02f, -1.21552601e-01f, 7.89487362e-02f,
  -6.63170516e-02f, -2.85564270e-03f, 6.69623539e-02f, -8.30053240e-02f, -5.50846346e-02f, -1.48731425e-01f, 2.08663240e-01f, -5.37874028e-02f, -1.66019857e-01f, -5.76001629e-02f,
  -1.31834581e-01f, -4.93663065e-02f, 2.97907798e-04f, 1.17970467e-01f, 8.97299126e-02f, -7.26227686e-02f, -7.67213404e-02f, -3.71206105e-02f, 2.17139632e-01f, -8.60283747e-02f,
  -1.75406254e-04f, 1.40688762e-01f, 1.72085632e-02f, -4.58638109e-02f, 4.14629616e-02f, 7.65748546e-02f, 6.76939562e-02f, 1.56602100e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  7.76486471e-02f, -5.08360788e-02f, -3.15789804e-02f, 1.80497959e-01f, 1.15412772e-01f, 5.06463312e-02f, 2.76569556e-02f, -2.26447526e-02f, 2.83934064e-02f, -3.66115198e-02f,
  4.11638711e-03f, -6.74697384e-02f, 8.19306225e-02f, 9.55876708e-02f, -1.59630645e-02f, 6.37945831e-02f, -2.48353113e-03f, 8.22599456e-02f, 1.46613017e-01f, 5.23393787e-02f,
  3.23827863e-02f, 1.15614742e-01f, 6.68885261e-02f, 1.15495399e-02f, 7.63791054e-03f, 8.68947655e-02f, 5.82792461e-02f, -4.85195480e-02f, 1.20895773e-01f, 2.52874922e-02f,
  1.03522748e-01f, 5.49798943e-02f, 3.51571217e-02f, 4.35893098e-03f, -4.14636685e-03f, -4.48447764e-02f, 1.02400810e-01f, 6.15248233e-02f, -1.70518123e-02f, 1.51949763e-01f,
  -7.11808400e-03f, 1.16983809e-01f, -2.54213493e-02f, 1.03078656e-01f, 6.28283396e-02f, 7.13919401e-02f, -3.98340560e-02f, -3.17871524e-03f, -5.43744117e-02f, 1.21430285e-01f,
  9.47383419e-02f, -5.55334128e-02f, 7.40617365e-02f, 2.16531813e-01f, 2.26922408e-01f, 1.38453186e-01f, -3.80919129e-02f, -1.21600710e-01f, -2.46579722e-02f, 1.39673129e-01f,
  -2.95691580e-01f, -1.93618909e-01f, 1.59851879e-01f, -1.49191409e-01f, -5.06142341e-02f, 1.71388775e-01f, -4.10279296e-02f, 9.16241407e-02f, 3.13288122e-02f, 7.67888278e-02f,
  -5.94595559e-02f, -5.31126298e-02f, -3.96842994e-02f, 7.89570361e-02f, 1.00419588e-01f, -1.86195504e-02f, 1.89858854e-01f, -3.14848544e-03f, -1.99139327e-01f, 1.74401298e-01f,
  -5.94875664e-02f, -4.99614626e-02f, 2.27734208e-01f, 1.99179098e-01f, 1.37369350e-01f, 2.40704685e-01f, -4.73208167e-02f, -8.13162536e-04f, 7.68415257e-02f, -1.73256680e-01f,
  1.34987608e-01f, -2.73462920e-03f, -4.26717885e-02f, 4.41086181e-02f, 6.60221949e-02f, 7.34642297e-02f, 1.55720323e-01f, 1.79920197e-01f, 1.01686522e-01f, 2.29902610e-01f,
  -1.45910457e-01f, 4.29681577e-02f, 9.77484360e-02f, 1.71549082e-01f, 1.57668665e-01f, -1.65933281e-01f, 8.04320276e-02f, -2.20504820e-01f, -2.17080161e-01f, -3.51984240e-02f,
  -1.53084338e-01f, -1.34644300e-01f, 1.31950583e-02f, -3.01833488e-02f, -1.38837695e-01f, -3.00429557e-02f, 1.03543214e-01f, -4.91762087e-02f, 2.87794530e-01f, -7.46686682e-02f,
  -1.21842392e-01f, -9.82782245e-02f, -1.98045373e-02f, -2.78726280e-01f, 1.24964394e-01f, 1.71605825e-01f, -1.73442846e-03f, -1.10904612e-01f, 6.56735301e-02f, -6.33203760e-02f,
  1.34894013e-01f, 1.53005426e-03f, 1.29375458e-01f, 3.44120227e-02f, 4.04437743e-02f, -1.50880218e-02f, 3.57863307e-02f, -9.99170467e-02f, 3.27320918e-02f, 6.46190019e-03f,
  3.61388177e-02f, 1.50623307e-01f, -2.69215312e-02f, -2.63035651e-02f, -2.90995203e-02f, 1.18713044e-01f, 5.82997203e-02f, 7.34366030e-02f, 2.09878162e-02f, 8.82440284e-02f,
  6.62550107e-02f, 1.47397090e-02f, 6.36321381e-02f, 1.22636147e-01f, 1.69445947e-01f, 1.10003091e-02f, 1.46261841e-01f, -1.48881786e-02f, 1.06887661e-01f, 1.27153799e-01f,
  -5.38345203e-02f, 4.05280814e-02f, 6.07485063e-02f, -1.37212651e-03f, 3.69076908e-04f, -7.34233623e-03f, 6.44238070e-02f, 3.86192724e-02f, 1.19171552e-01f, 2.04872221e-01f,
  4.55805920e-02f, 6.24089465e-02f, 2.15504430e-02f, 1.69278830e-02f, -9.44444686e-02f, 1.39092743e-01f, -1.19971506e-01f, 1.27487168e-01f, 8.45758170e-02f, -1.69664562e-01f,
  -1.85951889e-02f, 7.88667575e-02f, -1.36789745e-02f, -1.04730360e-01f, -9.47360247e-02f, -1.00013539e-01f, 7.33531639e-02f, 9.01491493e-02f, -1.38435081e-01f, -2.07320511e-01f,
  1.29891708e-01f, -1.27125069e-01f, 1.97099838e-02f, 6.49968386e-02f, -7.71223605e-02f, -5.14107645e-02f, -3.96450311e-02f, 1.22100823e-01f, -1.35914251e-01f, -4.60403264e-02f,
  2.30568629e-02f, 7.66060650e-02f, 2.36676157e-01f, 7.53408968e-02f, 1.27420202e-01f, 1.04484886e-01f, -1.38565060e-02f, 9.74428579e-02f, -2.37510726e-01f, 1.37506440e-01f,
  1.55151173e-01f, 1.25873730e-01f, 1.25453547e-01f, 9.35306400e-02f, -5.28661795e-02f, -2.67357435e-02f, 1.07282422e-01f, -1.30362138e-02f, 6.72206804e-02f, -7.25148916e-02f,
  -3.81721593e-02f, 1.02165505e-01f, 8.28006640e-02f, -5.23956567e-02f, 1.23141170e-01f, 2.09446624e-01f, 4.50837985e-02f, 6.64038286e-02f, -1.67925596e-01f, 9.09840465e-02f,
  8.65923464e-02f, -1.98967710e-01f, 6.87852204e-02f, -1.65272534e-01f, 9.37001035e-02f, -6.59786463e-02f, 4.25416324e-03f, -2.10454583e-01f, 2.86307987e-02f, -7.62702003e-02f,
  4.44685221e-02f, -1.57222986e-01f, -1.32595822e-01f, -7.45497225e-03f, 6.62568510e-02f, -2.22245157e-02f, 1.17784850e-01f, 4.65812348e-02f, -5.76036386e-02f, -7.42894933e-02f,
  2.85034832e-02f, 1.10185929e-01f, 1.69577837e-01f, 2.74602562e-01f, -7.44129717e-02f, 2.94562150e-02f, 5.28478716e-03f, -1.09438181e-01f, -5.24839126e-02f, -1.50516191e-02f,
  2.50406116e-02f, 1.07632704e-01f, -2.94280071e-02f, 5.30221015e-02f, 5.57191186e-02f, -2.72174068e-02f, -8.05483386e-03f, 2.45626289e-02f, -6.59880340e-02f, 9.10334811e-02f,
  -1.13228731e-01f, -9.17767286e-02f, -4.02354673e-02f, 1.19487115e-03f, -3.95728722e-02f, 5.09880148e-02f, 1.74115580e-02f, 5.63778952e-02f, -2.89026066e-04f, -4.24553342e-02f,
  -2.83438526e-03f, 7.64063522e-02f, 5.64427897e-02f, 2.40305346e-02f, 6.66112229e-02f, 7.05145001e-02f, 3.52489427e-02f, -1.33269997e-02f, -4.02344912e-02f, -1.30406143e-02f,
  4.13299352e-02f, -1.89214330e-02f, 1.27092293e-02f, 1.25829250e-01f, 2.51956079e-02f, 1.68897361e-02f, 6.05024509e-02f, 2.10725926e-02f, -7.73938000e-02f, -1.50908343e-02f,
  4.91417870e-02f, 5.54767512e-02f, -9.13105235e-02f, 9.93370265e-02f, -4.49700393e-02f, 4.75113168e-02f, 7.73376599e-02f, 3.99213955e-02f, 2.16654744e-02f, 7.18414634e-02f,
  1.94979966e-01f, 1.76241264e-01f, 6.49491996e-02f, -1.39037237e-01f, 2.42758878e-02f, 1.11649491e-01f, -1.24678530e-01f, 7.64332572e-03f, 2.27131784e-01f, -2.08240692e-02f,
  -1.30228128e-03f, 6.19034395e-02f, 4.57032993e-02f, -1.57871470e-02f, -4.80710454e-02f, 5.02902791e-02f, -1.46947995e-01f, 1.34637840e-02f, 4.38088365e-02f, 1.36918828e-01f,
  -3.61978188e-02f, -2.00833037e-01f, 3.92263420e-02f, 4.78086174e-02f, -3.68875749e-02f, 5.79491109e-02f, -4.26420681e-02f, -2.31826871e-05f, 2.51219720e-01f, 1.36238396e-01f,
  -8.30923468e-02f, 8.28537941e-02f, -1.01759315e-01f, -9.05650854e-02f, -7.95885399e-02f, -6.09482974e-02f, 8.62106085e-02f, 2.33155284e-02f, 2.25912511e-01f, 1.48084253e-01f,
  -4.69782129e-02f, -2.75942329e-02f, 8.64118263e-02f, 1.07629061e-01f, -1.21903429e-02f, 1.41202360e-01f, 6.82952162e-03f, -5.74020632e-02f, 9.26954821e-02f, 2.30689585e-01f,
  1.24238804e-01f, -3.39301415e-02f, 3.78126860e-01f, -9.78068933e-02f, -8.64336491e-02f, 3.52003314e-02f, -6.18071966e-02f, -1.19703420e-01f, 1.81745231e-01f, -4.90257554e-02f,
  -1.65443167e-01f, -4.20866497e-02f, 1.34082124e-01f, -1.50853293e-02f, 6.64473027e-02f, -5.90503868e-03f, -8.94155055e-02f, 1.05290011e-01f, -1.15639769e-01f, 2.32275426e-01f,
  3.55744600e-01f, 2.08731279e-01f, -5.59748672e-02f, -1.42299458e-01f, 3.75285819e-02f, -4.75761965e-02f, 7.75167393e-03f, 9.05791894e-02f, -7.38760782e-03f, 7.83937052e-02f,
  6.96925148e-02f, 9.96553451e-02f, 8.33290219e-02f, 1.69480503e-01f, 1.99202504e-02f, -1.40455011e-02f, 1.26966968e-01f, 1.14914946e-01f, -1.40949897e-02f, 8.80438462e-02f,
  -1.43654225e-02f, 4.30491101e-03f, -3.00526954e-02f, 8.85267332e-02f, 5.52199259e-02f, 8.22132751e-02f, 4.52173129e-02f, 2.96691004e-02f, 5.17596006e-02f, 1.02645764e-02f,
  7.66858086e-02f, -4.47139628e-02f, -4.26754449e-03f, 8.12671408e-02f, 3.20127583e-03f, 7.08641782e-02f, 7.79308081e-02f, 9.19837877e-02f, 2.99035404e-02f, 1.98275540e-02f,
  1.55517548e-01f, 8.51523429e-02f, -1.45325083e-02f, 1.03217080e-01f, 4.25188392e-02f, 4.44132090e-02f, -6.98498636e-02f, 5.85439503e-02f, 4.25880253e-02f, 4.43198383e-02f,
  5.45033403e-02f, -2.14327679e-06f, 8.67955685e-02f, 5.11075258e-02f, 6.27643988e-02f, 7.24259838e-02f, 2.83368863e-02f, 5.80225885e-02f, 2.20998794e-01f, 2.16724604e-01f,
  2.00723454e-01f, -4.61593010e-02f, -8.11742619e-02f, 1.03267066e-01f, -1.80846304e-01f, 5.17675653e-02f, 1.09417737e-01f, -1.04823768e-01f, -9.11669731e-02f, 2.53529310e-01f,
  -1.68033354e-02f, 1.29745916e-01f, -3.22901718e-02f, 7.41993561e-02f, -5.06694876e-02f, -1.16479553e-01f, 1.59164444e-01f, -4.38462272e-02f, -8.47619399e-02f, -2.12147892e-01f,
  -7.19887391e-02f, -7.71162063e-02f, 8.89895018e-03f, 2.04336885e-02f, 1.28819384e-02f, -7.72622898e-02f, 2.52025634e-01f, 1.99295938e-01f, -2.15531558e-01f, 1.29498973e-01f,
  -5.39285690e-02f, 2.74209236e-03f, -1.32577762e-01f, -2.93762870e-02f, 1.20488890e-01f, 1.11379951e-01f, 1.77889988e-01f, 7.98564330e-02f, -4.82165702e-02f, 3.65446620e-02f,
  1.07397966e-01f, 1.80604070e-01f, -8.04948062e-02f, 2.47917980e-01f, -1.43015131e-01f, -1.30190969e-01f, 1.93974257e-01f, 3.03680062e-01f, 1.49107039e-01f, -1.66590646e-01f,
  3.90622914e-01f, -9.86933559e-02f, -1.58373311e-01f, 1.11423820e-01f, -1.45049199e-01f, -4.34181578e-02f, 1.19669266e-01f, 1.39049012e-02f, 1.42455950e-01f, -8.95081386e-02f,
  4.29051034e-02f, -6.04178496e-02f, 1.85935795e-01f, -7.06155524e-02f, -1.17972776e-01f, 8.49647596e-02f, -2.34105363e-02f, 6.59524351e-02f, 1.50641426e-01f, 1.97941154e-01f,
  9.92797539e-02f, -5.51768914e-02f, 4.23166193e-02f, 3.03547401e-02f, -1.03201844e-01f, -1.45367226e-02f, 1.10341527e-03f, -4.55563068e-02f, 5.14129773e-02f, 1.13118831e-02f,
  -1.06383450e-02f, -6.36087060e-02f, 6.45366684e-02f, 1.19275503e-01f, 2.65899003e-02f, 1.23215802e-01f, -1.06172711e-02f, -9.16873962e-02f, 1.36493549e-01f, 9.88349617e-02f,
  -5.33505380e-02f, 1.42078111e-02f, 6.67243004e-02f, 7.24788755e-02f, -1.45270647e-02f, -2.16520187e-02f, -2.75062807e-02f, 1.97665896e-02f, 1.09183781e-01f, 8.75281766e-02f,
  5.91201894e-02f, 6.83566406e-02f, 6.79554418e-02f, -3.02299801e-02f, 4.62082475e-02f, 1.08342119e-01f, 1.25628412e-01f, 4.09684293e-02f, -6.31658137e-02f, 9.02260281e-03f,
  9.83178094e-02f, -6.42444268e-02f, 1.28989860e-01f, -1.94677077e-02f, 3.79257114e-03f, 1.90822650e-02f, 1.19922213e-01f, 7.93788210e-02f, 1.06046079e-02f, 1.23814784e-01f,
  -3.32349841e-03f, 1.78354010e-01f, 1.91239998e-01f, 9.86548662e-02f, -3.94675955e-02f, 3.70979011e-02f, -8.15919116e-02f, 8.08758438e-02f, -1.35671303e-01f, -8.36283043e-02f,
  9.07445326e-02f, -9.64143798e-02f, 1.77217141e-01f, 2.28778943e-01f, 4.13642675e-02f, 1.32402614e-01f, 4.95691299e-02f, -6.78841472e-02f, 1.04296640e-01f, -1.16143167e-01f,
  1.31279022e-01f, -4.92639951e-02f, 2.54618023e-02f, -8.44218433e-02f, -4.06512478e-03f, 7.32810572e-02f, -3.25111412e-02f, 1.07535698e-01f, 2.49950126e-01f, -1.70006771e-02f,
  -7.55081922e-02f, 5.73266670e-02f, -4.69460040e-02f, -3.35432291e-02f, -1.30184889e-01f, -1.35891795e-01f, 1.71191394e-01f, 1.65729143e-03f, 9.43593308e-02f, -8.92816260e-02f,
  -1.36232544e-02f, 1.02727674e-01f, -2.78055854e-02f, -2.66723037e-02f, -7.66607374e-03f, 7.20033869e-02f, -1.53652042e-01f, -4.56385799e-02f, -3.33654620e-02f, -1.45678639e-01f,
  -1.79742333e-02f, -2.55394310e-01f, 1.96770817e-01f, 1.10171221e-01f, -1.10043503e-01f, 1.14640348e-01f, -6.62969202e-02f, -6.88534603e-02f, -1.31588593e-01f, 2.61913478e-01f,
  1.60506114e-01f, 1.20075271e-01f, 2.43233502e-01f, -9.07278210e-02f, 7.46942163e-02f, 2.44566590e-01f, -1.53786153e-01f, 1.97925717e-01f, 9.24533606e-02f, 1.28161460e-01f,
  -4.68896367e-02f, 2.48209476e-01f, 1.57355696e-01f, -1.07647747e-01f, -9.29658115e-02f, 2.77564734e-01f, 4.94911186e-02f, -9.59440321e-02f, -8.13073292e-02f, 2.23820463e-01f,
  1.36853963e-01f, 9.92110074e-02f, -2.65067648e-02f, 8.49825963e-02f, 5.30253872e-02f, 7.07806796e-02f, 2.89579816e-02f, 5.96119091e-02f, 1.21520206e-01f, 3.70896496e-02f,
  1.18178807e-01f, 1.19350925e-01f, 4.98056039e-02f, 1.35596663e-01f, 3.56837921e-02f, 3.19541804e-03f, 1.09386422e-01f, 5.17274104e-02f, 2.88932491e-02f, -8.09127465e-04f,
  9.50706303e-02f, 1.12369470e-01f, 4.81112637e-02f, -1.49370618e-02f, -2.43985057e-02f, -1.77813228e-02f, -1.17042447e-02f, 1.66740224e-01f, 7.34913647e-02f, 2.60501593e-01f,
  1.53812155e-01f, 4.87110093e-02f, 1.27418950e-01f, 5.57748638e-02f, 1.33647770e-01f, -4.73578125e-02f, 5.35660796e-02f, 2.10647518e-03f, -5.47482185e-02f, 7.66615048e-02f,
  8.13105777e-02f, -2.66331783e-03f, 1.30147606e-01f, -1.72032267e-02f, 9.78858471e-02f, 8.76812264e-02f, 1.11922614e-01f, 6.98425695e-02f, 7.28933662e-02f, 7.46826977e-02f,
  8.95088762e-02f, -1.13188051e-01f, 1.09049387e-01f, 7.26994425e-02f, -3.57490294e-02f, 1.69557139e-01f, 1.38059547e-02f, -2.13079214e-01f, -7.96368569e-02f, -3.73437069e-04f,
  1.48660932e-02f, 4.84317616e-02f, 3.38639617e-02f, 2.31078878e-01f, -5.59205040e-02f, -6.77164420e-02f, 1.28252715e-01f, -9.01827887e-02f, 1.98397115e-01f, -2.18552127e-01f,
  2.15886354e-01f, -3.63813750e-02f, -3.92612964e-02f, -5.89952571e-03f, -5.55943400e-02f, -4.13797386e-02f, 1.43988818e-01f, -1.96645148e-02f, -1.56693056e-01f, 1.37154624e-01f,
  1.99749559e-01f, -2.40391672e-01f, 1.34760067e-01f, 2.21679360e-01f, 1.22256435e-01f, 3.59586447e-01f, 1.57358006e-01f, 8.58193710e-02f, 1.52843848e-01f, 1.68130323e-02f,
  1.56389326e-01f, 6.96494430e-02f, -2.91342400e-02f, -1.44856069e-02f, -1.57390788e-01f, 1.83196098e-01f, -4.11032215e-02f, 2.48628110e-01f, 3.82226966e-02f, -8.05831328e-03f,
  1.06342226e-01f, -2.54739113e-02f, -1.57936029e-02f, 1.30230233e-01f, 1.25291824e-01f, -5.33736423e-02f, -1.03418797e-01f, 1.36009008e-01f, 8.23871121e-02f, 1.46981284e-01f,
  1.95029125e-01f, -2.97016893e-02f, -1.05842039e-01f, 7.24477181e-03f, 4.79506738e-02f, -6.27700910e-02f, 4.08332841e-03f, -6.29505282e-03f, 1.79997325e-01f, 1.39693514e-01f,
  -1.61889672e-01f, -2.24698111e-01f, -5.73151074e-02f, 1.16149597e-01f, -3.92412618e-02f, -1.15080163e-01f, 1.48730963e-01f, -6.00539297e-02f, 5.63035309e-02f, 2.14478910e-01f,
  2.05942586e-01f, -5.44121861e-02f, 8.18224475e-02f, 2.56743878e-02f, 8.01695958e-02f, 3.00581586e-02f, 1.25355810e-01f, 1.72908798e-01f, 4.29519750e-02f, 1.60507411e-01f,
  5.78888170e-02f, 2.34592631e-02f, 8.52841362e-02f, 3.27140503e-02f, 6.28509745e-02f, 9.08325016e-02f, -1.03692181e-01f, 5.05666323e-02f, 8.31045136e-02f, 4.74347882e-02f,
  1.30508050e-01f, 1.76969841e-01f, 3.14860083e-02f, 5.27591854e-02f, 1.59454104e-02f, 1.25849321e-01f, 1.43512953e-02f, -6.48517627e-03f, -1.03492908e-01f, 1.92408070e-01f,
  2.12277725e-01f, 9.18940455e-02f, 5.13500497e-02f, 7.21082389e-02f, 1.57106087e-01f, 4.03961837e-02f, 1.26628220e-01f, -8.27561542e-02f, 1.33181006e-01f, -3.63863260e-02f,
  2.71915317e-01f, 4.07449752e-02f, 5.81307523e-03f, 9.45363343e-02f, 1.80114746e-01f, 3.59285325e-02f, 1.31011412e-01f, 5.70646822e-02f, -6.68271407e-02f, -3.49519737e-02f,
  -6.99203238e-02f, -2.01131701e-01f, -3.07803243e-01f, -3.21043193e-01f, 3.90604138e-02f, 5.28435484e-02f, 6.45256713e-02f, -7.58455321e-02f, 1.99695379e-01f, 5.82100973e-02f,
  -2.12594002e-01f, 7.89514557e-02f, 7.38791823e-02f, -7.76033178e-02f, 3.43823247e-02f, -1.05165705e-01f, 6.04712106e-02f, 1.35237100e-02f, -1.97956953e-02f, -5.51995263e-02f,
  1.16826870e-01f, -1.82591766e-01f, -1.76656991e-02f, -2.88883541e-02f, -1.69265181e-01f, 7.55401626e-02f, 2.62653977e-01f, -1.25665262e-01f, -5.77364080e-02f, 1.89224124e-01f,
  -1.37148440e-01f, -1.88783720e-01f, -1.13822877e-01f, -3.00209492e-01f, 2.61533931e-02f, -4.62668128e-02f, -9.71047115e-03f, 2.22826600e-01f, -1.31123275e-01f, -3.23609672e-02f,
  -8.01315308e-02f, 1.62280668e-02f, 1.22095406e-01f, -1.59981355e-01f, -1.58779733e-02f, -7.93117508e-02f, -8.18071142e-02f, -1.73711330e-01f, 1.22356229e-02f, -1.04682874e-02f,
  1.02469787e-01f, -2.79157102e-01f, -1.30887881e-01f, 1.50395498e-01f, -5.64277656e-02f, 2.42336825e-01f, 2.56454498e-01f, 2.39997264e-02f, 1.71848461e-01f, 9.64356586e-02f,
  -7.36010522e-02f, -7.60127231e-02f, 3.06592196e-01f, -2.88478166e-01f, -1.45077929e-01f, -7.05173537e-02f, -2.22335100e-01f, 2.26420891e-02f, 1.20443322e-01f, 7.72938654e-02f,
  9.47839320e-02f, 4.09810096e-01f, -2.08454549e-01f, -1.01717003e-01f, 1.71205327e-01f, 3.09787154e-01f, 3.34889926e-02f, 8.90075415e-02f, 1.74128830e-01f, 4.76454385e-03f,
  3.81055288e-02f, 5.14424480e-02f, 9.33670998e-02f, 1.94442831e-02f, 3.09915356e-02f, 5.71665615e-02f, 7.30894832e-03f, 5.16138487e-02f, 1.41967207e-01f, 4.15920950e-02f,
  6.93128482e-02f, 1.37667164e-01f, 8.45354944e-02f, 1.41491994e-01f, -3.02310288e-03f, 3.71000618e-02f, 1.09749869e-01f, 3.74313183e-02f, 7.19887912e-02f, 1.06423266e-01f,
  4.63571511e-02f, 3.49542089e-02f, 1.17339365e-01f, 4.68336977e-02f, 5.18438108e-02f, -5.27558848e-02f, -3.85749191e-02f, 1.20843105e-01f, 9.37158316e-02f, 1.15732685e-01f,
  5.58467768e-02f, 1.28350422e-01f, 1.45944491e-01f, 6.00817539e-02f, 7.34411553e-02f, 2.31775343e-02f, 1.28357247e-01f, 2.70247199e-02f, 7.29493126e-02f, 4.25314307e-02f,
  -7.92676117e-03f, 4.74992208e-02f, 9.86904949e-02f, 1.97117049e-02f, 7.30584338e-02f, 6.17265813e-02f, -4.62925946e-03f, -2.81103328e-02f, -1.35843828e-02f, -9.76063386e-02f,
  -5.34101166e-02f, -2.26857617e-01f, 1.35653690e-02f, 1.35434613e-01f, 8.75239819e-02f, 1.26656471e-03f, -2.78749038e-04f, -4.31761071e-02f, -1.32979706e-01f, -2.22455448e-04f,
  4.26110700e-02f, 1.11920781e-01f, -9.02519152e-02f, 8.22629929e-02f, 2.75741192e-03f, 9.98665169e-02f, -5.93759418e-02f, -2.98933592e-02f, 9.57579985e-02f, -1.35858417e-01f,
  4.76888046e-02f, 8.86880979e-02f, -8.91781375e-02f, 5.22197485e-02f, 1.22503862e-01f, -4.96736653e-02f, -2.07580239e-01f, 2.37398028e-01f, -8.11137557e-02f, -8.84773731e-02f,
  -1.97359473e-02f, -1.40828922e-01f, -6.99702129e-02f, -5.35822511e-02f, 2.79726107e-02f, 1.11176699e-01f, -1.15438469e-01f, 1.14012966e-02f, -9.38186795e-02f, 3.50516103e-02f,
  1.41073078e-01f, -1.54296711e-01f, 1.19647300e-02f, -1.61561668e-02f, -4.80482504e-02f, 4.24345098e-02f, -6.59448057e-02f, -1.38179641e-02f, 8.20626095e-02f, -2.89680034e-01f,
  -1.30829617e-01f, -4.42768633e-03f, 4.58387136e-02f, -1.60911884e-02f, -5.16396612e-02f, -1.67440653e-01f, -6.05107732e-02f, -7.41868746e-03f, 7.37631842e-02f, -2.36664363e-03f,
  1.97619021e-01f, -1.28914446e-01f, -7.40701631e-02f, -1.19311251e-01f, -7.80814588e-02f, -1.08843058e-01f, 9.77161303e-02f, -3.99184711e-02f, 1.94407869e-02f, 1.44270927e-01f,
  -1.42278299e-01f, 2.82053463e-03f, 1.06066853e-01f, 2.68888295e-01f, 6.39699399e-02f, -5.30801304e-02f, -1.11183867e-01f, 1.61709245e-02f, 1.58405900e-02f, 3.33461948e-02f,
  9.78452563e-02f, -9.45010483e-02f, 2.71496698e-02f, -1.26656607e-01f, 7.18811573e-03f, 8.05767849e-02f, 1.36310816e-01f, 6.00265041e-02f, 8.93756449e-02f, 5.76882586e-02f,
  1.41302928e-01f, 1.30908385e-01f, 2.78612841e-02f, 5.27388267e-02f, 6.93445355e-02f, 1.61981761e-01f, -4.90931235e-02f, -5.09033073e-03f, -9.11021307e-02f, -1.57663580e-02f,
  5.26704639e-02f, -1.89431608e-01f, -6.34929389e-02f, -5.45179844e-02f, 1.40684158e-01f, 1.52863069e-02f, 1.42785953e-02f, 1.16614968e-01f, -4.46376242e-02f, 2.84207910e-02f,
  -6.39025643e-02f, 2.85534877e-02f, -3.82585227e-02f, 6.06778972e-02f, 5.11092544e-02f, 1.20433167e-01f, 7.13144778e-04f, 2.90953796e-02f, 5.26485108e-02f, 2.24934649e-02f,
  1.43558802e-02f, 3.67836840e-02f, -3.70820239e-02f, 1.76353335e-01f, 1.26988620e-01f, 1.76100835e-01f, -5.59560768e-03f, 8.75890851e-02f, 1.74722269e-01f, 1.81783393e-01f,
  -1.46818236e-01f, -2.89642881e-03f, 1.43232256e-01f, -1.65566858e-02f, 1.47480309e-01f, 1.50747314e-01f, 8.51623192e-02f, -6.90042451e-02f, -8.78429264e-02f, 2.19921738e-01f,
  -4.37926091e-02f, -3.42517309e-02f, 4.85502258e-02f, 4.22725901e-02f, -7.95697048e-02f, -2.66352594e-01f, 2.16827635e-02f, -1.18079260e-01f, 1.07579164e-01f, 1.65278018e-01f,
  2.61383355e-01f, -4.89153143e-04f, 9.38285049e-03f, 1.84118837e-01f, -1.06016852e-01f, -4.41034324e-02f, -1.44957274e-01f, -1.62660599e-01f, 1.29337192e-01f, 3.93930152e-02f,
  -7.11710826e-02f, -1.09141104e-01f, 4.05058712e-02f, -7.98307657e-02f, -1.30059361e-01f, -8.06441307e-02f, -1.31135419e-01f, 2.30252780e-02f, -3.18344347e-02f, 3.91431712e-02f,
  1.11384645e-01f, -1.28073499e-01f, -2.46410631e-02f, -1.49736762e-01f, 6.95673972e-02f, 2.59124488e-01f, -1.83263928e-01f, 1.28227174e-01f, -1.04216188e-01f, -2.60125011e-01f,
  -1.23096414e-01f, 7.61294588e-02f, -1.69201434e-01f, 1.37329638e-01f, -1.40269607e-01f, -9.70073268e-02f, 5.80195822e-02f, 3.45005840e-01f, -1.79025680e-01f, 8.29022378e-02f,
  -1.25727300e-02f, 9.63421613e-02f, 3.44619960e-01f, 6.24324568e-02f, 1.49570554e-01f, 1.39860753e-02f, -3.28566544e-02f, -1.23994403e-01f, -3.64374765e-03f, -1.56586111e-01f,
  -4.16770130e-02f, 3.30099940e-01f, 1.13019451e-01f, 1.21435508e-01f, 2.43432634e-02f, 8.26266930e-02f, -2.75903307e-02f, 1.58652842e-01f, 9.85675976e-02f, 6.21089675e-02f,
  7.64251575e-02f, 1.30355224e-01f, 4.82561290e-02f, 4.86881509e-02f, 1.27632394e-01f, 1.22789517e-02f, 9.09071490e-02f, 1.23054929e-01f, 1.30690128e-01f, -3.33730057e-02f,
  1.04847156e-01f, 2.29529105e-02f, 7.70282745e-02f, 1.26829743e-01f, -1.63246244e-02f, -1.57409087e-02f, 1.29938405e-02f, -1.72767118e-02f, -3.50352824e-02f, -2.01563146e-02f,
  -4.82128449e-02f, 1.40751153e-01f, 9.33107361e-02f, 5.86195923e-02f, 1.10082708e-01f, 5.05110770e-02f, -3.75021435e-02f, -4.35752831e-02f, 5.96554764e-02f, 3.08953337e-02f,
  -9.49412361e-02f, 1.13665335e-01f, -6.39048368e-02f, 7.43292719e-02f, 6.51747733e-02f, 3.11341602e-04f, 1.01252161e-01f, 6.27994984e-02f, 1.85263172e-01f, 1.00708741e-03f,
  1.16015203e-01f, 1.84681322e-02f, 3.51285143e-03f, -3.24420966e-02f, 9.42696929e-02f, 6.79731146e-02f, 6.62555695e-02f, 2.37498686e-01f, 1.11545302e-01f, -3.60933095e-02f,
  -1.09364025e-01f, 4.56398651e-02f, 2.91972775e-02f, 1.17458679e-01f, -2.02080924e-02f, -1.95079464e-02f, -2.02887774e-01f, 7.45214298e-02f, 1.26750261e-01f, -2.22401414e-02f,
  3.47026139e-02f, -2.01596454e-01f, 1.56197757e-01f, -7.13800713e-02f, -3.59883830e-02f, -1.01712197e-01f, -5.22418097e-02f, -8.31472278e-02f, -6.25896780e-03f, -1.83920294e-01f,
  -2.15012976e-03f, 4.29442637e-02f, 2.45867446e-01f, -2.82840312e-01f, 8.03701580e-02f, 8.10783356e-02f, -1.32940978e-01f, 1.65980145e-01f, 1.25718400e-01f, 1.42912984e-01f,
  3.63430455e-02f, -7.18774050e-02f, 1.14662178e-01f, 3.71650867e-02f, 1.52919544e-02f, -2.59226598e-02f, -1.58030331e-01f, 2.36380950e-01f, 6.51078746e-02f, 9.26672667e-02f,
  -2.81663761e-02f, 2.77418308e-02f, -3.49003263e-02f, 9.86023061e-03f, -3.23427431e-02f, 2.95663446e-01f, 1.36333436e-01f, -1.32574409e-01f, -7.05399513e-02f, 1.02964252e-01f,
  4.11635339e-02f, 2.59144634e-01f, 3.26130912e-02f, 2.06232131e-01f, -6.03690445e-02f, 9.20761377e-02f, 1.83934554e-01f, -4.29603755e-02f, -1.00913169e-02f, 8.09723288e-02f,
  2.72613704e-01f, 4.47550453e-02f, -1.05737016e-01f, 9.40944329e-02f, 1.52916804e-01f, -1.60245493e-01f, -4.76341434e-02f, -9.49765444e-02f, 1.46516785e-01f, -1.15850791e-01f,
  9.19487178e-02f, 1.64138049e-01f, 8.09892081e-03f, 4.92835864e-02f, 4.99186963e-02f, 9.19796973e-02f, -8.65872018e-03f, 1.85207147e-02f, 1.39201237e-02f, 2.68018879e-02f,
  1.14445865e-01f, -9.18306317e-03f, 3.11064012e-02f, 8.93543847e-03f, 9.37677547e-02f, 2.77891047e-02f, 6.41996115e-02f, 2.89560109e-02f, 1.84141204e-01f, 1.50599517e-02f,
  3.61674540e-02f, 8.34300593e-02f, 5.04197627e-02f, -5.53148352e-02f, 9.86994654e-02f, -6.43778369e-02f, 3.72399054e-02f, 5.14762476e-02f, 1.01485856e-01f, 1.36344030e-01f,
  6.25962839e-02f, 8.05652663e-02f, 9.52859446e-02f, -6.05254024e-02f, 2.70171114e-03f, 4.85774763e-02f, 2.98966710e-02f, -2.39564367e-02f, -5.73896058e-02f, 1.23809397e-01f,
  -2.24450082e-02f, 4.22950238e-02f, 6.53107762e-02f, 9.75608528e-02f, 3.97192948e-02f, 6.43854290e-02f, 9.26293731e-02f, 7.51716495e-02f, 5.50759432e-04f, 5.18646091e-03f,
  3.52527499e-02f, -8.42184052e-02f, 1.45620212e-01f, 1.03409655e-01f, -8.69451687e-02f, -1.53083261e-03f, -1.49517447e-01f, 6.40621688e-03f, 5.03511690e-02f, -2.08082005e-01f,
  1.26296863e-01f, -1.76298786e-02f, -1.43809706e-01f, 9.90109220e-02f, 4.55966331e-02f, -1.92092553e-01f, -4.37055342e-02f, -7.81415030e-02f, -6.34460673e-02f, -9.65798497e-02f,
  3.01386006e-02f, 1.47852495e-01f, -2.39408731e-01f, 6.67749494e-02f, 1.44421890e-01f, 2.65905291e-01f, -5.36094094e-03f, 5.86390793e-02f, -6.49341419e-02f, -8.30679461e-02f,
  6.94355741e-02f, -2.27870569e-01f, -1.83253318e-01f, -1.67279258e-01f, 2.16411293e-01f, 5.65350316e-02f, 1.08851463e-01f, 2.04428807e-01f, 2.21041664e-01f, -1.69871166e-01f,
  -3.66346724e-02f, -1.36583358e-01f, -8.61596987e-02f, -1.09872170e-01f, -1.60191089e-01f, 1.82028905e-01f, -3.68895642e-02f, 2.68498547e-02f, 2.41426691e-01f, -1.34688661e-01f,
  1.57402769e-01f, 1.37023106e-01f, -1.87382266e-01f, 5.85625879e-02f, 1.49156228e-01f, 2.58379877e-02f, -1.42848492e-01f, 2.90790033e-02f, 2.03604609e-01f, -1.17743939e-01f,
  1.78672582e-01f, 2.16744214e-01f, -1.66450709e-01f, 1.88324124e-01f, -3.64549682e-02f, 1.60517186e-01f, -1.90121308e-02f, 1.31870165e-01f, 1.91107079e-01f, 4.63507399e-02f,
  2.92958994e-03f, 1.24367505e-01f, 2.00810239e-01f, -2.78214943e-02f, -1.41816586e-01f, -1.52665839e-01f, -1.45674035e-01f, -1.23986661e-01f, 1.59176514e-01f, 4.08911891e-02f,
  2.28288509e-02f, 8.19261447e-02f, 1.20485686e-01f, 1.23425713e-02f, 5.28587066e-02f, -2.13663168e-02f, 2.55443081e-02f, 3.70218493e-02f, 6.19284101e-02f, 1.06319010e-01f,
  4.99436036e-02f, 1.06742814e-01f, 4.82054763e-02f, -8.29987153e-02f, 1.55802950e-01f, 7.58655369e-02f, 6.27866909e-02f, 1.28203630e-01f, 2.52269376e-02f, 5.82125038e-02f,
  6.00570440e-03f, 1.23615988e-01f, 1.04654141e-01f, -2.98171993e-02f, 1.15669467e-01f, -4.58849557e-02f, 5.99391684e-02f, 3.41952555e-02f, 2.08658800e-02f, 1.48086384e-01f,
  7.13288561e-02f, 4.11233231e-02f, 2.48881027e-01f, -6.60092160e-02f, 9.13291499e-02f, 3.11960895e-02f, 3.46629955e-02f, -2.40094084e-02f, 1.53799787e-01f, 6.20016865e-02f,
  8.19542781e-02f, 1.18790515e-01f, 3.99574675e-02f, 7.19465911e-02f, 1.59774050e-02f, -3.86415794e-03f, -4.09311019e-02f, 1.40912846e-01f, 7.75578842e-02f, 1.34064276e-02f,
  3.41303386e-02f, 3.45057882e-02f, 1.19014174e-01f, -3.31330262e-02f, -1.62527964e-01f, -5.52226324e-03f, 1.35175794e-01f, -5.95655851e-02f, 6.29935563e-02f, -1.67994332e-02f,
  7.74113461e-02f, 1.38281479e-01f, 1.14518583e-01f, 1.19504355e-01f, -1.48666263e-01f, 4.93749678e-02f, -4.09964435e-02f, 1.50396869e-01f, -3.70323546e-02f, -7.96635449e-02f,
  -1.85560975e-02f, 2.17803549e-02f, 7.88385868e-02f, 2.11721361e-01f, 1.08471401e-02f, 1.31013885e-01f, -1.16488367e-01f, 9.46374014e-02f, -2.32964396e-01f, 1.87475801e-01f,
  -8.82327557e-02f, 4.37888950e-02f, 2.12201923e-01f, 7.87878484e-02f, -1.65405422e-01f, -3.98029126e-02f, 1.33590043e-01f, -1.47243172e-01f, -5.46636619e-02f, -3.88825163e-02f,
  -2.55505703e-02f, 2.58481223e-02f, 3.44301276e-02f, -1.01910584e-01f, -7.40182847e-02f, 1.15291081e-01f, 6.65758178e-02f, 5.46331666e-02f, 1.42080873e-01f, -1.04350289e-02f,
  -6.70292452e-02f, -1.32172629e-01f, -1.23464093e-01f, 1.82390325e-02f, 2.78483570e-01f, -8.07769224e-02f, -1.23898573e-01f, -7.20181689e-02f, -2.81328019e-02f, -1.89164817e-01f,
  6.90257549e-02f, 1.51500165e-01f, -1.06612369e-01f, 1.25694066e-01f, -9.56215244e-03f, -1.36291906e-02f, 1.96076229e-01f, -3.43047897e-03f, 5.95124699e-02f, -6.54030740e-02f,
  -1.25697345e-01f, 2.61339486e-01f, 8.66128057e-02f, 1.42322958e-01f, -1.60003871e-01f, 1.72293097e-01f, 1.01971179e-01f, 1.27636328e-01f, 2.43057050e-02f, 1.07370675e-01f,
  -1.40857119e-02f, 8.33858550e-02f, 4.60066274e-02f, 1.22040719e-01f, 8.13304186e-02f, 1.18369497e-01f, 1.38954222e-01f, 1.53044060e-01f, -1.10998116e-02f, 1.25876039e-01f,
  -3.23620886e-02f, -1.12445485e-02f, 2.52823588e-02f, 3.94306183e-02f, 6.17649732e-03f, 9.79230478e-02f, 5.62053882e-02f, -3.28370519e-02f, 3.68274674e-02f, 7.34801218e-02f,
  6.75792759e-03f, 9.89484414e-03f, -6.15832582e-02f, 2.43235365e-01f, 5.76237701e-02f, 1.98597401e-01f, -2.57736295e-02f, 1.28954127e-01f, 8.87243450e-02f, 5.04070595e-02f,
  2.25589052e-01f, -8.75940025e-02f, 1.36188537e-01f, 7.16896579e-02f, -3.50446962e-02f, 4.50912956e-03f, 4.08435576e-02f, -6.85118511e-02f, 1.06073558e-01f, 1.32036489e-02f,
  1.02411970e-01f, 6.54482022e-02f, 5.05284257e-02f, 2.74968483e-02f, 9.01259109e-02f, -1.30146453e-02f, 8.67880806e-02f, 8.55740979e-02f, 1.83170706e-01f, 1.23151958e-01f,
  -3.06203756e-02f, 5.26981577e-02f, 7.51975784e-03f, -1.80980846e-01f, 3.54449600e-02f, -2.74406057e-02f, 2.93134563e-02f, 1.03539668e-01f, 1.06848449e-01f, 3.34726721e-01f,
  1.66735530e-01f, -1.03671029e-01f, 1.07188903e-01f, 7.59937689e-02f, 1.62527695e-01f, -4.46100496e-02f, 1.10200591e-01f, 9.39241126e-02f, -6.98687881e-02f, 7.22356364e-02f,
  -1.00673653e-01f, -9.86336470e-02f, 4.52860072e-02f, 1.47945151e-01f, -2.46231645e-01f, -1.42138777e-02f, 4.11380194e-02f, -4.23011519e-02f, 1.44922018e-01f, 1.75618529e-01f,
  7.80175775e-02f, 8.80806744e-02f, 3.92960347e-02f, 8.76751244e-02f, 5.29509857e-02f, -2.20934283e-02f, 5.60878292e-02f, 8.62828940e-02f, 1.87732771e-01f, -1.11226104e-02f,
  -1.47527859e-01f, -2.60250214e-02f, -1.12076551e-01f, 1.57462895e-01f, 1.39614090e-01f, 1.46246776e-01f, 2.34561265e-01f, -2.33833149e-01f, 2.29308307e-02f, 2.42629111e-01f,
  1.40282318e-01f, 2.34918252e-01f, 1.62580580e-01f, 5.30477464e-02f, 1.41664758e-01f, 4.24011908e-02f, 5.95877580e-02f, -3.66978236e-02f, 3.16367745e-02f, 2.35963929e-02f,
  -1.62297282e-02f, -1.95628002e-01f, 1.28430784e-01f, -1.16943993e-01f, 5.26335575e-02f, -3.40432152e-02f, -1.94017276e-01f, -2.88792193e-01f, -1.03001222e-01f, 3.46494317e-01f,
  -7.33193383e-02f, 5.11166006e-02f, -2.79573202e-02f, -1.13328360e-01f, 8.33369419e-02f, 1.63923636e-01f, 1.41942829e-01f, 7.00097680e-02f, 7.24907964e-02f, 8.60839784e-02f,
  3.62279713e-02f, 3.21362875e-02f, 8.90279654e-03f, 6.06390834e-02f, 1.15649309e-02f, -1.26193219e-03f, 7.92271644e-02f, 5.74707650e-02f, 7.65690878e-02f, 1.61667183e-01f,
  5.26436120e-02f, 1.02506049e-01f, 2.86889262e-02f, 8.92804842e-03f, 6.25519454e-02f, 1.12057827e-01f, 4.13323194e-02f, 5.77375442e-02f, 2.06592306e-02f, 4.44705365e-03f,
  2.80094668e-02f, 1.01146009e-02f, 7.72461519e-02f, 4.69820313e-02f, 9.85246003e-02f, 1.41814739e-01f, 1.46088973e-01f, 7.73714036e-02f, -3.98066863e-02f, 6.58541247e-02f,
  8.54294077e-02f, -8.29801150e-03f, -2.37469357e-02f, 1.16595693e-01f, -7.41932483e-04f, 9.77834910e-02f, 1.17366984e-01f, 5.99273257e-02f, 3.93506549e-02f, 9.32235569e-02f,
  1.09929234e-01f, 4.80199158e-02f, 7.25687891e-02f, 3.16718407e-02f, -4.43664417e-02f, -2.13459179e-01f, 7.05229789e-02f, 3.56176682e-02f, -1.15525790e-01f, -7.80827552e-02f,
  -3.05150449e-02f, 1.55279152e-02f, 5.49859460e-03f, -1.69080514e-02f, -6.19488433e-02f, -3.25909331e-02f, -6.81476668e-02f, -7.81081766e-02f, -1.17392279e-01f, 9.09231380e-02f,
  -5.83585585e-04f, -8.38159174e-02f, 6.80272281e-02f, -6.62895590e-02f, 3.49859484e-02f, -6.34428337e-02f, -1.07847778e-02f, -1.06791876e-01f, 1.21250793e-01f, 9.55364034e-02f,
  4.44113873e-02f, -5.23759015e-02f, 1.13463007e-01f, 5.33580147e-02f, 7.04013631e-02f, -1.12223066e-01f, 6.64578378e-02f, -1.96230225e-03f, 2.46604020e-03f, 7.30623677e-02f,
  6.81180581e-02f, 1.05640106e-01f, 1.94943815e-01f, -3.74931144e-03f, -3.46049666e-02f, -4.77312356e-02f, -1.67104498e-01f, -1.53773092e-02f, 8.04729983e-02f, 1.05884545e-01f,
  1.15108386e-01f, 1.50862277e-01f, 7.87146240e-02f, -5.51602989e-03f, -1.38765484e-01f, 9.34980437e-02f, -2.17546485e-02f, -7.40742609e-02f, 1.16589591e-01f, -1.50575489e-01f,
  -2.32460424e-01f, 8.39021951e-02f, 1.35478988e-01f, -6.67991042e-02f, 3.62656415e-02f, 2.51710504e-01f, -1.35682404e-01f, -4.45936397e-02f, 1.30806074e-01f, -1.86993241e-01f,
  -8.36421624e-02f, -3.42326239e-02f, 2.08047181e-01f, -4.65492904e-02f, -6.62585050e-02f, -3.42692691e-03f, 2.30075151e-01f, -6.45560250e-02f, -2.69623756e-01f, -1.44281596e-01f,
  7.92532861e-02f, 5.49916141e-02f, 1.36867508e-01f, 7.12651312e-02f, 3.16450484e-02f, 2.00616911e-01f, 2.15886510e-03f, -1.29590509e-02f, 8.79659504e-02f, 9.78902914e-03f,
  -1.76091567e-02f, 1.57097206e-01f, 9.28851590e-02f, 6.28731549e-02f, 1.22454137e-01f, -6.00529052e-02f, 1.94179088e-01f, 2.03526005e-01f, 8.75267163e-02f, 9.07451585e-02f,
  2.32247800e-01f, 2.41422802e-02f, 1.09375678e-01f, 2.69930642e-02f, 6.14169203e-02f, 1.24112047e-01f, 6.37878105e-02f, 3.52646485e-02f, -1.71818286e-02f, 3.09888572e-02f,
  1.61035731e-01f, 6.45183474e-02f, 3.19088474e-02f, 9.05319862e-03f, 2.19498202e-02f, 1.16872694e-02f, 2.20368919e-03f, 1.79212391e-01f, 1.31590098e-01f, 1.30911488e-02f,
  9.07680914e-02f, 1.20565839e-01f, 2.42978912e-02f, 3.77067886e-02f, 2.43539549e-02f, 1.56786859e-01f, -8.10345111e-04f, 2.55857371e-02f, 4.45187725e-02f, 6.19488489e-03f,
  8.59718323e-02f, -1.70365919e-03f, 5.38699180e-02f, -6.37547448e-02f, 4.46765348e-02f, 1.56981274e-02f, -8.63738507e-02f, -1.51702300e-01f, -1.20163962e-01f, 1.44887626e-01f,
  -4.07419764e-02f, -1.57971039e-01f, -4.33591194e-02f, -1.93666384e-01f, -2.06075028e-01f, 5.88627085e-02f, 1.08081661e-01f, -7.93575048e-02f, -1.54656976e-01f, 1.39094934e-01f,
  -2.27956492e-02f, 4.35132720e-02f, 1.94313563e-02f, 1.09915413e-01f, -1.93608686e-01f, 5.92482723e-02f, 5.74709289e-02f, 2.78681040e-01f, -7.99054578e-02f, 1.34719266e-02f,
  2.40593404e-02f, -5.64897470e-02f, -1.53399380e-02f, -2.05870960e-02f, -2.53886819e-01f, -1.92327172e-01f, 1.71686023e-01f, -2.57237982e-02f, 9.59523693e-02f, 9.95454863e-02f,
  1.03871793e-01f, -1.53819948e-01f, -1.06670238e-01f, -7.67591074e-02f, -1.50240913e-01f, -1.96197525e-01f, 3.22666168e-02f, 6.93402253e-03f, -9.71653461e-02f, -1.58271685e-01f,
  1.00533597e-01f, -7.58490860e-02f, 6.36544973e-02f, 1.43530637e-01f, -5.88523373e-02f, -1.51319265e-01f, -6.58000931e-02f, 2.09441602e-01f, -2.46668279e-01f, -1.34726986e-03f,
  -2.71935593e-02f, -1.64768472e-01f, 5.41501679e-02f, 1.35450438e-01f, -5.67733832e-02f, 1.86039001e-01f, 6.67718574e-02f, 3.01394641e-01f, 8.63956939e-03f, 9.86749902e-02f,
  5.55602759e-02f, 1.43424449e-02f, 2.40460977e-01f, 6.39802516e-02f, 1.45040274e-01f, -2.99229294e-01f, -2.22071800e-02f, -7.43174776e-02f, -9.08319186e-03f, 1.70900095e-02f,
  8.80700201e-02f, 2.11719386e-02f, -4.24231738e-02f, 2.41230620e-04f, 6.13003857e-02f, -4.60227430e-02f, -1.68892741e-02f, 9.75256860e-02f, 4.10740189e-02f, 7.92825967e-02f,
  1.64550841e-01f, 1.70841813e-01f, -4.81893905e-02f, 5.48811592e-02f, 1.36011422e-01f, -1.99931636e-01f, 1.06465496e-01f, -2.93329038e-04f, 9.86837968e-02f, 8.67887437e-02f,
  5.25886565e-02f, 2.50376128e-02f, 6.16315678e-02f, 1.08409412e-01f, -1.76698212e-02f, 1.33109652e-03f, 6.75198734e-02f, 1.09476961e-01f, 4.79728281e-02f, 1.11097820e-01f,
  1.93121228e-02f, -3.89028341e-02f, 7.93719292e-03f, 2.11627856e-02f, 1.96390197e-01f, 6.67882785e-02f, -9.10025742e-03f, 1.24586932e-02f, 8.57889131e-02f, -1.11245930e-01f,
  1.31239057e-01f, -7.17928112e-02f, -1.38116321e-02f, 4.33885306e-02f, 6.91012219e-02f, 1.59709230e-02f, -2.62586623e-02f, 1.07195646e-01f, 7.46651366e-02f, -8.08437821e-03f,
  1.30104229e-01f, 3.87933813e-02f, -1.30797386e-01f, -1.52377144e-01f, -5.22130243e-02f, -4.83920909e-02f, -1.04426658e-02f, -1.23783790e-01f, 9.77531374e-02f, -2.16487586e-01f,
  6.65134117e-02f, 1.16877735e-01f, -3.76936235e-02f, 3.49718988e-01f, 1.65606156e-01f, -2.34328642e-01f, -8.58651474e-02f, -1.33210063e-01f, 5.16836196e-02f, -2.92077195e-02f,
  4.77249660e-02f, -3.52626778e-02f, -5.84126599e-02f, 2.13971511e-01f, -1.23844706e-01f, 1.31192133e-01f, 8.86933208e-02f, 1.65178806e-01f, 2.11020950e-02f, -8.89936164e-02f,
  -4.04119529e-02f, 1.00027487e-01f, -1.37419373e-01f, -8.88676122e-02f, 1.47817373e-01f, -1.70264728e-02f, 2.33517680e-02f, -1.17263921e-01f, -7.39777610e-02f, 1.19773276e-01f,
  -3.86572815e-02f, -1.97099280e-02f, 8.06631520e-02f, -4.63887006e-02f, -9.02551487e-02f, -8.87838751e-02f, -2.44211420e-01f, -2.13619009e-01f, -1.15458006e-02f, -1.89942062e-01f,
  3.49326342e-01f, -7.44901523e-02f, -4.40376401e-02f, -3.75504978e-02f, -1.32290751e-01f, 2.69285530e-01f, 2.96022654e-01f, 8.74787569e-02f, 5.19429110e-02f, -1.27019152e-01f,
  2.04559788e-01f, -1.99565768e-01f, 7.07137063e-02f, 1.82765603e-01f, -1.41231179e-01f, 2.67333597e-01f, 9.41672176e-02f, 1.45336958e-02f, -1.52874604e-01f, 1.33308440e-01f,
  1.92600980e-01f, 1.49490669e-01f, -1.60494715e-01f, 4.30086672e-01f, 3.26330096e-01f, 1.91060100e-02f, -5.51244095e-02f, 8.10856074e-02f, 4.38442044e-02f, 5.94457164e-02f,
  6.07036240e-02f, 1.95135713e-01f, 7.37320632e-02f, 2.81656440e-02f, 1.19790882e-01f, 1.42255183e-02f, 1.08216424e-02f, 1.44177854e-01f, 4.66653779e-02f, 7.63313994e-02f,
  1.44468144e-01f, 5.74780330e-02f, 9.30832252e-02f, 2.12222978e-01f, 8.84987563e-02f, 1.38465583e-01f, 1.03905916e-01f, 1.41036964e-03f, 1.02566615e-01f, 3.76579612e-02f,
  9.10158753e-02f, 6.48717210e-02f, 7.96075091e-02f, 9.61039290e-02f, 1.07431067e-02f, 8.20618495e-02f, 6.62008598e-02f, 3.40544730e-02f, 8.91790986e-02f, 4.20849286e-02f,
  7.08580166e-02f, 9.52170193e-02f, 1.29637644e-01f, 1.01202480e-01f, 2.68989235e-01f, 3.15193497e-02f, 2.25430727e-02f, 1.00752272e-01f, 6.88262284e-02f, -5.26113436e-03f,
  5.04414774e-02f, 2.53938530e-02f, 6.59315288e-02f, 4.90309261e-02f, 4.32767607e-02f, -5.17287552e-02f, 1.00135826e-01f, 4.14944626e-02f, 3.38477157e-02f, -4.29005250e-02f,
  2.11343588e-03f, -4.55765203e-02f, 1.06768616e-01f, -9.80685428e-02f, 3.16689946e-02f, 1.54971018e-01f, -1.57948911e-01f, 2.20626257e-02f, -2.32244283e-01f, -1.38209924e-01f,
  -8.86797681e-02f, 1.32897273e-01f, 2.07987311e-03f, 1.03244439e-01f, -1.01648442e-01f, 2.74770796e-01f, 1.26952648e-01f, 7.97386169e-02f, 1.68095678e-01f, 4.19408493e-02f,
  4.72372398e-02f, -1.99023150e-02f, -9.25025418e-02f, -9.55909584e-03f, -3.41774290e-03f, 1.54540827e-02f, -9.39749479e-02f, -3.42417844e-02f, -5.90500459e-02f, 2.01954320e-01f,
  -2.31832098e-02f, 4.94755581e-02f, 9.30448547e-02f, 1.71871275e-01f, 1.25120068e-02f, 6.37485906e-02f, -7.13475868e-02f, 1.34851420e-02f, 1.19475527e-02f, 9.78486612e-02f,
  -7.91446716e-02f, -1.15888134e-01f, 1.08128726e-01f, 4.71633655e-04f, -1.45029262e-01f, 6.54140264e-02f, -6.80836663e-02f, 2.70476997e-01f, 3.08601157e-04f, -1.88492313e-01f,
  2.14437544e-01f, -9.16312709e-02f, -1.11964278e-01f, 1.00395173e-01f, -3.23351920e-02f, -1.67420700e-01f, -2.70215005e-01f, -9.32708457e-02f, -1.95094138e-01f, -1.05956249e-01f,
  -9.69204959e-03f, -4.94901929e-03f, 2.24825814e-01f, 1.32441625e-01f, -3.99901415e-04f, -6.92412555e-02f, -1.02863684e-02f, -1.60795942e-01f, -4.42108251e-02f, -2.16825873e-01f,
  -1.53718591e-01f, -1.41205251e-01f, 1.71626955e-02f, 4.95651476e-02f, 2.10507303e-01f, 8.49842802e-02f, 1.44964725e-01f, 1.69169977e-01f, -4.42209691e-02f, 8.16740170e-02f,
  4.60070260e-02f, 2.00316254e-02f, 2.53228005e-02f, 8.18483457e-02f, 3.60612720e-02f, 1.62826791e-01f, 1.30600110e-01f, 7.39230216e-02f, 1.79419834e-02f, -3.16665098e-02f,
  1.20684698e-01f, 8.57656971e-02f, 8.33360553e-02f, 1.40636504e-01f, 1.32583126e-01f, 1.54810503e-01f, 3.31556946e-02f, 8.28739721e-03f, 8.16430077e-02f, 4.87226583e-02f,
  1.63028686e-04f, 4.25858311e-02f, 4.77892347e-02f, 1.12291925e-01f, 9.67747495e-02f, 1.17404059e-01f, -2.59410311e-02f, 6.77561909e-02f, 9.33169425e-02f, 5.50582036e-02f,
  1.06263466e-01f, 8.73058960e-02f, -1.09755993e-02f, 3.87797654e-02f, 4.57869768e-02f, 4.81844060e-02f, 2.39983350e-02f, 5.65275922e-02f, 9.44768190e-02f, 1.68443426e-01f,
  1.63245462e-02f, 5.95684536e-02f, 6.20808713e-02f, 1.52361225e-02f, 9.27216709e-02f, 3.12424637e-02f, 4.64640334e-02f, -4.08569491e-03f, 1.32013679e-01f, 1.41190246e-01f,
  -1.20370716e-01f, -1.06808625e-01f, -8.22301880e-02f, -9.74274948e-02f, 1.48311138e-01f, -1.10323921e-01f, -8.47518817e-03f, -7.55272573e-03f, -2.17251647e-02f, 9.77884755e-02f,
  1.34204179e-01f, -1.33313432e-01f, -5.24413697e-02f, 4.84738760e-02f, 5.63941849e-03f, 1.90995913e-03f, -4.32269797e-02f, 1.56026289e-01f, -1.79791003e-01f, 3.45832780e-02f,
  9.78037044e-02f, 1.74394622e-01f, 3.68538834e-02f, 1.52113229e-01f, -1.07497945e-01f, -1.12361588e-01f, 2.12731324e-02f, -1.18634254e-01f, -5.75622320e-02f, -8.94935206e-02f,
  8.11987817e-02f, -1.75317630e-01f, 9.74539593e-02f, 1.61252648e-01f, 1.36997119e-01f, -8.02672133e-02f, -1.32601216e-01f, -9.31130629e-03f, 3.15294601e-02f, -5.50325736e-02f,
  -5.77603355e-02f, -2.72896253e-02f, -5.50171407e-03f, -2.71119480e-03f, 2.29469046e-01f, 6.01919591e-02f, 9.92498919e-02f, 6.03364818e-02f, -1.02547467e-01f, 1.84826404e-01f,
  1.79671600e-01f, 1.55943617e-01f, -1.84218347e-01f, 1.26806339e-02f, 1.49086446e-01f, -2.01423809e-01f, 7.08043054e-02f, 2.21386150e-01f, -2.92139854e-02f, 1.33524954e-01f,
  -7.22544715e-02f, -1.60593450e-01f, 9.85050276e-02f, -6.22481704e-02f, 7.66911879e-02f, -1.45245001e-01f, 3.62669975e-02f, 1.42632620e-02f, 2.11856395e-01f, -4.84337099e-02f,
  -2.10165426e-01f, -7.33442083e-02f, -1.27170846e-01f, -6.88170493e-02f, 6.53817356e-02f, 5.30869178e-02f, 5.14267795e-02f, 6.86092302e-02f, 6.73631504e-02f, -2.14543641e-02f,
  7.39946812e-02f, 5.60731478e-02f, -1.75524652e-02f, 3.29598449e-02f, 5.20109795e-02f, -2.55076159e-02f, 1.58312947e-01f, -6.27582967e-02f, 1.73955023e-01f, 1.66819081e-01f,
  7.66270161e-02f, 4.53077517e-02f, 2.82444775e-01f, 6.79782256e-02f, 7.34011009e-02f, 8.37508515e-02f, 9.61399302e-02f, 1.09891653e-01f, 9.63093489e-02f, 1.24201849e-01f,
  8.95832777e-02f, -1.62244976e-01f, 8.75646397e-02f, -2.00040694e-02f, 1.28739238e-01f, 6.48523390e-04f, -1.04603237e-02f, 1.94797646e-02f, -1.05601028e-01f, 1.32203370e-01f,
  4.62376438e-02f, 4.74582575e-02f, 7.27906898e-02f, 1.06568165e-01f, -2.78672129e-02f, 1.75880313e-01f, 2.83525828e-02f, 2.20919013e-01f, 4.44364771e-02f, 4.36127335e-02f,
  5.59038222e-02f, 3.44162621e-02f, 6.93282112e-02f, 6.57400414e-02f, 1.36463689e-02f, 3.21236323e-03f, -1.05501078e-02f, 3.62309217e-02f, 1.43210635e-01f, -7.62100220e-02f,
  -8.61614048e-02f, 1.01803981e-01f, 5.55564128e-02f, -4.11399044e-02f, -2.81524248e-02f, -1.54341325e-01f, -7.28554055e-02f, -2.04946026e-01f, -6.38989508e-02f, 7.21580461e-02f,
  -1.93017930e-01f, 4.90700752e-02f, -2.13620916e-01f, 6.30606860e-02f, -1.59943029e-01f, 4.11904491e-02f, -1.02900490e-01f, 4.46262434e-02f, 1.66491628e-01f, 2.28433385e-01f,
  -5.97248040e-02f, -2.32408624e-02f, 6.18805699e-02f, -5.74796572e-02f, -3.29031050e-02f, -4.64024171e-02f, -1.71409622e-01f, -1.91891730e-01f, 5.36313839e-02f, -1.35172337e-01f,
  -7.50485212e-02f, 4.67836484e-02f, 7.38495365e-02f, -2.40523487e-01f, -1.26888767e-01f, -1.36397928e-01f, -1.25291958e-01f, -1.01795897e-01f, 7.04979524e-02f, -7.70027330e-03f,
  6.70154691e-02f, -1.91223547e-01f, 7.21183866e-02f, -1.79305230e-03f, -5.56469969e-02f, 1.68206632e-01f, -1.67131647e-02f, -1.91646758e-02f, -1.74525380e-02f, 1.11428693e-01f,
  -1.73329115e-02f, -1.00395456e-01f, -6.75267130e-02f, -9.45333540e-02f, -1.33993208e-01f, 2.17396408e-01f, 1.02635501e-02f, 2.56781727e-01f, -4.04267348e-02f, 2.98363805e-01f,
  5.98470196e-02f, 1.23961255e-01f, 1.89179212e-01f, -9.60145146e-02f, 1.76352829e-01f, 3.60129327e-01f, 2.91654497e-01f, -4.32877064e-01f, 1.30467102e-01f, 9.13269594e-02f,
  -3.60595658e-02f, -2.03282405e-02f, -7.04956874e-02f, -5.27415723e-02f, 1.84177347e-02f, -3.93052027e-02f, 5.09371795e-02f, 3.85980085e-02f, 1.23453386e-01f, 2.61750910e-02f,
  2.93098353e-02f, 6.85727894e-02f, -2.58424338e-02f, -1.41489953e-02f, 1.79600179e-01f, 1.10246435e-01f, -1.89861245e-02f, 5.63265719e-02f, 5.39521277e-02f, 5.89035638e-02f,
  -1.34010809e-02f, 1.05510294e-01f, 8.03633705e-02f, 1.24969579e-01f, -1.03389882e-02f, 6.15604669e-02f, 2.60921251e-02f, 8.22965652e-02f, 1.42038852e-01f, -1.30967304e-01f,
  -1.58970859e-02f, -4.97508869e-02f, 2.55591944e-02f, 4.65289205e-02f, 4.49579395e-03f, 1.49223238e-01f, 5.23796007e-02f, 9.75223407e-02f, 4.51165363e-02f, 8.48219693e-02f,
  9.84070897e-02f, 8.39082450e-02f, 6.99049234e-02f, 4.43778709e-02f, -2.44522933e-02f, 1.24230050e-02f, 3.66624594e-02f, 5.77857122e-02f, 4.64675725e-02f, 1.00757685e-02f,
  6.06633499e-02f, 1.28345534e-01f, 1.05966136e-01f, 2.17375517e-01f, 7.77156726e-02f, 1.02966882e-01f, 1.66319504e-01f, 9.53758508e-02f, 1.09173745e-01f, 7.01288134e-02f,
  9.61012989e-02f, 8.09698552e-02f, -5.67557402e-02f, 1.19606853e-01f, 1.02630354e-01f, -2.64538139e-01f, -1.39382899e-01f, 2.87491411e-01f, -2.56059300e-02f, 7.19826519e-02f,
  -1.32073030e-01f, 1.80175975e-01f, -2.11672857e-01f, -7.90339410e-02f, 1.15240037e-01f, -3.09829861e-02f, 2.77745966e-02f, -2.06772201e-02f, 5.13593219e-02f, -2.48160567e-02f,
  2.71515641e-02f, -3.81709896e-02f, -1.40505061e-01f, 3.66252996e-02f, 6.50066361e-02f, -3.26330736e-02f, -1.50649354e-01f, -1.54863894e-01f, -1.49044707e-01f, -6.06272481e-02f,
  -9.43840519e-02f, -2.24311762e-02f, -1.04771800e-01f, 2.84937155e-02f, 8.99419263e-02f, 1.51375845e-01f, -7.15066958e-03f, -5.27434237e-02f, 2.27430940e-01f, -8.14241916e-02f,
  1.92578640e-02f, 8.59299600e-02f, -1.23200402e-01f, 9.57058296e-02f, 9.05166119e-02f, 2.88813472e-01f, 1.40899241e-01f, -2.78793097e-01f, 1.96076646e-01f, -4.44310270e-02f,
  -1.32198274e-01f, -2.51426026e-02f, -1.89452052e-01f, 4.25818749e-02f, 2.50065267e-01f, 2.33117566e-01f, 3.91364992e-02f, -8.34586397e-02f, 9.66864675e-02f, -5.22712469e-02f,
  1.63421631e-01f, -1.07462406e-01f, 1.23376556e-01f, 2.18066216e-01f, 1.22852027e-01f, -3.25863212e-02f, 7.04284087e-02f, 1.14963241e-01f, -2.19035093e-02f, 2.10024819e-01f,
  1.56823874e-01f, 7.65929371e-02f, -1.01019211e-01f, 2.21715003e-01f, -7.88300931e-02f, -5.73205156e-03f, 4.86207791e-02f, 1.80911377e-01f, 3.36833224e-02f, 2.35539377e-01f,
  1.21429682e-01f, 4.62426394e-02f, 8.69054347e-02f, -7.37260208e-02f, 1.48577437e-01f, 1.19008131e-01f, 1.00000545e-01f, -3.41587886e-02f, 2.75493383e-01f, 1.06579237e-01f,
  3.71392109e-02f, 5.81795573e-02f, 5.92708029e-02f, 8.41374919e-02f, 7.37434700e-02f, 1.55247757e-02f, -1.15037881e-01f, -3.24480282e-03f, 1.06146537e-01f, 1.61530122e-01f,
  1.40525680e-02f, -7.97305182e-02f, 2.39722840e-02f, -6.27190545e-02f, -2.34535560e-02f, 1.07246963e-02f, 8.27004611e-02f, 5.18741272e-02f, -2.98466515e-02f, 1.65649354e-01f,
  -6.64911419e-02f, -3.94741297e-02f, -1.07957914e-01f, 1.82330206e-01f, 3.20162959e-02f, 6.27754070e-03f, 7.56053999e-02f, -5.80729991e-02f, 6.11982718e-02f, -1.27786219e-01f,
  1.03634866e-02f, 8.73322412e-02f, 4.19683047e-02f, 9.20151621e-02f, 1.57210678e-01f, 1.22309454e-01f, 4.95212525e-02f, 3.29583399e-02f, -1.29795700e-01f, -1.70982465e-01f,
  -5.86991794e-02f, -8.90561938e-02f, -4.95208502e-02f, 1.51002735e-01f, 7.40486160e-02f, -1.04594052e-01f, -7.54386410e-02f, 1.20681852e-01f, -7.98873082e-02f, -1.06567435e-01f,
  1.00745954e-01f, 1.05290577e-01f, -2.14485973e-01f, 1.38092935e-01f, -1.42690241e-01f, 5.67935258e-02f, -1.23934858e-01f, -2.91339252e-02f, -1.31375268e-01f, -8.53143409e-02f,
  2.11039200e-01f, -1.86330825e-01f, -1.07507147e-01f, -7.56163290e-03f, -1.33931926e-02f, 3.67161296e-02f, 6.40394986e-02f, 1.06508464e-01f, 9.48837493e-03f, -2.45218188e-01f,
  3.08952387e-02f, 7.10305050e-02f, 1.21044561e-01f, -2.52150625e-01f, -1.93117753e-01f, 9.09886882e-02f, -1.49647579e-01f, -1.24086700e-01f, 1.12368986e-01f, 1.52240455e-01f,
  1.99358225e-01f, -1.28031135e-01f, 6.75674230e-02f, 2.87713051e-01f, 2.26034690e-02f, 3.26089442e-01f, 7.08079785e-02f, -1.45150885e-01f, -9.68641862e-02f, -1.39108617e-02f,
  -4.80946749e-02f, 7.72795528e-02f, -6.42835647e-02f, 1.14726871e-01f, 4.95953765e-03f, 3.32742035e-01f, 1.58469945e-01f, 1.05307050e-01f, 1.15454998e-02f, -3.77112590e-02f,
  1.32395644e-02f, 2.06108421e-01f, 3.41094509e-02f, -2.60726929e-01f, 1.89381465e-01f, 2.93589178e-02f, -1.62758604e-02f, -2.50594825e-01f, 6.77531958e-02f, 4.05316725e-02f,
  8.29694569e-02f, 1.40034147e-02f, 2.05542073e-01f, -4.32539359e-03f, -3.18838619e-02f, 1.08841404e-01f, 5.43917678e-02f, 1.27047552e-02f, 1.19860165e-01f, 7.37477690e-02f,
  -5.93459085e-02f, 1.74435094e-01f, -1.92926880e-02f, -2.21486226e-01f, 5.38627710e-03f, 7.51275942e-02f, 1.00691959e-01f, 6.25059754e-02f, 1.02686457e-01f, 8.30063075e-02f,
  1.04042031e-01f, 1.87815335e-02f, 4.14477438e-02f, 6.56827241e-02f, 1.50765613e-01f, 1.04757085e-01f, 1.61405846e-01f, 4.10567895e-02f, 1.39858484e-01f, 1.04875483e-01f,
  -6.07690066e-02f, 1.11300185e-01f, 1.22572839e-01f, -1.54571915e-02f, -7.26132989e-02f, -5.20306872e-03f, 4.07942496e-02f, -4.62198034e-02f, 1.29241794e-01f, 1.27861708e-01f,
  1.44831195e-01f, 7.84577876e-02f, 3.56606692e-02f, 7.23865777e-02f, -1.18666306e-01f, 1.08450614e-01f, -7.98048675e-02f, 1.59405380e-01f, 7.86036775e-02f, -1.47321120e-01f,
  -3.32982130e-02f, 3.58792767e-02f, 1.59974974e-02f, -2.62350496e-02f, -4.59836125e-02f, -2.93692946e-01f, 1.43110648e-01f, 5.80444001e-04f, -1.72397792e-01f, -8.39147940e-02f,
  1.33301869e-01f, 3.63911279e-02f, 1.17855810e-01f, -3.67556252e-02f, -1.00812115e-01f, -1.67632252e-01f, 2.49231663e-02f, 1.06973629e-02f, -1.37062833e-01f, 1.38511918e-02f,
  -2.45536398e-02f, 7.70857036e-02f, 1.74382970e-01f, 6.61175549e-02f, 2.28900999e-01f, 1.81049854e-01f, 6.93739653e-02f, 9.79105234e-02f, -8.24015960e-02f, 1.39902169e-02f,
  2.40025312e-01f, 1.22750945e-01f, 1.80499062e-01f, 1.08871065e-01f, -1.28330290e-01f, -5.93391545e-02f, 1.56836256e-01f, -4.56164917e-03f, 6.27596304e-02f, -8.43371749e-02f,
  -1.39971334e-03f, 1.22829095e-01f, 4.06066924e-02f, -2.55090487e-03f, 6.73872754e-02f, 9.70112532e-02f, 1.46283597e-01f, 2.18136664e-02f, -1.39233088e-02f, 9.01062042e-02f,
  5.38914762e-02f, 7.79824238e-03f, 1.39497712e-01f, -4.48654853e-02f, 2.30635643e-01f, 1.12802880e-02f, 4.05149385e-02f, -2.69594610e-01f, 7.30605945e-02f, -1.37671232e-01f,
  7.50494599e-02f, -7.22377971e-02f, -2.81469792e-01f, -1.51960775e-01f, 8.54311883e-02f, -1.27130121e-01f, 1.93686903e-01f, 2.03193240e-02f, -6.84430972e-02f, 1.03623785e-01f,
  1.39770135e-02f, 1.91313535e-01f, 2.19653457e-01f, 1.40889421e-01f, -5.47858998e-02f, -2.65560206e-02f, 7.15219080e-02f, 4.82369587e-02f, 1.89186335e-02f, -7.98157081e-02f,
  1.28216997e-01f, 5.10374606e-02f, 1.06953979e-02f, 1.08346052e-01f, 6.57114089e-02f, 1.53333507e-02f, 1.39895171e-01f, 1.09102264e-01f, -4.62003797e-02f, 7.21223205e-02f,
  1.03244610e-01f, -1.55236810e-01f, 7.96099827e-02f, -1.31564826e-01f, 4.29553613e-02f, 6.92241937e-02f, 3.28321867e-02f, 1.08763330e-01f, 2.34508552e-02f, -3.89059186e-02f,
  2.80980039e-02f, 1.00951947e-01f, 7.57931499e-03f, -3.94467041e-02f, 5.31033091e-02f, 8.86710882e-02f, 1.00722097e-01f, 3.82760502e-02f, 3.79720591e-02f, 8.86647590e-03f,
  -2.72750738e-03f, -7.75696039e-02f, -1.23226285e-01f, 3.36829834e-02f, 1.01255272e-02f, 2.73361206e-02f, 1.12426607e-03f, 1.80848047e-01f, 1.55024633e-01f, 1.25390202e-01f,
  1.09543145e-01f, 7.44412765e-02f, 2.60062478e-02f, 1.95581257e-01f, -6.49304092e-02f, 4.71772403e-02f, 4.68667969e-02f, -1.52574733e-01f, -9.58424956e-02f, -8.59292671e-02f,
  -2.22798027e-02f, 1.46462381e-01f, -8.59054551e-02f, -1.37649506e-01f, 4.64458987e-02f, -4.84768413e-02f, 1.92434698e-01f, 4.12659124e-02f, -5.00168325e-03f, -6.81559891e-02f,
  -9.34921354e-02f, -1.37973562e-01f, 3.52495126e-02f, -2.92768806e-01f, -1.61707431e-01f, -1.77595064e-01f, -7.93018118e-02f, -6.89405799e-02f, -4.93083969e-02f, 6.86600655e-02f,
  9.86730382e-02f, 1.46113029e-02f, -2.25999914e-02f, -9.46556106e-02f, 1.04585476e-01f, 1.35895997e-01f, 2.14385167e-01f, -2.82710254e-01f, -2.36863866e-02f, 2.37562936e-02f,
  -4.27713618e-02f, 6.34622052e-02f, -6.65583590e-04f, -5.74416667e-02f, 1.76738668e-02f, -1.57328278e-01f, 4.77482602e-02f, -2.28194207e-01f, -3.40537913e-02f, -7.27298961e-04f,
  -1.11854866e-01f, 1.96021453e-01f, 3.23505215e-02f, -4.04130183e-02f, 2.48517189e-02f, -2.83323675e-01f, 2.49249805e-02f, 1.39227912e-01f, -2.11525172e-01f, -1.04694255e-01f,
  2.41190605e-02f, 3.13709043e-02f, 1.79154575e-01f, 1.88221142e-01f, 2.25746274e-01f, 2.64148116e-01f, 2.78760880e-01f, 1.81135610e-01f, -1.44636631e-01f, 9.09921527e-03f,
  -1.99109703e-01f, 8.85708854e-02f, -1.64251566e-01f, 2.41570085e-01f, 2.76143193e-01f, 2.48907581e-01f, 3.94273810e-02f, 3.80779237e-01f, 2.08626240e-01f, 1.24874339e-01f,
  1.48124889e-01f, 1.14668170e-02f, -2.98942495e-02f, -1.78271189e-01f, 9.74812806e-02f, 8.61000419e-02f, 6.87459260e-02f, -1.10299759e-01f, 6.17838055e-02f, 9.54370350e-02f,
  7.67929852e-03f, 9.24322680e-02f, 3.74470875e-02f, -4.24631685e-03f, 8.94471779e-02f, 5.36076613e-02f, 1.24792131e-02f, 2.63222284e-03f, 1.18053608e-01f, -4.92739417e-02f,
  8.34743083e-02f, -3.38947549e-02f, 4.37331349e-02f, 4.55323830e-02f, 2.15369314e-02f, 1.29840776e-01f, 5.38240746e-02f, -3.45798247e-02f, 1.10965930e-02f, 1.16410464e-01f,
  4.51525301e-02f, -5.49162515e-02f, -1.02408566e-02f, 3.04549951e-02f, 1.97447818e-02f, 5.11663780e-02f, 1.26246165e-03f, 5.04143871e-02f, -8.44495222e-02f, -2.99090287e-03f,
  -1.40597150e-01f, 2.82776337e-02f, 6.09189235e-02f, 2.41033845e-02f, -1.56323742e-02f, 1.85103968e-01f, 1.30033448e-01f, 6.62330538e-02f, 2.73283329e-02f, 3.94942611e-02f,
  1.05521150e-01f, 1.14079826e-01f, -5.37816016e-03f, 7.41295516e-02f, 4.45401445e-02f, -4.19169180e-02f, -6.02066964e-02f, -4.73986380e-02f, -3.09905745e-02f, 1.20114140e-01f,
  -5.63948862e-02f, 4.08232398e-02f, 1.04559675e-01f, -3.29353884e-02f, 2.76649028e-01f, 7.90166035e-02f, -7.97858164e-02f, -1.71648532e-01f, -1.40596241e-01f, 2.41489857e-02f,
  -1.01593928e-02f, -2.71392316e-01f, -1.93501279e-01f, -1.34134576e-01f, -1.16933309e-01f, -9.70433205e-02f, -4.08400707e-02f, -3.40444818e-02f, 1.51862293e-01f, 7.25213066e-02f,
  -7.74098188e-02f, -8.36363733e-02f, 1.73213363e-01f, 3.64984199e-02f, 1.74977794e-01f, -2.27243543e-01f, -1.60323456e-01f, -1.48477003e-01f, -1.15576141e-01f, -6.44364506e-02f,
  -4.48894687e-02f, 1.25044049e-03f, 4.87832166e-03f, -1.61826104e-01f, -4.90693003e-02f, -2.25027949e-01f, -1.02981210e-01f, 1.81234684e-02f, -6.31564930e-02f, 1.81767046e-01f,
  1.20640710e-01f, -1.65368855e-01f, -1.42990872e-02f, -2.98383266e-01f, 1.49486447e-03f, 2.59402514e-01f, -1.39196917e-01f, 2.14460236e-03f, 6.26281463e-03f, -1.14454351e-01f,
  4.13686931e-02f, 1.78766087e-01f, 2.05278605e-01f, 2.16141120e-01f, 1.77543834e-01f, 2.80667692e-01f, -1.79318003e-02f, 2.03719839e-01f, -1.10687904e-01f, 1.11086942e-01f,
  -1.50494099e-01f, 2.67102808e-01f, 2.40873381e-01f, 2.13321522e-01f, 1.57216713e-01f, 4.51915681e-01f, 2.84904391e-01f, -5.94516993e-02f, 7.99916387e-02f, -8.55859593e-02f,
  -7.24147633e-02f, -1.25339366e-02f, 3.47112417e-02f, -1.89499799e-02f, -7.03828335e-02f, 1.27917215e-01f, -2.27549449e-02f, 1.25376597e-01f, 8.42382014e-02f, 5.95391579e-02f,
  1.04479626e-01f, 3.79567705e-02f, 2.09301617e-02f, 5.72144389e-02f, 3.50273810e-02f, 1.12866595e-01f, -8.42162594e-03f, 1.05738513e-01f, 8.91691819e-02f, 2.18877234e-02f,
  -2.05786712e-02f, 7.51197711e-03f, 5.06156236e-02f, 7.42610097e-02f, -1.90391876e-02f, -9.35990289e-02f, 2.84023415e-02f, -3.51518169e-02f, -3.87225971e-02f, 9.22319368e-02f,
  -3.51787806e-02f, 1.42168567e-01f, 1.59712583e-02f, -1.50701944e-02f, 7.18206689e-02f, 3.42753381e-02f, 1.14381708e-01f, -3.12263537e-02f, 1.21538095e-01f, 5.00581600e-02f,
  1.10251829e-03f, 1.24483652e-01f, 6.01393022e-02f, -6.49400651e-02f, -4.53727469e-02f, -7.68146217e-02f, 8.87098610e-02f, -1.43558318e-02f, 3.53434756e-02f, 6.67545572e-02f,
  5.32308184e-02f, 1.92115476e-04f, 1.50576696e-01f, 1.03208840e-01f, 1.13090649e-01f, 1.67501137e-01f, 1.04267485e-01f, 2.36150980e-01f, 1.82786603e-02f, -1.82185862e-02f,
  -9.24943537e-02f, 5.64246671e-03f, -1.09407566e-02f, 1.38609201e-01f, 2.20517609e-02f, 9.44033191e-02f, -7.99157023e-02f, 3.22197638e-02f, 1.37345254e-01f, 4.87143956e-02f,
  6.92499802e-02f, -2.55256854e-02f, 1.67998657e-01f, -8.01382437e-02f, -4.03298810e-02f, 1.71096735e-02f, -1.15308121e-01f, -1.26643404e-01f, 1.06843077e-01f, -9.64255035e-02f,
  -2.16947764e-01f, 1.03597656e-01f, 1.03654586e-01f, -1.81546554e-01f, 6.79898560e-02f, 1.42429799e-01f, 2.36560460e-02f, 2.42549941e-01f, 1.83093548e-01f, 7.55690038e-02f,
  -1.62707083e-02f, 6.69701630e-03f, 1.27925664e-01f, 1.13420062e-01f, 9.59821790e-02f, -3.86231183e-03f, -2.65461028e-01f, 1.18498877e-01f, 2.31085718e-02f, 1.69801533e-01f,
  -7.22948788e-03f, 7.01341033e-02f, 1.03131704e-01f, -5.26710376e-02f, 3.09996195e-02f, 2.94737369e-01f, 1.67652309e-01f, -1.57886758e-01f, -8.69966373e-02f, 8.20191652e-02f,
  -2.00810339e-02f, 2.45226339e-01f, 6.30452111e-02f, -3.02535109e-02f, 5.35361469e-02f, 9.82155353e-02f, -1.49672078e-02f, 2.47733146e-01f, 1.17416054e-01f, 1.64216548e-01f,
  1.54878885e-01f, 1.72597483e-01f, -6.58507124e-02f, -2.30237380e-01f, -1.30985960e-01f, 7.06267431e-02f, 7.44764954e-02f, 4.98872139e-02f, -2.94679543e-04f, -5.47914654e-02f,
  4.00468931e-02f, 1.04859270e-01f, 1.06317684e-01f, -2.31679473e-02f, 1.55832261e-01f, 2.69183237e-02f, 6.68282807e-02f, 8.15032721e-02f, 5.12262620e-02f, 9.58527923e-02f,
  7.60900602e-02f, 4.81267460e-02f, 7.43721277e-02f, 6.74908236e-02f, 3.99856679e-02f, -6.32556677e-02f, -1.75220370e-02f, 3.92925739e-02f, 7.49527588e-02f, 3.07065658e-02f,
  6.84181228e-02f, 1.02792427e-01f, 1.01512663e-01f, 5.83934374e-02f, 1.55868446e-02f, 1.49789065e-01f, 2.25750078e-02f, 1.42818868e-01f, 1.44330904e-01f, 6.64977580e-02f,
  1.70388848e-01f, 1.53630063e-01f, -7.63663836e-03f, 7.36398697e-02f, -1.79149210e-02f, 6.35010973e-02f, 4.85850908e-02f, -9.86066088e-03f, 3.87905091e-02f, 5.49940346e-03f,
  6.42917380e-02f, 1.58534750e-01f, 1.50158092e-01f, 2.30543129e-02f, 2.44629867e-02f, 1.32340431e-01f, 5.56459762e-02f, 3.20160650e-02f, -4.17469069e-03f, 2.17585173e-03f,
  -1.68600734e-02f, -2.40801796e-01f, -1.47015914e-01f, -1.46465197e-01f, -1.68819338e-01f, -1.31666539e-02f, 5.82294501e-02f, -1.70105368e-01f, -3.57148163e-02f, 1.01168305e-01f,
  -1.34354040e-01f, -1.51653484e-01f, 8.34610015e-02f, -7.79879093e-02f, -1.00476392e-01f, -9.01658013e-02f, 2.42951028e-02f, -1.95925891e-01f, 1.15451932e-01f, -1.70090675e-01f,
  8.51765648e-02f, -3.51147950e-02f, 8.79774615e-02f, -6.98831752e-02f, 6.66326061e-02f, -1.88518912e-01f, 9.96228084e-02f, -9.01124477e-02f, 1.71047017e-01f, 1.16771057e-01f,
  1.43504292e-01f, -8.45137164e-02f, 1.44239396e-01f, 1.44848913e-01f, -6.41768798e-02f, 7.72984326e-02f, 2.52508391e-02f, -5.55547625e-02f, 1.17731085e-02f, 1.63628563e-01f,
  1.03904061e-01f, 3.11203767e-02f, -1.41224399e-01f, -1.80718675e-02f, 1.97113067e-01f, 7.70617276e-02f, 6.01570494e-02f, 4.31485213e-02f, -5.22769764e-02f, 1.84023622e-02f,
  -2.07991511e-01f, 2.08816957e-02f, 1.72749504e-01f, -1.82932541e-01f, -1.07589373e-02f, 6.05224818e-02f, 2.92920191e-02f, 1.20056883e-01f, 1.56029433e-01f, 5.66108711e-02f,
  1.28246620e-01f, 6.50214031e-03f, -5.63761853e-02f, -2.76541501e-01f, 5.26964553e-02f, -2.69745976e-01f, -3.27264443e-02f, -1.22990020e-01f, -4.60110605e-02f, 2.35733911e-02f,
  -1.14017487e-01f, 9.88257006e-02f, 8.34403187e-02f, -7.74596557e-02f, 5.37938066e-02f, -1.15757911e-02f, 2.49655247e-01f, -8.12575668e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  8.58569518e-02f, 1.01379909e-01f, 6.45144880e-02f, 7.30816424e-02f, 3.66707183e-02f, 4.70663011e-02f, 8.80053788e-02f, 6.34569004e-02f, 2.65893769e-02f, 6.44858330e-02f,
  5.77143878e-02f, 1.15550168e-01f, 4.73956354e-02f, 6.98659495e-02f, 8.20922181e-02f, 9.25282687e-02f, 5.42362705e-02f, 9.74313989e-02f, 9.58721191e-02f, 1.02385409e-01f,
  7.37016276e-02f, 1.22384243e-01f, 4.93570119e-02f, 9.23727602e-02f, 8.95696506e-02f, 9.97113958e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -4.65942807e-02f, 3.20513770e-02f, -1.39949933e-01f, 5.05835265e-02f, -7.58276433e-02f, 4.03545089e-02f, 3.07970960e-02f, 6.63629845e-02f, 4.29882035e-02f, -2.17295840e-01f,
  5.92168011e-02f, 1.61353886e-01f, -1.11838989e-01f, -1.19258620e-01f, -1.07177705e-01f, 1.76181383e-02f, 1.36894271e-01f, -1.81678101e-01f, 1.38505921e-01f, -4.03025709e-02f,
  -7.90412724e-02f, -2.26212382e-01f, -8.21469054e-02f, -1.36755770e-02f, -2.94987410e-02f, 1.10701792e-01f, 7.12583587e-02f, 6.69341683e-02f, -3.34011465e-01f, -6.47424906e-02f,
  -2.16664374e-03f, -1.64177015e-01f, 1.40230674e-02f, 6.14772029e-02f, 4.56492882e-03f, -1.47940546e-01f, -5.05440347e-02f, 1.95927955e-02f, -8.59055892e-02f, -7.46127889e-02f,
  -7.17852497e-03f, -1.82583228e-01f, -1.12708934e-01f, -8.70687962e-02f, 5.09971194e-02f, 3.29697430e-02f, 1.91097274e-01f, -1.99190527e-02f, 1.01884536e-03f, 4.97877933e-02f,
  5.64333312e-02f, -1.79461837e-01f, -2.84495175e-01f, -4.71032038e-02f, -1.83248356e-01f, -1.70168787e-01f, 2.60888070e-01f, -3.07216048e-01f, 5.25087379e-02f, -3.60558957e-01f,
  1.54540554e-01f, -2.66217403e-02f, 1.91513002e-01f, -1.71965018e-01f, -1.07461117e-01f, -2.17999458e-01f, -8.50458294e-02f, -7.08719864e-02f, 1.86948285e-01f, 2.54594713e-01f,
  -2.60753065e-01f, -1.13385037e-01f, -8.57381374e-02f, 1.07660338e-01f, -2.94493377e-01f, 1.96898639e-01f, -1.70422092e-01f, 9.16940719e-02f, 1.50888100e-01f, 7.78797343e-02f,
  -2.99306866e-02f, 2.81798959e-01f, -3.54627729e-03f, 1.61634445e-01f, -1.88717812e-01f, -5.33715002e-02f, 1.01604015e-01f, 1.99295476e-01f, -2.26853997e-01f, -1.03622735e-01f,
  -2.90695399e-01f, 1.28488943e-01f, -1.47327021e-01f, 1.81509256e-02f, 3.42684478e-01f, -1.83457211e-01f, 2.11605400e-01f, -3.45370695e-02f, 1.02386080e-01f, 2.24128682e-02f,
  1.40613362e-01f, -1.72264874e-01f, 7.16065615e-02f, -2.78977990e-01f, 1.85541943e-01f, 2.53461927e-01f, 5.80582209e-02f, 1.59095362e-01f, -3.57593030e-01f, -2.74387300e-01f,
  -4.56065349e-02f, 2.50735939e-01f, -1.60486236e-01f, -2.44138598e-01f, 2.90299445e-01f, -1.05062887e-01f, -4.54383612e-01f, -1.13416180e-01f, -2.15119701e-02f, 3.86158265e-02f,
  -3.85130525e-01f, 1.85949206e-01f, 1.92555308e-01f, -1.20428622e-01f, -3.34750444e-01f, -3.06212753e-01f, 3.36416095e-01f, -1.60719991e-01f, 1.31878853e-01f, -2.08207473e-01f,
  -6.13788180e-02f, -1.30532503e-01f, -1.62549347e-01f, 2.35220417e-02f, -5.15336357e-02f, 6.73918203e-02f, 4.28706296e-02f, 1.29013345e-01f, 3.99581343e-03f, -1.30556941e-01f,
  1.21911079e-01f, 9.99217182e-02f, 5.86339273e-03f, 1.46932960e-01f, 1.04087135e-02f, 2.19579428e-01f, -2.01651871e-01f, 1.47610679e-01f, 1.44983038e-01f, -1.99380741e-01f,
  9.97047871e-02f, -8.48279446e-02f, -3.35942023e-02f, -9.78267267e-02f, 4.75434847e-02f, 1.78044215e-01f, 1.73972085e-01f, 1.15536591e-02f, -1.43679455e-01f, 3.05343345e-02f,
  -5.61205845e-04f, -1.31015079e-02f, 4.25213985e-02f, -3.22001241e-02f, 2.93716304e-02f, 6.69266144e-03f, 1.99772522e-01f, 7.83868134e-02f, 1.18782490e-01f, 1.67254120e-01f,
  -1.38553366e-01f, -3.77613120e-02f, -1.11578785e-01f, 6.27138913e-02f, -2.05814421e-01f, -3.45832594e-02f, -1.03633732e-01f, 1.87587608e-02f, 1.02381989e-01f, 1.31641850e-01f,
  -1.29238144e-01f, 1.59734979e-01f, -1.29576549e-01f, -9.05092880e-02f, -3.46455246e-01f, 2.53472805e-01f, 1.08205222e-01f, 8.03235546e-02f, 3.05348098e-01f, 1.56945586e-01f,
  -2.18122751e-01f, -1.25721946e-01f, -1.99265797e-02f, -1.52517304e-01f, 5.85972145e-02f, -1.15372539e-01f, -1.03881620e-01f, 2.25163519e-01f, -1.67399377e-01f, 1.22911178e-01f,
  -5.93957491e-02f, 7.41593987e-02f, 3.88276398e-01f, 6.82183355e-02f, 2.12620169e-01f, 2.38882437e-01f, -9.33772400e-02f, 1.52626589e-01f, -2.28145897e-01f, -2.92933106e-01f,
  1.99149594e-01f, 4.98759449e-02f, -1.83581889e-01f, -1.94308504e-01f, 4.03551221e-01f, 2.42686108e-01f, -7.07147047e-02f, 5.91950864e-02f, 2.89673567e-01f, 3.00813735e-01f,
  -1.60292625e-01f, 2.30671242e-01f, -2.33746693e-01f, 2.21682340e-01f, 2.51160771e-01f, 1.57958224e-01f, 8.90681800e-03f, 8.18436965e-02f, -2.35063761e-01f, 1.88300565e-01f,
  2.97971398e-01f, 3.44859809e-01f, 2.19481423e-01f, 1.68749973e-01f, -3.38957578e-01f, -2.94667155e-01f, -4.17232066e-01f, 8.22152477e-04f, -1.52272955e-01f, -3.34895581e-01f,
  -4.49209183e-01f, 9.40169990e-02f, -5.30232750e-02f, -6.22878820e-02f, -2.58320719e-01f, -3.59507471e-01f, 1.09717362e-01f, -1.26901105e-01f, 1.08596450e-02f, 1.79564565e-01f,
  -1.84233174e-01f, 1.62948132e-01f, -4.79509562e-01f, -5.61258674e-01f, -5.83706610e-02f, -2.13389061e-02f, 3.00649274e-02f, 5.43546397e-04f, 1.01025917e-01f, 1.51729807e-01f,
  7.03831613e-02f, -1.53114453e-01f, 1.41729802e-01f, 7.33391941e-02f, -1.20221898e-01f, 1.36035562e-01f, 9.04837996e-02f, -9.83311310e-02f, -9.18068141e-02f, -6.38461486e-02f,
  2.11282000e-02f, 4.74018380e-02f, -1.11628219e-01f, -2.74844050e-01f, 9.62384790e-02f, -2.11766660e-01f, -1.75988791e-03f, -1.61488384e-01f, 1.76733024e-02f, 6.76171780e-02f,
  2.33446639e-02f, -2.07021460e-01f, 4.03502807e-02f, 8.10363516e-02f, -4.18291129e-02f, 7.58489072e-02f, -5.37837110e-02f, 2.68707797e-02f, -1.80573046e-01f, -6.33587837e-02f,
  -7.40605295e-02f, 5.56144826e-02f, -2.30839476e-01f, -1.96647853e-01f, -2.11936668e-01f, 3.49889100e-02f, 8.94667506e-02f, -4.76633050e-02f, 2.06679106e-01f, -3.71515341e-02f,
  6.76507279e-02f, -1.15916520e-01f, -3.06200124e-02f, 5.79661764e-02f, 8.46132934e-02f, -1.52061701e-01f, -1.55040145e-01f, -2.09900111e-01f, -1.79001361e-01f, -4.88622338e-02f,
  4.66877110e-02f, -3.78348259e-03f, -1.34837046e-01f, -3.77910547e-02f, 2.58760862e-02f, 9.89269689e-02f, 2.09582239e-01f, 2.39171952e-01f, -5.88706695e-02f, 1.77311331e-01f,
  -2.06432045e-01f, 1.37571231e-01f, 1.59476951e-01f, -1.31970525e-01f, -1.97239935e-01f, 1.64477855e-01f, 2.34513313e-01f, -3.16561103e-01f, -1.28966659e-01f, -2.49879956e-01f,
  -9.97177288e-02f, -2.73695439e-01f, 1.30157739e-01f, 1.63271040e-01f, -3.49697173e-02f, -1.73194155e-01f, 1.84624165e-01f, 3.94080818e-01f, -3.93555939e-01f, 8.50367919e-02f,
  1.72639519e-01f, 1.45783663e-01f, -2.34333962e-01f, 3.53345051e-02f, -1.11192815e-01f, 1.52602151e-01f, -2.98623681e-01f, -1.05867691e-01f, 3.26259255e-01f, -1.40489370e-01f,
  2.45718360e-01f, 1.13173167e-03f, 1.96637511e-01f, 2.44625777e-01f, -3.63961428e-01f, 2.16439411e-01f, -1.55513734e-01f, 8.14564805e-03f, -4.49459314e-01f, -3.88915278e-02f,
  6.64499700e-02f, 1.66644827e-01f, -1.49931937e-01f, -3.94906253e-01f, 3.19235176e-01f, 2.68125027e-01f, -3.24728161e-01f, -2.14167163e-01f, -2.71786898e-01f, 2.90979356e-01f,
  1.77132994e-01f, -2.01596648e-01f, -4.98878598e-01f, 1.33876801e-01f, -1.53691163e-02f, -1.40859529e-01f, -2.90413201e-01f, 1.87566727e-01f, -2.88101941e-01f, -6.98154271e-02f,
  -2.46660084e-01f, -2.48398900e-01f, -1.48001805e-01f, -4.08998251e-01f, -2.99838558e-02f, -1.28024459e-01f, 2.84192618e-02f, -2.76441813e-01f, -1.17602959e-01f, -1.12747945e-01f,
  8.70300606e-02f, 5.75322211e-02f, 1.38683096e-01f, 5.34803718e-02f, -1.85671642e-01f, -1.21217623e-01f, -2.26820856e-02f, -2.58942135e-02f, -4.42652330e-02f, -7.33053312e-03f,
  3.67158987e-02f, -1.78817391e-01f, 1.27022760e-02f, -9.86035392e-02f, -4.62023243e-02f, -1.24334075e-01f, -1.02676213e-01f, -1.63250536e-01f, -1.08825348e-01f, 1.06172301e-01f,
  -1.94229171e-01f, -1.71281457e-01f, -1.57720119e-01f, -4.86314110e-02f, -1.49509639e-01f, 1.27899766e-01f, -1.88531503e-01f, -1.59341708e-01f, 2.67728362e-02f, -1.42066758e-02f,
  -2.22405605e-03f, 1.42401144e-01f, 1.30549759e-01f, -2.85636596e-02f, -1.88817177e-02f, 2.46716458e-02f, -4.72729914e-02f, 4.47940305e-02f, 1.04474261e-01f, 1.01906888e-01f,
  -1.01864144e-01f, 1.24028265e-01f, -5.29754423e-02f, 2.36715376e-02f, 6.88274726e-02f, 4.63451855e-02f, 1.00354679e-01f, -2.45102152e-01f, 1.63354911e-02f, 1.93973109e-01f,
  1.34504408e-01f, -1.48198530e-01f, -2.01839164e-01f, -2.03632623e-01f, 1.05313443e-01f, 1.08199805e-01f, 9.35733840e-02f, -2.03164503e-01f, 1.60963818e-01f, -9.47387442e-02f,
  -4.20083553e-02f, 3.00090164e-01f, -9.37951654e-02f, -1.62513211e-01f, 1.30306900e-01f, -1.93161622e-01f, -1.10398509e-01f, 9.99741331e-02f, 3.02069988e-02f, 7.58533850e-02f,
  -1.22425385e-01f, 1.20027727e-02f, -8.89939144e-02f, 9.37807038e-02f, -1.48613811e-01f, 1.66218653e-01f, -6.42561242e-02f, -2.70089418e-01f, 1.99535377e-02f, -2.81836569e-01f,
  -2.74208963e-01f, -2.36667722e-01f, 2.43646815e-01f, -2.08988205e-01f, -1.65106744e-01f, 1.91249773e-01f, -2.05284089e-01f, -2.71016181e-01f, -9.60763246e-02f, -3.90155703e-01f,
  -2.03567088e-01f, 5.09693362e-02f, 3.96212600e-02f, -2.26774007e-01f, -2.09864318e-01f, -9.80660543e-02f, -1.57466680e-01f, -2.57572293e-01f, -5.35834320e-02f, -2.53146086e-02f,
  1.12606987e-01f, 1.55848771e-01f, 1.21594526e-01f, -1.60402432e-01f, 6.26339093e-02f, 2.02008992e-01f, -1.82017848e-01f, -2.91547686e-01f, -1.69535894e-02f, 4.22169119e-02f,
  -2.61530995e-01f, -2.46765688e-01f, -2.91478485e-01f, -3.73670816e-01f, -3.49584758e-01f, -2.19354600e-01f, -1.77450180e-01f, -4.64526892e-01f, 3.04073244e-01f, 2.29165256e-01f,
  1.37314096e-01f, 1.25935495e-01f, 1.88272268e-01f, -1.40464202e-01f, 7.91075677e-02f, 1.34877369e-01f, 2.24003658e-01f, 1.44651979e-01f, 3.44921649e-02f, -2.03852430e-01f,
  -1.50245894e-02f, 3.25276293e-02f, 1.45624369e-01f, 1.31414121e-03f, -4.22067754e-02f, 1.45290241e-01f, 5.35961241e-02f, 6.70620501e-02f, 1.13915853e-01f, -8.83245692e-02f,
  -6.02846220e-02f, 2.88360417e-02f, -6.92124665e-02f, 1.30954906e-01f, 1.73463881e-01f, 1.32243276e-01f, -2.57103499e-02f, 8.51823986e-02f, 2.03130081e-01f, -3.22628058e-02f,
  1.82279497e-01f, 7.32816532e-02f, 3.66808996e-02f, 1.04448117e-01f, 1.44576713e-01f, -7.20989774e-04f, -4.41576317e-02f, 1.79235309e-01f, -3.39531638e-02f, -5.00173196e-02f,
  -1.57688633e-01f, 1.71386227e-01f, 3.97043787e-02f, -7.25327060e-03f, 6.73490018e-02f, 1.17036954e-01f, 1.46353453e-01f, -1.20535508e-01f, -2.13526655e-02f, -3.71822454e-02f,
  1.65093377e-01f, 1.77449033e-01f, -1.42684449e-02f, 1.88817814e-01f, 1.11523278e-01f, 2.96570629e-01f, 2.14326695e-01f, 7.42859393e-02f, 3.76833469e-01f, -2.34136015e-01f,
  3.40681374e-01f, -3.52770537e-02f, 1.67349398e-01f, -3.27043861e-01f, 1.96738064e-01f, -3.20540637e-01f, -3.63458514e-01f, -8.73848498e-02f, 1.00208938e-01f, 2.19928235e-01f,
  2.56877750e-01f, -1.42049924e-01f, 1.97425783e-01f, -1.66506931e-01f, -1.14673398e-01f, -1.17153868e-01f, -3.02197605e-01f, -4.17670816e-01f, 2.14799538e-01f, 1.57536060e-01f,
  -3.07846040e-01f, 1.34306520e-01f, -7.14129731e-02f, -7.05593005e-02f, 1.41716555e-01f, 1.14734873e-01f, 1.84275061e-01f, 2.65349776e-01f, 1.42578319e-01f, -3.19871083e-02f,
  7.12806508e-02f, -1.89951614e-01f, 6.80455565e-02f, 7.37610310e-02f, -3.03472459e-01f, 2.19946206e-01f, -1.57930687e-01f, 1.47362679e-01f, -1.05036870e-01f, -3.83094579e-01f,
  1.23465307e-01f, 3.14531714e-01f, -6.93632513e-02f, -2.33194351e-01f, -1.13970600e-01f, 1.51971281e-01f, -4.41024965e-03f, -2.91167915e-01f, 2.42047027e-01f, 1.95442051e-01f,
  1.11740664e-01f, -1.50505342e-02f, -2.39244342e-01f, -1.55955955e-01f, 1.25579640e-01f, 3.16376500e-02f, 1.99489430e-01f, 8.47455412e-02f, -9.86713395e-02f, 2.55446255e-01f,
  -1.78783596e-01f, 9.31908563e-02f, -4.55138177e-01f, -4.21204180e-01f, -1.99182421e-01f, 2.69945234e-01f, 9.06316116e-02f, -1.07861064e-01f, -4.28782701e-02f, 9.20466408e-02f,
  5.16729839e-02f, 2.15094835e-01f, -8.63498002e-02f, 3.55980359e-02f, -1.32488146e-01f, -8.16771463e-02f, -1.11501664e-02f, -3.97374388e-03f, -1.76381618e-01f, 1.45405054e-01f,
  2.16418490e-01f, -1.10029943e-01f, 1.02693923e-01f, 1.02044642e-01f, -1.64435118e-01f, -3.76342535e-01f, 5.05987275e-03f, 1.54000640e-01f, 1.37759209e-01f, -1.17662668e-01f,
  -1.56440541e-01f, 2.04960749e-01f, 1.87148638e-02f, 9.16111190e-03f, -9.20125097e-02f, -2.55582668e-02f, 4.62940298e-02f, 6.43106550e-02f, 5.37087657e-02f, -1.10398546e-01f,
  -1.31549969e-01f, 2.89838076e-01f, -1.64857000e-01f, -6.47952259e-02f, -1.36624113e-01f, 1.52301088e-01f, -3.24840955e-02f, 1.33754928e-02f, -4.65603806e-02f, -3.48001719e-02f,
  1.13170125e-01f, 4.99813519e-02f, 1.46797478e-01f, -1.47980064e-01f, 2.81377677e-02f, -7.75294080e-02f, 9.42712650e-02f, -1.35281324e-01f, -5.96576817e-02f, 1.27720861e-02f,
  -9.15410146e-02f, -1.51255503e-01f, -2.74226419e-03f, 8.75578523e-02f, -1.30748719e-01f, -2.01362252e-01f, -7.51620904e-02f, 1.75085470e-01f, -3.28375310e-01f, 8.75295550e-02f,
  -2.15086296e-01f, -7.32518286e-02f, -7.34419003e-02f, -1.16844680e-02f, 2.13054538e-01f, -1.54508159e-01f, -9.45543572e-02f, -3.31211612e-02f, 5.21111898e-02f, -2.73590297e-01f,
  -2.68958509e-01f, 2.31951073e-01f, 3.48782428e-02f, -1.61463290e-01f, 2.25008473e-01f, 2.65305609e-01f, -1.08361892e-01f, 3.86459343e-02f, 7.53223076e-02f, -4.62134480e-02f,
  -2.14991927e-01f, -1.79137141e-01f, -1.32721186e-01f, 6.96159154e-03f, -2.58222640e-01f, 9.64324996e-02f, 5.66359498e-02f, -3.45423520e-01f, 2.57235169e-01f, -5.58483042e-02f,
  2.03811020e-01f, -3.00969899e-01f, -8.95441622e-02f, 1.68947905e-01f, -2.07474425e-01f, -3.33140194e-01f, -2.38781363e-01f, 1.94855586e-01f, 7.94058666e-02f, 1.90224096e-01f,
  3.07652533e-01f, 7.11545274e-02f, 2.41129860e-01f, 7.43537545e-02f, -3.62122543e-02f, -1.34360474e-02f, -1.08360693e-01f, 1.73603937e-01f, -4.52035576e-01f, -1.52149513e-01f,
  2.64305174e-01f, 2.34594017e-01f, 2.03882366e-01f, 1.25735760e-01f, 2.12357175e-02f, 1.93499327e-01f, 1.75282247e-02f, -3.28453541e-01f, -8.44401249e-04f, 1.12097181e-01f,
  1.32994980e-01f, -3.42795849e-02f, 1.36384100e-01f, 6.37342408e-02f, 5.20708635e-02f, -1.72880739e-02f, 9.24066976e-02f, -2.02553540e-01f, -3.13102528e-02f, 6.84267357e-02f,
  -8.34076554e-02f, -5.80860022e-03f, -1.49779692e-01f, -1.05656348e-01f, -1.70318127e-01f, -7.52222314e-02f, -1.02425538e-01f, -1.35524064e-01f, 2.74432041e-02f, 5.86207621e-02f,
  -7.13158697e-02f, -1.30970404e-01f, 1.91555128e-01f, -1.26969263e-01f, -5.90580478e-02f, -3.13634500e-02f, -1.59906492e-01f, 6.57123188e-03f, 1.09576464e-01f, 7.73691237e-02f,
  -5.69069991e-03f, -1.40292391e-01f, 6.22844845e-02f, -4.87215444e-02f, -9.96061489e-02f, -8.69776756e-02f, -5.47019541e-02f, -4.85994332e-02f, 4.29056212e-02f, -3.39237988e-01f,
  1.63864151e-01f, 3.57378982e-02f, -3.74151580e-02f, 1.00012995e-01f, 2.01284140e-01f, 2.91273482e-02f, 1.16641797e-01f, -5.10506914e-04f, -2.26021424e-01f, -6.31875023e-02f,
  -7.08812848e-02f, 1.54113382e-01f, 4.00106795e-02f, 1.20523900e-01f, -1.79681361e-01f, -2.57154200e-02f, -1.27001077e-01f, 1.28408536e-01f, -9.30190235e-02f, -2.00102761e-01f,
  5.27851246e-02f, 1.45384997e-01f, -4.57748212e-02f, 1.51158705e-01f, -5.68023175e-02f, 1.72940686e-01f, -1.77879930e-01f, 1.07362293e-01f, -1.05503477e-01f, 2.67685056e-01f,
  -1.82911560e-01f, 2.00133562e-01f, -2.78267473e-01f, -1.73240304e-01f, -1.98701456e-01f, -1.22307695e-01f, -2.14241505e-01f, -1.61505073e-01f, 1.99114650e-01f, -3.33859056e-01f,
  1.11091390e-01f, -3.20652813e-01f, 1.74974790e-03f, -2.22051814e-01f, 1.43909842e-01f, -2.80173928e-01f, -7.09686801e-02f, 7.49001279e-02f, 1.74122229e-01f, -5.83380610e-02f,
  2.03978475e-02f, -1.11613587e-01f, -5.26398234e-02f, 9.92981344e-02f, 9.72533301e-02f, -8.19269121e-02f, -1.18589535e-01f, 2.95388371e-01f, 1.36180446e-01f, -8.02582875e-03f,
  1.52701929e-01f, -4.37770575e-01f, -1.60546392e-01f, -1.80234551e-01f, -8.89305696e-02f, 1.07005991e-01f, 2.33049765e-01f, 1.09661654e-01f, 7.24809989e-02f, 1.69586033e-01f,
  -2.47498587e-01f, 1.00518512e-02f, -3.18584651e-01f, -4.46504831e-01f, 3.26831192e-01f, -3.94342035e-01f, 1.18718468e-01f, 1.80348277e-01f, 5.41097879e-01f, -3.66734445e-01f,
  2.60243705e-03f, 1.40956044e-01f, -3.82676184e-01f, 3.27155106e-02f, 1.06263869e-01f, 6.82283267e-02f, -2.03924432e-01f, 9.71386582e-02f, 2.34420568e-01f, 2.50815153e-01f,
  -4.11038876e-01f, 3.96316359e-03f, -9.94911715e-02f, 1.51327819e-01f, -3.68855685e-01f, -1.97569340e-01f, 5.21546490e-02f, -2.60666534e-02f, 1.33397445e-01f, -2.14385524e-01f,
  5.61947823e-02f, -9.07685012e-02f, 4.30350043e-02f, 3.99874225e-02f, 6.03048876e-02f, 2.84764171e-02f, 6.56907856e-02f, -7.65343606e-02f, 4.06104140e-02f, -8.02324787e-02f,
  1.09661603e-02f, -3.51876877e-02f, -5.32872900e-02f, 2.10642844e-01f, 8.58899057e-02f, 1.08800508e-01f, 4.88566346e-02f, 3.84829827e-02f, 4.46299352e-02f, 2.72825416e-02f,
  9.24465992e-03f, -1.25370175e-01f, -1.45178959e-02f, 6.17639050e-02f, 8.24518576e-02f, 8.52968395e-02f, 2.50939988e-02f, -6.28710315e-02f, 9.40302238e-02f, -5.97654805e-02f,
  2.76426319e-02f, -2.33244691e-02f, -1.51088769e-02f, -1.31648511e-01f, 9.80440825e-02f, -1.33919850e-01f, 5.57542145e-02f, 2.58642137e-02f, -3.98625918e-02f, -4.37010936e-02f,
  -5.73127307e-02f, -9.62215587e-02f, -7.39409253e-02f, -5.00524417e-02f, -7.49814883e-02f, -3.22997235e-02f, -4.44495082e-02f, 7.06324577e-02f, -3.92772527e-05f, -1.46085486e-01f,
  7.03655779e-02f, 1.24469876e-01f, 1.63797647e-01f, -1.61824562e-02f, -1.36029541e-01f, -2.41285171e-02f, 5.37138693e-02f, -1.36244714e-01f, 3.80683392e-02f, 2.83285230e-01f,
  2.94772208e-01f, 2.88799644e-01f, -4.52211723e-02f, 1.13223210e-01f, -1.40517026e-01f, 2.93525984e-03f, -1.44102901e-01f, -7.25030452e-02f, -6.15525171e-02f, 4.91869189e-02f,
  -1.65508449e-01f, 6.47775233e-02f, -1.39974058e-01f, -8.18514898e-02f, 2.23650798e-01f, -2.62075961e-01f, -1.19828649e-01f, 8.17123204e-02f, -1.45391405e-01f, -2.35100657e-01f,
  1.35393620e-01f, 1.11263998e-01f, 2.01279715e-01f, -1.45836934e-01f, 1.85296796e-02f, 2.91869432e-01f, -7.25759789e-02f, 1.32098451e-01f, 1.40065745e-01f, -4.87390980e-02f,
  -3.36494595e-02f, -1.96197778e-01f, -5.88308200e-02f, -1.31472394e-01f, -2.21422032e-01f, -2.24563584e-01f, 1.45499840e-01f, -5.93815893e-02f, -1.41784519e-01f, -1.03761397e-01f,
  -1.10431977e-01f, -2.02439740e-01f, 2.33989269e-01f, -1.60028022e-02f, -3.11717212e-01f, -1.91705629e-01f, -1.41562882e-03f, -4.06637155e-02f, 1.85908824e-01f, -7.74824247e-02f,
  -5.44118941e-01f, -3.80949706e-01f, 3.11709940e-01f, 3.71480048e-01f, 1.07048549e-01f, -2.88907349e-01f, 1.44974306e-01f, -2.05615759e-01f, 3.85912299e-01f, -3.68281364e-01f,
  1.67138278e-01f, 1.52975902e-01f, 1.79827318e-01f, -4.90052074e-01f, -3.53485644e-02f, 1.09562529e-02f, -1.03779063e-02f, 9.89688113e-02f, 9.45335627e-02f, -7.07619190e-02f,
  -7.40727335e-02f, -7.02350140e-02f, 1.04036607e-01f, -1.37008399e-01f, -7.92160854e-02f, -1.36246011e-01f, -6.69193566e-02f, -1.06866723e-02f, -3.02201286e-02f, -3.65232490e-02f,
  7.64348879e-02f, 1.18911758e-01f, -7.04488531e-02f, -7.37021565e-02f, -1.38946265e-01f, 2.01381613e-02f, 7.41416514e-02f, 8.13915208e-02f, -1.31170824e-01f, 4.95546125e-02f,
  -5.52920029e-02f, -1.73929214e-01f, -1.59878563e-02f, -2.26204202e-01f, 1.47584546e-03f, -8.42299871e-03f, -1.61171809e-01f, -1.60423592e-02f, -4.54309359e-02f, -5.71330190e-02f,
  7.29969963e-02f, 1.27634238e-02f, 9.28307232e-03f, -1.34988651e-01f, -6.26928806e-02f, 4.03326787e-02f, 6.99998066e-02f, -1.57735080e-01f, -1.22240975e-01f, 8.32935646e-02f,
  -2.85960827e-03f, -3.77514102e-02f, 5.11922911e-02f, -1.38662115e-01f, -1.46649346e-01f, 1.51589900e-01f, -1.15460843e-01f, -2.11797565e-01f, -7.30848983e-02f, 2.32288286e-01f,
  -1.15389921e-01f, -1.02083638e-01f, 2.30587453e-01f, -5.86063117e-02f, -1.60231039e-01f, -2.25193769e-01f, -4.24827859e-02f, 1.64150402e-01f, 8.48974064e-02f, 2.40499362e-01f,
  7.04488456e-02f, -5.89862913e-02f, -2.01257020e-01f, 4.76768203e-02f, 8.05281028e-02f, 1.97046518e-01f, 5.86254671e-02f, -1.10726133e-02f, 1.66732758e-01f, 8.59509129e-03f,
  -1.48844585e-01f, -1.71136022e-01f, -1.59221888e-02f, -9.00651049e-03f, 2.84816623e-01f, -7.37924576e-02f, 2.15168953e-01f, 1.56174719e-01f, 1.15075327e-01f, 1.09186463e-01f,
  -1.88869491e-01f, 5.38165085e-02f, -8.62533227e-02f, 1.33154213e-01f, -1.99583203e-01f, -1.03611946e-01f, -3.04525971e-01f, -2.66500562e-01f, 1.79632798e-01f, 1.34772211e-01f,
  7.87092187e-03f, -1.63123980e-01f, -2.13783950e-01f, -3.05200130e-01f, -4.18271348e-02f, 7.16990083e-02f, 7.03269094e-02f, 1.92600228e-02f, 3.03909272e-01f, 1.67786270e-01f,
  -3.24632466e-01f, -3.04157823e-01f, -2.78467000e-01f, -2.59167731e-01f, -1.39753520e-01f, -3.50726508e-02f, -2.55102873e-01f, -6.07681088e-02f, -1.84996128e-01f, -3.18033159e-01f,
  -3.66960704e-01f, 2.14018032e-01f, -2.89101720e-01f, -2.67143130e-01f, 2.09781528e-01f, 9.89733934e-02f, 2.00770438e-01f, 2.83062190e-01f, 4.65756327e-01f, 2.95950532e-01f,
  -3.89018327e-01f, 1.95697159e-01f, -1.50564909e-01f, 8.32342356e-02f, -1.87960565e-01f, 1.08249880e-01f, 2.58836467e-02f, 1.27846450e-01f, 1.59584001e-01f, 1.30552053e-01f,
  1.90996507e-03f, 2.03992687e-02f, -2.94886008e-02f, 4.13430482e-02f, 1.65077597e-02f, 2.76637841e-02f, -1.30171776e-01f, 9.48695168e-02f, 1.39657423e-01f, 7.14942142e-02f,
  -1.19001880e-01f, 6.73409253e-02f, 7.69617632e-02f, 7.85861388e-02f, 5.68138398e-02f, -1.14125982e-01f, -1.30748540e-01f, 6.66573569e-02f, 1.60275981e-01f, 2.06146687e-01f,
  -1.05223417e-01f, 4.71160598e-02f, -4.81592445e-03f, 6.15377799e-02f, -1.63770035e-01f, 1.19149111e-01f, -1.74950302e-01f, -1.42018750e-01f, 7.23195374e-02f, 5.27582355e-02f,
  4.19497751e-02f, 7.50231072e-02f, -1.80861637e-01f, 9.88179669e-02f, 2.85360850e-02f, 1.07581437e-01f, -7.42262416e-03f, 3.15889642e-02f, 1.90013379e-01f, 7.98293874e-02f,
  -8.67335647e-02f, 9.40272864e-03f, 4.10220325e-02f, -2.45718226e-01f, 2.05624089e-01f, 8.55957996e-03f, 2.11633798e-02f, -3.08814526e-01f, -2.67705023e-01f, -2.29872018e-01f,
  2.72624791e-01f, -1.33580402e-01f, -2.53995508e-01f, 2.48260438e-01f, 2.43979782e-01f, 1.84441477e-01f, -1.76824123e-01f, 3.65527570e-01f, 3.79058421e-02f, 9.35364068e-02f,
  -1.66958317e-01f, -2.22127587e-01f, -3.61878067e-01f, 6.46254718e-02f, 1.31713733e-01f, 2.71530241e-01f, 2.39053637e-01f, -1.72699884e-01f, -4.63267714e-02f, 1.56283736e-01f,
  2.79432178e-01f, -1.52525395e-01f, 2.17923120e-01f, 4.31698747e-02f, -2.31772289e-01f, 1.82961762e-01f, 1.10194229e-01f, -5.81436604e-03f, 2.07426414e-01f, 3.17230135e-01f,
  1.84487537e-01f, -1.12537071e-01f, 1.68391049e-01f, -2.08417162e-01f, 2.27070004e-01f, 3.06759387e-01f, 1.31827816e-01f, 1.90160260e-01f, -1.85037419e-01f, 1.55602485e-01f,
  -9.69633684e-02f, 1.79789364e-01f, 2.89791167e-01f, -2.02290744e-01f, -3.01025689e-01f, -2.95671850e-01f, -4.32090253e-01f, -4.32853818e-01f, -3.78088243e-02f, -1.56417355e-01f,
  1.34875491e-01f, 7.14333728e-02f, -3.73219579e-01f, -2.87519276e-01f, 9.94872004e-02f, 1.07769810e-01f, 2.20581397e-01f, -1.03550754e-01f, 3.37252438e-01f, 1.85992479e-01f,
  1.93372041e-01f, 2.89374977e-01f, 1.18437022e-01f, -4.10191357e-01f, 3.64667863e-01f, -1.54746652e-01f, -3.87862325e-01f, -3.88450354e-01f, -2.59746373e-01f, -3.14626336e-01f,
  -1.18479304e-01f, 1.13046087e-01f, 5.85029311e-02f, -9.73039344e-02f, -3.13062482e-02f, 1.74600601e-01f, -4.21864279e-02f, 9.66412425e-02f, -1.11252747e-01f, 3.10728960e-02f,
  -7.31315976e-03f, 1.78387642e-01f, 6.02435647e-03f, -6.82954416e-02f, 7.65840262e-02f, -8.49767309e-03f, -3.08099650e-02f, 2.95341481e-02f, 5.08941263e-02f, 1.30195413e-02f,
  1.06560931e-01f, -1.12938352e-01f, -5.95087782e-02f, -7.96436518e-02f, 1.67924669e-02f, -1.65491961e-02f, -1.44339845e-01f, -1.55219719e-01f, 4.89347950e-02f, 5.18599078e-02f,
  -2.43346393e-03f, -2.29545198e-02f, -1.37484580e-01f, -9.95001867e-02f, 1.39363073e-02f, 1.14924321e-02f, 6.52694777e-02f, -1.83027405e-02f, 3.43518853e-02f, 1.10314272e-01f,
  3.29213380e-03f, 6.26984686e-02f, 1.12520047e-01f, 1.23668440e-01f, -1.73972566e-02f, 6.37241676e-02f, -5.08813225e-02f, 2.45747734e-02f, -2.19498388e-02f, -7.81162530e-02f,
  1.12249022e-02f, 9.90129784e-02f, 5.05853407e-02f, -2.14404210e-01f, 1.94416225e-01f, 1.93410322e-01f, 2.28246540e-01f, 1.82243288e-01f, -1.52028963e-01f, 1.95283011e-01f,
  -1.93331331e-01f, -1.76975563e-01f, 3.67495902e-02f, 2.26541728e-01f, 2.19807461e-01f, -1.29570857e-01f, -2.34179273e-02f, -2.28515878e-01f, 2.59843379e-01f, 1.70587555e-01f,
  6.98254630e-02f, 2.15725973e-01f, 3.47041748e-02f, 1.27381697e-01f, -2.80643165e-01f, 1.41800106e-01f, 9.87207741e-02f, -1.18817598e-01f, 8.29960555e-02f, 1.96879253e-01f,
  -1.31456062e-01f, 5.29979691e-02f, 2.03844339e-01f, -2.97770977e-01f, 1.51461646e-01f, -2.32809156e-01f, -1.23359002e-01f, 1.23528317e-01f, -2.32278883e-01f, 2.27834344e-01f,
  1.72281206e-01f, 5.64435348e-02f, 7.93851539e-02f, 1.55980185e-01f, -1.47241563e-01f, 2.31453374e-01f, 2.85735846e-01f, -2.24904358e-01f, 1.21546991e-01f, -2.10899383e-01f,
  -9.40087959e-02f, 2.20470205e-01f, -3.45184132e-02f, -1.48414180e-01f, -1.39812157e-01f, 1.17910020e-01f, -2.57163584e-01f, 1.29121423e-01f, 2.39196002e-01f, 1.94929391e-01f,
  -1.39413208e-01f, 1.80552661e-01f, -2.61042982e-01f, -2.60576516e-01f, -2.37668250e-02f, 1.89490557e-01f, -1.25659583e-02f, -2.80442864e-01f, 3.71328384e-01f, -2.57088304e-01f,
  -2.09081158e-01f, -7.03740194e-02f, -1.57001838e-01f, -3.01118642e-01f, -2.75386214e-01f, -2.53463745e-01f, -2.39234399e-02f, 2.50732571e-01f, -8.27428326e-03f, -1.69766560e-01f,
  4.51193824e-02f, 9.02145132e-02f, 8.19411576e-02f, -1.34844482e-01f, -1.64491847e-01f, 3.22427005e-02f, 2.63290126e-02f, -1.51558250e-01f, 8.44037347e-03f, -2.63206996e-02f,
  1.02657750e-01f, 3.62312347e-02f, -1.00704245e-01f, -1.46216318e-01f, -3.21961790e-02f, 6.52667508e-02f, 7.06848176e-03f, -6.22232892e-02f, -7.89691731e-02f, 3.88066843e-02f,
  -3.24319154e-02f, 5.42872883e-02f, 7.38843083e-02f, -1.96343358e-03f, -1.11836113e-01f, -1.64587691e-01f, 1.57653894e-02f, 3.06099094e-02f, 5.91583848e-02f, -9.83850583e-02f,
  1.31942645e-01f, -1.96365570e-03f, 5.92335500e-02f, -1.24315105e-01f, -4.71578762e-02f, 6.68724924e-02f, -6.58049807e-02f, 4.51805741e-02f, -1.66496232e-01f, -9.04086903e-02f,
  -9.64286178e-02f, -5.97802736e-02f, 1.59647521e-02f, 2.27520876e-02f, 1.70229837e-01f, 6.33063242e-02f, 8.06838870e-02f, 4.81963269e-02f, 1.03297636e-01f, 2.34030619e-01f,
  1.36610746e-01f, -9.14695114e-02f, 8.40916708e-02f, -9.62017477e-02f, -2.52987623e-01f, 1.70968860e-01f, -1.52323276e-01f, 1.09005449e-02f, 6.87907124e-03f, -1.89045891e-01f,
  -1.28385484e-01f, -2.69569039e-01f, 1.59785077e-01f, -2.37510055e-01f, 5.41644497e-03f, -1.33468419e-01f, 2.34755024e-01f, -1.62791818e-01f, 1.67222291e-01f, 3.11436921e-01f,
  2.11575955e-01f, 1.98682427e-01f, 1.45777971e-01f, -7.33622611e-02f, -2.12479338e-01f, -1.67004801e-02f, -1.39458012e-02f, -1.38565078e-01f, 2.80937433e-01f, -1.34665966e-01f,
  -7.60492682e-02f, 7.91403651e-02f, -3.74587148e-01f, -2.35423833e-01f, -1.70023009e-01f, -3.30028050e-02f, 9.10981148e-02f, -3.01992059e-01f, -6.37424411e-03f, -1.11001357e-01f,
  2.32482627e-01f, -1.13164090e-01f, 1.97264105e-01f, 1.40478447e-01f, -1.52050510e-01f, 4.97301221e-02f, 3.99955437e-02f, -2.35505685e-01f, -1.04634590e-01f, -1.63949467e-02f,
  -3.35686773e-01f, -8.16705152e-02f, -3.10446590e-01f, -1.89860255e-01f, -2.69457579e-01f, -2.25842148e-01f, 1.61270961e-01f, 5.63686192e-02f, -2.97013611e-01f, 1.22061029e-01f,
  2.36256137e-01f, -4.88620698e-01f, -3.56772214e-01f, 2.59327739e-01f, 2.00924560e-01f, -3.73721033e-01f, -2.92911232e-01f, 1.36277512e-01f, 2.92616457e-01f, -6.69304421e-03f,
  -3.53106880e-03f, -2.05178186e-01f, 2.03198776e-01f, 3.29235494e-01f, -3.63360375e-01f, 5.08847199e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.68686479e-02f, 6.35710284e-02f, 4.43642512e-02f, 1.09052705e-02f, 7.40074366e-03f, -1.79857071e-02f, -2.31188498e-02f, 4.94613573e-02f, -2.77119111e-02f, -5.44839986e-02f,
  8.49742666e-02f, -9.66996606e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    