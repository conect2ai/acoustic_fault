/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.75616550e-02f, -3.09293028e-02f, -2.89559960e-01f, 1.43626453e-02f, -1.11049949e-03f, 1.87154617e-02f, 8.36788490e-02f, 1.19101830e-01f, 7.00714625e-03f, -4.74782661e-02f,
  -2.82222237e-02f, 8.52745995e-02f, 1.01748280e-01f, 7.13620111e-02f, -6.75129471e-03f, -9.71950293e-02f, -5.53685687e-02f, -9.19240043e-02f, 1.41554162e-01f, 1.44247830e-01f,
  5.82171753e-02f, 4.86857630e-02f, 1.76189225e-02f, 5.68076856e-02f, -2.71227327e-03f, 1.92551330e-01f, -1.15760371e-01f, -6.46733716e-02f, -1.63401559e-01f, -2.68036693e-01f,
  -1.59814104e-01f, -2.33231246e-01f, -2.32866220e-02f, -4.84146960e-02f, -2.93010604e-02f, 1.23263784e-02f, 9.65651684e-03f, -1.30609393e-01f, -8.11986178e-02f, -2.46198066e-02f,
  -1.35974199e-01f, -4.42108065e-02f, -3.03269140e-02f, -2.03286298e-03f, -1.24888504e-02f, -3.50445881e-02f, -1.06457390e-01f, -5.13741001e-02f, -6.16780035e-02f, -7.46973837e-03f,
  -2.30776314e-02f, -1.20814569e-01f, -5.15126437e-02f, 6.99943826e-02f, 7.23385159e-03f, -5.02612777e-02f, -1.36893973e-01f, -8.10328498e-02f, -2.22180989e-02f, -9.77975354e-02f,
  1.07660003e-01f, 5.42453630e-03f, 9.60514992e-02f, 1.73235312e-02f, 9.04183909e-02f, 6.12532571e-02f, 1.87440813e-02f, 1.86706688e-02f, 5.39990216e-02f, 1.21467456e-01f,
  9.96266827e-02f, -7.16782315e-03f, 9.54860598e-02f, -2.07653008e-02f, 2.57719364e-02f, 1.61519498e-02f, -7.25468015e-03f, 2.32026353e-02f, 1.25295687e-02f, -2.16141087e-03f,
  2.21263412e-02f, -1.88310500e-02f, 1.95740009e-04f, 4.80914749e-02f, -4.55535129e-02f, -8.89189467e-02f, -9.99518409e-02f, -4.96081039e-02f, 1.64599866e-02f, -7.44380951e-02f,
  2.74780631e-01f, -9.88080502e-02f, -3.92223820e-02f, -8.13605413e-02f, -9.16903615e-02f, -9.67448503e-02f, -9.66905355e-02f, -8.14832672e-02f, -8.99390951e-02f, 3.78273726e-02f,
  -6.01376817e-02f, -5.08123748e-02f, -2.68222615e-02f, -5.35952151e-02f, -2.02466920e-03f, -3.57133560e-02f, -7.83732980e-02f, -6.62014335e-02f, -4.57725488e-02f, -3.07293851e-02f,
  -1.20820478e-01f, 2.57195570e-02f, 3.12297009e-02f, -4.18092543e-03f, 4.10608836e-02f, -4.16403413e-02f, 5.86820729e-02f, 7.91812465e-02f, 1.02381982e-01f, 2.03589648e-01f,
  4.40892428e-01f, -1.33153368e-02f, -3.62450331e-02f, 1.36646912e-01f, -3.43226418e-02f, 1.09531090e-01f, 9.66202468e-02f, 3.51784267e-02f, -2.50725634e-02f, -1.28829509e-01f,
  -8.01276714e-02f, -1.28129739e-02f, -2.26794872e-02f, -1.00632035e-03f, 2.34459609e-01f, 1.28880039e-01f, 1.48563251e-01f, 1.49038374e-01f, 2.52185374e-01f, 1.19726770e-01f,
  -2.79998966e-02f, -3.86640429e-02f, -6.11655153e-02f, 4.04753126e-02f, -5.62162884e-02f, -3.48580629e-02f, -4.49322499e-02f, -1.35857701e-01f, -8.06723461e-02f, -3.12603265e-02f,
  -5.95294237e-02f, 6.94947615e-02f, 8.52063969e-02f, 1.99230500e-02f, -6.26314059e-02f, 7.96694458e-02f, 3.65255214e-02f, -1.35947661e-02f, -5.50749265e-02f, 3.61822136e-02f,
  -1.91899352e-02f, -1.15873832e-02f, -1.11517319e-02f, 1.52835259e-02f, -8.91922880e-03f, -2.63819247e-02f, -7.87108988e-02f, 8.71104449e-02f, 2.33295420e-03f, 3.37284133e-02f,
  -6.12741522e-02f, -1.49359135e-02f, 1.36137024e-01f, 4.92633246e-02f, 7.49691948e-02f, 1.12242952e-01f, 4.91851717e-02f, 9.22469571e-02f, 1.09139914e-02f, -3.21646407e-02f,
  4.04056534e-03f, -1.02188000e-02f, -1.91154592e-02f, -8.84093493e-02f, 1.46457534e-02f, -9.79828686e-02f, 3.08478940e-02f, -3.51717626e-03f, 2.58775465e-02f, -5.60652912e-02f,
  2.06326712e-02f, 7.59889036e-02f, 7.83915073e-02f, 5.09492531e-02f, -9.33129042e-02f, -4.07228200e-03f, 7.90968165e-02f, 2.13488527e-02f, 1.12900110e-02f, 8.73398408e-03f,
  3.47893797e-02f, 1.68501195e-02f, -2.87303086e-02f, 1.81209911e-02f, 9.10099447e-02f, 8.91597047e-02f, 2.48299725e-02f, -3.91025692e-02f, -4.62164320e-02f, 6.36580586e-02f,
  -1.03917986e-01f, 7.43979067e-02f, 3.75873931e-02f, 3.12905945e-02f, -5.45363128e-02f, 3.50359976e-02f, 3.01676011e-03f, -4.40944955e-02f, -4.81514856e-02f, -4.80648242e-02f,
  5.52050993e-02f, -4.98671979e-02f, -3.56517509e-02f, -3.03976554e-02f, -3.61813903e-02f, -6.74608201e-02f, 1.28660807e-02f, 2.16734665e-03f, 6.70747459e-02f, 4.14942726e-02f,
  2.24104431e-02f, 1.25089228e-01f, 9.30796713e-02f, 2.45806314e-02f, -2.53540780e-02f, 9.37075540e-02f, -7.39578307e-02f, -1.62943508e-02f, 6.05638027e-02f, -5.00709750e-02f,
  4.84128445e-01f, -2.20071584e-01f, -3.78684439e-02f, 1.75738707e-01f, -2.68669780e-02f, -4.43983823e-02f, -8.43884125e-02f, 4.67199311e-02f, 1.00970790e-01f, -1.32406950e-01f,
  -8.32171589e-02f, -1.06558412e-01f, -2.85360031e-03f, 4.54531014e-02f, 1.33023530e-01f, -1.47422001e-01f, -1.44379199e-01f, 1.27062738e-01f, 2.77309388e-01f, 8.71929750e-02f,
  -1.07549518e-01f, 7.52083734e-02f, 2.51288354e-01f, 1.76711977e-01f, -1.71745509e-01f, 9.23370942e-02f, -1.88132718e-01f, -2.54798029e-02f, -9.97750536e-02f, -3.37115049e-01f,
  -1.05780244e-01f, 1.43007353e-01f, 7.77524486e-02f, 2.71019675e-02f, -8.24925676e-02f, 1.72795355e-02f, -4.25360315e-02f, 6.85764626e-02f, 6.08054958e-02f, 1.55602572e-02f,
  -2.34972276e-02f, -1.22416802e-02f, 3.02588176e-02f, 4.74945232e-02f, -9.60089732e-03f, 3.27209085e-02f, 6.38170615e-02f, 9.52221379e-02f, 1.21527076e-01f, -6.77931309e-02f,
  -4.68121916e-02f, 3.95540558e-02f, -1.78829227e-02f, 2.29226481e-02f, 3.57913785e-02f, 1.65319815e-01f, 8.18104204e-03f, 1.16694890e-01f, 1.35001123e-01f, -1.61266223e-01f,
  1.56212952e-02f, -9.99266729e-02f, -3.84121165e-02f, 3.36629245e-03f, -7.25006461e-02f, -9.82234925e-02f, -2.04884261e-02f, -1.36017337e-01f, -9.69655365e-02f, 6.90352498e-03f,
  -1.10734475e-03f, -1.15369827e-01f, -6.49245530e-02f, 1.73039176e-02f, -1.12736642e-01f, -3.18099782e-02f, -7.04878345e-02f, 5.72363986e-03f, -5.19344695e-02f, 7.79422522e-02f,
  4.67192493e-02f, -5.91742285e-02f, -3.16373352e-03f, 2.71515502e-03f, 4.86233830e-02f, 4.92535345e-02f, -1.66846942e-02f, -2.39325464e-02f, -1.10993579e-01f, -9.44070704e-03f,
  -1.01079278e-01f, 1.83654964e-01f, -4.65518758e-02f, -2.82465364e-03f, 6.98985606e-02f, 2.43152995e-02f, 7.14406222e-02f, 5.47253527e-02f, -2.63467282e-02f, -4.32583392e-02f,
  1.04317859e-01f, 7.88636878e-02f, 8.18662122e-02f, 3.86461755e-03f, 1.22578502e-01f, 7.93627128e-02f, -2.53518787e-03f, 6.24314807e-02f, 6.80393651e-02f, -4.93225269e-02f,
  5.61334267e-02f, -5.12370914e-02f, 9.12994072e-02f, 1.69206858e-02f, -3.71584222e-02f, 1.10681839e-01f, -3.77868749e-02f, 5.79497814e-02f, 9.91231799e-02f, -6.80014640e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.21487577e-02f, -1.84247658e-01f, 2.49512866e-01f, 6.13310821e-02f, -1.53379977e-01f, -3.20910096e-01f, -5.73019922e-01f, -3.08967948e-01f, -1.15778260e-01f, -1.44627988e-02f,
  -3.09638172e-01f, -7.64949098e-02f, -1.27855614e-02f, 1.13455886e-02f, 2.58457009e-02f, 4.74129170e-02f, 2.80994147e-01f, 3.31696779e-01f, -7.31519312e-02f, -1.96397588e-01f,
  -2.11195601e-03f, 1.14465930e-01f, 1.04050331e-01f, -6.24399893e-02f, 1.31257847e-01f, 6.82876864e-03f, 1.47771820e-01f, 3.30726981e-01f, 1.63454667e-01f, 3.89933139e-01f,
  1.93205684e-01f, 1.94531083e-02f, -4.73595820e-02f, 4.82237339e-03f, 1.24045581e-01f, 1.72899701e-02f, 1.19913789e-03f, 1.88430145e-01f, -2.04465003e-03f, -8.87523293e-02f,
  5.90507835e-02f, -6.61412477e-02f, -1.28890052e-01f, 5.20673506e-02f, -1.64433122e-01f, -1.36057392e-01f, -2.02040877e-02f, -3.45576764e-03f, 1.10645339e-01f, -1.43611103e-01f,
  -1.19855896e-01f, -2.05503359e-01f, -1.22222163e-01f, -2.17578351e-01f, -4.16481160e-02f, 6.17033094e-02f, -1.02652133e-01f, 1.04910903e-01f, 5.44613898e-02f, 8.46116617e-02f,
  8.90383273e-02f, 1.56703800e-01f, 4.80370894e-02f, 1.44257039e-01f, -2.01192759e-02f, -6.74230233e-02f, 3.80052179e-02f, -3.52747813e-02f, 4.50494066e-02f, 4.41522785e-02f,
  1.58745237e-02f, -1.49912564e-02f, -3.06789521e-02f, 1.04207814e-01f, 1.80004895e-01f, 7.85321444e-02f, 7.55762383e-02f, -4.98677045e-03f, -4.04607989e-02f, 1.11122034e-01f,
  4.73149680e-02f, -4.46180701e-02f, 7.24192411e-02f, -7.50494190e-03f, 5.96214607e-02f, 9.33694914e-02f, 3.33342105e-02f, -1.28227677e-02f, 1.14204414e-01f, 5.71895353e-02f,
  -2.94333816e-01f, 6.87077595e-03f, 1.60409734e-01f, -1.43522369e-02f, 2.39625424e-01f, 1.10692784e-01f, 1.62263468e-01f, -7.93714896e-02f, 1.15511000e-01f, -1.80337369e-01f,
  -4.22698893e-02f, -6.45531528e-03f, -5.90260103e-02f, 1.42437071e-02f, -1.24923214e-01f, -9.77773685e-03f, -6.52450044e-03f, -1.46056600e-02f, 2.05263626e-02f, -8.16382617e-02f,
  -9.96858552e-02f, -2.20286041e-01f, -3.37872803e-01f, -3.13159287e-01f, 5.16310968e-02f, -1.10131346e-01f, -8.72486234e-02f, -3.10201012e-02f, -5.82487732e-02f, -2.04437196e-01f,
  -1.39838606e-01f, -2.71436661e-01f, 2.49459684e-01f, 1.69004053e-01f, 9.96302441e-02f, -3.63857955e-01f, -6.07296050e-01f, -4.53494221e-01f, -6.54635653e-02f, -1.25478461e-01f,
  -9.28946063e-02f, 3.06747202e-02f, 9.04527009e-02f, 1.36135176e-01f, -3.08739282e-02f, 8.79420787e-02f, 3.42980951e-01f, 5.11157393e-01f, 1.60106987e-01f, -3.00525054e-02f,
  5.70420511e-02f, 3.13261181e-01f, 2.93811947e-01f, 1.06272146e-01f, -5.34291286e-03f, -1.66206490e-02f, 7.70468712e-02f, 2.80525178e-01f, 1.11271530e-01f, 4.74697977e-01f,
  2.05241647e-02f, -2.75658011e-01f, 1.15412876e-01f, 1.49851916e-02f, 9.27305147e-02f, -1.24206759e-01f, -9.47209969e-02f, 4.14334424e-02f, -4.60944250e-02f, -1.16292916e-01f,
  1.39006138e-01f, -1.14643447e-01f, 8.82848948e-02f, 5.52507937e-02f, 1.57400742e-02f, -4.69867587e-02f, 3.18625905e-02f, 2.19267249e-01f, -1.37913395e-02f, -2.10653886e-01f,
  1.11991912e-01f, 1.95330366e-01f, -2.41732281e-02f, -6.44098818e-02f, -1.27495885e-01f, 4.29445319e-03f, -1.05860040e-01f, -1.45165041e-01f, -1.98383763e-01f, -7.49335214e-02f,
  -1.28805727e-01f, -5.49511015e-02f, -8.56157541e-02f, 1.39925368e-02f, 7.50149190e-02f, 4.73071784e-02f, 4.35567833e-02f, -2.54791025e-02f, 1.66408271e-02f, -4.83323596e-02f,
  -1.03290096e-01f, -7.35982060e-02f, 3.14030498e-02f, -8.43087398e-03f, -3.46614467e-03f, -4.92048170e-03f, -1.24429762e-02f, 7.54515752e-02f, 6.62007779e-02f, 9.05876309e-02f,
  2.98256818e-02f, 4.95819151e-02f, 3.64409685e-02f, 2.76622586e-02f, -1.01261020e-01f, 2.08473783e-02f, -1.40141789e-02f, 4.32003550e-02f, -2.48175934e-02f, -1.66025579e-01f,
  -1.11577794e-01f, 1.76745206e-01f, -5.60692102e-02f, -9.34547037e-02f, -1.25599667e-01f, -3.46938409e-02f, -1.32902399e-01f, -1.03421107e-01f, -5.89098372e-02f, -1.99783430e-01f,
  -3.89860868e-02f, -1.43562615e-01f, -9.12808347e-03f, -8.43871161e-02f, 1.52434707e-01f, 2.06408389e-02f, 6.64891675e-02f, 1.37715917e-02f, 6.61778450e-02f, -1.27727583e-01f,
  8.38257968e-02f, -7.54744187e-02f, -5.99034391e-02f, -9.43617225e-02f, -1.29843235e-01f, -1.15324892e-01f, -8.92375633e-02f, -1.07362472e-01f, -2.82901973e-01f, -3.42524230e-01f,
  -1.27198577e-01f, -4.30692285e-01f, -3.67662340e-01f, -2.06909344e-01f, -3.45924050e-01f, -1.12209342e-01f, -1.39667332e-01f, 9.49774384e-02f, 8.04283544e-02f, -4.03636366e-01f,
  -6.80129603e-02f, -2.31738873e-02f, -1.72010064e-01f, 7.05608502e-02f, 5.43780811e-02f, -3.23076427e-01f, -2.54051715e-01f, -3.57233994e-02f, 2.29577497e-01f, 1.67776123e-01f,
  -4.81114760e-02f, -1.51872456e-01f, 5.53809069e-02f, 7.75755271e-02f, -3.78928810e-01f, -2.32550099e-01f, -3.52295041e-01f, -1.70691907e-01f, -1.56395197e-01f, -4.57961649e-01f,
  -3.27464223e-01f, 1.86505064e-01f, 2.34014429e-02f, -5.03690206e-02f, -1.88852146e-01f, 2.46081039e-01f, 1.40717283e-01f, 5.25764227e-02f, -6.70751370e-03f, 7.37036616e-02f,
  -1.16835207e-01f, 9.24261734e-02f, 7.47358650e-02f, 9.51794907e-02f, -8.92360806e-02f, 1.24088630e-01f, -7.11946338e-02f, 2.54466068e-02f, 2.29076501e-02f, 8.39504972e-03f,
  -1.67932570e-01f, -1.02837846e-01f, -1.58346280e-01f, 1.77109949e-02f, 1.12627849e-01f, -1.03048068e-02f, -6.99147210e-02f, 8.78189132e-02f, -3.53515148e-02f, -3.06430578e-01f,
  -3.74443755e-02f, -7.11891875e-02f, 2.40823557e-03f, 1.34380609e-01f, 1.32094517e-01f, 1.39339047e-03f, -4.61460650e-02f, -7.33942464e-02f, 5.41871637e-02f, 7.01805949e-02f,
  -3.70220467e-02f, -9.74357054e-02f, 4.97854650e-02f, -3.96912172e-02f, -5.92704825e-02f, -5.12553379e-02f, -7.04766251e-03f, -1.27634600e-01f, -7.37488344e-02f, -3.71272527e-02f,
  4.79172021e-02f, -7.38751516e-02f, -7.79731795e-02f, 2.43155044e-02f, 5.41004092e-02f, -2.58320849e-02f, -1.99642454e-04f, 8.51578712e-02f, 1.19705662e-01f, 2.04171345e-01f,
  -2.65929222e-01f, 8.02270398e-02f, -7.97373280e-02f, -4.75412644e-02f, 5.82559891e-02f, -4.27639298e-02f, -5.17376512e-02f, 1.66030470e-02f, 8.37705750e-03f, 2.99236272e-02f,
  -5.98837249e-02f, -3.53057347e-02f, -9.49968621e-02f, 3.88057046e-02f, 6.10529929e-02f, 1.63498580e-01f, -1.36840612e-01f, -1.49536192e-01f, 5.16541265e-02f, 2.16730181e-02f,
  8.84739030e-03f, -4.57927175e-02f, 4.10216190e-02f, -7.82354251e-02f, 1.94478817e-02f, -2.36860197e-02f, -9.81896371e-02f, -9.63477716e-02f, -4.67091613e-02f, -1.66406304e-01f,
  -2.44636878e-01f, -4.56819981e-01f, 1.59242079e-02f, 1.55894384e-01f, 4.08908635e-01f, -9.02719051e-02f, -4.80568439e-01f, -3.18714470e-01f, 1.43050238e-01f, -3.23066115e-01f,
  -7.19732866e-02f, 1.50491655e-01f, 1.99401513e-01f, -7.19066858e-02f, -5.64574420e-01f, -7.00440109e-01f, -1.91042095e-01f, -2.63691470e-02f, 1.07620589e-01f, -1.16812456e-02f,
  1.56847864e-01f, 1.76339954e-01f, 1.63457930e-01f, 7.65611604e-02f, 4.67259698e-02f, -5.40563799e-02f, 3.09603885e-02f, 1.17619753e-01f, -1.38176456e-01f, -2.90204212e-02f,
  -6.06894270e-02f, -1.69036359e-01f, 1.03789844e-01f, 2.93288194e-02f, 1.72282502e-01f, -2.37714961e-01f, 1.08039007e-02f, 6.01328202e-02f, 7.81621262e-02f, -1.05716586e-01f,
  1.76256970e-01f, -1.34370821e-02f, 3.81254107e-01f, 6.83246413e-03f, 7.76078328e-02f, -1.17422156e-01f, -3.56996171e-02f, -7.52385557e-02f, -2.08097488e-01f, -2.02967212e-01f,
  9.86590385e-02f, 6.89125434e-02f, -9.86841023e-02f, -1.89928532e-01f, 7.62767345e-02f, 3.70996222e-02f, -4.73145097e-02f, 1.71795096e-02f, -1.65048331e-01f, -1.23344541e-01f,
  3.86788398e-02f, 5.38761318e-02f, 3.76538113e-02f, -1.05293863e-01f, -3.99618931e-02f, -1.90164167e-02f, -5.90079930e-03f, -1.56692490e-01f, -3.40764485e-02f, 5.39072789e-02f,
  1.11993261e-01f, 4.27355170e-02f, 9.92353931e-02f, -1.01649031e-01f, 4.64250632e-02f, -1.34448446e-02f, 1.64534412e-02f, -3.12148891e-02f, -2.71313190e-02f, 1.41562233e-02f,
  -2.95550134e-02f, 6.80183098e-02f, 3.09627522e-02f, -1.25713395e-02f, -1.71796456e-01f, -4.15966138e-02f, 5.56632094e-02f, -2.21006051e-02f, 5.41120023e-02f, -4.83450964e-02f,
  -1.75512239e-01f, -2.77464148e-02f, -1.72816142e-01f, -1.06274886e-02f, -1.57963880e-03f, 3.55831794e-02f, -2.79918686e-02f, 1.27792191e-02f, 8.53544027e-02f, -1.09464370e-01f,
  -2.51446338e-03f, -3.10311690e-02f, -5.90969808e-02f, 1.24535412e-01f, 4.34175618e-02f, -9.12192687e-02f, -9.29740071e-02f, -7.99774602e-02f, -1.64026301e-02f, 6.74794763e-02f,
  3.12609747e-02f, -1.51466072e-01f, -4.16583598e-01f, -2.46803746e-01f, 2.97065880e-02f, -2.72614241e-01f, -1.64517671e-01f, -9.46293995e-02f, -3.60461563e-01f, -3.50791663e-01f,
  -6.66511571e-03f, -1.83488905e-01f, 1.29032627e-01f, 2.76286304e-01f, 2.44976673e-03f, 1.04682371e-02f, -1.19354099e-01f, 6.28439561e-02f, 3.30318928e-01f, 7.66116753e-02f,
  2.07670614e-01f, 3.06958705e-01f, 3.20243299e-01f, 2.41790786e-01f, 1.86485931e-01f, 1.96981609e-01f, 3.22567970e-01f, 2.72219896e-01f, 9.58407670e-02f, 3.52433324e-02f,
  1.04055461e-02f, -1.19855348e-02f, 8.85496587e-02f, 3.88342924e-02f, -1.96712375e-01f, 1.30564809e-01f, 5.81193678e-02f, -7.13785067e-02f, -1.00925796e-01f, 5.12469327e-03f,
  -1.44343246e-02f, 1.78300142e-02f, 2.83831269e-01f, 8.29183236e-02f, -5.19529283e-02f, 1.00696422e-01f, 5.20904288e-02f, -2.83319363e-03f, -9.55732688e-02f, 1.11336090e-01f,
  1.78508705e-03f, -3.14685404e-02f, -1.26103600e-02f, -2.46238802e-02f, -1.14264809e-01f, -1.01339526e-03f, 1.20062128e-01f, 3.73136066e-02f, 4.05246019e-02f, 1.85069777e-02f,
  -1.00769140e-01f, 2.18233615e-02f, -1.00621246e-02f, -1.49588594e-02f, 1.39775723e-01f, 1.26965553e-01f, 5.34474012e-03f, 4.81343977e-02f, 8.35775211e-02f, 1.52345031e-01f,
  3.16648424e-01f, 9.50872451e-02f, -5.84158674e-02f, 1.10995136e-01f, -5.63311689e-02f, 1.53670013e-02f, -1.02681983e-02f, -6.97994307e-02f, -2.60615591e-02f, -1.46883890e-01f,
  -5.03088571e-02f, 9.22362506e-02f, 1.87339857e-01f, -3.69886011e-02f, -7.55782798e-02f, -7.78864026e-02f, -1.04500510e-01f, -5.49973659e-02f, 7.95820495e-04f, 6.18517324e-02f,
  1.10007897e-01f, -5.62689565e-02f, -2.23218575e-01f, -1.13624208e-01f, 1.68932062e-02f, 7.19617903e-02f, 2.99867447e-02f, -3.61265149e-03f, 3.25560599e-04f, -8.74229372e-02f,
  1.62550956e-01f, 1.00222968e-01f, 6.84708282e-02f, 1.36767358e-01f, 9.24658552e-02f, -1.90131769e-01f, -2.77805571e-02f, -1.15454178e-02f, -9.44316573e-03f, -2.90295109e-03f,
  4.21376377e-02f, -7.37065598e-02f, -4.05741334e-02f, -1.10629283e-01f, 3.59835252e-02f, -2.44326331e-02f, 1.67758450e-01f, 9.19011459e-02f, 5.69639355e-02f, -3.50518674e-02f,
  -1.89127366e-03f, 1.54044982e-02f, 9.66677815e-02f, 1.40627742e-01f, 1.09778633e-02f, 7.19696879e-02f, -1.01909027e-01f, 2.12742016e-02f, -1.07968457e-01f, -8.06494281e-02f,
  5.44814587e-01f, -2.43823186e-01f, -3.84837896e-01f, 1.16285950e-01f, -3.42613131e-01f, -1.90903008e-01f, -3.35625529e-01f, 1.61691412e-01f, 1.60160169e-01f, -2.27954358e-01f,
  3.67371254e-02f, 3.22339416e-01f, 9.19121131e-02f, 2.38731235e-01f, 2.25486830e-01f, -2.76685417e-01f, -3.54040831e-01f, -1.95298847e-02f, 2.06983790e-01f, 1.31735831e-01f,
  5.51918745e-02f, 6.29082844e-02f, 3.59097838e-01f, 2.48057634e-01f, -1.94718584e-01f, 3.06953993e-02f, -2.42646441e-01f, -2.39902854e-01f, -9.94951203e-02f, -3.71201217e-01f,
  -2.97730148e-01f, -1.04938500e-01f, 7.24351630e-02f, 1.11102328e-01f, -1.03399925e-01f, 1.55374527e-01f, -3.79216447e-02f, -6.04180954e-02f, -4.99188015e-03f, -6.86214566e-02f,
  -1.35997832e-01f, 3.67818214e-02f, 2.82637980e-02f, -7.25892186e-02f, -6.96751177e-02f, -1.65718496e-02f, 5.28230779e-02f, 5.28968386e-02f, -9.60381776e-02f, -3.22873220e-02f,
  -1.56753525e-01f, -7.60852471e-02f, -5.05866185e-02f, -6.69121221e-02f, -4.33374122e-02f, 1.84981979e-03f, -2.13843867e-01f, 4.04888764e-02f, 8.44354928e-03f, -1.62667438e-01f,
  4.90968898e-02f, -8.28360915e-02f, -8.68348926e-02f, 3.36806639e-03f, 3.84968445e-02f, 2.94437725e-02f, -3.31422910e-02f, -2.18995530e-02f, -4.86201122e-02f, -2.94945985e-02f,
  1.03890538e-01f, -7.99156874e-02f, -3.70583050e-02f, 3.71181816e-02f, 1.43800545e-02f, -6.21337369e-02f, 7.48890713e-02f, -2.41337530e-02f, -1.65483691e-02f, 7.86866397e-02f,
  2.74375966e-03f, -7.98059329e-02f, 3.21383514e-02f, 2.40666028e-02f, 3.03263627e-02f, 1.96130890e-02f, 8.69007930e-02f, 3.22862412e-04f, -1.65379550e-02f, 5.50511070e-02f,
  2.13976920e-01f, 1.02672681e-01f, 3.60055007e-02f, 5.80211431e-02f, -9.95062068e-02f, 5.15380548e-03f, -9.82559398e-02f, -4.65769134e-02f, -6.65470511e-02f, -5.70044741e-02f,
  4.40040119e-02f, -4.59747575e-02f, -1.16703227e-01f, -4.32933914e-03f, -5.03872335e-02f, -1.13521725e-01f, 4.81049344e-02f, 2.39831842e-02f, -1.03659965e-01f, -1.14969715e-01f,
  -1.90131217e-02f, 4.07499224e-02f, 1.49867743e-01f, -1.55978901e-02f, -9.37827080e-02f, 1.79808065e-01f, -1.19297430e-01f, -1.08768024e-01f, 7.41495788e-02f, 1.62282661e-02f,
  -7.25904629e-02f, -1.78611234e-01f, -2.82388359e-01f, -1.62793338e-01f, -2.13209152e-01f, 1.05009839e-01f, 1.52969643e-01f, 7.23395273e-02f, 1.26705498e-01f, -1.67634830e-01f,
  1.29614934e-01f, 2.62019902e-01f, 9.66926664e-02f, 7.05013573e-02f, 2.94993967e-01f, -3.80923636e-02f, -2.05158100e-01f, 1.43753237e-03f, 3.61005932e-01f, 1.88255429e-01f,
  6.26362041e-02f, -3.91945019e-02f, -1.71980970e-02f, 2.41520852e-01f, -1.82086051e-01f, -1.31723970e-01f, -2.24460155e-01f, -1.80841893e-01f, -1.38520643e-01f, -3.57124209e-01f,
  8.15539137e-02f, -1.35056883e-01f, -6.00662567e-02f, -2.58968417e-02f, -6.57483861e-02f, 1.67326614e-01f, -1.72335476e-01f, -1.17163993e-01f, -4.94074859e-02f, -5.52372774e-03f,
  -1.75966159e-01f, 7.89467096e-02f, -2.25400880e-01f, 3.00627146e-02f, -1.43459395e-01f, 1.02183692e-01f, -1.05285890e-01f, -1.38666004e-01f, -2.11463735e-01f, 1.07626751e-01f,
  -3.43327224e-02f, -1.41056925e-01f, -1.78996578e-01f, -5.02441153e-02f, -1.80228800e-01f, -2.17610653e-02f, -1.24436378e-01f, -1.40203059e-01f, -2.27510750e-01f, -2.00212881e-01f,
  -3.32640484e-02f, -1.65329397e-01f, 2.64373012e-02f, 7.38609061e-02f, 1.69921607e-01f, -3.51227149e-02f, -9.30901915e-02f, -2.91862674e-02f, 1.48443803e-01f, -1.37760267e-02f,
  -4.31365101e-03f, 7.15317652e-02f, 4.98017818e-02f, -8.57474059e-02f, -8.45932513e-02f, -1.02540888e-01f, 3.36451307e-02f, -9.20125172e-02f, 2.91026216e-02f, 3.86084653e-02f,
  -4.64832932e-02f, -1.67180330e-01f, -8.94964412e-02f, -1.58350027e-04f, -1.12788081e-01f, 5.66887148e-02f, 7.09284768e-02f, 9.45341289e-02f, 1.21983245e-01f, 1.38889402e-01f,
  1.78737178e-01f, -5.00532351e-02f, 1.57952443e-01f, 8.00980851e-02f, 2.35162675e-02f, 1.20543301e-01f, -1.63604498e-01f, 7.79111460e-02f, 7.41399899e-02f, 1.42250150e-01f,
  -2.36925054e-02f, 8.66517872e-02f, -1.53244361e-01f, -8.44190195e-02f, 7.60268942e-02f, -5.67095280e-02f, -6.37826324e-02f, 8.55814517e-02f, -9.37537476e-02f, -2.61512194e-02f,
  -9.44759995e-02f, 8.00659806e-02f, 2.91811451e-02f, -7.92872533e-02f, -1.09845273e-01f, 1.38922885e-01f, 7.58441091e-02f, -3.28281783e-02f, 6.72600195e-02f, 2.31403589e-01f,
  -4.45043892e-01f, -5.41969873e-02f, 2.69399345e-01f, -1.88967865e-02f, 2.45077014e-01f, 2.78933555e-01f, 5.49647510e-01f, 1.11967482e-01f, -1.10832632e-01f, 5.28436042e-02f,
  -3.42012346e-01f, -4.00148928e-01f, -3.30444545e-01f, -3.52388442e-01f, -1.71877131e-01f, 4.23295915e-01f, 3.35383356e-01f, -1.73330307e-02f, 5.25560463e-03f, 1.12024359e-01f,
  3.59695554e-02f, 3.43543221e-03f, -2.24084154e-01f, -1.26522005e-01f, 4.21678200e-02f, 1.25140488e-01f, 1.58568904e-01f, -4.07243371e-02f, -3.69036570e-02f, 1.27041591e-02f,
  6.62188008e-02f, -4.37171251e-01f, 1.32136315e-01f, -1.97296098e-01f, -1.12744421e-01f, 8.60017091e-02f, -1.06199505e-02f, -3.81723084e-02f, -4.91751172e-02f, -7.05732405e-02f,
  -1.49276093e-01f, -1.17320316e-02f, -7.97954723e-02f, 8.02500248e-02f, 7.64461309e-02f, 2.34512519e-02f, -3.54769900e-02f, -2.07400829e-01f, -2.71495253e-01f, -1.23799987e-01f,
  -8.18061680e-02f, -2.52283633e-01f, -1.74667239e-01f, -1.49096802e-01f, -3.42631340e-01f, -1.36421531e-01f, -9.83442217e-02f, -1.55686975e-01f, -3.07124019e-01f, -1.27576888e-01f,
  3.04820314e-02f, 4.26496789e-02f, 4.92976718e-02f, 6.28571138e-02f, -3.90040018e-02f, -1.63336680e-03f, -6.09483346e-02f, -8.00187662e-02f, 1.90114882e-02f, 1.23144770e-02f,
  -1.71994582e-01f, -5.75826019e-02f, -2.55344231e-02f, 6.08032197e-02f, 1.86427440e-02f, 2.08610576e-02f, 6.34274110e-02f, 3.60285863e-03f, -6.51955828e-02f, 1.53358117e-01f,
  -7.72612588e-03f, 3.09039839e-02f, 7.08008334e-02f, 1.03700720e-01f, -9.15899202e-02f, 9.67854410e-02f, 8.23736489e-02f, -5.71730956e-02f, 1.44007104e-02f, -5.33461971e-05f,
  1.84750274e-01f, -2.49027580e-01f, 9.25769955e-02f, -2.95004509e-02f, 5.86215854e-02f, -1.09591641e-01f, -8.06191843e-03f, 1.40888497e-01f, -2.14363858e-01f, -8.62549245e-02f,
  -2.03681052e-01f, -1.65041745e-01f, -7.14120688e-03f, 1.04718931e-01f, 2.11609945e-01f, 5.76662645e-02f, 1.26556735e-02f, 2.13123649e-01f, -1.01567261e-01f, 1.79910168e-01f,
  1.26317199e-02f, 2.44731963e-01f, 1.79123491e-01f, 1.46004722e-01f, -1.11125007e-01f, 1.57199889e-01f, 1.37221754e-01f, 1.81750283e-01f, 1.01009354e-01f, 4.25390691e-01f,
  7.33588278e-01f, 4.79675550e-03f, 2.69663244e-01f, 1.39425024e-01f, 1.53380796e-01f, -1.48845529e-02f, -4.72140163e-02f, 2.42761858e-02f, -3.71273002e-03f, -1.75658930e-02f,
  3.94236036e-02f, -6.71479106e-02f, 1.24213723e-02f, -1.09847263e-01f, 9.99863520e-02f, -9.15615037e-02f, 5.32709137e-02f, 3.01380962e-01f, 3.12125444e-01f, 1.97899714e-01f,
  6.49302974e-02f, 2.14493692e-01f, 3.37538362e-01f, 1.60048410e-01f, -3.14206891e-02f, -1.04871839e-01f, 1.87888034e-02f, 1.57622591e-01f, 8.01539570e-02f, 4.90003228e-02f,
  1.08334631e-01f, 1.63957536e-01f, 1.18554360e-03f, -2.81261355e-02f, 7.60412738e-02f, 6.72513843e-02f, 2.33270098e-02f, -4.55961972e-02f, -6.60046712e-02f, -2.70429011e-02f,
  -5.34626693e-02f, 6.48354460e-03f, -2.47112811e-02f, 1.09537141e-02f, 1.04893342e-01f, 5.07923700e-02f, 1.10511810e-01f, 7.13229626e-02f, 1.23265259e-01f, 4.39999700e-02f,
  -8.10713321e-02f, 7.49328360e-02f, 5.97456209e-02f, 9.20427777e-03f, 3.99241745e-02f, 5.72479665e-02f, -2.35528015e-02f, 6.29378036e-02f, -8.22203606e-02f, -2.46652924e-02f,
  -8.99916664e-02f, -5.39789125e-02f, 7.68156648e-02f, 1.47191301e-01f, 2.66309887e-01f, 3.86155210e-02f, -3.42197195e-02f, 1.52767347e-02f, 1.99130997e-01f, 1.32208318e-01f,
  7.16078281e-02f, 1.71509221e-01f, 1.23644680e-01f, 8.72130767e-02f, 1.93068191e-01f, 8.08771625e-02f, 3.46415900e-02f, 4.05266397e-02f, 1.24665864e-01f, 3.36242057e-02f,
  8.10452327e-02f, 1.78320974e-01f, 1.72218293e-01f, 1.32490061e-02f, 8.66918340e-02f, 7.89658800e-02f, 8.66683424e-02f, 1.83016121e-01f, 1.60312265e-01f, -1.79717108e-03f,
  -1.72793895e-01f, 3.23191702e-01f, -5.29318936e-02f, -1.69583514e-01f, -8.70335475e-02f, 5.70737012e-02f, -2.59929318e-02f, -1.78265199e-01f, -1.06812634e-01f, -1.05420962e-01f,
  3.06093227e-02f, 8.31259638e-02f, 4.13532667e-02f, 6.86661340e-03f, 3.51193771e-02f, 6.74477499e-03f, -2.04172462e-01f, -1.56114474e-01f, -1.17830470e-01f, -6.47119135e-02f,
  -1.24153085e-01f, -9.39281806e-02f, -4.14100848e-02f, -1.04410365e-01f, 1.21779563e-02f, -1.70076545e-02f, -6.95185512e-02f, -4.44072252e-03f, -1.32449269e-01f, -5.33510931e-02f,
  -1.30653247e-01f, 5.21388389e-02f, 2.68638670e-01f, -3.89777720e-02f, 2.11813703e-01f, 1.39660567e-01f, -4.84682210e-02f, 8.95121470e-02f, 1.74966842e-01f, -5.59743084e-02f,
  -6.60821721e-02f, -8.26286227e-02f, 1.26864295e-02f, -1.50548503e-01f, -3.35061789e-01f, -1.30193964e-01f, -7.94771314e-02f, -1.61085710e-01f, -3.48448843e-01f, -4.47072983e-01f,
  -2.69869387e-01f, -6.64525479e-02f, -1.27867132e-01f, -1.65265724e-01f, -7.93792084e-02f, -8.06342214e-02f, 9.65386629e-02f, 1.65946446e-02f, -1.43587232e-01f, -9.60130990e-02f,
  -1.72683477e-01f, 1.42409742e-01f, -8.34467784e-02f, -2.77734578e-01f, -5.33400178e-02f, 1.35833487e-01f, -2.42035631e-02f, 1.71227917e-01f, 6.79798797e-02f, 1.52082294e-01f,
  -1.27441436e-01f, -6.27802014e-02f, 2.03773584e-02f, 1.17344983e-01f, 7.28835166e-02f, 5.96761853e-02f, 1.22285597e-01f, 1.72443777e-01f, 1.72945023e-01f, 8.71111290e-04f,
  -1.95733011e-01f, -1.01371951e-01f, -7.54819736e-02f, 1.92388564e-01f, 2.72240639e-01f, 8.52724537e-02f, -5.39234504e-02f, 1.18855843e-02f, 9.40996855e-02f, -1.37291491e-01f,
  -8.80094618e-02f, 1.26648813e-01f, 1.13747254e-01f, 9.05170962e-02f, 5.12682050e-02f, 1.66144922e-01f, 2.41059940e-02f, -1.73343956e-01f, -9.24519375e-02f, 1.28358053e-02f,
  1.25124052e-01f, -6.49708649e-03f, -7.77360573e-02f, -1.55340403e-01f, 3.36832888e-02f, -5.93426153e-02f, 2.61828303e-02f, -8.13709795e-02f, -1.71111837e-01f, 1.01370022e-01f,
  -9.08975527e-02f, -2.51036715e-02f, 3.46632004e-02f, -7.18623772e-02f, 2.31183767e-02f, -1.99702024e-01f, 1.16036378e-01f, 2.26937607e-03f, -2.25672070e-02f, 7.24130496e-02f,
  -1.58544600e-01f, -5.53253219e-02f, -5.90370037e-02f, -1.65064842e-01f, -7.00351745e-02f, 5.09510674e-02f, -7.55960867e-02f, 1.47727668e-01f, 1.64352432e-01f, -9.68357250e-02f,
  -1.75199106e-01f, -1.14247575e-02f, 4.51067649e-03f, 1.17074717e-02f, 6.67789578e-02f, -2.21804492e-02f, -7.15127587e-03f, -1.21385477e-01f, -1.19588546e-01f, 1.69922724e-01f,
  5.06103449e-02f, -1.84282675e-01f, -2.40027100e-01f, 1.55923888e-02f, -1.10239789e-01f, -2.24217728e-01f, -9.62175280e-02f, -1.63408518e-01f, -1.37687668e-01f, -3.15476060e-01f,
  6.73996687e-01f, 5.06311476e-01f, 2.36985430e-01f, 9.15542170e-02f, -2.99831592e-02f, -8.26051533e-02f, -9.87300798e-02f, 4.13070731e-02f, 6.58857524e-02f, 1.49927616e-01f,
  2.29186025e-02f, 5.42268604e-02f, 4.77456562e-02f, -2.84709819e-02f, 3.75291146e-02f, 1.08000822e-01f, 7.56517425e-02f, 1.62370995e-01f, 8.85092542e-02f, 3.71244289e-02f,
  1.69156939e-01f, 3.49833757e-01f, 3.22277695e-01f, 5.94219491e-02f, 2.58637160e-01f, -4.01060693e-02f, 9.31343585e-02f, 1.79498255e-01f, 1.13293149e-01f, 3.16842467e-01f,
  -1.11319991e-02f, 2.47453138e-01f, -1.66098133e-01f, 1.61918223e-01f, 5.05043305e-02f, 1.29268020e-01f, 2.01662391e-04f, -1.17807426e-02f, 5.04031405e-03f, -1.09643169e-01f,
  9.21866223e-02f, -3.41184027e-02f, -6.18598424e-02f, -9.13548246e-02f, 7.12392926e-02f, -5.31382822e-02f, 2.08801571e-02f, 5.66123575e-02f, -4.66869101e-02f, -1.14096902e-01f,
  1.06399730e-02f, -4.30702940e-02f, -1.44967198e-01f, -3.19444269e-01f, -1.27750888e-01f, -2.39096433e-01f, -2.09339648e-01f, -1.16646804e-01f, -2.12639078e-01f, -3.66197452e-02f,
  -1.08951077e-01f, 1.31049201e-01f, -3.69063802e-02f, -1.33285776e-01f, -1.85692146e-01f, -1.09760530e-01f, -2.94619966e-02f, -1.67452931e-01f, -2.09398970e-01f, -2.77145207e-02f,
  -4.40920293e-02f, -7.54065663e-02f, -2.51044868e-03f, -8.56558383e-02f, 1.95693392e-02f, -8.54292512e-02f, 6.21390082e-02f, -1.29745305e-01f, -5.15844710e-02f, 4.50824294e-03f,
  -4.50856388e-02f, -5.31690307e-02f, 1.51877208e-02f, 7.60649592e-02f, 6.17754310e-02f, -9.03161764e-02f, -8.05789754e-02f, -4.06401530e-02f, -6.43643066e-02f, 1.47320777e-01f,
  -1.69683203e-01f, -4.30197090e-01f, 3.03810630e-02f, 1.36934578e-01f, 7.95327872e-02f, 5.09335101e-02f, 1.10402647e-02f, 1.10001273e-01f, 7.69888535e-02f, 5.77475540e-02f,
  5.64470701e-02f, 1.30468652e-01f, 9.92861018e-02f, 4.18528393e-02f, -8.16673338e-02f, 1.85402781e-02f, 1.79530438e-02f, 9.12392214e-02f, 2.50111669e-02f, 8.01278576e-02f,
  -8.13177880e-03f, -3.78599651e-02f, -2.36181438e-01f, -1.52944297e-01f, 2.45321486e-02f, -8.19964483e-02f, -2.04845537e-02f, -8.41255486e-02f, -4.20286022e-02f, -7.94726238e-02f,
  -7.33073354e-01f, 4.84971739e-02f, 3.02976429e-01f, -4.24156070e-01f, 6.33117557e-02f, 2.79701114e-01f, 2.40492657e-01f, -5.34120239e-02f, -3.21700603e-01f, -7.06611350e-02f,
  3.40920803e-03f, -2.74747610e-01f, -4.52638865e-02f, 1.26084760e-01f, 1.89629659e-01f, 3.35932285e-01f, 1.70294523e-01f, 1.85120314e-01f, 1.32364750e-01f, -5.57963476e-02f,
  2.21544225e-02f, -1.73552439e-01f, -1.74601629e-01f, 2.66436059e-02f, -3.93873304e-01f, -1.97505385e-01f, 9.52485651e-02f, 1.30649684e-02f, 1.58342123e-01f, -5.48362639e-03f,
  -2.94460446e-01f, -1.41551748e-01f, 1.14618959e-02f, -1.59184068e-01f, -1.26496792e-01f, -9.50936377e-02f, -1.84094474e-01f, -7.77889192e-02f, 1.47509560e-01f, -1.82783961e-01f,
  3.41943018e-02f, 1.66680247e-01f, -2.98430435e-02f, -3.36879529e-02f, -5.66591285e-02f, -1.03358537e-01f, 3.10439803e-02f, -8.03459361e-02f, -2.00153980e-03f, 4.23054304e-03f,
  3.21679898e-02f, -1.79033145e-01f, -2.49638349e-01f, 1.71359614e-01f, 1.10748366e-01f, -9.17449594e-02f, -1.90452617e-02f, -1.25679508e-01f, 1.81479409e-01f, -2.40928993e-01f,
  1.75306246e-01f, -8.98908451e-02f, 8.89449269e-02f, 1.60052031e-02f, -9.80877876e-03f, -2.82651391e-02f, 1.11920178e-01f, 9.39364210e-02f, -1.00445710e-01f, -1.70972813e-02f,
  1.40573695e-01f, -5.59725761e-02f, -8.34117755e-02f, -1.71612084e-01f, -2.95971297e-02f, -2.56912243e-02f, 8.29035416e-02f, -5.69061972e-02f, 4.89161052e-02f, 4.40527946e-02f,
  -5.27619757e-02f, -1.17577203e-01f, -4.33592089e-02f, 1.91442445e-02f, 3.59433182e-02f, 1.54959494e-02f, -9.63603184e-02f, -2.05871180e-01f, -1.44106790e-01f, -1.12625845e-01f,
  -4.41396564e-01f, 4.79024887e-01f, -2.42572695e-01f, -5.16899116e-02f, -2.45805625e-02f, -1.19487522e-02f, -1.06697351e-01f, 5.53707965e-02f, 8.07802156e-02f, 1.26978993e-01f,
  1.02121338e-01f, -9.24097076e-02f, -8.59588459e-02f, 1.39847457e-01f, 7.68115968e-02f, -1.14538528e-01f, 1.48512736e-01f, -6.13209512e-03f, 1.47262335e-01f, 4.39841524e-02f,
  1.33110853e-02f, -2.15128377e-01f, -3.64825189e-01f, -5.95384575e-02f, -6.45001829e-02f, -2.41757095e-01f, -2.47168884e-01f, -3.25664461e-01f, -6.74728751e-02f, -3.47944289e-01f,
  7.03383505e-01f, 2.74118900e-01f, -1.80049285e-01f, 2.73160279e-01f, -3.59598726e-01f, -3.79510403e-01f, 6.45466819e-02f, 1.32232651e-01f, 1.18987806e-01f, 3.63515675e-01f,
  -6.92650899e-02f, -3.31403881e-01f, -9.76193249e-02f, -1.77971378e-01f, -9.01231095e-02f, 1.06743410e-01f, 1.07337013e-01f, -2.72643387e-01f, -4.55296606e-01f, -2.74857134e-01f,
  -9.46224779e-02f, -7.27091311e-03f, 1.83090270e-01f, -1.15209511e-02f, 1.81711599e-01f, -1.16423503e-01f, 9.53969434e-02f, 3.52512933e-02f, -1.47216260e-01f, 3.86967242e-01f,
  -1.28733397e-01f, 2.36155689e-01f, -2.64815897e-01f, -5.07555418e-02f, -1.70397520e-01f, 8.36653933e-02f, -3.75351608e-02f, 4.28185202e-02f, -7.44872093e-02f, 4.10185494e-02f,
  -2.14675903e-01f, -3.46720330e-02f, -1.36373043e-01f, -9.43613946e-02f, -1.07953265e-01f, -8.55026320e-02f, 1.32570654e-01f, 1.16116041e-02f, 5.45585454e-02f, -3.17273699e-02f,
  -9.14732292e-02f, -1.65801719e-01f, -1.23952292e-01f, -2.70064306e-02f, -7.92231262e-02f, -2.42719367e-01f, -7.32849687e-02f, 1.14824083e-02f, -1.87604502e-01f, 5.39386094e-01f,
  1.47980645e-01f, -1.36847999e-02f, -5.44664972e-02f, 2.68233884e-02f, 6.73932508e-02f, 2.93429904e-02f, 2.67284214e-02f, -5.43517321e-02f, -2.46068481e-02f, 8.69822055e-02f,
  6.89512119e-02f, 1.28437914e-02f, -7.84258991e-02f, 6.03234284e-02f, -2.99822092e-02f, -1.20860850e-02f, 3.07619646e-02f, 7.33850598e-02f, -5.61408475e-02f, -2.61782482e-03f,
  -4.74751703e-02f, 1.86137650e-02f, 3.00871022e-02f, -1.21201696e-02f, 3.20465676e-03f, 1.13226220e-01f, -1.95184067e-01f, -7.64846951e-02f, 5.84318303e-02f, -2.58965567e-02f,
  -1.31756216e-01f, -3.14004421e-01f, 1.47813350e-01f, 7.03752367e-03f, -7.84809119e-04f, 3.64659131e-02f, 3.85506041e-02f, 3.05932923e-03f, -7.31515884e-02f, 1.45466411e-02f,
  -1.67822510e-01f, -7.07038790e-02f, 4.25572246e-02f, -2.51608286e-02f, -1.68455113e-03f, -4.75381985e-02f, 2.79147122e-02f, -7.01501891e-02f, -5.86664788e-02f, 7.24525377e-02f,
  1.47293299e-01f, 9.93920863e-02f, 7.74941873e-03f, 2.29349732e-02f, 6.71903696e-03f, -6.51764795e-02f, -1.10333622e-01f, -1.35786325e-01f, -1.82212874e-01f, 3.28047514e-01f,
  -4.14491773e-01f, 1.57446131e-01f, 1.02387957e-01f, 9.69987437e-02f, 9.93716251e-03f, -2.68272739e-02f, -6.89449832e-02f, -1.47429882e-02f, 6.16781935e-02f, -2.87929494e-02f,
  -1.73235163e-01f, 2.79222205e-02f, 1.76582038e-01f, 5.80430925e-02f, -8.52175876e-02f, 2.06569836e-01f, 3.53940904e-01f, 1.03076376e-01f, -2.72344202e-01f, -2.31972530e-01f,
  1.16680883e-01f, -1.74710304e-01f, -2.47063681e-01f, -4.33561988e-02f, 1.82729647e-01f, 4.40801196e-02f, 1.06843777e-01f, 6.28023967e-02f, 3.81032489e-02f, 3.80686611e-01f,
  -6.09653257e-02f, -1.15014404e-01f, -2.35102307e-02f, 3.57260332e-02f, -5.93398325e-02f, -1.98972687e-01f, 3.46297696e-02f, -9.03257579e-02f, 3.16141755e-03f, -4.16381620e-02f,
  -4.21365350e-02f, -2.15241648e-02f, 2.25483134e-01f, -4.92598787e-02f, -1.24147207e-01f, -1.00687958e-01f, -1.66037500e-01f, -2.18088459e-02f, -2.39910647e-01f, -1.64762482e-01f,
  2.19310850e-01f, -8.55962485e-02f, -1.97586074e-01f, -9.23201963e-02f, 4.89802659e-03f, -1.32261252e-04f, -2.50254959e-01f, -2.57372379e-01f, -4.18983698e-01f, 1.81560963e-02f,
  -1.29532263e-01f, -1.25147492e-01f, -6.96336571e-03f, 1.45332478e-02f, -1.56190723e-01f, 2.25484429e-04f, 5.41411340e-02f, 2.61260550e-02f, -4.27652821e-02f, -9.72627923e-02f,
  -5.87209873e-03f, -8.43393803e-02f, 1.66126788e-02f, -1.07978947e-01f, -1.39326125e-01f, 4.06949827e-03f, 1.57238692e-01f, -5.14148585e-02f, -3.67142335e-02f, -1.50899127e-01f,
  8.35101679e-03f, 9.03284997e-02f, -7.62201399e-02f, 7.93333203e-02f, -8.28330144e-02f, -1.32130951e-01f, -1.28169745e-01f, -1.23208947e-01f, -1.12152159e-01f, -8.39762241e-02f,
  -2.02979386e-01f, -1.72587857e-01f, 2.86737154e-03f, 1.69397458e-01f, 4.24991846e-02f, -8.65094140e-02f, 1.20532811e-01f, -5.63305058e-02f, 1.40186250e-01f, -1.10437348e-02f,
  -2.27676913e-01f, 1.52408239e-02f, 1.71864331e-01f, 1.16079524e-01f, -1.38783576e-02f, -4.68253391e-03f, 7.49673620e-02f, 3.46000120e-02f, -2.85063963e-02f, -4.50377092e-02f,
  1.53615788e-01f, -2.40312964e-02f, -2.49059826e-01f, 1.14770733e-01f, -5.07268123e-02f, -1.95018366e-01f, -2.37994954e-01f, -2.08252788e-01f, -3.43062103e-01f, -2.79865026e-01f,
  6.84043825e-01f, -3.20950747e-01f, 1.98751330e-01f, 2.46266201e-01f, 1.45366892e-01f, 1.43461645e-01f, -1.08317368e-01f, 5.04671596e-02f, 5.97919784e-02f, -1.56956747e-01f,
  -1.38812482e-01f, 8.41506049e-02f, -1.84448697e-02f, 3.27439271e-02f, 5.68716116e-02f, -1.49908051e-01f, -1.09145045e-01f, 2.08128646e-01f, 3.27917993e-01f, 5.70364669e-02f,
  -1.42273888e-01f, -1.07148118e-01f, 9.87785310e-02f, -5.45263737e-02f, -2.17823133e-01f, 2.36040656e-03f, -1.64016038e-01f, -1.58840820e-01f, -1.68987006e-01f, -2.78349429e-01f,
  -9.67173055e-02f, 9.11487937e-02f, 1.26060337e-01f, -6.01474792e-02f, 1.70281157e-02f, -6.30824035e-03f, -2.38881037e-02f, -1.45177796e-01f, -4.64583095e-03f, -1.14137039e-01f,
  -1.88170254e-01f, -2.06750650e-02f, -5.39920367e-02f, -1.68471456e-01f, -1.84427258e-02f, 2.97499169e-02f, -7.51961693e-02f, 1.00204639e-01f, -8.60456228e-02f, -7.88946450e-02f,
  -5.86476028e-02f, 6.66706637e-02f, 1.69671714e-01f, -8.80489573e-02f, 5.66201806e-02f, 2.67963652e-02f, -2.60062292e-02f, -5.94419613e-02f, 1.11944473e-03f, 1.32919019e-02f,
  -5.65504516e-03f, 8.06879923e-02f, 3.21661122e-02f, 5.32691851e-02f, -4.19068485e-02f, 4.94842641e-02f, -3.90242189e-02f, 6.24455288e-02f, 2.94080954e-02f, 1.49587113e-02f,
  -4.65025716e-02f, 2.33582214e-01f, 4.36922833e-02f, 1.83440577e-02f, 5.81409372e-02f, -1.59997996e-02f, -2.96043102e-02f, -5.81759848e-02f, -4.98628914e-02f, -2.31855344e-02f,
  1.19046852e-01f, -2.97469441e-02f, -5.76655567e-02f, -1.33802202e-02f, 2.32863054e-02f, 4.59925123e-02f, 1.01917833e-01f, -4.58568111e-02f, 5.95789589e-02f, 1.32940367e-01f,
  -2.15940446e-01f, 1.55302927e-01f, -4.21230644e-02f, -5.84182627e-02f, -9.86172110e-02f, -3.31412442e-02f, -6.73843920e-02f, -1.95248693e-01f, -1.98604181e-01f, -6.15246110e-02f,
  -6.68652430e-02f, 2.25926153e-02f, -1.35423988e-01f, -1.32533498e-02f, 3.17190704e-03f, 8.89326166e-03f, -1.55285373e-01f, 1.52830333e-01f, -7.18901232e-02f, -8.91421512e-02f,
  -6.95975199e-02f, 1.82665169e-01f, 2.07991645e-01f, 8.08513537e-02f, -1.47025939e-02f, 3.02031964e-01f, 1.44658284e-02f, 4.96861599e-02f, 1.55160084e-01f, 6.46568760e-02f,
  2.80018061e-01f, 4.21225131e-01f, 4.88075167e-02f, -3.55628543e-02f, 1.38072044e-01f, 3.09370309e-01f, 3.89065027e-01f, 1.63340285e-01f, -2.00501457e-01f, 6.18080013e-02f,
  1.28073990e-03f, -1.99437782e-01f, -1.71979740e-01f, -2.61537760e-01f, -4.81184460e-02f, 5.43015376e-02f, 1.98015347e-02f, -1.48587134e-02f, -1.77520454e-01f, -1.83677748e-02f,
  5.77350818e-02f, 1.36416018e-01f, 2.04052120e-01f, -2.73954067e-02f, -5.76281734e-02f, -1.63753510e-01f, 5.67006990e-02f, 3.22668463e-01f, 1.53660998e-01f, -2.00984143e-02f,
  5.07533550e-02f, 4.02911872e-01f, -3.14066857e-01f, -1.47974998e-01f, 7.16160387e-02f, 1.59494951e-02f, -5.60681447e-02f, 2.72735320e-02f, -4.71997708e-02f, -2.49512177e-02f,
  2.32140664e-02f, 3.05291768e-02f, 3.46641876e-02f, 1.12729724e-02f, 1.49710611e-01f, -5.51748909e-02f, 6.76132739e-02f, -9.60582197e-02f, -2.54464000e-01f, -1.13527857e-01f,
  8.00763220e-02f, 1.52902007e-01f, 3.10167402e-01f, -1.26716226e-01f, -1.30292520e-01f, -2.00149715e-01f, 5.26996478e-02f, 5.41382879e-02f, 4.08205017e-02f, -1.95397899e-01f,
  -5.14773875e-02f, -1.68201644e-02f, 2.74836197e-02f, -2.08741054e-02f, 1.46781746e-02f, -1.58701405e-01f, -3.94334383e-02f, -1.27129359e-02f, 4.73860651e-02f, 1.45258024e-01f,
  -1.60777465e-01f, -7.01851621e-02f, -1.17490739e-02f, -2.72054933e-02f, -1.57472547e-02f, -3.01193222e-02f, -8.92342627e-02f, -1.64624471e-02f, 2.40582023e-02f, 1.89242102e-02f,
  -8.78862478e-03f, -6.46879673e-02f, -9.45329964e-02f, -4.53731939e-02f, 7.39250984e-03f, -2.75402218e-01f, -2.28076894e-02f, -2.18983478e-04f, -6.01489991e-02f, 5.61880432e-02f,
  -1.10867612e-01f, 1.92195624e-01f, -4.19343054e-01f, -1.50454372e-01f, 4.89117056e-02f, -2.84096561e-02f, 1.04423769e-01f, -6.10738003e-04f, -1.44675644e-02f, -7.86520168e-02f,
  1.30856946e-01f, -9.10959765e-02f, 1.36239026e-02f, -9.46682021e-02f, -4.89125326e-02f, 4.77032810e-02f, 1.06127441e-01f, -2.74048075e-02f, -2.29695365e-02f, -9.98837501e-02f,
  -2.40281262e-02f, 1.37316557e-02f, -1.73590109e-01f, -3.54335696e-01f, -1.81466043e-01f, -4.06125993e-01f, -3.01508665e-01f, -1.04390569e-01f, 3.16760913e-02f, -2.73639411e-01f,
  -7.95732021e-01f, -1.85773745e-01f, 1.93019748e-01f, -8.97385955e-01f, -3.58650982e-01f, -9.51912925e-02f, -2.17368200e-01f, -1.45953551e-01f, -2.25018576e-01f, -2.48104587e-01f,
  -4.40790504e-02f, 7.75249079e-02f, 1.66869670e-01f, 2.43637711e-01f, 2.26583838e-01f, -1.24726549e-01f, 6.67597651e-02f, 2.19611913e-01f, 2.20934600e-01f, -1.71945971e-02f,
  -8.76742378e-02f, -2.55011141e-01f, -1.34762093e-01f, 2.41399258e-02f, -5.08237183e-01f, -2.03996703e-01f, -5.22081777e-02f, -1.04905516e-01f, 9.82758701e-02f, -2.41506830e-01f,
  -5.08283265e-02f, -2.83367127e-01f, 1.24344647e-01f, -5.21643609e-02f, -8.53916407e-02f, -7.22211879e-03f, -1.77059114e-01f, 2.04315502e-02f, 3.83149274e-02f, -1.78750187e-01f,
  -2.58038461e-01f, 4.40469496e-02f, -2.27692768e-01f, -9.28187594e-02f, -1.71328589e-01f, -5.01081124e-02f, 2.80338079e-02f, 1.43860221e-01f, 1.44465551e-01f, 2.99683008e-02f,
  -4.70908433e-02f, -3.44929285e-02f, -4.63535413e-02f, 2.05427393e-01f, 8.02166909e-02f, 7.88830072e-02f, 1.90219194e-01f, 4.31016162e-02f, 2.83795297e-01f, -9.96907502e-02f,
  -6.46159872e-02f, 7.13179484e-02f, 1.40471710e-02f, 3.44500504e-02f, -2.80224737e-02f, 7.45074227e-02f, -7.68874884e-02f, -1.38393164e-01f, 3.26490402e-02f, -7.25648329e-02f,
  5.76695092e-02f, -2.72517912e-02f, 1.01872213e-01f, 6.63081091e-03f, -8.01378787e-02f, -9.54634510e-03f, -7.49306604e-02f, 2.64646560e-02f, 5.27801886e-02f, -1.35648727e-01f,
  9.05400142e-02f, 8.91468972e-02f, -8.64654481e-02f, 8.18458758e-03f, 3.41953449e-02f, -5.94473928e-02f, 4.57096994e-02f, -5.61664300e-03f, -6.25396818e-02f, 7.07938224e-02f,
  -4.36232716e-01f, 3.80832255e-01f, -1.99684009e-01f, 1.02929100e-01f, -8.72158483e-02f, 9.45508629e-02f, -4.09463011e-02f, 1.88612361e-02f, -2.06064925e-01f, -2.52200156e-01f,
  6.20300509e-02f, -9.72340554e-02f, 3.97859840e-03f, 1.42915919e-01f, -5.42616136e-02f, 3.06883100e-02f, 9.97094736e-02f, -1.00975730e-01f, 1.64978132e-01f, 7.06914589e-02f,
  1.57178938e-01f, -4.49207388e-02f, -1.85121179e-01f, 5.71799092e-02f, 3.54380533e-02f, -7.01914076e-03f, 9.26905498e-02f, 6.57593906e-02f, 2.23128960e-01f, -1.83437273e-01f,
  4.85333174e-01f, -2.12867483e-01f, -5.02328515e-01f, 1.37420580e-01f, -2.21175283e-01f, -2.43932873e-01f, -2.80301809e-01f, 1.94676071e-01f, 4.23754863e-02f, -2.21552312e-01f,
  -1.02017686e-01f, 1.00845732e-01f, 3.50159444e-02f, 5.18968813e-02f, 1.52416140e-01f, -3.79507959e-01f, -2.91176230e-01f, 4.83049154e-02f, 2.17442021e-01f, 1.06686540e-01f,
  1.80275023e-01f, 1.82537735e-01f, 2.42344186e-01f, 2.21645772e-01f, -9.87660885e-02f, -9.98380873e-03f, -2.09253028e-01f, -1.32166892e-01f, -1.14664823e-01f, -3.21429700e-01f,
  -3.60581934e-01f, -1.25756785e-01f, 4.07134183e-02f, 9.15114805e-02f, -1.84904650e-01f, 1.55055404e-01f, 3.34635796e-03f, -5.99353388e-02f, 1.51756510e-01f, -1.09780535e-01f,
  -3.67665254e-02f, -3.27808373e-02f, 9.73384529e-02f, -1.38404354e-01f, -8.42205137e-02f, -5.15694991e-02f, -2.58586649e-02f, -8.65889937e-02f, -1.83445830e-02f, -4.91846018e-02f,
  4.58589569e-02f, -5.29909413e-03f, -6.51231185e-02f, -1.24708354e-01f, -5.46250157e-02f, 1.76997762e-02f, -2.15473518e-01f, -7.16124475e-02f, -1.36519149e-01f, -1.81036636e-01f,
  -6.31908029e-02f, -5.13648279e-02f, -3.72032411e-02f, 7.43974224e-02f, 5.99824637e-02f, -1.18376110e-02f, 6.16487823e-02f, 1.65639129e-02f, 1.56096488e-01f, 8.50567147e-02f,
  -1.29194692e-01f, -1.86507385e-02f, 7.70393088e-02f, -3.43872420e-02f, -7.37507194e-02f, 4.56264764e-02f, 2.24176738e-02f, -1.22438721e-01f, 1.03533089e-01f, 5.40580675e-02f,
  8.63580257e-02f, -9.98046026e-02f, 4.94002476e-02f, 9.46483612e-02f, -1.13980353e-01f, -1.50074353e-02f, -7.37078786e-02f, 9.93950143e-02f, 4.83067185e-02f, -3.95091102e-02f,
  1.27596393e-01f, -5.31582758e-02f, 1.15917828e-02f, 2.04814412e-02f, 2.15850789e-02f, 1.57556739e-02f, -2.40776408e-02f, -4.27514613e-02f, 4.07201014e-02f, -6.59841448e-02f,
  1.30112708e-01f, 1.92749761e-02f, -5.55244163e-02f, 9.23257321e-02f, 7.11484626e-02f, 1.68732349e-02f, 6.01212196e-02f, 7.09615648e-02f, 4.05490361e-02f, -8.60731825e-02f,
  -2.44858093e-03f, 1.15347356e-01f, 1.55458272e-01f, -7.95275420e-02f, 5.11286184e-02f, 1.36739656e-01f, -3.44597897e-03f, 4.52834032e-02f, 5.56266978e-02f, 1.78083405e-01f,
  -3.43139730e-02f, 2.27122024e-01f, 2.11716011e-01f, 1.24747157e-01f, -7.60007575e-02f, 1.34467393e-01f, 3.16374779e-01f, 1.27339110e-01f, -1.48662090e-01f, 4.84810546e-02f,
  -1.34994641e-01f, -2.47239172e-01f, -1.74230486e-01f, -8.74021351e-02f, 1.37439772e-01f, 2.16082990e-01f, 2.67634243e-01f, 9.52983499e-02f, -9.86191556e-02f, 1.31334856e-01f,
  -8.68936405e-02f, -1.16090432e-01f, -1.62355155e-01f, 9.75077078e-02f, 1.88158676e-01f, -2.95386016e-01f, -6.93926811e-02f, 7.11117461e-02f, 8.79078805e-02f, 2.55195707e-01f,
  -8.10061097e-02f, 7.71215633e-02f, -5.42613529e-02f, -3.14088464e-01f, -8.12178850e-02f, 1.58213507e-02f, -1.09503277e-01f, 3.16171609e-02f, -6.23752400e-02f, 1.33533664e-02f,
  -1.08128995e-01f, -7.42842481e-02f, 1.29632115e-01f, 1.21799059e-01f, 1.11601971e-01f, 1.56818423e-02f, 1.49344906e-01f, 4.75243367e-02f, 9.18352380e-02f, 1.07545607e-01f,
  3.06920782e-02f, -2.57337335e-02f, 1.73878781e-02f, 1.14806771e-01f, 1.95330516e-01f, -1.25697181e-01f, 4.10393961e-02f, -2.41001397e-02f, -9.20810550e-02f, -4.39112857e-02f,
  -4.00172621e-02f, 2.22968198e-02f, -1.13689192e-01f, 1.62090272e-01f, -9.91127081e-03f, -1.54592678e-01f, 8.35797265e-02f, -1.51906544e-02f, 1.47495240e-01f, 9.51898918e-02f,
  -1.32045951e-02f, -4.32963297e-02f, -2.95234174e-02f, 2.33791862e-03f, 2.11526155e-02f, 6.12375513e-03f, 1.49326995e-01f, 9.66214761e-02f, -8.06572884e-02f, -1.10458247e-02f,
  -5.08757643e-02f, 5.04401624e-02f, 1.07016541e-01f, 1.02862827e-01f, -5.02080051e-03f, -3.37819643e-02f, -1.48984730e-01f, -2.52804291e-02f, 1.71179827e-02f, -5.40819876e-02f,
  -1.54505163e-01f, -8.30862597e-02f, -5.02881370e-02f, -1.31979764e-01f, -1.01984635e-01f, -1.48150429e-01f, -5.58938943e-02f, -1.79579094e-01f, -5.50943501e-02f, -1.36119783e-01f,
  -5.87118082e-02f, -1.08050190e-01f, 5.63886277e-02f, -4.97983322e-02f, -7.56190494e-02f, -1.66279092e-01f, -2.00146377e-01f, 1.55700848e-03f, -3.41744609e-02f, -7.11455941e-02f,
  -4.66041155e-02f, -1.57800779e-01f, -2.63377875e-01f, 1.01794656e-02f, 7.23560452e-02f, -2.58301675e-01f, -2.07465962e-01f, -8.47360641e-02f, -6.23762198e-02f, -8.91121924e-02f,
  5.73948622e-01f, 2.11260483e-01f, 3.48178059e-01f, 2.45095193e-01f, 2.73375779e-01f, 3.27921867e-01f, 3.26356381e-01f, 3.92330140e-02f, -9.84349176e-02f, 1.15832493e-01f,
  2.93822497e-01f, 7.87869990e-02f, 9.63375866e-02f, -2.73462106e-02f, 1.38356686e-01f, 4.81262058e-02f, -1.71369202e-02f, 3.27803344e-02f, 3.30724232e-02f, 7.09537268e-02f,
  -1.61948666e-01f, -1.77930053e-02f, 8.82505625e-02f, 4.11403319e-03f, -1.54179603e-01f, -1.72848739e-02f, -5.50206378e-02f, 7.14299604e-02f, 4.56420220e-02f, -2.32832059e-01f,
  2.04240143e-01f, 3.36866587e-01f, -3.78820822e-02f, 4.00265492e-02f, 1.53745681e-01f, -7.04133734e-02f, 5.94272912e-02f, -3.43274102e-02f, 2.05193534e-02f, -1.08101003e-01f,
  5.81682250e-02f, -6.61069229e-02f, 1.13164000e-01f, 4.85303812e-02f, 7.98901841e-02f, 3.88639122e-02f, 1.03785783e-01f, -1.15615944e-03f, 8.14075321e-02f, -1.38440076e-02f,
  7.69903660e-02f, 3.90225723e-02f, 1.55467525e-01f, 2.28532422e-02f, 9.04895738e-02f, 1.12969510e-01f, 1.70503199e-01f, 4.00843360e-02f, 1.12779170e-01f, -8.86515006e-02f,
  1.33130863e-01f, -5.41040227e-02f, 2.05972657e-01f, -1.23427577e-01f, 1.12628482e-01f, -3.46452147e-02f, -2.50645839e-02f, -4.93664714e-03f, 7.46352971e-02f, -8.52654651e-02f,
  -2.33328392e-04f, -5.60663315e-03f, 1.82443429e-02f, -1.66467819e-02f, 4.02047709e-02f, 3.43904905e-02f, -8.38840306e-02f, -1.54474564e-02f, 1.19951002e-01f, 3.95388491e-02f,
  -1.42649263e-02f, -3.98302749e-02f, 3.55466418e-02f, 1.31624520e-01f, 3.80709916e-02f, 8.37602615e-02f, -5.90799786e-02f, 2.87867561e-02f, -4.60942313e-02f, -1.61786854e-01f,
  -3.61911714e-01f, 4.14555490e-01f, -1.90733932e-02f, -1.41744152e-01f, 6.23554327e-02f, -8.97234157e-02f, 5.71529642e-02f, -1.14238746e-01f, -1.42065600e-01f, -7.65736103e-02f,
  -8.79897773e-02f, -9.33607742e-02f, 7.74511397e-02f, 1.20762363e-02f, -1.50565296e-01f, -1.76210403e-01f, -6.16670884e-02f, -2.19156947e-02f, -8.18812251e-02f, -1.17545679e-01f,
  -1.07877001e-01f, -2.20352337e-01f, -2.31196284e-01f, -9.64497626e-02f, -8.60064849e-02f, -1.40353352e-01f, -4.70485799e-02f, -2.11948499e-01f, -6.72706962e-02f, -2.50397652e-01f,
  7.39543915e-01f, -2.52445668e-01f, 3.24310273e-01f, 1.92285702e-01f, 1.42405808e-01f, 3.55983287e-01f, 2.89185047e-01f, 4.23508137e-02f, -4.15321514e-02f, -2.53070742e-02f,
  -2.64605224e-01f, -2.69625068e-01f, -1.52634904e-01f, -1.79973185e-01f, -6.87876567e-02f, 1.85525715e-01f, 1.75436988e-01f, 2.49455377e-01f, 2.36529067e-01f, 7.41138160e-02f,
  1.48754288e-02f, 7.76545107e-02f, 6.08164025e-03f, 1.00870170e-01f, 7.07844272e-03f, -5.23354411e-02f, -4.57997173e-02f, 8.25223178e-02f, -1.29488781e-01f, -1.84782296e-01f,
  -2.54792333e-01f, 1.89056650e-01f, 5.41495420e-02f, -1.84830695e-01f, -1.13771431e-01f, -4.49065790e-02f, 1.68699399e-02f, -7.60427639e-02f, 2.05635428e-02f, -6.85975328e-02f,
  -3.64333950e-02f, -1.25778511e-01f, 6.71811849e-02f, -6.20919317e-02f, -7.98797086e-02f, -1.07739843e-01f, -3.98045406e-02f, 6.41480833e-02f, -8.70381016e-04f, -4.57155779e-02f,
  -1.47287458e-01f, 1.60533935e-01f, 1.47760823e-01f, 2.72718631e-02f, 8.23989809e-02f, 1.00467103e-02f, -2.57014968e-02f, -2.88608503e-02f, 1.54904708e-01f, -2.13481560e-02f,
  5.72642908e-02f, 3.80286179e-03f, -7.63289770e-03f, 9.94676501e-02f, 1.94845840e-01f, 2.15700597e-01f, 4.59011048e-02f, -4.86109704e-02f, 8.62066075e-02f, 6.36234432e-02f,
  2.26629470e-02f, -3.92683633e-02f, -8.98483582e-03f, 3.60108651e-02f, -8.77180025e-02f, -1.09752886e-01f, -7.54073262e-02f, -1.35874137e-01f, -1.11261070e-01f, 2.50060223e-02f,
  -7.58296475e-02f, -4.84406538e-02f, -5.25691099e-02f, -1.89034104e-01f, -2.98471823e-02f, -1.13636270e-01f, -1.41093761e-01f, -1.06479801e-01f, -9.87403467e-02f, 9.10204020e-04f,
  -6.44543767e-01f, 1.17960438e-01f, 1.94583721e-02f, 9.35652852e-03f, -8.66449773e-02f, -1.21606700e-01f, -2.47844285e-03f, 5.27296914e-03f, -1.92024335e-02f, -4.57452349e-02f,
  -4.81671356e-02f, -1.09355040e-01f, 2.50776112e-02f, 1.43905682e-02f, 1.75704658e-01f, 8.27100277e-02f, -1.57245100e-01f, 5.03513590e-02f, -1.86511934e-01f, -2.24792570e-01f,
  -1.38399810e-01f, 2.28270814e-02f, 9.47144926e-02f, 1.10292904e-01f, 1.02100253e-01f, 1.17999054e-01f, 6.69205561e-02f, -3.61500457e-02f, 2.27305576e-01f, 9.18243751e-02f,
  -2.50465333e-01f, 6.00252189e-02f, 2.60247380e-01f, 2.83216257e-02f, 1.14612371e-01f, -1.18679740e-01f, -2.48262197e-01f, -1.71625927e-01f, 9.51741561e-02f, 1.67973861e-01f,
  9.85634997e-02f, 1.95748657e-01f, 5.66171892e-02f, -4.09603901e-02f, -3.52777898e-01f, -1.90193057e-01f, -1.50321975e-01f, -2.35059172e-01f, -3.88351351e-01f, -3.71923476e-01f,
  -1.05262123e-01f, -1.69387266e-01f, -2.21707731e-01f, -2.00102165e-01f, 1.19435571e-01f, 8.99430662e-02f, 1.58012286e-01f, 1.22659117e-01f, 3.08572464e-02f, 2.90462315e-01f,
  2.87195742e-01f, -9.11622960e-03f, 3.55601800e-03f, -5.89713901e-02f, 2.41262503e-02f, 1.18314363e-02f, -1.44836411e-01f, 1.80399697e-02f, -2.15548947e-02f, 5.35327755e-02f,
  3.73023599e-02f, 2.17508599e-02f, 6.21494651e-02f, 1.53804287e-01f, -8.04525837e-02f, 3.77707998e-03f, -9.08426046e-02f, -1.39431819e-01f, -2.17732117e-01f, -1.54959291e-01f,
  -1.83641955e-01f, -4.24951389e-02f, -9.48845521e-02f, -1.24822907e-01f, -6.62906691e-02f, -1.49476960e-01f, 1.80585999e-02f, -1.26667053e-01f, -4.90677617e-02f, 9.28817838e-02f,
  -5.64353243e-02f, 8.55839171e-04f, 4.24230881e-02f, -8.33902657e-02f, 2.35376768e-02f, 8.29569101e-02f, 2.02181488e-02f, -3.56969647e-02f, -6.21029027e-02f, 1.54704424e-02f,
  9.60118696e-02f, -2.46509518e-02f, 4.64316159e-02f, -1.04545012e-01f, -1.45301493e-02f, 4.21664193e-02f, -5.99394273e-03f, -1.57209877e-02f, 4.30535153e-02f, 1.56121284e-01f,
  -5.93875535e-02f, 3.91208865e-02f, 1.19937487e-01f, -4.46767434e-02f, 1.65121093e-01f, -2.10498106e-02f, -1.01311514e-02f, 2.95172837e-02f, -1.18659146e-01f, -9.65262391e-03f,
  4.58681136e-02f, -2.01650597e-02f, 2.37972245e-01f, -7.60730729e-02f, -1.55972093e-01f, 1.70945212e-01f, 7.77129307e-02f, -4.92433123e-02f, 2.11350899e-02f, -6.01236857e-02f,
  1.55325364e-02f, -1.62747502e-01f, 2.55729556e-02f, -9.13124755e-02f, -1.31692486e-02f, -8.93806443e-02f, -9.36615244e-02f, -8.22101608e-02f, -1.11125104e-01f, -7.06055909e-02f,
  -1.83182761e-01f, -1.29934371e-01f, -7.71250501e-02f, 2.49246731e-02f, -6.97964570e-04f, -7.09514841e-02f, 8.82027969e-02f, -9.87420902e-02f, -2.10362017e-01f, -3.07016987e-02f,
  -7.41591930e-01f, 3.68260220e-02f, 9.97548774e-02f, -2.26454198e-01f, 1.87042311e-01f, 3.45594049e-01f, 5.22652686e-01f, 2.24025417e-02f, -2.47596860e-01f, -7.34800240e-03f,
  3.12383454e-02f, -2.29811057e-01f, -2.13675514e-01f, -1.63159668e-01f, -1.35628553e-03f, 3.18006098e-01f, 2.93153733e-01f, -2.09739022e-02f, -8.13552886e-02f, 3.96543555e-02f,
  1.36990890e-01f, -1.74287796e-01f, -2.79483944e-01f, -8.40509310e-02f, 2.51149898e-03f, -3.00010405e-02f, -3.16486927e-03f, -1.65573619e-02f, 1.37277097e-01f, 2.20487535e-01f,
  -2.33014673e-01f, -3.18752348e-01f, 1.63163841e-01f, -1.67472899e-01f, -4.31620739e-02f, -1.66653171e-01f, -1.51006486e-02f, -2.11621657e-01f, -1.66771874e-01f, -9.58086103e-02f,
  -3.39404531e-02f, 1.40468292e-02f, 7.24293524e-03f, 6.35141283e-02f, -5.07854968e-02f, 1.05178945e-01f, 5.52296564e-02f, -1.06521145e-01f, -6.23535477e-02f, 1.13122880e-01f,
  2.90833414e-01f, 4.50228713e-02f, -3.17535192e-01f, 1.20692410e-01f, -6.68531135e-02f, -1.29558668e-01f, -4.53408286e-02f, 1.06783368e-01f, 8.06825608e-02f, -2.17730939e-01f,
  8.90603587e-02f, -2.87757181e-02f, 1.36747941e-01f, 5.80636114e-02f, -4.56971489e-02f, -8.43154937e-02f, 6.32987916e-03f, 5.51009811e-02f, -1.15580551e-01f, 3.88587005e-02f,
  4.91111763e-02f, 3.36075537e-02f, -6.96079209e-02f, 2.73753684e-02f, -6.56743571e-02f, -4.29800898e-02f, 1.22902118e-01f, -7.50356168e-02f, -1.67516526e-02f, -1.83141325e-02f,
  -4.01774347e-02f, -3.15080360e-02f, -3.17635797e-02f, 5.57801351e-02f, 5.28157316e-02f, 5.50358035e-02f, -5.31650633e-02f, 4.49132547e-02f, 1.15616368e-02f, -1.86904613e-02f,
  -3.07626188e-01f, 6.39461130e-02f, -2.27763638e-01f, -6.60509511e-04f, 2.21202876e-02f, -9.33775976e-02f, -2.78835595e-02f, -5.71781918e-02f, -9.09993723e-02f, 2.51036398e-02f,
  5.46457805e-02f, -1.26803428e-01f, -1.12860203e-01f, -1.17809614e-02f, 1.60411775e-01f, -1.24692380e-01f, -6.20265789e-02f, 5.47082815e-03f, 4.31026258e-02f, -1.20164566e-02f,
  3.52453664e-02f, 1.12922072e-01f, -2.67114788e-01f, -4.59552044e-03f, -6.88569993e-02f, -1.53963044e-01f, -1.63209572e-01f, -3.74370031e-02f, -8.70528072e-02f, -1.15705445e-01f,
  4.16783690e-01f, 2.10864574e-01f, 1.71182796e-01f, 2.61626542e-02f, -1.28253430e-01f, -2.99792916e-01f, -4.57809240e-01f, -3.50945592e-02f, 6.51348904e-02f, -7.54896849e-02f,
  -1.71215758e-01f, 1.32336421e-02f, 3.63703594e-02f, 6.28100559e-02f, 6.32261159e-03f, 6.39345422e-02f, 1.21373713e-01f, 1.75629705e-01f, -9.64985862e-02f, -1.07301891e-01f,
  -1.52506500e-01f, 5.93320131e-02f, 1.25693440e-01f, 8.06447864e-03f, 8.80091041e-02f, -5.40790558e-02f, -5.21695651e-02f, 4.40748185e-02f, -9.86193940e-02f, 2.66241223e-01f,
  1.35907099e-01f, 2.57014632e-01f, -2.58750260e-01f, 7.83982351e-02f, -4.05383296e-03f, 1.64524913e-01f, 4.77154106e-02f, 2.12530240e-01f, 3.01078577e-02f, -2.99327653e-02f,
  -2.20219661e-02f, 7.67715201e-02f, 1.35590866e-01f, 9.43471193e-02f, -7.43672401e-02f, -6.23577200e-02f, 1.52485892e-01f, 1.85586676e-01f, -3.32470350e-02f, -1.70004889e-02f,
  -7.71958008e-02f, -1.77973378e-02f, -1.82507768e-01f, -1.18925035e-01f, -3.02453563e-02f, -2.30246130e-02f, -1.51169270e-01f, 1.42782658e-01f, -9.23928693e-02f, 2.00381372e-02f,
  4.00510064e-04f, -7.73004144e-02f, 6.80724755e-02f, 1.21296279e-01f, 5.10642491e-02f, 3.35428864e-02f, -7.35486597e-02f, -1.24219887e-01f, -1.33512631e-01f, 3.64181176e-02f,
  6.86346665e-02f, -5.66193685e-02f, -6.27770834e-03f, 1.31396845e-01f, -7.90743232e-02f, 7.98302516e-02f, -1.36636972e-01f, -1.05616704e-01f, -1.04679547e-01f, 7.26449862e-02f,
  -7.61163235e-02f, -1.46019980e-01f, 4.39833738e-02f, 3.45403999e-02f, -1.00454949e-02f, -6.52047098e-02f, 1.08782314e-02f, -7.36631500e-03f, -9.00906324e-02f, 1.30067468e-01f,
  -5.98262325e-02f, -2.69200742e-01f, 1.28863423e-04f, -8.86733979e-02f, -8.60353112e-02f, -5.95645308e-02f, -3.71518396e-02f, -1.12121597e-01f, -5.94928898e-02f, -3.84083167e-02f,
  -4.44882177e-02f, -3.98309454e-02f, -1.97527111e-02f, -2.29022987e-02f, 4.06630076e-02f, -1.43472210e-01f, -2.23761722e-01f, -1.39482066e-01f, -9.11766216e-02f, 6.05744161e-02f,
  -1.92435116e-01f, -2.13522717e-01f, -1.48002729e-01f, -7.33673200e-02f, -8.41616467e-02f, -2.87666976e-01f, -2.48008028e-01f, -1.23096239e-02f, -3.60054404e-01f, -2.40633711e-01f,
  -1.44464299e-01f, -7.55683258e-02f, 4.30646911e-03f, -2.00960070e-01f, 6.38202652e-02f, -1.89490870e-01f, -7.45954365e-02f, -1.71779573e-01f, -7.50350654e-02f, -2.82407179e-02f,
  -1.47449121e-01f, 7.27441609e-02f, 2.10529283e-01f, 1.91023469e-01f, 1.95001036e-01f, 1.35973975e-01f, 3.56416166e-01f, 2.46769994e-01f, -2.99058780e-02f, -1.11419544e-01f,
  3.72925103e-02f, -1.09973745e-02f, -5.77280810e-03f, 3.27252373e-02f, -5.20967692e-02f, -8.52630939e-03f, 6.65000826e-02f, 3.20154168e-02f, 2.40243077e-02f, 3.08206081e-01f,
  -1.20621979e-01f, 4.65401337e-02f, 1.27321035e-01f, 4.94513568e-03f, -1.13852024e-02f, -6.31574020e-02f, 7.53977969e-02f, -3.36406566e-02f, -1.92994773e-02f, 5.98698594e-02f,
  1.27369002e-01f, -7.66657945e-03f, -4.95382473e-02f, -8.72365162e-02f, -1.58531845e-01f, -1.43488735e-01f, -8.46994370e-02f, 1.74485460e-01f, -1.57353908e-01f, -2.02236008e-02f,
  2.83842623e-01f, -4.69639078e-02f, -1.18503600e-01f, -2.41997167e-02f, -1.32916868e-01f, 1.00754388e-01f, -1.36713356e-01f, -8.02725106e-02f, -8.86306465e-02f, -8.59681815e-02f,
  5.27214967e-02f, -1.57695804e-02f, -1.01477347e-01f, 1.41214207e-01f, 3.48623693e-02f, -8.83952081e-02f, 1.79703832e-01f, 7.19827861e-02f, 1.26573637e-01f, 6.24658912e-02f,
  1.73523128e-01f, -7.06306249e-02f, -1.11634202e-01f, 1.64093092e-01f, 1.64334953e-01f, -4.45776293e-03f, -6.94047511e-02f, 5.14855608e-03f, -1.76177137e-02f, 1.00696176e-01f,
  3.89140621e-02f, 5.13760466e-03f, -5.12264632e-02f, 1.08816415e-01f, 1.50816083e-01f, -7.04131648e-02f, -1.01317406e-01f, 4.32500504e-02f, -9.48598422e-03f, 1.04488574e-01f,
  -2.99576402e-01f, 1.30184337e-01f, -1.28503799e-01f, -1.35930628e-01f, -7.85668287e-03f, -2.01532319e-02f, 2.59785244e-04f, -1.13585472e-01f, -6.56953305e-02f, -6.87347502e-02f,
  -1.42113879e-01f, -1.98475644e-02f, -3.84175703e-02f, -9.99495462e-02f, 1.93470120e-02f, 3.86931971e-02f, -6.05858229e-02f, -1.86486579e-02f, -2.18841378e-02f, 5.81670813e-02f,
  -3.57170962e-02f, -1.50774360e-01f, -2.15055570e-01f, -1.11345433e-01f, -1.91867754e-01f, -6.63957894e-02f, -6.16759397e-02f, -7.70008117e-02f, -2.23982692e-01f, -3.93892735e-01f,
  -1.97116837e-01f, -3.12277704e-01f, 1.65460527e-01f, 3.62743586e-01f, 4.01970357e-01f, 2.81580478e-01f, 1.20907545e-01f, 1.81355283e-01f, 2.73467869e-01f, 2.01801062e-01f,
  3.68910618e-02f, 1.65605143e-01f, 1.71215490e-01f, 1.24823503e-01f, 1.98664308e-01f, 2.22527400e-01f, 3.42829883e-01f, 6.59993589e-02f, 2.10594550e-01f, 2.27739111e-01f,
  2.61088490e-01f, 1.51307747e-01f, -4.22855956e-04f, 5.48022799e-02f, 1.44392669e-01f, 2.81093985e-01f, 3.35262865e-02f, -2.98654903e-02f, 8.85427669e-02f, 1.81474552e-01f,
  1.40122389e-02f, -2.22732902e-01f, 1.25489503e-01f, 9.51215625e-02f, -2.36838460e-01f, -1.64010078e-01f, 1.12558804e-01f, -7.32307807e-02f, -2.74081845e-02f, 4.57785837e-02f,
  -7.87249133e-02f, -1.82917118e-01f, 1.85241327e-02f, -7.59039745e-02f, -6.76888153e-02f, -6.26282999e-03f, -1.33862793e-01f, -7.38376305e-02f, 2.15683222e-01f, -6.54895082e-02f,
  -4.74249609e-02f, -2.63378443e-03f, 2.72392984e-02f, 1.23359449e-01f, -1.85332596e-02f, 9.66661051e-02f, -7.07028061e-02f, 2.76053715e-02f, 1.84301510e-02f, -1.56812817e-01f,
  2.26180449e-01f, -2.21845135e-02f, 6.35401532e-03f, 6.09690230e-03f, -9.11836028e-02f, -2.04116385e-02f, -9.96870920e-02f, -7.68332109e-02f, 9.18086097e-02f, -3.58315483e-02f,
  5.09685054e-02f, 2.48970687e-01f, 4.91434075e-02f, 4.81070355e-02f, 5.90057075e-02f, -3.86809632e-02f, -1.38454899e-01f, 1.87002192e-03f, -4.56067510e-02f, -1.60068534e-02f,
  7.87579194e-02f, 2.88954265e-02f, -1.90179721e-01f, -1.10380195e-01f, 7.80414268e-02f, 1.15460448e-01f, 6.31771237e-02f, -2.58271545e-02f, 1.84573606e-02f, 1.27162859e-01f,
  2.02658936e-01f, 1.01689190e-01f, 1.61240891e-01f, -2.07338650e-02f, -6.39944598e-02f, -2.50703603e-01f, 3.36895771e-02f, -1.47817819e-03f, -2.46870127e-02f, 1.25750437e-01f,
  -1.63294569e-01f, -1.08683176e-01f, -8.22812989e-02f, -6.36050627e-02f, -1.62318885e-01f, 4.87763289e-04f, -1.63929224e-01f, 9.91653949e-02f, -3.16010904e-03f, -1.77709688e-03f,
  -8.77808928e-02f, 3.23851686e-03f, 1.38725182e-02f, 6.03443906e-02f, 3.16574052e-02f, 1.11869350e-01f, -9.77276638e-02f, -6.01482354e-02f, -4.46776971e-02f, -1.36754774e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.89929721e-03f, 1.68300346e-01f, 1.15605272e-01f, 1.22563928e-01f, -1.18955642e-01f, 2.16752514e-01f, 1.44503519e-01f, 3.70219469e-01f, 4.81997699e-01f, 8.02199319e-02f,
  8.91754553e-02f, 9.24027935e-02f, 1.89864874e-01f, 3.68116014e-02f, 2.59995490e-01f, 1.23693965e-01f, 5.96893370e-01f, 4.92389053e-02f, -2.24239361e-02f, 2.17729107e-01f,
  4.30337697e-01f, 3.12355440e-02f, -7.28881434e-02f, 2.41393950e-02f, 1.21106304e-01f, -6.06846362e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.15210205e-01f, -3.44577152e-03f, 8.55443999e-03f, 2.78221779e-02f, 4.85526957e-02f, 1.00011483e-01f, -5.66442348e-02f, 3.77021283e-01f, -1.60290211e-01f, -2.55949914e-01f,
  1.09629758e-01f, 1.87378570e-01f, -2.40739554e-01f, -1.31613523e-01f, 1.34795969e-02f, 9.59457308e-02f, 2.17593148e-01f, 1.95640743e-01f, -2.28508189e-01f, -1.88798860e-01f,
  1.16355754e-01f, 3.42114240e-01f, 9.96491760e-02f, -2.15763018e-01f, 7.00430796e-02f, 6.12199940e-02f, -1.96763352e-02f, -1.31869584e-01f, 1.28262758e-01f, 7.67703727e-02f,
  2.01422662e-01f, 1.43032119e-01f, -7.77883455e-02f, -4.84294211e-03f, -2.03206971e-01f, -1.37434751e-01f, 7.72688687e-02f, 4.78821956e-02f, -4.68281150e-01f, -3.43806475e-01f,
  1.15625747e-01f, -1.29619062e-01f, -1.72358111e-01f, 3.11407708e-02f, 1.67942733e-01f, 1.34851232e-01f, 3.79107669e-02f, -4.27984521e-02f, -1.88150346e-01f, 2.73208618e-01f,
  -2.30159596e-01f, -1.90997928e-01f, 2.80593112e-02f, 3.68506521e-01f, 3.62914093e-02f, 1.56882033e-01f, 1.40086204e-01f, 3.53248894e-01f, 1.59137607e-01f, -2.04970166e-01f,
  3.16335410e-01f, -4.48454529e-01f, -1.21175356e-01f, 6.71734288e-02f, -7.67994523e-02f, 4.26880457e-02f, -5.41645363e-02f, 7.93432668e-02f, 1.35309830e-01f, 5.93063459e-02f,
  -5.16208887e-01f, -4.89730418e-01f, 2.29335219e-01f, -1.15898624e-01f, -2.36475542e-01f, 2.42475092e-01f, 9.53638107e-02f, 7.09592253e-02f, 5.12055717e-02f, -3.40336226e-02f,
  6.62771314e-02f, 1.07171096e-01f, -7.70431086e-02f, 1.10470399e-01f, 5.06399758e-02f, 2.09851250e-01f, -1.39725715e-01f, 3.91132772e-01f, -2.01191045e-02f, 1.83380425e-01f,
  1.40332863e-01f, -1.45185992e-01f, 4.67473239e-01f, -3.23167652e-01f, 5.39970323e-02f, 2.39964321e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.63180921e-02f, 1.13968953e-01f, 1.36772290e-01f, 6.68601785e-03f, -1.13428906e-01f, -1.65797267e-02f, 4.15319562e-01f, 4.90177989e-01f, -1.47946291e-02f, 2.66085654e-01f,
  1.22697689e-01f, -1.41358167e-01f, -4.56952527e-02f, 2.63252798e-02f, -1.55470893e-01f, 3.26039702e-01f, -6.10892065e-02f, 3.75613600e-01f, -3.35428327e-01f, 2.35133290e-01f,
  -1.99566588e-01f, -3.43273170e-02f, 2.99585760e-01f, -1.94389284e-01f, -1.86534733e-01f, -4.82903533e-02f, -3.83663535e-01f, 2.17077985e-01f, 2.71483392e-01f, -3.19687463e-02f,
  2.99537688e-01f, 8.17686468e-02f, 3.16629559e-01f, 1.61849752e-01f, 1.16754696e-01f, 7.75293261e-02f, -1.35989830e-01f, -1.79744121e-02f, -2.19744444e-01f, -7.82018006e-02f,
  6.60700817e-03f, -3.60877216e-01f, 9.00542438e-02f, 1.84029713e-01f, 1.37289062e-01f, 5.38021982e-01f, -1.95571661e-01f, -1.56895757e-01f, -1.92363188e-01f, 2.76807070e-01f,
  -2.80728508e-02f, 5.12061000e-01f, 3.14643867e-02f, -1.26432821e-01f, 1.03609063e-01f, 1.73769504e-01f, 2.32841134e-01f, -4.52066720e-01f, 2.80723721e-01f, -1.14094943e-01f,
  4.40770626e-01f, -3.74142557e-01f, 2.85013523e-02f, 2.95545399e-01f, 2.33287305e-01f, 5.84950224e-02f, 1.49927646e-01f, -8.55864435e-02f, 2.73462310e-02f, -2.31740490e-01f,
  8.89894143e-02f, 2.12086260e-01f, -1.39774039e-01f, -4.78994586e-02f, -1.15561351e-01f, -1.10266767e-01f, -6.34016916e-02f, 2.24370182e-01f, 1.30261511e-01f, 1.05112538e-01f,
  3.04071009e-01f, -1.70302346e-01f, 4.36070770e-01f, 2.06256464e-01f, -9.50366259e-02f, 9.37516689e-02f, -2.04172865e-01f, 1.51807427e-01f, 1.10008880e-01f, -1.33063003e-01f,
  -5.80086000e-02f, 1.46521628e-01f, -1.57813638e-01f, 2.68269032e-01f, 1.96351886e-01f, -2.55862355e-01f, 2.47714460e-01f, 1.89461797e-01f, 7.08955759e-03f, -2.07516760e-01f,
  2.89484337e-02f, 1.32856563e-01f, 5.73211014e-02f, 1.92021176e-01f, 8.60350654e-02f, -1.54347226e-01f, 6.15360253e-02f, 2.80293882e-01f, -2.95434613e-02f, 1.03470579e-01f,
  1.49603993e-01f, -1.96064353e-01f, -1.36446834e-01f, 2.60565609e-01f, -1.74039632e-01f, -1.65839985e-01f, 2.27679968e-01f, 5.52452095e-02f, 2.45353475e-01f, 1.39343470e-01f,
  -1.13046214e-01f, -9.93656889e-02f, 2.06180304e-01f, -1.97004646e-01f, 1.98928773e-01f, 1.62108511e-01f, 1.22142471e-01f, 3.40016276e-01f, -1.64285868e-01f, 2.05262884e-01f,
  4.67093401e-02f, -4.99170311e-02f, 5.40196300e-01f, 3.06975752e-01f, 1.10069603e-01f, -1.78458571e-01f, -1.95913866e-01f, -2.91728944e-01f, -1.84571132e-01f, -4.08889890e-01f,
  -2.91014254e-01f, 4.01823431e-01f, 2.40823347e-02f, 3.63726616e-02f, 5.96615411e-02f, 2.66827255e-01f, 2.12910607e-01f, -7.30807260e-02f, 2.37192154e-01f, 2.25658089e-01f,
  -5.25052488e-01f, -2.78057337e-01f, 3.14491212e-01f, 8.81227255e-02f, 4.01227832e-01f, -2.50695914e-01f, 1.91632256e-01f, 1.16102085e-01f, 9.23641212e-03f, -1.47650599e-01f,
  9.85981897e-02f, 1.84148580e-01f, 1.14211597e-01f, -1.20141096e-01f, -6.29098341e-02f, -2.41867170e-01f, 2.75892079e-01f, -1.05317131e-01f, 2.31347606e-01f, -8.77742469e-02f,
  -1.25801697e-01f, -3.18299174e-01f, -1.79574236e-01f, -2.22761199e-01f, 5.57066165e-02f, 2.37838805e-01f, 2.47250721e-01f, 2.19976798e-01f, 2.75568545e-01f, 3.15298617e-01f,
  -1.38104841e-01f, 1.96177408e-01f, -1.26005605e-01f, -2.93977112e-01f, 1.52520776e-01f, -8.33756849e-02f, -5.45891672e-02f, 2.72481829e-01f, 1.22450723e-03f, 2.30572343e-01f,
  2.20980614e-01f, -1.57580256e-01f, 2.17396751e-01f, 2.22051367e-01f, 3.07220519e-01f, 1.88520506e-01f, -8.89185965e-02f, 5.62860444e-03f, 1.72589824e-01f, -2.81084836e-01f,
  7.56848305e-02f, -1.78925004e-02f, 6.85942397e-02f, -2.19409913e-02f, 3.14017147e-01f, 6.20541424e-02f, -2.91831970e-01f, 2.20004708e-01f, -2.12135062e-01f, 8.05155188e-02f,
  5.27706385e-01f, 1.94154177e-02f, -1.69976383e-01f, 1.34338140e-01f, -2.14124024e-02f, 1.78306505e-01f, 4.19119820e-02f, 1.48510858e-02f, -1.76634043e-01f, 1.91655353e-01f,
  -1.42973587e-01f, -3.45062502e-02f, -1.65263578e-01f, -3.59718740e-01f, 8.04753080e-02f, 7.16758594e-02f, 1.43361136e-01f, 5.44384830e-02f, -8.70899856e-02f, 8.93493518e-02f,
  3.90922464e-02f, 1.63791329e-01f, 2.30578594e-02f, 1.48958474e-01f, -6.26531020e-02f, 3.04439217e-01f, 2.75391757e-01f, -2.89247751e-01f, 1.65394738e-01f, 1.48630977e-01f,
  1.71386488e-02f, 2.05915853e-01f, -6.00351512e-01f, -1.87206939e-01f, 3.44096035e-01f, -3.13246220e-01f, 6.19658865e-02f, 7.83216730e-02f, -9.11066383e-02f, 3.13025489e-02f,
  3.41848671e-01f, -1.55195832e-01f, 8.46139640e-02f, -2.10596278e-01f, -2.96875816e-02f, 7.60944486e-02f, 1.63397580e-01f, 2.57659316e-01f, 2.98255868e-02f, -1.84363350e-01f,
  5.60004078e-02f, -1.18906103e-01f, -3.19656909e-01f, -6.43344998e-01f, 3.78267109e-01f, -5.22367246e-02f, 1.27529815e-01f, 3.07430714e-01f, 2.86048263e-01f, -1.80013236e-02f,
  -3.88612092e-01f, 1.00128688e-01f, -2.13131458e-01f, -2.80662831e-02f, 3.36991012e-01f, 7.43154362e-02f, -1.79221570e-01f, -1.97801337e-01f, 3.53958964e-01f, 3.88311803e-01f,
  5.73922368e-03f, -1.73208296e-01f, 1.68371517e-02f, 7.78834149e-02f, 1.36697277e-01f, -2.27381617e-01f, 8.79832432e-02f, -1.77445695e-01f, 8.85344297e-02f, 1.50208786e-01f,
  2.30922222e-01f, -1.06242292e-01f, 6.56996220e-02f, -1.76471025e-01f, 3.25869799e-01f, 3.04939628e-01f, -3.33185196e-02f, 7.96089992e-02f, 1.48242205e-01f, -2.97775060e-01f,
  -1.46248639e-01f, 2.39571437e-01f, -6.73291981e-02f, -1.12700216e-01f, 7.81931803e-02f, 2.13902339e-01f, -6.67155385e-02f, 5.13442636e-01f, -5.24259806e-02f, -3.27411175e-01f,
  1.73863575e-01f, -2.92067915e-01f, 1.81954369e-01f, -1.11888042e-02f, -1.73683956e-01f, 4.47629653e-02f, 5.32466948e-01f, 5.14341183e-02f, 3.19252104e-01f, 2.14058921e-01f,
  -3.06710899e-02f, 2.87422001e-01f, 5.71044944e-02f, 3.91076691e-02f, 1.75416023e-01f, 3.93132567e-01f, -1.53417382e-02f, 9.91064459e-02f, 3.09634686e-01f, 1.36975080e-01f,
  1.84311569e-01f, 1.88104838e-01f, 1.03902295e-01f, 1.51530944e-03f, 1.05361352e-02f, 2.43465334e-01f, -2.41065428e-01f, 4.51288342e-01f, -7.01038301e-01f, 2.13583604e-01f,
  -2.72921752e-02f, -3.54058951e-01f, 3.03489953e-01f, 2.34916061e-01f, 9.87186804e-02f, 1.05004646e-01f, 9.95766278e-03f, -7.42697855e-03f, 4.47863668e-01f, -2.52716422e-01f,
  1.53613552e-01f, -4.14973684e-02f, 2.69773602e-01f, 1.47853032e-01f, 1.90509707e-01f, 8.93480852e-02f, -2.87586987e-01f, -3.52597274e-02f, 2.76121974e-01f, 2.94049233e-01f,
  -1.02716856e-01f, 2.90918529e-01f, 3.38551099e-03f, -1.52821526e-01f, -1.42869614e-02f, 1.33111283e-01f, 1.11070797e-01f, -7.28235990e-02f, 2.83880025e-01f, -2.14383677e-01f,
  2.57926732e-01f, 1.31460249e-01f, -1.38770059e-01f, -2.67599225e-02f, 1.08235545e-01f, 9.16745514e-02f, -6.79513440e-02f, -2.40925327e-02f, -1.28227696e-01f, 1.54253274e-01f,
  -5.04549861e-01f, 1.91210821e-01f, -7.95174986e-02f, -3.33185822e-01f, 1.46132097e-01f, 2.49630198e-01f, 1.60718590e-01f, 1.33460298e-01f, -4.26813543e-01f, -4.21234220e-01f,
  5.03087528e-02f, 1.15628503e-01f, -3.91979516e-02f, 3.61965775e-01f, -4.59748283e-02f, 1.19243532e-01f, 1.98555470e-01f, 1.61156178e-01f, 6.83065578e-02f, 2.98264593e-01f,
  -7.02171847e-02f, -8.90554935e-02f, 7.15215951e-02f, 1.00049615e-01f, -2.84710318e-01f, 6.96769059e-02f, 1.66215152e-01f, 1.08953804e-01f, -3.82055491e-01f, -2.34500244e-01f,
  -4.40470248e-01f, 3.45344633e-01f, -2.56783128e-01f, -3.97095531e-02f, 2.30052248e-02f, -1.12811830e-02f, -2.40357835e-02f, 2.76696205e-01f, 2.89181858e-01f, -2.83241749e-01f,
  2.02115387e-01f, 2.32758030e-01f, 2.87924170e-01f, 2.82709360e-01f, -2.17341661e-01f, 3.52370262e-01f, 2.05832068e-02f, -3.44116949e-02f, -1.47443146e-01f, -7.56535530e-02f,
  4.07047629e-01f, -1.59789890e-01f, 3.11261535e-01f, -5.39347790e-02f, -8.87778029e-02f, -1.73781589e-01f, 4.27945368e-02f, 2.28641629e-01f, -5.53619683e-01f, 2.70276636e-01f,
  -1.26158267e-01f, 5.43113705e-03f, 3.26684892e-01f, -2.42187530e-02f, -2.91162580e-01f, 2.73072571e-01f, 1.51463866e-01f, -2.06839651e-01f, 2.44934559e-01f, 1.65919393e-01f,
  6.25478029e-02f, -2.04160094e-01f, -5.49865030e-02f, -1.84429795e-01f, -3.15391958e-01f, -2.08420947e-01f, -1.21362120e-01f, 2.56624460e-01f, -1.93194076e-01f, -6.05108738e-01f,
  -2.19163582e-01f, 2.50894159e-01f, 1.87539309e-01f, 1.36582002e-01f, 2.44389623e-01f, 1.49010524e-01f, -1.20812707e-01f, 1.14566013e-02f, 9.39431340e-02f, 6.57466888e-01f,
  -4.41912591e-01f, -4.18124974e-01f, 2.27284804e-01f, 3.58572721e-01f, 2.79010087e-01f, 7.38935545e-02f, 3.56645823e-01f, -3.27214897e-01f, 7.08117262e-02f, -1.77072003e-01f,
  2.10268080e-01f, 1.16756178e-01f, 2.55697727e-01f, -1.62205175e-01f, 6.00864813e-02f, 5.53462468e-03f, 1.66565061e-01f, 1.44701108e-01f, 1.50553137e-01f, 3.33242446e-01f,
  4.87650558e-02f, -1.30397808e-02f, 6.74591213e-02f, -2.87290603e-01f, 1.97878480e-01f, 9.13828313e-02f, -1.04585975e-01f, 3.23525578e-01f, -3.51551563e-01f, -8.20986629e-02f,
  -1.81604996e-01f, 2.48173505e-01f, 1.31683201e-01f, -1.11558214e-01f, -1.57999367e-01f, 4.15483505e-01f, 1.71476245e-01f, 1.81413904e-01f, 5.08570345e-03f, -2.42748976e-01f,
  -5.54437973e-02f, -3.08404386e-01f, 2.48467475e-01f, 3.04147273e-01f, 2.26226896e-01f, 2.57981807e-01f, -2.48976678e-01f, -1.60702184e-01f, -3.11366975e-01f, 2.14265406e-01f,
  -1.72547698e-01f, -5.00239730e-01f, -6.15755804e-02f, 1.58827171e-01f, 1.21688895e-01f, 4.67865884e-01f, 2.20676541e-01f, -1.22780055e-01f, -2.04333544e-01f, -3.74053717e-01f,
  4.74950105e-01f, -1.35457411e-01f, -1.33112341e-01f, -2.33409498e-02f, -6.00810722e-02f, 2.20839068e-01f, -2.39683270e-01f, -3.12107414e-01f, 5.01933247e-02f, -1.27960950e-01f,
  -3.17846686e-01f, -4.13248271e-01f, -2.47063443e-01f, 1.51186824e-01f, 1.88518897e-01f, 3.20126504e-01f, 2.35004172e-01f, 4.57219072e-02f, 4.74060364e-02f, -1.17282785e-01f,
  -2.08443254e-01f, 6.47246763e-02f, 1.58299863e-01f, -5.07696196e-02f, -7.10767880e-02f, 3.01929921e-01f, 1.44683793e-01f, 1.04581593e-02f, 7.35737309e-02f, -1.83994398e-01f,
  1.66600943e-01f, 1.72855303e-01f, -3.49082053e-01f, -3.44514474e-02f, 3.33102196e-01f, -4.54376712e-02f, 1.87626168e-01f, 3.95429343e-01f, 1.84632123e-01f, 1.44351915e-01f,
  2.95193583e-01f, -3.10487539e-01f, 2.32753456e-01f, -5.29646501e-02f, 1.54427469e-01f, 2.27501877e-02f, 1.96309626e-01f, 3.40433538e-01f, 2.44699836e-01f, -1.02838062e-01f,
  1.51257530e-01f, -1.60723045e-01f, 2.46545821e-01f, 7.32659847e-02f, -7.44162500e-02f, -1.46404281e-01f, -1.15734413e-01f, -3.21282089e-01f, -8.59693512e-02f, 5.06672524e-02f,
  2.79628128e-01f, 2.06644565e-01f, -7.50794113e-02f, 1.28493488e-01f, 4.64260131e-01f, 2.63624609e-01f, -3.10190499e-01f, 2.99766481e-01f, 5.78908660e-02f, -2.42323071e-01f,
  -1.51867205e-02f, 1.76230535e-01f, 4.08520922e-02f, 2.31968477e-01f, 4.42998745e-02f, 1.40269697e-01f, 1.59146145e-01f, -3.27224076e-01f, -8.16936567e-02f, 1.43247284e-02f,
  -8.06345791e-02f, 1.06447697e-01f, -1.16754085e-01f, 4.71424349e-02f, -3.99449676e-01f, -1.81856841e-01f, 3.42457831e-01f, 7.71435872e-02f, 3.02854061e-01f, 4.84783709e-01f,
  1.08684942e-01f, -3.32179189e-01f, 5.71129024e-02f, -5.11517972e-02f, 3.76613960e-02f, -2.02098012e-01f, -3.02601546e-01f, -2.30464980e-01f, 2.90025234e-01f, -3.50313008e-01f,
  -3.85939069e-02f, 4.80082035e-01f, 3.79934460e-02f, 2.74808276e-02f, 8.00325871e-02f, 9.35005322e-02f, -2.03169242e-01f, 3.63492151e-03f, -8.45908653e-03f, 2.78639812e-02f,
  5.16435742e-01f, 1.08180463e-01f, 3.06692630e-01f, -7.48266354e-02f, -1.18595250e-01f, -4.62937742e-01f, -2.71880955e-01f, -2.28303716e-01f, -3.88632677e-02f, -4.68415290e-01f,
  -2.57138580e-01f, -4.49801475e-01f, 3.69344592e-01f, 6.34634733e-01f, -2.64716204e-02f, 4.86652814e-02f, -4.26582009e-01f, 2.14108601e-01f, -4.81148243e-01f, -1.42491028e-01f,
  4.27095126e-03f, -1.81739807e-01f, 4.51654553e-01f, -3.70279461e-01f, -1.94386989e-01f, -2.68431544e-01f, 3.80790889e-01f, 4.04407561e-01f, 1.96520537e-01f, -4.69389051e-01f,
  -1.08515397e-01f, 6.09286763e-02f, 2.65461892e-01f, 1.17132023e-01f, 3.10963243e-01f, -7.99832027e-03f, -1.58775702e-01f, 1.10235229e-01f, -2.08058298e-01f, -2.23938316e-01f,
  1.49986669e-01f, 1.92685172e-01f, -1.55663282e-01f, 2.92254150e-01f, 2.88626581e-01f, -1.15220301e-01f, 6.41814098e-02f, 2.55384326e-01f, 1.72515120e-02f, 2.37553105e-01f,
  -2.27231085e-01f, -1.01169862e-01f, 1.06727399e-01f, 8.94705430e-02f, 4.29758430e-01f, 3.40737134e-01f, 6.20865710e-02f, 1.57305881e-01f, 1.02927230e-01f, -1.03269026e-01f,
  1.72147125e-01f, 3.00182793e-02f, -1.23603225e-01f, 4.42901291e-02f, 1.66147396e-01f, -1.75246689e-02f, 2.42563024e-01f, 1.62094697e-01f, 1.32196352e-01f, 1.90958738e-01f,
  5.35634812e-03f, -3.33761126e-02f, 3.62608969e-01f, 3.60176593e-01f, 2.05936469e-02f, 2.41671383e-01f, 3.83006446e-02f, -1.52590856e-01f, 2.70911567e-02f, 3.39751869e-01f,
  -2.88666356e-02f, 7.75269568e-02f, -5.85888803e-01f, 2.28781462e-01f, -1.77121367e-02f, -3.23085129e-01f, 2.25677878e-01f, 3.63203615e-01f, -7.47071998e-03f, 2.02785671e-01f,
  -1.67747047e-02f, -1.69080064e-01f, 1.63410053e-01f, -6.79101720e-02f, 2.04529017e-01f, 2.19237909e-01f, 3.06244165e-01f, 2.99932924e-03f, 8.90154764e-02f, -3.74410339e-02f,
  1.36444852e-01f, 2.66913652e-01f, 1.00317165e-01f, -1.88173771e-01f, -1.44198552e-01f, -3.95489812e-01f, 2.05090232e-02f, 4.54111308e-01f, 5.98910935e-02f, 1.28963470e-01f,
  1.97372973e-01f, -4.00247872e-02f, 1.52070731e-01f, -1.00844435e-01f, 2.02020004e-01f, 3.50178219e-02f, 3.30525845e-01f, -1.08221337e-01f, -1.43207625e-01f, 3.21534187e-01f,
  2.16028869e-01f, 5.61008975e-02f, 1.87696472e-01f, -3.98015678e-01f, 4.15053293e-02f, 1.91655993e-01f, -8.60925317e-02f, 1.35338917e-01f, 1.40479416e-01f, 1.69992939e-01f,
  2.51590014e-01f, -1.50187805e-01f, 2.08824813e-01f, -8.38159677e-03f, 1.73950031e-01f, 1.48832738e-01f, 3.44373494e-01f, 9.92446691e-02f, -4.16591465e-02f, -1.31278470e-01f,
  -7.19912648e-02f, -3.24746281e-01f, 2.24654526e-01f, 1.62334800e-01f, 2.64283210e-01f, 5.05576849e-01f, -2.95077235e-01f, 2.04184607e-01f, 8.36518481e-02f, 6.87943175e-02f,
  2.25066423e-01f, -8.68512690e-02f, 2.42699310e-01f, 4.65229392e-01f, -8.03329721e-02f, 5.09300008e-02f, 1.44744411e-01f, -5.03197387e-02f, 2.75181204e-01f, -2.53208339e-01f,
  -1.17714569e-01f, 2.30783358e-01f, 1.43447116e-01f, -9.40123722e-02f, 3.57922092e-02f, 2.71555841e-01f, 3.71289998e-02f, -9.39228833e-02f, 2.00942993e-01f, -5.60968101e-01f,
  1.35657445e-01f, 2.97314793e-01f, 1.28439501e-01f, 1.08336136e-01f, 1.64533243e-01f, 1.11691043e-01f, 2.95658469e-01f, -5.24852797e-02f, 6.16468906e-01f, -3.28749478e-01f,
  -2.27161825e-01f, 1.84076011e-01f, -3.09403986e-01f, 1.75330773e-01f, 1.11986227e-01f, -6.11486379e-03f, -7.80835599e-02f, -1.54845104e-01f, -3.37975323e-01f, 2.91751981e-01f,
  -7.74908736e-02f, -1.61536679e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.35911284e-02f, 2.10672945e-01f, 3.83067608e-01f, 9.93127897e-02f, -4.11703810e-02f, 1.11679122e-01f, 3.70409787e-01f, -9.00847614e-02f, 2.77804613e-01f, -7.96347260e-02f,
  -7.64586776e-02f, 3.35727274e-01f, 4.79544103e-01f, 2.68364042e-01f, 1.88622907e-01f, 1.43718183e-01f, 3.06455374e-01f, -8.46684352e-02f, 4.54057217e-01f, -1.26945287e-01f,
  1.67917624e-01f, 2.29639456e-01f, -1.30860373e-01f, -1.54198021e-01f, 1.37780011e-01f, 7.40961656e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  8.37158784e-02f, -1.47971466e-01f, 1.34817243e-01f, -1.94132745e-01f, 4.21467066e-01f, -8.49125311e-02f, 1.18490420e-01f, 1.52146429e-01f, -8.16092417e-02f, -2.56805606e-02f,
  3.06926876e-01f, -8.09630305e-02f, -1.62132517e-01f, 1.33737773e-01f, 1.30811080e-01f, 1.28181636e-01f, -1.19625837e-01f, 7.50495344e-02f, -1.51360650e-02f, 1.11716226e-01f,
  3.24057102e-01f, 1.51621848e-01f, -1.81643695e-01f, -4.79809679e-02f, -8.23400095e-02f, -2.26413727e-01f, 5.65039933e-01f, -5.43028042e-02f, -1.14962816e-01f, -1.51174203e-01f,
  -8.27370882e-02f, -3.12363178e-01f, 5.50980449e-01f, -3.07315476e-02f, -1.35189280e-01f, -3.79412234e-01f, 2.30697155e-01f, 6.84927180e-02f, -5.96619509e-02f, 7.30859563e-02f,
  -6.47484139e-02f, 3.15593630e-02f, -6.26094192e-02f, -8.12208354e-02f, -7.05941319e-02f, -1.33219659e-01f, 1.75854594e-01f, -8.01812857e-02f, 1.39577329e-01f, -2.26808473e-01f,
  3.77294756e-02f, -1.86156541e-01f, -8.18919465e-02f, -1.38812706e-01f, 2.95627892e-01f, 1.06528267e-01f, -6.79207817e-02f, 1.28944501e-01f, 2.09178284e-01f, 2.21425563e-01f,
  2.79598553e-02f, 1.72262952e-01f, -7.62370378e-02f, -1.25409290e-01f, 1.70755908e-01f, 6.79609850e-02f, -3.22399110e-01f, -8.61143172e-02f, 1.15623511e-01f, 2.75483519e-01f,
  -1.58049315e-02f, -1.97729212e-03f, -1.09790444e-01f, 1.18601263e-01f, -2.61538088e-01f, -2.71840334e-01f, 2.92489696e-02f, 2.06036627e-01f, -8.69622603e-02f, 1.61625355e-01f,
  -3.90798450e-02f, 2.60771834e-03f, 1.11329161e-01f, 1.12853266e-01f, -1.36107992e-04f, 6.06210716e-02f, 8.70016813e-02f, 1.39323309e-01f, -1.70086995e-01f, 4.27019686e-01f,
  -1.13781072e-01f, 1.73422262e-01f, 2.46759057e-02f, 5.14877513e-02f, -2.89124876e-01f, -6.16072938e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.16030443e-01f, -2.90486097e-01f, 8.96884594e-03f, 2.52303034e-02f, 2.18337610e-01f, 6.36120796e-01f, 1.23154886e-01f, -4.52314354e-02f, -1.23744540e-01f, -3.44742984e-02f,
  -1.89578027e-01f, -1.54414266e-01f, -5.00025004e-02f, 2.35159412e-01f, 2.75695592e-01f, -2.79212445e-01f, 3.10549021e-01f, 1.26125172e-01f, 1.60061255e-01f, -9.28624943e-02f,
  -6.79618344e-02f, 1.89943910e-01f, -3.31173867e-01f, 4.73439582e-02f, -3.40668023e-01f, 1.77242741e-01f, -1.21912323e-01f, 3.06844860e-01f, 2.91037261e-01f, -1.74496263e-01f,
  2.90034898e-02f, -1.31459773e-01f, 4.55549628e-01f, -2.35387728e-01f, 3.35389793e-01f, -4.37483430e-01f, -9.63505432e-02f, -4.59823817e-01f, -8.23405944e-03f, 1.08724579e-01f,
  2.18030900e-01f, 2.51780719e-01f, -1.37659401e-01f, -3.90875749e-02f, -4.42454219e-01f, 4.57823798e-02f, -4.32109505e-01f, 3.54651302e-01f, -9.44191590e-02f, 3.81490067e-02f,
  5.32443263e-02f, 3.05691630e-01f, -3.77417244e-02f, -2.49826327e-01f, -2.39518024e-02f, 1.29976362e-01f, -1.65028170e-01f, 2.85377473e-01f, -4.02924567e-02f, -3.34592640e-01f,
  3.83954972e-01f, 2.21187472e-01f, 3.73557284e-02f, -1.02073774e-01f, 3.42763603e-01f, 9.39585343e-02f, 3.96288574e-01f, -1.03455983e-01f, -8.64077330e-01f, -3.85054439e-01f,
  2.66422424e-02f, 1.98665559e-01f, 5.71041167e-01f, -1.50082082e-01f, 1.07115945e-02f, 2.30564937e-01f, 9.20585468e-02f, -2.74540246e-01f, 4.22041165e-03f, 1.41756475e-01f,
  -1.18782297e-01f, 1.13369681e-01f, 2.83112943e-01f, -1.00310996e-01f, 1.82494167e-02f, -1.36734247e-01f, 2.19874345e-02f, -7.10064592e-03f, 1.28035054e-01f, -1.20328866e-01f,
  -3.16217601e-01f, -2.25359529e-01f, 1.09867901e-01f, 9.41184387e-02f, 3.39552239e-02f, 2.04626992e-01f, 6.07270077e-02f, 7.15627611e-01f, 3.03399265e-01f, 4.22243744e-01f,
  -6.95142808e-05f, 1.73521787e-01f, -1.18164994e-01f, 6.25075519e-01f, 2.73035377e-01f, 3.12999398e-01f, 1.75132170e-01f, -2.51619564e-03f, -1.24236710e-01f, 2.07697581e-02f,
  1.52975664e-01f, 3.42120349e-01f, -2.58525740e-02f, -7.28375539e-02f, -1.31291255e-01f, -6.26616478e-02f, 1.67546257e-01f, -2.72791028e-01f, 3.36891025e-01f, 1.20489068e-01f,
  2.17289537e-01f, -2.13372439e-01f, 5.08751631e-01f, -1.24260589e-01f, 1.28428876e-01f, 1.38739541e-01f, -1.48529634e-01f, 2.91746892e-02f, 6.12823032e-02f, 1.50762081e-01f,
  4.11690958e-03f, 5.94457626e-01f, 3.00375164e-01f, 1.63326502e-01f, -2.80784126e-02f, 1.03525229e-01f, -1.17556266e-01f, 1.78867131e-01f, 7.46569317e-03f, -5.83300814e-02f,
  -6.49287552e-02f, 2.99886316e-01f, -8.87392461e-02f, 1.08690955e-01f, 4.14288938e-01f, -2.49424372e-02f, -3.25919688e-02f, -9.06858668e-02f, 3.05196792e-01f, 2.24977404e-01f,
  -3.17685962e-01f, 2.59145021e-01f, -1.01953216e-01f, 1.82768837e-01f, -5.60511053e-02f, -3.35975364e-02f, 2.12323725e-01f, 8.32630321e-02f, 1.12700507e-01f, -5.72966695e-01f,
  3.86794448e-01f, 3.71887372e-03f, 4.47559446e-01f, 4.46173102e-02f, -4.22031939e-01f, -5.05073547e-01f, 3.28424275e-01f, -2.07349546e-02f, 2.26984560e-01f, 2.47706965e-01f,
  3.51436846e-02f, 2.80072063e-01f, -2.32397422e-01f, -1.72358789e-02f, -3.00937235e-01f, 4.26445752e-01f, 3.73887718e-02f, 1.36469153e-03f, 1.38302580e-01f, -2.40636319e-02f,
  -1.95683300e-01f, 1.72425911e-01f, 2.32032582e-01f, -1.45460740e-01f, 3.32258165e-01f, -3.27306896e-01f, 2.63826977e-02f, -9.98206288e-02f, 1.34545729e-01f, 1.26486346e-01f,
  -2.36317422e-02f, -3.08912516e-01f, 9.41141322e-02f, -2.82480210e-01f, 1.42756775e-01f, -1.18354313e-01f, 3.52688849e-01f, 7.80145600e-02f, -1.59561276e-01f, -4.76600766e-01f,
  3.55402261e-01f, -1.16556406e-01f, 1.17916152e-01f, 3.23489428e-01f, -3.48250598e-01f, -2.71195382e-01f, -2.48006701e-01f, -2.30676204e-01f, -6.67297423e-01f, 3.31964009e-02f,
  -1.48973867e-01f, 3.54703218e-01f, 1.48935303e-01f, -9.29533876e-03f, -3.35136294e-01f, -5.61638325e-02f, 3.10026556e-01f, -2.15899557e-01f, -1.99114650e-01f, -1.19214565e-01f,
  -2.45301530e-01f, 4.50273417e-02f, 2.33991027e-01f, 2.48416483e-01f, -1.11047775e-01f, -4.35359448e-01f, -1.76435679e-01f, 1.81635171e-01f, -3.02368104e-01f, -1.80170298e-01f,
  -4.32032317e-01f, -4.77673113e-01f, 2.53142059e-01f, -2.33918145e-01f, 3.37526202e-01f, 1.65600002e-01f, -9.93935391e-02f, 5.21369698e-03f, -1.96739286e-01f, -1.79166362e-01f,
  -4.37265188e-01f, 1.30329579e-01f, 2.74852123e-02f, -2.13329252e-02f, 1.90635383e-01f, 3.86010669e-02f, 2.21760105e-02f, -1.04635373e-01f, 3.21655273e-01f, -4.24847513e-01f,
  1.06759757e-01f, -5.69243096e-02f, -1.77781284e-02f, 5.54205142e-02f, 1.59313884e-02f, 3.55715066e-01f, 3.36476266e-01f, 1.46352172e-01f, 3.16344589e-01f, -4.06002775e-02f,
  7.67845148e-03f, -4.33118463e-01f, 8.48754644e-02f, 2.78754719e-02f, 1.87874902e-02f, -1.72332942e-01f, -2.64447778e-01f, 1.01668470e-01f, 3.79675061e-01f, -2.61415213e-01f,
  3.03580731e-01f, -1.23954885e-01f, -1.12460598e-01f, 2.81568617e-01f, 3.92264187e-01f, -1.46232560e-01f, 3.41394655e-02f, 3.82163003e-02f, 4.87217074e-03f, -1.98168382e-01f,
  2.83233315e-01f, 2.01960038e-02f, 4.68931288e-01f, 1.29686715e-02f, -1.07837319e-01f, -3.74972433e-01f, -4.87536527e-02f, -3.09948504e-01f, -4.83126519e-03f, 2.12372452e-01f,
  5.05766213e-01f, -2.08023205e-01f, 4.26730841e-01f, 3.73448610e-01f, -3.04279506e-01f, -5.95395789e-02f, 2.25098342e-01f, 2.57899791e-01f, 3.67313862e-01f, -7.09341392e-02f,
  1.93501204e-01f, -2.55171861e-02f, 1.71834677e-01f, -2.64733166e-01f, -4.23144788e-01f, 3.01872164e-01f, -1.01603158e-01f, 4.10440952e-01f, 2.21304104e-01f, 2.59061344e-02f,
  6.26635015e-01f, 2.24442314e-02f, 1.18012793e-01f, -1.33013539e-02f, 1.46196291e-01f, 8.56192484e-02f, -1.89967856e-01f, 2.75225013e-01f, 3.18528302e-02f, 3.81987810e-01f,
  2.30829298e-01f, -1.14219740e-01f, 3.00657004e-01f, -1.32467195e-01f, 1.56435013e-01f, -3.73305768e-01f, 2.27441549e-01f, 6.58451691e-02f, 1.44249484e-01f, 1.76687986e-01f,
  -3.98314208e-01f, -1.77867875e-01f, 1.45987853e-01f, 1.60026059e-01f, -1.25191048e-01f, -1.46731511e-01f, -1.28607124e-01f, 2.62025416e-01f, 2.47441947e-01f, 2.19418973e-01f,
  -6.42469078e-02f, 2.70349950e-01f, 2.28514850e-01f, 1.42662719e-01f, 1.17359832e-01f, -4.18403566e-01f, 5.48695147e-01f, 5.66034541e-02f, -8.20033997e-02f, -2.38209039e-01f,
  6.43453822e-02f, -4.93858218e-01f, -1.99220508e-01f, 6.80439323e-02f, -2.76512772e-01f, 3.08311731e-01f, -7.78230354e-02f, 2.34749407e-01f, 1.60056504e-03f, -2.27983445e-01f,
  -2.70753264e-01f, -6.48176372e-02f, -3.24898511e-01f, 6.75613359e-02f, 9.80727077e-02f, 2.17474595e-01f, 2.59690851e-01f, -3.28774229e-02f, 3.07669133e-01f, 9.46689919e-02f,
  3.41533087e-02f, -1.17927074e-01f, -6.46305904e-02f, 2.53270119e-01f, -2.62984604e-01f, 2.31897995e-01f, -3.46669592e-02f, 2.42159650e-01f, -1.84878081e-01f, 2.10591778e-01f,
  8.72634873e-02f, -3.90067399e-02f, 3.83920431e-01f, -1.04209453e-01f, 2.45978191e-01f, -1.75919041e-01f, -9.79636908e-02f, -7.73302233e-03f, 7.44887069e-02f, 1.05020583e-01f,
  8.46847519e-02f, 2.80640632e-01f, 3.06896977e-02f, -1.21186018e-01f, 1.94182336e-01f, 2.85573483e-01f, -1.82862237e-01f, -3.08065653e-01f, 1.26616275e-02f, 3.68610650e-01f,
  -4.10498679e-02f, -9.91120860e-02f, -1.25107408e-01f, 1.05886929e-01f, 1.85179874e-01f, 6.83785304e-02f, -5.01843154e-01f, -7.29574859e-02f, 1.47370324e-01f, -6.24483287e-01f,
  1.39885157e-01f, 3.47837992e-02f, -1.98962167e-01f, -8.95299464e-02f, 2.78315097e-01f, -5.03318831e-02f, 1.35799676e-01f, -4.93313484e-02f, 2.76341885e-01f, 2.42334411e-01f,
  -2.49095991e-01f, -4.32726145e-01f, 3.22730392e-01f, -4.61366743e-01f, 2.52944559e-01f, -1.64729401e-01f, -1.16343684e-01f, 1.69633821e-01f, 4.22352739e-02f, 1.01744384e-01f,
  4.67550717e-02f, -9.21709910e-02f, 3.34701166e-02f, 3.02306145e-01f, 2.75716156e-01f, 8.94455146e-03f, 1.55152619e-01f, 3.59048635e-01f, -2.07566097e-01f, -2.01785848e-01f,
  3.46060425e-01f, -2.55391002e-01f, 1.70298833e-02f, 1.73800319e-01f, 6.79207668e-02f, -2.21372485e-01f, 1.97878510e-01f, -4.26679924e-02f, -2.05480039e-01f, 2.27332190e-01f,
  2.24621579e-01f, 5.31587079e-02f, 7.65986800e-01f, 7.99528301e-01f, -3.50009024e-01f, 2.52671689e-02f, -4.88734096e-02f, -3.98436897e-02f, 1.21492818e-01f, 4.82632816e-02f,
  2.45261893e-01f, 3.79250273e-02f, 2.37685785e-01f, -1.73832625e-01f, -1.39241278e-01f, -1.76767007e-01f, -1.14970645e-02f, -1.00053318e-01f, 4.92438346e-01f, -5.00849746e-02f,
  -1.43868834e-01f, 3.31733197e-01f, 7.09383786e-02f, 1.50008053e-01f, -2.45262519e-01f, 2.50934094e-01f, 2.17059419e-01f, 2.69668877e-01f, 2.34109774e-01f, -1.03051364e-02f,
  5.47177613e-01f, -3.04283071e-02f, 1.87417120e-01f, 1.62553117e-01f, 3.60370815e-01f, 2.48585746e-01f, 2.57791281e-01f, 3.31808209e-01f, 4.47357103e-04f, -1.21143525e-02f,
  2.52505541e-01f, 3.10011767e-02f, -1.41476944e-01f, 1.60508424e-01f, -2.12418392e-01f, 3.99292529e-01f, 1.60573125e-01f, -5.20773232e-02f, 2.07555279e-01f, 1.77302316e-01f,
  1.98024407e-01f, -1.54754091e-02f, -2.38993391e-01f, 2.10274041e-01f, 1.33361191e-01f, -2.58041382e-01f, 3.90861958e-01f, 5.55032194e-02f, -1.09942950e-01f, -1.25077918e-01f,
  2.12501422e-01f, -9.27808940e-01f, 2.81539470e-01f, 2.12207526e-01f, 1.63428366e-01f, 1.93157736e-02f, 5.82548082e-01f, 4.49052930e-01f, -8.90197232e-02f, 2.66086668e-01f,
  4.52214479e-02f, 1.90089509e-01f, 4.05734539e-01f, 6.52026460e-02f, -2.11286575e-01f, 9.04205367e-02f, 7.17775747e-02f, 2.30723411e-01f, 7.00228140e-02f, -3.39973837e-01f,
  -1.92834556e-01f, 1.69737097e-02f, 1.56867638e-01f, -1.26312464e-01f, 2.96509504e-01f, 1.20796256e-01f, 1.16049163e-01f, -2.67613292e-01f, 7.35958517e-01f, 1.68091014e-01f,
  -1.79193571e-01f, 1.45063728e-01f, -1.47346854e-02f, -1.80338606e-01f, -3.86503376e-02f, -4.75587398e-02f, 3.16722505e-02f, 2.83931971e-01f, -3.85483772e-01f, -4.42549944e-01f,
  2.75690466e-01f, -8.04887041e-02f, 2.84879953e-01f, 1.73689082e-01f, 1.08610570e-01f, 1.61613058e-02f, -4.19664592e-01f, -5.07572144e-02f, -4.36155558e-01f, 3.01214218e-01f,
  -1.49559528e-01f, 3.64161581e-01f, -1.62960052e-01f, 2.38379046e-01f, -1.29004464e-01f, -2.19716448e-02f, -2.92565167e-01f, 1.04532130e-01f, 4.02571447e-02f, 1.06263578e-01f,
  -2.43360713e-01f, -2.74977386e-01f, 6.06723409e-03f, 9.31430236e-02f, 2.04554006e-01f, 1.98321361e-02f, 2.59330660e-01f, 2.22582832e-01f, 1.94499284e-01f, -1.08468741e-01f,
  5.08228123e-01f, 3.29281837e-01f, 2.60597914e-02f, -2.01831222e-01f, -6.65944219e-02f, 9.53398719e-02f, 1.01492954e-02f, 1.36076629e-01f, 4.09587771e-01f, -4.34811749e-02f,
  1.04219325e-01f, -4.77890462e-01f, 1.04731858e-01f, 9.10316557e-02f, 1.96570799e-01f, -1.13294423e-01f, 1.73671037e-01f, 2.31560051e-01f, 2.58701265e-01f, -6.83418214e-02f,
  2.62826264e-01f, -1.89183861e-01f, 1.20789856e-01f, 3.64328951e-01f, -2.64044162e-02f, -1.65456682e-01f, 8.15637261e-02f, -2.85661817e-02f, 4.47501801e-02f, 1.65070653e-01f,
  3.27704996e-01f, -5.79273582e-01f, 3.76307458e-01f, 5.35354614e-01f, -1.68866694e-01f, 1.69430837e-01f, -1.06368139e-01f, 1.34392664e-01f, 8.43463764e-02f, 1.12328902e-01f,
  3.95508945e-01f, -1.57811806e-01f, 3.09907198e-01f, -2.18726635e-01f, -2.26578534e-01f, 2.26656385e-02f, 3.40678036e-01f, -1.92964911e-01f, -3.88662331e-02f, -1.25740051e-01f,
  6.35745764e-01f, 1.89531177e-01f, 3.09643187e-02f, -3.28734815e-01f, 4.74124640e-01f, 3.42410803e-01f, 1.48942573e-02f, 1.29489720e-01f, -3.68769560e-03f, 1.40920952e-01f,
  1.23367392e-01f, -9.50157344e-02f, 8.33166465e-02f, 4.77532208e-01f, 3.00769538e-01f, 2.68951245e-03f, 1.25559464e-01f, -3.67838591e-02f, 4.59345169e-02f, -5.88164665e-02f,
  8.73996317e-03f, 5.54738678e-02f, -1.55302137e-01f, 1.51586728e-02f, -2.87443697e-01f, -1.41699910e-01f, -4.13119346e-02f, -4.58364226e-02f, -3.24235521e-02f, 3.74988526e-01f,
  1.57763541e-01f, 3.45211536e-01f, -2.39605680e-01f, -1.61948934e-01f, 2.75308967e-01f, -2.46433213e-01f, 2.95628160e-01f, 1.64112389e-01f, -8.11311454e-02f, -2.24039584e-01f,
  1.35441631e-01f, -1.46957353e-01f, 5.58862925e-01f, 6.39474541e-02f, 3.71606112e-01f, -2.96299994e-01f, -2.19231695e-01f, -4.73415792e-01f, 4.04309124e-01f, -1.92424148e-01f,
  1.59856901e-01f, -1.71648040e-01f, -4.18073893e-01f, 2.27025554e-01f, 3.18115234e-01f, 8.60815272e-02f, 7.03797862e-02f, 1.40395418e-01f, 6.83673769e-02f, 1.36241810e-02f,
  2.40493149e-01f, -3.49581204e-02f, -2.62558430e-01f, 2.14400440e-01f, -9.12293345e-02f, -1.54188499e-01f, 1.92548066e-01f, -4.24682915e-01f, 3.33691120e-01f, 1.71865195e-01f,
  2.49404281e-01f, -3.16248119e-01f, 2.36710072e-01f, -5.76916218e-01f, -2.22606659e-01f, 1.05836540e-01f, 1.91894751e-02f, 4.40833956e-01f, 3.94579489e-03f, 1.30336672e-01f,
  4.57276970e-01f, 1.91903397e-01f, -3.55479866e-01f, 2.29344890e-01f, -1.45298064e-01f, 1.47679254e-01f, 9.09295976e-02f, -4.01141718e-02f, 2.31474668e-01f, 4.02114391e-01f,
  5.18907249e-01f, -2.45628536e-01f, 1.14252217e-01f, -3.39684099e-01f, -2.52782200e-02f, 1.23165086e-01f, -4.76368755e-01f, 2.57854193e-01f, 7.75814280e-02f, 1.64706513e-01f,
  -4.84039076e-02f, 1.78692713e-01f, 4.95920807e-01f, -9.46784988e-02f, 3.30089003e-01f, -3.40540439e-01f, 1.57697573e-01f, 1.76866472e-01f, 9.80381444e-02f, 6.21523559e-02f,
  3.34581882e-01f, 3.28838229e-01f, -4.36264306e-01f, 2.38783762e-01f, -6.06531017e-02f, 6.83021843e-02f, 1.00948513e-01f, -1.97313741e-01f, 1.05799384e-01f, 2.39029005e-01f,
  2.63502717e-01f, -1.94745913e-01f, 1.64740775e-02f, -1.29138142e-01f, -4.34488431e-02f, 1.37079403e-01f, 2.19377592e-01f, 4.87732142e-02f, 5.05949080e-01f, 3.05593878e-01f,
  -2.61393756e-01f, 1.45456344e-01f, -1.39105231e-01f, 3.77946794e-02f, 9.20327306e-02f, 1.21792935e-01f, 2.72618700e-02f, -6.83474690e-02f, -1.85762003e-01f, -1.92443341e-01f,
  -1.63584679e-01f, 5.10981560e-01f, -1.87178954e-01f, 1.15558458e-03f, 1.18490070e-01f, -3.09442073e-01f, -2.93916345e-01f, 1.39236152e-01f, -1.36577949e-01f, -8.30204934e-02f,
  2.43629619e-01f, 3.82327110e-01f, 1.99142098e-01f, -2.02370286e-01f, 1.25786245e-01f, 7.28029236e-02f, 3.64807308e-01f, 2.76106417e-01f, -3.40259857e-02f, 4.38900232e-01f,
  -1.74255550e-01f, 1.78067058e-01f, -7.12822825e-02f, 1.78057611e-01f, 8.78830478e-02f, 2.89961904e-01f, 1.14467829e-01f, -5.84135503e-02f, 2.68935382e-01f, -1.88076571e-01f,
  3.62362921e-01f, 4.91601884e-01f, 2.22573981e-01f, -3.07412088e-01f, -4.41236645e-01f, -4.09727514e-01f, -1.25968099e-01f, 7.59527311e-02f, 1.74574316e-01f, -2.28932753e-01f,
  -3.29981983e-01f, 2.04981968e-01f, 4.82041746e-01f, -3.18384290e-01f, 3.75322640e-01f, -1.61082938e-01f, -9.39688608e-02f, 3.28052968e-01f, 3.14949661e-01f, -1.46686539e-01f,
  -3.36963803e-01f, 5.28783500e-02f, 4.09339815e-01f, -1.56455666e-01f, 3.03213626e-01f, 8.17340706e-03f, 2.07746089e-01f, 2.15627745e-01f, 2.70905737e-02f, -2.85921812e-01f,
  -1.25228956e-01f, -7.48407887e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -8.08527097e-02f, 1.36468709e-01f, 3.79910529e-01f, 2.64158905e-01f, 1.14386603e-02f, 9.68542397e-02f, -3.07216607e-02f, 1.72722891e-01f, 2.87844390e-01f, 2.89299339e-01f,
  1.26278505e-01f, 1.15821600e-01f, -1.69540569e-01f, 4.43965495e-01f, -1.29082231e-02f, 1.39528036e-01f, -3.71696800e-02f, -6.81848675e-02f, 3.11632127e-01f, 1.85668524e-02f,
  2.16934942e-02f, 1.57639697e-01f, -1.97510287e-01f, 2.30749533e-01f, 2.93275923e-01f, 4.19851035e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.84926216e-02f, -1.45092905e-01f, 2.06594229e-01f, 2.43876547e-01f, -9.49338302e-02f, -6.03883505e-01f, -3.07347745e-01f, -3.93073484e-02f, -8.24282765e-02f, 1.43190548e-01f,
  -8.00122097e-02f, 3.05132747e-01f, -5.70288338e-02f, -7.10126981e-02f, 1.56492680e-01f, 9.74447578e-02f, 2.24591568e-01f, -1.50394768e-01f, 1.33703023e-01f, 1.90696195e-01f,
  -3.36497396e-01f, 1.83631219e-02f, -9.27947834e-02f, -1.71427175e-01f, -1.13855433e-02f, 3.83997685e-03f, 2.39649802e-01f, 1.73520267e-01f, -4.51541971e-03f, -4.59377170e-02f,
  -1.86905041e-02f, -1.18343160e-01f, -4.04752418e-02f, -2.95003682e-01f, 2.88407862e-01f, -2.07548723e-01f, -3.43993217e-01f, 1.10691875e-01f, -1.32299840e-01f, 7.13524967e-02f,
  8.78849179e-02f, -1.18462682e-01f, -1.98580205e-01f, 3.43303867e-02f, -7.69175068e-02f, -1.69584185e-01f, 7.26754144e-02f, -3.32021788e-02f, 2.19968408e-01f, 3.67446132e-02f,
  2.38991976e-02f, 1.05514117e-01f, -2.21368924e-01f, -1.79193392e-02f, -2.54788846e-01f, 1.90146625e-01f, -1.88581139e-01f, -1.55662268e-01f, 1.06253155e-01f, -1.15864530e-01f,
  -2.42998019e-01f, 1.52735963e-01f, 1.02501877e-01f, -6.02754503e-02f, -2.66436368e-01f, -2.18845353e-01f, -2.49802083e-01f, 2.16596648e-02f, 2.48331055e-01f, 6.38239607e-02f,
  1.81362003e-01f, 2.03265682e-01f, -1.54881895e-01f, -1.86757267e-01f, -2.88812574e-02f, 1.06433474e-01f, -1.00252807e-01f, 9.17186141e-02f, -9.29284468e-02f, -1.66474327e-01f,
  -6.50146306e-02f, 1.11799121e-01f, 9.62022841e-02f, -1.85923725e-01f, 6.11857399e-02f, 6.08417904e-03f, -1.67542715e-02f, 1.20360091e-01f, -3.93581167e-02f, -7.32602030e-02f,
  -4.60833423e-02f, -1.89888746e-01f, 1.96489319e-01f, 1.31568283e-01f, 2.59634256e-02f, -2.27266222e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.75853889e-02f, 1.97358713e-01f, 4.63196248e-01f, -5.56954145e-02f, -1.97423339e-01f, -4.41264868e-01f, 3.51684764e-02f, 1.91401079e-01f, 2.38897473e-01f, -1.98830023e-01f,
  8.61589685e-02f, 3.44193101e-01f, -4.17494327e-01f, -7.77449161e-02f, 2.16408387e-01f, -4.65168178e-01f, 1.85569867e-01f, 2.55810916e-01f, -4.15475480e-02f, 3.07775825e-01f,
  -3.10412824e-01f, -6.17812574e-02f, -4.59566146e-01f, 1.74988732e-01f, 2.49700457e-01f, -1.71823546e-01f, 2.88922582e-02f, 3.13170463e-01f, 2.35608250e-01f, -1.11139335e-01f,
  2.38081008e-01f, 2.67512977e-01f, 2.22132161e-01f, -4.34041321e-02f, 3.36819828e-01f, 9.88394797e-01f, 6.59614354e-02f, 2.35433146e-01f, -2.58438021e-01f, 7.72289410e-02f,
  -4.78678554e-01f, 9.15926173e-02f, 8.40804651e-02f, 1.11296788e-01f, 1.33523401e-02f, -1.36810303e-01f, 2.36864179e-01f, 3.79519671e-01f, 5.22781432e-01f, -3.53698909e-01f,
  -5.30005172e-02f, -9.60167274e-02f, -6.48839921e-02f, 2.98428595e-01f, 3.46561819e-01f, -1.59606084e-01f, 2.40804106e-01f, 9.49201882e-02f, 2.57197231e-01f, 7.16782436e-02f,
  -4.19943184e-01f, 2.13674292e-01f, 1.49744049e-01f, -7.42188096e-02f, 3.04651648e-01f, 4.53306645e-01f, 6.19019568e-01f, 5.35872355e-02f, 2.50403732e-01f, 3.63146573e-01f,
  -2.61539012e-01f, -2.15885848e-01f, 1.27179369e-01f, 2.83224255e-01f, -1.79236680e-01f, 2.81809289e-02f, -6.16609275e-01f, -6.81238294e-01f, 5.25645256e-01f, 1.13754824e-01f,
  3.37769955e-01f, -1.23636546e-02f, -1.22593250e-02f, 2.29206130e-01f, -3.01809777e-02f, 6.58032820e-02f, 2.68034369e-01f, -2.51469076e-01f, 5.52887097e-04f, 1.63496926e-01f,
  -1.13097057e-01f, 3.86741757e-01f, -6.19656444e-02f, 1.56107545e-01f, 3.16911610e-03f, 2.03251109e-01f, 2.01917738e-02f, 1.58666924e-01f, 3.70307155e-02f, -7.46078551e-01f,
  2.44498342e-01f, 9.54521075e-02f, -8.38852674e-02f, -5.51293008e-02f, -2.08203226e-01f, 1.17502421e-01f, -1.62583351e-01f, -1.09423921e-02f, 4.63637620e-01f, -1.98713213e-01f,
  -1.80162266e-01f, 5.03214359e-01f, -3.52662712e-01f, 1.69348940e-01f, 1.58618465e-01f, -1.38530433e-01f, 3.60647619e-01f, -2.75891185e-01f, 9.50913131e-02f, 1.22916743e-01f,
  -8.84359404e-02f, 3.12273532e-01f, -5.16850408e-03f, -1.97856814e-01f, -7.92933330e-02f, 3.60876285e-02f, -1.14182219e-01f, 9.97152179e-02f, 1.29271120e-01f, -8.51009935e-02f,
  1.68204099e-01f, -4.10215348e-01f, -4.65396911e-01f, 6.16716206e-01f, -2.81641558e-02f, 6.09464049e-02f, 3.29918087e-01f, -1.36834860e-01f, -1.27656281e-01f, 2.06810117e-01f,
  -5.55220060e-03f, 1.52547248e-02f, -2.32221708e-01f, 1.19087853e-01f, 3.83967429e-01f, 2.57411376e-02f, -1.46591976e-01f, 2.98021585e-01f, -1.54421687e-01f, 1.99276701e-01f,
  -2.36457109e-01f, 4.10573930e-01f, -2.19845474e-01f, -1.69186249e-01f, 1.88207343e-01f, -2.11543255e-02f, -1.86971575e-01f, -1.80954784e-01f, 1.74640745e-01f, -4.04926538e-02f,
  1.64901271e-01f, 3.06004547e-02f, -3.51481020e-01f, -3.25757742e-01f, 4.58722524e-02f, 1.49703979e-01f, 4.13208038e-01f, -1.97761267e-01f, -5.82328141e-02f, -3.10565289e-02f,
  -1.56063855e-01f, -2.14136809e-01f, -2.94365268e-03f, 1.72090158e-01f, 2.90653348e-01f, 5.52652292e-02f, -2.02827618e-01f, 2.96901196e-01f, 8.51029232e-02f, -1.73887778e-02f,
  1.22155190e-01f, -3.01254839e-01f, 8.40132311e-02f, -3.42541933e-01f, 2.52261609e-01f, 4.27905887e-01f, -3.23563546e-01f, 2.00203553e-01f, 3.30406964e-01f, 8.43303800e-02f,
  1.43087745e-01f, 2.69651502e-01f, 2.50643462e-01f, -7.53360018e-02f, 1.81062296e-01f, 9.06224668e-01f, 8.10168013e-02f, 1.38888076e-01f, -1.58278849e-02f, -1.27472699e-01f,
  -3.53068411e-01f, 3.82568538e-01f, -1.08483709e-01f, 2.29178771e-01f, 2.62976557e-01f, 1.67062715e-01f, -5.25253452e-02f, -1.93472460e-01f, 2.09860772e-01f, 6.95165340e-03f,
  3.44013661e-01f, -8.19534957e-02f, -2.54594952e-01f, 4.23384130e-01f, 5.72321355e-01f, 1.19397171e-01f, 1.16765881e-02f, 9.54996496e-02f, 2.81965286e-01f, -6.20243214e-02f,
  1.62798375e-01f, -1.29578620e-01f, -1.69342056e-01f, 3.94878425e-02f, 1.68466076e-01f, -3.47108543e-01f, -2.38003165e-01f, -4.66357112e-01f, -4.61728364e-01f, 2.85588413e-01f,
  1.52776405e-01f, -2.13895485e-01f, -3.79324555e-01f, 6.59110770e-02f, 3.57289255e-01f, 1.61352754e-01f, -3.33570123e-01f, -1.64965048e-01f, -4.42545265e-01f, -2.10133657e-01f,
  -6.36323094e-02f, 2.72137552e-01f, -1.32250071e-01f, -5.41085005e-02f, 1.34331644e-01f, 9.35660005e-02f, 2.15761438e-01f, 2.53054500e-01f, 7.80226439e-02f, -2.06127867e-01f,
  1.49821147e-01f, 7.16780499e-02f, 2.15710297e-01f, 1.98116884e-01f, 2.24608943e-01f, -3.22808892e-01f, -2.11444974e-01f, 1.36530757e-01f, -2.41397277e-01f, -2.34257001e-02f,
  -1.59830064e-01f, -1.13350600e-02f, 1.30907699e-01f, 3.96389402e-02f, -2.76769280e-01f, -1.09147936e-01f, -4.95601259e-03f, 7.35116228e-02f, 1.79540887e-01f, 3.93730074e-01f,
  -1.55519828e-01f, 4.98372793e-01f, 1.45800099e-01f, 2.27427617e-01f, 5.12724705e-02f, 1.91061606e-03f, -1.76163197e-01f, -1.26734316e-01f, 6.42571449e-02f, 2.64686108e-01f,
  6.52056783e-02f, -3.27081531e-01f, 1.89550385e-01f, -6.08657375e-02f, -2.31758598e-02f, -7.26316869e-02f, 1.74507186e-01f, -2.67820120e-01f, -2.01978952e-01f, -3.30368429e-01f,
  -3.64224821e-01f, -1.70150653e-01f, -3.71983886e-01f, 1.04708530e-01f, 2.60802776e-01f, -2.01539963e-01f, -2.26354375e-01f, -8.12635869e-02f, 2.95937657e-01f, -1.58041477e-01f,
  1.47627681e-01f, 2.56390274e-01f, -1.20843221e-02f, -3.18969578e-01f, 7.30555505e-02f, 2.46707126e-01f, 3.78193080e-01f, -1.43056614e-02f, 1.65372789e-01f, 2.59675473e-01f,
  1.73060760e-01f, -1.27154961e-01f, 1.41216427e-01f, -1.21144079e-01f, 3.43217939e-01f, 1.10505946e-01f, 2.17862874e-01f, 1.16296820e-01f, 2.80990064e-01f, -1.40002236e-01f,
  4.92347665e-02f, 2.49376193e-01f, 3.21787484e-02f, -3.73649746e-01f, 1.50028050e-01f, 4.39576626e-01f, 2.19094485e-01f, 3.57235312e-01f, 3.57038468e-01f, 2.75456935e-01f,
  -5.35606686e-03f, -1.45074934e-01f, -4.80138123e-01f, -7.83685267e-01f, -1.96588233e-01f, 3.65868181e-01f, -3.37578923e-01f, 2.88404543e-02f, -3.09484571e-01f, -2.81105369e-01f,
  1.10203020e-01f, -1.02546126e-01f, -2.16157548e-02f, 3.13622393e-02f, 1.95334315e-01f, 1.80757567e-01f, -1.07031152e-01f, -1.80159658e-01f, -1.16069674e-01f, 3.14518332e-01f,
  1.98566958e-01f, 2.86356241e-01f, 2.05732867e-01f, -8.10802877e-02f, -2.16792077e-01f, 4.56351526e-02f, -3.72013539e-01f, 8.40007961e-02f, 3.08987767e-01f, -3.33126366e-01f,
  -3.95140886e-01f, -1.80989608e-01f, 1.08822174e-01f, -2.51348436e-01f, 3.79382335e-02f, 1.88059651e-03f, 2.53598422e-01f, 3.05847749e-02f, 2.03846067e-01f, 1.23995155e-01f,
  2.25421656e-02f, 3.16023767e-01f, 3.85050803e-01f, 1.50996253e-01f, -5.90571091e-02f, 4.92525799e-03f, 2.98768967e-01f, -4.64038931e-05f, 1.54034778e-01f, 2.80402780e-01f,
  2.69978255e-01f, -5.08852070e-04f, 3.25402439e-01f, 2.06637740e-01f, 1.81422874e-01f, 1.60056904e-01f, 1.04485251e-01f, 1.24267109e-01f, -5.59344962e-02f, -7.63800815e-02f,
  -8.07556286e-02f, 7.30751157e-02f, 5.01217425e-01f, 2.44775519e-01f, 1.96199194e-02f, 4.52480391e-02f, 5.90846539e-01f, 4.16197479e-01f, -4.67825076e-03f, 4.17118818e-02f,
  -1.67828009e-01f, -2.31416091e-01f, 3.68154854e-01f, -2.18046792e-02f, -2.43625998e-01f, 7.21595585e-02f, -4.03514095e-02f, 1.92876413e-01f, -1.36345804e-01f, -1.02256052e-02f,
  -2.93131173e-03f, -6.58491179e-02f, -1.11367323e-01f, -5.80963567e-02f, -3.93318325e-01f, -1.20132687e-02f, -2.02331752e-01f, 2.57885665e-01f, -6.82611614e-02f, -4.54438537e-01f,
  1.00554638e-01f, -8.66332874e-02f, 2.24708300e-03f, 3.97517413e-01f, 2.05208659e-01f, 1.40188579e-02f, -9.65894610e-02f, 1.34660214e-01f, 6.50321543e-02f, 1.92328747e-02f,
  1.09076791e-01f, -2.50662088e-01f, 8.06390867e-02f, -2.36578196e-01f, 1.50479883e-01f, 1.99212164e-01f, -2.86528200e-01f, 2.97294945e-01f, -1.47695735e-01f, 3.95078242e-01f,
  -4.53498036e-01f, -2.48048350e-01f, -3.33090760e-02f, -1.00416578e-02f, 3.30499589e-01f, -2.83461690e-01f, -2.16167226e-01f, -1.40664965e-01f, -9.57697108e-02f, 6.69681206e-02f,
  5.06615825e-02f, -1.09433398e-01f, -1.12679742e-01f, -7.21934676e-01f, 2.90238351e-01f, 1.48267969e-01f, 1.70161545e-01f, -2.18523845e-01f, 4.28590737e-02f, -1.45471543e-01f,
  3.96240950e-01f, 1.98137194e-01f, 2.36264884e-01f, 1.31375328e-01f, 1.45622104e-01f, 1.75123677e-01f, -7.79127702e-02f, 3.55672538e-01f, 2.13518649e-01f, -2.11061500e-02f,
  -3.40459555e-01f, 2.77279038e-02f, 4.10415381e-01f, 1.07653715e-01f, 1.43388391e-01f, 4.14885253e-01f, 3.52572575e-02f, 7.01404363e-02f, 1.92850798e-01f, 9.83260572e-02f,
  -1.95697457e-01f, -2.17347890e-02f, 3.62900682e-02f, -3.66857886e-01f, -1.42645657e-01f, -3.96333873e-01f, -1.09668851e-01f, 1.72714978e-01f, 1.75865412e-01f, 8.49395245e-02f,
  4.50411975e-01f, 2.90476114e-01f, -3.80311787e-01f, -3.16904522e-02f, -2.28907287e-01f, -2.78780520e-01f, -2.83462912e-01f, 1.75336391e-01f, 9.69853699e-02f, -1.53062819e-02f,
  2.61004958e-02f, 2.11064965e-01f, 3.96357700e-02f, 1.16303258e-01f, -9.97216329e-02f, -7.38324746e-02f, -1.28556967e-01f, 2.36676812e-01f, 3.81536365e-01f, 1.61339894e-01f,
  1.92018539e-01f, -8.63698572e-02f, -6.81042671e-02f, -1.80568710e-01f, 1.52903259e-01f, 7.15389550e-01f, 2.17812568e-01f, -3.32216859e-01f, 8.43897760e-02f, -2.24679351e-01f,
  -1.29207939e-01f, 1.97756529e-01f, 2.08105475e-01f, -1.11865066e-01f, -5.20016905e-03f, -1.12400027e-02f, -1.46581784e-01f, -1.19447239e-01f, -1.20140724e-01f, -1.39749467e-01f,
  3.85879159e-01f, -3.06477509e-02f, 3.05460304e-01f, 3.93420011e-01f, 4.68304902e-01f, -2.69271046e-01f, 1.99962199e-01f, 6.63755313e-02f, 1.54280037e-01f, -1.70723096e-01f,
  1.13568917e-01f, -8.37744400e-02f, -9.23709720e-02f, -3.32611024e-01f, -1.37956753e-01f, -9.12856683e-03f, 1.37035279e-02f, -5.56113422e-02f, 5.24848439e-02f, -6.98514357e-02f,
  2.33148172e-01f, 3.11317332e-02f, 3.88539553e-01f, 1.92604810e-01f, 2.54922450e-01f, 3.59132558e-01f, 2.70761728e-01f, 4.50928420e-01f, -6.83983862e-02f, -2.69238949e-01f,
  -4.08293843e-01f, -3.23432274e-02f, 1.77068159e-01f, -1.31418094e-01f, 9.82812718e-02f, 3.61878797e-02f, 2.67349258e-02f, 9.70316753e-02f, -4.25130934e-01f, -5.45229837e-02f,
  1.13956377e-01f, -3.97526145e-01f, 2.06201479e-01f, -1.55567214e-01f, -2.50913739e-01f, -1.78491414e-01f, 1.37029052e-01f, -1.45648658e-01f, 2.76454002e-01f, -2.55770653e-01f,
  -1.12589309e-02f, -1.62201211e-01f, -1.55804724e-01f, 1.37458131e-01f, 2.04283416e-01f, 7.68085709e-03f, -3.13151181e-01f, 3.65789413e-01f, 1.03066854e-01f, 1.86918944e-01f,
  2.15616241e-01f, -2.85912305e-01f, 3.62963587e-01f, 9.06902850e-02f, 4.50527370e-01f, 1.60969555e-01f, -3.01271170e-01f, 3.53703350e-01f, 1.60595864e-01f, 1.79616749e-01f,
  -1.32449210e-01f, 2.12150346e-02f, 9.58566144e-02f, 2.58565605e-01f, 4.76492345e-02f, -3.86806190e-01f, 8.32721405e-03f, -2.77120825e-02f, 4.30015147e-01f, 1.58898711e-01f,
  1.54458255e-01f, 1.89349517e-01f, 1.42286196e-01f, 1.19323082e-01f, -2.01381832e-01f, 1.48790911e-01f, 3.21165621e-01f, 8.01423416e-02f, -3.34318787e-01f, 2.14693233e-01f,
  1.10462718e-01f, -3.68544087e-02f, 2.82009721e-01f, 5.50110161e-01f, 3.56490552e-01f, -2.12082788e-01f, -4.75087166e-02f, 2.11331397e-01f, -2.58201510e-01f, -3.91630456e-02f,
  2.32295975e-01f, 1.16022229e-01f, 4.12945375e-02f, 3.74454677e-01f, 1.75230727e-01f, 1.81992665e-01f, -2.15824425e-01f, -5.47035299e-02f, 2.76885927e-02f, 1.89033505e-02f,
  2.61289012e-02f, -1.01593189e-01f, 2.71347940e-01f, 1.54056266e-01f, -2.71499068e-01f, -3.39721859e-01f, -3.46141517e-01f, 8.53567570e-02f, 2.22892642e-01f, -7.65879825e-02f,
  6.03401382e-03f, 2.95064211e-01f, -7.16864243e-02f, -2.10967675e-01f, 3.86120409e-01f, -2.43495539e-01f, 3.39402944e-01f, -5.07225543e-02f, 2.30714940e-02f, 3.43644053e-01f,
  -2.13903129e-01f, 2.52381504e-01f, -1.50780156e-01f, 2.18899742e-01f, 8.82472023e-02f, -1.74379990e-01f, 9.70905572e-02f, 1.94907546e-01f, -1.86641872e-01f, -3.90968233e-01f,
  1.79456815e-01f, 7.95315206e-02f, 2.39915445e-01f, 1.05297873e-02f, -3.43169153e-01f, -5.15578091e-01f, 2.85204411e-01f, 1.83509678e-01f, -5.58318384e-03f, 1.27046570e-01f,
  -3.32418829e-01f, 1.95307761e-01f, 1.80177718e-01f, -9.74060744e-02f, -2.55160630e-01f, -4.64449465e-01f, -9.27015319e-02f, 8.17199722e-02f, 9.80775580e-02f, 1.01361861e-02f,
  2.79755071e-02f, -3.25332582e-01f, 2.89593842e-02f, -4.92438488e-02f, 2.01843128e-01f, 3.86847630e-02f, -5.08390889e-02f, 3.86993378e-01f, -2.95567811e-01f, -1.56289674e-02f,
  1.51607841e-01f, 1.55236959e-01f, 1.90350562e-02f, 1.78448290e-01f, 1.32902488e-01f, 1.89643800e-02f, 1.19155765e-01f, -3.54394242e-02f, -7.20110014e-02f, 4.62377429e-01f,
  1.82759315e-01f, 1.33047076e-02f, 2.67734855e-01f, 4.10263538e-01f, 2.03785062e-01f, 4.85699773e-02f, -2.56831974e-01f, -1.88183844e-01f, -1.36313632e-01f, 1.38751045e-01f,
  -1.38855860e-01f, -2.24354982e-01f, 2.82692406e-02f, -3.57951641e-01f, 1.68260261e-01f, 1.17338739e-01f, 1.13667332e-01f, -4.42664698e-02f, 6.91927820e-02f, 1.54754758e-01f,
  -8.72410089e-03f, -3.33196104e-01f, 5.13209328e-02f, 2.64203936e-01f, 1.10384434e-01f, -6.93148598e-02f, 7.63385892e-02f, 1.15532532e-01f, -4.29928266e-02f, -8.37576985e-01f,
  -6.08641934e-03f, -2.98916638e-01f, 1.26940444e-01f, 3.34882349e-01f, 5.00407398e-01f, 4.67800707e-01f, -1.76619038e-01f, 1.35693267e-01f, 4.15047854e-01f, 2.86184967e-01f,
  -1.36360526e-01f, 5.72536767e-01f, -2.62775183e-01f, -1.13999940e-01f, 2.30579197e-01f, 3.82565893e-03f, 4.56666112e-01f, -3.17899674e-01f, 2.05132499e-01f, 3.20018768e-01f,
  1.65579602e-01f, 1.07649319e-01f, -1.10319423e-04f, -3.28465939e-01f, 5.27415834e-02f, 1.47958592e-01f, -2.85928667e-01f, 5.33518977e-02f, 4.79026258e-01f, 4.83472168e-01f,
  3.48585755e-01f, -3.87939543e-01f, 4.14599687e-01f, 8.39955509e-02f, 1.02914058e-01f, -5.25528431e-01f, 2.25776359e-01f, -3.58642824e-02f, -1.48122281e-01f, 1.67844027e-01f,
  -5.72200119e-01f, -4.65531647e-01f, 2.98059493e-01f, 7.63070434e-02f, 8.95993188e-02f, 2.58071631e-01f, -2.29773507e-01f, 1.21163011e-01f, 5.54500781e-02f, -6.75030798e-02f,
  -2.34026849e-01f, -3.24910164e-01f, 3.28046769e-01f, 4.75449622e-01f, -2.99758703e-01f, 3.66883874e-01f, 2.95319349e-01f, 1.28919750e-01f, 4.02119346e-02f, 4.84060287e-01f,
  2.30182931e-01f, -2.14012608e-01f, 1.87762424e-01f, 2.11881567e-03f, -4.54240352e-01f, 4.36711043e-01f, -2.73069948e-01f, 1.45524502e-01f, 2.28966773e-01f, 2.57687211e-01f,
  1.23754226e-01f, 1.24731705e-01f, -1.40757218e-01f, -1.85591444e-01f, -1.95464343e-01f, -7.40430355e-02f, -3.23573202e-02f, 2.23153029e-02f, 6.84043579e-03f, 7.68277422e-02f,
  1.87638521e-01f, 1.55833229e-01f, 4.47290484e-03f, -5.44048846e-02f, 6.82690367e-02f, -5.22529840e-01f, 1.67818487e-01f, -1.50715768e-01f, 1.71859592e-01f, 9.03249234e-02f,
  -5.99324778e-02f, -3.64800036e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  8.91608074e-02f, 7.43268654e-02f, 1.04328871e-01f, 3.26193981e-02f, 2.14369580e-01f, 6.57144636e-02f, -1.04950240e-03f, -8.87656808e-02f, 1.25224128e-01f, -1.32628545e-01f,
  3.22572023e-01f, -1.69169586e-02f, 2.05509305e-01f, 2.06238002e-01f, 2.41700515e-01f, 9.06335097e-03f, 1.02059648e-03f, -7.54243881e-02f, -7.58106932e-02f, 1.54136091e-01f,
  4.80568372e-02f, 2.91486327e-02f, -1.11642562e-01f, 1.77938759e-01f, 1.28291443e-01f, 3.51132341e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.08228737e-01f, 1.62474718e-02f, -2.24496543e-01f, -3.23901772e-01f, -9.60241184e-02f, 3.46463621e-01f, -8.07175189e-02f, -3.72513264e-01f, 5.36703393e-02f, -4.46476966e-01f,
  -2.48031005e-01f, 2.97937274e-01f, -4.26925302e-01f, -2.51311734e-02f, 1.45333111e-01f, 3.13105583e-01f, -6.76630512e-02f, 3.00967723e-01f, -1.50714098e-02f, -4.12635915e-02f,
  1.82194963e-01f, 1.64767131e-02f, -3.52225542e-01f, -1.26031607e-01f, -4.60126400e-01f, -4.58757162e-01f, -3.65208298e-01f, -6.48439899e-02f, -1.49384916e-01f, -6.37838721e-01f,
  8.41019452e-02f, -3.70424122e-01f, -1.26855150e-01f, -1.50454447e-01f, -4.05252934e-01f, -1.25366673e-01f, 2.96127647e-02f, 3.08214903e-01f, -6.53529406e-01f, -2.43713066e-01f,
  -3.22035104e-01f, 1.67615831e-01f, -2.19571963e-02f, 2.02804863e-01f, -5.41015089e-01f, 1.87948003e-01f, 9.26861539e-02f, -6.82683196e-03f, 2.25649208e-01f, -7.98663870e-02f,
  -1.63329080e-01f, 5.60944192e-02f, -6.99651390e-02f, 2.59507537e-01f, -4.18421850e-02f, -1.18141837e-01f, -1.79900020e-01f, -6.80561423e-01f, -2.52353311e-01f, 2.13453189e-01f,
  1.70222595e-01f, 1.11167796e-01f, 3.49562205e-02f, 9.47146788e-02f, -1.35179237e-01f, -1.02258720e-01f, 3.49684000e-01f, -6.21417500e-02f, 1.66477174e-01f, 4.46727037e-01f,
  2.82720119e-01f, -2.35546693e-01f, -1.17099777e-01f, -1.00273892e-01f, 2.56960779e-01f, -3.73382479e-01f, -1.11982562e-01f, 3.36750686e-01f, 1.24332257e-01f, 1.83176711e-01f,
  -8.98313597e-02f, 2.57321484e-02f, -7.03334749e-01f, 1.02589585e-01f, -1.06103383e-01f, 2.25615218e-01f, -4.09727633e-01f, -6.32607698e-01f, 1.42490879e-01f, -2.11828187e-01f,
  1.40735030e-01f, -2.83516347e-01f, -2.24856943e-01f, -4.03224498e-01f, -2.56425768e-01f, 1.65568620e-01f, -2.34994456e-01f, -1.71850547e-02f, 2.10989401e-01f, 2.93411165e-01f,
  -1.43115923e-01f, -1.49650186e-01f, 1.29091581e-02f, -8.79802331e-02f, 7.44406879e-02f, -4.84281033e-02f, -7.12610543e-01f, 2.00614277e-02f, 2.13041142e-01f, -3.56768146e-02f,
  -5.42948604e-01f, 2.48802006e-01f, -5.29245138e-01f, 8.00817609e-02f, -2.94989288e-01f, -4.22543705e-01f, -4.83447220e-03f, 2.22271487e-01f, 3.04079324e-01f, -1.31221741e-01f,
  1.47944853e-01f, 9.20379348e-03f, -1.36383742e-01f, -7.36109018e-02f, -2.26895198e-01f, -4.47176278e-01f, -3.80653851e-02f, -3.15090328e-01f, 3.60881947e-02f, 2.76849985e-01f,
  -5.63458622e-01f, 4.03779030e-01f, 3.75877351e-01f, -5.63135982e-01f, 3.46225560e-01f, -3.78966600e-01f, 1.00960948e-01f, -4.04110312e-01f, -3.28096122e-01f, 6.89485297e-02f,
  -4.92906004e-01f, -3.46481144e-01f, -1.23306304e-01f, -2.23122910e-01f, -7.78794661e-02f, -1.04405299e-01f, -3.06249484e-02f, 2.83607971e-02f, 2.09508434e-01f, 2.79208779e-01f,
  -1.21621042e-01f, 2.06960216e-01f, 5.25593981e-02f, -3.73755698e-03f, 1.89718604e-02f, -2.52134383e-01f, -3.11372489e-01f, 8.72457325e-02f, 2.13978156e-01f, 2.20279545e-02f,
  3.07632834e-01f, 1.95597351e-01f, 1.86084136e-01f, -2.85988688e-01f, -3.26411456e-01f, 2.50586987e-01f, -4.92494106e-02f, -1.21516585e-01f, 2.31217667e-01f, 4.50742632e-01f,
  -2.03049272e-01f, 1.20738827e-01f, -6.43456578e-01f, -5.01062453e-01f, -1.88592032e-01f, -4.52889770e-01f, 2.65567750e-01f, -1.72652856e-01f, -1.70787483e-01f, 1.94069490e-01f,
  -3.07940021e-02f, -4.03118551e-01f, -2.64920890e-01f, 7.30035901e-02f, -5.23284912e-01f, 1.08485319e-01f, -5.07187784e-01f, 1.35068744e-01f, -6.98674992e-02f, 2.50735700e-01f,
  2.37488136e-01f, -1.99118003e-01f, -5.50129041e-02f, 2.10356534e-01f, -2.46853586e-02f, 3.09295624e-01f, 3.06399643e-01f, 1.78182840e-01f, -7.66918898e-01f, -4.14753824e-01f,
  -2.82489568e-01f, 1.12944946e-01f, 1.19059443e-01f, -1.74059182e-01f, 5.25827929e-02f, -4.37680423e-01f, 3.35226089e-01f, -1.91191226e-01f, -2.84998745e-01f, -6.81923985e-01f,
  2.08029866e-01f, 2.29228452e-01f, -1.55491844e-01f, -5.71013272e-01f, -5.63867450e-01f, 2.69631237e-01f, 1.44631401e-01f, 2.47789979e-01f, -1.65485591e-01f, 2.85475291e-02f,
  -2.73425519e-01f, 2.40618691e-01f, -1.88927531e-01f, -2.07659692e-01f, 2.85461806e-02f, 1.69408903e-01f, -1.04333721e-01f, 7.49283731e-02f, -1.37627199e-01f, 1.90184027e-01f,
  -1.09222747e-01f, -4.03927088e-01f, -1.04696788e-01f, -2.01325804e-01f, -4.68894839e-02f, -4.21038866e-01f, 1.35467276e-01f, 4.62881997e-02f, -4.61539537e-01f, -1.43117476e-02f,
  -2.70859659e-01f, -3.99266273e-01f, 1.41425207e-01f, 1.74705714e-01f, -4.95610207e-01f, 2.34427646e-01f, 3.06127012e-01f, 4.49982852e-01f, 1.00648411e-01f, -2.68641979e-01f,
  -1.12626135e-01f, -1.28337875e-01f, 1.44082934e-01f, 8.70283991e-02f, -4.76421207e-01f, 2.62505531e-01f, 8.68550241e-02f, -3.53806704e-01f, 2.03323364e-01f, -1.37645841e-01f,
  2.59371698e-01f, -9.12705287e-02f, -3.58139813e-01f, 3.69198501e-01f, 8.97732154e-02f, -1.00553654e-01f, 8.80299285e-02f, -6.15148067e-01f, 1.32917151e-01f, -1.77246854e-01f,
  -1.80260856e-02f, -2.53095537e-01f, 3.92542690e-01f, -5.86188316e-01f, -4.47369181e-02f, -5.17727673e-01f, -4.02681530e-01f, -7.42167085e-02f, 3.95518839e-01f, -7.16516972e-02f,
  -3.31750900e-01f, 1.66653395e-01f, -2.24691451e-01f, -5.99922501e-02f, 3.28983605e-01f, -1.95104089e-02f, -5.72799861e-01f, 4.40505892e-02f, 1.11120291e-01f, -4.13194150e-01f,
  -1.03692763e-01f, -1.82080761e-01f, 1.65276434e-02f, -3.70526046e-01f, 9.26688537e-02f, 1.03366680e-01f, -4.79004145e-01f, -3.67030680e-01f, 1.46630421e-01f, -3.19090724e-01f,
  -1.03652626e-02f, -3.74095291e-01f, -4.53919768e-02f, 3.37544046e-02f, -1.07806429e-01f, -2.20716819e-01f, 1.03536971e-01f, 2.96601325e-01f, 9.10850838e-02f, -1.89414307e-01f,
  -8.23404267e-02f, -1.52810082e-01f, 2.81359196e-01f, 2.17903435e-01f, 3.40693533e-01f, -8.79499257e-01f, -1.17182106e-01f, -9.65072960e-02f, -6.33281410e-01f, 1.59182232e-02f,
  -1.36297680e-02f, 2.52324820e-01f, -2.00553328e-01f, 1.26523152e-03f, -3.91883373e-01f, -2.46965200e-01f, -2.20648617e-01f, 4.08261657e-01f, 3.55079383e-01f, -3.26443851e-01f,
  -5.86395323e-01f, -3.22959386e-02f, 3.33664477e-01f, -3.83027196e-01f, -1.69458181e-01f, -4.49980617e-01f, -8.03919211e-02f, -8.32106993e-02f, -2.92648613e-01f, -3.29954475e-01f,
  -2.16868863e-01f, -4.67108399e-01f, -2.63208598e-01f, -8.98681395e-03f, -5.64956777e-02f, 3.63302469e-01f, -7.90854394e-02f, 1.47922516e-01f, -6.91285953e-02f, -7.70382762e-01f,
  1.12420060e-01f, -3.17279905e-01f, -1.95097283e-01f, -1.61259860e-01f, 4.15810384e-02f, 4.16330546e-01f, -2.65144527e-01f, 2.12005734e-01f, -4.33144689e-01f, 2.52014607e-01f,
  -3.46522957e-01f, 1.20307311e-01f, -1.10327370e-01f, -1.27899453e-01f, 2.77653933e-02f, -5.15502095e-02f, 1.59907073e-01f, 6.71583787e-02f, -3.70762616e-01f, 2.47499615e-01f,
  2.99202893e-02f, -5.71672618e-01f, 2.60555238e-01f, -4.05137956e-01f, 2.76548356e-01f, -9.91324335e-02f, -2.14834496e-01f, 3.16760130e-02f, -1.55748025e-01f, -5.30994475e-01f,
  -5.60405813e-02f, 1.76357940e-01f, -4.60533559e-01f, 1.47237867e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.97641994e-02f, 1.24209009e-01f, -5.62856607e-02f, -1.68280303e-01f, -2.28625629e-02f, 2.38852814e-01f, -8.31006616e-02f, -2.64611393e-01f, 5.48565425e-02f, 1.29080549e-01f,
  8.30587149e-02f, 1.00996196e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    