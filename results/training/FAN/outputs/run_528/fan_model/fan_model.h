/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.28433518e-02f, -1.31878750e-02f, -4.75552604e-02f, -1.29469782e-01f, 4.09684569e-01f, 2.33484685e-01f, -6.09326921e-02f, 1.62350044e-01f, -1.25131458e-01f, -1.46707252e-01f,
  1.10734642e-01f, -2.60845691e-01f, -6.54244497e-02f, -1.52801603e-01f, 3.09096295e-02f, -2.37127453e-01f, -5.35198450e-02f, -1.88047737e-01f, 1.16614280e-02f, 1.73455611e-01f,
  1.32487312e-01f, 2.03160346e-01f, 8.37067980e-03f, 3.64257187e-01f, 3.03892761e-01f, 7.35579506e-02f, 1.61876678e-01f, 5.81470095e-02f, 5.32464050e-02f, -9.59678926e-03f,
  8.79244357e-02f, 7.99874123e-03f, 8.94955844e-02f, -5.42282537e-02f, 1.23203613e-01f, -9.71662775e-02f, 3.56032588e-02f, -3.09121460e-02f, 1.91968847e-02f, 1.20905470e-02f,
  3.47266048e-02f, 5.22774719e-02f, -3.98021117e-02f, -7.58521333e-02f, 3.59752565e-03f, -1.81955914e-03f, -6.53047580e-03f, 3.79807912e-02f, 3.94259095e-02f, -3.80324535e-02f,
  -1.93004794e-02f, -4.87230010e-02f, -6.89254105e-02f, -1.75384693e-02f, 1.14921033e-01f, -1.66577857e-03f, -5.72975203e-02f, -1.97731592e-02f, 3.45424004e-02f, -8.33603218e-02f,
  5.22048660e-02f, 2.97177825e-02f, -5.76995127e-02f, -2.18984205e-02f, -3.12777348e-02f, 2.89920866e-02f, -1.53893381e-01f, 8.81676450e-02f, 4.35141474e-02f, 1.04322292e-01f,
  7.30045512e-02f, 1.14145549e-02f, 2.64448468e-02f, 3.61045673e-02f, -1.33260721e-02f, 5.13207214e-03f, -1.93899870e-02f, -5.24907187e-02f, -1.49614951e-02f, -2.14683171e-02f,
  -1.28041031e-02f, 4.32069264e-02f, 9.05985981e-02f, 1.42892441e-02f, -9.06126201e-03f, 3.26421224e-02f, 3.99820879e-02f, -1.13853090e-03f, 3.22523229e-02f, 4.38083149e-02f,
  1.03081763e-01f, 1.18954331e-01f, 4.82567549e-02f, 1.10806376e-01f, 2.70762146e-02f, -3.70956399e-02f, -2.84057297e-02f, -2.34810933e-02f, 9.13865119e-02f, 3.38190831e-02f,
  -3.12751252e-03f, 7.40345493e-02f, 2.58449484e-02f, -2.66905744e-02f, -7.03547616e-03f, -3.57567868e-03f, -3.39745767e-02f, 1.31910652e-01f, 9.03274640e-02f, 5.94244823e-02f,
  1.02536961e-01f, 8.36284831e-02f, -1.92865971e-02f, 7.81112462e-02f, 1.10392403e-02f, -6.25390410e-02f, -1.59529541e-02f, -5.53105026e-02f, 7.61025324e-02f, -1.57367922e-02f,
  -3.12998712e-01f, -1.69530973e-01f, -1.63362041e-01f, -1.81393512e-02f, -1.49777338e-01f, -3.03251147e-01f, -1.52966529e-01f, -1.80239812e-01f, -1.42869443e-01f, 1.55036628e-01f,
  4.91329804e-02f, -2.73972116e-02f, -1.38759419e-01f, 1.62694171e-01f, -1.36962593e-01f, 3.99791710e-02f, 2.66140252e-01f, 1.88103959e-01f, 8.31403583e-02f, -6.99064210e-02f,
  1.40138030e-01f, 2.07758471e-01f, 1.88530520e-01f, 1.80259228e-01f, 1.44955721e-02f, 4.47388832e-03f, 1.47170991e-01f, 1.01827867e-01f, 2.98107386e-01f, 8.53501335e-02f,
  -1.18793122e-01f, -3.24160494e-02f, -4.32715267e-02f, -8.10018256e-02f, -1.64066255e-02f, 3.81274894e-02f, -4.48160432e-02f, -2.17206609e-02f, -4.17319499e-02f, -2.66674161e-02f,
  -7.50311241e-02f, -1.71804056e-02f, 3.73641513e-02f, 1.43634090e-02f, -1.85393579e-02f, -7.77691305e-02f, 1.32655045e-02f, 1.62063185e-02f, -5.09458482e-02f, -8.30133930e-02f,
  -6.50492869e-03f, 7.38933450e-03f, -7.12180063e-02f, -4.79227416e-02f, -8.98458585e-02f, 1.94009990e-02f, 2.51849331e-02f, 1.30335549e-02f, -7.66962692e-02f, -7.34121799e-02f,
  -1.38284331e-02f, 9.80266090e-03f, -7.52966478e-03f, -5.21784388e-02f, 3.68235633e-02f, -4.66503538e-02f, 6.81701750e-02f, -2.51754513e-03f, 7.97668546e-02f, -1.06568746e-02f,
  -1.15738707e-02f, 5.33797629e-02f, -3.81856114e-02f, -6.49864227e-02f, 9.14407969e-02f, 6.95592072e-03f, 2.19569933e-02f, -5.03674708e-02f, -3.74947786e-02f, 1.11546870e-02f,
  -3.02740410e-02f, -9.47267562e-02f, -2.01887935e-02f, 5.16070016e-02f, 1.02040507e-02f, -1.01023704e-01f, 3.22047547e-02f, -7.71169513e-02f, 4.44919318e-02f, 1.53175695e-02f,
  -2.23882660e-01f, 1.89845171e-02f, 2.41688099e-02f, -7.38623887e-02f, 2.70388070e-02f, 7.66811222e-02f, 8.72158334e-02f, 3.36432829e-02f, -1.95197705e-02f, -2.57738102e-02f,
  5.55888936e-02f, 9.57633629e-02f, -4.04501363e-04f, -4.52458374e-02f, 3.67816840e-03f, -1.69140622e-01f, 2.25399435e-02f, -5.85750118e-02f, -1.90061796e-02f, -4.16743718e-02f,
  -2.96922345e-02f, 3.35130654e-02f, 8.69922861e-02f, 1.10206693e-01f, 4.01851311e-02f, 4.46429402e-02f, -3.12480610e-03f, -8.63276608e-03f, 5.56029230e-02f, -5.40421270e-02f,
  -4.45837647e-01f, -3.55046749e-01f, -2.02515438e-01f, -2.28217125e-01f, -8.36715624e-02f, 6.95836172e-02f, -1.82052553e-02f, -2.07600281e-01f, -2.87801892e-01f, -6.83794636e-03f,
  1.43814430e-01f, -2.87258893e-01f, 8.08787271e-02f, -9.35706273e-02f, 3.08995336e-01f, 2.08311900e-01f, -1.35499284e-01f, -1.27449427e-02f, -1.36892051e-01f, -2.59623796e-01f,
  -1.51157886e-01f, 1.37887314e-01f, 1.99598055e-02f, 5.64396009e-02f, -2.00214908e-01f, -1.59076884e-01f, 1.10572919e-01f, 9.82017145e-02f, 1.23153307e-01f, 1.43759936e-01f,
  -1.07373029e-01f, -1.86221972e-01f, -6.37337491e-02f, 9.44637880e-02f, -2.83750985e-02f, 2.74128318e-02f, 7.45241866e-02f, 6.75191283e-02f, 4.76310365e-02f, -3.09901256e-02f,
  2.36057979e-03f, 1.17109634e-01f, -7.38041103e-02f, 5.45148253e-02f, -1.32989913e-01f, -9.96681862e-03f, -7.78069049e-02f, 9.01251379e-03f, -7.93396756e-02f, -3.99699509e-02f,
  -8.99426714e-02f, -9.63602290e-02f, 4.43222886e-03f, -2.22261436e-03f, 4.68451828e-02f, -2.38479450e-02f, 1.89821962e-02f, 2.21483931e-02f, -1.25214760e-03f, -8.52632746e-02f,
  4.34255898e-02f, -9.54987630e-02f, 1.46069275e-02f, -3.83457467e-02f, 6.66933954e-02f, 4.41537462e-02f, 3.72633561e-02f, 8.00349861e-02f, -2.03940808e-03f, -4.32158075e-02f,
  3.25894766e-02f, -5.95664605e-02f, 1.89108383e-02f, -3.35328770e-03f, 8.96310620e-03f, -3.76582518e-02f, 9.86482352e-02f, 1.06851636e-02f, -1.04128942e-01f, -6.15598215e-03f,
  3.30538489e-02f, 2.61347163e-02f, 1.06567121e-03f, 1.35404468e-02f, 4.99197580e-02f, -7.14214845e-03f, 2.51633432e-02f, 1.79780107e-02f, -5.43893017e-02f, 6.35124892e-02f,
  -6.29322007e-02f, -2.17399314e-01f, -9.33536515e-03f, 7.52115482e-03f, 6.70453534e-03f, 1.33915152e-02f, 2.05954406e-02f, 2.69526821e-02f, -3.25284824e-02f, 3.60024758e-02f,
  8.50154683e-02f, -5.14710210e-02f, -5.78218885e-02f, 6.27515987e-02f, 1.22829974e-01f, -6.82115927e-02f, 6.56573894e-03f, 6.32682443e-02f, 5.34438416e-02f, 4.97991480e-02f,
  -3.28311957e-02f, 1.44985830e-02f, -8.01876709e-02f, -6.86876327e-02f, -8.53181351e-03f, -4.24728319e-02f, -8.77203867e-02f, -6.63795024e-02f, 7.58975148e-02f, -5.89451380e-02f,
  -1.22214183e-02f, -3.41020316e-01f, 7.65846744e-02f, -4.36459333e-02f, -3.29593420e-02f, 2.31195509e-01f, 2.01126635e-01f, -1.29073992e-01f, -7.05216005e-02f, -2.39872694e-01f,
  -1.56619877e-01f, -1.13323390e-01f, -8.29045102e-02f, -2.44714960e-01f, 3.86389583e-01f, 1.06760405e-01f, 7.70918503e-02f, 1.17377033e-02f, -5.93567938e-02f, -1.00912109e-01f,
  8.38065818e-02f, -1.49428681e-01f, 1.88292153e-02f, -2.10903808e-01f, -1.35192841e-01f, -9.25457031e-02f, 1.80522531e-01f, -1.92148071e-02f, -1.35759518e-01f, 7.13565946e-02f,
  -4.82899463e-03f, -1.98077604e-01f, -3.17886882e-02f, -1.28009589e-03f, 1.02215186e-01f, 4.19219136e-02f, 1.66203126e-01f, 7.68407360e-02f, -1.76378209e-02f, -5.69993183e-02f,
  4.01280820e-03f, -6.28140867e-02f, -6.65755346e-02f, -3.93262878e-02f, -6.51948750e-02f, -6.32789209e-02f, 4.19642916e-03f, 6.21629953e-02f, -3.26669440e-02f, -3.50781381e-02f,
  1.83711555e-02f, 6.29100204e-02f, 1.87647119e-02f, -5.71875134e-03f, 1.01279251e-01f, -4.61678356e-02f, 1.01840556e-01f, 1.00740105e-01f, 4.93878126e-02f, 2.44845753e-03f,
  -7.79631361e-02f, -5.41105773e-03f, -3.43635865e-02f, -7.35159591e-02f, -1.66754052e-02f, -3.83250415e-02f, 2.71494556e-02f, 2.65245587e-02f, 6.34173974e-02f, -9.09608789e-03f,
  1.03377491e-01f, -2.73807533e-02f, -5.07851243e-02f, -7.32637793e-02f, 2.15675253e-02f, 9.02729016e-03f, 2.04165578e-02f, -4.10527661e-02f, 2.94332933e-02f, -2.19973046e-02f,
  -4.16016877e-02f, 5.95810264e-02f, -4.41653701e-03f, 1.50613055e-01f, 2.81246621e-02f, -1.67194512e-02f, -1.21393010e-01f, -5.12262024e-02f, -1.77442271e-03f, 1.09484293e-01f,
  5.13466671e-02f, -1.40105024e-01f, 2.44910587e-02f, 1.05059370e-02f, 1.43793598e-02f, 4.17175964e-02f, -1.28386747e-02f, -1.87644158e-02f, -4.25902568e-03f, -4.11880808e-03f,
  -1.89519450e-02f, 5.71144894e-02f, 1.95492469e-02f, -6.91189542e-02f, 9.07840803e-02f, -7.77326599e-02f, -2.25645993e-02f, 8.23465958e-02f, 5.22348732e-02f, -2.79837791e-02f,
  -3.88765596e-02f, -7.05520809e-02f, 9.83480737e-02f, 5.07475585e-02f, -9.50302556e-03f, 8.01013708e-02f, -4.50688004e-02f, -1.70779098e-02f, -3.00586969e-02f, -2.27406491e-02f,
  1.75682068e-01f, 9.43665802e-02f, -3.53959762e-02f, 1.39042526e-01f, 7.94405937e-02f, -1.91101268e-01f, -2.63994247e-01f, 2.83432454e-01f, 2.09172219e-01f, -2.42525563e-01f,
  -6.25648797e-02f, 1.10287480e-01f, -2.38880187e-01f, -2.55296864e-02f, 7.46399164e-02f, -1.08433791e-01f, -3.33979726e-02f, -5.35306409e-02f, 1.50897339e-01f, 1.14354104e-01f,
  8.33963230e-02f, -1.30054727e-01f, 2.57394388e-02f, -4.36876551e-04f, 1.20314714e-02f, 1.27713501e-01f, -2.48965211e-02f, -1.14883624e-01f, -2.72745434e-02f, -8.23277608e-02f,
  -1.75187737e-02f, 8.96593779e-02f, 2.61742827e-02f, 1.06370807e-01f, -2.56940327e-03f, 4.40676883e-02f, -5.44316135e-02f, -1.18122958e-01f, -2.26918962e-02f, -9.02371630e-02f,
  2.67196931e-02f, 1.44296801e-02f, 2.26512142e-02f, 8.74254387e-03f, 9.35446396e-02f, -1.56448595e-02f, 9.21662748e-02f, 4.72160913e-02f, 5.32887205e-02f, 6.47995919e-02f,
  -3.32165975e-03f, 9.08201784e-02f, 9.23341289e-02f, -1.15037031e-01f, -5.32402769e-02f, -3.26934680e-02f, -6.25294894e-02f, -1.65718868e-02f, -4.97399941e-02f, -4.55425913e-03f,
  -7.93130603e-03f, -1.36778932e-02f, -3.48455310e-02f, 9.24488381e-02f, -7.10939150e-03f, 2.73705348e-02f, -2.56688297e-02f, 4.41079997e-02f, 1.61126889e-02f, 7.78196566e-03f,
  1.05221786e-01f, 1.11472003e-01f, 6.14216067e-02f, 3.30802053e-02f, 2.59052832e-02f, 9.62012336e-02f, -4.85853031e-02f, -8.07903707e-02f, 1.01931296e-01f, 9.16482210e-02f,
  -1.66353397e-02f, -1.44515615e-02f, 1.49726257e-01f, -2.01539956e-02f, 8.16320011e-04f, -3.68024828e-03f, -8.29516351e-03f, 8.36929381e-02f, 1.07488642e-02f, -6.84577972e-02f,
  8.38129893e-02f, 1.82166025e-01f, -5.02965190e-02f, 9.42079201e-02f, -1.17858775e-01f, 5.62277175e-02f, 2.05182936e-02f, 5.98642901e-02f, -8.39612335e-02f, -2.70322170e-02f,
  -3.85323018e-02f, -9.04067531e-02f, -1.64563470e-02f, -1.20228909e-01f, 2.27050483e-02f, -2.84155253e-02f, -5.22771326e-04f, -6.66389391e-02f, -9.59211811e-02f, -4.08828631e-03f,
  3.52545567e-02f, -8.75503123e-02f, -3.62170078e-02f, -2.61551570e-02f, 4.90613505e-02f, 3.30856964e-02f, 3.91990356e-02f, 5.17230183e-02f, -1.09813381e-02f, -2.85600424e-02f,
  1.47538379e-01f, 2.40443349e-01f, -2.94353545e-01f, 4.75607887e-02f, 1.94925871e-02f, 1.45559222e-01f, 1.30350962e-01f, 1.14026427e-01f, -6.27292469e-02f, 1.81666300e-01f,
  8.17853436e-02f, -5.84618114e-02f, -7.32823312e-02f, 2.85798192e-01f, -3.57872069e-01f, -2.56720454e-01f, 1.71732068e-01f, 2.03089073e-01f, -1.37336209e-01f, 1.56348214e-01f,
  -1.66037217e-01f, 2.50415206e-01f, -4.56890576e-02f, 2.31278408e-02f, 1.98704824e-01f, -5.50112911e-02f, 1.06424212e-01f, -1.57151878e-01f, 2.02628076e-01f, -4.21114601e-02f,
  1.32392257e-01f, 6.29529939e-04f, -2.23076058e-04f, -8.21177736e-02f, 6.15102351e-02f, 1.42392935e-02f, -3.03270128e-02f, -6.71632439e-02f, -4.68964204e-02f, -2.15741266e-02f,
  1.37173776e-02f, -1.85628645e-02f, 4.53707762e-02f, -1.01121478e-01f, 5.86775988e-02f, -6.30014017e-02f, -6.38627708e-02f, 4.71813455e-02f, 5.37779778e-02f, -7.02340007e-02f,
  -7.39171654e-02f, -6.28299564e-02f, 5.14052846e-02f, 7.44993519e-03f, -1.45318016e-01f, -2.86765266e-02f, -6.04838878e-02f, 1.33827804e-02f, 3.41193266e-02f, 4.52929288e-02f,
  -3.49409804e-02f, -5.87236024e-02f, 2.53262185e-02f, 4.41411361e-02f, 5.07578179e-02f, 4.92245518e-02f, 1.01131210e-02f, 4.16382924e-02f, -2.03161757e-03f, 3.45735550e-02f,
  9.46944952e-02f, 1.68824557e-03f, 3.40959094e-02f, 3.51549834e-02f, -6.38218224e-03f, 4.35834937e-02f, -2.13092528e-02f, 9.74330753e-02f, 2.00101435e-02f, -1.44089349e-02f,
  -1.70692280e-02f, 2.08994914e-02f, 5.05860001e-02f, 4.73830849e-02f, -4.89301793e-03f, -2.23568939e-02f, 1.67016927e-02f, -5.08522382e-03f, -5.24567105e-02f, -5.89667857e-02f,
  2.46446073e-01f, 1.16745763e-01f, 3.31464559e-02f, 8.93322974e-02f, 4.25026231e-02f, 1.37362778e-02f, -7.03093708e-02f, -6.31493255e-02f, 3.43959481e-02f, 2.45615412e-02f,
  -2.72082463e-02f, 7.68211260e-02f, 4.06812318e-02f, 6.09317236e-02f, -3.99873368e-02f, 2.49681640e-02f, 7.11685792e-02f, 3.31507698e-02f, 4.05021086e-02f, 2.86156442e-02f,
  6.17693327e-02f, 1.67079624e-02f, -1.24390811e-01f, -7.14973686e-03f, 5.40759712e-02f, 3.87950465e-02f, 2.56086811e-02f, -1.35629028e-01f, -3.05331200e-02f, -2.27363743e-02f,
  -3.07657421e-01f, 5.95724136e-02f, -1.46237716e-01f, -1.91923082e-01f, 1.82512909e-01f, -1.74994111e-01f, -1.41686788e-02f, -3.39883789e-02f, -2.33939305e-01f, 2.67117769e-01f,
  -1.06045090e-01f, -1.39120100e-02f, -6.37270287e-02f, -1.31510764e-01f, -3.69228810e-01f, -2.54866272e-01f, -1.81108370e-01f, -4.23843134e-03f, -1.86562687e-01f, -1.63648911e-02f,
  -1.72954470e-01f, 1.54302299e-01f, -1.45247385e-01f, 1.18451819e-01f, 1.20400235e-01f, 1.77223593e-01f, 1.81565791e-01f, 1.07614614e-01f, 1.09320492e-01f, 5.55891879e-02f,
  -1.24379911e-01f, 1.37840835e-02f, 8.28376487e-02f, -1.23184791e-03f, -3.47136706e-02f, 7.73951337e-02f, 4.57160920e-02f, 3.69351096e-02f, -1.53301544e-02f, -1.74181089e-02f,
  6.56319410e-02f, -9.12142619e-02f, -1.60923470e-02f, -1.26411906e-02f, 9.45384149e-03f, -5.63110188e-02f, -3.99522595e-02f, 1.21022612e-02f, 2.55402382e-02f, -5.93631454e-02f,
  -6.34481683e-02f, -5.95531054e-02f, 2.96291523e-02f, -5.76563478e-02f, -4.21913788e-02f, -7.76937045e-03f, -4.48678583e-02f, 7.65121058e-02f, -3.43570709e-02f, -1.14544727e-01f,
  4.23035137e-02f, 3.68853507e-04f, 4.49334830e-02f, -3.06446329e-02f, -2.55479123e-02f, 4.22750078e-02f, 8.52188189e-03f, 4.00038362e-02f, 3.25772949e-02f, -4.08840850e-02f,
  -6.37619272e-02f, 3.76164205e-02f, 3.52609195e-02f, -1.24196114e-04f, 3.17812711e-02f, 3.26987542e-02f, -3.01788561e-02f, 1.89065505e-02f, -1.28336161e-01f, -2.29268800e-02f,
  6.19763359e-02f, -6.09381124e-02f, 4.51512111e-04f, -2.79728952e-03f, -4.50497977e-02f, 3.28446850e-02f, 4.59019691e-02f, 1.74666836e-03f, 6.66296296e-03f, 3.09000202e-02f,
  -1.03366904e-01f, -1.06496429e-02f, 2.74296937e-04f, -1.49874883e-02f, 5.98357208e-02f, 4.87065129e-02f, -7.71135017e-02f, 4.13231552e-02f, -5.98774664e-02f, -9.89372469e-03f,
  2.67189499e-02f, 9.91509780e-02f, -1.00965975e-02f, -2.30779452e-03f, 1.06632290e-03f, -7.66882033e-04f, 1.82022452e-02f, 9.13021490e-02f, 7.40379095e-02f, -3.33603062e-02f,
  1.17778189e-01f, 4.38849702e-02f, 3.65440957e-02f, 6.78736642e-02f, -1.89721435e-02f, 5.46287149e-02f, 1.09454557e-01f, -5.33739291e-02f, 8.51360988e-03f, -1.31009435e-02f,
  1.78114668e-01f, 2.05266789e-01f, -1.51804790e-01f, -1.87019601e-01f, 1.24070868e-01f, 1.99734241e-01f, 9.16542485e-02f, 4.71940003e-02f, 6.64725602e-02f, 1.87229589e-01f,
  -1.50034815e-01f, 1.70616373e-01f, -1.77607611e-01f, 1.16346024e-01f, 9.49237943e-02f, -1.17038906e-01f, 1.34305701e-01f, 1.57131225e-01f, -1.44833535e-01f, -5.41238301e-03f,
  -9.69302729e-02f, 7.55633786e-02f, -1.48076594e-01f, -3.24750729e-02f, 1.88459679e-01f, -1.20175760e-02f, -1.26958191e-01f, -1.55071273e-01f, 1.97237894e-01f, 8.76345336e-02f,
  1.43830523e-01f, -2.69244909e-02f, 2.17425525e-02f, 1.01121023e-01f, 1.03586771e-01f, 1.87967368e-03f, -6.66713342e-02f, -1.29537597e-01f, -3.52814570e-02f, -5.45826964e-02f,
  5.90021312e-02f, 3.40359099e-02f, 5.77338561e-02f, -2.90081818e-02f, 5.14736250e-02f, 1.36289292e-03f, 4.40291502e-02f, -1.68960802e-02f, 5.51290028e-02f, -8.90226755e-03f,
  -1.09442174e-02f, -8.13518278e-03f, -2.16226038e-02f, -3.80953103e-02f, -1.08213596e-01f, -2.06249617e-02f, -7.69938007e-02f, 4.75757197e-03f, 7.37350881e-02f, 1.01622909e-01f,
  -1.31186426e-01f, -3.70272249e-02f, 3.05928919e-03f, 1.45175597e-02f, 3.83242406e-02f, -4.61597443e-02f, 5.66967241e-02f, 9.08517372e-03f, 5.49158268e-02f, -1.57552790e-02f,
  7.57630765e-02f, 6.32291585e-02f, -7.45221525e-02f, 5.63789485e-03f, -2.19287686e-02f, 1.35553321e-02f, 3.67531553e-03f, 8.65648910e-02f, -8.05842318e-03f, 8.93678702e-03f,
  -7.15188682e-02f, 4.15245108e-02f, 1.71628948e-02f, 5.58417551e-02f, -5.04388027e-02f, -1.69373546e-02f, -4.23604622e-02f, 3.55959423e-02f, -6.20071068e-02f, -1.65367499e-02f,
  2.35890880e-01f, 1.04736619e-01f, 4.16305149e-03f, 1.32168487e-01f, -1.94391217e-02f, 3.30572315e-02f, -7.68574700e-02f, 2.23652553e-02f, -3.86910774e-02f, 1.94478575e-02f,
  -4.27068211e-02f, -9.88316443e-03f, 3.60287982e-03f, 7.31928423e-02f, -3.73276956e-02f, -4.15490977e-02f, -7.25624263e-02f, 4.17141467e-02f, 1.71217378e-02f, 4.43632565e-02f,
  6.42455295e-02f, -7.45296776e-02f, -1.11209810e-01f, 1.99334547e-02f, 3.98720130e-02f, 6.36435077e-02f, -5.05905189e-02f, -2.52057444e-02f, 9.99235362e-02f, -2.03947909e-02f,
  -1.86283305e-01f, 3.64277154e-01f, -7.07411841e-02f, 5.94558567e-03f, -1.60749808e-01f, 1.13488138e-01f, -7.28516653e-02f, 2.05084845e-01f, 1.73366353e-01f, 3.65094721e-01f,
  3.16951312e-02f, 8.52425545e-02f, 7.63842929e-03f, 3.61238003e-01f, -6.53620949e-03f, 1.88829601e-01f, 2.59937286e-01f, 7.96075165e-02f, 1.63279101e-01f, -1.23052828e-01f,
  2.58018281e-02f, 1.94922656e-01f, -6.19646311e-02f, 3.40992697e-02f, 9.26601365e-02f, -1.63947955e-01f, -9.26911756e-02f, -2.26259962e-01f, 1.28945470e-01f, -2.30121836e-02f,
  3.02032344e-02f, 9.39608887e-02f, 2.39483025e-02f, -5.67305461e-02f, -1.28245279e-01f, -7.31254295e-02f, -9.18727741e-02f, -1.27484322e-01f, -1.07912429e-01f, -6.78083114e-03f,
  -8.09748694e-02f, 5.62169105e-02f, -2.20869714e-03f, 6.36796430e-02f, 1.13814855e-02f, 4.05592956e-02f, 1.04526833e-01f, 8.93738642e-02f, 1.21968448e-01f, 6.27757087e-02f,
  -2.72568921e-03f, 7.26196542e-03f, 5.34229726e-03f, -3.09716035e-02f, 1.69289391e-02f, -5.83293214e-02f, 3.87145043e-03f, -9.28294733e-02f, 6.52663112e-02f, 9.37877074e-02f,
  1.46363769e-03f, 2.70758905e-02f, -5.12276441e-02f, 2.42121834e-02f, -5.87131036e-03f, -3.72755453e-02f, 1.40171856e-01f, 1.04906140e-02f, -2.42226832e-02f, -4.56856331e-03f,
  -4.14498989e-03f, -4.81673377e-03f, 1.02362737e-01f, 9.83892754e-03f, -1.58274565e-02f, -3.85757512e-03f, -5.08572757e-02f, 4.36489582e-02f, -4.93334457e-02f, 6.35813549e-02f,
  -3.64529230e-02f, 5.87086789e-02f, -2.49938276e-02f, -2.97300480e-02f, 1.00936256e-01f, -2.98997723e-02f, 9.83600318e-03f, 3.39942090e-02f, -4.11462449e-02f, -1.22602126e-02f,
  1.07541859e-01f, 1.88018635e-01f, 9.91095975e-03f, -1.20755574e-02f, 3.62962894e-02f, 1.71560012e-02f, 6.84114695e-02f, 5.41442782e-02f, 1.24457721e-02f, 1.56847127e-02f,
  -1.06000476e-01f, -8.08478966e-02f, 3.30284908e-02f, 1.33309392e-02f, 4.33637537e-02f, -4.02374240e-03f, -3.58220562e-02f, -1.13879465e-01f, 1.79453716e-02f, -5.37079796e-02f,
  -3.23297605e-02f, -3.26591693e-02f, -4.90114614e-02f, 7.08189830e-02f, 2.52108858e-03f, -6.61174208e-02f, 4.38676439e-02f, -1.47878239e-02f, 7.46184140e-02f, 8.99499133e-02f,
  -2.56868064e-01f, -1.09867074e-01f, 2.04726681e-01f, -2.50579447e-01f, -5.78430407e-02f, 1.93046734e-01f, 2.91341901e-01f, -2.00932875e-01f, -1.78240985e-01f, 1.94112286e-02f,
  -2.05442756e-01f, 1.51437834e-01f, 2.11233184e-01f, -1.09246127e-01f, 3.35255675e-02f, 2.24107206e-01f, -1.11726336e-01f, 1.17389716e-01f, -9.38144326e-02f, -2.18215719e-01f,
  -4.77680676e-02f, -3.29739630e-01f, 1.62513942e-01f, -2.22172454e-01f, -1.92621678e-01f, -1.15570270e-01f, -2.23108724e-01f, 7.68249109e-02f, -1.23774864e-01f, -2.75075678e-02f,
  -9.25018489e-02f, -4.71936539e-02f, 2.94094700e-02f, 1.20867394e-01f, -1.74560603e-02f, 6.70414791e-02f, 8.36471394e-02f, 1.56090155e-01f, 6.61939159e-02f, -2.24271584e-02f,
  3.24782990e-02f, 1.05357291e-02f, -1.41906634e-01f, 4.17859927e-02f, 3.92049458e-03f, -8.94168566e-04f, 5.55266179e-02f, 4.75304164e-02f, 4.08074670e-02f, -1.18408184e-02f,
  4.58243601e-02f, 6.37434795e-02f, -1.39289610e-02f, 2.39583347e-02f, 7.39724040e-02f, -3.28223556e-02f, 1.28761917e-01f, 5.14322147e-02f, -4.99889441e-02f, -6.24334253e-02f,
  6.81677088e-02f, 1.82582438e-03f, -1.24669699e-02f, -3.55521962e-02f, -8.53268206e-02f, 1.29232472e-02f, -2.53911279e-02f, 4.93774144e-03f, 3.07737421e-02f, 1.41732134e-02f,
  -4.77061607e-02f, 1.26667917e-02f, -3.64201441e-02f, 3.38973268e-03f, -3.10168695e-03f, -1.04964137e-01f, 1.04884259e-01f, -4.42251861e-02f, 3.04407682e-02f, 5.19004092e-02f,
  1.71583856e-03f, -4.10829522e-02f, -7.72828087e-02f, 9.20410752e-02f, -4.74471692e-03f, 2.39985846e-02f, -9.16975588e-02f, 5.97653687e-02f, 3.76993604e-02f, 9.59770940e-03f,
  -1.96482882e-01f, -3.14366192e-01f, 1.17012978e-01f, -8.42914134e-02f, -2.27353014e-02f, 2.04762304e-03f, 4.23863083e-02f, 2.65929406e-03f, -9.26121920e-02f, -6.18173368e-02f,
  4.16609421e-02f, 3.38659510e-02f, -2.47408263e-02f, -1.10789593e-02f, 6.41135201e-02f, 2.23187748e-02f, 8.71312153e-03f, -2.71900631e-02f, -8.45710039e-02f, -7.01826289e-02f,
  -9.19351727e-02f, -2.74784165e-03f, 5.15523218e-02f, -7.79162645e-02f, -1.12198908e-02f, -3.06392461e-02f, -1.36745647e-01f, 8.15950613e-03f, 9.22804251e-02f, 6.14173338e-02f,
  4.44075912e-01f, -2.68660992e-01f, -1.39137402e-01f, 3.34684283e-01f, 3.65258716e-02f, 9.19541121e-02f, 9.96752903e-02f, 2.30190735e-02f, 2.94061989e-01f, -2.03844354e-01f,
  -4.51305024e-02f, 8.63754675e-02f, -1.19070455e-01f, 2.34572664e-02f, 2.89793223e-01f, 1.45536065e-01f, 1.48158178e-01f, 3.44192563e-03f, 1.43999323e-01f, 6.18058853e-02f,
  1.02948777e-01f, 2.81157553e-01f, -9.14508775e-02f, -9.69523937e-02f, -9.09462869e-02f, -9.29683223e-02f, -1.66248698e-02f, -1.62797734e-01f, -8.68715346e-02f, 1.81548335e-02f,
  -6.62764385e-02f, 1.41712114e-01f, -1.36062816e-01f, -3.55492458e-02f, -7.03861564e-03f, -1.33124599e-02f, -1.08350992e-01f, -3.67077962e-02f, 5.62496185e-02f, -1.83595698e-02f,
  1.90147031e-02f, 5.39678223e-02f, 8.00703242e-02f, 4.53618802e-02f, -3.14650461e-02f, 3.29496711e-02f, -4.31548506e-02f, -9.56394449e-02f, -2.51889843e-02f, 6.03417903e-02f,
  7.23127322e-03f, -7.83978850e-02f, 6.21806011e-02f, -7.85942301e-02f, 1.98074616e-02f, 8.91955644e-02f, -1.05276983e-02f, -8.57550725e-02f, 2.05770824e-02f, 7.08175898e-02f,
  2.18878463e-02f, 5.94207235e-02f, 2.58506718e-03f, 1.95060968e-02f, 1.66796207e-01f, -3.53975482e-02f, -9.66107845e-03f, -6.10341728e-02f, -2.33610403e-02f, -4.73867869e-03f,
  2.80461516e-02f, 3.86525132e-02f, -2.86396872e-02f, 6.02889024e-02f, 5.49662411e-02f, -1.56244347e-02f, 4.03811783e-02f, -1.17091946e-01f, 5.68190776e-02f, -7.58491457e-02f,
  -2.53552757e-02f, 4.65770103e-02f, -9.94980335e-02f, -1.20143786e-01f, -3.76817547e-02f, 1.34016871e-02f, 1.31605668e-02f, -9.43879038e-02f, -6.85392544e-02f, -3.95112485e-02f,
  -6.39774725e-02f, 5.65458871e-02f, 4.54434603e-02f, -5.83117865e-02f, -2.37182551e-03f, -8.89336399e-04f, 5.85691109e-02f, 2.21081264e-03f, 5.94693050e-02f, 1.02595270e-01f,
  -3.27827483e-02f, -5.91988787e-02f, -7.01139793e-02f, -2.50470769e-02f, 4.27872390e-02f, 1.62867755e-02f, 3.54507845e-03f, -2.68234517e-02f, -4.28057183e-03f, -1.34945801e-02f,
  -4.01764959e-02f, -4.08276590e-03f, 1.08015854e-02f, 1.25259414e-01f, -1.63882561e-02f, -7.37991184e-02f, 8.48044083e-02f, -2.93586981e-02f, 1.28157232e-02f, -2.61093657e-02f,
  -1.25538530e-02f, 1.45729437e-01f, 4.66706930e-03f, 1.37448162e-01f, -2.66007751e-01f, -2.78971493e-01f, -2.28424259e-02f, -2.05813512e-01f, 2.24655658e-01f, 1.07125707e-01f,
  4.00880771e-03f, 2.76765913e-01f, 2.23749980e-01f, 1.10599376e-01f, 4.18813787e-02f, 2.78185844e-01f, 6.42376626e-03f, 5.37912436e-02f, 1.36881113e-01f, -5.04940897e-02f,
  6.45456687e-02f, 4.04816307e-02f, 1.15839735e-01f, -4.28797714e-02f, -1.64709464e-01f, 3.14521305e-02f, 1.25261946e-02f, -2.09181607e-02f, -1.17287204e-01f, -4.16167229e-02f,
  1.07927050e-03f, 1.08112708e-01f, 1.63402513e-03f, 2.41774023e-02f, -4.49901037e-02f, -1.03927784e-01f, 7.48240680e-04f, 8.86472464e-02f, -5.73193170e-02f, 6.28007622e-03f,
  -4.55545671e-02f, 2.19118986e-02f, 8.94683748e-02f, 6.76539540e-02f, -1.34095952e-01f, 7.05618858e-02f, -1.21505018e-02f, -2.16145515e-02f, 3.10780182e-02f, 1.08619362e-01f,
  -2.76541337e-02f, 6.58193529e-02f, -1.41972438e-01f, 7.43986964e-02f, 4.48446870e-02f, -8.89085457e-02f, 2.46676393e-02f, 5.43016568e-02f, -3.41580398e-02f, 9.58818719e-02f,
  9.22172517e-02f, 6.85534626e-02f, 6.89959526e-02f, -7.49142617e-02f, 8.53139616e-04f, -2.86875665e-02f, 5.37617840e-02f, 8.30664113e-03f, 1.45490002e-03f, 2.42096502e-02f,
  -7.85733908e-02f, 1.25084515e-03f, -6.12357222e-02f, -9.68585312e-02f, -4.69255745e-02f, 5.22363931e-02f, -8.96354914e-02f, 1.02135930e-02f, -1.55005172e-01f, -1.38334334e-01f,
  4.05276902e-02f, -1.23463131e-01f, -3.85530409e-03f, -3.24996635e-02f, 6.76009282e-02f, 2.84690596e-02f, 5.26900496e-03f, -7.26005286e-02f, -3.68775614e-02f, -8.82789791e-02f,
  -5.97609580e-03f, 1.94882184e-01f, -2.09650397e-02f, -5.84606938e-02f, 4.63989116e-02f, -1.63406610e-01f, 1.72799807e-02f, -8.98992494e-02f, -9.25229324e-06f, -6.54249415e-02f,
  -8.08776021e-02f, -5.66890649e-02f, -4.56928574e-02f, -5.49511909e-02f, 4.36019823e-02f, -6.47418424e-02f, -4.46252562e-02f, 5.22527769e-02f, -1.33550391e-02f, -3.04039847e-02f,
  -5.02114631e-02f, 1.92492846e-02f, -5.36560174e-03f, -2.62632053e-02f, -1.39930593e-02f, 3.28037478e-02f, -4.19348702e-02f, 4.57046228e-03f, 4.40269336e-02f, 9.27674025e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.58526719e-01f, 1.17983267e-01f, -3.16797107e-01f, -1.65183377e-02f, -3.93792421e-01f, -1.91265047e-01f, 8.70332643e-02f, -5.82545549e-02f, 7.22122863e-02f, 2.99137592e-01f,
  -5.40630631e-02f, 1.14174217e-01f, 1.92043230e-01f, -2.02631932e-02f, -2.22666070e-01f, 4.40857202e-01f, 1.28291413e-01f, 2.64957279e-01f, -9.44941789e-02f, -2.07460690e-02f,
  -7.70923644e-02f, -5.83956055e-02f, -1.58453688e-01f, -1.74312051e-02f, -2.86713034e-01f, -2.27834746e-01f, -1.77105293e-01f, -1.65399194e-01f, -2.22561479e-01f, -2.58190900e-01f,
  -9.36854631e-02f, -1.24068357e-01f, -7.84491822e-02f, 4.04015779e-02f, -2.39650514e-02f, 8.09695572e-02f, 3.81339807e-03f, -1.62221223e-01f, 2.06380151e-02f, 7.91049004e-02f,
  2.96166632e-02f, 3.44499946e-03f, 2.52560768e-02f, -9.18508973e-03f, -3.88463549e-02f, -4.21016552e-02f, -9.80729610e-02f, -6.30760267e-02f, -6.64003147e-03f, -7.28090352e-04f,
  -3.33502479e-02f, 6.69135014e-03f, -2.74199490e-02f, 1.12336978e-01f, -8.50196183e-02f, 7.13015273e-02f, -5.20560220e-02f, -6.61809072e-02f, 6.48974776e-02f, -5.01305498e-02f,
  3.74622121e-02f, 8.19368586e-02f, 4.65398878e-02f, -4.24598120e-02f, -1.05036825e-01f, -7.76883736e-02f, 1.94648094e-02f, -7.53970742e-02f, 3.00766192e-02f, 3.20193693e-02f,
  -6.80534318e-02f, -4.82451543e-02f, -2.03298870e-02f, 3.36612500e-02f, 7.04048127e-02f, 1.05970442e-01f, 1.17312975e-01f, 2.67308336e-02f, 4.89550084e-02f, 4.36419696e-02f,
  5.17069502e-03f, -1.02081373e-01f, -1.40074128e-03f, 4.64327727e-03f, 3.65134142e-02f, -8.99403617e-02f, -1.42449047e-02f, -1.02424771e-01f, 4.63498523e-03f, -2.00235955e-02f,
  1.09166056e-02f, 1.30549654e-01f, 1.08333521e-01f, 6.42490536e-02f, 1.49504527e-01f, -5.54504581e-02f, -8.65186229e-02f, 3.42543609e-02f, -8.42658952e-02f, 1.11773267e-01f,
  8.16293210e-02f, 1.10073991e-01f, 4.07886282e-02f, 1.46388030e-02f, -8.73825420e-03f, -8.71188268e-02f, 9.31815505e-02f, 1.20895773e-01f, -9.74553823e-02f, -7.14217052e-02f,
  1.98950246e-02f, 4.27740850e-02f, 1.32265091e-01f, 1.02451712e-01f, 1.84424579e-01f, -2.77363677e-02f, -1.26773804e-01f, -1.04594259e-02f, -1.18734159e-01f, 5.49299680e-02f,
  1.68488175e-02f, 3.85503918e-02f, -2.33652353e-01f, -3.46665114e-01f, -2.77089141e-02f, -1.80423081e-01f, -2.83803880e-01f, -1.28485665e-01f, -5.72663099e-02f, -2.33590022e-01f,
  -2.35579610e-01f, 7.23413378e-02f, 2.87717193e-01f, -2.58244395e-01f, 1.41210914e-01f, 2.59527117e-01f, -2.53652394e-01f, -2.14087069e-01f, 1.74718909e-02f, -3.87277268e-02f,
  -1.38368055e-01f, -1.84928477e-01f, -1.43545210e-01f, 2.11298447e-02f, -2.36796170e-01f, -1.07567608e-01f, -4.44421135e-02f, -1.03242896e-01f, -1.86672419e-01f, -1.18227648e-02f,
  -4.91740834e-03f, -1.45143807e-01f, 6.18516430e-02f, -9.18844417e-02f, 1.01153394e-02f, -4.33108024e-02f, -1.03905611e-01f, 2.18938198e-03f, -3.63061056e-02f, -4.70172800e-02f,
  -1.54890595e-02f, 1.78177670e-01f, -2.29648477e-03f, 1.01127066e-01f, -1.26608834e-01f, -2.05199167e-01f, 4.73666973e-02f, -1.99407432e-02f, 1.10550225e-01f, 6.49496764e-02f,
  -2.94212457e-02f, -9.67336521e-02f, -1.91991687e-01f, -1.16445772e-01f, -2.31519416e-02f, -6.70754239e-02f, 8.24080110e-02f, -9.84412730e-02f, -1.50062382e-01f, -3.69279198e-02f,
  5.36485054e-02f, -3.20366248e-02f, 3.72867510e-02f, -5.38619943e-02f, 6.03930503e-02f, 2.98424847e-02f, -7.84169361e-02f, -1.40307080e-02f, -5.20735979e-02f, 4.15967479e-02f,
  -5.14369793e-02f, -2.24576723e-02f, 3.05557484e-03f, -1.70930743e-01f, 3.95293124e-02f, -3.88122723e-02f, 9.83032212e-02f, 2.59326883e-02f, -3.10847498e-02f, -6.06471412e-02f,
  -8.47752988e-02f, 2.55080815e-02f, 3.46513912e-02f, -4.95257676e-02f, -1.03475004e-01f, 2.16233134e-02f, -7.73974732e-02f, 6.21125437e-02f, -2.71664769e-03f, 1.53666034e-01f,
  -7.55531667e-03f, -1.16409056e-01f, 5.43639474e-02f, 4.29248624e-03f, 8.46318379e-02f, 4.97321934e-02f, 2.22944953e-02f, -1.25551179e-01f, -6.39535934e-02f, -1.02799267e-01f,
  -9.99953002e-02f, -3.93074714e-02f, -5.69354445e-02f, -1.57002419e-01f, 1.16342781e-02f, 8.48121196e-02f, 3.03585716e-02f, -1.07433908e-01f, 9.43258498e-03f, -2.49240212e-02f,
  2.06772573e-02f, 2.64148582e-02f, 1.05873041e-01f, -9.90241840e-02f, -5.02018072e-02f, -6.26367256e-02f, 4.38680537e-02f, -3.72221284e-02f, 4.57412414e-02f, -8.70432258e-02f,
  2.47285530e-01f, 3.76610786e-01f, 3.30634296e-01f, 1.84722707e-01f, -3.04432452e-01f, -1.14829101e-01f, 1.36939883e-01f, 7.30290562e-02f, 2.47570097e-01f, 1.35242477e-01f,
  -3.49938571e-01f, 5.20558953e-01f, -4.98056673e-02f, -1.35921091e-01f, 5.96376248e-02f, -8.39873105e-02f, -4.68228534e-02f, -8.52609873e-02f, -2.63997391e-02f, 1.95167914e-01f,
  1.10982023e-01f, -2.10819453e-01f, 3.30014005e-02f, -2.15835184e-01f, 1.94751993e-02f, 1.67997405e-01f, -2.42962122e-01f, -5.17380890e-03f, -3.93102430e-02f, -2.14048922e-02f,
  -1.25751004e-01f, -2.84012221e-03f, 3.01946766e-05f, 2.08675326e-03f, -5.05905040e-02f, -1.46949226e-02f, 6.21213205e-02f, -2.99854223e-02f, 6.76684529e-02f, -1.53196901e-02f,
  4.42699827e-02f, 1.39061019e-01f, 1.44706443e-01f, 7.50996172e-02f, -8.23656768e-02f, -7.91388284e-03f, -7.49386773e-02f, -1.03112496e-01f, 2.78084595e-02f, -3.83152999e-02f,
  -6.83093295e-02f, 6.06214479e-02f, 2.54514394e-03f, -1.96052361e-02f, 2.00906843e-01f, -3.73719968e-02f, -1.14148855e-02f, 6.67886287e-02f, -2.25933380e-02f, 1.59422189e-01f,
  -1.75698221e-01f, -1.78216351e-03f, -4.36880812e-02f, 1.34172231e-01f, -7.80736282e-02f, -1.19554162e-01f, -6.18434884e-02f, -1.37937814e-02f, 1.11406237e-01f, -1.27659351e-01f,
  -9.60662216e-02f, 4.39610556e-02f, -5.26399836e-02f, -1.60622433e-01f, -9.03105736e-02f, 2.03855872e-01f, 1.08521849e-01f, -7.50303194e-02f, 3.88686582e-02f, 5.87230250e-02f,
  -3.47218402e-02f, -6.18873350e-02f, 1.52360322e-02f, -1.45726681e-01f, 5.00040352e-02f, 1.56660169e-01f, 2.92277366e-01f, 8.02226551e-03f, -1.72009245e-01f, 1.85484085e-02f,
  -1.07298627e-01f, 2.25744039e-01f, 3.13352644e-02f, -1.40400961e-01f, 4.14065830e-02f, 9.39844474e-02f, -7.10339993e-02f, -1.01592559e-02f, 2.10525915e-01f, -7.57774562e-02f,
  3.74806323e-03f, -5.46451658e-03f, 1.57183930e-01f, -1.23257093e-01f, 8.52267891e-02f, -5.48436046e-02f, 1.21287376e-01f, -1.19829010e-02f, 4.85046618e-02f, -7.02207014e-02f,
  -5.06796427e-02f, 1.65381312e-01f, 4.86579873e-02f, 5.48548959e-02f, -7.76631534e-02f, 7.99358338e-02f, 1.32062301e-01f, -3.23887765e-02f, -1.13597646e-01f, 4.05340008e-02f,
  3.03508729e-01f, -3.00977767e-01f, -3.77106875e-01f, -2.16861263e-01f, 2.10097015e-01f, 3.53232890e-01f, -6.88355863e-02f, 2.02307012e-03f, -4.18639451e-01f, -1.67411380e-02f,
  9.53530595e-02f, -7.34963790e-02f, -2.80226618e-01f, 1.43757671e-01f, 3.40911478e-01f, -3.06215942e-01f, 1.27603292e-01f, 1.97740033e-01f, -1.44901723e-01f, -8.05662125e-02f,
  -1.03710461e-02f, 3.69471788e-01f, -3.09307456e-01f, 1.90506294e-01f, 3.11674416e-01f, -7.44828209e-02f, 1.74891785e-01f, 7.15084001e-03f, 2.71714360e-01f, 1.80468008e-01f,
  5.50653413e-02f, -1.23921551e-01f, -1.33299321e-01f, -6.52021691e-02f, -2.13406552e-02f, 1.27993181e-01f, 1.58381239e-01f, -1.07821841e-02f, 6.53786911e-03f, -6.68461546e-02f,
  1.62292585e-01f, 1.04289502e-01f, -1.51191568e-02f, 7.54577070e-02f, 1.19312763e-01f, -6.58338591e-02f, -1.00104071e-01f, -1.17828891e-01f, -1.62992567e-01f, -6.07863739e-02f,
  -1.43361107e-01f, 6.59779310e-02f, 5.95847219e-02f, -3.71259488e-02f, -8.02636817e-02f, -3.01160896e-03f, 6.38361871e-02f, -3.64180095e-02f, 1.41130656e-01f, -2.39760405e-03f,
  9.62479413e-02f, 9.98840481e-02f, 1.70713235e-02f, -6.70869499e-02f, 4.29861359e-02f, -1.64618772e-02f, 7.82449394e-02f, -1.73128191e-02f, -1.03187986e-01f, -4.69462164e-02f,
  -4.64482903e-02f, 5.47673032e-02f, -5.72366230e-02f, -1.76916402e-02f, -3.14394869e-02f, 4.12641577e-02f, 9.77647528e-02f, 1.27016718e-03f, -2.02633500e-01f, -7.79201388e-02f,
  -2.05446538e-02f, 1.00928500e-01f, -8.57654586e-02f, 6.22362867e-02f, 1.02554195e-01f, -7.72414953e-02f, 1.18324570e-02f, -7.49286339e-02f, -3.91426906e-02f, 7.78700933e-02f,
  5.39370291e-02f, -8.90583843e-02f, -4.04407121e-02f, 3.27168889e-02f, -1.43077955e-01f, 8.90625417e-02f, -9.48276669e-02f, -1.33892938e-01f, 7.23942695e-03f, -1.75725687e-02f,
  1.10616289e-01f, -1.59254838e-02f, 1.02815546e-01f, -8.72238204e-02f, -3.58670540e-02f, -1.70391694e-01f, 3.10709383e-02f, -3.80748659e-02f, -2.48546563e-02f, 3.46489772e-02f,
  -1.20837606e-01f, 6.63341284e-02f, 7.99928457e-02f, 1.11908838e-01f, -7.14277998e-02f, 6.95585981e-02f, 1.35916829e-01f, -4.14546356e-02f, 2.16913074e-01f, -1.32791236e-01f,
  5.29679894e-01f, -1.84400931e-01f, 3.30039769e-01f, 1.99293450e-01f, 1.29114047e-01f, -9.31864604e-02f, 4.09554392e-01f, -1.47205636e-01f, -7.54748955e-02f, -2.01139644e-01f,
  -8.52526128e-02f, 3.60497862e-01f, 3.87860276e-03f, -1.88147292e-01f, -1.00122362e-01f, -3.11120152e-01f, -1.29802302e-01f, 1.59519538e-02f, 9.73267704e-02f, 1.51405767e-01f,
  -3.24092880e-02f, -2.93284029e-01f, 3.84862460e-02f, -3.04184467e-01f, 1.67536393e-01f, 1.61096707e-01f, -3.18372935e-01f, 1.21061742e-01f, -8.58352333e-02f, -1.00602489e-02f,
  5.16427010e-02f, 2.88496558e-02f, 1.96364105e-01f, 1.87410135e-02f, 9.06428918e-02f, 1.16150685e-01f, 2.40830511e-01f, 1.88519247e-02f, 3.52923013e-02f, -3.34228538e-02f,
  1.57256946e-01f, 6.85533136e-02f, -1.71431378e-02f, -1.21465594e-01f, 1.36083141e-01f, 1.70463842e-04f, 9.42182913e-02f, 1.18452542e-01f, 8.37039128e-02f, 1.90663159e-01f,
  2.80862972e-02f, 1.81599259e-01f, 3.26275267e-02f, -6.98176697e-02f, 9.85266045e-02f, 3.58294509e-02f, 1.46983666e-02f, 2.22992420e-01f, -3.33502777e-02f, -1.82286836e-02f,
  -3.99307869e-02f, -6.22635148e-02f, 5.35889156e-02f, 7.56438542e-03f, -8.57410133e-02f, 1.47347882e-01f, -4.39776592e-02f, 1.01553939e-01f, 1.13067828e-01f, -8.41760710e-02f,
  4.98353466e-02f, 1.00801900e-01f, -3.86486873e-02f, -7.24507719e-02f, 4.81580980e-02f, -6.45572226e-03f, 4.60119322e-02f, -6.61042407e-02f, -8.89818836e-03f, 4.43335287e-02f,
  7.05273747e-02f, -2.14795917e-02f, 4.02773321e-02f, 3.24002281e-02f, -7.91485533e-02f, -9.77074504e-02f, 1.02566872e-02f, -3.59590203e-02f, -5.34500666e-02f, -1.96887832e-02f,
  -3.05530697e-01f, -4.58072424e-01f, 1.61062684e-02f, 5.70247583e-02f, -1.16989017e-01f, 5.49972989e-02f, -1.16921850e-01f, -8.15830156e-02f, -2.04003938e-02f, -1.49547026e-01f,
  4.12112512e-02f, 2.90102810e-02f, -8.84738564e-02f, -8.37937556e-03f, -3.42839248e-02f, -1.16126247e-01f, -6.37913123e-02f, -2.69786101e-02f, -5.30632511e-02f, -2.74576116e-02f,
  5.94550930e-02f, -1.22207269e-01f, 4.54197526e-02f, -6.07220223e-03f, -7.94421732e-02f, -6.34689955e-03f, -4.86216582e-02f, -5.09544201e-02f, -3.23454030e-02f, -1.46690421e-02f,
  4.15918767e-01f, 2.18218893e-01f, 2.59282887e-01f, 5.57036817e-01f, -1.71643868e-01f, -2.74059266e-01f, -1.80399686e-01f, 1.66243121e-01f, 4.94963557e-01f, -1.81573898e-01f,
  -1.39472097e-01f, 2.34095663e-01f, -1.46339595e-01f, 1.84977621e-01f, -4.88263741e-02f, -1.03457965e-01f, 1.44472986e-01f, -6.99478909e-02f, 2.01571181e-01f, 2.73650199e-01f,
  2.56949514e-01f, -1.27924249e-01f, 1.24398321e-01f, -2.61129111e-01f, 2.27431267e-01f, 3.33825648e-01f, -3.85984667e-02f, -1.68598220e-01f, -1.53457839e-02f, -2.34928176e-01f,
  -6.73498735e-02f, 2.00192183e-01f, 7.39509612e-02f, -6.09199852e-02f, 7.86835998e-02f, -4.20361990e-03f, 5.33407964e-02f, -1.90078735e-01f, -3.53456698e-02f, -1.11779580e-02f,
  7.03198384e-05f, -1.88252851e-02f, 3.01305521e-02f, -1.22722283e-01f, -6.94831982e-02f, 1.09989710e-01f, 8.65129903e-02f, 1.71899825e-01f, 4.75143567e-02f, 1.12034298e-01f,
  1.39621601e-01f, 9.74173769e-02f, 2.59554517e-02f, -6.02396727e-02f, 1.07385747e-01f, -2.75677200e-02f, -7.06258416e-02f, 1.22926626e-02f, 7.36023262e-02f, 7.87428916e-02f,
  -8.60159025e-02f, 6.72855377e-02f, 2.87599098e-02f, -1.81619786e-02f, 6.93384418e-03f, 7.14823231e-02f, -1.25862388e-02f, -5.03287874e-02f, 6.57860339e-02f, -6.09204434e-02f,
  -1.42145739e-03f, 1.15383036e-01f, -2.77331769e-02f, -4.72592786e-02f, 1.63994417e-01f, 6.13132566e-02f, -8.26285779e-02f, -5.44738881e-02f, 5.48522025e-02f, -1.27881216e-02f,
  3.54148857e-02f, -9.13431123e-02f, -1.09430682e-02f, -1.18670799e-01f, -1.40477061e-01f, 6.67856634e-02f, 1.12409070e-01f, 1.08095117e-01f, 2.47566942e-02f, -1.24421464e-02f,
  -1.22178435e-01f, 1.17096849e-01f, -4.56015281e-02f, -1.70692224e-02f, 3.27028818e-02f, 4.19822559e-02f, 5.89328334e-02f, 6.53594434e-02f, -8.70568007e-02f, -1.04368895e-01f,
  7.37844929e-02f, -2.04574857e-02f, -8.12083483e-02f, -1.14643238e-01f, -6.36172146e-02f, 2.77611855e-02f, 7.44933188e-02f, 1.10926896e-01f, 9.01880022e-03f, 5.59676252e-02f,
  8.07785057e-03f, -1.14452112e-02f, 3.37415449e-02f, -2.65240530e-03f, 8.08769278e-03f, -6.34050462e-03f, -1.68112442e-02f, -2.68439986e-02f, 5.37544070e-03f, 5.55347353e-02f,
  4.18102056e-01f, 6.88415095e-02f, 1.35199666e-01f, 6.33130968e-02f, 2.72852108e-02f, 2.56754369e-01f, -1.96117908e-01f, 2.95870304e-02f, -1.87881604e-01f, -5.48390811e-03f,
  -9.03332978e-02f, 1.12799622e-01f, -3.72970432e-01f, 3.49353403e-01f, -1.88642472e-01f, -2.37645239e-01f, 2.69030869e-01f, 1.69139445e-01f, 3.76932300e-03f, 1.47857934e-01f,
  -7.14676902e-02f, 2.57837512e-02f, -1.73242494e-01f, 8.85181352e-02f, 1.95814475e-01f, 2.62698948e-01f, -1.98985711e-01f, -2.36565962e-01f, 2.36722380e-01f, -1.94384716e-02f,
  9.54398811e-02f, 7.59488791e-02f, -9.25935246e-03f, 1.37269318e-01f, 7.78648034e-02f, 1.85097847e-02f, 1.01066850e-01f, -5.47265692e-04f, -7.34812841e-02f, -7.78891966e-02f,
  8.02898109e-02f, -7.48927006e-03f, 1.75928786e-01f, -1.64054967e-02f, 9.22544226e-02f, 8.53200331e-02f, 4.82630879e-02f, -5.24126776e-02f, 1.07049808e-01f, -1.79048954e-03f,
  4.91652340e-02f, 5.78604341e-02f, 1.50793009e-02f, 9.08428356e-02f, -4.15182672e-02f, 6.57883137e-02f, 6.72001466e-02f, -2.44447612e-03f, 5.38076349e-02f, 7.25434422e-02f,
  6.83178008e-02f, -1.04287557e-01f, 2.70623956e-02f, 8.41745287e-02f, -3.44485864e-02f, 4.00531590e-02f, 7.66679971e-03f, -3.09230983e-02f, -5.99569120e-02f, -1.30099684e-01f,
  2.39780080e-02f, 1.00113591e-02f, -7.01531991e-02f, 5.08162342e-02f, -5.38465790e-02f, 1.56010434e-01f, -3.11893388e-03f, 3.33640687e-02f, -8.09425339e-02f, 4.28607985e-02f,
  -1.05611302e-01f, 6.83323815e-02f, -2.82473005e-02f, 1.25368267e-01f, 1.17065730e-02f, -2.57453099e-02f, 3.83015536e-03f, -5.06921411e-02f, -2.55694836e-02f, 4.36181463e-02f,
  -4.45437804e-02f, -2.33085230e-01f, -4.24638279e-02f, -3.93419079e-02f, -7.29003623e-02f, 1.62656635e-01f, 2.08267029e-02f, 1.07490785e-01f, -3.90790962e-02f, 6.62452308e-03f,
  1.24959901e-01f, 2.24683434e-02f, 6.33122027e-02f, 1.33929141e-02f, 4.06281985e-02f, -4.39365730e-02f, -6.38901368e-02f, -1.47961393e-01f, 8.35039392e-02f, 2.96129528e-02f,
  7.19344243e-02f, 4.33696434e-03f, -1.71013046e-02f, -8.71907920e-04f, 4.44489345e-02f, -7.95393735e-02f, 9.00010485e-03f, -3.32528390e-02f, -6.25329912e-02f, -9.04888362e-02f,
  -2.47123450e-01f, -1.37226015e-01f, 3.98479074e-01f, -1.55230835e-01f, 2.32143328e-01f, 3.89355570e-01f, 2.68669188e-01f, 2.97729313e-01f, 3.33344698e-01f, -2.53319055e-01f,
  -2.38393426e-01f, -2.25212768e-01f, 1.18737645e-01f, -2.46657327e-01f, 4.79130626e-01f, 2.27456510e-01f, -3.45739760e-02f, 5.09196892e-02f, 1.23169482e-01f, 6.74120197e-03f,
  1.90271027e-02f, -1.92522347e-01f, -1.13904536e-01f, -2.69224048e-01f, -2.23634526e-01f, -1.91465169e-01f, -3.94939631e-01f, 1.55125648e-01f, -2.57064432e-01f, 7.50519410e-02f,
  -7.95318633e-02f, -7.82210827e-02f, -1.96047261e-01f, 5.74553618e-03f, 4.32065688e-02f, 5.06041478e-03f, 3.82149704e-02f, 1.07324690e-01f, 5.51271588e-02f, -4.49339710e-02f,
  -8.19762200e-02f, 8.90890658e-02f, -4.16490287e-02f, 2.30256431e-02f, 4.05991040e-02f, -7.40241855e-02f, -1.16206855e-02f, 3.64109054e-02f, 5.18310666e-02f, 2.00655714e-01f,
  7.76142925e-02f, -2.38707382e-02f, 5.51912822e-02f, -3.46531942e-02f, -3.95399481e-02f, -6.46714941e-02f, -1.32542113e-02f, -7.75715383e-03f, -3.95931639e-02f, 4.24525626e-02f,
  5.52882999e-02f, 1.94819003e-01f, 1.45109231e-02f, -6.47693351e-02f, 6.30022809e-02f, -2.91374512e-02f, -6.87619969e-02f, -5.33511378e-02f, 2.42346618e-02f, -8.93389806e-02f,
  -1.16465194e-02f, -1.09026745e-01f, 2.16835923e-02f, 2.57634688e-02f, -1.13637522e-01f, -2.44932324e-02f, -7.76477344e-03f, 2.61110477e-02f, 4.10038382e-02f, -1.12708900e-02f,
  -6.86764643e-02f, 7.50185177e-02f, -4.37077098e-02f, -1.32637694e-02f, -1.81575678e-02f, -8.21429677e-03f, 3.14668054e-03f, 5.82062788e-02f, 1.37916254e-02f, -3.34404223e-02f,
  1.48156077e-01f, 1.24407381e-01f, -8.90376344e-02f, -1.38165846e-01f, -3.63482237e-02f, -1.30798846e-01f, 4.66246344e-02f, -3.78237180e-02f, 1.52045473e-01f, 8.40383098e-02f,
  -4.96072583e-02f, 1.78917835e-03f, -2.08985507e-02f, -2.47238390e-02f, 6.29574209e-02f, 2.46206950e-02f, -9.33611467e-02f, -4.56414632e-02f, -3.12212277e-02f, -1.81271136e-02f,
  -1.47788346e-01f, 5.63063323e-02f, 1.23887531e-01f, -9.67763737e-02f, -1.22317292e-01f, -6.52829856e-02f, -5.20130023e-02f, 5.44949323e-02f, -1.42277889e-02f, 6.41129836e-02f,
  4.68526721e-01f, -3.76614362e-01f, -1.93653688e-01f, 1.75351515e-01f, 3.12818438e-01f, 2.22465530e-01f, 3.17266583e-01f, -2.39916250e-01f, 1.41126961e-01f, -3.24006170e-01f,
  2.46849373e-01f, -1.27543420e-01f, -9.16133374e-02f, 1.62665576e-01f, 3.37610811e-01f, -5.09296842e-02f, 1.64601400e-01f, 1.10207684e-01f, -1.19290777e-01f, 1.33448571e-01f,
  1.74029455e-01f, 2.75731444e-01f, 2.94511877e-02f, -3.44668090e-01f, 1.95514873e-01f, -3.48154098e-01f, -9.71824154e-02f, -1.57716796e-01f, -2.68508643e-01f, 1.81935281e-02f,
  1.30812868e-01f, 1.24421909e-01f, 6.91235811e-02f, 3.94810252e-02f, 4.91841743e-03f, 1.05984040e-01f, -4.61857952e-02f, 6.44847676e-02f, 4.84975278e-02f, 1.86904743e-02f,
  -1.62892658e-02f, 8.73592123e-02f, -7.04383701e-02f, 3.06994263e-02f, 2.36826781e-02f, -3.86779681e-02f, -4.41344455e-02f, 7.12739080e-02f, -1.75623178e-01f, -3.73493172e-02f,
  1.06909618e-01f, 1.41646778e-02f, 1.29445478e-01f, -7.61577189e-02f, 2.36070752e-02f, 5.68018295e-02f, -1.00513503e-01f, -7.93290660e-02f, -9.65613574e-02f, 9.36693400e-02f,
  -9.76531953e-02f, -3.78939807e-02f, -5.34947924e-02f, 5.53640090e-02f, 7.36238211e-02f, -7.91687984e-03f, 7.66635165e-02f, -1.48882940e-01f, -1.28848637e-02f, -7.44679496e-02f,
  2.02453528e-02f, 7.20051825e-02f, 3.17389816e-02f, -5.50775118e-02f, 6.13181852e-02f, 9.04712267e-03f, -3.87666970e-02f, -1.27971038e-01f, 6.09189644e-02f, -1.17580071e-02f,
  -4.21141759e-02f, 5.98548986e-02f, -1.00476034e-01f, -8.50269347e-02f, -8.39931220e-02f, 1.05960712e-01f, -1.11637404e-02f, 3.53755802e-02f, 5.18564135e-02f, 1.96220372e-02f,
  -1.06261715e-01f, -3.56672049e-01f, -9.44392830e-02f, -1.25752643e-01f, -7.86543190e-02f, 9.30388272e-02f, 6.28036587e-03f, 3.25371176e-02f, -2.68842094e-02f, 2.70506460e-02f,
  -5.19816317e-02f, -3.10140997e-02f, -9.63348001e-02f, 2.68175434e-02f, 2.32413206e-02f, -5.87037299e-04f, 2.79313717e-02f, -5.34740277e-02f, -4.18733172e-02f, -3.90590988e-02f,
  -6.28996044e-02f, -5.57940677e-02f, 8.05132389e-02f, 7.25568682e-02f, -8.85744542e-02f, -6.13300763e-02f, -5.14972135e-02f, -3.29354554e-02f, -1.09124422e-01f, -7.27116764e-02f,
  3.56900722e-01f, -2.08440498e-01f, 2.48613805e-01f, 3.21819007e-01f, 2.39866808e-01f, 3.03410739e-01f, 3.25037777e-01f, 1.23766335e-02f, 3.56547207e-01f, -3.73765886e-01f,
  -3.52191836e-01f, -1.03991397e-01f, 1.56045452e-01f, -2.93835014e-01f, 2.39529550e-01f, 2.04856664e-01f, 2.06033692e-01f, 1.62381157e-02f, 1.90307930e-01f, -5.52351251e-02f,
  9.74064097e-02f, -2.80424178e-01f, 2.50209477e-02f, -3.45347017e-01f, -1.48365244e-01f, -7.71551505e-02f, -3.32136899e-01f, 8.12870935e-02f, -4.07757908e-01f, 8.90907049e-02f,
  -8.25984702e-02f, 3.99729877e-04f, 5.50159998e-02f, -1.10848419e-01f, -7.43645504e-02f, -4.38342951e-02f, 7.60350376e-02f, 8.11674148e-02f, 9.30491760e-02f, -9.09275487e-02f,
  6.59507290e-02f, -1.44502327e-01f, -3.54110152e-02f, 3.51155214e-02f, 6.24526553e-02f, -1.14613049e-01f, 2.30291635e-02f, -1.05611406e-01f, -3.56595330e-02f, -5.20274490e-02f,
  6.49387762e-02f, -3.16457567e-03f, -7.42241293e-02f, -1.01563856e-01f, 6.37853667e-02f, 8.31266120e-03f, 1.26277119e-01f, 9.81643796e-02f, 4.93483506e-02f, 6.26394376e-02f,
  6.54700398e-02f, 1.59085274e-01f, -2.22127773e-02f, 3.74324918e-02f, 7.61173293e-02f, -4.53642793e-02f, -5.26070083e-03f, -1.59266904e-01f, -5.20747453e-02f, 3.36441956e-02f,
  4.89929691e-03f, -1.53891481e-02f, 4.96135205e-02f, 1.13133416e-01f, 4.14457656e-02f, 7.09713548e-02f, -3.84145416e-02f, -6.60576075e-02f, 1.95019804e-02f, -4.20767292e-02f,
  -2.02870183e-02f, 4.36425544e-02f, -3.50138114e-04f, -3.44798379e-02f, -1.15539348e-02f, 1.16763927e-01f, -6.04918525e-02f, 1.63534132e-03f, -3.75972991e-03f, -1.66103281e-02f,
  -1.10569380e-01f, -1.10163674e-01f, -5.82725322e-03f, -2.04522803e-01f, -5.02612516e-02f, -1.85783774e-01f, 2.77101975e-02f, -5.17522469e-02f, 1.75482891e-02f, 1.60019901e-02f,
  -5.27632684e-02f, -9.52535123e-02f, -2.55124532e-02f, -6.15001470e-02f, 5.69507629e-02f, -8.75778869e-02f, 1.15435913e-01f, -5.89478388e-02f, 4.65898886e-02f, 1.19346962e-03f,
  -1.15439191e-01f, -2.30515655e-03f, -5.72389625e-02f, -6.99814707e-02f, -1.57311156e-01f, -1.17087498e-01f, -4.53310460e-02f, -8.20626095e-02f, 3.74401100e-02f, -4.52824123e-03f,
  -4.88943964e-01f, 2.44942814e-01f, 8.07783678e-02f, -4.26241130e-01f, 1.95992008e-01f, 2.74534047e-01f, -1.99932203e-01f, 6.44935519e-02f, -3.01073521e-01f, 1.47070512e-01f,
  -1.44872861e-02f, -3.37383330e-01f, 1.40978530e-01f, -3.55272084e-01f, -3.42520237e-01f, -2.67058257e-02f, -2.19238728e-01f, -3.90467167e-01f, -7.99931288e-02f, -1.37626722e-01f,
  -2.46597588e-01f, -1.10837057e-01f, -1.51847035e-01f, 2.94936776e-01f, -2.13086735e-02f, -6.48513958e-02f, 6.71350509e-02f, 2.05818310e-01f, -6.86979340e-03f, 2.84762308e-02f,
  -1.72405258e-01f, -2.39591882e-01f, -1.73952997e-01f, -6.83351047e-03f, 2.02084929e-02f, -1.41820470e-02f, 6.29773214e-02f, -1.52679477e-02f, -1.19658947e-01f, 2.51169689e-03f,
  -1.70604084e-02f, -4.51066718e-02f, -7.53960162e-02f, 4.85750090e-04f, -2.09145695e-02f, 1.94605663e-02f, 5.19357249e-02f, 1.17616961e-02f, -8.58506411e-02f, 3.79181989e-02f,
  -3.17584649e-02f, 1.31736009e-03f, -8.17651376e-02f, -4.85134497e-02f, 4.46205288e-02f, -1.80916302e-02f, -7.78923035e-02f, 1.30325733e-02f, 8.41509271e-03f, -1.54657001e-02f,
  2.15278007e-02f, -4.85279411e-02f, 9.01167165e-04f, 1.10083073e-01f, -2.35120654e-02f, 9.47322696e-02f, -4.66977619e-02f, -3.81828472e-02f, 4.95041572e-02f, 1.56299874e-01f,
  1.00214094e-01f, 7.93314539e-03f, 7.19182789e-02f, 2.42050700e-02f, -1.35112315e-01f, -4.16732058e-02f, -2.19591297e-02f, 3.26417759e-02f, 3.43988155e-04f, -2.82564200e-02f,
  8.80082231e-03f, 1.59507524e-02f, 2.52809618e-02f, 2.54499540e-02f, -2.28066687e-02f, -2.78391335e-02f, 1.64439172e-01f, 9.78430584e-02f, -9.27157979e-03f, 8.94026831e-02f,
  -1.11093797e-01f, -7.64209265e-03f, -2.84386594e-02f, 1.06152959e-01f, -9.83887687e-02f, 5.54165021e-02f, -5.48284315e-02f, 1.14211895e-01f, 9.94868055e-02f, 1.28249535e-02f,
  -4.99141216e-03f, -3.28817852e-02f, 8.25043768e-02f, -6.97686598e-02f, -1.42221721e-02f, 3.14861871e-02f, 1.99813414e-02f, -1.86638124e-02f, -1.57257002e-02f, 7.85106793e-02f,
  6.00344837e-02f, -5.57770804e-02f, 4.43016514e-02f, 1.32946759e-01f, 9.21616778e-02f, 5.95103912e-02f, 4.06877585e-02f, -3.36803868e-02f, 3.16047110e-03f, -3.46898995e-02f,
  -1.09754220e-01f, -1.24520257e-01f, 2.81447619e-02f, 9.55469012e-02f, -5.54436482e-02f, -1.84168786e-01f, -1.77901879e-01f, 1.12206720e-01f, -3.12753230e-01f, 3.97724621e-02f,
  5.30487336e-02f, -1.50716946e-01f, -5.94624579e-02f, -2.46536836e-01f, -1.38376504e-02f, -3.66787285e-01f, 6.89777806e-02f, -2.39322200e-01f, 9.49384086e-03f, 2.72273093e-01f,
  1.87294945e-01f, 1.19285472e-01f, 1.48896322e-01f, 2.20285311e-01f, 6.95229247e-02f, 2.88798124e-01f, 3.73833984e-01f, 4.91601937e-02f, 2.83217400e-01f, -7.52809718e-02f,
  -2.09439576e-01f, 3.92467640e-02f, 7.89329186e-02f, -1.78919286e-01f, 2.34272107e-01f, 7.82450885e-02f, 3.18004042e-02f, -6.55974373e-02f, -2.38926373e-02f, -1.16329407e-02f,
  -2.40027681e-02f, -5.55884577e-02f, -1.17135607e-02f, -1.45417854e-01f, 1.42673068e-02f, -8.68132338e-02f, -9.89079326e-02f, 1.29238255e-02f, -7.62305111e-02f, 2.08335537e-02f,
  5.30991815e-02f, 4.61584851e-02f, 4.54662228e-03f, 3.37193720e-02f, 7.31899291e-02f, 4.76599559e-02f, -2.18959823e-02f, 1.63649306e-01f, -1.82774097e-01f, 1.44292817e-01f,
  -1.55679891e-02f, 4.83922623e-02f, 3.59389968e-02f, -1.62806660e-01f, -1.07669972e-01f, 3.10236705e-04f, -1.07945852e-01f, -1.15205958e-01f, -7.52948597e-02f, -3.50406282e-02f,
  6.85189962e-02f, 6.88887164e-02f, -1.91047072e-01f, -2.35915296e-02f, 8.78970101e-02f, -4.75438051e-02f, -3.72874103e-02f, -6.17486872e-02f, 1.08091258e-01f, -1.65968090e-02f,
  -2.06803501e-01f, 4.72118668e-02f, 7.38074630e-02f, -4.99758087e-02f, -1.81688145e-01f, 4.84846495e-02f, 1.31839037e-01f, -1.08621292e-01f, -3.10270535e-03f, -8.07866454e-03f,
  1.52859971e-01f, 2.45120779e-01f, 1.75944772e-02f, -1.18151672e-01f, 1.14612060e-03f, 5.53351007e-02f, -2.12889642e-01f, -3.36024128e-02f, 6.59351200e-02f, 6.83962852e-02f,
  2.11764857e-01f, 1.52777821e-01f, 8.61805379e-02f, 1.09977424e-02f, -4.87312414e-02f, 2.11374789e-01f, 7.40366578e-02f, 4.04342227e-02f, 1.50319666e-01f, 2.40850642e-01f,
  1.03828065e-01f, 4.85246480e-02f, -2.06045248e-02f, 2.38598213e-02f, 1.56671003e-01f, 8.04677755e-02f, 2.47135367e-02f, 5.43305464e-03f, -3.28972633e-03f, -1.15280919e-01f,
  -1.07211068e-01f, -4.18484136e-02f, -3.54071893e-03f, 3.90694022e-01f, -3.86171103e-01f, -3.66934575e-02f, 2.22823769e-01f, 3.58502306e-02f, 3.20809394e-01f, -8.30023140e-02f,
  -1.77461952e-02f, -1.17634222e-01f, 2.18418285e-01f, 1.15641668e-01f, 6.49290606e-02f, 3.40218842e-01f, 1.42980218e-01f, 1.10190742e-01f, 1.55877471e-01f, 1.11152835e-01f,
  1.25755027e-01f, -4.49784137e-02f, -8.43973979e-02f, -2.05782816e-01f, -1.63066521e-01f, -4.49662209e-02f, -1.55522183e-01f, -1.48005947e-01f, -2.20728502e-01f, -2.47112155e-01f,
  -4.09758417e-03f, 7.88041279e-02f, 7.62910582e-03f, -4.44822274e-02f, -2.26828624e-02f, -1.26998037e-01f, -1.03316337e-01f, -1.41102955e-01f, 1.84319913e-02f, 8.89539570e-02f,
  4.57137190e-02f, 1.64084844e-02f, 3.69808599e-02f, -3.78610902e-02f, -5.29387109e-02f, -1.01202369e-01f, -3.66035290e-02f, 2.00074073e-02f, -8.26064125e-02f, -6.55079708e-02f,
  -8.02734941e-02f, 3.17744017e-02f, 3.04437447e-02f, 5.81737235e-02f, 1.90081056e-02f, 1.38478242e-02f, 1.30801331e-02f, -2.54831482e-02f, 3.94390104e-03f, 7.11991042e-02f,
  2.10244283e-02f, -3.38650644e-02f, -1.13000743e-01f, -9.12421867e-02f, 2.96535064e-02f, 7.86420181e-02f, -7.57628083e-02f, 3.17312405e-02f, 2.07379669e-01f, -4.60773427e-03f,
  1.16421141e-01f, -4.79249842e-02f, 1.39005939e-02f, -4.64050062e-02f, 8.76761973e-02f, 4.47572917e-02f, 3.75120975e-02f, -4.16808091e-02f, 1.61551461e-01f, -1.02320507e-01f,
  -3.90821695e-02f, 1.24265820e-01f, 1.92133412e-02f, -1.13990583e-01f, -6.02573603e-02f, -7.66212791e-02f, 1.34687107e-02f, -1.21961245e-02f, 8.19035918e-02f, -2.92690936e-02f,
  1.57112032e-01f, 1.74106017e-01f, 1.41357007e-02f, 5.90254217e-02f, 9.93807539e-02f, -2.48177573e-02f, -9.43783522e-02f, 9.37797204e-02f, 3.23061869e-02f, 6.66291341e-02f,
  8.49149227e-02f, 4.17018868e-02f, 7.51389340e-02f, -3.16160843e-02f, -8.72329716e-03f, -5.20679019e-02f, 1.64282657e-02f, 6.31120463e-04f, 6.32015988e-02f, 1.69485318e-03f,
  4.41422826e-03f, -4.08686511e-02f, 1.14022240e-01f, -4.33868580e-02f, 2.54972535e-03f, 2.45719180e-02f, -1.83406338e-01f, 3.34297940e-02f, 6.30299449e-02f, 9.51904710e-03f,
  -5.23381075e-03f, 8.79362319e-03f, -1.06692091e-01f, -1.88747212e-01f, -7.72367641e-02f, 1.14683352e-01f, 3.19571286e-01f, -2.71097571e-01f, -2.52196491e-01f, 1.12041578e-01f,
  3.22855800e-01f, -3.23249787e-01f, 3.22255820e-01f, 3.27636153e-01f, -2.97320541e-03f, 4.19330657e-01f, 2.04191625e-01f, 1.31071240e-01f, -9.08645168e-02f, 6.66892678e-02f,
  -1.99338138e-01f, 1.14597231e-01f, 3.73195320e-01f, -1.55708820e-01f, 1.40170053e-01f, -1.60757110e-01f, -7.84424320e-02f, -6.24203729e-03f, -1.43447712e-01f, 6.65296242e-02f,
  1.71418399e-01f, 1.54826045e-01f, 2.03615069e-01f, 2.80642640e-02f, 6.94037601e-02f, 3.78909148e-02f, 6.99565709e-02f, 1.31954595e-01f, 5.17009795e-02f, -9.64603573e-02f,
  1.04093775e-02f, -3.75148989e-02f, -5.51447310e-02f, -9.66642499e-02f, -2.01915950e-01f, -4.54581827e-02f, 7.40814209e-03f, 3.46387923e-02f, -1.05903320e-01f, 2.03752592e-02f,
  9.91898477e-02f, 3.55200507e-02f, 8.06103740e-03f, -2.72900108e-02f, -1.27057850e-01f, -1.47290215e-01f, 1.09101966e-01f, 4.68592569e-02f, -1.16229400e-01f, -1.89650044e-01f,
  -1.44385219e-01f, 9.45517197e-02f, 1.00867704e-01f, 1.43232301e-01f, 8.47869962e-02f, 7.81809390e-02f, -7.15937540e-02f, 5.86816743e-02f, -5.58450781e-02f, 9.61100608e-02f,
  5.28281666e-02f, 1.65276900e-02f, 6.07211031e-02f, -2.46250047e-03f, -1.45747559e-02f, -7.94581696e-02f, 1.11476786e-01f, 7.17486963e-02f, -1.96263604e-02f, -2.07498278e-02f,
  5.18370494e-02f, -1.20217696e-01f, 5.09713925e-02f, -1.48272533e-02f, -7.32193526e-04f, -8.54879152e-03f, 2.38883048e-02f, 3.91034931e-02f, 2.16818869e-01f, -9.57607850e-03f,
  1.05052628e-01f, -2.24613845e-01f, 8.74164253e-02f, -4.67485301e-02f, 6.89012632e-02f, 1.06334254e-01f, 3.17777619e-02f, -1.14950426e-01f, -5.22748753e-02f, 9.31518376e-02f,
  -1.31054401e-01f, -3.73376682e-02f, -9.05177146e-02f, 4.30248529e-02f, -1.73108906e-01f, 1.73449554e-02f, 2.29274482e-02f, -1.03694379e-01f, 4.30332869e-02f, -2.11854905e-01f,
  -7.40816146e-02f, -7.54407868e-02f, 4.98109683e-02f, -3.25082382e-03f, -9.94204506e-02f, 3.85589488e-02f, -1.65999264e-01f, -5.84783778e-02f, -7.36356750e-02f, -1.50104640e-02f,
  -5.25929108e-02f, 3.80294055e-01f, 1.09158501e-01f, 6.06847368e-02f, -3.37390304e-02f, -5.23748279e-01f, -3.94809753e-01f, 2.08133042e-01f, 6.62156716e-02f, 5.28934412e-02f,
  1.00446016e-01f, 2.45979339e-01f, 2.07395345e-01f, 5.23066707e-02f, -3.04610193e-01f, -4.89864964e-03f, -1.63864076e-01f, -2.04825953e-01f, -7.73239508e-03f, 8.46055597e-02f,
  -5.70823550e-02f, 1.60038099e-01f, 1.09138533e-01f, 2.10719049e-01f, 1.11260504e-01f, 2.13560596e-01f, 2.65025169e-01f, 9.51837599e-02f, -7.34459162e-02f, -9.88192558e-02f,
  -6.04046956e-02f, 2.97560871e-01f, 1.46562820e-02f, -4.38780263e-02f, -6.11391887e-02f, -1.48272023e-01f, -6.91182762e-02f, -2.70300396e-02f, -2.11309642e-02f, -5.22585884e-02f,
  7.49036148e-02f, 8.98959562e-02f, -9.96615551e-03f, 1.00484200e-01f, -1.24961361e-02f, 6.71903789e-02f, -2.70547755e-02f, -1.20612301e-01f, 6.13916740e-02f, 1.15676343e-01f,
  5.90381213e-03f, -4.54702191e-02f, -2.18894687e-02f, 2.77908007e-03f, 2.36685891e-02f, 6.37896881e-02f, -4.70177941e-02f, -5.65784723e-02f, 8.78458023e-02f, 6.75444379e-02f,
  5.41149788e-02f, -1.52257115e-01f, -4.11236770e-02f, 5.30769154e-02f, -7.83737600e-02f, -3.64955887e-02f, -4.88132313e-02f, -3.52970026e-02f, -2.75732223e-02f, -7.05300714e-04f,
  -1.57628804e-01f, -5.26373722e-02f, 8.47059414e-02f, -1.14114568e-01f, 8.13683122e-03f, -9.12966430e-02f, -2.35220734e-02f, 7.64985830e-02f, -1.38111651e-01f, 2.35837996e-02f,
  7.99161121e-02f, -1.05834976e-01f, -3.34450826e-02f, -1.32475019e-01f, -8.07518661e-02f, 8.00465643e-02f, 1.06114447e-02f, 4.54295687e-02f, 2.78773643e-02f, -3.41867879e-02f,
  -2.29520705e-02f, 2.12004125e-01f, -2.24897619e-02f, 5.99408820e-02f, 8.35721716e-02f, -5.22754118e-02f, -1.74345355e-02f, -1.78742222e-02f, 6.46799430e-02f, -3.46471928e-02f,
  3.32334861e-02f, -1.23127244e-01f, -1.31335825e-01f, 1.76489577e-02f, 2.40663849e-02f, -1.93954036e-02f, 1.84751954e-02f, -6.84174299e-02f, 3.46467048e-02f, 6.60486296e-02f,
  9.48791057e-02f, 7.15172142e-02f, -5.19396178e-03f, -4.92393970e-02f, 4.12748605e-02f, -3.71821299e-02f, 1.36243403e-02f, 1.09536432e-01f, 6.66868985e-02f, -3.93771790e-02f,
  -7.15778291e-01f, 3.47361416e-01f, -1.50394544e-01f, -9.57284942e-02f, -9.13322270e-02f, -1.71696678e-01f, 4.70324345e-02f, 1.35582104e-01f, 8.22457150e-02f, 3.41531128e-01f,
  1.68285146e-01f, -1.77011192e-01f, 3.14882874e-01f, 2.17202544e-01f, -3.96310478e-01f, 1.24511734e-01f, -1.49458647e-01f, -9.88753140e-02f, -3.23259160e-02f, 7.72936866e-02f,
  -1.92360044e-01f, 2.47162461e-01f, 9.66474339e-02f, 2.95049459e-01f, -1.25322446e-01f, -4.68421392e-02f, 1.96021497e-01f, 2.38827795e-01f, -7.13719502e-02f, 1.26575921e-02f,
  -1.80262670e-01f, 8.19056779e-02f, 2.03068722e-02f, -1.88770130e-01f, -2.44816229e-01f, -1.14891484e-01f, -1.58504918e-01f, -3.50209884e-02f, -5.37151210e-02f, -2.13729534e-02f,
  -1.35633901e-01f, -6.10534055e-03f, -6.35735840e-02f, 7.73882270e-02f, -1.25181675e-01f, -2.58807950e-02f, 2.46612262e-02f, -7.41985813e-02f, 1.08981170e-01f, -1.09696299e-01f,
  7.54934251e-02f, -6.97899982e-02f, 2.68773325e-02f, 9.08230543e-02f, -6.10070452e-02f, 7.59396553e-02f, 2.55485214e-02f, -4.12301756e-02f, -1.82518914e-01f, -7.40897954e-02f,
  -4.31830436e-02f, 6.42933398e-02f, 7.27474242e-02f, -8.95631406e-03f, 8.72510821e-02f, -6.71620592e-02f, -8.23756959e-03f, -4.97146370e-03f, -1.00303032e-01f, 1.80556963e-04f,
  -1.28868669e-01f, -1.32109463e-01f, 7.43607283e-02f, 2.55079884e-02f, -3.79622988e-02f, -6.40629753e-02f, 2.05706526e-02f, 1.75669752e-02f, -9.29855183e-02f, -6.67716116e-02f,
  1.04843572e-01f, -3.35606262e-02f, -6.48256093e-02f, -1.05656153e-02f, -3.54255922e-02f, -2.66410364e-03f, 6.29767925e-02f, -1.53250098e-02f, -7.33689144e-02f, -8.11129734e-02f,
  -1.75541967e-01f, 3.44012375e-03f, 7.73894638e-02f, -1.22684270e-01f, -1.08530046e-02f, 1.06789405e-02f, 9.05160308e-02f, -2.38916539e-02f, 4.15311381e-02f, -9.36980620e-02f,
  1.00150714e-02f, -2.64325254e-02f, -7.57753626e-02f, 7.32108057e-02f, 6.97614998e-02f, 2.53497567e-02f, 1.68662831e-01f, -2.26840302e-02f, -4.31102104e-02f, -9.59696472e-02f,
  8.40975046e-02f, 5.30061908e-02f, 3.70001979e-02f, -8.95104371e-03f, 9.21508763e-03f, -7.21508637e-02f, -2.50530373e-02f, -3.38175055e-03f, -8.81091207e-02f, 5.05206957e-02f,
  3.90685380e-01f, 1.64867565e-01f, 3.48928422e-01f, 3.07703018e-01f, 3.45202237e-01f, 3.57171655e-01f, 4.76146229e-02f, 3.27548802e-01f, 4.65196669e-01f, -1.79559886e-01f,
  -4.38551605e-02f, -3.11371926e-02f, -1.86120152e-01f, 1.95817173e-01f, -1.49179041e-01f, -8.87337029e-02f, 2.93973321e-03f, -2.14053318e-01f, -6.73411861e-02f, -1.66846067e-01f,
  -9.00780037e-02f, -3.72316271e-01f, -1.49409786e-01f, -3.74237955e-01f, 7.36550465e-02f, -5.39413802e-02f, -2.63802320e-01f, -2.66094297e-01f, -1.28265843e-01f, -4.98456554e-03f,
  1.29538000e-01f, 1.26280054e-01f, 1.31166950e-01f, 8.99504274e-02f, 1.01738639e-01f, -4.57549766e-02f, -7.06384182e-02f, -8.46103802e-02f, 7.98286647e-02f, 1.16738483e-01f,
  -5.66832013e-02f, -7.19578639e-02f, 2.05323100e-02f, -8.69047791e-02f, 1.43737748e-01f, 1.78623319e-01f, 1.93350866e-01f, 1.86673582e-01f, 3.27552855e-02f, 8.59185383e-02f,
  2.11458981e-01f, 1.09327905e-01f, 2.46739581e-01f, -8.59736055e-02f, 8.79170001e-02f, 1.02943271e-01f, -2.78413994e-04f, 5.82221616e-03f, 1.02973439e-01f, 1.25686929e-01f,
  -9.76419523e-02f, -6.12041652e-02f, 2.49660332e-02f, 9.81384702e-03f, -1.65620092e-02f, 1.05537839e-01f, 2.38415468e-02f, -8.82636160e-02f, -3.19440849e-02f, -6.21682778e-02f,
  5.98600209e-02f, 6.58541545e-02f, 1.05275393e-01f, 6.98205009e-02f, 3.67968827e-02f, 1.34035163e-02f, -1.61163639e-02f, 3.34452353e-02f, 1.39656574e-01f, 1.82037298e-02f,
  -5.17352931e-02f, 2.69254539e-02f, -4.66598421e-02f, -5.10743484e-02f, -3.51607166e-02f, -1.62530970e-02f, -8.42585415e-02f, 5.72886057e-02f, -3.93571518e-02f, -1.20360091e-01f,
  -3.45520526e-02f, -3.36798251e-01f, 4.32597287e-03f, 3.95554816e-03f, -6.37627169e-02f, 8.32461342e-02f, -1.75388940e-02f, 1.86816558e-01f, -7.43192285e-02f, 7.59478584e-02f,
  4.01227139e-02f, -1.73346214e-02f, 8.06105882e-02f, -4.62530460e-03f, -1.01321928e-01f, 4.69298922e-02f, -1.25355572e-01f, 2.06472892e-02f, 8.72088447e-02f, -4.89933267e-02f,
  -9.80874225e-02f, 1.09075126e-03f, 3.67247723e-02f, -8.55101971e-04f, -1.06024027e-01f, -6.55923560e-02f, -5.09373471e-02f, 4.30800021e-03f, -1.29633352e-01f, -4.05002795e-02f,
  -7.60490745e-02f, -2.69124538e-01f, 4.31153290e-02f, 1.45744473e-01f, -1.24732219e-01f, -2.87173539e-01f, -3.12976688e-01f, -2.01139480e-01f, -3.19848917e-02f, -2.76856422e-01f,
  -1.30216703e-01f, 1.68513894e-01f, -3.01350355e-01f, 2.06799328e-01f, 3.78512472e-01f, -6.16834126e-02f, 1.14544347e-01f, 7.76761398e-02f, 6.05391152e-02f, -7.54289180e-02f,
  1.46657377e-01f, 1.08790472e-01f, 2.37901673e-01f, 1.83144167e-01f, 1.01931646e-01f, 1.79697677e-01f, 3.26131880e-01f, -1.34558873e-02f, 2.71891356e-01f, 2.01689169e-01f,
  -1.40462950e-01f, 7.02843592e-02f, -2.70002633e-02f, 2.08280142e-02f, -5.72974272e-02f, -6.70830086e-02f, 3.54421362e-02f, 4.44506947e-03f, 1.02076270e-01f, 2.66357958e-02f,
  1.17736394e-02f, 8.54731426e-02f, 1.12787716e-01f, 2.83377822e-02f, -7.37262219e-02f, 3.74356508e-02f, 1.94535814e-02f, -5.17636500e-02f, -2.57251747e-02f, -1.52941227e-01f,
  -1.39141068e-01f, -1.15992934e-01f, -5.37151918e-02f, 1.45085737e-01f, 3.74508165e-02f, -3.40276137e-02f, 7.18261972e-02f, -4.56567146e-02f, -1.84068158e-02f, 6.30476996e-02f,
  1.78435687e-02f, -2.93195359e-02f, -2.23889053e-02f, -5.73808663e-02f, -2.62699015e-02f, 7.60024637e-02f, -6.66223615e-02f, 7.69497901e-02f, 5.38938902e-02f, -4.44238372e-02f,
  2.25250963e-02f, 4.50137928e-02f, -5.96846454e-02f, 3.59373586e-03f, -2.28249263e-02f, -1.64572150e-02f, 4.08459008e-02f, 1.39934905e-02f, -6.48923963e-02f, 4.54467088e-02f,
  2.64106295e-03f, -5.26329083e-03f, -3.80122848e-02f, -6.21681809e-02f, -1.22044325e-01f, 4.84901965e-02f, 9.02791247e-02f, -6.47924617e-02f, 3.02990638e-02f, 8.52278098e-02f,
  1.06698543e-01f, 1.39132604e-01f, -1.85345802e-02f, 7.77596533e-02f, 2.44114436e-02f, 5.08223176e-02f, 3.61886881e-02f, 6.34855926e-02f, 2.01569032e-02f, 4.60166484e-02f,
  -1.40644489e-02f, 4.30522894e-04f, -4.00635414e-03f, -2.43151505e-02f, 1.55721143e-01f, -8.58497918e-02f, 7.33363852e-02f, 1.62555322e-01f, 1.26644671e-01f, 2.40012836e-02f,
  6.08555824e-02f, 4.55948804e-03f, 6.26377761e-02f, -9.16647911e-02f, -1.73508581e-02f, -4.02177908e-02f, -4.85998951e-02f, -7.31562078e-02f, 1.05243340e-01f, 6.72920793e-02f,
  8.54876731e-03f, 3.16385567e-01f, 2.79883772e-01f, -5.47027178e-02f, 4.15804714e-01f, 3.48723799e-01f, 1.16118960e-01f, 3.02771151e-01f, 2.92070746e-01f, -3.17761242e-01f,
  -1.09592788e-01f, 6.70395046e-02f, -2.36115232e-02f, -1.33544868e-02f, -5.06778248e-02f, -8.16638917e-02f, 9.22815949e-02f, -2.77644973e-02f, 2.81266987e-01f, 3.45551893e-02f,
  1.02380618e-01f, -9.37473327e-02f, 5.13747744e-02f, -6.32372499e-02f, 9.26542506e-02f, -1.31700963e-01f, -2.53059953e-01f, 1.92867339e-01f, -2.07007319e-01f, -3.55431512e-02f,
  1.03813425e-01f, -2.69192718e-02f, 6.14583455e-02f, 2.09971648e-02f, 1.62408829e-01f, 9.58504453e-02f, -1.23060420e-01f, 3.95715944e-02f, 3.84583995e-02f, 1.04247127e-02f,
  9.60910618e-02f, -8.02116748e-03f, -1.36855423e-01f, -6.04720674e-02f, 2.43202314e-01f, 5.47034144e-02f, -1.44834975e-02f, 1.32390752e-01f, 1.37124836e-01f, -1.63535180e-03f,
  1.02058379e-03f, 2.33017936e-01f, 1.76717535e-01f, -5.43328486e-02f, -5.99180274e-02f, 6.98622614e-02f, -3.40408571e-02f, 1.85837783e-02f, -8.82444605e-02f, 1.80961877e-01f,
  1.98916458e-02f, -8.40236433e-03f, -8.01445693e-02f, -3.38943899e-02f, -3.60231809e-02f, 3.23347114e-02f, 1.30909299e-02f, -1.11252427e-01f, 9.69249010e-02f, 6.26296848e-02f,
  1.14736103e-01f, 1.10215895e-01f, 2.94113010e-02f, -4.31004502e-02f, 2.22454946e-02f, 8.16580281e-02f, -4.39720079e-02f, -2.31704742e-01f, -1.10305548e-02f, 5.32264262e-03f,
  -5.96677735e-02f, -1.84407830e-01f, 7.13590682e-02f, -1.06062293e-01f, -2.52084546e-02f, 4.10385802e-02f, -1.42964453e-01f, 1.31052453e-02f, 5.92840984e-02f, 5.69514669e-02f,
  8.59435275e-02f, -2.27949515e-01f, 1.83396071e-01f, -1.24015376e-01f, -2.84988130e-03f, 3.24625559e-02f, 2.12507155e-02f, -1.08474821e-01f, -1.00907953e-02f, -2.77194418e-02f,
  5.66392615e-02f, -1.09308690e-01f, 3.57564539e-02f, 2.44836253e-03f, -8.00089240e-02f, -8.08928236e-02f, -2.49079809e-01f, -2.85394508e-02f, -1.23649940e-01f, -1.84944943e-01f,
  -1.31593168e-01f, 9.92503669e-03f, 4.98838499e-02f, 1.86628565e-01f, -7.56929256e-03f, 1.52939809e-02f, -1.62052605e-02f, -8.78172219e-02f, 3.61887813e-02f, 6.95782825e-02f,
  -7.13115036e-02f, -1.14071533e-01f, -4.58551079e-01f, -2.52869815e-01f, 6.20770305e-02f, -3.75406653e-01f, -2.12271377e-01f, -1.72342248e-02f, 1.06650591e-01f, 2.16366827e-01f,
  7.65967593e-02f, 1.56141266e-01f, 3.77629101e-01f, -3.93052459e-01f, -3.98842245e-01f, -5.39689139e-02f, -3.27475727e-01f, -1.98069304e-01f, 6.95580989e-02f, -1.26622394e-01f,
  -1.29373670e-01f, 1.39154969e-02f, -3.74498695e-01f, 2.17746556e-01f, -2.06966296e-01f, -8.14582184e-02f, 2.13263959e-01f, 1.75044000e-01f, -2.50055790e-01f, 2.41128821e-02f,
  -1.39316112e-01f, 9.94762182e-02f, -7.86795095e-02f, 3.95905562e-02f, -2.06136733e-01f, -6.61651418e-02f, -1.50464609e-01f, -4.83632460e-02f, 8.65726825e-03f, 3.00994106e-02f,
  8.61331224e-02f, 1.48310959e-01f, -1.51517037e-02f, 7.02688321e-02f, 1.51401423e-02f, -2.41635293e-02f, -8.40794221e-02f, -1.92060634e-01f, 9.26979780e-02f, -7.34417215e-02f,
  -1.65981248e-01f, -1.80356860e-01f, -1.26552448e-01f, 5.51337563e-02f, 5.98991700e-02f, -8.79635736e-02f, -1.32334515e-01f, -1.56944692e-01f, -1.13905363e-01f, -1.00394316e-01f,
  -2.38807537e-02f, 1.11183070e-01f, -6.31612092e-02f, 5.78672951e-03f, -4.47134823e-02f, -1.06810676e-02f, 8.34543556e-02f, 1.90006718e-02f, 1.50854141e-01f, -3.07713449e-02f,
  3.40704573e-03f, -4.62513082e-02f, 3.07701789e-02f, -3.88812460e-02f, 1.14122285e-02f, -5.93949258e-02f, 2.22547799e-02f, 6.60770340e-03f, -6.30761161e-02f, -8.71560201e-02f,
  8.97372812e-02f, 1.26114050e-02f, 5.08864038e-02f, 5.57855479e-02f, -1.24769121e-01f, 8.83434787e-02f, 9.16835144e-02f, -1.06922805e-01f, 3.38978018e-03f, 8.23115837e-03f,
  -6.03944622e-02f, 1.81325763e-01f, 8.27433765e-02f, 2.03465354e-02f, -7.48425275e-02f, 3.56056243e-02f, 1.51347648e-03f, -9.71360952e-02f, 3.32502532e-03f, 5.51510714e-02f,
  -6.66622892e-02f, -2.09005997e-02f, 2.61488911e-02f, 7.68230250e-03f, -7.61397034e-02f, -6.47991672e-02f, 9.56522971e-02f, 8.65192488e-02f, -4.16432768e-02f, -1.90208498e-02f,
  1.16716757e-01f, 1.91379666e-01f, 8.20199922e-02f, 7.83388466e-02f, 1.25995949e-01f, -7.04351142e-02f, 8.41392130e-02f, -4.20684554e-03f, 7.52604753e-02f, 1.01744920e-01f,
  -6.73896000e-02f, -9.74290296e-02f, 1.82435036e-01f, 2.13801429e-01f, 5.73545732e-02f, 1.37914211e-01f, -5.19386083e-02f, -2.87309974e-01f, -3.37380290e-01f, -5.77972084e-03f,
  -9.84940007e-02f, 2.76321650e-01f, -2.03125626e-01f, -1.52710125e-01f, -2.15325698e-01f, -4.50428486e-01f, -9.17975307e-02f, 8.59301537e-02f, -1.22770689e-01f, 1.45188957e-01f,
  -1.53660059e-01f, -2.45210275e-01f, -4.63092811e-02f, -1.48029149e-01f, 9.45907608e-02f, 3.66161883e-01f, 1.17633648e-01f, 6.16511814e-02f, 4.41007584e-01f, 1.83363222e-02f,
  3.86289358e-02f, -1.52393878e-01f, 1.05745628e-01f, 1.28422618e-01f, 4.85144295e-02f, 1.13452174e-01f, 1.53862551e-01f, -1.03474560e-03f, 1.07071139e-01f, 6.33099210e-03f,
  1.55281713e-02f, 1.29017174e-01f, -1.37789883e-02f, -1.45936474e-01f, -2.23651808e-02f, 6.58533573e-02f, 6.91019967e-02f, 8.48432407e-02f, -3.34600657e-02f, 1.12799481e-01f,
  1.51426151e-01f, 1.50936529e-01f, -2.19228938e-02f, 1.51611403e-01f, 9.64195207e-02f, -4.70456295e-03f, 1.60279512e-01f, 8.53775740e-02f, 1.06258780e-01f, 5.51336585e-03f,
  -6.30910024e-02f, -6.26209006e-02f, -3.23455371e-02f, -5.37088290e-02f, -2.21800044e-01f, -3.56088392e-02f, -8.10789168e-02f, -7.18705356e-02f, 1.16608590e-01f, -9.34486091e-02f,
  4.46379595e-02f, 3.89742889e-02f, -5.16102314e-02f, 1.94355160e-01f, -6.94339424e-02f, -1.54263243e-01f, 4.20836434e-02f, 1.56053334e-01f, 2.32603461e-01f, -2.83850133e-02f,
  -1.83342665e-01f, 3.75318341e-02f, 5.73915383e-03f, 4.61358316e-02f, -1.72889426e-01f, 4.54804264e-02f, -2.13275589e-02f, 2.49564219e-02f, -4.46176156e-02f, -5.65849282e-02f,
  1.82035625e-01f, -8.58034790e-02f, 5.65595627e-02f, 1.19093455e-01f, 3.63630429e-03f, -1.14598922e-01f, -1.61846146e-01f, 4.89450879e-02f, 4.66170497e-02f, -2.39929676e-01f,
  7.79888108e-02f, 4.41604927e-02f, 7.84225315e-02f, 2.32328405e-03f, 5.56211993e-02f, -3.26845683e-02f, 2.94344053e-02f, 3.67294885e-02f, 5.42071424e-02f, 7.74511322e-02f,
  9.69663337e-02f, 5.81594519e-02f, -7.89112896e-02f, 3.45190279e-02f, 1.20420329e-01f, 1.54678926e-01f, -1.21061457e-02f, 9.08818468e-02f, 2.84071080e-02f, 8.89813304e-02f,
  -2.26658229e-02f, 1.17618985e-01f, -3.88092935e-01f, 5.42406738e-02f, 3.58225740e-02f, -4.03858609e-02f, 7.74618238e-02f, 9.76936594e-02f, -3.05283546e-01f, 3.95350635e-01f,
  4.14474607e-01f, -2.94142842e-01f, 2.65040219e-01f, 3.81986290e-01f, -4.77961749e-02f, 1.25158921e-01f, 3.58803868e-01f, 2.34961599e-01f, -5.69597892e-02f, 1.38050452e-01f,
  5.45375906e-02f, 3.26740444e-01f, 1.63949713e-01f, 8.85104761e-02f, 3.15851092e-01f, -1.70500070e-01f, 4.06201750e-01f, -5.60336001e-02f, 2.86920518e-01f, -6.47948608e-02f,
  1.15049042e-01f, 2.66637765e-02f, 3.26653831e-02f, -1.16043858e-01f, 5.19594848e-02f, 9.43939667e-03f, 2.01412383e-02f, -1.04400039e-01f, -9.98147130e-02f, -6.01810887e-02f,
  -7.60376081e-02f, -7.40164369e-02f, -1.64579377e-02f, -9.88556221e-02f, -7.17540309e-02f, -1.03072301e-01f, -1.01351850e-02f, 2.29779016e-02f, -5.22901416e-02f, 2.85698995e-02f,
  -8.72865319e-02f, -2.65869480e-02f, 4.78297248e-02f, 7.92855099e-02f, -4.75779064e-02f, -1.33257106e-01f, -1.09435983e-01f, 4.78168391e-02f, 1.06256669e-02f, -4.91546886e-03f,
  3.20510715e-02f, 3.06846220e-02f, 5.73526919e-02f, -5.80193941e-03f, -7.09030852e-02f, -6.89112674e-03f, 8.74504820e-02f, 4.02365625e-02f, -1.20517813e-01f, 8.51442963e-02f,
  -8.39335546e-02f, -5.05998284e-02f, 2.68978551e-02f, -3.71335298e-02f, -1.80797428e-02f, -4.70170341e-02f, -8.99402127e-02f, 4.11944240e-02f, 4.08042707e-02f, 4.54043671e-02f,
  3.93737368e-02f, -8.35837424e-02f, 1.31103555e-02f, 8.98363516e-02f, -7.09338719e-03f, 7.68654495e-02f, 1.26363337e-01f, -6.40311018e-02f, -9.88170225e-03f, 4.40325472e-04f,
  6.40548468e-02f, 2.17794642e-01f, -4.91335988e-02f, -1.60675675e-01f, 1.60380751e-02f, 1.03761844e-01f, 3.29886959e-03f, -4.47353348e-03f, 3.40177603e-02f, 2.39738659e-03f,
  2.45978385e-02f, 4.30573011e-04f, 1.08572409e-01f, -4.81404737e-02f, -4.50447910e-02f, 1.45298913e-01f, 3.19348089e-03f, -1.94409322e-02f, 8.40379819e-02f, 5.93688376e-02f,
  8.39439854e-02f, -9.61210020e-03f, 6.31308258e-02f, -2.15528365e-02f, 5.28964028e-02f, 1.32238224e-01f, -2.35679299e-02f, 2.91199610e-02f, 6.46708608e-02f, 2.02001072e-02f,
  -3.07679832e-01f, 1.76044464e-01f, 1.08033985e-01f, -1.06785558e-01f, 4.19352315e-02f, -3.12223047e-01f, 7.12774917e-02f, -1.12292185e-01f, 8.35857391e-02f, 1.41008079e-01f,
  2.40076333e-01f, 2.09685653e-01f, 2.66915917e-01f, -3.06429397e-02f, -3.17886442e-01f, -8.79502296e-03f, -3.43097180e-01f, -2.17140302e-01f, -4.51219119e-02f, -2.32807547e-01f,
  -1.08854853e-01f, -2.62108762e-02f, -1.28562823e-01f, 3.32480446e-02f, 6.44360781e-02f, 4.43912996e-03f, -2.09450662e-01f, 2.79145688e-01f, -1.31745145e-01f, 1.86063334e-01f,
  -2.53794461e-01f, 2.26768348e-02f, -1.04492819e-02f, -8.36640075e-02f, -2.34460503e-01f, -1.05952643e-01f, -3.36919874e-02f, 1.68587551e-01f, 1.26784220e-01f, -5.66154271e-02f,
  8.37180391e-02f, 8.67685676e-02f, 1.51180685e-01f, 8.81859288e-02f, -4.48465385e-02f, 8.81846398e-02f, 3.23979072e-02f, -8.59810486e-02f, 6.19956031e-02f, 7.81748146e-02f,
  1.06294163e-01f, -5.30602001e-02f, 8.99921916e-03f, -1.98843852e-01f, -8.24854672e-02f, 1.42511129e-01f, -1.63155213e-01f, -5.08358702e-02f, -1.97967261e-01f, -7.89246038e-02f,
  -6.15632161e-03f, -7.02544302e-02f, -2.24885736e-02f, 8.36776793e-02f, 5.29367849e-02f, -2.44029965e-02f, -1.40529927e-02f, 2.41326280e-02f, 1.52262166e-01f, 6.29991814e-02f,
  -6.30476400e-02f, -1.05386965e-01f, 1.17991511e-02f, -1.02939777e-01f, -1.80248395e-02f, 4.56028245e-02f, -3.20696346e-02f, 3.62974182e-02f, -7.53604025e-02f, -8.62889066e-02f,
  8.63963813e-02f, -5.68493903e-02f, 6.72864467e-02f, -2.29393337e-02f, 1.85101125e-02f, -7.87643716e-02f, 1.89578384e-02f, -1.49428293e-01f, 2.33375449e-02f, 6.90963864e-02f,
  -2.52099633e-01f, -1.82128519e-01f, 7.96179399e-02f, 4.24081832e-02f, 1.01124262e-02f, -3.45209800e-02f, -6.44279271e-02f, -6.59226850e-02f, 7.61693120e-02f, -1.00223288e-01f,
  -1.46304578e-01f, -1.14641473e-01f, -1.11665502e-01f, 6.02088720e-02f, 6.24339767e-02f, -6.54238760e-02f, -3.51296626e-02f, 1.33706644e-01f, -4.92012948e-02f, 6.09690286e-02f,
  6.33429810e-02f, 8.46954957e-02f, 1.95844416e-02f, -1.25978649e-01f, -6.26499429e-02f, 1.34901002e-01f, -6.90814555e-02f, 7.21540377e-02f, -8.09787437e-02f, -7.19283670e-02f,
  1.98291272e-01f, -2.21477747e-01f, -1.47709131e-01f, -1.77311376e-01f, 2.50047743e-01f, 3.13694865e-01f, 6.43292069e-02f, 1.46922439e-01f, -1.93346322e-01f, 4.94182743e-02f,
  5.08287400e-02f, -4.74839419e-01f, -2.51575977e-01f, -1.71902210e-01f, -1.08833693e-01f, -2.84105420e-01f, -2.26257574e-02f, -8.90877396e-02f, -1.04426563e-01f, 2.26548955e-01f,
  -4.01759483e-02f, 2.44442686e-01f, -7.87373930e-02f, 3.47310185e-01f, 3.05661798e-01f, 2.56369531e-01f, 2.94299692e-01f, -3.58118154e-02f, 1.94246724e-01f, -1.12374425e-01f,
  -4.36692052e-02f, -8.70266259e-02f, 2.00110711e-02f, 5.69855832e-02f, 7.39981830e-02f, 2.07326412e-01f, 6.38691103e-03f, -5.29067367e-02f, -1.02719918e-01f, -7.05367550e-02f,
  -1.07881039e-01f, -3.26774903e-02f, 2.45360006e-02f, -8.11320394e-02f, 1.19997084e-01f, -4.04623337e-02f, 1.08708087e-02f, -5.05008176e-02f, -1.54636830e-01f, -1.59546122e-01f,
  -4.18852530e-02f, 3.93767729e-02f, -3.16488993e-04f, -6.83790892e-02f, -9.97782201e-02f, -4.63955663e-02f, 6.58858800e-04f, -4.35851552e-02f, -7.49583021e-02f, 6.08488433e-02f,
  1.56931311e-01f, -7.83435628e-03f, 1.45251825e-01f, -2.55911741e-02f, 1.12281129e-01f, -1.70371979e-02f, -9.64941178e-03f, -6.79393709e-02f, 3.36529203e-02f, 2.80134776e-03f,
  -3.20357531e-02f, -5.00579691e-03f, -8.18614438e-02f, 1.02263046e-02f, 4.66964655e-02f, -5.60994260e-02f, 4.14130054e-02f, 6.70081526e-02f, -5.49161769e-02f, 3.65624279e-02f,
  -2.15097159e-01f, -3.89840230e-02f, 1.00130159e-02f, -2.20800024e-02f, -1.00317122e-02f, -3.78418751e-02f, 7.35106394e-02f, 6.94696903e-02f, 8.95998906e-03f, -3.34942900e-02f,
  1.08366646e-01f, 9.09074098e-02f, 3.13293822e-02f, -1.37401342e-01f, -9.01706964e-02f, 1.98664039e-01f, -5.24073467e-02f, -5.03539406e-02f, 6.04692884e-02f, -1.98275484e-02f,
  1.90082461e-01f, 2.16345172e-02f, -1.26482053e-02f, -5.20158038e-02f, -3.45360860e-02f, 2.21198738e-01f, -5.96338548e-02f, 5.31793907e-02f, 1.62640512e-01f, 9.73531902e-02f,
  6.65620044e-02f, 8.84494856e-02f, -1.38109992e-03f, 1.19398452e-01f, 4.96073775e-02f, 2.40113717e-02f, 1.34576440e-01f, 8.97320881e-02f, -4.63857576e-02f, -1.15771972e-01f,
  3.57632071e-01f, -3.75802368e-02f, -3.03065330e-01f, -4.98395134e-03f, 7.52176298e-03f, 8.35448802e-02f, 6.70097321e-02f, -8.23156014e-02f, 7.18818456e-02f, -1.42485395e-01f,
  -3.32477331e-01f, -1.53989092e-01f, 4.03663106e-02f, -1.62706181e-01f, 3.37740302e-01f, 1.43505484e-01f, 1.34807453e-01f, -1.81819990e-01f, -1.10299692e-01f, 6.21047318e-02f,
  -1.40417337e-01f, -1.73307046e-01f, -2.29640707e-01f, -1.10404506e-01f, -1.86334923e-01f, -1.08472310e-01f, -1.41777126e-02f, -2.62262970e-01f, -3.23072165e-01f, -2.37822354e-01f,
  -1.53756768e-01f, -2.30563395e-02f, -1.16769753e-01f, -9.97035485e-03f, 3.63732129e-02f, 1.28588498e-01f, -3.94640416e-02f, -8.62386376e-02f, -9.37731713e-02f, -3.98375615e-02f,
  9.94430780e-02f, -1.03694230e-01f, 3.62020433e-02f, 4.55384590e-02f, -1.18664913e-01f, 6.72917590e-02f, -1.00238860e-01f, -4.49955650e-02f, -1.32979244e-01f, -9.45608094e-02f,
  8.22132379e-02f, 4.17350382e-02f, -1.05041303e-02f, -2.57303864e-02f, 9.41154733e-02f, 9.40843299e-02f, 1.25624061e-01f, 7.23538399e-02f, -3.64536531e-02f, 7.83457458e-02f,
  8.78664479e-03f, 9.24865827e-02f, 4.24010679e-02f, -1.93095326e-01f, -2.69049257e-02f, -2.34794226e-02f, -1.41333386e-01f, -1.02720514e-01f, -4.42400873e-02f, -5.80918677e-02f,
  7.66230449e-02f, -8.88792053e-02f, -6.28318191e-02f, 2.68206634e-02f, 1.37156621e-01f, 7.88906664e-02f, -2.79065035e-02f, 8.99582729e-02f, 6.66226000e-02f, -2.64655184e-02f,
  -6.61713108e-02f, 8.78760964e-03f, -4.46317643e-02f, -1.21921138e-03f, 3.53808589e-02f, -1.54929198e-02f, -1.27150849e-01f, -6.08602464e-02f, 2.24708300e-02f, -2.24946663e-02f,
  1.05202466e-01f, 2.15206817e-01f, -1.25256598e-01f, -7.29392236e-03f, 7.60084242e-02f, 1.30484313e-01f, -1.03053384e-01f, 3.25474218e-02f, 6.56790137e-02f, 1.16636969e-01f,
  1.40220061e-01f, 6.66523492e-03f, 3.76817323e-02f, 6.14425465e-02f, -1.15322582e-01f, 3.98311988e-02f, 8.49074647e-02f, 5.94149008e-02f, 1.08140007e-01f, 7.28782639e-02f,
  3.83381322e-02f, -4.90441620e-02f, 1.32616814e-02f, 4.09802645e-02f, 3.91292758e-02f, 1.18500300e-01f, 2.03328341e-01f, -1.70320198e-02f, 2.45039687e-02f, 3.48059162e-02f,
  -6.33331984e-02f, -1.80100769e-01f, -8.32301080e-02f, -1.80064291e-01f, 2.73394018e-01f, 2.83230841e-01f, 5.06551445e-01f, 1.88742590e-03f, -1.20264485e-01f, 7.41446912e-02f,
  1.50697410e-01f, 3.36741954e-01f, 3.15899640e-01f, 3.27734202e-02f, 2.76312381e-01f, 4.80284877e-02f, -2.04532102e-01f, 1.40254432e-02f, 2.22354569e-02f, -1.26706630e-01f,
  -2.19778717e-01f, 1.28365234e-01f, -1.89193174e-01f, -1.69787347e-01f, 8.16285759e-02f, -9.28379074e-02f, 1.23095341e-01f, 3.93827170e-01f, -1.18045593e-02f, 2.90047467e-01f,
  2.89836843e-02f, 1.17894873e-01f, -1.70395985e-01f, -9.57715213e-02f, -6.81759492e-02f, 1.03861643e-02f, 1.66862339e-01f, 2.25297183e-01f, 2.13843174e-02f, 1.26770750e-01f,
  1.65272310e-01f, -1.47469351e-02f, 1.92264784e-02f, -8.30775686e-03f, 2.52140053e-02f, -4.61308844e-02f, 1.07143587e-02f, -2.48627719e-02f, -4.23018001e-02f, -4.65662815e-02f,
  -1.16186976e-01f, -1.92651540e-01f, 4.78756800e-02f, -8.06726664e-02f, 1.01962574e-01f, -1.80177391e-01f, -1.85728878e-01f, 2.28871405e-01f, 7.13693053e-02f, -4.58897538e-02f,
  4.31714319e-02f, -1.87042914e-02f, 2.76186336e-02f, -1.06793664e-01f, 3.70219909e-03f, -1.62612926e-02f, 1.69947138e-03f, 1.04363321e-03f, -1.47428084e-02f, 7.39084929e-02f,
  -8.14612210e-02f, -7.47958198e-03f, 1.85601953e-02f, -1.95056386e-02f, 3.51414531e-02f, -4.52178791e-02f, 1.41401425e-01f, 7.73514435e-02f, -5.63328564e-02f, 1.08298950e-01f,
  -2.38482002e-03f, -9.10888799e-03f, 1.01142913e-01f, -1.71181694e-01f, 4.97544445e-02f, 9.60530639e-02f, -5.70303649e-02f, 5.62725812e-02f, -1.58234760e-01f, 1.69797644e-01f,
  4.00972292e-02f, 2.98663914e-01f, -3.77207771e-02f, -4.07103039e-02f, -3.46639678e-02f, 8.08630809e-02f, 6.64882958e-02f, -4.18968275e-02f, 1.84490308e-01f, 6.82615638e-02f,
  -7.97244012e-02f, -6.52608043e-03f, -5.53073175e-02f, -1.79395247e-02f, 6.98257685e-02f, -5.12675457e-02f, 1.03343390e-01f, 3.64341959e-02f, -2.36158865e-03f, 5.44627719e-02f,
  -5.63708469e-02f, -7.69161386e-03f, 4.13800366e-02f, 8.82498026e-02f, -8.91558006e-02f, 7.16707483e-02f, -8.17494094e-02f, 4.54115830e-02f, 5.41766658e-02f, 1.31737962e-01f,
  4.99047004e-02f, 7.29849637e-02f, -4.12584245e-02f, -1.95674568e-01f, -1.39957801e-01f, -3.51461560e-01f, -2.34725147e-01f, -9.06557217e-02f, 2.70233989e-01f, 5.45547642e-02f,
  -1.58433050e-01f, 2.42823005e-01f, 1.72289938e-01f, -2.76587427e-01f, 3.05247586e-02f, 2.35462010e-01f, -2.31526166e-01f, -1.70188770e-01f, 1.64355218e-01f, -1.98594958e-01f,
  -4.49807011e-02f, -2.00302795e-01f, -2.05038175e-01f, -2.51088709e-01f, -2.37483844e-01f, 7.22801238e-02f, 4.90606911e-02f, -9.76688415e-03f, -1.48941219e-01f, 6.05433481e-03f,
  -7.03094155e-03f, -3.59806977e-02f, 4.19161394e-02f, -7.01905787e-02f, -4.21420708e-02f, -7.22976029e-02f, -3.91300805e-02f, 6.71680495e-02f, 5.64540960e-02f, 1.19665623e-01f,
  7.38062561e-02f, 1.01933770e-01f, 8.22851434e-03f, 1.23443492e-01f, -5.37125915e-02f, 1.13288082e-01f, -5.74605018e-02f, 1.79992616e-02f, -9.34723094e-02f, 1.00876145e-01f,
  -9.63423699e-02f, 9.96866599e-02f, -9.91855264e-02f, 1.64906010e-01f, 4.28134669e-03f, 3.02876141e-02f, -5.77096567e-02f, 9.54395533e-02f, -4.25557978e-02f, 8.20787326e-02f,
  -1.14967115e-01f, 4.97836657e-02f, -1.24355085e-01f, 5.17480560e-02f, -8.72990787e-02f, 2.54611280e-02f, -9.83366221e-02f, 2.45677016e-04f, 1.10461041e-01f, 2.02592108e-02f,
  -5.56300245e-02f, 8.05387720e-02f, -3.69053371e-02f, -4.23424765e-02f, -1.26702273e-02f, 4.83246222e-02f, -6.95033073e-02f, -2.74921283e-02f, -1.67940855e-02f, -1.98744591e-02f,
  -3.15741748e-02f, -8.76902640e-02f, 5.79119064e-02f, 4.27936539e-02f, -1.27336070e-01f, 8.71677846e-02f, 4.82040830e-02f, -4.97812219e-02f, -1.74508300e-02f, -7.90711939e-02f,
  -1.18038245e-01f, -1.96924120e-01f, -9.88972280e-03f, 7.35314786e-02f, 6.44859225e-02f, 3.65012698e-02f, 1.09377420e-02f, -1.85619574e-02f, -1.44803420e-01f, -1.78315088e-01f,
  7.21486798e-03f, -7.33705461e-02f, -2.74813939e-02f, 9.01689455e-02f, -2.14621965e-02f, -4.31903973e-02f, 1.12618115e-02f, 7.91547913e-03f, -1.34622514e-01f, 9.50014219e-03f,
  -4.39929441e-02f, -5.33260591e-02f, 1.47338519e-02f, -8.62206239e-03f, -2.89780777e-02f, 1.11083668e-02f, -4.51179082e-03f, 1.29119325e-02f, -5.34107052e-02f, 2.05144938e-03f,
  -2.14635450e-02f, -4.71872799e-02f, -3.96852583e-01f, -3.43920887e-01f, 1.91369444e-01f, 4.66622151e-02f, -4.52887937e-02f, 2.73239426e-02f, -1.05477095e-01f, 2.39567518e-01f,
  2.44297832e-01f, -6.80385623e-03f, -9.06006917e-02f, -1.47539467e-01f, -3.93039942e-01f, -3.36356759e-01f, -1.24113880e-01f, -4.64083068e-02f, -1.37656361e-01f, 6.62909001e-02f,
  -1.87711224e-01f, 2.01216176e-01f, -2.14383110e-01f, 2.36669704e-01f, 1.67673007e-01f, -3.88039537e-02f, 1.90764174e-01f, 1.93554908e-01f, 1.51805311e-01f, 1.33704484e-01f,
  -8.55889991e-02f, -9.10760462e-03f, -9.40668657e-02f, 1.24811241e-02f, 5.17967381e-02f, -4.59095724e-02f, -6.77903509e-03f, -2.81313853e-03f, -2.65534502e-02f, -6.37178719e-02f,
  -3.37371379e-02f, -2.87173763e-02f, -3.99664156e-02f, 7.59951994e-02f, 1.04042605e-01f, 7.05134356e-03f, -1.08519480e-01f, -1.51645005e-01f, -1.14998460e-01f, -9.70647782e-02f,
  -7.23694861e-02f, -1.11506589e-01f, -5.44390455e-02f, -8.31605196e-02f, -8.77960250e-02f, 1.08025782e-01f, -5.35486080e-02f, -5.93823157e-02f, -8.44874159e-02f, -2.53099985e-02f,
  7.78502449e-02f, 2.12140486e-01f, -1.30360518e-02f, -2.36063711e-02f, -1.61952954e-02f, -5.63500561e-02f, -3.61671895e-02f, -4.49208431e-02f, 4.24938723e-02f, 1.05764968e-02f,
  5.48622459e-02f, -2.95625553e-02f, 4.11875024e-02f, 1.12785600e-01f, 7.10519552e-02f, -8.15115944e-02f, -9.08714458e-02f, 5.88673651e-02f, -1.70261394e-02f, -1.17175452e-01f,
  7.17006698e-02f, -1.34322117e-03f, -1.76104959e-02f, 1.57850923e-03f, -3.51052098e-02f, 1.66391246e-02f, 1.18106939e-01f, 1.01186046e-02f, -6.68147653e-02f, 7.33361207e-03f,
  3.50041799e-02f, 6.07947037e-02f, -3.15225050e-02f, 3.74034047e-03f, -1.21242432e-02f, 3.73128615e-02f, 1.99290402e-02f, -1.24742679e-01f, -3.54393981e-02f, 5.80381751e-02f,
  1.39058664e-01f, -9.48577188e-03f, 3.46356072e-02f, -4.03215103e-02f, -4.82795760e-02f, 6.23073019e-02f, 1.08820200e-01f, 7.73873925e-02f, 8.24077427e-02f, -6.33324236e-02f,
  1.30118012e-01f, 3.13062221e-02f, -2.46697739e-02f, 2.09819451e-02f, 3.84514146e-02f, 1.11137204e-01f, 1.85267478e-02f, 8.13512783e-03f, 4.76355031e-02f, 4.84323502e-02f,
  -1.48438752e-01f, -3.08221042e-01f, -5.45235947e-02f, 9.38942507e-02f, 1.20212711e-01f, 1.41904086e-01f, 2.88066715e-01f, -2.62963414e-01f, -4.73695874e-01f, -6.32299036e-02f,
  6.96472079e-02f, 1.78044662e-01f, -2.44704515e-01f, 3.41175832e-02f, 1.06184684e-01f, -1.99278802e-01f, 1.05715737e-01f, 1.12134241e-01f, -2.10313112e-01f, -1.39428467e-01f,
  -2.02971444e-01f, -7.09285960e-02f, -9.03960913e-02f, -1.13278419e-01f, 9.04270560e-02f, 1.28155902e-01f, 3.54599297e-01f, 2.23334804e-01f, 3.28779906e-01f, 2.68090695e-01f,
  4.81238775e-02f, -2.16323793e-01f, -1.19846147e-02f, -5.18171722e-03f, -1.48936445e-02f, 1.92636177e-01f, 2.22965211e-01f, 1.92740396e-01f, 1.05564989e-01f, -1.71428286e-02f,
  1.05930388e-01f, -5.10847829e-02f, 2.98841167e-02f, 5.48592024e-02f, -1.15452714e-01f, 6.85826018e-02f, -1.17386773e-01f, -5.97590581e-02f, -2.35104766e-02f, -1.23403758e-01f,
  -1.46049351e-01f, -1.22839227e-01f, 3.82637754e-02f, 7.58861378e-02f, -2.73823906e-02f, -1.70504421e-01f, -1.42680004e-01f, 1.24594115e-01f, 1.49232700e-01f, -6.25351667e-02f,
  9.84786749e-02f, 3.98728624e-02f, -1.01551652e-01f, -3.83113883e-02f, 2.45696567e-02f, 1.17734037e-01f, -2.36164834e-02f, -5.60278371e-02f, 8.30048844e-02f, -1.08947799e-01f,
  -5.91087192e-02f, -9.96288937e-03f, 5.11915274e-02f, -7.02299252e-02f, -2.50905287e-02f, -6.82109818e-02f, 1.18576892e-01f, 1.25682414e-01f, -1.18796453e-02f, -4.90076616e-02f,
  -5.46493456e-02f, 5.31281754e-02f, -1.18486904e-01f, -2.94886548e-02f, -9.71573070e-02f, 1.45744777e-03f, 1.50261566e-01f, -5.13356924e-02f, 7.87960459e-03f, 6.94362521e-02f,
  3.94350775e-02f, -2.75515579e-02f, -8.93217921e-02f, 1.23015955e-01f, 9.51722860e-02f, 5.21756560e-02f, 1.03717595e-01f, 7.65790716e-02f, -6.88058138e-02f, -1.29587755e-01f,
  -3.90903428e-02f, 9.06274691e-02f, 8.08381587e-02f, 5.16419113e-02f, 1.33858040e-01f, -1.33564457e-01f, -2.32686307e-02f, 8.12586471e-02f, 8.35081860e-02f, 3.31627540e-02f,
  -1.58625878e-02f, 6.96915686e-02f, 3.49171795e-02f, 2.96830852e-03f, -2.18519922e-02f, 1.36884868e-01f, 1.34658180e-02f, -3.04243211e-02f, 1.47488713e-01f, 1.43189877e-01f,
  -7.46624619e-02f, 2.45779365e-01f, -3.40524346e-01f, 3.51306021e-01f, -2.69605875e-01f, 3.72186810e-01f, 3.65537733e-01f, 8.15825444e-03f, 2.81103522e-01f, 3.21809769e-01f,
  7.36867562e-02f, 1.98108375e-01f, -6.08657077e-02f, 5.74054301e-01f, 3.03632826e-01f, 3.24226826e-01f, 5.70627272e-01f, 4.77463454e-01f, 8.19408670e-02f, 2.13157043e-01f,
  -4.36666608e-02f, 3.77177387e-01f, -2.65214056e-01f, -1.23057634e-01f, -1.41935974e-01f, -3.29001158e-01f, -2.61687189e-01f, -3.07919174e-01f, 1.56170681e-01f, -3.55475843e-02f,
  1.23437919e-01f, -3.84786678e-03f, -8.45819861e-02f, -7.56578008e-03f, 4.16464405e-03f, -4.12582941e-02f, -8.88811983e-03f, -9.50156152e-02f, 2.39213021e-03f, 4.51264419e-02f,
  1.09384023e-01f, 5.95285930e-02f, 1.17890611e-01f, -4.54267748e-02f, -4.09550779e-02f, -7.43232220e-02f, 2.36288067e-02f, -1.08076006e-01f, 1.91386547e-02f, -4.97338474e-02f,
  -8.52573514e-02f, 1.88191123e-02f, 3.94219123e-02f, 8.25712606e-02f, -1.07602224e-01f, 1.41809836e-01f, 1.20257616e-01f, -1.25157610e-01f, 5.14203385e-02f, 1.15804635e-02f,
  -3.10154278e-02f, 8.70677158e-02f, -3.14217992e-02f, -3.53814438e-02f, 4.29933146e-03f, -1.38626903e-01f, 1.23772115e-01f, -5.91155365e-02f, -7.92075843e-02f, 3.64634842e-02f,
  -1.83585845e-02f, -5.30646667e-02f, 6.94241598e-02f, 4.00657095e-02f, 5.79368621e-02f, 7.41540119e-02f, -1.02118738e-01f, 2.45328657e-02f, 4.03111950e-02f, -3.38913524e-03f,
  -5.44560514e-02f, 5.79192452e-02f, 3.43825743e-02f, -1.04332402e-01f, 5.88770285e-02f, -1.08392052e-01f, -2.26217918e-02f, -6.68019876e-02f, 2.48351209e-02f, -9.46268346e-03f,
  2.12996095e-01f, 3.13114345e-01f, 1.26994178e-02f, 7.27169067e-02f, -2.09111185e-03f, 6.33573160e-02f, 5.14119789e-02f, -1.84065495e-02f, 1.86489839e-02f, 7.31386915e-02f,
  4.19979878e-02f, 5.17159626e-02f, -2.67830379e-02f, -3.06454729e-02f, 5.87483793e-02f, 6.12989962e-02f, 1.29320696e-01f, -2.48006191e-02f, -9.03613865e-03f, 6.95064813e-02f,
  3.44727263e-02f, 7.63077512e-02f, -1.25856204e-02f, 2.26763450e-02f, 8.59377086e-02f, -5.89417368e-02f, 5.77983353e-03f, 1.49706500e-02f, -3.54283750e-02f, 5.81634939e-02f,
  -1.57085046e-01f, -6.93553314e-02f, 1.39413521e-01f, 9.59377065e-02f, 2.34743264e-02f, 2.41775900e-01f, 1.05924726e-01f, -1.31721646e-01f, 1.06100589e-01f, 2.31971554e-02f,
  -2.55424559e-01f, 7.89032057e-02f, -3.16004932e-01f, -2.68940121e-01f, -1.13802940e-01f, -6.44436032e-02f, 2.81333420e-02f, 1.00531667e-01f, -1.28401265e-01f, -5.49212098e-03f,
  -1.89444005e-01f, -1.37209073e-01f, -2.62666136e-01f, -1.30969822e-01f, 1.33194521e-01f, 1.37813538e-01f, 2.37182140e-01f, 1.59048572e-01f, 1.35580808e-01f, 4.06689867e-02f,
  9.41048283e-03f, -2.13673204e-01f, -7.90457949e-02f, -1.79388896e-02f, 1.24815494e-01f, 1.53968439e-01f, 1.22017793e-01f, -3.18356752e-02f, 1.12400891e-03f, -8.86429250e-02f,
  1.34496111e-03f, -4.92368788e-02f, 2.75583491e-02f, -6.85125217e-02f, -6.96228743e-02f, -4.04047407e-02f, 5.98370582e-02f, -3.42191719e-02f, -1.60071328e-02f, -1.04923591e-01f,
  -7.29719400e-02f, -2.15704087e-02f, 7.29708746e-02f, 1.92642733e-01f, -1.70809794e-02f, 1.13211875e-03f, 6.80903569e-02f, 8.28046724e-02f, 8.87237787e-02f, 1.27837792e-01f,
  -6.69127796e-03f, 5.39807826e-02f, -1.11383237e-01f, -1.03267320e-01f, -7.70855844e-02f, -1.02793500e-01f, -1.36542385e-02f, -5.11693470e-02f, -2.88604945e-02f, 7.16634765e-02f,
  1.22638345e-02f, -2.31086165e-02f, 2.21570432e-02f, 2.83275787e-02f, -1.52762696e-01f, -2.42271964e-02f, -6.69924766e-02f, 9.27341953e-02f, -2.45261239e-03f, 6.43785228e-04f,
  -1.42593458e-01f, 8.19029659e-02f, -1.53364092e-01f, 9.15684924e-02f, 2.23228317e-02f, -1.02991767e-01f, 5.45415208e-02f, -4.19428200e-03f, -1.25100156e-02f, -3.93132754e-02f,
  1.41056478e-01f, 2.64514625e-01f, -1.09862484e-01f, -1.05578907e-01f, 3.64919379e-02f, -7.20400829e-03f, -6.10390096e-04f, -7.04347715e-02f, 7.01941922e-02f, -8.83554146e-02f,
  2.74770651e-02f, -4.76484187e-02f, 1.52019650e-01f, 9.93342698e-02f, 5.48872538e-02f, -1.79160357e-01f, 2.09471107e-01f, 1.04198053e-01f, 1.84154212e-01f, 5.72987571e-02f,
  4.44784686e-02f, 1.05266623e-01f, -7.72665143e-02f, 1.02761993e-02f, -8.86524543e-02f, -7.73738623e-02f, 5.50082438e-02f, 1.34216338e-01f, 8.00355971e-02f, 1.45893320e-01f,
  -1.49479941e-01f, 4.16488469e-01f, 1.38396710e-01f, -1.06783897e-01f, -2.18992576e-01f, -1.96776018e-01f, -2.34187152e-02f, 1.58199474e-01f, 2.98770726e-01f, 2.16935828e-01f,
  -7.21752271e-03f, 2.92315692e-01f, 3.51681590e-01f, -9.58498642e-02f, -2.77713478e-01f, 1.08673014e-02f, -1.89050272e-01f, 6.29130676e-02f, 9.19174589e-03f, -1.44887075e-01f,
  -2.32396707e-01f, -3.67734730e-01f, -2.08434358e-01f, -1.25006303e-01f, -2.35763669e-01f, 9.99924690e-02f, -3.95024508e-01f, -1.60407245e-01f, -2.01908320e-01f, -1.51043478e-02f,
  7.82968998e-02f, 2.32907072e-01f, 8.12926888e-02f, 1.58362791e-01f, 3.22747007e-02f, 8.76137391e-02f, -6.53545782e-02f, -5.60442954e-02f, 7.77703077e-02f, 1.11289836e-01f,
  -2.22403109e-02f, 3.78165953e-02f, -7.18762875e-02f, -6.32941648e-02f, -6.45405948e-02f, 7.40842521e-03f, -2.49286555e-02f, -6.19420931e-02f, 1.62834689e-01f, -1.18675023e-01f,
  4.11655344e-02f, 4.77675088e-02f, -1.98011070e-01f, 5.19795790e-02f, -9.61867571e-02f, 8.13284889e-03f, 1.20297838e-02f, -1.04550496e-01f, -2.80254744e-02f, -1.13696322e-01f,
  -8.16146657e-02f, 4.50976230e-02f, 9.03105363e-02f, 9.63958949e-02f, -1.06599264e-01f, 4.13615294e-02f, -9.31153670e-02f, -7.81471357e-02f, -5.28786108e-02f, -9.55440924e-02f,
  1.30721116e-02f, 1.34124264e-01f, -3.67416851e-02f, -1.26582339e-01f, -1.86707482e-01f, 6.56936243e-02f, -1.30971313e-01f, 8.26285258e-02f, -1.26988545e-01f, 1.29686603e-02f,
  3.22886109e-02f, 5.02339154e-02f, 6.26904741e-02f, 2.25130524e-02f, 1.19990669e-01f, -4.69029844e-02f, -6.13117777e-02f, 6.13522641e-02f, 1.00569375e-01f, -2.60474861e-01f,
  1.52927756e-01f, -5.12221642e-02f, 1.32117897e-01f, 2.61610985e-01f, 5.88035882e-02f, 2.07742192e-02f, -1.32575452e-01f, 5.11879697e-02f, 2.37731002e-02f, 7.22025186e-02f,
  1.72576085e-02f, 1.01335607e-01f, -3.39586772e-02f, -9.68334377e-02f, -2.16945987e-02f, -7.43096620e-02f, -9.22075845e-03f, 1.19280994e-01f, 6.58871010e-02f, -5.92445349e-03f,
  -3.13415229e-02f, -2.47809645e-02f, 3.55370156e-02f, -1.31299689e-01f, -1.12458330e-03f, -1.17089555e-01f, -3.56529769e-03f, 9.86776352e-02f, -1.60551235e-01f, 1.18884463e-02f,
  -4.67191041e-01f, 3.06512117e-01f, 1.71744883e-01f, -4.08236235e-01f, 3.58043730e-01f, 3.75520349e-01f, -1.95029736e-01f, 2.04950020e-01f, 2.77694315e-01f, -2.33223885e-01f,
  -2.55337775e-01f, -1.68932289e-01f, 1.56635210e-01f, -2.81985551e-01f, 1.69806316e-01f, 3.42067063e-01f, -4.56685573e-02f, -1.60649642e-01f, 4.30773020e-01f, -1.89988434e-01f,
  6.06386177e-02f, -3.75602424e-01f, -1.31977171e-01f, 1.59317255e-01f, -1.85625002e-01f, -3.00095845e-02f, -2.82913357e-01f, 2.81999946e-01f, -2.35213578e-01f, 1.90944493e-01f,
  -2.84988945e-03f, -3.77389020e-03f, 8.59600827e-02f, 1.68947652e-01f, -1.83664083e-01f, -9.48401392e-02f, -2.46326551e-02f, -3.12414626e-03f, 1.09165154e-01f, 7.12450594e-02f,
  -1.04796782e-01f, 3.87436873e-03f, 3.80124114e-02f, 8.38274732e-02f, 1.82546020e-01f, 8.71019140e-02f, -2.49141641e-02f, -8.18926543e-02f, 5.19220419e-02f, 4.39933054e-02f,
  1.55503703e-02f, 7.62683824e-02f, -5.37447445e-02f, -2.48741098e-02f, 5.24381623e-02f, 7.32578412e-02f, -5.09772561e-02f, 6.68751001e-02f, 7.91815147e-02f, 2.08746009e-02f,
  3.63992676e-02f, 9.24862828e-03f, -5.15272804e-02f, -7.93766156e-02f, -2.02396382e-02f, -2.50276644e-02f, -5.72869517e-02f, -1.41620010e-01f, 8.71269405e-02f, -4.76112291e-02f,
  -4.20485064e-02f, -6.01759180e-02f, 2.85982694e-02f, 1.05728833e-02f, -4.98197712e-02f, -5.85208349e-02f, -8.28441158e-02f, -6.17275201e-02f, 2.07931008e-02f, 4.20158878e-02f,
  5.80942445e-02f, 4.89205718e-02f, -2.50476617e-02f, -9.71597899e-03f, 1.04817443e-01f, 4.79491949e-02f, -3.07562668e-03f, -8.43468308e-02f, 6.27492592e-02f, 2.61419453e-02f,
  1.03093252e-01f, -1.40173912e-01f, 1.05381738e-02f, 5.82467765e-02f, -8.82975832e-02f, 1.42308652e-01f, -5.83534911e-02f, 1.00411579e-01f, -1.53412782e-02f, 8.64027068e-02f,
  -6.46913424e-02f, -1.22243471e-01f, -7.75092915e-02f, 9.08709392e-02f, -1.66681744e-02f, 1.83974039e-02f, -1.60083964e-01f, -4.62984294e-02f, -6.11418448e-02f, 1.15241826e-01f,
  -3.73861268e-02f, -1.28299892e-01f, -5.05107753e-02f, 4.85243239e-02f, -2.76573934e-02f, -5.50070889e-02f, -6.20428324e-02f, 1.53820440e-01f, -6.18022159e-02f, 8.16685781e-02f,
  1.17188267e-01f, -3.09441149e-01f, -2.48238012e-01f, -3.75634521e-01f, -2.30906531e-01f, 1.67783022e-01f, -1.57257557e-01f, -9.98058394e-02f, -3.93043816e-01f, 4.40571755e-02f,
  -1.10660814e-01f, -1.28218278e-01f, 4.42228243e-02f, -2.58118123e-01f, 8.85765478e-02f, -9.93120447e-02f, -1.76226765e-01f, -1.69179127e-01f, -1.71601996e-01f, 3.85176726e-02f,
  3.94601859e-02f, 2.83468491e-03f, -1.46968842e-01f, 1.00603655e-01f, -1.26328588e-01f, -8.10128674e-02f, 1.29175171e-01f, -1.94560975e-01f, -9.85827819e-02f, -1.57428890e-01f,
  2.82098874e-02f, -1.28274664e-01f, 3.05253547e-02f, 5.10228872e-02f, 1.12919472e-01f, 6.66068047e-02f, -3.82505707e-04f, -4.03287224e-02f, -2.07852256e-02f, -2.44382047e-03f,
  1.70983896e-01f, 2.20371708e-02f, 1.69527978e-02f, -4.10745591e-02f, -4.35293801e-02f, 2.96876263e-02f, 7.33443797e-02f, -4.75195274e-02f, -3.95024791e-02f, 1.72178790e-01f,
  -1.36947677e-01f, -3.22380401e-02f, -1.71254296e-02f, -1.50626302e-01f, -5.29590100e-02f, 2.01152451e-02f, 1.62820697e-01f, 1.12718008e-01f, -1.83700830e-01f, 1.35226369e-01f,
  8.07826594e-02f, 7.24353641e-02f, 1.68208271e-01f, -1.75962642e-01f, 6.21319413e-02f, -7.70367756e-02f, 4.25295904e-03f, 1.21019296e-01f, -5.81349321e-02f, 1.13085978e-01f,
  -5.37707005e-03f, 9.90724843e-03f, 3.32125276e-02f, 1.01027191e-01f, 1.62733365e-02f, 1.18641503e-01f, -1.40114650e-02f, -3.63000594e-02f, -8.04173127e-02f, 1.84749672e-03f,
  -2.14508936e-01f, -9.68952384e-03f, 9.58296508e-02f, -1.20758355e-01f, -5.72577026e-03f, 7.74157941e-02f, -6.48702402e-03f, 7.02517927e-02f, -9.29765031e-02f, 2.57704756e-03f,
  -4.10455689e-02f, 1.27029181e-01f, -2.57223621e-02f, -1.24277705e-02f, 5.87472394e-02f, 3.67292166e-02f, -1.28363028e-01f, -3.17323916e-02f, -7.90045932e-02f, 8.48410875e-02f,
  1.43378794e-01f, -1.60456877e-02f, 9.88081619e-02f, -8.91267657e-02f, -1.00761071e-01f, 1.63396612e-01f, 7.06354901e-02f, -4.80303429e-02f, -7.74910254e-03f, 1.07205957e-01f,
  -3.96299623e-02f, 1.74629569e-01f, 4.24967892e-02f, -4.08381298e-02f, -7.91788772e-02f, 9.68827382e-02f, 2.63001293e-01f, 1.03574611e-01f, -1.53760895e-01f, -6.17180057e-02f,
  -4.26984217e-04f, 2.31469020e-01f, -4.02775258e-02f, 1.10056601e-01f, -3.09243590e-01f, 1.80633679e-01f, 4.44695026e-01f, -1.20973535e-01f, 1.92568734e-01f, 3.00451905e-01f,
  -2.11645335e-01f, 3.79067123e-01f, -1.70298025e-01f, -2.12738886e-02f, -1.76845521e-01f, -5.96718453e-02f, 2.92148441e-01f, 3.61701131e-01f, 5.21900505e-02f, 9.52060595e-02f,
  -1.03490859e-01f, -8.33076164e-02f, -1.17613561e-01f, -1.16273269e-01f, -7.93288648e-02f, 7.28527233e-02f, -2.93908268e-01f, -1.40113249e-01f, -1.54040346e-03f, -1.48135588e-01f,
  -2.31697485e-02f, -4.37940583e-02f, 1.00769512e-02f, 1.03393629e-01f, 4.18834463e-02f, 2.04772484e-02f, 1.01630809e-03f, -4.32856791e-02f, -7.25299045e-02f, -5.82931116e-02f,
  7.78058991e-02f, -2.24361978e-02f, 1.36745647e-01f, -4.11074944e-02f, 1.07783437e-01f, 1.77498199e-02f, -5.27705587e-02f, -6.51909858e-02f, 2.05616392e-02f, -1.04888745e-01f,
  4.24239188e-02f, -1.08085794e-03f, -1.80768654e-01f, 6.14534467e-02f, -3.17067653e-02f, -8.71031284e-02f, 8.33670422e-02f, -1.05858974e-01f, 1.37773708e-01f, -1.04612829e-02f,
  -5.95899113e-02f, -9.44484200e-04f, 9.65935178e-03f, -2.45346539e-02f, -7.24743083e-02f, -1.18614495e-01f, -1.44245205e-02f, 3.69732976e-02f, -3.64797525e-02f, -7.68416328e-03f,
  -1.48190400e-02f, -2.28331983e-02f, -8.95845704e-03f, -1.41229434e-03f, -5.14394837e-03f, 8.99146721e-02f, -7.25433826e-02f, -5.04297353e-02f, -3.19552720e-02f, -9.28932577e-02f,
  -9.43147689e-02f, 7.21170828e-02f, 1.09095067e-01f, 2.67788842e-02f, 1.51864402e-02f, -1.62793905e-01f, 4.97776223e-03f, -4.59390320e-02f, 2.98137963e-03f, 4.93594632e-03f,
  -9.09124501e-03f, 1.83657885e-01f, -3.06988992e-02f, 6.52380437e-02f, 8.95342603e-02f, -1.52386539e-03f, 1.08043656e-01f, 9.16223899e-02f, -1.51953902e-02f, 1.17872685e-01f,
  5.47646247e-02f, 5.46617322e-02f, 2.71125268e-02f, -1.00649528e-01f, 1.31035801e-02f, -2.14947239e-02f, -5.64957410e-02f, 2.30852179e-02f, -1.83737352e-02f, -6.59688637e-02f,
  6.14970289e-02f, 1.47486493e-01f, 1.19670518e-01f, 1.13192335e-01f, 5.77602312e-02f, 1.94501933e-02f, 8.78583267e-02f, -2.56384863e-03f, -5.75416908e-02f, 2.80646645e-02f,
  -8.61415416e-02f, 3.45442504e-01f, 1.98435381e-01f, 1.02730446e-01f, 1.47716478e-01f, -1.71499938e-01f, -2.83089131e-01f, 1.56186521e-01f, -5.88235185e-02f, -2.25913808e-01f,
  -1.37903079e-01f, 2.85088509e-01f, -1.93242028e-01f, 1.99143633e-01f, -3.90230209e-01f, -2.59976685e-01f, 2.44433172e-02f, -5.81194647e-03f, -5.33028990e-02f, -3.05655561e-02f,
  8.83501321e-02f, -1.30219474e-01f, -1.13033485e-02f, 1.88439935e-01f, 2.42140934e-01f, 2.04382569e-01f, -2.81371057e-01f, -2.05468554e-02f, 1.37832269e-01f, 1.33992255e-01f,
  -1.04950376e-01f, -1.55653194e-01f, -9.72899050e-02f, -1.44738508e-02f, -9.50701758e-02f, -2.64194757e-02f, -9.62319672e-02f, -6.65431246e-02f, -1.19580980e-02f, 7.34135732e-02f,
  -1.11625500e-01f, 2.66865846e-02f, 1.29274294e-01f, -7.29838340e-03f, 1.39437363e-01f, 2.20591202e-01f, 6.03350438e-03f, -3.77665684e-02f, 1.01469003e-01f, 3.22298631e-02f,
  4.86370623e-02f, 1.78835429e-02f, 9.11511481e-02f, -8.87123570e-02f, -6.36818781e-02f, 3.14124413e-02f, 1.04323789e-01f, -3.87388351e-03f, -3.32314484e-02f, 3.42642516e-02f,
  -9.78599191e-02f, -4.61095907e-02f, 9.68584865e-02f, 5.41490503e-02f, 3.29540484e-02f, -8.08286816e-02f, -7.23623484e-02f, -3.40300314e-02f, -3.58849503e-02f, -1.33315608e-01f,
  -3.46739567e-03f, 1.74463123e-01f, 2.00243145e-02f, -5.07336482e-03f, -1.21525817e-01f, 1.26953915e-01f, -5.39407991e-02f, -8.40834603e-02f, 2.21457463e-02f, -8.35033208e-02f,
  1.64827742e-02f, -2.68553663e-03f, 5.44822924e-02f, 5.37761673e-02f, -9.64443083e-04f, -1.79650739e-01f, -5.86284585e-02f, 1.04166269e-01f, -6.75633624e-02f, -6.77662790e-02f,
  -6.53412580e-01f, -4.77996886e-01f, -1.99844077e-01f, -1.14986420e-01f, 1.08261913e-01f, -3.32286060e-02f, -1.22143084e-03f, 1.28894106e-01f, -1.33124605e-01f, -1.44184932e-01f,
  1.13516126e-03f, -3.26637812e-02f, -2.12943777e-02f, 1.28770247e-02f, 2.71763094e-02f, -2.29974464e-02f, -1.20293833e-01f, -6.81598410e-02f, 8.04322865e-03f, -5.41545590e-03f,
  6.55326247e-02f, 4.77351993e-02f, 5.97001761e-02f, -4.04084101e-02f, 4.28476557e-02f, -1.11837611e-01f, 7.81959444e-02f, 1.58466011e-01f, 1.47259235e-02f, 1.10665627e-01f,
  4.93030012e-01f, -6.56133235e-01f, -5.90918250e-02f, 2.69989371e-01f, 3.26837152e-01f, 1.65380582e-01f, 3.51626098e-01f, -2.54009254e-02f, 1.46436900e-01f, -3.99437457e-01f,
  1.06531061e-01f, -1.77090973e-01f, -3.00378352e-01f, 2.17059538e-01f, 2.98501879e-01f, -1.37243524e-01f, 1.83771566e-01f, 5.05017750e-02f, -3.46559137e-02f, -5.27149551e-02f,
  7.60236382e-02f, 2.69439101e-01f, 1.06623001e-01f, -9.58950967e-02f, 3.13161649e-02f, -1.69026852e-01f, -2.50933077e-02f, -1.16543829e-01f, -3.21330242e-02f, 1.73470780e-01f,
  -7.78411701e-02f, 9.86630097e-03f, 2.24008590e-01f, -1.54679403e-01f, 8.64767805e-02f, 3.69869582e-02f, 5.01588508e-02f, -3.33719589e-02f, 1.90923631e-01f, -3.74321528e-02f,
  -9.18587297e-02f, -6.01781183e-04f, 3.78195867e-02f, 6.87716082e-02f, -6.39069229e-02f, -1.06461115e-01f, -1.39136603e-02f, -4.33375239e-02f, -1.59490630e-02f, -1.21209487e-01f,
  6.27511293e-02f, -1.23311803e-01f, 3.87532488e-02f, -3.35473716e-02f, 5.50758727e-02f, -2.70450041e-02f, 7.94239808e-03f, -4.65372298e-03f, -1.30857527e-01f, -7.36587157e-04f,
  4.10696045e-02f, -6.49239821e-03f, -9.48608071e-02f, -1.00373421e-02f, -2.78650131e-02f, 2.93459315e-02f, -8.27547535e-02f, 1.01857046e-02f, -6.94208294e-02f, 9.97992326e-03f,
  1.04109347e-01f, 3.26217874e-03f, -2.07492560e-02f, -2.29991190e-02f, 1.04450390e-01f, 2.64440477e-02f, 1.56263132e-02f, -5.40206246e-02f, 8.78131017e-02f, 1.40991077e-01f,
  -5.35274372e-02f, -3.01918648e-02f, 9.87260230e-03f, -3.69995236e-02f, -1.19581282e-01f, 4.45110314e-02f, -7.63289928e-02f, -2.79493276e-02f, 4.05059420e-02f, -1.79434102e-02f,
  -5.42767406e-01f, -4.06229556e-01f, 1.09842852e-01f, -6.39840811e-02f, -4.93887141e-02f, -4.38864455e-02f, -1.23544624e-02f, 5.97645119e-02f, -2.05544174e-01f, 4.88926796e-03f,
  -2.63977796e-02f, 1.71861507e-03f, -9.70590040e-02f, 1.19363051e-02f, -9.48392134e-03f, 9.88425910e-02f, -5.54038361e-02f, -1.96869541e-02f, 3.75920236e-02f, -1.69789925e-01f,
  -5.38248047e-02f, -7.41136745e-02f, 1.26419263e-02f, 1.01467848e-01f, -2.62419544e-02f, -1.99231375e-02f, -3.12378127e-02f, -1.70910507e-02f, -8.18098783e-02f, -3.12852263e-02f,
  -2.13052318e-01f, 5.12295842e-01f, 1.94594502e-01f, -1.17616616e-02f, 1.29639298e-01f, 2.12301761e-01f, -2.57601473e-03f, 1.66689798e-01f, -9.84959230e-02f, -1.13041364e-01f,
  -3.24619293e-01f, 1.43741861e-01f, -1.09906413e-01f, -1.08497396e-01f, -3.46193194e-01f, -2.39930406e-01f, -1.69341922e-01f, -1.51742980e-01f, 5.00027239e-02f, -1.79786403e-02f,
  -1.94822848e-02f, -2.89177865e-01f, 3.22657116e-02f, 2.71923274e-01f, 2.35367209e-01f, 1.93284869e-01f, -2.41164133e-01f, 1.18971072e-01f, 2.07894351e-02f, 2.28545889e-02f,
  -1.37052253e-01f, -1.45589963e-01f, -7.02412948e-02f, -6.04893430e-04f, -8.47726874e-03f, -9.96758416e-03f, -1.49093047e-01f, -6.29583821e-02f, -6.49427697e-02f, -3.87926520e-05f,
  7.67586827e-02f, -3.04036401e-02f, -8.16490352e-02f, 1.18239038e-02f, 1.73423067e-02f, 5.24354458e-04f, 1.36786088e-01f, 7.79248625e-02f, 3.41834947e-02f, 1.78765163e-01f,
  4.98403981e-02f, 1.03167430e-01f, -4.55526114e-02f, -2.33573616e-02f, 1.50726708e-02f, 6.58285767e-02f, 5.47411814e-02f, 2.49876827e-02f, 7.68199340e-02f, 1.46269575e-01f,
  8.96092504e-02f, -1.38006166e-01f, 6.44450188e-02f, -1.37492970e-01f, -2.91266423e-02f, 4.14996669e-02f, -5.00016473e-02f, -4.49673943e-02f, -6.43595383e-02f, -6.53087944e-02f,
  3.26883756e-02f, -6.00338075e-03f, 2.92982366e-02f, -5.01331277e-02f, 3.94842215e-02f, -4.39752005e-02f, -4.15441915e-02f, -1.15774065e-01f, -5.66483065e-02f, 8.30207840e-02f,
  1.82800423e-02f, -6.77773356e-03f, -9.15547535e-02f, 1.12324702e-02f, -1.16849273e-01f, 3.65415849e-02f, -3.26197818e-02f, 7.02648982e-03f, -4.20560502e-02f, -6.47202060e-02f,
  -2.67062992e-01f, -2.12796211e-01f, -1.48241162e-01f, -1.32176152e-04f, -2.17826739e-02f, -1.41339943e-01f, -1.41560733e-02f, 2.68947072e-02f, -1.43653661e-01f, -9.93271619e-02f,
  3.74625400e-02f, 3.60715240e-02f, -2.47558840e-02f, 4.47553350e-03f, -3.67175005e-02f, -2.42178813e-02f, -2.10057512e-01f, -1.27449796e-01f, -2.23618299e-01f, 1.82076469e-02f,
  -4.42541614e-02f, -1.44774064e-01f, -3.94272357e-02f, -8.44841730e-03f, -3.81424949e-02f, 6.28849790e-02f, -9.54811200e-02f, 1.09462425e-01f, -6.36529028e-02f, -5.51676229e-02f,
  1.72910273e-01f, -3.82615961e-02f, -2.09663838e-01f, -1.26938671e-01f, 1.33286849e-01f, 1.10213406e-01f, -2.95351654e-01f, 1.60189405e-01f, -3.12480867e-01f, -3.33326049e-02f,
  2.76825368e-01f, -8.52250457e-02f, -1.38857320e-01f, 4.37153459e-01f, 3.04779708e-01f, 3.78780402e-02f, 2.91035742e-01f, 1.25835404e-01f, 5.45857437e-02f, 3.01977098e-01f,
  2.28673384e-01f, 4.44158673e-01f, 2.70456046e-01f, 4.40748692e-01f, 2.34592825e-01f, -7.13859573e-02f, 2.15536341e-01f, -8.75396729e-02f, 2.89561629e-01f, 1.50302589e-01f,
  1.40723422e-01f, 1.22023784e-01f, 1.07099578e-01f, 8.15419778e-02f, 1.98363617e-01f, 2.52195783e-02f, -2.89253574e-02f, -6.31375536e-02f, -1.00764915e-01f, -1.31204221e-02f,
  -7.10894242e-02f, 7.19307438e-02f, 3.86267379e-02f, 2.96317209e-02f, -4.20662612e-02f, -2.51011737e-02f, -4.39720564e-02f, -5.45033850e-02f, -1.09867111e-01f, 6.45532608e-02f,
  -1.11685030e-01f, -6.06650859e-02f, -5.45294471e-02f, -1.93854887e-02f, -4.67475504e-02f, -9.62475687e-03f, -2.13718459e-01f, -2.43303110e-03f, 6.12271354e-02f, 5.75294718e-02f,
  8.92610848e-02f, 5.35598770e-02f, -2.78962236e-02f, -3.34451832e-02f, 1.14805073e-01f, -1.17103579e-02f, -1.67569369e-02f, 2.49147099e-02f, -8.66125375e-02f, 9.22705531e-02f,
  5.59709920e-03f, 1.93525422e-02f, 6.36762083e-02f, -7.26762414e-02f, 7.91978016e-02f, -2.60268003e-02f, 4.73671481e-02f, 6.46594688e-02f, -4.37614545e-02f, 7.65944198e-02f,
  -4.00627479e-02f, 3.90252434e-02f, 3.26904505e-02f, -2.58425679e-02f, 1.10915400e-01f, -6.12004697e-02f, -2.08683982e-02f, 1.48239043e-02f, -4.67412472e-02f, 3.38681112e-03f,
  7.50211477e-02f, 2.38469213e-01f, 2.57220548e-02f, -6.08743541e-02f, 7.19944239e-02f, 7.30776042e-02f, 1.04793720e-01f, 9.28439721e-02f, 3.56629342e-02f, 1.19121388e-01f,
  7.82187507e-02f, 1.14181442e-02f, 7.41335452e-02f, -4.00632620e-02f, -8.74328241e-03f, 9.53461826e-02f, 3.14029045e-02f, -1.26246959e-01f, -2.20657187e-03f, 1.64431825e-01f,
  2.21477915e-02f, 1.03989087e-01f, -3.36377546e-02f, -1.42895833e-01f, 1.20158065e-02f, -4.98110279e-02f, 7.75369927e-02f, -7.73428455e-02f, 4.36636694e-02f, -2.07897238e-02f,
  -3.50660354e-01f, -4.34943438e-01f, -3.20894301e-01f, 2.46461816e-02f, 1.27135530e-01f, 1.56995609e-01f, -9.45201516e-02f, -1.56978801e-01f, -2.54754454e-01f, -6.55596256e-02f,
  1.15165643e-01f, -2.52949774e-01f, -1.88801095e-01f, 1.79104097e-02f, -1.21086776e-01f, -2.91528493e-01f, -1.74859203e-02f, 1.58884581e-02f, -1.12852298e-01f, -1.86481297e-01f,
  -1.16687253e-01f, 2.92895902e-02f, -1.15144856e-01f, 2.12719783e-01f, 1.01076560e-02f, 1.66937664e-01f, 2.68206000e-01f, 4.12686169e-02f, 4.01268274e-01f, 1.73482507e-01f,
  4.35666069e-02f, -1.46238253e-01f, -9.71718431e-02f, -1.52491648e-02f, 4.25163917e-02f, 1.01249091e-01f, 1.68089435e-01f, 2.47272360e-03f, -4.12747189e-02f, -8.96847397e-02f,
  1.74454242e-01f, 4.28769318e-03f, 9.97701846e-03f, -1.12122811e-01f, 3.50706242e-02f, 6.37665018e-02f, -2.04432607e-02f, -1.27573470e-02f, 1.11566009e-02f, -1.68415412e-01f,
  -1.59437507e-01f, -2.14056633e-02f, 4.34621461e-02f, 5.80243170e-02f, -7.76767880e-02f, -8.73968899e-02f, 1.90528817e-02f, 3.37019078e-02f, 2.09237188e-02f, -5.10311611e-02f,
  4.50228788e-02f, 5.77943996e-02f, -1.28466720e-02f, 9.66225658e-03f, -6.49750605e-02f, 7.78115019e-02f, 3.41044031e-02f, -7.59568140e-02f, -4.64428402e-02f, 6.50985986e-02f,
  6.42087236e-02f, -1.31140053e-01f, 5.14276549e-02f, 2.87281964e-02f, 2.48980764e-02f, -4.55012694e-02f, -8.91853124e-02f, 3.21621671e-02f, -4.12791260e-02f, 1.72997657e-02f,
  6.32572025e-02f, 5.15316837e-02f, 6.09636456e-02f, 1.16821028e-01f, 1.91716999e-02f, 7.71703152e-03f, 8.85203481e-02f, -1.43405888e-02f, -7.76475179e-04f, 1.35939077e-01f,
  1.51088327e-01f, 7.62011041e-04f, -7.94052482e-02f, 1.14036396e-01f, -9.49079357e-03f, -1.17007136e-01f, 3.16620953e-02f, 1.20187830e-02f, 2.27041934e-02f, -7.47371688e-02f,
  3.26371975e-02f, 2.98695061e-02f, 1.84623390e-01f, -2.85783713e-03f, 8.62101838e-02f, 3.04556694e-02f, 5.31898178e-02f, 1.78707108e-01f, 2.42730938e-02f, 1.16108932e-01f,
  5.95250651e-02f, 5.10534458e-02f, -1.68182626e-02f, 3.05069368e-02f, 7.32723176e-02f, 1.22178523e-02f, 9.15384591e-02f, -9.10232514e-02f, 2.77251936e-02f, 5.05000353e-02f,
  -6.38800144e-01f, 1.36738852e-01f, 4.36161131e-01f, -2.09648043e-01f, -2.89959550e-01f, 1.25978723e-01f, 3.80641192e-01f, -1.04844593e-01f, -1.73448727e-01f, 3.52241695e-01f,
  1.23412862e-01f, 3.78162749e-02f, 2.22074330e-01f, 2.94813454e-01f, -2.56503046e-01f, 3.28486502e-01f, 1.02854157e-02f, 1.84973925e-01f, -1.21291399e-01f, -3.13535154e-01f,
  -2.07299143e-01f, -2.28833348e-01f, 2.46138945e-01f, -2.05810428e-01f, -1.89500451e-02f, -2.22029500e-02f, -1.06813252e-01f, 5.93717396e-02f, 1.42998740e-01f, 8.24817419e-02f,
  -4.88199562e-01f, -3.24613839e-01f, -5.52459732e-02f, 5.64885885e-03f, -4.29888889e-02f, 2.58443616e-02f, 8.01675096e-02f, -1.65960640e-02f, -1.16540879e-01f, -7.37620220e-02f,
  6.91792443e-02f, -3.59042734e-02f, -7.45481923e-02f, 2.29818635e-02f, -2.11784076e-02f, -8.04363226e-05f, 4.59719636e-02f, 8.45862776e-02f, 3.70133645e-03f, 1.07289247e-01f,
  1.76450610e-01f, 1.08954012e-01f, 1.07021771e-01f, 5.81822060e-02f, 4.60817926e-02f, -9.14656185e-03f, 5.21502793e-02f, 3.71202193e-02f, -3.86798456e-02f, -1.24262996e-01f,
  2.07041465e-02f, -6.45662546e-02f, -4.36067171e-02f, -8.59968588e-02f, 4.63528745e-02f, 5.73576465e-02f, 1.67882128e-03f, -1.24859903e-02f, 1.16422169e-01f, -4.38684085e-03f,
  -3.60777676e-02f, 3.74143645e-02f, -1.59165516e-01f, 6.54362291e-02f, -1.23762740e-02f, 6.04485422e-02f, 4.06353176e-02f, -6.03490286e-02f, 8.12093262e-03f, 2.05256343e-02f,
  -3.00048408e-03f, 9.74137411e-02f, 4.63374257e-02f, -1.13997506e-02f, 3.72511074e-02f, 2.70547494e-02f, 1.98494410e-03f, 7.02901408e-02f, -4.09004837e-02f, -8.26359242e-02f,
  -5.93483508e-01f, -5.03332734e-01f, 1.62079670e-02f, -9.64641050e-02f, -7.45413154e-02f, -5.64378314e-02f, -5.94565086e-02f, -4.71219122e-02f, -1.42737895e-01f, 1.22274132e-03f,
  -3.53118032e-02f, 9.72267017e-02f, -7.62502924e-02f, 4.93288077e-02f, 8.09305310e-02f, -3.03810183e-02f, -6.44588843e-02f, -3.00028292e-03f, -1.23667367e-01f, -3.78346443e-02f,
  -3.77014689e-02f, -1.39425874e-01f, 2.62752734e-02f, 3.32116820e-02f, -1.57403778e-02f, -5.26459850e-02f, -2.40110084e-01f, 8.99612531e-02f, -6.83302283e-02f, 1.53080001e-01f,
  2.55852984e-03f, -2.54673481e-01f, 2.75248379e-01f, 4.75659728e-01f, 1.87688228e-02f, -5.47581196e-01f, -3.76712292e-01f, 1.33753806e-01f, 9.30890366e-02f, -3.81533861e-01f,
  -7.32524469e-02f, 2.40063407e-02f, -3.91721159e-01f, 2.32188851e-01f, 2.21221939e-01f, -3.68443757e-01f, 3.40890259e-01f, -3.84345353e-02f, 1.81907505e-01f, 1.38280302e-01f,
  2.62699187e-01f, 1.55898109e-01f, 3.40855420e-01f, 9.35999379e-02f, 6.89680949e-02f, 2.82883376e-01f, 3.26892585e-01f, 1.02293715e-01f, 2.72103488e-01f, -1.49708800e-02f,
  -1.80899948e-01f, 1.09657973e-01f, 1.54195592e-01f, -4.94701229e-02f, 1.18255980e-01f, -3.84881794e-02f, -8.53570700e-02f, -4.71837074e-02f, 2.48784691e-01f, -3.02900616e-02f,
  -7.88062438e-02f, 1.23207778e-01f, 7.07609206e-02f, -4.91459519e-02f, 2.11634692e-02f, 1.71764806e-01f, 2.09919456e-02f, -1.08110987e-01f, 1.34417307e-04f, -1.64507348e-02f,
  3.30030695e-02f, -8.13590959e-02f, 4.92094606e-02f, -5.58111891e-02f, 7.09932894e-02f, 4.01820987e-02f, 1.25965141e-02f, -3.46443541e-02f, -3.06192823e-02f, 1.96748137e-01f,
  -8.15609694e-02f, 6.30972087e-02f, 5.74010126e-02f, 5.94890937e-02f, 2.47595441e-02f, 4.50945944e-02f, 4.32749465e-02f, -9.57183465e-02f, 4.71768901e-02f, -5.59899025e-02f,
  1.08808555e-01f, 1.00755766e-02f, -2.21946221e-02f, -1.66484830e-03f, 4.88485992e-02f, 3.71641479e-02f, 1.25018526e-02f, -6.69746250e-02f, 1.75999478e-02f, 1.49137452e-02f,
  5.65787591e-03f, -9.37345028e-02f, 5.20735383e-02f, 1.41960485e-02f, -9.81371999e-02f, -1.91681422e-02f, -1.00603998e-01f, 1.11103468e-02f, -1.26630636e-02f, 8.82070810e-02f,
  -2.23932460e-01f, 8.96732658e-02f, 7.48489946e-02f, -1.07596718e-01f, 3.22501659e-02f, 3.17207649e-02f, 1.79859214e-02f, -7.47712478e-02f, -4.18047048e-02f, -5.39921038e-02f,
  -1.08701615e-02f, -6.57798315e-04f, -7.25926086e-02f, -6.80176169e-02f, 9.02720168e-02f, -9.12049226e-03f, -3.68186869e-02f, -1.64526887e-02f, 6.43869787e-02f, 7.83058107e-02f,
  7.24271461e-02f, -1.21498935e-01f, 9.50940847e-02f, 6.93966374e-02f, -9.21101347e-02f, 1.08010694e-02f, -1.71498526e-02f, 9.33992863e-02f, 8.42301548e-02f, -1.76247042e-02f,
  -6.15940802e-02f, -4.53192204e-01f, 2.45616838e-01f, 4.43696566e-02f, 3.48838031e-01f, 2.65151411e-01f, 1.40937522e-01f, 6.87319189e-02f, -8.09983984e-02f, -3.20717782e-01f,
  -1.93631411e-01f, -2.57116765e-01f, -5.66566177e-02f, -6.41518682e-02f, 3.24503183e-01f, 9.96893495e-02f, 4.78614345e-02f, -1.34849429e-01f, 2.80906260e-01f, 7.06330612e-02f,
  1.46168604e-01f, 5.30699035e-03f, 3.07232350e-01f, 1.21047080e-01f, 1.42579108e-01f, 5.25071332e-03f, -1.81022301e-01f, 2.37273365e-01f, -1.28869683e-01f, 3.42233479e-02f,
  -9.05903131e-02f, -1.62687302e-01f, 2.20954977e-02f, -8.94214138e-02f, -5.45890294e-02f, -1.00757591e-01f, -6.00634441e-02f, 5.88738658e-02f, 1.20537147e-01f, 1.45469643e-02f,
  -6.40044138e-02f, 7.44727999e-02f, 4.98871598e-03f, 4.22602631e-02f, 6.26078621e-02f, 4.48337756e-02f, 9.13844109e-02f, 1.25206411e-01f, 1.16364874e-01f, 8.79947096e-02f,
  2.93849166e-02f, -5.74438199e-02f, 6.72883466e-02f, -8.42750892e-02f, 8.47122446e-02f, -6.06494769e-02f, 6.18219227e-02f, 3.35149886e-03f, 3.37739401e-02f, -1.44908736e-02f,
  1.43796839e-02f, -4.66768667e-02f, -3.53646241e-02f, -4.18902002e-02f, -4.49984781e-02f, -8.73118266e-02f, 9.99179482e-03f, -3.21170054e-02f, -4.39415313e-03f, -3.80140170e-02f,
  -6.69524670e-02f, -6.88164681e-02f, 1.27279893e-01f, 3.34375240e-02f, -1.33771181e-01f, -7.21873194e-02f, 9.10544116e-03f, 7.40753934e-02f, 2.30772216e-02f, 7.18846545e-02f,
  -5.37895374e-02f, 7.33205006e-02f, -1.96985975e-02f, 3.72505449e-02f, -5.15588224e-02f, -1.39581813e-02f, 2.01633945e-02f, 5.42480648e-02f, -1.55421328e-02f, -1.09817693e-02f,
  -4.67963189e-01f, -3.11346918e-01f, -7.41382241e-02f, -6.55744076e-02f, -6.66754767e-02f, -1.88170057e-02f, 5.34949712e-02f, -3.87944393e-02f, -7.86085650e-02f, 6.34179190e-02f,
  -1.75568834e-03f, 6.22880347e-02f, -8.25343188e-03f, 6.90417513e-02f, -4.88307774e-02f, -6.66691959e-02f, -1.20910130e-01f, -7.50170946e-02f, -1.61769286e-01f, -9.08308253e-02f,
  5.24371527e-02f, -5.75203123e-03f, -3.91793698e-02f, 1.47225097e-01f, 7.12281615e-02f, -4.65023220e-02f, -1.18079975e-01f, -7.98665509e-02f, 3.62715013e-02f, -7.74166882e-02f,
  -2.52702504e-01f, 2.14700490e-01f, 2.11259291e-01f, -3.59153390e-01f, -6.96984679e-02f, 4.11323220e-01f, -1.41607895e-01f, 5.59719130e-02f, -1.72858998e-01f, -2.72505358e-02f,
  -1.08018644e-01f, -1.99285775e-01f, 1.42927140e-01f, -8.51725638e-02f, 3.91025066e-01f, 2.09232166e-01f, -4.85921130e-02f, -3.86516154e-02f, -1.24389298e-01f, -2.68141478e-01f,
  -1.01477161e-01f, -1.98494136e-01f, 1.22742087e-01f, -1.96617424e-01f, -1.13422386e-01f, -2.03622475e-01f, -1.01226449e-01f, -1.91548511e-01f, -1.28657892e-01f, 7.85186440e-02f,
  8.55582952e-02f, -1.71409011e-01f, 1.77792758e-02f, 1.05332710e-01f, 1.35607338e-02f, -7.83531442e-02f, -4.80656289e-02f, 1.13855906e-01f, -9.50212479e-02f, -9.42260846e-02f,
  -9.93231460e-02f, 9.87041444e-02f, -9.06429589e-02f, -3.94184850e-02f, -1.92232594e-01f, -1.49310436e-02f, 1.29555643e-01f, -1.39201693e-02f, -3.35080884e-02f, 2.51987994e-01f,
  6.96814759e-03f, 5.72479293e-02f, -1.62813775e-02f, 1.02375820e-01f, -8.67407024e-03f, -7.10082427e-02f, 7.91087970e-02f, 5.70006259e-02f, -6.50657639e-02f, -2.18110457e-02f,
  -6.00803904e-02f, 5.18669039e-02f, 7.26308376e-02f, 3.41377631e-02f, -1.39755141e-02f, -3.41871642e-02f, -3.66259478e-02f, 1.13941245e-01f, -5.03889984e-03f, 3.24915014e-02f,
  -1.15769722e-01f, 4.24660966e-02f, -1.23517461e-01f, 4.81404327e-02f, -6.87685832e-02f, -1.97455212e-02f, -1.17179016e-02f, -1.42805070e-01f, -3.51131335e-02f, 1.19083211e-01f,
  -2.98328381e-02f, -7.85287544e-02f, 5.08239679e-03f, -8.77430663e-02f, 7.70522654e-02f, -4.72905859e-02f, 1.96513459e-02f, 1.08347736e-01f, 9.14981067e-02f, 3.96487974e-02f,
  5.25886603e-02f, -1.94191903e-01f, -8.04418698e-02f, -7.23200142e-02f, 6.41508922e-02f, -1.86391193e-02f, -1.28272966e-01f, 7.85352960e-02f, -1.70489624e-02f, -1.19717643e-01f,
  -9.68973432e-03f, 2.52186619e-02f, 5.38230687e-02f, -8.89554098e-02f, 4.52792868e-02f, 8.74192491e-02f, -9.28737782e-03f, -1.01503119e-01f, 4.74717692e-02f, -5.03970757e-02f,
  -7.75566474e-02f, -1.88571922e-02f, 3.14361341e-02f, -8.49601999e-02f, -1.13790601e-01f, -7.40419999e-02f, 1.71408728e-02f, -1.15566188e-02f, 1.21369842e-03f, -2.87146699e-02f,
  -4.46353145e-02f, -2.85338998e-01f, -6.23414218e-02f, 2.53304299e-02f, 1.33030578e-01f, 3.35370749e-01f, 4.16209519e-01f, -8.82112533e-02f, -6.92350566e-02f, -7.73652792e-02f,
  2.86325008e-01f, -1.63224917e-02f, 3.38806689e-01f, 2.20919371e-01f, 2.67125279e-01f, 2.47448489e-01f, 1.63576528e-01f, 6.65639490e-02f, -1.86097145e-01f, -1.56010672e-01f,
  -9.17134136e-02f, 9.79005769e-02f, 2.62890369e-01f, -4.09692645e-01f, 2.09845342e-02f, -3.01842391e-01f, -7.29999563e-04f, -4.93734889e-02f, -7.81273171e-02f, 1.55974358e-01f,
  -9.62335914e-02f, -3.08497220e-01f, 1.36034964e-02f, -7.00098649e-02f, -3.93498689e-02f, -9.05216858e-02f, 6.42083064e-02f, 1.02996349e-01f, -1.42245833e-02f, 2.42289323e-02f,
  2.95100082e-02f, -1.71298549e-01f, -1.18058123e-01f, 2.31728740e-02f, -5.10208346e-02f, -1.29235581e-01f, 4.96952655e-03f, -2.82489937e-02f, -2.62267124e-02f, 1.00459578e-02f,
  8.82413760e-02f, 5.29798567e-02f, -2.07232144e-02f, -4.22770455e-02f, 4.07862626e-02f, -1.87871198e-03f, 1.00464271e-02f, 5.55529147e-02f, 1.24097522e-03f, -5.10681011e-02f,
  1.02679484e-01f, -2.96294456e-03f, 5.08034714e-02f, -1.08000889e-01f, -7.21866963e-03f, 4.21067514e-02f, -3.38198952e-02f, 7.50179663e-02f, 1.23992069e-02f, 1.10586889e-01f,
  -2.61068139e-02f, -6.40738532e-02f, -8.73852670e-02f, 2.44254731e-02f, -1.26676094e-02f, -2.60244161e-02f, 7.93572329e-03f, -1.21866159e-01f, -6.80290237e-02f, 6.86118379e-02f,
  9.06720292e-03f, -6.93237707e-02f, 8.80434588e-02f, 5.10425270e-02f, -5.55890426e-02f, 1.49735451e-01f, -9.25183296e-03f, 5.52651249e-02f, -5.75273708e-02f, 1.94923747e-02f,
  -2.61487961e-01f, -3.54465753e-01f, -5.14554381e-02f, 3.03155966e-02f, -1.12648763e-01f, -1.22563310e-01f, -8.96192417e-02f, -9.99252871e-02f, -4.29357998e-02f, 8.83727446e-02f,
  -1.09378092e-01f, -4.98361373e-03f, -7.48158768e-02f, -3.91168110e-02f, -7.34288758e-03f, 8.12615380e-02f, 7.39724785e-02f, -2.34061517e-02f, 3.27080227e-02f, -4.96023335e-02f,
  3.93503793e-02f, -1.05922833e-01f, -5.69405332e-02f, 3.75025868e-02f, -1.20205596e-01f, 1.19445384e-01f, -7.45492131e-02f, -2.40701959e-02f, 3.44894156e-02f, -6.47736341e-02f,
  -6.33806705e-01f, 4.26735580e-01f, -4.22531068e-02f, -1.56253055e-02f, -1.69876758e-02f, 1.70305520e-01f, 1.39194414e-01f, -1.61784440e-01f, -6.13098517e-02f, 1.67990983e-01f,
  6.10247180e-02f, -1.54694021e-01f, -2.48467806e-03f, 2.09150955e-01f, -3.32391351e-01f, 1.38695404e-01f, 2.99938053e-01f, 1.12102821e-01f, 6.19522948e-03f, -1.77412122e-01f,
  8.22360511e-04f, 1.26531363e-01f, -1.48318922e-02f, 1.88024327e-01f, -1.74188912e-01f, -1.63338304e-01f, -4.84450795e-02f, -4.29366194e-02f, 2.16683179e-01f, -3.65360230e-02f,
  -2.75173128e-01f, -4.24660623e-01f, -2.52271593e-01f, -6.76487833e-02f, -1.13574438e-01f, 3.09717096e-02f, -3.20533030e-02f, -2.53808888e-04f, -1.25799268e-01f, 7.67720267e-02f,
  -5.12140989e-02f, -3.28893997e-02f, 4.97962162e-02f, 5.62646948e-02f, -5.50822094e-02f, -1.09551787e-01f, -2.68172286e-02f, 2.76674777e-02f, -1.20844387e-01f, -7.95149133e-02f,
  -9.92670730e-02f, -2.61479747e-02f, 1.10015102e-01f, 2.60764863e-02f, -5.31754419e-02f, 1.08730800e-01f, 1.78174768e-02f, 1.09151471e-02f, 9.58113149e-02f, 3.63079756e-02f,
  8.07223171e-02f, -1.65374931e-02f, 2.48195715e-02f, 3.97271365e-02f, 2.23213602e-02f, 8.28366652e-02f, 3.49613987e-02f, 7.86151588e-02f, -1.11881122e-02f, -4.39084880e-03f,
  1.83516853e-02f, 7.54591003e-02f, 1.43167761e-03f, 9.77796018e-02f, 4.70188111e-02f, 7.74511248e-02f, -9.78843123e-02f, -9.15684700e-02f, -3.13983150e-02f, 3.05978991e-02f,
  -1.06322423e-01f, -7.51834810e-02f, 6.05551973e-02f, 2.30945162e-02f, 4.45338115e-02f, -5.27126854e-03f, 3.11671998e-02f, -1.69463432e-03f, 2.87716482e-02f, -8.36615115e-02f,
  -1.40101478e-01f, -2.77687073e-01f, -2.21135885e-01f, -5.40759265e-02f, 9.50432196e-02f, -3.85698937e-02f, -1.62956920e-02f, -4.70144637e-02f, -4.68308516e-02f, 2.05616858e-02f,
  -9.78074819e-02f, 8.88133701e-03f, 1.85195766e-02f, -3.68885063e-02f, -6.58492604e-03f, 1.41099170e-02f, -5.62452264e-02f, -8.13499615e-02f, -6.81400672e-02f, -6.93617612e-02f,
  -2.02704355e-01f, -1.47224916e-02f, 2.34960150e-02f, -1.07717752e-01f, 5.75345531e-02f, -1.99387893e-02f, -1.19026400e-01f, -2.69855391e-02f, -1.23723678e-01f, 5.66058680e-02f,
  -3.99387747e-01f, 1.20863482e-01f, -3.93163204e-01f, -1.74471781e-01f, -6.05187938e-02f, -1.78275928e-01f, -1.10124484e-01f, -1.42252550e-01f, -9.34565291e-02f, 3.64782244e-01f,
  2.38691539e-01f, -2.57999837e-01f, 3.36816609e-01f, -1.77720100e-01f, -3.84481847e-01f, 5.89620806e-02f, -1.86451480e-01f, -1.43547475e-01f, -3.39743383e-02f, -1.80194065e-01f,
  -2.36463398e-01f, -1.40332669e-01f, -2.57479846e-01f, 1.15815692e-01f, -2.87350982e-01f, -4.94466126e-02f, 2.84180492e-01f, -7.86207430e-03f, -2.11218894e-01f, -9.95312184e-02f,
  -2.25208923e-01f, -1.91841587e-01f, -7.27745369e-02f, -1.85649633e-01f, -6.73931390e-02f, 7.18351528e-02f, -6.03311416e-03f, -1.12149110e-02f, -2.05464121e-02f, -5.93854897e-02f,
  3.89404222e-02f, -8.21461454e-02f, -9.24236998e-02f, 4.36191112e-02f, -7.96297863e-02f, -1.26440778e-01f, -1.12209886e-01f, -5.95713072e-02f, -7.26237148e-02f, -1.58379048e-01f,
  -2.27133900e-01f, -5.92393279e-02f, -1.17829137e-01f, 6.25066534e-02f, -8.55780989e-02f, -9.21209008e-02f, -3.67336944e-02f, 3.28294635e-02f, -5.58050089e-02f, -4.10196744e-02f,
  -8.83469954e-02f, 8.00106227e-02f, -9.18787792e-02f, -8.50270018e-02f, 7.06590638e-02f, -2.40659490e-02f, -3.32273468e-02f, 1.20261423e-01f, 2.62516295e-03f, -5.97210266e-02f,
  7.13065639e-03f, 3.41414995e-02f, 3.48520726e-02f, -1.23451194e-02f, -2.17613522e-02f, 6.53416943e-03f, -1.72471832e-02f, -7.00833127e-02f, 4.57650633e-04f, -6.79606795e-02f,
  2.24159216e-03f, -9.94307473e-02f, -2.38325372e-02f, 1.00685336e-01f, 2.09955461e-02f, -2.82233767e-02f, 1.28233761e-01f, -6.13876199e-03f, -1.82056352e-02f, -1.85684375e-02f,
  -2.87529260e-01f, -7.54766911e-02f, 2.26092543e-02f, -8.71964321e-02f, -5.41405194e-02f, 4.57831472e-02f, 7.90136531e-02f, -1.01291873e-02f, -2.59705298e-02f, 4.07908252e-03f,
  3.14509566e-03f, -5.40837236e-02f, -1.06640738e-02f, 1.28305748e-01f, 2.45357007e-02f, -7.57453293e-02f, -5.36799394e-02f, 4.61006910e-02f, -3.56027447e-02f, -4.59386893e-02f,
  1.36564886e-02f, 3.49102058e-02f, -3.20600905e-02f, -2.44454443e-02f, 4.72679213e-02f, 2.04935521e-02f, -1.42369745e-03f, -3.94223183e-02f, -3.94250862e-02f, 1.22641660e-02f,
  -3.75479192e-01f, 2.19942629e-01f, 4.74790186e-01f, 1.16359323e-01f, -1.42290488e-01f, 4.08885151e-01f, 4.71863031e-01f, -1.77710712e-01f, 1.76247790e-01f, 2.85312422e-02f,
  -8.98480192e-02f, 1.74324363e-01f, 2.61129677e-01f, 7.58867785e-02f, 2.76383281e-01f, 2.67598033e-01f, 1.60114273e-01f, 1.34394899e-01f, 1.05797082e-01f, -2.76037991e-01f,
  -1.74162343e-01f, -2.66773134e-01f, 7.11054057e-02f, -1.59245908e-01f, -1.09254479e-01f, -9.84780192e-02f, -1.09788127e-01f, 2.03244507e-01f, -1.89539880e-01f, 1.98227659e-01f,
  -2.10573599e-01f, -2.55752623e-01f, -3.02605867e-01f, -1.18623160e-01f, -1.21984258e-01f, -2.99193989e-02f, 6.42367527e-02f, 4.40941490e-02f, 8.31619352e-02f, 5.53455018e-02f,
  7.01138377e-02f, -4.29718643e-02f, -1.44186124e-01f, 5.85966073e-02f, 6.27019256e-02f, -1.11052349e-01f, -6.17114268e-03f, -1.61105350e-01f, -6.63064793e-02f, -9.59568396e-02f,
  -2.40752921e-02f, -1.40763447e-01f, -3.03224754e-02f, 3.20155360e-02f, 6.05326891e-02f, -8.19014013e-02f, 1.25369847e-01f, 1.16670705e-01f, 9.93545447e-03f, -3.47533077e-02f,
  9.20349881e-02f, 1.03276685e-01f, -8.97287857e-03f, 6.91819265e-02f, -2.42657978e-02f, -8.58312845e-02f, 1.89704690e-02f, -5.38565479e-02f, -4.93753143e-02f, -1.69958487e-01f,
  -2.11645253e-02f, -4.05268446e-02f, -1.53252065e-01f, 1.63615942e-02f, -5.40208369e-02f, -5.27508706e-02f, 9.36186686e-02f, 5.64926937e-02f, -3.02201696e-02f, -1.78642586e-01f,
  1.31005213e-01f, 8.78371075e-02f, -2.61038746e-04f, -2.54898779e-02f, -7.06292631e-04f, -2.55614929e-02f, 1.05501805e-02f, 3.63819003e-02f, -1.25204176e-01f, 5.76250814e-02f,
  2.80566812e-01f, 1.98714167e-01f, -2.75297947e-02f, -1.21783614e-01f, 9.09515694e-02f, 1.38710458e-02f, 1.20304348e-02f, -1.08123228e-01f, 1.16842955e-01f, -1.23694219e-01f,
  -6.00468665e-02f, 1.22585315e-02f, -4.74751666e-02f, 1.51418643e-02f, 9.26442742e-02f, 3.21557326e-03f, 7.35015422e-02f, -2.13974304e-02f, 2.88658962e-02f, -8.70793462e-02f,
  -2.40141168e-01f, -2.02458501e-02f, -2.83637550e-02f, -1.26560122e-01f, -1.49863660e-02f, -9.49726030e-02f, -8.44434649e-02f, -6.69735074e-02f, 6.65823231e-03f, -3.37066986e-02f,
  -2.77653456e-01f, 3.71119648e-01f, 3.50149661e-01f, -1.75426453e-01f, 3.21866900e-01f, -1.45791352e-01f, -2.06360333e-02f, 1.78995922e-01f, 8.41543898e-02f, -1.15194015e-01f,
  -9.02218297e-02f, 9.45890844e-02f, 1.06200390e-01f, -8.55909884e-02f, -3.41073304e-01f, -1.50768459e-01f, -3.00810605e-01f, -2.07882941e-01f, 1.35356039e-01f, -2.22978275e-02f,
  -1.75337598e-01f, -2.26903960e-01f, -3.39153409e-02f, 2.76012838e-01f, 1.37765616e-01f, 2.14471221e-01f, -2.84813851e-01f, 1.45619050e-01f, -1.39992431e-01f, -5.92056103e-03f,
  -9.65698063e-02f, -2.55587790e-02f, 1.52952954e-01f, 1.80618186e-02f, -7.22310990e-02f, -9.73326340e-02f, -1.67297110e-01f, 4.63575907e-02f, -1.26750534e-02f, 1.27086967e-01f,
  7.38239735e-02f, -8.22795853e-02f, 6.94172308e-02f, 1.17524460e-01f, 1.16727769e-01f, 1.28353417e-01f, 2.08347619e-01f, 1.09938234e-01f, 1.14239737e-01f, 3.70346308e-02f,
  7.05824941e-02f, 2.31749248e-02f, -8.12704116e-03f, -3.39418463e-02f, 5.42551726e-02f, 1.93006303e-02f, 1.98654905e-02f, -5.12927286e-02f, -6.44134134e-02f, -7.91572779e-03f,
  -5.27081378e-02f, -2.69954279e-02f, 1.35415703e-01f, 8.58262852e-02f, 4.76336703e-02f, 8.29066411e-02f, 7.43381754e-02f, 1.69529468e-02f, 4.97154631e-02f, -4.51946259e-02f,
  -8.15736800e-02f, 6.84500635e-02f, -3.48214582e-02f, 4.16952968e-02f, -8.95892382e-02f, -4.47230064e-04f, -2.00640857e-02f, -2.12373063e-02f, -2.24253628e-02f, -6.93586096e-02f,
  -6.52715936e-02f, -1.34569749e-01f, 8.55729133e-02f, 4.88811694e-02f, 2.18521673e-02f, -4.79488224e-02f, 2.60199234e-02f, 9.48213488e-02f, -4.89309728e-02f, -1.27490237e-01f,
  -3.19036067e-01f, -4.45397764e-01f, -1.05609317e-04f, 2.75315363e-02f, -3.87808643e-02f, -6.27103597e-02f, 5.79130277e-02f, 1.10020116e-01f, -6.09806813e-02f, -3.79480831e-02f,
  7.53514003e-03f, -7.52192587e-02f, -1.63257942e-01f, -8.41380730e-02f, -1.34823084e-01f, 1.80403758e-02f, 6.86692132e-04f, -8.02796558e-02f, -1.04360856e-01f, -1.05339818e-01f,
  -8.98962170e-02f, -3.34863104e-02f, 3.95257659e-02f, 4.64225747e-02f, -4.78838459e-02f, -7.95135051e-02f, -4.51404154e-02f, 2.79647633e-02f, -1.86534617e-02f, -3.91262621e-02f,
  4.06660050e-01f, -4.66874421e-01f, -1.54139623e-01f, 4.15910780e-01f, 2.72659242e-01f, -6.63903952e-02f, -1.01098955e-01f, 5.97673142e-03f, 2.23095059e-01f, -3.35530818e-01f,
  -2.79856119e-02f, -1.71041355e-01f, -4.25531447e-01f, 1.49900332e-01f, 2.30202720e-01f, -1.56283498e-01f, 8.13967083e-03f, 5.37493750e-02f, 1.25369772e-01f, -1.44372359e-01f,
  2.86154836e-01f, 1.27586961e-01f, -5.17724007e-02f, -2.66360734e-02f, -3.57525470e-03f, 9.56100076e-02f, -1.20621193e-02f, -1.65712357e-01f, 6.79499879e-02f, 8.92009288e-02f,
  -1.91083521e-01f, 1.58141449e-01f, -9.14272740e-02f, -3.58989052e-02f, -6.41796887e-02f, 8.31834041e-03f, 1.61601007e-02f, -6.12788908e-02f, 6.93870783e-02f, 3.51526402e-02f,
  -1.34203926e-01f, 7.25562200e-02f, 1.00527979e-01f, -1.11337833e-03f, 1.35729229e-02f, 9.33760777e-02f, 1.04572557e-01f, -7.46930093e-02f, -6.46906793e-02f, -5.53471036e-02f,
  -1.07727699e-01f, 2.32156329e-02f, 6.21130653e-02f, -3.36022838e-03f, -6.26127841e-03f, 4.25095484e-02f, 7.97739327e-02f, -4.73827012e-02f, -1.00724310e-01f, 5.27015775e-02f,
  2.40370184e-02f, -9.21135172e-02f, 3.10428869e-02f, 2.25771684e-02f, 4.49735933e-04f, 3.92534472e-02f, -2.26163995e-02f, 6.02118894e-02f, -3.12914066e-02f, -1.06657162e-01f,
  3.37638855e-02f, -3.50549556e-02f, 4.38150801e-02f, 1.98444743e-02f, -3.36721838e-02f, 9.78996977e-02f, 7.64710903e-02f, 4.78683524e-02f, 6.71692342e-02f, 1.76140703e-02f,
  -3.77570093e-02f, 2.61266399e-02f, -1.28193974e-01f, 7.85300955e-02f, -1.43156648e-01f, -1.00650758e-01f, 2.22198647e-02f, 6.12288043e-02f, 1.97360758e-03f, 6.31342549e-03f,
  -6.28199697e-01f, -5.39200723e-01f, -9.56300125e-02f, -4.32597697e-02f, -1.23209178e-01f, -9.30543244e-02f, -7.04578077e-03f, 1.12709373e-01f, -1.94040045e-01f, 6.89254105e-02f,
  -1.69864558e-02f, 5.90920486e-02f, 7.86827207e-02f, 1.56272471e-01f, -2.73097530e-02f, -2.32129861e-02f, -8.27074647e-02f, -1.21700857e-02f, -4.27222624e-02f, -1.19852096e-01f,
  -4.11613025e-02f, 3.85982692e-02f, -3.16885835e-03f, 9.10077766e-02f, 5.85762262e-02f, 5.09559959e-02f, 4.52975817e-02f, 4.04983424e-02f, 7.48508424e-02f, -5.87810129e-02f,
  -4.73249286e-01f, 1.95635110e-01f, 9.88110900e-02f, -3.39071184e-01f, 3.63419652e-02f, 3.43802512e-01f, -3.92657984e-03f, 1.00905173e-01f, -3.04931402e-01f, 3.29658926e-01f,
  6.29085749e-02f, -2.11795881e-01f, 6.57076910e-02f, -1.36234537e-01f, -3.26453567e-01f, -1.10344216e-01f, 6.62523061e-02f, -1.01689650e-02f, -2.09125161e-01f, 4.51511964e-02f,
  -1.57278731e-01f, -3.15810949e-01f, 5.28123043e-02f, 3.75197716e-02f, 3.87142636e-02f, 1.48352668e-01f, 7.92002007e-02f, 1.29875705e-01f, 1.36611640e-01f, -7.21337944e-02f,
  -4.27209735e-02f, -1.17368057e-01f, 7.58045241e-02f, 9.38596278e-02f, 1.18283197e-01f, 1.71025202e-01f, 1.25058189e-01f, -1.25545368e-01f, -1.80206567e-01f, 1.13699818e-02f,
  -1.93014313e-02f, -6.06902055e-02f, -9.40406919e-02f, -5.94165884e-02f, 5.29545099e-02f, -8.72811396e-03f, 7.18717203e-02f, 1.10445470e-01f, -4.69755717e-02f, 2.73507945e-02f,
  6.03816956e-02f, 4.47438136e-02f, 1.45040631e-01f, -3.82954744e-03f, 4.14462946e-02f, 6.23847209e-02f, 8.49571526e-02f, 1.97298661e-01f, 2.87230010e-04f, 5.76782860e-02f,
  4.90637273e-02f, 3.51276435e-02f, -1.06893189e-01f, -3.21759619e-02f, -9.53868404e-02f, 3.85033973e-02f, -1.26394182e-01f, 2.75675412e-02f, 6.79355934e-02f, 2.03857999e-02f,
  5.16152680e-02f, -3.57836038e-02f, -3.84131223e-02f, 3.04005817e-02f, -3.36435437e-02f, -8.20484608e-02f, -3.02961357e-02f, -5.35981096e-02f, 3.13572288e-02f, 4.71654013e-02f,
  -9.34275985e-02f, 1.16170600e-01f, 8.63061249e-02f, -1.13540394e-02f, -5.54563664e-02f, 7.24268109e-02f, 9.61059853e-02f, 7.83741027e-02f, 3.40871178e-02f, -9.46542323e-02f,
  7.29479715e-02f, -9.65727195e-02f, -1.09069839e-01f, -2.84350235e-02f, -2.82669673e-03f, 7.29259104e-02f, 8.53867549e-03f, 3.04791657e-03f, 2.48722006e-02f, -1.45311490e-01f,
  1.10874310e-01f, 1.64233372e-01f, 3.50796292e-03f, -8.91508833e-02f, 2.37165876e-02f, 1.13272958e-01f, -1.02794608e-02f, -1.06077217e-01f, -2.53776088e-02f, 5.42842411e-03f,
  -1.07346158e-02f, -1.20042518e-01f, 1.71934329e-02f, -5.10850400e-02f, -1.38670076e-02f, -2.86867600e-02f, -1.07223645e-01f, 1.33426832e-02f, 5.23846447e-02f, 1.77883077e-02f,
  -3.96586746e-01f, 2.69618094e-01f, 3.90196323e-01f, -2.02738151e-01f, -1.33729622e-01f, -2.78098956e-02f, -3.32268775e-01f, 3.72821122e-01f, -2.84736514e-01f, 5.08645028e-02f,
  1.41933247e-01f, -1.89142883e-01f, 2.58873433e-01f, -2.19195876e-02f, -4.27178703e-02f, -9.17963907e-02f, -8.70486200e-02f, 7.80921383e-03f, -5.37109487e-02f, 3.10612589e-01f,
  1.71375602e-01f, -2.35053841e-02f, 3.30283880e-01f, 1.87004432e-01f, 9.10587311e-02f, 1.73834369e-01f, 1.49056733e-01f, 2.38838464e-01f, 2.20281988e-01f, -7.64772370e-02f,
  -2.72481479e-02f, 1.64069697e-01f, 1.60102114e-01f, -5.01429066e-02f, 1.06855944e-01f, 1.01692788e-01f, 4.35722396e-02f, -1.79674942e-02f, -2.77332552e-02f, 4.38103899e-02f,
  -2.56507415e-02f, 3.97987142e-02f, 8.01228266e-03f, 1.75184067e-02f, -3.88869038e-03f, 6.50949851e-02f, 9.44524854e-02f, 5.72790429e-02f, -2.46706568e-02f, 7.91626647e-02f,
  1.62138551e-01f, -8.56396835e-03f, -9.95664508e-04f, -1.43415025e-02f, 6.79899976e-02f, -4.32427339e-02f, 3.90549637e-02f, 1.31086439e-01f, -3.51402648e-02f, 1.31981419e-02f,
  2.53246129e-02f, -1.17231227e-01f, -1.04813308e-01f, 4.31390759e-03f, -1.79738104e-02f, 1.32044768e-02f, -1.28300548e-01f, -4.52176258e-02f, -2.49940716e-02f, -1.60765497e-03f,
  4.71386202e-02f, 8.73329416e-02f, -3.84964459e-02f, -4.66294698e-02f, 2.97077522e-02f, -8.19729716e-02f, 6.69662058e-02f, 9.14870352e-02f, 1.55130133e-01f, 2.26108190e-02f,
  -4.66482267e-02f, 2.53155436e-02f, -6.13822192e-02f, 3.10522988e-02f, -1.29812703e-01f, 8.83483812e-02f, -2.40789894e-02f, 1.67584382e-02f, 1.08763926e-01f, 8.97458196e-03f,
  1.77783802e-01f, 2.64325440e-01f, 3.94798368e-02f, -1.27127573e-01f, 1.12210363e-01f, 8.31411332e-02f, -1.12493970e-01f, 2.99917217e-02f, 8.63604471e-02f, 1.09682508e-01f,
  1.67567506e-01f, -1.67934448e-02f, 6.24091774e-02f, 2.25020014e-03f, 2.26737466e-02f, 1.55131906e-01f, -4.59894128e-02f, -4.17433642e-02f, 1.53837621e-01f, 1.43238083e-01f,
  1.55228093e-01f, 6.76765526e-03f, 1.70140732e-02f, -1.39639631e-01f, -2.67081261e-02f, 7.10355490e-02f, 1.62096415e-02f, 5.53469025e-02f, 6.22793473e-02f, 5.66959418e-02f,
  -6.09815240e-01f, 4.08066452e-01f, -2.07768921e-02f, 7.73642957e-02f, -3.37092057e-02f, 5.24653375e-01f, 4.61638980e-02f, -2.62655858e-02f, -1.89573616e-01f, 2.38593534e-01f,
  -2.44423689e-04f, -2.47071251e-01f, -1.28994212e-01f, 4.22078788e-01f, 2.52080709e-01f, 4.11751181e-01f, 3.89974982e-01f, 1.85991245e-04f, 1.20894969e-01f, -3.25627923e-02f,
  1.28444612e-01f, 1.52337566e-01f, 2.46788859e-01f, 2.02501521e-01f, -1.34546220e-01f, -1.81060899e-02f, 6.87960461e-02f, -3.49570066e-02f, 2.50293821e-01f, 1.40001848e-01f,
  -3.45747560e-01f, -4.49186563e-01f, -2.74843276e-01f, -9.16236341e-02f, -4.49527316e-02f, -2.28125840e-01f, -4.12256755e-02f, -5.61402254e-02f, -5.01598381e-02f, 9.50888451e-03f,
  -1.68489620e-01f, -2.29194798e-02f, 2.50547542e-03f, -9.21664387e-02f, 6.78820489e-03f, 2.96740253e-02f, 4.14413027e-02f, 6.77228644e-02f, 3.60033177e-02f, 6.42776191e-02f,
  5.11501655e-02f, 1.57627329e-01f, 5.65711558e-02f, 9.12816748e-02f, 7.40610342e-03f, 1.63724080e-01f, 1.36358082e-01f, -8.80431086e-02f, 5.25601581e-02f, 2.90088858e-02f,
  7.08990097e-02f, -3.97226065e-02f, 2.92720851e-02f, -1.31515622e-01f, 2.23519411e-02f, 3.36417817e-02f, 1.30402014e-01f, -3.35884020e-02f, -5.19313067e-02f, 1.54187083e-01f,
  7.47710243e-02f, -2.21496560e-02f, -3.42899896e-02f, -1.57978926e-02f, 7.45897088e-03f, -2.11820304e-02f, -8.09865445e-02f, -7.80488476e-02f, 1.74212921e-02f, 2.30112802e-02f,
  -7.59401247e-02f, 4.36887853e-02f, -1.99567359e-02f, -1.08220942e-01f, 5.50657511e-02f, -2.99721211e-02f, -1.07838452e-01f, 1.24067038e-01f, -4.92241643e-02f, -7.25066103e-03f,
  -2.51818895e-01f, -3.63740027e-02f, 3.24239046e-03f, -7.31642023e-02f, -3.46398316e-02f, 7.04526380e-02f, 3.89155708e-02f, 1.66682675e-02f, 1.31681591e-01f, -8.50510076e-02f,
  -7.32392371e-02f, -9.45643615e-03f, -5.34415916e-02f, 4.40041609e-02f, 1.63793266e-01f, 3.18278670e-02f, -6.96385838e-03f, -8.20750222e-02f, -1.08614944e-01f, 8.54668543e-02f,
  -1.73451733e-02f, 2.84778257e-03f, 1.03404827e-01f, 1.07249007e-01f, 8.82919356e-02f, 7.10109100e-02f, -1.55941978e-01f, -8.00959840e-02f, 3.91358361e-02f, 8.39119628e-02f,
  3.58150452e-01f, 3.11592184e-02f, 1.69377893e-01f, 4.73489106e-01f, 2.90951073e-01f, -2.81752706e-01f, 1.96765885e-01f, 3.47517699e-01f, 5.28731644e-01f, -1.43369019e-01f,
  6.09637424e-02f, -2.99931429e-02f, -1.21310100e-01f, 8.02980065e-02f, -4.52873528e-01f, -1.55673400e-01f, -1.57735571e-01f, -1.27832428e-01f, 2.80372947e-01f, 1.86928976e-02f,
  6.67890385e-02f, -8.09298232e-02f, -1.47341460e-01f, 7.69992825e-03f, 2.04222396e-01f, 2.17982382e-01f, -2.65630633e-01f, 3.32242996e-02f, -1.75368682e-01f, -1.67714879e-01f,
  -1.24965543e-02f, 5.11637509e-01f, 5.81182130e-02f, 4.61554248e-03f, 1.55186011e-02f, -1.34550944e-01f, -3.91406491e-02f, -1.54251054e-01f, -1.45156207e-02f, 1.63168944e-02f,
  -1.25674590e-01f, -1.25047281e-01f, 6.12315722e-02f, 8.29491243e-02f, 1.76159590e-01f, 5.48211895e-02f, 1.16649382e-01f, 1.14411928e-01f, 6.42510653e-02f, 3.71909961e-02f,
  1.36109695e-01f, -1.15839113e-02f, -8.24530795e-02f, -6.71061501e-02f, 1.91561878e-02f, 1.24512680e-01f, -1.00559048e-01f, -1.26078099e-01f, -1.51529359e-02f, 2.31698081e-02f,
  1.31933168e-01f, -8.15976411e-04f, -1.35654146e-02f, -3.37621160e-02f, 1.97627954e-02f, 4.64697257e-02f, -9.88598913e-03f, -1.02420405e-01f, 2.03163903e-02f, -5.60419932e-02f,
  -5.05320691e-02f, 8.24594423e-02f, 1.60855666e-01f, 3.60029154e-02f, 1.44764245e-01f, 5.32218106e-02f, -1.88379094e-01f, 9.17332899e-03f, -3.60494629e-02f, 9.35997143e-02f,
  9.55399498e-02f, -6.40017614e-02f, -6.22958317e-02f, -4.25302833e-02f, -9.92723480e-02f, 4.11581770e-02f, 6.56359717e-02f, 2.56598201e-02f, 3.65761630e-02f, -3.75376195e-02f,
  -3.88380677e-01f, -6.04890883e-02f, -1.32060954e-02f, 2.08230894e-02f, -1.07126199e-01f, -7.43309110e-02f, -9.68657900e-03f, -4.27169614e-02f, -2.85142213e-02f, 3.43598686e-02f,
  -1.24277949e-01f, 5.50801158e-02f, -1.50691196e-01f, -9.48987752e-02f, -6.67793974e-02f, 1.25434715e-02f, 3.81695479e-02f, -5.55227627e-04f, -1.52850375e-01f, 4.56013251e-03f,
  -7.06243515e-02f, -3.21506313e-03f, -1.44394040e-01f, 1.21893041e-01f, -1.54943585e-01f, -4.87076901e-02f, -5.52293519e-03f, -1.08938413e-02f, -1.58852488e-01f, -4.20696847e-02f,
  -7.09416509e-01f, 2.74636269e-01f, -1.54308975e-01f, -1.78896621e-01f, -1.32786080e-01f, -1.97165012e-01f, -2.78260503e-02f, -2.38834232e-01f, -9.88854393e-02f, 4.02108878e-01f,
  2.66180396e-01f, -2.97606289e-01f, 2.70934343e-01f, 1.93814769e-01f, -4.43174243e-01f, 2.50120759e-01f, -4.85331863e-02f, -4.10914011e-02f, -5.76899052e-02f, -3.48945707e-01f,
  -1.80735946e-01f, -1.14186712e-01f, -3.85244563e-02f, 6.72823424e-03f, -1.31130099e-01f, -1.36060789e-01f, 1.54016644e-01f, 1.76549854e-03f, 1.09760799e-01f, -1.10771067e-01f,
  -1.25100046e-01f, -2.50382096e-01f, 4.89930473e-02f, -7.77437016e-02f, -1.97332069e-01f, 4.98079918e-02f, -5.48255965e-02f, -5.19534424e-02f, -5.51552773e-02f, -1.16826311e-01f,
  -1.16805732e-01f, -7.88207725e-02f, -5.95329553e-02f, -1.04462299e-02f, -4.71601933e-02f, -2.90985536e-02f, -1.14457561e-02f, 2.28587557e-02f, 3.06488536e-02f, -9.29161981e-02f,
  8.76246542e-02f, 1.31337389e-01f, 5.60385957e-02f, 1.07218459e-01f, -4.09392715e-02f, -2.04836670e-02f, 9.58777592e-02f, 8.18268284e-02f, -5.56534305e-02f, -8.75854045e-02f,
  -7.56346285e-02f, 2.94404873e-03f, 1.00138709e-01f, -6.57369420e-02f, 6.16967119e-02f, -1.79992907e-03f, 2.90063582e-02f, -6.36624470e-02f, -4.49448414e-02f, -1.54541256e-02f,
  7.23020174e-03f, -8.00244138e-02f, -8.26680288e-02f, -1.81315169e-02f, 4.29802909e-02f, 1.51595846e-02f, -1.85431354e-02f, -7.59866536e-02f, -2.53553446e-02f, 1.23619717e-02f,
  4.48751962e-03f, -7.65205920e-03f, 3.10334992e-02f, 6.44319206e-02f, -7.54231308e-03f, 9.81634203e-03f, 3.73127647e-02f, 2.70742085e-02f, 6.28833994e-02f, -4.02713455e-02f,
  -4.82297629e-01f, -3.56249034e-01f, -8.98346901e-02f, -7.44401589e-02f, 4.64221351e-02f, 8.71108286e-03f, -3.04909591e-02f, 5.81416069e-03f, -1.07317105e-01f, -1.21771842e-01f,
  -5.01603670e-02f, 7.21616372e-02f, -8.47658962e-02f, -7.97926113e-02f, -6.94532320e-02f, -7.44177587e-03f, -4.03364040e-02f, -1.65756643e-02f, -1.53013691e-01f, -8.28301460e-02f,
  -2.37075090e-02f, -5.38821965e-02f, 5.60263507e-02f, 1.73233114e-02f, -2.40141265e-02f, 2.61361198e-03f, -1.15431942e-01f, 2.19903123e-02f, 1.70358997e-02f, 9.43928510e-02f,
  1.00244172e-01f, -4.67082977e-01f, 5.85243991e-03f, 2.69622684e-01f, -5.33305928e-02f, -2.40951061e-01f, 3.21712065e-03f, -1.68693051e-01f, 2.35899419e-01f, -4.46044624e-01f,
  -7.70662278e-02f, 2.28193671e-01f, 2.67543077e-01f, -2.88319170e-01f, 6.45321786e-01f, 3.45702887e-01f, -1.51653677e-01f, 1.12192810e-01f, 1.82487190e-01f, -8.27105492e-02f,
  8.12939629e-02f, -3.64482462e-01f, -3.45221311e-02f, -4.60096687e-01f, -3.32546026e-01f, -2.36791626e-01f, -3.89251709e-02f, -1.37181550e-01f, -4.69843358e-01f, 3.12300827e-02f,
  1.96361896e-02f, -1.58387884e-01f, -1.66123465e-01f, -9.03942361e-02f, -6.46500140e-02f, 7.43549913e-02f, 9.13962200e-02f, 1.29425660e-01f, 1.05914526e-01f, 2.45927484e-03f,
  9.54649318e-03f, 9.45861340e-02f, -1.92959279e-01f, 1.81500502e-02f, 1.40217841e-02f, 8.85987282e-03f, 1.60079896e-02f, -7.33702853e-02f, -1.24065682e-01f, 1.80723667e-01f,
  6.65332153e-02f, -3.56798023e-02f, 3.34917605e-02f, -3.89537737e-02f, 5.43519668e-03f, -2.92415428e-03f, 7.88795650e-02f, 7.21976906e-02f, -1.29601955e-02f, 8.49309564e-02f,
  -1.13727167e-01f, -1.16599882e-02f, -6.12450615e-02f, -3.60377990e-02f, -3.56620573e-03f, -5.61543107e-02f, 8.34453851e-02f, -4.24761251e-02f, 8.32598954e-02f, 3.07464320e-02f,
  1.55897373e-02f, 1.50468796e-02f, 1.17615491e-01f, 5.88731170e-02f, -5.81824966e-02f, -2.78427061e-02f, -1.16130235e-02f, 5.11523709e-02f, 4.78647873e-02f, 5.17930323e-03f,
  -4.27567549e-02f, 1.24653941e-02f, 7.11824372e-03f, 1.21937707e-01f, 6.00501150e-03f, 4.22650836e-02f, -8.64972025e-02f, 1.18793757e-03f, 8.12781826e-02f, 1.54403169e-02f,
  2.29344089e-02f, -3.32492322e-01f, -1.58820361e-01f, -3.73590812e-02f, 9.90172625e-02f, -1.36474803e-01f, 9.85789485e-03f, -9.47308019e-02f, -4.54548895e-02f, -8.37569982e-02f,
  -1.31853983e-01f, 3.24926861e-02f, 7.43575022e-02f, 8.47148895e-02f, -1.91796329e-02f, 2.07882859e-02f, -1.56950410e-02f, 5.09218797e-02f, -1.26897812e-01f, -8.43171030e-02f,
  -6.23020306e-02f, 1.25763193e-01f, 7.34682530e-02f, -1.02004737e-01f, 5.06957993e-02f, -5.73942810e-02f, 6.90961555e-02f, -3.08334660e-02f, 9.45906192e-02f, 4.85311821e-02f,
  -6.41308069e-01f, 1.81131035e-01f, 3.22905511e-01f, -2.82322049e-01f, -7.46848285e-02f, 4.29466099e-01f, 4.64204282e-01f, 1.85464714e-02f, -2.76800394e-01f, 2.45105222e-01f,
  3.11966032e-01f, -1.70606747e-01f, 3.53214622e-01f, 1.68601438e-01f, 3.97204190e-01f, 3.82139504e-01f, 2.18584597e-01f, 9.00879279e-02f, -8.62620398e-02f, -1.65083930e-01f,
  -4.12034430e-02f, 1.51845619e-01f, 2.88712084e-01f, -1.87973589e-01f, -5.69732767e-03f, -2.71439224e-01f, -8.51116627e-02f, 1.91228241e-01f, 7.20154792e-02f, 2.04149991e-01f,
  1.47516429e-01f, -2.25086957e-01f, -7.70250186e-02f, 1.52492478e-01f, 2.95900628e-02f, -9.39972773e-02f, 5.64430468e-02f, 3.93083170e-02f, -1.63332984e-01f, 5.31352237e-02f,
  -1.54125676e-01f, 3.50916833e-02f, -1.35493487e-01f, 3.03434692e-02f, -1.58966586e-01f, 3.64183970e-02f, 2.52577309e-02f, 1.06960520e-01f, 1.28868639e-01f, 7.84553960e-03f,
  9.61191058e-02f, 1.41036183e-01f, 1.50681315e-02f, 6.37297109e-02f, 5.00133485e-02f, 2.14346591e-02f, -3.33554521e-02f, -3.57430652e-02f, -4.17267457e-02f, 4.34266729e-03f,
  -1.84920564e-01f, 5.57212606e-02f, 6.79569971e-03f, 7.60701150e-02f, -5.86274527e-02f, 3.05891763e-02f, 5.65156676e-02f, 5.20640276e-02f, -6.67253435e-02f, 1.22495927e-01f,
  -7.80436695e-02f, -9.21948180e-02f, -5.14708497e-02f, 1.75056304e-03f, -7.67931268e-02f, -9.63534974e-03f, 6.68748617e-02f, -1.46860015e-02f, 9.79109704e-02f, 1.02684200e-01f,
  -5.41648269e-02f, 2.04658732e-02f, 2.60803252e-02f, -1.40277371e-02f, 1.25570625e-01f, 4.81026396e-02f, -6.15404695e-02f, 1.60497576e-02f, 3.05068418e-02f, 4.14711423e-02f,
  6.78554997e-02f, -2.32261777e-01f, 6.07016962e-03f, 5.72399907e-02f, 3.29929367e-02f, 4.92539071e-02f, 2.60027940e-03f, -1.30389616e-01f, -1.07920721e-01f, 4.69928905e-02f,
  -1.44505858e-01f, -6.56485111e-02f, 7.28085113e-04f, -1.79906487e-02f, 6.93362253e-03f, 5.64673310e-03f, -2.52548382e-02f, -9.04760556e-04f, 6.26529679e-02f, 5.89686744e-02f,
  1.14121646e-01f, -6.70820773e-02f, -9.45238397e-03f, -3.41696069e-02f, -6.15882725e-02f, 1.32841036e-01f, -2.27242336e-01f, -1.23338945e-01f, -8.96568000e-02f, 6.85499422e-03f,
  -1.78112224e-01f, -2.60883451e-01f, 1.78853065e-01f, 3.13684881e-01f, -1.53514355e-01f, -8.72994065e-02f, 3.30395609e-01f, -1.43278569e-01f, -3.91459495e-01f, -2.03994095e-01f,
  2.05025449e-01f, 1.71711981e-01f, -6.16583973e-02f, 1.37781531e-01f, 3.93785238e-01f, 9.90545452e-02f, 5.85862575e-03f, 1.89692944e-01f, -3.61938328e-02f, -3.26771513e-02f,
  5.78600504e-02f, 1.87195927e-01f, 3.35008204e-01f, -1.04862964e-02f, 9.22814235e-02f, -3.13415229e-02f, 2.91509777e-01f, 9.84931216e-02f, 1.69726402e-01f, 1.31193370e-01f,
  -1.72399595e-01f, -1.12678491e-01f, 2.09360905e-02f, -2.80517936e-02f, -7.59388208e-02f, 7.42649287e-02f, 1.70588374e-01f, 1.83372036e-01f, 1.02127254e-01f, 3.33916694e-02f,
  -5.21865971e-02f, -2.49026984e-04f, 3.81237231e-02f, 3.29169556e-02f, -1.64112046e-01f, -1.21688955e-01f, -1.94002122e-01f, -8.32412466e-02f, -3.75258289e-02f, -4.46484759e-02f,
  -1.22630790e-01f, -4.14775647e-02f, 2.37561129e-02f, 6.94224313e-02f, 5.09011224e-02f, 1.73828024e-02f, 5.65766804e-02f, -1.10030724e-02f, -5.27384877e-02f, 5.66197112e-02f,
  5.22381477e-02f, 6.01713881e-02f, -4.85122949e-03f, 8.01637545e-02f, 3.82259898e-02f, 6.83444291e-02f, -1.18983514e-03f, 7.41814524e-02f, 1.10961616e-01f, 4.97775711e-02f,
  -3.48213278e-02f, -6.11847639e-02f, -2.75167115e-02f, -2.69095376e-02f, -4.61062528e-02f, -8.73847976e-02f, 1.37131065e-01f, -2.00062077e-02f, -4.63638976e-02f, 3.44243236e-02f,
  2.84582544e-02f, -4.82495911e-02f, 4.65040393e-02f, -2.05972418e-03f, 3.11265718e-02f, 1.05224356e-01f, 2.88238209e-02f, -6.57587945e-02f, -6.51569888e-02f, 7.64718428e-02f,
  -2.10449368e-01f, 1.51841000e-01f, -2.09106710e-02f, -9.34550464e-02f, 1.18558086e-01f, -1.09802783e-01f, 9.13351104e-02f, -1.01770066e-01f, -3.17491218e-02f, -8.13168213e-02f,
  -1.14486508e-01f, 4.16307971e-02f, -9.25499648e-02f, 4.59606610e-02f, 1.15243949e-01f, -1.03522234e-01f, 2.54162792e-02f, -7.57834762e-02f, 2.50680197e-04f, -8.61975085e-03f,
  1.14487268e-01f, -3.27797346e-02f, 1.70820758e-01f, -1.71709716e-01f, -5.77259250e-02f, 7.52400979e-02f, 8.43362659e-02f, 3.54462216e-04f, -8.15541968e-02f, 3.27479430e-02f,
  -2.52521724e-01f, 2.78254658e-01f, 4.11470383e-01f, -2.56166816e-01f, 8.41375887e-02f, -1.00414030e-01f, -1.19881190e-01f, 3.28323292e-03f, 3.68045866e-02f, -1.08110398e-01f,
  -1.48799628e-01f, 3.12775910e-01f, 2.79007018e-01f, -2.79063702e-01f, -1.10396750e-01f, -6.54716119e-02f, -3.68923903e-01f, -1.22868791e-01f, 1.11790411e-01f, -2.61440873e-02f,
  -1.46351963e-01f, -3.04557621e-01f, -1.11890651e-01f, 4.93799523e-03f, -6.57439232e-02f, -3.55331898e-02f, -2.35698536e-01f, 2.45654136e-01f, -3.35666053e-02f, 1.08806774e-01f,
  -2.17644662e-01f, -7.24770874e-02f, 3.26970220e-03f, -3.47371064e-02f, -6.47589117e-02f, -9.14674532e-03f, -1.93130299e-02f, 1.95986591e-02f, -7.49535784e-02f, 3.83518897e-02f,
  1.24694183e-01f, -1.38415433e-02f, 1.24890385e-02f, 1.71754044e-02f, -7.13464767e-02f, 3.76634523e-02f, 9.57838148e-02f, -9.12127644e-02f, 1.32338613e-01f, 2.69890931e-02f,
  1.11595415e-01f, 7.44517893e-02f, -9.80795324e-02f, -9.22762975e-02f, 1.10451117e-01f, 6.92301663e-03f, -7.26001486e-02f, -2.82747112e-03f, -6.54400140e-02f, -4.94346656e-02f,
  2.68151760e-02f, -5.70581928e-02f, 3.18811387e-02f, 8.55945423e-03f, 1.14744447e-01f, 5.14993351e-03f, 5.55757396e-02f, -6.95664063e-02f, -1.24404497e-01f, -3.12387033e-06f,
  -6.54168129e-02f, 5.30529674e-03f, -8.01631510e-02f, -1.14103854e-01f, 9.65072401e-03f, -3.46230678e-02f, 3.30608375e-02f, -4.34314981e-02f, -8.04970879e-03f, -1.14248218e-02f,
  -9.05646458e-02f, -9.45024267e-02f, 8.80951956e-02f, -1.33725375e-01f, 9.24192443e-02f, 4.48902175e-02f, -5.06542139e-02f, 8.38883519e-02f, -8.28317851e-02f, 9.95090902e-02f,
  -4.38922614e-01f, -3.84620726e-01f, -9.36180204e-02f, -1.67260438e-01f, 2.30007023e-02f, -1.58736885e-01f, -1.00203929e-02f, -4.98029664e-02f, -1.32211596e-01f, 1.07923690e-02f,
  -4.61689495e-02f, -2.71629989e-02f, -5.62152229e-02f, -1.05878271e-01f, -6.71734894e-03f, -1.18869230e-01f, -2.09750999e-02f, -2.04331670e-02f, -1.28056645e-01f, -6.15400299e-02f,
  -9.12492499e-02f, -1.11393347e-01f, 7.14007467e-02f, 1.39380852e-02f, -1.26458451e-01f, -7.88167045e-02f, -9.78405774e-02f, 9.40068960e-02f, 3.81974652e-02f, -2.06163004e-02f,
  2.46345595e-01f, -3.11303586e-01f, -3.94543499e-01f, 2.62171552e-02f, 3.72180134e-01f, 2.45284811e-01f, -7.14970753e-02f, 3.01582515e-01f, -2.73027182e-01f, -1.50332838e-01f,
  1.34967566e-01f, -1.03439622e-01f, -2.61451513e-01f, 3.03219229e-01f, 2.74270654e-01f, -1.64029226e-01f, 3.17134589e-01f, 1.62464827e-01f, 2.71945237e-03f, 4.18475829e-02f,
  7.93323219e-02f, 3.41860205e-01f, -1.46213755e-01f, 1.69974744e-01f, 2.73576975e-01f, 5.11736274e-02f, 5.86305745e-02f, -3.43030035e-01f, 2.09306508e-01f, 2.23065466e-01f,
  1.71147749e-01f, -4.39066738e-02f, -1.89285398e-01f, -1.43417269e-01f, -1.12918794e-01f, -1.73532113e-01f, -2.34867990e-01f, 6.89719841e-02f, -7.07998946e-02f, 7.46049881e-02f,
  -1.04809016e-01f, 1.56520322e-01f, 1.35732785e-01f, -5.29138185e-02f, 3.88626521e-03f, -3.86959873e-02f, 1.74332671e-02f, 1.57657079e-02f, -1.60841215e-02f, -9.12060554e-04f,
  -1.03733487e-01f, 1.04003169e-01f, -6.10495592e-03f, 1.78117845e-02f, -2.32729614e-02f, 2.70865718e-03f, -5.82710886e-03f, -3.23317535e-02f, 1.63944200e-01f, 1.51868295e-02f,
  2.70157028e-02f, -8.49570632e-02f, 3.69304605e-02f, -7.76855648e-03f, -3.67560610e-02f, -1.24918343e-02f, 1.73409153e-02f, 1.75270010e-02f, -1.71368808e-01f, 2.54311580e-02f,
  4.10373472e-02f, -6.53992072e-02f, 1.01880208e-02f, 4.75451313e-02f, -9.72824078e-03f, -1.53268771e-02f, -5.81562370e-02f, 1.28906816e-01f, -3.65321524e-02f, 6.44165650e-02f,
  1.42969638e-02f, 2.37163901e-02f, -7.33961463e-02f, -2.68372800e-02f, 1.14934020e-01f, -3.22713368e-02f, 3.35727632e-02f, -5.17057590e-02f, -5.09081893e-02f, 1.59858204e-02f,
  -2.16569342e-02f, -1.66167989e-01f, -2.46724654e-02f, 1.12158038e-01f, -1.79027483e-01f, 5.25703169e-02f, -1.16736405e-01f, 5.77962399e-02f, -5.33983111e-02f, -2.03250796e-02f,
  -4.05758731e-02f, -8.95798281e-02f, -6.23134896e-02f, 2.29201792e-03f, 3.14605981e-02f, -5.92650995e-02f, -4.24247086e-02f, -7.91007429e-02f, 4.77940589e-02f, -4.85230237e-03f,
  2.85720658e-02f, 5.01898453e-02f, 1.89662981e-03f, -3.46143008e-03f, 7.58200362e-02f, -5.86292520e-02f, 5.87372631e-02f, 2.08890848e-02f, 7.52217472e-02f, -2.82525904e-02f,
  -4.97510701e-01f, 2.78400749e-01f, -1.02904625e-03f, -2.70172864e-01f, -3.72465074e-01f, 1.25331536e-01f, 1.96713120e-01f, 5.34315854e-02f, 9.07166004e-02f, 4.12169546e-01f,
  -7.22101778e-02f, -2.34049484e-01f, 3.23601931e-01f, -5.65999486e-02f, -2.46104240e-01f, 4.00413990e-01f, 1.64680004e-01f, -1.57294236e-02f, -3.40126269e-02f, -6.44266084e-02f,
  -1.93697497e-01f, -2.25942135e-01f, -8.86100680e-02f, -3.14747766e-02f, -3.05817813e-01f, -2.40916848e-01f, -2.08933994e-01f, -8.46296847e-02f, -1.91346034e-01f, -2.53536612e-01f,
  -2.46348247e-01f, -1.48871288e-01f, -2.13622555e-01f, -3.98483649e-02f, -2.81411875e-02f, -8.38665292e-02f, -7.85914883e-02f, -1.76468790e-01f, -1.24928959e-01f, 4.66349497e-02f,
  6.65196925e-02f, -9.19578671e-02f, -3.27976979e-02f, 7.53599033e-02f, -6.72434792e-02f, -4.70675975e-02f, -1.82663292e-01f, -6.17648009e-03f, -8.04430768e-02f, -1.21447943e-01f,
  4.96781878e-02f, 6.58580139e-02f, -4.21858095e-02f, -2.96672676e-02f, -1.57758221e-01f, -4.31074835e-02f, -4.20100912e-02f, -7.52105191e-02f, -9.85598490e-02f, -4.29675803e-02f,
  4.20185886e-02f, -4.22983058e-02f, -6.61674663e-02f, 3.90015878e-02f, 1.76153615e-01f, 6.05478920e-02f, 9.14380923e-02f, -2.66812388e-02f, -6.08576462e-03f, -5.37515283e-02f,
  -1.46797858e-02f, -4.20439579e-02f, 1.64108668e-02f, -9.15894937e-03f, 3.49323414e-02f, 8.39499980e-02f, -4.33139205e-02f, -1.67087689e-01f, 8.86256248e-02f, -3.02827805e-02f,
  -1.46888960e-02f, 3.39338891e-02f, 2.82056117e-03f, -5.33227883e-02f, 8.57178271e-02f, -1.65203083e-02f, 8.30251276e-02f, -3.98065038e-02f, -2.45406926e-02f, -1.84792317e-02f,
  -2.36341923e-01f, -2.48373836e-01f, -1.07571527e-01f, -2.05378518e-01f, 4.21167500e-02f, 2.37535201e-02f, 7.86076486e-02f, -5.66259809e-02f, 6.57212287e-02f, -1.40470937e-02f,
  1.17187887e-01f, 1.87901538e-02f, -9.79187153e-03f, 8.21683630e-02f, 2.22589687e-01f, 3.67629118e-02f, -2.53027305e-02f, 1.02422908e-02f, -8.80565122e-02f, -2.16922499e-02f,
  -3.15107815e-02f, 2.12945728e-04f, 1.15684405e-01f, -6.86038956e-02f, -7.52394125e-02f, -6.47610286e-03f, -1.20858895e-02f, -1.43838510e-01f, -1.09002776e-01f, -3.71770076e-02f,
  1.74058110e-01f, 3.94792736e-01f, -1.53468937e-01f, 1.16552405e-01f, 1.61412969e-01f, 4.97157454e-01f, 1.87990099e-01f, 1.21840134e-01f, 2.62140542e-01f, 2.74076760e-01f,
  1.29963001e-02f, 1.34564504e-01f, -1.58727065e-01f, 1.07849076e-01f, 2.72730678e-01f, -9.28453803e-02f, 3.08436900e-01f, 2.16588095e-01f, -1.10981956e-01f, 2.58705080e-01f,
  1.80333350e-02f, 1.91722393e-01f, -3.21895033e-01f, -5.60826175e-02f, 7.16283470e-02f, -1.93336517e-01f, -1.58171862e-01f, -3.40685040e-01f, -1.03264078e-01f, 5.03336862e-02f,
  4.44853939e-02f, 1.77946519e-02f, -4.91385534e-02f, -6.65935948e-02f, -1.61990691e-02f, -4.50881682e-02f, -1.11785559e-02f, -6.61001056e-02f, -2.29557887e-01f, -8.71966407e-02f,
  4.81432155e-02f, 4.76772152e-02f, 1.60710230e-01f, 3.43142338e-02f, 7.88789317e-02f, 3.13358940e-02f, -1.07052207e-01f, 3.78376693e-02f, -4.67163548e-02f, -1.25614971e-01f,
  2.88643539e-02f, -7.87486359e-02f, 2.85749175e-02f, 4.47569638e-02f, 1.07758464e-02f, 4.06238399e-02f, 1.40165046e-01f, -3.50822248e-02f, 1.11205101e-01f, 6.63999617e-02f,
  1.06892504e-01f, 1.45349363e-02f, 6.29603863e-02f, -8.30633938e-03f, 1.20691098e-01f, -8.74945968e-02f, -2.09987722e-03f, -9.90550965e-02f, 4.54147458e-02f, 7.02393800e-02f,
  -4.51206118e-02f, -2.30001789e-02f, -2.79064365e-02f, -3.46070505e-03f, 1.28598630e-01f, -3.78470086e-02f, -3.06441803e-02f, -6.78867176e-02f, 1.23190522e-01f, 2.14469153e-02f,
  1.10422960e-02f, 1.60009608e-01f, -7.28712359e-04f, -5.41894697e-02f, -3.98201272e-02f, -1.24383576e-01f, 2.49412991e-02f, 1.51790371e-02f, -1.88934933e-02f, 7.35231787e-02f,
  1.67642027e-01f, 3.75102997e-01f, -7.54038393e-02f, -1.46585196e-01f, 5.69550097e-02f, 2.64791157e-02f, 5.86609468e-02f, 1.37627035e-01f, 1.04869112e-01f, 1.84360128e-02f,
  3.06498799e-02f, -2.53925845e-02f, 1.29216630e-02f, -3.25332507e-02f, -7.90652633e-02f, 1.09611005e-01f, 7.06308335e-02f, 6.33910447e-02f, 1.45380154e-01f, -4.89108153e-02f,
  6.93467259e-02f, 1.56369939e-01f, 9.23830494e-02f, 1.27731681e-01f, 1.65334880e-01f, 1.40842646e-02f, 1.54273152e-01f, -1.92809656e-01f, -1.79757085e-02f, 1.04667693e-01f,
  7.58678839e-02f, -2.14706779e-01f, -2.19429716e-01f, 6.28672019e-02f, 1.90420598e-01f, -2.79122263e-01f, -1.36559084e-01f, 8.40282813e-02f, 3.18954766e-01f, -1.16843216e-01f,
  -3.69753167e-02f, -4.21183929e-02f, 2.56463476e-02f, -4.41899687e-01f, -1.91656545e-01f, -1.67824343e-01f, -2.21716300e-01f, -2.66063601e-01f, 3.28492492e-01f, -9.96589959e-02f,
  5.20262718e-02f, -2.42362842e-01f, -1.60554469e-01f, -2.88954377e-02f, -2.07605705e-01f, 1.96189687e-01f, 6.80896938e-02f, 7.09194515e-04f, -2.02006429e-01f, -5.57639487e-02f,
  5.33464886e-02f, 3.39861438e-02f, -1.18194707e-01f, 2.78564207e-02f, -2.25239489e-02f, -6.08156528e-03f, -4.30731662e-02f, -2.80737318e-02f, 1.29868120e-01f, -1.34875160e-02f,
  1.84296779e-02f, 1.70375556e-01f, -2.96337549e-02f, -1.49562940e-01f, 4.18394245e-02f, -3.78156826e-02f, -2.18742602e-02f, 7.61311203e-02f, 1.01115964e-02f, -2.89940804e-01f,
  -1.22480012e-01f, -3.68189961e-02f, 1.47946641e-01f, 2.05759495e-01f, 2.09164396e-02f, -1.11810928e-02f, -6.63727969e-02f, -1.38943151e-01f, 8.66915882e-02f, -2.18134541e-02f,
  -1.00321613e-01f, -7.56341591e-02f, 6.00295067e-02f, 1.10307224e-01f, 2.06794217e-02f, 6.17774576e-02f, 4.53120098e-03f, 1.46743849e-01f, 8.17809105e-02f, -5.59109524e-02f,
  3.79610546e-02f, -1.29235640e-01f, -7.89102837e-02f, 7.54929557e-02f, -1.26932308e-01f, 8.58730152e-02f, 1.33936629e-01f, 1.42858019e-02f, 1.89287677e-01f, -6.16332842e-03f,
  -3.87073979e-02f, 8.87017548e-02f, -5.27124293e-02f, 3.68495956e-02f, -1.43739820e-01f, 1.27581462e-01f, -2.23792195e-01f, 3.95147204e-02f, 6.63464540e-04f, -4.99142930e-02f,
  3.11926305e-02f, 2.96332370e-02f, -6.44525290e-02f, 8.31453875e-02f, -3.49450670e-02f, -3.50837857e-02f, -4.91202287e-02f, -6.31312728e-02f, -1.61231067e-02f, -7.86837842e-03f,
  -2.86214948e-02f, 1.45764500e-01f, 1.77499458e-01f, 1.11520879e-01f, -3.30292969e-04f, -1.46322459e-01f, 1.30474746e-01f, 1.74712405e-01f, 1.26023784e-01f, -1.43423796e-01f,
  4.12346087e-02f, 6.97049871e-02f, 8.20811614e-02f, 1.63614079e-01f, 9.66950059e-02f, 1.23548768e-01f, 7.30673149e-02f, 6.05395138e-02f, 1.13740593e-01f, 1.18745357e-01f,
  6.74301945e-03f, -1.95519283e-01f, 2.78935879e-01f, 3.28597128e-02f, -6.90681934e-02f, 3.79584022e-02f, 3.21126282e-01f, -4.34640676e-01f, -4.80442166e-01f, -1.97392881e-01f,
  -8.27436373e-02f, 3.29898357e-01f, 3.72815192e-01f, -3.18226427e-01f, 3.65429878e-01f, -9.28220600e-02f, -1.81437746e-01f, -1.10220257e-02f, -1.37056485e-01f, 2.72647113e-01f,
  1.19343944e-01f, -2.74665356e-01f, 2.61972904e-01f, -2.82727122e-01f, 1.08164489e-01f, 2.52593514e-02f, 2.84506738e-01f, 3.63154471e-01f, 2.79651340e-02f, 1.35629307e-02f,
  -1.36005566e-01f, -2.59233028e-01f, 7.43365586e-02f, -4.06067781e-02f, -9.90441218e-02f, -6.34712502e-02f, -4.89186272e-02f, 1.29390433e-01f, 8.96703452e-02f, -3.29946876e-02f,
  1.20734230e-01f, 6.54538348e-03f, -7.34172389e-02f, 1.70319259e-01f, -5.22037558e-02f, -8.51159636e-03f, -9.87725258e-02f, 8.56187791e-02f, -5.41569255e-02f, 1.94394827e-01f,
  1.35024160e-01f, -9.72484648e-02f, -8.12323540e-02f, -1.28376782e-01f, 1.46082386e-01f, 7.41155893e-02f, 8.26761648e-02f, 3.02670121e-01f, 3.02063655e-02f, -1.37096226e-01f,
  -1.14626318e-01f, 9.81949270e-02f, 6.09542057e-02f, -1.62077527e-02f, -2.13067178e-02f, -1.92813501e-01f, 9.19853598e-02f, -6.95963018e-03f, -1.97606273e-02f, 1.28460810e-01f,
  1.26837939e-02f, -2.29034945e-02f, -2.88433015e-01f, 4.24691886e-02f, 1.00671744e-03f, -2.32612360e-02f, 1.11758545e-01f, -2.45664231e-02f, -1.08850978e-01f, -4.23920108e-03f,
  1.32238185e-02f, -1.14071229e-02f, 1.10043702e-03f, -5.30031286e-02f, -2.54389644e-01f, 8.51375461e-02f, -6.94477782e-02f, -6.94479942e-02f, -1.11727096e-01f, 2.35337660e-01f,
  1.07091172e-02f, 1.51545152e-01f, 1.22990347e-01f, -7.36454725e-02f, -5.60414828e-02f, 5.96377824e-04f, -1.36939287e-01f, -6.10739551e-02f, 6.01673983e-02f, -8.41754451e-02f,
  -8.88225436e-02f, 4.35985699e-02f, -8.91240407e-03f, 8.63538533e-02f, -1.67489573e-02f, 9.88449901e-02f, 1.27134174e-01f, -1.53460754e-02f, 9.05000046e-03f, 5.27684763e-02f,
  1.89233556e-01f, 1.42218873e-01f, 3.32407355e-02f, 1.67958438e-02f, 3.65227535e-02f, 1.20263286e-01f, 1.03297159e-01f, -3.45797576e-02f, 1.47918478e-01f, -1.89265236e-02f,
  -1.78792011e-02f, 3.11013639e-01f, -2.75814980e-01f, 1.28681019e-01f, -6.64810091e-02f, 4.07715052e-01f, 4.16816503e-01f, 1.01889208e-01f, 1.37364253e-01f, 4.25855130e-01f,
  3.35265219e-01f, 5.56279905e-02f, 8.25502425e-02f, 4.16643739e-01f, 2.13943515e-02f, 4.33361858e-01f, 4.14062798e-01f, 2.83955693e-01f, -6.90071285e-02f, 4.63479161e-02f,
  -1.10035334e-02f, 3.46478850e-01f, -1.44991577e-01f, -9.52833071e-02f, 1.21347420e-01f, -3.40896308e-01f, -1.70271128e-01f, -2.92891771e-01f, 3.04529339e-01f, 8.53838921e-02f,
  1.72561869e-01f, 5.73913381e-02f, -4.30383831e-02f, -4.75309382e-04f, -9.30586532e-02f, -2.79222075e-02f, -1.15176909e-01f, -1.45243332e-01f, -1.47777840e-01f, -8.52512419e-02f,
  -1.73704904e-02f, -5.27735651e-02f, 2.71832105e-02f, -1.07177570e-01f, 1.34050455e-02f, -3.57632264e-02f, 3.24979573e-02f, 5.91956675e-02f, 8.06857571e-02f, 4.60104868e-02f,
  -7.15153590e-02f, -6.31460324e-02f, -5.77446655e-04f, 1.27694711e-01f, 2.64903829e-02f, 1.94418826e-03f, 1.09001726e-01f, -3.16856615e-02f, 1.33622840e-01f, 6.74942732e-02f,
  1.43085010e-02f, 2.00650226e-02f, 3.35829742e-02f, 7.05599561e-02f, -3.86716761e-02f, -6.40906440e-03f, 1.99485254e-02f, 2.60688160e-02f, -1.12161748e-01f, 6.79655895e-02f,
  2.93371025e-02f, -4.73199040e-02f, 1.08669527e-01f, 2.16908343e-02f, 1.25891492e-01f, 7.24074394e-02f, -6.11252040e-02f, 7.29900897e-02f, 7.77072757e-02f, 5.17208502e-02f,
  4.59530056e-02f, 6.58191666e-02f, -3.34909596e-02f, -7.79603645e-02f, 8.54821801e-02f, -7.27532133e-02f, 3.42358351e-02f, 7.49939755e-02f, -2.04054341e-02f, -8.86588078e-03f,
  2.05514342e-01f, 8.32868963e-02f, 7.46700028e-03f, -1.13397734e-02f, -2.65290821e-03f, 3.42440009e-02f, 2.64793318e-02f, 1.23286834e-02f, 5.88426134e-03f, 4.15791646e-02f,
  -4.70086262e-02f, -9.17497352e-02f, 4.20868732e-02f, -6.03905283e-02f, 3.99614424e-02f, 9.05190259e-02f, 2.03647893e-02f, 2.34563742e-02f, -6.74001276e-02f, -7.47172982e-02f,
  -6.75994232e-02f, 1.84560791e-02f, -1.90154277e-02f, 4.55710329e-02f, 9.57019813e-03f, 9.87468436e-02f, -8.59248824e-03f, -8.78156647e-02f, -4.22178209e-02f, -1.44996238e-03f,
  -3.93401563e-01f, -2.12367162e-01f, -2.36980990e-01f, -1.54875204e-01f, -2.62107812e-02f, -7.28834495e-02f, -3.43678415e-01f, -1.77181005e-01f, -2.79575646e-01f, -2.77584821e-01f,
  -2.80214339e-01f, -4.53772582e-03f, -2.12227494e-01f, 1.80909112e-02f, 2.92858720e-01f, 2.67029762e-01f, 1.61985323e-01f, 2.09260195e-01f, 3.70113909e-01f, -1.29272074e-01f,
  2.34825343e-01f, 2.48910531e-01f, 2.95839518e-01f, 2.82340735e-01f, -3.23231332e-02f, -2.47398354e-02f, 1.63504198e-01f, 7.93187842e-02f, -3.51765454e-02f, 1.41084760e-01f,
  -9.11366791e-02f, -2.01505870e-01f, -1.17749460e-01f, -1.30389452e-01f, 3.78178880e-02f, -1.32440031e-01f, -2.04073638e-03f, 3.39313075e-02f, -5.76613955e-02f, -2.02672444e-02f,
  8.42908397e-03f, 1.32018775e-01f, -2.31030062e-02f, 9.41149592e-02f, -9.28418040e-02f, -1.81850735e-02f, 9.46933404e-02f, 4.08185683e-02f, -1.12508647e-01f, 2.66277120e-02f,
  -8.75321329e-02f, 4.39851992e-02f, 1.38871595e-02f, 1.12170294e-01f, -1.85072403e-02f, -8.73971507e-02f, -4.57799397e-02f, 3.83457402e-03f, 1.27294838e-01f, -4.90154773e-02f,
  8.20409060e-02f, 2.34933738e-02f, 3.65593731e-02f, -5.00647863e-03f, -1.10857330e-01f, -6.55874237e-02f, -7.13843629e-02f, 3.40100266e-02f, 7.06029385e-02f, -1.05006032e-01f,
  1.00905672e-02f, -2.93308161e-02f, -3.34658362e-02f, 2.38760989e-02f, 8.16510767e-02f, 8.89183581e-02f, 4.52275202e-03f, 1.37698390e-02f, 6.36887252e-02f, -6.92933202e-02f,
  2.23198626e-02f, -2.50165183e-02f, 3.18377577e-02f, 7.10254237e-02f, -3.95553187e-02f, -1.99794862e-02f, -9.28868800e-02f, -8.12842324e-02f, 1.62516758e-02f, 6.04749694e-02f,
  -1.49259448e-01f, -2.31292456e-01f, 2.94241346e-02f, -2.74285693e-02f, 9.42659751e-02f, 9.59937051e-02f, 9.71242040e-02f, 4.33339663e-02f, -1.31363243e-01f, -1.25029191e-01f,
  4.29280382e-03f, -5.79332979e-03f, 9.38709546e-03f, 2.17072107e-02f, 5.68029135e-02f, -1.66404583e-02f, -7.67365471e-02f, -1.02521487e-01f, -8.86829570e-02f, -3.96615453e-02f,
  -7.66915902e-02f, -2.16724947e-02f, 3.68398763e-02f, 1.13497734e-01f, 2.99836639e-02f, -1.12830438e-01f, -1.66853145e-02f, 4.83892933e-02f, 4.16095257e-02f, 6.54158741e-02f,
  -3.04230183e-01f, 5.29810607e-01f, 1.51945978e-01f, -3.29576693e-02f, -1.66215718e-01f, -4.85779881e-01f, -6.08658642e-02f, 3.39017399e-02f, 1.56654730e-01f, 4.11254883e-01f,
  -1.58791512e-01f, 3.70451361e-01f, 2.47513801e-02f, 6.70230836e-02f, -4.16459888e-01f, -1.58885121e-01f, -3.06932688e-01f, 6.28816187e-02f, -1.21917702e-01f, -1.66256055e-01f,
  -2.03074008e-01f, -3.19503844e-01f, -7.31225386e-02f, -5.41269593e-02f, 1.43396124e-01f, 1.69968650e-01f, -2.16034576e-01f, 3.18450108e-02f, 1.56142302e-02f, 3.95704061e-02f,
  -3.63073833e-02f, 1.83429807e-01f, 1.03940539e-01f, -1.64807830e-02f, -1.77176282e-01f, -2.58892272e-02f, -3.15938406e-02f, -3.00039668e-02f, 2.84585101e-03f, 5.73037192e-02f,
  1.09625213e-01f, 5.74218556e-02f, -7.07004666e-02f, 4.46634963e-02f, 1.16634041e-01f, 1.59282207e-01f, 8.98563489e-02f, 1.08018234e-01f, 3.10615953e-02f, 1.57140762e-01f,
  5.53323925e-02f, 4.35835347e-02f, -6.58841506e-02f, 1.72949359e-02f, 9.29065123e-02f, 9.45569575e-02f, -7.05335140e-02f, 8.66983533e-02f, 3.90718803e-02f, 4.11895327e-02f,
  8.66428390e-02f, -1.82897910e-01f, -5.13432771e-02f, 1.55123137e-02f, -1.01569839e-01f, 8.61875340e-02f, -3.84408347e-02f, -1.52496609e-03f, 6.05905391e-02f, 2.05573589e-02f,
  -4.92042638e-02f, 6.51953071e-02f, 5.98946512e-02f, -9.79509801e-02f, -5.67284506e-03f, 2.26660203e-02f, 2.64699999e-02f, 6.37011379e-02f, -5.22063337e-02f, 1.84500627e-02f,
  -2.11388711e-02f, -9.84977335e-02f, 2.58159656e-02f, 3.67609374e-02f, -9.08224955e-02f, -4.22613546e-02f, 5.58799505e-02f, 5.79278469e-02f, -1.56001896e-02f, -1.70923367e-01f,
  -3.97110581e-01f, -2.82843471e-01f, 3.43452729e-02f, 9.25656706e-02f, -2.55384482e-02f, -2.37528589e-02f, 4.31771539e-02f, 2.43716650e-02f, -7.89401904e-02f, -1.52057409e-01f,
  -6.70586228e-02f, 5.21615930e-02f, -1.65762618e-01f, -5.15005924e-02f, -1.16588436e-01f, -2.04190046e-01f, -1.14122361e-01f, -5.83517514e-02f, -1.02167249e-01f, 1.45509262e-02f,
  6.13541994e-03f, -6.78523034e-02f, -3.33261080e-02f, -1.87686216e-02f, 2.50317082e-02f, 5.87424114e-02f, -2.98257805e-02f, 9.61804017e-02f, -1.27983719e-01f, 3.79041508e-02f,
  2.62895107e-01f, 2.18397036e-01f, 9.96751785e-02f, 9.20690522e-02f, 3.75009067e-02f, -5.01065217e-02f, -1.99709117e-01f, -3.41084860e-02f, -2.05065176e-01f, 1.29245192e-01f,
  -1.62570581e-01f, 2.10769802e-01f, -3.13072652e-01f, -2.09974125e-01f, -3.60145420e-01f, -3.20337772e-01f, -1.62709460e-01f, -2.01161429e-02f, -6.14698976e-02f, 7.78676346e-02f,
  -1.46174237e-01f, -3.70364249e-01f, -2.40198255e-01f, -6.33114949e-02f, 2.83679485e-01f, 1.83858335e-01f, 5.44192828e-02f, -1.06963711e-02f, 9.31175426e-02f, -1.56018198e-01f,
  3.13651301e-02f, -9.67149287e-02f, 1.12464443e-01f, 5.29366508e-02f, 1.99128385e-03f, 1.10033996e-01f, 2.13766247e-01f, -1.34355262e-01f, -6.13135509e-02f, 1.68587770e-02f,
  7.11942986e-02f, -5.31771518e-02f, 3.56628485e-02f, -1.00977927e-01f, 7.70696774e-02f, 1.39624625e-01f, 9.39071253e-02f, 1.68172523e-01f, -2.37816330e-02f, -2.48101074e-02f,
  4.12728153e-02f, 2.15496317e-01f, 1.37771085e-01f, -1.50072547e-02f, -6.83348402e-02f, -7.12891147e-02f, -4.26155701e-02f, 1.46619841e-01f, 2.04563200e-01f, 4.29858640e-03f,
  4.19006310e-02f, 4.55512591e-02f, -1.47277778e-02f, -3.78839299e-02f, -8.70983228e-02f, -3.06835845e-02f, -1.51605168e-02f, 3.50838043e-02f, -3.51784155e-02f, 5.96747398e-02f,
  -3.82516496e-02f, 4.94333506e-02f, -5.73371956e-03f, -1.15260981e-01f, 3.17194201e-02f, 1.09193519e-01f, 2.84121577e-02f, 4.99396324e-02f, -6.35041669e-02f, 6.27200454e-02f,
  -8.46032873e-02f, -5.05986251e-03f, -1.25941277e-01f, 1.28591314e-01f, -6.21476993e-02f, -1.43505752e-01f, -3.10899131e-02f, 1.63993258e-02f, -1.04311623e-01f, -9.49061476e-03f,
  -4.16018796e-04f, -1.69973373e-01f, -6.83303475e-02f, -2.70461431e-03f, -1.19899154e-01f, 6.17152080e-03f, 6.84919059e-02f, -7.10799769e-02f, 1.19262245e-02f, -5.93401901e-02f,
  9.24585909e-02f, 1.74561851e-02f, 1.19032323e-01f, -8.64722673e-03f, -1.03215449e-01f, -1.02077812e-01f, 4.76618484e-02f, 1.45268008e-01f, 1.69889722e-02f, 1.30357027e-01f,
  5.91624640e-02f, 3.54253836e-02f, -3.22308354e-02f, -7.15432502e-03f, 2.66385507e-02f, 7.25241452e-02f, 4.86974418e-02f, -3.11878771e-02f, 7.93101788e-02f, -3.86210419e-02f,
  2.41218716e-01f, 2.07601145e-01f, 2.58132249e-01f, 2.78121769e-01f, -2.43484437e-01f, -7.67508969e-02f, 6.37060776e-02f, 4.85896738e-03f, 2.54254907e-01f, -2.28835791e-01f,
  -3.04316521e-01f, 3.00273240e-01f, -2.09668964e-01f, 9.60699469e-02f, 3.10643077e-01f, -2.05583885e-01f, 1.76387534e-01f, -1.53512834e-02f, -3.57930399e-02f, 7.99917653e-02f,
  1.57043219e-01f, -2.77130336e-01f, 1.81485444e-01f, -1.40904620e-01f, 2.32081071e-01f, 3.90083343e-01f, 8.97860080e-02f, 2.50077397e-01f, 3.44157249e-01f, 1.63978785e-01f,
  -1.59929156e-01f, 5.64252064e-02f, -5.74036650e-02f, 2.30562016e-02f, -1.85262635e-02f, 8.87525007e-02f, 7.83745572e-02f, 1.22138597e-01f, 1.60685390e-01f, -4.61887680e-02f,
  -8.33597109e-02f, 1.41165718e-01f, 1.56834096e-01f, 6.00002520e-02f, 3.03285234e-02f, 2.54443049e-01f, 5.27854897e-02f, -1.03236906e-01f, 1.62521712e-02f, -6.31421432e-02f,
  7.44182542e-02f, 7.83430412e-03f, 1.23375310e-02f, 2.33679339e-01f, 6.71431050e-02f, 6.44383719e-03f, 1.27024844e-01f, 1.69794559e-01f, 1.38750091e-01f, 1.20193712e-01f,
  -2.65555322e-01f, -6.33985996e-02f, -3.91165260e-03f, 1.35846794e-01f, 1.17287494e-01f, 8.23762268e-02f, -4.00033966e-02f, -1.77149642e-02f, 1.02408510e-02f, -2.48942077e-02f,
  4.32282453e-03f, -1.50596015e-02f, -1.36922561e-02f, 7.32687861e-02f, -1.47460639e-01f, -1.20872691e-01f, 1.92790538e-01f, 1.75049603e-01f, 5.45976758e-02f, -1.26666099e-01f,
  -5.19124977e-02f, 1.51836649e-01f, 5.29131480e-02f, -5.19951843e-02f, 1.19185932e-02f, 1.43686004e-04f, 3.64547670e-02f, 1.81395009e-01f, -2.58504182e-01f, 6.52839895e-03f,
  -1.88615546e-01f, 2.66605038e-02f, -1.07530273e-01f, -1.24404550e-01f, -1.40332058e-01f, -8.30708817e-02f, 1.44890219e-01f, -1.42359063e-02f, 1.70701742e-01f, -1.75679158e-02f,
  -1.04599662e-01f, -4.70037200e-02f, -2.90873758e-02f, -3.90068591e-02f, 2.87107583e-02f, -4.87692729e-02f, 6.42635003e-02f, 8.37552641e-03f, -3.55814472e-02f, -8.30659568e-02f,
  -6.35771304e-02f, -9.84912142e-02f, -7.44392052e-02f, 5.41682690e-02f, -1.92863181e-01f, -9.40605178e-02f, 1.44280180e-01f, 7.09294202e-03f, -2.80859414e-03f, 1.35590918e-02f,
  -4.96840835e-01f, 2.64616907e-01f, 1.29865974e-01f, -3.54366034e-01f, -1.57568902e-02f, 4.89748362e-03f, -3.63334179e-01f, 1.69717252e-01f, -1.24817282e-01f, 1.56597540e-01f,
  -1.63151190e-01f, -5.26178814e-02f, 3.11622441e-01f, -2.37754926e-01f, 1.17063493e-01f, 3.71791184e-01f, -9.80798900e-02f, -9.30823162e-02f, -1.90256406e-02f, -1.09899975e-01f,
  -7.77835175e-02f, -1.87461615e-01f, 1.11747235e-01f, 1.95950195e-01f, -2.16052875e-01f, -3.61356214e-02f, -2.78695464e-01f, -9.00431722e-02f, -2.18241766e-01f, -1.75884757e-02f,
  -2.19021395e-01f, -9.81639773e-02f, -1.62563503e-01f, 9.69383344e-02f, 4.90507744e-02f, -4.05860171e-02f, -1.56277671e-01f, -6.37681708e-02f, -1.96639802e-02f, -1.55277131e-02f,
  -1.12367580e-02f, 5.66859767e-02f, 2.60775760e-02f, 6.05909377e-02f, 9.40116763e-04f, -5.38696945e-02f, 1.54636413e-01f, 3.24977264e-02f, -1.68320574e-02f, -1.65472999e-02f,
  1.21807434e-01f, 2.42679585e-02f, -1.90038849e-02f, -3.23400870e-02f, -6.56016544e-02f, -9.01447237e-02f, -2.50364449e-02f, 5.69451489e-02f, 3.74273509e-02f, -1.97425601e-03f,
  4.67004813e-02f, -4.62244870e-03f, 1.69190504e-02f, 2.56207734e-02f, -9.93782207e-02f, -2.20414549e-02f, 2.97591761e-02f, -7.12258369e-02f, -2.88807489e-02f, 4.98991236e-02f,
  -7.65004456e-02f, -2.99251322e-02f, 1.69429705e-02f, 1.59249961e-01f, -1.07974119e-01f, 3.37095819e-02f, 3.71331908e-02f, 8.55318531e-02f, 5.56767546e-02f, 1.75931692e-01f,
  1.11911194e-02f, 4.65694844e-04f, -1.23899318e-02f, -3.93351950e-02f, 1.25055611e-01f, 9.67240036e-02f, 1.45439133e-01f, 4.19646427e-02f, 1.05186246e-01f, -1.76585689e-02f,
  -1.83199063e-01f, -9.34616476e-02f, -1.20284474e-02f, -1.46753863e-01f, -5.33848554e-02f, 1.21492609e-01f, 6.61988463e-03f, 2.09877137e-02f, -1.21584810e-01f, 1.08156420e-01f,
  4.14193720e-02f, 5.36239613e-03f, 2.38245819e-02f, -3.42676193e-02f, 2.73005124e-02f, 7.46155456e-02f, -5.66787086e-02f, 4.62129861e-02f, -1.68789625e-01f, 3.23957801e-02f,
  -3.45203765e-02f, -8.47820379e-03f, -3.36182043e-02f, 4.12537158e-02f, -1.03817880e-01f, -1.28035411e-01f, 8.26733932e-02f, -3.04360650e-02f, 3.79704870e-02f, 1.13880700e-02f,
  -3.86455990e-02f, -6.66415617e-02f, -5.77632450e-02f, 3.49074602e-01f, -1.99229717e-01f, -1.75032496e-01f, -3.03583354e-01f, -2.92108476e-01f, 7.30921775e-02f, -2.72008359e-01f,
  -1.21102557e-01f, 1.48594126e-01f, -4.06320006e-01f, 3.39209527e-01f, 2.81125724e-01f, -1.82073280e-01f, 1.34978011e-01f, 1.24258511e-01f, 7.17222039e-03f, -1.24001339e-01f,
  1.10919215e-01f, 2.66544282e-01f, 3.98392901e-02f, 2.00248420e-01f, -4.14112061e-02f, 2.80256152e-01f, 2.12188184e-01f, 2.53845360e-02f, 3.34281892e-01f, 2.40597650e-01f,
  -1.73771270e-02f, 2.70865448e-02f, 1.87708791e-02f, 1.22874059e-01f, -7.95901567e-02f, -1.21351920e-01f, 2.47876570e-02f, -1.71138961e-02f, -4.63061780e-02f, 2.21245214e-02f,
  3.60430032e-02f, 1.06878899e-01f, 1.00125402e-01f, 4.15511839e-02f, 4.71706055e-02f, 2.32174620e-01f, 9.06690657e-02f, -6.34743869e-02f, -8.30315873e-02f, -8.20859745e-02f,
  -4.51455303e-02f, -1.00688068e-02f, 2.68301461e-02f, 1.42765984e-01f, 1.34989798e-01f, 5.71864843e-02f, 1.91392317e-01f, -3.15144695e-02f, 1.72158599e-01f, 7.99416527e-02f,
  6.99462518e-02f, -1.12252245e-02f, -5.70108555e-02f, -8.49513635e-02f, 6.99181631e-02f, 7.15743424e-03f, 1.42850401e-02f, 2.13420624e-03f, 2.77377199e-03f, 9.30827782e-02f,
  1.00742981e-01f, 8.56638700e-02f, 7.44813010e-02f, 4.11371514e-02f, 5.99703752e-02f, -3.85331996e-02f, -1.49416909e-01f, 6.20176084e-02f, -3.63334678e-02f, 5.47869653e-02f,
  -1.14461326e-03f, 6.35659769e-02f, -1.63360480e-02f, -5.30229360e-02f, -1.11311592e-01f, -5.96676543e-02f, 5.88757470e-02f, 3.74723691e-03f, -1.24267869e-01f, -1.57615334e-01f,
  7.19055757e-02f, 3.40757579e-01f, -6.81809559e-02f, 1.32015601e-01f, 4.87808324e-02f, 1.32328216e-02f, 1.10659441e-02f, 6.90336451e-02f, 1.85957357e-01f, 6.70303106e-02f,
  1.38674285e-02f, 8.36293995e-02f, 8.20228606e-02f, 1.39264073e-02f, 9.52472240e-02f, -3.02369315e-02f, 3.25606689e-02f, 1.30684048e-01f, 1.29396290e-01f, 6.14153780e-02f,
  3.03062461e-02f, -2.28948176e-01f, 4.92740646e-02f, 1.90627594e-02f, 1.95881026e-03f, 3.08166519e-02f, -7.33179450e-02f, 4.88446131e-02f, 6.68832986e-03f, 6.35071248e-02f,
  -2.68533051e-01f, 3.61206025e-01f, 1.23906024e-01f, -2.32199535e-01f, -3.09644379e-02f, 3.66270304e-01f, -1.10144198e-01f, -3.06368456e-04f, -2.06011042e-01f, -1.70364052e-01f,
  -2.44524747e-01f, -1.92579571e-02f, 2.43192583e-01f, -9.01855901e-02f, 4.14907098e-01f, 2.56088555e-01f, 8.06195289e-03f, -1.74501240e-01f, 1.32275894e-01f, -9.51702939e-04f,
  1.45344123e-01f, -1.31502196e-01f, 1.91620350e-01f, 1.20172843e-01f, -1.64897397e-01f, -7.16171935e-02f, -1.80622652e-01f, 5.30877635e-02f, -2.81842262e-01f, -3.61324809e-02f,
  5.01079895e-02f, -5.89354411e-02f, 3.16016227e-02f, -5.66156842e-02f, -1.08942799e-01f, -2.01847553e-01f, -1.99453570e-02f, 6.17221296e-02f, -1.35770872e-01f, -7.29687838e-03f,
  -1.69151038e-01f, 7.34731108e-02f, -1.77877158e-01f, -2.11577322e-02f, -2.09551841e-01f, -3.01623754e-02f, 6.41142279e-02f, -1.10403568e-01f, 9.26668197e-02f, -9.35429521e-03f,
  9.01288986e-02f, 7.95795768e-02f, -1.80781275e-01f, -7.11048618e-02f, 4.52650897e-02f, -1.53414860e-01f, 8.15314054e-02f, -1.00100622e-01f, 9.43831429e-02f, -9.42108221e-03f,
  -4.34595942e-02f, -1.08543240e-01f, -7.24444762e-02f, 7.66798854e-03f, 1.37533829e-01f, -4.43190755e-03f, 2.04849746e-02f, -6.21931367e-02f, 2.82714888e-02f, -9.19824317e-02f,
  -1.60727784e-01f, -9.76284891e-02f, -1.03704043e-01f, -7.01407492e-02f, 1.99796837e-02f, -1.86420500e-01f, -4.19052765e-02f, 2.67062541e-02f, -5.26801087e-02f, -1.75090015e-01f,
  3.02975476e-02f, 9.35648233e-02f, 3.56629975e-02f, -2.65781656e-02f, -1.53987333e-01f, -5.99713847e-02f, -5.12832701e-02f, 2.08288003e-02f, -7.86021575e-02f, 2.21005678e-01f,
  1.09361317e-02f, 1.86558008e-01f, 3.92212942e-02f, 4.08701859e-02f, -2.04865020e-02f, 6.74175844e-02f, 1.38722301e-01f, -6.97755115e-03f, 6.83585405e-02f, 7.79996114e-03f,
  -1.28234535e-01f, -8.77920464e-02f, -1.34446234e-01f, -1.79961577e-01f, 1.00754522e-01f, -1.68639421e-02f, 4.39541116e-02f, 1.55316619e-02f, -2.52920873e-02f, -3.88631113e-02f,
  6.41587153e-02f, -5.21878116e-02f, 1.45781606e-01f, -2.39485741e-01f, -1.37548596e-01f, -1.80308312e-01f, 1.15626212e-02f, -4.43084054e-02f, -9.75315943e-02f, -1.52204454e-01f,
  -2.31676772e-01f, 4.06537563e-01f, -1.26376361e-01f, 2.41421774e-01f, -1.71421126e-01f, 3.53510320e-01f, 3.95366818e-01f, 8.60032160e-03f, 1.49500653e-01f, 4.02107358e-01f,
  -5.43972366e-02f, 4.19387743e-02f, 5.71373440e-02f, 3.95175554e-02f, -2.45518818e-01f, 2.11845651e-01f, 4.49783653e-01f, 3.82025212e-01f, -2.95295417e-02f, 1.41420618e-01f,
  -1.08342759e-01f, 2.33909506e-02f, -9.64376554e-02f, 7.23074749e-02f, -6.20027743e-02f, -3.71790305e-02f, -4.90279645e-02f, -1.42251343e-01f, 7.13387728e-02f, -1.16738997e-01f,
  5.58003224e-02f, -2.86434218e-02f, -2.26986594e-02f, -8.34976435e-02f, -5.09189330e-02f, 3.21382657e-02f, 1.32896110e-01f, -1.33321643e-01f, -1.16645440e-01f, 4.94736284e-02f,
  1.01241969e-01f, 1.55917797e-02f, 5.82384095e-02f, -1.07792959e-01f, -2.92122047e-02f, 7.91878067e-03f, -1.02266841e-01f, -1.40241891e-01f, 3.47725907e-03f, -8.10300410e-02f,
  -1.39588252e-01f, -6.43045232e-02f, 4.88422252e-02f, 1.30894436e-02f, -1.11724414e-01f, 1.10220306e-01f, 1.52408704e-01f, -3.04881893e-02f, 2.65391897e-02f, 4.63566594e-02f,
  -4.74256910e-02f, 3.59104276e-02f, 4.67227101e-02f, -6.22335523e-02f, -8.11508447e-02f, 1.31365377e-02f, -1.62040219e-02f, -4.13789712e-02f, 1.20058972e-02f, 1.21275848e-02f,
  -6.49131015e-02f, 1.69615466e-02f, -2.40216088e-02f, 1.05573200e-01f, 8.49949345e-02f, -9.18154046e-02f, -3.79585624e-02f, -2.38546319e-02f, -4.38839756e-03f, -6.42568171e-02f,
  5.95765747e-02f, 1.18306344e-02f, 2.35639997e-02f, 4.11764607e-02f, 7.78916627e-02f, -1.09684211e-03f, 7.45303347e-04f, -8.17962363e-02f, -1.47943301e-02f, 9.08353776e-02f,
  1.53654844e-01f, 4.20301676e-01f, -1.39109911e-02f, -6.28865212e-02f, 3.96907851e-02f, -7.79410750e-02f, 7.66225010e-02f, 7.05145374e-02f, 1.02587961e-01f, 1.86075382e-02f,
  2.85603926e-02f, 1.22022264e-01f, 4.11057137e-02f, -1.36101916e-01f, -5.25997207e-02f, 1.22556120e-01f, 8.63550305e-02f, -8.20582639e-03f, 6.24075048e-02f, -3.50120962e-02f,
  -1.06330670e-01f, 1.51692599e-01f, -2.35305307e-03f, 9.32745542e-03f, -6.93128398e-03f, 8.57830048e-02f, 1.02850117e-01f, -9.60807353e-02f, -3.25555056e-02f, 1.12921916e-01f,
  1.88588008e-01f, 1.10173887e-02f, -1.03187136e-01f, -3.84012498e-02f, 4.33198921e-02f, 2.12993287e-02f, 1.90136611e-01f, -3.56027409e-02f, 3.46319340e-02f, 2.58358300e-01f,
  -4.95494343e-02f, 4.38151769e-02f, -1.31336063e-01f, -3.59164089e-01f, -4.66371119e-01f, -4.15389240e-01f, -8.01619366e-02f, 4.90287952e-02f, 1.78185627e-02f, 1.65573642e-01f,
  3.16129625e-03f, -1.64791778e-01f, -3.26886624e-01f, 1.40389472e-01f, 1.75710052e-01f, 2.60073155e-01f, 3.28346044e-02f, 1.64637238e-01f, 7.38057075e-03f, -1.20169647e-01f,
  3.82489264e-02f, -1.50487140e-01f, 2.11524963e-02f, -8.28458592e-02f, -1.19330427e-02f, 1.43880516e-01f, 3.10356859e-02f, -1.04794919e-01f, -2.69163288e-02f, -1.14663341e-03f,
  9.94067118e-02f, -7.46318102e-02f, -1.78547800e-01f, -4.81449552e-02f, 1.60127610e-01f, 1.45250916e-01f, -7.04154596e-02f, 6.26783669e-02f, 6.75266460e-02f, 5.26917987e-02f,
  -6.96376804e-03f, 8.26520398e-02f, 1.67264119e-01f, -1.10888548e-01f, -2.41539478e-02f, -1.04842365e-01f, 1.60991605e-02f, -1.31336479e-02f, 1.47017702e-01f, -1.63833752e-01f,
  -1.16599677e-02f, 7.37653300e-02f, -7.73774236e-02f, 2.66665239e-02f, -8.36196076e-03f, -6.06654510e-02f, 1.14896707e-01f, 6.63569719e-02f, -3.27928830e-03f, 1.16027541e-01f,
  3.62177044e-02f, 4.17941138e-02f, -2.82250568e-02f, 1.08454138e-01f, 2.73650475e-02f, 1.18605956e-01f, -3.37265022e-02f, 5.02335839e-03f, 3.51134613e-02f, -3.50430980e-02f,
  -1.36464406e-02f, 3.32150310e-02f, -4.45060842e-02f, 1.15529515e-01f, -4.22617868e-02f, -1.44098386e-01f, -2.39258166e-02f, -1.38237536e-01f, 6.73176870e-02f, 1.85618460e-01f,
  5.06020337e-02f, 3.15285176e-02f, -7.25818500e-02f, -6.73241019e-02f, 5.77597395e-02f, 5.43829836e-02f, -6.97789863e-02f, -1.20644942e-01f, 3.11211199e-02f, -5.69134988e-02f,
  7.32565224e-02f, 2.85674542e-01f, 1.22177720e-01f, -7.76505172e-02f, -4.56954762e-02f, -3.62904891e-02f, 1.22683705e-03f, 1.11900173e-01f, 7.55653903e-02f, -4.33141068e-02f,
  2.57866144e-01f, 1.93758354e-01f, 1.24562271e-01f, 1.55354086e-02f, 1.72747225e-01f, -2.11924482e-02f, 1.52637690e-01f, 3.87092903e-02f, 1.24657795e-01f, -2.27484275e-02f,
  1.03128873e-01f, -4.13870215e-02f, 1.49101987e-01f, 2.63932884e-01f, 2.07584873e-02f, -3.04887950e-01f, -1.91606864e-01f, 7.76101351e-02f, 2.10482210e-01f, -3.39004874e-01f,
  -2.01640040e-01f, -7.41944388e-02f, -3.56626302e-01f, 1.41819447e-01f, 2.73112029e-01f, -9.00952742e-02f, 2.82517165e-01f, -1.49615720e-01f, 1.05060160e-01f, 1.11664563e-01f,
  2.45916009e-01f, 1.60506442e-01f, 2.69636482e-01f, 1.45100489e-01f, 1.24602675e-01f, 2.73209244e-01f, 3.23578179e-01f, 1.56775206e-01f, 2.20138520e-01f, 7.43249133e-02f,
  -1.44032270e-01f, 4.56097350e-02f, 1.37467593e-01f, 1.81805119e-02f, 1.29512370e-01f, -1.29909098e-01f, -7.54912794e-02f, -9.56360102e-02f, 3.65471020e-02f, 2.97370795e-02f,
  -5.36711402e-02f, -3.18988264e-02f, 2.93527148e-03f, 1.18222227e-02f, 6.74146935e-02f, 1.70915574e-01f, -1.07877804e-02f, 6.83964714e-02f, 3.15812379e-02f, -8.32853690e-02f,
  9.01325643e-02f, 4.74234894e-02f, 1.05172254e-01f, 4.87227961e-02f, 2.06232190e-01f, 1.16768681e-01f, 7.26384751e-04f, 7.21119791e-02f, 9.56565067e-02f, 1.41925067e-01f,
  -1.30546361e-01f, 3.78538929e-02f, -5.11219492e-03f, -2.92878598e-03f, 1.41805574e-01f, 1.20306745e-01f, 7.40336403e-02f, -3.54503095e-02f, 1.65920913e-01f, 4.91278432e-02f,
  1.55732349e-01f, 1.25760868e-01f, -2.13682745e-02f, -1.09956086e-01f, 1.41795818e-02f, -1.72204655e-02f, 5.55535965e-03f, -1.04461879e-01f, 4.01054062e-02f, 2.35170648e-02f,
  4.31287922e-02f, -2.47000735e-02f, -3.58072594e-02f, -1.12913236e-01f, -9.94709134e-02f, 2.64886469e-02f, -1.00600004e-01f, -3.48906033e-04f, 8.46036710e-03f, 1.63057595e-01f,
  4.63307661e-04f, 1.32070601e-01f, 1.10495307e-01f, -6.82989508e-02f, 1.62023567e-02f, -3.62043120e-02f, 3.63150463e-02f, -4.84595262e-02f, 1.70572579e-01f, -5.06401807e-02f,
  -5.66546135e-02f, 1.00840954e-02f, -6.97715357e-02f, -1.61723733e-01f, -9.91715938e-02f, -5.79961715e-03f, 6.92908466e-02f, 1.22298829e-01f, 9.70351994e-02f, -8.71910229e-02f,
  -1.60727557e-02f, -8.89717042e-02f, 1.29787266e-01f, 1.82847291e-01f, -7.69208074e-02f, 2.90965904e-02f, -9.36450437e-02f, 5.91011271e-02f, 1.05441459e-01f, -3.11142225e-02f,
  -5.65938175e-01f, -5.83072826e-02f, -4.96319346e-02f, -2.69880593e-01f, 2.44109213e-01f, 4.16207373e-01f, -1.81853220e-01f, 2.86018550e-02f, -3.76629651e-01f, 1.89419445e-02f,
  1.03818193e-01f, -2.32149377e-01f, -1.36226848e-01f, 1.34574994e-01f, 1.71459019e-01f, -4.69930433e-02f, 1.03662312e-01f, -5.37641943e-02f, -5.29848859e-02f, -2.07672909e-01f,
  -1.46240015e-02f, 2.88269967e-01f, 6.11596508e-03f, 1.07020780e-01f, 5.82484193e-02f, -9.64538753e-02f, -2.53577214e-02f, 6.77885190e-02f, 2.22519621e-01f, 1.09470285e-01f,
  -8.01183134e-02f, -3.87495786e-01f, -2.75689304e-01f, -2.14093804e-01f, -8.94456133e-02f, -6.87710270e-02f, -5.39212488e-02f, -3.89310941e-02f, 6.01259507e-02f, -1.32600982e-02f,
  -5.26712164e-02f, 4.02815118e-02f, 1.30775690e-01f, -7.07814768e-02f, -7.61364698e-02f, 2.55571138e-02f, 2.33291406e-02f, 7.16514289e-02f, 3.59379849e-03f, -2.95130238e-02f,
  -2.92017069e-02f, 9.21870098e-02f, 3.91953960e-02f, 8.59094709e-02f, 9.98619497e-02f, 6.88539445e-02f, 6.35737702e-02f, -7.10585564e-02f, 1.82390064e-01f, 6.39160872e-02f,
  7.02255126e-03f, -8.26366246e-03f, 3.18918638e-02f, -1.42173273e-02f, -6.58316985e-02f, 1.49119236e-02f, 9.22513008e-02f, 1.07966505e-01f, -8.42355862e-02f, 4.28541237e-03f,
  1.31375685e-01f, -2.73749861e-03f, -2.45064739e-02f, -2.99561769e-02f, -4.02889997e-02f, 6.58543333e-02f, 8.48725885e-02f, -1.23729948e-02f, 4.91142981e-02f, 1.51143849e-01f,
  -7.29320347e-02f, -3.80411595e-02f, -6.76048994e-02f, 1.34018719e-01f, 4.47282530e-02f, -7.48083442e-02f, 5.49891591e-03f, 4.89238314e-02f, -1.09827019e-01f, -4.28844765e-02f,
  -3.31115246e-01f, -3.08386296e-01f, -1.21092699e-01f, 9.73616019e-02f, -5.92752546e-02f, -7.67713711e-02f, -2.95002107e-03f, 1.06539369e-01f, -2.73122992e-02f, -1.47470742e-01f,
  -3.49567533e-02f, -1.81896950e-03f, 3.87758352e-02f, -1.05001286e-01f, -2.77073458e-02f, 4.03053127e-02f, -6.51281774e-02f, -5.47087453e-02f, -7.86093548e-02f, 5.51529452e-02f,
  -7.26043358e-02f, 1.95405930e-02f, 9.67224985e-02f, 1.77395403e-01f, 5.07012941e-02f, -1.18765552e-02f, -8.37769639e-03f, -8.34788457e-02f, 1.68218210e-01f, 1.28825605e-01f,
  2.49296635e-01f, 8.04699957e-02f, 2.57386625e-01f, 3.05178463e-01f, -3.33244234e-01f, 2.74699125e-02f, 1.67126745e-01f, -2.84204364e-01f, 3.30710530e-01f, 2.02085033e-01f,
  -1.04995869e-01f, 1.83709592e-01f, -1.18888147e-01f, 1.57326996e-01f, -1.51952699e-01f, 1.65753618e-01f, 1.77682459e-01f, 2.38302380e-01f, -3.31186838e-02f, -1.86545208e-01f,
  -7.02520134e-03f, -2.31837839e-01f, 3.97845432e-02f, -4.09733325e-01f, -1.11646369e-01f, -4.21592779e-02f, -2.30668172e-01f, -1.86519533e-01f, -2.08368953e-02f, -2.03275502e-01f,
  -2.51223207e-01f, -1.22879490e-01f, 1.39081001e-01f, 9.05797035e-02f, -3.12837213e-02f, 5.91911189e-02f, -3.39033231e-02f, -1.32147048e-04f, -8.96900594e-02f, 5.59574999e-02f,
  9.09603462e-02f, -9.07228068e-02f, -6.57534376e-02f, -5.63528948e-02f, 2.46728566e-02f, -3.40386219e-02f, 6.28894642e-02f, 1.83168352e-01f, 4.25722413e-02f, 1.15043886e-01f,
  1.97755262e-01f, 1.06817476e-01f, 1.13084473e-01f, 5.43386675e-02f, 2.48464569e-02f, 1.93099640e-02f, 1.70273066e-01f, 9.21094138e-03f, 2.53101178e-02f, 2.98023261e-02f,
  1.31914422e-01f, 2.91996845e-03f, 5.05258292e-02f, -6.27061799e-02f, 3.32751637e-03f, 4.88636084e-02f, -1.07399814e-01f, -9.31821838e-02f, 8.31977278e-02f, -1.10803820e-01f,
  -3.26650143e-02f, -1.91779062e-02f, -8.12374577e-02f, 5.47847487e-02f, -2.33721267e-02f, 1.38881370e-01f, 9.68088359e-02f, -3.35962623e-02f, 1.00669742e-01f, 8.93926919e-02f,
  8.53721872e-02f, -1.26290962e-03f, -8.85297135e-02f, 3.89285684e-02f, 2.19480842e-02f, -8.19694996e-02f, 5.34435473e-02f, 1.89809665e-01f, 8.14043656e-02f, -1.04774438e-01f,
  -4.45225954e-01f, -2.53453285e-01f, -4.42959443e-02f, 2.55925283e-02f, -4.16794121e-02f, -7.51755089e-02f, 2.42514652e-03f, -2.18512099e-02f, -2.60518581e-01f, -1.09279212e-02f,
  -1.14313606e-02f, 5.13947681e-02f, -8.74600336e-02f, -5.51151559e-02f, -8.53005275e-02f, -1.08614683e-01f, -1.07317142e-01f, -1.16404509e-02f, -1.20691516e-01f, -1.63020745e-01f,
  8.31390470e-02f, -8.83794501e-02f, -2.93412246e-02f, 4.82967459e-02f, 1.71063930e-01f, -5.49205244e-02f, -9.79800522e-02f, -2.66835634e-02f, -6.79140761e-02f, 5.41733168e-02f,
  2.13109061e-01f, -1.60675019e-01f, -3.59661430e-01f, -1.92892656e-01f, 2.83471018e-01f, 3.47768575e-01f, -8.79123658e-02f, 1.43551573e-01f, -1.53685182e-01f, 5.84666803e-02f,
  2.29227364e-01f, -1.54628139e-02f, -3.23006749e-01f, 1.52825609e-01f, 1.32027954e-01f, -3.95234913e-01f, 2.25499526e-01f, 1.76674649e-01f, -2.43470296e-01f, 2.73813009e-01f,
  1.18556343e-01f, 2.46994346e-01f, -7.65171573e-02f, 3.56262654e-01f, 1.65226847e-01f, 2.29668543e-02f, 2.03234553e-01f, -6.95159882e-02f, 2.15715423e-01f, 1.33215383e-01f,
  4.98951860e-02f, -2.21652165e-02f, -5.91266751e-02f, 3.68017294e-02f, -1.89014233e-03f, 1.81870237e-02f, 4.67754453e-02f, 3.93475816e-02f, -6.64044619e-02f, 2.49186978e-02f,
  4.97602485e-02f, 2.48683710e-02f, 1.02185704e-01f, -2.77087595e-02f, 8.06341022e-02f, 4.01468538e-02f, -7.84456059e-02f, -9.93132964e-02f, -1.08572371e-01f, 5.01571484e-02f,
  -1.57414675e-01f, -3.29826884e-02f, -1.65334232e-02f, -1.29880771e-01f, -1.94296092e-02f, -1.16978353e-02f, -8.58653150e-03f, 1.06874026e-01f, -7.26276040e-02f, 1.84116051e-01f,
  2.24400312e-02f, -8.97404645e-03f, 4.72058803e-02f, -9.66483206e-02f, -1.09442892e-02f, -8.14217776e-02f, -6.62861988e-02f, -1.14955017e-02f, 6.74181134e-02f, 6.30359799e-02f,
  -7.00626001e-02f, 8.86712316e-03f, 1.04411259e-01f, -3.44249676e-03f, 8.37375000e-02f, -9.72933546e-02f, -1.76938307e-02f, 3.82740274e-02f, 7.41022686e-03f, -1.60654008e-01f,
  -1.60363421e-01f, 7.64107555e-02f, 4.39357869e-02f, -9.36390832e-03f, -6.23496026e-02f, 1.58932373e-01f, 7.85851106e-03f, -7.27632595e-03f, -2.67787483e-02f, 1.81438755e-02f,
  5.46254031e-02f, 8.43633935e-02f, 2.37581916e-02f, -6.79973364e-02f, 8.29895120e-03f, 9.74223241e-02f, -4.02267091e-02f, 8.07330012e-03f, 4.01271246e-02f, 5.09619229e-02f,
  1.07081354e-01f, -1.05527975e-01f, 2.47599445e-02f, 1.53516522e-02f, 6.53013960e-02f, 1.45149723e-01f, 7.61395618e-02f, -4.61550280e-02f, 3.49113047e-02f, 1.04288466e-01f,
  -5.82101233e-02f, 7.92739540e-02f, 1.71648841e-02f, -9.23607945e-02f, -4.06737952e-03f, -5.05095087e-02f, 9.53114778e-03f, 1.21362619e-01f, -9.62524861e-02f, -4.24409285e-02f,
  -5.04079498e-02f, -3.25828135e-01f, 5.90426363e-02f, -1.32913709e-01f, -1.10285237e-01f, 1.01976059e-01f, 1.42182902e-01f, -1.37266114e-01f, -3.04386199e-01f, -2.54377872e-01f,
  -1.87900946e-01f, 4.29928079e-02f, 1.41401991e-01f, -3.82538825e-01f, 4.27516371e-01f, 9.33733806e-02f, -1.76474005e-01f, -5.27206622e-02f, -2.61484951e-01f, -2.14880615e-01f,
  -1.26904845e-01f, -3.52974564e-01f, 1.67387929e-02f, -3.64356369e-01f, -2.96173036e-01f, -2.92393118e-01f, 1.17534675e-01f, -4.77135135e-03f, -2.25755066e-01f, -3.09922956e-02f,
  -3.22813004e-01f, -3.23178679e-01f, -2.67408602e-02f, -9.43242535e-02f, -3.04982513e-02f, 1.27804372e-03f, 1.37696087e-01f, 1.38603851e-01f, -1.46725342e-01f, 3.70946415e-02f,
  1.80263460e-01f, -5.21455929e-02f, -1.00318536e-01f, 2.09421646e-02f, -9.74882916e-02f, -1.15329362e-01f, -7.93322548e-02f, 3.77166905e-02f, -9.71248280e-03f, 3.05509754e-02f,
  2.52183918e-02f, -5.16714714e-02f, -8.11616033e-02f, 1.22891374e-01f, 1.94224063e-02f, -1.26985297e-01f, 5.32274172e-02f, 4.17638868e-02f, 2.87218858e-02f, -1.25151888e-01f,
  6.61266595e-02f, 5.12998179e-02f, -4.02494371e-02f, 3.62398177e-02f, -8.52749944e-02f, -4.92422841e-03f, 1.31672844e-01f, 2.48251343e-03f, -3.54161710e-02f, 1.37431212e-04f,
  -7.65304118e-02f, 3.13072689e-02f, -6.40023872e-02f, -9.59689450e-03f, 1.54149020e-02f, 8.54304209e-02f, 2.96622347e-02f, -6.65293932e-02f, -1.34816498e-01f, 3.12619545e-02f,
  -3.82696055e-02f, 4.55270819e-02f, -1.05636597e-01f, 8.16222280e-02f, 7.23581314e-02f, -1.78027749e-02f, -8.13092813e-02f, 4.81943712e-02f, -5.48159406e-02f, 1.13806330e-01f,
  -1.57009214e-01f, -1.15914829e-01f, -1.55947000e-01f, -6.17546923e-02f, 2.37297770e-02f, -3.51559408e-02f, -1.78609397e-02f, -1.29868492e-01f, 7.95100406e-02f, 5.96066155e-02f,
  6.98493868e-02f, -8.11535940e-02f, 1.20525494e-01f, -2.27559749e-02f, 1.19688893e-02f, -7.34292045e-02f, 7.20153302e-02f, 4.30078320e-02f, 2.04725176e-01f, -9.33578610e-02f,
  -1.69909000e-02f, -2.05886997e-02f, 9.51795354e-02f, -6.34386837e-02f, -8.24825019e-02f, 7.21402839e-02f, 8.67683962e-02f, 1.96144357e-02f, 9.75070596e-02f, -8.06381553e-02f,
  2.73326308e-01f, -1.32629290e-01f, -2.40786389e-01f, -1.04900263e-01f, -1.18356980e-01f, -3.15476060e-01f, -2.65940666e-01f, -2.41917133e-01f, 1.39591489e-02f, -7.72348493e-02f,
  -4.86870930e-02f, -5.35954759e-02f, 2.18452469e-01f, -1.80672571e-01f, 1.34989053e-01f, 2.49875948e-01f, -3.12710851e-01f, -1.75914541e-01f, -1.00229622e-03f, -1.96547046e-01f,
  7.29542598e-02f, 8.59169662e-02f, -3.92442979e-02f, -1.65995017e-01f, -1.07881330e-01f, -5.00084199e-02f, 5.79322502e-03f, -6.81048185e-02f, -2.36360922e-01f, -7.63775110e-02f,
  7.46122301e-02f, 1.57992959e-01f, -4.46876995e-02f, -6.55087903e-02f, 2.21540071e-02f, 1.49006853e-02f, -1.50696307e-01f, 8.06890279e-02f, 1.08888686e-01f, -8.57117698e-02f,
  -3.21345218e-02f, 2.39646100e-02f, -5.69369420e-02f, 1.66591734e-01f, 3.51858363e-02f, -9.23976973e-02f, -7.14108646e-02f, -6.01616688e-02f, -1.00069948e-01f, 7.40467310e-02f,
  8.31762794e-03f, -1.13133252e-01f, -5.76072410e-02f, 7.16288090e-02f, 5.36251180e-02f, 1.06804207e-01f, -1.05007686e-01f, -1.03461668e-01f, -1.70260109e-02f, 7.77612478e-02f,
  5.30776232e-02f, 1.35308104e-02f, 8.01408589e-02f, 1.11138158e-01f, 2.30412222e-02f, -5.50024658e-02f, -1.02823572e-02f, -9.63584855e-02f, -1.56752802e-02f, -7.41981119e-02f,
  -6.04067557e-02f, 1.30044715e-02f, 6.28950968e-02f, -1.35249430e-02f, -3.38561535e-02f, -5.16090766e-02f, -4.57902178e-02f, -4.94079432e-03f, -2.14945212e-01f, -1.59980237e-01f,
  5.21385856e-02f, 7.06957206e-02f, -3.53389047e-02f, -1.04091421e-01f, -1.53998402e-03f, 3.06349783e-03f, -4.17523459e-02f, 3.59253474e-02f, -5.54357544e-02f, -3.35567109e-02f,
  -1.03058845e-01f, -1.71841662e-02f, -1.06558368e-01f, 9.50057246e-03f, -1.06678896e-01f, 5.42775281e-02f, -4.87732235e-03f, -8.36470053e-02f, 5.98933063e-02f, 1.36835885e-03f,
  -1.26861930e-01f, -7.32719377e-02f, -1.46560669e-01f, 1.49807287e-02f, -7.68944547e-02f, -5.22523820e-02f, -6.99362978e-02f, -5.35585806e-02f, -1.72695413e-01f, -1.28930762e-01f,
  -3.88312861e-02f, -3.40521298e-02f, -1.79502591e-02f, -3.25036459e-02f, -1.40016198e-01f, -3.10769193e-02f, -5.76733937e-03f, 8.93639699e-02f, 1.64772689e-01f, -1.39476195e-01f,
  -2.76462674e-01f, 3.58212471e-01f, 3.41369882e-02f, -1.82907656e-01f, 1.23787811e-02f, 8.52181464e-02f, 8.78148377e-02f, 1.95450604e-01f, 2.66778022e-01f, 3.86005305e-02f,
  -8.88168141e-02f, 1.06342891e-02f, 9.62076709e-02f, -6.71969876e-02f, -2.17094392e-01f, 1.04675628e-03f, -2.86454093e-02f, -2.47947201e-02f, 3.20200652e-01f, -9.05183926e-02f,
  -6.85640126e-02f, -3.54992539e-01f, -1.76833838e-01f, -6.91486895e-02f, -1.36063561e-01f, 1.52429968e-01f, -2.63024598e-01f, 2.09416643e-01f, -2.01248974e-01f, 8.42641965e-02f,
  1.12665027e-01f, 1.44234255e-01f, -2.52331211e-03f, 1.58645540e-01f, 6.72213435e-02f, -3.92589904e-03f, 4.50195670e-02f, -7.01880082e-02f, 1.32429630e-01f, 1.94092263e-02f,
  -1.13604032e-02f, 1.08474633e-03f, 9.73080546e-02f, -1.94952279e-01f, -7.36806309e-04f, 2.55634561e-02f, 7.40167350e-02f, -3.58633101e-02f, 2.15808842e-02f, -5.04181646e-02f,
  -5.38395457e-02f, -2.05040257e-02f, -3.28967012e-02f, 1.02863654e-01f, -1.06396317e-01f, 8.01670477e-02f, -1.63518693e-02f, -1.21231906e-01f, -4.10087928e-02f, 2.37227157e-02f,
  -4.10014996e-03f, 1.71474203e-01f, -1.07464410e-01f, -8.00537411e-03f, 3.39741223e-02f, 1.65483594e-01f, 1.38067171e-01f, -2.46528089e-02f, 7.05319420e-02f, 4.36009131e-02f,
  6.32404611e-02f, 3.63057926e-02f, 1.15754068e-01f, -4.36775535e-02f, -8.24649483e-02f, -8.01494867e-02f, -1.38595760e-01f, 1.41473591e-01f, 2.75643226e-02f, -5.78766577e-02f,
  -1.70386687e-01f, 3.04761454e-02f, 1.74570587e-02f, 6.83756024e-02f, -7.11180046e-02f, -3.33056860e-02f, -1.70857430e-01f, -1.10222273e-01f, 2.72684135e-02f, -4.81194071e-02f,
  1.50393263e-01f, 2.24006683e-01f, 1.52705789e-01f, 2.29274571e-01f, 1.44700348e-01f, -1.76096648e-01f, 2.68768575e-02f, 1.35114416e-02f, 1.63541555e-01f, 6.51579127e-02f,
  -9.47635174e-02f, 1.03648379e-01f, 3.19563858e-02f, -5.50978212e-03f, -8.08897242e-02f, -9.61529538e-02f, -3.00544500e-02f, 1.04821496e-01f, 5.94136491e-02f, -6.75033219e-03f,
  -9.55113918e-02f, -8.71470422e-02f, -8.55438262e-02f, 6.00883141e-02f, -7.41375387e-02f, -6.67193606e-02f, -2.07234882e-02f, -4.95929830e-03f, 1.52723901e-02f, 1.43402278e-01f,
  2.46432200e-01f, 8.42594057e-02f, 1.24945775e-01f, 5.41532278e-01f, -9.11651477e-02f, -2.33644769e-01f, -8.17460641e-02f, 1.80685759e-01f, 4.48842883e-01f, -1.00875692e-02f,
  -5.86718544e-02f, 4.20963913e-02f, -6.12425245e-02f, -9.33017358e-02f, -6.20192513e-02f, 9.09088328e-02f, 2.68316478e-01f, 1.44283503e-01f, 2.39258677e-01f, 8.81738961e-02f,
  2.26544276e-01f, -1.67865038e-01f, -1.87520340e-01f, -2.32209712e-01f, -1.79141060e-01f, 1.78525701e-01f, -2.66947359e-01f, -1.21732846e-01f, -1.04636542e-01f, -2.65170038e-01f,
  -7.53285065e-02f, 1.74234807e-01f, -1.18799806e-01f, -1.75939910e-02f, 1.16239354e-01f, -1.38346553e-01f, 7.61333853e-02f, -1.09397806e-01f, -3.30494195e-02f, 5.42655326e-02f,
  8.73048156e-02f, 3.57147865e-02f, 5.59801608e-02f, -6.16629906e-02f, -4.05606143e-02f, -5.20101562e-02f, 2.83418261e-02f, 1.02214189e-02f, -9.06450897e-02f, -2.19767001e-02f,
  -1.03115194e-01f, 2.10894234e-02f, -9.98004377e-02f, 1.89235136e-02f, 6.89516813e-02f, 1.67795289e-02f, -1.08851634e-01f, -7.32969716e-02f, -5.02316318e-02f, 1.16305873e-01f,
  1.22167766e-01f, 1.46437800e-02f, -7.23829940e-02f, -7.07642958e-02f, 9.27237980e-03f, -3.11023034e-02f, 2.08391771e-02f, -7.18336999e-02f, 7.82389119e-02f, -6.24946840e-02f,
  -2.17705388e-02f, 1.22268088e-02f, -2.24468298e-02f, -5.65161407e-02f, 1.54191628e-01f, 1.93613730e-02f, -9.13529322e-02f, 3.54981944e-02f, 5.70563041e-02f, -1.24737164e-02f,
  1.98227279e-02f, -8.47955495e-02f, -1.08793944e-01f, -1.76327489e-02f, -3.17746066e-02f, 6.15965053e-02f, 8.26002285e-02f, 9.34789032e-02f, 6.55877888e-02f, -1.26531363e-01f,
  2.18598284e-02f, 2.32700467e-01f, 8.23667571e-02f, -7.64520243e-02f, -9.06440523e-03f, -1.46377683e-01f, 9.00888070e-02f, 1.13159664e-01f, -2.47780923e-02f, -2.01292196e-03f,
  2.16692258e-02f, 4.25645858e-02f, -3.22131328e-02f, 2.81768367e-02f, 1.41615199e-03f, -1.41488358e-01f, 2.17517139e-04f, 9.68686864e-02f, -6.12930842e-02f, 1.59579203e-01f,
  -1.07341714e-01f, 2.84582581e-02f, 8.34238604e-02f, 1.77336335e-02f, -1.39439970e-01f, 3.36146019e-02f, 4.36458923e-02f, -1.20644979e-01f, -5.29360026e-02f, -6.99812640e-03f,
  -1.77753240e-01f, 3.58825400e-02f, -3.06932867e-01f, -1.18302241e-01f, 1.11075938e-01f, -3.55596542e-01f, -3.61855567e-01f, -7.46357143e-02f, -1.31949574e-01f, -1.35787129e-01f,
  -3.47914286e-02f, 1.87749445e-01f, -1.13628358e-01f, -1.65890187e-01f, -1.21839140e-02f, 3.06029659e-04f, -2.87304342e-01f, -5.48613034e-02f, 9.26446542e-02f, -1.54443905e-01f,
  3.66972312e-02f, 5.25636040e-02f, -1.38882905e-01f, 6.83445632e-02f, -2.33445302e-01f, 3.69932316e-02f, 2.81451736e-02f, 2.95497067e-02f, -1.80416368e-02f, 1.80586830e-01f,
  3.53841577e-03f, -2.06054792e-01f, -5.26670516e-02f, -7.01989755e-02f, -1.01740010e-01f, -3.05176806e-02f, -8.43653455e-02f, 6.08680360e-02f, -1.76283240e-01f, -6.02937639e-02f,
  -2.48155631e-02f, 3.47073227e-02f, 4.16629873e-02f, 1.84125468e-01f, -6.16192482e-02f, 6.47546425e-02f, -1.25770578e-02f, -4.03446071e-02f, -5.05749099e-02f, -5.80595108e-03f,
  -2.33801343e-02f, -1.20542765e-01f, -7.83684626e-02f, -7.94616565e-02f, 1.02701440e-01f, -4.04620543e-02f, -4.95053120e-02f, -5.74828461e-02f, -8.01882222e-02f, -1.40031483e-02f,
  -9.12452936e-02f, -9.96549055e-02f, -1.57158915e-02f, 1.52299300e-01f, -7.10308328e-02f, 6.13034852e-02f, 3.69136520e-02f, 5.69702014e-02f, -8.99362285e-03f, -3.70393880e-02f,
  6.84934929e-02f, 5.41347042e-02f, 1.94614939e-02f, -1.58398405e-01f, -5.01902588e-02f, -1.90125071e-02f, -2.57827155e-02f, 4.04397473e-02f, -3.04410607e-02f, -7.34417662e-02f,
  7.86257461e-02f, -1.23551086e-01f, -5.95979393e-02f, 7.32165501e-02f, -1.79803506e-01f, -8.52242857e-02f, 6.12322651e-02f, -1.75980538e-01f, -7.38082593e-03f, 6.73527271e-02f,
  -5.53981513e-02f, -3.80667657e-01f, -3.49360555e-02f, -6.82902262e-02f, 7.03009889e-02f, -9.43684299e-03f, 6.26094267e-02f, 5.91891445e-02f, -1.89431548e-01f, -6.79764897e-02f,
  -1.35093898e-01f, 2.26369575e-02f, -1.79475080e-02f, 3.12252855e-03f, 2.26667263e-02f, -8.71824920e-02f, 7.14996234e-02f, 5.66355474e-02f, 3.66005935e-02f, 4.07864414e-02f,
  8.27244744e-02f, -9.00698006e-02f, 9.12038758e-02f, -4.12975028e-02f, 2.62013860e-02f, -3.40359606e-04f, 2.63050850e-02f, 1.58068240e-01f, 5.03793918e-02f, 9.57838818e-03f,
  -2.18579546e-01f, -3.24820913e-02f, -2.85789371e-01f, -3.62553298e-01f, 2.26428002e-01f, -3.02414805e-01f, -2.84606606e-01f, -8.29981118e-02f, -3.65148149e-02f, 2.30676696e-01f,
  -1.22606166e-01f, -1.54691085e-01f, 1.46516323e-01f, -3.00307184e-01f, -4.07925189e-01f, -2.31572986e-01f, -4.26196784e-01f, -1.91357836e-01f, -5.71554266e-02f, -6.66614249e-02f,
  -1.72421977e-01f, -2.83795089e-01f, -1.99217826e-01f, 2.12833628e-01f, -9.50554609e-02f, 1.62929341e-01f, 3.18040073e-01f, 2.10273206e-01f, -2.32693329e-01f, -1.22087613e-01f,
  -1.81466147e-01f, -6.76620603e-02f, -9.64961667e-03f, -1.18277311e-01f, -1.93385184e-02f, 7.40099326e-02f, 7.60299852e-03f, 4.78638969e-02f, -8.82686526e-02f, -2.11248901e-02f,
  3.50214206e-02f, 1.05323847e-02f, -1.18287265e-01f, 8.14668760e-02f, 7.49031529e-02f, -4.12228070e-02f, 2.84382328e-02f, -4.09276970e-02f, -1.04090385e-01f, -2.18532488e-01f,
  -1.05690546e-01f, -4.14462835e-02f, -1.62538886e-03f, -3.78779098e-02f, -2.38985606e-02f, 2.97518522e-02f, -2.00482290e-02f, 2.86185462e-02f, 4.50610332e-02f, -3.68884616e-02f,
  6.31164461e-02f, 7.07996711e-02f, 3.45492400e-02f, -5.57063743e-02f, -1.01814657e-01f, -2.71671638e-02f, 7.94684291e-02f, -5.91504946e-02f, 5.92221655e-02f, 5.60232773e-02f,
  7.95475319e-02f, 7.78681338e-02f, 2.43011545e-02f, -2.44970005e-02f, -8.56480673e-02f, 3.40095884e-03f, -1.03099272e-02f, 4.88154590e-03f, -1.28566772e-02f, 6.20588288e-02f,
  6.82481304e-02f, 1.34807210e-02f, -2.66932361e-02f, -2.19432525e-02f, -4.41089878e-03f, 6.82797059e-02f, 6.30297437e-02f, -1.16320901e-01f, 5.71962893e-02f, 9.20610651e-02f,
  2.76874099e-02f, 1.40579656e-01f, 5.75357042e-02f, 7.81037733e-02f, 3.32179070e-02f, 4.51387353e-02f, 6.02501631e-03f, -6.82213381e-02f, 4.93180268e-02f, 4.54079695e-02f,
  4.17649979e-03f, 1.89807359e-02f, 1.14699751e-01f, -4.30217348e-02f, -3.52137089e-02f, -4.10460904e-02f, 2.38245502e-02f, 8.90258476e-02f, 4.78049479e-02f, 1.10108957e-01f,
  7.41322860e-02f, 9.46599692e-02f, -1.92182399e-02f, 7.27069452e-02f, 1.38234258e-01f, 1.49816591e-02f, 1.09316252e-01f, 1.84725840e-02f, -8.67587794e-03f, 2.15211473e-02f,
  -1.88037321e-01f, 3.78659785e-01f, -3.75832766e-01f, 7.60074779e-02f, -1.40757887e-02f, 4.52447861e-01f, 4.35036302e-01f, 1.57884419e-01f, 2.62938231e-01f, 3.92758518e-01f,
  1.65947795e-01f, 2.52730668e-01f, 1.27058150e-02f, 4.06754017e-01f, 2.04271734e-01f, 2.24946395e-01f, 3.97774696e-01f, 2.64951795e-01f, 1.77966096e-02f, 1.46572918e-01f,
  -1.90864783e-02f, 3.76400113e-01f, -2.67449200e-01f, -1.54004274e-02f, 5.31560592e-02f, -2.79962540e-01f, -7.81738460e-02f, -2.39908934e-01f, 8.73012394e-02f, 1.42924204e-01f,
  6.50369972e-02f, -1.32927507e-01f, -1.22581780e-01f, -8.52284804e-02f, -1.31788015e-01f, -1.91242188e-01f, -1.98483631e-01f, -7.54076391e-02f, -7.95918927e-02f, 5.08476235e-02f,
  3.06418957e-03f, -8.48586783e-02f, 2.59587504e-02f, 2.41934024e-02f, 3.36544998e-02f, -3.93750481e-02f, -9.75224655e-03f, 2.27374602e-02f, 3.70546244e-02f, -6.33731782e-02f,
  -7.40625039e-02f, 3.66413444e-02f, -2.06701402e-02f, 1.57437757e-01f, 1.92544945e-02f, 1.29210651e-01f, -2.54818443e-02f, -1.85314473e-02f, 4.54347916e-02f, 1.09521121e-01f,
  1.14487842e-01f, 3.86207104e-02f, -3.64849307e-02f, -5.90217151e-02f, 2.96645332e-02f, 1.41442930e-02f, 4.46737260e-02f, -2.83936877e-02f, -8.77718851e-02f, 4.41384614e-02f,
  1.00021940e-02f, -8.06367919e-02f, 4.33040317e-03f, -2.12365072e-02f, 9.22324695e-03f, 6.97482675e-02f, -2.27011088e-02f, 2.36626286e-02f, 1.77505277e-02f, -6.62764311e-02f,
  -3.49606574e-02f, 7.17286691e-02f, 4.98998091e-02f, -1.31563902e-01f, 1.22545302e-01f, -1.71841774e-02f, 4.27998081e-02f, -9.53285396e-03f, -1.35401627e-02f, -2.37999801e-02f,
  2.18494251e-01f, 3.79186958e-01f, 2.32733041e-02f, 5.71323223e-02f, 3.53354737e-02f, 6.65776655e-02f, 2.71197483e-02f, 5.21575958e-02f, 1.90915391e-01f, 5.97669370e-02f,
  -1.00486996e-02f, 4.01381403e-02f, 4.75191791e-03f, -5.35224266e-02f, -1.07012913e-02f, 3.31257842e-02f, -2.80074719e-02f, 2.27409117e-02f, 1.14644103e-01f, 5.44325411e-02f,
  -1.93820242e-02f, -1.62502471e-02f, 3.95947956e-02f, -9.62136835e-02f, 1.99388922e-03f, 5.37013039e-02f, 1.64514109e-01f, -2.86152717e-02f, 2.21939515e-02f, 8.36146027e-02f,
  3.33528847e-01f, -3.70374203e-01f, 1.38344184e-01f, 3.09321731e-01f, 3.17669690e-01f, 1.11157216e-01f, 2.62889981e-01f, -1.64896533e-01f, 1.03131942e-01f, -3.87820810e-01f,
  -1.94284096e-01f, 3.41486856e-02f, -1.57498598e-01f, -3.54157500e-02f, 4.45166618e-01f, -1.19382158e-01f, 1.37747377e-01f, 1.49798274e-01f, 1.13356985e-01f, -1.17192350e-01f,
  1.73829332e-01f, -4.13390633e-04f, 1.78433016e-01f, -1.91671684e-01f, 2.97314301e-02f, -7.49031678e-02f, -8.73270631e-02f, 2.07565099e-01f, -7.05981627e-02f, 2.35583395e-01f,
  -1.56357318e-01f, -2.73108687e-02f, 1.02325588e-01f, -3.44902836e-03f, -7.11571723e-02f, 3.12902890e-02f, 5.68062440e-02f, 1.14300571e-01f, 1.44373596e-01f, 2.38689035e-02f,
  -4.64682877e-02f, -5.25661111e-02f, 5.09699956e-02f, 9.74905640e-02f, 8.06275234e-02f, 2.75069270e-02f, 2.02476531e-02f, -1.47520512e-01f, 6.57216460e-03f, 4.24988073e-04f,
  -1.07185982e-01f, -9.49636847e-02f, -5.32402582e-02f, -6.35329485e-02f, 4.48365584e-02f, 7.99230039e-02f, 7.89172053e-02f, 1.17127091e-01f, -6.09540939e-02f, 1.18292242e-01f,
  1.71222135e-01f, 9.43569746e-03f, -5.86587228e-02f, 1.28085958e-02f, 9.19817761e-03f, 2.16003973e-02f, -2.57093087e-02f, -8.20548087e-03f, -2.84198858e-02f, -8.16125870e-02f,
  5.21298982e-02f, 3.00883129e-02f, 2.74725612e-02f, -1.72531437e-02f, -1.68157357e-03f, 1.95991639e-02f, 7.30867758e-02f, -1.11521244e-01f, 1.54629350e-02f, 4.88957241e-02f,
  -4.55729738e-02f, 1.19882850e-02f, -4.10855599e-02f, -2.92903837e-02f, 7.94838369e-02f, -1.14746289e-02f, -2.01745048e-01f, -9.25450027e-02f, 2.71683894e-02f, 4.41453755e-02f,
  -3.78403038e-01f, -3.76082063e-01f, -5.30640362e-03f, -1.18016809e-01f, -8.95372126e-03f, -1.46201821e-02f, -2.98765227e-02f, 2.33052974e-03f, -2.52388492e-02f, -6.58864006e-02f,
  -1.26103967e-01f, 5.68203675e-03f, -7.82936439e-02f, 4.28472757e-02f, 2.06770860e-02f, -1.17436513e-01f, 2.23900881e-02f, -5.15449978e-03f, 1.93113592e-02f, -8.48256350e-02f,
  -4.17567119e-02f, 5.01509011e-02f, 8.67060870e-02f, 4.28054184e-02f, -5.19871786e-02f, -1.52359530e-02f, 2.75640246e-02f, -3.79745141e-02f, -9.36133508e-03f, 3.15700248e-02f,
  -4.13396180e-01f, 2.13018253e-01f, 3.25203776e-01f, -2.40051925e-01f, -9.50544048e-03f, 4.52881098e-01f, 2.91498780e-01f, 1.37589246e-01f, -2.52208896e-02f, -7.64143988e-02f,
  -1.78945139e-01f, -1.94356069e-01f, 1.56071395e-01f, -7.95990005e-02f, 9.90696624e-02f, 3.06228012e-01f, 7.77202770e-02f, 9.92268398e-02f, 1.38313085e-01f, 2.75859646e-02f,
  -6.49600103e-03f, -9.98274311e-02f, 1.17011875e-01f, -6.35533631e-02f, -1.12769097e-01f, -1.51818767e-01f, -2.22035721e-01f, 2.00005844e-01f, -1.79281712e-01f, 4.61982451e-02f,
  5.73983751e-02f, 2.89755384e-03f, -3.26428749e-02f, 1.27960563e-01f, 7.51401782e-02f, 6.62728846e-02f, 6.78075552e-02f, 1.56664968e-01f, 1.76785830e-02f, -6.85464218e-02f,
  -6.65020421e-02f, -7.58274943e-02f, -7.96376020e-02f, 4.17581061e-03f, -1.37488380e-01f, -2.06200644e-01f, -3.40999737e-02f, 9.50736851e-02f, 6.27048761e-02f, 4.69351038e-02f,
  -2.17981171e-02f, 2.80906409e-02f, -4.08314690e-02f, -1.18099011e-01f, -8.08912292e-02f, -9.26857628e-03f, 1.49842739e-01f, 4.96141845e-03f, -8.83599967e-02f, -2.46350151e-02f,
  -5.85299097e-02f, 8.63798410e-02f, 8.16145465e-02f, 1.16516344e-01f, 1.92587264e-02f, -4.89303768e-02f, 9.05097835e-03f, -7.78816501e-03f, 4.28804867e-02f, -6.84754103e-02f,
  3.49998698e-02f, -2.60665012e-03f, 1.13636754e-01f, -4.92084138e-02f, -4.86130193e-02f, -1.07075796e-01f, -1.31945349e-02f, -3.86652746e-03f, -1.39083695e-02f, 3.11192814e-02f,
  2.40463950e-02f, -2.49984004e-02f, -9.80363116e-02f, 5.81686385e-02f, 1.30918488e-01f, 5.02570719e-02f, -3.58606018e-02f, -3.85205336e-02f, 5.61929047e-02f, -1.02974335e-02f,
  1.84609428e-01f, 1.08527489e-01f, 8.35011303e-02f, -6.44779131e-02f, 1.25042841e-01f, -9.95845571e-02f, 8.41845796e-02f, -2.53055897e-02f, 1.76229328e-02f, -1.11966059e-01f,
  -1.06167898e-01f, -1.08018098e-02f, -2.31265686e-02f, -4.99559268e-02f, -6.08665869e-02f, 3.73159684e-02f, 1.14324033e-01f, -5.95863238e-02f, 3.04417089e-02f, -1.12077214e-01f,
  -3.68853062e-02f, 5.13406023e-02f, -1.05122693e-01f, -1.60577610e-01f, -1.52978823e-01f, -9.45246294e-02f, 1.65987946e-02f, 7.84698054e-02f, -1.55276492e-01f, 5.28358780e-02f,
  4.01096463e-01f, -1.81727305e-01f, -4.07478273e-01f, 3.74018513e-02f, 1.60377890e-01f, 3.13196599e-01f, 3.61834168e-02f, 2.54033878e-02f, -1.59483746e-01f, -1.25395000e-01f,
  1.00256331e-01f, -2.00864851e-01f, -2.20685020e-01f, 3.15566689e-01f, 3.33300084e-01f, -1.96369112e-01f, 2.73423016e-01f, 1.65780261e-01f, -6.11474691e-03f, 1.71745513e-02f,
  9.19629857e-02f, 3.32627296e-01f, -9.98943597e-02f, 1.11130729e-01f, 2.73246109e-01f, -6.58878163e-02f, 2.88766157e-02f, -1.63441494e-01f, 9.90427509e-02f, 1.49351418e-01f,
  3.50963697e-02f, 1.80514567e-02f, -1.13694459e-01f, -7.88415447e-02f, 2.84728203e-02f, 1.12667359e-01f, 4.50317841e-03f, 5.41985594e-02f, -1.81912519e-02f, -2.97838282e-02f,
  -4.21062345e-03f, 1.08050548e-01f, 1.02436841e-01f, 4.29714005e-03f, 1.67188227e-01f, -4.49377447e-02f, -6.80440813e-02f, 1.96551662e-02f, -9.20322537e-02f, -6.84435852e-03f,
  -1.93650147e-03f, 4.05525416e-02f, 5.94912358e-02f, 5.77602535e-02f, -1.58805862e-01f, -2.09264569e-02f, -4.78631444e-02f, -1.66608110e-01f, 4.03923318e-02f, -4.09280546e-02f,
  -2.08492484e-02f, 1.02014959e-01f, 3.33981402e-02f, 1.09894490e-02f, 6.87748045e-02f, 2.44137994e-03f, 1.22809317e-02f, -6.88453168e-02f, -8.69019330e-03f, -1.48152774e-02f,
  -6.29515806e-03f, -3.83171774e-02f, 6.20768666e-02f, 2.61810776e-02f, 1.13225110e-01f, 1.39859691e-02f, 1.62661020e-02f, -8.68880972e-02f, -7.04013705e-02f, -1.07688479e-01f,
  -8.14205967e-04f, 3.26643921e-02f, -2.70769931e-02f, 3.33035402e-02f, 7.08560571e-02f, -1.06340438e-01f, 2.43933816e-02f, -2.15005893e-02f, -6.55641705e-02f, 5.81771806e-02f,
  -4.44074608e-02f, -1.71839282e-01f, -5.95403761e-02f, -4.23444919e-02f, -9.58279055e-03f, 1.44869640e-01f, 4.63544689e-02f, 4.38416600e-02f, -3.56882135e-03f, -1.94174591e-02f,
  -4.09983704e-03f, 4.90976423e-02f, -5.61529733e-02f, 5.14666326e-02f, 4.69438247e-02f, -1.28533673e-02f, -1.38675034e-01f, -1.16076335e-01f, -8.76941755e-02f, -3.37042175e-02f,
  -2.71109175e-02f, -2.07154863e-02f, -1.63303260e-02f, -7.92867169e-02f, -6.32012933e-02f, 2.23800223e-02f, -2.49253644e-04f, -4.85956408e-02f, 4.92406301e-02f, -1.55997604e-01f,
  -4.71568078e-01f, 1.40534922e-01f, -4.00838345e-01f, -3.35348487e-01f, 1.32481709e-01f, -2.28400096e-01f, -2.00080812e-01f, 1.89895928e-01f, -1.40284538e-01f, 2.61524647e-01f,
  1.70230165e-01f, -1.61043391e-01f, 1.96565911e-01f, -2.38549232e-01f, -3.66615325e-01f, -1.61042944e-01f, -3.23670536e-01f, -2.70311356e-01f, -1.14373818e-01f, 7.79616386e-02f,
  -1.66628674e-01f, 1.19686134e-01f, -3.83509815e-01f, 3.51727009e-01f, -1.53930793e-02f, 5.46167679e-02f, 2.37212658e-01f, 2.16309384e-01f, -2.03345433e-01f, -1.06089920e-01f,
  -1.97732434e-01f, 1.04618244e-01f, -1.55869480e-02f, -1.81599613e-02f, -5.88639639e-02f, 6.55025169e-02f, -1.81960892e-02f, -2.39060167e-02f, 2.29936671e-02f, -9.56597552e-02f,
  4.94633913e-02f, 6.93165138e-02f, 5.79593927e-02f, 9.16540474e-02f, 3.84160466e-02f, 3.55984196e-02f, -7.06183314e-02f, -1.20567799e-01f, -8.05727951e-03f, -1.33758813e-01f,
  -3.29585783e-02f, -9.45654139e-02f, -3.70711051e-02f, -7.52927661e-02f, -3.98120247e-02f, 1.01983227e-01f, -1.18727878e-01f, -2.72308029e-02f, -1.16027351e-02f, -1.19077183e-01f,
  4.70137224e-02f, -6.14426704e-03f, 2.49688737e-02f, 7.14885518e-02f, 5.78553267e-02f, 1.20686188e-01f, -1.96990045e-03f, 3.51491459e-02f, -4.91075814e-02f, -5.97137632e-03f,
  6.34614825e-02f, -3.26951481e-02f, 6.45023137e-02f, -4.30975668e-02f, -1.22587815e-01f, -8.20514858e-02f, -1.13372557e-01f, 7.33301640e-02f, -6.80272356e-02f, -1.00853786e-01f,
  7.10232556e-02f, -1.10708512e-02f, 5.18507995e-02f, 1.01381034e-01f, 2.68403478e-02f, -7.49952868e-02f, 1.82586629e-02f, -1.35128602e-01f, 6.52389973e-02f, -2.50442158e-02f,
  6.80013448e-02f, 1.52815819e-01f, 6.81955665e-02f, 7.65760019e-02f, -4.10823412e-02f, 2.15971954e-02f, -2.10017748e-02f, -4.71475534e-02f, -5.33436127e-02f, 5.67838661e-02f,
  6.18750043e-02f, 6.49308339e-02f, 1.28664359e-01f, -3.42672579e-02f, -9.18080360e-02f, -9.27647855e-03f, 5.33378534e-02f, -6.69876784e-02f, 3.35405208e-02f, 9.00503471e-02f,
  5.40046133e-02f, 1.24129005e-01f, -5.33212498e-02f, 1.72417518e-02f, -4.97089773e-02f, 4.49935719e-02f, 1.05904125e-01f, 3.53092365e-02f, -1.88324284e-02f, -7.55826011e-02f,
  1.81779325e-01f, -9.65018291e-03f, -4.11590874e-01f, -2.71543278e-03f, -2.56768525e-01f, 2.07045123e-01f, 4.80315059e-01f, -1.88590690e-01f, 8.57122913e-02f, 4.10764366e-01f,
  3.17783505e-01f, -9.39170457e-03f, 3.54846805e-01f, 3.97329062e-01f, 3.17928717e-02f, 4.01863307e-01f, 1.94558740e-01f, 1.84442326e-01f, -1.14151925e-01f, 1.19173244e-01f,
  -7.34130219e-02f, 2.68784970e-01f, -1.30153120e-01f, -5.57963140e-02f, -3.96047942e-02f, -3.59633207e-01f, -5.33010736e-02f, -2.21921816e-01f, -3.69874984e-02f, 5.42224310e-02f,
  8.15410819e-03f, 1.08772956e-01f, -8.87740105e-02f, -3.81242409e-02f, -9.66606196e-03f, 7.77373929e-03f, -6.41830564e-02f, -1.44052217e-02f, 6.63316920e-02f, 1.11961022e-01f,
  1.16061218e-01f, -4.14289832e-02f, 1.11128315e-01f, -5.24989553e-02f, 2.20260657e-02f, -4.43801656e-02f, -5.35159297e-02f, -3.01489793e-02f, -6.91626314e-03f, 2.18213592e-02f,
  7.88997114e-02f, -6.93426095e-03f, 6.61591664e-02f, 5.98926581e-02f, -1.02801576e-01f, -5.65749668e-02f, 2.15885174e-02f, -9.80887489e-05f, -3.70438658e-02f, -1.02971770e-01f,
  8.17380287e-03f, -1.63588207e-02f, 1.33796349e-01f, 1.23162782e-02f, -8.77453685e-02f, -9.45271701e-02f, 3.98350731e-02f, 3.71563546e-02f, -7.40421191e-02f, 8.45145881e-02f,
  2.80249789e-02f, -3.31076719e-02f, 5.57856634e-02f, 3.16575319e-02f, 9.20232758e-02f, 5.79496846e-02f, 8.74303579e-02f, -4.04517725e-03f, -2.51155719e-02f, -7.33094811e-02f,
  -1.03321381e-01f, 2.09602918e-02f, 8.13475698e-02f, -1.55564267e-04f, 4.57353285e-03f, -1.03293993e-02f, 8.21320489e-02f, -4.84958477e-02f, -4.73322682e-02f, -7.66201392e-02f,
  -1.57509223e-02f, 4.32563275e-02f, 4.43726033e-02f, 7.96163976e-02f, -3.13280113e-02f, 7.68224895e-02f, 1.17706329e-01f, 2.63847294e-03f, -7.57302269e-02f, 2.64333002e-02f,
  -1.64910890e-02f, 7.01755658e-02f, -4.88074124e-02f, 4.27616052e-02f, -3.47617222e-03f, 1.48177505e-01f, 2.40959153e-02f, -3.28994580e-02f, -6.73397556e-02f, -7.74543732e-02f,
  -6.64240420e-02f, -1.51766967e-02f, 1.10567547e-01f, 5.72495535e-02f, 5.17269298e-02f, 7.42470399e-02f, -4.62270565e-02f, -7.78931454e-02f, -3.50265279e-02f, -1.01565227e-01f,
  2.95985609e-01f, -4.79398131e-01f, 2.71391004e-01f, 1.83941394e-01f, 2.62507468e-01f, 1.10361390e-01f, 1.69515252e-01f, 3.21929925e-03f, -1.13228438e-02f, -3.31511468e-01f,
  3.80630083e-02f, -1.51672930e-01f, -1.62387908e-01f, -1.94979623e-01f, 4.50495869e-01f, -9.96006727e-02f, -2.00915992e-01f, -1.51414230e-01f, 1.73390895e-01f, -4.23309691e-02f,
  2.10860074e-01f, -1.83038071e-01f, 9.79409963e-02f, -2.37613425e-01f, -1.14301413e-01f, -1.11903377e-01f, 8.14524144e-02f, 6.92327768e-02f, -8.13992247e-02f, 1.00794807e-02f,
  -1.51521623e-01f, -1.22535206e-01f, -8.86656195e-02f, -5.36753125e-02f, 7.64849223e-03f, -1.98932588e-02f, 4.50255983e-02f, 5.16325906e-02f, 1.94043547e-01f, 6.98095709e-02f,
  9.17386543e-03f, 6.61978871e-02f, -7.59308040e-02f, -2.35836785e-02f, -7.17711775e-03f, 1.95648763e-02f, 1.27341319e-02f, 4.09890264e-02f, 1.35606918e-02f, 1.10162914e-01f,
  8.37780070e-03f, 8.75656083e-02f, 2.19428744e-02f, -6.74775988e-02f, 9.08547118e-02f, 3.69851738e-02f, 9.82511640e-02f, 3.87452543e-02f, -6.63347915e-02f, -8.32582451e-03f,
  1.38455406e-01f, -6.20249249e-02f, -2.44644731e-02f, 3.60873714e-02f, 4.62343842e-02f, 6.26904368e-02f, -5.95879136e-03f, 8.71050954e-02f, -4.44674753e-02f, -1.64512731e-03f,
  1.01911403e-01f, -2.01839413e-02f, 5.99456802e-02f, -4.11271118e-02f, -1.37905404e-02f, -1.69643480e-02f, 8.18044469e-02f, 2.66452692e-02f, -6.64368495e-02f, 2.07471903e-02f,
  9.52837244e-03f, 5.11581637e-03f, 2.32064985e-02f, 9.75416526e-02f, 1.94197968e-02f, 1.34432182e-01f, -1.20928921e-01f, 2.25338880e-02f, 1.07180603e-01f, 6.70914678e-03f,
  -6.18486404e-01f, -4.46618974e-01f, -1.12268575e-01f, -2.12862249e-02f, -2.99887899e-02f, -9.07753129e-03f, -4.79236580e-02f, -1.87983084e-02f, -1.90371156e-01f, -4.08630411e-04f,
  -4.40952554e-02f, -7.30724353e-03f, -1.07559450e-01f, 1.53878406e-02f, -1.80744797e-01f, -6.94649108e-03f, -8.36340785e-02f, -1.52438551e-01f, -2.43278965e-02f, -4.04091999e-02f,
  -9.99778211e-02f, 1.05673499e-01f, 2.10126620e-02f, -4.96139862e-02f, 4.95717973e-02f, 1.36939406e-01f, -7.58586153e-02f, 9.71035752e-03f, -1.44569133e-03f, -4.60626278e-03f,
  2.62282699e-01f, 4.11937922e-01f, 2.87048548e-01f, -9.85393971e-02f, -2.20010981e-01f, -2.30236903e-01f, -4.38537270e-01f, 1.29800469e-01f, -2.13280946e-01f, -4.83805016e-02f,
  -2.68709242e-01f, 1.08139209e-01f, -2.66923726e-01f, 1.21225193e-02f, 9.81360376e-02f, -1.85510874e-01f, 1.89265922e-01f, -9.18390676e-02f, 3.73450480e-02f, 1.61219880e-01f,
  1.14276201e-01f, -2.29500040e-01f, 1.76464379e-01f, 1.58793539e-01f, 7.33845402e-03f, 2.31491074e-01f, 1.05449073e-01f, -8.86931084e-03f, 1.73667267e-01f, -1.23783834e-01f,
  3.97496037e-02f, 3.71867372e-03f, 1.82184000e-02f, -9.96107757e-02f, 1.08495392e-02f, 2.06200946e-02f, 4.97605950e-02f, -7.05498904e-02f, -7.05736801e-02f, 2.85369847e-02f,
  1.44840479e-01f, -1.61408018e-02f, 9.49853472e-03f, -1.48955435e-01f, -2.80884877e-02f, -1.58419803e-01f, 6.67463057e-03f, 8.54512304e-02f, -1.08019054e-01f, 1.47075072e-01f,
  1.45198002e-01f, 2.19931632e-01f, 6.86249956e-02f, -2.13250443e-02f, 6.69939667e-02f, -6.08275831e-02f, 2.08192877e-02f, -6.02430403e-02f, 4.02849950e-02f, 3.50196660e-02f,
  6.16409145e-02f, -6.58960715e-02f, -6.37992993e-02f, 4.90924418e-02f, -9.77772772e-02f, -2.44156700e-02f, 2.93438993e-02f, 3.37257772e-03f, 1.02610178e-01f, 4.94060330e-02f,
  -3.37620378e-02f, -3.43055353e-02f, -1.94736734e-01f, -1.02302745e-01f, -1.26197100e-01f, -6.09354451e-02f, 4.25747521e-02f, -4.03198600e-03f, -1.26890466e-01f, 1.20594613e-01f,
  -1.36663452e-01f, -1.54399518e-02f, -1.29145488e-01f, 6.19846024e-02f, -1.89318880e-02f, 2.22653765e-02f, -8.80678222e-02f, -1.05710343e-01f, 1.84304297e-01f, 4.43505496e-02f,
  3.80433686e-02f, 1.80449963e-01f, 2.92171445e-02f, -1.79484084e-01f, -1.78464547e-01f, 1.19585395e-01f, -3.65847312e-02f, 1.22446910e-01f, 1.03766583e-01f, -1.44899666e-01f,
  9.56916735e-02f, 8.41389969e-02f, 1.08662695e-01f, 6.44321889e-02f, -7.19895735e-02f, 5.84721826e-02f, -2.01995429e-02f, -3.85661460e-02f, 2.36602388e-02f, 2.03177273e-01f,
  -2.19961666e-02f, -7.29533359e-02f, 1.31385416e-01f, 1.06153242e-01f, 3.25655155e-02f, 6.13575689e-02f, -1.87918544e-03f, -1.72621965e-01f, 1.19582660e-01f, -6.13944344e-02f,
  -5.58885979e-03f, -9.32870582e-02f, 4.09593046e-01f, 2.72778183e-01f, 2.91754276e-01f, 3.06204617e-01f, 1.92651302e-01f, 3.13347846e-01f, 5.66084445e-01f, -2.24952266e-01f,
  -1.64209843e-01f, -2.04774633e-01f, -3.17204654e-01f, 1.29242968e-02f, 9.34760049e-02f, -1.30525213e-02f, 1.84242368e-01f, -3.20110060e-02f, 1.70278475e-01f, -4.38274294e-02f,
  6.30791783e-02f, -1.83604404e-01f, -2.41054088e-01f, -6.73679858e-02f, -7.05448166e-02f, 1.48078188e-01f, -3.68437290e-01f, -9.13095623e-02f, -1.49160862e-01f, 1.02612510e-01f,
  -4.25386652e-02f, 3.73543017e-02f, -1.67416334e-01f, -3.27624604e-02f, -1.08325794e-01f, 1.23624593e-01f, 1.96343753e-02f, -1.44749835e-01f, 7.41443783e-02f, -2.71252934e-02f,
  -1.42121807e-01f, -6.51005236e-03f, -1.12352660e-02f, 4.45175171e-02f, 5.10901026e-02f, 3.38062532e-02f, 1.04438193e-01f, -5.30229555e-03f, 3.65550965e-02f, 5.81402779e-02f,
  -6.87561482e-02f, -1.75135210e-02f, 5.32787554e-02f, 1.37396306e-01f, -3.32701840e-02f, 9.16404277e-02f, 1.65381059e-02f, 9.26937014e-02f, -3.18495855e-02f, 1.04945861e-01f,
  2.92722099e-02f, 1.47614166e-01f, -1.38578817e-01f, 1.05776293e-02f, -6.56069592e-02f, -4.20787819e-02f, -1.46946296e-01f, -2.99629569e-02f, 1.10375255e-01f, -9.88909695e-03f,
  -5.25378175e-02f, -6.78690076e-02f, 1.32298961e-01f, 6.33533858e-03f, -7.88391083e-02f, 1.13139905e-01f, 4.65544015e-02f, 7.85581693e-02f, -6.40807673e-02f, -9.68323797e-02f,
  -8.65096748e-02f, 4.48000431e-02f, -8.26868415e-02f, -3.40606347e-02f, 4.80772071e-02f, -7.16934577e-02f, -5.27559128e-03f, 8.87755379e-02f, -5.45140319e-02f, -2.09166601e-01f,
  1.11477207e-02f, 7.75932148e-02f, -1.45055339e-01f, -2.13806808e-01f, -1.13188379e-01f, -9.49034169e-02f, 2.85839848e-02f, -1.89125948e-02f, -3.35260015e-03f, -5.39989062e-02f,
  -6.36951029e-02f, -1.78800542e-02f, -3.05167958e-02f, -2.06880420e-02f, -8.81443173e-02f, -9.36277807e-02f, -7.21314028e-02f, 6.32949099e-02f, -1.26536399e-01f, -1.21008325e-02f,
  -7.37717077e-02f, -4.44901288e-02f, -1.76633392e-02f, -4.74010482e-02f, 5.26562519e-02f, -1.05379231e-01f, 1.16338208e-02f, 4.00000326e-02f, 6.45614415e-02f, -2.79833619e-02f,
  1.00519806e-01f, 3.18386674e-01f, 1.55768827e-01f, -7.79855773e-02f, -2.75285304e-01f, 2.13811561e-01f, 1.55763216e-02f, 1.03251658e-01f, 2.51364589e-01f, 2.72425562e-01f,
  -2.55089283e-01f, 3.55907321e-01f, -3.43832350e-03f, -1.33143842e-01f, -1.89513624e-01f, -1.65912986e-01f, -8.80983621e-02f, -6.43453076e-02f, 2.78679915e-02f, -6.74111024e-02f,
  -9.28579047e-02f, -2.63179898e-01f, -1.92257896e-01f, -1.87737390e-01f, -2.46593244e-02f, 8.52294564e-02f, -3.71470749e-01f, -1.15159549e-01f, -1.98492743e-02f, -2.24858627e-01f,
  -2.11480204e-02f, -9.09348205e-02f, -2.33412832e-02f, 1.55124485e-01f, -8.80591385e-03f, 2.83707436e-02f, -1.12544201e-01f, -3.49923410e-02f, -1.07025959e-01f, 7.99683183e-02f,
  2.30404317e-01f, 6.57164752e-02f, 1.82981808e-02f, -1.48056941e-02f, 1.26428559e-01f, 9.11989212e-02f, 5.11386544e-02f, 1.02780975e-01f, 5.44737242e-02f, 4.05815896e-03f,
  3.97981964e-02f, 7.81666338e-02f, 1.33843079e-01f, 1.27338588e-01f, 2.36781370e-02f, -1.42500568e-02f, 3.91097739e-02f, 3.83914774e-03f, 6.59236982e-02f, 6.25122935e-02f,
  1.25171626e-02f, 8.37141201e-02f, 6.14462830e-02f, 4.89466004e-02f, -1.04828868e-02f, -4.48892526e-02f, -1.48414299e-02f, -7.63047487e-02f, 1.87910218e-02f, 1.64152458e-01f,
  9.00933594e-02f, -4.72953096e-02f, -1.38171583e-01f, 1.24475688e-01f, -8.68294165e-02f, 1.47787124e-01f, 1.27564576e-02f, 1.25079140e-01f, -3.06579396e-02f, -4.28675627e-03f,
  -1.73424054e-02f, -4.39470261e-02f, 4.38624946e-03f, -2.05834702e-01f, -7.31277689e-02f, 1.35646882e-02f, -1.01517839e-02f, -2.74322312e-02f, -1.97029039e-02f, -1.46149114e-01f,
  -2.39980184e-02f, 1.40768155e-01f, 9.32821408e-02f, 1.76319018e-01f, 3.56864370e-02f, 9.58450511e-03f, 4.40323651e-02f, 1.73595622e-01f, -6.34383708e-02f, 7.49483779e-02f,
  9.91626084e-02f, 4.70008068e-02f, 7.56065995e-02f, -5.03189825e-02f, -3.19554545e-02f, 6.83147237e-02f, -5.11982739e-02f, 7.40328878e-02f, -8.37859809e-02f, -8.54175314e-02f,
  5.86136319e-02f, 3.59900817e-02f, 1.05594702e-01f, 6.57226145e-02f, 3.67828794e-02f, 1.13200970e-01f, 1.77940175e-01f, -1.31188156e-02f, -9.28214341e-02f, -1.60541397e-03f,
  -1.29944563e-01f, -2.76501358e-01f, -2.64894187e-01f, 2.22165883e-01f, 3.71851176e-01f, -1.42616421e-01f, 9.43726450e-02f, 2.84993142e-01f, 4.78741527e-02f, 2.09035054e-02f,
  1.61532164e-02f, -4.77533817e-01f, -2.39235446e-01f, -2.82946885e-01f, -4.30320174e-01f, -3.44080597e-01f, -3.01319927e-01f, -2.49406099e-01f, -1.49188086e-01f, -9.93440598e-02f,
  7.96408430e-02f, 1.36763215e-01f, -1.24874763e-01f, 3.28680784e-01f, 1.91399232e-01f, 2.93438494e-01f, 2.41448686e-01f, 2.30299830e-01f, 3.91530804e-02f, -7.18771815e-02f,
  -1.42976701e-01f, 5.21478849e-03f, 1.09020360e-01f, -4.08423170e-02f, 1.38699010e-01f, 1.95778579e-01f, -3.50128338e-02f, -1.12975508e-01f, -7.44415149e-02f, -1.80596448e-02f,
  3.18474579e-03f, 2.89488751e-02f, -9.89959463e-02f, -5.80185987e-02f, 5.65809049e-02f, 1.14132784e-01f, -7.13039041e-02f, -4.07355018e-02f, 3.79160568e-02f, -1.50930613e-01f,
  -4.97838743e-02f, -3.87983508e-02f, -2.70045679e-02f, -1.00650355e-01f, -8.01850781e-02f, -6.95998669e-02f, 2.79763546e-02f, -2.55854931e-02f, -1.45994006e-02f, 7.11969733e-02f,
  7.79352561e-02f, 3.84738222e-02f, -1.84238944e-02f, -1.93582214e-02f, -7.88191892e-03f, 9.69345942e-02f, 1.79502312e-02f, -2.11100392e-02f, 2.82279793e-02f, 6.14789613e-02f,
  3.57391350e-02f, 1.12878896e-01f, -5.54999104e-03f, -3.24431472e-02f, 7.11547807e-02f, 4.72943187e-02f, -6.35165814e-03f, -6.58398941e-02f, 7.61929452e-02f, -2.90630688e-03f,
  6.67956918e-02f, 5.19985380e-03f, 4.01084684e-02f, 2.84712692e-03f, -8.25125445e-03f, -3.65718268e-02f, 5.86876879e-03f, -2.67835241e-02f, 3.12820785e-02f, 8.01378638e-02f,
  -5.12345619e-02f, 4.45850827e-02f, 3.57347839e-02f, 8.53693485e-02f, -4.56709079e-02f, 3.60905975e-02f, -1.22210972e-01f, 2.12263316e-02f, -1.17064402e-01f, -1.82493404e-02f,
  1.51020372e-02f, 1.18643880e-01f, 4.27147895e-02f, -2.93239020e-02f, 5.58543280e-02f, 1.78752076e-02f, 3.53919938e-02f, 2.83346139e-02f, 2.06565142e-01f, -3.99425030e-02f,
  2.09228128e-01f, 1.01838680e-02f, 1.71992049e-01f, 1.21033959e-01f, 1.91030242e-02f, 5.92273138e-02f, -2.80897394e-02f, -5.73148467e-02f, 4.92755212e-02f, -1.26356035e-01f,
  1.61482185e-01f, -1.97870642e-01f, 1.21980496e-01f, -2.32017711e-01f, -5.82750961e-02f, -1.60656139e-01f, 4.13985178e-02f, -3.01619262e-01f, -3.58499736e-01f, -1.17153123e-01f,
  -2.04400077e-01f, 2.16087535e-01f, 2.62213498e-01f, -1.85754791e-01f, 3.23935062e-01f, 2.29570538e-01f, -2.77165562e-01f, 6.18839301e-02f, -5.14193401e-02f, -2.05931678e-01f,
  -6.31862432e-02f, -3.25040996e-01f, 1.28220469e-01f, -1.62581310e-01f, -5.31659052e-02f, -4.73606922e-02f, 7.32431188e-03f, -7.76859149e-02f, -2.43970782e-01f, -6.96380995e-03f,
  -3.97399142e-02f, -5.88183664e-02f, 9.32222605e-02f, -2.58054910e-03f, -5.74032590e-02f, 1.08192161e-01f, 1.88833982e-01f, 3.28945592e-02f, -1.19144442e-02f, 4.42555919e-02f,
  1.18887551e-01f, -7.46142119e-02f, -1.69775963e-01f, 1.17146842e-01f, -1.29814237e-01f, -1.33547679e-01f, -3.72505561e-02f, 2.83952057e-03f, 2.02725232e-02f, 6.01637848e-02f,
  -3.17691527e-02f, 4.58871908e-02f, -1.54196750e-03f, -5.03866412e-02f, -1.13543130e-01f, -3.49118263e-02f, 1.25999361e-01f, 2.48962790e-01f, 5.68978824e-02f, -4.87224497e-02f,
  -5.92646226e-02f, 1.00915708e-01f, 1.59914792e-02f, -7.35629424e-02f, -7.10741058e-02f, -8.17981511e-02f, -2.46633086e-02f, -5.29731177e-02f, 3.93636897e-03f, -9.45951045e-02f,
  1.38289183e-02f, 5.94318919e-02f, 1.63711645e-02f, -8.30048472e-02f, -1.06935792e-01f, 8.01966041e-02f, 9.51865017e-02f, 5.61516806e-02f, -1.00998551e-01f, -5.37623279e-02f,
  -1.50651271e-02f, -4.94633391e-02f, -6.69556484e-02f, -7.22303987e-03f, 6.99454322e-02f, 9.94248539e-02f, -1.23438403e-01f, 2.44041067e-02f, 8.57440848e-03f, 8.34043398e-02f,
  -2.33949423e-02f, -2.33319506e-01f, -3.57583351e-02f, 9.84063372e-02f, 5.02268784e-02f, -1.29834842e-02f, 9.91951954e-03f, -1.48866534e-01f, 6.48808945e-03f, 4.05415446e-02f,
  -1.20423637e-01f, 8.44464600e-02f, -2.59874612e-02f, 1.56198675e-02f, -1.48715481e-01f, -1.10570602e-01f, -1.03647143e-01f, 8.79226923e-02f, -1.10785840e-02f, -7.32891783e-02f,
  -5.16891247e-03f, 5.26063368e-02f, -1.71028357e-02f, -6.78151473e-02f, 1.38261504e-02f, -5.59683610e-03f, 6.70729578e-02f, 4.82790470e-02f, 1.67497545e-02f, 9.16775502e-03f,
  -7.81117305e-02f, 1.40292183e-01f, 1.89972296e-01f, 2.63052851e-01f, -4.78231721e-02f, -2.74602264e-01f, -2.60499060e-01f, -4.57241051e-02f, -2.63305724e-01f, 1.55366622e-02f,
  -2.31065735e-01f, 2.32713357e-01f, -3.17486435e-01f, 2.74985135e-01f, -9.78000462e-02f, -4.48558688e-01f, 2.19073251e-01f, 4.76369113e-02f, -1.71341762e-01f, 2.45521277e-01f,
  5.07355034e-02f, -8.98514092e-02f, -6.34456752e-03f, 7.12008402e-02f, 1.57545432e-01f, 2.28110701e-01f, 1.96830779e-01f, -8.25961232e-02f, 2.62479842e-01f, 4.22354713e-02f,
  -3.51009741e-02f, -4.02062722e-02f, 4.09651622e-02f, 8.57341066e-02f, 2.46166121e-02f, 2.18851231e-02f, 1.44626498e-01f, 7.29374867e-03f, 3.84319685e-02f, 2.01557651e-02f,
  -1.75514016e-02f, 6.99126646e-02f, 3.18426266e-03f, -2.12934017e-02f, -2.83288416e-02f, 1.15620524e-01f, 2.40021329e-02f, 4.67678271e-02f, 9.22084898e-02f, -6.71619251e-02f,
  -1.10682910e-02f, 4.03647199e-02f, 8.03721845e-02f, 8.47852603e-02f, -5.16622625e-02f, 7.49752820e-02f, 1.61781296e-01f, 1.27479985e-01f, 3.65330540e-02f, 4.48475741e-02f,
  2.91102123e-03f, -2.65688282e-02f, -1.40507415e-01f, -9.58080441e-02f, -2.45567225e-02f, -2.33306549e-02f, -1.13163330e-01f, 8.57005082e-03f, -6.50747791e-02f, -7.33861327e-02f,
  5.07262163e-02f, -3.31223570e-02f, -2.10188553e-02f, 3.50073278e-02f, 2.26388182e-02f, -3.04533765e-02f, -5.33172153e-02f, 3.93346883e-02f, 5.12441620e-02f, -1.52157973e-02f,
  -7.85860792e-02f, -6.09843209e-02f, 4.97015892e-03f, -6.85219467e-02f, -8.42654705e-02f, -2.22180989e-02f, 1.13274112e-01f, 5.12089022e-02f, 4.02744114e-03f, -6.91544339e-02f,
  1.16778746e-01f, 2.23284125e-01f, 1.93787850e-02f, -1.41680790e-02f, 6.13278449e-02f, -4.12652176e-03f, -1.41619265e-01f, 1.00049205e-01f, 9.32114050e-02f, 1.21177752e-02f,
  1.81417212e-01f, -1.02266818e-01f, 5.42308427e-02f, 5.31082638e-02f, 8.92082825e-02f, -2.21176893e-02f, 8.57854337e-02f, 1.18604779e-01f, 8.01504850e-02f, 2.32382387e-01f,
  -5.66094508e-03f, 3.60472314e-02f, 4.23108637e-02f, -1.53159294e-02f, 5.86005300e-02f, 4.51566987e-02f, -3.50350477e-02f, 1.06303953e-03f, 1.76203791e-02f, 1.39494449e-01f,
  1.09011777e-01f, 3.76660615e-01f, 1.60820097e-01f, 4.78514060e-02f, -1.89012587e-01f, -1.61771670e-01f, -1.86770424e-01f, -1.35124817e-01f, 1.52918637e-01f, 2.46351287e-01f,
  -2.53047466e-01f, 2.70806164e-01f, 4.49079722e-02f, -6.62325993e-02f, -3.61114293e-01f, -6.59501404e-02f, -2.55234897e-01f, -1.57040004e-02f, 2.79788189e-02f, -3.02031748e-02f,
  -7.78407082e-02f, -2.25282669e-01f, -1.59071028e-01f, -9.21349078e-02f, -1.22085206e-01f, 6.94479346e-02f, -3.15903276e-01f, -3.81746739e-02f, -1.85506437e-02f, -1.22422263e-01f,
  -6.35503381e-02f, 1.88134104e-01f, 9.72278491e-02f, 1.03925675e-01f, -1.21468954e-01f, -1.33611877e-02f, 1.88459530e-02f, 9.24832374e-03f, -4.50034291e-02f, 1.65953308e-01f,
  9.42647904e-02f, 4.68193144e-02f, -3.08882501e-02f, 6.19831830e-02f, 8.23663175e-02f, -3.92167978e-02f, -2.64775287e-02f, -1.11483701e-01f, 7.07547143e-02f, 3.62433190e-03f,
  1.03757411e-01f, 3.42836529e-02f, -4.49423380e-02f, 8.21763873e-02f, 2.99893375e-02f, -4.75302972e-02f, 4.24724035e-02f, 1.28903329e-01f, 7.96919838e-02f, -1.83615778e-02f,
  1.43061668e-01f, -4.99208868e-02f, -6.19568489e-02f, -7.76488110e-02f, 1.23731606e-02f, 3.44291292e-02f, 1.16128027e-01f, -7.53732584e-03f, 7.23401201e-04f, -8.10163915e-02f,
  -7.29681272e-03f, 1.12034688e-02f, 1.13798156e-02f, -3.75862606e-02f, 6.68922532e-03f, 1.67806353e-02f, -1.35422453e-01f, 7.72823468e-02f, -3.84196378e-02f, -4.77841496e-02f,
  1.18785433e-01f, -1.04031682e-01f, 6.37240186e-02f, -6.43823892e-02f, -1.00847661e-01f, -7.51906249e-04f, -1.01614803e-01f, 7.32671618e-02f, -9.09924656e-02f, -1.57244816e-01f,
  -1.39594199e-02f, 9.60007831e-02f, 8.54470134e-02f, 3.03965732e-02f, -2.11278964e-02f, -8.45594555e-02f, -1.68657154e-02f, -2.27238834e-02f, 1.59800071e-02f, -4.95533124e-02f,
  -8.27668458e-02f, -3.40123810e-02f, -1.10322446e-01f, 1.09106665e-02f, 8.55626911e-02f, -6.67014644e-02f, -1.65961683e-01f, 5.77152893e-03f, -5.31761199e-02f, -2.27748342e-02f,
  -4.02981490e-02f, -2.52369512e-02f, 5.99414818e-02f, -4.80947969e-03f, 6.99530691e-02f, -5.33574149e-02f, 2.11454760e-02f, 5.57401739e-02f, 4.31017671e-03f, -6.27255216e-02f,
  1.06897637e-01f, 6.94324598e-02f, 1.82850629e-01f, 1.66194011e-02f, -2.47762665e-01f, -1.52405292e-01f, -2.60326356e-01f, -1.60684809e-01f, -3.92227799e-01f, -3.23776692e-01f,
  -1.26524463e-01f, 6.59735128e-02f, -2.17428505e-01f, 2.39772648e-01f, 3.35488975e-01f, -1.44416422e-01f, 3.13074470e-01f, 3.61993234e-03f, 1.25402272e-01f, 1.66518852e-01f,
  1.73900262e-01f, 2.14165583e-01f, 2.96355993e-01f, 2.60311335e-01f, 3.14277291e-01f, 2.52320588e-01f, 1.30461618e-01f, 1.71880037e-01f, 1.39381841e-01f, 8.08923617e-02f,
  1.83860715e-02f, 4.63357009e-02f, 7.15349391e-02f, 2.88918167e-02f, -3.77571285e-02f, 6.82515353e-02f, 8.03616047e-02f, -2.34254054e-03f, -1.07361265e-01f, -8.47436637e-02f,
  1.85288955e-02f, -3.14382873e-02f, 5.20605184e-02f, -4.35867114e-03f, -8.38280246e-02f, -3.49022299e-02f, 6.61300495e-02f, -2.42592003e-02f, -6.28515929e-02f, -2.84007695e-02f,
  -5.50169498e-02f, -7.61179850e-02f, -3.98604339e-03f, 1.21132039e-01f, -7.38419816e-02f, -1.69678345e-01f, -3.40269916e-02f, -3.50451581e-02f, -4.84990738e-02f, -3.28911990e-02f,
  2.39487421e-02f, -1.31324276e-01f, -6.26030192e-02f, -3.57515775e-02f, -3.92037518e-02f, -1.15802968e-02f, -3.57642956e-02f, 2.42834911e-02f, 4.77735046e-03f, -2.59874426e-02f,
  -1.11484848e-01f, 8.51142481e-02f, -6.53444603e-02f, -8.15962702e-02f, 8.68715495e-02f, 2.76106223e-02f, 5.80853745e-02f, 3.81762907e-02f, -1.46400211e-02f, 1.69867817e-02f,
  -2.20662449e-02f, -1.93112495e-03f, 6.65422454e-02f, 9.26448498e-03f, -9.54828635e-02f, -1.28339708e-01f, 2.10436387e-03f, 2.44452730e-02f, 3.38423513e-02f, 1.28680006e-01f,
  -1.56909972e-02f, 3.34018618e-02f, -5.13148420e-02f, -3.08016166e-02f, 4.95176539e-02f, 6.33019507e-02f, 2.52341852e-02f, 1.22927755e-01f, 1.66651420e-02f, 6.04785569e-02f,
  -6.32300749e-02f, -6.04450777e-02f, -8.90404060e-02f, 2.34295465e-02f, 1.27386138e-01f, -5.21492548e-02f, -8.20731521e-02f, -1.37530163e-01f, -7.75411949e-02f, 4.27872613e-02f,
  5.95034733e-02f, -1.01554483e-01f, 1.04785167e-01f, -5.53438738e-02f, 2.50728391e-02f, -1.36283964e-01f, 1.50647730e-01f, -1.17678568e-01f, 4.09916937e-02f, 7.59403855e-02f,
  -3.97973537e-01f, 5.16629159e-01f, 3.96485813e-02f, -2.59985358e-01f, 3.29030663e-01f, 1.59056112e-01f, -1.08773224e-01f, 1.11388475e-01f, 2.98303608e-02f, -5.13177477e-02f,
  -1.18238218e-01f, 1.49634793e-01f, 3.44019569e-02f, -1.02669559e-01f, -2.97133178e-01f, -4.97558378e-02f, -1.87299564e-01f, -2.17930630e-01f, 2.97610909e-01f, -1.51167884e-01f,
  5.54996468e-02f, -1.33227110e-02f, -1.05786294e-01f, 3.06998789e-01f, 1.71347428e-02f, -6.35545775e-02f, -3.08673233e-01f, 3.38194907e-01f, -2.07807496e-01f, 1.35860682e-01f,
  -1.94749743e-01f, -1.20061792e-01f, -1.19657218e-01f, -4.06355932e-02f, -1.79981038e-01f, -5.36725111e-02f, -1.69479296e-01f, -3.71912271e-02f, 1.16835453e-01f, 4.23099846e-02f,
  -1.37371108e-01f, 1.35857597e-01f, 6.54532462e-02f, 1.22685805e-01f, 6.05236255e-02f, 1.19505331e-01f, 1.51773328e-02f, -1.07110232e-01f, 1.11942351e-01f, 2.01036632e-02f,
  1.08144283e-01f, -5.92610389e-02f, -2.21134257e-02f, -7.89508149e-02f, -6.10917760e-03f, 5.87281510e-02f, -9.26410556e-02f, -4.93647307e-02f, 3.68074775e-02f, 2.29015630e-02f,
  8.72650519e-02f, 1.98600367e-02f, 3.34709957e-02f, -5.89311346e-02f, 1.64720360e-02f, -4.35544401e-02f, 9.47300270e-02f, -4.09469120e-02f, 2.04100236e-02f, 1.68784130e-02f,
  -2.20937878e-02f, 2.68291775e-02f, -3.67106870e-02f, -2.11578924e-02f, 1.85761359e-02f, -4.91618365e-02f, -8.97354633e-02f, 2.00971286e-03f, -1.26214519e-01f, -7.19163800e-03f,
  1.11405872e-01f, -8.51133242e-02f, 5.09350374e-02f, 2.47662961e-02f, -1.78825185e-02f, 7.33327568e-02f, 7.26359487e-02f, -1.31451249e-01f, 9.04161334e-02f, 4.39478308e-02f,
  -3.14209521e-01f, -1.33290410e-01f, 7.64623955e-02f, 7.22649172e-02f, 9.17496458e-02f, 3.52369286e-02f, -1.56518668e-02f, -3.58853452e-02f, -1.09006926e-01f, 7.27416873e-02f,
  8.67222715e-03f, -1.70746624e-01f, -3.56801860e-02f, 1.13243960e-01f, -7.94993993e-03f, -7.47424737e-02f, -1.92014232e-01f, -5.03410734e-02f, -1.60683677e-01f, -9.78253782e-03f,
  2.32565310e-02f, -1.45978658e-02f, -9.02697518e-02f, 3.93001875e-03f, -8.65308046e-02f, -9.18138623e-02f, -1.02336984e-03f, 9.43230316e-02f, -2.51820982e-02f, 8.55394900e-02f,
  5.54924309e-01f, -1.32729456e-01f, -1.77300498e-02f, 3.39897245e-01f, 3.31694692e-01f, 2.23858401e-01f, 3.24016958e-01f, 1.21185414e-01f, 2.85628378e-01f, -1.67934209e-01f,
  -7.14763701e-02f, -2.04954341e-01f, -2.01631576e-01f, 1.76379398e-01f, 4.33408797e-01f, -4.87606041e-02f, 3.68654221e-01f, 1.61605567e-01f, 8.22318047e-02f, 1.54248089e-01f,
  2.43504941e-01f, 2.62183905e-01f, -1.07836546e-02f, -1.14619836e-01f, 2.72389442e-01f, -1.38720781e-01f, -2.35995348e-03f, -8.39275122e-02f, -1.82121415e-02f, 1.30081892e-01f,
  -5.71857207e-04f, 1.21299617e-01f, -1.53826340e-03f, -7.68055692e-02f, 9.33078229e-02f, -9.70446393e-02f, -8.95275548e-02f, -3.83953676e-02f, 6.65071458e-02f, -1.20626912e-01f,
  -5.90569936e-02f, 4.70373891e-02f, -3.88420932e-02f, 3.17989066e-02f, 2.55064275e-02f, -1.74577795e-02f, -4.23079580e-02f, 2.48205569e-02f, -5.96596636e-02f, 9.26845819e-02f,
  -5.60414866e-02f, -6.53613806e-02f, 1.03128992e-01f, -6.92895129e-02f, 1.25340089e-01f, -2.29347241e-03f, -4.05546874e-02f, -3.53895687e-02f, -9.79797468e-02f, 6.10778108e-02f,
  2.04864480e-02f, 3.29592191e-02f, -2.06617080e-02f, 1.26371887e-02f, 3.07610910e-02f, 8.09598193e-02f, -2.95469314e-02f, -7.24555850e-02f, 7.32530057e-02f, -2.52586436e-02f,
  8.76341611e-02f, 4.32128198e-02f, 5.19948676e-02f, -7.44486079e-02f, 8.21600929e-02f, 6.73520518e-03f, 2.07428187e-02f, -6.92091510e-02f, 2.53279433e-02f, 2.70639919e-02f,
  7.20182508e-02f, 6.02219105e-02f, -8.42315629e-02f, -5.39166806e-03f, 6.67407289e-02f, -1.78061128e-02f, -6.40041614e-03f, 4.94606942e-02f, -5.45191839e-02f, 4.95822076e-03f,
  8.15704167e-02f, 2.23242324e-02f, -1.08634323e-01f, -1.25339016e-01f, -1.01615690e-01f, 1.09768696e-01f, 6.92112744e-02f, 9.66949612e-02f, 8.11781064e-02f, 1.12950534e-01f,
  8.37092847e-02f, -9.08567458e-02f, -7.62006873e-03f, 3.83616947e-02f, 2.74133943e-02f, 9.26914141e-02f, 1.53007859e-03f, -8.80938023e-02f, 7.00426176e-02f, -5.72148189e-02f,
  -7.14012310e-02f, 4.89326008e-03f, -3.01667582e-02f, 8.91747177e-02f, -5.25418855e-02f, -6.88114464e-02f, 5.94514124e-02f, -1.40742669e-02f, -5.33433259e-02f, -8.69829580e-02f,
  -2.08640620e-01f, 2.80810863e-01f, -2.21654877e-01f, 1.11945391e-01f, -1.08492389e-01f, -4.60764207e-02f, 5.83360158e-02f, 4.29167114e-02f, -2.05138952e-01f, 2.51063138e-01f,
  3.64058077e-01f, -2.29783386e-01f, 3.31610501e-01f, 4.37889546e-01f, 1.62421837e-01f, 2.66335130e-01f, 3.21013451e-01f, 2.95887917e-01f, 8.42767209e-02f, 2.82973558e-01f,
  1.01478375e-01f, 4.29195017e-01f, 2.92285293e-01f, 2.64411926e-01f, 3.16760540e-01f, -4.85278182e-02f, 2.47520491e-01f, -1.24021165e-01f, 2.34981865e-01f, 7.88904950e-02f,
  8.13615844e-02f, 5.90349846e-02f, -3.39028873e-02f, -1.10261396e-01f, 1.44684985e-01f, 3.42984125e-02f, 5.24184406e-02f, -2.28293724e-02f, -1.66552871e-01f, -3.60454395e-02f,
  -1.95069999e-01f, -1.34577760e-02f, -9.96114593e-03f, -1.80476978e-01f, -1.09051771e-01f, -4.84246910e-02f, -8.12346488e-02f, -8.13978091e-02f, -7.85930827e-02f, 3.08849066e-02f,
  2.36192271e-02f, 1.48358578e-02f, -7.02034542e-03f, -2.93016285e-02f, -5.11427745e-02f, -1.49360046e-01f, -7.90266097e-02f, 7.62188435e-02f, -4.77732383e-02f, 8.83452035e-03f,
  -7.71043748e-02f, 3.00101750e-03f, -1.45357251e-02f, -3.89437377e-02f, 3.42358984e-02f, 1.93750411e-02f, -2.21041963e-02f, 3.25186439e-02f, -3.58858928e-02f, 8.76107514e-02f,
  4.24162634e-02f, -1.19626652e-02f, -1.13767080e-01f, -6.28287047e-02f, -1.51238078e-02f, -4.00711671e-02f, -7.34810308e-02f, -3.13547403e-02f, -2.20309384e-02f, -1.35019645e-02f,
  -1.22590475e-01f, -6.81540370e-02f, 1.01700276e-02f, 1.00415852e-02f, -2.88523287e-02f, -3.16824429e-02f, 4.16712696e-03f, 7.38448352e-02f, -2.23937538e-02f, -3.65469884e-03f,
  1.73765600e-01f, 2.14835942e-01f, 4.27510366e-02f, -5.65921748e-03f, -2.85946596e-02f, 3.43595445e-02f, -8.96185413e-02f, -3.98964062e-02f, -3.39562893e-02f, -5.85911125e-02f,
  3.15213948e-02f, -7.78252110e-02f, -6.09824294e-03f, -2.02768259e-02f, 5.21152951e-02f, 6.72791749e-02f, -4.18767780e-02f, -1.17469184e-01f, -8.30962211e-02f, 3.26341912e-02f,
  -9.52179208e-02f, -3.87690403e-02f, -6.00235425e-02f, 2.85867527e-02f, 1.39355296e-02f, -1.93690285e-04f, -4.91619781e-02f, 2.27262322e-02f, 1.15024447e-01f, 1.34531874e-02f,
  3.03875983e-01f, -4.49766554e-02f, -1.85218751e-01f, 1.55297846e-01f, 1.77030265e-01f, 2.01099917e-01f, 3.15495223e-01f, 1.39152203e-02f, -1.25771731e-01f, -4.88407128e-02f,
  2.46260598e-01f, -2.62979586e-02f, 1.36758476e-01f, 2.26949677e-01f, 1.24297529e-01f, -4.35811467e-02f, 1.73344940e-01f, 1.09294705e-01f, -4.74700592e-02f, 1.16165668e-01f,
  3.76433693e-02f, 2.11630762e-01f, -8.51893350e-02f, -2.53190666e-01f, 2.83734471e-01f, -1.95164233e-01f, -1.08703218e-01f, -1.76009566e-01f, -1.16320722e-01f, -3.50578339e-03f,
  1.20946750e-01f, -2.57882848e-02f, -4.86876480e-02f, -4.11250405e-02f, 1.18463136e-01f, 9.77194086e-02f, 3.38014178e-02f, -1.84872989e-02f, -2.37533003e-02f, 3.09453923e-02f,
  -3.69814620e-03f, -9.07027721e-02f, 2.18230952e-02f, -5.76625057e-02f, 2.00759545e-02f, -3.92753258e-02f, 3.04752607e-02f, 6.39234260e-02f, -1.00111447e-01f, 3.11321001e-02f,
  3.42976116e-02f, 3.40484339e-03f, 1.22916177e-01f, -1.05168350e-01f, 2.69948579e-02f, -2.23872140e-02f, -6.81161531e-04f, 1.84948035e-02f, 7.71557018e-02f, 6.19245544e-02f,
  -3.45518105e-02f, -4.10385095e-02f, 8.20688605e-02f, 1.05706647e-01f, 2.11582929e-02f, 4.42222096e-02f, 6.70734420e-02f, 5.42813838e-02f, -7.19720647e-02f, 3.08345668e-02f,
  -7.63189839e-03f, 5.74846640e-02f, -4.69941832e-02f, 2.59620249e-02f, -5.63129634e-02f, 2.27016397e-02f, 2.64949370e-02f, 3.32944207e-02f, 5.72293950e-03f, -2.10425444e-02f,
  -6.38483688e-02f, -4.54139076e-02f, 7.41826296e-02f, 4.79268143e-03f, -5.82054816e-02f, -4.21029031e-02f, 3.07892519e-03f, 1.15562961e-01f, -7.97769651e-02f, 8.08090046e-02f,
  2.72165146e-02f, -1.51698753e-01f, -7.55927637e-02f, 2.41531041e-02f, 1.36786446e-04f, 1.54105976e-01f, -2.53155101e-02f, 3.20237763e-02f, -4.62219939e-02f, -2.20373850e-02f,
  -4.01858054e-03f, 5.35288826e-03f, 7.40315393e-02f, 7.33997151e-02f, -1.51207611e-01f, 7.04863444e-02f, -1.38611998e-02f, -1.13419734e-01f, -5.84379360e-02f, -8.49941671e-02f,
  4.98464406e-02f, 4.76970971e-02f, 4.17572185e-02f, 6.48110211e-02f, -1.91458277e-02f, -5.55217303e-02f, 4.38056234e-03f, -5.15309013e-02f, 1.41489178e-01f, -1.43144459e-01f,
  3.17152441e-01f, -3.41132373e-01f, -3.18729520e-01f, 2.00235561e-01f, 1.85988411e-01f, 3.43790561e-01f, 1.42081946e-01f, 1.61342800e-01f, 2.22475559e-01f, -3.18379812e-02f,
  1.54007092e-01f, -2.39694804e-01f, -3.62535179e-01f, 3.89352232e-01f, 1.51543468e-01f, -1.41587719e-01f, 3.19619238e-01f, 1.99759528e-01f, 6.19261041e-02f, 1.71946511e-01f,
  1.82784200e-01f, 2.05454215e-01f, -3.15865427e-01f, -6.37117252e-02f, 9.76429954e-02f, -9.45211796e-05f, -8.51416662e-02f, -2.82898605e-01f, 1.09892905e-01f, 5.45138158e-02f,
  1.08655922e-01f, 2.92927884e-02f, 3.52523127e-03f, 1.49991759e-03f, -1.65926851e-02f, -1.53089985e-02f, -1.59446225e-02f, -7.26726279e-02f, 1.80166513e-02f, 4.59615141e-02f,
  -5.39855622e-02f, 4.55950759e-02f, 6.29840568e-02f, -3.97654139e-02f, -5.13107097e-03f, -7.30530964e-03f, 1.10190377e-01f, -1.31005817e-03f, 5.30039286e-03f, -7.18586519e-02f,
  -6.18444346e-02f, -6.41918927e-02f, 9.89244953e-02f, -3.01680863e-02f, 4.34458889e-02f, 4.34991643e-02f, -2.81015560e-02f, -1.44969255e-01f, -1.09005524e-02f, 2.52226647e-02f,
  -8.89551118e-02f, -5.37214763e-02f, -2.76362095e-02f, 4.51294482e-02f, -5.40936776e-02f, 1.05632253e-01f, 8.12196359e-02f, 4.16168906e-02f, 2.65549477e-02f, -7.15683075e-03f,
  3.28556597e-02f, -2.35215444e-02f, 1.00465722e-01f, -7.53061241e-03f, 9.34840217e-02f, -3.93598191e-02f, -2.09928099e-02f, 1.17677590e-02f, 1.19267881e-01f, 1.70296466e-03f,
  -8.62989947e-02f, 9.14722607e-02f, -5.27354255e-02f, -7.94650242e-02f, 1.83028486e-02f, -7.18561411e-02f, 1.60533153e-02f, -2.17803773e-02f, 3.47841419e-02f, -8.55123624e-03f,
  -3.81221436e-02f, -2.50242203e-01f, 6.80208281e-02f, 8.99570808e-02f, -1.41363412e-01f, -2.92998180e-02f, -6.80255145e-02f, -1.01906862e-02f, -2.64988877e-02f, -2.69017201e-02f,
  -1.65317412e-02f, 6.59547523e-02f, -6.71605840e-02f, -7.50291685e-04f, 7.13371560e-02f, -5.58188260e-02f, 7.20885524e-04f, 1.15089335e-01f, 2.97887456e-02f, -3.88238579e-02f,
  -1.22176737e-01f, 1.27720892e-01f, -8.09699222e-02f, -3.73683460e-02f, 9.42380205e-02f, -3.20296660e-02f, 9.47713628e-02f, 3.03596258e-03f, -7.11607188e-02f, 1.55668706e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  2.39377528e-01f, 3.46728057e-01f, 4.46531355e-01f, 3.73451829e-01f, 3.32133561e-01f, 3.63878101e-01f, 3.28062445e-01f, 3.90035957e-01f, 2.44188040e-01f, 3.33747655e-01f,
  3.19490582e-01f, 2.02586457e-01f, 2.76159763e-01f, 3.44747633e-01f, 2.74898976e-01f, 2.57260531e-01f, 2.61849463e-01f, 1.55277506e-01f, 3.30406964e-01f, 2.80475587e-01f,
  3.68720949e-01f, 2.94828773e-01f, 4.16580886e-02f, 4.28068936e-01f, 4.51113492e-01f, 2.61048436e-01f, 1.32284626e-01f, 2.94945031e-01f, 4.14338022e-01f, 2.33206064e-01f,
  3.69620085e-01f, 2.78722435e-01f, 3.50547254e-01f, 2.46719152e-01f, 2.77907282e-01f, 3.04386646e-01f, 2.30016798e-01f, 2.84619689e-01f, 2.43074730e-01f, 2.11381063e-01f,
  3.16686988e-01f, 2.32672334e-01f, 3.04089606e-01f, 3.51545274e-01f, 3.29315037e-01f, 3.39290440e-01f, 3.00147504e-01f, 3.10453445e-01f, 2.67464310e-01f, 5.44725023e-02f,
  3.74976754e-01f, 4.16369200e-01f, 3.40773463e-01f, 2.66866863e-01f, 1.60002574e-01f, 4.07783002e-01f, 3.19470733e-01f, 2.24408627e-01f, 3.27306122e-01f, 7.18682557e-02f,
  2.82272786e-01f, 4.23496574e-01f, 1.77289039e-01f, 4.50446218e-01f, 2.06086352e-01f, 1.63219765e-01f, 2.15285733e-01f, 2.59055883e-01f, 4.40246373e-01f, 3.44819844e-01f,
  1.41525760e-01f, 3.26331496e-01f, 4.15414870e-01f, 2.65797764e-01f, 2.01212451e-01f, 2.55144835e-01f, 4.07821596e-01f, 2.15610191e-01f, 2.44942278e-01f, 1.61360979e-01f,
  2.38377810e-01f, 3.92159730e-01f, 2.13610128e-01f, 3.16813499e-01f, 3.74566466e-01f, 3.63613158e-01f, 3.83941591e-01f, 2.56416351e-01f, 1.98181421e-01f, 2.55312413e-01f,
  3.92827213e-01f, 5.63620329e-01f, 3.17749679e-01f, 2.64423341e-01f, 3.48313600e-01f, 1.55941069e-01f, 3.72782260e-01f, 3.12169671e-01f, 2.77353317e-01f, 1.99101999e-01f,
  4.73179758e-01f, 1.92779407e-01f, 2.70123929e-01f, 2.50152826e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.78800166e-01f, -1.62279144e-01f, -7.98914656e-02f, -9.01738461e-03f, -1.88888937e-01f, 2.33594421e-02f, -6.01370111e-02f, -2.93869451e-02f, -6.95993304e-02f, -3.53002176e-02f,
  -3.75791336e-03f, -1.92891091e-01f, -2.15515837e-01f, 3.29072386e-01f, 1.84919029e-01f, -3.05194780e-02f, -2.44883627e-01f, 1.82540670e-01f, 2.66812829e-04f, -1.61418214e-01f,
  1.21083111e-01f, 2.97220379e-01f, -2.76966900e-01f, 8.48202333e-02f, 3.11814427e-01f, -3.36467862e-01f, -4.35283303e-01f, -3.83322865e-01f, -1.95125327e-01f, -3.06022525e-01f,
  -1.69991612e-01f, -4.23912317e-01f, -2.25343004e-01f, -2.37264991e-01f, -1.07598804e-01f, -2.07876429e-01f, 1.99429661e-01f, 3.60846728e-01f, -1.56616598e-01f, 2.58467853e-01f,
  -2.06436604e-01f, -1.72660694e-01f, -3.27856153e-01f, -2.21206114e-01f, -1.63764786e-02f, 3.12780768e-01f, -6.52323142e-02f, -2.89533257e-01f, -2.66201049e-01f, -2.95307368e-01f,
  -1.46247059e-01f, -1.67447627e-01f, -2.42829267e-02f, 2.00671107e-01f, -1.64616406e-01f, 5.90366274e-02f, -6.17211282e-01f, -1.89722955e-01f, 5.06652445e-02f, -9.68041644e-02f,
  1.69086680e-02f, -4.09488410e-01f, -1.06117427e-02f, 1.00398459e-01f, 4.40040499e-01f, -2.04365641e-01f, -1.80229738e-01f, 9.56545919e-02f, 2.19874024e-01f, 3.75327796e-01f,
  1.98160306e-01f, 9.84259993e-02f, -3.35248798e-01f, -8.56098384e-02f, 1.55155838e-01f, 1.90040469e-02f, 2.41182938e-01f, -2.97304541e-01f, 4.76883739e-01f, -1.80722684e-01f,
  3.23251218e-01f, 1.02227852e-01f, -4.06573832e-01f, -2.43914098e-01f, 3.32429856e-01f, -1.89244166e-01f, -1.28897995e-01f, -3.33176821e-01f, 2.86665380e-01f, 2.78700572e-02f,
  1.39501378e-01f, -1.33532465e-01f, -4.95412707e-01f, -1.53193418e-02f, -1.80165142e-01f, -1.10387512e-01f, 2.32611850e-01f, -8.06738213e-02f, -3.55723053e-01f, 1.08562857e-01f,
  2.84458667e-01f, -2.49201447e-01f, -1.13280758e-01f, -1.53344750e-01f, -2.63335481e-02f, -1.09737754e-01f, -2.27471009e-01f, -2.21330732e-01f, 1.13046266e-01f, -3.35539967e-01f,
  1.33176744e-01f, -1.98413938e-01f, -7.34822229e-02f, 2.90124893e-01f, -2.58807898e-01f, -4.24592942e-01f, -3.29567879e-01f, -2.07697943e-01f, -2.04535857e-01f, -5.51167727e-02f,
  -1.33548513e-01f, -2.12554216e-01f, -3.32946181e-01f, -4.72189128e-01f, -3.64185542e-01f, 3.18904489e-01f, 4.03727852e-02f, -5.35166897e-02f, 1.52020082e-01f, 1.77491441e-01f,
  1.65146530e-01f, -1.38260666e-02f, 2.16846853e-01f, -2.93313354e-01f, 1.30880162e-01f, -1.68841884e-01f, -1.59443960e-01f, -6.41442314e-02f, 8.90915692e-02f, 1.44867107e-01f,
  3.25271755e-01f, -9.35536325e-02f, 1.11517990e-02f, -1.33286133e-01f, -4.82690893e-02f, 3.82315338e-01f, -9.10780728e-02f, 4.14222628e-01f, 2.12512076e-01f, -3.83745998e-01f,
  1.76924139e-01f, -6.62692785e-02f, -1.65030465e-01f, 2.36736182e-02f, -4.92796659e-01f, 3.95112216e-01f, 3.49839441e-02f, -2.65564620e-01f, 1.82517216e-01f, -2.28616804e-01f,
  2.44965374e-01f, -3.68400842e-01f, -1.31457552e-01f, -8.99116099e-02f, -2.43085191e-01f, 9.10071507e-02f, -1.94191933e-02f, -2.19728336e-01f, -3.37065221e-03f, -2.51754731e-01f,
  2.33971840e-03f, -6.03682511e-02f, -3.79117191e-01f, 3.24614882e-01f, -1.40652597e-01f, 2.14552954e-01f, 1.06693745e-01f, 2.70631701e-01f, -1.79561928e-01f, 1.79193720e-01f,
  9.72333737e-03f, 2.51790792e-01f, -1.37985602e-01f, -5.75510204e-01f, -2.90610790e-01f, 1.73745304e-01f, 3.15742791e-02f, -2.03208908e-01f, 4.42434959e-02f, -1.53234720e-01f,
  3.23489904e-01f, -1.58951804e-01f, -5.04009366e-01f, -5.97483099e-01f, -3.13401759e-01f, 9.99602154e-02f, 1.32706210e-01f, -3.82376611e-02f, -4.17823106e-01f, -1.82484433e-01f,
  -2.63023734e-01f, -2.88878977e-01f, -1.72671065e-01f, -6.95122555e-02f, 7.52168968e-02f, -3.09213728e-01f, -4.22132909e-01f, -5.39616704e-01f, 1.21811233e-01f, -7.20359981e-02f,
  -2.26067171e-01f, 3.43622923e-01f, -4.85138178e-01f, 3.61235797e-01f, -3.61527860e-01f, -2.99049318e-01f, 3.85503262e-01f, -1.08728252e-01f, -2.37089261e-01f, 3.84902284e-02f,
  -4.52509850e-01f, -3.80007893e-01f, -1.20079674e-01f, -3.33198793e-02f, 9.09908190e-02f, -1.11814346e-02f, -3.10585022e-01f, 4.97193150e-02f, -4.36950713e-01f, 3.27312976e-01f,
  -3.07323426e-01f, 2.08341703e-01f, -4.26144630e-01f, -2.05696255e-01f, -1.19787909e-01f, -2.29176238e-01f, 3.79444808e-01f, -3.05867583e-01f, -2.95766771e-01f, 4.08926964e-01f,
  -1.12998284e-01f, 3.14698249e-01f, -3.98778230e-01f, 3.52476500e-02f, -2.54098624e-01f, -1.73798904e-01f, -1.66697428e-01f, 4.09178296e-03f, -1.30893901e-01f, -1.87530890e-01f,
  4.94822562e-02f, -2.28998795e-01f, 2.48018444e-01f, 2.85117745e-01f, 3.06673646e-01f, 2.42142230e-01f, -4.12132218e-02f, -2.49436110e-01f, -6.15802780e-02f, -8.40353221e-02f,
  -8.87479633e-02f, -5.53168692e-02f, -1.25992104e-01f, -2.52193324e-02f, -1.30823001e-01f, -2.21438762e-02f, -1.70357168e-01f, -2.24220026e-02f, -6.60009310e-02f, 2.94696569e-01f,
  3.18870068e-01f, 1.89985320e-01f, -3.87542993e-02f, -3.05709578e-02f, 1.07016474e-01f, 6.53374940e-02f, -5.10664806e-02f, -1.26642942e-01f, -8.07038769e-02f, -1.62762880e-01f,
  -1.99693456e-01f, -2.07987323e-01f, -2.35304013e-01f, 3.59461457e-01f, -1.59711197e-01f, -4.03233856e-01f, 2.60796905e-01f, -2.90332854e-01f, 4.97023985e-02f, -3.59131843e-01f,
  -6.75105527e-02f, -7.64470547e-02f, -1.93664551e-01f, -2.62844771e-01f, -2.97471255e-01f, -2.53454030e-01f, -2.85382748e-01f, 3.04725081e-01f, -3.31261784e-01f, -2.29722783e-01f,
  1.52453735e-01f, -2.31134534e-01f, -1.03029959e-01f, -1.72873084e-02f, -3.54377747e-01f, -2.84725547e-01f, -9.71500054e-02f, 4.83982638e-02f, 2.78272063e-01f, 6.91396892e-02f,
  3.40109840e-02f, -7.04800487e-02f, -1.90584466e-01f, -1.98664665e-01f, -1.35614067e-01f, 2.17844740e-01f, 2.98612446e-01f, 4.90615778e-02f, 1.61864966e-01f, 3.14786226e-01f,
  -2.22315505e-01f, 2.44201839e-01f, 6.70315027e-02f, -2.20718712e-01f, -1.55444279e-01f, -4.82795276e-02f, -1.48826376e-01f, -2.90438324e-01f, -2.50930786e-01f, 3.57569933e-01f,
  -2.18979686e-01f, -3.47535998e-01f, 1.07431412e-01f, -2.30874300e-01f, -1.31931409e-01f, -9.10176244e-03f, -1.65153995e-01f, 2.47896165e-01f, -2.46558979e-01f, 3.47242117e-01f,
  -1.39033526e-01f, -1.42023951e-01f, -2.99337767e-02f, -2.77836770e-01f, -1.66532874e-01f, 1.80383831e-01f, -6.99304342e-02f, -1.51347434e-02f, 6.93242550e-02f, -2.46604934e-01f,
  3.12532336e-01f, -2.79711723e-01f, -4.24310833e-01f, -1.61965802e-01f, 1.14219666e-01f, 3.04973483e-01f, -1.48275897e-01f, 2.49815464e-01f, -7.45287016e-02f, -2.57180572e-01f,
  -1.26800731e-01f, -1.83836520e-01f, 1.60098523e-01f, -1.15443833e-01f, -1.05262198e-01f, 2.45497525e-01f, -2.73166090e-01f, 2.95712262e-01f, -2.99420834e-01f, -2.53580868e-01f,
  1.45830244e-01f, -1.38854399e-01f, -9.57177021e-03f, -6.71440586e-02f, 1.16767168e-01f, -2.50059813e-01f, 1.73658073e-01f, -1.39716685e-01f, 2.13973835e-01f, 9.62327328e-03f,
  1.17850758e-01f, -1.89908221e-01f, -1.37694851e-01f, 3.55422854e-01f, 1.17818058e-01f, 8.24183300e-02f, 8.20194855e-02f, -3.29576880e-01f, -1.48477733e-01f, 1.12257972e-01f,
  -1.81426987e-01f, -6.66332692e-02f, 9.45999250e-02f, 8.54211599e-02f, -1.23306960e-01f, 4.38276045e-02f, 6.47047088e-02f, 9.52409729e-02f, -3.45079042e-02f, -2.98702806e-01f,
  -5.09039797e-02f, -2.36977879e-02f, 2.24841461e-01f, -1.78156286e-01f, -6.09653629e-03f, -9.00948197e-02f, -4.37007770e-02f, 1.61006793e-01f, 4.59767394e-02f, 1.95076123e-01f,
  -3.23298499e-02f, -3.71421754e-01f, 4.68281657e-02f, -1.77064538e-01f, -3.55529994e-01f, -4.11242604e-01f, -1.41922757e-01f, -3.35979521e-01f, 2.15175927e-01f, -4.87975478e-01f,
  -2.33051524e-01f, 2.06067190e-02f, 3.83376747e-01f, 3.62086296e-01f, -5.38212597e-01f, -1.74817622e-01f, 3.43086347e-02f, 3.36826563e-01f, -4.26950693e-01f, -2.72075474e-01f,
  4.46240425e-01f, -2.17767015e-01f, -3.94244611e-01f, 1.76143125e-01f, 2.00693198e-02f, 1.97832525e-01f, -3.20088118e-01f, -1.56228393e-01f, -3.95015568e-01f, 2.67974764e-01f,
  1.04073763e-01f, -2.41468623e-01f, 2.40997821e-02f, 2.16594785e-01f, 4.89791669e-02f, 1.37627587e-01f, -1.97195381e-01f, -2.14789063e-01f, -4.38234732e-02f, -1.89471647e-01f,
  -7.40761012e-02f, -2.83624291e-01f, -2.63387531e-01f, 1.33652344e-01f, 2.73833305e-01f, -3.13877463e-01f, 3.67872775e-01f, -1.99165698e-02f, -5.61050139e-02f, -4.24567703e-03f,
  -3.95405829e-01f, 2.86535084e-01f, 2.67363608e-01f, -4.18958277e-01f, -2.61406839e-01f, -9.87279788e-02f, 2.89734185e-01f, -1.12159610e-01f, 6.94676116e-02f, -3.73279274e-01f,
  1.08575217e-01f, -3.21780831e-01f, -2.89170533e-01f, -1.60400510e-01f, 3.91004264e-01f, -1.90749317e-01f, -2.79927939e-01f, 1.48938030e-01f, 3.69420908e-02f, -2.07814090e-02f,
  -7.34226778e-02f, -2.09743506e-03f, -2.72582799e-01f, 2.34354381e-03f, -3.89739156e-01f, -4.01683688e-01f, -4.46420878e-01f, 1.35459155e-01f, 1.94172904e-01f, -7.80315101e-02f,
  2.68958360e-01f, 2.01461107e-01f, -1.28857940e-01f, -1.70632675e-01f, -9.91509706e-02f, -2.16425687e-01f, 3.73735696e-01f, 3.31546664e-02f, -4.17981058e-01f, -4.31987435e-01f,
  -2.94096559e-01f, 7.33533353e-02f, 1.08974047e-01f, -2.85501778e-01f, -3.08423907e-01f, 2.43953660e-01f, -3.01727533e-01f, 4.47565794e-01f, -1.79356143e-01f, -3.02688122e-01f,
  -2.77889341e-01f, -1.74290612e-01f, -5.87718785e-02f, -1.28274888e-01f, 1.18729055e-01f, 2.13846147e-01f, -5.80262486e-03f, 5.31987473e-02f, 2.06299841e-01f, -4.04652767e-02f,
  1.36903539e-01f, -5.67952134e-02f, 5.24479002e-02f, 1.42019749e-01f, 1.36834383e-01f, -1.37435542e-02f, 9.79908854e-02f, 9.49691460e-02f, -2.37373915e-02f, -3.67066652e-01f,
  -1.55206367e-01f, -9.09586474e-02f, 1.41212001e-01f, 2.99807817e-01f, -2.65424430e-01f, -1.61707357e-01f, -3.37072879e-01f, 1.38542816e-01f, 3.15944999e-02f, -1.26030907e-01f,
  -8.14964250e-02f, -2.48458967e-01f, -9.30135697e-02f, 2.84807175e-01f, -4.45973545e-01f, -1.04279615e-01f, 3.00044656e-01f, -1.59145802e-01f, -2.33779207e-01f, 1.54573530e-01f,
  -2.19999060e-01f, 1.32705113e-02f, 2.90397942e-01f, -1.17556259e-01f, 2.56352365e-01f, -4.65420336e-01f, -1.84736341e-01f, -8.16297308e-02f, -1.00937141e-02f, 5.25074899e-02f,
  -6.40258864e-02f, -5.44059463e-02f, -1.09957859e-01f, -2.54704714e-01f, -3.20964754e-01f, -6.31537735e-01f, -1.24057502e-01f, 1.50814444e-01f, 4.13969874e-01f, 1.16014518e-01f,
  -2.57427484e-01f, 1.02014393e-01f, -1.75049528e-01f, 3.14427972e-01f, 2.24571988e-01f, -1.84655696e-01f, 2.12530121e-01f, -1.48715124e-01f, 3.19837630e-01f, 3.89419556e-01f,
  -3.96042615e-02f, 1.81887433e-01f, -9.48153138e-02f, 1.29315868e-01f, 2.09054679e-01f, -1.85678244e-01f, 2.58790642e-01f, 2.87127763e-01f, 3.03804815e-01f, -1.85876682e-01f,
  1.10559374e-01f, -2.98020720e-01f, 3.01618338e-01f, -1.87796250e-01f, 1.99765220e-01f, -5.56660183e-02f, 1.17812939e-01f, -2.35148206e-01f, -3.80881399e-01f, -9.43713486e-02f,
  -2.60204226e-01f, 3.72818768e-01f, 4.21035849e-02f, -1.64238527e-01f, -1.65895596e-02f, 3.30479473e-01f, -3.01251173e-01f, 4.01634693e-01f, -2.35133588e-01f, -4.07339126e-01f,
  -6.56610951e-02f, 3.95881683e-01f, -1.52473673e-01f, -7.08349645e-02f, -7.61564821e-03f, -1.51319087e-01f, 1.13600686e-01f, -4.27617520e-01f, -1.36638597e-01f, -2.03915656e-01f,
  -2.01157749e-01f, -1.73291355e-01f, 3.81868035e-01f, -1.09043002e-01f, -1.97481617e-01f, -3.98459047e-01f, -6.90430822e-03f, 1.53960958e-01f, 1.77430421e-01f, 1.33904308e-01f,
  -4.99628752e-01f, 6.85481131e-02f, -3.29336673e-01f, -8.86007398e-02f, 2.45482400e-01f, 2.80033797e-01f, -2.96446592e-01f, 1.10681996e-01f, -1.42802820e-01f, -4.24251765e-01f,
  -1.36253946e-02f, 2.28730187e-01f, -1.56653598e-02f, 1.66810915e-01f, 5.11707887e-02f, 2.12872952e-01f, 5.15097193e-02f, 8.91866460e-02f, 1.81203503e-02f, 4.57498729e-02f,
  7.95876235e-02f, 1.88087001e-01f, -1.46348223e-01f, -1.93813771e-01f, -2.15370312e-01f, 5.29148057e-02f, -8.24782159e-03f, 4.81741987e-02f, -3.20239574e-01f, 2.11457476e-01f,
  2.65302718e-01f, -4.76337932e-02f, 3.21532547e-01f, 2.93227345e-01f, 3.62808317e-01f, 1.69830900e-02f, 2.81531841e-01f, -3.23697239e-01f, -4.49460506e-01f, 8.40217620e-02f,
  -1.32731581e-02f, 3.28703225e-01f, -3.04144770e-01f, 2.13026240e-01f, -4.06378299e-01f, -2.00410023e-01f, 2.69061834e-01f, -1.76717788e-01f, -3.43318641e-01f, -1.30562633e-01f,
  -6.14363374e-03f, 3.32623674e-03f, 1.63911030e-01f, 3.64164151e-02f, 7.83374608e-02f, -5.13213217e-01f, -1.95584744e-01f, -2.67131388e-01f, 1.66789964e-01f, 1.04638234e-01f,
  -1.74683511e-01f, -1.93895876e-01f, -1.18263531e-02f, 3.22044104e-01f, 3.46408933e-01f, 1.56052545e-01f, 2.79368311e-01f, 1.22263648e-01f, 3.74536812e-01f, -3.34302783e-01f,
  -2.19567791e-01f, -2.79824466e-01f, -3.22960079e-01f, -2.50629097e-01f, -2.27096528e-01f, -1.49928421e-01f, -2.79235452e-01f, -2.44167307e-03f, -2.01360345e-01f, -2.30294131e-02f,
  -1.31385401e-01f, 4.12552893e-01f, -4.45200145e-01f, -4.00398433e-01f, -4.30638999e-01f, -2.87453830e-01f, -5.36242202e-02f, 5.52526303e-02f, -4.92101133e-01f, -4.08145078e-02f,
  -1.25420853e-01f, -2.55844463e-02f, -2.20616877e-01f, -3.93417418e-01f, 2.54591048e-01f, 2.96615481e-01f, -3.34991924e-02f, 8.43518823e-02f, 1.17833331e-01f, -2.78869987e-01f,
  -4.93593544e-01f, -2.35984132e-01f, 2.88004309e-01f, 9.84614715e-02f, 2.27119014e-01f, 2.03333437e-01f, 3.43435556e-01f, 3.42117660e-02f, 2.23587736e-01f, -5.11203468e-01f,
  9.08203945e-02f, -2.23671988e-01f, -4.76049855e-02f, -2.02138647e-01f, 2.55390674e-01f, 2.25644007e-01f, -3.64088595e-01f, -2.65093029e-01f, 2.66590029e-01f, -2.61569247e-02f,
  2.47869626e-01f, -3.41717392e-01f, -1.90545559e-01f, 1.67596549e-01f, -4.45330262e-01f, -1.41000032e-01f, 3.60682756e-01f, 3.04668814e-01f, -3.17587107e-01f, -4.28612009e-02f,
  2.90108509e-02f, 3.55968848e-02f, -6.29098639e-02f, 4.91455421e-02f, 8.02775174e-02f, -3.14342976e-01f, -1.40529707e-01f, -1.62075348e-02f, -1.10921219e-01f, 5.65983467e-02f,
  8.94020684e-03f, 7.08895251e-02f, 5.81466667e-02f, 3.53418142e-02f, -1.08037218e-01f, 6.35831505e-02f, 7.51924589e-02f, 1.54954031e-01f, -8.17472041e-02f, 1.30363228e-02f,
  1.35910958e-01f, -2.02941284e-01f, -4.16956007e-01f, 1.01140372e-01f, 2.97130823e-01f, -1.95970044e-01f, -1.02899417e-01f, -1.23736233e-01f, -1.19565949e-01f, -9.51357856e-02f,
  2.34456480e-01f, -2.17521369e-01f, -2.62272745e-01f, -2.63173312e-01f, -2.39041075e-02f, -2.05733016e-01f, 2.11802900e-01f, 3.37328255e-01f, -1.54195586e-02f, 1.18231162e-01f,
  3.86788994e-01f, 2.52061516e-01f, -8.10544342e-02f, 7.40170898e-03f, 2.03930840e-01f, 4.33908366e-02f, -1.71122655e-01f, -2.61802107e-01f, 3.73889863e-01f, -3.40215355e-01f,
  3.02117378e-01f, -1.92002699e-01f, -2.28752151e-01f, -1.42772973e-01f, -3.36212128e-01f, 1.53280616e-01f, 5.68839945e-02f, -3.36126387e-01f, -1.38149057e-02f, -1.02355383e-01f,
  -4.17246878e-01f, -4.33670431e-02f, -2.16293201e-01f, -1.62938103e-01f, 3.01492531e-02f, -3.09533238e-01f, -1.63105011e-01f, 5.45841418e-02f, 3.42102319e-01f, 8.26764181e-02f,
  -2.18988240e-01f, -3.57991725e-01f, -2.70339757e-01f, 1.85397595e-01f, 2.44115829e-01f, -3.22496861e-01f, 3.02784983e-02f, -3.73042017e-01f, -2.65597850e-01f, -3.12141269e-01f,
  1.18506767e-01f, 4.58600700e-01f, -2.41479978e-01f, -3.08252573e-01f, -4.81222063e-01f, 4.22839820e-01f, -1.25518546e-01f, 2.36374557e-01f, -4.92456913e-01f, -3.11863512e-01f,
  -2.07371637e-01f, 3.80551592e-02f, -4.58716929e-01f, -1.60725508e-02f, 3.81290525e-01f, -4.32427049e-01f, -1.34400502e-01f, -3.06523651e-01f, -2.52577186e-01f, -1.67066783e-01f,
  5.71180880e-02f, -3.46635997e-01f, -3.20657015e-01f, -3.68693948e-01f, -3.56610447e-01f, 1.61745310e-01f, 1.73502937e-01f, -1.09094642e-01f, 2.13178396e-01f, -8.65287110e-02f,
  -3.21941108e-01f, 5.99894039e-02f, -9.88701358e-02f, 2.14390412e-01f, -3.13834846e-01f, -7.43744150e-02f, -2.68786728e-01f, 2.28936687e-01f, -1.67837530e-01f, 1.31791711e-01f,
  -1.48791328e-01f, 2.86552198e-02f, 3.02568763e-01f, -1.54626086e-01f, 3.13891411e-01f, -1.50262445e-01f, 3.95368427e-01f, -3.55789542e-01f, -4.44443315e-01f, -3.71066004e-01f,
  -2.17793062e-01f, -7.95180723e-02f, 3.14576030e-01f, -2.54435003e-01f, 2.25332022e-01f, 3.63300771e-01f, -1.25766098e-01f, -1.76169768e-01f, -1.51137292e-01f, -1.24207690e-01f,
  -1.55021757e-01f, -3.02154481e-01f, 3.71903554e-02f, -6.27205297e-02f, -4.08089943e-02f, 3.65844779e-02f, -2.08706036e-02f, -1.60348549e-01f, -2.25137919e-01f, 7.55529478e-02f,
  3.98753211e-02f, 1.35592595e-01f, 1.59329906e-01f, -2.18856573e-01f, -1.54257923e-01f, -1.77695855e-01f, -3.45815718e-02f, 4.56083007e-02f, 7.26163164e-02f, 1.82291001e-01f,
  1.68174088e-01f, 3.20362121e-01f, 7.99700469e-02f, -4.97962348e-02f, -2.03800783e-01f, 8.45575482e-02f, -2.70703733e-01f, 3.61624211e-02f, -1.15977570e-01f, -1.92139186e-02f,
  4.34040874e-02f, -8.26136693e-02f, 2.60115247e-02f, -2.52971679e-01f, 7.22440407e-02f, -2.56368846e-01f, -1.50603339e-01f, 2.36211479e-01f, -2.26548582e-01f, 2.67623603e-01f,
  -1.62318364e-01f, -1.46723554e-01f, 1.98013000e-02f, -2.65485734e-01f, 2.17486843e-01f, -1.98388293e-01f, 3.71511191e-01f, -1.21915795e-01f, -1.60433322e-01f, -2.20638812e-01f,
  -1.25073433e-01f, 1.62109002e-01f, 2.37911552e-01f, 1.76969126e-01f, -1.20749690e-01f, -7.91149437e-02f, -2.46697322e-01f, -3.49803060e-01f, -8.74175355e-02f, -1.46203460e-02f,
  -1.43979132e-01f, 5.74715203e-03f, -2.13409111e-01f, 1.86775178e-01f, -1.54175833e-01f, -3.11554730e-01f, 2.03007981e-01f, -1.73730940e-01f, -1.51980549e-01f, 9.09790993e-02f,
  -1.38819069e-01f, -3.13771486e-01f, -2.68308222e-01f, -3.29095364e-01f, 1.22885451e-01f, 3.86181861e-01f, -2.83972234e-01f, -1.44139633e-01f, 1.17260173e-01f, -1.60086825e-01f,
  9.71680507e-02f, -2.98941404e-01f, 3.54764253e-01f, -1.31332681e-01f, -1.53112382e-01f, 3.07729453e-01f, 1.26105184e-02f, -9.04625878e-02f, -1.27444267e-01f, 2.24529311e-01f,
  1.58862069e-01f, 5.63545078e-02f, -2.12561190e-01f, -2.54303396e-01f, 2.35079024e-02f, -2.06844628e-01f, 5.59918918e-02f, -2.18267426e-01f, 2.51773179e-01f, 3.16386193e-01f,
  -6.28106818e-02f, 1.38188720e-01f, 2.83298194e-01f, 2.42671385e-01f, -2.38616109e-01f, -1.10311180e-01f, -2.95615941e-01f, -2.45263323e-01f, -5.15579209e-02f, 2.17325357e-03f,
  1.08318157e-01f, 3.60877626e-02f, -1.25272468e-01f, 4.06839773e-02f, -2.93585390e-01f, 3.10479730e-01f, -3.41773927e-02f, 1.40591860e-01f, -7.21832141e-02f, -1.08718038e-01f,
  -1.26488015e-01f, -3.34954113e-01f, -2.53730685e-01f, -1.84253752e-01f, -8.96919984e-03f, -2.39860415e-02f, -4.79845703e-02f, 6.21579103e-02f, -7.61055201e-02f, 8.19673240e-02f,
  -8.74501988e-02f, -3.95202227e-02f, 1.25535652e-02f, -2.81512707e-01f, -7.52526969e-02f, -1.44473791e-01f, 8.83234516e-02f, 1.48851156e-01f, -1.58767909e-01f, -1.64775848e-01f,
  1.45565093e-01f, 7.74155110e-02f, -5.29386699e-02f, -2.47898340e-01f, -1.51294200e-02f, -1.18359521e-01f, -1.37350867e-02f, 2.12452322e-01f, -5.81879206e-02f, -1.04534574e-01f,
  1.91986129e-01f, -2.14085594e-01f, -1.59911707e-01f, 4.15555477e-01f, -7.75718614e-02f, -1.56431779e-01f, -3.56984437e-01f, -1.90331385e-01f, -2.60118604e-01f, 3.14656585e-01f,
  2.05383256e-01f, -2.35414326e-01f, 3.31725150e-01f, 1.41183227e-01f, -1.93182275e-01f, 2.92552501e-01f, -2.09785596e-01f, -2.18761116e-01f, -4.18109335e-02f, 2.36733362e-01f,
  -1.11291848e-01f, -3.16840820e-02f, 4.98489588e-02f, -2.16461465e-01f, -1.40690744e-01f, -1.93701640e-01f, -1.77777663e-03f, -9.07477960e-02f, -1.33271322e-01f, -2.14126512e-01f,
  -2.04613373e-01f, -1.52065977e-01f, -2.24996418e-01f, -9.65202525e-02f, -2.44142607e-01f, -1.68370083e-01f, 2.19721854e-01f, -4.88672815e-02f, -1.56164303e-01f, 3.66690725e-01f,
  -1.10306777e-01f, -2.46804208e-01f, -2.65430301e-01f, -2.83844471e-01f, -2.34859303e-01f, -2.04835117e-01f, -9.17165801e-02f, -2.82783747e-01f, -2.34601825e-01f, 3.56406063e-01f,
  3.71510461e-02f, 2.64274348e-02f, -1.73341528e-01f, -2.62938142e-02f, -1.34093329e-01f, 2.57196367e-01f, -1.65263548e-01f, -1.81394294e-01f, -1.76714972e-01f, 6.56770766e-02f,
  -7.69304708e-02f, 9.92759466e-02f, -2.66621500e-01f, -4.67046052e-02f, -2.23007455e-01f, -1.29380822e-01f, 2.53368109e-01f, 4.70377542e-02f, 2.39755005e-01f, 9.45514962e-02f,
  -4.01856378e-02f, -2.91999102e-01f, 3.24020356e-01f, -2.37899616e-01f, -2.46815428e-01f, -2.33574072e-03f, -2.15871483e-01f, -1.14803225e-01f, -1.59349427e-01f, 2.81094760e-01f,
  -6.90822005e-02f, -2.30582610e-01f, -4.99710664e-02f, -2.94912517e-01f, -2.74342477e-01f, -2.31884643e-01f, -1.77764967e-01f, -2.10862234e-01f, -1.26291320e-01f, 2.42669180e-01f,
  -2.52003849e-01f, -2.17151135e-01f, 3.85010499e-05f, -1.57563195e-01f, 3.01858276e-01f, 2.92854477e-02f, 3.06884974e-01f, -2.25050256e-01f, 1.19001180e-01f, 2.77527899e-01f,
  -1.88372880e-01f, -4.11588907e-01f, 1.26167059e-01f, 1.39012888e-01f, 1.33059412e-01f, -2.25796878e-01f, 2.14098543e-02f, -1.15996962e-02f, 1.26862973e-01f, 6.13995120e-02f,
  -7.78549388e-02f, -2.17869982e-01f, 1.20385855e-01f, 2.98764445e-02f, -1.35510102e-01f, -1.24733388e-01f, 3.67803872e-01f, 2.81996131e-01f, -2.47631803e-01f, -2.75129706e-01f,
  -1.01457223e-01f, -1.57190785e-01f, -3.64308864e-01f, 1.80311292e-01f, 1.61157977e-02f, 2.95786485e-02f, -2.09279656e-01f, 1.04709789e-01f, 8.36753771e-02f, 1.49454951e-01f,
  3.15406293e-01f, -4.19888675e-01f, -3.80248934e-01f, 2.30209202e-01f, 2.49524653e-01f, 3.16051006e-01f, -2.40606621e-01f, -1.40246689e-01f, -3.56670059e-02f, 1.98158696e-01f,
  -1.99908003e-01f, -3.05083930e-01f, -2.21020579e-01f, -6.29174709e-02f, -2.27157716e-02f, -1.69761196e-01f, 1.13056287e-01f, -1.33597806e-01f, 2.06898436e-01f, -4.26188141e-01f,
  1.38767853e-01f, 3.99544239e-01f, -8.17519650e-02f, -1.60265535e-01f, 2.95314401e-01f, -4.19829965e-01f, 4.25969586e-02f, -3.16179216e-01f, -2.04116464e-01f, -2.43265927e-02f,
  -1.46310255e-01f, -4.00592119e-01f, 2.38152981e-01f, -2.05458924e-01f, -3.83841425e-01f, 9.53117162e-02f, 1.75178900e-01f, -1.98517635e-01f, 1.89259395e-01f, 1.08015217e-01f,
  3.50824326e-01f, -3.38846207e-01f, -1.62686840e-01f, 2.75372654e-01f, -2.59053469e-01f, -2.58369129e-02f, -1.44553408e-01f, -1.72283068e-01f, -4.45261925e-01f, -5.37624240e-01f,
  -2.75183976e-01f, 4.32942510e-01f, 2.66139269e-01f, 3.89193863e-01f, 1.65266484e-01f, -1.45091057e-01f, -2.43839547e-01f, -3.00224423e-01f, -1.92821220e-01f, 4.13914382e-01f,
  -3.84566933e-01f, -1.19363591e-01f, -1.26316115e-01f, -7.98284635e-02f, 1.50866300e-01f, -3.95644516e-01f, -2.76276708e-01f, 6.42113611e-02f, -2.75013864e-01f, -2.61571147e-02f,
  -1.76615208e-01f, -8.97801667e-02f, 5.20984307e-02f, -1.86201170e-01f, 4.15261388e-01f, 3.96604054e-02f, -4.37282920e-01f, -3.98487926e-01f, -1.21928781e-01f, -1.41780794e-01f,
  -3.99187505e-01f, 3.41520250e-01f, 1.70151159e-01f, -5.25785424e-02f, -2.62800574e-01f, -3.20042036e-02f, 3.13258082e-01f, -2.86525309e-01f, -2.08054647e-01f, -3.34554911e-01f,
  -3.19983751e-01f, 4.00177509e-01f, -2.49130711e-01f, -1.57752499e-01f, 6.30884245e-02f, -3.33736479e-01f, 5.19737899e-02f, -2.34801278e-01f, 1.36161879e-01f, -2.04577446e-01f,
  5.50814420e-02f, 7.89235607e-02f, 1.10082269e-01f, 1.40577644e-01f, 1.14537023e-01f, 4.86996286e-02f, -1.81464329e-01f, 5.04604541e-02f, -8.27831551e-02f, 1.75790191e-01f,
  -3.60768624e-02f, -3.51127386e-02f, 2.80850351e-01f, 3.46174799e-02f, 1.16971210e-01f, -1.52026722e-02f, -1.22453824e-01f, 2.40451872e-01f, 2.56127477e-01f, 2.32444406e-02f,
  -2.57283807e-01f, -2.11960658e-01f, -2.96636581e-01f, -3.43998998e-01f, -2.30263080e-02f, -8.06254148e-02f, -1.56084761e-01f, 2.04633459e-01f, 8.12821928e-03f, -2.45651111e-01f,
  -1.07652113e-01f, -5.23255989e-02f, -2.92162865e-01f, -2.59523392e-01f, 3.05624008e-01f, 4.29723859e-01f, -2.11021572e-01f, -3.25542808e-01f, -1.01296730e-01f, -5.82049005e-02f,
  -1.69666052e-01f, -1.76698014e-01f, -6.32436350e-02f, 1.04435205e-01f, 2.21179590e-01f, 1.33239254e-01f, -2.38261640e-01f, 3.62927705e-01f, 8.47952291e-02f, 3.81639204e-03f,
  -3.50100279e-01f, 3.24839085e-01f, 2.10481793e-01f, -2.48904184e-01f, 3.02985668e-01f, -2.49424875e-01f, -3.28323901e-01f, 3.15770715e-01f, -1.14960549e-02f, -3.54875594e-01f,
  -2.87847191e-01f, -8.10689181e-02f, -1.39793992e-01f, 3.75095367e-01f, -4.74887013e-01f, -1.79639652e-01f, -1.98670104e-01f, -1.96304038e-01f, -2.80622423e-01f, 7.21860752e-02f,
  1.89100727e-01f, -2.64698744e-01f, -2.27231890e-01f, -1.88711286e-01f, 3.32652539e-01f, 2.48851597e-01f, -2.78806567e-01f, -3.30408722e-01f, -2.63006054e-02f, -1.39264807e-01f,
  -2.66695410e-01f, -1.39104694e-01f, -4.13475603e-01f, -1.59614161e-01f, -7.82804266e-02f, 7.52122104e-02f, 2.30524033e-01f, 1.95427313e-01f, -1.00872450e-01f, -2.26487309e-01f,
  -2.53952652e-01f, 2.78764635e-01f, -2.83999324e-01f, -6.09682389e-02f, -2.45921031e-01f, -3.51969093e-01f, 1.71321779e-01f, 3.72587055e-01f, -2.19247684e-01f, 8.24249163e-02f,
  -2.12715983e-01f, 2.58428723e-01f, 1.16231881e-01f, -4.10301715e-01f, 2.26543788e-02f, -1.51711270e-01f, -1.02694193e-02f, 3.71150941e-01f, -1.94919601e-01f, -2.73443580e-01f,
  -5.05660884e-02f, -1.71466768e-01f, 2.91817546e-01f, -2.48006463e-01f, -7.93439448e-02f, 6.03875443e-02f, -1.66381463e-01f, 1.02221303e-01f, 3.89536828e-01f, -2.00972989e-01f,
  1.22662656e-01f, -2.38414913e-01f, -4.10540700e-01f, -2.44511023e-01f, -2.98352033e-01f, -1.05378382e-01f, -1.31336167e-01f, -5.52330986e-02f, 1.03469923e-01f, 1.24876775e-01f,
  -2.63525546e-01f, -6.98809233e-03f, -7.30931293e-03f, 1.98678989e-02f, 2.29437277e-02f, 6.71964735e-02f, -3.61557975e-02f, 1.02991477e-01f, 6.52745226e-03f, 6.69413656e-02f,
  -2.24272192e-01f, -1.02444634e-01f, -2.44343236e-01f, -2.74967253e-01f, 1.07232556e-01f, 1.57518655e-01f, 7.91512877e-02f, 2.05084339e-01f, -6.05723355e-03f, 9.23507586e-02f,
  -2.52180606e-01f, 9.52048972e-02f, -5.86243160e-03f, -2.20286086e-01f, 4.02859032e-01f, -1.22312702e-01f, 3.86797935e-01f, 3.75705749e-01f, 3.54976892e-01f, -4.37877089e-01f,
  -2.56813049e-01f, -1.03662170e-01f, -2.61925995e-01f, -2.00054690e-01f, -2.28834465e-01f, -1.76985770e-01f, 1.16629966e-01f, -3.70435953e-01f, 2.89615959e-01f, -3.06784987e-01f,
  1.56869069e-01f, -3.79271597e-01f, 2.80456513e-01f, -1.22127235e-01f, 2.50651464e-02f, -1.85634881e-01f, -3.18520606e-01f, -2.54572809e-01f, 9.15876925e-02f, -2.44500190e-01f,
  4.41615433e-02f, -1.85005859e-01f, 6.83466867e-02f, 2.45721221e-01f, -1.83718935e-01f, -1.40561461e-01f, 2.32927680e-01f, 3.94945443e-01f, -2.75464445e-01f, 3.57036710e-01f,
  -3.86950225e-01f, -3.00080836e-01f, 1.20145462e-01f, -4.73320410e-02f, -1.58342317e-01f, -1.48730591e-01f, -2.72601932e-01f, -5.67743406e-02f, -2.47897878e-01f, -1.98953509e-01f,
  1.86952025e-01f, -1.67339683e-01f, 1.13964461e-01f, 2.06035990e-02f, -3.03302616e-01f, 1.80043727e-01f, -5.42605929e-02f, -1.92575827e-01f, -3.54364663e-01f, -2.23819926e-01f,
  2.04421639e-01f, -3.68341133e-02f, -3.01048934e-01f, -1.49355412e-01f, -1.05840161e-01f, 4.70782891e-02f, -1.57125890e-01f, -2.56249458e-01f, 3.78498882e-01f, 3.81881058e-01f,
  3.46217453e-01f, -1.36922434e-01f, -1.54307529e-01f, -2.69365340e-01f, 2.83751301e-02f, 2.74748981e-01f, -2.09139287e-01f, -2.50358611e-01f, 3.94485921e-01f, -4.50777933e-02f,
  -6.46274984e-02f, -2.59144366e-01f, 7.45555246e-03f, 1.80972293e-01f, -7.28036165e-02f, -1.27628103e-01f, -2.37458006e-01f, -1.45383939e-01f, -2.54454076e-01f, -1.86476171e-01f,
  -4.52619255e-01f, -2.17243984e-01f, -2.48905137e-01f, 2.27181911e-01f, -1.99126713e-02f, 3.31076831e-01f, -2.90441841e-01f, 1.05689742e-01f, 2.46734738e-01f, 3.60150158e-01f,
  7.91942626e-02f, 3.47645134e-02f, -2.95263946e-01f, -1.12368360e-01f, 5.15360162e-02f, -1.30221277e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.24123951e-02f, 1.06116168e-01f, -1.50536314e-01f, 1.39687508e-02f, 5.32822162e-02f, -5.83401881e-04f, -4.59352210e-02f, -8.70218500e-02f, -1.03504501e-01f, 5.41442372e-02f,
  9.23619345e-02f, 5.78163341e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    