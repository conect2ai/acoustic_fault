/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.23045373e-01f, 2.50479162e-01f, -4.15904880e-01f, -5.34847938e-02f, -2.07472891e-01f, 3.17718327e-01f, -5.99376559e-02f, -6.72560483e-02f, 7.20245987e-02f, 1.06582075e-01f,
  -1.27442837e-01f, 3.30261840e-03f, -1.48704991e-01f, 1.76202595e-01f, 1.57296836e-01f, 1.78460598e-01f, 2.36022726e-01f, -4.03141044e-02f, 2.13400647e-01f, -1.67396829e-01f,
  3.25930081e-02f, 1.62852392e-01f, -1.04509115e-01f, 1.52817413e-01f, -2.05448359e-01f, -1.78305835e-01f, -2.45405540e-01f, -1.72276214e-01f, 3.57439369e-02f, 9.00193304e-02f,
  2.40126252e-01f, -8.66036396e-03f, -2.85332829e-01f, 2.81861555e-02f, -8.98365825e-02f, -9.77483168e-02f, -1.06055856e-01f, -4.96990122e-02f, -2.81344876e-02f, 7.22526535e-02f,
  -6.04317486e-02f, 5.04002906e-03f, 9.42889825e-02f, 1.67924333e-02f, -2.41395812e-02f, -6.63720742e-02f, 7.00388625e-02f, -2.55526956e-02f, -3.12515683e-02f, 4.72143106e-02f,
  3.34743224e-02f, 3.37058902e-02f, -6.01311810e-02f, 8.40658247e-02f, -3.04248016e-02f, -1.93670150e-02f, -5.36986142e-02f, -6.45119548e-02f, 3.43883373e-02f, 4.58738804e-02f,
  1.80501631e-03f, -4.90346109e-04f, -3.77301686e-02f, -8.98574200e-03f, 2.21867748e-02f, -5.62958382e-02f, 1.17876073e-02f, 2.15160288e-02f, -5.10189459e-02f, 1.76371336e-02f,
  4.45454847e-03f, -2.40802299e-03f, -3.58381979e-02f, -7.56230962e-04f, -7.34079978e-04f, -1.67334955e-02f, -3.21001299e-02f, -1.52785489e-02f, 2.54320800e-02f, 1.53072802e-02f,
  -9.26044537e-04f, 3.61639932e-02f, -5.41392155e-02f, 3.15618664e-02f, 4.94488962e-02f, -8.62337127e-02f, -1.43630533e-02f, -2.34835800e-02f, -1.77685414e-02f, -3.42080891e-02f,
  1.68397903e-01f, -2.99248379e-02f, 4.94875796e-02f, -1.04326988e-02f, 5.46286404e-02f, 3.92501801e-02f, 1.00383058e-01f, 3.33136022e-02f, 5.53049892e-02f, 9.61675402e-03f,
  -2.31191628e-02f, -4.01068665e-02f, -4.38295230e-02f, 9.00033303e-03f, 3.10414247e-02f, -2.49381154e-03f, -5.36279045e-02f, 1.70847550e-02f, -3.87033224e-02f, -3.17716673e-02f,
  -6.41548857e-02f, -5.00838086e-02f, -2.29947199e-03f, -3.95128243e-02f, 1.63636357e-02f, -2.73479298e-02f, -2.86628064e-02f, 5.42962216e-02f, 8.72132741e-03f, 1.95793547e-02f,
  7.18761802e-01f, -1.23662561e-01f, -4.48994003e-02f, 1.89878061e-01f, 2.88378280e-02f, -3.13858211e-01f, 1.29259199e-01f, -2.01546371e-01f, 3.57485354e-01f, -2.41111085e-01f,
  2.79544275e-02f, 1.98818728e-01f, 2.05981761e-01f, -1.61894307e-01f, 2.51286149e-01f, 1.50150776e-01f, -4.01807651e-02f, -9.02496092e-03f, 1.17108718e-01f, -9.70915854e-02f,
  5.91791719e-02f, 7.45922327e-04f, -5.42841814e-02f, -2.05580309e-01f, 2.74960214e-04f, -6.88253716e-02f, -2.07361266e-01f, -9.32211801e-03f, -2.55193383e-01f, 4.97274809e-02f,
  -8.04639533e-02f, 1.15775384e-01f, -3.96381207e-02f, 1.41086467e-02f, -4.24704179e-02f, -6.20055944e-02f, -6.73808083e-02f, 7.63075277e-02f, 4.82732616e-02f, 4.54608649e-02f,
  4.52301092e-02f, 3.95705514e-02f, 1.66336019e-02f, 8.74678269e-02f, 5.43347560e-02f, -1.86199490e-02f, 2.11648252e-02f, -1.76768415e-02f, 3.99333127e-02f, 2.63952781e-02f,
  6.06264845e-02f, -5.73910773e-02f, -1.29073830e-02f, 1.74953379e-02f, 4.51120213e-02f, 8.69928822e-02f, -1.20907491e-02f, -3.13109974e-03f, -2.19324566e-02f, 4.87549193e-02f,
  2.30191723e-02f, -1.68958493e-02f, 1.21340305e-02f, -2.51816167e-03f, 3.99562679e-02f, -3.22337374e-02f, 6.03434779e-02f, -3.23104672e-02f, 7.28299916e-02f, -4.24003825e-02f,
  -2.50276979e-02f, 3.18724290e-02f, -1.01195546e-02f, -2.32882220e-02f, 9.45756398e-03f, -3.64480205e-02f, -1.22855762e-02f, -3.96173038e-02f, 2.80031022e-02f, -4.59501520e-02f,
  3.45880613e-02f, -3.55126821e-02f, 2.47526411e-02f, -4.27855551e-02f, 1.50306989e-02f, -9.38666705e-03f, 1.79602962e-03f, 1.14026777e-02f, -8.20880756e-03f, -2.00100914e-02f,
  -1.07184261e-01f, -1.82902589e-01f, 1.11399405e-02f, 2.20490303e-02f, -2.32735854e-02f, -1.35372672e-02f, 1.96350403e-02f, -3.56573276e-02f, -3.73371430e-02f, -2.15088967e-02f,
  -8.99612829e-02f, -1.15013989e-02f, -5.60901202e-02f, -2.57575717e-02f, -1.88228372e-03f, -2.92681064e-02f, -4.23606299e-02f, -5.75672351e-02f, -1.00537434e-01f, -1.59600601e-02f,
  -6.26570582e-02f, 4.74051386e-02f, 5.08772917e-02f, -2.42699347e-02f, -5.47133163e-02f, -5.00975847e-02f, -3.57693508e-02f, 2.08758656e-02f, -5.74352257e-02f, -2.67748795e-02f,
  -1.02241188e-01f, -2.55767286e-01f, -2.74552017e-01f, 7.63077382e-03f, 2.91950256e-01f, 1.50102032e-02f, -5.86198717e-02f, 1.67995870e-01f, -1.22715212e-01f, -5.72848730e-02f,
  1.95485309e-01f, -3.07390869e-01f, -2.26221204e-01f, 9.60023105e-02f, -5.30950204e-02f, -3.62208664e-01f, 1.13879479e-01f, -8.06649178e-02f, -8.83770585e-02f, 1.60889030e-01f,
  -1.23057945e-03f, 2.25772336e-01f, -8.24767947e-02f, 2.91497082e-01f, 1.55579299e-01f, -1.53568769e-02f, 2.55447477e-01f, 5.46114817e-02f, 8.29336345e-02f, -3.84743931e-03f,
  -3.09530012e-02f, -2.05981079e-02f, -1.05104242e-02f, -8.82012770e-02f, 8.44728723e-02f, 5.78222647e-02f, -9.18480195e-03f, -5.89619651e-02f, 3.46612521e-02f, -4.60723601e-02f,
  -5.94645999e-02f, 2.84223743e-02f, -1.84949022e-02f, 1.18759722e-02f, 1.09264962e-01f, -2.02010125e-02f, -6.79101469e-03f, 2.91752964e-02f, -7.77057707e-02f, -3.94819379e-02f,
  -6.42874464e-02f, -3.91800962e-02f, 6.65903240e-02f, -9.45668593e-02f, -2.85523962e-02f, 1.09477136e-02f, -7.12137446e-02f, -6.62755817e-02f, -9.97596141e-03f, -9.00979340e-03f,
  1.65067855e-02f, 4.85496409e-02f, -1.25801200e-02f, 2.40280409e-03f, -1.96464807e-02f, 2.58721858e-02f, -6.00431673e-03f, -1.12964055e-02f, 2.81061772e-02f, -1.04725023e-03f,
  3.77064720e-02f, -3.06747825e-04f, -1.05640218e-02f, 2.00849678e-02f, 2.97249272e-03f, -3.09197605e-02f, -1.62796956e-02f, -6.50801649e-03f, 1.11639900e-02f, 1.82484277e-02f,
  -1.92343332e-02f, 2.37915711e-03f, 1.92119423e-02f, 1.37336906e-02f, -2.33818069e-02f, -3.53267267e-02f, 1.26008445e-03f, -4.51037958e-02f, -1.82949624e-03f, 4.50102203e-02f,
  -4.78670001e-04f, -6.56915084e-03f, -4.14805338e-02f, 9.77738760e-03f, -4.64711040e-02f, 7.64704049e-02f, -1.63470600e-02f, -9.63476673e-03f, -4.46085967e-02f, 4.92899977e-02f,
  1.22610994e-01f, 1.26309972e-02f, 2.46301983e-02f, 2.72987671e-02f, -5.01246676e-02f, 5.19877896e-02f, 9.79399215e-03f, -1.29681348e-03f, 6.27415180e-02f, -9.04292613e-03f,
  9.48744863e-02f, 5.12152761e-02f, 1.12213315e-02f, 9.24796388e-02f, 5.23216836e-02f, 6.44692108e-02f, 6.30475804e-02f, -6.34288182e-03f, -1.79458188e-03f, -7.46497288e-02f,
  -6.38541281e-02f, 1.08546078e-01f, -1.95713737e-03f, 2.70651072e-01f, -7.45943636e-02f, 3.83998752e-01f, 3.73714000e-01f, 2.39191577e-03f, -1.83098108e-01f, 1.51098296e-01f,
  1.39875293e-01f, 8.31922218e-02f, -5.91673292e-02f, 3.08886945e-01f, 6.03949390e-02f, 5.58295697e-02f, 3.11473757e-01f, 2.64608085e-01f, -1.85984030e-01f, 1.82765216e-01f,
  -6.70431647e-03f, 1.77236855e-01f, 9.00871754e-02f, -2.33787701e-01f, 1.65864229e-01f, -8.45789239e-02f, 9.35161933e-02f, -1.88301384e-01f, 1.10144675e-01f, -4.48365323e-02f,
  -2.34366804e-02f, -1.88595444e-01f, 2.95950435e-02f, -8.81758109e-02f, 2.01483324e-01f, 1.00373819e-01f, 1.06978998e-01f, -7.04272762e-02f, -6.91164806e-02f, -2.39858720e-02f,
  7.48673156e-02f, 1.47410091e-02f, 2.52494197e-02f, -9.88866240e-02f, -4.25799042e-02f, -3.65699045e-02f, -3.28054167e-02f, -1.99004170e-02f, -3.35643440e-02f, 4.68933992e-02f,
  -2.11823899e-02f, 8.39010030e-02f, 9.14671794e-02f, 2.02440992e-02f, 1.78040173e-02f, -1.34051358e-02f, 8.18499997e-02f, 3.52611132e-02f, 9.00271386e-02f, -4.54506045e-03f,
  1.18224462e-03f, 4.12502466e-03f, 2.87410673e-02f, -1.09290540e-01f, 2.40864921e-02f, 1.07474846e-03f, -3.21351998e-02f, 2.40346808e-02f, -4.25288416e-02f, 5.56888208e-02f,
  1.20509779e-02f, 4.79950048e-02f, -7.12745115e-02f, 2.74686050e-02f, 2.42367312e-02f, 3.43199410e-02f, -3.33684385e-02f, -4.77558002e-03f, 2.38848533e-02f, 2.08684272e-04f,
  -5.86205609e-02f, 8.61773714e-02f, -4.87110205e-03f, 2.59622503e-02f, -1.79918185e-02f, -1.14062624e-02f, 2.89451666e-02f, -4.17132005e-02f, -8.80158972e-03f, 1.19678797e-02f,
  2.46048436e-01f, 2.11109355e-01f, -5.48823476e-02f, -2.04273909e-02f, -6.75800815e-02f, -2.37835236e-02f, -2.77024973e-02f, -6.44757319e-03f, 4.32127379e-02f, -2.82638855e-02f,
  6.05020151e-02f, 7.62200132e-02f, 2.17517260e-02f, 2.05459725e-02f, -2.09318511e-02f, -1.17194364e-02f, 8.10327083e-02f, 2.76367553e-02f, 1.02558948e-01f, 3.55601758e-02f,
  3.68894078e-02f, -5.10113612e-02f, -3.22170788e-03f, 7.42243379e-02f, 4.27686982e-02f, 4.71844375e-02f, -2.29663532e-02f, -6.57598823e-02f, -5.12251211e-03f, 3.93424258e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.49324358e-02f, 2.32712388e-01f, 3.54145765e-01f, 4.04200912e-01f, -4.55496013e-01f, -8.73889625e-01f, -6.07819915e-01f, -2.75868457e-02f, 5.13767526e-02f, -3.70955855e-01f,
  -3.20970237e-01f, 3.35225165e-01f, -3.05105094e-02f, 3.38800959e-02f, 2.77750909e-01f, 1.03618994e-01f, 3.39767337e-02f, -3.61255258e-02f, 3.09176683e-01f, 1.58764303e-01f,
  3.31863046e-01f, -3.20336074e-02f, 5.59581816e-01f, 1.61667857e-02f, 6.87389001e-02f, 2.96389520e-01f, 3.34480733e-01f, -4.69109565e-02f, 4.71341535e-02f, -3.09212301e-02f,
  -2.84775168e-01f, 1.02242731e-01f, 1.04768462e-01f, -6.38414100e-02f, 2.92052366e-02f, -1.14914209e-01f, -4.03220095e-02f, -1.03902124e-01f, 2.45907642e-02f, 2.42271996e-03f,
  3.24949855e-04f, 5.93135059e-02f, 3.88146788e-02f, 1.75617933e-02f, -8.16296935e-02f, 5.43683544e-02f, 1.38515100e-01f, 1.84771180e-01f, 7.17470273e-02f, 3.88315544e-02f,
  1.13445193e-01f, 2.49781404e-02f, 9.47880447e-02f, 2.03198269e-02f, 1.71289295e-01f, -7.21760020e-02f, -1.35833910e-02f, 5.02728932e-02f, 8.39419588e-02f, 4.93960157e-02f,
  4.18196432e-02f, -9.26547721e-02f, -7.82561079e-02f, -8.19047019e-02f, -3.66541371e-02f, -5.29151633e-02f, -2.67002638e-03f, -9.35055781e-03f, -3.60836498e-02f, 2.38774512e-02f,
  -9.00450919e-04f, 2.75186189e-02f, -4.53594849e-02f, -5.06752618e-02f, -6.61375420e-03f, -1.92946289e-02f, 1.08622499e-02f, -4.57332246e-02f, -3.54243629e-02f, 8.46910626e-02f,
  -6.55268645e-03f, -4.79139462e-02f, 8.78899638e-03f, -5.25582135e-02f, -1.00767910e-01f, -9.72842798e-03f, -7.28324428e-03f, 1.04241748e-03f, 3.68652120e-02f, 4.31814715e-02f,
  1.89958870e-01f, 3.54116976e-01f, -4.54153158e-02f, -6.76518828e-02f, 3.33732665e-02f, -2.15065200e-02f, 3.20533849e-02f, 2.93321460e-02f, 6.35753423e-02f, 4.84816767e-02f,
  2.12353352e-03f, -9.75023881e-02f, 1.62977092e-02f, 2.21097725e-03f, -2.63147708e-02f, 4.11570296e-02f, 6.10704422e-02f, 4.87242863e-02f, -2.58957185e-02f, 1.16742574e-01f,
  2.37704962e-02f, -9.95171741e-02f, 7.75843486e-02f, -6.43324777e-02f, -4.81955409e-02f, -2.28712820e-02f, -9.59424153e-02f, 1.80900898e-02f, 9.65564772e-02f, 1.13645047e-02f,
  2.63747782e-01f, -5.17705560e-01f, -2.63857603e-01f, 2.96097994e-01f, 1.09246410e-01f, 1.73441008e-01f, 8.56667608e-02f, -1.47140205e-01f, -3.49664330e-01f, -2.20446378e-01f,
  3.02493095e-01f, -9.91347991e-03f, -2.50241458e-01f, 7.38481581e-01f, 5.96611977e-01f, 5.60569577e-02f, 4.27396595e-01f, 2.48573989e-01f, -7.04327002e-02f, -7.64239058e-02f,
  1.40818089e-01f, 6.71552956e-01f, 1.81471363e-01f, 1.50134847e-01f, 3.22457850e-01f, -1.09981000e-01f, 2.24731937e-01f, -6.68957382e-02f, 4.41348910e-01f, 3.82961839e-01f,
  1.00189060e-01f, -8.33614692e-02f, -6.24297448e-02f, -6.22242354e-02f, -2.85782553e-02f, 3.64600606e-02f, 1.37754146e-03f, 1.69372946e-01f, 2.38148049e-02f, -7.01282322e-02f,
  -2.32471954e-02f, 1.01190574e-01f, 7.10985512e-02f, 3.07675172e-02f, -4.22300175e-02f, 2.86176819e-02f, -7.90396333e-02f, -2.69643571e-02f, -1.15181893e-01f, -5.88767417e-02f,
  -1.70594513e-01f, -4.79890034e-02f, -3.58956717e-02f, -1.11723440e-02f, -3.38116027e-02f, -4.03082371e-02f, 5.96159371e-04f, 2.79322062e-02f, -3.05691976e-02f, -1.29618030e-02f,
  6.38788044e-02f, -6.60050428e-03f, -7.29474947e-02f, 5.52680790e-02f, 1.83714237e-02f, 4.11358513e-02f, 8.87198653e-03f, 5.70593514e-02f, -5.91851212e-02f, 1.36019941e-02f,
  5.66092611e-04f, 3.85315306e-02f, 9.14135948e-03f, -7.67333806e-02f, 5.56019992e-02f, 3.71859130e-03f, 7.35057890e-02f, 4.12116311e-02f, -4.95904349e-02f, 4.21117805e-02f,
  1.50647359e-02f, -2.50000004e-02f, 2.59218067e-02f, 7.47065395e-02f, -2.14813836e-02f, 1.85697377e-02f, 2.67779059e-03f, -3.83206755e-02f, -5.02621196e-02f, 3.55014242e-02f,
  -4.37119091e-03f, -2.12602779e-01f, -6.64417148e-02f, 4.82195383e-03f, 1.29518341e-02f, -3.36284973e-02f, 6.48208782e-02f, 1.33090885e-02f, 4.14333353e-03f, -1.64919011e-02f,
  -2.25182213e-02f, -3.39049064e-02f, -3.95812243e-02f, 1.17588170e-01f, 5.28164059e-02f, -1.18355177e-01f, 2.23155506e-02f, 1.47610027e-02f, 3.42881009e-02f, -7.44025270e-03f,
  -6.81990013e-02f, -1.18100002e-01f, 7.27036297e-02f, -8.26644059e-03f, 1.01713590e-01f, -4.65703793e-02f, -3.55201028e-02f, -6.21211939e-02f, 5.11097647e-02f, -5.10194488e-02f,
  1.74944699e-01f, -3.62134933e-01f, 4.87660766e-02f, 4.37725693e-01f, 4.43236142e-01f, 4.89272773e-01f, 8.79745901e-01f, 1.61767736e-01f, 6.54182851e-01f, -2.15746269e-01f,
  -6.04973771e-02f, -1.89366058e-01f, 4.63486649e-02f, -2.53273323e-02f, 3.43607962e-01f, 1.61482215e-01f, 2.66628921e-01f, 1.62105203e-01f, 2.40057722e-01f, 6.10708036e-02f,
  1.75042301e-01f, 3.76486294e-02f, -1.94985196e-01f, -4.51462865e-01f, -6.36224449e-03f, -1.87856659e-01f, -1.93603590e-01f, 7.14305639e-02f, -2.94367492e-01f, -2.55504549e-02f,
  -4.91706133e-02f, 1.37433082e-01f, -1.15244523e-01f, -5.66272773e-02f, 3.60965705e-03f, -7.23951450e-03f, -2.02475991e-02f, -1.80062931e-02f, 3.48148048e-02f, 4.37923633e-02f,
  -2.94046160e-02f, -6.86154291e-02f, -3.95861566e-02f, 5.21364762e-03f, 5.64842112e-02f, -9.61318761e-02f, -1.43399552e-01f, -4.02512550e-02f, -5.95300272e-02f, -9.77886021e-02f,
  -2.00170994e-01f, -1.19337328e-01f, 8.12746212e-02f, -7.78134912e-02f, 1.09437946e-02f, 2.86529642e-02f, 3.79331149e-02f, -4.98204269e-02f, -4.08589505e-02f, 7.47245830e-03f,
  6.78953677e-02f, 1.11601822e-01f, -8.07532072e-02f, -5.50708473e-02f, -4.36590053e-02f, -6.48822412e-02f, -6.81311116e-02f, 3.78143229e-03f, -5.88840712e-03f, 4.73159291e-02f,
  5.05032241e-02f, -6.35797679e-02f, 5.81403188e-02f, 3.16142440e-02f, 8.81235749e-02f, 7.77148679e-02f, -3.59103233e-02f, -3.64097357e-02f, 3.42531167e-02f, -2.76733693e-02f,
  8.30489676e-03f, 3.21036242e-02f, -6.25017583e-02f, -5.69127575e-02f, -1.60201825e-02f, 1.74759906e-02f, -3.28095034e-02f, -2.01294385e-02f, 7.48754889e-02f, 5.02887927e-02f,
  1.31548807e-01f, 2.65850574e-01f, -1.69983227e-02f, -5.57487831e-02f, -3.61348912e-02f, -1.43334448e-01f, 9.35817733e-02f, 2.83552688e-02f, 1.06284030e-01f, 8.63990039e-02f,
  3.14974710e-02f, -6.23982446e-03f, -7.56696519e-03f, -1.83557216e-02f, 1.19276941e-02f, -2.67492067e-02f, 5.79987988e-02f, 1.04267351e-01f, 1.13063283e-01f, -1.59739092e-01f,
  -6.64672405e-02f, 6.68361112e-02f, 5.54079413e-02f, 1.98324174e-02f, 8.19693319e-03f, -2.76571605e-02f, 8.90082344e-02f, 6.00399636e-02f, -6.18425198e-02f, 3.40527296e-02f,
  7.49787509e-01f, 3.43887717e-01f, -2.31533930e-01f, 4.66989875e-02f, -4.89756949e-02f, 3.11279505e-01f, 1.46405116e-01f, 2.93405682e-01f, 6.83607906e-02f, 3.62364203e-01f,
  1.43588930e-01f, 6.03124276e-02f, -1.18576534e-01f, 4.49643224e-01f, 4.24310118e-01f, 9.82008949e-02f, 5.73951244e-01f, 1.63231418e-01f, -4.04391624e-02f, 3.11555952e-01f,
  1.77420303e-01f, 4.99668628e-01f, -2.09743857e-01f, 1.13623105e-01f, 2.04382792e-01f, -1.43029153e-01f, 4.44744751e-02f, -3.69386762e-01f, 6.11756602e-03f, 8.38039964e-02f,
  -8.54103789e-02f, 4.91812546e-03f, -2.66383551e-02f, -6.29128516e-02f, -5.24412654e-02f, 1.36271957e-02f, -1.61713079e-01f, -1.33820340e-01f, -2.05805585e-01f, -7.16453567e-02f,
  2.66917851e-02f, -2.06621531e-02f, 1.22015610e-01f, -1.94170978e-02f, 5.87097518e-02f, -3.90092768e-02f, -9.28341970e-02f, -2.74941493e-02f, -8.26376155e-02f, 7.58774430e-02f,
  -1.94445457e-02f, -1.05664553e-02f, -4.66055535e-02f, -2.94187721e-02f, -2.11035050e-02f, 3.71644832e-02f, -4.96792831e-02f, -5.68020307e-02f, 4.52076346e-02f, 7.92089552e-02f,
  2.34811217e-01f, 2.99582668e-02f, 9.48313624e-02f, 1.49271199e-02f, -8.03246070e-03f, 1.00841478e-03f, 4.85621244e-02f, -4.04882208e-02f, 4.08392698e-02f, 6.82709143e-02f,
  -6.66533187e-02f, 1.75507292e-02f, 2.98636202e-02f, 5.42166531e-02f, 1.06093451e-01f, 4.41164663e-03f, -5.77961095e-02f, 7.67321587e-02f, -8.48586392e-03f, -5.86477034e-02f,
  -4.46551219e-02f, 5.56484275e-02f, -7.44626578e-03f, -6.71128333e-02f, 2.98797470e-02f, -5.50520644e-02f, 1.57208130e-01f, 7.07821697e-02f, -7.71612972e-02f, 4.74863686e-02f,
  5.46873622e-02f, 5.03016949e-01f, -8.24834853e-02f, -1.09133422e-02f, -4.90872599e-02f, 1.40486345e-01f, 1.43244609e-01f, 1.24104649e-01f, 8.37559178e-02f, 2.23024815e-01f,
  1.63994059e-02f, -2.46502403e-02f, 9.86213535e-02f, -8.83878618e-02f, -9.90966707e-02f, 2.73774803e-01f, 4.55910340e-02f, -1.65980477e-02f, 4.65115234e-02f, 3.65287475e-02f,
  -4.70921472e-02f, 8.87922477e-03f, 4.52336520e-02f, -8.49564299e-02f, -2.21508332e-02f, 3.21266032e-03f, 2.82974541e-02f, -7.83506781e-02f, 4.34345938e-02f, -3.96227427e-02f,
  -1.15495108e-01f, -5.05241454e-01f, 4.98889118e-01f, -3.81866336e-01f, 2.71033198e-01f, 4.31641668e-01f, 2.28182346e-01f, 4.34166926e-04f, -3.32013071e-01f, -6.69141054e-01f,
  -7.34087452e-02f, -3.52483958e-01f, 2.35130861e-01f, -2.01970726e-01f, 7.94888675e-01f, 1.85044736e-01f, -1.03796735e-01f, -1.56931311e-01f, 1.55951623e-02f, -2.21172720e-01f,
  5.66564798e-02f, -3.28345835e-01f, 3.36377263e-01f, -2.90230989e-01f, -6.29071072e-02f, -2.12778836e-01f, -1.68484107e-01f, 1.17288671e-01f, -2.03237906e-01f, 1.79352328e-01f,
  -1.57432884e-01f, -3.98914784e-01f, -9.12849978e-02f, -3.83941121e-02f, 2.08223388e-02f, -3.07147522e-02f, 3.11106946e-02f, 1.30469754e-01f, -7.24579068e-03f, 6.09338619e-02f,
  -5.71990013e-02f, 2.30723284e-02f, -9.05589163e-02f, -2.88146902e-02f, -3.79486941e-02f, -2.07278822e-02f, 8.48826841e-02f, 6.74892440e-02f, -4.51685227e-02f, 2.57476032e-01f,
  9.97340605e-02f, 6.91793710e-02f, 6.32461905e-02f, -7.13990554e-02f, 1.28562540e-01f, 6.62450418e-02f, 3.17136161e-02f, 1.00487664e-01f, -3.01839877e-02f, -2.43495163e-02f,
  3.12124267e-02f, -3.80147807e-02f, 6.65220991e-03f, -3.53698134e-02f, 1.10514113e-03f, 4.84695919e-02f, -6.44861385e-02f, 2.46554893e-02f, -3.23273204e-02f, 3.49780358e-02f,
  1.97064076e-02f, -4.49543484e-02f, -3.32698300e-02f, 7.63326045e-03f, -1.12282764e-03f, -2.61149462e-02f, -8.19193758e-03f, -5.56725189e-02f, -4.25256677e-02f, 2.42569093e-02f,
  -7.09664524e-02f, 9.78397056e-02f, 1.09927962e-03f, -3.52581893e-03f, -1.03141693e-02f, 2.51101181e-02f, -4.49654385e-02f, 4.53210399e-02f, 6.04697056e-02f, 1.17044076e-01f,
  -4.72519040e-01f, -6.97766423e-01f, -1.52337596e-01f, -1.80976376e-01f, -1.29770339e-01f, -4.84344736e-02f, -8.94776955e-02f, -4.88079246e-03f, -8.21278840e-02f, -2.38604862e-02f,
  -6.30409196e-02f, -2.25620493e-02f, -7.66274557e-02f, -2.58944891e-02f, -3.62528339e-02f, -5.45525551e-02f, -1.25679970e-01f, -2.30434924e-01f, -1.31620690e-01f, -1.14199050e-01f,
  -1.07284375e-01f, -1.16638966e-01f, 5.66343702e-02f, -8.61700401e-02f, -1.51824757e-01f, -4.17236499e-02f, -9.64861214e-02f, -5.73035888e-02f, 7.43804034e-03f, -9.73502025e-02f,
  -7.30906963e-01f, 2.50275165e-01f, -5.85500360e-01f, -6.52840614e-01f, -1.98110342e-01f, -5.39575994e-01f, -3.34558815e-01f, -2.54743006e-02f, 9.58318040e-02f, 5.65953076e-01f,
  1.17536321e-01f, -1.78305179e-01f, 6.38225794e-01f, -3.11474621e-01f, -4.92344320e-01f, 3.54420483e-01f, -4.79444444e-01f, -1.37943119e-01f, 4.67693433e-02f, -4.06257004e-01f,
  -2.69276649e-01f, -1.50416568e-01f, -2.68535256e-01f, 8.78492072e-02f, -4.24733162e-01f, -2.13154539e-01f, 9.04007107e-02f, 4.52238927e-03f, -3.21601123e-01f, -1.18645497e-01f,
  -2.05765903e-01f, -5.76405376e-02f, -1.92726463e-01f, -2.97514368e-02f, -1.92797810e-01f, -1.20147817e-01f, -1.50097996e-01f, -1.11804485e-01f, -1.67584464e-01f, -7.92562887e-02f,
  1.86995994e-02f, -1.52205052e-02f, -4.68863323e-02f, 1.05478182e-01f, -1.91728268e-02f, 3.10079474e-02f, -3.17745097e-02f, -6.08578771e-02f, -6.68103248e-02f, -5.19351102e-02f,
  -3.89649048e-02f, -1.01235181e-01f, -7.49021247e-02f, 1.38268201e-02f, -8.66691768e-02f, -7.14743063e-02f, -1.23054869e-01f, -8.91251042e-02f, -9.14053023e-02f, -1.17694601e-01f,
  8.69940817e-02f, -1.21550076e-02f, 3.25521408e-03f, 2.61757360e-03f, -4.11072895e-02f, 5.67045175e-02f, 2.32615452e-02f, 4.06622328e-02f, 1.05773201e-02f, -1.55040645e-04f,
  -2.52751000e-02f, -3.11817098e-02f, 7.30008334e-02f, -8.79961699e-02f, 3.32398526e-02f, 2.58015878e-02f, 1.87531840e-02f, 9.29755904e-03f, -2.37663346e-03f, 3.85130718e-02f,
  7.33476803e-02f, 6.11696206e-03f, 7.35333040e-02f, 1.87404249e-02f, -2.74572838e-02f, 2.43037548e-02f, 1.84162352e-02f, -3.23182344e-02f, 2.72433497e-02f, 2.99040228e-02f,
  -2.36595482e-01f, -1.39349699e-01f, -4.99357767e-02f, -8.47727805e-03f, -1.01929838e-02f, -4.38394211e-02f, -2.58559566e-02f, -8.90937671e-02f, -1.14160240e-01f, 4.07395661e-02f,
  -6.39881417e-02f, 4.77423752e-03f, -1.29012004e-01f, -3.64913903e-02f, 3.05478219e-02f, -1.08280368e-01f, -2.32382845e-02f, -4.84733656e-02f, -1.01381235e-01f, -9.45863128e-02f,
  -1.85538922e-02f, 6.88406453e-02f, 1.57677308e-02f, 7.58057833e-03f, -3.71837355e-02f, -3.93733978e-02f, 9.30885039e-03f, -7.27839023e-02f, -1.16325103e-01f, -1.06682405e-02f,
  7.50000358e-01f, -2.09685609e-01f, 3.38739872e-01f, 8.16077292e-01f, 4.23460901e-02f, -1.46915257e-01f, -3.61996628e-02f, 1.63286716e-01f, 7.29994237e-01f, -2.97670096e-01f,
  -3.02005678e-01f, 2.98596293e-01f, -8.14057946e-01f, 3.85231644e-01f, -2.25056887e-01f, -5.22905171e-01f, 2.13589951e-01f, 2.01024398e-01f, 6.17605411e-02f, 9.39005390e-02f,
  2.93308586e-01f, -2.20479459e-01f, -1.37208208e-01f, -2.34447807e-01f, 3.23899359e-01f, 2.68159270e-01f, -4.12235618e-01f, -3.76059800e-01f, 1.38277724e-01f, -1.52853012e-01f,
  1.78667717e-02f, 9.57634374e-02f, 8.31625238e-02f, 5.33618927e-02f, 9.58907977e-03f, 2.80739237e-02f, -4.16829064e-02f, -1.11266963e-01f, 2.52305921e-02f, 9.83131770e-03f,
  -1.92102082e-02f, -1.59319378e-02f, 1.73207998e-01f, -8.55647177e-02f, 1.90945342e-01f, 1.44781843e-01f, 1.51811063e-01f, 1.67755336e-01f, 1.66428328e-01f, 1.20385721e-01f,
  9.22616944e-02f, 1.27386048e-01f, 1.06559500e-01f, 5.22058420e-02f, 3.24802995e-02f, 6.98214620e-02f, 3.65726314e-02f, -6.22166879e-02f, 1.00269318e-01f, 5.82293645e-02f,
  -2.13521384e-02f, -1.21672183e-01f, -5.83076663e-02f, 4.81455661e-02f, -4.02365848e-02f, 3.71071286e-02f, -2.13436112e-02f, -2.07715090e-02f, 5.45541570e-02f, -1.61929335e-02f,
  5.47374003e-02f, 7.08839148e-02f, 3.97496969e-02f, 5.25226630e-02f, -7.11774733e-03f, 1.19464979e-01f, -1.35497302e-02f, 1.17371781e-02f, 6.55519366e-02f, 6.93742335e-02f,
  -9.14294049e-02f, 5.68164438e-02f, -9.95582640e-02f, -1.04726052e-04f, -5.77009656e-02f, -9.43849087e-02f, 1.14988107e-02f, 1.34699047e-03f, 6.82419613e-02f, -2.49375422e-02f,
  -4.74211246e-01f, -4.66150999e-01f, -1.01910740e-01f, -1.51706627e-02f, -7.94081241e-02f, -2.79440433e-02f, 1.08515948e-01f, 9.68929827e-02f, -1.01093270e-01f, -2.23848559e-02f,
  -4.61438186e-02f, 8.68051797e-02f, -5.27150296e-02f, 1.12099223e-01f, -9.07661915e-02f, -6.27659634e-02f, -7.33902976e-02f, -1.16339773e-01f, -6.01410344e-02f, 3.35608027e-03f,
  4.01335135e-02f, -1.19222999e-01f, 6.26513287e-02f, 7.62829483e-02f, 3.27157043e-02f, -5.29327802e-02f, 1.28391664e-02f, -1.37118977e-02f, -1.00354023e-01f, -3.80078889e-02f,
  -4.34640765e-01f, -4.12829556e-02f, 3.16908136e-02f, 5.01916893e-02f, -4.37837660e-01f, 2.64064699e-01f, 6.28246188e-01f, -3.00045967e-01f, -9.71638262e-02f, 4.36449051e-01f,
  3.29778612e-01f, -6.87953085e-02f, 4.34942037e-01f, 3.28743964e-01f, 1.22123510e-01f, 4.74589705e-01f, 4.45798665e-01f, 4.81900096e-01f, -1.83109418e-01f, -7.95332417e-02f,
  -9.55674574e-02f, 1.04960419e-01f, 2.23671913e-01f, -3.24571639e-01f, 1.08005358e-02f, -3.35945070e-01f, -3.11331754e-03f, -6.97307438e-02f, -4.99961488e-02f, 2.60347239e-04f,
  -1.84585571e-01f, -2.16190204e-01f, 2.82436740e-02f, -1.01058356e-01f, -8.33120868e-02f, -1.70662161e-02f, 4.00355868e-02f, 4.68056351e-02f, -2.85282377e-02f, -9.58570018e-02f,
  -5.21617271e-02f, -8.90646577e-02f, -6.26956299e-02f, 2.53754780e-02f, -1.27186105e-01f, -9.07579139e-02f, -8.28794315e-02f, 5.73427640e-02f, -2.88790576e-02f, -5.15710190e-02f,
  2.68642865e-02f, -2.90998314e-02f, 7.69211501e-02f, 1.06102616e-01f, 2.06630118e-02f, 2.19602734e-02f, 7.45273978e-02f, -5.43494476e-03f, -1.23376427e-02f, -6.36718608e-03f,
  -2.72354390e-02f, -1.76091325e-02f, 6.19835183e-02f, -4.43476401e-02f, -6.98548034e-02f, -4.05623810e-03f, 4.25484776e-02f, -3.33997048e-02f, 3.70915458e-02f, -1.79836396e-02f,
  -2.46163793e-02f, -6.49395958e-02f, 4.35859710e-02f, 8.47249404e-02f, 2.34766118e-02f, 4.68099266e-02f, 6.14046492e-02f, -5.71062490e-02f, -9.42191482e-03f, -6.01680055e-02f,
  8.24267492e-02f, -3.27289887e-02f, 7.12721571e-02f, -1.24794468e-02f, -1.25164725e-02f, 4.00253832e-02f, 7.89085682e-03f, 9.18112509e-03f, 4.26115356e-02f, 7.36626163e-02f,
  -1.22739866e-01f, -2.42166504e-01f, -6.02472201e-02f, -3.35962768e-03f, -1.50670614e-02f, -1.76949129e-02f, 4.45159860e-02f, -7.51092583e-02f, -8.68605450e-02f, 2.51760967e-02f,
  -2.66322941e-02f, 1.78547110e-02f, -3.45177278e-02f, 2.33863387e-02f, 4.67722826e-02f, 2.63910019e-03f, 3.15272771e-02f, -3.38736549e-02f, 1.69524439e-02f, -1.46967947e-01f,
  1.08727384e-02f, -1.15656862e-02f, 2.44691223e-02f, -3.21468599e-02f, -2.15321332e-02f, 8.59657824e-02f, -1.53114676e-01f, -9.37440693e-02f, -3.21632698e-02f, -2.48755626e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.58525258e-01f, 3.39227855e-01f, 4.84999776e-01f, 5.04602909e-01f, 6.11266553e-01f, 7.63045013e-01f, 6.72616243e-01f, 2.93711513e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.70998794e-01f, -3.98125835e-02f, 2.28952140e-01f, -6.00233495e-01f, 2.80403167e-01f, -4.18086290e-01f, -2.60928392e-01f, 5.66737235e-01f, -2.87571877e-01f, 2.13137358e-01f,
  -9.61347967e-02f, -8.95197392e-02f, -1.98386520e-01f, 4.21147048e-01f, -5.44447660e-01f, 1.35538816e+00f, -1.16114758e-01f, 2.66046543e-02f, 2.53501356e-01f, -6.75779998e-01f,
  2.54051000e-01f, 1.47508428e-01f, 6.14830613e-01f, -7.80680869e-03f, -6.72479630e-01f, 6.68618858e-01f, 2.39128977e-01f, 1.33195925e+00f, -3.55911672e-01f, -6.40772164e-01f,
  -6.81689739e-01f, 1.41797230e-01f, -7.07777366e-02f, 2.04781070e-01f, -6.52607322e-01f, 1.79213714e-02f, 4.11846459e-01f, -3.32168967e-01f, 4.60447073e-01f, -1.23698100e-01f,
  -2.92705417e-01f, 1.20022178e+00f, -3.94930691e-01f, -1.49907991e-01f, 1.18346810e-01f, -5.85777223e-01f, 6.91254973e-01f, -2.67105490e-01f, 1.37137026e-01f, 6.31810248e-01f,
  6.80211544e-01f, -7.56494999e-01f, -2.55645722e-01f, -1.96953788e-02f, 2.58112460e-01f, -8.14418435e-01f, -3.84198844e-01f, -3.31765503e-01f, -6.84776977e-02f, -4.30321783e-01f,
  -7.36974657e-01f, 1.20964122e+00f, -2.62634099e-01f, -4.44777161e-01f, 2.39326388e-01f, 8.27035367e-01f, 6.00293636e-01f, 5.10170937e-01f, 9.08177316e-01f, -7.34179854e-01f,
  -6.22942567e-01f, -5.90487719e-01f, 1.75777167e-01f, -3.29259157e-01f, -2.69012332e-01f, -4.21784401e-01f, 1.22374570e+00f, 1.61234975e-01f, -5.07138312e-01f, 8.44979435e-02f,
  -2.35742871e-02f, 4.39854980e-01f, 6.24735579e-02f, 2.27869347e-01f, 6.63098276e-01f, 8.40877235e-01f, -1.06054366e+00f, 6.12009048e-01f, -2.32193381e-01f, -5.72945595e-01f,
  1.20309341e+00f, 5.47771394e-01f, -7.02890635e-01f, -1.46757870e-03f, 1.26776204e-01f, 2.27986619e-01f, 2.36904696e-02f, -3.25840831e-01f, 2.31111005e-01f, -1.72707990e-01f,
  -1.85918123e-01f, 6.37032330e-01f, 3.28575730e-01f, -3.56658041e-01f, -3.25930893e-01f, -3.08907449e-01f, 9.27361012e-01f, -1.66319862e-01f, 3.49700391e-01f, -6.00587606e-01f,
  1.10128367e+00f, -2.61010289e-01f, 6.42805621e-02f, -9.23462927e-01f, -5.41482151e-01f, -6.17563844e-01f, 3.92089695e-01f, 8.85711372e-01f, -4.18187946e-01f, -2.49618456e-01f,
  7.66014457e-01f, -3.57078433e-01f, -2.70706177e-01f, -1.26748741e-01f, 4.64884907e-01f, 9.09485579e-01f, -2.60991931e-01f, -2.34023169e-01f, -5.07405996e-01f, -2.59283781e-01f,
  3.59162949e-02f, 2.57682800e-02f, -4.85708892e-01f, 1.99029576e-02f, 4.21744883e-02f, 4.02792960e-01f, 1.30683672e+00f, 2.04010621e-01f, -1.81148291e-01f, 4.87159401e-01f,
  -1.05137855e-01f, -6.06644511e-01f, -2.97285289e-01f, -4.67152923e-01f, 9.17110220e-02f, 8.26921463e-02f, 3.01560789e-01f, 2.29727030e-01f, -7.46248662e-01f, 8.44556451e-01f,
  -5.96621573e-01f, 1.25538722e-01f, -1.41222313e-01f, 2.69566447e-01f, 4.96735454e-01f, -7.02170193e-01f, 1.14010549e+00f, -8.48880231e-01f, -5.15620530e-01f, 4.85638916e-01f,
  4.39641923e-01f, -6.02364421e-01f, -2.75169134e-01f, 1.12520742e+00f, -1.14148891e+00f, -1.28656173e+00f, 1.57959080e+00f, -7.87037686e-02f, -2.76133984e-01f, -3.92297179e-01f,
  1.33084238e-01f, -1.59610629e-01f, -2.72086650e-01f, 4.76564467e-01f, -1.25724360e-01f, -2.18801677e-01f, -4.22487175e-03f, 3.07625383e-01f, 7.10527301e-02f, 5.89570999e-01f,
  -6.44406557e-01f, 2.26261064e-01f, -1.04710746e+00f, -3.45912315e-02f, 2.42245153e-01f, -6.69107199e-01f, -7.52988279e-01f, -4.36936170e-01f, -3.91223460e-01f, -2.59101182e-01f,
  1.49409044e+00f, -2.45185077e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.84662920e-01f, -2.19712004e-01f, -2.50405937e-01f, -1.30120248e-01f, 2.54786402e-01f, 1.91019759e-01f, -3.59104216e-01f, -4.27211851e-01f, -4.27122980e-01f, -1.50784910e-01f,
  6.04802430e-01f, 1.50098532e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    