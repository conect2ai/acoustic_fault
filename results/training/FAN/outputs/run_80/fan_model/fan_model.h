/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.62813638e-02f, 4.82868813e-02f, 7.29252100e-02f, -3.55081171e-01f, 5.02076447e-02f, -1.68282613e-01f, -2.16348559e-01f, -4.77236472e-02f, -2.03150317e-01f, -1.73479840e-02f,
  -1.66975707e-01f, 6.23184852e-02f, -2.77445074e-02f, -3.68334174e-01f, -2.75734425e-01f, -1.45896539e-01f, -2.93115497e-01f, -1.74521297e-01f, -3.76374051e-02f, 2.90115122e-02f,
  -1.29501075e-01f, -1.45877078e-01f, -1.59845427e-01f, -6.05612025e-02f, -6.22202493e-02f, 9.50778723e-02f, 2.25075800e-02f, 1.14385776e-01f, 3.21197696e-02f, -5.87068219e-03f,
  2.57170107e-02f, 1.19544178e-01f, 6.48058429e-02f, 4.97187153e-02f, 3.54410969e-02f, 7.02328756e-02f, 1.12882964e-01f, 8.12649727e-02f, 7.23742992e-02f, 3.67059140e-03f,
  1.07398421e-01f, -1.52342469e-02f, -3.88300940e-02f, 5.21090953e-03f, -1.21278286e-01f, -3.93828228e-02f, -7.90170208e-02f, -4.82180603e-02f, -1.37118131e-01f, -3.26295905e-02f,
  -9.89822522e-02f, -1.01560345e-02f, -7.78072551e-02f, -9.87595841e-02f, -4.58933301e-02f, -3.79030481e-02f, 1.20339962e-02f, 3.22566554e-02f, 4.08776402e-02f, -6.01769648e-02f,
  -4.37777303e-02f, 8.30045640e-02f, 1.05890185e-01f, -7.60802580e-03f, 2.94328593e-02f, 3.99465896e-02f, 2.40827817e-02f, 2.16242950e-02f, 4.91047166e-02f, -1.47289261e-01f,
  -4.88910191e-02f, -4.65297513e-03f, -5.44675849e-02f, 2.30887216e-02f, -1.30778383e-02f, 2.01823674e-02f, -2.60499492e-02f, -2.27245819e-02f, -2.86693089e-02f, 5.10820262e-02f,
  -1.24342693e-02f, -2.56157573e-02f, -3.76645140e-02f, -1.99261904e-02f, -9.49095115e-02f, 2.36338191e-02f, -1.17650256e-01f, -3.25320773e-02f, 3.96639630e-02f, 3.11625432e-02f,
  9.35223326e-02f, 9.98132005e-02f, -5.09604886e-02f, -9.13785994e-02f, 4.94879447e-02f, -9.42471996e-03f, -5.01887873e-02f, -2.31662542e-02f, 6.23857640e-02f, 1.06210507e-01f,
  2.19326857e-02f, 8.11893791e-02f, 3.66194509e-02f, -4.16075438e-02f, -1.04893476e-01f, 2.21037790e-02f, -2.84276642e-02f, 6.09491915e-02f, -4.71574366e-02f, -9.92215648e-02f,
  -1.30393328e-02f, 1.60870686e-01f, -2.86648492e-03f, 8.43973085e-02f, 2.24902891e-02f, 1.30050653e-03f, 3.89208980e-02f, -2.12681107e-02f, -7.16281161e-02f, 2.35355739e-02f,
  -5.10990173e-02f, 1.34654731e-01f, -2.16514021e-01f, -2.25753665e-01f, -1.57093599e-01f, 2.24555105e-01f, -8.87362473e-03f, -6.30471334e-02f, -5.14271498e-01f, 3.44124466e-01f,
  1.75482363e-01f, -5.41120358e-02f, 3.18672843e-02f, 1.82072431e-01f, 4.35631573e-02f, 5.80549166e-02f, 1.00241393e-01f, 3.69090699e-02f, -2.88035572e-01f, 1.05002232e-01f,
  -1.69560954e-01f, 1.49208561e-01f, 1.02686053e-02f, 9.58856270e-02f, 3.28452028e-02f, -1.63040310e-01f, 2.23836452e-01f, -2.00863406e-01f, 1.71469510e-01f, 7.82604367e-02f,
  8.46179649e-02f, -7.76648596e-02f, -3.36681791e-02f, -6.70426935e-02f, 9.86164957e-02f, 1.31424535e-02f, 8.80173221e-02f, -1.05556667e-01f, -7.18838871e-02f, -1.83459055e-02f,
  8.87599885e-02f, -1.04518607e-02f, -6.40207436e-03f, -9.93713140e-02f, -1.69346184e-01f, -7.51522630e-02f, -7.38016143e-02f, 2.51396224e-02f, -6.90268576e-02f, -1.27853736e-01f,
  -7.64613179e-03f, -8.53563622e-02f, -2.87069893e-03f, 6.06107153e-02f, -1.65805612e-02f, -4.51307977e-03f, 3.00280731e-02f, 1.09476201e-01f, -4.72104549e-02f, -2.96269953e-02f,
  6.83271289e-02f, -1.06013149e-01f, -6.15756698e-02f, -5.08937612e-02f, 1.34330271e-02f, -2.75125094e-02f, -2.98443846e-02f, 2.61546969e-02f, 7.90194497e-02f, -4.15767059e-02f,
  3.71946730e-02f, -4.52060327e-02f, -6.41721711e-02f, -9.77768973e-02f, -1.10270064e-02f, 2.65275165e-02f, 6.29410520e-02f, 7.64782578e-02f, 2.00976189e-02f, -1.28480224e-02f,
  -2.03766786e-02f, -6.59022704e-02f, 6.81649148e-03f, -4.84882779e-02f, 7.12825963e-03f, -3.29386517e-02f, -4.14041020e-02f, -3.42635214e-02f, -1.23564884e-01f, 8.84853769e-04f,
  1.42910093e-01f, 1.75116941e-01f, 4.44563366e-02f, -1.32197421e-03f, 5.37313335e-02f, 1.21443823e-01f, -4.58717942e-02f, 7.80195817e-02f, 9.01398361e-02f, 6.09458126e-02f,
  7.26359012e-03f, -4.14095027e-03f, 5.46816699e-02f, -2.66379621e-02f, 2.06945185e-02f, -4.38319743e-02f, 6.44765496e-02f, 4.61184941e-02f, 1.15014426e-01f, 3.14670801e-02f,
  9.36377794e-02f, 8.61876234e-02f, 1.52724069e-02f, -5.13549186e-02f, 1.42602995e-01f, 7.56161287e-02f, -8.41946434e-03f, -8.38620141e-02f, 2.63312887e-02f, -1.46511169e-02f,
  1.83639258e-01f, -1.03472628e-01f, 2.67903447e-01f, -8.12437013e-03f, 1.67281672e-01f, 7.88698867e-02f, 2.80962009e-02f, -3.78933875e-03f, 4.67297845e-02f, -2.88565427e-01f,
  -1.35707200e-01f, 1.45355701e-01f, -3.09188783e-01f, -3.52448337e-02f, 2.90058613e-01f, 4.58715903e-03f, 3.04744747e-02f, -2.90136803e-02f, 1.64827481e-02f, -4.65011522e-02f,
  8.31603408e-02f, -1.31504416e-01f, -4.75828507e-04f, 3.80799510e-02f, -2.41851923e-03f, 8.29124376e-02f, -1.23633169e-01f, 1.77933592e-02f, -1.13456193e-02f, 1.71937086e-02f,
  -4.05964255e-02f, -5.86674698e-02f, -5.08146472e-02f, -8.56936201e-02f, -6.77150935e-02f, -1.77898929e-02f, -7.87983537e-02f, 1.00193456e-01f, 1.00184657e-01f, 2.95122098e-02f,
  7.42060244e-02f, -4.58905026e-02f, -2.34025680e-02f, 7.96839073e-02f, -7.38655180e-02f, 1.31890178e-01f, 6.34278357e-02f, 8.72398540e-02f, 4.76280265e-02f, -2.75102090e-02f,
  2.47982889e-02f, 3.47889811e-02f, 5.49987517e-02f, -3.40883248e-02f, 2.92492919e-02f, 5.60715944e-02f, 1.74680632e-02f, 8.02616104e-02f, -4.08900641e-02f, 1.40327858e-02f,
  1.02474727e-02f, 4.84535471e-02f, 6.73071668e-02f, -3.30876224e-02f, 1.02951620e-02f, 8.10159091e-03f, -1.26655307e-02f, 2.38316283e-02f, -3.37814204e-02f, -9.05729923e-03f,
  1.11380192e-02f, 2.43056584e-02f, 1.90073252e-02f, -1.51360361e-02f, -1.13254547e-01f, -5.70428884e-03f, -1.05657270e-02f, 1.08672917e-01f, 8.50563198e-02f, -2.42161080e-02f,
  -3.74166444e-02f, -1.23802386e-02f, -2.20856294e-02f, -3.75035517e-02f, -1.82954744e-02f, -9.37243924e-04f, -1.01331927e-01f, 1.20535806e-01f, 5.85005768e-02f, -2.21531726e-02f,
  -3.21601421e-01f, -2.00055048e-01f, -7.27522448e-02f, -6.39578775e-02f, 8.15252017e-04f, 5.48049435e-02f, 2.69916374e-02f, 5.22343181e-02f, -3.32390293e-02f, -1.32925659e-01f,
  -7.87498653e-02f, -1.04328401e-01f, -5.76556399e-02f, -1.14425063e-01f, -3.52744982e-02f, -1.71664730e-02f, -2.10259780e-02f, -3.46258134e-02f, -1.31408423e-01f, -1.51358768e-01f,
  -3.15977330e-03f, -6.59234896e-02f, 1.89909324e-01f, 1.19055517e-01f, -9.31669250e-02f, -3.25466767e-02f, 8.02277699e-02f, 1.10795274e-01f, 7.30419159e-02f, -4.94392067e-02f,
  -4.96310264e-01f, -2.37871408e-01f, -1.08782411e-01f, -1.67348981e-01f, -7.93149471e-02f, -3.31231982e-01f, -2.89050549e-01f, -6.91424832e-02f, -2.22577631e-01f, -9.34846625e-02f,
  2.86891847e-03f, 3.84045672e-03f, 1.36238217e-01f, -8.26532319e-02f, -3.51380669e-02f, 1.51036426e-01f, -2.13524446e-01f, -5.91042414e-02f, -2.10366789e-02f, -7.83357248e-02f,
  8.79178941e-03f, -7.65378326e-02f, 2.07862169e-01f, 8.49737674e-02f, -1.85710594e-01f, 7.30941966e-02f, 2.38415271e-01f, 3.27567710e-03f, -6.93854876e-03f, -7.93977976e-02f,
  -1.43847048e-01f, -4.81733307e-02f, 1.75004136e-02f, -3.74774449e-02f, 1.24165295e-02f, 9.56408978e-02f, 5.21260798e-02f, -9.10200644e-03f, 3.05375103e-02f, 3.38217430e-02f,
  -1.20791057e-02f, -2.95419954e-02f, -1.03634526e-03f, -2.23536622e-02f, -4.84470017e-02f, -1.13324740e-03f, 2.08159555e-02f, -5.71155101e-02f, 2.24394631e-02f, 7.29345307e-02f,
  -3.78116895e-03f, -1.61123518e-02f, 6.24327026e-02f, 4.89042886e-02f, 8.14681798e-02f, 2.86628194e-02f, 3.36504355e-02f, 9.42631215e-02f, 3.94484438e-02f, 3.96282300e-02f,
  8.24617296e-02f, 1.63636485e-03f, -9.14166644e-02f, -1.17651075e-02f, -1.85197350e-02f, 1.58889331e-02f, 8.06032680e-03f, 1.48052663e-01f, -2.44346145e-03f, 1.68566518e-02f,
  -1.11105047e-01f, -2.58947257e-02f, 4.20430973e-02f, -2.95455521e-03f, -4.59607095e-02f, 4.73468751e-02f, -2.47574225e-02f, -3.74391228e-02f, -2.25018822e-02f, -3.79315228e-03f,
  -9.32915602e-03f, -1.10965118e-01f, -5.71413301e-02f, 9.57067609e-02f, -1.82849113e-02f, 2.74600964e-02f, -3.08878589e-02f, -2.42457055e-02f, 2.87384633e-02f, -3.00508346e-02f,
  -2.13290006e-01f, -6.83244690e-02f, 4.42886315e-02f, -6.14555776e-02f, -4.02597189e-02f, -4.15091440e-02f, 2.66582221e-02f, -1.14626691e-01f, -2.84823440e-02f, -1.26367390e-01f,
  6.29356951e-02f, -2.21187584e-02f, 9.58823506e-03f, 4.18549590e-02f, -1.64896417e-02f, -4.18472514e-02f, 1.26517173e-02f, -1.11489162e-01f, 1.08213583e-02f, 2.82212012e-02f,
  3.65193635e-02f, -6.62031537e-03f, -1.84928868e-02f, -6.35805679e-03f, 7.36350641e-02f, -2.77462993e-02f, 1.90334599e-02f, 1.83574446e-02f, 4.80749272e-02f, -2.54772510e-02f,
  1.16000488e-01f, -3.14353168e-01f, -3.39161336e-01f, 1.11809149e-01f, 1.97555900e-01f, 1.78873941e-01f, 2.84239352e-02f, 9.31419432e-02f, -1.71183378e-01f, -1.77037548e-02f,
  1.23567320e-01f, -3.92076552e-01f, -1.84538588e-01f, 9.54832584e-02f, 4.19179760e-02f, -1.80504262e-01f, 1.94586858e-01f, -1.22917779e-02f, -8.09166282e-02f, -1.51185989e-02f,
  2.17126794e-02f, 2.57117391e-01f, -1.45794988e-01f, 1.07315652e-01f, 4.98109311e-02f, -1.12988114e-01f, 4.66093957e-01f, -2.14509182e-02f, 1.84354573e-01f, 6.38818741e-02f,
  -9.35878046e-03f, -1.12359345e-01f, -6.43715784e-02f, -3.51973400e-02f, 1.94669887e-02f, 1.03879124e-01f, -6.52834177e-02f, -7.59874284e-02f, 1.10886823e-02f, -9.25755594e-03f,
  5.78458840e-03f, 5.44269383e-02f, 5.64343706e-02f, 5.94047196e-02f, 7.07659945e-02f, 4.50537959e-03f, -1.38297016e-02f, 5.98096475e-03f, -6.77866936e-02f, -2.45885961e-02f,
  -5.49988933e-02f, -1.16866790e-01f, 1.30950725e-02f, -3.18131857e-02f, -1.00147225e-01f, -6.56121746e-02f, -1.52214887e-02f, -1.12259038e-01f, -1.11859646e-02f, -7.30928257e-02f,
  2.12491886e-03f, -1.69296954e-02f, 3.52532826e-02f, 3.04764248e-02f, 2.37758141e-02f, 3.73873785e-02f, 6.89965412e-02f, 5.10666184e-02f, 6.76579177e-02f, -1.65675357e-02f,
  5.44028822e-03f, 2.54384317e-02f, 7.64280707e-02f, 7.37638399e-02f, -3.41122970e-02f, -5.82084134e-02f, 4.06706054e-03f, -1.30586987e-02f, 2.12021042e-02f, 6.89703599e-02f,
  5.18381819e-02f, 1.20232970e-01f, -5.62037574e-03f, 1.71925221e-02f, -7.28837922e-02f, -1.55934524e-02f, 2.39428747e-02f, 2.82761808e-02f, -4.16889042e-02f, 2.96992939e-02f,
  -9.44895390e-03f, 4.81280545e-03f, -5.83350658e-02f, -8.67294371e-02f, -1.87450461e-02f, 6.59401119e-02f, -1.49015896e-02f, -9.65207815e-02f, -1.06513120e-01f, -3.19530279e-03f,
  3.59468982e-02f, 3.62828933e-02f, 1.85449887e-02f, 6.42975867e-02f, -2.14751568e-02f, 5.75305969e-02f, 7.56149217e-02f, -4.58628424e-02f, 5.19989356e-02f, 2.24622041e-02f,
  9.53141320e-03f, 1.46081531e-03f, -2.17641573e-02f, -3.05265207e-02f, 6.41637668e-02f, -4.18112949e-02f, -2.29992624e-02f, -8.56467581e-04f, 3.47522646e-02f, -2.68616043e-02f,
  -4.05550987e-01f, 3.32532148e-03f, -9.44292918e-03f, -1.87473550e-01f, -1.44496396e-01f, -7.93497860e-02f, -1.02235869e-01f, -5.68459481e-02f, 2.86554955e-02f, 1.72309324e-01f,
  -7.46678934e-02f, -7.97798485e-02f, 1.95661917e-01f, -1.55826196e-01f, 9.50260758e-02f, 2.87297279e-01f, -1.17614433e-01f, -5.82043342e-02f, -2.01690141e-02f, -1.42420292e-01f,
  -1.72113329e-01f, -5.98646067e-02f, -3.19690481e-02f, -5.76695129e-02f, -1.68737680e-01f, -1.06668368e-01f, 1.24343000e-01f, -1.21206045e-02f, -1.40456781e-01f, 2.97812279e-02f,
  -1.97374378e-03f, -8.49311724e-02f, -5.65910386e-03f, 5.50184399e-03f, -1.36350207e-02f, 2.39471253e-02f, 2.55161664e-03f, 6.23249263e-03f, -7.83524290e-02f, -7.37343505e-02f,
  9.75446925e-02f, -6.17206935e-03f, -3.70656699e-03f, 7.59134740e-02f, -1.18707798e-01f, -6.25943616e-02f, 1.56307593e-02f, -1.28605310e-02f, 3.34748738e-02f, -2.23831665e-02f,
  -3.65231596e-02f, -5.61246611e-02f, -6.34148791e-02f, -1.66075043e-02f, -9.86287221e-02f, -4.41818759e-02f, -8.56363866e-03f, -1.20903039e-02f, 1.10919893e-01f, -1.07776513e-02f,
  3.99353681e-03f, 4.28844094e-02f, -2.47388650e-02f, 7.59425759e-02f, -1.36158988e-02f, 1.11836560e-01f, 1.38479425e-03f, 4.57776524e-02f, -2.22840831e-02f, 2.52638338e-03f,
  3.86153758e-02f, -5.68924397e-02f, 5.81896864e-02f, -1.56297181e-02f, -9.85041112e-02f, 4.04100604e-02f, -1.06542129e-02f, 3.56529728e-02f, -1.18921675e-01f, 3.84486727e-02f,
  4.77128103e-02f, 4.12308313e-02f, 1.05793700e-02f, -2.67902184e-02f, -9.91443545e-03f, -8.76229331e-02f, -2.00917423e-02f, -1.75972953e-02f, 9.32852626e-02f, 7.57115930e-02f,
  1.94195157e-03f, 1.30366325e-01f, 2.85042636e-02f, 6.16881624e-02f, 1.30932629e-01f, -9.45827458e-03f, 5.48235290e-02f, -1.45475700e-01f, 1.66967493e-02f, -8.01266078e-03f,
  -1.68576203e-02f, 1.87240001e-02f, 6.37158602e-02f, -1.31898940e-01f, -5.85329756e-02f, 2.55096164e-02f, 9.99303013e-02f, 6.46652877e-02f, 8.75708461e-03f, -1.38455322e-02f,
  -2.52896678e-02f, 3.97055037e-02f, 7.49269128e-02f, -2.29215473e-02f, 8.48279707e-03f, 2.84670182e-02f, 2.52821445e-02f, -6.31078258e-02f, 1.13822846e-02f, 2.71411762e-02f,
  -4.94889647e-01f, -2.46064942e-02f, -1.38239115e-01f, 7.25060180e-02f, -3.69275408e-03f, -1.75540462e-01f, -2.85009861e-01f, 7.45330984e-03f, -1.80261225e-01f, 1.57270432e-02f,
  -6.53197393e-02f, -2.02414002e-02f, -2.25294214e-02f, 2.49108449e-01f, -7.78536964e-03f, -4.39441763e-02f, 1.14115112e-01f, 5.44586331e-02f, 4.53622378e-02f, -8.30067024e-02f,
  5.13332188e-02f, 1.79201052e-01f, 1.59345549e-02f, 1.50297835e-01f, -6.58992752e-02f, 4.04878445e-02f, 2.02223033e-01f, 5.30509986e-02f, 1.97159946e-01f, -5.14964610e-02f,
  -5.39311171e-02f, 1.28996943e-03f, -5.89871295e-02f, 4.82313186e-02f, -1.03657626e-01f, -8.53192434e-02f, -1.43292323e-01f, -6.08478033e-04f, -2.11760383e-02f, -1.64918825e-02f,
  -3.21036093e-02f, 2.61962763e-03f, -1.17838550e-02f, 4.22841869e-02f, -7.63401985e-02f, 3.82226929e-02f, 4.79257815e-02f, -5.81870601e-03f, -1.01127112e-02f, -7.54522309e-02f,
  -3.12487446e-02f, 1.12885557e-01f, -2.94818333e-03f, 2.92055379e-03f, 2.47292798e-02f, -1.91525405e-03f, 4.03657965e-02f, -3.81198851e-03f, 5.88749051e-02f, -2.33461279e-02f,
  -9.83772501e-02f, -8.88050348e-02f, 4.26553115e-02f, -1.92471016e-02f, 3.27667929e-02f, -9.47889984e-02f, 1.39861017e-01f, 9.91038163e-04f, -6.05694503e-02f, -2.32727472e-02f,
  1.80544518e-02f, -1.68609782e-03f, 2.77513843e-02f, 5.78978136e-02f, 2.29199305e-02f, -2.13037487e-02f, -1.10740056e-02f, 2.20466573e-02f, -5.83573617e-02f, 3.87354009e-02f,
  -7.80796334e-02f, -1.36299077e-02f, -1.40276685e-01f, -3.01708188e-02f, 4.01067510e-02f, 2.30866130e-02f, 6.29763156e-02f, -1.44181058e-01f, -4.84428518e-02f, 8.43845159e-02f,
  5.08391894e-02f, 6.77238330e-02f, 4.35923114e-02f, 1.09332725e-01f, -1.72135904e-02f, 5.12705836e-03f, -5.07130399e-02f, -1.66724026e-02f, 6.12607785e-02f, 4.52754181e-03f,
  -8.11280459e-02f, -1.53993387e-02f, 4.87894602e-02f, 1.14311837e-01f, 4.65513505e-02f, -2.38175243e-02f, 3.59414797e-03f, -6.13202378e-02f, 2.12949794e-02f, 9.73929167e-02f,
  4.65218304e-03f, 8.38153623e-03f, 8.88255611e-02f, 1.02231592e-01f, 2.81888563e-02f, 2.87062619e-02f, 1.12571530e-02f, -7.53856674e-02f, 5.33207133e-02f, 2.61964947e-02f,
  4.28408086e-01f, 1.70218796e-02f, 6.66755810e-02f, 9.00112987e-02f, 3.07620643e-03f, 1.84830911e-02f, -7.03344047e-02f, 5.39273731e-02f, 1.07488841e-01f, -1.77143008e-01f,
  1.17438408e-02f, 1.09374255e-01f, -2.12670505e-01f, 1.43963322e-01f, 2.55262494e-01f, -9.00866091e-02f, 3.82997543e-02f, 1.46038737e-02f, 1.20314278e-01f, 1.95113756e-02f,
  7.37782717e-02f, 1.56639040e-01f, 1.45331666e-01f, -3.06844544e-02f, 3.48641090e-02f, 4.45473939e-02f, -1.51681408e-01f, -9.45159197e-02f, -9.17244412e-04f, 5.37417978e-02f,
  6.07383577e-03f, 9.06521082e-03f, 3.48699689e-02f, 5.02270088e-02f, -4.75760251e-02f, -3.84813920e-02f, -5.71101569e-02f, -3.29748524e-04f, 9.24298987e-02f, 1.64321822e-03f,
  -8.70941356e-02f, 6.98918030e-02f, -3.28555447e-03f, -3.81445400e-02f, 7.13756830e-02f, 5.93545288e-02f, -5.51374219e-02f, -3.24986205e-02f, -4.61276546e-02f, 4.38777916e-02f,
  -3.90960723e-02f, 3.29580456e-02f, 5.19320183e-02f, -1.06543772e-01f, -1.72688272e-02f, 6.82698097e-04f, -5.64729311e-02f, -2.54450887e-02f, -4.49921861e-02f, 1.22495694e-02f,
  -1.90891530e-02f, 4.50687110e-02f, -3.69026363e-02f, -6.84822863e-03f, 2.82746293e-02f, 1.30406506e-02f, 4.99250032e-02f, -2.67784521e-02f, 1.82683673e-02f, -5.36580011e-03f,
  4.81421798e-02f, -5.98693639e-03f, 3.09741939e-03f, 3.83422449e-02f, 6.96166381e-02f, -4.82030176e-02f, 2.36739032e-02f, -4.52871397e-02f, 4.53439280e-02f, 1.14594363e-02f,
  -5.51065663e-03f, 7.25182742e-02f, -2.08918918e-02f, -1.37676289e-02f, -1.39476955e-02f, 2.66946666e-02f, 9.36024785e-02f, 3.23984288e-02f, -3.93978879e-02f, -6.40626475e-02f,
  -1.10325381e-01f, -6.86223581e-02f, -3.68955806e-02f, -1.95428096e-02f, -6.45578355e-02f, -3.14045209e-03f, 3.99035476e-02f, -1.25055518e-02f, 1.96253378e-02f, 6.91821724e-02f,
  -3.72774117e-02f, 2.21475847e-02f, -1.37711065e-02f, 6.60185665e-02f, -7.56407082e-02f, -1.27863809e-01f, -1.44521862e-01f, -4.20117117e-02f, -5.22263460e-02f, -3.19207050e-02f,
  -1.86129697e-02f, -4.86195199e-02f, 3.37913409e-02f, 3.94589230e-02f, -4.01153602e-02f, -6.31938353e-02f, -6.20841719e-02f, -3.28572914e-02f, -2.88216490e-02f, 2.43676361e-04f,
  4.00458962e-01f, -1.34415954e-01f, -8.52456540e-02f, -2.43844151e-01f, 1.17103718e-01f, -1.69318333e-01f, -1.87305018e-01f, -3.28092575e-02f, 1.23013832e-01f, -1.89341575e-01f,
  -1.96839757e-02f, 1.13076955e-01f, -4.90737706e-02f, -3.01312804e-01f, -2.98322409e-01f, -4.58587632e-02f, -2.93993860e-01f, -1.83010548e-02f, 1.46724775e-01f, -1.05441187e-03f,
  5.67316785e-02f, -2.29080766e-01f, -1.93202242e-01f, 9.21063311e-03f, 1.12601556e-02f, 4.88332137e-02f, -7.16550201e-02f, 2.25787666e-02f, -2.37310812e-01f, -1.11019999e-01f,
  3.12091541e-02f, 6.43236041e-02f, -5.62892780e-02f, -7.45932683e-02f, -4.33089845e-02f, -7.62617448e-03f, -1.56189710e-01f, -1.99879296e-02f, -9.96920280e-03f, -1.21151932e-01f,
  -1.48791596e-02f, -4.60805707e-02f, 4.86361161e-02f, -1.58962067e-02f, 7.07284957e-02f, 4.69006374e-02f, -1.34226130e-02f, 4.40121777e-02f, -6.94959285e-03f, 1.32035557e-02f,
  2.76197251e-02f, -5.18306717e-02f, -5.21594174e-02f, -1.17918603e-01f, 5.35065569e-02f, 1.71526689e-02f, -8.99124667e-02f, -3.49117909e-03f, -4.49955389e-02f, 5.18848607e-03f,
  7.08301514e-02f, -8.08720756e-03f, -6.04832545e-02f, 1.69717744e-02f, -9.31914523e-02f, -4.61067744e-02f, -7.67372772e-02f, -3.61959264e-02f, 1.05201162e-01f, -4.07290868e-02f,
  -1.22547988e-02f, -3.02796587e-02f, 2.11790241e-02f, -1.18356705e-01f, -3.47506516e-02f, 2.22613662e-02f, 5.28687425e-02f, -2.82147508e-02f, 6.30075559e-02f, 1.59560479e-02f,
  3.34063545e-02f, -7.59541988e-02f, 6.90399623e-03f, 6.27572611e-02f, -2.97272895e-02f, 9.08088088e-02f, -2.58691851e-02f, 5.49695417e-02f, -6.06977604e-02f, -5.00810072e-02f,
  -1.08554609e-01f, -1.79514855e-01f, -5.26230596e-02f, 1.95124485e-02f, -1.73510183e-02f, 8.30627531e-02f, -1.12392694e-01f, 2.48663817e-02f, 4.36943620e-02f, -5.15711308e-03f,
  4.02598977e-02f, -4.27723490e-02f, -3.57977897e-02f, -1.28586158e-01f, -4.09444124e-02f, -1.87908038e-02f, -5.54254279e-02f, 1.51266140e-05f, -2.05153227e-03f, -4.68868241e-02f,
  2.93896621e-04f, 1.26176141e-03f, 3.62815484e-02f, 1.43389245e-02f, 8.85207504e-02f, 4.14026305e-02f, 1.06610551e-01f, -4.87783253e-02f, -2.93021295e-02f, -3.01093627e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.05211260e-02f, -1.05844475e-01f, 1.29333898e-01f, -3.10948849e-01f, 1.22445479e-01f, 2.98074722e-01f, 2.99591690e-01f, -5.46561740e-02f, -3.23027074e-01f, -1.67234764e-01f,
  1.29805030e-02f, 2.96066180e-02f, 3.10966671e-01f, -1.27398640e-01f, 4.37966555e-01f, 3.85517180e-01f, 9.42266062e-02f, -1.89811531e-02f, -1.53653985e-02f, -8.25045407e-02f,
  -3.47732790e-02f, -6.44984320e-02f, 3.21512133e-01f, -9.19003785e-02f, 3.03802099e-02f, -1.49019465e-01f, -8.74681026e-02f, 2.38018692e-01f, -2.39649013e-01f, 1.12126723e-01f,
  1.46027640e-01f, -6.53889850e-02f, 1.26589566e-01f, 1.10262230e-01f, -6.06688336e-02f, 7.40617746e-03f, 1.65033802e-01f, 1.86600983e-01f, 6.61700964e-02f, -5.21569587e-02f,
  6.63943738e-02f, -2.21830402e-02f, -1.42129123e-01f, 2.62157451e-02f, -1.11366861e-01f, -1.02482088e-01f, 1.98691376e-02f, 8.32458958e-02f, -5.86688295e-02f, 1.76497437e-02f,
  -2.71527320e-02f, 5.40885516e-02f, -5.32920584e-02f, -1.84154406e-01f, 3.50272283e-02f, 2.98959427e-02f, 3.90052944e-02f, 1.54924855e-01f, -3.48674953e-02f, -1.14539757e-01f,
  -9.41634327e-02f, 6.26866743e-02f, 3.25332955e-02f, -2.44644526e-02f, 7.75442868e-02f, -1.76680744e-01f, 5.39083555e-02f, 3.97125185e-02f, -9.31628793e-02f, -9.96332988e-02f,
  7.14611858e-02f, 9.18668285e-02f, 5.37457205e-02f, -3.61481495e-02f, -1.12729549e-01f, -2.29412727e-02f, 1.19055718e-01f, 2.18919516e-02f, -1.01280466e-01f, 1.82782172e-03f,
  -1.22526139e-01f, -8.31260066e-03f, -2.25313902e-02f, -5.86073957e-02f, 3.18280421e-02f, 1.47982150e-01f, -6.01589680e-02f, 2.90929750e-02f, 7.84121826e-02f, 1.39487892e-01f,
  4.45811972e-02f, -1.89825282e-01f, 3.20436135e-02f, -1.88156869e-02f, 7.13890865e-02f, 1.75009087e-01f, 1.42014548e-01f, -1.93119794e-02f, -3.95037308e-02f, -2.26352885e-02f,
  1.37368757e-02f, 5.84639162e-02f, -1.57494750e-02f, -7.12622702e-02f, -1.28237411e-01f, -3.16433087e-02f, 2.52777450e-02f, 7.40764150e-03f, -2.76394188e-04f, 1.85095631e-02f,
  1.08920177e-03f, 1.11012354e-01f, -5.16539216e-02f, -1.26640305e-01f, -4.77236994e-02f, -1.06793560e-01f, 3.54403369e-02f, 7.02021122e-02f, -3.01689561e-02f, -3.94183956e-02f,
  3.45739484e-01f, -8.89888406e-03f, -2.73716420e-01f, -4.10345495e-02f, -9.15790126e-02f, -7.33502954e-03f, -6.19876757e-02f, -1.23163030e-01f, -1.65545363e-02f, 1.84044182e-01f,
  1.66423321e-01f, 7.64910728e-02f, 1.46787301e-01f, 3.05199444e-01f, 9.45399106e-02f, 1.70405224e-01f, 2.72688419e-01f, 1.63836852e-01f, 9.20733511e-02f, 1.09638646e-01f,
  6.58971667e-02f, 3.53167057e-01f, -2.13243246e-01f, -3.07503082e-02f, -4.37217131e-02f, -2.25856572e-01f, -1.51174385e-02f, -2.22209051e-01f, -1.62035301e-01f, 3.56742255e-02f,
  9.90409404e-02f, 1.57338083e-02f, -3.15888226e-02f, -4.89753261e-02f, -4.41100122e-03f, 1.29965439e-01f, -1.25636697e-01f, -1.31404594e-01f, -1.26016736e-01f, -8.50815617e-04f,
  -3.84935550e-02f, 3.91256027e-02f, 8.70681852e-02f, -5.10823168e-02f, 1.37572838e-02f, -2.69271862e-02f, -3.76831144e-02f, -1.79493636e-01f, -1.73401624e-01f, 1.04783013e-01f,
  -1.16736576e-01f, -1.70534048e-02f, 6.95661455e-02f, -1.58072971e-02f, -6.65138662e-02f, -1.47990612e-02f, -5.19614555e-02f, -7.08117932e-02f, -1.34768203e-01f, 7.08842278e-02f,
  1.09934270e-01f, -7.75499176e-03f, 1.45052299e-01f, -6.86442330e-02f, -9.28682312e-02f, -6.52702823e-02f, 9.77839157e-03f, -3.23565863e-02f, 3.16679734e-03f, -3.31253111e-02f,
  -1.03027105e-01f, -1.05328210e-01f, -6.41388446e-02f, 1.32433530e-02f, 2.12515131e-01f, 3.45757343e-02f, -3.12910369e-03f, 1.22334221e-02f, -1.63315926e-02f, -1.16226919e-01f,
  -3.86802331e-02f, 1.47811156e-02f, -2.18491461e-02f, -8.81312937e-02f, 1.42130628e-02f, -1.58224627e-02f, 2.01006398e-01f, 5.07124737e-02f, -6.17728606e-02f, -5.22785336e-02f,
  -1.82742383e-02f, 4.25965078e-02f, -1.30948678e-01f, -8.83298293e-02f, -5.61072677e-02f, 2.49727070e-01f, 4.16632444e-02f, 1.07271954e-01f, -5.68087213e-02f, 2.70747766e-02f,
  6.01291619e-02f, -6.83017373e-02f, -2.13056896e-02f, 3.58485319e-02f, -2.17927054e-01f, 5.77371232e-02f, -1.80448592e-02f, -7.78013319e-02f, -1.29844338e-01f, -1.30493147e-02f,
  3.67786437e-02f, -3.72780748e-02f, -4.81430404e-02f, -8.35631192e-02f, 4.61215600e-02f, 6.95563247e-03f, -3.67787108e-02f, -1.06318392e-01f, -1.83687583e-02f, -2.76888758e-02f,
  2.19383061e-01f, -5.64117610e-01f, 1.34951562e-01f, 9.80286524e-02f, 2.30814993e-01f, 1.02833234e-01f, 3.14279675e-01f, -2.64450520e-01f, -3.03434789e-01f, -3.65214080e-01f,
  -5.30949347e-02f, 8.93887877e-02f, 1.42491996e-01f, 4.23643924e-02f, 5.45792878e-01f, -8.81674793e-03f, 8.48285630e-02f, 8.87828469e-02f, -6.39791042e-03f, -5.88946566e-02f,
  8.30183029e-02f, 2.03938872e-01f, 1.52203739e-01f, -2.91279197e-01f, -8.43586284e-04f, -2.87731886e-02f, 1.14990592e-01f, 2.24492371e-01f, -9.15692747e-02f, 8.89983177e-02f,
  -1.59116071e-02f, -1.78891942e-01f, -1.18492786e-02f, -6.34480789e-02f, -8.84746090e-02f, -6.60646707e-02f, 1.92472972e-02f, 1.41912192e-01f, 2.16021966e-02f, -5.06057870e-03f,
  -7.32076168e-02f, 2.07519345e-02f, 5.02432056e-04f, 1.21871347e-03f, -1.15480855e-01f, -5.57739064e-02f, -4.97361049e-02f, -1.03073113e-01f, -1.10408552e-01f, -1.16972744e-01f,
  -1.05456717e-01f, -6.81962399e-03f, -4.33551613e-03f, 1.66340452e-02f, -8.12052041e-02f, -1.11677997e-01f, -2.24777982e-02f, 1.38079464e-01f, -4.06720527e-02f, -2.44981330e-02f,
  -8.13877434e-02f, 1.73756164e-02f, -7.67699853e-02f, -4.52811308e-02f, 9.38281268e-02f, 4.54091355e-02f, 1.30427688e-01f, -1.57604031e-02f, -5.00884727e-02f, 2.96357963e-02f,
  1.99476108e-02f, -6.53738454e-02f, -7.03593642e-02f, 8.42660852e-03f, 1.35930888e-02f, -1.22231275e-01f, 1.00742474e-01f, 3.75405848e-02f, -3.92093658e-02f, 1.92484062e-03f,
  8.70856941e-02f, 2.99599990e-02f, -1.40364645e-02f, 9.40178558e-02f, -9.21789855e-02f, 1.27445580e-02f, -9.62763429e-02f, -5.70998713e-02f, -1.66643970e-02f, 1.44186378e-01f,
  -3.70161712e-01f, -2.74129182e-01f, 1.12566940e-01f, 5.00946715e-02f, -3.31248194e-02f, -4.34665754e-02f, -1.17518552e-01f, -8.83491784e-02f, -3.26529816e-02f, 5.32322079e-02f,
  -3.35502140e-02f, 8.96247253e-02f, -4.50193556e-03f, 5.18473126e-02f, 3.27235870e-02f, -3.87318656e-02f, -3.59055959e-02f, -1.35949291e-02f, 8.98885056e-02f, -3.42845991e-02f,
  -1.47517174e-02f, 3.53094041e-02f, 1.57027587e-01f, -1.74390320e-02f, -1.28678113e-01f, -3.85454693e-03f, -3.19163091e-02f, -9.01188105e-02f, -5.49656153e-02f, 7.05235684e-03f,
  -5.80940135e-02f, 3.59644920e-01f, -2.52393931e-02f, -4.04216945e-02f, 6.22572228e-02f, -2.48960778e-01f, -1.59483880e-01f, 2.85591353e-02f, -1.20782979e-01f, 2.05330715e-01f,
  -1.28807575e-01f, -4.75452915e-02f, -7.14328364e-02f, -3.02469492e-01f, -6.53310061e-01f, -5.05375326e-01f, -1.94034889e-01f, -1.54155865e-01f, -1.91527545e-01f, 1.14922032e-01f,
  -1.27118677e-01f, -1.72153965e-01f, -1.99520782e-01f, 1.08028866e-01f, 1.85015827e-01f, 2.40269676e-01f, 1.83125347e-01f, 1.04271591e-01f, 1.99990913e-01f, -9.71308947e-02f,
  -4.90522571e-02f, -1.70083046e-02f, 1.32235095e-01f, -4.41146791e-02f, -1.25488290e-03f, 1.21444553e-01f, 1.42841309e-01f, -6.36879802e-02f, 4.06883191e-03f, -9.89650264e-02f,
  2.63685621e-02f, -4.59228456e-02f, -1.16555676e-01f, 2.52645258e-02f, 1.41102657e-01f, -1.19607121e-01f, 2.42786482e-02f, 2.75342562e-03f, -8.41658283e-03f, -3.98607664e-02f,
  1.01513257e-02f, 6.41255155e-02f, 1.08763464e-01f, 4.20811884e-02f, -9.23155248e-02f, -4.65442054e-02f, -2.63363384e-02f, 4.38186526e-02f, 6.81160465e-02f, -2.51741298e-02f,
  1.14322647e-01f, 9.15415213e-02f, -2.21924447e-02f, -1.02269255e-01f, -2.03003287e-02f, -1.51280249e-02f, -4.53847402e-04f, -1.55932093e-02f, -2.24339943e-02f, -1.21149765e-02f,
  -9.36494097e-02f, -5.10234199e-02f, -1.51344473e-02f, 6.86423779e-02f, 4.01339121e-02f, -4.99013215e-02f, 5.63502461e-02f, -2.66203023e-02f, 1.14470664e-02f, -5.35568297e-02f,
  1.75661966e-02f, 2.09514536e-02f, 4.56095375e-02f, 1.53590754e-01f, -1.80981606e-01f, 6.13018358e-03f, 9.17576477e-02f, -3.14725786e-02f, -4.22207899e-02f, -2.27838662e-02f,
  7.11880326e-02f, 1.31775722e-01f, -5.25623821e-02f, -1.07888803e-01f, -2.21083462e-02f, -8.20075423e-02f, -7.17550144e-02f, -1.37416109e-01f, 3.08040623e-03f, 9.17757209e-03f,
  1.74527138e-01f, 8.66513476e-02f, 1.24221936e-01f, 3.90057564e-02f, 9.68191847e-02f, -3.21972813e-03f, 9.74550769e-02f, 1.40212476e-02f, 1.11291565e-01f, 7.27254897e-02f,
  1.13818668e-01f, 7.29986876e-02f, 2.16870266e-03f, -1.00049682e-01f, 3.81819606e-02f, 6.23776093e-02f, 1.48926098e-02f, 7.76330158e-02f, 6.43465295e-02f, 3.55355367e-02f,
  -7.54248619e-01f, 1.47061870e-01f, 2.40152553e-01f, -1.64467484e-01f, -3.18398714e-01f, 3.72536242e-01f, 2.68323511e-01f, -6.01687618e-02f, 4.34592843e-01f, 2.48339370e-01f,
  -1.93712294e-01f, 6.70925751e-02f, 2.38561064e-01f, -5.53502291e-02f, 2.32173994e-01f, 4.05031443e-01f, 8.48258063e-02f, 1.87601760e-01f, 9.53577459e-02f, -7.87402466e-02f,
  -1.41033843e-01f, -2.53349721e-01f, -1.19906075e-01f, -3.10227543e-01f, -3.37903142e-01f, -2.10348368e-01f, -2.44801953e-01f, 5.53961508e-02f, -8.75446647e-02f, 4.46153507e-02f,
  -2.09294200e-01f, 1.76689364e-02f, -2.07179651e-01f, 8.68799537e-02f, -2.69425735e-02f, -1.71593614e-02f, -4.60560881e-02f, -6.07408676e-03f, -4.21604421e-03f, -1.79436747e-02f,
  4.35470454e-02f, -9.52968597e-02f, 4.73309755e-02f, -7.86519572e-02f, 9.50009450e-02f, 2.30800435e-02f, -7.22588971e-02f, -9.78444815e-02f, -3.40077542e-02f, -2.23892052e-02f,
  -1.70195512e-02f, -3.35907191e-02f, -4.39109914e-02f, 4.72876988e-02f, -9.24400836e-02f, 1.10401861e-01f, 2.04204962e-01f, -8.81681740e-02f, -4.72543612e-02f, 2.33336948e-02f,
  4.45828773e-02f, 3.23156714e-02f, 7.79964626e-02f, -4.88817729e-02f, 2.80572027e-02f, -1.38735652e-01f, 7.19115660e-02f, -8.45654532e-02f, -1.74118448e-02f, -8.93572196e-02f,
  -5.84362894e-02f, -2.58272365e-02f, -1.35709912e-01f, 2.06638761e-02f, 8.24143142e-02f, 5.70632033e-02f, 5.44245122e-03f, -8.52548853e-02f, 2.81908177e-02f, -1.45895733e-02f,
  -3.17064226e-02f, 1.02234602e-01f, -5.12570366e-02f, -1.34040518e-02f, 5.93191460e-02f, -1.25658074e-02f, -7.58125111e-02f, -3.01471930e-02f, -6.03573024e-03f, -3.32394466e-02f,
  1.61918327e-01f, 2.87572056e-01f, 9.35706589e-03f, -4.00651209e-02f, 2.62207445e-02f, 6.58975542e-02f, 6.86107576e-02f, -6.51775226e-02f, 1.03270277e-01f, 8.73958021e-02f,
  2.32907701e-02f, 2.51577096e-03f, -3.73129100e-02f, 2.67395712e-02f, 7.54814744e-02f, 1.03010885e-01f, 1.18895903e-01f, 2.81001572e-02f, 1.99369527e-02f, 1.26224449e-02f,
  -1.78813323e-01f, -4.71743904e-02f, 7.17893988e-02f, -1.24110095e-01f, -1.17454052e-01f, -3.71335596e-02f, -3.43487710e-02f, -3.83061320e-02f, -3.96146066e-02f, 5.14282659e-03f,
  -6.80155277e-01f, 1.59958154e-01f, 5.06134391e-01f, -3.95279557e-01f, 4.02523093e-02f, 3.07709724e-01f, -1.55535072e-01f, 1.48481086e-01f, -1.20221317e-01f, -1.82787940e-01f,
  -8.12652633e-02f, 6.91897348e-02f, -1.17436964e-02f, -4.57993709e-02f, 1.72825158e-01f, 1.83147211e-02f, -1.39445961e-01f, -1.03163794e-01f, 1.02596179e-01f, -5.81325293e-02f,
  -3.30972262e-02f, -1.74288899e-01f, 8.61174092e-02f, 1.72178403e-01f, 9.15961787e-02f, -5.40065318e-02f, -1.98831335e-01f, 1.49602309e-01f, 1.24943011e-01f, 2.63487220e-01f,
  -2.22364888e-01f, -1.00128248e-01f, -1.25989676e-01f, 1.90535579e-02f, 3.36534604e-02f, 2.06965227e-02f, -1.35122851e-01f, -2.43410710e-02f, -1.51723236e-01f, -2.49927547e-02f,
  -1.01645552e-02f, 4.38196510e-02f, 8.38264897e-02f, 9.12758242e-03f, 8.87773111e-02f, 1.20750166e-01f, 2.05174714e-01f, 3.36607508e-02f, 1.02202132e-01f, 1.93211451e-01f,
  2.28280440e-01f, -2.87405215e-02f, -5.20294495e-02f, -4.48324680e-02f, 1.49525180e-01f, -8.00023880e-03f, -6.11147918e-02f, -5.17697781e-02f, -4.89148274e-02f, -3.09851225e-02f,
  1.29792646e-01f, 6.71486463e-03f, 5.30248396e-02f, -2.55183373e-02f, -8.74467343e-02f, 6.19893111e-02f, 4.32285592e-02f, -2.96697132e-02f, -7.54081011e-02f, -1.38699770e-01f,
  -1.27128482e-01f, -3.08138710e-02f, -1.39076933e-01f, 1.92578156e-02f, 6.47720248e-02f, -9.22169536e-02f, 4.92228195e-04f, -4.76964712e-02f, -1.16928853e-02f, 1.04141831e-01f,
  1.43012721e-02f, 2.35348251e-02f, 6.12373129e-02f, -2.20137853e-02f, 3.25064920e-02f, -7.48954266e-02f, -1.30093932e-01f, 7.86149353e-02f, -4.67432216e-02f, -1.38167164e-03f,
  -3.69908690e-01f, -3.21820199e-01f, -8.28323513e-02f, -4.28732187e-02f, -2.01849490e-02f, -1.15344012e-02f, 2.98923329e-02f, 5.73160872e-03f, -1.41588166e-01f, -4.67663594e-02f,
  -6.37816079e-03f, -1.26881883e-01f, 7.86669180e-03f, -4.08091694e-02f, 1.27593294e-01f, -1.68885607e-02f, -1.20022938e-01f, -1.04151651e-01f, -1.00712121e-01f, 1.17078133e-01f,
  -1.85022298e-02f, -8.02723318e-02f, -6.17300458e-02f, -1.25706434e-01f, 2.60842498e-02f, 3.99277881e-02f, -9.92015153e-02f, 5.74179227e-03f, 5.56495786e-02f, 8.92632455e-02f,
  -9.95085061e-01f, 3.10739726e-01f, -3.07416677e-01f, -1.39350981e-01f, -1.59502745e-01f, -8.34255964e-02f, 6.41640946e-02f, 2.43207887e-02f, -7.99845830e-02f, 2.68736422e-01f,
  1.16705827e-01f, -1.98282197e-01f, 2.62238979e-01f, 1.57751873e-01f, -3.83403450e-01f, 1.98223710e-01f, -1.80549905e-01f, -1.17655337e-01f, 1.31162882e-01f, -1.70438811e-01f,
  -2.33939160e-02f, 1.45871669e-01f, -1.11065753e-01f, 2.09769711e-01f, -9.05219316e-02f, -1.33836046e-01f, -1.35313809e-01f, 1.82236936e-02f, -1.34516492e-01f, -4.50712442e-02f,
  -2.55079746e-01f, -3.10789466e-01f, -1.63646311e-01f, -2.61658132e-01f, -2.37897143e-01f, -5.25779650e-02f, -9.96333212e-02f, 6.31839260e-02f, -2.61107087e-02f, -4.60640667e-03f,
  -7.97557384e-02f, -3.22792120e-02f, -9.43577383e-03f, 9.59415957e-02f, -1.24832891e-01f, -3.95130180e-02f, -2.27172486e-02f, -4.91125062e-02f, 1.43736764e-03f, -9.46681853e-03f,
  -4.75150242e-04f, -8.93511549e-02f, 4.31449227e-02f, 2.18166802e-02f, -2.12046504e-02f, 5.33367321e-02f, 5.26299290e-02f, -1.12290755e-01f, -1.87953919e-01f, -1.20253012e-01f,
  -8.50319713e-02f, 4.62608226e-02f, 8.37877207e-03f, 2.00807094e-03f, -4.51728068e-02f, 9.41266899e-06f, -3.19174193e-02f, -2.28814352e-02f, 9.80132148e-02f, 4.44937404e-03f,
  -5.60735390e-02f, -4.98231016e-02f, -4.60307635e-02f, 7.55414134e-03f, 1.06301308e-01f, -2.77984198e-02f, 7.22962394e-02f, -9.70834941e-02f, 4.06235941e-02f, -2.89230607e-03f,
  7.45279640e-02f, -2.85741258e-02f, -2.21204590e-02f, -1.66491568e-02f, -7.18982667e-02f, -8.55741128e-02f, -5.22061586e-02f, 1.46861179e-02f, 5.16265221e-02f, -1.13192037e-01f,
  -4.18177664e-01f, -5.11099756e-01f, 1.00357151e-02f, -1.02546901e-01f, -6.26959279e-02f, -2.55550295e-02f, -9.51159298e-02f, -1.41548347e-02f, -9.47796330e-02f, -2.34482042e-03f,
  -1.20842882e-01f, -1.53906420e-01f, -4.98679057e-02f, 6.07686788e-02f, -1.74117424e-02f, -6.68210955e-03f, -6.02783076e-02f, -6.73642233e-02f, -1.65174678e-01f, -7.65701979e-02f,
  3.08728572e-02f, -6.24381006e-02f, 1.85072079e-01f, 4.77428176e-02f, 1.32950833e-02f, -6.74130246e-02f, -6.04702644e-02f, -5.28421327e-02f, -2.25951046e-01f, 4.30298932e-02f,
  -1.67095214e-01f, -7.66741559e-02f, 7.32156932e-02f, 3.83218080e-01f, -2.05586523e-01f, -3.93294930e-01f, -2.71464139e-01f, 5.57633163e-03f, -1.14259668e-01f, -6.11517653e-02f,
  -1.55452620e-02f, 1.42830238e-01f, 3.36834006e-02f, 2.69168049e-01f, 2.85120666e-01f, 1.64543524e-01f, 1.62385017e-01f, -6.52900524e-03f, 9.34194326e-02f, 1.40846699e-01f,
  2.18000680e-01f, 2.37832516e-01f, 3.58549058e-01f, 2.75921579e-02f, 7.92345852e-02f, 2.26552740e-01f, 3.19092959e-01f, 9.27975103e-02f, 2.07394898e-01f, -2.94008516e-02f,
  -1.54227912e-02f, 1.56257510e-01f, 9.45387036e-03f, -7.18374550e-02f, -2.40194723e-02f, -1.89086162e-02f, 5.41739576e-02f, -5.35648912e-02f, -2.34306175e-02f, 1.66860633e-02f,
  8.48529935e-02f, 2.91846003e-02f, -5.54106105e-03f, -5.58072329e-02f, -7.77160004e-03f, 5.94782121e-02f, 1.79604515e-02f, -8.61794278e-02f, -2.67071035e-02f, -3.51563059e-02f,
  -1.46783106e-02f, 1.12973861e-01f, 8.83724820e-03f, 8.08071941e-02f, 2.62731407e-02f, -4.99201939e-02f, -1.38680330e-02f, 4.59534749e-02f, 1.11505881e-01f, 4.31461260e-02f,
  5.61472178e-02f, -3.41324508e-02f, -5.11155091e-02f, -1.12595536e-01f, 1.85258258e-02f, 8.30493420e-02f, 2.24758387e-02f, 8.72047804e-03f, 3.25808786e-02f, 8.21955502e-02f,
  9.00734961e-02f, 5.83804622e-02f, 7.57030174e-02f, -6.79074228e-02f, 9.75864939e-03f, -2.77390592e-02f, -1.15111470e-01f, 1.84578709e-02f, 1.41477868e-01f, -7.19404295e-02f,
  4.47301976e-02f, -4.21176106e-02f, 6.60490766e-02f, -5.85092697e-03f, -7.18066171e-02f, 4.51391041e-02f, 7.50137493e-02f, 6.93413168e-02f, -1.66419689e-02f, -8.21706057e-02f,
  2.01769426e-01f, 3.50955904e-01f, -5.92339039e-02f, -1.06762983e-01f, 2.80793216e-02f, -1.56878114e-01f, -5.78331761e-02f, 4.75856736e-02f, 1.56851988e-02f, -5.10201417e-02f,
  9.70704854e-03f, -1.44741431e-01f, 4.92167510e-02f, -1.01156030e-02f, 9.96245444e-02f, 2.15355773e-02f, 6.97383210e-02f, 7.53173754e-02f, 1.68148100e-01f, -4.72448282e-02f,
  4.45312373e-02f, -1.16244748e-01f, -1.48850279e-02f, -1.04586303e-01f, -4.63698916e-02f, 1.36376629e-02f, -7.91073665e-02f, -5.28323948e-02f, 9.48501676e-02f, 4.57394123e-02f,
  4.41246867e-01f, -1.84616409e-02f, 2.75061041e-01f, 1.94794998e-01f, 1.13467321e-01f, 1.16305895e-01f, 4.12525892e-01f, -3.58531959e-02f, 1.92335993e-01f, -2.01747105e-01f,
  -5.66715258e-04f, 2.11740494e-01f, -5.32719530e-02f, -2.98596397e-02f, 1.09812923e-01f, -2.26457473e-02f, -5.44812344e-03f, -1.65471032e-01f, -1.08344213e-03f, -4.37122062e-02f,
  3.22048962e-02f, -2.88943619e-01f, -1.09922113e-02f, -2.98760653e-01f, 1.29291089e-02f, 7.09814876e-02f, -2.02037007e-01f, 3.22826318e-02f, -9.65783671e-02f, -2.08928920e-02f,
  7.07708895e-02f, -5.35803698e-02f, -3.26757343e-03f, 2.85637695e-02f, 4.03944850e-02f, 8.11541602e-02f, 4.23124731e-02f, 7.95248896e-02f, 3.89336236e-02f, -5.80327287e-02f,
  5.70188873e-02f, 6.13707490e-02f, -1.07930295e-01f, 9.63461325e-02f, 7.28960186e-02f, 7.80092180e-02f, 6.28549680e-02f, -1.28705679e-02f, 9.15775150e-02f, 5.75201921e-02f,
  7.64302388e-02f, -5.21771125e-02f, 1.35313556e-01f, 9.74536128e-03f, 7.58594945e-02f, 2.09094286e-02f, 1.10874236e-01f, 1.51337340e-01f, 5.72790541e-02f, 2.10341271e-02f,
  -7.70098493e-02f, -6.22610264e-02f, 1.09482342e-02f, -8.54496583e-02f, 2.41123047e-02f, -8.57952461e-02f, -2.43806243e-02f, 3.78743224e-02f, 5.15204929e-02f, -2.48022396e-02f,
  -2.51337625e-02f, -5.04077449e-02f, -3.28439213e-02f, 6.67015836e-02f, 3.40328232e-04f, 4.11501005e-02f, 4.81819995e-02f, -4.30144891e-02f, 5.69842122e-02f, -2.76670163e-03f,
  1.06358983e-01f, -2.76877489e-02f, -4.82978411e-02f, 3.48744006e-03f, 1.13016404e-01f, 5.07411100e-02f, 4.59291451e-02f, 3.32134170e-03f, 6.48357123e-02f, -1.58418082e-02f,
  -1.22558773e-01f, -3.16708177e-01f, -4.00145128e-02f, 9.00165513e-02f, 2.00712569e-02f, 1.04690325e-02f, -2.34215446e-02f, 4.21487167e-02f, -3.77625339e-02f, -5.50072119e-02f,
  7.03725638e-03f, -9.76536237e-03f, 6.65621385e-02f, 9.42420587e-02f, 4.42553088e-02f, -7.24771768e-02f, 1.56267807e-01f, -9.87618417e-02f, 2.60375775e-02f, -9.17465165e-02f,
  5.59720248e-02f, -6.17452748e-02f, 1.60804212e-01f, -2.24240869e-02f, 9.33339819e-02f, -3.78968567e-02f, 1.19695775e-01f, -6.27794191e-02f, -5.81074841e-02f, 8.67870525e-02f,
  2.16049328e-01f, 7.79800415e-02f, -4.37518135e-02f, -8.30689073e-02f, -1.51410505e-01f, -3.17323506e-01f, -3.80677819e-01f, -1.51814297e-01f, 1.85253203e-01f, -4.65108901e-02f,
  -2.21692026e-01f, 3.20229411e-01f, 1.32646576e-01f, -3.58171910e-01f, 4.14535224e-01f, 1.87626839e-01f, -1.34655237e-01f, -7.29995593e-02f, -2.49532843e-03f, -1.98055893e-01f,
  8.01835284e-02f, -3.49409133e-01f, -1.51416749e-01f, -2.83971250e-01f, -4.84485984e-01f, -1.75711036e-01f, -5.36947921e-02f, -3.08304489e-01f, -2.99978733e-01f, -1.29000917e-01f,
  -1.30297393e-01f, 9.75509733e-02f, -9.98344570e-02f, 3.97800133e-02f, -5.10779358e-02f, -5.59374578e-02f, -1.56519488e-01f, -5.52292764e-02f, 4.86212745e-02f, -8.36128462e-03f,
  1.37071595e-01f, 9.40279216e-02f, 1.68039603e-03f, 1.49944834e-02f, -1.17693678e-01f, -3.98754366e-02f, 1.30776078e-01f, -6.11987337e-02f, 2.29007173e-02f, -1.61788948e-02f,
  6.42693862e-02f, 5.91651462e-02f, -3.24651897e-02f, 1.00080468e-01f, 6.56700954e-02f, 4.70310263e-03f, 1.80213694e-02f, 9.70396325e-02f, -6.65222714e-03f, 8.68602470e-02f,
  -4.25105952e-02f, 7.52530172e-02f, -7.31657222e-02f, -1.58250704e-01f, -1.00011379e-01f, -6.10329434e-02f, 8.12706072e-03f, -6.34016022e-02f, 1.28417775e-01f, -1.77839808e-02f,
  5.17512783e-02f, -2.44674645e-03f, 1.10178804e-02f, 1.01016266e-02f, 1.91682391e-02f, -9.73703898e-03f, 3.78924198e-02f, -2.34286115e-02f, 1.03370860e-01f, -2.60698870e-02f,
  -6.59302548e-02f, -2.16259714e-02f, 1.72554813e-02f, -1.53720513e-01f, -6.58395812e-02f, 1.75657868e-02f, -6.93462342e-02f, -8.29060599e-02f, 2.35713646e-02f, -4.07429561e-02f,
  -4.02637050e-02f, 1.05905600e-01f, 1.19612226e-02f, 5.44233359e-02f, 7.53933117e-02f, 7.42031867e-03f, 8.80894214e-02f, 8.00998211e-02f, 6.89502135e-02f, -6.99377730e-02f,
  -1.09691188e-01f, 5.65619431e-02f, 2.20571943e-02f, -3.35362405e-02f, 1.40244871e-01f, -1.04617760e-01f, -1.84156410e-02f, 5.72176799e-02f, 1.02344640e-01f, -4.26133722e-02f,
  4.31200340e-02f, 7.17981160e-02f, 1.08466983e-01f, -1.49217527e-02f, -8.89021438e-03f, -5.07076830e-02f, 1.59332871e-01f, 4.11326811e-03f, -3.64542976e-02f, 1.55188888e-01f,
  3.47741812e-01f, -3.80497314e-02f, -2.14435354e-01f, 1.40589759e-01f, 4.04046088e-01f, 4.04183984e-01f, 4.30953413e-01f, 2.33214602e-01f, 3.57437521e-01f, 1.63771853e-01f,
  2.67062545e-01f, -1.06435344e-01f, -3.25538479e-02f, 1.83702901e-01f, 1.23290882e-01f, 3.52314413e-02f, 3.32085282e-01f, 5.79127632e-02f, 3.41909453e-02f, 5.95118850e-02f,
  5.45051098e-02f, 2.22113758e-01f, -3.67575213e-02f, -1.23538360e-01f, 9.19608250e-02f, -2.52456903e-01f, -1.34396449e-01f, -2.14858085e-01f, -4.48822863e-02f, 1.31922334e-01f,
  5.37418500e-02f, 2.82398816e-02f, -6.24995977e-02f, -1.25020832e-01f, 4.28046584e-02f, -1.26276225e-01f, -1.66358486e-01f, 8.38793721e-03f, 4.92916331e-02f, 8.84654745e-03f,
  -3.23461443e-02f, -4.95848730e-02f, 5.23883365e-02f, -6.26359582e-02f, 6.95451796e-02f, -2.64223758e-03f, 2.41514836e-02f, 2.88186371e-02f, -8.26559365e-02f, -6.23305738e-02f,
  -7.41627673e-03f, -3.26892175e-02f, 2.75910757e-02f, -4.61614244e-02f, -3.85127626e-02f, 1.04984576e-02f, 7.26932511e-02f, -9.67081860e-02f, 1.74732748e-02f, 3.77839170e-02f,
  -3.79728973e-02f, -6.24379627e-02f, -6.02807961e-02f, -2.87603606e-02f, -4.69892472e-02f, 6.72028363e-02f, 1.21518888e-01f, -1.30016645e-02f, -2.16790214e-02f, -5.16166957e-03f,
  -2.35073790e-02f, 7.08797872e-02f, 1.11859746e-01f, -6.22479245e-02f, 8.28411058e-02f, 7.26258382e-02f, 3.31049114e-02f, -1.44469351e-01f, -5.08382916e-02f, 7.97466263e-02f,
  8.92298967e-02f, -5.94008304e-02f, -9.76621732e-02f, -3.76306176e-02f, -1.90572366e-02f, -6.14892356e-02f, -8.01801458e-02f, -4.49566403e-03f, 3.32559869e-02f, -8.50923825e-03f,
  3.66328917e-02f, -1.02969266e-01f, -7.75359049e-02f, 3.34286354e-02f, -1.24669522e-01f, 7.31194168e-02f, -3.18921953e-02f, -4.29662392e-02f, 9.74859670e-03f, -3.55792418e-02f,
  3.14455554e-02f, -8.31739902e-02f, 8.19522887e-02f, -2.36120820e-02f, -8.98721442e-03f, 1.07427083e-01f, -2.71558459e-03f, 2.00072471e-02f, 1.08071588e-01f, -3.66833881e-02f,
  -2.03251541e-02f, -1.64870340e-02f, 6.92325458e-02f, 4.41023372e-02f, 1.15085259e-01f, 1.42647447e-02f, 5.56375384e-02f, -1.00546151e-01f, -6.26795366e-03f, 2.06821803e-02f,
  4.48712230e-01f, 1.77656353e-01f, 5.05242705e-01f, 6.06408954e-01f, -4.72822320e-03f, -4.32327718e-01f, -2.18744412e-01f, 2.32298091e-01f, 4.23982888e-01f, -3.02345932e-01f,
  -1.48116067e-01f, 2.12002054e-01f, -3.99513394e-01f, 2.84843594e-01f, 2.08930839e-02f, -3.85091454e-01f, 2.58366704e-01f, -3.38772759e-02f, 1.25983596e-01f, 2.14291200e-01f,
  2.20825717e-01f, -1.33173412e-03f, 1.99974015e-01f, -2.43247580e-02f, 2.49020576e-01f, 2.63847828e-01f, 1.72337279e-01f, -2.81816758e-02f, 2.32584685e-01f, -2.30077565e-01f,
  1.24956593e-02f, 8.99413750e-02f, 1.24616064e-01f, -4.57051843e-02f, 2.45327107e-03f, -5.14208041e-02f, -1.38367653e-01f, -8.53870213e-02f, -2.39674188e-02f, -7.13743549e-03f,
  -5.32238670e-02f, -1.63032591e-01f, 4.39030826e-02f, -2.07481552e-02f, -2.89938413e-02f, 1.68578982e-01f, 1.10042147e-01f, 4.03962210e-02f, 5.41657172e-02f, -1.93703584e-02f,
  9.48764309e-02f, 7.27192359e-03f, 1.53053373e-01f, -5.75208105e-02f, 7.62447715e-02f, 5.94427772e-02f, -2.61132959e-02f, -8.97075888e-03f, 1.28073126e-01f, 8.93471763e-02f,
  -1.67386066e-02f, -2.55752187e-02f, 3.83988768e-02f, 3.20523344e-02f, 5.76168578e-03f, 8.16009566e-02f, 3.33333798e-02f, -6.13868162e-02f, 2.78806295e-02f, -8.60926881e-03f,
  1.65048279e-02f, 5.55021912e-02f, 5.95316999e-02f, -7.84378946e-02f, 5.09075746e-02f, 7.85052925e-02f, -5.50722703e-03f, -1.27497822e-01f, 1.34017184e-01f, 9.57332477e-02f,
  2.23140270e-02f, -6.52840734e-02f, 7.44656548e-02f, -5.61783612e-02f, 3.56172211e-03f, -4.76741530e-02f, -7.49288574e-02f, 1.92831419e-02f, 6.96559846e-02f, 2.96042394e-02f,
  -9.04249623e-02f, 1.27249792e-01f, -6.81079701e-02f, -2.12483015e-02f, 8.35820064e-02f, 1.65960174e-02f, 9.31874663e-02f, 3.17781940e-02f, 3.68982032e-02f, -3.46136070e-03f,
  -8.27076472e-03f, -5.43904267e-02f, 2.71193008e-03f, 3.89949717e-02f, -3.66936736e-02f, -2.26302352e-02f, -3.06193274e-03f, 4.98936921e-02f, -7.30911316e-03f, 3.45067345e-02f,
  3.99209037e-02f, -1.33949131e-01f, 4.39196751e-02f, 1.05339639e-01f, -5.19253127e-02f, -3.39398533e-02f, 2.87563726e-02f, 4.73297872e-02f, 2.23865174e-02f, 2.32052635e-02f,
  -1.80179119e-01f, 3.30238611e-01f, 1.24355182e-01f, -2.78163314e-01f, -5.61563745e-02f, -3.04833323e-01f, -4.26007807e-01f, 1.37121052e-01f, 1.09185904e-01f, 1.15257412e-01f,
  -6.53472915e-02f, 2.28565499e-01f, 7.62845948e-02f, -1.29708692e-01f, -3.89604807e-01f, -2.66040981e-01f, -3.56335223e-01f, -1.73733309e-01f, -8.14804286e-02f, -2.52581894e-01f,
  -2.49964848e-01f, -3.52489322e-01f, -2.95850992e-01f, 1.78943668e-02f, -2.51715854e-02f, 1.19939230e-01f, -2.11799473e-01f, 1.96798635e-03f, -2.82452796e-02f, 6.85029104e-02f,
  -9.32876319e-02f, 1.53955832e-01f, 2.06142724e-01f, 1.14966691e-01f, -4.87603210e-02f, 3.18751708e-02f, -3.15950848e-02f, -7.58237541e-02f, 2.18389165e-02f, 4.50024568e-02f,
  -1.17487023e-02f, -1.58328991e-02f, -4.14833575e-02f, 4.65900861e-02f, 2.73688380e-02f, 1.86185464e-01f, 3.80201489e-02f, 5.36161363e-02f, 1.14812486e-01f, 4.32302989e-02f,
  -5.92268370e-02f, 1.36176765e-01f, 5.77786639e-02f, 1.32250348e-02f, -1.92136448e-02f, 1.08461834e-01f, -8.50784183e-02f, 1.97934266e-02f, 2.35271845e-02f, 3.99441905e-02f,
  -1.12773217e-02f, -9.11776945e-02f, -2.83846445e-02f, 7.67965093e-02f, -5.91497589e-03f, 6.20183758e-02f, 3.76749365e-03f, -4.04331386e-02f, 2.37314496e-02f, -7.27113262e-02f,
  -3.70009243e-02f, 3.14323753e-02f, 4.02322896e-02f, -4.22569923e-02f, -8.59920904e-02f, 1.36300758e-01f, -7.74477571e-02f, 8.49964023e-02f, -3.11307702e-02f, 1.21409809e-02f,
  -2.38630362e-02f, -2.94450559e-02f, 5.97572662e-02f, -1.76455110e-01f, 3.84326326e-03f, 2.40388867e-02f, 1.43936321e-01f, 1.40597031e-01f, -2.21665148e-02f, -1.71428591e-01f,
  -1.12771787e-01f, -6.26856536e-02f, 8.78961459e-02f, 1.61692441e-01f, -6.02262840e-02f, -3.20768878e-02f, -7.63700232e-02f, 5.37214689e-02f, -1.32518128e-01f, -1.18056372e-01f,
  -3.51146087e-02f, 2.81742420e-02f, -1.11702010e-01f, 8.16109851e-02f, 2.41929479e-02f, -4.03185375e-02f, -1.12175584e-01f, 1.03543848e-01f, -3.91231626e-02f, 4.17534783e-02f,
  -3.16739199e-03f, 2.24409495e-02f, -1.07791387e-01f, -6.56779855e-02f, -7.98486080e-03f, -1.10508621e-01f, 2.09314730e-02f, 9.69353542e-02f, -7.67583400e-02f, -2.92409863e-02f,
  -3.37696254e-01f, -3.12340319e-01f, -3.97691756e-01f, -1.48730591e-01f, 2.69853443e-01f, 1.44032747e-01f, -4.01202440e-01f, 1.54649362e-01f, -3.32376957e-01f, -8.62545893e-02f,
  1.66516285e-02f, -2.13546172e-01f, -4.40771073e-01f, -2.31129993e-02f, -1.98832136e-02f, -4.32174593e-01f, -1.86744370e-02f, -4.83507179e-02f, -1.26959145e-01f, -5.12878224e-03f,
  -1.61188841e-02f, 2.55456209e-01f, -1.41132087e-01f, 3.83904248e-01f, -5.52271530e-02f, 4.84132953e-02f, 3.36874694e-01f, -2.13331245e-02f, 3.26070130e-01f, 2.37448543e-01f,
  -5.12892962e-04f, -2.36862347e-01f, -2.74149124e-02f, -7.32553983e-03f, 4.62468714e-02f, -7.54972640e-03f, 6.21794015e-02f, 3.39065231e-02f, 2.66175475e-02f, -1.01956412e-01f,
  -3.36878113e-02f, 7.02339709e-02f, 1.08126976e-01f, 1.30877132e-03f, 3.11718602e-02f, 8.12573209e-02f, -9.61007457e-03f, 6.35346919e-02f, -1.51808202e-01f, -1.90369889e-01f,
  -1.14137173e-01f, 6.26826063e-02f, -4.12101904e-03f, -1.65478932e-03f, -9.57670212e-02f, 3.57407816e-02f, 4.72175851e-02f, -2.91615818e-03f, 6.36733919e-02f, 8.64651985e-03f,
  3.82016823e-02f, 3.11098378e-02f, -6.28640056e-02f, 1.43044498e-02f, -1.67517308e-02f, 7.59081263e-03f, 3.45398262e-02f, 3.78707945e-02f, -3.36126536e-02f, -7.32389390e-02f,
  4.54011299e-02f, -1.07518747e-01f, 4.04920131e-02f, 3.47586945e-02f, -3.80699560e-02f, 8.83062258e-02f, 2.16041543e-02f, 8.71820226e-02f, -7.17912763e-02f, 7.20713735e-02f,
  -1.56087885e-02f, 7.89662749e-02f, 2.89779180e-03f, 3.57074849e-02f, 1.00593984e-01f, -8.72190818e-02f, -7.98408501e-03f, -1.19303083e-02f, -2.56524067e-02f, 4.83881310e-02f,
  7.77859241e-02f, -6.74375221e-02f, -9.06124711e-02f, 3.24943326e-02f, 3.78884226e-02f, 6.51818886e-02f, 9.75722671e-02f, 4.65061851e-02f, -3.50684766e-03f, 4.53672670e-02f,
  8.90121907e-02f, 8.76510665e-02f, 2.26224419e-02f, 2.40134485e-02f, 1.32245436e-01f, -1.45547017e-02f, 1.44969197e-02f, 1.30842358e-01f, 1.18826471e-01f, 4.89035696e-02f,
  -2.06903834e-02f, -1.02443621e-02f, 6.28819987e-02f, -4.59213518e-02f, 6.35847300e-02f, -1.46648390e-02f, 9.62419361e-02f, -5.85236996e-02f, 1.05379820e-01f, -1.95989646e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.18291843e-01f, 1.66232094e-01f, 2.22002357e-01f, 1.57023549e-01f, 3.50950569e-01f, 1.49495512e-01f, 1.07645884e-01f, 6.21853359e-02f, 4.20961767e-01f, 2.74469316e-01f,
  3.36963385e-01f, 3.72504234e-01f, 3.15563589e-01f, 3.68254542e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.97524548e-02f, -1.12088084e-01f, -8.43594819e-02f, -1.04872040e-01f, 1.77219957e-01f, 2.02661350e-01f, 2.44115978e-01f, 1.79040834e-01f, 1.96321785e-01f, -2.10368976e-01f,
  3.71701382e-02f, 6.54832497e-02f, -1.32155195e-01f, 6.94069779e-03f, 2.47485578e-01f, -9.36900005e-02f, 7.89025798e-02f, -1.34656414e-01f, 2.93962687e-01f, 2.75222380e-02f,
  1.34773940e-01f, -2.67855674e-01f, 3.43106508e-01f, 7.40996227e-02f, -5.57943434e-02f, -4.35032919e-02f, 8.00719112e-02f, -1.13855429e-01f, 2.41025433e-01f, -2.71337032e-01f,
  -1.27631530e-01f, -3.09946626e-01f, 9.58903506e-03f, 1.70121789e-01f, 4.21662629e-02f, 7.25961700e-02f, -4.78948187e-03f, -4.39330637e-02f, -6.77506924e-02f, -6.96422532e-02f,
  -7.59848878e-02f, 3.13003600e-01f, -8.00367519e-02f, -1.74747303e-01f, 5.50630363e-03f, -6.05876185e-02f, -1.20821625e-01f, 2.37770658e-02f, -1.41082659e-01f, 2.70895958e-01f,
  -2.17266425e-01f, -2.71678150e-01f, -2.97816843e-01f, 1.87715247e-01f, -3.48684520e-01f, -9.39494669e-02f, -2.41164174e-02f, -1.82856053e-01f, -2.19366089e-01f, -2.83033282e-01f,
  -2.31353536e-01f, 7.43549019e-02f, 2.49685258e-01f, -5.13238870e-02f, -5.34829162e-02f, 1.77351072e-01f, -2.71217823e-01f, -5.83699532e-03f, 3.22323516e-02f, -1.61485791e-01f,
  -1.00501247e-01f, -1.81433260e-01f, -7.23074153e-02f, 2.15170532e-01f, -2.24726081e-01f, 2.06638202e-01f, 1.72313079e-01f, -1.62495494e-01f, -6.64833700e-04f, 1.87479541e-01f,
  -1.05357721e-01f, 2.91020483e-01f, 7.24050030e-02f, -1.54806167e-01f, 2.27652094e-03f, -1.66013762e-01f, -1.68935418e-01f, 2.51165062e-01f, 2.65491486e-01f, -1.93382248e-01f,
  -3.99056785e-02f, 8.49726349e-02f, -1.63389608e-01f, -4.09587741e-01f, 3.35843235e-01f, 7.07086325e-02f, -1.22847386e-01f, -1.39979854e-01f, -7.65216202e-02f, -1.87025666e-01f,
  -5.81282116e-02f, -2.09056482e-01f, -2.17452012e-02f, -1.26935378e-01f, -2.40415148e-02f, -2.40454212e-01f, 1.02396324e-01f, 1.08881854e-02f, -5.46886399e-02f, 1.89496428e-02f,
  -1.18020058e-01f, 9.53115672e-02f, 1.68819755e-01f, -1.29580721e-01f, -2.24168584e-01f, 2.49829888e-01f, -2.36556500e-01f, -1.54056773e-01f, 2.55978942e-01f, -3.63254249e-01f,
  2.92359357e-04f, 9.22307670e-02f, -9.88605097e-02f, -1.46579957e-02f, 8.54340643e-02f, 3.08901846e-01f, -2.02755898e-01f, 2.37231717e-01f, 2.16925383e-01f, 2.06689179e-01f,
  -1.61558818e-02f, 8.05576220e-02f, 8.56214240e-02f, 5.30192852e-02f, -6.33578002e-02f, 1.79314762e-01f, 9.17619020e-02f, 1.21551961e-01f, -8.72964114e-02f, 3.94813597e-01f,
  2.34666079e-01f, -3.52858275e-01f, -4.92839739e-02f, -1.22161277e-01f, 1.13959727e-03f, 5.41349920e-03f, 6.87512159e-02f, -2.94499904e-01f, 2.42856160e-01f, -3.51632744e-01f,
  1.83999896e-01f, 1.59496114e-01f, -2.56439626e-01f, 3.07833627e-02f, 2.82500297e-01f, 2.18313798e-01f, -1.01081379e-01f, 4.04624432e-01f, -1.06457859e-01f, -1.09448284e-01f,
  1.14999205e-01f, -2.46661544e-01f, 1.06823571e-01f, -2.08717555e-01f, 4.15303558e-02f, -1.21831037e-01f, -2.99167223e-02f, 2.34674335e-01f, -7.08241537e-02f, -3.24702524e-02f,
  9.10696387e-02f, -1.60363182e-01f, -3.24778974e-01f, 7.98628479e-02f, -2.06214055e-01f, -1.33629814e-01f, 1.28574327e-01f, 3.44453752e-01f, -1.39240921e-01f, 2.74586350e-01f,
  -3.90770882e-01f, 1.51875943e-01f, -6.40948489e-02f, -2.32286349e-01f, -2.56523252e-01f, -2.57528722e-01f, 8.49807486e-02f, 2.54619539e-01f, 1.43175676e-01f, 1.02311723e-01f,
  7.67639056e-02f, -4.41399440e-02f, 1.41924813e-01f, -4.60334361e-01f, 6.16727173e-02f, -2.05042109e-01f, 2.40315452e-01f, 8.05872604e-02f, 1.85387492e-01f, 1.46968603e-01f,
  -2.52252668e-01f, -1.86571613e-01f, -2.74274312e-02f, -3.06536525e-01f, -3.29791307e-01f, 1.61057830e-01f, 9.36732292e-02f, -1.71881363e-01f, -5.01021259e-02f, 1.03385816e-03f,
  -8.24064761e-02f, 2.74050832e-01f, -3.40872407e-01f, -1.72811672e-01f, 1.61543414e-01f, -2.61880338e-01f, -9.67946351e-02f, -2.07301695e-02f, -7.69808292e-02f, 2.47266158e-01f,
  1.80017650e-01f, 1.86042652e-01f, -3.23518395e-01f, -1.32527992e-01f, 6.78144470e-02f, -1.90809086e-01f, -1.30357131e-01f, 9.36212763e-02f, -1.63559005e-01f, -3.75080220e-02f,
  5.87025173e-02f, 1.26468897e-01f, 3.04604083e-01f, -1.51355058e-01f, 2.25345373e-01f, 1.69939861e-01f, -1.08229853e-01f, 3.19382071e-01f, -1.34612575e-01f, -1.11435428e-01f,
  1.38816983e-01f, 4.52403426e-02f, 1.26617074e-01f, 5.84730320e-02f, 2.32564330e-01f, -1.16764329e-01f, -1.06489159e-01f, 8.26682076e-02f, -1.79049551e-01f, -1.52335957e-01f,
  1.22168399e-01f, -8.14328641e-02f, 2.39280015e-01f, -1.97364181e-01f, -2.31859963e-02f, 9.18189883e-02f, 2.41837054e-01f, -1.00190707e-01f, 9.11252424e-02f, 4.19529341e-02f,
  -1.90406978e-01f, -1.72880113e-01f, -2.28816435e-01f, 1.09458946e-01f, 6.14758655e-02f, -1.81442067e-01f, -2.74744362e-01f, 2.22513855e-01f, -2.49126390e-01f, -1.90452620e-01f,
  -1.07949674e-01f, -5.31725921e-02f, 3.50265950e-01f, 7.02857226e-02f, -3.88309844e-02f, 7.36948699e-02f, -6.09719306e-02f, -1.17020003e-01f, 4.59105149e-02f, 1.65163994e-01f,
  -1.59208342e-01f, 5.23899235e-02f, 2.94641275e-02f, 3.44916433e-01f, -8.77891853e-02f, 4.33644712e-01f, 2.09891424e-02f, -6.49142712e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.28489926e-01f, 3.66576761e-01f, 2.27915555e-01f, 9.35689136e-02f, 3.55021775e-01f, 1.33693695e-01f, 1.69064730e-01f, 2.70407587e-01f, 1.96876526e-01f, 3.96859169e-01f,
  -2.75571227e-01f, 3.14027630e-02f, 2.48218969e-01f, -1.68125838e-01f, 1.58909917e-01f, 4.98591289e-02f, -2.90595382e-01f, 1.47724152e-01f, 3.19200009e-01f, 1.70557864e-03f,
  -1.02747582e-01f, 2.61972487e-01f, 3.46027352e-02f, 4.48246211e-01f, 4.98127937e-01f, -2.50662386e-01f, -5.49164228e-02f, -1.42001197e-01f, -1.92326844e-01f, -1.74503282e-01f,
  5.65998733e-01f, 2.33652294e-01f, 5.33924922e-02f, 3.85587931e-01f, 2.69634128e-01f, 5.74470088e-02f, 2.34553143e-01f, 1.28069237e-01f, 2.44710237e-01f, 2.79919684e-01f,
  1.65584907e-01f, -3.55580449e-01f, 2.14309469e-01f, -8.83291662e-02f, 4.24977317e-02f, -2.41145372e-01f, 1.09780028e-01f, 3.37568671e-01f, -9.81945544e-03f, -4.15687412e-01f,
  -8.66228566e-02f, 2.01048218e-02f, -1.03110828e-01f, -1.03032827e-01f, 4.81809884e-01f, 2.53309637e-01f, 4.25389677e-01f, 5.40010750e-01f, -1.96752340e-01f, -1.31557494e-01f,
  1.40223563e-01f, 3.53121102e-01f, 2.21472487e-01f, 1.11900724e-01f, 1.18175924e-01f, 9.10011008e-02f, 9.81320664e-02f, -1.03960380e-01f, 2.95188397e-01f, 4.55352738e-02f,
  3.03567469e-01f, 2.49798030e-01f, -2.30901778e-01f, -4.82638255e-02f, -2.21778955e-02f, -3.72933596e-01f, -1.61105264e-02f, -1.20789871e-01f, 1.58153474e-01f, 1.81636438e-01f,
  -2.67754138e-01f, -2.50130802e-01f, -1.15200626e-02f, -1.58779584e-02f, -3.15017819e-01f, 5.51172979e-02f, 5.32960117e-01f, -3.22302490e-01f, 5.08577108e-01f, 4.94405746e-01f,
  -1.69029728e-01f, 3.03454101e-01f, 1.73434727e-02f, 3.49245131e-01f, 5.12543879e-02f, -2.05226645e-01f, 3.47678691e-01f, 4.88228410e-01f, 2.77719229e-01f, 9.00244638e-02f,
  1.10753708e-01f, 1.68625072e-01f, 1.77928194e-01f, 1.79027364e-01f, 1.78095803e-01f, 1.49351373e-01f, -3.46427292e-01f, 3.84609699e-01f, 4.01295386e-02f, -3.85276943e-01f,
  2.49975935e-01f, 1.50125086e-01f, 3.66994068e-02f, 1.54279813e-01f, 2.45647714e-01f, -1.03333279e-01f, 3.07906661e-02f, -2.52481908e-01f, 1.52572449e-02f, 5.45497358e-01f,
  2.03026041e-01f, -8.30165595e-02f, 5.80148883e-02f, 2.09395990e-01f, -1.06012352e-01f, 6.65558083e-03f, 5.23904681e-01f, -7.89389983e-02f, 3.72791857e-01f, 3.22335899e-01f,
  1.94922954e-01f, 4.99152429e-02f, 1.90015689e-01f, 1.94573909e-01f, 3.34734350e-01f, 3.35307211e-01f, 4.72757339e-01f, 1.28386945e-01f, -4.34464663e-01f, 2.94244081e-01f,
  -3.26273978e-01f, -2.41355658e-01f, -1.74403861e-01f, -3.67132634e-01f, 3.16525966e-01f, 4.08851683e-01f, 1.92928372e-03f, -2.61165172e-01f, -1.57976318e-02f, -3.03849597e-02f,
  2.27865130e-01f, 3.58141899e-01f, 1.07878797e-01f, -3.21630329e-01f, 5.21749973e-01f, 3.51504982e-01f, 6.44219890e-02f, 5.11311233e-01f, 3.88769001e-01f, -3.11899304e-01f,
  -1.31207481e-01f, 1.74098089e-02f, 1.16911255e-01f, 2.70883292e-01f, -1.07743042e-02f, 2.99318701e-01f, 7.34403729e-02f, 9.01413262e-02f, 2.11635768e-01f, -2.18189135e-01f,
  2.44511411e-01f, -7.33514689e-03f, -9.25922915e-02f, 4.97846305e-01f, -3.57959926e-01f, -7.44427834e-03f, 2.53809750e-01f, 1.02756113e-01f, -7.20979869e-02f, 3.21245879e-01f,
  1.37119889e-01f, 7.35407591e-01f, -4.57243979e-01f, -2.55872924e-02f, -6.70634449e-01f, 1.50511906e-01f, 9.93552059e-02f, 5.83466627e-02f, 3.21140260e-01f, 6.39289021e-01f,
  1.54041499e-01f, 6.56248450e-01f, 9.24979970e-02f, 2.38783419e-01f, 3.15911651e-01f, 1.55624762e-01f, 3.60632598e-01f, 3.27439904e-01f, 2.00953633e-01f, 2.45467052e-01f,
  1.64125711e-01f, 2.41059631e-01f, 1.98037387e-03f, -1.64650083e-01f, 2.35788941e-01f, -5.76535761e-02f, 4.00583893e-01f, 8.72953534e-02f, -2.93593198e-01f, -8.69749580e-03f,
  3.95787567e-01f, -4.15753722e-02f, 2.59161443e-01f, -4.51581599e-03f, 3.37065905e-01f, 3.05567056e-01f, 4.64771748e-01f, 7.59213883e-03f, 1.27521381e-01f, -6.31082132e-02f,
  9.42055229e-03f, -5.69330573e-01f, 1.76646277e-01f, 1.60467580e-01f, 3.70613903e-01f, 2.03480840e-01f, 3.45679462e-01f, 1.84068814e-01f, 6.12907670e-02f, 3.51554677e-02f,
  3.63059580e-01f, 2.05162346e-01f, 2.13722065e-01f, 1.01492189e-01f, -2.97169536e-01f, 3.15709919e-01f, -1.55967653e-01f, -1.45435661e-01f, -7.99548849e-02f, -3.82140428e-01f,
  -1.11558968e-02f, 3.26881438e-01f, 1.70309812e-01f, -1.79172963e-01f, 4.41827744e-01f, -1.26364276e-01f, 1.97623447e-01f, 5.06297871e-02f, -1.81726336e-01f, -1.52722105e-01f,
  3.76024008e-01f, 5.09872258e-01f, 1.29940867e-01f, 1.71832159e-01f, 1.84848204e-01f, -4.93728995e-01f, 1.78644210e-01f, 1.59558699e-01f, -8.72964561e-02f, 4.02684212e-01f,
  -1.26163766e-01f, 1.36421502e-01f, 2.33749151e-01f, 2.49777481e-01f, 2.58318603e-01f, -3.20347458e-01f, 9.88985300e-02f, 3.28576654e-01f, 1.01816431e-02f, 2.94547468e-01f,
  -1.49895325e-01f, 7.57597759e-02f, 2.93271065e-01f, -1.21897325e-01f, 4.86061096e-01f, 7.91677535e-02f, 6.18012309e-01f, -3.20416659e-01f, 1.27651408e-01f, 3.71159226e-01f,
  1.33202806e-01f, 1.11958580e-02f, 1.94944873e-01f, -7.26008713e-02f, 2.35121936e-01f, -3.09617996e-01f, -2.80331910e-01f, 4.50492710e-01f, 5.21628596e-02f, 2.86368411e-02f,
  7.35406801e-02f, -2.76157171e-01f, 1.86119229e-01f, -2.75554091e-01f, -5.31791300e-02f, 6.12766631e-02f, -3.97213310e-01f, 1.90219253e-01f, -3.14261436e-01f, 1.90253474e-03f,
  1.80448756e-01f, -8.53771046e-02f, 1.98788851e-01f, 1.84817061e-01f, -6.58140630e-02f, 3.67821485e-01f, -3.23182084e-02f, 1.05746217e-01f, -1.38378993e-01f, -1.38426334e-01f,
  1.11705974e-01f, -5.04983142e-02f, 1.36633590e-01f, 3.90903205e-01f, -2.03762665e-01f, 4.74363774e-01f, -3.31126362e-01f, 2.90972590e-01f, 8.37051347e-02f, 4.15214933e-02f,
  3.55820596e-01f, 1.63609106e-02f, 4.34714071e-02f, 1.03139170e-01f, -7.95674138e-03f, 2.55304545e-01f, 2.88764328e-01f, 3.11930358e-01f, 4.61552173e-01f, -4.46097441e-02f,
  -3.37107807e-01f, 1.83507815e-01f, -5.04424930e-01f, -2.24791259e-01f, -1.80350676e-01f, -5.16740680e-01f, 1.77097335e-01f, 2.15560183e-01f, 1.95368677e-01f, -4.73425575e-02f,
  3.89999747e-01f, -1.06759526e-01f, 2.16391683e-01f, -1.37769148e-01f, -3.91981870e-01f, -1.75189808e-01f, 4.95116711e-01f, 2.45255545e-01f, 3.90618354e-01f, 3.01328059e-02f,
  -2.70406771e-02f, -2.09427804e-01f, 1.00765660e-01f, -4.20754045e-01f, 4.07566763e-02f, -1.41275361e-01f, 2.19054237e-01f, 2.18781278e-01f, 6.99276403e-02f, 3.60708505e-01f,
  2.65542418e-01f, -3.76849681e-01f, 1.25317248e-02f, -2.28333309e-01f, -6.56645834e-01f, 7.52676874e-02f, -2.66974866e-01f, -1.80977538e-01f, 2.97038466e-01f, 1.44061530e-02f,
  4.45796251e-02f, 3.90427709e-01f, -1.64053321e-01f, -1.83044896e-01f, 1.95092142e-01f, -2.98396051e-01f, -3.61295968e-01f, 1.17134169e-01f, 4.52224910e-02f, -5.02462015e-02f,
  4.79824215e-01f, 1.14578679e-01f, -3.23523611e-01f, -3.82541753e-02f, 2.13514283e-01f, -6.67912737e-02f, 1.53005973e-01f, 2.36817703e-01f, 1.37431651e-01f, 2.21704185e-01f,
  4.28438812e-01f, 3.44418347e-01f, 3.36329073e-01f, -4.39358741e-01f, 1.36159614e-01f, -1.25363752e-01f, -3.39917511e-01f, -1.13487385e-01f, 2.39139751e-01f, -1.77217096e-01f,
  -1.71571493e-01f, -5.90859652e-01f, 5.21141231e-01f, 1.84711307e-01f, 2.58004546e-01f, -4.56334412e-01f, 4.55377102e-01f, 1.13709532e-01f, 2.36580104e-01f, -1.09636933e-02f,
  3.04566979e-01f, 3.25051062e-02f, 3.70801061e-01f, -3.05293649e-01f, -3.37925166e-01f, -4.06593055e-01f, -1.56003737e-03f, -8.48153755e-02f, 2.07994744e-01f, -2.20536709e-01f,
  1.10501342e-01f, -1.63803294e-01f, -1.10558122e-01f, 1.11405671e-01f, -4.27361935e-01f, 2.01868087e-01f, -9.09850225e-02f, 7.10702017e-02f, -9.34030414e-02f, -9.55946669e-02f,
  1.79085329e-01f, 7.89271668e-02f, -1.12036414e-01f, 2.11832359e-01f, 1.46751285e-01f, 2.98106253e-01f, -1.58897132e-01f, -2.72520989e-01f, 1.70266807e-01f, -1.44771680e-01f,
  2.57050488e-02f, 7.76958019e-02f, -1.90801904e-01f, 5.42293131e-01f, -3.31367888e-02f, -1.45058617e-01f, 2.78332949e-01f, 8.79683271e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.03907287e-01f, 2.48675793e-01f, 2.49443814e-01f, 1.17092170e-01f, 2.85820812e-01f, 4.03961658e-01f, 1.10891968e-01f, 9.87404138e-02f, 3.25918972e-01f, 1.57856513e-02f,
  2.55318761e-01f, 3.02689224e-01f, 1.77142829e-01f, 7.96542969e-03f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  7.70990476e-02f, -1.64489359e-01f, -1.04438104e-02f, 2.59548873e-01f, 6.49344698e-02f, 2.22087994e-01f, -1.40206769e-01f, -8.16904604e-02f, -3.25414538e-02f, 1.36444882e-01f,
  -2.74215728e-01f, -1.81079924e-01f, 1.07466437e-01f, -3.09217453e-01f, 2.80293465e-01f, 4.39070106e-01f, 1.60824165e-01f, 9.46122482e-02f, -8.70366842e-02f, 2.88810935e-02f,
  8.12821463e-02f, -1.65677860e-01f, -9.51243192e-02f, -9.32050962e-03f, 1.22833863e-01f, -1.81244865e-01f, -4.23747972e-02f, 8.55056196e-02f, -1.56622007e-02f, 1.99109435e-01f,
  1.36670277e-01f, 3.68931949e-01f, -4.92585748e-02f, -5.77134965e-03f, -5.49756959e-02f, -2.06147626e-01f, -1.14363685e-01f, -2.53480463e-03f, -1.76023677e-01f, -1.09846210e-02f,
  -1.66001022e-02f, 2.26153269e-01f, 4.57295179e-02f, 1.59082517e-01f, -5.14800921e-02f, 3.29395086e-01f, -1.40845682e-02f, -1.40920639e-01f, -3.53164971e-02f, 1.69839352e-01f,
  2.02661440e-01f, -4.95602265e-02f, -1.96652234e-01f, 2.02708006e-01f, 2.72608668e-01f, -2.83338040e-01f, 5.42680845e-02f, 1.35853007e-01f, -1.02026388e-01f, -1.13942057e-01f,
  2.62882918e-01f, -1.89368054e-01f, 6.83794916e-02f, -1.88609034e-01f, 6.11408837e-02f, 1.41561925e-01f, 1.14155561e-01f, -1.95069797e-02f, 3.95113602e-02f, 5.49453758e-02f,
  6.55474961e-02f, 1.72064811e-01f, 2.45194044e-02f, -2.05948457e-01f, 3.59191656e-01f, -6.10655472e-02f, 7.55274221e-02f, 1.28235787e-01f, -7.83907622e-02f, -2.55217791e-01f,
  -1.28837645e-01f, 1.59994870e-01f, -4.84770089e-02f, 2.25760996e-01f, 6.15343228e-02f, -2.35135648e-02f, 1.18449973e-02f, 1.51899979e-01f, -1.64731201e-02f, 2.42415518e-02f,
  -2.50811577e-01f, -2.52642304e-01f, -3.64422537e-02f, -8.32484812e-02f, -1.37685999e-01f, -1.96214005e-01f, -4.00295928e-02f, -1.35786787e-01f, -1.27054691e-01f, 1.43365651e-01f,
  -1.38680175e-01f, -6.22752458e-02f, -6.93803560e-03f, 1.90341156e-02f, 3.06930412e-02f, 5.89919426e-02f, -1.15314879e-01f, 4.66709100e-02f, 2.10679144e-01f, -2.05988541e-01f,
  8.62427056e-02f, 3.49122286e-01f, -1.86725542e-01f, -3.42932865e-02f, -2.39757989e-02f, 9.14008692e-02f, 1.63343892e-01f, -3.92738059e-02f, -1.00624390e-01f, -1.33107558e-01f,
  1.82239175e-01f, -2.34942690e-01f, -1.78751200e-01f, 2.43091002e-01f, -1.63713217e-01f, 2.46195838e-01f, -5.12537034e-03f, 1.88866794e-01f, -6.15499318e-02f, 1.12016991e-01f,
  -2.50096433e-02f, 1.14609368e-01f, 7.24882036e-02f, -2.55172253e-02f, 1.32737041e-01f, 1.47953341e-02f, -1.83178872e-01f, -2.56681800e-01f, 1.00355923e-01f, -2.22358301e-01f,
  1.68056428e-01f, -2.02928051e-01f, 3.38033102e-02f, 2.52644438e-02f, -1.53032839e-01f, -2.03587487e-01f, 2.78918091e-02f, 1.94242254e-01f, 2.12013438e-01f, -2.30344385e-01f,
  -1.14721343e-01f, -1.52221322e-02f, 7.03037158e-02f, -8.74126703e-03f, -1.77277729e-01f, 2.03784227e-01f, -2.89081842e-01f, -1.87690616e-01f, -1.96459949e-01f, 1.71785712e-01f,
  8.87244567e-02f, -1.20368659e-01f, -1.71031300e-02f, -1.98049977e-01f, -1.36053923e-03f, -1.77003950e-01f, -2.61961594e-02f, -1.47391826e-01f, -6.09193891e-02f, 1.01702169e-01f,
  -5.93375079e-02f, 2.10889593e-01f, 2.77972706e-02f, 6.17155954e-02f, 1.83289349e-01f, -2.72032619e-01f, 1.94035172e-01f, 7.48956725e-02f, 4.07126993e-02f, 1.83639824e-02f,
  -2.02111721e-01f, 2.24741340e-01f, -1.50310427e-01f, 2.74244118e-02f, 5.13202464e-03f, -1.89289730e-02f, 2.34477073e-01f, 2.14296654e-01f, -4.96989116e-02f, -3.17322880e-01f,
  -1.74166664e-01f, 2.80468911e-01f, -1.28550693e-01f, -2.47127175e-01f, -2.62730628e-01f, -1.25455603e-01f, 4.54336405e-02f, -2.89548934e-01f, 9.36376974e-02f, -1.93430647e-01f,
  1.37026876e-01f, 7.82991350e-02f, -1.58026084e-01f, 5.90938888e-02f, 1.82121918e-01f, 9.99318212e-02f, -3.18061173e-01f, 1.41763054e-02f, -1.13542818e-01f, 2.06140950e-01f,
  1.57040775e-01f, 2.41228089e-01f, 1.27299681e-01f, 1.24808013e-01f, -1.20668381e-01f, -7.43152797e-02f, -7.10903257e-02f, -7.94421583e-02f, 1.86881667e-03f, 2.75964916e-01f,
  -2.58837342e-01f, -1.43220067e-01f, -1.03367260e-02f, 2.46326298e-01f, -6.05580844e-02f, 8.19054917e-02f, 7.32043013e-02f, -1.65823892e-01f, -1.13507695e-01f, 3.12976576e-02f,
  -1.26458146e-02f, -4.12995666e-02f, 1.73679292e-01f, 1.01401910e-01f, -1.88699394e-01f, -8.79904777e-02f, -7.46244416e-02f, 1.84633046e-01f, 2.87851878e-02f, -2.56352723e-01f,
  1.79180309e-01f, 1.91015616e-01f, -2.46214718e-01f, -1.47976577e-01f, -1.73545122e-01f, 7.81546999e-03f, -1.79510385e-01f, 7.41658583e-02f, 1.88194588e-01f, 9.21470597e-02f,
  2.23173410e-01f, -4.54517044e-02f, 6.13864399e-02f, -5.16916737e-02f, 1.98403280e-02f, -1.45722702e-01f, -4.51529492e-03f, 2.39839181e-02f, -5.22240326e-02f, 9.32506248e-02f,
  -1.37103766e-01f, 1.61798045e-01f, 5.61067872e-02f, -1.43996522e-01f, 3.76630835e-02f, -4.75011989e-02f, 1.18570939e-01f, -1.18299723e-01f, -1.34351207e-02f, -3.57638896e-01f,
  2.63261632e-03f, 2.78081089e-01f, -1.45267814e-01f, -2.82391787e-01f, 1.14064693e-01f, -8.20436478e-02f, 1.92338243e-01f, -8.18761364e-02f, -1.99446231e-01f, -8.65301713e-02f,
  2.14029357e-01f, -1.01413071e-01f, -1.73385650e-01f, 1.45089850e-01f, -2.96971321e-01f, 1.16438933e-01f, -1.09956702e-02f, 1.57042056e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.81018963e-01f, -4.60768826e-02f, 1.23016834e-01f, 3.32403146e-02f, -6.45623654e-02f, 7.89052993e-03f, -8.06963965e-02f, 1.86440542e-01f, 1.85591206e-01f, 2.61745691e-01f,
  -2.10447967e-01f, 2.04640359e-01f, -3.20579350e-01f, 3.94899607e-01f, -4.01797712e-01f, -2.08450317e-01f, 1.30430479e-02f, -1.09421825e-02f, 5.35943210e-01f, 2.66329110e-01f,
  2.12675214e-01f, 3.71381909e-01f, 4.24309760e-01f, -7.11967111e-01f, 5.34650028e-01f, 2.73714483e-01f, 1.45156786e-01f, -2.04830706e-01f, 2.66926616e-01f, -3.02656472e-01f,
  1.89858064e-01f, -1.47518972e-02f, 2.95421928e-01f, 3.11040759e-01f, -3.07527244e-01f, 9.09955800e-02f, 2.84549326e-01f, -7.37259015e-02f, 2.15152986e-02f, 1.97639659e-01f,
  1.48893431e-01f, 3.38747241e-02f, -2.17766240e-01f, 3.95289928e-01f, 4.68504690e-02f, 6.16365433e-01f, -1.08139150e-01f, -3.02274257e-01f, -2.56624017e-02f, 4.22301710e-01f,
  3.37450892e-01f, 4.10722107e-01f, 7.37618208e-02f, 4.70237941e-01f, 4.34990197e-01f, 2.35561937e-01f, -4.56802435e-02f, -1.63084552e-01f, 1.12561733e-01f, 2.74577349e-01f,
  -3.19666088e-01f, -2.38354802e-01f, -7.03805611e-02f, -2.61065480e-03f, 6.42123148e-02f, 1.88388810e-01f, -1.70155063e-01f, 1.44838661e-01f, 1.29033506e-01f, 2.35503912e-01f,
  -4.88622151e-02f, -9.47384983e-02f, 1.70117959e-01f, 9.12956223e-02f, -3.13658625e-01f, -3.37483436e-02f, 1.30614311e-01f, 1.14001229e-01f, 5.90152085e-01f, 3.35656643e-01f,
  5.63406199e-02f, 3.04288566e-01f, -6.83683231e-02f, -1.71875671e-01f, 4.44253013e-02f, 1.84673056e-01f, 5.05783319e-01f, 6.05991632e-02f, 3.38401347e-02f, 5.09248137e-01f,
  -9.62791964e-02f, 5.32507002e-01f, 5.63000143e-01f, 4.40822810e-01f, 1.03937812e-01f, 5.66896081e-01f, 3.43674794e-02f, -1.78104103e-01f, 3.80772769e-01f, 1.61499500e-01f,
  1.86282307e-01f, 1.67092904e-01f, 2.83393383e-01f, 1.70652926e-01f, 1.72071010e-01f, 6.49104640e-02f, -1.00193553e-01f, -4.43180978e-01f, 2.78474897e-01f, -3.55419457e-01f,
  -3.10719639e-01f, -3.09003051e-02f, -4.80291881e-02f, -4.50833112e-01f, -5.76795153e-02f, 3.88982624e-01f, 4.56784457e-01f, -4.20340598e-01f, -5.14109373e-01f, 4.69919622e-01f,
  3.00190479e-01f, -4.67144608e-01f, 1.89974189e-01f, -4.19835858e-02f, -2.39735380e-01f, 1.28552422e-01f, 5.66381335e-01f, -1.48612484e-02f, 1.73050523e-01f, 2.81629503e-01f,
  2.53716230e-01f, 2.56133229e-01f, -5.92501322e-03f, 2.43575498e-01f, 4.66507487e-02f, 1.04060220e-02f, -2.20636606e-01f, -2.45304033e-01f, 1.63169906e-01f, -5.74372299e-02f,
  -2.53156513e-01f, 1.53581724e-01f, 4.58832383e-01f, 1.02884538e-01f, -4.49847728e-02f, 1.74746782e-01f, 1.21309971e-02f, -4.36501354e-01f, -8.15020874e-02f, 5.91784045e-02f,
  2.94652253e-01f, 3.36645335e-01f, -3.06034863e-01f, 4.42708313e-01f, -1.95059717e-01f, 3.52936715e-01f, 3.56055170e-01f, -1.47986189e-01f, -3.07530373e-01f, 3.19053292e-01f,
  3.78988981e-02f, -1.07274614e-02f, -6.97882250e-02f, 2.87240177e-01f, 1.45544767e-01f, 1.13648966e-01f, 1.87960193e-01f, -1.39246089e-02f, 1.64615124e-01f, 2.76798666e-01f,
  -2.90031433e-01f, -2.91092157e-01f, 3.39916557e-01f, -1.55601844e-01f, -1.08770467e-01f, 4.10879433e-01f, 2.22588852e-01f, 2.66814888e-01f, -4.99603927e-01f, 4.70505446e-01f,
  3.31286818e-01f, -3.30016106e-01f, -5.82266524e-02f, 3.38339657e-01f, -2.44796962e-01f, -2.07995415e-01f, 3.82895768e-01f, -4.60505439e-03f, 3.18647146e-01f, 6.54287636e-01f,
  3.16525429e-01f, -2.99227852e-02f, 2.71739900e-01f, 6.49670810e-02f, 6.70870468e-02f, -4.50104661e-02f, 2.59195715e-01f, 4.15169671e-02f, -1.45161644e-01f, 1.17927361e-02f,
  -3.56765315e-02f, -5.20429015e-01f, 5.60513973e-01f, -1.33975953e-01f, -9.39646550e-03f, -5.65696582e-02f, 6.48288568e-03f, -4.21703279e-01f, -3.48418839e-02f, 1.48025468e-01f,
  2.65435576e-01f, 2.37381339e-01f, -7.36946240e-02f, 5.67947887e-02f, 3.62902641e-01f, 5.38767040e-01f, -2.93398529e-01f, 1.08848266e-01f, -6.08221181e-02f, -2.80966282e-01f,
  9.24021006e-02f, -2.93111429e-02f, -5.44797897e-01f, -3.73319060e-01f, -2.40085244e-01f, -1.85317606e-01f, 3.28963578e-01f, 1.64554361e-02f, 6.38121367e-02f, -1.11915879e-01f,
  1.09145008e-01f, 2.16581076e-01f, 4.52382177e-01f, 5.47522008e-01f, -5.40188134e-01f, -2.12594107e-01f, -9.64700133e-02f, 3.65555346e-01f, -2.97038078e-01f, -7.33703077e-02f,
  4.30965453e-01f, 1.26184121e-01f, 2.17146687e-02f, 2.99136311e-01f, -2.65351832e-01f, 1.80856824e-01f, 3.96655761e-02f, -1.16594918e-01f, 2.89224595e-01f, 6.92272708e-02f,
  7.60099173e-01f, -4.53830570e-01f, 4.08197284e-01f, 1.34646505e-01f, 6.45523429e-01f, -3.34610119e-02f, -1.28394112e-01f, 2.17450559e-01f, 2.65497535e-01f, 1.39552623e-01f,
  7.35984296e-02f, 2.50073969e-01f, 1.43601596e-01f, 1.63213670e-01f, -3.33488509e-02f, 1.02118984e-01f, -2.34538510e-01f, -6.96920082e-02f, -6.48316815e-02f, 4.61564392e-01f,
  1.63869467e-02f, 3.52530718e-01f, 1.38398111e-01f, 3.88313740e-01f, -2.34306574e-01f, -2.16689911e-02f, 1.57109439e-01f, 1.81436434e-01f, 5.83945274e-01f, -2.86105812e-01f,
  2.85417680e-02f, 4.50952142e-01f, -1.37778908e-01f, -7.11142495e-02f, 4.75375742e-01f, 5.27650336e-05f, 4.08149481e-01f, -5.48562929e-02f, 2.23178208e-01f, 1.78251445e-01f,
  2.73820162e-01f, 1.64134219e-01f, 1.42669454e-01f, 2.66347319e-01f, 1.12249255e-01f, 6.26560971e-02f, -1.34249479e-01f, -1.44040078e-01f, 5.02257168e-01f, 2.37236366e-01f,
  -4.21388358e-01f, -4.85770106e-01f, -3.48138958e-01f, -4.58732158e-01f, -2.68826723e-01f, -5.12137175e-01f, 7.15036809e-01f, 1.06082961e-01f, -6.51350841e-02f, 4.44689363e-01f,
  2.81972855e-01f, 1.39658138e-01f, 7.87011921e-01f, 1.17368773e-01f, 1.75874889e-01f, -5.97154126e-02f, -1.58509150e-01f, -4.59687799e-01f, -2.63478577e-01f, -4.57334034e-02f,
  -4.60949019e-02f, 3.95878516e-02f, 3.94691020e-01f, -2.74714857e-01f, 7.92513490e-02f, -1.77075312e-01f, -4.47982103e-02f, -1.52687788e-01f, -4.59713899e-02f, -1.36338517e-01f,
  2.59466141e-01f, 1.75284371e-02f, -3.25548410e-01f, 3.99002045e-01f, -3.36685419e-01f, -7.16137588e-01f, 2.37722322e-01f, 1.89762250e-01f, -1.00969709e-01f, -5.01534380e-02f,
  -5.81219614e-01f, 2.58725006e-02f, 3.57387900e-01f, 5.40254951e-01f, -6.90836981e-02f, 5.38192034e-01f, 5.55879772e-01f, -3.37256730e-01f, 2.79508799e-01f, -3.00545007e-01f,
  -1.88823447e-01f, -4.18132603e-01f, -5.48856594e-02f, 2.66959555e-02f, -4.02477145e-01f, 5.61344810e-02f, 1.80861712e-01f, 1.08179763e-01f, -1.37911633e-01f, 5.17335981e-02f,
  2.03282520e-01f, -2.43920892e-01f, 2.10480150e-02f, 3.42013761e-02f, 7.22233206e-02f, 3.32631171e-01f, 3.09819691e-02f, 3.16808820e-01f, -4.85009909e-01f, 3.72710139e-01f,
  9.08710286e-02f, 6.45224869e-01f, 8.12335908e-01f, 4.13820803e-01f, 4.08712775e-01f, -1.28091797e-01f, -5.27496077e-02f, 2.48762354e-01f, -4.73043293e-01f, 4.84907925e-01f,
  5.04786856e-02f, 9.87669751e-02f, -1.93069488e-01f, 2.22927734e-01f, -5.02648167e-02f, -8.03268626e-02f, 1.74929693e-01f, 9.05351415e-02f, 8.80523771e-02f, 3.30353975e-01f,
  7.26540238e-02f, -2.43992969e-01f, 2.22463131e-01f, 1.08153652e-03f, -8.51383582e-02f, -1.51251122e-01f, 1.67024001e-01f, -1.22015625e-01f, 3.68573815e-01f, 4.84104790e-02f,
  3.05356950e-01f, 2.04563409e-01f, -4.73840594e-01f, -1.70989588e-01f, -2.97356576e-01f, -1.04028620e-01f, 3.99478018e-01f, 5.45990825e-01f, -3.62980038e-01f, 3.76221240e-01f,
  3.44422817e-01f, -2.06953123e-01f, 5.18392682e-01f, 4.70317096e-01f, 2.79883444e-01f, -1.42044097e-01f, 2.80781567e-01f, 2.14560047e-01f, 1.37382582e-01f, 3.63671184e-01f,
  3.34522665e-01f, 4.33039457e-01f, 2.74846822e-01f, 2.42222212e-02f, 7.65526965e-02f, -2.32687458e-01f, 1.49417743e-01f, -2.44631693e-01f, 1.57064945e-01f, -3.69544864e-01f,
  3.03145319e-01f, 1.27951980e-01f, 2.74226695e-01f, -5.35028800e-02f, 1.42665461e-01f, 8.59009475e-02f, -2.51506239e-01f, -3.14964145e-01f, 1.62982181e-01f, 8.13370943e-01f,
  -1.80815846e-01f, -2.61207014e-01f, 1.31566703e-01f, -2.64538378e-02f, 6.63400367e-02f, 5.38108110e-01f, -2.33551785e-01f, -1.40752479e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.23129511e-02f, -2.42406409e-02f, 4.67688367e-02f, 1.49614990e-01f, 1.52380779e-01f, 5.75561598e-02f, 2.20850185e-01f, 1.14053868e-01f, 8.97926316e-02f, 2.67777383e-01f,
  -5.57209812e-02f, 1.23601653e-01f, -1.67148339e-03f, 3.18061322e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.06874101e-03f, 2.44529232e-01f, 1.94618806e-01f, -1.82221577e-01f, 5.01879044e-02f, -1.41859546e-01f, 1.16308734e-01f, 4.16993946e-02f, -4.52537090e-02f, 3.47214997e-01f,
  -2.30622724e-01f, -2.62416244e-01f, 1.72763824e-01f, 1.90003291e-01f, -4.25187439e-01f, 2.08725125e-01f, -2.64668107e-01f, 2.64868915e-01f, 1.45657197e-01f, -1.94626793e-01f,
  -7.06416309e-01f, 6.36184990e-01f, -3.54376376e-01f, 2.49555036e-01f, -1.24843165e-01f, 2.84070760e-01f, 1.13421164e-01f, -1.80632427e-01f, -4.56216544e-01f, -8.33790377e-02f,
  -6.47583723e-01f, -3.91518742e-01f, -2.78868139e-01f, -1.58987716e-01f, 1.02223463e-01f, 2.26711929e-01f, 1.24418139e-01f, 9.01625026e-03f, -1.22022040e-01f, 1.78162947e-01f,
  2.82015651e-01f, 3.14413548e-01f, -4.31950152e-01f, -3.69753093e-01f, 3.22481781e-01f, -2.00136915e-01f, -1.46891221e-01f, -2.90008307e-01f, 9.18969512e-03f, 4.74520028e-01f,
  -5.04378617e-01f, -6.42490506e-01f, 6.07250221e-02f, 3.11875761e-01f, -3.17773163e-01f, 3.98080885e-01f, -4.69565272e-01f, 1.76520690e-01f, -4.49845135e-01f, -3.07475328e-01f,
  -4.80047852e-01f, -4.90718067e-01f, 3.78374904e-01f, 5.06023347e-01f, 1.63958639e-01f, 1.12049237e-01f, 8.32864344e-02f, -1.62351012e-01f, 1.36758134e-01f, 2.05741003e-02f,
  7.44582266e-02f, -1.54775590e-01f, -2.58876920e-01f, 9.34042260e-02f, -1.28692821e-01f, 1.55281588e-01f, -2.28285775e-01f, -1.20212644e-01f, 4.86504793e-01f, 1.93602413e-01f,
  2.16756448e-01f, -3.50694597e-01f, -2.69779652e-01f, 2.10986435e-01f, -6.98092282e-01f, 1.13506645e-01f, -3.79807025e-01f, 1.55338362e-01f, 4.20116425e-01f, 1.98773474e-01f,
  -4.74542588e-01f, -4.23015773e-01f, 5.99519908e-01f, -3.77367318e-01f, 1.99268475e-01f, 2.34452635e-01f, 6.12136312e-02f, -8.53314549e-02f, 1.25959760e-03f, -2.78404094e-02f,
  2.40391389e-01f, 8.99698883e-02f, 3.96656990e-02f, -3.64139587e-01f, -6.42402694e-02f, -3.35716784e-01f, 2.67993152e-01f, 1.16506137e-01f, 1.03179552e-01f, 2.71117121e-01f,
  1.55828848e-01f, 4.25220758e-01f, -1.58744216e-01f, 2.11734489e-01f, 2.62646943e-01f, 1.88167647e-01f, -3.23546171e-01f, -4.10722196e-01f, -3.60663414e-01f, -9.72801000e-02f,
  2.55387425e-01f, -6.28064930e-01f, -3.40788126e-01f, 4.82263237e-01f, -6.73729002e-01f, 2.46277943e-01f, -9.84469429e-03f, -5.42251766e-01f, -6.81027398e-02f, 3.53378872e-03f,
  -7.57868588e-02f, 1.05792500e-01f, 3.06384210e-02f, 7.54097328e-02f, 1.47839755e-01f, 3.12877595e-01f, 2.45782822e-01f, -3.85353357e-01f, 5.02679609e-02f, -3.29651386e-01f,
  -2.86819905e-01f, -3.95640314e-01f, 3.80181789e-01f, 1.92426920e-01f, 9.54946205e-02f, -4.29677695e-01f, 3.17926824e-01f, 5.53516626e-01f, -3.39654647e-02f, -3.32263619e-01f,
  -9.90696326e-02f, -3.63840163e-01f, -4.38423008e-01f, 3.79890710e-01f, 1.06324196e-01f, 8.99187773e-02f, -4.70180064e-02f, -2.40305573e-01f, -7.60494292e-01f, -1.49948567e-01f,
  -3.06977835e-02f, -1.84345003e-02f, 2.16864541e-01f, 3.31507385e-01f, -4.53244746e-01f, -2.87838280e-01f, 1.44514680e-01f, 1.96876630e-01f, 1.97659999e-01f, 4.87846792e-01f,
  5.06428719e-01f, -6.39908239e-02f, 1.62375674e-01f, -2.41256639e-01f, -2.00824544e-01f, -3.12500417e-01f, -4.38730232e-02f, -1.73484802e-01f, 2.05173358e-01f, -1.06578268e-01f,
  2.08472639e-01f, -1.96283311e-01f, -3.81249368e-01f, 1.48528770e-01f, -3.01339179e-01f, 2.12474763e-01f, 3.00870061e-01f, -7.07758367e-01f, -4.60805088e-01f, 3.91379386e-01f,
  -2.13807914e-02f, -2.20092744e-01f, 2.39010364e-01f, 1.30106226e-01f, -9.09974501e-02f, -5.48358858e-02f, 1.32255657e-02f, -2.43806899e-01f, -3.31838876e-01f, -2.06495896e-02f,
  -5.11938557e-02f, 1.66621849e-01f, 1.81322932e-01f, -1.76824406e-01f, -3.13680053e-01f, -5.14482781e-02f, -2.99775988e-01f, 2.19368160e-01f, 2.41331160e-01f, -1.29820541e-01f,
  -2.84890532e-01f, -3.81089449e-01f, 1.78263754e-01f, -7.32359350e-01f, 2.23322749e-01f, 2.64402002e-01f, 3.20028737e-02f, -8.46904591e-02f, 2.25326613e-01f, -6.46638989e-01f,
  7.96682760e-02f, -5.22903562e-01f, 4.73009795e-01f, 4.32660550e-01f, 3.52405198e-02f, 1.12526212e-03f, -1.61519945e-01f, -5.56561425e-02f, -1.23019442e-01f, 1.56572480e-02f,
  -4.67930511e-02f, -9.66397747e-02f, -2.08042040e-01f, 1.92318529e-01f, -7.23724589e-02f, -3.27541173e-01f, 2.88621455e-01f, 1.28893733e-01f, 3.68867964e-01f, 3.02709758e-01f,
  -1.29049122e-01f, 1.22175194e-01f, -6.32665008e-02f, 1.58198372e-01f, 4.90220577e-01f, -2.12827638e-01f, 4.12338853e-01f, -2.91086644e-01f, -6.96846247e-01f, -5.87579846e-01f,
  9.17683393e-02f, -1.35681510e-01f, -5.17147660e-01f, 4.33776081e-01f, -3.57744843e-01f, -2.65264809e-01f, 2.02552855e-01f, 1.80935174e-01f, -3.27324092e-01f, 1.46815151e-01f,
  -1.21802509e-01f, -2.35375911e-01f, -1.36668354e-01f, 7.35472813e-02f, 1.24023385e-01f, -8.14741105e-02f, -1.86199397e-01f, 2.99105525e-01f, 2.49385089e-01f, 2.23784775e-01f,
  -2.30717227e-01f, 3.15036505e-01f, -2.19475895e-01f, -2.41610631e-01f, -3.47665668e-01f, 3.61513942e-01f, -2.48792410e-01f, 2.56742805e-01f, -3.00247192e-01f, 2.21697718e-01f,
  1.62800997e-01f, -5.59774995e-01f, -2.67734528e-01f, -5.18262804e-01f, -2.34185666e-01f, 6.13452494e-01f, -3.40830415e-01f, 2.52982199e-01f, -3.21228690e-02f, -1.52926475e-01f,
  -2.39088044e-01f, -3.58693391e-01f, 1.66409925e-01f, 1.61769629e-01f, -2.26319432e-01f, -4.47546244e-01f, -2.23305617e-02f, -2.99020708e-01f, -1.17459886e-01f, -1.01523057e-01f,
  -1.07358336e-01f, 3.99105586e-02f, 1.74706087e-01f, -3.80944192e-01f, 2.11573422e-01f, -8.40624571e-02f, 1.96945384e-01f, -5.32566965e-01f, -1.01121468e-03f, -3.42210829e-01f,
  -1.79250568e-01f, -1.49799004e-01f, -4.02068645e-01f, 3.88820380e-01f, 2.23596364e-01f, -1.15914434e-01f, 3.76940548e-01f, -6.98805988e-01f, 1.40911520e-01f, -7.34834015e-01f,
  1.08845010e-01f, 1.61421284e-01f, -1.12531424e-01f, 1.71931401e-01f, -7.42942244e-02f, 1.11513384e-01f, 1.18292324e-01f, 2.13992938e-01f, 2.78692275e-01f, -2.28147104e-01f,
  -3.16644609e-01f, 4.04377460e-01f, -4.20932263e-01f, 3.79670233e-01f, -1.25703201e-01f, -4.88427252e-01f, -3.64192635e-01f, 3.50369275e-01f, -2.12770820e-01f, -1.97409064e-01f,
  -4.53907877e-01f, 4.83910173e-01f, 1.44104257e-01f, -5.07296085e-01f, 3.39531660e-01f, -4.90350991e-01f, -2.15567052e-01f, 4.55878228e-01f, 1.07543379e-01f, -4.45383281e-01f,
  -5.52313685e-01f, 5.28785884e-01f, -4.27854806e-02f, -1.39458641e-01f, -1.20680973e-01f, -1.72421679e-01f, -1.01422958e-01f, 7.61945397e-02f, -3.59230377e-02f, 1.29365265e-01f,
  -1.73555180e-01f, -2.85460740e-01f, 6.18553050e-02f, 3.47073525e-01f, -1.68106779e-01f, -4.02326047e-01f, 1.70444757e-01f, -1.17774002e-01f, -1.29638538e-01f, -3.71121079e-01f,
  -1.12624474e-01f, 1.57413512e-01f, -3.18450890e-02f, -4.65020686e-01f, 4.06604379e-01f, -7.10543036e-01f, 5.23607135e-01f, -3.74713838e-01f, 9.78924409e-02f, -1.24993496e-01f,
  3.03905338e-01f, 8.29652846e-02f, 1.54477194e-01f, -6.55537695e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  9.59090590e-02f, 1.87336043e-01f, -5.78374378e-02f, 9.33451205e-02f, -4.36210539e-03f, -1.18115090e-01f, -4.01418693e-02f, 4.73229997e-02f, 7.60651082e-02f, -3.99619788e-02f,
  2.11424366e-01f, 2.28329338e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    