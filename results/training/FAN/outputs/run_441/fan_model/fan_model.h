/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.84571910e-01f, -2.62002051e-01f, 3.15065235e-01f, -4.30678576e-01f, 3.28354180e-01f, 3.20570916e-01f, 2.77049929e-01f, -5.65116107e-02f, 1.19392551e-01f, -3.55860561e-01f,
  7.31837675e-02f, 1.57979131e-02f, 2.33691316e-02f, -2.32096195e-01f, 3.51485163e-01f, -2.91219890e-01f, -1.25885382e-01f, -1.61931336e-01f, 3.07375714e-02f, -4.17278521e-03f,
  8.37030113e-02f, -2.22453639e-01f, -4.56399731e-02f, 7.38801295e-03f, 2.43023574e-01f, 7.32323946e-03f, -2.55649805e-01f, -2.13615509e-04f, 1.34760933e-02f, 2.46570483e-02f,
  8.75217542e-02f, -1.23627402e-01f, 8.69721249e-02f, -4.76728519e-03f, -2.75544636e-02f, 2.77036335e-02f, -1.37280496e-02f, 5.86064905e-02f, 1.27793342e-01f, 9.82574001e-03f,
  1.50377490e-02f, 2.37036776e-02f, 7.93514121e-03f, -1.08120199e-02f, 1.07304573e-01f, 4.56492826e-02f, 6.90232664e-02f, 5.53348139e-02f, -1.09887123e-02f, 2.72295158e-02f,
  2.48046760e-02f, -4.00344329e-03f, -5.27980216e-02f, -8.11467767e-02f, 4.07056957e-02f, -1.79569535e-02f, -4.25546095e-02f, 6.67190328e-02f, -4.57340330e-02f, -5.91659695e-02f,
  -3.91921178e-02f, 2.05538161e-02f, -5.89047279e-03f, 2.74298117e-02f, -8.27738270e-03f, 4.03375328e-02f, -1.97637398e-02f, 1.33815082e-03f, 3.87505889e-02f, 4.21951860e-02f,
  2.15235781e-02f, -5.79300616e-03f, -1.05536589e-02f, 9.73842666e-02f, -4.38138098e-02f, -9.97932404e-02f, 7.09136724e-02f, 5.18273786e-02f, 1.25792855e-02f, 1.13151081e-01f,
  2.25618156e-03f, 3.24304476e-02f, -1.52741047e-02f, 3.32570784e-02f, -7.41368085e-02f, 2.86381207e-02f, -8.25510547e-02f, 3.74667309e-02f, -1.14696054e-02f, 5.13976552e-02f,
  -2.94586211e-01f, -4.27803844e-01f, -7.72830099e-02f, -8.97345021e-02f, -3.12938131e-02f, -7.46528013e-03f, 1.50533458e-02f, 3.57047990e-02f, -1.01998076e-01f, -2.04849001e-02f,
  -7.39483908e-03f, -1.62086431e-02f, -1.93321370e-02f, 2.52085552e-02f, -4.13466990e-02f, -9.12164710e-03f, -6.94636926e-02f, -3.93951759e-02f, -4.32370827e-02f, -6.86251819e-02f,
  -3.97194624e-02f, 1.32718487e-02f, 2.00001784e-02f, 3.14463302e-02f, -4.97141667e-02f, -1.75197423e-02f, 1.12242308e-02f, -5.19749634e-02f, -6.14701887e-04f, 2.11582199e-04f,
  9.13364768e-01f, 1.73402041e-01f, -7.50674382e-02f, 4.15131629e-01f, 5.51875830e-02f, 5.08289337e-01f, 2.08197851e-02f, 3.30677062e-01f, 3.35668296e-01f, 5.79250157e-02f,
  1.87991381e-01f, -1.00872539e-01f, -8.86928663e-02f, 3.87802511e-01f, 2.13257223e-01f, 4.10539517e-03f, 4.37102199e-01f, 9.52282771e-02f, 8.19363743e-02f, 2.33307809e-01f,
  7.38148689e-02f, 2.97529429e-01f, 1.20169155e-01f, 8.74083638e-02f, 5.32406420e-02f, -2.61959974e-02f, 6.24571145e-02f, -1.81971148e-01f, 9.13471580e-02f, -6.16237484e-02f,
  -8.12874734e-02f, -1.55573681e-01f, -1.70502961e-02f, 5.92665561e-02f, 1.37667149e-01f, -6.05536923e-02f, -9.89010110e-02f, -1.66151345e-01f, -6.31864741e-02f, 3.43748219e-02f,
  -6.60212487e-02f, 1.12082036e-02f, 9.89021547e-03f, -3.53845209e-02f, 7.73704574e-02f, 1.26614980e-02f, 3.07353344e-02f, 1.00118350e-02f, -1.43134808e-02f, 6.10308535e-02f,
  -1.24403210e-02f, 1.98017452e-02f, 1.06982343e-01f, -1.21765658e-02f, -1.23921512e-02f, 1.32045569e-02f, -4.41404916e-02f, -9.28610116e-02f, -3.21043050e-03f, 8.87946263e-02f,
  1.07266165e-01f, -1.07158702e-02f, 1.75843202e-02f, -2.03330279e-03f, 1.77373085e-02f, -8.61226395e-02f, 8.78565386e-03f, -8.44497085e-02f, -1.37869921e-03f, -6.21879240e-03f,
  5.57692535e-02f, -3.38463634e-02f, 8.71603712e-02f, 2.94298474e-02f, 8.23853314e-02f, 2.89630741e-02f, 1.57296322e-02f, -5.92127964e-02f, 4.81245443e-02f, -3.92012894e-02f,
  -9.36949551e-02f, 2.26120353e-02f, -1.83027834e-02f, -2.09527090e-02f, -9.45954956e-03f, -1.96095053e-02f, 1.01762479e-02f, 4.71379571e-02f, -5.92635619e-03f, 2.68642860e-03f,
  1.19183697e-01f, 3.32997322e-01f, 1.74089875e-02f, -8.94945487e-02f, -1.13644771e-01f, 9.05622840e-02f, 2.98965219e-02f, 9.26079005e-02f, 9.64046828e-03f, 8.49053115e-02f,
  1.11609779e-01f, 2.69082971e-02f, 4.82701883e-02f, -3.55593972e-02f, -6.15194179e-02f, 8.09953213e-02f, -4.07060198e-02f, -5.52609302e-02f, 1.54093150e-02f, 9.01194289e-02f,
  1.05369906e-03f, -2.34587546e-02f, -4.54394147e-02f, 1.13443956e-02f, 5.17747225e-03f, 4.33225706e-02f, 5.51142506e-02f, -5.42331161e-03f, -5.71516231e-02f, -3.42335403e-02f,
  1.45717531e-01f, -1.65353402e-01f, 4.05674398e-01f, 6.32104397e-01f, -2.43268207e-01f, -6.84228003e-01f, 6.37809783e-02f, -3.37619372e-02f, 2.65656233e-01f, -1.81936979e-01f,
  -5.65681532e-02f, 2.75266245e-02f, 9.39574018e-02f, -1.42330796e-01f, -1.32760450e-01f, 1.85030371e-01f, 8.71755034e-02f, -3.03733684e-02f, 9.46977064e-02f, -5.73177114e-02f,
  2.29279950e-01f, -3.19987804e-01f, 3.52087319e-01f, -3.10482770e-01f, -1.85620282e-02f, 2.31227413e-01f, 1.74612924e-02f, -6.69983998e-02f, -1.26539260e-01f, -6.94291890e-02f,
  -2.05267787e-01f, 2.84681439e-01f, 7.40384683e-02f, 2.41317786e-02f, -2.20623836e-02f, -3.06524541e-02f, -6.70832768e-02f, 4.89104316e-02f, 7.53316954e-02f, 1.32260974e-02f,
  -8.53028521e-02f, -8.37876797e-02f, -1.07831638e-02f, -6.87080175e-02f, -1.65839829e-02f, 9.17673782e-02f, 8.21466669e-02f, 7.61859566e-02f, 6.82801232e-02f, -1.86297169e-03f,
  7.06081092e-02f, 1.72855780e-02f, 5.51398844e-02f, -4.30714786e-02f, 8.64847675e-02f, -2.72954199e-02f, 5.33183180e-02f, -9.02424380e-02f, -2.84057949e-02f, -4.09109481e-02f,
  1.06564000e-01f, 2.47335359e-02f, 1.77017357e-02f, -2.84916777e-02f, 3.92341614e-02f, 3.08917016e-02f, -2.01651622e-02f, -6.08803555e-02f, -1.38304206e-02f, -4.23488691e-02f,
  2.08328161e-02f, 1.91552378e-02f, 3.71479839e-02f, 3.08178775e-02f, -6.97909668e-02f, 2.42409166e-02f, 3.88108715e-02f, -7.05445707e-02f, 4.07271609e-02f, -1.28721129e-02f,
  -1.38674667e-02f, -5.94523922e-02f, -2.18367837e-02f, 1.20675387e-02f, 5.13864215e-03f, -2.66855918e-02f, 9.36422264e-04f, -1.54714119e-02f, -7.99747370e-03f, -1.45393163e-02f,
  -3.73795867e-01f, -3.99598956e-01f, 3.64322588e-02f, -8.94017518e-02f, 4.38233986e-02f, -4.90987860e-02f, 3.33795585e-02f, -3.58101614e-02f, -9.40750074e-03f, -7.99668655e-02f,
  2.44158991e-02f, 1.23195015e-01f, -2.86075682e-03f, 2.63959412e-02f, -8.55069384e-02f, -1.03219301e-01f, -1.77909601e-02f, -4.54787947e-02f, -9.56454203e-02f, -8.88976008e-02f,
  -5.20746373e-02f, 2.03983057e-02f, 2.97254436e-02f, 3.68131958e-02f, -5.45646586e-02f, 5.28963171e-02f, -9.08069387e-02f, 6.22333065e-02f, -6.96339607e-02f, -1.73279122e-02f,
  -7.26742685e-01f, -3.91540319e-01f, 2.70073175e-01f, -2.64738172e-01f, -3.06015134e-01f, 4.36526872e-02f, -4.35706675e-02f, -2.44266301e-01f, -4.07248527e-01f, -1.76477820e-01f,
  -2.85242319e-01f, -1.04349755e-01f, 5.64931631e-02f, -5.04845306e-02f, 4.71754193e-01f, 1.43234566e-01f, 7.24133924e-02f, -7.56502897e-02f, -1.17378294e-01f, -5.90051524e-02f,
  5.34110554e-02f, -1.27113491e-01f, 4.13215697e-01f, 4.41933833e-02f, -1.57509565e-01f, -7.11145401e-02f, 2.82610387e-01f, 7.17152134e-02f, 3.06473672e-01f, -1.36259664e-02f,
  9.74206850e-02f, -3.07138532e-01f, -8.34542289e-02f, 1.64912343e-01f, -4.56031486e-02f, 7.78286010e-02f, 1.25440195e-01f, 3.90324779e-02f, 1.71411186e-02f, 4.89572175e-02f,
  2.78948881e-02f, -2.69200876e-02f, -8.53602365e-02f, 5.77568039e-02f, -1.00047067e-01f, -2.66770786e-03f, -3.20714749e-02f, -7.72142410e-02f, -1.82313286e-02f, -2.27901414e-02f,
  -3.99501361e-02f, -3.30174267e-02f, 2.19177008e-02f, 5.26402555e-02f, 6.03402108e-02f, -6.63429871e-02f, 1.07945196e-01f, 7.44741932e-02f, 3.97719331e-02f, -2.04176769e-01f,
  -7.55743012e-02f, 1.13520458e-01f, 7.74216726e-02f, -6.58312812e-02f, -6.37627691e-02f, -4.89533804e-02f, 1.03977010e-01f, 4.65934239e-02f, -4.07462195e-02f, 1.49176398e-03f,
  -5.91708496e-02f, 4.54370715e-02f, -5.09820357e-02f, 1.66194998e-02f, 5.47085144e-03f, -1.18216895e-01f, 4.52816822e-02f, -9.64663364e-03f, -6.30752519e-02f, 1.03854639e-02f,
  -8.66879150e-03f, 3.64128500e-02f, 3.03759538e-02f, 6.89080060e-02f, 5.87455146e-02f, 3.82751748e-02f, -2.79378524e-04f, 2.04161685e-02f, 1.01059295e-01f, 9.63638574e-02f,
  -7.48199597e-02f, -3.91235463e-02f, 6.04410544e-02f, -5.78579009e-02f, 5.83588853e-02f, -3.14087910e-03f, -5.31908646e-02f, -1.82914566e-02f, 4.54544574e-02f, 2.23345347e-02f,
  -8.93579721e-02f, 2.76113804e-02f, 2.73942556e-02f, -6.07756972e-02f, 1.71216995e-01f, -2.30393894e-02f, 1.01769067e-01f, 9.80703980e-02f, 6.60695732e-02f, 1.51887834e-02f,
  9.21994075e-02f, 2.24902518e-02f, 2.03299914e-02f, 6.28848076e-02f, 1.81134157e-02f, -6.81110546e-02f, -1.02569818e-01f, -1.00168392e-01f, 3.39942388e-02f, 6.65825978e-02f,
  -2.49243096e-01f, 2.98780382e-01f, -1.26836836e-01f, -1.22207813e-01f, 6.62332550e-02f, 2.25837708e-01f, 8.88200626e-02f, 1.92641005e-01f, 1.35655969e-01f, 1.53525978e-01f,
  1.78560778e-01f, -2.17986569e-01f, 3.28750998e-01f, -1.78544179e-01f, -5.60793519e-01f, 2.13921890e-01f, -2.64168888e-01f, 2.74612326e-02f, 1.15832090e-01f, -4.54035252e-02f,
  -9.84910876e-02f, -3.19781572e-01f, -1.95211932e-01f, 5.18923178e-02f, -4.16681394e-02f, 1.83959857e-01f, -3.23614776e-01f, 1.28477782e-01f, -2.39511818e-01f, -7.68383667e-02f,
  7.38880411e-02f, 1.59357950e-01f, 1.90179497e-02f, 5.15586361e-02f, 2.33966764e-02f, 6.88322783e-02f, -3.47454697e-02f, 1.05733639e-02f, -2.15582326e-02f, 1.91013992e-01f,
  8.70238058e-04f, -1.53966099e-01f, -1.03435554e-02f, -2.05181185e-02f, -6.12803875e-03f, -4.62610163e-02f, 2.14412138e-02f, 4.56798188e-02f, 3.26586259e-03f, 3.53687182e-02f,
  3.97179425e-02f, 5.13535440e-02f, -5.40637672e-02f, -9.14664641e-02f, -1.19904526e-01f, 4.86512519e-02f, 5.53690961e-06f, -5.55848032e-02f, 6.90696165e-02f, -4.61970791e-02f,
  -1.25317350e-02f, 7.85217062e-02f, 5.59233828e-03f, 2.12237798e-02f, 3.50706168e-02f, 1.01228163e-01f, -1.43799447e-02f, -4.41525318e-02f, -6.61788881e-02f, -1.40925590e-02f,
  -3.37337181e-02f, 5.45498542e-03f, 4.33817953e-02f, 5.11894375e-02f, -1.99706182e-02f, 1.14294840e-02f, -2.95215882e-02f, 1.22713596e-01f, 2.88416655e-03f, -1.83709655e-02f,
  3.39209437e-02f, -3.67376208e-02f, 2.95911841e-02f, -9.59696155e-03f, 6.51991665e-02f, -6.17621560e-03f, -2.11522952e-02f, 3.89905795e-02f, 5.72254844e-02f, -7.02711642e-02f,
  -2.14580260e-02f, -2.21847877e-01f, 6.52952418e-02f, -8.48002583e-02f, -7.17584649e-03f, -4.30847108e-02f, -1.03356829e-02f, -2.26372527e-03f, -3.55047435e-02f, -5.06566279e-02f,
  -4.44655791e-02f, 7.85199478e-02f, -6.13253377e-02f, 1.87180180e-03f, -3.52437538e-03f, 5.15342765e-02f, -1.37987500e-02f, -1.00207582e-01f, -1.21418022e-01f, 8.74983426e-03f,
  -9.29076150e-02f, -3.02448850e-02f, -1.69890542e-02f, 1.03623681e-01f, -1.49138104e-02f, -6.05817027e-02f, 2.04332173e-02f, 5.25831617e-02f, -4.45814095e-02f, -4.36627567e-02f,
  1.18475664e+00f, 9.40781459e-02f, 1.92554265e-01f, 2.98509508e-01f, 1.05339058e-01f, -2.29475126e-01f, 1.08107202e-01f, -3.34401615e-02f, 2.73106664e-01f, -3.46155286e-01f,
  2.99232248e-02f, 2.10008740e-01f, 1.31221995e-01f, -1.38237983e-01f, 4.23967987e-01f, 7.72594213e-02f, 1.20437823e-01f, 7.17064142e-02f, 4.89653163e-02f, 2.08990470e-01f,
  1.70147151e-01f, -2.08734974e-01f, 5.04508466e-02f, -3.34504366e-01f, -2.59418208e-02f, 5.78875765e-02f, -7.06856176e-02f, -6.07435405e-02f, -1.14689320e-01f, -2.08877102e-02f,
  -5.50528392e-02f, 1.14627093e-01f, -1.07925460e-01f, -2.69667953e-02f, 5.83022013e-02f, -1.72993690e-02f, 3.24695408e-02f, -5.27052917e-02f, 1.20747536e-01f, -3.61127197e-03f,
  5.09618856e-02f, 5.43867983e-02f, -9.72076803e-02f, -1.14700748e-02f, -6.77900389e-02f, -4.62128855e-02f, -2.16935761e-02f, -6.70672804e-02f, 7.12863309e-03f, 1.82907451e-02f,
  -4.26408686e-02f, -1.23057542e-02f, 2.72823051e-02f, -3.94767476e-03f, 3.53133716e-02f, 1.06323306e-02f, -6.13058694e-02f, -1.98589265e-02f, 5.97832985e-02f, 4.61817253e-03f,
  6.98501319e-02f, 1.36250574e-02f, 1.88002270e-02f, -2.51145125e-03f, -9.82201542e-04f, -7.41232932e-02f, -3.70901003e-02f, -6.68163076e-02f, 1.14552341e-02f, 5.77449910e-02f,
  1.12871814e-03f, 3.55372913e-02f, -7.47151207e-03f, 1.64556336e-02f, 5.40306792e-03f, 2.96276156e-02f, -2.39376561e-03f, -3.58431078e-02f, -1.20770535e-03f, 6.58288673e-02f,
  1.96888149e-02f, 3.83758545e-02f, -1.27948653e-02f, 8.10692739e-03f, -7.81688839e-02f, 2.58182809e-02f, -4.20142151e-02f, -2.15563104e-02f, -9.39257257e-03f, 7.72466436e-02f,
  2.37782747e-01f, 2.51862288e-01f, -3.19531560e-02f, -5.04084229e-02f, -1.43333688e-01f, -3.76207568e-02f, -1.51094627e-02f, 5.08113988e-02f, -8.09626654e-02f, 1.86794251e-02f,
  -1.26198567e-02f, 6.14876719e-03f, 4.13239151e-02f, -3.46632041e-02f, 1.27809262e-02f, 9.61005501e-03f, 1.92564204e-02f, 1.82700937e-03f, 5.06269075e-02f, 3.04680262e-02f,
  4.10072356e-02f, 9.77734402e-02f, -7.34667778e-02f, -1.24919750e-02f, -5.01845777e-02f, -4.35899720e-02f, 1.29256889e-01f, -3.30980495e-02f, -3.13194729e-02f, -2.04109363e-02f,
  6.85494319e-02f, 1.45780474e-01f, 4.32838798e-01f, 6.86300844e-02f, -2.66008496e-01f, 2.05356359e-01f, 5.27780235e-01f, -1.99335203e-01f, 2.11003512e-01f, 5.69954328e-03f,
  3.84782739e-02f, 7.99954906e-02f, 2.76717752e-01f, -9.93384700e-03f, 3.96271646e-01f, 4.15803462e-01f, 8.87224898e-02f, 1.41404107e-01f, -3.32045592e-02f, -1.71137810e-01f,
  9.28910151e-02f, -2.32696265e-01f, 1.45775393e-01f, -1.36019543e-01f, -1.14348724e-01f, -8.43367428e-02f, -3.96704823e-01f, 2.36324683e-01f, -2.43015543e-01f, -5.45876585e-02f,
  1.85795799e-01f, -5.91508597e-02f, -3.52213755e-02f, -7.54974410e-03f, -6.33600801e-02f, -6.54150499e-03f, 4.19005565e-02f, 9.55237448e-02f, 6.20293766e-02f, 2.31794473e-02f,
  -5.67585230e-03f, -4.46326733e-02f, -1.27825364e-01f, -4.36999127e-02f, 9.57024377e-03f, 5.65817617e-02f, -1.70445014e-02f, -4.81374487e-02f, -5.23648039e-02f, 2.14327313e-02f,
  5.26446514e-02f, -1.25602726e-02f, -2.19897013e-02f, -3.21711190e-02f, 2.89517529e-02f, 7.23587275e-02f, -1.64664406e-02f, -4.01057452e-02f, 7.58724585e-02f, -1.20313399e-01f,
  -5.55360802e-02f, -3.53710018e-02f, 1.51915580e-03f, 3.81989032e-02f, 2.15087794e-02f, -6.21450320e-02f, 4.18892242e-02f, -7.89868534e-02f, 3.54205742e-02f, -1.05475383e-02f,
  -3.21450643e-02f, 1.92163698e-02f, -5.91923408e-02f, 2.79080048e-02f, 3.01415101e-02f, -1.75112799e-01f, 1.61679581e-01f, -1.35844573e-01f, -1.67561863e-02f, -2.27167252e-02f,
  9.28309262e-02f, -7.12686824e-03f, 6.58507599e-03f, -1.79080516e-02f, 7.53496662e-02f, 2.08612997e-02f, -1.16177931e-01f, -4.98502553e-02f, 8.93601477e-02f, 1.86711829e-02f,
  5.60550801e-02f, -8.88197273e-02f, 3.66836786e-02f, 1.09335668e-02f, 3.20691876e-02f, -2.98744696e-03f, 1.50052443e-01f, -1.71149120e-01f, 6.24014586e-02f, -1.25361942e-02f,
  -1.51469782e-01f, -3.56227644e-02f, -1.51113123e-01f, -2.59372424e-02f, 5.75785786e-02f, 4.37340327e-02f, 2.78844535e-02f, -1.74284875e-02f, -1.16762677e-02f, -1.11889228e-01f,
  -9.80480611e-02f, -2.53431797e-02f, -6.00206926e-02f, -7.02962726e-02f, -2.74377759e-03f, -9.72774997e-02f, -1.43658062e-02f, 3.54936086e-02f, -5.35167381e-02f, 1.16763473e-01f,
  3.20357591e-01f, -1.87565938e-01f, -1.08985603e-01f, 8.78405944e-02f, -2.79898286e-01f, 1.21811427e-01f, 3.02886605e-01f, -1.53976887e-01f, 2.61633098e-01f, -2.48846449e-02f,
  2.13325500e-01f, -1.26031533e-01f, 3.46966475e-01f, -9.43801850e-02f, 3.62422258e-01f, 3.21320057e-01f, 8.98512527e-02f, 6.33041263e-02f, -1.04963511e-01f, -7.74266571e-02f,
  -2.63557713e-02f, 2.31297374e-01f, 5.73498942e-02f, -2.94370592e-01f, -1.41193390e-01f, -7.38086328e-02f, 3.15086007e-01f, -8.56389329e-02f, -2.20452368e-01f, 2.09223405e-02f,
  -2.21721739e-01f, -2.33227789e-01f, -1.58162221e-01f, -4.68850769e-02f, 6.03639036e-02f, -1.12312557e-02f, 1.59176849e-02f, 3.28263938e-02f, 7.34484419e-02f, -2.74750683e-02f,
  2.51096189e-02f, -1.30184308e-01f, -2.82679778e-02f, 3.55074815e-02f, -1.00705750e-01f, -2.74955332e-01f, -5.81443943e-02f, 9.82163548e-02f, -1.59664929e-01f, -5.39168529e-02f,
  -3.24944928e-02f, -1.27106637e-01f, 7.50119537e-02f, 6.78053200e-02f, -3.74530591e-02f, -1.17908053e-01f, 1.18337488e-02f, -6.11985009e-03f, 1.28918635e-02f, -1.03054687e-01f,
  8.94002020e-02f, 6.13363720e-02f, -1.52066424e-02f, -3.70906591e-02f, 5.03997924e-03f, -1.38096854e-01f, 5.54420464e-02f, -1.02648139e-01f, 3.05274390e-02f, -6.11724183e-02f,
  7.29600266e-02f, -5.52414991e-02f, -3.78412916e-03f, 3.79009321e-02f, 1.14805460e-01f, 3.06336349e-03f, 8.94697756e-02f, 3.31960022e-02f, 2.00530495e-02f, -2.25647818e-02f,
  -3.93317230e-02f, 6.15364574e-02f, 4.92066294e-02f, 1.63887069e-02f, 4.63359850e-03f, 6.62932545e-02f, -1.04523130e-01f, -5.32160401e-02f, -6.39535636e-02f, 1.21583045e-01f,
  3.60788643e-01f, 5.21899760e-01f, 1.55691937e-01f, -3.86508405e-02f, -6.98610693e-02f, 2.83351615e-02f, -5.07506505e-02f, -1.14655392e-02f, 4.53297645e-02f, 6.48048744e-02f,
  -4.33085114e-02f, -2.37708143e-03f, 6.66325167e-02f, -9.54355299e-03f, 2.87043881e-02f, 2.42235795e-01f, 8.43411684e-02f, -6.96993545e-02f, 1.10583432e-01f, 3.44814397e-02f,
  -4.04187776e-02f, 7.14167878e-02f, -7.26159737e-02f, -3.74909677e-02f, -1.20733827e-02f, 2.47683991e-02f, 1.26379400e-01f, -5.15249930e-02f, -1.39310677e-02f, -2.65843756e-02f,
  -6.08204424e-01f, 2.25791082e-01f, -1.75856844e-01f, -3.36853743e-01f, -1.10242531e-01f, -2.51673579e-01f, -6.85048476e-02f, -1.51407778e-01f, -1.80325389e-01f, 4.05945212e-01f,
  1.85535047e-02f, 8.63738433e-02f, 3.02979201e-01f, -1.54173255e-01f, -4.74211752e-01f, 2.52054036e-01f, -3.69501352e-01f, -9.12575051e-02f, 5.42897619e-02f, -6.40743747e-02f,
  -9.19810385e-02f, -9.83091742e-02f, -7.93163553e-02f, -5.38261123e-02f, -6.46539852e-02f, -1.25101551e-01f, -2.79063713e-02f, 1.49212619e-02f, -8.84288847e-02f, -1.45294387e-02f,
  1.00123147e-02f, 1.56338066e-01f, -7.86167979e-02f, 1.26867324e-01f, -3.96762565e-02f, -2.38187946e-02f, -5.91184534e-02f, 2.44307648e-02f, -6.79649338e-02f, 1.32852197e-01f,
  3.12473383e-02f, -3.71319652e-02f, -5.35101108e-02f, 5.95225859e-03f, -7.23413825e-02f, -2.38320474e-02f, -4.78365347e-02f, -1.10408980e-02f, 4.25708480e-02f, -3.20545621e-02f,
  2.21721996e-02f, -7.90969953e-02f, -6.24970607e-02f, 3.81580293e-02f, -3.12024094e-02f, 4.87478590e-03f, -2.73565459e-03f, 1.31483506e-02f, 2.39624437e-02f, -1.24306478e-01f,
  -6.28133491e-02f, 1.29107302e-02f, 2.89727449e-02f, 1.84762813e-02f, -6.22633733e-02f, -1.28906183e-02f, 1.04840193e-02f, 2.27642488e-02f, -1.69795379e-02f, -2.37138830e-02f,
  -2.29523368e-02f, -4.95062098e-02f, -6.49302527e-02f, -5.05943671e-02f, 7.95850344e-03f, -5.68728000e-02f, 5.01266420e-02f, 7.00405911e-02f, -8.06739032e-02f, -4.10779379e-02f,
  2.15051807e-02f, -2.23143231e-02f, 3.03600635e-02f, -8.83420650e-03f, 7.28240761e-04f, -4.37633917e-02f, -4.31520827e-02f, -3.71497236e-02f, 1.71648827e-03f, -4.13745530e-02f,
  -2.48183478e-02f, -1.54150166e-02f, 8.58391523e-02f, 5.49163222e-02f, 4.27416787e-02f, 1.73268523e-02f, -1.71697941e-02f, -8.40691850e-02f, -2.03612018e-02f, -6.79908618e-02f,
  3.86760384e-02f, 2.11677589e-02f, 3.81402038e-02f, 5.14607935e-04f, -3.71449888e-02f, -1.75080765e-02f, 7.36849084e-02f, -4.42951394e-04f, -9.56886858e-02f, -5.83120659e-02f,
  4.34819683e-02f, 8.12537670e-02f, -4.26758304e-02f, -2.63337735e-02f, -1.81598421e-02f, 3.91631946e-02f, -8.30985606e-02f, -4.37631318e-03f, -4.08164673e-02f, -2.58980028e-04f,
  -2.90063545e-02f, 6.89269185e-01f, 1.11751564e-01f, 4.68511790e-01f, -9.26651657e-02f, 3.39542143e-02f, 1.46016806e-01f, 3.04453045e-01f, 1.83657393e-01f, 2.80370861e-01f,
  5.01926690e-02f, 4.46997210e-02f, 2.38404527e-01f, 4.47957993e-01f, -3.02930266e-01f, 2.52690256e-01f, 9.46300551e-02f, 1.60991967e-01f, 5.13051637e-02f, 8.47119763e-02f,
  8.30667019e-02f, 9.14303213e-02f, 1.61075518e-01f, -8.59938413e-02f, 2.26126105e-01f, -7.93714821e-02f, -8.16440284e-02f, -1.59005031e-01f, -8.23442489e-02f, -4.80653644e-02f,
  -6.32867683e-03f, 1.96586475e-01f, 1.70476139e-01f, -7.27804527e-02f, -3.78471389e-02f, -8.38638544e-02f, -1.25282323e-02f, -4.21678200e-02f, -2.07729675e-02f, -4.94513884e-02f,
  3.81414816e-02f, 1.71757378e-02f, -1.37680303e-02f, 1.88559666e-02f, 6.84938058e-02f, -2.65552942e-02f, 1.29894406e-01f, 2.87442245e-02f, 2.08099246e-01f, 2.05003228e-02f,
  1.34700626e-01f, 5.80456220e-02f, 1.07588306e-01f, 1.46873221e-02f, 4.03676070e-02f, 1.26790419e-01f, 2.73590330e-02f, -6.18892070e-03f, -3.90019752e-02f, 6.78239986e-02f,
  -3.04969624e-02f, -1.10431843e-01f, 5.67874052e-02f, 1.68070253e-02f, -1.51621345e-02f, -6.53059408e-02f, 4.51044329e-02f, -8.15345496e-02f, -6.11231662e-02f, 5.12465611e-02f,
  -1.87958516e-02f, 8.84837750e-03f, 4.40387614e-03f, 3.21649574e-02f, -3.06513230e-03f, 1.10549172e-02f, -7.28241205e-02f, -2.64437404e-02f, -1.00651328e-02f, 1.25090207e-03f,
  8.82454962e-03f, 6.09213077e-02f, 5.28104641e-02f, -9.84048098e-03f, -5.34111857e-02f, 4.99086194e-02f, -4.83501516e-03f, 1.09119646e-01f, 4.12337761e-03f, -1.12086408e-01f,
  -1.12220816e-01f, -1.43133163e-01f, -7.91215971e-02f, 2.46834029e-02f, -3.45214717e-02f, 6.86126873e-02f, -2.30879318e-02f, -1.13003310e-02f, 3.80345546e-02f, -2.26629395e-02f,
  -3.10157873e-02f, -1.56875886e-02f, -7.68830404e-02f, -7.59920990e-03f, -5.67620099e-02f, 7.36917779e-02f, -8.01457390e-02f, 4.24250141e-02f, -1.75259784e-01f, 2.59011593e-02f,
  -9.51583609e-02f, -3.72028463e-02f, -8.58072266e-02f, -3.44195310e-03f, -8.03732872e-02f, -6.19328916e-02f, -2.10028440e-02f, -1.64870601e-02f, -2.24645771e-02f, -6.17141575e-02f,
  1.39436066e-01f, -3.67621295e-02f, -1.12612002e-01f, -4.07913812e-02f, -2.83813685e-01f, -4.74444717e-01f, 2.63580739e-01f, -2.12510884e-01f, -7.50928298e-02f, 3.08505427e-02f,
  -8.47303420e-02f, 2.07704261e-01f, 4.03595895e-01f, -1.52939647e-01f, 4.81117368e-02f, 3.50792974e-01f, -4.45553899e-01f, -2.44461279e-02f, 1.32018954e-01f, -5.50588444e-02f,
  -2.31553558e-02f, 3.19528095e-02f, -1.50043175e-01f, -1.39549121e-01f, -3.23222764e-02f, -1.18766859e-01f, 4.07594889e-02f, 1.57542080e-01f, -1.72476575e-01f, 1.17823314e-02f,
  -2.02255994e-01f, 3.14707905e-02f, -3.99165750e-02f, 8.19775835e-02f, -1.71348393e-01f, -7.13700149e-03f, -2.26080287e-02f, 1.36160076e-01f, -2.70737968e-02f, 1.73310898e-02f,
  6.77606836e-02f, 5.54294139e-02f, 4.24230769e-02f, 1.00740299e-01f, -2.65705772e-02f, 3.02665923e-02f, -2.16506645e-02f, -1.11977950e-01f, 2.91781500e-02f, 6.81468518e-03f,
  -1.06820799e-02f, 1.96005963e-02f, -1.77050829e-01f, 6.39951006e-02f, -2.32192799e-02f, 3.85924475e-03f, -8.36199615e-03f, -3.09197716e-02f, -6.46382943e-02f, -1.11554116e-01f,
  7.78949633e-02f, 2.66154017e-02f, 4.44496758e-02f, -6.42956514e-03f, 6.76443279e-02f, -2.78055314e-02f, 6.07938915e-02f, 7.79029876e-02f, 2.75479294e-02f, 2.54161935e-02f,
  -8.85648727e-02f, -1.84245761e-02f, 7.80758187e-02f, -4.76888008e-02f, -5.82992993e-02f, -6.68273643e-02f, -2.08901148e-03f, 1.81721553e-01f, -1.28982678e-01f, -1.31592415e-02f,
  1.03877582e-01f, -1.34398386e-01f, 8.54753330e-02f, 3.31184268e-02f, -3.29175033e-02f, -5.49041806e-03f, 1.21663019e-01f, 7.45335536e-04f, -4.84369956e-02f, -9.98358950e-02f,
  -6.35418743e-02f, 1.30542949e-01f, 2.08723713e-02f, 2.50545908e-02f, 4.53179814e-02f, -2.27713808e-02f, -4.56999987e-02f, -8.04652199e-02f, 6.78291917e-02f, 2.48148851e-02f,
  -5.41586019e-02f, -1.05585262e-01f, -1.72897309e-01f, -7.21413195e-02f, 3.08686253e-02f, -2.04830945e-01f, 8.93171877e-02f, 7.09836259e-02f, -6.78482428e-02f, 1.75181292e-02f,
  -2.07125433e-02f, 5.54553643e-02f, -6.61816224e-02f, -1.88182220e-01f, -9.06257927e-02f, 3.05292495e-02f, -7.62986243e-02f, -3.82880829e-02f, 6.57226667e-02f, 5.99012673e-02f,
  2.54380614e-01f, -4.72375929e-01f, -2.10375741e-01f, 7.11743683e-02f, 2.32783899e-01f, -5.86317599e-01f, -1.50254324e-01f, -1.81994087e-03f, 1.95367783e-01f, -1.19367063e-01f,
  -1.61134137e-03f, -1.99441612e-01f, -1.85605854e-01f, -3.61612260e-01f, -1.03298567e-01f, -2.81909704e-01f, -1.43674865e-01f, -1.45870015e-01f, 7.99992215e-03f, -3.66591616e-03f,
  6.55482337e-02f, -8.68308023e-02f, -2.33793080e-01f, 7.87995234e-02f, -4.19166125e-02f, 9.63538513e-02f, 2.99486548e-01f, 1.07037418e-01f, -7.46854469e-02f, -1.48462206e-01f,
  -1.48920834e-01f, -8.01918060e-02f, 2.77822036e-02f, -3.31243612e-02f, 1.18148117e-03f, 4.31693569e-02f, 2.28072908e-02f, 1.84083544e-02f, 4.37285379e-02f, -8.71465877e-02f,
  -3.22877727e-02f, 2.61575859e-02f, -4.17670235e-02f, -1.49798263e-02f, 6.24086224e-02f, -4.22161780e-02f, -7.69786537e-02f, -2.07414161e-02f, -4.98557389e-02f, -4.35405448e-02f,
  -2.13169064e-02f, -4.30803001e-02f, 1.04470149e-01f, -6.97678104e-02f, -5.05115502e-02f, -5.50432056e-02f, -7.29920482e-03f, -1.60294883e-02f, 6.97291782e-03f, 4.91817817e-02f,
  -7.40911765e-03f, 1.04115054e-01f, -1.31738270e-02f, 5.46114780e-02f, -4.57885349e-03f, 3.27103287e-02f, 9.49133839e-03f, -5.20722307e-02f, -6.72693737e-03f, 2.03146674e-02f,
  9.40586478e-02f, 3.23961414e-02f, -3.04921828e-02f, -1.41342636e-02f, 4.47544940e-02f, 2.16269642e-02f, 3.07691898e-02f, -2.69739181e-02f, 6.31689057e-02f, 2.64616385e-02f,
  1.08161541e-02f, 3.35557349e-02f, -1.36362128e-02f, 9.03431773e-02f, -3.52308713e-02f, 1.93874668e-02f, -6.25580736e-03f, -2.27498077e-02f, 2.12123841e-02f, -1.09681822e-02f,
  -4.17097881e-02f, 3.14113162e-02f, 6.00345840e-04f, -3.24182324e-02f, 1.93827264e-02f, 3.05996612e-02f, -3.24874595e-02f, -8.75652395e-03f, -8.03148523e-02f, 4.41496074e-02f,
  4.97157276e-02f, 7.20289722e-02f, 2.88386066e-02f, 3.36256879e-03f, 2.28588991e-02f, 5.31624295e-02f, 3.86059657e-02f, 8.23944509e-02f, -1.12284487e-02f, 1.00018993e-01f,
  8.05647969e-02f, 2.35413890e-02f, 6.99024368e-03f, 7.70418942e-02f, 3.49814966e-02f, -1.98644027e-02f, 1.93382297e-02f, 2.59048827e-02f, 4.99090329e-02f, -4.27895337e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.04044640e+00f, 8.02791893e-01f, 4.04012471e-01f, -6.31252646e-01f, 1.26727149e-01f, -3.82708579e-01f, -7.56171107e-01f, 6.75113499e-01f, -4.21890467e-01f, -2.91122291e-02f,
  9.50339995e-03f, -6.67793453e-01f, 5.47687531e-01f, -5.60664117e-01f, -6.47409633e-02f, 6.17146902e-02f, -3.89718175e-01f, -5.87635994e-01f, 2.55889326e-01f, 1.28881112e-01f,
  7.97617882e-02f, -2.23441422e-01f, 3.19603294e-01f, 7.56293416e-01f, 4.50853780e-02f, 2.57170111e-01f, 5.29119253e-01f, 4.55015808e-01f, 1.11744609e-02f, -1.21589094e-01f,
  -9.05985385e-02f, 2.31229946e-01f, 6.32842705e-02f, -6.24055341e-02f, 1.37555629e-01f, -1.02722563e-01f, -1.60191208e-01f, -1.20131977e-01f, -1.91525847e-01f, -8.85181800e-02f,
  -1.12172976e-01f, 6.62939399e-02f, -1.13142513e-01f, -4.74881977e-02f, -1.30328715e-01f, 2.90270336e-02f, 1.73610047e-01f, 2.89560519e-02f, 2.61829998e-02f, -7.02300444e-02f,
  7.00912103e-02f, 5.26714623e-02f, -1.54761765e-02f, -1.98980749e-01f, 1.39671117e-01f, -5.80116361e-03f, -1.79472178e-01f, -5.01557738e-02f, -3.46674793e-03f, -1.85036182e-01f,
  1.24533679e-02f, -8.66467431e-02f, -1.33004943e-02f, -4.43895198e-02f, -6.53141038e-03f, -4.83407862e-02f, -1.21163383e-01f, -6.30951598e-02f, 4.19282308e-03f, -5.02779633e-02f,
  2.55785771e-02f, -6.38579652e-02f, 4.72240821e-02f, -1.08914740e-01f, -1.82239171e-02f, -9.94418412e-02f, -8.69016536e-03f, 2.50280257e-02f, -8.14149082e-02f, -6.25393987e-02f,
  2.15166342e-02f, -9.49901044e-02f, 6.07374683e-02f, 1.68216340e-02f, -4.82830480e-02f, 1.21237271e-01f, 2.77447719e-02f, -2.43882891e-02f, 1.34416163e-01f, 9.22159255e-02f,
  1.93435416e-01f, 6.75792634e-01f, 1.32560745e-01f, -1.19884335e-01f, -5.14883548e-03f, 2.49457713e-02f, -9.99026094e-03f, 8.09029490e-03f, 7.14907050e-02f, 7.39900693e-02f,
  8.24303254e-02f, -1.44081891e-01f, -3.84937786e-02f, -1.11279950e-01f, 5.18088834e-03f, 8.71689543e-02f, -1.25961617e-01f, -1.50097817e-01f, 6.51967674e-02f, 1.79748908e-01f,
  1.79647934e-02f, -4.14628796e-02f, -1.19222127e-01f, -1.42176561e-02f, -9.40013975e-02f, -4.39660847e-02f, 6.43879026e-02f, -2.55082417e-02f, 5.89416642e-03f, 3.80394608e-02f,
  -1.44464934e+00f, 2.35851750e-01f, -7.05776453e-01f, -4.20094699e-01f, -6.30589604e-01f, -7.16338038e-01f, -4.33697581e-01f, -2.03398824e-01f, 1.46728814e-01f, 4.19543058e-01f,
  1.44134954e-01f, 1.36227012e-01f, 7.67823339e-01f, 1.24231987e-01f, -4.24252570e-01f, 8.01582932e-01f, -3.39450270e-01f, -2.62185447e-02f, 8.31563473e-02f, -5.16501427e-01f,
  -4.52727258e-01f, 2.51396839e-02f, -1.02501102e-01f, -9.46845114e-02f, -8.58034015e-01f, -4.08506811e-01f, -1.38569385e-01f, -1.48033157e-01f, -4.37022299e-01f, -1.21941052e-01f,
  -1.05348861e+00f, -3.96601290e-01f, -1.80792317e-01f, -2.18849704e-01f, -4.76044387e-01f, -1.49253771e-01f, -3.15514326e-01f, 2.72704698e-02f, -6.11593649e-02f, -1.96304217e-01f,
  -2.79786158e-02f, 3.40915322e-02f, 6.80657551e-02f, 1.37284502e-01f, -2.02006340e-01f, -1.36411682e-01f, -5.43995686e-02f, -2.15157479e-01f, 7.41788149e-02f, -2.17607971e-02f,
  4.76120971e-02f, -1.36928678e-01f, -1.72617748e-01f, 4.15091477e-02f, -3.17351371e-01f, -1.61813051e-01f, 9.98514052e-03f, -9.42384377e-02f, -2.05193430e-01f, -2.09676996e-01f,
  8.92080665e-02f, -4.25285921e-02f, 9.09466222e-02f, 1.43177792e-01f, 1.06782354e-02f, -6.00907505e-02f, -8.07136446e-02f, 1.36607066e-02f, 1.41269220e-02f, -7.99824670e-02f,
  -6.17015585e-02f, -4.90411371e-02f, -1.18731610e-01f, -6.21658154e-02f, -5.11309020e-02f, 1.32885218e-01f, 2.52666958e-02f, -1.56738207e-01f, 4.95598167e-02f, -1.28315449e-01f,
  2.92525347e-02f, -5.08145168e-02f, 7.72701353e-02f, 2.11244337e-02f, -1.89023525e-01f, 6.02738336e-02f, -1.09688669e-01f, -8.72882307e-02f, 4.49113809e-02f, -1.72468737e-01f,
  -1.10031283e+00f, -7.75524557e-01f, 1.36564195e-01f, -1.89798668e-01f, -4.23303992e-02f, -9.24485996e-02f, 1.24059275e-01f, -2.68825591e-01f, -2.94445544e-01f, -5.76354526e-02f,
  -4.77286056e-02f, 9.61553678e-02f, -3.47390711e-01f, 4.49661165e-02f, 9.56887975e-02f, 7.79140592e-02f, -4.23419811e-02f, -1.29082948e-01f, -2.45428711e-01f, -1.46839758e-02f,
  -3.24600339e-02f, 8.11959431e-02f, 1.29625529e-01f, 5.68730617e-03f, 4.19340916e-02f, -1.34482440e-02f, -9.93663669e-02f, 8.85613263e-02f, -3.51113796e-01f, 2.13691026e-01f,
  -3.41536909e-01f, 3.38920355e-01f, -6.86379313e-01f, -4.78584506e-02f, -1.96769148e-01f, 3.71484309e-01f, 4.03406858e-01f, -1.39239416e-01f, -2.82010257e-01f, 8.83109868e-01f,
  1.99438810e-01f, 1.21674024e-01f, -6.53618947e-02f, 4.71182078e-01f, -1.15895915e+00f, -4.29177552e-01f, 5.31554341e-01f, 4.66892689e-01f, -4.40924615e-01f, 3.76388043e-01f,
  -1.85739130e-01f, 3.65754873e-01f, -4.62286502e-01f, 1.92516595e-01f, 2.56679088e-01f, 1.29472867e-01f, 3.34426522e-01f, -2.96689510e-01f, 6.04023814e-01f, -2.24090010e-01f,
  5.12108207e-02f, -1.69748247e-01f, 1.89317986e-02f, -4.48214151e-02f, 2.39570633e-01f, 2.85691261e-01f, 2.82581389e-01f, -3.00881416e-01f, -2.19573602e-01f, -6.18129224e-02f,
  2.38798812e-01f, -6.54808730e-02f, -1.45952925e-02f, -3.12985569e-01f, 1.54006571e-01f, -7.29118139e-02f, -1.62613839e-01f, 7.95507059e-02f, 1.65523589e-02f, -6.23137690e-02f,
  -2.13973537e-01f, 3.11831627e-02f, 2.20675781e-01f, 4.77949828e-02f, -1.48080543e-01f, 1.89752914e-02f, 8.29221532e-02f, 6.11527339e-02f, 1.33828640e-01f, -3.54892761e-02f,
  2.44977418e-02f, 1.59729734e-01f, 4.61159013e-02f, -1.75462943e-02f, -1.11713797e-01f, 5.24250455e-02f, 8.68344009e-02f, -1.16968751e-02f, -4.40917052e-02f, 8.03341344e-02f,
  1.27802021e-04f, -1.74198467e-02f, 1.22442760e-01f, 7.32995272e-02f, 3.72425467e-02f, 2.12373789e-02f, 5.03520854e-02f, 7.96448737e-02f, -6.34708032e-02f, -2.10191220e-01f,
  1.76404938e-02f, -3.47926132e-02f, 1.57307200e-02f, 1.60029724e-01f, -6.69873357e-02f, -4.62388918e-02f, 1.75693884e-01f, 1.96474623e-02f, 2.14734972e-02f, -6.77649751e-02f,
  2.92121768e-01f, 2.82087713e-01f, -8.39316398e-02f, -2.45538075e-02f, 1.46115676e-01f, 1.29539624e-01f, -1.08979106e-01f, 2.55311858e-02f, -5.39651327e-03f, 1.44750765e-02f,
  2.50517160e-01f, 1.69436201e-01f, 2.49526903e-01f, 4.83681448e-02f, -2.33361915e-01f, 2.45011430e-02f, 1.39914617e-01f, 1.04703113e-01f, 2.22853079e-01f, 2.86038071e-02f,
  1.31866783e-01f, 1.47858009e-01f, -5.75732216e-02f, 2.22412404e-02f, 2.30288729e-01f, 3.98484319e-02f, 6.09656163e-02f, -1.22263528e-01f, 3.68267782e-02f, 2.49040779e-02f,
  4.28835630e-01f, 9.26828802e-01f, 5.95400929e-01f, 6.03702724e-01f, -3.05779248e-01f, -1.07673442e+00f, -9.07109022e-01f, 2.47343272e-01f, 9.59426016e-02f, 8.10423121e-02f,
  -3.15161616e-01f, 7.51130164e-01f, -4.38276380e-01f, 3.89700323e-01f, -1.17060518e+00f, -7.52709031e-01f, -2.77961463e-01f, -7.96956792e-02f, -1.06045976e-01f, 2.99402446e-01f,
  -7.05667511e-02f, -3.30371380e-01f, 1.87721029e-01f, 4.94745746e-02f, 4.62235183e-01f, 7.86447048e-01f, 1.09439604e-01f, 1.09238386e-01f, 5.17289102e-01f, -1.38082087e-01f,
  -2.02891514e-01f, 8.44304785e-02f, 2.55845279e-01f, 2.98096822e-03f, -1.68206885e-01f, -1.14291035e-01f, 3.19590010e-02f, -1.26640424e-01f, -6.03399128e-02f, 9.89361331e-02f,
  1.09219320e-01f, -9.66636557e-03f, 1.34759977e-01f, -5.48314564e-02f, 2.64171753e-02f, 1.26257762e-01f, 1.47809654e-01f, 6.86742589e-02f, 1.00092143e-01f, 1.36866689e-01f,
  1.95492834e-01f, 1.02194510e-01f, -2.03000102e-02f, 6.22536540e-02f, 1.29397735e-01f, 4.18289676e-02f, -1.26100212e-01f, 1.48163885e-01f, 8.41428060e-03f, -1.30581541e-03f,
  6.48868978e-02f, -2.34950319e-01f, 5.91603853e-02f, 2.79524103e-02f, -1.30124092e-01f, 2.09680591e-02f, -9.10018235e-02f, -1.19410157e-02f, 3.80309634e-02f, -7.73010254e-02f,
  -4.50822413e-02f, 1.63792133e-01f, -5.57789616e-02f, -9.86910760e-02f, 3.92185524e-02f, 1.02421880e-01f, -4.36932631e-02f, 4.13263068e-02f, -4.22343723e-02f, 1.25131607e-01f,
  -1.13197424e-01f, -8.10216591e-02f, 4.55453433e-02f, -1.80900022e-02f, -2.68706232e-01f, 4.30462174e-02f, 3.49707063e-03f, 8.98889229e-02f, 4.59613279e-02f, -8.95564780e-02f,
  -1.37964472e-01f, 1.14933327e-01f, 7.30470121e-02f, 1.05378449e-01f, 1.30432323e-01f, -1.30853862e-01f, -3.11980955e-04f, 1.71078935e-01f, 7.67360628e-02f, -1.48797497e-01f,
  1.55931311e-02f, -8.12996328e-02f, -4.29253355e-02f, 3.82894604e-03f, 2.71793697e-02f, -4.56201807e-02f, -9.59510580e-02f, -1.27371950e-02f, -3.02670524e-02f, 1.84515864e-01f,
  6.61881343e-02f, -2.02913344e-01f, -2.26386227e-02f, -5.66162616e-02f, 3.69063653e-02f, 7.93064013e-03f, -5.63232321e-03f, 6.33255988e-02f, -3.37928347e-02f, 1.29027171e-02f,
  6.57344759e-01f, -2.32188284e-01f, 7.41236567e-01f, -7.38219798e-01f, -1.91224322e-01f, 1.35457456e-01f, -3.99564683e-01f, -4.38117713e-01f, -3.80941898e-01f, -6.02068126e-01f,
  -5.08847654e-01f, 2.47682884e-01f, 1.57721162e-01f, -4.31047201e-01f, 4.84356254e-01f, 9.90171805e-02f, -4.21247363e-01f, -3.29768360e-01f, 2.43916307e-02f, -5.29520631e-01f,
  -4.50585820e-02f, -9.40785646e-01f, 3.48809391e-01f, -7.03048229e-01f, -7.35963807e-02f, -1.46096321e-02f, -2.10457847e-01f, 9.44453701e-02f, -2.45757252e-01f, 4.29990552e-02f,
  1.18949041e-01f, -1.47685573e-01f, 6.29617498e-05f, 1.56130940e-01f, 2.31405143e-02f, 8.00913200e-02f, 1.69731319e-01f, 5.08639254e-02f, -1.08220940e-03f, 3.69476303e-02f,
  9.81772542e-02f, 1.13234229e-01f, -2.36517012e-01f, -2.80292537e-02f, -2.95616314e-02f, -4.11075726e-03f, 1.71135366e-01f, 1.71735123e-01f, -1.94414016e-02f, 3.70706022e-01f,
  8.35872293e-02f, 2.59744108e-01f, 1.40983418e-01f, -7.72680044e-02f, 4.74485829e-02f, -4.09397520e-02f, 5.25390692e-02f, 1.97752178e-01f, 7.24731907e-02f, 1.59119982e-02f,
  -1.28059074e-01f, 8.98533612e-02f, 4.16446477e-02f, 1.34569153e-01f, -7.28476495e-02f, 9.74776316e-03f, -9.33374837e-02f, 6.50395602e-02f, 3.63944247e-02f, 5.56769781e-02f,
  -6.08791374e-02f, 3.21234018e-02f, -2.68343929e-02f, -1.06016412e-01f, 3.58587550e-03f, 5.78862913e-02f, 5.95809333e-02f, -5.70900925e-02f, -5.78898415e-02f, -1.13171451e-02f,
  -1.64873809e-01f, -7.88654536e-02f, -2.12996602e-02f, -5.52434437e-02f, -7.71238655e-02f, 9.77934897e-02f, -8.71118233e-02f, 2.34467611e-01f, 8.58129412e-02f, 2.19147429e-02f,
  -1.60519764e-01f, -6.08938158e-01f, -1.17003329e-01f, -1.55675873e-01f, -6.81640133e-02f, 4.82904688e-02f, -1.26840845e-01f, -1.13340758e-01f, -2.98586823e-02f, -5.25006726e-02f,
  -3.43492217e-02f, -9.12338942e-02f, 1.08304605e-01f, -2.81387642e-02f, -1.59217894e-01f, -5.15902750e-02f, -3.33497286e-01f, -1.78536668e-01f, -2.00477064e-01f, -1.81490891e-02f,
  -1.30173653e-01f, -1.68708742e-01f, 4.38255817e-03f, -1.95874438e-01f, -2.73325771e-01f, 4.01036255e-02f, 1.48244109e-03f, 4.14724872e-02f, -8.37553218e-02f, -1.20303519e-01f,
  4.49387372e-01f, -7.47162253e-02f, 8.21015760e-02f, 5.95762610e-01f, 2.45108426e-01f, -3.32671791e-01f, 2.09274366e-01f, 1.75677121e-01f, 1.47138464e+00f, -4.71256495e-01f,
  -5.65153360e-01f, 1.19040579e-01f, -3.87446254e-01f, -3.61476570e-01f, -3.27410936e-01f, -8.00735783e-03f, -1.56850651e-01f, 1.86993796e-02f, 7.02508509e-01f, -9.45495348e-03f,
  1.76611558e-01f, -4.80104834e-01f, -6.68312550e-01f, -3.58634382e-01f, -3.16438884e-01f, 2.09941611e-01f, -7.71557868e-01f, -1.73506141e-01f, -7.20850646e-01f, -1.80562422e-01f,
  3.58225666e-02f, 4.21035796e-01f, 1.25252865e-02f, 1.69308037e-01f, 8.67893141e-06f, -1.41338453e-01f, -1.25264406e-01f, -2.04551354e-01f, 1.69496641e-01f, 1.76744059e-01f,
  1.08964942e-01f, -1.56834647e-01f, 8.43646675e-02f, -6.48000911e-02f, 3.94003510e-01f, 7.42838234e-02f, 2.22103044e-01f, 8.87340307e-03f, 9.87697095e-02f, -1.12197220e-01f,
  7.82390833e-02f, 2.16153115e-02f, 1.22281842e-01f, 9.07084495e-02f, 1.31480366e-01f, 2.94508606e-01f, 3.46889049e-02f, -2.56909132e-01f, -3.82416360e-02f, 1.01179011e-01f,
  -2.52810448e-01f, 5.53409904e-02f, -5.68892155e-03f, 1.18239820e-02f, -9.70763192e-02f, 6.69593513e-02f, 4.48579825e-02f, -8.33323300e-02f, 1.90910652e-01f, -1.50206536e-01f,
  -2.54840478e-02f, 1.40123546e-01f, 2.45508641e-01f, 6.42359406e-02f, -2.57377177e-02f, 2.11977437e-01f, -1.75486162e-01f, -6.65640011e-02f, 6.34675920e-02f, -1.21013969e-01f,
  8.99335369e-02f, 2.72674691e-02f, -9.43173096e-02f, -8.79283473e-02f, 7.41334260e-02f, 1.27939777e-02f, -7.70564452e-02f, 5.93357012e-02f, 1.57823473e-01f, -1.79887578e-01f,
  -6.31755516e-02f, 5.48504889e-02f, 9.91088077e-02f, 2.11405247e-01f, -7.14524314e-02f, -1.20667018e-01f, 3.58484015e-02f, 3.09606362e-02f, 1.26521261e-02f, -9.37421843e-02f,
  -1.10609226e-01f, -1.42087014e-02f, -8.12729448e-02f, -2.94129923e-02f, -1.26621649e-01f, -1.51739135e-01f, -1.05170101e-01f, 2.19942331e-01f, -7.71613568e-02f, -1.28101140e-01f,
  -8.26816410e-02f, 1.04933619e-01f, 1.67163778e-02f, -4.62779216e-02f, -8.10202910e-04f, -8.63142014e-02f, 2.04370427e-03f, 1.18874215e-01f, -1.53748915e-01f, -1.24287523e-01f,
  5.79623044e-01f, 1.10263932e+00f, 2.84119785e-01f, -2.62210906e-01f, -4.91870075e-01f, 6.54966474e-01f, -2.69309103e-01f, 2.10531261e-02f, 2.81566739e-01f, 5.05784929e-01f,
  -4.49883193e-01f, 5.01171172e-01f, -2.73308605e-01f, 1.93781734e-01f, 2.94467986e-01f, 5.37421942e-01f, 4.09317315e-01f, 9.79871824e-02f, 1.20688789e-02f, 1.30469218e-01f,
  1.70934439e-01f, -1.64074257e-01f, -2.59310216e-01f, -1.13338619e-01f, -2.20357969e-01f, 9.29885879e-02f, -4.17403251e-01f, -3.33310992e-01f, 1.45245761e-01f, -2.25879904e-02f,
  -4.36764061e-02f, -3.43480855e-02f, 3.13519426e-02f, 1.18852101e-01f, 3.70338894e-02f, -4.72394153e-02f, -1.29077330e-01f, -1.85677066e-01f, -2.88419843e-01f, 4.74855453e-02f,
  2.07451545e-02f, -4.29027826e-02f, 1.08189225e-01f, 6.62204400e-02f, -9.93216783e-02f, -4.28596884e-03f, 5.13059199e-02f, -1.21327907e-01f, -5.39473630e-02f, -4.17282395e-02f,
  -7.58709610e-02f, 1.27637703e-02f, -1.51686028e-01f, 9.76847708e-02f, -1.17530242e-01f, -1.19370475e-01f, 1.71000823e-01f, -8.78543034e-02f, 1.60482302e-01f, 1.99584499e-01f,
  2.88801026e-02f, 1.86517924e-01f, -2.20719110e-02f, -8.21988285e-02f, 7.14560673e-02f, -1.59771577e-01f, -2.12752726e-02f, -1.19630024e-01f, 6.27008975e-02f, -3.82234412e-03f,
  2.41703391e-02f, -1.74571248e-03f, -1.56769872e-01f, 4.97234017e-02f, 3.29107163e-03f, -4.30483669e-02f, -7.14715123e-02f, 2.00020745e-02f, -4.30525914e-02f, -6.00453913e-02f,
  -1.30307078e-01f, 3.74172144e-02f, -1.07149042e-01f, -9.61998552e-02f, -8.21495615e-03f, -1.18186027e-01f, 3.67352962e-02f, 7.63824284e-02f, -9.18951109e-02f, -4.93936874e-02f,
  3.87528360e-01f, 7.83555686e-01f, 7.23062307e-02f, -1.49143815e-01f, 8.57534483e-02f, 1.95102151e-02f, 1.95950985e-01f, 1.41660988e-01f, 2.84080744e-01f, 1.11618303e-01f,
  -2.27640718e-02f, 2.27497052e-02f, 1.08852871e-01f, -2.41598621e-01f, 1.27740987e-02f, 1.78643748e-01f, -2.67748665e-02f, 5.51457256e-02f, -2.77281906e-02f, 2.09448654e-02f,
  -3.96915078e-02f, -1.26223369e-02f, 1.41218126e-01f, -6.24617562e-02f, 7.09987339e-03f, -1.48079516e-02f, 9.83866677e-02f, -8.18093249e-04f, -5.79784326e-02f, 6.98997304e-02f,
  5.15510559e-01f, -5.24623036e-01f, -8.56353700e-01f, 4.13805306e-01f, 2.43633404e-01f, 2.64143020e-01f, 4.28006761e-02f, 3.86950634e-02f, -3.61562878e-01f, -1.66311160e-01f,
  6.64293885e-01f, -5.43034852e-01f, -3.99788022e-01f, 1.03753042e+00f, 7.60421038e-01f, 1.53737441e-01f, 5.98484874e-01f, 3.71106476e-01f, 2.10416745e-02f, 2.50123829e-01f,
  3.53440970e-01f, 1.04580235e+00f, 4.07271177e-01f, 2.68088132e-01f, 5.79018772e-01f, -2.50975341e-01f, 1.99990675e-01f, -5.21200061e-01f, 4.46153104e-01f, 2.46308148e-01f,
  3.21515977e-01f, 7.85197169e-02f, 3.20616513e-02f, -1.35945961e-01f, 9.15536880e-02f, 1.09408952e-01f, -1.58459827e-01f, -3.37250443e-04f, -2.38489844e-02f, -7.52332509e-02f,
  -1.97426870e-01f, 3.00331656e-02f, 9.13603976e-02f, -7.90233091e-02f, 2.42715888e-02f, 3.82109024e-02f, 6.04333393e-02f, 3.11810127e-03f, -1.86447129e-01f, 7.59168565e-02f,
  -1.77156121e-01f, 1.37757044e-02f, 1.23759999e-03f, -9.39528644e-02f, -2.13583156e-01f, -8.67475793e-02f, -1.74753681e-01f, -2.70075351e-01f, -4.99423854e-02f, -1.08949929e-01f,
  6.90099671e-02f, -5.10241613e-02f, 4.12519202e-02f, 2.10996911e-01f, 1.44468229e-02f, 1.86476588e-01f, 2.77519841e-02f, 6.85180277e-02f, -1.30994022e-01f, 3.49977873e-02f,
  6.35444000e-02f, 8.37507695e-02f, -7.71905556e-02f, -7.49010444e-02f, 1.64976582e-01f, -7.04208761e-02f, 2.19876729e-02f, 1.04936518e-01f, -1.53523907e-01f, 1.43502489e-01f,
  -1.27335237e-02f, -1.12937652e-01f, -5.23981415e-02f, 1.08488202e-01f, -9.64057595e-02f, -1.44659087e-01f, 8.28993917e-02f, -2.23845523e-02f, -1.42853130e-02f, -1.52916729e-01f,
  4.85744774e-02f, -4.26584512e-01f, -9.53316018e-02f, -2.02467875e-03f, -9.28958356e-02f, 5.53155690e-02f, 5.09230467e-03f, -2.68283132e-02f, -1.20193288e-01f, -1.39701944e-02f,
  1.52561283e-02f, 1.53206836e-03f, -8.00107270e-02f, 1.04518361e-01f, -7.34834373e-02f, 8.74499753e-02f, -9.23687145e-02f, -1.56048492e-01f, 4.27919999e-03f, -1.47112489e-01f,
  -1.04086444e-01f, 2.74111927e-02f, -1.60459146e-01f, -3.13572288e-02f, 7.75137693e-02f, 5.03442362e-02f, -7.63581246e-02f, -1.65460855e-01f, 3.44190598e-02f, -3.48261409e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.45115578e+00f, 5.45810044e-01f, 1.11327434e+00f, 7.04186261e-01f, 1.05382323e+00f, 1.00254941e+00f, 1.18241584e+00f, 7.95381188e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.18066871e+00f, 5.54747939e-01f, 3.44760627e-01f, -1.55430764e-01f, 3.69652063e-01f, -6.63753688e-01f, -1.97325870e-01f, -2.56978899e-01f, -2.32142821e-01f, -8.59820664e-01f,
  -1.67694278e-02f, -3.93463492e-01f, -8.07170212e-01f, 9.33576655e-03f, 1.87076360e-01f, 7.35103250e-01f, 7.06328392e-01f, -8.65844250e-01f, 7.52755344e-01f, 4.77232069e-01f,
  7.90248632e-01f, 3.91642004e-01f, -1.00914784e-01f, -4.70940143e-01f, -8.07012022e-01f, 9.04947162e-01f, 6.31299973e-01f, -7.90075958e-01f, -1.31633508e+00f, -7.84846365e-01f,
  -1.49940789e-01f, 2.87802398e-01f, 2.88806707e-01f, -8.94273579e-01f, -1.36360860e+00f, 4.84142721e-01f, 4.69281137e-01f, 3.78054470e-01f, 7.34504879e-01f, -2.69108802e-01f,
  8.32850814e-01f, -5.12934476e-02f, -3.59252781e-01f, -5.55054486e-01f, -3.86963189e-01f, 3.52129370e-01f, -1.03789282e+00f, -1.23734391e+00f, -9.63626921e-01f, -9.54565406e-02f,
  -6.90991342e-01f, 5.76212764e-01f, -7.89503813e-01f, 8.69023442e-01f, 3.43846023e-01f, -7.79962897e-01f, -7.12369800e-01f, -9.64523196e-01f, 5.68998873e-01f, -9.64979351e-01f,
  4.09793854e-01f, -1.33686984e+00f, 2.24588498e-01f, 6.87575102e-01f, 5.83083153e-01f, 1.87466294e-01f, 8.77100468e-01f, -9.38569531e-02f, -9.14122462e-01f, 8.37861449e-02f,
  -4.47814286e-01f, -1.88558906e-01f, -1.08989549e+00f, -2.84964710e-01f, -4.03718591e-01f, 4.54469919e-01f, 7.57082105e-01f, 5.18238306e-01f, -2.69812763e-01f, 1.01080441e+00f,
  -4.54690397e-01f, -6.78815782e-01f, -4.95157212e-01f, -9.11082923e-01f, -2.83549726e-01f, -1.15372205e+00f, -6.00224018e-01f, 4.94007260e-01f, -1.10741854e+00f, -8.18640232e-01f,
  -6.24125488e-02f, 1.78772673e-01f, -7.69769907e-01f, -5.93840480e-01f, -7.59910524e-01f, 8.90764475e-01f, -2.69773364e-01f, -9.83879805e-01f, 1.30068809e-01f, -3.97450268e-01f,
  -7.99579740e-01f, -3.74480456e-01f, 4.99405026e-01f, -5.13598382e-01f, -1.00263572e+00f, 7.58595228e-01f, -1.81680158e-01f, 4.72210139e-01f, -3.03701550e-01f, -2.86488473e-01f,
  -5.75384796e-01f, -8.51513743e-01f, -4.07684371e-02f, -2.46041492e-01f, -7.49866128e-01f, -7.07776129e-01f, 2.56995797e-01f, 4.51991707e-01f, 1.20170414e+00f, 7.70902038e-01f,
  6.83990777e-01f, 7.68341243e-01f, -2.29668602e-01f, 9.74729955e-02f, -1.26125705e+00f, 2.34389439e-01f, -8.95835638e-01f, -1.08652174e+00f, 3.92780632e-01f, 6.66607320e-01f,
  4.05326575e-01f, -2.34458178e-01f, -2.17030987e-01f, 9.52661559e-02f, 3.49295139e-01f, 2.21480191e-01f, 7.05388546e-01f, 3.19436818e-01f, 6.34485126e-01f, 3.04023832e-01f,
  6.57849729e-01f, -1.07504761e+00f, -4.56210107e-01f, 5.81559002e-01f, 7.18514323e-01f, -1.41358864e+00f, 1.13321781e+00f, -1.39916801e+00f, 8.02772641e-01f, 8.55713367e-01f,
  -6.71306551e-01f, -1.27460885e+00f, 7.83163130e-01f, 1.67514279e-01f, -1.21966970e+00f, -1.14661956e+00f, 5.05318701e-01f, -2.42111459e-01f, 1.89121380e-01f, -3.57003480e-01f,
  9.27041173e-01f, 1.27208129e-01f, 8.28303695e-01f, -1.54232606e-02f, 7.25938231e-02f, 6.94432735e-01f, -3.24585706e-01f, -4.09590527e-02f, 2.59070784e-01f, 5.54809093e-01f,
  3.37004870e-01f, 2.21048445e-01f, -6.86109245e-01f, 1.05451584e+00f, -4.56489056e-01f, -3.36549401e-01f, 1.31958142e-01f, 1.18534756e+00f, 8.15846384e-01f, 9.49796677e-01f,
  -3.51414084e-01f, 4.09604669e-01f, 4.40313727e-01f, -8.42362285e-01f, -1.18777883e+00f, 1.65770933e-01f, -1.15870304e-01f, -7.65457153e-01f, -1.25517762e+00f, 7.08151519e-01f,
  1.11489797e+00f, -1.16901100e+00f, -7.51805425e-01f, -2.69100666e-01f, -3.90176296e-01f, 4.48968083e-01f, 7.41663992e-01f, -3.61826979e-02f, 4.87990230e-01f, 3.35016102e-01f,
  -9.41482604e-01f, 5.06103277e-01f, -1.43702894e-01f, 3.11031565e-02f, 8.35219681e-01f, 1.12734234e+00f, 1.07196581e+00f, -1.36767685e+00f, 1.75970048e-01f, 2.11309627e-01f,
  3.08917016e-01f, -3.28773916e-01f, -6.23839557e-01f, 4.93444115e-01f, -8.79088283e-01f, 1.11893928e+00f, -2.41360724e-01f, -9.69329238e-01f, -1.31273866e+00f, -5.65660238e-01f,
  -7.30873346e-02f, 1.10551202e+00f, -8.96102548e-01f, 1.38445005e-01f, 8.34464952e-02f, -1.99084803e-01f, -4.91910160e-01f, -1.04289062e-01f, -4.79341716e-01f, -1.68835580e-01f,
  1.10616935e-02f, -2.61933565e-01f, -1.92035094e-01f, -8.21336210e-01f, -9.09151614e-01f, -6.89285278e-01f, -6.53834581e-01f, -2.76719853e-02f, 3.62962812e-01f, 3.17206115e-01f,
  -4.64777470e-01f, 6.07389450e-01f, -9.36357439e-01f, 4.15974528e-01f, 5.25342822e-01f, -7.14456439e-01f, 3.47511649e-01f, 7.26164222e-01f, -8.75907391e-02f, 6.17777884e-01f,
  -9.62616026e-01f, -3.93698901e-01f, 6.63876891e-01f, 3.04917336e-01f, 1.97696060e-01f, -4.99409050e-01f, -8.43330801e-01f, -4.94948268e-01f, -3.46089631e-01f, -2.18298420e-01f,
  -9.12359357e-01f, -3.32346350e-01f, -1.93666667e-01f, 2.93706179e-01f, 1.86052352e-01f, -6.92759752e-02f, 4.40587848e-02f, 2.11011678e-01f, -5.44773638e-01f, 6.59362793e-01f,
  7.00077355e-01f, 8.04743707e-01f, -5.55889368e-01f, 8.61695111e-01f, -4.79495913e-01f, 5.00684500e-01f, -8.11462045e-01f, 6.31386220e-01f, -4.47628982e-02f, 1.87795639e-01f,
  7.46436477e-01f, -9.03341591e-01f, -2.42743134e-01f, 7.72098482e-01f, -7.70769835e-01f, -9.38308835e-01f, 7.77491555e-02f, -7.29135796e-02f, -7.65639186e-01f, 7.04641283e-01f,
  2.79548049e-01f, -6.26717806e-02f, 7.57799447e-01f, 2.46770963e-01f, -8.00114453e-01f, 1.29681572e-01f, 6.90713525e-01f, 4.27574307e-01f, 5.10859787e-01f, 7.25622058e-01f,
  8.71685684e-01f, -1.03305268e+00f, 7.21955657e-01f, 1.38208103e+00f, -9.85262334e-01f, 1.07062042e+00f, 6.80071115e-01f, 1.12642550e+00f, -7.96916127e-01f, -9.77602601e-01f,
  1.16992116e+00f, -5.50933123e-01f, -1.18015206e+00f, -1.93459749e-01f, -6.28580630e-01f, -7.60696113e-01f, 9.93506968e-01f, -3.72377634e-01f, -1.28345346e+00f, -1.25848083e-02f,
  5.29650807e-01f, 2.81057805e-01f, -3.06672335e-01f, 5.36717474e-01f, 4.44190651e-01f, 2.14873143e-02f, -8.11022878e-01f, 5.71329117e-01f, 4.78104085e-01f, -3.04591089e-01f,
  4.24210966e-01f, -5.80283523e-01f, -5.56110084e-01f, -7.22271085e-01f, -7.34419942e-01f, -2.67445624e-01f, 8.73776436e-01f, -8.50555837e-01f, -8.28584433e-01f, -1.61094397e-01f,
  9.11771178e-01f, -1.27622879e+00f, -6.64024591e-01f, 1.01611066e+00f, 5.86359441e-01f, -8.98640990e-01f, 9.80484486e-01f, -3.01556468e-01f, -6.16157353e-01f, -4.04321015e-01f,
  -4.09640342e-01f, -1.05507267e+00f, 2.38675758e-01f, 1.67325199e-01f, -4.81559634e-02f, -3.85598063e-01f, 1.05053514e-01f, 5.90605550e-02f, 4.27746713e-01f, -5.70138395e-01f,
  2.78899401e-01f, -2.10948996e-02f, 2.22978339e-01f, 3.54574770e-01f, 5.28459728e-01f, -5.03194869e-01f, 5.85995555e-01f, -5.13494790e-01f, 6.46902740e-01f, 4.02072489e-01f,
  -1.75237805e-01f, -8.20776105e-01f, 4.65418041e-01f, 7.11171806e-01f, 1.40891418e-01f, -5.26373923e-01f, -9.88203764e-01f, -9.06800091e-01f, 2.36432642e-01f, 1.11485624e+00f,
  3.24579537e-01f, 1.09021544e-01f, 2.48313665e-01f, -1.26207471e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.68969625e-01f, -2.96551645e-01f, 1.47328168e-01f, -8.73997658e-02f, -3.73927429e-02f, 2.59226859e-01f, 4.24606532e-01f, -4.17635262e-01f, -1.55811697e-01f, 3.61375332e-01f,
  2.14774102e-01f, -3.20764154e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    