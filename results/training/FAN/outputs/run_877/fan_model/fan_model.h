/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.84824118e-02f, 2.47103080e-01f, 2.33995065e-01f, 1.67627320e-01f, 1.69009745e-01f, 1.22435294e-01f, 1.82132155e-01f, 6.81513846e-02f, -6.95787072e-02f, 2.04278424e-01f,
  6.33055940e-02f, -1.16043933e-01f, -1.39652630e-02f, -7.78338164e-02f, -7.29597360e-03f, 2.58624107e-01f, 2.94835985e-01f, 1.57597825e-01f, -1.32804319e-01f, -1.61489069e-01f,
  -7.61553571e-02f, -5.07299490e-02f, -1.87170595e-01f, 2.35511246e-03f, 1.30554318e-01f, -2.49602646e-02f, 1.67023644e-01f, 8.42563584e-02f, 6.64372370e-02f, 2.80935019e-01f,
  2.40019500e-01f, -3.43945622e-02f, 5.01074158e-02f, -7.39680305e-02f, -5.25444630e-04f, -5.30463569e-02f, 2.78103091e-02f, -5.05159609e-02f, 2.99845207e-02f, -1.89712457e-02f,
  6.28345925e-03f, -1.16416186e-01f, -7.11462870e-02f, -4.80258130e-02f, 8.92818943e-02f, -6.53936714e-02f, 2.72675566e-02f, -3.26234028e-02f, -6.70339912e-02f, -6.14032708e-03f,
  7.02878907e-02f, -1.93158034e-02f, 8.75152741e-03f, -5.18449359e-02f, -6.59318939e-02f, -3.76033154e-03f, -1.06272466e-01f, -1.06993675e-01f, -6.96248636e-02f, 4.58209822e-03f,
  4.88958284e-02f, 2.40810290e-02f, -1.86205693e-02f, -2.00728849e-02f, -1.76413711e-02f, 4.76185232e-02f, -2.97817471e-03f, 1.20529323e-03f, 1.41155906e-02f, -8.17223713e-02f,
  4.37514298e-02f, 7.71879554e-02f, 2.82341689e-02f, 2.87020132e-02f, 4.14506793e-02f, -4.24284954e-03f, -3.18513401e-02f, 1.01052612e-01f, -6.33287150e-03f, -2.55064480e-02f,
  2.58226674e-02f, -8.43871012e-02f, -2.23120917e-02f, 7.72337383e-03f, 2.09981892e-02f, 8.18875805e-02f, 1.00232353e-02f, 3.91865708e-03f, -1.50653692e-02f, -5.03877997e-02f,
  -5.67658246e-02f, -1.14155546e-01f, 1.88639715e-01f, 3.22892219e-02f, 9.88669768e-02f, -5.31435460e-02f, 8.37953016e-02f, 5.57089644e-03f, -7.41054211e-03f, 6.44991472e-02f,
  -2.55877618e-02f, 5.88994250e-02f, 1.16797149e-01f, -6.73033968e-02f, -3.11390702e-02f, -1.32105919e-02f, 9.08131152e-02f, -9.53225605e-03f, 3.52493115e-02f, 3.93323898e-02f,
  6.54779188e-03f, 5.64854145e-02f, 1.05157867e-01f, 3.01781222e-02f, 5.51775238e-03f, 6.15118369e-02f, 6.55253604e-02f, -1.20099736e-02f, -7.51124695e-02f, 7.61335194e-02f,
  -1.77150711e-01f, -5.46352565e-02f, -1.76530793e-01f, -1.68619335e-01f, -1.03596255e-01f, -2.33149286e-02f, -5.20159267e-02f, -7.45547116e-02f, 6.57782853e-02f, -2.02782545e-02f,
  1.38044477e-01f, 1.22687832e-01f, 2.54379213e-02f, 9.35644656e-02f, -9.95363370e-02f, -1.47874281e-01f, -2.56915987e-01f, -1.07687712e-01f, -1.49037406e-01f, -1.01445010e-03f,
  -6.72080964e-02f, -8.31464157e-02f, -7.77881593e-02f, 1.25709800e-02f, -6.39538933e-03f, 9.93693322e-02f, -3.71112525e-02f, -7.93325156e-02f, -8.10084343e-02f, -4.77805957e-02f,
  -9.88405570e-02f, -4.53845486e-02f, 9.82923806e-03f, 5.89282624e-02f, 2.16148160e-02f, 3.84285189e-02f, 8.27686414e-02f, -2.81523932e-02f, 1.36568159e-01f, -8.10392946e-02f,
  1.29545018e-01f, 2.39445381e-02f, 3.72450775e-03f, -7.76282325e-02f, -5.93480617e-02f, -1.55807717e-03f, -4.92090918e-02f, -3.64972837e-02f, -5.99210635e-02f, -3.50117385e-02f,
  7.38501027e-02f, 3.46093327e-02f, 1.87938791e-02f, 1.57113690e-02f, -9.29205492e-02f, 2.98179332e-02f, 5.82102463e-02f, -7.28902891e-02f, 3.25113423e-02f, -6.93221614e-02f,
  -3.30271274e-02f, 4.84527759e-02f, -1.52779063e-02f, -3.90451513e-02f, -1.58558376e-02f, 3.18703689e-02f, -4.94965166e-02f, -5.03699742e-02f, 1.33260861e-02f, -5.52656986e-02f,
  -8.77468437e-02f, -4.02144752e-02f, -2.03811452e-02f, -3.64627354e-02f, -3.22899632e-02f, 4.77057137e-02f, 3.96133699e-02f, 5.36208367e-03f, -5.72422929e-02f, -2.61389632e-02f,
  -6.20456263e-02f, -3.42403315e-02f, -5.10687903e-02f, -4.02258076e-02f, -5.95760234e-02f, -2.08786409e-02f, 4.45907656e-03f, 9.39309224e-03f, 5.91681227e-02f, -3.69017688e-03f,
  1.05181225e-01f, 2.24799346e-02f, -8.52914378e-02f, 4.95226830e-02f, 6.29562661e-02f, 8.38759840e-02f, 4.78636101e-02f, -4.54866402e-02f, -3.31616565e-03f, 3.59809250e-02f,
  4.91344184e-02f, 3.02832611e-02f, -3.86480279e-02f, 3.90666984e-02f, -6.16656430e-02f, 2.62750331e-02f, 5.50919510e-02f, -3.96208689e-02f, 5.51390871e-02f, -3.03099975e-02f,
  3.08699850e-02f, -1.21327303e-02f, -4.73421179e-02f, 7.56597072e-02f, 4.04228009e-02f, 1.17558941e-01f, -5.32380119e-02f, 8.21493715e-02f, 7.74351554e-03f, -1.53025374e-01f,
  -2.54952699e-01f, 3.15151870e-01f, -1.59182586e-02f, -1.52894825e-01f, 1.23615168e-01f, 1.85885131e-01f, 4.76127297e-01f, 1.93737671e-01f, 1.33757740e-02f, 2.21409768e-01f,
  4.09696028e-02f, -1.71824321e-01f, -1.43366948e-01f, -1.50635794e-01f, -4.52877246e-02f, 1.48786977e-01f, 6.07703701e-02f, -1.87443748e-01f, -2.35150367e-01f, 1.59580708e-02f,
  6.86390549e-02f, -2.51491927e-02f, -1.03131041e-01f, -3.56041901e-02f, -5.89814223e-03f, -6.33666739e-02f, 8.61919820e-02f, -9.19744447e-02f, -3.94141395e-03f, -8.24055523e-02f,
  -2.75506750e-02f, -1.25044122e-01f, -7.39538595e-02f, -1.04323231e-01f, -6.23968057e-02f, -8.25074036e-03f, 4.35694866e-02f, -4.50159656e-03f, -1.77874938e-02f, 4.19764481e-02f,
  -2.86308415e-02f, -9.65558216e-02f, 3.74743715e-02f, -7.56096169e-02f, 5.05066849e-02f, -4.53672893e-02f, -8.85232240e-02f, -2.08899468e-01f, -8.00672695e-02f, 9.03666615e-02f,
  1.23988681e-01f, 7.80779053e-04f, 1.63847785e-02f, 1.14480980e-01f, 7.63389468e-03f, -1.90004706e-01f, 3.85336243e-02f, -1.46606460e-01f, -7.99517035e-02f, 6.67920783e-02f,
  6.99660508e-03f, 4.80482308e-03f, -4.43826541e-02f, -2.29916424e-02f, 9.80181471e-02f, 2.06283405e-02f, -1.19847685e-01f, 4.64983024e-02f, -6.13322556e-02f, 6.36977926e-02f,
  -5.46393543e-02f, -2.29986012e-03f, 1.54909119e-02f, 5.99419400e-02f, 3.92329954e-02f, -5.33516705e-03f, -2.94064172e-02f, 3.32935378e-02f, 9.19869840e-02f, 5.93914697e-03f,
  -6.65497929e-02f, -7.30615705e-02f, -3.88448834e-02f, 7.97486827e-02f, -5.52033409e-02f, -5.89931458e-02f, -1.15226666e-02f, 5.47221117e-03f, 4.59760278e-02f, 2.85442825e-03f,
  1.31003276e-01f, -1.71706714e-02f, -4.69210856e-02f, -8.56801216e-03f, 2.36655045e-02f, 2.38426831e-02f, -8.79175216e-03f, -2.13841982e-02f, -9.86197963e-02f, -2.90029738e-02f,
  1.12003740e-02f, 2.91606449e-02f, 2.58246157e-02f, 4.07473790e-03f, 1.13194427e-02f, 1.68982279e-02f, 5.34623377e-02f, 1.13044807e-03f, 3.50005701e-02f, 6.86839446e-02f,
  1.37697995e-01f, 1.20016806e-01f, 7.33204037e-02f, 9.69412178e-02f, -1.87798366e-02f, -3.07422522e-02f, 1.43971518e-01f, 1.02511980e-01f, 9.46895592e-03f, 3.32614005e-01f,
  1.04449332e-01f, 3.19965109e-02f, 2.11370796e-01f, 4.10286859e-02f, -1.43626273e-01f, 5.11517785e-02f, -8.75777826e-02f, -1.10084288e-01f, -6.00196868e-02f, 4.33148183e-02f,
  7.27024004e-02f, -7.88702164e-03f, 2.05203965e-02f, 8.03803504e-02f, 8.23779404e-02f, -5.53526804e-02f, 7.64343515e-02f, -1.69093367e-02f, 5.15222810e-02f, -1.53204471e-01f,
  -2.23121211e-01f, -3.04766484e-02f, 5.74631095e-02f, -4.24462445e-02f, 4.39115353e-02f, -5.91695309e-02f, 6.23881854e-02f, 2.44619399e-02f, 6.75808266e-03f, -2.02082265e-02f,
  1.54125020e-01f, 8.15408900e-02f, -1.02242306e-01f, -1.11402437e-01f, 3.95515487e-02f, 5.16771190e-02f, -2.32020132e-02f, 1.01140052e-01f, -7.31832907e-02f, -3.84011306e-02f,
  6.94889873e-02f, 3.76505442e-02f, -1.90701487e-03f, -1.78398509e-02f, 7.76549950e-02f, 1.13797067e-02f, 1.41456788e-02f, 1.28950894e-01f, 5.49569204e-02f, -2.06714496e-02f,
  -8.60690176e-02f, -6.34276867e-02f, 1.65313959e-01f, -6.61030784e-02f, 7.99121037e-02f, 8.72994121e-03f, 3.91933843e-02f, 6.92166835e-02f, 1.41181260e-01f, -4.06522378e-02f,
  -9.74491164e-02f, 2.56384742e-02f, -7.55108222e-02f, -5.52885756e-02f, 2.74672303e-02f, 3.04051228e-02f, 3.91810276e-02f, -1.53753487e-02f, 3.55881453e-02f, 2.04577912e-02f,
  1.99364349e-02f, 3.94888520e-02f, -6.32401779e-02f, -2.87353098e-02f, 2.50796210e-02f, -5.51016517e-02f, -3.18279192e-02f, -3.05510536e-02f, 4.69060726e-02f, 4.73188311e-02f,
  -3.70829366e-02f, 5.48557490e-02f, 5.21618016e-02f, 1.12211378e-02f, -2.69505624e-02f, -1.27794994e-02f, 6.52397573e-02f, 2.65759416e-02f, -9.23432782e-02f, 5.61567582e-02f,
  -8.91975872e-03f, 6.41631857e-02f, -5.83499596e-02f, 4.27981056e-02f, 3.98086645e-02f, 3.14059258e-02f, -6.31101876e-02f, 7.95755070e-03f, 2.16505844e-02f, -1.12523036e-02f,
  4.78542373e-02f, -6.38789535e-02f, -2.37466837e-03f, -2.76080221e-02f, -9.62331612e-03f, -4.82467823e-02f, -4.05664061e-04f, -6.54371630e-04f, -8.55559111e-02f, 8.54506195e-02f,
  -9.74771604e-02f, -5.25638051e-02f, 5.53175993e-02f, 8.24671909e-02f, -1.89362820e-02f, -5.50081618e-02f, 1.31994430e-02f, 7.66666830e-02f, 2.91812122e-02f, -8.70117024e-02f,
  -3.61268252e-01f, 4.15921845e-02f, -4.03885357e-02f, -2.29835953e-03f, 1.71745509e-01f, -1.59400716e-01f, -1.05267286e-01f, -1.94682077e-01f, -4.21204045e-02f, 1.06025875e-01f,
  1.19521670e-01f, 1.73659280e-01f, 1.19713500e-01f, 1.02834783e-01f, -1.16544925e-01f, -5.55310436e-02f, -2.46678721e-02f, -6.05403818e-02f, -2.51518250e-01f, -6.66859224e-02f,
  3.68783139e-02f, 3.58517468e-02f, -1.87089041e-01f, 1.47420038e-02f, 1.75497070e-01f, 7.76096284e-02f, 7.63998032e-02f, 1.51908532e-01f, 1.03197902e-01f, 1.92565680e-01f,
  1.30100340e-01f, 5.50870821e-02f, -2.75411233e-02f, 4.78151962e-02f, 1.28479764e-01f, -1.28141895e-01f, -6.53119758e-02f, 6.81824535e-02f, 2.96351220e-02f, -6.30570054e-02f,
  1.68894768e-01f, -8.48811865e-03f, 4.12333533e-02f, 8.43735039e-02f, -4.74290214e-02f, 9.63093806e-03f, -1.10076210e-02f, -1.17266841e-01f, -1.31507859e-01f, 1.39379231e-02f,
  1.49324179e-01f, 3.68285216e-02f, -7.22493008e-02f, -3.46752368e-02f, -9.51722264e-02f, 3.17148156e-02f, 7.38387629e-02f, -7.99731724e-03f, -1.58353999e-01f, -4.18950133e-02f,
  1.74424853e-02f, 3.04512512e-02f, 1.49764242e-02f, -3.31832878e-02f, 4.45858575e-03f, 4.31686006e-02f, 1.89654436e-02f, 7.26959631e-02f, -6.66620350e-03f, -8.67072740e-05f,
  -3.68817113e-02f, 2.71509364e-02f, 2.51516532e-02f, -3.88382226e-02f, 8.58483016e-02f, 1.40881604e-02f, 5.09363823e-02f, 1.94718186e-02f, -2.08634622e-02f, -7.49113550e-03f,
  -1.47970505e-02f, -1.16186934e-02f, 1.18373282e-01f, 2.51985304e-02f, 2.08973456e-02f, 3.24310437e-02f, -1.70595292e-02f, 1.98241584e-02f, -3.44292298e-02f, -3.23660560e-02f,
  -7.22594783e-02f, -4.91949841e-02f, 2.75889244e-02f, -1.45348623e-01f, 3.78295481e-02f, 3.93666998e-02f, -5.27218962e-03f, -5.76396771e-02f, 1.16439655e-01f, -5.65571003e-02f,
  7.76266272e-04f, -6.97166026e-02f, -3.91823836e-02f, -7.44286999e-02f, -2.82837935e-02f, -2.94433758e-02f, 9.69484597e-02f, 2.85944138e-02f, 5.66674676e-03f, 5.63621558e-02f,
  -4.77066040e-02f, -1.34329453e-01f, -1.17953317e-02f, -3.43288593e-02f, -3.73194218e-02f, -1.09921694e-01f, -2.69042253e-02f, -1.05798347e-02f, -1.28991261e-01f, -2.80812293e-01f,
  -1.25411078e-01f, -5.12278266e-02f, 2.09409878e-01f, 1.73151582e-01f, 1.76066831e-01f, 4.49410034e-03f, 4.68127020e-02f, -6.20284304e-02f, 5.70177436e-02f, -2.25461069e-02f,
  -1.92395821e-01f, -1.81805208e-01f, -1.44422844e-01f, 7.26425694e-03f, 6.26332778e-03f, 1.31677240e-01f, 1.66491166e-01f, 1.57091603e-01f, -7.19832480e-02f, 1.97615381e-02f,
  7.54002035e-02f, 3.89531702e-02f, 9.15818438e-02f, 3.48907970e-02f, 1.66356176e-01f, -6.31116927e-02f, 8.86957571e-02f, 1.61708847e-01f, -2.70865280e-02f, 1.75150707e-01f,
  -2.55033940e-01f, 4.70631272e-02f, -3.92964482e-02f, -1.87615622e-02f, 4.75970730e-02f, -6.66444190e-03f, -6.60399441e-04f, 9.03449021e-03f, 8.62350781e-03f, 4.90276776e-02f,
  -1.51109826e-02f, 5.60912164e-03f, 9.14571509e-02f, 6.72913715e-02f, 6.44118488e-02f, 2.32727695e-02f, 9.22245011e-02f, 9.82369855e-02f, -3.38050537e-02f, -6.74366504e-02f,
  9.84441210e-03f, 1.71644211e-01f, -2.25734934e-02f, 2.04253439e-02f, 1.06158499e-02f, 2.75956988e-02f, -4.88041108e-03f, 1.10958237e-03f, 5.58466725e-02f, 2.76803635e-02f,
  8.11997149e-03f, -3.30244750e-02f, -1.90141648e-02f, -9.24663804e-03f, -3.63348350e-02f, -4.63588675e-03f, 8.82108510e-03f, -1.64066050e-02f, -3.03419568e-02f, 2.41380073e-02f,
  -9.21748485e-03f, -1.73798553e-03f, 6.13071918e-02f, -1.80745181e-02f, 5.25822937e-02f, 9.24927667e-02f, 5.17456792e-03f, -7.25057125e-02f, 1.28880404e-02f, -3.35065313e-02f,
  -9.60029736e-02f, 3.38339899e-03f, -2.19862666e-02f, -5.17208874e-02f, 2.41633784e-02f, -8.02055188e-03f, 3.84896137e-02f, -8.66417289e-02f, 3.36603029e-03f, 1.82439648e-02f,
  -1.80740118e-01f, 1.32579163e-01f, -9.57006216e-02f, -1.78612228e-02f, 7.13033453e-02f, -5.10134362e-02f, -1.88188404e-02f, -1.49610639e-02f, 4.48285230e-02f, -5.72315231e-02f,
  4.35315818e-02f, -9.64710936e-02f, -3.32436226e-02f, -5.90080395e-02f, 1.26387142e-02f, -1.04272831e-02f, -6.74349740e-02f, -8.98408238e-03f, 6.25499859e-02f, -2.81998590e-02f,
  2.77363192e-02f, -6.99913651e-02f, -1.19982613e-02f, -1.03599466e-01f, 1.86267383e-02f, 3.36235687e-02f, -1.19287439e-01f, -2.12064404e-02f, -6.90883026e-02f, -1.20564289e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.40148857e-01f, 4.87562194e-02f, 3.67966332e-02f, 1.24482043e-01f, -1.42557710e-01f, -2.68019289e-01f, -2.91832954e-01f, -2.03819543e-01f, 7.20281294e-03f, -7.16691464e-02f,
  -8.07203278e-02f, 8.27281401e-02f, -2.66348245e-03f, 9.92786046e-03f, -1.52347907e-01f, -7.05319792e-02f, -8.26543048e-02f, 2.75332499e-02f, 4.55086827e-02f, 6.58154394e-03f,
  -2.11066566e-02f, 1.03634149e-01f, 8.54554400e-02f, -1.22297136e-02f, 8.62229317e-02f, 5.05144894e-02f, 2.22301763e-02f, 1.64988488e-01f, 4.05460224e-02f, 2.96346456e-01f,
  2.78237581e-01f, 5.87695390e-02f, -1.94122605e-02f, 6.12647943e-02f, -2.29905527e-02f, 5.32674370e-03f, -1.86834298e-02f, -2.44065411e-02f, -1.11450842e-02f, -2.51902081e-02f,
  8.14269334e-02f, 2.63686776e-02f, 3.09390435e-03f, -5.10092936e-02f, -8.22879151e-02f, 2.36719530e-02f, 2.52336659e-03f, -2.14202870e-02f, -1.44196348e-02f, -1.70909299e-03f,
  8.78015757e-02f, -5.23343980e-02f, -8.52811933e-02f, -4.58584689e-02f, -8.00181180e-02f, -1.68201793e-02f, 1.25177773e-02f, -2.99077923e-03f, 1.00249993e-02f, 3.87334004e-02f,
  7.39386901e-02f, -4.51397076e-02f, 1.79599524e-02f, 2.90843118e-02f, 2.52849460e-02f, -4.24332311e-03f, 6.59536049e-02f, -5.56724705e-02f, 4.76224907e-02f, -6.04024902e-02f,
  -6.08512759e-02f, -3.45858708e-02f, 4.25284654e-02f, 5.90426885e-02f, 5.96449450e-02f, -4.57992926e-02f, 6.11363985e-02f, -1.72375068e-02f, 8.70978758e-02f, 5.60535723e-03f,
  1.04699939e-01f, -7.60900080e-02f, 9.60621759e-02f, -6.11120313e-02f, 4.36004326e-02f, 2.20044460e-02f, 1.09021053e-01f, -6.32693619e-03f, -3.18131315e-05f, 1.04144350e-01f,
  -2.90527754e-02f, -2.19395846e-01f, 4.72428277e-02f, 1.38486514e-03f, 8.75848830e-02f, 1.05572287e-02f, -2.93899123e-02f, 5.28157279e-02f, -4.39492278e-02f, -3.76284346e-02f,
  -1.97898829e-03f, -4.78540827e-03f, -4.84310426e-02f, 2.76240590e-03f, -1.05729617e-01f, 7.59321323e-04f, -1.14460438e-02f, 1.57100800e-02f, -1.19759344e-01f, -5.35889082e-02f,
  -1.05497614e-01f, -6.90652356e-02f, -1.14090204e-01f, -1.28898367e-01f, -2.72604171e-02f, -1.17607549e-01f, -6.84494600e-02f, 2.81527881e-02f, -1.24858327e-01f, -5.15614673e-02f,
  -7.30250869e-03f, -7.73439184e-02f, -2.61263214e-02f, 2.38856282e-02f, 3.45071144e-02f, -1.01542689e-01f, -2.87536476e-02f, 5.62301185e-03f, -2.50551477e-02f, -1.41368851e-01f,
  -5.65546155e-02f, 1.53616946e-02f, 2.26230286e-02f, 4.02674340e-02f, -4.95344065e-02f, -8.06540176e-02f, 2.81587671e-02f, 1.52314439e-01f, 8.12207907e-02f, 5.64964600e-02f,
  1.04274713e-01f, 1.90778702e-01f, 6.84941411e-02f, 4.56277505e-02f, -7.41412267e-02f, 1.00610495e-01f, -2.02081259e-03f, 3.70780565e-02f, 5.63567169e-02f, -5.53936660e-02f,
  -1.31087005e-01f, -1.48532689e-01f, 1.06269531e-01f, 5.68015836e-02f, 2.75165774e-02f, 8.46807307e-05f, -2.68773902e-02f, -2.61283889e-02f, -1.78893190e-02f, -9.36078504e-02f,
  1.97926685e-02f, -1.05880879e-01f, -8.36481154e-02f, -5.95594980e-02f, -6.44730479e-02f, -1.18364953e-01f, 3.97804156e-02f, 4.80038263e-02f, 5.56969345e-02f, -6.67349668e-03f,
  -3.72387320e-02f, 1.88785959e-02f, -2.71858592e-02f, -4.63065132e-02f, -4.45073843e-02f, -3.17206159e-02f, -7.27531463e-02f, 3.64623079e-03f, -3.28511894e-02f, -9.76484641e-02f,
  -4.38143648e-02f, 2.04369221e-02f, -1.92799009e-02f, 2.60164551e-02f, -9.54131186e-02f, 3.98489609e-02f, -1.34625398e-02f, -3.94215621e-02f, -1.99348330e-02f, -4.50504459e-02f,
  4.66668271e-02f, 8.26213101e-04f, -4.56582122e-02f, 2.69243848e-02f, 2.19400432e-02f, 2.93851476e-02f, 2.24636253e-02f, 3.99184711e-02f, 3.29054743e-02f, -4.46833894e-02f,
  4.73866751e-03f, -2.55162735e-02f, -2.77811550e-02f, 4.96578738e-02f, -6.99795783e-02f, 5.75507656e-02f, 8.86553004e-02f, -7.74591118e-02f, -1.27482833e-02f, -2.93271039e-02f,
  -2.15562489e-02f, 1.65223554e-01f, -7.90733919e-02f, -2.46268455e-02f, -6.36345968e-02f, 4.25258018e-02f, 2.37642555e-03f, -6.98960871e-02f, -4.92524505e-02f, -1.13183513e-01f,
  -3.56763303e-02f, -2.87665762e-02f, -9.99436527e-02f, 5.45084104e-03f, -3.29669081e-02f, -2.93585714e-02f, 8.36235657e-03f, 4.00776565e-02f, 2.68939249e-02f, 5.18307313e-02f,
  -2.69404147e-02f, -3.59432437e-02f, -1.19657889e-01f, -4.92312647e-02f, -4.30984274e-02f, -8.92083347e-02f, -2.45436579e-02f, -9.20721591e-02f, -1.19924963e-01f, 5.62918149e-02f,
  -6.89492747e-02f, -7.24393316e-03f, 1.71580449e-01f, -1.59413397e-01f, -1.02798231e-01f, -4.25263634e-03f, 1.11255504e-01f, 1.67958941e-02f, -1.66465089e-01f, 3.58928367e-02f,
  5.54730482e-02f, -9.93900672e-02f, -1.12439625e-01f, 7.23283272e-04f, 8.59135762e-02f, 6.32767230e-02f, -3.39010097e-02f, -3.46664302e-02f, -4.01050560e-02f, -4.23978902e-02f,
  -1.05735391e-01f, -1.07338995e-01f, -9.88505334e-02f, -8.81597474e-02f, -9.64827985e-02f, 5.55196293e-02f, 1.04738645e-01f, -2.53107324e-02f, 6.33164570e-02f, -1.31782098e-02f,
  8.86768848e-02f, 3.35059799e-02f, 9.36209261e-02f, 3.83549966e-02f, 9.37199127e-03f, 4.79814671e-02f, -8.76844302e-02f, -7.97435492e-02f, -1.00658134e-01f, -2.74566710e-02f,
  -2.53690835e-02f, -7.79629499e-02f, 3.70028168e-02f, 8.31382442e-03f, 2.61185374e-02f, 3.82682942e-02f, -4.80845571e-02f, -2.46861819e-02f, 5.34142964e-02f, -5.76191358e-02f,
  -8.12012982e-03f, -2.44198591e-02f, 6.89899549e-02f, 9.34259295e-02f, 7.85318539e-02f, 1.67801939e-02f, -9.93694557e-05f, -6.77249487e-03f, 6.86439797e-02f, -6.03928268e-02f,
  -2.30128784e-02f, 6.21148273e-02f, 9.15823430e-02f, 9.46740210e-02f, 5.65955341e-02f, 6.79605529e-02f, 6.69138506e-02f, 4.69191149e-02f, -1.95526262e-03f, -4.54365537e-02f,
  -8.65300819e-02f, 7.80565366e-02f, -8.56790319e-02f, -3.39583158e-02f, 4.51617986e-02f, 3.60542424e-02f, 7.27724982e-03f, 9.26534384e-02f, -4.79097143e-02f, 8.29083994e-02f,
  -3.78924645e-02f, -9.37764440e-03f, 1.97032709e-02f, -8.11655745e-02f, 8.82517453e-03f, 3.53845060e-02f, -8.77889097e-02f, 1.23434858e-02f, -6.03699349e-02f, -5.36085404e-02f,
  -1.06943555e-01f, 4.62430008e-02f, 9.02921408e-02f, 8.61351043e-02f, 1.06071658e-03f, 7.32929185e-02f, -8.48109573e-02f, -8.75906497e-02f, -4.85084280e-02f, 3.91702913e-02f,
  -2.17127688e-02f, -5.62816020e-03f, 4.41739447e-02f, -5.56073859e-02f, 5.31863756e-02f, 3.72951515e-02f, -7.67705813e-02f, -3.45243700e-02f, -1.79216564e-02f, -8.98895040e-02f,
  -1.33525329e-02f, -1.09152071e-01f, -1.39812574e-01f, 6.16596453e-02f, 4.41125454e-03f, -1.25504702e-01f, 1.51641676e-02f, 3.53634953e-02f, -4.84533198e-02f, -1.16029426e-01f,
  5.11219084e-01f, 2.72195250e-01f, 2.16978222e-01f, -2.17442010e-02f, -1.71771049e-01f, -9.60570350e-02f, 1.39908176e-02f, 8.01363681e-03f, -9.98061597e-02f, 6.24645054e-02f,
  5.71141057e-02f, -1.30309850e-01f, -1.53959632e-01f, -5.22548659e-03f, -7.98904449e-02f, 4.88778912e-02f, -7.15691969e-02f, 9.21494514e-03f, -2.07499992e-02f, -1.43864721e-01f,
  -1.58104077e-01f, 6.98914602e-02f, 1.77374661e-01f, 8.35849941e-02f, 5.86105734e-02f, -7.91529715e-02f, 6.33144677e-02f, 1.97228014e-01f, 1.31252468e-01f, 1.09546185e-01f,
  1.70923710e-01f, 3.92811358e-01f, -3.24079186e-01f, -3.98085602e-02f, 7.82239735e-02f, 1.30314648e-01f, 1.12905158e-02f, 1.09664157e-01f, 5.91210313e-02f, -1.11186830e-02f,
  9.82203707e-03f, -2.65197791e-02f, 7.00926855e-02f, -4.12935689e-02f, -2.16816757e-02f, -3.33590545e-02f, 4.22387719e-02f, 1.82632491e-01f, -1.94806904e-02f, 1.51870549e-02f,
  -8.70202631e-02f, -2.09007673e-02f, 4.81388494e-02f, -5.37256151e-03f, -1.79364942e-02f, 1.04202349e-02f, 5.03661223e-02f, 1.37200868e-02f, 7.20774457e-02f, 1.70546785e-01f,
  -1.16698686e-02f, 9.23413336e-02f, 7.47293010e-02f, 2.01223865e-02f, 8.06497112e-02f, -1.00333065e-01f, 5.74127212e-03f, -2.22652704e-02f, -8.50371048e-02f, 6.36995360e-02f,
  2.79361010e-02f, 2.87818052e-02f, 2.91620530e-02f, 9.19648781e-02f, -2.20905282e-02f, -3.82691957e-02f, -1.53696407e-02f, -3.83325038e-03f, 2.30885800e-02f, -6.66834712e-02f,
  -3.08698998e-03f, 1.61345601e-02f, 3.16024348e-02f, 3.60778496e-02f, -4.32590768e-02f, 4.88413014e-02f, -4.69731800e-02f, -4.30774763e-02f, 7.84659535e-02f, 5.26290983e-02f,
  -2.33627841e-01f, -2.65019745e-01f, -4.33319435e-02f, -2.36701779e-02f, 1.24675175e-02f, 7.39277005e-02f, -1.94664802e-02f, 6.91974834e-02f, 5.82460910e-02f, -3.98213379e-02f,
  1.93289071e-02f, -2.00151168e-02f, 6.94083124e-02f, -4.95786890e-02f, -7.03450367e-02f, -9.60142463e-02f, -5.67130484e-02f, -1.26077577e-01f, 4.53547073e-05f, 5.16438112e-02f,
  -2.13472769e-02f, -1.21864170e-01f, -2.20137343e-01f, -1.17282078e-01f, -1.63002517e-02f, -2.54675806e-01f, -5.70753217e-02f, -1.02302954e-01f, -1.73473313e-01f, -1.49312183e-01f,
  -9.37430712e-04f, 1.61899105e-01f, 2.11449921e-01f, -8.70655105e-02f, 5.93205094e-02f, 1.69435397e-01f, 3.31521273e-01f, 5.22987843e-02f, -2.96853390e-02f, 8.99781287e-02f,
  1.54010952e-02f, -1.83583617e-01f, -8.72951224e-02f, -8.51843413e-03f, 4.60169502e-02f, 5.83594181e-02f, -4.64972481e-02f, -4.62520681e-03f, -7.94877764e-03f, 1.84574036e-03f,
  -2.99087749e-03f, -1.29958123e-01f, 4.47882488e-02f, -1.45512238e-01f, -1.48326635e-01f, -1.93766043e-01f, 8.97335857e-02f, 4.55013588e-02f, 9.05550420e-02f, -1.22619003e-01f,
  -2.66206656e-02f, 2.81518400e-01f, 1.30049037e-02f, -9.21364948e-02f, 9.29666236e-02f, -1.41182840e-01f, 4.42018248e-02f, -9.01264250e-02f, 2.03325897e-02f, -2.08788477e-02f,
  -3.76698631e-03f, 2.24437229e-02f, -7.07003102e-02f, -6.29867986e-02f, 5.54028451e-02f, -4.43090536e-02f, -5.35814129e-02f, -6.30524978e-02f, 3.85783836e-02f, -5.56905307e-02f,
  -1.45036340e-01f, 1.16177186e-01f, 1.01500630e-01f, 8.34530443e-02f, -8.78963694e-02f, -3.88849666e-03f, 2.19782945e-02f, 6.03226125e-02f, 3.19380052e-02f, -1.07454680e-01f,
  -6.54889047e-02f, -6.59053549e-02f, -2.01784838e-02f, 4.95109102e-03f, -5.59528172e-02f, 4.16797400e-02f, 9.73946322e-03f, -1.05675375e-02f, 4.70612524e-03f, 3.03344708e-02f,
  6.51078746e-02f, 3.01703308e-02f, 4.91581559e-02f, 2.03404073e-02f, -5.71762659e-02f, -8.90421867e-03f, 5.72054088e-02f, -2.19003055e-02f, 3.51587348e-02f, -3.96031849e-02f,
  3.68650109e-02f, 7.02867135e-02f, -7.44554400e-03f, 2.86638439e-02f, 3.76455337e-02f, -4.89724539e-02f, -6.48721606e-02f, -9.45476070e-02f, -4.57205549e-02f, 1.07417880e-02f,
  -2.13740543e-01f, 2.29576141e-01f, -1.32600948e-01f, 1.37207378e-02f, -2.71815602e-02f, 1.57813057e-02f, -2.19222493e-02f, 6.72851279e-02f, 3.85813452e-02f, 8.27063248e-02f,
  4.17122506e-02f, 7.29086474e-02f, 1.01879090e-01f, 7.06753433e-02f, -9.97926202e-03f, -5.40593415e-02f, -1.16122879e-01f, 3.05217579e-02f, -6.81616887e-02f, 5.32560647e-02f,
  -1.04939260e-01f, 2.25813538e-02f, -8.80624503e-02f, -2.20590197e-02f, -4.31163944e-02f, -5.22457696e-02f, 8.07989091e-02f, -1.03165016e-01f, -6.25405833e-02f, -8.17302689e-02f,
  9.18574706e-02f, -1.08740374e-01f, -7.25757703e-02f, -3.87420952e-02f, -1.91826820e-02f, 1.10315554e-01f, 1.06361791e-01f, 3.70672457e-02f, -3.21402811e-02f, -8.40003490e-02f,
  -1.04490250e-01f, -5.06305322e-02f, -1.51249811e-01f, 1.70141142e-02f, 1.99071616e-02f, 2.74981707e-02f, -1.36085272e-01f, -1.24710212e-02f, 7.72285387e-02f, 1.30616382e-01f,
  8.40631686e-03f, -1.54051855e-02f, -9.02921706e-02f, -4.01823372e-02f, -4.22536097e-02f, -4.61271666e-02f, -1.00515664e-01f, 1.87266823e-02f, 3.94052491e-02f, -1.57974228e-01f,
  -1.03204787e-01f, -6.64358810e-02f, -4.70126495e-02f, 4.20061164e-02f, -1.08843431e-01f, -6.02877066e-02f, -4.06750105e-02f, -8.80799890e-02f, 6.08383939e-02f, -5.81851676e-02f,
  5.82509339e-02f, 1.37432450e-02f, -6.38709962e-02f, 2.56499853e-02f, -7.56714195e-02f, 7.03084171e-02f, -4.30760570e-02f, 3.02368570e-02f, -7.17500895e-02f, -7.02216923e-02f,
  7.22175092e-02f, -6.99493736e-02f, -8.07978734e-02f, 4.80580665e-02f, 4.69743125e-02f, 1.23812724e-02f, -9.72072408e-02f, -6.33839890e-02f, -2.30403803e-02f, -2.80940942e-02f,
  -5.11064976e-02f, 1.03959225e-01f, 7.14864507e-02f, 5.76443188e-02f, 6.28467277e-02f, -4.06955667e-02f, -2.84742378e-02f, 8.63794312e-02f, 4.98912763e-03f, -6.35608360e-02f,
  5.97308576e-03f, -1.10929878e-02f, 1.34373652e-02f, 1.86089259e-02f, -6.61290661e-02f, -5.73537946e-02f, 1.40041132e-02f, 8.20676237e-03f, -7.36607760e-02f, -8.36025178e-02f,
  -9.15936604e-02f, 5.39307250e-03f, -3.52228433e-02f, 4.06999849e-02f, 5.98826371e-02f, 1.96595327e-03f, -4.75738347e-02f, 3.63150276e-02f, -4.21630554e-02f, -2.78571956e-02f,
  -1.13703184e-01f, -4.78886552e-02f, 5.30706681e-02f, 4.27060463e-02f, -8.42672959e-02f, 2.02732421e-02f, -1.07884295e-01f, 6.52723899e-03f, -1.47857703e-02f, -4.50989716e-02f,
  4.05693427e-02f, 1.45761687e-02f, -2.29626559e-02f, 2.41119210e-02f, 1.09223858e-03f, -5.37143387e-02f, 7.96071663e-02f, -5.45279272e-02f, -1.88599937e-02f, 2.90599205e-02f,
  9.47701000e-03f, -1.91170946e-02f, -4.60745543e-02f, 1.73113141e-02f, -1.72794778e-02f, -5.62054943e-03f, 5.57869091e-04f, 5.28324246e-02f, -1.87052488e-02f, -4.89844605e-02f,
  -2.10622460e-01f, -1.65199995e-01f, 1.60582215e-01f, -1.88021630e-01f, -1.06678843e-01f, 3.64441127e-02f, -7.79554248e-02f, -3.70257273e-02f, -1.47453949e-01f, -2.11210877e-01f,
  -1.30401522e-01f, -1.26128674e-01f, 9.57669914e-02f, 8.98158923e-02f, 1.64647311e-01f, 2.64489893e-02f, 4.70358655e-02f, 1.89626768e-01f, 2.16071188e-01f, 4.14771959e-02f,
  -3.02308239e-02f, -3.53688709e-02f, 9.54037979e-02f, 2.89269313e-02f, -2.12811336e-01f, 5.38402833e-02f, -7.76546523e-02f, -9.52985212e-02f, 7.07061449e-03f, -1.09440789e-01f,
  1.84095763e-02f, -1.97178394e-01f, -1.61758643e-02f, 2.27822307e-02f, -6.89711347e-02f, 3.15818191e-02f, -3.20011340e-02f, 4.98143770e-02f, 5.67288371e-03f, -6.88764527e-02f,
  -6.15122505e-02f, -4.03897986e-02f, -5.37650920e-02f, -8.44253302e-02f, -1.21880695e-01f, 5.36239706e-02f, 7.60628358e-02f, 1.06025361e-01f, -1.75363813e-02f, -1.05831891e-01f,
  -7.35457465e-02f, -1.48345783e-01f, -8.83976147e-02f, -3.88244651e-02f, -1.76949874e-02f, -2.28686556e-02f, -3.37122120e-02f, -2.04525571e-02f, 3.06907482e-02f, -1.07442185e-01f,
  -3.59416101e-03f, 4.39458730e-04f, -4.10962179e-02f, -2.98146307e-02f, 9.77008119e-02f, -4.61343937e-02f, 6.41829744e-02f, -6.66354448e-02f, 2.19912659e-02f, -2.86696367e-02f,
  4.57047634e-02f, 6.07531555e-02f, 3.08397673e-02f, -3.61383371e-02f, -1.13173444e-02f, 2.17377506e-02f, -2.50008702e-02f, 2.35160403e-02f, -2.00174227e-02f, -2.95247808e-02f,
  5.07465079e-02f, -3.23764980e-02f, -8.60138610e-02f, -2.53333207e-02f, 6.96921945e-02f, 8.15767422e-03f, -7.32532283e-03f, -2.93456297e-03f, 1.05424086e-02f, -8.69797021e-02f,
  1.49302306e-02f, 2.05981866e-01f, -1.77978396e-01f, -2.53133718e-02f, -7.86594003e-02f, 5.50647303e-02f, 4.31084707e-02f, 1.32095907e-02f, 3.04532703e-02f, 1.95746180e-02f,
  -6.54412210e-02f, -2.58690361e-02f, -2.74701994e-02f, -8.71581063e-02f, -6.83752149e-02f, -4.99571450e-02f, 3.04117575e-02f, 2.71388721e-02f, 7.12253675e-02f, -1.19673014e-02f,
  -1.58160534e-02f, 1.98843814e-02f, 4.22260314e-02f, -2.49751043e-02f, -1.35005251e-01f, 8.19418207e-02f, 9.36598331e-02f, 2.24698111e-02f, 6.83280751e-02f, -4.28875349e-02f,
  3.77690107e-01f, -2.83160537e-01f, 1.68248434e-02f, 5.78681305e-02f, 2.60394886e-02f, 1.34343237e-01f, -4.12735604e-02f, -6.62685791e-03f, -3.60134766e-02f, -1.09730907e-01f,
  -1.36871919e-01f, -1.37069315e-01f, -9.71085355e-02f, -6.95834830e-02f, -8.30180291e-03f, 4.52116542e-02f, -5.38600646e-02f, -9.68335290e-03f, 2.00297609e-01f, -2.55754422e-02f,
  -3.14312950e-02f, 6.71894848e-02f, 1.08231127e-01f, -9.42768827e-02f, -2.23185524e-01f, -4.02409993e-02f, -1.85010374e-01f, -3.43509875e-02f, -7.35805482e-02f, -2.20850930e-01f,
  -1.88785017e-01f, -6.44067004e-02f, 5.40084243e-02f, 8.91826004e-02f, -1.19877607e-01f, 5.05513847e-02f, 1.00139733e-02f, 6.52308688e-02f, 8.64140838e-02f, -6.70678243e-02f,
  -3.31306495e-02f, -5.56059321e-03f, -1.53540289e-02f, -1.51255801e-01f, 1.00404963e-01f, 5.61033748e-02f, -2.86678877e-02f, -9.18558799e-03f, -8.07527080e-02f, -1.38227716e-01f,
  -1.80729821e-01f, -1.45493988e-02f, 4.21657003e-02f, 1.37223518e-02f, 2.27814056e-02f, 5.93628325e-02f, -7.50524551e-02f, -1.12669624e-01f, 6.41211048e-02f, 5.13430387e-02f,
  4.62681875e-02f, -3.03805172e-02f, 3.08922250e-02f, 5.75644197e-03f, 1.22293700e-02f, 4.24785018e-02f, 3.15981060e-02f, 2.13824231e-02f, -2.73568672e-03f, 3.40564027e-02f,
  -3.18200104e-02f, 4.17182548e-03f, -1.54978214e-02f, -6.89113559e-03f, -4.70398813e-02f, -3.51750590e-02f, -3.59380320e-02f, -4.37984429e-02f, -3.49981561e-02f, 2.53947861e-02f,
  -1.15068713e-02f, 4.55333591e-02f, -7.15921596e-02f, -3.27518247e-02f, -3.82779390e-02f, 3.43414955e-02f, 2.84488872e-02f, -1.05402499e-01f, -6.22761473e-02f, -3.33403870e-02f,
  -2.89903320e-02f, -8.04063976e-02f, 5.55888116e-02f, -2.18728296e-02f, 2.60601528e-02f, -1.20483413e-01f, -1.00649305e-01f, 7.93674495e-03f, -4.09969501e-03f, -4.97934707e-02f,
  -1.17141716e-01f, 5.39940074e-02f, -1.19721860e-01f, -2.83780508e-03f, 1.69491976e-01f, 9.08878967e-02f, 5.45485765e-02f, 5.25358729e-02f, -3.94292064e-02f, -5.81966974e-02f,
  -9.55855995e-02f, 2.97839671e-01f, 2.72169948e-01f, 9.22466740e-02f, 1.58517808e-02f, 2.34175876e-01f, 1.68351997e-02f, 1.22629762e-01f, 1.78351611e-01f, 1.89707488e-01f,
  -9.41702873e-02f, 6.71023056e-02f, -8.10193941e-02f, -9.32336301e-02f, 2.13758759e-02f, -3.55227571e-03f, 7.06692487e-02f, 8.45083296e-02f, -9.88776684e-02f, 9.62668732e-02f,
  -7.25611392e-03f, -3.00455913e-02f, -1.44156486e-01f, -4.45313826e-02f, -4.65469100e-02f, -6.77664354e-02f, 3.96191627e-02f, -1.18249319e-01f, -1.01154193e-01f, -1.30906790e-01f,
  -1.41906381e-01f, -1.77024499e-01f, -3.58012877e-02f, -1.04456224e-01f, -1.97788179e-02f, -2.77305394e-02f, -2.11904272e-02f, 2.51412857e-02f, -8.37946981e-02f, 6.26911744e-02f,
  1.13079734e-02f, 7.01446757e-02f, -9.31105539e-02f, 1.68539379e-02f, 1.00350469e-01f, -9.40776337e-03f, 4.25353199e-02f, 5.52325659e-02f, 1.02134645e-01f, 8.04329813e-02f,
  6.89734966e-02f, 8.50944519e-02f, -1.94009934e-02f, -4.24047187e-02f, -1.18512344e-02f, -7.83493817e-02f, 3.83596346e-02f, -2.87409760e-02f, -1.57264620e-02f, 2.84488108e-02f,
  -1.41362837e-02f, -5.63186444e-02f, -3.06736231e-02f, 1.10244296e-01f, 1.01353094e-01f, 1.75832976e-02f, -9.35267936e-03f, 1.75818913e-02f, -1.63987540e-02f, 1.32153079e-01f,
  1.11585341e-01f, 8.66393894e-02f, -4.39807475e-02f, -5.48511138e-03f, -6.60665613e-03f, -6.98401853e-02f, 4.87981318e-03f, 9.93342623e-02f, -4.57199961e-02f, -4.43588272e-02f,
  2.18619201e-02f, -5.04688956e-02f, 3.59764323e-02f, 7.39828721e-02f, -3.36134098e-02f, -6.54251426e-02f, 2.73036547e-02f, 5.68434522e-02f, 3.96773294e-02f, -1.17808077e-02f,
  7.67339692e-02f, 2.26019789e-02f, 5.71641028e-02f, 7.88827538e-02f, 9.80697572e-02f, 2.24523209e-02f, 7.53908753e-02f, 5.82319908e-02f, 8.14679265e-03f, 6.59174994e-02f,
  -7.18487874e-02f, -1.02784380e-01f, -8.48352984e-02f, 3.23180445e-02f, 5.00051081e-02f, 4.79151979e-02f, 6.56504408e-02f, 1.12375885e-01f, -1.72500722e-02f, -1.68799479e-02f,
  -2.34966706e-02f, 5.67321442e-02f, -2.33777389e-02f, -4.84453253e-02f, 4.39482108e-02f, 9.96935293e-02f, -3.16553377e-03f, 2.45937938e-03f, 3.53727536e-03f, 1.08455330e-01f,
  4.39206837e-03f, 2.51914095e-02f, -6.46827519e-02f, -7.20521435e-02f, -1.94326285e-02f, -1.46153286e-01f, -4.42436524e-02f, -5.89415319e-02f, -8.86045247e-02f, 1.11886993e-01f,
  2.15603352e-01f, 1.43289883e-02f, 1.30256891e-01f, 7.01220632e-02f, -6.33289218e-02f, 3.49075608e-02f, -7.84640163e-02f, 5.15945442e-02f, 9.59187225e-02f, 5.06541459e-03f,
  -2.30155922e-02f, -1.23507537e-01f, -7.00172484e-02f, 1.88071188e-02f, 1.97225679e-02f, 8.28412473e-02f, -8.68809130e-03f, 1.63023755e-01f, 1.34923011e-01f, 5.93181923e-02f,
  -7.45514361e-03f, -3.80664803e-02f, 1.39214292e-01f, 1.11476660e-01f, -3.94751728e-02f, -4.11430113e-02f, 7.49262348e-02f, -5.89389205e-02f, -8.10856521e-02f, 8.91146362e-02f,
  5.87400347e-02f, 7.44870529e-02f, 1.12698711e-02f, -7.00205788e-02f, -3.01055005e-03f, -1.05545437e-03f, 4.85756174e-02f, 2.93092299e-02f, -5.10245934e-02f, 3.09385508e-02f,
  -1.20546874e-02f, 1.45485178e-02f, -1.01415195e-01f, -1.58643927e-02f, -2.49703228e-02f, -9.60332341e-03f, -6.64997473e-02f, 1.58484057e-02f, 9.69635397e-02f, 5.93441986e-02f,
  -1.42173722e-01f, 1.40098250e-02f, 3.15267444e-02f, 5.74921295e-02f, -1.44499382e-02f, 1.92229487e-02f, 4.63440046e-02f, -5.18801138e-02f, 4.00005616e-02f, 7.17774406e-02f,
  -6.66649863e-02f, 4.40309346e-02f, -8.41667056e-02f, -7.62589797e-02f, 4.19132113e-02f, -5.20871691e-02f, 4.31517065e-02f, 6.23203814e-02f, -2.03691907e-02f, 1.74402092e-02f,
  -6.23691790e-02f, -1.43407444e-02f, -7.24423304e-02f, 2.53919344e-02f, -8.22784752e-02f, 6.06315285e-02f, -2.28489619e-02f, 8.85401294e-03f, 2.18330007e-02f, -8.50154757e-02f,
  -9.42990705e-02f, -4.44612876e-02f, -5.20873666e-02f, 1.35112191e-02f, 5.36803491e-02f, -7.01467320e-03f, -5.16118202e-03f, -6.10812241e-03f, -3.80276404e-02f, 2.64518298e-02f,
  -1.24532305e-01f, -1.10440202e-01f, 8.59955996e-02f, 4.31261882e-02f, 2.83565391e-02f, 7.64760599e-02f, 6.28442764e-02f, -3.10003888e-02f, -7.24001080e-02f, 4.74773981e-02f,
  4.10162546e-02f, -3.46676670e-02f, -8.47199634e-02f, 1.64958034e-02f, -1.37208980e-02f, -3.82236429e-02f, 1.16093643e-03f, 2.42165942e-02f, -3.73620801e-02f, 8.36878195e-02f,
  -4.18921970e-02f, 5.32427952e-02f, 1.34428274e-02f, 6.00722656e-02f, -1.98493861e-02f, 8.78852382e-02f, 7.73357553e-03f, -4.19265740e-02f, 7.54185468e-02f, -7.06965029e-02f,
  1.49390981e-01f, 1.15468383e-01f, -1.25883669e-01f, 9.97537300e-02f, -7.56850466e-02f, -2.86284313e-02f, -9.19725820e-02f, -1.37213811e-01f, 7.82437548e-02f, 7.75239095e-02f,
  5.38136661e-02f, 4.48842533e-02f, -8.06879774e-02f, -1.46261358e-03f, -2.06053443e-02f, 2.55796891e-02f, 1.07690580e-02f, -7.29152113e-02f, -4.14159857e-02f, 4.03608866e-02f,
  8.63434225e-02f, 4.14360948e-02f, -1.49902469e-02f, 5.62538914e-02f, 3.09533905e-03f, 6.11372069e-02f, -2.82276068e-02f, 2.30013859e-02f, -6.55993745e-02f, 5.09098247e-02f,
  -1.19929560e-01f, -1.50354087e-01f, -1.63589492e-01f, 6.58319369e-02f, -9.76945832e-02f, -6.32175952e-02f, 3.81310582e-02f, 2.41408199e-02f, -1.13342546e-01f, -5.01269400e-02f,
  -9.99307930e-02f, 3.16921738e-03f, 5.26556186e-02f, -8.19893107e-02f, 7.01709166e-02f, 3.68324816e-02f, 3.67428027e-02f, -1.13673054e-01f, -1.37536988e-01f, 4.35779290e-03f,
  -3.00895255e-02f, 8.07802193e-03f, -1.60321146e-02f, -1.19394258e-01f, -7.88353011e-02f, -8.06922838e-02f, -8.63559842e-02f, -1.14098877e-01f, -1.50769398e-01f, -2.70502660e-02f,
  5.92907853e-02f, -8.94530863e-03f, -5.19074202e-02f, 1.11250887e-02f, 4.74639125e-02f, 2.35733595e-02f, 2.63107382e-02f, 9.19438228e-02f, -5.85180260e-02f, -5.56667671e-02f,
  -5.07038180e-03f, -6.75326809e-02f, -2.81660613e-02f, -5.46488166e-02f, 4.72367592e-02f, -5.90261258e-03f, -4.45169397e-02f, 4.66591120e-02f, -7.73999244e-02f, 4.78918329e-02f,
  -5.13094701e-02f, 3.52522321e-02f, 3.29182222e-02f, -1.89946182e-02f, -3.40231694e-02f, -3.16336658e-03f, -8.65005888e-03f, -6.23375922e-02f, 9.15184543e-02f, 3.31222080e-02f,
  5.27714528e-02f, -3.36984508e-02f, -5.87037951e-02f, -3.28491256e-02f, -8.70324373e-02f, -3.51633206e-02f, -1.26832984e-02f, -8.87054205e-02f, -1.85832009e-02f, 4.04777266e-02f,
  -4.74178381e-02f, -9.59704295e-02f, 5.41846119e-02f, -1.53621696e-02f, -7.86311403e-02f, 4.01280709e-02f, 2.36484781e-02f, -7.87275657e-02f, -7.86027759e-02f, 7.16389669e-03f,
  2.62188204e-02f, -4.84393463e-02f, 1.13824464e-01f, -2.65803058e-02f, 3.04366406e-02f, 6.74941465e-02f, -9.94096920e-02f, 7.01573789e-02f, -7.86214918e-02f, 1.68487623e-01f,
  2.08292171e-01f, -3.19268135e-03f, 7.87469894e-02f, 5.32928519e-02f, -9.55903083e-02f, -3.50911081e-01f, -4.24456030e-01f, -2.44531438e-01f, 7.29501098e-02f, 1.97180384e-03f,
  -6.81694597e-02f, -2.79415939e-02f, 3.86194848e-02f, -1.48976026e-02f, -1.91829666e-01f, -3.47677507e-02f, -7.18507916e-02f, 1.52634069e-01f, 2.77442634e-02f, -5.40911853e-02f,
  -6.17756695e-03f, 6.35707825e-02f, 1.57720253e-01f, 4.79840441e-03f, 9.61614177e-02f, -4.49077152e-02f, 1.05135582e-01f, 1.25289530e-01f, -9.39366594e-03f, 1.32013768e-01f,
  7.27661103e-02f, 4.36788164e-02f, -3.76417898e-02f, -2.97989454e-02f, 9.87039953e-02f, -2.21618935e-02f, 1.26773193e-02f, 1.38476402e-01f, -3.06471274e-03f, -5.07115424e-02f,
  1.98989045e-02f, -3.75947803e-02f, 7.60378540e-02f, 7.70601705e-02f, -4.39511277e-02f, -2.75057349e-02f, 5.03943264e-02f, 1.18001148e-01f, 1.80203356e-02f, 3.85045670e-02f,
  -3.96206081e-02f, -1.70486476e-02f, -5.18045947e-02f, -8.72483030e-02f, 6.90183342e-02f, -4.29390222e-02f, -4.03364450e-02f, -5.02211158e-04f, -1.95162427e-02f, -9.64349136e-03f,
  3.52940410e-02f, 5.84315285e-02f, 2.90114768e-02f, -7.16213211e-02f, -7.97091797e-02f, 3.98353785e-02f, -1.18756834e-02f, 2.27222499e-02f, -2.94870045e-02f, 1.11514209e-02f,
  -3.42822559e-02f, 5.22963032e-02f, -9.90346819e-03f, -1.33731412e-02f, 1.22768760e-01f, 5.32583520e-02f, 2.50115953e-02f, -4.93187606e-02f, 3.29067111e-02f, 3.19972299e-02f,
  1.48042226e-02f, 3.26323844e-02f, -2.66863219e-03f, 3.71974111e-02f, 3.04864049e-02f, -2.48418171e-02f, 2.50277631e-02f, 3.69560197e-02f, 5.52423187e-02f, -3.54963169e-02f,
  6.61489889e-02f, -3.12406756e-02f, 1.28852027e-02f, 8.01710761e-04f, -2.04182183e-03f, 8.29123147e-03f, 6.44248426e-02f, 1.77689716e-02f, 8.79122037e-03f, -5.24631627e-02f,
  -9.65952873e-02f, 2.62335949e-02f, 4.36505601e-02f, -8.87296535e-03f, 7.12339394e-03f, -1.89555231e-02f, -1.10171415e-01f, 1.42219753e-04f, -6.71802312e-02f, -4.32916358e-02f,
  -6.09568227e-03f, -1.75710917e-01f, -1.63328052e-01f, -1.22801825e-01f, -8.17124024e-02f, -4.35915440e-02f, -4.06774879e-02f, -1.30764425e-01f, -1.24123566e-01f, -2.07044691e-01f,
  1.85845360e-01f, 5.70713431e-02f, -1.21542498e-01f, 7.57054007e-03f, -1.64035976e-01f, -2.14113608e-01f, -1.01796605e-01f, -1.39976650e-01f, 8.33879784e-02f, 8.08462352e-02f,
  4.93643023e-02f, 2.73956917e-02f, -8.27070549e-02f, -1.58316158e-02f, -6.80247024e-02f, -9.41397250e-02f, -4.40098234e-02f, -2.13642642e-02f, -1.92552343e-01f, 6.71031028e-02f,
  9.32255462e-02f, 6.15012534e-02f, 6.22082613e-02f, 5.90364598e-02f, 1.07533522e-01f, 1.21822879e-01f, 2.51664538e-02f, 9.78323817e-02f, 1.05825335e-01f, 1.38018981e-01f,
  1.25807554e-01f, 1.42204180e-01f, -1.04483649e-01f, -1.05500417e-02f, -1.17178997e-02f, 1.90814752e-02f, -6.42374977e-02f, -7.33586773e-02f, -6.77350834e-02f, 2.82177441e-02f,
  2.12595798e-03f, -6.89845160e-02f, -5.28615713e-03f, -9.88859832e-02f, 7.83030093e-02f, 3.12029812e-02f, 7.05526036e-04f, -6.66380897e-02f, -3.06052789e-02f, 1.87191591e-02f,
  -8.71008411e-02f, 1.29039260e-02f, -1.49872795e-01f, -1.26878753e-01f, -1.82914990e-03f, 4.84649166e-02f, -2.54889708e-02f, 5.59572577e-02f, 4.94706817e-03f, 1.58145398e-01f,
  -5.58691807e-02f, 8.87306258e-02f, -5.54854199e-02f, -3.87435406e-02f, -4.85834144e-02f, 3.67369130e-02f, -2.11501736e-02f, 2.36562844e-02f, -8.29751641e-02f, -5.36717067e-04f,
  -2.06338149e-02f, 3.96201834e-02f, -4.78130504e-02f, -5.53910946e-03f, 5.22954278e-02f, 2.82962639e-02f, -2.67106257e-02f, -4.58027655e-03f, -5.72640859e-02f, 4.91731279e-02f,
  6.61344826e-03f, -7.38663971e-02f, 2.94691697e-02f, -5.18477857e-02f, 4.08316292e-02f, -2.39000488e-02f, 5.01152612e-02f, -6.60655648e-02f, 4.99375910e-02f, -3.96378078e-02f,
  2.17958782e-02f, -2.30869919e-01f, 7.17928559e-02f, -1.78168397e-02f, 1.23089710e-02f, 2.81746741e-02f, 1.40484497e-02f, 1.23314634e-02f, -4.65173572e-02f, 7.47840106e-02f,
  5.16410954e-02f, 6.32673874e-02f, 2.85576992e-02f, 8.17697421e-02f, 4.60596289e-03f, -2.08334927e-03f, 1.17514208e-01f, -6.70899376e-02f, 9.98775940e-03f, 1.04586639e-01f,
  4.61468585e-02f, 6.71295598e-02f, -7.75501281e-02f, -4.04683203e-02f, -6.62753657e-02f, -9.02807117e-02f, -3.18480395e-02f, 2.89037004e-02f, -1.94796678e-02f, 9.60940048e-02f,
  -1.80959314e-01f, -1.97847918e-01f, 1.18170358e-01f, -1.73940822e-01f, -1.41413033e-01f, -2.16046534e-02f, -1.42865390e-01f, -1.31316096e-01f, -7.37479189e-03f, -1.83755327e-02f,
  3.64117362e-02f, -1.56425480e-02f, 7.80427605e-02f, -2.00692210e-02f, -5.30543476e-02f, -1.18893005e-01f, -7.32251257e-02f, 1.24250270e-01f, 1.08200558e-01f, -1.83416028e-02f,
  5.55561781e-02f, -3.53462510e-02f, 1.21388631e-02f, 9.34975669e-02f, -1.33719176e-01f, -7.11705685e-02f, 4.45537493e-02f, 1.39153097e-02f, -9.35228169e-02f, -1.77608117e-01f,
  -9.67130810e-02f, -1.34005328e-03f, 1.31960437e-01f, 2.46620160e-02f, 2.77398154e-02f, 4.71832454e-02f, -2.46692654e-02f, -2.75100339e-02f, -2.88308747e-02f, 5.08735925e-02f,
  4.30943966e-02f, -1.38747841e-02f, -7.09308833e-02f, 5.96515834e-02f, 2.19680741e-02f, -1.01242639e-01f, 8.39562267e-02f, 1.45874973e-02f, 8.37690011e-02f, -4.84720506e-02f,
  2.73835193e-02f, -1.42087981e-01f, 1.19427415e-02f, 1.39457937e-02f, -2.34533772e-02f, 9.72113851e-03f, 1.56270508e-02f, -7.32824802e-02f, -3.91791314e-02f, -1.42813340e-01f,
  -1.68838724e-02f, -1.59127042e-02f, -2.58970670e-02f, -6.07796712e-03f, 1.91935115e-02f, 4.90514338e-02f, -9.69856605e-02f, 7.49577880e-02f, -5.47581576e-02f, 4.25337255e-02f,
  -1.29287327e-02f, 6.99096778e-03f, 2.70560049e-02f, -7.08626583e-02f, -1.38199236e-02f, 1.96824707e-02f, -5.74510545e-02f, -5.76090580e-03f, -3.43792979e-03f, -2.15919483e-02f,
  6.92143664e-03f, -4.21990044e-02f, -4.06074114e-02f, 1.11111261e-01f, 7.12513477e-02f, -3.79852578e-02f, -2.64161695e-02f, -3.98851894e-02f, 1.78205352e-02f, -6.01965711e-02f,
  -9.79807749e-02f, 1.74952492e-01f, -8.75016302e-02f, -1.17314175e-01f, 3.35487872e-02f, -4.31247614e-02f, -5.99463731e-02f, 1.06022589e-01f, -4.78483774e-02f, -3.69125828e-02f,
  -2.73583513e-02f, -6.70922324e-02f, -1.41369430e-02f, 3.60875614e-02f, 3.35980132e-02f, 2.35454757e-02f, -1.20569639e-01f, 5.53736724e-02f, 5.63155413e-02f, 5.06781675e-02f,
  -9.75583866e-02f, -1.14430398e-01f, -1.49402082e-01f, -8.82080197e-02f, -2.28107646e-02f, -1.00807413e-01f, -3.79844271e-02f, -5.96113391e-02f, -1.47287659e-02f, -1.88284829e-01f,
  1.99600622e-01f, 1.79338027e-02f, -5.51695097e-03f, 1.29603827e-02f, 4.23354246e-02f, 1.18619859e-01f, 7.68679380e-02f, 1.61785204e-02f, 1.32428603e-02f, -3.71466763e-02f,
  1.15093164e-01f, -4.05456796e-02f, 1.62319036e-03f, -5.17748632e-02f, -1.08058406e-02f, 6.21116348e-02f, -2.18808930e-03f, 5.54582588e-02f, 1.21253721e-01f, 7.26806000e-02f,
  2.60645542e-02f, -6.28578663e-03f, -3.89267690e-02f, -4.10049632e-02f, 1.09195732e-01f, 9.65485498e-02f, -4.97162454e-02f, 1.28606305e-01f, 9.45429876e-02f, 4.35394607e-02f,
  1.37381375e-01f, 3.36398743e-02f, -2.81382129e-02f, -1.74063607e-03f, 9.65133980e-02f, -5.52656762e-02f, -7.98566788e-02f, 4.24869172e-02f, -9.81649831e-02f, 7.57999271e-02f,
  -3.26600112e-02f, 8.12302902e-02f, -7.24101067e-02f, 2.88638454e-02f, 1.40498569e-02f, -9.55408067e-02f, -2.83773709e-02f, -8.98008794e-02f, -5.18363602e-02f, 4.00440060e-02f,
  -6.12101480e-02f, -5.96299917e-02f, -1.25762997e-02f, -3.56447585e-02f, -2.32021157e-02f, -5.78303114e-02f, -2.99848896e-02f, 7.92698935e-02f, 4.16065305e-02f, -8.28191042e-02f,
  5.11434935e-02f, 5.91262467e-02f, -3.79914902e-02f, 2.37051919e-02f, -7.31485337e-02f, -3.24706212e-02f, 2.09871568e-02f, 7.26817474e-02f, 9.91974724e-04f, 1.87114440e-02f,
  -6.66854903e-02f, 2.22992674e-02f, -5.86994812e-02f, -3.27417031e-02f, -3.28809507e-02f, 1.69816501e-02f, 3.76488827e-02f, -6.99210465e-02f, -2.48161126e-02f, -8.13345388e-02f,
  4.60764840e-02f, -1.11237681e-02f, 4.67257649e-02f, 5.80237210e-02f, 7.53912926e-02f, -3.74917760e-02f, -2.52308324e-02f, -3.65120061e-02f, 7.38659203e-02f, -6.87926188e-02f,
  6.44887611e-02f, -7.28157014e-02f, 8.29651505e-02f, 2.13737376e-02f, -3.03453151e-02f, -2.11519767e-02f, 7.26263374e-02f, -2.59509552e-02f, -3.34698297e-02f, 6.23712577e-02f,
  -5.44385053e-02f, 1.53033063e-02f, 4.24706936e-02f, -4.34083641e-02f, 6.68030465e-03f, 7.70865977e-02f, -7.11233914e-02f, 1.18963271e-02f, 4.76773456e-02f, -6.89601526e-02f,
  -4.47830819e-02f, -7.53187165e-02f, -3.18376794e-02f, -5.26184700e-02f, -5.67552224e-02f, -5.51595390e-02f, 1.18508982e-02f, 1.38317049e-02f, -8.76128450e-02f, 5.14926501e-02f,
  1.41105235e-01f, -6.02249727e-02f, -5.29457629e-02f, 5.40103242e-02f, 8.24122354e-02f, -1.12851582e-01f, -1.64061084e-01f, -1.32275790e-01f, 3.96911316e-02f, -2.43912241e-03f,
  4.77776490e-02f, -1.05334232e-02f, -1.50500098e-02f, 3.26156877e-02f, -1.32894479e-02f, -1.83352590e-01f, -1.15985908e-01f, -8.74142796e-02f, -1.37959749e-01f, 6.07486404e-02f,
  7.23122582e-02f, -2.21449547e-02f, -3.53441425e-02f, 7.40669891e-02f, -3.15509886e-02f, 1.10273719e-01f, 7.84202758e-03f, -3.45028080e-02f, 4.65833358e-02f, 6.75307959e-02f,
  4.13747132e-02f, 1.59964263e-02f, -7.49187618e-02f, 2.70364769e-02f, 2.97200475e-02f, 8.49083252e-03f, 6.04038350e-02f, 1.84521899e-02f, -4.57698032e-02f, 6.47190884e-02f,
  3.00816186e-02f, 7.79702216e-02f, 5.59895225e-02f, -7.10843597e-03f, -7.77803659e-02f, -1.17382538e-02f, -8.11190009e-02f, -3.86806205e-02f, -3.51038016e-02f, 3.41355167e-02f,
  9.99866650e-02f, -4.79993783e-03f, -8.46106037e-02f, -4.88887504e-02f, 5.38370060e-03f, -7.05466140e-03f, -5.28848432e-02f, -4.83003967e-02f, -9.99773815e-02f, -8.53083357e-02f,
  -1.66289687e-01f, -4.27771136e-02f, -1.04526699e-01f, -2.60883160e-02f, 2.22698376e-02f, 3.45796458e-02f, 1.84833501e-02f, -1.06487468e-01f, 2.69724359e-03f, -5.14199622e-02f,
  -7.15423226e-02f, -2.74827573e-02f, -4.50201705e-02f, -3.57921049e-02f, -1.62549294e-03f, 9.78883076e-03f, -4.26232405e-02f, -5.22137713e-03f, -5.44194430e-02f, -2.27333847e-02f,
  -3.82489106e-03f, -6.69618770e-02f, -4.26076911e-02f, -5.35657890e-02f, -1.07658260e-01f, -1.22444533e-01f, -8.50283727e-03f, -9.23985243e-02f, -9.21493322e-02f, -2.59806979e-02f,
  9.43552554e-02f, -7.84682184e-02f, 6.56423196e-02f, 3.98701839e-02f, 5.08089885e-02f, -2.59633316e-03f, 1.40504718e-01f, 4.53604907e-02f, -1.40992664e-02f, -1.15170795e-03f,
  -1.78530123e-02f, -1.57419648e-02f, 9.83034149e-02f, -5.65548316e-02f, -3.42832506e-02f, 9.66322981e-03f, -8.74921679e-02f, -4.19411622e-02f, 4.69498411e-02f, 1.14844078e-02f,
  -8.20907503e-02f, -3.19697075e-02f, 2.69141011e-02f, -8.65708366e-02f, -1.49379829e-02f, -7.55663961e-02f, -2.52390914e-02f, -3.01059652e-02f, -1.52889386e-01f, 1.79070327e-02f,
  -1.91471949e-01f, 6.54949322e-02f, 1.31668448e-01f, -5.19943237e-02f, -3.94274071e-02f, 2.71863677e-02f, -3.39523479e-02f, 1.31973496e-03f, -5.10670245e-02f, -1.53820426e-03f,
  1.46268420e-02f, -1.41554475e-01f, -1.70228817e-02f, 2.18289948e-04f, -1.95575356e-01f, -1.61905102e-02f, -8.16594735e-02f, -2.03566015e-01f, -1.99200973e-01f, -1.61873549e-01f,
  -1.96295172e-01f, -2.40081787e-01f, -1.76403582e-01f, -1.10714763e-01f, -3.69992480e-02f, -3.55411582e-02f, 2.44329013e-02f, 5.60795218e-02f, 9.18284953e-02f, 4.55426350e-02f,
  2.53705513e-02f, 5.77817932e-02f, 3.06900614e-03f, -5.42405210e-02f, -4.58414219e-02f, 5.18658645e-02f, 6.42467961e-02f, -1.96692832e-02f, 6.63710460e-02f, -7.87522793e-02f,
  -4.97548208e-02f, 2.46377829e-02f, -3.50440703e-02f, -7.42637068e-02f, -8.48249197e-02f, -9.61942077e-02f, 1.29281515e-02f, -7.73850381e-02f, -6.56195730e-02f, -8.85187760e-02f,
  3.73535715e-02f, -1.26382783e-01f, 6.26183450e-02f, -5.07863536e-02f, 6.42782450e-02f, -4.98567596e-02f, -2.35201474e-02f, -1.87037066e-02f, 1.52677717e-02f, 3.51613685e-02f,
  -2.25871149e-03f, -8.66476912e-04f, 1.87978789e-03f, 1.94698311e-02f, -9.65611339e-02f, 6.50994182e-02f, 7.79233724e-02f, -6.54052868e-02f, -3.30468528e-02f, -5.78319877e-02f,
  4.18845117e-02f, 1.89755522e-02f, 6.31990954e-02f, 4.92285118e-02f, 2.42592655e-02f, 1.92242078e-02f, -8.67568403e-02f, -4.87088934e-02f, 1.46006299e-02f, 7.35508502e-02f,
  4.56007384e-02f, -1.21386247e-02f, -2.58369800e-02f, 1.00629758e-02f, 8.19805190e-02f, 5.01615042e-03f, -5.60920872e-02f, -2.31029149e-02f, -7.57658929e-02f, -8.52216855e-02f,
  1.87062472e-02f, 1.05704986e-01f, -1.08178914e-01f, -1.65959951e-02f, 3.08658555e-02f, -4.64829318e-02f, 8.45844075e-02f, -1.41635295e-02f, 6.91925734e-02f, -7.69901499e-02f,
  -3.04124840e-02f, -8.78026767e-04f, -1.00039855e-01f, -9.45958421e-02f, -6.67946562e-02f, -1.36153055e-02f, -1.34658694e-01f, -6.42046425e-03f, 3.00961267e-02f, -1.21941812e-01f,
  1.02140922e-02f, -2.02647537e-01f, -1.97616801e-01f, -4.74447422e-02f, 7.33517855e-03f, -2.35833377e-02f, -3.42435576e-02f, -1.34234533e-01f, -1.61865205e-02f, -2.23681822e-01f,
  -2.98685014e-01f, -1.96599782e-01f, -2.48702094e-02f, -1.06654949e-02f, 1.33665219e-01f, 1.62350342e-01f, 1.35078058e-01f, 2.25244593e-02f, -3.30658592e-02f, -1.19762525e-01f,
  -7.87331462e-02f, -7.20423162e-02f, 1.25068577e-03f, 8.74532685e-02f, 9.60806608e-02f, 5.39195277e-02f, 1.64221779e-01f, 7.20148757e-02f, 5.59013337e-02f, 3.76796164e-02f,
  -6.28353357e-02f, 5.46173304e-02f, -6.75707534e-02f, 9.02515203e-02f, -7.89711848e-02f, -3.08036041e-02f, 5.25915027e-02f, 3.42377499e-02f, -2.74893567e-02f, 5.15901782e-02f,
  -1.99524179e-01f, -1.28658742e-01f, -1.17191086e-02f, -6.05388507e-02f, -1.06266811e-01f, 5.29611437e-03f, -4.06912901e-02f, 3.87937785e-03f, 3.10445130e-02f, -3.05335205e-02f,
  -1.06425248e-01f, 3.59108411e-02f, -2.51701996e-02f, 1.36283087e-02f, -7.88641572e-02f, -3.91017459e-02f, -1.60037205e-02f, -5.18883020e-02f, 3.71950343e-02f, -8.95110071e-02f,
  -3.70126404e-02f, -5.92928827e-02f, 2.13454366e-02f, -7.68719837e-02f, -1.10681199e-01f, 8.28502625e-02f, -5.40167131e-02f, 1.69788282e-02f, -5.56451231e-02f, -7.78922439e-02f,
  8.22891593e-02f, -8.95919837e-03f, -5.07241488e-03f, 3.70415933e-02f, -2.13691704e-02f, 1.59356575e-02f, 2.22602673e-03f, 9.66253132e-02f, 8.51484090e-02f, -4.78052311e-02f,
  -5.90456417e-04f, -2.42677573e-02f, 3.41851823e-02f, -8.83508027e-02f, 1.88951138e-02f, -5.69424741e-02f, 7.55628496e-02f, 2.96344631e-03f, -2.78060995e-02f, 1.88583378e-02f,
  -7.96926022e-03f, 4.00456367e-03f, 1.27281472e-02f, -1.42300660e-02f, 4.72391546e-02f, 2.06449367e-02f, -6.74133971e-02f, 5.89584513e-03f, -3.40029933e-02f, 6.65787533e-02f,
  -1.28043562e-01f, 7.10912943e-02f, -1.33329779e-02f, 4.10966352e-02f, 3.88033949e-02f, 4.81007211e-02f, -6.63381368e-02f, 5.13585918e-02f, -5.90705685e-03f, 1.20739499e-02f,
  1.84908099e-02f, 3.86427902e-02f, -5.94809763e-02f, 5.32227755e-02f, -7.09938584e-04f, -4.95128287e-03f, -6.48374856e-02f, 9.03119743e-02f, 7.37494901e-02f, -3.46067697e-02f,
  -2.81920657e-02f, 2.39021592e-02f, -7.15000331e-02f, -6.52540177e-02f, -7.56542087e-02f, -4.85196747e-02f, 3.97164114e-02f, 4.16346416e-02f, -8.34034011e-02f, -1.33874014e-01f,
  -2.63102621e-01f, -8.97089019e-02f, 1.19843580e-01f, -1.89848527e-01f, -5.60296662e-02f, 1.10211140e-02f, 6.50552064e-02f, -8.99391621e-02f, -1.88962802e-01f, -1.16173383e-02f,
  -3.36331986e-02f, -2.57487893e-02f, -5.82557656e-02f, 7.55173191e-02f, 1.28655117e-02f, -2.51275729e-02f, -6.42752051e-02f, -6.51682308e-03f, -6.59569055e-02f, -8.88383687e-02f,
  -2.26307325e-02f, -1.63325682e-01f, -1.05988950e-01f, -1.19328290e-01f, 7.54321832e-03f, -1.16688889e-02f, -6.94691315e-02f, -1.23695225e-01f, 3.19168493e-02f, -5.56369685e-02f,
  2.52646685e-01f, -1.09002620e-01f, -6.60199206e-03f, -1.52313318e-02f, -2.25035995e-02f, -6.79154396e-02f, 4.28803936e-02f, -8.76456872e-02f, -3.84846143e-02f, 8.19528662e-03f,
  -9.03382674e-02f, -4.74092998e-02f, -7.63460845e-02f, -4.53979187e-02f, -1.11023389e-01f, -7.29223415e-02f, 3.33517119e-02f, 4.96650971e-02f, -3.52533683e-02f, 5.18957339e-02f,
  2.18107998e-02f, -8.76512602e-02f, -9.48777050e-03f, -5.01747876e-02f, -6.73682764e-02f, 2.39765495e-02f, -1.57163036e-03f, -4.08821478e-02f, 3.48383598e-02f, 4.06878963e-02f,
  1.07546775e-02f, 6.75747097e-02f, -1.78111847e-02f, 2.07277555e-02f, -3.81545387e-02f, 8.54632184e-02f, 4.94112596e-02f, -1.68553106e-02f, 8.19543097e-03f, 1.15661584e-02f,
  -3.74751799e-02f, 5.18090539e-02f, -6.44731894e-02f, -4.98775691e-02f, 1.15455706e-02f, 9.48914792e-03f, 5.79838734e-03f, -2.72303764e-02f, 1.72187965e-02f, -8.13183337e-02f,
  3.86070670e-03f, -7.51505122e-02f, -6.48820922e-02f, 7.44482949e-02f, -9.12995636e-02f, -6.99218065e-02f, -6.71380386e-02f, -1.49030350e-02f, 1.81269813e-02f, -5.02827205e-02f,
  1.08927995e-01f, -9.19008479e-02f, 3.36475894e-02f, -9.73755866e-03f, -1.18939251e-01f, -7.25997612e-03f, -9.44481045e-02f, -8.84152502e-02f, -9.89184715e-03f, -2.12079585e-02f,
  -3.53287831e-02f, 1.32164741e-02f, 7.94572309e-02f, 8.24056864e-02f, 3.04792412e-02f, 7.51774088e-02f, -4.23620194e-02f, -2.41191406e-02f, 7.90259801e-03f, -2.73888037e-02f,
  3.57336178e-02f, -4.03308198e-02f, 1.48705989e-01f, 1.53320476e-01f, 2.45324224e-02f, 1.31859407e-01f, 9.27831605e-02f, 1.34183422e-01f, 1.16859049e-01f, 1.11844122e-01f,
  -2.68647969e-02f, -1.47452325e-01f, -1.52508110e-01f, 2.04080995e-02f, -3.18430513e-02f, 3.68502289e-02f, -6.24833070e-02f, 1.15963053e-02f, 7.77741298e-02f, 1.67488176e-02f,
  -8.99510272e-03f, -1.99937392e-02f, -1.35392144e-01f, -7.47952461e-02f, -1.84078023e-01f, -1.88085496e-01f, -1.76414385e-01f, -1.42835096e-01f, -3.55391651e-02f, 6.38741031e-02f,
  -5.04834279e-02f, -1.17887467e-01f, -8.13701749e-02f, -8.89894366e-02f, -1.14057355e-01f, -5.76340370e-02f, -2.19275340e-01f, -1.50443077e-01f, -1.17364019e-01f, -9.82358307e-02f,
  -6.87407032e-02f, 9.81774926e-02f, 1.82705726e-02f, -1.91867854e-02f, 2.59246733e-02f, -5.16314320e-02f, -6.18569069e-02f, 5.85584715e-02f, 3.67136709e-02f, -2.23698840e-02f,
  -5.96720800e-02f, 8.93422738e-02f, -9.89217162e-02f, 4.41591777e-02f, 7.59250447e-02f, -2.83236299e-02f, -2.62080804e-02f, -9.66241211e-02f, -6.23949133e-02f, 7.88134113e-02f,
  3.98563268e-03f, 3.88466939e-02f, -1.29839569e-01f, 1.77250914e-02f, -3.08248848e-02f, -5.00299782e-02f, -1.07344635e-01f, 6.50254190e-02f, -1.50755137e-01f, -1.04852334e-01f,
  2.19476763e-02f, -2.83251535e-02f, -4.93389517e-02f, -3.65852416e-02f, -6.67620674e-02f, 4.11413833e-02f, -7.63405785e-02f, 2.16197111e-02f, 1.51646500e-02f, -8.07635114e-02f,
  1.93431247e-02f, 5.87885901e-02f, 7.37073272e-02f, 2.36995257e-02f, -1.37555137e-01f, -1.07739598e-01f, 2.98655648e-02f, -1.47953123e-01f, -1.03200987e-01f, 4.85467240e-02f,
  -4.33603860e-02f, -7.12905079e-02f, 4.61490713e-02f, -7.24577606e-02f, 1.46937203e-02f, 1.99432261e-02f, 4.35658619e-02f, 9.23483744e-02f, 8.19181874e-02f, 3.65600772e-02f,
  -1.11666195e-01f, 1.01257802e-03f, -1.08618036e-01f, 5.94298448e-03f, 1.13085220e-02f, 6.08045086e-02f, -8.71200934e-02f, 5.53056411e-02f, -4.20089513e-02f, 8.84951875e-02f,
  2.05770619e-02f, 3.28362510e-02f, -1.12667546e-01f, -9.35500197e-04f, 1.43029504e-02f, -2.43128445e-02f, -6.84772572e-03f, -1.02522872e-01f, -1.07597858e-01f, -7.26979226e-02f,
  -1.18799560e-01f, -1.22237086e-01f, -5.54189384e-02f, -4.75979075e-02f, -1.49694299e-02f, -8.73558521e-02f, -1.24508113e-01f, -7.11078569e-02f, -9.36644673e-02f, -1.44712135e-01f,
  2.70708770e-01f, 3.42144072e-01f, 1.83703288e-01f, -3.51500399e-02f, -1.22710355e-01f, -8.58635362e-03f, 2.42648914e-01f, 1.15017250e-01f, -1.30140767e-01f, 5.42515405e-02f,
  -6.32651197e-03f, -1.80683792e-01f, -1.22408621e-01f, -1.18079238e-01f, 1.28619626e-01f, 1.77473307e-01f, 8.77690017e-02f, 9.41309929e-02f, -4.29298356e-03f, -9.98196080e-02f,
  -9.61776450e-02f, -6.65106922e-02f, 2.82146204e-02f, 9.11450833e-02f, 1.63665134e-02f, -1.35468632e-01f, 6.55751079e-02f, 4.05603508e-03f, 1.05102219e-01f, -3.71028706e-02f,
  3.44119687e-03f, 3.08602065e-01f, -2.04653829e-01f, -1.24528691e-01f, 2.52684373e-02f, 9.61488411e-02f, -2.13643461e-02f, -1.29436702e-03f, -7.92179778e-02f, -2.76075881e-02f,
  -9.12326425e-02f, 6.69206753e-02f, 2.55728024e-03f, -3.96851487e-02f, -5.07053826e-03f, 3.20694558e-02f, 8.13448057e-02f, 3.86680141e-02f, 6.15757480e-02f, 6.59685209e-02f,
  -5.32384478e-02f, -7.93892741e-02f, 4.13898230e-02f, 7.38714859e-02f, 1.02797687e-01f, -1.62663519e-01f, 1.13429144e-01f, -8.48453492e-03f, 9.07985643e-02f, 1.25255540e-01f,
  -2.85441335e-02f, 3.35006006e-02f, -9.08818329e-04f, 2.10507438e-02f, 3.95105481e-02f, -3.33188777e-03f, 1.11613637e-02f, -6.77289218e-02f, -2.99461242e-02f, -1.53278979e-03f,
  -7.94445723e-02f, -4.36583310e-02f, -4.30839621e-02f, -1.93263032e-02f, -5.66667004e-04f, 3.67654860e-02f, 1.09405003e-01f, -2.84224786e-02f, -5.02980426e-02f, 4.01098765e-02f,
  2.61196550e-02f, 3.92614398e-04f, -6.85743615e-02f, 3.41090411e-02f, -4.08007950e-02f, -3.75267975e-02f, 4.54406925e-02f, 4.03424539e-02f, -8.19169730e-02f, -2.81415433e-02f,
  -2.20523849e-01f, -5.12238778e-02f, -7.65229315e-02f, -1.26948189e-02f, -8.99236128e-02f, -1.75242871e-02f, -7.45840594e-02f, -4.66861390e-03f, 4.80498420e-04f, 7.77458623e-02f,
  -2.92781461e-02f, 4.14756611e-02f, 3.91470268e-03f, -1.18558519e-02f, -5.57325268e-03f, 3.42683420e-02f, -5.99233508e-02f, -4.85893749e-02f, 2.85039470e-02f, 4.78492528e-02f,
  -4.83297594e-02f, -5.58496714e-02f, -1.58427991e-02f, -4.66107018e-03f, -1.32274479e-01f, -1.84968963e-01f, -1.16099007e-01f, -9.69273522e-02f, -5.80893196e-02f, -5.43864369e-02f,
  6.32944405e-02f, -1.30607383e-02f, 2.20372081e-02f, -4.25926596e-02f, 1.13563880e-01f, 2.03732669e-01f, 2.46627852e-01f, 1.59766003e-01f, 5.89162745e-02f, 3.44156474e-02f,
  2.08173785e-02f, 6.19883351e-02f, 6.12357333e-02f, -8.16675052e-02f, -2.67189816e-02f, 9.22144502e-02f, 2.75503146e-03f, 6.66609555e-02f, 1.05447687e-01f, -7.53288716e-02f,
  -1.77239887e-02f, -1.33124053e-01f, 5.06511307e-04f, -2.30328105e-02f, -4.23551500e-02f, -7.74717107e-02f, -1.76079199e-02f, -2.54116897e-02f, -4.81793508e-02f, -1.06101045e-02f,
  -1.21709652e-01f, -1.74732646e-03f, 4.34988700e-02f, 4.72791083e-02f, -5.31349331e-02f, -7.23240003e-02f, -4.85085510e-02f, -1.01534620e-01f, -6.26924112e-02f, -8.22056085e-02f,
  -8.61903429e-02f, -8.00208375e-03f, 1.01621903e-01f, -7.64297545e-02f, 1.96451209e-02f, -4.42770720e-02f, 1.77903567e-02f, -4.28083874e-02f, -5.37260156e-03f, -8.42467248e-02f,
  -8.00928473e-02f, -8.96214988e-05f, 6.97568059e-02f, 6.97149783e-02f, -1.95738096e-02f, 2.59547140e-02f, -8.64990577e-02f, -8.93549472e-02f, -5.89445531e-02f, -1.13187283e-01f,
  2.86252256e-02f, -1.39864022e-02f, 5.02628274e-02f, -7.59521723e-02f, 4.60022688e-02f, 3.15969363e-02f, -5.06491512e-02f, -4.11785059e-02f, 2.74540335e-02f, -4.99344654e-02f,
  -5.55184372e-02f, 6.60810843e-02f, -4.35918905e-02f, -4.72176000e-02f, 6.59068599e-02f, 7.55761713e-02f, 1.94433164e-02f, 4.94246781e-02f, 1.12329721e-02f, 1.03797223e-02f,
  6.85036648e-03f, 2.60380823e-02f, 6.81654289e-02f, -7.49307573e-02f, 8.57528001e-02f, -4.99993339e-02f, 8.89764577e-02f, -2.94771157e-02f, -6.37008250e-02f, 4.20692265e-02f,
  -1.31940484e-01f, 4.92470600e-02f, 1.04065657e-01f, -5.61768897e-02f, 2.20854543e-02f, -8.77844729e-03f, 5.43861538e-02f, -1.65057890e-02f, -2.31099897e-03f, -5.09961210e-02f,
  1.02211908e-01f, -1.30766898e-03f, 1.86799616e-02f, 5.04683703e-02f, 1.27228480e-02f, 1.04559600e-01f, 1.42682279e-02f, 3.97708677e-02f, 3.51897404e-02f, -9.79022160e-02f,
  -4.47849482e-02f, 1.56616159e-02f, 9.41169709e-02f, -1.02489647e-02f, -1.76431499e-02f, 9.65100303e-02f, -5.18147908e-02f, 2.68251505e-02f, 1.46136329e-01f, 1.27450656e-03f,
  -3.68260592e-02f, -1.24784835e-01f, -1.44180834e-01f, 2.17294823e-02f, -4.12292629e-02f, -1.99301392e-01f, -3.30125481e-01f, -1.07008614e-01f, 6.28041998e-02f, -1.14508279e-01f,
  -6.96781278e-02f, 1.42875433e-01f, 5.66460267e-02f, -4.55707423e-02f, -2.52727062e-01f, -3.29863191e-01f, -1.94048762e-01f, -1.48538336e-01f, -4.53752689e-02f, -9.25019979e-02f,
  -5.40217049e-02f, 3.93929332e-02f, 1.19917225e-02f, 7.84071833e-02f, 7.52538294e-02f, 1.48496553e-01f, -2.55411975e-02f, 5.60182109e-02f, -9.24907811e-03f, 9.60716605e-02f,
  6.58047944e-02f, -1.94048695e-02f, 1.60376653e-02f, 6.92552254e-02f, 3.92611213e-02f, 5.48142008e-04f, -4.34333980e-02f, -4.55740392e-02f, -3.68689746e-02f, -1.02285102e-01f,
  -6.69698790e-03f, 8.38989168e-02f, 8.81906301e-02f, 2.27710642e-02f, -3.98877040e-02f, 1.27732884e-02f, -1.38377026e-03f, -1.05156884e-01f, 1.91144680e-03f, -1.75493006e-02f,
  -1.69410501e-02f, -8.53026845e-03f, 4.29206435e-03f, 2.55246516e-02f, 1.20654851e-02f, 2.51641516e-02f, -2.16258764e-02f, 1.08440623e-01f, -7.96628147e-02f, -1.66922268e-02f,
  -5.51003255e-02f, 7.19217137e-02f, 2.07246076e-02f, -1.93648301e-02f, 5.03023714e-02f, 5.54668829e-02f, -6.49735853e-02f, 3.96898203e-03f, -3.41161229e-02f, -6.29652888e-02f,
  4.78493907e-02f, 1.09087214e-01f, 5.88639341e-02f, -6.14563674e-02f, -1.70869399e-02f, 5.62453829e-03f, -4.51217629e-02f, 1.47672454e-02f, 2.82962490e-02f, 2.58030258e-02f,
  2.48199590e-02f, 2.90457252e-02f, 9.15666744e-02f, 5.63904196e-02f, -5.94064854e-02f, -5.13531752e-02f, -4.89663407e-02f, -2.30714139e-02f, 9.12660584e-02f, -2.25304645e-02f,
  1.64005496e-02f, -9.26835537e-02f, -9.39646959e-02f, -4.73057330e-02f, -8.52386467e-03f, 9.04291421e-02f, -4.34203297e-02f, -1.35209933e-01f, 8.25060233e-02f, -4.17058766e-02f,
  6.99710324e-02f, 4.44705077e-02f, 5.96832484e-03f, -6.80871382e-02f, 4.68683504e-02f, 7.73945972e-02f, -1.40038624e-01f, -9.09791067e-02f, 4.42800671e-02f, 3.65608223e-02f,
  -1.18030444e-01f, 3.81290680e-03f, 2.86234096e-02f, -2.84895189e-02f, 7.66204065e-03f, -7.42314477e-03f, 1.53159583e-02f, -5.48190624e-02f, -9.97736529e-02f, -1.81454092e-01f,
  -8.76424462e-02f, -4.75556999e-02f, -1.91152796e-01f, -1.69074699e-01f, -9.06431675e-03f, -5.77648636e-03f, 1.14220865e-01f, 5.12586720e-02f, 3.82838212e-02f, -8.44223499e-02f,
  -3.37876789e-02f, -1.15424141e-01f, -1.52925402e-01f, -4.87701744e-02f, -1.10016149e-02f, 2.92700045e-02f, -9.54216272e-02f, -1.29738495e-01f, 3.78208198e-02f, 2.26590578e-02f,
  -6.65440932e-02f, -1.22162767e-01f, -8.60572085e-02f, -1.10443324e-01f, 3.97073440e-02f, 5.40377479e-03f, -1.55421808e-01f, -1.30232245e-01f, -1.04063891e-01f, -5.33865206e-02f,
  -1.11640081e-01f, -1.68451086e-01f, 1.49220945e-02f, 2.41394974e-02f, -3.63686122e-02f, -9.70202405e-03f, -9.91423801e-02f, -2.12375745e-02f, -1.02987692e-01f, -8.47538281e-03f,
  -1.04860172e-01f, 7.59373009e-02f, -1.47592500e-01f, 3.15282457e-02f, -8.94796625e-02f, 1.16074644e-02f, -8.08850825e-02f, -4.29688431e-02f, 5.60849085e-02f, -5.78914545e-02f,
  4.03887928e-02f, -3.28086019e-02f, -3.13471407e-02f, 7.23652542e-02f, -5.54306097e-02f, -1.15784951e-01f, -5.77318668e-02f, -3.08503024e-02f, -1.34327332e-03f, -3.29137444e-02f,
  6.71858788e-02f, 1.65178105e-02f, -8.28227103e-02f, -7.80976787e-02f, 2.88731586e-02f, -3.80478869e-03f, 4.55545783e-02f, 3.98491845e-02f, 4.51045595e-02f, -7.64684612e-03f,
  8.74460638e-02f, 5.98310269e-02f, 5.19210622e-02f, -7.78290480e-02f, 8.18945765e-02f, 2.39746589e-02f, 6.02363385e-02f, 8.42320845e-02f, 4.59530167e-02f, 1.98112205e-02f,
  1.56181445e-02f, 8.07405487e-02f, -8.41796622e-02f, 5.56084551e-02f, 9.82767865e-02f, -2.65635140e-02f, 9.39278156e-02f, 3.22353542e-02f, 8.26627165e-02f, -6.39891699e-02f,
  1.38024827e-02f, 3.47368489e-03f, -6.76805601e-02f, -3.51142958e-02f, 9.49227344e-03f, -5.02932258e-02f, 4.56380099e-02f, -3.70423831e-02f, -4.52499539e-02f, 7.63736516e-02f,
  -7.86390081e-02f, 2.78693102e-02f, 4.41108197e-02f, -1.01418383e-01f, -9.20464098e-03f, 5.95117174e-03f, -4.85252449e-03f, 4.67094220e-02f, -4.82014716e-02f, 6.54671863e-02f,
  1.16811497e-02f, 3.10045406e-02f, -8.06657132e-03f, 3.55214179e-02f, 6.47634417e-02f, -1.14264630e-01f, -2.31951866e-02f, 7.63429627e-02f, -3.60999219e-02f, 6.89150244e-02f,
  -1.08370498e-01f, -7.77630322e-03f, -6.03250377e-02f, 2.51667798e-02f, -8.19277018e-03f, -7.14535788e-02f, 9.75859612e-02f, 6.63703904e-02f, -4.64519002e-02f, -6.71056286e-02f,
  -1.97426509e-02f, 6.83190003e-02f, -1.90140065e-02f, 6.79505691e-02f, -8.04270953e-02f, -5.02900817e-02f, -1.14175715e-01f, -1.26758307e-01f, 3.80742028e-02f, 1.30504012e-01f,
  7.12703764e-02f, -7.64756948e-02f, -4.24324861e-03f, -1.87264197e-02f, -6.53653294e-02f, -8.48829094e-03f, -8.09604153e-02f, 3.36709581e-02f, -2.85666790e-02f, 1.72215179e-02f,
  7.66885933e-03f, 3.34934657e-03f, 1.04394183e-01f, 1.27312383e-02f, 2.11917870e-02f, 2.04686411e-02f, -2.18858942e-02f, 6.58363700e-02f, 8.52199420e-02f, 6.21302007e-03f,
  -4.91979271e-02f, -4.00016345e-02f, 6.66438416e-02f, 4.23647352e-02f, 6.42119441e-03f, 1.01922266e-01f, -3.52685265e-02f, -1.77137665e-02f, 1.12653203e-01f, 9.09918845e-02f,
  1.03437051e-01f, -8.77822712e-02f, -1.48873832e-02f, 3.94033492e-02f, -2.59981528e-02f, 2.73462106e-02f, 4.49787900e-02f, 6.15091026e-02f, -5.67958616e-02f, 6.28073737e-02f,
  1.29070599e-02f, 2.11098953e-03f, 5.78244627e-02f, 2.11582128e-02f, -4.74334992e-02f, -2.94917859e-02f, -7.46093243e-02f, 6.29737694e-03f, 4.09957953e-02f, -1.31511968e-02f,
  5.02662323e-02f, -5.75945936e-02f, 2.42711268e-02f, -4.14572917e-02f, -3.77087556e-02f, -6.24759980e-02f, -6.06981404e-02f, -8.30481201e-02f, 1.38866843e-03f, 1.56126097e-02f,
  -8.04270729e-02f, 8.68891552e-02f, 5.27312830e-02f, 5.11348397e-02f, 2.69838702e-02f, -2.72873826e-02f, 1.58772301e-02f, 4.12127227e-02f, 1.33751817e-02f, -7.25926161e-02f,
  9.20457244e-02f, -4.31143120e-02f, -3.55907902e-02f, 1.01796657e-01f, -8.21040869e-02f, -7.40300044e-02f, -1.01109512e-01f, 2.22795252e-02f, 9.44173336e-02f, 5.11323437e-02f,
  4.88990247e-02f, -2.62437630e-02f, 6.56622052e-02f, 9.38152969e-02f, 7.99013078e-02f, 3.44685875e-02f, 1.12606265e-01f, -1.44176083e-02f, -3.24757025e-02f, 9.60863903e-02f,
  6.80198297e-02f, -2.65694931e-02f, 6.62332028e-02f, 1.64924245e-02f, 5.01300208e-04f, -8.96198601e-02f, 7.09147751e-02f, 4.14471468e-03f, 5.88458590e-02f, -6.53713048e-02f,
  1.41702015e-02f, -1.91159695e-01f, 2.61973679e-01f, 6.67635724e-02f, 6.28436431e-02f, 1.73376039e-01f, -1.03195691e-02f, 4.25633155e-02f, -1.13087827e-02f, -7.81640187e-02f,
  -1.24629520e-01f, -3.43706571e-02f, -9.59053710e-02f, -6.59651682e-02f, -5.89690171e-02f, 4.51271608e-02f, 1.08859606e-01f, 1.95852458e-01f, 2.06788674e-01f, 1.13075159e-01f,
  4.76507917e-02f, 3.51287611e-02f, 2.70461570e-02f, 4.82850932e-02f, -4.48574387e-02f, -5.78490458e-02f, 6.25960678e-02f, -1.21563360e-01f, -1.15436159e-01f, -1.15861900e-01f,
  1.03079759e-01f, -2.36359209e-01f, 5.32045215e-02f, -7.35568777e-02f, 1.65184289e-02f, -1.08340435e-01f, -2.44576447e-02f, 8.30480605e-02f, -9.80328396e-02f, -4.68304940e-02f,
  -9.75407586e-02f, -1.19548954e-01f, -1.00563101e-01f, 3.94688360e-02f, -4.91682254e-02f, 9.37540550e-03f, -1.24016963e-01f, 5.04564308e-02f, -3.39507833e-02f, -2.75792871e-02f,
  -1.59665823e-01f, -1.11621387e-01f, 6.65959939e-02f, 7.77773857e-02f, 1.75811891e-02f, -1.73871052e-02f, -4.75525670e-02f, -1.65954400e-02f, 2.12560147e-02f, -9.79517400e-02f,
  -9.09829289e-02f, 1.04151197e-01f, -6.36351928e-02f, -3.80008034e-02f, 5.34573533e-02f, 1.19017668e-01f, -5.71550578e-02f, 3.15515720e-03f, 3.28282043e-02f, -3.69866230e-02f,
  5.25212325e-02f, 6.49677068e-02f, 2.59418413e-02f, 5.24434373e-02f, 5.18264137e-02f, -8.51794146e-03f, 2.29051057e-02f, -2.32156180e-02f, -5.58726303e-02f, 7.18586519e-02f,
  6.55400380e-02f, 8.87986924e-03f, 4.35439348e-02f, 1.20916935e-02f, 3.08472980e-02f, 8.02882165e-02f, -3.67678516e-02f, 1.86442882e-02f, -2.41213245e-03f, 1.76382829e-02f,
  9.44775529e-03f, -7.54444897e-02f, 6.53109625e-02f, -6.09071329e-02f, -9.59800836e-03f, 2.78381072e-02f, -6.54128492e-02f, -2.18371768e-02f, 7.46579142e-03f, 1.36471651e-02f,
  -4.68381383e-02f, 1.06707588e-02f, -4.47095744e-02f, 9.77520123e-02f, 4.90068980e-02f, -4.36388701e-02f, -1.50476441e-01f, 9.87055376e-02f, 1.52643910e-02f, -2.15644501e-02f,
  -1.55609159e-03f, 1.71536056e-04f, 1.56697407e-01f, 1.01529434e-01f, 5.49027510e-02f, 1.04215063e-01f, 1.16912074e-01f, 1.10726066e-01f, 1.93806902e-01f, 8.45185965e-02f,
  1.07777998e-01f, -2.18838900e-02f, 1.23483367e-01f, 5.51012680e-02f, 5.61230965e-02f, 4.16017957e-02f, -9.66661796e-02f, -4.63910811e-02f, -7.31698200e-02f, 6.83571398e-03f,
  -1.69774875e-01f, -1.23307548e-01f, -1.22799508e-01f, -3.84466462e-02f, 1.74797121e-02f, 7.96159133e-02f, 7.81454369e-02f, 9.75609422e-02f, 9.93483812e-02f, -9.20447893e-03f,
  5.97682111e-02f, 1.31707162e-01f, 1.02418460e-01f, 6.15433529e-02f, 6.85209827e-03f, 7.69497678e-02f, -7.36486539e-03f, -6.81917220e-02f, 5.28966263e-02f, 1.06185935e-01f,
  9.74112377e-03f, -6.71510473e-02f, 5.73252439e-02f, 3.46401446e-02f, -4.72524986e-02f, -2.00123191e-02f, -4.76264320e-02f, 5.73956296e-02f, 5.43878637e-02f, -2.42571197e-02f,
  7.47208670e-03f, -6.17964081e-02f, 6.93272129e-02f, -5.30373938e-02f, 3.45883295e-02f, 2.22365968e-02f, -6.52817264e-02f, -5.95940761e-02f, -7.72844777e-02f, 5.87259941e-02f,
  -8.88653100e-02f, -1.02310739e-01f, 6.97489008e-02f, -1.69697776e-02f, -9.18571278e-02f, 5.59256226e-02f, -6.92383796e-02f, -1.81557313e-02f, -5.80171123e-02f, 4.74715568e-02f,
  -5.30671887e-02f, 3.29598673e-02f, -3.40245999e-02f, -1.47787062e-03f, -1.92062613e-02f, 3.26885544e-02f, 7.37017542e-02f, -5.64205348e-02f, -3.91122140e-02f, 2.69601140e-02f,
  9.33300331e-03f, 4.67238128e-02f, 1.86653621e-02f, -6.35927990e-02f, -8.68694112e-03f, -6.98571876e-02f, -4.37102094e-02f, 2.85938345e-02f, -6.56861216e-02f, 4.90944870e-02f,
  3.09517551e-02f, -2.17960048e-02f, 9.73380730e-03f, -7.83286989e-03f, 6.93105441e-03f, 4.01855037e-02f, 2.40433216e-02f, 6.83626346e-03f, 7.26717785e-02f, -4.95321639e-02f,
  -9.26329494e-02f, -3.08202999e-03f, 1.57448933e-01f, -2.54233479e-02f, -1.55984946e-02f, 7.56025165e-02f, 6.24407418e-02f, 7.30892345e-02f, 7.52921551e-02f, 8.19464624e-02f,
  -5.80237769e-02f, 7.09280074e-02f, -5.34720346e-02f, -6.47297725e-02f, 1.13641120e-01f, 8.65091234e-02f, -4.59342338e-02f, -2.17488408e-02f, 7.72707015e-02f, -7.35119134e-02f,
  3.21531631e-02f, 1.24305770e-01f, -1.99024733e-02f, 2.52313707e-02f, -6.50205389e-02f, 1.16719522e-01f, 6.60614893e-02f, -2.97445506e-02f, 3.87738086e-02f, 4.62863296e-02f,
  4.16022748e-01f, 5.83952218e-02f, -4.22492683e-01f, 1.80872098e-01f, -1.32828355e-01f, -1.44162968e-01f, -2.54614148e-02f, -2.30872203e-02f, 6.75596371e-02f, -3.27616185e-02f,
  -7.03025609e-02f, 3.39422710e-02f, -3.73848937e-02f, -7.68473148e-02f, -3.80485244e-02f, -2.17653170e-01f, -2.62393445e-01f, -1.05966128e-01f, -1.68280125e-01f, 6.85698316e-02f,
  3.94176086e-03f, 1.14638194e-01f, 8.93316194e-02f, -4.86129709e-02f, -2.39914153e-02f, -6.23402931e-02f, -1.19312346e-01f, -1.62509251e-02f, -1.37832582e-01f, -1.99294075e-01f,
  -2.80601591e-01f, 2.29060464e-03f, -1.25832587e-01f, 2.49927901e-02f, -5.66840433e-02f, 3.76173146e-02f, 7.21544912e-03f, -1.65525097e-02f, 2.22630445e-02f, -9.57098678e-02f,
  -5.21172136e-02f, -6.73918501e-02f, -1.16154812e-01f, -2.19284371e-02f, 1.09947687e-02f, -6.52608052e-02f, 4.28963937e-02f, -8.91650692e-02f, -1.37480542e-01f, -6.66272268e-02f,
  5.01879118e-03f, -1.12025112e-01f, -1.23628452e-01f, -4.05011177e-02f, -1.18035361e-01f, -5.33883087e-02f, -1.73670098e-01f, -9.22806635e-02f, -1.46682695e-01f, 1.02419024e-02f,
  3.60733569e-02f, -4.29446027e-02f, 1.53053645e-02f, 7.20806867e-02f, 5.49549796e-03f, 5.69087639e-02f, -7.16269985e-02f, -6.99500833e-03f, 5.08521497e-02f, -2.83692311e-02f,
  1.21292453e-02f, -9.71051529e-02f, 7.75922760e-02f, -5.59403710e-02f, 1.13870893e-02f, -3.83347534e-02f, -3.72074801e-03f, -3.11761685e-02f, 3.72562334e-02f, 4.33513150e-02f,
  5.51682189e-02f, -2.87468862e-02f, -1.67972967e-02f, -3.56217362e-02f, 2.68527903e-02f, -3.31192389e-02f, -7.87378848e-02f, -9.82954912e-03f, 2.60408130e-03f, -4.67919335e-02f,
  2.03028291e-01f, -2.05593362e-01f, 4.09873836e-02f, 1.06670940e-02f, -1.16439886e-01f, 2.52148975e-02f, -1.90379824e-02f, 4.62946966e-02f, -2.67619896e-03f, -4.54781055e-02f,
  -1.17504776e-01f, 4.90377881e-02f, -4.30734232e-02f, -3.41598280e-02f, -2.94683315e-02f, 4.55711223e-03f, -2.36381032e-03f, -2.49762628e-02f, 2.46564057e-02f, 1.55052030e-02f,
  3.15246545e-03f, 5.60316257e-02f, 1.19583264e-01f, -1.37622580e-02f, -1.89607758e-02f, 6.04474917e-02f, 6.47482974e-03f, 3.53136100e-02f, 6.28989786e-02f, 2.36312076e-01f,
  1.25081748e-01f, 8.20013359e-02f, 2.04374567e-01f, -3.33200209e-02f, 6.85212016e-02f, 2.64095008e-01f, 2.06874117e-01f, 2.69283969e-02f, -1.39592797e-01f, 1.28938705e-02f,
  2.07554130e-03f, -2.54259780e-02f, -1.12990640e-01f, -7.52973557e-02f, -3.87701243e-02f, 9.67861116e-02f, 9.78284106e-02f, 1.02935448e-01f, 5.58590740e-02f, 8.20027590e-02f,
  -6.02523685e-02f, 3.28660794e-02f, -9.10532922e-02f, -3.33351940e-02f, -1.24643408e-01f, -8.87563899e-02f, -7.79840024e-03f, 9.40393209e-02f, -3.43494006e-02f, -1.45132586e-01f,
  -2.33310442e-02f, 1.15423985e-01f, -1.21104298e-02f, -1.21791951e-01f, -4.22911830e-02f, 2.16236040e-02f, -4.95132282e-02f, -9.88607705e-02f, 6.57552555e-02f, -1.81359295e-02f,
  -6.50404841e-02f, 5.03378883e-02f, 4.05786419e-03f, -7.15742856e-02f, -4.00526337e-02f, 3.81353982e-02f, 3.81214619e-02f, 6.06316999e-02f, 2.95745321e-02f, -3.31509896e-02f,
  -8.80547985e-02f, 2.52208691e-02f, 1.77353621e-03f, 1.22637890e-01f, 9.05536637e-02f, 8.11763760e-03f, 1.44790467e-02f, -1.48561895e-02f, 1.07412569e-01f, -3.21281180e-02f,
  6.41837576e-03f, -7.29809422e-03f, 6.23316355e-02f, -6.46778122e-02f, -7.12978616e-02f, 1.13466578e-02f, 4.58726324e-02f, -5.29136471e-02f, 2.49147657e-02f, -3.79262120e-02f,
  1.01584472e-01f, -6.45033866e-02f, -3.99357677e-02f, -6.76285475e-02f, 6.06645308e-02f, 4.67089750e-03f, 8.63513052e-02f, -1.05127627e-02f, 1.00016430e-01f, 7.82962367e-02f,
  6.59831688e-02f, 1.00434229e-01f, 7.79036582e-02f, -4.99808639e-02f, -5.41390013e-03f, 1.05571590e-01f, 8.42300430e-03f, 1.06458133e-02f, 8.17069225e-03f, -5.79550536e-03f,
  -1.74741000e-01f, 1.40863448e-01f, -2.78016161e-02f, -3.21343206e-02f, 2.19669696e-02f, -1.24973431e-01f, 1.16589312e-02f, 6.09049061e-03f, 3.47861350e-02f, -4.13929038e-02f,
  1.03153922e-01f, -2.86664143e-02f, 2.62021311e-02f, -1.11378422e-02f, 6.77190796e-02f, 1.91194639e-02f, 3.49900201e-02f, -6.12456501e-02f, -1.05225161e-01f, -3.31869908e-02f,
  -5.52156605e-02f, 1.12801222e-02f, -7.86156729e-02f, -2.85140555e-02f, 4.18309681e-02f, -1.48920836e-02f, 3.38433497e-02f, -1.89763505e-03f, -4.82573137e-02f, -8.63041505e-02f,
  3.48515413e-03f, -1.05311396e-02f, -2.25459039e-01f, -3.15844710e-03f, -1.16909109e-01f, -7.86468089e-02f, -1.81366615e-02f, 1.48639858e-01f, -1.96595695e-02f, -8.87998268e-02f,
  -2.14552432e-02f, -1.66911806e-03f, 5.51049262e-02f, -1.21036626e-01f, -6.43560812e-02f, -1.82091758e-01f, -1.98978260e-01f, -1.53860882e-01f, -1.21333905e-01f, 2.61130407e-02f,
  9.72315483e-03f, 4.19606343e-02f, 3.84722324e-03f, 8.11487287e-02f, -1.93193741e-02f, -3.36506553e-02f, -6.54398724e-02f, -1.02278747e-01f, -1.16901889e-01f, -1.34074524e-01f,
  -1.69373229e-01f, 4.52852212e-02f, 6.60216957e-02f, 1.08371705e-01f, -4.94398288e-02f, 1.19655088e-01f, 1.00832041e-02f, 4.95278426e-02f, 1.36663038e-02f, 1.20130852e-02f,
  3.30109447e-02f, -2.13103108e-02f, 9.77907628e-02f, 8.76707435e-02f, 9.92725566e-02f, 6.95345807e-05f, 1.41961545e-01f, 2.65726559e-02f, 7.02996254e-02f, -3.02102156e-02f,
  6.10529892e-02f, -9.48500931e-02f, -8.83506611e-02f, 4.90401536e-02f, -5.67206293e-02f, 3.33966352e-02f, 7.33116176e-04f, 6.96569011e-02f, -5.36772907e-02f, 1.36006936e-01f,
  -1.03830464e-01f, -8.40034336e-02f, 1.32407583e-02f, 4.40563075e-02f, -7.17684627e-04f, -6.43480048e-02f, -9.75354947e-03f, -6.29089624e-02f, -4.10039052e-02f, 7.50482753e-02f,
  3.96232978e-02f, -7.61038437e-02f, -4.73469123e-02f, 3.46700773e-02f, 2.72786058e-02f, 2.87245470e-03f, -1.52009204e-02f, 1.79218780e-02f, -3.00302766e-02f, 6.61869301e-03f,
  8.21247473e-02f, -8.82339180e-02f, 8.93086791e-02f, 6.11936189e-02f, -8.05244297e-02f, 2.79121171e-03f, -1.10844336e-02f, -3.22449282e-02f, -6.57655746e-02f, -3.70655884e-03f,
  1.30238041e-01f, -1.13550790e-01f, -5.62464297e-02f, 3.28921489e-02f, 6.11037090e-02f, -1.56632401e-02f, 1.49747860e-02f, -2.77817175e-02f, -6.90701380e-02f, 6.17510565e-02f,
  3.74175161e-02f, 8.27095956e-02f, 7.53523558e-02f, -3.85242775e-02f, 5.85877560e-02f, 3.27657759e-02f, 7.23538175e-02f, -2.75954250e-02f, -6.52641952e-02f, 6.17432147e-02f,
  8.56774226e-02f, 2.85764900e-03f, 1.03601225e-01f, -3.50677297e-02f, -5.02686612e-02f, 8.84813548e-04f, 1.35897938e-02f, 1.11762524e-01f, -3.19159813e-02f, 3.41526903e-02f,
  2.73351371e-01f, -2.76425242e-01f, -2.49803945e-01f, -3.99060622e-02f, -1.50886014e-01f, -2.01914668e-01f, -3.82182717e-01f, -1.89824756e-02f, -3.34111713e-02f, -2.50055850e-01f,
  -1.06545836e-01f, 2.17029959e-01f, 1.83946133e-01f, 1.24473087e-01f, 6.84221312e-02f, -3.07662755e-01f, -1.48382455e-01f, 1.41251445e-01f, 2.55718708e-01f, -4.26536053e-02f,
  -1.01591289e-01f, 1.31468587e-02f, 1.17761642e-01f, 5.73906973e-02f, -1.07033238e-01f, -4.22936939e-02f, -9.79160368e-02f, -2.30349158e-03f, -1.28320336e-01f, -2.12084085e-01f,
  -2.51282364e-01f, -7.22934455e-02f, 5.95267117e-02f, 1.40905768e-01f, 4.61834371e-02f, 1.83490105e-02f, 3.95215582e-03f, 5.75365238e-02f, 5.28035359e-03f, -1.00981109e-01f,
  -7.11483136e-02f, 3.42118591e-02f, 7.60113448e-02f, -1.12883812e-02f, -4.44405861e-02f, -7.00919107e-02f, -5.45374602e-02f, -3.99624836e-03f, -5.56404777e-02f, -9.08751739e-04f,
  -1.28742203e-01f, -1.18179530e-01f, 8.70466791e-03f, -5.52370325e-02f, 2.67772581e-02f, 1.05523333e-01f, -7.26677477e-02f, -1.41067982e-01f, 2.63216090e-03f, -2.16620475e-01f,
  -3.25736552e-02f, 5.50048985e-02f, -1.00763865e-01f, -5.08422516e-02f, 7.78924674e-02f, -7.05233812e-02f, 1.27175811e-03f, 5.49689867e-02f, 6.53197914e-02f, -1.50448084e-02f,
  4.05851975e-02f, -2.69888956e-02f, 8.43037367e-02f, 4.46106791e-02f, 6.03286326e-02f, 1.48282703e-02f, 1.59882419e-02f, 3.34658064e-02f, 9.56193432e-02f, 6.59059500e-04f,
  1.74783133e-02f, 1.84328984e-02f, -3.88179831e-02f, 8.14241394e-02f, -2.36765482e-02f, -7.49071538e-02f, 2.12953682e-03f, 5.90424277e-02f, 8.45655501e-02f, 4.81555536e-02f,
  1.21295542e-01f, 2.14431897e-01f, -8.32888782e-02f, 3.11662443e-02f, -3.03711537e-02f, -7.90953636e-02f, -8.50571096e-02f, 1.75605677e-02f, 7.03675076e-02f, 3.57479043e-02f,
  7.89656416e-02f, -1.29733712e-03f, -8.59447718e-02f, -1.16294965e-01f, 8.99635404e-02f, -2.56199837e-02f, -5.94771057e-02f, -3.15361023e-02f, 1.16848387e-02f, -1.26132861e-01f,
  1.09904222e-02f, 2.83816718e-02f, 1.05488129e-01f, 1.11594096e-01f, 1.54276183e-02f, 1.82811484e-01f, -7.79425278e-02f, -1.06086016e-01f, 4.05789167e-02f, -7.98352435e-02f,
  -1.54673189e-01f, 2.98801839e-01f, 2.03099161e-01f, -8.81122574e-02f, -1.93239935e-02f, 1.53611228e-01f, 1.76805004e-01f, 5.94842471e-02f, -5.22890277e-02f, 6.91095181e-03f,
  9.63033140e-02f, -2.33010262e-01f, -1.47161797e-01f, -1.80314422e-01f, -4.38486151e-02f, 4.77032224e-03f, -7.06769899e-02f, -2.35500932e-01f, -3.17774355e-01f, -2.36837298e-01f,
  -1.64643556e-01f, -2.98297226e-01f, -2.92041212e-01f, -4.97590974e-02f, -1.35663584e-01f, -1.57747790e-01f, 1.51205703e-03f, -3.58493663e-02f, 1.37637749e-01f, -3.85803543e-02f,
  -1.68258566e-02f, 1.46825761e-01f, -1.33558691e-01f, -6.10233955e-02f, 4.83880043e-02f, -4.37612794e-02f, -8.65209568e-03f, -6.34168694e-03f, -1.29303457e-02f, -6.27573580e-02f,
  8.18146542e-02f, -8.66930559e-02f, -9.28956345e-02f, -5.51255643e-02f, 2.02480890e-02f, -9.10604000e-02f, 3.34684364e-02f, -8.00697505e-02f, -2.53608674e-02f, 1.02127962e-01f,
  9.12954882e-02f, 1.80556297e-01f, 8.63305107e-03f, 2.70034606e-03f, 8.93415287e-02f, 3.35165635e-02f, 1.10624194e-01f, 1.29185572e-01f, 1.06817961e-01f, 5.05239144e-02f,
  3.68722305e-02f, 7.04783499e-02f, 1.20645319e-03f, -2.21713297e-02f, -3.21390526e-03f, -8.24272912e-03f, -1.47506781e-03f, 1.04459403e-02f, -1.83418691e-02f, -1.94708332e-02f,
  8.51752330e-03f, 8.80200788e-02f, -6.96759969e-02f, 2.91629583e-02f, 4.04287241e-02f, -1.27565460e-02f, -2.25470606e-02f, -3.26549821e-02f, 3.56457531e-02f, -5.18810861e-02f,
  -9.11266804e-02f, 8.46921131e-02f, 2.52422895e-02f, -8.44917744e-02f, 1.29792631e-01f, 1.33046061e-02f, 4.93354276e-02f, -3.62956636e-02f, 4.39912453e-02f, -8.61787498e-02f,
  -2.79346317e-01f, 1.05178967e-01f, -5.56367189e-02f, -1.55801833e-01f, 7.68830925e-02f, 1.30969156e-02f, 1.02475546e-01f, -4.22911979e-02f, 6.48309290e-02f, -2.78578158e-02f,
  -3.78306098e-02f, 1.07410392e-02f, -2.67645437e-02f, -5.75947277e-02f, -1.51541099e-01f, -1.19462162e-02f, 8.40366483e-02f, -8.57299790e-02f, 2.99251657e-02f, 9.53069627e-02f,
  1.15305163e-01f, 5.07554561e-02f, -1.34772047e-01f, -5.81491441e-02f, 2.04678923e-02f, -1.45375088e-01f, -1.79048162e-02f, -3.37307043e-02f, 6.85022585e-03f, -1.54673263e-01f,
  1.50188923e-01f, 1.66326746e-01f, 1.42555937e-01f, 1.83572173e-01f, 2.10924566e-01f, 2.21643403e-01f, 1.78510323e-01f, 1.48039721e-02f, 7.98110887e-02f, 1.73116669e-01f,
  1.32414073e-01f, 8.51453319e-02f, 1.37563094e-01f, 7.29942396e-02f, 9.43304747e-02f, -1.79196130e-02f, 2.20275354e-02f, -6.49707019e-02f, -4.49910946e-02f, 1.03977561e-01f,
  9.62127000e-02f, 8.74548778e-02f, 8.95560011e-02f, -1.02429325e-02f, 5.66284247e-02f, 5.43454140e-02f, -2.86339968e-02f, 1.04757845e-01f, 2.47273855e-02f, 1.16119860e-02f,
  1.09289013e-01f, 1.22462884e-01f, 3.83573584e-02f, 2.07716483e-03f, -2.08641831e-02f, 1.30715501e-03f, -2.92435046e-02f, -8.29741359e-02f, -4.89184223e-02f, -1.22252263e-01f,
  -7.00951293e-02f, -1.26676187e-01f, 5.96185103e-02f, -1.05538100e-01f, -1.15279155e-02f, -1.14188135e-01f, -9.55350846e-02f, -1.38062034e-02f, 2.84559447e-02f, -1.13911457e-01f,
  -4.29464951e-02f, -4.78143245e-03f, 1.36508532e-02f, -6.44832104e-02f, -3.50667052e-02f, 4.52738479e-02f, 5.72241396e-02f, -6.54279515e-02f, -6.36149496e-02f, -5.14216628e-03f,
  1.66248772e-02f, 3.95469181e-02f, 1.12758458e-01f, 5.99208549e-02f, -2.45447177e-02f, -4.89523774e-03f, 1.77559741e-02f, -6.05130345e-02f, -1.23705603e-02f, -3.62281762e-02f,
  5.56036457e-03f, 4.61238287e-02f, -7.18640834e-02f, 1.35140568e-02f, -6.94057941e-02f, 7.76896253e-02f, -7.46882111e-02f, 4.85948361e-02f, -3.48316617e-02f, 5.45068234e-02f,
  4.59250808e-02f, -6.50480809e-03f, 4.99701221e-03f, -7.33778179e-02f, -1.90042816e-02f, 4.78886180e-02f, -1.95946191e-02f, -7.60880187e-02f, 6.89782128e-02f, -9.28609744e-02f,
  -2.22320464e-02f, 1.10521056e-02f, -8.01126845e-03f, -8.62715468e-02f, 8.05746019e-02f, -3.38363796e-02f, 9.81170610e-02f, -5.71200214e-02f, -7.35263824e-02f, 1.72884911e-02f,
  3.35360058e-02f, 5.91389649e-02f, 4.33267690e-02f, 2.15350874e-02f, -9.22890380e-02f, -8.87474343e-02f, -1.05802462e-01f, -1.08331786e-02f, -9.83691067e-02f, -4.84925210e-02f,
  -5.58002014e-03f, -6.71660434e-03f, -9.88480002e-02f, 2.03652941e-02f, -9.39035565e-02f, -5.99900410e-02f, -4.38595563e-02f, 2.68599344e-03f, -4.24718000e-02f, -4.59797308e-02f,
  -1.31064067e-02f, 3.58147882e-02f, -6.74458966e-02f, 9.79164243e-02f, -3.99159268e-03f, -5.41026667e-02f, -2.92993113e-02f, -2.91743260e-02f, 8.16299394e-02f, -4.10422012e-02f,
  3.69204655e-02f, 1.12809196e-01f, 8.98045823e-02f, 6.05768934e-02f, -5.43695539e-02f, -7.96977729e-02f, 2.93674879e-03f, 5.61796054e-02f, 2.38961633e-02f, -6.66247904e-02f,
  4.87364754e-02f, 1.09661862e-01f, 7.40154237e-02f, 3.17204557e-02f, 1.19621143e-01f, 9.29421633e-02f, -2.31593288e-03f, 1.11069903e-01f, -4.12180573e-02f, 4.31098528e-02f,
  7.09976628e-02f, 6.07058294e-02f, -4.98963110e-02f, 9.66020301e-02f, 1.01228707e-01f, 1.16359316e-01f, 8.31345990e-02f, 1.35484058e-02f, 9.38659906e-02f, 5.48697682e-03f,
  -1.49935707e-02f, 4.78241220e-02f, -6.29032627e-02f, -2.77341008e-02f, 8.05270523e-02f, -1.30546708e-02f, -1.69887170e-02f, -3.51427756e-02f, 3.37542742e-02f, -6.11750260e-02f,
  1.15640096e-01f, -6.26907721e-02f, 2.91553102e-02f, -2.05851276e-03f, -1.03056207e-02f, 9.49582458e-02f, 5.21899089e-02f, 2.02147923e-02f, -3.33665274e-02f, 9.52779651e-02f,
  -9.46356133e-02f, 7.18407426e-03f, -5.69780581e-02f, -4.32115002e-03f, -1.09238364e-02f, 3.42355408e-02f, -7.69830644e-02f, 2.98488736e-02f, 1.84931513e-02f, -7.57682174e-02f,
  3.88211310e-02f, 6.03673309e-02f, -7.55610764e-02f, -7.62471743e-03f, 6.17113523e-02f, -1.36775607e-02f, -1.18512893e-02f, -5.42029962e-02f, -3.52956429e-02f, -6.10652715e-02f,
  1.39427576e-02f, -4.58044792e-03f, -9.48804170e-02f, -1.07186303e-01f, -3.56908999e-02f, 1.69729330e-02f, -7.55655542e-02f, 2.57604271e-02f, 2.51182336e-02f, 1.23256138e-02f,
  -1.78728835e-04f, 2.61158831e-02f, -1.00795375e-02f, -3.71900038e-03f, 2.85778027e-02f, -5.67179509e-02f, 9.56833269e-03f, -2.84077879e-02f, 2.04825457e-02f, 5.31590059e-02f,
  -6.75089937e-03f, -2.23666080e-03f, 3.65108140e-02f, -4.21693772e-02f, 6.40458614e-02f, 2.49899980e-02f, 2.65374947e-02f, -9.39667970e-02f, 5.33729270e-02f, -1.60875078e-02f,
  4.57542054e-02f, 1.21959895e-02f, -1.09417021e-01f, -1.92302726e-02f, 3.04994769e-02f, 1.38715459e-02f, 6.31684065e-02f, -6.97774696e-04f, -4.61212918e-02f, 4.92296070e-02f,
  -2.97753811e-01f, 6.95111230e-02f, -3.98896188e-02f, -5.67484200e-02f, 7.81281441e-02f, 2.40074415e-02f, 1.31053582e-01f, -8.61425623e-02f, -3.96045819e-02f, -5.87220024e-03f,
  3.65231745e-02f, 7.70113915e-02f, 4.19878364e-02f, 7.17559382e-02f, 5.21980189e-02f, 5.80527000e-02f, 8.86099339e-02f, -4.60135192e-02f, -6.08177036e-02f, 2.43796036e-02f,
  1.74665928e-01f, 5.29262312e-02f, -1.07090227e-01f, -7.85316825e-02f, 5.47568463e-02f, 4.72729281e-02f, -6.49555847e-02f, 9.12664458e-02f, 8.86700600e-02f, 2.18584284e-01f,
  -1.00036748e-01f, -8.06610286e-02f, -1.50707979e-02f, -1.84756126e-02f, -9.78148133e-02f, 4.40650843e-02f, 3.63957696e-02f, -2.69675013e-02f, -6.83604926e-02f, 3.03693041e-02f,
  -4.97202799e-02f, 5.98352291e-02f, 5.38779050e-02f, 4.03749384e-02f, -8.53778347e-02f, -1.30515307e-01f, -1.93896762e-03f, -9.19745862e-02f, 6.03439379e-03f, 2.61473600e-02f,
  2.28779707e-02f, 2.98465136e-02f, -1.43595189e-01f, -4.99164918e-04f, -3.89826111e-02f, -6.26580194e-02f, -6.54504672e-02f, -1.28714284e-02f, -8.01775381e-02f, -1.28731698e-01f,
  3.51009890e-02f, -6.66379556e-02f, 2.22785641e-02f, 5.92412660e-04f, -3.26244696e-03f, -5.53740701e-03f, 9.94516239e-02f, 5.63170053e-02f, -2.04711743e-02f, -6.67883605e-02f,
  2.47725360e-02f, 1.14631094e-02f, 3.13957296e-02f, -5.30994721e-02f, 6.33126125e-02f, 5.38584217e-02f, 1.12762637e-01f, 2.87998114e-02f, -2.80057043e-02f, -5.05416691e-02f,
  4.06906102e-03f, -5.37311621e-02f, -7.32365325e-02f, -1.76538937e-02f, 2.84903459e-02f, -6.58717081e-02f, -6.18372187e-02f, 2.41133571e-02f, 1.57171432e-02f, -6.64643720e-02f,
  -2.34075487e-01f, -1.49921075e-01f, -1.09991953e-01f, -3.32691297e-02f, 7.64877126e-02f, -7.44701400e-02f, 4.22085151e-02f, -8.47598687e-02f, 2.37965081e-02f, -6.57165982e-03f,
  -8.27737302e-02f, -2.71816589e-02f, -9.40641165e-02f, -1.15622277e-03f, -1.24292254e-01f, -1.40232950e-01f, -3.91023457e-02f, -9.04784128e-02f, -3.76031809e-02f, 2.91945804e-02f,
  5.84770069e-02f, -8.22316483e-02f, -1.35072455e-01f, -4.70500775e-02f, -7.93503374e-02f, -3.75483446e-02f, -1.30922347e-01f, -1.27969489e-01f, -2.15410367e-01f, -9.99720767e-02f,
  -7.74031803e-02f, -2.27602925e-02f, -7.51161948e-02f, 6.48872256e-02f, 9.43477079e-02f, 6.20675273e-02f, 4.62538376e-02f, 1.09607011e-01f, 9.94128734e-02f, 2.93806233e-02f,
  1.32641017e-01f, 2.18583301e-01f, 5.82172237e-02f, 1.64521664e-01f, -6.97051734e-03f, 5.98580912e-02f, 1.72537610e-01f, 8.43392015e-02f, 6.52080541e-03f, 1.00088947e-01f,
  8.13649967e-02f, 1.18922628e-01f, -1.53450090e-02f, -2.59186011e-02f, 7.12209493e-02f, 1.86705664e-01f, 1.08237028e-01f, 1.21987179e-01f, 1.16665207e-01f, 2.00665459e-01f,
  5.11460081e-02f, -1.52769824e-02f, 6.85569495e-02f, -5.70458407e-03f, 2.76425779e-02f, 1.31182168e-02f, 3.92161831e-02f, -9.69320610e-02f, -2.16205698e-02f, -2.98079532e-02f,
  -2.06161402e-02f, -1.85519122e-02f, 4.02274542e-02f, 4.78414148e-02f, -6.16572686e-02f, 1.49485469e-02f, -2.73421705e-02f, 1.85709763e-02f, -4.40841429e-02f, 7.20242634e-02f,
  9.83168110e-02f, -3.70645747e-02f, 3.08968946e-02f, -9.65643525e-02f, 9.24816355e-02f, -1.27228554e-02f, -3.92952599e-02f, -2.08298415e-02f, -3.15219760e-02f, -9.24154818e-02f,
  8.21946040e-02f, 3.39672342e-02f, -2.71186382e-02f, 1.80912297e-02f, 4.09638546e-02f, -6.13865666e-02f, 9.68836844e-02f, 6.52274536e-03f, -3.97523083e-02f, 2.24020407e-02f,
  4.98889200e-03f, 1.38556371e-02f, -8.02210420e-02f, -1.79440174e-02f, -4.76725809e-02f, -4.96294834e-02f, -1.03416676e-02f, 5.11318035e-02f, 6.86086416e-02f, -9.17325988e-02f,
  7.90721551e-02f, 3.97245027e-02f, -9.18737948e-02f, -2.72451472e-02f, -7.75133222e-02f, 5.21888658e-02f, -7.33897686e-02f, -8.41254275e-03f, -2.81624775e-02f, -1.51275136e-02f,
  8.36119726e-02f, 2.12544692e-03f, 1.19854972e-01f, 4.33923081e-02f, 2.48792153e-02f, -6.47120774e-02f, 4.26451676e-02f, 3.74266952e-02f, 2.50474606e-02f, -1.74808372e-02f,
  -4.55348156e-02f, -6.53202534e-02f, 4.80908379e-02f, -3.27527635e-02f, -4.78464589e-02f, -3.42014097e-02f, 2.61341203e-02f, 4.80107851e-02f, 2.54973155e-02f, -6.14351444e-02f,
  5.71100079e-02f, 6.72683939e-02f, -9.10323337e-02f, 1.16180722e-02f, -5.34535050e-02f, 1.17098235e-01f, -1.31640956e-01f, -9.10758898e-02f, -6.74503222e-02f, -1.29682302e-01f,
  2.45419264e-01f, -1.39118642e-01f, 1.61966190e-01f, 7.23416731e-02f, 1.06441312e-01f, 2.13126421e-01f, 6.47159368e-02f, 1.20956443e-01f, 1.03815638e-01f, 2.09353361e-02f,
  -6.37354925e-02f, 2.11567730e-02f, -6.95984885e-02f, -3.73585708e-02f, -9.70160887e-02f, -2.75807008e-02f, 1.41055668e-02f, 6.79380149e-02f, 1.31871417e-01f, 1.03210710e-01f,
  -6.91400319e-02f, -1.77594759e-02f, -8.11797287e-03f, -2.55464762e-02f, -9.16100442e-02f, 3.17468774e-03f, -6.77025616e-02f, 5.50838653e-03f, 2.95651350e-02f, -8.64360482e-02f,
  4.52927016e-02f, 4.07015011e-02f, 1.18144549e-01f, -3.63656483e-03f, -1.98608730e-03f, -6.76685870e-02f, 3.07998043e-02f, -4.29881290e-02f, 3.19628678e-02f, 3.34151089e-02f,
  4.60884012e-02f, 3.42698283e-02f, -4.34086360e-02f, 2.36043837e-02f, -5.42008551e-04f, -4.06173021e-02f, -5.42271324e-03f, -7.72977620e-02f, 7.06401542e-02f, 7.82343298e-02f,
  -7.07067996e-02f, 1.21360786e-01f, 1.04534395e-01f, 9.98319760e-02f, 4.16036174e-02f, 8.31235498e-02f, -1.00913823e-01f, 7.87176564e-02f, 1.37606069e-01f, 3.59779149e-02f,
  -4.41479944e-02f, 8.91030487e-03f, 3.23555805e-02f, -1.24262705e-01f, 3.78508605e-02f, -5.67010641e-02f, 1.08205732e-02f, -1.09208992e-03f, 4.17077988e-02f, -5.87560721e-02f,
  -3.69271785e-02f, 6.16165586e-02f, -4.67946790e-02f, 1.38595290e-02f, 1.06512969e-02f, 8.35388303e-02f, 1.87653787e-02f, -4.28002551e-02f, -6.68081641e-02f, 6.18877448e-02f,
  8.63300413e-02f, -5.50368917e-04f, 6.45069703e-02f, -5.96407009e-03f, -8.25770646e-02f, -5.10422811e-02f, 7.70448800e-03f, -3.28937359e-02f, 5.34739941e-02f, 4.54173759e-02f,
  -2.96177231e-02f, 1.74057022e-01f, 8.81249458e-03f, -7.39284903e-02f, 8.05785358e-02f, 5.31279966e-02f, 2.94593424e-02f, -5.76663800e-02f, -6.44762367e-02f, -4.19524014e-02f,
  9.34015736e-02f, -6.47824779e-02f, 8.81372169e-02f, 1.65144063e-03f, 2.38510165e-02f, -1.68586168e-02f, 2.79016271e-02f, 5.18187769e-02f, 2.10083574e-02f, -4.82133143e-02f,
  4.98869941e-02f, 1.95356235e-01f, 2.69449856e-02f, 1.16858825e-01f, 1.25390049e-02f, 1.89313725e-01f, 6.56930506e-02f, 3.02233063e-02f, 1.58170760e-01f, 5.81714604e-03f,
  -2.31074065e-01f, -3.88691053e-02f, -1.83251482e-02f, -4.93349992e-02f, 8.51952732e-02f, 1.76729828e-01f, 6.87412024e-02f, 1.37681782e-01f, 4.73374082e-03f, 6.36306182e-02f,
  -4.83739153e-02f, 9.39744189e-02f, -1.56959333e-02f, 1.11266524e-02f, -1.02959182e-02f, 7.08444566e-02f, 3.59356366e-02f, 6.15996197e-02f, 1.07005127e-01f, 6.27336698e-03f,
  -1.74487699e-02f, 4.60653640e-02f, -7.88319036e-02f, -9.95342340e-03f, 9.38998684e-02f, 1.12961486e-01f, 1.37354404e-01f, 1.25131682e-01f, 1.45883309e-02f, -3.27739567e-02f,
  1.29359394e-01f, -1.29321396e-01f, 7.67573118e-02f, -8.84680226e-02f, -1.18920282e-01f, -2.31116880e-02f, -4.70158644e-02f, -4.93282601e-02f, -3.37990746e-02f, 2.54125800e-02f,
  -3.09891999e-02f, -1.07851839e-02f, -1.27121508e-01f, -1.59413461e-02f, -3.15587930e-02f, -3.00920475e-02f, -1.09257273e-01f, -8.55757948e-03f, -4.76578772e-02f, -5.17675988e-02f,
  4.84405458e-02f, -8.36613998e-02f, 4.10616584e-02f, 1.07635237e-01f, -5.67175671e-02f, -6.27882173e-03f, 9.92933139e-02f, 1.76143646e-02f, 9.49466787e-03f, 7.90034831e-02f,
  6.23484254e-02f, -1.73095856e-02f, 1.93099044e-02f, 3.49495187e-02f, 1.53508885e-02f, 7.68920705e-02f, 1.00320332e-01f, 1.08192898e-01f, -9.60814860e-03f, 6.95041344e-02f,
  5.37762791e-02f, -1.16298422e-02f, -1.82068199e-02f, 2.71198340e-03f, -8.41609202e-03f, -1.05924476e-02f, -6.01261668e-02f, -4.60859090e-02f, 1.67503711e-02f, -5.15847318e-02f,
  6.47035390e-02f, -2.09494568e-02f, 2.92820502e-02f, 1.73698757e-02f, -1.76542327e-02f, -1.35944579e-02f, 3.29583399e-02f, -5.27235419e-02f, 2.65554083e-03f, -4.93412986e-02f,
  2.49142453e-01f, -6.90436065e-02f, -3.78497019e-02f, 8.94811098e-03f, 2.66600233e-02f, 1.93924382e-02f, -3.42739075e-02f, -5.15855365e-02f, 4.41666432e-02f, 1.40010238e-01f,
  4.26488183e-02f, -7.93704093e-02f, -1.12104125e-01f, -5.66889830e-02f, 5.46759255e-02f, 5.47893383e-02f, 8.67985946e-04f, -5.65869454e-03f, 6.37432113e-02f, 2.53519658e-02f,
  -1.07132383e-02f, 1.28157794e-01f, 1.32276267e-01f, 1.20883234e-01f, -4.05529290e-02f, 6.38355091e-02f, 4.10319678e-02f, 1.48941621e-01f, 7.06919730e-02f, 1.74357250e-01f,
  1.54958919e-01f, 5.25304787e-02f, -2.31605008e-01f, 2.42556795e-01f, 9.97928157e-02f, -1.06502518e-01f, -1.63032055e-01f, -1.41324058e-01f, 2.51881983e-02f, 1.57079212e-02f,
  4.21270588e-03f, 8.48680958e-02f, -1.58166252e-02f, -1.15621313e-01f, -1.35221824e-01f, -2.62914509e-01f, -1.26383424e-01f, -1.09445266e-01f, -1.33948743e-01f, -7.24261999e-02f,
  4.79772501e-02f, 2.64531989e-02f, 1.78368744e-02f, -6.77578673e-02f, 5.37325963e-02f, 3.27544473e-02f, -5.57253920e-02f, 2.09494494e-02f, -3.32431234e-02f, 7.37668527e-03f,
  -6.66967779e-02f, 6.13666438e-02f, -5.25544956e-02f, -4.01333012e-02f, 9.13270749e-03f, -6.06475063e-02f, -7.78960884e-02f, 5.94764482e-03f, 8.17877650e-02f, 8.30313936e-03f,
  3.90749983e-02f, 5.97939976e-02f, 5.47058322e-03f, 8.68898854e-02f, 2.49584224e-02f, -5.63893840e-02f, -5.59524633e-02f, -1.36429578e-01f, -2.06986219e-02f, -1.80389546e-02f,
  4.01238278e-02f, 2.36800034e-02f, -4.07210365e-03f, -1.08241938e-01f, -8.41870084e-02f, -4.38337065e-02f, 1.56413894e-02f, -7.30540529e-02f, -9.56278145e-02f, -2.82283928e-02f,
  -2.24276837e-02f, -1.23712635e-02f, 8.59241374e-03f, 9.13605988e-02f, -7.29984557e-03f, 9.74550992e-02f, 4.42964919e-02f, -2.89492831e-02f, 2.58375332e-02f, 8.46704170e-02f,
  -7.56279472e-03f, -1.42262943e-04f, -6.31517470e-02f, 5.35778366e-02f, 1.58716179e-02f, 2.93052774e-02f, -4.14353870e-02f, 8.67227614e-02f, -3.92710119e-02f, 6.82990775e-02f,
  -3.05266604e-02f, -4.80226539e-02f, 3.49228387e-03f, 2.67502740e-02f, -5.30741289e-02f, 2.26573162e-02f, 6.80730566e-02f, 8.10749680e-02f, 6.09226003e-02f, -8.10366962e-03f,
  2.26563260e-01f, -1.50262654e-01f, 7.51003921e-02f, -5.34969121e-02f, 2.20722705e-02f, -5.42825907e-02f, 1.06194474e-01f, 6.64299950e-02f, 8.86414647e-02f, 1.73331134e-03f,
  7.02624992e-02f, -6.54697567e-02f, 7.21517652e-02f, -1.11476695e-02f, -7.24451104e-03f, 4.15029228e-02f, 3.58719309e-03f, -5.45212105e-02f, -8.56765360e-02f, 9.50823873e-02f,
  5.72005399e-02f, 2.85129212e-02f, 8.44770949e-03f, 4.01981473e-02f, -3.61197367e-02f, 1.41116343e-02f, -2.15550363e-02f, -1.07399046e-01f, -1.32948846e-01f, -4.36205342e-02f,
  2.30947763e-01f, -1.19018726e-01f, -6.88489527e-02f, 9.91941243e-02f, -1.48216516e-01f, -1.71319038e-01f, -1.47987366e-01f, 1.69705413e-02f, 8.90352800e-02f, 9.51792113e-03f,
  1.47418499e-01f, 2.73244649e-01f, 2.70426840e-01f, 1.72043264e-01f, 1.81777030e-02f, -4.54351343e-02f, -3.99563611e-02f, -2.26645675e-02f, 9.66349393e-02f, -4.08388749e-02f,
  -7.69591983e-03f, -1.62919462e-01f, 5.52430078e-02f, -5.15760928e-02f, -6.57994971e-02f, 2.44330652e-02f, 2.94360109e-02f, -1.13488086e-01f, -1.53452270e-02f, 2.91647706e-02f,
  1.75865233e-01f, 3.90484929e-02f, 1.28175974e-01f, -5.16852224e-03f, 1.79386158e-02f, 3.97938602e-02f, 4.60781194e-02f, 2.62925178e-02f, -2.14515477e-02f, -5.71898092e-03f,
  3.46629024e-02f, 7.44800791e-02f, 1.22313835e-02f, -2.98291426e-02f, -1.25282660e-01f, -5.84100699e-03f, 4.37759906e-02f, -3.55008096e-02f, -2.75252890e-02f, -2.77847704e-02f,
  2.22915187e-02f, -4.06545587e-02f, 1.45658189e-02f, -4.29096818e-02f, -5.23415655e-02f, 1.46588191e-01f, 1.12386532e-01f, -1.77267585e-02f, 1.05940983e-01f, -1.12761441e-03f,
  7.58828297e-02f, 2.73786802e-02f, 8.52104947e-02f, 6.71360642e-02f, 7.48196766e-02f, 1.07442208e-01f, -2.58017108e-02f, -3.66757922e-02f, 1.35946022e-02f, 6.66809753e-02f,
  -4.98857722e-02f, 7.51955658e-02f, -3.08250170e-02f, -5.92091642e-02f, 1.13326572e-02f, -2.44887527e-02f, 3.79623398e-02f, -4.23787236e-02f, 1.16328508e-01f, -2.20217742e-02f,
  6.04188330e-02f, -1.14970868e-02f, -4.86122854e-02f, 3.06086261e-02f, -8.79973639e-03f, -1.83243176e-03f, 4.77010459e-02f, 2.80389283e-02f, -1.89023968e-02f, -9.80389677e-03f,
  7.65260011e-02f, 1.39144450e-01f, -2.49531232e-02f, 5.33697605e-02f, -4.81564216e-02f, -3.16252816e-03f, 2.99677923e-02f, 2.84637678e-02f, -3.34639661e-02f, 1.02685895e-02f,
  -2.43438315e-02f, 7.41089731e-02f, 1.19324466e-02f, -2.97846645e-02f, -2.36435793e-03f, -3.54350954e-02f, 1.03644490e-01f, 2.82245856e-02f, 1.57062449e-02f, 7.18709901e-02f,
  3.56700621e-03f, -4.98713367e-02f, 1.42438605e-01f, 8.07417557e-02f, -1.88489836e-02f, 3.65031138e-02f, -1.58091616e-02f, -4.84661311e-02f, 4.08774149e-03f, -3.79177891e-02f,
  5.90139553e-02f, -1.82839528e-01f, -1.12788931e-01f, -1.02934882e-01f, -1.51922673e-01f, -1.26703650e-01f, -3.14306229e-01f, -1.32980615e-01f, -7.89842382e-02f, -1.36806041e-01f,
  4.71562035e-02f, -1.86620951e-02f, -7.28149936e-02f, -2.70488393e-02f, -2.39855334e-01f, -2.00546816e-01f, -2.47020021e-01f, -2.15628684e-01f, -1.46746144e-01f, -9.82719436e-02f,
  -1.86823934e-01f, -1.71742409e-01f, -1.40720755e-01f, -4.19654837e-03f, 2.68663485e-02f, -5.56002595e-02f, -1.49172068e-01f, -4.25458439e-02f, -1.00398794e-01f, -1.10805631e-01f,
  -1.61638200e-01f, 1.23941280e-01f, 5.08444533e-02f, 3.32726426e-02f, 2.41450835e-02f, 6.67542890e-02f, 3.73566486e-02f, 3.49099115e-02f, 3.56406868e-02f, 2.31353305e-02f,
  -3.33700776e-02f, -5.70882671e-02f, 1.02692600e-02f, -2.11275574e-02f, -3.12661715e-02f, -1.14220656e-01f, -2.40027606e-02f, 4.99187596e-02f, -6.08564317e-02f, 2.08022688e-02f,
  -9.37680900e-02f, -1.01019070e-02f, -6.84472322e-02f, 5.91356046e-02f, 4.80019376e-02f, -4.14853096e-02f, 3.29498500e-02f, 1.29589224e-02f, -8.49453509e-02f, -1.37074724e-01f,
  -6.65630028e-02f, -3.20373774e-02f, -2.61181034e-02f, 6.79873973e-02f, -9.20391530e-02f, 7.74869323e-02f, 6.30928054e-02f, -3.22927460e-02f, -3.88351791e-02f, -1.34142106e-02f,
  8.10120404e-02f, 1.72782335e-02f, -1.84734538e-02f, -7.66821876e-02f, 5.64622581e-02f, 6.16963534e-03f, 2.44894885e-02f, 2.69370557e-05f, -7.11155869e-03f, -5.84147498e-02f,
  3.75689752e-02f, -1.21072149e-02f, -9.30661708e-02f, -5.92342913e-02f, 2.34660506e-02f, 1.79880727e-02f, -6.41641915e-02f, -4.34255116e-02f, 6.10572137e-02f, -7.15976655e-02f,
  -1.12062298e-01f, 2.93522738e-02f, -2.25845464e-02f, 2.67519057e-02f, -1.53733892e-02f, -1.32234413e-02f, -3.24795693e-02f, 3.41050550e-02f, 1.34920895e-01f, 2.63196342e-02f,
  1.08085782e-03f, -9.66477245e-02f, 2.78451648e-02f, -4.02618982e-02f, -9.51168239e-02f, 6.76368251e-02f, -1.11046322e-01f, -6.27525747e-02f, 3.58259007e-02f, -7.64372721e-02f,
  -1.31663904e-01f, -3.20232175e-02f, -1.01296470e-01f, -5.02888598e-02f, 3.21477093e-02f, 1.29817054e-02f, -2.62686554e-02f, 3.30090113e-02f, -2.43614502e-02f, -1.75128788e-01f,
  6.80530146e-02f, 2.40313247e-01f, 9.00668874e-02f, 6.63613826e-02f, 7.38244802e-02f, -1.34254500e-01f, -4.10860851e-02f, -9.69828740e-02f, -4.54983599e-02f, 8.29128027e-02f,
  -1.02694146e-01f, 2.73727463e-03f, -2.56446265e-02f, -7.07723498e-02f, -1.04568072e-01f, 7.43814260e-02f, 1.69960096e-01f, -8.09711311e-03f, -3.37383389e-01f, -2.38005102e-01f,
  -3.05639450e-02f, -3.67977121e-03f, -1.66017786e-01f, -8.79382119e-02f, 2.02985585e-01f, -1.03063300e-01f, 1.26732498e-01f, 1.85335483e-02f, -4.44541797e-02f, 2.90715218e-01f,
  1.11847371e-01f, 1.83695346e-01f, -1.79315254e-01f, 2.13953713e-03f, -2.21814830e-02f, 6.77746162e-02f, 2.19872147e-02f, 6.06341138e-02f, -3.31875570e-02f, -3.39738303e-03f,
  -3.93497497e-02f, -2.36169975e-02f, 1.48907881e-02f, -9.27845091e-02f, 3.78139950e-02f, -1.42748579e-01f, 8.07751156e-03f, -3.63745056e-02f, -5.89394569e-02f, -3.08319610e-02f,
  -3.60818617e-02f, 6.55458793e-02f, 6.35448424e-03f, -2.39487756e-02f, -3.95487510e-02f, -1.32109255e-01f, -4.54264060e-02f, -6.34532794e-02f, -4.72304597e-02f, 1.28637239e-01f,
  -1.40681386e-01f, -2.28695804e-03f, -5.09793684e-02f, -2.26954240e-02f, 5.53077310e-02f, -1.62826497e-02f, 9.66618024e-03f, 2.24833470e-02f, 1.24563894e-03f, 1.77922025e-02f,
  -1.46853393e-02f, -2.26090625e-02f, -2.04415130e-03f, 4.77937199e-02f, -1.42968176e-02f, 8.64398479e-03f, -5.48311435e-02f, -6.63869688e-03f, -6.65219724e-02f, -7.63935130e-03f,
  -5.13168238e-02f, 5.98378703e-02f, -3.49018648e-02f, 5.23172952e-02f, 3.67266452e-03f, -2.39093807e-02f, -3.52515578e-02f, -8.08005556e-02f, -5.23231588e-02f, 7.96098262e-02f,
  -1.01363242e-01f, -2.89982647e-01f, 1.67186018e-02f, -3.95549536e-02f, 2.31827460e-02f, 1.55127596e-03f, 1.47457086e-02f, -7.63201043e-02f, 3.87227312e-02f, 1.51054384e-02f,
  -9.87182632e-02f, 4.92984802e-02f, 8.07416067e-03f, -1.99495330e-02f, -1.32732108e-01f, -5.35929911e-02f, -6.17268644e-02f, 1.74125526e-02f, -1.05251603e-01f, 1.29881203e-02f,
  -1.00149155e-01f, -1.98540494e-01f, -2.15092093e-01f, -8.52152333e-02f, -4.03944589e-02f, -2.54187852e-01f, -4.54195365e-02f, -1.50088400e-01f, -2.61663854e-01f, -7.75346085e-02f,
  -5.58788240e-01f, 1.09135561e-01f, 7.47721568e-02f, -1.91566106e-02f, 1.75775230e-01f, 1.66934654e-01f, 6.52799830e-02f, 1.15723945e-02f, -1.03631325e-01f, -7.39783645e-02f,
  -1.87727809e-02f, -4.34959121e-02f, -6.56591728e-02f, 6.67200685e-02f, -4.54699919e-02f, 7.90970549e-02f, 1.53347909e-01f, -1.21924415e-01f, -8.34551007e-02f, 1.96594708e-02f,
  1.44017622e-01f, -7.48926699e-02f, -2.56964773e-01f, -1.51024684e-02f, 1.45408399e-02f, 1.86300017e-02f, 3.66483107e-02f, -8.27485695e-02f, 7.85799325e-02f, 2.96475887e-02f,
  -7.89025798e-02f, -2.06339389e-01f, 2.44129803e-02f, -1.76687520e-02f, 7.24575445e-02f, -1.34757131e-01f, -1.00206167e-01f, 1.76607538e-02f, 3.26149352e-02f, 5.95234334e-02f,
  1.36726322e-02f, 4.86052260e-02f, 6.31482080e-02f, -2.61148368e-03f, -5.38079143e-02f, -6.64199144e-02f, -1.56243294e-01f, -3.92290689e-02f, -3.49974670e-02f, 3.36545631e-02f,
  2.27675363e-02f, -5.97751178e-02f, -1.74728781e-01f, -1.08296357e-01f, -3.54752280e-02f, -1.35085136e-01f, -1.19410031e-01f, -1.06162012e-01f, -1.82623476e-01f, -1.21958829e-01f,
  -4.09341715e-02f, 4.73913252e-02f, 3.06373294e-02f, -5.11240810e-02f, -5.30297607e-02f, -6.12906995e-04f, 8.92883018e-02f, -1.14221766e-03f, -1.59113593e-02f, 2.37463024e-02f,
  7.18067288e-02f, -2.67360043e-02f, -6.48976937e-02f, -8.54635164e-02f, -1.77852791e-02f, 5.35126776e-02f, 3.85834314e-02f, -8.00134018e-02f, 1.98573712e-03f, 5.60018159e-02f,
  4.91163693e-02f, -4.34336858e-03f, -6.49969801e-02f, 5.33019230e-02f, 4.73457053e-02f, 5.85680222e-03f, 4.34533972e-03f, -8.22914466e-02f, -6.26498759e-02f, 6.46956731e-03f,
  -1.29092544e-01f, -3.24801244e-02f, -2.87150927e-02f, -1.23357974e-01f, -3.17440033e-02f, 8.00762028e-02f, 7.28631690e-02f, 5.00914492e-02f, -1.93792731e-02f, -9.08216983e-02f,
  -3.74625400e-02f, -1.42057687e-01f, 1.20841153e-02f, -8.22305679e-03f, -3.13336439e-02f, -1.00758351e-01f, -3.70769203e-02f, -1.27673507e-01f, -1.32440431e-02f, -1.04447338e-03f,
  -1.98701844e-02f, -1.59765586e-01f, -1.96848378e-01f, -2.36872863e-02f, -7.49483332e-02f, -1.31191850e-01f, -1.40009716e-01f, -1.52026042e-01f, -1.19171798e-01f, -1.38226211e-01f,
  -1.70932710e-01f, 1.99918747e-02f, -4.96188290e-02f, -1.06884725e-01f, -1.31386310e-01f, -8.92097726e-02f, 7.82779232e-02f, -4.52778600e-02f, -1.10357583e-01f, -6.04187138e-02f,
  -1.19451825e-02f, -1.05823539e-01f, -2.53880341e-02f, 5.15096262e-02f, -2.94931307e-02f, 7.96321929e-02f, -9.44436938e-02f, -1.44074470e-01f, -3.08621339e-02f, -1.55018792e-01f,
  -1.10580832e-01f, -2.56709278e-01f, -1.05195470e-01f, -1.33681148e-01f, -1.65713459e-01f, -9.14049819e-02f, 1.01907142e-02f, -4.04044352e-02f, 9.35333818e-02f, -1.09991595e-01f,
  6.35311753e-02f, 9.86834168e-02f, -6.63626865e-02f, 4.67879232e-03f, 1.25545505e-02f, 6.95528984e-02f, -3.17091332e-03f, -6.67946339e-02f, -1.00513762e-02f, -1.58273187e-02f,
  4.54205088e-02f, 2.45614871e-02f, 2.03211401e-02f, -6.93408102e-02f, -1.28279820e-01f, 3.88462618e-02f, -4.42330278e-02f, -6.98129833e-02f, 1.30809814e-01f, -3.07842181e-03f,
  3.06196604e-02f, 1.01544335e-01f, 1.31078839e-01f, 1.38721257e-01f, 1.12957269e-01f, 9.90378708e-02f, -5.96770383e-02f, 5.48071079e-02f, 1.14154212e-01f, -7.39392266e-02f,
  2.10321546e-02f, 7.74773881e-02f, 8.85152593e-02f, 2.70769373e-02f, -2.34868452e-02f, -2.77599841e-02f, -2.53079049e-02f, -2.86062472e-02f, -5.57461008e-02f, -5.36246151e-02f,
  -5.10159694e-02f, 9.50296074e-02f, -4.78115231e-02f, -8.22384134e-02f, -4.05280180e-02f, 9.15910825e-02f, -1.25848223e-02f, 7.47003630e-02f, -2.23947391e-02f, 6.27991743e-03f,
  -1.55763719e-02f, 8.10340643e-02f, 2.91084629e-02f, 8.51994567e-03f, -3.44347907e-03f, -7.44228289e-02f, 9.11855474e-02f, 7.78220519e-02f, 3.09833400e-02f, 7.53661767e-02f,
  -1.61704779e-01f, 6.22515902e-02f, 7.62702674e-02f, 2.68607084e-02f, -2.09631734e-02f, -1.05215795e-01f, -3.43516991e-02f, 1.65801365e-02f, -8.82480219e-02f, -1.46553451e-02f,
  2.46750694e-02f, -3.41069177e-02f, -6.26028180e-02f, 1.64930839e-02f, -9.86567289e-02f, 8.53817165e-03f, 9.30471439e-03f, 6.04374073e-02f, 1.14606656e-01f, 8.37156735e-03f,
  1.16842180e-01f, 9.96250212e-02f, 6.77720755e-02f, -2.92967688e-02f, 8.73228237e-02f, 1.15407467e-01f, 1.29780080e-02f, 3.82304452e-02f, 5.12186699e-02f, -9.70497876e-02f,
  3.74487430e-01f, -2.81427950e-01f, -3.28655951e-02f, 7.30173215e-02f, -7.44998455e-02f, -1.44743361e-03f, -1.46710113e-01f, 8.42927694e-02f, 1.39115766e-01f, -3.50555666e-02f,
  4.71673049e-02f, 2.80934185e-01f, 2.75080651e-01f, 1.03619903e-01f, 1.90623879e-01f, -6.36306256e-02f, -8.71892497e-02f, 1.16793729e-01f, 1.36304095e-01f, -1.44967316e-02f,
  6.81693014e-03f, -8.32808837e-02f, 7.26597309e-02f, -5.81704155e-02f, -2.14267924e-01f, 2.74756141e-02f, -7.20094517e-02f, -1.99932277e-01f, -8.26313570e-02f, -1.92323938e-01f,
  5.63779250e-02f, 5.59707135e-02f, 1.28207907e-01f, 3.42233516e-02f, -1.01956047e-01f, -1.88587476e-02f, 5.05204760e-02f, -1.42790660e-01f, 1.02824168e-02f, -1.00412272e-01f,
  -9.26155671e-02f, 6.71387240e-02f, 1.27926953e-02f, -2.07215380e-02f, -4.90705408e-02f, 7.44173601e-02f, -3.22679132e-02f, -2.23645400e-02f, 6.29442036e-02f, 3.20914686e-02f,
  -1.67525932e-01f, -5.71444556e-02f, -2.09232196e-02f, -1.34016518e-02f, 1.64967943e-02f, 3.29650082e-02f, -5.89935184e-02f, 7.00320825e-02f, 9.16995108e-02f, -1.67304710e-01f,
  3.44248898e-02f, 2.99915913e-02f, 6.30351007e-02f, -8.46539065e-03f, 5.67616820e-02f, -7.40961134e-02f, 3.42326090e-02f, 4.36474085e-02f, 9.04265698e-03f, -9.26931128e-02f,
  5.18634729e-03f, 2.80741248e-02f, -1.16199972e-02f, 6.42800555e-02f, 9.73114446e-02f, -5.43745607e-02f, -2.88164783e-02f, -1.15461960e-01f, -1.01067191e-02f, 3.53967138e-02f,
  -6.83806313e-04f, 1.86576005e-02f, -1.87263265e-02f, 1.17997741e-02f, 1.75062642e-02f, 1.49296299e-02f, 4.94752266e-03f, -7.89885991e-04f, 6.40602782e-02f, -1.06829181e-01f,
  -1.47456244e-01f, 1.28898278e-01f, 9.72545817e-02f, 8.54980797e-02f, -8.10635537e-02f, -5.22060972e-03f, 4.50306246e-03f, -7.05251768e-02f, -9.41720977e-02f, -6.52221292e-02f,
  -5.29822707e-03f, 4.85408679e-02f, -2.84388778e-03f, -5.04750833e-02f, 3.28231454e-02f, 5.59199899e-02f, -9.88092199e-02f, 4.76455204e-02f, 3.84104811e-02f, -3.93724293e-02f,
  -7.62708485e-02f, 2.15793326e-02f, 1.42451540e-01f, 1.42246606e-02f, -4.44236845e-02f, 1.92332804e-01f, 4.21373919e-03f, -2.92444248e-02f, 1.57647654e-01f, -5.76174185e-02f,
  2.88365334e-01f, 1.74705070e-02f, 1.23400129e-01f, 4.72005131e-03f, 5.09219095e-02f, 1.88035220e-01f, 1.03504911e-01f, 6.13351464e-02f, -3.87309976e-02f, 7.25545213e-02f,
  -1.11100465e-01f, -1.30228791e-02f, -9.45993662e-02f, -2.63628014e-03f, 6.35048598e-02f, -2.16996353e-02f, -3.24699394e-02f, 5.93082719e-02f, 1.05808392e-01f, 2.25654710e-02f,
  -1.46256834e-02f, 5.67308143e-02f, 4.88738641e-02f, 8.87510404e-02f, -1.27843686e-03f, -6.42802119e-02f, -7.68078715e-02f, 6.98670149e-02f, 5.77726634e-03f, -7.73895606e-02f,
  -2.89567118e-03f, 1.56939149e-01f, 7.94854853e-03f, -1.56922251e-01f, 3.84813547e-02f, 2.71939579e-02f, 2.38699764e-02f, -1.40432650e-02f, -4.85958345e-02f, 2.03470532e-02f,
  -1.51224621e-02f, -2.05561183e-02f, 7.40597909e-03f, -2.75756698e-02f, 9.97024700e-02f, -4.17635702e-02f, -9.20846909e-02f, 5.83036151e-03f, -5.13207875e-02f, -3.87347639e-02f,
  -1.24368392e-01f, -5.88181540e-02f, 4.69478406e-02f, 4.56924224e-03f, 7.85725117e-02f, 6.91044927e-02f, -9.41562932e-03f, 1.48286903e-02f, 8.01794790e-03f, 2.86778230e-02f,
  3.46577284e-03f, 5.99733926e-02f, -2.17029452e-03f, -9.21042189e-02f, 3.40149887e-02f, -9.30046141e-02f, -7.20273107e-02f, 5.02654910e-02f, 1.25974203e-02f, -3.80439423e-02f,
  -3.31977867e-02f, 6.21565953e-02f, 5.25901839e-02f, -5.62318182e-03f, -1.10432126e-01f, -8.30125995e-03f, -2.35384572e-02f, -8.56894534e-03f, 3.88575643e-02f, 4.35295962e-02f,
  5.61189167e-02f, -5.25354072e-02f, 8.40927474e-03f, -1.63095223e-03f, 3.80011462e-02f, 4.23071384e-02f, -7.89163932e-02f, -1.09928362e-01f, -2.75609754e-02f, -1.58601515e-02f,
  -1.51136279e-01f, 8.12800303e-02f, -1.82216626e-03f, 3.38234976e-02f, 9.91028617e-04f, -5.66609092e-02f, -6.24855980e-02f, -3.35756727e-02f, -4.41372581e-03f, 9.91119165e-03f,
  2.00862214e-02f, 3.44577283e-02f, -4.08102423e-02f, -9.41211805e-02f, 3.65816541e-02f, 5.96446097e-02f, -6.33017197e-02f, 5.53403869e-02f, -1.07899658e-01f, -3.79299223e-02f,
  -4.76428159e-02f, 1.25599980e-01f, 1.05926313e-01f, 3.00319176e-02f, 3.67966816e-02f, 9.01798233e-02f, 4.95659113e-02f, -3.43802311e-02f, -1.33113805e-02f, -6.64131120e-02f,
  -3.21356803e-01f, 3.12567800e-02f, -6.16695583e-02f, -1.04934417e-01f, -3.18430215e-02f, 5.86538278e-02f, -4.36780937e-02f, -5.65504469e-02f, 2.84324847e-02f, 4.57116850e-02f,
  -5.40444627e-02f, -3.30773182e-02f, 8.81159753e-02f, -2.06353068e-02f, 9.15175304e-02f, 2.64819749e-02f, 2.80016307e-02f, -2.86981482e-02f, 9.41087082e-02f, 2.80087348e-02f,
  1.31968439e-01f, 3.76866311e-02f, -8.99252295e-02f, 4.11942638e-02f, 1.23267196e-01f, -3.74062397e-02f, 9.51341018e-02f, 9.31904018e-02f, -1.95305925e-02f, 9.31752548e-02f,
  -7.13144019e-02f, -1.02025554e-01f, 4.76317592e-02f, -7.29083791e-02f, -5.12614250e-02f, -6.80472180e-02f, -9.16021317e-02f, -2.19527781e-02f, -7.33527467e-02f, -3.85000780e-02f,
  -8.11339170e-02f, -1.08796600e-02f, 3.20593007e-02f, -3.84703763e-02f, -5.14271185e-02f, -7.10762367e-02f, -6.11192780e-03f, -1.54386079e-02f, 6.93262815e-02f, -2.81329527e-02f,
  1.32703513e-01f, -8.92393813e-02f, -1.10875383e-01f, -8.95862840e-03f, 3.63065116e-02f, -7.87198395e-02f, 2.60268385e-03f, -4.06198651e-02f, -5.24276756e-02f, -5.00213504e-02f,
  6.30068704e-02f, -8.95914529e-03f, -7.18509546e-03f, -6.30440377e-03f, 3.47689614e-02f, 7.70888254e-02f, 8.17114487e-02f, -3.89283746e-02f, -5.44643663e-02f, -6.30607363e-03f,
  -4.00981344e-02f, 3.67238224e-02f, 2.75303554e-02f, 6.79166168e-02f, -1.41112963e-02f, -1.05361395e-01f, 6.18983097e-02f, -6.51468188e-02f, -5.09864539e-02f, -8.77447724e-02f,
  -8.82015526e-02f, 3.33507285e-02f, 7.61014894e-02f, 2.57313494e-02f, -7.60313272e-02f, -4.47989255e-02f, -8.02563056e-02f, -7.95982629e-02f, -1.90111920e-02f, -1.09149881e-01f,
  5.97722903e-02f, 5.03628850e-02f, 8.32121968e-02f, -3.56287062e-02f, -5.36583625e-02f, -9.12074745e-02f, 5.21574430e-02f, -2.25225557e-02f, 2.57738456e-02f, 8.84874910e-03f,
  -7.17611015e-02f, -8.19456205e-02f, -4.81378324e-02f, 8.43956023e-02f, -2.28702333e-02f, -8.99082422e-03f, 9.61707532e-02f, 5.04038222e-02f, -3.89290340e-02f, 9.31664929e-03f,
  1.91903114e-02f, -4.74307574e-02f, -1.06882015e-02f, -2.03833394e-02f, 7.62754157e-02f, 1.37352645e-02f, 1.12181783e-01f, 7.08957985e-02f, -4.74174134e-02f, 3.65632661e-02f,
  -6.01188764e-02f, -1.21964455e-01f, -1.52254701e-01f, -2.06666544e-01f, -7.47238053e-03f, 7.36652091e-02f, 4.90594208e-02f, 7.63829127e-02f, 5.59379682e-02f, -9.29356217e-02f,
  2.64444016e-02f, -3.08312457e-02f, -4.15040879e-03f, -2.03879662e-02f, 1.74822453e-02f, -1.22708894e-01f, -1.06716014e-01f, -1.60481595e-02f, 9.22358334e-02f, 1.34419188e-01f,
  3.48320417e-02f, -1.39203630e-02f, -9.82538089e-02f, -6.61701038e-02f, -1.44914091e-01f, -1.59337938e-01f, -8.86844099e-02f, -1.02939300e-01f, 3.01425233e-02f, -2.16243580e-01f,
  -5.76994009e-02f, 3.54144117e-03f, 1.03119440e-01f, -4.09157947e-02f, 4.70207036e-02f, 6.58641830e-02f, 7.39718368e-03f, 4.96188290e-02f, 4.10629585e-02f, -5.38370274e-02f,
  -4.06244397e-03f, 2.53523551e-02f, -3.09424084e-02f, 8.95841196e-02f, 2.53345515e-03f, 1.17923692e-01f, 1.72652546e-02f, -4.17144448e-02f, -1.54180946e-02f, 4.88956384e-02f,
  3.45833525e-02f, 4.73620705e-02f, -8.46565291e-02f, -7.01492056e-02f, -5.29419668e-02f, -7.63781592e-02f, -3.39354947e-02f, -7.27111325e-02f, 3.84251811e-02f, -3.68984304e-02f,
  5.65410480e-02f, 8.02223980e-02f, 2.38855146e-02f, 2.87241898e-02f, -5.81355058e-02f, -3.59813981e-02f, -8.80431309e-02f, 5.33528440e-02f, 1.27485134e-02f, 5.85076921e-02f,
  -2.36985739e-03f, 3.83067839e-02f, -6.17688112e-02f, 1.70540754e-02f, -4.67716269e-02f, -4.20480222e-02f, -6.44067898e-02f, -4.01282459e-02f, -1.10219764e-02f, -7.72850141e-02f,
  5.32445796e-02f, 6.85413256e-02f, -6.83303103e-02f, 8.66783969e-03f, -5.76879345e-02f, -7.56313875e-02f, 9.51347351e-02f, -1.33615518e-02f, 6.25933632e-02f, 4.35306914e-02f,
  -2.17058048e-01f, 6.72831312e-02f, -9.76421088e-02f, 2.87211370e-02f, -9.63574722e-02f, -3.51496460e-03f, -2.06731949e-02f, 8.13249778e-03f, -4.94710989e-02f, 8.41754228e-02f,
  8.84628668e-02f, 4.19937298e-02f, 2.87655299e-03f, 8.11432451e-02f, 3.82766649e-02f, 7.83682615e-02f, -6.98071644e-02f, -6.84506670e-02f, 1.91735160e-02f, -4.30256352e-02f,
  -6.85625151e-02f, -1.41063914e-01f, -7.23229349e-02f, -6.54567853e-02f, -2.24462654e-02f, -1.20756589e-01f, -9.65575650e-02f, -1.15041159e-01f, -1.80047959e-01f, -1.12481430e-01f,
  6.31437004e-02f, 5.97988702e-02f, -4.24130149e-02f, 1.52503299e-02f, 6.41383678e-02f, 2.29147437e-04f, 1.69759139e-03f, 1.22348189e-01f, -4.37173024e-02f, 4.35454808e-02f,
  1.03519402e-01f, -7.43402774e-03f, 1.96007937e-02f, -5.95795438e-02f, -3.56883220e-02f, 1.86149739e-02f, 8.98028258e-03f, -3.64991054e-02f, 6.87704161e-02f, 9.95835871e-04f,
  -9.81784388e-02f, 8.32329169e-02f, 5.25669486e-04f, 5.62686250e-02f, -8.17155540e-02f, 1.21763153e-02f, -2.30521057e-02f, 7.79581517e-02f, 8.94261897e-03f, 2.01228689e-02f,
  -1.19644972e-02f, 2.57111024e-02f, 1.10865105e-03f, 3.59852202e-02f, -5.77447414e-02f, 6.69418275e-02f, -1.78880449e-02f, 5.78896217e-02f, -7.41788596e-02f, 5.26600629e-02f,
  -1.01012483e-01f, -8.10887814e-02f, -1.60097182e-02f, 7.05104843e-02f, -6.70955051e-03f, -1.56054953e-02f, -5.92341162e-02f, 4.22099940e-02f, -8.73449668e-02f, -1.53585551e-02f,
  -1.00076459e-02f, 5.05538099e-02f, 4.84959148e-02f, -4.26544249e-02f, -8.64744710e-04f, -9.88944024e-02f, 7.28428140e-02f, 3.13395895e-02f, 3.39860581e-02f, -7.46616395e-03f,
  1.85952280e-02f, -4.49869744e-02f, 1.22961588e-04f, -7.79402331e-02f, 3.50541025e-02f, 6.40950203e-02f, 4.10260586e-03f, -4.46618125e-02f, -5.44807613e-02f, -1.20117133e-02f,
  -9.40847327e-04f, 1.08270653e-01f, 7.51784965e-02f, 2.15739030e-02f, -4.17481773e-02f, -1.96139701e-02f, 9.62542370e-02f, 1.11538552e-01f, 4.42325994e-02f, -5.65059818e-02f,
  6.43592153e-04f, 1.19392864e-01f, 7.89378881e-02f, 9.86321568e-02f, 1.73008144e-02f, 1.18898237e-02f, 3.29488330e-02f, 1.25473693e-01f, 1.30914524e-01f, -3.05794142e-02f,
  -3.14148962e-02f, 7.73732364e-02f, -9.25795957e-02f, -3.09268422e-02f, 4.40718792e-02f, 6.77801520e-02f, 6.47858605e-02f, -9.61061344e-02f, 3.52821201e-02f, -4.57051732e-02f,
  5.21608442e-02f, -7.95518830e-02f, -4.01023068e-02f, 9.69318822e-02f, -6.77953735e-02f, 1.77621525e-02f, 3.80813815e-02f, 1.74944568e-02f, -5.30016087e-02f, 5.24330027e-02f,
  -1.13563307e-01f, -1.73486248e-02f, -4.90179136e-02f, 7.77410269e-02f, 7.40676820e-02f, 3.22524309e-02f, -5.06691225e-02f, -9.17330235e-02f, 5.95672987e-02f, 4.34250087e-02f,
  -1.96875200e-01f, -1.39310569e-01f, 7.55331367e-02f, -1.53511509e-01f, -9.94712934e-02f, -1.14707902e-01f, 7.02146441e-02f, -3.63642834e-02f, -2.00322896e-01f, -3.30334678e-02f,
  5.14788739e-02f, 3.44851837e-02f, 1.71225935e-01f, 8.33473355e-02f, -2.99760350e-03f, 9.21210740e-03f, 3.15009356e-02f, 1.86338406e-02f, 6.89940974e-02f, 2.74755545e-02f,
  -2.74873730e-02f, -6.05972931e-02f, -1.54939413e-01f, -2.73152068e-02f, -5.81454672e-02f, 5.62876873e-02f, -4.09593657e-02f, -1.62589690e-03f, -8.49758983e-02f, -8.23389590e-02f,
  5.23465157e-01f, -1.37382105e-01f, 1.28784746e-01f, -1.04785927e-01f, 5.39801866e-02f, -5.89104816e-02f, 9.20899138e-02f, -7.28858560e-02f, -8.26742053e-02f, 9.63480175e-02f,
  9.17238221e-02f, 7.75385201e-02f, 2.09964514e-02f, -1.21591222e-02f, 2.84137242e-02f, -9.87968687e-03f, -1.53340802e-01f, -4.95394804e-02f, -1.01576345e-02f, -5.75731769e-02f,
  -1.41724408e-01f, 1.99612360e-02f, 1.33397043e-01f, -9.35678780e-02f, -1.83420219e-02f, 1.96497068e-02f, 8.67369696e-02f, -8.42325240e-02f, 8.15862417e-03f, -9.43136495e-03f,
  5.70362397e-02f, -1.07490420e-02f, -6.65536597e-02f, -8.38645268e-03f, -2.42317487e-02f, -6.64943829e-02f, -2.24534273e-02f, -9.63424705e-03f, -6.87838271e-02f, 6.65641949e-02f,
  -1.15771703e-02f, -5.17155714e-02f, -1.73199940e-02f, 7.41189048e-02f, 5.26008345e-02f, 7.93512724e-03f, 2.80294176e-02f, -4.18178067e-02f, -3.62610407e-02f, -6.13439605e-02f,
  1.58223975e-02f, 8.04111436e-02f, -3.22700627e-02f, -5.25293984e-02f, 4.30055000e-02f, -4.19696346e-02f, 9.03183408e-03f, 5.25277527e-03f, -3.13563570e-02f, -6.54098392e-02f,
  3.56126875e-01f, -9.97338444e-02f, 1.02944680e-01f, 3.58594842e-02f, -2.74248384e-02f, -5.45212924e-02f, 7.03811496e-02f, 6.43754527e-02f, -4.08321358e-02f, 1.77476648e-02f,
  -1.27765909e-02f, 2.70299278e-02f, 5.82338944e-02f, 4.02367562e-02f, -5.00296056e-02f, 4.41181734e-02f, -1.57471508e-01f, -1.48122264e-02f, 8.40165168e-02f, 6.97671017e-03f,
  3.30118313e-02f, 1.23812109e-01f, 1.79037735e-01f, 6.19774163e-02f, 4.15704064e-02f, 8.73577073e-02f, 1.82428613e-01f, 1.03263073e-01f, 7.52598494e-02f, 6.55993149e-02f,
  2.17978105e-01f, 7.35320598e-02f, 9.46904942e-02f, 1.35179475e-01f, 1.03684470e-01f, 1.08556829e-01f, 1.35281816e-01f, 4.46801120e-03f, -2.04359833e-02f, 1.02301098e-01f,
  4.01182007e-03f, -7.83505812e-02f, -3.28681804e-02f, 6.99252263e-02f, 2.53653590e-04f, 6.85283840e-02f, -4.76941615e-02f, -3.59704271e-02f, 5.85796833e-02f, -5.91565343e-03f,
  1.13052514e-03f, -1.94331333e-02f, -4.64981794e-02f, -4.45249863e-02f, -1.28277224e-02f, 4.86405604e-02f, 3.57112549e-02f, -2.20444035e-02f, 3.46014276e-02f, -1.27840817e-01f,
  -6.75018951e-02f, -4.28252742e-02f, 4.72964570e-02f, -7.83165358e-03f, -3.96426357e-02f, -5.01805954e-02f, -7.47079030e-02f, 2.71255653e-02f, 7.48828724e-02f, -2.71127392e-02f,
  4.18942235e-03f, -9.43192989e-02f, 6.52493164e-02f, -8.72502029e-02f, -3.00885849e-02f, -1.52494311e-02f, -9.49832648e-02f, -7.35272989e-02f, -4.57479954e-02f, 4.29023020e-02f,
  -6.30159751e-02f, 9.06918645e-02f, -1.32786110e-02f, 9.44720283e-02f, -2.12310106e-02f, 4.68934551e-02f, -4.92866412e-02f, 8.11595353e-04f, 1.81145575e-02f, 2.16773022e-02f,
  -1.22570448e-01f, 7.97021538e-02f, 5.83578534e-02f, 6.36620075e-02f, 7.65942335e-02f, 1.05419960e-02f, -2.02991366e-02f, 6.34674728e-02f, 6.64534792e-02f, 3.56693156e-02f,
  -3.36658433e-02f, 1.96589679e-02f, -3.83240879e-02f, 1.05836742e-01f, 4.23023924e-02f, -4.64671925e-02f, -2.94094207e-03f, -2.98566353e-02f, 5.50489081e-03f, -8.80363211e-02f,
  1.29727111e-03f, 6.91290721e-02f, -6.00236692e-02f, -9.92573723e-02f, -7.02501535e-02f, -7.86160678e-02f, 2.22880999e-03f, 3.78122404e-02f, -8.11055023e-03f, 1.58313774e-02f,
  4.79995310e-02f, -7.88308773e-03f, -1.18296199e-01f, -6.44574389e-02f, -5.69543876e-02f, 2.02812944e-02f, 7.94590637e-03f, -7.56582618e-02f, 4.53371182e-02f, -4.86199036e-02f,
  -9.92485229e-03f, 7.61992391e-03f, 4.41581495e-02f, -2.04356238e-02f, 2.22665798e-02f, 5.77967688e-02f, 4.17565554e-02f, -5.37342466e-02f, -1.53436400e-02f, 1.77542940e-02f,
  9.04471800e-02f, 1.23686261e-01f, 5.13869226e-02f, 4.10809368e-02f, 5.97024038e-02f, 8.92039463e-02f, 3.31508555e-02f, -4.65376005e-02f, 2.01496594e-02f, 2.98452862e-02f,
  -4.83322293e-01f, -1.75914809e-01f, -8.15255195e-02f, -2.01595634e-01f, -5.64240664e-02f, 1.90152898e-02f, -3.88398112e-05f, -2.75182761e-02f, -4.46024127e-02f, -1.31329551e-01f,
  2.76020896e-02f, -3.82614583e-02f, -7.51769021e-02f, 4.94585782e-02f, 1.85744520e-02f, -1.47100706e-02f, -1.35100305e-01f, -1.32659391e-01f, -1.04556724e-01f, -5.21389507e-02f,
  -1.10994391e-01f, -8.07719380e-02f, -1.05222568e-01f, -2.81422101e-02f, 5.61412796e-03f, -5.97039014e-02f, -2.33199843e-03f, -3.55206393e-02f, 9.47532356e-02f, 1.65535174e-02f,
  3.24310720e-01f, -5.29075786e-02f, -9.54513531e-03f, -1.96227822e-02f, -5.78591786e-03f, 1.66947357e-02f, -3.38967741e-02f, 2.44864244e-02f, 1.00312829e-02f, -4.63064499e-02f,
  -1.34148942e-02f, -8.43905360e-02f, 3.75715867e-02f, 9.56100896e-02f, 2.57468484e-02f, -3.59412096e-02f, -1.29795298e-01f, -9.67042670e-02f, -1.94584653e-02f, 5.92362210e-02f,
  -7.46530816e-02f, -4.67908345e-02f, -7.05095893e-03f, 2.78580058e-02f, 5.39938640e-03f, 1.98891461e-02f, 2.59398222e-02f, 1.26985341e-01f, 7.24050701e-02f, 3.13923880e-02f,
  -2.66380981e-02f, -2.22227853e-02f, 4.75860648e-02f, -3.45215797e-02f, -1.17088845e-02f, -6.42309487e-02f, -4.36535329e-02f, 7.94840083e-02f, 1.38535583e-02f, -7.47727901e-02f,
  6.05363026e-02f, -7.00657517e-02f, 2.28817742e-02f, -4.76251058e-02f, 4.28438224e-02f, 3.07977479e-02f, -6.40029274e-03f, 7.39803538e-02f, -2.58187838e-02f, 1.43027119e-03f,
  -8.82697776e-02f, 4.20935638e-02f, -7.17908219e-02f, 1.88086368e-02f, 5.96842691e-02f, -3.67853791e-02f, -1.27083743e-02f, 7.55142942e-02f, 1.92837918e-03f, -9.16885659e-02f,
  8.64148140e-02f, -4.09355387e-02f, 2.95804106e-02f, 1.08344899e-02f, -2.45778151e-02f, -8.97952765e-02f, -5.79842459e-03f, 1.29177449e-02f, 4.88608554e-02f, -4.70867977e-02f,
  2.75935326e-02f, -9.92162228e-02f, 2.19239034e-02f, 9.28750932e-02f, 4.99735139e-02f, 5.98789612e-03f, -1.29585907e-01f, -7.93511122e-02f, -1.72721855e-02f, 5.17686233e-02f,
  -1.34278193e-01f, -4.54662144e-02f, -6.83994964e-02f, 7.91355371e-02f, 1.09706067e-01f, -3.14383656e-02f, 8.01005214e-02f, 7.22510070e-02f, 5.67205623e-02f, -5.19588776e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  8.25434551e-02f, 1.40277550e-01f, 3.55950445e-02f, 3.66242677e-01f, 1.51669577e-01f, -3.99972238e-02f, 3.55051547e-01f, 2.66181737e-01f, 1.36144936e-01f, 1.04817919e-01f,
  1.07760325e-01f, 2.70914018e-01f, 1.36051565e-01f, 8.29584375e-02f, 9.72118527e-02f, 8.88227895e-02f, 7.63166323e-02f, 1.37981787e-01f, 1.69324756e-01f, 9.46631283e-03f,
  1.07099429e-01f, 1.37153059e-01f, 2.28467762e-01f, 4.78365384e-02f, -5.16602583e-03f, 2.95176804e-01f, 5.55213541e-02f, 2.01288775e-01f, 1.91312999e-01f, 4.41731233e-03f,
  3.17187697e-01f, 2.39536032e-01f, 1.10716686e-01f, 1.15082758e-02f, 1.60354376e-01f, 2.84785070e-02f, 1.25137597e-01f, 1.94148347e-01f, 1.29232898e-01f, 1.78576201e-01f,
  2.29000255e-01f, 2.24567369e-01f, 2.62643427e-01f, 8.04475024e-02f, 2.10852578e-01f, 8.78068730e-02f, 1.10954292e-01f, -1.03965439e-02f, -4.74706218e-02f, 7.84709379e-02f,
  1.07363805e-01f, 1.69343993e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.13077007e-01f, 7.31783509e-02f, 1.39793143e-01f, 1.80900946e-01f, -1.36368172e-02f, -9.27274674e-03f, 1.79955848e-02f, 1.15428613e-02f, 1.39438972e-01f, -2.03919201e-03f,
  -1.79093987e-01f, -7.37075731e-02f, 1.63673997e-01f, -5.25415614e-02f, 5.23777977e-02f, -2.05328271e-01f, -1.95511077e-02f, -9.84652117e-02f, -6.26986548e-02f, 2.30415449e-01f,
  2.77996100e-02f, 9.83840004e-02f, 1.37798429e-01f, -6.69819936e-02f, 1.62530035e-01f, 2.11325344e-02f, -5.52739389e-02f, -1.64356083e-02f, -1.41332507e-01f, -7.96226710e-02f,
  1.48309439e-01f, -1.51139572e-01f, 8.44774302e-03f, 7.61268064e-02f, 2.73387935e-02f, 3.00362483e-02f, -8.70472565e-02f, 1.79932788e-01f, 1.88099667e-01f, -3.65868546e-02f,
  -1.92803089e-02f, 1.37393717e-02f, -1.43032208e-01f, -1.99691787e-01f, 8.04807022e-02f, -1.36632416e-02f, 7.06429705e-02f, 3.49116027e-02f, 7.14901136e-03f, 1.97956651e-01f,
  1.40552977e-02f, 6.19222708e-02f, -2.37288073e-01f, -1.04296014e-01f, -1.26072198e-01f, 7.34552220e-02f, -5.59978001e-03f, -4.69196662e-02f, -4.57477197e-02f, -1.96187608e-02f,
  -1.91570222e-02f, 1.42451555e-01f, 4.00134437e-02f, 4.33458434e-03f, 7.53189623e-02f, 1.68704197e-01f, 2.49280408e-02f, 1.76694728e-02f, -1.96431309e-01f, -1.54926017e-01f,
  2.52414849e-02f, -1.87567651e-01f, 1.18171439e-01f, -2.49243855e-01f, 1.67999506e-01f, 1.64022997e-01f, 1.74369767e-01f, 1.11006446e-01f, -9.65572670e-02f, -1.49442077e-01f,
  -2.25782603e-01f, 1.61530241e-01f, -1.19358808e-01f, -9.07783806e-02f, 9.03509259e-02f, 1.63721237e-02f, 1.25220597e-01f, 3.31251062e-02f, 8.11857916e-03f, 7.46947993e-03f,
  8.32565501e-03f, 1.09510519e-01f, -6.93564489e-02f, 1.80169642e-01f, -7.89332911e-02f, -5.46066687e-02f, -1.64112329e-01f, -6.65577948e-02f, -5.20713665e-02f, 1.39175057e-01f,
  -2.10368279e-02f, -8.89719650e-02f, -3.81696969e-02f, 1.89266697e-01f, 6.54958338e-02f, 5.69997318e-02f, -8.47289860e-02f, 2.98993401e-02f, -1.19588405e-01f, 9.62966904e-02f,
  1.43732503e-01f, 6.05931506e-02f, -2.14799196e-01f, -2.02567652e-02f, 1.76983804e-01f, -2.58136511e-01f, -6.59049228e-02f, 5.12579456e-02f, 2.45897368e-01f, -2.27490425e-01f,
  -2.93976367e-01f, -1.58983946e-01f, 8.40923339e-02f, 1.11845702e-01f, 8.68859738e-02f, -2.69778520e-01f, 2.23243367e-02f, -6.50565252e-02f, -3.08401674e-01f, -9.20650922e-03f,
  2.32919455e-02f, -2.10951772e-02f, -2.26489991e-01f, -7.31307343e-02f, 7.21372813e-02f, 1.51269615e-01f, 8.26221611e-03f, -1.10167392e-01f, 2.01871008e-01f, -8.46766382e-02f,
  -4.10712287e-02f, 7.32243285e-02f, -9.30792093e-02f, -2.12283120e-01f, -2.40857825e-01f, -4.34646010e-02f, -3.12284291e-01f, -1.02440827e-01f, 1.34503897e-02f, -4.32523154e-02f,
  1.59697548e-01f, -3.24370014e-03f, 5.63139655e-02f, -1.62843615e-01f, 3.48400301e-03f, 9.92981121e-02f, -5.84423169e-02f, -6.80322424e-02f, -2.38076314e-01f, 1.76398322e-01f,
  -1.12914994e-01f, -3.49929966e-02f, 1.77545279e-01f, 1.28164571e-02f, -3.62653024e-02f, -1.83052704e-01f, -2.31637992e-02f, 2.28197277e-01f, -2.07659453e-01f, 1.79117769e-01f,
  -4.91118357e-02f, -1.30279079e-01f, 6.97210059e-02f, 6.20972551e-02f, -4.52600792e-02f, 2.03606844e-01f, -8.74176770e-02f, 9.12604034e-02f, 2.47572154e-01f, 2.12881133e-01f,
  1.54899627e-01f, -8.06901306e-02f, 6.88495114e-03f, 1.97206046e-02f, 2.36912519e-02f, -1.65731102e-01f, -4.64362688e-02f, 1.64655045e-01f, 3.04132905e-02f, -8.42829421e-02f,
  -8.82640556e-02f, 5.39860837e-02f, 1.00622579e-01f, 2.54035629e-02f, -4.84069847e-02f, 4.25028093e-02f, -8.79480913e-02f, 6.10314943e-02f, 1.83647856e-01f, 7.85605684e-02f,
  3.53563428e-01f, -6.29193056e-03f, -1.43318459e-01f, 1.57101676e-01f, -1.57869533e-01f, -1.33684903e-01f, 1.01611815e-01f, 1.61170602e-01f, 2.38954425e-01f, -3.41326743e-02f,
  -6.78244010e-02f, -4.84612286e-02f, 1.06268652e-01f, 1.37621567e-01f, 1.04739502e-01f, -4.01310213e-02f, -6.43640086e-02f, -1.57952040e-01f, -2.49601156e-02f, -2.98238602e-02f,
  3.35066132e-02f, 1.15955919e-01f, 7.06800711e-05f, 3.75232100e-02f, 2.54812121e-01f, -1.71522908e-02f, -2.54973561e-01f, 1.25354663e-01f, -1.27649322e-01f, 6.56329766e-02f,
  3.34265232e-02f, -1.06218666e-01f, 1.76000729e-01f, -6.25556409e-02f, -2.53715247e-01f, 2.52777934e-01f, -1.97975468e-02f, 2.68969424e-02f, 9.63132549e-03f, 1.14533668e-02f,
  1.67191565e-01f, 5.90745173e-03f, -1.65086463e-01f, -1.99420884e-01f, -9.58250761e-02f, 1.11530006e-01f, 7.46150687e-02f, 1.19756974e-01f, -2.58824348e-01f, 9.10098851e-02f,
  -1.77572090e-02f, 7.31353611e-02f, -4.35354561e-02f, -1.74789757e-01f, 1.32677928e-01f, -8.81996304e-02f, 1.32782161e-01f, 6.89891214e-03f, -3.49790379e-02f, -8.71758312e-02f,
  7.47142807e-02f, 5.72615862e-02f, 5.32247499e-02f, -8.34777728e-02f, -3.55521925e-02f, 5.68607673e-02f, 1.64446190e-01f, 1.05926663e-01f, 2.61938497e-02f, -3.74803692e-02f,
  -7.64630511e-02f, 2.32697472e-01f, -1.22258052e-01f, 2.39024982e-02f, -1.91007871e-02f, -1.51222363e-01f, 1.40513241e-01f, 7.64997303e-02f, 2.28743553e-02f, 4.21717167e-02f,
  5.94384857e-02f, -3.28089558e-02f, 4.24325019e-02f, 1.55956194e-01f, -4.32772376e-02f, 1.19276948e-01f, -1.54760242e-01f, -1.15660794e-01f, 1.05623133e-01f, 4.79959808e-02f,
  -1.52603880e-01f, 2.72738058e-02f, -9.35132727e-02f, 3.13751064e-02f, 4.00291495e-02f, -6.43338859e-02f, -1.37908131e-01f, -1.68072790e-01f, -1.85150892e-01f, 1.19339541e-01f,
  -6.53357059e-02f, 3.28479186e-02f, 1.85292065e-01f, 2.01551899e-01f, 5.04997112e-02f, -1.14981003e-01f, 5.08366562e-02f, 5.29729277e-02f, 4.62151086e-03f, 3.20988566e-01f,
  -5.88817820e-02f, 1.62272435e-02f, -1.14180267e-01f, -1.12115152e-01f, 2.94820182e-02f, -1.67911932e-01f, -7.20266476e-02f, -6.35912195e-02f, -1.03857249e-01f, -1.12146191e-01f,
  -2.85114404e-02f, -5.12416586e-02f, -2.58110147e-02f, 4.67157690e-03f, -5.47120161e-02f, -1.60404831e-01f, 1.49704367e-01f, 1.00890502e-01f, 1.93396330e-01f, 1.25612736e-01f,
  -1.89253464e-01f, -9.99903977e-02f, -1.45395264e-01f, -2.36158147e-02f, -9.75556448e-02f, -1.94782436e-01f, 3.54282968e-02f, 2.32894141e-02f, 1.28137827e-01f, 1.98119655e-01f,
  -8.18445534e-02f, 5.25728650e-02f, 2.52550337e-02f, -8.49664211e-02f, -2.32874341e-02f, -8.40026420e-03f, -3.29593808e-04f, -4.84012589e-02f, -1.21579424e-01f, 2.93927379e-02f,
  -4.87299636e-02f, -8.21639001e-02f, 1.55958429e-01f, 1.44155875e-01f, -9.13400874e-02f, -1.94435436e-02f, 5.07521331e-02f, 2.04649627e-01f, 9.98117402e-02f, -8.60081241e-02f,
  1.17773771e-01f, 8.18808749e-02f, 9.01210457e-02f, -6.10911623e-02f, 5.32640591e-02f, -1.00952603e-01f, -5.00261076e-02f, -1.97779566e-01f, 8.09098184e-02f, 1.71851173e-01f,
  -2.56665368e-02f, 5.12620248e-02f, -4.49771658e-02f, -1.71298578e-01f, -1.09301042e-02f, -2.53633540e-02f, -2.60301847e-02f, 1.32340908e-01f, 6.13285154e-02f, -1.74923643e-01f,
  5.81258237e-02f, 1.17453352e-01f, 1.50383055e-01f, -9.72905606e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.73285636e-02f, -1.69212654e-01f, 5.50483838e-02f, 1.30823106e-01f, 1.97657093e-01f, -1.87427979e-02f, 2.70799845e-01f, -2.72055984e-01f, 1.41971678e-01f, 1.47223651e-01f,
  2.56010424e-02f, 1.80260748e-01f, 9.61515680e-02f, -1.42688096e-01f, 9.85724702e-02f, 3.33968222e-01f, 2.26660550e-01f, -3.86797041e-02f, -1.24008311e-02f, 4.21099886e-02f,
  -4.91629541e-02f, 1.79799795e-01f, 2.88746804e-02f, -1.04145139e-01f, 1.06317773e-02f, -4.57053147e-02f, -8.30136519e-03f, -5.46641275e-02f, -9.18000117e-02f, -2.59616580e-02f,
  6.66387379e-02f, -2.21245270e-02f, 3.56999129e-01f, 1.91134185e-01f, -1.68143705e-01f, 2.43210699e-02f, -2.44254488e-02f, -1.01547077e-01f, -8.45448300e-02f, 3.53442021e-02f,
  1.60422847e-01f, 4.52344343e-02f, -2.20932409e-01f, -1.26018196e-01f, 2.90741473e-01f, -9.45933014e-02f, 2.06579745e-01f, 2.28480205e-01f, 3.58074568e-02f, 8.24327618e-02f,
  -1.21244356e-01f, -9.97013673e-02f, -9.80425999e-02f, 2.84813195e-01f, 3.05058677e-02f, 7.72943944e-02f, 4.48456369e-02f, 1.01147048e-01f, 6.69754371e-02f, -6.38069585e-02f,
  6.48624673e-02f, 6.50602356e-02f, -2.80882791e-02f, 4.24498953e-02f, 7.07881153e-02f, 5.61929457e-02f, 3.08626860e-01f, 1.73503980e-01f, 2.12124690e-01f, 2.67162442e-01f,
  -1.56312674e-01f, -7.50716180e-02f, 8.94111022e-02f, -8.19901302e-02f, -3.54744762e-01f, -7.92351738e-02f, -2.13756695e-01f, 1.50206104e-01f, -4.57172208e-02f, -6.35510311e-02f,
  4.71018367e-02f, 1.36355609e-01f, 2.45362759e-01f, 5.42892158e-01f, 6.94980398e-02f, 4.52209488e-02f, 8.22344124e-02f, -1.54166192e-01f, -1.41742826e-01f, 7.85372481e-02f,
  1.32377192e-01f, -5.58541939e-02f, -1.29181007e-02f, 4.76542115e-02f, -9.60516706e-02f, 2.27421802e-02f, 8.17021057e-02f, 2.12603420e-01f, 8.25402979e-03f, 1.65986702e-01f,
  -9.99047831e-02f, 2.08727926e-01f, 1.10824695e-02f, 3.26111138e-01f, 2.70897180e-01f, 3.82473543e-02f, 3.57871741e-01f, 1.98097229e-01f, 1.98691338e-01f, 9.80757922e-02f,
  -1.05997346e-01f, -3.44810151e-02f, 1.60237432e-01f, -1.56314403e-01f, -7.83945173e-02f, -6.09633960e-02f, 1.61951423e-01f, -2.77915210e-01f, -8.10598210e-02f, 1.86260596e-01f,
  2.27738604e-01f, 2.35340357e-01f, -1.53174505e-01f, 8.52527916e-02f, 1.56547144e-01f, -3.11352640e-01f, 1.12547264e-01f, -2.18509927e-01f, 3.07101369e-01f, 1.38865143e-01f,
  7.97033906e-02f, 1.88165352e-01f, 1.36012092e-01f, 2.05358446e-01f, -2.07937479e-01f, 2.51284868e-01f, -3.21905911e-02f, 5.59353605e-02f, 1.18456379e-01f, -1.71114609e-01f,
  -8.60424489e-02f, 2.08320301e-02f, 1.03953332e-01f, 2.10506171e-02f, 1.57500982e-01f, -1.41575560e-01f, -6.39286730e-03f, -9.73792896e-02f, 6.28045350e-02f, 1.93677656e-02f,
  -9.02677998e-02f, 5.31210005e-02f, -8.36653411e-02f, 9.50902477e-02f, -1.01610206e-01f, -5.89890517e-02f, 2.99354136e-01f, -1.39184177e-01f, 1.30133256e-01f, -2.75965929e-02f,
  -1.03592277e-01f, 1.51022542e-02f, 8.91352221e-02f, 1.27766564e-01f, -1.11876372e-02f, -1.44546270e-01f, -1.00522004e-01f, -1.89259201e-01f, 1.80769321e-02f, -6.56766370e-02f,
  -4.53230068e-02f, 3.40837210e-01f, -8.16613734e-02f, 3.29085849e-02f, 2.00101361e-02f, 7.45119005e-02f, 5.16629070e-02f, 4.16556671e-02f, 1.42660275e-01f, 5.78061752e-02f,
  1.90749466e-01f, -3.20038125e-02f, 2.63054937e-01f, 2.21367493e-01f, -5.91098927e-02f, -8.58243629e-02f, 9.80097726e-02f, -1.03378920e-02f, -3.78494449e-02f, -4.46293168e-02f,
  -4.64990810e-02f, 1.17713973e-01f, 9.40416753e-02f, 1.43628135e-01f, 1.59097463e-01f, 1.49677783e-01f, -3.18528153e-02f, -7.79960630e-03f, 1.23915672e-01f, 1.05692759e-01f,
  2.20123958e-02f, 5.54101542e-02f, 4.50667851e-02f, -8.15919414e-02f, 3.43347266e-02f, -1.77820567e-02f, -4.37669493e-02f, -1.02149667e-02f, -3.66942249e-02f, 2.70541590e-02f,
  1.18197156e-02f, 2.86418259e-01f, 8.12138617e-02f, -1.11471526e-01f, 1.69935599e-01f, -1.09089985e-01f, 8.99585038e-02f, -6.54627457e-02f, 1.03601411e-01f, -2.62506362e-02f,
  7.95233101e-02f, -6.55555576e-02f, -1.52878650e-02f, -6.25115307e-03f, -1.12177931e-01f, 1.26556545e-01f, 7.84290656e-02f, -8.29598401e-03f, -3.63380760e-02f, 1.35289311e-01f,
  1.21149518e-01f, 2.08192080e-01f, -9.69534274e-03f, 4.59323339e-02f, 1.04740493e-01f, 5.00040948e-02f, 1.53655022e-01f, 4.35590781e-02f, -9.71544236e-02f, 6.90957233e-02f,
  -4.51067649e-02f, -2.47437670e-03f, 1.58305243e-01f, -1.37574762e-01f, 3.09488308e-02f, 9.71648917e-02f, -1.52642354e-01f, -5.20993732e-02f, -7.12666065e-02f, 1.25709966e-01f,
  -9.70993638e-02f, -1.10413857e-01f, 7.47875497e-02f, 1.27614170e-01f, 1.75306439e-01f, -1.16347171e-01f, -1.21564180e-01f, 1.22080632e-01f, 1.12992227e-01f, -6.35256395e-02f,
  -3.61134224e-02f, -8.40132609e-02f, -2.27207150e-02f, 5.31271286e-03f, -9.79349241e-02f, -1.35381863e-01f, 1.19514078e-01f, 1.39490977e-01f, -5.57125211e-02f, -7.67559260e-02f,
  -1.05303533e-01f, -8.64053220e-02f, -1.34005785e-01f, 6.12486601e-02f, -7.58371502e-03f, 1.54518383e-02f, 1.31455034e-01f, -9.57046300e-02f, 1.55389458e-01f, 1.30564466e-01f,
  3.35832015e-02f, -9.40502137e-02f, -1.07340522e-01f, 1.44204900e-01f, 2.46442296e-02f, 5.66615239e-02f, -1.10697858e-01f, 5.53418770e-02f, -7.67484382e-02f, -3.45149003e-02f,
  6.35252520e-02f, 1.03966091e-02f, -6.92281574e-02f, -7.51010478e-02f, -6.51179180e-02f, 1.24806218e-01f, 6.89034071e-03f, -4.69042473e-02f, 1.33673221e-01f, 1.05880953e-01f,
  1.16286322e-01f, -2.57870331e-02f, 1.75566033e-01f, 1.07408747e-01f, -2.75454745e-02f, -4.89022993e-02f, 1.72419667e-01f, 9.20385271e-02f, 9.33474451e-02f, 5.72618097e-02f,
  2.65568458e-02f, -6.09053001e-02f, -5.30891679e-02f, 5.57454936e-02f, 1.01936750e-01f, -5.06850854e-02f, -6.64080605e-02f, 7.96865895e-02f, 9.37844738e-02f, 8.32795352e-02f,
  3.68837714e-01f, 3.12409345e-02f, 1.65777192e-01f, 1.80373505e-01f, -1.12964951e-01f, 2.70885855e-01f, -4.35801409e-02f, -2.42379252e-02f, 8.52614939e-02f, 2.21709147e-01f,
  3.04814696e-01f, 7.81082660e-02f, 2.37088248e-01f, -2.45436683e-01f, 8.89345333e-02f, 4.60238487e-01f, 1.02919951e-01f, -1.31734535e-01f, -3.28453809e-01f, -2.71733195e-01f,
  1.20515279e-01f, -1.88749395e-02f, -3.20632868e-02f, 2.00468436e-01f, 1.98628917e-01f, 4.18933015e-03f, 1.53867140e-01f, 2.36309856e-01f, 3.35395962e-01f, -2.60046989e-01f,
  -7.15084374e-02f, 9.26249847e-02f, 3.04294407e-01f, -1.30271897e-01f, 7.51848221e-02f, -2.10539937e-01f, -5.34004122e-02f, -1.01456985e-01f, -1.06492057e-01f, -2.23721698e-01f,
  9.14776549e-02f, 9.69131477e-03f, -2.82457918e-01f, 4.92921680e-01f, 1.00536183e-01f, 6.98368391e-03f, -5.37373014e-02f, -1.20972991e-01f, 7.71020576e-02f, -8.09829608e-02f,
  1.47628799e-01f, -2.68426444e-03f, 1.18802309e-01f, 3.77744317e-01f, -6.22449908e-03f, 1.91024333e-01f, -1.44802466e-01f, 1.37162670e-01f, -1.77343175e-01f, -1.68790847e-01f,
  1.80536076e-01f, 2.83570942e-02f, 1.35843437e-02f, 1.02270678e-01f, -2.95126021e-01f, -4.59941104e-02f, 1.96528673e-01f, 1.37061000e-01f, -1.77306682e-02f, 6.95582777e-02f,
  -1.84017926e-01f, 1.45685613e-01f, -3.67561877e-01f, 4.59335893e-02f, -3.73239703e-02f, -2.17792150e-02f, 6.39640987e-02f, 6.36321865e-03f, -1.53750390e-01f, 3.97968441e-02f,
  -1.22530743e-01f, 1.18716836e-01f, -1.00625426e-01f, 1.12836786e-01f, -1.18084587e-01f, 1.09827720e-01f, -7.59227425e-02f, 1.49481297e-01f, -3.37824821e-02f, 1.53330714e-01f,
  1.00260161e-01f, 1.08257756e-01f, 8.99924859e-02f, 8.18625391e-02f, -1.50328442e-01f, 1.02775730e-01f, -7.75325373e-02f, 5.05401529e-02f, 2.10526377e-01f, 3.62764741e-03f,
  -1.04665207e-02f, -5.32374084e-02f, 6.41119331e-02f, 1.82810351e-01f, 1.46715157e-02f, 1.19047157e-01f, 4.43994731e-01f, -1.03588656e-01f, 1.22281775e-01f, 7.46948123e-02f,
  -5.68769276e-02f, -1.85754467e-02f, 1.96043804e-01f, -2.70572565e-02f, -3.01803788e-03f, 2.90323615e-01f, 3.15257967e-01f, -1.63988948e-01f, -2.06050098e-01f, 9.65444371e-02f,
  3.47721905e-01f, 9.61046666e-02f, 2.27178317e-02f, 1.54209331e-01f, 3.57219949e-02f, -1.28690809e-01f, -5.51035404e-02f, 1.15542701e-02f, -1.27944291e-01f, -1.26780093e-01f,
  1.03200920e-01f, 1.82813495e-01f, 2.25489214e-01f, -7.33319446e-02f, 1.32689357e-01f, -6.76540937e-03f, -7.14046061e-02f, -2.58056037e-02f, -2.59648692e-02f, -1.94581747e-01f,
  1.89556792e-01f, -1.00077707e-02f, -4.93993377e-03f, -1.83818042e-02f, 4.63588350e-03f, -8.39208364e-02f, 7.17028156e-02f, -1.10323697e-01f, -2.76400410e-02f, 1.01891719e-01f,
  6.64217174e-02f, 1.30192384e-01f, 9.02040899e-02f, 5.85688427e-02f, 1.18921772e-01f, 1.14033990e-01f, -1.44318983e-01f, -1.32929698e-01f, 1.40983701e-01f, 2.81538200e-02f,
  -1.53492829e-02f, 3.17895785e-02f, 1.56635702e-01f, 1.63486913e-01f, -1.14866551e-02f, -8.71957652e-03f, 4.54017669e-02f, 2.77629524e-01f, -2.82590464e-02f, 3.12906131e-02f,
  2.88013875e-01f, -2.66186863e-01f, -4.28591482e-03f, 8.63398984e-02f, -3.50661948e-02f, -8.98999423e-02f, -2.08246872e-01f, 9.07173846e-03f, 1.18011624e-01f, 6.04217313e-02f,
  1.89461246e-01f, -3.10685728e-02f, -1.37485027e-01f, 1.11827236e-02f, 1.35180414e-01f, 4.24385490e-03f, -2.27305833e-02f, -8.33516046e-02f, -3.46706882e-02f, 1.81882039e-01f,
  -2.88442802e-02f, 1.80618390e-01f, 9.59967915e-03f, 1.35917455e-01f, -4.25686613e-02f, 1.35598853e-01f, 2.48320013e-01f, 7.37212552e-03f, 1.18054766e-02f, -2.26483807e-01f,
  9.78079364e-02f, 8.60373303e-02f, 1.39040083e-01f, 2.32754141e-01f, -9.15200114e-02f, -3.82445827e-02f, 1.98490217e-01f, 2.27277249e-01f, 2.13179052e-01f, 6.74913870e-03f,
  1.10581089e-02f, -5.05631603e-02f, 2.59463266e-02f, -3.76322046e-02f, -1.11092195e-01f, 8.54954273e-02f, -1.24836117e-01f, 2.03347113e-03f, 2.23940760e-02f, 2.29707453e-02f,
  1.24118321e-01f, -5.95031260e-03f, -6.82059526e-02f, 1.24135613e-02f, 2.64493555e-01f, 1.17737830e-01f, -1.40939161e-01f, -9.12269801e-02f, -2.04855409e-02f, 5.14237583e-02f,
  -9.13738981e-02f, -2.22517148e-01f, 1.37378186e-01f, -6.66782409e-02f, -1.20445304e-01f, 5.73128127e-02f, 2.29570214e-02f, 8.05697963e-03f, 2.15327010e-01f, -9.86031517e-02f,
  -2.37952136e-02f, -1.73384622e-01f, -1.34875596e-01f, 9.32701305e-02f, 5.20892814e-02f, 2.47783795e-01f, 2.56143183e-01f, 1.42494798e-01f, -1.09589472e-01f, -8.13796893e-02f,
  4.97573316e-02f, 1.36443287e-01f, 5.83140031e-02f, -8.21813270e-02f, 6.04615659e-02f, 9.66833308e-02f, -2.78741270e-02f, 5.20076975e-02f, 6.30069748e-02f, 2.59998385e-02f,
  -1.20121576e-01f, 6.51600137e-02f, -3.69896330e-02f, 5.27037457e-02f, -2.10371122e-01f, 8.86755362e-02f, 5.53244464e-02f, 5.01038842e-02f, 1.10927075e-01f, 1.04638174e-01f,
  -3.66448238e-02f, -1.47988796e-01f, 1.12667687e-01f, -3.74951325e-02f, 1.61718413e-01f, 1.05125681e-01f, 5.87026216e-02f, 8.74011368e-02f, -1.75910205e-01f, 1.47217572e-01f,
  -4.56630774e-02f, 8.47946852e-02f, -2.73235561e-03f, 7.52763003e-02f, -4.38031480e-02f, 1.20071709e-01f, 1.59285828e-01f, -5.12230247e-02f, -4.36399095e-02f, 6.70484174e-03f,
  1.65618867e-01f, -9.98895392e-02f, -1.74459904e-01f, 2.56586075e-01f, 1.49503797e-01f, -1.70148149e-01f, 9.32321846e-02f, -1.65606245e-01f, 1.17005385e-01f, -1.21389583e-01f,
  -2.44719791e-03f, -1.41665936e-01f, -6.48391172e-02f, -1.29650114e-02f, 8.34342316e-02f, -2.42829993e-02f, -1.12396516e-01f, 1.51643172e-01f, 7.31485486e-02f, 2.89530810e-02f,
  1.01236887e-02f, -3.06086056e-02f, 1.96213856e-01f, -4.26574126e-02f, 2.33364217e-02f, -5.43090180e-02f, -1.17637932e-01f, 1.54380083e-01f, -1.52003523e-02f, 6.24311715e-02f,
  1.01159386e-01f, 1.76054075e-01f, -3.64671685e-02f, 1.75076723e-01f, 1.85707375e-01f, 1.91393986e-01f, 8.98326486e-02f, -1.86960042e-01f, -9.22150612e-02f, -3.45968548e-03f,
  3.41407433e-02f, 1.14413537e-02f, 2.08685338e-01f, -3.81078087e-02f, 2.11653970e-02f, 2.72158802e-01f, -2.30998039e-01f, -1.12134323e-01f, -6.04005568e-02f, 4.92053330e-02f,
  1.10548720e-01f, -5.52050397e-02f, 1.46606371e-01f, 2.58824468e-01f, 2.29662836e-01f, 7.27310916e-03f, -1.05506647e-02f, 2.51269154e-02f, 4.32223864e-02f, 3.47622186e-02f,
  1.83260422e-02f, 9.02838539e-04f, 9.54203829e-02f, -1.38664931e-01f, 1.66773275e-01f, -4.34852205e-02f, -8.42346400e-02f, -4.30168696e-02f, 5.91485389e-02f, 2.12353915e-01f,
  5.33429021e-03f, 2.28450857e-02f, -2.17807316e-03f, -1.39038950e-01f, 1.92109421e-02f, 1.36711756e-02f, 1.13003328e-01f, 6.47742823e-02f, -6.49746358e-02f, -1.60382763e-01f,
  -1.47962142e-02f, 1.01121165e-01f, -3.19299176e-02f, 2.19677374e-01f, -2.52824780e-02f, 4.04654555e-02f, -1.63477615e-01f, -1.53081730e-01f, 1.29077537e-02f, -6.55471087e-02f,
  -7.21169189e-02f, -7.94318393e-02f, -1.49567142e-01f, -1.48293957e-01f, 1.08847141e-01f, 1.77037656e-01f, 5.61719760e-04f, 1.40772268e-01f, 1.29096955e-01f, 2.09508210e-01f,
  4.90023941e-02f, -6.90761730e-02f, -3.90888453e-01f, -2.73561962e-02f, 1.71659216e-01f, -6.36380389e-02f, 3.26242238e-01f, 1.02573954e-01f, -1.54233187e-01f, 3.15344632e-01f,
  -1.93721130e-01f, 9.76603702e-02f, -1.68424591e-01f, 5.58415353e-02f, -5.67716919e-02f, 1.29392743e-01f, 2.00448409e-01f, 2.59350866e-01f, 2.12650880e-01f, -1.07145332e-01f,
  1.31373212e-01f, 2.43712828e-01f, -1.03744328e-01f, -1.40302209e-03f, -1.11014389e-01f, 1.51213497e-01f, -1.19836710e-01f, -1.33188367e-01f, 1.36932373e-01f, -1.04067326e-01f,
  -7.26718679e-02f, 3.21646146e-02f, 1.47114933e-01f, 3.13996077e-01f, -3.58970240e-02f, 1.48969591e-01f, 2.62544721e-01f, -1.18842915e-01f, 1.97230503e-01f, 1.77053407e-01f,
  1.55115336e-01f, 1.10249832e-01f, -2.63852533e-02f, -8.87531564e-02f, 2.55305260e-01f, 5.74244447e-02f, 1.93951875e-01f, 1.70400739e-01f, -1.36580318e-01f, 1.31940451e-02f,
  1.97963223e-01f, -1.13334067e-01f, -1.41076103e-01f, -1.43315881e-01f, 9.02464613e-02f, 3.29721607e-02f, 9.32604596e-02f, -2.29265556e-01f, -5.62820025e-02f, 1.31403744e-01f,
  6.70371354e-02f, 1.53109252e-01f, 1.30068399e-02f, -1.15795545e-01f, -1.86926743e-03f, -1.08725250e-01f, 1.28091797e-01f, 7.15616345e-02f, -1.24820963e-01f, 5.52985743e-02f,
  -2.97774263e-02f, -4.57306206e-02f, -9.18116197e-02f, -5.16374037e-02f, 5.38188592e-02f, 3.28954458e-02f, 1.03465013e-01f, 4.39743176e-02f, -1.01014912e-01f, -8.27071164e-03f,
  -2.62087919e-02f, -1.32364789e-02f, 1.15690902e-01f, -1.32712290e-01f, 1.34811804e-01f, -8.82876217e-02f, 2.53018234e-02f, -1.23786107e-01f, 8.70946124e-02f, 9.80240330e-02f,
  9.13876444e-02f, -2.39675603e-04f, 8.25940371e-02f, -7.86744952e-02f, -2.44893823e-02f, 3.82065363e-02f, 7.80288726e-02f, 9.59934145e-02f, -1.13543063e-01f, 1.01322494e-01f,
  3.87481861e-02f, 4.30356413e-02f, 7.41912499e-02f, -7.09197745e-02f, -8.02320614e-02f, -1.84716955e-02f, 9.76087004e-02f, 4.94170673e-02f, 7.71732926e-02f, -1.35829663e-02f,
  5.18610440e-02f, -1.22791706e-02f, -3.49668786e-02f, 6.39453903e-02f, 4.82178293e-02f, 9.78852734e-02f, -5.38691357e-02f, 3.18944491e-02f, -6.22400045e-02f, -2.06288435e-02f,
  9.20445770e-02f, 2.50496948e-03f, 1.12764603e-02f, 7.55962506e-02f, 1.83554798e-01f, 1.84075132e-01f, 8.78254771e-02f, -1.14373326e-01f, 9.63008404e-02f, -1.83484331e-01f,
  -7.84850195e-02f, -1.32293388e-01f, 1.09510049e-01f, 3.11376154e-01f, -4.01773863e-02f, 4.34512608e-02f, 1.32256635e-02f, -5.62259033e-02f, 1.00529060e-01f, -6.24927953e-02f,
  1.83317676e-01f, 7.18500167e-02f, -5.08426763e-02f, -1.17737344e-02f, 3.87467630e-02f, -6.11928441e-02f, -1.69240147e-01f, -5.18185273e-02f, 1.05917826e-01f, 9.83864367e-02f,
  -8.95735435e-03f, 2.30464935e-01f, -9.06193480e-02f, -9.88207757e-02f, -8.68114531e-02f, 1.42322659e-01f, 8.68692398e-02f, -3.34727503e-02f, -7.34301051e-03f, 2.00410739e-01f,
  5.50929010e-02f, -1.50469244e-01f, 1.41579747e-01f, -9.94631723e-02f, 2.36942079e-02f, -1.88051560e-03f, 2.20526792e-02f, -8.00693780e-02f, 3.31566215e-01f, 1.34949923e-01f,
  5.05808555e-02f, 6.14867918e-02f, 1.30117796e-02f, -3.37322392e-02f, 2.48616183e-04f, 5.33286445e-02f, 3.83484274e-01f, -6.89352825e-02f, -1.45777345e-01f, -1.30862549e-01f,
  -9.97821894e-03f, -1.16842672e-01f, 5.55163436e-02f, 2.20840991e-01f, -6.46104068e-02f, 7.35405535e-02f, 1.38434380e-01f, -5.09776117e-04f, -5.93756624e-02f, 3.22239697e-02f,
  5.09926639e-02f, 9.77352783e-02f, -4.05286737e-02f, -3.76636982e-02f, -2.61368006e-01f, 1.85277224e-01f, 1.97120041e-01f, -1.32011697e-01f, 3.25966418e-01f, -9.44625437e-02f,
  -6.81496561e-02f, 1.83784634e-01f, -2.52968103e-01f, -2.09173143e-01f, -1.20070837e-01f, -9.25116837e-02f, -1.19643800e-01f, 4.78705801e-02f, -2.82387212e-02f, 3.30212861e-01f,
  9.90834907e-02f, -4.62647639e-02f, -5.93191460e-02f, 1.07145749e-01f, 5.88471442e-02f, -7.78314397e-02f, -3.33082187e-03f, -8.32823440e-02f, -2.00523925e-03f, 2.26812977e-02f,
  1.82286873e-01f, -5.09367250e-02f, -7.29474332e-03f, 6.26029670e-02f, 9.45356563e-02f, -3.56038697e-02f, -1.95969552e-01f, -1.07915431e-01f, 1.70963898e-01f, -1.36621788e-01f,
  8.60039368e-02f, 1.55250207e-01f, 2.25028973e-02f, 1.93389252e-01f, -9.37413946e-02f, -8.62942357e-03f, 1.21256486e-01f, 3.12816739e-01f, 1.68927044e-01f, 2.45357394e-01f,
  6.98278248e-02f, 1.04144990e-01f, 7.96262175e-02f, 1.12328464e-02f, 1.34615585e-01f, -1.79634526e-01f, -8.51947218e-02f, 1.36619627e-01f, 4.85886671e-02f, 1.16584944e-02f,
  -7.52677172e-02f, 2.66229082e-02f, 9.71308872e-02f, 1.05520286e-01f, 1.97633216e-03f, 3.25165391e-02f, -9.05758664e-02f, -4.81984466e-02f, -2.07293570e-01f, 9.81379524e-02f,
  -7.78758153e-02f, -1.44890547e-01f, -3.32254320e-02f, -9.66866389e-02f, 7.50042731e-03f, -1.98181141e-02f, 6.44616038e-02f, -2.17494853e-02f, 2.33591154e-01f, 1.28783792e-01f,
  -1.50765941e-01f, 1.01191089e-01f, -8.04316923e-02f, 7.44772404e-02f, -1.28405109e-01f, 1.29131228e-01f, 1.17425561e-01f, 4.20316383e-02f, -1.18283525e-01f, 8.90789554e-02f,
  -3.98149155e-03f, -3.01137883e-02f, -3.09618451e-02f, 1.89025328e-01f, -3.72498147e-02f, -1.50808692e-01f, -2.05590770e-01f, 2.43710846e-01f, -2.62780493e-04f, -2.01543216e-02f,
  1.73017710e-01f, -1.65899709e-01f, 3.09066176e-01f, -7.29140192e-02f, 1.79742798e-01f, -2.99598724e-02f, -6.10954016e-02f, -9.73024070e-02f, 1.94579527e-01f, -1.95726961e-01f,
  -3.50802951e-02f, -1.89325232e-02f, -2.73325741e-02f, -1.06871732e-01f, -9.05748978e-02f, 2.12114975e-01f, 3.86848450e-01f, 1.85501739e-01f, 1.82788912e-02f, 4.67552766e-02f,
  1.10160738e-01f, 1.05032444e-01f, 9.69629213e-02f, -1.13711283e-02f, 7.78962001e-02f, 2.07690820e-01f, 8.51672143e-02f, 1.35586783e-01f, 2.98869580e-01f, -7.97108784e-02f,
  -2.75807269e-02f, -1.59012880e-02f, 1.64065674e-01f, -8.63728300e-03f, -9.28841233e-02f, -7.63282329e-02f, -1.08810678e-01f, 8.17061886e-02f, 1.37701901e-02f, 1.58256292e-01f,
  2.29033530e-01f, -2.12554149e-02f, 2.45995164e-01f, -1.21276081e-01f, -9.88393798e-02f, -7.20743462e-03f, 7.76006728e-02f, -8.49704519e-02f, -9.70879793e-02f, 4.27586921e-02f,
  -3.86435539e-02f, -7.97393359e-03f, -8.97937790e-02f, 9.89155769e-02f, 8.36804137e-02f, -1.01703145e-01f, 9.40493271e-02f, -8.42082873e-02f, 1.57922059e-02f, 8.56440421e-03f,
  -4.35351208e-02f, -6.65487722e-03f, -1.10622823e-01f, -2.41484419e-02f, 7.35785663e-02f, 8.09405074e-02f, 1.12784794e-02f, 6.29009604e-02f, 7.85644054e-02f, 4.97206524e-02f,
  -6.73187375e-02f, -4.13663983e-02f, -1.42319426e-01f, -8.76383334e-02f, 4.08348925e-02f, -3.28688510e-02f, -2.63779815e-02f, -1.49744684e-02f, -5.33243455e-02f, 3.27841975e-02f,
  6.82549998e-02f, -7.14485571e-02f, 5.94144538e-02f, 8.45302418e-02f, -6.77788034e-02f, 1.72636047e-01f, 4.36442085e-02f, 2.21935064e-02f, 2.08907470e-01f, 2.41815567e-01f,
  -1.19799845e-01f, 2.28314728e-01f, 2.35863432e-01f, 2.40669802e-01f, -3.58805731e-02f, -2.13678211e-01f, 3.71626392e-02f, 1.59334287e-01f, 1.02619074e-01f, 2.02084556e-01f,
  8.27150717e-02f, 1.26131624e-01f, 1.49261266e-01f, 2.93734759e-01f, 7.82957450e-02f, 9.25786048e-03f, 3.92318740e-02f, 1.41535059e-01f, -1.02933832e-02f, 1.64068595e-01f,
  4.24044356e-02f, 1.72134459e-01f, 1.08971305e-01f, 4.95687760e-02f, -1.00272097e-01f, -1.29530370e-01f, 1.18446246e-01f, 8.32309797e-02f, 1.53071165e-01f, -7.35286474e-02f,
  -3.16065340e-03f, -1.07072957e-01f, -5.72565384e-02f, -5.04939854e-02f, -1.19817086e-01f, 9.22292024e-02f, 2.54657539e-03f, -1.03734992e-01f, -1.31786312e-03f, -3.56379859e-02f,
  -5.06157242e-02f, -4.03145701e-02f, -1.97750498e-02f, -6.33841828e-02f, -2.60928515e-02f, -1.21664904e-01f, -6.22253269e-02f, -6.40004054e-02f, 5.93474843e-02f, -6.47625513e-03f,
  -2.88285371e-02f, 2.00770628e-02f, -4.04266156e-02f, 9.70423280e-05f, -1.87817693e-01f, 8.96869302e-02f, 7.18219131e-02f, 9.38503891e-02f, -9.75507051e-02f, 3.13501321e-02f,
  -1.17902130e-01f, 8.80893096e-02f, -1.31369948e-01f, 7.44119734e-02f, -7.62265623e-02f, 3.23971286e-02f, 1.18562160e-02f, -2.17064526e-02f, -1.14664391e-01f, 9.86870229e-02f,
  -2.52313586e-03f, -9.32524055e-02f, 3.27472426e-02f, -1.02450266e-01f, -2.61367690e-02f, -1.04590610e-01f, -7.73201287e-02f, -6.95844218e-02f, 2.93402374e-02f, -4.28476110e-02f,
  4.62232605e-02f, 9.80161503e-02f, 4.89722937e-02f, 2.38372236e-02f, -1.27690122e-01f, 9.60323662e-02f, -5.63650280e-02f, -5.68747036e-02f, 1.08675785e-01f, 9.28390846e-02f,
  -1.12924293e-01f, 7.88744166e-02f, -1.10006355e-01f, -6.26907647e-02f, -9.80447531e-02f, -3.70545057e-03f, 7.22832680e-02f, -2.36067772e-02f, -4.98344935e-02f, 1.16725437e-01f,
  -9.92763042e-02f, -6.03258982e-03f, -3.53939757e-02f, 1.55611744e-03f, -1.93342613e-03f, -6.33745641e-02f, -6.93782493e-02f, 4.88945842e-02f, 5.74757196e-02f, 8.58764052e-02f,
  3.44351046e-02f, -1.22802921e-01f, -9.22134593e-02f, -8.13456327e-02f, 3.82797532e-02f, -1.25424815e-02f, 1.25203878e-01f, -2.08056215e-02f, 9.82079469e-03f, -6.84027225e-02f,
  3.87404002e-02f, 1.30706713e-01f, -4.83374447e-02f, -1.31569445e-01f, -5.82262757e-04f, 3.96311954e-02f, -1.34528503e-01f, 2.05600099e-03f, 9.26121622e-02f, 1.42599359e-01f,
  1.13370836e-01f, 2.38360465e-01f, -6.73702136e-02f, 1.84798211e-01f, -1.39803708e-01f, -2.58963425e-02f, 1.08015604e-01f, -4.37207632e-02f, -1.31349072e-01f, 2.16100477e-02f,
  2.23461300e-01f, -2.20285673e-02f, 1.54887915e-01f, 1.67631999e-01f, 1.42087698e-01f, 3.81505024e-03f, 1.09801233e-01f, -4.02895063e-02f, -1.01729490e-01f, 8.58716667e-02f,
  -1.19283460e-01f, 3.28711063e-01f, -1.32450879e-01f, 3.34615819e-02f, 2.52085865e-01f, 1.32533506e-01f, -1.05046958e-01f, 3.51537436e-01f, 3.42810713e-02f, -5.61678037e-02f,
  2.82774210e-01f, 2.38544211e-01f, 8.87381211e-02f, -1.29586995e-01f, -1.19790681e-01f, -6.12023175e-02f, 9.50829983e-02f, 4.11180966e-02f, 2.28086993e-01f, 3.29150170e-01f,
  -6.00942858e-02f, 8.92910808e-02f, 8.30608159e-02f, -5.40656038e-02f, 6.20301664e-02f, -1.36453405e-01f, 7.48348758e-02f, -8.01600814e-02f, 3.19821149e-01f, -1.25540033e-01f,
  2.90780127e-01f, 2.41175070e-01f, -1.85719635e-02f, -7.90161416e-02f, 8.58005583e-02f, 3.38435322e-01f, 3.37959155e-02f, -2.02208221e-01f, -2.56544780e-02f, 9.42628309e-02f,
  8.23213235e-02f, 7.40816351e-03f, -2.07338352e-02f, -5.12867793e-02f, 1.27965853e-01f, -9.78307649e-02f, -4.38212119e-02f, 1.28863081e-02f, -1.27985522e-01f, 9.78565738e-02f,
  -3.14301625e-02f, 9.14205462e-02f, -7.26748034e-02f, 5.66182956e-02f, 6.21010736e-02f, 6.83556125e-02f, 5.41968085e-02f, 2.42924727e-02f, 7.08171651e-02f, 5.55682974e-03f,
  -1.00059710e-01f, -3.23665552e-02f, -1.15988620e-01f, 8.51644725e-02f, -9.41988453e-02f, 1.01732358e-01f, 2.02272385e-02f, 3.53158801e-04f, 8.85140523e-02f, 7.87035301e-02f,
  1.48963645e-01f, 4.22081724e-02f, -7.38358647e-02f, 1.03274565e-02f, 3.03188921e-03f, 4.17355224e-02f, 9.77457762e-02f, 5.65094315e-02f, -1.06174439e-01f, -1.37939498e-01f,
  -1.10915959e-01f, 6.72144815e-02f, 1.74904063e-01f, -3.38607654e-02f, -4.55472171e-02f, 1.26198366e-01f, -1.13359550e-02f, -1.10659033e-01f, 1.70306605e-03f, 1.11606471e-01f,
  -8.18984583e-03f, -7.38319661e-03f, -1.10287756e-01f, -3.06197517e-02f, 5.56757748e-02f, -8.78624395e-02f, -8.14172179e-02f, -7.01394752e-02f, -6.12508357e-02f, 2.08854824e-02f,
  2.07502600e-02f, 1.87582567e-01f, -7.54040927e-02f, 3.24722081e-02f, 3.38188589e-01f, 4.46227789e-02f, 1.53184414e-01f, 2.65247375e-01f, 1.01916835e-01f, -7.09105879e-02f,
  3.71491835e-02f, 5.57333454e-02f, 1.92800790e-01f, -1.43541574e-01f, -9.58873704e-02f, -1.14919223e-01f, -8.33337083e-02f, -5.36655411e-02f, 8.82579684e-02f, -1.40418097e-01f,
  -2.57202163e-02f, 1.68511290e-02f, 9.09582376e-02f, 1.92654833e-01f, 9.16224811e-03f, 9.46427137e-03f, 5.84543347e-02f, -1.59635127e-01f, -1.09339179e-02f, -1.64599553e-01f,
  3.84164043e-02f, 3.40800472e-02f, 7.42058158e-02f, 9.93555710e-02f, 2.44388238e-01f, -1.62079513e-01f, -1.41004190e-01f, 1.78141966e-02f, -1.66388318e-01f, 1.53565988e-01f,
  -1.80006072e-01f, 3.00918549e-01f, -9.26178880e-03f, 1.48628742e-01f, -6.82664523e-03f, -1.44810423e-01f, 7.49208406e-02f, -5.82586676e-02f, 8.87615308e-02f, -8.30184370e-02f,
  -3.75601761e-02f, -5.01101948e-02f, 1.01441592e-01f, 1.61076143e-01f, -1.25799060e-01f, -9.82687920e-02f, 1.06464271e-02f, -1.83009021e-02f, 1.42672166e-01f, 7.01982528e-02f,
  4.87476215e-02f, -4.06764261e-02f, 8.75874236e-03f, 2.88589764e-02f, 9.30559933e-02f, 2.52922356e-01f, -1.53052965e-02f, -1.36449849e-02f, 1.75525889e-01f, 2.23292068e-01f,
  6.33372590e-02f, 2.23711774e-01f, 1.59553796e-01f, 3.50897899e-04f, -1.87390611e-01f, 6.94612637e-02f, 3.89241308e-01f, -1.25767708e-01f, 1.62436262e-01f, -1.80090562e-01f,
  -1.36264384e-01f, 2.85355728e-02f, 1.33549139e-01f, -1.28616348e-01f, -3.58189084e-02f, 3.50764692e-02f, 1.00501709e-01f, -1.12365656e-01f, 1.50800556e-01f, -6.74379617e-02f,
  1.20947838e-01f, -7.74499029e-02f, 5.23258261e-02f, 2.18255043e-01f, -2.93410346e-02f, -1.68053076e-01f, 2.78288692e-01f, -4.77259345e-02f, 2.46526614e-01f, 2.11544111e-01f,
  1.67637020e-01f, 2.63533127e-02f, -6.53376952e-02f, 2.00395197e-01f, 3.58685888e-02f, 1.34171858e-01f, -8.89610648e-02f, -1.38183221e-01f, 2.97483001e-02f, 1.41031845e-02f,
  -1.90899391e-02f, 3.92424077e-01f, 2.82706469e-02f, 8.91612992e-02f, 1.42898142e-01f, 3.90029587e-02f, 1.80793982e-02f, 1.27850562e-01f, -1.43916935e-01f, -4.37335186e-02f,
  1.24820463e-01f, -8.11959803e-02f, 3.13429981e-01f, 2.65126854e-01f, -1.08916901e-01f, -6.05970360e-02f, 2.03221038e-01f, 1.33044645e-01f, -8.00019950e-02f, 2.10199818e-01f,
  6.21528290e-02f, 3.35066557e-01f, 7.91850537e-02f, 1.44814607e-02f, -2.09834389e-02f, 1.62535772e-01f, 1.76995799e-01f, -2.57852692e-02f, 1.74257353e-01f, -3.29924468e-03f,
  2.86705852e-01f, -5.25561199e-02f, -4.67674509e-02f, -1.07543923e-01f, 2.67266035e-02f, 1.02365878e-03f, -2.64796596e-02f, -9.44206715e-02f, -9.49209854e-02f, 9.95553657e-02f,
  1.22683756e-01f, 8.70831758e-02f, 9.20798630e-02f, 2.33165603e-02f, -2.86229104e-02f, -1.44445971e-01f, -8.29827338e-02f, 6.26540482e-02f, -5.31140603e-02f, -4.58423011e-02f,
  -6.07128069e-02f, -2.14048345e-02f, 5.96877523e-02f, -2.87538078e-02f, 7.09889978e-02f, -5.05498014e-02f, 1.21968783e-01f, 1.53630763e-01f, -1.61403825e-03f, 2.55266368e-01f,
  1.53096452e-01f, -1.09453537e-01f, -8.33420381e-02f, 7.43164681e-03f, -1.47077799e-01f, -4.26261686e-02f, -3.97837721e-02f, -2.40289066e-02f, 1.55567035e-01f, -2.31500203e-03f,
  5.19780517e-02f, 2.42553785e-01f, -1.14040487e-02f, -1.55386049e-02f, -1.26241207e-01f, 5.78095904e-03f, 2.17308119e-01f, 2.95411851e-02f, -1.02344364e-01f, -1.14181519e-01f,
  1.60901144e-01f, 4.32716422e-02f, 2.19307244e-02f, 2.57954299e-01f, -1.04105860e-01f, 2.36076742e-01f, -8.47405940e-03f, 9.09566209e-02f, -4.86594997e-03f, 7.13526309e-02f,
  1.77159950e-01f, 1.62489470e-02f, 2.24260874e-02f, 1.22348078e-01f, 2.36418486e-01f, 2.80400505e-03f, 1.14033677e-01f, -8.56658593e-02f, -1.16284527e-01f, -7.00633302e-02f,
  5.98672926e-02f, -1.80280041e-02f, -2.66452180e-03f, 1.70303509e-02f, -1.63698286e-01f, -6.34259507e-02f, 7.38700852e-02f, -1.01617232e-01f, 5.47414012e-02f, -1.07551567e-01f,
  1.56858236e-01f, 1.37080178e-02f, -6.02131039e-02f, 1.02713503e-01f, 1.57247275e-01f, 6.41022921e-02f, 1.43895224e-01f, 1.69707984e-01f, 1.36516050e-01f, -1.20364018e-01f,
  2.08864823e-01f, 1.22761846e-01f, 6.33035749e-02f, -1.03568155e-02f, -9.55744833e-02f, 1.03286348e-01f, 1.27395391e-01f, 9.74355265e-02f, -7.79817626e-02f, 6.57674447e-02f,
  -8.07785839e-02f, -7.77818561e-02f, -2.17090081e-02f, -1.29999787e-01f, -1.38603419e-01f, -2.47039758e-02f, 1.01582445e-01f, 4.82915156e-02f, 1.22893743e-01f, 3.42570581e-02f,
  -5.27152121e-02f, -2.54903128e-03f, -3.46531570e-02f, 5.46507463e-02f, 2.11129766e-02f, 1.58586994e-01f, 6.52474537e-02f, 2.15934619e-01f, 6.16859198e-02f, 2.82462865e-01f,
  -1.19911082e-01f, -1.14769876e-01f, -3.42066139e-02f, -4.04259302e-02f, 4.13249470e-02f, -8.55071396e-02f, 6.99326620e-02f, 2.84842011e-02f, 7.67105967e-02f, 4.15816950e-03f,
  2.17106752e-02f, 7.35902861e-02f, -6.49932176e-02f, 8.38114247e-02f, -9.06026289e-02f, 4.84858491e-02f, 1.00397192e-01f, -8.49685520e-02f, 5.64983860e-02f, 2.40412615e-02f,
  1.06984256e-02f, -2.80107930e-02f, -7.91978613e-02f, 3.07466667e-02f, 7.83427581e-02f, -6.54293131e-03f, -5.27320243e-02f, 6.73073437e-03f, -1.16087042e-01f, -1.24926537e-01f,
  -8.65531936e-02f, -1.09578565e-01f, 1.01126358e-01f, -6.70827702e-02f, 2.83971690e-02f, -7.01713748e-03f, 6.67856336e-02f, 6.86299987e-03f, 7.30508938e-02f, -3.13678011e-02f,
  -2.59224977e-02f, 6.32964000e-02f, -4.11313511e-02f, 1.02297686e-01f, -2.99183764e-02f, 1.17369987e-01f, 1.02917999e-01f, 7.83118531e-02f, 1.26598760e-01f, -5.60549181e-03f,
  -6.16774634e-02f, 4.80137132e-02f, 5.91827631e-02f, -8.81003588e-02f, -7.32473210e-02f, 3.57804745e-02f, 7.24624470e-02f, 2.98330113e-02f, -4.29480299e-02f, -3.56459133e-02f,
  4.13894132e-02f, 8.37778151e-02f, 9.71046165e-02f, -1.88830756e-02f, 1.08736783e-01f, -4.12841998e-02f, 1.83895379e-01f, 9.48971435e-02f, 1.94381937e-01f, -1.29257530e-01f,
  -1.65761322e-01f, 1.58526033e-01f, 3.33162010e-01f, -1.58690467e-01f, -2.34246865e-01f, -4.26645786e-01f, 3.73248756e-02f, -1.14582710e-01f, -8.38058144e-02f, -1.12926699e-02f,
  2.04135504e-04f, 3.43964137e-02f, -6.43255338e-02f, 8.18927363e-02f, 1.48418054e-01f, -1.41991019e-01f, 3.97652984e-02f, 1.46335131e-02f, 2.03331977e-01f, -2.21267655e-01f,
  -1.97575446e-02f, 1.62393332e-01f, 3.01282294e-03f, -8.88680965e-02f, 1.44913018e-01f, 2.33792454e-01f, 5.85044101e-02f, 4.96061891e-02f, 1.34458154e-01f, 1.63819835e-01f,
  1.63224507e-02f, -6.08126372e-02f, -1.25161991e-01f, 4.28324044e-01f, -5.58354296e-02f, 2.66907185e-01f, 2.06211820e-01f, -1.91176485e-03f, -2.63640452e-02f, 5.18887863e-02f,
  -3.09495386e-02f, -4.06338684e-02f, -2.33120427e-01f, 2.84952037e-02f, 2.78456837e-01f, 7.39222690e-02f, 1.43627033e-01f, -6.74771070e-02f, -2.81797312e-02f, 2.80491747e-02f,
  -1.19548719e-02f, 6.21226523e-03f, 1.02151610e-01f, -1.35410214e-02f, -1.95188783e-02f, 1.60600282e-02f, 1.24607468e-02f, 3.47658657e-02f, -2.61296495e-03f, -4.09539379e-02f,
  1.25221282e-01f, 9.20274258e-02f, 3.09898034e-02f, 1.33442611e-01f, 5.03386632e-02f, -6.49003386e-02f, -3.28125320e-02f, -7.23205209e-02f, -2.21778646e-01f, 4.15953062e-02f,
  -9.34469327e-02f, -8.03348646e-02f, 7.77784437e-02f, 1.58581480e-01f, 7.76165277e-02f, 1.18423462e-01f, -8.40318389e-04f, 3.39961678e-01f, -8.22123662e-02f, 3.48069258e-02f,
  9.63778570e-02f, 5.45317680e-02f, -1.23192139e-01f, -1.07412897e-01f, -1.62482932e-02f, 6.61015809e-02f, -2.63993833e-02f, -1.31041696e-02f, -8.22536349e-02f, 3.19258720e-02f,
  5.17437160e-02f, 2.20244918e-02f, 8.50219727e-02f, -3.95472683e-02f, -1.38730049e-01f, 1.65497571e-01f, 4.28239990e-04f, 4.66616601e-02f, 1.34551570e-01f, 2.55817436e-02f,
  3.17828506e-01f, -8.22077170e-02f, -1.99065395e-02f, -7.37140030e-02f, -1.20727688e-01f, 8.08063224e-02f, 1.29069120e-01f, -3.99405509e-02f, 1.18099183e-01f, 1.11753277e-01f,
  1.00996792e-01f, 1.36847384e-02f, -1.97726741e-01f, -4.34862934e-02f, 3.22509229e-01f, 1.17899723e-01f, 6.57238588e-02f, -6.12196466e-03f, 6.74341321e-02f, -2.07150206e-02f,
  1.62349343e-01f, -4.46510315e-02f, 2.01654360e-02f, 1.71092898e-01f, -7.77015239e-02f, 1.51710838e-01f, 6.07749932e-02f, -5.17858826e-02f, 1.24920383e-02f, 2.04550289e-02f,
  -2.39915937e-01f, -1.54709235e-01f, 2.23178551e-01f, 1.43832237e-01f, 9.04329028e-03f, 8.31595659e-02f, -5.25896484e-03f, -6.89298138e-02f, -1.41601071e-01f, -1.16138393e-02f,
  1.37416929e-01f, -1.10074103e-01f, 2.69650817e-02f, -1.35990500e-01f, -7.13764597e-03f, 7.78626800e-02f, -7.06727207e-02f, 5.42478673e-02f, -1.18944913e-01f, 9.21435803e-02f,
  -4.18623202e-02f, 1.92367703e-01f, 1.08284159e-02f, 1.14496179e-01f, -1.62242219e-01f, -5.35848811e-02f, 8.37921202e-02f, 2.69151218e-02f, 1.38497040e-01f, -3.18289064e-02f,
  1.05372123e-01f, -1.51946396e-01f, 7.32330084e-02f, -6.66248100e-03f, 2.35324576e-01f, -9.16876867e-02f, -6.71088025e-02f, 4.47971597e-02f, 2.83929437e-01f, 1.04015142e-01f,
  -2.22397801e-02f, -6.68911040e-02f, -9.35703963e-02f, -6.33449852e-02f, 1.42152205e-01f, 1.82657659e-01f, 1.43524438e-01f, 1.25214994e-01f, 1.29483759e-01f, -2.94587631e-02f,
  2.10062459e-01f, 1.25864148e-02f, -1.16015181e-01f, 6.96873590e-02f, -8.61940980e-02f, 1.36533873e-02f, -3.17135714e-02f, -3.85352247e-03f, 4.87940907e-02f, -7.20423609e-02f,
  -1.63071007e-01f, 2.00840935e-01f, 7.07652420e-02f, 1.94671750e-01f, 3.86984833e-02f, -1.27732232e-01f, -1.11930646e-01f, -1.81303024e-01f, 8.52421224e-02f, 3.90572846e-02f,
  -4.36573364e-02f, 4.17534746e-02f, 5.35019562e-02f, -1.03211626e-02f, -2.11238265e-01f, 1.58734739e-01f, 7.07507059e-02f, 8.58192742e-02f, 9.51915309e-02f, 5.61147518e-02f,
  4.10245657e-02f, 3.50243151e-02f, 1.05712109e-03f, 5.55225275e-02f, -4.43414822e-02f, -1.06190458e-01f, -1.94935463e-02f, 1.89385459e-01f, -1.00285001e-01f, 1.27903998e-01f,
  1.91953644e-01f, 4.04441357e-02f, -1.13397405e-01f, -1.29072219e-01f, -1.11488029e-01f, 1.73048079e-01f, -1.04264244e-01f, -1.62416312e-03f, -2.01747250e-02f, 1.18139215e-01f,
  1.75630689e-01f, 1.22730313e-02f, 2.57270671e-02f, 1.72372907e-01f, 1.79693371e-01f, 2.05836654e-01f, 2.10224077e-01f, 1.60320923e-01f, 2.06045926e-01f, -9.01323438e-05f,
  1.09001376e-01f, 5.42844832e-02f, 2.67842282e-02f, -6.39747903e-02f, 9.44398046e-02f, 1.55510992e-01f, 2.19287574e-02f, -1.53625995e-01f, -4.62737828e-02f, -2.45375391e-02f,
  9.71898809e-02f, 1.22701019e-01f, 2.30836887e-02f, 1.70278683e-01f, 6.48804754e-02f, 1.01290330e-01f, -1.24743097e-01f, 1.97906986e-01f, 2.45023012e-01f, -4.94441390e-02f,
  1.66130398e-04f, -2.24267468e-01f, 2.15559565e-02f, -1.21133998e-01f, 1.17228426e-01f, 8.68878365e-02f, 9.25978571e-02f, 8.12241659e-02f, -1.81978062e-01f, -1.34424701e-01f,
  2.00480908e-01f, -7.35722557e-02f, -9.36489180e-02f, -7.18181655e-02f, 8.47074389e-03f, 1.58543199e-01f, 6.83440790e-02f, -2.49126907e-02f, 2.81422466e-01f, -6.80056140e-02f,
  8.15685019e-02f, 2.33291522e-01f, -6.47978112e-02f, -2.03778371e-02f, 4.47385423e-02f, 1.07031479e-01f, 1.19954124e-01f, 5.33321314e-02f, -1.18889054e-03f, 1.35992512e-01f,
  -1.28505239e-02f, 1.69010520e-01f, -1.47929832e-01f, 2.66715169e-01f, 1.27950357e-02f, -5.44545576e-02f, -4.33449149e-02f, -9.48810205e-03f, 8.89928788e-02f, -7.14805722e-03f,
  1.41669139e-01f, -1.08679034e-01f, 1.56327888e-01f, 1.18097238e-01f, 7.81529099e-02f, 2.12424576e-01f, -1.74794376e-01f, -9.52514410e-02f, -3.57374214e-02f, 1.95188671e-01f,
  1.34286493e-01f, -8.58957469e-02f, 1.21096328e-01f, 2.41458997e-01f, 1.50057733e-01f, 2.79946160e-03f, -1.09219693e-01f, 6.09690957e-02f, 1.56697959e-01f, 1.13951117e-02f,
  -1.41101675e-02f, -1.46863565e-01f, -1.99325100e-01f, -7.10295811e-02f, -9.26727429e-02f, 1.75058201e-01f, 3.41978073e-02f, 1.97083317e-02f, 6.97693378e-02f, 3.70784625e-02f,
  -4.92922403e-02f, 6.97382689e-02f, 1.63588189e-02f, 8.11566561e-02f, 1.47974333e-02f, 6.52447566e-02f, 2.76788343e-02f, 1.75820574e-01f, -8.10007751e-02f, 1.76030830e-01f,
  -1.18642338e-01f, 1.10514708e-01f, 1.43315420e-01f, 1.33414358e-01f, -1.10750891e-01f, 8.72080475e-02f, 1.72359440e-02f, -1.17175922e-01f, 1.20610051e-01f, -9.93355960e-02f,
  -6.07780553e-02f, 8.14871117e-02f, 1.38208479e-01f, -1.69836745e-01f, -7.00167865e-02f, 9.70295817e-02f, 1.19347624e-01f, 7.43862940e-03f, -5.85587770e-02f, 1.01727851e-01f,
  -1.10986955e-01f, -5.39131835e-02f, 2.76923962e-02f, -7.09179193e-02f, -1.18647896e-01f, 3.12505662e-02f, -5.60954362e-02f, -4.11765128e-02f, 9.88612026e-02f, -1.02833197e-01f,
  -7.75898108e-03f, 5.87939806e-02f, 6.77654967e-02f, 6.14123121e-02f, 1.26936100e-02f, 1.13829456e-01f, -5.11352792e-02f, -3.68772671e-02f, 2.93216296e-02f, 4.04680893e-02f,
  1.77931204e-01f, -5.62865520e-03f, -2.68426817e-02f, 7.70244002e-03f, 2.15570927e-01f, -1.51276678e-01f, 1.05658561e-01f, -7.51551613e-02f, -1.19602852e-01f, 8.05829540e-02f,
  5.07751433e-03f, 1.18891157e-01f, -4.37485911e-02f, -1.41435102e-01f, 1.33309901e-01f, 2.77703349e-02f, 5.69970086e-02f, 2.71726012e-01f, 8.09784885e-03f, -1.93481445e-02f,
  3.14916782e-02f, -1.63660824e-01f, 8.62213820e-02f, -1.09476380e-01f, -6.84128106e-02f, -9.06584598e-03f, 9.89881381e-02f, 2.10410953e-01f, 9.49298441e-02f, -6.77572712e-02f,
  8.67114291e-02f, 2.07220048e-01f, -1.13337345e-01f, -7.34835863e-02f, -7.42690489e-02f, 2.86971420e-01f, 1.06416553e-01f, -1.50618637e-02f, 4.64951247e-02f, -1.38520867e-01f,
  4.03539045e-03f, -6.60102665e-02f, 5.77122625e-03f, -5.01260348e-02f, 1.14558131e-01f, -8.10574889e-02f, 1.36822492e-01f, 1.74462348e-01f, 4.49227542e-02f, -1.76017374e-01f,
  -1.77800119e-01f, 5.19095957e-02f, 2.17118844e-01f, -9.80353877e-02f, -1.33701396e-04f, 1.46083906e-01f, 1.47048756e-01f, 9.22182798e-02f, -1.64802354e-02f, 7.76501969e-02f,
  1.17150798e-01f, -3.43543515e-02f, -2.14858819e-02f, -5.44432625e-02f, -1.11337982e-01f, -6.34949580e-02f, -7.56860748e-02f, 4.69240099e-02f, -3.38016786e-02f, -5.79286478e-02f,
  -9.73700956e-02f, -6.10962324e-02f, 8.24487507e-02f, -1.19532399e-01f, -1.20449878e-01f, -9.14574042e-02f, -6.88621849e-02f, 7.13480413e-02f, -1.23727702e-01f, 2.46161036e-02f,
  -8.83363336e-02f, 3.67462710e-02f, -1.23664312e-01f, -2.55084336e-02f, 2.81102639e-02f, 1.24059264e-02f, -1.12686433e-01f, -4.21588658e-04f, 1.75044388e-02f, -7.37338290e-02f,
  -1.35870446e-02f, -1.65298842e-02f, -4.65415865e-02f, 9.98939872e-02f, -9.48652029e-02f, 5.74046001e-02f, -1.10889316e-01f, -6.80766925e-02f, 5.21134920e-02f, -4.50265929e-02f,
  -9.54458788e-02f, 1.33105190e-02f, 6.99664578e-02f, 1.59994494e-02f, -1.12008555e-02f, -2.86359340e-02f, -3.37815955e-02f, -2.39909366e-02f, -3.23781557e-02f, 1.12196237e-01f,
  1.01598948e-01f, 1.34661183e-01f, -2.73680165e-02f, -6.81085065e-02f, -1.17723383e-01f, -8.99524838e-02f, -8.92922953e-02f, 1.86814051e-02f, -4.15392816e-02f, 7.83826485e-02f,
  2.12460048e-02f, -8.54940247e-03f, -8.19755867e-02f, 1.67275429e-01f, 8.13181400e-02f, 8.79839286e-02f, 1.67682275e-01f, 2.95709744e-02f, 6.31309152e-02f, -2.31973771e-02f,
  2.86957681e-01f, 1.28251567e-01f, 1.20413437e-01f, -9.93197858e-02f, -2.21730128e-01f, 1.53568521e-01f, -1.84511721e-01f, 4.16823365e-02f, 1.56982049e-01f, 4.62825410e-02f,
  2.02006102e-02f, 4.94024396e-01f, 7.77763489e-04f, -9.62982029e-02f, -9.79969930e-03f, 3.21861245e-02f, 2.24871701e-03f, 1.13436811e-01f, -1.07269004e-01f, 2.55279571e-01f,
  1.68837130e-01f, -1.04907259e-01f, 8.24525654e-02f, 1.45982146e-01f, 1.21672526e-01f, -1.32190719e-01f, -9.94016454e-02f, 5.55688180e-02f, 3.98336887e-01f, -1.82892933e-01f,
  7.28792092e-03f, -1.05273157e-01f, -6.73870817e-02f, -6.02323823e-02f, 1.39147386e-01f, -5.44176847e-02f, 1.86163843e-01f, 1.50112733e-01f, 2.17806436e-02f, 1.10295959e-01f,
  -5.73458821e-02f, 6.50224462e-02f, -3.99562716e-02f, -1.81360934e-02f, 2.57577468e-02f, -1.37434080e-01f, -6.38239086e-02f, 9.74062085e-02f, 2.93144472e-02f, 1.90913215e-01f,
  -2.31944129e-01f, -5.55285551e-02f, 1.40179694e-01f, 1.64822489e-01f, -1.66251123e-01f, 1.11127750e-03f, 1.05665028e-01f, 7.74579681e-03f, -8.75220895e-02f, -3.15544643e-02f,
  -1.14296831e-01f, 8.31255317e-02f, -7.09556341e-02f, 5.92088699e-02f, 2.57058181e-02f, 7.58711547e-02f, 2.61614434e-02f, -2.88340468e-02f, -3.74316871e-02f, -1.08379260e-01f,
  4.92815077e-02f, -1.12589322e-01f, -1.07982010e-01f, -9.35188606e-02f, 7.38267079e-02f, 4.56252061e-02f, -8.88402164e-02f, -1.24579974e-01f, -9.53018740e-02f, 1.12912059e-01f,
  1.18749179e-01f, -6.64789453e-02f, -6.58152401e-02f, 4.64537330e-02f, -1.06612585e-01f, -1.12490408e-01f, 8.84463713e-02f, 7.79476315e-02f, -6.33684173e-02f, 3.10830143e-03f,
  6.68044314e-02f, 3.49907093e-02f, 1.13925144e-01f, 6.24764562e-02f, -8.38360414e-02f, 7.69752935e-02f, 7.45779797e-02f, 2.48725209e-02f, -2.15736199e-02f, 5.80742471e-02f,
  -2.88180877e-02f, -8.82392526e-02f, 3.64039801e-02f, -3.89565043e-02f, -9.33504030e-02f, -9.00263488e-02f, 7.32473060e-02f, -9.49425027e-02f, -1.06028862e-01f, -6.28591478e-02f,
  5.42824045e-02f, -9.53447223e-02f, -2.47256588e-02f, -5.72557785e-02f, -1.19245656e-01f, 8.78401175e-02f, -8.68837684e-02f, -1.21560521e-01f, -3.02474312e-02f, -4.65011932e-02f,
  -5.83322421e-02f, -9.72276777e-02f, -8.40251148e-02f, -7.08126500e-02f, 1.84487402e-01f, 6.05305210e-02f, 1.79573640e-01f, 8.50974675e-03f, 1.29804969e-01f, 9.19119939e-02f,
  1.04354009e-01f, -1.14460252e-01f, 1.43859342e-01f, 1.42816529e-01f, -2.97654301e-01f, 9.58291590e-02f, -1.50192052e-01f, -1.94698782e-03f, -5.91664761e-02f, 7.72856697e-02f,
  3.04735035e-01f, 5.57656400e-02f, -4.30052262e-03f, 1.89908415e-01f, 8.65221173e-02f, 7.65845031e-02f, 1.66038908e-02f, -9.90027264e-02f, -1.34896457e-01f, -7.36052990e-02f,
  2.92828977e-02f, 6.53640851e-02f, 2.25545187e-02f, 1.10294007e-01f, 4.15086225e-02f, -4.13554870e-02f, 1.71358183e-01f, 8.02727938e-02f, -1.40039608e-01f, -1.86834540e-02f,
  -7.54745230e-02f, -8.49168003e-03f, 4.45739590e-02f, 6.78073466e-02f, 2.66476691e-01f, -3.10839470e-02f, 3.72226909e-02f, 1.64525002e-01f, 1.57937303e-01f, -1.01052649e-01f,
  -6.45076856e-02f, -9.37978476e-02f, 1.08881436e-01f, 1.24649882e-01f, 3.35109197e-02f, -1.50792673e-01f, 6.87492043e-02f, 1.67237207e-01f, 1.72357112e-02f, 7.82208890e-02f,
  1.11978091e-01f, 9.74347964e-02f, -1.13871619e-01f, -8.85595903e-02f, 6.84787035e-02f, 5.97068816e-02f, 2.33246714e-01f, 4.74778078e-02f, -3.55823152e-02f, 1.59601390e-01f,
  1.54773325e-01f, 1.49882719e-01f, 2.10423589e-01f, -1.36418222e-02f, -2.10616388e-04f, -1.15650019e-03f, -1.63605168e-01f, -9.25178081e-02f, 1.03791311e-01f, 1.67764463e-02f,
  1.49520978e-01f, 2.45017067e-01f, -4.55459990e-02f, 1.14717253e-01f, -6.08057193e-02f, -9.34795514e-02f, 3.62569652e-02f, 5.70070334e-02f, -9.12179996e-04f, -1.20647006e-01f,
  1.62028432e-01f, 2.32160047e-01f, 1.94096580e-01f, 9.25447717e-02f, 1.17644340e-01f, 1.80266842e-01f, -1.95631459e-02f, -2.03382000e-02f, -6.21875711e-02f, 1.19457573e-01f,
  -1.94079369e-01f, -4.17611897e-02f, 1.02291703e-01f, 8.34762231e-02f, 9.95775312e-02f, 9.37216878e-02f, -2.52522789e-02f, 7.53109306e-02f, -8.33060071e-02f, 1.95195317e-01f,
  2.74585485e-01f, -9.89552066e-02f, -1.00352310e-01f, 1.84629425e-01f, 5.67344204e-03f, -8.63547176e-02f, -1.31050974e-01f, 9.60700810e-02f, 1.90685064e-01f, -8.81338865e-03f,
  -1.09799221e-01f, -1.16330765e-01f, -1.47071362e-01f, -2.28254780e-01f, -1.19242653e-01f, -1.46390915e-01f, 8.58967081e-02f, 6.92748949e-02f, 8.85800645e-02f, 1.81350291e-01f,
  -5.98095916e-02f, 9.48490128e-02f, -1.94067322e-02f, 1.19569957e-01f, 7.79352039e-02f, 8.78806263e-02f, 1.13865294e-01f, -6.60815537e-02f, -1.00341588e-01f, 1.01138502e-01f,
  1.16522029e-01f, -1.88324079e-02f, 2.52659500e-01f, -1.19536668e-01f, -9.23439339e-02f, -1.92401614e-02f, 1.30848110e-01f, -2.95394175e-02f, -6.50278628e-02f, -1.05327800e-01f,
  2.14714229e-01f, -6.17768965e-04f, -6.36287630e-02f, -7.27398843e-02f, -1.06674530e-01f, -5.45040406e-02f, -1.89337194e-01f, -4.06932980e-02f, 4.28166464e-02f, 3.58721502e-02f,
  1.02058545e-01f, 1.87763393e-01f, 2.94203699e-01f, -9.73065346e-02f, -5.62509298e-02f, -1.74711160e-02f, 1.21875495e-01f, 5.49240336e-02f, -1.86509043e-02f, 5.73954061e-02f,
  -1.56909674e-01f, -2.17186674e-01f, 1.10014543e-01f, -1.79469958e-01f, 2.07958464e-02f, 6.99907308e-03f, 1.66509494e-01f, -1.04058841e-02f, 1.97208866e-01f, 1.85862780e-01f,
  -9.63257998e-02f, 2.25765660e-01f, -1.28833219e-01f, 7.54969120e-02f, 8.83597359e-02f, 1.01006433e-01f, 1.70074731e-01f, 2.24075198e-01f, 2.04399198e-01f, -4.13051434e-02f,
  1.70129180e-01f, -1.61434680e-01f, -3.21688391e-02f, 2.37176135e-01f, -3.83460522e-02f, 2.74804026e-01f, -1.66787595e-01f, -3.23540866e-02f, -2.23252960e-02f, 1.15618214e-01f,
  2.58272402e-02f, 2.32445505e-02f, -1.78356022e-01f, -8.79489910e-03f, -1.91668436e-01f, 1.74027935e-01f, -6.05808720e-02f, 1.35879472e-01f, 1.01457894e-01f, 1.03404142e-01f,
  -4.63555427e-03f, 5.21153323e-02f, -7.26714060e-02f, -5.96715398e-02f, 1.21916175e-01f, -1.19758487e-01f, 5.69572672e-02f, -1.57680493e-02f, -2.29994729e-02f, 9.83843859e-03f,
  3.04979905e-02f, 1.86424538e-01f, -1.11268125e-01f, -1.01795550e-02f, 6.43884763e-02f, 2.96907425e-02f, 8.54964182e-02f, -6.68141199e-03f, 1.09071456e-01f, -2.37591043e-02f,
  2.21186921e-01f, -1.08708620e-01f, -2.93393107e-03f, 8.30630213e-02f, -1.15060940e-01f, -1.04026645e-01f, 5.53079806e-02f, 1.42031893e-01f, 2.14070529e-01f, -1.38809666e-01f,
  -7.45351464e-02f, -7.65057355e-02f, -1.58100769e-01f, -4.48544696e-03f, 5.34699596e-02f, 4.67909873e-02f, 3.71040516e-02f, 2.18454301e-01f, 2.21198723e-01f, -1.21975675e-01f,
  -8.24243017e-03f, 4.24327422e-03f, 1.33228645e-01f, 4.44363914e-02f, -9.13863108e-02f, 2.41683405e-02f, -1.04525954e-01f, 1.71278238e-01f, -5.30904792e-02f, 1.03234671e-01f,
  1.83979779e-01f, 1.75138116e-01f, 1.09593235e-01f, 1.15477048e-01f, 6.61077499e-02f, 1.39224857e-01f, 1.25131905e-01f, -9.85013545e-02f, 1.40991434e-01f, 3.42697464e-02f,
  -1.70853168e-01f, 2.02426650e-02f, 1.31678313e-01f, 1.54822633e-01f, 2.77904458e-02f, 3.08425296e-02f, 3.12807187e-02f, 9.24304202e-02f, -3.77772516e-03f, 1.44163683e-01f,
  8.30789059e-02f, 1.22850634e-01f, -8.91964883e-02f, 1.54971376e-01f, -3.94392386e-02f, -2.85873562e-02f, 4.79726158e-02f, -6.06736131e-02f, -1.11569082e-02f, 1.38734588e-02f,
  1.50349319e-01f, -5.40687628e-02f, 2.38816366e-02f, -2.83499584e-02f, -1.03333876e-01f, 9.19591039e-02f, 1.03708185e-01f, 1.47399411e-01f, 1.34193659e-01f, -2.02364996e-02f,
  1.81328759e-01f, -1.35033295e-01f, -1.06652111e-01f, -5.14005050e-02f, -2.16431141e-01f, -6.57003671e-02f, -1.04722261e-01f, -6.84816688e-02f, 1.28214285e-01f, 1.63356513e-01f,
  -1.16452254e-01f, -2.30767131e-01f, -9.08240974e-02f, 2.74392334e-03f, 6.22551478e-02f, -5.22249192e-02f, -1.67934775e-01f, 1.39744937e-01f, 1.01852350e-01f, 2.37866994e-02f,
  2.71780370e-03f, 1.72811240e-01f, 2.91377306e-02f, 1.04146712e-01f, -1.28811643e-01f, 1.43438011e-01f, 1.53525874e-01f, -8.97011757e-02f, 4.83310781e-03f, -4.82705720e-02f,
  1.63124144e-01f, 6.48918794e-03f, 4.99122553e-02f, -5.75338723e-03f, 2.57323951e-01f, 5.17606251e-02f, -9.74410865e-03f, -5.75497039e-02f, -9.95256454e-02f, 1.68133542e-01f,
  -2.66168378e-02f, -5.52655086e-02f, -1.73974797e-01f, -5.79848886e-02f, 1.79061696e-01f, -1.89534709e-01f, 4.37086672e-02f, -5.28663732e-02f, 2.61268616e-02f, -1.32739067e-01f,
  1.30168453e-01f, 1.76234648e-01f, 1.01375729e-01f, 5.12947701e-02f, 4.71111014e-02f, 1.26939401e-01f, -1.22678891e-01f, -7.69116133e-02f, 2.03586936e-01f, -7.29663149e-02f,
  4.11545411e-02f, -1.84933513e-01f, -1.47231724e-02f, 5.51223801e-03f, 8.45822170e-02f, 2.59129051e-02f, 1.08968467e-02f, 1.54013157e-01f, 1.66608855e-01f, 9.30719301e-02f,
  1.39414817e-01f, 1.85932014e-02f, -1.13117605e-01f, 1.57399595e-01f, 9.87057239e-02f, -9.68322381e-02f, 1.44441053e-01f, 2.33451918e-01f, 1.76941141e-01f, 6.27005026e-02f,
  -6.65260106e-02f, 8.10376778e-02f, 8.03945214e-02f, 8.00155178e-02f, 1.38886273e-03f, 2.68160533e-02f, -4.12351638e-02f, 1.22911006e-01f, -4.67657745e-02f, 9.88157541e-02f,
  -8.66302401e-02f, -4.99038585e-02f, -7.13327006e-02f, -2.44259220e-02f, 8.51946534e-04f, -2.27348302e-02f, 6.60229996e-02f, 7.06391931e-02f, -7.13672629e-03f, 2.68217642e-02f,
  -1.86027214e-03f, -7.94368982e-02f, 1.93394385e-02f, -7.96953291e-02f, -7.83677623e-02f, 6.30544201e-02f, 2.98715420e-02f, -4.82317209e-02f, -1.14835920e-02f, 5.34287915e-02f,
  6.54569864e-02f, 3.17827500e-02f, 4.86698709e-02f, 3.55421714e-02f, -1.99463870e-02f, -5.05733676e-02f, -6.74012825e-02f, 6.24505803e-03f, 1.53290881e-02f, -2.16996260e-02f,
  7.35252723e-02f, -7.35884085e-02f, 2.59726215e-02f, -2.63158362e-02f, 5.27782477e-02f, -5.73586226e-02f, -3.49495523e-02f, -8.65080804e-02f, -1.10905178e-01f, -4.86795194e-02f,
  -7.95376301e-02f, 5.38709722e-02f, 6.42634630e-02f, -2.96091773e-02f, -1.17090017e-01f, 6.57681003e-02f, 6.67239204e-02f, 1.33099273e-01f, 5.65235466e-02f, 6.94976971e-02f,
  -9.93103068e-03f, 6.29816949e-02f, -5.71601391e-02f, 7.01439902e-02f, 1.04316726e-01f, -4.59088236e-02f, 9.00875553e-02f, -1.20695867e-01f, -1.24167465e-01f, -3.71150933e-02f,
  -4.89157625e-02f, -4.81908098e-02f, -8.28346238e-03f, -3.17397900e-02f, 6.02622610e-03f, 4.71053571e-02f, -1.41057551e-01f, 1.26514405e-01f, 8.72750878e-02f, -5.33526875e-02f,
  -4.31773216e-02f, -2.55318433e-02f, 4.05661799e-02f, 1.24778524e-01f, -8.93157274e-02f, 8.66307095e-02f, -4.20875028e-02f, -8.45999941e-02f, -6.66077211e-02f, -1.14181854e-01f,
  -2.92898808e-02f, -1.49298012e-02f, -5.78082427e-02f, -4.37685922e-02f, -4.75501046e-02f, -2.87037212e-02f, 2.44183326e-03f, -1.04421549e-01f, 6.26090169e-02f, 9.05385539e-02f,
  -7.76754543e-02f, 1.34374291e-01f, -9.71608534e-02f, -7.12903291e-02f, -1.10591725e-01f, -1.89545117e-02f, -7.57954940e-02f, -1.09985732e-01f, -9.27154049e-02f, -6.63639084e-02f,
  -1.23097241e-01f, -9.93160307e-02f, -4.12900820e-02f, -9.61161181e-02f, 5.17256819e-02f, 6.67184591e-03f, 1.09961003e-01f, 9.38709155e-02f, 1.53159767e-01f, 8.16067234e-02f,
  -1.76750366e-02f, 1.67066723e-01f, 6.64107129e-02f, 7.45173767e-02f, -4.69675548e-02f, 1.16419151e-01f, 1.67677417e-01f, 5.32212071e-02f, -4.55985293e-02f, -1.36107663e-02f,
  -2.25887783e-02f, -4.23879065e-02f, -8.03650022e-02f, 1.30106822e-01f, 1.27567440e-01f, 3.93161140e-02f, -1.77682508e-02f, 9.78467241e-02f, 1.22428030e-01f, 1.30605742e-01f,
  -1.38904080e-02f, 5.42962663e-02f, 6.08027913e-02f, -1.75303891e-01f, -1.76136971e-01f, -4.41365540e-02f, -1.17452238e-02f, 1.77188501e-01f, 1.58636734e-01f, -5.02600521e-02f,
  1.07743450e-01f, 3.80137205e-01f, 1.24766856e-01f, 9.04835165e-02f, -1.87489569e-01f, -1.40544713e-01f, -4.82519995e-03f, 5.63559309e-02f, 1.25013500e-01f, 1.52735159e-01f,
  1.87582940e-01f, -5.35136908e-02f, 6.44706115e-02f, 1.64365750e-02f, -5.75889647e-02f, -1.25830173e-01f, -6.84042573e-02f, -3.97578329e-02f, 4.88424897e-02f, -2.01106723e-02f,
  1.21179804e-01f, 1.04835881e-02f, 1.25323171e-02f, -1.60518035e-01f, -9.46703479e-02f, 3.71082053e-02f, 9.18249264e-02f, 4.42170240e-02f, -1.41883373e-01f, 1.38122857e-01f,
  1.42318159e-01f, 1.93622126e-03f, -1.31292902e-02f, 1.31679196e-02f, 7.98353460e-03f, -1.13712132e-01f, 8.41448531e-02f, 2.07059626e-02f, -7.40026012e-02f, 2.21550375e-01f,
  -3.20585258e-02f, -2.09240448e-02f, -1.16228042e-02f, 7.19777818e-05f, -1.44510418e-01f, 1.73763809e-04f, -8.42063800e-02f, 9.82271731e-02f, 8.34522471e-02f, -8.70679542e-02f,
  -5.12278229e-02f, 6.20191284e-02f, -7.73611143e-02f, 1.59901232e-01f, -2.79349964e-02f, 8.57178420e-02f, -7.77940676e-02f, -3.13797072e-02f, -1.06664859e-02f, 1.11801647e-01f,
  1.18709758e-01f, -9.45023745e-02f, -1.14040717e-01f, -6.45388588e-02f, 7.75025487e-02f, 1.27833700e-02f, 1.31994113e-01f, -2.74193808e-02f, -2.72425567e-03f, 4.45435569e-02f,
  -9.09393653e-02f, 8.18888843e-02f, -9.98515263e-02f, -2.47592293e-02f, -1.19373940e-01f, -6.62933066e-02f, -9.95929241e-02f, 1.09098762e-01f, 8.47730488e-02f, -8.63086581e-02f,
  -6.99502276e-03f, 1.33149445e-01f, 7.07017779e-02f, 4.78836074e-02f, -6.99192882e-02f, 7.00290576e-02f, -4.55184886e-03f, -3.66007239e-02f, -5.86879291e-02f, 2.05932721e-03f,
  4.83640805e-02f, -9.47501957e-02f, -4.49562930e-02f, 1.25978172e-01f, -6.58084378e-02f, 4.55517545e-02f, 1.38488961e-02f, 2.46909913e-02f, -7.95114636e-02f, -3.24885249e-02f,
  -1.63407810e-02f, -7.93416053e-02f, 3.50750834e-02f, 1.44126281e-01f, 1.16987757e-01f, 8.51622447e-02f, 1.16104797e-01f, 2.37734169e-02f, -6.65805861e-02f, -7.15801194e-02f,
  -1.84749011e-02f, -6.22520708e-02f, -1.80387106e-02f, 3.62473205e-02f, -5.03290296e-02f, 4.89264727e-02f, 1.89308785e-02f, -1.31450042e-01f, 1.15505219e-01f, 6.06846921e-02f,
  -9.95747522e-02f, 2.33974047e-02f, -2.04452947e-01f, -1.66772977e-02f, -7.00442716e-02f, -3.90707590e-02f, -7.30267689e-02f, -6.80345371e-02f, 8.09273571e-02f, 7.69753903e-02f,
  6.12778217e-02f, -1.30666913e-02f, -9.37659014e-03f, 1.16141543e-01f, 8.37466940e-02f, -1.21484824e-01f, -9.50710550e-02f, -1.73367530e-01f, -1.62215561e-01f, 1.42642379e-01f,
  -7.85543695e-02f, 1.26893902e-02f, 1.12260535e-01f, 1.57046676e-01f, 9.07725394e-02f, 1.07521743e-01f, 1.07065745e-01f, 1.84056625e-01f, -4.29557785e-02f, -9.78274620e-04f,
  1.11952117e-02f, 3.74858901e-02f, -1.03948690e-01f, -1.68640777e-01f, 1.51801676e-01f, 2.12536715e-02f, 1.76348612e-01f, 1.18320465e-01f, 2.06973895e-01f, 8.74746740e-02f,
  1.19447865e-01f, 3.36000882e-02f, 6.46348372e-02f, -1.09258100e-01f, 6.52848855e-02f, 1.87238961e-01f, 1.84475884e-01f, -1.73169762e-01f, 2.38211416e-02f, 7.84035623e-02f,
  1.46357805e-01f, 7.10275844e-02f, 7.33776903e-03f, 1.82435423e-01f, 4.16761711e-02f, -7.01274425e-02f, 1.45531327e-01f, -3.45969573e-02f, 3.34420472e-01f, 1.04563311e-01f,
  -5.02242558e-02f, 3.90342809e-02f, 1.37491554e-01f, 9.08053443e-02f, -2.05299407e-01f, 5.59461564e-02f, 1.38806939e-01f, 1.11647397e-02f, 5.44114113e-02f, -1.67067423e-01f,
  -4.43315580e-02f, 7.07440600e-02f, 4.49404977e-02f, 1.48488224e-01f, 3.34200710e-02f, -9.60726514e-02f, 8.75098407e-02f, -9.55525488e-02f, 1.61272690e-01f, 9.95343849e-02f,
  1.39204025e-01f, 2.11838841e-01f, -7.39365770e-03f, 1.79758091e-02f, -6.44568130e-02f, -3.11699267e-02f, 5.29532582e-02f, 1.18835354e-02f, 6.74622655e-02f, -1.10803820e-01f,
  2.02798638e-02f, -4.93483543e-02f, 8.71307999e-02f, -8.12885836e-02f, 1.71045307e-02f, -1.15867034e-01f, 3.50957662e-02f, 1.23721302e-01f, -9.79642123e-02f, -4.94079478e-02f,
  -4.95270044e-02f, 3.52182947e-02f, -1.56086475e-01f, -2.76676379e-02f, -9.38238725e-02f, -1.77075062e-02f, -4.86657098e-02f, 7.08989948e-02f, 1.76981091e-02f, 1.34325206e-01f,
  3.91220860e-02f, 2.17869312e-01f, 7.33979419e-02f, -1.34393871e-01f, -1.03383698e-01f, -1.84339844e-02f, 4.49405313e-02f, -1.96466222e-01f, -1.06153429e-01f, 8.39173347e-02f,
  1.10705391e-01f, 1.40334936e-02f, -8.78881887e-02f, -3.85446921e-02f, 5.69168963e-02f, 2.79328302e-02f, 1.29931629e-01f, 1.39050325e-02f, 5.02597056e-02f, -1.63493454e-01f,
  -3.87233570e-02f, -1.62521541e-01f, 1.87408119e-01f, 1.03024162e-01f, 1.77570418e-01f, 2.44559180e-02f, -2.66475510e-02f, 3.78638059e-02f, -1.05842032e-01f, 8.37424397e-02f,
  -1.26173962e-02f, 1.52704595e-02f, -7.89130405e-02f, 2.45081298e-02f, -6.22849353e-02f, 1.17907383e-01f, 1.01819178e-02f, 1.01678036e-01f, -5.38160540e-02f, 1.51392803e-01f,
  -9.45921838e-02f, 1.06540754e-01f, -1.21910676e-01f, -4.66614626e-02f, -4.96635400e-02f, -2.70858221e-02f, 1.31834134e-01f, 9.85578969e-02f, 7.27099702e-02f, -7.84264356e-02f,
  4.27887887e-02f, 6.49380833e-02f, -1.18042760e-01f, 3.32431518e-03f, -5.58948331e-02f, -1.40606984e-01f, -7.94472247e-02f, 3.49460803e-02f, 1.20918497e-01f, 1.72575608e-01f,
  -1.57863915e-01f, -6.10060543e-02f, -3.66779752e-02f, -2.80438904e-02f, -7.29071200e-02f, 2.10296541e-01f, 2.11801022e-01f, -4.22750413e-02f, 3.84687074e-02f, -1.50929406e-01f,
  1.91886708e-01f, -1.14028543e-01f, 4.68060188e-02f, -4.87174764e-02f, 5.46670007e-03f, -1.47635769e-02f, 8.12239945e-02f, -8.88311788e-02f, 1.31680623e-01f, 3.91289964e-03f,
  -1.45513508e-02f, -3.91252860e-02f, -1.92457244e-01f, 1.27467006e-01f, 3.18475403e-02f, 1.35893956e-01f, 2.68305447e-02f, -3.76655832e-02f, -8.63818079e-02f, -1.75310653e-02f,
  -3.44954655e-02f, 7.42806122e-02f, -3.23829390e-02f, -1.39368102e-01f, 1.20657720e-01f, 8.59817043e-02f, 1.01010175e-02f, -7.12049380e-02f, -1.90923296e-04f, 1.07723199e-01f,
  -1.18565105e-01f, 5.50656803e-02f, -7.93538317e-02f, -1.07516989e-01f, 1.24959156e-01f, -9.21658278e-02f, -2.38263570e-02f, -6.62133396e-02f, -8.12548548e-02f, 9.24758147e-03f,
  7.37905130e-02f, 5.22408215e-03f, -1.05551496e-01f, 8.29843059e-02f, -1.14675485e-01f, 7.01232553e-02f, -7.32039586e-02f, 6.78706020e-02f, -2.59868288e-03f, 5.28822094e-03f,
  4.41055596e-02f, 5.32182120e-03f, -1.27737289e-02f, 1.11345515e-01f, -3.35693732e-02f, 8.97453800e-02f, 8.64630863e-02f, 9.02609304e-02f, 8.20605904e-02f, 2.65624677e-03f,
  -5.38813025e-02f, -2.79583279e-02f, 5.15641980e-02f, 5.03245890e-02f, 6.32402375e-02f, -1.70746520e-01f, 1.92427896e-02f, -4.84859273e-02f, -9.97984260e-02f, 6.95047388e-03f,
  1.27992481e-01f, 7.88818896e-02f, 1.51552752e-01f, -8.20093602e-02f, 1.03470445e-01f, 3.69328298e-02f, 6.40746281e-02f, -1.37007609e-01f, 1.15535602e-01f, -9.12008714e-03f,
  -6.72885403e-02f, 1.60173327e-01f, -1.04665577e-01f, -1.04694637e-02f, 1.16610169e-01f, 1.52142286e-01f, 1.91658929e-01f, 9.33028460e-02f, 1.01089507e-01f, 9.99135524e-02f,
  -3.45066674e-02f, 1.40247151e-01f, -4.05833274e-02f, 1.15666669e-02f, 8.68226737e-02f, -9.82344523e-02f, -8.10822174e-02f, -1.23374850e-01f, 1.43738836e-02f, 6.63465783e-02f,
  -6.11331649e-02f, -1.15417823e-01f, 7.02510849e-02f, 4.90426905e-02f, 8.41261372e-02f, 1.13495596e-01f, 1.33720636e-01f, -6.93794489e-02f, 1.52360499e-02f, 1.17651179e-01f,
  3.69274467e-02f, 3.46989520e-02f, -3.08582168e-02f, 7.77334422e-02f, 7.89445639e-02f, 6.37760386e-02f, -1.26216635e-01f, -5.50107844e-02f, 7.95056745e-02f, -7.54869953e-02f,
  -2.13628751e-03f, -9.65997502e-02f, -7.16623738e-02f, 1.56023920e-01f, -5.00429980e-02f, -1.99446455e-03f, -1.39430165e-01f, 1.61443174e-01f, -4.25692610e-02f, -1.25796363e-01f,
  1.33074239e-01f, 2.91131269e-02f, -5.77329099e-02f, 8.10532868e-02f, 2.38572419e-01f, 3.03017616e-01f, 1.26623675e-01f, 1.36423722e-01f, 1.05390847e-02f, 1.61270052e-01f,
  -2.80452311e-01f, 4.75682616e-02f, -1.85920715e-01f, 1.14032216e-01f, 1.92132846e-01f, 1.99779272e-02f, 1.58108190e-01f, 1.32040575e-01f, -1.30258963e-01f, -1.65299207e-01f,
  -1.45086467e-01f, -1.50741264e-01f, 8.84384289e-02f, -7.48737380e-02f, 6.93173185e-02f, -1.11696154e-01f, 1.17118470e-01f, 2.42011428e-01f, 5.58838360e-02f, 2.07542390e-01f,
  2.00459156e-02f, 6.75095096e-02f, 6.12363443e-02f, 6.78570494e-02f, -5.59092723e-02f, 1.32879183e-01f, -3.01019192e-01f, -1.17757179e-01f, 1.56187758e-01f, 9.88734365e-02f,
  -1.06461518e-01f, -4.24719676e-02f, -3.74765620e-02f, 1.36453345e-01f, -7.15220794e-02f, 4.33185734e-02f, 2.54299194e-01f, 5.62572964e-02f, 1.07105926e-01f, -1.17955469e-02f,
  2.35487428e-02f, 6.21549971e-03f, -1.81915313e-02f, -3.33262272e-02f, 2.03094810e-01f, 9.17946026e-02f, 1.56470358e-01f, 3.77411060e-02f, 1.49091527e-01f, 1.50730452e-02f,
  -9.61269960e-02f, -8.12117979e-02f, 4.45322581e-02f, 6.50691241e-02f, -5.68256788e-02f, -1.35551050e-01f, 5.23147956e-02f, -1.17947765e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -2.95270071e-03f, 3.30214143e-01f, 1.62309334e-01f, -4.07676771e-03f, 4.50006351e-02f, 1.94849297e-02f, -2.34697331e-02f, 1.96502745e-01f, 1.51585832e-01f, 1.19226202e-01f,
  1.08611792e-01f, 5.92434183e-02f, -8.10989290e-02f, 1.79134518e-01f, 2.06419066e-01f, -3.01386937e-02f, 2.21442014e-01f, 1.59879699e-01f, -5.63447364e-03f, 1.18963532e-01f,
  9.81711224e-02f, 1.31284893e-01f, 1.80793464e-01f, 5.08829020e-03f, 1.43060997e-01f, -1.00882158e-01f, 1.01601392e-01f, 8.21519122e-02f, 1.85107797e-01f, 3.49376090e-02f,
  -2.35139485e-02f, -1.68586671e-02f, -6.33166544e-03f, 9.37556401e-02f, 1.78171962e-01f, 5.86326420e-03f, 8.34892169e-02f, 1.61579847e-01f, 1.95614230e-02f, 2.66842525e-02f,
  -3.71246692e-03f, 1.77142639e-02f, -5.59791774e-02f, 5.60840145e-02f, 5.62553853e-02f, -2.77675446e-02f, -2.66263355e-02f, 2.00198770e-01f, 4.11925986e-02f, 3.31623144e-02f,
  -3.39929722e-02f, 1.25766248e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.44046986e-01f, 3.29580754e-02f, -4.09267545e-01f, -1.42473653e-01f, -3.72584641e-01f, -5.22200540e-02f, -1.61166772e-01f, -2.93826591e-02f, 2.25680724e-01f, -3.39930296e-01f,
  -2.04448700e-01f, -1.85492977e-01f, -1.39540374e-01f, 2.24129692e-01f, -2.12520659e-01f, -1.43892571e-01f, 1.37462676e-01f, -5.28663695e-01f, 5.50253451e-01f, 2.60285318e-01f,
  -3.66620004e-01f, -1.72560990e-01f, -1.90748408e-01f, 1.88661497e-02f, 7.51064196e-02f, -1.65270194e-01f, -3.00554782e-01f, -1.59168527e-01f, -1.12484701e-01f, -2.73925275e-01f,
  9.82047096e-02f, 6.50916457e-01f, 2.19411030e-03f, -3.22657853e-01f, 2.20556185e-02f, -1.19936345e-02f, 2.49954909e-01f, -3.56865907e-03f, 2.67428458e-01f, 2.67279111e-02f,
  1.31837577e-01f, 1.91835880e-01f, 2.26072639e-01f, 2.75864191e-02f, -4.29529930e-03f, 1.89106334e-02f, -1.99316576e-01f, -5.48849590e-02f, -2.50582635e-01f, 2.71403223e-01f,
  -2.93336570e-01f, 2.03995392e-01f, -7.72074461e-02f, 1.52312785e-01f, -1.14905417e-01f, 9.35376883e-02f, -1.66289866e-01f, -3.40000466e-02f, 1.05448321e-01f, -3.85686129e-01f,
  1.17713362e-01f, -1.63371965e-01f, -2.44420525e-02f, 3.13629508e-02f, 8.55763182e-02f, -4.91083652e-01f, 2.46067405e-01f, -1.39990419e-01f, -2.20572248e-01f, 1.84533879e-01f,
  1.24527693e-01f, -3.93288970e-01f, 7.02944472e-02f, -3.18822980e-01f, -6.81273714e-02f, 1.25266090e-01f, 1.54858947e-01f, 5.08378267e-01f, 7.56624015e-03f, 9.88727361e-02f,
  -2.84472182e-02f, -2.39894032e-01f, 5.97398102e-01f, 2.08766520e-01f, -1.18270017e-01f, 1.73119560e-01f, -2.67700285e-01f, 2.84039408e-01f, 1.20313549e-02f, -1.68159977e-01f,
  2.30420560e-01f, 6.76333606e-01f, -9.11600050e-03f, -4.59690213e-01f, -1.02214433e-01f, -9.37080756e-02f, -8.39063451e-02f, 1.29857734e-01f, -3.25196385e-01f, -4.11753297e-01f,
  -1.59479648e-01f, -5.86484000e-02f, 2.38188758e-01f, 4.94972259e-01f, -4.59731817e-02f, 1.11682236e-01f, -2.29711384e-01f, -1.13165505e-01f, -2.21597403e-01f, -8.27251598e-02f,
  2.54895948e-02f, -5.60598522e-02f, 1.38016313e-01f, -1.65038481e-01f, 1.88668579e-01f, 9.83905271e-02f, -4.65875298e-01f, -2.22579464e-01f, -8.57409835e-02f, 1.20350763e-01f,
  -3.44425440e-02f, 7.20613152e-02f, 3.81357521e-01f, -1.66973010e-01f, -1.81188509e-01f, 2.00332582e-01f, -2.05124065e-01f, -4.67230156e-02f, 2.08093360e-01f, 1.77513823e-01f,
  -8.72335583e-02f, 5.65663315e-02f, 1.93852991e-01f, 1.21472575e-01f, -1.39690936e-01f, 5.68822250e-02f, -3.36663902e-01f, -3.46916705e-01f, 4.73121554e-02f, -1.58431128e-01f,
  -4.73468393e-01f, 1.94360226e-01f, 1.47890508e-01f, -2.13784367e-01f, 1.64921563e-02f, -2.49665901e-01f, 1.35780007e-01f, -1.10513821e-01f, 6.84689507e-02f, 2.67818809e-01f,
  5.92109337e-02f, 1.48450226e-01f, -1.36809379e-01f, 1.42163008e-01f, 1.65777281e-01f, 1.47638738e-01f, 1.72678530e-01f, 3.65146160e-01f, 1.14994206e-01f, 2.64082611e-01f,
  1.35940984e-01f, -1.42960325e-01f, -3.29848565e-02f, -6.83101714e-02f, -3.72050643e-01f, -8.26344043e-02f, -5.24464846e-01f, -4.70768940e-03f, 2.91645348e-01f, -3.56753349e-01f,
  -3.04230601e-01f, 3.62927735e-01f, -2.02779576e-01f, 8.36113319e-02f, 1.35950938e-01f, 9.65658948e-02f, -1.77946925e-01f, 3.32614124e-01f, -1.57758803e-03f, 2.75538951e-01f,
  3.95112224e-02f, -3.10960561e-01f, 6.23786971e-02f, -1.29063800e-01f, -1.48541704e-01f, 1.26203150e-02f, 4.89764027e-02f, 2.60098666e-01f, 1.45863434e-02f, 1.10079192e-01f,
  -1.52943777e-02f, 4.85489666e-01f, 1.19919870e-02f, -1.59521639e-01f, 1.32975608e-01f, 2.26529837e-02f, -5.48894294e-02f, -1.94468051e-01f, -6.02744557e-02f, 1.65595207e-02f,
  -2.84665406e-01f, 4.62216973e-01f, -1.03245676e-02f, -1.49686843e-01f, -2.10776970e-01f, 1.51360169e-01f, 5.00061512e-01f, -2.31790513e-01f, -1.51802510e-01f, 1.88075930e-01f,
  -3.38048965e-01f, -3.91216129e-01f, 1.29321098e-01f, -1.28114894e-01f, -2.84030735e-01f, -5.79032838e-01f, -1.27464384e-01f, -8.43142867e-02f, -3.81930202e-01f, -2.68764552e-02f,
  2.13401597e-02f, -4.60492745e-02f, -4.04900163e-02f, 5.57843864e-01f, -7.87038282e-02f, 2.10486844e-01f, 7.03979254e-01f, 7.64986649e-02f, 1.40207410e-01f, 4.21782769e-02f,
  -1.10992856e-01f, -2.85531878e-01f, -2.46234965e-02f, 6.79419711e-02f, 4.09368843e-01f, -4.17155074e-03f, -5.31953089e-02f, 1.06299311e-01f, -3.11684817e-01f, -6.38416335e-02f,
  9.36266035e-02f, -3.98425460e-01f, 1.94021881e-01f, -2.49089062e-01f, 1.78366993e-02f, -5.17895706e-02f, -6.47837147e-02f, -1.07622974e-01f, -2.48741314e-01f, 2.01530680e-01f,
  2.26372749e-01f, -8.11371505e-02f, 1.65577289e-02f, -1.34265423e-01f, -1.58403233e-01f, -1.53150558e-01f, -2.21049979e-01f, 2.51018088e-02f, -1.19289113e-02f, -1.27071157e-01f,
  1.62723362e-01f, -2.70515025e-01f, -1.95981175e-01f, -1.09076001e-01f, 2.52473056e-01f, -1.00294292e-01f, 7.95275718e-03f, -1.41738996e-01f, -1.82952687e-01f, -3.53136748e-01f,
  3.77109885e-01f, -5.94325513e-02f, 9.76722687e-02f, 7.59337842e-01f, 4.49743494e-02f, -1.13233797e-01f, -2.08148256e-01f, 4.77064066e-02f, -5.44948578e-02f, -2.50260308e-02f,
  -3.62786278e-02f, -3.75529796e-01f, 3.31075132e-01f, -2.14616612e-01f, -2.43306234e-01f, -1.30734980e-01f, -3.53528038e-02f, 1.24768212e-01f, -5.17344568e-04f, -1.40473545e-01f,
  2.22002044e-01f, -7.05793947e-02f, 2.27419958e-01f, 3.88497263e-02f, 1.77895784e-01f, -1.34474516e-01f, -1.02297597e-01f, 2.03323483e-01f, 4.26052243e-01f, -1.86506975e-02f,
  -1.39029190e-01f, 7.54219443e-02f, 1.26559585e-01f, 7.47378916e-03f, -6.98563233e-02f, -1.36490002e-01f, 4.63359877e-02f, 1.54648423e-01f, -2.76268460e-02f, 2.67444581e-01f,
  7.97838196e-02f, -2.03354806e-02f, -8.11380818e-02f, 1.65048227e-01f, -1.70633733e-01f, 3.46128881e-01f, -8.50377828e-02f, 2.09742829e-01f, 8.26952457e-02f, 2.00107202e-01f,
  1.74276635e-01f, 5.39940238e-01f, 3.05658847e-01f, 3.76716048e-01f, 2.43528351e-01f, 3.65004599e-01f, 3.02151680e-01f, 2.13867560e-01f, 1.47713661e-01f, -6.02924153e-02f,
  -1.14471987e-01f, -1.41221788e-02f, -1.67296994e-02f, 5.63686907e-01f, -4.94984277e-02f, 3.40479344e-01f, 7.00858459e-02f, -2.84842491e-01f, -6.15851246e-02f, 5.72015792e-02f,
  -3.57687443e-01f, -4.30784285e-01f, 1.65396690e-01f, 2.93195933e-01f, 1.01104237e-01f, -2.72381157e-01f, -1.28978044e-01f, -3.21078539e-01f, 1.87558278e-01f, -9.53555852e-02f,
  -7.28770643e-02f, -1.35057405e-01f, -1.88954651e-01f, 3.20641458e-01f, 1.45597130e-01f, -8.15318078e-02f, 7.16928169e-02f, 1.34621039e-01f, 7.12444603e-01f, 1.15105763e-01f,
  -2.69154310e-01f, 2.14979798e-01f, 1.65217340e-01f, -1.86459184e-01f, 3.76345776e-02f, -2.58185044e-02f, -1.09839618e-01f, 4.29129191e-02f, 1.60482243e-01f, 2.56836712e-01f,
  -3.43322635e-01f, -3.53564233e-01f, -4.01961058e-02f, -1.25361145e-01f, 1.91280767e-02f, 9.73655507e-02f, -8.08330029e-02f, -1.60133600e-01f, -1.72186136e-01f, 3.10223937e-01f,
  -1.07046232e-01f, -2.71698390e-03f, 8.25320929e-02f, 1.59948140e-01f, 1.31491393e-01f, 2.37345561e-01f, -1.28220603e-01f, 1.33861274e-01f, -1.43288076e-01f, -8.75322744e-02f,
  2.41536833e-02f, -2.00671494e-01f, -2.14145690e-01f, 1.94852203e-01f, 1.48196995e-01f, -1.70737922e-01f, 4.20109957e-01f, -4.18118984e-01f, -5.06226480e-01f, -1.94778413e-01f,
  -2.10237667e-01f, 2.69791186e-01f, -7.92106539e-02f, 1.00100473e-01f, 1.90495566e-01f, -1.51180714e-01f, 4.53987449e-01f, 4.21360642e-01f, 2.35940851e-02f, -1.84667692e-01f,
  2.93599516e-01f, -1.34243548e-01f, -6.98160455e-02f, 3.41868430e-01f, 4.57111001e-02f, -5.65544009e-01f, 5.31421453e-02f, -8.53486210e-02f, -4.99538571e-01f, 2.26131231e-02f,
  -2.04144359e-01f, 3.04962024e-02f, -6.09176233e-02f, 5.29646017e-02f, -1.13954902e-01f, -2.71783978e-01f, -2.93918252e-01f, 9.54056159e-02f, -1.75731719e-01f, -5.59183322e-02f,
  7.48597562e-01f, 7.11209401e-02f, -1.24208584e-01f, -2.76348125e-02f, -3.33987266e-01f, -1.00834928e-01f, 1.30734578e-01f, -1.50562480e-01f, 3.02076675e-02f, -1.03780925e-01f,
  3.71676058e-01f, -1.39165953e-01f, -2.88485467e-01f, 6.67755231e-02f, 1.61085874e-01f, 2.65184734e-02f, 7.70431086e-02f, -4.20904547e-01f, 8.14589486e-02f, -2.58749127e-01f,
  1.27681300e-01f, -4.51990739e-02f, -9.79674906e-02f, 5.13919927e-02f, -5.66748157e-02f, 4.20924962e-01f, 6.81896806e-02f, 2.73782641e-01f, 3.30249757e-01f, -2.37806626e-02f,
  3.68557155e-01f, -4.10967231e-01f, -2.03321859e-01f, -1.20331757e-01f, 1.97239846e-01f, -3.61107856e-01f, -1.37044713e-01f, -2.99752593e-01f, 3.09096634e-01f, -9.31774080e-02f,
  -2.68633720e-02f, -6.77858815e-02f, 9.85756442e-02f, 5.94743490e-01f, 7.11595714e-02f, -1.64754897e-01f, -2.63594408e-02f, -1.19662054e-01f, 2.05794219e-02f, -1.32288426e-01f,
  -4.10012389e-03f, 4.84806225e-02f, 6.91610500e-02f, 2.90444911e-01f, -1.42597333e-01f, 8.96096677e-02f, -1.79118186e-01f, -6.05820939e-02f, 3.91304106e-01f, -6.07069917e-02f,
  -4.68538627e-02f, -8.82965177e-02f, 2.76029676e-01f, 1.08508840e-01f, -4.20001417e-01f, -2.13144533e-02f, 1.05678476e-02f, -2.03059599e-01f, 4.00611639e-01f, 3.75164635e-02f,
  -8.99682054e-04f, 2.75719404e-01f, 1.20617092e-01f, 2.67868012e-01f, -1.81818772e-02f, -9.57329571e-02f, -3.70973498e-02f, -5.28180599e-02f, 3.69108826e-01f, -1.40010631e-02f,
  -3.39853205e-02f, -1.01544783e-01f, -2.32710272e-01f, 1.17374890e-01f, -6.89330101e-02f, -4.89704460e-02f, 1.68131992e-01f, 6.54192036e-03f, 2.37240687e-01f, -1.19974993e-01f,
  -2.36631438e-01f, 3.69665086e-01f, -1.96879417e-01f, 3.95259321e-01f, 6.04645349e-02f, 4.62960839e-01f, -3.45029622e-01f, 2.18570501e-01f, -1.60379663e-01f, -3.43179107e-01f,
  -2.47677222e-01f, -2.11698219e-01f, -1.58849210e-01f, 2.23574758e-01f, -1.93612143e-01f, -1.38724282e-01f, 1.34262174e-01f, 1.67097464e-01f, -3.24100763e-01f, 2.92220294e-01f,
  -1.53237700e-01f, 1.08402357e-01f, 6.32627457e-02f, -3.14248711e-01f, -1.53821856e-01f, 4.24739897e-01f, -1.74336001e-01f, 1.68535382e-01f, -1.26047119e-01f, -1.03057362e-01f,
  -2.08287373e-01f, 3.51177305e-01f, -2.22437277e-01f, -6.32009581e-02f, -2.66544402e-01f, -3.31471562e-02f, 5.70627630e-01f, -1.17362857e-01f, -2.77316682e-02f, -4.77711484e-02f,
  4.01042193e-01f, -1.33139506e-01f, -1.54307202e-01f, -2.46021405e-01f, 4.57339227e-01f, -1.55524373e-01f, -1.42675713e-01f, -3.99111724e-03f, -2.69341707e-01f, -9.84510854e-02f,
  -1.52076557e-01f, -1.71934426e-01f, 4.38521542e-02f, -2.22554002e-02f, 1.16836712e-01f, -3.25042158e-01f, 1.70628931e-02f, -6.25698343e-02f, 3.41547400e-01f, 1.76430419e-01f,
  2.85774563e-02f, -3.15633714e-01f, 5.23864627e-02f, 2.39101589e-01f, 4.18745458e-01f, -2.74619997e-01f, 2.28583694e-01f, -2.76647389e-01f, -2.36243322e-01f, -5.19555748e-01f,
  1.79395638e-02f, 1.26216471e-01f, 2.36764953e-01f, 4.28674459e-01f, 1.74891502e-02f, -5.67100793e-02f, -1.62447497e-01f, 3.23583893e-02f, 3.21856678e-01f, 6.55500293e-01f,
  -9.50487237e-03f, 1.26698837e-01f, 4.57389057e-01f, -1.82690427e-01f, -3.08120817e-01f, 9.04341638e-02f, -7.27621466e-02f, -7.24564493e-02f, -1.85869560e-01f, -1.20129049e-01f,
  -4.16988522e-01f, -2.06215441e-01f, -2.93348450e-02f, -3.65720876e-02f, -6.35101870e-02f, -1.24754079e-01f, 2.27765054e-01f, 1.96403533e-01f, -7.89651275e-02f, -9.00011435e-02f,
  -1.73762962e-01f, -1.10977486e-01f, -9.71369594e-02f, -9.29365531e-02f, -3.94512624e-01f, 2.60561258e-01f, -6.29897416e-02f, -1.97912619e-01f, -1.26294896e-01f, 3.77148539e-01f,
  3.82876843e-02f, 1.76456511e-01f, 3.00911069e-01f, 1.11080512e-01f, -1.29851744e-01f, -7.52050802e-02f, 2.77140349e-01f, -1.27393350e-01f, -1.71692446e-01f, 3.51536095e-01f,
  -1.12530597e-01f, -1.30195860e-02f, 2.30216514e-02f, -1.89733282e-02f, -4.08863015e-02f, 1.43786922e-01f, 1.62762195e-01f, -2.13441148e-01f, -1.19705789e-01f, -2.04797104e-01f,
  -2.91168720e-01f, 1.77326009e-01f, -1.24504454e-02f, -4.50486809e-01f, 2.25510877e-02f, 1.13259014e-02f, -1.07891835e-01f, -3.07821572e-01f, -3.13773185e-01f, 3.72972876e-01f,
  -1.30924150e-01f, 3.73135209e-02f, -2.05493361e-01f, -3.42994690e-01f, 6.48243204e-02f, -4.32640389e-02f, 5.86185940e-02f, -3.53345126e-02f, 3.16109329e-01f, 1.15874819e-01f,
  1.98696945e-02f, -3.16686511e-01f, 1.53841987e-01f, 4.20882612e-01f, 4.55389410e-01f, 4.04167265e-01f, 3.27965647e-01f, -1.09109044e-01f, 3.17691416e-01f, -1.76079214e-01f,
  -3.24612111e-02f, -3.26228559e-01f, 6.35753572e-02f, -1.60469323e-01f, -9.69005898e-02f, 9.85467248e-03f, -1.83428660e-01f, 3.60146612e-02f, -1.05372153e-01f, 2.55578905e-01f,
  5.11025965e-01f, 1.47125917e-02f, 1.40328005e-01f, 4.58681397e-02f, 1.89354513e-02f, -7.57871345e-02f, -1.25329858e-02f, -8.01993757e-02f, -2.40117252e-01f, 2.13024572e-01f,
  -8.00933037e-03f, 7.68428668e-02f, -1.07249081e-01f, -2.49189258e-01f, 4.49291691e-02f, -7.05768466e-02f, -2.40311086e-01f, -4.22597438e-01f, 1.54480383e-01f, 6.69494197e-02f,
  -1.86828598e-01f, -2.78874278e-01f, -1.27874300e-01f, 3.67818296e-01f, 2.18629554e-01f, 1.36893287e-01f, 4.13774371e-01f, 1.16554812e-01f, -8.11217166e-03f, -3.23556848e-02f,
  -1.47972882e-01f, 6.01231992e-01f, -2.65226275e-01f, -2.86077857e-01f, 3.97230864e-01f, -1.72259435e-01f, -1.49847642e-01f, -1.36104494e-01f, 8.54352489e-02f, 1.36066116e-02f,
  -3.20772439e-01f, 3.50515987e-03f, 2.81151503e-01f, 1.32550567e-01f, 7.36639947e-02f, -5.43078147e-02f, 1.02097169e-01f, -1.49192929e-01f, -4.68972027e-02f, -1.04901299e-01f,
  7.85202384e-02f, 2.67323367e-02f, -1.22597896e-01f, 2.83214878e-02f, -3.58468443e-01f, -1.11084789e-01f, 8.42999890e-02f, -1.95503309e-01f, -5.75095415e-02f, -7.92975202e-02f,
  3.20723981e-01f, -9.07426700e-02f, 4.54253584e-01f, -2.79190093e-01f, -1.23328261e-01f, -6.00742549e-02f, 2.36580819e-02f, 1.96350321e-01f, 6.31742328e-02f, -4.61137220e-02f,
  2.93827444e-01f, 1.29610792e-01f, 1.28676847e-01f, 2.39413064e-02f, -2.88041592e-01f, 7.48819038e-02f, 3.38777930e-01f, -2.62569666e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.85272515e-01f, -7.18723312e-02f, 9.01128277e-02f, -4.35190760e-02f, -3.82385217e-04f, 1.85458571e-01f, 1.08387277e-01f, 3.02045792e-02f, 1.23008095e-01f, -1.39191570e-02f,
  6.29671887e-02f, 4.69637960e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    