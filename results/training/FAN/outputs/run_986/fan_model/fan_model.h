/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.76042712e-01f, 2.59231478e-01f, 9.87074301e-02f, 1.44634452e-02f, -1.24066360e-02f, -2.13551104e-01f, -1.69859216e-01f, -3.46478708e-02f, -1.23645601e-04f, 1.36305273e-01f,
  -9.48192403e-02f, -1.91177666e-01f, -6.37361705e-02f, -5.81438579e-02f, -1.52038217e-01f, 1.97079316e-01f, 3.41151237e-01f, 4.22289260e-02f, -2.61085898e-01f, -1.93999693e-01f,
  1.30343139e-01f, 7.93682411e-02f, -1.83565561e-02f, 2.94643920e-02f, 1.75896764e-01f, -1.17688384e-02f, 2.91426867e-01f, 9.84050557e-02f, -1.69227682e-02f, 5.32486737e-01f,
  -8.44941661e-02f, 1.49793392e-02f, -3.68193462e-02f, 3.19466315e-04f, 8.91586393e-03f, 5.26914233e-03f, -2.85044704e-02f, 1.59284800e-01f, 4.48424518e-02f, 4.53068279e-02f,
  -2.21764483e-02f, 1.67741929e-03f, -1.84073970e-02f, 7.38803968e-02f, -1.54531887e-03f, -8.36429670e-02f, 9.75756496e-02f, -5.93821285e-03f, 6.74002171e-02f, -1.29219359e-02f,
  1.10491075e-01f, -3.22843231e-02f, -6.58689663e-02f, 2.87474953e-02f, -3.92093584e-02f, -3.96257527e-02f, 6.57627881e-02f, 5.01036551e-03f, 3.63181578e-03f, 1.76239222e-01f,
  -3.54724750e-02f, -7.89456367e-02f, -8.14915076e-02f, 2.70378981e-02f, -4.24234271e-02f, -4.86460626e-02f, 2.04891115e-02f, -3.65708657e-02f, 5.57902008e-02f, 8.17759521e-03f,
  8.62299697e-04f, -3.70315905e-03f, -2.92536262e-02f, -3.78226787e-02f, 3.46166082e-02f, -3.28597724e-02f, -7.87738785e-02f, 5.34159951e-02f, 1.91361625e-02f, 2.56975670e-03f,
  -1.92092936e-02f, 5.23754172e-02f, 3.20439525e-02f, 8.22257157e-03f, -2.32299194e-02f, -4.18052413e-02f, -1.76109727e-02f, -5.63295744e-02f, -6.75659105e-02f, -1.40814316e-02f,
  -2.26221308e-02f, -1.11040853e-01f, 2.73516793e-02f, 3.11203748e-02f, 2.91183051e-02f, 8.83366540e-02f, -3.05293668e-02f, 1.18688852e-01f, 2.51265839e-02f, 1.30521208e-01f,
  -3.56220044e-02f, -4.97938469e-02f, 1.25716010e-03f, 9.66791362e-02f, -3.87441963e-02f, 2.70200409e-02f, 3.69396470e-02f, -6.24344870e-03f, 1.68308280e-02f, 2.08399445e-01f,
  1.54990241e-01f, 7.21665099e-02f, -1.63557112e-01f, 5.79890348e-02f, 2.06818562e-02f, -1.89137459e-01f, 4.08719853e-02f, -3.08073387e-02f, -2.22511292e-01f, 8.53921473e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.63662899e-01f, 7.16364622e-01f, 1.00736819e-01f, -6.39786720e-01f, 2.34557435e-01f, 1.85409501e-01f, 1.81827471e-01f, -3.99647467e-02f, 3.49783599e-02f, 3.61064404e-01f,
  4.22066182e-01f, 9.52898785e-02f, 2.03788877e-02f, -1.63599372e-01f, -3.25004905e-01f, -3.03316470e-02f, -2.90535633e-02f, -5.21859646e-01f, -5.92327178e-01f, -1.73900276e-01f,
  1.37922794e-01f, -2.50036806e-01f, -5.41823626e-01f, -4.26308990e-01f, -7.79587179e-02f, -2.58593351e-01f, -1.55334979e-01f, -3.69799554e-01f, 3.53786387e-02f, -7.05029592e-02f,
  -7.32303336e-02f, 1.88779738e-02f, 6.96667284e-02f, -7.09647387e-02f, 2.87319273e-01f, -1.05449624e-01f, 1.20029613e-01f, -5.40215746e-02f, 1.12602375e-01f, 6.99080750e-02f,
  1.38999432e-01f, 8.68476108e-02f, -8.09878260e-02f, -1.10762395e-01f, -3.13707829e-01f, -1.56809524e-01f, -9.59649831e-02f, -4.97149616e-01f, -2.49363527e-01f, 1.63179383e-01f,
  5.95093518e-02f, 2.74306089e-01f, -3.51700217e-01f, 4.12539952e-02f, -1.61833271e-01f, -7.29620829e-02f, -2.89818883e-01f, -5.13336062e-01f, -4.63184088e-01f, -5.61606407e-01f,
  1.85679421e-01f, 1.20118678e-01f, 1.30498126e-01f, -2.88718138e-02f, -1.15733370e-01f, 1.15603372e-01f, -2.08742972e-02f, -1.08819015e-01f, -4.19059061e-02f, -1.84303626e-01f,
  5.32658845e-02f, 1.66905150e-01f, 7.21396785e-03f, 5.37087247e-02f, 1.11851044e-01f, -2.52180845e-02f, -1.79700240e-01f, -9.52555388e-02f, -6.58084005e-02f, 5.73910102e-02f,
  -1.05957739e-01f, -1.32500127e-01f, 8.39986131e-02f, -1.48136988e-01f, -5.13320006e-02f, -6.07319474e-02f, 2.16481060e-01f, 2.17723101e-01f, 1.32328067e-02f, 6.59762397e-02f,
  -3.55581731e-01f, 2.33891383e-01f, -5.13361674e-03f, 8.60172734e-02f, -1.06706783e-01f, -2.99990922e-02f, 1.27407566e-01f, 1.43640161e-01f, 1.16238974e-01f, -1.51763141e-01f,
  2.81442776e-02f, 1.15282893e-01f, 3.59275229e-02f, 4.80918624e-02f, -3.17006379e-01f, 5.83615638e-02f, -7.39177642e-03f, -2.45557576e-01f, -1.37010649e-01f, -1.67581551e-02f,
  -1.67770967e-01f, -1.16974965e-01f, -4.31517452e-01f, -2.77610451e-01f, -1.88083529e-01f, -4.54606533e-01f, -3.88900995e-01f, -5.08553684e-01f, -4.61729765e-01f, -4.96789128e-01f,
  1.08541632e+00f, 1.43439472e-01f, 2.65966356e-01f, 1.06000051e-01f, -5.17615378e-01f, -2.24140927e-01f, -2.72834152e-01f, 1.00192465e-01f, 6.33763224e-02f, 1.54419661e-01f,
  5.96684963e-02f, 2.28044331e-01f, 2.99210250e-01f, 2.96955615e-01f, 3.66630018e-01f, 6.82220459e-02f, -1.11470483e-01f, 4.22082961e-01f, 3.76248032e-01f, 2.52021253e-01f,
  -8.89736563e-02f, -7.14702010e-02f, 2.15899676e-01f, 7.29922578e-02f, -1.54428005e-01f, 1.81287453e-02f, -4.64956500e-02f, -2.38674283e-01f, -1.49270579e-01f, -5.14965691e-02f,
  5.14635861e-01f, 2.63362706e-01f, 2.58660406e-01f, 7.74538219e-02f, -1.31006509e-01f, 1.43253520e-01f, 7.38994926e-02f, 5.26798218e-02f, -1.60839811e-01f, -7.39068091e-02f,
  -1.83882862e-01f, -2.68205255e-02f, -8.15423056e-02f, -2.01091021e-01f, -1.98252842e-01f, -1.35515809e-01f, -1.43601269e-01f, 2.15751052e-01f, 1.46346003e-01f, 3.98387499e-02f,
  -1.34937599e-01f, -2.11129010e-01f, -6.46893829e-02f, -9.35994461e-02f, 1.04594752e-01f, -1.82198677e-02f, -8.73220339e-02f, 5.06280065e-02f, -3.87906842e-02f, 9.18666348e-02f,
  1.76520362e-01f, 2.79827826e-02f, 1.79690085e-02f, 1.76054202e-02f, -2.12929510e-02f, -7.93926325e-03f, 9.66295004e-02f, 2.05786526e-02f, 1.71165764e-02f, -1.29798323e-01f,
  -9.52424482e-02f, 1.82978928e-01f, 8.71804804e-02f, 1.75336927e-01f, 7.15303570e-02f, -1.55515641e-01f, -8.43056068e-02f, 2.01886922e-01f, -1.35594858e-02f, -1.06898472e-01f,
  -3.30396667e-02f, 8.28906298e-02f, -3.80697399e-02f, 1.60043295e-02f, -9.38811526e-02f, 9.61323641e-03f, -1.56356245e-01f, -4.13927473e-02f, -1.54927120e-01f, -1.83561698e-01f,
  -5.12562431e-02f, 1.30617082e-01f, 2.66180396e-01f, -5.90678006e-02f, -1.22097746e-01f, -6.95883855e-02f, -1.04871504e-01f, 1.24987379e-01f, -7.67263323e-02f, -3.03292018e-03f,
  -6.75203204e-02f, 2.65503991e-02f, 1.64675172e-02f, -7.34264925e-02f, -1.76030487e-01f, -5.77262007e-02f, -1.65194541e-01f, 1.46715239e-01f, 1.66751176e-01f, -6.39672503e-02f,
  -1.37255460e-01f, 3.76096331e-02f, 2.13928685e-01f, 2.06690371e-01f, 3.56650352e-02f, 2.59189695e-01f, -2.81761643e-02f, -1.26186851e-02f, 9.50143859e-02f, -4.14844975e-02f,
  6.20711744e-01f, -4.30342644e-01f, -8.51970077e-01f, -2.59204190e-02f, -5.52979648e-01f, -3.21936488e-01f, -4.03674781e-01f, 2.33659938e-01f, 2.44683266e-01f, -4.23432142e-01f,
  7.79187307e-02f, 5.20703018e-01f, 3.18901330e-01f, 2.66398996e-01f, 3.67938757e-01f, -5.54332256e-01f, -6.09468162e-01f, -1.94821388e-01f, 1.25931293e-01f, 1.79892302e-01f,
  8.67863446e-02f, 8.89715701e-02f, 3.17503750e-01f, 1.57121822e-01f, -3.11928332e-01f, -8.36737920e-03f, -4.95983660e-01f, -2.39007488e-01f, -3.03709924e-01f, -6.07798874e-01f,
  -2.49892101e-01f, -3.09801459e-01f, 1.02903254e-01f, 6.63579330e-02f, -2.66195655e-01f, 2.13932805e-02f, 7.77444663e-03f, -2.35737085e-01f, -1.17450226e-02f, -1.92028567e-01f,
  -1.85595155e-01f, -9.82176885e-02f, -8.12302306e-02f, 3.21046375e-02f, -7.51660839e-02f, -4.79837582e-02f, -3.28217894e-02f, -9.50595886e-02f, -1.37311772e-01f, -2.33441025e-01f,
  -3.76629531e-02f, -1.88455284e-01f, -2.15925232e-01f, -2.13982984e-02f, -5.75163625e-02f, -9.08670500e-02f, -2.43852124e-01f, -1.55927375e-01f, -3.18507776e-02f, -2.39038944e-01f,
  -1.10256962e-01f, -1.17531843e-01f, 2.20283121e-02f, -2.77691726e-02f, -6.61436170e-02f, 1.14491835e-01f, 5.73919900e-02f, 6.45546466e-02f, 8.68246853e-02f, 2.08011866e-02f,
  -7.84825906e-03f, -8.17180648e-02f, 6.85898168e-03f, 8.68546367e-02f, -1.17058614e-02f, 7.77608901e-02f, 7.95871988e-02f, -4.41593491e-02f, -9.42877606e-02f, -4.01146933e-02f,
  3.92372757e-02f, -4.97725271e-02f, -2.20173947e-03f, 6.76616877e-02f, -1.46877483e-01f, -1.34475827e-01f, 3.05956695e-02f, -2.89707836e-02f, 3.21144350e-02f, -5.09793870e-02f,
  5.76593995e-01f, -6.55610636e-02f, 5.95184676e-02f, 1.05747961e-01f, -1.55156881e-01f, -7.17395097e-02f, -1.10670462e-01f, -9.50955600e-02f, -1.18053507e-03f, -4.90617240e-04f,
  -6.69501498e-02f, 4.32065725e-02f, -1.66880141e-04f, 5.72394952e-02f, -1.09423429e-01f, 7.20793009e-02f, 6.30508289e-02f, 1.86890304e-01f, -8.30282085e-03f, -9.27341506e-02f,
  2.43914872e-02f, 1.18930295e-01f, 1.53660417e-01f, 1.28357485e-01f, 1.21860564e-01f, 2.22417951e-01f, -2.14565098e-02f, 1.67733636e-02f, 2.48257801e-01f, 1.15438603e-01f,
  -6.69914335e-02f, 1.48913175e-01f, 5.11332273e-01f, 2.88947910e-01f, 5.85275769e-01f, 6.40878201e-01f, 9.09160197e-01f, 3.67758095e-01f, -8.44363961e-03f, 1.77126825e-01f,
  -1.18532516e-01f, -2.60347873e-01f, -2.15158224e-01f, -1.74278915e-01f, 2.63923019e-01f, 4.38891917e-01f, 4.66639012e-01f, 1.42952710e-01f, 5.19871190e-02f, 1.74415141e-01f,
  6.69605285e-02f, 2.63452232e-02f, -1.42738342e-01f, -5.90479970e-02f, 1.40463948e-01f, -4.22562547e-02f, 1.80145517e-01f, 1.76525831e-01f, 1.38573647e-01f, -7.18132686e-03f,
  3.61904576e-02f, 3.01898122e-01f, -1.32919326e-01f, -2.87454069e-01f, -1.79106340e-01f, -2.08177567e-01f, -9.87196490e-02f, -1.20651424e-01f, -1.71314165e-01f, -1.17728569e-01f,
  2.67866626e-03f, -1.08887814e-01f, 7.40001127e-02f, -1.51448503e-01f, 1.90950539e-02f, -9.88144651e-02f, 3.59484670e-03f, 1.87835827e-01f, 1.20194338e-01f, -6.58361837e-02f,
  -5.27860178e-03f, -2.02050665e-03f, 2.46045038e-01f, 1.21816769e-01f, 2.06291631e-01f, -7.07799122e-02f, 9.21464115e-02f, -9.17839184e-02f, 5.45053668e-02f, -1.53782010e-01f,
  -5.63758388e-02f, 1.50585517e-01f, 1.26892045e-01f, 2.24171150e-02f, 3.97636034e-02f, -7.29210004e-02f, 3.39373723e-02f, 1.09832473e-01f, 2.61576831e-01f, 1.23073407e-01f,
  -4.86770011e-02f, 5.49501367e-02f, 6.27282411e-02f, 6.91249222e-02f, 2.30548158e-02f, 1.53527617e-01f, 6.30254745e-02f, -5.38732372e-02f, 2.74416972e-02f, -1.76985085e-03f,
  1.51736885e-01f, 8.60759243e-02f, -1.35336248e-02f, 1.40425339e-01f, -9.98889655e-03f, -1.15148304e-02f, -6.63910210e-02f, -6.52487054e-02f, -7.06054345e-02f, -7.31867328e-02f,
  -1.57588981e-02f, 3.41260105e-01f, -6.85572475e-02f, 4.80804630e-02f, -4.21989970e-02f, -3.22231911e-02f, 1.21269459e-02f, -2.73038950e-02f, -2.24231947e-02f, -7.09496364e-02f,
  5.36461808e-02f, -1.55965447e-01f, 4.88425083e-02f, 6.06398582e-02f, -6.35742694e-02f, -7.58902803e-02f, -7.10211843e-02f, 4.67157327e-02f, 3.09850983e-02f, -8.94971266e-02f,
  -9.55811590e-02f, -3.39400372e-03f, 6.97240755e-02f, 1.39773458e-01f, -6.15949966e-02f, -2.10804537e-01f, 1.75769441e-02f, -1.54182166e-01f, 5.21045923e-03f, -2.11858958e-01f,
  -6.61958516e-01f, -3.91837507e-01f, 1.44919008e-01f, 2.57362366e-01f, 2.34905839e-01f, -2.26197928e-01f, -6.34985209e-01f, -4.30144072e-01f, 1.31150767e-01f, -1.87384844e-01f,
  -2.23341182e-01f, 4.37673002e-01f, 4.63410735e-01f, 3.34886342e-01f, 2.67676655e-02f, 7.67098740e-02f, 5.75970709e-01f, 6.61680400e-01f, 3.09571624e-01f, 4.50908579e-02f,
  5.38479090e-01f, 5.31922519e-01f, 4.29024667e-01f, 3.68251055e-01f, 2.90853322e-01f, 6.16461456e-01f, 4.87067968e-01f, 3.87090564e-01f, 3.42963845e-01f, 5.85502386e-01f,
  -4.06118006e-01f, -6.39125168e-01f, 2.41770864e-01f, 1.94738626e-01f, -9.60226357e-02f, -2.85898566e-01f, -1.93130523e-01f, -1.08175173e-01f, -2.18727872e-01f, -1.55413315e-01f,
  1.01807997e-01f, -2.00642228e-01f, 3.45626138e-02f, 6.80258796e-02f, -1.80669382e-01f, -1.95396915e-01f, -1.30151033e-01f, -2.57255603e-02f, -1.49857551e-01f, -3.82433236e-01f,
  3.41155559e-01f, 2.04593558e-02f, -4.67395604e-01f, -1.29735738e-01f, -3.23455840e-01f, 3.79715681e-01f, -3.90886158e-01f, -4.02495295e-01f, -4.34154302e-01f, -6.62880659e-01f,
  -1.45743638e-01f, -7.22454414e-02f, -1.13559820e-01f, -3.24474908e-02f, 1.09331766e-02f, 2.01840681e-04f, 1.02682829e-01f, 3.21475379e-02f, 2.07881019e-01f, -7.68391714e-02f,
  -1.61404803e-01f, -9.99661610e-02f, -2.84372568e-02f, -1.59252048e-01f, 3.31668407e-02f, 4.08392325e-02f, -4.70039211e-02f, 1.37501005e-02f, 5.59559129e-02f, -4.28974405e-02f,
  1.32470354e-01f, 2.14468315e-02f, 1.59683272e-01f, 1.08245641e-01f, -7.60712251e-02f, -1.26297353e-02f, 1.01446643e-01f, -7.27421865e-02f, -1.04738228e-01f, -1.64052233e-01f,
  2.36771349e-02f, 3.68879467e-01f, -1.73637182e-01f, 1.19129777e-01f, -7.95907304e-02f, -1.02924347e-01f, 8.99234861e-02f, -1.35420457e-01f, -2.99786124e-02f, -1.01593025e-01f,
  -2.38577589e-01f, -2.69640654e-01f, -6.01585694e-02f, 8.19841698e-02f, -4.48685102e-02f, -1.12916753e-01f, 1.41841099e-02f, 1.55294254e-01f, -4.70329225e-02f, -2.20989585e-01f,
  -4.24959743e-03f, -2.55264401e-01f, -3.49303424e-01f, -3.56300831e-01f, -6.47698417e-02f, -5.87251149e-02f, -2.18870580e-01f, -3.39628547e-01f, -5.17103016e-01f, -7.04875946e-01f,
  -8.68175149e-01f, -9.00458574e-01f, -1.79189384e-01f, -6.45621836e-01f, -1.42620221e-01f, 2.84928977e-01f, -3.07732046e-01f, 1.43507002e-02f, -1.12056620e-01f, -4.88860160e-01f,
  -1.05060756e-01f, 6.76022470e-02f, -1.66455731e-01f, 9.85868350e-02f, 1.77869216e-01f, -1.44724101e-01f, -1.98906496e-01f, -4.52349111e-02f, 4.82135355e-01f, 5.71003258e-01f,
  5.26096039e-02f, -3.81430984e-01f, -8.47635940e-02f, 8.79699290e-02f, -3.93367112e-01f, -2.27364942e-01f, -5.02498031e-01f, -3.10123652e-01f, -1.08187990e-02f, -6.61243677e-01f,
  -2.75712997e-01f, -1.95284232e-01f, 2.15376541e-01f, 1.15010953e-02f, -1.71960548e-01f, 1.24616414e-01f, -5.57379648e-02f, -2.29805931e-01f, 1.02590755e-01f, -3.27091478e-02f,
  -1.27803683e-02f, 1.25175947e-02f, -7.83390775e-02f, 8.62312224e-03f, -6.25596717e-02f, 8.46759230e-03f, -6.35627657e-02f, -7.27932006e-02f, 3.14274803e-02f, 1.23795189e-01f,
  9.26055713e-04f, -5.85875735e-02f, -4.66489233e-02f, 1.84300169e-01f, 2.43922412e-01f, 9.61817652e-02f, 5.10322191e-02f, 1.70360982e-01f, 2.28103295e-01f, -3.85392338e-01f,
  -2.15747461e-01f, -3.98653150e-02f, 8.32842290e-03f, 2.04161964e-02f, 1.02989808e-01f, -7.38018053e-03f, -1.25054374e-01f, -9.02913511e-02f, 6.06762469e-02f, -2.34400392e-01f,
  2.10790057e-02f, 7.79087096e-02f, 9.67507809e-02f, -1.88415617e-01f, -7.04664513e-02f, -1.16221555e-01f, 9.29676462e-03f, -6.36477917e-02f, 5.75267673e-02f, -2.06197258e-02f,
  5.54225110e-02f, 3.20005640e-02f, -1.27037466e-01f, 1.34763157e-03f, 6.75198957e-02f, -5.95351681e-02f, 3.41278091e-02f, 1.15497142e-01f, -3.23706158e-02f, 1.17652975e-01f,
  -5.95546305e-01f, 2.34550551e-01f, -2.32929677e-01f, 1.14517912e-01f, -1.20632321e-01f, -2.91776843e-02f, -7.92032108e-02f, 1.09888650e-01f, -1.12499304e-01f, 2.20136672e-01f,
  1.91560030e-01f, 9.14577802e-04f, -1.87129900e-01f, 5.13559170e-02f, 7.66825378e-02f, 1.41017660e-01f, -1.47216082e-01f, -1.20729171e-01f, 2.65456289e-01f, 1.15155969e-02f,
  1.21598775e-02f, 6.59633055e-02f, -1.48113191e-01f, -3.61231267e-02f, 6.07247315e-02f, 1.28529862e-01f, -1.10896438e-01f, 5.36397919e-02f, 5.78247495e-02f, -2.62230814e-01f,
  1.37259233e+00f, 7.65162587e-01f, 4.36420366e-03f, -8.05420801e-03f, -4.38898385e-01f, -3.25465113e-01f, -3.40336114e-02f, -7.40103126e-02f, -1.03524365e-01f, 2.78984815e-01f,
  3.26163061e-02f, -2.17962131e-01f, -3.81652147e-01f, -2.34848142e-01f, -9.52272564e-02f, 5.98424906e-03f, -9.56322774e-02f, 4.15627509e-02f, -2.70611048e-01f, -2.44142562e-02f,
  -8.30369350e-03f, 2.94322878e-01f, 3.21949869e-01f, -8.28389600e-02f, 2.15987787e-01f, -4.09325093e-01f, -1.83377430e-01f, 1.67882621e-01f, 2.22328342e-02f, 4.05992359e-01f,
  5.40113270e-01f, 4.76365089e-01f, -5.36777675e-01f, -1.59426138e-01f, 1.40544280e-01f, 1.43586800e-01f, -2.66122222e-02f, 1.63781680e-02f, -3.30810398e-02f, -3.53956632e-02f,
  7.70215988e-02f, 2.32494473e-01f, -8.05561319e-02f, -7.32063130e-02f, 7.38812983e-02f, -4.33603534e-03f, -2.31286045e-02f, 1.38677612e-01f, -7.62810633e-02f, 1.03791952e-01f,
  -6.27822727e-02f, 1.47037774e-01f, 6.98131174e-02f, -3.67306441e-01f, -1.79686219e-01f, -2.25908011e-01f, 1.08089997e-02f, 4.86680716e-02f, -6.18392751e-02f, 4.05419290e-01f,
  -2.35327408e-01f, -1.09833591e-02f, 4.16736975e-02f, 1.17116012e-01f, 3.07072364e-02f, -6.62297606e-02f, -1.28386058e-02f, -1.17707126e-01f, -5.16600162e-02f, 3.40268947e-02f,
  -1.45605817e-01f, -2.96509545e-02f, 1.06354682e-02f, 1.47184078e-02f, -1.67232811e-01f, -8.63808021e-02f, -7.64128268e-02f, -2.85597821e-03f, 6.91772252e-02f, 1.37343537e-02f,
  3.58871929e-02f, 1.02102198e-02f, 1.48233483e-02f, -2.45419387e-02f, -7.57141784e-02f, -4.63904999e-02f, -5.50493482e-04f, -3.89472507e-02f, -9.61719379e-02f, 1.52750403e-01f,
  3.75267640e-02f, -6.28830671e-01f, -7.20472634e-02f, -7.98041597e-02f, 1.13995381e-01f, -1.33188099e-01f, -3.72267850e-02f, -9.00517032e-03f, 1.55414402e-01f, 2.16868185e-02f,
  1.09978523e-02f, -6.11406751e-03f, 5.77426329e-02f, 5.06253242e-02f, -1.44453853e-01f, -1.66158363e-01f, -3.30856927e-02f, -2.17825666e-01f, -2.00869188e-01f, -6.03766814e-02f,
  -2.01255575e-01f, -1.72221661e-01f, -2.28994861e-01f, -1.77026063e-01f, -2.38762766e-01f, -1.42868221e-01f, -1.73706755e-01f, -1.00387461e-01f, -3.80625993e-01f, 2.74646208e-02f,
  3.48702222e-01f, -5.95948100e-01f, -1.59771010e-01f, 6.84963306e-03f, 1.48997337e-01f, 2.13195950e-01f, 1.92332461e-01f, 2.00223416e-01f, 1.15119487e-01f, 1.30683770e-02f,
  -2.77476192e-01f, -2.90290266e-01f, -3.14488888e-01f, -2.82469630e-01f, 1.22655882e-02f, 7.19198510e-02f, -1.23462705e-02f, -7.71145374e-02f, 2.39363372e-01f, 3.09453964e-01f,
  -4.67684083e-02f, 1.95734829e-01f, 2.11422563e-01f, -1.43006342e-02f, -1.00111775e-01f, 1.12876827e-02f, -1.30138740e-01f, -1.48941904e-01f, -1.15993910e-01f, -4.73077059e-01f,
  -1.86173573e-01f, -2.24132001e-01f, 2.78715402e-01f, -2.55171047e-03f, -1.77147314e-02f, 3.04452688e-01f, -6.07395247e-02f, 3.83856148e-02f, -1.59041226e-01f, -1.86709657e-01f,
  -2.44980395e-01f, -2.63252407e-01f, -3.37420583e-01f, -1.14897192e-01f, -6.76451251e-02f, 1.44615635e-01f, 1.64867006e-02f, -3.39564919e-01f, -2.53041863e-01f, -1.38742834e-01f,
  -3.09002638e-01f, -4.22260225e-01f, -2.20620289e-01f, -8.85593295e-02f, -3.03333193e-01f, -2.07465634e-01f, -3.98165941e-01f, -3.45104605e-01f, -1.54866755e-01f, -4.32360508e-02f,
  9.99361277e-02f, -1.08155392e-01f, 2.08409969e-02f, 1.48973003e-01f, 9.19162408e-02f, -1.21497497e-01f, -2.91971564e-01f, -4.23666742e-03f, 1.25324264e-01f, 1.07075341e-01f,
  -1.03853419e-01f, -2.11031642e-03f, -4.71285097e-02f, -4.31550061e-03f, -1.00995801e-01f, -1.14034146e-01f, -3.43627646e-03f, 1.24082498e-01f, 1.98070213e-01f, 2.63775975e-01f,
  4.33927849e-02f, 6.50776103e-02f, 1.64881334e-01f, -3.15373912e-02f, 3.22908871e-02f, -5.51494434e-02f, 4.73189019e-02f, -1.16954902e-02f, 7.22732693e-02f, 1.25252679e-01f,
  2.67415255e-01f, 6.22785464e-02f, 7.44694918e-02f, 5.46130762e-02f, 2.04413533e-01f, 8.12527463e-02f, -3.07117426e-03f, 2.95021199e-02f, -7.41582215e-02f, -2.12760624e-02f,
  -1.13894537e-01f, -2.13321596e-01f, -1.82390004e-01f, -7.92478472e-02f, 1.45791113e-01f, 1.50467560e-01f, -2.09268909e-02f, -5.25627285e-02f, -4.72982004e-02f, 1.61963210e-01f,
  1.47504592e-02f, 2.69257039e-01f, 4.36379850e-01f, 1.82159245e-01f, -3.04956101e-02f, 2.96287417e-01f, 7.39017799e-02f, 1.73798297e-02f, 2.62269050e-01f, 7.35518873e-01f,
  6.36571586e-01f, 2.84053445e-01f, 3.22803296e-02f, 2.56692588e-01f, 6.69554546e-02f, 2.29582801e-01f, 3.23701859e-01f, 1.74765661e-01f, 1.57339066e-01f, 1.15394361e-01f,
  1.70600936e-01f, 9.53212976e-02f, 4.57801856e-02f, 1.29211634e-01f, 2.78908741e-02f, 2.24976823e-01f, 2.40054205e-01f, 1.35727361e-01f, -1.28883850e-02f, 2.37885565e-01f,
  1.69948444e-01f, 7.83602819e-02f, 4.97544222e-02f, 2.35129949e-02f, 4.22080219e-01f, 9.46843922e-02f, 6.74563199e-02f, 1.20833792e-01f, 1.63332358e-01f, 2.93317854e-01f,
  -2.49891907e-01f, 4.62406069e-01f, 6.63007945e-02f, 6.40047267e-02f, -4.51003686e-02f, -1.54670864e-01f, -1.06539823e-01f, -1.40320703e-01f, -9.51519012e-02f, 1.02588758e-02f,
  -1.65859967e-01f, -3.12559009e-02f, 1.46702275e-01f, 5.08921631e-02f, -3.07597755e-03f, 1.91833696e-03f, 1.90105140e-01f, 3.30187231e-02f, 3.34310085e-02f, -3.92955467e-02f,
  4.66227122e-02f, -5.43958135e-02f, -1.78718045e-01f, -5.40907728e-03f, 9.00209919e-02f, -1.25967711e-02f, 1.55338332e-01f, 2.08271459e-01f, 7.46987313e-02f, 1.42516479e-01f,
  1.24556102e-01f, 1.95862979e-01f, 3.13691020e-01f, 2.15227097e-01f, 3.53516966e-01f, 1.63529366e-01f, 1.55077636e-01f, -7.60329748e-03f, 2.06976190e-01f, 6.70315400e-02f,
  -1.75014138e-01f, 3.50016579e-02f, 3.42791826e-02f, 4.23236713e-02f, 1.01665758e-01f, -4.65163440e-02f, -2.84023266e-02f, -2.62862886e-04f, -9.62431543e-03f, -4.50315848e-02f,
  -1.17257118e-01f, -1.32376567e-01f, 1.46032432e-02f, -1.95043366e-02f, 1.04157403e-02f, 1.97812349e-01f, 8.74701142e-02f, 6.18044250e-02f, -7.41508929e-03f, 9.29811448e-02f,
  -8.72212887e-01f, -2.38830939e-01f, 3.02786022e-01f, 1.05130225e-01f, 4.70786653e-02f, -4.06231806e-02f, 8.62995312e-02f, 3.82091850e-02f, -5.99430948e-02f, -1.07625760e-01f,
  -1.66187316e-01f, -9.01107639e-02f, 2.55512912e-03f, -9.37881246e-02f, -1.34811342e-01f, -1.35595962e-01f, -7.36917630e-02f, -1.57464653e-01f, -1.07931405e-01f, -1.34737045e-01f,
  -1.17609560e-01f, -2.58994818e-01f, -4.17784721e-01f, -2.20840260e-01f, -3.60654704e-02f, -1.35522097e-01f, -1.60635054e-01f, -6.88140243e-02f, -2.02196121e-01f, -8.83014128e-02f,
  6.47631288e-01f, -2.99639851e-01f, -5.16950607e-01f, 5.18475771e-01f, -2.90825754e-01f, -6.38553739e-01f, -1.01375711e+00f, -2.60416925e-01f, 5.15295744e-01f, -3.65250051e-01f,
  -3.48076858e-02f, 5.69052815e-01f, 4.95683610e-01f, 3.49382572e-02f, -2.09275588e-01f, -1.14774084e+00f, -6.91303611e-01f, -1.82115436e-01f, -1.40393585e-01f, -2.35010982e-01f,
  2.50476412e-02f, 3.00416887e-01f, 5.09769261e-01f, 2.22087562e-01f, -1.67879805e-01f, -6.25057220e-02f, -3.01828086e-01f, -1.47582605e-01f, -6.11674190e-01f, -5.69468677e-01f,
  -5.04116118e-01f, -3.50333780e-01f, -1.16113871e-01f, 1.50874361e-01f, 2.48951633e-02f, 2.10028321e-01f, -1.92346543e-01f, -1.19342171e-01f, 9.66967195e-02f, -8.40949118e-02f,
  2.59364247e-02f, -5.90677299e-02f, -1.16657808e-01f, -3.47426571e-02f, -8.52018073e-02f, 2.20505912e-02f, -1.19194284e-01f, 5.15302643e-02f, -6.76385760e-02f, -1.31650478e-01f,
  -1.55048817e-01f, -2.97067523e-01f, -4.31553453e-01f, -3.77195746e-01f, -3.80495816e-01f, -2.65882649e-02f, -3.37811857e-01f, -5.33983588e-01f, -5.24023950e-01f, -4.40371245e-01f,
  8.54265243e-02f, 1.75692379e-01f, -1.25154451e-01f, 2.42419424e-03f, 1.51142180e-01f, 1.95761826e-02f, -1.30166560e-01f, -1.32826656e-01f, 8.15975368e-02f, 9.43362266e-02f,
  4.95881103e-02f, 4.23424691e-02f, 1.96292892e-01f, 4.40383516e-02f, -6.76608309e-02f, -2.11438820e-01f, -1.37906820e-01f, -1.29299834e-01f, -1.02565534e-01f, -6.70975968e-02f,
  2.67277341e-02f, -1.21619627e-01f, 1.83043465e-01f, 7.35004693e-02f, -4.60096598e-02f, -6.26672804e-02f, 9.52511840e-03f, 3.42810266e-02f, 1.45453274e-01f, 1.04267828e-01f,
  7.66299725e-01f, 4.60848957e-02f, -1.34026825e-01f, -2.23904103e-02f, -9.93314609e-02f, 3.39583345e-02f, 5.72727136e-02f, -7.63417482e-02f, 1.83350354e-01f, 4.15978916e-02f,
  1.13495529e-01f, 3.09785306e-01f, 1.08266599e-01f, -2.72266585e-02f, -1.35279119e-01f, 7.31640905e-02f, -6.24937788e-02f, -1.70720797e-02f, -7.65683055e-02f, 2.36235306e-01f,
  1.78589538e-01f, -9.42751989e-02f, -1.09969480e-02f, -9.73202065e-02f, 7.22519308e-02f, -2.78009102e-02f, -6.93617761e-02f, -2.20308140e-01f, -3.04472968e-02f, 1.86112687e-01f,
  -8.62897456e-01f, -2.57040113e-01f, 3.90937835e-01f, -3.14761579e-01f, 3.21032882e-01f, 1.76981866e-01f, -3.26932400e-01f, -1.03947073e-01f, -5.64158261e-02f, 5.00235101e-03f,
  1.09582677e-01f, -1.50600582e-01f, -9.09940302e-02f, -1.82154715e-01f, -6.92853093e-01f, -2.51036167e-01f, -1.28905401e-01f, -2.43578553e-01f, -4.05392826e-01f, -5.03515899e-01f,
  -2.50896245e-01f, -3.34243149e-01f, -3.23281437e-01f, -1.20011903e-01f, 7.05001354e-02f, 1.48107991e-01f, 3.73014838e-01f, 5.97765706e-02f, 2.62576312e-01f, 1.55426323e-01f,
  1.31027922e-01f, -1.12187177e-01f, 1.33662641e-01f, -2.12194547e-01f, 2.52997041e-01f, -1.77605692e-02f, -2.60071546e-01f, 1.66785717e-01f, -1.17121823e-01f, -3.17343920e-02f,
  1.90930944e-02f, 8.07805825e-03f, -1.36722475e-01f, 2.97659308e-01f, -2.05737486e-01f, -2.38903895e-01f, -9.38351601e-02f, -2.04449117e-01f, -1.53304255e-02f, 3.07431649e-02f,
  -3.07889104e-01f, -2.31571764e-01f, -1.72869533e-01f, 2.28358731e-01f, 1.18553907e-01f, 4.69074398e-02f, 1.72781065e-01f, 2.28459120e-01f, 3.82079482e-01f, 1.18634403e-01f,
  -1.15432851e-02f, 1.15582176e-01f, 1.12241872e-01f, 7.65353143e-02f, 8.03043321e-02f, 4.27697003e-02f, 5.57251722e-02f, -1.62571758e-01f, 5.94966039e-02f, -4.69548330e-02f,
  2.92560399e-01f, 7.14303926e-02f, 3.45554911e-02f, -1.82699990e-02f, 3.41516174e-02f, 4.73319227e-03f, -8.82707443e-03f, 4.01568413e-02f, -3.71535197e-02f, -4.07495126e-02f,
  -1.41612381e-01f, 5.36045954e-02f, -1.73088133e-01f, -4.12323102e-02f, -4.25645337e-02f, -1.65950328e-01f, -2.42627766e-02f, -8.58089402e-02f, -4.14276831e-02f, 8.16398412e-02f,
  -1.28347486e-01f, 2.35796362e-01f, -8.06344002e-02f, -1.76926360e-01f, 1.26644641e-01f, 5.40776066e-02f, 5.01075238e-02f, -1.90281812e-02f, -1.75945684e-02f, -1.23678371e-01f,
  -8.95753428e-02f, -1.15297668e-01f, 1.08185723e-01f, 2.48138040e-01f, -8.64590928e-02f, -1.12197876e-01f, -9.39895064e-02f, -1.89181864e-01f, -1.20109655e-01f, -8.89112279e-02f,
  -3.00066620e-01f, -5.13356626e-01f, -5.75132012e-01f, -2.32050613e-01f, -1.33789226e-01f, -4.73985553e-01f, -5.22947572e-02f, -7.90855289e-02f, -1.63404614e-01f, -3.58572632e-01f,
  -9.49415982e-01f, 4.34394062e-01f, 2.27223992e-01f, -5.45749128e-01f, -4.53260243e-01f, -4.21560884e-01f, 2.44082451e-01f, -8.55448619e-02f, -3.76800418e-01f, 3.02605689e-01f,
  2.51742452e-01f, 1.17223665e-01f, 2.87695587e-01f, 8.33752528e-02f, 8.59728381e-02f, 4.39726382e-01f, -6.89458251e-02f, -2.23091379e-01f, -2.79855967e-01f, -3.37466896e-01f,
  1.70354322e-02f, -8.55507702e-02f, -4.48274314e-01f, -1.69883341e-01f, 8.48468915e-02f, -6.25426769e-02f, 2.34672740e-01f, -1.69058353e-01f, -7.17155561e-02f, 3.89401838e-02f,
  3.09506059e-01f, -3.60522717e-01f, -2.43285686e-01f, -3.39579195e-01f, 1.10198766e-01f, -1.15611903e-01f, -3.29154432e-02f, -2.12953717e-01f, -1.15897849e-01f, -1.59806311e-02f,
  -1.72994122e-01f, -5.79528622e-02f, -1.60832211e-01f, -1.69531386e-02f, -1.80086836e-01f, -1.24755166e-01f, 6.55177906e-02f, -1.53441682e-01f, 1.44041851e-01f, 8.85518268e-02f,
  1.16455518e-02f, -2.93749124e-01f, -1.67527735e-01f, -1.13598462e-02f, -1.61491483e-02f, -1.41625509e-01f, -9.64604542e-02f, -2.00866893e-01f, -2.62134105e-01f, 1.46307245e-01f,
  -1.12958811e-02f, 4.36214395e-02f, 7.50668496e-02f, 3.62745263e-02f, 7.35866949e-02f, 4.31641657e-03f, 1.04157619e-01f, 1.53124863e-02f, 2.88773365e-02f, 6.51248619e-02f,
  4.15391708e-03f, 1.70696497e-01f, 3.71533446e-02f, 6.19142316e-02f, 8.14375430e-02f, -6.73829913e-02f, -1.58606954e-02f, 2.56910503e-01f, -1.12705521e-01f, -1.23924814e-01f,
  -1.66257858e-01f, -8.34882706e-02f, 7.27838054e-02f, 1.04909979e-01f, -1.14961058e-01f, 1.09374352e-01f, -9.10339579e-02f, -2.52647270e-02f, 4.33062091e-02f, -8.58257711e-02f,
  4.47129786e-01f, -1.70311853e-01f, 2.20398024e-01f, 1.47018090e-01f, -1.90961622e-02f, -7.30447620e-02f, -3.56135294e-02f, -4.17562909e-02f, -6.30582049e-02f, 1.24923363e-02f,
  -1.01896271e-01f, 3.21418382e-02f, 1.37813091e-01f, 1.49764866e-01f, -1.89717069e-01f, -1.02641113e-01f, 9.06722918e-02f, -1.90852582e-02f, 1.85714057e-03f, -3.08494065e-02f,
  1.02173559e-01f, 2.95616686e-03f, 1.26550263e-02f, 9.64206755e-02f, 1.27662346e-01f, -4.45455089e-02f, 2.07491338e-01f, 3.94395180e-02f, 1.22467866e-02f, 5.21156728e-01f,
  6.79876029e-01f, 4.68242079e-01f, 2.91818589e-01f, 5.98836243e-01f, 2.32091963e-01f, 3.10411245e-01f, 5.32502532e-01f, 1.40793577e-01f, 5.56361265e-02f, 2.44254604e-01f,
  1.72989294e-01f, 5.51371649e-02f, 5.54313660e-02f, 3.37409750e-02f, 1.78540945e-01f, 2.16586828e-01f, 8.15177485e-02f, 5.44122458e-02f, 5.33269625e-03f, 2.69862741e-01f,
  1.43440604e-01f, 2.08714843e-01f, 1.68779671e-01f, 1.54353723e-01f, 2.18963608e-01f, -1.51563133e-03f, 1.72688365e-01f, 2.29249135e-01f, 2.71848530e-01f, 2.89072633e-01f,
  2.86411315e-01f, 5.61056912e-01f, -2.68574208e-01f, -1.86916322e-01f, -2.46089831e-01f, -1.90650508e-01f, -1.26615986e-01f, -3.37380707e-01f, -2.17599973e-01f, -2.36672759e-02f,
  -8.22142586e-02f, -8.87813419e-02f, -1.19765356e-01f, -6.11051470e-02f, -1.60850570e-01f, -1.50825053e-01f, -1.67972505e-01f, -1.13170324e-02f, -1.70468524e-01f, -1.27252683e-01f,
  -8.13707262e-02f, -1.82476670e-01f, -1.06622325e-02f, -1.21857233e-01f, 2.16941331e-02f, -1.23834342e-01f, -5.38294278e-02f, -5.77352531e-02f, -1.98234692e-01f, -7.50920270e-03f,
  -1.52330726e-01f, 6.13518469e-02f, 2.83138398e-02f, 6.83770403e-02f, 6.28398359e-02f, -6.17399663e-02f, 2.37422194e-02f, 5.67246750e-02f, -4.74389829e-02f, -8.29179138e-02f,
  -4.95946035e-02f, 1.44094646e-01f, 1.70747135e-02f, -1.90461744e-02f, 7.42639154e-02f, -1.30108610e-01f, -1.16027467e-01f, -1.73849896e-01f, 7.04710484e-02f, 2.04077605e-02f,
  8.86063352e-02f, -1.85656156e-02f, 1.43343890e-02f, 4.51811142e-02f, -8.54149908e-02f, 9.17184800e-02f, -6.34817854e-02f, -3.22034135e-02f, 3.75623740e-02f, -2.29437314e-02f,
  -3.38936985e-01f, -1.82561129e-01f, 9.37297568e-02f, -4.49673086e-02f, -2.13406216e-02f, 3.23673822e-02f, 1.12406332e-02f, 4.96550426e-02f, 1.89258963e-01f, 2.12847874e-01f,
  9.78824198e-02f, -2.44838325e-03f, -3.29700019e-03f, -1.09201223e-01f, -2.14640841e-01f, -1.66531920e-01f, 4.31743301e-02f, -6.93453103e-02f, -1.11356139e-01f, -8.31857324e-02f,
  -8.18386674e-02f, -1.26671746e-01f, -2.76744425e-01f, -2.11633235e-01f, -2.31513917e-01f, -1.13242507e-01f, -2.43916169e-01f, -1.98476240e-01f, -2.71562815e-01f, -3.61289591e-01f,
  -1.73404496e-02f, -1.02943987e-01f, 2.98371881e-01f, 1.01287067e-01f, 5.07433057e-01f, 4.25751507e-01f, 5.59589565e-01f, 1.56269848e-01f, -8.52201506e-02f, 1.44540608e-01f,
  -2.61037976e-01f, -5.00503421e-01f, -4.08510417e-01f, -4.05726314e-01f, -2.58523434e-01f, 3.87571782e-01f, 2.38710478e-01f, 4.13124636e-03f, 3.16164106e-01f, 2.61558861e-01f,
  3.30196321e-02f, 1.30707890e-01f, 2.76840292e-02f, -1.03807114e-01f, -1.17711462e-01f, -4.14385088e-02f, 1.50363091e-02f, -4.46690470e-02f, -2.22079426e-01f, -2.23328575e-01f,
  -2.35301703e-01f, -2.61638641e-01f, -4.04951721e-03f, -9.16016940e-03f, -1.38215542e-01f, -1.32274568e-01f, -1.17778346e-01f, -2.31453896e-01f, -1.51969437e-02f, 1.61953226e-01f,
  -8.08296539e-03f, -1.19989648e-01f, -7.67637938e-02f, -9.49889794e-02f, 3.63808796e-02f, 8.40794444e-02f, -2.06589280e-03f, -1.49606705e-01f, -1.63394362e-01f, -2.61848480e-01f,
  -2.30205998e-01f, 4.29737270e-02f, 2.73279264e-03f, -6.08359650e-02f, -1.45764217e-01f, -6.23744689e-02f, -1.07065275e-01f, -1.27486780e-01f, -1.50420427e-01f, 9.14040506e-02f,
  8.92328694e-02f, -1.74030010e-02f, -2.11839423e-01f, -6.34186156e-03f, 2.96482816e-02f, 2.27237046e-01f, 4.95242439e-02f, -4.38455530e-02f, -7.07164500e-03f, 1.22566754e-02f,
  -4.62188721e-02f, -7.16542676e-02f, -8.52393433e-02f, 6.28303438e-02f, -1.58913895e-01f, -1.62955731e-01f, -1.79431647e-01f, -1.54123455e-01f, -1.92208484e-01f, -1.28630444e-01f,
  -1.09180905e-01f, -8.06041136e-02f, 7.40195215e-02f, -1.34718210e-01f, -4.16798480e-02f, -1.11877799e-01f, -4.17704321e-02f, -1.13932990e-01f, -4.16980311e-02f, -3.21093239e-02f,
  -1.62018821e-01f, -3.00469011e-01f, -3.17662470e-02f, -1.06291629e-01f, -1.23656161e-01f, -1.98537365e-01f, -1.95398450e-01f, -1.67866826e-01f, 2.35793181e-02f, 7.39167258e-02f,
  5.38395941e-02f, -8.71974006e-02f, -1.58901699e-02f, -3.99451256e-02f, 1.96827605e-01f, 1.03815183e-01f, -8.55219662e-02f, 5.91780320e-02f, 3.15176062e-02f, 5.60479879e-04f,
  -2.75931880e-02f, 1.83870122e-01f, 1.75486654e-01f, -1.47686088e-02f, -5.26164062e-02f, 2.10332811e-01f, 2.41221443e-01f, 8.97814408e-02f, 1.78631440e-01f, 5.20328522e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.88791257e-01f, 1.70580894e-02f, 3.77677411e-01f, 4.46637541e-01f, 8.26088905e-01f, 4.10916954e-01f, 4.64667618e-01f, 5.04366696e-01f, 4.92946267e-01f, 1.10868216e+00f,
  4.26563412e-01f, 3.64762723e-01f, 6.40223265e-01f, 6.88961923e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.24019215e-02f, -1.75847977e-01f, -2.03158081e-01f, 3.95344585e-01f, 2.10231021e-01f, -6.97263796e-03f, -3.27303588e-01f, -2.82021672e-01f, 1.80957094e-01f, 3.42365593e-01f,
  -1.64454699e-01f, -1.25831902e-01f, -1.70097172e-01f, 1.05445698e-01f, 1.38356537e-01f, 2.11022958e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.38566422e-01f, 3.50815314e-03f, 7.13219881e-01f, -2.89283276e-01f, 4.09931540e-01f, -4.93656099e-01f, -6.57251060e-01f, 1.08380449e+00f, -3.10627550e-01f, -3.48862350e-01f,
  -1.89252436e-01f, 2.61251301e-01f, 8.96826565e-01f, -3.81964058e-01f, 3.58585082e-02f, -3.45597178e-01f, 1.88800156e-01f, -4.98509966e-02f, 6.23941600e-01f, -6.12219982e-03f,
  -1.14769600e-01f, 6.37724221e-01f, 1.13445684e-01f, 5.05220294e-01f, -5.42004824e-01f, 2.56874830e-01f, 3.76597755e-02f, -5.97393155e-01f, 3.18712108e-02f, 6.69744909e-01f,
  -6.45760670e-02f, 2.44059324e-01f, -1.56366022e-03f, -2.68923968e-01f, -2.63047725e-01f, 3.09442490e-01f, 7.01491237e-01f, 4.23730791e-01f, 1.13064162e-01f, 4.20202427e-02f,
  1.99097991e-01f, 2.41233647e-01f, 4.02120739e-01f, 3.87155235e-01f, -4.11249399e-01f, -5.04716858e-02f, 4.51295912e-01f, 1.79819062e-01f, -5.78806520e-01f, -4.09373552e-01f,
  -3.04568529e-01f, 7.76989684e-02f, 6.90031111e-01f, -2.06901774e-01f, 3.90784219e-02f, 6.03688121e-01f, -8.44807386e-01f, 9.25871283e-02f, -1.13715678e-01f, 4.74544495e-01f,
  -2.49279708e-01f, -5.40615916e-01f, 4.56913501e-01f, -5.57275414e-01f, 8.14440250e-01f, 5.19109845e-01f, 4.56360802e-02f, -6.60208687e-02f, 5.22172511e-01f, -8.56970102e-02f,
  3.92487437e-01f, -5.38796008e-01f, 8.91547322e-01f, -1.64479673e-01f, 5.94176829e-01f, 5.39829314e-01f, -7.58796856e-02f, -2.68658310e-01f, 5.20112693e-01f, 2.33571306e-01f,
  7.84556210e-01f, 6.21730924e-01f, 5.65262794e-01f, -1.11083221e+00f, -2.81462014e-01f, 1.95944995e-01f, 5.28609216e-01f, 7.47098848e-02f, -6.05980933e-01f, -4.13053483e-02f,
  1.28816634e-01f, 4.83376056e-01f, 6.69229686e-01f, 8.78229856e-01f, 5.71240438e-03f, 3.05652112e-01f, 6.03088498e-01f, -1.66142151e-01f, 7.44116679e-03f, -2.31338024e-01f,
  4.73948419e-01f, -2.32086033e-01f, 5.21502376e-01f, -1.38148963e-01f, -5.54385245e-01f, 2.42362157e-01f, -1.63424671e-01f, 7.98787117e-01f, -8.56027529e-02f, 8.74683797e-01f,
  1.39471501e-01f, 2.11693868e-01f, 5.02975762e-01f, 3.34973991e-01f, 5.71337879e-01f, -4.29032296e-01f, 3.25038224e-01f, -5.52310586e-01f, 7.89121389e-01f, 7.85216033e-01f,
  7.56435171e-02f, 8.72011781e-02f, -4.63807359e-02f, 7.75707543e-01f, 8.51031125e-01f, -7.89378524e-01f, -8.83493200e-02f, -1.72547027e-01f, 3.46106142e-01f, -3.11732680e-01f,
  4.53059465e-01f, -4.67989773e-01f, -5.80533385e-01f, 6.35465324e-01f, 3.25348705e-01f, 3.04730117e-01f, 5.33295095e-01f, 3.52114290e-01f, 2.27713257e-01f, -7.41641283e-01f,
  2.20527455e-01f, -7.72960484e-02f, 5.93828499e-01f, 6.12558603e-01f, 6.64441109e-01f, -3.17459136e-01f, 5.39486885e-01f, -6.42519295e-01f, 3.02953660e-01f, 2.49090463e-01f,
  -3.07157695e-01f, 1.50415190e-02f, 3.92367601e-01f, 4.44966078e-01f, -1.21312059e-01f, -3.04887071e-03f, -1.76369712e-01f, -2.97142774e-01f, 2.93473750e-01f, 5.75500965e-01f,
  7.46092945e-02f, 5.76888770e-02f, -1.54821023e-01f, 3.12851220e-01f, -2.77425319e-01f, -1.35377929e-01f, 7.65825570e-01f, -6.37375191e-02f, 1.48945972e-02f, 1.20333001e-01f,
  2.64900982e-01f, 5.92885911e-01f, 1.22410044e-01f, -3.23445797e-01f, 4.75635938e-03f, -1.94415316e-01f, 6.24007583e-02f, -4.84498888e-01f, -9.39512104e-02f, -2.54806817e-01f,
  5.86975813e-01f, 3.68881434e-01f, -1.12359710e-01f, 2.11105615e-01f, -4.94877458e-01f, 8.41416419e-01f, 1.33850291e-01f, 1.80900559e-01f, -4.43211794e-01f, -6.40755832e-01f,
  1.47395328e-01f, 4.58294749e-01f, 2.13817209e-01f, -4.30198759e-02f, -1.66465998e-01f, -8.63935705e-03f, 6.36968970e-01f, 5.91825992e-02f, -2.76251584e-01f, -4.42797899e-01f,
  -3.09017062e-01f, 8.34420979e-01f, 3.35213721e-01f, 3.10820580e-01f, -9.54896137e-02f, 6.01380587e-01f, 1.13921598e-01f, 3.40919316e-01f, 4.55018610e-01f, 2.99512178e-01f,
  7.76430639e-03f, -1.45745941e-03f, -1.08213022e-01f, -1.60092235e-01f, 5.77003479e-01f, 1.92130491e-01f, -1.01438141e+00f, 5.60448706e-01f, -5.17858118e-02f, -5.18402345e-02f,
  2.36306205e-01f, 5.90015709e-01f, 1.31146252e-01f, 6.58472359e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.04972893e-01f, -2.39688396e-01f, 2.74689887e-02f, -2.32993692e-01f, 5.31092346e-01f, 8.81155133e-01f, 4.83439952e-01f, 9.08232152e-01f, 5.15644252e-01f, 5.43327451e-01f,
  6.69735312e-01f, 3.42914283e-01f, 2.11301282e-01f, 3.64748091e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.33290317e-03f, -6.95827961e-01f, 3.02863494e-03f, -4.70429659e-01f, -3.64517987e-01f, 1.92847550e-01f, -3.46921049e-02f, -1.85277626e-01f, -1.08417809e-01f, 2.74580270e-01f,
  1.14423297e-01f, 1.31328732e-01f, -3.18154752e-01f, 5.29023409e-01f, -1.99082047e-01f, 4.34889138e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  8.65753412e-01f, -2.26202875e-01f, -4.79648381e-01f, -9.68654573e-01f, -3.17703396e-01f, -8.04378629e-01f, 1.97732911e-01f, 4.72428381e-01f, 5.00912070e-01f, 2.68531382e-01f,
  -4.09309613e-03f, 1.15748383e-01f, 2.46575624e-01f, -3.32147807e-01f, 4.48952556e-01f, 3.52611929e-01f, 6.06166840e-01f, -1.53399855e-01f, -1.00973688e-01f, 3.89016569e-01f,
  2.57850647e-01f, -4.86109078e-01f, 5.27288973e-01f, 3.00119936e-01f, -1.96270421e-01f, 9.01964679e-02f, 3.09802860e-01f, 2.61192471e-01f, 1.98268443e-01f, -5.85675418e-01f,
  -1.71871752e-01f, -8.15047801e-01f, 2.82980531e-01f, 7.28125036e-01f, -1.56572029e-01f, -5.33731699e-01f, 2.71439046e-01f, 6.19913578e-01f, 5.54186165e-01f, -5.96063912e-01f,
  3.89034033e-01f, 2.07259208e-01f, 4.68056053e-01f, 6.66138291e-01f, -9.26320106e-02f, 7.35973299e-01f, 1.38090402e-01f, -7.12316275e-01f, -2.90720761e-02f, 5.56395888e-01f,
  -2.17785269e-01f, -2.23891944e-01f, 4.86712724e-01f, 4.39098507e-01f, 5.39383292e-02f, -2.06781447e-01f, 7.25326002e-01f, 1.02345698e-01f, -3.29122096e-01f, -3.75977159e-01f,
  3.78707200e-01f, 4.90763783e-01f, 6.36863112e-01f, 1.00203490e+00f, -5.89995682e-01f, -2.16461256e-01f, 4.93258655e-01f, 5.04654408e-01f, -2.87013113e-01f, -1.78790204e-02f,
  -2.75121570e-01f, 8.22532415e-01f, -2.40871087e-02f, 6.69599354e-01f, 3.68363798e-01f, 6.00416780e-01f, -1.65338308e-01f, 7.33108595e-02f, -5.08470774e-01f, 5.00776052e-01f,
  -4.51981604e-01f, 9.74195182e-01f, -1.98614135e-01f, 5.54518938e-01f, 1.70617148e-01f, 4.17469591e-01f, -1.51914760e-01f, 3.66987824e-01f, 5.31175911e-01f, 4.23520617e-02f,
  3.37360740e-01f, -5.37866592e-01f, -1.51512176e-01f, 1.27607644e-01f, 1.09591782e-01f, 2.09306866e-01f, -7.01452792e-01f, 2.05896139e-01f, -1.00535715e+00f, -3.47508758e-01f,
  -7.65200034e-02f, 2.77799010e-01f, 3.55209678e-01f, 2.82849491e-01f, 2.99445182e-01f, 4.31940019e-01f, 5.50768934e-02f, -4.20186907e-01f, 6.52220130e-01f, -1.24528803e-01f,
  -7.86680341e-01f, 2.49933496e-01f, -8.45812023e-01f, 3.30679029e-01f, 2.58865446e-01f, 4.79295015e-01f, 2.37053454e-01f, 8.66691768e-02f, -2.06157386e-01f, -1.77665472e-01f,
  2.12386176e-01f, 2.70811226e-02f, 3.33812296e-01f, 4.61043537e-01f, -1.44527018e-01f, 9.22147632e-01f, 6.37753308e-01f, 9.18283582e-01f, 5.05080342e-01f, 3.83282423e-01f,
  3.90379786e-01f, 2.12578684e-01f, 4.61516917e-01f, 3.86669725e-01f, 4.64603573e-01f, -7.11602688e-01f, -2.64060527e-01f, -2.96373636e-01f, 4.92484599e-01f, 1.13306761e-01f,
  9.11012739e-02f, 6.05764329e-01f, 3.03385884e-01f, -4.29320961e-01f, -2.45369673e-02f, -4.10562545e-01f, 5.49819827e-01f, -7.04925954e-01f, 2.21010014e-01f, 4.83265877e-01f,
  9.00646374e-02f, 2.26170644e-01f, 4.04334486e-01f, 3.42878580e-01f, -7.15512097e-01f, 2.81623125e-01f, 2.37590611e-01f, -2.07589492e-01f, 7.00656831e-01f, -8.73449817e-02f,
  5.00069916e-01f, 1.36021778e-01f, -5.26558042e-01f, -5.30865081e-02f, 6.74387962e-02f, -4.72857326e-01f, 3.75660434e-02f, 2.26585463e-01f, -2.88379695e-02f, -1.01814911e-01f,
  3.23233515e-01f, 1.02549541e+00f, -4.40001756e-01f, 5.13477683e-01f, 8.51753801e-02f, 2.86599934e-01f, 4.94564652e-01f, -2.62425154e-01f, -5.47087729e-01f, -6.86015487e-01f,
  8.81571919e-02f, -5.73971748e-01f, 9.22033370e-01f, 1.42327603e-02f, -2.69855797e-01f, -3.39348704e-01f, 4.03782517e-01f, 4.37983394e-01f, 4.01268452e-01f, -1.97575763e-01f,
  -2.47010663e-01f, -6.18745565e-01f, -4.54584062e-02f, 1.10160168e-02f, -6.61969066e-01f, 5.78002810e-01f, 1.01967506e-01f, -5.09056389e-01f, -1.55897334e-01f, 1.25776327e+00f,
  4.64929581e-01f, -3.91683578e-01f, 2.64718473e-01f, 8.33474517e-01f, -3.77130836e-01f, 2.37346530e-01f, 1.33228436e-01f, 6.14393711e-01f, -4.30705160e-01f, -5.26722431e-01f,
  3.34840596e-01f, -2.35292669e-02f, 1.21145472e-01f, 1.49508983e-01f, 3.58903170e-01f, 6.83217227e-01f, 2.29393914e-01f, 8.12761188e-01f, -2.04037070e-01f, -3.40108186e-01f,
  7.68804789e-01f, 3.32997255e-02f, -2.66174495e-01f, -5.24048284e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.49079108e-01f, 2.09495842e-01f, -1.76961973e-01f, 3.57988715e-01f, 1.85402855e-01f, -1.14661925e-01f, 1.48889974e-01f, -1.85989648e-01f, 5.40704668e-01f, 6.98486328e-01f,
  2.34113514e-01f, 3.16591591e-01f, 1.38845116e-01f, 7.36903846e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.15114728e-01f, -5.78074977e-02f, -8.67590249e-01f, -3.30530792e-01f, 2.13698819e-01f, 7.77111128e-02f, 1.48979336e-01f, -3.46635073e-01f, 4.40726757e-01f, 1.64726391e-01f,
  -4.84375685e-01f, 3.58082116e-01f, -7.06141353e-01f, -1.54396612e-02f, -7.36869693e-01f, 1.79167897e-01f, -4.09508705e-01f, -3.07025403e-01f, -1.20286822e+00f, -2.50710487e-01f,
  5.80390453e-01f, 3.57395977e-01f, -5.40553510e-01f, 2.72997886e-01f, -9.24834013e-02f, 2.82359600e-01f, 3.96845162e-01f, 1.58507541e-01f, -4.36467677e-01f, -2.71393941e-03f,
  -8.49574447e-01f, -2.90806830e-01f, 8.50749388e-03f, 2.29823157e-01f, 5.39195955e-01f, -2.64028460e-01f, -6.55981541e-01f, 3.93187582e-01f, -2.06842981e-02f, 3.49453628e-01f,
  5.58541834e-01f, -4.11757171e-01f, -3.89422417e-01f, -3.59544307e-01f, -7.41041720e-01f, -7.32840598e-01f, -4.13746119e-01f, 2.41559625e-01f, 1.55064419e-01f, 3.62233937e-01f,
  -8.01197410e-01f, -5.44385731e-01f, -5.90020001e-01f, -9.52039719e-01f, 4.24413174e-01f, 3.67495716e-01f, -7.44811654e-01f, 3.72913063e-01f, -5.98282397e-01f, -2.09629685e-01f,
  9.31108519e-02f, -1.88066319e-01f, 2.62731344e-01f, -2.71994509e-02f, 1.38766766e-01f, 7.32582927e-01f, 3.70192975e-01f, 2.82040507e-01f, -8.35376918e-01f, -2.53665507e-01f,
  2.79922843e-01f, -5.64626157e-01f, -9.11331356e-01f, -1.08595356e-01f, 4.59856868e-01f, 2.22262681e-01f, -1.85506180e-01f, -7.61849821e-01f, -2.81780988e-01f, 3.79011691e-01f,
  1.02237427e+00f, 2.99859350e-03f, 6.81911469e-01f, -3.24173778e-01f, 1.88535020e-01f, 4.05760407e-01f, -4.93407905e-01f, -3.46115649e-01f, -2.82757640e-01f, 2.41327226e-01f,
  -1.74206719e-01f, 1.96485907e-01f, 7.57017434e-02f, 2.28094347e-02f, -1.59215927e-01f, -1.38915032e-01f, 6.88824281e-02f, -7.29499698e-01f, -2.36940339e-01f, 3.03300381e-01f,
  3.66170913e-01f, -4.20705765e-01f, -1.11099315e+00f, -5.56102574e-01f, 2.11249456e-01f, -9.80070353e-01f, 4.42550868e-01f, -3.55085373e-01f, -1.57209724e-01f, 5.11668444e-01f,
  -1.10919142e+00f, 4.53449339e-02f, -2.94607460e-01f, 2.17160478e-01f, -4.65492487e-01f, 2.60576308e-01f, -4.43158209e-01f, -1.61583394e-01f, 1.40090613e-02f, 3.80642861e-01f,
  2.07089201e-01f, -1.18403686e-02f, -1.68880518e-03f, -8.95119131e-01f, -8.12469721e-02f, -1.68887705e-01f, 4.54273492e-01f, 1.23101976e-02f, 2.96963125e-01f, 5.89311182e-01f,
  -6.97278678e-02f, -2.54759818e-01f, 1.95216477e-01f, -8.84179249e-02f, -1.17960848e-01f, -1.44591585e-01f, -6.90675154e-02f, 3.37434232e-01f, -1.37908887e-02f, -5.13740420e-01f,
  4.62172627e-01f, -3.74589294e-01f, 5.29179931e-01f, -7.36011028e-01f, 2.11441994e-01f, 8.98112878e-02f, 7.47594118e-01f, 2.85213292e-01f, 4.85042036e-02f, -3.34893793e-01f,
  -4.48769748e-01f, -1.99357569e-01f, 3.98396194e-01f, -4.44936603e-01f, -4.73897994e-01f, -2.58182019e-01f, -2.66799122e-01f, 3.33841771e-01f, -2.79404730e-01f, 3.42972368e-01f,
  -1.21586740e-01f, -7.03597903e-01f, 6.45064056e-01f, -6.36092544e-01f, -6.55320108e-01f, 2.76637197e-01f, -1.95386052e-01f, 4.89768744e-01f, -8.36631000e-01f, -5.05761504e-02f,
  -1.61653471e+00f, 1.20978132e-02f, -2.38992676e-01f, -1.96880296e-01f, 7.72431791e-01f, -8.34929645e-01f, 4.17390287e-01f, -4.19023603e-01f, -6.94668770e-01f, 9.07499194e-02f,
  5.53300381e-01f, -1.10297143e+00f, -2.44625553e-01f, -1.19381920e-01f, -4.93718117e-01f, -3.54513049e-01f, 3.88314009e-01f, -5.74388027e-01f, 4.46732402e-01f, 3.02376330e-01f,
  4.49689180e-01f, -7.38611400e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.43261999e-01f, -1.36100113e-01f, 3.69961530e-01f, 5.42175137e-02f, 2.73168951e-01f, 4.93612826e-01f, -9.68694761e-02f, -3.79481226e-01f, -3.40013564e-01f, -8.36897939e-02f,
  -4.70509715e-02f, 1.85177743e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    