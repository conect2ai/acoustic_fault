/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.37970459e-02f, -1.98831797e-01f, 3.46246600e-01f, 2.44608194e-01f, -1.92188665e-01f, 9.38838422e-02f, 8.23141262e-02f, 5.71268983e-03f, 3.75258982e-01f, -4.38767165e-01f,
  3.21804062e-02f, -7.33394623e-02f, -4.45456803e-03f, -2.14429736e-01f, 5.70572555e-01f, 1.00883961e-01f, -6.81747571e-02f, -2.74298847e-01f, 1.68363079e-01f, -9.55408365e-02f,
  2.53206402e-01f, -1.85213536e-01f, 2.74688542e-01f, -5.26021831e-02f, -1.57626018e-01f, -1.90186538e-02f, -2.05934927e-01f, -8.58794302e-02f, -2.27270499e-01f, -5.74528277e-02f,
  1.12584792e-01f, -4.85310294e-02f, 3.09375618e-02f, 3.44127677e-02f, -3.72271352e-02f, -1.04991749e-01f, -1.96665779e-01f, -9.13131237e-02f, 1.15968622e-01f, -5.52678704e-02f,
  -1.98474154e-01f, -6.09241761e-02f, 6.70130923e-02f, -4.89756046e-03f, -1.30788237e-01f, 7.75374845e-02f, 9.51782987e-02f, -6.75785989e-02f, 7.93390200e-02f, -4.02058773e-02f,
  4.83437963e-02f, -1.30089432e-01f, -2.42658798e-02f, -1.80328473e-01f, 1.69434711e-01f, 3.95582383e-03f, -3.30787040e-02f, -1.45267934e-01f, -1.23397894e-01f, -3.69714200e-03f,
  -1.07033797e-01f, -1.55086428e-01f, -2.17690505e-02f, -4.72178385e-02f, 8.86167511e-02f, 1.80625752e-01f, -8.67594257e-02f, -1.22353435e-01f, 1.22550972e-01f, 1.87392160e-02f,
  3.15094888e-02f, 1.07443377e-01f, -1.44541293e-01f, 6.96729794e-02f, -2.94414684e-02f, -1.89141873e-02f, -6.25358941e-03f, -1.16031587e-01f, 3.26878950e-02f, 1.98794186e-01f,
  -5.67323156e-02f, 3.78066525e-02f, 7.31213838e-02f, -2.29725122e-01f, -5.99142537e-02f, 1.26862481e-01f, -8.88157040e-02f, -1.14473617e-02f, 2.13532392e-02f, 8.88196460e-04f,
  -1.13233604e-01f, -1.11732095e-01f, 6.98620528e-02f, -1.69402733e-02f, 3.06847487e-02f, -5.33418655e-02f, 9.56094116e-02f, 7.66313002e-02f, 6.57401234e-02f, 1.40140042e-01f,
  -9.70168784e-02f, 6.66418206e-03f, -1.85196191e-01f, -1.09544685e-02f, 1.26847997e-01f, -3.23212147e-02f, -6.58197701e-02f, -6.46634400e-02f, 5.20825274e-02f, -1.44953802e-02f,
  -5.03007881e-02f, -7.40943030e-02f, 6.05379902e-02f, 1.05658725e-01f, -5.47634214e-02f, -7.58428127e-02f, -1.24102822e-02f, 4.29407693e-02f, -1.30188525e-01f, -1.19696865e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.28673762e-01f, 9.79693174e-01f, -4.35438380e-02f, 8.96797851e-02f, -3.51253569e-01f, -1.05946290e+00f, -5.39235353e-01f, -1.59490749e-01f, 5.39819360e-01f, 4.36468661e-01f,
  -4.37389374e-01f, 9.23053265e-01f, 2.84333587e-01f, -1.23651743e-01f, -7.88433909e-01f, 3.15951719e-03f, -6.29418373e-01f, 1.85334031e-02f, 3.08961064e-01f, -2.11971670e-01f,
  -2.19051421e-01f, -5.20884335e-01f, -3.38453680e-01f, 4.93502952e-02f, -3.19400340e-01f, 2.03166395e-01f, -4.65626180e-01f, 1.79170325e-01f, -3.46510231e-01f, -1.66581079e-01f,
  -6.54583275e-02f, 5.27387500e-01f, 1.03952922e-01f, 5.03302785e-03f, -4.31591928e-01f, -1.58207610e-01f, -1.53921932e-01f, 9.55350474e-02f, 9.90474224e-02f, 1.66024715e-01f,
  1.66035965e-01f, -3.24871503e-02f, 7.95277506e-02f, 9.26103443e-02f, 2.22480088e-01f, 1.52669907e-01f, 8.26649442e-02f, -1.87208548e-01f, 2.60572910e-01f, 1.21466763e-01f,
  -7.03747524e-03f, 3.18576284e-02f, -2.95439869e-01f, 3.37068327e-02f, -1.27095044e-01f, -5.65710589e-02f, -8.74262303e-02f, -4.49637510e-02f, -1.02107860e-01f, -1.64302997e-02f,
  -9.79789346e-03f, -1.02113346e-02f, -5.79750016e-02f, 9.26161557e-02f, 7.93909729e-02f, -1.01687998e-01f, 8.56127031e-03f, 7.89181504e-04f, 3.67637277e-02f, -6.46980945e-03f,
  -1.58099636e-01f, 2.03955457e-01f, 3.08152698e-02f, -8.19432586e-02f, -8.42184722e-02f, 1.01178952e-01f, -8.48456174e-02f, 1.22158229e-01f, -1.73619270e-01f, -1.47746935e-01f,
  1.82823807e-01f, -2.13894233e-01f, 1.05835892e-01f, -1.63539276e-01f, -2.19766989e-01f, 4.99369465e-02f, -4.03051712e-02f, -9.93536413e-03f, 2.04089787e-02f, -2.52837181e-01f,
  -4.99354988e-01f, -1.66194122e-02f, 8.63527209e-02f, 2.23239288e-01f, 9.24385861e-02f, -8.20642784e-02f, 7.07838312e-02f, 8.44714604e-03f, -4.08896618e-02f, -1.29426345e-01f,
  -2.19750747e-01f, 2.89415736e-02f, -3.96876872e-01f, -4.41207364e-02f, 6.60865009e-02f, -2.42242858e-01f, -1.10354267e-01f, 6.02347963e-02f, -2.65040129e-01f, 2.40725409e-02f,
  3.02540660e-02f, 1.46812703e-02f, 5.99983335e-02f, -1.24765255e-01f, -1.08928010e-02f, -2.78217327e-02f, 8.45657736e-02f, 1.29231080e-01f, -9.93686765e-02f, 3.41792069e-02f,
  -5.91130972e-01f, 8.25040698e-01f, 8.68682861e-01f, -5.91287343e-03f, -5.59808791e-01f, -1.38653412e-01f, -1.90550312e-01f, 3.58146310e-01f, -4.58005279e-01f, 1.94148198e-01f,
  6.31825849e-02f, -1.95470273e-01f, 4.28691506e-01f, 5.93317091e-01f, -1.10182136e-01f, 4.96455789e-01f, 3.03435862e-01f, 8.93708169e-02f, 1.08928084e-01f, 5.64365685e-01f,
  2.45844781e-01f, -5.36287315e-02f, 8.13251138e-01f, 1.07059285e-01f, 3.76587242e-01f, 2.22440779e-01f, 2.16121465e-01f, 1.33648902e-01f, 2.12256983e-01f, -3.22688013e-01f,
  2.88986355e-01f, 1.89910561e-01f, 2.93479979e-01f, 9.69175342e-03f, 2.42014185e-01f, 3.50952297e-02f, -2.69592949e-03f, -1.14949331e-01f, -3.13003451e-01f, 8.86345282e-02f,
  -1.25595927e-01f, -1.37120411e-01f, -1.17475085e-01f, -2.02825725e-01f, -3.56937975e-01f, -2.51525432e-01f, 1.52422301e-02f, -1.04361661e-01f, 1.04577884e-01f, 1.23955704e-01f,
  2.30036601e-01f, 1.77595779e-01f, -1.12706264e-02f, 4.07027230e-02f, -4.67918888e-02f, -1.39995515e-01f, 6.27202988e-02f, 1.04942799e-01f, 8.92532244e-02f, -1.34924576e-01f,
  -6.88260049e-02f, -1.23039849e-01f, 3.29745747e-02f, -1.57370251e-02f, -5.55921309e-02f, -1.94987580e-02f, -9.73363966e-02f, 1.46646395e-01f, -1.33482352e-01f, -7.24350214e-02f,
  -2.14130193e-01f, -1.16929552e-02f, -2.84971413e-03f, -1.08406164e-01f, -4.23329510e-02f, 1.50949042e-02f, -7.07111135e-02f, 5.48456386e-02f, -2.30963051e-01f, 2.11580563e-02f,
  -5.95801733e-02f, -1.51367113e-01f, -1.42338937e-02f, 5.20821549e-02f, 6.42105844e-03f, 4.56141401e-03f, -2.34405041e-01f, 1.78104341e-01f, 2.28187293e-01f, -1.08273990e-01f,
  1.63545713e-01f, 3.29485208e-01f, 1.21691100e-01f, -1.28978997e-01f, 4.87600118e-02f, 1.60781831e-01f, 1.85121626e-01f, 2.74681538e-01f, -3.77902240e-02f, 1.12705059e-01f,
  -8.48304629e-02f, 4.77109067e-02f, -2.67034695e-02f, -1.41642258e-01f, -9.16294307e-02f, 1.45194381e-01f, 9.50768366e-02f, -1.92638531e-01f, 2.18807552e-02f, 1.33571446e-01f,
  1.71200290e-01f, -1.35192201e-01f, 5.18407039e-02f, -9.46987569e-02f, -1.88211486e-01f, 1.18687987e-01f, -7.13039264e-02f, -5.50008006e-02f, -7.16047222e-03f, -1.26467302e-01f,
  -1.37166739e+00f, 6.53984547e-01f, -3.27042848e-01f, 3.13610941e-01f, -4.29556549e-01f, 1.03365600e+00f, 8.12550664e-01f, -9.17553902e-02f, 1.71381786e-01f, 6.25762999e-01f,
  1.70768797e-01f, -2.24700630e-01f, -6.84321076e-02f, 7.00313389e-01f, 1.40560701e-01f, 7.43393898e-01f, 5.00633419e-01f, 3.77906233e-01f, -8.30243602e-02f, -4.72269922e-01f,
  -2.02636361e-01f, 5.99714160e-01f, 1.62590876e-01f, 7.59313554e-02f, -2.14884371e-01f, -2.92378128e-01f, -1.38243482e-01f, -4.21983004e-02f, 4.56770837e-01f, 3.12750250e-01f,
  -2.77824789e-01f, -7.62749910e-01f, -3.23183149e-01f, -2.38549367e-01f, -8.62620026e-02f, -8.32860693e-02f, -1.83075313e-02f, -7.18242452e-02f, 7.32120052e-02f, -7.85999969e-02f,
  -1.36953831e-01f, -1.18886359e-01f, 6.42492101e-02f, -2.33588158e-03f, 1.36587948e-01f, -8.38032737e-02f, -5.86548857e-02f, 5.83557934e-02f, -4.67427447e-02f, -1.87067017e-01f,
  3.13475244e-02f, -1.59923011e-03f, -1.45542398e-02f, 1.76718161e-01f, -4.30248007e-02f, 1.23519108e-01f, 1.50201842e-01f, -8.98202136e-02f, 2.02959597e-01f, 1.77867711e-01f,
  1.37435328e-02f, 4.30899635e-02f, -6.38992712e-02f, 5.49279153e-02f, 9.45774913e-02f, 8.22550654e-02f, 5.01864590e-03f, -3.81303877e-02f, 2.02030197e-01f, 5.26969247e-02f,
  -5.44399880e-02f, -7.90288895e-02f, -1.25598341e-01f, 1.24624945e-01f, -1.31309047e-01f, -7.97966942e-02f, -1.75567523e-01f, -9.68881920e-02f, 1.51575729e-01f, -8.54624361e-02f,
  -6.22759340e-03f, 4.15320732e-02f, 1.79633886e-01f, -2.31775418e-01f, 3.89133580e-02f, 2.71170568e-02f, -8.70212391e-02f, 1.82825029e-02f, -2.93033458e-02f, -1.15615346e-01f,
  1.17716640e-01f, -1.95764616e-01f, -4.25773673e-03f, 7.00874478e-02f, 8.59169215e-02f, 5.46062030e-02f, 1.86490566e-02f, -1.93759650e-01f, 2.33046129e-01f, -3.04194335e-02f,
  -1.03425160e-01f, 1.85666550e-02f, -2.26330459e-01f, -1.00412061e-02f, 2.49146953e-01f, 1.37941524e-01f, -3.79195325e-02f, -2.45039351e-02f, 5.17860614e-03f, -1.02308661e-01f,
  -1.69882365e-02f, 9.83640552e-03f, 9.05990154e-02f, -1.10596433e-01f, 3.71355116e-02f, -1.15723446e-01f, -1.14443481e-01f, -3.89046669e-02f, -8.27044323e-02f, 2.70345449e-01f,
  -7.10272014e-01f, 2.84120768e-01f, -7.04252183e-01f, 2.34907508e-01f, 1.40455797e-01f, 2.00969666e-01f, 3.92765224e-01f, 7.85344541e-02f, 3.43459845e-01f, 6.50034904e-01f,
  9.75431621e-01f, -4.68692869e-01f, 6.43973649e-01f, 8.21494818e-01f, -6.42490923e-01f, 6.37584507e-01f, 2.32971460e-01f, 4.63375211e-01f, -6.59728646e-02f, -9.07381922e-02f,
  -1.45418644e-01f, 7.58349299e-01f, -4.16427813e-02f, -2.35814989e-01f, 1.69373155e-01f, -4.49419826e-01f, 3.15545946e-02f, -4.20700431e-01f, 1.06049180e-01f, -1.85961604e-01f,
  -1.34581223e-01f, 1.80556223e-01f, -5.75601198e-02f, -2.94760644e-01f, -1.26847774e-01f, -1.77792847e-01f, -3.20638895e-01f, -1.20727904e-01f, -4.10776362e-02f, 3.68713364e-02f,
  -7.20543228e-03f, -1.15963258e-01f, 6.03821389e-02f, 1.29943848e-01f, -7.75284916e-02f, -1.43897742e-01f, 1.85730219e-01f, 3.48610757e-03f, -1.73657238e-02f, 4.03243974e-02f,
  3.38217169e-02f, 7.18652382e-02f, 1.78315759e-01f, 3.52971591e-02f, 1.68362819e-02f, 1.56168580e-01f, -8.33631679e-02f, -2.21448123e-01f, -3.66549306e-02f, -1.95192233e-01f,
  -1.88072957e-02f, -2.57988181e-02f, 1.77255005e-01f, 1.10650085e-01f, 2.20574234e-02f, 8.09474736e-02f, -5.05896658e-03f, -4.41710576e-02f, -2.26084471e-01f, 3.55673768e-02f,
  -4.28455696e-02f, 1.71403959e-01f, -3.21075246e-02f, 4.16670106e-02f, 1.32556066e-01f, -6.89448416e-02f, -8.59645568e-03f, -4.93946113e-02f, 1.06624946e-01f, -7.98552409e-02f,
  1.04251206e-01f, -4.55006808e-02f, 9.35110599e-02f, -6.73131272e-02f, 3.57204326e-03f, 6.78155422e-02f, 2.10098118e-01f, 3.49280573e-02f, 7.17130899e-02f, -4.47231121e-02f,
  -2.13694245e-01f, -5.23193419e-01f, -2.70952284e-02f, -4.98797484e-02f, -1.71247229e-01f, 4.46083024e-02f, -6.45047203e-02f, -6.32641837e-02f, -2.49328703e-01f, 1.08110137e-01f,
  2.31640115e-02f, -4.06679846e-02f, -9.71090272e-02f, 1.50048152e-01f, -9.61058363e-02f, 3.84586424e-01f, -6.49234802e-02f, -2.45438874e-01f, -1.72307819e-01f, -1.48270473e-01f,
  -1.17237240e-01f, 9.32734236e-02f, -1.43284902e-01f, 1.32546751e-02f, -4.75124046e-02f, 2.20888332e-02f, -1.47420652e-02f, -1.08623132e-01f, -1.33216493e-02f, 1.17980160e-01f,
  5.36920071e-01f, 1.69655140e-02f, -4.19595480e-01f, -4.01868112e-02f, 8.28066319e-02f, 1.73893452e-01f, -4.50707018e-01f, -7.05404580e-02f, -3.74011457e-01f, 3.55579019e-01f,
  2.13694245e-01f, 1.76352412e-01f, -6.64011419e-01f, 6.50354087e-01f, 1.16677709e-01f, -5.16751289e-01f, 4.76123959e-01f, 3.44112009e-01f, -1.55477747e-01f, 2.91892201e-01f,
  1.76761940e-01f, 7.08526850e-01f, -2.31114849e-01f, 4.13067073e-01f, 4.24825698e-01f, -1.33495525e-01f, 4.22458351e-01f, -3.12944591e-01f, 6.43098950e-01f, 1.67796120e-01f,
  6.60083294e-02f, -8.31772536e-02f, -9.41602737e-02f, -6.60123080e-02f, 5.07382676e-02f, 2.26362646e-01f, 1.39837384e-01f, -2.33481303e-01f, -2.95475990e-01f, -1.33193191e-02f,
  1.26150092e-02f, 4.60782722e-02f, 1.07098550e-01f, -2.11956978e-01f, 1.46300256e-01f, 6.73103258e-02f, -5.06540164e-02f, 7.60488678e-03f, -1.76816478e-01f, 1.24943689e-01f,
  -1.14161268e-01f, 2.91821454e-02f, 1.36099234e-01f, -1.18431985e-01f, -8.85960534e-02f, 3.44818644e-02f, 5.45899048e-02f, -1.93796698e-02f, 2.25438878e-01f, 8.75546932e-02f,
  1.97437152e-01f, 6.63989410e-02f, 6.62596151e-02f, 8.37117992e-03f, 5.15367500e-02f, -4.16738838e-02f, 9.24348012e-02f, 7.36975297e-03f, -1.40908480e-01f, -1.27746742e-02f,
  1.30563617e-01f, -6.70370758e-02f, 1.22407913e-01f, 7.25686625e-02f, 2.45296746e-01f, 3.44229862e-03f, -7.70400316e-02f, 8.03713873e-02f, 9.34716500e-03f, 1.33121356e-01f,
  -1.33292556e-01f, 8.00689608e-02f, -6.47880360e-02f, -1.07049882e-01f, -2.61228941e-02f, -1.49073586e-01f, 3.64599347e-01f, 1.33672729e-01f, -2.22561747e-01f, -6.17864132e-02f,
  -3.11169773e-02f, 2.85923928e-01f, -1.83175832e-01f, -1.70413464e-01f, -5.93896993e-02f, 3.07128817e-01f, 4.23787944e-02f, 8.12522322e-02f, 1.40450910e-01f, 3.07264011e-02f,
  8.74675512e-02f, -6.26681671e-02f, 2.32356727e-01f, -3.81129012e-02f, -1.99382707e-01f, 5.80633283e-02f, 1.02116004e-01f, -8.17126036e-02f, 8.69171810e-04f, 1.35837689e-01f,
  4.03086729e-02f, 8.77268426e-03f, 2.32742950e-01f, -6.00622892e-02f, 7.71707222e-02f, -4.99580950e-02f, 3.49108167e-02f, 2.52862331e-02f, 1.60250410e-01f, -1.32649496e-01f,
  -1.14597893e+00f, 2.59533882e-01f, 5.83112478e-01f, -1.04538274e+00f, 3.28334510e-01f, 4.35440950e-02f, 5.54715805e-02f, -1.71767816e-01f, -4.26470637e-01f, -2.27121994e-01f,
  -7.64082521e-02f, 1.97601408e-01f, 7.39218950e-01f, -2.03372270e-01f, 1.39113382e-01f, 5.70282638e-01f, -6.09853148e-01f, -4.12834674e-01f, 1.31488293e-01f, -4.62870628e-01f,
  -1.55092254e-01f, -6.09642752e-02f, 2.88659573e-01f, 5.07330783e-02f, -1.44054115e-01f, -3.61066550e-01f, -2.05335319e-01f, 4.10163522e-01f, -3.64852905e-01f, 4.83730227e-01f,
  -6.58306599e-01f, -3.72553676e-01f, -1.33195937e-01f, -3.59124653e-02f, -1.77577913e-01f, 1.62067227e-02f, -1.86294559e-02f, 2.66185999e-01f, -5.25042787e-02f, -1.82786528e-02f,
  3.46017145e-02f, 1.30714893e-01f, -1.57740638e-01f, 1.86672345e-01f, -2.70107508e-01f, 6.14516772e-02f, 6.34385347e-02f, -2.09783074e-02f, 5.85106909e-02f, 1.29397869e-01f,
  1.67453229e-01f, 3.15771736e-02f, -9.12798345e-02f, 6.49111765e-03f, 1.69220209e-01f, 1.00829236e-01f, -3.92265655e-02f, 8.48857611e-02f, -1.44891059e-02f, -2.10529640e-01f,
  5.18477112e-02f, 1.39503539e-01f, 7.22500086e-02f, -5.17054759e-02f, 8.51515159e-02f, 7.68957809e-02f, 2.46868432e-02f, 1.62645187e-02f, 5.63029237e-02f, 7.84754381e-02f,
  -1.18176468e-01f, -1.02846973e-01f, -1.13739632e-01f, -1.43776104e-01f, -3.02466787e-02f, -5.59666529e-02f, 1.19556077e-02f, 7.92766735e-02f, -1.12825492e-02f, 8.12896714e-03f,
  2.29027253e-02f, 8.29779729e-02f, 4.55684215e-02f, 2.07742155e-02f, 3.85180190e-02f, 8.76167193e-02f, 4.18855064e-02f, 4.99237515e-03f, -6.22055009e-02f, 1.34071693e-01f,
  -1.16638792e+00f, -9.15733278e-01f, -2.51308400e-02f, -1.21018618e-01f, -1.30764350e-01f, -2.41352078e-02f, -8.07124823e-02f, -1.57627121e-01f, -3.36279497e-02f, -1.08138584e-01f,
  -1.39845729e-01f, -9.21914652e-02f, -1.38572678e-01f, -1.97422192e-01f, 6.00538179e-02f, -3.26066911e-02f, -1.11847393e-01f, -1.21045798e-01f, -1.50504187e-01f, -1.08568676e-01f,
  -2.54389886e-02f, -2.29271222e-02f, 1.87054724e-01f, -8.05389285e-02f, -7.96305463e-02f, -1.15862556e-01f, -2.78288394e-01f, 3.69849578e-02f, -1.75008345e-02f, 1.77564636e-01f,
  9.49969947e-01f, -4.69536096e-01f, -2.57088304e-01f, 6.04557805e-02f, 3.46090227e-01f, 9.05066013e-01f, 1.02985561e+00f, -3.25611085e-01f, -1.51306033e-01f, -3.30783784e-01f,
  1.69355810e-01f, 2.00503767e-01f, 1.72206163e-01f, 4.08476293e-01f, 1.14153504e+00f, 2.29131281e-01f, 2.24548295e-01f, 3.43590260e-01f, -2.29673639e-01f, 1.92696512e-01f,
  1.14063211e-01f, 3.36987764e-01f, -1.83261156e-01f, -5.16039073e-01f, 5.30894578e-01f, -5.16740322e-01f, -3.74500275e-01f, 8.85466635e-02f, -2.76288450e-01f, 4.01829988e-01f,
  8.48544911e-02f, 7.06283003e-02f, -4.33606394e-02f, -3.26532349e-02f, 6.69724587e-03f, 1.71381891e-01f, 2.71024033e-02f, 2.85876602e-01f, 5.93446866e-02f, -1.60964772e-01f,
  6.01468869e-02f, 3.18497978e-02f, -1.30583271e-01f, 7.41661191e-02f, 1.96953908e-01f, -1.73379317e-01f, -2.38054171e-01f, -1.66675255e-01f, -1.94685251e-01f, 1.88101768e-01f,
  -5.73790073e-03f, -1.03725664e-01f, 5.09230047e-02f, -1.89562276e-01f, 1.23764500e-02f, -6.30487353e-02f, 7.34179690e-02f, 9.94014144e-02f, -8.76690298e-02f, 1.57383755e-01f,
  9.09931362e-02f, 1.37724414e-01f, 1.03003673e-01f, -7.22754970e-02f, 1.38231471e-01f, -1.48148522e-01f, 1.56169906e-01f, -7.01938570e-02f, -8.91523995e-03f, 1.19455889e-01f,
  -7.43077472e-02f, 3.47335823e-02f, 1.19013153e-01f, 3.17626446e-02f, 9.39086750e-02f, -8.11800808e-02f, 6.50425553e-02f, 2.92076804e-02f, 1.91457346e-02f, -1.56092048e-01f,
  -1.31182084e-02f, 9.61134285e-02f, 4.68227640e-03f, -1.25228971e-01f, 1.12627354e-03f, -3.27735841e-02f, -6.53496105e-03f, -1.25494031e-02f, -4.10364978e-02f, 5.27322590e-02f,
  -5.51000349e-02f, -6.24796376e-02f, -1.07656062e-01f, -9.04162228e-02f, -5.26981354e-02f, 3.14477719e-02f, -9.44039598e-03f, -1.72011033e-02f, -9.48593989e-02f, 1.77782327e-01f,
  -1.10100858e-01f, -6.18409738e-03f, -1.76965352e-02f, -8.67859796e-02f, -1.45214424e-01f, 5.59568591e-02f, -1.66424196e-02f, -1.58495665e-01f, 5.07970154e-02f, -1.75630838e-01f,
  5.52240666e-03f, 2.51020193e-01f, -1.88551079e-02f, 2.23918166e-02f, -5.34594618e-02f, 2.53571514e-02f, 9.77125317e-02f, -1.30131155e-01f, 9.29508284e-02f, -2.35600561e-01f,
  2.71425813e-01f, 5.56036115e-01f, 4.55458671e-01f, 1.02347577e+00f, 4.01082724e-01f, -2.11717308e-01f, 1.08955726e-01f, 7.69592047e-01f, 1.33106840e+00f, -4.40925539e-01f,
  -3.04868612e-02f, -1.16212904e-01f, -7.67616928e-02f, 1.80001274e-01f, 1.54975399e-01f, 1.91298306e-01f, 3.52519542e-01f, -5.29720969e-02f, 6.64873540e-01f, 3.14889252e-01f,
  5.64720869e-01f, 1.48171455e-01f, -7.27824420e-02f, 1.95412055e-01f, 7.55475461e-02f, 2.04271838e-01f, -4.48283702e-01f, 1.69469133e-01f, -6.23979986e-01f, -2.42458194e-01f,
  -1.85072720e-01f, 4.52103645e-01f, -1.67830303e-01f, -9.36636999e-02f, 1.89953055e-02f, -8.18232521e-02f, -3.28108847e-01f, -2.62072414e-01f, 1.34381903e-02f, -4.16125879e-02f,
  -1.94239780e-01f, -2.04310119e-02f, -8.11252967e-02f, -4.78719398e-02f, 2.67562628e-01f, 1.28395319e-01f, 1.82627738e-02f, -7.05885068e-02f, 2.48993598e-02f, -7.57224113e-02f,
  1.47887096e-02f, -9.66995507e-02f, 1.00742340e-01f, -1.42065421e-01f, 5.64962327e-02f, 1.69788420e-01f, -2.14565963e-01f, -1.58079565e-01f, -4.17951904e-02f, 1.38975993e-01f,
  7.96281323e-02f, 1.62721515e-01f, -9.10578221e-02f, 4.23838459e-02f, 6.85042366e-02f, -6.00708947e-02f, 1.19975656e-01f, -2.04698280e-01f, 1.71441242e-01f, -1.64030552e-01f,
  8.23945105e-02f, 3.06911450e-02f, 9.70793664e-02f, -3.97356562e-02f, 5.86493909e-02f, 6.31880313e-02f, -1.70945004e-01f, -8.94446522e-02f, -1.67430770e-02f, 1.82427634e-02f,
  8.43411535e-02f, -1.17560290e-01f, 5.39080799e-02f, -1.57554597e-01f, -6.10364154e-02f, -1.70387793e-02f, 6.11426421e-02f, -3.93179618e-03f, 2.46043857e-02f, -5.98776378e-02f,
  2.20599920e-01f, 7.13415086e-01f, 3.14298384e-02f, -1.73849538e-01f, -1.62658319e-02f, 5.62802739e-02f, 1.44144207e-01f, 4.84869592e-02f, 2.81701446e-01f, 1.91071823e-01f,
  -1.01956859e-01f, -1.38154998e-01f, -1.55866981e-01f, 5.16414829e-02f, -5.08332103e-02f, 7.50401616e-03f, -1.29787743e-01f, 1.09374247e-01f, -9.64853726e-03f, -1.10616773e-01f,
  -1.57143727e-01f, 7.50503242e-02f, 1.86420307e-02f, 1.97607040e-01f, -1.69588849e-01f, -2.60607779e-01f, 2.30868056e-01f, 2.05387957e-02f, -1.97329193e-01f, 4.94033210e-02f,
  3.64907235e-01f, 2.69307792e-01f, -5.24373710e-01f, 6.84942454e-02f, -7.20498800e-01f, -1.10926844e-01f, 3.16064239e-01f, -4.29005921e-01f, 4.85502690e-01f, 6.99813902e-01f,
  -2.62654632e-01f, 4.78935987e-01f, 4.94565666e-01f, -6.21257834e-02f, 2.90253699e-01f, 8.26907635e-01f, 5.47901928e-01f, 3.89806211e-01f, 7.61381462e-02f, 2.20946044e-01f,
  9.94501039e-02f, 8.13175812e-02f, -1.94581524e-01f, -3.55308682e-01f, -4.12022144e-01f, -4.13188219e-01f, -2.52628207e-01f, -5.12675047e-01f, -1.80471078e-01f, -7.49519765e-02f,
  -1.43590957e-01f, 1.27690226e-01f, -8.08659270e-02f, 1.03776500e-01f, -4.98531908e-02f, -1.44125894e-01f, -3.08795273e-02f, -3.69319543e-02f, -1.26581535e-01f, 1.81654021e-01f,
  2.73378670e-01f, 1.36780366e-01f, 2.80254215e-01f, -1.05884641e-01f, -1.94338247e-01f, -1.44351900e-01f, 6.52145445e-02f, -1.62742987e-01f, 7.85601512e-03f, 8.78679194e-03f,
  9.17006880e-02f, -6.02599643e-02f, -1.16636962e-01f, 3.15939695e-01f, -2.80605797e-02f, 7.18606263e-02f, 1.52421460e-01f, -3.01728826e-02f, 1.25013128e-01f, 2.20264550e-02f,
  5.92194349e-02f, 1.63591787e-01f, 5.59670776e-02f, -1.71799868e-01f, -9.45382938e-02f, -1.54539213e-01f, 7.79809654e-02f, -6.96422234e-02f, -5.18176071e-02f, 1.88504439e-02f,
  -7.61172697e-02f, -1.27417505e-01f, -6.46472797e-02f, -1.47065446e-02f, 7.49696717e-02f, 5.08907735e-02f, 5.96143911e-03f, 5.93834594e-02f, 1.96954384e-01f, -1.94802046e-01f,
  2.16425508e-02f, 1.92092404e-01f, -3.73283140e-02f, 1.27747459e-02f, 8.28686431e-02f, -3.62526253e-02f, 9.58559439e-02f, -1.23711556e-01f, 1.93122085e-02f, -9.53026935e-02f,
  1.00222878e-01f, 6.07017994e-01f, 1.45925522e-01f, 5.09973727e-02f, -2.48942208e-02f, -1.70955479e-01f, 1.06812932e-01f, 3.54307853e-02f, 2.03315720e-01f, 5.40114269e-02f,
  1.00895099e-01f, 1.74619555e-01f, 1.11623937e-02f, -2.14534119e-01f, -1.12678431e-01f, 1.91318337e-02f, 3.70669365e-01f, 4.07403745e-02f, 3.26025970e-02f, -1.50867686e-01f,
  -7.69988671e-02f, 3.63039106e-01f, 1.97469831e-01f, 4.45928015e-02f, 1.66677877e-01f, 1.65348232e-01f, -1.31148085e-01f, -8.82807225e-02f, 8.91811177e-02f, 1.53410941e-01f,
  -6.40292645e-01f, -2.16729641e-01f, -6.00380778e-01f, -3.22320253e-01f, 2.11503923e-01f, -8.84497106e-01f, -6.67536736e-01f, -7.77722374e-02f, -1.97397843e-01f, 2.31502220e-01f,
  2.23372579e-01f, -4.45264697e-01f, 4.49493170e-01f, -9.65931833e-01f, -6.26357138e-01f, -4.16663378e-01f, -5.96672475e-01f, -5.77144444e-01f, -1.19991012e-01f, 4.77019325e-02f,
  -7.71883354e-02f, -2.05150113e-01f, -3.63728315e-01f, 4.90685821e-01f, -2.79146791e-01f, 3.88337344e-01f, 9.30598080e-01f, 3.61804903e-01f, -1.71025932e-01f, -2.59105504e-01f,
  -3.69483382e-01f, 7.02304989e-02f, -7.76681826e-02f, -2.17978612e-01f, 1.10127009e-01f, 3.32134306e-01f, -3.22183548e-03f, -9.36915651e-02f, -7.84130692e-02f, -1.18368852e-03f,
  5.78187667e-02f, 6.23517968e-02f, -2.18528509e-01f, 3.63216326e-02f, 7.57700182e-04f, 9.85150319e-03f, -1.40679285e-01f, -1.29070859e-02f, -3.09853982e-02f, -1.63097978e-01f,
  -1.85540512e-01f, -1.04239345e-01f, 1.41056851e-01f, 8.31756815e-02f, 1.73657820e-01f, 6.61947858e-03f, -2.29515936e-02f, 1.35982156e-01f, -3.54448035e-02f, 1.88513279e-01f,
  1.32119521e-01f, 1.98352411e-02f, -1.47990972e-01f, -8.09778199e-02f, -6.68880790e-02f, 6.28976375e-02f, -1.93697214e-03f, -3.56051028e-02f, -9.00586601e-03f, 5.85088097e-02f,
  5.30246645e-02f, 3.87750193e-02f, -9.99966636e-02f, 5.43054007e-02f, 9.74774063e-02f, -9.61044282e-02f, -7.69186690e-02f, -9.08856988e-02f, -3.05344574e-02f, -1.97254092e-01f,
  1.09420180e-01f, 2.75806114e-02f, 2.00994704e-02f, 1.69560671e-01f, -8.25086161e-02f, 1.83602586e-01f, 1.42477810e-01f, -9.16070640e-02f, -4.87908088e-02f, 1.29733786e-01f,
  1.53658733e-01f, 5.47680080e-01f, 3.50905322e-02f, -7.58332461e-02f, -5.14090136e-02f, -1.03545142e-02f, -1.78408638e-01f, -2.61708945e-01f, -4.00706604e-02f, -2.28500105e-02f,
  1.40201777e-01f, 2.66587967e-03f, 2.23670676e-01f, 5.62615972e-03f, 3.33999656e-02f, 1.21545888e-01f, 2.11968869e-01f, -1.66438427e-02f, 2.93234468e-01f, 1.59405932e-01f,
  3.42140824e-01f, 1.18186630e-01f, 2.48751462e-01f, -2.91756280e-02f, 1.84850320e-02f, 1.82478428e-01f, 1.47510678e-01f, -5.20606749e-02f, 1.52081832e-01f, 6.98175281e-02f,
  1.23373806e-01f, -2.77886569e-01f, -5.02063036e-01f, 3.98474813e-01f, 3.36642712e-01f, -9.89347771e-02f, -7.78882861e-01f, 5.70040941e-01f, -5.77376783e-01f, -5.74414611e-01f,
  7.57277459e-02f, -3.37876976e-01f, -6.95780575e-01f, 3.75446916e-01f, 8.90633345e-01f, -7.02460229e-01f, 6.13674581e-01f, 2.26965204e-01f, 1.47018339e-02f, 3.44582736e-01f,
  5.70800066e-01f, 8.04101229e-01f, 6.46135092e-01f, 7.05330372e-01f, 3.81826013e-01f, 4.28252578e-01f, 7.55331814e-01f, -2.30652034e-01f, 7.66973197e-01f, 3.19669187e-01f,
  -9.60609615e-02f, -1.25522301e-01f, -1.07217349e-01f, -1.59740627e-01f, 1.41648520e-02f, -5.26130460e-02f, -1.31533025e-02f, 1.63256437e-01f, 1.48985684e-02f, -3.64038721e-02f,
  1.44729884e-02f, 4.06991869e-01f, 1.99945629e-01f, 5.47684282e-02f, 2.25079469e-02f, 1.98380932e-01f, 8.44915584e-02f, -9.78225693e-02f, -2.87369955e-02f, -5.05855419e-02f,
  -1.74775600e-01f, 3.02211307e-02f, -1.47508532e-02f, -8.64062645e-03f, 8.82115494e-03f, 8.78077671e-02f, -1.85513914e-01f, -1.90236211e-01f, -4.60704602e-02f, -3.70510807e-03f,
  1.96451575e-01f, -2.19086632e-01f, -8.57890174e-02f, -2.07633659e-01f, -4.31825332e-02f, -1.41382545e-01f, 5.47425970e-02f, -3.24149877e-02f, -1.36381045e-01f, 3.71251022e-03f,
  1.31535437e-02f, 1.30596086e-01f, -6.89672977e-02f, -6.89195096e-02f, 8.36605486e-03f, -3.28812338e-02f, -9.22643691e-02f, 6.07686825e-02f, -1.68329164e-01f, -8.83865207e-02f,
  -2.48910654e-02f, 5.86912483e-02f, -1.53654739e-01f, 1.95253313e-01f, -3.69906984e-02f, -1.50298933e-02f, -4.60680720e-04f, -1.10018611e-01f, -1.91573780e-02f, 6.97571710e-02f,
  7.79997259e-02f, 2.29126170e-01f, -1.20628849e-01f, 9.97743830e-02f, -1.02840006e-01f, 3.94034833e-02f, -5.13599403e-02f, 1.49311900e-01f, 4.42377329e-02f, -1.48366187e-02f,
  2.64569044e-01f, 3.91099229e-02f, -1.28857419e-01f, -3.31176743e-02f, 2.23104492e-01f, -2.71556061e-02f, 7.10944682e-02f, -2.00799435e-01f, 1.99409962e-01f, 2.11926818e-01f,
  -4.02794074e-04f, 1.03883870e-01f, -9.64896083e-02f, -1.22169293e-02f, 2.08282158e-01f, -1.54482409e-01f, 1.34048998e-01f, -9.11419913e-02f, 2.45680362e-01f, -3.53205167e-02f,
  -1.07769811e+00f, 7.28016257e-01f, 1.43575877e-01f, -6.25397444e-01f, 3.54678065e-01f, 9.14443076e-01f, -8.04535598e-02f, 1.70240954e-01f, 2.20257640e-02f, 2.55345672e-01f,
  -1.80934981e-01f, 8.80907327e-02f, -1.37748331e-01f, -3.46167088e-01f, -7.95129597e-01f, -2.28379235e-01f, -2.19629169e-01f, -7.72332177e-02f, 8.73347148e-02f, 2.24737868e-01f,
  -1.81566864e-01f, -3.34773540e-01f, -7.01517522e-01f, 3.53816777e-01f, -1.01161174e-01f, 3.09152097e-01f, -5.17037690e-01f, 1.96287781e-01f, -6.59975857e-02f, 5.02055325e-02f,
  -3.38673472e-01f, -1.03675164e-01f, -8.83606914e-03f, 2.14065805e-01f, 1.43427908e-01f, -1.29989795e-02f, 1.67797401e-03f, -8.74430463e-02f, -1.16056642e-02f, 4.30242680e-02f,
  8.22110549e-02f, 8.88649374e-02f, -2.85832938e-02f, 2.54861489e-02f, 2.31388122e-01f, 1.75822303e-01f, 5.41170686e-02f, 4.60168794e-02f, 9.20189992e-02f, -2.31982246e-02f,
  8.72939476e-04f, 1.67563856e-01f, 2.37879172e-01f, 1.27224978e-02f, 1.68661866e-02f, 1.37226447e-01f, 2.95735486e-02f, 2.88788248e-02f, 1.69291705e-01f, 1.13388106e-01f,
  1.37954891e-01f, 9.19089615e-02f, 4.55434546e-02f, -5.72769754e-02f, 2.53585912e-02f, 1.67441450e-03f, -5.98263927e-02f, -1.71960935e-01f, -3.41853611e-02f, 6.50188774e-02f,
  -2.21909061e-02f, 6.67710751e-02f, 1.05396137e-01f, 1.71123162e-01f, -7.56460875e-02f, -1.18647859e-01f, -2.29586624e-02f, 1.67158514e-01f, 5.31003252e-02f, -1.55216336e-01f,
  -9.71957594e-02f, 1.41693205e-01f, -1.47869186e-02f, -8.68487433e-02f, 5.41802123e-02f, -1.63583960e-02f, 1.76783383e-01f, -6.05518557e-02f, -8.46660808e-02f, -2.25907266e-02f,
  5.27013779e-01f, 5.48383534e-01f, 3.97865772e-02f, -2.31387317e-02f, -4.35197838e-02f, 2.29309574e-02f, -1.12062782e-01f, 9.51864272e-02f, 9.31512490e-02f, 1.93236973e-02f,
  6.93310946e-02f, -1.09683545e-02f, 2.38195062e-01f, -6.98954090e-02f, -8.75723287e-02f, 9.98737291e-02f, -4.09603715e-02f, 1.75860561e-02f, 7.50658140e-02f, 4.83113490e-02f,
  -3.68321277e-02f, 1.02042772e-01f, -1.86193317e-01f, -6.38197828e-03f, 4.22027297e-02f, -8.53550155e-03f, 1.06090166e-01f, -3.95645611e-02f, 7.50928745e-03f, 1.21893935e-01f,
  -5.42304218e-01f, -3.64953279e-01f, 2.80139774e-01f, -4.86078650e-01f, -5.13816297e-01f, 2.46475413e-01f, 1.16323784e-01f, -3.43544602e-01f, -4.12699282e-02f, -3.93619955e-01f,
  -5.59054554e-01f, 1.82620659e-01f, 3.02859038e-01f, -3.97901893e-01f, 1.29857135e+00f, 7.41917968e-01f, -6.47810176e-02f, 1.15358517e-01f, -9.88900587e-02f, -4.45989937e-01f,
  -5.91134317e-02f, -6.17985189e-01f, 1.34217739e-01f, -8.06154072e-01f, -7.06871867e-01f, -4.57402378e-01f, -1.14375845e-01f, 3.08252182e-02f, -5.70922911e-01f, -2.25499179e-03f,
  -4.09493476e-01f, -4.29952890e-01f, -3.94043595e-01f, 7.69563541e-02f, -1.84161782e-01f, 1.84485614e-02f, 1.93891540e-01f, 2.69125611e-01f, 2.79814540e-03f, 2.00848151e-02f,
  1.00521758e-01f, 3.97526808e-02f, -2.31024355e-01f, 3.09688132e-02f, -8.22652429e-02f, -8.28284770e-02f, -2.22738311e-02f, -1.44140929e-01f, -1.46116719e-01f, 1.39435664e-01f,
  -1.14362158e-01f, 1.11276945e-02f, -1.67850256e-01f, -7.58461431e-02f, 1.98281854e-02f, -1.31111369e-01f, 1.95397317e-01f, 2.04410017e-01f, 2.74972487e-02f, -1.99381076e-02f,
  5.89987971e-02f, 1.59229517e-01f, -1.18445665e-01f, 9.21499170e-03f, -1.23211600e-01f, -2.02940106e-01f, -8.17772076e-02f, -3.79476808e-02f, 7.84352235e-03f, -1.60589665e-01f,
  -1.39653563e-01f, -2.43356195e-03f, -5.82220517e-02f, -5.39443381e-02f, -9.15227309e-02f, 1.70987193e-02f, 1.42695745e-02f, 1.29385677e-03f, -4.20169951e-03f, 2.80941371e-03f,
  7.05635920e-02f, 3.66483741e-02f, -2.38385573e-01f, -3.72136990e-03f, -1.01610668e-01f, 8.21586922e-02f, -6.41073510e-02f, -3.29733752e-02f, 1.18741095e-01f, -2.48386599e-02f,
  -2.83814296e-02f, -1.08258195e-01f, -2.16496944e-01f, -2.76954621e-01f, 4.25506793e-02f, 1.68761872e-02f, 1.28529677e-02f, -8.52783322e-02f, 1.12575121e-01f, 9.27060004e-03f,
  3.30665521e-02f, -5.85860237e-02f, 4.97334227e-02f, 9.30233151e-02f, -2.06399877e-02f, 7.17470329e-03f, -4.41774866e-03f, -8.61912221e-02f, -1.87295035e-01f, -1.06000759e-01f,
  -1.61969155e-01f, -6.78064078e-02f, 2.65889019e-01f, -1.99563742e-01f, -1.28967747e-01f, 8.06640461e-02f, -1.86451208e-02f, -1.74092367e-01f, 8.19249898e-02f, -2.80496795e-02f,
  1.07475317e+00f, -4.81723636e-01f, 8.27171683e-01f, 9.20474112e-01f, 2.37383291e-01f, 1.36899890e-03f, 5.04797339e-01f, -1.60506904e-01f, 6.35960460e-01f, -5.05916476e-01f,
  -4.71341908e-01f, 4.89445031e-01f, -8.95855188e-01f, 5.25800325e-02f, -1.51434392e-01f, -7.00152040e-01f, 1.10458709e-01f, 1.64669797e-01f, -5.12040046e-04f, 1.71747893e-01f,
  2.22766712e-01f, -6.17297053e-01f, 1.01466864e-01f, -5.55641353e-01f, 5.60644805e-01f, 3.59841526e-01f, -4.90037203e-01f, -9.22865644e-02f, 1.54660687e-01f, -9.90157574e-02f,
  -8.12413171e-03f, 7.49412403e-02f, 1.97386220e-01f, -6.81408122e-02f, 2.90920585e-02f, 4.05590571e-02f, 1.91872492e-01f, 1.47783710e-02f, 1.29569337e-01f, 2.78528929e-02f,
  6.36298731e-02f, 9.10217986e-02f, 9.41436645e-03f, -5.41249290e-02f, 1.50980875e-01f, 1.41195923e-01f, 1.63721830e-01f, 2.93828279e-01f, 1.48654193e-01f, 2.28050992e-01f,
  3.77367526e-01f, 1.66850016e-01f, 1.49352178e-01f, -5.65078156e-03f, 2.15793014e-01f, 1.91908956e-01f, 2.23200276e-01f, 2.39456445e-01f, 1.13422066e-01f, 2.88696408e-01f,
  -1.42052665e-01f, -1.15715861e-01f, -1.15728006e-01f, -6.64457083e-02f, 7.63805071e-03f, 1.06017031e-01f, -6.11494035e-02f, -4.31600325e-02f, 8.27046856e-02f, -2.51965621e-03f,
  8.56347010e-02f, -9.44836587e-02f, 1.66681223e-02f, 1.10769659e-01f, -1.62623394e-02f, 1.68392822e-01f, 1.34393841e-01f, -1.29375488e-01f, 1.71455339e-01f, 6.96689412e-02f,
  -3.84606235e-02f, 8.00387710e-02f, -4.36929837e-02f, 8.47941563e-02f, -9.86839458e-02f, 7.21712271e-03f, -2.89134644e-02f, 1.46620125e-01f, -5.91158271e-02f, -1.29464254e-01f,
  -8.76390636e-01f, -9.42384303e-01f, -1.49512842e-01f, 5.43734385e-03f, -9.75163504e-02f, -7.65997693e-02f, -3.89422961e-02f, 9.01760459e-02f, -1.66667745e-01f, -4.47886288e-02f,
  -6.08577393e-02f, 1.46233425e-01f, 8.45156610e-02f, 1.01890169e-01f, -1.73396856e-01f, -1.96920499e-01f, 1.76093485e-02f, -2.60106444e-01f, -1.32247582e-01f, -1.88051358e-01f,
  1.28415851e-02f, 8.64032004e-03f, 9.34028998e-02f, 1.75030500e-01f, 3.56145799e-02f, -3.41293998e-02f, 1.00137241e-01f, -6.40582442e-02f, -2.40266155e-02f, -2.07611341e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.24039268e-01f, 9.20123279e-01f, 8.34009230e-01f, 2.54727125e-01f, 8.03462386e-01f, 8.35131884e-01f, 9.18177009e-01f, 9.74462152e-01f, 8.43056262e-01f, 8.77972543e-01f,
  8.17338049e-01f, 1.52117753e+00f, 1.19197917e+00f, 1.37164807e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -6.54309476e-03f, -8.48863602e-01f, -6.01971626e-01f, 7.11175382e-01f, 1.08697045e+00f, 1.14426029e+00f, -1.49045721e-01f, -2.81615108e-01f, -8.77921462e-01f, -1.38787997e+00f,
  3.46696675e-01f, -7.20507562e-01f, -1.46814537e+00f, -7.50691414e-01f, -7.37633035e-02f, -5.42957604e-01f, -3.18607301e-01f, -1.07043743e+00f, -7.22764194e-01f, -2.41265208e-01f,
  3.31989586e-01f, 6.24472558e-01f, 8.17514300e-01f, -1.38968432e+00f, 1.04382873e+00f, -2.55736411e-01f, 1.50596812e-01f, -6.48951709e-01f, 5.56595288e-02f, -1.81518912e-01f,
  -1.42282701e+00f, -1.71304965e+00f, 3.38018715e-01f, 3.89974833e-01f, -3.35748345e-01f, -1.51367414e+00f, 1.36468351e-01f, -9.32919681e-01f, 5.07553458e-01f, -3.19540352e-01f,
  -7.66198337e-02f, -7.77332008e-01f, -8.92857254e-01f, -7.05765247e-01f, 1.16861248e+00f, -7.87643492e-01f, -1.39321983e-01f, 1.30436912e-01f, -1.58803552e-01f, -5.68059266e-01f,
  1.09778309e+00f, -3.40298444e-01f, -6.26036584e-01f, 3.92059296e-01f, -1.17794108e+00f, 8.21164608e-01f, -4.07697469e-01f, 2.61961937e-01f, -5.89922488e-01f, 3.77466381e-01f,
  -9.07917559e-01f, 2.69452572e-01f, -1.14903474e+00f, -1.31598508e+00f, 6.15920544e-01f, 1.05794287e+00f, -6.58321321e-01f, 9.62167263e-01f, 2.73430318e-01f, -3.43824446e-01f,
  -6.56915784e-01f, 1.03068602e+00f, -8.75203073e-01f, -3.99850100e-01f, -1.22401726e+00f, -1.02017140e+00f, -8.63517672e-02f, 8.92125905e-01f, 6.35138452e-01f, -5.88869989e-01f,
  4.69719976e-01f, 6.23881102e-01f, -3.01468074e-01f, -3.38055700e-01f, 2.90468395e-01f, -4.70094144e-01f, -3.49252969e-01f, -1.07413030e+00f, -1.29604340e-01f, 8.10982585e-01f,
  1.05479431e+00f, -1.13410509e+00f, -9.73136365e-01f, 7.14837372e-01f, 5.54234266e-01f, -3.16729099e-01f, -9.63012755e-01f, 7.43906200e-01f, -9.02149081e-01f, -1.21346390e+00f,
  -1.54572523e+00f, 5.75653493e-01f, -7.67221987e-01f, -1.07768738e+00f, 4.44302320e-01f, 1.14860606e+00f, -3.90405171e-02f, -9.38229845e-04f, -2.67225742e-01f, -1.24663532e+00f,
  -3.41621906e-01f, 1.10448956e+00f, 6.73039071e-03f, -2.55283982e-01f, 6.41784847e-01f, -1.13737881e+00f, -1.06295872e+00f, -9.10461187e-01f, -2.47273028e-01f, 3.06326956e-01f,
  -3.29966873e-01f, -5.32045722e-01f, 6.40789568e-01f, 6.25304997e-01f, -5.50738335e-01f, -1.00905550e+00f, 9.73067999e-01f, -8.46561790e-01f, -2.03905523e-01f, 4.53982204e-01f,
  -6.40003458e-02f, 5.05716562e-01f, -6.87351286e-01f, -5.79213202e-01f, 2.24178329e-01f, -4.48074192e-01f, -1.36830759e+00f, 8.42638254e-01f, -1.13822550e-01f, 2.24007696e-01f,
  6.65894210e-01f, -1.16129160e+00f, -5.07134378e-01f, -7.20626175e-01f, 5.37298694e-02f, 4.34016138e-02f, -7.39751518e-01f, -3.47963005e-01f, -4.46520329e-01f, -6.25709653e-01f,
  -1.19056618e+00f, 6.30708039e-01f, 1.07973301e+00f, -1.20533276e+00f, -4.00333226e-01f, -3.57750893e-01f, -3.25998008e-01f, -1.33824551e+00f, 8.96954119e-01f, 3.96886259e-01f,
  -7.64002383e-01f, -6.77416861e-01f, -1.07788372e+00f, -4.72812891e-01f, -3.29291612e-01f, -9.69816685e-01f, 1.73230037e-01f, -8.69734049e-01f, -7.36141980e-01f, -7.56983042e-01f,
  -7.43710935e-01f, 1.21633375e+00f, 8.07366055e-03f, 9.78234172e-01f, -4.16273981e-01f, -5.24447322e-01f, 2.41743043e-01f, -6.25680268e-01f, 1.13201439e+00f, 2.07921788e-01f,
  -4.96744335e-01f, -4.57954586e-01f, 1.32899389e-01f, -3.17068845e-01f, -9.00620520e-01f, -2.79874802e-01f, -3.48004073e-01f, -8.49811077e-01f, -9.16471183e-01f, 2.55231470e-01f,
  -8.14880371e-01f, 1.05681181e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.82090062e-01f, -9.72718298e-02f, 2.57742912e-01f, -1.91959769e-01f, 3.21662933e-01f, -1.06942117e-01f, 2.18983054e-01f, -2.75543183e-01f, -2.80146569e-01f, 1.67917937e-01f,
  4.64483678e-01f, 1.98456988e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    