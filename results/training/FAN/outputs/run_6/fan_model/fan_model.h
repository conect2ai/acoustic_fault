/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.42069411e-01f, -5.54015934e-01f, -1.57447532e-01f, -4.05781716e-02f, -1.17966928e-01f, -1.32886216e-01f, 1.11151844e-01f, -3.00652295e-01f, 1.59010887e-01f, -3.43652219e-01f,
  1.08103558e-01f, -2.95577854e-01f, 9.57407802e-02f, -2.06688344e-01f, 2.62955457e-01f, 8.07632580e-02f, -1.93800569e-01f, -2.42741212e-01f, 1.57154456e-01f, -3.24295819e-01f,
  1.05444588e-01f, -5.40699363e-02f, 1.58321440e-01f, -7.45681301e-02f, -1.14287011e-01f, -9.91175100e-02f, -1.84652075e-01f, 1.82658210e-02f, -2.85278618e-01f, 7.63186067e-02f,
  1.02015689e-01f, 2.41967272e-02f, 4.66218591e-02f, -3.10874614e-03f, -3.58147435e-02f, 5.89758977e-02f, -1.23034222e-02f, 7.04848692e-02f, 7.72345886e-02f, -2.62990016e-02f,
  -4.67434004e-02f, 9.65911746e-02f, -1.64395403e-02f, 2.62423158e-02f, -1.83835685e-01f, 2.91806888e-02f, 6.04317822e-02f, 1.57848094e-02f, -3.44096273e-02f, 1.86013058e-02f,
  -2.96714865e-02f, 4.84277261e-03f, 5.93977645e-02f, -7.66217113e-02f, 6.87331185e-02f, 1.16230838e-01f, 1.98297933e-01f, -3.94073240e-02f, 2.51965299e-02f, 4.98684011e-02f,
  1.05061047e-01f, -2.12663189e-02f, 6.65543005e-02f, 6.11437671e-03f, 5.96631579e-02f, 1.18397377e-01f, -1.12263206e-02f, -2.72391527e-03f, -2.02265307e-02f, 2.05426384e-02f,
  -1.98930558e-02f, -3.05768084e-02f, -5.96634718e-03f, 1.04125275e-03f, -4.32302281e-02f, -4.41649184e-02f, -4.68762219e-02f, -2.04774588e-02f, -2.26999931e-02f, 4.78412578e-04f,
  -6.85121268e-02f, 2.10337453e-02f, -1.60855904e-01f, 1.58139635e-02f, 9.10592675e-02f, 1.03597892e-02f, -6.75861910e-02f, -7.39740506e-02f, 8.60898495e-02f, 3.22994776e-02f,
  -4.02286530e-01f, -4.52003628e-01f, -4.16259356e-02f, 3.22112218e-02f, -1.00599357e-03f, -5.28341383e-02f, -7.23255947e-02f, 9.68698133e-03f, -3.35023403e-02f, 4.72108275e-02f,
  2.29398236e-02f, -7.74762779e-02f, -9.24034044e-02f, -1.03860326e-01f, 6.94143847e-02f, -4.95421588e-02f, -4.53655832e-02f, -1.12891659e-01f, -2.63631660e-02f, -6.31150156e-02f,
  5.45525588e-02f, -4.24315594e-02f, 1.40510827e-01f, -6.25994056e-02f, -1.03830826e-02f, 7.15801725e-03f, -1.69355124e-01f, 9.96826887e-02f, -5.05299456e-02f, -4.93124612e-02f,
  -5.50627887e-01f, 7.37085998e-01f, -1.87733814e-01f, 4.22175705e-01f, -4.43548858e-01f, -2.67301381e-01f, -9.00504738e-02f, 3.21338773e-02f, -1.13013558e-01f, 2.86345750e-01f,
  -1.07497394e-01f, 2.76562780e-01f, -4.23735529e-02f, 4.21364427e-01f, -4.11450744e-01f, 2.07411245e-01f, 1.57732636e-01f, 1.47056535e-01f, 4.20987643e-02f, -1.16387814e-01f,
  -8.45951438e-02f, 1.15743667e-01f, 9.13614705e-02f, 1.10244974e-01f, -4.03696410e-02f, 6.89590797e-02f, 5.67974523e-02f, -4.96685430e-02f, -6.33308887e-02f, -5.66476174e-02f,
  6.98848441e-02f, 1.33520693e-01f, 4.37707379e-02f, -8.43235757e-03f, 2.57276744e-02f, 5.88934310e-02f, 9.77847446e-03f, -9.06651095e-02f, -1.08450957e-01f, 3.16891596e-02f,
  5.17952815e-02f, -2.83750780e-02f, 3.88295949e-02f, 5.95387481e-02f, -1.27969563e-01f, -1.45287979e-02f, -2.21222807e-02f, 1.56788193e-02f, 5.39418757e-02f, 1.11025237e-02f,
  -1.03204139e-02f, 6.86129406e-02f, -3.86575935e-03f, 2.65862457e-02f, -7.71683231e-02f, -1.86166819e-02f, -3.98775516e-03f, 7.47934729e-02f, 8.17232281e-02f, -4.46881959e-03f,
  3.59757729e-02f, 3.54366638e-02f, 3.24346824e-03f, -2.96857618e-02f, -1.61260664e-02f, -5.46685159e-02f, -2.32455577e-03f, -5.20447716e-02f, -1.36853615e-02f, 3.41759212e-02f,
  1.05613590e-05f, 2.81273220e-02f, 8.99129882e-02f, -7.72491619e-02f, 5.03375083e-02f, 4.92345951e-02f, 1.63280219e-02f, 3.24529856e-02f, 8.24810639e-02f, 4.66427095e-02f,
  -2.36677546e-02f, -3.80313918e-02f, -1.51540553e-02f, 2.17869524e-02f, 2.19975971e-02f, -3.42524610e-02f, 2.84518618e-02f, -4.66980338e-02f, -9.62460712e-02f, -3.35677154e-02f,
  1.11413643e-01f, 1.19291417e-01f, 7.37955943e-02f, 5.00176065e-02f, -2.13245656e-02f, -9.51057971e-02f, -1.07223662e-02f, -3.79444174e-02f, 1.05608679e-01f, -7.64527470e-02f,
  -3.65860434e-03f, -1.64410360e-02f, 5.40516339e-02f, -1.77210838e-01f, 1.02534823e-01f, -6.97252452e-02f, 9.35727134e-02f, 6.18276745e-03f, 8.64396617e-02f, -2.62073204e-02f,
  -5.13184965e-02f, -9.75410342e-02f, 2.23474335e-02f, 3.61023261e-03f, 4.40578274e-02f, 4.41852286e-02f, 3.76140699e-02f, -6.88754395e-02f, -1.05456496e-02f, 3.33735496e-02f,
  -3.40278387e-01f, -1.73501849e-01f, 3.52491885e-02f, -4.69294898e-02f, 3.85394245e-01f, -3.98386680e-02f, -3.42633352e-02f, 3.26110631e-01f, -2.37150490e-01f, -1.77484136e-02f,
  -4.45344369e-04f, -4.48015869e-01f, 1.77365448e-02f, -3.14590745e-02f, -1.78433686e-01f, -1.34719595e-01f, -2.14680895e-01f, -2.78483570e-01f, -1.82754427e-01f, -6.65008947e-02f,
  -5.25343651e-03f, 1.86270520e-01f, 1.92221761e-01f, 1.93982676e-01f, 4.56571519e-01f, -1.08859707e-02f, 1.82075486e-01f, 1.48765564e-01f, 1.14022441e-01f, -3.17594744e-02f,
  1.06018744e-01f, 3.18885185e-02f, 1.39202356e-01f, -5.08212522e-02f, 3.66704650e-02f, 7.97198564e-02f, -4.67324369e-02f, 2.43822578e-02f, 5.31410314e-02f, -5.99029213e-02f,
  -1.20829560e-01f, 2.12086793e-02f, -1.66070476e-01f, 4.60195057e-02f, -3.09023517e-03f, -5.91817638e-03f, 2.09180312e-03f, 1.05235733e-01f, 3.66854444e-02f, 4.40066904e-02f,
  8.91789421e-02f, 7.71919116e-02f, -5.05976640e-02f, -1.04650281e-01f, 1.68766882e-02f, 9.11327152e-05f, 1.44897299e-02f, 3.12452056e-02f, -6.48117438e-02f, 2.81564090e-02f,
  -3.03312764e-02f, -3.85617651e-02f, 2.79023312e-02f, 8.00466910e-02f, -1.93755850e-02f, 9.26415101e-02f, -9.96983647e-02f, 4.92836721e-02f, 1.57955214e-02f, 4.41237427e-02f,
  5.36552779e-02f, -1.79618746e-02f, 4.11287099e-02f, 6.30962923e-02f, -7.73695782e-02f, -1.14328228e-02f, -4.82505187e-03f, 6.05499856e-02f, 1.51767884e-03f, 9.92313698e-02f,
  -3.79359499e-02f, -5.12234420e-02f, -2.13023238e-02f, 1.33678280e-02f, -6.98531494e-02f, 7.13066906e-02f, 8.90227109e-02f, 6.41477033e-02f, 2.92075071e-02f, 6.34514168e-02f,
  -2.23244831e-01f, -2.79119611e-01f, -1.58393309e-02f, 1.00266738e-02f, -1.16485991e-01f, -2.48728995e-03f, -9.68014225e-02f, 3.18910554e-02f, -1.03869505e-01f, -6.40575588e-02f,
  1.38004601e-01f, 5.38387038e-02f, 1.60966869e-02f, -3.51966508e-02f, 4.95111085e-02f, -2.91410740e-02f, -1.10162579e-01f, -4.86507565e-02f, 2.69566756e-02f, -3.96192521e-02f,
  1.42240582e-03f, -3.74591462e-02f, 7.20002651e-02f, 1.42718375e-01f, 9.05767735e-03f, -4.81083617e-02f, 3.45045030e-02f, -2.54721828e-02f, 9.65973884e-02f, -1.00967279e-02f,
  -7.13996962e-02f, -5.21703482e-01f, -3.81045416e-02f, 2.40596086e-01f, 1.23743922e-01f, 2.02093959e-01f, 4.18947130e-01f, -1.14986725e-01f, 5.93794696e-03f, -1.44086659e-01f,
  1.37170628e-01f, -4.92861271e-02f, 1.88357625e-02f, -8.20590463e-03f, 4.65662897e-01f, -1.41167656e-01f, 2.35115409e-01f, -5.34686958e-03f, -1.87124342e-01f, 1.05733410e-01f,
  -2.96484809e-02f, 3.66778597e-02f, -2.88985949e-03f, -1.35528356e-01f, 2.90455930e-02f, -4.14938144e-02f, 2.91088343e-01f, -5.16767055e-02f, 1.62572429e-01f, 1.03088766e-01f,
  -1.43153965e-01f, -4.31324571e-01f, -6.98957741e-02f, 6.23947233e-02f, -3.20402812e-03f, 1.38406396e-01f, 1.13908701e-01f, 1.20223880e-01f, 5.83862662e-02f, -8.92511755e-02f,
  5.61014861e-02f, -3.73082161e-02f, 1.33977653e-02f, -4.30214480e-02f, -1.42851800e-01f, -9.84559879e-02f, -1.61080614e-01f, 3.31210787e-03f, -9.74155962e-02f, -1.17975444e-01f,
  -1.52395636e-01f, -4.02246527e-02f, 1.84520259e-02f, -1.46255642e-02f, -6.48413748e-02f, -1.69478521e-01f, 1.55301273e-01f, -3.13405842e-02f, -2.35171104e-03f, -1.07129164e-01f,
  5.19712009e-02f, 1.22616030e-01f, -3.28128338e-02f, -9.21036527e-02f, -2.32225023e-02f, -1.14297993e-01f, -2.02386770e-02f, -2.49272510e-02f, 3.58868651e-02f, -8.50552842e-02f,
  6.16619661e-02f, -8.31024200e-02f, -1.99770704e-02f, 1.40830195e-02f, 3.62399742e-02f, 6.44129701e-03f, 3.29672452e-03f, -3.73814963e-02f, 3.09263114e-02f, -6.81711808e-02f,
  2.55882666e-02f, 9.58489105e-02f, 8.34597182e-03f, 6.75209984e-02f, 2.62912326e-02f, 7.24152848e-02f, 8.07653069e-02f, -2.54308581e-02f, -7.28682987e-03f, 1.69757858e-01f,
  2.94103414e-01f, 3.83219600e-01f, 3.38024907e-02f, 3.20516080e-02f, 9.93677415e-04f, -1.34781763e-01f, -3.57064418e-02f, -8.55098814e-02f, -2.20189430e-02f, 1.96984261e-02f,
  2.38699149e-02f, 1.22642875e-01f, 4.54700291e-02f, -2.03812215e-02f, 1.02128655e-01f, -5.52414358e-02f, 1.20050386e-01f, 7.28718638e-02f, 2.48044580e-01f, 7.60944262e-02f,
  1.75944939e-01f, 7.49500468e-02f, 2.12788045e-01f, -1.88552551e-02f, 1.18499711e-01f, 1.37585312e-01f, 4.73022126e-02f, -1.06241610e-02f, 4.04253677e-02f, 3.54044475e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.29616451e+00f, -1.86447024e-01f, -2.01677114e-01f, -5.76733112e-01f, -5.84231555e-01f, -3.01431328e-01f, 3.99718106e-01f, -3.93635660e-01f, -1.67696491e-01f, 2.41247684e-01f,
  1.45587653e-01f, 8.05942640e-02f, 1.08199787e+00f, 1.49567932e-01f, 3.77512313e-02f, 7.34084427e-01f, -4.63447243e-01f, 1.23916388e-01f, -9.49883554e-03f, -4.69369024e-01f,
  -3.29061389e-01f, -1.37505606e-01f, 3.23022962e-01f, -5.08557141e-01f, -5.26759148e-01f, -4.54901129e-01f, -1.80343375e-01f, 1.24361210e-01f, -6.37649357e-01f, 6.52949931e-03f,
  -1.04914892e+00f, -6.84681416e-01f, -2.89814383e-01f, -1.73403010e-01f, -3.16664636e-01f, -7.44698048e-02f, 8.12981799e-02f, 3.74930531e-01f, 4.29598503e-02f, -2.51518991e-02f,
  4.22118343e-02f, -3.59916538e-02f, -2.66989499e-01f, 1.47622563e-02f, -2.01588243e-01f, -8.50607380e-02f, -1.00287735e-01f, -1.68278933e-01f, 6.51944289e-03f, 5.97803630e-02f,
  1.52029917e-01f, -2.03378990e-01f, -1.89273655e-01f, -6.78768456e-02f, -1.25896528e-01f, -1.43305272e-01f, 4.58730645e-02f, 7.17218220e-02f, -2.36345202e-01f, -2.87589133e-01f,
  -2.70552747e-02f, 2.06382543e-01f, 7.45418891e-02f, 9.35600623e-02f, 1.14431921e-02f, -1.03893980e-01f, 2.22166684e-02f, 1.87948287e-01f, 1.09665632e-01f, -4.29238826e-02f,
  -2.57318020e-01f, -1.16694525e-01f, -8.57716277e-02f, -6.47857487e-02f, 1.25658838e-02f, 1.10769719e-01f, 3.26837264e-02f, -1.52377129e-01f, -9.54611897e-02f, -1.45547539e-01f,
  8.20548236e-02f, 6.83521433e-03f, -6.30994700e-03f, 1.07815981e-01f, -1.31197080e-01f, 7.70431533e-02f, -1.22849122e-01f, 6.68604001e-02f, -1.14578595e-02f, -9.62523147e-02f,
  -1.11969042e+00f, -7.31869459e-01f, 1.05797946e-01f, -1.83142722e-01f, -3.57981324e-02f, -1.69280827e-01f, 6.63109869e-02f, -2.38220721e-01f, -3.18367004e-01f, -1.01931892e-01f,
  -1.35932773e-01f, 7.11462647e-02f, -1.06518254e-01f, 8.98267329e-02f, 1.01355821e-01f, -4.09002714e-02f, -1.89814083e-02f, -6.84311613e-02f, -1.93159789e-01f, -1.90070346e-01f,
  5.18312445e-03f, 1.76016182e-01f, 1.80780992e-01f, 1.22828938e-01f, -2.07476411e-02f, -1.03080176e-01f, -3.19166571e-01f, -3.38733383e-02f, -2.33757049e-01f, -8.68262199e-04f,
  -1.67665228e-01f, -3.25735241e-01f, -8.23047519e-01f, -6.48195148e-01f, 1.89439401e-01f, 1.05676174e+00f, 1.90942720e-01f, -8.43559057e-02f, -8.99212420e-01f, 6.95143819e-01f,
  7.35918522e-01f, -7.90888548e-01f, -1.12537555e-02f, 3.50039631e-01f, -3.83008331e-01f, -5.67316310e-03f, 5.66533625e-01f, 3.65815550e-01f, -4.69188333e-01f, 3.50235701e-02f,
  -2.17360139e-01f, 5.72231293e-01f, -8.40422586e-02f, 2.17322782e-01f, 3.82540733e-01f, -3.71261805e-01f, 5.98136067e-01f, -1.22202009e-01f, 4.54523444e-01f, -1.03763409e-01f,
  1.68512296e-02f, -2.34367371e-01f, -8.79003480e-02f, -2.17265829e-01f, 4.49028283e-01f, 3.67490917e-01f, 1.89507246e-01f, -1.40944660e-01f, -3.93025041e-01f, 7.37415301e-03f,
  -2.45563835e-02f, -2.27251321e-01f, -1.45091310e-01f, -1.58573553e-01f, 2.54244190e-02f, -3.23683113e-01f, -1.46844655e-01f, 8.74451473e-02f, -3.00233662e-01f, 1.55303150e-01f,
  -1.27226219e-01f, -1.91766638e-02f, 7.25768059e-02f, -1.20680854e-01f, -2.60799557e-01f, -1.08971454e-01f, 8.33385438e-02f, 7.03906938e-02f, -8.27800930e-02f, -1.54194757e-02f,
  2.99534917e-01f, 2.57674426e-01f, 1.09615453e-01f, 7.03449994e-02f, -1.17988899e-01f, 1.49714112e-01f, -1.38087599e-02f, 7.40834698e-02f, -2.25728497e-01f, 1.67509452e-01f,
  -3.21127847e-02f, -6.79361597e-02f, 1.50222126e-02f, 1.47094816e-01f, 1.07796460e-01f, -1.10683978e-01f, 2.94420845e-03f, 1.15394285e-02f, -5.48019707e-02f, 3.14241312e-02f,
  -8.95294994e-02f, 8.68660659e-02f, 6.95197806e-02f, 2.35359013e-01f, -3.93537804e-04f, -7.64882341e-02f, 6.21931590e-02f, -6.66660024e-03f, -3.36213745e-02f, 1.90584306e-02f,
  1.71957344e-01f, 2.08673716e-01f, -7.60245398e-02f, -1.68404579e-01f, -1.88399971e-01f, 1.98371202e-01f, -6.64076060e-02f, -4.63702008e-02f, 3.12947258e-02f, -3.88614275e-02f,
  2.53289968e-01f, 5.66992015e-02f, 2.84071326e-01f, -3.39967906e-02f, -1.60892144e-01f, 3.38691175e-01f, 1.40894890e-01f, -2.10119203e-01f, 2.64005989e-01f, 1.74392626e-01f,
  5.11773527e-02f, 1.71589166e-01f, -1.80786222e-01f, 1.04712144e-01f, 9.41637307e-02f, 1.90011859e-01f, -4.31852303e-02f, -2.55017029e-03f, 1.53788701e-01f, -7.97014609e-02f,
  9.08996642e-01f, -7.47753382e-01f, -2.99377829e-01f, 5.92053235e-01f, 4.65943485e-01f, -8.76033962e-01f, -1.42975676e+00f, 5.42029083e-01f, -1.21267736e-01f, -8.77405822e-01f,
  2.79410422e-01f, -2.61471450e-01f, -6.52932167e-01f, 7.12130249e-01f, 1.37367976e+00f, -4.09882337e-01f, 8.33048820e-01f, 1.93226904e-01f, 2.79295981e-01f, 2.86924124e-01f,
  9.98744786e-01f, 9.24107313e-01f, 7.09996819e-01f, 5.06210268e-01f, 3.52196783e-01f, 2.40661472e-01f, 7.08307922e-01f, -4.11702722e-01f, 2.45530277e-01f, 2.68971890e-01f,
  -1.62396822e-02f, 1.67851299e-01f, -4.52303141e-02f, -4.28696424e-02f, 3.61455120e-02f, -6.90337792e-02f, -1.15420699e-01f, -6.41693920e-02f, -7.18432963e-02f, -1.46003321e-01f,
  -2.37674475e-01f, 2.90988743e-01f, -3.51312794e-02f, 4.90824953e-02f, 8.15193057e-02f, 5.32212108e-03f, 1.62797034e-01f, 1.69355306e-03f, -2.79901803e-01f, 1.32545173e-01f,
  -3.17544006e-02f, 1.32031918e-01f, 1.91409230e-01f, -1.14404680e-02f, 5.79635315e-02f, 1.74167901e-02f, -2.35283449e-01f, -1.21829547e-01f, -9.46796015e-02f, 9.75349694e-02f,
  2.06733391e-01f, -1.47998512e-01f, -8.01697299e-02f, -1.32892653e-01f, 8.16001277e-03f, -6.74171969e-02f, 1.02276996e-01f, -2.22484581e-02f, -5.19750603e-02f, 2.77373455e-02f,
  -6.43770397e-02f, 6.36255518e-02f, -6.33329153e-02f, -4.09983546e-02f, 7.42774978e-02f, 1.56317130e-01f, -1.56689763e-01f, 9.90868360e-02f, -5.20439222e-02f, -2.44568344e-02f,
  2.72751339e-02f, 1.60026416e-01f, -2.48422071e-01f, 1.08391680e-01f, -3.28943692e-02f, 2.42199376e-02f, -2.50298041e-03f, -4.50647250e-02f, -1.36952177e-01f, -7.48688728e-02f,
  -1.22390173e-01f, 1.62813276e-01f, -3.02272320e-01f, -3.18584330e-02f, -1.31670967e-01f, 1.21144652e-01f, -1.01949923e-01f, 1.45316394e-02f, -6.38258308e-02f, 2.11781282e-02f,
  2.94734806e-01f, -3.55539843e-02f, -2.61577107e-02f, 1.27900839e-01f, -4.98056635e-02f, 3.33907828e-02f, -1.21528525e-02f, -1.13723621e-01f, 1.51790246e-01f, 2.28051186e-01f,
  6.72762915e-02f, -1.96689799e-01f, -2.37714499e-02f, -4.11586873e-02f, -3.74655277e-02f, -1.62521839e-01f, 6.09054193e-02f, -1.48230672e-01f, 1.48798510e-01f, 8.41361061e-02f,
  3.96132171e-02f, -2.46535465e-01f, 4.75302964e-01f, -1.04708946e+00f, 7.71831162e-03f, 5.74425161e-01f, -2.67044216e-01f, -3.85378897e-01f, -4.28308457e-01f, -6.24238372e-01f,
  -7.77495623e-01f, 1.40094683e-01f, 1.71565115e-01f, -6.34059846e-01f, 1.53549421e+00f, 7.05619276e-01f, -1.44408554e-01f, -2.16153860e-01f, -6.30819052e-02f, -5.78958631e-01f,
  -4.16167118e-02f, -8.21049273e-01f, 2.98121899e-01f, -6.28678262e-01f, -3.55587870e-01f, -4.06738877e-01f, -3.25293392e-01f, 1.24730997e-01f, -5.29925287e-01f, 3.44427764e-01f,
  -6.73328936e-02f, -2.77468830e-01f, -7.88677186e-02f, 1.24176353e-01f, 7.25515112e-02f, 2.11173203e-02f, -1.19524430e-02f, 1.85205251e-01f, -1.40078723e-01f, 9.73425880e-02f,
  3.33511494e-02f, 3.22300196e-02f, -2.26386100e-01f, 7.93361589e-02f, -1.01094022e-01f, -1.58862665e-01f, 2.21411213e-02f, 1.02052249e-01f, -9.65307280e-02f, 1.89036220e-01f,
  9.96501595e-02f, 1.94790140e-01f, -1.67547509e-01f, 3.32827978e-02f, 3.68379802e-02f, -1.11755893e-01f, -1.13663981e-02f, 2.44656891e-01f, 1.27606904e-02f, 4.45434526e-02f,
  -3.02064084e-02f, 1.71011180e-01f, 2.22041998e-02f, -1.13893062e-01f, -3.34850959e-02f, -2.19933361e-01f, -8.38523507e-02f, 1.14036705e-02f, -1.55387782e-02f, -4.01370302e-02f,
  -1.98606715e-01f, -2.92246528e-02f, -1.10980459e-01f, -1.24808357e-04f, 6.54642582e-02f, -1.79115847e-01f, 1.54348612e-01f, 2.20882799e-02f, -1.37658656e-01f, 4.26386669e-02f,
  -8.89933929e-02f, 1.78704709e-02f, -9.25127640e-02f, -1.46039218e-01f, 2.22773198e-02f, -5.42277656e-03f, -1.41261563e-01f, 1.34358972e-01f, 5.50784953e-02f, 1.25746280e-01f,
  -3.15748574e-03f, 3.13471973e-01f, -3.26793455e-02f, -9.11641568e-02f, 2.14392040e-02f, 8.07251930e-02f, 7.85127953e-02f, -1.12964459e-01f, 1.74774244e-01f, 9.90760252e-02f,
  -1.27685815e-01f, -1.05434895e-01f, 1.22000135e-01f, -2.04419047e-01f, 4.91555072e-02f, 1.08622998e-01f, -4.11057547e-02f, -4.76031825e-02f, -1.26367630e-02f, -5.79704568e-02f,
  -1.59680411e-01f, -1.57683832e-03f, 8.61950889e-02f, -1.71068728e-01f, -3.13172579e-01f, 1.21043630e-01f, 4.57944870e-02f, -2.51568425e-02f, 1.76105022e-01f, 4.83462997e-02f,
  1.68322670e+00f, -4.65563476e-01f, -3.00300121e-01f, 6.13858759e-01f, -4.23272140e-02f, 7.27165341e-01f, 9.72338498e-01f, -1.82526886e-01f, 7.01491714e-01f, -9.83657613e-02f,
  -3.41301076e-02f, 4.51812863e-01f, -4.43972468e-01f, 5.81147373e-01f, 3.91284019e-01f, 8.44948180e-03f, 5.71338356e-01f, 5.43217421e-01f, -5.16849384e-03f, 1.59084842e-01f,
  2.73474067e-01f, 4.17075694e-01f, -3.95285815e-01f, -5.35831630e-01f, 2.51642168e-01f, -3.20237011e-01f, -3.94720674e-01f, -5.64845085e-01f, -1.61017612e-01f, 3.78851108e-02f,
  1.34366706e-01f, 1.21465325e-01f, 3.38171758e-02f, 3.53496633e-02f, -2.90890019e-02f, 9.87992957e-02f, -2.16584634e-02f, -2.19661985e-02f, 2.15794332e-02f, 2.00798027e-02f,
  1.09567426e-01f, -3.81907634e-02f, 1.12538345e-01f, -8.10965523e-03f, 2.32952237e-01f, 7.82316029e-02f, -1.09469714e-02f, 4.95498851e-02f, -8.26374367e-02f, 1.06586680e-01f,
  4.19425443e-02f, -2.37129871e-02f, 1.05220109e-01f, -9.04730987e-03f, -7.72330761e-02f, -2.90878937e-02f, 4.11009453e-02f, -9.01814550e-02f, 5.08181192e-02f, 2.64028847e-01f,
  3.64689007e-02f, 1.17258467e-01f, 1.61000118e-02f, 3.34644108e-03f, 1.52817354e-01f, -1.68864593e-01f, 1.06254168e-01f, -2.56972779e-02f, 1.23880044e-01f, -3.28653380e-02f,
  1.99746639e-02f, 7.45539442e-02f, -8.82047135e-03f, 1.65291771e-01f, 9.12460983e-02f, 1.29698068e-01f, -3.68214324e-02f, -1.26679009e-03f, -1.98502056e-02f, -8.18011910e-03f,
  -1.15420245e-01f, 1.41010076e-01f, -9.20390636e-02f, -1.32709935e-01f, -9.82381552e-02f, -6.68848306e-02f, -3.34216170e-02f, 4.75823730e-02f, -8.14003721e-02f, -1.49848625e-01f,
  -2.96689659e-01f, -4.02896523e-01f, -4.47858498e-02f, 5.52421212e-02f, -4.24043424e-02f, -6.57943934e-02f, 1.75992376e-03f, 1.26362175e-01f, -1.36177123e-01f, 1.44238099e-01f,
  -3.63430306e-02f, 9.72696990e-02f, 2.54723392e-02f, -1.85379218e-02f, -1.40382117e-02f, -1.19952984e-01f, -8.42192098e-02f, -1.49482992e-02f, -1.33773936e-02f, -3.05623710e-01f,
  -1.39732063e-01f, 2.32788354e-01f, 1.25577271e-01f, 1.36355385e-01f, 8.11779052e-02f, -7.59210363e-02f, 2.16010753e-02f, 1.12853367e-02f, -1.47270799e-01f, -8.56318846e-02f,
  5.30194640e-01f, 5.87680697e-01f, 1.16529286e+00f, 6.99288309e-01f, 1.03594288e-01f, 2.41725653e-01f, 5.35691559e-01f, 7.63861418e-01f, 1.15794671e+00f, -4.09079552e-01f,
  -4.62192446e-01f, 1.44293129e-01f, -3.00623216e-02f, 9.75754112e-02f, -3.80706906e-01f, -1.65871009e-01f, 2.75551498e-01f, -1.24109000e-01f, 5.98569870e-01f, 3.46875250e-01f,
  3.52850854e-01f, -5.47259450e-01f, 1.83195770e-01f, -3.63066286e-01f, 3.97651911e-01f, 3.42800409e-01f, -7.07796097e-01f, 1.04087278e-01f, -8.36901307e-01f, -2.80111581e-01f,
  2.06156656e-01f, 2.40274936e-01f, 1.41707182e-01f, 2.27298811e-01f, 2.48062223e-01f, 1.53447883e-02f, -1.18100822e-01f, -2.23779649e-01f, 6.34020641e-02f, 1.00508645e-01f,
  -1.25970706e-01f, -8.64850730e-02f, 1.02928691e-01f, 2.39534918e-02f, 1.93533137e-01f, 1.09430410e-01f, 1.09938800e-01f, 2.81497419e-01f, -1.89261213e-02f, 2.65790522e-01f,
  1.43488362e-01f, 2.40897194e-01f, 2.11059541e-01f, -1.21492840e-01f, -1.76352654e-02f, 2.22016558e-01f, 1.60786361e-01f, 8.38746354e-02f, 1.09579422e-01f, 1.35207102e-01f,
  -1.70338288e-01f, 2.04921126e-01f, -1.28124431e-01f, -1.18946820e-01f, -1.92236274e-01f, 7.35491514e-02f, -1.34978265e-01f, -1.24514572e-01f, 2.22052913e-02f, -1.44961238e-01f,
  -8.99319723e-03f, -7.39776120e-02f, 9.33856331e-03f, 6.63922504e-02f, 4.09776419e-02f, -3.21340375e-02f, -2.99950093e-02f, -1.76034391e-01f, 2.06746787e-01f, 1.13836363e-01f,
  -1.03255592e-01f, 8.68787616e-02f, -1.43462226e-01f, 1.11591220e-01f, -4.04289141e-02f, 4.85768877e-02f, 1.01846144e-01f, 1.27333933e-02f, 5.41109964e-02f, -1.19214885e-01f,
  -4.50251371e-01f, -4.85498086e-02f, -2.12739091e-02f, -2.33509824e-01f, -1.15262829e-01f, -1.54133320e-01f, 8.70998278e-02f, 7.44320005e-02f, 1.93021204e-02f, -4.24487554e-02f,
  6.18246011e-02f, -5.97962551e-02f, 1.32029414e-01f, -1.29392624e-01f, -1.37454763e-01f, -9.03664157e-02f, 2.51428075e-02f, -1.29403487e-01f, 7.84373730e-02f, -6.67371824e-02f,
  -2.70019919e-02f, -1.89438630e-02f, -6.86645275e-03f, 6.05762005e-02f, -7.17736781e-02f, -1.18181288e-01f, 1.11492112e-01f, -3.76828350e-02f, -2.35815331e-01f, 8.11093301e-03f,
  -5.54381609e-01f, 3.98966998e-01f, -5.33030868e-01f, -8.42690408e-01f, 8.53462494e-04f, -1.04832494e+00f, -1.03480411e+00f, 4.73235324e-02f, -1.21065984e-02f, 4.76785630e-01f,
  -3.31315011e-01f, 3.91420037e-01f, 1.73125342e-01f, -9.80943501e-01f, -1.53894937e+00f, -5.77700675e-01f, -1.31454051e+00f, -5.88775635e-01f, -8.13947394e-02f, -3.56054664e-01f,
  -4.98124391e-01f, -9.19726014e-01f, -1.01032782e+00f, 2.28645355e-01f, -2.99063116e-01f, 5.99700212e-01f, 5.56521527e-02f, 4.35540378e-01f, -5.10107100e-01f, -1.87678367e-01f,
  -3.78861070e-01f, 3.85468394e-01f, 1.46110013e-01f, -1.22188055e-03f, -1.63177997e-01f, 1.65254593e-01f, 3.63222063e-02f, -3.84447314e-02f, 7.70905912e-02f, 3.09912525e-02f,
  3.66891980e-01f, 3.70722190e-02f, -2.39467584e-02f, 1.24155149e-01f, 1.94618762e-01f, 9.77110490e-02f, 1.04099691e-01f, -1.51274696e-01f, 1.40420049e-01f, -4.96424958e-02f,
  -1.45955279e-01f, 1.89156711e-01f, -8.30764249e-02f, -2.52981670e-02f, 4.36997600e-03f, -3.47295478e-02f, -1.77557126e-01f, 2.35078946e-01f, 7.64216334e-02f, -1.01192199e-01f,
  1.49892911e-01f, 1.26508713e-01f, -4.02424261e-02f, -1.58256203e-01f, -1.70483395e-01f, -6.00505508e-02f, 4.35599387e-02f, 1.65195130e-02f, 7.98812807e-02f, -7.42022172e-02f,
  -7.73946866e-02f, 4.79643140e-03f, -3.92464027e-02f, -6.69663399e-02f, -1.65444121e-01f, 8.62405300e-02f, -1.08321734e-01f, 1.96817145e-01f, -1.57132432e-01f, -1.73368394e-01f,
  2.11351993e-03f, -2.38731518e-01f, -1.66619346e-02f, -1.37720898e-01f, -3.10606509e-01f, 9.94003117e-02f, 1.09238513e-01f, 3.88098741e-03f, -1.34526175e-02f, 1.35835215e-01f,
  -1.54857606e-01f, 4.35063057e-02f, 8.00974667e-02f, 9.24800709e-02f, 1.32607415e-01f, -2.88785249e-02f, -2.02244222e-01f, -1.00987591e-01f, -1.85384437e-01f, -6.98089004e-02f,
  6.78054942e-03f, -7.74595365e-02f, -6.50450774e-03f, 8.52025598e-02f, -2.26151437e-01f, -1.62096530e-01f, -1.12027213e-01f, 1.31449848e-01f, -2.60949850e-01f, -1.22610377e-02f,
  3.14206541e-01f, 5.00552468e-02f, 1.62817352e-02f, 9.37435925e-02f, 2.13331711e-02f, 1.82249874e-01f, 1.04942426e-01f, 1.27768949e-01f, 1.72456224e-02f, 8.93478766e-02f,
  5.56171954e-01f, -5.08227468e-01f, 7.93506026e-01f, 2.32894719e-01f, 7.68649206e-02f, -3.64439189e-02f, 3.12447578e-01f, -3.32525432e-01f, -5.00149310e-01f, -6.94779217e-01f,
  -2.59535968e-01f, 7.47185111e-01f, -7.98146307e-01f, 3.29086214e-01f, -3.68652079e-04f, -6.67801023e-01f, -1.55819520e-01f, 1.82436854e-01f, -1.33235320e-01f, -2.45965242e-01f,
  9.64680873e-03f, -4.88498509e-01f, 3.18002343e-01f, -3.30900133e-01f, 3.79655719e-01f, 1.51109785e-01f, -4.56467092e-01f, 1.40986204e-01f, 3.01296711e-01f, 3.11718524e-01f,
  -1.07276082e-01f, -2.00456858e-01f, 1.59419313e-01f, 5.85447252e-02f, -1.73266187e-01f, 6.54535592e-02f, 4.47170228e-01f, 2.00226232e-01f, 6.72687292e-02f, 4.04691733e-02f,
  1.04970150e-01f, 2.49560978e-02f, 2.56980479e-01f, -9.74879880e-03f, -4.67269160e-02f, -1.84636451e-02f, 3.03236619e-02f, 1.09927654e-01f, -6.88888878e-02f, 1.85312897e-01f,
  7.46332109e-02f, 2.33666673e-01f, -5.64865284e-02f, 3.60970013e-02f, 1.63275283e-02f, -6.81029707e-02f, 6.45574043e-03f, 3.32178175e-01f, -4.62783910e-02f, 2.42262725e-02f,
  -9.04844105e-02f, -1.51690366e-02f, -9.32504088e-02f, 1.66029260e-02f, -1.44594416e-01f, 1.44247517e-01f, -5.35308644e-02f, 5.64207658e-02f, 1.20081790e-01f, -5.48397787e-02f,
  -7.73702264e-02f, 5.70152737e-02f, -6.29011393e-02f, -4.59010005e-02f, -2.89303027e-02f, -1.02445990e-01f, 1.16298370e-01f, 7.49398917e-02f, 7.07842633e-02f, 5.88937439e-02f,
  -6.43192651e-03f, -7.73413703e-02f, -7.33470991e-02f, 3.57648805e-02f, -6.01424910e-02f, -8.65915939e-02f, -7.12424144e-02f, 4.10765298e-02f, -2.87757516e-02f, 1.26885936e-01f,
  -1.57011557e+00f, -1.16012013e+00f, -1.01622857e-01f, 8.72069225e-02f, 9.45333317e-02f, 2.26112865e-02f, -5.25933094e-02f, -4.56123799e-02f, -1.61159813e-01f, -2.69563273e-02f,
  -3.03461179e-02f, 9.98168141e-02f, -5.23838364e-02f, 4.08729687e-02f, 3.86714488e-02f, -1.95385888e-01f, -1.40548319e-01f, -2.27396237e-03f, 4.11953218e-02f, 2.24886350e-02f,
  -8.08934942e-02f, -7.80039504e-02f, 6.61332160e-02f, -6.06595213e-03f, 1.35437921e-01f, 7.21601993e-02f, -8.25508311e-02f, 5.02692126e-02f, 7.78092742e-02f, -1.47612393e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.54207540e-01f, 1.14995992e+00f, 1.03430867e+00f, 1.41797328e+00f, 1.64151514e+00f, 1.48923028e+00f, 1.21158767e+00f, 1.00598621e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  3.78732383e-01f, -1.21390498e+00f, 3.70562106e-01f, 4.83228564e-01f, 9.32901561e-01f, 1.14540946e+00f, -8.89379084e-01f, 2.45763510e-01f, 1.10960388e+00f, 9.30880666e-01f,
  -1.49413681e+00f, -1.32582808e+00f, -3.63361388e-01f, -1.10226107e+00f, -1.15331864e+00f, -4.10796970e-01f, -3.41835171e-02f, 8.48724246e-01f, 7.80447245e-01f, 1.98762134e-01f,
  -1.24004602e+00f, 4.23782945e-01f, -7.70702660e-01f, -3.52160841e-01f, -1.39464378e+00f, 8.71405900e-01f, 7.23611563e-02f, -1.33517176e-01f, 6.67975247e-01f, -1.64706492e+00f,
  -1.04263234e+00f, -1.60886025e+00f, 1.84059620e-01f, 5.01596868e-01f, -1.00427186e+00f, -8.51609647e-01f, 5.53843558e-01f, -1.15036571e+00f, 5.11746526e-01f, 4.97207850e-01f,
  -1.31001759e+00f, -5.92930257e-01f, 6.94470286e-01f, -1.09628344e+00f, 2.28294641e-01f, -1.71254182e+00f, -7.71596193e-01f, 1.00926471e+00f, 4.10996288e-01f, 3.00498009e-01f,
  -2.61750400e-01f, -1.17105949e+00f, 3.97170722e-01f, 8.44568431e-01f, 2.05426782e-01f, -7.77466476e-01f, 6.32283926e-01f, -9.43103373e-01f, -6.78558409e-01f, -1.53390396e+00f,
  -1.04506242e+00f, -9.55144048e-01f, 1.12730634e+00f, -1.08189082e+00f, 6.59728348e-01f, 1.19042468e+00f, 7.23637760e-01f, 7.55317926e-01f, 1.33182156e+00f, -5.26189148e-01f,
  1.38428915e+00f, -1.54719865e+00f, 5.01448512e-01f, 2.43386757e-02f, -3.49159807e-01f, 9.89474177e-01f, -2.56149173e+00f, 5.72442532e-01f, -5.81972182e-01f, -8.43468383e-02f,
  1.05398202e+00f, 1.66844487e+00f, -1.59473336e+00f, 3.54008526e-01f, -8.49637151e-01f, 9.11559939e-01f, -1.52662039e+00f, 1.12921584e+00f, -8.02308172e-02f, -9.71249282e-01f,
  -1.07136142e+00f, 3.56337875e-01f, 7.08301723e-01f, 7.24747241e-01f, -8.98217797e-01f, -1.59863544e+00f, -1.50162160e-01f, -1.42735708e+00f, -3.25887889e-01f, 7.07871497e-01f,
  1.39530289e+00f, -1.43947315e+00f, 1.54218137e+00f, -2.20194776e-02f, -1.22530019e+00f, -1.07681501e+00f, -1.30770147e-01f, -6.19023263e-01f, 8.52739096e-01f, 9.38735723e-01f,
  -1.25089753e+00f, -4.98953573e-02f, -1.11139488e+00f, -4.74239558e-01f, -8.85922134e-01f, -3.96966487e-01f, -9.30700004e-02f, -2.28378803e-01f, -1.04226089e+00f, 1.06849127e-01f,
  5.50058246e-01f, -1.40337455e+00f, 2.87340820e-01f, 9.50917780e-01f, -9.00558889e-01f, -1.32325697e+00f, 5.04781663e-01f, -6.90441966e-01f, -8.82156312e-01f, -7.09644675e-01f,
  5.33778727e-01f, 5.25155544e-01f, -6.84846759e-01f, 9.13983643e-01f, 6.61160052e-01f, 6.60435498e-01f, -9.16175783e-01f, -6.64830267e-01f, 1.23683536e+00f, -5.25423706e-01f,
  -1.64995730e+00f, 1.60087705e-01f, -1.10654704e-01f, -9.96583939e-01f, -7.56137669e-01f, -1.31731606e+00f, 9.83621001e-01f, -8.95387888e-01f, 3.84627692e-02f, -9.45510685e-01f,
  2.05686223e-02f, 1.72044182e+00f, 3.74613225e-01f, -6.13673210e-01f, -5.92743754e-01f, 8.94202948e-01f, -2.28121623e-01f, -3.86550397e-01f, -1.17206025e+00f, 9.35630739e-01f,
  2.09618732e-01f, 4.29805964e-01f, 2.84950167e-01f, 1.21160460e+00f, -1.00212443e+00f, -6.86662018e-01f, 1.21404946e+00f, 8.41695011e-01f, -1.69956625e+00f, 1.19422519e+00f,
  -1.18506980e+00f, -7.84085035e-01f, -1.33962023e+00f, -4.55047369e-01f, 7.48424292e-01f, -8.35401654e-01f, -7.18315661e-01f, -1.81410074e-01f, 3.50908399e-01f, -5.00534356e-01f,
  -1.21322405e+00f, 7.07904875e-01f, -6.52949631e-01f, -1.08923137e+00f, -1.29492629e+00f, -1.10629153e+00f, -1.09693348e+00f, -7.11388767e-01f, 1.16353802e-01f, 3.18100810e-01f,
  4.78069216e-01f, 1.21013653e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.16452533e-01f, -2.63598055e-01f, -3.82777154e-01f, -3.92528996e-02f, 7.74135530e-01f, 6.55485868e-01f, -6.18946671e-01f, -7.85634518e-01f, 2.69044071e-01f, -4.99059379e-01f,
  1.71217173e-01f, -9.56597328e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    