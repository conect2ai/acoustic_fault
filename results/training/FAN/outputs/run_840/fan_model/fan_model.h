/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.88209221e-01f, -1.85232043e-01f, -3.17322552e-01f, 1.24443308e-01f, -6.40813215e-03f, 9.19217691e-02f, 2.09789410e-01f, 2.42649570e-01f, 1.18205599e-01f, 2.46292657e-05f,
  -3.82021815e-02f, 1.38008986e-02f, -1.54572502e-02f, 2.87092254e-02f, 1.33064583e-01f, -9.25621614e-02f, -2.35046208e-01f, -7.87967667e-02f, 2.44661331e-01f, 2.45734215e-01f,
  1.69224441e-01f, 1.39474437e-01f, 9.36963335e-02f, 8.44148621e-02f, -1.14978261e-01f, 3.19756083e-02f, -1.85341254e-01f, -8.85167047e-02f, -1.70703158e-01f, -3.95614207e-01f,
  -3.77345532e-01f, -1.65003359e-01f, 7.31979758e-02f, 7.27021769e-02f, -1.28333718e-01f, -2.94712689e-02f, -3.64815928e-02f, -5.46729341e-02f, -3.12311091e-02f, -4.14267629e-02f,
  -9.58906487e-02f, -1.27143841e-02f, -9.00535360e-02f, -9.45067778e-02f, -4.56423461e-02f, -1.88960265e-02f, 2.27738172e-02f, -4.36671562e-02f, 7.21238777e-02f, -4.83580381e-02f,
  -1.22960974e-02f, -9.19991955e-02f, -1.10574089e-01f, 4.40877602e-02f, 1.59478448e-02f, -3.79772931e-02f, -8.17081332e-02f, 4.64901365e-02f, -5.92756644e-02f, -9.30993631e-03f,
  1.48161456e-01f, -9.84282792e-02f, 1.54357348e-02f, 6.80044740e-02f, 8.83041397e-02f, 1.63305178e-02f, -5.76041378e-02f, -2.53984537e-02f, 3.44657749e-02f, 4.73298971e-03f,
  6.26367405e-02f, -3.59546253e-03f, -4.84484364e-04f, -5.73536344e-02f, -1.09767830e-02f, -6.46958500e-02f, -1.65975448e-02f, -6.74914848e-03f, -4.75845188e-02f, 1.81118734e-02f,
  7.63513322e-04f, 5.34954574e-03f, -8.40233564e-02f, -4.31916155e-02f, -4.97498969e-03f, -4.88330349e-02f, 9.25308093e-03f, 7.23380148e-02f, 4.38470803e-02f, 5.28026149e-02f,
  1.80052906e-01f, 4.56688441e-02f, -4.03255075e-02f, 1.94149930e-02f, -3.48101370e-02f, -1.72957163e-02f, -5.28479032e-02f, -5.44247776e-02f, -5.40427640e-02f, -4.81604133e-03f,
  1.52520521e-03f, 9.66876969e-02f, -6.94660889e-03f, 7.26144612e-02f, 8.60110000e-02f, 5.86933531e-02f, 2.64059436e-02f, 3.92341502e-02f, -8.10361560e-03f, -7.24564120e-02f,
  8.82874653e-02f, 1.36590391e-01f, 3.68347839e-02f, -3.38716875e-03f, 2.96681337e-02f, 7.42757320e-02f, 4.76524122e-02f, 1.46534471e-02f, 9.90283862e-02f, 2.37522870e-01f,
  -2.99465626e-01f, -8.10047984e-02f, -1.77706540e-01f, 1.50878325e-01f, 1.63090318e-01f, 5.17158695e-02f, -1.19811438e-01f, -2.38153860e-02f, 9.30081010e-02f, 8.42281505e-02f,
  3.41968611e-02f, -5.98640405e-02f, -6.21552654e-02f, -1.15539826e-01f, -2.18747735e-01f, -1.47128537e-01f, -8.00356120e-02f, -1.54791310e-01f, -2.65263528e-01f, -2.98017506e-02f,
  2.08085150e-01f, 1.29037771e-05f, -9.16411057e-02f, 7.36749172e-02f, 3.09460223e-01f, -5.57333305e-02f, 1.29287153e-01f, 1.16343103e-01f, 3.55722830e-02f, 2.00876638e-01f,
  -7.83505961e-02f, 1.10216305e-01f, -7.28787854e-02f, -4.08107676e-02f, 4.87843342e-02f, -3.59817594e-02f, -2.41591409e-01f, 7.84308743e-03f, 1.40287383e-02f, -1.17537297e-01f,
  4.44387309e-02f, -4.79671396e-02f, -4.25015055e-02f, -3.44678871e-02f, 1.16520887e-02f, -7.60854862e-04f, 5.14471270e-02f, 3.58357839e-02f, -8.60314220e-02f, 2.79501304e-02f,
  3.93593907e-02f, 1.39560699e-01f, 1.07019767e-01f, 9.53629166e-02f, -5.88931106e-02f, -4.90963599e-03f, 1.61629319e-02f, 2.66791843e-02f, 1.89332087e-02f, 3.58672589e-02f,
  3.52824703e-02f, -1.17649976e-02f, 9.18035954e-02f, -6.98281303e-02f, -3.51049565e-02f, 2.66096704e-02f, 2.43854523e-02f, 1.98005396e-03f, -3.65737863e-02f, -3.55015695e-02f,
  -1.68801509e-02f, -6.23801425e-02f, 2.54918747e-02f, -4.69535124e-03f, 2.45808307e-02f, 1.16133280e-01f, -4.32548635e-02f, 1.29760858e-02f, 2.40610391e-02f, 1.34183811e-02f,
  4.30035815e-02f, -5.54527231e-02f, -6.15803106e-03f, 1.53165190e-02f, 4.68531102e-02f, 1.37633597e-02f, 5.48854843e-02f, 8.52344632e-02f, -1.13965413e-02f, 1.00735771e-02f,
  -1.18733108e-01f, -3.99687588e-02f, -7.10766912e-02f, 5.41956760e-02f, 5.59312366e-02f, -3.23905833e-02f, 9.92393680e-03f, -4.45184931e-02f, -6.98407413e-04f, -6.69065583e-03f,
  -1.04318798e-01f, -5.25909886e-02f, 1.10913552e-02f, -3.99910882e-02f, -5.27201854e-02f, 1.58336908e-02f, 4.15604189e-02f, -6.97589368e-02f, 1.83030926e-02f, -1.44139696e-02f,
  -9.60614085e-02f, -6.98476508e-02f, -8.10857937e-02f, -1.27627999e-02f, 6.54763356e-02f, -9.15676355e-02f, -4.67235297e-02f, -2.01682728e-02f, -1.55413970e-01f, -2.51772881e-01f,
  2.61035740e-01f, 1.13950364e-01f, -7.19921589e-02f, -3.71703692e-03f, 2.70113051e-02f, 5.61887622e-02f, 1.23096250e-01f, -1.34166062e-01f, -1.07006028e-01f, 2.47257426e-02f,
  -2.01928206e-02f, 6.76361769e-02f, -5.39259650e-02f, 5.94982170e-02f, 1.40421912e-01f, 1.30034596e-01f, 1.92763001e-01f, 8.07823241e-02f, 4.82098497e-02f, 5.90229295e-02f,
  -3.94912763e-03f, 3.15694734e-02f, 2.25926470e-02f, -9.46461186e-02f, 2.60967780e-02f, -6.49526119e-02f, -1.35398611e-01f, -2.51360498e-02f, -1.07065607e-02f, 2.68841177e-01f,
  5.51031344e-03f, 1.98398586e-02f, -8.69954452e-02f, 7.72162154e-02f, -9.09607336e-02f, 1.51167614e-02f, -1.22947292e-02f, -7.20508918e-02f, -4.49014679e-02f, 6.32220060e-02f,
  1.38545379e-01f, -5.13067516e-03f, 4.83991206e-02f, -6.13508634e-02f, -1.64974052e-02f, -9.38917622e-02f, -6.46455213e-03f, -3.13941427e-02f, 5.77657484e-02f, -1.05024382e-01f,
  8.62800181e-02f, 1.22416124e-01f, 6.31048679e-02f, -2.02771947e-01f, -2.51919720e-02f, 1.04483269e-01f, 2.97541078e-02f, 1.22052096e-02f, -4.52373289e-02f, 5.78025207e-02f,
  -8.80837515e-02f, 3.34429517e-02f, 7.87850097e-02f, 3.34033445e-02f, 1.21576823e-02f, -5.38161471e-02f, 1.12097047e-01f, 2.12051417e-03f, -7.72413835e-02f, -1.25563359e-02f,
  8.13313574e-03f, -2.59061679e-02f, -6.27188459e-02f, -9.94514674e-03f, -3.24109085e-02f, 1.82429329e-03f, 4.75812443e-02f, 7.07233325e-03f, -2.69498490e-02f, -9.89447534e-02f,
  3.57593708e-02f, -1.73211808e-03f, -6.61124215e-02f, -1.28631853e-02f, -3.99531040e-04f, 1.52674317e-02f, -4.69191410e-02f, -2.49545164e-02f, -8.61490443e-02f, -2.03847755e-02f,
  -1.85889840e-01f, -8.13963637e-02f, 9.77605805e-02f, 6.75773695e-02f, -4.39536646e-02f, -1.69433951e-02f, -3.15588750e-02f, 2.12843474e-02f, 1.81247443e-02f, -2.58513652e-02f,
  -3.20653617e-02f, 3.79317403e-02f, 2.49909908e-02f, -4.41046543e-02f, 2.49423347e-02f, -5.79672717e-02f, -3.26359458e-02f, 2.07168162e-02f, -3.09310276e-02f, -1.82769094e-02f,
  1.19620021e-02f, -1.04049677e-02f, -4.14730096e-03f, 1.05630269e-03f, -1.18814908e-01f, 1.35097325e-01f, -7.36087654e-03f, -2.88055167e-02f, -1.36281364e-02f, -8.85816887e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.05969052e-03f, -6.61866739e-02f, -3.01430207e-02f, 5.07249273e-02f, -6.04223236e-02f, -1.07621308e-02f, -6.24640360e-02f, 1.79489069e-02f, 3.85550149e-02f, 2.41700895e-02f,
  -1.61821526e-02f, 8.47956166e-02f, 6.44076988e-02f, -3.45535092e-02f, -9.88934487e-02f, -7.93616101e-03f, -4.51495238e-02f, 2.53682565e-02f, 8.80742725e-03f, -1.02194026e-01f,
  -1.29944816e-01f, 4.13962156e-02f, 1.75584834e-02f, -4.93411487e-03f, 5.86847477e-02f, -1.34935100e-02f, 7.86565430e-03f, 1.02843503e-02f, -2.16307491e-02f, -3.25222798e-02f,
  1.80180594e-01f, -5.05877174e-02f, 9.10599995e-03f, -2.12639719e-02f, 6.47312850e-02f, -5.75370342e-02f, 2.85032932e-02f, -6.60419697e-03f, -8.24183822e-02f, -6.90603331e-02f,
  3.66545804e-02f, -3.88029814e-02f, 7.56873935e-03f, 4.99077737e-02f, -8.30191560e-03f, -2.37693600e-02f, -1.07356638e-01f, 5.60258552e-02f, -5.04877120e-02f, -6.46148175e-02f,
  -8.39906633e-02f, -8.64570364e-02f, 4.56764102e-02f, -4.68933396e-02f, -8.97227526e-02f, 1.68800587e-03f, 5.34729920e-02f, 3.95476446e-03f, -7.64233097e-02f, 2.84973346e-03f,
  1.38634844e-02f, 8.38473439e-02f, -6.82883756e-03f, -7.54652396e-02f, 2.77159475e-02f, 4.28306963e-03f, -6.57116100e-02f, -6.81887418e-02f, -1.57463029e-02f, 2.02470757e-02f,
  8.69373605e-02f, -1.35436170e-02f, 9.72366799e-03f, -1.59968087e-03f, 5.34236208e-02f, 6.39533550e-02f, -6.46866346e-03f, -5.58799021e-02f, -5.27088866e-02f, -4.06455956e-02f,
  -2.44682021e-02f, -7.65794814e-02f, 1.14421017e-01f, -8.18749368e-02f, -9.67846811e-02f, -3.28643769e-02f, -5.45756668e-02f, -8.21258649e-02f, 9.96568576e-02f, -2.54949648e-02f,
  6.27450198e-02f, -2.69891378e-02f, 4.28000279e-02f, -8.51222575e-02f, -3.08568329e-02f, -5.73464483e-02f, 1.64473541e-02f, -1.16464354e-01f, -9.41613838e-02f, 9.32110287e-03f,
  8.86002835e-03f, 3.43143307e-02f, 4.53245901e-02f, 7.94567913e-02f, -1.17083034e-02f, -8.36946070e-02f, 2.07439344e-02f, -2.21496131e-02f, -5.19488268e-02f, 8.23782459e-02f,
  -4.35563847e-02f, -3.18028331e-02f, 2.63337232e-02f, -3.52694467e-02f, 8.67485106e-02f, -7.57607520e-02f, 7.08136708e-02f, -3.54437670e-03f, 2.12501804e-03f, -5.34815080e-02f,
  5.90840399e-01f, 3.63712870e-02f, 1.04315624e-01f, 5.50197065e-02f, -2.10585043e-01f, -1.34595871e-01f, -1.57013476e-01f, -3.83455046e-02f, 1.06114205e-02f, 1.11691002e-02f,
  -3.60549539e-02f, 1.13467172e-01f, 1.04237996e-01f, 4.43224609e-02f, 2.20364735e-01f, 7.95566663e-02f, -1.99963562e-02f, 2.03323364e-01f, 2.12439090e-01f, -7.14880899e-02f,
  2.24183244e-03f, -5.81232868e-02f, 5.81382737e-02f, -4.21573548e-03f, 3.18295620e-02f, -5.36586717e-02f, -3.06082349e-02f, -7.77336806e-02f, -2.49561202e-02f, 1.56423777e-01f,
  9.35246795e-02f, 9.14147645e-02f, 4.91549224e-02f, 1.73023473e-02f, -9.86478925e-02f, 3.51439603e-02f, 2.80672740e-02f, 6.49270117e-02f, -1.48192775e-02f, -3.61338370e-02f,
  -7.88684487e-02f, -2.26836465e-02f, 1.91131923e-02f, -6.50635287e-02f, -5.82315139e-02f, 5.33494242e-02f, 3.82751860e-02f, 1.97794333e-01f, 1.22960985e-01f, 1.20842986e-01f,
  -3.41335721e-02f, -1.13075115e-01f, -7.52085969e-02f, 1.16111180e-02f, 1.66148514e-01f, -2.47378461e-02f, -1.13132447e-01f, 5.59939742e-02f, 9.00577083e-02f, 8.22879747e-02f,
  5.39873503e-02f, 4.06685509e-02f, -3.15068252e-02f, -4.15174291e-02f, -3.98067422e-02f, 6.96258098e-02f, 5.38087599e-02f, -2.01886687e-02f, 3.79681252e-02f, 5.55853508e-02f,
  -7.72627294e-02f, 7.73041770e-02f, 2.13084593e-02f, 6.72698840e-02f, 9.76328477e-02f, 7.19213709e-02f, 2.74900422e-02f, -2.96044350e-03f, 3.86984125e-02f, -1.74285173e-02f,
  -3.72803248e-02f, 1.09947594e-02f, -4.85415459e-02f, 7.93459937e-02f, -2.16119476e-02f, 2.92963218e-02f, -2.48466004e-02f, 1.10457381e-02f, -7.84175470e-03f, 2.14861222e-02f,
  -1.72934800e-01f, 4.13600318e-02f, 3.80242579e-02f, 1.13928663e-02f, -1.89202204e-02f, 1.65279047e-03f, 3.27077284e-02f, -9.42227915e-02f, -1.37990221e-01f, 1.85882542e-02f,
  -1.10002290e-02f, 1.14161730e-01f, 3.95177081e-02f, -7.39073083e-02f, 2.15101223e-02f, 4.30503674e-02f, -2.61853188e-02f, 3.78259458e-02f, 5.56233451e-02f, 3.21541540e-03f,
  5.48872538e-02f, -3.54517996e-02f, 2.04876205e-03f, -7.31089935e-02f, 7.26699531e-02f, -6.31105667e-03f, -5.25011271e-02f, 3.84016335e-02f, 6.78193420e-02f, -7.68054649e-02f,
  6.67157099e-02f, -4.44330901e-01f, -2.77813107e-01f, -4.56134863e-02f, -3.60006452e-01f, -9.15717036e-02f, -2.33226135e-01f, -1.60391554e-02f, -2.93650925e-02f, -2.54548103e-01f,
  -1.72971070e-01f, 1.77450791e-01f, 1.44149274e-01f, 9.99130383e-02f, 1.11993141e-01f, -2.45668977e-01f, -1.60148352e-01f, 2.31625326e-02f, 1.63602650e-01f, -1.20632224e-01f,
  -7.40981773e-02f, -1.81560870e-02f, 1.09940507e-01f, 7.62952343e-02f, -2.96477675e-01f, -1.09171726e-01f, -1.48632944e-01f, -7.87268132e-02f, -2.33742535e-01f, -3.85152519e-01f,
  -1.72014475e-01f, 8.15842748e-02f, 7.88614526e-02f, 1.65483225e-02f, -7.73448274e-02f, -1.96110699e-02f, -3.85155119e-02f, -2.10876707e-02f, -5.46478778e-02f, -7.45712593e-02f,
  -1.95495784e-02f, 4.62188199e-02f, 4.39227261e-02f, 9.76128355e-02f, 3.31940725e-02f, 3.51212882e-02f, -2.39116997e-02f, 1.36464322e-02f, -1.12898415e-02f, -2.30248179e-02f,
  -1.23009242e-01f, 4.32513014e-04f, -1.80647001e-02f, -8.01659077e-02f, 3.55435070e-03f, -6.79960242e-03f, -5.71689047e-02f, -1.27331674e-01f, -1.10687383e-01f, -1.95736989e-01f,
  -8.18785876e-02f, 3.76193300e-02f, 8.11240679e-05f, -9.56394896e-02f, -5.53565435e-02f, 3.35954055e-02f, -1.69547077e-03f, -5.67554124e-02f, 3.40027735e-02f, 2.35090032e-02f,
  -3.90278436e-02f, 2.54774913e-02f, 3.24300043e-02f, 1.36716729e-02f, 2.32416019e-02f, 3.85013074e-02f, 4.60662544e-02f, 3.46955773e-03f, 2.52154544e-02f, 7.50923948e-03f,
  7.18391687e-02f, -3.34792919e-02f, 4.74383794e-02f, 8.49928856e-02f, -3.27292308e-02f, -4.88263965e-02f, 6.22528046e-02f, 6.25616983e-02f, -2.68570445e-02f, -4.94155623e-02f,
  -1.34700537e-02f, 2.12150335e-01f, -8.31587166e-02f, 1.27538085e-01f, -2.02614572e-02f, 1.78606864e-02f, 2.69335303e-02f, 5.22206873e-02f, 1.74281657e-01f, -6.93980455e-02f,
  5.09318896e-02f, 5.11220880e-02f, -2.31629852e-02f, -5.80325015e-02f, 3.24309282e-02f, -4.52492423e-02f, -7.60786012e-02f, -4.05745059e-02f, -1.95987057e-02f, 1.57927144e-02f,
  -6.98677599e-02f, 1.67967193e-02f, 7.83225670e-02f, 5.11137024e-03f, -8.56476203e-02f, 5.18255420e-02f, -7.39736781e-02f, -5.45372767e-03f, 3.02234367e-02f, -2.07790807e-01f,
  -8.17880854e-02f, -1.01079650e-01f, 1.11259073e-01f, -8.38215053e-02f, -3.33586484e-02f, 4.87335473e-02f, -7.59926811e-02f, -3.81941721e-02f, 7.84328207e-02f, -9.81037766e-02f,
  2.66254600e-02f, 1.43101826e-01f, 1.46008387e-01f, 1.44143283e-01f, 1.07135452e-01f, -7.37144649e-02f, 4.32257599e-04f, 3.34807076e-02f, 2.08387733e-01f, 2.59708911e-02f,
  -1.83772631e-02f, -1.11888602e-01f, -2.24671066e-02f, 1.77340694e-02f, -8.37174281e-02f, 1.86811108e-02f, 4.95574661e-02f, 1.97076574e-02f, 1.59120914e-02f, 6.47409493e-03f,
  1.53493673e-01f, -2.25250140e-01f, -7.92958662e-02f, -3.66990343e-02f, -6.11870959e-02f, -5.20189824e-05f, 5.52548245e-02f, -8.42698216e-02f, -1.24924872e-02f, 2.58414317e-02f,
  3.21124047e-02f, -5.80237992e-02f, 3.90621349e-02f, -4.73691784e-02f, -4.70094457e-02f, -5.43754809e-02f, -1.17340676e-01f, -5.11006378e-02f, 2.49877479e-02f, 3.42044607e-02f,
  -3.65001522e-02f, -1.23451389e-01f, 3.01092379e-02f, 5.72812818e-02f, -6.07278347e-02f, -2.50753537e-02f, -1.04995675e-01f, -1.47337131e-02f, 3.71337831e-02f, -1.15597218e-01f,
  8.73119608e-02f, 1.01423055e-01f, 1.12872040e-02f, -2.50960886e-03f, -4.71084118e-02f, 3.96479145e-02f, 3.19086481e-03f, -2.83475919e-03f, 9.13828462e-02f, 5.68386726e-02f,
  3.55042256e-02f, 4.33177277e-02f, -5.15788309e-02f, 3.10929958e-02f, 5.16988635e-02f, 7.79466555e-02f, 5.55294491e-02f, -7.77436122e-02f, -1.20295938e-02f, -1.30666085e-02f,
  9.48372334e-02f, -6.09554760e-02f, 5.50877787e-02f, 9.19465050e-02f, -3.29346880e-02f, 9.00408104e-02f, -1.88611243e-02f, -3.67342047e-02f, 7.74964541e-02f, 8.15757923e-03f,
  7.77378082e-02f, 4.86622471e-03f, 6.83938339e-02f, -5.07713482e-02f, 4.50234190e-02f, 4.31862846e-02f, -6.49496242e-02f, -7.21761435e-02f, -4.92603891e-02f, 6.57808781e-02f,
  -6.47700652e-02f, 4.21261117e-02f, 5.73876314e-02f, 2.35538464e-02f, -2.91639175e-02f, -7.86834657e-02f, 2.69132517e-02f, -1.17483111e-02f, 3.92669104e-02f, 2.78334096e-02f,
  -1.07642738e-02f, -9.30226296e-02f, 1.06097069e-02f, -4.19512503e-02f, -3.44971754e-02f, 9.10363793e-02f, 6.93104118e-02f, -5.77218495e-02f, 6.96015731e-02f, 2.83711925e-02f,
  -1.75032020e-01f, -2.04018027e-01f, 1.90992970e-02f, 2.92541772e-01f, 3.30550879e-01f, 1.44044563e-01f, 8.05690736e-02f, 1.03900991e-01f, 1.01729929e-01f, 1.22655164e-02f,
  -1.29634753e-01f, 1.10275811e-02f, -6.56652004e-02f, -9.33318362e-02f, 4.69979271e-03f, 1.25933349e-01f, 3.57522637e-01f, 8.67004171e-02f, 4.84371670e-02f, 1.51047319e-01f,
  2.07875833e-01f, 1.04998268e-01f, -2.38975640e-02f, 8.34955275e-02f, 8.47611129e-02f, 1.49048403e-01f, 2.17149090e-02f, 6.04711995e-02f, 7.92597607e-02f, 2.02096060e-01f,
  -6.31690323e-02f, -9.25492216e-03f, 5.59716225e-02f, 5.06541319e-02f, -1.33305728e-01f, -1.33560076e-01f, 3.65291610e-02f, 2.11553536e-02f, -2.86842864e-02f, 1.72151614e-03f,
  5.29598258e-02f, 2.86981668e-02f, -6.82950951e-03f, -6.41848296e-02f, -6.30835071e-02f, 2.05183700e-02f, -8.11510906e-02f, -9.06155109e-02f, -3.37702483e-02f, -9.18876473e-03f,
  3.77536863e-02f, -3.09674665e-02f, -6.82926401e-02f, -3.48055772e-02f, 6.54913078e-04f, 3.86896282e-02f, -1.53381988e-01f, -7.63089061e-02f, -4.34729792e-02f, -4.98939715e-02f,
  4.70547639e-02f, -6.68023080e-02f, 7.35250255e-03f, -7.10963905e-02f, -6.02622032e-02f, 4.29398194e-02f, 7.33854771e-02f, 4.44849469e-02f, -4.44586203e-02f, -5.71879409e-02f,
  -7.28543336e-03f, -2.10102703e-02f, 1.41075952e-02f, 9.91452672e-03f, 7.33612850e-03f, 4.88991067e-02f, -4.19229902e-02f, -1.03386790e-01f, 1.30320841e-03f, -5.50387949e-02f,
  -1.33859115e-02f, 4.10603583e-02f, -2.44278014e-02f, -3.01807281e-02f, -6.45355042e-03f, -1.81313083e-02f, 6.01911247e-02f, 3.09193012e-04f, -7.17856660e-02f, -2.07464658e-02f,
  4.31045666e-02f, -1.94243565e-01f, 5.64947501e-02f, -3.04656252e-02f, 1.16766572e-01f, -8.55645090e-02f, 5.00997109e-03f, -2.14787014e-02f, 7.64904097e-02f, -8.04254711e-02f,
  -7.27277771e-02f, -2.20327321e-02f, -4.20945585e-02f, -1.06991362e-03f, 3.08399871e-02f, -3.95815633e-02f, -3.26518379e-02f, 8.33843499e-02f, 5.35873547e-02f, 4.11010860e-03f,
  7.12047666e-02f, 8.12496021e-02f, 9.32267532e-02f, 3.53915505e-02f, 5.06716073e-02f, -3.75389191e-03f, 4.28333282e-02f, 1.19459972e-01f, 4.38971743e-02f, 9.30657908e-02f,
  7.52757251e-01f, 1.21631734e-01f, 3.78871053e-01f, 1.92521915e-01f, 3.10783461e-03f, 2.42890269e-01f, 3.20923150e-01f, 5.81590682e-02f, -8.44705328e-02f, 5.12806624e-02f,
  -1.47961110e-01f, -2.69145459e-01f, -1.41596138e-01f, -1.93275243e-01f, 1.03143133e-01f, 1.31757945e-01f, 4.34564464e-02f, 2.14558646e-01f, 1.36273116e-01f, 8.09560567e-02f,
  -1.66262358e-01f, 1.55292014e-02f, 1.65286958e-01f, 1.13746570e-02f, 3.99229117e-02f, -5.87323308e-02f, 2.61081047e-02f, 6.36042655e-02f, -9.71388910e-03f, -1.38386218e-02f,
  8.12079683e-02f, 2.74696738e-01f, -1.45434946e-01f, -1.50553763e-01f, -6.27644137e-02f, 1.62891671e-03f, -2.62289345e-02f, -5.10678776e-02f, 4.92640212e-02f, -3.82516235e-02f,
  -1.21903859e-01f, -4.03361917e-02f, -3.58578600e-02f, -1.39083713e-01f, 3.48697938e-02f, 1.08619504e-01f, -8.65732282e-02f, 9.59030911e-02f, -3.79233360e-02f, 4.62886877e-02f,
  -2.11795643e-01f, 4.97061014e-02f, 1.53241813e-01f, 1.32428133e-03f, 1.18830323e-01f, 3.36308442e-02f, 6.62640855e-02f, -1.59143712e-02f, 1.00260794e-01f, -3.65016563e-03f,
  1.54773495e-03f, 2.54639890e-02f, 4.95801382e-02f, -8.57375339e-02f, 3.78633700e-02f, -8.93297344e-02f, -7.16622770e-02f, -6.69211075e-02f, 3.26491594e-02f, -1.53403152e-02f,
  2.50145327e-03f, -2.28103288e-02f, 1.34984674e-02f, 6.26310334e-02f, -6.71282262e-02f, 4.32368368e-03f, -3.38716134e-02f, -1.99150797e-02f, 3.48121673e-02f, -5.86086288e-02f,
  -2.31056698e-02f, 8.89386609e-03f, 7.18384758e-02f, -7.38356411e-02f, 6.08533546e-02f, 2.58306181e-03f, -1.51881268e-02f, -1.13709942e-01f, -3.11372802e-02f, 4.21034433e-02f,
  -1.65337816e-01f, -8.68094638e-02f, -6.16587624e-02f, -3.27931298e-03f, 4.36372459e-02f, -9.20071453e-02f, -7.67886126e-03f, -2.32196618e-02f, 2.94510908e-02f, -4.77310590e-04f,
  -3.69954258e-02f, 1.96550395e-02f, 2.90282518e-02f, 4.98148017e-02f, -2.91166063e-02f, 6.35949615e-03f, -1.19380064e-01f, 1.04416292e-02f, -1.42869771e-01f, 2.38635764e-02f,
  -1.12808272e-01f, -1.78824924e-02f, 1.12725440e-02f, -4.69004959e-02f, -8.58748108e-02f, -1.00301318e-01f, 2.60612331e-02f, -9.50628612e-03f, 2.83146575e-02f, -4.39138487e-02f,
  -1.55615866e-01f, 1.02742292e-01f, 8.68336111e-03f, -3.58170643e-02f, 1.71461761e-01f, 1.08852051e-01f, 1.46823868e-01f, 3.99095044e-02f, 1.14791043e-01f, -3.10291201e-02f,
  1.40249254e-02f, -4.17374894e-02f, -1.83732018e-01f, -2.03482956e-01f, -2.85820842e-01f, -8.76497477e-02f, -1.26074180e-01f, -3.23120207e-01f, -3.59065235e-01f, 1.07051224e-01f,
  9.75766927e-02f, -1.21161655e-01f, -2.96530128e-01f, -1.87404260e-01f, 1.71990842e-02f, -2.29990631e-01f, -1.95469171e-01f, -9.77211520e-02f, -1.18985109e-01f, -1.40439361e-01f,
  -5.60132489e-02f, 1.66905910e-01f, 5.69984056e-02f, 1.99746154e-02f, 5.05775176e-02f, 2.15995386e-02f, 9.04643983e-02f, 1.06379380e-02f, -3.62075842e-03f, -5.09284576e-03f,
  7.23454952e-02f, 1.57658055e-01f, 5.52406907e-02f, -4.04303372e-02f, -4.55271155e-02f, -4.41061407e-02f, -7.20518231e-02f, -1.64710119e-01f, -6.34149089e-03f, 1.17306389e-01f,
  -6.62986282e-03f, -7.31689632e-02f, -1.23855531e-01f, 1.60077978e-02f, -3.18951979e-02f, -4.06962596e-02f, 6.74758777e-02f, -2.04269588e-02f, 1.04372958e-02f, -7.63715878e-02f,
  -8.54857266e-02f, 1.07703611e-01f, 1.31268173e-01f, 5.72270490e-02f, -3.32063325e-02f, 5.66732511e-02f, -4.27857824e-02f, -6.64578751e-02f, -8.56978074e-02f, -6.81540603e-03f,
  1.06759354e-01f, 4.36854623e-02f, -3.66732627e-02f, -7.60831684e-03f, -6.39542341e-02f, -8.73867124e-02f, 5.45392111e-02f, -1.53851390e-01f, -7.84622319e-03f, -5.45395203e-02f,
  -9.86098945e-02f, -4.66830060e-02f, 1.99193452e-02f, -5.82382157e-02f, 1.13150924e-02f, -9.78257507e-02f, -1.70401651e-02f, 5.09168627e-03f, 3.09479721e-02f, -3.31501593e-03f,
  -1.70277983e-01f, -6.96758628e-02f, 3.58750182e-03f, -5.42908944e-02f, -6.43380880e-02f, 6.48511667e-03f, 5.67132942e-02f, 1.95536111e-02f, 9.79206041e-02f, 1.54412317e-03f,
  3.02360975e-03f, 5.63416705e-02f, -1.20698125e-03f, 1.39522687e-01f, 2.83310525e-02f, -5.65240122e-02f, -3.70084308e-02f, -1.00711562e-01f, -5.97459413e-02f, 1.28283381e-01f,
  -2.63783541e-02f, -2.10816801e-01f, -2.29853928e-01f, -1.58422440e-02f, 3.00786868e-02f, -1.90377712e-01f, -1.69553459e-01f, -9.07187760e-02f, -1.45685747e-01f, -2.04588965e-01f,
  -5.80659509e-01f, -1.25319749e-01f, 2.58618832e-01f, -3.06079775e-01f, -9.39821005e-02f, 1.14541404e-01f, 1.81787401e-01f, -8.88230801e-02f, -1.47586033e-01f, 3.19150314e-02f,
  -7.47676045e-02f, -3.65110785e-02f, 4.78834286e-02f, 5.99755498e-04f, -4.73485095e-03f, 1.04802467e-01f, 7.65348300e-02f, 1.05646089e-01f, 4.80265543e-02f, 1.13462098e-01f,
  -2.04892829e-02f, -1.32538989e-01f, -1.40851006e-01f, -1.00002170e-01f, 7.56616378e-03f, 1.15984917e-01f, -6.40996546e-02f, -4.38676495e-03f, 6.83337497e-03f, 2.61504482e-02f,
  6.16143644e-01f, -1.37657970e-01f, 6.87433854e-02f, -2.45129973e-01f, -5.32598123e-02f, 2.36111563e-02f, 1.73832595e-01f, 6.20847605e-02f, -1.00449890e-01f, 2.68009510e-02f,
  -4.57686186e-03f, -1.54079229e-03f, -4.68733534e-02f, 6.25363365e-02f, -2.40468942e-02f, -3.33147608e-02f, -1.23382047e-01f, 2.15465873e-02f, -2.93470751e-02f, 5.37244342e-02f,
  -4.34772447e-02f, 8.65630209e-02f, 6.80812299e-02f, 1.38283893e-01f, -3.92985530e-03f, 2.77715009e-02f, 2.07762331e-01f, 2.91645117e-02f, 1.83306411e-02f, -3.73208262e-02f,
  3.64715420e-02f, 2.04350222e-02f, 1.37917511e-02f, 7.34474212e-02f, -9.56266075e-02f, -9.23507661e-03f, 2.16587130e-02f, 2.56029610e-02f, -6.46642372e-02f, -2.39885622e-03f,
  4.49780282e-03f, -1.50619261e-02f, 1.04240417e-01f, 1.45515936e-04f, -3.18460278e-02f, 5.52849919e-02f, 3.94916832e-02f, 1.08462302e-02f, -7.50606731e-02f, -5.80329299e-02f,
  4.41615470e-02f, 2.88353991e-02f, 6.32550791e-02f, 1.99131854e-02f, 9.18275490e-02f, -4.89664450e-02f, -4.31081727e-02f, 4.44347486e-02f, -6.31409660e-02f, 3.11347786e-02f,
  1.61686018e-01f, -1.26005709e-01f, 3.66937071e-02f, -3.70387621e-02f, -5.69608063e-02f, -1.57142639e-01f, -7.82763734e-02f, -1.19447909e-01f, 2.87047005e-03f, 6.86011165e-02f,
  8.21535569e-03f, 1.03738112e-02f, 2.46683974e-02f, 2.39591580e-02f, -5.07118218e-02f, -1.64365582e-03f, -9.26783308e-02f, 7.18487846e-03f, 7.51715479e-03f, 1.14750385e-01f,
  -1.05029494e-01f, 5.29961735e-02f, 1.43384755e-01f, 8.39944258e-02f, 3.72942165e-02f, 1.01433247e-01f, 2.33040288e-01f, 1.29013672e-01f, -1.74754616e-02f, 8.00610483e-02f,
  -9.52816010e-02f, -8.49642605e-03f, -4.60740179e-02f, 1.24665983e-01f, 3.18899192e-02f, -2.79685557e-02f, -3.13526765e-02f, 6.90012053e-02f, -1.05081638e-03f, 3.52844857e-02f,
  7.18397228e-03f, 1.18076369e-01f, 8.88479352e-02f, 7.85792992e-02f, 1.78836241e-01f, 1.64461017e-01f, 2.76510954e-01f, 1.19434714e-01f, 3.32024917e-02f, -1.90869998e-02f,
  1.92851141e-01f, 8.57357234e-02f, -1.00691393e-01f, 4.70730476e-02f, 1.02994308e-01f, 1.07396409e-01f, 7.63013661e-02f, 2.52719615e-02f, 4.47418317e-02f, 1.23023897e-01f,
  -1.49374500e-01f, -2.02505112e-01f, 7.34011270e-03f, 8.29568133e-02f, -2.82298308e-02f, -1.77910607e-02f, 3.00152898e-02f, -9.20415297e-02f, -1.03450604e-01f, -4.16867854e-03f,
  -3.19666602e-02f, -5.04475124e-02f, 3.87382805e-02f, 4.19877730e-02f, -4.75304835e-02f, -1.17557459e-01f, 3.42386477e-02f, 7.44700208e-02f, -8.69084150e-02f, -8.47310126e-02f,
  -8.72526318e-03f, -2.69273967e-02f, -1.60981864e-01f, -8.43081176e-02f, -9.39531345e-03f, -6.02933727e-02f, 2.20061000e-02f, 2.07820293e-02f, -1.25134155e-01f, -1.35482952e-01f,
  3.77793722e-02f, 4.13348116e-02f, 1.76819917e-02f, 2.70636450e-03f, 2.96501238e-02f, 3.30996886e-02f, 1.96853783e-02f, 6.24019206e-02f, 4.03817296e-02f, -4.09545451e-02f,
  3.74940522e-02f, -2.55338605e-02f, -7.88280815e-02f, 9.49318185e-02f, 7.74577633e-02f, -7.57503510e-02f, 6.73859194e-02f, -2.25224178e-02f, 1.72665250e-02f, -1.03133000e-01f,
  3.76955681e-02f, -4.23589163e-02f, 4.93925326e-02f, 3.88818532e-02f, -2.68569682e-02f, -2.11192705e-02f, -5.96446171e-02f, -3.24880122e-03f, 7.92250708e-02f, -8.04760307e-02f,
  -4.81220428e-03f, -1.12076126e-01f, 4.60858569e-02f, 3.97319868e-02f, -5.52797019e-02f, -9.39452425e-02f, 2.80690342e-02f, 8.26711487e-03f, 1.82274207e-02f, 5.10938652e-03f,
  1.08122807e-02f, -5.94806112e-02f, -3.83347869e-02f, -9.33105648e-02f, 3.43866013e-02f, 3.89698916e-03f, -1.18764183e-02f, -3.06262728e-02f, -1.78789664e-02f, -1.37022972e-01f,
  -2.46081166e-02f, 2.12711524e-02f, -1.01803012e-01f, 3.24814580e-02f, -9.03491676e-02f, -5.97063936e-02f, -1.33326530e-01f, -4.20105504e-03f, -2.67506260e-02f, -1.51815951e-01f,
  1.19411670e-01f, 2.66436130e-01f, 1.64000720e-01f, -3.00168595e-03f, 2.25248232e-01f, 1.34372368e-01f, 3.40035409e-01f, 9.62567627e-02f, -1.32011995e-01f, 9.86366719e-02f,
  2.52402723e-02f, -1.25576362e-01f, -2.13955626e-01f, -9.43156108e-02f, 3.47047113e-02f, 1.34918988e-01f, -2.11459063e-02f, -1.40028903e-02f, -1.94184542e-01f, 1.80469465e-03f,
  6.47136346e-02f, 1.15339555e-01f, 7.03640804e-02f, -8.74428153e-02f, -7.72231966e-02f, -1.85017511e-01f, 2.02550273e-02f, 1.33180022e-01f, 5.52314073e-02f, -3.03210225e-02f,
  1.28258869e-01f, 3.34875733e-01f, -1.96943894e-01f, 4.30405512e-03f, 2.90329754e-02f, -1.36729360e-01f, -6.03389740e-02f, -2.21157055e-02f, -8.70948508e-02f, 3.36369984e-02f,
  3.52994241e-02f, 3.86694223e-02f, 2.73255631e-02f, 4.73212777e-03f, 4.09922823e-02f, 3.95804681e-02f, 6.74869940e-02f, 6.50251657e-03f, -1.55129731e-01f, 8.28830823e-02f,
  1.01125501e-01f, 1.83762580e-01f, 3.90085243e-02f, -3.58764715e-02f, -2.82973628e-02f, -6.83838725e-02f, 6.63747340e-02f, 9.07635093e-02f, 7.76049122e-02f, 1.75153911e-02f,
  4.66796383e-02f, -3.75525951e-02f, 6.04631491e-02f, 5.26288562e-02f, -4.18496318e-02f, 6.71584671e-03f, 3.69649450e-03f, 7.07194507e-02f, 2.99569089e-02f, 6.56894669e-02f,
  3.29998545e-02f, -3.95124126e-03f, 2.81058736e-02f, 5.21069169e-02f, 5.31715062e-03f, 1.13027200e-01f, 8.47313479e-02f, 9.11102891e-02f, -8.01701937e-03f, -3.72582711e-02f,
  1.79116651e-02f, 6.78476691e-02f, 1.06383443e-01f, 5.04166931e-02f, 3.04544950e-03f, -5.95503561e-02f, 8.53987038e-02f, 9.25014019e-02f, 6.25360832e-02f, 1.60545871e-01f,
  -7.01347515e-02f, 2.14051619e-01f, -2.94668507e-02f, -8.90639871e-02f, -4.94188182e-02f, 1.99009199e-02f, 9.72048566e-02f, -1.10569922e-02f, -1.92262344e-02f, -8.98431763e-02f,
  4.04846705e-02f, -2.19348650e-02f, 2.78268270e-02f, -2.45606769e-02f, 2.91960668e-02f, -1.13341078e-01f, -1.54680116e-02f, -5.07608838e-02f, 3.01515982e-02f, -1.05284207e-01f,
  3.22581716e-02f, -3.29247564e-02f, -4.11550403e-02f, -6.91320077e-02f, 9.56392568e-03f, -1.13920175e-01f, -1.69194639e-02f, -5.54673932e-02f, -4.77726460e-02f, -1.66571528e-01f,
  -9.86820459e-02f, -1.74477577e-01f, -5.07264696e-02f, -2.01435417e-01f, -1.24685861e-01f, 2.42454698e-03f, -3.03965267e-02f, -3.56188752e-02f, -1.42941251e-01f, -2.66810451e-02f,
  -2.09264848e-02f, -2.47054249e-02f, -9.98167247e-02f, 2.58468054e-02f, -6.10014834e-02f, -1.61620408e-01f, -7.07341135e-02f, -1.02670714e-01f, -4.63126861e-02f, 4.79676053e-02f,
  -1.23664439e-01f, -3.91633846e-02f, 2.20503602e-02f, -8.65536034e-02f, 1.41676469e-02f, -8.52029994e-02f, -2.72177141e-02f, -9.66547281e-02f, -2.73839254e-02f, -7.87987635e-02f,
  -3.57985832e-02f, 6.78732246e-02f, 1.11377135e-01f, 7.29645416e-02f, -8.41658488e-02f, 2.97640841e-02f, 2.23118160e-02f, -8.47589150e-02f, -4.67023887e-02f, 1.81399137e-02f,
  2.90272590e-02f, 3.97149846e-02f, -6.03815392e-02f, -6.32045558e-03f, -8.00659135e-02f, -4.53362726e-02f, -2.08401810e-02f, 1.27705112e-02f, -6.66451007e-02f, 4.81821448e-02f,
  -6.05214015e-03f, -6.54559210e-02f, -1.16132662e-01f, 2.52662576e-03f, 1.16131371e-02f, 1.50389923e-02f, 4.81692553e-02f, -7.49966055e-02f, 9.76011828e-02f, -1.02662578e-01f,
  -8.01367164e-02f, -4.61779088e-02f, 4.37211432e-02f, 1.75674949e-02f, 2.19097063e-02f, -7.33076185e-02f, -1.01048695e-02f, 7.92102888e-02f, -5.82471229e-02f, -2.12965198e-02f,
  1.30548310e-02f, 7.73517787e-02f, -1.15440181e-02f, -7.81852193e-03f, -5.50627671e-02f, 4.57144901e-02f, 1.82282440e-02f, -2.35616788e-02f, 1.73107013e-02f, 4.75384574e-03f,
  1.55799175e-02f, 2.73938999e-02f, -8.36993754e-02f, 7.28113204e-02f, -5.15260957e-02f, 9.59589854e-02f, -3.73765491e-02f, 1.03202783e-01f, 1.11793898e-01f, 1.12493299e-01f,
  4.97006141e-02f, 1.40223041e-01f, -8.35674703e-02f, -5.75951077e-02f, -1.42580876e-02f, 3.71980779e-02f, -4.97820154e-02f, -5.97629249e-02f, -8.78813043e-02f, -7.58655742e-02f,
  -7.50328526e-02f, 7.58747756e-02f, -9.68909264e-02f, 5.04417403e-04f, 3.47375609e-02f, -2.23574359e-02f, -7.35312030e-02f, 6.45254925e-02f, 2.86379643e-02f, 5.05217910e-02f,
  6.34555742e-02f, -4.49681981e-03f, -6.02555983e-02f, 7.06313318e-03f, -5.19298874e-02f, -5.35335205e-03f, -4.64478396e-02f, 3.16742621e-02f, -5.28711900e-02f, -5.51015735e-02f,
  -3.15816730e-01f, 1.69964917e-02f, 2.38170207e-01f, -3.16125192e-02f, 3.32020700e-01f, 4.35764462e-01f, 6.00753963e-01f, 1.57355726e-01f, -1.08493917e-01f, 4.09196168e-02f,
  -2.17068702e-01f, -2.79760659e-01f, -3.31050694e-01f, -1.83542952e-01f, 8.80802125e-02f, 2.00394377e-01f, 2.83854753e-01f, -3.47616971e-02f, 2.17803195e-02f, 1.10811464e-01f,
  8.54215696e-02f, -1.54113427e-01f, -2.01554105e-01f, -5.15318997e-02f, 3.56697142e-02f, -1.09513514e-02f, -9.14334953e-02f, -4.68440279e-02f, -5.32897003e-02f, 3.56844030e-02f,
  -5.02251051e-02f, 3.43401134e-02f, 2.97100078e-02f, -2.19500571e-01f, -8.04575277e-04f, -4.90932800e-02f, -4.46377741e-03f, -9.56959650e-02f, -9.95496362e-02f, -4.38607186e-02f,
  -3.33671197e-02f, -8.64154547e-02f, -3.39550078e-02f, 7.80451447e-02f, -3.04597784e-02f, 2.18867566e-02f, -1.17447190e-01f, -6.19021757e-03f, -1.19701147e-01f, -7.35483617e-02f,
  3.72552574e-02f, 1.40221398e-02f, 1.48492277e-01f, 1.22250818e-01f, 8.15558881e-02f, 8.44582636e-03f, 6.06583767e-02f, -2.65013538e-02f, -4.02439870e-02f, -1.30483225e-01f,
  2.19942369e-02f, -3.40652503e-02f, 1.16172232e-01f, -3.61859202e-02f, 4.41368856e-02f, -3.99909206e-02f, 2.03804504e-02f, -1.86475664e-02f, 8.55395570e-02f, 2.97734216e-02f,
  -2.19480786e-02f, 7.44598731e-02f, -2.09229207e-03f, -2.92829275e-02f, -6.50158618e-03f, 1.02995262e-01f, 9.06872079e-02f, 1.37588428e-02f, -4.37558778e-02f, 4.19247225e-02f,
  -2.70334557e-02f, 3.28127034e-02f, -1.17137447e-01f, -9.31748524e-02f, 4.29817997e-02f, 1.21414312e-03f, -1.50579726e-02f, -3.75320390e-02f, -6.89837784e-02f, -4.50709164e-02f,
  -3.68283689e-01f, 7.19772791e-03f, -7.88511336e-02f, 2.61076484e-02f, -2.54721311e-03f, -7.44329393e-02f, -6.57449439e-02f, 3.23020830e-03f, -1.53930532e-02f, -7.93617591e-03f,
  3.76477763e-02f, -5.69858514e-02f, -2.80687604e-02f, -4.22597043e-02f, 2.04636287e-02f, 7.90726915e-02f, 1.09424047e-01f, 2.93788444e-02f, -4.31902297e-02f, -7.75634348e-02f,
  -1.70009397e-02f, 3.21307965e-02f, -2.83228774e-02f, -4.89191040e-02f, -9.12070740e-03f, 6.66106911e-03f, -1.05532527e-01f, -3.49633098e-02f, 5.48683405e-02f, -4.46404703e-02f,
  -2.89978355e-01f, -4.85499129e-02f, -9.71276015e-02f, -1.10232625e-02f, 4.75724526e-02f, -2.76999432e-03f, -3.09319347e-02f, -1.32827505e-01f, -4.33285534e-02f, -5.57323694e-02f,
  9.71844047e-02f, 4.37188111e-02f, -2.10021436e-03f, -9.77538228e-02f, -8.79243612e-02f, -7.52926916e-02f, -9.71579328e-02f, -8.92004445e-02f, -5.14326952e-02f, 6.32545054e-02f,
  5.94718792e-02f, -1.17610767e-01f, -1.78597346e-01f, -8.56655613e-02f, 6.64973632e-02f, -9.76737142e-02f, -8.07231963e-02f, -1.82084665e-02f, 6.23176917e-02f, 6.63009807e-02f,
  -1.85241234e-02f, 7.41008148e-02f, 1.24467604e-01f, -3.77215743e-02f, 2.55426932e-02f, 1.98738836e-02f, -2.16004457e-02f, 1.08659696e-02f, -2.80032624e-02f, -1.05196133e-01f,
  -5.80427051e-02f, -1.81921218e-02f, 7.78264105e-02f, 3.05477418e-02f, 2.98078656e-02f, -1.03110246e-01f, 5.60494885e-03f, -4.05226974e-03f, 1.22739328e-02f, 4.46558520e-02f,
  4.11842130e-02f, -5.62606268e-02f, -1.06167272e-01f, -9.19239596e-02f, -4.11925465e-02f, -9.09151230e-03f, 2.36095507e-02f, 9.20706335e-03f, -4.07382809e-02f, -1.32819906e-01f,
  1.12409573e-02f, 1.40758399e-02f, -7.61398375e-02f, -1.34523734e-02f, -3.78638343e-03f, 5.41020855e-02f, -5.56661077e-02f, -4.30538505e-03f, 7.27764890e-02f, -4.93367016e-02f,
  1.24135608e-04f, -7.12137902e-03f, -2.55879201e-02f, -2.30029970e-02f, 6.67303801e-02f, -9.21368152e-02f, -2.00296268e-02f, -1.12938881e-01f, -1.49450153e-02f, -4.02903222e-02f,
  1.78491808e-02f, 9.08008739e-02f, 6.91534504e-02f, -9.83899683e-02f, -4.71625067e-02f, -1.37779847e-01f, 2.22999323e-02f, 4.25186753e-02f, 7.06154704e-02f, 4.29803692e-02f,
  -1.90518305e-01f, 4.94075194e-02f, -1.42022397e-03f, -2.39417665e-02f, -3.26025374e-02f, -2.16778293e-02f, 1.81906745e-02f, -7.44684786e-02f, 2.71882154e-02f, 2.12979373e-02f,
  6.08121194e-02f, -4.35136370e-02f, -1.89563222e-02f, -6.68586344e-02f, 4.01124507e-02f, -2.96908035e-03f, -6.53768927e-02f, -1.00019604e-01f, 6.57592863e-02f, 3.94934155e-02f,
  -7.83526804e-03f, -1.21570401e-01f, -3.97298150e-02f, -9.63137597e-02f, 4.84240688e-02f, -1.55678242e-01f, 2.41951179e-03f, -3.46598700e-02f, -1.40041381e-01f, -1.10621065e-01f,
  8.43641758e-02f, 1.06012160e-02f, -1.00605443e-01f, 1.82049684e-02f, -4.52331491e-02f, 1.05077801e-04f, -6.59991335e-03f, 1.28572658e-01f, -6.98941341e-03f, 5.56058101e-02f,
  -2.72220396e-03f, 1.02133960e-01f, -2.99241245e-02f, 6.27384558e-02f, -3.03839706e-02f, -5.41641489e-02f, -2.57953089e-02f, 6.02643229e-02f, 1.81673188e-02f, 4.77333330e-02f,
  4.01821546e-02f, 5.61646149e-02f, 8.73184353e-02f, -3.57253328e-02f, -4.47684862e-02f, 2.25411579e-02f, -1.06105737e-01f, -5.78630017e-03f, -1.33216113e-01f, -1.84806228e-01f,
  -8.24626982e-02f, 7.51073137e-02f, -3.22261010e-03f, 4.77939285e-02f, 2.59458367e-02f, -3.16009372e-02f, 1.00914329e-01f, 1.01627648e-01f, 8.34355503e-02f, -2.73726005e-02f,
  5.26072681e-02f, -2.92641260e-02f, 7.46950284e-02f, 8.58677179e-03f, 1.04544699e-01f, 7.69414380e-02f, 8.06856826e-02f, 3.89604904e-02f, -2.81770173e-02f, 2.14098953e-03f,
  -1.34881837e-02f, 9.20980424e-02f, -4.25063958e-03f, -2.29051989e-03f, -2.94559523e-02f, -2.94329897e-02f, 9.56865326e-02f, 4.40807864e-02f, 1.31802419e-02f, 1.05712846e-01f,
  3.38637121e-02f, 1.62691865e-02f, -6.11947924e-02f, 3.98998260e-02f, 2.71725580e-02f, -3.13816825e-04f, 6.66148812e-02f, 3.49638499e-02f, 8.07352066e-02f, -4.95135263e-02f,
  7.01329038e-02f, -6.89869821e-02f, 4.83307615e-02f, 3.96508574e-02f, 2.06618328e-02f, -1.04023233e-01f, -1.38618955e-02f, -6.13670796e-02f, 3.80626833e-03f, 5.85850095e-03f,
  1.86954660e-03f, -5.40993251e-02f, 2.88526807e-02f, -9.80028883e-03f, -1.97150018e-02f, -2.13610977e-02f, -1.78933353e-03f, -3.00119873e-02f, 6.37499243e-02f, 1.30479047e-02f,
  1.06307060e-01f, -1.57565013e-01f, -3.22261043e-02f, -8.04673135e-02f, -1.03173666e-01f, -3.35641131e-02f, 3.02013103e-02f, -5.80096282e-02f, -5.52388132e-02f, -3.15817771e-03f,
  5.18679582e-02f, -6.90385923e-02f, -2.92721596e-02f, -7.03198314e-02f, 5.52400574e-02f, -7.01387748e-02f, 3.52338441e-02f, -3.98002900e-02f, -3.00993118e-02f, -1.00422926e-01f,
  2.72412337e-02f, 3.07844225e-02f, 1.28270477e-01f, 5.94483390e-02f, -7.96034187e-02f, -8.78163800e-03f, -3.45369950e-02f, 9.18050334e-02f, 1.70550179e-02f, 9.90267396e-02f,
  -6.01416290e-01f, 1.03105411e-01f, -6.96660876e-02f, -2.57545203e-01f, 1.29953414e-01f, 2.60553449e-01f, 4.19474393e-01f, 5.06660976e-02f, -1.40274644e-01f, 1.06455080e-01f,
  8.94287601e-02f, -2.40282621e-02f, -1.32590294e-01f, 1.27827063e-01f, 7.37511665e-02f, 3.18263054e-01f, 1.64714307e-01f, -3.77067216e-02f, -1.39819533e-01f, 3.46834026e-02f,
  1.10437900e-01f, -1.40125662e-01f, -3.25045317e-01f, -1.78917155e-01f, -9.75955725e-02f, -1.06826589e-01f, -1.09610572e-01f, -7.50782341e-02f, 8.56317505e-02f, 1.62584543e-01f,
  1.00377098e-01f, -1.87818818e-02f, 1.36043921e-01f, 4.78019305e-02f, 8.03024694e-02f, -6.94420710e-02f, -8.17634282e-04f, 5.88008538e-02f, -3.46233025e-02f, 6.69985488e-02f,
  5.95160015e-03f, 3.17882486e-02f, -3.41956802e-02f, -5.98744899e-02f, -1.23051040e-01f, -3.58751602e-02f, 4.17301990e-02f, -1.31047189e-01f, 6.65872619e-02f, 1.06515957e-03f,
  1.78205326e-01f, 9.31206718e-02f, -3.80339734e-02f, 1.36872292e-01f, 1.40770644e-01f, 4.22714762e-02f, 2.02172212e-02f, -5.61174527e-02f, -1.73201282e-02f, -4.12497297e-02f,
  7.48497546e-02f, 5.58623904e-03f, 2.23284513e-02f, 1.64908860e-02f, -7.67040029e-02f, 3.79421078e-02f, -5.20316102e-02f, 5.28400093e-02f, -8.74421746e-02f, -8.52077454e-02f,
  -9.01017897e-03f, 5.54786734e-02f, 2.51844376e-02f, -1.31356180e-01f, -5.37362956e-02f, 2.84996387e-02f, -2.55549476e-02f, -1.19585600e-02f, 8.58870149e-02f, -8.63705482e-03f,
  -6.95111230e-04f, 6.89749345e-02f, -6.54090419e-02f, 3.81527394e-02f, 5.44075035e-02f, 1.17581049e-02f, -5.99109277e-04f, -2.93816943e-02f, -8.25263187e-02f, 1.21948924e-02f,
  -2.19522312e-01f, 1.63415909e-01f, -3.37530300e-02f, 6.09448820e-04f, 2.98012071e-03f, -1.48843974e-01f, -1.67646129e-02f, -7.01383501e-03f, -1.74347498e-02f, -4.72330749e-02f,
  3.36324126e-02f, -9.94460434e-02f, -9.18239448e-03f, 9.11928937e-02f, -5.39290532e-03f, -7.32011199e-02f, 4.66705225e-02f, -6.89642727e-02f, 1.75620839e-01f, 5.58977611e-02f,
  1.95330586e-02f, -1.34316168e-03f, -1.76533639e-01f, -5.91404326e-02f, -4.00627106e-02f, -8.05720314e-02f, 2.81799473e-02f, -6.74574077e-02f, -1.07902717e-02f, -2.08262265e-01f,
  1.13339514e-01f, 3.09476312e-02f, 1.26329243e-01f, 1.11564487e-01f, -1.09357268e-01f, -1.89292833e-01f, -3.12739015e-01f, -1.38059631e-01f, -1.50484042e-02f, -7.42382109e-02f,
  -1.27146706e-01f, -1.99046843e-02f, 1.65481165e-01f, 1.18963555e-01f, -3.02721858e-02f, -2.66506933e-02f, 8.05640966e-02f, 1.87788501e-01f, 2.42940299e-02f, -2.59248279e-02f,
  6.56545982e-02f, 3.20373327e-02f, 1.25842020e-01f, -5.60669340e-02f, 1.47501677e-01f, -1.89636182e-02f, -6.18821848e-03f, 1.26232907e-01f, -2.85323169e-02f, 3.53136897e-01f,
  9.40125361e-02f, -2.04965528e-02f, -3.93918268e-02f, 2.76786778e-02f, 8.44766721e-02f, -5.98047897e-02f, -2.47308761e-02f, 6.21538721e-02f, -3.48582258e-03f, -4.11045812e-02f,
  9.88051295e-02f, 3.92944999e-02f, 8.81563649e-02f, -5.20591550e-02f, -8.55078548e-02f, 7.65714608e-03f, 1.27791241e-02f, 1.48030203e-02f, -1.07154008e-02f, -1.06087081e-01f,
  3.75126228e-02f, 3.28595154e-02f, -8.73508453e-02f, -1.01866700e-01f, 3.32153849e-02f, 9.28100571e-03f, -2.24961285e-02f, -7.46631250e-02f, -1.01540387e-01f, 4.64651547e-02f,
  6.79460540e-02f, -1.13167036e-02f, -6.93688914e-03f, 6.94276467e-02f, -1.09577002e-02f, 7.89521113e-02f, 1.38474526e-02f, 1.94418672e-02f, 4.72540371e-02f, 9.42630768e-02f,
  1.26328366e-02f, 5.91529440e-03f, -8.05322081e-03f, 2.35234760e-02f, -8.31762515e-03f, 2.09093317e-02f, -1.42211351e-03f, 6.23113699e-02f, -6.65455312e-02f, 1.81269776e-02f,
  6.26150817e-02f, -3.11560016e-02f, 9.94525850e-02f, 7.54896831e-03f, 4.77641709e-02f, 1.55417966e-02f, -7.38032758e-02f, -5.50388843e-02f, -2.60550026e-02f, 1.36756608e-02f,
  -7.39574507e-02f, -1.62535504e-01f, -4.04105969e-02f, -1.57781295e-04f, -4.53527831e-02f, 7.62194768e-02f, -1.76098812e-02f, 1.41375884e-02f, -4.28963900e-02f, -3.93248610e-02f,
  -1.36831611e-01f, -3.85745540e-02f, -5.05229458e-02f, -2.43127327e-02f, 1.44794006e-02f, -1.01000294e-01f, -9.07729045e-02f, -2.33123153e-02f, -1.33543342e-01f, -1.24907777e-01f,
  -5.92487752e-02f, -1.99327409e-01f, -2.14489639e-01f, -9.65938717e-02f, -2.81086117e-02f, -1.73472419e-01f, -1.30666673e-01f, -1.66739210e-01f, -2.32713059e-01f, -1.95745736e-01f,
  -2.63200909e-01f, -2.84096509e-01f, -2.08351061e-01f, -1.46819487e-01f, -4.33479057e-04f, 6.01777844e-02f, -1.44194728e-02f, -3.80373821e-02f, -8.08346421e-02f, 1.14193466e-02f,
  8.76278952e-02f, 3.00883241e-02f, 1.65979080e-02f, -6.96457699e-02f, 3.56593318e-02f, 3.45159927e-03f, 1.66746341e-02f, -5.05319610e-02f, 2.83829253e-02f, 6.57704994e-02f,
  1.61251530e-01f, 6.97759315e-02f, 4.70968075e-02f, 6.69228137e-02f, 1.25884011e-01f, 9.76844318e-03f, 6.24158159e-02f, 1.03151917e-01f, 5.78463040e-02f, -1.09116718e-01f,
  5.29412553e-03f, -1.10547751e-01f, 5.32302968e-02f, -1.00978641e-02f, -7.36397831e-03f, -9.59704369e-02f, -7.88460113e-03f, -7.37475306e-02f, 3.42051946e-02f, -8.93442780e-02f,
  6.17321394e-02f, 2.51567550e-02f, 2.66929418e-02f, 4.37032478e-03f, -3.51722585e-03f, 6.79611834e-03f, -1.32018313e-01f, -3.53313312e-02f, -8.68742615e-02f, -5.61928861e-02f,
  -6.99116439e-02f, 3.91005762e-02f, -1.96262971e-01f, -9.11848545e-02f, 1.74018610e-02f, -4.11748737e-02f, 4.72575240e-03f, -5.26356846e-02f, -1.29059423e-02f, -1.74488693e-01f,
  1.86031852e-02f, 9.51905400e-02f, -1.87128987e-02f, -1.29732639e-01f, -3.71259786e-02f, -5.31427786e-02f, 8.24450850e-02f, 2.73114908e-02f, 2.94050239e-02f, -2.22651660e-02f,
  -2.72752568e-02f, -4.88250107e-02f, 4.19263393e-02f, -1.53963631e-02f, 3.63650247e-02f, 9.01173577e-02f, 7.55381733e-02f, -3.00884712e-03f, 3.52453850e-02f, -2.71410812e-02f,
  1.28472568e-02f, 8.23729932e-02f, -3.85507345e-02f, 1.03363186e-01f, -2.03990377e-02f, -6.37571290e-02f, -3.13321836e-02f, 2.18592901e-02f, -1.00031301e-01f, -9.23831090e-02f,
  -1.42757252e-01f, 2.41297051e-01f, -1.63931516e-03f, 7.28656948e-02f, -4.53329682e-02f, 3.14739011e-02f, -4.82804514e-02f, -1.67191625e-02f, -7.93104172e-02f, -5.58502488e-02f,
  3.72576378e-02f, 2.12903153e-02f, -1.06573798e-01f, -3.14096361e-02f, -1.19415902e-01f, -3.96127850e-02f, -7.43600950e-02f, -1.85349490e-02f, -8.25338140e-02f, -7.84151033e-02f,
  -1.98773891e-01f, -1.21216118e-01f, -2.92117119e-01f, -1.93483949e-01f, -1.15503468e-01f, -1.24285355e-01f, -5.20259552e-02f, -9.21751186e-02f, -1.70187980e-01f, -3.02228332e-01f,
  -4.51648943e-02f, 3.86788249e-02f, -1.53614487e-02f, 3.59744988e-02f, 1.04918562e-01f, -5.74071445e-02f, 1.42737748e-02f, 3.37609872e-02f, -4.66802083e-02f, 1.64822768e-02f,
  5.26756495e-02f, -5.16820699e-02f, -6.79260939e-02f, -6.71178028e-02f, -1.15200661e-01f, 7.81194493e-02f, 3.59418779e-03f, -7.78359026e-02f, -1.60916656e-01f, -5.51065877e-02f,
  -4.04873602e-02f, -5.03172167e-02f, -7.45296478e-02f, -7.36857802e-02f, 9.38026533e-02f, -2.70907953e-03f, -3.11024506e-02f, 1.26718253e-01f, 4.84175328e-03f, 2.08730120e-02f,
  -8.72069448e-02f, 1.22701516e-02f, -1.07093759e-01f, 9.74055007e-02f, -1.24367597e-02f, -4.85443771e-02f, -2.20486820e-02f, -1.05866522e-01f, -2.48608598e-03f, -8.61704350e-02f,
  -7.70521089e-02f, 6.76800236e-02f, -8.23528841e-02f, 7.25091621e-02f, -5.38005196e-02f, 6.55729622e-02f, 5.42650297e-02f, -1.39545240e-02f, -2.13933997e-02f, 3.39489840e-02f,
  1.03930175e-01f, 5.88163920e-02f, 6.11598417e-02f, 1.65024158e-02f, 1.02740275e-02f, -5.96819445e-02f, 8.50223452e-02f, 8.41836855e-02f, -4.81609330e-02f, 7.23434985e-02f,
  1.80317163e-01f, 1.98283363e-02f, 5.73898554e-02f, 4.31453660e-02f, 3.47658284e-02f, -4.47793752e-02f, 5.70532158e-02f, 7.13475347e-02f, 3.05564771e-03f, 9.50710028e-02f,
  3.45770828e-02f, 5.63862454e-03f, 3.78025584e-02f, 9.31677744e-02f, 7.28113130e-02f, 9.61982310e-02f, -1.73928589e-02f, -3.80943827e-02f, -6.13267645e-02f, 7.87999034e-02f,
  -9.54008549e-02f, 5.07922024e-02f, -7.36166164e-02f, 5.72082922e-02f, 1.21488281e-01f, 1.63392778e-02f, 1.03557939e-02f, 4.18161042e-03f, -3.69872898e-02f, 4.10510302e-02f,
  1.62765775e-02f, -4.79519032e-02f, -3.63591574e-02f, 3.77263762e-02f, 2.42189784e-02f, 9.71454307e-02f, -3.72256562e-02f, -2.06973813e-02f, 1.42626716e-02f, 7.37264976e-02f,
  -4.17723134e-02f, 6.11995645e-02f, 4.64585535e-02f, -1.79913417e-02f, -1.85172912e-02f, 4.39689308e-02f, 1.63944915e-01f, 9.58989412e-02f, -9.12478119e-02f, 4.52176072e-02f,
  3.38483974e-02f, -4.93740700e-02f, -3.68684046e-02f, -3.71890105e-02f, 6.66996837e-02f, 6.87809139e-02f, -3.85020524e-02f, 2.77156918e-03f, -4.65346426e-02f, 1.48453861e-01f,
  1.35309398e-01f, -3.38330835e-01f, -1.60066590e-01f, -3.47657464e-02f, -2.24403858e-01f, 5.91724366e-02f, -1.46775082e-01f, -7.70009868e-03f, -7.37169944e-03f, -5.08339368e-02f,
  -6.48033917e-02f, 7.84884989e-02f, -6.79777339e-02f, 4.86126766e-02f, 1.01166628e-01f, -1.30716354e-01f, -1.87786788e-01f, -3.42276059e-02f, 1.68457270e-01f, 1.97617579e-02f,
  1.14490492e-02f, -1.15742162e-01f, -1.14148287e-02f, 8.73647705e-02f, -8.13760757e-02f, 1.16225325e-01f, -1.14315078e-01f, -1.35446221e-01f, -9.29731205e-02f, -3.04373533e-01f,
  -2.07847673e-02f, -1.60728827e-01f, 1.60494074e-02f, -7.14940578e-02f, -4.38407660e-02f, 9.45411772e-02f, 1.54234394e-02f, 1.26518337e-02f, 3.78221907e-02f, -4.95776236e-02f,
  3.59303597e-03f, 1.23359645e-02f, 8.14968869e-02f, 4.27316949e-02f, 3.56161175e-03f, 1.57367513e-02f, 4.47267517e-02f, -8.33570119e-03f, 6.47877231e-02f, -5.78043349e-02f,
  -1.62147552e-01f, -7.38741308e-02f, -6.99221119e-02f, 8.74533355e-02f, 3.98779735e-02f, 6.80235028e-02f, -8.28744546e-02f, -4.05007303e-02f, 8.99673179e-02f, -6.02568313e-02f,
  5.48027530e-02f, 1.09858960e-02f, 8.01334530e-02f, -1.32365208e-02f, 2.07784157e-02f, 4.52610552e-02f, -5.31862043e-02f, 9.14097577e-02f, 6.69450164e-02f, 2.55071186e-02f,
  -4.57131751e-02f, -9.15041566e-02f, -4.48196493e-02f, -6.56684786e-02f, 7.30542745e-03f, -8.18366855e-02f, -1.35797467e-02f, 3.59896831e-02f, -5.97061291e-02f, -2.55587772e-02f,
  -5.54549843e-02f, -4.09619473e-02f, 2.61457842e-02f, 9.75585431e-02f, -9.01367441e-02f, 3.59531641e-02f, -2.19716001e-02f, -2.13132687e-02f, 7.67552257e-02f, -7.83451721e-02f,
  2.55099628e-02f, -7.63523877e-02f, -3.43277585e-03f, 3.45683880e-02f, 7.00476393e-02f, 7.88241159e-03f, -4.94151488e-02f, 5.89297935e-02f, -4.07732887e-06f, 4.54618130e-03f,
  -3.83027010e-02f, -1.17090391e-02f, 1.95237268e-02f, -6.75928518e-02f, 1.04681447e-01f, 4.64174002e-02f, -1.03119083e-01f, 2.15467555e-03f, 3.84653807e-02f, -6.00914238e-03f,
  -1.47115201e-01f, 9.62801129e-02f, 2.75403727e-02f, 1.36014387e-01f, 6.78867176e-02f, 1.40947327e-01f, 1.15132369e-01f, 9.09071118e-02f, 1.28739491e-01f, -9.03705731e-02f,
  -3.35876271e-02f, -1.13511167e-01f, 1.21898763e-01f, -2.65049245e-02f, -2.09160194e-01f, -1.98833659e-01f, -3.19084287e-01f, -1.06906127e-02f, -6.43707588e-02f, -2.02094525e-01f,
  -9.71774086e-02f, -1.27240615e-02f, 1.93092987e-01f, 1.61750332e-01f, 5.94503507e-02f, -7.65532106e-02f, -9.70558226e-02f, 1.06686972e-01f, 2.09145561e-01f, -1.59345567e-01f,
  -2.01253459e-01f, 6.94528371e-02f, 1.15248971e-01f, 5.83098754e-02f, -1.12629540e-01f, 2.53125019e-02f, 3.92521247e-02f, -1.71516128e-02f, -1.25859931e-01f, -9.59300846e-02f,
  6.98376372e-02f, -5.59175871e-02f, 3.26557271e-02f, -4.89436388e-02f, -6.27152771e-02f, -1.40787270e-02f, -1.37819171e-01f, 3.15431296e-03f, 1.12373121e-02f, -4.09967303e-02f,
  2.58849710e-02f, -9.89678688e-03f, 7.29295313e-02f, -6.75231442e-02f, 2.31298096e-02f, 2.32686736e-02f, 3.79419923e-02f, 2.22088993e-02f, 1.00858666e-01f, -3.13946865e-02f,
  -1.76816911e-01f, -9.32014138e-02f, -7.35113537e-03f, 9.83405113e-03f, 7.57645220e-02f, 6.38509840e-02f, 7.13460743e-02f, 4.68359105e-02f, 7.08315820e-02f, 9.67881829e-03f,
  -3.74927260e-02f, 4.61857058e-02f, -6.03408143e-02f, -3.23437452e-02f, 6.78818673e-02f, -8.00994560e-02f, -1.04460451e-04f, 8.09987932e-02f, -3.47255990e-02f, 1.12648867e-02f,
  6.07042834e-02f, 6.43719407e-03f, 7.73770139e-02f, -1.21093378e-03f, -3.31839640e-03f, 5.34896739e-02f, 2.33504735e-02f, -8.57050419e-02f, 2.38130260e-02f, -3.19525562e-02f,
  1.62922814e-02f, 2.65831035e-02f, -9.61766317e-02f, -8.47926289e-02f, -4.47884537e-02f, 1.52098881e-02f, -1.94983147e-02f, -2.71097291e-02f, -2.33029276e-02f, 1.36046605e-02f,
  1.33520558e-01f, -1.75843704e-02f, -4.10100669e-02f, 3.03448876e-03f, -6.36566877e-02f, 1.19941216e-02f, -9.46925581e-02f, 2.20005009e-02f, 6.33034706e-02f, 1.89954955e-02f,
  -2.63785068e-02f, -2.32636966e-02f, -2.70357300e-02f, -8.24637935e-02f, -1.22741535e-01f, -5.27772196e-02f, -6.21550009e-02f, -2.59810556e-02f, -6.75303414e-02f, 3.55442613e-02f,
  -8.25060010e-02f, -1.29604727e-01f, -1.52871348e-02f, -2.92388406e-02f, 4.10542861e-02f, -3.04004811e-02f, -6.82340786e-02f, -8.40893239e-02f, -1.30161280e-02f, -7.76223615e-02f,
  2.79033817e-02f, 1.98855653e-01f, 1.23403907e-01f, 3.31198648e-02f, 1.22448564e-01f, 5.79346670e-03f, 5.59264123e-02f, -1.06076427e-01f, -1.29739866e-01f, 1.09291501e-01f,
  3.70572582e-02f, -3.95301878e-02f, -1.20082945e-01f, -4.69461530e-02f, -7.09707737e-02f, -7.85332266e-03f, -1.29421223e-02f, -5.17699867e-02f, -1.58133745e-01f, 2.79140044e-02f,
  9.47433114e-02f, 4.69469018e-02f, -6.64067194e-02f, -6.40766025e-02f, -6.61095977e-02f, 4.17043455e-03f, -9.86702442e-02f, 2.42409408e-02f, 1.36389941e-01f, 1.47851661e-01f,
  6.73136786e-02f, 1.36388600e-01f, -5.01328195e-03f, -1.90836433e-02f, 2.19461843e-02f, 3.20660062e-02f, 8.75532776e-02f, 1.12516480e-02f, -6.34612963e-02f, -7.48346618e-04f,
  9.12485551e-03f, 6.96128160e-02f, 3.38758007e-02f, -1.24505699e-01f, 8.79429728e-02f, 4.05162573e-02f, -6.12006411e-02f, -1.02817468e-01f, -2.36845501e-02f, 1.95476804e-02f,
  1.39818825e-02f, 1.40318647e-01f, -2.98994109e-02f, -1.04698628e-01f, -9.67762247e-02f, -1.25289246e-01f, -7.61587918e-02f, -1.04377076e-01f, -1.98011827e-02f, 2.67138816e-02f,
  1.34134875e-03f, 8.04121122e-02f, -1.05886199e-02f, -6.42877296e-02f, 6.77405223e-02f, 2.32556579e-03f, 4.23889607e-02f, 2.33412646e-02f, -6.18898459e-02f, -4.90032695e-02f,
  7.08773062e-02f, -6.85184970e-02f, 4.74972539e-02f, -1.80329755e-02f, 4.42911219e-03f, 1.37923462e-02f, -1.63515862e-02f, 2.78667100e-02f, -7.59663209e-02f, -4.73890528e-02f,
  5.44069521e-02f, 2.56407950e-02f, -8.56659561e-02f, 1.69174392e-02f, 2.46435963e-02f, 3.47120618e-03f, 2.84986547e-03f, -1.04718432e-01f, -1.10854603e-01f, 2.19354723e-02f,
  -1.81512401e-01f, 3.40408161e-02f, -8.97328034e-02f, -1.01881422e-01f, -8.07979256e-02f, -7.64232874e-02f, -6.87105069e-03f, 6.52970150e-02f, 9.42088142e-02f, 1.14091493e-01f,
  5.00608943e-02f, 1.99886737e-03f, -3.82880867e-02f, -1.16424963e-01f, -4.69187507e-03f, -5.14738746e-02f, 8.33131596e-02f, -1.82989761e-02f, -5.97542673e-02f, -5.09985872e-02f,
  -1.14857011e-01f, 4.59645651e-02f, -3.77409570e-02f, -2.60985806e-03f, -5.16705662e-02f, 2.72610621e-03f, 8.80759582e-03f, -1.25114456e-01f, -1.04035936e-01f, -7.37459809e-02f,
  6.47050440e-02f, -6.50501326e-02f, 2.44048126e-02f, 6.75278381e-02f, -6.80719391e-02f, -1.25001907e-01f, -1.63306966e-01f, -8.93754140e-02f, 8.60928819e-02f, 4.68759611e-03f,
  -6.23448119e-02f, -9.27699506e-02f, -1.41877621e-01f, -1.01324014e-01f, -5.41613214e-02f, -6.51393011e-02f, -1.05869666e-01f, -1.42301857e-01f, -1.54519930e-01f, -1.83824256e-01f,
  -2.85929199e-02f, -7.51252845e-02f, -7.90205970e-02f, -7.16832057e-02f, 5.29284962e-02f, 2.41469145e-02f, -6.42900467e-02f, -1.08675689e-01f, -1.62076727e-01f, -1.01168469e-01f,
  -1.79839116e-02f, -1.29995257e-01f, -1.03700995e-01f, -3.88500281e-02f, 2.43159253e-02f, -7.77297094e-02f, 1.86470039e-02f, 9.12156478e-02f, 8.38982165e-02f, 5.99860735e-02f,
  -1.38462773e-02f, -4.66168113e-02f, -8.43752995e-02f, 2.94763371e-02f, 3.82321589e-02f, 1.97089687e-02f, 5.38589014e-03f, 2.04569986e-03f, -1.14621036e-02f, -1.02041028e-01f,
  6.52656555e-02f, -8.93934593e-02f, -3.15406583e-02f, 5.88412397e-02f, -6.18076399e-02f, 8.95451382e-02f, 9.54535380e-02f, 8.08899477e-02f, -2.59851455e-03f, 7.27097690e-02f,
  7.02841282e-02f, -4.29075584e-02f, -5.30288368e-02f, 3.34213041e-02f, -4.21887636e-02f, 5.13440706e-02f, -9.20777395e-02f, 2.72884499e-02f, 2.65610721e-02f, -2.40400825e-02f,
  -2.01512799e-02f, 2.91390568e-02f, 2.87095699e-02f, 3.68642807e-03f, 3.06578372e-02f, 5.47076985e-02f, 9.60463732e-02f, 1.08153999e-01f, -6.58297017e-02f, -2.59488821e-02f,
  7.03600422e-02f, 6.04410693e-02f, 2.03121416e-02f, 1.09760994e-02f, -6.38769642e-02f, 1.32183045e-01f, 1.25958636e-01f, 2.97976900e-02f, 1.48694925e-02f, 1.39498204e-01f,
  2.84804832e-02f, 1.75162088e-02f, 2.90246103e-02f, -8.77112299e-02f, 5.11372238e-02f, 2.08449606e-02f, -1.64525211e-02f, 2.03909891e-04f, 9.98159125e-02f, 2.33989302e-02f,
  -8.25713295e-03f, -6.21181540e-02f, -8.48839879e-02f, -1.06578179e-01f, 3.97203155e-02f, -5.30459359e-02f, 8.63358453e-02f, 5.83848245e-02f, -7.22689973e-03f, 2.99385823e-02f,
  1.15092278e-01f, -2.61530858e-02f, 5.71225323e-02f, -5.59665598e-02f, 9.13356990e-02f, 4.74530570e-02f, -3.13128680e-02f, 1.38066653e-02f, -9.44598299e-03f, 6.25048429e-02f,
  1.15610130e-01f, -1.06182192e-02f, 1.87277254e-02f, 7.98512995e-02f, 1.63381204e-01f, -3.53702940e-02f, 1.75309584e-01f, -4.20757830e-02f, -3.60676385e-02f, 1.63563751e-02f,
  5.75067773e-02f, -1.05629809e-01f, -1.32121205e-01f, -7.81259164e-02f, -1.10304877e-01f, -6.44257143e-02f, -9.02986377e-02f, -7.82092735e-02f, -9.35540125e-02f, 4.09082286e-02f,
  -7.72019615e-04f, 1.64492205e-02f, -1.57574713e-02f, -6.11886419e-02f, 7.70928711e-02f, -1.07726688e-02f, 1.00660110e-02f, -6.81445152e-02f, 6.15076069e-03f, -2.97806459e-04f,
  -2.54388563e-02f, -8.26114118e-02f, -7.57347420e-02f, -8.86704400e-02f, -9.57639515e-02f, 2.83991694e-02f, 3.40671359e-05f, -1.51742250e-01f, -1.16286464e-01f, 4.37283423e-03f,
  5.21291643e-02f, 3.30377966e-02f, 4.13401686e-02f, 5.08995801e-02f, 2.13791709e-02f, 1.07185787e-03f, -7.30049014e-02f, 1.46226876e-03f, -7.52547383e-02f, -3.29902433e-02f,
  -4.96818312e-02f, -2.56048632e-03f, 1.55903056e-01f, 5.87078650e-03f, -7.22789615e-02f, -6.78468347e-02f, -2.76706018e-03f, 9.01644304e-02f, 2.77485624e-02f, 6.07418083e-02f,
  8.33199695e-02f, -1.38666050e-03f, -3.62695456e-02f, -5.71129248e-02f, -6.41493350e-02f, -4.89938892e-02f, 1.68067440e-02f, -1.21498611e-02f, -2.50540860e-02f, 6.89528808e-02f,
  -5.76174892e-02f, 8.29952955e-02f, 3.83741632e-02f, 8.42770115e-02f, 2.82457247e-02f, 8.07381701e-03f, 8.55853260e-02f, 3.13832238e-02f, -5.69365993e-02f, -2.67000366e-02f,
  5.81424423e-02f, 3.43688735e-04f, -4.72008288e-02f, 3.36132459e-02f, 1.50834508e-02f, 3.89803909e-02f, -6.27065673e-02f, -9.56828371e-02f, -1.99276526e-02f, -3.36302631e-02f,
  -6.49975240e-02f, -2.86198538e-02f, -4.50191908e-02f, 2.50974987e-02f, 6.80040717e-02f, 3.31828259e-02f, -6.00312799e-02f, 1.38147585e-02f, -4.07625698e-02f, 8.21194947e-02f,
  6.45976290e-02f, -3.66892479e-02f, 5.92382140e-02f, -4.07063030e-02f, 6.33443072e-02f, 7.15641901e-02f, -1.30890934e-02f, -7.99521208e-02f, -5.19337691e-02f, 3.95651273e-02f,
  3.63667272e-02f, 8.39429870e-02f, 5.67820817e-02f, 3.97744253e-02f, -6.64776564e-02f, 7.34630786e-03f, -4.95536290e-02f, 2.02169325e-02f, 8.06618780e-02f, -4.07490088e-03f,
  -1.44516258e-02f, -7.65740573e-02f, 4.11207527e-02f, 6.93584653e-03f, 7.17056543e-02f, 7.94165116e-03f, 7.02376536e-04f, 1.13765545e-01f, -2.73279697e-02f, 6.83254227e-02f,
  1.96687784e-02f, -2.98147276e-03f, -8.97371694e-02f, 5.54954596e-02f, -1.07973516e-01f, -1.96622573e-02f, -6.43058494e-02f, 5.49939275e-02f, 4.17731889e-02f, 2.80401856e-02f,
  -6.86934218e-03f, 4.97365370e-03f, -8.63598585e-02f, 3.82904820e-02f, -1.02041988e-02f, -5.73526584e-02f, 4.13683392e-02f, 8.01956207e-02f, -5.02166860e-02f, 3.58216874e-02f,
  -2.87527032e-02f, -7.20957220e-02f, 7.45643824e-02f, -2.64324807e-02f, 3.19158100e-03f, -1.03033990e-01f, 3.83166261e-02f, 4.51859497e-02f, 2.48647612e-02f, -1.96999009e-03f,
  2.78542675e-02f, -5.51461019e-02f, 3.37589495e-02f, 6.86428100e-02f, 1.03643380e-01f, -1.01884129e-03f, 3.51520889e-02f, 8.35974067e-02f, 4.84915525e-02f, 3.32636721e-02f,
  -5.04271733e-03f, 2.16587689e-02f, 1.06624797e-01f, 5.22706844e-02f, 7.81718045e-02f, 1.24647962e-02f, 2.96606566e-03f, 8.99636447e-02f, 4.81763370e-02f, 2.12696567e-01f,
  -1.16171893e-02f, 4.96637262e-02f, 2.31515914e-02f, 9.58295763e-02f, 9.12842378e-02f, 5.54348789e-02f, 1.88321341e-02f, 8.98948833e-02f, 1.98299773e-02f, 2.07133852e-02f,
  -5.64106330e-02f, 7.96734914e-02f, 9.14495885e-02f, -1.47263240e-02f, -3.25449295e-02f, -7.80536160e-02f, 3.69876064e-02f, -9.30837728e-03f, 4.72331643e-02f, -7.68450031e-04f,
  -5.54250553e-02f, -9.24597904e-02f, -5.39736152e-02f, -8.96887407e-02f, -7.46924579e-02f, -7.52472579e-02f, -4.16196287e-02f, -3.99231762e-02f, -9.45891738e-02f, -9.49118957e-02f,
  1.08367220e-01f, -1.08968362e-01f, -8.50919634e-02f, 8.09740089e-03f, -9.51400548e-02f, -3.00409812e-02f, 6.87314495e-02f, 4.94468994e-02f, 2.79754046e-02f, -1.74251124e-02f,
  -9.11504850e-02f, 1.21553782e-02f, -4.49814200e-02f, -3.73762026e-02f, 8.14507809e-03f, -2.92870644e-02f, -7.26912618e-02f, 4.86966111e-02f, -6.93477094e-02f, 6.23048283e-02f,
  -2.29499321e-02f, 2.58690640e-02f, 2.32872814e-02f, 5.56108616e-02f, 6.11112453e-02f, 3.58971022e-02f, 1.59324080e-01f, 9.65999290e-02f, 7.36814588e-02f, 2.08848551e-01f,
  3.43660712e-01f, -4.30541933e-01f, 1.44526064e-01f, 1.27503812e-01f, 8.20784867e-02f, 2.22209334e-01f, 1.31330535e-01f, 2.40481719e-02f, 1.31634131e-01f, 6.39595315e-02f,
  -1.33792117e-01f, -1.96509082e-02f, 2.88735516e-02f, -9.19471607e-02f, -6.53840527e-02f, 9.90086868e-02f, 7.85706490e-02f, 1.22615300e-01f, 1.53445289e-01f, 6.85221329e-02f,
  -1.09241284e-01f, -2.42683347e-02f, 5.76078286e-03f, -1.59014836e-02f, -4.66103926e-02f, 6.85278401e-02f, -1.02394991e-01f, -7.78434724e-02f, -1.42221704e-01f, -1.34060252e-02f,
  1.53944060e-01f, 3.95215265e-02f, 1.92589894e-01f, 5.17518213e-03f, -3.01954318e-02f, 5.83275035e-02f, 6.30837902e-02f, -2.62845643e-02f, 2.13253349e-02f, -3.42766866e-02f,
  -7.97394663e-02f, -4.74217013e-02f, 9.12781581e-02f, -3.17836627e-02f, -4.09087949e-02f, -3.39173190e-02f, -1.16573296e-01f, -2.52941884e-02f, 4.49724309e-02f, -1.23809420e-01f,
  -1.55823171e-01f, -7.70708779e-03f, 1.01912692e-01f, 1.48733472e-02f, 6.55633723e-03f, 1.00755803e-01f, -9.77824032e-02f, -7.28660077e-02f, 2.80711465e-02f, -1.30173326e-01f,
  -2.78609176e-03f, 8.72577578e-02f, 5.93491234e-02f, 5.31595014e-02f, -1.41083570e-02f, -3.31530645e-02f, 6.60514086e-02f, -3.58800963e-02f, -5.40696234e-02f, -1.02955557e-01f,
  -2.99990345e-02f, 8.66426080e-02f, -3.89877222e-02f, 4.81378883e-02f, 1.25545114e-02f, 7.15227202e-02f, 5.66838309e-03f, -1.23446234e-01f, 9.39673837e-03f, 7.78440163e-02f,
  -3.46588865e-02f, 1.09232776e-01f, -2.49660062e-03f, 3.86089720e-02f, 3.17650959e-02f, -1.53637975e-02f, 1.29918620e-01f, -8.90399963e-02f, 3.25754061e-02f, -3.85537138e-03f,
  -9.39970836e-03f, 1.76126748e-01f, 1.08665086e-01f, -4.34309505e-02f, 4.60395478e-02f, -5.51895723e-02f, 7.98289701e-02f, -1.04443222e-01f, -8.92391801e-02f, 6.53436556e-02f,
  -1.38603598e-02f, 2.99367942e-02f, -2.81206220e-02f, -1.03942104e-01f, 5.48760854e-02f, 6.78199977e-02f, -1.03417620e-01f, 1.49822339e-01f, -9.04724523e-02f, -4.31471132e-02f,
  -6.61942959e-02f, 1.75601885e-01f, 2.31793076e-01f, 1.50546387e-01f, 4.20841128e-02f, 1.42243117e-01f, -4.71506789e-02f, 1.57653634e-02f, 2.70502008e-02f, 4.89699803e-02f,
  4.79499698e-01f, 1.48296007e-03f, 1.33318454e-01f, 3.44181322e-02f, -1.77320316e-01f, -2.23114058e-01f, -2.51260310e-01f, -1.71101764e-01f, -7.66441002e-02f, -2.63286736e-02f,
  1.96590032e-02f, 2.98750661e-02f, 9.21447650e-02f, 1.92402616e-01f, 1.03676125e-01f, -8.43796805e-02f, 6.55324161e-02f, 3.41322213e-01f, 1.75256997e-01f, -4.52840850e-02f,
  2.62766494e-03f, 1.23614162e-01f, 1.97279379e-01f, 8.97535905e-02f, -8.66820104e-03f, -1.11036077e-01f, 6.98330030e-02f, 1.39860690e-01f, -4.01529074e-02f, 9.34605226e-02f,
  1.76022500e-01f, 2.54266679e-01f, -1.22085856e-02f, -1.10997818e-02f, 1.05520397e-01f, 4.87916693e-02f, -5.00527385e-04f, 9.85117555e-02f, -9.01258290e-02f, -4.88135256e-02f,
  -2.21673157e-02f, 5.63309267e-02f, -9.74403694e-02f, 4.33302224e-02f, -1.56580266e-02f, 3.72924209e-02f, -6.09013923e-02f, 2.18075931e-01f, 1.54628769e-01f, 6.29704073e-02f,
  -1.01619221e-01f, -5.10859378e-02f, 3.42689566e-02f, -9.50767100e-02f, 1.74579662e-04f, 8.59241337e-02f, -9.40092094e-03f, 5.49596250e-02f, 6.76403642e-02f, 8.03497359e-02f,
  5.86496256e-02f, -5.47115691e-03f, -4.85791489e-02f, -1.97193883e-02f, -2.60309130e-02f, -9.49065238e-02f, -6.29974827e-02f, 3.10068913e-02f, -2.52286484e-03f, -9.12776589e-02f,
  -3.45825590e-02f, 8.20854157e-02f, -3.98115814e-02f, -3.26129533e-02f, -6.22792877e-02f, -4.21259180e-03f, -6.38716966e-02f, 1.39863609e-04f, 4.85494966e-03f, -4.08298895e-02f,
  2.12307926e-02f, 5.16489334e-02f, -8.29558223e-02f, -2.23508086e-02f, -9.77813546e-03f, 6.01792149e-02f, 2.54675690e-02f, 1.66786630e-02f, -1.53371105e-02f, -1.75779907e-03f,
  -1.34363830e-01f, 1.25553161e-01f, 2.58085504e-02f, 7.53652081e-02f, 4.82024662e-02f, -3.83712575e-02f, 2.85873711e-02f, 1.56603218e-03f, 4.76868066e-04f, 4.12619486e-02f,
  1.25985667e-02f, 3.96224447e-02f, 5.82773872e-02f, 7.27147982e-02f, -9.90697891e-02f, -3.35186794e-02f, 2.27321740e-02f, 3.54945138e-02f, 6.41961619e-02f, -8.93677771e-02f,
  -2.72422861e-02f, -1.06696911e-01f, -1.19119339e-01f, -1.02708712e-01f, -1.25942513e-01f, -7.86007419e-02f, -1.71797663e-01f, -5.15350290e-02f, -1.13504995e-02f, -2.38973111e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -2.13595685e-02f, 9.53407586e-02f, 1.47555038e-01f, 2.86932647e-01f, 1.23629354e-01f, 3.35960865e-01f, 1.71154201e-01f, 1.64048582e-01f, 7.57569373e-02f, 2.61937439e-01f,
  2.35706270e-01f, 4.49727803e-01f, 1.74747646e-01f, -1.48433903e-02f, 3.99668068e-02f, 2.11804777e-01f, 1.70503929e-01f, 1.11920647e-01f, 3.08693528e-01f, 1.70358688e-01f,
  7.53333271e-02f, 2.04270661e-01f, 1.46443918e-01f, 8.77226591e-02f, 5.91695644e-02f, 4.35473740e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.34713193e-02f, 1.97542146e-01f, -1.06776189e-02f, -5.03057420e-01f, 3.56137276e-01f, 2.05486715e-01f, 1.10245876e-01f, 1.86121002e-01f, -4.09212172e-01f, -1.79300085e-01f,
  -2.23724067e-01f, 2.46939898e-01f, 3.10466826e-01f, 1.39264241e-01f, -2.37579122e-01f, 2.46527210e-01f, -1.58419639e-01f, -2.77122319e-01f, -4.32170695e-03f, -4.58130166e-02f,
  -3.67371808e-03f, 1.33695900e-01f, -1.76361591e-01f, 1.41912803e-01f, -1.75920218e-01f, 1.20292768e-01f, 2.27817580e-01f, -4.45473976e-02f, 1.45783812e-01f, 7.83741400e-02f,
  -9.95591581e-02f, 2.30720490e-01f, -1.84591919e-01f, -3.79008986e-02f, -1.87652439e-01f, -3.39716792e-01f, 4.66490805e-01f, 2.34950408e-01f, -3.17676440e-02f, -4.92397770e-02f,
  -1.81740522e-01f, -2.14854285e-01f, 1.41496463e-02f, -1.24267913e-01f, 2.69048512e-01f, -3.16674471e-01f, 2.82054663e-01f, 2.08790436e-01f, 6.00156374e-02f, -8.58838297e-03f,
  1.96313664e-01f, -5.63345253e-02f, 4.64349747e-01f, 1.77907020e-01f, -7.98336882e-03f, 2.42575526e-01f, -2.04614118e-01f, -2.09530815e-01f, 9.31592509e-02f, -2.20175902e-03f,
  1.30394161e-01f, -1.14797205e-01f, -4.08324599e-01f, 2.39581261e-02f, -1.39772803e-01f, 9.36435461e-02f, -1.33140266e-01f, 4.21548158e-01f, 2.27375761e-01f, -1.29671782e-01f,
  1.86079703e-02f, -1.58902630e-01f, -2.00760558e-01f, -1.80414468e-01f, 1.04390606e-01f, 1.26823306e-01f, 2.86883593e-01f, -2.36155331e-01f, -8.70153755e-02f, 2.30729505e-01f,
  -3.91547345e-02f, 1.77506894e-01f, 1.79520026e-01f, -8.06575119e-02f, 2.18496233e-01f, -1.59504384e-01f, 3.73058051e-01f, 2.15154424e-01f, -3.72885913e-02f, -2.53702193e-01f,
  1.14381323e-02f, -8.96891057e-02f, 1.71322986e-01f, 1.22140646e-01f, -2.85500020e-01f, -2.80167341e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.57935724e-01f, 2.15617374e-01f, 2.05383256e-01f, 1.52601302e-01f, -1.99278250e-01f, 1.79227874e-01f, 1.11796549e-02f, -1.66586608e-01f, 8.46987441e-02f, 2.54341103e-02f,
  4.17591751e-01f, 2.61602700e-01f, -1.10514112e-01f, -6.30954728e-02f, 1.88634008e-01f, 1.52263358e-01f, -2.77738888e-02f, 5.36975920e-01f, -1.98515803e-02f, -1.49497539e-01f,
  2.13816732e-01f, -1.05348974e-02f, -6.86769634e-02f, -1.12097964e-01f, 3.76269758e-01f, -1.39626786e-01f, 1.51604554e-02f, 2.52996415e-01f, 1.38529569e-01f, -6.08652607e-02f,
  4.27985638e-01f, -3.90492231e-01f, -9.14826617e-02f, 1.42258957e-01f, 1.32974610e-01f, -1.65067881e-01f, 5.12386523e-02f, 1.86296948e-03f, 1.80570036e-01f, -1.36148691e-01f,
  -7.31620416e-02f, 2.78267395e-02f, -1.37593567e-01f, 8.45007375e-02f, 6.27744794e-02f, 1.14797264e-01f, -1.58330441e-01f, 2.04331920e-01f, -1.55509755e-01f, 1.67157918e-01f,
  -1.71643615e-01f, 5.67596667e-02f, -1.27711684e-01f, 8.14107209e-02f, -4.50307690e-02f, 9.42090340e-03f, -1.61514595e-01f, -8.61807764e-02f, 8.28359500e-02f, -3.86774763e-02f,
  1.57452404e-01f, 1.12074338e-01f, 3.69612873e-02f, 1.62143096e-01f, 1.96668282e-02f, 5.34378923e-02f, 3.78655404e-01f, 5.35130382e-01f, -3.01942900e-02f, -1.65369421e-01f,
  -1.00576624e-01f, 5.70490435e-02f, 5.91587663e-01f, 1.94740489e-01f, -1.50518000e-01f, -1.86071873e-01f, 3.59230816e-01f, -2.04387754e-01f, 2.74671376e-01f, -1.17096454e-01f,
  2.13491708e-01f, -1.74522787e-01f, 9.25061628e-02f, 1.58783332e-01f, -2.70811439e-01f, -2.73262281e-02f, 1.84670106e-01f, 9.78777185e-02f, 3.74538392e-01f, 3.34030151e-01f,
  -1.48160353e-01f, 1.18265804e-02f, -2.29736999e-01f, 2.42295682e-01f, -1.35128051e-01f, 1.07151866e-01f, 3.24469209e-02f, -1.06999995e-02f, 1.67059034e-01f, -2.14483336e-01f,
  9.70740989e-02f, -7.43988901e-02f, -6.08704090e-02f, -7.22947903e-03f, -1.99806064e-01f, -5.78874834e-02f, 2.52840966e-01f, -1.25667155e-01f, 2.88577080e-01f, 4.32816595e-01f,
  -9.63713527e-02f, -1.67383760e-01f, 1.97703108e-01f, 4.26517501e-02f, 8.50354135e-02f, -4.12210040e-02f, 1.38924912e-01f, 1.57407641e-01f, -5.27482964e-02f, 1.27271175e-01f,
  1.53441697e-01f, -1.38700694e-01f, 1.33448750e-01f, 1.66808948e-01f, 1.86891645e-01f, 2.01957583e-01f, 2.19375059e-01f, 4.05559167e-02f, 8.76886472e-02f, -7.46860132e-02f,
  -8.02726224e-02f, -8.44765157e-02f, -3.84872891e-02f, 1.77485183e-01f, -1.66926924e-02f, -1.33505508e-01f, -1.43157244e-01f, -1.52805328e-01f, -1.20023608e-01f, -7.96250328e-02f,
  -2.73798332e-02f, -1.63080141e-01f, -3.99765223e-02f, -3.19547988e-02f, 1.12733319e-02f, 1.04923025e-01f, 1.33578330e-01f, 1.08057447e-01f, -5.08603305e-02f, -1.01838805e-01f,
  -6.63774088e-02f, 6.76244497e-02f, 4.87201959e-02f, 1.65900066e-02f, 5.28867580e-02f, -5.67577034e-02f, 7.34786987e-02f, 4.22331877e-02f, -5.68890944e-02f, 1.01807546e-02f,
  -3.49260010e-02f, -1.22551747e-01f, -1.07095368e-01f, -1.17715202e-01f, 1.30156308e-01f, 1.75825760e-01f, -1.16707563e-01f, 8.66437927e-02f, -1.49081394e-01f, 3.20223793e-02f,
  1.87532678e-01f, 5.18629067e-02f, -7.75317326e-02f, 3.64355207e-03f, -5.70795387e-02f, 1.70336708e-01f, -1.73841000e-01f, 1.82371959e-01f, -3.35682556e-03f, -7.70870298e-02f,
  5.54518308e-03f, 1.79453120e-02f, -1.26599923e-01f, 9.83327553e-02f, 1.57258421e-01f, -1.32515758e-01f, 1.19160989e-03f, 1.09687224e-01f, 7.73861911e-03f, 6.22659214e-02f,
  1.87522754e-01f, -1.30565614e-01f, -8.41289684e-02f, -1.91139013e-01f, 1.04487455e-02f, -8.17770734e-02f, 1.51774943e-01f, -1.46928266e-01f, 3.81027088e-02f, 2.01550722e-01f,
  1.35830283e-01f, 1.00785367e-01f, -1.34983644e-01f, 1.25109866e-01f, -9.66446027e-02f, -7.58186653e-02f, -1.68215409e-01f, 2.31461748e-01f, 1.37923479e-01f, 1.72887798e-02f,
  1.68451324e-01f, -3.24887633e-02f, 1.42566874e-04f, 5.64128198e-02f, -5.36802970e-02f, 1.48560867e-01f, -4.59435023e-03f, 9.31712508e-04f, -3.45019959e-02f, -1.41890585e-01f,
  1.38006389e-01f, 1.15484729e-01f, 1.48580223e-01f, 7.30544329e-02f, -1.36512771e-01f, -4.02884521e-02f, -6.15283921e-02f, -1.24712937e-01f, 1.31778955e-01f, -7.39231780e-02f,
  6.33770600e-02f, 1.06193222e-01f, -4.02073078e-02f, 6.84772283e-02f, -1.33587182e-01f, -7.92747959e-02f, -1.29156513e-03f, -3.77580486e-02f, 3.26471888e-02f, 3.07914764e-02f,
  -6.83982857e-03f, -4.06505391e-02f, 1.51040182e-01f, -1.78759351e-01f, -9.39146280e-02f, -1.03107601e-01f, -6.28578588e-02f, -6.74871877e-02f, -1.52691767e-01f, -9.14757419e-03f,
  1.02147445e-01f, 2.20772028e-01f, -6.81166351e-02f, -4.85753827e-02f, -3.76117565e-02f, 6.64066151e-02f, 3.72892857e-01f, 3.19678545e-01f, 4.06056404e-01f, -4.76983428e-01f,
  -7.49785977e-04f, -7.51443766e-03f, -9.20241475e-02f, -1.20889686e-01f, -4.45649587e-02f, -4.44613434e-02f, -1.02514498e-01f, -4.02722828e-04f, 6.46801805e-03f, 1.16933823e-01f,
  1.35868743e-01f, 2.11977050e-01f, 6.63992837e-02f, -1.41586185e-01f, 1.51026174e-01f, -1.87221870e-01f, 6.20637052e-02f, 2.66591787e-01f, 2.41975933e-01f, 1.63164392e-01f,
  -2.44812101e-01f, -4.79317792e-02f, 1.83739215e-01f, 1.23695448e-01f, -1.60073489e-01f, -6.19973764e-02f, -7.68802315e-02f, 3.28289300e-01f, 3.36068064e-01f, 1.72201082e-01f,
  3.16415370e-01f, 1.30950511e-01f, -4.73228455e-01f, -2.72664398e-01f, 9.69157144e-02f, -3.66421677e-02f, 3.36664021e-01f, 3.03683907e-01f, -1.59936011e-01f, 7.80868158e-02f,
  -2.80634820e-01f, 3.08089525e-01f, 1.04195520e-01f, 4.22438383e-02f, 1.00695968e-01f, 6.53104708e-02f, -1.01910323e-01f, -4.52761501e-02f, -7.01864436e-02f, 1.06450506e-01f,
  -2.03736633e-01f, -5.79152368e-02f, 2.90939450e-01f, 2.69612879e-01f, -1.43692270e-01f, 1.08960599e-01f, 8.41573030e-02f, 2.23425776e-02f, 2.04246074e-01f, -1.26565427e-01f,
  1.63876191e-01f, 1.66774780e-01f, -3.59615795e-02f, 1.20873414e-01f, -9.14931148e-02f, -1.22907184e-01f, -1.57216966e-01f, -2.59471893e-01f, 3.96936247e-03f, -2.02251956e-01f,
  -2.92099774e-01f, 4.67134237e-01f, 2.62206554e-01f, 3.37316357e-02f, -3.04411590e-01f, 4.14715409e-01f, 2.39489689e-01f, 3.14580649e-01f, -7.58297145e-02f, 1.89306512e-01f,
  2.24492505e-01f, -3.30406040e-01f, 2.17737392e-01f, 1.90992534e-01f, -1.38373435e-01f, 6.12068884e-02f, 2.36235261e-01f, 8.54323059e-02f, 1.41710266e-01f, 1.03153221e-01f,
  5.12852008e-03f, 1.27466574e-01f, 1.15060218e-01f, 2.23366208e-02f, 7.90835172e-02f, 1.08890794e-01f, 8.37009549e-02f, -1.14869304e-01f, 8.64454061e-02f, 1.12176858e-01f,
  1.70649081e-01f, -3.49841118e-02f, -1.18937097e-01f, -2.89976224e-02f, -9.63626951e-02f, 4.06274557e-01f, 5.27270958e-02f, -1.45105943e-01f, -1.17363539e-02f, -1.19371273e-01f,
  2.11375862e-01f, -2.83942628e-03f, -4.56765331e-02f, 4.65814173e-02f, 2.15218753e-01f, -1.46553278e-01f, 2.82290369e-01f, 2.30597600e-01f, -9.41066369e-02f, -1.22234456e-01f,
  -2.29981495e-03f, -1.49044082e-01f, -8.81128311e-02f, -1.45322248e-01f, 1.84192002e-01f, 1.65950358e-01f, 5.57632046e-03f, -2.99136311e-01f, 1.69014961e-01f, -1.38759926e-01f,
  2.05232501e-01f, -1.15598282e-02f, 5.73986862e-03f, 1.96503356e-01f, -2.33207252e-02f, 1.24514349e-01f, 1.05708636e-01f, 1.46225706e-01f, 1.19619220e-02f, 2.69464731e-01f,
  3.93240526e-02f, -7.06592649e-02f, 1.18344672e-01f, -1.77477330e-01f, -3.34891789e-02f, 2.75888324e-01f, 5.32858483e-02f, 9.62294545e-03f, 1.11033441e-02f, -9.95813310e-02f,
  6.91191331e-02f, 1.25673056e-01f, 6.21190481e-02f, -1.69033110e-01f, -8.34724158e-02f, 3.83078307e-01f, 2.42626756e-01f, 4.26202208e-01f, 2.68090487e-01f, -3.24113429e-01f,
  6.52010813e-02f, 4.45854485e-01f, -2.12598026e-01f, 2.48862907e-01f, -8.50506797e-02f, 1.73375458e-01f, 9.17440653e-02f, 2.71097571e-01f, -4.80553061e-02f, 1.67894706e-01f,
  2.69553900e-01f, 2.14162499e-01f, 1.95657238e-01f, 4.24328238e-01f, 2.28652954e-01f, -2.94121414e-01f, 3.96410048e-01f, 4.23847228e-01f, 8.62709358e-02f, 8.15929919e-02f,
  -1.31536573e-01f, -1.78372070e-01f, 3.17304611e-01f, -1.68134779e-01f, 1.03850104e-01f, -1.82071611e-01f, -6.20443486e-02f, 2.98112631e-01f, 1.45231605e-01f, 2.03754500e-01f,
  -6.85989782e-02f, -2.10665509e-01f, 1.66037440e-01f, 2.92894930e-01f, -5.79653657e-04f, 2.48238757e-01f, -1.07258759e-01f, 1.72685787e-01f, 3.14319313e-01f, -2.26643443e-01f,
  -2.04501629e-01f, -1.03107639e-01f, 3.06504041e-01f, -6.09241053e-02f, -1.44382000e-01f, 2.65545219e-01f, -4.32502758e-03f, -1.72707513e-01f, -1.19543625e-02f, 4.10723150e-01f,
  1.92031950e-01f, 2.19875388e-02f, -1.65000901e-01f, 4.21416014e-02f, -1.53299165e-03f, -1.36460304e-01f, -2.05187395e-01f, -1.10545337e-01f, 1.47599339e-01f, 2.51974344e-01f,
  7.84048960e-02f, 2.13538364e-01f, -4.40813601e-02f, 1.52970701e-01f, -1.19222291e-01f, 2.28915736e-01f, -1.59042343e-01f, 1.74344942e-01f, 2.29530543e-01f, 6.40794709e-02f,
  -1.18235491e-01f, 2.83912480e-01f, -1.53587848e-01f, -2.42990449e-01f, -1.10671325e-02f, 3.19141328e-01f, 1.50778741e-01f, 3.00403237e-01f, -2.14943457e-02f, -1.51848495e-01f,
  1.92312226e-01f, 5.46236895e-02f, 1.72494091e-02f, 1.10010922e-01f, 1.95521519e-01f, 1.70390964e-01f, -8.38927329e-02f, -8.90658423e-03f, 3.28112394e-02f, -2.22065467e-02f,
  -1.45273075e-01f, 1.88250035e-01f, 2.44188830e-02f, 2.13395581e-01f, 2.66074091e-01f, 5.60243547e-01f, -3.20337236e-01f, 7.74724036e-02f, -1.58382043e-01f, 1.62755758e-01f,
  2.91391402e-01f, -1.40662506e-01f, 7.72410780e-02f, 5.38168967e-01f, -2.23675892e-02f, -3.92019808e-01f, 7.32954517e-02f, 2.57051528e-01f, 1.16063669e-01f, 3.84322971e-01f,
  3.20167840e-02f, 1.93810880e-01f, -7.41502792e-02f, -1.10778354e-01f, -5.24791237e-03f, 6.60979524e-02f, 2.40520954e-01f, -1.48503929e-01f, -7.38718808e-02f, 1.98717669e-01f,
  2.22743079e-01f, 4.36107442e-02f, 4.22451586e-01f, 1.16564771e-02f, 3.12250435e-01f, 2.40187809e-01f, 1.86742648e-01f, -2.84456819e-01f, 4.19438541e-01f, -3.59254032e-01f,
  2.57919990e-02f, -1.89144462e-01f, 7.99801648e-02f, 1.42803416e-01f, -6.20744191e-02f, -3.98633569e-01f, 6.04656994e-01f, 6.23868369e-02f, -2.68351939e-03f, 9.53097939e-02f,
  1.43180281e-01f, -2.77158022e-01f, 2.78146893e-01f, -1.44204617e-01f, -1.74842894e-01f, 3.61229986e-01f, 3.43368828e-01f, 1.15445346e-01f, 1.04258686e-01f, 2.26841167e-01f,
  -1.55133530e-01f, 3.67940396e-01f, 6.38846084e-02f, 9.98122394e-02f, -6.10373504e-02f, 1.10617198e-01f, -8.14581737e-02f, 1.50649205e-01f, -8.46116021e-02f, -1.44046903e-01f,
  1.85822815e-01f, 2.77501076e-01f, -1.85677752e-01f, 4.54851925e-01f, 2.12319389e-01f, -2.36497503e-02f, 1.10876247e-01f, 2.05865636e-01f, -1.42590880e-01f, 4.61361893e-02f,
  1.32380771e-02f, -6.68564960e-02f, -1.47228107e-01f, 1.80617068e-02f, -1.49782687e-01f, 5.40439077e-02f, -1.64580837e-01f, 1.57728538e-01f, -1.66359484e-01f, 7.10670426e-02f,
  -3.28684412e-02f, 7.33414665e-02f, -1.21164881e-01f, -1.95025936e-01f, -1.35990515e-01f, 1.24470033e-01f, -3.06203943e-02f, 4.38732743e-01f, 1.21791296e-01f, -4.59894761e-02f,
  1.63944364e-01f, 2.17136517e-01f, -2.14584157e-01f, -6.26872256e-02f, 1.84990659e-01f, -5.98049387e-02f, 6.65582940e-02f, 2.42599830e-01f, 8.08558688e-02f, 3.41296121e-02f,
  -1.56176105e-01f, 2.52902806e-01f, -1.38008207e-01f, -1.40561089e-01f, 8.78489837e-02f, 1.83303177e-01f, 9.83279645e-02f, -1.56240789e-02f, -9.20388475e-02f, -3.24604829e-04f,
  -1.16988651e-01f, 2.76488792e-02f, 2.44027823e-02f, 2.97942385e-02f, 8.42646956e-02f, -6.35278597e-02f, -2.06969120e-02f, 3.92941386e-02f, 1.12947375e-01f, -2.02707097e-01f,
  2.61434138e-01f, -5.01333885e-02f, 1.09791249e-01f, -2.79991888e-02f, -2.87596345e-01f, -6.75399229e-03f, -1.39640361e-01f, 8.57662261e-02f, 2.95929849e-01f, 1.69653490e-01f,
  -1.04582898e-01f, -8.16483945e-02f, -2.21060172e-01f, 2.61281103e-01f, 7.85378274e-03f, -1.65870726e-01f, 2.49425068e-01f, 1.38318809e-02f, -3.87432575e-02f, -1.61229327e-01f,
  -1.05246030e-01f, -6.15701489e-02f, -1.27371456e-02f, -2.31011346e-01f, 3.17034602e-01f, 2.32579350e-01f, -8.49837437e-02f, -1.66158766e-01f, 1.11418089e-03f, 1.54393809e-02f,
  2.52824221e-02f, 2.24101674e-02f, 2.73326170e-02f, 1.15299150e-01f, 2.89940417e-01f, 1.55679896e-01f, -1.64639816e-01f, 1.32439792e-01f, 4.52542938e-02f, 3.95428747e-01f,
  4.99685764e-01f, -1.35473475e-01f, -3.52684528e-01f, 5.42131066e-01f, -1.67906687e-01f, -3.59935850e-01f, -2.96338826e-01f, 2.40310207e-01f, 1.04454719e-01f, 1.21260539e-01f,
  -4.71696109e-02f, -7.92966597e-03f, -3.48084956e-01f, -1.75855272e-02f, 2.69837286e-02f, -2.03617349e-01f, 2.57450007e-02f, 2.27502868e-01f, 1.18267044e-01f, 1.07142761e-01f,
  -6.89214021e-02f, -1.94255814e-01f, 1.82908356e-01f, 3.80441248e-01f, -6.48625717e-02f, -1.58684328e-01f, -1.33667365e-01f, -1.85819697e-02f, -7.31432671e-03f, 9.49950144e-02f,
  -4.22646403e-02f, -7.51823112e-02f, -5.34982532e-02f, -1.87536646e-02f, -2.29293685e-02f, -7.20000640e-02f, 1.38752699e-01f, -1.24236815e-01f, -5.94805926e-02f, 1.22645088e-01f,
  -3.19661200e-02f, -9.31363329e-02f, -1.43314809e-01f, 1.40033022e-01f, 9.87385288e-02f, -5.11922315e-02f, 9.88944545e-02f, -1.21183775e-01f, 4.84047011e-02f, -1.63029969e-01f,
  3.08382101e-02f, -2.10991246e-03f, 5.07448688e-02f, -5.53308204e-02f, -1.61701441e-01f, -1.71908319e-01f, 2.91411042e-01f, 1.67837039e-01f, 9.03580189e-02f, 1.59310266e-01f,
  1.19629093e-01f, 5.66477180e-02f, -2.53688663e-01f, -2.90111899e-01f, 4.38761935e-02f, -8.34274665e-02f, 2.04032540e-01f, 1.33082211e-01f, 4.88828391e-01f, 2.31250137e-01f,
  4.13450710e-02f, 2.97178566e-01f, 2.05263585e-01f, 6.57611132e-01f, 2.91073561e-01f, -3.87496762e-02f, 6.86260700e-01f, -2.57185429e-01f, 4.77572203e-01f, 9.57338512e-02f,
  1.17287330e-01f, -2.00393900e-01f, 1.41015202e-01f, 1.13064215e-01f, 4.94338311e-02f, 4.08040881e-02f, -3.13399464e-01f, -2.85154790e-01f, 1.72126621e-01f, 1.44940853e-01f,
  -9.61377919e-02f, -1.89693552e-02f, -2.58276135e-01f, -1.48978636e-01f, -4.01320197e-02f, -5.20841777e-02f, 1.35814652e-01f, 1.59936115e-01f, -4.11506407e-02f, 1.85132042e-01f,
  3.56930159e-02f, 4.38930005e-01f, -1.54618070e-01f, 1.84735894e-01f, -3.76177579e-02f, 2.06030145e-01f, -1.73785239e-01f, 1.27848938e-01f, 1.31425932e-02f, -2.04885513e-01f,
  -2.33624713e-03f, -5.65387271e-02f, 1.51584074e-01f, -1.21400282e-01f, -8.28527436e-02f, 5.26569858e-02f, -3.46179977e-02f, 1.44860223e-01f, 1.34874254e-01f, 2.00074375e-01f,
  -1.94840208e-02f, 3.12326141e-02f, -7.49184489e-02f, -4.22296599e-02f, -5.32525405e-02f, 2.00269774e-01f, 1.75789837e-02f, 1.43386573e-01f, 1.26212761e-01f, 7.59047503e-03f,
  3.63081582e-02f, 2.06362188e-01f, -1.67149916e-01f, 4.17427756e-02f, 5.63032106e-02f, 1.66880205e-01f, 1.48662567e-01f, -9.41979885e-02f, 4.85788807e-02f, -4.67056967e-02f,
  -5.98124266e-02f, -4.12612967e-02f, -1.19641192e-01f, 1.12598345e-01f, 3.07043325e-02f, 1.49427071e-01f, -7.14824954e-03f, 2.54791547e-02f, -6.13992400e-02f, -1.71434522e-01f,
  -8.77158195e-02f, 1.05736377e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.81152504e-02f, -1.27109081e-01f, 5.27724147e-01f, 2.98561249e-02f, -1.52979463e-01f, 1.18629985e-01f, 1.63733922e-02f, -1.59477908e-02f, 2.06164092e-01f, 2.81532109e-01f,
  9.13029388e-02f, -3.41030303e-03f, 2.58948475e-01f, 2.07912207e-01f, 2.39286497e-01f, 2.47926757e-01f, 3.79604429e-01f, 5.57029545e-01f, 6.86795115e-02f, 3.86483618e-03f,
  2.47015208e-01f, 1.90675646e-01f, -1.57771140e-01f, 2.19675407e-01f, -4.91650216e-02f, -1.24654047e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.58825094e-01f, 4.69241679e-01f, 3.47602628e-02f, 3.11631769e-01f, 2.57663220e-01f, 1.25111490e-01f, -3.75195563e-01f, 4.20403555e-02f, 9.26516801e-02f, -2.03787565e-01f,
  -1.48504004e-02f, 8.29248503e-03f, 1.76393315e-01f, -1.27283365e-01f, 1.11975379e-01f, -2.85814613e-01f, 2.02582955e-01f, 1.10265128e-01f, 1.26050964e-01f, 3.89914624e-02f,
  -9.81335491e-02f, -6.95584640e-02f, 8.00011531e-02f, 2.52707213e-01f, 1.90809309e-01f, -2.43467107e-01f, -1.18473247e-01f, 2.99397171e-01f, 8.60322863e-02f, -1.53935179e-01f,
  -9.06650051e-02f, -9.79611576e-02f, 4.64902937e-01f, 4.05714959e-01f, 3.63055795e-01f, -2.55168434e-02f, 2.69281492e-03f, 3.11297208e-01f, -2.55375981e-01f, 3.95833515e-04f,
  1.62315816e-01f, 7.08686840e-03f, -5.08733056e-02f, -9.16554332e-02f, 1.64056681e-02f, -6.07485808e-02f, 5.28497323e-02f, -1.34321079e-01f, 1.27616048e-01f, 7.98413679e-02f,
  3.61775532e-02f, -1.30910546e-01f, -1.97824284e-01f, 9.53597873e-02f, -1.67257637e-01f, 1.69921592e-01f, -2.71669984e-01f, -7.32615665e-02f, 5.43664210e-02f, -2.46985540e-01f,
  2.79905535e-02f, 1.61634192e-01f, -6.75463080e-02f, -2.06362307e-01f, -1.55646086e-01f, -5.10508537e-01f, -3.42497885e-01f, 5.06204180e-02f, 4.67453599e-02f, -8.35374966e-02f,
  1.17445201e-01f, 1.25549167e-01f, -2.15908259e-01f, 1.84569776e-01f, 8.36904421e-02f, 1.96418390e-02f, 5.92478365e-03f, -1.08242938e-02f, -2.11051002e-01f, 3.03053111e-01f,
  2.60321866e-03f, 1.11888938e-01f, -1.86139822e-01f, 2.98547059e-01f, 2.20770732e-01f, 2.47759476e-01f, 8.86779055e-02f, -3.16160560e-01f, 3.51954252e-01f, -5.83635010e-02f,
  2.01883823e-01f, -5.23483381e-02f, -2.85427347e-02f, 5.16598001e-02f, 1.77492037e-01f, -1.04046129e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.95751354e-01f, -7.23897815e-02f, 1.70107305e-01f, -2.05006078e-01f, -4.54892628e-02f, -1.53148547e-02f, -5.30892313e-02f, 1.19428538e-01f, -7.95827508e-02f, -9.10786837e-02f,
  -1.00789875e-01f, -1.10151947e-01f, 1.15817986e-01f, 8.06642324e-03f, -1.11005530e-01f, -1.21133709e-02f, 7.52133597e-03f, 4.10716385e-02f, -1.10969953e-01f, -9.89775062e-02f,
  -1.34060994e-01f, 1.71342701e-01f, 5.61463945e-02f, -1.71334390e-02f, 5.43614626e-02f, 3.53020914e-02f, 1.48559019e-01f, -1.77368447e-01f, -8.80092904e-02f, 2.30209506e-03f,
  -1.24420851e-01f, -1.71574354e-01f, -1.07946778e-02f, 1.35271445e-01f, 2.85423435e-02f, 1.11099342e-02f, 2.62070566e-01f, -7.26078898e-02f, -5.60821444e-02f, 1.53809562e-01f,
  9.52576771e-02f, 6.52253404e-02f, -1.09551132e-01f, 1.90948267e-02f, 5.10495752e-02f, 1.34801909e-01f, 1.66800350e-01f, -8.59116688e-02f, -9.94086042e-02f, -1.22389980e-01f,
  1.42539144e-01f, 7.50860348e-02f, 7.27606490e-02f, -6.30616620e-02f, 8.24299604e-02f, 2.54081398e-01f, 4.33069691e-02f, -5.69303185e-02f, -2.06073418e-01f, -9.11977291e-02f,
  -1.44416885e-02f, -2.09739313e-01f, 1.22612186e-01f, -1.24943540e-01f, -1.09317668e-01f, 3.17051709e-01f, 3.11371833e-01f, 1.22629471e-01f, -2.15774417e-01f, -3.69400442e-01f,
  -7.71695524e-02f, -3.28654312e-02f, 4.26993132e-01f, -9.91128013e-02f, -1.42881900e-01f, -1.15168028e-01f, 3.81086431e-02f, 8.24883021e-03f, 2.66325772e-01f, -4.47684957e-04f,
  -8.17388445e-02f, -1.79904755e-02f, 1.82276711e-01f, 1.70498922e-01f, 3.03999484e-01f, 3.25661898e-01f, 3.07225853e-01f, 1.36528094e-03f, -6.05796129e-02f, 8.14462006e-02f,
  -7.95275252e-03f, 6.12268627e-01f, -5.20710321e-03f, -5.52456319e-01f, -2.12553218e-01f, -2.48502125e-03f, 3.27557698e-02f, -2.76097395e-02f, -1.89126745e-01f, 9.33954492e-02f,
  -2.03072399e-01f, -7.90188536e-02f, -1.94268405e-01f, -1.02385178e-01f, 2.87624776e-01f, -5.41789420e-02f, -4.72764112e-03f, -6.66274652e-02f, 1.27236784e-01f, -1.75890908e-01f,
  5.80471903e-02f, 2.83305496e-01f, -2.20228910e-01f, 1.40261993e-01f, 1.41573310e-01f, 1.09170288e-01f, 1.21588877e-03f, 7.86746815e-02f, 1.32903993e-01f, -2.37159207e-02f,
  2.16893718e-01f, -3.18429731e-02f, 2.54031777e-01f, 3.79597098e-01f, -4.24939767e-03f, -1.72697440e-01f, 1.82550773e-03f, 3.62878889e-02f, 1.68386281e-01f, -1.24846995e-01f,
  -2.45280173e-02f, -1.54399052e-01f, -4.46616560e-02f, 1.57031268e-01f, 1.47745043e-01f, 4.58597541e-02f, 1.56908408e-01f, 7.99363852e-02f, -1.54483140e-01f, 5.10932244e-02f,
  -7.86988288e-02f, -3.93124893e-02f, -1.62684768e-01f, -1.91920847e-01f, -2.64549315e-01f, 1.68723296e-02f, -8.14020708e-02f, 3.52740735e-01f, 2.97670484e-01f, -1.05977967e-01f,
  -4.12524231e-02f, -3.64541635e-02f, -5.69938123e-03f, 3.34152617e-02f, -8.55086148e-02f, -2.89910138e-01f, -1.05107024e-01f, 4.15486038e-01f, 5.55694960e-02f, 1.39419705e-01f,
  3.67360711e-01f, 1.97143316e-01f, 4.39449281e-01f, -4.29703474e-01f, -4.49144602e-01f, 1.02638640e-02f, 3.08722079e-01f, 5.15923202e-02f, 1.31755069e-01f, -1.65911928e-01f,
  -8.93104896e-02f, 1.58401847e-01f, -2.03206986e-01f, 2.54251081e-02f, -1.90148860e-01f, 9.10769105e-02f, 1.24029413e-01f, -5.22924401e-03f, -1.19707949e-01f, 8.45838487e-02f,
  -1.03443936e-01f, -6.58285394e-02f, 5.01744568e-01f, -2.57528991e-01f, -6.96670264e-02f, 2.44717263e-02f, 1.18384995e-02f, 2.00860295e-02f, -1.52778238e-01f, -1.87819168e-01f,
  2.14010142e-02f, 8.88228491e-02f, 7.84018636e-02f, 6.54838830e-02f, -7.78258294e-02f, -1.99587956e-01f, -7.03127757e-02f, 1.35080814e-01f, -3.49432305e-02f, 4.36464474e-02f,
  7.36486763e-02f, 3.65691930e-02f, -1.32722795e-01f, 1.38485268e-01f, 5.53690605e-02f, -1.67772740e-01f, -1.02604374e-01f, 2.38863394e-01f, 1.87924400e-03f, -1.21594459e-01f,
  8.53724629e-02f, 5.68179861e-02f, 1.29878074e-01f, 4.63831276e-02f, 5.69092594e-02f, -1.35492951e-01f, 1.13927446e-01f, 1.38161510e-01f, -4.00858670e-02f, -1.40247673e-01f,
  1.22018240e-01f, -1.01717189e-01f, 2.49457642e-01f, 1.04447618e-01f, -9.42702070e-02f, -2.88411863e-02f, 2.67388046e-01f, 2.96256334e-01f, 2.15804800e-01f, -1.10606678e-01f,
  -2.18930677e-01f, 2.18610898e-01f, -1.22601099e-01f, 1.71755627e-01f, -5.43058515e-02f, 1.35024801e-01f, -6.05130009e-02f, -3.31053250e-02f, 9.37869251e-02f, -4.14546244e-02f,
  -6.80211931e-02f, 1.16485963e-02f, 3.05512905e-01f, 2.58271039e-01f, 1.79579884e-01f, -1.23192575e-02f, -1.69508561e-01f, 2.17996284e-01f, 2.38964036e-01f, -7.39138573e-02f,
  -1.60283431e-01f, 1.68440640e-01f, 3.32394615e-02f, 7.00613367e-04f, -2.00205967e-01f, 1.35099128e-01f, 1.92829043e-01f, -5.62462322e-02f, 9.28799212e-02f, -4.16107029e-01f,
  -6.43190682e-01f, -2.95819819e-01f, 5.26548922e-01f, -2.26743162e-01f, 3.74742359e-01f, -3.36294711e-01f, -2.11180195e-01f, -1.27934933e-01f, -1.72071710e-01f, -1.77773386e-02f,
  -1.59761682e-01f, 4.79942739e-01f, -9.26842019e-02f, 6.97361454e-02f, -2.20359147e-01f, 1.72178522e-01f, 3.24851871e-01f, 1.94472581e-01f, 4.87444341e-01f, -2.04041854e-01f,
  1.41086221e-01f, 1.34088993e-01f, 2.39193439e-01f, 3.94510567e-01f, -1.67055771e-01f, -1.51756406e-01f, -5.00088371e-03f, 1.09672047e-01f, -2.42157355e-02f, 3.06956805e-02f,
  4.33117598e-02f, -1.82380050e-01f, 2.09258661e-01f, 1.60751417e-01f, 1.65126115e-01f, -1.12834148e-01f, 1.70542195e-01f, -1.75528884e-01f, -2.28115134e-02f, 1.57061994e-01f,
  -1.62934944e-01f, -6.86908066e-02f, -7.36031830e-02f, -8.12998414e-02f, -1.44306431e-02f, 5.91942435e-03f, -5.79794729e-03f, 1.06028557e-01f, 3.12441558e-01f, 8.89965221e-02f,
  -1.11106947e-01f, 1.46134466e-01f, -1.76795304e-01f, -3.66574302e-02f, 1.60242945e-01f, -2.18642682e-01f, -1.34406820e-01f, 1.58329293e-01f, -2.16746002e-01f, 4.93288040e-02f,
  4.07670289e-01f, -7.44946301e-02f, 4.19364460e-02f, -2.61628985e-01f, -4.86468315e-01f, -3.05037320e-01f, -5.96272536e-02f, 3.67978029e-02f, 3.82987499e-01f, -3.75965089e-02f,
  -8.92067701e-02f, -2.55332112e-01f, -7.22178966e-02f, -1.28788516e-01f, 2.33621612e-01f, 6.28579915e-01f, 2.69151647e-02f, 4.05957907e-01f, 2.37370759e-01f, -6.71153069e-02f,
  -9.95457321e-02f, -1.89123601e-01f, -3.49987477e-01f, 3.11573327e-01f, -5.52324615e-02f, 2.85181016e-01f, 4.70485896e-01f, -1.33949935e-01f, -9.29743052e-02f, -9.65032727e-02f,
  3.13840240e-01f, 7.82182589e-02f, -4.36685719e-02f, -2.77955472e-01f, -1.04212992e-01f, -3.54529262e-01f, 1.54994339e-01f, 9.57267508e-02f, 2.71714717e-01f, -5.25843203e-02f,
  5.29516637e-02f, 1.52768299e-01f, -7.89441839e-02f, 2.23875150e-01f, -2.47174618e-03f, -1.70837358e-01f, 4.11924161e-02f, -1.22024022e-01f, -1.39959753e-01f, 1.56270981e-01f,
  -2.74834194e-04f, 2.77916342e-01f, 1.72815576e-01f, 1.85576096e-01f, 1.48670256e-01f, -8.87451544e-02f, -1.64684772e-01f, -2.23004725e-02f, 1.60468191e-01f, -1.89240962e-01f,
  4.83804867e-02f, 4.95435238e-01f, -1.26599506e-01f, -1.48820713e-01f, 2.23740757e-01f, 1.71971954e-02f, 2.14180380e-01f, 7.16337785e-02f, -2.63473362e-01f, 1.16013154e-01f,
  1.67799130e-01f, -7.89968818e-02f, 5.54693639e-02f, 2.57493444e-02f, -8.78486857e-02f, 6.37830347e-02f, 1.34998620e-01f, 1.50620475e-01f, -1.59780502e-01f, 3.12955007e-02f,
  -9.95122045e-02f, -2.07139388e-01f, 9.01877210e-02f, -6.12936579e-02f, -4.98538800e-02f, 6.38887808e-02f, 3.75626832e-01f, -9.49133560e-03f, 2.25134455e-02f, 7.85943568e-02f,
  -1.76153425e-03f, 2.93791980e-01f, -1.41028613e-02f, -1.09014094e-01f, 8.01027939e-02f, 8.98448154e-02f, 6.77962750e-02f, -2.44832292e-01f, -8.41468945e-02f, 3.79125774e-02f,
  -1.53630212e-01f, -1.42579034e-01f, -2.85025761e-02f, -1.67130917e-01f, 8.90903771e-02f, 2.10714385e-01f, 1.44319504e-01f, 7.49304220e-02f, -6.30586445e-02f, 3.38595323e-02f,
  -8.68490487e-02f, -4.89480384e-02f, -2.68595982e-02f, 5.16188852e-02f, 2.49741748e-02f, 2.93159187e-01f, 2.09670156e-01f, 1.72468886e-01f, -1.71568111e-01f, 7.49362484e-02f,
  8.72923136e-02f, 2.51846202e-02f, -5.62695228e-02f, -9.02903602e-02f, -1.26487359e-01f, 7.46161714e-02f, 1.28073707e-01f, -1.11758977e-01f, -5.57043105e-02f, 2.42127091e-01f,
  8.53271261e-02f, -4.68086898e-01f, -2.73327045e-02f, 4.75608498e-01f, 2.94662386e-01f, -1.28738537e-01f, 4.56187159e-01f, 1.26505956e-01f, -1.37428910e-01f, 2.48819171e-03f,
  4.72895764e-02f, -1.14184774e-01f, -3.19209784e-01f, -2.02892616e-01f, 3.63807321e-01f, 1.63973197e-01f, -8.83340687e-02f, -1.99351721e-02f, -2.92610209e-02f, 2.30633169e-02f,
  4.82425898e-01f, 1.06306067e-02f, 1.59967437e-01f, 4.07946892e-02f, -1.34730950e-01f, 3.10548116e-02f, 1.00510269e-01f, 5.48727632e-01f, 1.21856734e-01f, -1.22276038e-01f,
  -3.68882231e-02f, 9.19442400e-02f, 1.77849904e-02f, 5.58150597e-02f, -1.70139268e-01f, -9.84102041e-02f, 1.97921142e-01f, 1.35470778e-01f, -5.49016334e-02f, -2.75354266e-01f,
  -6.37242617e-03f, 2.96837483e-02f, 1.33489192e-01f, -1.57696903e-02f, -1.54508976e-02f, -4.32240404e-02f, 3.93138438e-01f, -1.21915422e-01f, 9.68302786e-03f, 1.81513205e-01f,
  -1.22201815e-01f, 2.52047002e-01f, 1.85941651e-01f, -2.05195382e-01f, 3.63863371e-02f, -2.97886375e-02f, 1.32562444e-01f, 1.93292275e-01f, -1.51947394e-01f, 2.94955879e-01f,
  2.05900371e-01f, -1.25255078e-01f, 2.21613050e-01f, 2.39907368e-03f, 1.02845520e-01f, 4.14310932e-01f, 6.65331364e-01f, 1.18604563e-01f, 1.04766116e-01f, -6.87095448e-02f,
  -2.35753909e-01f, -4.02659597e-03f, -1.19331755e-01f, -1.69231713e-01f, -1.72165900e-01f, -2.09981240e-02f, 5.21380365e-01f, -2.06055433e-01f, 3.09432685e-01f, 4.15680483e-02f,
  2.74084866e-01f, 7.46006072e-01f, 1.34391308e-01f, 1.77619621e-01f, -2.41662323e-01f, 2.36522481e-02f, -1.43625904e-02f, -5.90557940e-02f, 1.85321700e-02f, -1.10883094e-01f,
  -9.97587368e-02f, 4.71035928e-01f, 6.75755665e-02f, -5.08153113e-03f, 2.07561627e-01f, 1.03780843e-01f, 2.48825252e-01f, 3.66218127e-02f, -1.95372820e-01f, 2.48797879e-01f,
  5.10599971e-01f, -2.46941354e-02f, -1.12736739e-01f, -6.12755120e-02f, 1.49176121e-01f, 1.69806302e-01f, -1.83998257e-01f, 2.89130472e-02f, 7.71539379e-03f, 1.45022437e-01f,
  2.79289782e-01f, -1.05336815e-01f, -1.89339504e-01f, 1.10256195e-01f, -1.81300923e-01f, 1.20121084e-01f, 4.22532290e-01f, -2.91366339e-01f, -2.26828501e-01f, 8.68126005e-02f,
  9.16801468e-02f, 1.88570172e-01f, -6.92278966e-02f, 5.44990972e-02f, 1.14734873e-01f, -1.58764467e-01f, -1.92801040e-02f, 4.39527094e-01f, 4.30697590e-01f, -3.84447038e-01f,
  -4.29332644e-01f, 1.91048503e-01f, -2.14982390e-01f, -1.38668537e-01f, 5.48951387e-01f, -2.99126834e-01f, 4.99513410e-02f, -1.77370962e-02f, -8.52553248e-02f, -1.87749907e-01f,
  -2.87018865e-01f, 1.69504911e-01f, 1.78653747e-02f, -1.25343218e-01f, -2.28067353e-01f, -3.21431577e-01f, -2.08075136e-01f, 4.18266878e-02f, 1.57654226e-01f, 1.95784628e-01f,
  -8.69763419e-02f, -8.24996755e-02f, -6.19922690e-02f, -1.62901338e-02f, -7.50147924e-02f, 1.18124001e-01f, -1.66420639e-01f, 4.38917242e-02f, -2.39989728e-01f, -1.09069265e-01f,
  9.75870267e-02f, 4.59501147e-01f, 2.77896017e-01f, -1.41981663e-02f, 6.23656288e-02f, 2.18385890e-01f, -2.09746659e-01f, -5.97435236e-02f, 7.71013424e-02f, 2.04812393e-01f,
  1.44069642e-01f, 4.74913344e-02f, -8.57402105e-03f, -2.73948640e-01f, 1.13707930e-01f, 8.33492652e-02f, 2.59711236e-01f, 3.73128861e-01f, 2.78793544e-01f, 9.37709808e-02f,
  1.85424596e-01f, -7.28475749e-02f, 1.11076929e-01f, -5.68583421e-02f, -2.84071416e-01f, 3.80494781e-02f, -8.22549835e-02f, 9.70569253e-02f, -2.00781673e-01f, 1.74164221e-01f,
  2.48733774e-01f, 1.18930630e-01f, 4.97944504e-02f, -5.69741242e-02f, -1.17065042e-01f, 2.95005888e-01f, 5.34048751e-02f, 1.40051723e-01f, -1.92561537e-01f, 3.99580076e-02f,
  4.34269803e-03f, -1.05121275e-02f, -8.78663827e-03f, 9.85718295e-02f, 2.02105477e-01f, 3.24778140e-01f, 2.73388565e-01f, -2.08283207e-04f, -1.34048507e-01f, 1.04855746e-01f,
  -3.31598639e-01f, 1.47159785e-01f, 3.24837655e-01f, -1.94713771e-01f, -2.81636715e-01f, 1.72671527e-01f, -1.70088336e-01f, -1.12365127e-01f, -1.13995880e-01f, 4.14301068e-01f,
  7.84659944e-03f, -2.84777861e-02f, 1.13650914e-02f, -8.62964839e-02f, -1.01730958e-01f, -1.79116547e-01f, -2.04394400e-01f, 2.75020152e-01f, 2.62487024e-01f, 6.36491776e-02f,
  -1.13540679e-01f, -1.00553066e-01f, 6.81880638e-02f, -3.92186679e-02f, 3.87062877e-02f, -6.00404330e-02f, 1.12903818e-01f, 3.41562405e-02f, 3.34985465e-01f, -2.65715998e-02f,
  9.45338830e-02f, 3.76813002e-02f, -5.02262078e-02f, 1.99325025e-01f, 1.94674999e-01f, -1.83410034e-01f, -2.68832117e-01f, 2.25637089e-02f, -5.72231114e-02f, 1.33254871e-01f,
  -1.11605942e-01f, 4.40856725e-01f, 2.76860058e-01f, 1.05041005e-01f, -4.81150635e-02f, 1.15731515e-01f, -6.72514737e-02f, -2.45242584e-02f, -2.35061675e-01f, 1.16405904e-01f,
  -1.84620067e-01f, -6.66064909e-03f, 3.59683841e-01f, -2.09854871e-01f, 6.40982017e-02f, -5.57369739e-02f, 1.05147257e-01f, 6.61191866e-02f, -1.30542293e-01f, 3.37909795e-02f,
  3.36900473e-01f, 3.52277271e-02f, 1.57397985e-01f, 1.76740140e-01f, -2.21492097e-01f, 3.41699898e-01f, 1.28710926e-01f, 1.11672014e-01f, 2.57616252e-01f, -9.81088206e-02f,
  1.73173249e-01f, 5.73921263e-01f, 1.61716357e-01f, -1.77965701e-01f, -2.93159187e-02f, 2.04494447e-01f, 1.26676992e-01f, 2.82594115e-01f, 8.70741308e-02f, 3.66889507e-01f,
  2.40941018e-01f, -2.70022422e-01f, -4.87811714e-02f, -1.95264563e-01f, 1.82920277e-01f, -2.13180229e-01f, -1.15678348e-02f, 8.75372887e-02f, -4.75105606e-02f, 1.72413632e-01f,
  4.06173497e-01f, 7.81384110e-02f, -3.46976995e-01f, -9.25667137e-02f, 8.12422633e-02f, 4.78492111e-01f, 4.63347763e-01f, 2.21900806e-01f, 1.97515965e-01f, 1.87203020e-01f,
  2.34015271e-01f, -1.31264284e-01f, 6.57292642e-03f, 1.04219839e-01f, 6.02175295e-03f, -3.81987900e-01f, -4.09564339e-02f, 1.72835052e-01f, -2.51371771e-01f, -3.50975096e-02f,
  -1.37966871e-01f, -3.12517941e-01f, -8.90724957e-02f, -1.04154022e-02f, -7.62703642e-02f, -1.22940978e-02f, 3.02313864e-01f, -1.77109554e-01f, -1.56815976e-01f, -8.17222521e-02f,
  8.60889181e-02f, 1.32924676e-01f, -2.10918754e-01f, 1.12562791e-01f, -1.02072112e-01f, 1.92233443e-01f, -1.21644750e-01f, -3.24407876e-01f, -1.66382432e-01f, -1.09840415e-01f,
  1.61583558e-01f, 9.75906104e-02f, -6.07063025e-02f, 7.32785389e-02f, 8.56482312e-02f, 4.23374325e-02f, 6.34486303e-02f, 2.21230555e-02f, 1.56419836e-02f, 8.33533481e-02f,
  5.92600644e-01f, 5.86430669e-01f, 5.56687176e-01f, 2.06394434e-01f, 2.74972945e-01f, 1.79477572e-01f, -2.10569203e-01f, -2.38187209e-01f, 4.47453260e-01f, 3.14593524e-01f,
  -1.00903526e-01f, -1.66372240e-01f, -4.31565978e-02f, 3.75113934e-02f, 2.42645025e-01f, 4.67754109e-03f, 2.67252147e-01f, -1.26822472e-01f, 2.33531058e-01f, -7.40426853e-02f,
  -1.35182276e-01f, -2.24788815e-01f, -1.35215744e-01f, 1.07524204e+00f, -1.85329318e-01f, -2.13444680e-01f, -1.67162478e-01f, -3.87895137e-01f, -4.75066639e-02f, 4.11068290e-01f,
  -2.57741868e-01f, -1.70145050e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.75749278e-02f, 1.77564874e-01f, 8.41474384e-02f, -1.06867522e-01f, 1.11700408e-01f, 7.93297738e-02f, -3.39999795e-02f, 4.38407436e-02f, 2.45459646e-01f, 1.49159938e-01f,
  2.16215670e-01f, -1.45481810e-01f, 6.76096510e-03f, -8.94189179e-02f, 7.32407272e-02f, -3.07146609e-02f, 3.69059771e-01f, -2.03371421e-02f, 1.19258583e-01f, 1.67756662e-01f,
  3.12301099e-01f, -3.29910638e-03f, 1.84379071e-01f, 7.29004517e-02f, -9.64343324e-02f, 4.08361614e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -1.98961258e-01f, -3.74546885e-01f, -5.07545695e-02f, 3.38057816e-01f, 1.43570527e-01f, -3.07840616e-01f, 4.81380038e-02f, -1.16357103e-01f, -2.32838348e-01f, 1.24502614e-01f,
  -1.01440158e-02f, -1.31314486e-01f, -1.30774394e-01f, -2.03443259e-01f, 1.09542301e-02f, 2.43500963e-01f, -5.47874682e-02f, 1.91699594e-01f, -1.84795111e-01f, -5.95877729e-02f,
  7.76840746e-01f, -5.68428449e-02f, -5.89819312e-01f, -2.20354542e-01f, 6.47238791e-01f, -3.00619245e-01f, -5.19715585e-02f, 2.05883905e-01f, 2.91150302e-01f, -5.03652573e-01f,
  4.39568073e-01f, 1.71222687e-01f, 1.06787704e-01f, -1.67294055e-01f, -1.42891690e-01f, -2.98108071e-01f, -3.08305234e-01f, 2.20086753e-01f, 2.64540166e-02f, -3.29453573e-02f,
  4.62207317e-01f, 3.25867355e-01f, -2.22344637e-01f, 3.07927996e-01f, 2.99424808e-02f, -2.75282294e-01f, 7.24933743e-01f, -5.39891906e-02f, 8.56850967e-02f, 2.62620840e-02f,
  2.94690609e-01f, -9.58728343e-02f, -1.57305151e-01f, 8.71778503e-02f, -5.25662124e-01f, -8.78971964e-02f, 2.31683627e-01f, 1.60722941e-01f, -2.37149701e-01f, -5.86303920e-02f,
  3.02010685e-01f, 1.45890281e-01f, 4.82511729e-01f, -8.68585527e-01f, 2.13791415e-01f, 5.88657677e-01f, 2.78601944e-01f, 5.11205196e-01f, 2.46137500e-01f, -5.01148820e-01f,
  -1.64685741e-01f, 8.89649801e-03f, 5.13461173e-01f, 3.01081032e-01f, -2.33100981e-01f, -1.35225400e-01f, 3.15508321e-02f, -1.58011332e-01f, 3.36317033e-01f, 9.20503065e-02f,
  2.22865105e-01f, -2.03519434e-01f, -1.49445668e-01f, -8.56385976e-02f, -3.26965809e-01f, -1.78512096e-01f, -9.57778245e-02f, -2.95515180e-01f, -2.78416246e-01f, -4.71387625e-01f,
  -3.41101885e-01f, -1.81894630e-01f, 3.85911971e-01f, 5.26574433e-01f, -2.97893047e-01f, 2.18411889e-02f, 2.43378356e-01f, -1.47022530e-01f, 2.72273660e-01f, 1.06849611e-01f,
  3.91558647e-01f, -4.76037338e-02f, -8.59994218e-02f, -2.27505863e-01f, -4.62830067e-01f, -2.69813687e-01f, 2.96476603e-01f, -4.70173657e-02f, -9.46801305e-02f, -2.30594426e-01f,
  -4.84578520e-01f, 3.42604369e-02f, -1.42218783e-01f, 3.23895484e-01f, -9.31693316e-02f, 2.34766509e-02f, 2.56116003e-01f, -6.03841133e-02f, 3.76970172e-01f, -7.36199692e-02f,
  -1.37567028e-01f, -1.61476165e-01f, 4.45693374e-01f, 3.03302258e-01f, -7.71409944e-02f, -2.53760159e-01f, -3.51083055e-02f, 4.58289921e-01f, 5.14683453e-03f, -4.16737013e-02f,
  -2.71174937e-01f, 4.47107553e-01f, 4.09725815e-01f, -1.56574994e-01f, 4.53682989e-02f, 2.74648309e-01f, -2.87427932e-01f, -1.21969134e-01f, -1.27716288e-01f, -2.87639797e-01f,
  2.06132144e-01f, 1.87198848e-01f, -5.90004444e-01f, 3.62532102e-02f, -1.19259544e-01f, -3.18240076e-01f, 1.63941011e-01f, 5.49570774e-04f, -1.19114975e-02f, -2.03019246e-01f,
  -1.49357334e-01f, -1.97684467e-01f, 9.73104760e-02f, -8.42354223e-02f, -1.31568268e-01f, -3.37075591e-01f, 7.65845329e-02f, -1.43972971e-02f, -1.12548180e-01f, 1.15106785e+00f,
  5.79758406e-01f, 3.53292435e-01f, 4.90908027e-01f, -2.37014771e-01f, 4.43222612e-01f, -4.35750008e-01f, 2.16351956e-01f, 1.02905035e-02f, 1.89585075e-01f, -1.98299482e-01f,
  3.39917913e-02f, 7.02949345e-01f, 1.61509514e-01f, -2.21596174e-02f, 3.48324239e-01f, -5.98999932e-02f, -4.04695198e-02f, -2.00999334e-01f, 1.82388172e-01f, -1.47048309e-01f,
  5.26296459e-02f, -2.73381397e-02f, -4.69839156e-01f, 1.83548495e-01f, 7.03166306e-01f, -2.44046733e-01f, 3.48356366e-01f, 5.97952530e-02f, 1.28789721e-02f, -6.85747489e-02f,
  -8.41295794e-02f, 2.45649517e-01f, -2.09809855e-01f, -2.63461053e-01f, -2.04581171e-02f, 2.61117041e-01f, -4.68933225e-01f, 3.39790791e-01f, 1.30678922e-01f, -9.96490791e-02f,
  4.54508871e-01f, 2.46246248e-01f, -1.62597880e-01f, -3.05158079e-01f, -2.48806238e-01f, 4.78023589e-01f, -4.82775755e-02f, -2.70803511e-01f, -4.78008270e-01f, -2.66111195e-01f,
  -2.12378979e-01f, 4.33651283e-02f, -5.09332597e-01f, -4.32160534e-02f, 2.10494906e-01f, -2.78555632e-01f, -2.72034287e-01f, 3.04030895e-01f, -1.82817951e-01f, -2.73708820e-01f,
  3.54978979e-01f, 4.84227568e-01f, 9.87224057e-02f, -8.68694961e-01f, -2.53790826e-01f, -1.53965607e-01f, -6.03422225e-01f, -5.29443026e-01f, -3.13382536e-01f, 1.20168291e-01f,
  -6.26855493e-02f, -1.16809756e-01f, -4.47751135e-01f, -2.64644295e-01f, 4.69831318e-01f, -2.69636363e-01f, 1.88531447e-02f, 3.36639881e-02f, 8.44778121e-02f, 4.09969002e-01f,
  -2.82369345e-01f, 6.28644764e-01f, -2.88030922e-01f, 2.33232304e-01f, 7.83573166e-02f, 6.32122084e-02f, 4.11582798e-01f, 1.68767422e-02f, -3.39615315e-01f, 1.26361832e-01f,
  -1.58214763e-01f, 3.82235013e-02f, -3.42349410e-01f, 8.94526392e-02f, -1.74947664e-01f, -7.69884586e-02f, -4.51263994e-01f, -7.51264244e-02f, -2.16262579e-01f, -4.87667352e-01f,
  -5.82876623e-01f, 3.87930036e-01f, 6.83938712e-02f, -1.96995586e-01f, -2.64703304e-01f, -2.29042694e-01f, 8.73668790e-02f, 4.98020113e-01f, 3.26996930e-02f, -2.13432118e-01f,
  5.63068092e-01f, -4.63599488e-02f, -3.05067807e-01f, 1.27351612e-01f, 2.00421616e-01f, 6.78369999e-02f, 1.11492030e-01f, 1.28772452e-01f, -3.72860879e-01f, 6.50125325e-01f,
  -3.37793738e-01f, -1.60976633e-01f, 3.36673588e-01f, 3.60764444e-01f, -4.04901028e-01f, -4.05394047e-01f, 8.57194215e-02f, -2.66519785e-01f, 5.77873699e-02f, 4.33418959e-01f,
  2.89960980e-01f, 3.57009083e-01f, -1.63165897e-01f, -2.46646255e-01f, 5.15642241e-02f, 3.05536747e-01f, 7.90122822e-02f, -1.28757805e-01f, 3.77988592e-02f, -2.73924582e-02f,
  -1.80058897e-01f, 3.90196532e-01f, -6.19605303e-01f, 1.06345877e-01f, -4.49492306e-01f, 7.33121997e-03f, -3.14216882e-01f, -2.12065205e-02f, -4.38315421e-01f, -3.95011961e-01f,
  6.44565940e-01f, -2.03591317e-01f, -2.53899813e-01f, 4.24025893e-01f, -2.40631059e-01f, -1.08400345e-01f, -3.50691348e-01f, 4.61830229e-01f, -1.24982119e-01f, 3.63454819e-01f,
  -1.30533367e-01f, 4.71058279e-01f, 7.26899505e-02f, -4.00525600e-01f, 8.33820105e-02f, 3.57434362e-01f, 9.29507986e-02f, -2.39784226e-01f, -4.12674338e-01f, 1.87632740e-01f,
  -1.51601747e-01f, -6.29160926e-02f, 1.49664253e-01f, 9.16529596e-02f, 2.28612170e-01f, -8.79343748e-02f, 1.15486431e+00f, -1.70825705e-01f, -2.74453878e-01f, 2.02585131e-01f,
  -5.05202949e-01f, 3.03494814e-03f, -2.35887289e-01f, -2.63650715e-01f, -1.80071563e-01f, -2.72517592e-01f, 1.38087630e-01f, -6.68136775e-02f, -5.53540401e-02f, -3.50075930e-01f,
  9.77930352e-02f, -2.18820237e-02f, 7.65369833e-02f, 1.29974157e-01f, -4.44312431e-02f, 3.97351474e-01f, -6.74609020e-02f, 4.29020375e-01f, -1.65644526e-01f, -1.00047387e-01f,
  -8.19758773e-02f, -1.40235126e-01f, -3.86538178e-01f, -1.50105357e-01f, -7.64739588e-02f, 3.08637116e-02f, -2.94184834e-01f, -8.22305456e-02f, -3.45291466e-01f, -2.86029652e-02f,
  -8.68322849e-02f, -2.26160660e-01f, 7.08633661e-02f, 5.06573737e-01f, 5.18540561e-01f, 2.56823659e-01f, -4.89529260e-02f, 3.29312772e-01f, 3.72593850e-01f, 4.84022319e-01f,
  4.20957744e-01f, -2.04697892e-01f, -9.87620652e-02f, -3.95000249e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.91354811e-01f, -4.64182764e-01f, 2.12868378e-01f, 6.98870718e-02f, 2.89738506e-01f, 9.64118615e-02f, -1.30315544e-02f, -2.62019604e-01f, -3.08170021e-01f, 9.47889388e-02f,
  1.41191840e-01f, 4.43484914e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    