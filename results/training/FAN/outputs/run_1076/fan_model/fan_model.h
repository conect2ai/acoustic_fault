/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.44962171e-01f, 9.15806815e-02f, 2.39905760e-01f, 2.52837867e-01f, -3.25697176e-02f, -3.84780504e-02f, -8.60700198e-03f, -3.73865664e-02f, 9.07330513e-02f, 1.74212188e-01f,
  1.24437604e-02f, 4.53991145e-02f, 1.32811531e-01f, 9.34759378e-02f, 2.54213601e-01f, 3.05118233e-01f, 2.37482965e-01f, 2.21307531e-01f, 6.54630363e-02f, -1.26640975e-01f,
  -1.12575151e-01f, 1.37164108e-02f, -2.72465385e-02f, -4.90820259e-02f, 2.89635584e-02f, 4.18276116e-02f, 9.76563618e-02f, -7.41758645e-02f, -7.32502267e-02f, 1.13759577e-01f,
  5.81641309e-02f, -6.60021678e-02f, -1.08125694e-02f, -1.15201451e-01f, -9.99571905e-02f, 8.25187266e-02f, -6.49165735e-02f, 9.29662120e-03f, 3.68091068e-03f, -4.08995990e-03f,
  -2.69221943e-02f, 2.86082309e-02f, -4.48729703e-03f, -1.42002091e-01f, -5.99983893e-02f, -1.13357536e-01f, -1.76517554e-02f, -3.42228333e-03f, 9.57228392e-02f, -1.23031840e-01f,
  -9.18042213e-02f, -5.14351502e-02f, 1.53991412e-02f, 1.23942774e-02f, -6.05339408e-02f, -4.04176377e-02f, -7.52454326e-02f, -8.04426670e-02f, 4.89282422e-04f, -4.92844470e-02f,
  4.90592793e-02f, 3.14046256e-02f, 2.59662308e-02f, 5.92194088e-02f, -3.69449034e-02f, 5.47940098e-03f, 2.00832952e-02f, 4.66944724e-02f, -3.31173129e-02f, -1.70334149e-02f,
  -9.61174548e-04f, 6.18994720e-02f, 1.28023396e-03f, 1.15017615e-01f, 4.69529815e-02f, 2.72635017e-02f, -2.93022152e-02f, -3.68588492e-02f, 6.91492781e-02f, 4.61010449e-02f,
  -5.19563723e-03f, -1.38168093e-02f, 7.75436535e-02f, 8.70916410e-04f, -3.15765627e-02f, 8.42411444e-02f, -8.22527334e-03f, -1.75028818e-03f, 7.12574199e-02f, -7.86165595e-02f,
  6.63593039e-02f, -2.81347404e-03f, 1.39766186e-01f, 6.70548528e-02f, 5.34235947e-02f, -7.14014173e-02f, 8.91790465e-02f, 1.20237179e-03f, -5.93715906e-02f, -6.99875578e-02f,
  -6.46893308e-02f, -5.99373365e-03f, 4.57791425e-02f, -4.70721759e-02f, -1.22634172e-01f, 1.58925280e-02f, 8.50531925e-03f, 6.43678829e-02f, 1.32857636e-02f, -1.67886510e-01f,
  1.11139449e-03f, -4.88022156e-02f, 8.46671313e-02f, 1.04619376e-01f, -2.94357073e-02f, 8.47411305e-02f, 5.19312024e-02f, -1.07765140e-03f, 4.88988049e-02f, 1.57119215e-01f,
  -1.34593263e-01f, 1.11959867e-01f, -3.52599025e-01f, -2.27894798e-01f, -1.15168795e-01f, -1.78200662e-01f, 6.15589926e-03f, 4.63356152e-02f, -3.33216367e-03f, 2.45518740e-02f,
  1.25708610e-01f, 9.70532671e-02f, 1.61678329e-01f, 1.91833582e-02f, 4.47716005e-02f, -4.01301272e-02f, -3.09044361e-01f, -2.31412008e-01f, -1.20711751e-01f, -5.54382103e-03f,
  1.43202975e-01f, 5.06971218e-02f, -8.01898688e-02f, -2.52009486e-03f, -9.67871398e-02f, 6.16942979e-02f, 6.07659146e-02f, -9.63924974e-02f, 8.02904144e-02f, -2.24408522e-01f,
  -2.75075883e-02f, -9.28406641e-02f, 1.50104016e-02f, 3.51821184e-02f, -3.65974419e-02f, 1.13479845e-01f, 4.30542417e-02f, 9.98554230e-02f, 1.93568781e-01f, 7.21855182e-03f,
  8.09969939e-03f, 4.01448458e-02f, -4.83348593e-02f, 6.05783872e-02f, -7.58000016e-02f, -6.04647808e-02f, 4.06097248e-02f, -6.69475272e-02f, -4.05988172e-02f, 9.93464664e-02f,
  -1.58858101e-03f, -1.70482934e-01f, -1.77502036e-01f, 2.02011410e-02f, -1.59403458e-02f, -4.92500998e-02f, 6.84144720e-03f, -9.35167223e-02f, -1.93392485e-02f, 2.42731511e-03f,
  1.27488121e-01f, -3.46436501e-02f, -1.24813407e-03f, 5.45610078e-02f, 8.47218907e-04f, 7.19915517e-03f, -2.05202699e-02f, -4.03719321e-02f, 6.41426595e-04f, 3.53188850e-02f,
  -9.42964980e-04f, -3.85528840e-02f, 6.65619522e-02f, -6.28022477e-02f, 5.41445613e-02f, -1.14082590e-01f, -8.91375318e-02f, 1.42318606e-02f, -2.70874500e-02f, -1.73216760e-02f,
  3.48220021e-02f, -1.07364930e-01f, -1.54291010e-02f, 1.43502752e-04f, -5.71133867e-02f, -1.85932394e-03f, -3.86907980e-02f, 7.89980814e-02f, 5.96447326e-02f, -4.69355658e-02f,
  2.55529463e-01f, 7.74236768e-02f, 3.92256193e-02f, 1.09157721e-02f, -2.57749930e-02f, -2.65827635e-03f, -3.45125459e-02f, -5.94982281e-02f, -1.53624015e-02f, -1.11776907e-02f,
  -6.41505569e-02f, 2.91550886e-02f, 4.17500213e-02f, 1.10204192e-02f, 8.63556191e-02f, 1.47381611e-03f, 1.88141931e-02f, -1.11797340e-01f, -1.93362422e-02f, -1.06610423e-02f,
  3.58951394e-03f, -7.29161203e-02f, -1.05346359e-01f, -3.97323221e-02f, -7.89694414e-02f, -4.47966680e-02f, -2.08881665e-02f, -1.38590261e-02f, -6.43063337e-02f, 1.59819216e-01f,
  -2.19523013e-01f, 8.45445395e-02f, 2.46304095e-01f, -1.55875608e-01f, -9.60311294e-02f, 7.10907904e-03f, 2.90293340e-02f, -5.57612032e-02f, -1.18639335e-01f, -1.31481022e-01f,
  -1.55183271e-01f, -2.50716239e-01f, -1.36681780e-01f, -9.46962982e-02f, -1.22857220e-01f, 2.40146413e-01f, 1.62078470e-01f, 1.09145828e-02f, -1.50814041e-01f, -2.05707550e-01f,
  -1.97605312e-01f, -1.04269490e-01f, -4.07286510e-02f, -4.01362684e-03f, 2.30722651e-02f, -1.07115947e-01f, 1.38600379e-01f, 5.20086177e-02f, 8.65666121e-02f, 3.20709348e-01f,
  1.79943800e-01f, 7.40993097e-02f, 1.00628268e-02f, -1.47285998e-01f, 3.79510373e-02f, 3.16637680e-02f, 5.09616766e-05f, 2.59341560e-02f, 1.42457169e-02f, 5.39725944e-02f,
  4.73148841e-03f, -2.31268983e-02f, 2.26407051e-02f, -2.76384298e-02f, -2.40598060e-02f, -3.99857685e-02f, 2.76128184e-02f, 3.54244970e-02f, 2.75003631e-02f, 3.17228073e-03f,
  -7.71558583e-02f, -6.57619163e-02f, -3.15363370e-02f, -1.58235766e-02f, -1.07911052e-02f, -7.46145248e-02f, 4.66020731e-03f, -2.10463349e-02f, 5.91078997e-02f, 1.38296455e-01f,
  -1.20450035e-02f, 8.56846273e-02f, 2.28197742e-02f, 6.46459609e-02f, 1.55465677e-02f, 7.84319118e-02f, 3.04637402e-02f, 2.70164777e-02f, 2.40013599e-02f, 5.05213346e-03f,
  3.71227111e-03f, 6.43696412e-02f, -3.84310484e-02f, 3.77761535e-02f, -7.74903968e-03f, -8.33617896e-03f, -4.59253863e-02f, 8.11164156e-02f, 2.75207385e-02f, 1.09186089e-02f,
  -4.64758053e-02f, 1.17719490e-02f, 5.95808327e-02f, -3.33107263e-02f, 3.61506045e-02f, 5.23541681e-02f, 4.76658605e-02f, -1.05578196e-03f, -4.97244149e-02f, -7.29977489e-02f,
  -2.23663583e-01f, -3.65881063e-02f, -6.36379570e-02f, -2.60941219e-02f, 5.47466986e-02f, 1.79153886e-02f, -2.10048817e-02f, -5.86185940e-02f, -3.06946915e-02f, -4.23664637e-02f,
  -5.07133566e-02f, -2.24882588e-02f, 3.49386148e-02f, -6.20418340e-02f, -1.09856259e-02f, -4.67310064e-02f, 4.61802818e-02f, -1.37435216e-02f, -1.00207984e-01f, 2.32768860e-02f,
  4.16051559e-02f, -1.48756877e-01f, -1.37384072e-01f, -8.56191963e-02f, -1.04650684e-01f, -1.29127577e-01f, -4.50462177e-02f, -5.50864302e-02f, -1.54167071e-01f, -1.05023123e-01f,
  -6.47343755e-01f, 2.85204381e-01f, 1.99064314e-01f, -2.00821012e-01f, 9.21265185e-02f, -5.76421991e-02f, 1.39875310e-02f, 4.87195440e-02f, 9.70816612e-02f, 2.00670317e-01f,
  1.55814931e-01f, 1.95652649e-01f, 2.29436859e-01f, 1.78296000e-01f, 2.65910737e-02f, 2.50260621e-01f, 8.04048181e-02f, -1.17860697e-01f, -5.74629419e-02f, 4.49145660e-02f,
  9.67394039e-02f, -2.78392136e-02f, -2.10005313e-01f, -2.44930200e-02f, 2.30076134e-01f, 9.85114649e-02f, 2.21160159e-01f, 4.32601683e-02f, 1.72024712e-01f, 3.00231159e-01f,
  1.48659483e-01f, 2.43531223e-02f, 6.06907196e-02f, 1.32668599e-01f, 1.08881116e-01f, 6.76652491e-02f, 7.28065073e-02f, 1.54246777e-01f, 3.71942669e-02f, 9.25127193e-02f,
  1.81861252e-01f, 7.79334083e-03f, 1.45846019e-02f, 1.45642102e-01f, 6.04084469e-02f, 1.12077430e-01f, 4.26623151e-02f, 6.67900667e-02f, 3.95393223e-02f, 2.12525755e-01f,
  2.25359648e-01f, -1.23899095e-02f, -1.30633004e-02f, 7.16441423e-02f, 5.09000197e-02f, 4.54468876e-02f, 1.98481530e-01f, 6.89765960e-02f, 1.08692586e-01f, 1.55893505e-01f,
  5.57411239e-02f, -1.96211897e-02f, 3.55978310e-02f, -1.02210745e-01f, 1.49769299e-02f, -6.31806906e-03f, 5.21419477e-03f, -2.60641612e-02f, -9.42808688e-02f, -3.04385461e-02f,
  4.11234088e-02f, 2.88920123e-02f, 1.61857288e-02f, -7.87435621e-02f, 1.20582115e-02f, -1.64802652e-02f, -3.52490358e-02f, 2.59424304e-03f, -1.00910105e-02f, -4.07436080e-02f,
  -7.69223943e-02f, -4.71406505e-02f, 7.45557770e-02f, 5.12465574e-02f, -1.99834350e-02f, -2.38994192e-02f, 2.98357126e-03f, 1.06822094e-02f, 2.19557993e-02f, 8.32870696e-03f,
  1.42589092e-01f, 2.78284159e-02f, 1.34554850e-02f, 5.63997403e-02f, 5.15407212e-02f, 7.01570660e-02f, 6.89363703e-02f, 1.12604313e-01f, 6.59264103e-02f, 7.16786832e-02f,
  1.12993650e-01f, 2.43489444e-02f, 3.88652645e-02f, 1.42379940e-01f, 3.71588953e-02f, 8.98269415e-02f, 7.11497366e-02f, 1.00324161e-01f, 1.19012341e-01f, 1.55970588e-01f,
  1.57797545e-01f, -5.05112186e-02f, -6.63817301e-02f, 9.08125713e-02f, 1.44513950e-01f, -6.63258955e-02f, 1.45720661e-01f, 5.35669504e-03f, -1.56340487e-02f, -2.88887434e-02f,
  1.55004367e-01f, -2.96964586e-01f, -1.62013955e-02f, -1.81911156e-01f, 4.90179798e-03f, -1.97397117e-02f, -3.95362563e-02f, 7.22300038e-02f, 8.13115910e-02f, -1.44452497e-01f,
  4.27092128e-02f, 1.47410780e-01f, 4.59028557e-02f, 2.16382548e-01f, 1.34633914e-01f, -2.17762649e-01f, -1.66419089e-01f, 8.76692161e-02f, 4.15853679e-01f, 9.82709527e-02f,
  1.17848162e-02f, -1.16455324e-01f, 1.57019883e-01f, 1.13595642e-01f, -4.24582548e-02f, 8.27297047e-02f, -1.38152316e-01f, -3.61650027e-02f, -3.49156708e-02f, -1.88261986e-01f,
  1.50043800e-01f, 6.66532815e-02f, 2.48956457e-01f, 9.59525350e-03f, 1.38464838e-01f, 3.28226499e-02f, 5.42313047e-02f, 4.80979644e-02f, 1.20201297e-02f, -4.19428423e-02f,
  4.08564508e-02f, 1.57575592e-01f, 8.39309767e-02f, 1.14162229e-01f, 1.43037001e-02f, 1.08713895e-01f, 3.42291705e-02f, 1.36132270e-01f, 1.28758460e-01f, 2.36885305e-02f,
  -8.81428048e-02f, -8.78486130e-03f, 1.71678036e-01f, 8.34378898e-02f, 1.46305174e-01f, 2.13208988e-01f, 1.57655135e-01f, 1.34467185e-01f, 2.54890651e-01f, 3.09728943e-02f,
  2.96283886e-03f, 3.79913710e-02f, 2.96973176e-02f, -1.02416255e-01f, -1.48838833e-02f, -7.69374371e-02f, -5.83937950e-02f, -1.27305582e-01f, 1.80005729e-02f, -4.98371944e-02f,
  -9.06982087e-03f, -7.15708286e-02f, -7.92837664e-02f, -1.02177210e-01f, 3.46006081e-02f, -3.52798589e-02f, 3.07276119e-02f, -9.08174217e-02f, 1.64253525e-02f, -6.01282227e-04f,
  3.04528251e-02f, 6.01659110e-03f, -2.35807523e-02f, -4.28095721e-02f, -4.35367264e-02f, -5.88703454e-02f, -8.02322328e-02f, 1.77420005e-02f, -9.67386514e-02f, -5.34430593e-02f,
  -9.41059589e-02f, 2.00800851e-01f, -8.28517675e-02f, 5.29222526e-02f, 7.67011493e-02f, 1.05988830e-01f, -4.75965925e-02f, 1.21977918e-01f, -8.68454017e-03f, 7.86801130e-02f,
  1.06608637e-01f, 8.01636875e-02f, 9.94627997e-02f, 4.57799323e-02f, 1.46011099e-01f, 9.49142799e-02f, 9.90100484e-03f, 1.12178398e-03f, 1.36479899e-01f, 7.70788491e-02f,
  2.11916752e-02f, 1.29951388e-02f, 9.28291678e-02f, 9.04145315e-02f, 2.82166749e-02f, 1.71023816e-01f, 1.46735877e-01f, 8.21891800e-02f, 9.05865878e-02f, -1.21509299e-01f,
  2.09684417e-01f, -5.77220097e-02f, -2.86760122e-01f, 3.02743129e-02f, -8.74283910e-02f, 6.24362342e-02f, -2.23834943e-02f, 1.75925583e-01f, 1.19790718e-01f, -4.17360328e-02f,
  9.24247652e-02f, 1.84021126e-02f, -3.72294746e-02f, 5.55791222e-02f, -1.04738036e-02f, -2.49566242e-01f, -2.29123622e-01f, -2.35625878e-01f, 1.23485625e-01f, 8.45079571e-02f,
  -2.28572320e-02f, -1.19494973e-02f, 3.32818106e-02f, -1.24697387e-01f, -2.42001787e-01f, -1.91570088e-01f, -3.50049734e-01f, -1.07612856e-01f, -2.66063511e-01f, -5.15067935e-01f,
  -1.85281828e-01f, 3.33904140e-02f, -5.95490970e-02f, -7.70798549e-02f, -1.46645904e-01f, 2.01815851e-02f, -2.86174472e-02f, -1.35004342e-01f, 6.11924492e-02f, -7.16106296e-02f,
  -1.03724776e-02f, -2.71564592e-02f, -8.46682489e-02f, -9.57293808e-03f, -9.11725312e-02f, -5.27552590e-02f, -8.98591876e-02f, -4.25313190e-02f, -2.85293162e-02f, -1.19589001e-01f,
  -1.17474394e-02f, -1.51495710e-01f, -1.98141068e-01f, -5.68191521e-02f, 2.93492395e-02f, -3.16152945e-02f, -1.59240201e-01f, -1.56130835e-01f, -3.91736925e-02f, -1.73475608e-01f,
  -1.41058192e-02f, 5.27289174e-02f, 6.78225011e-02f, 1.02261819e-01f, 8.17178488e-02f, 1.15366057e-01f, -4.12298627e-02f, 3.31186014e-03f, 3.81753445e-02f, 1.10915840e-01f,
  6.11057021e-02f, 1.22313663e-01f, 9.08884034e-02f, 2.07520071e-02f, -1.30555443e-02f, 5.65403812e-02f, 6.06805012e-02f, 6.85750097e-02f, 3.50308022e-03f, 4.94042188e-02f,
  8.23667720e-02f, 5.94927110e-02f, 4.12028842e-02f, 9.43943262e-02f, 2.29919460e-02f, 7.73583353e-02f, 1.31164402e-01f, 1.55681223e-01f, 1.50129765e-01f, 1.16622373e-01f,
  -8.08856357e-03f, 4.01376598e-02f, -9.63024944e-02f, -6.94701402e-03f, -1.79455187e-02f, -3.37333232e-02f, -9.46205109e-02f, 9.26250368e-02f, -5.07091507e-02f, -5.39700501e-02f,
  6.02020249e-02f, 2.12262832e-02f, 5.72336093e-03f, -4.00789604e-02f, 2.18993984e-02f, -2.92296428e-03f, 4.29331176e-02f, -1.43964812e-01f, -7.30726346e-02f, -3.68203893e-02f,
  5.56567274e-02f, -1.71567481e-02f, 4.28401902e-02f, -7.82938004e-02f, -7.09573478e-02f, -1.11187488e-01f, -9.11554247e-02f, -5.51057011e-02f, -1.52198508e-01f, -5.24075851e-02f,
  4.46304351e-01f, -1.46928042e-01f, -5.28072566e-02f, 1.08219914e-01f, 1.07208759e-01f, 6.76670447e-02f, 1.56868566e-02f, -7.45268539e-02f, -6.65249676e-03f, -1.28382146e-01f,
  -1.78283051e-01f, -3.57038043e-02f, -1.73712254e-01f, -1.43159926e-01f, -6.82129040e-02f, -1.38175920e-01f, -6.66770041e-02f, -4.56323139e-02f, 1.08182142e-02f, 9.99804214e-03f,
  -8.04138705e-02f, 1.64361462e-01f, 1.76417828e-01f, -2.12894473e-03f, -2.26239979e-01f, -6.49956241e-02f, -1.93319723e-01f, 1.00923749e-02f, -1.35457471e-01f, -3.71779650e-01f,
  -2.63284683e-01f, -5.03473617e-02f, -7.59404078e-02f, -7.96407759e-02f, -6.45722598e-02f, -9.70896780e-02f, -1.22096524e-01f, -6.31326959e-02f, -9.14298072e-02f, -1.16010569e-01f,
  -1.45534471e-01f, -8.63569081e-02f, -1.07801363e-01f, -2.07741484e-01f, -7.74438754e-02f, -1.08541064e-01f, -2.66042091e-02f, -1.58289388e-01f, -3.88727486e-02f, -1.73338920e-01f,
  -1.95450231e-01f, -1.05357379e-01f, -1.08212784e-01f, -8.55498463e-02f, -1.66185677e-01f, -2.00547799e-02f, -8.29832777e-02f, -2.45484546e-01f, -1.17151640e-01f, -1.64191812e-01f,
  5.03549315e-02f, -2.01951596e-03f, 7.33455718e-02f, 9.91012231e-02f, 1.16316736e-01f, 6.19422421e-02f, 8.68711546e-02f, 8.49184617e-02f, 1.29810274e-01f, 1.27765208e-01f,
  6.54834881e-02f, 9.65408981e-02f, 2.11359374e-02f, 7.38711432e-02f, 3.93828340e-02f, 5.88512383e-02f, 1.15435548e-01f, 9.03960913e-02f, 6.17752261e-02f, 1.40739068e-01f,
  1.02314554e-01f, -2.16794405e-02f, 5.64459451e-02f, -4.04141657e-03f, 8.02567452e-02f, 2.33275555e-02f, 1.64660975e-01f, 1.20925255e-01f, 1.00467905e-01f, 1.52335048e-01f,
  9.90108252e-02f, 1.03185758e-01f, -1.26994938e-01f, -7.65272602e-02f, -3.37571986e-02f, -7.67503902e-02f, 2.70516332e-02f, -3.20800208e-02f, -4.67966460e-02f, -9.46254209e-02f,
  -3.46940495e-02f, -7.07707033e-02f, -1.44593436e-02f, -3.37420888e-02f, 8.70433543e-03f, -7.52531961e-02f, -5.55391572e-02f, -1.47230620e-03f, -9.12439823e-02f, -1.00122951e-01f,
  -6.24535084e-02f, 5.67795634e-02f, 8.70778635e-02f, -1.57913025e-02f, -1.42415404e-01f, -2.78794784e-02f, -4.81757857e-02f, -4.38898653e-02f, -9.07769892e-03f, 1.27801552e-01f,
  2.29801938e-01f, 1.90414235e-01f, 3.35584581e-01f, 2.41197214e-01f, -4.95020598e-02f, -1.89118460e-03f, 2.20630150e-02f, -1.03949703e-01f, -4.76702414e-02f, 9.44133252e-02f,
  -9.85680968e-02f, -1.59292638e-01f, -4.21113707e-02f, -2.84777563e-02f, -1.08319096e-01f, 1.81879118e-01f, 3.28307837e-01f, 2.49215532e-02f, -1.04372770e-01f, -2.71953017e-01f,
  -2.68171787e-01f, -3.01900078e-02f, -5.74624203e-02f, -1.14317968e-01f, 1.32709712e-01f, -5.09777069e-02f, 1.58457413e-01f, 8.11344236e-02f, -1.16246203e-02f, 1.93719760e-01f,
  6.13270551e-02f, 2.64235228e-01f, 7.69311050e-03f, -1.20529979e-01f, -4.85935546e-02f, -6.86653331e-02f, -6.83792606e-02f, 4.14242893e-02f, -4.06068452e-02f, -7.82140121e-02f,
  4.76628654e-02f, -3.23149450e-02f, -3.06143966e-02f, -4.42479737e-02f, 6.45213276e-02f, -1.06402956e-01f, 9.85765606e-02f, 2.93310080e-02f, 1.19347446e-01f, 7.08046108e-02f,
  -5.40512316e-02f, -2.38048434e-02f, 7.02675804e-02f, -1.02931596e-01f, 9.50862393e-02f, 9.81720281e-04f, -7.57779926e-02f, -5.91601804e-02f, -7.01846778e-02f, -4.98702042e-02f,
  4.87019913e-03f, -1.45603372e-02f, -1.54284630e-02f, 2.55571939e-02f, -3.51189747e-02f, -2.02247407e-02f, 1.06441505e-01f, -4.36709523e-02f, -5.97601272e-02f, 5.36063546e-03f,
  -4.55213748e-02f, 6.60229698e-02f, -1.25090685e-02f, 1.01120010e-01f, 2.30335593e-02f, 2.55639832e-02f, 6.49988055e-02f, 2.92497315e-02f, -2.32676491e-02f, 4.27893922e-02f,
  -5.19525483e-02f, -1.41938208e-02f, 4.54663895e-02f, -1.05692735e-02f, 1.45612538e-01f, -3.36269173e-03f, 1.34621605e-01f, -7.04836547e-02f, 9.91889276e-03f, 5.56924902e-02f,
  -6.33084625e-02f, -4.61455015e-03f, 1.10662743e-01f, 2.09827777e-02f, 6.14807382e-02f, 4.29355213e-03f, 1.98646691e-02f, -1.91086512e-02f, 3.30476873e-02f, 3.93855311e-02f,
  -4.25058268e-02f, 6.64895549e-02f, -2.47543398e-02f, -4.62304987e-02f, -3.16591524e-02f, -2.60404348e-02f, 1.30190980e-02f, 1.07526518e-01f, 1.15420585e-02f, -5.90028688e-02f,
  3.86960804e-02f, -1.07420266e-01f, 8.96419492e-03f, -4.74447012e-02f, -3.73358168e-02f, -5.47780953e-02f, -1.00585595e-02f, -9.11189541e-02f, -9.22703817e-02f, -8.69297385e-02f,
  -5.95556432e-03f, -1.16088048e-01f, 5.48517518e-02f, -5.96668795e-02f, -7.03304261e-02f, 8.10743943e-02f, 1.78056210e-01f, 6.47079498e-02f, -9.07018483e-02f, -1.13628477e-01f,
  -1.87859684e-01f, -1.54905796e-01f, 3.11937556e-02f, 1.40005965e-02f, 1.61111116e-01f, 1.17934711e-01f, 2.38776252e-01f, 1.79079667e-01f, 1.60117209e-01f, -2.29307590e-03f,
  5.05714852e-04f, 3.26663516e-02f, -1.06855445e-02f, -1.10147588e-01f, 1.11306331e-03f, -7.84411728e-02f, 5.35920374e-02f, 4.90124673e-02f, -4.42756666e-03f, -2.82519311e-02f,
  1.64143965e-01f, -2.58319259e-01f, -9.59984586e-02f, -2.86237061e-01f, -1.94011271e-01f, -1.82820648e-01f, -1.54535025e-01f, -8.95434618e-02f, -2.17260182e-01f, -1.48694456e-01f,
  -1.91389352e-01f, -1.92325145e-01f, -7.34899044e-02f, -9.22281891e-02f, -3.12682800e-02f, -2.03855366e-01f, -1.70450166e-01f, -4.10645036e-03f, -1.74110979e-01f, -1.53866589e-01f,
  -1.69240892e-01f, -1.64860040e-01f, -9.09504388e-03f, -8.67528990e-02f, -1.68539733e-01f, -1.81063801e-01f, -6.88858405e-02f, -3.66999507e-02f, 4.28521913e-03f, 6.84709894e-03f,
  1.98743362e-02f, 1.31633148e-01f, 1.16973259e-01f, 1.57632276e-01f, 1.96942002e-01f, 7.92002901e-02f, 2.20330149e-01f, 1.94666311e-01f, 9.01614800e-02f, 1.83412373e-01f,
  6.70732185e-02f, 1.92821562e-01f, 2.08911896e-01f, 1.88546360e-01f, 9.99251753e-02f, 1.61381811e-01f, 9.59705561e-02f, 1.83795169e-01f, 1.15880921e-01f, 5.94035983e-02f,
  1.69949889e-01f, 1.64559215e-01f, 8.82822126e-02f, 1.81950510e-01f, 7.47490525e-02f, 2.22072214e-01f, 1.19480036e-01f, 9.08399001e-02f, 1.56874835e-01f, 1.33813053e-01f,
  1.11150153e-01f, -2.70097524e-01f, -6.42005876e-02f, -5.74054047e-02f, -5.43836243e-02f, -1.23180464e-01f, -1.49294108e-01f, -7.92017803e-02f, -8.77650976e-02f, -2.43698657e-02f,
  -1.09897412e-01f, -1.00007161e-01f, -5.88761345e-02f, -3.27953435e-02f, -5.57458252e-02f, -6.36596978e-03f, -8.88461694e-02f, -7.37744272e-02f, -8.17794949e-02f, -1.64842919e-01f,
  -6.04838282e-02f, -8.05697143e-02f, -7.53174201e-02f, -4.96141836e-02f, 2.70524062e-02f, 1.91106100e-03f, 4.02733758e-02f, -1.12424744e-02f, -3.57792377e-02f, 1.39963433e-01f,
  -8.15378204e-02f, 3.41727398e-03f, -1.30416214e-01f, -7.80422008e-03f, 2.60791760e-02f, -4.05265875e-02f, -1.71253189e-01f, 1.38107345e-01f, 1.52672067e-01f, -1.74715724e-02f,
  2.56325215e-01f, 4.14354771e-01f, 3.36178929e-01f, 1.79829702e-01f, 1.11094736e-01f, -1.63052723e-01f, -6.14249147e-02f, -7.42523894e-02f, 6.98077455e-02f, 3.75040285e-02f,
  1.19522475e-01f, 1.26801953e-01f, 7.75741637e-02f, 5.83010986e-02f, 5.91170527e-02f, 9.11977217e-02f, 1.91572476e-02f, 5.23009151e-02f, 2.89432760e-02f, 9.18170996e-03f,
  8.88532698e-02f, 6.89461753e-02f, 1.58534884e-01f, 1.07202530e-01f, 7.35074878e-02f, 1.07538216e-01f, 1.90291610e-02f, 1.51465282e-01f, 8.15484822e-02f, 1.37913063e-01f,
  2.27681562e-01f, 1.64627761e-01f, 1.09732099e-01f, 1.75831452e-01f, 1.17504165e-01f, 8.81020650e-02f, 1.69261783e-01f, 3.13535444e-02f, 1.63347661e-01f, 9.33668166e-02f,
  8.23486000e-02f, 7.75894448e-02f, 1.67974576e-01f, 1.22789316e-01f, 2.31492504e-01f, 8.74940529e-02f, 2.12959275e-01f, 2.13108584e-01f, 9.88492370e-02f, 5.05540818e-02f,
  -8.01074691e-03f, -1.18394814e-01f, -3.71397361e-02f, -1.24870464e-01f, -5.11331600e-04f, -1.06335558e-01f, -2.58107930e-02f, -4.33096923e-02f, -6.87756389e-02f, -1.31598547e-01f,
  -2.40427647e-02f, -1.07239835e-01f, -9.46842581e-02f, -1.67219177e-01f, -7.45321065e-02f, -1.23447634e-01f, -5.47232926e-02f, -1.42722785e-01f, -5.23024201e-02f, -1.09269045e-01f,
  -9.43844393e-02f, -7.89000764e-02f, -1.65287390e-01f, -4.25094031e-02f, -1.65115088e-01f, -6.88652471e-02f, -1.32328272e-01f, -5.95343597e-02f, -6.09400570e-02f, -8.34416896e-02f,
  1.05217531e-01f, 1.70061499e-01f, -4.98569459e-02f, 9.24484432e-02f, 1.03333443e-01f, 6.25529811e-02f, 1.05569951e-01f, 9.52622369e-02f, 6.55193776e-02f, 2.91882013e-03f,
  5.67914322e-02f, 4.14645448e-02f, 4.40700427e-02f, 1.44619599e-01f, 5.68371192e-02f, 1.49276793e-01f, 5.24504744e-02f, 1.06395751e-01f, 6.50470331e-02f, 1.15153678e-01f,
  4.30261120e-02f, 4.05718535e-02f, 7.38621429e-02f, 1.16031013e-01f, 1.13359094e-01f, -3.52025405e-02f, -2.30940729e-02f, -4.34894487e-02f, 5.47501445e-02f, -1.22186318e-01f,
  -2.53021270e-01f, -2.97829658e-01f, -1.09218746e-01f, -1.72159731e-01f, -1.16562039e-01f, 1.01595119e-01f, -1.02159716e-01f, -6.76733404e-02f, -3.27223763e-02f, -2.38636732e-01f,
  -1.28651544e-01f, 1.11514755e-01f, -1.20387841e-02f, 8.19723755e-02f, 7.35828429e-02f, -1.14250779e-01f, 4.56961542e-02f, 2.66470969e-01f, 5.08236051e-01f, 1.58060342e-01f,
  1.20242797e-01f, -2.74959449e-02f, 7.64872506e-02f, -2.37504654e-02f, -2.14113981e-01f, 4.62849885e-02f, -1.33174062e-01f, -2.70534098e-01f, -1.55654415e-01f, -3.26551974e-01f,
  -9.15579945e-02f, -2.37999871e-01f, 3.13649386e-01f, 8.43043104e-02f, 3.81839611e-02f, 7.93597251e-02f, 5.34381308e-02f, 4.82896455e-02f, -1.05353370e-02f, 3.40286382e-02f,
  8.67794678e-02f, 7.44607598e-02f, -1.73887871e-02f, 6.25135824e-02f, 2.91686715e-03f, 1.79765016e-01f, 1.23623246e-02f, -2.42504757e-03f, 1.17609002e-01f, 1.35896355e-02f,
  -2.60078143e-02f, 1.11371931e-02f, -7.77545059e-03f, 1.12156898e-01f, 2.19853148e-02f, 1.97867408e-01f, -6.55067116e-02f, 1.94619689e-02f, 1.30088791e-01f, -2.59928592e-02f,
  1.23657353e-01f, -5.08229025e-02f, -1.47648379e-01f, -1.34409323e-01f, -8.13397095e-02f, -9.83158275e-02f, 2.92207282e-02f, -1.08597159e-01f, -3.95995304e-02f, -3.64450067e-02f,
  -5.13894707e-02f, -5.46776205e-02f, -1.32904649e-01f, -1.14981905e-01f, -4.71862443e-02f, -1.12707838e-01f, -1.48718342e-01f, -5.62714897e-02f, -4.33041155e-02f, -5.78103960e-02f,
  -8.12796317e-03f, -1.82471462e-02f, -4.53044660e-02f, -5.88301308e-02f, -2.99639739e-02f, -3.68892998e-02f, -1.98919140e-02f, -1.02159940e-01f, -1.04784124e-01f, -6.33118078e-02f,
  2.09454796e-03f, 1.86421692e-01f, 8.34301710e-02f, 1.01789385e-01f, 1.44608214e-01f, 1.74237445e-01f, 1.05313472e-01f, 9.43214521e-02f, 1.07605867e-02f, 8.99686441e-02f,
  1.12841673e-01f, 8.72764811e-02f, 5.44403903e-02f, 1.60242915e-01f, 2.18685627e-01f, 9.66362432e-02f, 1.10958755e-01f, 1.85404390e-01f, 9.20512825e-02f, 4.95769829e-02f,
  1.00801796e-01f, 2.81104028e-01f, 2.77324975e-01f, 7.02950209e-02f, 1.35090619e-01f, 2.71385223e-01f, 8.41725916e-02f, 2.19793439e-01f, 1.91071004e-01f, 1.47112116e-01f,
  3.50263953e-01f, 1.45725369e-01f, 1.02993555e-01f, 1.12334043e-01f, -1.76373459e-02f, -4.19332609e-02f, 6.36332408e-02f, 6.40194165e-03f, 7.06148073e-02f, 2.56894916e-01f,
  8.17889348e-02f, -6.79581910e-02f, 3.24111581e-02f, -8.88306051e-02f, -1.88203633e-01f, 2.25415036e-01f, 4.68297265e-02f, -9.87502709e-02f, -1.82390243e-01f, 1.58832744e-02f,
  9.46544409e-02f, 1.36953607e-01f, -8.93391073e-02f, -6.03186302e-02f, 1.39824912e-01f, 8.20105970e-02f, 6.28470555e-02f, 4.93677296e-02f, 8.03147033e-02f, 2.60284007e-01f,
  9.60760191e-02f, -2.66569424e-02f, -1.10749632e-01f, -7.91865289e-02f, -4.52314056e-02f, 9.70811844e-02f, 8.10713768e-02f, -2.23325733e-02f, 1.82190873e-02f, 7.76422769e-02f,
  -3.97474654e-02f, 1.01063093e-02f, 5.09369886e-03f, -4.47518565e-02f, -6.07358068e-02f, -4.03798185e-02f, -4.05120701e-02f, -4.56217341e-02f, -1.63684875e-01f, -5.87918535e-02f,
  1.22321378e-02f, 3.48551050e-02f, 1.13903945e-02f, -1.01283036e-01f, -1.33102387e-01f, -4.90002297e-02f, 3.97335663e-02f, -5.42944111e-02f, 7.15213194e-02f, 2.86785543e-01f,
  1.57060236e-01f, 1.43262476e-01f, -7.80396536e-02f, 5.52407689e-02f, 1.51191233e-02f, 6.93503097e-02f, -8.20680615e-03f, -9.73850936e-02f, -9.04663205e-02f, 6.76915199e-02f,
  -5.54189309e-02f, 1.12403445e-02f, 2.29478292e-02f, 5.93824424e-02f, 2.36673988e-02f, 4.84656133e-02f, 1.97926350e-02f, -5.43050282e-03f, -8.58298466e-02f, -7.74602666e-02f,
  -5.06847277e-02f, -8.98484886e-03f, -4.66694916e-03f, -3.23772281e-02f, -1.22006591e-02f, 5.18189818e-02f, -4.58158478e-02f, 7.58057982e-02f, -1.26328741e-04f, -1.65633261e-02f,
  1.72047660e-01f, -3.13401431e-01f, 5.68758398e-02f, -1.32425949e-01f, 3.38589251e-02f, -8.73292461e-02f, -1.29099202e-03f, 4.32944670e-02f, -3.75271477e-02f, -1.46785863e-02f,
  -7.98443556e-02f, 3.03504653e-02f, 6.50596758e-03f, -6.26953915e-02f, 1.64850652e-02f, 9.05448478e-03f, -2.16988772e-02f, -8.23651534e-03f, -4.08071242e-02f, 6.26084059e-02f,
  1.29856998e-02f, 2.93512121e-02f, 1.12343980e-02f, -2.16560513e-02f, -2.75559667e-02f, 7.61780143e-02f, 9.51216519e-02f, 9.66384187e-02f, 8.18472058e-02f, 3.07400078e-01f,
  -2.67647691e-02f, -3.09601158e-01f, -7.91315921e-03f, 3.59097980e-02f, -4.16975729e-02f, 2.81108841e-02f, -2.54373372e-01f, 2.06958931e-02f, 5.54543324e-02f, -2.10882172e-01f,
  4.39245030e-02f, 2.97615230e-01f, 2.25956187e-01f, 2.75588721e-01f, 9.04415995e-02f, -1.83833987e-01f, -1.99535087e-01f, 1.68739632e-01f, 4.07474458e-01f, 1.90636277e-01f,
  1.61727574e-02f, 5.72943082e-03f, 1.73468828e-01f, 1.35037616e-01f, -1.62795484e-01f, 9.29520652e-02f, -1.99271649e-01f, -1.09392658e-01f, -7.46128857e-02f, -2.66546696e-01f,
  -1.68840304e-01f, -1.14059038e-01f, 8.56887773e-02f, 2.05290560e-02f, -8.52512475e-03f, -8.74732509e-02f, -4.45424393e-02f, -1.18289545e-01f, -1.19782820e-01f, -4.56851423e-02f,
  -7.04641417e-02f, -3.86367030e-02f, -4.02282402e-02f, 1.95880868e-02f, -4.71757120e-03f, 2.52889376e-02f, -8.08570087e-02f, -1.65202226e-02f, 5.42204343e-02f, -3.31519768e-02f,
  -3.83432815e-03f, -3.62935178e-02f, -9.99733992e-03f, -6.05699199e-04f, 1.21127060e-02f, 1.18971199e-01f, -7.05462769e-02f, -1.06353611e-02f, 1.38311595e-01f, -1.10245422e-01f,
  -1.57548045e-03f, -1.02315815e-02f, 2.11394560e-02f, 1.81943586e-03f, -8.03916436e-03f, 3.89100388e-02f, -3.70538197e-02f, -1.82132926e-02f, 9.80957132e-03f, 2.73544453e-02f,
  5.30309342e-02f, 1.13738785e-02f, 2.11767685e-02f, -4.24631312e-02f, -3.21909375e-02f, -1.00384168e-02f, -2.82215029e-02f, 3.06549016e-02f, 3.55699472e-02f, 6.94761475e-05f,
  6.67097494e-02f, -6.51427777e-03f, -3.89174521e-02f, 8.70199054e-02f, -5.81254289e-02f, 4.63646203e-02f, -5.46175539e-02f, 1.00385606e-01f, 3.71056832e-02f, -4.86255959e-02f,
  1.10513806e-01f, 1.67493865e-01f, -9.41811502e-02f, -9.73295271e-02f, -8.87554511e-02f, 1.80865824e-02f, -8.36505666e-02f, -1.89198293e-02f, -2.89527066e-02f, -4.10448126e-02f,
  1.89046375e-02f, 1.91961713e-02f, -8.34831893e-02f, -7.25429356e-02f, 4.95820530e-02f, 2.70928517e-02f, -7.99286887e-02f, -1.29555669e-02f, -9.20090638e-03f, -1.35593995e-01f,
  -7.52715692e-02f, -5.76321483e-02f, 4.95808348e-02f, -6.03577867e-02f, -5.30210789e-03f, -1.04822302e-02f, 1.00964624e-02f, -7.02639893e-02f, 3.56950872e-02f, -2.62311161e-01f,
  -5.43884993e-01f, 2.57079422e-01f, -1.28484398e-01f, -1.99686125e-01f, 1.88260332e-01f, 2.03867048e-01f, 3.82166713e-01f, 6.27588034e-02f, -2.08362624e-01f, 4.83293310e-02f,
  1.54546618e-01f, -6.28978983e-02f, -8.11301097e-02f, -9.56695229e-02f, -7.34144896e-02f, 2.26306871e-01f, 7.43173584e-02f, -3.03685427e-01f, -2.49629498e-01f, -1.31544203e-01f,
  3.86559330e-02f, -2.71758754e-02f, -2.19930664e-01f, -1.94971830e-01f, -3.62015585e-03f, -9.64857042e-02f, 8.33892003e-02f, -1.18470930e-01f, 1.34626567e-01f, -1.83953255e-01f,
  -1.77470326e-01f, -2.29825675e-01f, -5.30547425e-02f, -1.04944535e-01f, -1.00198919e-02f, -8.11805949e-02f, -1.04078412e-01f, -1.56231537e-01f, -1.20400656e-02f, -1.49121964e-02f,
  -8.37601945e-02f, -1.46610841e-01f, -1.58039972e-01f, -1.17046662e-01f, -5.76543100e-02f, -9.67772081e-02f, -1.29351810e-01f, -1.78615838e-01f, -5.56682353e-04f, 1.47280358e-02f,
  2.29441859e-02f, -6.08964935e-02f, -2.10812818e-02f, 5.00924885e-02f, -6.60457984e-02f, -1.34059325e-01f, -7.21719116e-02f, -1.89897910e-01f, -9.49564576e-02f, -1.32600695e-03f,
  -8.75765271e-03f, 1.04548633e-01f, 7.83977583e-02f, 4.58397232e-02f, 8.87796581e-02f, 6.16532862e-02f, 6.32906109e-02f, 1.45045012e-01f, 2.81631164e-02f, 7.88723454e-02f,
  4.03789617e-02f, 8.40801373e-02f, 2.53345128e-02f, 1.33745046e-02f, 9.34259370e-02f, 2.87369695e-02f, 4.42159537e-04f, 9.26423520e-02f, 2.08133757e-02f, -2.28754412e-02f,
  -9.83452052e-03f, 2.89005376e-02f, 3.03288922e-02f, 5.71886450e-02f, 6.78481832e-02f, -1.62328370e-02f, 2.15514638e-02f, 1.08690538e-01f, -1.66870933e-02f, 6.10678419e-02f,
  -7.10816607e-02f, -1.59070846e-02f, -9.73020270e-02f, -1.16887853e-01f, -6.72600567e-02f, -1.18942343e-01f, -1.05037421e-01f, -2.60283127e-02f, -8.62720460e-02f, -5.73548526e-02f,
  -1.15204729e-01f, -4.97496836e-02f, 5.81077021e-03f, -7.89856762e-02f, -1.65038556e-02f, -7.57625178e-02f, 3.31788883e-02f, -9.66388807e-02f, -2.37429347e-02f, -8.17009285e-02f,
  8.69271904e-02f, 8.72406662e-02f, 3.52011621e-02f, 1.83103047e-02f, -7.32400939e-02f, -6.15997389e-02f, 4.24297154e-02f, -1.05150677e-01f, -2.16616485e-02f, 1.87630564e-01f,
  3.97162259e-01f, 1.25161380e-01f, -3.85662317e-02f, 1.32738382e-01f, -1.70729652e-01f, -2.20608383e-01f, -1.77795425e-01f, 2.61955708e-02f, 9.09259021e-02f, -7.40263704e-03f,
  -4.72590439e-02f, -6.69333115e-02f, -1.98517174e-01f, -1.88454151e-01f, -1.90083876e-01f, -1.40819490e-01f, -1.70298740e-01f, -2.60984927e-01f, -2.38348320e-01f, -2.39967093e-01f,
  -1.74233153e-01f, 3.30530293e-02f, 6.83713704e-02f, 2.09626947e-02f, 4.90506589e-02f, -1.47673860e-01f, 8.29951316e-02f, 5.34057505e-02f, -7.37507343e-02f, 5.65073304e-02f,
  3.74320522e-02f, 2.01744139e-01f, -2.65738219e-01f, -9.71528217e-02f, -3.69307995e-02f, -7.23616853e-02f, -1.24572866e-01f, -4.40414548e-02f, -3.66629921e-02f, 3.64775360e-02f,
  5.35065830e-02f, -4.59335046e-03f, -7.04552457e-02f, -8.02968666e-02f, 3.45099978e-02f, -5.19755408e-02f, 3.99351269e-02f, -1.03586398e-01f, -2.76969261e-02f, 1.22130355e-02f,
  -7.57038072e-02f, -4.95509319e-02f, -3.73560861e-02f, -1.20582871e-01f, 1.30945360e-02f, -1.43798277e-01f, -2.18873355e-03f, 2.37977281e-02f, -4.44401279e-02f, 7.22764730e-02f,
  -1.29734635e-01f, 6.88672066e-04f, 3.52149047e-02f, 1.02022700e-01f, 1.17345572e-01f, 9.49778557e-02f, 1.12095922e-01f, -7.40358047e-03f, 3.48167270e-02f, 8.34726617e-02f,
  7.49450922e-02f, 4.99822684e-02f, 7.87545592e-02f, 1.18947111e-01f, 1.37174623e-02f, 1.41402647e-01f, 8.45415369e-02f, 3.64667103e-02f, 1.18939213e-01f, 1.21510997e-01f,
  1.29482836e-01f, 1.38873398e-01f, 4.65723053e-02f, 7.78978616e-02f, 1.07253306e-01f, 4.05507386e-02f, 1.24335289e-01f, 6.50369972e-02f, 3.83296013e-02f, 1.04490325e-01f,
  -6.60611391e-02f, -2.14370176e-01f, 2.60892101e-02f, 4.87673655e-03f, -3.01803183e-02f, -5.12869656e-02f, -1.76730379e-02f, -4.10931706e-02f, -7.75546506e-02f, -8.07476714e-02f,
  -4.89232875e-02f, -4.52631563e-02f, 3.41093838e-02f, -2.42191721e-02f, -1.46522284e-01f, 1.01405336e-02f, 1.20371897e-02f, -5.90636767e-02f, -9.86108929e-02f, 6.57561934e-03f,
  -1.09382913e-01f, -1.92878634e-01f, -1.71284333e-01f, -1.52482674e-01f, -1.19241454e-01f, -2.28277966e-01f, -1.72229946e-01f, -1.59400508e-01f, -2.80877829e-01f, -1.75303876e-01f,
  4.86483037e-01f, -7.03023300e-02f, 9.04592127e-02f, 3.04740276e-02f, -8.83023515e-02f, -1.69107541e-01f, -2.07219467e-01f, -8.01497549e-02f, -1.50168926e-01f, -1.79405555e-01f,
  -9.02519152e-02f, 1.27718776e-01f, 1.04683243e-01f, 5.44227697e-02f, 7.40497485e-02f, -6.95682913e-02f, 1.90820266e-02f, 2.90554762e-01f, 2.48018280e-01f, 1.35101024e-02f,
  2.13842392e-02f, 1.31661538e-02f, 1.64067447e-01f, 1.62069481e-02f, -1.33998543e-01f, 7.80348608e-04f, -2.19699368e-01f, -9.02433172e-02f, 2.69830544e-02f, 1.83400512e-01f,
  3.90494734e-01f, 5.45251630e-02f, 1.19375825e-01f, 9.18202028e-02f, -7.78632909e-02f, 8.83299410e-02f, 8.70665163e-02f, -3.46500077e-04f, -8.72468799e-02f, -5.15366755e-02f,
  -1.71450600e-02f, 3.14883329e-02f, 1.98855437e-02f, 6.79703709e-03f, 4.84887371e-03f, -8.26986134e-02f, -1.16235830e-01f, 6.69363141e-02f, 5.34674637e-02f, -9.57177952e-02f,
  -7.85999075e-02f, 2.69629937e-02f, 1.04507945e-01f, -7.06933811e-02f, -1.22622520e-01f, 8.57521370e-02f, -9.58162770e-02f, 3.54996510e-02f, 2.02236362e-02f, 1.59071777e-02f,
  -1.73354931e-02f, 3.37086455e-03f, -3.43674943e-02f, 3.02416943e-02f, -4.53192964e-02f, -8.64060819e-02f, 1.90540999e-02f, 2.20969808e-03f, 3.46178859e-02f, -1.26312114e-02f,
  -1.02204904e-01f, 3.92470062e-02f, -6.25448255e-03f, -3.18220258e-02f, -1.92961060e-02f, 9.55295190e-02f, 5.76769784e-02f, -7.15139881e-03f, 4.51356471e-02f, -2.00988669e-02f,
  7.11831078e-02f, -5.91093712e-02f, 4.40548025e-02f, 3.11704036e-02f, 8.17597657e-02f, 6.73962608e-02f, 5.21565937e-02f, -6.12662127e-03f, -4.19965982e-02f, -4.49258685e-02f,
  -9.88170430e-02f, 5.74238934e-02f, 9.91137177e-02f, 1.00385614e-01f, 3.97565216e-02f, -9.67089981e-02f, 4.34339419e-02f, 6.70449063e-02f, 4.23406400e-02f, 6.18372411e-02f,
  -8.28121230e-02f, 5.58593944e-02f, -3.08708381e-02f, 5.43656610e-02f, 5.83705530e-02f, 2.66960151e-02f, -4.20782305e-02f, 1.51047006e-01f, -5.68395033e-02f, -4.24469374e-02f,
  6.65438315e-03f, 1.02145784e-01f, 5.27595468e-02f, -1.16751334e-02f, -2.79041082e-02f, 1.79024652e-01f, -4.73936042e-03f, 2.56391559e-02f, 9.93812084e-02f, -8.47992301e-02f,
  -1.04520135e-01f, 1.96351722e-01f, 1.43339172e-01f, 1.23319111e-03f, 1.86165452e-01f, 1.46886021e-01f, 2.58246362e-01f, 9.21867341e-02f, -9.93881896e-02f, 2.71549225e-01f,
  4.65960652e-02f, -2.04112649e-01f, -1.16381057e-01f, -1.18602365e-01f, -6.80171102e-02f, 1.34535506e-01f, 1.68020904e-01f, -1.59550637e-01f, -2.29586244e-01f, 3.48742940e-02f,
  5.21664415e-03f, -7.21644461e-02f, -2.40270302e-01f, -6.93234429e-02f, 2.15046063e-01f, 3.99232842e-02f, 1.78560793e-01f, 1.10543832e-01f, 6.62305206e-02f, 2.18976870e-01f,
  2.55818009e-01f, 1.50139451e-01f, 1.08548775e-01f, 2.98038814e-02f, 5.06355092e-02f, 1.39429811e-02f, 9.77761298e-02f, 2.58820597e-02f, 4.94321212e-02f, 9.47938040e-02f,
  1.28138661e-01f, -5.16875163e-02f, -2.92219445e-02f, -3.30822468e-02f, 9.76248011e-02f, 9.88870040e-02f, 9.73239616e-02f, -4.25825976e-02f, -3.39441653e-03f, 7.36667961e-02f,
  1.24895670e-01f, 1.72243416e-01f, 1.06435552e-01f, 6.50691018e-02f, 4.71920036e-02f, -2.11160835e-02f, 1.62598461e-01f, 4.57429960e-02f, 9.84000936e-02f, 1.98009968e-01f,
  1.21752478e-01f, -2.06966288e-04f, -2.51239967e-02f, -7.26990923e-02f, -3.17237265e-02f, -3.86523455e-02f, 3.72502655e-02f, -8.07386115e-02f, 6.17335085e-03f, -5.04862070e-02f,
  -8.48045200e-02f, -4.01405692e-02f, -3.21314074e-02f, -3.07421908e-02f, 3.04431412e-02f, -1.97294187e-02f, -3.06648277e-02f, 5.38267195e-02f, 5.83257265e-02f, -5.26564084e-02f,
  -3.25578614e-03f, -3.24888388e-03f, 4.71781066e-04f, -5.71841151e-02f, -3.27237770e-02f, -2.94313729e-02f, -7.19310120e-02f, -3.97888124e-02f, 2.40961183e-02f, -9.06527415e-03f,
  -1.14353597e-01f, 4.94986447e-03f, 1.32271156e-01f, -1.79917105e-02f, 1.32240698e-01f, 9.98901799e-02f, 6.96620494e-02f, 1.84213612e-02f, 4.53161448e-02f, 7.86303282e-02f,
  -3.43702994e-02f, 3.93915698e-02f, 5.80362752e-02f, 3.51534300e-02f, 5.15000075e-02f, 1.06113106e-01f, 3.23492959e-02f, 3.41440476e-02f, -1.76864099e-02f, 8.78609940e-02f,
  5.64214885e-02f, 5.09390794e-02f, 2.12096516e-03f, 9.66823772e-02f, 1.46605209e-01f, 1.55663723e-02f, 8.57636258e-02f, 1.25610366e-01f, -1.31281577e-02f, 1.93944439e-01f,
  -3.88319671e-01f, -2.21260078e-02f, -8.68269354e-02f, -1.34014249e-01f, 2.71078050e-01f, 2.32076541e-01f, 3.81697208e-01f, 1.99910805e-01f, -4.24606614e-02f, -6.66817501e-02f,
  -4.31111967e-03f, -2.55646765e-01f, -2.67198682e-01f, -2.28979915e-01f, -1.23088509e-01f, 6.81333765e-02f, -2.13534813e-02f, -9.78769362e-02f, 3.79935727e-02f, 2.03794956e-01f,
  1.36534292e-02f, 5.25848055e-03f, -7.66382664e-02f, 2.21289899e-02f, 2.68658325e-02f, -1.27933994e-01f, 3.88740888e-03f, 5.44130355e-02f, 2.03036983e-02f, -1.97166070e-01f,
  -1.22272894e-01f, 1.42818093e-01f, 2.27117404e-01f, 1.04150161e-01f, 8.31877142e-02f, 8.22435394e-02f, 1.80312946e-01f, 5.17439693e-02f, 9.56660509e-02f, 8.67762789e-02f,
  1.37394249e-01f, 1.03196256e-01f, 4.81568649e-02f, 2.16026474e-02f, 1.16074920e-01f, 1.01932175e-01f, 4.55931164e-02f, -7.44123757e-02f, -5.25738345e-03f, 1.37357488e-01f,
  9.22892690e-02f, 7.42483810e-02f, 1.33738533e-01f, 1.71280369e-01f, 1.30547792e-01f, 2.09849025e-03f, 1.55813977e-01f, 5.42258769e-02f, 3.78380492e-02f, -2.37844624e-02f,
  5.52484803e-02f, -3.40563469e-02f, -2.51362529e-02f, -5.03262840e-02f, -4.11820039e-02f, -7.11916089e-02f, -6.14756234e-02f, -3.40130515e-02f, -5.52590564e-02f, -5.59644550e-02f,
  -5.64779006e-02f, -9.71447602e-02f, -1.59555878e-02f, -9.92219001e-02f, -5.54487668e-02f, -1.12196906e-02f, -1.02843203e-01f, -8.21011662e-02f, -6.58076182e-02f, -3.30656245e-02f,
  -9.58510265e-02f, -6.69263229e-02f, -2.94850394e-02f, -8.74852836e-02f, -6.90173730e-02f, -2.53399480e-02f, -1.01651803e-01f, -7.26268739e-02f, -3.75157483e-02f, -8.67108628e-02f,
  -7.59301111e-02f, 2.24307522e-01f, -7.23954737e-02f, 5.79527244e-02f, 7.05247447e-02f, -2.84971073e-02f, -3.35387103e-02f, 7.94981569e-02f, 4.26644050e-02f, 6.83821598e-03f,
  9.83607471e-02f, -1.23508731e-02f, 3.53328362e-02f, 1.30932480e-01f, 1.61934152e-01f, 9.66150239e-02f, 9.26247314e-02f, 7.03738257e-02f, 7.06835613e-02f, 6.48998991e-02f,
  1.33534387e-01f, 8.99251401e-02f, 5.71102463e-02f, -7.16213079e-04f, 1.33301288e-01f, 9.82296243e-02f, 1.25084281e-01f, 1.29347444e-01f, 5.45974895e-02f, 1.57641277e-01f,
  3.22397739e-01f, -1.10786580e-01f, -7.08211511e-02f, 8.37070122e-02f, 6.80713728e-02f, 2.20961824e-01f, 1.02914117e-01f, 8.60739052e-02f, 5.75056337e-02f, -2.11024657e-02f,
  1.52806342e-01f, 3.35420936e-01f, 2.11002961e-01f, 1.13758914e-01f, 5.29212318e-02f, -1.77394226e-01f, -1.86850280e-01f, 1.17549911e-01f, 2.66617358e-01f, 1.72057122e-01f,
  6.25783205e-02f, 3.87545265e-02f, 5.26139736e-02f, 3.24476622e-02f, -4.51585874e-02f, 1.50899112e-01f, -1.06285498e-01f, -5.70528321e-02f, 5.89833409e-02f, -1.43582851e-01f,
  1.57989278e-01f, -8.11489075e-02f, 2.58601278e-01f, 8.08164850e-02f, 1.20347254e-01f, 1.16752610e-01f, 1.37523636e-01f, 9.17550772e-02f, 1.01715609e-01f, 4.70745675e-02f,
  8.71645212e-02f, 4.85211657e-03f, 1.19854502e-01f, -1.52313737e-02f, 1.20960020e-01f, 7.61618391e-02f, -4.39276807e-02f, -7.91689847e-03f, -2.80149877e-02f, 6.31388128e-02f,
  7.14991689e-02f, 5.12983650e-02f, 1.77259624e-01f, 1.21787690e-01f, 1.89182423e-02f, 1.73580155e-01f, 6.33744001e-02f, 1.84288040e-01f, 2.16411993e-01f, 1.17331572e-01f,
  3.45496349e-02f, -1.26321033e-01f, -1.89824417e-01f, -6.80702403e-02f, -4.59798314e-02f, -1.13697372e-01f, -4.98943068e-02f, -1.15975685e-01f, -1.24159135e-01f, -2.99069900e-02f,
  -1.37019053e-01f, -1.20256431e-01f, -6.74481019e-02f, -1.64691374e-01f, -5.27321137e-02f, -6.33650124e-02f, -4.08037938e-03f, -1.37584299e-01f, -1.18875042e-01f, -1.50769904e-01f,
  -9.86849591e-02f, -5.53469881e-02f, -1.06494978e-01f, -8.07681456e-02f, -7.74140507e-02f, -1.60448819e-01f, -7.20172822e-02f, -1.17517769e-01f, -1.18710749e-01f, -8.80099013e-02f,
  2.06341147e-01f, 1.73467293e-01f, 1.34478286e-01f, 2.05840170e-01f, 8.39364752e-02f, 1.90245956e-02f, 1.43163458e-01f, 6.69407994e-02f, 2.56934185e-02f, 1.81371048e-01f,
  1.33914664e-01f, 1.29763559e-01f, 3.18421461e-02f, 1.21460333e-01f, 1.38712868e-01f, 1.25981942e-01f, 1.07494943e-01f, 1.27815649e-01f, 1.52854189e-01f, 7.86318406e-02f,
  5.50836734e-02f, 2.08885565e-01f, 3.14079344e-01f, 1.52499288e-01f, 2.27947697e-01f, 2.76559114e-01f, 2.55572468e-01f, 3.27351809e-01f, 2.73485839e-01f, 2.73066491e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.74364708e-02f, 2.23981440e-01f, 7.58046284e-02f, 2.44913310e-01f, 3.75586241e-01f, 3.65464121e-01f, 4.12564099e-01f, 2.44179219e-01f, 6.24720864e-02f, 6.61357343e-02f,
  8.60176012e-02f, -5.91474026e-02f, 7.54631236e-02f, 2.14298125e-02f, 9.44629684e-03f, 3.23260665e-01f, 2.81576335e-01f, -8.55169222e-02f, -1.16681688e-01f, 1.55597270e-01f,
  1.44487262e-01f, 1.90827206e-01f, -7.93099403e-03f, -4.54356149e-02f, -1.67024527e-02f, 1.07275426e-01f, 1.68489382e-01f, 2.18043342e-01f, 1.50753006e-01f, -1.06220394e-02f,
  -2.11500943e-01f, 1.29143372e-02f, -3.51759680e-02f, -4.72115306e-03f, -1.41952693e-01f, -2.16286778e-01f, -2.06467807e-02f, -1.36389896e-01f, -8.94159302e-02f, -7.58769810e-02f,
  6.84262346e-03f, -2.11288687e-02f, 1.31640788e-02f, -1.06603675e-01f, -6.03889860e-02f, -1.03369944e-01f, -1.17582887e-01f, -1.06557466e-01f, -7.81858936e-02f, -8.35054293e-02f,
  -4.40455135e-03f, -1.11666657e-01f, -2.22369954e-02f, 7.14307502e-02f, -3.94659080e-02f, -1.38179481e-01f, -9.39779952e-02f, -6.46640435e-02f, -5.29806726e-02f, -8.79726112e-02f,
  3.50177810e-02f, 1.41695082e-01f, -5.83452769e-02f, -4.27528331e-03f, -6.17882796e-03f, 1.11635901e-01f, -5.04922196e-02f, 2.47622952e-02f, 1.14015117e-01f, 1.35951648e-02f,
  2.03183927e-02f, -1.10216036e-01f, -2.14058399e-01f, -6.87686354e-02f, -7.51226097e-02f, -1.41515359e-01f, 7.38788024e-03f, -7.99083039e-02f, -2.14749932e-01f, -1.07850105e-01f,
  -1.23580895e-01f, 6.82870224e-02f, -1.44912079e-01f, -1.41847879e-01f, -1.97275698e-01f, -9.53113288e-02f, -1.90091640e-01f, -6.79825172e-02f, 3.09640262e-03f, 9.17285755e-02f,
  -3.97305116e-02f, -1.18392393e-01f, 3.81561071e-02f, 1.15526386e-01f, 6.19614050e-02f, -4.78386283e-02f, -1.25363050e-02f, -6.15873113e-02f, 9.63945240e-02f, -5.88672273e-02f,
  7.91537762e-02f, -4.75414544e-02f, 3.41715105e-02f, -8.22397247e-02f, 6.14601597e-02f, -6.73552379e-02f, -5.42063490e-02f, 1.18863784e-01f, 8.47152099e-02f, 3.98968011e-02f,
  4.64533344e-02f, 1.13640077e-01f, 1.41003817e-01f, 1.44066647e-01f, 3.15653682e-02f, 7.81309977e-02f, 4.06238101e-02f, -1.98002364e-02f, -3.28306877e-03f, 8.66528004e-02f,
  2.07175374e-01f, -3.10970694e-01f, -6.72794044e-01f, -3.32158923e-01f, -3.57110530e-01f, -1.11077227e-01f, -8.54298323e-02f, 1.89602092e-01f, -1.20525397e-01f, -3.22298527e-01f,
  -7.79710189e-02f, 1.91583052e-01f, -1.74818099e-01f, -5.72956800e-02f, 1.77295998e-01f, -5.01014233e-01f, -4.22076523e-01f, -1.48349047e-01f, 2.00340867e-01f, 3.68947923e-01f,
  1.43535165e-02f, -5.07571846e-02f, -5.39377593e-02f, -1.57788426e-01f, -3.68820548e-01f, -1.81733072e-01f, -4.79166746e-01f, -2.62995034e-01f, -1.65412605e-01f, -5.67189574e-01f,
  -4.18360561e-01f, 4.55493964e-02f, 5.24857566e-02f, 2.24651009e-01f, -1.79891378e-01f, 1.63122296e-01f, 7.60391578e-02f, -1.03242256e-01f, -2.18495610e-03f, -1.89570501e-01f,
  -8.19795430e-02f, 1.37273788e-01f, -3.53318416e-02f, -3.94088589e-02f, -7.25711836e-03f, 1.05297342e-02f, 3.21192965e-02f, 6.29961938e-02f, 2.51752068e-03f, -6.15691692e-02f,
  -1.28571447e-02f, 7.46844411e-02f, 6.71798959e-02f, 1.63503751e-01f, 6.65180534e-02f, -3.86131043e-03f, -6.76628500e-02f, 9.20350477e-02f, 3.55062112e-02f, -1.45884454e-01f,
  -1.13587059e-01f, -1.09325260e-01f, 6.29530624e-02f, 1.33287951e-01f, 6.99254796e-02f, -2.39044204e-02f, -5.04484102e-02f, 1.63317904e-01f, 1.98178381e-01f, -5.81616759e-02f,
  -3.57492231e-02f, 1.86889414e-02f, 5.41164214e-03f, -6.65090233e-02f, -1.50720179e-01f, 1.32335667e-02f, -1.74553152e-02f, -8.14345665e-03f, -5.76228984e-02f, 4.79757376e-02f,
  3.93229313e-02f, 9.84616429e-02f, -1.18311651e-01f, -2.48082876e-02f, -8.75382200e-02f, -2.24243477e-02f, 4.97816764e-02f, 1.51446074e-01f, 1.02527402e-01f, 1.37669686e-02f,
  -1.29322037e-01f, -1.42187830e-02f, -8.81522149e-03f, 1.96361363e-01f, -1.56879038e-01f, -7.04316050e-02f, -1.58199444e-01f, -8.36956650e-02f, -3.98292206e-02f, 1.02615170e-01f,
  6.72166497e-02f, 3.26778777e-02f, -1.09341569e-01f, -6.34272909e-03f, 1.30106673e-01f, 4.72175591e-02f, 5.58790453e-02f, 2.13374533e-02f, 9.59281623e-02f, 7.45666698e-02f,
  8.46118852e-02f, 2.67136067e-01f, 2.73493439e-01f, 1.13243088e-01f, 1.13380536e-01f, 9.48882997e-02f, 5.30876927e-02f, 1.37384489e-01f, 4.17322628e-02f, -2.26712953e-02f,
  5.99146605e-01f, 2.31283046e-02f, 2.42993429e-01f, 2.32998561e-02f, 5.23010604e-02f, 2.52901673e-01f, 2.70260304e-01f, 2.14452401e-01f, 1.02180950e-01f, -2.20320430e-02f,
  -2.30947927e-01f, -3.43846679e-01f, -2.25957394e-01f, -2.34352052e-01f, 2.07359586e-02f, 1.73394680e-01f, 1.28147498e-01f, 1.15766667e-01f, 2.62666047e-01f, 1.87243029e-01f,
  -2.60918774e-03f, 1.40877068e-01f, 2.22763047e-01f, 9.89210159e-02f, -9.62477028e-02f, -7.17070848e-02f, 1.44294491e-02f, 1.12067170e-01f, -3.47893089e-02f, 3.13422158e-02f,
  -2.25814492e-01f, 7.40835071e-02f, 2.06150971e-02f, -1.12815730e-01f, -3.92828062e-02f, 9.40738916e-02f, 6.42229021e-02f, -2.35612802e-02f, -4.42972817e-02f, -1.03742173e-02f,
  1.19343549e-02f, -1.51077911e-01f, -1.34338200e-01f, -1.23122528e-01f, -1.00190163e-01f, 2.31536329e-02f, 4.13901396e-02f, 2.14003567e-02f, -2.78241821e-02f, -1.44710585e-01f,
  -2.08810210e-01f, -1.36787266e-01f, 6.92055374e-02f, 2.17105318e-02f, -3.28330584e-02f, -7.91646019e-02f, 7.84190279e-03f, -9.86032337e-02f, 3.11001036e-02f, 2.93608871e-03f,
  -6.15589209e-02f, -1.75013952e-02f, -1.73688710e-01f, -1.33838728e-01f, 4.01552767e-02f, -7.76314875e-03f, -6.00907058e-02f, -4.59979661e-02f, 4.59549129e-02f, 7.53596658e-04f,
  -6.94611901e-03f, -1.84490606e-01f, -1.86679751e-01f, 8.35669786e-03f, -2.01368153e-01f, -1.37725145e-01f, 2.03060545e-02f, -1.09917231e-01f, -1.22212894e-01f, -6.75195381e-02f,
  -1.28452724e-04f, 7.77680650e-02f, 1.64573360e-02f, -1.15384407e-01f, -1.79592788e-01f, -9.44894254e-02f, -1.47616062e-02f, -6.83082864e-02f, 1.54035697e-02f, 4.50581983e-02f,
  -4.29758579e-01f, -3.33636522e-01f, 1.05229981e-01f, 1.83456808e-01f, 9.95530710e-02f, -6.50366992e-02f, -1.47928283e-01f, -3.40440609e-02f, -2.95510050e-02f, 2.31647119e-02f,
  3.86896282e-02f, -9.87346750e-03f, -1.26691416e-01f, -2.53194142e-02f, 9.70373675e-02f, -4.11272198e-02f, -1.25438556e-01f, 4.00679521e-02f, -9.09610279e-03f, -1.21987291e-01f,
  -2.40081698e-02f, 1.54956197e-02f, 1.12227410e-01f, 4.12789993e-02f, 1.25538796e-01f, 7.63317123e-02f, -3.26836389e-03f, 1.05848894e-01f, 1.35430545e-02f, 1.77939191e-01f,
  2.41197154e-01f, -2.44619429e-01f, -6.29993796e-01f, 7.98328891e-02f, -1.60361439e-01f, -2.81237692e-01f, -3.04914206e-01f, 1.70564711e-01f, 2.90769160e-01f, -3.75713319e-01f,
  -2.06070065e-01f, 7.47695044e-02f, -2.33645350e-01f, -3.62243384e-01f, -3.28187853e-01f, -5.80005646e-01f, -3.95858347e-01f, -4.09264296e-01f, -2.03438476e-01f, -2.91845649e-02f,
  -2.17173044e-02f, -7.31033161e-02f, -1.96358915e-02f, 3.95210125e-02f, 1.20228156e-01f, -6.43732324e-02f, -1.05325624e-01f, -4.42669429e-02f, -1.61548644e-01f, -2.67206192e-01f,
  -4.86806154e-01f, -2.73656368e-01f, -5.96845895e-02f, -1.32561177e-01f, -3.66257839e-02f, 1.30550116e-01f, 8.66094306e-02f, 2.15320829e-02f, 7.93332383e-02f, -1.45861745e-01f,
  -5.74780218e-02f, 8.42839926e-02f, 5.89306764e-02f, -5.04746176e-02f, 9.73786935e-02f, 4.86123599e-02f, 7.67401084e-02f, -4.18417752e-02f, -2.20641568e-01f, -1.92195669e-01f,
  -1.44154921e-01f, -1.83196738e-01f, -1.50291994e-01f, -2.81647816e-02f, -2.11049933e-02f, -7.53672123e-02f, 8.14431906e-02f, 1.54839516e-01f, 3.34066823e-02f, 9.88140032e-02f,
  1.72752902e-01f, 6.92057237e-02f, 1.09367840e-01f, 1.66685224e-01f, -1.79613773e-02f, 1.21245235e-02f, 7.81888515e-03f, -4.15364243e-02f, 1.04140244e-01f, 1.11338608e-01f,
  5.86817339e-02f, -8.88703465e-02f, 2.77429707e-02f, 9.32795554e-03f, -1.16761945e-01f, -6.07155301e-02f, -9.53121334e-02f, -6.30723760e-02f, -1.07318707e-01f, -8.59338269e-02f,
  -1.60091579e-01f, 1.08614817e-01f, 1.58725381e-02f, 8.35793465e-02f, -5.35190478e-02f, 2.25743596e-02f, -2.51671672e-02f, -2.85826232e-02f, 5.28197475e-02f, -6.36658892e-02f,
  1.85982034e-01f, -3.96129668e-01f, -2.22500652e-01f, 8.41251388e-02f, -6.16749413e-02f, -6.20639138e-02f, 4.86718789e-02f, 6.81429431e-02f, 3.41341598e-03f, 2.74302717e-02f,
  -1.00546949e-01f, -5.76671353e-03f, -1.16493523e-01f, -2.82997964e-03f, 1.04469351e-01f, 1.12441577e-01f, 3.07089742e-02f, -1.21439174e-01f, -5.22100627e-02f, 1.97077140e-01f,
  -4.22671326e-02f, -2.05167994e-01f, -7.23206159e-03f, -4.28849980e-02f, 2.46067151e-01f, -1.06046289e-01f, -1.84325442e-01f, -9.95446593e-02f, -1.34588793e-01f, -4.29340936e-02f,
  -2.29557097e-01f, 8.97168070e-02f, 1.35885328e-02f, 2.84271121e-01f, 2.57320791e-01f, -1.89417556e-01f, -3.81848633e-01f, -3.89439613e-01f, -6.53907657e-02f, 4.30827588e-02f,
  1.61200203e-03f, 1.80277601e-01f, 6.81145191e-02f, 3.91417295e-02f, -3.14667732e-01f, 2.86255992e-04f, 2.40470022e-01f, -1.33560207e-02f, -2.97962397e-01f, -1.41673610e-01f,
  7.84879699e-02f, 1.55129567e-01f, -1.43829495e-01f, -6.03043959e-02f, 2.74253815e-01f, 1.26941338e-01f, 1.65937960e-01f, 2.18621820e-01f, 8.69723335e-02f, 4.21724379e-01f,
  9.90672186e-02f, -5.82365468e-02f, -1.55316174e-01f, 1.37480110e-01f, 2.72031277e-01f, 7.10673556e-02f, -7.97559172e-02f, 1.47339508e-01f, 7.43702799e-02f, 8.97363015e-03f,
  1.86191112e-01f, 3.60537064e-03f, 2.33054280e-01f, -1.38526838e-02f, -1.25015989e-01f, -2.63014972e-01f, -9.79121923e-02f, -9.05393735e-02f, -1.02871306e-01f, -1.37601957e-01f,
  3.91290575e-01f, 3.29401493e-01f, -7.89923891e-02f, -4.94229905e-02f, -1.40410826e-01f, 5.87978140e-02f, -1.91613525e-01f, -1.27243862e-01f, -4.50808704e-01f, -7.33211040e-02f,
  -1.10202774e-01f, 2.13494599e-02f, -1.16145946e-02f, 4.17689383e-02f, 1.89690292e-02f, 2.60697883e-02f, 1.53847307e-01f, 1.73115730e-02f, 9.47013423e-02f, -4.75466624e-02f,
  -5.58894686e-03f, -3.03032864e-02f, 1.72139555e-02f, -1.68338150e-01f, -7.02911988e-02f, 9.43783950e-03f, 9.15533006e-02f, -1.19896032e-01f, -1.50034681e-01f, -4.06906381e-02f,
  1.23555064e-01f, 5.38492352e-02f, 1.78467035e-01f, -1.27014555e-02f, 6.09278083e-02f, 2.80212741e-02f, 1.62653551e-02f, -4.14695330e-02f, -1.39514223e-01f, 1.61587335e-02f,
  -3.10637116e-01f, -2.00761244e-01f, -3.10057066e-02f, -1.02799386e-01f, 4.69684824e-02f, -1.95142650e-03f, 7.92053863e-02f, 1.70210693e-02f, 5.87289110e-02f, -7.85717145e-02f,
  -1.89170949e-02f, -5.91066144e-02f, 9.57037583e-02f, -7.41945803e-02f, -2.65923049e-02f, 7.34312460e-04f, -1.07326005e-02f, 8.16659033e-02f, -7.70187676e-02f, -4.84729819e-02f,
  3.56587581e-02f, -4.28582937e-01f, -3.31901133e-01f, -2.72147864e-01f, -1.30724534e-01f, -3.10505569e-01f, -2.35725626e-01f, -3.00905824e-01f, -3.78152192e-01f, -4.67414051e-01f,
  -7.08226740e-01f, 3.17809403e-01f, 8.27122703e-02f, -3.84419024e-01f, -3.12329322e-01f, -2.22587526e-01f, 2.75480330e-01f, -1.96667716e-01f, -3.52054030e-01f, 2.85205215e-01f,
  -1.20590672e-01f, -3.96887720e-01f, -2.06333995e-01f, -7.61471018e-02f, -1.35444164e-01f, 3.61179262e-01f, 1.04076944e-01f, -1.91524714e-01f, -5.44255733e-01f, -2.59066015e-01f,
  -1.88928977e-01f, -3.58864307e-01f, -4.42158848e-01f, -2.79479563e-01f, -1.09113790e-01f, -3.11678261e-01f, 1.33728877e-01f, -2.28562877e-01f, -1.59365699e-01f, 2.03934815e-02f,
  2.02769786e-01f, -3.34387124e-01f, -1.24019735e-01f, -9.99120101e-02f, -1.96509808e-02f, -9.57965627e-02f, 1.38192680e-02f, -1.06306612e-01f, 4.37811464e-02f, 3.06307003e-02f,
  -1.43558979e-01f, 1.50859775e-02f, -2.54946023e-01f, 1.43737523e-02f, -1.16239227e-01f, -1.18702099e-01f, 7.72748441e-02f, -9.15998966e-03f, 4.76900451e-02f, 1.64456278e-01f,
  1.22412339e-01f, 1.01150744e-01f, 4.86949123e-02f, 1.10883884e-01f, 3.74222957e-02f, -9.32586268e-02f, 5.25259338e-02f, -5.35552688e-02f, -1.01633236e-01f, 2.01813206e-01f,
  2.17195392e-01f, 8.31722915e-02f, -1.01076521e-01f, -7.12685240e-03f, 1.35420948e-01f, 3.61190587e-02f, 1.16368150e-02f, 8.15514773e-02f, 1.22495173e-02f, 4.44967672e-02f,
  1.36633456e-01f, -6.86890036e-02f, -7.43905529e-02f, 6.79169148e-02f, -6.76049143e-02f, -7.62823001e-02f, 8.00613165e-02f, -2.10411604e-02f, 7.29616135e-02f, -6.01651296e-02f,
  -1.13368586e-01f, 5.74239381e-02f, -7.49342740e-02f, -1.06874526e-01f, -2.64319032e-02f, -5.60062043e-02f, 4.03858684e-02f, -7.07925810e-03f, -3.30823101e-02f, -1.89643763e-02f,
  5.60327172e-02f, -2.93012172e-01f, 1.95698202e-01f, 4.04261760e-02f, -3.50232907e-02f, 4.44239751e-02f, -7.39524215e-02f, -8.03287104e-02f, -9.15839151e-02f, -6.45496473e-02f,
  -1.21308520e-01f, 2.89013311e-02f, -3.36220860e-02f, 1.16091676e-01f, -8.71151239e-02f, -2.31997296e-02f, 1.55999824e-01f, 6.82918802e-02f, 1.26629546e-02f, 1.78703099e-01f,
  1.72243193e-01f, 2.85680413e-01f, 2.55388141e-01f, 2.51081765e-01f, 7.40189664e-03f, 6.88536912e-02f, 2.04929560e-01f, 5.69312163e-02f, 4.21286151e-02f, 4.12066847e-01f,
  8.09057236e-01f, 5.74403465e-01f, 2.44480461e-01f, -9.81113613e-02f, -9.26150978e-02f, -6.73187599e-02f, 1.60386384e-01f, 8.75229910e-02f, 6.07989840e-02f, 1.20822661e-01f,
  1.64684281e-01f, -8.05038959e-03f, -6.02671057e-02f, -3.51845585e-02f, 1.28079444e-01f, -7.92143196e-02f, -1.41345635e-01f, -5.89281917e-02f, -4.27991673e-02f, -3.74151878e-02f,
  -1.90692082e-01f, 1.37074918e-01f, 3.12484801e-01f, 1.39452338e-01f, 6.78699985e-02f, -2.80897349e-01f, -2.60674376e-02f, 2.93261725e-02f, -8.15472379e-02f, -7.57045969e-02f,
  -1.02116667e-01f, 2.76486307e-01f, -2.60315895e-01f, 1.16012260e-01f, 2.94330209e-01f, 2.94178605e-01f, 9.86858755e-02f, 1.73695877e-01f, 1.92140445e-01f, -6.62244037e-02f,
  2.89283432e-02f, 1.47826061e-01f, 1.05886832e-02f, 9.09141451e-02f, 1.25532346e-02f, -2.19165962e-02f, 1.04131877e-01f, -2.92358994e-02f, -1.78621225e-02f, 1.67898070e-02f,
  3.02046500e-02f, 1.74728094e-03f, -3.83723676e-02f, -7.36728236e-02f, -1.10277534e-01f, -2.22160853e-02f, -1.10933390e-02f, 1.47183826e-02f, 4.42639217e-02f, 3.08046974e-02f,
  -1.46469235e-01f, 2.16946378e-02f, -5.42573407e-02f, -9.40631926e-02f, 4.72482946e-03f, -7.19310120e-02f, -1.06238350e-01f, -1.01828076e-01f, -1.07651152e-01f, 8.27898085e-02f,
  -1.45932034e-01f, -5.46096750e-02f, 6.28755763e-02f, -1.02693982e-01f, 7.74547830e-02f, 4.49739695e-02f, -6.03198598e-04f, 1.54019967e-02f, 1.46763123e-04f, 5.34746498e-02f,
  -9.45565626e-02f, -5.10952249e-02f, 1.48485377e-02f, 1.47152930e-01f, -6.42333776e-02f, -3.95892225e-02f, 1.87497083e-02f, 1.40067935e-01f, 5.34582837e-03f, -1.10751744e-02f,
  -9.96239781e-02f, -9.98500176e-03f, -2.11191922e-01f, 3.32733430e-02f, 1.59439772e-01f, 2.13114545e-01f, -4.38048244e-02f, 4.16507125e-02f, 7.31240883e-02f, -4.31048274e-02f,
  5.81539944e-02f, 1.55799165e-01f, 1.72319084e-01f, 7.08282962e-02f, -4.66009714e-02f, -7.24362954e-02f, -8.90845899e-03f, -1.21233821e-01f, -6.34279922e-02f, 4.95032370e-02f,
  3.34691182e-02f, -1.03050344e-01f, -1.97675407e-01f, -1.85101792e-01f, -2.65176386e-01f, -1.93025768e-01f, -2.34206632e-01f, -1.73879668e-01f, -1.65324047e-01f, -4.85922657e-02f,
  -2.96574324e-01f, 1.82609316e-02f, 2.39083141e-01f, 5.55067137e-02f, 1.65451884e-01f, -1.37117520e-01f, -4.62736160e-01f, -2.18564644e-01f, 7.25899041e-02f, -2.31181458e-01f,
  -3.58303338e-02f, -1.32207200e-02f, -7.13408142e-02f, -3.35368246e-01f, -8.34722936e-01f, -6.21972382e-01f, -3.55955154e-01f, -3.52351069e-01f, -3.07255387e-01f, -1.79278746e-01f,
  -4.47142683e-02f, -1.57181203e-01f, -1.09599166e-01f, 1.02964662e-01f, 3.43093812e-01f, 1.17260322e-01f, 2.35598385e-01f, 1.04517534e-01f, 1.46499231e-01f, 2.13044703e-01f,
  -8.28428119e-02f, 1.81168988e-01f, -5.34751161e-04f, -2.05996148e-02f, 1.35519534e-01f, -5.78227714e-02f, -2.03251183e-01f, 1.14007600e-01f, 5.06926589e-02f, -3.76537777e-02f,
  1.97244748e-01f, -3.86201311e-03f, 1.38122886e-01f, -6.85878769e-02f, -4.48795455e-03f, -8.14407989e-02f, 3.00182682e-02f, -1.33958831e-01f, -2.07711712e-01f, -2.67694723e-02f,
  -1.59187242e-01f, -1.82778269e-01f, -2.59194337e-03f, 4.90762293e-02f, -7.55961686e-02f, -9.52521116e-02f, 3.50910068e-01f, 3.58001947e-01f, 5.76496832e-02f, 5.63561730e-02f,
  -4.30092961e-02f, -6.55247942e-02f, 2.03295313e-02f, 2.86110980e-03f, -2.19539255e-01f, 8.57561678e-02f, 1.33250654e-02f, -6.52649179e-02f, -6.14015274e-02f, -1.15421548e-01f,
  -6.85253888e-02f, 3.96396853e-02f, 8.21431577e-02f, 1.72048435e-02f, 4.96214032e-02f, 2.85795401e-03f, 4.01398130e-02f, -1.09453820e-01f, 2.70925444e-02f, 1.21115856e-02f,
  -1.42389566e-01f, 1.95052288e-02f, 5.46091646e-02f, -5.34218363e-02f, 1.29020110e-01f, -3.63131538e-02f, 1.19715497e-01f, -3.32165360e-02f, -5.65533116e-02f, -2.34323349e-02f,
  -4.83327843e-02f, -9.91037022e-03f, -2.05099925e-01f, -1.60948798e-01f, -3.47050615e-02f, 8.97855833e-02f, 9.62465033e-02f, -1.59044802e-01f, -3.12871113e-02f, -6.81471750e-02f,
  1.58812836e-01f, -1.41866311e-01f, 9.56609324e-02f, -3.91851515e-02f, -2.41104886e-01f, 6.01519458e-02f, -4.17191535e-01f, 3.23247313e-02f, -1.76559776e-01f, 8.67704526e-02f,
  -1.48101717e-01f, -4.56989229e-01f, -4.01513368e-01f, -1.53495729e-01f, -5.47555760e-02f, -1.39556140e-01f, -3.93930152e-02f, 7.15431646e-02f, -4.13439184e-01f, -5.44835269e-01f,
  3.82324010e-01f, -1.62134215e-01f, 8.91496465e-02f, 1.04680926e-01f, 1.53204575e-01f, -2.54244041e-02f, -1.63979724e-01f, -6.40832260e-02f, 1.03213876e-01f, 8.59794095e-02f,
  1.04566962e-01f, 4.13517803e-01f, 2.27077544e-01f, 1.20206393e-01f, 1.12572759e-02f, 4.24747430e-02f, 6.38355687e-02f, 2.44249851e-01f, 2.79521883e-01f, 8.75028670e-02f,
  1.14485122e-01f, 4.61773016e-02f, -4.65422198e-02f, -1.81481242e-02f, 1.41833685e-02f, 2.86635458e-01f, 2.69920360e-02f, -1.91309769e-02f, -1.64545588e-02f, 1.90089911e-01f,
  3.62844586e-01f, -1.23869032e-01f, 1.15073696e-01f, -4.61556688e-02f, -1.01410011e-02f, -1.63754702e-01f, -6.92431033e-02f, -8.73458683e-02f, -4.72868495e-02f, -8.58863145e-02f,
  7.16565847e-02f, -9.77497771e-02f, -1.25464290e-01f, -3.58308405e-02f, -7.02497724e-04f, 3.15711349e-02f, -1.90814614e-01f, -1.49241671e-01f, -5.39991073e-02f, 6.89618010e-03f,
  -1.70612987e-02f, 4.93388139e-02f, 3.62733305e-02f, -1.41999662e-01f, -6.27276376e-02f, 1.42165661e-01f, 3.85397486e-02f, -3.20485570e-02f, -1.62058510e-02f, 2.76382472e-02f,
  1.20602906e-01f, 1.54132023e-01f, 3.38196874e-01f, 2.08472237e-01f, 1.13593519e-01f, 2.26818413e-01f, 1.11890668e-02f, 9.23645347e-02f, 6.58376664e-02f, 1.06957160e-01f,
  2.33217761e-01f, 1.33939818e-01f, -8.17823131e-03f, 1.45351261e-01f, 7.59561136e-02f, 2.16013744e-01f, 1.39607251e-01f, 1.90202724e-02f, 1.39737993e-01f, 1.27105013e-01f,
  1.85283154e-01f, 1.92014184e-02f, 1.44685507e-01f, 7.83281401e-02f, 3.46044116e-02f, 2.16965094e-01f, 1.20970741e-01f, 1.15144752e-01f, 1.19433828e-01f, 5.75037487e-02f,
  -1.59459457e-01f, -7.26353824e-02f, 9.09258798e-02f, 6.48062211e-03f, 7.08479881e-02f, -1.36851132e-01f, 5.79388104e-02f, -1.42075479e-01f, -2.11947244e-02f, -1.50106788e-01f,
  9.17793438e-02f, -3.92267928e-02f, -6.39259145e-02f, -1.44832820e-01f, 1.39387518e-01f, 2.60973349e-03f, 8.28152448e-02f, -3.10988985e-02f, -1.00408413e-01f, -1.05647892e-01f,
  -4.96862121e-02f, -1.16548017e-01f, 1.69787273e-01f, 4.92496565e-02f, -9.04152021e-02f, 1.88118502e-01f, 1.27719894e-01f, -4.13259864e-02f, -1.92914791e-02f, 3.77335362e-02f,
  -7.14569092e-01f, -3.23573261e-01f, 2.26506546e-01f, -2.52779782e-01f, 2.89134800e-01f, 4.53301072e-01f, 5.91447771e-01f, 1.47079006e-01f, -1.02229891e-02f, 4.74251211e-02f,
  -1.80629119e-01f, -1.97986841e-01f, -8.70665535e-02f, 8.37198347e-02f, 1.61031559e-01f, 3.25928986e-01f, 3.67516875e-01f, 2.33751163e-02f, 2.46908486e-01f, 1.60652623e-01f,
  7.70172477e-02f, -1.84574604e-01f, -3.49403739e-01f, -6.99481741e-02f, -2.46327203e-02f, -3.87375541e-02f, -1.81692585e-01f, -1.95420921e-01f, -3.25788334e-02f, -7.70008483e-04f,
  -1.50643498e-01f, -6.10423744e-01f, 2.70707220e-01f, -1.89796790e-01f, 1.86734647e-02f, 3.71081196e-02f, 8.58322084e-02f, -3.09220254e-01f, -1.69078380e-01f, -1.34763479e-01f,
  -1.71913460e-01f, -1.22141398e-01f, -9.02286172e-02f, 1.12316251e-01f, -6.93027079e-02f, 8.54837801e-03f, -1.32233024e-01f, -1.80876300e-01f, -2.44657487e-01f, -1.78408638e-01f,
  4.26129363e-02f, -2.31024235e-01f, -2.34717607e-01f, -2.29563247e-02f, 5.05140191e-03f, 6.80548255e-04f, -1.54093176e-01f, -1.57260984e-01f, -1.48565143e-01f, -2.51914024e-01f,
  1.04746960e-01f, -8.07878375e-02f, -2.52672769e-02f, -4.96230647e-03f, -6.78467527e-02f, 6.74744621e-02f, 4.71191965e-02f, -7.42222816e-02f, -2.59965695e-02f, 4.26167510e-02f,
  -1.54128363e-02f, 6.19414784e-02f, -4.43046875e-02f, -1.19311012e-01f, 3.54721700e-03f, -1.61055937e-01f, 1.89672902e-01f, -1.87133417e-01f, 5.05310157e-03f, 3.76991834e-03f,
  -1.39256371e-02f, 8.24070908e-03f, -2.16039978e-02f, 1.96840420e-01f, 1.75842047e-01f, 1.62607059e-01f, 1.59816667e-02f, 1.39981769e-02f, -1.49846515e-02f, -5.43166026e-02f,
  4.29595746e-02f, 1.56605262e-02f, -1.71956673e-01f, -1.25920728e-01f, -1.50600553e-01f, -1.83888786e-02f, -1.73979014e-01f, -1.03255622e-01f, 7.70047978e-02f, -4.65477593e-02f,
  -8.68009403e-02f, -1.05051905e-01f, -2.41446458e-02f, 1.65898341e-03f, 1.16286628e-01f, 9.00223255e-02f, 7.18859136e-02f, 8.41298625e-02f, -3.29217166e-02f, -2.93868463e-02f,
  5.62458485e-02f, 1.58446938e-01f, 2.86948621e-01f, 1.98151231e-01f, 5.04486822e-02f, 2.27792308e-01f, 1.26390934e-01f, 2.46962413e-01f, 2.66511500e-01f, 2.80042857e-01f,
  5.48992693e-01f, 9.12270229e-03f, 2.18736336e-01f, 2.70076185e-01f, 5.22205122e-02f, -4.36644256e-02f, -5.33591993e-02f, 1.54429823e-01f, 1.30837068e-01f, 1.13958262e-01f,
  1.83685541e-01f, 3.26243877e-01f, 3.00465107e-01f, 3.31013024e-01f, 2.00885564e-01f, 1.73939794e-01f, 2.42010072e-01f, 2.69835740e-01f, 3.25062931e-01f, 1.75196037e-01f,
  1.80807009e-01f, 5.29498421e-02f, 1.51772887e-01f, 1.40722141e-01f, 7.04411417e-02f, 9.80562493e-02f, 9.36819762e-02f, -6.78164214e-02f, 8.54244232e-02f, 2.01346621e-01f,
  -1.44586980e-01f, 6.16443940e-02f, 1.55222505e-01f, -4.04963605e-02f, -5.80594204e-02f, -1.41315028e-01f, -3.42841707e-02f, -1.51409134e-01f, -1.76499546e-01f, -4.55493554e-02f,
  -1.64580241e-01f, -1.27924949e-01f, -2.74774432e-02f, -3.58779402e-03f, -6.53398558e-02f, -4.49699014e-02f, 1.40096070e-02f, -1.11930361e-02f, 1.15008958e-01f, -5.42536974e-02f,
  2.55513024e-02f, -1.73307270e-01f, -4.33787368e-02f, 6.91797808e-02f, 1.88020676e-01f, -1.59550030e-02f, -7.19577670e-02f, -4.74553220e-02f, 3.27427387e-02f, 6.87572062e-02f,
  1.81840211e-01f, 1.58323929e-01f, 1.33124635e-01f, 1.04948923e-01f, 1.64783463e-01f, 8.99740309e-02f, 3.38151939e-02f, 3.40296440e-02f, 4.77683134e-02f, -6.68468550e-02f,
  -7.80129712e-03f, 4.90009896e-02f, 1.11693561e-01f, -1.09465644e-02f, 8.93676952e-02f, -1.34616047e-01f, -1.68626070e-01f, -1.26109451e-01f, 7.31086656e-02f, -1.14962004e-01f,
  -5.39051834e-03f, -1.16601653e-01f, -3.29568423e-02f, -8.08711350e-02f, -2.75194868e-02f, 7.05214664e-02f, -8.35820008e-03f, -2.52629891e-02f, -7.72370845e-02f, -4.46510725e-02f,
  -6.07426047e-01f, 2.02458635e-01f, 1.40766785e-01f, -3.17647085e-02f, -2.72746924e-02f, -1.11445174e-01f, 1.94533825e-01f, -1.22856535e-02f, -2.25311562e-01f, -1.27886638e-01f,
  -2.00335681e-01f, 5.62667251e-02f, -1.19054295e-01f, -8.95730853e-02f, -1.43969923e-01f, -1.85045853e-01f, -1.19168228e-02f, -2.58980151e-02f, -7.19689205e-02f, -1.19762808e-01f,
  -1.01398882e-02f, -6.30983487e-02f, -9.60731879e-02f, -9.68046412e-02f, -1.78801231e-02f, 5.37292399e-02f, -1.60536855e-01f, -1.39960825e-01f, -9.58661288e-02f, -1.68725505e-01f,
  -5.00619829e-01f, -9.03837606e-02f, 5.25506616e-01f, -3.60307842e-01f, -3.24787736e-01f, -4.29409683e-01f, -2.79642016e-01f, -3.66138041e-01f, -3.69345784e-01f, -1.88130066e-01f,
  -1.93360388e-01f, 3.81064601e-02f, 2.23118678e-01f, 1.24417230e-01f, 2.08216026e-01f, 1.80974185e-01f, 1.55890897e-01f, 3.77473235e-01f, 3.40436369e-01f, -6.64250851e-02f,
  7.19085485e-02f, 1.75634503e-01f, 1.24339417e-01f, 1.19154148e-01f, 3.32730711e-02f, 3.76035012e-02f, 7.31870458e-02f, 5.74649498e-02f, 3.09818890e-02f, 4.24996108e-01f,
  7.05171049e-01f, -3.12748015e-01f, -5.80283366e-02f, -3.73969227e-02f, 1.34888574e-01f, 1.74685251e-02f, 7.88285211e-02f, 2.93411277e-02f, -1.46210954e-01f, -4.77641635e-02f,
  3.24684121e-02f, -4.97297011e-02f, -1.00259684e-01f, -2.12341473e-02f, 3.59012075e-02f, -3.12059559e-02f, -1.22542318e-03f, 5.93070872e-02f, -4.07701824e-03f, -1.50436489e-03f,
  4.33170423e-03f, -2.10325867e-01f, -4.83626798e-02f, -1.02368787e-01f, -9.76697952e-02f, 3.02858576e-02f, -1.73918239e-03f, -3.08212023e-02f, -7.52538219e-02f, -1.27154335e-01f,
  6.14707023e-02f, 4.38199751e-02f, -1.21363677e-01f, 1.33860372e-02f, -2.93833613e-02f, -1.07018605e-01f, -1.01257518e-01f, 6.86296001e-02f, 5.42045273e-02f, 4.86741215e-02f,
  -1.15787685e-01f, 3.47437593e-03f, -5.15340036e-03f, -2.95483693e-02f, 3.05872019e-02f, 7.70020336e-02f, -3.37737687e-02f, 8.09140429e-02f, -1.88535362e-01f, -1.36613265e-01f,
  -1.40974924e-01f, 5.57702258e-02f, 6.96855830e-04f, 9.19369832e-02f, -2.12073959e-02f, -5.47534041e-02f, -1.92520972e-02f, -1.18329838e-01f, -2.52670962e-02f, 3.17282160e-03f,
  3.14532042e-01f, -1.98564097e-01f, 5.60422086e-05f, 9.72269699e-02f, -6.67917877e-02f, -4.52764593e-02f, 7.87118729e-03f, -4.41921409e-03f, -8.10097679e-02f, 3.14188339e-02f,
  7.11280107e-03f, 1.17900312e-01f, 1.61646217e-01f, 1.24425553e-01f, 7.46552572e-02f, -3.19571160e-02f, -6.45176396e-02f, -3.53807770e-02f, 4.87256274e-02f, -2.52003521e-02f,
  -5.37641421e-02f, -2.81502958e-02f, 3.37895192e-02f, 1.94316283e-02f, -1.42896131e-01f, 2.93982942e-02f, 5.44084683e-02f, 1.24948516e-01f, -1.25375651e-02f, 9.58106220e-02f,
  -5.45146763e-01f, 1.75327852e-01f, -5.56579903e-02f, -5.40080480e-02f, 4.44476992e-01f, 3.21111202e-01f, 2.47634500e-01f, 5.97656593e-02f, -4.98677827e-02f, -5.15469629e-03f,
  2.88605213e-01f, 2.06602246e-01f, 5.89515967e-03f, 6.86728656e-02f, -2.55707875e-02f, 1.23640299e-01f, 1.85905155e-02f, -2.16939032e-01f, -1.59107633e-02f, 9.83151793e-02f,
  3.08796197e-01f, -1.89332679e-01f, -3.62761766e-01f, -2.14364573e-01f, -5.03566489e-02f, -1.81672409e-01f, -2.22210497e-01f, -1.47989675e-01f, 4.62414883e-02f, -1.62164897e-01f,
  -2.42896527e-01f, -4.35019322e-02f, 7.93710649e-02f, -6.02054000e-02f, 1.36430159e-01f, -1.74605057e-01f, -4.68378179e-02f, -2.49444962e-01f, 8.45141485e-02f, -2.36320108e-01f,
  9.47520807e-02f, 1.13301955e-01f, 1.09850086e-01f, -6.07956089e-02f, -1.23316385e-01f, -3.72422487e-02f, -1.49990305e-01f, -1.17593542e-01f, -2.23639145e-01f, -8.15685093e-02f,
  3.18072051e-01f, 1.43096089e-01f, -2.37336785e-01f, -2.20670160e-02f, 8.95504467e-03f, -1.54308438e-01f, -2.18801320e-01f, -2.22899631e-01f, -2.01065570e-01f, -7.34807611e-01f,
  -3.63633186e-02f, 6.96573630e-02f, 4.46705148e-02f, -5.21734953e-02f, -7.17455819e-02f, 3.19491513e-02f, 1.96600668e-02f, 7.69164786e-02f, 6.56387657e-02f, -1.78711005e-02f,
  7.72011727e-02f, 4.10975516e-02f, -1.37823746e-02f, -1.99044812e-02f, -1.22466810e-01f, -1.27758477e-02f, -1.36472499e-02f, -6.28376454e-02f, -1.86829418e-02f, -1.29824147e-01f,
  9.24938843e-02f, -3.53851169e-02f, 8.39938130e-03f, -2.80883741e-02f, 6.01904951e-02f, -1.01619147e-01f, -1.50904566e-01f, 9.98155400e-03f, -6.39319345e-02f, -5.68832308e-02f,
  -3.41721207e-01f, 3.06891680e-01f, -2.54325777e-01f, -3.71683426e-02f, 9.71542597e-02f, -2.05908958e-02f, -6.30758405e-02f, 7.51817748e-02f, 1.77834705e-01f, -1.89017907e-01f,
  2.01622933e-01f, -9.53130797e-02f, -1.25563979e-01f, -1.55464426e-01f, -1.15198568e-01f, -7.96458498e-02f, -1.08047679e-01f, -1.00234421e-02f, 8.15909207e-02f, -7.24228919e-02f,
  -7.34025910e-02f, -2.21744537e-01f, -4.08393979e-01f, -2.36621857e-01f, -2.50940830e-01f, -3.63829464e-01f, -3.86548460e-01f, -3.17348421e-01f, -3.01759392e-01f, -8.33980441e-01f,
  4.70107377e-01f, 3.93646151e-01f, 1.33432254e-01f, 3.74179482e-02f, 5.17354272e-02f, 3.33436728e-01f, 5.48440754e-01f, 3.37201923e-01f, 3.20763737e-02f, 2.02498093e-01f,
  9.81030315e-02f, -7.15202540e-02f, -1.56200379e-01f, -1.32177860e-01f, 1.43474475e-01f, 1.55088127e-01f, -2.79444605e-02f, 6.10011555e-02f, -1.10384049e-02f, 1.10742273e-02f,
  -2.27421075e-02f, 1.90499678e-01f, 6.77139387e-02f, -1.09311668e-02f, 4.18250263e-02f, -2.07470372e-01f, 9.24047604e-02f, 9.89273936e-02f, -2.57592648e-03f, -2.49050125e-01f,
  -2.08218545e-02f, 3.13482881e-01f, -3.43065500e-01f, -1.27426341e-01f, -6.05942775e-03f, -1.15896478e-01f, -1.71865076e-02f, -9.38766748e-02f, -9.79718566e-02f, -5.03196828e-02f,
  -1.23171553e-01f, 4.84641865e-02f, 1.86749414e-01f, 1.22848079e-02f, 1.08846776e-01f, -2.28686202e-02f, 1.45990163e-01f, 1.37672082e-01f, 8.84592310e-02f, 2.36204229e-02f,
  -8.82082954e-02f, 7.66236335e-02f, 1.34576917e-01f, 7.53436238e-02f, 5.12124822e-02f, -8.31353366e-02f, 1.00871719e-01f, 6.24819361e-02f, 4.56469692e-02f, -3.84332575e-02f,
  1.62217021e-02f, 3.15277800e-02f, 1.15892485e-01f, 1.36025492e-02f, 4.66747060e-02f, 1.44751249e-02f, -3.35176736e-02f, 7.95869008e-02f, 1.43245175e-01f, 1.66890621e-01f,
  9.93167832e-02f, 1.31038725e-01f, 2.22900003e-01f, 1.25976890e-01f, -7.35597238e-02f, 5.41391745e-02f, 1.72656178e-01f, 7.40362480e-02f, 4.80159745e-02f, 8.11996087e-02f,
  8.91552642e-02f, 1.44766420e-01f, 1.05906785e-01f, 1.48307636e-01f, 6.37397468e-02f, -9.06110927e-03f, 1.74989477e-02f, 1.07880488e-01f, 7.17955977e-02f, 1.56590909e-01f,
  -1.03221804e-01f, 2.94466764e-01f, -2.01914832e-01f, -1.81829259e-01f, 2.95599480e-03f, -5.13133593e-02f, -3.11065745e-02f, -6.25425354e-02f, -1.68967575e-01f, -7.86654875e-02f,
  -2.37547215e-02f, 4.45570424e-03f, 1.17230289e-01f, 1.81678057e-01f, -5.30335046e-02f, -3.22279111e-02f, -5.34754135e-02f, 2.80482154e-02f, -1.43481970e-01f, -2.04464585e-01f,
  4.48372923e-02f, 2.69654542e-02f, -7.00262189e-02f, -1.16569676e-01f, -8.76388773e-02f, -1.41773775e-01f, 3.23229320e-02f, -3.65977846e-02f, -4.67817648e-04f, -9.81436484e-03f,
  -1.05925322e-01f, -3.74824703e-01f, 2.35328212e-01f, 2.36873068e-02f, 1.14950083e-01f, -6.68401942e-02f, -1.89919338e-01f, -2.75593847e-01f, -4.52834815e-02f, -1.83203951e-01f,
  -4.86682355e-03f, 1.33495942e-01f, 6.55285865e-02f, 9.11574140e-02f, 6.37581921e-04f, -2.11699918e-01f, -9.98831466e-02f, 1.44403473e-01f, 1.72035784e-01f, 5.25426567e-02f,
  -1.59220934e-01f, -2.11854860e-01f, -4.51590680e-02f, -6.99940622e-02f, -1.20296873e-01f, 2.16856822e-02f, -1.31777257e-01f, -1.85583428e-01f, -1.60295248e-01f, -1.18203044e-01f,
  6.41788006e-01f, 5.30141443e-02f, 2.81824201e-01f, 8.65765475e-03f, -1.33495256e-01f, -7.40556866e-02f, 2.59314217e-02f, 5.63752986e-02f, -8.40741489e-03f, -4.78943959e-02f,
  8.86438861e-02f, 3.14337313e-02f, -1.15906172e-01f, -6.19451627e-02f, -3.92023437e-02f, 9.54683404e-03f, 2.03246810e-02f, -2.21505687e-02f, -8.97764415e-02f, -6.06991053e-02f,
  -6.50259629e-02f, 1.29666433e-01f, 1.02056094e-01f, 9.77733657e-02f, -6.61492646e-02f, 1.09022424e-01f, 1.24560326e-01f, 1.47764245e-02f, 6.97165579e-02f, -1.48907617e-01f,
  9.70046893e-02f, 9.99363661e-02f, 6.79993927e-02f, 1.21830292e-01f, -5.73301464e-02f, -3.53718176e-02f, 1.33357242e-01f, 5.13104163e-02f, -8.81059915e-02f, -5.68200909e-02f,
  1.27094965e-02f, -8.14378187e-02f, -7.34830648e-02f, 6.77814614e-03f, 1.01769809e-02f, -9.93088726e-03f, 8.04526806e-02f, 1.18317321e-01f, -1.05089478e-01f, -1.33289054e-01f,
  -3.97735126e-02f, -4.66339663e-02f, 1.19332653e-02f, -1.06015369e-01f, -9.74267349e-02f, 5.52018508e-02f, 9.17413011e-02f, -9.05025601e-02f, -1.25185117e-01f, -7.53325820e-02f,
  3.70029151e-01f, 1.88958541e-01f, 1.50272056e-01f, -4.39681299e-02f, 5.58249094e-02f, -6.13127388e-02f, 1.52358174e-01f, -8.76019243e-03f, 6.89378604e-02f, 1.60566077e-01f,
  9.02275890e-02f, -2.41071731e-02f, 3.47980410e-02f, -9.66942608e-02f, 1.50977764e-02f, 6.70179948e-02f, -5.44209369e-02f, 1.74919114e-01f, 9.18752104e-02f, 4.03646640e-02f,
  -1.49171844e-01f, 1.60552055e-01f, 3.27575743e-01f, 1.65101990e-01f, 9.52415019e-02f, 2.23287955e-01f, 1.54070362e-01f, 1.67745516e-01f, 9.10975188e-02f, -9.42213908e-02f,
  -4.45692539e-01f, 4.06670004e-01f, 4.42156017e-01f, -4.98615295e-01f, -2.36089230e-01f, 9.70977768e-02f, 2.67953962e-01f, -1.38294464e-02f, -2.78050005e-01f, 9.87064391e-02f,
  3.13652866e-02f, -4.31692094e-01f, -1.15312167e-01f, 1.05282575e-01f, 2.33987942e-01f, 3.84830505e-01f, 3.12369883e-01f, 4.23295703e-03f, -1.62980691e-01f, -1.78011909e-01f,
  -2.04293638e-01f, -2.64652252e-01f, -2.51457125e-01f, -3.77378613e-02f, -1.30962268e-01f, -2.23078370e-01f, 1.60916999e-01f, -4.59859334e-02f, 2.74331748e-01f, 1.75984606e-01f,
  1.22081757e-01f, 8.58182982e-02f, 4.55794903e-03f, -1.79297775e-01f, -6.96983859e-02f, -2.07137894e-02f, 5.04853912e-02f, 1.42621815e-01f, -1.08379781e-01f, 2.13159218e-01f,
  -1.22463025e-01f, 1.69235021e-02f, -2.34456956e-01f, -1.52162820e-01f, -1.45470053e-01f, -1.80288926e-01f, 1.82884663e-01f, 1.40276000e-01f, 6.50486443e-03f, 5.12110814e-02f,
  -1.09687649e-01f, -2.17749476e-01f, -1.46987557e-01f, 1.74004704e-01f, 2.60669142e-01f, -2.71616220e-01f, 1.14611030e-01f, 1.90402400e-02f, 2.25919578e-02f, -3.51277925e-02f,
  4.10720818e-02f, 7.33358739e-03f, 1.19964354e-01f, 5.36368638e-02f, -8.71928483e-02f, 3.53620611e-02f, 2.02316567e-02f, 1.76267102e-02f, -4.88486621e-05f, -8.15141201e-02f,
  -1.78263765e-02f, -5.36461361e-02f, -1.20254410e-02f, 3.77406776e-02f, -4.60537001e-02f, -4.11148518e-02f, -8.06026086e-02f, 4.39082235e-02f, -6.24483218e-04f, -2.55963276e-03f,
  -1.22423701e-01f, 1.54008269e-02f, -7.56792873e-02f, -1.41499471e-02f, 2.53270149e-01f, 4.07269634e-02f, 6.17723018e-02f, -1.63954571e-01f, -9.29943174e-02f, -3.20641175e-02f,
  -5.10801494e-01f, 2.51743495e-01f, -4.85213771e-02f, 1.15495630e-01f, -5.36419526e-02f, 2.26402860e-02f, -8.28651898e-03f, 1.14481524e-01f, 1.98861118e-02f, -6.15307391e-02f,
  1.49201706e-01f, -1.39406081e-02f, -7.32010305e-02f, -5.79337850e-02f, -2.88211197e-01f, -8.30296949e-02f, -1.42635584e-01f, -3.38533968e-01f, -1.28600657e-01f, -1.98762208e-01f,
  -2.01409727e-01f, -3.38903874e-01f, -4.65087742e-01f, -3.02978843e-01f, -2.50607312e-01f, -4.45138872e-01f, -1.97849825e-01f, -2.21854702e-01f, -2.39586473e-01f, -3.35921198e-01f,
  -6.44096434e-02f, 4.33069259e-01f, -3.48192096e-01f, 2.89239973e-01f, 8.51723254e-02f, -2.55502373e-01f, -2.63825715e-01f, -2.68724859e-01f, 1.79370642e-01f, 1.58124775e-01f,
  1.16487585e-01f, 9.84103084e-02f, 1.76714323e-02f, -3.92103456e-02f, -3.16794038e-01f, 4.37001772e-02f, 8.70032907e-02f, -2.78592199e-01f, -4.56510663e-01f, -3.33772749e-01f,
  3.24554473e-01f, 2.56041169e-01f, -5.67698702e-02f, -1.17207646e-01f, 2.89581090e-01f, 2.57863641e-01f, 1.59566090e-01f, 2.61841297e-01f, 1.31745666e-01f, 2.87664533e-01f,
  -2.93364465e-01f, -2.34529004e-01f, -2.98624933e-01f, 1.05750173e-01f, 1.25138074e-01f, -1.86420962e-01f, -3.10842246e-01f, -2.04005182e-01f, -2.69976735e-01f, -1.26551956e-01f,
  -2.94368081e-02f, -2.21672937e-01f, -1.63068116e-01f, 7.62434676e-02f, 1.97577551e-02f, -3.33660483e-01f, -6.44438490e-02f, -3.13270926e-01f, -2.69148231e-01f, -3.22938472e-01f,
  1.14668675e-01f, -6.26964346e-02f, -4.46372926e-01f, -2.70560741e-01f, -2.64397234e-01f, -1.17254727e-01f, -2.07328394e-01f, -3.20504755e-01f, -4.72849220e-01f, 4.98283058e-02f,
  -6.14150017e-02f, 6.77492172e-02f, 1.59042329e-01f, 2.09113806e-01f, -1.92943644e-02f, 6.69226721e-02f, -1.01816766e-02f, 1.01750933e-01f, 2.04019877e-03f, 4.43774723e-02f,
  -2.36229226e-01f, -9.88576561e-04f, -1.10732846e-01f, 3.14779617e-02f, 6.57042563e-02f, -8.38524029e-02f, -6.29585758e-02f, 9.62855443e-02f, 2.85636783e-02f, 1.57277286e-02f,
  -8.71931463e-02f, -1.21168263e-01f, 1.01888731e-01f, -1.77443013e-01f, 6.85208514e-02f, -6.95450697e-04f, 5.00670820e-02f, -5.62770404e-02f, -2.41254140e-02f, 2.17586718e-02f,
  2.18325466e-01f, -8.80561247e-02f, -2.90679885e-03f, -5.59941344e-02f, 1.20462112e-01f, -1.73157372e-03f, 9.78041366e-02f, 8.33679587e-02f, 2.19476860e-04f, -1.74823597e-01f,
  -3.04401577e-01f, -2.78286546e-01f, -1.53178535e-02f, 1.15976287e-02f, -2.24660225e-02f, 7.51408115e-02f, 2.73507118e-01f, 1.68177202e-01f, 3.74362431e-02f, 7.88822491e-03f,
  1.99610278e-01f, 6.81838021e-02f, 1.30302876e-01f, 5.07406844e-03f, 1.22333176e-01f, 1.16166063e-01f, 1.31986244e-02f, -1.63769182e-02f, -1.01363562e-01f, 4.56444800e-01f,
  7.76526093e-01f, -4.34091389e-01f, 1.45973891e-01f, 7.76626319e-02f, -9.39912573e-02f, -2.93545201e-02f, -1.81951940e-01f, -5.71591593e-02f, 8.77658427e-02f, -1.47965193e-01f,
  -6.55356273e-02f, -4.78488542e-02f, 9.32995826e-02f, 1.09159507e-01f, 4.10032272e-02f, -2.10957564e-02f, -1.56037703e-01f, 2.17258453e-01f, 1.77707449e-01f, -5.16493209e-02f,
  -1.94430441e-01f, -8.55084658e-02f, 1.36391059e-01f, 1.18001392e-02f, -2.74361223e-01f, -6.23622090e-02f, -1.28865510e-01f, -1.61631778e-01f, -2.62034982e-01f, -3.23562652e-01f,
  -1.07557110e-01f, 1.22286715e-01f, 2.23503143e-01f, 3.60339545e-02f, 3.52119394e-02f, 8.58386233e-02f, 6.25082031e-02f, -2.02028695e-02f, -4.82099764e-02f, -1.44414663e-01f,
  2.19233073e-02f, -3.39062419e-03f, -9.65635255e-02f, -5.48252501e-02f, -1.48777351e-01f, 2.30563805e-02f, -4.06423621e-02f, 6.69436753e-02f, -9.53629017e-02f, -5.58385439e-02f,
  -6.28388226e-02f, -8.10325667e-02f, -7.15057328e-02f, 1.21954449e-01f, 1.04691647e-01f, 4.29560021e-02f, 7.98813328e-02f, 2.65000444e-02f, 1.30211547e-01f, 1.04582451e-01f,
  1.30231217e-01f, 7.85205439e-02f, 1.55020773e-03f, 7.00821802e-02f, 9.56645422e-03f, 1.56801224e-01f, -7.55101517e-02f, 2.09197756e-02f, 1.25142127e-01f, 8.57215673e-02f,
  -1.14186980e-01f, -1.17412638e-02f, -3.46787050e-02f, 5.70033379e-02f, 7.92464539e-02f, -5.79490028e-02f, -2.98139788e-02f, -1.25103459e-01f, -3.36224847e-02f, -2.50905380e-02f,
  1.14028476e-01f, -9.54667926e-02f, -8.90891328e-02f, -1.34611621e-01f, -2.04341546e-01f, 5.78243993e-02f, -4.17461954e-02f, -6.01843782e-02f, -7.30094984e-02f, -1.46369711e-01f,
  -2.96071857e-01f, 2.12540954e-01f, 1.03697553e-01f, -3.34013328e-02f, 1.95751898e-02f, -2.39134151e-02f, 1.29459828e-01f, -1.20257467e-01f, -1.28074855e-01f, -6.33291453e-02f,
  -6.56547770e-02f, 1.07562743e-01f, -5.27500641e-03f, -1.95570067e-02f, 4.78147157e-02f, 1.18889473e-01f, 1.48187475e-02f, 1.10748127e-01f, 4.39898521e-02f, -1.39500082e-01f,
  -1.88708808e-02f, 6.21529557e-02f, 1.46692783e-01f, 7.80571327e-02f, 1.17432743e-01f, 1.92037657e-01f, -2.61497730e-03f, 3.29211354e-03f, 5.98199368e-02f, -2.79792380e-02f,
  -2.04343170e-01f, -2.77485568e-02f, 1.26169786e-01f, 2.32728854e-01f, 1.46886021e-01f, 3.26961458e-01f, 2.32843563e-01f, 2.46471182e-01f, 1.89162433e-01f, 8.79812762e-02f,
  5.04023694e-02f, 9.66007784e-02f, 1.72303498e-01f, 2.53310680e-01f, 2.19669327e-01f, 2.45737895e-01f, 1.56521410e-01f, 1.02844179e-01f, -2.73399092e-02f, 4.77180555e-02f,
  5.81961498e-03f, -9.26792920e-02f, -1.80484757e-01f, -5.09840203e-04f, -6.95898011e-02f, 5.83512746e-02f, 1.77666396e-02f, 9.46252719e-02f, 2.85060313e-02f, -3.73983271e-02f,
  -1.15358010e-02f, -5.99659421e-02f, 1.45120457e-01f, 4.01421003e-02f, -1.95602804e-01f, -2.10773140e-01f, -9.00389999e-03f, -2.11783543e-01f, -1.68057442e-01f, -4.07244749e-02f,
  -5.65556511e-02f, -6.18282221e-02f, 2.99372766e-02f, -5.74996099e-02f, -7.04891533e-02f, -4.30117399e-02f, -2.14182641e-02f, 1.24536619e-01f, 2.06476465e-01f, 1.26913741e-01f,
  -1.91486869e-02f, 6.52626669e-03f, 6.96060658e-02f, 2.02325165e-01f, 1.40132397e-01f, 1.31517187e-01f, 1.86195839e-02f, -7.32490197e-02f, 4.49060723e-02f, -2.54497194e-04f,
  1.63219288e-01f, 5.03552966e-02f, 1.24285839e-01f, 1.08381733e-01f, 9.91235301e-02f, 7.18572289e-02f, 7.55952075e-02f, 1.70990214e-01f, 5.84679954e-02f, -9.01458412e-02f,
  1.53912194e-02f, 1.72102675e-01f, 1.74214005e-01f, 1.13728784e-01f, 1.20110775e-03f, -2.62570567e-02f, -1.02509424e-01f, -5.94675429e-02f, 3.45970392e-02f, 3.93695608e-02f,
  1.72578543e-02f, 3.45077775e-02f, -1.99287027e-01f, -1.20220017e-02f, -2.99871434e-02f, 1.65204611e-02f, 5.98435104e-02f, 3.81696131e-03f, 7.53197772e-03f, -1.43954471e-01f,
  1.16962261e-01f, 4.68996495e-01f, -1.67840335e-05f, -3.73874581e-03f, -2.35767975e-01f, -9.69822630e-02f, 1.05266638e-01f, -6.07259460e-02f, -4.19720262e-02f, 2.17113961e-02f,
  -7.86624849e-03f, -1.90217346e-01f, -6.30726516e-02f, -3.38222161e-02f, -1.19899131e-01f, -1.04725726e-01f, -1.23714685e-01f, 3.80591936e-02f, 1.10689051e-01f, -1.03748001e-01f,
  -2.81548258e-02f, -5.18915849e-03f, 5.70294298e-02f, 2.15200394e-01f, 1.74450263e-01f, 1.04261436e-01f, -4.63667475e-02f, -9.80843138e-03f, -5.59170134e-02f, -4.13986892e-02f,
  8.78251418e-02f, 7.09721446e-03f, -2.28365734e-01f, 4.33187962e-01f, 1.39145523e-01f, -3.31684262e-01f, -4.76264954e-01f, -2.95995861e-01f, 1.46442950e-01f, 6.88001662e-02f,
  1.07984789e-01f, 1.74571991e-01f, 8.21934417e-02f, 3.42242084e-02f, -2.88600355e-01f, -6.54878244e-02f, 1.47631943e-01f, 6.16417674e-04f, -2.79342204e-01f, -1.57321036e-01f,
  2.55353987e-01f, 1.63475186e-01f, 5.08064078e-03f, 4.07650098e-02f, 3.98123890e-01f, 2.21761584e-01f, 1.83552086e-01f, 2.43185997e-01f, 6.10962808e-02f, 4.99295354e-01f,
  5.47626913e-02f, -5.83844595e-02f, -2.18369082e-01f, 8.43769386e-02f, -4.02087010e-02f, -1.40510097e-01f, -7.37812370e-02f, 6.58000857e-02f, 1.25251442e-01f, -6.34101182e-02f,
  1.95240140e-01f, 6.48258552e-02f, 2.30084792e-01f, 3.72350030e-02f, 6.49848906e-03f, -2.29823217e-01f, -1.99594051e-01f, -2.68230498e-01f, -1.09748155e-01f, -8.95416215e-02f,
  3.15279961e-01f, 1.21988565e-01f, -2.11184129e-01f, -2.94710428e-01f, -2.24081933e-01f, 3.06174271e-02f, -1.52371094e-01f, -6.47539971e-04f, -4.77884084e-01f, -1.16690017e-01f,
  -6.07047305e-02f, -7.55709484e-02f, -1.04022011e-01f, -9.91534144e-02f, -3.65046486e-02f, 7.19016343e-02f, 1.39034435e-01f, -3.67591567e-02f, 5.06615601e-02f, -6.07949607e-02f,
  -9.34922323e-03f, -4.07139622e-02f, -9.56693850e-03f, -6.52805120e-02f, -3.63667905e-02f, 2.63149152e-03f, -2.88655832e-02f, -6.56486303e-02f, -1.15976229e-01f, 1.53706474e-02f,
  -2.83549745e-02f, -3.35555635e-02f, -5.48154465e-04f, -1.02834597e-01f, 9.42283347e-02f, -2.05308311e-02f, 5.02040014e-02f, -1.22082755e-01f, -7.31614418e-04f, -6.49572760e-02f,
  -1.46283340e-02f, -2.42709115e-01f, 1.31235763e-01f, 2.65619736e-02f, 1.12147769e-02f, -5.51287718e-02f, 6.63147941e-02f, -7.18226582e-02f, 1.72031820e-02f, -1.03450380e-01f,
  -1.31938338e-01f, -5.10401651e-02f, -2.06575133e-02f, -7.09247664e-02f, -1.52033180e-01f, 1.27485264e-02f, -1.20702021e-01f, -6.51347339e-02f, -1.96698397e-01f, -9.29396451e-02f,
  -1.24103986e-01f, -4.09897476e-01f, -2.23738194e-01f, -2.63812900e-01f, -2.10712656e-01f, -2.18782321e-01f, -1.37244701e-01f, -2.19157845e-01f, -4.17106688e-01f, -5.12557209e-01f,
  4.24548954e-01f, -1.76322266e-01f, -6.88792884e-01f, -7.09939525e-02f, -5.41046202e-01f, -5.09900987e-01f, -4.82242346e-01f, 2.81274207e-02f, 1.20575890e-01f, -2.88114995e-01f,
  -2.29976326e-01f, 3.82393658e-01f, 7.26800114e-02f, 2.51011569e-02f, 1.52776297e-02f, -4.97759938e-01f, -5.49134135e-01f, -2.81493038e-01f, -1.40178874e-01f, -1.63366124e-01f,
  -1.29251465e-01f, -1.39830962e-01f, 3.29812542e-02f, -2.46446375e-02f, -1.85671613e-01f, -7.71679953e-02f, -4.58164185e-01f, -3.11534137e-01f, -3.82139832e-01f, -3.97976667e-01f,
  -2.55412608e-01f, -2.18167871e-01f, -9.99957249e-02f, 3.06926221e-02f, -2.23577976e-01f, 1.31962914e-02f, -3.94001007e-02f, -4.86449189e-02f, 1.39087632e-01f, -3.95407267e-02f,
  -1.10668138e-01f, -7.34244660e-02f, 7.90568292e-02f, -1.55078530e-01f, -3.19642752e-01f, -7.87043348e-02f, -1.92961723e-01f, -5.85933328e-02f, -2.35492960e-01f, -2.22900108e-01f,
  -1.21660739e-01f, -3.61571580e-01f, -5.82501404e-02f, -1.93143472e-01f, -2.22646415e-01f, -4.66455258e-02f, -2.04874247e-01f, -1.60296753e-01f, -2.26708248e-01f, 1.01396941e-01f,
  8.50256309e-02f, -1.54669667e-02f, -1.41213194e-01f, 3.19391936e-02f, 7.79892951e-02f, -1.49635449e-01f, 4.94451560e-02f, 5.65802678e-02f, 3.20653692e-02f, 4.13041301e-02f,
  -8.51441696e-02f, -1.23998448e-01f, -6.19170628e-02f, -8.56573358e-02f, -1.63987845e-01f, -8.19546655e-02f, -8.79506115e-03f, -1.07073188e-01f, -4.15547788e-02f, 3.49279493e-02f,
  7.16202036e-02f, 6.86259493e-02f, 3.46333310e-02f, 1.28474668e-01f, -6.70164824e-02f, -6.78191474e-03f, -2.23724376e-02f, 1.19726332e-02f, 2.48612631e-02f, -2.05258988e-02f,
  6.59082830e-01f, -1.35927737e-01f, 1.39129326e-01f, 4.70629744e-02f, -7.15225339e-02f, -1.34339228e-01f, 8.58374014e-02f, -1.13654546e-02f, 1.79967687e-01f, 7.91064948e-02f,
  -2.77184863e-02f, 9.27993432e-02f, -1.90632213e-02f, -1.26949849e-03f, -1.83792502e-01f, -1.16673775e-01f, 5.89109072e-03f, 3.99366580e-02f, 2.01525050e-03f, -2.20523164e-01f,
  -2.77044810e-02f, 1.18495449e-02f, 3.84363353e-01f, 1.52141467e-01f, 1.15112498e-01f, 1.03523411e-01f, 7.48129562e-02f, 8.05857852e-02f, 2.39380091e-01f, 3.46245974e-01f,
  -8.35265756e-01f, 1.22911401e-01f, 1.68593377e-01f, -2.25994945e-01f, -7.73071125e-02f, -2.04200998e-01f, -2.60679960e-01f, -2.52937287e-01f, -1.93604842e-01f, 1.58163831e-01f,
  1.79175630e-01f, -1.56602710e-02f, 5.12229018e-02f, -2.35871464e-01f, -4.06185746e-01f, -1.84544623e-01f, -1.55096069e-01f, -4.52257186e-01f, -6.40412211e-01f, -4.20351297e-01f,
  -3.18206251e-01f, -3.68456483e-01f, -5.21613717e-01f, -3.28147471e-01f, 2.11537391e-01f, 5.82024641e-02f, 1.38796940e-01f, -4.54597287e-02f, -8.31025653e-03f, 6.66383281e-02f,
  3.60190600e-01f, 1.65547475e-01f, 2.44436227e-02f, -2.17743337e-01f, 1.59844309e-01f, -9.11856294e-02f, 3.31080072e-02f, -1.29452031e-02f, 2.66308710e-02f, 1.15090162e-01f,
  1.04675908e-02f, -1.20914161e-01f, -9.65801626e-03f, 1.31221831e-01f, -2.20902488e-02f, -1.03789650e-01f, -7.57673522e-03f, 2.74200495e-02f, 1.52909145e-01f, 2.49680772e-01f,
  2.09589615e-01f, -2.42878962e-02f, 6.37077242e-02f, 1.12235427e-01f, 1.35156929e-01f, 3.61170582e-02f, 2.20406085e-01f, 2.40150049e-01f, 1.75334156e-01f, 1.57543987e-01f,
  -1.85313880e-01f, 1.10241205e-01f, -5.95613793e-02f, 5.51681891e-02f, -8.68418626e-03f, -1.76894814e-02f, 7.94786867e-03f, -5.05283810e-02f, -3.03096268e-02f, -1.76912583e-02f,
  9.66390222e-02f, 1.17966883e-01f, 4.85203601e-02f, -1.18856631e-01f, -3.13818501e-03f, -5.79828471e-02f, -4.46481183e-02f, -3.34947743e-02f, -2.63289455e-02f, 1.03582172e-02f,
  -9.18625519e-02f, 3.85139212e-02f, 2.56076157e-02f, -1.02138586e-01f, 6.24978505e-02f, -1.83945429e-02f, 4.70520444e-02f, 9.38175470e-02f, -2.89410260e-02f, 9.82180834e-02f,
  2.02501148e-01f, -1.28131509e-01f, -2.35261470e-02f, -1.14840329e-01f, 1.19487621e-01f, 1.19302511e-01f, 1.63661599e-01f, -6.86373003e-03f, 4.01347317e-02f, 8.20168406e-02f,
  -5.48279323e-02f, -1.27393216e-01f, 2.67303456e-02f, 1.50854588e-01f, -1.60413876e-01f, -5.16290665e-02f, -2.02148664e-03f, -6.11098632e-02f, -5.29927621e-03f, 9.62509736e-02f,
  4.37305532e-02f, -1.13615192e-01f, -1.66110337e-01f, 1.02257736e-01f, 1.30635342e-02f, -2.27286249e-01f, 1.00495338e-01f, 1.44278884e-01f, -1.24760821e-01f, -7.14675561e-02f,
  -2.62823194e-01f, -2.80731637e-02f, 1.34324087e-02f, 1.85684443e-01f, 1.70108512e-01f, 4.46491092e-02f, 1.14356659e-01f, 1.77528754e-01f, 1.03977211e-01f, 8.30342248e-02f,
  3.08635443e-01f, 3.81513655e-01f, 3.98966998e-01f, 2.21273750e-01f, 1.56930938e-01f, 9.21300650e-02f, 1.82400376e-01f, 1.01663463e-01f, 1.74604252e-01f, 1.21297330e-01f,
  2.14491189e-01f, 3.34552526e-02f, -9.67733935e-02f, 1.00472808e-01f, 5.17756213e-03f, 2.35385820e-01f, 1.72526419e-01f, 2.25445498e-02f, 7.74983093e-02f, 6.41780645e-02f,
  1.26846835e-01f, -2.32668564e-01f, 1.95143014e-01f, -8.90868250e-03f, -3.18338089e-02f, -1.86843413e-03f, 7.20911101e-02f, -7.71181583e-02f, -5.57722617e-03f, 1.01015307e-01f,
  -4.45951894e-02f, 1.15091279e-02f, -8.17447379e-02f, -9.29426923e-02f, -1.20890096e-01f, -8.88200253e-02f, -1.37270600e-01f, 4.75606397e-02f, 1.48906231e-01f, 1.13611691e-01f,
  5.11126406e-02f, -9.33737382e-02f, 3.60193178e-02f, 2.81508286e-02f, 4.46477346e-03f, 1.34808719e-01f, 1.44532872e-02f, 4.53381352e-02f, 3.06238569e-02f, 1.34809110e-02f,
  7.29551315e-02f, 1.32249996e-01f, -3.38109061e-02f, 3.84090729e-02f, 1.03482231e-01f, -4.08858201e-03f, 1.09275021e-01f, 2.24058237e-02f, 1.49234697e-01f, -4.68070693e-02f,
  8.61273035e-02f, 1.76380873e-01f, 1.31783053e-01f, 7.02054873e-02f, 2.05046341e-01f, 2.85020843e-02f, -6.31455556e-02f, 1.25239056e-03f, -9.44018215e-02f, -8.55820626e-02f,
  -1.03282325e-01f, 1.47488648e-02f, 1.25460746e-02f, -1.02109648e-01f, 4.10749810e-03f, 8.76676664e-02f, -4.85575646e-02f, 1.16053291e-01f, -2.29975823e-02f, -9.34797078e-02f,
  2.98859626e-01f, 7.04675913e-02f, -8.31509456e-02f, -1.81152642e-01f, -2.05223888e-01f, -1.49261594e-01f, 6.09110147e-02f, -1.41103148e-01f, -9.37941298e-02f, 3.16700749e-02f,
  -7.01220632e-02f, -1.37636781e-01f, -1.14764161e-01f, -3.29379216e-02f, 3.49776749e-03f, -9.51235071e-02f, -1.25633806e-01f, 4.08444367e-02f, 1.20411934e-02f, -1.12224519e-01f,
  -7.39720091e-02f, 4.28717695e-02f, 2.11330116e-01f, 1.99754745e-01f, 1.35446832e-01f, 6.81563392e-02f, 9.56744105e-02f, -5.78681789e-02f, 4.86180186e-03f, -2.83161048e-02f,
  1.63208485e-01f, -6.03055716e-01f, 1.99351296e-01f, -1.17355533e-01f, -4.14678812e-01f, -3.49663854e-01f, -3.93784165e-01f, -1.28515288e-01f, -1.13723770e-01f, -4.64647830e-01f,
  -3.29524666e-01f, 1.67640179e-01f, 7.77332708e-02f, 1.59666479e-01f, 3.69962960e-01f, -2.29970649e-01f, -6.44548144e-03f, 6.26711190e-01f, 6.70836747e-01f, 5.78895770e-02f,
  -1.84981763e-01f, 3.20020497e-01f, 6.70760214e-01f, 3.67517531e-01f, -2.15536490e-01f, 9.56317633e-02f, -7.76705565e-03f, 2.84167901e-02f, -1.16917588e-01f, -8.73339251e-02f,
  -4.15185839e-01f, -2.73265094e-01f, 9.14175436e-02f, 3.67752872e-02f, 5.53466678e-02f, 1.79175556e-01f, -9.79554281e-02f, 4.82801422e-02f, 5.15001267e-02f, -1.09712973e-01f,
  -6.37007728e-02f, 6.82308674e-02f, 3.84561382e-02f, 8.78257230e-02f, -1.60149410e-01f, 8.95454958e-02f, 2.48015955e-01f, 2.95567602e-01f, 2.52823472e-01f, -9.50288028e-02f,
  -2.60159880e-01f, -2.14411601e-01f, -2.87543591e-02f, -9.72618535e-02f, -1.47563130e-01f, 1.06908120e-01f, -5.54035306e-02f, -3.14801000e-02f, 1.49572656e-01f, -2.23861799e-01f,
  -1.03059389e-01f, 5.94972968e-02f, 5.00230156e-02f, -4.14424483e-03f, -1.01039745e-02f, 3.33049558e-02f, 1.23539001e-01f, -5.35725728e-02f, 3.32161225e-02f, -8.23404640e-03f,
  7.84317553e-02f, -1.02990083e-01f, 9.76170748e-02f, -2.90519856e-02f, -1.73208751e-02f, -9.81732504e-04f, -3.57896015e-02f, 5.07028326e-02f, -1.65898737e-03f, 6.07286431e-02f,
  9.65086818e-02f, 3.20025273e-02f, -6.50047809e-02f, 1.28585026e-01f, -4.22847234e-02f, 1.26198187e-01f, -4.82414588e-02f, 2.71673687e-02f, -1.01054870e-01f, -4.53391718e-03f,
  -1.32241651e-01f, 2.50210941e-01f, -3.42848748e-01f, 6.12182915e-02f, -4.00830060e-02f, -7.21755400e-02f, -1.50595412e-01f, 8.67435336e-02f, -1.29281536e-01f, -2.00801283e-01f,
  -1.76482633e-01f, -1.39422640e-01f, -1.64551601e-01f, 3.20849493e-02f, 1.15026701e-02f, -1.14665300e-01f, -2.30888098e-01f, -3.75058390e-02f, 4.65033725e-02f, -1.41248718e-01f,
  1.30899101e-01f, -3.57933305e-02f, -1.48196444e-01f, -1.34167805e-01f, -2.93946832e-01f, 1.63443908e-02f, -1.07040316e-01f, -1.08570352e-01f, 3.12012210e-02f, -3.07676464e-01f,
  5.80539703e-01f, -1.12096546e-02f, 3.34554851e-01f, 1.29973635e-01f, 1.91389978e-01f, 3.11703622e-01f, 4.06345785e-01f, 1.27043322e-01f, -2.61182827e-03f, 1.26640186e-01f,
  -2.33506411e-01f, -5.72683096e-01f, -4.38640803e-01f, -4.00194764e-01f, -1.15434982e-01f, 1.28743380e-01f, 1.52080640e-01f, 1.27657071e-01f, 1.83243409e-03f, 2.01483503e-01f,
  -6.50676340e-02f, 3.82152289e-01f, 2.58884192e-01f, -2.96861678e-02f, 6.17940798e-02f, -1.07183784e-01f, 1.47345871e-01f, 2.08642781e-01f, -8.59832168e-02f, -9.51913148e-02f,
  2.55381107e-01f, 3.93313259e-01f, -3.06141675e-01f, -3.15388203e-01f, 1.82088092e-02f, -1.78354695e-01f, -1.04666045e-02f, 1.36783039e-02f, -8.59628916e-02f, 2.07760539e-02f,
  -8.95245075e-02f, -1.15506135e-01f, -8.95766914e-02f, -3.37923802e-02f, 2.79520869e-01f, 9.80483070e-02f, 2.89928354e-02f, -3.69216390e-02f, 3.75562608e-02f, 4.78837304e-02f,
  -2.69785076e-01f, 1.15458228e-01f, 3.09404582e-01f, 1.77800993e-03f, -3.35936807e-02f, -8.39832574e-02f, 7.91257173e-02f, 6.89427480e-02f, -1.16234059e-02f, -3.86807211e-02f,
  -1.39667928e-01f, -1.45997191e-02f, 1.03103682e-01f, 2.09282022e-02f, 9.08450633e-02f, 7.78604764e-03f, 5.97958677e-02f, 3.30362618e-02f, 2.04061083e-02f, 1.11193202e-01f,
  -6.34193197e-02f, -8.59243446e-04f, -6.60976395e-02f, -1.84589997e-02f, -1.13407224e-01f, 8.48426446e-02f, -7.42185954e-03f, -1.64422497e-01f, 6.14958592e-02f, 1.56732559e-01f,
  -2.23588869e-02f, -1.33996261e-02f, 6.87756538e-02f, 5.66175468e-02f, -1.22102182e-02f, -1.35561615e-01f, -7.87181109e-02f, -7.10143521e-02f, 2.00830605e-02f, 9.30176489e-03f,
  4.38642725e-02f, -1.32409796e-01f, -7.03073218e-02f, -2.83078045e-01f, 1.04205906e-01f, -1.85161158e-01f, -4.34401184e-02f, -1.44166410e-01f, -7.80854449e-02f, -1.48391083e-01f,
  -4.25817594e-02f, -1.71237543e-01f, 9.22110770e-03f, 3.11217085e-02f, -3.11963465e-02f, -4.56905998e-02f, -1.41417846e-01f, -1.14607811e-02f, -1.50076538e-01f, 2.82319356e-02f,
  -1.55021101e-01f, 1.27392367e-01f, 1.71230718e-01f, -6.88783824e-02f, -1.45077482e-01f, -9.13282558e-02f, 1.60035789e-01f, -8.79876129e-03f, 1.53541148e-01f, 2.76311725e-01f,
  9.09056962e-02f, 3.31182331e-01f, -8.66857320e-02f, 2.14532763e-01f, 2.04584524e-01f, -4.62973490e-03f, -1.42059505e-01f, -8.85979310e-02f, 1.70820236e-01f, 1.89753771e-01f,
  2.97799230e-01f, 2.54542202e-01f, 1.95901647e-01f, -2.48305239e-02f, -1.88904315e-01f, -6.86970130e-02f, -1.52685806e-01f, -2.51204312e-01f, -1.53086960e-01f, -1.32370889e-01f,
  2.35451590e-02f, 8.67354590e-03f, 4.95846644e-02f, -9.17595625e-02f, 1.76793367e-01f, 1.43726841e-01f, -6.10978715e-03f, 5.23679070e-02f, 1.42931668e-02f, 6.06352799e-02f,
  -1.36961220e-02f, -1.32895708e-01f, 1.32372156e-01f, 8.97276476e-02f, 1.08675674e-01f, 1.33203849e-01f, 3.92772481e-02f, 2.01503094e-02f, 2.40248099e-01f, -7.46378442e-04f,
  6.36638999e-02f, -1.23499194e-03f, -8.90706554e-02f, -2.56378041e-03f, 8.84272233e-02f, -1.94307175e-02f, 3.54971588e-02f, -2.46730875e-02f, -6.07601926e-02f, 4.67960956e-04f,
  -3.64208035e-02f, 1.07280321e-01f, 5.09740412e-03f, -4.64186408e-02f, -2.72228450e-01f, 7.54727125e-02f, -2.89911870e-02f, -1.15091100e-01f, -9.60083455e-02f, -1.20907933e-01f,
  -4.17266600e-02f, 2.32767444e-02f, -1.02365240e-02f, 1.25476360e-01f, 3.88310924e-02f, 2.05627140e-02f, 2.70602643e-03f, -1.28202941e-02f, -1.05508342e-01f, 3.48291397e-02f,
  1.76442042e-01f, 2.41400637e-02f, -2.92095523e-02f, 5.73348328e-02f, 4.67571877e-02f, 3.73699628e-02f, -4.95885871e-02f, 2.42019054e-02f, -1.10876985e-01f, 1.15056820e-01f,
  3.57471257e-02f, -2.54941117e-02f, 1.57927841e-01f, -5.20464443e-02f, 3.38815674e-02f, 1.96864214e-02f, -9.73465145e-02f, 6.79514483e-02f, -6.51338547e-02f, 1.03976503e-01f,
  3.96620661e-01f, -3.03155273e-01f, 9.71417576e-02f, -2.27056518e-01f, -3.97030525e-02f, -6.97988132e-03f, -6.93946257e-02f, -3.94864790e-02f, 1.20724648e-01f, 3.47040743e-02f,
  5.59889674e-02f, -1.02180175e-01f, 4.85103540e-02f, -1.86817888e-02f, 2.54094731e-02f, 5.93127012e-02f, 9.01288539e-02f, 5.30512184e-02f, -5.92754297e-02f, -2.76712282e-03f,
  4.32895124e-02f, 6.82506114e-02f, 8.12691450e-02f, -2.87128799e-02f, -4.04533707e-02f, 1.47528172e-01f, 8.33539069e-02f, 5.17635792e-02f, -8.82822671e-04f, 1.70577213e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.63194138e-01f, 1.92519173e-01f, 2.29049683e-01f, 2.77553797e-01f, 1.70226991e-01f, 4.69282746e-01f, 4.03544933e-01f, 1.13393553e-01f, 2.46710122e-01f, 8.32883894e-01f,
  3.71388942e-01f, 5.33705294e-01f, 3.58500868e-01f, 3.13468575e-01f, -2.06579175e-02f, 3.15136015e-01f, 4.64387655e-01f, 1.97303906e-01f, 1.85779959e-01f, 3.76115590e-01f,
  3.69486839e-01f, 1.33097425e-01f, 1.41108334e-01f, 3.59772712e-01f, 7.16995299e-01f, 4.03039753e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.21436147e-02f, 8.27012509e-02f, -1.28089553e-02f, 7.83915818e-02f, -4.34757769e-02f, 2.72195667e-01f, 1.42311141e-01f, -5.52112684e-02f, -7.29196370e-02f, 8.14929157e-02f,
  9.26258136e-03f, -2.27444306e-01f, -1.15490697e-01f, -1.54887572e-01f, -9.52766016e-02f, 1.57890730e-02f, 2.76740547e-02f, -5.91688342e-02f, -1.35417372e-01f, -3.72408479e-02f,
  -7.87635520e-02f, 1.58153474e-01f, -4.07217108e-02f, -1.20592266e-02f, -3.83502752e-01f, -1.66821569e-01f, 1.51443288e-01f, 4.35578823e-02f, 3.20120938e-02f, -4.55689579e-02f,
  4.05147895e-02f, 7.28906924e-03f, 2.06814811e-01f, -1.74278580e-02f, -5.81304878e-02f, -2.20803749e-02f, 1.05186544e-01f, -7.46450201e-02f, -1.15449071e-01f, -7.36765265e-02f,
  -1.84737761e-02f, -2.73640811e-01f, 1.00358613e-01f, 2.74743363e-02f, 2.12749422e-01f, 5.26244380e-02f, -7.62864128e-02f, -8.11506063e-02f, -2.71970611e-02f, 7.05137383e-03f,
  9.25967321e-02f, 1.86315835e-01f, -2.13822559e-01f, 4.10799146e-01f, -9.49943140e-02f, -6.15656525e-02f, -9.38896164e-02f, -6.77364171e-02f, -2.44614020e-01f, 1.36691570e-01f,
  -1.92683622e-01f, 1.96311802e-01f, 1.40298739e-01f, -1.94832876e-01f, -2.40750108e-02f, -1.10360228e-01f, -1.26300350e-01f, -9.62833874e-03f, -1.44126723e-02f, -8.56404752e-02f,
  -3.24439518e-02f, -9.87502038e-02f, 4.35038097e-02f, 2.71011256e-02f, -3.11498735e-02f, -1.23241907e-02f, -2.23697163e-02f, -9.62359309e-02f, 2.26420965e-02f, 1.59477368e-01f,
  -4.53751720e-02f, 1.16090976e-01f, -2.75581274e-02f, 9.10035521e-02f, -1.12281302e-02f, 5.93694975e-04f, 2.15204824e-02f, -3.69312875e-02f, -4.32964787e-03f, -5.74732237e-02f,
  3.95859359e-03f, 5.70055246e-02f, -6.03767205e-03f, -3.39467935e-02f, -1.90610617e-01f, -3.36686671e-02f, 1.29925177e-01f, -1.88406795e-01f, -1.85765903e-02f, 8.85732763e-04f,
  1.13345899e-01f, -1.02725178e-02f, 2.02839553e-01f, 1.86477244e-01f, -1.88371295e-03f, -1.23819254e-01f, -1.49049088e-01f, 1.66932773e-02f, -1.66641250e-01f, -1.33456498e-01f,
  -9.48650613e-02f, 4.25909728e-01f, -2.94497516e-02f, -2.57120371e-01f, 4.55954015e-01f, 1.35194018e-01f, -1.01407208e-01f, 6.75779879e-02f, -2.82521158e-01f, -3.09494454e-02f,
  1.30228177e-01f, -1.86181009e-01f, -2.73727383e-02f, -7.75866657e-02f, 9.49765556e-03f, -3.72618109e-01f, 3.91935669e-02f, -1.95319355e-02f, 1.86636131e-02f, 1.27001271e-01f,
  -1.73873276e-01f, 1.15742765e-01f, 7.03039169e-02f, -2.78008670e-01f, -1.54753610e-01f, -2.57167011e-01f, 4.48562019e-02f, -1.63811352e-02f, 1.63770407e-01f, -8.31682980e-02f,
  -4.88650464e-02f, 1.47397429e-01f, 2.44561564e-02f, 6.55881837e-02f, 4.45823185e-02f, 7.07389638e-02f, 8.23919922e-02f, -1.19815305e-01f, 4.51746071e-03f, -1.24493815e-01f,
  -1.64164200e-01f, 8.12346414e-02f, 2.18955934e-01f, 1.18024342e-01f, -2.58677363e-01f, -1.97382420e-01f, 4.83171307e-02f, 7.97005091e-03f, 1.18222959e-01f, 8.52822065e-02f,
  -1.23593479e-01f, 5.81583679e-02f, 3.87146659e-02f, -2.09684506e-01f, -1.02467172e-01f, 1.16411678e-01f, 5.21697290e-02f, 3.48627836e-01f, -2.73564570e-02f, 8.17825794e-02f,
  7.87825659e-02f, 2.50882041e-02f, 5.21356128e-02f, -2.98398547e-02f, 1.11244008e-01f, -1.32774964e-01f, -2.16122091e-01f, -8.53383988e-02f, -1.09240882e-01f, -7.54435137e-02f,
  -7.27939419e-03f, -3.64851147e-01f, 1.92226887e-01f, -8.57347474e-02f, -1.52208820e-01f, -2.67156772e-03f, 2.45846882e-01f, -2.20572829e-01f, 2.47232020e-02f, 2.78307468e-01f,
  -1.27306702e-02f, 1.43152745e-02f, -2.03168932e-02f, 3.65097374e-02f, 9.84360948e-02f, -8.43722373e-02f, -2.45922767e-02f, 2.72105932e-02f, 8.05867370e-03f, 2.20809445e-01f,
  -1.67726576e-02f, -7.51015246e-02f, -1.12713195e-01f, 7.97851756e-02f, 7.93107226e-02f, 1.52661264e-01f, 1.01043351e-01f, 3.91059034e-02f, -8.35470706e-02f, 5.34505099e-02f,
  -3.64810750e-02f, 1.29717097e-01f, -7.94939771e-02f, 9.06895325e-02f, -1.24709085e-02f, -8.43838900e-02f, -1.51638225e-01f, 5.50150499e-02f, 3.10080405e-02f, 1.04453348e-01f,
  9.40734819e-02f, 1.14628248e-01f, -1.18292660e-01f, -4.24379148e-02f, 3.15388665e-02f, -1.90901890e-01f, 8.46507102e-02f, -9.03894939e-03f, 5.21076843e-03f, -4.90743071e-02f,
  7.41000995e-02f, -3.53306860e-01f, 7.30368644e-02f, -9.49534997e-02f, 1.29024237e-01f, -1.65600002e-01f, -6.05255291e-02f, -9.21690017e-02f, -1.15245748e-02f, 3.73682469e-01f,
  -1.91074342e-01f, 2.18467742e-01f, -1.52272955e-01f, -7.25836214e-03f, 1.90062106e-01f, -2.66939234e-02f, 2.08614543e-01f, -6.63856324e-03f, 5.11976928e-02f, 9.74671021e-02f,
  4.13861535e-02f, -1.03571996e-01f, -1.00857504e-02f, 2.68287301e-01f, 4.34883893e-01f, -6.98554283e-03f, -1.44130066e-02f, 8.04062486e-02f, -1.41585335e-01f, 5.95760942e-02f,
  1.37871718e-02f, -6.63937256e-02f, -1.51465414e-02f, -1.12182312e-01f, -3.41222174e-02f, 6.09581247e-02f, -1.39415953e-02f, -4.92809601e-02f, -1.23811543e-01f, -3.68691562e-03f,
  5.67376465e-02f, 1.52716294e-01f, -1.71034634e-01f, -5.99073060e-02f, 3.76540683e-02f, -5.59638813e-02f, -5.97522706e-02f, 1.06096387e-01f, -2.91032251e-02f, 2.37754300e-01f,
  -4.26999144e-02f, 1.99352682e-01f, -2.39135907e-03f, 1.13922738e-01f, 4.17684857e-03f, -1.91055592e-02f, -2.80836165e-01f, 1.32998586e-01f, -2.51037061e-01f, 1.50098965e-01f,
  2.33241588e-01f, 9.16710570e-02f, 4.49695811e-02f, 1.42517686e-01f, -7.23572623e-04f, 1.80708900e-01f, 1.45171374e-01f, 2.12776542e-01f, -1.70671403e-01f, -2.84740180e-01f,
  1.04843095e-01f, 2.01268956e-01f, -2.98388302e-02f, -2.28451654e-01f, 1.41857281e-01f, -1.76991597e-01f, -2.90038763e-03f, 2.34832868e-01f, -1.11718722e-01f, -5.83665958e-03f,
  -4.66751456e-01f, 6.48571104e-02f, 8.04802179e-02f, -1.45370781e-01f, -1.20910397e-02f, -1.27386600e-01f, -1.25558063e-01f, 3.89822811e-01f, 2.34889597e-01f, -1.36936486e-01f,
  6.22213297e-02f, 8.61551017e-02f, -1.00185916e-01f, 7.67756021e-03f, 1.32768318e-01f, -1.23115025e-01f, -8.96952003e-02f, 6.73994571e-02f, -2.62447447e-02f, 9.77171212e-02f,
  -1.04833052e-04f, 1.07918926e-01f, 4.03886475e-02f, 4.61520255e-02f, -4.44819294e-02f, -7.63970241e-02f, -8.06847811e-02f, -1.03056088e-01f, 2.13765912e-02f, 2.10051462e-02f,
  -2.51102775e-01f, 2.39219447e-03f, -1.24475345e-01f, 1.84156522e-01f, -4.25459407e-02f, 4.30286415e-02f, 9.12830308e-02f, -5.99654317e-02f, -8.23656991e-02f, -1.26928821e-01f,
  -1.72491536e-01f, -7.98026323e-02f, -1.21674366e-01f, 2.13291630e-01f, -9.57341343e-02f, -2.04412732e-02f, 2.48444732e-04f, -8.95466469e-03f, 1.06172888e-02f, 7.79334307e-02f,
  3.71412411e-02f, 1.97525993e-01f, 6.06936365e-02f, -1.36638567e-01f, 2.79451609e-01f, 2.60306895e-01f, 1.16325147e-01f, -4.37410533e-01f, 1.23781614e-01f, -1.84526056e-01f,
  -1.25547424e-01f, 2.61715621e-01f, 5.06808385e-02f, -2.42069185e-01f, -9.31844488e-02f, -2.19120346e-02f, -1.01216003e-01f, 3.20027143e-01f, -9.26810130e-03f, 8.60131308e-02f,
  -1.09160580e-01f, -1.73392102e-01f, 4.66452353e-02f, 4.83308695e-02f, -1.40434355e-01f, -5.47791235e-02f, -6.13320880e-02f, -1.21884055e-01f, 1.66952368e-02f, -1.37104928e-01f,
  7.21929669e-02f, 6.97716922e-02f, 7.58231729e-02f, -1.04666106e-01f, -1.08484335e-01f, -2.93854531e-02f, -3.52012627e-02f, -1.97645754e-01f, -2.31971413e-01f, -1.76203594e-01f,
  -6.84274808e-02f, -1.36838049e-01f, -6.53460473e-02f, 3.76035459e-02f, -2.72549540e-01f, 2.27901071e-01f, 2.24095732e-01f, -7.31317401e-02f, -1.15634345e-01f, -2.40091130e-01f,
  6.26994893e-02f, 1.47053406e-01f, 1.11779578e-01f, -8.35680217e-02f, -3.12899286e-03f, -2.38887146e-02f, -2.23088503e-01f, 9.51430723e-02f, 6.85693920e-02f, -6.27616569e-02f,
  -1.52628511e-01f, -1.53224736e-01f, 5.55012375e-02f, -1.17849767e-01f, 1.48276255e-01f, -2.09933281e-01f, 2.35727742e-01f, -1.54958203e-01f, -6.82514831e-02f, -1.56146914e-01f,
  -9.97445136e-02f, -2.41660867e-02f, 1.21500008e-01f, 1.99661702e-01f, -1.89331442e-01f, -1.77187309e-01f, 1.46137968e-01f, 1.89325839e-01f, -5.80866635e-03f, 1.51760712e-01f,
  4.36443798e-02f, 2.24952817e-01f, -2.55994558e-01f, 1.22221760e-01f, -1.27173826e-01f, 2.15211228e-01f, -3.20512533e-01f, -1.42044023e-01f, 6.76740855e-02f, 5.01141418e-03f,
  3.06420140e-02f, 3.38907391e-02f, -4.88681793e-02f, 1.10809267e-01f, -5.04338108e-02f, -1.23357199e-01f, 7.82835111e-03f, -5.33792116e-02f, 9.50677842e-02f, -4.53404598e-02f,
  -1.81218520e-01f, 7.43073672e-02f, 9.65651497e-02f, 1.10453084e-01f, -1.72243267e-01f, 2.21080314e-02f, -3.29178534e-02f, -7.22884834e-02f, 1.00380488e-01f, -2.68364996e-01f,
  -2.13451102e-01f, 1.72813028e-01f, 1.25173360e-01f, 7.19240308e-02f, -1.62351176e-01f, 4.54057679e-02f, -1.80053040e-02f, 1.25123501e-01f, 2.52342802e-02f, 8.81788358e-02f,
  6.33472903e-03f, -1.28848210e-01f, 1.36036888e-01f, 9.89597738e-02f, 5.82898743e-02f, 9.56618860e-02f, 2.00750474e-02f, 2.55652755e-01f, -1.78381987e-02f, 1.75545305e-01f,
  2.38703899e-02f, -2.53153831e-01f, 1.61959201e-01f, -3.38182002e-02f, 8.57753493e-03f, -1.90530807e-01f, 2.35194098e-02f, -9.08879489e-02f, 1.21957120e-02f, 7.35237598e-02f,
  -3.64256948e-02f, -4.15375441e-01f, -9.85070691e-02f, 1.34720042e-01f, 4.25042957e-02f, -8.08845367e-03f, 1.72210053e-01f, -1.95316046e-01f, 1.26343787e-01f, 2.86363810e-01f,
  1.79050639e-01f, 9.32186693e-02f, -9.39984247e-02f, -1.21081434e-01f, 1.11490814e-02f, -3.13881552e-03f, 8.14823806e-02f, -2.29566339e-02f, 5.50126769e-02f, 1.53564155e-01f,
  -1.45996824e-01f, -1.78507850e-01f, 3.27539742e-02f, 9.40478072e-02f, -1.02130346e-01f, 1.35013223e-01f, -1.43803535e-02f, 6.69064298e-02f, -1.34162724e-01f, 7.19658807e-02f,
  7.56940022e-02f, 1.92126054e-02f, -5.92116304e-02f, -1.23631895e-01f, -2.61036932e-01f, -3.95342261e-02f, 6.94858953e-02f, 2.37637267e-01f, 3.58692929e-02f, -8.75736028e-02f,
  -6.84187841e-03f, -2.15625182e-01f, 6.03976361e-02f, -9.09957662e-02f, -1.46003678e-01f, 2.20237076e-02f, -1.88709497e-01f, 9.84932184e-02f, 6.35924488e-02f, 6.14281967e-02f,
  1.66858867e-01f, -7.94609189e-02f, 1.18280172e-01f, 2.93035805e-01f, 1.35233372e-01f, -1.73724517e-02f, 1.46130240e-02f, 1.68857485e-01f, 8.84529352e-02f, -3.69138807e-01f,
  -2.54879802e-01f, -2.19240814e-01f, -1.47989646e-01f, 2.09664643e-01f, -7.66910166e-02f, -3.11071068e-01f, 1.83786824e-01f, 2.74932347e-02f, -1.10510528e-01f, 1.32438123e-01f,
  4.46629077e-02f, -9.36012268e-02f, -9.47393328e-02f, -3.52451861e-01f, 3.55336070e-01f, 2.61030793e-01f, 1.00104198e-01f, 1.55402049e-01f, 7.56235123e-02f, 1.52662629e-02f,
  -1.39133185e-01f, 1.04713209e-01f, 9.40696374e-02f, 2.31161714e-01f, -4.37568538e-02f, 1.26952175e-02f, -4.63923216e-02f, 4.00981829e-02f, 1.33869022e-01f, 1.04566313e-01f,
  -1.74627788e-02f, -1.86615214e-01f, 2.63196472e-02f, 4.90909442e-02f, 2.42533861e-03f, 4.69544046e-02f, -1.91306248e-01f, 1.63162678e-01f, -1.80579007e-01f, 6.11513108e-02f,
  -9.48713869e-02f, 7.58044273e-02f, 2.84805715e-01f, -6.09100387e-02f, 7.23579004e-02f, -3.40329073e-02f, -3.87112126e-02f, -3.62513661e-02f, -4.72741798e-02f, 1.74791336e-01f,
  2.99313068e-01f, -1.18735202e-01f, -1.87608927e-01f, 3.38462554e-02f, -5.72650619e-02f, -1.63724065e-01f, 8.91485885e-02f, -1.12578288e-01f, 3.03129613e-01f, -1.19707249e-01f,
  4.57236171e-02f, 1.36936530e-01f, 1.61779612e-01f, -3.28139931e-01f, 5.76244444e-02f, 1.10340275e-01f, -2.53893763e-01f, -9.19411983e-03f, 1.21397391e-01f, -2.89994329e-02f,
  -6.58776537e-02f, 4.52612340e-02f, -1.12761453e-01f, 7.07174912e-02f, -5.46093425e-03f, 4.93562743e-02f, -1.40839875e-01f, 2.77850509e-01f, 1.37292057e-01f, 1.17295861e-01f,
  7.82310218e-02f, -5.66833243e-02f, 1.32315710e-01f, 8.42893273e-02f, 9.01437327e-02f, 7.14754015e-02f, 1.13136701e-01f, -8.37818235e-02f, -3.25755402e-02f, -4.17517349e-02f,
  -9.10589471e-02f, 4.39322134e-03f, 6.57178611e-02f, -1.21407598e-01f, 1.97180975e-02f, -7.90938884e-02f, 2.91394796e-02f, -9.07619819e-02f, 1.24658190e-01f, 1.39822513e-01f,
  3.80101055e-02f, -4.23846627e-03f, 1.52880279e-02f, -6.81673288e-02f, -1.08010508e-01f, 1.54891852e-02f, 9.13783833e-02f, -3.92006747e-02f, 3.28804366e-02f, 5.67174181e-02f,
  -1.69408783e-01f, -1.07484713e-01f, 3.45317088e-02f, 3.56001370e-02f, 1.17187880e-01f, -1.91637814e-01f, -1.01152301e-01f, -8.28439295e-02f, -1.47274852e-01f, -2.09963486e-01f,
  2.12343521e-02f, -2.29244575e-01f, 9.83886421e-02f, -8.74184594e-02f, 2.55915135e-01f, 2.87277568e-02f, -9.89345312e-02f, -3.20301294e-01f, 2.15917870e-01f, 9.00308713e-02f,
  -1.87138692e-01f, 2.39343360e-01f, -2.03789063e-02f, 2.71605372e-01f, -2.16708228e-01f, 1.90797731e-01f, -1.38411736e-02f, -1.24511160e-01f, -6.73107058e-02f, -4.07006554e-02f,
  -2.35553697e-01f, 8.83361604e-03f, 1.83879182e-01f, -9.50522423e-02f, 1.02149889e-01f, 3.42758819e-02f, -4.20284690e-03f, 6.51030429e-03f, 1.56500358e-02f, 5.69412112e-02f,
  1.33355513e-01f, 1.53387919e-01f, -6.56159781e-03f, 7.02537894e-02f, -6.79396912e-02f, 3.20553422e-01f, 1.10132461e-02f, 8.24082121e-02f, -4.53032134e-03f, -2.81338254e-03f,
  4.13625836e-02f, 5.77725098e-02f, -8.17656741e-02f, 7.73549527e-02f, 1.77776113e-01f, -1.27224132e-01f, 6.61336109e-02f, -1.09542377e-01f, -2.24590413e-02f, -6.24998808e-02f,
  1.36255160e-01f, -3.28134559e-02f, -1.38643291e-02f, -2.16956183e-01f, 2.02054590e-01f, -1.67837620e-01f, -1.45916687e-03f, 2.28851557e-01f, 2.65203267e-01f, -1.19726509e-01f,
  -2.62326717e-01f, 8.51103812e-02f, 1.98241416e-02f, 2.22800300e-02f, -8.17427188e-02f, -9.26812887e-02f, 1.49808899e-01f, 6.00639880e-02f, 2.28457168e-01f, -3.75669077e-02f,
  2.49231737e-02f, -2.71564215e-01f, 1.00814678e-01f, 8.09591338e-02f, -1.07661560e-01f, 4.56619449e-03f, 9.07371491e-02f, -2.80981034e-01f, 1.88268080e-01f, -8.47592130e-02f,
  4.91984338e-02f, 1.25751078e-01f, 1.66459337e-01f, 6.27193302e-02f, 2.08937880e-02f, -4.02478993e-01f, -4.87432778e-02f, 2.11460918e-01f, 1.46929324e-01f, -3.96036953e-02f,
  8.11228976e-02f, 4.93949652e-02f, -7.23221228e-02f, -8.93484429e-02f, -1.04604788e-01f, 1.67968825e-01f, -4.14836481e-02f, -1.09678373e-01f, -1.11804567e-01f, 2.12388620e-01f,
  1.57023013e-01f, 3.42166936e-03f, 2.90448926e-02f, 8.71522427e-02f, -1.58967320e-02f, -7.50964601e-03f, 6.62077069e-02f, 1.00013912e-01f, -8.86868760e-02f, 6.65814290e-03f,
  -1.27416641e-01f, -1.03223071e-01f, 1.10376040e-02f, 7.59786321e-03f, 1.01707950e-01f, -4.31647003e-02f, -1.39712811e-01f, -1.48789182e-01f, 1.53692365e-01f, -1.71252310e-01f,
  -3.91439628e-03f, 2.38516510e-01f, -6.23651519e-02f, -7.42139816e-02f, -1.00937434e-01f, -6.72352267e-04f, 1.68240696e-01f, -1.85872719e-01f, 1.63453564e-01f, 6.59109503e-02f,
  -1.93044860e-02f, -4.90520447e-02f, 1.48637474e-01f, 5.91075886e-03f, -2.00939119e-01f, -3.42760026e-01f, 5.08530624e-02f, -3.65774751e-01f, -2.40011856e-01f, 1.10144950e-01f,
  5.75889647e-02f, -3.64719555e-02f, 2.43195459e-01f, 8.07289183e-02f, 8.61321613e-02f, 1.11142069e-01f, 8.24590698e-02f, -7.95820132e-02f, 7.78758377e-02f, -4.57300931e-01f,
  2.98091739e-01f, 1.20927796e-01f, -1.60483733e-01f, -1.83651030e-01f, -1.32199377e-01f, -3.92746180e-03f, 8.59742537e-02f, -3.08610611e-02f, -5.90079576e-02f, 3.78989205e-02f,
  -1.07995227e-01f, 6.09506504e-04f, 1.62426785e-01f, 3.27257290e-02f, 4.20230441e-02f, -1.23496875e-01f, -1.18159726e-02f, 9.13860127e-02f, 8.11616108e-02f, -1.68561578e-01f,
  5.26439697e-02f, -6.91867098e-02f, -2.84974426e-02f, -2.17868760e-01f, -2.14373827e-01f, -9.71323773e-02f, -1.15326913e-02f, 2.91360216e-03f, -6.26474172e-02f, -1.24706537e-01f,
  -7.68521652e-02f, 4.51920778e-02f, 2.82685548e-01f, -9.82763097e-02f, -6.23656921e-02f, -1.39961347e-01f, 1.75530389e-01f, 1.71646550e-01f, -6.94096014e-02f, 1.04874186e-01f,
  -6.23001345e-02f, 2.75916934e-01f, -1.01087485e-02f, 2.07510777e-02f, 8.22289288e-02f, -1.60590425e-01f, 4.11530696e-02f, -5.02148420e-02f, 1.17380969e-01f, 9.80252177e-02f,
  -8.96102339e-02f, -1.48109153e-01f, -1.23370305e-01f, -1.48335621e-01f, 1.23773687e-01f, -4.07596737e-01f, 2.90023088e-01f, 1.63741902e-01f, 2.42605116e-02f, 3.08191180e-01f,
  8.99851099e-02f, -2.50477463e-01f, 2.95621231e-02f, -2.00652614e-01f, -1.17496409e-01f, 2.25045055e-01f, -9.66899022e-02f, -3.32347117e-02f, -3.97024490e-02f, -6.35191351e-02f,
  7.37384483e-02f, 3.80504839e-02f, -7.26415142e-02f, 1.41481861e-01f, 8.30066279e-02f, 4.39759158e-02f, -2.56016944e-02f, -4.66841273e-02f, -8.69029667e-03f, 2.25312766e-02f,
  9.07685384e-02f, 3.54707092e-02f, 6.37367740e-03f, 4.34730388e-02f, -7.32200667e-02f, -1.69848301e-03f, 1.40512791e-02f, 4.43643034e-02f, -2.33537536e-02f, 1.63639098e-01f,
  8.39302912e-02f, 1.05908222e-01f, -9.58465934e-02f, 3.55518535e-02f, -6.35307282e-02f, 1.01952806e-01f, -1.22905537e-01f, 9.50674787e-02f, -1.15869969e-01f, -8.79855677e-02f,
  1.56240016e-01f, -2.64795013e-02f, 2.27239840e-02f, -5.49957491e-02f, -1.85517207e-01f, 1.80780277e-01f, -7.78041896e-04f, -1.50290698e-01f, -9.18386951e-02f, 1.41416878e-01f,
  -1.56123921e-01f, -7.58889616e-02f, 1.64508671e-02f, 3.58653158e-01f, 2.88602412e-02f, -9.73134711e-02f, -1.09462487e-02f, -9.52233523e-02f, -1.02492340e-01f, 2.47026071e-01f,
  -2.03905091e-01f, -8.05754513e-02f, -3.18535119e-02f, -1.87282920e-01f, -2.81736776e-02f, -9.56944376e-02f, -8.88967514e-02f, 3.49466085e-01f, 5.63921221e-02f, -1.13198094e-01f,
  9.82206911e-02f, 3.03699803e-02f, 1.09745875e-01f, -9.76651236e-02f, -4.69232537e-02f, 7.10607693e-02f, -5.90247922e-02f, 1.12734539e-02f, -9.13253054e-02f, 3.72461267e-02f,
  2.67489851e-02f, 7.69276023e-02f, 1.42297387e-01f, -2.86100403e-04f, -1.29005248e-02f, 8.39890689e-02f, 4.99127917e-02f, -7.44076148e-02f, 2.35500070e-03f, 3.41016576e-02f,
  3.45737003e-02f, -8.31667483e-02f, -1.89107787e-02f, -4.21952493e-02f, -1.48526172e-03f, 1.92784816e-01f, -9.81027260e-02f, -4.92290892e-02f, -1.24928601e-01f, 1.35209084e-01f,
  8.63504261e-02f, -1.21756345e-01f, 6.60402253e-02f, -1.80000514e-01f, 3.05648372e-02f, -1.85205825e-02f, -2.59329360e-02f, -9.59278122e-02f, 6.11682534e-02f, 1.76700018e-03f,
  -3.24131548e-02f, -4.13008809e-01f, 2.67866492e-01f, 2.87487268e-01f, -1.69290572e-01f, -1.99779510e-01f, -5.23741730e-02f, 4.62721199e-01f, -1.36376351e-01f, -1.81508541e-01f,
  1.71859205e-01f, -3.12494010e-01f, 2.41769522e-01f, -1.47685543e-01f, 4.04887766e-01f, -7.50198439e-02f, 4.32961695e-02f, 2.45433431e-02f, -9.87600386e-02f, -1.37162451e-02f,
  6.22423217e-02f, 8.66506621e-02f, 9.68879238e-02f, 8.32954049e-02f, 1.49868503e-02f, -1.88563704e-01f, 2.34630287e-01f, 6.36422774e-03f, 8.66250992e-02f, 1.44913822e-01f,
  1.64016694e-01f, 4.90904525e-02f, 1.83518417e-02f, -1.23284645e-01f, -5.60883805e-02f, -4.06297222e-02f, 1.08494304e-01f, -2.73660421e-01f, -1.69850484e-01f, 6.01561414e-03f,
  1.42821595e-01f, 4.26405761e-03f, -1.82179809e-02f, -1.18650697e-01f, -2.38668486e-01f, 1.19392686e-01f, 2.96188027e-01f, -1.94912821e-01f, -1.98363066e-01f, -2.68258274e-01f,
  1.76922917e-01f, -6.87607154e-02f, 1.02942800e-02f, -3.37815396e-02f, 6.28717393e-02f, -2.29780421e-01f, 1.18709214e-01f, 2.92626441e-01f, -2.72745639e-01f, -2.04535798e-04f,
  1.52166754e-01f, -1.08887449e-01f, 4.45045121e-02f, -1.03197925e-01f, -7.12518692e-02f, -1.97112411e-01f, 2.87707239e-01f, 2.19773620e-01f, -9.57117826e-02f, 1.23376533e-01f,
  2.63573248e-02f, -8.86627734e-02f, -1.15016848e-02f, 6.07460551e-02f, 9.77166370e-02f, 1.44321442e-01f, -5.06250262e-02f, 1.79054305e-01f, 1.58735335e-01f, -5.77279180e-02f,
  1.68175980e-01f, 1.54245866e-03f, -2.30671778e-01f, 3.43257077e-02f, 5.16558997e-02f, -2.61273801e-01f, -2.03613102e-01f, -1.26767848e-02f, 1.19440407e-01f, 2.64012273e-02f,
  -2.64515784e-02f, -2.40518190e-02f, 4.83476706e-02f, 6.01624101e-02f, -5.34150042e-02f, -4.75654602e-02f, 3.50935310e-02f, 3.13782431e-02f, -7.73760602e-02f, 1.21912353e-01f,
  -7.67612644e-03f, 1.38576806e-01f, 3.26810703e-02f, 5.52573651e-02f, -1.69271305e-01f, -8.75145048e-02f, -5.13097532e-02f, 2.22223997e-02f, -1.59928232e-01f, 1.50298029e-02f,
  -7.04002529e-02f, -1.45045877e-01f, 2.16185674e-02f, 1.82948321e-01f, 1.61478501e-02f, -1.10707760e-01f, 5.88129945e-02f, 1.75488871e-02f, 9.29025635e-02f, -1.59027398e-01f,
  2.14469638e-02f, 1.75776213e-01f, 4.34231013e-03f, 1.24652959e-01f, 1.47343874e-01f, 1.97457075e-02f, 1.52244955e-01f, -5.62662296e-02f, 9.69493091e-02f, 8.65719244e-02f,
  9.68902409e-02f, 7.39526227e-02f, -3.39993052e-02f, -3.57875794e-01f, -1.14712231e-02f, 8.32724869e-02f, -1.94278270e-01f, -2.59584337e-01f, 1.46940738e-01f, 3.13423574e-02f,
  -6.07905239e-02f, -1.12864457e-01f, 3.38523299e-01f, -3.01969028e-03f, -1.27562821e-01f, -4.88283224e-02f, -1.89040810e-01f, -1.97324336e-01f, -1.43873945e-01f, -5.12240469e-01f,
  2.65274346e-01f, 5.85533641e-02f, -1.43523300e-02f, 3.71004976e-02f, 3.82502042e-02f, -5.62767312e-02f, -1.33419288e-02f, -1.44985884e-01f, 7.25496411e-02f, -3.14796679e-02f,
  -7.09168836e-02f, -4.00382429e-02f, 3.14716622e-02f, -1.00153841e-01f, 5.38281873e-02f, 1.66019753e-01f, -3.64049640e-03f, 6.51590377e-02f, 5.70909120e-02f, 3.09956856e-02f,
  -2.07726900e-02f, -6.89235106e-02f, -8.97126347e-02f, -6.89677522e-02f, 2.00885639e-01f, 1.75220403e-03f, -2.37348378e-02f, 1.04838898e-02f, -1.19779706e-01f, 3.00849285e-02f,
  6.78722709e-02f, -4.96936217e-03f, 7.70227090e-02f, 5.70221469e-02f, -4.43216134e-03f, 4.95168790e-02f, -1.82820842e-01f, -2.37683747e-02f, 1.11509427e-01f, 4.89918627e-02f,
  1.34634897e-01f, 8.96293391e-03f, 4.23706658e-02f, 3.54226045e-02f, -2.04892337e-01f, 2.96437919e-01f, -1.83500707e-01f, 1.33698270e-01f, -1.17216460e-01f, 2.16703013e-01f,
  -1.17203347e-01f, 5.80456406e-02f, 3.31536233e-01f, -4.54626977e-02f, 1.74163938e-01f, 3.59544784e-01f, -3.30420315e-01f, -2.05464568e-02f, 6.89638108e-02f, -3.45786959e-01f,
  -2.03923970e-01f, -1.95041243e-02f, -2.98611484e-02f, -1.36509493e-01f, 3.70652497e-01f, -6.46605389e-03f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.04323480e-02f, 4.61780906e-01f, 3.11770141e-01f, 1.95897773e-01f, 3.29928696e-01f, 1.80316806e-01f, 6.37046099e-02f, 4.13264185e-01f, 7.13216886e-02f, 1.79476663e-01f,
  1.61533520e-01f, 3.64380300e-01f, 7.35663474e-02f, 5.50270557e-01f, 2.18991011e-01f, 3.88173789e-01f, 1.09731406e-01f, 4.87048239e-01f, 2.62771752e-02f, 2.51572486e-02f,
  3.95116389e-01f, -2.34233886e-01f, 2.49101147e-01f, 2.16474146e-01f, 2.70254254e-01f, 1.51271448e-01f, -3.62641871e-01f, 8.08640048e-02f, 2.24033058e-01f, 1.76153146e-02f,
  -1.72624782e-01f, 6.26216888e-01f, -9.44488775e-03f, -2.90032625e-01f, -9.81618166e-02f, -2.92404056e-01f, -3.26245248e-01f, 2.02702925e-01f, -3.36816370e-01f, -3.99410985e-02f,
  -6.96854115e-01f, 2.18749285e-01f, 6.51839003e-02f, 4.16833401e-01f, -1.54726757e-02f, 5.76556385e-01f, 1.94227099e-01f, 1.62051618e-01f, -2.29635779e-02f, 4.54750359e-01f,
  3.55564117e-01f, -3.89260948e-01f, 2.27486016e-03f, -5.19572236e-02f, 1.12410448e-01f, -1.92580625e-01f, -2.44769707e-01f, 1.35815039e-01f, 4.00842160e-01f, 5.23890972e-01f,
  1.19954936e-01f, 4.23156202e-01f, -2.78925776e-01f, 1.87554210e-02f, 8.61096010e-02f, 9.04249027e-02f, 3.25745851e-01f, 9.36274305e-02f, 2.63336778e-01f, 1.12087801e-01f,
  8.60437751e-02f, 1.62524596e-01f, -2.04962548e-02f, 1.31663010e-02f, 1.49547299e-02f, 2.82891721e-01f, 4.59585458e-01f, 3.52318138e-01f, 1.17599875e-01f, 2.40274906e-01f,
  2.15493873e-01f, 2.49769002e-01f, -8.28087628e-02f, 1.49336338e-01f, -9.08413623e-03f, -9.16547030e-02f, 8.13061092e-03f, 7.42883654e-03f, 1.21001219e-02f, 1.80779267e-02f,
  -4.44507152e-02f, 6.07380718e-02f, -1.81522429e-01f, 1.29283264e-01f, 2.89902627e-01f, -9.80419740e-02f, 1.59770444e-01f, -2.24514723e-01f, 2.18766227e-01f, 1.97592095e-01f,
  -1.00013375e-01f, 8.39581415e-02f, 1.37887076e-01f, 4.58456054e-02f, 1.21689357e-01f, -6.65558130e-02f, 1.71142310e-01f, 1.87007502e-01f, -5.39848745e-01f, -2.66437232e-01f,
  4.44043964e-01f, 7.19555676e-01f, -1.80275962e-01f, 3.37214857e-01f, -1.32943124e-01f, -6.93290830e-02f, 1.29950806e-01f, -4.40942764e-01f, 3.80473733e-01f, 7.63024539e-02f,
  6.23714644e-03f, 1.29701525e-01f, 1.36022151e-01f, 1.01296492e-01f, 9.95776206e-02f, -4.20345277e-01f, 4.35984164e-01f, 3.50543447e-02f, 1.56179532e-01f, -9.17667449e-02f,
  1.58301041e-01f, 1.61452413e-01f, 1.30689517e-01f, 9.98627394e-02f, 1.66800290e-01f, 1.37545496e-01f, 1.79136116e-02f, 6.99174851e-02f, 3.10720295e-01f, 2.39275277e-01f,
  8.21825415e-02f, 1.96963325e-01f, 1.78268597e-01f, 1.17156118e-01f, 1.15069196e-01f, 1.89407840e-01f, 1.98999539e-01f, 7.04389438e-02f, 2.88908720e-01f, 1.62746415e-01f,
  -2.31769875e-01f, -1.56940922e-01f, -2.77187973e-01f, 2.28767037e-01f, -3.25143375e-02f, 1.70280591e-01f, -1.47417709e-01f, 6.58148378e-02f, 4.98584807e-01f, -2.53287882e-01f,
  1.66880824e-02f, -7.66386418e-03f, -7.41217211e-02f, 1.01031289e-01f, -1.37240696e-03f, 2.20804736e-02f, 8.78006592e-02f, -2.72927824e-02f, 4.40609813e-01f, 1.60475507e-01f,
  -1.45601824e-01f, 2.96203852e-01f, 1.39475241e-01f, -4.88287061e-01f, -7.04502612e-02f, 3.40552330e-01f, -2.93826405e-02f, 4.97510105e-01f, -6.70163870e-01f, 1.36823386e-01f,
  -1.13921173e-01f, 4.49397743e-01f, 2.72167265e-01f, -2.02125646e-02f, -3.92697394e-01f, -8.05697218e-02f, -2.14893483e-02f, -2.42014527e-01f, -1.70534790e-01f, 5.98694503e-01f,
  7.67624199e-01f, 6.04076870e-02f, 2.61149138e-01f, 3.52737814e-01f, 9.83146131e-02f, 1.39973745e-01f, 6.16867915e-02f, 6.02218397e-02f, 7.58937970e-02f, 4.10901487e-01f,
  7.68560246e-02f, 3.74832809e-01f, 5.19825183e-02f, 4.84209433e-02f, 3.68046433e-01f, 6.54197112e-02f, 7.22640529e-02f, 1.28523365e-01f, 2.65492976e-01f, 3.46069820e-02f,
  2.41917595e-02f, -1.12157084e-01f, 2.88210690e-01f, 1.64944053e-01f, 3.93217415e-01f, -2.66842782e-01f, -9.37045589e-02f, -2.16531560e-01f, -1.09418347e-01f, 2.23177467e-02f,
  4.15557213e-02f, -2.52410769e-01f, 1.96743920e-01f, -3.42669994e-01f, 4.82870489e-01f, -5.53883128e-02f, -4.29082423e-01f, -1.16962068e-01f, -7.54548833e-02f, -1.23810470e-01f,
  1.22315601e-01f, -2.60362446e-01f, -2.10455552e-01f, -7.68725872e-02f, 2.55220532e-01f, 3.42779934e-01f, -6.71761036e-02f, 1.09487362e-01f, 8.94512311e-02f, 2.18388185e-01f,
  -1.65968478e-01f, 4.70009834e-01f, 1.18295617e-01f, -2.70312369e-01f, -1.27212182e-01f, 2.39236534e-01f, 6.10821784e-01f, -4.15141821e-01f, -3.72915156e-02f, 1.37080565e-01f,
  3.44995782e-02f, 4.14146304e-01f, 7.20194429e-02f, -3.76208395e-01f, -2.07459062e-01f, 1.97627783e-01f, -2.33988836e-01f, 3.16543877e-02f, 1.62643954e-01f, 2.57725835e-01f,
  2.92860419e-01f, 5.64483404e-02f, 1.79500468e-02f, -2.07966626e-01f, -7.77205778e-03f, 2.58783046e-02f, 1.88475251e-01f, -1.89060420e-01f, -1.13356300e-01f, 2.30090469e-01f,
  2.55771130e-01f, 2.95981675e-01f, 2.22538307e-01f, 1.35590613e-01f, 1.19128987e-01f, -2.59365469e-01f, 1.83560997e-01f, -1.53853461e-01f, 2.18121156e-01f, -1.01341248e-01f,
  1.04762219e-01f, -9.42710191e-02f, -1.66715384e-01f, -2.66429931e-02f, -5.75307868e-02f, -7.90980011e-02f, -2.23875970e-01f, 4.88126092e-02f, 1.67707987e-02f, -6.45413399e-02f,
  -5.02381682e-01f, -3.18559073e-02f, 5.30936599e-01f, -1.57997578e-01f, 5.37541434e-02f, 2.41267502e-01f, -2.99181968e-01f, 4.20206696e-01f, 3.99236917e-01f, -1.29463837e-01f,
  -1.42668903e-01f, 9.90953892e-02f, -2.44974986e-01f, 2.26529479e-01f, -2.71999594e-02f, -2.44254798e-01f, 5.24362504e-01f, -1.52881384e-01f, -5.14340937e-01f, 9.91330370e-02f,
  5.68500459e-01f, -4.91405815e-01f, -2.71257525e-03f, 4.88269717e-01f, 1.28205657e-01f, 1.19879479e-02f, 1.10208042e-01f, -1.70726236e-02f, -2.47335330e-01f, -8.82495046e-02f,
  2.70424426e-01f, 1.09637327e-01f, 1.40124321e-01f, 6.87390640e-02f, 3.92755084e-02f, 2.95738965e-01f, 2.13474721e-01f, 4.83845800e-01f, 4.18966897e-02f, 1.24923736e-01f,
  -2.24224776e-01f, 1.72426686e-01f, 3.79518956e-01f, 2.25523919e-01f, 2.11085528e-01f, 2.06403941e-01f, 2.66290307e-01f, 1.18970126e-01f, -2.68033575e-02f, 1.06479801e-01f,
  1.07097909e-01f, 3.55813473e-01f, 1.76329985e-01f, -1.31945908e-01f, -1.02522165e-01f, -7.89176077e-02f, 5.98098040e-02f, 2.49056041e-01f, -1.52690411e-01f, -1.34091780e-01f,
  1.90947250e-01f, -2.80375540e-01f, 2.02719405e-01f, 2.95488127e-02f, -2.66926408e-01f, -1.30468518e-01f, 1.15887515e-01f, -8.00263956e-02f, 1.44341141e-01f, -1.02251902e-01f,
  1.28795892e-01f, -6.92592859e-02f, -5.89823257e-03f, 5.53658426e-01f, 1.79743528e-01f, 1.57262295e-01f, 1.28831677e-02f, 2.44123682e-01f, -2.76921868e-01f, 2.77614295e-01f,
  -1.61459148e-02f, 2.19038337e-01f, -1.27619520e-01f, 5.40474236e-01f, -4.99623567e-02f, -3.40320617e-01f, 1.82752818e-01f, -2.28795946e-01f, -1.07284129e-01f, 1.88240111e-01f,
  2.09023461e-01f, -2.92717308e-01f, 4.21587110e-01f, 6.87496886e-02f, 6.26545176e-02f, 6.91913962e-02f, 1.86068043e-01f, 7.95832574e-02f, 2.29217291e-01f, 7.77128860e-02f,
  1.78762764e-01f, 1.88921448e-02f, 1.14315189e-01f, 9.01362970e-02f, -1.60465091e-01f, -1.48582598e-02f, 3.18978369e-01f, 1.51887000e-01f, 8.00156295e-02f, 7.24185258e-02f,
  1.77695066e-01f, 8.84509236e-02f, -3.59077603e-02f, 7.31047168e-02f, -2.80583680e-01f, -8.81990790e-02f, -1.87431186e-01f, -1.45058870e-01f, -1.28917158e-01f, -5.16819209e-03f,
  3.75348121e-01f, 1.20927200e-01f, -1.29030854e-01f, -2.15291753e-01f, 1.42625898e-01f, -8.71250927e-02f, -3.69209088e-02f, 1.85206369e-01f, 3.02475303e-01f, 2.99597979e-01f,
  4.42749411e-02f, 7.38121709e-03f, 1.65405586e-01f, -2.13478267e-01f, -6.83865324e-02f, -7.06479177e-02f, 4.76080388e-01f, -2.91356713e-01f, -2.05180600e-01f, 9.43307877e-02f,
  2.74295449e-01f, 2.02028111e-01f, 2.57353961e-01f, -9.47874710e-02f, 3.21196496e-01f, 3.48468065e-01f, 3.62357982e-02f, -4.39860761e-01f, 2.31923908e-02f, -6.80174381e-02f,
  1.09623939e-01f, 4.53761280e-01f, -4.07996148e-01f, -1.21822506e-01f, 6.56554252e-02f, -6.88393295e-01f, 6.97198987e-01f, 5.46561629e-02f, 2.94083595e-01f, 1.80480316e-01f,
  6.50859550e-02f, 1.62590384e-01f, 2.32021064e-01f, -6.18184432e-02f, -5.46692424e-02f, 2.25988105e-01f, 2.07339451e-01f, 1.15751654e-01f, 1.25011951e-01f, 7.20113292e-02f,
  8.75541940e-02f, 2.65716791e-01f, 3.04261833e-01f, 1.84112266e-01f, -2.13446423e-01f, 2.45370641e-01f, 1.53207649e-02f, 1.37090981e-01f, 8.08247849e-02f, -2.22437263e-01f,
  -3.20722550e-01f, -6.59249574e-02f, 1.21069223e-01f, 3.01488608e-01f, 3.42889107e-03f, -1.88261345e-01f, 1.01517275e-01f, -1.55478880e-01f, -1.41701266e-01f, 6.91364631e-02f,
  -1.47149831e-01f, 2.73420662e-01f, -3.76993529e-02f, -1.63600251e-01f, -9.18316022e-02f, -4.07402106e-02f, -5.56662790e-02f, 2.92276055e-01f, 1.24501795e-01f, 5.00359058e-01f,
  -3.41767281e-01f, 1.51385851e-02f, 4.01035100e-01f, 1.08641073e-01f, -1.08299531e-01f, -5.03949583e-01f, 2.18025431e-01f, -2.85317153e-01f, -5.67655489e-02f, 2.70524472e-01f,
  5.51592745e-02f, -2.92750716e-01f, 2.04286888e-01f, 3.43823910e-01f, 6.00020923e-02f, 9.61080287e-03f, 3.91975611e-01f, -4.48560016e-03f, 1.07256301e-01f, 3.74750614e-01f,
  1.36892781e-01f, 1.31350905e-01f, -9.49766710e-02f, 1.25235558e-01f, -2.42438689e-01f, 1.04619265e-01f, 1.69374183e-01f, -1.39184371e-01f, -4.39804122e-02f, -2.08611980e-01f,
  6.17594607e-02f, -1.91620633e-01f, 1.71019684e-03f, 1.67641699e-01f, -1.89846102e-02f, 2.08626632e-02f, 1.06737882e-01f, 1.45965636e-01f, 2.58926209e-02f, 8.41840636e-03f,
  -6.67512268e-02f, -3.44821423e-01f, 2.26014033e-01f, -1.97820932e-01f, 9.91956443e-02f, 1.28054321e-01f, 2.03262463e-01f, -7.17531368e-02f, -4.06455100e-01f, -8.01048875e-02f,
  1.71246141e-01f, 2.61773527e-01f, -4.64412928e-01f, 2.76160598e-01f, -1.85646906e-01f, -2.45167613e-01f, 7.62838870e-02f, -2.17473097e-02f, 2.15864867e-01f, 1.19793370e-01f,
  -4.71797734e-01f, 4.78379577e-01f, -4.01209235e-01f, 3.50915641e-01f, -3.70088160e-01f, 1.04099356e-01f, -3.60901564e-01f, 2.14336455e-01f, 8.45176354e-02f, 3.65261793e-01f,
  -4.05553818e-01f, -2.03662589e-01f, 3.81424636e-01f, 4.19837907e-02f, 1.33053750e-01f, 2.69860238e-01f, -4.78535265e-01f, -2.31764659e-01f, -1.07240081e-01f, -3.03788543e-01f,
  3.99572462e-01f, -7.28147924e-02f, -3.16448808e-02f, 9.58530009e-02f, -5.31889260e-01f, -3.58461529e-01f, 1.38218507e-01f, 1.73087135e-01f, 6.05870113e-02f, 2.14288637e-01f,
  2.38785014e-01f, 2.03885317e-01f, -2.10400939e-01f, 1.52405605e-01f, 2.32599407e-01f, 1.24886587e-01f, 1.65396288e-01f, 1.03091232e-01f, 1.17159478e-01f, 9.73837636e-03f,
  1.58913016e-01f, 2.12768421e-01f, 2.80180275e-02f, 1.98480785e-01f, -8.42357799e-03f, -3.32094096e-02f, 1.97662994e-01f, -1.87121525e-01f, -1.86807603e-01f, -1.44748449e-01f,
  2.73174405e-01f, 8.41259584e-02f, -1.10523164e-01f, -8.26766640e-02f, 8.58661532e-02f, 1.89527553e-02f, -8.21397230e-02f, 8.33786353e-02f, 3.16444606e-01f, -1.99977815e-01f,
  -1.15483247e-01f, 4.24337164e-02f, 1.51955977e-01f, -1.12085961e-01f, 2.14637831e-01f, 4.64268029e-01f, 1.03718705e-01f, 2.35531390e-01f, -3.17301959e-01f, 2.67071575e-01f,
  3.43654677e-03f, -2.32174233e-01f, -2.60126770e-01f, 3.08572620e-01f, 4.26069170e-01f, -2.66771883e-01f, 4.23179299e-01f, 7.22758323e-02f, -9.70095992e-02f, 1.70072481e-01f,
  2.71567732e-01f, 1.67923495e-01f, 2.72038907e-01f, -7.64815584e-02f, 4.46263701e-01f, 2.26323660e-02f, 1.81801602e-01f, -5.50137699e-01f, -2.77341932e-01f, -2.84118671e-02f,
  3.29824723e-02f, 1.90286726e-01f, 2.72450298e-01f, 1.65823787e-01f, -7.68110380e-02f, 3.11594252e-02f, -1.13388680e-01f, 3.33909661e-01f, -1.31877512e-01f, -1.51981767e-02f,
  -1.47154510e-01f, 5.51976450e-03f, 4.03047651e-01f, 2.88253754e-01f, 1.80774897e-01f, 8.91529992e-02f, -8.76858756e-02f, -1.62747838e-02f, -1.16645195e-01f, 1.27039418e-01f,
  -3.26575398e-01f, -1.48805827e-01f, -1.00349970e-01f, -1.03500582e-01f, -1.11767389e-01f, -7.55437762e-02f, 2.71806866e-01f, 2.22159624e-01f, -1.72277931e-02f, 1.39480412e-01f,
  7.54581317e-02f, -1.66841328e-01f, -1.30130962e-01f, 1.18871720e-03f, 2.08143100e-01f, 7.92383552e-02f, -9.10915732e-02f, 5.10639744e-04f, 3.72244030e-01f, -2.35810906e-01f,
  1.63014695e-01f, 2.88804293e-01f, 4.71313268e-01f, -1.37001336e-01f, -1.25653207e-01f, 1.41393701e-02f, 2.03577206e-01f, 2.34006345e-01f, 1.89082921e-01f, 3.33420113e-02f,
  2.68644691e-01f, -1.00693971e-01f, -8.85896087e-02f, -3.68871689e-01f, 5.31162262e-01f, -9.08457786e-02f, 2.86657810e-01f, 4.88740593e-01f, 2.88231194e-01f, -2.71867871e-01f,
  3.04521322e-01f, -6.32306814e-01f, -7.38035813e-02f, 1.21112861e-01f, 2.11840376e-01f, 2.41516918e-01f, 2.69410051e-02f, 2.20395997e-02f, -1.09523488e-02f, 7.39966556e-02f,
  3.29341590e-01f, 5.82369566e-02f, -4.03361060e-02f, -3.13652074e-03f, -3.50466743e-02f, 3.96819189e-02f, 1.22195065e-01f, 1.21479705e-01f, 1.42086595e-01f, 9.00807232e-02f,
  7.59390742e-02f, 1.89870566e-01f, 1.59916878e-01f, 2.25976586e-01f, -3.27584803e-01f, 2.51178533e-01f, -2.27601647e-01f, 8.60454421e-03f, -1.49386469e-02f, 6.46111742e-02f,
  2.20548406e-01f, 2.93222427e-01f, -2.53481418e-01f, 2.43205909e-06f, 6.36908635e-02f, -8.70069936e-02f, -1.86760232e-01f, 1.35635063e-01f, 2.13052377e-01f, 2.90130824e-01f,
  2.11485952e-01f, 1.57932770e-02f, 1.78248793e-01f, -2.70790100e-01f, 1.34383097e-01f, -2.29064748e-01f, 1.28254876e-01f, -1.00935958e-01f, 2.76037186e-01f, 9.62794274e-02f,
  4.47679088e-02f, 3.63001436e-01f, -5.08408584e-02f, 2.12594897e-01f, -2.51414388e-01f, 4.71034795e-01f, 7.57998526e-02f, 7.29723871e-01f, -4.32766199e-01f, 1.00344092e-01f,
  -3.22967231e-01f, -1.82030164e-02f, -5.09295702e-01f, -5.21201611e-01f, -5.72676003e-01f, 8.23037028e-01f, 9.93047535e-01f, -2.71806061e-01f, 6.31449465e-03f, 3.53865802e-01f,
  2.60009281e-02f, 1.64188117e-01f, 2.31831864e-01f, 2.22527444e-01f, 3.65253001e-01f, 2.16086417e-01f, 1.91285551e-01f, 1.21058457e-01f, 2.63936907e-01f, 1.86825469e-01f,
  1.70629844e-01f, 1.51471436e-01f, 2.93041463e-04f, 1.67000860e-01f, 2.75838226e-01f, 2.65037585e-02f, 1.17006764e-01f, -1.71507243e-02f, -4.37440425e-01f, 3.23431641e-01f,
  -2.31753603e-01f, 1.11095808e-01f, -2.33030990e-01f, -4.35313769e-02f, 2.64457792e-01f, 1.62435591e-01f, -3.07140589e-01f, 9.22229066e-02f, -7.91808814e-02f, -1.17254399e-01f,
  -2.67256021e-01f, 2.25337803e-01f, 3.71802390e-01f, -7.32324924e-03f, -7.44345561e-02f, -9.02494937e-02f, -1.68312211e-02f, -1.27291486e-01f, 1.05902769e-01f, -3.21092218e-01f,
  5.13954818e-01f, -3.43270034e-01f, 8.25244039e-02f, -3.38400379e-02f, 4.30242330e-01f, 2.74002165e-01f, 2.70490319e-01f, 3.33437294e-01f, -3.40293273e-02f, 2.44482696e-01f,
  -1.21362038e-01f, 6.53850257e-01f, -2.31451780e-01f, 8.45491812e-02f, -1.43751845e-01f, 4.25658375e-01f, -3.25927287e-01f, -2.26185277e-01f, -2.27775693e-01f, 7.55364001e-01f,
  7.07351387e-01f, -1.21539161e-01f, 2.38650516e-01f, 8.68007019e-02f, 1.80609122e-01f, 1.40658364e-01f, 7.34074563e-02f, 7.11788237e-02f, -9.37957037e-03f, 9.37342346e-02f,
  1.07616358e-01f, 4.34292033e-02f, 3.09980720e-01f, 2.03603342e-01f, 2.18589291e-01f, 1.49915859e-01f, 2.92660445e-01f, 4.01954859e-01f, 4.58560623e-02f, 3.77369732e-01f,
  2.25581780e-01f, 8.78775418e-02f, 4.18265402e-01f, -4.85204548e-01f, -3.59307408e-01f, 1.23994082e-01f, 4.24287468e-01f, 2.62706548e-01f, -3.54635686e-01f, 3.87680605e-02f,
  -2.97821090e-02f, 2.24480316e-01f, 2.33146504e-01f, 1.60959110e-01f, 9.66022313e-02f, -3.04548800e-01f, 2.72213966e-01f, 8.52056891e-02f, 1.28011117e-02f, 2.35890895e-01f,
  -1.92580279e-02f, 5.54088295e-01f, 8.59947726e-02f, 1.68970376e-01f, -4.67345923e-01f, 3.24015915e-02f, -7.86264539e-02f, -2.06994280e-01f, 2.24759683e-01f, 2.08378866e-01f,
  2.06603318e-01f, -1.56721070e-01f, -2.18040317e-01f, 3.20580453e-01f, -2.50160813e-01f, -4.92024302e-01f, 1.89382121e-01f, -4.58506234e-02f, 9.90036353e-02f, -2.67913099e-03f,
  4.79985774e-01f, -3.96437258e-01f, 2.68074069e-02f, -1.16051562e-01f, 2.69967467e-01f, -2.22542584e-02f, 2.80592948e-01f, 3.79461318e-01f, 1.61234185e-01f, 2.67775450e-02f,
  1.30798265e-01f, 1.50851473e-01f, 1.80080831e-01f, 2.23767638e-01f, -6.78047026e-03f, 2.91094214e-01f, 2.37310335e-01f, 2.75534898e-01f, 1.84304476e-01f, 1.15397476e-01f,
  8.47879499e-02f, 1.51213244e-01f, 2.20515147e-01f, 6.47417456e-02f, 2.16762740e-02f, 6.81009144e-02f, 1.15279816e-01f, -5.01532517e-02f, 1.76299140e-01f, -2.51598179e-01f,
  -2.05110133e-01f, 1.01297095e-01f, 1.32266685e-01f, -7.96559919e-03f, 1.25384023e-02f, -7.41581693e-02f, 2.29757667e-01f, 1.34383058e-02f, -2.71772832e-01f, 1.77384645e-01f,
  1.46871563e-02f, -1.09990470e-01f, -3.17472219e-01f, 1.17297716e-01f, 1.20735019e-01f, -1.20436572e-01f, -1.67908609e-01f, 2.17561483e-01f, 3.10996026e-01f, 1.45791814e-01f,
  2.56215632e-01f, 2.03030556e-01f, 1.93289950e-01f, -4.61709827e-01f, 4.08712447e-01f, 3.33011448e-01f, -2.81821400e-01f, -3.64637733e-01f, 1.72348723e-01f, -3.51796508e-01f,
  4.95200753e-01f, 8.80969390e-02f, -1.92773297e-01f, 4.93556261e-01f, 4.08461303e-01f, 2.92520523e-01f, 1.12127386e-01f, 4.07514751e-01f, -4.20134693e-01f, 3.20571721e-01f,
  -3.51045802e-02f, -2.33163014e-02f, 1.69525534e-01f, 3.14123988e-01f, 3.39843124e-01f, 6.97155967e-02f, -5.84165230e-02f, 5.72637022e-02f, 1.49189048e-02f, 1.65192619e-01f,
  1.44923031e-01f, 1.02571070e-01f, 5.24197705e-02f, 3.12709123e-01f, 8.90831053e-02f, 4.30107802e-01f, 7.14344997e-03f, -2.33631171e-02f, 1.53977811e-01f, -2.17854723e-01f,
  1.68670759e-01f, -1.55096278e-02f, 1.00009128e-01f, -6.29278943e-02f, 1.84824735e-01f, 3.84335481e-02f, -1.29696950e-01f, -9.68469828e-02f, 1.86280251e-01f, -2.31780902e-01f,
  1.67092122e-02f, -4.01835665e-02f, 2.58978426e-01f, 7.11970478e-02f, -5.13379276e-01f, -1.24659702e-01f, 3.05942297e-01f, -1.87846180e-02f, 1.57673568e-01f, 2.11876199e-01f,
  3.64887305e-02f, 2.25614309e-01f, -5.39121926e-01f, 2.99609095e-01f, 4.08133954e-01f, 1.04693688e-01f, -4.21955347e-01f, -1.90179855e-01f, -1.36231646e-01f, -6.29457533e-01f,
  5.43910384e-01f, 5.17582297e-01f, -5.46091914e-01f, 3.94751549e-01f, 6.08769417e-01f, -4.64591891e-01f, -1.52922915e-02f, -3.71105164e-01f, 1.73339829e-01f, 3.78472880e-02f,
  -1.08106755e-01f, -5.68116605e-01f, 2.99857259e-01f, 1.64454371e-01f, 1.97314784e-01f, 4.54320088e-02f, 2.66441941e-01f, 1.79336369e-01f, 6.86130151e-02f, 1.47443831e-01f,
  9.99121144e-02f, 3.82741570e-01f, 3.20612527e-02f, 2.67659098e-01f, 5.57578867e-03f, 1.37857914e-01f, 1.79449499e-01f, 2.48738468e-01f, 3.55295539e-01f, 4.14217085e-01f,
  2.06221417e-01f, 2.56293267e-01f, 1.73575252e-01f, -8.96691009e-02f, -1.19174747e-02f, 1.61969423e-01f, 1.81008041e-01f, -2.30190024e-01f, 7.96886394e-04f, 1.16718829e-01f,
  -7.16486052e-02f, -3.10565177e-02f, -2.73697793e-01f, 2.78585646e-02f, -2.97881365e-02f, -3.56535017e-01f, 6.03558719e-01f, -2.32498422e-01f, -6.12731516e-01f, -2.37205345e-02f,
  4.29439098e-01f, -1.92834333e-01f, 2.32818142e-01f, 8.83262083e-02f, -6.02942072e-02f, 8.67800787e-02f, 1.96367785e-01f, 5.13654649e-01f, 2.08312506e-03f, 9.50454548e-03f,
  -3.74951720e-01f, 6.49689555e-01f, -1.73356161e-01f, -5.27957141e-01f, 2.96507120e-01f, 2.37410620e-01f, -5.27343750e-01f, 2.37761408e-01f, 6.04048073e-01f, -2.98080385e-01f,
  4.92577925e-02f, 9.70236510e-02f, 1.44776460e-02f, 1.68252796e-01f, -9.99011248e-02f, -4.18010116e-01f, 1.46511331e-01f, 4.91283461e-02f, 1.77110270e-01f, 3.33986551e-01f,
  2.03407213e-01f, 2.23238975e-01f, 2.55178958e-01f, 1.76534187e-02f, 1.76789537e-02f, 5.05298913e-01f, -1.44153044e-01f, 1.37347087e-01f, -1.39358252e-01f, 3.44583750e-01f,
  2.90341616e-01f, 1.72277763e-01f, 2.53789276e-01f, 3.45860869e-01f, 1.39733478e-01f, -1.70548670e-02f, 8.93424749e-02f, -9.53722820e-02f, 2.45028958e-01f, -9.60730314e-02f,
  1.70533732e-01f, -1.62598014e-01f, -2.09900998e-02f, -1.60145238e-01f, 5.79729564e-02f, -1.84930190e-01f, 1.74151048e-01f, -3.58781755e-01f, 3.45433146e-01f, -2.89048851e-01f,
  2.89995879e-01f, 2.44524658e-01f, -2.84954846e-01f, -7.10089803e-02f, 1.24920785e-01f, 2.86853090e-02f, 1.35987923e-01f, -1.36899168e-03f, 4.84410562e-02f, 1.35834098e-01f,
  6.53993059e-03f, 4.62186188e-01f, 3.60063761e-01f, 2.66529292e-01f, 2.32562032e-02f, -7.48449862e-01f, -1.07083373e-01f, -3.06318074e-01f, -1.72102116e-02f, 3.51031631e-01f,
  -5.41493595e-01f, 3.33276749e-01f, 6.48810208e-01f, -3.58062148e-01f, -1.48567528e-01f, 1.90303311e-01f, -3.42314579e-02f, 1.48198768e-01f, -2.63667285e-01f, -5.53595006e-01f,
  2.51932561e-01f, 3.51961195e-01f, 3.65757078e-01f, 1.83472946e-01f, 2.33202443e-01f, 3.22083086e-01f, 2.03200877e-01f, 6.46554604e-02f, 2.36233715e-02f, 4.03978288e-01f,
  -8.00274387e-02f, 3.25304210e-01f, -9.52378586e-02f, 2.25114346e-01f, 4.42722529e-01f, 3.31177026e-01f, -1.09891663e-03f, 1.31805211e-01f, 1.79134056e-01f, 1.54101821e-02f,
  2.11961985e-01f, -1.06090687e-01f, -1.20957337e-01f, 1.60228878e-01f, -8.63163769e-02f, -2.29018778e-01f, -1.82658434e-01f, 7.65077919e-02f, 2.46737763e-01f, -2.26575613e-01f,
  7.76733682e-02f, -3.77759874e-01f, 2.23695174e-01f, -2.49958903e-01f, -5.38862459e-02f, 4.37063754e-01f, -9.22725797e-02f, -2.27920800e-01f, -2.10102975e-01f, -5.65464273e-02f,
  1.88909471e-01f, -2.26273522e-01f, -1.20915353e-01f, 9.60769877e-02f, 3.83298755e-01f, 1.68223456e-01f, 3.56423557e-01f, 1.15729921e-01f, 1.18732847e-01f, -6.22185290e-01f,
  -1.96208864e-01f, -1.42579228e-02f, 5.71568049e-02f, 2.39294022e-01f, -2.92353064e-01f, 1.82686001e-01f, 5.36663294e-01f, -2.97907859e-01f, -1.27282426e-01f, 1.10720597e-01f,
  2.21845116e-02f, 1.56528100e-01f, -2.91141897e-01f, -5.29679596e-01f, 3.23483229e-01f, 2.84049958e-01f, 1.87636003e-01f, 4.00932997e-01f, 3.43030751e-01f, 7.68736973e-02f,
  3.76411498e-01f, 2.36640736e-01f, -2.44370848e-02f, 2.55127907e-01f, 1.19920865e-01f, 2.08485514e-01f, 2.15113059e-01f, 1.56149685e-01f, 1.95042893e-01f, 1.51790828e-01f,
  1.07750133e-01f, 3.17227155e-01f, 3.79893839e-01f, 2.29523972e-01f, 1.61005735e-01f, -6.80864602e-02f, 2.35653952e-01f, -2.84860209e-02f, 1.35839969e-01f, 1.22684948e-01f,
  -8.96739736e-02f, -9.42620859e-02f, -9.09108594e-02f, 8.19268003e-02f, 1.11740597e-01f, 2.85925984e-01f, -2.33807713e-01f, 2.61364639e-01f, -1.69507414e-01f, -1.86014920e-01f,
  4.50182229e-01f, -1.16173469e-01f, -3.61829311e-01f, -8.26957151e-02f, -4.31553684e-02f, 2.48995587e-01f, 5.79964593e-02f, 6.77296892e-02f, 1.58849791e-01f, -1.42038926e-01f,
  -6.71460554e-02f, -9.83240604e-02f, 1.54553279e-01f, 3.13910246e-01f, 4.64871198e-01f, 4.79499251e-01f, -3.07627350e-01f, 3.56701296e-03f, -3.57468650e-02f, -3.94819885e-01f,
  1.42604232e-01f, 2.19375476e-01f, -5.75432517e-02f, 2.95394719e-01f, 6.73642695e-01f, -9.41458642e-02f, 1.09438762e-01f, 7.13192284e-01f, -2.83501327e-01f, 5.64236520e-03f,
  -2.67734528e-01f, 2.57641245e-02f, 1.38169631e-01f, 2.89246768e-01f, 1.61013320e-01f, 8.94772261e-02f, 6.63117543e-02f, -1.49050027e-01f, -5.32539487e-02f, 1.53560480e-02f,
  7.36001134e-02f, 8.93597752e-02f, -8.21644440e-02f, 5.63840717e-02f, -6.43218830e-02f, -2.15074103e-02f, 1.77983698e-02f, 6.91105723e-02f, 9.04717371e-02f, -1.42264992e-01f,
  -6.44523352e-02f, 9.93683040e-02f, 2.03883454e-01f, -1.10302344e-01f, -1.23849981e-01f, -1.44313872e-01f, -3.38015631e-02f, -1.53207993e-02f, 4.49392013e-02f, -2.30025917e-01f,
  -2.12580040e-01f, 8.35036784e-02f, -1.12050831e-01f, 1.60993978e-01f, -2.59628385e-01f, -7.61563182e-02f, 3.07884425e-01f, -7.31361732e-02f, 1.97867244e-01f, 2.04708651e-01f,
  -2.24124670e-01f, 4.23581332e-01f, 3.95250231e-01f, -1.57646947e-02f, -4.92028892e-02f, 7.35945165e-01f, -8.07148069e-02f, -5.47343493e-02f, 1.11967921e-01f, -2.67457157e-01f,
  5.36167800e-01f, -2.58938372e-01f, 6.66959658e-02f, -1.12698741e-01f, 2.88594961e-01f, -3.42129946e-01f, -4.87877056e-03f, 5.06306410e-01f, -8.96421075e-02f, 6.14239514e-01f,
  9.21463966e-02f, -2.77770877e-01f, -1.81174368e-01f, 6.60786107e-02f, 2.98996836e-01f, 2.12352470e-01f, 5.64033799e-02f, 3.09337735e-01f, 5.94793744e-02f, 9.31007490e-02f,
  3.34368013e-02f, 2.95759410e-01f, 1.20096684e-01f, 1.30054966e-01f, 5.35908788e-02f, 2.00206354e-01f, 1.19765475e-01f, 8.32020864e-02f, 3.90320756e-02f, 7.44200796e-02f,
  1.81102782e-01f, 3.23257484e-02f, 6.74989372e-02f, 2.08347127e-01f, 3.58897537e-01f, 6.07468672e-02f, -2.30378300e-01f, -1.94094285e-01f, 1.96201757e-01f, 1.95012540e-01f,
  -3.72186452e-02f, 4.02973853e-02f, -4.97700348e-02f, -3.09760928e-01f, 2.33467594e-01f, -3.09186637e-01f, 4.07573330e-04f, 1.96153849e-01f, 5.38296886e-02f, -2.21600570e-03f,
  -2.90459424e-01f, -4.84844856e-02f, 2.95419067e-01f, 1.07082538e-01f, 2.91232467e-01f, 1.06352225e-01f, -2.63251066e-01f, 5.92075661e-02f, 1.47444367e-01f, -4.45962906e-01f,
  -6.94924966e-02f, -1.77958965e-01f, 2.45271027e-01f, -9.27682687e-03f, -6.14915490e-01f, 2.56093115e-01f, -1.69477090e-01f, 1.15519732e-01f, 3.93905006e-02f, 1.43338054e-01f,
  -1.92775130e-01f, 1.72285493e-02f, 3.55163157e-01f, -1.09497882e-01f, -1.46656334e-01f, -1.21097863e-01f, 3.80480111e-01f, 1.00096986e-01f, -1.43934470e-02f, 1.25742435e-01f,
  1.91987529e-01f, 2.25324288e-01f, 3.77517603e-02f, 7.63988355e-03f, 2.11318493e-01f, 1.57790810e-01f, 1.50734261e-02f, -5.00388108e-02f, 1.54806927e-01f, 1.11630976e-01f,
  1.26554087e-01f, 1.78234562e-01f, 1.17697693e-01f, 1.60811305e-01f, 1.11644723e-01f, 1.32429138e-01f, 1.02929950e-01f, -8.13983940e-03f, 6.08557612e-02f, 1.29274517e-01f,
  3.52832645e-01f, -2.63132118e-02f, -7.92584345e-02f, -2.01981682e-02f, 1.33126840e-01f, -1.28842443e-01f, 3.76129709e-02f, -3.09648544e-01f, -8.88461173e-02f, -8.78275409e-02f,
  -1.90182939e-01f, 4.56359684e-01f, 1.35573745e-01f, -1.67805657e-01f, -2.82162428e-01f, -1.18971899e-01f, -2.00324103e-01f, -3.25798243e-01f, -3.86271507e-01f, 3.93234700e-01f,
  3.25133741e-01f, -3.11634958e-01f, 2.50226855e-01f, 5.77257633e-01f, 2.36670732e-01f, -8.68628561e-01f, 2.61203870e-02f, 2.51654804e-01f, -1.05922539e-02f, -2.75586903e-01f,
  -1.94892343e-02f, 1.23140782e-01f, 1.78041756e-01f, -6.65377006e-02f, -1.74193129e-01f, 4.47802514e-01f, 4.27026860e-02f, 8.03584699e-03f, -4.13857847e-02f, 8.44119370e-01f,
  -1.12041727e-01f, 2.77119040e-01f, -5.50592095e-02f, 3.12707663e-01f, 4.90806364e-02f, 2.88647376e-02f, 1.27965868e-01f, 2.31618315e-01f, 1.65874213e-01f, -7.01838136e-02f,
  1.16861202e-01f, 1.73774853e-01f, -7.13271275e-02f, 1.43554717e-01f, 2.65430570e-01f, -1.15635954e-01f, -7.08691031e-02f, -4.17344421e-02f, 3.49062175e-01f, 3.48389568e-03f,
  1.08270921e-01f, 6.38251379e-02f, -1.45879000e-01f, 3.60858649e-01f, -3.28130834e-02f, -2.14189529e-01f, -1.72481507e-01f, -1.85681179e-01f, 5.83262622e-01f, 2.94549300e-05f,
  -1.16841815e-01f, -3.10783744e-01f, 2.79112644e-02f, -2.18406737e-01f, -2.05234274e-01f, 4.68809813e-01f, 2.81037092e-01f, 2.01761693e-01f, -3.33700240e-01f, -2.08353847e-01f,
  1.47960067e-01f, -1.21532336e-01f, 4.38212603e-02f, -3.24913085e-01f, 4.83789951e-01f, -3.86696577e-01f, 2.73854375e-01f, 5.39443456e-02f, 1.37438118e-01f, -3.74853879e-01f,
  4.48194772e-01f, 9.35016423e-02f, 1.64848953e-01f, 2.83257008e-01f, -1.75369903e-01f, 1.65715188e-01f, -3.22138846e-01f, 4.82064812e-03f, 2.10621423e-04f, 5.90554416e-01f,
  -3.87204140e-01f, 1.05470054e-01f, -1.26101166e-01f, -3.47470254e-01f, 2.65122622e-01f, -1.76780716e-01f, 8.28816369e-02f, 1.64127752e-01f, 9.33391154e-02f, 9.90832299e-02f,
  3.67363803e-02f, 1.19809799e-01f, 1.09666981e-01f, 1.31010011e-01f, 2.01946124e-01f, 1.39241681e-01f, 2.43491083e-01f, 7.00270683e-02f, 9.21710506e-02f, 5.76276444e-02f,
  1.25456005e-01f, 2.56338328e-01f, 9.89787951e-02f, 2.47925833e-01f, -2.85312571e-02f, -2.14388873e-02f, -2.21406177e-01f, 7.06338063e-02f, -1.52787622e-02f, 2.47469857e-01f,
  9.38482806e-02f, -2.82878354e-02f, 5.83689883e-02f, -5.87141812e-02f, -5.07788882e-02f, 9.92446914e-02f, -2.91743100e-01f, 2.58545697e-01f, -3.69038014e-03f, -3.82329971e-01f,
  -4.21254337e-02f, -2.01219842e-01f, 1.49051324e-01f, -6.17985316e-02f, -6.88681602e-02f, 1.79881215e-01f, -1.33984774e-01f, 5.53154051e-02f, -9.25837830e-02f, 1.31315798e-01f,
  -3.08713550e-03f, 1.41564846e-01f, 4.34601195e-02f, 5.96291065e-01f, 4.34435219e-01f, -2.45140746e-01f, 6.52071834e-01f, -1.22575238e-01f, 5.58839403e-02f, 5.07871628e-01f,
  -5.02603590e-01f, 2.11443260e-01f, 3.73750240e-01f, -7.59787858e-02f, -6.59397542e-02f, 6.86841905e-02f, 1.54542714e-01f, 6.80734754e-01f, -3.81340563e-01f, -1.11156181e-01f,
  4.82555851e-02f, 2.55738497e-01f, -1.61387771e-02f, -3.77989970e-02f, 2.29215026e-01f, -1.00746401e-01f, 7.44937211e-02f, -2.58465465e-02f, -6.68909624e-02f, 2.02379242e-01f,
  -4.18321677e-02f, 1.96112409e-01f, 1.27398372e-01f, 5.40834591e-02f, -5.92429079e-02f, 3.64659913e-02f, -1.01746090e-01f, 9.98765677e-02f, -5.06320298e-02f, -2.95523316e-01f,
  -2.47980263e-02f, -1.48528233e-01f, -8.90476108e-02f, 5.32012582e-02f, -1.19000502e-01f, -1.56268492e-01f, -1.69931889e-01f, -4.24377173e-02f, 2.39053816e-01f, -1.26966119e-01f,
  -1.69993043e-01f, 8.54492933e-02f, -2.16143534e-01f, 1.47758454e-01f, -1.40383728e-02f, 5.01554683e-02f, 1.03786796e-01f, -8.09133276e-02f, -3.73116553e-01f, 2.21072659e-01f,
  -1.31489158e-01f, 4.05780464e-01f, 3.30519646e-01f, -1.73807353e-01f, 6.31146058e-02f, 4.86719310e-01f, 3.04192305e-01f, -5.74269235e-01f, -2.02411368e-01f, -4.88493890e-01f,
  3.61618638e-01f, 2.67133921e-01f, 2.66636670e-01f, -1.39096633e-01f, 3.74472924e-02f, -6.28277883e-02f, -2.62291163e-01f, 3.53794158e-01f, 2.87402213e-01f, 4.69994605e-01f,
  -4.43610638e-01f, -9.34072062e-02f, -1.13541894e-01f, -7.62409195e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.42436230e-01f, 2.09657997e-01f, 3.87832224e-01f, 2.29089186e-01f, 2.10922688e-01f, 7.36502707e-02f, 2.96971709e-01f, 3.43006104e-02f, 2.35641915e-02f, 1.75921336e-01f,
  2.69275099e-01f, 3.45722735e-01f, 2.63774544e-01f, 2.05686733e-01f, 3.66541862e-01f, 2.58557677e-01f, 3.53488207e-01f, 3.46866220e-01f, 2.09931672e-01f, 2.45326608e-01f,
  3.60868871e-02f, 2.28324160e-01f, 1.70257866e-01f, 1.73532501e-01f, 3.01908702e-01f, 1.36058226e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.32209241e-01f, -1.26860514e-01f, -5.26162386e-01f, -2.52824903e-01f, -6.19141459e-02f, -1.19583055e-01f, -1.58335030e-01f, -3.47863063e-02f, 7.76746729e-03f, -3.33046168e-01f,
  -1.17173947e-01f, 5.17492667e-02f, -2.10186258e-01f, 1.81630850e-01f, 2.35379800e-01f, -2.15135932e-01f, -2.44180784e-01f, -2.94104487e-01f, -1.83053911e-01f, 9.60407779e-03f,
  3.25428009e-01f, 1.70427144e-01f, -1.39304057e-01f, 4.13306445e-01f, 4.00848836e-02f, -8.66034068e-03f, 4.60522085e-01f, 3.59576382e-02f, -2.69061476e-01f, 1.26810893e-01f,
  -5.32357574e-01f, -3.80782336e-01f, -9.45953652e-02f, 1.35275751e-01f, -3.94594014e-01f, -3.61101240e-01f, -1.09267421e-03f, 5.41889668e-02f, 1.17497131e-01f, -3.38022977e-01f,
  -4.13567364e-01f, -2.91726589e-01f, 2.76482373e-01f, -6.61788881e-01f, -1.65004089e-01f, 1.92857057e-01f, 2.52039880e-01f, 1.00872651e-01f, -4.07117814e-01f, -2.50711501e-01f,
  -2.05990404e-01f, 9.27820653e-02f, 1.01464555e-01f, 9.58998948e-02f, -1.39033094e-01f, -1.15098648e-01f, -6.03447497e-01f, -6.99301735e-02f, 2.41542354e-01f, -5.19959390e-01f,
  9.95717123e-02f, -2.56708950e-01f, 9.39821526e-02f, 3.71347129e-01f, -3.70027006e-01f, 1.68872625e-01f, -2.05535829e-01f, 2.92079389e-01f, 1.95833877e-01f, 2.80097187e-01f,
  -8.84720832e-02f, -4.54882890e-01f, 2.38254100e-01f, 3.04087013e-01f, 1.23804733e-01f, -1.49814665e-01f, -9.76270065e-02f, 6.83927089e-02f, -4.59252447e-02f, 5.43284953e-01f,
  -1.20021991e-01f, 5.06261513e-02f, 5.54841995e-01f, -3.42697561e-01f, 1.11338973e-01f, -1.90438747e-01f, 1.23252146e-01f, 1.74008608e-01f, 2.97963507e-02f, -2.03569859e-01f,
  2.09691525e-01f, -1.18021876e-01f, 1.85425326e-01f, -1.57529637e-01f, 2.81498700e-01f, -2.05027714e-01f, 2.79881716e-01f, 4.22588468e-01f, 2.62816101e-01f, 4.06399220e-02f,
  -4.90135729e-01f, -3.41272801e-02f, 2.65628956e-02f, -1.17362421e-02f, -3.64321917e-01f, -5.87477088e-01f, -6.27539217e-01f, -4.47788954e-01f, 1.37256429e-01f, 2.44938001e-01f,
  3.13437283e-01f, 2.19745845e-01f, 1.12174585e-01f, -1.66370451e-01f, 4.19348590e-02f, 4.38613892e-01f, 8.80245194e-02f, -4.91962999e-01f, -9.49419558e-01f, -6.58739150e-01f,
  -4.48917121e-01f, 4.16790396e-01f, -5.14213979e-01f, 1.10558040e-01f, -3.17075074e-01f, 2.79303163e-01f, 2.01523662e-01f, 1.75824970e-01f, 1.61901221e-01f, -2.25160420e-01f,
  1.64390206e-01f, -1.34683520e-01f, 6.60963058e-02f, 1.30593225e-01f, 2.13957712e-01f, -6.59663081e-02f, 1.35592610e-01f, -2.08005637e-01f, 1.75346002e-01f, -9.31487884e-03f,
  -2.25128129e-01f, -1.27211317e-01f, -8.75814110e-02f, 4.73190919e-02f, 1.36333585e-01f, -1.07623741e-01f, 1.36014774e-01f, 5.62190294e-01f, -1.49628416e-01f, 1.19574450e-01f,
  1.09719403e-01f, 7.66573027e-02f, 3.63827720e-02f, 2.64426321e-01f, 2.66226202e-01f, -1.87328801e-01f, 2.90998399e-01f, 3.29941213e-01f, -4.42909569e-01f, -3.25811505e-01f,
  -1.28813684e-01f, 6.67528510e-01f, -4.55466360e-02f, -2.85189122e-01f, -3.50252777e-01f, -3.48665655e-01f, 2.83752292e-01f, -2.02461258e-01f, 1.51421398e-01f, -1.52193740e-01f,
  -2.72784084e-02f, -2.63969898e-01f, -5.09204626e-01f, 2.28556797e-01f, -3.52665782e-01f, -2.04710782e-01f, -5.20111978e-01f, 2.05003768e-01f, 2.78544784e-01f, -3.48514348e-01f,
  1.62992373e-01f, -4.05352712e-01f, -2.40694672e-01f, -5.22237182e-01f, -9.88451391e-02f, 2.85196722e-01f, -2.76161879e-01f, -4.03533161e-01f, 3.65480959e-01f, -2.40666628e-01f,
  3.05030584e-01f, -1.49372086e-01f, 4.49219272e-02f, -2.43712395e-01f, 6.27875105e-02f, 1.97209626e-01f, -1.30812004e-01f, 2.18019426e-01f, -6.48246408e-02f, -1.97723985e-01f,
  -8.79253894e-02f, -4.00404751e-01f, -5.69400936e-03f, 1.29640013e-01f, -2.18682483e-01f, 4.43142466e-03f, -2.04351172e-01f, -3.31130512e-02f, -1.45719588e-01f, 9.09344703e-02f,
  -2.31327593e-01f, 2.85520673e-01f, 3.09821844e-01f, -1.11980997e-01f, -1.46042824e-01f, -1.83959633e-01f, -6.02693021e-01f, -2.59246945e-01f, -2.33275503e-01f, -7.67375112e-01f,
  -3.23844254e-01f, -1.42447859e-01f, -5.62109888e-01f, -2.90327013e-01f, -8.76775756e-02f, 5.82181633e-01f, 4.38290656e-01f, 5.92380762e-01f, -5.18721268e-02f, -2.20946163e-01f,
  1.30464677e-02f, -6.80276826e-02f, -1.22266330e-01f, 2.56645143e-01f, 9.00241137e-02f, 3.47976506e-01f, -4.45974976e-01f, -5.20521581e-01f, 1.35068625e-01f, 2.09306091e-01f,
  -9.31252539e-01f, -5.71446680e-02f, -1.55365601e-01f, -3.31667989e-01f, -4.08705056e-01f, 2.55559295e-01f, 5.09106755e-01f, 2.04209715e-01f, -1.00958988e-01f, -8.30994010e-01f,
  3.33265327e-02f, -4.81635243e-01f, -2.48991892e-01f, -2.27398023e-01f, 4.11987036e-01f, -3.16365920e-02f, 2.12535694e-01f, 2.31304452e-01f, 2.37436906e-01f, 1.26452073e-01f,
  2.06718460e-01f, -1.24875546e-01f, 4.88180295e-02f, 2.50649840e-01f, -1.75542515e-02f, 4.64302987e-01f, -1.40476683e-02f, 2.17165425e-01f, 4.38184053e-01f, 5.52318245e-02f,
  1.80337757e-01f, -7.32490867e-02f, 1.26481071e-01f, -1.48173645e-01f, 2.65478585e-02f, -2.90336609e-01f, -1.90318078e-01f, 9.60111618e-02f, -2.75344789e-01f, -1.39841586e-01f,
  4.70362157e-01f, -1.53837219e-01f, -9.52322781e-01f, 2.36957267e-01f, 3.67530659e-02f, -2.49460310e-01f, 2.53715217e-01f, 2.13426635e-01f, -6.30218685e-01f, -4.02529329e-01f,
  -2.16909289e-01f, 1.46516040e-01f, -1.21219540e-02f, 4.31499302e-01f, 1.34217069e-01f, -4.22492206e-01f, -5.68755686e-01f, 2.76138425e-01f, -4.54770438e-02f, 2.21823767e-01f,
  -9.38783884e-02f, 1.23751014e-01f, -9.93045047e-02f, 2.00741328e-02f, 1.17171139e-01f, -5.08494079e-01f, -6.12543583e-01f, -6.25897169e-01f, 1.03769064e-01f, -3.59278135e-02f,
  8.86334404e-02f, 2.66700327e-01f, 1.95716172e-01f, -3.01657081e-01f, 1.77646056e-01f, -1.68396816e-01f, 1.52731463e-01f, -4.79555428e-01f, 1.54397925e-02f, 1.56734690e-01f,
  1.01530487e-02f, 9.40954387e-02f, -1.85427815e-01f, 2.52627373e-01f, -4.95573059e-02f, 8.19715932e-02f, -2.26242945e-01f, -3.60095315e-02f, 2.68920581e-03f, 2.06185263e-02f,
  1.23805843e-01f, -1.84412643e-01f, -1.85326517e-01f, -1.88027263e-01f, 1.61231607e-02f, -3.10831442e-02f, 2.69197971e-01f, 2.89201438e-01f, 4.80651706e-02f, -2.37390682e-01f,
  -1.55296132e-01f, 2.34697819e-01f, -4.07556415e-01f, -2.51172483e-01f, 1.39766231e-01f, 5.23817018e-02f, 2.59240925e-01f, 3.74431580e-01f, -1.12813048e-01f, -1.65444642e-01f,
  1.70803383e-01f, 4.87296581e-01f, 1.60205066e-01f, -3.46033394e-01f, -1.80046484e-01f, -3.48452955e-01f, 1.59884304e-01f, -3.73774260e-01f, -7.52467215e-02f, -5.78073319e-04f,
  2.47174308e-01f, 6.57430515e-02f, -6.97717955e-03f, -6.75248802e-02f, -1.27127245e-01f, 1.94598466e-01f, -2.41963789e-01f, 1.58155262e-01f, 3.70694771e-02f, -3.77689898e-01f,
  -3.54467303e-01f, 2.68475741e-01f, 5.87831847e-02f, 2.82780647e-01f, 2.51780778e-01f, 4.25136417e-01f, 1.17968991e-01f, -4.15672958e-02f, -3.23980093e-01f, 3.32791120e-01f,
  -5.41733205e-02f, -3.17216247e-01f, -4.93807703e-01f, -2.39699274e-01f, -1.01418786e-01f, -4.18950051e-01f, 1.72109127e-01f, 1.75965428e-02f, 8.85923281e-02f, -1.96112767e-01f,
  -4.25870866e-02f, -1.40094995e-01f, 1.31774306e-01f, -2.33479828e-01f, -3.38415414e-01f, -1.87462643e-02f, 2.82879621e-01f, 2.73366809e-01f, -5.43428734e-02f, 7.89648443e-02f,
  -2.84255091e-02f, 1.51963487e-01f, 3.21191587e-02f, 2.32015818e-01f, -3.49922985e-01f, -1.38338149e-01f, -1.22934729e-01f, 3.60221058e-01f, 1.74612954e-01f, 4.53421950e-01f,
  -2.23252892e-01f, 1.93786919e-02f, 9.79999974e-02f, 4.59048599e-01f, 1.79332420e-01f, 3.86747122e-01f, -9.18484181e-02f, -2.33493865e-01f, -4.81107295e-01f, 5.04986793e-02f,
  -2.90730923e-01f, -1.52751878e-01f, -9.37150002e-01f, -6.01857901e-01f, 3.42305154e-01f, -9.40370336e-02f, -6.98819876e-01f, 1.41879013e-02f, -1.75332893e-02f, -1.37336506e-02f,
  -8.21051840e-03f, -2.82688946e-01f, -6.93703592e-02f, 3.77974629e-01f, 3.99827600e-01f, -3.55305105e-01f, 1.25252753e-01f, -8.83217573e-01f, -8.52257729e-01f, 1.46444589e-02f,
  1.71033993e-01f, 9.24655050e-02f, -2.72707760e-01f, 2.98101127e-01f, 1.33990660e-01f, 3.81260097e-01f, -2.83580750e-01f, -5.35994947e-01f, 7.16864020e-02f, -6.63647577e-02f,
  -1.17288105e-01f, -3.10984075e-01f, -1.28362879e-01f, 1.59199357e-01f, -1.87639762e-02f, 5.50613739e-02f, -1.28319077e-02f, 2.28305086e-01f, -7.20116124e-02f, -2.58424655e-02f,
  -1.84487328e-02f, -1.11340389e-01f, -2.72940457e-01f, -3.29158992e-01f, -3.09785396e-01f, 4.37637940e-02f, -1.37417480e-01f, 3.78812045e-01f, 2.13123843e-01f, -9.07081291e-02f,
  1.31226152e-01f, -5.10278642e-02f, -3.71668160e-01f, 4.56252873e-01f, -1.30570695e-01f, -2.43474007e-01f, 3.06290183e-02f, -2.96030521e-01f, 2.10224003e-01f, -2.24522520e-02f,
  4.52481993e-02f, -1.51896805e-01f, -7.21585602e-02f, 6.03195392e-02f, 2.67720491e-01f, -8.56540725e-02f, -5.45687318e-01f, 1.40615078e-02f, -5.57255268e-01f, 3.93692315e-01f,
  2.41122574e-01f, 4.19567712e-02f, 1.31503239e-01f, -2.15873823e-01f, -5.50134122e-01f, 1.34156302e-01f, 2.77536988e-01f, -2.80067772e-01f, -1.44974506e-02f, -4.86603200e-01f,
  -1.05243266e-01f, -1.84680924e-01f, 5.63450456e-01f, -3.40125710e-01f, -1.84462920e-01f, -9.36096385e-02f, 3.01417172e-01f, -5.11372387e-01f, -5.15113175e-01f, -4.99290973e-02f,
  1.24144562e-01f, -4.04543519e-01f, 2.40846965e-02f, 1.31912023e-01f, 2.25793645e-01f, -6.09650970e-01f, 2.11560652e-01f, 2.80495912e-01f, -1.88506022e-01f, 2.27857113e-01f,
  -2.86302436e-02f, -2.78982054e-02f, 1.69764012e-01f, 4.33506966e-01f, -2.27860093e-01f, 1.85149059e-01f, 1.51357681e-01f, -3.21303546e-01f, 3.53760347e-02f, -2.69658081e-02f,
  -2.38775954e-01f, -2.34784842e-01f, 1.06733903e-01f, -1.11219764e-01f, -8.87257680e-02f, 1.09677024e-01f, -1.55547589e-01f, -2.25811437e-01f, 9.16387439e-02f, 2.29140580e-01f,
  2.28158578e-01f, -1.70261770e-01f, -1.93510681e-01f, 1.98583513e-01f, 1.88798323e-01f, 3.43280703e-01f, 3.36930543e-01f, -3.30856770e-01f, 6.05785310e-01f, 3.37714195e-01f,
  -4.92788076e-01f, 4.84813422e-01f, 4.25583571e-01f, -5.64594865e-01f, -3.87546629e-01f, 1.50623739e-01f, 2.60323465e-01f, -9.30661187e-02f, -3.71829599e-01f, -2.29190320e-01f,
  1.56350985e-01f, 5.32522857e-01f, 2.01585039e-01f, 2.28724793e-01f, -5.66352248e-01f, -5.98770261e-01f, 1.26962245e-01f, -8.00285161e-01f, -3.70592266e-01f, -1.63179100e-01f,
  -5.07305622e-01f, 3.35350670e-02f, -5.29689252e-01f, -4.19888079e-01f, -5.90816066e-02f, -1.80191636e-01f, -4.84700426e-02f, -9.11078453e-02f, 7.51772374e-02f, -4.80852835e-02f,
  5.83563978e-03f, -2.10244685e-01f, 3.43115628e-02f, 2.94825613e-01f, -2.54606992e-01f, -3.63133073e-01f, 4.93199438e-01f, -2.66634196e-01f, 1.69709310e-01f, -7.70504624e-02f,
  -1.99112177e-01f, -2.63389423e-02f, -2.86824461e-02f, 2.34951407e-01f, -2.55875945e-01f, -1.57062933e-01f, -3.33194971e-01f, 1.93272874e-01f, 1.61187425e-01f, -4.72457439e-01f,
  4.13259536e-01f, 1.35659687e-02f, 1.40044495e-01f, 2.50121415e-01f, 3.56008410e-01f, 1.09310552e-01f, 3.88958633e-01f, 1.10785387e-01f, 6.58337235e-01f, -4.45827067e-01f,
  3.88942063e-01f, 1.25664204e-01f, -1.19138002e-01f, 1.60798412e-02f, -5.18143214e-02f, 1.16103619e-01f, -4.35160756e-01f, 1.38467476e-01f, 1.95894226e-01f, -5.95728159e-01f,
  1.92659006e-01f, -3.19046348e-01f, -4.39081222e-01f, -7.11750269e-01f, 9.03385282e-02f, -2.11243317e-01f, 7.94557035e-02f, -3.64013016e-01f, 3.14051211e-01f, -5.37314236e-01f,
  -3.60095114e-01f, 1.45392358e-01f, 2.34858587e-01f, 1.40749529e-01f, 2.25918606e-01f, -5.34882367e-01f, 2.26103336e-01f, 5.67788668e-02f, -3.64426047e-01f, 2.62095749e-01f,
  -5.40087521e-02f, 9.31524336e-02f, 1.89067498e-01f, -7.32722431e-02f, -4.35548633e-01f, -3.35235775e-01f, -1.56338662e-01f, 3.63218179e-03f, -6.02397770e-02f, 5.64930029e-02f,
  -5.86282015e-02f, 5.47789969e-02f, -7.29680732e-02f, 1.15260094e-01f, 2.34602436e-01f, -1.61205113e-01f, 1.65311515e-01f, -2.50771433e-01f, -1.44974962e-02f, -1.89538285e-01f,
  -6.97373971e-02f, 9.13964063e-02f, 2.19703510e-01f, -4.12912332e-02f, -3.98273945e-01f, 3.20382975e-02f, -1.13515750e-01f, -4.26439047e-01f, -3.46321195e-01f, -2.31723160e-01f,
  2.29626536e-01f, -6.65209830e-01f, -2.28869081e-01f, -3.73388499e-01f, 2.05612615e-01f, 1.36573687e-01f, -2.78653264e-01f, 3.60697061e-01f, 4.31611687e-01f, 3.90157372e-01f,
  2.78288007e-01f, 5.22050500e-01f, -3.97791296e-01f, 3.52891266e-01f, -4.11340892e-01f, -6.26013756e-01f, -3.35048102e-02f, -1.28863901e-01f, -5.48947990e-01f, -4.26367283e-01f,
  -4.51236576e-01f, 6.29244745e-02f, 1.53367683e-01f, -3.86708856e-01f, -1.40837610e-01f, -4.44063067e-01f, -4.67842788e-01f, 3.83712798e-01f, -3.07282329e-01f, -6.60513267e-02f,
  -3.34988445e-01f, -1.89552203e-01f, -4.94866222e-01f, -5.12464464e-01f, -1.26106553e-02f, 2.32685208e-01f, 1.88208502e-02f, 9.10387263e-02f, -2.65769839e-01f, -2.01150775e-01f,
  5.11444844e-02f, -1.51876599e-01f, -1.62954703e-01f, 1.29344493e-01f, -2.24579766e-01f, -3.89491767e-02f, -2.06044450e-01f, -6.76671118e-02f, -7.40403533e-02f, 2.03973040e-01f,
  -6.84109628e-02f, -1.57775521e-01f, 5.65643199e-02f, 4.36607391e-01f, 4.79947001e-01f, -1.16939254e-01f, 2.00827956e-01f, 3.63276839e-01f, 2.85970777e-01f, -5.00679731e-01f,
  1.28981918e-01f, 1.41929582e-01f, 2.60169119e-01f, 2.27936193e-01f, 1.92276865e-01f, -1.12580918e-02f, -6.68904066e-01f, -3.10275704e-01f, -3.61687690e-01f, 1.12436615e-01f,
  3.26793104e-01f, 2.53841013e-01f, -3.41677457e-01f, -3.92424047e-01f, 4.71424870e-03f, -3.03100944e-01f, -3.07197899e-01f, 2.32734427e-01f, 2.40191147e-01f, 7.94431567e-02f,
  -1.81321606e-01f, -7.06512332e-02f, -2.33121350e-01f, 3.47121119e-01f, 1.31321669e-01f, -4.97342423e-02f, -7.40689635e-01f, 5.27297258e-01f, 2.09264532e-01f, 3.88911158e-01f,
  3.42298090e-01f, -5.62114179e-01f, -2.85236418e-01f, 7.59756193e-02f, -4.25962299e-01f, 2.56484538e-01f, -2.82589346e-01f, 2.39368677e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.81216924e-02f, 8.70445818e-02f, 3.50572728e-02f, -4.12360132e-02f, -1.02187850e-01f, -8.15715612e-05f, 1.25334844e-01f, 8.56734514e-02f, 5.68007268e-02f, -8.71499404e-02f,
  1.77189671e-02f, 3.75326909e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    