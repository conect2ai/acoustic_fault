/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.22155049e-01f, -1.97489083e-01f, -1.40981033e-01f, -2.15099305e-01f, -6.85621053e-02f, -8.64935666e-02f, -1.60405293e-01f, -6.17851019e-02f, -3.20763253e-02f, -7.51746371e-02f,
  -4.31872457e-02f, -6.87835962e-02f, -1.48335248e-01f, -1.24218300e-01f, -1.24335654e-01f, -2.66525090e-01f, -1.46829858e-01f, -2.30782077e-01f, -1.08891711e-01f, -8.83478299e-02f,
  -1.64921492e-01f, -2.35157106e-02f, -1.69366479e-01f, 2.27188109e-03f, -1.26824439e-01f, 4.89417696e-03f, -1.26389951e-01f, -5.39041311e-02f, -1.54931173e-01f, -2.35386446e-01f,
  -1.72766268e-01f, -5.78045696e-02f, 1.55111142e-02f, -9.57858264e-02f, -6.92748791e-03f, -1.25994325e-01f, -3.78247947e-02f, -7.90360570e-02f, -4.69287746e-02f, -1.22319728e-01f,
  -1.28661409e-01f, -1.27002941e-02f, -6.90200627e-02f, -1.27248792e-02f, -1.39276654e-01f, 4.30658832e-03f, -4.39087600e-02f, -1.13517754e-01f, -6.90144897e-02f, -2.73062568e-02f,
  -1.61980599e-01f, -1.53901413e-01f, -1.99364111e-01f, -1.33255467e-01f, -1.65750403e-02f, 7.91323464e-03f, -2.85548344e-02f, 2.37260610e-02f, 1.30138630e-02f, -1.75739542e-01f,
  9.22884699e-03f, 2.25693919e-03f, -6.79188175e-03f, 5.29442206e-02f, 1.01239175e-01f, 9.65676978e-02f, 4.04122882e-02f, 1.32625803e-01f, 8.18553492e-02f, 8.93552676e-02f,
  1.33605525e-01f, 1.22765265e-01f, 1.34597532e-02f, 7.05311075e-02f, 3.48295644e-02f, -4.25569601e-02f, 1.63824022e-01f, 1.34507865e-01f, 2.79456917e-02f, 1.25002339e-01f,
  1.00878820e-01f, 8.79515857e-02f, 3.94011624e-02f, 1.46516204e-01f, 4.00564261e-02f, 1.90006092e-01f, 5.63422777e-02f, 6.64753094e-02f, 1.38167083e-01f, 7.07730725e-02f,
  -1.45328254e-01f, 1.10201612e-01f, -1.07835889e-01f, -2.80890856e-02f, -1.63670689e-01f, -2.34728977e-02f, 2.24950071e-02f, -6.87915683e-02f, -5.71905524e-02f, -1.07015267e-01f,
  -2.42543947e-02f, -1.18576556e-01f, -6.16097488e-02f, -1.22266114e-01f, -6.35841340e-02f, -1.59255520e-01f, -1.56796619e-01f, -1.61733240e-01f, -5.58968559e-02f, -5.69450632e-02f,
  -1.75594628e-01f, -1.22066058e-01f, -9.44956318e-02f, -1.78575724e-01f, -6.71331733e-02f, -6.71765804e-02f, -1.47789717e-01f, -4.67219204e-02f, -7.20679685e-02f, -2.00386837e-01f,
  1.75996453e-01f, -1.14188790e-01f, 1.56002268e-01f, 1.46296546e-02f, -2.63518721e-01f, -1.96981117e-01f, -2.42526442e-01f, -3.25383805e-02f, 1.89977940e-02f, -8.86473730e-02f,
  -1.50949225e-01f, -4.97987717e-02f, 1.38272773e-02f, 1.00793438e-02f, -6.27365336e-02f, 2.08213422e-02f, 1.50089636e-01f, 1.80662245e-01f, 7.90711120e-03f, -1.75186634e-01f,
  -3.65106985e-02f, 1.11353122e-01f, 1.96441680e-01f, 1.45814270e-01f, -8.43285844e-02f, -3.92526947e-02f, 8.78243968e-02f, 2.86278054e-02f, 1.72272436e-02f, 1.51511073e-01f,
  -6.32027071e-03f, -1.49074122e-01f, -7.97317177e-02f, -1.34499505e-01f, -2.15124950e-01f, -4.57751714e-02f, -9.61515978e-02f, -5.40409759e-02f, -2.20468745e-01f, -1.59430698e-01f,
  -9.71309543e-02f, -1.90709963e-01f, -1.20731041e-01f, -2.13158935e-01f, -1.03206642e-01f, -5.37066422e-02f, -8.07523429e-02f, 2.34946404e-02f, 2.22834311e-02f, -1.26205519e-01f,
  -1.79267898e-01f, -1.85659274e-01f, -1.32814035e-01f, -6.21736720e-02f, -1.68113425e-01f, 3.28285024e-02f, 3.65384226e-03f, -1.15187010e-02f, -3.37529257e-02f, 5.87729700e-02f,
  9.97930318e-02f, 1.43381685e-01f, 1.07041426e-01f, 1.07147597e-01f, 1.35871857e-01f, 1.53665543e-01f, 7.21282959e-02f, 1.25009999e-01f, 4.10484150e-03f, 1.39407203e-01f,
  1.37356699e-01f, 3.27533707e-02f, 1.40363529e-01f, 1.49271488e-01f, 8.38763565e-02f, 5.80506772e-02f, 1.00579292e-01f, 6.28471673e-02f, 9.62802395e-02f, 1.02196671e-01f,
  5.76607622e-02f, 6.48611337e-02f, 8.00103545e-02f, 7.24965259e-02f, 1.38366371e-01f, 1.63795128e-01f, 6.64252713e-02f, 3.77878621e-02f, 1.65542498e-01f, 1.55304521e-01f,
  -2.16244794e-02f, -1.78949729e-01f, -1.49959907e-01f, -3.39892395e-02f, -9.82041433e-02f, -1.47073239e-01f, -1.02588452e-01f, -6.14270382e-02f, -2.27816284e-01f, -1.11326315e-01f,
  -1.43429458e-01f, -9.20403004e-02f, -7.04381317e-02f, -1.18241608e-01f, -1.46259338e-01f, -1.11471735e-01f, -1.43108591e-01f, -2.02479735e-02f, -4.43392321e-02f, -9.89094749e-02f,
  -5.14950894e-04f, -9.17309150e-02f, 4.09961492e-02f, -3.66180688e-02f, -1.10579394e-01f, 5.71398884e-02f, -7.50447735e-02f, 4.34252732e-02f, 4.71005253e-02f, -5.13969548e-03f,
  -4.82103705e-01f, -2.63727933e-01f, 1.76892042e-01f, -3.49283963e-02f, 1.39377326e-01f, 7.62435049e-02f, 5.19823208e-02f, 6.26518875e-02f, -3.40623222e-02f, -1.88892372e-02f,
  -1.26472101e-01f, -1.02852188e-01f, -3.61992344e-02f, 1.01082355e-01f, 6.47542551e-02f, 8.58569220e-02f, 1.99157715e-01f, 1.12199157e-01f, 1.00622468e-01f, -2.68127136e-02f,
  1.07334644e-01f, 5.56718707e-02f, -1.16339721e-01f, -1.54732317e-02f, 6.19975999e-02f, -9.39121693e-02f, 9.33221132e-02f, -1.83885712e-02f, -1.68972351e-02f, -1.54107824e-01f,
  -4.66326028e-02f, -2.03412384e-01f, 1.57556251e-01f, -4.35864041e-03f, 1.28453508e-01f, -1.78108085e-02f, -2.64615770e-02f, -1.80288088e-02f, 8.23569149e-02f, -4.31123003e-02f,
  4.13659550e-02f, 3.54433954e-02f, 9.25668851e-02f, 3.79313268e-02f, 8.94638449e-02f, -1.26183114e-03f, 1.58930331e-01f, 4.04343270e-02f, 6.50098398e-02f, -4.17877771e-02f,
  6.72672167e-02f, -8.33395645e-02f, -3.26736197e-02f, 4.30137217e-02f, 4.18814234e-02f, -3.06036673e-03f, -3.97428088e-02f, -7.37027600e-02f, 5.78388423e-02f, -4.92782332e-02f,
  -3.90283801e-02f, -1.40090421e-01f, -3.25948633e-02f, -6.68185204e-02f, -2.91463751e-02f, -3.69860716e-02f, -2.14341655e-02f, -7.96043351e-02f, -7.28470832e-02f, -4.18783352e-02f,
  -2.13230699e-02f, -6.13825619e-02f, 3.00484765e-02f, -5.40673919e-02f, 1.97631661e-02f, -7.18973801e-02f, -1.89186092e-02f, -7.68312886e-02f, -5.29731959e-02f, -1.08320266e-01f,
  -8.51595104e-02f, -9.76288319e-02f, 3.86430994e-02f, 2.19248421e-02f, 1.78783457e-03f, 3.46988998e-02f, -1.20271996e-01f, 4.10408378e-02f, -6.48612157e-02f, -9.81426910e-02f,
  -3.87184843e-02f, 1.32513404e-01f, -5.01168557e-02f, 3.95508744e-02f, 5.25165200e-02f, 1.40905336e-01f, 2.79605333e-02f, 1.32888369e-02f, 4.10501026e-02f, 2.36328412e-02f,
  2.15867124e-02f, -2.78805513e-02f, 2.30920427e-02f, 1.22762524e-01f, 1.06328756e-01f, 8.29650909e-02f, -1.17246564e-02f, 1.34184537e-03f, 1.51981533e-01f, 1.11828022e-01f,
  1.59570441e-01f, 7.27274865e-02f, -3.71057242e-02f, 3.11766807e-02f, -4.31594886e-02f, -1.04280993e-01f, 3.27937212e-03f, -5.42515591e-02f, -4.92844731e-02f, -7.16605559e-02f,
  3.05184692e-01f, 1.40037552e-01f, -7.29176477e-02f, 5.16594015e-02f, -1.83629408e-01f, -3.04546088e-01f, -3.25337768e-01f, -1.38862608e-02f, -4.52636741e-02f, -6.35272935e-02f,
  -2.36402787e-02f, 1.61932446e-02f, -1.12511940e-01f, -4.85526882e-02f, -3.68899852e-02f, -1.61121771e-01f, -2.04570904e-01f, -5.28833345e-02f, -1.89538285e-01f, -6.15141205e-02f,
  -1.98581219e-01f, -3.14602777e-02f, 4.55321185e-02f, -2.60314476e-02f, -5.95023930e-02f, -2.65455227e-02f, -4.24108766e-02f, -6.19027428e-02f, -1.53939083e-01f, -1.25465587e-01f,
  1.66921407e-01f, 2.50978231e-01f, -7.95472041e-02f, 5.24441861e-02f, -5.55687323e-02f, -3.25649083e-02f, -8.55504945e-02f, 4.04562540e-02f, -5.88353761e-02f, -5.32216616e-02f,
  5.59334978e-02f, 2.59462222e-02f, 7.18292213e-05f, -1.73333175e-02f, -6.87882751e-02f, -1.33059788e-02f, 7.11710425e-03f, -4.76942509e-02f, -1.37728881e-02f, 3.71451378e-02f,
  -4.23939563e-02f, -6.62392825e-02f, 5.61868809e-02f, -3.16744810e-03f, -2.65887361e-02f, -1.63591012e-01f, 8.17607529e-03f, -4.07862589e-02f, 2.43950635e-02f, -3.87543328e-02f,
  -1.23926923e-02f, 7.41374865e-02f, 8.26746002e-02f, 1.98056951e-01f, 5.63067384e-02f, 8.27174354e-03f, 1.15100205e-01f, 2.64868401e-02f, 4.36453857e-02f, 8.04858133e-02f,
  7.96696246e-02f, 1.19686440e-01f, 4.32537049e-02f, -8.44801217e-03f, 3.39732356e-02f, 1.17293276e-01f, 2.08641496e-02f, 1.00146003e-01f, 9.57990885e-02f, 1.29603967e-01f,
  1.05490513e-01f, 6.25026748e-02f, 4.90747876e-02f, 1.37713492e-01f, 9.45384428e-02f, 1.28987446e-01f, 1.47574246e-01f, 1.24226756e-01f, 1.59205690e-01f, 1.35149032e-01f,
  -2.01509967e-02f, -1.18743509e-01f, -1.13482855e-01f, -6.95559457e-02f, -5.79138212e-02f, -3.80754098e-03f, -5.54552227e-02f, -2.66682170e-02f, -8.01732987e-02f, -9.03559476e-02f,
  -7.34772533e-02f, 5.58886328e-04f, 1.43275391e-02f, 5.07686241e-03f, -2.29049176e-02f, -1.18837498e-01f, -1.34965539e-01f, -1.63980186e-01f, -1.04555134e-02f, -4.49287593e-02f,
  -1.83910608e-01f, -1.99185967e-01f, -1.73643634e-01f, -1.94647685e-01f, -5.30816168e-02f, -2.21390024e-01f, -1.55401990e-01f, -1.64323211e-01f, -1.47274181e-01f, -2.31532708e-01f,
  -2.92426258e-01f, -2.62772113e-01f, 5.87965809e-02f, 3.81265245e-02f, 2.51283318e-01f, 3.11772704e-01f, 1.16324410e-01f, 5.11011146e-02f, 1.05649374e-01f, -1.88655909e-02f,
  1.31628728e-02f, 1.51854947e-01f, 8.27355012e-02f, 8.68673995e-02f, 1.10051341e-01f, -4.20802366e-03f, 7.00026080e-02f, 2.29183789e-02f, 1.59882307e-01f, 1.77952722e-01f,
  2.51941010e-02f, -7.36628547e-02f, 3.67324837e-02f, 1.34859815e-01f, 1.14963777e-01f, 1.68359265e-01f, 9.70074907e-02f, 1.80113852e-01f, 1.31406203e-01f, -1.90099515e-02f,
  2.43495151e-01f, -2.54940502e-02f, 1.65431783e-01f, 1.11937031e-01f, 7.64040425e-02f, 1.57597456e-02f, 9.70175192e-02f, 1.21062919e-01f, 7.24088699e-02f, 1.35950938e-01f,
  1.40753061e-01f, 2.29853368e-03f, 1.25111882e-02f, 1.00453749e-01f, 1.34525701e-01f, 1.08329572e-01f, 2.39452180e-02f, 5.74234091e-02f, 6.43420443e-02f, 5.41927181e-02f,
  1.33208737e-01f, 1.13979317e-01f, 5.55495955e-02f, 1.09487861e-01f, 1.27823979e-01f, 1.23255320e-01f, 7.31931403e-02f, 1.97068721e-01f, 1.51958466e-01f, -4.61889096e-02f,
  2.87209991e-02f, -6.65857792e-02f, -2.77401414e-02f, -1.44036204e-01f, -5.47522269e-02f, -4.84009571e-02f, -3.00919283e-02f, -1.39074638e-01f, -1.19414918e-01f, -8.43894109e-02f,
  -9.65398997e-02f, -9.70873982e-02f, -1.33541435e-01f, -1.39803588e-01f, -7.47551322e-02f, -1.48159757e-01f, -4.84955907e-02f, -1.86445788e-01f, -1.51759461e-01f, -1.40981346e-01f,
  -8.43776315e-02f, -7.25028291e-02f, -4.31846194e-02f, -1.18559696e-01f, -1.81578025e-01f, -1.17897592e-01f, -1.87275916e-01f, -1.39702693e-01f, -1.76644579e-01f, -7.44268522e-02f,
  1.77718312e-01f, 1.55758545e-01f, 1.14480048e-01f, 5.80909215e-02f, 2.50646416e-02f, 1.63284034e-01f, 8.04031566e-02f, 1.30997181e-01f, 3.59649584e-02f, 1.69797316e-01f,
  1.71690419e-01f, -6.52820710e-03f, 1.28393784e-01f, 2.00547844e-01f, 9.50834081e-02f, 1.68559238e-01f, 1.82593949e-02f, 1.83269098e-01f, 1.62591472e-01f, 1.75108314e-01f,
  2.97924206e-02f, 1.57295600e-01f, 6.81519061e-02f, 2.43311629e-01f, 2.34165132e-01f, 1.26136422e-01f, 1.79093331e-01f, 1.29779950e-01f, 2.06446230e-01f, -1.58694852e-02f,
  -1.35423750e-01f, -2.85678118e-01f, 9.82232466e-02f, -1.26579583e-01f, 1.83783337e-01f, 1.77999422e-01f, 2.31239945e-01f, 8.96692872e-02f, -1.34456642e-02f, -1.44161731e-01f,
  -9.92765948e-02f, 1.32953152e-01f, 4.07272018e-02f, 1.07456900e-01f, 2.09680572e-01f, -7.19285756e-03f, 1.80253386e-01f, 1.82623371e-01f, 3.60423863e-01f, 1.52049333e-01f,
  8.94970354e-03f, -1.69773385e-01f, 1.10069441e-03f, 7.34636262e-02f, -1.37946650e-01f, 2.69026421e-02f, -1.98293760e-01f, -1.06894061e-01f, 7.47514293e-02f, -2.12325975e-01f,
  -7.23010600e-02f, 7.28831440e-03f, 1.35169223e-01f, 4.68991958e-02f, -6.96442127e-02f, -1.09213572e-02f, 8.19264352e-02f, 7.75700286e-02f, -4.53468226e-02f, -1.38918115e-02f,
  -6.65081143e-02f, 3.45565788e-02f, 1.09186936e-02f, 3.88593413e-02f, 8.59497711e-02f, 6.85209874e-04f, 2.38597021e-03f, 1.88863501e-02f, 1.35094717e-01f, 1.13765359e-01f,
  2.54990123e-02f, 5.04108854e-02f, 7.64928013e-02f, 9.16911438e-02f, 7.89518803e-02f, 1.42376959e-01f, 1.74292903e-02f, -3.60484906e-02f, 1.18042409e-01f, -1.45801142e-01f,
  -5.33560887e-02f, -4.07051519e-02f, -2.24230308e-02f, -1.65682789e-02f, -7.71940127e-02f, 2.46393047e-02f, -8.47444520e-04f, -9.21357498e-02f, 3.43018323e-02f, -2.95997206e-02f,
  -2.06453558e-02f, 5.32125905e-02f, -9.67608858e-03f, -1.04627842e-02f, -6.22601360e-02f, 3.40199694e-02f, -2.58951094e-02f, -2.79681347e-02f, 5.03174076e-03f, -5.16778044e-02f,
  5.95060410e-04f, 1.89019106e-02f, -1.18541367e-01f, -8.78260564e-03f, -1.58334207e-02f, 6.86856285e-02f, 5.97311556e-03f, -8.72602314e-03f, -8.43959600e-02f, 3.20455321e-04f,
  -2.59656787e-01f, 1.71254337e-01f, 1.07331537e-02f, 5.01309037e-02f, 3.14457491e-02f, 7.62843713e-02f, -5.58028482e-02f, -2.55963746e-02f, -2.96426564e-02f, 1.35355992e-02f,
  2.77595110e-02f, 9.21832696e-02f, -5.62764779e-02f, 3.20633315e-02f, 1.83824275e-03f, 5.06897718e-02f, -9.25948620e-02f, 6.38479292e-02f, 7.53631145e-02f, -6.84392080e-02f,
  -4.92373593e-02f, 1.74758751e-02f, 4.36376035e-02f, -2.48153042e-02f, 1.11652888e-01f, 1.09054849e-01f, -4.44964021e-02f, 1.86832901e-02f, 1.44421145e-01f, -9.29443762e-02f,
  3.70458007e-01f, 2.03104734e-01f, 1.36669710e-01f, 2.06642866e-01f, 1.99824825e-01f, 2.11552292e-01f, 8.95930007e-02f, 7.35303164e-02f, 1.63108349e-01f, 1.53266326e-01f,
  8.51836726e-02f, 2.05668010e-04f, 8.44570901e-03f, -9.75369010e-03f, 5.05069569e-02f, 3.02432537e-01f, 1.82767063e-01f, 7.91482553e-02f, 7.88456127e-02f, 1.21594600e-01f,
  1.65954709e-01f, 2.10249454e-01f, 1.97827503e-01f, 1.78665206e-01f, 2.60696411e-02f, 7.01394081e-02f, 1.25738725e-01f, 1.29735619e-01f, 9.29996669e-02f, 9.40501466e-02f,
  -1.74629670e-02f, 6.20694198e-02f, 3.65750566e-02f, 4.34553847e-02f, 1.16599418e-01f, -4.95834462e-03f, -4.71133739e-02f, -4.27796431e-02f, -1.46156466e-02f, -1.05579970e-02f,
  1.88928694e-02f, -3.82398404e-02f, 7.55931064e-02f, -6.67522028e-02f, 6.71320036e-02f, -6.74738511e-02f, 3.03956997e-02f, 8.91416073e-02f, 1.41016431e-02f, -5.28143793e-02f,
  1.53731918e-02f, 2.61622109e-02f, -8.36428069e-03f, 2.65927762e-02f, 7.49938563e-02f, 4.39797668e-03f, -3.83713059e-02f, 8.67814124e-02f, 7.05803186e-02f, 1.43606871e-01f,
  4.26105643e-03f, -2.03584712e-02f, -4.56904173e-02f, -5.47771156e-02f, -6.48356825e-02f, -5.11948578e-02f, -1.08831063e-01f, 2.92205717e-03f, -5.99413645e-04f, -1.16424337e-01f,
  1.61954726e-03f, -6.36689886e-02f, -9.03262272e-02f, -4.02623862e-02f, -8.89947265e-02f, -3.06721427e-03f, 5.76281035e-03f, 3.27804163e-02f, -7.52859637e-02f, -2.31713187e-02f,
  -9.54035521e-02f, -3.01325694e-02f, -1.44568579e-02f, -1.13153011e-01f, -1.13106273e-01f, -9.29156877e-03f, -7.92268142e-02f, -2.75206286e-02f, -3.88689861e-02f, 3.77722345e-02f,
  -1.16062813e-01f, 3.32020782e-02f, 5.32358438e-02f, -2.44585145e-03f, 5.54930903e-02f, 1.11043520e-01f, 1.08098052e-01f, 1.25683129e-01f, -2.42610611e-02f, 1.21106654e-01f,
  6.25149831e-02f, -7.85924215e-03f, 5.89632280e-02f, 5.97571321e-02f, 1.09188206e-01f, 5.12285419e-02f, 4.88261543e-02f, 1.41489699e-01f, 6.08677082e-02f, 1.79299694e-02f,
  9.79866609e-02f, 6.11898191e-02f, 7.03429745e-04f, -4.37609013e-03f, -2.64023915e-02f, 1.02014065e-01f, 7.00533539e-02f, -1.77250020e-02f, 7.62934834e-02f, 2.41160914e-01f,
  8.59906226e-02f, 3.59758511e-02f, -3.17887247e-01f, 9.70172957e-02f, 1.38200998e-01f, 1.43463582e-01f, 1.21216394e-01f, 2.17540488e-01f, 2.03583464e-01f, 2.07518548e-01f,
  1.24902189e-01f, 2.44273663e-01f, 1.57328561e-01f, 1.90376788e-01f, 4.91244234e-02f, 6.59090653e-02f, -5.79951257e-02f, -1.69132724e-01f, 8.20507407e-02f, 1.16069973e-01f,
  2.61752069e-01f, 1.38842240e-01f, 9.38748419e-02f, 2.07003996e-01f, 9.14205089e-02f, 1.47374924e-02f, 1.09731210e-02f, 8.77497345e-03f, 5.66604771e-02f, -9.68077332e-02f,
  -2.74565727e-01f, 2.77469903e-02f, 1.11320831e-01f, 2.50851095e-01f, 5.02775088e-02f, 5.08950464e-02f, 1.13373876e-01f, 2.59505808e-02f, 1.32271647e-01f, 1.36645466e-01f,
  8.34531859e-02f, 8.31781328e-02f, 5.75796643e-04f, 1.81676462e-01f, 2.08731666e-02f, 4.11048569e-02f, 6.86527342e-02f, 1.77405868e-02f, 8.12376849e-03f, 1.90382645e-01f,
  2.14425400e-01f, 1.72743753e-01f, -2.44967211e-02f, 9.89350006e-02f, 1.49901778e-01f, 1.87036067e-01f, 9.96339321e-02f, 2.43385285e-02f, 1.23104684e-01f, 6.13273606e-02f,
  4.70375456e-03f, -2.38947384e-02f, -5.36068343e-02f, -3.41075025e-02f, -5.79499826e-02f, -1.20193902e-02f, -5.57901151e-02f, 1.27354998e-03f, 8.51560291e-03f, -2.44805645e-02f,
  -8.89602005e-02f, -1.72610823e-02f, -3.97379659e-02f, 1.71298441e-02f, -8.85152817e-02f, -1.40098646e-01f, -8.28891471e-02f, -3.71104665e-02f, -4.53526601e-02f, -1.64308190e-01f,
  9.93095990e-03f, -1.20573930e-01f, -2.87839286e-02f, -2.87620798e-02f, -1.96267050e-02f, -9.96108353e-03f, 2.12129597e-02f, -5.57428831e-03f, 7.09909014e-03f, -5.69740087e-02f,
  -5.03532104e-02f, 1.01808675e-01f, -4.00995649e-02f, 5.49755022e-02f, 4.71754037e-02f, 1.31566212e-01f, 1.94956176e-02f, 7.50689432e-02f, 2.32199542e-02f, -1.53416255e-02f,
  -1.72791875e-03f, 1.11515649e-01f, 9.24714506e-02f, 1.37261882e-01f, 1.15419082e-01f, 2.34163329e-02f, 1.45887271e-01f, 3.99308950e-02f, 8.62628147e-02f, 1.33376587e-02f,
  1.01432338e-01f, 1.50004193e-01f, 5.05840592e-02f, 1.33702621e-01f, 1.24463495e-02f, 6.12691324e-03f, 3.22835594e-02f, 8.32540989e-02f, -5.84973581e-02f, 6.30733818e-02f,
  -1.21433370e-01f, 4.77878191e-03f, -1.41284928e-01f, -2.45986342e-01f, -1.99665040e-01f, -9.61861014e-02f, -4.82042544e-02f, -4.18947935e-02f, -2.23591417e-01f, -3.95471640e-02f,
  -1.45845011e-01f, -6.78808913e-02f, -1.47767469e-01f, -1.01296445e-02f, -5.27605675e-02f, 3.61360908e-02f, 3.39201875e-02f, -1.21709697e-01f, -1.36742577e-01f, -1.22546770e-01f,
  -7.96015710e-02f, -8.61131400e-02f, -1.30488679e-01f, -1.74603939e-01f, -2.01410353e-01f, -1.72744229e-01f, -2.01392382e-01f, -2.80471444e-01f, -1.32962033e-01f, -1.99793845e-01f,
  -5.47484048e-02f, -2.57743627e-01f, -1.21102303e-01f, -1.91549584e-01f, -7.01979324e-02f, -1.27319306e-01f, -1.63600937e-01f, -1.36168465e-01f, -1.51325241e-01f, -1.60951331e-01f,
  -1.19106516e-01f, -1.56302154e-01f, -2.35463321e-01f, -1.28359318e-01f, -1.45217806e-01f, -2.25318059e-01f, -7.04636797e-02f, -1.70171604e-01f, -1.66814148e-01f, -5.51266596e-02f,
  -1.91203207e-01f, -1.30274862e-01f, -1.44141898e-01f, -4.70274277e-02f, -1.99548602e-01f, -1.94866750e-02f, -8.41232166e-02f, -1.96332261e-01f, -2.69891582e-02f, -2.03149736e-01f,
  1.96859892e-02f, 7.30058104e-02f, 1.57138146e-02f, -4.36252318e-02f, -6.22752449e-03f, -8.60401988e-02f, -7.21523017e-02f, 5.29457666e-02f, 6.41097724e-02f, 9.99859720e-03f,
  -3.12086567e-02f, 5.53749911e-02f, -1.09580822e-01f, 8.39501396e-02f, 2.10403465e-02f, 4.04344462e-02f, 1.57863963e-02f, 1.10979177e-01f, 2.43432857e-02f, 9.73201636e-03f,
  4.67226058e-02f, -3.79071794e-02f, 5.96103147e-02f, 7.05142319e-02f, 5.58953360e-02f, 1.10398233e-01f, 2.11805832e-02f, 1.83313973e-02f, -5.76838814e-02f, -2.78092064e-02f,
  -4.31883968e-02f, 7.23419636e-02f, -1.62299555e-02f, -1.74993709e-01f, -1.19773686e-01f, -1.88307285e-01f, -5.90303056e-02f, -9.56780761e-02f, -1.66108966e-01f, -1.26818568e-01f,
  -1.66479498e-01f, -7.54566640e-02f, -1.51667863e-01f, -1.29110754e-01f, -1.45196855e-01f, -5.03242537e-02f, -6.36737037e-04f, -7.50919133e-02f, -7.52962381e-02f, -8.93616006e-02f,
  -1.62687562e-02f, -3.49597931e-02f, 5.68216592e-02f, -1.09667346e-01f, -9.26225781e-02f, -8.68658796e-02f, -2.43115239e-02f, -1.31723508e-01f, 2.26203948e-02f, -5.50487898e-02f,
  -3.43932122e-01f, -2.25965865e-02f, 1.35047331e-01f, -1.39298424e-01f, -5.03200181e-02f, 1.62519187e-01f, 1.41967982e-01f, -2.94084884e-02f, -1.07746333e-01f, -4.66881394e-02f,
  -2.27373630e-01f, -1.66140079e-01f, -1.60037875e-01f, -1.43109793e-02f, -2.47398615e-02f, 1.11954100e-01f, 9.49147567e-02f, 7.49099329e-02f, 7.85171613e-02f, 6.86348379e-02f,
  -1.52716599e-02f, 1.02760075e-02f, -6.10168204e-02f, 7.33025670e-02f, -6.04448169e-02f, -4.30944599e-02f, -4.30234596e-02f, 3.34329233e-02f, 1.27618477e-01f, 1.53960764e-01f,
  -6.14898205e-02f, -2.32070848e-01f, -6.08509667e-02f, -1.76686093e-01f, -1.78537071e-01f, -3.36320698e-02f, -4.32508327e-02f, -1.13773018e-01f, -5.99142164e-02f, -1.44545520e-02f,
  -4.14456539e-02f, -8.99094716e-03f, -8.81462693e-02f, 4.79931422e-02f, -4.54059094e-02f, 3.31651904e-02f, -6.87208995e-02f, -6.55840412e-02f, -2.95416713e-02f, -1.10913925e-01f,
  4.52566706e-02f, 1.61389075e-02f, 1.75788030e-02f, -5.72928824e-02f, 2.35314537e-02f, -8.61016586e-02f, -1.16069503e-01f, 8.32258316e-04f, -1.37620553e-01f, -4.02039178e-02f,
  -3.25484872e-02f, 9.49314833e-02f, 6.15922511e-02f, 5.43542467e-02f, 1.36550337e-01f, 1.31535247e-01f, 6.97914436e-02f, 1.20252997e-01f, 9.39842537e-02f, 1.16379887e-01f,
  8.93356428e-02f, 2.49327552e-02f, 1.16843075e-01f, 2.40007862e-02f, 5.42824902e-02f, 1.47622481e-01f, 1.32332817e-01f, 1.46640465e-01f, 1.42445967e-01f, 5.62612712e-02f,
  1.08848117e-01f, 1.65215313e-01f, 4.42430750e-02f, 1.19783238e-01f, 6.91130087e-02f, 6.78166822e-02f, 7.81511590e-02f, 1.11893907e-01f, 1.08719252e-01f, 1.61974996e-01f,
  -2.20366716e-01f, -2.38388970e-01f, -6.42525554e-02f, -3.35573144e-02f, -8.99859890e-02f, -1.10834993e-01f, -4.38857190e-02f, -7.03807995e-02f, -1.01357818e-01f, -9.97551903e-02f,
  -1.72470629e-01f, -2.54009236e-02f, -6.19914159e-02f, -3.38124251e-03f, 1.08926287e-02f, -1.18312240e-01f, -5.74292056e-02f, -8.75684917e-02f, 1.11100990e-02f, -7.40329251e-02f,
  -4.31526862e-02f, 5.03362827e-02f, -4.20372114e-02f, -2.64260639e-02f, -7.55166169e-03f, -9.91946757e-02f, 3.89909633e-02f, -2.26413347e-02f, 3.34945805e-02f, -2.97999233e-02f,
  3.48796137e-02f, -2.06332996e-01f, -1.35022759e-01f, 4.22844961e-02f, 1.14321388e-01f, 1.06967971e-01f, 1.24570668e-01f, 3.85193489e-02f, 6.72909394e-02f, 1.80562232e-02f,
  -7.82636832e-03f, -3.61800976e-02f, -7.41557404e-02f, -5.61406948e-02f, 1.51946386e-02f, -6.41305149e-02f, 1.70882139e-02f, -7.19726458e-02f, -6.26418814e-02f, -1.00808106e-01f,
  -4.34638001e-02f, -1.17312938e-01f, -8.69502202e-02f, -1.80973694e-01f, -6.92905262e-02f, -7.65128434e-02f, -2.25196168e-01f, -1.38704136e-01f, -1.99675545e-01f, -2.79460549e-01f,
  -3.02072108e-01f, -2.45645538e-01f, -3.86378765e-02f, -1.67756662e-01f, -1.81964517e-01f, -1.91049561e-01f, -3.78666036e-02f, -1.59720123e-01f, -1.43632159e-01f, -1.44219175e-01f,
  -9.69828293e-02f, -1.34329543e-01f, -1.18524611e-01f, -8.97839889e-02f, -1.55846685e-01f, -1.83884352e-01f, -2.90638078e-02f, -8.46537128e-02f, -8.39005560e-02f, -1.27555683e-01f,
  5.17792534e-03f, -1.43542007e-01f, 5.83011005e-03f, -1.42834425e-01f, -1.82540223e-01f, -3.57506648e-02f, -1.12658262e-01f, -2.62677938e-01f, -1.30730882e-01f, -1.58030048e-01f,
  1.14923351e-01f, 1.54674985e-02f, 7.02356026e-02f, 5.94351962e-02f, 1.72405347e-01f, 1.45255566e-01f, 9.80025455e-02f, 4.58415523e-02f, 6.60872757e-02f, 1.32316932e-01f,
  8.15842524e-02f, 1.50175661e-01f, 1.31226003e-01f, -1.02054421e-02f, 1.36996016e-01f, 7.39196688e-02f, 2.23576576e-02f, 3.66089679e-02f, 8.38808939e-02f, 8.30360800e-02f,
  7.76707157e-02f, 1.25663474e-01f, 1.10836707e-01f, 9.28379372e-02f, 1.15194924e-01f, 8.40955302e-02f, 1.64485928e-02f, 1.01242252e-01f, 2.78955530e-02f, 4.92001846e-02f,
  -6.96130916e-02f, -6.39126375e-02f, -1.73587367e-01f, -3.75525989e-02f, -1.12662695e-01f, -6.14500754e-02f, -1.38031602e-01f, -1.46850213e-01f, -1.76389620e-01f, -1.25438556e-01f,
  -1.04714692e-01f, -1.34054661e-01f, -8.96191522e-02f, -1.85057819e-01f, -6.17395751e-02f, -2.14625634e-02f, -5.65016717e-02f, -3.39402072e-02f, -4.48734201e-02f, -1.03449561e-01f,
  -8.78623649e-02f, 3.46779674e-02f, 2.86078192e-02f, 6.36889562e-02f, -8.87563080e-02f, 4.37374152e-02f, -1.56849250e-01f, -2.18945043e-03f, -5.65303229e-02f, 7.84643367e-02f,
  1.12124503e-01f, -7.22561330e-02f, 1.58807054e-01f, 3.85425548e-04f, -1.07865058e-01f, 1.36866957e-01f, 1.08772062e-01f, 1.25431165e-01f, 6.52803555e-02f, -8.55970941e-03f,
  -1.65995881e-02f, -2.64055971e-02f, 5.58471791e-02f, 9.55161005e-02f, -2.40320945e-03f, -1.03020214e-01f, -8.62161443e-02f, -2.09723711e-02f, 1.18892565e-01f, 3.76664742e-04f,
  -1.02896005e-01f, -1.56892017e-01f, -5.06596230e-02f, -1.74525619e-01f, -2.87958920e-01f, -1.95650980e-01f, -1.27455235e-01f, -6.70647025e-02f, -2.29559228e-01f, -3.26728791e-01f,
  5.68043999e-02f, -2.47972030e-02f, -5.41090593e-02f, -1.63119689e-01f, -1.04662977e-01f, -1.69802234e-02f, -6.37818053e-02f, -2.67553125e-02f, 1.29720327e-02f, -1.11577600e-01f,
  2.07014252e-02f, -7.92237148e-02f, -9.21280533e-02f, -1.30904317e-01f, -4.72913533e-02f, -3.02786147e-03f, -2.17452962e-02f, -8.17424804e-03f, -5.18516079e-02f, -7.90994465e-02f,
  -2.28043050e-01f, -1.98390439e-01f, -1.88200772e-02f, -5.34135252e-02f, 4.92697954e-02f, 4.26023640e-02f, -1.36204496e-01f, -1.82457864e-01f, 2.24067476e-02f, -2.45561957e-01f,
  -3.64639573e-02f, 1.63250801e-03f, 3.22821476e-02f, -2.91891303e-02f, 7.58274943e-02f, -3.56331542e-02f, -1.16884755e-03f, 8.47608782e-03f, -3.70543823e-02f, 7.67083839e-02f,
  4.53692973e-02f, 2.04754304e-02f, 9.46432203e-02f, 5.43473102e-03f, -5.17991856e-02f, -4.42231596e-02f, -2.19534934e-02f, -4.63660210e-02f, 4.10408713e-02f, 1.69532299e-02f,
  4.28272923e-03f, 1.80055052e-02f, 3.85976881e-02f, -4.19992246e-02f, 1.78488195e-02f, 2.53486149e-02f, 7.62352794e-02f, 6.26828894e-02f, 1.51786745e-01f, 1.61387690e-03f,
  1.07675843e-01f, 1.12308413e-01f, -1.75502393e-02f, -1.19077057e-01f, -6.83844164e-02f, -4.46425602e-02f, -2.87673213e-02f, -8.43780786e-02f, -1.17425118e-02f, -5.82460724e-02f,
  -2.82545965e-02f, 4.92174774e-02f, 1.15052667e-02f, -1.39569089e-01f, -3.65552120e-02f, -1.22113220e-01f, -1.76495597e-01f, -9.55949202e-02f, -1.05224863e-01f, -2.11864971e-02f,
  -1.78903446e-01f, 2.17543039e-02f, 4.61954512e-02f, 6.39909972e-03f, -1.17769204e-02f, 9.05592218e-02f, 2.05578897e-02f, -1.67404264e-02f, -1.25835659e-02f, -1.04602858e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.97689050e-01f, 5.89299314e-02f, 8.88814107e-02f, 7.40282238e-02f, -3.99738997e-02f, 2.43662428e-02f, 4.68323417e-02f, 1.22939423e-01f, 1.61900878e-01f, 3.86099219e-02f,
  -2.91841151e-03f, -4.80151847e-02f, -4.97778505e-02f, 6.77295923e-02f, -4.83195186e-02f, 1.56322449e-01f, 8.84475335e-02f, -5.14178276e-02f, -8.16305075e-03f, -4.16557640e-02f,
  9.61648077e-02f, 1.02347635e-01f, -1.75384786e-02f, 1.29497588e-01f, 1.91029862e-01f, -1.11823708e-01f, 2.78916378e-02f, -3.65589857e-02f, 9.99918878e-02f, 1.88323781e-01f,
  8.24043974e-02f, -5.05071208e-02f, -7.39404410e-02f, -6.52838778e-03f, 1.05578750e-01f, 1.64452687e-01f, 9.73594412e-02f, 5.87800257e-02f, 1.58070520e-01f, 1.92531481e-01f,
  1.44705206e-01f, -2.24543922e-02f, 2.23849919e-02f, -2.63768397e-02f, 1.46765023e-01f, -4.94747143e-03f, 1.30969957e-01f, 5.31183630e-02f, 1.02259740e-01f, 5.37082702e-02f,
  -1.31754167e-02f, -5.48607372e-02f, 3.48207131e-02f, -4.23029847e-02f, -1.11655835e-02f, 6.51895329e-02f, 8.50708783e-03f, 4.20410261e-02f, 2.59296484e-02f, -9.94438455e-02f,
  1.78310350e-01f, 1.37419954e-01f, -7.14771971e-02f, -1.93120822e-01f, -7.80303404e-02f, -8.06880277e-03f, 4.14671637e-02f, 2.18396429e-02f, -9.34089273e-02f, -2.01154519e-02f,
  2.97990274e-02f, -1.13333844e-01f, -1.01225287e-01f, 3.37458402e-03f, -5.03382413e-03f, 6.52218005e-04f, -6.84451386e-02f, 3.29036452e-02f, 4.08771634e-03f, 4.44134464e-03f,
  -7.36012235e-02f, 1.07017875e-01f, 8.28978419e-02f, 6.42993227e-02f, 1.70760334e-01f, 4.38401811e-02f, 8.71046036e-02f, -8.00114684e-03f, 5.91762178e-02f, -3.59595865e-02f,
  1.53946429e-01f, -2.61785746e-01f, -1.00885019e-01f, -4.64698970e-02f, 5.28275259e-02f, 1.51976705e-01f, -2.84472685e-02f, -5.48196994e-02f, 1.82536636e-02f, 7.10404590e-02f,
  -9.65530891e-03f, 3.39157656e-02f, -3.35996300e-02f, 2.38078572e-02f, -2.83276048e-02f, 3.25422063e-02f, 2.03307513e-02f, 6.11387230e-02f, 6.50528371e-02f, 2.18398422e-01f,
  6.84526190e-02f, 2.70204116e-02f, 4.64705983e-03f, 4.82533798e-02f, 3.06550087e-03f, -2.48187184e-02f, -7.54232481e-02f, 9.43317562e-02f, -7.65256882e-02f, 5.89870065e-02f,
  2.47371554e-01f, 6.63816258e-02f, -3.82547289e-01f, 3.23566645e-01f, -2.29347706e-01f, -4.55051512e-01f, -6.15438223e-01f, -3.35139751e-01f, 1.30224362e-01f, -4.68146801e-02f,
  1.22597599e-02f, 8.37863889e-03f, -1.39336333e-01f, -2.56882519e-01f, -3.83646905e-01f, -1.92181990e-01f, -1.04063958e-01f, -1.82937518e-01f, -3.82493734e-01f, 2.22738590e-02f,
  1.88871339e-01f, 3.01462084e-01f, 3.54440808e-01f, 1.01291493e-01f, 3.66932750e-01f, 1.94978267e-01f, 1.77010700e-01f, 2.46860325e-01f, -1.75395031e-02f, 3.20506990e-01f,
  6.70511648e-02f, 1.41842991e-01f, -2.46131480e-01f, 2.37120435e-01f, 8.34828839e-02f, -8.41381252e-02f, -1.56823203e-01f, 2.09303153e-06f, -2.92768866e-01f, -1.30872980e-01f,
  -1.45357057e-01f, -1.14113465e-02f, -1.05781481e-01f, -2.79564857e-02f, 3.15162688e-01f, -2.28203446e-01f, 1.79914758e-01f, -1.31897867e-01f, -3.04342538e-01f, -3.15746479e-02f,
  -9.97434184e-02f, 4.03865270e-04f, -1.91832185e-01f, -2.84146577e-01f, -2.38247126e-01f, -1.63243756e-01f, -3.10693204e-01f, -1.44275829e-01f, -2.57156163e-01f, 1.48160756e-01f,
  -3.30164842e-02f, 7.81593695e-02f, -7.13940486e-02f, 7.30910078e-02f, 6.35922328e-03f, 4.75582704e-02f, 5.58045432e-02f, 7.41986483e-02f, -1.15600459e-01f, -1.22160420e-01f,
  -1.29984599e-02f, -1.30751103e-01f, -7.33685195e-02f, -5.16788550e-02f, -5.97248003e-02f, 7.40742981e-02f, -7.72684664e-02f, 5.44363894e-02f, -8.60761479e-03f, 4.28752266e-02f,
  9.32708010e-03f, -1.05151944e-01f, 1.17663875e-01f, -5.49256951e-02f, 1.12683866e-02f, -9.11750793e-02f, -6.58060089e-02f, -5.27546331e-02f, -4.75686714e-02f, 7.35614896e-02f,
  2.82020986e-01f, -1.91658273e-01f, 5.11508211e-02f, 2.91569326e-02f, -3.75080258e-02f, 9.22535062e-02f, 1.19003735e-01f, -1.31496117e-01f, -1.14165001e-01f, -1.26805484e-01f,
  -2.78172523e-01f, -2.39962101e-01f, 9.94168520e-02f, -8.31645429e-02f, -1.08607210e-01f, -1.68414876e-01f, 1.01049744e-01f, -1.41961470e-01f, -1.12082474e-01f, 9.02522877e-02f,
  -9.37176123e-02f, -7.18779340e-02f, -8.34377632e-02f, -3.86750013e-01f, -1.15757838e-01f, -2.27896571e-01f, -2.35602826e-01f, -1.56294301e-01f, -4.52383667e-01f, -1.76090762e-01f,
  5.67859888e-01f, 1.91567793e-01f, 7.30082914e-02f, 1.68672830e-01f, 8.38362724e-02f, 8.92603621e-02f, 3.15828264e-01f, 1.02428928e-01f, 5.50116710e-02f, 7.76118636e-02f,
  -2.99501598e-01f, -3.09266537e-01f, -2.29324326e-01f, -3.44557106e-01f, -6.80690482e-02f, 1.01816081e-01f, 1.73059970e-01f, 1.66242477e-02f, -7.38847181e-02f, 9.09276400e-03f,
  1.17108360e-01f, 3.36808801e-01f, 1.50373608e-01f, 1.56990126e-01f, 4.32084464e-02f, -7.50202313e-02f, 8.41811672e-02f, 7.35321119e-02f, 2.75031719e-02f, 1.79945044e-02f,
  -3.66079479e-01f, 1.64864495e-01f, -6.68274462e-02f, -6.10750727e-02f, -1.51142627e-01f, 3.06393262e-02f, -6.59570321e-02f, 3.38636339e-02f, -2.27451380e-02f, 1.09828323e-01f,
  -1.05466500e-01f, -3.00281625e-02f, -1.97458029e-01f, -1.22758538e-01f, 4.68229651e-02f, -2.58933157e-02f, 1.13177048e-02f, -4.96347919e-02f, -1.98415026e-01f, -1.27648592e-01f,
  -2.13333994e-01f, -6.58567622e-03f, 1.06674038e-01f, -8.62972215e-02f, -5.82721680e-02f, -1.75383270e-01f, -7.31019378e-02f, -1.13575226e-02f, -1.25292256e-01f, 1.19658507e-01f,
  -8.35268423e-02f, 4.54850681e-02f, -3.25097106e-02f, 9.91739035e-02f, 3.92702445e-02f, -4.08319123e-02f, 2.88552754e-02f, -8.40331241e-02f, 3.54479179e-02f, 1.57215729e-01f,
  7.79334158e-02f, -9.60311517e-02f, -9.63965431e-02f, 5.02909608e-02f, 2.29500458e-02f, -4.26390618e-02f, -9.25292168e-03f, 1.28517039e-02f, -2.49600764e-02f, -4.95498963e-02f,
  -8.01145658e-03f, 7.20582576e-03f, -6.13748804e-02f, 8.13047215e-03f, -5.73020577e-02f, 6.95908964e-02f, -6.57223091e-02f, -6.60498887e-02f, -9.60594695e-03f, 2.30196174e-02f,
  1.17845992e-02f, -3.66748005e-01f, -6.91589862e-02f, -6.77410364e-02f, -6.06042296e-02f, -2.46147308e-02f, -1.69701099e-01f, -1.88229546e-01f, -5.59129193e-02f, 3.59082855e-02f,
  -1.26225859e-01f, -7.78483972e-02f, -2.74794716e-02f, -1.96947213e-02f, 8.05812553e-02f, 8.27201381e-02f, 2.99461801e-02f, -1.42990109e-02f, -7.15399608e-02f, -7.75042847e-02f,
  6.88595995e-02f, 1.77708581e-01f, 8.11008364e-02f, 6.57748803e-03f, -2.80378368e-02f, -9.33046713e-02f, 4.68503237e-02f, 1.22421972e-01f, -4.73843925e-02f, 3.15472662e-01f,
  -3.19070965e-01f, 6.72790170e-01f, 3.55953336e-01f, -3.69018704e-01f, 1.95203781e-01f, 4.42680329e-01f, 5.92737496e-01f, 1.73676521e-01f, -7.92122707e-02f, 2.97550887e-01f,
  3.58193219e-01f, -2.59921223e-01f, 2.71225292e-02f, -6.20102957e-02f, 2.16743089e-02f, 3.25050712e-01f, 1.90587834e-01f, -3.53287399e-01f, -3.22676212e-01f, -2.13824108e-01f,
  -1.79923177e-01f, -2.44806379e-01f, -3.80000621e-01f, -3.05690289e-01f, -1.23830795e-01f, -2.97875553e-01f, 5.79793900e-02f, -3.64756696e-02f, 2.70568371e-01f, -2.36881942e-01f,
  -1.10484459e-01f, 3.90700907e-01f, -1.43141314e-01f, -1.02347545e-01f, 1.27296865e-01f, -1.90717742e-01f, -3.34082209e-02f, -8.52035135e-02f, -5.35027012e-02f, -1.78623851e-02f,
  3.86954728e-03f, -8.96767974e-02f, 7.02099651e-02f, -4.43597063e-02f, -6.79302439e-02f, 2.57944521e-02f, -1.24375328e-01f, -1.66155696e-01f, -1.90538436e-01f, -8.22752938e-02f,
  2.33577518e-03f, -4.63041104e-02f, 1.57233223e-01f, -3.46898586e-02f, -4.64785434e-02f, -3.06415111e-01f, 1.44399330e-01f, -3.59700263e-01f, -1.66363399e-02f, -4.32143748e-01f,
  -1.65737405e-01f, 6.50613457e-02f, 8.41455534e-02f, -3.17376480e-02f, -8.15712661e-02f, 3.02709028e-04f, -1.84903909e-02f, 8.49703152e-04f, -8.61188322e-02f, -1.33993343e-01f,
  4.39052060e-02f, -5.14453202e-02f, 4.98435413e-03f, 1.73812270e-01f, -1.00546479e-01f, 2.44059302e-02f, 1.22344997e-02f, 1.19973850e-02f, 2.82598920e-02f, -7.18937740e-02f,
  2.79934499e-02f, 3.38898115e-02f, -1.06750183e-01f, -1.16548747e-01f, 5.93201481e-02f, 4.59652208e-02f, -1.45646453e-01f, -8.89748037e-02f, -7.37090260e-02f, 1.52426809e-01f,
  -3.11404675e-01f, 1.69341221e-01f, -3.22765201e-01f, 4.59017344e-02f, 1.86822325e-01f, 8.44844282e-02f, 1.36977181e-01f, 1.66363731e-01f, 8.23761746e-02f, 8.75122398e-02f,
  5.50485738e-02f, 8.98260474e-02f, 2.08519608e-01f, -2.95258611e-02f, -5.00206053e-02f, 2.88444385e-02f, -3.05465646e-02f, 1.95701607e-02f, -2.08447501e-01f, -1.14802703e-01f,
  -6.07613064e-02f, -2.42610693e-01f, -3.41348946e-01f, -1.07406907e-01f, -2.81653881e-01f, -2.22306535e-01f, -2.02055544e-01f, -1.48036927e-01f, -1.49690762e-01f, -4.19189632e-01f,
  -7.10013881e-02f, -2.32802480e-01f, 1.72041237e-01f, 1.33724988e-01f, 3.67089398e-02f, -1.41198963e-01f, -3.87960672e-01f, -1.83392391e-01f, -9.57229286e-02f, -9.16473418e-02f,
  -3.75692666e-01f, -2.99060732e-01f, -2.02561885e-01f, -1.75217271e-01f, -3.70829254e-01f, 8.96020979e-03f, 1.46682486e-01f, 4.44705319e-03f, -1.51349530e-01f, -2.48804107e-01f,
  -2.62683749e-01f, -3.62105407e-02f, -8.73037502e-02f, -1.45786228e-02f, 3.41556258e-02f, -6.94360211e-02f, 1.63992196e-01f, -2.34379224e-03f, -1.95778251e-01f, 1.22485990e-02f,
  -6.20932356e-02f, -6.62705898e-02f, 1.11547187e-02f, -1.06535204e-01f, -6.24092817e-02f, -1.62645385e-01f, -2.00548500e-01f, 8.41897801e-02f, 5.35656326e-03f, -6.24017008e-02f,
  -6.49880022e-02f, -1.45429090e-01f, -4.89114262e-02f, -1.41189128e-01f, -5.94803840e-02f, 1.55028282e-02f, -3.62519501e-03f, -2.26278295e-04f, -2.39027180e-02f, -1.43959418e-01f,
  -1.41174018e-01f, -6.23301305e-02f, -2.39567142e-02f, -1.70219183e-01f, -1.95543557e-01f, -3.95150222e-02f, -1.39839530e-01f, -7.92432353e-02f, -1.14246421e-02f, -9.90191475e-02f,
  -2.51684546e-01f, -2.75248706e-01f, -1.77591413e-01f, -3.97508219e-02f, -6.96166530e-02f, -1.68893814e-01f, -1.50315091e-01f, -1.86595574e-01f, -2.14793488e-01f, -9.00486335e-02f,
  -2.64991254e-01f, -8.36772770e-02f, -1.55138046e-01f, -7.97827840e-02f, -1.85625508e-01f, -1.34249479e-01f, -2.02802777e-01f, -7.08756596e-02f, -1.10663205e-01f, -9.73997116e-02f,
  -1.31053492e-01f, -7.56391361e-02f, -1.45889109e-03f, 9.76394920e-04f, -9.43691656e-02f, -1.05058067e-01f, -1.08137809e-01f, -1.97561592e-01f, -1.13513194e-01f, -3.75256427e-02f,
  -6.37985095e-02f, 3.64198387e-02f, 6.70537055e-02f, -7.27053406e-03f, 1.23884305e-01f, -4.42428440e-02f, -6.72327504e-02f, 1.11035928e-01f, 6.55994043e-02f, -8.90032500e-02f,
  3.25216651e-02f, -4.20674868e-02f, 9.04235616e-02f, 3.38783227e-02f, -6.03235848e-02f, 4.79585603e-02f, -8.32158886e-03f, 3.01834494e-02f, 5.17540087e-04f, 1.82321388e-02f,
  1.55669227e-01f, -9.24451370e-03f, 1.09278142e-01f, 1.20323464e-01f, 8.54594912e-03f, -1.99531205e-02f, 5.57477996e-02f, 7.15296119e-02f, 4.53521647e-02f, 1.39193594e-01f,
  -8.36243331e-02f, -1.76612377e-01f, -6.24970376e-01f, -2.34000131e-01f, -1.49028942e-01f, -9.68673080e-02f, 1.41353428e-01f, 1.29257068e-01f, -7.65786320e-03f, -1.06195398e-01f,
  -4.24617669e-03f, 1.08856082e-01f, -3.05113018e-01f, -5.75336218e-02f, -4.72445637e-02f, -4.11765605e-01f, -4.56808209e-01f, -2.22329184e-01f, 2.90212572e-01f, 5.60628533e-01f,
  4.10135001e-01f, 2.04922706e-01f, 1.49535298e-01f, 4.71412428e-02f, -3.81512903e-02f, -2.89055072e-02f, -3.19935769e-01f, -2.04271108e-01f, -8.66883099e-02f, -3.16355169e-01f,
  -8.19714665e-02f, -2.19897434e-01f, 3.35346069e-03f, 1.60205469e-01f, -1.02372199e-01f, 9.51454323e-03f, 2.25485846e-01f, -1.03617333e-01f, -1.28095001e-01f, -1.15812398e-01f,
  -2.43566115e-03f, 4.82597686e-02f, 2.07422953e-02f, 1.22289255e-01f, 1.31946206e-01f, 2.65689313e-01f, 4.18639295e-02f, -1.24835826e-01f, -3.18900645e-01f, -2.32256949e-03f,
  1.47596449e-01f, -1.26387581e-01f, -3.00734729e-01f, -1.74650237e-01f, -8.81960317e-02f, -2.30331406e-01f, 2.16383450e-02f, 1.25164658e-01f, -2.31497347e-01f, -1.35107622e-01f,
  7.27492943e-02f, -5.25053069e-02f, 4.28737700e-02f, 4.27670404e-03f, 2.04208985e-01f, -1.78128824e-01f, -7.58296996e-02f, -3.29303532e-03f, -7.17571471e-03f, -6.25509322e-02f,
  -8.62715691e-02f, -1.01495780e-01f, -8.38150680e-02f, -1.40626475e-01f, 1.00501571e-02f, -1.20690934e-01f, -2.06658021e-01f, 5.72731793e-02f, -2.10518520e-02f, -6.33755252e-02f,
  -7.89581016e-02f, -5.97112365e-02f, -6.75543547e-02f, 1.38552979e-01f, -2.94523276e-02f, -1.09547563e-01f, -9.48421285e-02f, 1.43444642e-01f, 7.37990588e-02f, 2.31181551e-02f,
  1.98813602e-01f, -2.80056894e-01f, -2.36685544e-01f, -8.82024765e-02f, -1.62123829e-01f, -2.93056164e-02f, -6.05120473e-02f, -7.64253139e-02f, -2.07014397e-01f, 9.42598879e-02f,
  1.27481043e-01f, 1.02788761e-01f, -1.11057460e-01f, 1.43462241e-01f, 1.43165112e-01f, -8.15382879e-03f, 3.27729508e-02f, -9.46120098e-02f, -1.31209478e-01f, 9.16472226e-02f,
  -1.05030999e-01f, -1.45008624e-01f, -4.41466942e-02f, -1.67536840e-01f, 2.60594282e-02f, 4.15880419e-02f, 5.28035015e-02f, 1.89903647e-01f, -2.40274176e-01f, 1.34075433e-01f,
  -2.34312452e-02f, 7.67766535e-02f, 3.51835310e-01f, -8.53368342e-02f, 1.20898448e-01f, 1.70724124e-01f, 1.00174882e-01f, -1.96663365e-01f, -2.63807565e-01f, -1.68486983e-01f,
  -1.43871289e-02f, -1.90086886e-01f, -2.33874902e-01f, -7.66864270e-02f, -9.32341293e-02f, 7.64942542e-03f, -7.92280212e-03f, 5.19713014e-02f, 2.06085801e-01f, 8.36105421e-02f,
  -1.58144347e-02f, 2.07708612e-01f, 2.62226462e-01f, 8.32492709e-02f, -3.54477242e-02f, -6.95742443e-02f, 1.19579390e-01f, 2.12377295e-01f, 5.27720340e-02f, -1.43625364e-02f,
  9.98118892e-02f, -1.62567943e-02f, -8.28803033e-02f, -1.20522611e-01f, 1.19126998e-01f, -6.82928935e-02f, -4.36203666e-02f, 9.12649184e-03f, 1.41958501e-02f, -3.08621302e-02f,
  -3.87672521e-02f, -2.82872841e-02f, 4.40189727e-02f, 6.60599209e-03f, 2.86876084e-03f, -6.95684776e-02f, -1.04998447e-01f, 3.63856852e-02f, -1.16835386e-01f, -1.15517126e-02f,
  -2.28572916e-02f, 5.70316389e-02f, 3.35709006e-02f, -1.05018960e-02f, -8.34146962e-02f, 5.97606041e-02f, 3.26440833e-03f, 3.59398536e-02f, -7.83323124e-03f, -1.89886615e-01f,
  -8.06417316e-02f, -4.44828048e-02f, -4.92988676e-02f, 5.92093468e-02f, -1.20942570e-01f, 6.64416049e-03f, 6.73527364e-03f, 1.12342305e-01f, 3.31788063e-02f, 3.01555861e-02f,
  1.40936926e-01f, 1.14555225e-01f, 1.49105951e-01f, 1.47723347e-01f, 1.12246852e-02f, 7.27589652e-02f, 1.35040402e-01f, 9.95076299e-02f, 9.05266851e-02f, -6.57578744e-03f,
  3.98529321e-02f, 7.57054463e-02f, 1.23877063e-01f, 9.55697745e-02f, 1.51030526e-01f, 1.23276629e-01f, 8.54693204e-02f, 8.31873789e-02f, 8.12142156e-03f, 1.22084171e-01f,
  2.89136749e-02f, 1.01560034e-01f, -1.75842106e-01f, -1.16282746e-01f, 7.46121407e-02f, 4.90672104e-02f, 7.08578005e-02f, -1.26298182e-02f, 1.05012722e-01f, -9.41926539e-02f,
  6.51183128e-02f, 1.06372349e-02f, -1.35769974e-02f, -9.95073561e-03f, -3.28546874e-02f, -2.71801818e-02f, 6.60038590e-02f, -8.59602317e-02f, -8.36029947e-02f, 7.63560738e-03f,
  -8.79278556e-02f, -1.78361102e-03f, -7.60819316e-02f, 2.70007015e-03f, -3.10585741e-02f, 8.36676210e-02f, 8.03501382e-02f, -3.66506726e-02f, 1.17305806e-02f, -1.32337078e-01f,
  5.57321489e-01f, -2.78359234e-01f, -5.66246271e-01f, 4.42416579e-01f, 1.97384983e-01f, -1.17482632e-01f, 1.20179363e-01f, 5.45674860e-01f, 5.14666677e-01f, -7.46920332e-02f,
  -4.73753482e-01f, -2.84418911e-01f, -4.86668855e-01f, -2.96031415e-01f, -3.65812272e-01f, -2.98965633e-01f, -1.90796226e-01f, -2.88655967e-01f, 7.74347642e-03f, 2.99539059e-01f,
  2.05243334e-01f, 3.99421960e-01f, 2.88588673e-01f, 8.47232714e-03f, -4.37644646e-02f, -3.68225202e-02f, -1.55214846e-01f, -1.60166040e-01f, -4.40812767e-01f, -5.07036328e-01f,
  -3.81857544e-01f, -1.54523551e-01f, -6.86499923e-02f, 8.83002728e-02f, -3.50125208e-02f, -7.82206003e-03f, -8.28212872e-02f, -1.47017688e-01f, -1.47049919e-01f, -1.60182536e-01f,
  -2.62863785e-01f, -1.35636374e-01f, -1.86431527e-01f, -1.49573728e-01f, 6.05468340e-02f, -3.53584290e-02f, -6.24670237e-02f, -1.55453011e-01f, -1.56778544e-01f, -1.31240144e-01f,
  -2.41196349e-01f, -3.12282383e-01f, -2.62236148e-01f, -4.06030118e-02f, -1.70825064e-01f, -9.10479352e-02f, -9.86978486e-02f, -1.53796315e-01f, -2.74162829e-01f, 1.97309136e-01f,
  2.13572562e-01f, 8.06209818e-02f, -2.92354506e-02f, -5.89235723e-02f, 8.58443901e-02f, -1.80445649e-02f, -4.83245403e-03f, -1.38038918e-02f, 2.56300215e-02f, 6.40967488e-02f,
  -8.66630524e-02f, -1.24105535e-01f, 7.11614639e-02f, 1.12117603e-01f, -8.85406733e-02f, -6.55598193e-02f, -1.05834231e-02f, 1.66945942e-02f, -3.81570943e-02f, 1.74272120e-01f,
  2.10220534e-02f, 5.45920581e-02f, 1.24100000e-01f, -1.17145553e-02f, -1.37594461e-01f, -7.21937492e-02f, 1.54665068e-01f, 2.13223230e-02f, 8.97333622e-02f, 1.38041340e-02f,
  3.88881177e-01f, -2.34173179e-01f, 8.22280049e-02f, -1.03342012e-02f, 7.82662705e-02f, -1.16065688e-01f, 2.11017765e-02f, -1.48214609e-03f, -2.42667481e-01f, -5.53593561e-02f,
  -2.24092498e-01f, 3.16789337e-02f, -2.41919741e-01f, 2.72916211e-03f, -1.29619017e-02f, 8.30362886e-02f, -2.83313240e-03f, -6.00567237e-02f, -3.24045494e-02f, 1.47133559e-01f,
  1.52079746e-01f, 2.44772837e-01f, 1.85412183e-01f, 7.91949332e-02f, 1.83693483e-01f, 2.73346901e-01f, 2.77084224e-02f, 6.85982555e-02f, -8.70568007e-02f, 4.86980021e-01f,
  -4.21630383e-01f, -3.06492776e-01f, -1.62391663e-01f, 1.96625665e-01f, 3.60136777e-01f, -2.68089231e-02f, -2.49077663e-01f, -2.12584674e-01f, 8.42079334e-03f, -1.65275767e-01f,
  -5.36407754e-02f, 6.09479696e-02f, -2.23868135e-02f, 4.21573408e-02f, -1.06161684e-01f, -6.73764339e-03f, 2.94434756e-01f, 2.32196122e-01f, 1.18016355e-01f, 6.35697097e-02f,
  2.74381280e-01f, 1.62667334e-01f, -1.50416838e-02f, 1.67653382e-01f, 2.75562823e-01f, 2.72304267e-01f, 1.16573863e-01f, 1.87078133e-01f, 1.30496919e-01f, 3.24563205e-01f,
  -3.73931706e-01f, -3.69945496e-01f, 1.58198535e-01f, 1.64483771e-01f, 5.35488091e-02f, -2.10043401e-01f, -1.79383550e-02f, -3.34658213e-02f, -2.31173560e-02f, -1.06553687e-02f,
  1.13894075e-01f, -1.14328697e-01f, 5.40460572e-02f, 2.99166776e-02f, -1.19813465e-01f, -1.69278800e-01f, -1.28933907e-01f, -1.31842494e-01f, -1.46541536e-01f, -2.11597666e-01f,
  4.55720663e-01f, 2.48305872e-01f, -1.45930573e-01f, -1.16513588e-01f, -2.35492066e-01f, 1.74274087e-01f, -1.92030013e-01f, -1.24972537e-01f, -3.79544318e-01f, -2.48897627e-01f,
  -9.03631374e-02f, -5.84062946e-04f, 4.17018011e-02f, -1.49007186e-01f, 9.79167526e-04f, -3.09242122e-03f, 7.26363435e-02f, 1.20400026e-01f, 2.70848665e-02f, -6.24994456e-04f,
  -1.43016160e-01f, -7.17145950e-02f, -1.51564414e-02f, -1.90053090e-01f, 1.25238001e-01f, -4.01363969e-02f, 1.65920511e-01f, 2.22033504e-02f, -6.03736117e-02f, -1.22791342e-01f,
  -1.77973256e-01f, -2.78362222e-02f, 8.80809799e-02f, -2.59486139e-02f, -3.35667469e-02f, -1.31358327e-02f, 2.27863528e-02f, 4.43505011e-02f, -1.10219292e-01f, -9.27200988e-02f,
  -2.53053546e-01f, 3.76773030e-02f, -6.49130866e-02f, -1.13062523e-01f, 1.04222670e-01f, -8.26861709e-02f, 5.55839539e-02f, 5.09854667e-02f, -5.99149317e-02f, -1.78465117e-02f,
  -1.84898078e-01f, -1.36879638e-01f, -1.11878671e-01f, 1.41579613e-01f, 3.23373894e-03f, -3.92617956e-02f, 7.82396570e-02f, 6.50141090e-02f, 4.45204526e-02f, -3.61729786e-02f,
  1.69646591e-01f, -1.20740518e-01f, -2.42980704e-01f, -1.34153858e-01f, -2.93302089e-02f, -8.47470015e-02f, -1.02843948e-01f, -1.54923275e-01f, -2.53809512e-01f, -3.89851183e-01f,
  -2.74374306e-01f, -3.77429128e-01f, 2.67681092e-01f, -2.25846142e-01f, 2.38720551e-01f, 3.76682788e-01f, 3.44769269e-01f, 1.34594783e-01f, 2.46987250e-02f, 8.54651853e-02f,
  -2.41920233e-01f, -4.15915489e-01f, -4.38303947e-01f, -2.89066195e-01f, -3.26471299e-01f, 2.26544812e-01f, 3.46161574e-01f, 1.22073442e-01f, 1.88427139e-02f, 5.93731925e-02f,
  -7.68976510e-02f, -1.66717768e-01f, -3.56725782e-01f, -2.71695167e-01f, -8.08074474e-02f, -1.73823953e-01f, -1.43595897e-02f, -5.65405972e-02f, -6.80305064e-02f, -4.29024845e-02f,
  2.39861250e-01f, -2.23275691e-01f, 9.34661254e-02f, -1.82247430e-01f, -1.64332569e-01f, -1.26779869e-01f, -6.56764433e-02f, -9.59241688e-02f, -1.58779845e-01f, 1.14057854e-01f,
  -7.30615258e-02f, -1.45037264e-01f, -1.09060146e-01f, -1.55839231e-02f, 1.00225300e-01f, 1.98574755e-02f, -3.43171731e-02f, -1.62227795e-01f, -1.29844725e-01f, 3.14453640e-03f,
  -2.54789293e-01f, 6.03468381e-02f, 7.38839284e-02f, 7.95479193e-02f, -1.40349910e-01f, 1.81932154e-03f, 1.23934813e-01f, -9.06624049e-02f, 1.95900369e-02f, 7.50571415e-02f,
  1.20038755e-01f, 3.93737927e-02f, -6.93363547e-02f, -6.08947426e-02f, 4.00476269e-02f, -2.12857127e-02f, -1.17691206e-02f, -5.52550443e-02f, -3.34309265e-02f, -1.21163733e-01f,
  -9.56916884e-02f, -8.31370801e-02f, -1.21794872e-01f, -3.43768261e-02f, -9.82154086e-02f, -1.13275811e-01f, 1.10305855e-02f, -1.09532841e-01f, -1.48132052e-02f, -1.22916400e-02f,
  -8.71545970e-02f, 6.04735315e-03f, -4.56118174e-02f, 2.34501213e-02f, -6.60989136e-02f, -1.85357966e-02f, -8.10750946e-02f, -5.99599369e-02f, -1.41614154e-01f, 1.27109094e-02f,
  -8.24631900e-02f, -1.43276364e-01f, 5.96307851e-02f, -1.30231574e-01f, 8.79293308e-02f, -1.55351415e-01f, -8.56176838e-02f, 1.60287190e-02f, -9.77006033e-02f, -3.64776817e-04f,
  -5.19792847e-02f, -7.98808113e-02f, -1.05938368e-01f, -3.59277166e-02f, 1.55747816e-01f, 9.70525146e-02f, -8.07569176e-02f, -1.37885194e-02f, 3.79561866e-03f, -6.08216859e-02f,
  3.18173915e-02f, 1.26650408e-01f, 1.86864674e-01f, 8.56573507e-02f, -2.63323984e-03f, 1.02542758e-01f, 2.32754350e-01f, 1.71374649e-01f, 7.94978514e-02f, 3.27256292e-01f,
  5.24781287e-01f, 3.84770006e-01f, 2.97177315e-01f, 1.29331499e-01f, 2.35858366e-01f, 2.43501157e-01f, 2.56632566e-01f, 1.26663595e-01f, -5.20159565e-02f, 9.83769745e-02f,
  3.27020556e-01f, 9.32812989e-02f, 1.46952316e-01f, 1.25364780e-01f, 9.89479274e-02f, 1.00517392e-01f, -3.47271413e-02f, 1.08596705e-01f, -5.13830446e-02f, 4.53683548e-02f,
  1.59052864e-01f, 7.05027208e-02f, 1.64326295e-01f, 1.41688824e-01f, 2.10607797e-02f, -2.09462568e-02f, 2.92479601e-02f, 1.87024489e-01f, 1.82492122e-01f, -1.27217874e-01f,
  -4.99612950e-02f, 1.80123955e-01f, -2.37208039e-01f, -2.00078860e-02f, 3.53454836e-02f, -5.29753678e-02f, -6.16728999e-02f, -1.34986490e-01f, -9.30395648e-02f, -1.80889457e-01f,
  8.39612558e-02f, -3.59225236e-02f, 9.73290354e-02f, -1.15545541e-02f, 3.30974087e-02f, 2.64733518e-03f, 2.79548634e-02f, -3.39630395e-02f, 3.48600075e-02f, -8.73859897e-02f,
  5.12676537e-02f, 5.00041693e-02f, 1.45584075e-02f, -7.09441397e-03f, 6.85961023e-02f, -1.67867970e-02f, 6.59688339e-02f, 5.45804501e-02f, 6.96081668e-02f, -1.42092649e-02f,
  -1.44666374e-01f, 2.06103802e-01f, 1.29362047e-01f, -8.80010128e-02f, 7.76685961e-03f, -1.18430406e-01f, -7.53795505e-02f, 9.40180290e-03f, 9.48070511e-02f, -4.81324792e-02f,
  -2.80790590e-02f, -1.05505489e-01f, 2.01351531e-02f, -7.77736381e-02f, -1.49884494e-02f, 6.10723384e-02f, -7.94147700e-02f, -3.41214798e-02f, 8.92167017e-02f, 4.53529097e-02f,
  9.31329653e-02f, -9.13285539e-02f, -8.06272626e-02f, 4.21421509e-03f, -1.41430631e-01f, 3.16339098e-02f, -1.22087739e-01f, -1.01349819e-02f, -4.01627049e-02f, 4.31412682e-02f,
  -4.07237679e-01f, 1.85705751e-01f, -2.61586845e-01f, -1.48405135e-01f, 1.19695859e-02f, -1.28456667e-01f, 2.54914872e-02f, -3.89023907e-02f, -4.09483984e-02f, -8.19845423e-02f,
  -3.78616378e-02f, 1.96715333e-02f, 1.03920653e-01f, -5.17707542e-02f, -1.29300535e-01f, -1.74464539e-01f, -6.33873791e-03f, -1.61317512e-01f, -8.21537152e-02f, -1.85776085e-01f,
  -9.77784693e-02f, -6.49480000e-02f, -1.67874813e-01f, -7.44019076e-02f, -1.50489025e-02f, -2.24899769e-01f, -5.74334487e-02f, -2.28667393e-01f, -1.31713584e-01f, -1.72693506e-01f,
  -1.08867519e-01f, -5.32380827e-02f, -8.44978020e-02f, 9.01244134e-02f, -7.78267458e-02f, -2.41979241e-01f, -3.45930248e-01f, -4.06857699e-01f, 1.32454589e-01f, 2.38586590e-01f,
  1.78458095e-01f, 2.07791850e-01f, 1.19831398e-01f, -3.31624635e-02f, -3.60868007e-01f, -3.17011446e-01f, -2.45800197e-01f, -3.43056083e-01f, -3.55231285e-01f, -2.24880472e-01f,
  6.42713383e-02f, -4.60836925e-02f, -2.34904438e-01f, -1.21153787e-01f, 4.52908993e-01f, 2.35739291e-01f, 1.36605099e-01f, 2.25171238e-01f, 9.91742220e-03f, 3.99855494e-01f,
  3.40528935e-01f, -7.44664371e-02f, -8.88152793e-02f, -3.46866809e-02f, -5.14141023e-02f, -3.66247334e-02f, 5.23873046e-02f, -6.82762712e-02f, 4.60227439e-03f, 5.05401902e-02f,
  1.04933657e-01f, -2.73657907e-02f, -1.13753289e-01f, 1.53190151e-01f, -5.29313274e-02f, 4.11775224e-02f, -5.99297956e-02f, -2.44764000e-01f, -1.50165901e-01f, 1.14849560e-01f,
  8.44751671e-02f, -7.86270276e-02f, -1.25215694e-01f, -1.68452859e-01f, -1.86794668e-01f, 1.86658818e-02f, -3.44055779e-02f, 5.95559068e-02f, -9.43806618e-02f, 2.61083364e-01f,
  4.44603860e-02f, 9.45385471e-02f, 9.83520299e-02f, 2.82810275e-02f, 1.25668943e-01f, -2.61819772e-02f, 5.74511252e-02f, 1.68300152e-01f, 2.35085413e-02f, 1.22229688e-01f,
  -9.37651694e-02f, -5.11356220e-02f, -3.51805985e-02f, -6.24839365e-02f, 1.32746667e-01f, 1.65628627e-01f, 7.03727603e-02f, 3.22894938e-02f, 3.02171968e-02f, 1.67470217e-01f,
  1.56236932e-01f, -2.17552744e-02f, 1.06718518e-01f, -3.68775167e-02f, 3.05592436e-02f, -1.19617349e-02f, 1.92737669e-01f, 1.68411154e-02f, 6.03530146e-02f, 4.57766354e-02f,
  2.70055592e-01f, -4.01650012e-01f, 2.11061105e-01f, 3.48565057e-02f, -5.00992388e-02f, 9.57143828e-02f, 2.76375473e-01f, 3.77794802e-02f, 1.40471742e-01f, 1.61696345e-01f,
  -1.61551200e-02f, 1.70472134e-02f, -1.76822543e-02f, 1.11825867e-02f, 3.92551757e-02f, 1.15778260e-01f, 1.01308832e-02f, 1.03386678e-01f, 9.81699862e-03f, 1.64060965e-01f,
  -1.24111488e-01f, -8.29652622e-02f, -2.06164923e-02f, -4.25599627e-02f, -1.40389549e-02f, -6.76613152e-02f, -7.40592415e-03f, 1.72448847e-02f, -6.69670179e-02f, 1.83930565e-02f,
  -6.53865755e-01f, -1.23145618e-01f, -6.47375435e-02f, -8.84692520e-02f, 4.34645265e-02f, 1.72583550e-01f, 1.97838888e-01f, 1.46168560e-01f, 8.17126557e-02f, -5.78562878e-02f,
  -1.55200168e-01f, 5.24310395e-02f, 6.91081882e-02f, 4.33826409e-02f, 1.25954583e-01f, 3.17788571e-01f, 2.13413283e-01f, -6.19450100e-02f, 9.76414699e-03f, 7.75994360e-02f,
  2.20544457e-01f, -1.05592802e-01f, -2.68748939e-01f, -3.07199806e-02f, 9.70830470e-02f, 1.46352917e-01f, 1.27663419e-01f, -5.95919043e-02f, 1.87495276e-01f, 9.54247192e-02f,
  2.74069637e-01f, -3.59198570e-01f, -4.09775823e-02f, -9.87611637e-02f, -2.11265877e-01f, -1.06927738e-01f, -4.74237949e-02f, -8.30982849e-02f, -6.37814999e-02f, 6.05675392e-03f,
  -2.92676426e-02f, -1.00758202e-01f, -6.32746369e-02f, 1.62191857e-02f, -7.94845149e-02f, -7.90114999e-02f, -6.34281114e-02f, -2.57583279e-02f, 1.50268286e-01f, 1.23222852e-02f,
  -1.68498717e-02f, -1.57882497e-01f, -1.45990048e-02f, 1.75910041e-01f, 9.03256088e-02f, -5.96585833e-02f, -2.71369014e-02f, -1.08437769e-01f, -1.82672013e-02f, -6.71279877e-02f,
  1.49750471e-01f, 9.97592881e-02f, -4.51628491e-02f, -1.39367923e-01f, -5.97931026e-03f, 5.77817410e-02f, 6.83513284e-03f, 7.38537684e-02f, 1.00462325e-01f, 7.44336545e-02f,
  -3.11754402e-02f, 4.56694663e-02f, 8.40896368e-02f, 5.36211483e-05f, -1.15545981e-01f, -1.64025631e-02f, -4.87906635e-02f, 4.74173240e-02f, 3.51381339e-02f, -1.88612286e-02f,
  -7.75094330e-02f, 7.27892146e-02f, -1.61142990e-01f, 5.00958934e-02f, -5.75264022e-02f, -7.55388290e-02f, 1.44537976e-02f, -1.28936442e-02f, -1.22030243e-01f, -4.12908150e-03f,
  2.87809521e-01f, -1.76330924e-01f, 1.56663787e-02f, -1.17140368e-01f, -3.80756371e-02f, -9.71938968e-02f, -5.03268884e-03f, -7.57876635e-02f, 2.76392326e-03f, 1.10623993e-01f,
  4.60574683e-03f, -1.55138999e-01f, 3.30758728e-02f, -2.18312200e-02f, 5.30506484e-02f, -2.97071021e-02f, 2.75603421e-02f, 3.89022604e-02f, 1.33623198e-01f, 1.65143106e-02f,
  1.10877231e-01f, 7.26106316e-02f, 1.38998717e-01f, 1.99884549e-01f, 6.07437491e-02f, -1.73737691e-03f, 1.10187091e-01f, 1.52662724e-01f, 1.32469177e-01f, 1.12240024e-01f,
  4.53086942e-02f, 9.57702920e-02f, 3.53565812e-01f, -6.64264336e-02f, 2.98850685e-01f, 2.01936319e-01f, 2.49904618e-01f, 1.39228463e-01f, 3.32576670e-02f, 7.54892230e-02f,
  1.10404305e-01f, -2.39768162e-01f, -1.91197097e-01f, -4.96553704e-02f, -6.08970039e-02f, -2.35218983e-02f, -4.54215769e-04f, -7.10239857e-02f, 9.77781713e-02f, -9.18817371e-02f,
  -1.62340760e-01f, -5.31529039e-02f, 1.41030289e-02f, -2.43880376e-02f, -2.06019767e-02f, -1.49287447e-01f, 8.65039229e-02f, 1.85881078e-01f, 7.83352405e-02f, -1.56021327e-01f,
  1.25472963e-01f, 3.17168236e-01f, -4.13492918e-02f, -1.03062607e-01f, 1.15754344e-01f, 4.22925912e-02f, 1.16533764e-01f, -1.39824906e-02f, 8.38250071e-02f, -5.72019517e-02f,
  1.38681114e-01f, 1.49533823e-01f, 1.77916855e-01f, 6.91946074e-02f, 1.25115648e-01f, 7.60764107e-02f, -1.32888071e-02f, -8.71518254e-03f, -1.01470605e-01f, 3.31185684e-02f,
  -5.40747158e-02f, 1.19733244e-01f, 1.69985548e-01f, 2.10247599e-02f, -8.32416490e-02f, 7.17355385e-02f, 2.02611521e-01f, 1.60453826e-01f, 1.92040578e-01f, 4.71682101e-02f,
  -9.00785252e-02f, -1.55727103e-01f, -5.24154082e-02f, 4.65495661e-02f, -5.75841330e-02f, -1.27304075e-02f, -3.27152871e-02f, -7.82450512e-02f, 7.02993721e-02f, 1.51859764e-02f,
  4.59896540e-03f, 6.64484873e-02f, -3.72245163e-03f, -3.82766426e-02f, 1.35699168e-01f, 1.76987275e-01f, 5.40804900e-02f, 1.20588951e-01f, 1.30429551e-01f, 9.87675115e-02f,
  6.04672469e-02f, 2.10156254e-02f, 2.16171414e-01f, 5.07127531e-02f, 1.52127683e-01f, 2.08977163e-01f, 3.96181047e-02f, 1.00738369e-01f, 1.41048029e-01f, 2.91974358e-02f,
  -9.23688412e-02f, 2.77653545e-01f, -2.93594211e-01f, -1.34409949e-01f, 1.47638116e-02f, 8.09372142e-02f, -2.93160919e-02f, -3.26145776e-02f, 1.84349221e-04f, 2.57333741e-02f,
  9.51633528e-02f, -3.08835171e-02f, -6.13289662e-02f, 1.00197233e-01f, -2.28691157e-02f, 9.79507416e-02f, -8.82627219e-02f, -6.17988445e-02f, -6.56541884e-02f, 8.40699151e-02f,
  -4.38387468e-02f, -1.37871340e-01f, -3.10343150e-02f, -8.84835981e-03f, -1.23675570e-01f, -8.94054398e-02f, -3.98151465e-02f, -1.37989685e-01f, -1.18621374e-02f, -1.81142375e-01f,
  -7.01991975e-01f, -1.71390161e-01f, 8.19816589e-02f, -3.92046392e-01f, 5.00650182e-02f, 1.14332542e-01f, -1.91147253e-01f, 7.70169944e-02f, 1.73666477e-01f, -1.29549488e-01f,
  6.93012103e-02f, -1.75489038e-01f, -2.25731358e-01f, -3.17024320e-01f, -5.60736001e-01f, -3.03600907e-01f, -2.71646082e-01f, -4.29449111e-01f, -3.85059178e-01f, -2.11670563e-01f,
  -1.93857670e-01f, -4.46026415e-01f, -4.14133817e-01f, -9.21507031e-02f, 1.69782653e-01f, -6.05612434e-02f, 5.50764613e-02f, -1.09116107e-01f, -5.66295758e-02f, -7.11800084e-02f,
  -1.36000887e-01f, 1.76303223e-01f, 1.25090435e-01f, 6.51613623e-02f, 4.73517962e-02f, 1.33162895e-02f, 8.02363902e-02f, -1.06747523e-02f, -5.69970235e-02f, -1.59008391e-02f,
  -4.70147915e-02f, 1.48323953e-01f, -6.14731535e-02f, 4.74010371e-02f, 2.77000256e-02f, -5.01923449e-02f, -2.72464976e-02f, -5.52468300e-02f, -8.18936303e-02f, 3.36180508e-01f,
  -4.60436977e-02f, -1.46573856e-01f, -2.58159280e-01f, 7.99537264e-03f, 2.68052518e-01f, -7.56999776e-02f, 6.91040754e-02f, 1.90262735e-01f, 1.51019305e-01f, -1.79159467e-03f,
  -1.94134843e-02f, 4.35208082e-02f, -2.20653582e-02f, 7.67690456e-03f, 2.90472452e-02f, 4.05352935e-02f, -8.48124400e-02f, -2.06165135e-01f, -3.37848999e-02f, -6.15536310e-02f,
  1.40228331e-01f, 2.75938958e-02f, -4.89488244e-02f, 4.55831513e-02f, 2.08117925e-02f, -2.04130754e-01f, -1.07427649e-01f, -8.51356983e-02f, -3.84602882e-02f, 2.99773458e-02f,
  -5.74662127e-02f, -8.64928141e-02f, -2.64914725e-02f, -1.65393457e-01f, 1.04194775e-01f, -3.70316729e-02f, 1.29600227e-01f, 1.17461108e-01f, 1.11650661e-01f, 9.33502913e-02f,
  -2.20483884e-01f, -4.81924415e-02f, -1.58969194e-01f, -2.19427258e-01f, -1.40457079e-01f, 2.46037409e-01f, -5.84647916e-02f, -9.52721387e-02f, 7.18743280e-02f, -9.58790556e-02f,
  1.22587584e-01f, -1.28455102e-01f, -1.08772963e-02f, -4.99003679e-02f, -7.18949363e-02f, 1.71512943e-02f, -3.36516976e-01f, -2.57657975e-01f, -1.06829450e-01f, 9.49809179e-02f,
  -1.05647169e-01f, -4.55718011e-01f, -5.45560956e-01f, -3.04433823e-01f, 9.63419490e-03f, -3.22905600e-01f, -2.15224221e-01f, 3.63586135e-02f, -2.55466849e-01f, -3.37887406e-01f,
  -3.72456819e-01f, -1.70957565e-01f, -4.76024836e-01f, -3.45256180e-01f, -4.71457154e-01f, -2.82205939e-01f, -8.44120905e-02f, -2.03133017e-01f, -2.37312943e-01f, -2.79596806e-01f,
  3.64765115e-02f, 1.56562641e-01f, -7.58461133e-02f, 6.26119971e-02f, 1.91217318e-01f, -1.91057101e-01f, -2.64656663e-01f, -2.71898657e-01f, -9.14748013e-03f, 1.06832907e-01f,
  -1.30184725e-01f, -3.29704970e-01f, -2.01317668e-01f, -2.07594752e-01f, -4.39164728e-01f, -2.45327741e-01f, -4.23647076e-01f, -2.53241807e-01f, -1.83983311e-01f, -4.56801206e-01f,
  7.81975463e-02f, -2.17108309e-01f, 1.34502605e-01f, 8.85301232e-02f, -5.36260158e-02f, 1.19706042e-01f, -3.33164558e-02f, -1.10550426e-01f, 1.81527790e-02f, -4.98671122e-02f,
  -9.51716080e-02f, 7.82204419e-03f, 1.38291167e-02f, -2.73322314e-02f, -4.91717011e-02f, -9.47739035e-02f, -1.98060215e-01f, -1.21463612e-01f, -1.88460767e-01f, -1.19331010e-01f,
  -2.82375403e-02f, -1.10313214e-01f, -7.06710741e-02f, 3.08401398e-02f, -5.04212081e-02f, -1.08267300e-01f, -1.19626805e-01f, -1.35235399e-01f, -8.09529349e-02f, -1.77333444e-01f,
  -7.54579604e-02f, -1.27465010e-01f, -1.09147383e-02f, -1.94848310e-02f, -1.86119080e-02f, -4.91051078e-02f, -8.23694002e-03f, 2.25548185e-02f, 5.60675859e-02f, -1.44990848e-03f,
  7.09677637e-02f, -8.09783638e-02f, 2.71165073e-02f, -6.58574253e-02f, -4.77555441e-03f, -1.21721111e-01f, 6.08176999e-02f, 6.91137314e-02f, 1.33249670e-01f, -8.85340273e-02f,
  6.76991045e-02f, -8.60921573e-03f, -4.01553586e-02f, 1.23486705e-01f, 3.88567685e-03f, -2.08534840e-02f, 4.34687501e-03f, 1.43103704e-01f, -1.93275958e-02f, -1.26596749e-01f,
  1.30835548e-01f, -6.49491400e-02f, 4.14087716e-03f, 9.79272425e-02f, -5.58965243e-02f, -5.59011009e-03f, -8.79018307e-02f, 8.55947435e-02f, -7.32215717e-02f, -3.25915962e-02f,
  -9.92527325e-03f, 1.17081702e-01f, 6.97586387e-02f, -8.04494619e-02f, 1.42295742e-02f, 7.25817075e-03f, 6.80253580e-02f, 3.91293205e-02f, 6.28957003e-02f, -1.78954363e-01f,
  -1.34127289e-01f, 2.26783350e-01f, 3.17049593e-01f, 2.25358412e-01f, 5.09628057e-02f, 1.72553957e-01f, 4.06258591e-02f, 1.16183825e-01f, 2.53508449e-01f, 8.40803385e-02f,
  2.47397110e-01f, -2.91667759e-01f, -6.05906487e-01f, 1.35580689e-01f, -3.07271834e-02f, 3.15847360e-02f, 3.02264214e-01f, 4.18964863e-01f, 4.00614470e-01f, 1.40850812e-01f,
  -1.49841309e-01f, -3.34861487e-01f, -3.91117781e-01f, -3.08471590e-01f, -8.69591236e-02f, 5.14050350e-02f, -1.08746730e-01f, -3.01702768e-01f, -1.03266407e-02f, 2.50415742e-01f,
  1.63299784e-01f, 2.42438883e-01f, 2.34773699e-02f, -2.95797568e-02f, 8.11696723e-02f, 3.42638679e-02f, -8.44307616e-02f, -7.00397938e-02f, -2.21878663e-01f, -2.42492139e-01f,
  -1.77310437e-01f, -1.06119953e-01f, 1.09382302e-01f, -1.03081733e-01f, -1.65892281e-02f, 1.36206141e-02f, 9.56255943e-02f, -1.14578769e-01f, -9.56363007e-02f, -8.80791619e-02f,
  -2.22853720e-01f, -1.31378412e-01f, -1.85809210e-01f, -3.52871604e-02f, -3.16948211e-03f, 4.83631976e-02f, -1.86246708e-01f, -2.23503247e-01f, -1.71610892e-01f, -1.34158731e-02f,
  -3.43499959e-01f, -2.66829044e-01f, -2.94651181e-01f, 1.35440482e-02f, -1.29155368e-01f, -1.92259133e-01f, -6.95163459e-02f, -9.23437104e-02f, -7.35015720e-02f, 1.61227122e-01f,
  1.13510210e-02f, 5.82362786e-02f, 4.98639827e-04f, 1.12091631e-01f, 8.76565203e-02f, -1.11458763e-01f, -8.92165005e-02f, -7.23925233e-02f, 6.90261424e-02f, 7.68247843e-02f,
  -5.00256605e-02f, 2.82871965e-02f, -1.67263038e-02f, 3.73449065e-02f, 9.43128578e-03f, 5.16638579e-03f, -1.46162838e-01f, -4.03786935e-02f, 8.83045793e-02f, 5.12167439e-02f,
  -8.05752166e-03f, 1.55008093e-01f, 1.05538391e-01f, 5.39250523e-02f, 2.00238507e-02f, -2.85012592e-02f, 1.01051718e-01f, -5.83095066e-02f, -5.16095124e-02f, 9.52413231e-02f,
  4.87956107e-01f, -9.90424529e-02f, 1.79454073e-01f, 8.75368938e-02f, 3.79559956e-02f, 4.30361331e-02f, 4.31713089e-02f, -2.84772981e-02f, -7.26510137e-02f, 2.96231289e-03f,
  -1.78992465e-01f, -2.93398350e-02f, -2.08243757e-01f, 1.35353819e-01f, 2.00976968e-01f, -3.72723583e-03f, -4.59547713e-03f, -1.50634825e-01f, 1.41207483e-02f, 1.23376660e-01f,
  5.32287322e-02f, 9.66572389e-02f, 1.26640797e-01f, 9.82494652e-02f, 1.24180958e-01f, 1.86938792e-01f, 1.12291038e-01f, 1.15347929e-01f, -7.61853233e-02f, 4.28743571e-01f,
  4.79513220e-02f, -1.45107552e-01f, 2.54515618e-01f, 4.51695025e-02f, -5.04693985e-01f, -3.35512459e-01f, -4.27072734e-01f, 4.42055464e-02f, 1.31585047e-01f, -2.98876733e-01f,
  -5.28475344e-01f, -4.45572674e-01f, -1.65802285e-01f, -3.79244164e-02f, 1.22296542e-01f, 7.52587989e-02f, 1.08629927e-01f, 2.88131863e-01f, -4.91625667e-02f, -2.62118220e-01f,
  -5.09388566e-01f, -9.80789363e-02f, 2.81695038e-01f, 2.58351713e-01f, 2.09025741e-01f, 1.06311720e-02f, 2.73077071e-01f, -5.37449084e-02f, -5.26445359e-03f, 1.07902266e-01f,
  -2.63621635e-03f, 3.18011284e-01f, -1.82664189e-02f, -1.73888251e-01f, -1.95177153e-01f, 8.17883834e-02f, -1.35822058e-01f, 2.93885797e-01f, -1.86212867e-01f, 1.18047111e-01f,
  -3.17274451e-01f, -1.43426105e-01f, -1.68590918e-01f, -4.65123542e-02f, -1.56170815e-01f, 7.03223422e-02f, 2.72530138e-01f, 3.26335847e-01f, 2.23923028e-01f, 1.66984931e-01f,
  -4.13162977e-01f, -3.34242225e-01f, -3.24323326e-02f, 1.83490142e-01f, 3.32258314e-01f, -1.37038350e-01f, 1.20384231e-01f, 1.05320841e-01f, 2.07699493e-01f, 1.98342770e-01f,
  -1.67100951e-02f, -1.99736413e-02f, -1.49066178e-02f, -1.02970274e-02f, -1.39880538e-01f, 3.44050862e-02f, 6.44757599e-02f, 6.50144462e-03f, -6.63487315e-02f, 2.56245621e-02f,
  2.93571651e-02f, -8.94188602e-03f, 2.88279355e-02f, 1.27390161e-01f, 1.09873623e-01f, 5.61276749e-02f, -3.45548987e-02f, 1.21428119e-03f, -5.41371480e-02f, 2.14942284e-02f,
  1.83924679e-02f, -6.41913293e-03f, -2.04450823e-02f, 1.12744555e-01f, 4.80045006e-02f, 1.62501276e-01f, 1.96831953e-02f, -1.43609419e-01f, -4.69146483e-02f, -2.99144648e-02f,
  -2.07812831e-01f, -2.08817348e-01f, -8.74813721e-02f, 1.30279750e-01f, -5.70644215e-02f, 1.39062792e-01f, -1.70625806e-01f, 6.51225401e-03f, -1.57036781e-01f, -1.05338752e-01f,
  -1.34823546e-01f, 2.83842012e-02f, 2.90652812e-02f, -7.34283477e-02f, -2.58343592e-02f, -1.34156525e-01f, -3.37333947e-01f, -2.51161009e-01f, -1.43243104e-01f, -8.20581988e-02f,
  -1.28069401e-01f, -2.99740046e-01f, -4.41952229e-01f, -1.75887972e-01f, -1.61777109e-01f, -3.44064176e-01f, -2.29481652e-01f, -2.45915264e-01f, -1.68673679e-01f, -3.02433223e-01f,
  -4.45206285e-01f, 3.44423294e-01f, 2.40818739e-01f, -2.22748443e-01f, -7.04068691e-02f, -2.53459942e-02f, 7.77937099e-02f, -8.60676840e-02f, -1.31284013e-01f, 1.09960616e-01f,
  1.87195152e-01f, -2.05369636e-01f, 1.91147644e-02f, -1.72140121e-01f, -4.27321792e-01f, -8.40221718e-02f, -1.27101526e-01f, -4.18801636e-01f, -5.02043784e-01f, -3.87891084e-01f,
  -2.94871151e-01f, -2.45459124e-01f, -3.39314312e-01f, -1.32402539e-01f, 1.23978950e-01f, -8.11655298e-02f, 2.50647455e-01f, 7.85000920e-02f, 7.12112337e-02f, 9.40677747e-02f,
  3.66895139e-01f, 8.91221836e-02f, -7.53571317e-02f, -2.64659822e-01f, 1.31244048e-01f, -9.89759862e-02f, 6.10550568e-02f, 4.20183018e-02f, -1.34619534e-01f, 6.82297945e-02f,
  8.77346396e-02f, -1.23480521e-01f, -8.46973807e-02f, -4.18249667e-02f, -4.81781214e-02f, -2.26154044e-01f, -1.87361062e-01f, -2.99626082e-01f, -9.61222351e-02f, 8.42530131e-02f,
  -1.03736836e-02f, -6.76593781e-02f, 1.66543752e-01f, 9.93163511e-02f, 2.41379235e-02f, -2.77104884e-01f, 2.28109106e-01f, 9.74808335e-02f, 1.26235336e-01f, 1.43883169e-01f,
  1.63183752e-02f, 3.37807536e-02f, -1.09922640e-01f, 6.93430379e-02f, -1.07417531e-01f, 8.29068199e-02f, 1.45276599e-02f, -9.26557481e-02f, -1.07055530e-01f, 1.40688732e-01f,
  1.19749077e-01f, 1.40284404e-01f, 5.81907183e-02f, 1.34179816e-01f, 6.33602664e-02f, -2.81745531e-02f, -1.06592879e-01f, 5.94963469e-02f, 1.04121724e-02f, 4.28693332e-02f,
  -7.54490271e-02f, 1.47655196e-02f, 8.04548040e-02f, 4.22462076e-02f, -6.53121844e-02f, -1.09172933e-01f, -1.00494288e-01f, -8.52112547e-02f, -1.43625706e-01f, -9.11657512e-02f,
  2.68398255e-01f, -1.60443366e-01f, 4.02596742e-02f, -2.51762927e-01f, -7.23384246e-02f, 1.25401886e-02f, 1.14111729e-01f, -1.62152290e-01f, 1.20746844e-01f, -7.67249689e-02f,
  -1.14042804e-01f, -3.82887982e-02f, 1.67476088e-01f, -4.70006540e-02f, -1.99473724e-01f, -7.83531144e-02f, -1.60508394e-01f, -9.96761769e-03f, -6.54576272e-02f, 8.15023705e-02f,
  3.99207734e-02f, -1.07785150e-01f, -1.27448374e-02f, 1.77207775e-02f, 1.38756409e-01f, -1.13676876e-01f, 1.92349315e-01f, 1.69224903e-01f, -1.37491167e-01f, 1.89643666e-01f,
  3.74485552e-01f, -1.27292484e-01f, 9.22755226e-02f, 2.90356129e-02f, 6.53344691e-02f, -1.07172243e-01f, -1.56333789e-01f, 1.66848395e-02f, 3.50558609e-02f, 1.12751715e-01f,
  1.86315298e-01f, 2.11015597e-01f, 2.35531211e-01f, 2.47166216e-01f, 1.44237638e-01f, -6.56149983e-02f, -2.24619657e-02f, 1.88370660e-01f, 1.26920253e-01f, -1.61687173e-02f,
  -4.21515852e-02f, 4.10609245e-02f, 9.25731510e-02f, 5.49619831e-02f, -9.87875387e-02f, 1.32162601e-01f, -4.26200517e-02f, 1.92928556e-02f, -4.28832695e-02f, 6.18061163e-02f,
  -7.20940232e-02f, -5.51234372e-02f, 2.15876307e-02f, 3.65522392e-02f, -7.20534995e-02f, -4.87778187e-02f, -7.92691186e-02f, -3.21965478e-02f, 6.03430197e-02f, 4.03098762e-03f,
  1.77840609e-02f, -7.06819296e-02f, -2.21749842e-02f, -6.23599328e-02f, -1.19851083e-01f, 2.15457734e-02f, -8.63085911e-02f, 1.33586144e-02f, 7.48168007e-02f, 7.33748376e-02f,
  -2.61840280e-02f, 2.30578966e-02f, -6.61928728e-02f, -5.19808643e-02f, 3.60722728e-02f, 4.57998700e-02f, 6.34528473e-02f, 6.32914307e-04f, -6.53641373e-02f, -3.14946584e-02f,
  1.52418956e-01f, 4.29119766e-02f, 7.47536942e-02f, 1.06423110e-01f, 1.81852281e-01f, 1.37932882e-01f, -6.34141415e-02f, 8.53516161e-02f, 2.23861896e-02f, -4.82191369e-02f,
  -1.12021770e-02f, 6.39301166e-02f, 5.71574010e-02f, -5.97978495e-02f, 6.05408661e-03f, -6.61784643e-03f, 2.08401978e-02f, 1.50305638e-02f, 1.24010868e-01f, 9.97789949e-02f,
  1.52952403e-01f, -3.65482941e-02f, -2.85896361e-02f, -3.74856219e-02f, 4.25985195e-02f, -3.12763266e-02f, 3.85493189e-02f, 6.61089504e-03f, -4.83054928e-02f, -5.81652150e-02f,
  -2.25855753e-01f, 3.10808867e-01f, 1.00702435e-01f, -7.06026983e-03f, 1.77189820e-02f, -5.70983365e-02f, 2.51557566e-02f, -3.92548032e-02f, -4.68739904e-02f, -5.28659001e-02f,
  -2.00716238e-02f, 2.14222055e-02f, -1.05006211e-01f, -5.20268194e-02f, 2.01056525e-02f, -1.03874661e-01f, -3.75797637e-02f, 3.62736881e-02f, 9.31383297e-02f, -5.86859621e-02f,
  -5.77130094e-02f, 2.15353593e-02f, -1.09867282e-01f, 3.00435591e-02f, -4.27523144e-02f, -1.28367599e-02f, -1.10522546e-01f, -8.46598074e-02f, -6.88798279e-02f, -1.13502122e-01f,
  5.98647296e-01f, -2.90515482e-01f, -8.24197754e-02f, 1.94304839e-01f, -5.96995316e-02f, -3.68877612e-02f, -1.60259932e-01f, -9.63406339e-02f, 9.09347981e-02f, 3.84263322e-02f,
  8.20747912e-02f, 1.49815381e-01f, 1.29708976e-01f, 1.23529360e-01f, 4.49986644e-02f, 1.37465373e-02f, 5.49160577e-02f, 7.70187527e-02f, 2.67949998e-01f, 1.85901850e-01f,
  1.54949307e-01f, 8.61141607e-02f, 2.93272346e-01f, 1.67850420e-01f, -8.57432857e-02f, 7.25573376e-02f, -1.16624404e-03f, 2.60796472e-02f, -1.65898388e-03f, -2.58960966e-02f,
  -6.80913553e-02f, -1.25982478e-01f, 1.13952383e-01f, 1.22320935e-01f, -1.28087541e-02f, -5.34878559e-02f, 3.47804651e-02f, -8.69019404e-02f, -9.55671445e-02f, -1.00002130e-02f,
  -1.43359289e-01f, -7.42755160e-02f, -1.02384590e-01f, -1.08769685e-01f, -2.71151606e-02f, 4.88238037e-02f, -6.19680099e-02f, 4.87924088e-03f, -9.15388465e-02f, -1.85587332e-02f,
  -1.19212486e-01f, -5.44751659e-02f, -1.39249221e-03f, -1.37982011e-01f, -9.99888331e-02f, 6.72685355e-02f, -8.58200938e-02f, -2.73172874e-02f, -4.47420925e-02f, -1.22504903e-03f,
  1.44224569e-01f, 2.07953125e-01f, 2.34567389e-01f, 2.39390135e-02f, 1.07094437e-01f, 1.70217659e-02f, 1.40143791e-02f, -4.08029445e-02f, 3.60690020e-02f, -2.16632597e-02f,
  3.13518792e-02f, 1.00529470e-01f, 1.23248488e-01f, 4.31428216e-02f, 1.39482021e-01f, 8.57330412e-02f, 1.13414496e-01f, 1.65310562e-01f, 1.22543156e-01f, 2.26305991e-01f,
  1.49578616e-01f, 5.51899821e-02f, 1.02404587e-01f, 2.92995367e-02f, 1.73319086e-01f, 1.45889938e-01f, 2.53181756e-01f, 2.06553802e-01f, 4.12031785e-02f, 1.30290255e-01f,
  -3.30673084e-02f, 8.71686339e-02f, 1.16638198e-01f, -8.07900429e-02f, -2.66635399e-02f, -1.13845423e-01f, 1.59595851e-02f, -3.14695872e-02f, -6.03434779e-02f, -5.01020774e-02f,
  -1.67566627e-01f, -1.43799305e-01f, -9.69836265e-02f, -7.85636753e-02f, 9.67144370e-02f, 1.13832112e-02f, -3.48520428e-02f, -7.79180154e-02f, -2.73577627e-02f, -1.75517648e-02f,
  -6.33087456e-02f, -9.13987085e-02f, 9.56743062e-02f, -2.24491023e-02f, -1.20792091e-01f, 1.26942292e-01f, -2.14954223e-02f, -2.51690652e-02f, -8.06392282e-02f, 5.67436032e-02f,
  -6.13647141e-02f, -5.86924314e-01f, -2.74781346e-01f, -3.76228034e-01f, -3.64832312e-01f, -4.27596241e-01f, -4.82805580e-01f, -4.04061116e-02f, -1.78009234e-02f, -3.43903959e-01f,
  -1.09314144e-01f, 7.91578293e-02f, 5.61791547e-02f, 1.71489120e-01f, 2.99748778e-01f, -2.45653376e-01f, -9.21943635e-02f, 2.34286442e-01f, 2.80635267e-01f, -3.64796049e-03f,
  -1.61096945e-01f, 3.39052826e-02f, 2.54177094e-01f, 7.24892914e-02f, -4.20843869e-01f, -5.27276099e-02f, -3.52356791e-01f, -3.29095036e-01f, -2.91491687e-01f, -4.65274572e-01f,
  -3.43892276e-01f, -2.58011580e-01f, 1.42516747e-01f, 1.96224913e-01f, -1.50078222e-01f, 1.17825307e-01f, -1.55845851e-01f, 1.67365313e-01f, 4.39464487e-02f, -1.31315067e-01f,
  -5.73482774e-02f, 8.25425610e-02f, -3.70681807e-02f, -1.72728896e-02f, -1.77207172e-01f, -6.03934973e-02f, 7.34578446e-02f, 9.67092440e-02f, 7.60108829e-02f, -2.00315461e-01f,
  -3.28892350e-01f, -2.65912801e-01f, -1.66620135e-01f, 1.70392469e-02f, -5.92494607e-02f, 2.33032063e-01f, -1.39879480e-01f, -3.28941107e-01f, 1.28577780e-02f, -5.09314358e-01f,
  -6.04976751e-02f, -4.01685014e-02f, -9.31305587e-02f, 2.52188426e-02f, 9.32279974e-02f, -7.67729804e-02f, -2.65268348e-02f, 3.70284915e-02f, 6.84646219e-02f, -1.70177504e-01f,
  1.71888270e-03f, -7.24484026e-02f, 4.87393364e-02f, -5.61556965e-02f, -1.88458398e-01f, -1.02871202e-01f, -6.69565871e-02f, 3.24686579e-02f, -1.95550523e-03f, -2.52703018e-02f,
  -6.75318167e-02f, -7.30380565e-02f, 4.48314175e-02f, 1.93923116e-02f, -1.89222023e-02f, -1.85308624e-02f, -1.11741707e-01f, 9.23528969e-02f, -7.79345408e-02f, -2.42823530e-02f,
  -5.96200339e-02f, 3.57601821e-01f, -3.96627307e-01f, 1.41742721e-01f, -1.58972472e-01f, 2.16215998e-02f, -6.02866188e-02f, 2.39267543e-01f, 9.52815823e-03f, -1.84887826e-01f,
  -1.98904760e-02f, 5.65310102e-03f, -1.45854115e-01f, 3.07814907e-02f, 1.55032855e-02f, -3.48469280e-02f, 8.52950513e-02f, -9.40276161e-02f, 2.96743829e-02f, -9.43412930e-02f,
  7.84348547e-02f, -1.26641035e-01f, -5.19207679e-02f, -5.15950173e-02f, -1.36702091e-01f, 1.01082958e-01f, -1.49620414e-01f, -2.37938598e-01f, 2.93212645e-02f, -2.20486462e-01f,
  1.20345972e-01f, -4.37048525e-02f, 2.84692675e-01f, 1.26235917e-01f, 1.46878213e-01f, 2.82015055e-01f, 1.98133320e-01f, 1.58309311e-01f, -8.77263956e-03f, 5.93435094e-02f,
  8.28712657e-02f, -1.19713563e-02f, -6.17589103e-03f, 3.44653912e-02f, 1.41604379e-01f, 1.33959666e-01f, 5.40789627e-02f, 1.22541532e-01f, 1.23771399e-01f, 1.61447763e-01f,
  4.47611474e-02f, -4.94836690e-03f, 8.05965289e-02f, 6.19080067e-02f, 3.68826091e-02f, 8.74968022e-02f, 7.09074140e-02f, 5.77220879e-02f, 7.25065097e-02f, 7.72169083e-02f,
  1.27082214e-01f, 1.18119204e-02f, 1.60135403e-02f, -1.37258261e-01f, -3.16672549e-02f, -1.19800165e-01f, -1.13932483e-01f, -3.91816795e-02f, -8.70260596e-02f, -3.66221108e-02f,
  1.10825151e-02f, -1.22704893e-01f, -5.49404100e-02f, -1.44095002e-02f, -8.56111497e-02f, -6.95544556e-02f, -1.23790607e-01f, 1.53292734e-02f, 7.29869530e-02f, 2.46941615e-02f,
  -1.16599470e-01f, -7.60017633e-02f, 5.98498732e-02f, -6.45974129e-02f, 1.01570740e-01f, -4.94350493e-02f, -6.91040158e-02f, 4.63073179e-02f, -5.06680384e-02f, -1.18347220e-01f,
  6.35662153e-02f, 1.06227240e-02f, 4.71406654e-02f, -2.29876805e-02f, 1.33446574e-01f, 6.71115145e-02f, -8.00017267e-02f, 7.32402131e-03f, 3.97739746e-03f, -1.42837092e-02f,
  -9.03650448e-02f, 8.16162676e-02f, 6.25868291e-02f, -1.06577948e-01f, 3.07025481e-02f, 3.24287005e-02f, -5.56272641e-03f, -1.25647798e-01f, 1.01497822e-01f, -2.47512255e-02f,
  5.82129918e-02f, 1.71879642e-02f, -5.44413328e-02f, -8.99703875e-02f, -1.31869182e-01f, -1.12168737e-01f, -7.13498369e-02f, -1.21827699e-01f, -1.51291683e-01f, -5.24325743e-02f,
  -2.31103674e-01f, 1.23331428e-01f, 1.39712960e-01f, -4.41613235e-02f, 3.09035946e-02f, -1.26965910e-01f, 1.62310079e-01f, -4.19567525e-02f, 5.29342927e-02f, -8.00163820e-02f,
  -4.18140553e-02f, 3.91456373e-02f, -3.80566157e-02f, -3.82879600e-02f, -2.85895038e-02f, 3.16100121e-02f, -9.87578034e-02f, 3.07048988e-02f, -1.02077365e-01f, -9.88636613e-02f,
  -1.94407292e-02f, -1.00894988e-01f, 9.18247476e-02f, -2.77324896e-02f, 2.53268760e-02f, -1.50330923e-02f, -8.03278387e-02f, 4.07641158e-02f, -8.35169107e-02f, -1.03623904e-01f,
  4.83257115e-01f, 5.81938565e-01f, 3.82998765e-01f, 8.49489942e-02f, 1.62282899e-01f, -1.50068896e-03f, 5.82118854e-02f, -1.63108289e-01f, -4.16631624e-02f, 2.30716050e-01f,
  1.85075194e-01f, -7.47643933e-02f, -9.88619700e-02f, -2.47505248e-01f, -2.26523578e-01f, -7.20690116e-02f, -4.92941551e-02f, -2.33916730e-01f, -3.86937112e-01f, -2.69324958e-01f,
  -4.77316305e-02f, -2.21530944e-02f, -4.09755819e-02f, -9.11587998e-02f, 2.70826936e-01f, -1.09466188e-01f, 1.00270599e-01f, 2.39566863e-01f, 1.22881852e-01f, 3.73075128e-01f,
  1.33389145e-01f, 4.92299110e-01f, -6.20971680e-01f, -2.72586383e-02f, 2.25543007e-01f, -1.02847569e-01f, -7.81995058e-02f, 5.67982607e-02f, 5.98565340e-02f, -1.04844691e-02f,
  1.29586697e-01f, 8.40385333e-02f, 2.21465275e-01f, 2.03543082e-02f, 2.58862413e-02f, -1.28591195e-01f, -1.76784433e-02f, -1.12471893e-01f, -2.00967520e-01f, 2.83354610e-01f,
  3.41779888e-02f, 2.41195217e-01f, 2.44964749e-01f, -1.09912336e-01f, 4.96146344e-02f, -2.01233014e-01f, 4.85375896e-02f, 7.82419220e-02f, -1.02310799e-01f, 1.65752903e-01f,
  -1.43406272e-01f, 9.55161452e-02f, 2.21215393e-02f, 1.05963603e-01f, -2.35790327e-01f, -3.28861699e-02f, 1.04913086e-01f, 3.41013782e-02f, -1.54794425e-01f, 4.47321199e-02f,
  -8.32712799e-02f, 7.06463261e-03f, 4.56989966e-02f, 6.45440966e-02f, -7.86332637e-02f, 1.36032522e-01f, 3.66848595e-02f, -5.00932261e-02f, -5.68864308e-02f, -8.16097930e-02f,
  -9.93553847e-02f, -3.98058370e-02f, 1.30401269e-01f, 1.17273383e-04f, -6.22664206e-03f, -1.34022720e-02f, -1.17460519e-01f, -1.01077750e-01f, -4.42859940e-02f, -8.53529200e-02f,
  -3.26912701e-01f, -3.48607242e-01f, -1.15088396e-01f, -1.59642309e-01f, 1.72939762e-01f, 5.21136597e-02f, 2.15723105e-02f, 8.00210983e-02f, 1.52005062e-01f, 2.67129000e-02f,
  8.56069177e-02f, -1.29290029e-01f, 1.57970414e-01f, -5.11439741e-02f, -2.08039552e-01f, 2.98573710e-02f, -1.82454556e-01f, -2.52333563e-02f, -1.54044628e-01f, 1.42289862e-01f,
  -2.21444950e-01f, -4.35153455e-01f, -2.26680562e-01f, -2.80374140e-01f, -2.44924858e-01f, -4.33838308e-01f, -3.23280543e-01f, -3.62067491e-01f, -3.95478010e-01f, -3.99741620e-01f,
  1.04691252e-01f, -1.84996456e-01f, 2.69681185e-01f, -2.44936526e-01f, -4.60945368e-01f, -3.76858383e-01f, -4.35744315e-01f, -2.82556683e-01f, -1.47457197e-01f, -2.77642488e-01f,
  -1.26756383e-02f, 4.62681979e-01f, 3.71439725e-01f, 3.08684587e-01f, 3.40594918e-01f, -1.67228013e-01f, -1.75591394e-01f, 4.02144134e-01f, 4.20668334e-01f, -2.06435293e-01f,
  -3.54202867e-01f, -5.52912056e-02f, 9.48753282e-02f, -9.46973264e-02f, -2.31014028e-01f, 6.67626932e-02f, -1.44379124e-01f, -1.38531059e-01f, -2.54529268e-01f, -8.78499076e-02f,
  3.37542802e-01f, -7.87927732e-02f, 3.55477892e-02f, -1.61503777e-02f, -6.10839762e-02f, 1.74803099e-05f, -4.96371873e-02f, -6.37903661e-02f, -8.12424421e-02f, -1.57119915e-01f,
  -1.89588085e-01f, -7.82136340e-03f, -5.88476993e-02f, -7.24523887e-02f, -1.05939724e-01f, -5.59213664e-03f, -1.95393357e-02f, 3.83066759e-02f, 3.97089496e-02f, 6.68303594e-02f,
  -1.79757550e-02f, -1.70415878e-01f, 7.42093697e-02f, -7.96330497e-02f, -8.87043178e-02f, -2.19687391e-02f, -1.79111101e-02f, -1.57849088e-01f, 6.56369105e-02f, -1.18012182e-01f,
  -1.32671848e-01f, 1.37986183e-01f, -1.49451479e-01f, -1.89765558e-01f, -7.69256800e-02f, -1.49875164e-01f, -8.43528733e-02f, -4.97335196e-03f, -1.05133746e-02f, -1.10579558e-01f,
  -9.38593745e-02f, -1.27725497e-01f, -2.10201535e-02f, -3.66835929e-02f, 3.78342830e-02f, 8.56012180e-02f, 2.74092462e-02f, 1.17998580e-02f, -1.06575154e-01f, -1.71700865e-02f,
  -1.16669931e-01f, 2.88163498e-02f, -1.08814932e-01f, -1.06486775e-01f, -1.14130594e-01f, -6.07966036e-02f, -9.63611975e-02f, -2.82997712e-02f, 2.13742275e-02f, -1.62725300e-01f,
  2.85716206e-01f, -8.50434080e-02f, -7.22122984e-03f, 1.02690645e-01f, -1.17163070e-01f, 2.60086395e-02f, -5.77070052e-03f, -1.54877469e-01f, -1.09707259e-01f, 7.99317509e-02f,
  1.12822857e-02f, 9.28827077e-02f, 1.86504554e-02f, 2.58282050e-02f, -1.96616679e-01f, 5.33401035e-03f, -1.31817266e-01f, 1.20369844e-01f, -1.15058832e-01f, -5.47838621e-02f,
  -9.46194213e-03f, -2.08819024e-02f, 1.22405067e-01f, 5.83184175e-02f, 1.65378433e-02f, 1.75452486e-01f, 1.39456093e-01f, 3.44143212e-02f, 1.30557135e-01f, -1.51334524e-01f,
  -5.22472680e-01f, 3.31491858e-01f, 6.02534339e-02f, -3.41716230e-01f, 1.38119593e-01f, 3.28466147e-01f, 4.06651348e-01f, 3.90170142e-02f, -2.87323713e-01f, 9.31115746e-02f,
  8.78332555e-02f, -6.41945750e-02f, -1.21740550e-01f, 2.36022417e-04f, 8.35533217e-02f, 3.39354485e-01f, 1.19179055e-01f, -1.48400232e-01f, -2.36277848e-01f, 1.25567585e-01f,
  1.04206920e-01f, -2.61798173e-01f, -3.05430591e-01f, -5.62060066e-02f, -7.23123252e-02f, -4.40780707e-02f, 5.01249218e-03f, 7.05290213e-02f, 3.02395344e-01f, 2.18682751e-01f,
  -1.55458311e-02f, -1.46026567e-01f, -1.78453073e-01f, -2.36750111e-01f, -3.49171981e-02f, 2.52878722e-02f, 5.06236777e-02f, -1.18863747e-01f, 1.27831012e-01f, -4.03173305e-02f,
  -1.18181640e-02f, -4.33305688e-02f, 1.37834428e-02f, 5.11091575e-02f, -1.50752053e-01f, -1.05842754e-01f, -2.40250021e-01f, -2.65814811e-01f, -2.37182155e-01f, 9.06529725e-02f,
  2.99648285e-01f, 4.51420546e-02f, -1.52105480e-01f, -4.18546610e-02f, -1.07699379e-01f, -2.57813931e-01f, -1.48402974e-01f, -1.48130357e-01f, -2.48424243e-02f, -1.59766763e-01f,
  -4.22827899e-02f, -1.20361596e-01f, -6.93388581e-02f, -1.29387349e-01f, 8.70440807e-03f, 6.50147209e-03f, -5.40390685e-02f, 1.55012429e-01f, 3.93605009e-02f, -8.35747123e-02f,
  4.53649424e-02f, -5.62384538e-02f, -1.68797716e-01f, 4.72267158e-02f, 1.44055843e-01f, -3.61571577e-03f, 4.20446806e-02f, -3.86655284e-03f, 4.15205136e-02f, 3.70331667e-02f,
  4.21780348e-02f, -7.44794309e-02f, -9.84067023e-02f, 8.49222951e-03f, 1.25378355e-01f, -4.87531871e-02f, 1.53186619e-02f, -5.80211654e-02f, -1.35667145e-01f, 1.18181612e-02f,
  -4.60179508e-01f, 2.06015289e-01f, -9.32206362e-02f, -1.18318595e-01f, 1.10290097e-02f, 2.61316989e-02f, 1.15193859e-01f, 8.93322453e-02f, -5.23882080e-03f, -1.44418821e-01f,
  1.56953305e-01f, -2.81104557e-02f, -9.81910154e-02f, -4.08520475e-02f, -7.61111900e-02f, -1.12409338e-01f, 1.96669251e-03f, -6.10414594e-02f, -1.44767642e-01f, -4.51687612e-02f,
  9.53951403e-02f, -1.17203809e-01f, -1.94494218e-01f, -1.03533104e-01f, -1.14950210e-01f, -2.67441690e-01f, -1.42247260e-01f, -1.58374920e-01f, -5.84725700e-02f, -2.89756387e-01f,
  4.63402629e-01f, 3.05958927e-01f, -7.94008449e-02f, 2.53870130e-01f, 7.26164877e-02f, 8.00040513e-02f, 2.35982344e-01f, 1.16585620e-01f, 1.75178006e-01f, 2.21354991e-01f,
  7.14012682e-02f, 1.78462878e-01f, 1.70947060e-01f, 1.50632337e-01f, 1.97234705e-01f, 1.20679110e-01f, -6.11200789e-03f, 1.06244512e-01f, 9.68109146e-02f, 2.06335261e-02f,
  3.55484411e-02f, 2.06383094e-01f, 1.05000593e-01f, 1.63329557e-01f, -4.85725254e-02f, 9.55175236e-02f, 8.63067880e-02f, 1.00822046e-01f, 2.98323110e-03f, -9.25499722e-02f,
  -2.64133185e-01f, -9.84404013e-02f, -7.42039233e-02f, 2.02194508e-03f, -6.52146898e-03f, -1.26694422e-02f, -3.16764936e-02f, 9.98447742e-03f, 4.07545781e-03f, -1.66920014e-02f,
  1.15352254e-02f, -1.02631383e-01f, 5.59830554e-02f, 3.89026031e-02f, 3.04862810e-03f, -5.35868481e-02f, -4.61747013e-02f, -2.21690964e-02f, 1.44472299e-02f, -2.55372915e-02f,
  -6.17369004e-02f, -3.41055281e-02f, -1.19173087e-01f, -8.31152275e-02f, 8.39755982e-02f, -1.11375667e-01f, -5.65159768e-02f, -4.17359881e-02f, -5.20880111e-02f, -4.82432656e-02f,
  3.58663127e-02f, -9.07066185e-03f, 5.50895929e-02f, 1.28794953e-01f, 1.63881674e-01f, -9.05035362e-02f, 3.77368461e-03f, -2.64795292e-02f, -4.78160605e-02f, -1.32627979e-01f,
  -1.58676848e-01f, 3.47976759e-03f, -7.34433606e-02f, -9.32052433e-02f, 8.46818611e-02f, -2.85766274e-02f, -1.04333170e-01f, -8.03733319e-02f, -3.49116027e-02f, -2.24599335e-02f,
  2.88467482e-02f, -1.92140285e-02f, -1.82823315e-02f, -1.15662113e-01f, -2.74277845e-04f, 4.28015925e-02f, 8.19128528e-02f, -5.84794320e-02f, -3.40028815e-02f, 9.49362293e-02f,
  -1.04249036e-02f, -2.25515924e-02f, -5.08857444e-02f, -3.00814444e-03f, -1.34112593e-02f, -6.86293989e-02f, -9.35481116e-02f, -1.46828845e-01f, -2.16412563e-02f, -8.95331353e-02f,
  -1.17137115e-02f, -9.89262015e-02f, -9.09857750e-02f, -4.05749865e-02f, -1.64053872e-01f, -3.12003884e-02f, -8.26900080e-02f, -1.37422150e-02f, 2.99758073e-02f, -1.85002968e-01f,
  -8.27402547e-02f, -6.93932101e-02f, -6.20543547e-02f, 9.31343343e-03f, -4.14142422e-02f, -2.33766772e-02f, -4.70615067e-02f, -1.20604835e-01f, -1.69224143e-02f, -2.54468359e-02f,
  -2.58835256e-01f, 2.72355855e-01f, 2.21997753e-01f, -5.36689937e-01f, -3.36371101e-02f, 3.81117046e-01f, 4.84535635e-01f, 1.65618639e-02f, -4.14636195e-01f, -7.80478567e-02f,
  1.49125010e-01f, -9.43975821e-02f, -8.20418000e-02f, 1.35599926e-01f, 3.14313471e-01f, 7.81314895e-02f, -2.19913393e-01f, -1.31286150e-02f, 1.34964019e-01f, 3.29252899e-01f,
  -4.05922160e-03f, -9.47182998e-02f, 2.06851009e-02f, -5.99074662e-02f, -4.12903935e-01f, -3.17721903e-01f, -7.08576888e-02f, -2.69339960e-02f, 1.85644671e-01f, -3.92992169e-01f,
  2.95065224e-01f, -6.48363261e-03f, -3.83489504e-02f, -1.30672976e-01f, 1.17416799e-01f, -1.51030093e-01f, -8.43873024e-02f, -7.51941949e-02f, -1.09933630e-01f, -8.71114805e-02f,
  -1.03261173e-01f, 3.29780835e-03f, -9.42217931e-02f, 8.83063301e-02f, 1.12475365e-01f, 1.52007833e-01f, -6.06315359e-02f, -6.55563027e-02f, 9.61525366e-02f, 1.98111132e-01f,
  8.41478929e-02f, 9.47317630e-02f, 1.31601870e-01f, 1.39524832e-01f, 5.11896908e-02f, -4.94521149e-02f, 2.02364296e-01f, -1.76590737e-02f, 7.44046420e-02f, -9.09683332e-02f,
  -1.12943441e-01f, -7.49986619e-02f, 1.17641024e-01f, 2.64606811e-02f, 4.59554307e-02f, -1.28126204e-01f, -1.48674935e-01f, 2.15451643e-02f, 1.43864646e-03f, 8.08792785e-02f,
  2.84450036e-03f, 3.28868255e-02f, -1.88097302e-02f, -1.02743544e-01f, -1.38301685e-01f, -4.24035378e-02f, 5.77965900e-02f, 1.80906970e-02f, -1.33252870e-02f, 2.00914481e-04f,
  1.45851718e-02f, -7.63153657e-02f, -1.02174610e-01f, 6.98978826e-02f, 2.30038203e-02f, -1.39799446e-01f, -1.45031825e-01f, 8.78652558e-02f, -3.74950580e-02f, 7.89132621e-03f,
  -8.60622227e-02f, 3.21874231e-01f, -2.47812316e-01f, -1.33630067e-01f, -8.04490298e-02f, -3.09581659e-03f, -1.42279670e-01f, -6.67841583e-02f, 1.10505205e-02f, -3.38743366e-02f,
  1.28347695e-01f, -8.91731605e-02f, 3.77388708e-02f, 5.52570634e-02f, -8.11208934e-02f, -1.92297008e-02f, -8.89456868e-02f, -1.01687819e-01f, 5.37755759e-03f, -1.67473760e-02f,
  -6.41898438e-02f, -4.82986681e-02f, -6.35248050e-02f, -2.22618803e-01f, -1.81404963e-01f, -2.43946120e-01f, 6.76378384e-02f, 5.50423786e-02f, 1.49426147e-01f, -8.12744498e-02f,
  -4.75326180e-01f, 1.45848751e-01f, 4.03200150e-01f, -3.02661210e-01f, 3.95593584e-01f, 4.23930079e-01f, 5.77983618e-01f, 8.53726044e-02f, -2.23059967e-01f, 2.23255277e-01f,
  -8.84060469e-03f, -5.31730235e-01f, -4.05132562e-01f, -3.49392921e-01f, -1.98327839e-01f, 3.75304461e-01f, 4.12970096e-01f, 1.12042502e-01f, -7.83723965e-02f, 7.05423281e-02f,
  -8.57698768e-02f, -2.38271713e-01f, -3.73322606e-01f, -6.62011951e-02f, -1.26164749e-01f, -1.00161180e-01f, 1.74176216e-01f, 6.69142827e-02f, 2.19028249e-01f, -8.19163397e-02f,
  -1.29963040e-01f, 1.23364858e-01f, -2.52167787e-02f, -3.37464251e-02f, 3.06969378e-02f, -2.22780257e-01f, 8.10106099e-02f, -1.85800031e-01f, -8.77868310e-02f, 2.85200290e-02f,
  -1.26586989e-01f, -2.92803407e-01f, -1.67783469e-01f, -2.11313635e-01f, -2.06993967e-01f, -3.96042243e-02f, -2.08400786e-01f, -1.90798908e-01f, -7.22125396e-02f, -8.58066380e-02f,
  -2.85403933e-02f, 2.14740425e-01f, 9.60837677e-02f, 1.72458261e-01f, 9.34143439e-02f, 2.42662486e-02f, 1.00739434e-01f, 2.06042547e-02f, 1.63189679e-01f, -2.89751142e-01f,
  6.76038349e-03f, -1.25869187e-02f, 9.80397090e-02f, -8.27896968e-02f, -7.42617473e-02f, -3.73425782e-02f, -5.45037426e-02f, -4.10158746e-02f, 5.78098558e-02f, -4.36685011e-02f,
  -5.32710627e-02f, -1.04074180e-01f, -4.48923595e-02f, 2.63935551e-02f, -2.44840104e-02f, -6.13824837e-02f, 6.01991676e-02f, -1.37760252e-01f, 7.06606507e-02f, 6.23909459e-02f,
  -1.03993408e-01f, 2.39389390e-02f, 2.34879516e-02f, -2.06559166e-01f, 1.87844306e-01f, 1.29475728e-01f, -4.27246355e-02f, 1.00669496e-01f, -3.02518904e-03f, 2.53683954e-01f,
  -5.75470567e-01f, 2.56938845e-01f, -2.94092357e-01f, 5.68878800e-02f, 6.22467771e-02f, 1.18550055e-01f, -1.54864257e-02f, 4.45437878e-02f, -2.63401922e-02f, -1.09774828e-01f,
  -2.50991452e-02f, -1.66451484e-01f, -1.15024626e-01f, -3.69419940e-02f, -6.11908399e-02f, 4.21092808e-02f, -1.54407760e-02f, 1.79057196e-02f, 9.70533267e-02f, -1.54774152e-02f,
  5.26979044e-02f, 1.26257151e-01f, -1.67450249e-01f, -5.59351854e-02f, 8.92550945e-02f, -1.24925867e-01f, 3.01289279e-03f, 7.69453868e-02f, 1.16752148e-01f, -1.14164256e-01f,
  2.85946429e-01f, -2.67723113e-01f, 9.65561345e-02f, 1.76869377e-01f, 6.23756684e-02f, 1.12428091e-01f, 1.45847276e-01f, 1.83974624e-01f, 1.47948518e-01f, 7.57165859e-03f,
  -1.49960443e-02f, 2.72963375e-01f, 2.20004112e-01f, 2.24375412e-01f, 1.75658241e-01f, 7.94388801e-02f, 1.04075767e-01f, 9.72061455e-02f, 4.90980521e-02f, -3.05801928e-02f,
  9.12943408e-02f, 1.93382264e-04f, -2.71013509e-02f, 4.99216467e-02f, 4.81413417e-02f, 1.36345103e-01f, 6.17947616e-02f, 8.05306956e-02f, -1.05150394e-01f, -1.51582493e-03f,
  -2.12247029e-01f, 9.76096690e-02f, 1.45405009e-01f, 5.47092259e-02f, -1.29859477e-01f, -9.99866948e-02f, 5.90593554e-02f, -3.22394483e-02f, -1.77830338e-01f, -1.41317591e-01f,
  -1.12091087e-01f, -1.42723680e-01f, 3.73922102e-02f, -6.27968758e-02f, -5.66755375e-03f, -4.91403528e-02f, 2.58627050e-02f, 6.67002378e-03f, 3.65680596e-03f, -7.23591819e-02f,
  -1.32898510e-01f, 4.82987203e-02f, 4.22672369e-02f, 1.99311767e-02f, 1.44032270e-01f, 1.83337927e-02f, -8.53496492e-02f, -1.09909646e-01f, -7.21346959e-02f, -9.28771719e-02f,
  8.59203264e-02f, 1.09574497e-01f, 1.54217258e-01f, 1.54279977e-01f, 1.31128758e-01f, 1.01120874e-01f, 6.72056302e-02f, 3.99242714e-02f, 9.15821269e-02f, 1.02616183e-01f,
  3.65603119e-02f, 1.18470863e-01f, 1.67039838e-02f, 1.36781096e-01f, 2.81143282e-02f, 3.94243412e-02f, 5.23913540e-02f, -5.74937882e-03f, 2.63003353e-02f, -1.12185357e-02f,
  1.55418903e-01f, -7.11621195e-02f, -2.00360492e-01f, -2.09344104e-02f, 7.74407340e-03f, -1.49737671e-02f, -2.29116641e-02f, -8.35216641e-02f, 4.44338843e-02f, -7.63245374e-02f,
  4.86915968e-02f, 3.41636747e-01f, 1.47900850e-01f, 3.26422267e-02f, -9.59266126e-02f, -6.99259639e-02f, 1.24130249e-01f, -1.40143588e-01f, -1.16475835e-01f, 8.48735403e-03f,
  -5.17238267e-02f, -7.31043741e-02f, -1.97649677e-03f, -7.14883655e-02f, 4.36303392e-02f, -1.99256707e-02f, -2.39307787e-02f, 1.03579648e-02f, 9.66600105e-02f, 5.53842960e-03f,
  4.18918915e-02f, 3.35155288e-03f, 1.34133518e-01f, 1.60056099e-01f, 2.03264505e-01f, 1.93568736e-01f, 4.29153964e-02f, -4.85070646e-02f, -1.33457640e-02f, 4.77102101e-02f,
  -3.32424939e-01f, -5.87738216e-01f, 1.75783455e-01f, 1.62527367e-01f, -1.23291612e-01f, -3.46671075e-01f, -6.44374788e-01f, -2.16156095e-01f, -4.00652550e-03f, -2.62619078e-01f,
  -4.03838992e-01f, -1.93183258e-01f, -2.24248603e-01f, -7.71839321e-02f, -1.70000643e-01f, -3.51363122e-01f, 1.85659200e-01f, 3.19036841e-01f, 3.19481671e-01f, -1.29850442e-02f,
  -1.65251821e-01f, 1.77607536e-01f, 2.85347760e-01f, 3.24658453e-01f, 4.17772174e-01f, 2.52151579e-01f, 2.61495709e-01f, 2.72248060e-01f, -1.03089057e-01f, 4.19597864e-01f,
  4.85650077e-02f, -7.30019435e-02f, 1.13372855e-01f, 5.59725091e-02f, 8.28072131e-02f, -1.69574067e-01f, -7.16116419e-03f, 1.80774778e-01f, 4.30994853e-02f, 9.77390856e-02f,
  1.71876587e-02f, -6.31102547e-02f, 2.51467768e-02f, 6.67605549e-02f, -1.02701820e-01f, -4.23943922e-02f, 1.90729856e-01f, 1.83022320e-01f, 9.96610448e-02f, -5.07072508e-02f,
  -1.51671767e-01f, 4.62201284e-03f, -2.09329888e-01f, -1.63932696e-01f, -2.27635894e-02f, 1.03640713e-01f, 1.45203665e-01f, 2.08968818e-01f, 6.02278858e-02f, -5.57646118e-02f,
  7.28387609e-02f, 2.92942598e-02f, 3.55611183e-02f, 9.57697481e-02f, -2.10076660e-01f, -3.92454304e-02f, 1.77581921e-01f, -8.08775946e-02f, 5.80691770e-02f, -1.27206832e-01f,
  -1.74117044e-01f, -2.07953826e-02f, 1.49756566e-01f, 7.74444919e-03f, 1.93309039e-01f, 6.05500080e-02f, -1.20307349e-01f, 7.41929635e-02f, 2.63019919e-01f, 1.71197280e-02f,
  -7.19297454e-02f, 2.02543568e-02f, 4.06416133e-02f, -4.47650142e-02f, -2.24691983e-02f, 2.26214424e-01f, 4.88344170e-02f, 2.97229830e-02f, -1.35838566e-03f, -1.58472043e-02f,
  -1.95459515e-01f, 8.37143958e-02f, -1.29322425e-01f, 7.88294375e-02f, 5.46025038e-02f, -3.19900028e-02f, 9.78822038e-02f, 1.34658953e-03f, 9.09197628e-02f, 9.64406133e-02f,
  3.51923667e-02f, -1.79253906e-01f, -5.29417917e-02f, 1.77612919e-02f, 5.99068739e-02f, 3.86289433e-02f, -2.11956754e-01f, -1.42576560e-01f, -5.61035378e-03f, -2.30710823e-02f,
  -5.72456196e-02f, -2.71326602e-01f, -4.14658189e-01f, -5.10389745e-01f, -7.72434473e-02f, -1.49934649e-01f, -3.75007950e-02f, -6.43300563e-02f, -4.29859430e-01f, -4.49138135e-01f,
  2.24832729e-01f, 4.43193972e-01f, -2.92668879e-01f, 1.42908543e-01f, -1.85612082e-01f, -2.16204092e-01f, 3.56322289e-01f, 1.84154227e-01f, 2.29507193e-01f, 4.66924518e-01f,
  9.85563993e-02f, -4.64537442e-01f, -4.61044490e-01f, -4.51905310e-01f, -4.20178950e-01f, 2.14521185e-01f, -1.08289778e-01f, -5.07296026e-01f, -6.81418777e-01f, -2.97826320e-01f,
  -8.57333839e-02f, -1.10173173e-01f, -2.01892018e-01f, -2.03464001e-01f, -1.15281694e-01f, -4.88802642e-01f, -1.92531019e-01f, -3.31157207e-01f, -3.77296269e-01f, -2.46643633e-01f,
  -2.17922017e-01f, 1.04089804e-01f, -1.58984676e-01f, -1.79468729e-02f, 4.96821813e-02f, -1.57006029e-02f, -6.72247112e-02f, -1.29657656e-01f, 1.56618934e-02f, 1.77688837e-01f,
  -1.47722155e-01f, 3.60884480e-02f, -1.44119054e-01f, -2.36352533e-01f, -2.99686715e-02f, 1.05656320e-02f, 8.91684443e-02f, -2.03930229e-01f, -1.58765800e-02f, 1.43006369e-01f,
  1.99778557e-01f, -2.26495087e-01f, -2.90733695e-01f, 2.02510562e-02f, -5.49501814e-02f, -2.89652109e-01f, -1.35694310e-01f, -2.73298800e-01f, -4.55664694e-01f, 9.37006176e-02f,
  2.28753611e-01f, 5.55579998e-02f, -8.89024287e-02f, -3.25359069e-02f, 7.85235316e-02f, 2.40572803e-02f, 6.95213526e-02f, -3.29881124e-02f, -1.68979000e-02f, 5.49218804e-02f,
  5.49377548e-03f, 9.92365628e-02f, 1.15103006e-01f, 4.16627862e-02f, -1.33469850e-01f, 2.69725248e-02f, 7.19651431e-02f, 1.75182179e-01f, -7.68183991e-02f, -1.00222260e-01f,
  -6.51640818e-02f, -5.80937322e-03f, -1.57279864e-01f, -5.65246865e-03f, -9.24007036e-03f, 4.18651365e-02f, 2.07875147e-02f, -5.17465137e-02f, 6.68551773e-02f, 3.66165712e-02f,
  -6.47780076e-02f, -1.66842610e-01f, 1.77835638e-03f, -7.75167495e-02f, 5.62008731e-02f, -7.34429508e-02f, 9.67777520e-02f, 1.14555366e-01f, -9.38117802e-02f, 6.02882914e-02f,
  5.38999476e-02f, 1.55062228e-01f, 3.65373045e-02f, 9.97869764e-03f, -6.15894422e-02f, -5.29758297e-02f, 9.94973406e-02f, -1.30296439e-01f, -2.09473092e-02f, 9.08919275e-02f,
  3.27568978e-01f, 3.51572521e-02f, -5.85696921e-02f, 2.70245160e-04f, -4.60844487e-03f, -2.91894317e-01f, -1.99137285e-01f, -1.96560353e-01f, -2.41041929e-01f, 2.90315658e-01f,
  -1.81918219e-01f, -4.51257885e-01f, -1.47080660e-01f, -4.92854893e-01f, -4.41513389e-01f, -2.98429310e-01f, -2.52915859e-01f, -1.21521823e-01f, -3.04929137e-01f, -2.08291754e-01f,
  -1.14859402e-01f, 4.64365594e-02f, -8.44530091e-02f, 4.99940999e-02f, 1.26566673e-02f, -1.29596502e-01f, -1.45370796e-01f, 4.38284092e-02f, 1.62253082e-01f, -1.38644084e-01f,
  -1.70250520e-01f, -2.25653827e-01f, -1.79315776e-01f, -1.43871307e-01f, -2.82570094e-01f, -1.32909492e-01f, -2.00025797e-01f, -1.77908406e-01f, -6.73793182e-02f, -3.69111300e-01f,
  5.16240671e-02f, 1.38384178e-01f, 1.24058858e-01f, 1.33658096e-01f, 1.11362696e-01f, 8.90425220e-02f, 1.00197665e-01f, -1.06617063e-01f, -4.46110219e-02f, -3.00087128e-02f,
  1.29972468e-03f, 6.97029307e-02f, -2.42705010e-02f, 4.69573848e-02f, -2.13795807e-03f, 1.31401300e-01f, 1.56747326e-01f, 5.37042655e-02f, -1.85711123e-02f, -1.91552117e-02f,
  5.98419793e-02f, -3.06356680e-02f, 8.50849375e-02f, 1.56257376e-01f, 2.02974856e-01f, 2.22120821e-01f, 1.56414419e-01f, 2.29719296e-01f, 2.05758616e-01f, 8.24981928e-02f,
  2.14468930e-02f, 1.07351139e-01f, 1.08879535e-02f, 7.54807070e-02f, 2.81851403e-02f, 2.67669111e-02f, -7.96076208e-02f, -5.10300510e-02f, 1.78586766e-01f, 3.65515128e-02f,
  -1.42681807e-01f, 4.68217544e-02f, 9.11528543e-02f, -2.69387625e-02f, 5.54286465e-02f, 1.41895022e-02f, 3.92460376e-02f, 6.36224374e-02f, 1.60677865e-01f, 4.95555028e-02f,
  7.94112757e-02f, 9.61846020e-03f, -7.58732334e-02f, 2.45451685e-02f, 6.25381200e-03f, -1.70520823e-02f, 1.33063674e-01f, 1.23083666e-01f, 1.28153011e-01f, -6.05212860e-02f,
  2.80262884e-02f, 2.68365890e-01f, -4.43261452e-02f, 1.37148470e-01f, -4.91871312e-02f, 7.74829984e-02f, 3.57068032e-02f, 3.51514411e-03f, -2.23167524e-01f, 7.12962414e-04f,
  7.26166815e-02f, 1.44087955e-01f, 2.31750906e-02f, 1.19602852e-01f, 9.24236029e-02f, 1.47056371e-01f, 1.04300275e-01f, -5.89206964e-02f, 3.14949639e-02f, -8.18558559e-02f,
  5.97423948e-02f, 6.86254278e-02f, 4.51404527e-02f, -7.47944415e-03f, 6.99124932e-02f, 3.50792333e-02f, 6.75965175e-02f, -4.22190176e-03f, -8.69239122e-03f, -1.27658918e-01f,
  3.59250277e-01f, 5.66053689e-01f, -1.31205946e-01f, 1.21384058e-02f, -3.45276862e-01f, -3.16135019e-01f, 1.80657074e-01f, 2.12201566e-01f, -1.98081154e-02f, 2.86595434e-01f,
  -2.49577790e-01f, -3.51274848e-01f, -1.46023542e-01f, -4.96094152e-02f, 1.60709813e-01f, 3.37592661e-01f, 2.68400729e-01f, 7.95824453e-02f, -3.05210739e-01f, -1.59932107e-01f,
  -1.15156077e-01f, -7.88909346e-02f, 5.09662321e-03f, -1.53813977e-02f, 3.81836854e-02f, -2.08126873e-01f, 1.93358377e-01f, -9.19732749e-02f, 5.13412543e-02f, 2.61468947e-01f,
  -2.94990748e-01f, 3.91159672e-03f, -4.55784261e-01f, -1.71743780e-01f, -2.59779155e-01f, -3.13656852e-02f, -4.24525328e-02f, -5.17219231e-02f, 2.50165127e-02f, 2.04752788e-01f,
  -2.80859083e-01f, -2.05900460e-01f, -9.06925425e-02f, -1.89923123e-02f, -1.00875251e-01f, -2.08970532e-01f, 1.50579691e-01f, 2.09147543e-01f, 1.30324855e-01f, -1.49933193e-02f,
  -3.30481566e-02f, -1.24809183e-01f, -1.42901152e-01f, 1.03390150e-01f, 1.44961089e-01f, -2.03728914e-01f, 1.50788531e-01f, 3.50987092e-02f, -2.91946027e-02f, 4.36319172e-01f,
  4.08942550e-02f, -3.88478786e-02f, 7.39884377e-02f, 1.22581579e-01f, 1.28632426e-01f, -3.93237732e-02f, 1.78474505e-02f, -9.08690318e-02f, 2.25553513e-02f, -9.62416232e-02f,
  -4.76091877e-02f, 8.27817768e-02f, -4.37651277e-02f, -1.79605037e-02f, 2.89858375e-02f, 8.35295208e-03f, -6.39854297e-02f, 2.35527053e-01f, 1.14344150e-01f, 5.22210933e-02f,
  -1.48616269e-01f, -3.77792902e-02f, -1.90115809e-01f, 3.64348702e-02f, 9.96156484e-02f, -6.26352131e-02f, 3.46801430e-02f, -2.48970650e-02f, 1.60108507e-01f, -3.80684808e-02f,
  -2.72087634e-01f, -3.04975599e-01f, 2.07808763e-02f, 6.40670583e-02f, 1.82470232e-02f, -1.93792924e-01f, -1.47754759e-01f, -1.65953804e-02f, 2.74242237e-02f, 4.05707657e-02f,
  -1.47567056e-02f, -5.09428966e-04f, 1.68371052e-02f, 1.41573520e-02f, -2.68198460e-01f, -7.33909979e-02f, 8.28491524e-02f, -2.99925525e-02f, 3.57830636e-02f, -8.27743113e-02f,
  2.29349732e-01f, 5.54616861e-02f, -1.07509792e-01f, 2.06492990e-02f, -1.90041866e-02f, -1.43593729e-01f, -6.07606322e-02f, -7.62467682e-02f, 1.06963573e-03f, 3.86975080e-01f,
  2.18527287e-01f, -2.80335277e-01f, -1.28798544e-01f, -1.87686875e-01f, -1.75079331e-01f, -1.24955550e-01f, -5.10476887e-01f, -2.34047845e-01f, -2.78111845e-02f, -4.43781912e-01f,
  4.64681797e-02f, 5.50775409e-01f, 2.98883259e-01f, 3.15262794e-01f, 2.37030938e-01f, -5.24609685e-01f, -4.85624373e-01f, 8.81984532e-02f, 4.78732973e-01f, 5.00953421e-02f,
  -2.18314499e-01f, -1.89264700e-01f, 5.82335256e-02f, -7.54416883e-02f, -4.37270522e-01f, -5.21317199e-02f, -3.50780100e-01f, -3.30037981e-01f, -3.14076185e-01f, -4.77009445e-01f,
  -1.56393304e-01f, 7.16814026e-02f, 1.86978310e-01f, 1.58159032e-01f, -7.21421391e-02f, 8.98062810e-02f, -3.00718918e-02f, -1.68073084e-02f, 8.45090821e-02f, -1.03433348e-01f,
  3.77119705e-02f, 1.36197373e-01f, 1.39487177e-01f, 4.83362079e-02f, -1.24620683e-01f, -1.20687485e-02f, -1.50396321e-02f, 6.21356517e-02f, 4.17069793e-02f, -1.88360617e-01f,
  -2.40547508e-01f, -5.74573241e-02f, 1.59037665e-01f, -1.58405125e-01f, -9.20457020e-02f, 2.92857468e-01f, -1.75745219e-01f, -3.58486176e-02f, 4.39945422e-02f, -5.25053501e-01f,
  -5.13884611e-02f, 2.04523727e-02f, -4.79744421e-03f, -1.46010541e-03f, -5.47016896e-02f, 1.06232548e-02f, 2.07066759e-02f, 1.08032478e-02f, 6.83882907e-02f, -7.53071159e-02f,
  1.16779119e-01f, -4.74228188e-02f, 1.64863858e-02f, -1.47169456e-01f, -3.96741331e-02f, -2.42064465e-02f, -2.77937986e-02f, -7.91344866e-02f, -6.23594075e-02f, -4.90495563e-02f,
  6.58890978e-02f, -1.10149598e-02f, 2.76856385e-02f, -8.77307430e-02f, -5.74147105e-02f, 1.09005690e-01f, 7.25555494e-02f, 3.14529501e-02f, 5.69082389e-04f, 6.61251470e-02f,
  1.40534520e-01f, 3.02114248e-01f, -1.13666981e-01f, 8.35975781e-02f, -1.36880219e-01f, -3.87140140e-02f, -1.46605343e-01f, -3.22051831e-02f, 4.08568308e-02f, 5.18666068e-03f,
  5.81064336e-02f, 8.01408738e-02f, -7.41614550e-02f, 1.95296854e-03f, -4.84228246e-02f, 3.53709310e-02f, -1.32407650e-01f, 8.60874727e-02f, 5.62910363e-02f, -1.66552782e-01f,
  -1.97266161e-01f, 3.93089540e-02f, 1.59375831e-01f, 1.43345725e-02f, -2.70437561e-02f, 1.38868317e-01f, -2.00187966e-01f, -1.40460521e-01f, 2.08252177e-01f, -3.64078045e-01f,
  -6.66603297e-02f, 1.15392566e-01f, 1.14788905e-01f, 1.01142786e-01f, -4.17946845e-01f, -4.07859027e-01f, -4.38716680e-01f, -2.23033562e-01f, -4.50543165e-02f, -4.85759303e-02f,
  -2.32645139e-01f, -2.42219254e-01f, -1.86510924e-02f, -2.64171208e-03f, -2.42334250e-02f, 6.47679791e-02f, 4.19445246e-01f, 1.65680349e-01f, -2.14651048e-01f, -2.39134550e-01f,
  9.76908877e-02f, 3.20062727e-01f, 4.35932100e-01f, 2.04315647e-01f, 1.88076213e-01f, 2.31649294e-01f, 4.49013442e-01f, 1.65749297e-01f, 1.31857589e-01f, 3.93248320e-01f,
  -7.32115954e-02f, -1.76486857e-02f, -4.16759774e-02f, 2.32121572e-01f, 1.31855279e-01f, 1.20223826e-02f, -1.52245417e-01f, 1.39988884e-01f, -1.97905630e-01f, 1.95563631e-03f,
  -1.29618406e-01f, -2.88832560e-02f, -3.20651174e-01f, 1.70053467e-02f, -4.27366607e-02f, -3.71941358e-01f, 3.35996330e-01f, 8.08632076e-02f, 1.10142790e-01f, -2.41610974e-01f,
  -1.55503824e-01f, -2.06542134e-01f, -3.54495496e-01f, -5.97439967e-02f, -2.92337149e-01f, 1.04116590e-03f, -1.52209923e-02f, -1.19409800e-01f, 1.20426089e-01f, 2.79712766e-01f,
  7.63862357e-02f, -1.45528272e-01f, 2.40857769e-02f, 9.98203531e-02f, 1.03701493e-02f, -1.79449052e-01f, 7.73408487e-02f, 1.62087083e-02f, -4.93012480e-02f, -6.74392581e-02f,
  -2.23463729e-01f, -9.91421863e-02f, -8.15560818e-02f, -4.37008590e-02f, -9.92722344e-04f, 9.92508531e-02f, -3.29848193e-02f, 2.05264270e-01f, 6.54756576e-02f, 1.38314158e-01f,
  2.05906667e-02f, -4.12993617e-02f, 1.82399064e-01f, 7.28004053e-02f, 6.05872273e-03f, -2.74027307e-02f, 5.35277985e-02f, 2.26065461e-02f, 1.27113789e-01f, 1.52894899e-01f,
  2.82042772e-01f, 2.63920158e-01f, -1.03398331e-01f, 1.18516214e-01f, -1.47870872e-02f, -8.15363228e-02f, 7.89904129e-03f, 4.22960334e-02f, -1.37152731e-01f, -1.71182528e-01f,
  -2.35940248e-01f, -1.83180720e-01f, -1.46091785e-02f, -8.77552703e-02f, -3.33774626e-01f, -1.98338225e-01f, 6.02401979e-03f, -3.43851209e-01f, -7.11843297e-02f, -1.60920262e-01f,
  -4.05742414e-02f, -1.49346158e-01f, -2.64984697e-01f, -1.99182898e-01f, -1.89949825e-01f, -2.33524874e-01f, -1.94041997e-01f, -1.57916009e-01f, -1.74090281e-01f, -3.85599099e-02f,
  -4.94571298e-01f, -4.19391572e-01f, -4.23508361e-02f, -4.02174979e-01f, 3.00081018e-02f, -1.60058647e-01f, -4.84057456e-01f, -3.02650720e-01f, -3.31833772e-03f, -2.60432631e-01f,
  -4.65803966e-02f, 1.91954434e-01f, -1.53227389e-01f, 2.90689548e-03f, -4.51721758e-01f, -3.66431057e-01f, -2.56064862e-01f, -1.49982020e-01f, 1.36511207e-01f, 2.21323133e-01f,
  2.02004313e-01f, 4.18821760e-02f, 6.79089651e-02f, 3.30627337e-02f, -1.48653211e-02f, 4.54197302e-02f, 3.14167030e-02f, -9.21060592e-02f, -3.91295692e-03f, -1.30584702e-01f,
  -1.12449288e-01f, -3.06178480e-01f, 2.82374680e-01f, 1.25707492e-01f, 2.24434897e-01f, -3.80162406e-03f, -3.22218537e-02f, 4.69138175e-02f, -2.92315264e-03f, -3.50788385e-02f,
  5.75227439e-02f, 1.26067370e-01f, 9.96417850e-02f, 1.36695102e-01f, -1.03837745e-02f, -1.46933153e-01f, 8.11408460e-02f, -4.05246764e-02f, -4.38117608e-02f, 1.60921782e-01f,
  1.22943416e-01f, -5.81655316e-02f, -3.17282528e-01f, -1.73407629e-01f, -1.43938333e-01f, -1.01778440e-01f, -8.84099454e-02f, 3.60947885e-02f, -2.91143149e-01f, -3.99191469e-01f,
  -2.27254760e-02f, 3.32922786e-02f, 1.36220455e-01f, -4.66877595e-02f, -7.10582063e-02f, 3.18368264e-02f, -1.45817995e-02f, -8.80821645e-02f, 8.52621868e-02f, -9.10300314e-02f,
  -8.04858841e-03f, -7.74825811e-02f, -2.19488163e-02f, -1.61441430e-01f, 5.94321564e-02f, -8.23236853e-02f, -1.45119682e-01f, -5.93025088e-02f, -1.35922348e-02f, 5.66984639e-02f,
  -4.09462564e-02f, -1.69199128e-02f, 5.70226647e-02f, -9.78064388e-02f, 8.13773200e-02f, 5.41954376e-02f, -1.77056435e-02f, -3.81817599e-03f, 4.82791625e-02f, -1.43257985e-02f,
  -3.10522318e-01f, 2.77792662e-01f, -3.20867509e-01f, -1.11418955e-01f, -1.01080976e-01f, 2.17538491e-01f, 1.95412915e-02f, 1.23491205e-01f, 5.04237898e-02f, 9.19532850e-02f,
  5.03735952e-02f, -1.82325970e-02f, -6.31241277e-02f, 1.09443814e-01f, 3.06601208e-02f, -1.87384170e-02f, -2.50977337e-01f, -1.60699338e-01f, -9.69987288e-02f, 6.52731434e-02f,
  -1.35986283e-01f, -4.13558632e-01f, -4.56488401e-01f, -4.17473257e-01f, -1.79395661e-01f, -1.98532894e-01f, -2.14580774e-01f, -1.08896904e-01f, -3.80866319e-01f, -4.64090556e-01f,
  -4.48384851e-01f, 2.91817278e-01f, -6.81599140e-01f, 1.95040181e-01f, 1.82409137e-01f, -1.45996004e-01f, 8.63901675e-02f, -5.32449074e-02f, 2.44086087e-01f, 2.72347689e-01f,
  1.65142506e-01f, 1.75401270e-01f, 1.16448052e-01f, 3.93982492e-02f, -2.00189546e-01f, 2.34443232e-01f, 1.46846995e-01f, -4.38052028e-01f, -5.28281927e-01f, -1.87478170e-01f,
  2.35467553e-01f, 6.42694673e-03f, -2.50105381e-01f, -1.00186467e-01f, 3.58933777e-01f, 1.85949475e-01f, 1.58353940e-01f, 1.34813488e-01f, -3.17696179e-03f, 1.36086106e-01f,
  -2.19139770e-01f, -2.41380930e-01f, -2.76319146e-01f, -1.17114708e-01f, -1.43692449e-01f, -1.63457856e-01f, -2.49422312e-01f, -2.13437229e-01f, 2.71053463e-02f, -1.31006360e-01f,
  -4.16581705e-02f, -2.26962596e-01f, -4.65262309e-03f, 1.21241949e-01f, 2.18479931e-02f, -9.80412811e-02f, -1.58553764e-01f, -2.81206846e-01f, -2.24258438e-01f, -3.93640757e-01f,
  1.98655516e-01f, -2.99617827e-01f, -4.76800084e-01f, -1.67281121e-01f, -2.19983175e-01f, -2.46047035e-01f, -2.07425445e-01f, -4.50199962e-01f, -4.84432608e-01f, -1.97472692e-01f,
  -9.31513309e-02f, -5.65794632e-02f, -9.49629918e-02f, 7.88914114e-02f, 1.53425604e-01f, 9.82929915e-02f, 7.24382550e-02f, 9.41909254e-02f, 1.03717536e-01f, -2.03628242e-02f,
  1.92218125e-02f, -9.07212421e-02f, -1.10135853e-01f, 3.15515995e-02f, 1.04838714e-01f, -3.82280201e-02f, -3.85379605e-02f, 1.00555308e-01f, -1.18182860e-01f, 9.26923826e-02f,
  -1.42803015e-02f, 3.90173011e-02f, 1.06019024e-02f, 8.45141858e-02f, 3.20136435e-02f, -8.28657076e-02f, 3.51166911e-02f, 6.38782233e-02f, -2.69327778e-02f, 3.10213882e-02f,
  3.92579705e-01f, -1.05799392e-01f, 7.95542374e-02f, -7.97760263e-02f, -8.54570642e-02f, -2.38621365e-02f, 1.94988269e-02f, -5.32988235e-02f, 1.01393931e-01f, -9.78414714e-02f,
  -2.44960934e-01f, -1.12581521e-01f, 1.66543335e-01f, 1.37416199e-02f, -3.41074057e-02f, -2.15735212e-02f, 8.72376040e-02f, -1.01963528e-01f, -3.28313373e-02f, -1.00245871e-01f,
  3.10010552e-01f, -3.81520651e-02f, -1.13351522e-02f, 4.61741351e-02f, -2.48370785e-02f, 1.22305632e-01f, 4.57533710e-02f, 5.98428352e-03f, -9.75901857e-02f, 2.70075589e-01f,
  4.50764924e-01f, -5.60017228e-01f, 4.02704716e-01f, 1.18341722e-01f, 1.81538627e-01f, 2.06722289e-01f, 6.03568181e-02f, 9.35063213e-02f, 6.33362606e-02f, -1.00294903e-01f,
  -2.32457027e-01f, -9.74133685e-02f, -1.28403921e-02f, -2.58468348e-03f, 4.99569252e-02f, 2.23443717e-01f, 3.22232693e-01f, 4.41461295e-01f, 4.17623013e-01f, 2.04948306e-01f,
  -3.04071400e-02f, 5.07987244e-03f, 1.95641652e-01f, 7.34628662e-02f, 4.01984490e-02f, 8.87885690e-02f, -4.74620983e-02f, -1.00332208e-01f, -7.22703934e-02f, 7.93183669e-02f,
  -6.77962378e-02f, -2.45983899e-01f, 1.40537858e-01f, -2.69786656e-01f, -1.75642639e-01f, -8.98102745e-02f, -3.82600203e-02f, -1.48300864e-02f, -8.66527390e-03f, -1.07335396e-01f,
  -1.88056663e-01f, -2.69411672e-02f, -9.48207527e-02f, -1.29805580e-01f, -1.73912738e-02f, -1.24415588e-02f, -6.12920150e-03f, 8.98513645e-02f, -7.08856508e-02f, -1.70900390e-01f,
  -1.67939901e-01f, -4.45461944e-02f, 1.51747130e-02f, -1.92906633e-02f, -1.11006163e-02f, 1.06397644e-01f, -3.18714678e-02f, 3.97457890e-02f, -2.92845573e-02f, 6.94147497e-02f,
  -1.67662203e-02f, 7.49590546e-02f, 7.06111118e-02f, 1.76905587e-01f, 1.58572406e-01f, 2.11670518e-01f, 1.92972392e-01f, -9.38008912e-03f, 1.25686601e-01f, -3.39559205e-02f,
  6.41098768e-02f, -7.24891527e-03f, 1.34867936e-01f, 7.83495456e-02f, 7.65154809e-02f, 4.76764627e-02f, 2.12929696e-02f, -1.15433022e-01f, -6.71220897e-03f, 9.38053802e-02f,
  1.60334438e-01f, -2.05874406e-02f, -5.78213995e-03f, 6.34351894e-02f, 4.36889455e-02f, 1.83950905e-02f, 4.73992042e-02f, -1.37655362e-01f, -9.41504836e-02f, 6.32351935e-02f,
  -3.39261651e-01f, 6.87653124e-02f, 1.90313622e-01f, -7.06658363e-02f, -2.57248920e-03f, -1.81574337e-02f, -2.13415828e-02f, -1.37963220e-01f, -5.02951257e-02f, -1.80555452e-02f,
  -3.57937478e-02f, -8.07416365e-02f, -4.22024354e-02f, 1.46940881e-02f, 1.70984730e-01f, 6.81259856e-02f, -5.19851185e-02f, 6.60401732e-02f, 3.26919630e-02f, -1.28129527e-01f,
  -1.76637232e-01f, -1.53266229e-02f, 1.82642713e-01f, 3.77310477e-02f, 9.05029774e-02f, 1.83896288e-01f, 1.03531592e-01f, 4.51495200e-02f, 1.28822103e-02f, -2.13570166e-02f,
  4.63092208e-01f, 3.02561671e-01f, 2.78220326e-02f, 3.68117005e-01f, -1.85921073e-01f, -5.55153728e-01f, -4.52028662e-01f, -4.53195155e-01f, -8.64158869e-02f, -1.35196492e-01f,
  -2.12791786e-01f, -3.66664818e-03f, 1.80963054e-02f, 3.16402763e-02f, 1.40596344e-03f, -7.42255896e-02f, 2.48588055e-01f, 3.72536778e-01f, 1.05818823e-01f, 1.35470450e-01f,
  1.53853685e-01f, 3.68997067e-01f, 4.49705124e-01f, 2.27584898e-01f, 2.21306890e-01f, 1.84630081e-01f, -5.30909523e-02f, 2.17586935e-01f, 9.72654223e-02f, 4.71890330e-01f,
  2.76352726e-02f, -2.76635766e-01f, -2.65773535e-01f, 2.30754301e-01f, 1.36322349e-01f, 1.67674631e-01f, -2.81114839e-02f, 8.94966573e-02f, 2.09940951e-02f, 1.09488219e-01f,
  1.07444264e-01f, 3.84855382e-02f, -4.91158366e-02f, 1.47980988e-01f, 6.55611902e-02f, -3.27129453e-01f, 6.66561201e-02f, -5.95770180e-02f, -1.15013891e-03f, -1.55733945e-02f,
  1.08122922e-01f, 7.54538402e-02f, -2.52491891e-01f, -3.86240840e-01f, -1.45994276e-01f, 1.06676303e-01f, -1.32686928e-01f, -1.19057663e-01f, -1.64095908e-01f, 1.64021209e-01f,
  -1.62069812e-01f, 1.83653012e-02f, -4.56875525e-02f, 1.16464309e-01f, 1.86504483e-01f, -6.47280067e-02f, 1.45026520e-02f, 1.14638433e-01f, 1.52685910e-01f, 4.79097590e-02f,
  3.09827980e-02f, 9.80686024e-02f, -1.84947811e-02f, 6.19291840e-03f, 7.00277239e-02f, 5.37206307e-02f, -2.90066861e-02f, 1.40139326e-01f, 7.28298947e-02f, 2.97512896e-02f,
  1.99375432e-02f, -7.51709044e-02f, 5.48217930e-02f, -1.97688192e-02f, 3.55975777e-02f, 2.28232667e-02f, 9.02088061e-02f, 5.64976111e-02f, -2.78625581e-02f, -2.03816053e-02f,
  -6.71985522e-02f, -3.34458560e-01f, 2.98701655e-02f, 4.98183034e-02f, 1.42248292e-02f, -6.58737682e-03f, -7.30587589e-03f, 1.62774399e-02f, 1.23132899e-01f, 9.67281535e-02f,
  6.91337660e-02f, 1.05389513e-01f, 4.77528106e-03f, 9.38987732e-03f, 3.18638533e-02f, -2.66645074e-01f, 6.54237717e-02f, 6.55376390e-02f, -1.63809415e-02f, -9.15182978e-02f,
  1.11764275e-01f, -1.91704219e-03f, -2.07005098e-01f, -2.20691770e-01f, -1.89400405e-01f, -2.09734552e-02f, -1.07925773e-01f, -1.48944199e-01f, -2.66841471e-01f, -1.90434488e-03f,
  -2.39817664e-01f, 1.30806059e-01f, -4.08592582e-01f, 2.19117373e-01f, 3.81495118e-01f, -9.72935036e-02f, -4.05653715e-02f, -1.47276809e-02f, 1.94229692e-01f, 1.11655109e-01f,
  -3.82009856e-02f, 1.41459033e-01f, 3.72172669e-02f, -2.65594069e-02f, -2.85678059e-01f, -2.82036830e-02f, 2.86418974e-01f, -1.64095715e-01f, -2.52730489e-01f, 8.57691243e-02f,
  3.11645895e-01f, 3.31433356e-01f, 1.65544927e-01f, 6.49212301e-03f, 2.26422369e-01f, 1.98059261e-01f, 2.10050359e-01f, 1.47241637e-01f, -1.09685108e-01f, 1.50832161e-03f,
  -7.05312729e-01f, -3.01763624e-01f, -2.88382210e-02f, 3.14669579e-01f, 2.65638474e-02f, -1.36175215e-01f, 4.16111387e-03f, 1.45829633e-01f, 1.66946575e-01f, -4.95796502e-02f,
  2.06930533e-01f, -9.82051045e-02f, 1.97314218e-01f, 6.31854236e-02f, 1.62198961e-01f, -1.18289232e-01f, 1.64883882e-01f, -2.08173007e-01f, -2.38777235e-01f, -1.74361736e-01f,
  2.40056187e-01f, 1.03707299e-01f, -8.75006467e-02f, -1.44890100e-01f, -4.37127292e-01f, -1.81520164e-01f, -1.65487766e-01f, -3.12433332e-01f, -2.85313249e-01f, -1.93783969e-01f,
  -1.63369969e-01f, -2.60483157e-02f, -1.03885300e-01f, 4.00476083e-02f, -9.45156906e-03f, 3.38486061e-02f, -8.42510313e-02f, -1.27598703e-01f, -1.40490010e-01f, 1.35958388e-01f,
  5.68907447e-02f, -1.31792635e-01f, -1.52368397e-01f, -5.65966517e-02f, 1.33791432e-01f, -4.63209450e-02f, -5.72963357e-02f, -1.41282901e-01f, -1.34944931e-01f, -1.32274166e-01f,
  -2.04026587e-02f, -1.68042675e-01f, 7.84911290e-02f, -1.14724286e-01f, -4.70703281e-02f, -2.20611900e-01f, -5.60173094e-02f, -1.14097409e-01f, 9.47815105e-02f, 1.16574645e-01f,
  2.86976814e-01f, 3.05126086e-02f, -2.85762936e-01f, -6.61404282e-02f, -1.95504948e-01f, -7.77278543e-02f, -1.47292569e-01f, -1.84835464e-01f, 2.52179019e-02f, -8.81416351e-02f,
  -9.42259580e-02f, -3.43614638e-01f, 1.14364132e-01f, -4.98714410e-02f, -4.32963520e-02f, 3.51211652e-02f, 8.94085690e-02f, -1.15542203e-01f, -1.67736299e-02f, -4.86992039e-02f,
  2.34529957e-01f, -8.61470774e-02f, -8.73052776e-02f, -2.19096020e-01f, -2.48636398e-02f, -1.41249210e-01f, -9.79618207e-02f, -1.39440253e-01f, -2.67606199e-01f, -9.56494082e-03f,
  3.78923059e-01f, 4.67586875e-01f, 1.00205690e-01f, 2.06724510e-01f, 1.58379048e-01f, 7.34920129e-02f, 2.49016300e-01f, 3.13296318e-01f, 3.12240481e-01f, 1.69684917e-01f,
  2.40327567e-01f, 3.41708660e-01f, 2.53461689e-01f, 2.12700352e-01f, 2.70333916e-01f, 3.11686993e-01f, 1.22087017e-01f, 5.69513291e-02f, -2.18156353e-02f, 1.28486663e-01f,
  2.60453790e-01f, 1.56370476e-01f, 9.25859287e-02f, 6.91557080e-02f, 1.78441495e-01f, 2.15145990e-01f, 1.88576147e-01f, 1.91716999e-01f, 1.97573513e-01f, 2.95806348e-01f,
  -1.52682856e-01f, 1.25926763e-01f, -9.36835185e-02f, -1.25417084e-01f, -1.27412975e-01f, -1.15034401e-01f, 4.82907705e-02f, -1.44352302e-01f, -6.71316404e-03f, -7.33855143e-02f,
  -9.86362696e-02f, 1.59956831e-02f, -5.59952557e-02f, -1.26151159e-01f, -1.88626349e-01f, -2.11397007e-01f, 2.84082443e-02f, 6.09721690e-02f, 1.00768618e-01f, 4.46716920e-02f,
  6.95969313e-02f, -7.10749999e-02f, -8.95202905e-02f, 1.32874837e-02f, 6.47113621e-02f, -9.08342823e-02f, -6.77499548e-02f, 8.16049334e-03f, -6.44076020e-02f, 1.55245028e-02f,
  1.01458654e-01f, 2.22732108e-02f, 1.53495818e-02f, -3.23275998e-02f, 8.82525090e-03f, -1.09411582e-01f, -6.63192421e-02f, -6.87016472e-02f, 7.93995410e-02f, -8.04482773e-02f,
  -6.07462451e-02f, -7.38486275e-02f, 5.26939854e-02f, -2.96546854e-02f, -1.21215940e-01f, 2.21788343e-02f, 3.16368602e-02f, -1.06653117e-01f, -2.27927595e-01f, -3.59303169e-02f,
  -2.65089441e-02f, -6.40358478e-02f, -1.30142257e-01f, -1.72230348e-01f, -1.36729613e-01f, -5.00104055e-02f, -1.18139416e-01f, -6.11256137e-02f, 2.56469324e-02f, 3.99460010e-02f,
  1.04914211e-01f, -1.30212620e-01f, 1.66243687e-01f, 2.09480092e-01f, -5.88046536e-02f, -1.11198299e-01f, 2.14961227e-02f, -4.28569838e-02f, -3.57296914e-02f, -6.34139627e-02f,
  -1.50132686e-01f, 1.32040018e-02f, -7.98946097e-02f, 2.03034338e-02f, -1.84855565e-01f, -1.19480975e-01f, 1.17592625e-01f, 2.04467073e-01f, 3.03431693e-02f, 5.75121343e-02f,
  3.33479010e-02f, 3.00163217e-03f, -1.27977490e-01f, -1.20521486e-01f, 7.09341466e-03f, -3.72197777e-02f, -1.53020173e-01f, -4.37477790e-02f, -6.91799223e-02f, -5.07187024e-02f,
  -1.73824102e-01f, -1.79357156e-01f, 2.23880008e-01f, -2.85094708e-01f, -9.26999450e-02f, 1.16574772e-01f, 2.43299171e-01f, 1.07760884e-01f, -7.14761764e-02f, 1.41258523e-01f,
  5.12023922e-03f, -7.81657174e-03f, 3.95673476e-02f, -5.79029582e-02f, 5.05142361e-02f, 2.68605500e-01f, 1.21352546e-01f, 1.48319483e-01f, 3.70204151e-02f, -1.25408351e-01f,
  -1.61108717e-01f, -1.83556467e-01f, -2.48797864e-01f, -1.97312757e-01f, -2.53106028e-01f, -2.70389821e-02f, -8.67305323e-02f, -7.94571266e-02f, 5.63356020e-02f, 1.37931490e-02f,
  2.37132207e-01f, -3.34482670e-01f, 1.16692290e-01f, -1.77598432e-01f, -5.15208654e-02f, -6.60682213e-04f, 1.18104227e-01f, -8.38843584e-02f, -8.51835981e-02f, -2.51879860e-02f,
  -2.97149904e-02f, -3.29105109e-02f, -1.69768650e-02f, -6.97452426e-02f, -3.49374413e-02f, -3.76082249e-02f, -1.94550857e-01f, -1.60148978e-01f, -1.45899042e-01f, -1.10301552e-02f,
  -1.71172366e-01f, -1.40787289e-01f, -5.11151105e-02f, -3.60071659e-02f, -3.36595774e-02f, -5.70053756e-02f, -8.64519849e-02f, -3.48081440e-02f, -6.90039322e-02f, -2.97288299e-02f,
  -3.01353149e-02f, 8.38180929e-02f, 3.05723809e-02f, 1.28185302e-02f, -7.03431293e-02f, 6.95002973e-02f, -4.72135097e-02f, -2.78918131e-04f, 8.74925405e-02f, 1.41502082e-01f,
  -1.31808491e-02f, 8.91728103e-02f, 1.48261666e-01f, 7.53947273e-02f, 1.04808882e-01f, 6.03490546e-02f, 5.80652021e-02f, -5.57998614e-03f, 4.53002527e-02f, 1.58306360e-01f,
  5.03201745e-02f, 1.97971445e-02f, 9.51910838e-02f, 2.03090906e-01f, 1.14935122e-01f, 9.27068144e-02f, 1.26286194e-01f, 3.62843499e-02f, 5.12492545e-02f, 9.68382284e-02f,
  1.70315325e-01f, 2.52026822e-02f, 1.93184420e-01f, -6.59649745e-02f, 5.32646999e-02f, -4.77983057e-02f, 1.01606585e-01f, 2.71646772e-02f, -3.89708541e-02f, -7.53786042e-02f,
  2.13698782e-02f, -4.34136130e-02f, 1.07184447e-01f, 3.37708648e-03f, 1.10225201e-01f, 1.05637662e-01f, -1.27260506e-01f, -4.00117747e-02f, 6.31691441e-02f, 2.38860454e-02f,
  -7.14475363e-02f, 9.11060125e-02f, 2.66620815e-01f, 1.25187248e-01f, -7.57274479e-02f, 6.54635504e-02f, 1.99029326e-01f, 6.80965781e-02f, 1.61103979e-01f, 2.42382824e-01f,
  -1.32397994e-01f, 8.00203979e-02f, 5.51092565e-01f, 6.00276664e-02f, -1.47083715e-01f, -3.32855135e-01f, -3.89135331e-01f, -1.92475662e-01f, -9.85381566e-03f, -6.27519339e-02f,
  -1.45757481e-01f, -1.02875695e-01f, 2.84294903e-01f, -9.72570255e-02f, -1.47069752e-01f, 4.06932011e-02f, 1.41567543e-01f, 1.68230966e-01f, -3.35157543e-01f, -6.67699456e-01f,
  -3.27581644e-01f, -1.97511718e-01f, -8.18200707e-02f, -8.43126848e-02f, 1.39743581e-01f, -4.77136821e-02f, 4.52348650e-01f, 1.08060829e-01f, -4.01326381e-02f, 2.55709141e-01f,
  8.53570104e-02f, 9.60993096e-02f, -3.50922346e-02f, 1.47262542e-02f, 1.25999495e-01f, 6.59952685e-02f, -2.38673296e-02f, 1.19364284e-01f, -4.75892350e-02f, 6.94884732e-02f,
  4.96107666e-03f, -1.14981562e-01f, 8.53117183e-02f, 9.09352768e-03f, -1.02843486e-01f, -1.47669122e-01f, 1.16287628e-02f, 1.15928352e-01f, 2.19132885e-01f, -6.56883046e-03f,
  -3.93854916e-01f, -3.20156634e-01f, 1.50570020e-01f, -1.62287056e-02f, 1.36659279e-01f, 5.92732280e-02f, -4.75807674e-02f, -2.04206347e-01f, 1.38364732e-01f, -9.79143381e-03f,
  -6.71201646e-02f, 6.70364574e-02f, 6.66455254e-02f, 7.17887059e-02f, -7.40635246e-02f, 1.79731220e-01f, 7.82524645e-02f, -4.95212413e-02f, 1.75006911e-01f, 9.45040062e-02f,
  -2.41653770e-02f, 2.94791106e-02f, 6.37188926e-02f, 1.49608165e-01f, 1.62872106e-01f, -3.00409365e-03f, -1.55573174e-01f, -1.11937717e-01f, 5.73626123e-02f, -1.10233262e-01f,
  -5.04084900e-02f, 1.35720402e-01f, 1.03473850e-01f, -4.31348197e-02f, 1.60660058e-01f, -5.79748712e-02f, -4.44428809e-02f, -6.63442016e-02f, 1.55548230e-02f, -6.59171492e-02f,
  -1.60428628e-01f, 1.17862813e-01f, -7.66987503e-02f, -1.04295142e-01f, 7.64326565e-03f, -3.40887606e-02f, 4.26127426e-02f, -1.12365253e-01f, -5.57612441e-02f, -1.81859612e-01f,
  -1.79724187e-01f, -5.06837480e-02f, 1.00845225e-01f, 3.03636175e-02f, -2.43360728e-01f, -2.97452626e-03f, -3.22620243e-01f, 2.22158413e-02f, -6.68978617e-02f, -1.27226010e-01f,
  -4.18438502e-02f, -4.95707422e-01f, -2.82350719e-01f, -2.20993593e-01f, -2.12819472e-01f, -1.68868169e-01f, 1.12220962e-02f, -1.76756680e-01f, -2.57476419e-01f, -3.48720461e-01f,
  6.15236461e-01f, 5.07734492e-02f, 2.55216919e-02f, 9.80327800e-02f, 1.64642155e-01f, 2.07246944e-01f, 3.20304483e-01f, 2.49319896e-01f, 1.38570443e-01f, -7.43222795e-03f,
  5.12626469e-02f, -1.14327364e-01f, -2.00584605e-01f, -1.61968425e-01f, -9.54856426e-02f, -1.85964584e-01f, -1.75142184e-01f, -1.40808955e-01f, -9.92764235e-02f, -1.12822384e-01f,
  -1.93668932e-01f, -4.78568561e-02f, -9.81044769e-02f, -2.38822594e-01f, -2.34258994e-01f, -2.07421765e-01f, -2.05835439e-02f, -2.02358533e-02f, -1.71399534e-01f, -2.92188287e-01f,
  -4.17677760e-01f, 1.35925665e-01f, -8.76112357e-02f, -2.28498384e-01f, -1.00775823e-01f, -1.72013473e-02f, 4.04349566e-02f, 8.07556212e-02f, 1.24917552e-01f, -6.06238395e-02f,
  -1.35942221e-01f, -1.56326070e-01f, -2.40861867e-02f, -3.72314528e-02f, 1.33443698e-01f, 9.06690508e-02f, 2.20039487e-01f, 7.90421143e-02f, 4.46013957e-02f, -6.20704740e-02f,
  -8.41655806e-02f, 2.38783345e-01f, 2.33434543e-01f, 1.91338748e-01f, 2.28569999e-01f, 7.37535357e-02f, 1.21728674e-01f, 3.30333635e-02f, 1.10262573e-01f, 2.11346745e-01f,
  -1.66117921e-01f, 1.36868167e-03f, 2.57570855e-02f, 1.30081370e-01f, 1.71828225e-01f, 1.33322075e-01f, -9.87098645e-03f, 6.43065199e-02f, 7.81793296e-02f, -2.18492490e-03f,
  -7.91682675e-02f, -3.56227998e-03f, 1.08448818e-01f, -1.65034980e-01f, -1.39745936e-01f, 2.18118932e-02f, 3.10302172e-02f, -5.56148216e-02f, -6.47110343e-02f, 1.97245162e-02f,
  -1.34827614e-01f, -1.90738700e-02f, -1.48237631e-01f, -1.51158631e-01f, 5.70968054e-02f, 2.13506259e-02f, -2.14858074e-02f, -1.10775381e-01f, -3.23913037e-03f, -1.06669314e-01f,
  -3.68067682e-01f, -1.58456415e-02f, -2.00462177e-01f, -1.56376839e-01f, -2.34045857e-03f, -1.04233764e-01f, -1.45552427e-01f, -9.33836028e-02f, 1.64509043e-02f, -1.30844116e-01f,
  5.83697669e-02f, -1.61499292e-01f, -1.57716125e-01f, -2.58606672e-02f, 7.90116787e-02f, -1.26410425e-02f, 1.25900894e-01f, 1.33310750e-01f, -4.36440669e-02f, -7.08757564e-02f,
  5.18937334e-02f, 2.15401500e-01f, 7.24334866e-02f, 3.60908993e-02f, 1.76640436e-01f, 3.89232114e-02f, 9.59724281e-03f, 6.74549565e-02f, 2.53224410e-02f, 1.80047438e-01f,
  5.79584062e-01f, 3.62138063e-01f, 4.34261560e-02f, 7.11578503e-02f, -6.33357987e-02f, -1.63367718e-01f, -5.44015020e-02f, -1.38977706e-01f, -1.51989117e-01f, 2.24096090e-01f,
  2.67403480e-02f, -7.10664466e-02f, 1.06702773e-02f, -1.32651195e-01f, -5.35670370e-02f, 1.40085685e-04f, -8.12770575e-02f, -1.09240390e-01f, -3.71235073e-01f, -3.00715238e-01f,
  -1.18371144e-01f, 1.11127131e-01f, -4.77589779e-02f, -6.47615269e-02f, 1.75529271e-01f, -1.36263728e-01f, 1.40941054e-01f, 1.59191057e-01f, -5.15023842e-02f, 2.28034630e-01f,
  2.11884990e-01f, 2.67080635e-01f, -3.85424316e-01f, -1.06490068e-01f, 1.17271669e-01f, 1.17641263e-01f, 1.11805581e-01f, 1.84254304e-01f, 5.24396077e-02f, 2.13062003e-01f,
  1.46953911e-01f, 1.10453755e-01f, 6.80001453e-02f, 1.13955528e-01f, 8.74017552e-02f, -8.69173482e-02f, -1.57673042e-02f, -1.22745059e-01f, 3.95106524e-02f, 8.15106332e-02f,
  3.67535017e-02f, 7.29558021e-02f, 1.00973345e-01f, -1.30024940e-01f, -6.22739866e-02f, -5.51927760e-02f, -5.79108000e-02f, -3.52856144e-02f, -1.14476725e-01f, 8.34440142e-02f,
  -1.04064224e-02f, 1.00018434e-01f, 9.33396146e-02f, 2.73129325e-02f, 1.51415661e-01f, 5.36188781e-02f, 1.65009543e-01f, 6.35975674e-02f, 3.39786895e-02f, 3.17018144e-02f,
  -9.33123287e-04f, -2.16166396e-02f, 1.43500850e-01f, 5.28497957e-02f, 5.90727814e-02f, 9.98948589e-02f, 1.02124818e-01f, 8.26167539e-02f, 8.62474814e-02f, 1.46146834e-01f,
  2.30205543e-02f, -3.56846601e-02f, 8.62818584e-02f, 5.96550032e-02f, -5.97805828e-02f, -1.92054966e-03f, 8.64034425e-03f, -1.69517007e-02f, -1.14531470e-02f, 5.68185300e-02f,
  -1.07677892e-01f, -3.23821545e-01f, -1.25517428e-01f, -1.20517135e-01f, 1.33221328e-01f, -4.20295112e-02f, 6.65788874e-02f, 3.72503996e-02f, 1.11040585e-02f, 9.63175222e-02f,
  4.28340286e-02f, 3.07289008e-02f, 1.52776361e-01f, -1.60746370e-02f, -9.83954743e-02f, -4.39578816e-02f, 1.38929710e-01f, -8.19873363e-02f, -1.43789291e-01f, 9.57132056e-02f,
  -1.93306673e-02f, -1.41853750e-01f, -1.73425049e-01f, -7.12900534e-02f, -1.39574297e-02f, -1.38697818e-01f, -5.19821458e-02f, -1.54141441e-01f, -2.02848569e-01f, -1.93562135e-02f,
  -2.24031627e-01f, 2.36092627e-01f, 1.04269832e-01f, -2.30908766e-01f, -2.59362966e-01f, -1.75315902e-01f, 2.90583014e-01f, -5.48042394e-02f, -2.42805675e-01f, 2.05795377e-01f,
  1.63419634e-01f, -8.76604244e-02f, -6.87407255e-02f, -1.23331614e-01f, 8.14773664e-02f, 2.63075590e-01f, 1.15529485e-01f, -1.40072852e-01f, -2.33881041e-01f, -2.51459569e-01f,
  7.91411567e-03f, -1.61636904e-01f, -7.46717900e-02f, -1.69001713e-01f, -9.40869376e-02f, -1.74295634e-01f, -1.99580267e-02f, -1.17965668e-01f, -1.01309337e-01f, -1.34553120e-01f,
  1.67572245e-01f, -2.72618979e-01f, -1.35383293e-01f, -1.77256852e-01f, 3.56925726e-02f, 1.56307951e-01f, 2.90159602e-02f, 2.14203708e-02f, 6.64107222e-03f, 7.12356642e-02f,
  8.22066050e-03f, -7.37969279e-02f, -6.45614266e-02f, 1.61337145e-02f, -2.13123709e-02f, -5.25943451e-02f, -1.68482304e-01f, -1.21853324e-02f, -9.82868001e-02f, -1.06291831e-01f,
  -1.00747615e-01f, -8.03018883e-02f, 6.86160550e-02f, -4.50581461e-02f, -2.00163513e-01f, -4.37408537e-02f, -1.91022921e-02f, -1.38857841e-01f, -7.21330121e-02f, 1.17046990e-01f,
  -1.14038542e-01f, 1.24316439e-01f, 1.16040530e-02f, 1.57730311e-01f, 1.85562134e-01f, 1.08036868e-01f, 8.98533240e-02f, 1.43271208e-01f, 9.88979824e-03f, 1.06732123e-01f,
  7.82161206e-02f, 2.62748092e-01f, 1.84758857e-01f, 2.71813244e-01f, 1.98134780e-02f, 1.01563483e-01f, 1.25567451e-01f, 2.13619664e-01f, 6.23615598e-03f, -3.54136457e-03f,
  4.28138562e-02f, 2.67152209e-02f, -3.81543487e-02f, 2.00477928e-01f, -2.55870018e-02f, -3.36197056e-02f, -2.57123038e-02f, 9.51086283e-02f, -9.58266035e-02f, 1.00579241e-03f,
  2.69007057e-01f, -5.51593527e-02f, 6.77941740e-02f, -9.91359800e-02f, -7.24957064e-02f, -6.58886880e-02f, 7.72645697e-02f, 1.23045012e-01f, 9.49434713e-02f, 5.85384183e-02f,
  -1.03110865e-01f, 1.66256115e-01f, 1.67181462e-01f, 7.24873617e-02f, 8.55630487e-02f, 6.89150691e-02f, 6.28501922e-02f, 5.74191846e-02f, -2.67679319e-02f, -9.60947946e-02f,
  6.27296418e-02f, 2.80657429e-02f, 2.03617096e-01f, 6.00406937e-02f, 4.16105874e-02f, 2.68700179e-02f, 2.76145160e-01f, 5.06968163e-02f, 1.06837086e-01f, 3.25335324e-01f,
  4.80615884e-01f, -1.41902342e-01f, -4.26595271e-01f, 3.54752541e-01f, -2.31167868e-01f, -4.33917999e-01f, -4.77328181e-01f, 8.50388408e-02f, 3.16659361e-01f, 3.71098518e-02f,
  -8.91536251e-02f, 2.08133936e-01f, 2.79676080e-01f, -9.94796455e-02f, -1.36259452e-01f, -1.95404142e-01f, -1.02669127e-01f, -3.69544417e-01f, -5.29299200e-01f, -5.42288363e-01f,
  -4.28028286e-01f, -1.64674446e-01f, -2.38304734e-01f, -1.19913355e-01f, 1.18187256e-02f, -3.86857651e-02f, -2.55048238e-02f, -2.09596843e-01f, -5.15554428e-01f, -2.85964966e-01f,
  -4.38982666e-01f, -1.61382139e-01f, 3.59576792e-02f, 1.10016033e-01f, -2.57066339e-02f, 1.50966331e-01f, -2.42194179e-02f, 8.67564753e-02f, 1.78268149e-01f, 9.14838314e-02f,
  9.36866552e-02f, 1.21600050e-02f, -5.55068441e-02f, 5.76695986e-02f, -7.96399415e-02f, 3.61494124e-02f, 1.29438024e-02f, 5.30090407e-02f, 7.23159239e-02f, -2.33135894e-02f,
  -3.85692827e-02f, -1.44312322e-01f, 4.81307022e-02f, 1.31727546e-01f, -5.46297133e-02f, -7.71393925e-02f, -7.35280216e-02f, -3.58253084e-02f, 4.78247963e-02f, 2.13000715e-01f,
  -1.77004308e-01f, 4.28098440e-02f, 2.14671250e-02f, -5.64395897e-02f, 1.36372715e-01f, -4.45860060e-04f, -1.17911492e-02f, 3.48684266e-02f, -4.79302332e-02f, -5.16807102e-02f,
  1.51140109e-01f, -4.69085127e-02f, -7.71900639e-02f, -8.34052861e-02f, -9.34836790e-02f, 8.32356978e-03f, -3.19350399e-02f, -8.18339288e-02f, 6.81760237e-02f, 1.77034423e-01f,
  3.01798210e-02f, -4.89517068e-03f, 3.67553830e-02f, -8.68133605e-02f, -1.25328988e-01f, 9.29024294e-02f, -9.51763336e-03f, -8.96474055e-04f, 8.32650587e-02f, 1.21011061e-03f,
  1.49192482e-01f, -1.58252418e-01f, 8.67935196e-02f, 7.81779587e-02f, 4.48008180e-02f, -1.95821356e-02f, 5.84626794e-02f, 1.44396592e-02f, -9.16487202e-02f, -1.44454464e-01f,
  -6.02009892e-02f, 4.27712314e-03f, 8.15645326e-03f, 2.52096597e-02f, -8.21553618e-02f, -1.30544350e-01f, 4.49072160e-02f, -2.22804565e-02f, -5.24579175e-02f, 1.19487472e-01f,
  1.13737896e-01f, 1.00563109e-01f, 1.80562392e-01f, 4.95120697e-02f, 6.05327152e-02f, 1.01329368e-02f, -3.02376524e-02f, -3.47696468e-02f, -4.38221134e-02f, 1.32283881e-01f,
  -4.57709551e-01f, 4.19733047e-01f, -4.16876972e-01f, -1.83724701e-01f, -2.13313505e-01f, -7.59205148e-02f, 3.83075655e-01f, 2.74098784e-01f, -5.95407560e-03f, 1.81379855e-01f,
  1.23396188e-01f, -1.05557600e-02f, 5.16849849e-03f, 1.07363015e-01f, 1.76265240e-01f, 3.07876855e-01f, 1.64875120e-01f, -3.45830262e-01f, -1.99454293e-01f, 2.86053494e-02f,
  2.10655645e-01f, 4.49417830e-02f, -8.92314985e-02f, 8.91953632e-02f, 1.33381933e-02f, -1.36518469e-02f, 4.34744507e-02f, -1.53626144e-01f, 1.02363259e-01f, 2.52918452e-02f,
  -1.14352100e-01f, -2.73932338e-01f, -1.46539032e-01f, -1.12412073e-01f, -2.15204179e-01f, -2.87326425e-02f, -5.05194664e-02f, -2.07410932e-01f, -1.33607343e-01f, -1.86276454e-02f,
  -1.31507650e-01f, -1.67298704e-01f, -5.43992333e-02f, 3.46832983e-02f, -1.10762797e-01f, -1.45747215e-01f, 2.74484679e-02f, -1.83735654e-01f, 1.75688379e-02f, 5.11058606e-04f,
  5.23382835e-02f, -1.91563696e-01f, -2.43716344e-01f, 1.03773270e-02f, -4.91997674e-02f, -1.10966668e-01f, -6.99358582e-02f, -2.01915100e-01f, -7.55715966e-02f, 8.43728483e-02f,
  -7.81194568e-02f, -3.36078256e-02f, -6.80840388e-02f, -1.40693216e-02f, 1.54902607e-01f, 3.50932255e-02f, -9.53472219e-03f, 2.55629923e-02f, 4.34943549e-02f, 4.47285324e-02f,
  7.57337641e-03f, 1.76629782e-01f, 1.00799784e-01f, 3.58011909e-02f, 1.05726786e-01f, -6.64136410e-02f, -7.60462210e-02f, 1.19143285e-01f, -4.18622931e-03f, -2.53661685e-02f,
  -5.67427166e-02f, -7.21360417e-03f, -1.07221669e-02f, 6.94527477e-02f, -5.22514991e-02f, -1.22323610e-01f, 1.03615513e-02f, 1.17724843e-01f, -3.04657333e-02f, 3.36926803e-02f,
  5.68042040e-01f, 1.46905174e-02f, 1.61112800e-01f, 9.26377475e-02f, 7.85809290e-03f, 4.41965163e-02f, 2.57281326e-02f, -2.36600987e-03f, -1.01253211e-01f, 4.57443371e-02f,
  2.45249290e-02f, -3.72477807e-02f, 4.14053760e-02f, 3.77652496e-02f, 3.68966796e-02f, 2.12921854e-02f, 2.12985143e-01f, -1.16424270e-01f, 1.50837153e-01f, 4.45133932e-02f,
  2.08560526e-01f, 7.07195625e-02f, 9.80369002e-02f, 1.38044626e-01f, 4.39000502e-02f, 2.99291983e-02f, 1.04412585e-01f, 6.33259192e-02f, 7.33668953e-02f, 3.07600260e-01f,
  4.98495787e-01f, 4.41584587e-01f, 2.95943618e-01f, -1.38410002e-01f, -1.05227150e-01f, -1.18413955e-01f, -2.79275954e-01f, 3.94588560e-02f, 9.04032513e-02f, 2.01691151e-01f,
  2.83775419e-01f, -1.74435288e-01f, -1.43095985e-01f, -2.30510339e-01f, -2.01310679e-01f, -3.93051393e-02f, -1.64448828e-01f, -1.07697457e-01f, -1.96478099e-01f, -2.63834566e-01f,
  -2.08310828e-01f, -7.68966451e-02f, 1.09835841e-01f, -4.47776318e-02f, 2.80629337e-01f, -3.81461494e-02f, 1.25763252e-01f, 3.30144346e-01f, 2.12738961e-01f, 4.31650162e-01f,
  3.33375931e-01f, 6.31121218e-01f, -4.65813965e-01f, -5.35374358e-02f, 2.90592052e-02f, -1.09418146e-01f, -9.20750499e-02f, 1.02408864e-01f, 1.44472374e-02f, -4.78352513e-03f,
  -6.81404839e-04f, 2.44622961e-01f, -5.71041740e-02f, -1.52674556e-01f, 3.36961411e-02f, -1.21881403e-01f, 2.20083967e-02f, 4.68291901e-02f, -2.24512935e-01f, 3.14943194e-01f,
  -3.92081469e-01f, 7.39352703e-02f, 1.75122023e-01f, -8.92646015e-02f, 6.90046176e-02f, -2.35918343e-01f, 3.66290845e-02f, 2.19701290e-01f, 6.76791091e-03f, 3.43936235e-01f,
  -4.62296456e-02f, 1.03928708e-01f, -8.09785351e-03f, 1.45061731e-01f, -1.32488132e-01f, -1.35155476e-03f, -4.93879952e-02f, -9.55807194e-02f, -2.31361426e-02f, 3.04006096e-02f,
  4.06379532e-03f, 2.06182338e-02f, -5.75790219e-02f, 3.41153219e-02f, -6.43738508e-02f, -1.18422462e-03f, -7.80286193e-02f, -9.05410796e-02f, -3.12463529e-02f, 3.62814292e-02f,
  -1.46714136e-01f, -4.96112779e-02f, 8.00531805e-02f, -2.86041368e-02f, 2.12740481e-01f, 2.73622759e-03f, 4.12073098e-02f, -1.21948244e-02f, 1.69828966e-01f, 1.78978875e-01f,
  -3.31399798e-01f, -3.33496213e-01f, -4.42087315e-02f, 4.64124456e-02f, 4.63409796e-02f, -3.69940558e-03f, -3.51084806e-02f, 2.76127178e-03f, 7.96822533e-02f, 4.37358767e-02f,
  1.39893582e-02f, -8.56552795e-02f, -3.35821733e-02f, -9.75956693e-02f, -1.77895859e-01f, -1.29106328e-01f, -3.50573003e-01f, -3.49333018e-01f, -1.98012561e-01f, 2.31670849e-02f,
  -4.09410179e-01f, -3.43787372e-01f, -4.32311624e-01f, -2.34730199e-01f, -4.29452471e-02f, -5.22920787e-01f, -2.78119981e-01f, -1.64609104e-01f, -4.29522574e-01f, -3.68918717e-01f,
  -6.23459995e-01f, -1.69029534e-01f, -3.61842573e-01f, -5.45577526e-01f, -1.84260905e-02f, 1.79063067e-01f, 1.73782736e-01f, 1.51453584e-01f, -2.35855669e-01f, -3.04737777e-01f,
  -8.35978519e-03f, 1.81328982e-01f, -1.60746560e-01f, -3.20018753e-02f, 5.69919907e-02f, -2.56655604e-01f, -4.97350365e-01f, -3.73795390e-01f, 3.49580526e-01f, 6.88983738e-01f,
  1.85962960e-01f, -2.48941883e-01f, -2.69920200e-01f, -8.92949179e-02f, -1.47489142e-02f, -6.90559819e-02f, -4.30104285e-01f, -2.32751653e-01f, -8.82870108e-02f, -5.32395720e-01f,
  5.44833355e-02f, -1.36566386e-01f, 1.02942102e-01f, -7.28043541e-02f, -1.30041409e-02f, -6.81184307e-02f, 1.69328526e-02f, -3.49884294e-02f, -1.10374056e-01f, -1.82504520e-01f,
  8.33163038e-03f, 1.13982640e-01f, 3.23148468e-03f, 1.55946627e-01f, 2.01627277e-02f, 1.00075170e-01f, -5.07409386e-02f, -1.54939681e-01f, -1.02578692e-01f, 1.38792157e-01f,
  1.02481321e-01f, -2.15101093e-01f, -2.43705049e-01f, 7.33016199e-03f, 3.73010077e-02f, -1.16415769e-01f, 1.59609243e-01f, 2.05321983e-01f, -9.11261439e-02f, -1.55695483e-01f,
  5.28562665e-02f, -1.69486813e-02f, -2.73421407e-02f, 2.03618199e-01f, 2.87978211e-03f, 1.01033999e-02f, -1.16266116e-01f, 3.58777121e-02f, 1.36272013e-01f, 3.93866412e-02f,
  -3.48428190e-02f, -3.85835953e-02f, 3.46808359e-02f, -1.48271415e-02f, 2.57804077e-02f, -1.61622018e-01f, -5.59237897e-02f, -1.91352498e-02f, -3.51690538e-02f, -1.74664155e-01f,
  -1.20188020e-01f, 1.39015857e-02f, -1.02634132e-01f, 1.09657913e-01f, -9.53764394e-02f, -4.26206179e-02f, 2.01992858e-02f, 1.31298199e-01f, 8.77859816e-02f, -4.26077843e-02f,
  2.02838495e-01f, -1.32827625e-01f, -1.93901062e-01f, 2.51863208e-02f, -4.44286540e-02f, -2.13372391e-02f, -1.08991548e-01f, -6.29833946e-03f, -1.99692741e-01f, 5.86027242e-02f,
  1.39782310e-01f, -2.97886524e-02f, -7.18978643e-02f, 1.27803147e-01f, 1.74854293e-01f, 1.35499407e-02f, -7.23818615e-02f, -8.64395723e-02f, -7.27759227e-02f, 1.84594393e-02f,
  -1.03094988e-01f, -1.71878323e-01f, -2.35574916e-01f, -1.27424493e-01f, -3.91454156e-03f, -1.06573053e-01f, 6.24320358e-02f, 1.46280229e-01f, -3.77427936e-02f, -2.52123233e-02f,
  -6.38477147e-01f, 2.44144529e-01f, 6.95254132e-02f, -1.27845109e-01f, 4.28482108e-02f, 2.98092179e-02f, 3.54784429e-02f, -1.21574644e-02f, -1.51463792e-01f, 4.12007496e-02f,
  4.72199358e-02f, 8.80827606e-02f, 9.95816104e-03f, 3.54614519e-02f, 2.26341261e-04f, 5.72137423e-02f, -1.60813965e-02f, -1.13905095e-01f, -1.73025534e-01f, 8.13454315e-02f,
  2.37237364e-02f, -4.59965542e-02f, -1.77291080e-01f, -5.69553114e-02f, 9.21633691e-02f, 9.95462015e-02f, 1.20760903e-01f, 1.72160134e-01f, 2.09759653e-01f, 3.21440369e-01f,
  4.47802514e-01f, -3.92959937e-02f, -7.24722147e-02f, 6.35333732e-02f, 3.99531536e-02f, -1.01777785e-01f, -9.03025493e-02f, 2.25849822e-02f, 2.35772990e-02f, 1.48486853e-01f,
  7.43614361e-02f, 5.40771969e-02f, 2.36107800e-02f, 9.21069533e-02f, 3.12454179e-02f, 8.76268595e-02f, -1.19851418e-01f, 8.08021948e-02f, -2.99451430e-03f, 8.91827941e-02f,
  1.24179341e-01f, 8.47711340e-02f, -8.09087139e-03f, 4.70045581e-02f, -4.90827113e-02f, 5.65223768e-03f, 1.93556712e-03f, -7.75511712e-02f, 1.28566539e-02f, -1.24214962e-01f,
  1.17901117e-01f, -3.01980525e-02f, -1.19788349e-01f, -1.43108904e-01f, -1.68374956e-01f, -1.64289355e-01f, 5.03727347e-02f, 3.48104686e-02f, -7.62786642e-02f, -1.74607620e-01f,
  -2.16904539e-03f, -2.08744034e-02f, -1.38159081e-01f, 3.79641633e-03f, 7.52308294e-02f, 1.02032311e-01f, -1.02038383e-02f, 8.89445841e-02f, -1.67803504e-02f, 2.12721992e-02f,
  -1.21039100e-01f, 4.46807314e-03f, 3.73678207e-02f, 1.71169803e-01f, 1.30405471e-01f, 3.31614651e-02f, 1.83037911e-02f, -3.91941890e-03f, 6.40471354e-02f, 9.60108191e-02f,
  2.82120854e-01f, -1.94973767e-01f, -9.25560296e-03f, -2.26079095e-02f, 3.69933434e-02f, 7.99005702e-02f, 1.13250483e-02f, 8.56342688e-02f, 2.23727778e-01f, 8.38459954e-02f,
  2.55814544e-03f, 8.12595058e-03f, -1.27290552e-02f, -6.08108416e-02f, -1.47235036e-01f, 6.68690950e-02f, -6.18113279e-02f, -5.45634329e-02f, 5.42174317e-02f, 2.13217571e-01f,
  6.93962872e-02f, 2.44773529e-03f, 5.64455576e-02f, 4.51369956e-02f, -1.30038127e-01f, -2.44116243e-02f, -9.66067333e-03f, 1.31513104e-01f, -2.28026658e-02f, -3.14477272e-02f,
  5.34086704e-01f, 1.84313029e-01f, -4.86669540e-02f, 3.02825533e-02f, -1.08094886e-03f, -1.72205687e-01f, 2.69226935e-02f, -2.22430885e-01f, -1.73122078e-01f, -8.83481931e-03f,
  6.72228113e-02f, -4.24738415e-02f, -6.71601295e-02f, -6.45399764e-02f, -1.30170450e-01f, -1.80077523e-01f, -1.51566491e-01f, 1.12555772e-01f, 6.07916936e-02f, 2.06000417e-01f,
  2.18970224e-01f, 1.91358194e-01f, 2.72410631e-01f, 6.82879314e-02f, 1.99532554e-01f, 1.50859216e-02f, -1.40016358e-02f, 1.79777026e-01f, 1.79567352e-01f, 2.06946179e-01f,
  2.60901660e-01f, 2.38295197e-01f, -6.96105063e-02f, 6.52373433e-02f, 2.91624498e-02f, -3.17823887e-02f, 2.80530211e-02f, -4.02643569e-02f, -1.14047855e-01f, -4.63861600e-02f,
  6.45966455e-02f, 7.95289129e-02f, 2.26144064e-02f, -2.37664976e-03f, -1.68618262e-02f, 5.53556234e-02f, 1.36569841e-02f, -5.85230105e-02f, -3.40438709e-02f, 2.65724771e-02f,
  -9.66534615e-02f, 9.02580768e-02f, -1.37394816e-01f, -2.12469712e-01f, -1.10241011e-01f, -1.74959719e-01f, -1.95967518e-02f, -7.10309446e-02f, -1.61392853e-01f, -9.82610732e-02f,
  -2.61826515e-01f, -4.78451215e-02f, 9.06405225e-03f, -2.09680393e-01f, -1.08721055e-01f, -6.60753101e-02f, -4.08658534e-02f, -1.88230962e-01f, -1.55696437e-01f, -4.92056198e-02f,
  -1.23130105e-01f, -7.12413564e-02f, -8.77737403e-02f, 3.33315134e-03f, -1.43989921e-01f, -1.02485798e-01f, 2.87682600e-02f, 3.19636501e-02f, -1.43946275e-01f, 7.58857746e-03f,
  4.00695438e-03f, -5.23280762e-02f, -4.61858623e-02f, -3.49661596e-02f, -6.77851811e-02f, -8.41892287e-02f, -1.24257654e-01f, -1.23878211e-01f, -1.84340492e-01f, 5.68237975e-02f,
  -2.25377351e-01f, -8.38176981e-02f, 1.60031572e-01f, 1.20596349e-01f, 1.06631599e-01f, 6.96979314e-02f, 1.07018808e-02f, -2.13699993e-02f, 8.92885402e-02f, 3.75493392e-02f,
  1.33362696e-01f, 4.61582951e-02f, 9.59757995e-03f, -1.47075253e-02f, 1.17958514e-02f, 3.96837778e-02f, -7.03450665e-03f, -4.87895794e-02f, -7.91608915e-02f, -1.53072774e-02f,
  4.83544059e-02f, -1.04703940e-01f, -9.64854360e-02f, -2.45871857e-01f, -7.98331276e-02f, -1.94283128e-01f, -8.59737694e-02f, 4.76957336e-02f, -9.68274772e-02f, -1.69476569e-01f,
  4.68045563e-01f, 2.51736641e-01f, 1.00051999e-01f, 8.79645050e-02f, -1.17064103e-01f, 9.58126113e-02f, 7.58687407e-02f, 8.75742584e-02f, -6.90256283e-02f, 1.63902864e-01f,
  1.57298669e-01f, -1.86764225e-02f, 8.86382014e-02f, 9.95332673e-02f, -1.68533120e-02f, -3.66338566e-02f, -1.44208148e-01f, 4.89929728e-02f, 2.43065730e-02f, 2.61831619e-02f,
  -1.18788950e-01f, 9.92229953e-02f, 1.89180389e-01f, -4.77637053e-02f, -8.42842907e-02f, -1.75677449e-01f, 7.07463175e-02f, 4.07240503e-02f, 1.49999531e-02f, -2.98104495e-01f,
  -1.65590793e-01f, 2.35928819e-01f, -1.62877247e-01f, 8.50386452e-03f, 9.82339531e-02f, 3.20341624e-02f, 7.28226826e-02f, -2.81598382e-02f, -3.58385816e-02f, -3.35359015e-02f,
  -3.86303626e-02f, 1.03702784e-01f, 6.84616715e-02f, -6.09122403e-02f, -2.35751681e-02f, -3.63804363e-02f, 1.29560024e-01f, -4.46433276e-02f, -4.41515893e-02f, 9.12231281e-02f,
  3.80781963e-02f, 4.02923264e-02f, 1.11632511e-01f, -7.82179981e-02f, 6.11048974e-02f, -4.89384830e-02f, -6.30924404e-02f, -1.34903928e-02f, 5.31934900e-03f, 6.08631819e-02f,
  5.05284928e-02f, 1.11999862e-01f, 2.64574997e-02f, 2.32304446e-02f, 1.01212375e-01f, 6.78752363e-02f, -1.10516623e-01f, 1.02942809e-03f, -3.60068344e-02f, 3.78933037e-03f,
  -9.25984513e-03f, 1.48835629e-01f, 2.87632309e-02f, 5.77123910e-02f, -1.77159663e-02f, 1.22773878e-01f, -4.31927741e-02f, 6.75718039e-02f, 1.47854134e-01f, 1.14570267e-01f,
  -3.33722644e-02f, 1.13750920e-01f, 4.28992771e-02f, -3.01640779e-02f, 4.86702211e-02f, -4.11236696e-02f, 6.61309287e-02f, 1.49586916e-01f, 1.10939905e-01f, 1.55674294e-01f,
  -5.69312498e-02f, 1.52774885e-01f, -3.08751352e-02f, -1.27258778e-01f, -2.68460494e-02f, -6.62976205e-02f, -1.30138040e-01f, -1.18143000e-01f, -8.07552263e-02f, 1.10144599e-03f,
  -3.27660553e-02f, -9.32971984e-02f, 1.09598577e-01f, -7.15472847e-02f, 7.29077728e-03f, -1.48489792e-02f, 7.17962757e-02f, -7.26653412e-02f, 1.71994809e-02f, -3.13700251e-02f,
  3.67486067e-02f, 1.78715661e-02f, 3.27096060e-02f, -1.27930611e-01f, 1.47542497e-02f, 1.83155178e-03f, -1.07785776e-01f, -1.43343449e-01f, -6.92871884e-02f, -9.55406353e-02f,
  -2.79680640e-01f, -2.53977627e-01f, -1.63999140e-01f, -7.60830566e-03f, -9.16707292e-02f, -9.78416502e-02f, -2.70948291e-01f, -2.21570954e-01f, -1.64374579e-02f, -1.01691857e-01f,
  1.63554654e-01f, 2.77469486e-01f, 2.30128527e-01f, 1.70683607e-01f, -4.73805629e-02f, -1.20563254e-01f, -8.88493136e-02f, -5.33007681e-02f, 3.83145511e-02f, -3.01612727e-02f,
  1.77090568e-03f, -1.34461988e-02f, -1.38054326e-01f, 5.29852249e-02f, 3.99468802e-02f, 1.41286448e-01f, 3.07148304e-02f, 2.17898134e-02f, -6.51512742e-02f, 1.00301400e-01f,
  3.48660469e-01f, 8.10042992e-02f, 1.34130880e-01f, 5.73353916e-02f, -1.03836678e-01f, -1.85187832e-01f, 2.88177654e-02f, -1.21581763e-01f, -2.14141998e-02f, -7.70892277e-02f,
  2.75716204e-02f, 2.96785147e-03f, 2.93546226e-02f, 4.51648571e-02f, 2.59954985e-02f, -1.36592553e-03f, -4.47083563e-02f, 5.77390231e-02f, -1.04547702e-02f, 4.76264879e-02f,
  -8.33994057e-03f, -1.77128706e-02f, 1.12438358e-01f, -1.83676276e-02f, 1.07044011e-01f, 1.10136978e-01f, 7.66084623e-03f, 1.07582346e-01f, -2.38991328e-04f, 1.16411939e-01f,
  3.14404815e-03f, -1.80502042e-01f, 2.00758234e-01f, 1.53294429e-01f, 1.58789888e-01f, -6.70458749e-02f, 1.04899015e-02f, 1.39371762e-02f, -5.53951487e-02f, -1.08131945e-01f,
  2.72473115e-02f, 2.06463620e-01f, 1.68926083e-02f, 4.89475690e-02f, 9.56422463e-02f, -1.46641359e-01f, -5.44810668e-02f, 8.81540254e-02f, 2.06712559e-01f, 4.24470119e-02f,
  1.05356149e-01f, -1.10509440e-01f, -6.21680059e-02f, 2.86735538e-02f, 6.97233304e-02f, 6.19991049e-02f, 5.09679690e-02f, -6.11147331e-03f, -1.64355785e-01f, -8.58177319e-02f,
  1.77778438e-01f, 3.85584325e-01f, 8.67369249e-02f, 1.16285123e-01f, -3.32730711e-02f, -1.82927877e-01f, 2.00297430e-01f, -2.42232326e-02f, -5.57756573e-02f, 4.05527763e-02f,
  -3.03904731e-02f, -6.76442683e-02f, -4.87646759e-02f, 8.65651742e-02f, 9.38103944e-02f, 7.86684453e-02f, 9.24818292e-02f, -2.07898691e-02f, 2.74285022e-02f, -2.16445443e-03f,
  -1.79940864e-01f, -9.14799422e-02f, 3.01126316e-02f, 2.50406619e-02f, 7.91391879e-02f, 5.02621755e-02f, 8.08117539e-02f, 8.55730698e-02f, 3.79837006e-02f, -2.20095720e-02f,
  2.95006037e-01f, 3.75689805e-01f, 5.26312552e-02f, 9.78284180e-02f, 2.17215180e-01f, 3.66974482e-03f, -1.52616426e-01f, -3.03581029e-01f, 1.02442680e-02f, -7.91493878e-02f,
  3.58761638e-01f, 1.56889483e-01f, -1.48263931e-01f, -2.97253489e-01f, -4.66187268e-01f, -5.17137349e-01f, -3.61032665e-01f, -3.79633009e-01f, -3.27284783e-01f, -2.61423260e-01f,
  -1.42828926e-01f, -1.40693232e-01f, -2.12852478e-01f, -3.56170356e-01f, -1.62524611e-01f, -2.25127235e-01f, -2.18931779e-01f, -2.31299952e-01f, -9.94425938e-02f, -2.43323937e-01f,
  -3.58409584e-01f, 1.63615793e-01f, -9.01060030e-02f, 6.21060356e-02f, 9.09291059e-02f, -7.71954516e-03f, 8.47625732e-02f, 4.35029753e-02f, 9.53424051e-02f, 4.12590317e-02f,
  1.42327294e-01f, -1.29776951e-02f, -6.64246306e-02f, -9.56539884e-02f, -7.98949227e-02f, -3.44500095e-02f, -1.54699311e-01f, -1.72782168e-01f, -4.09172922e-02f, 1.26561299e-01f,
  8.21530819e-02f, 1.21952608e-01f, 8.34756419e-02f, 4.83505093e-02f, -1.08733848e-01f, 1.69690419e-02f, -1.06343925e-01f, -3.78253423e-02f, -4.81399074e-02f, -3.06034144e-02f,
  -1.96698293e-01f, -5.18326163e-02f, -5.01351692e-02f, 1.07216775e-01f, 1.18935835e-02f, 2.67792027e-02f, -1.52436107e-01f, -1.11768499e-01f, 1.00121405e-02f, -1.13229014e-01f,
  -4.65174243e-02f, 1.15493089e-02f, 6.18836693e-02f, -4.77632806e-02f, -6.51850998e-02f, -4.99137342e-02f, -4.26869206e-02f, -1.64797112e-01f, -3.18417698e-02f, -1.56367317e-01f,
  -2.91886199e-02f, -8.21370035e-02f, -1.11380681e-01f, -1.79764450e-01f, -7.10039660e-02f, -5.71588613e-02f, 1.20238690e-02f, -4.11270447e-02f, -8.80093873e-02f, 2.78726909e-02f,
  -1.99587554e-01f, 2.01842119e-03f, -1.53332904e-01f, -1.41392007e-01f, -6.24761060e-02f, 1.17180701e-02f, 2.24813253e-01f, -1.81432604e-03f, -1.04450611e-02f, -1.02149718e-01f,
  -4.75214235e-02f, -5.46759693e-03f, 6.74623773e-02f, -1.83352549e-02f, -6.93648010e-02f, -5.80434576e-02f, 5.29578142e-02f, -1.09849066e-01f, -4.79242131e-02f, 1.99964568e-01f,
  1.21722639e-01f, -2.40881424e-02f, -6.30036071e-02f, -1.36393368e-01f, 1.81651264e-02f, -9.90807265e-02f, -2.47315869e-01f, -1.98088944e-01f, -2.28577927e-01f, -3.10413837e-01f,
  2.95805871e-01f, -2.26575449e-01f, 1.79033116e-01f, 4.01230939e-02f, -4.42372821e-02f, -6.37000054e-02f, -1.16026953e-01f, -1.50827736e-01f, -9.57193151e-02f, -3.40047367e-02f,
  -1.54590175e-01f, -1.33159459e-01f, -2.48277500e-01f, -1.17456138e-01f, -1.57000721e-01f, -5.15919775e-02f, 2.11554408e-01f, 1.68812707e-01f, 1.84737206e-01f, 2.18580619e-01f,
  9.77483019e-02f, 2.48312905e-01f, 1.49451584e-01f, 1.22149229e-01f, 6.09690696e-03f, 1.04569048e-01f, -6.44830838e-02f, 9.08690020e-02f, -9.77117345e-02f, 9.51657072e-02f,
  2.47277021e-01f, -1.63880855e-01f, 1.34079114e-01f, -1.17646046e-01f, 6.70914203e-02f, -6.13107346e-02f, -3.96628007e-02f, 6.93364143e-02f, -7.98537806e-02f, -2.37001609e-02f,
  -5.79258353e-02f, -3.52367051e-02f, -1.50339872e-01f, -2.59232689e-02f, -1.26939965e-02f, 3.26887853e-02f, -2.08943132e-02f, -1.47502452e-01f, -6.68179765e-02f, -1.53927848e-01f,
  -9.16815624e-02f, -5.58887571e-02f, 3.83563600e-02f, -1.20135754e-01f, -1.75126046e-01f, -9.65368226e-02f, -1.26585171e-01f, -1.13293089e-01f, -1.81619767e-02f, -1.84432883e-02f,
  1.28366977e-01f, -4.65891548e-02f, -2.16149911e-01f, -6.59202859e-02f, -1.87642291e-01f, -2.33349018e-02f, -1.15186036e-01f, -1.23793632e-01f, -2.10768133e-01f, -1.18198078e-02f,
  -1.45184755e-01f, -1.83836907e-01f, -1.40031114e-01f, -5.49888937e-03f, -6.27848804e-02f, -9.04628262e-02f, -8.62839669e-02f, -1.01913065e-02f, -1.19836569e-01f, -5.18732406e-02f,
  -1.14952125e-01f, 2.10178737e-02f, 4.93010655e-02f, 5.69709353e-02f, 1.24307591e-02f, -7.64694959e-02f, 3.05972435e-02f, -1.46239474e-01f, 9.54887122e-02f, 9.88356322e-02f,
  4.34819162e-02f, -3.51333886e-01f, 7.27947950e-02f, -7.54695684e-02f, 3.69925611e-02f, -1.14597566e-01f, -2.24216521e-01f, -1.41039595e-01f, -1.23562872e-01f, -4.47078608e-02f,
  -1.21063637e-02f, -4.58839834e-02f, -1.19650647e-01f, -3.73693146e-02f, 2.34947637e-01f, 1.33279487e-02f, 3.01346481e-02f, 8.45964774e-02f, -6.84807375e-02f, 7.07541555e-02f,
  4.49808547e-03f, 9.55756307e-02f, 2.03958273e-01f, 3.90407853e-02f, -3.05385366e-02f, 1.54548302e-01f, 9.50179175e-02f, 1.35861874e-01f, 6.90467507e-02f, 2.85340846e-01f,
  -4.19843465e-01f, 4.69392747e-01f, -4.00478780e-01f, 6.98129758e-02f, 7.66831636e-02f, 1.24264255e-01f, 5.35376251e-01f, 3.07165056e-01f, 1.85845375e-01f, 3.64131719e-01f,
  -1.49942666e-01f, -3.58186632e-01f, -1.80990696e-01f, -1.46212250e-01f, 1.03474699e-01f, 5.13105690e-01f, 3.55376244e-01f, -3.60329777e-01f, -4.17024940e-01f, -1.56148346e-02f,
  1.82892293e-01f, -1.47771001e-01f, -2.96311349e-01f, -2.02186316e-01f, 8.51599947e-02f, -1.21418200e-01f, 6.51203319e-02f, -2.30277553e-01f, -6.16363473e-02f, 4.06249892e-03f,
  -5.64896345e-01f, -4.39882129e-01f, -2.55711377e-01f, -2.36727342e-01f, -2.42567331e-01f, -4.08473462e-02f, 9.23024565e-02f, -2.11360723e-01f, 8.18364099e-02f, -4.25301455e-02f,
  -5.10077085e-03f, -1.18898772e-01f, -1.50918663e-01f, -7.60404915e-02f, -1.35842949e-01f, -7.23111406e-02f, 4.15964350e-02f, -2.32365415e-01f, -2.57011443e-01f, -2.06331924e-01f,
  1.62665933e-01f, -1.77440390e-01f, -4.32614863e-01f, 1.53727621e-01f, -4.60970663e-02f, -2.80754000e-01f, -8.48616809e-02f, -2.86764324e-01f, -4.45542991e-01f, -9.69924778e-03f,
  1.56409502e-01f, 2.22404495e-01f, 1.50966316e-01f, 7.38299415e-02f, 3.10973618e-02f, 4.46999073e-02f, 4.16307896e-02f, 1.41394669e-02f, -4.49375510e-02f, -9.30343270e-02f,
  -1.04891181e-01f, -8.04472528e-03f, -7.57132098e-02f, -2.98227668e-02f, 1.30617380e-01f, -4.03110571e-02f, 5.00896052e-02f, 8.75311345e-02f, -3.24578993e-02f, -5.92784164e-03f,
  -1.05474748e-01f, -8.83256507e-05f, -1.35536864e-01f, -1.67298689e-02f, -3.67359556e-02f, 8.69262218e-03f, 6.50642514e-02f, -9.58014056e-02f, -8.31852406e-02f, -5.22870086e-02f,
  -2.86558658e-01f, -8.05309191e-02f, 5.34290858e-02f, -4.01295274e-02f, -1.15393743e-01f, -2.26845276e-02f, 2.47858800e-02f, 1.22765101e-01f, -2.54393313e-02f, -7.48384297e-02f,
  5.72342612e-02f, 1.46095917e-01f, -9.62872803e-02f, 4.91637439e-02f, -1.08930543e-01f, 1.99633583e-01f, 3.37996423e-01f, 1.11737177e-01f, 1.29660621e-01f, -2.14510243e-02f,
  3.34427714e-01f, 1.90046206e-01f, 8.35867375e-02f, 1.62866399e-01f, 8.34854916e-02f, 1.32112382e-02f, -8.44536200e-02f, -1.35774389e-02f, -1.10814862e-01f, 5.81328988e-01f,
  4.47288960e-01f, -3.78388673e-01f, -2.18795478e-01f, 2.35065341e-01f, 2.66494691e-01f, 1.57414451e-01f, 4.01498713e-02f, 7.74503797e-02f, 1.07009180e-01f, -6.96208775e-02f,
  -1.38469726e-01f, -1.67613104e-01f, -8.05293173e-02f, -1.88698962e-01f, -1.83238745e-01f, -1.30264670e-01f, 1.38754159e-01f, 9.35394168e-02f, 1.35653257e-01f, 1.66704372e-01f,
  7.72152767e-02f, 6.26786500e-02f, 8.01193640e-02f, -1.23912916e-01f, -1.82390213e-01f, -1.02777898e-01f, -9.00107846e-02f, -2.03741699e-01f, -1.54322252e-01f, -1.67411089e-01f,
  -3.54124755e-01f, -2.16770977e-01f, 8.67432505e-02f, -6.87315390e-02f, -9.93782468e-03f, -1.35909757e-02f, 7.31004775e-02f, -1.10756569e-01f, 3.14241275e-02f, 1.03738077e-01f,
  -2.48980541e-02f, -6.31695688e-02f, -1.05135687e-01f, -4.70907241e-03f, -9.40347165e-02f, -3.36313657e-02f, -1.11400168e-02f, -6.74429014e-02f, -1.36380747e-01f, -1.77793980e-01f,
  -1.15658872e-01f, -8.54349434e-02f, -1.01572081e-01f, -2.70407591e-02f, -7.38895908e-02f, 2.24572532e-02f, -1.04733594e-01f, -4.89814803e-02f, -8.26849565e-02f, 8.23818222e-02f,
  -1.68768689e-02f, -1.83335125e-01f, -2.91943438e-02f, 1.17755599e-01f, 3.74590117e-03f, 1.16467945e-01f, 1.52403027e-01f, 8.56000930e-02f, 4.37246915e-03f, 5.88089675e-02f,
  8.62493441e-02f, -2.54329462e-02f, -7.98558444e-02f, -3.44902650e-03f, -2.93600815e-03f, -2.12679356e-01f, -2.51949988e-02f, -1.17949180e-01f, -1.03640750e-01f, 3.69908325e-02f,
  -6.90205172e-02f, -1.40462043e-02f, -9.04638469e-02f, -1.51299283e-01f, -9.29677039e-02f, -4.42894995e-02f, -1.28770068e-01f, -1.56617045e-01f, -5.32334819e-02f, -3.60365286e-02f,
  -8.09101388e-02f, 7.93267563e-02f, 1.22934468e-01f, -1.01277575e-01f, -1.12364106e-01f, -8.38941112e-02f, -8.12139809e-02f, 3.40343565e-02f, 6.44264445e-02f, 4.86794747e-02f,
  -1.09780662e-01f, -3.64829712e-02f, -1.48362368e-01f, 3.56513374e-02f, 1.76706195e-01f, 2.38573481e-03f, -8.60762373e-02f, 1.06519148e-01f, -1.22775435e-01f, 1.23366164e-02f,
  6.99307956e-03f, 2.15939268e-01f, 2.02813402e-01f, 8.97644088e-02f, 1.52525946e-01f, 2.40138128e-01f, 1.63540304e-01f, 1.01509251e-01f, 2.19670355e-01f, 3.36195081e-01f,
  6.55101895e-01f, -1.41345367e-01f, -6.69024527e-01f, 3.27691466e-01f, -6.20112680e-02f, -3.33951384e-01f, -3.02784771e-01f, 1.09632395e-01f, 2.88479388e-01f, -1.83985457e-01f,
  -2.29960665e-01f, -8.54862109e-03f, -2.57047236e-01f, -3.13260615e-01f, -3.08227539e-01f, -4.37349856e-01f, -4.73822296e-01f, -3.24474901e-01f, -1.72510639e-01f, 1.73005741e-02f,
  8.17653611e-02f, 2.49404043e-01f, 1.06068283e-01f, 7.83179551e-02f, 1.22289788e-02f, 5.36511093e-02f, -2.32362971e-01f, -1.45939395e-01f, -2.76714355e-01f, -3.74419957e-01f,
  -3.59413594e-01f, -1.44926757e-01f, -5.75305670e-02f, 5.16629145e-02f, 1.98653527e-02f, 1.32019877e-01f, -4.66309153e-02f, 5.57691008e-02f, 1.48033246e-01f, -7.14907423e-02f,
  -2.08911858e-02f, -4.99377400e-03f, -2.81129163e-02f, -2.94151101e-02f, 7.96925277e-02f, -3.13293077e-02f, 6.27587084e-03f, -2.72974633e-02f, -8.16175640e-02f, -1.19306535e-01f,
  -1.22980304e-01f, -9.50863585e-02f, -7.68205374e-02f, -4.13499586e-02f, -8.88949409e-02f, -1.28038093e-01f, -7.81836808e-02f, -6.76800832e-02f, -1.59153953e-01f, 1.52655048e-02f,
  2.27604178e-03f, 2.07834132e-03f, 1.36694118e-01f, 1.68172717e-01f, 2.20069513e-01f, 1.27310097e-01f, 1.25965297e-01f, 2.24459800e-03f, -3.84826143e-03f, 5.56505751e-03f,
  -1.05494661e-02f, -1.72047131e-02f, 4.10289504e-02f, 6.43713027e-02f, 2.00320166e-02f, -4.90192361e-02f, -6.73031062e-02f, 4.63909749e-03f, 6.36533573e-02f, 1.69211775e-01f,
  1.19898662e-01f, 1.90575998e-02f, 3.50196324e-02f, 8.56951624e-02f, -4.97239195e-02f, -8.37717205e-02f, -1.17611229e-01f, 1.48429191e-02f, -4.59321365e-02f, -1.41757816e-01f,
  2.19654217e-01f, -2.13002890e-01f, -7.02142119e-02f, -2.91179623e-02f, -5.44390716e-02f, -3.70546393e-02f, -1.42781943e-01f, 3.18459570e-02f, 5.82767837e-02f, 1.22350389e-02f,
  -8.60334709e-02f, -9.68229491e-03f, 1.81975793e-02f, -9.53550786e-02f, 3.29133682e-02f, -5.61351255e-02f, 6.83532655e-02f, 3.56008373e-02f, -7.41536766e-02f, -2.81561855e-02f,
  1.83167458e-02f, -6.37096167e-03f, 1.91350237e-01f, 7.93997347e-02f, 8.94547105e-02f, 2.92299911e-02f, -6.74239825e-04f, -1.11835012e-02f, 1.31611694e-02f, 9.37251598e-02f,
  7.69114017e-01f, -2.97745973e-01f, -8.40826869e-01f, 3.59124988e-01f, -1.82591185e-01f, -1.95989922e-01f, -7.10050017e-02f, 1.34335369e-01f, 3.50334406e-01f, 3.04980949e-02f,
  -1.49520278e-01f, 2.84117460e-01f, 5.12819923e-02f, -3.11704352e-02f, 5.17885806e-03f, -3.93319517e-01f, -3.99030715e-01f, -2.58107990e-01f, 1.08571284e-01f, 3.78670841e-01f,
  3.83813560e-01f, 4.30786997e-01f, 2.76319653e-01f, 6.62774071e-02f, -1.64486259e-01f, -8.48783180e-02f, -3.91521811e-01f, -2.86573827e-01f, -3.61904472e-01f, -4.64262724e-01f,
  -4.05466914e-01f, -2.00948790e-01f, 7.60136824e-03f, 1.46832168e-02f, -4.35518213e-02f, 9.84204710e-02f, 7.87666664e-02f, -1.11590430e-01f, -9.44004878e-02f, -3.74484248e-03f,
  -1.49423286e-01f, 1.58009008e-01f, -9.54981614e-03f, -1.45761566e-02f, 3.35385650e-02f, 1.50197580e-01f, -1.06624074e-01f, -1.02569938e-01f, -1.10073000e-01f, -2.00355083e-01f,
  -1.07372269e-01f, -2.01599479e-01f, -3.36406648e-01f, -2.46709451e-01f, -2.64567822e-01f, -1.80777043e-01f, -3.40611160e-01f, -1.76657736e-01f, -1.43840492e-01f, -4.25718948e-02f,
  1.18207231e-01f, -4.17558663e-02f, -1.62266120e-01f, -2.57312078e-02f, 1.10042050e-01f, -7.34007061e-02f, -4.16000709e-02f, -8.82445425e-02f, -1.09965466e-01f, 2.14258507e-02f,
  -1.14376089e-02f, 2.72742286e-02f, -9.69621837e-02f, 6.31047487e-02f, 5.13522476e-02f, -1.66423351e-01f, -8.10076669e-02f, -6.80089816e-02f, -7.03896284e-02f, 9.51553360e-02f,
  -2.11924482e-02f, -1.39178559e-01f, -6.02630340e-02f, 2.89374986e-03f, -6.56384304e-02f, -1.60647959e-01f, -7.28229955e-02f, -2.71376898e-03f, 1.34248763e-01f, -5.16173840e-02f,
  5.62455177e-01f, 4.75534871e-02f, 8.42602178e-02f, 2.74618324e-02f, -2.44379655e-01f, -3.69002372e-02f, 6.70273826e-02f, -6.51419982e-02f, -1.06037349e-01f, 5.25705442e-02f,
  -4.91670929e-02f, 1.65387452e-01f, 9.43055376e-02f, -1.40472084e-01f, 1.19448885e-01f, 3.26880217e-02f, 6.49420843e-02f, -2.78343949e-02f, -5.52555136e-02f, -3.32653224e-02f,
  1.16293959e-01f, 1.48748443e-01f, 1.88449219e-01f, -4.72990945e-02f, -8.01512077e-02f, 2.50123918e-01f, -1.28570110e-01f, -5.05298711e-02f, 2.67778374e-02f, 3.67250830e-01f,
  -6.43924057e-01f, -2.63670951e-01f, 3.20836395e-01f, -4.87207294e-01f, -4.28267956e-01f, -5.29166520e-01f, -5.50585389e-01f, -3.00274491e-01f, -4.00343060e-01f, -2.99526900e-01f,
  -1.00036412e-01f, 9.19215158e-02f, 2.97463924e-01f, 1.76895931e-01f, 3.04598391e-01f, -1.54107437e-01f, 2.04371382e-02f, 1.77625164e-01f, 1.25501931e-01f, -4.81316030e-01f,
  -3.76725584e-01f, -1.01581372e-01f, 7.39000589e-02f, 9.12511945e-02f, -1.85142919e-01f, 8.70439187e-02f, 1.19069770e-01f, -2.16107741e-02f, -1.49415344e-01f, -2.05116272e-01f,
  2.04679340e-01f, -4.06806260e-01f, 6.10549711e-02f, -4.49048840e-02f, -5.06827610e-06f, -2.61408258e-02f, -4.24632728e-02f, 1.43316478e-01f, -7.06117079e-02f, -1.14149511e-01f,
  -7.01929182e-02f, -2.05412395e-02f, -1.66746542e-01f, 7.39992633e-02f, -2.52712443e-02f, -4.91801389e-02f, 5.96051142e-02f, 7.79013336e-02f, 9.11323950e-02f, 6.27721772e-02f,
  -1.56622320e-01f, -2.77896851e-01f, -3.97432745e-02f, 4.23261262e-02f, -2.83867819e-03f, 8.40696022e-02f, 9.37123150e-02f, -7.97828734e-02f, 1.55952215e-01f, -6.25646487e-02f,
  5.17274663e-02f, 1.20366551e-01f, -3.04512288e-02f, -6.70125801e-03f, 3.58516797e-02f, -1.26536423e-02f, -4.24374379e-02f, -2.95261424e-02f, -3.78697366e-02f, 7.18561336e-02f,
  5.33928312e-02f, 1.31559551e-01f, 7.17147440e-02f, -5.41178100e-02f, -1.07184589e-01f, -1.95199344e-03f, 7.68826306e-02f, 3.83829549e-02f, -2.94226110e-02f, -1.21016003e-01f,
  -1.45343438e-01f, 9.17926244e-03f, -4.10995223e-02f, 1.14114866e-01f, -5.87708578e-02f, -2.01382823e-02f, -3.18282507e-02f, -2.57251244e-02f, -2.07512043e-02f, -2.03676596e-01f,
  3.39192688e-01f, 2.66148120e-01f, 2.01988005e-05f, -8.21651965e-02f, -8.90877098e-02f, 1.19979670e-02f, -1.44591993e-02f, 8.65093768e-02f, -8.31534490e-02f, -1.83952942e-01f,
  -7.88561702e-02f, -4.72217537e-02f, -4.28068191e-02f, 1.28299728e-01f, -6.26634136e-02f, -5.55462204e-02f, 1.22894518e-01f, -5.81969460e-03f, 1.92545597e-02f, -5.20211123e-02f,
  2.16603540e-02f, -1.86987624e-01f, -4.61103301e-03f, 9.12665799e-02f, -9.75027680e-02f, -1.05491355e-02f, 1.31530091e-01f, 2.56711505e-02f, 6.74601868e-02f, 1.25406116e-01f,
  -4.87270445e-01f, -2.42463395e-01f, -4.41918701e-01f, -3.25165689e-01f, -7.05127940e-02f, 1.87735409e-01f, 3.14996302e-01f, 8.38217810e-02f, -1.53669223e-01f, -3.19189548e-01f,
  6.98734596e-02f, 3.64191979e-02f, -2.32123673e-01f, 1.14580296e-01f, 2.06680626e-01f, -1.09753281e-01f, -2.03600779e-01f, -1.05266742e-01f, 3.96237731e-01f, 3.46008509e-01f,
  1.84052303e-01f, -1.57927647e-02f, -1.10989816e-01f, -3.98179609e-03f, -2.12952107e-01f, -8.81209448e-02f, -4.17481959e-01f, -1.43997431e-01f, -1.03662036e-01f, -3.23825747e-01f,
  -2.66221583e-01f, -1.37684524e-01f, 2.19683856e-01f, 1.31618068e-01f, -1.64753139e-01f, -7.43562281e-02f, 4.48535457e-02f, -1.72157496e-01f, -1.72976982e-02f, -3.91962454e-02f,
  -1.30690429e-02f, 5.66312894e-02f, -1.23205416e-01f, -9.35167726e-03f, 5.53657152e-02f, 8.41334015e-02f, 5.40329665e-02f, 6.43158033e-02f, -3.20489593e-02f, 7.00818896e-02f,
  1.53284997e-01f, -1.16225310e-01f, -2.42153525e-01f, 3.22958529e-02f, 7.01380223e-02f, -1.61357775e-01f, 9.16159898e-03f, 1.60757616e-01f, 3.84834073e-02f, -2.68396646e-01f,
  -4.67085354e-02f, -4.57410440e-02f, 5.23477271e-02f, -9.97990090e-03f, 4.41442579e-02f, -1.14635684e-01f, -6.98065013e-02f, 9.87989828e-02f, -1.60194933e-02f, 2.65013762e-02f,
  8.98951292e-02f, -5.74462861e-02f, 9.22589079e-02f, -1.25972591e-02f, 3.56141897e-03f, -6.38763383e-02f, 1.29435314e-02f, -3.18980068e-02f, -9.79178250e-02f, -1.92140006e-02f,
  4.89900932e-02f, -7.10580125e-02f, -9.90025178e-02f, 9.56691578e-02f, -2.06134543e-02f, 1.47647737e-02f, -6.10001497e-02f, 1.67985514e-01f, 5.96545963e-03f, -3.52740474e-02f,
  -2.79503107e-01f, 2.02909827e-01f, -3.15918535e-01f, 1.12918280e-01f, -1.25074640e-01f, -1.23194627e-01f, -8.92361775e-02f, 1.20019026e-01f, -2.10348845e-01f, 6.80408552e-02f,
  7.51920342e-02f, 1.61766878e-03f, -1.90509990e-01f, 2.45292038e-02f, 5.70113622e-02f, -1.01518661e-01f, 1.97942499e-02f, -4.72899266e-02f, 1.30287707e-01f, -4.72063497e-02f,
  -1.39982030e-01f, 4.31459062e-02f, -1.48999393e-01f, -1.06763758e-01f, -1.07039467e-01f, 6.40598638e-03f, -2.26928920e-01f, 1.63184945e-02f, -1.26568139e-01f, -3.31458867e-01f,
  1.57043919e-01f, -7.41059557e-02f, 8.71945620e-02f, -2.50483066e-01f, 1.96180701e-01f, 2.54767418e-01f, 3.10504049e-01f, 1.56663090e-01f, -1.34660363e-01f, 8.90256613e-02f,
  -4.51363623e-02f, -1.23312175e-01f, -1.82229176e-01f, -1.30668223e-01f, 7.49583393e-02f, 2.49186587e-02f, 5.66405850e-03f, -7.46988645e-03f, 2.72463232e-01f, 2.33456939e-01f,
  7.93727040e-02f, -1.59616023e-01f, -1.26732036e-01f, -1.50378272e-01f, -3.04364890e-01f, -2.12647423e-01f, -2.27399960e-01f, -1.28600433e-01f, -5.66069596e-02f, -1.38179749e-01f,
  8.75292867e-02f, -1.32481232e-01f, -5.05995825e-02f, -1.11887380e-01f, -8.37345719e-02f, -5.61728515e-02f, -6.61818087e-02f, -1.85208559e-01f, -1.22734025e-01f, -1.55954003e-01f,
  -1.61754727e-01f, -7.15047047e-02f, -3.74277495e-02f, -7.77675165e-03f, 1.44133568e-02f, -4.10080291e-02f, -1.50702000e-01f, -3.25153247e-02f, -1.01056919e-01f, -7.63253644e-02f,
  8.26415326e-03f, 1.73572630e-01f, 1.22275382e-01f, 6.14731163e-02f, -5.54017676e-03f, 5.88903800e-02f, -8.19157884e-02f, 2.74936222e-02f, 6.99037388e-02f, -9.31248888e-02f,
  4.29263823e-02f, -3.14829163e-02f, -5.39968815e-03f, 6.17338382e-02f, -3.43188606e-02f, -1.41529599e-02f, -8.37512016e-02f, 5.30523760e-03f, 6.27407953e-02f, 1.52737901e-01f,
  1.61050007e-01f, 1.68363631e-01f, 1.79535165e-01f, 1.24311060e-01f, -4.63321283e-02f, 1.33577147e-02f, 1.69868007e-01f, 7.50772133e-02f, -8.70065838e-02f, 1.44337341e-01f,
  9.54457819e-02f, 1.33337393e-01f, -3.36400978e-02f, 1.66599285e-02f, 1.43304065e-01f, 7.58808926e-02f, 1.07004844e-01f, 6.17709495e-02f, 6.64969608e-02f, 5.72072081e-02f,
  -8.95602182e-02f, 8.35329294e-02f, -4.59276373e-03f, -5.35059981e-02f, -9.66983438e-02f, -1.51119724e-01f, -4.69954722e-02f, -1.81738198e-01f, -1.52364135e-01f, 7.29656145e-02f,
  1.20346062e-02f, -2.96019912e-02f, 4.46958058e-02f, 8.37244391e-02f, 9.32965577e-02f, 9.16944221e-02f, -7.44569823e-02f, 1.23411296e-02f, 3.98980901e-02f, 1.79091077e-02f,
  5.90049326e-02f, 8.36939439e-02f, 1.26543418e-01f, 8.60790387e-02f, 3.14439386e-02f, 1.68107644e-01f, 2.85032187e-02f, 1.64734319e-01f, 1.65384337e-01f, 1.29324913e-01f,
  1.57693386e-01f, 2.03368485e-01f, 4.95615870e-01f, -4.54075575e-01f, -7.62192383e-02f, 2.66432375e-01f, 5.23872316e-01f, 9.01018232e-02f, -4.12451476e-01f, 8.28563198e-02f,
  -1.49321452e-01f, -6.27385616e-01f, -6.32250607e-01f, -2.64329582e-01f, 1.58525571e-01f, 4.20381665e-01f, 1.82865188e-01f, 1.21319257e-01f, 2.24091206e-02f, 2.20483199e-01f,
  1.10898796e-03f, 7.65872374e-02f, 5.91920689e-02f, 1.06341861e-01f, -1.97070912e-01f, -3.60030711e-01f, -3.16795111e-02f, 1.07970163e-01f, 2.14020476e-01f, -1.15912206e-01f,
  2.14121174e-02f, 4.07130271e-01f, 2.44698022e-02f, -4.16649014e-01f, -1.81841463e-01f, -3.26535627e-02f, 1.33815959e-01f, -6.39768317e-02f, -1.51346207e-01f, 1.42665863e-01f,
  -1.39176980e-01f, -1.16176561e-01f, -2.80126482e-01f, 9.10124928e-03f, -1.43284529e-01f, 8.24002847e-02f, 2.23216131e-01f, 1.20592527e-01f, -1.22671761e-01f, 1.58242732e-01f,
  -2.79966772e-01f, 8.10486823e-02f, 3.05374175e-01f, 7.10657015e-02f, 7.35775381e-02f, -3.21209133e-01f, 6.74483404e-02f, 3.35571058e-02f, 1.37187988e-01f, 2.62038279e-02f,
  6.99516609e-02f, 2.48700492e-02f, -1.83487718e-03f, -4.33496162e-02f, -1.73813533e-02f, 2.82580610e-02f, -4.43442799e-02f, -4.80383933e-02f, -1.10968053e-01f, 7.27235898e-02f,
  1.06093690e-01f, 1.86723694e-01f, 1.16737254e-01f, 1.11385614e-01f, -2.66315788e-01f, -3.75640579e-02f, 8.95604119e-02f, -5.03313877e-02f, 2.38905735e-02f, 5.46292290e-02f,
  -2.10016742e-02f, 6.31880462e-02f, -1.81994453e-01f, -7.95707777e-02f, 5.22242896e-02f, -1.16813183e-01f, -1.98908448e-01f, -6.30108789e-02f, -2.65711341e-02f, 2.25994676e-01f,
  -3.86698872e-01f, 3.46230775e-01f, -1.11968793e-01f, -4.37598601e-02f, -4.84302975e-02f, -7.29019716e-02f, 3.77681144e-02f, 1.15240052e-01f, -6.44455701e-02f, 1.15081415e-01f,
  1.44121200e-01f, -6.06040359e-02f, -6.96105137e-02f, 5.66259064e-02f, -4.98690121e-02f, 3.87811251e-02f, 1.20415144e-01f, -1.23672076e-01f, -1.08275160e-01f, -3.66787612e-02f,
  -1.24097757e-01f, 8.97213891e-02f, -3.32786664e-02f, -8.27319100e-02f, -6.34297878e-02f, -2.52809346e-01f, -9.10740066e-03f, 8.19578245e-02f, 5.78593723e-02f, 7.87635595e-02f,
  3.06832045e-01f, 1.07305922e-01f, 3.60675097e-01f, 1.18443333e-01f, 2.02886045e-01f, 1.74959049e-01f, 2.36885741e-01f, 2.18475610e-01f, 4.46221121e-02f, -4.16517965e-02f,
  -2.23091215e-01f, -2.38249794e-01f, -1.28075540e-01f, -2.57810622e-01f, -2.43946966e-02f, -4.46916074e-02f, 1.08711451e-01f, 2.13070601e-01f, 2.61247128e-01f, -2.02428475e-02f,
  -1.99610397e-01f, 2.30519995e-01f, 1.82428345e-01f, 2.99429335e-02f, -7.64522105e-02f, -8.36938918e-02f, 8.39683563e-02f, 2.03589097e-01f, -6.94241896e-02f, -1.08205095e-01f,
  -7.14468211e-02f, 2.32658148e-01f, 3.09026334e-03f, -1.72753170e-01f, -4.91001494e-02f, -3.79656292e-02f, -6.76598996e-02f, -6.79589137e-02f, -1.30428765e-02f, -5.63798808e-02f,
  -1.08324789e-01f, -3.05889151e-03f, 8.74778479e-02f, 5.26206829e-02f, 1.42448112e-01f, 5.46036586e-02f, 2.22379025e-02f, 1.05389714e-01f, -1.33621067e-01f, -4.92471941e-02f,
  -8.45679641e-02f, 1.75420120e-02f, 5.37706129e-02f, 5.23366518e-02f, -9.63226855e-02f, -1.21476114e-01f, 1.03868239e-01f, -2.41669659e-02f, 6.92405701e-02f, 1.04268892e-02f,
  -1.88627094e-01f, -9.92553234e-02f, -4.36770767e-02f, -5.62932789e-02f, 4.26242538e-02f, 1.91534609e-01f, 1.77937925e-01f, 9.18521136e-02f, 8.34680274e-02f, 1.30577743e-01f,
  2.33571060e-04f, 1.11590147e-01f, 2.31088847e-01f, 2.79899407e-02f, -1.61482580e-02f, 1.91914633e-01f, 1.11485735e-01f, 4.44453023e-03f, 7.86757749e-03f, 1.14064522e-01f,
  5.36587723e-02f, 1.55042306e-01f, 1.97150394e-01f, 1.28133688e-04f, 3.54788490e-02f, 1.25439554e-01f, 4.89719473e-02f, 2.99646053e-02f, -2.12037638e-02f, 3.17290463e-02f,
  1.77243426e-01f, 1.27928853e-01f, -1.80417061e-01f, -1.13075189e-01f, 7.52020180e-02f, -1.89002082e-02f, -9.12021920e-02f, -3.73598672e-02f, -6.10311292e-02f, 1.08956344e-01f,
  -1.77685600e-02f, 6.52104691e-02f, 7.62222409e-02f, 7.99542852e-03f, 2.39023790e-01f, 7.14239255e-02f, -2.21478771e-02f, 3.84040214e-02f, -1.19896770e-01f, -1.27305859e-04f,
  -4.06611115e-02f, -2.43792273e-02f, 9.17193666e-02f, -7.29148742e-03f, -8.00337046e-02f, -2.86546145e-02f, 4.17571589e-02f, -5.31906076e-03f, 1.09598292e-02f, 1.23735584e-01f,
  -4.45399702e-01f, -5.08317277e-02f, 2.01850563e-01f, -9.57332610e-04f, -6.03602044e-02f, 3.18579711e-02f, 1.77561283e-01f, -6.46974798e-03f, -1.02736786e-01f, 3.56822647e-02f,
  4.57074158e-02f, -6.52433783e-02f, -5.45033291e-02f, -1.24948911e-01f, 3.54153360e-03f, 8.83402824e-02f, 9.57936198e-02f, -1.78045090e-02f, -1.23553090e-01f, -1.66707262e-01f,
  -1.26929939e-01f, -1.27762824e-01f, -9.05460045e-02f, -8.66032988e-02f, -3.18836942e-02f, -3.31440866e-02f, 1.62581459e-01f, 1.46734556e-02f, -2.54406855e-02f, -4.54238765e-02f,
  3.98269057e-01f, 9.88891795e-02f, -3.78829204e-02f, -1.70358315e-01f, -1.09205067e-01f, -6.48124665e-02f, -7.33529776e-02f, 7.35224783e-02f, -4.19706814e-02f, 4.28161351e-03f,
  -6.92828968e-02f, 5.37742972e-02f, 8.38292912e-02f, 7.01454133e-02f, 2.22496483e-02f, 4.58342917e-02f, 1.12688132e-01f, 1.04008131e-01f, -6.62556291e-02f, 1.93479247e-02f,
  -8.01375806e-02f, -5.41699305e-02f, 4.40680906e-02f, 1.85764916e-02f, -2.92588491e-02f, -1.01834148e-01f, -3.64346616e-02f, 1.33638587e-02f, 4.26614918e-02f, 1.00024613e-02f,
  -9.90740061e-02f, -4.82521430e-02f, 2.95943860e-02f, 1.10037848e-01f, 2.07053777e-03f, 8.09512660e-02f, 1.29803374e-01f, 9.20702703e-03f, 5.28246686e-02f, 5.30833043e-02f,
  9.11042318e-02f, -1.39845293e-02f, 1.10681266e-01f, 4.05328115e-03f, 8.16153809e-02f, 6.96502859e-03f, 6.19636429e-03f, 4.57298458e-02f, 7.12264627e-02f, 9.50408876e-02f,
  -1.64081864e-02f, 1.26551285e-01f, -6.67398050e-03f, 7.56084323e-02f, 8.91617984e-02f, 8.93519521e-02f, 1.44289017e-01f, 2.95553263e-02f, -2.16889456e-02f, 6.28399253e-02f,
  1.02599829e-01f, -1.51560009e-01f, -3.62491347e-02f, -3.89494635e-02f, 1.27933607e-01f, -5.39926551e-02f, 6.23630509e-02f, -5.19235968e-04f, -4.66468036e-02f, 1.17158972e-01f,
  5.00175506e-02f, 3.86331603e-02f, 9.72677767e-02f, 1.44697934e-01f, 2.16549225e-02f, -3.78229544e-02f, -5.22424057e-02f, -7.77698308e-02f, -1.89668834e-02f, 8.45313370e-02f,
  4.96735834e-02f, -3.27552785e-03f, 7.25613013e-02f, 6.41942546e-02f, 5.89759462e-02f, -1.22286044e-01f, -2.58427821e-02f, -4.26630862e-02f, 3.35973166e-02f, -1.29117696e-02f,
  -3.96315843e-01f, -2.37878680e-01f, -4.84890819e-01f, -2.85996705e-01f, 1.62873641e-01f, 2.69992292e-01f, 2.42018908e-01f, 8.33808631e-02f, -1.21381618e-01f, -2.26090103e-01f,
  1.25261873e-01f, 2.82639652e-01f, -1.25836596e-01f, 1.19201913e-01f, -2.21158341e-02f, -1.24949209e-01f, -1.29754961e-01f, -9.48958024e-02f, 2.96110362e-01f, 5.55305123e-01f,
  3.74767423e-01f, -7.95795545e-02f, -1.75074652e-01f, -2.50312965e-02f, -4.70465235e-02f, 7.50751123e-02f, -2.79541284e-01f, -1.59424692e-01f, 8.82795022e-04f, -4.88150604e-02f,
  -3.53842944e-01f, -2.58275181e-01f, 1.80301219e-01f, 1.90353245e-01f, 1.38252629e-02f, -1.48671821e-01f, -8.10956731e-02f, -2.06541777e-01f, 3.14540528e-02f, -2.28158087e-01f,
  1.59150679e-02f, 3.65030859e-03f, -2.08648723e-02f, -1.05801411e-02f, -1.16310969e-01f, -3.85620147e-02f, -1.82896867e-01f, -1.81236222e-01f, -3.07724535e-01f, -1.22023821e-01f,
  3.05337906e-01f, 7.48381019e-02f, -3.30579966e-01f, -1.30062746e-02f, -2.12688178e-01f, -2.88224071e-01f, -2.90395409e-01f, -9.26380220e-04f, -4.15411383e-01f, -3.36455435e-01f,
  5.61656691e-02f, -5.44750616e-02f, -2.48114709e-02f, -1.23840541e-01f, 2.19716970e-02f, 3.31306718e-02f, 3.21718864e-02f, 1.77613676e-01f, 2.15382501e-02f, 6.48930669e-02f,
  4.36977744e-02f, 3.24057862e-02f, 9.50609222e-02f, -6.81057051e-02f, 7.61252493e-02f, 8.40153359e-03f, 4.17128764e-02f, -5.12263179e-02f, -2.39471849e-02f, 8.04632343e-03f,
  4.53627445e-02f, -3.65005545e-02f, -1.18684024e-01f, 1.23319633e-01f, -4.89671482e-03f, -1.54303983e-01f, -6.91805556e-02f, 4.02854122e-02f, -3.39682330e-03f, -2.24982835e-02f,
  -2.58937389e-01f, -2.29766443e-02f, -1.48001149e-01f, 5.54572940e-02f, -6.90732077e-02f, 5.19095687e-03f, -8.68938491e-02f, 7.20979646e-02f, -1.16743937e-01f, 2.03481242e-02f,
  8.27633515e-02f, -5.81735298e-02f, -2.82642692e-01f, 2.29619537e-02f, 2.83094868e-02f, -5.24633527e-02f, -3.99902947e-02f, -2.58507803e-02f, -5.78602019e-04f, 4.26670983e-02f,
  -1.86534166e-01f, 3.39945741e-02f, -3.59216779e-01f, -2.17241496e-01f, 2.54568942e-02f, -8.50827619e-02f, -2.66160071e-01f, -1.30866915e-01f, -2.69333214e-01f, -5.19399703e-01f,
  5.40643454e-01f, -2.02047333e-01f, -4.72238600e-01f, -1.92235842e-01f, -4.10593897e-01f, -3.32317382e-01f, -3.83841485e-01f, -6.01734072e-02f, -9.99868363e-02f, -5.71662784e-01f,
  -1.43059596e-01f, 1.51871443e-01f, -4.66366373e-02f, -2.48150662e-01f, -5.03553376e-02f, -6.58087134e-01f, -6.82843745e-01f, -4.31032509e-01f, -2.98145473e-01f, -4.55729067e-01f,
  -4.72882241e-01f, -2.41605133e-01f, -6.26756391e-03f, -4.98488247e-02f, -3.77095401e-01f, -2.14529619e-01f, -3.91365975e-01f, -1.24000140e-01f, -2.70026356e-01f, -3.13263029e-01f,
  -3.76048505e-01f, 3.62532258e-01f, -9.24260095e-02f, -7.36771002e-02f, -2.53966153e-01f, 4.80196811e-02f, 4.26361337e-02f, 4.94017601e-02f, 7.16920495e-02f, 4.17778753e-02f,
  7.94852227e-02f, -1.47968382e-01f, 1.67424589e-01f, -1.46360761e-02f, -1.46497712e-01f, -1.26411214e-01f, -2.93242127e-01f, -1.51119888e-01f, -1.96072668e-01f, -3.58675957e-01f,
  -1.68851465e-01f, 2.03990132e-01f, 2.60029465e-01f, 2.96527948e-02f, 2.53452092e-01f, -1.27977785e-02f, 9.86655802e-03f, 8.29642862e-02f, 2.98451692e-01f, -5.68471588e-02f,
  -7.90713876e-02f, 4.53279167e-02f, -4.13662158e-02f, 3.92116793e-02f, -1.24671847e-01f, 5.21239378e-02f, 6.85865283e-02f, -1.79786533e-02f, 9.55175515e-03f, 2.27104984e-02f,
  -1.43456817e-01f, -9.06534195e-02f, 5.60382083e-02f, -5.42916022e-02f, -1.33658767e-01f, -5.93391573e-03f, 9.45085287e-02f, -8.41353610e-02f, 7.30157550e-03f, 2.26426776e-02f,
  -1.18369773e-01f, -4.58503217e-02f, 9.62387621e-02f, 5.95607422e-02f, 1.49496377e-03f, -2.67039351e-02f, -4.99006547e-02f, 5.19760028e-02f, 8.23556557e-02f, -7.57359266e-02f,
  -5.65275066e-02f, 1.48305148e-01f, 8.82253349e-02f, 2.94240806e-02f, -3.87463532e-02f, -9.84025970e-02f, 3.33489366e-02f, 3.91298868e-02f, 9.74456221e-02f, 9.68593452e-03f,
  1.21889241e-01f, 1.25978712e-03f, 5.19620739e-02f, -7.64360651e-02f, -6.48437142e-02f, -5.91517873e-02f, -2.10901245e-01f, -1.73385575e-01f, -5.72583359e-03f, -1.53688401e-01f,
  -3.23238432e-01f, -4.96680848e-02f, 1.17319152e-01f, -2.78265905e-02f, 1.85378224e-01f, 1.59471050e-01f, -7.03794435e-02f, 6.65625557e-02f, 2.88512647e-01f, -1.87724262e-01f,
  1.74084529e-01f, 4.94351923e-01f, -1.45022646e-01f, -2.59425104e-01f, -3.60478103e-01f, -1.41192555e-01f, 4.10905302e-01f, 1.58081695e-01f, -1.32243335e-01f, 6.35169446e-02f,
  -2.10172206e-01f, -3.51438016e-01f, -1.44563019e-01f, 3.02954484e-02f, 2.89143831e-01f, 2.65393019e-01f, 2.19998181e-01f, 9.44676623e-02f, -1.83635391e-02f, 1.32240400e-01f,
  1.32569432e-01f, -1.09683059e-01f, 5.50441146e-02f, 1.46505788e-01f, 1.16790729e-02f, -1.88034892e-01f, -1.66474730e-01f, -2.06489325e-01f, 1.02210484e-01f, 2.59477645e-01f,
  -3.61664705e-02f, 1.33844525e-01f, -8.41308087e-02f, -3.03167254e-01f, -3.85328638e-03f, 3.19266230e-01f, 1.86717093e-01f, 2.60887384e-01f, 2.28212982e-01f, 2.41960511e-01f,
  -1.77543923e-01f, 1.82644635e-01f, 2.06477046e-02f, 1.75807834e-01f, -8.15783069e-02f, 8.72125998e-02f, 1.08305365e-01f, 1.88266754e-01f, 1.11561581e-01f, 8.52585435e-02f,
  -3.08678877e-02f, -1.59664437e-01f, -3.58173639e-01f, -7.47831538e-02f, 9.34627652e-02f, -3.46776277e-01f, -3.94234955e-02f, 2.26215310e-02f, -4.43628132e-02f, 2.94749081e-01f,
  -1.27026308e-02f, -5.99527396e-02f, 1.20088443e-01f, 1.75240681e-01f, 1.09423801e-01f, 1.91633254e-02f, -3.66629474e-03f, -5.03128134e-02f, -1.38335126e-02f, 1.32505119e-01f,
  -3.94393913e-02f, 3.49237467e-03f, 1.95447747e-02f, 1.20266497e-01f, -9.55835134e-02f, 2.10597496e-02f, -5.76882511e-02f, 1.08267795e-02f, -1.15172625e-01f, 9.98722911e-02f,
  -5.44558764e-02f, -3.11167222e-02f, -8.42906088e-02f, 1.46287829e-01f, -1.73094571e-02f, -1.74834393e-02f, 6.26657829e-02f, -9.80404839e-02f, -5.72554655e-02f, 3.75576168e-02f,
  -1.15100645e-01f, -9.32185426e-02f, 7.74796382e-02f, -4.25039232e-02f, -8.94299671e-02f, -5.82537688e-02f, -1.58335809e-02f, -2.18016710e-02f, -9.21387672e-02f, -6.16971010e-05f,
  4.24008146e-02f, 4.72356640e-02f, 4.55011837e-02f, 8.24672058e-02f, -9.47805569e-02f, -1.82772234e-01f, -8.43007956e-03f, -3.87443155e-01f, 2.78441943e-02f, -1.10023506e-01f,
  -5.66580333e-02f, -1.17626272e-01f, -3.89708102e-01f, -2.53430992e-01f, -1.30171970e-01f, -2.75470227e-01f, -1.91246971e-01f, -2.25511417e-01f, -1.81296065e-01f, 4.11088206e-02f,
  3.90516132e-01f, -1.99862756e-02f, -1.66757315e-01f, 1.80246308e-01f, -8.92269686e-02f, -1.53717935e-01f, -2.33585283e-01f, -6.52124584e-02f, 1.44219890e-01f, 1.69272780e-01f,
  5.19507267e-02f, 1.71377301e-01f, 2.39976808e-01f, 1.89518839e-01f, 1.52657002e-01f, 7.08853155e-02f, 1.96134016e-01f, 2.50225127e-01f, 1.54460609e-01f, 1.23563491e-01f,
  2.96450704e-01f, 1.21049047e-01f, 2.25117892e-01f, 2.67473459e-01f, 2.17501596e-01f, 9.88120660e-02f, 6.87676817e-02f, 2.08318487e-01f, 1.10972077e-01f, 3.41035396e-01f,
  6.32928535e-02f, -2.23927293e-02f, -7.19190985e-02f, 1.33859649e-01f, 2.37647612e-02f, -1.22645432e-02f, 6.14167824e-02f, -6.15323558e-02f, 1.17482962e-02f, -4.13626730e-02f,
  8.26258436e-02f, 1.11878291e-01f, 7.74159236e-03f, 8.49221572e-02f, -8.35899711e-02f, -9.25579760e-03f, 8.02690983e-02f, 7.14230984e-02f, -1.43190343e-02f, 2.33262982e-02f,
  1.22692950e-01f, -7.54406154e-02f, -8.26992765e-02f, -2.04606116e-01f, 7.31980503e-02f, 1.08656578e-01f, -8.55841339e-02f, -2.80075911e-02f, -3.35660614e-02f, -9.26595647e-03f,
  1.31219238e-01f, 8.58503282e-02f, 3.42099108e-02f, 5.10122366e-02f, 2.06292108e-01f, 5.92831075e-02f, -7.31109921e-03f, 3.95640582e-02f, 1.50738597e-01f, 4.64840606e-02f,
  -3.32972184e-02f, 1.21243082e-01f, 5.85315153e-02f, 1.04792275e-01f, 1.32212620e-02f, -2.38105897e-02f, -5.99617884e-02f, -4.90478091e-02f, 4.71576117e-02f, -2.04657465e-02f,
  1.30234445e-02f, -1.32481987e-02f, -5.59845455e-02f, -9.12509160e-04f, 4.68643047e-02f, -2.24740393e-02f, 1.14506841e-01f, 1.01418979e-01f, -5.61025180e-02f, -5.42162824e-03f,
  -1.93782881e-01f, -2.25817770e-01f, 9.35962424e-02f, 2.77062114e-02f, -1.04282238e-01f, -4.52566147e-02f, -8.95535760e-03f, -7.24031962e-03f, 5.48367854e-03f, -1.18254721e-01f,
  -1.12447448e-01f, 7.17170956e-03f, -3.69676054e-02f, -3.38620469e-02f, -1.01458915e-01f, -1.30714327e-01f, 3.19215804e-02f, 1.76771998e-03f, -6.46047741e-02f, -1.26401618e-01f,
  -1.99152052e-01f, -1.95517465e-01f, -1.66657746e-01f, -1.66018456e-01f, -1.58712059e-01f, -4.96693105e-02f, -9.70941707e-02f, -2.02479228e-01f, -1.43306404e-01f, -2.62305468e-01f,
  -1.18912771e-01f, 2.15101406e-01f, -1.73547015e-01f, -1.20458364e-01f, 1.11308843e-02f, -1.95270196e-01f, -4.21863854e-01f, -5.02744734e-01f, -1.66617766e-01f, -1.26185669e-02f,
  7.95659795e-02f, 9.25453529e-02f, -3.76100726e-02f, -1.68981627e-01f, -5.23163736e-01f, -3.83943558e-01f, -2.57935852e-01f, -3.19188833e-01f, -5.04694045e-01f, -2.21629590e-01f,
  1.04259498e-01f, -1.07453391e-01f, -1.36873499e-01f, -2.74471879e-01f, 1.05547510e-01f, 2.40801219e-02f, -5.95828369e-02f, 5.28450906e-02f, 9.54576582e-02f, 2.20108554e-01f,
  5.18429764e-02f, -2.89379120e-01f, -2.34805033e-01f, -2.28894036e-02f, 7.18323328e-03f, 8.54844153e-02f, -3.06324810e-02f, -1.43116951e-01f, 1.10085765e-02f, -5.24166748e-02f,
  9.17485282e-02f, -5.00764214e-02f, 3.50070447e-02f, -2.17191335e-02f, -8.69056061e-02f, -2.20934689e-01f, -1.38109401e-01f, -1.89909175e-01f, -9.47739407e-02f, 9.59939808e-02f,
  3.06076497e-01f, 7.53441732e-03f, -2.25301951e-01f, -1.14955850e-01f, -2.37031072e-01f, -7.17352703e-02f, -1.70028970e-01f, -1.94716319e-01f, -2.89100111e-01f, 6.86039552e-02f,
  -3.52986082e-02f, 3.20734307e-02f, -2.77352836e-02f, 1.13740060e-02f, -1.15227737e-02f, 6.42914250e-02f, -4.48500551e-02f, -1.36892915e-01f, -8.70244130e-02f, -2.03397591e-02f,
  -8.18931777e-03f, 8.43227655e-02f, -1.46906748e-01f, -9.33675170e-02f, -1.02907136e-01f, -1.60258442e-01f, -8.05000067e-02f, -4.06566933e-02f, -1.59044191e-01f, 7.57230120e-03f,
  -1.67880461e-01f, -1.17077753e-01f, 1.13690875e-01f, -1.24373600e-01f, -4.47444431e-02f, -1.82919994e-01f, -1.24252299e-02f, -1.88370317e-01f, -4.53853384e-02f, -1.46054968e-01f,
  3.60223427e-02f, -1.58076495e-01f, 1.60707925e-02f, -1.92691684e-01f, 5.14791254e-03f, 2.62780428e-01f, 2.06160456e-01f, -1.39326900e-01f, 9.00045484e-02f, -1.74514905e-01f,
  -2.06427455e-01f, -9.57879145e-03f, -5.70340715e-02f, 4.97748479e-02f, -1.18914530e-01f, -1.20781772e-01f, 8.93315151e-02f, 6.14096746e-02f, 3.57973315e-02f, 1.82555526e-01f,
  1.16086133e-01f, -1.08110748e-01f, -7.74131119e-02f, -1.43094221e-02f, -4.21622619e-02f, -1.56871349e-01f, 2.94701681e-02f, -8.87404755e-02f, -2.39268616e-01f, 1.80912226e-01f,
  1.83058873e-01f, 4.41881716e-01f, -5.84622324e-01f, -2.32832786e-03f, -2.07319185e-01f, -1.31149635e-01f, 1.23133153e-01f, 1.77919000e-01f, 3.36314142e-02f, 7.45436251e-02f,
  -5.73287047e-02f, -1.63021237e-01f, -1.30774960e-01f, -2.02204913e-01f, -4.10331674e-02f, 4.79293093e-02f, -1.69427693e-01f, -4.24930751e-01f, -4.20961499e-01f, -2.07382724e-01f,
  -1.30404785e-01f, -5.47840968e-02f, -1.57681316e-01f, -1.93455055e-01f, -1.11395828e-02f, -2.58714259e-01f, -2.96186060e-01f, -3.36831182e-01f, -3.48031551e-01f, -2.67905653e-01f,
  -2.67349988e-01f, -7.77059793e-02f, -1.25717847e-02f, 1.62359625e-01f, 1.19631544e-01f, 5.90671115e-02f, 8.54717344e-02f, 1.03420720e-01f, 1.12186901e-01f, 1.53506652e-01f,
  -1.02868490e-01f, -9.95953567e-03f, -5.37759205e-03f, -4.80740741e-02f, 5.25050499e-02f, 1.45799704e-02f, 1.07791878e-01f, 2.17369124e-02f, 9.75254402e-02f, 7.49812424e-02f,
  1.18686415e-01f, -1.34730086e-01f, 2.67481692e-02f, 1.88078806e-01f, -1.12116493e-01f, -1.47899970e-01f, -1.68932173e-02f, -9.48406477e-03f, -2.74165776e-02f, 2.65467882e-01f,
  -7.02424347e-02f, 1.58880483e-02f, -2.19999086e-02f, 6.78027943e-02f, 4.69549559e-02f, 7.60300681e-02f, 2.15984993e-02f, 1.07773580e-01f, 1.09937325e-01f, 2.01162696e-01f,
  2.14574948e-01f, -4.93917093e-02f, 3.44320573e-02f, 9.25697908e-02f, -6.92091708e-04f, -4.28685546e-02f, -2.02647652e-02f, 5.73062673e-02f, -7.92003945e-02f, 1.44542739e-01f,
  1.01018257e-01f, 8.34170878e-02f, -7.15044662e-02f, 8.12557340e-03f, 4.63697761e-02f, 5.53100556e-02f, 1.04460050e-03f, -3.16249393e-02f, -7.81368539e-02f, -5.63406944e-02f,
  1.56978577e-01f, -3.18492264e-01f, 2.19265983e-01f, -1.14094857e-02f, -6.92541525e-02f, 3.54200751e-02f, -1.52458042e-01f, -3.68208215e-02f, -7.55425841e-02f, -1.06772512e-01f,
  -9.87658128e-02f, 1.24165872e-02f, -4.75251339e-02f, 1.90899476e-01f, 1.97158158e-02f, -8.18576664e-02f, 1.95661321e-01f, -8.60234257e-03f, 2.02234425e-02f, 9.81840864e-02f,
  1.00523412e-01f, 2.43589103e-01f, 2.40058303e-01f, 1.34607241e-01f, -3.39509062e-02f, -4.06797342e-02f, 4.91279960e-02f, 7.15983659e-02f, -7.91032910e-02f, 3.06608617e-01f,
  4.57810611e-01f, 4.24000591e-01f, -1.53051987e-01f, 3.46303344e-01f, -6.27611801e-02f, -1.63803279e-01f, -1.04653075e-01f, 1.44020617e-01f, 2.81654269e-01f, 1.32833093e-01f,
  -6.08211607e-02f, -3.33809078e-01f, -1.14297912e-01f, -3.64638358e-01f, -4.25347239e-01f, -2.38877580e-01f, -2.47723520e-01f, -4.26723957e-01f, -4.24856782e-01f, -2.13294774e-01f,
  -3.00223559e-01f, 2.07544956e-02f, -1.20035388e-01f, 6.71882695e-03f, 2.25318551e-01f, -1.73946723e-01f, 1.19458251e-01f, 2.14125663e-02f, -1.76624179e-01f, 4.21262980e-02f,
  -5.19352183e-02f, 5.19352555e-01f, -2.23837838e-01f, -1.34034440e-01f, -8.17504525e-02f, 3.07278205e-02f, 1.30298559e-03f, 3.42183188e-02f, 2.08494477e-02f, 1.32298961e-01f,
  -8.65259171e-02f, 2.71296483e-02f, -5.22537492e-02f, -7.78997019e-02f, 4.36009765e-02f, -6.32773489e-02f, -3.88523676e-02f, -9.30048600e-02f, -1.19335219e-01f, 8.43311101e-02f,
  -1.03760973e-01f, -3.44081968e-02f, 7.33028352e-02f, 2.36186776e-02f, 1.70789465e-01f, -2.71459937e-01f, 1.24220468e-01f, 1.90531194e-01f, 2.76536215e-03f, 3.76067549e-01f,
  7.57896304e-02f, -8.36238265e-02f, 4.07501153e-04f, 1.99675247e-01f, -6.04704283e-02f, 4.83349152e-03f, -3.25897709e-02f, 3.50108817e-02f, -3.93437929e-02f, 9.42057371e-02f,
  6.64643347e-02f, -1.73469633e-02f, 3.81129012e-02f, 2.04823136e-01f, -1.12932712e-01f, 8.96891281e-02f, 4.27554129e-03f, 3.45008858e-02f, -6.62859529e-02f, -5.33654653e-02f,
  -5.69306575e-02f, -6.72273636e-02f, -7.14606643e-02f, -2.18167044e-02f, 1.85021246e-03f, 3.00699603e-02f, 6.64183795e-02f, -3.93052446e-03f, -4.63273609e-03f, 5.43026552e-02f,
  6.88913390e-02f, -1.53379738e-01f, 1.41609848e-01f, -1.10372137e-02f, -5.42425886e-02f, 4.60927300e-02f, -2.16342900e-02f, -8.91552642e-02f, 1.74434766e-01f, -2.36920565e-02f,
  4.58714999e-02f, 3.91908437e-02f, 2.42507458e-02f, -1.97585821e-01f, -1.59316123e-01f, 6.30723312e-02f, -2.04057157e-01f, -1.43657058e-01f, -1.35360956e-01f, 1.09085955e-01f,
  7.73245692e-02f, -1.31540924e-01f, -1.89074680e-01f, -1.67325974e-01f, 5.16106226e-02f, -3.14721733e-01f, -7.66661689e-02f, -5.52731194e-02f, -3.73662025e-01f, -9.71030742e-02f,
  -2.95935065e-01f, -6.56580999e-02f, 3.14914465e-01f, 3.16032052e-01f, 3.90480995e-01f, 3.27740520e-01f, 3.12329799e-01f, 3.57512712e-01f, 2.76070148e-01f, 2.33283147e-01f,
  3.49326506e-02f, 9.99080688e-02f, 7.76067972e-02f, 2.48653069e-02f, 6.68014735e-02f, 3.59588146e-01f, 3.23145032e-01f, 1.72292754e-01f, 2.19940931e-01f, 9.26642343e-02f,
  -1.79295130e-02f, 1.25712827e-01f, 7.02629089e-02f, 3.77594084e-02f, 1.52220786e-01f, 1.47528663e-01f, 3.13047051e-01f, 2.47250050e-01f, 4.88482276e-03f, 5.06331734e-02f,
  -1.37279764e-01f, 3.98811921e-02f, 4.43738513e-02f, -1.79551080e-01f, -1.20829657e-01f, -1.05245739e-01f, -6.17482373e-03f, -4.93077114e-02f, -1.07812762e-01f, -5.20937666e-02f,
  5.05146338e-03f, -1.03002980e-01f, 3.52487224e-03f, 3.36003639e-02f, 1.38115034e-01f, 6.22795075e-02f, 2.47402396e-02f, -2.41867434e-02f, 1.76197272e-02f, 5.98158804e-04f,
  -1.01187997e-01f, 7.46688545e-02f, 2.19264969e-01f, 1.32862002e-01f, -8.37502331e-02f, 1.10716177e-02f, -1.18183373e-02f, -1.01906918e-01f, 1.58644300e-02f, -4.47830372e-03f,
  3.43445204e-02f, -1.24091662e-01f, 6.73742732e-03f, 3.44278775e-02f, 4.43429407e-03f, 1.81308843e-03f, 8.68012458e-02f, 1.45476505e-01f, 1.23174690e-01f, 1.37888759e-01f,
  1.35721490e-01f, 4.17950712e-02f, 2.05527350e-01f, -5.46586886e-02f, -4.40695696e-02f, 1.00188352e-01f, 3.14050652e-02f, 5.81035428e-02f, 6.89690188e-02f, 9.64010358e-02f,
  1.01386905e-01f, 3.34066525e-02f, -5.18947840e-02f, 4.32642661e-02f, -2.24299934e-02f, -2.41169948e-02f, 8.14195815e-03f, -3.51232365e-02f, 4.03802246e-02f, -3.72941568e-02f,
  3.25463831e-01f, 1.14143848e-01f, -1.49065733e-01f, 3.71483341e-03f, -1.43593371e-01f, -1.48171425e-01f, -3.03915553e-02f, -1.62670895e-01f, -5.78981638e-02f, 9.44419205e-02f,
  -1.11969382e-01f, -8.56961608e-02f, 6.45637885e-03f, -5.99128045e-02f, 8.74652416e-02f, 9.60327964e-03f, -1.93194970e-01f, 9.08348709e-02f, 3.46262865e-02f, -2.67686136e-02f,
  -5.66172935e-02f, 8.92093033e-02f, 5.27808629e-02f, 2.20032260e-02f, 3.89217772e-02f, 3.62492241e-02f, 3.10857929e-02f, 3.92684676e-02f, 7.06922188e-02f, -5.41985184e-02f,
  6.68504000e-01f, -1.14110015e-01f, 1.24642953e-01f, 1.61609843e-01f, 2.47016028e-01f, 1.54899180e-01f, -3.34991105e-02f, -6.38544410e-02f, 1.83266148e-01f, 9.38677564e-02f,
  2.49180630e-01f, 2.52005816e-01f, 1.01151571e-01f, 8.16479791e-03f, 3.70857790e-02f, -8.85485411e-02f, 8.22570249e-02f, 2.21626595e-01f, 2.27487564e-01f, 7.86740780e-02f,
  4.18125466e-02f, 1.06267355e-01f, 5.91636486e-02f, 6.99350163e-02f, -2.30148509e-02f, 6.58885688e-02f, -9.32225883e-02f, 9.51372180e-03f, 8.36762935e-02f, -7.95155540e-02f,
  -3.93029004e-02f, 7.59980753e-02f, 1.42176095e-02f, 1.04652762e-01f, 6.57100379e-02f, -2.66603772e-02f, 8.70521516e-02f, -1.40585229e-02f, 1.33579709e-02f, -2.07013428e-01f,
  -7.30798319e-02f, 1.38299959e-02f, 1.13739101e-02f, -3.72198634e-02f, 9.00678039e-02f, -4.76958640e-02f, 1.19526044e-01f, 2.82277609e-03f, -6.22644946e-02f, -9.44901034e-02f,
  -1.35727506e-02f, 1.64101660e-01f, 1.18418202e-01f, -8.50898307e-03f, -3.05654407e-02f, 1.10015705e-01f, 3.89498994e-02f, 1.97768677e-02f, 9.19656530e-02f, -2.51602121e-02f,
  2.53215939e-01f, 4.43415821e-01f, 2.93355525e-01f, 1.79206297e-01f, 4.58494574e-02f, 1.91365346e-01f, 1.50473446e-01f, -5.18566631e-02f, 1.07405372e-01f, 1.09250300e-01f,
  -7.98382889e-03f, -1.07094068e-02f, -8.39866977e-03f, 2.16640979e-01f, 2.59449661e-01f, 2.46660501e-01f, 7.09978864e-02f, -1.62955225e-02f, 1.32311910e-01f, -5.65926842e-02f,
  3.98839302e-02f, -5.07965721e-02f, -1.58563070e-02f, -3.03537361e-02f, 4.27523302e-03f, 2.67393172e-01f, 2.01885566e-01f, 1.18425421e-01f, 2.75261730e-01f, 7.33720213e-02f,
  -3.78194869e-01f, -2.62617376e-02f, 8.46347064e-02f, -1.00100301e-02f, 6.31554723e-02f, 3.08178756e-02f, -5.91947883e-02f, -1.58317879e-01f, -2.87364900e-01f, -2.47946844e-01f,
  -6.56691790e-02f, -2.85046566e-02f, 5.87006025e-02f, -3.97428237e-02f, -3.83543484e-02f, 4.96592075e-02f, 7.44100660e-02f, 1.08203344e-01f, -4.36442420e-02f, -1.65882453e-01f,
  -6.01439290e-02f, 1.54620275e-01f, 1.10357121e-01f, 8.56477693e-02f, 1.56735945e-02f, 1.28134385e-01f, -8.43315572e-02f, -1.14887077e-02f, 1.64122488e-02f, 4.42075506e-02f,
  -5.47574699e-01f, -1.72390923e-01f, 2.30905995e-01f, -4.02929336e-02f, 3.86901617e-01f, 9.10978466e-02f, -3.60558420e-01f, -3.48157316e-01f, -1.24890786e-02f, -1.77962124e-01f,
  8.57957453e-02f, 1.71298504e-01f, 2.28316456e-01f, 4.03581858e-02f, -1.29070505e-01f, -1.18663676e-01f, 2.34513298e-01f, 1.05148137e-01f, 3.41596752e-02f, -1.86568022e-01f,
  4.10853885e-02f, -6.93194643e-02f, -1.48444459e-01f, -1.43050581e-01f, -4.78267297e-03f, 1.45238668e-01f, 1.32633783e-02f, 9.52264760e-03f, 9.07988399e-02f, 1.74169600e-01f,
  -2.29401454e-01f, -2.93142557e-01f, -9.57259815e-03f, 1.51158124e-01f, 3.06737602e-01f, -4.02411729e-01f, -3.20467293e-01f, 3.94465476e-02f, -7.95972645e-02f, -1.72794282e-01f,
  2.35150561e-01f, 5.52187413e-02f, 1.38007507e-01f, 1.37507766e-02f, -1.82624996e-01f, -1.91617966e-01f, 1.82710234e-02f, -1.80989295e-01f, -2.13494852e-01f, -1.65462077e-01f,
  1.93933874e-01f, 1.24304250e-01f, -1.05748363e-01f, -1.09890997e-01f, -3.89849663e-01f, 5.35902455e-02f, -2.66065717e-01f, -3.51411819e-01f, -4.28204089e-01f, -4.33652461e-01f,
  1.30271807e-01f, 1.89359859e-01f, 1.45643666e-01f, 1.49414828e-02f, -4.84271273e-02f, 4.37801145e-02f, 1.54448748e-01f, 3.16694528e-02f, 6.00843243e-02f, 1.16484370e-02f,
  2.33248591e-01f, 3.84660400e-02f, -2.36932784e-02f, -4.81933244e-02f, 9.60013196e-02f, -8.02887976e-02f, -7.44626950e-03f, -9.66945440e-02f, 4.54733372e-02f, 5.61156019e-04f,
  8.12108293e-02f, 4.93612327e-03f, 9.73471552e-02f, -7.99327046e-02f, 3.09203230e-02f, 1.15367793e-01f, -4.98468801e-02f, 1.05553372e-02f, -4.64877393e-03f, -3.59922871e-02f,
  -1.55217737e-01f, 2.64971793e-01f, -2.70576507e-01f, -7.85572827e-02f, -1.33951064e-02f, 7.67067224e-02f, -6.10981695e-02f, -1.21158771e-02f, 1.59986809e-01f, -1.68762490e-01f,
  -1.37102500e-01f, -6.10680319e-02f, 1.08138055e-01f, -2.11534649e-02f, -2.02585012e-01f, -1.08731933e-01f, 1.23774735e-02f, -4.33810763e-02f, -5.71403988e-02f, -8.65185186e-02f,
  -5.32669276e-02f, -2.20602080e-01f, -3.50454420e-01f, -2.85083741e-01f, -2.25628749e-01f, -1.60006016e-01f, -2.11659938e-01f, -3.27619463e-01f, -3.26378912e-01f, -4.06698167e-01f,
  2.83715948e-02f, -1.07761018e-01f, -1.16479434e-02f, 1.39698014e-01f, -5.96076716e-03f, 1.02403306e-03f, -1.75694987e-01f, -3.16403015e-03f, 4.72819917e-02f, 1.58358574e-01f,
  1.93009153e-01f, 2.01712579e-01f, 2.04821214e-01f, 1.12350382e-01f, 1.17591098e-01f, -8.04994479e-02f, 1.10520668e-01f, 2.86180340e-02f, -2.19071074e-03f, -6.71708584e-02f,
  1.12092793e-01f, 8.48028362e-02f, 6.23009130e-02f, -3.42970677e-02f, -5.73306233e-02f, 7.67735466e-02f, 8.48851576e-02f, 1.99922957e-02f, -5.94072640e-02f, -8.59186891e-03f,
  -2.80892868e-02f, -2.06765309e-01f, 4.60006520e-02f, -2.70148795e-02f, -5.89493502e-05f, 5.27193919e-02f, -4.54160795e-02f, -3.18899825e-02f, -9.76027548e-02f, -5.50440932e-03f,
  2.57919338e-02f, -5.80871180e-02f, -2.34472547e-02f, 4.16798182e-02f, -1.59047525e-02f, -2.16784216e-02f, -2.82298541e-03f, -8.04562569e-02f, -2.76591238e-02f, -3.12101562e-02f,
  3.64307873e-02f, 3.36303702e-03f, -4.27199602e-02f, -8.58477801e-02f, -8.36215168e-02f, 7.66470889e-03f, -1.27736345e-01f, -1.20654479e-02f, 4.83921170e-02f, -6.47761533e-03f,
  8.02608430e-02f, -1.08746894e-01f, 1.87433474e-02f, 1.29683157e-02f, -3.81338061e-03f, 1.31919160e-01f, 8.71818513e-02f, -1.39983427e-02f, -1.60276368e-02f, 1.23999000e-01f,
  -2.05886550e-02f, 2.56565008e-02f, -4.36040014e-02f, 1.04513519e-01f, 1.12134241e-01f, 3.37624997e-02f, -1.11918822e-01f, -5.87686300e-02f, -5.97413145e-02f, -1.04292348e-01f,
  -7.88487121e-02f, -1.87725052e-02f, 5.76860420e-02f, -1.02555297e-01f, 6.79141805e-02f, -2.17639678e-03f, -1.03846751e-02f, 8.28019828e-02f, 5.35092056e-02f, -3.22973393e-02f,
  9.46436524e-02f, -1.45915626e-02f, -1.01499557e-01f, -1.87563568e-01f, -1.30572215e-01f, -1.39123704e-02f, -1.01626158e-01f, 1.61854047e-02f, -5.91755137e-02f, -1.01369619e-01f,
  -2.37236787e-02f, 2.64130179e-02f, -1.00635640e-01f, 2.53933258e-02f, 6.93733990e-02f, 2.87782289e-02f, -9.57020149e-02f, 6.79236129e-02f, -1.16040550e-01f, -8.84195045e-02f,
  -2.85297241e-02f, 3.33370417e-02f, 9.26355794e-02f, -2.30340529e-02f, 3.59856039e-02f, 1.55682573e-02f, -6.48842081e-02f, -4.77324650e-02f, 3.80263813e-02f, 3.70317474e-02f,
  -6.58420697e-02f, -3.48472118e-01f, -9.14866626e-02f, -2.99822599e-01f, -3.39274734e-01f, -1.99564725e-01f, -3.32641125e-01f, -2.42156208e-01f, -3.06764394e-01f, -2.06945896e-01f,
  3.26673016e-02f, 5.58440387e-01f, 4.95794237e-01f, 4.75590438e-01f, 4.64813173e-01f, -3.27790618e-01f, -2.37450197e-01f, 2.09475875e-01f, 3.97805929e-01f, -6.07435144e-02f,
  -1.23228572e-01f, -3.01185608e-01f, -1.19901605e-01f, -1.82216048e-01f, -4.92293090e-01f, 3.06146219e-02f, -4.03542668e-01f, -2.93514192e-01f, -7.79934302e-02f, -3.89914513e-01f,
  1.59909084e-01f, -2.21817672e-01f, 9.12818164e-02f, 1.38867274e-01f, -2.42101520e-01f, 2.87007000e-02f, -1.19373694e-01f, -1.56758308e-01f, -4.56001572e-02f, -2.31188968e-01f,
  -5.78757152e-02f, 9.81454775e-02f, 1.47735523e-02f, -1.80057377e-01f, -2.88337618e-01f, -7.40081593e-02f, -2.32140571e-01f, -5.63034713e-02f, 1.26351684e-01f, -1.23540781e-01f,
  -9.35223475e-02f, -1.11628100e-02f, 2.06783503e-01f, -7.48651624e-02f, -9.47104916e-02f, 2.46010333e-01f, -1.61663573e-02f, -5.24570271e-02f, 1.01391710e-01f, -3.05007756e-01f,
  -3.89701091e-02f, 6.89973161e-02f, -8.43590274e-02f, -1.34168923e-01f, -4.85830419e-02f, 2.30285209e-02f, 2.14309860e-02f, -8.31053853e-02f, -4.32343297e-02f, 6.66889548e-02f,
  1.66242220e-03f, 2.15818435e-02f, -1.04307443e-01f, -7.30731636e-02f, -3.83626781e-02f, 7.08195642e-02f, 6.45441469e-03f, 7.28563666e-02f, -2.13933457e-02f, 4.30660956e-02f,
  9.89722088e-02f, 5.04721999e-02f, -1.47038130e-02f, 8.50898400e-02f, -4.03456483e-03f, 9.45759937e-02f, 5.15904538e-02f, 1.15725480e-01f, 1.22886948e-01f, -6.74430877e-02f,
  9.63556767e-02f, 3.99851114e-01f, 2.80067441e-03f, 7.24966004e-02f, -1.57940373e-01f, -7.54265562e-02f, 6.94869272e-03f, -1.65160969e-01f, -1.39872814e-02f, -1.92912798e-02f,
  -5.04507963e-03f, 1.76217541e-01f, -1.77340154e-02f, -2.37718578e-02f, -1.03616819e-01f, 5.63305728e-02f, -3.92928608e-02f, 1.56403407e-01f, 1.40941635e-01f, -2.69796290e-02f,
  -4.07100022e-02f, 1.29944548e-01f, 1.60091177e-01f, 2.30233282e-01f, -4.92172949e-02f, 2.18559161e-01f, 5.31942882e-02f, 1.94501802e-01f, 3.36604804e-01f, -1.37610048e-01f,
  -2.20782474e-01f, 7.81968832e-02f, 1.44820129e-02f, -5.93217053e-02f, -7.67221451e-02f, -2.08691165e-01f, -4.14746284e-01f, -3.18752885e-01f, -5.96161038e-02f, 1.55272603e-01f,
  1.99648127e-01f, 7.14435130e-02f, 3.41811404e-02f, -9.63010415e-02f, -3.10720026e-01f, -1.89275354e-01f, -2.10193656e-02f, -2.95023769e-01f, -1.99245736e-01f, -1.23481259e-01f,
  8.25632513e-02f, -4.99019362e-02f, -9.36212987e-02f, -3.57423760e-02f, 3.36289018e-01f, 1.82597101e-01f, 1.60280630e-01f, 2.07274109e-01f, 1.18410088e-01f, 2.54264623e-01f,
  4.50965106e-01f, -5.48114581e-03f, -1.61421120e-01f, 6.02877233e-03f, 1.11837149e-01f, -6.71654493e-02f, -6.65454492e-02f, -3.74553986e-02f, -1.14408679e-01f, 1.37563646e-01f,
  7.50405118e-02f, 8.95826221e-02f, 1.37415482e-02f, 4.97384593e-02f, -1.23634040e-02f, 5.18560857e-02f, 4.94896546e-02f, -1.42433524e-01f, -7.96709880e-02f, 1.25453621e-01f,
  1.58039451e-01f, 9.25818682e-02f, 7.75986956e-03f, -5.95177449e-02f, -3.55819613e-02f, -3.21500525e-02f, 9.40542594e-02f, 1.08085319e-01f, -1.04145557e-01f, 1.07895195e-01f,
  1.53289512e-02f, -3.48320045e-02f, -1.76303294e-02f, 3.19528417e-03f, 7.19465911e-02f, 8.61810073e-02f, 3.55557613e-02f, 3.55241150e-02f, 3.88176776e-02f, 8.37217048e-02f,
  4.78136055e-02f, 9.02241617e-02f, -4.16155048e-02f, -8.29673111e-02f, 1.48317724e-01f, -4.37381901e-02f, 7.22010657e-02f, 8.83064196e-02f, 1.15355588e-01f, 1.21668614e-01f,
  8.79572183e-02f, -5.32475561e-02f, 3.26428451e-02f, -3.33504044e-02f, 9.13468301e-02f, 1.05119571e-01f, 1.77657858e-01f, 1.01598360e-01f, 1.16713442e-01f, 1.29245043e-01f,
  1.00039043e-01f, -2.73911774e-01f, 1.84591845e-01f, -4.92834896e-02f, 2.80057527e-02f, 1.60849229e-01f, 2.07985878e-01f, -2.00403053e-02f, 3.33725363e-02f, 1.71832219e-01f,
  1.04895346e-01f, 7.54892677e-02f, 1.97202191e-02f, 2.86334660e-02f, 9.48592052e-02f, 1.64228052e-01f, 9.49847177e-02f, -6.14523739e-02f, -1.52007788e-01f, 1.94943771e-01f,
  -8.57028887e-02f, -2.11006880e-01f, -1.37910873e-01f, -2.22207159e-01f, 7.35925883e-02f, -1.80283174e-01f, -5.76805416e-03f, 3.04355435e-02f, -2.16893673e-01f, -1.93763033e-01f,
  7.50335753e-01f, 2.55683094e-01f, -5.49763203e-01f, -3.77376638e-02f, -4.07310963e-01f, -4.29552615e-01f, -3.63383412e-01f, -3.71214300e-01f, -3.27421688e-02f, -1.09303398e-02f,
  2.15892524e-01f, 8.92765149e-02f, -3.90534401e-02f, -2.69462705e-01f, -3.78227502e-01f, -3.87580395e-01f, -3.03963333e-01f, -4.29220587e-01f, -5.62692046e-01f, -4.86078739e-01f,
  -1.41614765e-01f, -1.83188170e-01f, -2.10793942e-01f, -3.15912157e-01f, -1.34955317e-01f, -1.61087170e-01f, -2.40396753e-01f, -3.04480731e-01f, -1.71912596e-01f, -5.48070632e-02f,
  -4.19942200e-01f, -1.34770209e-02f, -2.40449071e-01f, 1.72224790e-01f, 7.17252567e-02f, 1.60321638e-01f, -1.34909362e-01f, 3.12281344e-02f, 3.07049662e-01f, -1.66971222e-01f,
  -3.18270251e-02f, -4.31288406e-02f, 1.21379405e-01f, -5.33223413e-02f, -2.24627674e-01f, -2.23739907e-01f, -1.51198432e-01f, -1.46107450e-01f, -1.56548336e-01f, -3.03499512e-02f,
  2.74440259e-01f, 1.29652426e-01f, -2.25690067e-01f, -1.77144766e-01f, -2.96663493e-01f, -5.33251241e-02f, -3.57791036e-01f, -1.84940889e-01f, -3.53470683e-01f, 2.89147701e-02f,
  1.32111952e-01f, 1.78287417e-01f, 5.09200431e-02f, -4.97503057e-02f, -4.36582938e-02f, 1.50713354e-01f, 4.47461493e-02f, 4.96970639e-02f, -2.04779999e-03f, -1.40702009e-01f,
  -1.90937091e-02f, -3.72556075e-02f, 3.98890004e-02f, 1.28014430e-01f, -6.56826571e-02f, 1.01675112e-02f, 2.36976966e-01f, 6.39776420e-03f, -2.95073185e-02f, 2.16622055e-02f,
  2.05195211e-02f, -5.61784431e-02f, 3.22549045e-02f, 1.03160173e-01f, -5.42410500e-02f, -2.94591654e-02f, -7.85325933e-03f, 2.79662795e-02f, -1.57004535e-01f, 1.65542096e-01f,
  -2.33590454e-01f, -1.28865480e-01f, 3.06479279e-02f, 4.19857912e-02f, -3.66865061e-02f, -1.08763456e-01f, 2.49414161e-01f, 1.36482283e-01f, 2.52176046e-01f, 2.69887652e-02f,
  -1.71472400e-01f, 1.19197942e-01f, -5.34943081e-02f, 1.80392921e-01f, -9.56493393e-02f, 7.23170582e-03f, 6.18579872e-02f, 9.24337879e-02f, -4.58754599e-02f, 2.32025966e-01f,
  1.28282517e-01f, 1.22028708e-01f, 9.66823474e-02f, -8.68399441e-02f, -7.24123195e-02f, 7.55445808e-02f, -2.16163486e-01f, -1.53006077e-01f, -3.45777124e-02f, 2.16674477e-01f,
  4.75384265e-01f, -3.29220176e-01f, -1.82304561e-01f, 4.74125110e-02f, -2.83600122e-01f, -2.99338818e-01f, -5.18524706e-01f, -2.04029724e-01f, -6.70962110e-02f, -5.30386090e-01f,
  -3.78823906e-01f, 2.45652974e-01f, -2.14819890e-02f, 2.82488000e-02f, 1.57854483e-01f, -5.64121544e-01f, -3.63962322e-01f, 1.31768614e-01f, 6.25410914e-01f, 3.80984426e-01f,
  -1.01819104e-02f, 2.44780734e-01f, 4.19070154e-01f, 2.32912347e-01f, -2.21358687e-01f, -3.33753936e-02f, -2.31687352e-01f, 3.78435180e-02f, -2.36591786e-01f, -2.96539247e-01f,
  -3.26397032e-01f, 2.15185389e-01f, -5.47636896e-02f, 1.91160649e-01f, -2.08523393e-01f, -1.10974454e-03f, -1.10157415e-01f, 2.78617837e-03f, 9.53587964e-02f, -7.33078793e-02f,
  -1.98466718e-01f, -3.26754749e-02f, -4.28022072e-02f, -1.83395773e-01f, -1.05671555e-01f, 9.34537724e-02f, -3.99778634e-02f, 2.70329773e-01f, 6.34307191e-02f, -1.02482244e-01f,
  -1.99200645e-01f, 1.03840731e-01f, 2.21593305e-02f, -7.95378163e-02f, 1.02359727e-01f, 9.95251387e-02f, 2.66938396e-02f, 1.89148083e-01f, -9.01964307e-02f, -3.58725131e-01f,
  -1.72010824e-01f, -1.84298120e-02f, -1.41414896e-01f, 6.28119195e-03f, 1.64052676e-02f, -9.48549882e-02f, 7.05289915e-02f, -6.65028244e-02f, 9.59840864e-02f, -6.79675676e-03f,
  8.95474032e-02f, 4.85644154e-02f, 1.87677965e-01f, 4.22510058e-02f, 2.51196269e-02f, 2.15697493e-02f, 1.93454828e-02f, -2.07524002e-02f, 1.45221381e-02f, -1.69766508e-02f,
  1.07750602e-01f, -4.37031165e-02f, 8.14146176e-03f, 1.25900537e-01f, -5.25387749e-03f, -3.42956670e-02f, -8.57948046e-03f, -8.38710053e-04f, -1.53286755e-01f, -9.71970782e-02f,
  -1.44716442e-01f, -1.27162160e-02f, -3.41842055e-01f, 1.53365389e-01f, -1.57996804e-01f, -3.83047611e-02f, -2.23998398e-01f, 6.69702441e-02f, 7.03041106e-02f, 2.08372846e-02f,
  9.47342068e-02f, 3.64566818e-02f, -3.10427040e-01f, -1.40624410e-02f, -7.98896551e-02f, -7.80680105e-02f, -2.62755543e-01f, -4.63080443e-02f, -5.12487069e-02f, -7.54433349e-02f,
  -1.61455497e-01f, -1.85957819e-01f, -1.72463998e-01f, -1.96956113e-01f, -7.98903927e-02f, 7.34015275e-03f, -2.79006541e-01f, -1.31287843e-01f, -2.17110083e-01f, -4.17305082e-01f,
  2.64338672e-01f, -4.27770428e-02f, 4.25508954e-02f, -2.92877574e-02f, -1.15500867e-01f, -2.23581381e-02f, -1.26937583e-01f, -6.74513578e-02f, -3.87949236e-02f, -1.75684705e-01f,
  -3.62516902e-02f, 5.27227931e-02f, -7.84283131e-02f, 4.50302905e-04f, 6.69853911e-02f, -1.10666245e-01f, -1.39757946e-01f, 3.67610082e-02f, 1.19619653e-01f, -1.68218657e-01f,
  -1.22760452e-01f, -4.01822999e-02f, 1.16330035e-01f, 9.35821503e-04f, -1.65405005e-01f, -1.63696855e-01f, -6.66274130e-02f, -5.20507433e-03f, -8.28151032e-02f, -2.90444493e-01f,
  -1.17436394e-01f, 2.25282967e-01f, 4.11545187e-02f, 1.28902972e-01f, 6.26003891e-02f, 7.27433264e-02f, 3.30772288e-02f, -2.92782802e-02f, 3.18531245e-02f, -3.39534022e-02f,
  -4.24748622e-02f, 5.04474491e-02f, 1.74814180e-01f, 9.74204168e-02f, 1.00336820e-01f, 7.33022168e-02f, 2.33336799e-02f, -8.03305581e-02f, 7.31934095e-03f, -2.01620329e-02f,
  -5.53039871e-02f, 2.77810115e-02f, 7.74424523e-02f, 6.24659173e-02f, 6.71080947e-02f, 4.67357022e-05f, 1.29138917e-01f, 7.54134133e-02f, 1.70304000e-01f, 5.95823489e-02f,
  1.79061025e-01f, -5.60958050e-02f, 1.60981402e-01f, 6.03045151e-03f, 1.26318485e-01f, 6.33418858e-02f, -7.63758570e-02f, -1.75532736e-02f, 1.24696746e-01f, 1.54227808e-01f,
  -2.03996241e-01f, -1.76424738e-02f, 5.29298559e-02f, -2.62008160e-02f, 1.40177518e-01f, -2.34698299e-02f, -5.08343466e-02f, 9.03959572e-02f, 1.40800834e-01f, 1.07186176e-01f,
  6.03479892e-02f, -1.69347957e-01f, -3.39406952e-02f, 1.20430142e-02f, -4.18110490e-02f, -7.99661875e-03f, -6.99555967e-03f, -1.57274511e-02f, -3.25183906e-02f, -1.26889095e-01f,
  -2.35442549e-01f, 3.03105175e-01f, -3.25765163e-02f, 5.47849052e-02f, -2.94119250e-02f, 8.21994692e-02f, 1.32936984e-01f, 3.08907609e-02f, -1.16408609e-01f, -9.93924960e-02f,
  8.25190991e-02f, 3.46127301e-02f, -2.29237564e-02f, 4.83831540e-02f, 4.83579002e-02f, 6.04821295e-02f, 2.78734174e-02f, 1.51017983e-03f, 1.94404330e-02f, -7.70386904e-02f,
  5.26674576e-02f, -1.54534042e-01f, -7.35759139e-02f, -2.04924606e-02f, 3.64024490e-02f, 5.14527224e-02f, -1.66546311e-02f, -1.72572210e-02f, 1.01609141e-01f, -1.75329670e-01f,
  -9.79376212e-02f, -1.18774064e-02f, 1.40468106e-01f, 1.80291876e-01f, -5.72993644e-02f, -2.12057322e-01f, -2.19993636e-01f, -1.13551959e-01f, -9.23114549e-03f, -1.16474524e-01f,
  -1.87071770e-01f, 6.39747754e-02f, 9.36239064e-02f, 1.93635583e-01f, 3.36312167e-02f, 6.10817745e-02f, 2.30454654e-01f, 3.33497763e-01f, 2.16810405e-01f, -6.20512441e-02f,
  -4.34171408e-02f, 9.00879726e-02f, 2.04425842e-01f, 2.05228895e-01f, 1.66461855e-01f, 1.51082605e-01f, 1.49714336e-01f, 1.02133509e-02f, 7.59328231e-02f, 4.25845534e-01f,
  -5.41481897e-02f, -1.71573922e-01f, -8.85493755e-02f, 7.01406673e-02f, -3.53828929e-02f, 5.21997660e-02f, -1.34295240e-01f, 6.19002730e-02f, 5.26858866e-02f, 9.91011187e-02f,
  -9.69249606e-02f, 6.58854023e-02f, 1.69049606e-01f, -3.59046422e-02f, -9.25391242e-02f, -2.09064618e-01f, 7.50949085e-02f, 2.97970563e-01f, 1.06952459e-01f, -6.39932603e-02f,
  2.33861342e-01f, -6.26185536e-02f, -2.06485987e-01f, -1.99392930e-01f, 4.12857309e-02f, 1.18044876e-01f, -2.03747258e-01f, -6.10163733e-02f, -1.71740830e-01f, -1.54558560e-02f,
  2.65484769e-02f, -6.97845072e-02f, -6.72724545e-02f, 4.79888842e-02f, 1.26223534e-01f, 6.43375516e-02f, 6.71251789e-02f, -4.03893255e-02f, 9.78163630e-02f, 1.39020681e-01f,
  1.36040226e-01f, -1.85512714e-02f, 5.36642447e-02f, 1.26579739e-02f, 1.59914628e-01f, -4.82781529e-02f, -2.22528595e-02f, 4.65267561e-02f, -1.47055522e-01f, 6.03278093e-02f,
  1.11933313e-01f, 2.42418107e-02f, 1.05530415e-02f, 1.25604182e-01f, 1.17931075e-01f, 1.13867084e-02f, -4.01633419e-02f, -4.45933603e-02f, -2.25419644e-03f, -1.87422559e-01f,
  -2.65070558e-01f, -1.99418873e-01f, -1.74030498e-01f, 5.68149574e-02f, 7.56487548e-02f, -1.18814204e-02f, -8.60014744e-03f, -2.81658955e-02f, -1.30861953e-01f, -5.27991652e-02f,
  -2.13711292e-01f, 9.80418269e-03f, -1.39466107e-01f, -4.59952056e-02f, -8.90397951e-02f, -1.15148388e-01f, -6.41144440e-02f, 8.74497741e-02f, 1.40512874e-02f, -3.98849733e-02f,
  8.55520144e-02f, -2.01313913e-01f, -3.13126594e-01f, -2.64508724e-01f, -2.62050807e-01f, -2.13443011e-01f, -2.52248466e-01f, -2.97150075e-01f, -3.79941463e-01f, -2.80070961e-01f,
  2.76308835e-01f, -1.67420045e-01f, -6.34827018e-01f, -3.58670175e-01f, -4.97920603e-01f, -2.78399080e-01f, -1.46420240e-01f, 4.76867259e-02f, -5.76847531e-02f, -1.87878385e-01f,
  -1.59163371e-01f, 1.85370911e-02f, -1.78965569e-01f, -6.65783957e-02f, 1.64771706e-01f, -3.47448140e-01f, -3.43788266e-01f, -1.09151952e-01f, 1.51683107e-01f, 6.02025203e-02f,
  -3.25363874e-02f, -2.45231260e-02f, 4.61875871e-02f, -5.79582378e-02f, -2.37565488e-01f, -2.51311719e-01f, -4.13981289e-01f, -2.83427179e-01f, -2.43267432e-01f, -4.74496961e-01f,
  -3.89453292e-01f, -1.69016525e-01f, -9.33025591e-03f, 2.36223653e-01f, -6.02366924e-02f, 3.91875803e-02f, 5.10108359e-02f, 4.43838015e-02f, 1.83727860e-01f, -1.22254498e-01f,
  -2.85216626e-02f, 1.53650478e-01f, 2.60286275e-02f, -3.43514867e-02f, -1.16842322e-01f, 4.63609658e-02f, -3.24765518e-02f, 3.45813781e-02f, -1.72362961e-02f, 1.17931990e-02f,
  2.05689715e-03f, -2.17634868e-02f, -1.14371911e-01f, 6.71792403e-02f, -2.11215876e-02f, -3.16420905e-02f, -1.95063561e-01f, -1.20216198e-01f, -1.61130562e-01f, -1.98912039e-01f,
  9.41384509e-02f, -2.87241060e-02f, 3.26586962e-02f, 9.11832899e-02f, 1.74908057e-01f, 7.12573603e-02f, 9.85846072e-02f, 1.60222322e-01f, 7.42138252e-02f, -2.35982109e-02f,
  -6.98590204e-02f, -2.34768651e-02f, 4.32645865e-02f, 5.91905415e-02f, 1.87583677e-02f, 6.68260679e-02f, -8.03069153e-04f, -1.64256580e-02f, -3.59233879e-02f, 5.71986288e-02f,
  -7.64011070e-02f, 1.09684087e-01f, -7.88211077e-02f, 3.56368348e-02f, 6.47003725e-02f, -5.32249995e-02f, -1.12440363e-01f, 3.46564464e-02f, -8.82284790e-02f, -3.06014512e-02f,
  -8.87193531e-02f, 1.36507554e-02f, -4.51752730e-02f, 1.04008773e-02f, -1.13383250e-03f, -2.95769889e-02f, -5.95633388e-02f, 1.35334268e-01f, 7.65169933e-02f, -2.47727986e-02f,
  -1.00495415e-02f, -2.85721309e-02f, -1.25966713e-01f, -1.07283145e-03f, -7.16323778e-02f, 7.72612393e-02f, 6.20534606e-02f, 3.28687578e-02f, 3.89957167e-02f, -4.57287990e-02f,
  2.83549186e-02f, 2.82627881e-01f, 1.91979066e-01f, -7.44570270e-02f, -3.90645973e-02f, 1.94954611e-02f, -1.11193143e-01f, -4.77044657e-03f, 6.21231571e-02f, 7.91598409e-02f,
  -4.89917278e-01f, -1.20953254e-01f, 1.25951931e-01f, 4.15533632e-01f, 3.30780238e-01f, -4.13578451e-02f, -2.93819487e-01f, -3.98730338e-01f, 1.32650673e-01f, 1.87874764e-01f,
  3.60847563e-01f, 3.56641263e-01f, 3.81986141e-01f, 2.58988947e-01f, -9.39407051e-02f, -2.28562951e-02f, 7.96374306e-02f, -1.19223401e-01f, -6.79959729e-02f, -1.54986726e-02f,
  2.56674528e-01f, 4.92649991e-03f, -1.28102005e-01f, -2.55103499e-01f, 3.19678038e-01f, 2.83825755e-01f, 7.95740541e-03f, 1.56525880e-01f, 4.35539074e-02f, 4.15888906e-01f,
  4.99535054e-01f, -3.55135351e-01f, 1.77443117e-01f, 1.00428008e-01f, 3.78673933e-02f, -1.62396133e-01f, -9.75988954e-02f, -2.68101692e-01f, -1.68791384e-01f, -1.66844562e-01f,
  1.17462426e-01f, -7.32301772e-02f, 8.29900429e-02f, -2.74753626e-02f, -3.27539325e-01f, -3.33035797e-01f, -4.47421223e-01f, -5.60511827e-01f, -3.10917675e-01f, -3.26128572e-01f,
  7.30860010e-02f, 3.57462987e-02f, -2.72403322e-02f, -2.88877934e-01f, -3.41636866e-01f, 8.77743959e-02f, -2.04304606e-01f, -3.27345639e-01f, -5.10846257e-01f, -2.77872264e-01f,
  -7.08142594e-02f, -5.02678789e-02f, -3.35340295e-03f, -9.69691724e-02f, -3.06188930e-02f, 1.64830256e-02f, -5.93193099e-02f, 5.34877256e-02f, 3.07347402e-02f, 4.28250805e-03f,
  7.97049403e-02f, -4.16162945e-02f, -2.54411274e-03f, -1.26112709e-02f, 2.55378317e-02f, -2.19014706e-03f, 3.48776579e-02f, -7.40665197e-02f, -1.47754923e-01f, -8.89536440e-02f,
  9.65895057e-02f, 1.16469152e-02f, 1.00075658e-02f, -2.88280427e-01f, 2.61943154e-02f, -1.25944346e-01f, 9.95296687e-02f, 1.83187462e-02f, 2.73049418e-02f, -1.45310640e-01f,
  3.63303244e-01f, -3.48659098e-01f, 3.14701051e-01f, -6.94699585e-02f, 5.82803115e-02f, -1.06856145e-01f, 7.21963271e-02f, 1.51463235e-02f, 6.97501972e-02f, -1.35009304e-01f,
  -3.45788412e-02f, -6.65057078e-02f, 9.52463150e-02f, -1.48207337e-01f, -2.67208181e-02f, -4.59137885e-03f, 4.42096666e-02f, 1.05774917e-01f, -2.73190320e-01f, -2.01420292e-01f,
  -4.04272787e-03f, -1.93462014e-01f, 1.88919917e-01f, 1.09856389e-01f, 8.38716328e-02f, 1.90159887e-01f, 1.07019164e-01f, 6.83278590e-02f, -4.69243377e-02f, 3.38914767e-02f,
  1.83069125e-01f, -3.88014495e-01f, -1.75577506e-01f, 2.85154164e-01f, -1.26713768e-01f, -1.39532341e-02f, -1.18917443e-01f, 1.49780795e-01f, 1.82996109e-01f, -1.29299358e-01f,
  1.94102287e-01f, 5.99160254e-01f, 6.06351793e-01f, 4.57669199e-01f, 2.21387282e-01f, -3.19664419e-01f, -2.41536036e-01f, 7.36203417e-02f, 1.25062749e-01f, 6.74388045e-03f,
  -2.26938277e-02f, 1.34653272e-02f, 1.02461912e-01f, 8.42490643e-02f, -4.76717085e-01f, 5.78740723e-02f, -3.32221180e-01f, -4.34843570e-01f, -3.85540515e-01f, -7.68926919e-01f,
  -2.37378716e-01f, -2.49124974e-01f, 1.91965014e-01f, 1.14021093e-01f, -1.26435578e-01f, 1.94961727e-02f, -1.64428696e-01f, -2.85677195e-01f, -8.67291614e-02f, -2.71266609e-01f,
  -1.19375676e-01f, -6.01311289e-02f, 1.01412553e-02f, -2.54193962e-01f, -2.38574207e-01f, 2.66418476e-02f, -7.16240332e-02f, -1.87574223e-01f, 1.61694899e-01f, -2.40809932e-01f,
  -2.27674991e-01f, -5.53300738e-01f, -4.63191569e-01f, -1.18495412e-01f, -1.18682556e-01f, 1.91771507e-01f, -4.57449794e-01f, -3.68936330e-01f, -1.33830711e-01f, -6.75005734e-01f,
  8.27305764e-02f, -5.11755086e-02f, 1.00607552e-01f, 5.36830053e-02f, 1.67803600e-01f, 6.86071580e-03f, -5.56912757e-02f, 1.12912998e-01f, -1.08849294e-01f, -1.64697036e-01f,
  2.42661968e-01f, 1.06457256e-01f, 7.17705116e-02f, -1.05342321e-01f, 3.62581275e-02f, -3.51256281e-01f, -2.76862830e-02f, 1.03799075e-01f, 3.18586603e-02f, -5.29146530e-02f,
  3.81506197e-02f, -1.78781953e-02f, 6.98354840e-02f, -2.15252559e-03f, 5.15499003e-02f, 1.53274268e-01f, -9.50845480e-02f, 8.63758773e-02f, -1.78680830e-02f, -7.29738623e-02f,
  2.85644621e-01f, 5.53876996e-01f, -1.92893773e-01f, 1.09262034e-01f, -1.64763793e-01f, 1.00482339e-02f, 5.75920641e-02f, -2.00166292e-02f, 1.02223717e-01f, 1.95656106e-01f,
  -2.32512683e-01f, -5.61783910e-02f, -3.50014046e-02f, -1.46602899e-01f, 4.11061719e-02f, 4.70640473e-02f, -8.61913636e-02f, -3.55153643e-02f, 3.05187120e-03f, -3.50111812e-01f,
  -2.30390981e-01f, -9.99985561e-02f, -6.27710596e-02f, -1.16282180e-01f, -3.22327703e-01f, 2.05667719e-01f, -1.50903076e-01f, -2.91715831e-01f, 2.48860896e-01f, -1.42936632e-01f,
  -2.80199051e-01f, 5.06874204e-01f, 3.88856083e-01f, -4.30897713e-01f, -1.70999557e-01f, 2.11389527e-01f, 4.90729481e-01f, 1.96673468e-01f, -2.40820244e-01f, 1.41288012e-01f,
  -8.48769471e-02f, -2.62015194e-01f, -1.34912401e-01f, -6.34189099e-02f, 2.26684660e-01f, 2.53181756e-01f, 1.59212604e-01f, 1.45421237e-01f, -1.55405611e-01f, -3.06962393e-02f,
  -1.71124801e-01f, -1.84197217e-01f, -9.78366435e-02f, -6.18077181e-02f, -8.24746192e-02f, -2.83701062e-01f, -3.46291400e-02f, -6.66484758e-02f, 2.58238792e-01f, 1.68764606e-01f,
  4.06378880e-03f, 2.56017506e-01f, -1.09008901e-01f, -1.31065682e-01f, -1.49997950e-01f, 7.88826197e-02f, 2.31973864e-02f, -4.55652252e-02f, -3.39880437e-02f, 1.13956690e-01f,
  -2.40107685e-01f, 3.17996442e-02f, -1.04745872e-01f, -5.89249320e-02f, -1.39811590e-01f, -6.78368211e-02f, 7.23792315e-02f, 1.81670934e-01f, -6.19706251e-02f, 1.19460620e-01f,
  -1.13817364e-01f, -2.47006491e-01f, -7.01676533e-02f, 1.03744276e-01f, 1.83097452e-01f, -3.29617202e-01f, 3.03543862e-02f, 1.35222271e-01f, 1.56449109e-01f, -1.39164925e-01f,
  -1.74376488e-01f, 6.31062835e-02f, -3.41311134e-02f, 4.12294678e-02f, -1.54536190e-02f, 4.19499092e-02f, 8.64125730e-04f, -6.98769093e-02f, 8.54876637e-02f, -6.05241917e-02f,
  2.70143319e-02f, -1.02546871e-01f, 5.69333730e-04f, 4.87120263e-02f, -5.07370085e-02f, -5.78774177e-02f, -3.76977473e-02f, 3.98103930e-02f, 4.08820063e-02f, 6.67559505e-02f,
  -9.20425802e-02f, 1.92560963e-02f, -1.11449346e-01f, 1.52946457e-01f, 9.99966934e-02f, 7.13337511e-02f, -9.27175134e-02f, -1.28018513e-01f, -1.84596121e-01f, 1.25860751e-01f,
  -3.04786712e-01f, 1.04152009e-01f, -2.51556367e-01f, 9.08095986e-02f, -4.61579561e-02f, -6.07874058e-02f, 2.01303698e-02f, -8.17256235e-03f, -1.01839028e-01f, 2.91714650e-02f,
  1.32888213e-01f, 8.98903385e-02f, -1.19139664e-01f, -8.92942622e-02f, -1.14997216e-01f, -1.68924540e-01f, -8.35619420e-02f, -1.69817686e-01f, -1.72120839e-01f, -1.20827772e-01f,
  -1.16532229e-01f, -2.89622664e-01f, -5.00873506e-01f, -2.32950240e-01f, -3.61350894e-01f, -4.21141922e-01f, -1.55670702e-01f, -1.82956994e-01f, -1.32647827e-01f, -2.89540619e-01f,
  2.80559838e-01f, 4.16187495e-01f, -5.32514602e-03f, 1.25792384e-01f, 1.33836418e-01f, 7.40623325e-02f, 2.58635014e-01f, 4.52372730e-02f, -8.51270929e-03f, 1.06625892e-01f,
  3.96822952e-03f, -2.28869185e-01f, -8.58014598e-02f, -6.01249672e-02f, -1.44704521e-01f, 8.13170001e-02f, 4.24801782e-02f, -4.89626825e-02f, -1.51623324e-01f, 4.49717417e-02f,
  -3.59748751e-02f, 1.60276920e-01f, 1.01775870e-01f, 3.09971143e-02f, -4.09310535e-02f, -1.07071705e-01f, 1.06009886e-01f, 1.33278370e-01f, -3.94369811e-02f, -8.61966386e-02f,
  -2.35910654e-01f, 5.67951202e-02f, -2.77456284e-01f, -2.26825606e-02f, 6.46233633e-02f, -4.57789749e-02f, 4.02920917e-02f, 7.64377788e-02f, 7.50341862e-02f, 6.80559035e-03f,
  -5.32608964e-02f, 1.08877989e-02f, 9.46663544e-02f, 9.41563025e-02f, 5.41752689e-02f, 2.99839322e-02f, 8.39148685e-02f, -9.89811681e-03f, 6.00732677e-03f, -1.06809169e-01f,
  -6.53137732e-03f, 3.31987776e-02f, 7.46028423e-02f, -6.81871176e-02f, -9.30513591e-02f, -3.44957747e-02f, 2.10175179e-02f, -9.67930479e-04f, -1.36097491e-01f, -1.69018167e-03f,
  -2.73474783e-01f, -6.58463538e-02f, 2.13426054e-02f, -8.50280095e-03f, 1.68275516e-02f, 3.58498879e-02f, 1.04182884e-01f, 5.55768237e-02f, 1.59659458e-03f, 1.46287978e-01f,
  5.95486388e-02f, -6.63815662e-02f, -6.90465420e-02f, 8.03357735e-02f, -1.06309660e-01f, -2.99775414e-03f, 2.92506274e-02f, -1.56900417e-02f, 4.67965044e-02f, 9.99632776e-02f,
  1.41195739e-02f, 1.19027589e-02f, 9.21475142e-02f, 2.35383827e-02f, 8.18660334e-02f, -6.02856055e-02f, 1.12557514e-02f, 1.28969476e-02f, 6.39694333e-02f, 5.08020222e-02f,
  1.01750433e-01f, -9.37392414e-02f, -1.09189682e-01f, 4.25463282e-02f, 6.46207929e-02f, 4.22567688e-02f, -1.16342613e-02f, 3.86939459e-02f, 9.84665975e-02f, 7.93315098e-02f,
  4.10450585e-02f, -1.04809463e-01f, -5.68408370e-02f, 4.85943742e-02f, -2.99849687e-03f, -7.30869174e-02f, 9.90138203e-02f, 9.69559420e-04f, 3.98403481e-02f, -3.85422520e-02f,
  5.15804477e-02f, 2.43821424e-02f, -3.04044988e-02f, -1.49956971e-01f, -9.98432040e-02f, -9.41968188e-02f, -1.02120325e-01f, -1.18288092e-01f, -4.03629430e-02f, 1.01846904e-01f,
  6.97992146e-01f, -4.43796776e-02f, -1.05230324e-01f, 5.34686893e-02f, -3.15764081e-03f, -2.20961310e-02f, 9.54812318e-02f, 1.62022293e-01f, 1.05121743e-03f, 8.50477964e-02f,
  1.43884704e-01f, 2.01496884e-01f, 1.91881835e-01f, 1.37723476e-01f, 1.38233528e-01f, 2.74427738e-02f, -6.36446774e-02f, -4.22636978e-02f, 1.61283627e-01f, 8.45126435e-02f,
  -1.01434179e-01f, 3.31884138e-02f, 1.39217749e-02f, 9.78991240e-02f, -1.27076447e-01f, -3.69717745e-04f, -5.73601052e-02f, -1.86467141e-01f, -9.33447033e-02f, -2.99960524e-01f,
  -3.11920881e-01f, 1.34924844e-01f, -3.69030349e-02f, 5.65988757e-03f, 4.48852815e-02f, 8.58920515e-02f, 1.22820280e-01f, -7.26404637e-02f, -6.69368282e-02f, -5.85389920e-02f,
  -2.56580468e-02f, -6.80446997e-03f, -1.09756410e-01f, -4.82738763e-02f, -9.45082381e-02f, -3.45054977e-02f, 8.72747153e-02f, -1.16143432e-02f, -1.34982795e-01f, 2.32651308e-02f,
  -2.82806102e-02f, -1.10681966e-01f, -1.08362287e-01f, 8.70622620e-02f, 7.60237724e-02f, -1.81139987e-02f, -7.25506917e-02f, -4.20668274e-02f, 6.69954643e-02f, 5.84435277e-02f,
  -3.82965850e-03f, 1.69723347e-01f, 8.33680015e-03f, 7.92546943e-02f, 1.68733612e-01f, 8.12841654e-02f, -5.54485060e-02f, -4.72856872e-02f, 1.09304063e-01f, 7.53050148e-02f,
  -9.25988629e-02f, -3.67149338e-02f, -5.36233606e-03f, 1.37052750e-02f, -1.13910310e-01f, -1.14363290e-01f, -8.26032553e-03f, 4.12649568e-03f, -9.24306437e-02f, -8.72362182e-02f,
  -5.23960330e-02f, -9.30637345e-02f, -1.84594437e-01f, -6.01622015e-02f, -2.02404290e-01f, -1.37640489e-02f, 1.23396292e-02f, 5.49962744e-02f, -4.04548505e-03f, -6.44154176e-02f,
  -2.15765253e-01f, 1.39469981e-01f, -1.62329841e-02f, 7.51953796e-02f, -3.78316045e-02f, 6.35066554e-02f, 1.34415910e-01f, -3.56083810e-02f, -6.23193346e-02f, -1.05424076e-01f,
  1.48002980e-02f, -1.35387685e-02f, 4.02094536e-02f, 4.73589078e-02f, 9.16062519e-02f, -9.14166495e-02f, 1.06974609e-01f, -2.46506855e-02f, -1.40613660e-01f, -9.38467085e-02f,
  -1.37625992e-01f, 1.00442804e-02f, 6.05870038e-02f, 1.04100734e-01f, 1.41013861e-01f, 7.02081099e-02f, 7.59722665e-02f, -9.61282700e-02f, -2.97580548e-02f, 9.67503563e-02f,
  2.19210416e-01f, -1.05250835e-01f, 1.21656358e-01f, 2.02358484e-01f, 1.80488870e-01f, 3.42567742e-01f, 4.22727317e-01f, 3.12368810e-01f, 1.93169743e-01f, -1.15916217e-02f,
  -2.97825098e-01f, -2.99401700e-01f, -2.96962738e-01f, -2.05282018e-01f, -1.68891817e-01f, 2.52768397e-01f, 2.74999738e-01f, 5.63901626e-02f, 1.06085185e-02f, 1.05377294e-01f,
  7.85864815e-02f, 5.94662018e-02f, -1.47961885e-01f, 1.43741653e-03f, 1.51166663e-01f, 5.98079935e-02f, 6.70852736e-02f, 1.57892421e-01f, -8.78011286e-02f, 1.80040188e-02f,
  -3.42129856e-01f, -7.39570633e-02f, -1.05556771e-01f, -1.84358239e-01f, -7.39867464e-02f, -4.68251817e-02f, -2.36512767e-03f, -7.01448321e-02f, -1.02969617e-01f, 1.21135125e-02f,
  -1.22623764e-01f, -1.63055360e-01f, -1.03937358e-01f, -1.94335282e-02f, 1.06943674e-01f, -1.11620575e-02f, -6.51426390e-02f, -2.09028763e-03f, -4.81336638e-02f, -5.35414554e-02f,
  -1.10773437e-01f, -3.80981900e-02f, 5.74392639e-03f, -3.48027572e-02f, -9.03556272e-02f, -1.24250919e-01f, -7.15873623e-03f, -1.40587538e-01f, -2.41540070e-03f, 8.36618692e-02f,
  -7.30243847e-02f, 3.81703563e-02f, 5.54059893e-02f, 8.59396234e-02f, -3.38810049e-02f, -4.99372110e-02f, 1.31633550e-01f, -2.10887124e-03f, 5.06966747e-02f, -1.69335026e-02f,
  3.78711633e-02f, -4.89377975e-02f, 2.51589660e-02f, 7.68307298e-02f, -1.08358555e-01f, 7.07067400e-02f, 1.18340306e-01f, -1.23306662e-01f, -1.36805162e-01f, 4.57136855e-02f,
  -4.29126620e-02f, -5.13145607e-03f, -3.74117456e-02f, -5.31027764e-02f, -8.75730533e-03f, 1.03609189e-02f, 3.96411791e-02f, -4.37374450e-02f, -5.56586310e-02f, 1.13891952e-01f,
  1.59451216e-02f, -2.16871202e-01f, 1.54556846e-02f, -1.60049926e-02f, -1.61822850e-03f, -1.55674174e-01f, -7.55988508e-02f, -8.26827437e-02f, 5.60633466e-02f, -7.40550309e-02f,
  -1.29355296e-01f, -1.39642283e-01f, -1.79145448e-02f, -7.48397186e-02f, 4.97745946e-02f, -4.89307493e-02f, -9.79639813e-02f, 7.76254535e-02f, -8.55385661e-02f, -6.52393838e-03f,
  -7.03330189e-02f, 7.03101754e-02f, 1.28871337e-01f, 1.03182018e-01f, 7.10368529e-02f, 9.33294967e-02f, 4.15818989e-02f, 8.48118290e-02f, 4.54755984e-02f, 1.61383212e-01f,
  -2.76933283e-01f, -5.25110543e-01f, -5.00320852e-01f, -4.39840883e-01f, 1.58566907e-02f, 2.26967424e-01f, 7.76546374e-02f, -2.78733554e-03f, -1.96212843e-01f, -3.87573034e-01f,
  -3.22783083e-01f, -1.87162265e-01f, -4.94249612e-01f, -1.24998964e-01f, 1.06277563e-01f, -2.76769638e-01f, -2.15254396e-01f, -3.30443978e-02f, 3.77089292e-01f, 4.33910519e-01f,
  1.54277578e-01f, -2.10037187e-01f, -8.73019323e-02f, -3.79069448e-02f, -3.55209261e-01f, -1.11182652e-01f, -3.53055835e-01f, -2.68853664e-01f, -1.45388590e-02f, -4.70921248e-01f,
  -2.92264462e-01f, -2.85498887e-01f, 2.65915900e-01f, -4.25684592e-03f, -1.51844949e-01f, -1.71546657e-02f, -6.39126673e-02f, -1.43835440e-01f, -1.04037426e-01f, -2.73713827e-01f,
  -1.17881916e-01f, 4.40724939e-02f, -6.51065633e-02f, -8.62366334e-02f, -8.31193849e-02f, 8.02671611e-02f, -5.62700480e-02f, -1.65940635e-02f, -9.79913846e-02f, -3.64809670e-02f,
  2.36904249e-02f, 1.04941830e-01f, 3.97515297e-02f, 1.04006559e-01f, 1.86296836e-01f, 1.31573468e-01f, -9.09888744e-02f, 2.54424304e-01f, 1.45917535e-01f, -2.43943915e-01f,
  9.20409113e-02f, -5.52859344e-02f, 6.83111772e-02f, 7.22560333e-03f, 1.02750629e-01f, 9.87772942e-02f, -9.26179253e-03f, -2.76405346e-02f, 1.35942891e-01f, -7.48779252e-02f,
  3.50751951e-02f, 4.95348535e-02f, -2.45478116e-02f, -9.88049805e-02f, 3.37891057e-02f, -8.30397531e-02f, 5.78749739e-02f, -5.75377569e-02f, -6.16283640e-02f, 6.36268556e-02f,
  2.33686771e-02f, -1.96383474e-03f, -9.09578726e-02f, 1.60804894e-02f, 5.81883565e-02f, -1.29674464e-01f, 1.37372185e-02f, 2.94954088e-02f, -6.19608238e-02f, 7.89969414e-02f,
  -4.42539066e-01f, 1.92197457e-01f, -1.75683603e-01f, 3.36817950e-02f, -4.71247919e-02f, -7.56182149e-02f, -9.52182487e-02f, 3.46919186e-02f, -9.00359675e-02f, 2.84682284e-03f,
  -9.39118396e-03f, -2.97899693e-02f, -2.15449274e-01f, -1.56699158e-02f, 6.61302805e-02f, 1.40349150e-01f, 4.26495112e-02f, -8.87845457e-02f, 3.70383263e-02f, 8.61972943e-02f,
  -9.70871374e-03f, 2.69089192e-01f, 9.68307555e-02f, -3.80828902e-02f, 1.49239346e-01f, 2.51515061e-01f, -8.14107209e-02f, 1.41308174e-01f, 3.03582519e-01f, -1.45253986e-01f,
  -5.49338639e-01f, 2.92462051e-01f, 2.38453016e-01f, -1.69437930e-01f, 1.96144819e-01f, 2.82819360e-01f, 3.64084959e-01f, -1.94766894e-02f, -1.59878060e-01f, 3.56264524e-02f,
  4.23307195e-02f, -1.87890604e-01f, -1.01812534e-01f, -9.11787972e-02f, -6.46338856e-04f, 2.77837157e-01f, 2.47790053e-01f, 3.07157356e-02f, -2.73831397e-01f, -1.67503148e-01f,
  5.49511276e-02f, -6.63902685e-02f, -2.89915353e-01f, -1.21833369e-01f, -7.32249990e-02f, -7.11993873e-02f, 2.00606152e-01f, 2.91567147e-02f, 1.71007007e-01f, 4.29564156e-02f,
  -1.85870007e-01f, -1.05045639e-01f, 7.65621662e-02f, 5.02023939e-03f, 4.01755981e-02f, -2.77265340e-01f, -2.38937110e-01f, -2.58293957e-01f, -6.12477250e-02f, -2.59379931e-02f,
  8.01793039e-02f, -4.96167764e-02f, 1.21954530e-02f, 2.34549232e-02f, -1.75910845e-01f, -2.02341646e-01f, -4.42445762e-02f, -1.64715990e-01f, -1.19535677e-01f, -1.55342817e-01f,
  1.50608003e-01f, 1.57570727e-02f, -1.41981572e-01f, 6.39600605e-02f, -7.73315728e-02f, -2.45327204e-01f, 4.63251546e-02f, -2.50249386e-01f, -2.27816284e-01f, -2.97585249e-01f,
  -3.97163071e-02f, 1.64900959e-01f, -1.35847209e-02f, 4.73782495e-02f, 7.41073191e-02f, 3.76137942e-02f, 9.63149965e-02f, 2.80728694e-02f, 4.06863019e-02f, 7.38917664e-02f,
  -7.82266930e-02f, -1.51277527e-01f, -2.32986566e-02f, -1.38278127e-01f, -1.77017003e-01f, 1.16040982e-01f, 5.04059419e-02f, 8.47029835e-02f, 2.31137779e-02f, 3.62558960e-04f,
  -1.14729911e-01f, -3.21369097e-02f, -4.90041040e-02f, -9.97172669e-02f, -4.55674380e-02f, 7.86390007e-02f, -6.64515495e-02f, -7.46551752e-02f, 4.57096361e-02f, 1.49699479e-01f,
  -2.09411845e-01f, 3.22338492e-01f, -7.82306269e-02f, 1.39138969e-02f, 8.86574388e-03f, -3.64877582e-02f, -2.03954861e-01f, -1.45622212e-02f, -4.71056104e-02f, -1.31926402e-01f,
  5.60644232e-02f, -8.62053856e-02f, 1.00184038e-01f, -3.70382965e-02f, -1.19286217e-01f, -1.84967384e-01f, 1.51719138e-01f, -8.71358216e-02f, -1.31398037e-01f, -7.24634305e-02f,
  4.25588079e-02f, -5.39034046e-02f, -2.52960622e-01f, -8.75978842e-02f, -2.51218490e-02f, -1.93048224e-01f, -6.06480846e-03f, -1.27338693e-01f, -1.22054107e-01f, -1.12332821e-01f,
  -9.91773084e-02f, 3.94511633e-02f, -1.04479462e-01f, 2.93454498e-01f, 3.30326915e-01f, -2.95902193e-01f, -5.05705774e-01f, -3.25854987e-01f, 1.40250087e-01f, 9.07605365e-02f,
  1.24643788e-01f, 2.35206425e-01f, -4.29619811e-02f, -1.51733711e-01f, -6.01811111e-01f, -4.85669702e-01f, -3.12627882e-01f, -4.33975220e-01f, -4.87523526e-01f, -2.50315756e-01f,
  4.76082228e-03f, 5.54559417e-02f, -1.91399530e-01f, -4.74276543e-02f, 4.59411055e-01f, 2.10286066e-01f, 1.21701553e-01f, 1.75131336e-01f, -5.28209805e-02f, 1.81599185e-01f,
  1.09155618e-01f, 1.61168993e-01f, -1.22832991e-01f, 1.72450155e-01f, 2.80901372e-01f, -1.82197154e-01f, -2.38420382e-01f, 4.45155129e-02f, 8.49363860e-03f, -1.16740547e-01f,
  2.70087630e-01f, -2.13292334e-02f, 1.66885674e-01f, -3.42324786e-02f, -4.01251614e-02f, -1.65062502e-01f, -1.87297851e-01f, -3.38660181e-01f, -3.07379574e-01f, -2.07502723e-01f,
  1.03977978e-01f, 1.67627335e-01f, -9.71463323e-02f, -3.11731189e-01f, -1.72625005e-01f, -1.09515645e-01f, 8.28518649e-04f, -1.66188493e-01f, -3.28833580e-01f, -1.52883038e-01f,
  -2.82451641e-02f, 7.46352822e-02f, 1.90389361e-02f, 7.00471997e-02f, -6.58660531e-02f, 1.55799791e-01f, 1.07466221e-01f, -5.97075373e-02f, 3.36214453e-02f, -6.90850988e-02f,
  2.07396261e-02f, -1.56676117e-02f, 4.36729416e-02f, -4.14778814e-02f, -1.52979996e-02f, 3.25738527e-02f, -6.79826438e-02f, -6.13664016e-02f, -1.55704737e-01f, 3.67413908e-02f,
  -6.01838604e-02f, 3.44515741e-02f, 1.61194816e-01f, 4.15553041e-02f, -6.30607083e-02f, -4.69753742e-02f, 1.72561407e-01f, 5.68744056e-02f, -1.55019872e-02f, 4.72396649e-02f,
  2.02878520e-01f, -1.31585598e-01f, -4.16478179e-02f, -1.21054895e-01f, 1.58524781e-01f, -2.95527801e-02f, 1.19835168e-01f, -1.14324413e-01f, 7.00589120e-02f, -1.23032808e-01f,
  -1.05118655e-01f, -9.25876573e-02f, 5.02053350e-02f, -1.13753356e-01f, -2.24317685e-01f, 2.63057239e-02f, -1.77851006e-01f, 7.48236701e-02f, -2.24355012e-01f, 5.93619123e-02f,
  -1.20665327e-01f, -3.60126644e-01f, -2.80007333e-01f, -1.77204728e-01f, -6.49845749e-02f, -2.37696454e-01f, -2.54750580e-01f, -9.97408107e-02f, -4.40860003e-01f, -3.36388201e-01f,
  -4.35703754e-01f, 2.34023929e-01f, 2.06006870e-01f, -6.38008937e-02f, 2.64377385e-01f, 2.11080760e-01f, 3.55436683e-01f, 2.02267140e-01f, -2.08428595e-02f, 4.71462086e-02f,
  1.26777589e-01f, -8.37136954e-02f, -2.27869064e-01f, -1.12813190e-01f, -2.71635175e-01f, -6.35247007e-02f, -1.32157549e-01f, -2.11404875e-01f, -2.59636611e-01f, -5.98571189e-02f,
  -2.24851266e-01f, -3.30051869e-01f, -3.31483096e-01f, -2.38661572e-01f, -7.75211826e-02f, -1.68303162e-01f, 6.22824021e-02f, 6.50737286e-02f, 1.54092267e-01f, -1.46074191e-01f,
  -1.54910833e-02f, 3.24741542e-01f, -1.20850921e-01f, -1.01875007e-01f, 4.94205058e-02f, -4.55062166e-02f, -6.52517006e-02f, -2.85280999e-02f, -5.66172004e-02f, 3.40706259e-02f,
  9.41006094e-02f, 1.07134305e-01f, -6.20030705e-03f, 9.41454768e-02f, 8.58778208e-02f, 1.00920781e-01f, 6.91755861e-02f, 9.53510776e-02f, 9.74130537e-03f, 1.40781090e-01f,
  5.08826673e-02f, 9.07634571e-02f, 1.50413826e-01f, 1.22775212e-01f, 1.46830663e-01f, 6.26524985e-02f, 1.74019262e-01f, 1.46209210e-01f, 1.75255723e-02f, -9.58530977e-02f,
  5.48402295e-02f, -2.12423373e-02f, 1.62655592e-01f, 1.34637788e-01f, -2.32398622e-02f, -1.61661878e-02f, -3.52204181e-02f, -7.40514025e-02f, -1.31750897e-01f, -1.06898181e-01f,
  5.07972054e-02f, 1.73733812e-02f, 5.10877743e-02f, -9.29781869e-02f, -1.68679968e-01f, 5.97951114e-02f, -9.66387242e-02f, -5.27975857e-02f, 7.66863972e-02f, -2.68183332e-02f,
  -6.59657121e-02f, 1.00003937e-02f, 2.35377508e-03f, -1.68121699e-02f, 1.00203000e-01f, -2.26011593e-02f, 9.72442999e-02f, 2.15618871e-02f, -9.20730308e-02f, -1.38126329e-01f,
  1.83050206e-03f, 1.75224438e-01f, -1.95550293e-01f, -4.16307226e-02f, -5.52952774e-02f, 3.69260348e-02f, 9.69132502e-03f, -6.49970844e-02f, 1.18774146e-01f, -4.34109047e-02f,
  7.93257207e-02f, -9.81744975e-02f, 4.12379391e-02f, -1.34448763e-02f, -1.36248041e-02f, -2.27152021e-03f, 6.31041080e-02f, -6.48239553e-02f, 1.04355574e-01f, 2.02207819e-01f,
  1.06647499e-01f, -1.39275223e-01f, -2.26159334e-01f, -3.35674249e-02f, -1.28227323e-01f, -1.69475362e-01f, -1.35564655e-01f, -8.45185444e-02f, -6.13795146e-02f, -3.10680151e-01f,
  -6.49686038e-01f, 2.47324049e-01f, 1.44153953e-01f, -1.07581146e-01f, 6.66417852e-02f, -5.75833768e-02f, -5.87011799e-02f, -7.48518482e-02f, -8.65371525e-03f, 7.46798292e-02f,
  1.31001025e-01f, -1.59850836e-01f, -1.38476342e-01f, -1.45917341e-01f, -3.88043195e-01f, -1.62043169e-01f, -1.49244651e-01f, -4.26794976e-01f, -5.32010376e-01f, -3.63657415e-01f,
  -1.76690683e-01f, -3.92098814e-01f, -4.54807967e-01f, -1.52441278e-01f, 1.88040048e-01f, -2.12091014e-01f, 1.68080479e-02f, -1.62301123e-01f, -2.01200143e-01f, -1.33489311e-01f,
  2.22387105e-01f, 4.20069546e-02f, -8.06192681e-02f, -1.27497032e-01f, 7.32261315e-02f, 3.26213576e-02f, -1.22289836e-01f, 8.71259943e-02f, 1.20826468e-01f, -5.49429003e-03f,
  -7.08813518e-02f, 4.46042307e-02f, -1.35829384e-02f, 7.75899366e-02f, 5.78260943e-02f, 7.22884610e-02f, 1.36217713e-01f, -8.88819322e-02f, 8.43260810e-03f, 4.59890440e-02f,
  9.55038443e-02f, 7.26494044e-02f, 9.74916890e-02f, -3.60118523e-02f, -1.01394862e-01f, -1.56679943e-01f, 7.03171035e-03f, -6.71671852e-02f, -1.00552984e-01f, 3.11147291e-02f,
  -1.06498323e-01f, -5.76105304e-02f, -5.67411147e-02f, 1.10656563e-02f, 2.89483406e-02f, -3.36939543e-02f, 4.13024351e-02f, 1.03686722e-02f, -4.82544452e-02f, 7.16471253e-03f,
  1.21764436e-01f, -1.24493577e-02f, -4.28351574e-02f, 2.66527683e-02f, 3.54448333e-02f, -5.06790467e-02f, -8.67810324e-02f, 5.08579202e-02f, 5.85996769e-02f, 6.37127012e-02f,
  4.02896181e-02f, 4.28137556e-02f, 1.48737682e-02f, 5.32175191e-02f, 1.54611826e-01f, 1.71384797e-01f, 1.15554020e-01f, 1.01021327e-01f, -3.84415351e-02f, 1.12671047e-01f,
  1.00714773e-01f, -1.02373801e-01f, 5.14302440e-02f, -2.13058498e-02f, 1.11732066e-01f, 1.48738340e-01f, 1.77652523e-01f, 1.07710131e-01f, 3.85008194e-02f, 4.38088141e-02f,
  1.45830289e-01f, -1.05511788e-02f, 1.52639672e-01f, 1.15449645e-01f, 7.29343668e-03f, 2.73348857e-02f, 4.17845547e-02f, 4.31423411e-02f, 6.20935336e-02f, 2.21100822e-01f,
  1.99566796e-01f, -7.19478577e-02f, -9.81888324e-02f, -2.38174782e-03f, -2.32013650e-02f, -4.09401357e-02f, 9.00890231e-02f, 1.45605832e-01f, 4.43237163e-02f, 1.03523202e-01f,
  5.53086042e-01f, 1.16499893e-01f, -1.34648249e-01f, 1.96400493e-01f, 6.66816384e-02f, -1.85369104e-01f, -1.16743572e-01f, -9.79354307e-02f, 1.55366091e-02f, 2.22431690e-01f,
  2.28224620e-01f, 2.92946547e-01f, 2.99562365e-01f, 6.94074035e-02f, 1.65681969e-02f, -4.85241637e-02f, -1.01820834e-01f, 1.27786119e-03f, 1.34989947e-01f, 2.77113877e-02f,
  1.45750642e-01f, 1.18517149e-02f, 1.04894154e-01f, -2.57401373e-02f, -2.90536974e-02f, 2.09085885e-02f, -4.79711555e-02f, 9.34875757e-02f, 1.32876500e-01f, 8.15566406e-02f,
  4.50721443e-01f, 1.35619845e-02f, -1.03978343e-01f, 1.07421458e-01f, -1.14682518e-01f, -1.30981833e-01f, -1.30984798e-01f, -1.98662683e-01f, -2.88707335e-02f, -3.35927494e-02f,
  -4.07090858e-02f, -6.71643391e-02f, -2.74494756e-02f, -1.68655246e-01f, -5.99396303e-02f, 4.05735895e-02f, -1.03798375e-01f, -6.82952106e-02f, -9.42944288e-02f, -6.43408857e-03f,
  7.47862831e-02f, 3.12137138e-02f, -9.46594519e-04f, -1.50341555e-01f, -6.28013238e-02f, 8.29994157e-02f, -3.74074839e-02f, 5.89262508e-03f, -9.56983194e-02f, -5.89938574e-02f,
  5.47946393e-02f, 1.63960099e-01f, 1.54499948e-01f, 2.18496341e-02f, 6.15840070e-02f, -3.36682759e-02f, 5.18468507e-02f, 5.36592081e-02f, 6.66589066e-02f, 2.12176796e-02f,
  -1.15866028e-02f, 2.09118694e-01f, 4.16405033e-03f, -1.42527942e-03f, 1.45901367e-01f, -7.12741539e-03f, -5.62171713e-02f, 5.97312152e-02f, -2.59099025e-02f, -5.59837036e-02f,
  1.53688550e-01f, -7.04903305e-02f, 6.18789084e-02f, -7.00565502e-02f, -7.13507161e-02f, 7.31886402e-02f, -4.85137552e-02f, 7.96486661e-02f, 1.82092413e-02f, -2.87942309e-02f,
  7.55014345e-02f, 1.83680691e-02f, 4.13984545e-02f, -1.30232289e-01f, -3.00249681e-02f, -5.44736087e-02f, -6.10805266e-02f, -2.05650583e-01f, -1.17677510e-01f, -1.10351682e-01f,
  -1.47630961e-03f, -6.01349995e-02f, -9.69172567e-02f, -2.09226876e-01f, -1.43642545e-01f, 4.90664644e-03f, -3.99313755e-02f, -4.57307324e-02f, -3.62880640e-02f, -6.26025768e-03f,
  8.10873043e-03f, -1.47722168e-02f, 5.14405780e-02f, -1.06589444e-01f, -1.25395820e-01f, -1.70211680e-02f, -1.07743643e-01f, -4.28498685e-02f, -7.19293579e-03f, 7.62540661e-03f,
  6.33332670e-01f, -1.63770437e-01f, 2.55769581e-01f, -1.29056975e-01f, -3.58236253e-01f, -1.98289245e-01f, -2.19096079e-01f, 5.55124544e-02f, 7.39942193e-02f, -1.13105349e-01f,
  -2.58141279e-01f, -6.30326848e-03f, 4.20518927e-02f, 1.39217183e-01f, 2.52113461e-01f, 1.52077347e-01f, 1.03359677e-01f, 3.22558254e-01f, 3.62661839e-01f, 1.89018384e-01f,
  -8.65757763e-02f, 1.29460916e-01f, 2.80410051e-01f, 2.35905021e-01f, -9.21263099e-02f, 4.25024182e-02f, 6.18038420e-03f, -1.30072713e-01f, -2.01295409e-03f, 2.32583746e-01f,
  1.01462796e-01f, 1.40902877e-01f, 8.25031251e-02f, -5.37002785e-03f, -1.23421419e-02f, 2.17766702e-01f, 1.02531658e-02f, 1.57612979e-01f, -1.13022193e-01f, 6.09082635e-03f,
  -1.45949900e-01f, 5.31088486e-02f, -9.59011689e-02f, 1.91213861e-02f, -5.80446869e-02f, -6.30415753e-02f, 1.42437696e-01f, 2.14533105e-01f, 1.15873419e-01f, 2.89606322e-02f,
  -1.95559219e-01f, -2.22278550e-01f, -4.97255363e-02f, -3.79348285e-02f, 3.00937332e-02f, -1.53135592e-02f, -7.05687329e-02f, -5.51722497e-02f, 1.12848304e-01f, 1.80830017e-01f,
  -7.49480678e-03f, -1.93590224e-02f, -4.15789969e-02f, -5.47282211e-02f, -7.40110455e-03f, 5.08093014e-02f, -3.94714512e-02f, -1.12486430e-01f, 7.89884850e-02f, 7.34176263e-02f,
  -1.95902735e-02f, -3.57090347e-02f, 8.12385008e-02f, 1.82217509e-02f, 1.12339966e-01f, -1.52244985e-01f, -1.10314354e-01f, -5.97109552e-03f, 4.73472327e-02f, 1.86565500e-02f,
  -1.31091336e-03f, 1.62022579e-02f, 2.42717434e-02f, 8.68974179e-02f, -1.62171945e-02f, -2.76279468e-02f, 8.35841298e-02f, 2.92948019e-02f, -1.19218700e-01f, -1.00132398e-01f,
  -3.53125393e-01f, -2.80754287e-02f, 1.97476938e-01f, 1.21043876e-01f, -7.92622045e-02f, 9.72704142e-02f, -6.09552898e-02f, 2.43680011e-02f, -1.56343326e-01f, 6.28634095e-02f,
  -7.87178650e-02f, 8.33263174e-02f, -8.21112394e-02f, 3.31005044e-02f, 7.94199333e-02f, -1.59665346e-01f, -4.30053733e-02f, -4.82458510e-02f, -1.32405683e-01f, -1.02061346e-01f,
  -1.17849857e-01f, -1.79305792e-01f, -5.14251515e-02f, -1.35802358e-01f, -2.73759365e-02f, -9.85261798e-02f, 1.29143451e-03f, -1.28884748e-01f, -3.11081465e-02f, -4.70363311e-02f,
  -8.17426324e-01f, 1.40922680e-01f, 3.39202613e-01f, -4.86697674e-01f, -5.66184260e-02f, 1.37179047e-01f, 2.76858985e-01f, -1.02310583e-01f, -4.77973223e-01f, 2.16415226e-01f,
  1.51425198e-01f, -3.66838813e-01f, -1.47743672e-01f, -6.57199621e-02f, -4.08311263e-02f, 4.74389195e-01f, 8.32587406e-02f, -1.55633956e-01f, -3.40536147e-01f, -2.92649150e-01f,
  -1.06509767e-01f, -4.67764229e-01f, -4.51416820e-01f, -3.40023428e-01f, -5.91793917e-02f, -2.05326527e-01f, -2.18764711e-02f, -1.47657260e-01f, 9.75875184e-02f, -1.07103884e-01f,
  5.15860915e-01f, -1.46481320e-01f, -4.46185544e-02f, -2.60890305e-01f, -6.03185445e-02f, -2.21120358e-01f, 5.94388582e-02f, -2.49278516e-01f, -3.47075760e-02f, -4.90340590e-02f,
  -1.65108100e-01f, -2.10898057e-01f, -1.73347637e-01f, -6.53292462e-02f, -4.67525190e-03f, -7.98801780e-02f, -1.88890740e-01f, -1.46140635e-01f, -7.05864578e-02f, 1.49067238e-01f,
  1.07975930e-01f, 1.04915455e-01f, 1.11060992e-01f, 1.32164687e-01f, -7.99212828e-02f, -1.34718008e-02f, 1.85553312e-01f, -4.95505184e-02f, -3.87001112e-02f, 4.23700213e-02f,
  6.35811687e-03f, 1.08461604e-01f, -4.52181585e-02f, -4.98574898e-02f, 6.75665736e-02f, 9.73383859e-02f, -4.77302913e-03f, 9.31948200e-02f, -3.19009759e-02f, -9.38788652e-02f,
  -3.39391045e-02f, 8.71240124e-02f, -1.03042454e-01f, -1.15141332e-01f, -4.27934453e-02f, -9.14162025e-02f, -3.13135795e-02f, -9.83984619e-02f, -5.32913506e-02f, -5.31218238e-02f,
  -1.83478862e-01f, 3.36796115e-03f, -1.65405404e-02f, -8.78995359e-02f, -2.37331484e-02f, -1.12433985e-01f, -4.87219021e-02f, -1.58065185e-01f, -9.48883146e-02f, -8.39162990e-02f,
  7.81207904e-02f, -1.18341215e-01f, 2.69864589e-01f, -1.07379407e-01f, -1.16923481e-01f, -1.22432701e-01f, -1.62118539e-01f, -2.20463678e-01f, 5.48611162e-03f, 4.69614007e-02f,
  -5.53929694e-02f, -4.20108326e-02f, 9.72244740e-02f, 3.43508199e-02f, -4.01018523e-02f, -1.23314187e-02f, 7.89072663e-02f, 2.25112084e-02f, 7.63608217e-02f, 2.58317977e-01f,
  1.63957447e-01f, 7.44067803e-02f, 2.06857726e-01f, 1.70108110e-01f, 3.40814777e-02f, 3.53350192e-02f, 2.92834163e-01f, 9.70870256e-02f, 1.06449731e-01f, 1.00117564e-01f,
  5.24696112e-01f, -1.60660669e-01f, -1.80987030e-01f, 1.21704347e-01f, -2.94208396e-02f, -2.51724303e-01f, -2.81513512e-01f, -8.24786723e-03f, 9.82499942e-02f, 4.38079089e-02f,
  3.70291248e-02f, 1.45373754e-02f, -3.68081182e-02f, 5.63759133e-02f, 9.23497528e-02f, -1.81159198e-01f, -5.32553270e-02f, 5.21547906e-02f, 6.93464801e-02f, 1.38640888e-02f,
  -4.12722826e-02f, 3.39797735e-02f, 1.22634411e-01f, 2.12116260e-02f, -1.07597254e-01f, -1.20207970e-03f, -8.51770788e-02f, -1.59642786e-01f, -1.92612663e-01f, -8.64105299e-02f,
  -2.66408533e-01f, -3.53099704e-02f, 6.51877597e-02f, 1.62513882e-01f, 5.90839200e-02f, 3.65771540e-02f, 1.41878694e-01f, 5.15792146e-02f, 6.27773553e-02f, -7.30131119e-02f,
  7.09341392e-02f, -8.17433372e-03f, 9.59904492e-02f, -1.11368664e-01f, -5.69217540e-02f, 9.73210037e-02f, -2.06622723e-02f, 2.50459593e-02f, -1.38535395e-01f, -1.20586678e-01f,
  -4.75252829e-02f, -1.29549392e-02f, -1.48764253e-01f, 4.47359681e-02f, -3.35441977e-02f, 4.51730005e-02f, -4.61611226e-02f, -4.93552350e-03f, 8.77114385e-02f, 1.58629455e-02f,
  -5.40115051e-02f, 8.55885819e-02f, 5.80505505e-02f, -7.56268799e-02f, 1.03954272e-02f, 1.58794690e-02f, -8.87307823e-02f, 3.72439921e-02f, 1.45190254e-01f, 1.74203157e-01f,
  -9.76499766e-02f, -8.97683799e-02f, -5.12824394e-02f, 8.38547014e-03f, 1.51200444e-01f, -4.31654043e-02f, -1.13601219e-02f, -6.04248010e-02f, -3.02964021e-02f, -5.33960536e-02f,
  1.01879284e-01f, 3.91744589e-03f, 1.49065247e-02f, -4.38271426e-02f, -1.12809367e-01f, -1.32957056e-01f, 6.91465065e-02f, -5.07567972e-02f, 7.43527189e-02f, 2.23520789e-02f,
  -2.73548424e-01f, 8.16137493e-02f, 9.93724838e-02f, 6.01202063e-02f, 7.81155527e-02f, 1.21286914e-01f, 8.50530118e-02f, 9.25333947e-02f, 2.07124017e-02f, -9.82289389e-02f,
  6.57458082e-02f, 1.16487026e-01f, 3.84748764e-02f, 1.16753597e-02f, 1.86354205e-01f, 8.50148201e-02f, 9.15189758e-02f, 9.50247347e-02f, -1.51208322e-02f, -1.05336323e-01f,
  5.45829572e-02f, -2.05152351e-02f, -3.56720462e-02f, 3.68744768e-02f, 9.09368023e-02f, 9.48164389e-02f, 6.30948767e-02f, 9.07134712e-02f, 1.11633323e-01f, 1.95915669e-01f,
  5.59469163e-01f, -4.06809092e-01f, 1.63803045e-02f, 3.31641257e-01f, 3.02128643e-01f, 3.00067127e-01f, -5.72917797e-03f, 1.74232930e-01f, 2.62060225e-01f, 6.43142015e-02f,
  -1.34212956e-01f, 2.06851820e-03f, 5.65818734e-02f, -1.39641404e-01f, -6.80820793e-02f, -1.88940123e-01f, -1.46417096e-01f, -6.14390522e-02f, 2.00904861e-01f, -5.66495908e-03f,
  -1.00578979e-01f, -2.59919930e-02f, -1.04399309e-01f, -1.06705278e-01f, -1.56162590e-01f, 1.55416047e-02f, -1.34269297e-01f, -9.64914635e-02f, -2.79786110e-01f, -3.48702699e-01f,
  1.20189033e-01f, -1.44290715e-01f, 2.95019690e-02f, -1.08387895e-01f, -1.73070021e-02f, 2.87485812e-02f, 4.96874712e-02f, -6.59797154e-03f, 6.94735721e-02f, -3.08853425e-02f,
  -1.10618606e-01f, -2.47392226e-02f, 1.58729814e-02f, 4.22529168e-02f, 1.13159195e-01f, 9.12506282e-02f, 1.45212933e-03f, -6.42291009e-02f, -1.49817094e-01f, -1.24153912e-01f,
  -1.73575461e-01f, -2.51069125e-02f, 9.88802016e-02f, -4.65871487e-03f, -9.84290242e-02f, 2.55615450e-02f, -7.34795257e-02f, 9.96184722e-02f, 1.11285448e-01f, 1.41906410e-01f,
  -4.98339608e-02f, 1.88135862e-01f, 3.17011471e-03f, 6.87057525e-02f, 1.08007625e-01f, 4.41246107e-02f, 5.93772009e-02f, 6.22565560e-02f, 7.58592188e-02f, 3.93090025e-02f,
  5.14782779e-02f, 5.00815287e-02f, 3.79433477e-04f, 3.54355574e-02f, -4.92729396e-02f, -7.58332312e-02f, -1.58935823e-02f, -7.08537400e-02f, -8.70914906e-02f, -5.94235808e-02f,
  -6.37237430e-02f, -1.19252630e-01f, -7.98135325e-02f, -2.03682169e-01f, -1.44262478e-01f, -5.52722961e-02f, -1.08163565e-01f, -9.07682627e-02f, -5.18809520e-02f, -5.97484000e-02f,
  1.31908923e-01f, -2.06616938e-01f, 1.06288001e-01f, -1.52819961e-01f, -1.02818951e-01f, -3.44361439e-02f, 9.45038442e-03f, -9.75623652e-02f, 1.39331399e-02f, 5.56705780e-02f,
  -3.01872045e-02f, -4.38524932e-02f, -4.29938622e-02f, 1.49621796e-02f, 1.61548495e-01f, -2.22540256e-02f, -1.43354237e-01f, 6.52933270e-02f, -1.71194538e-01f, -1.55860752e-01f,
  -8.51447135e-02f, 1.61946416e-01f, 1.72745734e-01f, 1.42559826e-01f, 8.11959058e-02f, 1.98090613e-01f, 1.74989238e-01f, 6.02906384e-02f, 4.88912500e-02f, 1.64845213e-01f,
  -3.36384684e-01f, 2.65026152e-01f, -7.95298666e-02f, -1.02089092e-01f, -5.07564917e-02f, -1.01644143e-01f, -1.91392899e-02f, 3.87662463e-02f, 1.41446084e-01f, 3.68178844e-01f,
  -1.19500784e-02f, -4.41364646e-01f, -2.26241529e-01f, -3.48287344e-01f, -3.67803007e-01f, 1.57839537e-01f, -1.00990064e-01f, -3.88665676e-01f, -6.78395569e-01f, -5.26181757e-01f,
  -2.75912017e-01f, -2.35355869e-01f, -4.00268883e-01f, -2.37397581e-01f, 2.06909016e-01f, -1.07820325e-01f, 1.77148297e-01f, -3.41768302e-02f, -4.90611754e-02f, 1.01859681e-02f,
  1.16427183e-01f, 1.44675225e-01f, -1.41988724e-01f, -9.18358415e-02f, 2.08424330e-01f, 6.75303191e-02f, -8.13151821e-02f, 1.29420944e-02f, -1.49860159e-01f, 7.71762878e-02f,
  -1.72451064e-01f, 6.59676921e-03f, -2.40911707e-01f, -8.60598311e-02f, -5.45486845e-02f, -1.26596943e-01f, -8.08831081e-02f, -1.54077604e-01f, -7.19669163e-02f, -2.02294383e-02f,
  -1.17390007e-01f, -3.30098569e-01f, -1.71782136e-01f, 1.08618505e-01f, -7.41471872e-02f, -3.20725411e-01f, -5.47419582e-03f, -1.45767955e-02f, 8.42514932e-02f, 1.86808065e-01f,
  1.10022850e-01f, 7.60873733e-03f, -3.37394215e-02f, -2.97312848e-02f, 4.03463207e-02f, 5.44409268e-02f, 2.05397513e-02f, 6.92785298e-03f, -5.38693257e-02f, -3.91479917e-02f,
  6.21104054e-02f, 1.00524895e-01f, 2.76069455e-02f, 1.59485176e-01f, 5.56471618e-03f, -8.75656977e-02f, 2.25524288e-02f, 8.42198879e-02f, 4.05634455e-02f, 4.68882807e-02f,
  -1.53394546e-02f, -5.74701093e-03f, 2.41161138e-02f, 7.99171329e-02f, 5.19470386e-02f, 8.95198807e-02f, 4.98046428e-02f, 5.42433560e-02f, -1.28453061e-01f, -7.36753568e-02f,
  1.00801349e-01f, -2.23593712e-01f, 2.23206401e-01f, -5.21022566e-02f, 1.86120301e-01f, 4.35567684e-02f, -1.12673473e-02f, -3.14746648e-02f, -1.21647380e-02f, -5.91544493e-04f,
  -2.78973758e-01f, 6.72681630e-02f, 2.25879345e-02f, 1.09515665e-02f, -2.08623409e-01f, -9.29133743e-02f, 9.27083966e-05f, -1.43493742e-01f, -1.79698840e-01f, -3.71974185e-02f,
  2.11161375e-02f, -6.91918284e-02f, -6.91684857e-02f, 1.21516339e-01f, 2.28958335e-02f, -1.57780170e-01f, 3.04073207e-02f, 4.98424023e-02f, -1.25998661e-01f, 3.59029114e-01f,
  -7.80857742e-01f, -3.99530292e-01f, 4.89432514e-01f, -5.58005929e-01f, -4.94081751e-02f, -9.86839682e-02f, -5.29249430e-01f, -4.24543768e-01f, -8.90179276e-02f, -7.37338290e-02f,
  1.90298975e-01f, 2.83851594e-01f, 2.85789996e-01f, 1.87790945e-01f, -1.07769586e-01f, -4.25214460e-03f, 9.60306376e-02f, 1.59199387e-01f, -5.99271655e-02f, -2.96491712e-01f,
  -1.94946662e-01f, -2.09837511e-01f, -1.58287898e-01f, -1.67235479e-01f, -2.43741676e-01f, -8.01808164e-02f, 2.64162391e-01f, -1.34044826e-01f, 5.27124293e-03f, 3.70295672e-03f,
  -2.29763508e-01f, -2.66848564e-01f, 1.94747284e-01f, 2.30678305e-01f, 8.75930637e-02f, -2.66707912e-02f, -1.23863250e-01f, 4.41828780e-02f, -7.20559657e-02f, 7.80276060e-02f,
  -6.88544847e-03f, 5.68495430e-02f, -2.34749950e-02f, 7.90635198e-02f, -5.43511100e-02f, -4.85590175e-02f, 9.21926498e-02f, -1.60521287e-02f, 4.88212220e-02f, 1.80276588e-01f,
  -7.23335845e-03f, -8.81607234e-02f, -3.75218573e-03f, 9.12237689e-02f, -9.48903412e-02f, 1.26000598e-01f, -1.13841303e-01f, -2.14101136e-01f, -1.62827387e-01f, -4.75848466e-01f,
  -5.11676110e-02f, 1.00368850e-01f, 1.38199985e-01f, -6.30072802e-02f, -1.55619651e-01f, 1.45290896e-01f, 1.87984966e-02f, 8.18735454e-03f, 3.22167426e-02f, -1.12156784e-02f,
  1.02107160e-01f, 4.81790826e-02f, 7.29572712e-05f, -5.34209646e-02f, 1.39312491e-01f, -1.98593996e-02f, -2.03146562e-02f, -5.59582040e-02f, 6.87111914e-02f, 6.10414222e-02f,
  1.38225466e-01f, 2.90476419e-02f, 1.30773082e-01f, -4.81073186e-02f, 1.65990561e-01f, -5.44419698e-03f, -5.94506599e-02f, 3.60787027e-02f, -7.33552054e-02f, 8.02175328e-02f,
  -4.13447618e-01f, 4.19307530e-01f, -1.76525801e-01f, 9.43858400e-02f, -1.56979095e-02f, 2.33097672e-01f, -2.19881330e-02f, -4.36845459e-02f, -1.91354770e-02f, -7.33965188e-02f,
  -8.74907896e-02f, -1.80849731e-01f, 4.08846047e-03f, 1.34412363e-01f, -6.74646646e-02f, 9.78776887e-02f, 1.06491391e-02f, 8.62544701e-02f, 1.56942740e-01f, -5.00397058e-04f,
  1.62740007e-01f, -2.05969319e-01f, -3.80179137e-01f, -1.29844606e-01f, -2.29121223e-01f, -4.85177077e-02f, -3.14245820e-01f, -1.92458048e-01f, -1.27433077e-01f, -6.82959497e-01f,
  7.13458478e-01f, -4.55082767e-02f, -1.61962762e-01f, 2.34044015e-01f, -2.87514687e-01f, -1.19986691e-01f, -2.26916358e-01f, 4.44587432e-02f, 6.13913387e-02f, -2.53450517e-02f,
  -1.08229019e-01f, 3.93856578e-02f, 1.42481357e-01f, 4.90784533e-02f, 1.76943481e-01f, 1.36892512e-01f, 8.49114731e-02f, 2.27701619e-01f, 9.47636142e-02f, 5.46605326e-03f,
  6.00152165e-02f, 8.42394754e-02f, 1.86261654e-01f, 3.86088877e-03f, -1.82474717e-01f, -2.21779794e-02f, -2.18430206e-01f, -1.74114019e-01f, -1.07533336e-01f, 4.96219099e-02f,
  -2.62032360e-01f, -1.20056234e-01f, 6.16170391e-02f, 3.57155949e-02f, -8.83850008e-02f, 1.55524090e-01f, -6.83013862e-03f, 3.01317432e-05f, 6.25718683e-02f, -4.13519479e-02f,
  -1.56679660e-01f, -1.09154113e-01f, -1.27824441e-01f, -5.48861995e-02f, -3.92279774e-02f, -1.15148798e-01f, -7.19974041e-02f, -2.39510424e-02f, -3.39602283e-03f, 2.40668487e-02f,
  -7.99989477e-02f, -1.48139685e-01f, -6.29398972e-02f, 1.43441893e-02f, 7.04607144e-02f, -8.84441286e-02f, -1.61146030e-01f, -2.55044401e-02f, 5.24414703e-03f, 1.02221482e-01f,
  2.52966862e-02f, -1.01128243e-01f, -2.34045953e-01f, -1.42788842e-01f, -3.06819789e-02f, 3.91769446e-02f, -6.90780673e-03f, -7.13376924e-02f, -1.02148801e-01f, -1.68893576e-01f,
  -2.35769469e-02f, 7.15849921e-02f, 4.94728144e-03f, 1.09218387e-02f, 7.03828558e-02f, -1.78374052e-02f, -6.73290044e-02f, -8.02094042e-02f, -1.40452489e-01f, 5.37341312e-02f,
  -5.67797833e-05f, -7.84892067e-02f, -7.52372518e-02f, -8.74286219e-02f, -7.63026848e-02f, -4.37466949e-02f, 1.15903966e-01f, -5.64804561e-02f, -4.01303060e-02f, 5.87046444e-02f,
  5.73337777e-03f, -2.23972127e-02f, -1.49125047e-02f, 3.06238700e-02f, -1.72426000e-01f, -7.84190670e-02f, -5.45568764e-02f, 1.20492643e-02f, -2.48132665e-02f, 7.61399567e-02f,
  -1.75534829e-01f, -5.02084009e-02f, 1.94065776e-02f, -1.02709077e-01f, 3.78667302e-02f, 3.44623476e-02f, 3.33787575e-02f, 6.04045354e-02f, 5.90289570e-02f, -7.99620152e-02f,
  -3.53328735e-02f, 8.04793276e-03f, 1.23266421e-01f, -5.28092422e-02f, -3.82407419e-02f, 9.47352573e-02f, -2.88792960e-02f, 3.88416089e-02f, -2.99169831e-02f, 2.05427974e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  -1.07361510e-01f, 4.63259906e-01f, 5.66157222e-01f, 2.46335760e-01f, 2.73006737e-01f, 1.13358110e-01f, 2.75468647e-01f, 4.73864973e-01f, 2.42594853e-01f, 6.38436794e-01f,
  4.45156604e-01f, 4.11387920e-01f, 4.25040036e-01f, 2.49409810e-01f, 1.43602937e-01f, 1.23285651e-01f, 4.78520781e-01f, 3.30614895e-01f, 3.21387559e-01f, 2.92560309e-01f,
  3.87282968e-01f, 3.78133506e-01f, 2.85827696e-01f, 3.03991944e-01f, 5.91170609e-01f, 1.32478163e-01f, 4.29730654e-01f, 6.30969346e-01f, 7.40404189e-01f, 3.29764277e-01f,
  5.56371808e-01f, 3.13303351e-01f, 1.93432510e-01f, 4.56997842e-01f, 1.68903440e-01f, 5.01717567e-01f, 2.23225877e-01f, 4.81169254e-01f, 5.37493408e-01f, 4.92466986e-01f,
  3.01041305e-01f, 2.21739367e-01f, 3.79700899e-01f, 3.72032553e-01f, 3.31158549e-01f, 5.49474359e-01f, 4.51493800e-01f, 5.09917736e-01f, 4.48541939e-01f, 4.36117172e-01f,
  -7.50686566e-04f, 9.10894498e-02f, 2.37833247e-01f, 4.14961278e-01f, 2.38560587e-01f, 3.79238069e-01f, 4.59832102e-01f, 4.34641063e-01f, 5.01901805e-01f, 3.65369141e-01f,
  6.21944249e-01f, 6.70026183e-01f, -1.62695292e-02f, 3.82789195e-01f, 7.61644721e-01f, 4.37534004e-01f, 2.76375711e-01f, 1.54591173e-01f, 1.53124690e-01f, 2.68344194e-01f,
  3.37407678e-01f, 3.45591426e-01f, 2.79443920e-01f, 3.96965057e-01f, 3.61707330e-01f, 3.27901155e-01f, 2.36162081e-01f, 1.85371771e-01f, 3.26441705e-01f, 3.44925761e-01f,
  5.57472765e-01f, 2.69101858e-01f, 2.07045376e-01f, 3.06671232e-01f, 1.18630320e-01f, 4.99504328e-01f, 5.81545234e-01f, 3.39051813e-01f, 3.14006776e-01f, 4.01104033e-01f,
  4.93994355e-01f, 1.45969361e-01f, 3.31725299e-01f, 9.49920714e-02f, 2.86291093e-01f, 4.53684032e-01f, 4.71387237e-01f, 4.42897320e-01f, 4.06403601e-01f, 3.57209027e-01f,
  5.71826696e-01f, 2.90094107e-01f, 5.19302905e-01f, 6.17142975e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.23593971e-01f, -4.51530404e-02f, -5.54884076e-02f, -1.50943607e-01f, -1.43902808e-01f, -7.58112893e-02f, -1.55328125e-01f, -1.43561110e-01f, -1.24535397e-01f, -4.87298742e-02f,
  -1.51811719e-01f, -1.52534410e-01f, -2.04259008e-01f, -2.28231207e-01f, 1.75151780e-01f, 6.48220405e-02f, 2.53519118e-02f, 1.56665877e-01f, 1.17839143e-01f, 2.47035950e-01f,
  -1.62557125e-01f, -9.27598402e-02f, -8.12557563e-02f, -9.25395116e-02f, 5.74479476e-02f, 2.60561015e-02f, -2.10148409e-01f, -3.07604551e-01f, -6.40821517e-01f, 5.00530124e-01f,
  -6.81604743e-02f, 2.80884445e-01f, 1.56974524e-01f, -4.04492319e-01f, -1.13029331e-01f, -1.27077028e-01f, -1.61444157e-01f, -4.29316126e-02f, 1.11861296e-01f, 1.05507985e-01f,
  1.35963291e-01f, 2.93545872e-02f, -1.39055178e-01f, -1.12756521e-01f, -1.35766104e-01f, 2.13498235e-01f, -5.05451299e-03f, -3.63404304e-01f, -1.67180195e-01f, -3.65700960e-01f,
  -1.22119576e-01f, 1.08469680e-01f, -4.31907266e-01f, -2.56140321e-01f, 1.15976267e-01f, 2.74798484e-03f, 1.86364055e-01f, -5.99216878e-01f, 2.88191617e-01f, -2.11604059e-01f,
  2.35894546e-01f, -2.15406597e-01f, -1.70075685e-01f, -1.58954069e-01f, -3.75526547e-02f, -3.57067019e-01f, -4.20304060e-01f, -5.98018825e-01f, 2.72841305e-01f, -6.00704432e-01f,
  -5.20887077e-01f, -1.18179992e-01f, -9.39454418e-03f, -9.28095132e-02f, 4.94857579e-01f, -4.31296155e-02f, -1.35865346e-01f, -7.87996833e-05f, 9.45794880e-02f, 1.28022283e-01f,
  -2.13364094e-01f, -1.72444895e-01f, -1.11825190e-01f, 2.45468840e-01f, 2.94214755e-01f, -6.20828345e-02f, 5.64086735e-01f, -2.15039346e-02f, -9.15316045e-02f, -6.19128160e-02f,
  -1.66187152e-01f, 4.85944629e-01f, 1.16969235e-01f, 3.49382695e-04f, 1.33847684e-01f, 1.21669145e-02f, 3.31715345e-02f, 5.39611802e-02f, -2.52908975e-01f, -2.79140711e-01f,
  -5.55810034e-02f, -6.30288646e-02f, -2.20402293e-02f, -1.30271032e-01f, 7.15075433e-03f, 4.84842867e-01f, 1.04318857e-01f, -1.09605312e-01f, 2.25114673e-01f, -6.02581024e-01f,
  1.69578373e-01f, -1.94966137e-01f, -3.03964559e-02f, -1.18963774e-02f, -1.47594318e-01f, 3.42666805e-01f, -3.97105336e-01f, -4.40586777e-03f, 1.19652808e-01f, 9.31211486e-02f,
  -1.46329388e-01f, -1.10903710e-01f, -5.01156807e-01f, 9.54542588e-03f, 8.21515918e-02f, -1.75404906e-01f, -1.78294644e-01f, -1.90673694e-01f, 8.29721764e-02f, 1.00970186e-01f,
  -1.30663916e-01f, 2.99887243e-03f, 5.34252562e-02f, 8.84313732e-02f, -4.80364673e-02f, 1.72049969e-01f, 8.32427070e-02f, 8.68257955e-02f, 1.71059910e-02f, -7.56810308e-02f,
  1.63394418e-02f, 1.04379117e-01f, -1.46332219e-01f, -1.98374852e-03f, 1.65241174e-02f, 1.38777241e-01f, -3.36355641e-02f, -3.34313586e-02f, 1.74753264e-01f, -1.40529692e-01f,
  2.11734191e-01f, 2.73380458e-01f, -1.16900861e-01f, -6.36929631e-01f, -3.44629765e-01f, -1.05749056e-01f, -6.05237894e-02f, -1.85936511e-01f, -1.98921427e-01f, -1.17209382e-01f,
  -3.25691372e-01f, -5.43127060e-01f, 1.90446317e-01f, -1.90487072e-01f, -7.03012198e-02f, -1.57102361e-01f, -6.67319894e-01f, 2.07004622e-01f, -1.70784548e-01f, -1.45770654e-01f,
  -4.32529688e-01f, 1.70655221e-01f, 2.58819431e-01f, 3.62075686e-01f, 1.53810844e-01f, -2.08428726e-01f, 2.81710804e-01f, -1.15865611e-01f, 2.19289571e-01f, -1.39001518e-01f,
  -6.62128747e-01f, 2.20189661e-01f, -6.78328335e-01f, -5.23799241e-01f, 2.12989733e-01f, -7.19346166e-01f, 6.74173892e-01f, -6.88677192e-01f, -5.25211453e-01f, -3.23599577e-01f,
  1.76336452e-01f, -2.15620682e-01f, -6.18708193e-01f, 5.71862496e-02f, 3.64935696e-02f, 1.69641301e-02f, 1.77855566e-01f, -2.86988199e-01f, -1.16393961e-01f, 2.18392670e-01f,
  -2.58801520e-01f, -2.59463489e-01f, -4.02605981e-01f, -2.34883055e-01f, -4.87653650e-02f, 1.06165260e-01f, 5.35332449e-02f, 1.63796976e-01f, -1.75830334e-01f, -9.43932116e-01f,
  1.05594382e-01f, 9.62518230e-02f, 3.15983146e-01f, 1.54306844e-01f, -2.04097405e-02f, 7.81745091e-02f, -6.60397053e-01f, -7.85200819e-02f, -1.82623371e-01f, -9.28893760e-02f,
  4.46694672e-01f, -6.00102723e-01f, 2.27260545e-01f, -5.63682318e-02f, -5.71704097e-02f, -5.68689048e-01f, 2.89138947e-02f, 2.43453339e-01f, -1.56881571e-01f, 6.04698285e-02f,
  5.57038784e-01f, -3.80810350e-01f, 2.64287680e-01f, 3.06453437e-01f, 8.99655595e-02f, -4.98958081e-02f, 3.44149768e-01f, 1.35084182e-01f, 5.74255824e-01f, -1.50924459e-01f,
  -1.14913337e-01f, 2.04327151e-01f, -1.45126268e-01f, 1.86900020e-01f, -5.40125608e-01f, -5.53834677e-01f, -1.92342579e-01f, -2.86248118e-01f, 3.27316701e-01f, 2.95097530e-01f,
  -4.17179257e-01f, 1.03512459e-01f, 9.78048369e-02f, -5.10719180e-01f, -6.44610897e-02f, 2.61161566e-01f, 3.54882069e-02f, -5.70689216e-02f, 4.89583313e-02f, 1.19306669e-01f,
  2.86422521e-02f, 1.08306147e-01f, 1.41967669e-01f, -4.22328850e-03f, 1.03819102e-01f, 8.81301891e-03f, 2.09782466e-01f, 2.03223884e-01f, 1.55320451e-01f, 2.31614441e-01f,
  2.20169961e-01f, 6.92419782e-02f, 3.04922257e-02f, 2.58457512e-01f, -1.47268325e-02f, -9.81376618e-02f, -1.37827724e-01f, -1.00373521e-01f, -1.73898220e-01f, 4.60074246e-02f,
  8.91547278e-02f, -1.28520401e-02f, -3.39259982e-01f, -3.80344242e-01f, 1.63159430e-01f, -3.19098175e-01f, 3.46553296e-01f, -3.03660840e-01f, 2.63418615e-01f, -9.66653526e-02f,
  -1.63306981e-01f, -4.17276591e-01f, -1.63839951e-01f, 2.39581734e-01f, 6.37435867e-03f, -2.84375697e-01f, -3.41440678e-01f, 3.60352278e-01f, -2.55543619e-01f, 1.46442369e-01f,
  7.95415044e-02f, 4.90839392e-01f, -1.36538416e-01f, -3.75470370e-01f, 1.93910465e-01f, -2.56168991e-01f, -1.06416069e-01f, 5.51402383e-02f, 9.65429172e-02f, -9.09004435e-02f,
  4.74049091e-01f, -3.81519258e-01f, 1.31199837e-01f, -1.54883210e-02f, 3.09327811e-01f, 3.61637443e-01f, 3.85467976e-01f, -4.71095502e-01f, 1.02834530e-01f, 2.17977479e-01f,
  -6.39104769e-02f, -4.07255679e-01f, -1.23942673e-01f, 3.62223417e-01f, -2.81298608e-01f, -3.40239942e-01f, -1.64298743e-01f, -9.17409286e-02f, -2.52815515e-01f, -2.47340739e-01f,
  -3.30041409e-01f, 4.26565893e-02f, -9.55047831e-02f, -6.93674479e-03f, 6.27331585e-02f, -1.44951150e-01f, 1.01519160e-01f, -3.19545805e-01f, 1.18190721e-01f, -1.63645998e-01f,
  -3.77665728e-01f, 4.67156649e-01f, 1.30817130e-01f, -2.41110489e-01f, 1.44314513e-01f, 1.29358172e-01f, -1.04975298e-01f, -1.99558333e-01f, -4.63601917e-01f, -2.96148568e-01f,
  -6.19632490e-02f, -7.34868199e-02f, -3.93479586e-01f, -4.83825654e-01f, -6.85523497e-03f, -1.88162148e-01f, 4.21449006e-01f, 4.88234609e-02f, 2.41763398e-01f, -1.41469657e-01f,
  -4.42765325e-01f, 3.67934912e-01f, 1.37281671e-01f, 2.52915621e-01f, -2.22028971e-01f, -3.15300733e-01f, 2.71937281e-01f, 6.38108552e-02f, -1.36665002e-01f, -4.31388617e-02f,
  -3.95368338e-01f, -8.02377015e-02f, 6.79649487e-02f, -1.70501575e-01f, -5.99033013e-02f, -1.54169276e-01f, -2.59982824e-01f, 2.63923019e-01f, -1.90825567e-01f, 8.02269801e-02f,
  -1.07852831e-01f, -3.91287386e-01f, 5.94110072e-01f, 2.15091277e-02f, -3.84837575e-02f, -1.74094290e-01f, -9.09867585e-02f, 8.67335647e-02f, 1.32086186e-03f, -1.21836677e-01f,
  -3.87916975e-02f, 1.57805160e-02f, 3.31248506e-04f, -4.94080409e-02f, 4.26218612e-03f, -4.70992401e-02f, 1.36217311e-01f, -5.55957928e-02f, 3.01271200e-01f, -1.83480486e-01f,
  1.41460061e-01f, 3.13014656e-01f, -6.74125478e-02f, 1.45622745e-01f, 1.89464524e-01f, 2.19633475e-01f, -1.18921682e-01f, -8.62410218e-02f, -2.58336216e-01f, -5.10449827e-01f,
  -2.90737659e-01f, 5.34924328e-01f, -3.69278908e-01f, -9.71675739e-02f, 8.52326825e-02f, -5.89851320e-01f, -1.37019768e-01f, 3.32169831e-01f, -1.50078997e-01f, -2.77327865e-01f,
  1.24178872e-01f, 8.99360329e-02f, 1.78845420e-01f, 9.83827636e-02f, -1.37133300e-01f, -1.39165269e-02f, 6.45905957e-02f, -4.22791392e-02f, -1.30841896e-01f, 9.18547809e-02f,
  -1.09422699e-01f, -1.61986068e-01f, -3.68326485e-01f, 5.62437296e-01f, -2.44131893e-01f, 4.74062920e-01f, 6.99545979e-01f, -3.06147426e-01f, -3.33345085e-01f, 1.29649714e-01f,
  2.06908345e-01f, 1.97363213e-01f, -7.22615793e-02f, -7.34833404e-02f, 1.73133224e-01f, -4.79731448e-02f, -1.45653978e-01f, -2.77052104e-01f, -5.15578270e-01f, -4.76587147e-01f,
  1.66616350e-01f, -9.25688371e-02f, 4.74538989e-02f, -4.13163930e-01f, 1.00258470e-01f, -5.75027764e-01f, 1.32157192e-01f, -5.31897917e-02f, 1.89564973e-01f, 1.23356044e-01f,
  -2.31912747e-01f, -9.39690843e-02f, -3.32941771e-01f, 4.50280420e-02f, -2.41152361e-01f, 3.61106634e-01f, -3.83251011e-01f, -5.34884989e-01f, -6.69719398e-01f, 3.97471935e-02f,
  3.37926656e-01f, 2.77635604e-01f, 5.29495776e-01f, -4.40245509e-01f, 6.69927523e-03f, 2.24233285e-01f, -1.92128316e-01f, 3.57627094e-01f, -1.68616846e-01f, 1.20234847e-01f,
  -9.10055544e-03f, -2.35205889e-01f, -4.32759017e-01f, -1.88116044e-01f, 7.67060220e-02f, -2.03569800e-01f, 8.83028731e-02f, -1.51206300e-01f, 3.16759646e-02f, -5.47841072e-01f,
  -2.23793879e-01f, -3.42022747e-01f, 1.31794680e-02f, -6.05870008e-01f, 6.66427016e-02f, 4.83734548e-01f, -4.01501298e-01f, -2.27400690e-01f, -1.74700543e-01f, 3.26601774e-01f,
  3.85178089e-01f, -3.92105311e-01f, 2.93033004e-01f, 1.51074752e-01f, -2.23066673e-01f, 7.93080702e-02f, 4.83550370e-01f, -2.76999027e-01f, -6.16124868e-01f, 1.53335199e-01f,
  4.65768784e-01f, -1.72240555e-01f, -3.12032282e-01f, -7.07973763e-02f, -5.45771793e-03f, 2.20319931e-03f, 1.22009581e-02f, -1.95375636e-01f, -1.43493772e-01f, -1.21548474e-02f,
  1.45374283e-01f, -2.02401374e-02f, -4.81091850e-02f, -1.60771996e-01f, 1.69816479e-01f, -1.85095891e-01f, 3.72215658e-02f, 3.44751298e-01f, 1.34980634e-01f, -3.05579733e-02f,
  -2.16298476e-01f, 8.41882173e-03f, -2.31371716e-01f, -1.93240479e-01f, -2.16198489e-01f, 1.29803360e-01f, 5.46358861e-02f, 1.66002735e-01f, -1.85197935e-01f, 1.17830694e-01f,
  1.49456277e-01f, -3.48038912e-01f, -3.61955047e-01f, -1.36729643e-01f, -2.41309881e-01f, -1.67918727e-01f, -1.52995765e-01f, 2.68373102e-01f, -1.36125267e-01f, 5.53814229e-03f,
  2.72527397e-01f, -2.07075238e-01f, -7.10775033e-02f, 2.77351439e-01f, 3.17659616e-01f, -7.40334764e-02f, -2.78673112e-01f, -7.79138058e-02f, -1.23856105e-01f, 2.92244732e-01f,
  1.19969910e-02f, -3.06025386e-01f, -2.02556074e-01f, -3.35502625e-01f, -1.34321019e-01f, 1.66705679e-02f, 1.66900039e-01f, 1.40466169e-01f, -2.41560116e-01f, 1.08484380e-01f,
  -2.43546851e-02f, 1.43693343e-01f, 1.02745146e-01f, 9.54056904e-02f, -1.47920012e-01f, -5.91249108e-01f, 8.45114365e-02f, 1.50089741e-01f, -1.19123325e-01f, 4.77883756e-01f,
  7.60592595e-02f, 1.31298319e-01f, -1.07533894e-01f, 3.63879770e-01f, -2.18466550e-01f, 3.33985001e-01f, -1.88173860e-01f, 1.43450387e-02f, -2.35705197e-01f, 5.53229079e-02f,
  -2.06533000e-02f, 2.44665250e-01f, -2.63576865e-01f, -1.53667763e-01f, -4.84084368e-01f, -7.62567595e-02f, -4.47752088e-01f, 5.26019931e-02f, -4.59305346e-01f, -3.53211612e-01f,
  -2.70812660e-01f, 1.15577213e-03f, 2.46441469e-01f, -3.37711722e-01f, 3.95792350e-02f, -1.37523964e-01f, -4.94141012e-01f, 2.29297996e-01f, -1.65181272e-02f, 3.50196749e-01f,
  1.68406874e-01f, 9.77002550e-04f, 1.10322364e-01f, 9.43702161e-02f, -1.94785416e-01f, 2.74795979e-01f, 1.17131449e-01f, -2.70809323e-01f, -3.36391665e-02f, -1.61292240e-01f,
  -2.12594688e-01f, 1.71345565e-02f, 2.74478830e-02f, -8.82920548e-02f, -1.10477423e-02f, 9.10866819e-03f, 7.03705475e-02f, -3.58300924e-01f, -1.07369579e-01f, 4.25494879e-01f,
  1.59897685e-01f, 4.89169925e-01f, -2.60705918e-01f, -2.41510406e-01f, -6.70928136e-02f, -1.22572094e-01f, -1.09100444e-02f, 3.76720756e-01f, 2.60651439e-01f, -2.65988022e-01f,
  8.04186761e-02f, 1.87360883e-01f, 1.70256466e-01f, 1.32480085e-01f, 4.25825864e-02f, 1.57931969e-02f, 1.72702327e-01f, 1.42129257e-01f, -1.31734805e-02f, 5.81270941e-02f,
  2.81963614e-04f, 1.35688484e-01f, 1.99063644e-02f, 2.21286878e-01f, -1.15738899e-01f, 7.69496188e-02f, -3.01092952e-01f, -5.15333772e-01f, 1.28707588e-01f, 1.90560848e-01f,
  1.89945698e-01f, -1.60765260e-01f, 4.23453860e-02f, -7.67106414e-02f, 1.05507575e-01f, 3.66754055e-01f, 2.45980397e-01f, -4.43755180e-01f, -7.88858086e-02f, 1.59095272e-01f,
  -1.94513947e-01f, 4.39553291e-01f, -2.04783708e-01f, -1.10516973e-01f, -1.51852086e-01f, 5.72574697e-02f, -3.94279733e-02f, -2.89636940e-01f, -3.34676713e-01f, 1.43080056e-02f,
  3.00520837e-01f, -3.38153988e-02f, 2.22949516e-02f, -1.18738182e-01f, 1.34915143e-01f, 3.85644324e-02f, -1.89420000e-01f, -6.92089140e-01f, -3.01628381e-01f, -2.85122335e-01f,
  9.43090543e-02f, -1.61129430e-01f, -4.99564976e-01f, -1.53772920e-01f, -5.06382048e-01f, 4.68994319e-01f, -2.67656147e-01f, 5.36860645e-01f, -4.35652643e-01f, 3.13226223e-01f,
  -2.71135718e-01f, 4.21078622e-01f, -5.04814088e-01f, 2.78310448e-01f, 5.00773668e-01f, 6.29881844e-02f, -2.18162034e-02f, -4.05463934e-01f, 1.66951269e-01f, 2.42227346e-01f,
  2.53976315e-01f, 3.65076959e-01f, 2.85347372e-01f, -4.89062965e-01f, -2.86730349e-01f, -7.11855653e-04f, -7.76350573e-02f, 1.92611992e-01f, -1.65505841e-01f, -2.12213770e-01f,
  1.79736882e-01f, 4.98455912e-01f, 9.09891054e-02f, 3.56328785e-01f, 4.89485621e-01f, 1.47529226e-02f, -2.46579602e-01f, -7.64457136e-02f, 4.40985635e-02f, 3.16260383e-03f,
  -1.07307278e-01f, -3.35679859e-01f, -4.54228818e-02f, 1.96181700e-01f, -9.05762389e-02f, 1.81260228e-01f, 4.38385040e-01f, 1.27956003e-01f, -3.95722799e-02f, -2.68100530e-01f,
  -5.14424741e-01f, 1.06210485e-01f, -3.12958926e-01f, -1.39909640e-01f, 2.80374944e-01f, -4.84194010e-01f, -9.71398950e-02f, -3.05993944e-01f, 1.85557142e-01f, -4.51061800e-02f,
  6.03340268e-02f, -4.24742043e-01f, 1.41036108e-01f, 3.31683084e-02f, 7.79283093e-03f, -1.77094623e-01f, -1.98460445e-01f, -1.07883207e-01f, -3.10239702e-01f, -2.91853175e-02f,
  8.97457749e-02f, -2.56564945e-01f, -5.80216125e-02f, 7.41603822e-02f, 7.48036429e-02f, 3.00537378e-01f, -6.59098327e-01f, 1.92849249e-01f, -3.99278430e-03f, 3.14395763e-02f,
  -4.70898077e-02f, -1.24800839e-01f, -2.49360606e-01f, -2.36186329e-02f, 4.80053062e-03f, -6.69855475e-02f, -2.80073937e-02f, -4.61642146e-02f, 5.30513152e-02f, -5.84911890e-02f,
  -1.05361760e-01f, 3.45601082e-01f, -1.70524478e-01f, 1.29977554e-01f, -1.84612229e-01f, -1.57996520e-01f, 2.19892681e-01f, -1.52319074e-01f, -1.86848968e-01f, 6.96942061e-02f,
  -2.67348260e-01f, -1.03265144e-01f, 9.43479165e-02f, 2.14506790e-01f, 2.74647862e-01f, -4.35853481e-01f, 2.64418367e-02f, -3.61771017e-01f, -1.46140724e-01f, -2.64957130e-01f,
  -2.65282959e-01f, -2.04981118e-01f, -4.72028293e-02f, -2.19395205e-01f, -4.06395078e-01f, -3.89787227e-01f, -3.16290468e-01f, -1.14684477e-01f, -1.30788848e-01f, 4.92642045e-01f,
  -3.54804248e-01f, -5.97948879e-02f, 1.26097947e-02f, -4.67053950e-01f, -1.10237867e-01f, 2.69742727e-01f, 4.04283583e-01f, -1.05603993e-01f, -3.16024758e-02f, -3.76010448e-01f,
  -3.45898837e-01f, -2.64892638e-01f, 1.88213050e-01f, -3.08115602e-01f, -8.33448246e-02f, 5.00999391e-01f, -3.46926361e-01f, 2.53706127e-01f, -4.07103360e-01f, -5.60157299e-01f,
  3.53272110e-02f, 4.21194613e-01f, -4.61277485e-01f, 1.91510916e-01f, 2.06160024e-02f, 1.81160733e-01f, -5.57186007e-01f, 3.13381553e-01f, -1.24939911e-01f, -8.20959583e-02f,
  -2.27697209e-01f, 4.40842032e-01f, -2.48863980e-01f, -2.11953837e-03f, 3.24190587e-01f, 4.00105566e-02f, -2.02642396e-01f, -5.72972059e-01f, 1.55054972e-01f, -3.15723360e-01f,
  -3.02228779e-01f, -3.39497149e-01f, -4.57657039e-01f, -4.37033266e-01f, -5.77119440e-02f, -1.84594870e-01f, 2.54089683e-01f, 1.26914363e-02f, 8.38111639e-02f, -6.53484106e-01f,
  -3.11523587e-01f, 6.52562141e-01f, 2.51473188e-01f, -5.94411552e-01f, -1.33436024e-01f, 2.71744907e-01f, -3.09402615e-01f, -1.64934084e-01f, -5.33285856e-01f, -8.02294165e-02f,
  -2.86273688e-01f, 6.43819645e-02f, -5.02324283e-01f, 2.82219976e-01f, 1.49095627e-02f, 2.74605751e-01f, -2.34568253e-01f, -5.25327146e-01f, -5.75158656e-01f, 3.13409120e-01f,
  5.69990054e-02f, 3.54169495e-02f, -5.19207343e-02f, -1.85626656e-01f, -4.55452472e-01f, -4.22687888e-01f, -3.17511499e-01f, -5.39902627e-01f, 2.06941850e-02f, 4.54430133e-01f,
  -2.39151344e-01f, 1.26353383e-01f, -3.04229021e-01f, -3.18687499e-01f, -4.86922503e-01f, 2.37986416e-01f, -6.49501011e-02f, -1.90903321e-01f, -2.44565070e-01f, -9.32838991e-02f,
  -2.03065917e-01f, 6.99560717e-02f, 9.50707048e-02f, -4.88052145e-02f, -1.31374732e-01f, -1.64965481e-01f, -1.26676276e-01f, -8.93892422e-02f, -7.98644647e-02f, -8.46426934e-02f,
  1.51759475e-01f, -3.44438195e-01f, 6.05570078e-02f, 1.92440767e-02f, 2.61245400e-01f, 1.20142780e-01f, 1.48065761e-01f, 1.91858158e-01f, 2.61443973e-01f, -2.12591708e-01f,
  6.86578155e-02f, -3.57979506e-01f, -6.41415194e-02f, 2.60687381e-01f, 1.68770432e-01f, -1.56065255e-01f, -3.05010498e-01f, -1.44380778e-01f, 3.25511068e-01f, 2.74564009e-02f,
  -2.65228208e-02f, -1.66415587e-01f, 3.67430031e-01f, -7.55744353e-02f, -1.78822637e-01f, -2.32584134e-01f, -2.89886892e-01f, -1.94336131e-01f, -2.67179757e-01f, -4.60369326e-02f,
  -3.98317367e-01f, -2.29986936e-01f, 2.80171055e-02f, -3.86772156e-02f, -2.63179123e-01f, 3.03046256e-01f, 3.86614539e-02f, -2.25406349e-01f, 3.27663660e-01f, 1.35642260e-01f,
  -2.33433411e-01f, -2.41243780e-01f, -3.15354168e-01f, 2.95501471e-01f, -5.70011996e-02f, -1.02835372e-01f, -1.80651844e-01f, 3.92224163e-01f, -6.74142316e-02f, -1.33093014e-01f,
  3.64855111e-01f, 1.39690295e-01f, -6.72835559e-02f, 6.41233549e-02f, -2.20984519e-01f, -6.84402585e-02f, -1.57010823e-01f, -3.24575305e-02f, 4.70354348e-01f, -4.53168094e-01f,
  5.71396127e-02f, 1.10173605e-01f, -4.37078387e-01f, -1.72999427e-01f, 1.16467200e-01f, -2.01379523e-01f, -2.35150710e-01f, 7.63987422e-01f, -1.59507096e-01f, -1.50850400e-01f,
  -4.92523253e-01f, -2.58433789e-01f, 1.86653957e-01f, -2.54382372e-01f, -4.66371864e-01f, -2.16635838e-01f, 2.03279257e-02f, 3.04032087e-01f, -1.12936668e-01f, 1.58908486e-01f,
  3.89983319e-02f, -2.36055523e-01f, -2.83104867e-01f, -1.09961554e-01f, 1.95323497e-01f, -2.49340191e-01f, 2.88997859e-01f, 2.46286783e-02f, -2.46786833e-01f, -2.49829099e-01f,
  -2.00027555e-01f, -3.84648919e-01f, -7.93084726e-02f, 1.68357223e-01f, -1.66931093e-01f, 1.03943162e-01f, -1.08668968e-01f, 1.93288043e-01f, -5.40231057e-02f, -2.22714603e-01f,
  1.55545399e-01f, -1.90126330e-01f, 4.13720936e-01f, 1.34112194e-01f, 1.26245111e-01f, -2.88550168e-01f, -2.93270588e-01f, -3.66461992e-01f, 2.62523979e-01f, -1.62301034e-01f,
  -2.91751534e-01f, -1.52603954e-01f, 6.88563064e-02f, -1.31505892e-01f, -8.36291015e-02f, -7.17253890e-03f, 1.08300604e-01f, -3.09182238e-02f, 4.47680280e-02f, 8.08793232e-02f,
  5.63799515e-02f, 1.17467172e-01f, 3.39290537e-02f, 2.40022317e-02f, 5.59346154e-02f, 1.77111223e-01f, -2.46139511e-01f, 9.98130217e-02f, 2.97326483e-02f, -2.09062174e-01f,
  1.56601340e-01f, 3.10943484e-01f, 2.76220798e-01f, -1.29437506e-01f, 4.42976803e-02f, 3.22606236e-01f, 2.30304301e-01f, 4.59598174e-04f, -1.48029566e-01f, -2.51092285e-01f,
  4.94696200e-01f, -3.19744796e-01f, 1.85265988e-01f, -3.07898521e-01f, 1.30143955e-01f, 4.30234641e-01f, 1.96524233e-01f, 5.66745400e-01f, -3.80455166e-01f, -7.81015381e-02f,
  9.08738002e-02f, 9.29000303e-02f, -3.05764049e-01f, -2.21190155e-01f, 2.73302734e-01f, -1.68323740e-01f, -4.34257388e-01f, -1.74161792e-01f, 1.38084099e-01f, -3.05317461e-01f,
  9.90263373e-02f, -2.78046697e-01f, -1.10707998e-01f, -1.29345477e-01f, -1.15909524e-01f, -1.06978513e-01f, 3.54808480e-01f, 3.92246246e-02f, 7.94199333e-02f, -3.93341184e-01f,
  -3.13083708e-01f, -2.43011564e-01f, -3.46902043e-01f, -2.84622163e-01f, -2.21409440e-01f, -5.29255688e-01f, 4.20159817e-01f, 7.63282254e-02f, 7.64984637e-02f, -3.18434626e-01f,
  1.83544457e-01f, -7.53689557e-02f, 1.40746310e-02f, -4.03087348e-01f, 5.32966144e-02f, -1.72876030e-01f, -2.97324240e-01f, -3.77348125e-01f, -3.11355114e-01f, -2.08013251e-01f,
  -4.47658673e-02f, -9.39176530e-02f, -2.06316695e-01f, -3.41726422e-01f, 3.49482983e-01f, 1.63993984e-01f, 3.95727664e-01f, 1.14338934e-01f, 7.97616169e-02f, -2.59845883e-01f,
  -3.50230515e-01f, 2.07603887e-01f, 4.40565377e-01f, 2.67560661e-01f, 3.36862989e-02f, -1.00668505e-01f, -3.78172129e-01f, -2.47354940e-01f, -2.38519266e-01f, -3.49974900e-01f,
  -2.41871834e-01f, -3.69502544e-01f, 1.68969989e-01f, 9.39772129e-02f, -1.45610958e-01f, -8.30972785e-05f, -1.83927700e-01f, -1.75961763e-01f, -4.23749983e-01f, -1.66794673e-01f,
  -1.67871803e-01f, -1.50251046e-01f, -2.77187824e-01f, 1.58806711e-01f, -7.77037978e-01f, -1.76867619e-01f, 4.26974427e-03f, -1.39525890e-01f, 5.17834425e-01f, 2.67657399e-01f,
  4.70150262e-02f, -1.58801824e-01f, -2.94864595e-01f, -2.31172010e-01f, -1.44677281e-01f, 7.28312954e-02f, -5.54212416e-03f, -6.29282966e-02f, 4.05600429e-01f, -2.15445355e-01f,
  -1.70263544e-01f, 7.54977837e-02f, 2.37824433e-02f, 1.09048583e-01f, 1.73148662e-02f, 7.39288405e-02f, 9.31377485e-02f, -1.30456910e-01f, 4.99502430e-03f, -5.97949848e-02f,
  -1.23644441e-01f, 5.02468608e-02f, 6.49327040e-02f, -1.17702462e-01f, 1.58135384e-01f, -1.57224342e-01f, -1.80595443e-01f, 2.37567484e-01f, -9.08713341e-02f, -2.15595707e-01f,
  1.33707421e-02f, 3.90554243e-03f, 2.17414442e-02f, 2.19074339e-02f, -2.62848616e-01f, -3.20714027e-01f, -1.27602249e-01f, 3.87901932e-01f, -4.80247945e-01f, -3.39355737e-01f,
  2.19441697e-01f, 6.77157417e-02f, 1.88393593e-01f, -2.36184239e-01f, 3.83995026e-01f, -2.87858725e-01f, -3.22358832e-02f, 4.41481739e-01f, -3.79400074e-01f, -1.99468821e-01f,
  1.58581343e-02f, -3.80049825e-01f, -3.23841125e-01f, -4.13625717e-01f, -4.03458206e-03f, 6.93676919e-02f, 2.13414028e-01f, -4.63666797e-01f, -2.74590179e-02f, 2.60590613e-01f,
  -3.54126483e-01f, 2.50273850e-02f, -1.51464820e-01f, -4.16748226e-01f, -3.25879693e-01f, -2.13800132e-01f, 1.32837415e-01f, -6.53418526e-02f, -3.75540882e-01f, -4.26072180e-01f,
  -2.67845273e-01f, 1.16526142e-01f, 2.60451615e-01f, 8.10429528e-02f, -1.88020200e-01f, 3.59229922e-01f, 3.55612129e-01f, -9.93222296e-02f, -1.79826319e-01f, -2.32035611e-02f,
  -4.38266337e-01f, 2.17077866e-01f, -1.34292364e-01f, -2.17261016e-01f, -5.34636497e-01f, 1.69285163e-01f, -3.85200739e-01f, 2.07282156e-01f, 3.11338633e-01f, -1.04771316e-01f,
  3.17751437e-01f, 4.68966663e-01f, 5.28871864e-02f, -5.33288598e-01f, 5.93498088e-02f, 6.22836314e-02f, -2.44670585e-01f, -6.44952059e-01f, -1.61457285e-01f, -1.86745524e-01f,
  -6.69970214e-01f, -4.51606899e-01f, -3.33073735e-01f, 1.77160144e-01f, -2.96375543e-01f, -3.59967440e-01f, 2.40414456e-01f, 5.47059476e-01f, -2.92660624e-01f, 7.73991048e-02f,
  -2.94503480e-01f, 2.57324457e-01f, 3.47432435e-01f, 8.47521201e-02f, -3.88152838e-01f, 4.59457904e-01f, 4.46006775e-01f, -2.39704773e-02f, -1.12770334e-01f, 1.26389563e-01f,
  -1.82341382e-01f, 4.97572392e-01f, -4.67633009e-01f, -3.58914912e-01f, -4.57077622e-02f, -3.89099330e-01f, -3.43903840e-01f, -3.24061424e-01f, -7.90291056e-02f, 5.72868645e-01f,
  -2.66630631e-02f, 1.43281385e-01f, 3.43039930e-01f, -3.13756198e-01f, -3.55323046e-01f, 4.86942455e-02f, -1.70479491e-01f, -2.25174114e-01f, 2.64517628e-02f, -1.34755045e-01f,
  6.79283589e-02f, 1.37013152e-01f, 1.18533820e-01f, 4.80573066e-02f, -3.35101970e-02f, 1.34639516e-01f, -3.50667313e-02f, 2.67762411e-02f, -7.35571384e-02f, 9.60036516e-02f,
  1.02034949e-01f, 9.58438739e-02f, -1.85283069e-02f, -6.72880467e-03f, 5.62288314e-02f, -8.52809325e-02f, 1.87147275e-01f, -2.19289199e-01f, -2.04726785e-01f, -2.31596187e-01f,
  1.15005568e-01f, 2.12789565e-01f, -9.79470760e-02f, 1.49777636e-01f, -3.03543895e-01f, -4.42441106e-01f, -3.14223886e-01f, -2.01173559e-01f, -1.74220279e-01f, 2.14887723e-01f,
  5.69849014e-02f, -2.42363140e-01f, -2.04410970e-01f, 2.61964679e-01f, -2.29284227e-01f, 2.04171672e-01f, 4.67112839e-01f, -4.13814723e-01f, -3.37783873e-01f, 2.96213418e-01f,
  3.34278382e-02f, -2.82896847e-01f, 3.20327759e-01f, -1.79610908e-01f, -2.11187705e-01f, -4.39175993e-01f, -6.20059520e-02f, -2.14529783e-01f, 4.63560611e-01f, -2.03863010e-01f,
  -2.81719774e-01f, 3.98815215e-01f, -4.37378079e-01f, -3.36610645e-01f, -3.65954995e-01f, -4.94046360e-01f, 7.62991980e-02f, -1.83897555e-01f, 2.61713192e-03f, -3.05917025e-01f,
  -2.92048782e-01f, 2.30136991e-01f, -2.49300852e-01f, -1.99577957e-01f, -2.70514667e-01f, -2.42032632e-01f, 3.41615915e-01f, -2.83040434e-01f, -4.60991114e-01f, -4.92047193e-03f,
  4.44227576e-01f, -2.93552518e-01f, 4.10449892e-01f, -2.70705134e-01f, 4.62152869e-01f, 1.64721116e-01f, -1.21631868e-01f, -1.16642468e-01f, 9.15398896e-02f, -5.11554062e-01f,
  2.32736230e-01f, 2.28352938e-02f, -3.04290295e-01f, -1.16224028e-01f, -1.58875361e-01f, 5.20562112e-01f, -2.22933933e-01f, 7.40352273e-02f, -1.03170872e-01f, -1.20277107e-01f,
  2.76991904e-01f, -1.29756197e-01f, -2.64581531e-01f, -1.64330065e-01f, -2.76500553e-01f, 9.18862298e-02f, -3.92616764e-02f, -4.25421536e-01f, -1.98769897e-01f, -3.58176172e-01f,
  -2.90748864e-01f, 7.56657198e-02f, 3.61812860e-01f, 1.69311628e-01f, -4.20248002e-01f, -3.56005669e-01f, -2.87469417e-01f, -1.44299895e-01f, -2.94463247e-01f, 3.44014704e-01f,
  -6.31955862e-02f, -2.49272555e-01f, -2.09995776e-01f, -4.89615053e-02f, -2.16066524e-01f, -3.72268021e-01f, 7.29055377e-03f, -2.61359125e-01f, -4.32810992e-01f, 1.79709926e-01f,
  1.43846229e-01f, -8.55668038e-02f, 5.45261264e-01f, -4.37920898e-01f, 7.52574876e-02f, 4.81551513e-02f, -4.29906219e-01f, -9.94642675e-02f, 2.70355754e-02f, 1.02929980e-01f,
  8.46940875e-02f, 7.50200897e-02f, 2.13110424e-03f, 6.93108365e-02f, -9.35934484e-02f, 6.80933893e-02f, 4.34781127e-02f, 1.36647567e-01f, 8.70741233e-02f, 9.04080644e-02f,
  -6.30065128e-02f, -2.50941306e-01f, -2.78583467e-01f, 1.37439251e-01f, -1.48229152e-01f, -2.89825490e-03f, 5.83635457e-02f, -9.71941575e-02f, -3.98388840e-02f, -3.86208110e-02f,
  1.16043426e-02f, 1.64890349e-01f, -2.30121583e-01f, -2.45960161e-01f, 2.03295335e-01f, 4.99948680e-01f, 9.80652124e-03f, -2.71363556e-01f, 3.14267397e-01f, -3.39150608e-01f,
  -4.11932081e-01f, -6.16207570e-02f, 3.87287766e-01f, -3.68813545e-01f, -4.47804481e-01f, 3.78936023e-01f, -2.21906260e-01f, -2.57107884e-01f, -3.07307005e-01f, -2.85888582e-01f,
  1.59004658e-01f, -1.57020867e-01f, -3.01817179e-01f, -1.95726395e-01f, 1.42589778e-01f, 3.94498169e-01f, -1.71819210e-01f, 1.31745905e-01f, 1.59795791e-01f, 6.03015661e-01f,
  4.53086883e-01f, -2.35607058e-01f, -3.24042648e-01f, 1.10272981e-01f, -1.68337405e-01f, 7.92742595e-02f, -1.84829488e-01f, -2.36972868e-01f, -3.33700418e-01f, -3.13683063e-01f,
  -2.43301213e-01f, -2.88540512e-01f, 9.61145759e-03f, 2.21195223e-04f, -2.98909228e-02f, 4.53482904e-02f, 2.27898598e-01f, 2.87205219e-01f, 1.25767529e-01f, -4.43545848e-01f,
  -2.46881768e-01f, 3.11496496e-01f, -1.07977778e-01f, -1.86057091e-01f, 3.91668111e-01f, 3.57702374e-01f, -3.59285772e-01f, 1.42229587e-01f, -1.89715877e-01f, -1.81301817e-01f,
  -4.97461468e-01f, -2.65728146e-01f, -3.51444364e-01f, -1.74363449e-01f, -2.96767354e-02f, 1.45712674e-01f, 6.51963651e-01f, 3.32908064e-01f, 1.59211963e-01f, -3.23720545e-01f,
  1.87453821e-01f, -1.85004529e-02f, -2.07900435e-01f, -2.59465694e-01f, -1.72569975e-01f, 2.79213727e-01f, 4.52388227e-02f, 2.17512045e-02f, 1.46383850e-03f, -2.28738919e-01f,
  -1.63614780e-01f, -1.54148087e-01f, -1.02039315e-01f, -1.15274467e-01f, 8.11810270e-02f, -2.92714238e-01f, -2.95097381e-01f, -3.41366917e-01f, -1.90174162e-01f, 2.85087138e-01f,
  3.66961539e-01f, 7.76081113e-03f, 1.31744489e-01f, -3.03919911e-01f, 2.78266996e-01f, 6.59296438e-02f, 3.77959847e-01f, 1.38694748e-01f, 6.38733581e-02f, -4.52964842e-01f,
  2.12723956e-01f, -2.93007404e-01f, -2.72467226e-01f, -1.44126832e-01f, -3.10903311e-01f, -4.25182521e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.50732994e-01f, 1.52351454e-01f, 1.44426361e-01f, -1.49705052e-01f, -1.33699656e-01f, 2.74732430e-02f, 2.80884821e-02f, -4.10588086e-02f, 2.61675175e-02f, 5.64720519e-02f,
  3.96473892e-02f, 8.44052900e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    