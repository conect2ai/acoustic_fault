/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.50339171e-01f, 3.62411797e-01f, 1.48336990e-02f, -8.30113962e-02f, 6.44449219e-02f, 1.09135285e-01f, 2.86889046e-01f, 1.56351030e-01f, -1.53750867e-01f, 6.07618317e-03f,
  1.50619954e-01f, -4.19231988e-02f, -1.10740110e-01f, -8.62070471e-02f, 1.13653261e-02f, 3.20071280e-02f, -2.13913590e-01f, -2.55057991e-01f, -8.43288898e-02f, 1.56846464e-01f,
  -7.46754557e-03f, -1.99945927e-01f, -1.74886748e-01f, -6.52048439e-02f, -1.88314408e-01f, -4.48707968e-01f, -1.43156081e-01f, -2.46080961e-02f, -1.29044829e-02f, -6.69497430e-01f,
  1.29538417e-01f, 3.46717834e-01f, -7.17462674e-02f, 7.66767934e-02f, 1.13861784e-01f, 1.04795871e-02f, -9.60389338e-03f, 2.70202756e-02f, 3.08321901e-02f, 2.73607448e-02f,
  -5.69354109e-02f, 6.20071404e-02f, -5.04029840e-02f, -5.99307567e-02f, 9.01553631e-02f, 3.73439752e-02f, 1.14422403e-01f, 4.51181568e-02f, -7.65231997e-02f, 1.76992625e-01f,
  -4.84681129e-02f, -2.16377117e-02f, 1.16373617e-02f, 2.50612330e-02f, 1.44579619e-01f, -5.98530173e-02f, 1.81178734e-01f, -4.93563674e-02f, -9.47103873e-02f, -1.38180405e-01f,
  -2.85290778e-02f, -1.05079226e-02f, -3.23474966e-02f, 3.80601212e-02f, -1.40187861e-02f, -5.91477659e-03f, 1.00674704e-02f, -3.58862877e-02f, -6.60482547e-05f, -3.77509631e-02f,
  -1.08279530e-02f, 7.34563097e-02f, -3.19869854e-02f, -6.92912238e-03f, -8.25741813e-02f, 4.17014677e-03f, -4.85354774e-02f, -9.27194953e-03f, 5.28300926e-02f, -1.45997945e-02f,
  4.18264419e-02f, -8.37623421e-03f, 6.67799090e-04f, -6.62752092e-02f, 6.59577455e-03f, 1.40490825e-03f, -7.47340918e-02f, 4.34965901e-02f, 5.74431010e-02f, 5.75101599e-02f,
  2.65179724e-02f, -1.69250518e-01f, -7.57089332e-02f, -1.67657761e-03f, -5.21449186e-02f, 6.05941452e-02f, -2.10232195e-02f, 2.43844055e-02f, -2.58538406e-02f, 7.38434121e-03f,
  9.46375355e-02f, -6.10026233e-02f, 3.42166983e-02f, -2.80594826e-02f, -4.79614176e-02f, -2.81886049e-02f, -2.35320330e-02f, -1.22504137e-01f, 5.24544716e-02f, 8.91726762e-02f,
  7.97876269e-02f, -9.68690738e-02f, -1.24878429e-01f, -3.98093276e-02f, -9.04865637e-02f, -2.01442897e-01f, 4.46703145e-03f, -7.48970918e-03f, -9.90493000e-02f, 2.04733517e-02f,
  -8.09765637e-01f, 4.05895323e-01f, -3.18848521e-01f, 3.56432833e-02f, 1.47037491e-01f, -1.87835112e-01f, 1.45369694e-01f, -3.97977866e-02f, 5.29438071e-02f, 1.38459757e-01f,
  1.12924427e-02f, -4.42201318e-03f, -3.54032144e-02f, -9.28474590e-02f, -4.09061611e-01f, 1.42908573e-01f, 4.80598137e-02f, -4.20963168e-01f, -4.22746539e-01f, -8.33791196e-02f,
  2.81842977e-01f, 1.70520887e-01f, -2.68790424e-01f, -1.24212712e-01f, 4.23299372e-01f, 1.68155059e-01f, 4.24618125e-02f, 8.39307755e-02f, 3.38823125e-02f, 4.25778121e-01f,
  5.25542498e-02f, 6.77114278e-02f, -1.15278482e-01f, -8.92761222e-04f, 3.99846723e-03f, -4.36251462e-02f, 3.02921291e-02f, 6.21745922e-02f, -1.22440874e-03f, 8.49992335e-02f,
  3.69555503e-02f, 5.71862608e-02f, -1.03865094e-01f, 1.12338848e-01f, 6.15545139e-02f, 9.25058722e-02f, 1.95846502e-02f, -7.84578621e-02f, 2.70285588e-02f, 2.37503089e-02f,
  2.08765715e-01f, 5.96261676e-03f, -4.01068814e-02f, 1.14419470e-02f, -2.18341246e-01f, -1.40061989e-01f, 3.65889966e-02f, -8.98909345e-02f, -2.25879595e-01f, 1.00698590e-01f,
  3.92300040e-02f, 9.02069267e-03f, -2.73182150e-02f, 2.58122422e-02f, -1.46278655e-02f, 3.93577758e-03f, -1.61138363e-02f, 2.40732655e-02f, -2.15187483e-02f, -1.82665972e-04f,
  2.34910510e-02f, 1.44362012e-02f, 1.79114994e-02f, -3.66589651e-02f, 1.89840458e-02f, -2.38377554e-03f, -6.76641613e-02f, 3.14027369e-02f, -5.72649501e-02f, 3.43754031e-02f,
  -3.69856469e-02f, -1.36862844e-02f, 3.50219086e-02f, -2.55195098e-03f, 3.55496965e-02f, -5.08354008e-02f, -8.32372531e-03f, 2.47936752e-02f, 2.78658569e-02f, 3.19370180e-02f,
  2.25980699e-01f, -3.12433153e-01f, 7.97522515e-02f, 7.15129171e-03f, -1.49640432e-02f, -3.88851226e-03f, -3.04791168e-03f, 7.96537567e-03f, 2.48662918e-03f, 4.46324907e-02f,
  -8.77219737e-02f, -4.94426861e-02f, 1.74211040e-02f, -5.92281227e-04f, -1.04607590e-01f, -3.72511074e-02f, -2.47420259e-02f, -3.81021425e-02f, -2.37776730e-02f, 1.14581317e-01f,
  1.16087161e-02f, -6.86260592e-03f, 5.05716763e-02f, 4.50992910e-03f, -6.25495194e-03f, -1.04074642e-01f, 6.31957054e-02f, 9.77791101e-02f, -2.07006618e-01f, 3.52215618e-01f,
  -2.33262390e-01f, 4.02544856e-01f, 3.82206529e-01f, -8.65441412e-02f, 2.54875064e-01f, 2.24800035e-01f, 5.72669148e-01f, -1.50015146e-01f, -3.37940693e-01f, 3.25384736e-01f,
  2.78455645e-01f, -2.28130836e-02f, 1.15869921e-02f, -8.42393786e-02f, 1.65879369e-01f, 3.40061545e-01f, 1.48284778e-01f, 2.06275401e-03f, 9.31259152e-03f, 1.90162092e-01f,
  1.61990434e-01f, 7.65420198e-02f, -1.99718684e-01f, -1.64235741e-01f, 3.29610556e-02f, -9.20128226e-02f, -6.60163611e-02f, -1.50584042e-01f, 9.92667899e-02f, 2.45233968e-01f,
  3.47645462e-01f, 4.02149409e-02f, -3.07209976e-02f, -1.46384249e-02f, 6.11674413e-02f, -9.01915804e-02f, 3.72560620e-02f, -8.05548802e-02f, -6.70987368e-02f, 2.37208419e-02f,
  1.22441337e-01f, -1.30169345e-02f, -5.50449565e-02f, 2.40266174e-02f, 9.34032071e-03f, 4.76864018e-02f, -7.69582018e-02f, 6.94875512e-03f, -2.88680810e-02f, 1.50922820e-01f,
  1.23698376e-01f, 2.77376145e-01f, 1.36297777e-01f, 4.82954942e-02f, -8.57935771e-02f, 2.42851228e-02f, 1.05172850e-01f, -5.51112965e-02f, -5.10369390e-02f, -8.66785944e-02f,
  1.38381133e-02f, -2.72462089e-02f, 3.27081084e-02f, -4.73215769e-04f, -6.18357472e-02f, -2.36034505e-02f, 2.79211701e-04f, -7.47665949e-03f, 2.96607856e-02f, -3.45597491e-02f,
  -2.43675589e-04f, 3.24441381e-02f, 2.10032333e-02f, 8.44305940e-03f, 6.06564954e-02f, 1.08677223e-02f, 4.85480130e-02f, 5.83697259e-02f, -4.23290394e-02f, -1.60355698e-02f,
  9.71040316e-03f, -4.67286669e-02f, -1.06465425e-02f, -2.84530669e-02f, 8.32927078e-02f, 1.09014213e-02f, 2.35590879e-02f, -8.93937331e-03f, -9.07630548e-02f, -2.22343262e-02f,
  -2.86601126e-01f, 1.06876984e-01f, 1.03513952e-02f, -6.88151196e-02f, -4.70037833e-02f, -9.20577645e-02f, 6.95642605e-02f, -3.02587394e-02f, -5.42016290e-02f, -1.81100685e-02f,
  -1.26198377e-03f, -3.37879658e-02f, 4.75330465e-02f, -3.47709656e-02f, 4.08233935e-03f, -1.11361109e-02f, -4.58124792e-03f, 2.61747185e-02f, -5.81306070e-02f, -1.49816543e-01f,
  -8.67412537e-02f, -1.35324717e-01f, -4.47792225e-02f, -4.09111269e-02f, -1.30080715e-01f, 2.76940838e-02f, -1.16968583e-02f, -3.27713080e-02f, -2.52516530e-02f, -7.32061267e-02f,
  1.63740784e-01f, -2.47710317e-01f, -1.94787636e-01f, -2.28924528e-01f, 9.48017929e-03f, 2.07337961e-01f, -9.08259116e-03f, 1.06501140e-01f, 1.31348565e-01f, -1.90870732e-01f,
  3.73516023e-01f, 1.36950254e-01f, 7.35184457e-03f, 1.67215303e-01f, 2.83641994e-01f, -1.67633414e-01f, -3.85156274e-01f, -2.03992710e-01f, 2.54635543e-01f, 3.22143734e-01f,
  -2.51813475e-02f, -2.90274948e-01f, 2.68530101e-03f, -4.60723601e-02f, -2.27342218e-01f, -8.25660527e-02f, -2.00059459e-01f, -1.00748859e-01f, 1.00081258e-01f, -7.71173775e-01f,
  -7.46235847e-02f, -4.55072476e-03f, 1.07015818e-01f, 5.63379675e-02f, -1.75188780e-02f, 5.24107479e-02f, 2.05583200e-02f, -1.03653818e-01f, -1.32212741e-02f, -5.59680611e-02f,
  2.01016124e-02f, -1.53780263e-02f, -4.57684062e-02f, -4.44079116e-02f, -2.03029439e-02f, 1.05387717e-02f, 7.80020515e-03f, 2.42157746e-03f, 5.11001535e-02f, 8.69406164e-02f,
  -8.51232931e-02f, 2.99618207e-02f, 3.20404284e-02f, 1.17714070e-01f, 1.41111672e-01f, 2.42341217e-02f, 6.70941845e-02f, 1.49470106e-01f, 3.12523544e-01f, -1.40592843e-01f,
  4.50855903e-02f, -7.00436980e-02f, 3.20513844e-02f, -4.27857414e-02f, -2.81549450e-02f, -1.96587294e-02f, -2.35268530e-02f, -2.22164392e-02f, 5.70975021e-02f, -9.40928310e-02f,
  2.42587905e-02f, 7.27539062e-02f, -2.51323413e-02f, 2.74453126e-02f, -3.04038599e-02f, 2.26011705e-02f, -3.07843685e-02f, -5.35426475e-02f, 3.47212073e-03f, -1.76910497e-02f,
  1.38644818e-02f, 1.68145746e-02f, -2.50941105e-02f, -1.70772467e-02f, 1.59756336e-02f, -4.06949222e-02f, 5.24655450e-03f, 2.52995063e-02f, 4.06641960e-02f, 1.19575104e-02f,
  1.02475680e-01f, 2.90088981e-01f, -1.05678052e-01f, 1.90982632e-02f, -3.84499952e-02f, 1.32591249e-02f, -2.47167367e-02f, 8.35069492e-02f, 2.62722764e-02f, -3.18369418e-02f,
  1.40162334e-01f, -3.14060450e-02f, -4.17636447e-02f, 2.63211387e-03f, 2.12695636e-02f, 6.22972474e-02f, -4.11904193e-02f, -2.71547474e-02f, 7.58460164e-02f, 2.78294887e-02f,
  -7.27611333e-02f, 3.00817750e-02f, 8.75120759e-02f, 5.64845651e-03f, 6.59258738e-02f, 6.45179898e-02f, -2.61725020e-02f, -4.13762145e-02f, 8.18800479e-02f, -2.46334225e-01f,
  5.45073032e-01f, -2.39785433e-01f, -6.78734064e-01f, 4.91311103e-01f, 4.09792423e-01f, 1.67396903e-01f, -6.61285371e-02f, -1.82133541e-02f, 1.73199788e-01f, -3.34825590e-02f,
  1.13819659e-01f, 3.10162574e-01f, -2.76230015e-02f, -1.22685783e-01f, -1.68537408e-01f, -3.43092114e-01f, -3.20379704e-01f, -2.52443492e-01f, 3.10344566e-02f, 3.38311166e-01f,
  3.25682253e-01f, 1.48912206e-01f, 5.86850159e-02f, -8.82378146e-02f, -2.47774925e-02f, 2.62789965e-01f, -2.56418407e-01f, -9.17340666e-02f, -1.52416319e-01f, -1.88078344e-01f,
  -2.88678706e-01f, -1.60653055e-01f, 1.74653828e-01f, 1.84586108e-01f, 4.39143460e-03f, -7.83706829e-02f, 4.06793840e-02f, -8.54766369e-02f, 6.29474744e-02f, -6.66916147e-02f,
  6.32358342e-02f, 3.73385823e-03f, 1.04373448e-01f, -7.98471831e-03f, 5.54633774e-02f, 6.37997314e-03f, -8.26786831e-02f, -1.91594794e-01f, -8.33791271e-02f, -1.34741634e-01f,
  1.91754088e-01f, 1.41249225e-01f, -1.92411449e-02f, 4.77389209e-02f, -1.50360495e-01f, 1.13297090e-01f, -4.76180352e-02f, -1.15531623e-01f, -1.08990140e-01f, -5.66103756e-02f,
  6.35959581e-02f, -7.81506766e-04f, -2.15068590e-02f, -2.08064984e-03f, 1.75071619e-02f, 7.66558200e-03f, -9.92026273e-03f, 5.76411374e-02f, 2.22698860e-02f, 1.11414455e-02f,
  1.58456154e-02f, 3.54891852e-03f, -1.36568798e-02f, -2.89450679e-02f, -6.73503731e-04f, -2.64894422e-02f, -9.14575811e-03f, -1.30846342e-02f, -1.82397142e-02f, -5.07378355e-02f,
  1.70292556e-02f, -1.31305018e-02f, 5.58779761e-02f, -5.42470701e-02f, -1.15324836e-02f, -7.52086565e-02f, 6.36790916e-02f, 1.70565993e-02f, 1.23899058e-03f, 3.29891182e-02f,
  2.52990186e-01f, 3.17813829e-02f, -1.00359553e-02f, -9.34126228e-02f, 3.06536425e-02f, -6.55405670e-02f, 3.42342909e-03f, 6.10133447e-02f, -1.20269014e-02f, -6.70218915e-02f,
  -2.26791073e-02f, -4.92279883e-03f, -9.32123587e-02f, -8.71225893e-02f, 6.32405281e-02f, -1.84228842e-03f, 5.43093272e-02f, 7.15906322e-02f, -4.45386022e-02f, -6.18312694e-02f,
  -1.19668908e-01f, 3.86159234e-02f, 2.35516250e-01f, 1.56582892e-02f, 7.64235435e-03f, 1.61692739e-01f, -5.58225960e-02f, 1.78573448e-02f, 1.46475519e-04f, 2.59383202e-01f,
  -2.07796574e-01f, 4.49526340e-01f, 4.42934642e-03f, -7.25158304e-02f, 1.75411448e-01f, 2.57819086e-01f, 3.26348186e-01f, 1.03464693e-01f, -9.78672802e-02f, 5.30778915e-02f,
  6.84192730e-03f, -3.24072987e-01f, -3.66671503e-01f, -1.72097802e-01f, 3.70373228e-03f, 1.83519393e-01f, 1.34800911e-01f, -1.53476596e-01f, -2.62685090e-01f, 6.30625486e-02f,
  2.67490055e-02f, -4.35839705e-02f, -1.02255821e-01f, -6.38584793e-02f, -5.60035147e-02f, -2.44637579e-01f, 1.19579476e-04f, 1.80769097e-02f, 1.68417722e-01f, 2.83974141e-01f,
  -4.43162434e-02f, 2.27266952e-01f, -2.59091347e-01f, -2.84560677e-02f, 1.33711742e-02f, -5.06084338e-02f, 5.75581286e-03f, -8.34240913e-02f, -1.64079498e-02f, 4.23728339e-02f,
  -8.33507441e-03f, 3.03274486e-02f, 5.51845133e-02f, -1.36466520e-02f, 5.24112284e-02f, -3.19712260e-03f, -3.29890475e-02f, -2.10200492e-02f, -1.12397425e-01f, 4.25984571e-03f,
  1.06081270e-01f, 2.05401212e-01f, 1.22008603e-02f, 1.14036068e-01f, -6.14074338e-03f, -1.27908036e-01f, 1.70633402e-02f, 5.21212704e-02f, 4.83410656e-02f, 5.49160093e-02f,
  -7.05115274e-02f, 5.94152510e-02f, -9.39696468e-03f, 2.99739316e-02f, -3.54980007e-02f, 3.26748043e-02f, -1.07762208e-02f, -5.65928407e-02f, 1.99683104e-03f, 3.39058153e-02f,
  -2.56330092e-02f, -4.91697481e-03f, -1.58771165e-02f, -2.98923850e-02f, -1.01673424e-01f, 7.01341331e-02f, 1.24578420e-02f, 2.20216848e-02f, -2.80049015e-02f, -1.16739813e-02f,
  -5.01314700e-02f, 1.98837114e-03f, -9.65022482e-03f, -3.81989987e-03f, 2.77084354e-02f, -1.36955176e-02f, -1.29737444e-02f, 3.40518430e-02f, -8.47333670e-02f, 1.80994347e-02f,
  -3.97179067e-01f, -1.17350020e-01f, -5.56646511e-02f, -1.82774439e-02f, 1.92478113e-02f, 2.07161973e-03f, -4.78769876e-02f, -1.54089415e-03f, 3.83450314e-02f, 2.15569232e-02f,
  5.84321022e-02f, -5.01005612e-02f, -1.57881118e-02f, 5.47769181e-02f, -2.67543402e-02f, 1.78424385e-03f, 5.37020713e-02f, -6.07919320e-02f, 8.65913704e-02f, 4.76005152e-02f,
  6.37809336e-02f, -5.09397089e-02f, -2.52609611e-01f, -1.27095580e-01f, -2.43849941e-02f, -1.81536078e-01f, -1.03530295e-01f, -1.24144748e-01f, -1.42217740e-01f, -1.81408346e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.11281399e-02f, 3.96990687e-01f, -4.46469218e-01f, -2.35933036e-01f, -4.95044798e-01f, -4.66037720e-01f, -7.55855069e-02f, -1.34648502e-01f, -1.63624346e-01f, 7.91018978e-02f,
  -9.54232085e-03f, 5.66177070e-02f, 2.38171265e-01f, 5.26989214e-02f, 1.28535733e-01f, 1.12117166e-02f, -2.08878994e-01f, -1.66435122e-01f, -2.52794921e-01f, -3.02032202e-01f,
  -1.79430500e-01f, -9.53174680e-02f, -1.65851980e-01f, -1.80826619e-01f, -1.61944821e-01f, -1.22057535e-01f, -1.56351522e-01f, -1.80135190e-01f, -1.57109693e-01f, -3.13253194e-01f,
  2.21938506e-01f, -3.51411939e-01f, -1.66114926e-01f, -6.48127198e-02f, -4.09842990e-02f, -1.12001643e-01f, -1.58440638e-02f, -2.76709925e-02f, -3.53382342e-02f, -5.45776375e-02f,
  -8.84869769e-02f, -2.39942707e-02f, -1.04295604e-01f, -1.54691786e-01f, -1.18121266e-01f, -6.24129139e-02f, -8.66793394e-02f, -1.07671306e-01f, -2.79697683e-02f, -1.53456554e-01f,
  -1.45244882e-01f, -2.51237243e-01f, -1.61525786e-01f, 2.85371244e-02f, -1.43588439e-01f, -8.84626582e-02f, -8.66025165e-02f, -1.92804322e-01f, -1.06312692e-01f, 5.90461008e-02f,
  3.95275876e-02f, 5.69001064e-02f, -5.91020919e-02f, 6.72751442e-02f, 4.60673757e-02f, 6.24780953e-02f, 3.43937390e-02f, 7.75826052e-02f, 5.97834252e-02f, 5.92242144e-02f,
  1.21097982e-01f, -2.81041134e-02f, 2.34267283e-02f, 8.03517997e-02f, 7.22024292e-02f, -1.27805382e-01f, -2.05231775e-02f, 6.79207370e-02f, 4.52167504e-02f, -1.22172393e-01f,
  -5.77397598e-03f, -8.02317634e-02f, -8.22635293e-02f, -7.10190926e-03f, -2.42318004e-01f, -2.23760363e-02f, -1.52391410e-02f, -8.78210273e-03f, 1.86570510e-02f, -1.71379000e-01f,
  7.60460496e-01f, -1.69858396e-01f, 1.93885103e-01f, 8.77979770e-02f, -1.42480940e-01f, -2.03281594e-03f, 8.21772665e-02f, -5.49159832e-02f, -3.47956978e-02f, 3.84894498e-02f,
  -6.14580512e-02f, 1.49238715e-02f, 1.38303459e-01f, 2.54782941e-02f, 7.99054839e-03f, -1.74286552e-02f, 1.28603667e-01f, -5.36424248e-03f, -1.19850919e-01f, -7.20538571e-02f,
  1.21046595e-01f, 8.01593661e-02f, 3.46982896e-01f, 1.60110131e-01f, -7.29043456e-03f, 1.62806541e-01f, 2.32800320e-01f, 1.07813179e-01f, 1.76942691e-01f, 5.92598915e-01f,
  -1.07793140e+00f, -5.78962386e-01f, -3.54083478e-01f, -4.32201743e-01f, 2.27583223e-03f, 1.56679302e-01f, 3.68095398e-01f, 1.54351741e-01f, -1.49077818e-01f, -3.59833360e-01f,
  -3.10636699e-01f, -6.64943680e-02f, -1.05826683e-01f, 2.52381712e-01f, 3.61979425e-01f, 1.87038537e-02f, 8.75028893e-02f, 1.55872464e-01f, 3.19098055e-01f, 2.76375502e-01f,
  2.96266198e-01f, 1.00629918e-01f, -3.68380956e-02f, 1.38135567e-01f, -1.71372592e-01f, -7.51638934e-02f, -1.84013441e-01f, -1.31364360e-01f, -7.03375936e-02f, -2.99493849e-01f,
  -6.81029141e-01f, -6.20125473e-01f, 2.93494642e-01f, 2.18301639e-02f, -1.77434385e-01f, -1.06976621e-01f, -8.90032426e-02f, -1.33445948e-01f, -2.58164536e-02f, -6.05660491e-02f,
  -7.72151947e-02f, -1.08001478e-01f, -1.00368030e-01f, 1.22700758e-01f, -1.68478802e-01f, 3.97693217e-02f, 3.06710415e-02f, 6.60695955e-02f, 3.91166508e-02f, -4.09099869e-02f,
  8.09317902e-02f, -1.88586175e-01f, -2.65973061e-01f, 2.06038505e-01f, 1.60840191e-02f, 3.73671129e-02f, -1.26937270e-01f, -6.67004064e-02f, 4.59608883e-02f, -3.03781241e-01f,
  6.15166537e-02f, -9.37113538e-02f, -1.07114878e-03f, -1.34746572e-02f, 9.26684663e-02f, -6.97980076e-02f, -9.74174961e-03f, 4.21621371e-03f, 5.85612543e-02f, -3.89691293e-02f,
  5.19757345e-02f, -5.84815219e-02f, 1.95463970e-02f, -6.88073635e-02f, -2.70118285e-02f, -4.83910665e-02f, 8.02321881e-02f, 7.63307288e-02f, 2.49039046e-02f, 7.34524522e-03f,
  6.32654130e-03f, -4.63343039e-03f, -8.39414075e-02f, 9.18680131e-02f, 5.04324846e-02f, -3.19309942e-02f, -1.15010124e-02f, 4.73361649e-02f, -7.98922870e-03f, -6.14574030e-02f,
  -1.16674371e-01f, 4.01416898e-01f, -2.97859371e-01f, 7.76757151e-02f, -1.98066309e-01f, 8.14917833e-02f, -1.25688583e-01f, 1.70020387e-02f, -2.00511321e-01f, -4.78740036e-02f,
  -1.68645084e-02f, -3.93499397e-02f, -1.28522426e-01f, 1.20739721e-01f, 4.83724363e-02f, -3.40625793e-02f, -1.58082079e-02f, -5.79936430e-02f, 9.67947990e-02f, -5.19824997e-02f,
  1.30484372e-01f, 3.00632529e-02f, -2.72733301e-01f, -9.98582616e-02f, -1.23783231e-01f, -2.41883069e-01f, -1.35729924e-01f, -1.00159667e-01f, -1.16721854e-01f, -1.57230556e-01f,
  -3.02238226e-01f, -6.57579064e-01f, 5.32306671e-01f, -1.24233030e-01f, 4.00615633e-01f, 5.52964449e-01f, 3.90485942e-01f, 1.43331438e-01f, -1.82832003e-01f, -1.40008315e-01f,
  -2.39671364e-01f, -3.03483754e-01f, -3.61943901e-01f, -2.68329471e-01f, -1.82492927e-01f, -4.32294682e-02f, -7.21776998e-03f, 1.04098141e-01f, 4.81699169e-01f, 4.04015958e-01f,
  -1.58216134e-01f, -9.96241122e-02f, -2.34619245e-01f, -2.04675868e-01f, -2.00427026e-01f, -8.30830261e-03f, -1.82927191e-01f, -1.28808558e-01f, -1.11671366e-01f, -2.98828393e-01f,
  5.52304626e-01f, -2.61355489e-01f, 2.12988511e-01f, -3.77968460e-01f, 1.68643277e-02f, -8.00393224e-02f, 1.35911450e-01f, -7.22683966e-02f, -8.97373632e-02f, 7.98352659e-02f,
  -8.76545236e-02f, -9.24463868e-02f, -1.24335689e-02f, -1.15904190e-01f, 6.01371713e-02f, -3.30488919e-03f, -1.19473346e-01f, -1.37767643e-01f, -1.63279191e-01f, -5.62011823e-02f,
  -2.96320528e-01f, 5.33825485e-03f, 1.10786334e-01f, 4.27462645e-02f, -1.32661223e-01f, -1.06759490e-02f, -4.28187810e-02f, -8.62077475e-02f, -1.28337499e-02f, -1.68915957e-01f,
  -2.76705530e-02f, 9.13699791e-02f, 6.02763072e-02f, 1.18577359e-02f, 3.26428935e-02f, 3.64112705e-02f, 1.80787481e-02f, 9.84541029e-02f, -1.12368837e-02f, 1.00583807e-02f,
  7.83436447e-02f, 2.57325068e-04f, -1.40361041e-02f, -4.51848656e-02f, 8.26821430e-04f, -5.54713197e-02f, 3.79842333e-02f, -6.68072402e-02f, -2.96670925e-02f, -2.46752589e-03f,
  -7.50475302e-02f, 2.00593583e-02f, -5.84120750e-02f, -5.42319939e-02f, -1.38330087e-01f, -1.93188731e-02f, 4.73823510e-02f, -4.75458940e-03f, 1.89161748e-02f, -6.85925782e-02f,
  7.03554899e-02f, -1.32032216e-01f, 4.81081642e-02f, -7.10938498e-02f, 3.72068174e-02f, -1.61645278e-01f, -1.05504967e-01f, -2.45836340e-02f, -8.37006941e-02f, 8.05345997e-02f,
  1.72815230e-02f, 1.96668636e-02f, -8.97123739e-02f, -4.18341868e-02f, 2.36845776e-01f, 8.29896331e-02f, -2.28722155e-01f, 5.79625331e-02f, -9.38116480e-03f, -5.03438991e-03f,
  -1.90655470e-01f, 2.30808884e-01f, 2.68341690e-01f, 2.24303082e-01f, 3.25843394e-02f, 2.07015812e-01f, 3.34835440e-01f, 2.21231267e-01f, 2.14047775e-01f, 1.58662334e-01f,
  -4.20781672e-01f, -3.62482399e-01f, -8.25881884e-02f, 3.50796469e-02f, 1.17939189e-01f, -2.64330715e-01f, -7.45301008e-01f, -5.56691349e-01f, -1.76808670e-01f, -4.41806912e-02f,
  1.17872059e-01f, 1.02978341e-01f, -1.14458270e-01f, -1.16068318e-01f, -6.54231966e-01f, -4.52481687e-01f, -3.97509903e-01f, -4.74581510e-01f, -3.51292551e-01f, -1.94386318e-01f,
  1.09711643e-02f, -1.03273578e-01f, -2.75022745e-01f, -1.24362625e-01f, 2.83884615e-01f, 1.67728767e-01f, 8.21304470e-02f, 1.69188082e-01f, 1.60560638e-01f, 2.96253175e-01f,
  3.01794499e-01f, -2.59852648e-01f, 1.90678407e-02f, 1.53004110e-01f, 1.46491870e-01f, -8.81174579e-02f, -5.92730306e-02f, -8.58433992e-02f, 3.65278274e-02f, -1.29660308e-01f,
  2.55428344e-01f, 4.15223166e-02f, -4.10531908e-02f, -7.60171562e-02f, -1.65250987e-01f, -1.90604463e-01f, -2.11825207e-01f, -2.85839617e-01f, -2.22378209e-01f, -8.98295268e-02f,
  1.47605494e-01f, 6.97548091e-02f, -2.88992912e-01f, -1.69458166e-01f, -1.93405002e-01f, 9.40717310e-02f, -4.73324321e-02f, 2.04840265e-02f, -8.67380947e-02f, -2.20990270e-01f,
  1.41321933e-02f, 9.22106393e-03f, -1.27350609e-03f, -7.36444816e-03f, -4.32359427e-03f, 1.05900705e-01f, 1.98165178e-02f, -5.15013039e-02f, -5.70445247e-02f, -1.35181779e-02f,
  2.28919461e-03f, 6.59379289e-02f, -6.76624477e-02f, -4.28069048e-02f, 1.01590507e-01f, -1.32982358e-02f, 2.61595380e-02f, -1.27269566e-01f, -1.63214542e-02f, -1.16444621e-02f,
  -2.07967199e-02f, 4.86216974e-04f, 1.17393740e-01f, -5.46109164e-03f, -3.85536030e-02f, -2.60245032e-03f, 1.83886997e-02f, 3.29113938e-02f, -2.19873022e-02f, -1.27670523e-02f,
  -2.78644338e-02f, 3.02763507e-02f, -1.85549315e-02f, -1.75795481e-01f, 3.77623527e-03f, 6.94505572e-02f, 1.50094196e-01f, -3.28772306e-03f, 1.35928065e-01f, -1.68829501e-01f,
  -2.61172708e-02f, -1.11107565e-01f, 6.50847033e-02f, 8.02784041e-03f, -1.17813319e-01f, -1.08727738e-02f, -7.45407417e-02f, -1.02300785e-01f, -6.56324327e-02f, -4.59591150e-02f,
  -4.05700020e-02f, -3.79341722e-01f, -4.75160688e-01f, -2.45585293e-01f, -7.03032985e-02f, -1.83663234e-01f, -2.95570821e-01f, -1.64847434e-01f, -3.37905586e-01f, -4.97359186e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  6.02112532e-01f, 5.50236344e-01f, 4.99274790e-01f, 2.88857669e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -6.60564661e-01f, -5.40057234e-02f, -1.02313077e+00f, -1.07957542e+00f, 3.22058126e-02f, 3.99156690e-01f, 6.58351064e-01f, -3.53658907e-02f, -3.51830035e-01f, 4.19221967e-01f,
  9.82918680e-01f, -2.85757422e-01f, 9.80799049e-02f, 7.56303251e-01f, -1.84543934e-02f, 4.56551433e-01f, 5.30819476e-01f, -8.76671195e-01f, -8.23092401e-01f, -4.29521799e-01f,
  -1.67017028e-01f, -2.58040398e-01f, -3.07712108e-01f, -1.66942680e+00f, -3.35396193e-02f, 9.99735892e-01f, 1.17393136e+00f, -7.33916044e-01f, 7.65156388e-01f, -1.21056579e-01f,
  -2.53365397e-01f, -5.18438935e-01f, 8.17405134e-02f, -3.17441106e-01f, 5.31216383e-01f, 6.44313216e-01f, 1.17539475e-02f, 4.70083505e-01f, -8.10455739e-01f, -1.00884330e+00f,
  -9.44586158e-01f, 2.57665694e-01f, -7.28436172e-01f, -5.09855747e-01f, -3.73184681e-01f, 8.64293635e-01f, -5.11140287e-01f, 2.19160497e-01f, -6.87965989e-01f, 3.77650678e-01f,
  1.01446736e+00f, -4.57457244e-01f, -2.51932591e-01f, -4.97646242e-01f, 6.80683672e-01f, 4.02816087e-01f, -2.98130978e-02f, 9.35897231e-01f, -9.03288007e-01f, 5.08879304e-01f,
  -6.98954538e-02f, 8.37112427e-01f, 2.35705182e-01f, 2.45732307e-01f, -7.01507628e-01f, -2.35466510e-01f, -6.61033750e-01f, 3.52020264e-01f, 8.83121490e-02f, 1.25050426e-01f,
  6.76369786e-01f, 8.68948579e-01f, -8.60635757e-01f, 5.45914352e-01f, -6.45880878e-01f, -1.33756533e-01f, 6.70334473e-02f, -8.86420488e-01f, -4.29258317e-01f, 1.13296020e+00f,
  5.01692295e-01f, 8.23857605e-01f, -2.12095797e-01f, 5.86968362e-01f, -4.65078503e-01f, 4.59096968e-01f, 4.42580432e-01f, 7.64934778e-01f, -6.88097715e-01f, -4.47201077e-03f,
  1.18060029e+00f, -7.48233199e-01f, 1.07799828e+00f, -6.59772605e-02f, -7.70261049e-01f, -5.05630791e-01f, 4.58193302e-01f, 8.29233050e-01f, 9.82639074e-01f, -2.77527869e-01f,
  -4.90659118e-01f, 2.07362249e-01f, -1.13540328e+00f, -1.81650028e-01f, 5.61809301e-01f, -1.09236848e+00f, -1.16901827e+00f, 8.73447239e-01f, -4.10900384e-01f, -4.48932707e-01f,
  -4.93651062e-01f, -4.26020205e-01f, -4.66131896e-01f, -2.10220385e-02f, -8.91086340e-01f, -6.38650715e-01f, 2.47344896e-01f, -4.06454325e-01f, -6.11145198e-01f, 1.06480289e+00f,
  4.23677713e-01f, -7.92145669e-01f, 1.89028412e-01f, 6.29672289e-01f, -3.55956584e-01f, 1.13797307e+00f, -1.36805758e-01f, -7.40792572e-01f, -1.94421843e-01f, 1.40164539e-01f,
  1.84328735e-01f, 9.33478326e-02f, -3.26116145e-01f, 2.67019540e-01f, -5.95553041e-01f, -2.92713940e-01f, -1.23874426e-01f, -2.06842229e-01f, 6.86071277e-01f, -4.43035901e-01f,
  -5.57731569e-01f, -2.09001526e-01f, 1.51044297e+00f, -5.95125854e-01f, -7.55287632e-02f, -1.04663976e-01f, 3.70976657e-01f, -6.68677911e-02f, 6.28959477e-01f, 2.46346951e-01f,
  -7.17798769e-01f, 7.85452604e-01f, 2.62392372e-01f, -7.96054065e-01f, 7.17689633e-01f, 1.80643365e-01f, -7.05929160e-01f, -8.02465856e-01f, -4.75737751e-01f, 1.16124880e+00f,
  1.30270630e-01f, -7.03737736e-01f, 4.81486559e-01f, 2.48666897e-01f, 2.85163134e-01f, -4.93351460e-01f, 4.45244670e-01f, 9.28846419e-01f, 2.96327591e-01f, -1.76911786e-01f,
  -5.26049495e-01f, -6.05686605e-01f, 8.75622094e-01f, -2.11262345e-01f, 6.76888347e-01f, -4.65069771e-01f, 7.00965762e-01f, 4.93758321e-01f, -9.81655478e-01f, 8.25419486e-01f,
  6.81986034e-01f, -8.55474651e-01f, 1.10849547e+00f, -7.86354482e-01f, 8.27108979e-01f, 1.05150864e-01f, -3.94167513e-01f, 8.59057307e-01f, -3.55204135e-01f, -4.19520348e-01f,
  4.04928289e-02f, -3.35635334e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.49097574e-01f, 8.96747351e-01f, -4.05704588e-01f, -3.05039614e-01f, -1.07976735e-01f, 5.72965108e-02f, 3.96933615e-01f, 2.16566622e-01f, -3.48590672e-01f, 9.29313898e-03f,
  -4.09469217e-01f, 5.25429785e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    