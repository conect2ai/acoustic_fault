/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.56311178e-01f, 1.36657521e-01f, -1.56698972e-02f, 1.78161621e-01f, 1.23177841e-01f, 7.82745779e-02f, 1.60099268e-02f, 5.26679717e-02f, 3.85320038e-02f, 1.87480927e-01f,
  3.09544712e-01f, 2.69917864e-02f, -5.97239211e-02f, -2.03736722e-02f, -2.25407984e-02f, -1.24300316e-01f, -2.66513109e-01f, -2.46423990e-01f, -2.10292950e-01f, 1.03205696e-01f,
  4.30397615e-02f, -1.89462677e-04f, -6.57156631e-02f, -1.34140193e-01f, 5.35466373e-02f, -1.24961361e-01f, -1.21154398e-01f, 1.03584364e-01f, 9.73577276e-02f, 1.42347828e-01f,
  2.75994867e-01f, 2.85702765e-01f, -8.70760530e-02f, 5.13013452e-02f, 3.60595956e-02f, -1.01248287e-01f, -1.11299947e-01f, -7.70368427e-02f, -1.22617818e-02f, -2.59408336e-02f,
  1.31227538e-01f, 2.53768303e-02f, -5.05415983e-02f, 2.92265937e-02f, -9.08639431e-02f, 1.15559392e-01f, -3.63372453e-02f, -7.60383382e-02f, -3.05249784e-02f, 1.50641844e-01f,
  6.59781992e-02f, 1.81504771e-01f, 1.07019469e-01f, 1.06707746e-02f, 2.54410300e-02f, 4.12160419e-02f, 6.32135421e-02f, 1.36819124e-01f, 9.82603580e-02f, -4.23644148e-02f,
  1.48087842e-02f, -3.17347348e-02f, 7.28794709e-02f, -9.10270493e-03f, -9.33300238e-03f, -6.20317422e-02f, -1.10676028e-01f, -6.39485121e-02f, 8.10863730e-03f, -2.53174156e-02f,
  -4.80930544e-02f, 4.41947840e-02f, -5.77900149e-02f, -7.20835124e-06f, 1.60110686e-02f, 3.74329388e-02f, -7.59671209e-04f, -5.68344072e-03f, 4.03496251e-02f, 3.20542604e-02f,
  9.47137550e-02f, 3.60288545e-02f, -9.35454946e-03f, 3.22253705e-04f, 4.32600230e-02f, -5.09601496e-02f, 3.79301868e-02f, 1.55950654e-02f, -2.75292788e-02f, 4.21184860e-02f,
  -2.08111808e-01f, 4.00067233e-02f, 7.46869445e-02f, -4.63947915e-02f, 7.29787908e-03f, 3.15094367e-02f, 3.42168398e-02f, 1.99725013e-03f, 3.37096862e-02f, 3.69551890e-02f,
  1.00762136e-01f, -3.69287319e-02f, -2.41258107e-02f, -4.29762667e-03f, -6.87844828e-02f, 2.80288085e-02f, 2.39602923e-02f, -4.52904515e-02f, 4.32097800e-02f, 2.63085549e-05f,
  -2.45611165e-02f, -1.30687192e-01f, -1.07891010e-02f, -1.02039315e-01f, 2.47570500e-02f, -6.09255210e-02f, -1.25803187e-01f, -8.06780607e-02f, -1.47661805e-01f, -2.50081390e-01f,
  -1.95504859e-01f, -8.88934210e-02f, 1.51602507e-01f, -2.31007427e-01f, 1.36271834e-01f, 1.78926170e-01f, 1.44608974e-01f, 1.03371821e-01f, -1.22574843e-01f, -1.53507173e-01f,
  2.86189392e-02f, 7.50340298e-02f, -2.44014226e-02f, 4.73499415e-04f, 5.31133562e-02f, -1.47267908e-01f, -8.27487335e-02f, 2.75278222e-02f, 2.52001226e-01f, 2.48175800e-01f,
  1.41282184e-02f, -1.09391846e-01f, -7.82605633e-02f, 3.05054616e-02f, -1.77659869e-01f, -2.17820406e-01f, -2.48516083e-01f, -5.30158915e-02f, -2.62130816e-02f, -2.58195639e-01f,
  -1.89288296e-02f, 1.45114258e-01f, -3.95708159e-02f, -1.11344062e-01f, -1.51225915e-02f, -8.39966610e-02f, -1.22793475e-02f, -1.48468208e-03f, -4.73367497e-02f, -1.36472762e-01f,
  -1.15785899e-03f, 8.59899074e-02f, 8.93027931e-02f, -1.84748340e-02f, -6.55714329e-03f, -3.64173017e-02f, -4.66916934e-02f, -2.87242197e-02f, -8.19493607e-02f, 6.58258647e-02f,
  2.42790319e-02f, 1.30736396e-01f, 1.15379967e-01f, 8.80044475e-02f, -2.78748088e-02f, 2.32210942e-02f, 3.26223148e-04f, 2.50611957e-02f, -9.66670439e-02f, -3.60942990e-01f,
  -3.59413587e-02f, 3.45628522e-02f, 4.82465066e-02f, 7.24863410e-02f, -8.50070789e-02f, 3.66431996e-02f, -1.00284582e-02f, 1.46484114e-02f, 6.18529320e-02f, -5.90367690e-02f,
  8.04015622e-02f, 8.16194154e-03f, 6.01538420e-02f, -2.78737098e-02f, -7.58823380e-02f, -1.45547818e-02f, 2.48268675e-02f, -7.84449652e-02f, 2.09420398e-02f, -9.80176479e-02f,
  1.39358500e-02f, 9.02539194e-02f, -1.81528963e-02f, 8.68273992e-03f, -3.38932015e-02f, 4.30339091e-02f, 1.70213301e-02f, 8.81146789e-02f, -6.63587749e-02f, 1.28595987e-02f,
  -3.89663547e-01f, 2.08761975e-01f, -1.39769167e-01f, -9.99139696e-02f, -1.29530614e-03f, -9.75495055e-02f, -3.74327488e-02f, 4.65984195e-02f, 7.35036582e-02f, 2.62971539e-02f,
  5.18413726e-03f, -8.09198096e-02f, -2.14586947e-02f, 5.34752831e-02f, 3.53143401e-02f, -5.65234497e-02f, -9.13966075e-02f, 7.60611221e-02f, 1.70218162e-02f, 1.00523401e-02f,
  -4.68647666e-02f, -6.34642839e-02f, -8.41649249e-02f, -1.30004928e-01f, 1.14028156e-02f, -8.23681429e-02f, -4.06176671e-02f, -1.65609032e-01f, -6.22617500e-03f, -4.11981195e-01f,
  -4.14708346e-01f, -7.75916502e-02f, -1.13140814e-01f, -3.43579859e-01f, -3.45743805e-01f, -2.11844742e-01f, -1.68122187e-01f, -1.26355663e-02f, -9.50126499e-02f, -9.74016935e-02f,
  8.97135120e-03f, 7.51328394e-02f, -2.65680533e-02f, 4.36576791e-02f, 8.40720534e-02f, -1.40072212e-01f, -1.57644659e-01f, -6.21428899e-02f, -4.55295667e-02f, -1.63201928e-01f,
  -1.03895575e-01f, -2.29169801e-01f, -8.35490748e-02f, 4.35559042e-02f, -7.68558681e-02f, -2.50390787e-02f, -1.45333871e-01f, -1.19981334e-01f, 1.02716433e-02f, -3.44353467e-02f,
  -1.10987701e-01f, -6.91209361e-02f, 1.12775460e-01f, 2.84223258e-02f, -1.21234946e-01f, 1.15407920e-02f, -7.83776306e-03f, -2.08269190e-02f, 1.17540963e-01f, -3.92562784e-02f,
  -5.45099890e-03f, 2.16256082e-02f, -4.47217450e-02f, 6.98627457e-02f, -1.45635396e-01f, 2.48645265e-02f, 3.93217430e-02f, 1.39696700e-02f, 2.04974953e-02f, 4.22979333e-02f,
  -5.20017259e-02f, 3.85089889e-02f, 3.58314887e-02f, 1.37496442e-01f, 5.48051707e-02f, 1.05977364e-01f, 1.00127220e-01f, 8.19156468e-02f, 4.59424295e-02f, 5.60686626e-02f,
  -7.25294650e-02f, 2.25807056e-02f, 2.66661663e-02f, 3.40141132e-02f, -5.17192157e-03f, 5.33462912e-02f, 8.45906849e-04f, -1.87463649e-02f, 4.73908931e-02f, 1.88733842e-02f,
  -2.83785816e-02f, -5.82282245e-02f, -7.63098756e-03f, -1.89757664e-02f, 7.61771202e-03f, 3.48470509e-02f, 4.54391912e-02f, -2.75679063e-02f, 4.62417491e-02f, 1.02853492e-01f,
  2.94657401e-03f, 8.00013691e-02f, -7.01498911e-02f, 3.74412797e-02f, -4.67999615e-02f, -7.08648041e-02f, -2.64898837e-02f, -3.58795328e-03f, -4.58889222e-03f, 3.58556435e-02f,
  2.66764429e-03f, 1.39786124e-01f, 1.63015090e-02f, 2.11806665e-03f, 3.29811312e-03f, 1.19308218e-01f, -7.15446472e-02f, 9.39874202e-02f, -5.77139445e-02f, 8.42226390e-03f,
  5.04569449e-02f, -3.33187939e-03f, -4.72827554e-02f, 5.21531440e-02f, -4.11163084e-02f, -3.59025858e-02f, 2.92347427e-02f, -9.95199904e-02f, 5.08403704e-02f, -1.38064688e-02f,
  -6.25748783e-02f, -4.41865949e-03f, 1.17508834e-02f, 5.36957569e-02f, -5.99161945e-02f, -7.00600520e-02f, 6.32181317e-02f, -1.60220303e-02f, 6.06160574e-02f, -1.05058048e-02f,
  3.29836667e-01f, -2.03070596e-01f, -5.39005995e-01f, 2.30869558e-02f, -1.61332130e-01f, -1.12519056e-01f, -3.53721112e-01f, 7.14934021e-02f, 2.98473984e-01f, -1.10637948e-01f,
  1.26404986e-01f, 4.65313762e-01f, 2.47831061e-01f, 3.30408812e-01f, 1.04560263e-01f, -3.64144355e-01f, -3.68484378e-01f, -1.33443207e-01f, 1.41258642e-01f, 2.41439521e-01f,
  1.47606060e-01f, -5.42961992e-02f, 6.53202608e-02f, 4.01132293e-02f, -1.08732350e-01f, 1.56659245e-01f, -2.39603639e-01f, -5.13059758e-02f, -1.05334461e-01f, -2.18738303e-01f,
  -1.22517981e-01f, -1.63413510e-01f, 1.14538468e-01f, 1.81422114e-01f, -7.13536590e-02f, 7.34737590e-02f, -1.28588658e-02f, -9.57448110e-02f, 1.66804940e-02f, 2.11761612e-02f,
  8.01040605e-03f, 7.67166466e-02f, -1.54224066e-02f, -8.44630226e-02f, 6.95847347e-03f, -1.08245676e-02f, -3.22052464e-02f, -1.70264523e-02f, -2.69258358e-02f, 2.39311790e-04f,
  -1.52042499e-02f, -1.18254170e-01f, -1.92908809e-01f, 3.53394113e-02f, -4.60871682e-02f, 1.49892628e-01f, -8.16436559e-02f, 2.81932708e-02f, -2.83678770e-02f, -4.04871331e-04f,
  3.19864899e-02f, 2.75202487e-02f, 1.20507339e-02f, -1.55015858e-02f, 6.60200119e-02f, -3.59983295e-02f, -4.35536094e-02f, -3.48951072e-02f, 4.63499464e-02f, -1.25524336e-02f,
  1.98234636e-02f, -1.31372791e-02f, -4.39847521e-02f, -5.13938181e-02f, 3.51012312e-02f, -8.41781273e-02f, -4.66811731e-02f, 1.74845140e-02f, -7.79041904e-04f, 1.31146712e-02f,
  9.92433056e-02f, -2.94422880e-02f, -2.05217507e-02f, 1.13077909e-02f, -3.03227585e-02f, -2.46124994e-02f, -5.83290355e-03f, 7.34393522e-02f, -8.88899527e-03f, -2.00959109e-02f,
  1.11611247e-01f, 1.45300608e-02f, 5.12115890e-03f, 5.73440306e-02f, -9.76474062e-02f, -1.90514512e-03f, -5.97490289e-04f, 3.74110602e-02f, 1.18316115e-04f, -1.20287552e-03f,
  3.88996787e-02f, 2.20728368e-02f, -4.34218384e-02f, -4.40831147e-02f, 8.17902982e-02f, 6.84869066e-02f, 2.74377037e-02f, -2.25518998e-02f, 2.64732894e-02f, -6.11492544e-02f,
  -2.89923865e-02f, 4.44977134e-02f, 1.88691393e-01f, 3.50725949e-02f, 7.58805871e-02f, 5.21904118e-02f, -8.11082944e-02f, -4.74302918e-02f, 2.11189929e-02f, -2.35649291e-02f,
  -1.89054966e-01f, -1.71079069e-01f, 2.07442865e-01f, -2.48741567e-01f, 5.57286963e-02f, 2.10182622e-01f, 1.74601674e-01f, 4.29952070e-02f, -1.84295282e-01f, -1.33394182e-01f,
  -2.05736890e-01f, -1.02426866e-02f, 3.66413482e-02f, -3.36640626e-02f, 2.53815591e-01f, 3.52845807e-03f, 5.58336489e-02f, 1.84115186e-01f, 4.65835482e-01f, 2.07954302e-01f,
  3.81753147e-02f, -6.78843856e-02f, -1.49322832e-02f, 1.69790853e-02f, -7.72146359e-02f, 5.22414222e-02f, 3.27732344e-03f, -8.92515555e-02f, -1.00437021e-02f, -1.30728826e-01f,
  1.63313765e-02f, -9.05598179e-02f, 1.57704145e-01f, -2.58741714e-02f, -9.84492805e-03f, -6.34330604e-03f, 6.59164507e-03f, 8.58408511e-02f, 8.31081495e-02f, 4.22924161e-02f,
  4.27961759e-02f, 7.96721950e-02f, 8.73637944e-02f, 7.35065565e-02f, -2.95765065e-02f, 4.40594554e-02f, 7.14959800e-02f, 7.29169175e-02f, 1.10407313e-02f, -1.70619581e-02f,
  -7.34648779e-02f, -1.09144241e-01f, 4.34667468e-02f, 1.14831001e-01f, 1.14635125e-01f, 1.95938647e-02f, -1.01968013e-01f, -6.67909160e-02f, 3.11876852e-02f, -1.39718860e-01f,
  -3.92254926e-02f, 2.52547804e-02f, 6.67845225e-03f, -6.21355399e-02f, 5.43479212e-02f, -1.57180559e-02f, -3.87330540e-02f, -6.93750754e-02f, 1.48665661e-03f, -2.64876988e-02f,
  -1.09129390e-02f, -1.06339315e-02f, 2.07626820e-02f, -1.67528633e-02f, 3.37910876e-02f, 1.00471564e-02f, -1.38902832e-02f, -2.31824443e-02f, -1.11032262e-01f, 6.63827825e-03f,
  2.74942466e-03f, 2.90600886e-03f, -1.27152372e-02f, 1.04637876e-01f, -5.18299267e-02f, 3.54089215e-02f, 1.38231982e-02f, 2.32755095e-02f, -8.98968603e-04f, -3.32950540e-02f,
  -1.02613166e-01f, 1.80534691e-01f, -1.39272675e-01f, 1.16446719e-01f, -4.03001457e-02f, 2.19600070e-02f, -9.57631990e-02f, -2.57306099e-02f, -2.75224485e-02f, 3.03021576e-02f,
  8.30436423e-02f, 1.59181491e-01f, -2.05838773e-02f, 1.26109282e-02f, 1.13165550e-01f, 8.23806413e-03f, -1.15331836e-01f, 1.28186136e-01f, 3.72051038e-02f, -1.22599892e-01f,
  -3.56206521e-02f, -9.54088941e-03f, -8.29729736e-02f, 2.44337209e-02f, -1.08222570e-02f, 4.89034131e-02f, 1.22668378e-01f, 4.21438292e-02f, 1.11349948e-01f, 5.46531118e-02f,
  -8.84769499e-01f, -8.09468105e-02f, 8.79685134e-02f, -1.74240708e-01f, 9.48694441e-03f, 5.95865808e-02f, -5.94525635e-02f, -1.78556800e-01f, -8.53846595e-02f, -1.17778204e-01f,
  7.73884133e-02f, 2.09284082e-01f, 9.80518162e-02f, 1.74432665e-01f, -1.82062667e-03f, -2.94931177e-02f, -4.68518734e-02f, -1.01153411e-01f, 1.01052232e-01f, 4.02001590e-02f,
  1.32584065e-01f, -1.91857532e-01f, -2.59161383e-01f, -3.04908454e-02f, -7.42017254e-02f, 1.27514988e-01f, 2.60228029e-04f, -1.98575795e-01f, 8.03885683e-02f, -6.44798502e-02f,
  4.57603857e-02f, -2.32927710e-01f, 2.58996636e-01f, -4.60551493e-03f, 5.73717691e-02f, -4.75364812e-02f, 5.46568185e-02f, -8.34706426e-02f, -1.50171584e-02f, -1.52076492e-02f,
  -4.39113239e-03f, -1.63068026e-02f, 6.68270811e-02f, 3.81394364e-02f, -7.13811517e-02f, -6.31233603e-02f, -7.03470185e-02f, -1.44169733e-01f, 1.17838141e-02f, 5.84089719e-02f,
  4.15990129e-02f, 9.61876214e-02f, -9.27477628e-02f, 4.43127863e-02f, 1.13408320e-01f, 4.75415178e-02f, 2.81201042e-02f, -3.45026702e-02f, 2.88440231e-02f, -2.51721710e-01f,
  3.57144512e-02f, 1.78101920e-02f, 3.84184234e-02f, -6.71362579e-02f, 1.22058652e-02f, -4.08437522e-03f, -2.77261585e-02f, -4.42558341e-02f, 4.16940860e-02f, -5.28522469e-02f,
  5.73142283e-02f, -3.11798765e-03f, 1.28267212e-02f, -8.98497328e-02f, 6.26168475e-02f, -8.63036588e-02f, 2.16432661e-03f, -2.87781004e-03f, 4.05946150e-02f, -2.48973239e-02f,
  -1.69940069e-02f, 4.18430455e-02f, -6.35383949e-02f, 1.84334852e-02f, 8.85701925e-02f, -3.16974595e-02f, 8.63602199e-03f, 2.93666814e-02f, -5.26549928e-02f, -5.83224650e-03f,
  -1.06850125e-01f, 1.25422850e-01f, -8.16806555e-02f, 1.87011231e-02f, -2.67493688e-02f, 3.65870707e-02f, -5.90290129e-03f, 3.85256372e-02f, 6.81273639e-02f, -4.95672561e-02f,
  -7.34161818e-03f, -5.67074716e-02f, -6.11258447e-02f, 5.03804302e-04f, -5.05760461e-02f, 5.86173870e-02f, 8.33731238e-03f, 3.86690497e-02f, 6.47175387e-02f, -4.34698276e-02f,
  6.42085895e-02f, -1.24356747e-01f, -5.18014878e-02f, 3.38869691e-02f, -2.67167725e-02f, 1.33740706e-02f, -4.42125835e-04f, -4.95048985e-02f, 9.10944045e-02f, -2.66532332e-01f,
  -3.28392625e-01f, 2.16913894e-01f, 8.13418925e-02f, 1.33369252e-01f, 6.68340102e-02f, 5.22868522e-02f, 7.23723993e-02f, -4.33952324e-02f, 8.51945058e-02f, 1.75082982e-01f,
  2.55795419e-02f, -4.60771583e-02f, -4.60439250e-02f, -9.56891179e-02f, -2.33354822e-01f, 3.92159224e-02f, 2.45248377e-02f, -1.95567027e-01f, -3.48610669e-01f, -7.63791576e-02f,
  1.62212960e-02f, 2.21988708e-02f, -1.06719151e-01f, 3.79118361e-02f, 2.56435305e-01f, -7.10364431e-02f, 1.05817117e-01f, 1.92355186e-01f, 1.27071097e-01f, 2.79912233e-01f,
  -8.46723244e-02f, 6.31153658e-02f, -7.12405518e-02f, 3.35939042e-02f, 5.40727302e-02f, -4.38774750e-02f, -5.84607273e-02f, 6.34188429e-02f, -7.49276485e-03f, 1.04327120e-01f,
  1.75247453e-02f, 9.88718402e-03f, 6.01144955e-02f, -4.21754606e-02f, -3.72582935e-02f, -3.98164466e-02f, 1.30479783e-01f, -7.14612678e-02f, -7.67029971e-02f, 1.50493602e-03f,
  8.35622251e-02f, 1.55881688e-01f, -7.87457079e-02f, 4.18590307e-02f, -1.36796340e-01f, -6.61913678e-02f, 9.08958837e-02f, 1.27510773e-02f, 3.19368653e-02f, 1.62979111e-01f,
  -2.01477185e-02f, 6.79442361e-02f, 3.00722178e-02f, 1.67666655e-02f, -7.74023458e-02f, 5.07266708e-02f, 2.41035316e-02f, 3.05433441e-02f, 3.01411022e-02f, -1.79097038e-02f,
  1.94198377e-02f, -9.28081106e-03f, -7.66208163e-03f, 2.36930270e-02f, 2.03778427e-02f, 5.33709396e-03f, -5.15227159e-03f, 3.97724658e-02f, 1.73701923e-02f, -7.09168389e-02f,
  -7.72537291e-03f, -1.30033614e-02f, 2.99681677e-03f, 9.05727677e-04f, 1.35291945e-02f, -3.00301425e-03f, -4.30575646e-02f, -5.55386208e-03f, 3.27068046e-02f, 4.51017432e-02f,
  -1.78904995e-01f, -4.59322706e-02f, -3.51391882e-02f, -1.10262394e-01f, -3.12551185e-02f, 2.10415125e-02f, 3.87850478e-02f, 9.17175487e-02f, 2.53170151e-02f, -5.70326783e-02f,
  -2.33654864e-02f, -3.42403650e-02f, -1.55014126e-02f, 4.57989499e-02f, 2.00554803e-02f, -6.78589335e-03f, 2.21060254e-02f, -7.98938200e-02f, -2.50442028e-02f, -2.39131432e-02f,
  9.42454673e-03f, -1.61626622e-01f, -2.50933498e-01f, -8.31733495e-02f, -6.76278993e-02f, -2.75524497e-01f, -8.72396082e-02f, -1.07866608e-01f, -2.69043654e-01f, -2.03366727e-01f,
  1.41756490e-01f, -1.37113184e-01f, 1.22723714e-01f, 1.49844870e-01f, -6.40879720e-02f, -2.79997051e-01f, -4.36047018e-01f, -2.20757529e-01f, 9.22829937e-03f, -1.15890257e-01f,
  -1.34081870e-01f, 5.01569137e-02f, -3.11698392e-03f, 7.98074901e-02f, 6.23581633e-02f, -1.25032663e-01f, 7.60621279e-02f, 2.36494243e-01f, -6.62552267e-02f, -1.70799211e-01f,
  -6.91406727e-02f, 1.13974191e-01f, 2.22638130e-01f, 1.56885296e-01f, 1.41862467e-01f, -8.45390037e-02f, -2.17789914e-02f, 1.22631133e-01f, -1.45382658e-01f, 1.97620735e-01f,
  -7.84563571e-02f, 1.10450186e-01f, -3.35061215e-02f, 3.59956361e-02f, -1.76325049e-02f, 1.28995525e-02f, -1.04056925e-01f, 1.32087409e-01f, 7.76651176e-03f, -3.52817192e-03f,
  6.65949062e-02f, 1.05238125e-01f, 1.99903324e-02f, 1.01331420e-01f, 2.54230984e-02f, -2.59261895e-02f, 1.18403934e-01f, 2.33350068e-01f, 5.09011783e-02f, 1.05987824e-02f,
  -1.92262121e-02f, 3.11511103e-02f, -5.28765731e-02f, -6.19051345e-02f, 2.90644951e-02f, 7.40635907e-03f, -6.78764656e-02f, 1.35101095e-01f, -7.02991635e-02f, 4.43852954e-02f,
  -1.28876260e-02f, 2.56383922e-02f, 1.67262163e-02f, 1.35293312e-03f, -1.25828907e-01f, -6.36594519e-02f, 6.08442426e-02f, -6.00631759e-02f, -9.14387312e-03f, -6.90624788e-02f,
  -5.81228314e-03f, -4.06642929e-02f, -1.04924217e-02f, 1.30110122e-02f, -2.72361003e-03f, -1.40585639e-02f, 5.65646812e-02f, -2.70707794e-02f, -1.63772702e-02f, 6.61947802e-02f,
  4.66046706e-02f, -4.93079200e-02f, 1.13189342e-02f, 5.70852533e-02f, 3.51870619e-02f, 6.00546636e-02f, 2.15691747e-03f, 4.25279373e-03f, -6.01585619e-02f, -2.68150750e-03f,
  -1.17886281e-02f, -2.30397913e-03f, 3.14088278e-02f, 2.63072457e-02f, 1.32504240e-01f, 7.76687413e-02f, 8.38306081e-03f, -2.41881907e-02f, 1.07039042e-01f, 1.80807393e-02f,
  -6.02166690e-02f, -9.22205485e-03f, 3.07669938e-02f, 1.36438953e-02f, -5.43223284e-02f, -1.26572415e-01f, 6.91827293e-03f, 2.55202735e-03f, -1.08555770e-02f, 8.79873335e-02f,
  -8.89134929e-02f, -1.05299503e-01f, -1.53339222e-01f, -9.07100439e-02f, -9.04984474e-02f, -1.61499649e-01f, -2.16979325e-01f, -1.38503432e-01f, -1.32659197e-01f, -3.46627831e-01f,
  -6.88892186e-01f, 3.64571840e-01f, 4.53814000e-01f, -2.46660084e-01f, 2.08152637e-01f, 3.66917133e-01f, 7.77963400e-01f, 1.07974902e-01f, -2.09162325e-01f, 1.72889560e-01f,
  7.94606954e-02f, -3.19303960e-01f, -9.38195884e-02f, 4.03947458e-02f, 1.44337222e-01f, 5.44457793e-01f, 2.84760445e-01f, 3.25347856e-02f, -1.49716705e-01f, -5.95868677e-02f,
  3.00789773e-02f, -2.11841211e-01f, -3.49868149e-01f, -7.19514564e-02f, 4.01885957e-02f, -1.21234678e-01f, 1.12393968e-01f, -5.60805686e-02f, 1.50513887e-01f, -1.84169173e-01f,
  1.98105589e-01f, -3.63213159e-02f, -6.66536856e-03f, -9.36579630e-02f, 2.89276261e-02f, -4.75694574e-02f, -1.66755859e-02f, -1.01342564e-04f, -3.43123823e-02f, 8.49599484e-04f,
  7.10834144e-03f, -3.52836251e-02f, -7.67587870e-02f, -9.02514607e-02f, 2.09683590e-02f, -4.65452932e-02f, -7.37166628e-02f, -2.18675714e-02f, 8.33741874e-02f, 1.24118112e-01f,
  6.40400276e-02f, 8.84061158e-02f, 8.90337825e-02f, 1.04868442e-01f, 1.80589318e-01f, -1.29006118e-01f, 7.35644624e-02f, -5.71411140e-02f, 2.70281173e-02f, -6.01794384e-02f,
  2.09227409e-02f, -1.00030359e-02f, 2.08026133e-02f, -1.90604106e-02f, -4.89267148e-03f, -3.02942703e-04f, 1.25174159e-02f, 3.43284458e-02f, -3.99899520e-02f, -4.35128510e-02f,
  -3.76907410e-03f, -1.92963853e-02f, -6.91205561e-02f, -1.32130906e-02f, -2.93340348e-02f, -1.71918906e-02f, 2.21962365e-03f, 2.03267261e-02f, -5.88256083e-02f, -3.27175558e-02f,
  3.05047389e-02f, 2.43515279e-02f, 4.34163027e-02f, 1.06878509e-03f, 6.49840161e-02f, -2.42209993e-02f, -1.21504441e-02f, -2.72260979e-02f, -8.09797496e-02f, -6.50310218e-02f,
  -1.31481990e-01f, 9.75873023e-02f, 3.21476869e-02f, -2.59103207e-03f, -2.27799416e-02f, -2.36591063e-02f, -2.47850530e-02f, -2.43120305e-02f, -4.25047129e-02f, 5.32417148e-02f,
  -2.60072518e-02f, -3.46627943e-02f, 4.83128652e-02f, -1.70290582e-02f, -3.37183103e-02f, -5.63297458e-02f, 9.10012797e-02f, -2.55427379e-02f, -4.41899151e-03f, -2.65981257e-02f,
  1.17586598e-01f, 2.20156256e-02f, -4.24045697e-02f, 1.41607031e-01f, -1.24463122e-02f, 2.30549313e-02f, 1.23121865e-01f, 4.42679450e-02f, 1.47275865e-01f, 2.09619239e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.56572159e-02f, -4.92227748e-02f, 9.75345671e-02f, 1.05062813e-01f, 2.01579407e-01f, 1.50413945e-01f, 1.77152470e-01f, 5.08186817e-02f, 7.25886524e-02f, 9.15272683e-02f,
  7.08122477e-02f, -6.88953996e-02f, -1.32629976e-01f, -1.41862659e-02f, -3.89173031e-02f, 5.48900329e-02f, 2.99305306e-03f, 1.84947229e-03f, 3.69399861e-02f, 2.79428866e-02f,
  -3.23482184e-03f, -4.02919278e-02f, 3.40548418e-02f, -4.70447354e-02f, 4.53542210e-02f, 3.08622196e-02f, 5.44587821e-02f, -1.29588898e-02f, -6.69606403e-02f, -1.30082279e-01f,
  -1.73763618e-01f, 1.29114091e-01f, 3.30723971e-02f, 1.52236093e-02f, 4.10241890e-04f, -1.12864776e-02f, 1.32323811e-02f, -3.20347324e-02f, -4.16252315e-02f, -9.09288824e-02f,
  2.34505301e-03f, -2.02867426e-02f, -2.51539145e-02f, -4.58329283e-02f, -3.62879261e-02f, -1.24333408e-02f, -1.15620822e-01f, -3.63528100e-03f, 2.43550129e-02f, -8.94539431e-02f,
  2.14721467e-02f, -3.16501781e-02f, 1.34980187e-01f, -2.41948590e-02f, -1.70814898e-02f, -5.04439324e-02f, -4.46464717e-02f, -2.20815260e-02f, 9.03771371e-02f, 2.78021153e-02f,
  -4.47609574e-02f, 3.58675830e-02f, 9.64909643e-02f, 1.15033323e-02f, 2.16026790e-03f, 6.81953505e-02f, 5.27173318e-02f, -5.77724213e-03f, 8.54168758e-02f, -2.79291421e-02f,
  -1.43886423e-02f, 8.00156519e-02f, 5.97405434e-02f, 2.03658417e-02f, -6.24704622e-02f, -2.84164697e-02f, 1.18095325e-02f, -2.12486796e-02f, 3.67444754e-02f, -2.19665896e-02f,
  -6.34389818e-02f, 5.71990386e-02f, -4.75682020e-02f, -8.33670348e-02f, -3.31144482e-02f, -8.62749889e-02f, 5.12911417e-02f, -5.58208674e-02f, -1.13903955e-02f, -5.98940849e-02f,
  -9.01695415e-02f, 6.49354458e-02f, -2.85955276e-02f, -3.07219848e-03f, 2.19553038e-02f, -9.42192525e-02f, -3.22764963e-02f, -7.95789436e-02f, 1.13661669e-01f, 2.39854604e-02f,
  -6.42265975e-02f, -3.56835201e-02f, 1.05894068e-02f, 2.68200543e-02f, -6.81570917e-02f, 1.54880052e-02f, 1.44129219e-02f, 1.91945191e-02f, -9.38069522e-02f, 6.41649291e-02f,
  -5.92553765e-02f, 1.10174946e-01f, 8.96601602e-02f, -2.52610836e-02f, -6.34522364e-02f, -5.52491248e-02f, 6.44494072e-02f, -3.20274681e-02f, 2.93497778e-02f, 1.89581921e-03f,
  2.42364138e-01f, -5.37601970e-02f, 4.27371375e-02f, -1.27134427e-01f, 3.37361428e-03f, 6.05639480e-02f, 4.00136150e-02f, 3.90041880e-02f, -9.84383747e-02f, 8.48838910e-02f,
  -1.62770838e-01f, -1.03560589e-01f, 5.68796471e-02f, -1.06038544e-02f, -1.19725149e-02f, -1.81640079e-03f, 1.33709148e-01f, 5.39225452e-02f, 1.58092171e-01f, 1.10928090e-02f,
  -1.01191625e-01f, 1.00780942e-01f, 5.99588938e-02f, -2.26769131e-02f, -1.20785877e-01f, 3.85188451e-03f, -1.11641608e-01f, -1.69962347e-01f, -1.97775155e-01f, -7.50920400e-02f,
  7.83045739e-02f, -2.69452363e-01f, 1.36270244e-02f, -8.02606996e-03f, -3.33297998e-02f, -6.43228441e-02f, 9.56818685e-02f, 1.94027442e-02f, -1.31461367e-01f, -5.11139929e-02f,
  -4.38642800e-02f, -1.15170114e-01f, -6.08927645e-02f, -1.23588927e-03f, 3.11671272e-02f, 2.64312159e-02f, -7.40111014e-03f, -8.98775086e-02f, -1.74615756e-01f, -8.70506652e-03f,
  -1.32518575e-01f, -1.20737419e-01f, -1.10102154e-03f, -2.80625448e-02f, -1.56898379e-01f, -1.16089964e-02f, -1.19866431e-01f, -1.25713781e-01f, -1.51581392e-01f, 8.98912773e-02f,
  9.49995816e-02f, -5.50651865e-04f, -3.98183502e-02f, 3.93092148e-02f, -4.68231738e-02f, 2.72358656e-02f, -3.61088738e-02f, -6.32479489e-02f, 1.16929889e-01f, 1.34190083e-01f,
  -7.66384751e-02f, -4.32683229e-02f, -4.24370952e-02f, 1.95684340e-02f, 2.51928233e-02f, -7.42463255e-03f, 4.75539081e-02f, 3.71664539e-02f, -5.77197783e-02f, 3.08650844e-02f,
  8.19635689e-02f, 5.66896051e-02f, 1.94891244e-02f, 3.42000239e-02f, -6.85534328e-02f, -2.92490181e-02f, 4.82073128e-02f, -1.10135458e-01f, -1.26006026e-02f, 4.82146777e-02f,
  2.55861253e-01f, -1.75957978e-01f, 2.45636240e-01f, 4.60375361e-02f, -1.15799373e-02f, -1.57966167e-02f, -7.33796880e-03f, 2.32876576e-02f, 5.22804335e-02f, 1.22948185e-01f,
  -1.30663961e-01f, 1.12077333e-01f, 8.89335107e-03f, 2.47268770e-02f, 8.27761516e-02f, -4.07161489e-02f, 4.36194427e-02f, -8.63688532e-04f, 5.10268193e-03f, -9.56143811e-02f,
  -2.16066707e-02f, 1.43951371e-01f, 2.87551761e-01f, 1.11163288e-01f, -8.64184201e-02f, 1.62530959e-01f, 1.08449325e-01f, 1.49854749e-01f, 1.38627842e-01f, 3.73191983e-01f,
  -1.31591454e-01f, 1.00959474e-02f, 2.11886577e-02f, 1.99107826e-01f, 8.61256793e-02f, -2.00046986e-01f, -2.65208513e-01f, -1.01895891e-01f, -6.73948675e-02f, -6.59003630e-02f,
  4.09713835e-02f, 3.60337235e-02f, 4.87270765e-02f, 4.76832762e-02f, -1.29376590e-01f, -3.61289009e-02f, 1.44460276e-01f, 3.38819884e-02f, 1.49803376e-02f, -9.26992744e-02f,
  8.96792188e-02f, 1.65638968e-01f, 7.31550306e-02f, 6.16263188e-02f, 1.76529631e-01f, 2.00513601e-01f, 4.78652827e-02f, 7.07587227e-02f, 1.71974972e-02f, 3.85962874e-01f,
  4.85795327e-02f, -2.12586805e-01f, -2.07136460e-02f, -3.94553430e-02f, 4.06580307e-02f, -2.60289162e-02f, -4.36620861e-02f, 4.72871400e-02f, -6.88440502e-02f, -3.05035394e-02f,
  1.13035545e-01f, 1.88629124e-02f, 5.52656092e-02f, 8.84615928e-02f, -5.04516810e-02f, -1.01865821e-01f, -8.14931020e-02f, 2.55795922e-02f, -1.04167864e-01f, -1.18363798e-01f,
  1.36157632e-01f, -3.24298888e-02f, -1.91436887e-01f, -4.65311147e-02f, -9.62587819e-02f, -4.36148047e-02f, 2.87503134e-02f, -2.73016803e-02f, -1.22007601e-01f, 4.99412231e-02f,
  4.20945212e-02f, -5.66911511e-02f, -6.39038980e-02f, 4.61001284e-02f, 3.14247645e-02f, 3.74049805e-02f, 2.61703227e-02f, 6.24658773e-03f, 2.79362109e-02f, 3.38584036e-02f,
  -6.11548163e-02f, -3.18181925e-02f, 3.29678580e-02f, -8.57228339e-02f, 6.93582892e-02f, 2.36760583e-02f, -9.68692526e-02f, -6.74293637e-02f, 2.65082461e-03f, -3.97166994e-04f,
  2.60075461e-02f, -5.57526872e-02f, 8.60101804e-02f, -2.65862811e-02f, 6.33913726e-02f, 3.91703285e-02f, 3.52352043e-04f, -7.94997886e-02f, -3.28317396e-02f, -8.81522428e-03f,
  -3.98984030e-02f, -1.15249582e-01f, -5.14457040e-02f, -7.00169848e-03f, -4.51804549e-02f, 6.41855001e-02f, 2.51565613e-02f, 2.94115730e-02f, -2.39620376e-02f, -8.51505101e-02f,
  -1.03156023e-01f, -7.16431811e-02f, -3.77636142e-02f, -7.13038146e-02f, -9.50702205e-02f, -8.63067135e-02f, 3.78965251e-02f, -1.26762979e-03f, -1.17963450e-02f, -5.64991646e-02f,
  4.57634814e-02f, -9.46898162e-02f, -1.26708731e-01f, -9.51279104e-02f, -1.09279595e-01f, -8.00726563e-02f, -1.50072664e-01f, -1.20538957e-02f, -6.61286190e-02f, -1.64197370e-01f,
  1.47117479e-02f, 5.14966212e-02f, -2.33891711e-01f, -1.05126187e-01f, -8.06988552e-02f, 1.68516934e-01f, 1.61762968e-01f, 1.24585424e-02f, -4.27618884e-02f, 2.18791626e-02f,
  -5.65028377e-02f, -9.43621099e-02f, -8.12076181e-02f, -9.01399553e-02f, 3.76182259e-03f, -1.78812429e-01f, -9.75833759e-02f, -1.67722404e-01f, 1.62018482e-02f, 1.33000597e-01f,
  -7.64793605e-02f, -2.92338897e-02f, 4.40902077e-02f, -8.76528323e-02f, -1.44789532e-01f, -7.01753721e-02f, -2.02772856e-01f, -4.97188978e-02f, -1.19169513e-02f, -9.90882888e-02f,
  -2.92378426e-01f, 1.55025303e-01f, 7.00540915e-02f, -2.69383229e-02f, -1.16337417e-02f, 8.04565400e-02f, -3.90086658e-02f, -4.02078368e-02f, -7.71572068e-02f, 3.39463800e-02f,
  4.37741913e-02f, -3.96911614e-02f, -1.13296406e-02f, 5.31558543e-02f, 4.33658808e-02f, -6.27917573e-02f, -8.94645080e-02f, 3.13912854e-02f, -4.56275344e-02f, -2.89237369e-02f,
  -2.64727417e-02f, 1.86929945e-02f, 2.86045671e-02f, 1.28655165e-01f, 1.04556575e-01f, 3.69378440e-02f, 1.29494756e-01f, 1.11821316e-01f, 6.90062419e-02f, 2.35278886e-02f,
  6.02885820e-02f, 1.54485728e-03f, 3.54816541e-02f, -3.96167189e-02f, -3.68915908e-02f, -1.84382722e-02f, 1.10598374e-02f, 1.79414693e-02f, 8.29184651e-02f, 1.69542618e-04f,
  -3.73173319e-02f, -4.96944971e-02f, -3.87559608e-02f, -1.20013366e-02f, -9.96670797e-02f, -1.42164370e-02f, 8.52631554e-02f, -1.65756829e-02f, -8.70149769e-03f, 2.89952703e-04f,
  1.96702238e-02f, 8.26448575e-02f, -1.04422281e-02f, 1.47013494e-03f, 3.92154492e-02f, 3.76964323e-02f, 5.16471267e-02f, -4.19426486e-02f, 3.27769630e-02f, 1.58000477e-02f,
  -2.33375311e-01f, 1.46776900e-01f, -1.49649531e-01f, -1.89730525e-03f, -5.28895147e-02f, 1.80352665e-02f, -8.06928321e-04f, -9.65242162e-02f, -8.72731861e-03f, -3.46613787e-02f,
  7.80561641e-02f, -3.48067023e-02f, 6.00191429e-02f, -1.39231402e-02f, 3.73749845e-02f, 5.30403890e-02f, 5.10955825e-02f, 1.38552124e-02f, 1.55305564e-02f, 2.55692750e-02f,
  1.15568181e-02f, 9.52431466e-03f, 1.00973688e-01f, 8.71257577e-03f, -2.18287110e-02f, 5.87946996e-02f, 4.72253598e-02f, -4.26509157e-02f, 2.13032495e-02f, -1.26909703e-01f,
  -4.27040815e-01f, -8.78838599e-02f, -2.74879754e-01f, 2.14022421e-03f, 2.60861814e-01f, 9.01399329e-02f, -1.64458845e-02f, -1.22149020e-01f, 1.36158727e-02f, 4.90162298e-02f,
  9.41713005e-02f, 7.83578902e-02f, 6.59832060e-02f, -3.08756251e-02f, -6.78613186e-02f, -7.43045732e-02f, -3.24992426e-02f, -1.50333092e-01f, -1.27000302e-01f, 8.43706951e-02f,
  2.38266766e-01f, 6.23482093e-02f, -4.90692556e-02f, -7.53996447e-02f, 9.00559798e-02f, 7.08371252e-02f, 4.53400367e-04f, 4.27588187e-02f, 1.40745878e-01f, 2.31337339e-01f,
  -7.86140859e-02f, -2.00430632e-01f, 4.15032096e-02f, 9.64717418e-02f, 2.14601681e-02f, -8.83822739e-02f, -8.03707317e-02f, -6.28594309e-02f, 3.47339250e-02f, -5.38629517e-02f,
  1.54703180e-03f, -3.14993970e-02f, 8.00137520e-02f, -1.74106527e-02f, -8.00894350e-02f, -1.88685441e-03f, -1.01304941e-01f, -2.54180729e-01f, -2.38815784e-01f, -5.28010167e-02f,
  2.37995982e-01f, 6.96473643e-02f, -1.23482406e-01f, -1.99255005e-01f, -1.73611730e-01f, -3.25231887e-02f, -1.71701223e-01f, -1.42106056e-01f, -2.47894242e-01f, -1.09080657e-01f,
  1.80481281e-02f, -2.87174806e-02f, 1.00549674e-02f, -6.15115017e-02f, -1.17358845e-02f, 1.04016967e-01f, 1.25434563e-01f, 6.96653947e-02f, 1.02431364e-02f, -6.37503043e-02f,
  -1.24953990e-03f, -2.51452085e-02f, -1.68143082e-02f, 2.13499106e-02f, 1.86025389e-02f, 6.07899576e-02f, 5.98051846e-02f, -1.40295886e-02f, -1.59920994e-02f, 9.76919942e-03f,
  -1.10241184e-02f, -8.08536634e-02f, 3.85831892e-02f, -5.75290397e-02f, -4.17659022e-02f, -4.09164280e-02f, 1.74521934e-02f, -9.16640386e-02f, 6.88335812e-03f, -7.47342035e-02f,
  4.94626351e-02f, -1.10028088e-01f, -6.36314554e-03f, 3.67492214e-02f, 1.05155461e-01f, -9.86764729e-02f, 2.41089910e-02f, -1.12753622e-02f, 9.14984383e-03f, -9.20263976e-02f,
  1.23479320e-02f, -1.09098442e-02f, -5.82394302e-02f, 7.89607933e-04f, -4.32335958e-03f, -8.26723799e-02f, 7.41166121e-04f, -6.22066036e-02f, -3.20485570e-02f, -1.01634480e-01f,
  -1.15673319e-01f, -8.87378752e-02f, -1.65736288e-01f, -1.27836689e-01f, 5.70221525e-03f, -8.31091478e-02f, -1.08112723e-01f, -3.40207554e-02f, -2.18573272e-01f, -1.55850813e-01f,
  5.10299265e-01f, -1.80335730e-01f, 1.37860611e-01f, 5.72597049e-02f, -2.74577439e-01f, -3.32274765e-01f, -3.56383145e-01f, -1.48972750e-01f, 4.57091704e-02f, -1.83394700e-01f,
  -6.29652664e-02f, 9.31976736e-02f, 8.47293064e-02f, 2.17309356e-01f, 2.94696689e-01f, 1.58865638e-02f, 1.85235247e-01f, 3.14303875e-01f, 2.19796240e-01f, -2.06958484e-02f,
  -1.34823933e-01f, 7.99870938e-02f, 2.71379501e-01f, 6.99407086e-02f, -1.42599851e-01f, 2.81968303e-02f, -2.04012170e-02f, -5.97580895e-02f, -4.91432361e-02f, 1.74461111e-01f,
  -1.42725874e-02f, -5.77985756e-02f, 1.34115919e-01f, -6.93772361e-03f, -4.58396552e-03f, -2.77918875e-02f, -4.37923037e-02f, 7.18640983e-02f, -9.40131620e-02f, 1.77107137e-02f,
  -7.26297572e-02f, -4.52573895e-02f, 1.24429995e-02f, -6.79125404e-03f, -5.07868044e-02f, -5.79313710e-02f, 6.28155321e-02f, 2.08112448e-01f, 6.29456267e-02f, -7.08092526e-02f,
  -9.92227569e-02f, -1.38959154e-01f, -2.95077544e-02f, -4.35015038e-02f, -1.45830596e-02f, 8.00459608e-02f, -6.05914146e-02f, 2.77480315e-02f, 2.46378556e-02f, 5.58302319e-03f,
  7.13942721e-02f, 5.18466309e-02f, -8.03386327e-03f, 2.15791888e-03f, 1.83444265e-02f, 3.29332687e-02f, -7.71608353e-02f, 3.71965170e-02f, -2.70637497e-02f, 6.64644688e-02f,
  -4.13072743e-02f, 9.32016522e-02f, -5.84389269e-02f, 3.86833847e-02f, 3.86344045e-02f, -4.68315091e-03f, -1.14506911e-02f, 4.22708392e-02f, -1.83894020e-02f, 3.16731669e-02f,
  5.73257469e-02f, -2.30967421e-02f, -1.90778133e-02f, -1.19693717e-02f, -2.50294730e-02f, 4.58099619e-02f, -1.59033053e-02f, -1.43668111e-02f, 5.92898519e-04f, -6.17043376e-02f,
  -1.13747507e-01f, 1.93005905e-01f, 4.18758541e-02f, 1.19503357e-01f, 5.34205930e-03f, -8.00387114e-02f, -5.20547256e-02f, 1.79683417e-02f, -6.97674751e-02f, -4.79356200e-02f,
  -9.42050740e-02f, 1.52368154e-02f, -4.38714698e-02f, -3.24211605e-02f, 5.30144162e-02f, -4.46463749e-02f, -6.23909943e-02f, 2.61852685e-02f, 1.52546447e-02f, -1.46315545e-01f,
  -1.33081794e-01f, 5.32384515e-02f, 1.94004271e-02f, 4.63769920e-02f, 8.84289388e-03f, 1.02651641e-01f, -4.78653386e-02f, -1.27952984e-02f, 2.72880774e-02f, 1.00456979e-02f,
  3.33130002e-01f, 2.84105986e-01f, 2.21700042e-01f, -8.88917521e-02f, -1.27608508e-01f, 8.38795230e-02f, 2.49766603e-01f, 4.38040355e-03f, -8.99654776e-02f, -1.34502240e-02f,
  -8.25546011e-02f, -2.00099602e-01f, -2.85853177e-01f, -7.75923207e-02f, -2.16333987e-03f, 1.14260681e-01f, 1.33846715e-01f, 3.30331028e-02f, -1.53848246e-01f, -1.12789266e-01f,
  -7.19059631e-02f, -8.15340206e-02f, 8.64153802e-02f, 5.30918166e-02f, -8.85991827e-02f, -3.00232768e-01f, 6.41178191e-02f, 1.09292474e-02f, -8.96787457e-03f, 4.48481254e-02f,
  3.12324055e-02f, 2.74498880e-01f, -1.30735025e-01f, -4.35991511e-02f, -1.07004799e-01f, 1.64158959e-02f, -6.77310862e-03f, -3.62039506e-02f, -8.59243125e-02f, 2.60509625e-02f,
  -1.28808888e-02f, -3.28272656e-02f, -1.47864409e-03f, 3.01956636e-04f, -5.25741652e-03f, 2.15495508e-02f, -1.71148591e-02f, 7.25486130e-02f, -6.43368140e-02f, 8.53420570e-02f,
  -1.20027959e-01f, 4.49643172e-02f, 9.04383883e-02f, -2.48198882e-02f, -5.09286411e-02f, -1.09052405e-01f, 5.38037829e-02f, 3.18202600e-02f, -5.17365485e-02f, 6.16388954e-02f,
  4.07301597e-02f, 1.18167643e-02f, -9.10776332e-02f, -1.76083054e-02f, 5.86878061e-02f, -1.88987367e-02f, -1.53129008e-02f, -4.57809903e-02f, 3.09633799e-02f, 3.44594829e-02f,
  4.94044013e-02f, -2.56288536e-02f, -5.74777462e-02f, 5.80997765e-02f, 1.63918512e-03f, 4.18229476e-02f, -3.47526670e-02f, 5.50599657e-02f, -1.02091301e-02f, 6.19874336e-02f,
  -4.66697030e-02f, 5.88008314e-02f, -8.02282915e-02f, -7.90799111e-02f, 2.30279583e-02f, 7.19032139e-02f, -3.92049812e-02f, 5.63943014e-02f, -3.10135949e-02f, 4.49275319e-03f,
  -2.89724797e-01f, -1.35800853e-01f, -3.68942246e-02f, -3.97348739e-02f, -2.35866141e-02f, 2.43439004e-02f, -3.38693075e-02f, 8.26310553e-03f, -8.15466195e-02f, -6.01820229e-03f,
  2.97185080e-03f, 9.21389461e-03f, 3.20330448e-02f, 3.31840143e-02f, -9.58344117e-02f, 4.05187644e-02f, 1.78479739e-02f, -4.18049321e-02f, -5.35468869e-02f, -7.73405563e-03f,
  -6.11615255e-02f, 1.79301128e-02f, 1.12802275e-02f, -1.22204646e-02f, -2.19610054e-02f, -2.47101814e-01f, -2.63736807e-02f, -6.12976551e-02f, -2.80112699e-02f, -2.23445557e-02f,
  2.64050603e-01f, -6.21466674e-02f, 1.79796830e-01f, 2.28673920e-01f, 1.65306941e-01f, 1.26481429e-01f, 1.32454842e-01f, 1.58670083e-01f, 1.12150431e-01f, -8.64391681e-03f,
  -5.66391572e-02f, -1.39052168e-01f, -5.76558784e-02f, 5.61513677e-02f, 4.93104607e-02f, 1.46582201e-01f, 3.31018791e-02f, 1.33495703e-01f, 2.38221437e-01f, 9.19568166e-03f,
  -6.51020557e-02f, 6.54441044e-02f, 1.39077604e-01f, 1.05227374e-01f, -9.11200196e-02f, 5.76731898e-02f, -1.57737825e-02f, -6.26078025e-02f, -9.31122690e-04f, -3.91355902e-02f,
  -1.10852703e-01f, 1.36306241e-01f, -1.12467296e-02f, -6.58203587e-02f, -8.18872303e-02f, 7.81196356e-02f, -6.37786975e-03f, -1.24867275e-01f, -7.83019047e-03f, 4.87174839e-02f,
  -5.29851168e-02f, -8.50379989e-02f, -7.73527250e-02f, -1.00259662e-01f, -2.54663592e-03f, 2.98521109e-02f, -1.40038356e-02f, 8.34747627e-02f, 5.46728112e-02f, -1.19558722e-01f,
  -1.75940692e-01f, -4.00237627e-02f, 1.19815864e-01f, -1.57401077e-02f, -4.52555530e-02f, 2.20851842e-02f, 2.34557893e-02f, 6.19720761e-03f, 4.28870469e-02f, -5.81099615e-02f,
  3.65869217e-02f, 1.72488205e-02f, 9.19917524e-02f, -1.61486678e-02f, -1.83409336e-03f, -1.82631370e-02f, -7.18210707e-04f, -5.01798757e-04f, -3.16963159e-02f, 5.85573763e-02f,
  4.06027995e-02f, -2.67806500e-02f, 6.59911782e-02f, 7.58162588e-02f, -8.65793750e-02f, -5.79089187e-02f, -6.56709969e-02f, -8.40854943e-02f, 4.53303382e-02f, 5.05146384e-02f,
  4.43281904e-02f, 8.84482712e-02f, 4.62189354e-02f, -5.12703508e-02f, -1.03167035e-02f, 5.28102703e-02f, -6.01973049e-02f, -2.82290857e-02f, 4.38752957e-02f, -6.58668950e-02f,
  -1.75314575e-01f, -5.98805808e-02f, -3.31695238e-03f, 3.76641527e-02f, -5.76689839e-02f, -6.53618798e-02f, 1.23580918e-03f, -7.68384058e-03f, -6.93859905e-02f, -7.40341172e-02f,
  -6.91786706e-02f, -7.75281116e-02f, -1.11871716e-02f, -6.49310574e-02f, 6.93913922e-02f, 3.35592851e-02f, -6.03405386e-02f, 4.15279716e-03f, 1.54850418e-02f, -6.78574946e-03f,
  -7.38178492e-02f, 1.05016164e-01f, 4.23589256e-03f, 6.96420744e-02f, -6.67980360e-03f, 5.84848002e-02f, -7.24150911e-02f, 5.62822074e-02f, 6.57724813e-02f, 2.46794932e-02f,
  -1.69255316e-01f, 8.18204358e-02f, -6.03054404e-01f, 6.70448020e-02f, -2.04188988e-01f, -2.81095859e-02f, 5.85036259e-03f, 1.44668162e-01f, 8.27775896e-02f, -7.86669403e-02f,
  -1.06484026e-01f, -1.52128100e-01f, -1.53782323e-01f, -2.43999854e-01f, -2.58801430e-01f, -1.59066677e-01f, -4.22346354e-01f, -3.63020658e-01f, -3.86365950e-01f, -2.48395372e-02f,
  -3.58753279e-02f, -6.76826164e-02f, -1.18482888e-01f, 3.29791382e-02f, 7.88768977e-02f, 5.17339706e-02f, -6.16690069e-02f, -2.03075737e-01f, -1.66239500e-01f, -1.41980603e-01f,
  -3.62049222e-01f, -1.14568770e-01f, -1.08395807e-01f, 2.84831114e-02f, -8.70673656e-02f, -5.02269715e-02f, -4.35002968e-02f, -3.15095074e-02f, 4.82695512e-02f, -4.19029072e-02f,
  -1.27404541e-01f, 4.60039154e-02f, -7.57907405e-02f, 2.92163156e-02f, -3.40224206e-02f, -3.21577042e-02f, -3.68448086e-02f, -1.93006564e-02f, -1.16001219e-02f, 8.93690251e-03f,
  1.57647450e-02f, -1.48747355e-01f, -8.84068757e-02f, 6.53292388e-02f, 6.66457368e-03f, -1.43265754e-01f, 9.55782011e-02f, 1.66563570e-01f, -1.60625260e-02f, 1.47621363e-01f,
  5.48324585e-02f, 5.44388825e-03f, -8.04302543e-02f, 9.93668195e-03f, 6.83987662e-02f, -5.12744263e-02f, -2.34904862e-03f, -2.23960355e-03f, 8.20877925e-02f, -1.50112975e-02f,
  -2.41077952e-02f, 1.99368456e-03f, -1.64463352e-02f, 3.25785987e-02f, 9.80124716e-03f, -1.84659548e-02f, -5.25143109e-02f, -4.70241578e-03f, -5.38019128e-02f, -1.91432443e-02f,
  -6.80162758e-02f, -2.89771743e-02f, 3.26985717e-02f, 6.62872940e-02f, -6.96186274e-02f, 4.16323021e-02f, 2.08009705e-02f, 3.04885185e-03f, 5.94913810e-02f, -9.71816629e-02f,
  2.27451220e-01f, -3.30085695e-01f, -7.68839673e-04f, 5.33098318e-02f, -5.39633855e-02f, 3.59796546e-02f, -4.72896993e-02f, -2.45552398e-02f, -6.42197132e-02f, 4.26990017e-02f,
  1.29539063e-02f, 4.68864627e-02f, 2.41186190e-02f, 8.84115621e-02f, -5.14998622e-02f, -5.78336455e-02f, 1.19258963e-01f, -1.32207170e-01f, -7.16231987e-02f, 1.82423726e-01f,
  1.36072055e-01f, -3.57880108e-02f, -5.28628714e-02f, 7.97233954e-02f, -2.56860275e-02f, -1.93924412e-01f, 3.67022417e-02f, 3.90990749e-02f, -7.87887350e-02f, 2.08775595e-01f,
  -1.05632596e-01f, -3.06454636e-02f, -7.46751809e-03f, 2.93400642e-02f, 8.27538595e-02f, 1.63485646e-01f, -1.23493727e-02f, 1.47964507e-01f, 9.95286256e-02f, -2.14976594e-02f,
  4.39965390e-02f, 1.62698850e-01f, 1.32487178e-01f, 4.30985726e-02f, 6.95481449e-02f, 1.23239979e-01f, 2.17378125e-01f, 5.43519594e-02f, 7.09547251e-02f, 4.45449613e-02f,
  6.79357424e-02f, 2.75894022e-03f, -1.61336347e-01f, -3.14577408e-02f, 1.18554518e-01f, 2.34018326e-01f, 4.87564206e-02f, 7.08496720e-02f, 4.67393994e-02f, 1.32658646e-01f,
  -1.09535657e-01f, -2.26687208e-01f, 1.01903386e-01f, -5.10417484e-02f, -1.51015878e-01f, -2.54270732e-02f, -9.77260768e-02f, -4.18940820e-02f, -6.49704412e-02f, 6.15797155e-02f,
  -2.67630536e-02f, -1.23053834e-01f, -8.99379253e-02f, -4.18526083e-02f, -1.07469082e-01f, -6.41029254e-02f, -5.21955416e-02f, -3.11253965e-02f, 4.69379909e-02f, 3.60185429e-02f,
  1.00910328e-02f, 2.07244772e-02f, 4.89934124e-02f, -9.60206985e-03f, 1.12726927e-01f, 5.88259734e-02f, 5.60476780e-02f, 2.18526833e-02f, 3.20162885e-02f, -3.82246892e-03f,
  6.52917102e-02f, -3.62785868e-02f, -3.58836949e-02f, 3.75858648e-03f, 5.56982160e-02f, 9.49948095e-03f, 1.32559277e-02f, 1.15477778e-01f, 2.31232541e-03f, -6.98847547e-02f,
  -4.10163887e-02f, -2.32538525e-02f, -1.13605624e-02f, 2.73912530e-02f, -7.97256175e-03f, 5.60235679e-02f, -3.91948596e-03f, 5.22015020e-02f, 3.36824656e-02f, 6.83169439e-02f,
  -6.42410815e-02f, -3.50356363e-02f, 7.66325509e-03f, 6.70107603e-02f, -4.95369621e-02f, 1.73047297e-02f, 8.04101210e-03f, -1.02504725e-02f, -5.51123582e-02f, -6.56582490e-02f,
  -5.48483282e-02f, 3.35610695e-02f, 1.72503769e-01f, -4.77515087e-02f, -8.45910460e-02f, -7.63749033e-02f, 5.32257520e-02f, -6.51305243e-02f, -2.04232391e-02f, 2.35640537e-02f,
  1.56907737e-02f, 8.11375678e-02f, -7.59709552e-02f, -1.59283169e-02f, 1.08002883e-03f, -1.57370269e-02f, -1.04457131e-02f, 1.07092083e-01f, 5.35493866e-02f, 4.22420986e-02f,
  -5.37275337e-02f, 4.87292074e-02f, 4.46927175e-02f, 2.75092777e-02f, 1.21552907e-01f, 1.28471449e-01f, 3.03112734e-02f, 1.13260806e-01f, 2.48331930e-02f, -5.88536859e-02f,
  -1.05558045e-01f, 1.32404361e-02f, 4.39224467e-02f, 1.06339052e-01f, 8.93723890e-02f, 1.87233642e-01f, 8.30846056e-02f, 6.06942885e-02f, -5.06640077e-02f, 3.49855684e-02f,
  -2.03179285e-01f, -1.56792447e-01f, -1.26248971e-01f, -8.88595656e-02f, 4.44693267e-02f, 1.39430985e-01f, 1.21397294e-01f, -2.35533156e-02f, 1.89145263e-02f, -3.37815657e-02f,
  1.15050651e-01f, 9.72744301e-02f, -9.18283302e-04f, 1.09962495e-02f, 1.66442469e-02f, -5.80354184e-02f, 9.03753713e-02f, 1.26722474e-02f, 7.76723102e-02f, 4.58588526e-02f,
  -2.49299005e-01f, -1.96643561e-01f, -1.68622809e-03f, -1.16015702e-01f, -6.23333007e-02f, 9.98252910e-03f, -5.79451397e-02f, -9.61014330e-02f, -1.16194993e-01f, -7.90635496e-02f,
  5.02948323e-03f, -2.31755245e-02f, 4.10063454e-04f, 6.15039803e-02f, -2.75353584e-02f, 6.09154738e-02f, -3.86289507e-02f, 2.05391571e-02f, 3.61284204e-02f, -9.10305418e-03f,
  -2.39552110e-02f, -3.53932530e-02f, -4.86725941e-02f, -4.91009839e-02f, 3.58975455e-02f, -4.88360599e-02f, -1.13462739e-01f, -6.17597997e-02f, -9.99333784e-02f, -2.33063810e-02f,
  -3.06059774e-02f, -1.88515261e-02f, -4.98835146e-02f, -3.18673812e-02f, 4.99396846e-02f, -3.28618214e-02f, -8.92047398e-03f, -3.03553231e-02f, 6.67437017e-02f, 9.61275771e-02f,
  -2.98151504e-02f, -5.23841493e-02f, -1.18339553e-01f, -7.54945278e-02f, -4.83410358e-02f, 5.99709414e-02f, 2.42191330e-02f, 6.11459836e-02f, 5.26774712e-02f, -1.62426941e-02f,
  3.28908116e-02f, -2.19968334e-02f, -1.60873551e-02f, 7.81715736e-02f, -4.36112136e-02f, 1.17066227e-01f, -3.69526111e-02f, 3.95936593e-02f, -8.72869119e-02f, 1.29031157e-02f,
  -8.81672055e-02f, -2.45640893e-02f, -4.94642854e-02f, 6.08999208e-02f, 8.95637199e-02f, -5.52256964e-02f, -8.86630714e-02f, -2.20476426e-02f, -4.90515456e-02f, 3.24088708e-02f,
  -1.00965977e-01f, -4.48790081e-02f, -5.04947789e-02f, -7.79063925e-02f, 1.04505554e-01f, 2.73846611e-02f, -2.53027701e-03f, 9.10664797e-02f, -7.68096894e-02f, 7.96054490e-03f,
  5.22505678e-02f, 1.81280430e-02f, 7.24985376e-02f, 9.71699059e-02f, 3.19889858e-02f, 4.86832261e-02f, -1.69994067e-02f, 7.39419535e-02f, -6.54559210e-02f, -4.48490456e-02f,
  1.57921404e-01f, 2.61547212e-02f, -1.80617310e-02f, 7.70505890e-02f, 8.32281187e-02f, 3.96709219e-02f, -2.07624724e-03f, 1.16796076e-01f, 1.19296752e-01f, 4.48351726e-02f,
  4.43353318e-02f, 1.01408921e-01f, 1.21015519e-01f, 6.14371710e-02f, -1.67676192e-02f, 4.59399447e-02f, 5.07169217e-02f, -3.38365026e-02f, 2.45259628e-02f, 2.59766299e-02f,
  1.52489962e-02f, 1.00675724e-01f, 5.21026365e-03f, 9.96847376e-02f, -2.67059393e-02f, -3.82444821e-02f, -5.17435409e-02f, 3.57581594e-04f, -1.67562030e-02f, -2.78825080e-03f,
  3.53253931e-02f, 9.34361890e-02f, 2.92309187e-02f, 6.20649680e-02f, 9.01385471e-02f, 2.60270182e-02f, -2.63653398e-02f, 5.96445054e-02f, -2.75739748e-02f, 1.05585292e-01f,
  6.17191978e-02f, 3.36093903e-02f, 8.64955112e-02f, 6.52733147e-02f, -9.87352803e-03f, 3.57794799e-02f, 5.02979979e-02f, -8.98927916e-04f, 6.29758537e-02f, -2.32961308e-02f,
  1.83230359e-02f, 7.83568919e-02f, 5.53587750e-02f, 1.01369835e-01f, 7.88052157e-02f, 1.47751961e-02f, 6.72922730e-02f, 5.25030866e-02f, -4.95453738e-02f, 5.21252714e-02f,
  -4.36917730e-02f, -5.83877228e-02f, -6.14885874e-02f, 1.19395216e-03f, 1.42549034e-02f, 1.83712896e-02f, -3.86672691e-02f, 9.94783081e-03f, -8.11575726e-02f, -3.14820521e-02f,
  -8.21948610e-03f, -5.14344089e-02f, -2.85259318e-02f, 2.77559715e-03f, 9.13113728e-02f, 6.76310435e-02f, -3.46222557e-02f, -1.22517329e-02f, 4.08975072e-02f, -3.34328003e-02f,
  6.14239872e-02f, 8.72762725e-02f, -4.38505821e-02f, -4.88046817e-02f, 2.38724034e-02f, 4.20922711e-02f, -2.27192193e-02f, -6.35859817e-02f, 2.11560838e-02f, 7.45111257e-02f,
  -5.23794293e-02f, 7.16690645e-02f, 6.08613193e-02f, -5.71985394e-02f, 6.62070513e-02f, -6.99865445e-02f, -5.82082644e-02f, -2.17100140e-02f, 2.46301461e-02f, 4.11990136e-02f,
  -1.17545845e-02f, 1.03836708e-01f, -7.82209337e-02f, -2.81679295e-02f, 9.50996578e-02f, 5.78178056e-02f, -3.29808928e-02f, 9.96426493e-02f, 6.82551488e-02f, -1.28436564e-02f,
  5.23598045e-02f, -1.18499983e-03f, 4.45115454e-02f, 8.39165226e-02f, 8.18443485e-03f, -4.64118049e-02f, -1.68931447e-02f, -8.11279863e-02f, 3.86383161e-02f, 2.18181387e-02f,
  1.92436710e-01f, -1.61327884e-01f, -2.92408541e-02f, 5.60611673e-02f, 6.60560140e-03f, 4.26713973e-02f, 1.13671161e-01f, -4.75918837e-02f, 4.08062190e-02f, -1.13655463e-01f,
  3.19488049e-02f, 6.04831614e-02f, -1.62090436e-02f, -7.97321871e-02f, 4.46114987e-02f, -1.45413071e-01f, -6.27523735e-02f, 3.57232504e-02f, 2.59247553e-02f, 6.20670505e-02f,
  5.38501255e-02f, -4.81911749e-02f, 5.42920008e-02f, -5.30405901e-02f, -1.22883245e-01f, 2.02426650e-02f, -1.34497747e-01f, 1.01244198e-02f, -1.47926867e-01f, -1.37220189e-01f,
  -2.42150575e-01f, -3.42757180e-02f, -3.34813558e-02f, 3.39206457e-02f, -7.49883950e-02f, -5.07537536e-02f, -3.98917682e-02f, -4.23108377e-02f, 7.45513588e-02f, -1.18906632e-01f,
  -5.64322434e-02f, 1.05087245e-02f, -6.57334849e-02f, -3.75125594e-02f, -4.16650064e-02f, 4.37808447e-02f, 3.08479611e-02f, -1.08601563e-01f, 2.90485676e-02f, -4.53904085e-02f,
  -1.07715674e-01f, 1.02203652e-01f, 1.35785297e-01f, -9.38745290e-02f, -8.11690167e-02f, 3.54549214e-02f, -1.40538579e-02f, 3.42194252e-02f, -8.69180709e-02f, -9.92396995e-02f,
  -8.42510909e-02f, 1.32582383e-02f, 1.76722910e-02f, 6.71304241e-02f, -1.86778158e-02f, -4.66901846e-02f, 7.28859147e-03f, 1.00836098e-01f, 9.24708471e-02f, -7.21042454e-02f,
  -2.43717805e-02f, -1.88579503e-02f, -2.57450286e-02f, 3.15495320e-02f, -1.12625845e-02f, -3.74586992e-02f, 2.17713546e-02f, 6.88318163e-03f, 5.42104170e-02f, -1.32737644e-02f,
  -3.97424214e-02f, -5.28631695e-02f, -8.96233618e-02f, 5.50594963e-02f, -5.64282201e-02f, -7.09500983e-02f, 1.01785041e-01f, -4.80461717e-02f, 3.19521017e-02f, -2.90759355e-02f,
  -6.77841082e-02f, 7.46652707e-02f, 1.02178276e-01f, 8.26275796e-02f, 6.76667467e-02f, -5.01669869e-02f, -1.80600360e-02f, 8.62082243e-02f, -5.61073516e-03f, -6.41410658e-03f,
  -1.70495491e-02f, 1.24260038e-02f, 1.01638241e-02f, -7.29117319e-02f, 2.69132145e-02f, -7.83444848e-03f, 2.55132746e-02f, -3.11392918e-02f, -4.21449579e-02f, -6.79104626e-02f,
  -9.26107913e-02f, 2.65559331e-02f, 1.95887730e-01f, 1.17294744e-01f, 6.47980869e-02f, 8.07185397e-02f, 5.41860089e-02f, -1.69036780e-02f, 1.10722750e-01f, 4.77708057e-02f,
  -1.32823929e-01f, -1.42810926e-01f, 5.90695105e-02f, -3.65891717e-02f, -9.32865962e-02f, -2.36292243e-01f, -2.55286545e-01f, -1.75762221e-01f, -9.64199603e-02f, -1.78942114e-01f,
  -1.01978771e-01f, -6.54342100e-02f, 4.56989370e-02f, 1.01068215e-02f, 2.84929834e-02f, -7.52910078e-02f, -5.11886254e-02f, 1.83594003e-01f, 5.40100634e-02f, -1.13078758e-01f,
  -4.42203991e-02f, 1.11809947e-01f, 9.26331878e-02f, 8.90781730e-03f, -1.04974657e-01f, 1.91826131e-02f, 3.23222764e-02f, 7.84201026e-02f, -6.88200817e-02f, -6.57362714e-02f,
  4.31707449e-04f, -1.07923187e-01f, 5.82384355e-02f, -1.06245726e-01f, -3.36341523e-02f, -5.51508628e-02f, -1.10565290e-01f, 9.95496213e-02f, 9.75915883e-03f, 3.30046117e-02f,
  -9.29246321e-02f, 1.65827647e-02f, 3.12479287e-02f, -4.89170924e-02f, -6.18431438e-03f, 7.77832940e-02f, 2.74777971e-02f, 2.76194215e-02f, 7.50976130e-02f, -9.30887759e-02f,
  -4.04788405e-02f, -2.87647396e-02f, -3.06868907e-02f, -4.82511427e-03f, 1.86192188e-02f, 7.24371150e-02f, 1.00104898e-01f, -7.20270257e-03f, 1.38105661e-01f, -1.37559511e-02f,
  -6.56656846e-02f, 8.19077995e-03f, -3.00458372e-02f, -7.28935469e-03f, -6.64650872e-02f, 3.13641317e-02f, 1.62854064e-02f, -7.52654904e-03f, 4.47453419e-03f, 4.97705862e-02f,
  1.16737261e-01f, -2.47051213e-02f, -1.70386937e-02f, -3.52040157e-02f, 9.06513035e-02f, 1.73995725e-03f, -3.86222377e-02f, -8.11650325e-03f, 4.55726497e-02f, -1.24774752e-02f,
  -2.18047737e-03f, 6.94786310e-02f, 4.01573703e-02f, -3.52287255e-02f, -7.60536715e-02f, 5.01910523e-02f, 2.83948276e-02f, 5.75513802e-02f, -5.57407364e-02f, 6.84028044e-02f,
  1.06287636e-01f, 1.46152064e-01f, -9.12959278e-02f, -4.17190418e-02f, -6.90003783e-02f, -1.92481503e-02f, -1.13317147e-01f, 1.07439697e-01f, -6.25698566e-02f, -7.16546178e-02f,
  -3.86273563e-02f, -3.81852612e-02f, 6.46668971e-02f, 4.87766694e-03f, -3.35141793e-02f, -1.04235299e-02f, -9.26342234e-02f, 6.99722022e-02f, -5.19622751e-02f, -8.26645717e-02f,
  -4.44216840e-02f, -1.35569870e-01f, -9.19215083e-02f, -6.29607588e-02f, -1.65182073e-02f, -5.13397977e-02f, 7.61568397e-02f, -2.00859867e-02f, 9.58086774e-02f, -9.76940468e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.02077556e-02f, 2.93496430e-01f, 1.84756190e-01f, 2.13157743e-01f, 1.97001666e-01f, 4.94202644e-01f, 3.82590741e-01f, 2.56977320e-01f, 5.14377594e-01f, -9.56003144e-02f,
  8.88968185e-02f, -7.30482489e-02f, 2.04514652e-01f, 7.20419884e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.94477603e-01f, 1.01382382e-01f, -1.34314179e-01f, -4.11628306e-01f, 4.05884348e-02f, 2.05933630e-01f, -3.48408334e-02f, -7.04789907e-02f, -3.43977720e-01f, 1.89921614e-02f,
  1.25677809e-01f, -3.00873846e-01f, -3.32636870e-02f, -1.60240345e-02f, -6.17513321e-02f, 1.56983793e-01f, 4.16156143e-01f, -2.36527294e-01f, -4.63734334e-03f, -2.20582917e-01f,
  3.57759714e-01f, 1.13735594e-01f, 1.88621759e-01f, 1.08421117e-01f, -1.92524210e-01f, 6.01882748e-02f, -1.51008770e-01f, 2.54718900e-01f, 1.75155953e-01f, 1.01805903e-01f,
  5.46090156e-02f, 3.66751589e-02f, 2.26369694e-01f, -2.26181611e-01f, 1.02022760e-01f, -3.43938321e-02f, 2.12504968e-01f, -3.95515934e-02f, 2.15668142e-01f, -1.51426435e-01f,
  -2.13100106e-01f, 4.18644398e-01f, 3.44213367e-01f, 2.05441281e-01f, 1.49387911e-01f, -1.19954206e-01f, -8.06742534e-03f, 3.12963516e-01f, 4.97227222e-01f, -5.00111938e-01f,
  -2.97539651e-01f, -4.12677675e-01f, 4.68682908e-02f, 5.40352240e-02f, -8.26386958e-02f, 2.93448776e-01f, -1.76205814e-01f, -3.11030131e-02f, 2.25227848e-01f, 1.35115623e-01f,
  -2.98354685e-01f, -1.63574219e-01f, -8.53178725e-02f, 3.44451576e-01f, -4.08146456e-02f, -3.15450311e-01f, -3.50774765e-01f, -5.41611493e-01f, 2.53796309e-01f, -9.44873095e-02f,
  -1.61965013e-01f, 1.62607133e-02f, -1.72375649e-01f, 3.42239469e-01f, 4.76626009e-01f, 2.00335145e-01f, 4.33285385e-02f, 2.76989508e-02f, 4.83254671e-01f, 6.29037246e-02f,
  -1.63491458e-01f, 2.45542958e-01f, 7.29762986e-02f, -3.43901008e-01f, -2.71076232e-01f, 1.14684060e-01f, 9.84258279e-02f, -6.20725043e-02f, -3.56839113e-02f, 3.52096781e-02f,
  2.29214653e-01f, 3.81681370e-03f, -4.85615060e-02f, -1.26721412e-01f, 8.05142000e-02f, 6.81638643e-02f, 2.04792947e-01f, 3.73506814e-01f, 2.25166306e-02f, 1.68250501e-02f,
  1.11473173e-01f, 4.87410605e-01f, -9.95644256e-02f, -3.89769301e-02f, -1.89586207e-01f, -2.28686631e-01f, 6.01252681e-03f, 3.18175733e-01f, 3.13358188e-01f, -9.64345187e-02f,
  1.36322543e-01f, -1.04282647e-01f, 3.22426796e-01f, -5.37542224e-01f, -1.07440859e-01f, 6.10771105e-02f, 9.39510092e-02f, -1.31872684e-01f, -8.13330933e-02f, 2.57933021e-01f,
  -3.22847575e-01f, -1.45597398e-01f, 2.37167597e-01f, -2.44040117e-01f, -1.58221960e-01f, -1.56907737e-01f, -8.29083696e-02f, 3.34597677e-01f, -1.01235304e-02f, 8.38863552e-02f,
  1.82103589e-01f, 2.90776134e-01f, -3.22725594e-01f, 1.18187360e-01f, 1.31042600e-01f, 8.27744752e-02f, 1.11467503e-02f, 3.69797647e-01f, -1.55243993e-01f, 2.76911616e-01f,
  4.40409124e-01f, -5.38682520e-01f, -1.49315208e-01f, 2.85626799e-01f, 1.16482884e-01f, -5.48245609e-01f, -3.01492140e-02f, -2.28940055e-01f, 2.68277258e-01f, -2.03198865e-02f,
  1.95961908e-01f, 2.21699610e-01f, -3.02687228e-01f, -2.37304553e-01f, 2.04997301e-01f, -1.53359264e-01f, -2.55084544e-01f, 4.99875583e-02f, -2.50854015e-01f, -1.71660215e-01f,
  6.94531724e-02f, -1.65115163e-01f, 1.08452566e-01f, -6.99250698e-02f, 1.10276148e-01f, 3.53914261e-01f, 4.91808727e-02f, 1.24626562e-01f, -1.22044839e-01f, -3.11672956e-01f,
  2.76050061e-01f, 5.24278939e-01f, 1.84375852e-01f, -8.22302923e-02f, 6.45330727e-01f, -1.99168146e-01f, -9.87933390e-03f, -1.41839549e-01f, 8.52776319e-03f, -1.79245815e-01f,
  8.62510949e-02f, 1.18540786e-01f, 7.76689574e-02f, -2.02322111e-01f, -2.48126402e-01f, -2.04302132e-01f, 1.70675769e-01f, 6.31146878e-02f, 9.92521644e-02f, -2.71960467e-01f,
  1.00327753e-01f, 1.95908234e-01f, 7.89010376e-02f, 8.82113948e-02f, 1.03240408e-01f, 2.68575490e-01f, -2.10894421e-01f, 5.34421653e-02f, 1.07042268e-01f, -3.09312254e-01f,
  2.11963549e-01f, 3.25759128e-02f, -1.96232632e-01f, -1.48734331e-01f, -1.72872439e-01f, 8.15418586e-02f, -9.90549698e-02f, 1.83925077e-01f, 3.06193590e-01f, -6.28251880e-02f,
  -2.77273566e-01f, -1.84675649e-01f, 1.41558468e-01f, -2.80796617e-01f, 1.48457929e-01f, 8.70866701e-02f, 6.14764579e-02f, -2.74170011e-01f, -2.66597062e-01f, 1.40544977e-02f,
  5.29069789e-02f, -3.43857333e-02f, -2.39113003e-01f, 1.36462584e-01f, -1.53655052e-01f, 1.09302528e-01f, -1.28258780e-01f, -3.67793590e-02f, -6.12403229e-02f, -9.80788320e-02f,
  -2.32666269e-01f, -1.75105289e-01f, -7.59266093e-02f, 3.61576498e-01f, -1.44627884e-01f, -4.91866350e-01f, -4.87714231e-01f, 1.24473937e-01f, -2.81122506e-01f, 2.58752227e-01f,
  2.69479126e-01f, 3.27278972e-01f, 9.56337303e-02f, -1.29250333e-01f, 2.00307801e-01f, -3.86456959e-02f, 1.19484730e-01f, -2.26387545e-01f, 2.54656941e-01f, 1.39138922e-01f,
  -4.20109779e-01f, -2.26354405e-01f, 1.57817781e-01f, -8.17632899e-02f, 7.10038394e-02f, -2.04348415e-01f, -1.84481695e-01f, -2.75653988e-01f, -1.46457076e-01f, -2.72422612e-01f,
  1.99555576e-01f, 2.33784273e-01f, -5.77851422e-02f, 6.72800886e-03f, 2.26632934e-02f, -3.06196153e-01f, -1.54169515e-01f, 3.05286124e-02f, 4.48315114e-01f, 2.81653464e-01f,
  5.20353019e-01f, -6.34246469e-01f, -3.97707015e-01f, 4.26406264e-01f, -2.21406594e-02f, 2.67177641e-01f, -9.99200866e-02f, 1.36629432e-01f, 1.76882505e-01f, -3.44398260e-01f,
  -3.14313829e-01f, -2.68314499e-02f, 5.09249009e-02f, 2.96148837e-01f, 4.78613786e-02f, -1.65794846e-02f, 3.83284800e-02f, 3.48419361e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.82015800e-01f, -3.34379345e-01f, 1.84826374e-01f, 1.76550999e-01f, 2.47375831e-01f, 6.97545186e-02f, 4.39473361e-01f, 4.66764390e-01f, 1.28373817e-01f, 2.44307965e-01f,
  2.04672739e-01f, 3.16025168e-01f, 2.88905621e-01f, -4.29625481e-01f, 1.01262487e-01f, 3.32201898e-01f, -3.53238851e-01f, 2.43903339e-01f, 5.82092144e-02f, -2.10148484e-01f,
  1.27084747e-01f, 3.81439507e-01f, 5.90420783e-01f, -4.66380656e-01f, 2.28572607e-01f, -2.00701170e-02f, 1.08116770e+00f, -4.97798063e-02f, -2.67735776e-02f, -1.03541799e-02f,
  -9.46278945e-02f, -9.17173102e-02f, 1.49980381e-01f, 5.13704956e-01f, -9.08079594e-02f, 2.13862404e-01f, 4.26812083e-01f, 6.04051411e-01f, -2.98452079e-01f, 3.60237993e-02f,
  -1.37986600e-01f, -7.22764015e-01f, 2.60185391e-01f, 1.23066127e-01f, 1.38587654e-01f, 6.09680831e-01f, 6.34511471e-01f, -4.46160048e-01f, -2.00810611e-01f, 2.17736155e-01f,
  9.90000814e-02f, 4.73897964e-01f, 2.83543497e-01f, 4.93497103e-02f, 3.96363974e-01f, 4.75769401e-01f, -3.76248896e-01f, 2.27576107e-01f, -2.77044803e-01f, 3.34961951e-01f,
  1.98162496e-02f, -1.48906946e-01f, 2.27894619e-01f, 1.96082726e-01f, 1.44530162e-01f, 4.01276708e-01f, -2.51233056e-02f, 1.57463536e-01f, -1.02994919e-01f, 5.92658758e-01f,
  4.93441969e-02f, 2.98550606e-01f, 1.20765254e-01f, 2.60426104e-01f, -1.37391984e-01f, 8.64060149e-02f, 3.55457246e-01f, -5.84899068e-01f, -3.40877920e-01f, 8.55178237e-02f,
  4.30969805e-01f, -7.81198502e-01f, -1.69285219e-02f, -7.65526667e-02f, 3.38968009e-01f, -1.80683106e-01f, 1.81485161e-01f, 2.47750863e-01f, -1.04988649e-01f, 5.02404124e-02f,
  3.30013931e-01f, 9.54864025e-02f, -2.10940167e-01f, 6.52498752e-02f, 4.52362001e-03f, 1.75171662e-02f, -8.34052116e-02f, -7.32355267e-02f, 5.93234077e-02f, 3.29200849e-02f,
  2.30746642e-02f, -1.31062552e-01f, 9.37994942e-02f, -8.29023495e-02f, -8.68198574e-02f, -1.29962951e-01f, -1.14208058e-01f, 1.53782547e-01f, 5.93469068e-02f, -1.76900327e-01f,
  1.54023200e-01f, -2.38854121e-02f, 1.33192584e-01f, 6.88215569e-02f, -4.02339846e-02f, -4.05635796e-02f, -1.43544614e-01f, 7.16089606e-02f, -4.78323065e-02f, 8.18965584e-02f,
  -5.74649982e-02f, 1.62044972e-01f, -1.00980677e-01f, 3.98218296e-02f, 1.59002319e-01f, 1.15387410e-01f, -1.12968177e-01f, -1.75357401e-01f, 1.35101825e-01f, -1.15444750e-01f,
  6.43706545e-02f, 1.85615137e-01f, -5.22444583e-02f, -5.71356863e-02f, -3.26581784e-02f, -1.60644680e-01f, 1.29325926e-01f, 5.94393611e-02f, 8.83361772e-02f, -5.53070717e-02f,
  -1.82585806e-01f, 2.93402690e-02f, 1.02209657e-01f, 1.45576268e-01f, -2.07399070e-01f, 1.33279368e-01f, -5.97971724e-03f, -1.20526507e-01f, -6.99858069e-02f, -6.06564246e-02f,
  2.62602895e-01f, -9.46125910e-02f, -1.78852022e-01f, -2.13458296e-02f, 2.92992517e-02f, 2.25889862e-01f, 1.60619393e-01f, -5.98537698e-02f, -6.59835041e-02f, -1.55093804e-01f,
  3.58501166e-01f, 3.91221404e-01f, 5.80743253e-01f, 3.17050606e-01f, 7.77478814e-02f, 2.71754414e-01f, 5.14870644e-01f, -3.84327993e-02f, 6.12802207e-01f, -5.73915124e-01f,
  -6.96942627e-01f, -3.81321535e-02f, -1.72893688e-01f, 8.74338970e-02f, -6.34024084e-01f, -3.58206481e-01f, -2.18663901e-01f, -2.37888396e-01f, 5.29609881e-02f, 5.16493261e-01f,
  -6.65581599e-02f, -2.14137271e-01f, -3.24586302e-01f, 2.87440985e-01f, 2.56974488e-01f, 3.63755435e-01f, 3.07924062e-01f, -1.44226328e-01f, 1.77610129e-01f, -1.48141369e-01f,
  1.53362930e-01f, 1.63905263e-01f, -1.33214012e-01f, 3.42714757e-01f, -2.72816718e-01f, -4.20290917e-01f, 2.79415727e-01f, 1.85044497e-01f, -1.65926754e-01f, 5.04661262e-01f,
  8.95129964e-02f, 2.59800196e-01f, -9.25305411e-02f, 4.18613739e-02f, 3.03884268e-01f, 4.57590446e-02f, -6.21128738e-01f, -3.26375932e-01f, -2.33142395e-02f, -7.58356452e-02f,
  2.75206923e-01f, 7.39406273e-02f, -3.86088490e-02f, 3.47947121e-01f, -2.87079781e-01f, 5.86944401e-01f, 1.72924370e-01f, 5.08619905e-01f, -1.79501306e-02f, -2.54804920e-02f,
  -1.83624223e-01f, 2.11991966e-02f, 3.74257207e-01f, -3.50785591e-02f, 2.04018265e-01f, 1.28865495e-01f, 3.37449729e-01f, -6.42710552e-02f, 2.43872866e-01f, 1.09938934e-01f,
  6.65838718e-02f, -4.00743186e-02f, -1.14019424e-01f, 1.04693048e-01f, 6.16819747e-02f, -3.44588488e-01f, -5.19152701e-01f, -2.40674559e-02f, -1.28940746e-01f, 2.44465500e-01f,
  3.41848105e-01f, 2.41647691e-01f, 8.39255229e-02f, -1.34729773e-01f, 1.31258890e-01f, 1.00177899e-02f, 2.00487107e-01f, 2.06087410e-01f, 4.30868864e-01f, 3.91184241e-02f,
  -3.16913605e-01f, -1.70361340e-01f, 2.35192478e-01f, 4.81905043e-02f, 9.75898132e-02f, 1.68199331e-01f, -6.86641708e-02f, 5.51220700e-02f, -1.26449078e-01f, -1.49791002e-01f,
  -1.11374989e-01f, 2.27750577e-02f, -1.76165789e-01f, -1.46477595e-01f, -1.19310049e-02f, -2.93381456e-02f, 2.78218444e-02f, -1.73254967e-01f, 1.09994054e-01f, 1.59620896e-01f,
  -1.18613124e-01f, -7.39789009e-02f, -3.34800035e-02f, 4.60156016e-02f, -8.17324743e-02f, -8.97804946e-02f, -9.71898958e-02f, -1.45191327e-01f, 6.28315657e-02f, 1.44000962e-01f,
  4.31825370e-02f, -1.24342944e-02f, 6.54844567e-02f, 2.42800295e-01f, 1.05770893e-01f, 2.38855556e-01f, 1.75294921e-01f, -1.02027193e-01f, 3.35714477e-03f, 2.13703122e-02f,
  2.87373904e-02f, -4.74404275e-01f, 5.99460630e-03f, 2.56656468e-01f, 1.60802796e-01f, 1.42742693e-01f, -1.69351891e-01f, -8.20034593e-02f, -1.65072441e-01f, 3.36374529e-02f,
  4.94681567e-01f, -7.77385570e-03f, -1.56826988e-01f, -2.76302159e-01f, -5.70858736e-03f, -1.97966278e-01f, -1.06169775e-01f, 1.06148958e-01f, -9.13254246e-02f, 1.15354374e-01f,
  1.23130926e-03f, 2.52218515e-01f, 7.08053708e-02f, -2.56546196e-02f, 2.40515858e-01f, -1.31058112e-01f, -6.46151081e-02f, 4.90272865e-02f, 2.32276544e-01f, -1.28958642e-01f,
  -1.17243871e-01f, -1.49475615e-02f, -6.84652254e-02f, -7.67391771e-02f, -5.17723151e-02f, -1.22766905e-01f, 8.71572644e-02f, 7.97167644e-02f, 1.06239971e-02f, 9.95379686e-02f,
  -4.30563875e-02f, -7.71179944e-02f, 3.80928107e-02f, 9.86922160e-02f, -1.59526974e-01f, -9.12629589e-02f, 1.45317186e-02f, 2.09554713e-02f, -1.16118737e-01f, 2.83297375e-02f,
  -7.54362270e-02f, -1.79831684e-02f, -5.72286025e-02f, -6.19108975e-02f, -1.17628351e-01f, -1.22965857e-01f, -2.56017018e-02f, -1.09317444e-01f, 1.16556063e-01f, -8.09834059e-03f,
  1.00145731e-02f, -1.40126914e-01f, 4.49088931e-01f, 2.40719274e-01f, 1.07969806e-01f, 4.46859151e-01f, -5.87583594e-02f, -1.45503193e-01f, 1.18235126e-01f, -4.67728339e-02f,
  3.21562678e-01f, -2.77878523e-01f, 2.05116153e-01f, -3.82749438e-02f, -3.20302546e-01f, 2.93692406e-02f, -4.77275029e-02f, 4.57718790e-01f, 2.77843267e-01f, -2.29809731e-01f,
  -9.45707336e-02f, -4.27744947e-02f, 4.08107340e-01f, -2.17812493e-01f, 4.33245115e-03f, 3.69128227e-01f, 2.60004610e-01f, 1.28306359e-01f, -1.62953343e-02f, 1.22477971e-01f,
  2.78551608e-01f, -1.82484999e-01f, -1.22547761e-01f, 2.95198977e-01f, -6.75081983e-02f, -2.11240128e-01f, -1.18236199e-01f, 2.72412095e-02f, -1.54189598e-02f, -1.12774178e-01f,
  3.42556648e-02f, -1.46897659e-01f, -4.94606094e-03f, 1.04267858e-01f, 1.68965512e-03f, -1.09271228e-01f, -1.14496410e-01f, -1.27758577e-01f, -6.51189312e-02f, 9.82128084e-02f,
  -2.06757009e-01f, 4.46299603e-03f, -6.51733577e-02f, -6.29574712e-03f, 3.67624424e-02f, -1.78067312e-01f, -1.80882011e-02f, 8.06443468e-02f, 2.32738182e-02f, -9.01667178e-02f,
  9.61150005e-02f, 3.65888327e-02f, -9.17565227e-02f, -8.11324716e-02f, -7.18089715e-02f, 6.14817105e-02f, -1.67994238e-02f, 1.61859557e-01f, 9.60957482e-02f, -1.25320822e-01f,
  1.64724827e-01f, -5.09083532e-02f, 5.61424829e-02f, -1.25876918e-01f, -1.29841670e-01f, -3.91990282e-02f, -1.61975324e-01f, -1.92906901e-01f, -8.79796594e-02f, -1.07927121e-01f,
  9.09985974e-02f, -1.13214582e-01f, 4.20452766e-02f, 1.56562358e-01f, 1.51472732e-01f, 1.87459245e-01f, 3.87802541e-01f, -7.15092793e-02f, 5.62178791e-01f, -1.63253039e-01f,
  -2.29428932e-01f, -7.33821541e-02f, 2.56140262e-01f, 2.55577385e-01f, 1.74727097e-01f, -1.03009112e-01f, 1.69509724e-01f, -1.44181982e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.18055809e-01f, 2.14142188e-01f, 3.10534328e-01f, -1.61307573e-01f, 7.16350675e-02f, 1.21585585e-01f, 2.95278758e-01f, 3.89690459e-01f, 1.82349712e-01f, 7.91407004e-03f,
  2.06430163e-02f, 2.09272638e-01f, -1.70165032e-01f, 7.90456682e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.36777490e-01f, -5.95723867e-01f, -6.54894471e-01f, -1.74435422e-01f, 4.58505116e-02f, -5.75770438e-01f, -5.81973255e-01f, -2.97244787e-01f, 8.80991146e-02f, 4.50401127e-01f,
  1.22657456e-01f, 3.42145413e-01f, 3.01125944e-01f, 2.62573123e-01f, 1.60211697e-01f, -1.89999953e-01f, 2.76342053e-02f, 5.53646147e-01f, 6.46698952e-01f, -2.56678313e-02f,
  1.38309970e-01f, 1.32702198e-02f, 6.73118681e-02f, -6.27508402e-01f, 4.10232395e-02f, -9.94926840e-02f, -9.16095451e-02f, 4.64115173e-01f, 5.93487136e-02f, -6.69808626e-01f,
  -5.50659485e-02f, 1.23951785e-01f, 2.00188994e-01f, 5.87656558e-01f, 3.37602377e-01f, -4.87887233e-01f, 3.34594756e-01f, -1.51741430e-01f, -3.56460810e-01f, -7.40650967e-02f,
  2.70442456e-01f, -9.33864387e-04f, -2.99132794e-01f, -1.89420092e-03f, 7.64830858e-02f, 8.60581920e-02f, -1.34134591e-01f, -2.04140201e-01f, -2.91079253e-01f, 5.76671183e-01f,
  -7.12497354e-01f, 5.55227280e-01f, 2.88017064e-01f, 5.50800711e-02f, -1.91846028e-01f, -9.90843326e-02f, 1.02925813e+00f, -3.31612259e-01f, 1.58497747e-02f, 4.64833021e-01f,
  1.65899773e-03f, -4.46988851e-01f, 1.75811917e-01f, -3.31285805e-01f, 1.53032094e-01f, -2.99117982e-01f, -8.04926679e-02f, -6.38844907e-01f, 1.75807357e-01f, 2.30323017e-01f,
  -3.94661799e-02f, -3.86897437e-02f, 7.31560402e-03f, 3.32085639e-01f, 4.10683155e-01f, -3.17327529e-01f, 2.06396163e-01f, 3.83148581e-01f, 7.53236413e-01f, 3.36126000e-01f,
  -4.92603362e-01f, -6.41267240e-01f, -5.76081157e-01f, 5.39677203e-01f, -1.21036433e-02f, -3.81732844e-02f, -9.45838243e-02f, 3.00443679e-01f, -2.29794338e-01f, 2.26170719e-01f,
  9.98046845e-02f, -5.88433184e-02f, 1.06653944e-01f, 5.28400004e-01f, 1.25153109e-01f, -4.36449498e-01f, 1.68275520e-01f, 5.56881309e-01f, -3.02832155e-03f, 6.75019622e-01f,
  3.19921076e-01f, 2.22760495e-02f, -1.24697648e-01f, 5.29235601e-02f, 4.37464476e-01f, -3.84875566e-01f, 3.32916409e-01f, 6.18885636e-01f, -6.28252089e-01f, -2.84234807e-03f,
  4.01133895e-01f, -1.85410693e-01f, -5.55802166e-01f, 3.22275430e-01f, 8.69436741e-01f, -1.22580364e-01f, -6.35645151e-01f, 6.39083982e-02f, 1.82973474e-01f, -5.20031929e-01f,
  -1.15825608e-01f, -4.05102223e-02f, -7.54622743e-02f, -2.90347755e-01f, 1.59726948e-01f, -4.24724706e-02f, 6.24301881e-02f, -9.75897387e-02f, 2.68005222e-01f, -2.03556985e-01f,
  4.22299832e-01f, -5.88841997e-02f, -5.17244041e-01f, -2.06745505e-01f, 2.41013303e-01f, -3.70454222e-01f, 7.94892982e-02f, -9.88187864e-02f, 2.24896654e-01f, 5.12388349e-01f,
  2.26561576e-01f, 3.75705183e-01f, 3.59142035e-01f, -9.65611488e-02f, -4.86568302e-01f, -5.17253041e-01f, 5.68017721e-01f, -5.24406612e-01f, 7.00333834e-01f, -3.66912037e-02f,
  -8.90823826e-02f, -1.70525804e-01f, -3.36780071e-01f, -4.23182875e-01f, 1.67415097e-01f, -3.90091091e-01f, -1.50281996e-01f, 3.29021305e-01f, 9.80439186e-02f, -2.78417140e-01f,
  -8.79413038e-02f, 5.26471615e-01f, -1.39826104e-01f, 1.40915707e-01f, -7.65669793e-02f, 1.22576252e-01f, -1.38601556e-01f, -1.14203662e-01f, 2.85139620e-01f, -2.31877953e-01f,
  -4.32239503e-01f, -4.89713579e-01f, 1.02521464e-01f, 3.68542701e-01f, -7.30308816e-02f, 8.00535008e-02f, -9.51050669e-02f, 2.75445282e-01f, 2.36345544e-01f, -6.36057913e-01f,
  3.97141159e-01f, 3.89085710e-02f, -6.16911165e-02f, 9.58879054e-01f, 1.92565039e-01f, -4.45991665e-01f, 6.73120376e-03f, 3.74847829e-01f, -2.88561583e-02f, -2.37963527e-01f,
  4.00602631e-02f, 1.10136496e-03f, -6.81117252e-02f, -9.20432732e-02f, -3.15569103e-01f, 3.65582377e-01f, 3.41202497e-01f, -5.92628062e-01f, -1.55911088e-01f, 2.35252604e-01f,
  -6.35637224e-01f, 1.75674051e-01f, 3.01629275e-01f, -2.78315216e-01f, -2.23461971e-01f, 4.10763741e-01f, -7.31632829e-01f, 4.03710544e-01f, 6.31614208e-01f, -1.15075905e-03f,
  -8.62261891e-01f, -7.06233561e-01f, 1.31346822e-01f, 1.55995518e-01f, -9.49523225e-02f, 5.27212083e-01f, 2.01781601e-01f, 3.27936977e-01f, 4.43896838e-03f, -2.60112509e-02f,
  7.51385391e-02f, 6.21621251e-01f, -7.81385601e-02f, -2.22718120e-01f, -6.91480935e-01f, 2.40159720e-01f, -6.34433981e-03f, 5.54609783e-02f, 6.23915531e-02f, 3.61876965e-01f,
  7.74317002e-03f, 1.27292275e-01f, 1.78662777e-01f, 3.61986041e-01f, -5.06292880e-01f, 5.68041168e-02f, -3.81401688e-01f, -4.31922853e-01f, 4.16933745e-02f, 1.13482706e-01f,
  6.62468731e-01f, -7.82671273e-02f, -1.79744810e-01f, 7.75676489e-01f, -1.97715655e-01f, 1.83438823e-01f, 2.43356988e-01f, -7.28699088e-01f, -4.06595856e-01f, 3.25983495e-01f,
  7.72283599e-02f, -1.80959672e-01f, -1.12697043e-01f, 2.75783032e-01f, -1.28634930e-01f, 4.26384658e-01f, 2.47684568e-01f, -5.72563767e-01f, -4.67257023e-01f, 5.00490665e-02f,
  -6.89725041e-01f, -4.25402075e-02f, -5.30656688e-02f, 3.90802562e-01f, 1.19527817e-01f, -1.22214839e-01f, -3.65386844e-01f, -1.49098560e-01f, -5.98587751e-01f, -3.59370172e-01f,
  -6.15695536e-01f, -1.67107791e-01f, 3.00827503e-01f, 1.62923351e-01f, -4.99889791e-01f, 5.14102876e-01f, -6.61143899e-01f, -1.03885636e-01f, -1.12328447e-01f, 7.91625738e-01f,
  1.96778744e-01f, 1.35841727e-01f, 1.72003150e-01f, -2.17639193e-01f, -1.08524188e-01f, 4.91827205e-02f, -1.50280163e-01f, 5.74587174e-02f, -2.80271083e-01f, -1.70427188e-01f,
  -1.19544929e-02f, 8.23545307e-02f, -7.43973315e-01f, 6.61087155e-01f, -5.61260898e-03f, 3.68340880e-01f, -5.37567914e-01f, 2.64775813e-01f, 5.12354195e-01f, -4.50401902e-01f,
  4.80597168e-01f, 2.30056629e-01f, -5.18065989e-01f, 6.01762533e-01f, 3.88575315e-01f, -6.77587211e-01f, 3.19612548e-02f, -2.71023959e-01f, 6.87534034e-01f, -1.20394811e-01f,
  -4.72499020e-02f, -4.03631598e-01f, -2.82897830e-01f, 3.82650703e-01f, -3.46039869e-02f, 7.63401166e-02f, 6.34025112e-02f, 3.85106355e-02f, -5.75491637e-02f, 3.90747637e-01f,
  -1.50072917e-01f, -1.72465143e-03f, 1.13273747e-01f, 2.17723310e-01f, -8.05479512e-02f, 8.36134404e-02f, 4.90485802e-02f, -1.35935739e-01f, -6.44204319e-01f, -7.00544834e-01f,
  -6.89419627e-01f, -1.16167411e-01f, 4.28304255e-01f, -5.69477916e-01f, 6.10776365e-01f, 3.73289436e-02f, -3.75811398e-01f, 3.59878212e-01f, -1.32809475e-01f, 7.17756450e-01f,
  -6.26824141e-01f, -5.88800460e-02f, 9.55169126e-02f, 5.77648759e-01f, -6.83464170e-01f, -1.10390335e-01f, -2.46631712e-01f, -7.21761808e-02f, -8.57405271e-03f, -4.16121602e-01f,
  8.06346443e-03f, 2.08150879e-01f, 4.27968234e-01f, 5.61611772e-01f, 4.31353211e-01f, -1.67352721e-01f, 6.37282133e-02f, 6.30571395e-02f, 1.00047953e-01f, -1.76962525e-01f,
  -2.45424688e-01f, 9.40310806e-02f, -1.82189569e-01f, 3.64804029e-01f, -7.94404685e-01f, -5.88209450e-01f, -7.15998590e-01f, -1.36595324e-01f, 7.53691435e-01f, -6.93257213e-01f,
  1.30013809e-01f, -6.15013242e-01f, -1.90803245e-01f, -2.06534211e-02f, -1.79032192e-01f, -7.65319392e-02f, 5.45347750e-01f, 7.00514734e-01f, 3.33015323e-02f, -5.82114123e-02f,
  2.07071975e-02f, -1.84722677e-01f, -9.73916277e-02f, -2.56674260e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.34148255e-01f, -2.29687672e-02f, -2.09552303e-01f, 2.52158735e-02f, -7.79466331e-02f, -4.93453331e-02f, 1.38269499e-01f, 5.33994008e-03f, -2.89621115e-01f, 1.06415018e-01f,
  1.52707696e-01f, 1.55108109e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    