/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.15762806e-01f, -1.57624096e-01f, 1.87930965e-03f, 2.93119431e-01f, -9.47481394e-02f, -3.57391864e-01f, -4.30044323e-01f, -1.78436756e-01f, 1.34451300e-01f, -3.93461138e-02f,
  -2.00603217e-01f, 9.36619714e-02f, -1.02810061e-03f, -4.98369820e-02f, 3.77413370e-02f, -1.37684911e-01f, 1.47170320e-01f, 2.27437645e-01f, 1.13983698e-01f, -1.26908198e-01f,
  -6.91118017e-02f, 1.92903131e-01f, 2.19326556e-01f, 2.12276742e-01f, 1.12147201e-02f, 8.05433432e-04f, 4.51549627e-02f, 7.63756130e-03f, -6.05227835e-02f, 1.30617127e-01f,
  -1.35630414e-01f, 9.43772867e-02f, 4.54524793e-02f, 8.21348056e-02f, -7.71804899e-02f, 6.85745478e-02f, -9.16233286e-03f, 1.47367697e-02f, 9.88815073e-03f, 5.96707501e-02f,
  6.76929727e-02f, -3.69083253e-03f, 3.20155709e-03f, 1.86004788e-02f, -1.20963240e-02f, -9.64487344e-02f, 3.73786055e-02f, 1.67308524e-01f, 1.18104024e-02f, -1.30691603e-01f,
  -1.86057687e-02f, -5.94305173e-02f, -1.09901419e-02f, -1.31314665e-01f, 1.91729218e-02f, 1.09994002e-02f, -1.03925504e-01f, 1.77538581e-02f, 1.74238924e-02f, 3.97293316e-03f,
  -8.30733124e-03f, 1.57073047e-03f, -2.25395374e-02f, 3.30048688e-02f, -3.04099936e-02f, 1.72718447e-02f, -3.62696499e-02f, -2.97547113e-02f, -2.64586899e-02f, 8.54674820e-03f,
  -4.63196775e-04f, -2.02965811e-02f, 2.03695036e-02f, 8.16873908e-02f, 6.61206106e-03f, 3.75578143e-02f, 3.17643397e-02f, -4.92203422e-02f, -3.38372104e-02f, 1.54588008e-02f,
  6.82376772e-02f, -8.96570832e-03f, 1.80847906e-02f, -3.63385119e-02f, -4.72825952e-02f, 5.38170822e-02f, 6.79526255e-02f, -3.85507867e-02f, -4.66441177e-02f, 6.19351082e-02f,
  -8.77174884e-02f, -9.83272403e-05f, 7.82470331e-02f, 6.74967170e-02f, 5.29061593e-02f, 3.01637463e-02f, -9.15476028e-03f, 5.56864701e-02f, -3.03010270e-02f, -1.43118566e-02f,
  -9.42986608e-02f, 4.06996347e-02f, -1.90470684e-02f, -1.69045001e-03f, 1.95453931e-02f, 4.47392054e-02f, 1.30968299e-02f, 4.69369069e-02f, 1.56019386e-02f, 5.06190071e-03f,
  2.15124171e-02f, 3.12036891e-02f, 3.67707983e-02f, -1.09698750e-01f, -5.70212156e-02f, 9.26848128e-02f, -1.20272182e-01f, -5.85113280e-02f, -2.74828821e-02f, -1.02079771e-01f,
  -7.81667382e-02f, -5.51280640e-02f, -1.15862235e-01f, -1.25295013e-01f, -2.68435609e-02f, 5.03697135e-02f, 8.91590789e-02f, 5.75575419e-02f, 6.59159943e-02f, -8.60855505e-02f,
  2.87698004e-02f, 1.22845545e-01f, 4.37632501e-02f, 7.46320635e-02f, 8.40982273e-02f, -1.19703464e-01f, -7.70697147e-02f, -1.30583003e-01f, 9.22728479e-02f, 9.27177221e-02f,
  2.98169646e-02f, -1.26205519e-01f, 8.75231475e-02f, -1.01737484e-01f, -2.47135431e-01f, -1.11044310e-01f, -1.59828708e-01f, -8.88481289e-02f, -8.37148800e-02f, -4.52447385e-01f,
  -2.67180622e-01f, 7.45438412e-02f, 6.52454570e-02f, 1.54118109e-02f, -7.69821703e-02f, 1.38153704e-02f, 1.72040071e-02f, -4.72497893e-03f, -5.60414046e-02f, -1.58980750e-02f,
  1.79560389e-02f, 6.84247240e-02f, 2.06132196e-02f, -2.38876957e-02f, -8.26226100e-02f, 2.19202833e-03f, -1.96998287e-02f, -2.17370559e-02f, -7.48021081e-02f, -8.56841076e-03f,
  9.68589913e-03f, -2.14473289e-02f, 2.72299740e-02f, 9.81903747e-02f, 4.94634658e-02f, 4.71367575e-02f, -2.59375218e-02f, 8.15390497e-02f, 6.63036257e-02f, -1.94585174e-01f,
  -3.96458581e-02f, -7.45105818e-02f, 6.71782419e-02f, 6.77406928e-03f, -1.72104351e-02f, 6.89124987e-02f, -6.74788374e-03f, -5.51556647e-02f, 6.78890795e-02f, -3.18773203e-02f,
  6.81550149e-03f, 3.61201540e-02f, 9.53456853e-03f, -5.03120981e-02f, -6.76384941e-02f, 5.90975061e-02f, -5.02780604e-04f, -4.86686975e-02f, -5.36481477e-03f, -3.02092209e-02f,
  -5.86979911e-02f, 3.51114012e-02f, -7.43520632e-02f, 1.82153396e-02f, 2.11465545e-02f, 1.71740521e-02f, -3.91233489e-02f, 4.60896343e-02f, 6.15075938e-02f, 4.59038606e-03f,
  4.80471030e-02f, 2.16449067e-01f, -5.66274002e-02f, 4.07159030e-02f, -1.14840813e-01f, -1.95959900e-02f, -5.03763109e-02f, -1.02161504e-01f, -1.00614496e-01f, 4.45650965e-02f,
  -2.12475304e-02f, 8.11926946e-02f, -2.54748184e-02f, -4.27909121e-02f, 4.37941998e-02f, 5.29731736e-02f, 6.08595796e-02f, -1.59696974e-02f, 9.36993659e-02f, 5.21570165e-03f,
  8.73020291e-03f, 3.96214165e-02f, 1.20679915e-01f, -7.20814429e-03f, 7.71390498e-02f, 8.39230865e-02f, 1.02088362e-01f, 6.83799013e-03f, 1.18419722e-01f, 3.85403410e-02f,
  3.93110693e-01f, -5.29943183e-02f, 6.77171722e-02f, 9.89351273e-02f, -6.60298839e-02f, -3.46609265e-01f, -3.97476941e-01f, -7.92471617e-02f, 8.55547283e-03f, -6.89673424e-02f,
  9.78415310e-02f, -3.26239169e-02f, 1.24249749e-01f, 3.06976703e-03f, -2.82133296e-02f, -2.92272657e-01f, -2.11741731e-01f, 1.82679296e-02f, -6.99468702e-02f, -4.17079441e-02f,
  -1.62350550e-01f, 6.29757866e-02f, 3.08678597e-01f, 1.00646473e-01f, -2.76803374e-02f, -3.76326442e-02f, 4.99241129e-02f, 7.20941499e-02f, -3.48641314e-02f, -7.45417103e-02f,
  4.63236868e-02f, 3.22886676e-01f, -8.57073888e-02f, -1.37222698e-02f, -1.74238700e-02f, -6.44656792e-02f, -2.54859123e-02f, 5.76220751e-02f, 8.07841867e-02f, 9.22415480e-02f,
  7.79622644e-02f, 1.10999390e-01f, 8.59922171e-02f, -3.76453288e-02f, 1.13313273e-01f, 8.34753811e-02f, 5.09114787e-02f, 1.52661756e-01f, 8.80819634e-02f, -4.52425145e-03f,
  -1.13104858e-01f, 8.14211145e-02f, 1.09980494e-01f, -1.59705058e-02f, 1.28377870e-01f, -8.62441957e-03f, 8.84116665e-02f, 8.27371776e-02f, 8.33691508e-02f, 3.04795746e-02f,
  -6.64619878e-02f, 5.59308603e-02f, -5.96929714e-02f, 1.60797201e-02f, -9.54286568e-03f, 2.24883743e-02f, -4.39835787e-02f, -5.17381029e-03f, 3.10009927e-03f, 3.43370326e-02f,
  1.45976311e-02f, 3.69788557e-02f, 1.20112742e-03f, 1.10511500e-02f, -4.82414626e-02f, 3.69511619e-02f, -5.93156070e-02f, -7.51737282e-02f, 1.11509755e-01f, 1.70577504e-02f,
  9.63970423e-02f, 2.17520036e-02f, 8.73482153e-02f, -4.69193347e-02f, 2.99051944e-02f, -3.31940167e-02f, -7.29551390e-02f, 2.65326966e-02f, 4.27477574e-03f, 1.75921805e-02f,
  -2.30463278e-02f, 7.61915520e-02f, -8.14278796e-02f, 3.71943675e-02f, -1.64100807e-02f, 9.26653519e-02f, -2.41757836e-02f, 1.23818992e-02f, 1.10014779e-02f, -6.00274689e-02f,
  2.67215408e-02f, -3.83350849e-02f, 3.91143337e-02f, 2.27685254e-02f, -5.31392246e-02f, -9.37679633e-02f, -7.76959583e-02f, -9.63961259e-02f, -2.31285822e-02f, 7.93968290e-02f,
  -4.86358777e-02f, -2.00466782e-01f, -1.73605815e-01f, -7.64852688e-02f, -7.67308027e-02f, -8.72481689e-02f, -2.06373841e-01f, -1.79516748e-01f, -9.74295512e-02f, -3.78924102e-01f,
  -2.96548102e-03f, -3.27674188e-02f, -2.78092206e-01f, -1.80503741e-01f, -2.23384261e-01f, -1.30998902e-02f, -7.75221288e-02f, -4.03919742e-02f, -9.77373943e-02f, -1.36933789e-01f,
  5.15359677e-02f, 1.08894892e-01f, -1.45221576e-01f, -8.46742019e-02f, -7.54304454e-02f, -2.09715426e-01f, -2.53128976e-01f, -1.51042908e-01f, -1.76035345e-01f, -9.53985453e-02f,
  -1.67919233e-01f, -1.75663993e-01f, -2.54723728e-01f, -1.82108805e-01f, -1.29951864e-01f, -9.66560543e-02f, -2.21245751e-01f, -1.44826725e-01f, -1.37004331e-01f, -2.72238582e-01f,
  -1.10657156e-01f, 1.00537473e-02f, 1.56031614e-02f, 7.27046803e-02f, -3.54500860e-02f, -1.98232755e-02f, 1.32924542e-02f, 7.45160282e-02f, 8.92530680e-02f, -5.69858104e-02f,
  -1.50011964e-02f, 3.94239724e-02f, -1.76956120e-03f, 3.82622480e-02f, 6.72054524e-03f, 7.27567226e-02f, -3.17685492e-02f, 5.13191102e-04f, 1.00614643e-02f, 3.69359530e-03f,
  5.95914163e-02f, 2.45960634e-02f, -9.88461263e-03f, 6.16989657e-02f, 4.90798391e-02f, 8.80889297e-02f, 8.59275609e-02f, 1.25277832e-01f, 2.64606010e-02f, 8.44206437e-02f,
  2.49179080e-02f, 3.91838178e-02f, 2.11448781e-02f, 7.19864815e-02f, 8.76590312e-02f, 8.37042630e-02f, 4.76732440e-02f, 5.78525290e-02f, 2.94754561e-02f, 4.07515727e-02f,
  7.70563306e-03f, -2.66951434e-02f, -3.76268364e-02f, -2.20457502e-02f, 1.36260772e-02f, -9.80508607e-03f, 2.75521614e-02f, -6.74727606e-03f, 7.55192190e-02f, 6.41508102e-02f,
  3.80796492e-02f, -1.67729775e-03f, 4.15670574e-02f, 5.51431812e-02f, -3.14550102e-02f, -5.03505990e-02f, 5.19676134e-02f, 9.69597325e-02f, -4.11360189e-02f, -2.23917868e-02f,
  1.54863998e-01f, 3.44108939e-02f, -5.12805320e-02f, 6.03844784e-02f, -3.88754196e-02f, 3.09794955e-02f, -1.49187129e-02f, 5.59789175e-03f, 4.29106914e-02f, -2.77118199e-03f,
  9.09464136e-02f, 1.29181482e-02f, -3.47472704e-03f, 1.07760251e-01f, -7.64689641e-03f, -3.87533531e-02f, 3.15636657e-02f, -2.97226105e-02f, 3.40973325e-02f, -2.02331748e-02f,
  5.10351360e-03f, 8.51860121e-02f, 9.98660251e-02f, 8.86554345e-02f, -4.75494453e-04f, 7.38629550e-02f, 1.32958829e-01f, 6.47874177e-02f, 1.19423524e-01f, -4.93124239e-02f,
  -4.61750299e-01f, 5.16751297e-02f, 1.80417821e-01f, -2.26105358e-02f, -1.26882479e-01f, -1.00437105e-01f, -1.52158424e-01f, -2.67587095e-01f, -1.68148190e-01f, -6.85217455e-02f,
  1.21255524e-01f, 9.57738832e-02f, 1.90594316e-01f, 1.98491812e-01f, 2.47375425e-02f, 4.46940549e-02f, 2.47056931e-01f, 1.55031249e-01f, 8.70958786e-04f, -4.52338792e-02f,
  2.65245549e-02f, -8.60038623e-02f, -1.68583483e-01f, -7.22077023e-03f, 1.79064587e-01f, 1.90166458e-01f, 2.95370985e-02f, 6.65050596e-02f, 1.71670362e-01f, 2.61216879e-01f,
  3.38313460e-01f, -1.68571785e-01f, 9.31514651e-02f, -4.06875461e-03f, -1.81387423e-03f, -3.06358859e-02f, 2.07614228e-02f, 2.47098524e-02f, -5.53538965e-04f, -7.70897567e-02f,
  5.32406084e-02f, 5.12123806e-03f, 8.24555382e-02f, -1.07263206e-02f, -4.93439659e-02f, -6.22660592e-02f, -3.64453234e-02f, -1.30346743e-02f, -1.76083744e-02f, -7.18179792e-02f,
  1.13406114e-01f, 1.39449351e-02f, -7.49438256e-02f, -9.37619507e-02f, -5.01465686e-02f, 4.82679084e-02f, -5.44851497e-02f, 1.33022610e-02f, -5.37672415e-02f, -9.86241698e-02f,
  -1.71550475e-02f, 4.86722961e-02f, -2.98752189e-02f, 5.21578677e-02f, -5.39447516e-02f, 3.13957557e-02f, 4.97817695e-02f, 2.04678348e-04f, -4.16145176e-02f, 1.12115964e-02f,
  1.90588925e-02f, 5.43477526e-03f, -1.15676885e-02f, -1.79630183e-02f, 3.72072086e-02f, 2.44418858e-03f, -1.52888717e-02f, -2.83635892e-02f, 6.69941353e-03f, -4.40797284e-02f,
  7.42537752e-02f, -1.60405822e-02f, 6.83923950e-03f, 1.95100885e-02f, 3.27560641e-02f, 3.59070972e-02f, 2.48223413e-02f, 2.00687423e-02f, -7.49022737e-02f, 2.43938752e-02f,
  -3.02487314e-02f, 8.46294872e-03f, 9.29507241e-02f, 5.25182970e-02f, 6.93767145e-02f, -2.96899788e-02f, 9.94594097e-02f, 1.65761895e-02f, 1.98905356e-02f, 1.08906124e-02f,
  -5.50189018e-02f, -1.00915648e-01f, -8.66598729e-03f, 1.31070977e-02f, -3.15208621e-02f, 1.32430820e-02f, -2.53014136e-02f, 1.74594462e-01f, -1.22000994e-02f, -8.76804292e-02f,
  -6.90352693e-02f, -1.40829477e-02f, 2.29912635e-04f, 6.50383625e-03f, -4.14205752e-02f, 7.72438422e-02f, 9.22390074e-02f, 6.55949395e-03f, -1.92528404e-02f, -9.59675908e-02f,
  -1.86915584e-02f, 1.00800544e-01f, 1.32990822e-01f, 1.22978352e-01f, -9.17603374e-02f, -2.12406561e-01f, -4.57469344e-01f, -3.06259125e-01f, 7.92399496e-02f, 9.91704911e-02f,
  1.08090565e-01f, 3.29688713e-02f, 5.39049320e-02f, 9.90755185e-02f, -1.58800602e-01f, 4.49998118e-02f, 9.68102142e-02f, -2.72193085e-02f, -1.48120418e-01f, -1.74759954e-01f,
  7.68394396e-02f, 2.83132251e-02f, 2.60914396e-02f, 3.96788269e-02f, 1.73474476e-01f, 6.73379377e-02f, 2.28176370e-01f, 8.96655023e-02f, -1.98885845e-03f, 4.69242692e-01f,
  1.62757859e-01f, -8.44377875e-02f, -8.66681859e-02f, 1.11240625e-01f, 1.07801966e-01f, 4.66480851e-02f, -3.77892405e-02f, 7.67853186e-02f, 1.24275601e-02f, -3.68797518e-02f,
  1.15220837e-01f, -5.56375235e-02f, 9.58423770e-04f, -3.44462097e-02f, -2.94112749e-02f, -8.59604254e-02f, -3.63458460e-03f, -7.34704807e-02f, -6.01931335e-03f, 1.04926582e-02f,
  1.33561239e-01f, -3.31295133e-02f, -6.64987741e-03f, -1.45563520e-02f, -1.44760787e-01f, 4.52299528e-02f, -8.56901705e-02f, 1.27810193e-02f, -1.13300569e-01f, 5.23338020e-02f,
  4.10658643e-02f, 8.41626748e-02f, 1.24692721e-02f, -2.56342683e-02f, -8.81292950e-03f, 5.48145920e-02f, 5.18381782e-02f, -6.53739050e-02f, -4.83771488e-02f, -3.74554843e-02f,
  1.56810675e-02f, -2.01783106e-02f, 1.91247165e-02f, -5.37133813e-02f, 1.27002552e-01f, -2.53778324e-02f, 5.76804243e-02f, -7.96053465e-03f, -5.99120259e-02f, 4.29947339e-02f,
  -5.23935147e-02f, -6.04251623e-02f, 3.95870991e-02f, 4.48733158e-02f, -3.00871534e-03f, 8.49558339e-02f, -4.93851416e-02f, 7.44929090e-02f, -1.44149447e-02f, 5.51267676e-02f,
  -2.12139804e-02f, -1.09646015e-01f, 8.11058357e-02f, -8.93461779e-02f, 2.86142528e-03f, 5.50981611e-02f, 3.57939415e-02f, 3.70103978e-02f, 7.68542886e-02f, 3.32322940e-02f,
  -7.90183023e-02f, 5.24686603e-03f, 3.39345671e-02f, -6.20785495e-03f, -1.11968718e-01f, -7.53459036e-02f, -4.89877276e-02f, 5.94252236e-02f, -4.02011164e-02f, 1.03739975e-02f,
  3.19131240e-02f, -1.34009987e-01f, -1.73043817e-01f, -1.34491712e-01f, -2.75746977e-04f, -8.70499089e-02f, -2.37736525e-03f, -3.07839662e-02f, -2.63075709e-01f, -5.11317700e-02f,
  5.35536945e-01f, 2.00726584e-01f, -1.99743748e-01f, 3.86252493e-01f, 2.73201406e-01f, 4.77014184e-02f, 1.61695890e-02f, -3.64075266e-02f, 8.27186406e-02f, 1.91836104e-01f,
  3.63704637e-02f, 7.31595308e-02f, -8.83726552e-02f, -2.43861511e-01f, -2.93676674e-01f, -1.26259685e-01f, -7.80030936e-02f, -2.91548520e-01f, -3.30810905e-01f, -1.05786845e-01f,
  9.15950984e-02f, 7.98477381e-02f, -2.33478472e-03f, -1.08625166e-01f, 7.50496313e-02f, 1.85646154e-02f, 1.07059322e-01f, -8.86471197e-03f, -5.56670725e-02f, 5.72122820e-02f,
  -6.21227473e-02f, 1.17637878e-02f, -1.72747239e-01f, -4.95556854e-02f, 6.18741177e-02f, 2.03393158e-02f, -3.35573517e-02f, -8.45084712e-03f, 9.73828882e-02f, -1.28425136e-02f,
  2.61294860e-02f, -1.82288326e-02f, -1.09923724e-02f, -8.16464797e-02f, 4.55439128e-02f, 4.33560796e-02f, -2.39379350e-02f, -1.76070452e-01f, -1.77385151e-01f, -1.16763756e-01f,
  3.45675200e-02f, -8.96744058e-03f, -7.59055791e-03f, -1.18653618e-01f, -7.08131269e-02f, -1.03850842e-01f, -1.69387721e-02f, -1.84823617e-01f, -5.09312935e-02f, 8.14330876e-02f,
  5.19732535e-02f, 1.42928986e-02f, -7.40715442e-03f, 1.51543822e-02f, 1.46226902e-02f, 3.92792076e-02f, -6.45248592e-02f, 8.85712635e-03f, -1.19352015e-02f, 5.68173751e-02f,
  -4.14291248e-02f, 5.82477264e-03f, -3.47037837e-02f, 9.72243324e-02f, -4.38307747e-02f, 3.43017001e-03f, -8.60620886e-02f, 5.05712181e-02f, -1.29093276e-02f, -6.02605613e-03f,
  -4.66210991e-02f, -6.36149645e-02f, 1.11710176e-01f, -5.61407804e-02f, -9.86231044e-02f, -3.28972153e-02f, -8.66172742e-03f, -8.99390038e-03f, 3.46117951e-02f, -1.28331911e-02f,
  2.27538884e-01f, -1.79402083e-01f, 9.49777737e-02f, -3.59552130e-02f, 7.34069049e-02f, 1.61500822e-03f, 9.91766676e-02f, -4.99033695e-03f, 1.23003079e-02f, 1.69979222e-02f,
  -5.87379001e-02f, 6.00689091e-03f, 9.73053202e-02f, -3.67286652e-02f, 1.48887159e-02f, 4.81088683e-02f, 1.26726508e-01f, 2.04542931e-02f, -1.86079312e-02f, 5.71008809e-02f,
  9.68980789e-03f, 1.91045120e-01f, 1.62501067e-01f, 4.93218191e-02f, -7.55525902e-02f, 5.23555838e-02f, -2.79043466e-02f, 5.59706800e-02f, 5.32222986e-02f, 2.74387687e-01f,
  5.24617732e-02f, 1.62596777e-01f, -3.86026531e-01f, 1.62936449e-01f, -7.22651035e-02f, -3.55582565e-01f, -4.01479304e-01f, -8.40378106e-02f, 7.99982771e-02f, -6.91432580e-02f,
  6.52592480e-02f, 2.45278999e-01f, 8.95368978e-02f, 7.24018039e-03f, -1.95777506e-01f, -2.01545328e-01f, -2.50605881e-01f, -1.24924436e-01f, -1.53235197e-01f, -4.60785665e-02f,
  1.37577638e-01f, 1.75174281e-01f, 1.75720811e-01f, 1.52028307e-01f, 2.61721462e-01f, 1.16815560e-01f, 1.83644798e-02f, 7.95548633e-02f, -7.56230392e-03f, 1.07692286e-01f,
  3.91824171e-02f, 3.39111872e-02f, -1.36679292e-01f, 5.26707359e-02f, -1.80120915e-02f, 1.08479988e-02f, -2.74050841e-03f, 1.28594572e-02f, -3.08502768e-03f, 4.47791070e-02f,
  3.06202210e-02f, -4.04762279e-04f, -9.56906006e-03f, 6.37951344e-02f, 3.00128665e-03f, -2.81305332e-02f, -1.92071684e-02f, -1.64900199e-02f, -8.35979283e-02f, 9.12153646e-02f,
  8.01898763e-02f, 2.87637059e-02f, -1.73396841e-01f, -6.58601243e-03f, -2.71793231e-02f, -5.96643277e-02f, 1.96551532e-02f, 7.31950924e-02f, -5.49932681e-02f, 1.45967051e-01f,
  -3.72773297e-02f, 1.83086060e-02f, -3.67125534e-02f, 2.88767703e-02f, -2.79356167e-03f, -1.73992384e-02f, 1.66585371e-02f, 1.64951980e-02f, 4.25100438e-02f, 3.25126648e-02f,
  8.24298058e-03f, -1.32619934e-02f, 3.19669081e-04f, 6.19854517e-02f, 3.39035392e-02f, -1.15297008e-02f, -3.26552913e-02f, 5.42921573e-02f, 5.07282605e-03f, -2.88505238e-02f,
  -3.93909123e-03f, -5.66552347e-03f, 6.75666481e-02f, 4.26613055e-02f, -2.25774255e-02f, -2.26282310e-02f, 2.68188138e-02f, 6.02298591e-04f, 7.41630327e-03f, -6.76379204e-02f,
  2.10311577e-01f, -2.76708871e-01f, 1.17002375e-01f, -9.16211400e-03f, -2.06116270e-02f, 1.10374084e-02f, 6.01757020e-02f, 1.80633161e-02f, -6.56582508e-03f, -7.92851020e-03f,
  8.68333783e-03f, 2.66260989e-02f, 3.71129364e-02f, 4.87305447e-02f, -2.28248769e-03f, 3.74690406e-02f, 7.00719655e-02f, -3.75713147e-02f, -9.92767960e-02f, 2.66781673e-02f,
  -1.83640942e-02f, -1.25217766e-01f, -1.20792121e-01f, -4.08556089e-02f, 5.96858263e-02f, -1.21294186e-01f, -1.00339770e-01f, -8.35837349e-02f, -1.13035515e-01f, 1.12539768e-01f,
  -4.06352460e-01f, 3.11082929e-01f, 2.74910420e-01f, -7.08407909e-03f, 1.20847635e-02f, 5.35656884e-02f, 2.28868619e-01f, 6.40896782e-02f, -5.83801046e-02f, 1.23971120e-01f,
  -1.63743347e-02f, -3.11022580e-01f, -1.49011299e-01f, -1.54094160e-01f, -1.49109662e-01f, 1.63222104e-01f, 1.92906260e-01f, 7.81652145e-03f, -1.78798616e-01f, -2.32751861e-01f,
  2.68555935e-02f, 7.88021758e-02f, -5.06513231e-02f, -2.85866763e-03f, 1.08529322e-01f, 7.10771838e-03f, 2.44818240e-01f, 7.87233561e-02f, 1.30564436e-01f, 1.66275874e-01f,
  -7.71186873e-02f, 1.01227999e-01f, -1.61191732e-01f, -1.42076656e-01f, -1.68128479e-02f, -3.68229114e-02f, 5.08692162e-03f, -2.54894067e-02f, 1.52433207e-02f, 3.15668397e-02f,
  -3.26925218e-02f, 6.87605236e-03f, -4.59971540e-02f, 4.33246307e-02f, 9.45624560e-02f, -6.14923090e-02f, 6.06214032e-02f, 8.41917619e-02f, 5.81494533e-02f, -6.39977604e-02f,
  4.62952582e-03f, 7.04309866e-02f, 2.89022624e-02f, 7.58880526e-02f, -5.68696484e-02f, -9.68711898e-02f, 7.29549751e-02f, -3.43669504e-02f, 1.85898952e-02f, 1.74984150e-02f,
  -6.35941476e-02f, -5.01900427e-02f, -1.23577826e-02f, 5.31733073e-02f, -4.03999351e-03f, 6.64664656e-02f, 5.22289164e-02f, 3.64842340e-02f, 3.66392657e-02f, 1.10032707e-01f,
  -1.25780571e-02f, 3.06462217e-03f, -3.34092900e-02f, 3.80280241e-02f, -6.61873519e-02f, 7.01008290e-02f, 3.24988104e-02f, -5.24047799e-02f, 4.15625088e-02f, 4.25027460e-02f,
  -4.35069129e-02f, -7.89553374e-02f, 7.28501081e-02f, 6.98422790e-02f, 2.05988549e-02f, 8.36035162e-02f, 3.77381593e-02f, -3.86792980e-02f, -5.72653152e-02f, 1.68981999e-02f,
  -1.39414728e-01f, -6.99918270e-02f, -7.06398338e-02f, -1.04885332e-01f, 5.25453016e-02f, -3.57562900e-02f, -2.44703852e-02f, -4.33828421e-02f, -2.65544411e-02f, -3.22924666e-02f,
  -6.28881902e-02f, -4.59793620e-02f, 3.07020247e-02f, 1.16041720e-01f, -3.56513411e-02f, -2.46538911e-02f, 1.36851788e-01f, -6.25357926e-02f, -7.16698244e-02f, 7.01681757e-03f,
  9.45891589e-02f, -6.84549436e-02f, -1.64338648e-01f, -4.81322743e-02f, 9.78750736e-03f, -2.52718300e-01f, 5.48680499e-02f, -3.82304564e-02f, -1.57490775e-01f, 5.85707612e-02f,
  2.66652167e-01f, -3.34005147e-01f, -6.87296808e-01f, 5.48858494e-02f, -3.29871811e-02f, -5.22063300e-02f, -1.46077573e-01f, 9.16767716e-02f, 2.14253649e-01f, -1.46480277e-01f,
  -1.76747851e-02f, 1.16982542e-01f, 8.95994231e-02f, 9.97068211e-02f, -8.11646208e-02f, -2.73702055e-01f, -1.83256119e-01f, -2.16832235e-01f, 9.74265635e-02f, 1.45741090e-01f,
  6.23985454e-02f, 1.41423628e-01f, 1.17577419e-01f, 1.54421598e-01f, 1.01792179e-02f, 3.53906713e-02f, -1.74910232e-01f, -1.34179637e-01f, -1.97377414e-01f, -1.46727204e-01f,
  -3.28836411e-01f, -2.60411531e-01f, 3.19050178e-02f, 1.71351030e-01f, -4.63426374e-02f, 4.07506758e-03f, 1.68132074e-02f, -3.29494700e-02f, 4.09259833e-02f, -8.07080604e-03f,
  -7.31959566e-02f, 3.79440524e-02f, -8.61347690e-02f, -2.61409506e-02f, 1.03798755e-01f, 5.84947830e-03f, -1.16360215e-02f, -1.21759109e-01f, 1.91647429e-02f, -1.18895821e-01f,
  -6.21495508e-02f, -7.65079111e-02f, -1.11132115e-01f, -1.93797275e-02f, -6.45739585e-02f, -4.06794660e-02f, -1.21486001e-01f, -6.58817142e-02f, -2.66923998e-02f, 4.33523394e-02f,
  3.01053841e-02f, -4.08014022e-02f, 4.48478349e-02f, 1.04207387e-02f, 8.39629546e-02f, 2.09322441e-02f, -5.63529283e-02f, 8.01594406e-02f, 1.41691999e-03f, 1.01289697e-01f,
  -1.04462504e-02f, -4.93552573e-02f, -4.09967229e-02f, -1.69890951e-02f, -6.78460523e-02f, -4.45675105e-02f, -1.96890179e-02f, 1.34177525e-02f, -1.93460597e-04f, 6.31078929e-02f,
  7.46787265e-02f, -1.98209845e-02f, -2.38762777e-02f, -2.11621332e-03f, -2.24814005e-02f, -1.00438826e-01f, -8.35059676e-03f, 6.33583367e-02f, -1.54534252e-02f, -2.40623523e-02f,
  2.82366723e-01f, -1.42074421e-01f, 3.62745263e-02f, 5.09271547e-02f, -6.17002398e-02f, 4.55125235e-02f, -4.96883318e-02f, 6.46639690e-02f, -4.98285778e-02f, -3.88528011e-03f,
  -9.12168026e-02f, 4.74865660e-02f, -1.24921724e-02f, -4.41933423e-02f, 8.58291462e-02f, 1.38325803e-02f, 4.71448675e-02f, 2.64168950e-03f, 5.58271296e-02f, -2.94678994e-02f,
  7.70080611e-02f, 2.38408931e-02f, 1.72863886e-01f, 9.41641182e-02f, -5.02822082e-03f, 1.30900994e-01f, -2.73468643e-02f, 7.68817142e-02f, 4.90991725e-03f, 2.89846092e-01f,
  2.26662129e-01f, -5.29948883e-02f, -2.10853741e-01f, 1.37652889e-01f, 2.01090261e-01f, 7.78899416e-02f, 1.53531798e-03f, -8.54159743e-02f, 9.82977450e-02f, 2.68849116e-02f,
  1.95211858e-01f, 7.85059109e-02f, -4.26586643e-02f, -3.46692912e-02f, -1.94416210e-01f, -1.36762157e-01f, -1.07957564e-01f, -2.56760418e-01f, -1.43578351e-01f, 6.84226826e-02f,
  2.26343423e-02f, 3.10108680e-02f, -5.85820004e-02f, -1.81982070e-02f, 1.63042713e-02f, -1.12435102e-01f, -1.85953796e-01f, -3.46939936e-02f, -8.05645436e-02f, -1.00568153e-01f,
  -8.01579356e-02f, 1.60562187e-01f, -2.94625852e-02f, 4.55183461e-02f, 1.15805402e-01f, -2.53653247e-02f, 1.03929676e-01f, -9.93782505e-02f, 4.96848226e-02f, -1.11453004e-01f,
  8.57000202e-02f, 8.65500048e-02f, -5.51929185e-03f, 3.87456804e-03f, 2.96891462e-02f, -7.38672912e-02f, -1.33489341e-01f, -1.04635015e-01f, -1.30825177e-01f, -5.79678565e-02f,
  1.40975401e-01f, 9.93826017e-02f, 7.48143643e-02f, -1.25891656e-01f, -1.52410403e-01f, 3.71875381e-03f, -2.11746376e-02f, -5.65839000e-02f, -1.59042820e-01f, -1.87311515e-01f,
  -4.75332960e-02f, 4.83440980e-02f, 3.52167711e-02f, 2.83000283e-02f, -5.12054637e-02f, -3.05438098e-02f, -2.29976345e-02f, 2.43875221e-03f, -2.89605744e-02f, -5.74890971e-02f,
  1.34917656e-02f, 2.00711749e-03f, -4.31824056e-03f, 3.06698866e-02f, -5.81788691e-03f, -6.75062928e-03f, 7.05984384e-02f, -1.22218393e-01f, 6.42369315e-02f, -2.84883212e-02f,
  4.10919823e-02f, -1.50160370e-02f, 3.94766144e-02f, -3.00121885e-02f, 6.19705766e-03f, 1.23934662e-02f, -2.94354418e-03f, 6.57863542e-02f, 3.87967378e-02f, 3.02558243e-02f,
  -2.76439451e-02f, 1.60754919e-01f, -4.17778082e-02f, -4.32147495e-02f, 1.07877851e-01f, -1.27602676e-02f, 1.61853898e-02f, -1.34147257e-02f, 4.41828780e-02f, 3.72490436e-02f,
  7.63933286e-02f, -5.14455372e-03f, 2.92727780e-02f, -1.09264195e-01f, 7.03699291e-02f, -6.45647757e-03f, 7.05448091e-02f, -4.12564073e-03f, -7.25052282e-02f, -5.58901913e-02f,
  -5.79540990e-02f, -6.29236624e-02f, -4.78767753e-02f, -9.13537368e-02f, 4.75075468e-02f, 3.98649685e-02f, -7.57305846e-02f, -1.32524267e-01f, -6.70316145e-02f, -1.92678303e-01f,
  4.02056836e-02f, 3.13361377e-01f, 1.26380950e-01f, 4.57078964e-02f, 1.11825675e-01f, 1.48871720e-01f, 1.98134467e-01f, -1.01009347e-01f, -1.19301856e-01f, 1.34194657e-01f,
  1.67666197e-01f, -2.83782668e-02f, 7.18464181e-02f, -2.52703410e-02f, -1.03279747e-01f, 6.67300299e-02f, 2.54614428e-02f, 4.10598367e-02f, -1.22363247e-01f, 3.97989899e-02f,
  7.93992425e-04f, 9.27879512e-02f, 4.65055840e-04f, -1.21341320e-02f, 1.17123954e-01f, 5.57393618e-02f, -1.20295342e-02f, 6.43248186e-02f, 1.56843141e-01f, 1.69945151e-01f,
  1.40716374e-01f, 8.27446729e-02f, -4.19465192e-02f, -5.92043996e-02f, 6.47044405e-02f, -3.64264175e-02f, 6.49486482e-02f, -1.06890023e-01f, 1.96110737e-02f, 1.74884144e-02f,
  7.89268538e-02f, -5.17956987e-02f, 4.68057208e-02f, -5.74192069e-02f, 4.02811132e-02f, -6.41219988e-02f, -1.55424982e-01f, -1.40417412e-01f, 1.63684953e-02f, 7.22530484e-02f,
  1.86559856e-01f, 2.53143132e-01f, 8.86919871e-02f, 1.18216500e-02f, -2.85133924e-02f, 2.12990027e-02f, 8.02675933e-02f, -4.05594110e-02f, -7.16906115e-02f, -8.41137990e-02f,
  -2.83324774e-02f, -4.29804772e-02f, -2.74536200e-03f, -3.77310775e-02f, 8.01824126e-03f, 1.54538173e-02f, 1.67363863e-02f, -2.23252997e-02f, -1.37604037e-02f, 1.94092058e-02f,
  -1.27972206e-02f, 3.11401803e-02f, -2.24498492e-02f, -5.08052707e-02f, -9.55447741e-03f, 1.38850361e-01f, 1.50385406e-02f, 8.49370006e-03f, -1.87697783e-02f, 3.74243334e-02f,
  -6.44777808e-03f, 6.38740212e-02f, 6.43799156e-02f, -3.00429994e-03f, -1.54166911e-02f, -2.75291828e-03f, -2.68160459e-02f, 2.30198950e-02f, 5.19623188e-03f, 4.16654535e-02f,
  -7.87145123e-02f, 2.03961991e-02f, -3.76374740e-03f, -6.59432039e-02f, 5.21849245e-02f, -1.57326926e-02f, 4.82580997e-02f, -1.49961449e-02f, 5.91650270e-02f, 1.64790973e-02f,
  -4.60462160e-02f, 3.13469791e-03f, 8.51685032e-02f, -4.34308872e-02f, -6.36796430e-02f, -8.71890709e-02f, -4.32791896e-02f, 9.33524668e-02f, -4.11053598e-02f, -4.44221199e-02f,
  1.08509101e-01f, 2.72220261e-02f, 4.82238345e-02f, 7.26057664e-02f, -5.94110861e-02f, 3.19945775e-02f, -1.34092253e-02f, -4.91297171e-02f, -6.46698922e-02f, -2.86338925e-02f,
  2.06720188e-01f, 1.83128938e-01f, 1.79838538e-01f, 7.55316988e-02f, 7.23108426e-02f, 1.56739846e-01f, 2.27782920e-01f, 8.08173493e-02f, -7.25039765e-02f, 1.62760168e-01f,
  -1.67457834e-02f, -2.58924272e-02f, -1.30965933e-01f, -1.17142215e-01f, 2.65126731e-02f, 2.29301661e-01f, 1.70009047e-01f, -3.62615450e-03f, -1.45361647e-02f, 8.14757645e-02f,
  5.38121983e-02f, 3.49229872e-02f, -1.08864427e-01f, -2.14721149e-05f, 9.30084661e-02f, -5.90431988e-02f, 8.11149478e-02f, -3.29026505e-02f, 1.47079363e-01f, 1.07917637e-01f,
  3.89817774e-01f, 6.59794584e-02f, -6.55186325e-02f, -1.33025885e-01f, -3.00814006e-02f, 3.03743873e-02f, 8.60925242e-02f, -1.22725651e-01f, -4.91895266e-02f, 7.19476938e-02f,
  -2.90839300e-02f, 1.50033589e-02f, 4.82654907e-02f, -8.84821732e-03f, -7.90650994e-02f, -3.53413820e-02f, 3.46048735e-02f, -8.06836113e-02f, 1.64429359e-02f, 1.01810686e-01f,
  4.03697044e-03f, 8.09153616e-02f, 7.79828504e-02f, -1.23667838e-02f, 2.78151873e-02f, -2.61238795e-02f, -5.61021566e-02f, -6.26280308e-02f, -9.65312496e-02f, 8.45152363e-02f,
  -2.42170575e-03f, -3.90995517e-02f, -4.93495278e-02f, 1.49652259e-02f, -2.61863004e-02f, -4.06011567e-02f, 4.56741592e-03f, 1.12250470e-01f, -4.90482897e-02f, 3.46022397e-02f,
  -1.23662297e-02f, -2.07268521e-02f, 1.91454235e-02f, 1.31126354e-02f, 4.06616107e-02f, -1.47707667e-02f, 1.65962260e-02f, -1.71152391e-02f, -3.56873125e-02f, -7.02685565e-02f,
  1.23141864e-02f, -3.34651507e-02f, -8.71310383e-03f, 6.54100673e-03f, 4.13988978e-02f, -3.69306952e-02f, -4.77930438e-03f, -9.07067433e-02f, -3.00644301e-02f, 6.24264590e-02f,
  -4.30942290e-02f, -2.94184893e-01f, 1.24889962e-01f, 6.86691478e-02f, 3.74032110e-02f, -3.94339897e-02f, -3.34285712e-03f, 1.31932413e-02f, 7.45157152e-02f, 1.13490961e-01f,
  6.02936521e-02f, 3.99198644e-02f, -1.84679721e-02f, 4.65106852e-02f, 7.77712688e-02f, 5.05363196e-02f, 7.79435188e-02f, 5.36432602e-02f, -1.65474638e-02f, -3.27062942e-02f,
  -4.87773083e-02f, 5.48528768e-02f, 1.28649876e-01f, 9.19710621e-02f, -6.00303672e-02f, 1.15563177e-01f, 1.16667315e-01f, 1.61998913e-01f, 6.63096607e-02f, 1.80109829e-01f,
  4.54870403e-01f, -2.92709917e-01f, -3.05669874e-01f, 6.82961345e-02f, -1.34462789e-01f, -2.75957227e-01f, -4.36612576e-01f, -1.68402065e-02f, 5.82524203e-02f, -1.53307706e-01f,
  -2.86547337e-02f, 1.91359013e-01f, 2.10661367e-01f, 2.04004213e-01f, 1.82536945e-01f, -2.07156181e-01f, -6.72118366e-02f, 1.56208947e-01f, 3.36602420e-01f, 8.25097561e-02f,
  -6.85340678e-03f, 4.20907550e-02f, 2.44309366e-01f, 1.06592901e-01f, -1.18153907e-01f, 4.91368137e-02f, -6.34181350e-02f, -1.31680727e-01f, -2.07648147e-02f, -8.50486457e-02f,
  -2.30806246e-01f, 3.06256041e-02f, 9.44947526e-02f, 1.92032397e-01f, -3.37078013e-02f, -4.72256495e-03f, -1.40291881e-02f, -1.24877520e-01f, -4.90593314e-02f, -3.35370563e-03f,
  -1.21265883e-02f, 5.92869595e-02f, 7.27472752e-02f, -9.10541341e-02f, -8.29031691e-02f, -3.72864492e-03f, 2.74960906e-03f, 1.50329798e-01f, 5.92887960e-02f, -9.61122587e-02f,
  -7.94462711e-02f, 2.47275904e-02f, -8.84943530e-02f, 8.92508402e-03f, 1.04527973e-01f, 1.61018923e-01f, -1.21403225e-01f, 5.08087352e-02f, -1.25246309e-02f, -2.90200226e-02f,
  1.25986394e-02f, -7.10441545e-02f, 6.27333745e-02f, -6.39330149e-02f, 6.43943027e-02f, -5.52226752e-02f, -3.47106135e-03f, -2.67367233e-02f, 9.71333608e-02f, -2.78147664e-02f,
  -8.11721198e-03f, -1.43537866e-02f, -1.16682993e-02f, 4.36155917e-03f, 3.91096100e-02f, -7.43607208e-02f, -3.31858322e-02f, 3.61277759e-02f, 1.77568439e-02f, 2.85061449e-02f,
  6.28892481e-02f, -6.39605075e-02f, -3.62568311e-02f, 6.18667342e-02f, 6.77853264e-03f, 2.42684167e-02f, 1.28914267e-02f, -1.44151375e-02f, -2.34431960e-02f, 3.18259113e-02f,
  -9.92879793e-02f, 1.77967891e-01f, -3.20052244e-02f, 6.00829758e-02f, -3.16447541e-02f, 7.99528789e-03f, -9.01136249e-02f, 7.20563903e-02f, 4.35838625e-02f, -4.97152880e-02f,
  1.92609746e-02f, 5.13841547e-02f, -2.29783058e-02f, 3.45842615e-02f, 9.14011076e-02f, 1.00068189e-02f, 3.74606950e-03f, -6.00523828e-03f, 2.30731089e-02f, -5.20341657e-02f,
  2.41330136e-02f, -2.16772920e-03f, 7.59686753e-02f, -8.12590420e-02f, 9.01623443e-02f, 4.39104959e-02f, -1.12318404e-01f, -9.14110392e-02f, -2.44514998e-02f, -2.11659789e-01f,
  4.67778862e-01f, 8.96045044e-02f, 2.73756325e-01f, 2.16628447e-01f, 1.55458748e-01f, 2.12584108e-01f, 2.69585580e-01f, 1.85134485e-01f, 8.03299323e-02f, 1.55178010e-01f,
  -9.71659552e-03f, -1.57763232e-02f, 8.69931579e-02f, 6.18994869e-02f, 1.43213525e-01f, 3.29017520e-01f, 3.39742094e-01f, 2.98485816e-01f, 1.49029166e-01f, -2.73574479e-02f,
  8.81727599e-03f, 2.24977255e-01f, 1.52116150e-01f, 7.00970218e-02f, 5.66161089e-02f, 7.49562820e-03f, 2.09703520e-02f, 3.84783447e-02f, -1.05973110e-01f, 8.97189751e-02f,
  1.64154604e-01f, 8.43810141e-02f, -8.52358863e-02f, -7.86428079e-02f, -6.36897087e-02f, -3.47534008e-02f, 4.36993800e-02f, 3.60815190e-02f, -7.82277510e-02f, 8.25095326e-02f,
  -2.83444617e-02f, 3.87910679e-02f, -1.01864643e-01f, -3.49913016e-02f, 4.50823642e-02f, 9.74690989e-02f, 1.63039088e-01f, 1.70116186e-01f, 6.77617043e-02f, -1.00435846e-01f,
  -4.45536897e-02f, -7.24250451e-03f, 5.09016290e-02f, -1.21895254e-01f, -9.49984640e-02f, -1.17135733e-01f, -8.47790316e-02f, -6.02545217e-02f, -9.71070379e-02f, 2.67202370e-02f,
  3.34490812e-03f, -7.86763337e-03f, -3.55859995e-02f, -3.87120619e-02f, 4.79764976e-02f, -1.89238265e-02f, 1.84869654e-02f, 2.68834680e-02f, 4.30894410e-03f, 4.46102358e-02f,
  -7.14746770e-03f, -2.28064638e-02f, -2.74045160e-03f, 7.59918988e-02f, 2.27798093e-02f, -3.38835903e-02f, -3.72065715e-02f, -6.36206893e-03f, -6.35884004e-03f, 4.34329212e-02f,
  -1.11335923e-03f, -8.97133797e-02f, -1.72244553e-02f, -6.48356974e-03f, -3.11916955e-02f, 5.21582738e-02f, -3.76139395e-02f, -3.41462828e-02f, -3.89733836e-02f, 5.71348704e-02f,
  -3.87269668e-02f, -9.19886157e-02f, 8.78130198e-02f, 1.48090735e-01f, 3.36622745e-02f, 5.29864556e-05f, -1.07590921e-01f, 1.31737106e-02f, -1.45714417e-01f, 2.49919482e-02f,
  -8.70902836e-02f, 2.49404665e-02f, 6.80915639e-02f, -2.54266784e-02f, 5.66857643e-02f, 5.25794066e-02f, 6.28286526e-02f, 7.79570937e-02f, -5.81877939e-02f, -5.63253388e-02f,
  -5.49860066e-03f, 1.43937916e-01f, 7.21302330e-02f, -3.00658364e-02f, -6.45777434e-02f, 4.88738418e-02f, -5.72617687e-02f, -1.02064997e-01f, 1.17524356e-01f, 7.00608492e-02f,
  9.24595073e-02f, -1.49454787e-01f, -2.68114239e-01f, -7.41529986e-02f, -9.79702473e-02f, 6.25025630e-02f, -1.21572003e-01f, 2.45829355e-02f, 1.46436676e-01f, -8.95647407e-02f,
  -8.43673944e-03f, 2.72399157e-01f, 2.43809298e-01f, 1.49741203e-01f, 1.46206349e-01f, -7.18821362e-02f, -1.05406597e-01f, -7.29006082e-02f, 1.51917711e-01f, 1.48972303e-01f,
  6.70603439e-02f, -1.01034068e-01f, -1.01500258e-01f, -1.09108232e-01f, -4.49993946e-02f, 4.87913489e-02f, -1.43222790e-02f, -3.90272178e-02f, -1.25726432e-01f, -2.30999783e-01f,
  1.44104719e-01f, -1.92044109e-01f, 2.02355251e-01f, 1.02555342e-01f, -4.33987789e-02f, 5.00638485e-02f, -8.28570873e-03f, -2.83937082e-02f, -6.71307230e-03f, -6.11528046e-02f,
  3.88977677e-02f, -4.09370288e-02f, -6.70351163e-02f, -2.83563342e-02f, 6.68892041e-02f, 1.71376187e-02f, -8.52152184e-02f, -8.17863047e-02f, 7.94194043e-02f, -7.16014951e-03f,
  -1.23416588e-01f, -9.65923145e-02f, 7.70769194e-02f, 9.45173651e-02f, -2.54804008e-02f, 4.42645922e-02f, -7.75048882e-02f, -3.08238175e-02f, -1.06841460e-01f, 1.65662430e-02f,
  4.66107912e-02f, -3.54954563e-02f, -3.56927328e-02f, 1.64437629e-02f, 6.13562837e-02f, 5.61268628e-02f, -1.71302855e-02f, 1.72748193e-02f, -9.68324207e-03f, -3.30098011e-02f,
  5.01620881e-02f, -1.45586412e-02f, 6.81164265e-02f, -2.20222063e-02f, 8.31688493e-02f, -2.10188292e-02f, -8.73191189e-03f, 6.97527677e-02f, -3.15549187e-02f, -2.73860265e-02f,
  -2.56568454e-02f, 3.60966078e-03f, -4.24173139e-02f, 2.76153609e-02f, -5.65035120e-02f, 4.73566353e-02f, 3.51256249e-03f, 1.41848961e-03f, 3.94704565e-02f, -1.88547783e-02f,
  4.32938308e-01f, 8.43226761e-02f, 8.74426588e-02f, 2.06299536e-02f, 4.54394519e-02f, -2.50279885e-02f, -1.45566405e-03f, -7.00155124e-02f, -5.67018166e-02f, 1.34301698e-02f,
  -2.08221078e-02f, 2.36498900e-02f, 1.48804188e-02f, -2.25847308e-02f, -2.79369624e-03f, 3.93149294e-02f, -2.68670339e-02f, 5.70495911e-02f, -3.36227305e-02f, 3.66740823e-02f,
  6.76570237e-02f, 1.50877386e-01f, 2.60329366e-01f, 1.82111368e-01f, 1.01881571e-01f, 2.61888146e-01f, 1.48075089e-01f, 1.31658241e-01f, 2.15671778e-01f, 2.96450227e-01f,
  -8.85601640e-02f, 1.82703093e-01f, -1.23598360e-01f, 3.91238220e-02f, -1.71081766e-01f, -1.34714112e-01f, -9.92537811e-02f, 4.51257788e-02f, 4.80353199e-02f, 1.33010924e-01f,
  -6.21222444e-02f, 1.61378067e-02f, -2.97698993e-02f, 9.64729208e-03f, -2.02144191e-01f, -4.75329272e-02f, -2.18654443e-02f, -1.70716509e-01f, -2.56847262e-01f, -9.10386816e-02f,
  -4.87882756e-02f, -9.43029299e-02f, -8.15071166e-02f, 2.62444746e-03f, 1.47144794e-01f, -3.05678342e-02f, 1.42895922e-01f, -5.48599362e-02f, 3.89552931e-03f, 1.53697357e-01f,
  2.08186731e-01f, 7.35212415e-02f, -7.07350224e-02f, -7.95586929e-02f, -4.60581444e-02f, -4.59682085e-02f, -4.65522707e-02f, -1.58182066e-03f, -8.09211880e-02f, 2.16394793e-02f,
  -8.41995478e-02f, -2.92244367e-03f, -1.21476516e-01f, 5.15918471e-02f, -1.00442789e-01f, -8.79519060e-02f, -5.29798046e-02f, -6.07768148e-02f, -4.33664136e-02f, 1.35495827e-01f,
  -7.69349262e-02f, -2.25960929e-02f, -1.38405070e-01f, 5.24063148e-02f, 7.72890151e-02f, -2.48488616e-02f, 1.14881694e-01f, 1.01814717e-01f, -2.27850769e-02f, 2.01982439e-01f,
  3.50026637e-02f, -1.57884937e-02f, 1.22374659e-02f, -5.22750095e-02f, -4.87977304e-02f, -3.69729474e-02f, 6.35091960e-02f, -7.11410716e-02f, 3.66744921e-02f, 5.52357286e-02f,
  -7.17130676e-02f, 6.30738288e-02f, 8.17907155e-02f, 8.30634013e-02f, -6.73198653e-03f, -4.89573516e-02f, -1.18605280e-02f, 5.12118712e-02f, -6.19500056e-02f, -4.05577980e-02f,
  7.67080709e-02f, -7.22625181e-02f, 4.92305122e-02f, -3.47985933e-03f, 5.16994894e-02f, 1.26745831e-02f, -4.05456759e-02f, -5.75163923e-02f, 5.83244339e-02f, -1.88276987e-04f,
  1.10832535e-01f, -1.79720089e-01f, 3.25202346e-02f, -4.62618470e-02f, 4.84051369e-02f, 4.10759188e-02f, 8.03431845e-04f, -6.88493624e-03f, -9.23222583e-03f, -7.35779926e-02f,
  -7.13782832e-02f, -6.25784621e-02f, -8.81133135e-03f, -1.73722357e-02f, -7.61918277e-02f, 1.46151111e-02f, -1.28049939e-03f, -4.77793962e-02f, -4.67550866e-02f, 6.44052923e-02f,
  1.20295184e-02f, -3.15750204e-02f, -1.34355068e-01f, -3.38995866e-02f, 1.86857525e-02f, -1.51221305e-01f, -3.52290943e-02f, 7.11312443e-02f, -7.55479708e-02f, 8.18892270e-02f,
  -5.38851880e-02f, -1.69434845e-01f, 2.12059870e-01f, -1.47717893e-01f, 1.31552175e-01f, 2.88629085e-01f, 2.57095993e-01f, 1.11295618e-01f, -7.41050094e-02f, -3.24282274e-02f,
  -1.50344923e-01f, -8.28144327e-02f, -2.66232509e-02f, 5.17864451e-02f, 2.16023073e-01f, 5.72241060e-02f, 1.52968213e-01f, 2.54377335e-01f, 3.28685582e-01f, 5.85122257e-02f,
  2.75957398e-02f, 5.72118051e-02f, -2.83347238e-02f, 1.11401603e-01f, -1.94416538e-01f, -2.74051279e-02f, -8.10002014e-02f, -5.82228377e-02f, 3.80624980e-02f, -1.41774476e-01f,
  -1.70227438e-01f, -9.97902006e-02f, 1.21698461e-01f, -6.76169321e-02f, 9.54783484e-02f, -6.15760162e-02f, 2.12606378e-02f, 7.64036458e-03f, 4.30281274e-02f, -1.05222300e-01f,
  3.12197339e-02f, -1.02987058e-01f, -5.91630256e-03f, 1.40815624e-03f, 5.06210700e-02f, -4.50500706e-03f, -4.23879772e-02f, -3.97760011e-02f, 2.38739364e-02f, -7.06659071e-03f,
  -1.57879218e-02f, -1.03907762e-02f, 1.17578700e-01f, 1.30232260e-01f, 2.45854240e-02f, 1.50196835e-01f, 6.73206672e-02f, -4.63848040e-02f, 1.09764516e-01f, -1.89680398e-01f,
  4.84068617e-02f, -1.47174858e-02f, 1.31285964e-02f, -4.06072848e-02f, -5.08803781e-03f, -9.37574059e-02f, 3.74322198e-02f, -4.76846583e-02f, 1.51977071e-03f, 1.60595160e-02f,
  -5.04191741e-02f, 3.69793884e-02f, 3.30728553e-02f, 2.31282040e-02f, 4.18871036e-03f, -3.55811268e-02f, 3.00399456e-02f, -5.06760851e-02f, 2.40156874e-02f, -7.21196607e-02f,
  1.41304396e-02f, -3.65864262e-02f, 1.63555294e-02f, -1.26373386e-02f, 4.77392524e-02f, -8.47177766e-03f, -4.49420661e-02f, 2.44907103e-02f, -8.27470701e-03f, -1.48699628e-02f,
  -2.10977510e-01f, 2.77137130e-01f, -9.70101580e-02f, -1.98055971e-02f, -7.12172762e-02f, -6.84780404e-02f, -1.15976840e-01f, -8.76741577e-03f, -8.45918730e-02f, -4.51135598e-02f,
  5.10359406e-02f, 2.26862375e-02f, -5.07085063e-02f, -1.93604156e-02f, 5.33488840e-02f, 3.26172053e-03f, -8.08840916e-02f, 4.48654331e-02f, 1.58286281e-02f, -4.47331034e-02f,
  -5.43148480e-02f, 4.69299033e-03f, 1.47900937e-04f, -5.27033359e-02f, -6.94866478e-02f, 1.35575086e-01f, -2.23384891e-02f, -8.09459686e-02f, 1.54446974e-01f, -8.06445852e-02f,
  -5.69573224e-01f, 1.83767602e-01f, -3.08492690e-01f, -7.41930380e-02f, 1.28774315e-01f, -4.31970693e-03f, 9.51848999e-02f, -6.02995381e-02f, -4.15267758e-02f, 2.28480041e-01f,
  2.53070742e-01f, 1.62397072e-01f, 1.07831471e-02f, 6.68994412e-02f, -1.86167628e-01f, -7.89438337e-02f, -1.82182476e-01f, -3.85193169e-01f, -3.51452202e-01f, -6.46613836e-02f,
  2.06521049e-01f, 3.04997265e-02f, -3.09901714e-01f, -1.71759859e-01f, 1.62331536e-01f, 1.74248859e-01f, -7.76228458e-02f, 1.09538086e-01f, 1.86137512e-01f, 1.96167216e-01f,
  6.94882125e-02f, -3.36306803e-02f, -1.27823383e-01f, 1.07116632e-01f, 1.61002621e-01f, -8.47820342e-02f, 4.61128764e-02f, -1.69830676e-02f, 2.39055548e-02f, -2.25783642e-02f,
  1.32728770e-01f, 4.13368605e-02f, 8.76078010e-02f, 9.31996703e-02f, -3.53696980e-02f, 8.14753398e-02f, -7.60105997e-02f, -2.58055866e-01f, -1.47315040e-01f, 4.84537557e-02f,
  2.87752211e-01f, 5.26491702e-02f, 7.99629837e-03f, -2.06206851e-02f, -8.09701458e-02f, 2.60879402e-04f, 7.17774704e-02f, 7.45963491e-03f, -1.24021038e-01f, -5.27004488e-02f,
  -1.98740326e-02f, -1.49005596e-02f, 9.29814577e-03f, -2.81356052e-02f, 3.66686173e-02f, -6.27933582e-03f, -7.38350451e-02f, 6.03319034e-02f, -2.14549694e-02f, 4.78562750e-02f,
  -4.31130901e-02f, -6.24752380e-02f, 7.10243778e-03f, -9.85690355e-02f, 1.03741251e-01f, -7.94596598e-03f, -1.32172331e-02f, -1.35887666e-02f, 7.75795132e-02f, -3.89534347e-02f,
  -3.44450884e-02f, 2.15201615e-03f, -6.35844693e-02f, 7.24259317e-02f, -3.57831419e-02f, -4.63683642e-02f, -8.98073800e-03f, 9.62098390e-02f, 1.09864660e-01f, 5.12135886e-02f,
  -5.70143647e-02f, -2.03985423e-01f, 2.64164824e-02f, 3.15678865e-02f, -6.17480278e-02f, 1.77824534e-02f, 1.61630157e-02f, -4.82452996e-02f, -4.12678532e-02f, -4.88530621e-02f,
  -1.95755810e-02f, -2.92648152e-02f, 2.50962377e-02f, 2.68164258e-02f, -1.98617987e-02f, 8.78221169e-02f, 7.70453513e-02f, -8.16278607e-02f, 3.63814202e-03f, 1.74013693e-02f,
  5.38276769e-02f, -8.58947858e-02f, -2.00955436e-01f, -2.94766314e-02f, 9.19452086e-02f, -5.56675158e-02f, 1.90989915e-02f, 1.89378429e-02f, -1.88117087e-01f, -1.00422330e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.45051497e-01f, 1.27115339e-01f, 1.79835036e-02f, -2.59160727e-01f, -1.18744761e-01f, 2.66704261e-02f, 1.39881700e-01f, -1.48481820e-02f, -9.34269503e-02f, 6.73757214e-03f,
  1.11402251e-01f, -1.06311953e-02f, -1.01822644e-01f, -9.63269025e-02f, -9.72196311e-02f, 1.01445571e-01f, 1.03932515e-01f, -1.01194009e-01f, -1.65107608e-01f, -5.69649413e-02f,
  -9.97146517e-02f, -2.06893131e-01f, -2.16638729e-01f, -1.12845816e-01f, 1.29722757e-02f, -1.02758696e-02f, 4.60005403e-02f, -8.09146091e-02f, 5.84550388e-02f, -9.63692321e-04f,
  2.94096828e-01f, -1.60122618e-01f, -8.41107965e-02f, -6.15304299e-02f, -4.06258227e-03f, -4.99846414e-02f, 1.74921136e-02f, -1.11497626e-01f, -1.21020682e-01f, 1.05710160e-02f,
  -5.23623861e-02f, -1.71723880e-03f, -8.39687958e-02f, -1.20076826e-02f, 5.44322729e-02f, 3.94069776e-02f, -4.96413261e-02f, 4.96259034e-02f, -7.06560090e-02f, 1.16738163e-01f,
  9.23491269e-02f, -1.30403340e-01f, -3.89712192e-02f, -1.03507079e-02f, -3.12074786e-03f, -1.23683922e-01f, 5.23317419e-02f, -6.95618838e-02f, -9.04863849e-02f, 3.93160712e-03f,
  1.33627489e-01f, 4.30695564e-02f, -3.55710201e-02f, -1.51544577e-02f, 2.00124756e-02f, -5.34823649e-02f, -2.34682653e-02f, -2.53619850e-02f, -6.25542318e-03f, 5.66969020e-03f,
  -4.32292894e-02f, 6.30783811e-02f, 8.57601594e-03f, -2.72600614e-02f, -1.16912406e-02f, -7.38704503e-02f, -1.29940351e-02f, 2.78878510e-02f, 5.83686419e-02f, -6.56126365e-02f,
  3.26894340e-03f, -3.38312611e-02f, -1.57255251e-02f, -3.43481153e-02f, 7.71633685e-02f, 1.92545000e-02f, -9.28121507e-02f, -3.91317308e-02f, -5.53082302e-03f, -3.25094499e-02f,
  1.55375645e-01f, -1.63859382e-01f, 4.93642278e-02f, -9.51198023e-03f, -6.60569444e-02f, 4.99242544e-02f, -5.78862801e-02f, 3.04746209e-03f, -7.18230382e-02f, 7.42836371e-02f,
  4.37370362e-03f, 7.11379573e-03f, 1.71903223e-02f, 5.63338883e-02f, 1.48366215e-02f, 4.36293706e-02f, 9.13672894e-03f, 4.15403210e-02f, 4.17509302e-03f, 1.07949823e-02f,
  1.11349523e-01f, 7.95304850e-02f, 7.00036734e-02f, 8.66659582e-02f, 1.47775365e-02f, -3.13498601e-02f, 1.60012066e-01f, 8.81002545e-02f, 6.37806728e-02f, 2.37519667e-01f,
  3.78995910e-02f, -2.61251360e-01f, -3.72070700e-01f, -5.73261008e-02f, 1.53568117e-02f, 3.78233120e-02f, -1.16967456e-02f, -1.07301094e-01f, -3.15481834e-02f, -5.21983318e-02f,
  -8.97994339e-02f, -2.40626875e-02f, -1.17653973e-01f, -9.07455310e-02f, -7.69047290e-02f, -2.87397772e-01f, -1.63563833e-01f, -2.16997772e-01f, 1.03782557e-01f, 2.19300270e-01f,
  4.11061086e-02f, -3.59222628e-02f, -1.21014275e-01f, 4.10080701e-02f, -2.49319114e-02f, -2.92718560e-02f, -6.31319061e-02f, -1.91749707e-02f, 1.85083244e-02f, -1.19214892e-01f,
  -2.96239145e-02f, -3.41350324e-02f, -2.11313888e-02f, 4.31992821e-02f, -7.92619884e-02f, 4.57852520e-03f, 4.35322225e-02f, -2.23801378e-03f, -5.39597049e-02f, -1.27156615e-01f,
  2.01187823e-02f, -1.95495710e-02f, -7.29805529e-02f, 7.14537799e-02f, -2.25137006e-02f, 2.11008620e-02f, -1.29270822e-01f, -1.66498676e-01f, -1.20328791e-01f, 7.07933381e-02f,
  -3.46888378e-02f, 2.82167904e-02f, -3.01404838e-02f, -1.53600320e-01f, 1.40173323e-02f, 3.98174599e-02f, -4.58649397e-02f, 1.42758526e-02f, -1.51542500e-01f, -1.17536023e-01f,
  9.24021825e-02f, 4.50703651e-02f, -1.07331434e-02f, 6.92251325e-02f, 6.91391751e-02f, -5.75589500e-02f, -2.55213864e-02f, 9.94889345e-03f, -2.56471578e-02f, -2.65166108e-02f,
  6.02984466e-02f, -9.75858197e-02f, 4.41923738e-02f, -5.43468520e-02f, -8.76626596e-02f, -5.21275066e-02f, -6.17410894e-03f, -1.06849045e-01f, -8.04214999e-02f, 9.15617421e-02f,
  1.82281318e-03f, 2.93221492e-02f, 7.13324919e-02f, -2.04003863e-02f, -7.00998902e-02f, -1.03052743e-02f, 5.88168167e-02f, 1.12852916e-01f, -5.02505116e-02f, -5.07018007e-02f,
  -1.33467214e-02f, -1.45549506e-01f, -2.19159313e-02f, -1.92246903e-02f, -3.83068211e-02f, -4.42190543e-02f, -7.58545548e-02f, -6.13637678e-02f, 5.24327829e-02f, 2.87638344e-02f,
  7.45450780e-02f, 5.06000128e-03f, -1.09250009e-01f, 8.52098614e-02f, 5.56162149e-02f, 5.86949438e-02f, -1.62931755e-02f, -4.25935127e-02f, -4.64052036e-02f, 5.66623993e-02f,
  -1.37793452e-01f, -7.33290985e-02f, -1.27141833e-01f, -9.64726806e-02f, -2.65167728e-02f, -7.57825077e-02f, -4.62216362e-02f, -7.78823644e-02f, -2.03655094e-01f, -1.07651979e-01f,
  1.20907903e-01f, 5.74593395e-02f, -4.12458666e-02f, 1.65326864e-01f, -2.44270917e-02f, -1.03153527e-01f, 6.28556078e-03f, -1.25027951e-02f, 1.29551440e-01f, 1.14581488e-01f,
  2.00589234e-03f, -2.89697163e-02f, 4.98058535e-02f, 8.44230279e-02f, -1.42072607e-02f, 1.54812038e-01f, 8.24564844e-02f, 9.22540352e-02f, 8.57260674e-02f, 1.46534620e-02f,
  1.06664881e-01f, 1.24630816e-01f, 1.09218918e-01f, 5.35261557e-02f, 1.84974164e-01f, 5.47024161e-02f, 7.13905096e-02f, -1.11321583e-02f, 5.43573387e-02f, 3.69424492e-01f,
  -2.75096893e-02f, -7.82604143e-02f, -9.31284875e-02f, 2.19833814e-02f, -1.31402284e-01f, 2.02301238e-03f, -7.69411996e-02f, -8.95417780e-02f, 1.40623236e-02f, 6.13931529e-02f,
  -8.96382555e-02f, 9.51235965e-02f, 2.34517511e-02f, 8.13299567e-02f, -2.46449877e-02f, -1.71556603e-02f, 2.05036364e-02f, 5.22234663e-03f, -3.14391069e-02f, -3.45960185e-02f,
  6.91347495e-02f, -1.24567114e-02f, -1.61405519e-01f, -8.20833519e-02f, -2.66032312e-02f, 3.56074423e-02f, -5.61773852e-02f, 4.70751338e-02f, -3.09673492e-02f, -1.84720811e-02f,
  -1.28001189e-02f, -6.74754567e-03f, 6.23612814e-02f, 3.54614556e-02f, 8.74619931e-02f, 4.15671878e-02f, -7.23123492e-04f, 7.94106945e-02f, 2.97016725e-02f, -4.38393978e-03f,
  -3.02392635e-02f, -6.29586726e-02f, 9.95894801e-03f, 4.20518331e-02f, 1.50102079e-02f, 3.80101651e-02f, -2.13553868e-02f, 8.27627331e-02f, -5.65787666e-02f, 2.27628835e-02f,
  -3.67282294e-02f, 6.63156882e-02f, -8.42906013e-02f, -3.32257859e-02f, -3.70696448e-02f, 3.96403708e-02f, 3.88547629e-02f, -6.26036432e-03f, 3.48517299e-02f, -4.85073701e-02f,
  -9.90908816e-02f, -2.69877076e-01f, 1.67128339e-01f, 1.41724907e-02f, -1.02706417e-01f, -1.13528192e-01f, 3.40869501e-02f, -8.34976360e-02f, -7.98457414e-02f, 8.11038911e-02f,
  -1.12929344e-01f, 3.93981449e-02f, -1.40435532e-01f, -8.31820890e-02f, -3.96203361e-02f, -2.27550212e-02f, 3.49007957e-02f, -2.41928007e-02f, 3.85585651e-02f, -5.68336248e-02f,
  -7.12701231e-02f, 2.05301512e-02f, -1.11325093e-01f, -2.15171240e-02f, 3.14582586e-02f, -1.09540001e-01f, -1.22166947e-01f, -9.02103167e-03f, -1.34772494e-01f, -1.08541496e-01f,
  -6.45318106e-02f, 2.28343233e-01f, -7.70005807e-02f, 2.10266367e-01f, 1.97444916e-01f, -5.66007756e-02f, 8.83969069e-02f, 5.78570105e-02f, 1.01599462e-01f, 5.00752330e-02f,
  4.93707582e-02f, -2.92285788e-03f, 4.56765741e-02f, -1.37246832e-01f, -1.94607556e-01f, 2.87722647e-02f, 2.20625196e-02f, -2.29370862e-01f, -2.15295956e-01f, -1.09595090e-01f,
  1.24788955e-02f, 4.15929332e-02f, -1.67787731e-01f, -9.93796159e-03f, 9.55011323e-02f, 9.79935229e-02f, 1.14621297e-01f, 1.01198345e-01f, 3.00169960e-02f, 1.63580969e-01f,
  -7.61473924e-02f, 6.14064001e-02f, -6.61048815e-02f, 1.49921961e-02f, 7.82255530e-02f, -4.97103259e-02f, -4.92372662e-02f, -4.54530977e-02f, -8.49417523e-02f, -1.36776373e-03f,
  6.27029836e-02f, 4.17438559e-02f, 9.20916535e-03f, -6.81973100e-02f, -9.79818217e-03f, -7.50192776e-02f, -1.32887155e-01f, -1.87295958e-01f, -1.63544342e-01f, -8.89555961e-02f,
  -1.18782297e-02f, 1.38114378e-01f, -2.02487353e-02f, -9.88967493e-02f, -6.59718318e-03f, -1.36188120e-01f, -2.94639114e-02f, 7.80236209e-03f, -1.78472936e-01f, 2.52098381e-03f,
  -7.31510967e-02f, 7.31668845e-02f, -1.24835847e-02f, 2.81438939e-02f, 6.20772652e-02f, 4.26602699e-02f, 5.84722590e-03f, -4.67717939e-04f, 1.52863748e-02f, -9.48426221e-03f,
  2.88923420e-02f, -6.01534769e-02f, 3.21416929e-02f, 2.09096372e-02f, -2.53320597e-02f, -5.91125973e-02f, 4.84731644e-02f, -6.60001636e-02f, -1.71504095e-02f, -7.64975622e-02f,
  1.09138666e-02f, -8.47752541e-02f, 8.97065678e-04f, -2.93918489e-03f, 2.28738356e-02f, 2.23755129e-02f, -6.83130026e-02f, -2.37897728e-02f, -7.26727396e-02f, -8.34056735e-03f,
  -1.73642356e-02f, -4.06822748e-02f, -1.34789929e-01f, -8.25310722e-02f, -2.12744270e-02f, -7.87354857e-02f, 2.45085377e-02f, 4.39678505e-03f, 7.05653504e-02f, -1.43301845e-01f,
  1.69929098e-02f, -9.01513472e-02f, 2.36467961e-02f, -1.94470938e-02f, -1.01398729e-01f, -8.94782096e-02f, 2.90584639e-02f, -8.87574032e-02f, -8.28675628e-02f, 4.29791398e-02f,
  -1.12776928e-01f, -1.39000505e-01f, -8.93914476e-02f, -7.26490021e-02f, -8.39819163e-02f, -7.23257586e-02f, -6.16466515e-02f, -3.42026129e-02f, -1.52755484e-01f, -1.15184978e-01f,
  1.29836887e-01f, 1.13676582e-02f, 3.54290158e-02f, 4.80499044e-02f, -1.60937235e-02f, -1.13429986e-01f, 4.59036268e-02f, 1.22680245e-02f, -2.43799202e-03f, 1.88984182e-02f,
  -3.65838297e-02f, -7.21600652e-02f, -4.25244793e-02f, -7.68293673e-03f, 1.72391236e-02f, 1.21647574e-01f, -5.44238761e-02f, 7.71354064e-02f, -3.70942466e-02f, -5.18388208e-03f,
  -1.08875073e-01f, 2.84240264e-02f, 8.27547386e-02f, 9.56576169e-02f, -9.22965556e-02f, -5.71365468e-02f, 2.49470584e-02f, 1.92987248e-02f, 5.06342910e-02f, 1.79704484e-02f,
  -5.85000440e-02f, -6.37174845e-02f, 8.10736045e-03f, 2.30903141e-02f, 1.06519619e-02f, 7.27848709e-02f, -5.36097512e-02f, -1.73199642e-03f, 6.88124895e-02f, 3.65014039e-02f,
  2.07935255e-02f, -5.04118130e-02f, -1.05171381e-02f, -6.93118051e-02f, 2.78843381e-02f, -7.31595159e-02f, 7.31251016e-02f, 3.60271521e-02f, 3.92435789e-02f, 1.49361035e-02f,
  2.42246240e-02f, -1.24018393e-01f, -2.75869723e-02f, -3.28361876e-02f, 7.29663000e-02f, 1.14230458e-02f, -4.82947864e-02f, 4.79388945e-02f, 6.58587664e-02f, 4.52977158e-02f,
  1.00633919e-01f, -5.19783795e-02f, -6.97487071e-02f, 3.78711820e-02f, 2.28043105e-02f, 2.46248841e-02f, -2.68351007e-02f, -6.06557876e-02f, 7.99091719e-03f, 2.16549449e-02f,
  -5.28260460e-03f, 4.33671474e-02f, 6.21955842e-02f, -3.68920304e-02f, -5.06726839e-02f, 3.51695456e-02f, -4.60796058e-02f, 3.44030862e-03f, 2.34260708e-02f, 5.90399280e-02f,
  -3.61020602e-02f, -9.97045189e-02f, -4.07995693e-02f, -6.77419454e-02f, -7.82316923e-02f, 1.28147854e-02f, 3.63574028e-02f, 2.26747897e-02f, -5.88846654e-02f, -6.12182878e-02f,
  6.21839538e-02f, -5.71889579e-02f, -6.02361374e-02f, 7.89815560e-02f, -8.79976824e-02f, 5.93807213e-02f, -1.16067916e-01f, -7.81349838e-02f, 7.19067231e-02f, -5.86921908e-02f,
  5.23137823e-02f, 9.44856703e-02f, 6.75021634e-02f, 5.68089336e-02f, 1.80018358e-02f, 3.34105105e-03f, 9.48660821e-02f, -1.16110751e-02f, -5.94173744e-02f, 2.99904495e-02f,
  3.76738124e-02f, 8.64634886e-02f, -6.66508393e-04f, 1.24124885e-02f, -1.69915371e-02f, -7.13240132e-02f, -5.57061322e-02f, -1.34360800e-02f, 1.98516715e-03f, 3.49518023e-02f,
  1.85756553e-02f, -5.37598729e-02f, -3.08779981e-02f, 2.43983641e-01f, 8.47391710e-02f, 1.11582786e-01f, -5.73693737e-02f, 9.96551570e-03f, 4.73406017e-02f, 1.99547827e-01f,
  1.93380237e-01f, 3.05260360e-01f, 2.38519073e-01f, 1.87494650e-01f, 6.37666658e-02f, -6.24638461e-02f, -3.28525789e-02f, 2.67534070e-02f, -7.52456300e-03f, 1.62163317e-01f,
  2.02963993e-01f, -2.12465525e-02f, -6.08577989e-02f, 1.32717444e-02f, 1.82684153e-01f, 1.89913467e-01f, 3.20085958e-02f, -1.87350921e-02f, 4.49118875e-02f, 1.10685527e-01f,
  7.28037208e-02f, 9.72423144e-03f, 2.67642401e-02f, 9.43686347e-04f, -7.15637431e-02f, -2.81602759e-02f, 4.30739895e-02f, -2.55052261e-02f, 3.11526768e-02f, -6.60915766e-03f,
  3.73849832e-02f, -4.03366350e-02f, 9.54025313e-02f, 1.31707639e-02f, -1.33817241e-01f, 1.89408381e-02f, -7.88962021e-02f, -7.43020996e-02f, -4.85438295e-02f, 4.36663404e-02f,
  1.38292208e-01f, 6.53708354e-02f, -1.16410308e-01f, -1.00585617e-01f, 1.12922367e-04f, 1.00479379e-01f, -9.82961506e-02f, -4.19513471e-02f, -8.05402547e-02f, 6.01974167e-02f,
  2.76731476e-02f, 2.07251087e-02f, -2.67244186e-02f, -4.68835421e-02f, -2.40250807e-02f, 8.26535374e-02f, 5.57906851e-02f, 1.03186093e-01f, -4.26447652e-02f, -6.11778758e-02f,
  4.33587888e-03f, 1.23905316e-01f, -1.93215143e-02f, -4.88385223e-02f, 7.55008608e-02f, -6.86445599e-03f, -6.39406918e-03f, -2.53450368e-02f, -8.13526809e-02f, 5.83180636e-02f,
  5.10035716e-02f, 3.11123375e-02f, -7.15606660e-02f, -7.15589821e-02f, 3.53073329e-02f, -1.75363868e-02f, 1.13599315e-01f, 7.65234530e-02f, 1.44337723e-03f, -6.07996397e-02f,
  4.14087214e-02f, -2.69531459e-02f, -1.27925351e-03f, -1.03304744e-01f, -3.86967175e-02f, 2.95791011e-02f, 3.42389420e-02f, -4.50482331e-02f, -1.07556723e-01f, 1.12671126e-02f,
  -6.41806200e-02f, 5.14428830e-03f, -2.95468010e-02f, 1.33396713e-02f, -4.04489040e-02f, -9.98547226e-02f, 5.23771159e-02f, 7.64320344e-02f, -7.24382326e-02f, -1.23793952e-01f,
  1.70945898e-02f, -8.02440494e-02f, 3.87443975e-02f, 8.68749842e-02f, -2.13922299e-02f, 3.97526920e-02f, -1.71318501e-02f, -7.59891421e-02f, -9.59988609e-02f, -1.06024489e-01f,
  3.67268205e-01f, 5.43532409e-02f, 3.46210897e-02f, 4.64936756e-02f, -1.35848537e-01f, -1.66380942e-01f, -2.32281923e-01f, -1.01237394e-01f, -6.37277365e-02f, 3.90178189e-02f,
  -3.04715671e-02f, 1.05275095e-01f, 4.62548435e-02f, 8.98576602e-02f, 1.04373671e-01f, -4.59146574e-02f, 9.25210640e-02f, 1.20524913e-01f, 3.92315760e-02f, 6.52586818e-02f,
  1.78950112e-02f, 1.53490767e-01f, 1.85441673e-01f, 1.62298426e-01f, 6.57612085e-02f, 9.80478302e-02f, 7.20745027e-02f, 2.81722583e-02f, 4.69706729e-02f, 1.98902518e-01f,
  1.35544255e-01f, 5.23917414e-02f, -8.45672470e-03f, 4.08278033e-02f, -1.28227742e-02f, 5.11319526e-02f, 2.08883211e-02f, -1.96618121e-02f, 4.28668894e-02f, 4.86602634e-02f,
  7.04222172e-02f, 1.26015067e-01f, 2.74479948e-02f, 3.30812521e-02f, -5.21878675e-02f, -5.19867018e-02f, -3.26574109e-02f, 2.61532515e-02f, -5.00961393e-02f, 4.85210940e-02f,
  4.36449498e-02f, -3.24374735e-02f, -1.13465995e-01f, -6.09622225e-02f, -1.06083803e-01f, -9.66580510e-02f, 5.72615005e-02f, 5.80411740e-02f, 4.06307802e-02f, 1.08680137e-01f,
  -4.25255421e-04f, -5.90193160e-02f, 3.51983197e-02f, 9.21920314e-03f, -5.76095283e-02f, -9.37475562e-02f, 5.26574291e-02f, -4.05545048e-02f, -3.13054211e-02f, 5.87398605e-03f,
  -7.32120052e-02f, -4.36998829e-02f, -7.84326121e-02f, -7.12535307e-02f, -1.01414211e-02f, 4.55832854e-02f, 3.60767153e-04f, 2.02079695e-02f, -4.75952215e-03f, 3.71113569e-02f,
  -3.89508195e-02f, 1.20206047e-02f, -4.48975749e-02f, -7.39705563e-02f, -6.27698153e-02f, -8.35357085e-02f, 1.19470181e-02f, 8.38821288e-03f, -3.25752534e-02f, 1.00650348e-01f,
  -4.94897813e-02f, -1.11139216e-01f, 7.22553730e-02f, 5.67709692e-02f, 7.32944235e-02f, 9.27811563e-02f, 8.18557739e-02f, 4.78486195e-02f, 4.99444641e-03f, -3.22497003e-02f,
  9.51503292e-02f, 7.00808018e-02f, -9.01273414e-02f, -2.14708243e-02f, -4.07070182e-02f, -8.37899819e-02f, 8.53681490e-02f, 8.02633688e-02f, -8.50484744e-02f, 8.92494842e-02f,
  1.05191616e-03f, -6.97156340e-02f, -1.28225446e-01f, -1.15905233e-01f, 1.02949981e-02f, -9.78746861e-02f, -1.69804860e-02f, -1.17841095e-01f, -7.75595307e-02f, -1.44245744e-01f,
  4.82534349e-01f, 3.06907117e-01f, 3.22551340e-01f, -5.15893325e-02f, -2.21313134e-01f, -1.66858643e-01f, 3.54605988e-02f, 3.26986015e-02f, 4.51695286e-02f, 4.08919193e-02f,
  -3.88610736e-02f, 1.87002011e-02f, 5.03377914e-02f, 5.42168021e-02f, 2.78329074e-01f, 5.10972738e-02f, -1.05906492e-02f, 9.70359370e-02f, 2.18155503e-01f, 4.60242592e-02f,
  -8.57431591e-02f, 5.48436902e-02f, 2.42291033e-01f, 1.81963906e-01f, 2.65996065e-02f, -1.95313051e-01f, -6.50810152e-02f, 7.49629214e-02f, 5.73614873e-02f, 4.29353416e-02f,
  7.38860853e-03f, 3.80598962e-01f, -6.41179830e-02f, -8.47064108e-02f, -1.30677775e-01f, 1.69501215e-01f, 6.24362705e-03f, 1.29707292e-01f, -7.94033185e-02f, -7.69513398e-02f,
  -8.61743391e-02f, -6.49645030e-02f, -8.65422189e-02f, -2.62079164e-02f, -1.08238477e-02f, -6.09684177e-02f, 6.57190159e-02f, 1.67524755e-01f, 1.28505230e-01f, 6.49532601e-02f,
  -8.69438797e-02f, -6.96477816e-02f, -6.56866953e-02f, -4.44210097e-02f, 1.13185616e-02f, -1.29965246e-01f, 1.32940076e-02f, 9.90599543e-02f, 2.23960588e-03f, 1.02721527e-01f,
  5.88738825e-03f, 4.07323800e-02f, 1.53424283e-02f, 7.10823312e-02f, 6.34416789e-02f, -8.22567102e-03f, -9.98595846e-04f, -9.23607051e-02f, -2.71452256e-02f, -7.21702129e-02f,
  4.38357554e-02f, -8.20248872e-02f, 3.30842324e-02f, -1.62204839e-02f, -8.74028057e-02f, -7.11859111e-03f, -7.33324289e-02f, 4.72994931e-02f, -5.53278141e-02f, 9.22571216e-03f,
  5.49007067e-03f, 7.73204342e-02f, 9.75055713e-03f, 5.63968904e-02f, 2.93725803e-02f, -4.19932939e-02f, -1.96212269e-02f, 1.32625205e-02f, 5.12281656e-02f, -4.62125614e-02f,
  -2.47464404e-01f, -6.69169798e-02f, -6.34676069e-02f, 8.35183933e-02f, 2.37315390e-02f, 6.01056078e-03f, -3.97218503e-02f, 1.08920738e-01f, -1.11385822e-01f, 5.20170517e-02f,
  -8.61892402e-02f, 4.37097698e-02f, -8.32165405e-03f, 4.48486581e-02f, -8.50272626e-02f, -9.16285533e-03f, -5.49951382e-02f, -4.22701761e-02f, 4.35941257e-02f, -2.25633383e-02f,
  -4.55482416e-02f, -6.71806037e-02f, -1.39534265e-01f, -5.23017198e-02f, -8.92249197e-02f, -8.04818794e-02f, -3.61094475e-02f, 1.10836467e-02f, 1.67362660e-03f, 6.09943867e-02f,
  -1.37194663e-01f, -4.88480777e-02f, -9.21634510e-02f, 1.24264926e-01f, 4.91535757e-03f, 6.34030811e-03f, 1.14698604e-01f, 1.45548195e-01f, 3.16186361e-02f, 5.19956984e-02f,
  9.91276279e-02f, 1.49248883e-01f, 1.17664009e-01f, 9.10295174e-02f, -1.41263343e-02f, 9.32316557e-02f, 1.02211423e-01f, 4.02507596e-02f, 2.31256615e-02f, 2.03473940e-02f,
  6.22381866e-02f, -1.15103805e-02f, -1.47667632e-01f, 7.19465837e-02f, 9.52488184e-02f, 1.01066671e-01f, 5.45511357e-02f, 2.49705371e-02f, 9.17723328e-02f, 6.39487952e-02f,
  -6.39977902e-02f, -3.59150991e-02f, 2.13967469e-02f, 1.72162112e-02f, 5.85087091e-02f, -6.56933486e-02f, 1.00088052e-01f, -7.42510408e-02f, -5.78563325e-02f, 2.23371964e-02f,
  8.63937289e-03f, -5.60171679e-02f, 8.83400887e-02f, -1.72773860e-02f, 1.84760988e-02f, -1.66354422e-02f, -1.34423058e-02f, 1.14118338e-01f, 5.76384040e-03f, 9.32286456e-02f,
  2.62439959e-02f, -7.99608827e-02f, -1.03404513e-02f, 1.52575687e-01f, -4.71201260e-04f, 8.64637867e-02f, -9.98184783e-04f, 4.56391945e-02f, 1.05923623e-01f, 9.73332822e-02f,
  -4.75616492e-02f, 8.22783932e-02f, 9.92717370e-02f, 8.19682851e-02f, -3.16224508e-02f, 1.81315616e-02f, 9.63348076e-02f, -6.77237138e-02f, -1.25733791e-02f, -4.35673408e-02f,
  5.52690998e-02f, 5.91622815e-02f, -3.28806229e-02f, -5.49834333e-02f, 2.53695622e-02f, 6.85639456e-02f, -5.30397668e-02f, -9.90413316e-03f, -7.46897236e-02f, 1.60282310e-02f,
  -2.85747051e-02f, 4.47229436e-03f, 3.42803495e-03f, 6.70661544e-03f, -3.85558270e-02f, 3.36751454e-02f, -3.18822227e-02f, -3.76611724e-02f, -1.82074029e-02f, -1.00354128e-01f,
  -1.93968359e-02f, 5.58174774e-02f, 6.95088729e-02f, 1.22288570e-01f, -3.78429480e-02f, 1.14389630e-02f, -4.03471403e-02f, 1.07271941e-02f, 3.98977520e-03f, 7.77239427e-02f,
  2.89313663e-02f, 2.14741156e-02f, -2.66440772e-02f, -2.32485309e-02f, -4.83432645e-03f, 8.32203031e-02f, -6.24296302e-03f, 1.27013206e-01f, 9.67450514e-02f, 1.94813982e-02f,
  1.08895160e-01f, -5.19371917e-03f, -5.41403964e-02f, 2.08462179e-02f, 1.26677692e-01f, -9.55584086e-03f, -7.30587691e-02f, 9.75882411e-02f, -5.54424375e-02f, -5.01982011e-02f,
  -1.14643902e-01f, -3.62760834e-02f, 2.89958715e-02f, 9.07463059e-02f, 1.45460367e-01f, 1.38405025e-01f, 2.62727663e-02f, 4.26634178e-02f, -6.39371499e-02f, 1.38317505e-02f,
  1.05314322e-01f, -6.00263551e-02f, -4.18967083e-02f, 7.12496191e-02f, -1.01809449e-01f, 4.10950780e-02f, -2.44200765e-03f, 2.40767039e-02f, 2.78074518e-02f, 7.34437332e-02f,
  9.07993764e-02f, 1.59631781e-02f, -1.12005308e-01f, 5.59592582e-02f, 2.91468631e-02f, -7.32688513e-03f, -3.92427519e-02f, 4.40456159e-02f, 3.51765454e-02f, 4.75879349e-02f,
  -1.68705955e-02f, -3.15460153e-02f, 2.06964258e-02f, 8.37093592e-02f, -1.70904752e-02f, -1.43034354e-01f, 7.67038343e-03f, -9.97006968e-02f, 4.48999926e-02f, -9.06799883e-02f,
  4.79087792e-02f, -7.32164681e-02f, 6.62726685e-02f, -1.02864217e-03f, 6.47501741e-03f, -1.18120775e-01f, -1.35744259e-01f, -4.74030199e-03f, -8.89795739e-03f, -3.31310295e-02f,
  -2.79974602e-02f, 1.00779861e-01f, 5.29236011e-02f, -3.64017934e-02f, -9.70763266e-02f, -1.14995338e-01f, -5.91870397e-02f, -5.84232770e-02f, -9.57398787e-02f, -2.72437911e-02f,
  2.91807987e-06f, -2.16665026e-02f, -5.77341057e-02f, -3.47285420e-02f, 4.91271988e-02f, 4.22328785e-02f, -7.81298727e-02f, -1.15225827e-02f, 5.98330423e-02f, 1.57215586e-03f,
  -7.28030875e-02f, -2.98587997e-02f, -4.56282087e-02f, -3.33217233e-02f, -2.10653190e-02f, -1.32765137e-02f, 2.47150194e-03f, 6.13299608e-02f, 8.56131408e-03f, -4.49001640e-02f,
  -4.15840968e-02f, 1.79850645e-02f, 4.74755690e-02f, 2.74503138e-03f, -7.53339904e-04f, -8.06243941e-02f, 2.01365091e-02f, -7.08904266e-02f, -8.08157027e-02f, -7.19416812e-02f,
  -9.43582803e-02f, 1.10349558e-01f, 1.24174999e-02f, -1.08945616e-01f, -9.79264616e-04f, -8.08974728e-02f, 8.69235992e-02f, 5.51997572e-02f, 3.28813680e-02f, -7.06486627e-02f,
  1.85393281e-02f, 3.79252173e-02f, 3.03526539e-02f, -9.04458538e-02f, 5.80099076e-02f, -2.74980497e-02f, -3.17530483e-02f, -6.94208816e-02f, 1.87461339e-02f, -1.22220637e-02f,
  -1.55575518e-02f, -3.91236693e-02f, -1.30201265e-01f, -3.88724431e-02f, -5.31229116e-02f, -1.03942566e-01f, -1.11152351e-01f, 6.97527407e-03f, -8.52288306e-02f, -2.29515601e-02f,
  -1.69846565e-01f, -4.08823080e-02f, 1.43862709e-01f, -1.62349209e-01f, 1.80621713e-01f, 3.33020598e-01f, 3.96205008e-01f, 8.83257687e-02f, -1.55649364e-01f, 3.12216417e-03f,
  -1.09723605e-01f, -2.82401860e-01f, -2.48438045e-01f, -1.52843252e-01f, 2.88568288e-02f, 2.23465875e-01f, 8.55899602e-02f, 2.67437901e-02f, -9.86563563e-02f, 1.56159308e-02f,
  -2.79666781e-02f, -1.84121624e-01f, -1.08990774e-01f, -6.15429133e-02f, -1.15441106e-01f, -1.38543829e-01f, -2.25786585e-02f, -7.48159140e-02f, 1.17252432e-01f, -1.51475504e-01f,
  -2.16547456e-02f, -2.90296227e-02f, -5.92587888e-02f, -1.35301411e-01f, 2.61978321e-02f, -9.21946950e-03f, 6.15206026e-02f, -1.73513874e-01f, -3.23765948e-02f, 5.58275916e-02f,
  -1.58112403e-02f, -1.03121497e-01f, -5.94565123e-02f, 3.59084234e-02f, -2.13301610e-02f, -2.37080455e-02f, 2.40560472e-02f, 1.84299126e-02f, -1.18527524e-01f, 1.04505710e-01f,
  -2.62299217e-02f, 1.27252802e-01f, 8.24090764e-02f, 7.10033402e-02f, 2.38006469e-02f, -5.66537604e-02f, 7.69036785e-02f, 2.63197308e-05f, -1.99186262e-02f, -4.99421284e-02f,
  2.49039736e-02f, 3.86878513e-02f, 1.62092969e-02f, -2.85561243e-03f, 7.29848668e-02f, 1.91177316e-02f, -1.24780852e-02f, -3.44001193e-04f, 3.91371325e-02f, 3.43473479e-02f,
  -3.26981321e-02f, 5.93312979e-02f, -5.46610430e-02f, -1.89760141e-02f, 2.29264842e-04f, -6.49629086e-02f, 3.54687162e-02f, 4.10542749e-02f, 2.95619555e-02f, -3.84817608e-02f,
  5.76439388e-02f, -5.49649401e-03f, -2.61912774e-03f, -6.55863658e-02f, -6.65734708e-03f, 7.80051574e-02f, 1.16146309e-02f, 3.65461633e-02f, -5.43965138e-02f, -1.72168463e-02f,
  -3.27302903e-01f, 1.39558524e-01f, -5.21197692e-02f, -1.30370766e-01f, -6.68407883e-03f, -1.45287684e-03f, -7.38618746e-02f, 2.45726090e-02f, -6.77788705e-02f, -3.61710042e-02f,
  -6.19718730e-02f, -1.11911535e-01f, -9.75968838e-02f, 8.12375844e-02f, -4.33495594e-03f, -1.46147853e-03f, 1.20669059e-01f, -8.61678198e-02f, -1.65875200e-02f, 1.10990286e-01f,
  7.66267953e-03f, 1.27295658e-01f, -6.45132363e-02f, -8.88759177e-03f, 9.34836343e-02f, 6.83371127e-02f, 2.07711775e-02f, 1.06031887e-01f, 5.77369966e-02f, 9.79229435e-02f,
  8.12577922e-03f, -2.27975726e-01f, 2.56457359e-01f, 1.41973972e-01f, 1.75201446e-01f, 1.45193741e-01f, 7.08490610e-02f, 1.00023806e-01f, 3.81522477e-02f, -9.22282934e-02f,
  -2.04896986e-01f, -1.97928116e-01f, -1.43228516e-01f, -1.56484634e-01f, -6.93675578e-02f, 6.55456781e-02f, 1.20171912e-01f, 6.59785122e-02f, 2.32962176e-01f, 1.56392679e-01f,
  -7.18253478e-02f, 8.89121592e-02f, -5.93885891e-02f, 1.01896480e-01f, -3.32149230e-02f, -1.57777891e-02f, -2.86036115e-02f, -7.14164153e-02f, -1.08909514e-02f, -1.46630285e-02f,
  8.38519260e-03f, -3.25935357e-03f, 2.95488145e-02f, -1.50055036e-01f, -7.61872828e-02f, -6.05390593e-02f, 9.96762812e-02f, 2.45618336e-02f, -3.94862555e-02f, 8.91885161e-02f,
  -8.99539143e-02f, -8.13422799e-02f, -8.53934661e-02f, 4.20416519e-02f, 7.48180971e-02f, -3.50896716e-02f, -7.31210113e-02f, -2.70662587e-02f, -1.07268862e-01f, -6.08127788e-02f,
  -1.84193373e-01f, 4.34863456e-02f, 1.31156519e-01f, -6.40201122e-02f, -3.90516669e-02f, -5.99975921e-02f, -9.91892144e-02f, -7.30818659e-02f, -1.07446657e-02f, 3.63967679e-02f,
  -6.81883618e-02f, 3.22532207e-02f, 2.72094589e-02f, -9.11710486e-02f, -1.04059549e-02f, -2.36265175e-02f, 1.02951325e-01f, -2.45149247e-02f, -2.78484393e-02f, 7.86479935e-02f,
  -4.90298271e-02f, 1.01061866e-01f, -4.35773991e-02f, -4.17623110e-02f, -5.02522103e-02f, 6.81126788e-02f, 4.70395498e-02f, -5.45162000e-02f, 2.33780537e-02f, -3.26110683e-02f,
  -3.15710418e-02f, -2.21386384e-02f, 5.21781556e-02f, -7.63788000e-02f, 3.58962603e-02f, -2.58500241e-02f, 7.88095742e-02f, 8.54384061e-03f, 6.23114556e-02f, 3.01398523e-02f,
  -1.46825626e-01f, -5.25233373e-02f, 7.50623271e-02f, -6.17919676e-02f, 8.79349783e-02f, 4.15405929e-02f, -3.72577943e-02f, -9.47220176e-02f, -2.46323254e-02f, 3.88557129e-02f,
  -3.17780003e-02f, -5.36029115e-02f, -3.87052037e-02f, 1.34161646e-02f, 1.77762151e-01f, 2.50569116e-02f, -4.39952128e-02f, 5.85969836e-02f, -8.26889575e-02f, -9.34560671e-02f,
  -1.14818685e-01f, 1.44599602e-01f, 1.83981672e-01f, 5.84293753e-02f, 8.83622393e-02f, 1.98095277e-01f, 1.04407847e-01f, 1.74025819e-01f, 1.54251412e-01f, 1.22594751e-01f,
  -7.59455115e-02f, -2.49611422e-01f, 1.72571484e-02f, 2.32309237e-01f, 3.22524816e-01f, 3.08417082e-01f, 1.54024869e-01f, 1.12170212e-01f, 1.77285001e-01f, -2.48013269e-02f,
  -3.64785679e-02f, 3.19058336e-02f, 1.13775872e-01f, -5.56331649e-02f, 1.66184995e-02f, 1.46877438e-01f, 9.56081823e-02f, 1.57092184e-01f, 2.07199499e-01f, 1.15460917e-01f,
  2.64389887e-02f, 4.48034555e-02f, -9.67188701e-02f, -9.57206576e-05f, 6.71202540e-02f, 4.60296161e-02f, 1.30136952e-01f, -5.31846378e-03f, -2.63940636e-02f, 1.57764807e-01f,
  -1.68018401e-01f, -1.09395124e-01f, 1.83135942e-01f, -5.31077571e-03f, -6.09166771e-02f, -4.61245961e-02f, 3.34880687e-02f, -4.20760550e-02f, -1.27312839e-01f, 3.44705731e-02f,
  -1.16502434e-01f, -3.63232382e-02f, 4.03728634e-02f, -5.35440519e-02f, 2.81610701e-04f, 3.63791585e-02f, -6.83021694e-02f, -3.67113613e-02f, -3.70587409e-02f, -3.91426422e-02f,
  -2.24304814e-02f, -6.79763258e-02f, 8.02292153e-02f, -5.72873987e-02f, 1.20425271e-02f, -1.27634555e-02f, -5.48588075e-02f, -5.02904579e-02f, 4.79847081e-02f, -3.72155830e-02f,
  3.71287490e-04f, -4.46212813e-02f, 8.56397301e-02f, 2.87376679e-02f, 6.94367141e-02f, 8.58404934e-02f, 2.90198810e-02f, 1.63579534e-03f, -3.41154523e-02f, 3.70592549e-02f,
  7.39706680e-03f, -1.61456764e-02f, 4.28217351e-02f, 1.40344091e-02f, -3.92309092e-02f, -2.71148104e-02f, 3.60524133e-02f, -7.88243022e-03f, 4.44485433e-02f, 8.61244928e-03f,
  1.76708251e-02f, 9.48773474e-02f, 6.43777624e-02f, 2.91129425e-02f, -3.97287235e-02f, -1.81239359e-02f, -9.37397312e-03f, -5.43058403e-02f, -3.46541591e-02f, -3.69781479e-02f,
  -4.12475914e-02f, -4.63398173e-02f, 1.37220234e-01f, 4.23421226e-02f, 4.03151615e-03f, -1.41489521e-01f, -1.68497823e-02f, 4.01243940e-02f, -1.06766693e-01f, -4.97896895e-02f,
  -1.28001004e-01f, 3.98348048e-02f, -1.02696069e-01f, 6.42036833e-03f, 3.91301662e-02f, -1.95280686e-02f, -8.22730139e-02f, 1.74524002e-02f, 4.67375405e-02f, -1.21012069e-01f,
  -1.13942765e-01f, 7.91017860e-02f, 3.98029238e-02f, 1.26653343e-01f, 1.27841741e-01f, 1.68905005e-01f, 6.45639896e-02f, -2.67599504e-02f, 1.56647712e-01f, 1.21188350e-01f,
  -1.04379915e-02f, -2.72558600e-01f, 2.40834475e-01f, -2.37552807e-01f, -2.04192042e-01f, -2.18846217e-01f, -2.58355349e-01f, -1.37235090e-01f, -1.99355870e-01f, -1.19384505e-01f,
  -7.43747354e-02f, 8.01183805e-02f, 2.84513116e-01f, 1.55120507e-01f, 9.32203382e-02f, -1.06297873e-01f, -4.41598780e-02f, 3.19104314e-01f, 3.42511982e-01f, -3.23143937e-02f,
  -4.41914536e-02f, -4.30511199e-02f, 3.58168893e-02f, -3.36150452e-02f, -1.48247793e-01f, -5.32908179e-02f, 3.62988822e-02f, -1.14885546e-01f, 7.18702748e-03f, -7.62177408e-02f,
  1.75954744e-01f, -1.41399190e-01f, 3.55673023e-02f, 1.59883015e-02f, 4.37276289e-02f, -8.13180059e-02f, 3.81905660e-02f, -2.33774558e-02f, 2.73575839e-02f, -7.20889196e-02f,
  -8.94516408e-02f, 5.45241572e-02f, -1.64693817e-02f, -5.84571771e-02f, -1.95889659e-02f, -9.82315615e-02f, -8.20717216e-02f, 1.08861588e-01f, 3.98364663e-02f, -7.69335702e-02f,
  -8.70772526e-02f, -1.50177881e-01f, -8.82632006e-03f, 3.18117552e-02f, 6.46845922e-02f, 1.28358990e-01f, 4.25324477e-02f, -1.10383136e-02f, 1.26205832e-01f, -2.23046154e-01f,
  -7.79145360e-02f, 8.79891440e-02f, 4.16397564e-02f, -6.26277179e-02f, -9.17715579e-03f, 3.16172130e-02f, -4.14756089e-02f, 5.11125624e-02f, -5.10264980e-03f, -3.26430425e-02f,
  9.36167911e-02f, -3.01223435e-02f, 1.85365342e-02f, -1.63453817e-02f, 3.75945158e-02f, -8.41925107e-03f, -1.46713993e-02f, -2.51691621e-02f, 4.82353158e-02f, 1.01277390e-02f,
  4.43618558e-02f, 4.86661866e-02f, -4.71197143e-02f, 1.46855656e-02f, -4.45303321e-02f, -3.70622352e-02f, 6.27305591e-03f, -1.63155720e-02f, 2.57090293e-02f, -3.61501873e-02f,
  7.51626492e-02f, 2.73783505e-01f, -3.86003554e-02f, -4.47145291e-02f, -1.00099377e-01f, 3.59913260e-02f, 1.21812886e-02f, -2.68658102e-02f, -7.44317891e-03f, 2.04590466e-02f,
  -1.70714445e-02f, 2.71988306e-02f, 7.16436133e-02f, -1.00209974e-01f, -6.84203696e-05f, -1.25373565e-02f, -4.92281541e-02f, -2.98407041e-02f, 6.80260360e-02f, -6.78647086e-02f,
  -1.12038605e-01f, -8.65281895e-02f, 1.23475872e-01f, 1.10070117e-01f, -7.23200813e-02f, 1.07742392e-01f, 1.08114026e-01f, 3.32279503e-02f, 1.37455955e-01f, -1.42818734e-01f,
  -6.90999269e-01f, -4.94298409e-04f, -1.33790120e-01f, -2.96592087e-01f, 1.52223378e-01f, 3.72973084e-01f, 3.37429672e-01f, 1.01865187e-01f, -8.07951763e-02f, -3.33197042e-02f,
  1.30524505e-02f, -1.08209951e-02f, -2.81969123e-02f, 1.29164398e-01f, 1.09957166e-01f, 1.21443845e-01f, 6.53761476e-02f, 1.13652023e-02f, 1.10838421e-01f, 2.06380814e-01f,
  3.03711090e-02f, -8.66866112e-02f, -2.79235750e-01f, -4.23065765e-04f, -8.14892352e-02f, -6.41456023e-02f, -1.70300771e-02f, -1.25845745e-01f, 3.76687683e-02f, -9.41055566e-02f,
  -3.63682151e-01f, -1.37645498e-01f, 8.02261569e-03f, 3.02566960e-03f, -1.14169396e-01f, -8.47817212e-02f, -8.89515653e-02f, -3.79664376e-02f, 3.10256761e-02f, -5.50145432e-02f,
  -7.90382549e-02f, -4.50493917e-02f, -1.27096683e-01f, -5.09583540e-02f, -1.06578402e-01f, 1.71757340e-02f, -8.00662115e-02f, -1.09244116e-01f, -4.81434576e-02f, -4.72703725e-02f,
  1.19774185e-01f, -3.80926095e-02f, -2.02745929e-01f, 6.80878833e-02f, 3.95669602e-02f, -1.81936949e-01f, -1.23049572e-01f, -6.89715073e-02f, -1.12817794e-01f, -2.49564707e-01f,
  5.93922520e-03f, 3.24796364e-02f, 7.74867535e-02f, -4.59270962e-02f, -6.74100667e-02f, -1.82055160e-02f, 1.82083752e-02f, 3.38626914e-02f, 1.55585185e-02f, -4.34116349e-02f,
  8.26923400e-02f, -2.39800718e-02f, 1.95499733e-02f, -3.93987373e-02f, -4.10635620e-02f, -2.27605049e-02f, 4.75837663e-02f, -1.05457455e-02f, -3.58872563e-02f, -2.27647293e-02f,
  -3.60667370e-02f, 4.26275246e-02f, -6.28417805e-02f, 1.02018848e-01f, 1.09393977e-01f, -8.77138413e-03f, -4.77402024e-02f, -3.50027196e-02f, -9.41512734e-03f, -9.41836536e-02f,
  -4.06312823e-01f, 1.50400534e-01f, -1.73867673e-01f, -4.59211431e-02f, -3.37893516e-02f, 1.91852488e-02f, -5.13276048e-02f, 6.52618520e-03f, -1.14843629e-01f, -5.48377298e-02f,
  -2.56907870e-03f, -9.16852243e-03f, -9.53080505e-02f, 1.90973692e-02f, 4.49011363e-02f, 3.45102549e-02f, 1.08237527e-02f, -8.56744796e-02f, 5.55824600e-02f, -3.15601937e-02f,
  4.36346084e-02f, -4.44805883e-02f, -1.35546297e-01f, 4.85626282e-03f, -1.24534465e-01f, -1.64261207e-01f, -1.25468150e-01f, -1.51338816e-01f, -1.38222165e-02f, -2.85443276e-01f,
  6.08439259e-02f, -2.77343035e-01f, -2.49731064e-01f, 1.82944778e-02f, -5.55780381e-02f, -1.55010670e-01f, -3.68060827e-01f, -9.48116183e-03f, 1.01748835e-02f, -2.16366544e-01f,
  -2.13639368e-03f, 1.18151933e-01f, 3.73062454e-02f, -9.01515260e-02f, -1.46962687e-01f, -2.74452835e-01f, -1.46326855e-01f, -1.23208780e-02f, -2.89406255e-02f, -7.71309808e-02f,
  -5.23241907e-02f, 1.14090949e-01f, 1.33004680e-01f, 5.91710992e-02f, 4.94781435e-02f, 1.70026533e-03f, 4.12100274e-03f, 6.02342114e-02f, -7.31917098e-02f, -1.35005862e-01f,
  -3.15075815e-01f, -1.24740966e-01f, -4.02995385e-02f, -5.46166115e-03f, 2.59082336e-02f, -6.08680174e-02f, -5.21345623e-02f, 9.25379619e-02f, -5.97440684e-03f, -1.29452497e-01f,
  -4.66438197e-02f, 3.59905586e-02f, 3.63453180e-02f, -5.07477252e-03f, -8.93595889e-02f, -7.79983625e-02f, 7.52132982e-02f, 2.47764830e-02f, 1.04096821e-02f, -6.01172894e-02f,
  -5.31611666e-02f, -1.01918921e-01f, -1.21762820e-01f, 3.93222980e-02f, -3.20161618e-02f, 8.69217813e-02f, -4.36553881e-02f, -1.33439759e-02f, 6.16095634e-03f, -7.09508732e-02f,
  -7.95209557e-02f, -1.55164236e-02f, -9.93851572e-02f, 6.13016114e-02f, -5.34928963e-03f, 3.91613431e-02f, 1.37945302e-02f, -3.62657122e-02f, 5.29898778e-02f, 3.85895930e-02f,
  -5.86501211e-02f, -6.07978515e-02f, 4.86048162e-02f, -3.50065976e-02f, -2.01459695e-02f, 1.08099440e-02f, -6.64178133e-02f, -8.16714317e-02f, 2.75160391e-02f, 3.05104330e-02f,
  -5.63311577e-02f, 2.88528129e-02f, 2.96636336e-02f, 1.12542640e-02f, -1.04450859e-01f, -7.15627521e-03f, 5.23080863e-03f, 1.27992651e-03f, -1.86848808e-02f, 1.14791133e-02f,
  2.95712389e-02f, -6.01629764e-02f, -8.87044296e-02f, -6.22427985e-02f, -5.94200147e-03f, 6.34214878e-02f, -9.79477093e-02f, 1.34333894e-02f, 9.91127044e-02f, -6.78885356e-02f,
  -8.96845907e-02f, -5.39797880e-02f, -8.92163590e-02f, 3.43489908e-02f, 2.16546226e-02f, 6.41170666e-02f, 4.56956998e-02f, -3.67531069e-02f, 7.70527823e-03f, -5.34084961e-02f,
  1.55977588e-02f, -7.51085952e-02f, 1.40252905e-02f, -4.81470153e-02f, -3.45730074e-02f, 9.78142098e-02f, -1.28857613e-01f, -6.72620256e-03f, 2.13390589e-03f, -4.74200957e-02f,
  -1.81550488e-01f, -3.46045904e-02f, 1.69321790e-01f, -9.54427272e-02f, -2.36023329e-02f, 5.17670587e-02f, 3.81815694e-02f, -7.61076808e-02f, -3.54860537e-02f, -8.83998722e-02f,
  3.17352242e-03f, -3.44756320e-02f, -1.23457219e-02f, -3.81452367e-02f, -1.09840184e-01f, -8.74606147e-02f, -6.75001517e-02f, -1.62804574e-01f, -1.37661517e-01f, -8.74288380e-02f,
  -1.27187490e-01f, -1.46708742e-01f, -1.84922114e-01f, -4.33385707e-02f, -1.03407085e-01f, -1.76814765e-01f, -7.04534352e-02f, -1.51980340e-01f, -5.72904907e-02f, -2.01123327e-01f,
  1.10307984e-01f, 2.20051706e-01f, -6.11712150e-02f, -6.90249130e-02f, 5.03014214e-02f, 1.00343339e-02f, 6.63504750e-02f, 7.04494771e-03f, 4.60817665e-02f, -3.73611115e-02f,
  7.48919398e-02f, 4.17453758e-02f, -9.33685675e-02f, 2.67052185e-02f, -4.82621714e-02f, -9.80193019e-02f, -2.89243143e-02f, 1.19139785e-02f, 6.04366586e-02f, 5.02069481e-02f,
  4.90309857e-02f, -1.14997640e-01f, -2.87513831e-03f, -4.25581671e-02f, -6.38534352e-02f, 1.05147697e-02f, -1.21159060e-02f, -5.30020669e-02f, 1.61546599e-02f, -4.44446057e-02f,
  1.51261995e-02f, -3.36056091e-02f, -3.20246331e-02f, 7.54190888e-03f, -3.00177261e-02f, -8.79168883e-03f, 1.99500211e-02f, 4.06161956e-02f, -1.89612098e-02f, -1.03010796e-01f,
  -1.67563949e-02f, 1.13246545e-01f, 7.36876763e-03f, -5.68141788e-02f, 6.36025444e-02f, -1.93704609e-02f, -1.10428087e-01f, 1.71481236e-03f, -8.00687596e-02f, -1.13538401e-02f,
  1.97563712e-02f, -4.28560786e-02f, -5.36435619e-02f, -2.00684350e-02f, -2.70782635e-02f, -6.07612217e-03f, -4.28277962e-02f, 2.03247741e-02f, 9.81298313e-02f, -3.09582744e-02f,
  -6.09949343e-02f, 1.84051290e-01f, 2.40794625e-02f, -9.76197273e-02f, -1.46874841e-02f, -7.50672072e-02f, 9.49654821e-03f, -3.14434543e-02f, 1.33700762e-02f, 4.14988250e-02f,
  8.29558000e-02f, -7.52456710e-02f, 9.20244306e-03f, -2.15763971e-02f, 2.20476594e-02f, -6.42433763e-02f, -7.01863468e-02f, -1.63344681e-01f, 3.35526429e-02f, 6.19961917e-02f,
  4.81405109e-03f, -2.03971118e-01f, -2.20612571e-01f, -1.09399877e-01f, -1.00207865e-01f, -4.46215309e-02f, 3.77414264e-02f, 2.79553235e-03f, -7.93500245e-02f, -1.73638672e-01f,
  2.28888020e-01f, 1.38367862e-01f, 5.72271459e-02f, 1.76709481e-02f, -9.06238258e-02f, -1.24348164e-01f, -8.23166519e-02f, -1.05147541e-01f, -1.84667297e-02f, 5.46399578e-02f,
  -8.16112012e-02f, 6.30653650e-02f, -7.27157667e-02f, -1.00864746e-01f, -1.41077131e-01f, -4.50886190e-02f, 1.17352910e-01f, 1.09322429e-01f, -4.72082198e-02f, 6.27186596e-02f,
  1.67698711e-01f, 1.63507491e-01f, 4.42644991e-02f, 1.71618070e-02f, 8.16992447e-02f, -2.92019341e-02f, 7.67333200e-03f, 1.00699656e-01f, 1.00937970e-01f, 9.46457461e-02f,
  1.10485457e-01f, -8.53642076e-03f, 7.84891285e-03f, 1.19955428e-01f, 5.38470373e-02f, -8.90404508e-02f, -8.97400081e-02f, -3.50759365e-02f, 6.41214475e-02f, -3.00610848e-02f,
  2.50318870e-02f, -7.44339172e-03f, -5.25067449e-02f, 2.00990401e-03f, 7.47813955e-02f, 7.68547580e-02f, -9.97312926e-03f, 1.38424337e-02f, -1.28007263e-01f, 4.40291762e-02f,
  -2.74953861e-02f, 1.23026773e-01f, -1.06002782e-02f, -1.37386948e-01f, -9.57122594e-02f, -2.32421234e-02f, -1.37781918e-01f, -1.53415967e-02f, -5.94516844e-02f, 5.46761826e-02f,
  9.45855305e-03f, -7.11149490e-03f, -7.12051392e-02f, 5.82349114e-02f, -7.64451697e-02f, 5.99560421e-03f, -7.81123936e-02f, 7.27274502e-03f, 3.25936526e-02f, -1.72136370e-02f,
  -2.19072979e-02f, -6.97809383e-02f, 6.54195473e-02f, -7.71879405e-02f, 3.39516997e-02f, -8.63290429e-02f, -2.11794637e-02f, 6.72121942e-02f, -2.38427967e-02f, 1.07555389e-02f,
  2.29092781e-02f, 5.50280958e-02f, -1.37073342e-02f, -5.90862930e-02f, 3.92925665e-02f, -8.40980336e-02f, -1.34110451e-02f, -9.22758058e-02f, -4.72236313e-02f, 2.50495300e-02f,
  -7.83302262e-02f, -1.94272965e-01f, 3.88268987e-03f, 8.85012150e-02f, 6.39052242e-02f, 3.46705392e-02f, -5.78804612e-02f, -1.04971640e-02f, -9.46486816e-02f, 7.07613602e-02f,
  1.97385885e-02f, -8.88087898e-02f, 1.60319824e-02f, -1.07871152e-01f, -5.24886213e-02f, -4.54310402e-02f, 7.27652386e-03f, -6.56609461e-02f, 2.72445325e-02f, -1.20844599e-02f,
  -7.73866475e-02f, -3.94503661e-02f, -8.15047920e-02f, -1.62040386e-02f, -8.37673023e-02f, -6.24289811e-02f, -1.36006266e-01f, -6.36150967e-03f, -8.70360732e-02f, -7.48729482e-02f,
  3.71180356e-01f, 3.84274125e-01f, 2.86949933e-01f, 1.14398248e-01f, 1.07967533e-01f, 1.61459818e-01f, 3.72420460e-01f, 2.65945226e-01f, -9.55422074e-02f, 6.76261932e-02f,
  5.59885800e-02f, -8.83922204e-02f, -1.19912609e-01f, -1.20690860e-01f, 6.19447082e-02f, 4.02768813e-02f, -1.18356027e-01f, -1.10110126e-01f, -5.00810426e-03f, -8.42181072e-02f,
  -1.00538880e-01f, 3.09285857e-02f, 1.36159241e-01f, 2.52572503e-02f, 7.16036325e-03f, -5.61113209e-02f, 1.52947396e-01f, 7.55214393e-02f, 7.14906901e-02f, -5.81344403e-02f,
  -1.22045524e-01f, 3.70475084e-01f, -2.80075580e-01f, -1.13623492e-01f, 5.03718108e-02f, -1.53526226e-02f, -1.75310124e-03f, 5.46100661e-02f, 3.95950228e-02f, 8.78379419e-02f,
  1.20274099e-02f, -4.83627021e-02f, -2.02793702e-02f, -3.19441743e-02f, 1.67323947e-01f, 8.24050158e-02f, 7.41985440e-02f, 1.35916863e-02f, -2.92027835e-02f, -4.48502973e-02f,
  -1.53048322e-01f, 1.58081174e-01f, 1.84451878e-01f, -1.27927642e-02f, 4.55769561e-02f, -1.69360995e-01f, 1.73719689e-01f, 5.72392382e-02f, 1.11202367e-01f, -2.09989166e-03f,
  -7.92816952e-02f, 3.00048348e-02f, 2.45086644e-02f, -4.47878391e-02f, -1.43129975e-02f, -8.19436982e-02f, -2.24596802e-02f, 1.15145668e-02f, -1.51875913e-02f, 8.31901431e-02f,
  5.34489043e-02f, -5.24382703e-02f, 1.09910415e-02f, 3.79479080e-02f, -9.11509246e-02f, 1.32782441e-02f, 8.13474134e-02f, -6.02975860e-02f, -2.70824065e-03f, -2.02072086e-03f,
  2.61490997e-02f, 4.83865514e-02f, -1.01733990e-02f, 2.48237066e-02f, -5.27891656e-03f, -1.04494831e-02f, 9.65772197e-03f, 1.75952504e-03f, 4.21529673e-02f, 2.86771506e-02f,
  -5.63232340e-02f, 1.22306995e-01f, -2.26252168e-01f, -3.92375961e-02f, 1.11125382e-02f, -5.05735120e-03f, -8.76718089e-02f, -5.21755964e-02f, 4.24262583e-02f, 3.41481715e-02f,
  -7.29307253e-03f, 4.60034832e-02f, 4.23006266e-02f, -6.90420493e-02f, -1.77609269e-02f, 2.80067213e-02f, -6.71120882e-02f, -2.05026064e-02f, -7.73558170e-02f, -5.21320440e-02f,
  -1.65045373e-02f, -2.58187018e-03f, 8.42260569e-03f, 2.97020506e-02f, 8.87691695e-03f, -1.78009987e-01f, -9.66475904e-02f, -8.72958601e-02f, 6.06375970e-02f, -2.61843894e-02f,
  1.84604585e-01f, -1.27601206e-01f, -4.55550179e-02f, 5.49071915e-02f, -9.52903181e-02f, -1.30599678e-01f, -9.64974463e-02f, -2.97689456e-02f, -4.89641204e-02f, 8.08792096e-03f,
  -1.19268909e-01f, 2.06280723e-02f, -4.84803356e-02f, 5.79413027e-02f, -7.86388367e-02f, -2.85961423e-02f, 1.63206412e-03f, -1.24929799e-02f, 2.70702019e-02f, 1.08104087e-01f,
  1.05581336e-01f, 1.23328269e-01f, 3.21672074e-02f, 8.72336552e-02f, -1.07196338e-01f, 5.32545187e-02f, 1.80652048e-02f, 1.86221190e-02f, -7.27777258e-02f, -1.57141358e-01f,
  2.66611632e-02f, -9.75610465e-02f, 9.10568535e-02f, 3.59546319e-02f, -7.67861307e-02f, 1.23590948e-02f, -2.31607165e-02f, -1.17877088e-02f, -4.92288619e-02f, -3.79932635e-02f,
  -7.37276375e-02f, 1.76315773e-02f, -3.03294379e-02f, 5.14992401e-02f, -4.23226058e-02f, -5.91163151e-02f, -5.68584576e-02f, -6.45397976e-02f, 6.44841641e-02f, -8.98757279e-02f,
  -8.26705694e-02f, -4.05595228e-02f, 8.63382444e-02f, -7.77819529e-02f, -1.11623406e-01f, 2.89102215e-02f, -3.79706994e-02f, -2.24371422e-02f, 2.85751540e-02f, -1.00741699e-01f,
  6.40696660e-02f, -7.16914907e-02f, -5.87414019e-02f, 4.34695296e-02f, -7.52347559e-02f, -9.03738961e-02f, 4.84824702e-02f, 3.89237441e-02f, -5.96847124e-02f, 3.47391404e-02f,
  -6.47984967e-02f, -6.66756704e-02f, -7.73090199e-02f, -5.77479638e-02f, 5.77438287e-02f, -7.57588297e-02f, -6.44114763e-02f, -3.75025719e-02f, 4.49514762e-03f, 2.40443703e-02f,
  -4.34495509e-02f, -2.91068573e-02f, -1.71341654e-02f, -8.32926333e-02f, -3.62966023e-02f, 2.66050957e-02f, -6.75380677e-02f, -9.34771262e-03f, -8.03086832e-02f, -7.80660659e-02f,
  6.96468353e-02f, 1.48309737e-01f, 1.39306992e-01f, 5.68439476e-02f, -7.69592300e-02f, -7.39915520e-02f, 6.61272407e-02f, -1.00492705e-02f, -2.94563510e-02f, -3.94746251e-02f,
  2.58451998e-02f, -1.52956210e-02f, -2.50646211e-02f, -5.84280444e-03f, 1.73576161e-01f, 7.17077553e-02f, 7.66850188e-02f, 7.01849759e-02f, -4.82129082e-02f, -9.80028808e-02f,
  3.26668471e-02f, 5.53458557e-02f, 8.34915638e-02f, 3.17123458e-02f, -2.77926773e-02f, 1.13009229e-01f, 1.99060962e-02f, -7.32383598e-03f, 1.16829947e-01f, 1.77021667e-01f,
  -1.26163453e-01f, -3.06365669e-01f, -2.11579919e-01f, 1.18301844e-03f, -6.18399344e-02f, -7.87158608e-02f, -2.05136538e-01f, 7.42980018e-02f, 1.72897857e-02f, -1.51177645e-01f,
  -5.38123734e-02f, -2.30150670e-02f, 3.71913388e-02f, -8.89870971e-02f, -4.08257432e-02f, -2.80955672e-01f, -2.94206858e-01f, -6.61964267e-02f, 5.96344098e-02f, 1.08044982e-01f,
  -2.41821371e-02f, -1.12884641e-01f, -1.14988852e-02f, 5.77234626e-02f, -6.96019307e-02f, -3.04883067e-02f, -1.87913030e-01f, -1.13573901e-01f, -3.32320556e-02f, -2.18535289e-01f,
  -2.78877635e-02f, 1.20757632e-01f, 2.66132373e-02f, -5.22113405e-02f, 3.48751023e-02f, 4.03488390e-02f, -8.15225020e-03f, 1.51335569e-02f, 9.87597927e-02f, 2.28960235e-02f,
  1.10655902e-02f, -2.93243639e-02f, 2.84664910e-02f, 9.65580642e-02f, -2.92838980e-02f, 7.69482255e-02f, -3.18160802e-02f, 4.21807989e-02f, 2.36326065e-02f, -6.07065782e-02f,
  -9.40946117e-03f, -4.09062319e-02f, 3.00569572e-02f, 8.67250189e-02f, 9.76081863e-02f, -5.75986765e-02f, -6.28403202e-02f, 7.94983208e-02f, 6.81866631e-02f, -1.40418515e-01f,
  -4.18418981e-02f, -7.65749738e-02f, 1.01343151e-02f, 4.28127199e-02f, -1.01330064e-01f, -5.93623258e-02f, -2.72807311e-02f, -8.49272385e-02f, 9.64936763e-02f, -9.80328396e-02f,
  -1.09662302e-02f, 1.27434991e-02f, -9.46362875e-03f, -4.85020988e-02f, -7.55620450e-02f, 5.23551553e-02f, 1.00684296e-02f, 6.06184173e-03f, -5.44985645e-02f, -6.95189908e-02f,
  7.55992457e-02f, -2.08530873e-02f, 4.04009856e-02f, -8.41822997e-02f, -7.68525451e-02f, -5.11170775e-02f, 1.96006726e-02f, -4.92459983e-02f, -1.32179121e-02f, 5.49105816e-02f,
  6.16249815e-03f, 5.84516414e-02f, 2.04357244e-02f, 7.84647167e-02f, 6.98196441e-02f, -3.14316116e-02f, -2.29892582e-02f, -9.32104979e-03f, 2.52438970e-02f, 4.75110337e-02f,
  1.20803356e-01f, -3.57419550e-02f, -9.40322578e-02f, 1.53494934e-02f, -2.54827347e-02f, 6.66067004e-02f, -5.57473190e-02f, 4.95693870e-02f, -6.60554171e-02f, -3.00111249e-02f,
  -1.37362525e-01f, -7.71727040e-02f, -1.12694107e-01f, -3.31129581e-02f, 6.92472160e-02f, -7.02538639e-02f, -7.88747147e-02f, 6.45084232e-02f, -1.23633087e-01f, -2.57111609e-01f,
  -1.58145741e-01f, 1.53182194e-01f, 2.28275801e-03f, 2.14939699e-01f, 1.38144791e-01f, 1.90847471e-01f, 1.99797243e-01f, 1.91624284e-01f, 7.48040825e-02f, 7.47099221e-02f,
  1.60817996e-01f, 1.86960787e-01f, 1.17639951e-01f, 2.26062849e-01f, 1.05615519e-01f, 2.07771361e-01f, 2.18045712e-01f, 7.89035857e-02f, 5.11071570e-02f, -1.65324882e-02f,
  1.55871108e-01f, 3.89367826e-02f, -2.23790556e-02f, -3.67896333e-02f, 6.92166388e-02f, 1.54800087e-01f, -5.09110130e-02f, 9.97544080e-02f, -4.21290994e-02f, 1.40634865e-01f,
  -1.61184773e-01f, -1.10453963e-01f, -3.31835337e-02f, 9.37776044e-02f, 3.20223384e-02f, 4.89078648e-03f, -3.28204148e-02f, -6.79882467e-02f, 1.45441042e-02f, 6.69871224e-03f,
  -7.75830224e-02f, 4.54112664e-02f, 4.63996567e-02f, 5.91787770e-02f, -4.94180210e-02f, -3.36004086e-02f, -1.15975074e-01f, 6.64871326e-03f, -3.56641859e-02f, -4.45985496e-02f,
  1.29820377e-01f, -1.29165594e-02f, -3.88316484e-03f, 9.54551697e-02f, -7.19537288e-02f, 1.60665736e-02f, -4.89210114e-02f, -4.72936721e-04f, -2.04618890e-02f, 2.86878217e-02f,
  7.97776133e-02f, 5.73138073e-02f, -4.76017185e-02f, 2.52026599e-02f, 4.03899774e-02f, -6.99567050e-02f, 3.20054255e-02f, 6.01878725e-02f, -4.32024263e-02f, 3.25680301e-02f,
  3.83260809e-02f, -2.84381788e-02f, -6.80951402e-02f, -1.75217614e-02f, -4.18019034e-02f, -6.71359077e-02f, -1.71124134e-02f, -1.26460968e-02f, 1.61192212e-02f, -1.43689159e-02f,
  -7.85541087e-02f, 1.95764527e-02f, -1.12175405e-01f, 1.73498746e-02f, -4.21551540e-02f, 2.80401576e-02f, 2.27280278e-02f, 6.81246817e-02f, -3.51991574e-03f, -2.78564692e-02f,
  1.80102475e-02f, -6.13188259e-02f, -2.83374321e-02f, 7.80666620e-02f, -1.42127099e-02f, 1.42628849e-02f, 9.51907188e-02f, -5.91593832e-02f, -8.15730914e-02f, -2.53528599e-02f,
  -1.21840239e-02f, -5.59353270e-02f, 4.39700205e-03f, -7.20156580e-02f, -8.30072910e-02f, -1.33461341e-01f, 2.87016407e-02f, -2.52215229e-02f, 1.21325562e-02f, -7.21064657e-02f,
  -2.87585594e-02f, 4.00880389e-02f, -1.06949322e-01f, -7.54139200e-02f, -3.75897400e-02f, -1.06584821e-02f, -4.99202944e-02f, -3.44042964e-02f, -8.50972384e-02f, 1.58466375e-03f,
  -8.21555704e-02f, -1.71092659e-01f, 2.05894932e-03f, -1.08275271e-03f, 1.94744483e-01f, -3.51462290e-02f, -9.17645767e-02f, -1.59226745e-01f, -5.68700098e-02f, -3.79446372e-02f,
  1.72566399e-01f, 9.93416235e-02f, 7.47653097e-02f, -5.64356847e-03f, -2.88266391e-02f, -9.77133140e-02f, -1.46384254e-01f, -1.07966736e-01f, 9.37614217e-02f, 6.97978288e-02f,
  1.08957663e-01f, 6.95158765e-02f, -2.32203044e-02f, 1.01637822e-02f, 7.10419789e-02f, -1.18712662e-02f, 6.33400604e-02f, 1.20982900e-01f, -4.46137935e-02f, -1.07303455e-01f,
  -2.87530031e-02f, 4.68701608e-02f, -7.22425571e-03f, 9.06433538e-03f, 5.10731153e-02f, -1.03509374e-01f, -4.52752300e-02f, -6.32696450e-02f, 5.72659597e-02f, 2.66805775e-02f,
  5.38052358e-02f, -3.85322012e-02f, -3.61861140e-02f, -8.06979984e-02f, 4.63492982e-03f, -8.12324062e-02f, 2.21743993e-02f, -8.84765480e-03f, -1.02865286e-01f, 4.66753989e-02f,
  1.10045075e-01f, 2.18934044e-02f, -1.39609724e-02f, -8.15122500e-02f, -3.21002565e-02f, 2.37891190e-02f, -3.18583078e-03f, -3.84702906e-03f, -1.54619515e-01f, -2.17436388e-01f,
  8.06800351e-02f, -3.96226533e-02f, 3.14988792e-02f, -3.38597596e-02f, 4.58917022e-02f, 5.19841351e-02f, 6.47554845e-02f, 2.43104622e-02f, 1.76959876e-02f, -7.25492537e-02f,
  -4.98389900e-02f, -4.17626165e-02f, 6.80200011e-03f, -1.86875574e-02f, 3.37950513e-02f, 5.83675243e-02f, -8.27740207e-02f, -7.95594789e-03f, 6.21900521e-02f, -5.25409803e-02f,
  4.36707810e-02f, 1.59004517e-02f, 8.27490631e-03f, -2.45652981e-02f, 5.00056334e-02f, -6.10417128e-03f, 1.85671058e-02f, 2.44554095e-02f, 5.06246090e-02f, -5.42080626e-02f,
  -1.28098816e-01f, 7.86026344e-02f, -8.20068568e-02f, -9.21362340e-02f, 7.98017904e-02f, -2.79686730e-02f, -9.74805001e-03f, -2.40607676e-03f, 1.66943315e-02f, -1.09295011e-01f,
  1.77007560e-02f, -4.43294197e-02f, -4.48228233e-02f, 2.65711918e-02f, -1.02621289e-02f, -4.82264645e-02f, 6.27589505e-03f, -7.55298883e-02f, 1.28230685e-02f, -2.88816188e-02f,
  -9.47678611e-02f, -1.06257878e-01f, -8.81644189e-02f, -1.30562961e-01f, 2.57920530e-02f, -5.47679774e-02f, -1.41950399e-01f, -1.24838866e-01f, -5.64607345e-02f, -1.38391212e-01f,
  1.74098149e-01f, 1.57728583e-01f, -3.53868045e-02f, 1.16851702e-01f, -9.48956758e-02f, -7.21603930e-02f, 1.00673057e-01f, 1.75482258e-01f, -5.70398942e-03f, 7.12213516e-02f,
  -5.16131334e-02f, -1.33863688e-01f, -9.70885381e-02f, 5.82892597e-02f, 1.11410238e-01f, 1.34075969e-01f, 1.30330352e-02f, -5.93038909e-02f, 3.49739902e-02f, 1.10049937e-02f,
  -3.23181152e-02f, 1.03007682e-01f, 1.07014418e-01f, -2.98247281e-02f, -8.88935924e-02f, -1.94170307e-02f, -5.06143235e-02f, -1.08421378e-01f, -6.06317818e-02f, 6.53160065e-02f,
  -2.00675398e-01f, -1.64623201e-01f, -4.35662530e-02f, -1.11494306e-02f, -1.46833003e-01f, -5.70220724e-02f, -1.27280921e-01f, -2.72269025e-02f, 2.64672227e-02f, -3.64618674e-02f,
  -1.52209699e-01f, -6.55466244e-02f, 3.50013413e-02f, 2.06849109e-02f, 1.37901520e-02f, -2.20940169e-02f, 1.25303641e-05f, -5.43189794e-02f, -9.26564485e-02f, -5.46743423e-02f,
  -9.30982009e-02f, -1.38334766e-01f, -6.41005784e-02f, 4.50416692e-02f, -3.03002857e-02f, 2.84938677e-03f, -7.90823076e-04f, -1.09867891e-02f, -3.23225297e-02f, 2.35318043e-03f,
  -5.20472527e-02f, -1.15449727e-02f, -2.18095724e-02f, 1.85370017e-02f, -6.11043014e-02f, -6.04691333e-04f, 3.41152251e-02f, -8.09885841e-03f, 6.85615167e-02f, -8.83296430e-02f,
  3.55099216e-02f, 5.38510829e-03f, 4.30244841e-02f, 2.00414658e-03f, 2.18445547e-02f, 2.74251070e-04f, 3.59922126e-02f, 9.80125815e-02f, 1.61243789e-02f, -5.08132717e-03f,
  -2.36591958e-02f, 4.30331938e-02f, -8.16187635e-02f, -9.90990326e-02f, -8.93085636e-03f, 3.09422184e-02f, -6.68631718e-02f, -8.55751336e-03f, 4.57692817e-02f, 3.07723004e-02f,
  1.06646255e-01f, -1.64259538e-01f, -2.81901211e-02f, 3.82568352e-02f, 1.85350562e-03f, -2.35048309e-02f, -4.14540656e-02f, -6.15366250e-02f, -3.44882417e-03f, -4.41031903e-02f,
  -3.55632827e-02f, -1.05167836e-01f, 8.54843669e-03f, 1.14077786e-02f, 1.04780369e-01f, 1.79299042e-02f, 6.44775331e-02f, -2.51823142e-02f, 5.95355593e-02f, 3.83571954e-03f,
  1.23833992e-01f, 2.02146955e-02f, 8.23676412e-04f, 3.66580598e-02f, -8.84741843e-02f, -9.66655910e-02f, 7.01522753e-02f, 6.65175319e-02f, -5.18236868e-03f, 1.62982449e-01f,
  3.66882980e-01f, -1.00120962e-01f, -1.49886981e-01f, 6.95472732e-02f, -1.10774294e-01f, -1.72821805e-02f, -8.42845300e-04f, 8.82853046e-02f, -2.32820865e-02f, 6.75307736e-02f,
  -7.43036196e-02f, 1.82629481e-01f, 1.96991488e-01f, 9.22221094e-02f, 1.27754271e-01f, -4.24053706e-02f, -8.48620459e-02f, 2.53704675e-02f, 1.24045663e-01f, -2.40004472e-02f,
  -1.01212308e-01f, -9.20051038e-02f, 2.42119022e-02f, 5.09448461e-02f, -7.65414238e-02f, -6.73418343e-02f, -3.90721411e-02f, -1.56826511e-01f, -1.05365090e-01f, -2.15610355e-01f,
  4.73503582e-02f, -1.14279628e-01f, 3.75755690e-02f, -1.60548333e-02f, -1.02165207e-01f, -6.29787892e-02f, -7.16169327e-02f, 1.44073106e-02f, -4.52630483e-02f, -4.06670198e-02f,
  -7.98507854e-02f, 1.35605689e-02f, -7.55759254e-02f, -2.47820970e-02f, -8.10720325e-02f, -4.35864227e-03f, 2.25471091e-02f, 1.11386292e-02f, 3.18061039e-02f, -1.20986998e-01f,
  -9.12208706e-02f, -7.63939694e-02f, 8.84271115e-02f, -3.21147442e-02f, -1.74331695e-01f, -1.26338098e-02f, -9.73294377e-02f, -5.74261621e-02f, -7.72253275e-02f, -1.37156129e-01f,
  1.93244629e-02f, 2.95747705e-02f, 7.01977015e-02f, -3.66684608e-02f, -7.54982652e-03f, -2.06522215e-02f, -2.73459721e-02f, -4.99451458e-02f, 6.89600930e-02f, 4.33413014e-02f,
  -3.25988978e-02f, -6.89530224e-02f, 6.90597948e-03f, 1.65563747e-02f, -5.73805571e-02f, 8.29901919e-02f, 6.39287606e-02f, 6.34513274e-02f, 1.82388872e-02f, -3.06187738e-02f,
  8.74389485e-02f, 7.97765926e-02f, 5.31458817e-02f, 1.17856255e-02f, -7.70847732e-03f, -1.89874209e-02f, 1.04533723e-02f, -1.41996250e-03f, 8.84872954e-03f, 8.87426361e-02f,
  2.90223043e-02f, 5.41535057e-02f, 1.68590955e-02f, -1.54183917e-02f, 6.92952350e-02f, -1.08619258e-01f, 2.19364353e-02f, -8.00478011e-02f, -3.24246734e-02f, -3.33260447e-02f,
  -1.10104224e-02f, 2.78319474e-02f, -2.32038721e-02f, -1.94286220e-02f, 7.66792670e-02f, 5.73342154e-03f, -2.66787056e-02f, 5.13491482e-02f, -2.45625135e-02f, -6.53344020e-03f,
  -8.76348838e-02f, 1.01731665e-01f, 2.63412237e-01f, 5.70045300e-02f, -8.14701710e-03f, 2.62745380e-01f, 1.50880128e-01f, 1.21619262e-01f, 2.24932864e-01f, 1.01438448e-01f,
  -1.38896435e-01f, -8.12466219e-02f, 1.30669400e-01f, -9.01812762e-02f, -4.09649052e-02f, 3.78557853e-02f, -3.22109344e-03f, 3.20482105e-02f, -1.22661307e-01f, -9.83601362e-02f,
  1.73453502e-02f, 2.97767743e-02f, 1.37752309e-01f, -1.23375347e-02f, 6.78248256e-02f, -8.86023343e-02f, -1.13434069e-01f, 3.91130149e-02f, 2.23811671e-01f, -1.03493780e-02f,
  3.30616832e-02f, -6.51910678e-02f, 1.28539512e-02f, 1.73870735e-02f, -1.26470000e-01f, -1.14352666e-02f, -3.61931510e-02f, -6.10040091e-02f, -1.39887435e-02f, -5.76268733e-02f,
  3.48974615e-01f, -1.19794741e-01f, 9.84330624e-02f, -1.61642030e-01f, -5.04802018e-02f, -8.02384913e-02f, 7.51436353e-02f, -2.31416393e-02f, 1.24800671e-03f, -1.83753800e-02f,
  -9.58652347e-02f, -1.71425324e-02f, -5.78053668e-02f, -4.04018909e-02f, -5.79430573e-02f, 4.49824855e-02f, -1.25009418e-01f, -5.39017655e-03f, -7.56045952e-02f, 1.25308167e-02f,
  -9.34807509e-02f, -5.97965233e-02f, -4.51160669e-02f, -1.36137884e-02f, -7.91929662e-03f, 8.25447962e-02f, -2.76625296e-03f, -7.76756182e-02f, -5.94375916e-02f, -1.21435761e-01f,
  -1.11605018e-01f, 6.65693805e-02f, 2.95413025e-02f, 7.07182586e-02f, 5.24900444e-02f, 7.17918053e-02f, -5.12667038e-02f, 3.23753692e-02f, 7.92122483e-02f, 5.73152378e-02f,
  -4.41463664e-02f, -5.73617630e-02f, 7.62027875e-02f, 9.80579033e-02f, -4.24047820e-02f, 3.93845327e-02f, -9.60010570e-03f, -5.46969622e-02f, 2.79462487e-02f, 2.65589841e-02f,
  -4.76172892e-03f, -3.43769155e-02f, -7.47135431e-02f, -4.47635241e-02f, -9.09269676e-02f, 1.89195666e-02f, -9.46782250e-03f, -2.87446771e-02f, 5.57034882e-03f, -8.70696679e-02f,
  1.91989824e-01f, -1.71206463e-02f, 1.01914726e-01f, -7.78156938e-03f, -1.04594983e-01f, -9.17131379e-02f, 2.15919688e-02f, -2.73375064e-02f, -9.42621827e-02f, 6.82352409e-02f,
  4.50965241e-02f, 2.80854814e-02f, 5.79691008e-02f, 3.71946916e-02f, 1.54265482e-02f, 1.25174206e-02f, 8.32334254e-03f, -1.48020051e-02f, -5.44585809e-02f, -3.06427516e-02f,
  -1.71517223e-01f, 1.31241009e-01f, 1.83622971e-01f, 1.27005443e-01f, 3.56962718e-02f, 1.85795069e-01f, 2.48967141e-01f, 1.39176339e-01f, 2.03894839e-01f, 1.19621746e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.01633975e-01f, 1.47171333e-01f, 7.15447962e-03f, 1.73818558e-01f, 6.33358210e-02f, 2.53651179e-02f, 1.89777777e-01f, 2.21630096e-01f, 5.38883731e-02f, 1.98272220e-03f,
  3.08560789e-01f, 8.04645494e-02f, 1.07118115e-01f, 3.10329527e-01f, 1.96092978e-01f, 2.59784669e-01f, 1.32200018e-01f, 6.44112974e-02f, 1.68575764e-01f, 1.27235413e-01f,
  2.50889268e-02f, 9.25760716e-03f, 1.81411594e-01f, 2.13208556e-01f, 2.21454039e-01f, 1.48913488e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.94914097e-02f, -3.20346862e-01f, -2.05413714e-01f, -1.17413186e-01f, -2.82952279e-01f, -5.29120192e-02f, 9.83703136e-02f, -1.59711719e-01f, -2.80495793e-01f, -6.26017869e-01f,
  -2.44337633e-01f, -3.95182163e-01f, -2.70775557e-01f, -5.62694855e-02f, -3.48799914e-01f, 1.55655324e-01f, 4.54985388e-02f, 4.87699285e-02f, -4.52971794e-02f, -9.07366127e-02f,
  1.82597384e-01f, 1.22272171e-01f, -1.41111135e-01f, -3.65697026e-01f, -4.20738608e-01f, -2.08054543e-01f, 2.97727048e-01f, -4.83256459e-01f, 4.09095228e-01f, 2.14435890e-01f,
  -2.37621397e-01f, -8.10541064e-02f, 4.01852638e-01f, 1.12600386e-01f, 1.88190818e-01f, 1.14926390e-01f, -1.36489883e-01f, 1.30150884e-01f, -2.51784116e-01f, 6.65833235e-01f,
  -5.89087903e-02f, -2.57075518e-01f, -5.61876893e-02f, -3.50126810e-02f, -1.60208132e-04f, -2.67560575e-02f, 1.97764143e-01f, -2.39184666e-02f, -1.44728452e-01f, -1.23171195e-01f,
  -1.43275648e-01f, -6.70797080e-02f, 2.80672848e-01f, 3.80704880e-01f, 1.10019192e-01f, -5.36289215e-02f, 1.15183972e-01f, 3.97195201e-03f, 6.40998721e-01f, -1.43553659e-01f,
  1.55967087e-01f, -2.32749414e-02f, -4.72074524e-02f, -5.55733442e-02f, 1.38201550e-01f, -3.16964090e-01f, 2.14490861e-01f, -4.69871491e-01f, 2.36550152e-01f, 8.29686970e-02f,
  2.15783656e-01f, 2.84646004e-01f, -4.99969155e-01f, -2.46656269e-01f, -5.72810806e-02f, -1.06942374e-03f, 5.24538644e-02f, -2.99773067e-01f, -6.23636171e-02f, -2.16822639e-01f,
  2.16965541e-01f, 3.80174592e-02f, -7.53716230e-02f, 2.98035353e-01f, 1.54365882e-01f, 3.04567851e-02f, 1.47047803e-01f, -8.04823488e-02f, -3.22871387e-01f, 1.33628383e-01f,
  -3.59723151e-01f, -7.00765252e-01f, 2.07003713e-01f, 1.47872284e-01f, -3.03098291e-01f, -7.14057460e-02f, 5.81110835e-01f, -3.50196987e-01f, 6.65887296e-01f, -3.92862111e-01f,
  1.51831493e-01f, -5.28941274e-01f, -4.64384854e-01f, -5.59008308e-02f, 1.10744216e-01f, -1.95139885e-01f, -4.26063165e-02f, 3.88079494e-01f, -1.98959676e-03f, 2.13542551e-01f,
  1.02096580e-01f, -6.41143098e-02f, -3.44242901e-01f, -3.66853811e-02f, 2.76505798e-01f, 4.92640197e-01f, -3.17091584e-01f, 1.95448369e-01f, 8.92232696e-04f, -1.88217759e-01f,
  -7.31632710e-02f, 2.21778661e-01f, 1.45452067e-01f, 2.75683910e-01f, -1.47328049e-01f, 2.35099439e-02f, 6.62287414e-01f, 2.21134752e-01f, -1.85476744e-03f, 1.41468257e-01f,
  -9.59855840e-02f, 3.92323405e-01f, 1.05848871e-01f, 1.36252612e-01f, -2.75487214e-01f, 1.51702479e-01f, 2.85370797e-01f, 3.04573178e-01f, 2.32096791e-01f, 1.51803404e-01f,
  -8.34320486e-02f, -1.26771361e-01f, 5.44539988e-01f, 3.70227814e-01f, 1.93359703e-01f, 3.24626602e-02f, -3.38467620e-02f, 3.61128122e-01f, -1.20859124e-01f, 3.69952768e-01f,
  -3.35707992e-01f, 1.64874017e-01f, 3.37989181e-01f, -6.34119391e-01f, -2.96205468e-02f, 8.41448754e-02f, -1.66283488e-01f, -3.16091269e-01f, -2.45240927e-01f, -5.91748655e-01f,
  4.89768177e-01f, -2.47982040e-01f, -3.47547144e-01f, -2.80661762e-01f, 3.69281232e-01f, -4.89436746e-01f, -2.32596770e-02f, -2.17052341e-01f, -2.52941132e-01f, -3.20426464e-01f,
  1.21597983e-01f, -2.47198209e-01f, 1.40173212e-01f, 8.14327821e-02f, 4.49250117e-02f, -4.13362905e-02f, -1.71136588e-01f, -1.80872560e-01f, -4.77617197e-02f, 6.16250098e-01f,
  8.35819766e-02f, 2.62087792e-01f, -1.66800860e-02f, -5.57148084e-02f, -1.49170414e-01f, 1.53849453e-01f, -5.11482172e-02f, -2.04060242e-01f, 1.43832311e-01f, -3.07788816e-03f,
  -3.86098586e-02f, -1.19683050e-01f, -3.71192515e-01f, -1.71217427e-01f, 4.10820805e-02f, 9.63531435e-02f, 2.73091286e-01f, 1.08422123e-01f, 3.61149907e-02f, -4.94092293e-02f,
  9.08522531e-02f, 4.01895404e-01f, -8.94744769e-02f, -7.47944713e-02f, 4.76496145e-02f, -6.96047544e-02f, -3.08388144e-01f, 1.88748166e-01f, 8.70922953e-02f, 1.80099338e-01f,
  -6.85149580e-02f, -5.09687006e-01f, 1.88337386e-01f, -4.51582640e-01f, 1.18367493e-01f, -4.08228971e-02f, -2.53157675e-01f, -5.12484670e-01f, -5.73660314e-01f, 1.67478576e-01f,
  -1.66759551e-01f, 1.73910931e-02f, -8.41969252e-03f, -1.83709621e-01f, -2.96344340e-01f, -3.34512949e-01f, -3.43987882e-01f, 1.99523613e-01f, 1.03925161e-01f, 2.27178127e-01f,
  3.88880968e-01f, 1.36203587e-01f, -1.50479674e-01f, -1.98422030e-01f, -1.80157330e-02f, -2.11553082e-01f, -1.18377455e-01f, -2.02709556e-01f, -1.85452208e-01f, 4.87757027e-02f,
  7.30861723e-01f, 7.58480355e-02f, -2.07682550e-01f, -9.57615077e-02f, 8.09640169e-01f, -3.61937284e-01f, 4.13368106e-01f, -1.86821476e-01f, -1.82268545e-01f, -1.86975554e-01f,
  3.78216393e-02f, -2.30932549e-01f, 1.85458977e-02f, -8.32089782e-02f, -1.73406869e-01f, -1.14815898e-01f, 3.77647340e-01f, 2.52575785e-01f, -2.22289748e-02f, -2.39945203e-02f,
  -2.63075270e-02f, 9.57097709e-02f, 2.83278942e-01f, 7.75162429e-02f, 1.25914335e-01f, 6.73007965e-01f, -2.80370027e-01f, 3.80659290e-02f, -1.20435447e-01f, 2.96123922e-01f,
  -5.76862037e-01f, 2.84609854e-01f, -5.32007217e-01f, -3.42617005e-01f, 4.04805550e-03f, -2.13439032e-01f, -2.60229222e-02f, 3.60799372e-01f, 5.19939005e-01f, 5.47976196e-02f,
  5.19889414e-01f, 3.65828544e-01f, 3.28455001e-01f, 2.59941399e-01f, 2.69253850e-01f, 5.66304065e-02f, -1.64972931e-01f, -2.88041383e-01f, -5.12585759e-01f, -2.43744060e-01f,
  -2.24962324e-01f, 4.45464939e-01f, -5.73006749e-01f, 4.03337240e-01f, 1.00088030e-01f, 1.01232916e-01f, -1.44029856e-01f, 2.76868135e-01f, 1.29773584e-03f, -7.39253387e-02f,
  -6.54880181e-02f, -1.50957122e-01f, 1.75077513e-01f, -6.49587959e-02f, -1.89409390e-01f, -9.03034061e-02f, 7.71187395e-02f, -8.38242844e-02f, -2.40852043e-01f, 1.80323064e-01f,
  5.26939750e-01f, -8.36648345e-02f, 9.18682590e-02f, -2.62659281e-01f, 2.62067705e-01f, -2.16413271e-02f, 4.93340427e-04f, -1.72772661e-01f, -2.86482811e-01f, -1.15590744e-01f,
  3.85164291e-01f, 3.31792951e-01f, 4.27997231e-01f, -4.66876179e-02f, 1.11626647e-01f, 3.38498354e-01f, -2.80964613e-01f, 1.29116148e-01f, 3.94908607e-01f, -4.88594025e-01f,
  1.72166795e-01f, 7.45942816e-02f, 4.02303129e-01f, 4.20108497e-01f, 2.67707169e-01f, 2.93401629e-01f, 3.83241586e-02f, -5.92680722e-02f, 3.56059402e-01f, 5.80270290e-02f,
  2.60325342e-01f, -4.00676191e-01f, 4.14580554e-01f, -5.68100333e-01f, -1.42962143e-01f, 7.99500465e-01f, 3.78251106e-01f, -2.51048535e-01f, 6.07791245e-01f, 5.31272404e-02f,
  -1.60453320e-01f, -3.61327603e-02f, -3.58500592e-02f, -2.71166116e-01f, 6.43230438e-01f, 2.97748148e-01f, -4.46416438e-01f, -5.70749864e-02f, 1.68362364e-01f, 1.68597512e-02f,
  -2.73580886e-02f, -3.84947173e-02f, 1.91124111e-01f, 8.40708911e-02f, 2.15579737e-02f, 7.06632063e-02f, -3.50802802e-02f, -1.32668912e-01f, 1.27518398e-03f, -1.23728380e-01f,
  -5.18213250e-02f, -5.03344357e-01f, -3.17199111e-01f, 1.60020038e-01f, -1.83853686e-01f, 4.77154404e-02f, 1.32579178e-01f, 1.86918095e-01f, -3.30413282e-01f, 1.05307706e-01f,
  -2.38110006e-01f, 4.97629404e-01f, 1.91574901e-01f, -1.11398704e-01f, -2.36680493e-01f, -2.73977727e-01f, -2.05233946e-01f, -1.84688628e-01f, 1.16384521e-01f, 2.42537186e-02f,
  1.69357404e-01f, -6.86975755e-03f, -1.08735479e-01f, -1.76342040e-01f, -6.23959564e-02f, 1.62560180e-01f, 2.24981606e-02f, -2.69905888e-02f, -1.43368483e-01f, -3.14618468e-01f,
  -3.67839336e-02f, 1.52763233e-01f, 1.14148162e-01f, 4.41878229e-01f, -2.74457484e-01f, 2.71047175e-01f, -4.64925975e-01f, 8.02333504e-02f, 3.76142114e-01f, -2.53722250e-01f,
  2.62297690e-01f, 1.47357047e-01f, -3.88986498e-01f, -4.23609436e-01f, 9.69493985e-02f, 2.74646223e-01f, 1.02850251e-01f, 5.37280619e-01f, -3.23771566e-01f, 1.76437467e-01f,
  -1.50409266e-01f, -4.76882696e-01f, -1.19874626e-01f, -1.82480946e-01f, 4.34092194e-01f, -1.49928242e-01f, 9.62403566e-02f, -2.52687395e-01f, 5.43672681e-01f, 7.90297806e-01f,
  -1.55135870e-01f, -2.82730937e-01f, -2.02552557e-01f, -4.92147468e-02f, -2.30218709e-01f, -2.57400777e-02f, -4.18291688e-01f, -3.92360002e-01f, -2.44309247e-01f, 3.28393042e-01f,
  6.42764196e-02f, -2.80223731e-02f, -9.23944637e-02f, -1.14177972e-01f, -3.24791014e-01f, 1.98443234e-01f, -3.41811702e-02f, -1.45281792e-01f, 1.20263368e-01f, -1.11063160e-01f,
  -3.63895416e-01f, -3.70690048e-01f, -2.86586702e-01f, -1.16491117e-01f, 1.34314699e-02f, -1.81455344e-01f, -2.92742342e-01f, -6.66191578e-02f, 5.58372661e-02f, -1.71251297e-01f,
  1.02465943e-01f, 3.14156711e-02f, -2.02281699e-01f, -1.91968367e-01f, -1.15654029e-01f, -1.17728442e-01f, -2.77061611e-01f, -1.03679396e-01f, -9.78778824e-02f, -4.46235090e-01f,
  -1.13389768e-01f, 3.84651065e-01f, 7.99398217e-03f, -1.83804646e-01f, -7.12840557e-02f, 3.69025201e-01f, -2.03335136e-01f, -4.33570966e-02f, 9.03758556e-02f, 1.40739217e-01f,
  -2.06807241e-01f, 2.99993426e-01f, -1.05880678e-01f, -9.91875455e-02f, 2.54373640e-01f, 3.22395205e-01f, 1.26156677e-02f, -2.11172402e-01f, 2.57422745e-01f, 4.16379720e-01f,
  -9.30792391e-02f, 1.08717792e-01f, -2.02573001e-01f, -4.59411055e-01f, 2.75076628e-01f, 1.99524581e-01f, 8.89686644e-02f, 9.00332816e-04f, 3.70008498e-01f, -1.67323798e-01f,
  7.11832523e-01f, -4.26846705e-02f, -8.21682438e-02f, 2.52430607e-02f, -3.21491390e-01f, -1.24066927e-01f, -1.76892072e-01f, 4.93943006e-01f, 1.60726234e-02f, 1.80832222e-01f,
  -1.60218716e-01f, -6.32792413e-02f, 1.46159321e-01f, 1.57204896e-01f, -2.17798188e-01f, 1.32394269e-01f, -7.77743533e-02f, -1.45295098e-01f, 8.24371167e-03f, -3.25685173e-01f,
  5.56133911e-02f, 1.02590360e-01f, 8.25913921e-02f, 1.90800086e-01f, -8.71054456e-02f, 1.49331853e-01f, -1.17238071e-02f, 1.93741530e-01f, 8.96887109e-02f, -9.69992951e-02f,
  -3.40747297e-01f, 7.57869557e-02f, -1.35920882e-01f, -5.22223353e-01f, -1.02766469e-01f, -1.22651704e-01f, -2.43096292e-01f, 3.54074180e-01f, -4.48956162e-01f, -4.18329984e-02f,
  1.31959438e-01f, -1.18699893e-01f, 4.44470383e-02f, 5.39460421e-01f, -3.56354028e-01f, 6.60185099e-01f, 3.19066316e-01f, -3.29592407e-01f, 3.90386134e-01f, -4.21181560e-01f,
  -9.99230891e-02f, -4.00937945e-02f, 3.41321267e-02f, -1.80222198e-01f, -4.44302596e-02f, -9.99242365e-02f, -2.25434855e-01f, -2.46129140e-01f, -1.06497347e-01f, 1.05092958e-01f,
  3.85031879e-01f, 8.20035875e-01f, 6.04204893e-01f, -9.85250920e-02f, -2.21268777e-02f, -7.44055808e-02f, -1.66248932e-01f, 8.98274779e-02f, 7.54743889e-02f, 1.98641434e-01f,
  -1.99417487e-01f, -2.12292805e-01f, -1.40738621e-01f, 1.48543358e-01f, 2.55150914e-01f, 2.23695055e-01f, 7.90207013e-02f, -1.54115811e-01f, -1.23853367e-02f, 1.86713263e-01f,
  -2.26581737e-01f, -5.07312119e-01f, -5.27932588e-03f, -2.72134930e-01f, 1.73378333e-01f, 2.19713882e-01f, -5.00568897e-02f, 4.83872555e-02f, 2.70094901e-01f, -3.79976630e-02f,
  5.42462111e-01f, 9.48598906e-02f, 1.44406065e-01f, 3.50060053e-02f, 9.51702371e-02f, 4.61906075e-01f, -4.49421108e-01f, 2.17047945e-01f, -1.59844533e-01f, 3.34325045e-01f,
  4.98751670e-01f, 2.71421164e-01f, 5.35758853e-01f, -6.05946779e-02f, -1.80695787e-01f, 4.30459261e-01f, 4.79308397e-01f, 4.74092104e-02f, 1.25875175e-01f, -2.44374961e-01f,
  -2.86531210e-01f, 9.78193581e-02f, -4.11125511e-01f, 6.94723904e-01f, -5.85389026e-02f, 2.26880655e-01f, 2.51224607e-01f, 3.26667547e-01f, -2.04033017e-01f, 3.38591337e-01f,
  4.37902093e-01f, -2.80829608e-01f, -7.86055103e-02f, 1.93403810e-01f, -1.23792924e-01f, -5.27346358e-02f, -1.05320789e-01f, -1.99720845e-01f, -3.48139107e-01f, 1.09115116e-01f,
  -1.14866130e-01f, 4.32989061e-01f, -3.96084756e-01f, 8.99032950e-02f, -7.14231133e-02f, 3.72646935e-03f, 3.47765923e-01f, -2.27530718e-01f, -1.33895993e-01f, -1.74315557e-01f,
  -3.50403339e-01f, 1.23392902e-01f, -1.12868175e-01f, -5.11372695e-03f, -2.67229285e-02f, 1.34890467e-01f, 1.72646135e-01f, 1.04843296e-01f, -1.22877229e-02f, 1.50711089e-01f,
  -1.62013903e-01f, 1.39899909e-01f, 1.69230238e-01f, -3.86803776e-01f, 1.58383101e-01f, -5.26134193e-01f, 1.02566011e-01f, 7.61432797e-02f, 1.74157187e-01f, -3.74427944e-01f,
  -2.45752260e-02f, -4.77584034e-01f, 1.72601178e-01f, 6.62948072e-01f, -3.93532105e-02f, 6.27859263e-03f, 1.17104456e-01f, -5.53882085e-02f, -4.26361300e-02f, -2.75515139e-01f,
  4.22939919e-02f, 4.61781174e-01f, -5.26784778e-01f, -3.95090580e-01f, 4.58995610e-01f, 2.98163921e-01f, -1.57600805e-01f, 3.83437872e-01f, 5.39367974e-01f, -7.42171556e-02f,
  -7.16422126e-02f, -5.10050282e-02f, -3.76067013e-02f, -7.04251677e-02f, -2.03448787e-01f, -1.58898786e-01f, -1.65728018e-01f, -4.77465913e-02f, -1.56684980e-01f, 1.87875573e-02f,
  -5.85118532e-02f, 4.69294548e-01f, -1.41991228e-01f, -3.61577153e-01f, 1.06494330e-01f, -2.13902872e-02f, -2.03939289e-01f, 1.17167793e-01f, -5.29864095e-02f, -2.17698038e-01f,
  -9.58058164e-02f, 1.55342864e-02f, 1.62777603e-01f, 6.91649556e-01f, 1.23955473e-01f, 1.12607330e-01f, -1.37007749e-02f, 1.74507678e-01f, 6.33845329e-02f, 2.20667526e-01f,
  -1.47047332e-02f, 1.69671968e-01f, -7.45248869e-02f, -4.31085438e-01f, 6.68940647e-03f, -2.01170757e-01f, -2.65248697e-02f, -2.55220830e-02f, 1.29355058e-01f, -1.67964473e-01f,
  -5.00164777e-02f, 1.16805114e-01f, 2.34315053e-01f, -2.36817256e-01f, 5.26012853e-02f, 2.68296987e-01f, -8.70112851e-02f, -3.72933030e-01f, -4.12848026e-01f, 2.65950471e-01f,
  -4.04188246e-01f, 4.41835731e-01f, -4.95324373e-01f, 3.23639899e-01f, 5.53292334e-01f, 2.44957119e-01f, -3.41913402e-01f, 2.39631370e-01f, -4.02817994e-01f, -3.11899245e-01f,
  4.04421687e-01f, -4.57424857e-02f, -1.11142874e-01f, -2.27387533e-01f, -3.12800795e-01f, 2.52434969e-01f, 1.07761705e-02f, -2.14978799e-01f, -3.50376032e-02f, 2.96320796e-01f,
  -1.84914902e-01f, 1.10293433e-01f, 2.93864250e-01f, -5.87484650e-02f, -1.88435629e-01f, -8.53023455e-02f, -2.32157726e-02f, -2.43841007e-01f, 1.35326400e-01f, 4.98058759e-02f,
  9.18181777e-01f, -2.18331113e-01f, -2.61877384e-02f, -6.61369937e-04f, 1.44622818e-01f, 8.98650885e-02f, -9.97198150e-02f, -8.00763220e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.91673660e-02f, -3.95799987e-02f, -5.94253726e-02f, -1.38004184e-01f, 8.56427178e-02f, 1.71766177e-01f, 3.85648198e-02f, -9.48175713e-02f, -5.50730005e-02f, 1.47282600e-01f,
  6.25638589e-02f, 8.29383638e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    