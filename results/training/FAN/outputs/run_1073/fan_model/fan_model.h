/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.47031802e-02f, -1.25223175e-01f, -1.64709181e-01f, 1.61010865e-02f, -3.11320717e-03f, -2.21148431e-01f, -2.85736412e-01f, -2.11887248e-02f, 2.45343205e-02f, -1.52918115e-01f,
  1.38217760e-02f, 2.55992323e-01f, 1.45618707e-01f, 1.20082170e-01f, 3.21596116e-02f, -1.69851810e-01f, -2.53407001e-01f, 2.12410446e-02f, 1.53083980e-01f, -6.68416731e-03f,
  7.27513165e-04f, 1.55907208e-02f, 4.58859913e-02f, 1.10258237e-02f, -6.56613111e-02f, -6.15657084e-02f, -9.04529467e-02f, -1.94521751e-02f, -1.72043130e-01f, -1.17371164e-01f,
  2.23499760e-01f, 1.12240642e-01f, 2.13786021e-01f, 7.79095665e-02f, 1.16964258e-01f, 1.99564934e-01f, 1.58724293e-01f, 1.81083068e-01f, 1.31357118e-01f, 7.33345188e-03f,
  1.75369486e-01f, 9.00355428e-02f, 6.33996651e-02f, 8.92725959e-02f, 1.50484204e-01f, 3.12952362e-02f, 7.65184239e-02f, 1.02131695e-01f, 1.44868746e-01f, 1.35784283e-01f,
  6.60716519e-02f, 2.35678609e-02f, -5.69607597e-04f, 8.27735662e-02f, -1.56665258e-02f, 4.98842262e-02f, 3.90527062e-02f, -9.72843263e-03f, 2.44009942e-02f, -1.57248974e-01f,
  -5.48252612e-02f, -4.38651480e-02f, -3.55608314e-02f, -1.41918600e-01f, -8.87187794e-02f, -4.78241816e-02f, -4.93872091e-02f, -6.99088126e-02f, -1.91474333e-02f, -5.85857816e-02f,
  4.73977649e-04f, -5.04080914e-02f, 4.97065373e-02f, -7.28205889e-02f, -1.13298511e-02f, -9.91359130e-02f, -6.71439767e-02f, 9.24166408e-04f, -7.03989267e-02f, 2.78078634e-02f,
  3.23851742e-02f, -1.14486134e-02f, -1.06086999e-01f, -5.72396740e-02f, -1.28661534e-02f, -1.63585208e-02f, 3.26821767e-02f, -2.87399404e-02f, 8.40741843e-02f, 5.84886596e-03f,
  1.06972426e-01f, 6.67691678e-02f, 3.29356082e-02f, 6.80826679e-02f, 8.30973685e-02f, 1.10295288e-01f, 3.03564612e-02f, 1.82759836e-02f, 4.16845195e-02f, 6.76921755e-02f,
  1.13845296e-01f, 5.78419901e-02f, 1.00047149e-01f, 2.05712486e-02f, 4.00910154e-02f, -2.21861638e-02f, -6.98524388e-03f, 6.17498271e-02f, -2.60344148e-02f, 2.69578621e-02f,
  7.40827471e-02f, -1.28667459e-01f, 1.99329481e-02f, -3.09582725e-02f, 7.24043027e-02f, 5.26673310e-02f, 3.73398652e-03f, -1.48002906e-02f, -7.32273683e-02f, -6.07183948e-02f,
  -3.20552945e-01f, 1.14478275e-01f, -2.93915600e-01f, -1.32327780e-01f, 4.86703105e-02f, -8.47706571e-02f, 3.86780202e-02f, -1.26520574e-01f, -7.78654516e-02f, -2.03715041e-04f,
  -1.24742828e-01f, -1.23435244e-01f, -1.12802893e-01f, -1.30482629e-01f, -1.85210362e-01f, -1.50930276e-02f, 1.56759083e-01f, -5.47560602e-02f, -1.94707781e-01f, -6.66991472e-02f,
  1.16858490e-01f, 3.57497782e-02f, -6.07003793e-02f, -3.97008620e-02f, 6.19462840e-02f, -4.22571264e-02f, -9.20647234e-02f, -5.59422672e-02f, 6.91004619e-02f, 1.61386251e-01f,
  -2.60993898e-01f, -1.35450125e-01f, -1.17688693e-01f, 3.99138778e-02f, -1.04510829e-01f, -9.59249064e-02f, -1.16492249e-01f, -1.84604451e-01f, -1.27747253e-01f, -4.97656576e-02f,
  -1.10777058e-02f, -8.07347447e-02f, -1.16178222e-01f, -1.10937208e-02f, -9.42921713e-02f, -1.22552840e-02f, -6.79227114e-02f, -1.69816032e-01f, -2.22626284e-01f, -1.37593091e-01f,
  -4.27415036e-02f, -9.22897309e-02f, -2.03584284e-01f, -9.55072194e-02f, -5.20071462e-02f, -1.28458157e-01f, -8.51826295e-02f, -1.52177393e-01f, -1.60588920e-01f, 2.58220881e-02f,
  1.24207258e-01f, 8.64374116e-02f, 3.36764753e-03f, 3.33702415e-02f, 8.22701678e-02f, 4.76683602e-02f, -2.21299659e-02f, 1.97618827e-02f, 2.31267251e-02f, 3.15826014e-02f,
  -3.10126394e-02f, -1.08756842e-02f, -6.31243065e-02f, 6.17493577e-02f, 3.19615565e-03f, -3.65093201e-02f, -5.43064363e-02f, 7.42146373e-02f, -3.39073613e-02f, -5.64066321e-02f,
  5.74077666e-02f, 2.16562934e-02f, -4.03626561e-02f, -3.84868607e-02f, 3.29340510e-02f, -6.00055009e-02f, 5.52540692e-03f, 5.93485683e-02f, -3.54404822e-02f, -6.60998747e-02f,
  -2.36604780e-01f, -2.25461259e-01f, -1.06607273e-01f, -9.84169245e-02f, -5.30774444e-02f, -3.78493592e-02f, -1.10180117e-01f, -6.64229691e-02f, -1.33220404e-01f, -2.93456241e-02f,
  -1.73451349e-01f, -2.35935859e-02f, -7.76100978e-02f, -7.04252273e-02f, -1.42177910e-01f, 6.38344698e-03f, -5.06936014e-02f, 2.04666192e-03f, -2.91786008e-02f, -1.84404682e-02f,
  -1.09511986e-02f, 1.01378765e-02f, -1.16470769e-01f, -5.90277612e-02f, -1.06515206e-01f, -1.92925617e-01f, -4.99935970e-02f, -5.58754243e-02f, -1.41101107e-01f, -1.27656356e-01f,
  4.34524834e-01f, -3.40258777e-02f, -1.54910654e-01f, 1.18411086e-01f, -1.97612524e-01f, -3.44847083e-01f, -3.98741156e-01f, -1.46806166e-01f, 1.85654268e-01f, -5.43542728e-02f,
  -1.83070138e-01f, 7.32674003e-02f, 5.56166917e-02f, 9.48184505e-02f, -1.92204103e-01f, -2.19913974e-01f, -1.74682483e-01f, -6.25546044e-03f, -1.29486367e-01f, -2.20718175e-01f,
  -2.63129771e-02f, -2.08792902e-04f, 2.04915345e-01f, 4.09025997e-02f, 1.59924939e-01f, 1.95195168e-01f, 1.19917646e-01f, 2.07610670e-02f, -1.12428337e-01f, 9.16138366e-02f,
  -4.54405136e-02f, 1.64120361e-01f, -1.56369686e-01f, 8.73269364e-02f, -3.16534229e-02f, 5.65852150e-02f, -4.03400734e-02f, -1.09840995e-02f, -3.42949890e-02f, 3.38856243e-02f,
  -3.10161132e-02f, -5.24068102e-02f, -1.12289730e-02f, 3.28742974e-02f, 2.94376630e-03f, -7.09197372e-02f, -3.14183012e-02f, 5.27294092e-02f, -2.69288607e-02f, -2.36708205e-02f,
  -7.19329566e-02f, -6.51567951e-02f, -1.39672458e-01f, -4.58523668e-02f, -7.21542910e-02f, -5.08606620e-03f, -2.14187242e-03f, 5.23680151e-02f, -1.00891307e-01f, 1.58202007e-01f,
  -2.83873603e-02f, 1.09938592e-01f, 3.74401696e-02f, -1.23287761e-03f, 5.52717298e-02f, -1.60494410e-02f, 6.73317835e-02f, -2.73710955e-02f, 1.77834984e-02f, 6.89513236e-02f,
  1.70685798e-02f, -2.37195026e-02f, 2.18192930e-03f, 7.51898736e-02f, 2.98006963e-02f, -5.77177815e-02f, -2.45023072e-02f, 6.04756959e-02f, -2.51669884e-02f, 2.82197110e-02f,
  4.50831987e-02f, -6.58122078e-02f, -2.65581701e-02f, 5.24805263e-02f, -6.13088720e-02f, 3.09791118e-02f, -5.07385954e-02f, 4.98647466e-02f, -1.96416657e-02f, -3.93784009e-02f,
  2.73663104e-01f, -2.16707870e-01f, 5.43973222e-02f, -4.62720031e-03f, 3.82038020e-02f, -6.19902909e-02f, -2.29141470e-02f, 3.50836068e-02f, 2.39673425e-02f, -7.23489001e-02f,
  -1.22824602e-01f, 2.79301908e-02f, 1.68470480e-02f, -1.17897261e-02f, -8.21011439e-02f, -2.88185999e-02f, -1.27274254e-02f, 4.76130424e-03f, -9.29525793e-02f, 8.18871800e-03f,
  3.12380306e-02f, -1.04768239e-01f, -3.42967990e-03f, -1.11584850e-01f, -4.46047373e-02f, -5.30439913e-02f, -8.02509263e-02f, -1.10804059e-01f, -8.09871703e-02f, -1.34771513e-02f,
  9.23746154e-02f, -2.79242456e-01f, 2.21475422e-01f, 5.84066547e-02f, -1.74007975e-02f, 7.25110024e-02f, -1.32571664e-02f, 1.17172569e-01f, -2.53778562e-04f, 9.12890583e-02f,
  6.06099293e-02f, 2.18120515e-01f, 1.87382922e-01f, 1.61152750e-01f, 3.19022238e-01f, 1.29252642e-01f, 1.08073413e-01f, 2.59366900e-01f, 3.57812703e-01f, 5.68445250e-02f,
  -8.04561302e-02f, 6.10898808e-02f, 1.16575003e-01f, 4.06280607e-02f, 3.10058496e-03f, 1.19534083e-01f, 1.75392359e-01f, 9.46641266e-02f, 5.05467085e-03f, -9.42999963e-03f,
  3.36450219e-01f, 5.60480580e-02f, 2.03707397e-01f, 9.71718654e-02f, 1.05810761e-01f, 1.64040074e-01f, 1.86963573e-01f, 1.34305626e-01f, 8.01635981e-02f, 6.12963624e-02f,
  1.99206322e-01f, 7.47461170e-02f, 7.29680434e-02f, 1.40549883e-01f, 1.71285644e-01f, 7.98925608e-02f, -1.82453562e-02f, 9.88594294e-02f, 7.74315596e-02f, 3.30895074e-02f,
  -5.35411239e-02f, 1.21899977e-01f, 1.80473685e-01f, 5.58562763e-02f, 4.53669652e-02f, 1.34649888e-01f, 1.58641383e-01f, 1.61601603e-01f, 9.95115638e-02f, 4.91766259e-02f,
  -3.71332355e-02f, -5.56511283e-02f, -1.00040235e-01f, -3.96518670e-02f, 2.47914698e-02f, -1.50619249e-03f, -8.53588730e-02f, 1.03886239e-02f, -3.46919410e-02f, -1.03373583e-02f,
  -8.86844355e-04f, 1.06271496e-02f, -5.45519963e-02f, 1.32903367e-01f, -3.59672084e-02f, -5.44722714e-02f, -2.50322856e-02f, -3.97310182e-02f, -5.84202297e-02f, -1.01328455e-02f,
  -3.28509994e-02f, 5.20945154e-03f, 3.78433540e-02f, -3.52513604e-02f, 4.51981500e-02f, 8.63529555e-03f, 5.78730963e-02f, -5.25047146e-02f, 3.74086387e-02f, 2.80881650e-04f,
  1.73392162e-01f, 7.54314736e-02f, 1.21757656e-01f, 5.49015775e-02f, 1.38760984e-01f, 3.47479992e-02f, -1.35355219e-02f, 3.10507398e-02f, 9.34872925e-02f, 1.84367433e-01f,
  2.77512297e-02f, 7.07014054e-02f, 7.42460415e-02f, 5.16524948e-02f, 1.16301805e-01f, 1.21444464e-01f, -3.23128700e-02f, 1.22593895e-01f, 4.71414030e-02f, -8.46402161e-03f,
  1.21764140e-02f, -1.15105612e-02f, 1.85758546e-01f, 1.62962109e-01f, 7.24053681e-02f, 1.91601127e-01f, 1.82646021e-01f, 8.52714106e-02f, 2.14395225e-01f, -1.16207125e-02f,
  1.19890876e-01f, 3.30949272e-03f, 2.88493276e-01f, -2.32917219e-02f, 5.93845509e-02f, 8.78754482e-02f, 4.77224365e-02f, -9.77235809e-02f, -1.43067837e-02f, -2.34417934e-02f,
  3.82893123e-02f, -5.11002019e-02f, 5.23804799e-02f, 6.54728785e-02f, 1.22544512e-01f, 1.12896450e-01f, 2.08809555e-01f, 1.05622850e-01f, 6.32110462e-02f, 7.98185244e-02f,
  4.43389490e-02f, -3.24251950e-02f, -1.75518654e-02f, 1.07976496e-01f, 4.49678414e-02f, -5.87215535e-02f, 1.08994380e-01f, 1.46645671e-02f, 7.57694319e-02f, 1.88839912e-01f,
  2.20708445e-01f, 1.64685950e-01f, 7.37904683e-02f, 6.52035652e-03f, -8.57759826e-03f, -7.96841606e-02f, 1.74343404e-06f, -4.00068946e-02f, -7.23068342e-02f, 3.23642045e-02f,
  8.33884478e-02f, 7.08419681e-02f, 4.19317968e-02f, -4.11130972e-02f, -3.30022490e-03f, 4.27659750e-02f, -9.38955694e-02f, -7.67219067e-03f, 4.07581627e-02f, -2.36856926e-04f,
  1.04636587e-01f, 5.82508333e-02f, 1.71738029e-01f, -8.42982903e-02f, 1.03895538e-01f, 2.09836826e-01f, 6.31805509e-02f, 8.24525133e-02f, 7.71417422e-03f, -9.09975469e-02f,
  -1.84117071e-02f, -6.56301342e-03f, -7.26711005e-02f, -8.22855830e-02f, -7.79242888e-02f, -1.43468436e-02f, -7.20893405e-03f, -4.09626439e-02f, 5.79780489e-02f, -6.83709607e-02f,
  -4.72174287e-02f, 9.81859211e-03f, 1.23609812e-03f, 4.05776389e-02f, -3.27867409e-03f, 2.97602080e-02f, -3.21602896e-02f, -2.27220710e-02f, -2.52889898e-02f, -6.02351725e-02f,
  -6.02766313e-02f, 1.37168569e-02f, -7.70420283e-02f, -1.00698315e-01f, -5.70619479e-02f, -4.26500626e-02f, -1.58474725e-02f, -5.53817190e-02f, -1.33855134e-01f, 4.61917259e-02f,
  -3.02174479e-01f, 1.36530042e-01f, 2.12438274e-02f, 2.35735960e-02f, 1.10311560e-01f, -2.54667643e-02f, 1.93475047e-03f, -2.74274554e-02f, 9.24630016e-02f, -6.30325079e-03f,
  6.38937652e-02f, -2.22931430e-02f, 6.22699000e-02f, 8.08221940e-03f, 4.62926179e-02f, 5.76473996e-02f, 3.14908698e-02f, 1.00550212e-01f, 8.28865916e-02f, -5.16414754e-02f,
  -1.06568716e-01f, 8.87291413e-03f, -1.94991715e-02f, -8.72759148e-02f, 6.04498647e-02f, 6.44128546e-02f, -2.53329817e-02f, -5.94866760e-02f, 4.38274667e-02f, -2.31857821e-01f,
  5.22540390e-01f, 1.00115256e-03f, -3.78373601e-02f, 1.42216831e-01f, 1.16214760e-01f, 1.77150592e-01f, 3.24806184e-01f, 2.00506374e-01f, 1.29618734e-01f, 1.18781261e-01f,
  1.67669639e-01f, 6.62542209e-02f, 9.97387096e-02f, 4.33779247e-02f, 1.93828285e-01f, 5.02419136e-02f, -1.21717252e-01f, 6.07412159e-02f, 1.27941459e-01f, 1.76331222e-01f,
  3.64394970e-02f, -6.12637587e-02f, 4.02660808e-03f, 3.04347202e-02f, -1.29083753e-01f, 1.14769172e-02f, -1.37555271e-01f, -1.17232271e-01f, 5.52050695e-02f, -3.04971099e-01f,
  -4.22169752e-02f, 1.89981401e-01f, 1.34261832e-01f, 1.13153651e-01f, 9.40819383e-02f, -5.48730511e-03f, 1.26849636e-01f, -2.91129574e-02f, 7.18569607e-02f, 7.36648217e-02f,
  1.06211364e-01f, 6.25440180e-02f, 2.01893762e-01f, 6.86414093e-02f, 8.16355571e-02f, 3.78774516e-02f, -2.54903152e-03f, 2.06359271e-02f, 1.19321998e-02f, 1.06106117e-01f,
  7.37935537e-03f, 7.83654898e-02f, 2.01478228e-01f, 5.11016846e-02f, 1.44619539e-01f, 6.64852411e-02f, 6.93346560e-02f, 1.11928657e-01f, 3.84870134e-02f, -1.40327001e-02f,
  -7.51029402e-02f, 9.51114371e-02f, 3.37302722e-02f, 1.34984767e-02f, 1.48604717e-02f, 1.17862187e-01f, 3.64573970e-02f, 2.33189501e-02f, 4.71316837e-02f, 6.73159063e-02f,
  -2.54533142e-02f, 2.88243070e-02f, 9.63094644e-03f, 1.41391546e-01f, -6.48672283e-02f, 8.57673362e-02f, 4.74110693e-02f, -5.09957150e-02f, -3.78356241e-02f, -3.17164668e-05f,
  8.40557665e-02f, 5.38210236e-02f, -3.05117555e-02f, 6.51251385e-03f, 2.53602508e-02f, 1.01698916e-02f, -1.96193159e-02f, 3.71583402e-02f, 1.24280499e-02f, -9.78382025e-03f,
  -5.98514918e-03f, 1.73283741e-01f, 2.19659097e-02f, 5.99684902e-02f, 8.07553828e-02f, 6.19384237e-02f, 6.04341514e-02f, 2.12077349e-02f, 6.83391243e-02f, 7.53482804e-02f,
  1.32796258e-01f, 1.31929055e-01f, 2.04602629e-03f, -4.53980155e-02f, 4.43496592e-02f, 6.34797737e-02f, 2.26613916e-02f, 9.30842757e-02f, 1.25547290e-01f, -7.75458105e-03f,
  -3.24541493e-03f, 1.62325770e-01f, 1.65343508e-01f, 1.11995690e-01f, 5.55738732e-02f, 2.37405330e-01f, 2.82785408e-02f, 1.42533302e-01f, 1.76170021e-01f, 2.19404344e-02f,
  -9.36144441e-02f, -3.49973500e-01f, -1.18047267e-01f, -3.51616085e-01f, -6.98624998e-02f, -7.58426040e-02f, -3.16346320e-03f, 1.13033745e-02f, -1.39035791e-01f, -7.40223154e-02f,
  -1.49651781e-01f, -1.15286559e-01f, -5.91807440e-02f, -1.11791238e-01f, -1.14363261e-01f, -6.32626712e-02f, -2.42565483e-01f, -6.18062280e-02f, -3.05503365e-02f, -1.27048209e-01f,
  -2.03616500e-01f, -1.30115345e-01f, -1.01915151e-01f, -5.08462712e-02f, -2.39444569e-01f, -8.11560731e-03f, -1.70973882e-01f, -1.98686749e-01f, -3.68195251e-02f, -1.67683184e-01f,
  6.42840639e-02f, -2.82766849e-01f, -4.85478379e-02f, -1.76130489e-01f, -1.61548808e-01f, -1.21321008e-01f, -1.48785278e-01f, -1.71505958e-01f, -1.33460924e-01f, -5.46598844e-02f,
  -2.06371859e-01f, -2.10367188e-01f, -1.50601238e-01f, -1.44973099e-01f, -1.12569548e-01f, -7.29175955e-02f, -1.74287960e-01f, -2.72000223e-01f, -1.36736885e-01f, -1.58517361e-01f,
  -3.02220941e-01f, -1.64060682e-01f, -2.59790346e-02f, -9.85036269e-02f, -1.23053305e-01f, -9.42022577e-02f, -9.59415585e-02f, -1.92457452e-01f, -3.35636400e-02f, -1.42814606e-01f,
  9.43654478e-02f, 7.49264732e-02f, 1.14567257e-01f, 9.87639427e-02f, 4.71115522e-02f, 9.52412039e-02f, -2.15092096e-02f, 1.11552656e-01f, 4.39040400e-02f, 8.61619487e-02f,
  4.46380302e-02f, -2.88496092e-02f, -2.60866582e-02f, -7.21995113e-03f, 9.51568931e-02f, 2.93532033e-02f, 5.48319928e-02f, 3.02117802e-02f, 1.44965500e-01f, 1.24418706e-01f,
  6.23397902e-02f, 5.59060276e-02f, 1.31149450e-02f, 1.32904112e-01f, -7.94172063e-02f, -1.23952162e-02f, 5.13481558e-04f, 6.57393411e-02f, -1.08495681e-02f, 1.12491183e-01f,
  1.99357390e-01f, 1.35934517e-01f, -1.90432426e-02f, -9.11804587e-02f, -4.29089181e-02f, -3.30647044e-02f, -1.14975289e-01f, -6.26944453e-02f, -3.66842858e-02f, -8.22819620e-02f,
  -1.14663437e-01f, -6.21761568e-02f, -1.57524958e-01f, -1.31306469e-01f, -9.59345475e-02f, -7.73421451e-02f, -9.21439305e-02f, -8.45640376e-02f, -1.04389466e-01f, -1.11788839e-01f,
  -1.09110475e-01f, -1.34302340e-02f, 3.04304305e-02f, 2.04877090e-02f, -7.58245289e-02f, 4.75093424e-02f, 1.96760856e-02f, -3.78621295e-02f, 7.93207511e-02f, 2.85746679e-02f,
  -2.39618704e-01f, -2.41979718e-01f, -5.96908405e-02f, -1.81275532e-01f, 2.34685857e-02f, 9.79269221e-02f, 1.43453568e-01f, 7.30542243e-02f, -1.10610627e-01f, -7.95509815e-02f,
  1.77341755e-02f, 8.87393206e-02f, 8.87099206e-02f, 1.33149460e-01f, 3.36975418e-02f, 8.64739418e-02f, 5.26879504e-02f, 7.28856325e-02f, 1.85347870e-01f, 2.18402654e-01f,
  1.60523012e-01f, -2.02637371e-02f, -2.28550553e-01f, -7.07378462e-02f, -1.16810277e-01f, 4.15917225e-02f, -1.49161413e-01f, -2.25634024e-01f, -7.01469406e-02f, -2.29577720e-01f,
  6.10845648e-02f, -1.95206076e-01f, 7.68902153e-02f, -1.16202958e-01f, -6.39669448e-02f, 3.07855159e-02f, -3.60463448e-02f, -1.44251133e-03f, -1.16026424e-01f, -4.50615287e-02f,
  -7.04408959e-02f, -7.93885440e-02f, 6.59590261e-03f, -4.76873852e-02f, -6.34638667e-02f, 3.89641374e-02f, -1.26345307e-01f, -1.78145260e-01f, -1.03531420e-01f, -6.59020022e-02f,
  1.40325911e-02f, -1.12201758e-01f, -1.15006000e-01f, -4.29871827e-02f, -1.27597585e-01f, 1.55611895e-02f, -8.24486315e-02f, -5.19350991e-02f, -9.98022109e-02f, -8.94815922e-02f,
  -7.77037963e-02f, 2.64421944e-02f, 3.89867015e-02f, 1.33662587e-02f, -1.29231419e-02f, -3.96537296e-02f, -1.86242126e-02f, -2.38523576e-02f, 6.92762882e-02f, -1.99747514e-02f,
  1.69569235e-02f, 4.68090028e-02f, 4.63491259e-03f, -5.32565415e-02f, 5.72558679e-03f, -3.93904671e-02f, 1.01000078e-01f, -4.62491401e-02f, -3.21658291e-02f, -8.94100594e-05f,
  -4.19825464e-02f, -3.82963829e-02f, 3.30723263e-02f, 8.61967653e-02f, 2.79659480e-02f, 1.41078578e-02f, -4.30907216e-03f, 5.49319349e-02f, 6.24779016e-02f, 3.98234800e-02f,
  -3.64958718e-02f, -8.57743397e-02f, 1.28675908e-01f, 7.98824653e-02f, -7.97923282e-03f, -1.29916966e-01f, -7.20504625e-03f, -7.41061494e-02f, -7.01406673e-02f, 2.02383827e-02f,
  -3.72906439e-02f, 3.37420218e-02f, 2.70457081e-02f, -1.38077943e-03f, 2.41320841e-02f, -5.19900024e-02f, 6.09461442e-02f, 7.53005818e-02f, -9.78673697e-02f, -1.73089821e-02f,
  -5.15077151e-02f, -7.29230512e-03f, 3.18215117e-02f, 6.03202619e-02f, -5.86753264e-02f, 1.00401901e-01f, 1.09215029e-01f, 2.81260964e-02f, 4.32023369e-02f, -6.68910332e-03f,
  5.31652607e-02f, -5.48380204e-02f, -8.84538889e-02f, 9.38968807e-02f, -9.16578397e-02f, -1.24431700e-01f, -2.87463337e-01f, -1.05076514e-01f, 1.50342733e-01f, -3.26429680e-02f,
  1.46394908e-01f, 3.98934245e-01f, 3.01642388e-01f, 1.43142521e-01f, 1.18278913e-01f, -2.04941645e-01f, -1.73999369e-01f, -9.99895297e-03f, 1.51068002e-01f, 9.99791548e-02f,
  -5.71690090e-02f, 5.76738305e-02f, 1.14819668e-01f, 1.27111658e-01f, 3.54282781e-02f, 5.83138950e-02f, -8.90108645e-02f, -5.22901155e-02f, 3.13932374e-02f, -1.21688962e-01f,
  6.56142458e-02f, 3.63838263e-02f, 1.40530523e-02f, 8.13056454e-02f, 3.20492238e-02f, 8.91973227e-02f, -1.94322839e-02f, 6.98307604e-02f, 1.34250104e-01f, 8.59613940e-02f,
  7.02770352e-02f, 5.49831428e-02f, 1.78145126e-01f, 7.66668022e-02f, -1.62900880e-03f, -3.08408141e-02f, 3.16419788e-02f, 1.44982308e-01f, 8.99259970e-02f, 1.30963447e-02f,
  1.12845913e-01f, -6.83228746e-02f, 1.36623442e-01f, 1.26557320e-01f, 6.37142137e-02f, 1.71922266e-01f, 8.09198916e-02f, 4.57535610e-02f, 2.60144882e-02f, -9.38317031e-02f,
  -9.48938504e-02f, -1.13034453e-02f, -2.11377610e-02f, -4.00440581e-02f, -2.37710178e-02f, -5.24515770e-02f, 4.09819977e-03f, -3.17908973e-02f, 5.80460019e-03f, -3.07959262e-02f,
  1.88429728e-02f, 3.08695678e-02f, -1.61254909e-02f, 3.97596881e-02f, -2.86995117e-02f, 3.75688565e-03f, 4.82457466e-02f, -3.80173922e-02f, -4.67321463e-02f, -9.01789218e-02f,
  -8.47048219e-03f, -3.88012491e-02f, 3.19902116e-04f, 5.36940694e-02f, -7.42834881e-02f, -2.31834482e-02f, 2.05578394e-02f, -4.77815829e-02f, -3.71346883e-02f, -1.10016584e-01f,
  2.83876657e-01f, 9.84670743e-02f, -9.61113162e-03f, -3.60528231e-02f, 2.69817412e-02f, -3.93392630e-02f, 7.23797530e-02f, 4.30825278e-02f, 2.11726176e-03f, 1.27183333e-01f,
  6.84175864e-02f, 1.61889389e-01f, 5.21402434e-02f, 3.71186845e-02f, 8.65871310e-02f, -3.97272268e-03f, -1.21085763e-01f, 1.21046379e-02f, 3.97178717e-02f, 6.17295392e-02f,
  -1.01860546e-01f, -1.83209907e-02f, 9.43745300e-02f, -6.88467026e-02f, 1.01122729e-01f, 1.65026542e-02f, -1.58044957e-02f, -2.40448620e-02f, -5.58364391e-02f, -2.78181523e-01f,
  -3.08159977e-01f, -1.94199309e-01f, 7.50064803e-03f, -9.51806828e-02f, -4.26827520e-02f, -2.45229095e-01f, -3.38241428e-01f, -2.17882827e-01f, -1.05590880e-01f, -1.18716739e-01f,
  1.11889634e-02f, 1.57399431e-01f, 1.14398755e-01f, 1.58336103e-01f, 6.65106624e-02f, -3.22888084e-02f, -3.79139669e-02f, 2.00190157e-01f, 1.20810397e-01f, 1.15491478e-02f,
  -6.00265115e-02f, -9.63291675e-02f, -4.27401289e-02f, 1.15587607e-01f, 1.95228197e-02f, 6.00646660e-02f, -5.27642220e-02f, 2.31531560e-02f, -9.39494669e-02f, 1.46523505e-01f,
  1.82555705e-01f, -2.65725195e-01f, 1.75997522e-02f, -6.53871596e-02f, -3.59790139e-02f, -4.12786901e-02f, -1.06584847e-01f, 1.07132830e-02f, -4.24573608e-02f, -1.29763231e-01f,
  -1.64710209e-02f, -1.54474601e-01f, -1.52310923e-01f, -6.21914715e-02f, -6.03495091e-02f, -9.27493945e-02f, -4.95681278e-02f, 8.11841898e-03f, -1.40818313e-01f, 8.19207449e-03f,
  1.73548777e-02f, -6.32515773e-02f, -1.55880615e-01f, -5.11430502e-02f, -1.33654565e-01f, -5.31936288e-02f, -1.03744403e-01f, -1.00947559e-01f, -1.21999763e-01f, 1.64038632e-02f,
  -1.15138637e-02f, 1.11947350e-01f, 7.56260306e-02f, 7.67767429e-02f, 7.40358047e-03f, 1.12603731e-01f, 8.05463642e-03f, 1.02613214e-02f, 1.18379161e-01f, -8.76216777e-03f,
  5.97463883e-02f, 4.49751727e-02f, 5.07974476e-02f, 2.99969595e-02f, 6.26696423e-02f, 2.57060025e-02f, 1.38651997e-01f, 2.58105434e-02f, 7.84004182e-02f, 5.77262370e-04f,
  2.53467243e-02f, 9.37725678e-02f, 3.32963504e-02f, 7.00789392e-02f, -9.71792173e-03f, 1.00964084e-01f, 4.15529385e-02f, 8.86442233e-03f, 2.80357935e-02f, 4.04780656e-02f,
  -1.42765567e-01f, -1.03623293e-01f, -1.58899389e-02f, -3.63628119e-02f, -1.41503289e-02f, -5.94460219e-02f, 6.02414496e-02f, -4.67376374e-02f, -3.25976536e-02f, 1.82417165e-02f,
  -1.76099204e-02f, -6.62402958e-02f, 1.02979988e-02f, 1.11677786e-02f, -4.97566536e-02f, -1.73503440e-02f, -2.99908891e-02f, -3.66870351e-02f, 3.85130420e-02f, -6.05286509e-02f,
  -1.23230718e-01f, -4.70527411e-02f, -1.07391469e-01f, -4.97981533e-03f, -6.06935173e-02f, -2.17780732e-02f, 7.07557425e-03f, 2.70460602e-02f, 8.44390877e-03f, -1.47280097e-01f,
  5.38693547e-01f, -7.14830086e-02f, 1.43532902e-01f, 2.31513396e-01f, -1.00088730e-01f, 1.70569718e-02f, -1.62505031e-01f, 4.53619510e-02f, 1.66560352e-01f, 4.63416278e-02f,
  6.17988734e-03f, 8.37993249e-02f, 8.62289146e-02f, 1.29592538e-01f, 1.82473421e-01f, -2.56804097e-03f, -1.47717714e-01f, 2.71095902e-01f, 3.09541047e-01f, -4.22303043e-02f,
  -1.42903820e-01f, 7.56351575e-02f, 2.49945432e-01f, 1.34711325e-01f, -7.64899924e-02f, 8.83868858e-02f, 7.66251534e-02f, -1.08181931e-01f, -1.13453515e-01f, -1.89462647e-01f,
  -6.92511648e-02f, 2.50438154e-02f, 9.42598656e-02f, 1.04085378e-01f, 9.76366773e-02f, 1.91140622e-01f, 8.34879801e-02f, 6.88776672e-02f, 1.11799976e-02f, 1.24385655e-01f,
  -9.42544173e-03f, -7.63333542e-03f, 3.72482948e-02f, -4.08114605e-02f, 3.16085219e-02f, 1.08688518e-01f, 1.13895945e-01f, 1.74087137e-01f, 1.06306992e-01f, -2.60048360e-02f,
  -8.59752744e-02f, -3.71316001e-02f, 6.14676112e-03f, 1.84830427e-02f, 7.31012970e-02f, -1.06919911e-02f, 9.85733420e-03f, 9.78304967e-02f, 6.85672760e-02f, 1.22267693e-01f,
  1.22190500e-02f, -1.46172745e-02f, -3.76527309e-02f, -4.80142608e-02f, 5.32026961e-02f, -5.49451821e-02f, -5.84689379e-02f, -9.77914035e-03f, -2.30396483e-02f, -5.36216125e-02f,
  -7.25496635e-02f, -3.34032029e-02f, -3.14523317e-02f, -1.83373317e-02f, -6.28033951e-02f, -4.62314449e-02f, -6.07421994e-02f, -1.47514373e-01f, -2.10752152e-03f, -7.95250461e-02f,
  -2.43943445e-02f, -8.33655596e-02f, -4.42148112e-02f, -5.41577414e-02f, -1.02016658e-01f, -3.71867232e-02f, -6.66420236e-02f, -5.72886020e-02f, -3.96018848e-02f, -5.72224446e-02f,
  1.39880911e-01f, 1.61900237e-01f, 7.33174160e-02f, 3.49740908e-02f, 3.04507129e-02f, -3.51443677e-03f, 1.20242767e-01f, 1.20048910e-01f, -1.89524945e-02f, 2.48253737e-02f,
  7.33914226e-02f, 2.02102304e-01f, 5.17876744e-02f, 6.92789629e-02f, 8.29905048e-02f, 4.05281596e-02f, 5.59992231e-02f, 3.81164625e-02f, 8.44163913e-03f, -3.88536341e-02f,
  2.75306143e-02f, 1.55761570e-01f, 1.78413764e-01f, 1.83711559e-01f, 4.95333150e-02f, 1.24641530e-01f, 1.06136300e-01f, 1.00616857e-01f, 1.54875323e-01f, 1.86082050e-01f,
  -3.70087445e-01f, -4.00763601e-01f, 1.39554411e-01f, -1.98618099e-01f, -5.71921282e-02f, 6.71427101e-02f, -1.30271658e-01f, 6.86400430e-03f, -1.97160337e-02f, -2.22404972e-01f,
  -4.99495342e-02f, 9.75129232e-02f, 1.16674870e-01f, 2.69367635e-01f, 5.06520048e-02f, -1.14891596e-01f, -6.51169419e-02f, 2.09555581e-01f, 2.66524583e-01f, 2.03913406e-01f,
  -4.66129370e-02f, -1.08617581e-01f, 1.17034381e-02f, 5.83400540e-02f, -1.35796368e-01f, -2.28538783e-03f, -1.55287668e-01f, -6.29712641e-02f, -4.98094317e-03f, -2.66136169e-01f,
  1.98929906e-01f, -5.40859103e-02f, 8.05827752e-02f, -8.33455846e-03f, -4.90330094e-05f, -1.09578287e-02f, -1.13313466e-01f, -9.11999270e-02f, -2.04845052e-02f, 5.86070260e-03f,
  4.34234962e-02f, 5.43444231e-02f, 3.56395096e-02f, -1.97999805e-04f, -1.22073725e-01f, 2.28664633e-02f, -3.14992294e-02f, 5.88346981e-02f, 3.26071866e-02f, 2.58920691e-03f,
  -9.65723246e-02f, 2.44554318e-02f, -1.05274782e-01f, -5.74007779e-02f, 9.41089988e-02f, 5.29038683e-02f, 1.17480885e-02f, -4.05277871e-02f, -1.34639014e-02f, -2.30570406e-01f,
  -7.53356293e-02f, -6.44470602e-02f, 7.34113604e-02f, -1.99730955e-02f, 1.49779739e-02f, -9.85622033e-03f, 1.17121628e-02f, 4.94180545e-02f, -2.36781407e-02f, 8.01923033e-03f,
  4.04075980e-02f, 8.19182545e-02f, 2.49107778e-02f, -2.43904851e-02f, 3.48204002e-02f, -1.23695992e-02f, -3.16241831e-02f, -4.54417244e-02f, 7.18562976e-02f, -5.35357706e-02f,
  6.44981191e-02f, 6.48213550e-02f, 3.34446691e-03f, 3.53295617e-02f, 4.17385809e-02f, -7.75290355e-02f, 1.14723668e-03f, 1.70313455e-02f, -6.92242235e-02f, -4.11396176e-02f,
  -1.85982928e-01f, 2.15803027e-01f, -2.74718590e-02f, 4.03287448e-02f, -5.63173741e-02f, 9.46296903e-04f, 2.97208391e-02f, -1.41457980e-02f, -4.65311967e-02f, -2.56089829e-02f,
  -3.20159122e-02f, 1.03667779e-02f, -7.56997988e-02f, 2.77447607e-02f, 5.84706068e-02f, 1.33774718e-02f, -5.28491847e-02f, -2.68948600e-02f, 5.15921190e-02f, 4.32921611e-02f,
  -7.92723373e-02f, -7.03240931e-02f, 1.51711581e-02f, 5.08019812e-02f, 3.68229933e-02f, 6.14205226e-02f, 4.42949962e-03f, 7.10242894e-03f, 9.70836133e-02f, -2.47982278e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.42927939e-01f, 1.33815914e-01f, 2.59421188e-02f, 3.11439991e-01f, 4.29231226e-01f, 3.02821308e-01f, 3.23637843e-01f, 1.51446790e-01f, -1.64963715e-02f, 7.18940198e-02f,
  5.06739169e-02f, -2.18571890e-02f, -9.33042467e-02f, 4.00681496e-02f, -6.81834072e-02f, 9.27506164e-02f, 1.77564114e-01f, 3.81242000e-02f, -3.78598869e-02f, 1.01748526e-01f,
  1.43168673e-01f, 6.41641766e-02f, -1.76651895e-01f, 4.24238034e-02f, 1.60214663e-01f, 3.30328010e-02f, 8.05078596e-02f, 3.14251989e-01f, 1.72400758e-01f, 1.26755133e-01f,
  5.12922555e-02f, -3.67069468e-02f, -5.53933047e-02f, -3.20574408e-03f, -1.46717250e-01f, -1.35929033e-01f, -7.46139809e-02f, -2.24946499e-01f, -4.60640900e-02f, -6.31569028e-02f,
  9.57142413e-02f, 7.88098350e-02f, 1.10494725e-01f, 4.62481454e-02f, -7.34340325e-02f, -9.06318948e-02f, -8.24301541e-02f, -9.29519236e-02f, -1.17825285e-01f, -1.04604386e-01f,
  7.82698020e-02f, 1.62288815e-01f, 1.35455668e-01f, -1.22957351e-02f, -5.05139157e-02f, -2.04624739e-02f, -7.07055777e-02f, -2.24626232e-02f, 7.70578580e-03f, -1.36765823e-01f,
  -1.25167474e-01f, 4.20310162e-02f, 1.05091088e-01f, -7.65859336e-02f, 4.11060117e-02f, -7.13996217e-02f, 3.26488800e-02f, 5.08763455e-02f, -3.39208059e-02f, -1.02234878e-01f,
  -6.86217472e-02f, -1.48071898e-02f, -1.19450567e-02f, -1.10151678e-01f, -1.54714718e-01f, 2.24771388e-02f, 7.99618363e-02f, -8.07511732e-02f, -1.06651887e-01f, -1.13459572e-01f,
  2.40240898e-02f, 3.92294340e-02f, -4.00605425e-02f, 7.91400969e-02f, -2.07275581e-02f, -1.12593755e-01f, -1.23990044e-01f, -1.05665781e-01f, -7.78046697e-02f, -1.89485047e-02f,
  -4.78572724e-03f, 4.62500155e-02f, 3.79822031e-02f, 6.39602318e-02f, 1.71266705e-01f, -9.28551480e-02f, -1.31586725e-02f, 1.10334665e-01f, 6.16838261e-02f, 7.74017051e-02f,
  4.33303788e-02f, 6.47162879e-03f, 4.52589542e-02f, -1.75540030e-01f, -5.69566563e-02f, -4.56396788e-02f, -5.90338595e-02f, 4.98381481e-02f, -2.92140469e-02f, 2.11746246e-02f,
  1.44712599e-02f, 5.68804666e-02f, -9.38425679e-03f, 6.43921196e-02f, -8.72634202e-02f, -6.92491531e-02f, -3.36610824e-02f, 4.19168435e-02f, -4.82567213e-02f, -6.58075511e-02f,
  3.95937830e-01f, -3.14174026e-01f, -3.60257089e-01f, 1.31148502e-01f, 6.74792677e-02f, -4.79178391e-02f, -1.18080646e-01f, 1.27058163e-01f, 2.17558667e-01f, -1.48827970e-01f,
  -1.51446303e-02f, 1.22005083e-01f, -1.63119063e-01f, -8.59756693e-02f, -2.11925969e-01f, -3.91227335e-01f, -3.40235442e-01f, -1.75769746e-01f, 4.70811278e-02f, 2.13552907e-01f,
  8.58777538e-02f, -3.58397178e-02f, -1.00706987e-01f, -2.17053648e-02f, -1.01674423e-02f, -7.00564459e-02f, -1.69525385e-01f, -2.39353493e-01f, -2.46296763e-01f, -3.46945316e-01f,
  -3.99657398e-01f, -1.51343569e-01f, 1.88345630e-02f, 5.79663590e-02f, -2.32597906e-02f, 1.14014849e-01f, -1.76922251e-02f, 6.11200407e-02f, 1.62319511e-01f, 7.16129094e-02f,
  -4.43914235e-02f, 5.05130105e-02f, 4.54278365e-02f, 6.70847967e-02f, 1.16872840e-01f, 1.02708325e-01f, 5.98014072e-02f, 1.38163159e-03f, -1.37345493e-01f, -3.29005383e-02f,
  1.57977156e-02f, 7.44719207e-02f, 6.03915602e-02f, 2.79863644e-02f, -2.86751725e-02f, 2.37670150e-02f, 9.36436094e-03f, 9.19654146e-02f, 1.80129148e-03f, 7.14871734e-02f,
  -2.90419646e-02f, 2.53815595e-02f, 4.08556983e-02f, 5.26724979e-02f, 2.21140310e-01f, 6.83747232e-02f, 7.17585310e-02f, -2.95997746e-02f, -3.32107171e-02f, 4.17067930e-02f,
  1.35224223e-01f, -1.06279455e-01f, -4.55989270e-03f, 1.09193206e-01f, -8.10948014e-02f, -8.17881599e-02f, -9.86650586e-03f, -6.90558329e-02f, -1.59806460e-02f, -4.96333018e-02f,
  -1.93211827e-02f, -1.78817138e-02f, -7.81403333e-02f, -1.28713787e-01f, -4.77544107e-02f, 7.04246685e-02f, -1.12509787e-01f, -2.29571015e-02f, -8.92452225e-02f, -6.51713759e-02f,
  2.63098609e-02f, -2.35353068e-01f, -3.20221744e-02f, -7.22093284e-02f, -2.99076866e-02f, -8.67710076e-03f, -1.05566621e-01f, 9.23603028e-02f, 5.11761494e-02f, 8.69515091e-02f,
  1.00038818e-03f, 6.60255086e-03f, -1.54495955e-01f, 5.41117676e-02f, 1.56149536e-01f, 8.68161116e-03f, 3.12701911e-02f, 1.16369516e-01f, -1.41751915e-01f, 1.07044878e-03f,
  5.22097796e-02f, 2.39018902e-01f, 1.95019707e-01f, 1.17217831e-01f, 7.04595819e-02f, 5.25634512e-02f, 7.92894065e-02f, 5.53071201e-02f, 7.23679662e-02f, 1.41007796e-01f,
  6.37534320e-01f, 1.62886336e-01f, 1.32004946e-01f, 2.38397062e-01f, -5.54483235e-02f, -1.44205526e-01f, -1.04068302e-01f, 1.46496877e-01f, 7.77418092e-02f, 1.10645413e-01f,
  6.46017864e-02f, 1.55647412e-01f, 2.57916510e-01f, 2.52434939e-01f, 2.14499936e-01f, 3.06226555e-02f, 9.73319709e-02f, 2.54649609e-01f, 3.03534299e-01f, 1.02101870e-01f,
  1.02785707e-01f, 5.25192209e-02f, 2.75108725e-01f, 2.08320007e-01f, 1.28432453e-01f, 3.38756368e-02f, -2.13185679e-02f, -1.54394014e-02f, -2.11091852e-03f, 8.84455666e-02f,
  -2.14148954e-01f, 4.43655588e-02f, 1.36812061e-01f, -3.08962539e-02f, -1.25100672e-01f, 1.01315878e-01f, -3.02167609e-02f, -8.32880437e-02f, -2.34654769e-02f, 2.35901047e-02f,
  -1.15932308e-01f, -1.41933206e-02f, -1.72662381e-02f, 3.37235816e-02f, -6.89227507e-02f, -1.21835947e-01f, 2.48770006e-02f, 1.15966938e-01f, -3.05266157e-02f, 3.00803315e-02f,
  3.36477309e-02f, -1.22602932e-01f, -1.13268718e-01f, -8.42119828e-02f, 6.52348772e-02f, -3.78450491e-02f, -5.50156683e-02f, -3.98951210e-02f, 7.14287721e-03f, 1.30982414e-01f,
  5.67225069e-02f, 7.49192238e-02f, 1.87151469e-02f, 1.81630015e-01f, 2.14557469e-01f, -1.94917079e-02f, 1.26605853e-02f, -1.58883616e-01f, 8.82153660e-02f, 1.09890498e-01f,
  3.78360786e-02f, 4.32845987e-02f, 6.26920760e-02f, -5.55453151e-02f, 8.00598934e-02f, -6.46587834e-02f, -1.61015034e-01f, -5.31391017e-02f, 3.01028751e-02f, -8.36778358e-02f,
  7.72007555e-03f, 2.18820218e-02f, -3.03991605e-02f, 4.27225940e-02f, -1.26214279e-02f, -2.69813109e-02f, 1.18091684e-02f, -3.04218139e-02f, 4.82936054e-02f, 2.06687003e-02f,
  -4.58474874e-01f, 1.08246133e-01f, 1.90970358e-02f, 6.98095411e-02f, -5.04610054e-02f, 4.19111690e-03f, -6.88413009e-02f, -2.33170651e-02f, -1.46702260e-01f, -1.23639762e-01f,
  -1.54509425e-01f, 1.59624033e-02f, -2.46294104e-02f, 3.52847315e-02f, -8.33409652e-02f, -9.73995849e-02f, -1.59269609e-02f, 1.20246327e-02f, 2.48040725e-03f, -1.59406960e-01f,
  -6.68368861e-02f, -1.57799479e-02f, -7.32423440e-02f, -1.66900292e-01f, 2.42511909e-02f, -1.07527927e-01f, -2.16916371e-02f, -4.33377922e-02f, -3.19822282e-02f, 5.54016344e-02f,
  -3.34441900e-01f, -1.79754764e-01f, 1.71570823e-01f, 3.09786469e-01f, 3.49525034e-01f, 3.60592902e-01f, 2.28723913e-01f, 2.49444857e-01f, 8.11123997e-02f, 1.22900894e-02f,
  3.38739008e-02f, 6.76428676e-02f, 1.03189707e-01f, 1.06024958e-01f, 1.25070840e-01f, 3.02946478e-01f, 3.22932124e-01f, 8.11821520e-02f, 1.04181021e-01f, 1.23595543e-01f,
  2.21174210e-01f, -4.41614874e-02f, -2.16363311e-01f, -1.32134734e-02f, 1.95896015e-01f, 1.69932425e-01f, 1.00810863e-01f, 1.94200486e-01f, 1.18930392e-01f, 1.98720291e-01f,
  -1.05534978e-01f, 1.03989020e-02f, 9.33793485e-02f, -9.34021249e-02f, -1.00860775e-01f, -1.41754895e-01f, -8.29794258e-02f, -1.85382470e-01f, -1.58396959e-01f, 1.12457378e-02f,
  3.44689637e-02f, -1.20239377e-01f, 6.53676093e-02f, -2.18204614e-02f, 4.43753265e-02f, -1.21422850e-01f, -1.04771800e-01f, 8.68491735e-03f, 1.12496048e-01f, -5.33499792e-02f,
  2.06335206e-02f, 1.14438318e-01f, 8.69435370e-02f, 1.84353516e-01f, 7.92224705e-02f, 1.05460491e-02f, 4.31232527e-02f, 1.42771360e-02f, -4.88477200e-02f, -9.58080515e-02f,
  2.22359270e-01f, 8.17512721e-02f, 1.35756582e-01f, 1.06676415e-01f, 1.30421236e-01f, 7.29798572e-03f, 1.60205781e-01f, 1.32000402e-01f, 1.52305007e-01f, 1.20127492e-01f,
  2.35919636e-02f, 1.15614474e-01f, 1.13775797e-01f, -1.02218324e-02f, 2.70979926e-02f, 2.33817361e-02f, 3.23847234e-02f, -1.56954105e-03f, -2.87721194e-02f, -2.51619890e-02f,
  7.90810212e-02f, -2.94419322e-02f, -1.73441634e-01f, 5.64304069e-02f, -6.86496496e-02f, 1.58920586e-01f, 1.91196464e-02f, 3.96248959e-02f, -6.07490726e-02f, -2.05059145e-02f,
  -3.91993858e-03f, 1.20623790e-01f, 1.90760251e-02f, -1.71877034e-02f, 4.86690179e-02f, -2.03158334e-01f, 9.17668268e-02f, -5.53539097e-02f, -3.60963941e-02f, -1.14938147e-01f,
  -4.97917682e-02f, -1.33973867e-01f, 2.26787832e-02f, 1.35794003e-02f, 5.96673377e-02f, 3.62208225e-02f, 1.00984043e-02f, 1.07390217e-01f, -3.00227925e-02f, -5.20574562e-02f,
  -2.51353197e-02f, 1.38051018e-01f, 7.96701238e-02f, 1.05489202e-01f, 6.16682880e-02f, 1.43308848e-01f, -4.30492200e-02f, 4.37133946e-02f, 6.16257899e-02f, -6.49069101e-02f,
  -4.33564514e-01f, -5.59087396e-01f, 3.62256825e-01f, -1.48253292e-01f, 1.60845950e-01f, 2.68637061e-01f, 2.00092673e-01f, -4.66005988e-02f, -1.12588465e-01f, -5.26173338e-02f,
  -1.40086129e-01f, -2.10490599e-02f, 3.83906905e-03f, 1.22531895e-02f, 1.26583586e-02f, 1.28321394e-01f, 1.80365056e-01f, 3.06858808e-01f, 4.02917534e-01f, 1.53582051e-01f,
  1.00700215e-01f, -4.39339094e-02f, -2.36897320e-01f, -1.77753530e-02f, 1.13386260e-02f, 1.66781858e-01f, 8.57322961e-02f, 9.43797454e-03f, -5.11297844e-02f, -3.47653031e-02f,
  3.55622202e-01f, -3.21104378e-01f, 2.32902408e-01f, -1.28773645e-01f, -3.50826494e-02f, -1.63582757e-01f, 9.83245205e-03f, -4.70927730e-02f, -8.83060545e-02f, -2.59672012e-02f,
  -1.14739798e-02f, -1.03103973e-01f, -9.03003216e-02f, -1.12931013e-01f, 5.29329777e-02f, -9.65533927e-02f, -1.99761078e-01f, -1.79441571e-01f, -1.53499961e-01f, -9.92108509e-02f,
  -4.14462723e-02f, -1.29668474e-01f, 2.07909532e-02f, 7.67814294e-02f, -6.91732988e-02f, 2.04697717e-02f, -5.63333668e-02f, -1.71476662e-01f, -1.86414972e-01f, -1.37829125e-01f,
  7.06647560e-02f, -6.04929682e-03f, -4.98429947e-02f, -4.06224616e-02f, 7.48628527e-02f, 2.38730721e-02f, 1.35348544e-01f, 1.05609633e-02f, -7.36182276e-03f, 1.05324663e-01f,
  1.78779531e-02f, 2.82512102e-02f, 3.52453440e-03f, -4.85943519e-02f, -3.06268372e-02f, 5.07110395e-02f, 9.61148813e-02f, -8.45371261e-02f, -5.73789068e-02f, -9.28352550e-02f,
  -8.64948798e-03f, -5.44638280e-03f, -4.45062667e-02f, -3.81820016e-02f, -6.69884458e-02f, -2.91781705e-02f, -2.15162002e-02f, -7.89832175e-02f, -1.09154843e-01f, -1.09229669e-01f,
  2.62219906e-01f, -2.29820535e-01f, 7.40685686e-02f, -3.08912378e-02f, 5.67879342e-02f, -1.78063214e-01f, -4.48383726e-02f, -4.19509485e-02f, -7.59985894e-02f, 5.80672827e-03f,
  -1.21629186e-01f, 3.79845388e-02f, 6.61570653e-02f, -7.46826530e-02f, 2.61038572e-01f, -4.97349259e-03f, -2.34600350e-01f, -1.99264986e-03f, -4.51346487e-02f, -3.09630316e-02f,
  -6.18015714e-02f, -7.48858647e-03f, 2.34706208e-01f, 9.05666277e-02f, -1.80698857e-02f, 1.53720200e-01f, 2.41639912e-01f, 1.30113855e-01f, 1.48867279e-01f, 2.10510209e-01f,
  7.55920470e-01f, 2.14058608e-01f, 3.05207461e-01f, 2.16959938e-01f, 7.71586969e-02f, -8.35400969e-02f, -6.78762719e-02f, 2.44129542e-02f, -1.66579504e-02f, 6.69124052e-02f,
  1.34780660e-01f, 1.70609400e-01f, 8.49364921e-02f, 8.88820440e-02f, 1.85950711e-01f, 8.46000537e-02f, -5.27856052e-02f, 2.04786539e-01f, 1.64519206e-01f, 1.70275941e-01f,
  3.95624340e-03f, 2.97476668e-02f, 2.27139607e-01f, 1.68181971e-01f, 1.09331079e-01f, 1.35935163e-02f, 2.01618262e-02f, 1.78747177e-01f, 1.54579684e-01f, 1.76337361e-01f,
  4.53079700e-01f, 4.25026000e-01f, -6.49431497e-02f, 2.35097948e-03f, 7.46763572e-02f, 1.06539791e-02f, 9.38339531e-02f, -1.91969126e-02f, -1.63886324e-02f, -1.07982092e-01f,
  -9.67608020e-02f, -3.67858820e-02f, -6.09351099e-02f, -3.92722450e-02f, 4.63860333e-02f, -3.79450768e-02f, 1.16378017e-01f, 2.26392550e-03f, -3.60245071e-02f, 2.55885422e-02f,
  -1.17417812e-01f, 4.96946760e-02f, -8.93499628e-02f, -1.45359293e-01f, 5.53396493e-02f, 1.57294050e-02f, 1.01545461e-01f, 7.66476467e-02f, 5.53626008e-02f, 1.24881238e-01f,
  5.46436310e-02f, 4.27429155e-02f, 1.12989247e-01f, 1.07191674e-01f, 2.78752476e-01f, 5.86077496e-02f, 4.35052849e-02f, 5.83034083e-02f, 1.30300060e-01f, 7.80812874e-02f,
  3.58475409e-02f, 1.20265022e-01f, 9.33424383e-02f, -6.97279423e-02f, -5.57975657e-02f, -8.76907539e-03f, -1.20982220e-02f, -2.92036831e-02f, 4.35833074e-02f, 4.06286083e-02f,
  8.36554915e-02f, -3.92059386e-02f, -2.08492973e-03f, -3.50452960e-02f, -5.12960888e-02f, 1.31537616e-01f, 5.42295389e-02f, 3.95660289e-02f, 4.96514402e-02f, -9.00430381e-02f,
  -4.95619833e-01f, -1.21719487e-01f, 5.51186465e-02f, 1.49059454e-02f, -2.38700304e-02f, -1.11982636e-01f, -7.40588922e-03f, -1.48596615e-01f, -1.64354429e-01f, 3.78098078e-02f,
  -7.80723318e-02f, 9.25995782e-02f, -6.35434389e-02f, -1.67242158e-02f, -1.39053136e-01f, -1.35839209e-01f, 1.47037329e-02f, -1.95532572e-02f, -1.09035544e-01f, -1.10579565e-01f,
  -1.73408404e-01f, -1.57422617e-01f, -1.91007033e-01f, -8.73472169e-02f, -1.12467319e-01f, -9.13650393e-02f, -6.07888913e-04f, -9.12085474e-02f, -5.03239296e-02f, -1.10197447e-01f,
  -1.27827153e-02f, 3.13407242e-01f, 1.50099546e-01f, 1.74599230e-01f, 3.45864072e-02f, -1.78209469e-01f, -1.01802804e-01f, -1.84895724e-01f, -1.04442663e-01f, 2.55073439e-02f,
  9.80847925e-02f, -7.51772672e-02f, -1.19978990e-02f, -1.99907258e-01f, -2.32527822e-01f, 8.67997333e-02f, 1.95958257e-01f, -1.93341687e-01f, -3.99375826e-01f, -4.51169878e-01f,
  -1.50782824e-01f, -2.15394899e-01f, -2.11587384e-01f, -1.24442756e-01f, 2.02044949e-01f, -4.80164923e-02f, 1.15173750e-01f, 2.14253534e-02f, -1.71612520e-02f, 2.94267654e-01f,
  1.53044552e-01f, 2.07350463e-01f, -2.97659338e-01f, -2.20391288e-01f, -2.35204417e-02f, -7.38581270e-02f, -6.91556782e-02f, -8.09005648e-03f, -8.79575908e-02f, -4.81151678e-02f,
  2.32289005e-02f, -3.98464687e-02f, 1.66711628e-01f, -2.22811908e-01f, -8.72010067e-02f, -1.61594167e-01f, -3.07957139e-02f, -2.14161962e-01f, -9.35378298e-02f, 1.61456808e-01f,
  5.95873185e-02f, 2.29574423e-02f, 8.73264223e-02f, -3.05208936e-02f, 1.84755608e-01f, -7.32925534e-02f, -1.20993100e-01f, -1.55102164e-01f, -5.84341921e-02f, 6.51145354e-02f,
  -4.32259478e-02f, 1.14160022e-02f, -9.59084462e-03f, 3.42040583e-02f, -1.09970927e-01f, 4.85665388e-02f, -2.12462768e-02f, -7.45913684e-02f, -1.65569745e-02f, -3.51289921e-02f,
  -7.61294365e-03f, 8.09142888e-02f, 3.17319818e-02f, 2.09351912e-01f, 8.52889195e-03f, 4.81175855e-02f, -1.76221859e-02f, 2.22991779e-02f, -4.08198871e-02f, -2.60948986e-02f,
  4.52831611e-02f, 9.35737044e-02f, -2.13963483e-02f, -1.53566688e-01f, 8.64730403e-02f, 9.06270668e-02f, -1.22682089e-02f, 4.65844721e-02f, -2.66259257e-02f, 6.23818487e-02f,
  -3.27731185e-02f, -2.75808156e-01f, 2.13932842e-02f, -2.08274871e-01f, -1.34999573e-01f, 5.50317429e-02f, 8.26851204e-02f, -2.63698310e-01f, 9.47910845e-02f, -1.45003989e-01f,
  -1.29798815e-01f, -4.71425354e-02f, 1.74406797e-01f, -7.32640401e-02f, -1.55886337e-01f, -4.64200880e-03f, -1.82567939e-01f, -2.30549186e-01f, -9.81250554e-02f, -5.95498867e-02f,
  2.26205010e-02f, -3.61512572e-01f, -1.73113316e-01f, -1.04857482e-01f, 7.58596957e-02f, -2.92350203e-01f, -2.64418453e-01f, -2.08097368e-01f, -3.33143324e-01f, -3.33153903e-01f,
  7.05027282e-01f, -3.28882068e-01f, -6.36602223e-01f, -7.90492520e-02f, -3.61844987e-01f, -3.49591225e-01f, -4.29504514e-01f, -4.24318351e-02f, 6.32658601e-03f, -4.09291059e-01f,
  -3.47455144e-01f, 1.20756134e-01f, -5.97631093e-04f, -1.61163192e-02f, 2.20647097e-01f, -3.54394317e-01f, -3.15440774e-01f, 2.40797387e-03f, 2.83211082e-01f, 9.70957428e-02f,
  -3.05494126e-02f, 1.00643605e-01f, 2.93004483e-01f, 1.69220239e-01f, -2.01349303e-01f, -4.95347232e-02f, -3.67088169e-01f, -2.13775739e-01f, -2.73223668e-01f, -4.04836118e-01f,
  -3.87459189e-01f, -9.69021097e-02f, -1.07931331e-01f, 9.66535211e-02f, -2.01947525e-01f, -1.02489414e-02f, -7.82521889e-02f, -7.12222606e-02f, 6.46611527e-02f, -2.43179664e-01f,
  -7.30546936e-02f, 7.62481540e-02f, -2.80587003e-02f, -5.79401739e-02f, -1.45744011e-01f, -1.33263469e-02f, 1.29969856e-02f, -2.78990567e-02f, -5.98447323e-02f, -1.34933934e-01f,
  -9.58728045e-03f, -1.16514124e-01f, -4.62156460e-02f, -4.25201207e-02f, -4.96504409e-03f, 7.07275346e-02f, -1.80113211e-01f, -1.94051981e-01f, -1.05805673e-01f, -1.49537325e-01f,
  1.22130867e-02f, -1.87494993e-01f, -3.06531917e-02f, 9.90135968e-02f, 5.21834120e-02f, 2.28347238e-02f, -1.04449965e-01f, 1.22444786e-03f, 1.10400701e-02f, 4.03090902e-02f,
  -5.01703545e-02f, -1.08118109e-01f, 3.86490375e-02f, -8.48798305e-02f, -1.01108989e-02f, -1.49085978e-02f, 3.85605246e-02f, 2.44263653e-02f, 1.13660898e-02f, 5.11825532e-02f,
  -3.83194932e-03f, -2.21432392e-02f, 2.32174508e-02f, 1.20852381e-01f, -9.38677415e-02f, -1.43627658e-01f, -1.26254931e-01f, 4.18075621e-02f, -6.41389713e-02f, -7.28175640e-02f,
  1.50297850e-01f, -1.23358585e-01f, -1.61038190e-01f, -8.04625154e-02f, -1.02592066e-01f, -1.51371390e-01f, -2.79620856e-01f, 5.40873334e-02f, 3.34878340e-02f, -1.23545915e-01f,
  -9.96548310e-02f, 4.24239486e-02f, -2.30341181e-02f, -8.44231769e-02f, -1.33441715e-02f, -1.26947677e-02f, 3.37441377e-02f, 1.17726848e-01f, 8.69864319e-03f, 1.35320006e-02f,
  5.73603995e-03f, 1.52431980e-01f, 1.42145574e-01f, 3.33652385e-02f, 2.90973000e-02f, 1.01784609e-01f, -8.84278566e-02f, -2.65139192e-02f, 1.85545802e-01f, 1.28424272e-01f,
  -4.56875451e-02f, 2.40062848e-01f, -2.79601693e-01f, 1.87924787e-01f, 1.19432755e-01f, -1.88700229e-01f, -1.06526420e-01f, -1.56496301e-01f, 2.03966051e-01f, 1.21070184e-01f,
  1.53222725e-01f, 3.59043367e-02f, -1.60456359e-01f, -3.99067461e-01f, -5.96021593e-01f, -3.85588825e-01f, -2.79368222e-01f, -5.73848426e-01f, -5.41608572e-01f, -2.79873699e-01f,
  -4.69777063e-02f, -1.76630363e-01f, -2.76730657e-01f, -1.16183475e-01f, 3.52736443e-01f, 1.79595083e-01f, 1.17908254e-01f, 5.70460185e-02f, 3.90841775e-02f, 1.70260444e-01f,
  -6.20990209e-02f, -8.02076682e-02f, -1.64061174e-01f, -7.15688989e-02f, 2.59997398e-01f, -5.65590225e-02f, -9.93556157e-02f, -3.22954692e-02f, 6.47991002e-02f, -1.28169015e-01f,
  6.20382391e-02f, -2.28570960e-02f, -1.30934149e-01f, -1.98470756e-01f, -2.46355459e-01f, -1.89370558e-01f, -1.35891542e-01f, -2.93210626e-01f, -2.75801003e-01f, -1.32579714e-01f,
  -1.21357426e-01f, -1.14342131e-01f, -3.25317472e-01f, -1.94295332e-01f, -1.26059338e-01f, -2.22466956e-03f, 3.43187638e-02f, 4.27851491e-02f, -5.10998666e-02f, 2.69238412e-01f,
  -1.07456185e-02f, -2.68186163e-02f, 3.68214361e-02f, 2.13575084e-02f, 6.98278472e-02f, 8.78714472e-02f, 1.45607432e-02f, -1.59666628e-01f, -1.59677491e-01f, -3.38761955e-02f,
  -1.33536221e-03f, 3.68470163e-03f, -8.92921835e-02f, -1.38954133e-01f, 5.84401265e-02f, -5.60387857e-02f, 3.29797827e-02f, -1.64173450e-02f, -2.19030708e-01f, -6.39198422e-02f,
  -1.47672638e-01f, -1.02763847e-01f, 1.21471122e-01f, 3.59802283e-02f, -1.02100521e-01f, -4.44631241e-02f, -6.45466372e-02f, -1.49496913e-01f, -3.80493025e-03f, 1.97402667e-02f,
  2.29595855e-01f, -1.28812686e-01f, 1.15821294e-01f, -6.84868395e-02f, 9.67922285e-02f, 3.31695452e-02f, 1.98011130e-01f, 1.94994025e-02f, -6.53691068e-02f, -4.21320088e-02f,
  -2.35915393e-01f, -1.01150330e-02f, 3.79521959e-02f, -5.33142090e-02f, -1.42202422e-01f, 2.29629930e-02f, 7.85678551e-02f, 3.68846804e-02f, -7.96926171e-02f, 1.27106681e-01f,
  -3.65025811e-02f, -1.18176691e-01f, -1.35087773e-01f, -3.11364289e-02f, -2.36245673e-02f, 2.41250042e-02f, -9.52930450e-02f, 6.52097985e-02f, -1.92956254e-01f, 2.10519060e-01f,
  5.78968711e-02f, -7.57631838e-01f, 3.00569981e-01f, -5.52190244e-02f, 1.82771444e-01f, 2.72010714e-01f, 2.94248629e-02f, 4.78991233e-02f, -5.77997342e-02f, -2.11540863e-01f,
  -3.34016860e-01f, -2.34924838e-01f, -2.46454492e-01f, -9.95290428e-02f, -3.35043743e-02f, 6.04055449e-02f, 1.78912133e-01f, 1.90783873e-01f, 3.72181267e-01f, 2.08325878e-01f,
  -2.71492060e-02f, -9.42484383e-03f, -5.36235720e-02f, -5.26058450e-02f, -2.37853572e-01f, -4.02780399e-02f, -1.22491524e-01f, -6.43723235e-02f, -7.34605268e-03f, -2.78659642e-01f,
  -1.56371146e-01f, -2.27217495e-01f, 1.88029766e-01f, -1.43787801e-01f, -9.51544791e-02f, -9.73083898e-02f, 5.06645776e-02f, -1.29039148e-02f, -1.42225564e-01f, 1.95072312e-02f,
  -8.87727514e-02f, 1.03700291e-02f, -1.21234901e-01f, -4.24250588e-02f, -3.15279588e-02f, 4.24219854e-02f, -6.79149032e-02f, -1.07453644e-01f, -1.25957623e-01f, -3.16721648e-02f,
  -1.63034022e-01f, -3.89175825e-02f, -2.17836741e-02f, 5.01459986e-02f, -3.03167128e-03f, -4.36942233e-03f, -9.82266814e-02f, 3.41701657e-02f, 8.46487582e-02f, -6.52781427e-02f,
  1.03138722e-01f, -3.55159305e-02f, -2.94012646e-03f, 1.06214285e-02f, 1.55904833e-02f, 1.27899963e-02f, -2.67253537e-02f, -9.53961571e-05f, 2.53976844e-02f, -2.83326060e-02f,
  -1.95382655e-01f, 1.21286502e-02f, -1.00460490e-02f, -3.46476361e-02f, -9.32522416e-02f, -1.33917809e-01f, 4.71317917e-02f, -1.02394633e-01f, -7.82942697e-02f, -6.79653063e-02f,
  -1.42717920e-02f, 3.12560312e-02f, -6.05494305e-02f, -1.18647590e-01f, -6.23878241e-02f, -8.40321407e-02f, -3.83570455e-02f, 8.46187351e-04f, -2.18534842e-02f, -8.88456777e-02f,
  -3.23323578e-01f, 3.29100430e-01f, 8.82617012e-02f, -7.66344592e-02f, 8.12669024e-02f, -1.52421622e-02f, 5.67603633e-02f, 9.34078842e-02f, -7.20141456e-02f, 8.86370912e-02f,
  -4.05513346e-02f, 5.47016151e-02f, -9.03765559e-02f, -9.56893116e-02f, 1.72979504e-01f, 1.88708395e-01f, -1.41392469e-01f, -7.50300363e-02f, 2.22753957e-02f, -1.11504473e-01f,
  -1.74521971e-02f, 1.71657279e-01f, 4.63215597e-02f, 7.27361143e-02f, 5.39161675e-02f, 2.73681849e-01f, 1.32044673e-01f, 2.01118551e-03f, 1.50071099e-01f, 3.20914388e-02f,
  -7.69274294e-01f, -3.32381576e-01f, -6.04277886e-02f, -6.41748726e-01f, -2.88856059e-01f, 1.03056850e-02f, -3.60233374e-02f, -1.48201481e-01f, -2.41604164e-01f, -1.89501438e-02f,
  6.14861175e-02f, 7.44685456e-02f, -7.02953264e-02f, -3.94573295e-03f, 1.16853595e-01f, 5.98461665e-02f, -1.95885375e-01f, -2.34379813e-01f, -1.50622681e-01f, 6.65369034e-02f,
  -7.31022283e-02f, -4.77747500e-01f, -4.61119145e-01f, -3.20353121e-01f, -2.47977614e-01f, -2.62906373e-01f, -2.34427586e-01f, -2.05283731e-01f, -9.15510654e-02f, -3.99775833e-01f,
  2.25292385e-01f, -2.58112967e-01f, -6.43275008e-02f, -1.12564690e-01f, 1.02223717e-02f, -9.42839775e-03f, -5.58252931e-02f, -1.19585507e-01f, -2.10857727e-02f, -1.13668457e-01f,
  -7.83411488e-02f, 6.06103204e-02f, -2.39076726e-02f, -3.76911908e-02f, -1.64305240e-01f, 3.61206047e-02f, 4.68767667e-03f, -1.04258016e-01f, 7.42183998e-02f, 2.51429617e-01f,
  1.57333493e-01f, 9.96301994e-02f, -4.25077714e-02f, 9.04099792e-02f, 2.59790719e-01f, 7.40014669e-03f, 4.75322381e-02f, 1.11431174e-01f, 1.87688857e-01f, -1.94603890e-01f,
  1.09842122e-01f, 4.58061509e-02f, -1.62804034e-02f, -1.00458391e-01f, 4.35728468e-02f, -2.65650917e-02f, -2.37438772e-02f, 5.81605826e-03f, 2.64585763e-02f, 1.57314574e-03f,
  8.97443853e-03f, 9.44113955e-02f, 4.25832011e-02f, -9.76622943e-03f, 6.08356530e-03f, -7.07411617e-02f, -3.40603553e-02f, 3.34629156e-02f, 1.09418117e-01f, -8.71003345e-02f,
  -3.75806093e-02f, -2.92734858e-02f, 1.45267965e-02f, 3.35604958e-02f, 4.60031703e-02f, -1.16015587e-03f, 7.76584670e-02f, 9.47689712e-02f, 1.97007116e-02f, 9.65801105e-02f,
  -1.28363773e-01f, 1.55114993e-01f, -1.26568750e-01f, 3.10622947e-03f, -1.29864857e-01f, 1.56377509e-01f, 3.08217737e-03f, 1.30750748e-04f, -6.15072250e-02f, 8.25426280e-02f,
  1.59826979e-01f, -2.01976150e-02f, 9.25134402e-03f, 2.10086871e-02f, -1.82397276e-01f, 5.38140424e-02f, 1.03043690e-01f, -1.06766425e-01f, 1.08801596e-01f, 6.58376962e-02f,
  1.87695712e-01f, 1.65231422e-01f, 9.05688945e-03f, 3.33275534e-02f, 7.10394904e-02f, 2.95339935e-02f, 1.56699389e-01f, 1.92790851e-01f, 1.34826303e-01f, -7.09723756e-02f,
  1.97768044e-02f, 6.55994751e-04f, -8.43244344e-02f, 2.89301574e-01f, 3.21496278e-01f, 3.18320364e-01f, 3.28509808e-01f, 2.61189967e-01f, 2.47632831e-01f, 8.94356892e-02f,
  9.97731164e-02f, 2.25120723e-01f, 1.28973097e-01f, 1.89535096e-01f, 1.47087529e-01f, 1.88043773e-01f, 7.23069161e-02f, 4.16744053e-02f, 1.97978243e-02f, 5.60552664e-02f,
  1.46029547e-01f, 1.34187818e-01f, -1.03312366e-01f, 7.54724815e-02f, -2.24906132e-02f, 1.62387818e-01f, 1.76425986e-02f, -1.51543198e-02f, 3.54610244e-03f, -1.77995160e-01f,
  -3.98874849e-01f, -1.52992085e-01f, 9.51875150e-02f, -6.75565600e-02f, -5.54591343e-02f, -1.14326954e-01f, -2.82528009e-02f, -1.01031691e-01f, -1.51482772e-03f, -7.03247488e-02f,
  -1.23437792e-01f, -2.30516449e-01f, -7.92664364e-02f, -1.59205452e-01f, -1.32867500e-01f, -1.66804731e-01f, -1.19171090e-01f, -2.13789232e-02f, -1.03002660e-01f, -1.93931282e-01f,
  -3.94134484e-02f, -1.17865697e-01f, -8.98361132e-02f, -5.79558723e-02f, -4.95003685e-02f, 1.27123762e-02f, -8.32400694e-02f, -1.40377313e-01f, -7.42681548e-02f, -2.67884046e-01f,
  7.73355737e-02f, -1.25069380e-01f, -1.55282915e-01f, 2.21741088e-02f, 8.32270607e-02f, 5.57020158e-02f, 2.79577132e-02f, 6.34206682e-02f, -8.91950428e-02f, -1.44590512e-01f,
  2.13338099e-02f, 3.40935849e-02f, -4.02873103e-03f, 8.73479620e-03f, 6.28874525e-02f, -5.09860218e-02f, -1.41006768e-01f, -8.73450860e-02f, -6.21589571e-02f, -4.27545309e-02f,
  -5.93977943e-02f, -1.74631476e-01f, -2.02216595e-01f, -2.01261833e-01f, -3.77699248e-02f, -1.48945749e-01f, -5.16313054e-02f, -2.18187869e-02f, -3.04782707e-02f, -7.82959163e-03f,
  5.27106635e-02f, 1.86310828e-01f, -1.96744855e-02f, -2.10557170e-02f, -1.88263267e-01f, -1.34849072e-01f, 1.17864393e-01f, -1.58230692e-01f, -3.34849884e-03f, 3.17363553e-02f,
  -2.95045711e-02f, -1.15554370e-01f, 6.93466216e-02f, -1.97301954e-02f, 7.80305779e-03f, -1.00026680e-02f, -7.24587068e-02f, -5.08255437e-02f, 7.26465136e-02f, -1.49823233e-01f,
  -1.17877992e-02f, 1.92818791e-02f, 6.46988153e-02f, 1.48733228e-01f, 7.44697591e-03f, 1.89478993e-01f, 5.42460568e-02f, -5.44807129e-03f, 1.08352214e-01f, 9.88244116e-02f,
  -1.62420928e-01f, -4.11387831e-01f, -2.20879376e-01f, 7.58669823e-02f, 1.23921618e-01f, 2.12416258e-02f, -4.56165940e-01f, -2.53143311e-01f, -9.44998208e-03f, -3.04810673e-01f,
  2.29774252e-01f, 4.21582580e-01f, 3.06991232e-03f, 9.48976502e-02f, -2.82661855e-01f, -3.73534113e-01f, -1.70661539e-01f, 1.91947911e-02f, 3.42381060e-01f, 3.40413153e-01f,
  2.44420290e-01f, 1.77112892e-01f, 2.34409750e-01f, 1.61240205e-01f, 8.12893640e-03f, 5.66709749e-02f, -1.50151417e-01f, -1.77461561e-02f, -1.04503199e-01f, -1.30715147e-01f,
  -1.99476495e-01f, -1.40342444e-01f, 1.38337016e-01f, 1.82905734e-01f, 1.88695341e-01f, -2.43752912e-01f, -1.09785192e-01f, 9.21360627e-02f, 1.04870856e-01f, -2.81996995e-01f,
  2.38255084e-01f, 5.91601357e-02f, 1.63386315e-01f, 9.77404714e-02f, -3.68806650e-03f, -1.64759725e-01f, -2.17379600e-01f, -1.20210089e-01f, -1.91204503e-01f, -1.86737970e-01f,
  8.52848813e-02f, 5.84294572e-02f, -2.22160190e-01f, -1.64294228e-01f, -3.36800873e-01f, 1.79518908e-02f, -1.95425674e-01f, -8.22404325e-02f, -2.14220852e-01f, -4.39319342e-01f,
  7.63664246e-02f, 1.16200171e-01f, -1.03219584e-01f, -1.09392472e-01f, -4.66375612e-02f, 2.47729775e-02f, -1.33591462e-02f, -5.40828891e-02f, 1.85716704e-01f, -9.82599556e-02f,
  8.28041509e-02f, -4.49408256e-02f, 5.90111502e-02f, -2.20108274e-02f, 1.59254998e-01f, -7.79148713e-02f, 8.73922743e-03f, -1.68416888e-01f, 7.01884702e-02f, 1.68185066e-02f,
  8.26579258e-02f, -1.08162062e-02f, -2.58773509e-02f, 8.86364803e-02f, -3.33115794e-02f, -6.42500147e-02f, -5.80897443e-02f, 3.51754166e-02f, -6.23325333e-02f, -1.53325917e-02f,
  -2.60531038e-01f, 1.48423731e-01f, -1.64424017e-01f, -5.71506135e-02f, -9.11749899e-03f, -2.94805598e-03f, -3.50399986e-02f, -3.66259590e-02f, 6.14327788e-02f, -4.95845489e-02f,
  5.62261865e-02f, -3.65736373e-02f, -2.04667434e-01f, -4.61566597e-02f, -4.48677242e-02f, -1.94918998e-02f, -1.75268069e-01f, -2.84288973e-02f, 6.48289099e-02f, 5.51839285e-02f,
  -1.82329968e-01f, -1.93757012e-01f, -2.76893467e-01f, -2.73579776e-01f, -2.23256852e-02f, 2.14164320e-04f, -9.27618369e-02f, -1.55382842e-01f, -2.83119589e-01f, -6.02144122e-01f,
  -2.53844321e-01f, 4.52661663e-02f, -4.53151226e-01f, -8.01395178e-02f, 4.96882722e-02f, -2.60977745e-01f, -3.76985461e-01f, -3.25581849e-01f, 1.51068196e-01f, 1.49552628e-01f,
  1.73101708e-01f, 3.48005056e-01f, 4.14477326e-02f, -2.36734748e-02f, -3.92336845e-01f, -3.81578088e-01f, -3.06903303e-01f, -3.42637837e-01f, -2.26665661e-01f, 9.76756886e-02f,
  3.31706107e-01f, 1.85040772e-01f, 3.55083607e-02f, -5.12761697e-02f, 2.96734005e-01f, 1.86121881e-01f, 1.05920263e-01f, 1.33935660e-01f, 4.23769541e-02f, 1.22332051e-01f,
  1.72548458e-01f, -2.19958439e-01f, -9.41554084e-02f, 7.80466711e-04f, -1.32677667e-02f, -3.61384712e-02f, -2.74933735e-03f, -1.44152254e-01f, -2.71470416e-02f, 3.62419859e-02f,
  1.41269743e-01f, 1.41070664e-01f, -1.30518049e-01f, 1.09419003e-01f, 6.01697601e-02f, 5.37786521e-02f, -1.74333364e-01f, -2.74956077e-01f, -2.66422778e-01f, -3.12302019e-02f,
  5.43177053e-02f, -5.84993400e-02f, -7.25589544e-02f, -9.96467769e-02f, -1.58782393e-01f, -5.44996560e-02f, 5.60996048e-02f, 6.19274303e-02f, -1.99144199e-01f, 2.41107140e-02f,
  1.03683490e-02f, 1.30792603e-01f, 7.65375122e-02f, 1.01156726e-01f, 1.86698660e-01f, 6.75854757e-02f, 2.24454999e-02f, 1.61876082e-01f, 5.61906174e-02f, -2.73564551e-02f,
  -8.29307642e-03f, -1.16901837e-01f, 8.84517934e-03f, -8.32447410e-02f, 5.75079247e-02f, -2.45576650e-02f, -1.95334107e-03f, 5.57235703e-02f, 5.62562458e-02f, 6.25042245e-02f,
  2.75422819e-02f, 3.72418389e-02f, 7.57133588e-02f, -1.10673480e-01f, 5.68819325e-03f, 4.06595059e-02f, 1.20984716e-02f, 1.43071681e-01f, -1.16139054e-02f, 4.47585173e-02f,
  4.09809828e-01f, -1.96671724e-01f, 1.17121123e-01f, -7.24150166e-02f, -1.43588960e-01f, 2.96267904e-02f, -1.33319441e-02f, -5.78010529e-02f, 3.76209393e-02f, -5.32371551e-03f,
  5.10161631e-02f, -2.84749549e-02f, 4.61674146e-02f, 7.98135400e-02f, 8.65692496e-02f, 1.02635853e-01f, 5.58992848e-02f, -1.23774320e-01f, -3.25575322e-02f, 4.65409532e-02f,
  -1.09266192e-01f, 3.10870372e-02f, 7.64749572e-02f, -1.00587852e-01f, -1.26511725e-02f, 1.76406577e-02f, 2.33178437e-01f, 8.45316574e-02f, -7.27557242e-02f, -4.78078239e-03f,
  5.99747539e-01f, -2.80455619e-01f, -1.87949792e-01f, -5.04852086e-02f, -8.79792720e-02f, 1.13592610e-01f, -6.00776672e-02f, 7.64571577e-02f, 5.08136153e-02f, 5.48974238e-02f,
  2.45080832e-02f, 2.63761163e-01f, 2.20523685e-01f, 2.07550585e-01f, 3.27714562e-01f, -6.95397258e-02f, -1.10616989e-01f, 1.99933469e-01f, 3.85843635e-01f, 1.12471782e-01f,
  -7.20549598e-02f, -1.44502625e-01f, -8.77626985e-03f, -8.79449621e-02f, -4.35208172e-01f, -4.32718406e-03f, -2.89483488e-01f, -2.06612006e-01f, -1.87204883e-01f, -2.44549602e-01f,
  1.00838929e-01f, -1.36958107e-01f, 9.51207653e-02f, 1.21634202e-02f, -7.74005949e-02f, 1.05930962e-01f, 3.37645411e-02f, -7.47957900e-02f, -8.10397789e-02f, -1.57470077e-01f,
  -3.10799722e-02f, 5.24604768e-02f, 6.27137721e-03f, -1.12569056e-01f, -1.23618059e-01f, -5.25857620e-02f, -1.37225062e-01f, -9.71248373e-03f, 5.08354194e-02f, -6.37761876e-02f,
  -1.70674846e-01f, -7.19687045e-02f, -7.79657364e-02f, -1.09919831e-01f, -1.82650536e-01f, 1.29458204e-01f, -1.54761016e-01f, -1.89834788e-01f, -2.74221506e-03f, -1.61596537e-01f,
  -1.50902513e-02f, 4.24039997e-02f, -6.76982701e-02f, -8.58231187e-02f, 6.12621754e-02f, 8.03694203e-02f, 1.88892260e-02f, -3.64172086e-02f, 4.10900973e-02f, -9.01304111e-02f,
  -5.59297018e-02f, -3.57244238e-02f, 5.39183542e-02f, 3.87595519e-02f, 1.03262261e-01f, -2.12535802e-02f, -5.11920042e-02f, 3.52758169e-02f, -3.88390608e-02f, 1.05781138e-01f,
  1.50364012e-01f, 2.59954464e-02f, 1.44065060e-02f, 1.53088570e-01f, 7.22966567e-02f, 2.03824472e-02f, 4.25109901e-02f, 5.51600084e-02f, -5.12961969e-02f, -3.72908041e-02f,
  -4.17088084e-02f, 2.68825710e-01f, 8.76617879e-02f, 4.68849801e-02f, -1.03808403e-01f, 2.17303392e-02f, -1.19051579e-02f, 5.47793992e-02f, -1.79175977e-02f, 5.52794188e-02f,
  -5.74690849e-02f, 1.34768471e-01f, -1.10465653e-01f, -1.37640148e-01f, 6.53544366e-02f, 5.63887805e-02f, -6.27106354e-02f, 1.29299447e-01f, 1.62674367e-01f, 7.74883404e-02f,
  -5.18471710e-02f, 4.23797127e-03f, 1.75199196e-01f, 5.59613667e-03f, -5.64976223e-02f, 2.54795343e-01f, 1.17173947e-01f, 5.72689921e-02f, 2.39296034e-01f, 1.14437461e-01f,
  -1.45405099e-01f, 2.01242805e-01f, -1.86584398e-01f, 8.25730525e-03f, 1.45716175e-01f, -1.21355141e-02f, 1.89655155e-01f, -8.47474858e-02f, 3.77180204e-02f, 4.15622026e-01f,
  3.22791457e-01f, -1.43904015e-01f, -1.52373612e-01f, -2.70750672e-01f, -4.31774437e-01f, -1.34398201e-02f, -2.02668026e-01f, -5.74506879e-01f, -5.71922779e-01f, -3.58221591e-01f,
  -1.35526031e-01f, -2.30084255e-01f, -3.82913858e-01f, -3.55001837e-01f, 1.67829126e-01f, -3.78362536e-01f, -1.83289170e-01f, -2.75032640e-01f, -2.10206628e-01f, 6.58553913e-02f,
  -2.99109578e-01f, -1.13111086e-01f, -2.34682392e-02f, 7.75751323e-02f, 1.32098258e-01f, 4.77567129e-02f, 1.44733384e-01f, -9.54998471e-03f, 2.82348424e-01f, 1.06826358e-01f,
  2.36821532e-01f, 1.07783310e-01f, 7.69636035e-02f, 2.11002100e-02f, 6.54360652e-02f, 6.45028427e-02f, -4.81909439e-02f, -8.53667185e-02f, 4.36235890e-02f, 9.40656438e-02f,
  3.15755188e-01f, -3.34609374e-02f, 2.02641319e-02f, -2.97990581e-03f, -8.53022039e-02f, -1.26326066e-02f, 4.40840200e-02f, -2.04413041e-01f, -2.97570527e-01f, 1.18279913e-02f,
  7.71622881e-02f, 1.60639316e-01f, 2.67035849e-02f, -4.32278663e-02f, 9.73955318e-02f, -1.64413303e-02f, -1.71577912e-02f, 1.45293415e-01f, -8.20784718e-02f, 2.98843309e-02f,
  6.18929304e-02f, 6.24827780e-02f, 9.32585746e-02f, -1.51433395e-02f, 1.83737315e-02f, 2.39430815e-02f, -1.20942844e-02f, -2.52410416e-02f, 5.40612377e-02f, 2.94924527e-02f,
  3.55759822e-02f, 1.15092181e-01f, -1.96734555e-02f, -4.17558178e-02f, 2.12345142e-02f, -3.60045768e-02f, 8.01330730e-02f, 8.59913155e-02f, 9.14986655e-02f, 1.10352404e-01f,
  -3.61089587e-01f, -1.28219575e-01f, 4.46169786e-02f, 2.20761485e-02f, 8.77905786e-02f, -1.15391240e-03f, 1.69023186e-01f, 2.35768426e-02f, 1.93010420e-01f, 1.28160655e-01f,
  1.20725021e-01f, 1.91174254e-01f, 3.20052803e-02f, 5.25713041e-02f, 5.78258336e-02f, 5.73255960e-03f, 7.94546381e-02f, -6.00918271e-02f, -3.13584171e-02f, 2.85860032e-01f,
  1.40702456e-01f, -1.37707070e-01f, -9.84720811e-02f, 4.78447229e-02f, 1.18282266e-01f, -1.89716443e-01f, -8.94997790e-02f, -1.38355061e-01f, -2.83683896e-01f, -5.71673438e-02f,
  -3.25667351e-01f, -1.18584968e-01f, -1.01724230e-01f, -3.41435038e-02f, 1.57551005e-01f, -6.39248686e-03f, -1.22336507e-01f, 1.93907619e-01f, 3.36084187e-01f, 3.19200940e-02f,
  4.45037112e-02f, -2.92177964e-02f, -7.07305148e-02f, -2.26474971e-01f, -2.94079393e-01f, -1.13109224e-01f, -2.32744843e-01f, -3.31277102e-01f, -2.69948512e-01f, -9.87395346e-02f,
  -9.01134312e-02f, -2.32478961e-01f, -2.52583891e-01f, -2.02506185e-01f, -1.13730066e-01f, -2.96923876e-01f, -2.19820395e-01f, -1.65878668e-01f, -3.27074170e-01f, -2.10277215e-01f,
  -1.73530906e-01f, 1.78074419e-01f, -7.11960793e-02f, -1.25357315e-01f, -4.60012583e-03f, 8.35767537e-02f, 4.31632176e-02f, 5.53569831e-02f, 3.27334590e-02f, 4.42743078e-02f,
  -6.36709929e-02f, 2.18528628e-01f, 1.12524837e-01f, -9.32496786e-02f, 1.39790848e-02f, 2.19817087e-03f, 7.09279627e-02f, -6.47734180e-02f, 5.18280007e-02f, 6.91335201e-02f,
  7.09103001e-03f, -2.47274131e-01f, -3.03334504e-01f, -7.82609805e-02f, 4.69925590e-02f, -1.31151259e-01f, -9.61707383e-02f, -1.49850383e-01f, -3.47745508e-01f, -3.41971725e-01f,
  5.25671095e-02f, 7.52070993e-02f, 1.00928664e-01f, -2.79261544e-02f, 3.68259177e-02f, 1.35025874e-01f, -7.47433901e-02f, -1.88166216e-01f, 6.34498149e-02f, -1.31034166e-01f,
  7.97108263e-02f, -2.17065588e-02f, 8.69929269e-02f, -9.01463926e-02f, -8.27395767e-02f, -6.85707703e-02f, -1.13626413e-01f, -1.64338961e-01f, -2.84947723e-01f, -1.47739127e-01f,
  -9.41933468e-02f, 1.86842401e-02f, 1.70649618e-01f, 4.99090627e-02f, -1.22322455e-01f, -1.70182765e-01f, 6.49702176e-02f, -3.95286595e-03f, 1.67455643e-01f, 7.24520460e-02f,
  1.51564991e-02f, -1.58520982e-01f, -1.87649131e-01f, -1.31182089e-01f, -1.07645422e-01f, -5.78638092e-02f, -1.37498364e-01f, -4.00408916e-02f, 1.00638203e-01f, 2.34341957e-02f,
  -2.21274961e-02f, 1.39022380e-01f, 1.33678541e-01f, -1.11476490e-02f, 6.38587167e-03f, -4.33352124e-03f, -1.59367651e-01f, -1.11773916e-01f, -7.60582685e-02f, 1.75573245e-01f,
  -5.30685447e-02f, -4.26118284e-01f, -2.98205018e-01f, -2.15189591e-01f, -8.25709924e-02f, -4.10010785e-01f, -2.79548675e-01f, -1.24340355e-01f, -2.81218886e-01f, -4.47325736e-01f,
  8.71287167e-01f, -7.26179825e-03f, -5.37159741e-01f, 2.43165851e-01f, -3.19790930e-01f, -1.90657899e-01f, -1.93849549e-01f, 1.05397142e-01f, 1.70456886e-01f, -1.62089795e-01f,
  8.59066248e-02f, 4.14243191e-01f, 3.10959190e-01f, 1.64791256e-01f, 1.82227865e-01f, -1.91368520e-01f, -4.07482475e-01f, -6.12234585e-02f, 1.22167110e-01f, 5.42360963e-03f,
  -1.00360677e-01f, -1.28459670e-02f, 1.55431896e-01f, 9.64577198e-02f, -2.51192927e-01f, -5.86786307e-02f, -3.83968711e-01f, -2.44131237e-01f, -2.61678487e-01f, -3.83582443e-01f,
  -1.10658526e-01f, 8.70859772e-02f, -1.77277863e-01f, 1.34833112e-01f, -1.44110695e-01f, 8.89260918e-02f, 8.56146216e-02f, -2.65760999e-02f, -1.39632830e-02f, -2.61247307e-02f,
  -2.20271274e-02f, 1.00521944e-01f, 9.58842635e-02f, -6.41200170e-02f, -9.09753367e-02f, 1.52409365e-02f, -1.18678845e-01f, -4.30159718e-02f, -7.62957931e-02f, -2.71177143e-02f,
  9.67460964e-03f, -2.02974826e-02f, -9.95225981e-02f, -9.01240781e-02f, -1.58736244e-01f, -1.24387339e-01f, -2.30199873e-01f, -1.79847956e-01f, 2.06715874e-02f, -1.69476122e-01f,
  1.02091625e-01f, -9.42445733e-03f, -1.31257877e-01f, -1.02596462e-01f, -1.92671176e-02f, 3.78578864e-02f, 3.15424316e-02f, -6.95395917e-02f, -1.30309043e-02f, 6.71122894e-02f,
  -4.71992306e-02f, 4.17630747e-03f, -3.73123586e-02f, 1.28952354e-01f, 5.17521845e-03f, -1.53890047e-02f, 7.35593587e-02f, 5.21838339e-03f, -6.75820187e-02f, 2.99100112e-02f,
  4.11468148e-02f, -1.16997682e-01f, 1.12760827e-01f, 3.17474492e-02f, -7.58842230e-02f, -3.55119072e-02f, 1.38502661e-02f, -4.75365184e-02f, 1.22194417e-01f, -1.97087824e-02f,
  4.10101414e-01f, 1.15088694e-01f, 5.27695529e-02f, -8.45684633e-02f, 1.99071001e-02f, 4.10688110e-03f, -2.99494825e-02f, -1.19056195e-01f, 1.71428062e-02f, 8.13913569e-02f,
  -1.01186007e-01f, 1.27785653e-01f, -3.53103168e-02f, -7.87148550e-02f, -2.09611934e-02f, 7.65252858e-03f, -8.96105021e-02f, -6.83074445e-02f, 1.57803316e-02f, -1.10760011e-01f,
  -4.26349714e-02f, 3.99378128e-02f, 1.75420254e-01f, 1.16536453e-01f, -4.34456766e-03f, 1.59209028e-01f, -6.01109490e-02f, -1.51388124e-01f, 1.25852972e-01f, -6.09501414e-02f,
  3.70050162e-01f, -2.87321657e-01f, -3.12416375e-01f, 1.75989151e-01f, -2.21070886e-01f, -2.23548189e-01f, -3.52918983e-01f, -6.13436708e-03f, 1.34259418e-01f, -3.92811775e-01f,
  -2.37286776e-01f, 2.04620749e-01f, -1.75953899e-02f, -1.59314677e-01f, -1.00428231e-01f, -5.06971180e-01f, -3.81443560e-01f, -2.71793395e-01f, -1.28009796e-01f, -1.69437885e-01f,
  -5.65957092e-02f, 1.88278360e-03f, -4.95211296e-02f, 4.88766246e-02f, -4.15376686e-02f, -1.08979698e-02f, -2.35288724e-01f, -9.80034173e-02f, -2.50108421e-01f, -2.86940753e-01f,
  -2.51255870e-01f, 1.16483003e-01f, 2.80626845e-02f, 5.37443087e-02f, -8.55381861e-02f, 6.40310422e-02f, -8.30219537e-02f, 1.15518868e-01f, 8.88759494e-02f, 1.23113822e-02f,
  7.09870970e-03f, 4.36661094e-02f, 1.88288942e-01f, 3.95368151e-02f, 2.75991913e-02f, 6.81276470e-02f, -1.10806795e-02f, -7.84491524e-02f, -1.10481322e-01f, -3.56739983e-02f,
  -1.68518528e-01f, -1.54473290e-01f, -7.39381015e-02f, 7.10835010e-02f, 1.51513144e-01f, 6.63661212e-02f, -4.13600393e-02f, 1.61685139e-01f, 5.32049052e-02f, 6.70601130e-02f,
  -1.23068437e-01f, 2.01012939e-02f, -2.66324934e-02f, -2.36779582e-02f, 1.12751462e-01f, -6.21631704e-02f, -3.00559662e-02f, -5.18504381e-02f, 1.95147342e-03f, 1.44745577e-02f,
  7.25626014e-03f, -2.22559068e-02f, 5.83603717e-02f, -7.94466361e-02f, -1.82387039e-01f, 2.23021023e-02f, 5.97736752e-03f, -3.76218334e-02f, -6.18847869e-02f, 6.02015555e-02f,
  4.66168523e-02f, -3.82664725e-02f, 3.27987559e-02f, -7.13450387e-02f, -1.03186041e-01f, -7.85332918e-03f, -5.81146963e-03f, -9.15589835e-03f, 1.17310092e-01f, 2.92699784e-02f,
  5.09310514e-02f, -2.02454150e-01f, -1.03085175e-01f, 1.43696859e-01f, 1.47567503e-02f, -2.20543575e-02f, -4.52904776e-02f, -7.66346604e-02f, 1.94127019e-03f, -3.52934487e-02f,
  -2.57586464e-02f, 6.21420592e-02f, -1.20067177e-02f, -2.34157573e-02f, -6.27500266e-02f, -7.24311545e-02f, -9.43203270e-02f, -3.63707505e-02f, -2.49227900e-02f, 1.06514581e-01f,
  -1.30476549e-01f, -9.08174217e-02f, 1.54978270e-02f, -1.00050934e-01f, 3.97482440e-02f, -4.18103263e-02f, -6.53067306e-02f, -8.00934806e-02f, -1.17455691e-01f, -1.78072289e-01f,
  -2.67551720e-01f, -2.81588137e-01f, 1.66034698e-01f, 1.73333511e-01f, 1.64245874e-01f, -2.32747421e-01f, -4.83895242e-01f, -4.79081273e-01f, -9.63608474e-02f, 6.89796507e-02f,
  9.11539644e-02f, 1.35292768e-01f, 1.89902589e-01f, 1.60371855e-01f, -8.90027061e-02f, 6.79410473e-02f, 1.59414560e-01f, 1.60051480e-01f, -1.47404701e-01f, -2.55998403e-01f,
  1.52705938e-01f, 8.23195279e-02f, -8.44752043e-02f, -7.94654563e-02f, 1.79957360e-01f, -9.94830113e-03f, 1.01813421e-01f, 1.41092643e-01f, 3.08540631e-02f, 3.63330901e-01f,
  3.21897358e-01f, -1.44435272e-01f, 8.89358819e-02f, 8.17977414e-02f, 1.77940875e-01f, -1.69295013e-01f, -7.08620623e-02f, -4.51911539e-02f, -1.10708596e-02f, -4.38365526e-02f,
  8.30287412e-02f, -7.84999281e-02f, 6.88531771e-02f, -1.83746628e-02f, -1.85638994e-01f, -3.49813193e-01f, -1.18023142e-01f, -8.18851516e-02f, -1.14059381e-01f, -2.65785307e-01f,
  1.99813113e-01f, 3.77721190e-02f, -1.22781768e-01f, -2.25876212e-01f, -2.44912535e-01f, 3.79921645e-02f, -1.49488524e-01f, -1.75372988e-01f, -4.02715743e-01f, -1.81388900e-01f,
  5.96325099e-02f, 6.10954389e-02f, -5.66573888e-02f, -4.97943722e-02f, -5.51089225e-03f, 1.83079466e-01f, 1.82596073e-01f, 1.16844267e-01f, 1.83751360e-02f, -5.36715463e-02f,
  -3.25814821e-02f, -2.11364236e-02f, -9.01653711e-03f, -9.82464105e-03f, 1.63932368e-01f, -1.07127585e-01f, 5.30982716e-03f, -9.21921432e-02f, 8.69183540e-02f, -4.37128730e-02f,
  2.76863184e-02f, -1.54467989e-02f, 6.48479462e-02f, -1.27569720e-01f, -5.39112929e-03f, -1.73325595e-02f, 3.05947661e-03f, -5.67443557e-02f, -3.30039747e-02f, -1.24489471e-01f,
  -2.85880398e-02f, 1.20221145e-01f, 6.24649934e-02f, 6.08259533e-03f, 9.69828740e-02f, 8.44959989e-02f, 7.00720027e-02f, 5.70804030e-02f, -3.46066058e-02f, -1.40079811e-01f,
  -2.80706018e-01f, -5.91899976e-02f, -2.21651718e-02f, -1.24147143e-02f, -1.98137373e-01f, -1.37919456e-01f, 7.93095082e-02f, 2.12258138e-02f, -7.62129389e-03f, -3.17310654e-02f,
  -7.62493510e-05f, -1.61224976e-01f, -2.37909421e-01f, -1.76646546e-01f, -1.22920647e-01f, -8.70050639e-02f, -9.08413678e-02f, -2.43643433e-01f, -3.33867580e-01f, -5.53662002e-01f,
  2.72644222e-01f, -3.78129482e-01f, -3.54418963e-01f, -3.04364800e-01f, -2.79658318e-01f, -6.26644492e-02f, -9.17741507e-02f, -7.63604268e-02f, -5.01249246e-02f, -1.98576957e-01f,
  1.68332234e-02f, 2.16421142e-01f, 4.44177128e-02f, 6.40803576e-02f, 5.57919480e-02f, -1.61748752e-01f, -2.02125415e-01f, 4.77634594e-02f, 1.73527077e-01f, 7.31085241e-02f,
  -2.56709587e-02f, -5.76598197e-02f, -1.62786152e-02f, 2.67508477e-02f, -2.20270291e-01f, -3.17280740e-02f, -3.11632484e-01f, -1.15973361e-01f, -1.86137870e-01f, -3.28784525e-01f,
  -1.69236630e-01f, 4.66912836e-02f, 5.23850359e-02f, 2.47185677e-03f, -3.08877639e-02f, 4.87921014e-02f, 8.12334418e-02f, -7.30894506e-02f, -2.32741013e-02f, -6.96150586e-02f,
  -1.23643540e-02f, 2.81972717e-02f, 6.57927245e-02f, -5.41441180e-02f, -9.76338461e-02f, 8.97483453e-02f, -1.12951934e-01f, -6.49085594e-03f, -3.06200739e-02f, -6.06360175e-02f,
  2.27440409e-02f, 1.80192245e-03f, -7.87907466e-02f, -5.91960996e-02f, 3.23869251e-02f, 1.09351967e-02f, -7.73378387e-02f, -1.27208494e-02f, 2.17922824e-03f, -2.57510003e-02f,
  -1.01354674e-01f, -2.99726930e-02f, -1.52308410e-02f, 1.37690911e-02f, 8.59960169e-02f, 2.16275901e-02f, -1.61374062e-02f, 7.84707963e-02f, 6.62679598e-02f, 2.70476174e-02f,
  -1.31527409e-01f, -1.07952982e-01f, -6.25406727e-02f, -9.81469452e-03f, 9.16701462e-03f, -7.14555457e-02f, -3.73182334e-02f, 6.02366440e-02f, -7.97556415e-02f, -7.77182057e-02f,
  -4.28781956e-02f, -2.30342690e-02f, -1.31701678e-01f, -8.79872218e-02f, -4.54689190e-02f, -1.77487835e-01f, -2.94263829e-02f, 1.19689414e-02f, 1.45986341e-02f, -3.77691910e-02f,
  -1.24201238e-01f, 1.92337409e-01f, 1.32680774e-01f, 9.37447697e-02f, 1.03971409e-02f, 8.25481415e-02f, 1.34876342e-02f, -1.25542181e-02f, 4.06146199e-02f, -5.45857660e-02f,
  2.37468872e-02f, 1.24465033e-01f, -1.05880760e-02f, 2.36954186e-02f, 9.53442007e-02f, 1.58729196e-01f, 3.23293321e-02f, 3.54988612e-02f, 5.14526106e-03f, 2.27529556e-02f,
  -4.89780866e-02f, 1.17894210e-01f, 1.15124144e-01f, 4.10077311e-02f, 2.08974183e-01f, 2.07131669e-01f, 1.06956057e-01f, 1.25087321e-01f, 5.43839745e-02f, -5.74854314e-02f,
  2.29243740e-01f, 3.09275389e-01f, -8.71554483e-03f, 1.68354526e-01f, 2.65617520e-01f, -7.46460184e-02f, -5.45107983e-02f, -1.56404704e-01f, 2.92977877e-02f, 2.34650373e-01f,
  2.89631784e-01f, 2.25089431e-01f, 6.21577390e-02f, -6.71731532e-02f, -1.31347671e-01f, -1.36312634e-01f, -2.57548932e-02f, -7.57504702e-02f, -2.36378193e-01f, 3.29645653e-03f,
  1.87945709e-01f, 2.87030697e-01f, 8.51297155e-02f, 7.84518477e-03f, 9.68826562e-02f, -4.49622422e-02f, 7.81482086e-02f, 2.03467190e-01f, 2.33611852e-01f, 2.70606399e-01f,
  7.43264407e-02f, 1.49722114e-01f, -3.67366523e-01f, 6.15215972e-02f, 7.74392635e-02f, -5.93515076e-02f, -1.00026563e-01f, 2.47838870e-02f, 2.74486747e-02f, -1.35564312e-01f,
  1.32991612e-01f, 1.05496682e-02f, 2.46696353e-01f, -1.86500605e-02f, 6.38131425e-02f, 3.20591615e-03f, -4.03188430e-02f, -1.21271424e-01f, -1.88927099e-01f, -1.33176178e-01f,
  2.13332713e-01f, 2.17952311e-01f, -9.53432359e-03f, -2.57749975e-01f, -3.21477681e-01f, -1.74822971e-01f, -6.31153286e-02f, -1.64968878e-01f, -2.05680892e-01f, -2.00477362e-01f,
  -1.47307336e-01f, -2.59120613e-01f, 7.96882249e-03f, 1.07870856e-02f, -1.14910744e-01f, -1.06485546e-01f, -5.05468808e-02f, -1.85617611e-01f, -1.05795905e-01f, -7.47563168e-02f,
  4.08786125e-02f, -1.84816718e-01f, -1.26194134e-01f, -8.35851058e-02f, -4.89693275e-03f, -7.93492198e-02f, -1.40321895e-01f, -1.17109403e-01f, -1.11114876e-02f, -5.65334223e-02f,
  1.14258841e-01f, -1.67404011e-01f, 3.71794179e-02f, -3.37226912e-02f, -4.11277637e-02f, -2.11922511e-01f, -1.64905697e-01f, -7.14648217e-02f, -1.13744557e-01f, 1.00259393e-01f,
  1.25100583e-01f, 5.73550276e-02f, -1.35219187e-01f, -2.37005446e-02f, 8.25810730e-02f, -1.66196171e-02f, 9.74596292e-02f, 5.37658930e-02f, 1.17587507e-01f, -6.47262335e-02f,
  4.31866720e-02f, -1.90332398e-01f, 1.82618737e-01f, 7.00635538e-02f, -1.80042572e-02f, 7.17731938e-03f, 3.58231440e-02f, 5.06460853e-02f, -6.64727315e-02f, -5.27138263e-02f,
  -3.22156921e-02f, -6.30515292e-02f, -2.01089278e-01f, -2.82934487e-01f, -1.27643332e-01f, -1.07954986e-01f, -1.55601859e-01f, -1.05171427e-01f, -2.42326722e-01f, -2.32700944e-01f,
  4.04907525e-01f, -1.11778773e-01f, 2.64965534e-01f, 2.52125949e-01f, 2.48812735e-01f, 2.09069476e-01f, 6.49155229e-02f, 6.85523972e-02f, -2.26594470e-02f, 1.03225835e-01f,
  1.89770497e-02f, -1.92569513e-02f, 4.23083343e-02f, -1.37768388e-01f, -1.39509648e-01f, -1.88848987e-01f, -1.40229002e-01f, 6.96234033e-02f, 6.89097568e-02f, 9.30547807e-03f,
  -3.23790610e-02f, 2.76889130e-02f, 2.28959639e-02f, -9.16389897e-02f, -5.03012270e-04f, 3.20313051e-02f, -8.09954014e-04f, 2.21487340e-02f, 4.21025530e-02f, -1.99401274e-01f,
  3.58633429e-01f, 3.58497709e-01f, 1.10467046e-01f, 1.06748626e-01f, -8.77085328e-03f, 5.94440103e-03f, 1.33304894e-01f, -3.01433317e-02f, -6.34818673e-02f, 1.79169476e-02f,
  4.66479734e-02f, 6.18443266e-02f, 7.10800439e-02f, 9.19257849e-02f, 2.43198946e-02f, 2.62528062e-02f, 9.68847573e-02f, -5.27867191e-02f, -1.01242490e-01f, 2.71464675e-03f,
  4.40532006e-02f, 8.93292651e-02f, 1.38808005e-02f, 4.22518104e-02f, 6.25389591e-02f, 6.37117848e-02f, 1.53666764e-01f, 1.10423356e-01f, 9.53922272e-02f, 4.19295728e-02f,
  6.51287809e-02f, -5.32083474e-02f, 1.27259552e-01f, 1.02896906e-01f, -8.39540213e-02f, -8.28255042e-02f, -9.29424986e-02f, -2.44845282e-02f, -7.12143704e-02f, -6.41922131e-02f,
  -1.05696276e-01f, 9.71673131e-02f, 1.86168682e-02f, -2.27540769e-02f, 5.88314123e-02f, 1.35994643e-01f, -2.64244433e-02f, 3.26064341e-02f, 1.32999286e-01f, 2.07444374e-02f,
  9.56332237e-02f, -7.41207823e-02f, 2.75062323e-02f, 3.02499961e-02f, 2.90047135e-02f, 4.79561724e-02f, 2.13991031e-02f, 1.10794445e-02f, -4.28951606e-02f, -4.12284285e-02f,
  -1.62608419e-02f, 2.61718780e-01f, -2.95403376e-02f, -6.39384910e-02f, 8.00952464e-02f, -1.70318261e-02f, 1.20812252e-01f, -4.18520048e-02f, -8.88613984e-02f, 8.99157673e-02f,
  -5.17832749e-02f, 5.55080250e-02f, 6.92498162e-02f, 3.72173786e-02f, -5.95294759e-02f, 1.36639997e-01f, -4.04323079e-03f, -6.72419295e-02f, -1.04728006e-01f, 3.49407122e-02f,
  -3.54028121e-02f, -2.70904060e-02f, 5.67227006e-02f, -1.48709128e-02f, -4.62159961e-02f, 1.58150703e-01f, 5.89271225e-02f, 1.22151807e-01f, 4.67057945e-03f, 6.55172542e-02f,
  2.33712383e-02f, 5.38458705e-01f, 2.94105917e-01f, -1.06352590e-01f, 2.56465226e-01f, 3.33981186e-01f, 6.18368208e-01f, 4.61686663e-02f, -1.57316923e-01f, 7.96364173e-02f,
  2.27963880e-01f, -3.23997110e-01f, -2.46726826e-01f, -9.11345631e-02f, 6.02363795e-02f, 7.48514533e-02f, 4.06885296e-02f, -1.55262798e-01f, -1.68761700e-01f, -6.35444596e-02f,
  -1.24251686e-01f, -2.01581702e-01f, -1.28429070e-01f, -2.28966609e-01f, -3.71148176e-02f, -3.20403039e-01f, 1.05655260e-01f, 2.29085416e-01f, 2.19784006e-01f, -5.44291697e-02f,
  7.15852156e-02f, 4.76667106e-01f, -2.99302131e-01f, -2.08875701e-01f, 1.53383791e-01f, -1.94077611e-01f, -1.67242259e-01f, -2.07173843e-02f, -4.44093719e-02f, -2.59735081e-02f,
  5.91609739e-02f, 1.72254245e-03f, 7.36352205e-02f, -3.95891117e-03f, 1.11083733e-02f, -3.50060202e-02f, 1.28740057e-01f, 2.54495312e-02f, -1.59870639e-01f, 5.88115826e-02f,
  -5.42387143e-02f, 2.69402146e-01f, 3.36383373e-01f, 8.99030119e-02f, 1.03096396e-01f, -2.22540766e-01f, 1.65387735e-01f, 2.52757370e-02f, 1.69171289e-01f, -1.44688591e-01f,
  -1.78549454e-01f, 4.49079648e-02f, 1.45230278e-01f, 3.00600007e-02f, -3.95065956e-02f, 1.58618335e-02f, 2.57239249e-02f, -6.13687038e-02f, -1.04210444e-01f, 7.98244867e-03f,
  -6.81970417e-02f, -2.07634345e-02f, -5.04051745e-02f, 6.76947534e-02f, -1.34269834e-01f, 1.03813589e-01f, 1.14479639e-01f, 3.55280749e-02f, 1.30830720e-01f, 5.89871556e-02f,
  -1.36006083e-02f, -5.84307685e-02f, 2.39915568e-02f, -4.79813926e-02f, 2.93982979e-02f, -1.04923025e-01f, -1.36374742e-01f, -4.92038988e-02f, -5.48478141e-02f, 2.39422619e-02f,
  -2.16972560e-01f, 3.40485334e-01f, -2.75896966e-01f, -1.24616034e-01f, 1.03456438e-01f, 9.64446634e-04f, -1.04476288e-02f, -1.99792627e-02f, 1.09260879e-01f, -1.81763068e-01f,
  2.06171691e-01f, 4.75144498e-02f, 7.90548548e-02f, 7.10104257e-02f, -2.01953083e-01f, -8.04756731e-02f, 7.52748400e-02f, -9.39606428e-02f, -1.64891124e-01f, 1.38706816e-02f,
  -1.50431097e-01f, -1.35742739e-01f, -2.29728103e-01f, -2.33460873e-01f, -2.48678803e-01f, -4.00731623e-01f, -1.59130506e-02f, -9.18583348e-02f, -1.17789738e-01f, -2.87780315e-01f,
  3.80044162e-01f, -1.28847733e-01f, 3.33194554e-01f, 1.35883823e-01f, 2.31501639e-01f, 2.38431901e-01f, 3.28482211e-01f, 1.74316943e-01f, 1.40682245e-02f, -2.54105777e-02f,
  -1.28699437e-01f, -2.59726793e-01f, -2.62650102e-01f, -2.96578944e-01f, -2.36484539e-02f, 1.08388647e-01f, 1.12607852e-01f, 2.87411630e-01f, 1.65797561e-01f, 1.45327836e-01f,
  -9.20467898e-02f, 1.78941712e-01f, 1.80621192e-01f, 3.11666988e-02f, -1.16703864e-02f, -1.06603965e-01f, 1.58854485e-01f, -2.16624141e-02f, -3.64317596e-02f, -1.85726970e-01f,
  6.73336312e-02f, 4.58913930e-02f, -1.94835186e-01f, -2.51480728e-01f, -1.22121476e-01f, 1.06691550e-02f, -3.04639488e-02f, -1.62563883e-02f, -2.66918913e-02f, 3.30587588e-02f,
  1.41649200e-02f, -1.84857065e-03f, -1.05372086e-01f, 3.75752524e-02f, 1.21173546e-01f, -2.42496040e-02f, -1.25787240e-02f, 1.54295921e-01f, -8.12142491e-02f, -3.16214487e-02f,
  -2.68918157e-01f, -3.87412147e-03f, 8.64451602e-02f, -1.19562605e-02f, 1.10659283e-02f, 4.90365140e-02f, -5.89175243e-03f, -4.48941961e-02f, -6.81250542e-03f, 1.23674143e-02f,
  -1.05743371e-01f, -6.42890707e-02f, 1.26630953e-02f, 1.05364799e-01f, -3.58356792e-03f, -1.78638920e-02f, 1.32759186e-02f, 9.17323753e-02f, 1.03360146e-01f, 1.16823591e-01f,
  1.25657618e-01f, 1.13961913e-01f, 2.21797287e-01f, 1.76355630e-01f, -9.36481506e-02f, 5.86042507e-03f, 3.74467708e-02f, -8.45768079e-02f, 9.91922542e-02f, 1.28585845e-01f,
  5.60967214e-02f, 8.22191387e-02f, 1.25463650e-01f, 1.11167720e-02f, 5.36813922e-02f, 1.23977579e-01f, 1.26347363e-01f, 4.10721079e-02f, 4.69635427e-02f, 8.08980390e-02f,
  5.78828789e-02f, -3.70975919e-02f, -1.78592011e-01f, -4.12920713e-02f, 3.07276119e-02f, -6.41386136e-02f, -7.83879310e-02f, -6.40438423e-02f, -3.95120978e-02f, 1.15618505e-01f,
  -3.55702192e-02f, 4.25791517e-02f, 9.81788710e-02f, 2.29241792e-02f, 2.42518887e-01f, 6.23535551e-02f, -1.75466090e-01f, -1.39471274e-02f, -5.52055426e-02f, -3.01330462e-02f,
  -4.22737114e-02f, 1.29406422e-01f, 9.23347399e-02f, 5.21912389e-02f, 1.43745486e-02f, -1.47305056e-03f, 1.42203540e-01f, -4.79199886e-02f, 1.38324559e-01f, 2.77382545e-02f,
  3.01573396e-01f, 1.17785640e-01f, 2.99389035e-01f, 1.34659186e-01f, 2.82870203e-01f, 9.62331370e-02f, 1.78389654e-01f, -3.12147159e-02f, 1.77372992e-02f, 1.41332328e-01f,
  1.06344938e-01f, -4.33299690e-02f, 4.93346937e-02f, 4.20055613e-02f, -1.80885457e-02f, -2.74424218e-02f, -9.63497069e-03f, 1.43647790e-02f, 1.03579089e-01f, 9.36650634e-02f,
  1.15930941e-02f, 7.51346946e-02f, 8.81795809e-02f, 7.13674277e-02f, -5.84028549e-02f, 6.21380322e-02f, 8.92446190e-02f, 1.25975803e-01f, -1.56769005e-04f, -9.72647816e-02f,
  4.73051012e-01f, 2.65186906e-01f, -6.60486817e-02f, 5.71704544e-02f, 8.13172609e-02f, -2.85377800e-02f, 7.70030543e-02f, -2.46339422e-02f, -2.04301961e-02f, -1.34875342e-01f,
  1.01173557e-01f, 1.01810850e-01f, 1.46304414e-01f, -8.35791975e-02f, 1.01515427e-01f, 1.04063647e-02f, -1.84430834e-02f, -7.31935427e-02f, 4.23559807e-02f, 5.39625809e-02f,
  -5.55872992e-02f, 9.98761505e-02f, 7.58193210e-02f, -4.80443351e-02f, 5.11636510e-02f, 1.23767376e-01f, 1.32606730e-01f, 8.25513620e-03f, 3.43645550e-02f, 3.28803807e-02f,
  8.20332170e-02f, -7.00962497e-03f, 2.16389194e-01f, -4.69031893e-02f, 2.95216162e-02f, -1.64753824e-01f, -4.44963947e-03f, -4.07113284e-02f, 8.58585387e-02f, -2.34169085e-02f,
  3.63107119e-03f, 2.04141364e-02f, -3.62943336e-02f, -4.47006635e-02f, 1.72244072e-01f, 1.50241241e-01f, 2.15365039e-03f, 6.75202757e-02f, 1.38400104e-02f, 9.45339128e-02f,
  3.46121006e-02f, -4.83205989e-02f, 7.17967227e-02f, 8.21928829e-02f, -5.55673167e-02f, -5.41780703e-02f, -8.79960135e-03f, 1.10922288e-02f, 8.63012820e-02f, 7.50450138e-03f,
  2.93813944e-01f, 3.52758229e-01f, -8.71768370e-02f, -2.01783687e-01f, -4.95770983e-02f, 2.92858817e-02f, 2.60094530e-03f, 1.62612554e-02f, -4.26457934e-02f, -8.13821927e-02f,
  7.71502256e-02f, -2.65339334e-02f, 3.28054279e-02f, -5.79513125e-02f, 5.19835949e-02f, 1.16712051e-02f, -4.43993509e-02f, -9.51396078e-02f, 9.06852726e-03f, 5.85207529e-02f,
  -1.88954566e-02f, -2.32172366e-02f, -6.16511554e-02f, -6.41890392e-02f, 1.08629047e-05f, -1.75822817e-03f, 4.83975075e-02f, -4.88093942e-02f, 9.58479643e-02f, 2.23598909e-02f,
  4.42676961e-01f, -6.81357980e-02f, -9.40042734e-02f, 2.36959428e-01f, -2.11386010e-02f, -3.23233604e-01f, -3.61674726e-01f, -1.91040874e-01f, 3.24908607e-02f, 2.07448542e-01f,
  1.03542544e-01f, 3.20336133e-01f, 1.96435004e-01f, 1.41866848e-01f, -1.51466846e-01f, -1.33597031e-01f, 1.97224781e-01f, 2.22663611e-01f, 8.64298567e-02f, 1.90322489e-01f,
  2.37449348e-01f, 2.50872701e-01f, 1.75676167e-01f, 1.70280993e-01f, 3.25102270e-01f, 2.04372257e-01f, -2.42772028e-02f, 7.44050294e-02f, 1.24471664e-01f, 3.78195494e-01f,
  2.16437668e-01f, -6.12054579e-02f, 4.26404178e-02f, 1.30884260e-01f, 7.86856040e-02f, 4.35727313e-02f, -9.32661630e-03f, -3.13824415e-02f, -3.62891443e-02f, 5.50752170e-02f,
  8.58734846e-02f, 1.48112819e-01f, -7.14989007e-02f, 7.36817345e-03f, 7.57546052e-02f, 3.31718437e-02f, 6.63251728e-02f, 1.16167916e-03f, -1.73645854e-01f, -2.16719788e-02f,
  1.78066507e-01f, 1.16300963e-01f, -2.68031269e-01f, -3.12470496e-01f, -2.37939328e-01f, 7.58147761e-02f, -2.27032393e-01f, 4.10810113e-02f, -2.64502794e-01f, 1.35862023e-01f,
  1.46865454e-02f, 5.90928979e-02f, 7.53988102e-02f, 1.21604696e-01f, 7.13747889e-02f, 1.97562855e-02f, 1.23018391e-01f, 3.96404117e-02f, 9.14979875e-02f, -5.23584783e-02f,
  1.36247091e-02f, 1.62572600e-02f, -1.05584383e-01f, -2.79921386e-02f, 1.14233956e-01f, 1.07579187e-01f, 5.19207194e-02f, 3.75761576e-02f, 9.07728635e-03f, 6.07602447e-02f,
  1.57548517e-01f, 1.52209951e-02f, 1.02283657e-01f, 3.07975542e-02f, 4.17908356e-02f, 1.08331986e-01f, 1.04319572e-01f, 1.80234108e-02f, 7.85906985e-02f, 1.00075781e-01f,
  -1.56342074e-01f, -1.75663650e-01f, 1.72022223e-01f, 1.25395991e-02f, 2.23050267e-03f, -6.62942976e-02f, 5.19014597e-02f, 4.47114632e-02f, 4.29008119e-02f, -3.04711536e-02f,
  -7.74032772e-02f, -7.52650350e-02f, -2.15657260e-02f, -1.29106760e-01f, -6.34366125e-02f, -9.52269137e-02f, -5.05448468e-02f, 4.75971065e-02f, -8.34273696e-02f, -9.09307003e-02f,
  -6.75042346e-02f, -1.53436780e-01f, -2.79217958e-01f, -3.20080280e-01f, -1.75428867e-01f, -1.79296955e-02f, -1.46669656e-01f, -1.18956923e-01f, -3.42144787e-01f, -2.26780936e-01f,
  -4.08021867e-01f, 1.19327798e-01f, -5.90842925e-02f, -1.81328863e-01f, -2.03413721e-02f, -1.02202214e-01f, 2.12408304e-01f, 2.31322870e-02f, 3.56787294e-02f, -7.02688191e-03f,
  1.48013264e-01f, 2.52567798e-01f, 1.14787027e-01f, 2.39484087e-01f, 1.72467977e-01f, 1.28023803e-01f, 3.27077881e-02f, 3.81009793e-03f, -1.31408144e-02f, 1.02601603e-01f,
  1.96752295e-01f, 7.46902227e-02f, -1.23523422e-01f, -6.90809637e-02f, 1.07747957e-01f, 7.00660869e-02f, 5.33719920e-02f, 5.91871180e-02f, 4.16498706e-02f, 8.98120552e-02f,
  3.85772139e-01f, -2.61493057e-01f, 8.66629481e-02f, -9.89411101e-02f, -4.77813855e-02f, -7.79242739e-02f, -5.83053455e-02f, -9.56226438e-02f, 3.28704379e-02f, 1.64669324e-02f,
  -9.44160018e-03f, -4.90114652e-02f, 4.91081458e-03f, -7.28354231e-02f, -1.30817130e-01f, 5.41037470e-02f, 6.34409208e-03f, -9.78607610e-02f, 6.79983804e-03f, 5.03485017e-02f,
  7.07095712e-02f, -1.25771239e-01f, -1.32464513e-01f, 3.26726548e-02f, -4.98494878e-02f, -5.89473173e-02f, -6.27116486e-02f, -1.89640850e-01f, -5.15115410e-02f, 1.37342587e-02f,
  1.30628869e-01f, 1.23893097e-01f, -4.83756661e-02f, 5.06140664e-02f, -8.11123475e-02f, 4.59521897e-02f, 2.58336812e-02f, 1.78185571e-02f, 4.32511978e-02f, -1.42029166e-01f,
  2.86210272e-02f, -7.61533827e-02f, 2.68995315e-02f, 7.41550922e-02f, -1.03060389e-02f, 9.51111410e-03f, -8.83519128e-02f, 1.47945747e-01f, -1.50848806e-01f, -4.52876762e-02f,
  -1.84096202e-01f, 5.71344001e-03f, -1.44499972e-01f, 6.53000399e-02f, 2.44898945e-02f, -5.23417890e-02f, -8.44610855e-02f, 2.94594485e-02f, -5.58321700e-02f, -5.15992902e-02f,
  4.88288820e-01f, -2.71013796e-01f, 1.13333061e-01f, 5.88766597e-02f, -5.88459633e-02f, -4.93842922e-02f, -1.21901622e-02f, 1.08336665e-01f, -5.18438965e-02f, -2.89438548e-03f,
  -7.66067654e-02f, -6.44145235e-02f, 4.21025492e-02f, 1.89915746e-02f, 6.35809591e-03f, 1.67208817e-02f, 7.95478970e-02f, 4.27322835e-02f, 9.74970832e-02f, 3.62320840e-02f,
  -2.04983894e-02f, 1.15253240e-01f, 4.43996489e-02f, 1.43967167e-01f, 2.15863530e-02f, 2.64387745e-02f, 1.69866532e-01f, 2.05331054e-02f, 1.53204584e-02f, 6.28010333e-02f,
  9.50044617e-02f, -7.06444323e-01f, 4.26684588e-01f, -1.00009225e-01f, -1.67820975e-01f, -8.34256336e-02f, -5.73839068e-01f, -2.17159078e-01f, -7.61020929e-02f, -5.50874352e-01f,
  -3.18607986e-01f, 7.51868337e-02f, 1.96845651e-01f, -5.81980264e-03f, -7.03506693e-02f, -5.65171659e-01f, -1.82900101e-01f, 3.33377063e-01f, 3.75058651e-01f, -1.49663463e-01f,
  -4.74762082e-01f, -1.06137305e-01f, 1.92300782e-01f, 7.50233233e-02f, -1.36738122e-01f, 1.84406132e-01f, -2.52675172e-02f, 2.05553845e-02f, -1.99339941e-01f, -3.09379697e-01f,
  4.93163103e-03f, -5.63821420e-02f, 1.70173034e-01f, -6.72561824e-02f, -1.68388162e-03f, 3.16277742e-02f, -8.21753312e-03f, 1.33542523e-01f, -1.28030762e-01f, -4.93345689e-03f,
  -5.19318245e-02f, -7.46181086e-02f, 1.71077967e-01f, 1.87856238e-02f, 1.02438768e-02f, 7.66229182e-02f, 2.74391137e-02f, 1.30018771e-01f, 5.13101779e-02f, -1.95230439e-01f,
  -3.60947639e-01f, -1.23036370e-01f, 2.07038596e-01f, 4.42730077e-02f, 1.78453267e-01f, 2.84276724e-01f, 9.38528124e-03f, 9.19314921e-02f, 3.07420731e-01f, -2.06027016e-01f,
  -2.80520506e-02f, 1.74029812e-01f, 7.80732408e-02f, 4.04526703e-02f, 1.59990601e-02f, -8.38808566e-02f, 1.35567889e-01f, -5.84465377e-02f, 3.70040350e-02f, -6.18937053e-02f,
  1.17922887e-01f, -8.36268514e-02f, -3.34744304e-02f, -1.02385595e-01f, -5.85585786e-03f, 5.99683709e-02f, -7.39865974e-02f, -6.69262558e-02f, -3.65603827e-02f, 4.03035767e-02f,
  9.94377420e-04f, 5.40225916e-02f, -3.35591361e-02f, 1.05470836e-01f, -5.09068295e-02f, 7.34316036e-02f, 5.63199352e-03f, 7.37833753e-02f, 1.36371832e-02f, -4.19657454e-02f,
  1.55387789e-01f, 2.18841001e-01f, -2.04470187e-01f, -7.93970394e-05f, -5.88583387e-02f, -8.44210535e-02f, -8.11992139e-02f, 7.76920188e-03f, 8.75863135e-02f, -8.05985853e-02f,
  2.07159314e-02f, -7.24884942e-02f, 1.09723218e-01f, -3.90741676e-02f, -3.71899083e-02f, 4.90075275e-02f, -2.01334104e-01f, 5.86803779e-02f, -9.78556741e-03f, -1.56646535e-01f,
  -1.46851018e-01f, -4.31352220e-02f, -1.81381050e-02f, 1.84388272e-02f, -8.21897388e-02f, 1.19387887e-01f, 4.93455455e-02f, 3.61175053e-02f, 1.99992329e-01f, -3.53381932e-01f,
  -4.09777641e-01f, 9.14402381e-02f, 3.29181790e-01f, -1.32162705e-01f, 1.42787561e-01f, 2.01832466e-02f, 1.14056781e-01f, -1.74932480e-01f, -1.77918568e-01f, -1.86860383e-01f,
  -8.79706517e-02f, -7.75338933e-02f, 5.60734496e-02f, 1.86214939e-01f, 6.83090836e-02f, 3.18568736e-01f, 4.11435485e-01f, 3.07815433e-01f, -1.36787137e-02f, -2.23681316e-01f,
  -3.15849148e-02f, -4.51674908e-02f, -8.67136493e-02f, 1.90616995e-02f, 3.37661915e-02f, -1.63426653e-01f, 1.82793289e-01f, 1.73750386e-01f, 1.72086611e-01f, 3.53767097e-01f,
  -1.97201788e-01f, -7.51453415e-02f, -4.53496687e-02f, 2.01823153e-02f, 2.10149691e-01f, 4.18875217e-02f, -1.01517692e-01f, 2.18843237e-01f, 1.39785677e-01f, -1.11787923e-01f,
  -2.84886509e-02f, 9.30559039e-02f, -8.36050287e-02f, 1.85209103e-02f, -5.23359962e-02f, -8.24751109e-02f, 7.86821842e-02f, 9.88706574e-02f, -8.95091817e-02f, 2.42197830e-02f,
  2.22408772e-01f, -1.62193298e-01f, -1.47651315e-01f, -6.38875887e-02f, -5.51636517e-02f, -5.56665249e-02f, -1.84678122e-01f, -1.36111617e-01f, -1.91225424e-01f, -3.68725270e-01f,
  -5.06685004e-02f, 2.60548722e-02f, 9.57628116e-02f, 9.97491926e-02f, -1.10205866e-01f, -7.27217048e-02f, 1.95310771e-01f, 9.79951173e-02f, 1.57536089e-01f, 5.09435609e-02f,
  2.07758680e-01f, -9.63836089e-02f, -2.87001878e-02f, 3.56091224e-02f, 2.28927955e-02f, -1.81156754e-01f, -4.78988811e-02f, 1.14964433e-01f, -3.56434137e-02f, 1.35561869e-01f,
  -6.25933812e-04f, 1.89880967e-01f, 9.63518173e-02f, 1.70530573e-01f, 2.05919445e-01f, 4.87154536e-02f, -3.90786640e-02f, -1.48589388e-01f, -8.10143650e-02f, -1.24901988e-01f,
  -2.97861397e-01f, 2.48789832e-01f, -3.12542498e-01f, 8.89948010e-02f, -3.59816737e-02f, 1.59501329e-01f, 1.13033712e-01f, 1.29750580e-01f, 1.00366332e-01f, -1.19729482e-01f,
  -5.90530708e-02f, 4.03558128e-02f, -6.72050342e-02f, 5.77581897e-02f, -1.78974018e-01f, -1.83361530e-01f, -1.72084142e-02f, 8.23734924e-02f, -9.85513702e-02f, -1.86789897e-03f,
  1.03932694e-01f, -4.68034863e-01f, -4.65943754e-01f, -1.45730689e-01f, -3.27566862e-01f, -4.08625662e-01f, -1.62640989e-01f, -1.12663493e-01f, -3.54227126e-01f, -4.57143873e-01f,
  -3.63681018e-01f, 1.22301325e-01f, 1.68988463e-02f, 1.65745639e-03f, -2.06378326e-02f, 3.31828631e-02f, -1.69300795e-01f, 6.12030290e-02f, 2.90418416e-01f, 9.57729816e-02f,
  1.82281062e-01f, 7.15697855e-02f, -1.94202904e-02f, -1.13294944e-01f, -3.18801045e-01f, -2.67333299e-01f, -2.43225142e-01f, -4.01233703e-01f, -3.17285329e-01f, -3.48143637e-01f,
  -1.77986056e-01f, -3.01861227e-01f, -2.42184535e-01f, -1.05935484e-01f, 1.40596703e-01f, 9.40297246e-02f, 2.10166886e-01f, -2.14526951e-02f, -1.95407551e-02f, -4.06796038e-02f,
  1.30344555e-01f, 2.24267706e-01f, -3.69864190e-03f, -9.69335437e-02f, 6.81868568e-02f, 2.61899531e-02f, -8.41232613e-02f, 1.73758417e-01f, 1.13808677e-01f, -6.74585029e-02f,
  -1.49473682e-01f, -3.08345854e-02f, 3.01401652e-02f, -7.02371001e-02f, -2.09106311e-01f, -2.33329639e-01f, -2.10922718e-01f, -2.19273686e-01f, -9.18226838e-02f, 2.94813383e-02f,
  -2.70578891e-01f, -2.65077055e-01f, -1.77389950e-01f, 1.11818880e-01f, 1.02596089e-01f, -2.21078649e-01f, 1.38238743e-01f, 1.19622074e-01f, -1.76555924e-02f, 1.30233660e-01f,
  -2.12317053e-02f, -8.18742439e-02f, -5.78646511e-02f, 2.44242279e-03f, -7.44733289e-02f, 1.32181689e-01f, 4.30805311e-02f, -3.11201252e-02f, 1.00049255e-02f, 5.88454539e-03f,
  -1.77037194e-02f, 1.08303457e-01f, 1.02813713e-01f, -8.43570456e-02f, 1.68227404e-02f, -5.67304082e-02f, 4.93386537e-02f, -1.31888660e-02f, 2.17138510e-03f, 6.85300753e-02f,
  7.68836439e-02f, 9.32375118e-02f, 3.59211862e-02f, 1.44899264e-01f, 7.26324841e-02f, 2.35694163e-02f, 6.44365232e-03f, 1.42815277e-01f, -2.40013166e-03f, -1.13105282e-01f,
  2.33851954e-01f, -1.71434641e-01f, -5.14637399e-03f, -9.41617489e-02f, 1.49461150e-01f, 4.58601378e-02f, 1.25294462e-01f, 2.31521111e-02f, 1.06892370e-01f, -8.64659175e-02f,
  -8.03474188e-02f, -5.19181415e-02f, -2.09951717e-02f, 9.34164077e-02f, -1.66439220e-01f, -1.08482547e-01f, -2.50073731e-01f, -1.17873326e-01f, -3.65161672e-02f, 2.53581218e-02f,
  -2.38907978e-01f, -3.59495372e-01f, -2.85812736e-01f, 1.12085372e-01f, 6.99473396e-02f, -1.64407939e-01f, 4.40835170e-02f, 1.57164529e-01f, -2.13624407e-02f, 4.96883206e-02f,
  -2.36251459e-01f, 3.83733064e-01f, 2.43039280e-01f, -4.05863434e-01f, -2.78138012e-01f, 4.10039127e-02f, 2.75720388e-01f, 1.56037793e-01f, -2.90700346e-01f, 6.08010851e-02f,
  -3.71677168e-02f, -3.31396967e-01f, -5.69575615e-02f, -2.72914059e-02f, 2.52191663e-01f, 4.48250949e-01f, 2.64687657e-01f, 1.02187291e-01f, -1.50409102e-01f, -1.96701273e-01f,
  -9.51742455e-02f, -8.35940763e-02f, -2.37182692e-01f, -2.39919554e-02f, 7.34103769e-02f, -1.46484435e-01f, 9.95346606e-02f, -6.77679181e-02f, 3.02096874e-01f, 2.69086987e-01f,
  1.91274304e-02f, 2.25245208e-01f, -4.00724262e-02f, -1.86747551e-01f, -2.03031600e-01f, -2.91007906e-02f, 1.12502351e-01f, 1.12262763e-01f, 1.96833313e-02f, 1.99486941e-01f,
  -2.10868478e-01f, -6.88655749e-02f, -1.60971478e-01f, -1.06362641e-01f, -2.81008929e-01f, 3.14194299e-02f, -1.16324097e-01f, 2.43693843e-01f, -5.79021722e-02f, 8.17562342e-02f,
  -5.85806742e-02f, -2.37713844e-01f, -7.84700140e-02f, 8.76008570e-02f, 1.90133274e-01f, -2.81942874e-01f, 1.27277046e-01f, 1.06022909e-01f, 6.00207485e-02f, 1.71946794e-01f,
  -1.12214081e-01f, -4.00289223e-02f, -1.03817899e-02f, 1.42116934e-01f, -3.04667000e-03f, -6.13139709e-03f, -1.43941035e-02f, -7.09520653e-02f, -6.70493469e-02f, -8.16793367e-03f,
  4.21999991e-02f, -8.09569135e-02f, 2.16046534e-02f, 5.34783900e-02f, -1.48602799e-02f, -2.26261932e-02f, 3.34988668e-04f, 9.73846465e-02f, 1.27985671e-01f, 4.98947501e-03f,
  -3.10423840e-02f, -2.82623209e-02f, 1.28627000e-02f, 1.04671493e-01f, 1.77741483e-01f, 6.46313503e-02f, -8.70082602e-02f, -6.99978471e-02f, -1.73351124e-01f, 8.12041834e-02f,
  -2.95907646e-01f, 1.50438212e-02f, 1.15157478e-01f, 9.23156664e-02f, -1.38412490e-01f, -1.07287325e-01f, -8.10128916e-03f, 3.67640890e-02f, -1.20447263e-01f, 9.37524776e-04f,
  4.71209399e-02f, -1.52881714e-02f, -9.38722342e-02f, -1.38090968e-01f, -2.18039989e-01f, -1.27858594e-01f, -2.60404110e-01f, -2.50779241e-01f, -2.35515535e-01f, -2.29058892e-01f,
  -1.93954483e-01f, -2.65773296e-01f, -3.96161675e-01f, -2.66330689e-01f, -3.33063155e-01f, -4.34093386e-01f, -2.32291698e-01f, -1.22318290e-01f, -1.91583142e-01f, -1.07311644e-01f,
  -4.85562325e-01f, -1.35630816e-01f, 4.69463244e-02f, -3.93692613e-01f, -7.03078285e-02f, -2.58324742e-02f, 2.42420018e-01f, -1.42784193e-01f, -3.69419277e-01f, -1.93996429e-02f,
  -1.11033536e-01f, -3.88991892e-01f, -3.32491696e-01f, -1.31803378e-01f, -5.19676059e-02f, 3.23247612e-01f, 1.65294409e-01f, -1.73407495e-01f, -1.62867010e-01f, -1.88320782e-02f,
  -1.36932045e-01f, -1.92325056e-01f, -3.06663722e-01f, -2.00273991e-01f, -1.14832714e-01f, -1.72557399e-01f, -8.59729871e-02f, -2.18729988e-01f, -8.49292800e-02f, -1.69754386e-01f,
  2.49609709e-01f, -4.17854071e-01f, -2.87558716e-02f, -2.16134578e-01f, -1.62748724e-01f, -7.73243457e-02f, -8.12723786e-02f, -1.34445623e-01f, -1.53401494e-01f, -2.55442802e-02f,
  -1.48434326e-01f, -2.37563066e-02f, -3.65121588e-02f, -4.17481884e-02f, -1.02831930e-01f, -6.87533244e-02f, -1.05333991e-01f, -7.32125416e-02f, -8.52118526e-03f, -6.42198101e-02f,
  1.59435719e-02f, -5.69930151e-02f, 1.68389436e-02f, -4.27872315e-03f, -3.47395428e-03f, -7.61746913e-02f, 7.88741931e-02f, -7.80948345e-03f, 5.25842281e-03f, 1.00002438e-01f,
  2.39528373e-01f, 5.53001538e-02f, -1.17446989e-01f, 3.58952060e-02f, 6.22422472e-02f, -7.23788049e-03f, -8.48954767e-02f, 7.62566831e-03f, -1.45286277e-01f, 7.06466883e-02f,
  -3.85851748e-02f, -9.04150903e-02f, -3.71872797e-03f, -2.20856983e-02f, -8.43564719e-02f, -1.32239133e-01f, 2.23734621e-02f, 1.19288331e-02f, -5.80585338e-02f, -1.48111865e-01f,
  -1.55756027e-01f, -1.06279319e-02f, -5.72976768e-02f, 4.30151336e-02f, -9.13537219e-02f, -7.23191723e-02f, -5.05252704e-02f, -1.03116892e-01f, -4.54053245e-02f, -1.59161806e-01f,
  1.24966331e-01f, -1.70710161e-01f, 8.57997090e-02f, -1.39453813e-01f, -8.48839656e-02f, -1.21844508e-01f, -8.91960710e-02f, -6.69038370e-02f, -9.83920097e-02f, 5.41328341e-02f,
  -1.49908692e-01f, 5.46376631e-02f, 7.28198290e-02f, 7.98019245e-02f, 1.20053366e-01f, -2.41836682e-02f, 1.10689975e-01f, 1.13726132e-01f, 1.19231775e-01f, 1.22752979e-01f,
  6.24628179e-02f, 1.37826785e-01f, 1.77379176e-01f, 2.33484611e-01f, 1.04633465e-01f, 1.28567338e-01f, 1.49840817e-01f, 1.73330352e-01f, 2.69796640e-01f, 4.33186501e-01f,
  -1.48690090e-01f, -1.36218503e-01f, -4.82336223e-01f, -3.14353794e-01f, -4.84131008e-01f, -3.69506866e-01f, 3.01346593e-02f, -1.70472041e-01f, -3.44866723e-01f, -1.33469939e-01f,
  1.95358992e-02f, 9.83127654e-02f, 5.98455546e-03f, -1.34088770e-02f, 1.96608290e-01f, -1.75269350e-01f, -2.58896619e-01f, -1.93527445e-01f, -6.79037794e-02f, -1.87905245e-02f,
  1.35678472e-02f, -1.00987121e-01f, -6.85693398e-02f, -6.61453232e-02f, -8.71568620e-02f, 2.65698880e-02f, -2.16862082e-01f, -1.85153216e-01f, -2.66697824e-01f, -2.58550435e-01f,
  1.61213830e-01f, -2.86826700e-01f, -3.84081453e-02f, -9.33140516e-02f, -1.19149424e-02f, -7.88226351e-02f, 1.39580026e-01f, -4.67256680e-02f, 7.40283504e-02f, -8.21656585e-02f,
  -1.09768569e-01f, -2.20869668e-02f, 6.52363291e-03f, -5.43168187e-03f, -5.69040440e-02f, 2.22031213e-03f, -1.51183739e-01f, -1.76517889e-01f, -2.18337938e-01f, -5.20019308e-02f,
  -5.24764918e-02f, -2.00606614e-01f, -3.09668351e-02f, -8.37006122e-02f, -7.54069462e-02f, -1.42208830e-01f, -9.51347966e-03f, -1.37435898e-01f, -2.07564712e-01f, 1.07840538e-01f,
  3.14253755e-02f, 3.43342572e-02f, 4.34949063e-04f, 1.07330561e-01f, -8.45572799e-02f, -2.11984795e-02f, -4.73701134e-02f, 8.17417577e-02f, 1.34675846e-01f, 7.53474981e-02f,
  -1.14954105e-02f, -9.67154000e-03f, 4.38320749e-02f, -3.98693010e-02f, 8.27902481e-02f, -8.30005035e-02f, 5.33597060e-02f, 1.19596794e-01f, 7.28685111e-02f, -4.56503890e-02f,
  -7.23922327e-02f, -5.19827828e-02f, 2.05599517e-02f, 5.24508990e-02f, -1.60603344e-01f, 1.79788526e-02f, -7.13068992e-02f, 1.26174628e-03f, 3.64435725e-02f, -7.05388337e-02f,
  3.80362302e-01f, -1.26420170e-01f, 2.02005923e-01f, 1.26832962e-01f, 1.05564306e-02f, -4.18145917e-02f, -4.91763838e-03f, -8.01543966e-02f, -8.61625522e-02f, -2.47554760e-03f,
  -1.15962051e-01f, 1.33655101e-01f, 1.43565714e-01f, 5.52021414e-02f, 1.15172684e-01f, -1.12677747e-02f, 1.31201610e-01f, -1.16332655e-03f, -1.17045879e-01f, -4.37017679e-02f,
  -4.28386293e-02f, 8.53359178e-02f, 3.01749974e-01f, 2.39242345e-01f, 4.08253353e-03f, 1.31808892e-01f, 1.33119956e-01f, 3.02408393e-02f, 1.96818143e-01f, 3.42182904e-01f,
  -6.11918747e-01f, -2.49681816e-01f, -8.69982913e-02f, -7.73291111e-01f, -2.16824207e-02f, 2.33043417e-01f, 1.71417028e-01f, -5.80574498e-02f, -3.05418611e-01f, -2.34582961e-01f,
  -5.16552664e-02f, -1.04446866e-01f, -1.30847827e-01f, -4.48035151e-02f, 1.28857389e-01f, -3.01499307e-01f, -3.44889462e-01f, 2.07029134e-02f, 3.62203658e-01f, 4.33342427e-01f,
  1.93342119e-01f, -1.60625100e-01f, -8.17761645e-02f, -1.73192024e-02f, -3.80760282e-01f, -1.21767804e-01f, -3.15996319e-01f, -1.09002538e-01f, -4.41454304e-03f, -4.57511693e-01f,
  -2.83234984e-01f, -2.50070632e-01f, 2.32701063e-01f, 7.98730627e-02f, 3.80511247e-02f, -1.62963316e-01f, -1.72570292e-02f, -1.04707703e-01f, 2.72619855e-02f, -1.29352137e-01f,
  -1.04360707e-01f, 9.81954858e-02f, -1.57351643e-01f, 6.77292747e-03f, -4.15814808e-04f, 1.94100291e-02f, 3.63729596e-02f, -3.23083773e-02f, -2.53091212e-02f, 1.52777269e-01f,
  1.07445225e-01f, -6.26060879e-03f, -1.94553092e-01f, 1.89580068e-01f, 1.52760088e-01f, -1.35662844e-02f, 1.23279281e-01f, 1.63363114e-01f, 7.69208223e-02f, -3.31812888e-01f,
  1.84125211e-02f, -8.83330330e-02f, 9.09877270e-02f, -9.25721228e-02f, 1.80727281e-02f, -5.13958856e-02f, -1.45286143e-01f, -8.90352726e-02f, 2.00077772e-01f, -2.10091297e-04f,
  7.35744014e-02f, 3.72790024e-02f, -2.99812537e-02f, -1.22555830e-01f, -9.03865471e-02f, -6.38469383e-02f, 2.32405216e-02f, 7.85840526e-02f, 1.18381428e-02f, -5.56945726e-02f,
  3.71355377e-03f, -1.37006799e-02f, -1.67071506e-01f, 1.64852235e-02f, 3.57781872e-02f, 2.97702271e-02f, -1.94848999e-02f, 1.93923697e-01f, -6.26420081e-02f, -1.48131708e-02f,
  -3.70571971e-01f, 4.20405656e-01f, -3.35351646e-01f, -3.16159101e-03f, -1.43307477e-01f, 9.01002288e-02f, -1.29498228e-01f, 1.98843721e-02f, -8.69212523e-02f, -7.80431554e-02f,
  1.92112371e-01f, -1.73355207e-01f, -1.87267527e-01f, 1.25113383e-01f, 7.25521147e-02f, -2.33298000e-02f, -9.23080444e-02f, -2.61851043e-01f, 1.59061313e-01f, 8.54931213e-03f,
  -3.01206615e-02f, 8.19456652e-02f, -3.12061936e-01f, -2.05258861e-01f, -7.11538270e-02f, -1.03613667e-01f, -7.11313859e-02f, -1.21250778e-01f, 1.30151669e-02f, -4.46887940e-01f,
  2.68695325e-01f, 4.50570643e-01f, 5.77669926e-02f, 1.23644210e-01f, -2.31429234e-01f, -4.30170409e-02f, 2.16536134e-01f, 1.64909065e-01f, 1.74678445e-01f, 1.05061263e-01f,
  1.34624084e-02f, 1.72386076e-02f, 1.46705374e-01f, 1.54351264e-01f, 2.45529205e-01f, 1.94384605e-01f, 2.08357111e-01f, 1.73439667e-01f, 8.36755782e-02f, -2.32930854e-02f,
  4.97064851e-02f, -1.98643357e-02f, -3.17050703e-02f, 1.20617203e-01f, 1.50542364e-01f, 2.17351504e-02f, 1.31106786e-02f, -8.50395411e-02f, 1.24311022e-01f, 1.81208208e-01f,
  -2.12066323e-01f, -8.50464702e-02f, -6.72400296e-02f, -1.64851397e-02f, -1.35609061e-01f, 1.41067624e-01f, -1.19887963e-01f, 4.88355942e-02f, 7.03821778e-02f, 3.01921628e-02f,
  -3.33588906e-02f, -6.00198209e-02f, -1.22394614e-01f, -1.26653435e-02f, -1.06054753e-01f, -8.77479762e-02f, -4.55390476e-02f, 1.32306516e-01f, 1.36215258e-02f, -8.65843892e-03f,
  -6.78472817e-02f, -1.69144928e-01f, -1.60065830e-01f, -9.98320058e-03f, 4.48578037e-02f, -9.39410273e-03f, 5.27472817e-04f, -5.16947471e-02f, 8.24898016e-03f, -4.20755222e-02f,
  -3.18938307e-02f, 6.58241883e-02f, -1.14748426e-01f, -1.35757789e-01f, -5.20544872e-02f, -1.30690560e-01f, -8.38277787e-02f, -2.91702189e-02f, -7.43056124e-04f, -8.81596580e-02f,
  -1.32451743e-01f, -1.98003218e-01f, -5.13366051e-02f, -1.15352161e-01f, -3.51885967e-02f, -5.69431223e-02f, -5.24509139e-02f, -1.69445708e-01f, -1.65739909e-01f, -1.05198510e-01f,
  -1.30863219e-01f, 9.71026644e-02f, -3.95396575e-02f, -2.95825694e-02f, -1.08868919e-01f, -1.76221505e-01f, -1.41722143e-01f, -6.72366843e-02f, -8.30147602e-03f, 2.66754031e-02f,
  -2.50002027e-01f, -4.04463887e-01f, 1.40567003e-02f, 2.58912891e-01f, 1.12527445e-01f, 6.38661087e-02f, 6.13233559e-02f, -6.28221110e-02f, -1.62082966e-02f, 3.75835523e-02f,
  6.25630394e-02f, 4.07273211e-02f, -5.19112386e-02f, -7.45493965e-03f, -1.73554197e-01f, -2.79355925e-02f, 5.56929447e-02f, 1.78185627e-01f, 1.87665209e-01f, 5.56426421e-02f,
  1.31833076e-01f, -1.06348164e-01f, -5.89816310e-02f, 5.33042848e-02f, 9.65386555e-02f, -1.18857384e-01f, -1.58749565e-01f, -1.03764897e-02f, -4.53331210e-02f, -9.01942253e-02f,
  6.15921259e-01f, -1.93333272e-02f, 4.02147770e-01f, 1.67723149e-01f, -3.05007137e-02f, 1.29870653e-01f, 4.70612422e-02f, 1.38793394e-01f, 2.09297895e-01f, 5.84155992e-02f,
  -2.36135826e-01f, -2.52857625e-01f, -1.47629902e-01f, -6.40224963e-02f, 9.70571954e-03f, 1.80399179e-01f, 2.19994083e-01f, 2.55591720e-01f, 3.08630526e-01f, 1.73002243e-01f,
  -1.12391569e-01f, 1.07314989e-01f, 3.18227053e-01f, 1.73348546e-01f, 2.54202392e-02f, -3.18591967e-02f, -1.66780315e-02f, 2.68342383e-02f, -8.69159587e-03f, 1.67094748e-02f,
  -2.08881617e-01f, 2.96867136e-02f, -1.05200045e-01f, -1.15506925e-01f, -1.64854795e-01f, 9.87188891e-02f, 1.12396898e-02f, 8.76243599e-03f, -4.81237546e-02f, 5.03451638e-02f,
  -1.79146156e-01f, -3.30657959e-02f, -1.02556132e-01f, -5.86305596e-02f, 1.06111966e-01f, 7.80569762e-02f, 1.04320552e-02f, 7.96876475e-03f, 1.34526463e-02f, -9.28621143e-02f,
  -2.40579590e-01f, -4.96830977e-02f, 5.19326590e-02f, 7.45705515e-03f, -2.33344119e-02f, -1.36058941e-01f, 5.66084753e-04f, -5.70375398e-02f, 3.58794294e-02f, 6.64597526e-02f,
  -1.54118046e-01f, 7.65575767e-02f, -8.66076052e-02f, -5.36264144e-02f, 7.76316151e-02f, 2.35525407e-02f, -4.78725955e-02f, -8.27417299e-02f, 5.71471115e-04f, -1.06420740e-02f,
  3.69184592e-04f, -5.43141998e-02f, 3.81633975e-02f, -7.57256970e-02f, 2.57459693e-02f, -4.91175465e-02f, 1.59568933e-03f, -3.85120474e-02f, -1.81237027e-01f, -5.09426631e-02f,
  -4.89422716e-02f, 4.40491810e-02f, -1.38193639e-02f, -9.34692100e-02f, -3.24832536e-02f, 8.61866549e-02f, 8.01575482e-02f, -1.23092048e-01f, 3.49715166e-02f, -1.24818422e-02f,
  -2.33836353e-01f, -2.11310491e-01f, -3.54497065e-03f, -3.30087095e-02f, 4.79131490e-02f, -1.84620619e-02f, -1.53055698e-01f, -4.93630320e-02f, -4.94673438e-02f, -9.69569162e-02f,
  -8.97474866e-03f, -1.52894026e-02f, -2.24418826e-02f, -1.67489331e-02f, 2.14599329e-03f, 5.64968958e-02f, -9.07714739e-02f, 4.99783084e-02f, -7.88554922e-03f, -2.93772127e-02f,
  -1.07506938e-01f, 1.41544819e-01f, 8.40000510e-02f, 5.98762631e-02f, -2.56195571e-02f, 1.04602329e-01f, 3.37379128e-02f, 8.64437744e-02f, 9.36357453e-02f, 2.28213683e-01f,
  -2.84609646e-01f, 1.28340617e-01f, -3.31713825e-01f, 2.65200138e-02f, 1.71684712e-01f, 2.23882928e-01f, 1.87308669e-01f, 2.31009573e-01f, 8.64564329e-02f, 1.72318324e-01f,
  8.66616890e-02f, 1.13188721e-01f, 1.81862071e-01f, 9.91058499e-02f, 5.58046028e-02f, 2.33829767e-01f, 1.53876901e-01f, -8.14655423e-03f, -1.36434864e-02f, 8.91079754e-02f,
  1.56472206e-01f, 5.50793260e-02f, -9.37916338e-02f, -3.04768384e-02f, 1.80027261e-02f, 1.51652247e-01f, 9.27478895e-02f, -8.22787434e-02f, -1.03551801e-02f, -1.13127626e-01f,
  -1.43875271e-01f, -3.30906451e-01f, 1.54345945e-01f, -2.55234353e-02f, -2.13912904e-01f, -3.60212438e-02f, -6.85247108e-02f, -7.04989135e-02f, -3.16094905e-02f, 9.17910337e-02f,
  -1.15364203e-02f, -1.60141230e-01f, -7.20048025e-02f, -3.50452065e-02f, -1.21407270e-01f, -1.27890468e-01f, -1.85475066e-01f, 4.45174463e-02f, 5.72449192e-02f, -2.35212920e-03f,
  6.22396134e-02f, -9.41425860e-02f, 4.89606373e-02f, 7.35392123e-02f, 5.20708859e-02f, 3.35828252e-02f, -5.22388667e-02f, -3.23607150e-04f, -1.32513985e-01f, 3.82084101e-02f,
  1.83147099e-02f, 6.73485994e-02f, -4.05848548e-02f, 3.26624699e-02f, -3.34079401e-03f, -1.89733654e-02f, 4.47060317e-02f, 1.91757023e-01f, 1.06215440e-01f, 1.19921947e-02f,
  7.45311305e-02f, 5.69824362e-04f, -6.60822392e-02f, 1.18154265e-01f, -5.98410591e-02f, -5.35606220e-02f, -3.80803607e-02f, -2.44592428e-02f, -1.77975297e-02f, 7.76972505e-04f,
  1.77340992e-02f, -4.22790013e-02f, -1.37218863e-01f, -1.45812050e-01f, -6.57639802e-02f, 1.92896258e-02f, 3.21218185e-02f, -8.31099898e-02f, -6.80512637e-02f, 8.64451751e-02f,
  3.29794556e-01f, -1.32908747e-01f, 1.21576868e-01f, -3.90375555e-02f, -1.53829738e-01f, -1.82311207e-01f, -6.65727630e-02f, 5.57316793e-03f, -4.69233170e-02f, 1.12349309e-01f,
  -6.99864700e-02f, -7.87582695e-02f, -8.81536603e-02f, -7.03125298e-02f, -6.35182709e-02f, -1.67820901e-02f, 1.61520857e-02f, 3.86546319e-03f, 1.39016047e-01f, 2.02771998e-03f,
  7.69896209e-02f, 1.06651090e-01f, 1.76505581e-01f, 1.96984440e-01f, 2.08123907e-01f, 3.61427628e-02f, 1.46500856e-01f, 7.12244511e-02f, 4.87509072e-02f, 2.72894919e-01f,
  -1.40788689e-01f, 5.55023318e-03f, 2.32257620e-01f, 1.56291444e-02f, -2.78601974e-01f, -4.88336027e-01f, -5.54367125e-01f, -4.73164260e-01f, -1.14927851e-01f, -2.54892129e-02f,
  -1.62732765e-01f, -6.33660331e-02f, 1.40546840e-02f, -1.60773993e-02f, -3.18318903e-02f, -1.39322160e-02f, 1.79913923e-01f, 9.07817855e-02f, -5.22592999e-02f, -1.76249519e-01f,
  1.37776583e-01f, 1.79947495e-01f, 1.84866428e-01f, 1.04516178e-01f, 2.69297600e-01f, 2.26385772e-01f, 1.68404102e-01f, 2.86149979e-01f, 2.12473750e-01f, 4.04740751e-01f,
  4.92169023e-01f, -7.86976218e-02f, -1.16836436e-01f, 5.84341073e-03f, 1.29308989e-02f, -8.89854655e-02f, -1.07384875e-01f, 6.10984489e-02f, -1.61324933e-01f, -2.25719344e-02f,
  1.94594301e-02f, 7.65632838e-02f, 2.76700556e-02f, 8.90595559e-03f, -1.31902501e-01f, -1.40499309e-01f, 4.82846051e-02f, 9.15642083e-02f, 7.73778856e-02f, -3.28830667e-02f,
  2.69350111e-02f, -9.38444212e-02f, -1.53022081e-01f, -2.42747277e-01f, -9.55768824e-02f, 5.99126667e-02f, -8.43628868e-02f, 2.47230870e-03f, 2.53896900e-02f, 5.00227064e-02f,
  -1.95746392e-01f, -4.40377146e-02f, -6.21428415e-02f, -1.21524662e-01f, -1.83705926e-01f, -1.89916432e-01f, -8.38521346e-02f, -1.69214919e-01f, -1.56186700e-01f, -4.56062816e-02f,
  -1.50045171e-01f, -1.09790124e-01f, -5.65624274e-02f, 2.20830087e-02f, -4.01512310e-02f, 9.71255451e-03f, -9.71877798e-02f, -5.08397333e-02f, 1.52696110e-02f, -9.57783237e-02f,
  -6.91532940e-02f, -3.38884373e-03f, 3.72791551e-02f, 2.45392658e-02f, -6.01324625e-03f, -2.66849231e-02f, -6.41926751e-02f, -5.43788411e-02f, 3.92780751e-02f, -1.77879706e-02f,
  1.96870089e-01f, -1.31853208e-01f, 1.99137866e-01f, 2.86482461e-02f, 4.27005477e-02f, 1.57962844e-01f, 1.04311354e-01f, -3.78497839e-02f, -5.62806148e-03f, -3.29860672e-02f,
  -2.29920587e-03f, 1.73614502e-01f, 1.64151043e-01f, 1.56186149e-01f, -7.93212056e-02f, -6.75173551e-02f, -8.49813372e-02f, -7.89345428e-02f, 2.68177465e-02f, -1.23212142e-02f,
  -5.84595054e-02f, -1.31394416e-01f, -1.81492388e-01f, -1.31057888e-01f, -1.12364898e-02f, -1.32702693e-01f, 6.64024204e-02f, 8.21873993e-02f, -2.41868868e-02f, -1.80074304e-01f,
  -4.50265080e-01f, 5.02572209e-03f, -1.47166565e-01f, -1.67297944e-02f, 2.54177302e-01f, 2.82212257e-01f, 2.45182142e-01f, 1.25028446e-01f, 1.55924699e-05f, 6.22373559e-02f,
  7.23905340e-02f, 1.38372511e-01f, 2.51875520e-01f, 2.24971369e-01f, 1.77415907e-01f, 2.48101875e-01f, 2.52158821e-01f, 4.83691767e-02f, 5.13838930e-03f, -4.05306406e-02f,
  1.28579631e-01f, -1.95400462e-01f, -3.98292035e-01f, -1.14560865e-01f, 8.72757882e-02f, 1.17673114e-01f, -6.81737587e-02f, 7.69231841e-02f, 7.81018212e-02f, 2.01400772e-01f,
  1.82995126e-02f, -2.80534387e-01f, 1.00017332e-01f, -1.48091894e-02f, -9.99489054e-02f, -2.53951937e-01f, -7.18176141e-02f, -3.13057512e-01f, -1.94507837e-01f, -2.18159690e-01f,
  -1.00846477e-01f, -5.26757501e-02f, 7.15988502e-02f, 4.15078960e-02f, -1.11405946e-01f, -6.31640926e-02f, -1.51043266e-01f, -5.75234927e-02f, -2.24116355e-01f, -1.44204259e-01f,
  2.06572667e-01f, -1.75270900e-01f, -1.74524859e-01f, 5.74358739e-02f, -1.02028856e-02f, -9.10407677e-02f, -1.17440604e-01f, -1.58908039e-01f, -3.18038732e-01f, -2.65455186e-01f,
  -3.14413235e-02f, -1.72625020e-01f, -2.98499838e-02f, -2.55170539e-02f, 7.11969510e-02f, 2.20281929e-02f, 1.42348617e-01f, 1.44465297e-01f, -1.08043611e-01f, 5.07437512e-02f,
  8.33061114e-02f, 3.29601876e-02f, -5.73046952e-02f, -6.79605380e-02f, 1.71798334e-01f, -5.38791604e-02f, 4.28845435e-02f, -1.04078203e-01f, 6.91962689e-02f, 2.29708757e-02f,
  9.67709199e-02f, -5.70621304e-02f, -3.81524451e-02f, 1.26748815e-01f, 1.30584553e-01f, 1.41938224e-01f, -5.85089810e-02f, 4.82792147e-02f, 2.08016671e-02f, -7.44104311e-02f,
  8.26790780e-02f, -1.41459718e-01f, 4.03166227e-02f, -6.58144355e-02f, 5.30684367e-02f, 3.54433507e-02f, -1.25762537e-01f, -1.62852436e-01f, 1.49840713e-02f, -3.07383239e-02f,
  1.21398903e-02f, 5.34505993e-02f, 7.46504450e-03f, 5.08983880e-02f, -3.50321345e-02f, 4.13114019e-02f, 1.48988560e-01f, 2.17821062e-01f, -7.52501339e-02f, -1.39481619e-01f,
  -4.74485382e-02f, -1.06377475e-01f, 1.53150886e-01f, 1.12736493e-01f, -2.17789318e-02f, -5.58851007e-03f, 2.82124579e-02f, 9.24750715e-02f, -1.01273477e-01f, -9.98918116e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.42951384e-01f, 1.98454067e-01f, 3.80588025e-01f, 1.39270723e-01f, 5.30977726e-01f, 3.48534197e-01f, 2.25853339e-01f, 3.20998698e-01f, 4.37048674e-01f, 4.96522844e-01f,
  4.04587358e-01f, 3.48530918e-01f, 2.80399501e-01f, 4.81385589e-01f, 4.61608380e-01f, 3.64053398e-01f, 8.54296014e-02f, 3.79933715e-01f, -2.92649027e-02f, 2.41659939e-01f,
  -1.28722051e-03f, 3.56097817e-01f, 3.41279320e-02f, 3.32081944e-01f, 4.67967063e-01f, 8.48629773e-02f, 2.57181048e-01f, 6.22235425e-02f, 5.44873953e-01f, 5.34937024e-01f,
  3.03477734e-01f, 2.73361236e-01f, 3.28853309e-01f, 3.80901784e-01f, 2.45403156e-01f, -1.25763029e-01f, 3.96123409e-01f, 1.01727813e-01f, 5.02468467e-01f, 1.82758659e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.50014907e-01f, -1.08033419e-01f, -1.47904241e-02f, -7.69313350e-02f, -8.58377367e-02f, -3.46918814e-02f, -1.78238153e-01f, -6.25843331e-02f, -1.51974365e-01f, -1.52558774e-01f,
  -6.49903491e-02f, -2.62963469e-04f, 2.72474617e-01f, -4.41574678e-02f, 3.47906917e-01f, 9.15089026e-02f, 6.22300133e-02f, -7.11239725e-02f, -5.55379353e-02f, -7.63547197e-02f,
  3.17370534e-01f, 1.85629979e-01f, 2.09029555e-01f, 1.76950648e-01f, -1.41612560e-01f, -1.08696140e-01f, 3.76929522e-01f, 1.39085818e-02f, -1.16979174e-01f, 1.01509131e-01f,
  -9.85027477e-02f, 3.29595447e-01f, -1.62622064e-01f, 2.74107270e-02f, 4.41099592e-02f, 7.42363706e-02f, 1.07160382e-01f, -1.40818939e-01f, -1.66346654e-02f, -1.20213717e-01f,
  -6.70434907e-02f, 8.95027146e-02f, 2.92001337e-01f, -1.40406042e-02f, -9.19365585e-02f, -2.03898638e-01f, -1.31640360e-01f, -3.00596774e-01f, -4.83866967e-02f, -1.21487677e-01f,
  3.50032933e-02f, -3.75914127e-02f, 3.20002794e-01f, -6.57371506e-02f, -1.29845068e-01f, 1.01369463e-01f, -3.60536456e-01f, -7.76585117e-02f, -6.87958021e-03f, 1.59689263e-01f,
  2.45824046e-02f, 9.35646147e-02f, 8.51410478e-02f, 1.21210918e-01f, 2.23398358e-01f, 7.77743608e-02f, 3.09254266e-02f, -1.38734151e-02f, -8.87662247e-02f, 8.17077681e-02f,
  -1.07421249e-01f, 7.29606450e-02f, -1.01873733e-01f, 9.24106985e-02f, -3.60939167e-02f, 1.40369087e-01f, 1.37039619e-02f, -1.11783229e-01f, 2.40110576e-01f, -1.22827841e-02f,
  -2.29063518e-02f, -3.18684466e-02f, -4.16735560e-02f, -9.03471112e-02f, -1.18833899e-01f, 7.36523420e-02f, 2.16703147e-01f, -4.89043146e-02f, -5.51188700e-02f, -4.82311770e-02f,
  2.49956533e-01f, -5.90001158e-02f, -2.36353669e-02f, 8.85157883e-02f, 3.70643772e-02f, 1.22536518e-01f, -9.25359428e-02f, -7.64455572e-02f, -1.74986139e-01f, -1.19840488e-01f,
  -1.66482091e-01f, -7.97334015e-02f, -1.87987108e-02f, 3.95438485e-02f, -1.42743826e-01f, -2.53207535e-02f, -1.44364554e-02f, -9.08939689e-02f, -1.83085620e-01f, 1.51610151e-01f,
  -6.81744665e-02f, -3.11616719e-01f, 1.62031516e-01f, -6.18344061e-02f, 2.12610066e-02f, -5.19751646e-02f, 8.08687359e-02f, -1.40104160e-01f, -8.45349655e-02f, 1.53326452e-01f,
  1.28541864e-03f, 1.68240797e-02f, -2.40354747e-01f, 2.34253574e-02f, 1.88633204e-01f, -2.36680672e-01f, 2.84872591e-01f, -3.01766217e-01f, 1.20247111e-01f, 1.01724260e-01f,
  1.82983518e-01f, -3.96259166e-02f, -6.33010492e-02f, -2.65815817e-02f, -1.62227149e-03f, 5.26170991e-02f, 4.17836979e-02f, -1.68689550e-03f, -3.56799029e-02f, 1.55533105e-01f,
  2.64110025e-02f, 1.41565865e-02f, -1.29839599e-01f, 1.21027336e-01f, -1.65491283e-01f, 2.40415186e-01f, 1.55294865e-01f, 5.81739992e-02f, -2.15456575e-01f, -1.34548083e-01f,
  1.13731824e-01f, -6.73624799e-02f, -2.72894725e-02f, 6.45292774e-02f, -1.49869859e-01f, -7.58721828e-02f, 1.15732349e-01f, 5.88474870e-02f, -6.48735045e-03f, 2.13478655e-01f,
  1.29416272e-01f, -5.33922836e-02f, -5.86150251e-02f, 1.02945276e-01f, -5.23312427e-02f, 1.16508596e-01f, 4.24562246e-02f, -1.31166011e-01f, -1.81602180e-01f, 2.00518146e-01f,
  -5.98411895e-02f, -5.02738170e-02f, 7.97054991e-02f, 6.30889237e-02f, 1.55892402e-01f, -2.44218875e-02f, 2.28509642e-02f, 1.18030414e-01f, -9.41753201e-03f, 1.46594480e-01f,
  -3.09347421e-01f, -1.96223080e-01f, -1.40243143e-01f, -1.62867680e-01f, 1.89661786e-01f, 2.65677333e-01f, -2.81162471e-01f, -1.38836682e-01f, -2.36724243e-02f, 1.81028858e-01f,
  -1.39909834e-01f, 3.83238271e-02f, -1.41124442e-01f, 3.62773500e-02f, -7.46925771e-02f, 4.55350578e-02f, -6.48825765e-02f, 2.62317806e-02f, 7.91972876e-03f, 2.05123648e-02f,
  -8.76928344e-02f, 5.99510735e-03f, 2.26914044e-02f, -2.29118820e-02f, -7.53668919e-02f, -3.37543301e-02f, 3.21864001e-02f, -1.55650705e-01f, -5.45309559e-02f, 3.93771231e-02f,
  5.48151741e-03f, 8.93336758e-02f, -1.15055166e-01f, 6.88054338e-02f, 1.62970513e-01f, -2.11044773e-01f, -4.94373254e-02f, 8.25686455e-02f, 6.28456380e-03f, 3.77409458e-02f,
  1.12046465e-01f, 4.54920679e-02f, -2.81704754e-01f, 2.33178347e-01f, -1.28409207e-01f, 1.44002110e-01f, 1.80797949e-01f, -3.07782926e-02f, -2.22089693e-01f, -5.22610843e-02f,
  4.69249673e-02f, -5.63712344e-02f, -8.03684816e-02f, -5.73655870e-03f, -5.37108630e-02f, -1.85990080e-01f, -9.46811363e-02f, -1.69935450e-01f, 1.40010133e-01f, -6.29268736e-02f,
  2.58031726e-01f, 1.66088641e-01f, -5.90681322e-02f, 1.48034647e-01f, -1.73915699e-01f, -1.83266804e-01f, -7.35907033e-02f, 1.66708276e-01f, 7.31790885e-02f, -1.42199732e-02f,
  -2.43457016e-02f, -1.30007358e-03f, 1.56452551e-01f, 5.62702008e-02f, -2.72385590e-02f, -2.22898230e-01f, -1.08057104e-01f, -3.02929003e-02f, 3.72626930e-02f, -6.64973818e-03f,
  -1.17097706e-01f, 1.04641775e-02f, 7.48788342e-02f, -7.96228498e-02f, 9.75261107e-02f, -9.45445821e-02f, -3.18194404e-02f, 1.06379576e-01f, -1.01848997e-01f, 1.20105065e-01f,
  1.39859810e-01f, 3.55438925e-02f, -2.03708351e-01f, 1.31210918e-02f, -4.15360071e-02f, 1.17684804e-01f, 1.84707150e-01f, 7.72682652e-02f, -2.19539076e-01f, -1.39283746e-01f,
  -1.20391948e-02f, 1.52027115e-01f, -2.24480808e-01f, 5.65077141e-02f, 8.61300603e-02f, -5.83890788e-02f, -1.27200261e-01f, -1.76155612e-01f, 2.95306385e-01f, -1.51192591e-01f,
  9.32797343e-02f, -3.64505909e-02f, 1.49341896e-01f, 2.47523829e-01f, -2.80948877e-01f, 2.65493423e-01f, 4.95093949e-02f, -3.03927697e-02f, 1.39569983e-01f, 2.10407555e-01f,
  6.25933846e-03f, 3.72828916e-02f, 4.66175331e-03f, -2.65996307e-01f, -1.55052572e-01f, 5.40540889e-02f, 1.85636550e-01f, 1.98235601e-01f, -3.81294072e-01f, -9.49623883e-02f,
  1.94396555e-01f, -2.31186301e-01f, 1.55415654e-01f, 9.10169929e-02f, -2.24348083e-01f, -7.24150985e-02f, -1.90485358e-01f, 1.99692354e-01f, 3.75115201e-02f, 4.45061997e-02f,
  -8.38908702e-02f, -9.47000235e-02f, 7.61804283e-02f, -4.32599261e-02f, 8.91284831e-03f, 6.94715530e-02f, -2.86224205e-02f, 4.81726415e-02f, -5.52915083e-03f, -1.57968536e-01f,
  -9.22055542e-02f, -6.13459852e-03f, 2.66188178e-02f, -7.98378885e-02f, -9.43480581e-02f, 1.96047559e-01f, -1.45401835e-01f, 6.94241896e-02f, 7.88079277e-02f, 2.33178422e-01f,
  1.52032286e-01f, 3.18257771e-02f, 1.59103900e-01f, 1.99222788e-01f, 4.73658666e-02f, 8.79078507e-02f, 1.85979351e-01f, -4.90801036e-02f, 4.21855114e-02f, -7.75888339e-02f,
  -3.72492254e-01f, 2.08119094e-01f, -1.93385959e-01f, 4.92274128e-02f, -3.62305604e-02f, 1.13221496e-01f, 1.28541321e-01f, 9.52368826e-02f, 7.75874825e-03f, 1.88627429e-02f,
  -2.02238783e-01f, 3.70083243e-01f, 2.03994617e-01f, -3.06141257e-01f, 1.39027014e-01f, 2.48741033e-03f, -1.97668791e-01f, -2.81539619e-01f, -1.14710450e-01f, -1.31716937e-01f,
  -8.18713009e-02f, 1.17490731e-01f, 7.76350033e-03f, 7.10926056e-02f, 5.27744479e-02f, -2.46300057e-01f, 1.33460267e-02f, 1.02550007e-01f, 9.39721055e-03f, -1.36639610e-01f,
  -1.25088975e-01f, 6.52936846e-02f, -1.05446093e-02f, 2.56056398e-01f, -4.56633233e-02f, -8.61216560e-02f, -5.21586351e-02f, 1.72278099e-02f, 1.08431160e-01f, 1.42826149e-02f,
  9.63353738e-02f, -8.10901970e-02f, -1.37932882e-01f, 1.33851059e-02f, -9.03272033e-02f, 6.64833526e-04f, 1.10256903e-01f, -1.82983577e-01f, -2.90879697e-01f, 2.54130602e-01f,
  -5.25314771e-02f, 1.15480043e-01f, 8.28089043e-02f, 2.43767008e-01f, 1.86162621e-01f, -9.68447775e-02f, 1.88073982e-03f, 2.97298670e-01f, 7.07404539e-02f, -8.81992504e-02f,
  -1.26747206e-01f, 8.39167237e-02f, 1.63546242e-02f, 3.09845526e-02f, -2.36854136e-01f, -7.62416869e-02f, 5.01825176e-02f, 5.89047819e-02f, 2.28563696e-01f, 9.31950137e-02f,
  2.52539903e-01f, -1.09525092e-01f, 1.98624000e-01f, -1.11021437e-01f, 3.01661026e-02f, 1.32018149e-01f, -6.79656789e-02f, -2.16063529e-01f, 3.32704000e-02f, -1.81715146e-01f,
  6.09920956e-02f, 2.58148342e-01f, -8.80370215e-02f, 6.09847642e-02f, -1.94845483e-01f, 1.42761111e-01f, 2.70379782e-01f, 1.32545814e-01f, 8.63310993e-02f, 1.79641542e-03f,
  -1.95676815e-02f, 7.51169398e-02f, 2.35470131e-01f, 1.19337887e-01f, 5.18405847e-02f, 2.51603257e-02f, -2.64460474e-01f, 1.07269555e-01f, 3.47553119e-02f, -8.04447308e-02f,
  1.33051530e-01f, -5.48557304e-02f, -6.54211640e-02f, -1.79242283e-01f, -2.21923292e-02f, 1.02283150e-01f, 5.32858223e-02f, -1.33590251e-01f, -6.08325861e-02f, -2.65367888e-02f,
  1.07995436e-01f, -3.31183746e-02f, -1.61393523e-01f, 1.64269656e-01f, 2.14806516e-02f, -7.29073808e-02f, -1.83983091e-02f, 2.94057310e-01f, 1.26593515e-01f, 2.27467597e-01f,
  -3.50223109e-02f, 1.87607169e-01f, 1.50871933e-01f, -1.35006934e-01f, -7.60592967e-02f, 4.28801924e-02f, 3.13057572e-01f, 3.42843197e-02f, 1.50145954e-02f, -1.99359462e-01f,
  -1.94915250e-01f, 1.46301851e-01f, -7.27351904e-02f, -1.11695729e-01f, 2.22061072e-02f, 1.02124199e-01f, 9.05455202e-02f, -8.38963017e-02f, -2.42960274e-01f, -2.34221593e-01f,
  -9.26304907e-02f, 1.72771603e-01f, 5.24326265e-02f, 1.35610491e-01f, 7.08173662e-02f, 6.58443719e-02f, 7.68688694e-02f, 7.25052059e-02f, -9.95587334e-02f, 7.78379813e-02f,
  2.60695070e-01f, 3.76280434e-02f, -1.22134104e-01f, -2.44209394e-01f, 4.60429713e-02f, 6.46067560e-02f, -1.00230068e-01f, -1.51552811e-01f, -5.16381860e-02f, -1.19395934e-01f,
  3.21760699e-02f, 1.62327483e-01f, -5.35269827e-03f, 9.61398929e-02f, 1.64794073e-01f, 5.13511039e-02f, -1.23641402e-01f, 1.06225595e-01f, -1.06108122e-01f, 2.66765356e-02f,
  4.75508943e-02f, 9.56070572e-02f, 4.05858569e-02f, -7.42142601e-03f, -2.32666992e-02f, -1.09910585e-01f, -1.21039152e-01f, 1.22068590e-02f, 1.20865926e-01f, 2.75132596e-01f,
  7.87765831e-02f, 1.86301172e-01f, 7.94236287e-02f, -2.51028359e-01f, 2.42393672e-01f, -8.64987001e-02f, -5.15259989e-02f, 5.58952093e-02f, -1.18385414e-02f, -1.04947895e-01f,
  3.90406884e-02f, -5.42652160e-02f, -2.50166029e-01f, 2.51557022e-01f, -1.10075936e-01f, 1.33666039e-01f, -1.75749019e-01f, 2.75740236e-01f, 1.05446316e-01f, -4.78849113e-02f,
  2.35413760e-01f, -1.07824832e-01f, -5.49428426e-02f, 3.57468486e-01f, 1.71757922e-01f, -1.11247852e-01f, 1.66542456e-01f, 8.26642150e-04f, -2.30650492e-02f, -3.35645094e-03f,
  2.32011512e-01f, -7.25418404e-02f, -1.18252397e-01f, -1.72524322e-02f, 1.47027194e-01f, -1.85332030e-01f, -1.81673735e-01f, -1.42992437e-01f, -8.06950182e-02f, 1.25415504e-01f,
  1.46028891e-01f, 7.97495246e-02f, 1.28158823e-01f, -5.17166331e-02f, -1.01108283e-01f, -7.22085536e-02f, 1.36556640e-01f, 1.65565223e-01f, -3.70589979e-02f, 2.56415512e-02f,
  4.80063260e-02f, 2.73040608e-02f, 6.56577945e-02f, 7.71753192e-02f, 2.83194780e-02f, -2.45443564e-02f, 2.04854757e-01f, 6.34421408e-02f, -1.16071187e-01f, 2.85001546e-02f,
  -1.33247010e-03f, -8.09251964e-02f, 6.81815371e-02f, -2.65685469e-01f, -5.43419868e-02f, -2.70741463e-01f, 7.81507865e-02f, 3.70918028e-02f, -7.81280622e-02f, 7.91016296e-02f,
  -6.27629086e-02f, -8.82136151e-02f, -1.21890746e-01f, -1.82078913e-01f, -1.42734870e-01f, 1.62150934e-01f, 2.96812356e-01f, -2.36248270e-01f, 7.56950118e-03f, 4.47918549e-02f,
  -5.69456704e-02f, -5.24643101e-02f, 3.07033192e-02f, -4.55876477e-02f, -2.06252947e-01f, 2.96150316e-02f, 1.34087235e-01f, -1.57853872e-01f, -1.62786935e-02f, 8.61276239e-02f,
  -8.92502367e-02f, 1.97090507e-01f, 1.08078131e-02f, 2.41424382e-01f, 1.73415691e-01f, 1.41927093e-01f, -2.62388103e-02f, -1.39792651e-01f, 2.33586699e-01f, 7.06517100e-02f,
  2.66624801e-02f, -2.42550299e-02f, -1.30991682e-01f, -1.46782368e-01f, -1.72371399e-02f, -1.42443329e-01f, -9.32821333e-02f, -1.34585857e-01f, 4.93131615e-02f, -1.75311223e-01f,
  -2.85754483e-02f, -8.95328727e-03f, 2.92193536e-02f, -4.87140864e-02f, 6.24307990e-02f, 4.37477715e-02f, 1.10770459e-03f, -7.11737806e-03f, 1.13325834e-01f, 1.81856994e-02f,
  -7.29128569e-02f, 2.21388750e-02f, -2.07207784e-01f, -6.70010448e-02f, -9.22219679e-02f, -7.47757927e-02f, -1.53339595e-01f, 1.64011091e-01f, 1.26500994e-01f, -1.35812372e-01f,
  -5.89981750e-02f, -1.49281383e-01f, -2.01030314e-01f, 4.60739853e-03f, -1.24167241e-01f, 1.35123497e-02f, -1.32257611e-01f, -1.33719161e-01f, -9.65581164e-02f, -2.28802003e-02f,
  -2.16502205e-01f, 8.88687819e-02f, 9.40474495e-02f, -7.46690929e-02f, 3.11925150e-02f, -1.19230688e-01f, 1.39672041e-01f, 9.59862098e-02f, -2.10605711e-02f, 2.11465120e-01f,
  4.64101434e-02f, 2.21755534e-01f, 1.85570359e-01f, -1.56897888e-01f, 7.96421617e-02f, -2.82731175e-01f, -1.09362096e-01f, 1.58839270e-01f, -7.36715049e-02f, -1.88892990e-01f,
  -1.02525935e-01f, -2.19383255e-01f, -1.41337499e-01f, -1.81049943e-01f, 5.02325706e-02f, 1.23305157e-01f, -1.09388255e-01f, 6.46588653e-02f, 3.48564759e-02f, -2.11530492e-01f,
  -8.54451731e-02f, -1.57113057e-02f, -1.45782128e-01f, -5.17309196e-02f, -3.00618354e-02f, -3.34851481e-02f, -3.79290357e-02f, 1.30558297e-01f, -1.18486919e-02f, 6.91036731e-02f,
  5.96941039e-02f, 7.72560611e-02f, 3.37928645e-02f, 7.85071850e-02f, 3.35622244e-02f, 1.20396368e-01f, -4.22012992e-02f, 4.47539985e-02f, 1.95699453e-01f, -1.02583967e-01f,
  -1.91008225e-01f, 1.26538992e-01f, 9.78711769e-02f, -1.04923680e-01f, 1.14221238e-02f, -1.08500265e-01f, 7.60573670e-02f, -1.65259942e-01f, 9.28673986e-03f, 2.52352625e-01f,
  -6.82334304e-02f, -1.15887649e-01f, -6.98996559e-02f, -1.30455658e-01f, -1.22151241e-01f, 2.79982835e-01f, 1.17746659e-01f, -6.50762990e-02f, -9.21476632e-02f, -1.86226424e-02f,
  3.82075235e-02f, 1.33906677e-01f, -2.61664260e-02f, 7.04274401e-02f, 1.08629912e-01f, 4.36487943e-02f, 1.81027427e-01f, -2.06845433e-01f, 4.37879376e-02f, -1.30812362e-01f,
  7.12803900e-02f, 2.19958946e-02f, -8.50255077e-04f, -1.42353058e-01f, -3.60063910e-02f, -1.27167106e-01f, 6.48962408e-02f, -6.71094730e-02f, 8.14647377e-02f, -1.92391381e-01f,
  -1.77161485e-01f, 3.35119553e-02f, -3.12716104e-02f, -1.11287996e-01f, -1.71317175e-01f, 1.68415122e-02f, -2.74312304e-04f, -1.03840627e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -9.25393254e-02f, 1.47756100e-01f, 1.90688625e-01f, 1.48337051e-01f, 2.78104484e-01f, 6.74659386e-02f, 9.66376737e-02f, 4.16301638e-02f, 1.65101960e-01f, 1.79438606e-01f,
  1.78488672e-01f, -1.12087674e-01f, 1.08287975e-01f, -1.87314510e-01f, -1.82315812e-01f, -7.19838310e-03f, -2.00839072e-01f, -1.84608862e-01f, 2.04501301e-01f, 1.98706821e-01f,
  2.73531258e-01f, 2.03848794e-01f, -1.86762854e-01f, 4.01413113e-01f, -2.07352102e-01f, -1.20148338e-01f, -9.60092694e-02f, -1.52622610e-01f, 2.07909301e-01f, -2.73591280e-02f,
  -2.84063399e-01f, 1.48803711e-01f, 1.97334766e-01f, -1.25644496e-02f, 7.30295539e-01f, -1.41525775e-01f, 2.24932685e-01f, 2.91954130e-01f, 2.61414349e-01f, 1.47591323e-01f,
  1.81397632e-01f, -1.18428294e-03f, 5.64380176e-02f, 2.32897270e-02f, 2.45333701e-01f, -3.36201459e-01f, -2.05447599e-01f, 1.83470428e-01f, -3.63265842e-01f, -3.07410210e-01f,
  -4.51024204e-01f, 1.48928836e-01f, 4.72325116e-01f, 9.74050760e-02f, 3.34756166e-01f, 3.54228348e-01f, 3.90028238e-01f, 2.71915734e-01f, 5.98987579e-01f, -2.83813387e-01f,
  -4.88551736e-01f, -1.27099091e-02f, 1.64717600e-01f, 1.02075286e-01f, 7.34623745e-02f, 4.92573902e-02f, 2.14774400e-01f, 4.87089306e-02f, 2.13500038e-01f, 2.11067960e-01f,
  6.98687583e-02f, 1.27312198e-01f, 2.51319885e-01f, 3.04152787e-01f, 3.34427468e-02f, 1.87953576e-01f, -2.11371884e-01f, -1.00628272e-01f, 2.70727836e-03f, 2.53333356e-02f,
  8.35461468e-02f, 6.36742711e-02f, -1.26040593e-01f, 8.19651559e-02f, -3.89849171e-02f, -1.38716802e-01f, 1.98873445e-01f, 3.46579216e-02f, 1.24220096e-01f, 1.05828848e-02f,
  2.16475889e-01f, 9.59659889e-02f, 1.59990981e-01f, 2.17509747e-01f, 9.66815501e-02f, 5.78238785e-01f, -2.79326081e-01f, 2.80681431e-01f, -1.22033514e-01f, 2.52525806e-01f,
  -4.74812120e-01f, -4.05019522e-01f, 3.53032708e-01f, -2.85673022e-01f, -3.57661843e-01f, 4.78333533e-01f, 1.01289518e-01f, -1.92656443e-01f, 1.33494735e-01f, -6.89356998e-02f,
  -1.12398095e-01f, -2.27693081e-01f, 2.15258837e-01f, -9.61255133e-02f, 1.93791091e-01f, -2.91358810e-02f, 3.49281788e-01f, 4.93976176e-02f, -5.77732436e-02f, 4.38033253e-01f,
  -3.80867603e-03f, 2.17841506e-01f, -3.82976204e-01f, 9.90941599e-02f, 1.50983352e-02f, 8.48358944e-02f, 6.94748983e-02f, 1.19425125e-01f, -1.43349528e-01f, 1.80067480e-01f,
  1.77760109e-01f, 3.28052305e-02f, 9.51327011e-03f, -4.29177508e-02f, -7.90070370e-02f, 2.49746274e-02f, 3.66466120e-02f, 3.60201076e-02f, 1.20152019e-01f, 1.18326642e-01f,
  1.91414356e-01f, -1.70124590e-01f, 2.15547487e-01f, 2.46788412e-02f, -2.47136846e-01f, 1.66617736e-01f, -4.57003340e-03f, -3.27142403e-02f, 1.66256577e-01f, -8.20466131e-02f,
  4.63237055e-04f, 2.20562935e-01f, 3.89357060e-02f, 3.04299921e-01f, 1.64447203e-01f, -6.79615662e-02f, -1.23425618e-01f, 2.39212587e-01f, 8.91532302e-02f, 2.50894189e-01f,
  3.42815071e-01f, -1.42113164e-01f, 1.41331837e-01f, 2.75523543e-01f, 4.31194305e-01f, 2.67710537e-01f, 1.17776945e-01f, 1.79888144e-01f, 3.51931632e-01f, 3.85502249e-01f,
  3.71862471e-01f, 1.48877874e-01f, 1.66850179e-01f, 1.90714002e-01f, 7.45805651e-02f, -1.03243351e-01f, -1.21780504e-02f, 3.55145968e-02f, 1.21938594e-01f, -5.81180453e-02f,
  5.52021675e-02f, -3.56780082e-01f, 2.93819517e-01f, -4.63038594e-01f, -3.48620594e-01f, 1.19828641e-01f, 1.96561828e-01f, -2.63175145e-02f, 2.18941625e-02f, -7.55700422e-03f,
  -2.36702859e-02f, 7.56832734e-02f, -2.90299412e-02f, -1.02317706e-01f, -7.32742772e-02f, 7.43077099e-02f, 2.48217523e-01f, -3.08161024e-02f, 5.07166646e-02f, 1.71434898e-02f,
  1.08596936e-01f, 2.23745212e-01f, -1.37313068e-01f, 2.58423164e-02f, -5.36050163e-02f, 1.17498949e-01f, -1.22218439e-02f, -2.28186786e-01f, -2.96216067e-02f, -2.65146106e-01f,
  8.45893547e-02f, -1.85390398e-01f, -1.23678640e-01f, 1.43733591e-01f, -2.76472151e-01f, -1.11363314e-01f, 2.14024425e-01f, -1.94186971e-01f, -1.63536280e-01f, 3.40132535e-01f,
  5.80877811e-02f, -1.82724342e-01f, 4.34123814e-01f, -3.89746159e-01f, 1.65496081e-01f, 7.72637799e-02f, 2.89429605e-01f, -6.08475022e-02f, -6.03582570e-03f, -4.93461378e-02f,
  -4.08786565e-01f, 1.96074545e-01f, 2.34149590e-01f, -2.57032901e-01f, -1.59437954e-01f, 4.50658798e-01f, -6.67655934e-03f, -2.33812761e-02f, -8.08894485e-02f, 1.76250756e-01f,
  -3.60239118e-01f, -1.54215127e-01f, 1.56253725e-01f, 2.05159206e-02f, 1.95066333e-02f, 4.71274883e-01f, 1.75348103e-01f, 2.28640154e-01f, 2.14219511e-01f, -3.02894950e-01f,
  -1.30269915e-01f, 7.67541453e-02f, -8.93375948e-02f, 1.96266640e-02f, 1.27931356e-01f, 2.28889018e-01f, -2.86116283e-02f, 1.95490569e-01f, 1.17240712e-01f, 8.56567696e-02f,
  -8.16945508e-02f, -8.91723484e-03f, 9.79446396e-02f, -5.33311032e-02f, 7.87992105e-02f, -3.59972306e-02f, 2.05856249e-01f, 1.36970133e-01f, 1.34138703e-01f, -6.01786077e-02f,
  2.18931898e-01f, 1.83090806e-01f, -1.79687646e-04f, -3.11076909e-01f, 3.69100869e-02f, 1.71474934e-01f, 1.13854215e-01f, 1.93241671e-01f, -1.95171028e-01f, 1.13144107e-01f,
  -1.55331716e-02f, 1.86115012e-01f, 8.40593800e-02f, -1.57533884e-01f, 4.01729941e-01f, -1.20869473e-01f, -1.91138312e-01f, -4.52190191e-02f, 1.44683838e-01f, -2.77929574e-01f,
  6.75262287e-02f, 1.89809397e-01f, 3.41434628e-01f, 3.32937777e-01f, -2.82819659e-01f, -7.24185184e-02f, 1.37181327e-01f, 1.15915425e-02f, 5.85220195e-02f, 1.54631078e-01f,
  -3.70050706e-02f, -4.87109646e-02f, 1.80437136e-02f, -2.20008254e-01f, -3.37265544e-02f, 1.81430325e-01f, 2.27461085e-01f, 2.92832907e-02f, 3.37156862e-01f, -4.04074416e-02f,
  2.50251770e-01f, -3.30873340e-01f, 6.63848221e-02f, 8.98826346e-02f, 1.00915648e-01f, -1.40216932e-01f, -2.32948899e-01f, -1.77219123e-01f, 2.81295717e-01f, 1.03674322e-01f,
  3.43145952e-02f, 2.84955084e-01f, 1.29228160e-01f, 1.53259024e-01f, 6.22543395e-02f, -1.98766515e-02f, 9.68238711e-03f, 2.07636669e-01f, 1.13673143e-01f, 1.77420005e-01f,
  2.46806979e-01f, 2.42565200e-01f, 7.46656358e-02f, 4.05050181e-02f, 1.04197353e-01f, 6.32750243e-02f, 5.45209758e-02f, -1.65028647e-01f, -6.04147762e-02f, 1.54732674e-01f,
  1.49024174e-01f, 2.72291958e-01f, 3.69477004e-01f, 1.90403700e-01f, -2.20177546e-01f, -2.22512707e-02f, 1.28759682e-01f, -1.69652387e-01f, 2.58042604e-01f, 3.47484410e-01f,
  -9.89926979e-03f, 1.07226431e-01f, -5.71394086e-01f, 6.09626472e-02f, 9.91095379e-02f, -2.05047116e-01f, -4.69384491e-02f, -2.25246251e-01f, 3.77304018e-01f, -5.78638732e-01f,
  -2.43590072e-01f, 2.11606950e-01f, -8.53893161e-02f, 4.96151075e-02f, 2.58679450e-01f, -4.29513007e-02f, 1.27262920e-01f, -2.68800944e-01f, 2.43499383e-01f, 4.47189575e-03f,
  1.54300645e-01f, 1.17723987e-01f, 7.32656896e-01f, 9.73090231e-02f, -2.52552867e-01f, 2.41050228e-01f, -1.14612311e-01f, 1.09442599e-01f, 1.58977747e-01f, 7.90496543e-02f,
  -5.50126843e-02f, -2.19522983e-01f, 3.38552594e-01f, -3.18498947e-02f, 1.62370950e-02f, 4.09558974e-02f, -3.00719235e-02f, 5.32093197e-02f, 1.70250073e-01f, -2.68562610e-04f,
  4.56308238e-02f, 8.76295045e-02f, 1.15049273e-01f, -1.53297288e-02f, 2.35728323e-01f, 8.96553546e-02f, 3.93279567e-02f, -1.56847566e-01f, 2.53865927e-01f, 1.18393108e-01f,
  -1.20502241e-01f, -5.87967373e-02f, -7.54738525e-02f, -7.44658709e-02f, 1.84195101e-01f, 6.05255701e-02f, -4.46553864e-02f, -3.00167829e-01f, 1.94741473e-01f, -1.86992660e-01f,
  1.38295680e-01f, 2.14238569e-01f, 9.36383680e-02f, 3.60164016e-01f, 3.22870195e-01f, -2.43057877e-01f, 2.70736814e-01f, -2.58889467e-01f, 1.83834732e-01f, 2.59067327e-01f,
  -1.95030376e-01f, 2.78426826e-01f, -1.14226840e-01f, 3.40158850e-01f, -5.23288287e-02f, 2.36371547e-01f, 1.17107771e-01f, 3.03857744e-01f, -1.92387670e-01f, 3.43522847e-01f,
  -1.47893419e-02f, 2.46393993e-01f, -2.25497499e-01f, 2.96458118e-02f, 1.30315676e-01f, 2.92785883e-01f, -1.21828720e-01f, 4.93157804e-02f, 3.30414712e-01f, -1.65988773e-01f,
  6.65075928e-02f, 1.87415734e-01f, -6.27025008e-01f, 2.28142500e-01f, 8.43493640e-02f, 8.27620775e-02f, 2.31375992e-01f, 2.11374208e-01f, 1.11011080e-01f, 7.02245161e-02f,
  6.81592822e-02f, 1.14468522e-02f, 6.12296835e-02f, 2.57845558e-02f, -6.50644023e-03f, 5.78052737e-02f, 1.11912742e-01f, 2.70516068e-01f, -3.79949948e-03f, 3.17561239e-01f,
  1.93834007e-01f, -1.10153496e-01f, 4.19717401e-01f, 1.30075008e-01f, 2.20111787e-01f, -3.17884892e-01f, -2.48679146e-01f, -2.71128237e-01f, 4.13713068e-01f, 3.82348925e-01f,
  2.03296155e-01f, 3.40783507e-01f, -3.83782052e-02f, -1.20315515e-02f, 2.40130037e-01f, 7.52779841e-02f, 2.00263020e-02f, 4.74002510e-01f, -1.51297525e-01f, 2.84811139e-01f,
  -2.70120531e-01f, -3.58883105e-02f, 7.28465319e-02f, -8.63393247e-02f, 1.90327451e-01f, -1.92165703e-01f, 4.77025688e-01f, -1.96665421e-01f, -2.89046288e-01f, 3.86574745e-01f,
  1.30978599e-01f, 2.37162367e-01f, 2.50077695e-01f, 4.24396023e-02f, -5.50227910e-02f, -3.60613227e-01f, -5.87461852e-02f, -2.08526384e-02f, 4.15439367e-01f, -2.18538055e-03f,
  4.68311012e-01f, 7.84706846e-02f, -2.55379736e-01f, 6.34003654e-02f, -3.06749165e-01f, -6.24000691e-02f, -5.89756779e-02f, -3.00645898e-03f, 6.74248161e-03f, -1.14626393e-01f,
  4.06100601e-01f, -5.44832796e-02f, 1.25087753e-01f, 1.03445612e-01f, 2.93061286e-01f, 1.55887038e-01f, 6.57308905e-04f, 1.46857351e-01f, 4.19777744e-02f, 2.78392345e-01f,
  2.16789424e-01f, -7.01871440e-02f, 8.08846205e-02f, 4.30116877e-02f, 7.94560984e-02f, 1.31938830e-02f, -2.17946872e-01f, -1.57827020e-01f, 2.53440380e-01f, 4.58721779e-02f,
  -1.41889393e-01f, 3.21895257e-02f, -1.28377050e-01f, -1.05780438e-01f, -3.55564058e-01f, 7.28654675e-03f, 3.42969507e-01f, -2.37161875e-01f, -1.32793695e-01f, 2.51929998e-01f,
  -1.07412025e-01f, -1.40751317e-01f, 1.11264579e-01f, -3.73167843e-02f, 2.12042794e-01f, 1.12729385e-01f, 6.50487617e-02f, 5.88017888e-02f, 4.30373937e-01f, 1.10688381e-01f,
  -3.15950215e-01f, 3.44417334e-01f, 2.15704456e-01f, -1.46765128e-01f, 1.60432518e-01f, 3.66418630e-01f, -8.84142220e-02f, 2.91967988e-01f, 5.18176034e-02f, 5.14667451e-01f,
  -3.48620974e-02f, -1.71196628e-02f, 4.57487963e-02f, -1.48705319e-01f, -1.69369176e-01f, 1.78950414e-01f, 4.36175577e-02f, 8.07644874e-02f, 4.22586016e-02f, 4.76626158e-02f,
  4.10608441e-01f, -1.14457272e-01f, -3.33442986e-01f, 3.56690772e-02f, -3.40516940e-02f, 1.91831023e-01f, -4.76311930e-02f, 1.26230717e-01f, -2.24216983e-01f, 5.66492975e-02f,
  -3.26284319e-02f, 1.89331606e-01f, 1.74055681e-01f, 1.63247243e-01f, 1.11091465e-01f, 3.52988280e-02f, 2.93125987e-01f, 2.56043464e-01f, 1.64508924e-01f, -1.97292134e-01f,
  2.33628079e-01f, -6.16240911e-02f, 8.68224576e-02f, -7.27482466e-03f, -5.17184548e-02f, -3.56907517e-01f, 2.79855281e-01f, -2.96654224e-01f, -1.61449417e-01f, -2.79228151e-01f,
  2.15541154e-01f, 2.42721975e-01f, 1.08788431e-01f, -2.03631431e-01f, -2.48957679e-01f, 4.05974209e-01f, 3.64035815e-01f, 1.83462918e-01f, 1.47086993e-01f, -5.61409593e-01f,
  7.58175226e-03f, -2.29718342e-01f, 1.37108788e-01f, 3.43804210e-01f, -5.71689844e-01f, 2.20550641e-01f, 9.99829620e-02f, 1.19483203e-01f, 3.42562795e-01f, -1.72662679e-02f,
  -9.28899497e-02f, 3.20281476e-01f, 2.30185524e-01f, 2.87504911e-01f, 3.86969239e-01f, 1.04288422e-01f, 1.00354142e-01f, -6.15637749e-02f, 8.50489512e-02f, -7.01226890e-02f,
  1.73819900e-01f, -4.65949578e-03f, -1.51576743e-01f, -6.82778507e-02f, -1.97261557e-01f, 4.56997566e-02f, 6.44892454e-02f, -2.34139949e-01f, 9.59943905e-02f, -3.55070710e-01f,
  2.63674885e-01f, 1.69647470e-01f, 8.92505702e-03f, 1.34384692e-01f, 7.12105110e-02f, 3.05432290e-01f, 1.36951923e-01f, 2.36498490e-01f, 3.11978042e-01f, 1.87233448e-01f,
  2.20254421e-01f, 3.17309529e-01f, -1.55592382e-01f, 1.35574475e-01f, 3.67430389e-01f, -1.50183812e-01f, -2.02390194e-01f, -2.17646077e-01f, 1.23649491e-02f, -2.99284011e-01f,
  -4.05533522e-01f, 1.00166248e-02f, 3.83359313e-01f, -6.76539898e-01f, -8.31777006e-02f, 1.60156831e-01f, 7.33211413e-02f, -1.74333081e-01f, 2.76124150e-01f, -1.40353709e-01f,
  2.35652417e-01f, 1.72408864e-01f, 2.93203682e-01f, 1.88483417e-01f, -2.70215720e-01f, 1.88241333e-01f, 8.86980146e-02f, 2.27381527e-01f, 4.49167518e-03f, 3.27101767e-01f,
  8.38231444e-02f, 1.10710002e-01f, -7.04513639e-02f, 2.42184356e-01f, -2.58484483e-01f, 2.82457203e-01f, -2.62020202e-03f, -2.85280585e-01f, 1.76842600e-01f, 1.17184773e-01f,
  2.55940199e-01f, -1.62758261e-01f, -1.60375029e-01f, 5.43211438e-02f, 5.50714359e-02f, -3.79664421e-01f, 1.58398598e-01f, 7.40780756e-02f, -4.68977034e-01f, -3.23505849e-01f,
  1.24601230e-01f, -9.93941799e-02f, 3.34318429e-01f, -2.20931560e-01f, 5.02051376e-02f, 2.79970884e-01f, 2.85784006e-01f, 2.36414611e-01f, 3.03320289e-01f, 7.85382390e-02f,
  1.50966525e-01f, 1.13340825e-01f, 2.35318676e-01f, 9.32315215e-02f, 2.55131602e-01f, -1.28959224e-01f, -1.18496073e-02f, -3.85687500e-02f, -3.35395694e-01f, -4.29733424e-03f,
  6.57763854e-02f, -7.62576386e-02f, 1.32882118e-01f, -2.22621053e-01f, 1.59268379e-01f, -1.12889744e-01f, -1.83774024e-01f, 2.44635627e-01f, 1.33981064e-01f, -2.20163971e-01f,
  -1.25924885e-01f, -2.08076209e-01f, -1.93787426e-01f, 1.41248152e-01f, 1.47254199e-01f, -2.57643610e-01f, -6.10410534e-02f, 9.84473303e-02f, 3.50165069e-01f, -2.37281129e-01f,
  2.36230984e-01f, -7.65906125e-02f, -9.17195007e-02f, 4.32125740e-02f, 7.66656101e-02f, -3.47708225e-01f, -2.32869104e-01f, 2.47189760e-01f, -8.21484104e-02f, 1.47819683e-01f,
  1.06439181e-01f, 6.40419662e-01f, 1.96867004e-01f, 1.70142472e-01f, -1.68273166e-01f, -8.67362991e-02f, 4.60642904e-01f, 3.45849156e-01f, 9.48741734e-02f, 3.74422520e-01f,
  3.31953675e-01f, -1.29657820e-01f, 4.45687681e-01f, 6.37612715e-02f, -4.83110175e-02f, -2.52986401e-01f, 1.97737157e-01f, -2.40001440e-01f, 2.36075208e-01f, 1.78366050e-01f,
  1.01665273e-01f, 1.79389045e-01f, 2.55536046e-02f, 2.10687920e-01f, -5.68044297e-02f, 2.91548800e-02f, 1.75915509e-01f, 2.06192359e-01f, 2.85347015e-01f, 2.18773961e-01f,
  -1.04048438e-01f, -8.23791996e-02f, 1.16728298e-01f, -2.32450455e-01f, -3.33526850e-01f, -8.48746523e-02f, 2.46618062e-01f, -9.14316475e-02f, -1.82439774e-01f, -1.56919077e-01f,
  1.38255075e-01f, -3.25265735e-01f, -1.68496519e-01f, 2.76237607e-01f, 5.53783886e-02f, -2.34930679e-01f, -1.02678306e-01f, -2.14793190e-01f, -2.18933687e-01f, 2.59226203e-01f,
  3.64877522e-01f, -2.02957541e-01f, 1.34030695e-03f, 1.16093948e-01f, 2.16024034e-02f, 3.43539953e-01f, 7.52871856e-03f, 4.29118782e-01f, 1.94142893e-01f, 2.25426197e-01f,
  1.02198496e-01f, -4.00170758e-02f, 1.68645665e-01f, 8.28439929e-03f, 1.04356326e-01f, -2.50427395e-01f, -1.28161594e-01f, -5.27272262e-02f, 1.32179797e-01f, 1.82152972e-01f,
  -3.95000339e-01f, -4.19802368e-01f, 3.83301705e-01f, 3.73653695e-02f, 3.18385810e-01f, 4.17153150e-01f, 1.54956102e-01f, 1.53196812e-01f, 8.87594074e-02f, 5.57736456e-02f,
  9.77399349e-02f, 1.98350817e-01f, -4.10487652e-02f, 1.26660436e-01f, 9.11961198e-02f, 1.77929342e-01f, 6.21109009e-02f, 1.25748321e-01f, 1.78572789e-01f, 9.88713950e-02f,
  4.32487810e-03f, -1.32201789e-02f, 9.92524922e-02f, 9.41229612e-02f, 1.37370646e-01f, -3.15571241e-02f, 2.30608091e-01f, 9.79172066e-02f, -2.50057802e-02f, 2.20085364e-02f,
  -1.94662169e-01f, -9.29749981e-02f, 4.22609299e-01f, 1.12543739e-01f, 3.00969899e-01f, 3.99262935e-01f, -1.37164623e-01f, 5.04231229e-02f, 9.81007889e-02f, 1.09612525e-01f,
  -1.00587152e-01f, 2.18592525e-01f, -2.04948545e-01f, 4.17322874e-01f, -1.51289105e-01f, 1.08566783e-01f, -1.39800683e-01f, 2.36493990e-01f, 5.47702312e-01f, 2.62074489e-02f,
  3.00020278e-01f, -2.49453694e-01f, 1.43726692e-01f, 1.35442898e-01f, 2.20967442e-01f, 3.57313156e-01f, 2.83765614e-01f, 4.36579026e-02f, 2.22726956e-01f, -1.83376625e-01f,
  -1.64987355e-01f, 1.51084706e-01f, 2.21977293e-01f, -1.37081221e-01f, 4.49527293e-01f, 1.73391610e-01f, -6.72667697e-02f, -2.73868978e-01f, -3.10094684e-01f, 1.55655453e-02f,
  3.73536944e-01f, -8.84645730e-02f, -1.01732574e-01f, -6.33243769e-02f, -4.75441851e-02f, 5.49432598e-02f, 7.43442178e-02f, 5.29351309e-02f, 3.28118116e-01f, 1.09879129e-01f,
  2.93412060e-01f, 2.59416997e-01f, 8.64355862e-02f, 2.88604528e-01f, 1.44989818e-01f, 1.37692720e-01f, 1.65813178e-01f, 1.98597327e-01f, 1.48994148e-01f, -4.99195941e-02f,
  -4.37498152e-01f, 2.43642151e-01f, 1.75748151e-02f, -1.30042545e-02f, 1.19866155e-01f, 5.03490031e-01f, -1.53372303e-01f, 1.96341246e-01f, 8.84785652e-02f, 3.97246271e-01f,
  3.65078896e-02f, -1.51050821e-01f, 1.69643834e-01f, -5.25041036e-02f, 5.02371013e-01f, -2.07731128e-01f, -2.28339747e-01f, 2.65750647e-01f, -4.76055816e-02f, 4.65802133e-01f,
  3.16594541e-01f, 4.69920576e-01f, 1.12191103e-01f, 1.92353576e-01f, 4.27412301e-01f, -7.07796961e-02f, 5.69796152e-02f, -3.53298645e-04f, -1.64752766e-01f, 2.48088241e-02f,
  7.33141899e-02f, -6.79987147e-02f, -2.39133865e-01f, -1.55335203e-01f, 2.08672062e-01f, -4.60740291e-02f, -1.30888402e-01f, 8.20457786e-02f, -7.25015998e-02f, 2.25449964e-01f,
  -7.91599303e-02f, 6.83553666e-02f, 3.59441608e-01f, 3.36503237e-01f, 4.42254543e-01f, -1.81515604e-01f, 1.43090293e-01f, 2.64428198e-01f, -3.51670831e-02f, 3.42221141e-01f,
  3.20416182e-01f, 1.44429222e-01f, 1.76087275e-01f, 2.50137806e-01f, 1.18375108e-01f, 2.20374212e-01f, -4.04616818e-02f, 2.29669109e-01f, 1.74519747e-01f, 4.15934511e-02f,
  1.54820204e-01f, 1.42749995e-01f, -1.19211916e-02f, -1.53526505e-02f, 1.35926962e-01f, 9.75540653e-03f, -3.80018502e-01f, -1.56404361e-01f, 1.80832744e-01f, 2.49284163e-01f,
  -7.80306384e-02f, 1.82076156e-01f, 2.32676297e-01f, -1.43237963e-01f, -2.89090663e-01f, -1.96434870e-01f, 1.07389547e-01f, -2.87815273e-01f, 6.57351688e-02f, -1.56781331e-01f,
  -2.53105521e-01f, -4.70718518e-02f, 1.10478677e-01f, -1.95222989e-01f, 1.74737349e-01f, 2.34948590e-01f, -3.63480449e-01f, 2.77851313e-01f, 9.88135785e-02f, 1.65938571e-01f,
  -5.58829717e-02f, 1.84728041e-01f, -2.72977471e-01f, 1.07775368e-01f, -2.06292823e-01f, 2.02945441e-01f, -1.10970721e-01f, -2.76246488e-01f, 2.89011672e-02f, -1.36177525e-01f,
  -1.16682589e-01f, 2.37620398e-01f, -2.35266492e-01f, -5.57023399e-02f, 8.70342255e-02f, 1.64571136e-01f, 2.91349143e-01f, 3.13941330e-01f, -5.11223190e-02f, -6.32242560e-02f,
  3.70223005e-03f, 9.28946659e-02f, 2.17572883e-01f, 2.38181815e-01f, 2.70455986e-01f, 3.45888376e-01f, 2.86366165e-01f, 1.30679160e-01f, 1.34397775e-01f, 2.81281888e-01f,
  2.17929646e-01f, 2.21044376e-01f, 4.03326571e-01f, 2.81423837e-01f, 7.42342547e-02f, 1.87077314e-01f, -1.67326331e-01f, -2.01693587e-02f, 3.41973782e-01f, -1.11822531e-01f,
  -1.93930209e-01f, -2.22255066e-01f, 2.48741731e-02f, -1.53201208e-01f, -2.92490780e-01f, 5.73892854e-02f, 2.41250157e-01f, -3.17296565e-01f, -3.10627788e-01f, -1.48019388e-01f,
  2.40148097e-01f, -1.11660048e-01f, -1.92679211e-01f, 1.23190917e-01f, 1.16852537e-01f, 1.13792069e-01f, 5.17445914e-02f, 1.26781568e-01f, 1.80520922e-01f, -5.97442538e-02f,
  -1.26981974e-01f, -5.93995191e-02f, -8.74046236e-02f, 1.45266801e-01f, 3.81593104e-03f, -9.32248086e-02f, -2.18627602e-01f, 2.54610419e-01f, -2.39739224e-01f, 1.11049995e-01f,
  -2.41444036e-01f, -2.27394745e-01f, 4.90642227e-02f, -2.36385480e-01f, 2.17171282e-01f, -1.14356250e-01f, -3.00758958e-01f, 2.42568657e-01f, 3.64207923e-02f, 2.95725316e-01f,
  3.82336557e-01f, 1.93597563e-02f, -1.14327751e-01f, -1.16056487e-01f, 3.49210709e-01f, 1.97468981e-01f, 2.79073805e-01f, -2.39169627e-01f, -6.50880784e-02f, 1.70137748e-01f,
  -5.54366671e-02f, 2.12980211e-01f, 1.93484470e-01f, -8.37777480e-02f, 2.51662999e-01f, 2.82940716e-01f, 3.77037078e-02f, 8.04169849e-03f, 5.99925295e-02f, 3.81055963e-03f,
  8.91573131e-02f, -2.59497277e-02f, 2.19172031e-01f, -1.86347440e-01f, 1.14217639e-01f, -3.68543684e-01f, -1.21723793e-01f, -3.12763941e-03f, 2.40560696e-01f, 1.10204957e-01f,
  1.10232949e-01f, 3.59476268e-01f, -6.24845177e-02f, 1.25773996e-01f, 1.05672233e-01f, 2.64678478e-01f, 4.89706814e-01f, -2.43962646e-01f, 1.44509926e-01f, 6.43118545e-02f,
  5.02554923e-02f, 3.51289779e-01f, -8.24087709e-02f, 9.67955440e-02f, 2.21821338e-01f, -6.12315834e-02f, -2.58725822e-01f, -5.06480820e-02f, 3.37150574e-01f, -2.82402158e-01f,
  2.72661686e-01f, -5.92195168e-02f, 1.80114508e-02f, -2.60447949e-01f, -2.50769913e-01f, -9.22755077e-02f, 3.35302472e-01f, -1.83251366e-01f, -1.94998160e-01f, -6.08177744e-02f,
  7.13712513e-01f, 3.23824584e-01f, 3.08692995e-02f, 2.38920078e-02f, -2.09891379e-01f, -2.90596753e-01f, 1.09398231e-01f, 2.95657087e-02f, 1.62082553e-01f, -5.48833385e-02f,
  1.83232442e-01f, 1.53088853e-01f, 1.05689093e-01f, -3.28231864e-02f, 1.34818614e-01f, 8.42768699e-03f, 1.13053702e-01f, 5.73201515e-02f, -5.61006479e-02f, 4.36708033e-02f,
  1.68894917e-01f, 8.80053639e-02f, 1.31668925e-01f, 2.83232391e-01f, -2.57587470e-02f, -1.81073204e-01f, -4.93570745e-01f, 2.41704926e-01f, 1.60562113e-01f, 3.88877153e-01f,
  1.24362826e-01f, 1.56612635e-01f, -2.16181460e-03f, -6.35252595e-02f, 1.14875950e-01f, 2.74463743e-01f, -1.20470813e-02f, -1.81359664e-01f, 1.30469352e-01f, 1.46523714e-01f,
  2.17162937e-01f, 2.97749579e-01f, 7.73472991e-03f, 9.39060971e-02f, -2.45392576e-01f, 2.73094058e-01f, 3.50050032e-01f, 1.59115121e-01f, -6.43358529e-02f, -2.28417054e-01f,
  2.89866269e-01f, -2.89428048e-04f, -1.12285644e-01f, 2.43913963e-01f, -1.41060174e-01f, -1.14986107e-01f, 5.12129590e-02f, -5.78054301e-02f, 4.31434810e-02f, 4.45492983e-01f,
  4.37775224e-01f, 7.34000793e-03f, -1.52354851e-01f, -2.52545744e-01f, 3.96780342e-01f, 5.67810722e-02f, -6.98728561e-02f, 1.24875143e-01f, 2.21112505e-01f, 1.76801816e-01f,
  5.23782730e-01f, -2.50314832e-01f, 1.15743026e-01f, -9.59285498e-02f, -3.82271528e-01f, 1.51156932e-01f, 6.45622909e-02f, 1.46356449e-01f, 1.08733781e-01f, 1.39998376e-01f,
  -5.23787632e-04f, 9.07272324e-02f, -2.68045138e-03f, 2.00189888e-01f, 1.81276396e-01f, 8.71391594e-02f, 2.25594267e-01f, 2.56729834e-02f, -1.10185314e-02f, 1.05645508e-01f,
  1.49869472e-01f, -1.45176604e-01f, 1.78535178e-01f, -6.91231154e-03f, -9.66194198e-02f, -3.82057339e-01f, 2.62852281e-01f, -5.00951298e-02f, -1.76108003e-01f, -2.39484549e-01f,
  2.04631574e-02f, -1.56975180e-01f, 1.24527469e-01f, -1.67285845e-01f, -2.26736069e-02f, 2.68465281e-01f, 3.59726042e-01f, 9.92740039e-03f, -1.37117594e-01f, -8.03618506e-03f,
  -2.40747079e-01f, -1.40403017e-01f, 2.97122210e-01f, -7.19676018e-02f, -1.38090700e-01f, -3.16300578e-02f, -2.26265371e-01f, -3.08680177e-01f, -1.88587785e-01f, 2.46045247e-01f,
  1.87488657e-03f, 3.86435747e-01f, 4.21134010e-02f, 5.40733099e-01f, 1.88456953e-01f, 1.21851645e-01f, 3.33588898e-01f, -1.20978795e-01f, 8.30773339e-02f, 2.14517772e-01f,
  -2.47821271e-01f, 2.08133981e-01f, -6.80376440e-02f, -3.60505491e-01f, -4.39217761e-02f, 4.03986573e-02f, -1.30340997e-02f, -3.09043497e-01f, 3.74749422e-01f, -1.16976365e-01f,
  -1.33462891e-01f, -1.18589610e-01f, -2.80963313e-02f, 1.17593549e-01f, 1.76355585e-01f, -2.86425222e-02f, 4.92594354e-02f, 1.05979359e-02f, -2.34212540e-02f, 2.22794712e-01f,
  -5.61425574e-02f, -2.25347672e-02f, -2.51218230e-02f, -8.34233463e-02f, 7.96741620e-03f, -2.17797458e-01f, -3.38021840e-04f, -1.91689208e-01f, -4.42651771e-02f, 7.52215683e-02f,
  -6.34841397e-02f, -7.74387717e-02f, -1.30199254e-01f, 2.15299591e-01f, 1.00860126e-01f, -2.07366139e-01f, -1.46216042e-02f, 1.85781330e-01f, -2.80045979e-02f, -3.73020709e-01f,
  4.02482957e-01f, -3.68248075e-01f, 6.59341663e-02f, -2.01820377e-02f, 2.26415262e-01f, 2.20870793e-01f, 1.17775276e-01f, -1.14589758e-01f, -5.11463344e-01f, 2.68221557e-01f,
  1.21813394e-01f, -2.90592104e-01f, -1.65462881e-01f, 3.55056196e-01f, -4.15920615e-02f, -4.61834483e-02f, -4.54183728e-01f, 2.86582947e-01f, -1.72269896e-01f, -4.38957036e-01f,
  -3.24894339e-02f, 1.87303743e-03f, 1.37264907e-01f, 3.86029750e-01f, 1.87998906e-01f, 3.37401241e-01f, 1.70513377e-01f, -1.01790100e-01f, 4.28647436e-02f, 2.84268796e-01f,
  -2.35172331e-01f, 1.32526718e-02f, 8.35457668e-02f, 2.68067986e-01f, -8.27100947e-02f, 1.32588625e-01f, 2.71071434e-01f, 1.71959534e-01f, 5.33814169e-02f, 1.73188761e-01f,
  2.28453651e-02f, 2.22905144e-01f, 1.16310440e-01f, 1.02851130e-01f, 2.03729600e-01f, 1.11004733e-01f, 7.22367242e-02f, -1.77542660e-02f, 1.60245091e-01f, -1.32792279e-01f,
  8.77057537e-02f, -1.26627803e-01f, -1.15822859e-01f, -1.17364563e-01f, 1.06670365e-01f, 1.94126189e-01f, 2.33293194e-02f, 1.41740099e-01f, 1.27771750e-01f, 1.08975813e-01f,
  -3.23737785e-02f, -2.28503227e-01f, -6.06473722e-02f, -8.15415382e-02f, -9.53243300e-02f, 1.30449891e-01f, 2.44872138e-01f, 8.26739073e-02f, -5.58874458e-02f, -1.14320796e-02f,
  5.79695165e-01f, 4.20126110e-01f, -2.13445589e-01f, 2.34038174e-01f, 2.61082232e-01f, -1.73244715e-01f, 4.08915430e-02f, 3.19280803e-01f, -6.77916259e-02f, 2.06336945e-01f,
  2.15293139e-01f, 3.53982858e-02f, -6.01773225e-02f, 1.57843396e-01f, 2.52520710e-01f, -1.74388975e-01f, 1.06975123e-01f, 7.03444928e-02f, -1.13148034e-01f, -3.47821593e-01f,
  -1.64974660e-01f, -2.68293232e-01f, 3.99730891e-01f, -3.25526357e-01f, -4.65062708e-01f, -2.32451901e-01f, 1.60632417e-01f, 2.40881220e-02f, -1.26936913e-01f, -3.34348530e-02f,
  1.09809697e-01f, 5.03695756e-02f, 1.38907701e-01f, -8.36757571e-02f, 2.34792665e-01f, 8.15681815e-02f, -1.50251845e-02f, -1.19507201e-02f, 1.42229721e-01f, 1.43737182e-01f,
  9.64030996e-02f, -9.95627120e-02f, 3.19607377e-01f, -8.28818753e-02f, 6.93664700e-02f, -1.23355791e-01f, 1.06650315e-01f, -2.57026494e-01f, 3.91411543e-01f, 2.47404903e-01f,
  9.18953046e-02f, 2.64827728e-01f, -6.60118088e-02f, 1.96439907e-01f, -1.20036408e-01f, -1.35233611e-01f, -7.78662562e-02f, -1.81554213e-01f, 1.55207530e-01f, 3.36556971e-01f,
  8.57209936e-02f, 2.33815759e-01f, 9.81896967e-02f, -9.80522707e-02f, 3.76924157e-01f, 2.53271699e-01f, 2.60201544e-01f, -2.73231473e-02f, 3.47472019e-02f, 1.49547115e-01f,
  1.92693144e-01f, 3.24043542e-01f, 2.40180835e-01f, 2.15502471e-01f, 1.11276835e-01f, -1.07251897e-01f, -2.17198044e-01f, -7.96222761e-02f, 2.23353967e-01f, -2.70660371e-01f,
  6.73857629e-01f, 1.19183637e-01f, 1.64090261e-01f, -2.17542708e-01f, -3.60779434e-01f, -2.18184968e-03f, 1.09283142e-01f, -1.00030288e-01f, -5.25560260e-01f, -5.69638908e-01f,
  1.20604947e-01f, -2.64151573e-01f, -4.52443250e-02f, -1.21374376e-01f, 2.00378209e-01f, 5.72591163e-02f, -4.48559746e-02f, 3.72965857e-02f, -7.69868819e-03f, 1.56335995e-01f,
  4.19250913e-02f, 6.70768619e-02f, -4.91953306e-02f, 1.36177495e-01f, -1.78486273e-01f, 1.40102729e-01f, -3.24816927e-02f, -1.45293564e-01f, 2.31930509e-01f, 1.58964530e-01f,
  -2.59209305e-01f, 1.99686289e-01f, -1.09383225e-01f, -1.93972424e-01f, -6.30981922e-02f, -3.29956599e-02f, 1.65189311e-01f, -2.15256900e-01f, 1.41996117e-02f, 2.99518287e-01f,
  7.52848461e-02f, 1.48919314e-01f, 3.38067055e-01f, -3.25792730e-01f, 4.89626437e-01f, -2.18400106e-01f, -3.40793170e-02f, 4.26708817e-01f, 1.25227019e-01f, 2.05621734e-01f,
  -1.05345830e-01f, 4.12354559e-01f, 9.52645242e-02f, 9.32167191e-03f, -1.81873441e-01f, 2.49984443e-01f, -1.92059383e-01f, 2.36057833e-01f, 2.98438556e-02f, 3.40537757e-01f,
  -4.25686128e-02f, 1.03064507e-01f, -3.66269052e-02f, 1.02417789e-01f, -3.80396336e-01f, 2.10161969e-01f, 6.46656156e-02f, -8.91784504e-02f, -3.51965078e-03f, 2.89760958e-02f,
  -7.67917139e-03f, -1.23983454e-02f, -1.06281571e-01f, 2.66766369e-01f, -1.57677531e-01f, 3.86398911e-01f, 7.55965933e-02f, 9.90429074e-02f, -1.85201652e-02f, 1.70956865e-01f,
  1.62231609e-01f, 2.50281423e-01f, 5.86828478e-02f, 2.06831411e-01f, 1.22330479e-01f, 2.83480734e-01f, 1.62236586e-01f, 2.94853151e-01f, -3.10369611e-01f, -7.49040470e-02f,
  -6.17974438e-03f, -1.71187773e-01f, 8.95064846e-02f, 1.13943473e-01f, -3.76842469e-02f, 2.54772864e-02f, -1.13117948e-01f, -3.28090519e-01f, 1.59593761e-01f, -2.96682119e-01f,
  1.95624575e-01f, 1.44607991e-01f, 1.42731592e-01f, -3.42645533e-02f, -3.22211869e-02f, 1.21926352e-01f, 1.77014396e-01f, 5.15994370e-01f, -2.52960205e-01f, 2.83385694e-01f,
  -4.24701087e-02f, 1.96332484e-01f, -4.75590110e-01f, -3.30011904e-01f, 2.21652418e-01f, -5.23514040e-02f, -5.36103593e-03f, 2.74478078e-01f, 1.23359174e-01f, -1.68872863e-01f,
  1.55068964e-01f, 1.04524426e-01f, -4.98754643e-02f, 2.08693400e-01f, 3.96875858e-01f, -2.39455514e-02f, 8.81763622e-02f, -5.54696359e-02f, 2.91022390e-01f, 6.14074729e-02f,
  -9.58509296e-02f, 2.37091213e-01f, 3.94832231e-02f, 4.77083921e-02f, -3.89602780e-01f, 1.47864878e-01f, 2.48004779e-01f, 1.49537399e-01f, -1.13670416e-01f, -9.98996422e-02f,
  1.40710965e-01f, 2.39539593e-01f, 2.19644040e-01f, 4.89379540e-02f, 3.31093520e-02f, 2.37120345e-01f, 2.52436817e-01f, 2.86599457e-01f, 3.00446212e-01f, 2.43360460e-01f,
  1.05113171e-01f, 2.92449832e-01f, 6.20796755e-02f, 5.96640185e-02f, 3.09600145e-01f, 2.83588395e-02f, -1.53661355e-01f, -1.24295041e-01f, -8.23883265e-02f, -2.63874084e-01f,
  8.21719225e-03f, -1.26316771e-01f, -1.06158733e-01f, -1.42596602e-01f, -1.10645771e-01f, 2.55419314e-01f, 1.04403235e-01f, -8.10138062e-02f, -3.53171945e-01f, 2.02981204e-01f,
  1.77988246e-01f, 1.32242888e-01f, 2.95930952e-01f, -1.66077539e-01f, 2.42194161e-01f, 3.36961262e-03f, 1.69773385e-01f, 2.20052347e-01f, -9.59915202e-03f, 3.07332635e-01f,
  3.08757067e-01f, 1.01666242e-01f, 5.47211543e-02f, 2.03721210e-01f, 4.14550789e-02f, 2.64197707e-01f, 8.67213532e-02f, 5.33150993e-02f, -4.43593040e-03f, -1.38926312e-01f,
  2.61984110e-01f, -1.90051734e-01f, -1.57770962e-01f, -2.85701659e-02f, 8.95293504e-02f, 6.59733266e-02f, 8.71200338e-02f, -7.07994998e-02f, 1.98162086e-02f, -1.95355773e-01f,
  -1.19311586e-01f, 5.91127723e-02f, 3.08508817e-02f, -6.75318241e-02f, 1.06043287e-01f, 7.71098733e-02f, 1.89090520e-01f, 1.26595318e-01f, 1.90166593e-01f, 8.60801488e-02f,
  -1.65536687e-01f, 8.28093663e-02f, -7.84163177e-03f, 9.79782194e-02f, 5.58373779e-02f, 1.93632945e-01f, 1.07690305e-01f, -1.93636820e-01f, 1.31729826e-01f, 1.48472875e-01f,
  -8.35178122e-02f, 1.96371034e-01f, -3.29091996e-02f, 2.84989804e-01f, 3.08942467e-01f, 8.77916068e-02f, 3.87413055e-01f, 4.60365832e-01f, 4.59243357e-02f, 1.48745805e-01f,
  3.06549102e-01f, -3.07133850e-02f, 1.57554537e-01f, 3.43335778e-01f, -3.66385311e-01f, 3.66559803e-01f, -1.69914186e-01f, 4.46432643e-03f, 1.51328951e-01f, 1.43671945e-01f,
  1.30598754e-01f, -6.96971780e-03f, 4.43644285e-01f, -2.00270474e-01f, 1.24211498e-02f, 5.15724421e-01f, 1.07101277e-01f, -1.86971620e-01f, 1.24838933e-01f, -1.63091913e-01f,
  9.47744399e-02f, -4.53923851e-01f, 1.29702061e-01f, 2.99032368e-02f, -8.06535687e-03f, -1.13111198e-01f, 2.94386715e-01f, -1.05860442e-01f, -9.82219949e-02f, -1.40111476e-01f,
  -2.07686678e-01f, 3.32557380e-01f, 4.22297508e-01f, -1.01357475e-01f, 2.99237855e-02f, -9.50738713e-02f, -5.74881062e-02f, 1.16436437e-01f, 1.98825940e-01f, -6.03484102e-02f,
  -1.25388190e-01f, 1.47740424e-01f, 1.29277498e-01f, 2.17638522e-01f, -7.05705583e-02f, 1.07062779e-01f, 2.07173042e-02f, 6.74887970e-02f, 1.83397621e-01f, 1.19930297e-01f,
  -3.00650477e-01f, 1.29566386e-01f, -3.74191888e-02f, -6.76432997e-02f, 1.46053731e-01f, 6.67312182e-03f, -2.66842157e-01f, -1.08141750e-01f, -1.35494187e-01f, -2.59832054e-01f,
  -6.81448430e-02f, -1.82765454e-01f, 1.36190310e-01f, -2.98695862e-01f, 5.59680089e-02f, -1.26130227e-02f, -2.80055016e-01f, 2.15819672e-01f, 3.33753884e-01f, -2.93646425e-01f,
  -3.89331549e-01f, -4.37374622e-01f, 1.67351705e-03f, -1.96237504e-01f, -4.35974628e-01f, -5.36061108e-01f, -1.91512376e-01f, 4.62709107e-02f, -5.40846437e-02f, -5.09031266e-02f,
  -1.41303852e-01f, -1.30054653e-01f, 6.56088674e-03f, 1.45415336e-01f, -1.34302452e-01f, 5.63923001e-01f, 2.25726783e-01f, -4.07860428e-02f, -7.55966082e-02f, 2.88777594e-02f,
  -1.77259028e-01f, 2.37231076e-01f, -1.28284827e-01f, 5.67258656e-01f, -1.49641812e-01f, -2.32369184e-01f, -3.84038657e-01f, 2.09005222e-01f, -9.91967320e-02f, -7.48903165e-03f,
  2.41900817e-01f, 7.03747384e-03f, 2.34820440e-01f, 1.98746324e-02f, -5.60818464e-02f, 3.53232473e-02f, 1.03897132e-01f, 5.19403517e-02f, -1.44363508e-01f, 9.87607613e-02f,
  1.19101815e-01f, 2.07847089e-01f, 1.77449137e-01f, 2.91401446e-01f, 9.87228081e-02f, 5.52957281e-02f, 3.30079079e-01f, 4.12669778e-02f, -2.60738045e-01f, -1.50574580e-01f,
  -7.98794702e-02f, -4.88362834e-02f, 5.44540919e-02f, 9.20410752e-02f, 7.42554069e-02f, -2.65355855e-01f, 7.59696290e-02f, 1.26510039e-01f, 1.31274760e-01f, 2.05417931e-01f,
  1.37617826e-01f, 1.61994234e-01f, 1.32832870e-01f, 4.59414482e-01f, 2.08006367e-01f, -1.28626809e-01f, 2.00686250e-02f, 3.07279855e-01f, -1.79935526e-02f, 5.02903044e-01f,
  1.71572477e-01f, 1.01779982e-01f, -2.69385614e-02f, 3.45729649e-01f, 1.90438375e-01f, 3.31770599e-01f, 1.32511556e-01f, 2.40815312e-01f, -6.28977790e-02f, -4.97413486e-01f,
  -4.84134592e-02f, 7.03466833e-02f, 3.61749351e-01f, 1.22240342e-01f, 1.21897385e-02f, -8.22269171e-02f, 2.17838719e-01f, -3.00552994e-01f, -3.06769293e-02f, 3.36829841e-01f,
  -5.68609416e-01f, 1.38925880e-01f, 1.35650501e-01f, 2.36325324e-01f, 2.56892383e-01f, 2.29753435e-01f, 1.13656536e-01f, 1.06907405e-01f, 1.61400005e-01f, -5.67826554e-02f,
  1.21582069e-01f, 2.98682936e-02f, 1.34439781e-01f, 1.26465663e-01f, 1.93813980e-01f, 3.71896215e-02f, -1.34981293e-02f, 1.88707054e-01f, -9.72011406e-03f, 2.41606623e-01f,
  1.46784037e-01f, 1.77329838e-01f, 6.36800155e-02f, -2.03668132e-01f, -2.29815915e-01f, -1.49184152e-01f, 2.07526162e-01f, 3.45966995e-01f, -2.06634492e-01f, 1.12324834e-01f,
  2.49736775e-02f, -3.90646756e-02f, 2.24394687e-02f, 7.20061883e-02f, 1.56119704e-01f, 2.56299704e-01f, 1.20322011e-01f, -1.57165512e-01f, 3.33001375e-01f, -5.02303941e-03f,
  3.75022560e-01f, -2.49852777e-01f, 4.00869489e-01f, 4.90672678e-01f, -4.96666253e-01f, 3.08383495e-01f, 3.79230887e-01f, -4.47841495e-01f, 9.90628749e-02f, 1.16256796e-01f,
  1.76857244e-02f, 2.23812953e-01f, -1.28275469e-01f, -2.51178324e-01f, -7.98110366e-02f, -1.08557619e-01f, 3.30242813e-01f, 1.42016873e-01f, -3.04484963e-01f, 1.23505801e-01f,
  2.90107399e-01f, 1.15396634e-01f, 8.48221853e-02f, 9.73716378e-02f, 2.08601132e-01f, -9.87958256e-03f, -9.69945118e-02f, -1.59778774e-01f, 3.82921308e-01f, -1.89431775e-02f,
  3.19346711e-02f, -3.28295119e-02f, -6.19132333e-02f, 1.85564421e-02f, 1.70474976e-01f, 8.62037912e-02f, 1.95840791e-01f, 1.42460957e-01f, 1.03300154e-01f, 9.26098749e-02f,
  -8.96938145e-03f, 1.15921795e-01f, 7.42770685e-03f, 1.20418957e-02f, -1.46369621e-01f, -8.66533890e-02f, 2.55558848e-01f, 2.16982186e-01f, -1.66750774e-02f, -1.98257849e-01f,
  -2.54075259e-01f, -1.75801575e-01f, -2.10862204e-01f, -1.52621552e-01f, 5.86770624e-02f, -2.15219796e-01f, 2.50178743e-02f, 2.93106079e-01f, 6.98070228e-02f, -1.25397205e-01f,
  4.41586941e-01f, -3.53836447e-01f, 2.62267381e-01f, 8.18027481e-02f, 2.56100416e-01f, 8.48095771e-03f, -2.08215535e-01f, -3.02512646e-01f, -1.23536848e-01f, 2.96649426e-01f,
  2.14199930e-01f, -2.00478673e-01f, -1.51616022e-01f, -6.43264130e-02f, -3.51207107e-01f, -6.56360537e-02f, 1.56348571e-01f, 6.88946545e-01f, 2.50940770e-01f, 1.48494437e-01f,
  -1.25535429e-01f, -1.14162870e-01f, 1.61525443e-01f, 8.32523406e-02f, 9.92794558e-02f, 5.48836052e-01f, 7.66494274e-02f, -2.26906180e-01f, 1.41909003e-01f, -4.74192463e-02f,
  2.03007013e-02f, 7.65487477e-02f, -1.17857195e-01f, -4.06932719e-02f, 1.95378065e-02f, 2.15467200e-01f, 1.88158467e-01f, 8.18461999e-02f, 2.14076191e-01f, 1.54307242e-02f,
  6.56977966e-02f, 1.18443124e-01f, 7.52363950e-02f, 6.00559525e-02f, 1.72474936e-01f, 2.54586637e-01f, 1.68874599e-02f, -1.36129037e-01f, -1.77266836e-01f, 1.79760233e-01f,
  -9.43353176e-02f, 1.33199960e-01f, 1.28261194e-01f, 2.75807858e-01f, 1.23846553e-01f, 1.46479681e-01f, 3.40512842e-01f, 2.48944238e-01f, 4.77439314e-02f, 2.99335629e-01f,
  2.24656776e-01f, 1.04888976e-01f, 4.10647452e-01f, 1.45779461e-01f, -4.57085639e-01f, 2.60333329e-01f, -3.10103744e-01f, 3.38414758e-01f, -1.72158897e-01f, 1.47714466e-01f,
  8.44862591e-03f, -1.58934042e-01f, 2.51159877e-01f, -2.70644903e-01f, -8.48319829e-02f, 3.47715355e-02f, -7.52393249e-03f, 2.24734053e-01f, 9.09939855e-02f, -6.44963235e-02f,
  1.43466070e-01f, -5.49156547e-01f, 2.15707690e-01f, -2.61150599e-02f, 9.34979096e-02f, -1.53885767e-01f, 6.29134417e-01f, -1.82150397e-02f, -1.46420196e-01f, -2.48295143e-01f,
  7.45286793e-02f, 1.57237127e-01f, -7.15488791e-02f, -1.60209835e-01f, 2.47901395e-01f, -5.95818497e-02f, 3.07117309e-02f, 4.38291505e-02f, 1.73675790e-01f, 2.47529790e-01f,
  1.23273768e-01f, 1.89837828e-01f, 5.74271530e-02f, 3.12427759e-01f, 1.42325789e-01f, 3.15887868e-01f, 1.87389463e-01f, 7.69156814e-02f, 8.48188326e-02f, 5.48227690e-02f,
  -2.59638697e-01f, 2.39881948e-02f, -4.17576581e-01f, -1.39896482e-01f, -1.61655918e-01f, 2.69091100e-01f, 2.97924709e-02f, -8.05719569e-02f, -3.12932998e-01f, -4.28797275e-01f,
  4.19943258e-02f, -3.21626574e-01f, -1.10000838e-02f, 1.92181736e-01f, -5.04955240e-02f, -4.04178305e-03f, 2.88051832e-03f, -3.30737919e-01f, -1.59154832e-02f, 9.86879617e-02f,
  5.55938222e-02f, 1.86366126e-01f, 5.91525957e-02f, 2.64489979e-01f, 5.84573075e-02f, 3.25933620e-02f, 5.36986589e-02f, 2.01084152e-01f, 5.18572144e-02f, -9.43936314e-03f,
  -6.40430450e-02f, -1.25486210e-01f, -1.04371935e-01f, 2.51317993e-02f, -9.91771966e-02f, 4.04908299e-01f, 3.32370400e-01f, 2.44954415e-03f, -3.19311209e-02f, -3.88320908e-02f,
  -3.89286429e-01f, 2.03480884e-01f, 6.35585710e-02f, 2.30469257e-01f, 3.50218475e-01f, 1.58363536e-01f, 3.52924705e-01f, -1.35374263e-01f, 2.30928566e-02f, 1.23408645e-01f,
  -3.60411435e-01f, 8.51462223e-03f, 2.49539733e-01f, 2.40953788e-01f, 2.13617340e-01f, 4.45501991e-02f, 1.96259692e-01f, 1.36584103e-01f, 4.31658775e-02f, 2.87929595e-01f,
  1.46823689e-01f, 7.77660981e-02f, 2.91576087e-01f, 3.24764550e-01f, -1.54893130e-01f, -1.13540739e-02f, -2.50593215e-01f, 2.93473862e-02f, 9.88065824e-02f, 1.50000378e-01f,
  4.49792854e-02f, -1.58742607e-01f, -6.91650808e-02f, -3.06847185e-01f, 1.43250585e-01f, -2.16265112e-01f, 1.70832127e-01f, 1.36495352e-01f, 1.24530087e-03f, 7.58849010e-02f,
  9.95805934e-02f, 3.10093872e-02f, 1.14796624e-01f, 1.85602739e-01f, -3.38026851e-01f, 2.58517742e-01f, -1.72968864e-01f, 9.40226391e-02f, -1.09646149e-01f, -2.12923452e-01f,
  1.37823790e-01f, -8.35521892e-02f, -1.77876204e-01f, -6.41619181e-03f, -1.93309665e-01f, -3.12012404e-01f, -1.96019739e-01f, 2.57882416e-01f, -1.02749191e-01f, 3.92587423e-01f,
  4.50486511e-01f, 9.28881839e-02f, -2.60016561e-01f, -2.24903047e-01f, 3.88226241e-01f, -5.69767989e-02f, -2.63925701e-01f, 1.31564885e-01f, 1.23880759e-01f, -1.05351523e-01f,
  -5.94543219e-02f, -8.04319233e-02f, 2.13196769e-01f, -8.06061029e-02f, 3.03920414e-02f, -7.60256648e-02f, 4.58166040e-02f, 1.56121910e-01f, -1.60707925e-02f, 9.42797288e-02f,
  7.19549805e-02f, -6.10309616e-02f, 9.91315991e-02f, -3.95183377e-02f, 1.74043313e-01f, 9.00415406e-02f, 7.63961393e-03f, 2.76130289e-01f, 2.58902926e-02f, -1.27335832e-01f,
  3.61899048e-01f, 6.84631169e-02f, -3.12300354e-01f, 1.74337491e-01f, 2.46172175e-01f, -1.94112286e-01f, 2.69717008e-01f, -8.95785764e-02f, 3.13831121e-01f, -1.16575174e-01f,
  9.74162072e-02f, -4.47961651e-02f, 1.70967832e-01f, 1.23655930e-01f, 4.20440994e-02f, 2.00740770e-01f, 5.52561358e-02f, 2.33400375e-01f, 2.61120945e-01f, -1.47364840e-01f,
  2.90874969e-02f, 1.75545916e-01f, -1.13513961e-01f, 2.21570909e-01f, 2.36499324e-01f, -9.88101214e-02f, 4.69465666e-02f, 4.34746772e-01f, 1.89328581e-01f, 1.43296212e-01f,
  -1.10293359e-01f, 2.67910868e-01f, 2.28539370e-02f, -8.65719318e-02f, 3.45821492e-03f, 9.16949511e-02f, -2.48079494e-01f, -9.35852826e-02f, 3.39549094e-01f, -2.57662416e-01f,
  2.12808445e-01f, -1.78403214e-01f, -7.82882888e-03f, 1.02821849e-01f, -2.80442804e-01f, -1.20369315e-01f, 2.25270707e-02f, 9.16074589e-02f, -6.21968023e-02f, 7.89913982e-02f,
  2.61111498e-01f, -1.54772578e-02f, 3.01644713e-01f, 1.85960397e-01f, 9.90670845e-02f, 3.44340533e-01f, -1.74467340e-01f, 2.34078124e-01f, 1.54540405e-01f, 4.77615222e-02f,
  -1.09788561e-02f, 1.55342728e-01f, 6.07327521e-02f, 7.53407925e-02f, 2.53078286e-02f, -1.23669505e-01f, -8.60569403e-02f, -9.19497833e-02f, -1.50964968e-02f, 2.93976158e-01f,
  -1.17521226e-01f, 5.04969321e-02f, -1.60641775e-01f, -4.23418909e-01f, 1.13359377e-01f, 4.33051176e-02f, -3.76860090e-02f, 5.96144572e-02f, 3.26254100e-01f, -2.61807442e-01f,
  9.08187181e-02f, -3.28792296e-02f, 3.41006219e-01f, -3.78769636e-01f, 6.88349307e-02f, 1.52432188e-01f, 3.74035090e-02f, 6.47106647e-01f, -2.08523050e-01f, 1.85787350e-01f,
  -2.55380310e-02f, 1.70983374e-02f, -9.02502835e-02f, 2.98784643e-01f, -9.52475592e-02f, 3.47998232e-01f, -1.64257690e-01f, -8.54887515e-02f, -2.19072670e-01f, -1.58561170e-01f,
  1.38734832e-01f, 2.54613489e-01f, -5.87180436e-01f, 1.88559934e-01f, 1.29412994e-01f, -1.41455367e-01f, 3.74029815e-01f, 5.02116442e-01f, -1.75408825e-01f, -9.25329402e-02f,
  -3.07652146e-01f, 1.98878661e-01f, 1.57084078e-01f, 3.65785211e-01f, 1.90786108e-01f, 8.16847384e-02f, 2.13853106e-01f, 4.04670238e-02f, 1.15217157e-01f, 2.79035926e-01f,
  -7.31606409e-02f, 6.72623441e-02f, 1.30359292e-01f, 1.12639867e-01f, 2.31929481e-01f, 1.48844659e-01f, -1.34905666e-01f, 9.24568549e-02f, 1.88559443e-01f, -7.87426624e-03f,
  1.20727569e-01f, -1.28340453e-01f, -2.81610221e-01f, -3.28173220e-01f, 8.85774344e-02f, -5.41392379e-02f, -6.44118786e-02f, -3.35437685e-01f, 1.90898508e-01f, -1.64425403e-01f,
  -2.25366466e-02f, -7.11762346e-03f, -6.83629140e-02f, 1.96417525e-01f, 1.69486716e-01f, 1.87714994e-01f, -1.38473749e-01f, -1.83644712e-01f, -3.01052958e-01f, 1.34054497e-02f,
  2.04071090e-01f, 3.14854562e-01f, -1.55075669e-01f, 1.65928647e-01f, -2.72558063e-01f, -1.08984504e-02f, -1.01166882e-01f, 2.87990153e-01f, 8.91258791e-02f, 3.68356138e-01f,
  -5.96739240e-02f, 5.36314487e-01f, 1.37635738e-01f, 5.98239824e-02f, 1.96338952e-01f, 2.55070776e-02f, -4.15261388e-01f, 1.47824168e-01f, -2.97223121e-01f, 1.22024991e-01f,
  -8.79856125e-02f, -8.97840261e-02f, -3.10819056e-02f, 1.70463640e-02f, -1.48070425e-01f, -5.03480136e-02f, 4.02752489e-01f, 5.60132563e-02f, -1.88474897e-02f, -1.20395720e-01f,
  1.53261110e-01f, -5.89204803e-02f, 2.34782875e-01f, 1.10785682e-02f, 1.45043477e-01f, 3.88354622e-02f, 6.18797690e-02f, 1.22153163e-01f, -8.43852907e-02f, 3.80701683e-02f,
  5.16124116e-03f, -5.84669784e-02f, -1.81833014e-01f, 3.13897192e-01f, 4.85775843e-02f, -3.82827371e-02f, -1.15885092e-02f, 1.44114554e-01f, 3.89284417e-02f, 1.56445906e-01f,
  -1.57280713e-01f, 2.46323094e-01f, 6.72442764e-02f, -1.24165393e-01f, -2.30982471e-02f, 2.75346637e-01f, 3.75158638e-01f, -2.45805085e-01f, -7.71573335e-02f, -2.31528267e-01f,
  1.32578596e-01f, 1.95196062e-01f, 3.55915517e-01f, 1.22978143e-01f, 8.59973058e-02f, -3.64675000e-02f, -5.01559163e-03f, 2.69375797e-02f, 1.26955435e-01f, -2.45263919e-01f,
  -2.88701896e-02f, 2.94399947e-01f, -1.24173090e-01f, -1.57137990e-01f, -4.68516648e-02f, -1.52260035e-01f, -9.03976411e-02f, 1.52483076e-01f, -1.11582927e-01f, 2.16532081e-01f,
  4.60511655e-01f, 4.14242268e-01f, 3.04874927e-01f, 1.68183655e-01f, 1.94561735e-01f, -1.06424861e-01f, 3.61465722e-01f, -1.86845094e-01f, 1.17183395e-01f, 2.41285115e-01f,
  -7.77466744e-02f, 1.45179987e-01f, 4.69289348e-02f, -1.77776497e-02f, 6.20300137e-02f, -6.48727044e-02f, 1.67436227e-01f, 1.87061340e-01f, 6.08615018e-02f, 2.75149763e-01f,
  2.61683106e-01f, 1.10544182e-01f, 1.60797432e-01f, 3.58962744e-01f, -2.57107198e-01f, -6.32086843e-02f, -4.76839721e-01f, 4.31442522e-02f, 3.41910906e-02f, -1.94504634e-01f,
  1.58710063e-01f, 4.08113867e-01f, -2.12600753e-01f, 2.90985197e-01f, -1.74455777e-01f, 2.05420062e-01f, 2.70856619e-01f, -7.47333318e-02f, -1.84815943e-01f, 1.90551832e-01f,
  6.39337361e-01f, -1.26244992e-01f, -4.91416678e-02f, -6.14529788e-01f, -1.19754672e-01f, 4.80876446e-01f, 5.43749519e-02f, 7.51109421e-02f, -6.57568872e-02f, 1.12652436e-01f,
  2.94200126e-02f, -1.55950159e-01f, -1.28348827e-01f, -5.98002076e-01f, -2.49804169e-01f, 1.15063846e-01f, 7.25492239e-02f, -1.37702152e-01f, 1.52104516e-02f, 2.33256817e-01f,
  3.10962737e-01f, -2.03366250e-01f, -1.91151217e-01f, 3.08448188e-02f, 4.20850933e-01f, 3.70660156e-01f, 3.03149283e-01f, 3.54684740e-01f, 4.30124015e-01f, 1.41365811e-01f,
  3.03193480e-01f, -2.32422844e-01f, 3.08483411e-02f, -6.20847717e-02f, 1.99824557e-01f, 2.91565865e-01f, 2.62821794e-01f, 1.77158654e-01f, -1.28841728e-01f, 5.43428101e-02f,
  3.32877427e-01f, 2.83563845e-02f, 2.60620832e-01f, 4.31550480e-02f, 1.06884971e-01f, 1.71215773e-01f, 2.72712320e-01f, 1.69348836e-01f, 1.00741975e-01f, -8.21859092e-02f,
  2.32642546e-01f, -1.21540548e-02f, 2.09602416e-01f, -2.56150573e-01f, -1.81905944e-02f, -3.31384361e-01f, 8.56806785e-02f, 2.30406612e-01f, 2.42822450e-02f, -1.65339522e-02f,
  -1.35002181e-01f, -2.21373945e-01f, 2.62063947e-02f, -3.34931433e-01f, -5.54314032e-02f, 1.84015691e-01f, 2.79356211e-01f, -3.53088230e-01f, 1.50715083e-01f, -2.18523845e-01f,
  2.29693681e-01f, -2.44379520e-01f, -1.41866878e-01f, -2.05678359e-01f, -2.51334965e-01f, 1.65089741e-01f, 5.09203225e-02f, -3.10948461e-01f, 7.66170174e-02f, 2.25487113e-01f,
  2.05076276e-03f, -5.19561470e-02f, -6.93236515e-02f, 2.08188310e-01f, 2.40949675e-01f, 1.22930110e-02f, 1.44469067e-01f, -7.61162350e-03f, 4.50691342e-01f, 3.29974264e-01f,
  1.46331102e-01f, 4.50194657e-01f, 9.44402907e-03f, -1.48037151e-01f, -4.94285896e-02f, 1.72456965e-01f, 1.24785967e-01f, -3.90234053e-01f, 4.31329936e-01f, -2.24180311e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  9.81708914e-02f, 2.69952655e-01f, 4.38232236e-02f, 8.72727260e-02f, 1.28168866e-01f, 2.33314484e-01f, 3.35296661e-01f, 1.11441128e-01f, 1.95584849e-01f, 3.26702565e-01f,
  1.95086688e-01f, 3.44036967e-01f, 1.20594434e-01f, 2.47438908e-01f, 1.16688281e-01f, 2.84016371e-01f, 2.85951972e-01f, 9.92429629e-02f, 4.94113863e-02f, 2.61068404e-01f,
  4.13562134e-02f, 1.41917557e-01f, -9.27000958e-03f, 1.02932885e-01f, 1.23625159e-01f, 2.94280440e-01f, 1.03815749e-01f, 2.12839335e-01f, 2.10105702e-01f, 2.22762242e-01f,
  1.93200737e-01f, 1.84687585e-01f, 2.26359382e-01f, 2.86647797e-01f, 3.00520211e-01f, 8.59489515e-02f, 2.36141235e-01f, 7.23890290e-02f, 1.82051212e-01f, 3.08616698e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  8.71031061e-02f, -1.52113512e-01f, 2.18239814e-01f, 1.85596451e-01f, -2.76632644e-02f, -2.28887632e-01f, -3.23180765e-01f, -6.19085319e-02f, 4.12471406e-02f, 4.51008491e-02f,
  -7.83448741e-02f, -3.46807152e-01f, 2.96490192e-01f, 1.98899522e-01f, -2.93489724e-01f, -1.83180913e-01f, 7.50287101e-02f, 3.73452634e-01f, -6.55012429e-02f, 9.20455828e-02f,
  4.77753103e-01f, -2.58966655e-01f, 1.91525579e-03f, 8.09449330e-02f, 2.15843543e-01f, -4.10968870e-01f, 2.61601120e-01f, -4.03465509e-01f, 2.13960513e-01f, 3.88593562e-02f,
  -5.04511833e-01f, -1.17129289e-01f, 3.50751616e-02f, 2.24385321e-01f, -4.04214233e-01f, -1.46411076e-01f, 9.40443575e-02f, 1.97598994e-01f, 1.41007558e-01f, -2.75256157e-01f,
  -3.04656446e-01f, 3.38853836e-01f, -6.49893954e-02f, -1.94746301e-01f, -2.73279965e-01f, 2.02171817e-01f, 2.41159633e-01f, -6.15197897e-01f, -1.28786728e-01f, 3.50259990e-02f,
  2.37060666e-01f, 1.39628768e-01f, -1.48434341e-01f, 1.36518747e-01f, -4.44015861e-01f, 5.77832200e-02f, -2.98163854e-02f, -2.86635131e-01f, -1.48758024e-01f, -2.19199359e-01f,
  -1.71639860e-01f, 4.80136685e-02f, -3.49014908e-01f, -3.58484000e-01f, 1.99289303e-02f, 3.12828720e-01f, 1.03548460e-01f, 3.69552448e-02f, 2.70693898e-01f, -3.74115378e-01f,
  -1.63373232e-01f, 2.18651786e-01f, -4.81788553e-02f, -9.99876037e-02f, -2.59065956e-01f, -1.11894369e-01f, 3.91706318e-01f, -2.16128200e-01f, 3.91924262e-01f, 1.75448749e-02f,
  -4.08381373e-01f, 1.13709634e-02f, 3.75795037e-01f, 5.62213957e-02f, 3.69685031e-02f, -2.79142022e-01f, 2.22236574e-01f, -2.91078482e-02f, 1.89852104e-01f, 2.35767633e-01f,
  1.29263669e-01f, -2.23605156e-01f, -1.95352688e-01f, 1.49047464e-01f, 8.64634067e-02f, 4.01566118e-01f, -5.11439025e-01f, -1.74681038e-01f, -4.30211902e-01f, -4.06925291e-01f,
  -9.97067988e-02f, 2.24660128e-01f, 6.38693571e-02f, -8.97588655e-02f, -6.38814569e-01f, -3.72312427e-01f, 1.98659673e-01f, -9.77424830e-02f, -1.09988540e-01f, -2.82985985e-01f,
  3.76331717e-01f, 1.26739323e-01f, 1.33205235e-01f, -1.02623224e-01f, 4.17327970e-01f, -1.32891804e-01f, 1.19405575e-01f, -5.28522372e-01f, -1.24778517e-01f, 2.44461730e-01f,
  -2.37802982e-01f, -8.08104593e-03f, 2.83106774e-01f, -4.81749594e-01f, -1.22013070e-01f, -2.71469094e-02f, -6.11975849e-01f, -3.54581416e-01f, -1.46029130e-01f, -5.30767292e-02f,
  -1.14106745e-01f, -9.12934542e-03f, 1.53621528e-02f, 3.11770320e-01f, 1.45172393e-02f, 7.87295997e-02f, -1.09799206e-02f, 7.32794777e-02f, -7.96038136e-02f, 2.85446048e-01f,
  4.66717929e-01f, 1.87703058e-01f, -4.43636745e-01f, -3.54299992e-01f, -9.97662023e-02f, 6.16503432e-02f, -6.07861148e-04f, 3.65204692e-01f, -1.57784581e-01f, 3.77771765e-01f,
  -3.11198860e-01f, -2.73920506e-01f, -2.11701170e-01f, -3.05066928e-02f, -1.46466821e-01f, -1.28762886e-01f, 1.21975578e-01f, 2.78645098e-01f, -4.42541897e-01f, 1.96920618e-01f,
  3.23141855e-03f, -8.04419219e-02f, 6.78989366e-02f, 4.00030196e-01f, -1.79333165e-01f, 3.56924176e-01f, -9.24789533e-03f, -8.16387683e-03f, 1.53129578e-01f, 4.33847368e-01f,
  -8.68858919e-02f, 7.65297636e-02f, 1.23705640e-01f, 2.72817045e-01f, 2.05207333e-01f, -3.35696518e-01f, -1.40843421e-01f, -9.62860510e-02f, -1.84014230e-03f, -5.76708674e-01f,
  -1.98409677e-01f, -2.25160956e-01f, 2.43828278e-02f, 1.74312398e-01f, -1.08738817e-01f, -4.47442289e-03f, -1.94771048e-02f, -4.95153904e-01f, -3.27838622e-02f, 6.72381297e-02f,
  8.73735994e-02f, 2.46125013e-01f, -3.21565717e-01f, -1.62037775e-01f, 8.21047649e-02f, -9.10216942e-02f, 4.24174666e-02f, -6.83025718e-02f, -1.12440906e-01f, 4.33577821e-02f,
  -6.99888915e-03f, 8.76578838e-02f, 1.52966157e-01f, 3.08805436e-01f, -5.27638607e-02f, -2.17046626e-02f, -1.51716673e-03f, -1.98835343e-01f, -3.40322666e-02f, -1.00804485e-01f,
  -1.20076500e-01f, -3.10654491e-01f, 2.48534046e-02f, 1.32245585e-01f, 1.36384964e-01f, -2.43578907e-02f, 2.37006620e-01f, -1.28906354e-01f, -6.03706837e-02f, 2.35618040e-01f,
  -2.39005789e-01f, -4.23418760e-01f, -3.68013501e-01f, -2.26176262e-01f, 1.74050942e-01f, -4.87330437e-01f, -7.80001879e-01f, 3.54048640e-01f, 1.54973147e-02f, -5.11147022e-01f,
  2.66667724e-01f, 5.05392998e-02f, 2.74005413e-01f, -4.49300200e-01f, 2.52938628e-01f, -2.86250323e-01f, 2.18821317e-01f, -1.04012467e-01f, -1.84107542e-01f, -8.68449453e-03f,
  -2.79731870e-01f, 1.12812757e-01f, -1.70286685e-01f, -2.19230652e-01f, -7.43490815e-01f, 6.96776584e-02f, 2.68633544e-01f, -1.30653739e-01f, 2.72175997e-01f, -1.57805786e-01f,
  -5.21727979e-01f, -1.33915693e-02f, -2.53627300e-01f, 2.25284442e-01f, 2.70194083e-01f, 6.12374283e-02f, 1.44115403e-01f, -1.62007138e-01f, 1.53144225e-01f, -1.44264117e-01f,
  -1.70212507e-01f, 3.75296444e-01f, 4.08873796e-01f, 1.10336632e-01f, -1.90177821e-02f, 1.73198223e-01f, 3.48908961e-01f, -1.09022863e-01f, -2.13620842e-01f, -2.51651585e-01f,
  -3.03170085e-01f, 1.83268309e-01f, 1.72583640e-01f, -4.14296776e-01f, 1.25255555e-01f, -8.96165818e-02f, -5.13005078e-01f, 3.97884160e-01f, 4.63846236e-01f, 3.38887334e-01f,
  8.08417201e-02f, -1.63333431e-01f, 1.15983017e-01f, 2.46545404e-01f, 9.35771540e-02f, -2.64242828e-01f, 2.73463935e-01f, -2.69661456e-01f, -7.20720887e-02f, 2.98255444e-01f,
  -2.25720424e-02f, -1.49442852e-02f, 2.29387190e-02f, -2.34203950e-01f, -2.70052522e-01f, -9.79437530e-02f, 4.58045229e-02f, 1.47076443e-01f, -3.12086672e-01f, -5.54403961e-01f,
  1.90641016e-01f, -6.94471896e-02f, 1.75526366e-01f, -3.48484814e-02f, -1.19754180e-01f, 1.17656581e-01f, -3.83688629e-01f, -1.01747200e-01f, 2.06558220e-03f, 1.10528491e-01f,
  1.99422136e-01f, -6.46522790e-02f, -2.35353589e-01f, -4.00173366e-02f, 2.13372856e-01f, -1.58988461e-01f, -4.22344714e-01f, 1.17802963e-01f, -1.56310081e-01f, 3.46173674e-01f,
  2.74153143e-01f, 1.23137735e-01f, -2.01001778e-01f, 3.29946727e-01f, -1.05912559e-01f, 2.59221524e-01f, 4.41015065e-01f, -1.83621645e-01f, 6.26719519e-02f, 1.96102396e-01f,
  -2.99240425e-02f, -1.68373168e-01f, -1.93998963e-01f, 1.93007872e-01f, 2.68950135e-01f, 2.39186987e-01f, 1.49601594e-01f, 4.33284104e-01f, -3.01324457e-01f, -4.26457971e-01f,
  4.07909840e-01f, -2.67708868e-01f, 3.73380363e-01f, 3.46058339e-01f, -1.33438319e-01f, 8.56976286e-02f, 5.43137975e-02f, -5.24193764e-01f, -7.34811574e-02f, -1.92069918e-01f,
  1.16200157e-01f, -3.07428479e-01f, -5.34029864e-02f, 4.06164899e-02f, 5.82162201e-01f, -5.46409488e-01f, 4.08170998e-01f, -2.55074680e-01f, 6.64043650e-02f, 3.01839739e-01f,
  4.43499863e-01f, -4.35976565e-01f, -2.76674658e-01f, -2.45318055e-01f, -5.24349332e-01f, -7.19184056e-02f, -2.41426066e-01f, -5.99746890e-02f, 1.94830909e-01f, 1.70619100e-01f,
  -9.77331027e-02f, -1.40609577e-01f, 1.81348950e-01f, -1.40304729e-01f, -3.28676403e-01f, -4.93561924e-02f, 3.76103789e-01f, 6.91670775e-02f, 1.33673325e-01f, 2.64936268e-01f,
  5.41685447e-02f, -2.14238420e-01f, -5.38581073e-01f, -5.28279603e-01f, 8.70933309e-02f, -3.74840170e-01f, -3.04706348e-03f, 1.88649148e-01f, 6.66972026e-02f, -1.43423408e-01f,
  -2.32862920e-01f, 1.74341500e-01f, -3.38144675e-02f, -1.49110844e-03f, -2.54157066e-01f, -2.03130037e-01f, 2.78587908e-01f, 1.20854072e-01f, -1.85614109e-01f, -1.07125841e-01f,
  -3.27713460e-01f, -1.52461201e-01f, -1.59823164e-01f, -3.14997911e-01f, -1.12558864e-01f, 6.05881736e-02f, -2.66191773e-02f, -2.24829242e-01f, -2.42036462e-01f, 2.49864236e-01f,
  -2.94911295e-01f, -7.66789243e-02f, -4.25821036e-01f, 3.65317881e-01f, 6.70930520e-02f, 3.51831466e-01f, -3.57594997e-01f, 2.05509871e-01f, 7.53166005e-02f, 6.24214597e-02f,
  -1.03900217e-01f, -1.49841785e-01f, -4.65866029e-01f, -4.06961292e-02f, 3.67069364e-01f, -2.98867617e-02f, -3.01850438e-01f, 2.05181926e-01f, -2.93493807e-01f, -4.07085001e-01f,
  -6.10166848e-01f, -2.84112871e-01f, 2.05432668e-01f, 2.61100717e-02f, -6.97304830e-02f, 4.04545456e-01f, -2.39085741e-02f, 1.31912455e-01f, -2.20932469e-01f, -2.44691715e-01f,
  -4.94307697e-01f, -6.64394498e-02f, -2.73660094e-01f, -3.69837046e-01f, 1.98470220e-01f, -2.18942851e-01f, -4.27970290e-01f, 3.94178838e-01f, 5.52355647e-02f, -2.10210189e-01f,
  -1.60179898e-01f, -1.37226477e-01f, -2.32161190e-02f, 7.65593499e-02f, -1.32147700e-01f, 1.01268493e-01f, 3.48694734e-02f, -1.67064345e-03f, -3.07072788e-01f, -1.19218878e-01f,
  -5.00360318e-02f, -3.87892090e-02f, -2.16832727e-01f, -3.24467778e-01f, 3.73538658e-02f, -7.50454292e-02f, -2.28795763e-02f, 8.01457837e-03f, -3.11052918e-01f, -3.46789688e-01f,
  -1.23578250e-01f, -9.47506875e-02f, -5.24035931e-01f, 8.65275785e-02f, -3.34874660e-01f, 4.79344845e-01f, -2.81564921e-01f, -4.07229573e-01f, 2.01566637e-01f, -1.80950031e-01f,
  3.19848269e-01f, -3.06726635e-01f, -3.59113038e-01f, -3.91522586e-01f, -2.72359520e-01f, -1.03749618e-01f, 4.85460320e-03f, -1.62307352e-01f, -3.66061300e-01f, 2.93892711e-01f,
  -2.53931105e-01f, -3.48340906e-02f, 4.72273916e-01f, -2.49627605e-01f, -8.77325684e-02f, 3.16110045e-01f, -1.63703542e-02f, -3.91074061e-01f, -3.44920486e-01f, 1.55022606e-01f,
  6.15407974e-02f, -1.26811907e-01f, 2.16227800e-01f, -3.19478840e-01f, 4.86464687e-02f, -2.61887342e-01f, -6.87236385e-03f, 3.55667859e-01f, 1.10183202e-01f, 2.64825583e-01f,
  2.59875298e-01f, -4.56235647e-01f, -1.16569765e-01f, 9.02280733e-02f, 5.16307019e-02f, -2.87554741e-01f, -1.51257977e-01f, 3.02027225e-01f, 9.35657546e-02f, -9.58389118e-02f,
  -1.75751120e-01f, 7.53069147e-02f, -7.80062079e-02f, 1.52028710e-01f, -2.12667316e-01f, 9.52881351e-02f, 1.86617464e-01f, 2.82965422e-01f, -1.88667715e-01f, -1.53487414e-01f,
  7.06894845e-02f, 1.99772954e-01f, 1.91521943e-01f, -1.66890934e-01f, -1.95527300e-01f, -9.58762616e-02f, -5.63172698e-01f, 2.36731127e-01f, -3.65584821e-01f, -1.86566003e-02f,
  -2.96915889e-01f, 4.01202291e-02f, -2.59093016e-01f, -2.80071080e-01f, -1.75189063e-01f, -3.38688701e-01f, 2.68286973e-01f, -3.05852771e-01f, -3.05944443e-01f, -2.78737336e-01f,
  2.23507226e-01f, -2.99785763e-01f, -6.71397448e-02f, 3.33428591e-01f, 2.70909399e-01f, -2.24223629e-01f, -3.48925769e-01f, -3.03052336e-01f, -2.39883915e-01f, -9.92712080e-02f,
  2.62064755e-01f, -4.05069590e-01f, 3.98858479e-04f, -2.22461477e-01f, -1.36078641e-01f, -2.32647479e-01f, 2.01005131e-01f, 3.61540467e-01f, 2.37849280e-01f, 3.56988162e-01f,
  -8.33011419e-02f, -4.50526178e-01f, -2.16290161e-01f, 1.62919253e-01f, 5.89418769e-01f, -2.61651099e-01f, -2.10456941e-02f, 1.87156007e-01f, 1.18262731e-01f, -3.48598599e-01f,
  -7.00759888e-02f, -1.63568005e-01f, -2.41299838e-01f, -1.09077215e-01f, -4.22788970e-02f, 6.25737607e-02f, 1.93628907e-01f, 9.91236269e-02f, -2.55841851e-01f, 2.00173438e-01f,
  7.15323463e-02f, 1.08960852e-01f, 5.53861558e-01f, -2.56105036e-01f, -2.61115313e-01f, 2.87361830e-01f, -1.76542491e-01f, -4.30655405e-02f, -2.75665551e-01f, 2.43260413e-02f,
  -6.76735520e-01f, -2.79716253e-01f, 6.47341684e-02f, 8.42787102e-02f, -2.16656793e-02f, -1.04791172e-01f, 9.02199447e-02f, 2.60576665e-01f, 2.37552375e-01f, 9.81773064e-02f,
  2.59883553e-01f, -1.12770915e-01f, -1.13191806e-01f, 6.88432530e-02f, -3.58150423e-01f, -4.56194341e-01f, -1.41702518e-02f, -4.24888402e-01f, -1.49670348e-01f, 1.97688952e-01f,
  -1.91480100e-01f, 3.28745306e-01f, 1.61076665e-01f, 8.18574056e-02f, -3.66085321e-01f, 2.12049767e-01f, -3.74484628e-01f, -2.62301326e-01f, 1.34247437e-01f, 3.34800690e-01f,
  -4.96599555e-01f, -1.95830137e-01f, -4.66886818e-01f, -4.40755546e-01f, -1.86930031e-01f, 3.27755511e-01f, 2.74878293e-01f, -2.76451379e-01f, -1.61775589e-01f, -7.84173235e-02f,
  6.79978430e-02f, 1.03149064e-01f, -6.75360858e-02f, 1.60102397e-01f, -2.33980313e-01f, -9.14883837e-02f, -1.64042726e-01f, -1.83268294e-01f, 1.44993082e-01f, -7.51851052e-02f,
  1.64016355e-02f, 1.44925311e-01f, 3.45602725e-03f, -2.09781811e-01f, 9.54355747e-02f, 2.02680007e-01f, 2.81635106e-01f, 3.46152395e-01f, 9.56864282e-02f, 4.81988907e-01f,
  -1.44627795e-01f, -1.99102178e-01f, -2.90549219e-01f, -2.18242899e-01f, 2.64221072e-01f, -4.66530994e-02f, -2.49941528e-01f, -2.25353599e-01f, 2.54080296e-01f, 8.04490745e-02f,
  2.23119959e-01f, -1.46062570e-02f, -3.15059394e-01f, -5.24215043e-01f, -1.80518225e-01f, 4.69321534e-02f, 3.83045636e-02f, -5.97688615e-01f, 2.40871117e-01f, 4.54684973e-01f,
  -1.85202330e-01f, -2.06681266e-01f, -1.06931031e-02f, -1.32101089e-01f, -1.67797551e-01f, -4.73553151e-01f, -4.47010309e-01f, -1.66149125e-01f, -5.14313161e-01f, -3.58636826e-01f,
  6.31805882e-02f, -1.30903512e-01f, -3.00242472e-02f, 8.95946175e-02f, -5.28876841e-01f, 2.53492650e-02f, -3.01784575e-01f, -1.64700091e-01f, 5.77824935e-02f, 4.79387641e-01f,
  -7.03304037e-02f, 2.03932509e-01f, 4.86065149e-01f, -1.20013840e-01f, -1.97403684e-01f, 2.32357174e-01f, 1.93582460e-01f, 1.41023427e-01f, -1.47314772e-01f, -2.16470450e-01f,
  1.91021606e-01f, 2.11736094e-02f, 6.96121082e-02f, -1.08720973e-01f, 1.53223306e-01f, 9.04259309e-02f, -3.52563560e-01f, 1.97400823e-01f, 1.36637419e-01f, -5.56960655e-03f,
  -3.02620709e-01f, -1.61998123e-01f, 1.36214318e-02f, 1.79803699e-01f, 2.70461619e-01f, 3.57383192e-01f, -5.55422790e-02f, -1.12617977e-01f, -2.01338947e-01f, -3.26894559e-02f,
  -1.35585025e-01f, -1.96413562e-01f, -2.61758566e-01f, -3.97258222e-01f, 8.03898424e-02f, -4.93511349e-01f, 2.65031695e-01f, 2.83230603e-01f, -1.65446594e-01f, 4.74442124e-01f,
  -4.19565499e-01f, -2.85793781e-01f, -3.68787587e-01f, -2.14230284e-01f, -3.13346714e-01f, -2.66331226e-01f, 2.80133665e-01f, 2.56612629e-01f, -2.07410783e-01f, -7.44672790e-02f,
  -8.76908377e-02f, 1.62896618e-01f, 1.42787322e-01f, -1.01589471e-01f, -1.75291017e-01f, 3.46781731e-01f, -3.45189899e-01f, -3.49962264e-01f, 3.38577837e-01f, -4.49484289e-01f,
  2.91301310e-01f, 3.65510136e-01f, 1.57593563e-02f, -2.59871453e-01f, 2.58462965e-01f, -4.59420294e-01f, -5.83365597e-02f, 1.35924639e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.73126787e-01f, 1.31788841e-02f, -6.65450990e-02f, -2.79232226e-02f, 7.00297486e-03f, 7.10487589e-02f, 9.28603485e-02f, 4.69552651e-02f, 9.04127508e-02f, -7.88080767e-02f,
  7.12038577e-02f, 5.45705343e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    