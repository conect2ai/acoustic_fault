/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.31650984e-01f, -8.39646347e-03f, -1.89339697e-01f, 7.96316005e-03f, 1.07287914e-01f, 1.45640925e-01f, 1.49599418e-01f, 2.22826913e-01f, 2.41921339e-02f, -5.75217493e-02f,
  2.00146079e-01f, 9.97366011e-02f, -5.79388952e-03f, 2.49053016e-02f, -3.27928960e-02f, -3.66698027e-01f, -4.49270546e-01f, -1.54999867e-01f, 9.92051736e-02f, 3.07835370e-01f,
  1.89127877e-01f, 2.10564837e-01f, 1.46201238e-01f, 3.50980312e-02f, -8.20674747e-02f, -4.09901626e-02f, -1.96411610e-01f, -8.97095576e-02f, -7.24184886e-02f, -5.20286560e-01f,
  -6.89708516e-02f, 9.88627970e-03f, 1.42899351e-02f, 2.49804351e-02f, 6.20761812e-02f, -3.69819179e-02f, -3.90494913e-02f, 3.79416421e-02f, 5.27305007e-02f, -1.06260357e-02f,
  -5.07868044e-02f, 7.35248700e-02f, 4.54524979e-02f, -3.16048274e-03f, -1.51971942e-02f, -2.39686370e-02f, 4.76376154e-02f, -6.97652996e-02f, 5.02296817e-03f, 3.46427411e-02f,
  6.33319169e-02f, 8.49413425e-02f, 1.87903792e-02f, -2.74522789e-02f, 4.12695529e-03f, 2.80023646e-02f, -5.31323068e-02f, -1.24030516e-01f, -5.11003137e-02f, -1.92940101e-01f,
  3.53414081e-02f, -3.72571163e-02f, 2.68333349e-02f, 1.81533955e-02f, 4.40243967e-02f, 5.71950898e-02f, -5.54659851e-02f, 5.49101718e-02f, 5.57671376e-02f, 9.39883571e-03f,
  7.56794913e-03f, -3.31940362e-03f, 1.33509226e-02f, -8.53669047e-02f, -9.77662206e-02f, -2.24838499e-02f, -4.71581593e-02f, -1.37942024e-02f, 3.40381041e-02f, -4.46794368e-03f,
  2.53002662e-02f, -1.82197150e-02f, -4.64748070e-02f, 4.89206053e-03f, -6.11792412e-03f, -1.14174103e-02f, -2.62537948e-03f, 1.11267485e-01f, 5.25611006e-02f, 3.22754234e-02f,
  5.02802990e-02f, -4.17981520e-02f, -5.46799749e-02f, -4.35803831e-03f, -2.10504280e-03f, 7.27631375e-02f, 3.46248895e-02f, 5.57268858e-02f, 8.43125582e-02f, 1.74159016e-02f,
  9.70486775e-02f, -3.95270027e-02f, -1.15785869e-02f, 5.80890253e-02f, 8.50831270e-02f, 3.52458730e-02f, -1.30591355e-02f, -4.92621474e-02f, -1.67016350e-02f, 1.06254362e-01f,
  -1.06267771e-03f, 1.73520937e-03f, -1.21235205e-02f, -5.35793714e-02f, 3.94237116e-02f, -2.72920728e-02f, -4.43712100e-02f, -5.17036952e-03f, -1.87369242e-01f, -1.63225323e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.78531051e-01f, 2.98580021e-01f, 5.11376202e-01f, -1.09327877e+00f, -2.89150774e-01f, 1.67672262e-01f, 2.81627178e-01f, -2.02800572e-01f, -5.56148887e-01f, 1.61650971e-01f,
  2.16549233e-01f, -8.57184529e-02f, 2.62529939e-01f, 3.09304118e-01f, -8.06339607e-02f, 1.56504691e-01f, -1.30487829e-01f, -8.62988383e-02f, -5.89816161e-02f, -4.10090625e-01f,
  -1.62219867e-01f, -3.84613901e-01f, -4.25360113e-01f, -2.80272067e-01f, -4.68502752e-02f, 1.12980820e-01f, 1.95265114e-01f, -2.51116902e-01f, 2.38133848e-01f, -1.65418193e-01f,
  6.06646717e-01f, -4.83994782e-02f, -4.80444692e-02f, -2.91051984e-01f, -8.75274930e-03f, 9.81272198e-04f, -3.64438333e-02f, -1.11324126e-02f, -1.20260626e-01f, -1.35756470e-02f,
  -2.50334889e-01f, -5.60257286e-02f, -1.38656780e-01f, 1.32632405e-01f, -1.09586634e-01f, -2.18517147e-02f, 6.25172183e-02f, 2.70982571e-02f, 7.77519718e-02f, 1.95445344e-01f,
  7.26276934e-02f, -2.37252459e-01f, -4.65303250e-02f, 1.28362447e-01f, 1.48095846e-01f, -1.16135538e-01f, 1.66825294e-01f, 7.03515559e-02f, 1.55587435e-01f, -6.52226899e-03f,
  1.09427966e-01f, 5.68415644e-03f, 7.18514100e-02f, 6.27530962e-02f, 7.81215122e-03f, -3.67585197e-02f, 1.47079816e-02f, 2.96408739e-02f, 1.86812878e-02f, 8.27800408e-02f,
  4.46909256e-02f, 6.55394606e-03f, 3.17473039e-02f, -1.54375276e-02f, 2.25447081e-02f, -8.84907767e-02f, -4.26822715e-02f, 7.81324413e-03f, 2.57936139e-02f, -7.21933395e-02f,
  -5.39363399e-02f, 7.99904466e-02f, -3.88963930e-02f, 1.27619267e-01f, 1.26571814e-03f, -7.93376938e-02f, -3.85020413e-02f, -1.38995880e-02f, 5.45325950e-02f, -8.22798610e-02f,
  -1.93972930e-01f, 5.45067303e-02f, -1.56446382e-01f, 1.48143470e-02f, -3.96362282e-02f, -5.38332313e-02f, 2.50669778e-03f, 1.02246322e-01f, 1.57935154e-02f, -9.58511531e-02f,
  9.09817219e-03f, -1.02687716e-01f, 1.32543817e-01f, 1.75826699e-01f, -6.20944574e-02f, -1.06207959e-01f, -1.35753021e-01f, -2.54224576e-02f, -3.55029032e-02f, -1.15963086e-01f,
  -3.76870409e-02f, -1.87535197e-01f, -1.79433405e-01f, 6.89773038e-02f, -3.38259228e-02f, -6.85637817e-02f, 1.33901745e-01f, 1.95868891e-02f, 1.95239726e-02f, 1.80352509e-01f,
  5.13205409e-01f, 1.75153166e-01f, 4.64048505e-01f, 3.77814651e-01f, -6.80621862e-02f, -5.87960422e-01f, -4.77477789e-01f, -4.01491493e-01f, -1.40964419e-01f, 2.85374634e-02f,
  -8.23196843e-02f, -9.50490013e-02f, -1.18513852e-01f, -1.34502828e-01f, 4.94413041e-02f, 5.86698949e-02f, 3.21203202e-01f, 4.53018278e-01f, -1.17928930e-01f, -1.73766568e-01f,
  -2.40571201e-01f, 2.15780333e-01f, 2.41956607e-01f, 6.19745776e-02f, 2.98807740e-01f, -1.86487779e-01f, 1.59021735e-01f, 2.47942179e-01f, 9.11574066e-03f, 7.34191477e-01f,
  4.15480137e-01f, 2.49120772e-01f, -3.52935731e-01f, -8.10741037e-02f, 1.56185776e-01f, -9.34588388e-02f, -3.59664708e-02f, 1.46358266e-01f, 2.58251769e-03f, 1.40541404e-01f,
  1.94893181e-02f, 7.60064721e-02f, 9.93222371e-02f, 3.10195386e-02f, 2.25025713e-02f, -5.00168204e-02f, -3.60441692e-02f, 2.47607827e-01f, -7.90423378e-02f, 2.13054791e-02f,
  -4.61901799e-02f, 1.32233784e-01f, 7.13223964e-02f, -3.68221462e-01f, 8.24105516e-02f, 2.49039028e-02f, 6.23768987e-03f, 2.08313450e-01f, -3.30447167e-01f, 6.09876737e-02f,
  -8.98158476e-02f, 2.33307537e-02f, 4.31585722e-02f, 6.64921924e-02f, 8.47795010e-02f, 2.81476835e-03f, 1.31209835e-01f, 5.16630113e-02f, -4.88564596e-02f, 8.93265754e-02f,
  -5.41089885e-02f, -3.86862680e-02f, -4.44548875e-02f, -2.70589776e-02f, -1.81212544e-01f, 1.04630440e-01f, -5.48253804e-02f, -1.42938569e-01f, 4.77375537e-02f, -4.07121740e-02f,
  5.95346652e-02f, 3.36980224e-02f, 2.71636266e-02f, 4.24711220e-02f, -4.59484830e-02f, 2.83230213e-04f, 3.60785015e-02f, -1.98692113e-01f, -9.64135826e-02f, 2.18915455e-02f,
  -7.97863863e-03f, -3.48440170e-01f, 2.05539633e-02f, -8.53740871e-02f, 5.16602956e-02f, -1.11093037e-01f, -1.31457061e-01f, -7.86780193e-03f, 7.85112381e-02f, -2.77593642e-01f,
  -1.49921834e-01f, -6.41186237e-02f, -4.03673388e-02f, -3.42335738e-02f, -2.03580096e-01f, -2.38724321e-01f, -2.37536922e-01f, -1.35690406e-01f, -2.43055075e-01f, -3.00796442e-02f,
  -4.87320349e-02f, -4.84242260e-01f, -5.28923750e-01f, -5.03291786e-01f, -4.84392673e-01f, -6.40393734e-01f, -3.95080328e-01f, -3.34704161e-01f, -5.49731016e-01f, -5.08724332e-01f,
  -2.76848137e-01f, -5.69282889e-01f, 4.58603464e-02f, 4.85416740e-01f, 3.78700227e-01f, 4.93698210e-01f, 3.89477938e-01f, 1.85450971e-01f, 2.55547285e-01f, 9.92411468e-03f,
  -2.05640033e-01f, -7.04027787e-02f, -3.94301824e-02f, -8.36612657e-03f, -1.19373268e-02f, 2.07288623e-01f, 4.19381022e-01f, -8.33302960e-02f, -3.70895229e-02f, 1.09767854e-01f,
  7.63638169e-02f, -2.10624561e-01f, -2.95170873e-01f, -1.13036729e-01f, -6.25140890e-02f, 1.77497596e-01f, -1.05636001e-01f, -1.57139421e-01f, -3.31202984e-01f, -1.25992477e-01f,
  -4.38449830e-01f, -2.72181243e-01f, 2.89649487e-01f, -8.66108611e-02f, -1.84107825e-01f, -1.87244833e-01f, -1.88176073e-02f, -1.65915221e-01f, -4.87026460e-02f, 1.00477815e-01f,
  -2.47920193e-02f, -2.48460725e-01f, -2.14312822e-02f, -9.44836214e-02f, -1.10486254e-01f, -1.30015418e-01f, -1.99601337e-01f, -7.19365403e-02f, 8.49957466e-02f, -1.70259401e-01f,
  -1.53925553e-01f, -1.20016225e-01f, -1.48064028e-02f, 1.74018949e-01f, 1.57718852e-01f, -5.41831702e-02f, -1.44655034e-01f, -1.56870648e-01f, 9.24739055e-03f, -1.33425772e-01f,
  1.53612256e-01f, -3.37907374e-02f, 3.22100632e-02f, 1.33035421e-01f, 9.60452706e-02f, 1.12836555e-01f, 3.50667462e-02f, 5.88591993e-02f, 4.48027439e-02f, 7.43410289e-02f,
  4.83870730e-02f, 1.31060228e-01f, 1.74660310e-02f, 1.96232423e-01f, -9.32862982e-02f, -1.52278155e-01f, -7.89204985e-02f, -6.74693808e-02f, -8.49619657e-02f, 1.10145146e-03f,
  1.03719659e-01f, -8.15404654e-02f, -2.01371700e-01f, 2.64525414e-03f, -9.10543874e-02f, 2.42808796e-02f, 4.18866463e-02f, 2.95444466e-02f, 3.04940762e-03f, -1.54692037e-02f,
  8.22761580e-02f, 1.86773315e-01f, 3.03724736e-01f, 9.64000449e-02f, -6.79854974e-02f, -1.39814496e-01f, 1.64058343e-01f, -1.13597093e-02f, -1.45204753e-01f, 1.05523139e-01f,
  -2.10504383e-02f, -2.44959500e-02f, -4.51350436e-02f, 6.87788725e-02f, 1.38147041e-01f, 4.56455722e-02f, -6.65043369e-02f, 1.20803177e-01f, 7.36607835e-02f, -5.04169427e-02f,
  -5.71689894e-03f, 6.41915575e-02f, 1.44694224e-01f, 2.00639695e-01f, 1.08853079e-01f, 2.74700373e-01f, 1.34373724e-01f, 1.08575374e-01f, 1.31944463e-01f, 1.80680662e-01f,
  3.89833838e-01f, -3.81324917e-01f, -6.28274441e-01f, -7.94662684e-02f, -8.17305446e-01f, -5.32567382e-01f, -7.14031458e-01f, -1.83077753e-01f, 5.21040708e-02f, -4.99297082e-01f,
  -4.03264314e-01f, -8.98335874e-02f, -2.73888677e-01f, -1.90578371e-01f, 1.26730546e-01f, -5.00671923e-01f, -4.83434260e-01f, -2.03249305e-01f, 8.88029933e-02f, -3.73599194e-02f,
  -5.79772145e-02f, 6.64800182e-02f, 4.52640176e-01f, 1.43560082e-01f, -3.85484993e-01f, -1.76326394e-01f, -5.06925344e-01f, -2.07108617e-01f, -4.20433700e-01f, -7.29988873e-01f,
  -5.39152026e-01f, -3.49616528e-01f, -7.54291415e-02f, 1.68678448e-01f, -2.09061816e-01f, 1.02689788e-01f, 2.75503248e-02f, -8.11604932e-02f, 6.38443679e-02f, -1.05127722e-01f,
  -1.79656953e-01f, 2.52381004e-02f, -8.25373828e-02f, -1.07514732e-01f, -4.17998470e-02f, 1.89257264e-01f, 1.18472159e-01f, 1.28747046e-01f, -2.82431394e-03f, -2.31004342e-01f,
  -1.85333744e-01f, -3.06194484e-01f, -1.56542957e-01f, -5.08262776e-02f, -2.31925752e-02f, -1.83303028e-01f, -3.89867574e-01f, -2.77148813e-01f, -2.12720737e-01f, -2.16048032e-01f,
  -5.38761280e-02f, -6.75471500e-02f, -1.36018500e-01f, -7.71306381e-02f, 8.35333169e-02f, -4.98088151e-02f, -3.52326594e-02f, -2.05080807e-02f, 5.89138530e-02f, 8.11862573e-02f,
  -4.99669723e-02f, -2.27882285e-02f, -1.45178707e-02f, -2.01864876e-02f, -4.40790318e-02f, -8.84167093e-04f, 3.61383259e-02f, -2.58440506e-02f, 1.88034162e-01f, 1.33524165e-01f,
  -3.29435281e-02f, 2.65747625e-02f, 2.51391213e-02f, 4.09899093e-02f, -2.22294778e-01f, -3.09879351e-02f, -9.11955833e-02f, 2.34729741e-02f, 1.14477113e-01f, 4.39436994e-02f,
  2.89856523e-01f, -6.39427006e-02f, -2.08230868e-01f, -4.59102802e-02f, -2.09282339e-01f, 3.39897051e-02f, -2.79166549e-01f, 1.23018563e-01f, 5.73758446e-02f, -1.11232676e-01f,
  -1.92493185e-01f, 8.90556425e-02f, -1.42797083e-01f, 8.84761661e-03f, 3.20704162e-01f, -1.20309971e-01f, -7.57555962e-02f, -4.38708663e-02f, -7.62659609e-02f, 1.65846229e-01f,
  3.28846931e-01f, 1.09706573e-01f, 1.42980471e-01f, 5.90408631e-02f, 1.16435595e-01f, -2.64370702e-02f, -1.22577153e-01f, -6.35754466e-02f, 1.65799782e-02f, 2.43800953e-01f,
  -6.39249444e-01f, -1.58623442e-01f, 2.38051564e-02f, -2.67006099e-01f, 2.88662136e-01f, 1.25317555e-02f, -4.55084383e-01f, -3.51759672e-01f, -4.67707925e-02f, 1.34332450e-02f,
  2.24027798e-01f, 1.04498975e-01f, 1.24420628e-01f, -5.90923503e-02f, -8.25316131e-01f, -5.90789855e-01f, -3.61309201e-01f, -4.06981975e-01f, -5.44746876e-01f, -1.19266719e-01f,
  7.10039809e-02f, -2.10318625e-01f, -3.30687374e-01f, -7.26304725e-02f, 4.82258275e-02f, -1.43169925e-01f, 1.12055317e-01f, -2.00628042e-01f, -5.56065552e-02f, -2.02192124e-02f,
  2.80037761e-01f, 1.46703059e-02f, 1.87901035e-01f, -8.98253620e-02f, 3.01572382e-01f, 3.57484408e-02f, 2.02677116e-01f, -5.43614812e-02f, 1.01563729e-01f, -2.11548984e-01f,
  1.52445540e-01f, -7.02423649e-03f, 1.67310730e-01f, -7.42987916e-02f, 2.81260490e-01f, -7.55634308e-02f, -1.57644495e-01f, -1.85663283e-01f, -2.67779797e-01f, 8.14222991e-02f,
  1.59417093e-01f, 8.39011669e-02f, -3.65600318e-01f, -2.33261093e-01f, 2.76469998e-02f, -3.06142010e-02f, -8.91434923e-02f, 4.40061241e-02f, -2.33588874e-01f, -4.91768628e-01f,
  6.08794279e-02f, 1.16606601e-01f, 2.43781134e-01f, -1.46707088e-01f, 1.10852737e-02f, 2.24049296e-03f, 2.41748132e-02f, -1.46555886e-01f, 2.27990597e-02f, -1.45751789e-01f,
  3.79471146e-02f, -1.04095072e-01f, 1.48160100e-01f, -4.61831242e-02f, -9.28600356e-02f, -8.44250619e-02f, 8.46859813e-02f, -1.47284701e-01f, -5.29245473e-02f, 7.77999684e-02f,
  -8.96215364e-02f, 1.55522078e-01f, -4.26379452e-03f, -1.53684527e-01f, -8.02635252e-02f, 1.16724558e-02f, -1.91698764e-02f, -1.06238924e-01f, -1.51683062e-01f, -3.88383260e-03f,
  -3.12704980e-01f, 2.82963365e-01f, -2.35782526e-02f, -1.39269650e-01f, -1.26167983e-01f, -5.06646484e-02f, 2.24542052e-01f, -8.28985572e-02f, -7.20194727e-02f, -1.81514800e-01f,
  1.43080249e-01f, -2.24715993e-01f, -4.18374017e-02f, -1.14348635e-01f, -4.38717892e-03f, -9.08856541e-02f, -4.41675097e-01f, -2.66274847e-02f, -1.74717769e-01f, 7.01592118e-02f,
  -2.40331799e-01f, -4.20648366e-01f, -4.14182425e-01f, -4.04265881e-01f, -2.82190144e-01f, -3.43038052e-01f, -2.50453413e-01f, -2.51504481e-01f, -5.36854863e-01f, -9.49726284e-01f,
  -1.38868868e-01f, 3.15344743e-02f, -1.58477008e-01f, 3.04002404e-01f, 3.38673592e-01f, 2.31506497e-01f, 1.29848719e-01f, 2.00312242e-01f, 1.74435705e-01f, 2.08468571e-01f,
  3.01614106e-01f, 3.60543877e-01f, 3.51732254e-01f, 2.53892869e-01f, 1.53869614e-01f, 2.53853738e-01f, 2.83781886e-01f, -4.65509593e-02f, 1.22540310e-04f, 1.91917241e-01f,
  3.21239799e-01f, 1.82840124e-01f, -8.74012932e-02f, 7.91896954e-02f, -1.09335139e-01f, 1.67281777e-01f, 1.80232733e-01f, 1.03126504e-01f, 6.29553422e-02f, 7.55102709e-02f,
  -1.26758441e-01f, 1.00759365e-01f, 2.23088205e-01f, 1.03301361e-01f, -1.12062261e-01f, -6.86478615e-02f, -4.10617515e-02f, -1.44320741e-01f, -1.07003383e-01f, -4.09581475e-02f,
  -4.41321172e-02f, -8.96912664e-02f, -1.19449995e-01f, -1.30127236e-01f, -1.23759948e-01f, -1.04654185e-01f, -6.57544136e-02f, 8.05989131e-02f, 1.69475913e-01f, 4.52867150e-02f,
  5.23215458e-02f, 5.92908449e-02f, -6.83514178e-02f, 3.19978260e-02f, 7.93489218e-02f, -1.34741208e-02f, -1.11848507e-02f, -1.10568359e-01f, -1.88532798e-03f, 3.70032853e-03f,
  1.65482610e-01f, 1.47348285e-01f, 7.64371604e-02f, 9.89307687e-02f, -1.59856118e-02f, 1.62621159e-02f, 2.28639436e-03f, 5.43156080e-02f, -8.64240224e-04f, -1.81140855e-01f,
  -3.16602923e-02f, 1.13894828e-01f, 1.57669075e-02f, -4.64446172e-02f, -2.66210474e-02f, -1.30904332e-01f, -2.27966636e-01f, 7.70376623e-03f, -3.83636914e-02f, -5.54309636e-02f,
  -7.78613985e-02f, 2.36303080e-02f, -1.26441475e-02f, 2.92849075e-03f, -1.41998718e-03f, 7.78323859e-02f, 7.09530562e-02f, 1.50615461e-02f, 1.14432024e-02f, 2.10831370e-02f,
  1.09076872e-01f, 3.71417761e-01f, 6.61057280e-03f, -1.37479946e-01f, -1.17100462e-01f, -2.29374096e-01f, 1.77674573e-02f, -1.38223767e-01f, -2.00109527e-01f, 2.33584717e-02f,
  -2.25864112e-01f, -1.97070614e-01f, -1.36745065e-01f, -1.84432641e-01f, -2.30869889e-01f, -1.05933383e-01f, -7.42061883e-02f, 1.07347161e-01f, 5.05271144e-02f, -2.98954323e-02f,
  -5.07275797e-02f, -1.70982182e-02f, -1.15236767e-01f, -4.14137132e-02f, 1.15219012e-01f, 1.35659456e-01f, -2.01036185e-01f, -3.68370190e-02f, -1.73029322e-02f, -2.63253581e-02f,
  -8.10431004e-01f, -3.95963192e-01f, 5.54296732e-01f, -6.12188697e-01f, 1.50143862e-01f, 4.77475882e-01f, 6.38997316e-01f, -1.12248614e-01f, -3.49480987e-01f, 7.87253305e-02f,
  -3.23386461e-01f, -4.78015065e-01f, -3.61679375e-01f, -1.37104169e-01f, 8.37240443e-02f, 4.60684717e-01f, 3.63133162e-01f, 2.85097539e-01f, 5.22076905e-01f, 2.84555972e-01f,
  -5.35806119e-02f, -3.11080247e-01f, -5.17318368e-01f, -1.65371552e-01f, -7.71710724e-02f, -3.63954455e-02f, -4.73003052e-02f, -3.40549678e-01f, 6.55223876e-02f, -2.13715032e-01f,
  2.15661228e-01f, -4.79271293e-01f, 8.26040879e-02f, -3.26868951e-01f, -4.90446016e-02f, -1.41498849e-01f, -5.23104072e-02f, 4.62553948e-02f, -4.34871390e-02f, -1.55743286e-01f,
  -1.73586175e-01f, -2.90798582e-02f, -2.66139269e-01f, 3.20843197e-02f, -6.67261258e-02f, -6.82398528e-02f, -1.56355724e-01f, -1.01833828e-01f, -1.19845316e-01f, -5.98626249e-02f,
  1.61172636e-02f, 7.10847741e-03f, -9.48034506e-03f, 4.68925573e-02f, -9.31326523e-02f, -4.99774702e-02f, -5.29282764e-02f, -1.57947287e-01f, -1.08374573e-01f, -6.59616068e-02f,
  -6.16483837e-02f, 4.97756042e-02f, 3.70310061e-02f, 1.48551082e-02f, 1.32103823e-02f, 6.26501814e-02f, -5.13442159e-02f, 6.04208633e-02f, 6.50519803e-02f, 1.22197054e-01f,
  -2.51470157e-03f, 4.54815440e-02f, -5.47298752e-02f, -1.28608510e-01f, -4.18917798e-02f, -1.10611521e-01f, 5.81101738e-02f, -5.98243624e-02f, -6.30992204e-02f, -1.07877463e-01f,
  -5.99074438e-02f, 2.01050062e-02f, -2.30922513e-02f, 3.27014141e-02f, -9.42728519e-02f, 1.01181241e-02f, -4.31805961e-02f, -1.17713427e-02f, 9.99909081e-03f, 6.72143372e-03f,
  6.55494444e-03f, -1.80753738e-01f, 1.06963359e-01f, -7.73674622e-02f, -4.45265025e-02f, -1.38902858e-01f, -1.52580574e-01f, -1.40930966e-01f, -6.34771064e-02f, 1.74630284e-02f,
  -8.47118124e-02f, -8.92370120e-02f, -1.78553283e-01f, -1.13697760e-01f, 1.20876290e-01f, 6.36102632e-02f, -4.60270904e-02f, 1.17738321e-02f, -6.75265044e-02f, -5.82329296e-02f,
  -1.52635157e-01f, 1.66805416e-01f, 1.22204162e-01f, 2.03495115e-01f, -5.53971417e-02f, 2.57067889e-01f, 2.49585405e-01f, 2.41243765e-01f, 2.85744041e-01f, 3.51219684e-01f,
  -6.83120668e-01f, 3.00859988e-01f, 2.57875204e-01f, -5.75792193e-01f, -2.83399969e-01f, -1.68417349e-01f, 3.50434244e-01f, -2.18445525e-01f, -2.77995259e-01f, 3.77365023e-01f,
  2.04444498e-01f, -2.64617860e-01f, 7.50516728e-02f, 4.39364463e-02f, 7.25041106e-02f, 4.54366595e-01f, 1.69632494e-01f, -2.53397435e-01f, -4.79044974e-01f, -2.54538953e-01f,
  -7.37825334e-02f, -4.91053194e-01f, -4.54577148e-01f, -2.08665147e-01f, -1.33256242e-01f, -4.59457517e-01f, 5.43987006e-03f, -3.72825772e-01f, -1.63521748e-02f, -1.00919753e-01f,
  3.74521524e-01f, -3.41418207e-01f, 1.65487453e-02f, -1.78154916e-01f, -9.57782939e-02f, -1.61787763e-03f, -6.93522096e-02f, -1.32701680e-01f, 1.22747030e-02f, 1.25463247e-01f,
  -1.52723551e-01f, -4.52691875e-02f, -1.97682917e-01f, -2.61647590e-02f, -1.82648182e-01f, -1.54169872e-01f, 6.68074414e-02f, -1.05188817e-01f, 5.38194962e-02f, 8.49714726e-02f,
  1.65572345e-01f, -1.11185014e-01f, 4.25465256e-02f, 7.67272934e-02f, 4.08446766e-04f, -1.30155697e-01f, -7.72303343e-02f, -3.16137671e-01f, -1.34995788e-01f, -5.37517015e-03f,
  1.33685753e-01f, 1.30678937e-01f, -1.14528993e-02f, -4.84543182e-02f, 2.82223094e-02f, -5.82850315e-02f, -8.21594968e-02f, 8.57113376e-02f, -6.80604130e-02f, -5.97124025e-02f,
  2.43621152e-02f, 8.02446008e-02f, 2.41848617e-03f, 9.11961682e-03f, 7.62492120e-02f, -1.07831739e-01f, -1.26716904e-02f, 1.49453864e-01f, 1.00190051e-01f, -6.92567229e-02f,
  -9.09740478e-03f, -8.26684013e-02f, 1.23941399e-01f, -1.29523143e-01f, -4.11609828e-04f, -3.87500562e-02f, 1.20567001e-01f, -1.17020711e-01f, 5.72645664e-02f, 2.31174082e-02f,
  6.33529052e-02f, 1.27235521e-02f, 1.40908018e-01f, 7.01131374e-02f, -7.24160969e-02f, 6.02551438e-02f, -4.49369177e-02f, 1.11943766e-01f, -1.07745908e-01f, 5.94400875e-02f,
  -8.21626112e-02f, 3.83549333e-02f, 3.75152230e-02f, 3.79900225e-02f, -1.10914625e-01f, -8.19056928e-02f, 1.89693496e-01f, 2.26635151e-02f, 1.00215957e-01f, 7.09005147e-02f,
  2.64182180e-01f, 1.33717731e-01f, 2.13375971e-01f, 1.87915102e-01f, -8.44927132e-02f, -3.14630195e-02f, 4.69158925e-02f, 2.67251711e-02f, 2.15116460e-02f, 3.53971809e-01f,
  -9.38769042e-01f, 2.38456279e-01f, -5.15096128e-01f, 3.17586809e-01f, 5.18959999e-01f, 1.08466215e-01f, 1.71324611e-01f, -1.91671476e-02f, 8.58643278e-02f, -8.30091983e-02f,
  1.11340493e-01f, 2.47429997e-01f, 7.86298066e-02f, 1.65362567e-01f, -1.84872434e-01f, 1.99446738e-01f, 3.32538903e-01f, -2.51585811e-01f, -3.34163815e-01f, 5.33533879e-02f,
  3.61607730e-01f, 2.01805942e-02f, -2.42941439e-01f, 3.78677659e-02f, 2.64974684e-01f, 1.65418208e-01f, 5.07886596e-02f, 1.25187054e-01f, 1.03856511e-01f, 2.30234340e-01f,
  -5.63486934e-01f, -3.69510621e-01f, -1.51881382e-01f, 1.12638220e-01f, 2.48777255e-01f, -5.18566728e-01f, -2.36378759e-01f, -1.45320117e-01f, 1.61865056e-01f, -9.02644172e-02f,
  1.85590878e-01f, -1.07523799e-01f, 3.59656334e-01f, 7.45226443e-03f, -1.91863135e-01f, -2.23842651e-01f, -3.07529956e-01f, -4.58992124e-01f, -6.66638136e-01f, -4.06788588e-01f,
  5.62184036e-01f, 6.48217618e-01f, -1.31274298e-01f, -1.20148621e-01f, -2.18240976e-01f, 1.81731790e-01f, -7.66755641e-02f, -2.39414394e-01f, -5.07287920e-01f, -7.28454351e-01f,
  -9.57571790e-02f, 4.55785282e-02f, -6.39337748e-02f, -2.44781841e-03f, 2.54308820e-01f, 1.70628250e-01f, 1.40134066e-01f, 1.89445049e-01f, 2.70871818e-01f, 5.58173545e-02f,
  2.66192913e-01f, -1.10654697e-01f, 9.40758586e-02f, -4.34039049e-02f, 4.17577848e-02f, -5.50600104e-02f, -1.21498117e-02f, -1.32693291e-01f, 6.58397451e-02f, -1.09400675e-01f,
  1.97026819e-01f, 6.76705837e-02f, -4.45983782e-02f, 4.06430289e-02f, 1.84279364e-02f, -1.50338516e-01f, 5.69271222e-02f, -9.36458185e-02f, -1.49782047e-01f, -1.64203301e-01f,
  3.31969204e-04f, 3.66179883e-01f, -3.18417698e-01f, -1.43899441e-01f, 1.14614971e-01f, 9.71368998e-02f, 1.52586281e-01f, -2.99279802e-02f, 4.57695611e-02f, -3.99189144e-01f,
  9.90292430e-02f, -3.39147188e-02f, 1.48425907e-01f, -9.51323435e-02f, -1.95966959e-01f, 1.19291823e-02f, -1.14287205e-01f, -1.93020292e-02f, -1.67257637e-01f, -2.58873571e-02f,
  1.18702680e-01f, -2.47663394e-01f, -5.31528831e-01f, -2.59261072e-01f, -2.09581852e-01f, -8.25797468e-02f, -1.57554612e-01f, -3.18975449e-01f, -3.98846805e-01f, -5.18973231e-01f,
  4.05480325e-01f, -5.34369111e-01f, -2.89245754e-01f, -1.90994129e-01f, -5.22029579e-01f, -6.61106855e-02f, -2.98402309e-01f, -6.33295849e-02f, -1.19736917e-01f, -3.98281544e-01f,
  6.39318377e-02f, 6.67205989e-01f, 6.12181783e-01f, 4.32637364e-01f, 3.57943952e-01f, -4.16217417e-01f, -6.09118760e-01f, 2.91265529e-02f, 5.19391358e-01f, 1.32193863e-01f,
  -2.10581273e-01f, -1.17083207e-01f, 2.74139587e-02f, 1.85312722e-02f, -2.86461294e-01f, 1.07039556e-01f, -5.88898957e-01f, -3.14609826e-01f, -3.23370665e-01f, -7.45009243e-01f,
  5.90145886e-01f, -3.52074265e-01f, -2.52879206e-02f, -8.16965848e-02f, -1.08121149e-01f, 6.92186952e-02f, 6.20081648e-02f, -1.60215467e-01f, 1.28974970e-02f, -2.68118441e-01f,
  -1.80485263e-01f, 7.11485324e-03f, 7.46069178e-02f, -5.25496975e-02f, -8.55034888e-02f, 6.29363805e-02f, -1.50742561e-01f, -1.75942481e-01f, -2.89160132e-01f, 1.94414910e-02f,
  -2.16607172e-02f, -3.91203910e-02f, 2.99451724e-02f, -1.01220474e-01f, -1.19804077e-01f, -1.17225549e-03f, -1.47770613e-01f, -4.66320887e-02f, -2.12182298e-01f, -9.96576548e-02f,
  1.80345610e-01f, 8.72686058e-02f, 8.32135826e-02f, 1.47864772e-02f, -2.63135526e-02f, 7.19060823e-02f, -1.06248654e-01f, 1.18887804e-01f, -9.59157124e-02f, 6.12786897e-02f,
  -3.49303298e-02f, 4.66142856e-02f, 2.01931167e-02f, -1.87382735e-02f, -7.97361955e-02f, -8.72384757e-02f, 7.69464225e-02f, 6.64734170e-02f, 2.69670878e-02f, -8.93888846e-02f,
  3.15666981e-02f, -1.26419544e-01f, -7.56071806e-02f, 1.39982715e-01f, -1.24666475e-01f, -7.09419847e-02f, -1.51788101e-01f, -1.88957956e-02f, 9.69337896e-02f, -1.44552514e-01f,
  5.02296746e-01f, 9.22474563e-02f, 2.78568923e-01f, 1.55135110e-01f, -8.46747383e-02f, -1.03721067e-01f, -5.42660877e-02f, -3.36639136e-02f, -5.86493313e-02f, -1.18993819e-01f,
  -5.92882633e-02f, 6.17329068e-02f, -8.20614323e-02f, -1.80407405e-01f, -6.55944496e-02f, 6.29954785e-02f, -2.34309182e-01f, 1.30013987e-01f, -1.51369154e-01f, -5.45146726e-02f,
  -5.55302463e-02f, 1.95151046e-02f, 3.60057086e-01f, 7.58304000e-02f, -5.97483329e-02f, 2.09285617e-01f, 1.39495924e-01f, 5.39138131e-02f, 2.66636610e-01f, 1.30781323e-01f,
  2.32537910e-02f, 4.09572840e-01f, -5.87490261e-01f, 3.54934037e-01f, -3.22954118e-01f, -5.24050117e-01f, 1.27668828e-01f, 1.98493287e-01f, 2.26004332e-01f, 3.21180373e-01f,
  5.38541004e-02f, -5.19418597e-01f, -1.16428368e-01f, -4.52599347e-01f, -4.35156703e-01f, 4.55541871e-02f, -2.31166974e-01f, -7.74455309e-01f, -1.07073212e+00f, -6.54387712e-01f,
  -2.44196311e-01f, 3.05412468e-02f, -2.43458286e-01f, -1.78276271e-01f, 1.40143216e-01f, -2.14143828e-01f, 2.72391260e-01f, -6.36355057e-02f, -1.22406274e-01f, -3.85627955e-01f,
  -8.56454521e-02f, -2.66184419e-01f, -3.60860497e-01f, -1.35935619e-01f, 5.16246185e-02f, -1.06081925e-01f, -1.40864715e-01f, -2.33902961e-01f, 5.53123280e-02f, 1.42195955e-01f,
  -2.24175960e-01f, -2.29010060e-01f, -1.43353626e-01f, -3.69682550e-01f, 1.76385753e-02f, -2.02984735e-01f, 4.99456376e-02f, -2.77350187e-01f, -1.92681104e-01f, -1.75596088e-01f,
  -6.66910559e-02f, -4.82644409e-01f, -3.01939934e-01f, 1.00354768e-01f, 6.96066618e-02f, -3.73076856e-01f, -9.97704174e-03f, -5.86662553e-02f, -3.85619938e-01f, 4.51102048e-01f,
  1.56068787e-01f, 1.33700231e-02f, -3.80387940e-02f, 1.25243351e-01f, 1.28910869e-01f, 1.54222727e-01f, 9.21581313e-02f, 2.05867775e-02f, 8.29858780e-02f, 1.76842839e-01f,
  1.29986063e-01f, 3.22350919e-01f, 1.64699242e-01f, 1.39898151e-01f, 1.54123390e-02f, -6.45373985e-02f, -4.54106368e-02f, 4.10611406e-02f, -9.82407480e-02f, 9.52094048e-03f,
  -1.01088852e-01f, -1.06944323e-01f, -4.32985052e-02f, -2.70204525e-02f, -2.41279706e-01f, 1.09782973e-02f, -1.54963806e-01f, -1.55479414e-02f, 5.83017990e-03f, -8.70495811e-02f,
  8.60157192e-01f, -2.77421623e-01f, 2.14493319e-01f, 5.13150357e-02f, -5.42867649e-03f, -1.61196411e-01f, 1.82960376e-01f, 9.54769626e-02f, -6.74499497e-02f, -4.83138710e-02f,
  -1.23658538e-01f, 2.05210075e-02f, 2.15986744e-01f, 1.74886659e-02f, -3.55810784e-02f, -1.00634716e-01f, 4.91184816e-02f, -2.43989587e-01f, -1.01391524e-01f, 6.88026939e-03f,
  3.62891108e-01f, -5.61166778e-02f, 2.43962422e-01f, 2.30875999e-01f, -1.05885817e-02f, -8.08863789e-02f, 2.62727380e-01f, 1.74464285e-01f, -7.37926885e-02f, 5.83133161e-01f,
  -9.33839798e-01f, -7.07651734e-01f, 3.63495909e-02f, -4.81663018e-01f, -2.23839983e-01f, -4.95076850e-02f, -7.20150709e-01f, -1.02932878e-01f, 1.29522100e-01f, -7.77851164e-01f,
  -4.20830429e-01f, -6.32214099e-02f, 1.55808374e-01f, 2.22008862e-02f, -1.89341158e-01f, -6.83284700e-01f, -2.81701028e-01f, 2.50726610e-01f, 2.74963319e-01f, -4.13521707e-01f,
  -6.12329185e-01f, -2.43544966e-01f, 2.24744901e-01f, 2.04005286e-01f, -3.57138634e-01f, 2.28899196e-01f, 8.44669715e-02f, 1.30756572e-01f, -1.87673584e-01f, -4.25192147e-01f,
  -3.98652345e-01f, -1.49363518e-01f, 3.55340332e-01f, -1.60255820e-01f, -3.36437076e-01f, -1.56790331e-01f, -4.08692837e-01f, 1.06744997e-01f, 8.90291706e-02f, -1.22880407e-01f,
  -1.97218597e-01f, -1.52090847e-01f, -9.77315847e-03f, -4.89262231e-02f, -8.33082646e-02f, -7.23919049e-02f, 2.80270576e-01f, 1.25678554e-01f, 2.52984911e-01f, -1.37779698e-01f,
  -3.46195042e-01f, -2.59134084e-01f, 1.05993353e-01f, 1.88856050e-01f, 1.23776615e-01f, 1.85551137e-01f, 2.80245513e-01f, 1.79306984e-01f, 5.14421642e-01f, -1.61021888e-01f,
  -9.79128554e-02f, 1.52023081e-02f, -2.50986218e-02f, 2.75817327e-02f, 6.51034862e-02f, 4.61583361e-02f, 6.70000538e-02f, -1.60922408e-01f, 1.46195427e-01f, -1.23188525e-01f,
  1.26176938e-01f, -4.09555212e-02f, -6.01513274e-02f, -1.79077145e-02f, 4.25469466e-02f, -5.51190749e-02f, -5.74451052e-02f, -2.23305915e-02f, -1.72759686e-02f, -1.80088561e-02f,
  8.11688900e-02f, 7.68072084e-02f, 9.45954844e-02f, 2.33838670e-02f, -2.62443293e-02f, -9.96708646e-02f, 8.79668742e-02f, 6.55717179e-02f, -1.00687752e-02f, 6.47815363e-03f,
  -1.55944809e-01f, 2.79698730e-01f, -4.47864026e-01f, -1.11646526e-01f, -5.55917136e-02f, 1.90537259e-01f, -3.77910994e-02f, -5.04868403e-02f, 7.28295296e-02f, -1.37169167e-01f,
  1.09700248e-01f, 2.91969301e-03f, 6.19002543e-02f, 5.97494096e-02f, 4.32231501e-02f, -9.68857035e-02f, -8.96177813e-02f, -7.61364847e-02f, 1.24806874e-01f, -1.08631067e-01f,
  -3.81429158e-02f, -2.96102941e-01f, -3.27084571e-01f, -4.11373414e-02f, 8.53226110e-02f, -5.53687960e-02f, 1.91876888e-01f, 9.80860889e-02f, 1.02432802e-01f, -5.48782885e-01f,
  5.03881276e-01f, 2.75606513e-01f, 5.67425549e-01f, 2.82201499e-01f, 1.96019888e-01f, 3.19056302e-01f, 5.26249647e-01f, 2.97508359e-01f, 7.68376701e-03f, 7.66552612e-02f,
  -1.64923649e-02f, -1.61730751e-01f, -1.24584995e-01f, 2.36112694e-03f, 8.64331201e-02f, 2.31374517e-01f, 1.22695111e-01f, 1.31464809e-01f, 1.63978279e-01f, 1.43091783e-01f,
  -1.31463408e-01f, 4.52129506e-02f, 3.08046658e-02f, -4.92973253e-02f, 5.05875498e-02f, -5.51881269e-02f, 4.65165526e-02f, 6.88854456e-02f, -1.45196512e-01f, -7.19212070e-02f,
  -1.55846179e-01f, 3.97403747e-01f, -1.27709985e-01f, -2.65672207e-01f, 1.41955744e-02f, -1.27987161e-01f, 4.48623300e-02f, -5.72340786e-02f, 5.56693263e-02f, 7.15818182e-02f,
  -1.63554922e-02f, -4.15631710e-03f, 1.65012464e-01f, -4.66651618e-02f, 5.40631078e-02f, -1.19066790e-01f, -5.45504168e-02f, 1.18768804e-01f, 1.15779452e-01f, -1.56303629e-01f,
  -4.78829145e-02f, -3.20210122e-02f, 5.18321358e-02f, 9.70976893e-03f, 1.29613370e-01f, 5.49273901e-02f, -4.77277152e-02f, 2.86565796e-02f, 9.53597799e-02f, 9.70392525e-02f,
  2.27231055e-01f, 9.12573040e-02f, -8.72447640e-02f, 1.23159349e-01f, 1.96433038e-01f, 1.52666733e-01f, -7.62994960e-02f, 1.34456486e-01f, 2.97543705e-01f, 1.71060339e-01f,
  -1.68725606e-02f, 4.32186648e-02f, 3.10571462e-01f, 9.45166275e-02f, 3.72607773e-03f, -6.19929805e-02f, -8.19866806e-02f, -4.88346629e-02f, 9.11251456e-02f, -1.73155904e-01f,
  2.38340318e-01f, -7.73072615e-02f, -1.62550867e-01f, 1.28539696e-01f, -8.91681388e-02f, 1.23967744e-01f, -2.80970782e-02f, -1.43959761e-01f, -6.35115057e-02f, -2.27627833e-03f,
  -7.01541662e-01f, 1.08733755e-02f, -1.12228170e-02f, -1.47776231e-01f, 3.70940231e-02f, -3.06776240e-02f, 1.54973432e-01f, -8.09083804e-02f, -1.97692275e-01f, -9.75825265e-02f,
  -4.95163947e-02f, -4.50515263e-02f, 9.03482214e-02f, 9.32674333e-02f, -6.11815080e-02f, -1.06771775e-01f, -7.64684454e-02f, -1.03759542e-01f, -1.38064086e-01f, -2.19637260e-01f,
  -7.52117634e-02f, -6.37056455e-02f, -1.35697126e-01f, -4.02557068e-02f, 2.34600045e-02f, -1.22580014e-01f, -1.08878531e-01f, -1.03143044e-01f, 1.16028003e-02f, -1.22134984e-01f,
  7.12327719e-01f, 2.13814989e-01f, 2.41751328e-01f, -3.02782562e-03f, 5.03365993e-01f, 5.12364864e-01f, 8.43482792e-01f, 1.83403283e-01f, -1.12928301e-01f, 1.92939430e-01f,
  3.88241671e-02f, -5.46119809e-01f, -4.71681058e-01f, -5.66817403e-01f, -1.35718182e-01f, 2.76922937e-02f, 8.20788220e-02f, -7.58804753e-02f, -1.67240694e-01f, 1.17823467e-01f,
  -1.20024264e-01f, 4.23538506e-01f, 2.22223625e-01f, -6.72492757e-02f, -1.74834132e-01f, -3.23156595e-01f, 3.08242738e-02f, 2.36766711e-01f, 9.81055424e-02f, -4.76644635e-01f,
  -1.43498823e-01f, 4.02495891e-01f, -2.46191680e-01f, -8.38436633e-02f, 5.16700782e-02f, -1.54451147e-01f, -4.39367704e-02f, -1.09796457e-01f, -2.24300139e-02f, -4.85902373e-03f,
  -7.25494400e-02f, 1.48749528e-02f, -3.76561247e-02f, -8.90282094e-02f, 1.49921715e-01f, -1.51877534e-02f, 3.79512981e-02f, -6.98072389e-02f, -1.84609607e-01f, -1.48379162e-01f,
  -1.44385800e-01f, 1.30919993e-01f, 1.54974744e-01f, -4.73836027e-02f, -1.38482124e-01f, -1.34819210e-01f, 1.22933634e-01f, -1.84116419e-02f, -5.23853526e-02f, -8.29314962e-02f,
  -1.98801607e-02f, 2.56848475e-03f, 3.48606966e-02f, 1.74144618e-02f, -2.09641014e-03f, -4.58033681e-02f, -5.13252094e-02f, 4.45710123e-03f, -5.48279211e-02f, 7.64769018e-02f,
  -1.35896772e-01f, -9.13851410e-02f, -1.63403630e-01f, -3.39899659e-02f, -1.81537956e-01f, 3.54324430e-02f, -3.64280567e-02f, -3.67494263e-02f, -3.16066146e-02f, 7.74728321e-03f,
  -3.35657271e-03f, -1.44052012e-02f, 2.99818302e-03f, -7.72935897e-02f, 1.91529915e-02f, -9.45472345e-02f, -5.68867847e-02f, -2.10146047e-02f, 2.49286015e-02f, 6.15450889e-02f,
  -7.07997307e-02f, 2.35973932e-02f, -2.99937189e-01f, -1.69412315e-01f, 1.96338624e-01f, -1.56177044e-01f, -1.36686638e-01f, -1.56936750e-01f, 3.44680883e-02f, -8.11809599e-02f,
  4.46721986e-02f, -1.84273094e-01f, -1.58896565e-01f, 7.70992190e-02f, 3.99599932e-02f, -6.25222474e-02f, 1.37353465e-02f, -5.83408251e-02f, -7.23973662e-02f, -7.17419535e-02f,
  -1.51176751e-01f, -6.05912618e-02f, -9.90546774e-03f, -1.26395792e-01f, -1.32099077e-01f, -3.09050735e-02f, 4.29253327e-03f, 5.13533838e-02f, 1.75519735e-01f, 1.89507902e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -6.86342195e-02f, 6.10611379e-01f, 8.61242563e-02f, 4.13026959e-01f, 2.70911902e-01f, 1.15807392e-02f, 8.50913882e-01f, 3.57385993e-01f, 5.42202473e-01f, 3.00432533e-01f,
  8.12459469e-01f, 3.24624062e-01f, 2.26068392e-01f, 2.98133463e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.23573828e-01f, -4.37008552e-02f, 3.89253050e-02f, 1.05635956e-01f, -6.21545836e-02f, -2.26584524e-01f, -2.98588365e-01f, -1.67747900e-01f, -2.86930408e-02f, -1.45478576e-01f,
  -4.20623630e-01f, 4.98046875e-01f, 1.77028880e-01f, -7.75112137e-02f, 4.42653447e-01f, 4.39701021e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.85857369e-02f, -7.22723827e-02f, 7.72313997e-02f, 2.25697272e-03f, -2.17938796e-02f, 6.89415991e-01f, 2.67777771e-01f, -9.95033979e-02f, -1.97606519e-01f, 1.23828165e-01f,
  4.00358140e-01f, 5.19974589e-01f, 5.92123449e-01f, 5.14487863e-01f, -2.95229089e-02f, -5.54691851e-02f, -1.38178915e-01f, 2.72665381e-01f, -5.27798057e-01f, 2.36706868e-01f,
  -4.48830366e-01f, 4.91087288e-01f, 3.39308560e-01f, 4.40024510e-02f, -8.75787258e-01f, -5.47642171e-01f, -9.45551693e-02f, 4.93123710e-01f, 3.59440446e-01f, 2.27215111e-01f,
  4.23204422e-01f, 5.25791287e-01f, 3.15710545e-01f, -1.33186996e-01f, -9.10237849e-01f, -1.44686356e-01f, 3.60300928e-01f, 6.96320832e-01f, -3.70627195e-01f, 1.52792364e-01f,
  -1.80150375e-01f, -6.28890246e-02f, 4.48578984e-01f, 6.14705741e-01f, 9.11654532e-02f, 2.21831441e-01f, 2.36255988e-01f, -1.09898090e-01f, 3.81620198e-01f, -2.23423559e-02f,
  9.21660542e-01f, -2.11859956e-01f, -4.77437586e-01f, 2.49901488e-01f, 1.99261233e-01f, -3.24942976e-01f, 8.79944384e-01f, 4.58090514e-01f, 1.97764248e-01f, 4.72699255e-01f,
  1.82627663e-02f, 4.95367348e-01f, -1.08461305e-01f, -1.68578714e-01f, 6.60254657e-01f, 9.93626863e-02f, -2.63706952e-01f, -1.00535989e-01f, -3.24190035e-02f, 2.34645724e-01f,
  2.00319856e-01f, 1.21012479e-01f, -4.06111151e-01f, 4.53802288e-01f, 6.08552337e-01f, -5.98846674e-01f, 8.35098922e-01f, -8.38226616e-01f, -3.66364390e-01f, 6.41410887e-01f,
  5.43108582e-01f, -1.46691978e-01f, 9.17918310e-02f, 1.97435409e-01f, 4.48290735e-01f, 3.12206537e-01f, -8.62760127e-01f, -1.00997567e-01f, 3.09832335e-01f, -8.52514207e-02f,
  -4.16823983e-01f, 7.95982778e-01f, 1.90428063e-01f, -3.59404296e-01f, 5.87224185e-01f, 7.15057611e-01f, 7.01632619e-01f, -2.47840360e-01f, -4.15432841e-01f, 4.61669326e-01f,
  -1.18473954e-01f, 2.35171705e-01f, 9.88825336e-02f, -2.15989202e-01f, 8.27905834e-01f, 1.55590698e-01f, 6.39586806e-01f, -6.81812763e-01f, -2.83232957e-01f, 2.68762082e-01f,
  7.50410408e-02f, -1.95366025e-01f, 5.45832098e-01f, 1.97488949e-01f, -5.98373473e-01f, 6.10167682e-01f, -5.73891640e-01f, -3.50730717e-01f, 6.01199903e-02f, -3.82956713e-01f,
  -2.50231355e-01f, -3.36109132e-01f, -1.70422211e-01f, 2.76695848e-01f, -2.30037257e-01f, -6.16355166e-02f, 2.86664784e-01f, 2.64289111e-01f, 2.80995339e-01f, -2.94312626e-01f,
  -5.94519556e-01f, 7.51333296e-01f, 5.28903246e-01f, 2.46413246e-01f, -4.13639605e-01f, -1.38879240e-01f, 9.52848852e-01f, -1.14247106e-01f, -9.41153336e-03f, -3.19984227e-01f,
  -6.10247076e-01f, 8.96426141e-02f, 6.32262453e-02f, -6.49413392e-02f, 5.79549670e-01f, -3.43231291e-01f, 1.12473806e-02f, 9.37078059e-01f, -3.33450615e-01f, -2.10093737e-01f,
  1.48776203e-01f, 2.31572464e-02f, -3.90337169e-01f, 2.76816756e-01f, -2.61151761e-01f, -3.69580865e-01f, 7.24994242e-02f, 3.65612149e-01f, -2.82405764e-01f, -5.74499488e-01f,
  1.70757592e-01f, -1.20327130e-01f, 1.44976720e-01f, -9.32074413e-02f, 4.36550647e-01f, 4.94487673e-01f, 3.76212001e-01f, 4.50193852e-01f, -4.80470419e-01f, -2.64460921e-01f,
  7.27241218e-01f, 2.27726176e-01f, 3.97992969e-01f, 8.57602656e-01f, -3.42509262e-02f, -3.72587115e-01f, 1.66570559e-01f, 1.07443899e-01f, -8.69744003e-01f, 5.97582161e-01f,
  -1.56089783e-01f, -3.83287340e-01f, 3.39783370e-01f, -4.52836126e-01f, 7.08734632e-01f, -3.31109345e-01f, -4.29992825e-02f, -2.72874713e-01f, 1.20769083e-01f, -1.02236915e+00f,
  2.60055155e-01f, 5.36420763e-01f, 5.50971985e-01f, 1.30001502e-02f, 9.48637605e-01f, 3.09118420e-01f, -4.89720166e-01f, -2.22866997e-01f, 6.52920961e-01f, -3.93492103e-01f,
  3.57235759e-01f, 8.28487515e-01f, 3.47701937e-01f, -4.63177830e-01f, 4.08940285e-01f, 3.32663924e-01f, -5.18222272e-01f, -3.30030084e-01f, 8.63735437e-01f, -5.16064525e-01f,
  -5.14278471e-01f, 8.64282072e-01f, 6.70510111e-04f, 1.59307733e-01f, -5.01606539e-02f, 2.29823872e-01f, -4.00948316e-01f, 2.79110521e-01f, 2.60189652e-01f, 4.22093213e-01f,
  -3.90493274e-01f, 4.25024897e-01f, 3.03088248e-01f, -3.57706100e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.35644776e-01f, 9.26089287e-01f, 5.67299664e-01f, 2.63931900e-01f, 1.57798767e-01f, 1.35289088e-01f, 3.85069668e-01f, 5.19978344e-01f, 1.28684625e-01f, 4.90315348e-01f,
  -2.46622227e-02f, 3.49148035e-01f, 3.75984758e-01f, 3.00132304e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.26982290e-01f, 4.51551914e-01f, -1.59782141e-01f, -4.85671200e-02f, -2.64904588e-01f, 1.72270790e-01f, 1.40859023e-01f, 3.79296511e-01f, -1.84936121e-01f, -2.97586232e-01f,
  -4.94649373e-02f, -3.38725507e-01f, -3.22390310e-02f, 2.23603621e-01f, 1.56547189e-01f, -2.19620857e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.17800832e+00f, -1.40473515e-01f, 4.79054898e-02f, 5.99060476e-01f, 7.74049699e-01f, -3.81476730e-01f, 1.10646510e+00f, 9.94403958e-02f, -1.31047666e-01f, -1.46818057e-01f,
  -6.56810760e-01f, 4.55693692e-01f, 5.03245652e-01f, -7.72060573e-01f, -4.78110462e-02f, 2.71039099e-01f, -8.50882351e-01f, 5.01307063e-02f, 3.34583968e-01f, 3.71108592e-01f,
  7.24417984e-01f, 3.04207653e-02f, 4.07391161e-01f, 3.25677603e-01f, 3.88113827e-01f, 1.27084643e-01f, -9.73176360e-02f, -1.58361614e+00f, 2.50434488e-01f, 4.65683937e-01f,
  -4.79263812e-01f, -2.66991615e-01f, -6.36417568e-01f, -8.16832542e-01f, -4.18163717e-01f, 9.36663672e-02f, 4.12344843e-01f, -5.36685050e-01f, 8.75494480e-01f, 9.36828256e-02f,
  2.58798838e-01f, 3.83126110e-01f, -9.88504961e-02f, -7.16523468e-01f, 1.72300965e-01f, 5.47811985e-01f, 4.69614640e-02f, 2.59700269e-01f, -5.91124177e-01f, 1.18896937e+00f,
  8.05602074e-02f, -7.00456977e-01f, 7.27809817e-02f, 7.24478006e-01f, -6.38342351e-02f, 8.66807818e-01f, 2.25869790e-01f, -5.78246236e-01f, 4.91734833e-01f, -5.19647181e-01f,
  -1.34310618e-01f, 2.39551842e-01f, 3.53408724e-01f, -4.22074020e-01f, 3.00815761e-01f, 2.77918756e-01f, -8.90310481e-02f, 1.14149857e+00f, -6.28222525e-02f, -4.60403204e-01f,
  -6.43020451e-01f, -1.10987455e-01f, 1.98732004e-01f, 8.77645075e-01f, -2.11968482e-01f, 8.13834608e-01f, -8.28261197e-01f, 7.38353372e-01f, 6.93973969e-04f, 3.10180038e-01f,
  4.10531729e-01f, -6.67201877e-01f, 5.13327360e-01f, 3.92882407e-01f, -2.91351169e-01f, 3.84704173e-01f, 1.14998555e+00f, -2.84005344e-01f, 5.65749943e-01f, 5.15469313e-02f,
  -5.65585732e-01f, 4.21813130e-01f, 1.30403712e-01f, 3.84771675e-02f, 7.87085354e-01f, -8.93787965e-02f, -3.01915288e-01f, 5.77677786e-01f, 3.20986331e-01f, 5.66117406e-01f,
  3.61106753e-01f, 3.85742277e-01f, -5.96251965e-01f, 4.99825418e-01f, -4.12586659e-01f, -5.46268374e-02f, -3.08381885e-01f, -1.21070516e+00f, -7.69027099e-02f, -2.58556128e-01f,
  -7.09568709e-02f, 1.00275420e-01f, 4.81888354e-01f, 3.20522517e-01f, -8.61649811e-02f, -8.09158459e-02f, 3.60650271e-01f, -3.25838253e-02f, -6.74969733e-01f, 4.61080343e-01f,
  5.96757293e-01f, 3.65566403e-01f, 7.88449049e-01f, 2.50173777e-01f, 5.97474948e-02f, 4.05408382e-01f, -3.32000375e-01f, 5.79956889e-01f, 6.37030080e-02f, 3.45512241e-01f,
  -5.71618080e-01f, -9.97001007e-02f, 6.77765533e-02f, -2.28189871e-01f, 4.53114897e-01f, 1.08074412e-01f, 4.86771435e-01f, 3.08923006e-01f, 4.60338801e-01f, 3.91214311e-01f,
  -3.94678682e-01f, 9.77294445e-01f, -8.46431311e-03f, 6.38303235e-02f, -1.11312456e-01f, -5.50575733e-01f, 2.63062775e-01f, 5.58153749e-01f, 2.71263957e-01f, -7.02021047e-02f,
  -5.96444905e-01f, -3.07374477e-01f, -6.47238553e-01f, -3.47296238e-01f, -4.07671750e-01f, -2.01659665e-01f, 5.94142854e-01f, -2.80765053e-02f, -1.21020585e-01f, 1.15589567e-01f,
  1.40857965e-01f, 1.27763152e-01f, 2.30816215e-01f, 2.22213447e-01f, 6.18712902e-01f, -2.38964297e-02f, -1.21715319e+00f, -9.56003591e-02f, 4.17567551e-01f, 1.42511547e-01f,
  2.46435776e-01f, 2.46658370e-01f, 2.74367392e-01f, -3.36743385e-01f, -3.22583973e-01f, 6.15775764e-01f, 3.25298280e-01f, 9.40028667e-01f, -3.31430614e-01f, 1.91925690e-01f,
  1.66161712e-02f, -2.62005180e-01f, -4.49629903e-01f, 2.97491819e-01f, 1.28534853e-01f, 3.72586101e-01f, 7.94703186e-01f, 3.83092076e-01f, -6.90047264e-01f, 9.62681532e-01f,
  -1.34259626e-01f, 2.00163558e-01f, -5.22630177e-02f, -1.17866349e+00f, 3.77586819e-02f, 1.16604799e-02f, -5.22751451e-01f, 2.32286409e-01f, -8.18774849e-02f, -8.52518976e-01f,
  8.22583199e-01f, 8.59390721e-02f, 3.05985302e-01f, 4.93648499e-01f, 7.11765170e-01f, 1.48634268e-02f, 9.38161910e-01f, 2.29038596e-01f, 7.44500101e-01f, 4.53594029e-01f,
  2.62346029e-01f, 8.18468779e-02f, 3.22717220e-01f, 6.31451190e-01f, -9.51780796e-01f, 1.37836233e-01f, -1.79868504e-01f, -2.65860260e-01f, -7.22806811e-01f, -9.19528827e-02f,
  3.00791174e-01f, -6.31528020e-01f, 4.72642839e-01f, 1.46491438e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.12668455e-01f, -1.18323475e-01f, 1.94909945e-02f, 9.38390046e-02f, 4.42310303e-01f, 1.70263335e-01f, 1.04369625e-01f, 9.68892053e-02f, 1.16201475e-01f, -3.31862837e-01f,
  1.87675148e-01f, 5.48928380e-01f, 8.40242133e-02f, 4.78435665e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  3.57415378e-02f, -3.10443819e-01f, -1.10878877e-01f, 5.03986299e-01f, -1.52349997e+00f, -7.22390652e-01f, 1.56699970e-01f, -1.95104331e-02f, 4.04755175e-01f, -5.93269944e-01f,
  -5.68675175e-02f, 5.91857076e-01f, 6.42468333e-02f, 3.97982895e-01f, 2.90979356e-01f, 1.12703763e-01f, 1.55767590e-01f, -6.48919120e-02f, 2.50118941e-01f, 6.74273223e-02f,
  -1.93079740e-01f, -2.58713603e-01f, -1.69238269e-01f, -3.80341172e-01f, 5.68885982e-01f, 3.11422676e-01f, -2.67499179e-01f, 3.28697801e-01f, 3.90767306e-01f, -1.43792301e-01f,
  -7.73031473e-01f, 4.29807872e-01f, -2.10333169e-01f, -1.04214445e-01f, -3.66905108e-02f, -5.57293236e-01f, -1.16034126e+00f, -4.76208627e-01f, 1.43313676e-01f, 1.17322095e-01f,
  -4.17474329e-01f, 3.81248146e-01f, -7.53332078e-01f, -5.55174589e-01f, 4.42182064e-01f, -6.89109921e-01f, 3.15342039e-01f, 2.53628045e-01f, -5.69800377e-01f, 8.93897712e-01f,
  -5.12088597e-01f, -6.83446169e-01f, 1.84703544e-01f, 2.49268726e-01f, -7.53406346e-01f, 4.48098600e-01f, -2.31217474e-01f, -4.72286373e-01f, -5.47949851e-01f, -2.78896749e-01f,
  -9.82826352e-01f, -2.01226741e-01f, 4.86355573e-01f, 4.27795723e-02f, 5.05872726e-01f, 1.37602970e-01f, 2.62548834e-01f, -5.10282040e-01f, 2.69581825e-01f, -6.75583720e-01f,
  -1.04874408e+00f, 3.71001512e-01f, -3.66584152e-01f, -4.82098341e-01f, -1.90731406e-01f, 3.69924754e-01f, -4.97767210e-01f, -7.92869568e-01f, 4.32835221e-01f, 1.34886637e-01f,
  1.13214597e-01f, 7.19905086e-03f, 7.21217096e-01f, 4.28867966e-01f, -1.41977206e-01f, 1.58451125e-02f, -5.26892304e-01f, 4.36772764e-01f, 5.48201203e-02f, -2.99117267e-01f,
  -1.74418852e-01f, -2.99298435e-01f, -3.74859869e-01f, -5.89332521e-01f, -6.49184167e-01f, 3.06895599e-02f, 1.69970259e-01f, -4.46648479e-01f, -6.23003840e-01f, -7.90702999e-01f,
  -4.14001852e-01f, -9.98898387e-01f, 5.58433950e-01f, -4.74651933e-01f, -3.92308623e-01f, 2.98714817e-01f, 1.38251290e-01f, 4.06128764e-01f, 2.76627272e-01f, 3.78241181e-01f,
  -4.89037424e-01f, 8.62271786e-02f, -1.87452972e-01f, -1.33121535e-01f, -6.65534362e-02f, 4.21540499e-01f, 6.41068339e-01f, -8.35336596e-02f, -1.14407980e+00f, -1.16226479e-01f,
  -6.23153687e-01f, 2.27525681e-01f, 5.39471693e-02f, 2.09646206e-02f, 1.47446871e-01f, -6.17476463e-01f, 2.20407024e-01f, -5.53853095e-01f, -7.75327981e-02f, 6.17633104e-01f,
  -1.76210910e-01f, 9.85292718e-02f, -1.85629234e-01f, 5.79911411e-01f, -6.52525723e-01f, -9.77292955e-01f, -1.72923543e-02f, 4.26650733e-01f, 3.65542501e-01f, -1.08799087e-02f,
  -2.83904493e-01f, 3.91806126e-01f, -7.91569173e-01f, -2.90838778e-01f, -4.28818077e-01f, -4.30710793e-01f, 2.02628657e-01f, -6.66224837e-01f, -1.22387037e-01f, -6.77891016e-01f,
  2.65549660e-01f, 2.20258117e-01f, -5.22758424e-01f, 7.84828737e-02f, 1.63589507e-01f, -9.00622308e-01f, -2.18436524e-01f, -2.45937154e-01f, 4.11568820e-01f, -1.23645759e+00f,
  -7.17463315e-01f, 1.84967667e-01f, -1.10048127e+00f, -4.07464951e-01f, 2.11507916e-01f, 9.12562728e-01f, -5.28859556e-01f, 1.58469960e-01f, 5.13180792e-01f, -7.57385850e-01f,
  -9.72830772e-01f, -6.34913981e-01f, -1.01128638e+00f, -8.06351602e-01f, -4.48674798e-01f, 5.39096653e-01f, 1.92233562e-01f, 9.34338093e-01f, -1.31850317e-01f, 3.67980689e-01f,
  5.20425439e-01f, -4.16549981e-01f, 5.09012997e-01f, -1.35063904e-03f, -5.42100109e-02f, 4.91268486e-02f, 2.83126235e-01f, -6.36061370e-01f, -6.90798879e-01f, 1.54214695e-01f,
  -8.17721725e-01f, -6.36827230e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.54489920e-01f, -4.85910401e-02f, 1.02243081e-01f, -5.84064782e-01f, -9.59654674e-02f, 5.62344551e-01f, -2.05076054e-01f, -5.58046810e-02f, 3.48961890e-01f, -6.32699206e-02f,
  2.00784653e-01f, -1.28874034e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    