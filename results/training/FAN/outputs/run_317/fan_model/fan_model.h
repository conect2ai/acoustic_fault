/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.54409724e-01f, 1.65214553e-01f, 1.39670551e-01f, -1.57025754e-02f, -2.13554218e-01f, -1.86354011e-01f, -2.25730002e-01f, -5.60935363e-02f, -1.93497673e-01f, 1.43466666e-01f,
  -1.30492106e-01f, 6.94782436e-02f, 8.74284282e-02f, 3.87038738e-02f, -2.48070017e-01f, -4.76862537e-03f, -3.72775756e-02f, 1.45566487e-03f, -1.51699027e-02f, 3.27815190e-02f,
  -7.48252049e-02f, -1.95710137e-01f, 9.17313248e-02f, 8.63896832e-02f, 8.96115229e-02f, 9.62457582e-02f, 6.51289821e-02f, 1.18978441e-01f, 1.41155466e-01f, -1.96414702e-02f,
  -4.20338884e-02f, -9.38978195e-02f, -7.80033227e-03f, 6.12644851e-02f, 4.57966030e-02f, 7.12549388e-02f, 1.87254809e-02f, 2.51338966e-02f, 1.52215390e-02f, -2.79368553e-02f,
  2.35122181e-02f, 3.86821735e-03f, -6.06619902e-02f, -3.69496681e-02f, -4.31039222e-02f, 5.87464981e-02f, 3.65334935e-02f, -2.54425760e-02f, 8.33963603e-02f, 7.65089020e-02f,
  4.55447026e-02f, 5.61201759e-02f, 2.72552986e-02f, -8.07641819e-03f, 5.92689477e-02f, -5.56548089e-02f, -3.05088814e-02f, 5.92437610e-02f, -5.03826886e-02f, 1.40932345e-04f,
  -3.04792169e-02f, -1.21525619e-02f, -4.84718801e-03f, 7.96079263e-02f, 9.78208985e-03f, -5.80287129e-02f, 2.53659375e-02f, -3.32458057e-02f, -8.52503255e-03f, 2.19718665e-02f,
  6.20599883e-03f, 5.19832736e-03f, 4.12687585e-02f, 8.65989644e-03f, 1.83270164e-02f, -3.08104861e-03f, 5.78813590e-02f, 3.22740665e-03f, 6.72257245e-02f, 2.58957054e-02f,
  3.41375507e-02f, -2.46607661e-02f, 5.77076189e-02f, 3.99284512e-02f, -1.41346743e-02f, -9.67198517e-03f, 3.57262753e-02f, 5.64020276e-02f, -1.89548247e-02f, -1.69412829e-02f,
  -7.64539093e-02f, -1.03061125e-02f, 3.96062853e-03f, 5.40311448e-03f, 6.30710199e-02f, 2.39085723e-02f, -1.47600388e-02f, 2.66521759e-02f, -9.85977985e-03f, -3.38102728e-02f,
  3.11235879e-02f, 3.94630432e-03f, -1.55800977e-03f, 5.55454195e-03f, -2.30108202e-02f, -1.11347446e-02f, -2.41644662e-02f, 5.61953820e-02f, -2.65733786e-02f, 3.24973576e-02f,
  7.38679916e-02f, -3.50648202e-02f, 2.64423918e-02f, -4.22546407e-03f, -2.92158015e-02f, 4.83687073e-02f, -9.63283237e-03f, 4.18490395e-02f, 2.99864635e-02f, 7.84521103e-02f,
  -1.26904190e-01f, -1.75283536e-01f, 3.24673951e-02f, -1.85644865e-01f, -5.18182442e-02f, 1.22967146e-01f, 8.04375112e-02f, -1.68459699e-01f, -1.78312600e-01f, -1.14117943e-01f,
  2.69339625e-02f, -2.15055063e-01f, 9.27541479e-02f, -7.34876655e-03f, 4.06293094e-01f, 2.16493964e-01f, 9.72197130e-02f, -3.37091051e-02f, -4.77630794e-02f, -7.99531117e-02f,
  5.04322052e-02f, 5.65381832e-02f, 2.23003313e-01f, -7.82048628e-02f, 1.29528930e-02f, -1.48493052e-01f, 6.95011690e-02f, 1.33222053e-02f, -9.49078426e-02f, 7.03449845e-02f,
  2.95342915e-02f, -2.03578934e-01f, -2.13375594e-02f, -3.33950594e-02f, 6.71671852e-02f, 3.68947424e-02f, -2.58564744e-02f, 5.63612916e-02f, 5.13142012e-02f, -1.22709135e-02f,
  4.34504859e-02f, 2.76771886e-03f, -3.36483121e-02f, 2.55060550e-02f, 1.23762684e-02f, -3.07915285e-02f, -1.71165296e-03f, 2.34284848e-02f, -1.04572669e-01f, -1.12964343e-02f,
  -1.59045383e-02f, 5.04833274e-02f, 1.20413667e-02f, -4.21887543e-03f, 5.63848438e-03f, 5.93969598e-02f, 1.38974364e-03f, 1.45483278e-02f, -4.61682342e-02f, -4.22622152e-02f,
  1.43981976e-02f, -7.08610490e-02f, 3.82650383e-02f, -9.48689505e-02f, 5.14832586e-02f, 3.35866176e-02f, 5.67357708e-03f, 3.77068520e-02f, 2.72202231e-02f, 3.89152020e-02f,
  -1.16436454e-02f, -4.13217954e-02f, -3.04487906e-02f, 8.34628288e-03f, 3.22270133e-02f, -4.31965627e-02f, 3.44485790e-02f, -5.98661304e-02f, 6.18435666e-02f, 4.12317924e-03f,
  -2.57412754e-02f, 5.66432811e-02f, -8.75848979e-02f, 3.01522221e-02f, 5.98744443e-03f, 9.67160508e-04f, -6.52775094e-02f, -1.32650239e-02f, 2.73675919e-02f, 6.65207505e-02f,
  -5.01499325e-02f, -2.15322599e-01f, -6.48761690e-02f, -7.49779074e-03f, -4.33651060e-02f, -1.31315878e-02f, 2.34745499e-02f, -5.03187953e-03f, -2.57785916e-02f, -2.11771876e-02f,
  2.72261444e-02f, 8.17120913e-03f, -2.46086288e-02f, 4.86846007e-02f, 4.58458401e-02f, 2.59101074e-02f, 1.87048409e-02f, 5.82838431e-02f, -3.47508048e-03f, -2.67283409e-03f,
  -6.71849400e-03f, -5.47556356e-02f, 1.42907463e-02f, 2.97508365e-03f, 3.10463291e-02f, 9.27909836e-03f, -8.00194815e-02f, -2.61642374e-02f, 6.30974844e-02f, 5.69882523e-03f,
  4.85536873e-01f, 1.11059397e-01f, 3.70284617e-02f, 1.06709719e-01f, -3.83377410e-02f, 5.35102226e-02f, -3.15127149e-02f, 7.51522705e-02f, 2.10703507e-01f, -5.28212637e-02f,
  -1.20295048e-01f, 1.93515301e-01f, -7.98691362e-02f, -7.25768358e-02f, 4.45866734e-02f, -3.81350284e-03f, -3.55906598e-02f, 4.16183919e-02f, 6.40294030e-02f, 3.11100911e-02f,
  9.13764536e-02f, -1.88379750e-01f, -1.04025900e-01f, -2.08074883e-01f, 2.61917412e-02f, 4.15842533e-02f, -1.53086320e-01f, 2.13247095e-03f, -1.09234601e-01f, -2.72865966e-02f,
  2.91193593e-02f, -2.33585294e-02f, 7.03482106e-02f, 6.74887002e-02f, 4.25498262e-02f, -1.57096665e-02f, -4.18155976e-02f, -6.54021576e-02f, -2.72085648e-02f, -7.87835009e-03f,
  -5.01586087e-02f, -1.23139599e-03f, -4.57270481e-02f, 1.24264192e-02f, 3.94958816e-02f, 9.80120674e-02f, 5.87279946e-02f, -3.85341905e-02f, 5.81420539e-03f, -2.49238475e-03f,
  1.05404891e-01f, 5.41406386e-02f, -1.86850447e-02f, -3.44256544e-03f, 2.05836650e-02f, -9.61265247e-03f, 9.09760036e-03f, 4.93892096e-02f, -3.70151550e-02f, 5.78953624e-02f,
  7.64423907e-02f, 7.05831125e-03f, 6.68365415e-03f, -3.00032496e-02f, -6.14557676e-02f, 2.33053379e-02f, -3.37277651e-02f, 1.93301421e-02f, 7.07856044e-02f, 2.96757687e-02f,
  8.35849345e-03f, 1.13756554e-02f, -3.63823026e-02f, 8.53689760e-02f, 4.25480716e-02f, 2.04158090e-02f, 1.70365404e-02f, -5.51172160e-02f, 1.41959600e-02f, 6.31235912e-02f,
  -7.44090903e-06f, 1.85446702e-02f, 2.64266692e-02f, 2.35136040e-02f, -6.92718923e-02f, -4.38903309e-02f, 2.17977110e-02f, 8.83127563e-03f, -6.58088923e-02f, -3.29967253e-02f,
  -8.33618641e-02f, 4.31403033e-02f, -8.55143592e-02f, -3.28090414e-02f, -1.79190747e-02f, -7.03875497e-02f, 1.91540401e-02f, 4.13678288e-02f, 1.03386931e-01f, -1.03420755e-02f,
  2.40301229e-02f, 2.51562018e-02f, 4.89304401e-02f, -5.75486012e-03f, 4.14352641e-02f, -8.72064829e-02f, -2.77039483e-02f, 3.07437666e-02f, -6.65016547e-02f, -4.47024219e-02f,
  -5.40935509e-02f, 4.86537721e-03f, -1.20884702e-02f, -6.67535979e-03f, -2.75881346e-02f, 2.13013845e-04f, 6.58909976e-02f, 4.66608182e-02f, 8.64994060e-03f, 8.28677416e-02f,
  1.41164050e-01f, 1.62104562e-01f, 2.21931621e-01f, 4.13797498e-01f, -1.89635962e-01f, -1.43379927e-01f, -1.34743333e-01f, 1.47181028e-03f, 2.10923254e-01f, -1.15482345e-01f,
  -8.54606926e-02f, 2.93444782e-01f, -4.47839499e-02f, 2.42869064e-01f, 1.77609965e-01f, 1.56445634e-02f, 2.76624948e-01f, 8.47558528e-02f, 8.69735107e-02f, 1.14126466e-02f,
  8.01301226e-02f, 3.77080813e-02f, 1.68932214e-01f, -1.66387498e-01f, 2.02111434e-02f, -2.82448083e-02f, -8.62716697e-03f, -8.92765895e-02f, 8.24938789e-02f, 3.83517221e-02f,
  -9.61591899e-02f, -4.09245631e-03f, 5.09637082e-03f, -2.68659751e-05f, -3.17369662e-02f, -1.08632565e-01f, -6.33208826e-02f, 4.46047559e-02f, 2.06474438e-02f, 5.82486950e-02f,
  1.87222753e-02f, 4.19861227e-02f, 8.56752601e-03f, -1.11468276e-02f, 8.57948326e-03f, 1.33259585e-02f, 4.62280065e-02f, 5.88100515e-02f, 1.25469845e-02f, 3.87864327e-03f,
  3.87713946e-02f, -3.91364358e-02f, 1.19610140e-02f, -6.23523407e-02f, -9.17881634e-03f, 2.89330655e-03f, 2.10778564e-02f, 2.09127720e-02f, 6.17172569e-02f, 1.49098993e-03f,
  -1.71502829e-02f, -2.54350863e-02f, 1.47975804e-02f, 6.04495220e-02f, 3.32275741e-02f, -2.59587937e-03f, 2.00088713e-02f, -6.44605681e-02f, 5.58104403e-02f, 1.54792061e-02f,
  2.21702065e-02f, 3.74052152e-02f, 9.52546522e-02f, -4.02106754e-02f, -3.75763811e-02f, 2.26039588e-02f, -6.16221875e-02f, -3.55756357e-02f, 4.59785722e-02f, 2.48738974e-02f,
  -2.15109438e-02f, 4.45272438e-02f, 3.65382060e-02f, -5.60098477e-02f, 1.83054563e-02f, 2.57316995e-02f, 3.17354910e-02f, -1.54289342e-02f, 4.96590883e-03f, 9.55355633e-03f,
  1.07130498e-01f, 1.09646223e-01f, 5.97030893e-02f, 2.76651885e-03f, -4.89097387e-02f, 7.06646442e-02f, 4.14192416e-02f, 3.69826704e-02f, -7.65536129e-02f, -2.87583414e-02f,
  -7.02342242e-02f, -8.02261904e-02f, -1.79369152e-02f, 4.31594327e-02f, 1.71639733e-02f, 6.53259829e-02f, 5.02941851e-03f, -3.75842378e-02f, 6.52461424e-02f, 9.42247882e-02f,
  -1.39849372e-02f, 1.54045448e-02f, -4.43478301e-03f, -1.36089502e-02f, -1.12084588e-02f, -5.03703021e-02f, 5.38253551e-03f, -1.12713002e-01f, 4.13192920e-02f, 4.52715196e-02f,
  9.41808969e-02f, 1.88565224e-01f, -1.93250343e-01f, 1.37296483e-01f, -2.20004693e-01f, 6.72767982e-02f, 1.40822595e-02f, 1.89467877e-01f, -1.56236375e-02f, 3.00147712e-01f,
  1.29746437e-01f, -8.51570256e-03f, -1.08154476e-01f, 2.34498277e-01f, -3.56012166e-01f, -8.70806277e-02f, 7.18196258e-02f, 1.64453447e-01f, -3.33041102e-02f, 1.64579555e-01f,
  -1.74680762e-02f, 8.54168609e-02f, -1.55295193e-01f, -3.25725488e-02f, 5.87626211e-02f, 8.20150152e-02f, -7.87569508e-02f, -1.08104937e-01f, 1.62431132e-02f, -6.54223934e-02f,
  -3.93789122e-03f, 4.23169397e-02f, -1.87602185e-03f, 5.44357188e-02f, 1.47885541e-02f, -5.27645759e-02f, -6.48097917e-02f, -1.29875705e-01f, -6.32227063e-02f, -1.57582797e-02f,
  6.52882457e-02f, -5.46055622e-02f, 5.65399677e-02f, -1.89581960e-02f, -5.97388335e-02f, 1.92124466e-03f, 6.58733919e-02f, 4.01718169e-03f, -3.00933607e-04f, -1.27877191e-01f,
  -2.40189675e-02f, 4.49607568e-03f, 7.45228678e-03f, -5.28475130e-03f, -9.56289843e-02f, 2.90869437e-02f, -5.86468354e-03f, -1.13408202e-02f, 1.33014377e-03f, 7.14223832e-02f,
  3.00456281e-03f, -5.50958365e-02f, 2.26485841e-02f, 1.45443045e-02f, 9.09108073e-02f, 4.91026118e-02f, 3.62845771e-02f, -1.82291865e-02f, 6.51571304e-02f, 4.11895588e-02f,
  3.96005362e-02f, 3.81437056e-02f, 4.49080057e-02f, 4.89755869e-02f, 1.23840466e-01f, 9.58484262e-02f, -2.62874132e-03f, 3.73841710e-02f, -2.16797572e-02f, 6.60530180e-02f,
  2.37118043e-02f, 4.78873402e-03f, 2.52426211e-02f, -9.07315612e-02f, -1.10214930e-02f, -5.10564968e-02f, -5.73827028e-02f, 1.33964859e-04f, 3.34216952e-02f, -2.09507607e-02f,
  8.45872909e-02f, 2.74667025e-01f, 2.85955910e-02f, -3.72017771e-02f, 6.03550039e-02f, 1.77485310e-02f, -4.33894135e-02f, 6.55156299e-02f, 6.01367578e-02f, 7.57794082e-02f,
  -1.25741418e-02f, 6.38984665e-02f, -3.90174575e-02f, 2.28963867e-02f, 2.56564785e-02f, -6.78211525e-02f, -2.87815612e-02f, 1.46080684e-02f, -2.98481975e-02f, -8.67448654e-03f,
  6.90403953e-02f, -1.02850730e-02f, 6.11093780e-03f, 1.99602614e-03f, -3.90168577e-02f, 4.98900265e-02f, 4.04381678e-02f, 9.35955148e-04f, -3.46938372e-02f, -4.13854904e-02f,
  2.32562665e-02f, 2.11829245e-01f, 1.52797118e-01f, 1.38177082e-01f, 1.94535986e-01f, -1.40413985e-01f, -3.13411295e-01f, 1.96931586e-01f, -1.46827772e-01f, -1.75071955e-01f,
  1.01653837e-04f, -7.20266905e-03f, -1.53956875e-01f, -9.97688249e-03f, -9.33450609e-02f, -2.47169420e-01f, -6.27141492e-03f, -5.86339831e-02f, -8.44025388e-02f, 1.57992885e-01f,
  1.41744176e-02f, 2.36930978e-02f, -4.57026809e-03f, 1.52307495e-01f, 5.75029962e-02f, 1.90484032e-01f, 1.19420633e-01f, 1.68911554e-02f, 4.20507044e-02f, -8.48676786e-02f,
  -9.04632732e-02f, 2.86030080e-02f, -3.75877135e-02f, -3.95062342e-02f, 3.33314463e-02f, 1.15970606e-02f, -1.06546171e-02f, -7.69012496e-02f, -5.37618399e-02f, -4.63199206e-02f,
  -3.02423220e-02f, -5.75984269e-02f, 6.85923919e-03f, -3.41801383e-02f, 7.58315101e-02f, -1.53690735e-02f, -7.09505454e-02f, -1.56387668e-02f, 1.22832358e-01f, 1.58549342e-02f,
  3.36113758e-02f, 5.55176064e-02f, 6.50954694e-02f, 3.59599963e-02f, 3.58760059e-02f, 1.83807779e-02f, -3.02610751e-02f, -7.98278861e-03f, 5.66370301e-02f, 4.81283702e-02f,
  6.54857382e-02f, 2.56361570e-02f, -1.68113615e-02f, -4.41940036e-03f, 3.26997377e-02f, 5.09671569e-02f, 1.16814710e-02f, -7.41668092e-03f, -4.22482789e-02f, -2.49060988e-02f,
  -4.10464592e-02f, 9.15063620e-02f, 4.22118558e-03f, -4.54511382e-02f, 7.25378543e-02f, 1.98707767e-02f, 2.19781394e-03f, -5.59171177e-02f, 2.91180518e-02f, -1.01648411e-02f,
  -7.13350102e-02f, 2.97224987e-02f, -8.91883969e-02f, 2.29936633e-02f, -1.48386173e-02f, -8.34125560e-03f, -1.77212264e-02f, -2.74138134e-02f, -3.47800297e-03f, -5.68029191e-03f,
  1.45000607e-01f, 8.95469263e-02f, -6.10321388e-02f, 6.93511590e-02f, -4.35433909e-02f, -8.44387221e-04f, -1.53556373e-02f, -8.84274021e-03f, -8.40331148e-03f, -9.24040191e-03f,
  1.04789831e-01f, 4.90964800e-02f, 4.40943427e-02f, -4.22756746e-02f, 8.15650728e-03f, 4.61875573e-02f, -7.05128023e-03f, 1.00801722e-03f, 5.77310100e-02f, 4.20026258e-02f,
  1.11342840e-01f, -1.06210811e-02f, 1.86221115e-02f, 2.03612298e-02f, -4.98404214e-03f, 6.68120664e-03f, 9.35832188e-02f, 9.92206112e-03f, 1.22103170e-02f, -7.66212642e-02f,
  -5.66609681e-01f, 1.91138878e-01f, -6.12202547e-02f, 1.16470093e-02f, -4.40086126e-02f, -6.32735416e-02f, -5.57503626e-02f, -1.48993675e-02f, -1.44677415e-01f, 1.60748571e-01f,
  -5.87018915e-02f, -8.60243365e-02f, 2.24347170e-02f, 5.28562488e-03f, -1.46078110e-01f, 1.26593024e-01f, -8.38413239e-02f, 4.37419340e-02f, 1.18577294e-01f, -2.31682812e-03f,
  4.96752746e-02f, 1.05033033e-01f, 1.56670976e-02f, 1.19239084e-01f, -6.79975376e-02f, -1.97972972e-02f, -1.42793190e-02f, 1.24089628e-01f, -1.08643295e-02f, 6.32347763e-02f,
  -4.32589911e-02f, 4.09097262e-02f, -1.23921871e-01f, -6.78403750e-02f, -1.24164499e-01f, -2.75329109e-02f, -1.76879000e-02f, 2.82850973e-02f, -2.15011113e-03f, 1.86989550e-03f,
  -5.02914451e-02f, -8.13208818e-02f, 1.54674444e-02f, 4.25691083e-02f, -1.58197768e-02f, -2.82706022e-02f, 1.14829224e-02f, -2.48443447e-02f, 1.57278012e-02f, -2.28429958e-02f,
  6.70352429e-02f, 3.45421978e-03f, -4.97350134e-02f, 4.61416952e-02f, -4.48961891e-02f, 3.38965245e-02f, 4.23748381e-02f, -5.63157583e-03f, 3.52908708e-02f, 1.94869041e-02f,
  4.30545472e-02f, -7.47688711e-02f, 2.92588584e-02f, -8.44633430e-02f, 9.77667700e-03f, 1.30141294e-02f, -3.27943079e-02f, 4.29637842e-02f, 9.80392657e-03f, -3.28436214e-03f,
  -4.02600206e-02f, -6.73051327e-02f, -5.55849522e-02f, 3.49113829e-02f, 4.62796446e-03f, -3.90478708e-02f, -3.88462804e-02f, -5.25013134e-02f, 5.21312188e-03f, -1.77780855e-02f,
  3.86346057e-02f, 2.34173369e-02f, 7.54421763e-03f, 3.54735889e-02f, -3.22444476e-02f, -2.54620854e-02f, 3.92466113e-02f, 5.07789142e-02f, -5.79161395e-04f, -5.57357930e-02f,
  2.33215988e-01f, 2.63133273e-02f, 6.36316545e-04f, -2.24041566e-02f, -3.18000130e-02f, -8.36110935e-02f, -2.61743199e-02f, -4.32597324e-02f, 1.63609013e-02f, -6.26002206e-03f,
  -5.85832037e-02f, -9.10390262e-03f, -3.04158293e-02f, -5.78159094e-02f, 5.00134490e-02f, 5.95860109e-02f, -3.20514329e-02f, 1.80700645e-02f, -3.41524221e-02f, -1.48622934e-02f,
  -4.10675742e-02f, 2.17438079e-02f, -4.64856072e-04f, 2.55818982e-02f, -6.93611950e-02f, -8.70161206e-02f, -5.68099208e-02f, 4.34832796e-02f, -1.24072284e-02f, 2.23697089e-02f,
  -1.05229644e-02f, -7.23682567e-02f, 2.88190693e-01f, -1.22164182e-01f, -5.31599820e-02f, -1.52972579e-01f, 1.14871040e-01f, -1.04837298e-01f, 2.29851872e-01f, -1.28629267e-01f,
  -1.20018952e-01f, 1.69271469e-01f, 1.54762536e-01f, -4.77185957e-02f, 5.18919602e-02f, 1.32753074e-01f, 1.49802100e-02f, -7.15195388e-02f, 1.41584128e-01f, -6.47132695e-02f,
  -7.15665743e-02f, -1.93500653e-01f, -1.50007475e-02f, -2.03224793e-01f, 5.19719068e-03f, -1.76495558e-03f, -2.36985281e-01f, 1.45663833e-02f, -1.22762002e-01f, 1.66843738e-02f,
  -5.11568226e-02f, 4.86192442e-02f, -4.61641513e-02f, -2.21459158e-02f, -4.56016287e-02f, 1.51551841e-02f, 2.50147637e-02f, 6.76263496e-02f, 3.05374488e-02f, -7.12568453e-03f,
  9.82118621e-02f, -1.96995260e-03f, -1.23366835e-02f, -4.81173731e-02f, 2.01922134e-02f, 1.50922416e-02f, 3.12363449e-02f, -4.26197127e-02f, -2.51754615e-02f, 1.54728740e-02f,
  3.29040224e-03f, -2.09103730e-02f, 4.68295701e-02f, -4.89757909e-03f, 2.00315937e-02f, 9.32105724e-03f, 1.45988644e-03f, -5.98887634e-03f, 4.06295527e-03f, 9.29211639e-03f,
  -5.07477783e-02f, 2.56640054e-02f, 2.68254727e-02f, -9.57022980e-03f, 2.28645373e-02f, -5.52221388e-02f, -1.37559604e-02f, -2.98122261e-02f, 3.42204310e-02f, -4.30622883e-02f,
  -9.24090967e-02f, 3.12317675e-03f, 6.33557066e-02f, -5.39987870e-02f, 1.70235094e-02f, 7.17072934e-02f, -3.37043442e-02f, -8.86093825e-02f, 7.21193245e-03f, 4.76703979e-03f,
  1.74907744e-02f, -7.58722126e-02f, 1.10922325e-02f, -1.12035600e-02f, -3.18158902e-02f, 1.52398385e-02f, -5.92107959e-02f, 1.92346293e-02f, 5.01710698e-02f, -2.90564578e-02f,
  -3.16877604e-01f, -1.82995170e-01f, -5.90456873e-02f, -5.31245321e-02f, -2.05906052e-02f, -3.63412201e-02f, 3.56445787e-03f, 2.63070986e-02f, 1.31854415e-02f, 7.31020793e-02f,
  -4.78712618e-02f, -5.00868782e-02f, -9.88673232e-03f, -8.77227169e-03f, 2.64648274e-02f, 6.59598503e-03f, -1.10543370e-02f, -4.65831570e-02f, -4.06372286e-02f, -3.47288661e-02f,
  -8.32837448e-02f, 7.08311936e-03f, 2.29440257e-03f, -7.85686225e-02f, -4.47613187e-02f, -4.29834053e-02f, -8.13668594e-02f, -3.03859748e-02f, 2.99110208e-02f, -9.07206815e-03f,
  2.43086085e-01f, 2.83707436e-02f, 3.80061790e-02f, 1.70535669e-02f, 8.14152583e-02f, 1.04824230e-01f, -1.41124696e-01f, 9.77936089e-02f, 1.00722037e-01f, -4.77321595e-02f,
  -5.72240315e-02f, 3.09960395e-02f, -1.47771180e-01f, -5.09297065e-02f, -1.18706167e-01f, -1.26699895e-01f, 8.37267861e-02f, 6.32098839e-02f, 6.19763285e-02f, 3.19530070e-02f,
  1.16848499e-02f, 3.81560102e-02f, -1.30972937e-01f, 6.78130463e-02f, 8.32037255e-02f, -2.58602519e-02f, -1.20318674e-01f, -1.00315727e-01f, -4.03006524e-02f, -8.37780163e-02f,
  3.95062082e-02f, -1.00975707e-01f, -4.48769256e-02f, 5.39073944e-02f, -3.82849313e-02f, 5.06660677e-02f, -3.31865586e-02f, -1.00384802e-02f, 2.07562707e-02f, -4.61519025e-02f,
  -1.38838694e-03f, 3.88274007e-02f, -1.74502004e-03f, 2.95411348e-02f, -4.38635685e-02f, -1.41875762e-02f, 6.33097440e-02f, 2.91027483e-02f, -2.22865418e-02f, -2.98074763e-02f,
  -7.22780526e-02f, 4.55187075e-02f, 6.66386634e-02f, -1.89069391e-03f, 3.46776061e-02f, -7.41693657e-03f, 4.05135415e-02f, -7.70769939e-02f, -3.07426061e-02f, 3.75561789e-02f,
  -6.16482124e-02f, -4.72607277e-02f, 2.09044125e-02f, -2.34120265e-02f, 3.12336124e-02f, 4.77935486e-02f, -5.43434583e-02f, -6.16079643e-02f, 6.20073220e-03f, -1.63682420e-02f,
  2.02140063e-02f, 3.04677021e-02f, -3.94743010e-02f, 7.92652890e-02f, 4.69180848e-03f, 4.44194749e-02f, -3.78210545e-02f, 5.55243492e-02f, 2.15430297e-02f, 7.58327693e-02f,
  -4.32118550e-02f, 3.94320004e-02f, -4.16880436e-02f, 2.72659194e-02f, -2.75757294e-02f, 3.83492224e-02f, -2.81792204e-03f, 5.03979623e-02f, 5.73789179e-02f, -2.62712520e-02f,
  -5.08096516e-02f, -1.03799328e-02f, -1.06723811e-02f, -1.18038394e-02f, -2.52484884e-02f, 1.43541116e-02f, -1.92258768e-02f, 9.03172195e-02f, -4.02183980e-02f, 1.15555506e-02f,
  -6.86127273e-03f, -4.56103608e-02f, 6.60262555e-02f, -8.11952651e-02f, 1.37329306e-02f, -4.13921736e-02f, 4.98674996e-02f, -6.03505671e-02f, -5.53516373e-02f, -1.15440646e-02f,
  2.36742329e-02f, 4.52106856e-02f, 3.86620723e-02f, 2.96745244e-02f, 2.83065271e-02f, -4.65255491e-02f, -4.81446683e-02f, 3.09273116e-02f, 9.98087227e-03f, 6.92714425e-03f,
  -2.32469141e-01f, -8.37761462e-02f, 3.92943546e-02f, -5.68290204e-02f, 3.52706052e-02f, 1.41754329e-01f, 1.26092121e-01f, 7.12476894e-02f, -4.65203412e-02f, -1.16723485e-01f,
  2.81578768e-02f, -1.96984649e-01f, 9.62696820e-02f, -1.31167248e-01f, -1.73445165e-04f, 4.38927561e-02f, -8.38861708e-03f, -1.05765022e-01f, 2.74661593e-02f, -2.19699591e-02f,
  -4.40957248e-02f, -4.18801643e-02f, 1.36263728e-01f, 7.03674331e-02f, -3.65021802e-03f, 1.05485551e-01f, -1.08269595e-01f, 2.21247271e-01f, 4.39700065e-03f, -5.81413470e-02f,
  3.43529843e-02f, -2.55498011e-02f, -2.26309299e-02f, -1.20694591e-02f, 8.14534351e-02f, -1.67586729e-02f, -6.81579262e-02f, 9.90414917e-02f, -5.75391874e-02f, 4.01188582e-02f,
  -9.10629854e-02f, -4.28572223e-02f, 2.89575750e-04f, 7.68325664e-03f, -3.42358695e-03f, -4.72471751e-02f, -2.96822228e-02f, 3.87367047e-02f, 5.92437610e-02f, 7.32281655e-02f,
  7.91076869e-02f, 3.03009637e-02f, -6.54702857e-02f, -1.50577500e-01f, 2.11749389e-03f, 5.98119423e-02f, -2.86806244e-02f, 8.86565074e-02f, -1.88550074e-02f, -5.80392145e-02f,
  1.10577680e-02f, 5.13109379e-03f, -4.83899005e-02f, 2.19049435e-02f, -3.30758989e-02f, 1.34535031e-02f, -3.07936333e-02f, -6.65023848e-02f, 3.62205952e-02f, -2.77589262e-02f,
  -3.07529457e-02f, 2.35002320e-02f, 3.15932781e-02f, 2.19733473e-02f, -3.91800515e-02f, -6.84487224e-02f, -1.14140801e-01f, -5.95561303e-02f, 2.65167821e-02f, 9.05347839e-02f,
  -4.94298339e-02f, -8.39259401e-02f, 4.18543406e-02f, -4.93588932e-02f, 1.97224878e-02f, 4.78975428e-03f, 2.11007930e-02f, -1.41981114e-02f, -4.72146319e-03f, 5.32160774e-02f,
  8.73797163e-02f, -6.08668067e-02f, 7.33411089e-02f, -6.05558790e-02f, 2.50164829e-02f, 4.55604792e-02f, 8.59842345e-04f, -4.64258194e-02f, 3.22038941e-02f, -3.76423597e-02f,
  2.01931279e-02f, 1.37197496e-02f, -4.24955152e-02f, 1.45683242e-02f, 2.56382022e-03f, -1.92677081e-02f, -2.82019246e-02f, 1.96687435e-03f, -8.59654769e-02f, 9.34443250e-03f,
  -3.84366103e-02f, -1.14576757e-01f, 2.74897069e-02f, -2.00903416e-02f, 2.14115642e-02f, 6.20789081e-03f, -2.57620625e-02f, -3.07546742e-02f, -3.51067781e-02f, -4.59703915e-02f,
  -2.47373030e-01f, 6.48321658e-02f, 7.24878684e-02f, -2.83462778e-02f, -3.17058153e-02f, -2.57313579e-01f, -1.08057119e-01f, -3.56299840e-02f, 3.22845541e-02f, 1.26729339e-01f,
  -4.91366833e-02f, 5.44858947e-02f, 2.07465664e-02f, -1.29821151e-01f, -1.79344028e-01f, 3.13474275e-02f, -1.18706264e-01f, -4.27765734e-02f, -5.47321513e-02f, -1.03978075e-01f,
  -8.40031449e-03f, -1.55137777e-01f, -1.56641051e-01f, -2.81364769e-02f, -1.04554102e-01f, 2.49298885e-02f, 3.75087857e-02f, -8.77036825e-02f, 5.36226705e-02f, -7.78562874e-02f,
  -8.27430338e-02f, 1.10874526e-01f, 3.47266980e-02f, 1.02575883e-01f, 2.03167135e-03f, -9.79531929e-03f, -6.11050762e-02f, 2.43973657e-02f, -1.89286582e-02f, 5.54816052e-02f,
  7.86806047e-02f, 3.43870325e-03f, 5.45137329e-03f, -1.42629314e-02f, 5.21960184e-02f, -5.67572825e-02f, 6.97103329e-03f, 6.34222180e-02f, 1.61445644e-02f, -6.49014935e-02f,
  -5.05258106e-02f, -6.75271219e-03f, 9.89787746e-03f, -8.62289220e-03f, -1.83278159e-03f, -2.82096956e-02f, -1.39992908e-02f, 6.47752807e-02f, -2.53070774e-03f, -5.48424153e-03f,
  -3.69084589e-02f, 7.00408146e-02f, -2.40202714e-02f, -1.80871952e-02f, -2.23366097e-02f, 3.37521248e-02f, -1.77520178e-02f, -2.92868149e-02f, -6.36128560e-02f, 4.54348475e-02f,
  2.91916132e-02f, 3.05751693e-02f, -4.20741662e-02f, 3.65128517e-02f, 1.61674377e-02f, 8.14665928e-02f, -3.62076238e-02f, -2.58726603e-03f, -2.89747324e-02f, -3.88752744e-02f,
  1.60429918e-03f, -4.21211347e-02f, -2.13090498e-02f, 8.28418583e-02f, -5.89645691e-02f, -7.52027184e-02f, 2.08447166e-02f, -4.82374020e-02f, -4.95399758e-02f, -8.06487054e-02f,
  5.64669110e-02f, 3.41758877e-02f, 1.14252446e-02f, -7.47588696e-03f, 1.17869093e-03f, -2.14759558e-02f, 5.92242107e-02f, -7.32519478e-02f, 5.50403669e-02f, -5.65533638e-02f,
  3.86020280e-02f, -5.67220114e-02f, 8.49024057e-02f, -6.96825096e-03f, -7.08095282e-02f, 1.78660322e-02f, 4.12326530e-02f, -3.10277455e-02f, -5.18382527e-02f, -6.25975281e-02f,
  5.51542751e-02f, 2.37079188e-02f, 3.45663279e-02f, 1.01770228e-02f, 8.70435536e-02f, 1.89743638e-02f, 7.64042884e-02f, 2.68130023e-02f, 4.84815575e-02f, 6.40217075e-03f,
  -2.02480346e-01f, 2.01347228e-02f, 1.23543032e-01f, -2.17919853e-02f, -6.85000345e-02f, -2.11622089e-01f, -3.32567990e-01f, 4.24010009e-02f, -1.62974939e-01f, -7.61230439e-02f,
  -1.70137852e-01f, -1.84107758e-02f, -9.64640267e-03f, -2.08061829e-01f, -1.69226959e-01f, -1.01199135e-01f, -2.91476250e-01f, -9.03893039e-02f, 1.55832861e-02f, 5.01108319e-02f,
  3.88218462e-02f, -6.71126992e-02f, 1.25932172e-02f, 9.96203721e-02f, 2.30485853e-03f, 2.47140542e-01f, 2.31893107e-01f, 1.02093168e-01f, 2.50390172e-02f, -6.14730008e-02f,
  -1.29726768e-01f, -8.98683257e-03f, 8.14460143e-02f, 6.95728650e-03f, 3.07248309e-02f, -3.06726303e-02f, 7.98275769e-02f, 1.55736916e-02f, 6.39873967e-02f, 2.18526926e-02f,
  -3.44140604e-02f, 3.26426653e-03f, -7.54654631e-02f, 2.77526304e-03f, -2.25592311e-02f, -2.07826383e-02f, 8.72552618e-02f, -2.97202226e-02f, -3.38239856e-02f, -6.13085255e-02f,
  -2.24312674e-03f, -3.33914086e-02f, 1.57730877e-02f, -5.42475516e-03f, -7.19504012e-03f, -1.75893176e-02f, 2.03077998e-02f, -5.00624403e-02f, 9.50643700e-03f, -6.18950613e-02f,
  -6.94275275e-02f, 1.76773351e-02f, 4.29856665e-02f, 1.95179787e-02f, -3.82030709e-03f, 2.24351957e-02f, -1.09168026e-03f, 2.60121878e-02f, 2.10755952e-02f, -8.02725740e-03f,
  -8.56102444e-03f, 2.06649173e-02f, -4.38841134e-02f, -9.05492157e-03f, -4.69017252e-02f, -2.33958755e-02f, 2.17697024e-02f, -1.65370405e-02f, 1.41924359e-02f, -8.93060677e-03f,
  -4.47399952e-02f, -2.72703101e-03f, 7.36660883e-02f, -3.33155766e-02f, -3.24577354e-02f, 2.50365920e-02f, -1.80189181e-02f, 1.43390261e-02f, 2.07166392e-02f, -5.51294312e-02f,
  -5.57508208e-02f, 6.92961290e-02f, -1.28964894e-02f, -8.08922946e-02f, -2.10197885e-02f, 4.30521555e-02f, -6.83692023e-02f, -5.30767664e-02f, -2.58297729e-03f, -2.77433055e-03f,
  3.06390934e-02f, -4.67250906e-02f, 5.30934287e-03f, 1.76170468e-02f, -1.68235991e-02f, -2.13618260e-02f, 4.67764214e-02f, 3.00769359e-02f, 4.03275266e-02f, 9.37666669e-02f,
  5.38984910e-02f, 5.57093211e-02f, -5.59552088e-02f, -4.98610362e-02f, -8.73121712e-03f, -2.67438474e-03f, 1.56477112e-02f, -3.90653498e-02f, -1.61419995e-02f, -1.57119688e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.67323945e-02f, -2.89400835e-02f, -8.14059526e-02f, -7.12950751e-02f, -9.40093920e-02f, -2.96693332e-02f, 6.61325501e-03f, -8.55995715e-02f, 1.66120287e-02f, 2.50173779e-03f,
  1.02363214e-01f, 6.23817593e-02f, 7.46076107e-02f, -6.18645102e-02f, 1.25657185e-03f, 8.84161592e-02f, -1.02634735e-01f, 6.54617772e-02f, 1.28584802e-02f, -3.14883366e-02f,
  -5.02900966e-02f, 6.73762932e-02f, -1.23704039e-02f, 4.06383388e-02f, -3.46258767e-02f, -8.82928893e-02f, 5.50466366e-02f, 2.02041063e-02f, -5.81592433e-02f, 1.40566565e-03f,
  7.14185461e-02f, 5.11848405e-02f, -2.76713744e-02f, 4.34187949e-02f, -7.42949322e-02f, 6.15466833e-02f, 1.98829453e-02f, -6.85759857e-02f, -9.62792188e-02f, 5.07632233e-02f,
  2.35811453e-02f, -6.58533052e-02f, -3.58236432e-02f, -3.83404307e-02f, -1.05087511e-01f, -1.33392671e-02f, 4.28412482e-02f, 4.13146280e-02f, -4.04556561e-03f, -1.71175599e-02f,
  -6.61802068e-02f, 8.04091841e-02f, 5.10817766e-02f, 7.21746087e-02f, -5.96795715e-02f, -1.02060921e-02f, 8.74117576e-03f, 4.69383299e-02f, -6.75651133e-02f, 2.78304219e-02f,
  2.12495364e-02f, -9.66010541e-02f, -4.72441167e-02f, 7.34762996e-02f, 3.19783576e-02f, -3.11947186e-02f, -9.29655507e-02f, -7.33555108e-02f, -1.61166303e-02f, -7.54758492e-02f,
  5.57672344e-02f, -1.63840968e-02f, -8.70274603e-02f, -3.11243776e-02f, -8.93825293e-03f, 3.38548012e-02f, 3.70248668e-02f, -3.12122274e-02f, -6.58876076e-02f, 4.96638182e-04f,
  -1.25055248e-02f, 5.42973913e-03f, -5.47599420e-02f, 5.36785871e-02f, 1.73755717e-02f, 1.51031073e-02f, -6.49592057e-02f, -9.22141783e-03f, -4.60839905e-02f, 3.72758210e-02f,
  4.56560552e-02f, -3.17871906e-02f, -5.40261716e-02f, 7.60339573e-02f, 6.11083023e-02f, 3.02600730e-02f, 1.36694331e-02f, 4.04457711e-02f, -1.22469598e-02f, -7.45846033e-02f,
  -4.77597266e-02f, -5.82746118e-02f, 1.59455370e-02f, 7.82684702e-03f, -7.99874717e-04f, 3.80872041e-02f, 6.58039993e-04f, 2.84604598e-02f, -5.51791526e-02f, 8.51012543e-02f,
  -6.45729573e-03f, -1.46407988e-02f, 4.85390946e-02f, -1.04740418e-01f, -4.78450321e-02f, 2.03489326e-02f, -4.65550609e-02f, -4.69306745e-02f, 4.97031324e-02f, 6.57038987e-02f,
  1.09916985e-01f, -9.14768949e-02f, -2.06392109e-01f, 1.81083187e-01f, -7.91088119e-02f, -9.13868099e-02f, -1.18093021e-01f, 4.20627110e-02f, -2.05681875e-01f, -1.36866020e-02f,
  1.28865689e-01f, -5.91491070e-03f, -4.76006381e-02f, 3.44718695e-01f, 2.46154055e-01f, 8.76472294e-02f, 2.20870927e-01f, 6.29098713e-02f, -5.96469082e-02f, 6.46582693e-02f,
  1.93237484e-01f, 3.79608333e-01f, 3.12904090e-01f, 2.68468410e-01f, 1.83613122e-01f, 1.65026218e-01f, 3.21218699e-01f, 2.40924321e-02f, 3.29368562e-01f, 1.44382298e-01f,
  5.96057251e-02f, -1.05128393e-01f, 3.55391344e-03f, -4.50267233e-02f, -5.07251360e-02f, -4.32531051e-02f, -2.80363131e-02f, 5.70990033e-02f, 8.62090616e-04f, 5.04116900e-02f,
  -4.51008454e-02f, 1.11687243e-01f, 6.95544807e-03f, 2.39706300e-02f, 5.12714982e-02f, -8.11551288e-02f, 3.98412645e-02f, 2.76082614e-03f, -9.96788144e-02f, -5.83295561e-02f,
  -4.98678349e-02f, 1.56751610e-02f, 2.15622727e-02f, -1.74154546e-02f, -1.49970679e-02f, 1.54451625e-02f, -4.83642034e-02f, 1.38607342e-02f, -9.67193674e-03f, 5.36554679e-02f,
  -4.41177934e-02f, -5.43960230e-03f, 9.55158146e-04f, 1.13603622e-02f, -6.18357286e-02f, 6.96018711e-02f, 9.62777510e-02f, 7.81459883e-02f, -2.67975740e-02f, 9.29562673e-02f,
  3.53198051e-02f, -2.51466651e-02f, 1.57276485e-02f, 5.39689437e-02f, 4.70456928e-02f, -6.59248559e-03f, -2.07079649e-02f, 1.42113818e-02f, -4.59197499e-02f, 3.74373831e-02f,
  -3.81310284e-02f, -9.13529377e-03f, 4.20508645e-02f, -2.38396297e-03f, -2.47764196e-02f, -4.59260345e-02f, 7.03584477e-02f, -4.43314165e-02f, -3.07084396e-02f, -6.78116307e-02f,
  3.64245400e-02f, 1.56750694e-01f, -4.64854874e-02f, 3.56383994e-02f, -1.38981957e-02f, 3.69589706e-03f, -5.56372367e-02f, 8.61662179e-02f, 6.03123307e-02f, -5.19807972e-02f,
  -8.82538706e-02f, -6.34837002e-02f, -5.65272793e-02f, 8.21397267e-03f, -3.44907236e-03f, 2.65065432e-02f, 5.99766187e-02f, 1.28234765e-02f, 1.40223326e-02f, 1.12108514e-01f,
  6.43450348e-03f, -2.73250118e-02f, 1.29132271e-02f, -1.02895111e-01f, 1.38281258e-02f, -3.51925604e-02f, 7.38574117e-02f, 4.98577720e-03f, 3.37088294e-02f, 4.11937898e-03f,
  -6.55989200e-02f, -6.05855063e-02f, 1.25480577e-01f, 8.16700608e-02f, -6.60812780e-02f, 3.95589359e-02f, -5.24418950e-02f, 2.43476145e-02f, -6.21705726e-02f, -2.06115656e-02f,
  -9.12045687e-02f, 6.49550408e-02f, 3.98390330e-02f, 5.55284657e-02f, -8.00741091e-03f, 7.05543235e-02f, 5.73279858e-02f, 1.53977592e-02f, 4.86269146e-02f, -8.97197723e-02f,
  -1.08487390e-01f, -9.08204019e-02f, 2.97981985e-02f, 2.16734987e-02f, 2.46687885e-03f, 5.76769859e-02f, -1.10549023e-02f, -2.64492091e-02f, 8.32672268e-02f, -7.67173769e-04f,
  -9.48697850e-02f, 5.19786254e-02f, -3.89946112e-03f, 6.49630576e-02f, 1.91872139e-02f, -3.56706344e-02f, -1.94815509e-02f, 4.06043977e-02f, -4.92305271e-02f, -5.35992235e-02f,
  -2.27058586e-03f, -3.54564264e-02f, 6.04961701e-02f, -8.00931752e-02f, 3.47458944e-02f, 2.54154485e-02f, -2.63546854e-02f, 8.33493471e-02f, 7.00055882e-02f, -2.71566864e-02f,
  -7.21045863e-03f, -3.25570628e-02f, -7.00733364e-02f, -2.02628821e-02f, 3.14000528e-03f, -7.81152695e-02f, 1.90496854e-02f, 2.96985712e-02f, -4.03932817e-02f, 3.58468033e-02f,
  1.02849916e-01f, 5.75192794e-02f, 3.71296182e-02f, 6.14400655e-02f, -3.23623940e-02f, -3.53828296e-02f, 9.12299752e-03f, 1.64044392e-03f, -7.37349018e-02f, 1.44119486e-02f,
  4.99608442e-02f, -2.69356798e-02f, 1.42855626e-02f, -4.19301018e-02f, 7.91142657e-02f, 2.90431641e-02f, 8.87726694e-02f, 4.02426533e-03f, -8.57825857e-03f, 2.49896012e-02f,
  -1.00733437e-01f, 7.96670690e-02f, -1.07013965e-02f, -6.94109201e-02f, 8.82569700e-02f, 7.13380501e-02f, -7.09445551e-02f, 3.19160223e-02f, 3.97946984e-02f, -4.94915172e-02f,
  -6.17482439e-02f, -1.11357421e-01f, 7.89674819e-02f, -2.17670593e-02f, 4.62174416e-02f, -3.14755142e-02f, 7.45301321e-02f, 6.57796338e-02f, 5.91730662e-02f, 3.89860123e-02f,
  -1.00666784e-01f, 2.16476377e-02f, 6.66635334e-02f, 4.20753993e-02f, 7.79363438e-02f, -2.11874751e-04f, -7.56716505e-02f, -3.77715230e-02f, -1.51592400e-02f, -7.13387504e-02f,
  -3.24794557e-03f, -6.33910447e-02f, -2.95392936e-03f, 1.86866261e-02f, -4.01313268e-02f, -5.44301122e-02f, 5.35817742e-02f, -2.35288814e-02f, 1.74453133e-04f, -2.96207648e-02f,
  -6.08426146e-02f, -2.98568569e-02f, 1.12276319e-02f, 1.21539690e-01f, 2.90065259e-02f, -1.23154232e-03f, -1.02944970e-02f, -1.51778767e-02f, 2.28024703e-02f, 1.81150641e-02f,
  7.57468715e-02f, 1.52600929e-01f, 4.88221273e-02f, 1.39737934e-01f, 1.95385646e-02f, 1.22856766e-01f, 1.14002243e-01f, 9.52969342e-02f, -1.93246491e-02f, -4.76371422e-02f,
  -1.13878008e-02f, 3.23882103e-02f, 9.24008787e-02f, -4.16105017e-02f, -8.95940512e-03f, 3.69481966e-02f, -5.68709858e-02f, -3.60895991e-02f, 1.28127322e-01f, 1.92133673e-02f,
  -5.33095896e-02f, -4.94380854e-02f, -3.01423091e-02f, -1.33433780e-02f, 4.46331352e-02f, 1.96206197e-02f, -3.74302380e-02f, -1.05992798e-02f, 6.74958676e-02f, 1.65085811e-02f,
  -6.77774996e-02f, 5.45512214e-02f, 4.45956774e-02f, 5.23736030e-02f, -2.82303374e-02f, 7.23225251e-02f, -1.39467949e-02f, 3.06603387e-02f, 7.54291117e-02f, -1.04116285e-02f,
  4.71701324e-02f, -7.81542435e-02f, 6.37788996e-02f, 2.24902779e-02f, -7.63751864e-02f, -3.33973616e-02f, 6.25836253e-02f, -3.97469290e-02f, 8.21862444e-02f, -1.32092973e-02f,
  -5.69971874e-02f, 5.14147505e-02f, -7.73536712e-02f, 2.69412957e-02f, 7.65079409e-02f, 5.16380370e-02f, -6.88968450e-02f, 4.85190339e-02f, 2.74454150e-02f, -6.61932752e-02f,
  6.37745485e-02f, 8.60659704e-02f, -1.01209171e-02f, 5.91289401e-02f, -3.60775702e-02f, -3.16413268e-02f, 1.49378451e-02f, -7.38729686e-02f, -7.96961337e-02f, -3.90410013e-02f,
  4.65972014e-02f, -2.71020997e-02f, 1.78682953e-04f, -8.12329650e-02f, -8.44376907e-02f, 7.11557269e-02f, 1.49284173e-02f, -2.06514429e-02f, -7.20502734e-02f, 9.21684802e-02f,
  7.15178251e-02f, 1.36171412e-02f, 3.65892574e-02f, -8.13226849e-02f, -3.13858911e-02f, -2.27995683e-02f, 5.85823581e-02f, -3.72195654e-02f, 2.45872680e-02f, 6.46033213e-02f,
  -5.24178222e-02f, 4.34082141e-03f, -2.41744891e-03f, -1.44464131e-02f, 2.93487012e-02f, 3.69144902e-02f, 5.00807203e-02f, 1.99842621e-02f, 6.79471344e-02f, 8.69549587e-02f,
  9.08090547e-02f, 5.42919338e-03f, -4.47448203e-03f, 8.27110931e-02f, 7.91354198e-03f, 8.72966200e-02f, -6.14671595e-02f, -4.57570981e-03f, -6.47485182e-02f, 2.39267908e-02f,
  -7.86150098e-02f, 6.12367801e-02f, -4.53648493e-02f, 1.41662896e-01f, 9.28073749e-03f, -1.92330599e-01f, -9.98742059e-02f, 6.53279051e-02f, -4.55229022e-02f, 9.97894555e-02f,
  6.31548613e-02f, -1.09286821e-02f, 2.92041022e-02f, -7.05732182e-02f, -8.10723230e-02f, -3.16589139e-02f, -8.18139538e-02f, -1.47906803e-02f, 8.29104930e-02f, 7.09202588e-02f,
  -1.44288810e-02f, 8.42052698e-02f, 2.75064223e-02f, 7.69026875e-02f, 6.46411162e-03f, 1.31665379e-01f, 2.17968598e-01f, 5.81444688e-02f, 5.46871498e-02f, 2.43226364e-02f,
  -1.25628382e-01f, 1.97117507e-01f, 5.35722934e-02f, 6.63834661e-02f, 5.01096994e-02f, -7.93838948e-02f, 3.81859019e-02f, -3.14167626e-02f, 3.85040492e-02f, 2.83216499e-03f,
  6.61888719e-02f, -3.17607038e-02f, -6.90463260e-02f, 2.67515946e-02f, -4.50539067e-02f, 7.62626305e-02f, -4.16556969e-02f, -5.10405079e-02f, -9.12346244e-02f, -2.51619872e-02f,
  -3.34053636e-02f, 2.03124341e-02f, 5.46141602e-02f, -8.21566302e-03f, 1.15003616e-01f, 5.80693744e-02f, -9.56100672e-02f, 5.14770970e-02f, -1.52679188e-02f, -2.66973414e-02f,
  7.13592395e-02f, -1.63137726e-02f, 7.43703684e-04f, -2.66496800e-02f, 4.87625152e-02f, 4.43436811e-03f, 4.60813902e-02f, -1.79976337e-02f, -3.42202112e-02f, 6.67800941e-03f,
  9.56689287e-03f, 8.18008150e-04f, 1.02666523e-02f, -2.37923376e-02f, -1.62518416e-02f, 5.63760288e-02f, 3.01960893e-02f, 1.43945089e-03f, -4.17824201e-02f, -4.46809195e-02f,
  1.06562369e-01f, -5.07639609e-02f, -8.74586403e-02f, 2.27685068e-02f, 4.09789979e-02f, 1.59730446e-02f, 3.05372942e-02f, -3.39676514e-02f, -5.46911545e-02f, -3.40944864e-02f,
  8.42763633e-02f, 2.71795928e-01f, 2.50797998e-02f, -8.88881180e-03f, 2.67549064e-02f, 5.15241502e-03f, 4.65155616e-02f, 7.30063245e-02f, 4.76525091e-02f, 3.69721837e-03f,
  7.13257715e-02f, 6.08366057e-02f, 9.21434462e-02f, -5.97646497e-02f, -3.72715993e-03f, -1.35650998e-02f, 2.56232172e-02f, -5.06163053e-02f, 6.12551197e-02f, 6.15314655e-02f,
  1.31506994e-02f, -3.57707106e-02f, 2.63542179e-02f, -2.38519572e-02f, 8.74848105e-03f, 5.67351654e-02f, -7.72900209e-02f, 8.18315707e-03f, -4.40109745e-02f, 2.72576045e-02f,
  -2.72056937e-01f, 9.54825059e-02f, -2.34609976e-01f, 6.27617761e-02f, -2.91218832e-02f, 2.43311986e-01f, 2.01411664e-01f, -1.03822105e-01f, 1.55850127e-02f, 1.61670506e-01f,
  1.49864137e-01f, -7.32852370e-02f, 1.50345355e-01f, 3.07000399e-01f, 5.64090721e-02f, 1.72413766e-01f, 2.51558304e-01f, 1.87892035e-01f, -6.33175224e-02f, -2.75365775e-03f,
  -8.48719478e-02f, 2.18051136e-01f, -8.94310698e-02f, -4.22166027e-02f, 2.51162406e-02f, -2.19706118e-01f, 5.04976027e-02f, -1.96038261e-01f, -4.69192676e-02f, 2.11818423e-02f,
  -5.28723747e-02f, -2.54499558e-02f, -1.01466179e-01f, -8.14379305e-02f, -4.08122875e-02f, 8.63564294e-03f, 2.36123018e-02f, -2.41873413e-02f, -4.66046408e-02f, 1.50216799e-02f,
  -7.49759153e-02f, -4.94689085e-02f, -6.18790872e-02f, -8.31793398e-02f, 6.67860210e-02f, 2.07203832e-02f, -2.42697410e-02f, -9.54884291e-03f, -5.66526577e-02f, -3.06255724e-02f,
  -1.05725098e-02f, 5.85317910e-02f, 5.00552990e-02f, 3.24874520e-02f, 7.01220101e-03f, -3.78302671e-02f, 4.24588285e-02f, -2.07254756e-02f, 4.24066819e-02f, -8.96223336e-02f,
  4.58222395e-03f, -5.93971983e-02f, -2.44260244e-02f, 7.63759837e-02f, 5.30700050e-02f, -1.66306607e-02f, 8.67193192e-02f, -2.11055367e-03f, 1.63980909e-02f, -4.86250818e-02f,
  -4.05047089e-02f, 6.36291876e-02f, -4.97600101e-02f, 1.33253094e-02f, -2.94738207e-02f, 4.87238169e-02f, -5.07742278e-02f, -6.58449754e-02f, 3.26855145e-02f, 2.50457991e-02f,
  5.80481393e-03f, -7.37942681e-02f, 2.84268484e-02f, -1.60306282e-02f, -1.51644722e-02f, -4.59666401e-02f, 1.16087139e-01f, -2.31653266e-02f, -4.91667353e-03f, -5.15341647e-02f,
  3.27372998e-02f, -3.77987884e-02f, -5.49439946e-03f, -3.27009559e-02f, 8.94762501e-02f, -2.73476522e-02f, 2.15881374e-02f, 3.62594016e-02f, 6.71100914e-02f, -2.46900916e-02f,
  4.81473058e-02f, -2.82743685e-02f, -4.09988277e-02f, -5.93682416e-02f, 1.82858035e-02f, 2.52213497e-02f, -2.91312616e-02f, 4.43254746e-02f, 1.02815039e-01f, -7.99362585e-02f,
  -4.80905175e-02f, -3.26854065e-02f, 3.44093628e-02f, -1.26681915e-02f, 9.54266414e-02f, 7.65637960e-03f, -7.34567130e-03f, -9.30199251e-02f, 6.51127845e-02f, -2.42870394e-02f,
  3.01797111e-02f, 3.61275785e-02f, -1.60756912e-02f, -2.11301055e-02f, -9.89509001e-02f, 1.31736184e-02f, -2.12662295e-02f, -9.47436467e-02f, -3.10922936e-02f, 4.51443419e-02f,
  5.54694273e-02f, 1.87738892e-02f, 2.99421865e-02f, -3.13266031e-02f, 6.36912091e-03f, -4.53865416e-02f, -6.22216612e-02f, -1.95169803e-02f, -6.73977584e-02f, 6.11149706e-02f,
  2.73230448e-02f, -5.31588458e-02f, 1.41171776e-02f, -2.41112392e-02f, -1.05712220e-01f, -1.03606237e-02f, 1.41859278e-02f, -1.91429537e-03f, 1.51167065e-02f, -7.51985013e-02f,
  3.97683531e-02f, 1.64014064e-02f, 6.50846399e-03f, -2.74792537e-02f, -5.58370054e-02f, 3.93403508e-02f, -1.17216092e-02f, 6.49863034e-02f, -1.96448341e-02f, 3.03593501e-02f,
  -2.61297897e-02f, -7.88438246e-02f, -1.89430695e-02f, 3.26697864e-02f, -4.82315337e-03f, -5.96537404e-02f, -3.14385374e-03f, 9.06906053e-02f, -4.76789922e-02f, -8.74679983e-02f,
  -5.24526164e-02f, 9.06885862e-02f, 6.75840303e-02f, 6.49045110e-02f, 1.44606072e-03f, 3.15688439e-02f, 9.71424859e-03f, -4.62999567e-02f, 6.71105981e-02f, 4.66040075e-02f,
  -3.14209871e-02f, 6.23769537e-02f, 4.88882419e-03f, -8.90623853e-02f, 6.10978864e-02f, 5.11923921e-04f, 6.22666590e-02f, 5.20488843e-02f, 3.23993526e-03f, -4.60142419e-02f,
  -5.30391224e-02f, -5.11251651e-02f, -7.46294260e-02f, -4.89500612e-02f, 7.24299252e-02f, 2.49201269e-03f, -3.09152231e-02f, 7.14875758e-02f, 7.67611042e-02f, 6.03403524e-02f,
  3.04550473e-02f, -2.14081071e-02f, -6.41824380e-02f, -8.40065628e-02f, 2.78081801e-02f, -7.24532802e-05f, -7.22419694e-02f, 8.05715658e-03f, 6.89878240e-02f, 5.49991578e-02f,
  -6.81956187e-02f, 6.36769608e-02f, -9.03775841e-02f, 8.66891295e-02f, -5.63383773e-02f, -5.93166845e-03f, 7.59295598e-02f, -5.39955907e-02f, 4.16361727e-02f, 1.94914863e-02f,
  -8.89870822e-02f, -1.34314494e-02f, -1.02725506e-01f, -5.62912645e-03f, 6.80409372e-02f, -5.96662946e-02f, 9.05232131e-03f, 1.02526270e-01f, -7.43493959e-02f, -3.71955112e-02f,
  7.75896236e-02f, 4.01035510e-02f, 2.23934241e-02f, -1.07051926e-02f, -3.46439630e-02f, 7.09764138e-02f, -3.33419107e-02f, -7.88543224e-02f, -2.30735615e-02f, -1.74028799e-02f,
  -5.32214567e-02f, -2.57626213e-02f, 1.37753010e-01f, 2.73321592e-03f, 4.81312536e-02f, 9.56233069e-02f, 2.66195416e-01f, -1.89539328e-01f, 1.16904236e-01f, 2.82797795e-02f,
  1.13575555e-01f, -5.72129302e-02f, 1.99055210e-01f, -2.06816886e-02f, 1.74951285e-01f, 8.61133635e-02f, -1.26499236e-02f, 1.28652513e-01f, 4.30442113e-03f, -1.02338843e-01f,
  -4.40028012e-02f, -6.10600486e-02f, 6.31484613e-02f, -1.16715208e-01f, 1.47520723e-02f, -1.05722181e-01f, 6.27693161e-02f, 1.10647239e-01f, -9.44876149e-02f, 2.69308407e-02f,
  2.93473490e-02f, 2.47021765e-02f, -1.06401153e-01f, 2.19777580e-02f, -8.07880238e-02f, -3.04243211e-02f, -5.93988374e-02f, 9.73599330e-02f, 4.44302447e-02f, 7.00824931e-02f,
  -6.16888292e-02f, -1.16171073e-02f, 7.74965249e-03f, -3.83788534e-02f, -7.19336644e-02f, 1.84770133e-02f, -3.58624086e-02f, -7.44333267e-02f, 4.96149324e-02f, -1.65747926e-02f,
  1.65079515e-02f, -8.02001581e-02f, 1.31084034e-02f, 8.99333693e-03f, 3.96677479e-02f, -1.74754318e-02f, -3.32917012e-02f, 9.48552229e-03f, -7.63835758e-02f, -5.72735108e-02f,
  7.59396842e-03f, -5.19552305e-02f, -5.70018142e-02f, -1.73306186e-02f, -2.41613891e-02f, -5.66026345e-02f, -2.41067037e-02f, -4.11930345e-02f, -3.61529663e-02f, 9.02833883e-04f,
  -9.44879428e-02f, 8.04410726e-02f, -1.17359899e-01f, 3.56467776e-02f, 7.22598284e-02f, -8.68108422e-02f, 5.73576987e-02f, 8.80548730e-02f, 9.28514265e-03f, 1.04765035e-02f,
  1.13332815e-01f, 1.35818692e-02f, 2.81935092e-02f, 1.41214859e-02f, -1.77842695e-02f, 2.42153667e-02f, 5.23818545e-02f, -7.16685057e-02f, -3.22758667e-02f, 4.16856483e-02f,
  2.17453148e-02f, 9.82169285e-02f, -6.62217811e-02f, 5.41693047e-02f, 4.97403182e-02f, -3.55358832e-02f, -3.14051216e-03f, 4.41047177e-02f, 6.39801398e-02f, 7.87077770e-02f,
  -3.48420776e-02f, -2.76147854e-02f, -4.18938547e-02f, -6.10436127e-02f, -4.63392725e-03f, -4.30518910e-02f, 9.48954374e-02f, -2.86535528e-02f, 3.04455813e-02f, 5.44373691e-02f,
  4.77826297e-02f, -2.00505853e-02f, 7.51156956e-02f, -5.95472800e-03f, -4.70653176e-02f, 8.79989937e-02f, 2.91639715e-02f, 5.86490333e-02f, -4.45749536e-02f, 4.78087887e-02f,
  8.54636058e-02f, -3.23638916e-02f, 1.38642833e-01f, 7.14128511e-03f, -6.15092516e-02f, 1.36211198e-02f, 8.45344663e-02f, -7.00573474e-02f, -1.09203823e-01f, -1.23518221e-01f,
  -3.44227031e-02f, -4.40016985e-02f, -6.10843785e-02f, -1.02357874e-02f, 1.18208505e-01f, -7.93225169e-02f, 4.04425822e-02f, -6.41734228e-02f, 3.84707041e-02f, 2.16873437e-02f,
  -3.96919213e-02f, 3.24562821e-03f, 1.44489780e-01f, 8.72659162e-02f, 4.09295186e-02f, 1.09648302e-01f, 9.20384154e-02f, 5.15035959e-03f, -5.47115952e-02f, 1.14623584e-01f,
  -5.36225140e-02f, -6.77280277e-02f, 7.53497928e-02f, -5.37735969e-02f, -4.20792922e-02f, 6.69295490e-02f, 4.43555266e-02f, -4.83910367e-02f, -1.44997770e-02f, 2.12095268e-02f,
  -1.01350576e-01f, -5.27659096e-02f, 3.54447290e-02f, -4.07153107e-02f, 2.56891511e-02f, -1.99572109e-02f, -5.07317707e-02f, -4.13413793e-02f, -5.01927026e-02f, -1.76120233e-02f,
  9.54065099e-02f, -8.75500068e-02f, -3.67194624e-03f, -4.54512388e-02f, 3.69728915e-02f, -1.13603408e-02f, -3.26845087e-02f, -4.98719839e-03f, 4.63339314e-02f, 2.17025299e-02f,
  2.29921695e-02f, -2.88005900e-02f, -3.97963747e-02f, 4.15250137e-02f, -4.98517528e-02f, 5.86064570e-02f, 6.43365458e-02f, 7.46292248e-02f, 5.56519330e-02f, -3.73773873e-02f,
  -4.40079905e-02f, -1.06214052e-02f, -6.77446499e-02f, -1.63982324e-02f, 3.78604233e-02f, -3.99281047e-02f, -5.24818189e-02f, 3.16908471e-02f, 3.32372598e-02f, 6.07789606e-02f,
  7.89715424e-02f, 6.98034465e-02f, 1.01195224e-01f, 2.78366613e-03f, 8.26897696e-02f, -2.62133628e-02f, -7.30532855e-02f, -7.92518407e-02f, -2.19314117e-02f, 1.47695653e-03f,
  -1.11676499e-01f, -1.37464777e-01f, 6.01521358e-02f, 2.34641433e-02f, 3.90057564e-02f, -4.64144237e-02f, -8.21699724e-02f, -6.30044416e-02f, -1.47661427e-02f, -7.24985376e-02f,
  3.11100725e-02f, -1.36492690e-02f, 5.39682731e-02f, -3.12197395e-02f, 5.75439930e-02f, 2.96334783e-03f, -8.03077407e-03f, -3.34641337e-02f, -1.05298096e-02f, 6.71585724e-02f,
  7.96414018e-02f, 4.99119610e-02f, 2.53713802e-02f, -3.12080104e-02f, 6.47888780e-02f, 7.29869166e-03f, -1.96212512e-02f, -5.17843664e-02f, -4.73888358e-03f, -5.95516227e-02f,
  1.12227358e-01f, 2.32875301e-03f, 1.06906958e-01f, 6.76871538e-02f, -2.49155387e-02f, 9.82339215e-03f, -9.86946821e-02f, 4.66464907e-02f, 8.40892419e-02f, -6.18114956e-02f,
  5.83538087e-03f, 5.89791201e-02f, -9.80289876e-02f, 8.39288309e-02f, -1.58565596e-01f, -8.87665972e-02f, -8.90622810e-02f, 7.04866424e-02f, 6.68960214e-02f, 8.77567604e-02f,
  -6.52389824e-02f, -1.65173590e-01f, -5.44746332e-02f, 2.12207101e-02f, 1.26611188e-01f, 1.03563502e-01f, -1.25253335e-01f, -8.58891606e-02f, 7.04788119e-02f, -4.72788140e-02f,
  3.34237926e-02f, 5.90520687e-02f, 1.30636916e-01f, 6.79593682e-02f, -8.29690620e-02f, 6.43149167e-02f, -2.27159988e-02f, 4.53994833e-02f, 2.23096851e-02f, 2.69998424e-02f,
  5.61014935e-02f, -4.89983559e-02f, -7.25679770e-02f, 6.74687549e-02f, 1.10223489e-02f, 4.44416516e-02f, 4.33552526e-02f, 9.04098228e-02f, 8.69370103e-02f, -2.14858204e-02f,
  4.55158725e-02f, 1.03339918e-01f, 5.01294434e-02f, -2.47430429e-02f, 4.60773334e-02f, 1.73690245e-02f, -1.38846496e-02f, -6.47241399e-02f, 1.56095135e-03f, -2.57851295e-02f,
  3.62737589e-02f, -1.64474491e-02f, -9.27896202e-02f, -3.56978290e-02f, -1.26679745e-02f, 1.72738247e-02f, 5.11894263e-02f, 2.56598387e-02f, 3.15665193e-02f, -5.47746243e-03f,
  -2.57303677e-02f, -4.71602492e-02f, -4.09897752e-02f, 2.37903204e-02f, 3.28829624e-02f, -5.36613800e-02f, -8.22031125e-02f, -9.88419983e-04f, 3.75824533e-02f, -3.86804598e-03f,
  -5.19881509e-02f, -2.06969604e-02f, -4.10825126e-02f, -6.97637796e-02f, -8.18527490e-02f, -1.43658081e-02f, 3.19044888e-02f, 5.02040843e-03f, -5.77759556e-02f, -4.60483879e-03f,
  4.41028550e-03f, -1.37855217e-01f, -5.26067652e-02f, 5.33558875e-02f, -4.79562059e-02f, -4.18933816e-02f, -7.12196454e-02f, -4.52080928e-02f, 3.44137624e-02f, -4.30301838e-02f,
  -4.19589616e-02f, -6.13215603e-02f, 2.11013271e-03f, 6.95994198e-02f, 6.92596287e-02f, 1.37550021e-02f, -8.54621157e-02f, 6.93962127e-02f, 6.37551695e-02f, -4.59524803e-02f,
  5.99134760e-03f, -5.16683981e-02f, -3.95180956e-02f, -2.79310439e-02f, -3.52973081e-02f, -5.70951290e-02f, 1.45957537e-03f, -1.69183090e-02f, 3.22700292e-03f, -3.01463660e-02f,
  -1.70437530e-01f, 5.96119016e-02f, -1.30138218e-01f, -1.52567387e-01f, -4.19861451e-02f, -4.43382919e-01f, -4.59749758e-01f, -4.55559753e-02f, 5.34201488e-02f, -8.47792029e-02f,
  -1.37603477e-01f, -1.73965506e-02f, 7.17912465e-02f, -2.32565165e-01f, -1.55451715e-01f, 1.45744151e-02f, -4.03947651e-01f, -2.84853309e-01f, -2.38939151e-02f, -2.14587077e-01f,
  -6.47644177e-02f, -7.38532692e-02f, -8.30333084e-02f, -3.26937102e-02f, -2.36829713e-01f, -1.66127253e-02f, 9.75823682e-03f, -1.24586914e-02f, -1.82311833e-01f, 5.40611371e-02f,
  -9.42073464e-02f, 2.30422541e-02f, -3.12321596e-02f, 2.74776164e-02f, -1.47412032e-01f, -1.60809889e-01f, -1.60946041e-01f, -7.32811354e-03f, -3.62312198e-02f, -7.33430013e-02f,
  -3.35373287e-03f, -4.51432401e-03f, -1.39988875e-02f, 1.10736445e-01f, 4.02476750e-02f, 7.92458281e-02f, 8.69668126e-02f, -4.98467907e-02f, 2.72340197e-02f, 4.76883538e-02f,
  -3.40746343e-02f, -3.01098148e-03f, -5.66437244e-02f, 9.94798169e-03f, -1.46758351e-02f, -2.35645287e-02f, -3.17545645e-02f, -5.49863428e-02f, -9.24201012e-02f, -5.18198535e-02f,
  -4.23331708e-02f, 7.08493823e-03f, 4.50215302e-02f, 1.10010169e-01f, -7.96034038e-02f, 5.07104434e-02f, 7.86813870e-02f, 4.28355373e-02f, 6.91607445e-02f, -2.95284484e-02f,
  -6.88932464e-02f, -1.96406022e-02f, 2.27923272e-03f, -9.14592072e-02f, -1.17573753e-01f, -2.20510829e-02f, -6.02934789e-03f, 1.04574382e-01f, -9.93511230e-02f, -1.65246893e-02f,
  5.89991026e-02f, 6.72757551e-02f, -1.63631104e-02f, -4.47051525e-02f, 7.32885599e-02f, 2.63428222e-02f, -2.10701860e-02f, 3.25708352e-02f, -3.47420620e-03f, 9.55352618e-04f,
  -1.92995995e-01f, -9.36680660e-02f, 2.64515895e-02f, -9.12555400e-03f, 2.14837883e-02f, -1.23102367e-02f, -5.73316298e-04f, 3.13894562e-02f, -1.84585173e-02f, -2.07143649e-02f,
  -6.35299459e-02f, -2.55734287e-02f, -2.82627735e-02f, -2.98861004e-02f, -4.91951741e-02f, -2.37451922e-02f, -7.03935921e-02f, 4.43119975e-03f, -8.62813070e-02f, 1.59480572e-02f,
  2.86786966e-02f, -1.74446665e-02f, 4.29392867e-02f, 1.42534459e-02f, 4.25843336e-02f, -1.29843559e-02f, -2.39155628e-02f, 3.56769599e-02f, 6.60295133e-03f, -5.32915257e-02f,
  2.75611738e-03f, -4.33239825e-02f, -8.47148895e-02f, -4.77876440e-02f, 2.34395359e-02f, 1.35868117e-01f, 2.22699307e-02f, 8.15521106e-02f, 8.82849991e-02f, 4.71581109e-02f,
  1.41051486e-02f, 3.23332697e-02f, -8.12716335e-02f, 9.41152722e-02f, 9.01514292e-02f, 1.10609651e-01f, 1.19551942e-01f, 5.60678020e-02f, -2.97110397e-02f, -3.26002166e-02f,
  5.33674806e-02f, 6.83127046e-02f, 9.60594118e-02f, -6.53390074e-03f, -5.39769270e-02f, 6.20550066e-02f, 1.57509129e-02f, -1.87199228e-02f, 1.15062907e-01f, 4.24829796e-02f,
  4.38750684e-02f, 6.89467713e-02f, -4.21260521e-02f, -4.00840826e-02f, -6.02885373e-02f, -5.55088446e-02f, -2.56508719e-02f, -7.70498589e-02f, 4.50498834e-02f, 4.30424660e-02f,
  1.95409358e-02f, -6.92626163e-02f, -1.78575981e-02f, 3.42643000e-02f, -7.69721270e-02f, -9.21679363e-02f, -1.24238050e-02f, -1.82265863e-02f, -3.29937646e-03f, -3.05991117e-02f,
  4.55083475e-02f, -2.10507922e-02f, 5.15648797e-02f, 6.56271353e-02f, -9.22234450e-03f, 5.38797006e-02f, 9.41653829e-03f, -1.12934038e-02f, 6.28104759e-03f, -4.02356982e-02f,
  5.92620894e-02f, 8.36617202e-02f, 4.45657708e-02f, 1.08652450e-02f, -1.08886790e-02f, 2.03202050e-02f, 4.44026757e-03f, -7.27206245e-02f, 2.35842839e-02f, 8.31652284e-02f,
  -7.13479742e-02f, 9.85844955e-02f, 2.32599098e-02f, -7.21758157e-02f, 7.58538693e-02f, 7.99174681e-02f, -6.52107224e-02f, -5.72113059e-02f, -2.93506775e-02f, -2.64426265e-02f,
  -5.92504106e-02f, -4.85922992e-02f, -7.70499036e-02f, 3.57535705e-02f, 5.45566436e-03f, -9.04952586e-02f, -4.60235141e-02f, -5.37892878e-02f, 6.68803155e-02f, -7.96743259e-02f,
  7.33852433e-03f, 1.13462575e-01f, -7.58520365e-02f, 5.28186932e-02f, -8.77037048e-02f, 5.99350445e-02f, 8.34067538e-02f, 9.11370218e-02f, 8.87418687e-02f, 4.49895412e-02f,
  9.42463800e-02f, -6.98978221e-03f, -6.47547692e-02f, 7.44442418e-02f, 5.66850826e-02f, -2.54846178e-02f, 3.13907862e-03f, 6.98064938e-02f, 2.86052879e-02f, -2.02564541e-02f,
  5.36202565e-02f, -4.48241271e-02f, -5.06706573e-02f, -3.22107561e-02f, 2.25126855e-02f, 6.20693490e-02f, -1.57324634e-02f, -1.04534428e-03f, 3.69528569e-02f, 4.23320243e-03f,
  8.75167176e-02f, -9.56951752e-02f, -9.25188810e-02f, -1.13437869e-01f, -1.65410832e-01f, -3.62887979e-01f, -3.57330441e-01f, -1.93498820e-01f, -8.10629595e-03f, -7.70699605e-02f,
  -4.34302688e-02f, 1.57640889e-01f, 7.58631304e-02f, -1.63615838e-01f, 1.48309991e-01f, 1.05390266e-01f, -2.74786919e-01f, -1.33347064e-01f, 4.11914624e-02f, -7.10565969e-02f,
  -4.87869233e-02f, -2.56585717e-01f, -7.32167438e-02f, -1.17716305e-02f, -1.45587355e-01f, 1.42026425e-03f, 1.05251789e-01f, -1.14647105e-01f, -9.66153443e-02f, -1.00700289e-01f,
  -1.95128273e-03f, 1.06748432e-01f, 6.46684924e-03f, -7.07403012e-03f, -1.04627535e-01f, -7.08047301e-02f, -2.50570532e-02f, 1.02839977e-01f, -9.10554975e-02f, 6.58044368e-02f,
  -1.09354556e-02f, 2.18866579e-03f, -8.11442286e-02f, 5.10978587e-02f, -2.55954135e-02f, -7.00181052e-02f, 1.69781465e-02f, 1.29951807e-02f, 4.84592840e-02f, 8.66189077e-02f,
  2.73269266e-02f, -6.29533157e-02f, -5.22833951e-02f, 8.39451514e-03f, -1.98960910e-03f, -8.44540372e-02f, 6.62257299e-02f, 3.74820046e-02f, -3.74973081e-02f, -8.42108391e-03f,
  7.02356696e-02f, 6.53460994e-02f, -7.87366927e-02f, -1.23999012e-03f, 4.37008329e-02f, 7.44752288e-02f, -6.89999759e-02f, 4.35374044e-02f, -2.70721894e-02f, -4.11277041e-02f,
  9.23903584e-02f, 3.29014240e-03f, -2.76094954e-02f, -1.21491654e-02f, 2.24482045e-02f, 4.35496680e-03f, -5.73609583e-02f, 3.21957134e-02f, 3.53403389e-02f, 5.09798788e-02f,
  2.76347883e-02f, -9.57665890e-02f, 7.50632882e-02f, 7.78250843e-02f, -3.28679644e-02f, 6.07540319e-03f, 1.15935896e-02f, -3.33297290e-02f, 3.05157024e-02f, 4.39999439e-02f,
  -1.61058344e-02f, -5.39581031e-02f, -5.81379011e-02f, -3.31153087e-02f, 8.44207034e-02f, 4.31258641e-02f, -7.80354813e-02f, -5.68567179e-02f, -1.47145651e-02f, -9.22691599e-02f,
  -3.74290571e-02f, 8.03327933e-02f, 4.22508083e-03f, -2.68454757e-02f, -2.69355401e-02f, -8.11434463e-02f, -6.81178644e-02f, 8.70388187e-03f, -1.58376563e-02f, 1.17531288e-02f,
  2.14757435e-02f, 2.99378447e-02f, 8.04435313e-02f, 1.31107131e-02f, 7.47052655e-02f, -8.63513201e-02f, 5.17665558e-02f, 6.95357546e-02f, 9.60914977e-03f, -6.33126944e-02f,
  6.92462176e-02f, -1.28035933e-01f, 2.26559445e-01f, -5.99000528e-02f, 1.46094680e-01f, 1.26800999e-01f, 1.32477805e-01f, -1.20451704e-01f, -7.48893172e-02f, -1.73663974e-01f,
  8.98785293e-02f, 1.42708635e-02f, 7.38680735e-02f, 7.10169179e-03f, 2.25611538e-01f, -9.03561339e-02f, -1.37628138e-01f, 1.51394801e-02f, 1.10491998e-02f, 6.80402620e-03f,
  8.81379470e-02f, 4.07000259e-02f, -2.16849931e-02f, -1.43899366e-01f, 8.49067271e-02f, 1.19606778e-02f, -7.37435073e-02f, 1.61604404e-01f, 3.86176854e-02f, 9.10115838e-02f,
  -2.49807537e-02f, -9.88422409e-02f, -8.37635472e-02f, 7.56830275e-02f, -1.45047950e-03f, -7.76957199e-02f, -8.57098773e-02f, 7.16574118e-02f, 5.53419665e-02f, 2.71482952e-02f,
  -8.08850676e-02f, 6.38918877e-02f, -3.47327180e-02f, 6.17126487e-02f, -2.53265593e-02f, -9.79495328e-03f, 6.45749047e-02f, -1.65964998e-02f, -1.14187121e-03f, 2.61629187e-02f,
  -5.68628684e-03f, -4.17516157e-02f, -3.79157774e-02f, -9.22083184e-02f, 2.06228532e-02f, -9.28395167e-02f, -1.02672674e-01f, 3.77445966e-02f, 2.67893244e-02f, 2.12778915e-02f,
  -1.21819064e-01f, 1.45723335e-02f, 7.49198124e-02f, 3.78322341e-02f, 1.42274573e-01f, 9.15917978e-02f, 1.06459275e-01f, -3.48771550e-02f, 2.83405334e-02f, 8.63504037e-02f,
  9.14092213e-02f, -3.94801348e-02f, -7.76185980e-03f, 2.26898007e-02f, 2.03874707e-02f, 2.51244139e-02f, -3.25971544e-02f, -5.12551293e-02f, -8.21345299e-02f, 1.01557188e-02f,
  -9.41728577e-02f, -6.46905182e-03f, -4.56232280e-02f, 2.13377886e-02f, -8.47690403e-02f, -4.79819775e-02f, -9.74850804e-02f, 2.37569660e-02f, -6.91681653e-02f, 2.63297302e-03f,
  -2.26690397e-02f, -1.12715997e-01f, -1.67799592e-02f, -6.48737773e-02f, -1.01369270e-03f, -4.67019007e-02f, -2.57458556e-02f, -3.53772603e-02f, -1.52143296e-02f, -4.26300243e-02f,
  5.89527423e-03f, -7.74831418e-03f, 1.30109433e-02f, 2.09305044e-02f, -3.16814110e-02f, -2.49515977e-02f, -9.35109034e-02f, -6.46490827e-02f, -2.94472817e-02f, -8.20079222e-02f,
  3.28805707e-02f, 5.13002537e-02f, 1.25846311e-01f, -6.53791651e-02f, -1.13524690e-01f, -5.94980754e-02f, 2.44085807e-02f, 1.01951640e-02f, -5.92992939e-02f, -3.95227745e-02f,
  8.35728198e-02f, -5.87711036e-02f, -8.26776177e-02f, 1.10745821e-02f, 1.75474510e-02f, 7.85501227e-02f, 8.92188326e-02f, -2.12763939e-02f, 1.05667457e-01f, -4.44576778e-02f,
  9.77687016e-02f, -1.03922099e-01f, -3.50885130e-02f, -8.36142823e-02f, -7.63199478e-02f, -1.25113457e-01f, -2.58391444e-02f, -8.43328089e-02f, 2.77841166e-02f, 3.14831994e-02f,
  -1.35771129e-02f, -1.62756462e-02f, -7.31884316e-02f, -3.39075290e-02f, 9.46732163e-02f, 1.06539875e-01f, 5.99181950e-02f, 2.64591072e-02f, -4.77755442e-02f, -7.50424415e-02f,
  -4.73800639e-04f, -5.27566969e-02f, 5.23489043e-02f, 8.00388400e-03f, 2.60031335e-02f, 4.55503687e-02f, -5.71607128e-02f, 3.33684050e-02f, 5.98571859e-02f, -6.10058894e-03f,
  -1.12078600e-02f, 1.32807530e-02f, 1.02080556e-03f, 8.86138901e-03f, 7.38970339e-02f, 6.14566617e-02f, -1.16657279e-02f, -5.06613180e-02f, 1.24265440e-03f, -4.95807193e-02f,
  -2.79361829e-02f, -2.84975786e-02f, 3.99660179e-03f, -4.59936783e-02f, -7.72381946e-02f, 7.22265467e-02f, 3.34427319e-02f, 4.60740775e-02f, 4.73927222e-02f, -8.23239982e-02f,
  -2.47853585e-02f, 7.91694298e-02f, 6.88052252e-02f, -3.80136296e-02f, -4.52001132e-02f, 5.31990677e-02f, 3.59826721e-02f, 7.78611451e-02f, 7.29586110e-02f, -6.68333322e-02f,
  5.68734370e-02f, 8.70326236e-02f, 5.51149063e-02f, -4.10288014e-02f, 5.92556596e-03f, 2.53742505e-02f, 5.51969148e-02f, -5.08543588e-02f, 1.26613090e-02f, 5.64658307e-02f,
  -9.12695080e-02f, 3.21669020e-02f, 4.35555503e-02f, -4.22793673e-03f, 6.62836432e-02f, -1.70364026e-02f, -5.27893612e-03f, -2.02190988e-02f, 1.53182484e-02f, 4.24884073e-03f,
  8.48183259e-02f, -2.14275671e-03f, 4.97391112e-02f, -5.89059703e-02f, 5.09202592e-02f, 7.59543711e-03f, 3.00251655e-02f, 6.04896201e-03f, -6.60668388e-02f, -8.77691954e-02f,
  9.02599469e-02f, 6.83658570e-02f, -4.65515032e-02f, -5.51967099e-02f, 5.75018562e-02f, -3.27748396e-02f, -3.34826633e-02f, 3.09186559e-02f, -7.43006691e-02f, -6.08856976e-02f,
  -6.46786168e-02f, 1.09826513e-02f, 3.40052620e-02f, 1.61363371e-02f, 3.46569456e-02f, 7.26531148e-02f, 3.31855044e-02f, 2.44966219e-03f, 2.40825098e-02f, 1.19859707e-02f,
  -2.49472894e-02f, -4.22196537e-02f, -6.25980124e-02f, -1.49259031e-01f, 4.25538141e-03f, -8.88668448e-02f, -1.19726323e-01f, -4.41811755e-02f, -1.31380573e-01f, -1.71262518e-01f,
  -6.07833378e-02f, 8.58398452e-02f, -9.37769096e-03f, -9.40457210e-02f, 1.35017931e-01f, 1.61209062e-01f, -2.78461613e-02f, 5.30751515e-03f, -3.02767474e-02f, -1.53383136e-01f,
  -6.62707537e-02f, -3.45159732e-02f, 6.50860518e-02f, -2.52578557e-02f, -7.91950896e-02f, 6.38815109e-04f, 7.73224533e-02f, -4.00571190e-02f, -1.11533634e-01f, -5.44365905e-02f,
  -1.07054710e-01f, -1.56027839e-01f, -2.16622036e-02f, -8.21483657e-02f, -4.88232896e-02f, -2.82630064e-02f, 7.94400554e-03f, 3.03609222e-02f, -1.01723000e-02f, -9.59963277e-02f,
  -2.98632756e-02f, -5.13397716e-02f, 4.74920176e-04f, 1.02332450e-01f, -6.77353367e-02f, 2.25303266e-02f, -3.55909541e-02f, -2.00163946e-02f, 6.62641302e-02f, -6.52950183e-02f,
  -2.71938369e-02f, 4.60005626e-02f, 2.42271572e-02f, -1.41193988e-02f, 7.79232681e-02f, -9.66472253e-02f, 5.41687608e-02f, 1.47773298e-02f, 3.30491960e-02f, -2.85471212e-02f,
  -8.93546715e-02f, 5.21470001e-03f, -7.03187212e-02f, -8.21027309e-02f, -2.68574599e-02f, 3.01057030e-03f, 1.87002064e-03f, -4.85364795e-02f, -9.10304300e-03f, 6.37293234e-02f,
  7.71003142e-02f, 8.05061236e-02f, 8.99491459e-02f, 3.62921320e-02f, 7.06219487e-03f, -8.75130966e-02f, 6.27452433e-02f, -8.10562819e-02f, -3.97523828e-02f, 4.46877964e-02f,
  -6.56708628e-02f, 3.75994891e-02f, -7.99842030e-02f, -8.87489021e-02f, -1.42420689e-02f, 9.87567008e-02f, -3.42373066e-02f, -2.55044904e-02f, -1.66031532e-02f, 7.14137554e-02f,
  -2.07790304e-02f, -2.26771101e-01f, 3.15739885e-02f, 5.00716418e-02f, 2.00522467e-02f, 2.46507153e-02f, 3.60568278e-02f, 6.60000667e-02f, -3.03319935e-02f, -7.92821348e-02f,
  6.95546716e-02f, 3.31472419e-02f, -4.02453495e-03f, 1.01420972e-02f, -4.07752693e-02f, -5.19451462e-02f, -1.21656517e-02f, 1.47138657e-02f, -9.88839716e-02f, 2.82357959e-03f,
  4.58024293e-02f, 3.09470017e-03f, -8.00903216e-02f, 6.25343472e-02f, 3.81591246e-02f, -6.49982318e-02f, 4.66990247e-02f, -2.99314223e-02f, -5.34321852e-02f, 1.67161878e-02f,
  9.87296999e-02f, 4.46876371e-03f, -8.58072490e-02f, -2.75067743e-02f, -1.30944669e-01f, 6.80220798e-02f, 3.95391583e-02f, -1.18660234e-01f, -1.27392814e-01f, 7.19673932e-02f,
  5.41509390e-02f, -1.33289889e-01f, 2.41849750e-01f, 1.34235350e-02f, 1.51790321e-01f, 1.34937599e-01f, -2.66563892e-02f, 1.17463462e-01f, -1.20528772e-01f, 1.63110327e-02f,
  -1.05967252e-02f, 1.10207029e-01f, 3.14390026e-02f, -9.12086442e-02f, -1.10338353e-01f, -5.39593846e-02f, -4.01917286e-02f, -3.23169231e-02f, -9.45689604e-02f, 3.17504331e-02f,
  5.33866957e-02f, -2.21333038e-02f, 4.58600000e-02f, 2.23039314e-02f, 5.44245839e-02f, 9.04218629e-02f, -5.00623882e-03f, 7.97682777e-02f, -8.99591669e-02f, -3.19879092e-02f,
  9.15799737e-02f, -4.27824864e-03f, 8.09742138e-03f, -1.06303290e-01f, -8.12963247e-02f, -2.87419073e-02f, 1.73633844e-02f, -4.15611826e-02f, -3.67037728e-02f, -3.86100449e-02f,
  -9.48224078e-06f, 5.53682894e-02f, -5.71716726e-02f, -5.84906526e-02f, 3.21289487e-02f, -5.39154299e-02f, -4.89797592e-02f, 9.54165012e-02f, 2.46619689e-03f, 1.34622976e-02f,
  -9.49867740e-02f, -3.88691835e-02f, -2.42346488e-02f, 6.78581521e-02f, -5.33099808e-02f, -5.05665354e-02f, 7.21241385e-02f, 4.32255194e-02f, -8.03294331e-02f, 1.90483965e-02f,
  -5.65060647e-04f, -8.75051841e-02f, 8.66594240e-02f, 2.45778486e-02f, -3.85018401e-02f, 4.81513776e-02f, 2.26011239e-02f, 2.28479709e-02f, 2.09705140e-02f, 5.26322424e-02f,
  -3.70909050e-02f, -2.76843943e-02f, -6.23310618e-02f, -1.24530820e-02f, -7.34115392e-02f, -1.81586370e-02f, 1.21933138e-02f, -4.11636494e-02f, 7.95786753e-02f, -2.51078084e-02f,
  -6.07373230e-02f, -9.76358354e-02f, -7.30940420e-03f, -5.40831871e-02f, 2.15023551e-02f, -2.05067173e-02f, -1.18408184e-02f, -8.45067054e-02f, 9.62175056e-03f, 4.49789315e-02f,
  -9.14368406e-02f, 3.67421098e-02f, 3.02173756e-02f, 1.24902772e-02f, 3.20852064e-02f, -5.13233170e-02f, 2.24311817e-02f, 4.54269163e-03f, -8.19389820e-02f, -1.10946007e-01f,
  4.87614945e-02f, 5.93457557e-02f, -2.26672599e-03f, -3.98467332e-02f, -4.74673919e-02f, 6.77777231e-02f, 1.90670732e-02f, 6.70091212e-02f, 1.04717337e-01f, 1.81657635e-02f,
  1.73276186e-01f, -1.11251250e-01f, -2.77944142e-03f, 9.20900106e-02f, 6.70436993e-02f, 7.67121986e-02f, -3.65791917e-02f, -5.46664745e-02f, 2.28836183e-02f, -5.37964217e-02f,
  5.56088565e-03f, -4.88879830e-02f, -1.01407632e-01f, -3.58623639e-02f, 8.05895254e-02f, -1.61852956e-01f, 2.37508863e-02f, -5.74386492e-02f, 6.30549416e-02f, 5.06602461e-03f,
  1.00644127e-01f, 4.94615287e-02f, 4.59154174e-02f, -6.17131069e-02f, 1.01158895e-01f, 6.71812370e-02f, 4.42532897e-02f, -7.08318576e-02f, -6.10773675e-02f, 1.12836575e-03f,
  -7.75682181e-02f, 6.20074496e-02f, -5.41904978e-02f, -7.59142414e-02f, -1.78509566e-03f, -7.50562996e-02f, -1.62495561e-02f, 3.80618982e-02f, -7.70269148e-03f, -1.65127609e-02f,
  -3.66747528e-02f, 3.62873226e-02f, 9.47067514e-02f, -7.03610182e-02f, 1.42774452e-02f, -7.28246570e-02f, 1.44437598e-02f, 4.34052907e-02f, -1.56552773e-02f, -4.85582091e-02f,
  -1.04543166e-02f, -7.30043948e-02f, 1.88023672e-02f, -5.63546978e-02f, 5.39900325e-02f, 3.77364382e-02f, 3.39269415e-02f, 6.41676635e-02f, -4.20235358e-02f, 8.59665126e-02f,
  4.79215644e-02f, -9.42175463e-03f, -9.23753891e-04f, 5.73072657e-02f, -7.49552771e-02f, 7.76890218e-02f, -8.35503936e-02f, 6.63529858e-02f, 5.63958585e-02f, -6.59576654e-02f,
  5.43699078e-02f, 4.07549143e-02f, -2.13527190e-03f, -8.79337564e-02f, -4.41503860e-02f, -5.55383787e-02f, -7.94989988e-02f, -2.95267049e-02f, 4.91569564e-03f, -7.16662630e-02f,
  8.54996219e-02f, 5.94891235e-03f, -9.26989093e-02f, -2.04227585e-02f, 8.58496688e-03f, -6.55396795e-03f, -1.30216032e-02f, 6.65276358e-03f, -4.08010893e-02f, -7.72745833e-02f,
  -1.53503314e-01f, -2.96816677e-02f, 2.24203113e-02f, 1.78653526e-03f, -5.62420227e-02f, -3.33442949e-02f, 4.92065176e-02f, -9.40701142e-02f, -3.12726498e-02f, 4.44096029e-02f,
  -9.65863373e-03f, -1.26816146e-02f, -1.81626305e-02f, -7.44021311e-03f, 6.09768666e-02f, 3.10932398e-02f, -3.06906831e-02f, 5.89404777e-02f, 4.11618873e-03f, -8.31577182e-02f,
  4.08256017e-02f, -6.56397715e-02f, -5.41960560e-02f, 1.97126679e-02f, -8.23395401e-02f, -6.67734966e-02f, 7.20834434e-02f, 3.56585793e-02f, -3.91978547e-02f, -4.87336367e-02f,
  -8.61491486e-02f, -5.49015403e-02f, -5.55700809e-03f, -7.08095729e-02f, -2.70853937e-02f, 4.21677856e-03f, 1.79299433e-03f, -4.85903956e-02f, -9.24598519e-03f, -8.73270109e-02f,
  -1.16415307e-01f, 5.85565493e-02f, -8.76568351e-03f, -5.08854240e-02f, -7.92723894e-02f, -9.18021947e-02f, -1.10291228e-01f, -1.31420596e-02f, -5.02734371e-02f, -1.11554628e-02f,
  -3.81343905e-03f, 2.78155264e-02f, 9.14019346e-02f, 2.20963173e-02f, 7.92035684e-02f, -3.61414906e-03f, -4.38583307e-02f, 5.98281100e-02f, 3.79026271e-02f, 4.17030491e-02f,
  8.07151645e-02f, -6.83008911e-05f, 1.27511159e-01f, 4.98975553e-02f, -2.56739929e-02f, -2.30248719e-02f, 4.18159552e-02f, -2.28338838e-02f, 8.19031745e-02f, 7.10516572e-02f,
  1.52797857e-03f, 9.06378180e-02f, -2.70815240e-03f, 2.90684421e-02f, -7.80789275e-03f, 1.01632074e-01f, -6.79098442e-02f, 2.16001067e-02f, -5.21889376e-03f, -1.58039723e-02f,
  -2.87173633e-02f, 4.56304252e-02f, 7.43334666e-02f, 6.59730732e-02f, -3.51458490e-02f, -4.70392182e-02f, -8.73023570e-02f, 2.87823658e-02f, 2.02775337e-02f, -1.38057582e-02f,
  -8.24708715e-02f, -5.83802573e-02f, -8.93154889e-02f, 7.49405771e-02f, -7.26524414e-03f, 6.29627258e-02f, -3.85259045e-03f, -2.21957248e-02f, -1.91107914e-02f, -1.99903212e-02f,
  -3.17357108e-02f, 6.86121881e-02f, -8.35539103e-02f, -3.69719490e-02f, 5.08388393e-02f, 7.96475857e-02f, 6.92256168e-02f, 4.81006876e-02f, -4.08409396e-03f, -1.93493888e-02f,
  -1.27131715e-02f, -6.36933818e-02f, -3.95154441e-03f, 8.15662071e-02f, 1.52829522e-02f, -6.21729419e-02f, -2.78402623e-02f, -3.15008387e-02f, -1.91014144e-03f, -3.30989994e-02f,
  -2.79039657e-03f, 7.10317586e-03f, 6.30446384e-03f, 2.37025842e-02f, 7.75936097e-02f, -3.36108059e-02f, 3.79587971e-02f, -1.78575497e-02f, 5.68590127e-02f, -3.55377495e-02f,
  -3.22552323e-02f, -7.40880594e-02f, 5.22591993e-02f, -1.66536868e-02f, 7.24112689e-02f, -4.96855564e-02f, 8.09500590e-02f, -2.52376013e-02f, 7.83893745e-03f, -6.79593980e-02f,
  2.58789454e-02f, -7.38825947e-02f, -3.03639844e-02f, -6.93820789e-02f, -8.77783597e-02f, 4.72984649e-02f, -1.21000875e-02f, 9.20378417e-03f, -2.73334794e-03f, 7.44562447e-02f,
  8.05612430e-02f, -1.08310699e-01f, 1.77943513e-01f, -2.53616944e-02f, -1.05023868e-01f, -1.22966692e-01f, -2.43532434e-02f, -5.41945063e-02f, -1.07015871e-01f, -1.83549941e-01f,
  -5.26083261e-02f, 2.33811885e-01f, -2.39465442e-02f, 4.73182984e-02f, 1.67086869e-01f, 1.36111015e-02f, -7.16536641e-02f, 1.18159883e-01f, -8.36445540e-02f, -1.08043656e-01f,
  -5.41501269e-02f, -4.71918210e-02f, 3.33703905e-02f, -1.38649747e-01f, -1.31881431e-01f, -3.00509315e-02f, 8.46058801e-02f, 6.27427250e-02f, -6.55568913e-02f, 4.42766026e-02f,
  -1.00356199e-01f, -3.39777470e-02f, 5.38759679e-02f, -4.50868793e-02f, 3.56730842e-03f, -7.77617916e-02f, 1.04019836e-01f, 9.59279984e-02f, 5.74300028e-02f, 2.74760835e-02f,
  1.20553233e-01f, -5.89776449e-02f, -1.00932442e-01f, 2.84341723e-02f, 3.52887847e-02f, -1.69439185e-02f, 7.60264769e-02f, -6.11512586e-02f, -3.64967771e-02f, 2.07091291e-02f,
  -6.12511709e-02f, 2.85401233e-02f, -1.24866506e-02f, 1.12849876e-01f, 6.76776990e-02f, 2.25099996e-02f, 1.30066304e-02f, 6.39052093e-02f, -4.28672209e-02f, 4.35683094e-02f,
  5.16384169e-02f, -4.22565117e-02f, -4.71802149e-03f, -7.06912056e-02f, -4.05893847e-02f, -5.27069084e-02f, -1.91928726e-02f, -7.42415339e-02f, -4.00627442e-02f, -6.32772222e-02f,
  -7.63216764e-02f, 5.06803058e-02f, -6.48296699e-02f, 5.91763631e-02f, -1.05113210e-02f, 2.12168787e-02f, 1.18076414e-01f, -7.34422915e-03f, 4.66980115e-02f, -6.93956837e-02f,
  7.56667648e-03f, -7.57344142e-02f, 4.85023707e-02f, -7.52991140e-02f, -4.37860796e-03f, 1.10163845e-01f, -8.76201466e-02f, -2.75835395e-02f, 7.98887759e-02f, 1.79640148e-02f,
  -1.44385416e-02f, -1.20575786e-01f, 1.68210827e-02f, -1.28690684e-02f, -4.14468832e-02f, 5.47655895e-02f, -1.45295681e-02f, -8.03953856e-02f, 1.89453959e-02f, -6.93040118e-02f,
  -7.43528679e-02f, -1.96220987e-02f, 4.16262224e-02f, 1.33359293e-02f, -3.53312120e-02f, -4.28914167e-02f, -4.93794046e-02f, -6.27929857e-03f, 9.98665392e-03f, -8.15701485e-02f,
  2.24870443e-02f, -1.16831129e-02f, -1.32796401e-03f, 2.20096461e-03f, -3.03469468e-02f, -3.95977348e-02f, -3.12728845e-02f, 1.08831130e-01f, 1.27939865e-01f, -7.95937404e-02f,
  -3.10221948e-02f, 2.03753207e-02f, -9.03551206e-02f, -1.01675540e-01f, -1.41307490e-03f, -2.39980817e-02f, -8.10705200e-02f, 2.87471600e-02f, -5.36622144e-02f, -3.14274095e-02f,
  -3.16640735e-02f, -3.08743287e-02f, 3.21048498e-02f, -8.11859034e-03f, -1.51392110e-02f, -7.93747455e-02f, 4.68411781e-02f, -2.33513582e-02f, 4.13217880e-02f, 4.86938767e-02f,
  -4.00184207e-02f, -2.89058387e-02f, 3.87231037e-02f, -5.27922772e-02f, -4.62452546e-02f, -6.72691986e-02f, 9.86467078e-02f, -3.76446620e-02f, 8.13568234e-02f, -1.32026104e-02f,
  -3.98518238e-03f, 1.05407797e-01f, -3.52550559e-02f, 8.76256377e-02f, 9.01416391e-02f, 1.01632103e-01f, 5.64537048e-02f, 2.19619051e-02f, -8.61355513e-02f, -5.92393801e-02f,
  7.81868473e-02f, 7.04373792e-02f, -9.86532867e-03f, -7.07669035e-02f, -9.92741883e-02f, 6.77802563e-02f, 1.37826158e-02f, 2.72046663e-02f, 3.74063104e-02f, 2.86972299e-02f,
  -7.75623992e-02f, -1.21540083e-02f, 2.87373699e-02f, -1.40620461e-02f, -3.39510175e-03f, -6.53509647e-02f, 2.08491515e-02f, 4.63711768e-02f, -1.56516321e-02f, 2.39110086e-02f,
  -6.60167709e-02f, -8.65688249e-02f, 3.96855474e-02f, 1.71322506e-02f, -1.50806261e-02f, 2.11217012e-02f, 8.48169811e-03f, -1.71136819e-02f, -3.22596505e-02f, 2.60639358e-02f,
  4.74643931e-02f, 3.86387967e-02f, -3.97428907e-02f, -1.10048633e-02f, 2.90405960e-03f, -2.62009911e-03f, 6.42923564e-02f, -2.67943572e-02f, 1.36990100e-02f, -6.96030036e-02f,
  5.45588769e-02f, -5.05951867e-02f, 8.27327892e-02f, 6.52875528e-02f, 1.65263005e-02f, -8.06807429e-02f, 4.85558510e-02f, -3.31952907e-02f, 8.52383077e-02f, 3.37152928e-02f,
  -4.04927544e-02f, 2.12993305e-02f, -7.43479058e-02f, 2.86516994e-02f, 2.22456716e-02f, -4.05166708e-02f, -9.53854695e-02f, 2.32599396e-03f, -3.05130426e-02f, 3.19470614e-02f,
  -4.02738601e-02f, 8.26745853e-02f, -7.75845125e-02f, -5.16775474e-02f, -6.45936728e-02f, -2.29690224e-02f, -4.56815809e-02f, 8.35185051e-02f, -4.79867421e-02f, 5.47219031e-02f,
  1.60669964e-02f, -7.11623430e-02f, -6.96114153e-02f, 6.35657758e-02f, 1.84814595e-02f, 8.50544684e-03f, -7.22580180e-02f, 7.85115883e-02f, 8.64825472e-02f, -7.28400275e-02f,
  -9.04970020e-02f, -8.25088173e-02f, -8.69560316e-02f, 7.39682466e-02f, -1.28312126e-01f, -6.36276230e-02f, -1.62534982e-01f, 3.93505171e-02f, -4.29759920e-02f, -8.08854923e-02f,
  -2.88959462e-02f, 4.34705503e-02f, -3.80460434e-02f, -5.74456668e-03f, -6.67632595e-02f, 4.90112454e-02f, -8.02473351e-02f, 7.69238696e-02f, -1.37175601e-02f, -9.39091109e-03f,
  -5.14716953e-02f, -1.23087326e-02f, 1.00042179e-01f, -4.05940525e-02f, -1.01924039e-01f, 1.08223751e-01f, 2.13321604e-04f, -3.38761369e-03f, 6.79267431e-03f, 6.17972985e-02f,
  -5.94721921e-02f, -4.93619479e-02f, 1.32756876e-02f, 2.27310285e-02f, -8.24915096e-02f, 3.71856615e-02f, 2.03969963e-02f, -7.94661418e-02f, -9.47411731e-03f, 2.21425900e-03f,
  5.91772199e-02f, -1.28431618e-02f, -2.46409085e-02f, -5.02549969e-02f, 4.28981483e-02f, 5.97544620e-03f, -1.77131649e-02f, -8.54293853e-02f, -3.95328999e-02f, 2.35347413e-02f,
  1.21980514e-02f, -8.62877592e-02f, 5.14938422e-02f, 6.77692443e-02f, 7.21013620e-02f, 2.38084653e-03f, -7.72970766e-02f, 6.48579001e-02f, -2.58033350e-02f, -1.04523309e-01f,
  -6.37106225e-02f, 7.36353323e-02f, -3.42270173e-02f, -4.47274521e-02f, -6.31245449e-02f, -3.87848802e-02f, 5.41236326e-02f, 3.79012637e-02f, 2.36862469e-02f, -7.05863461e-02f,
  7.50885829e-02f, 5.15982434e-02f, -9.18861851e-02f, -8.28440189e-02f, -1.95534993e-02f, 8.42735823e-03f, 5.48489280e-02f, -1.04376003e-02f, -3.95355374e-02f, 5.84947206e-02f,
  -6.97446242e-02f, 6.32011369e-02f, 8.30127373e-02f, 5.02404990e-03f, 4.42471169e-02f, -4.75882851e-02f, 7.61767328e-02f, -3.58317830e-02f, 1.09843444e-03f, 6.68592844e-03f,
  3.80090959e-02f, 7.14349300e-02f, -4.31540597e-04f, 3.78567874e-02f, -6.46632612e-02f, 3.94440927e-02f, -8.84825662e-02f, -2.68375445e-02f, -4.76298146e-02f, -3.59549234e-03f,
  5.15858307e-02f, -3.08178961e-02f, 2.69304346e-02f, 9.95721435e-04f, 6.50044158e-02f, -2.13525053e-02f, 6.25738576e-02f, 6.49889410e-02f, 5.10403737e-02f, 8.12967122e-02f,
  -2.42503006e-02f, 4.74137180e-02f, -4.81680594e-02f, 2.39485912e-02f, 6.09205179e-02f, 4.46999865e-03f, 5.29879667e-02f, 3.16481851e-02f, -4.96765189e-02f, 3.83114107e-02f,
  1.03346892e-01f, -1.14589306e-02f, -1.91257238e-01f, -8.50642771e-02f, -1.35676898e-02f, -6.83983555e-03f, -7.46327117e-02f, 2.01306827e-02f, -1.23350089e-02f, -3.38918320e-03f,
  1.67300671e-01f, -1.07608058e-01f, 2.35373690e-03f, 4.20455225e-02f, -1.74579420e-03f, 2.02873927e-02f, 1.14339784e-01f, 3.90740968e-02f, -8.41815025e-02f, 1.23094186e-01f,
  5.93046360e-02f, 1.81704447e-01f, -1.10621434e-02f, -1.47247994e-02f, 9.68417339e-03f, -8.77957139e-03f, 3.13778147e-02f, -3.22030075e-02f, -5.60824424e-02f, 6.80968538e-02f,
  -2.51220223e-02f, 7.73147121e-02f, 2.44505145e-02f, -7.85673633e-02f, 4.33393754e-02f, 1.51673444e-02f, 1.69944521e-02f, -7.51504302e-02f, 2.06438377e-02f, -6.31322637e-02f,
  2.23931903e-03f, -4.80414480e-02f, -3.42159010e-02f, 4.98967059e-02f, -7.90347084e-02f, 7.27104396e-02f, -5.59688658e-02f, 3.99978794e-02f, -1.06394261e-01f, 3.85794006e-02f,
  -2.75475662e-02f, -1.32062193e-02f, 6.05987851e-03f, -3.62721309e-02f, -5.91328330e-02f, -4.97409888e-02f, -1.59216691e-02f, 5.31167127e-02f, 1.65513402e-03f, 7.13451356e-02f,
  3.77259851e-02f, -3.80842686e-02f, -1.38320010e-02f, 3.60390521e-03f, -2.11335979e-02f, 1.68283675e-02f, 8.63416027e-03f, 5.07544652e-02f, -5.60554974e-02f, 1.09517640e-02f,
  3.15650105e-02f, -3.41245681e-02f, -5.82177266e-02f, -2.43595038e-02f, -4.61415648e-02f, -7.08511993e-02f, -8.42624754e-02f, -1.38803283e-02f, 2.62028873e-02f, 5.89913279e-02f,
  -6.77829981e-02f, -2.19317246e-02f, 2.32445635e-02f, 7.01477155e-02f, -2.04427913e-02f, 1.55608319e-02f, -3.12511213e-02f, 3.00991759e-02f, -4.25293371e-02f, -7.86583349e-02f,
  1.35525405e-01f, 8.86123553e-02f, -2.07706708e-02f, -2.64624376e-02f, -1.96116678e-02f, 1.02559468e-02f, 7.54179657e-02f, 3.33701149e-02f, -5.65986708e-02f, -2.77412310e-02f,
  -7.85039552e-03f, -7.00892061e-02f, -7.82886147e-03f, 4.67689969e-02f, -8.22449103e-02f, 1.35825481e-02f, 4.62403819e-02f, 5.73501401e-02f, 5.87169938e-02f, -1.67232305e-02f,
  -4.12185788e-02f, 1.10940367e-03f, -5.86863793e-02f, 2.34202109e-02f, 3.12846573e-03f, -3.21081318e-02f, 1.91136003e-02f, 9.16813780e-03f, -6.49326518e-02f, -1.89078879e-02f,
  1.38928041e-01f, 7.69349793e-03f, -1.30383208e-01f, -4.97308560e-02f, 5.07946983e-02f, 7.42874593e-02f, -6.05927035e-02f, 3.07770837e-02f, -1.47742793e-01f, 9.80657637e-02f,
  9.51229781e-02f, -4.29849513e-02f, -2.44377870e-02f, 1.44946221e-02f, 1.17504679e-01f, 7.26415887e-02f, 1.10745385e-01f, 3.85759473e-02f, 7.92401657e-03f, 3.03642750e-02f,
  -5.23610078e-02f, 1.47722632e-01f, -2.12190729e-02f, 5.07535897e-02f, 5.35550043e-02f, 2.85967421e-02f, 1.17626891e-01f, -1.76781546e-02f, 1.99057870e-02f, 4.49311081e-03f,
  4.32184972e-02f, -9.68258921e-03f, -6.33820379e-03f, -2.36839503e-02f, -4.91985157e-02f, -4.00722995e-02f, -5.45356311e-02f, 6.82383552e-02f, -5.67456074e-02f, 1.20308064e-02f,
  -1.04229609e-02f, -6.67894632e-02f, -2.09255796e-02f, -6.07132278e-02f, 8.31545293e-02f, -2.59110462e-02f, -3.40317786e-02f, 3.21095735e-02f, -3.74743827e-02f, 5.11796884e-02f,
  4.37038615e-02f, 1.91111844e-02f, 5.45563959e-02f, -1.05123827e-02f, -3.45211290e-02f, -5.08476831e-02f, 3.63496020e-02f, -5.66801317e-02f, -8.43261555e-03f, 6.45993128e-02f,
  -1.78490523e-02f, 3.92023139e-02f, 9.82958227e-02f, -2.83257887e-02f, -3.23241912e-02f, 5.21596847e-03f, 8.97166356e-02f, 6.97614998e-02f, -5.51096164e-02f, -2.36388836e-02f,
  1.05290804e-02f, 5.20366840e-02f, -8.62500817e-03f, -2.32760254e-02f, -5.32635190e-02f, -3.69815975e-02f, -5.90788275e-02f, -1.54976677e-02f, 6.77291900e-02f, 7.00045973e-02f,
  7.74265751e-02f, 5.37521485e-03f, -1.35876471e-02f, -9.23818443e-03f, -3.79224657e-03f, -1.84429493e-02f, 8.61093588e-03f, 8.54053572e-02f, -5.13543189e-02f, 8.54170248e-02f,
  5.90476468e-02f, 6.04876690e-02f, -4.24640551e-02f, 7.26183737e-03f, -6.13231137e-02f, 2.24711373e-03f, 6.02079704e-02f, 8.84623919e-03f, 6.48024958e-03f, 7.76031837e-02f,
  8.99408832e-02f, 1.81795228e-02f, 7.06463493e-03f, -6.21663816e-02f, 7.01574758e-02f, -5.88820279e-02f, 9.63423052e-04f, -7.84956142e-02f, -7.06350580e-02f, -8.42141509e-02f,
  4.01207246e-02f, -5.39244562e-02f, 5.67748994e-02f, 1.53695373e-03f, -7.68423453e-02f, -1.93172600e-02f, -4.30767722e-02f, 1.22515904e-02f, -4.07571457e-02f, 9.07487348e-02f,
  2.26371706e-01f, -2.48711072e-02f, -1.91076562e-01f, 3.62232178e-02f, -3.95812206e-02f, 5.66438697e-02f, 7.34736547e-02f, -6.39880728e-03f, -1.84523731e-01f, 1.07351534e-01f,
  5.38058355e-02f, -1.32037446e-01f, -8.23574290e-02f, 1.75371125e-01f, 1.48162186e-01f, 1.55214006e-02f, 2.13826329e-01f, 8.37565362e-02f, -2.11557560e-02f, 1.51479796e-01f,
  -8.57045222e-03f, 1.67128235e-01f, -1.01609282e-01f, -1.19473068e-02f, 4.51298729e-02f, -9.98805538e-02f, 6.29228726e-02f, -1.50277808e-01f, 4.04877402e-02f, -1.64049771e-02f,
  -1.15350503e-02f, 2.75721010e-02f, -1.03131756e-01f, 5.12915514e-02f, 8.97306129e-02f, 1.72489315e-01f, 2.14454811e-02f, -4.79790233e-02f, -5.23225851e-02f, -5.78601733e-02f,
  -1.96233802e-02f, -1.03581935e-01f, 6.33612927e-03f, 3.53108197e-02f, 4.54875343e-02f, 2.31737774e-02f, -1.21032029e-01f, -1.22352958e-01f, -1.02997512e-01f, -3.73370163e-02f,
  -5.41956648e-02f, -7.91851953e-02f, -5.20903729e-02f, -2.80885282e-03f, -7.85037875e-02f, 2.14132462e-02f, -1.16857097e-01f, -4.21447307e-02f, -5.96011244e-02f, -1.09614305e-01f,
  6.31490396e-03f, 3.47700366e-03f, 6.44288808e-02f, -6.10211454e-02f, 1.96365966e-03f, -1.60557218e-03f, -5.43862544e-02f, -9.37562659e-02f, -1.79018322e-02f, 9.46419016e-02f,
  8.13901797e-03f, -2.33147815e-02f, -4.62347083e-02f, -1.51858218e-02f, -6.61415653e-03f, 5.21627851e-02f, 2.32344470e-03f, -3.50251384e-02f, -2.23244820e-03f, -6.87051788e-02f,
  -9.65577457e-03f, -1.96552370e-04f, 2.36276388e-02f, 6.33202568e-02f, -6.12941682e-02f, 8.89894553e-03f, 1.11118302e-01f, 1.71286811e-03f, -7.32390024e-03f, 1.03653679e-02f,
  1.52785435e-01f, -2.40119956e-02f, 3.65175903e-02f, -3.50931957e-02f, 1.17649762e-02f, 2.20681392e-02f, 1.19400900e-02f, -4.25740518e-02f, 6.62156641e-02f, 5.83111420e-02f,
  1.39529452e-01f, 7.24752620e-03f, 1.06554218e-01f, -2.78004259e-02f, -4.08962220e-02f, 3.20194550e-02f, 1.30427359e-02f, -4.35131826e-02f, -2.54966412e-03f, 2.72219386e-02f,
  1.95214823e-02f, -6.51598126e-02f, -9.42796171e-02f, 1.12931076e-02f, -3.80715798e-03f, -7.06270039e-02f, -3.92276235e-02f, -1.03610367e-01f, -4.20066789e-02f, -9.86618772e-02f,
  4.81600314e-02f, 1.62695259e-01f, -3.80985811e-03f, 4.94743064e-02f, 2.55804639e-02f, 8.75695944e-02f, 9.77927819e-02f, -4.41181026e-02f, 1.70375973e-01f, -3.52120660e-02f,
  -1.34866703e-02f, 1.86018169e-01f, 1.15832957e-02f, -6.02314509e-02f, -1.33457288e-01f, -7.64212459e-02f, -6.12053536e-02f, 6.59843460e-02f, 3.24461721e-02f, -4.41757031e-02f,
  -8.03425685e-02f, -2.01780070e-02f, -4.72791791e-02f, -7.37607181e-02f, -2.18244269e-02f, -3.13716829e-02f, -6.34528622e-02f, -1.49899656e-02f, -1.46565598e-03f, -1.40456529e-02f,
  4.64412943e-02f, 1.02642275e-01f, -4.50982302e-02f, 9.55404416e-02f, -5.10017201e-02f, -5.08117713e-02f, 4.42153402e-03f, -7.63583705e-02f, 9.24814269e-02f, -4.81798835e-02f,
  -5.56402840e-02f, 1.49948504e-02f, -5.67935631e-02f, 5.35576046e-02f, 1.17443360e-01f, 7.98970535e-02f, 1.13994060e-02f, 4.25209887e-02f, -1.93776246e-02f, -4.40596007e-02f,
  -2.72030402e-02f, -1.06739225e-02f, -4.82438952e-02f, 4.48039845e-02f, -8.89842212e-03f, -4.91251564e-03f, 5.08850552e-02f, -5.32370619e-02f, 1.11108460e-01f, 9.40660834e-02f,
  7.04575032e-02f, 1.93782728e-02f, 1.46529330e-02f, 4.72965799e-02f, 2.55178544e-03f, 9.28568654e-03f, 6.42928854e-02f, 3.06685399e-02f, 5.20619862e-02f, 2.99452785e-02f,
  -6.18902892e-02f, 6.27956295e-04f, 1.64733771e-02f, 6.05476052e-02f, -6.44523054e-02f, -1.87053848e-02f, 1.40749605e-03f, -3.39250383e-03f, -2.39052121e-02f, -7.17757344e-02f,
  3.71278971e-02f, 2.55317874e-02f, -7.36608431e-02f, -4.51946408e-02f, -3.74425203e-02f, 5.35117611e-02f, -8.81946385e-02f, 1.21126799e-02f, 4.99081910e-02f, 4.79305387e-02f,
  4.98230122e-02f, 1.12025954e-01f, 5.12815081e-02f, -2.14137360e-02f, 4.36253473e-02f, -3.15774344e-02f, 5.48549853e-02f, -2.63659526e-02f, -7.29414523e-02f, -4.16302681e-02f,
  2.49214340e-02f, -7.45311752e-02f, 8.12827945e-02f, -5.43743670e-02f, -7.36441389e-02f, 5.29737808e-02f, -5.52457422e-02f, -2.21484900e-02f, 2.76403632e-02f, 5.98637201e-02f,
  -3.93000618e-02f, 7.81694055e-02f, 2.83092633e-02f, 5.31003997e-02f, -3.99599522e-02f, 5.91229647e-02f, -6.35897517e-02f, 7.27182850e-02f, -4.41335374e-03f, 3.93357920e-03f,
  1.38394594e-01f, -2.98071057e-01f, -3.58292200e-02f, 1.40523642e-01f, 1.56258389e-01f, 5.09863608e-02f, -2.54202783e-02f, -7.62835098e-03f, -1.01461910e-01f, -1.34424701e-01f,
  2.41075382e-02f, 7.54600437e-03f, -1.79828823e-01f, 4.50476930e-02f, 2.01000273e-01f, -1.26095697e-01f, 7.08345175e-02f, 2.71192309e-03f, 2.98445690e-02f, -1.84017662e-02f,
  1.22627072e-01f, 1.60679221e-01f, 1.25315189e-01f, 1.15718417e-01f, 1.09564126e-01f, 5.48199192e-02f, 6.44012913e-02f, 8.65448862e-02f, 1.64913759e-01f, 1.32472128e-01f,
  3.70928715e-03f, -4.24795002e-02f, -4.50776182e-02f, 3.43606435e-02f, 3.29266489e-02f, -7.73542896e-02f, -7.79403150e-02f, 1.19009145e-01f, -2.46682893e-02f, -4.61934395e-02f,
  7.60719925e-03f, -1.61857549e-02f, 1.33627251e-01f, 5.20618595e-02f, 4.61155958e-02f, 4.90069613e-02f, 6.45163730e-02f, 3.68091278e-02f, -7.11249486e-02f, -5.66642731e-02f,
  8.36930610e-03f, 5.96053116e-02f, -8.15239735e-03f, 5.71319461e-02f, 5.55201694e-02f, 1.02243192e-01f, -2.45880168e-02f, 2.72555910e-02f, -4.43875268e-02f, -4.81859595e-02f,
  -1.39025822e-02f, -4.62355055e-02f, -8.84062573e-02f, 4.66566086e-02f, 3.87904188e-03f, -9.18577798e-03f, 8.16297084e-02f, 6.10393398e-02f, 1.12837795e-02f, 1.91973094e-02f,
  -3.06663718e-02f, 8.50701332e-02f, -7.75327310e-02f, 4.38259020e-02f, 1.70751158e-02f, -1.03250459e-01f, -1.07468488e-02f, -1.42372418e-02f, 3.19747813e-02f, -7.30123073e-02f,
  1.25989048e-02f, 3.23359296e-02f, -7.68544525e-02f, 7.94714019e-02f, -4.59044725e-02f, 1.79525893e-02f, 5.30241206e-02f, -1.06980048e-01f, 4.29420471e-02f, -2.38765832e-02f,
  -1.70982629e-01f, -1.80107072e-01f, -3.07336636e-03f, 1.08524691e-02f, -5.60366549e-02f, -3.34797651e-02f, 7.46437982e-02f, -9.18704197e-02f, -9.00902040e-03f, 4.10317741e-02f,
  -1.73231922e-02f, 2.93490272e-02f, -1.07940271e-01f, 7.07027782e-03f, -7.14747831e-02f, -5.20553961e-02f, -6.97410246e-03f, -3.73654589e-02f, -4.97518666e-02f, 5.58947735e-02f,
  -9.06453803e-02f, -6.43422306e-02f, -2.50197086e-03f, 7.35384300e-02f, 4.64460962e-02f, 2.40198113e-02f, -4.57898937e-02f, 3.73043492e-02f, 2.75024995e-02f, 3.72481421e-02f,
  -3.68181050e-01f, 4.76360731e-02f, -1.11672483e-01f, -7.30130598e-02f, 4.67965659e-03f, 1.72992513e-01f, 6.07148111e-02f, 6.66209161e-02f, -8.82092565e-02f, 2.08636746e-01f,
  2.01739892e-01f, -1.97141692e-01f, 1.26375467e-01f, 3.30894217e-02f, -7.63382539e-02f, -1.76712889e-02f, 1.97089072e-02f, 1.17494658e-01f, -8.21793005e-02f, -7.78679624e-02f,
  -8.32680091e-02f, 4.06360626e-02f, -6.79067671e-02f, 3.49249355e-02f, 4.56593893e-02f, -7.25846887e-02f, 7.82387629e-02f, 5.96269742e-02f, 5.67509867e-02f, 9.14089382e-03f,
  -7.25011081e-02f, 1.58333443e-02f, 3.88796777e-02f, -3.73644233e-02f, 4.68274392e-02f, 5.20688631e-02f, -9.31929499e-02f, 5.48398644e-02f, -1.04407080e-01f, 4.84880581e-02f,
  -1.04262000e-02f, 3.80530693e-02f, 3.92345376e-02f, 3.20053250e-02f, 1.86140314e-02f, 3.34401242e-02f, 7.52439350e-02f, 4.72041778e-02f, 3.83383408e-02f, -7.94132501e-02f,
  7.85692260e-02f, 6.09983318e-02f, 2.04429985e-03f, 4.73972857e-02f, 3.79439853e-02f, -4.63489406e-02f, 6.65104110e-03f, -3.94485965e-02f, 5.99208251e-02f, -2.57569682e-02f,
  4.84866351e-02f, 6.14977852e-02f, 8.35243165e-02f, 5.77750010e-03f, -2.14658901e-02f, 9.50482860e-02f, -6.26142099e-02f, -1.02875242e-02f, 5.68045899e-02f, 3.71927805e-02f,
  1.45572424e-02f, -5.60240149e-02f, -5.71593121e-02f, -2.74268519e-02f, 5.50971664e-02f, -1.72473851e-03f, -6.51736483e-02f, 2.59828698e-02f, -6.95919693e-02f, -1.35170100e-02f,
  -2.06529070e-02f, 6.09455109e-02f, 7.70268738e-02f, 3.05993259e-02f, -5.99914640e-02f, -1.03056058e-01f, -4.04127762e-02f, -7.39234760e-02f, -7.50165060e-02f, -6.57109870e-03f,
  9.71412361e-02f, -5.00471704e-02f, 1.30636618e-02f, 6.07717261e-02f, -3.46462354e-02f, 6.50944840e-03f, 9.50690592e-04f, 3.09506562e-02f, 3.10448073e-02f, 2.82209013e-02f,
  -5.71107492e-02f, 1.48354974e-02f, 5.86202815e-02f, -3.82214859e-02f, 3.29500362e-02f, 5.52691184e-02f, -4.74867597e-03f, -9.26928222e-02f, 5.00599146e-02f, -7.15373233e-02f,
  -6.08285554e-02f, 4.81239781e-02f, -4.11646813e-02f, 3.94454598e-02f, -5.46751870e-03f, -3.34034488e-02f, 4.52553034e-02f, -8.09041131e-03f, 4.86513861e-02f, 6.47767931e-02f,
  -6.07629307e-02f, 6.34422749e-02f, 2.59217937e-02f, -4.87328060e-02f, -1.30769387e-01f, -9.64065897e-04f, 3.28949913e-02f, 1.28702156e-03f, 1.14958435e-02f, 6.73863962e-02f,
  -3.85192335e-02f, 1.54661566e-01f, 1.05700761e-01f, 4.81649209e-03f, 1.10996649e-01f, -4.77769636e-02f, -1.06560484e-01f, 2.57248972e-02f, 3.24986018e-02f, -9.94215608e-02f,
  2.54397690e-02f, -1.52649909e-01f, -4.51556742e-02f, -1.48137122e-01f, -6.77324086e-02f, 5.56735918e-02f, 8.15910101e-03f, -5.42794764e-02f, -2.56906934e-02f, 2.15122607e-02f,
  3.14252377e-02f, 5.95418587e-02f, 1.67265944e-02f, -1.88000295e-02f, 5.10582104e-02f, 2.43838951e-02f, 2.65110787e-02f, -2.79788133e-02f, -3.38814221e-02f, -3.98181491e-02f,
  -1.65253151e-02f, 2.21469272e-02f, 5.60631081e-02f, 6.24040253e-02f, 6.58994615e-02f, -1.24144591e-02f, -7.56526664e-02f, -1.09522780e-02f, 9.49790552e-02f, 1.58578102e-02f,
  8.70955810e-02f, 4.19710875e-02f, 1.23750996e-02f, 3.75965573e-02f, -6.02944121e-02f, 2.96063107e-02f, -4.40862291e-02f, 6.88130618e-04f, 6.47999868e-02f, -3.45663652e-02f,
  -1.39613710e-02f, -2.45477725e-02f, 4.99425572e-04f, -8.41826275e-02f, 8.87115970e-02f, 5.48684523e-02f, -7.94843584e-02f, 5.29191643e-02f, 7.34720752e-02f, 7.14223534e-02f,
  -5.41276410e-02f, 3.76476832e-02f, -5.04800901e-02f, -3.19628045e-02f, -1.44780045e-02f, 4.31979746e-02f, 3.03255860e-02f, 4.88679297e-02f, 5.70949279e-02f, 3.48028839e-02f,
  2.15672068e-02f, 2.11130027e-02f, -2.80419346e-02f, 3.21164243e-02f, -4.21135454e-03f, 1.66551303e-02f, 7.58569986e-02f, 1.08108208e-01f, 5.48245795e-02f, -5.62245622e-02f,
  -4.82232310e-02f, -5.10578565e-02f, 7.77162239e-02f, 4.64611575e-02f, -1.69616309e-03f, -1.07705593e-01f, 4.57425714e-02f, -7.33010620e-02f, 2.30347291e-02f, -4.43084314e-02f,
  5.21718599e-02f, -6.37863204e-02f, -4.51943539e-02f, -8.62126872e-02f, 7.17934147e-02f, 9.97949913e-02f, -1.86945684e-02f, -2.68746112e-02f, -4.32564318e-03f, -7.04962239e-02f,
  -2.12738477e-03f, -5.39661124e-02f, -1.13680493e-02f, -1.31834131e-02f, 6.43712794e-03f, 1.95083842e-02f, 5.90803847e-02f, 2.65453551e-02f, -6.15568236e-02f, -5.04515506e-02f,
  4.73627783e-02f, -5.68029247e-02f, 1.12762870e-02f, -1.17765345e-01f, 1.70459449e-02f, 5.74863181e-02f, -2.52250116e-02f, -4.97892462e-02f, -1.03662699e-01f, -1.44770637e-01f,
  6.06799982e-02f, -7.62530193e-02f, 6.18592463e-02f, -6.86887875e-02f, 6.52769431e-02f, -5.14842123e-02f, -5.98846525e-02f, -1.26921132e-01f, 6.75932765e-02f, -5.33916317e-02f,
  4.22556177e-02f, -7.57697374e-02f, -1.05331736e-02f, 8.02998915e-02f, -8.83525461e-02f, -5.18675707e-02f, -5.49598746e-02f, 8.63208324e-02f, -2.13511791e-02f, -2.04400979e-02f,
  7.35789016e-02f, 5.20746522e-02f, 1.20769545e-01f, 8.30932558e-02f, -4.45559174e-02f, 2.14817803e-02f, 4.18012738e-02f, 3.71236950e-02f, -1.69981830e-02f, 6.05690554e-02f,
  -9.32734087e-02f, 2.06027599e-03f, 4.14379843e-04f, -7.30544776e-02f, 2.66594812e-02f, 6.32850230e-02f, -2.08390988e-02f, -6.64429814e-02f, 3.82547267e-02f, 2.11782828e-02f,
  -1.40309958e-02f, -8.35402682e-02f, -1.21990241e-01f, 4.60826270e-02f, -3.97327207e-02f, 8.00244436e-02f, 4.03958336e-02f, -1.83843430e-02f, -8.04079846e-02f, -7.35504404e-02f,
  -9.89570171e-02f, 2.68370472e-03f, 2.58414950e-02f, -6.42302632e-02f, 3.98544632e-02f, 3.54130715e-02f, -7.53262192e-02f, -5.97963743e-02f, -7.10226521e-02f, -3.65035720e-02f,
  8.00560489e-02f, -6.48638308e-02f, -5.96340746e-02f, 3.28770168e-02f, -3.36538330e-02f, 6.07811846e-02f, 2.50891503e-03f, -6.25239983e-02f, 4.38481718e-02f, -3.72276120e-02f,
  1.25385700e-02f, -9.51298475e-02f, -5.17284945e-02f, 8.46514553e-02f, 7.88216442e-02f, 3.00807841e-02f, 9.03801585e-04f, -6.42042607e-02f, 1.94189642e-02f, -8.72345269e-02f,
  1.38158888e-01f, -1.56588368e-02f, 9.43725631e-02f, 3.57464813e-02f, 7.44606480e-02f, 4.23891656e-02f, 7.35926628e-02f, 3.55927981e-02f, 8.20377544e-02f, -7.82961249e-02f,
  -4.46586646e-02f, 5.65414764e-02f, -6.90025687e-02f, -7.16074556e-02f, 1.78916398e-02f, 4.77212220e-02f, -1.20866597e-02f, 4.25031688e-03f, 1.31598245e-02f, -6.53728284e-03f,
  1.43840332e-02f, -5.04220426e-02f, -2.22913735e-02f, 1.18256351e-02f, -8.43454972e-02f, -5.03886305e-02f, 5.12025543e-02f, -4.64641768e-03f, -3.48152667e-02f, -1.04928121e-01f,
  7.69699365e-02f, 7.69813657e-02f, 1.81618929e-01f, 2.27007598e-01f, -6.91697299e-02f, -1.55862585e-01f, -1.33287042e-01f, 5.26704593e-03f, 1.08313330e-01f, 1.29841957e-02f,
  -1.38408110e-01f, 1.88192502e-01f, -1.10388830e-01f, 6.14749342e-02f, -4.91755828e-02f, -3.52828838e-02f, -7.76034966e-02f, -9.62114185e-02f, 1.65091250e-02f, 1.21728301e-01f,
  -2.08538938e-02f, 6.24742918e-02f, 4.81243283e-02f, 1.00949481e-02f, 1.32962856e-02f, 1.82378173e-01f, -3.64896059e-02f, -2.02896763e-02f, 8.77517611e-02f, 1.19340802e-02f,
  3.20714973e-02f, 4.55489196e-02f, 1.05705500e-01f, 1.31075867e-04f, -3.63687798e-02f, 4.53286767e-02f, 1.02659017e-01f, -3.23793595e-03f, 5.60611039e-02f, 6.90629855e-02f,
  8.98517594e-02f, 8.75858963e-02f, 9.56786275e-02f, -9.68693048e-02f, 9.26955342e-02f, 8.26557204e-02f, -1.12536903e-02f, -5.33628603e-03f, 2.48692445e-02f, 1.70422066e-02f,
  1.84985697e-02f, -6.10261708e-02f, -3.12228762e-02f, -6.98420554e-02f, 7.48917460e-02f, 6.32177144e-02f, 2.01415084e-02f, -4.41346951e-02f, 2.51950789e-02f, -4.89590168e-02f,
  8.06230754e-02f, 1.32145677e-02f, 1.96566712e-02f, -4.23291232e-03f, 4.71321493e-02f, -9.20684892e-04f, -4.54342971e-03f, -7.94486776e-02f, -3.29325460e-02f, 2.77548488e-02f,
  5.43727865e-03f, -5.75145632e-02f, 3.28996927e-02f, 4.43267822e-02f, -6.69215759e-03f, -1.32054808e-02f, 6.84482008e-02f, -7.32738003e-02f, 8.10016170e-02f, -1.05829323e-02f,
  -9.03325062e-03f, -7.46895298e-02f, 5.57946339e-02f, 2.26967763e-02f, 2.71542799e-02f, -1.16954353e-02f, -1.75752062e-02f, -5.19109853e-02f, 5.83142154e-02f, -5.11971116e-02f,
  -3.56757604e-02f, 4.25444581e-02f, 5.84167242e-03f, -7.66226426e-02f, -3.29683423e-02f, -8.42576250e-02f, -2.17323680e-03f, 4.51069809e-02f, 2.25814693e-02f, 7.20521286e-02f,
  -5.53682856e-02f, 2.83753630e-02f, 1.29574668e-02f, 7.85046741e-02f, 9.30454135e-02f, -6.48083985e-02f, 3.20090959e-03f, 4.50603515e-02f, -7.21341465e-03f, -2.16407347e-02f,
  7.79223144e-02f, 1.77886877e-02f, -5.61014283e-03f, 1.15920529e-02f, -1.50891319e-02f, -4.15127650e-02f, 1.56992264e-02f, -4.67443801e-02f, 1.45349866e-02f, -5.62560186e-02f,
  -2.10818544e-01f, 1.41054332e-01f, 5.96414469e-02f, -1.44451976e-01f, -9.53295901e-02f, 1.36022572e-03f, -8.70038697e-04f, 8.08610320e-02f, -4.62951232e-03f, 9.89605859e-03f,
  4.89766560e-02f, 1.37035921e-02f, 1.14856176e-01f, -2.01373212e-02f, -7.32223615e-02f, -7.17024580e-02f, -1.28027543e-01f, 7.74854794e-02f, 6.18232749e-02f, -4.11485955e-02f,
  2.43091513e-03f, 2.03632060e-02f, -9.94272232e-02f, 5.24788164e-02f, -1.00921141e-02f, 4.13972884e-02f, 3.33891250e-02f, 1.07710587e-03f, -5.96625991e-02f, -4.51590605e-02f,
  -4.26827148e-02f, 3.83002795e-02f, -2.80622561e-02f, -1.03613183e-01f, 2.91069355e-02f, 4.57608253e-02f, 2.52217352e-02f, -1.60143320e-02f, 1.04398681e-02f, -6.17824644e-02f,
  -4.95813489e-02f, 3.85471545e-02f, -4.68174852e-02f, -1.71362124e-02f, 3.79838655e-03f, -2.90756561e-02f, -8.64422247e-02f, 5.73983379e-02f, -2.52413750e-02f, -2.87690144e-02f,
  8.24995264e-02f, -6.87622502e-02f, -4.23047915e-02f, -2.30893902e-02f, -4.74177077e-02f, -6.78505301e-02f, -9.12096649e-02f, -3.49359550e-02f, 1.65698095e-03f, -6.49055764e-02f,
  -5.13710305e-02f, 9.49881040e-03f, 3.36338058e-02f, 7.08259046e-02f, 4.29926813e-02f, -7.61621594e-02f, 4.55947258e-02f, 1.96091421e-02f, -2.06569396e-02f, -6.70637563e-02f,
  3.41970287e-02f, 7.30709285e-02f, -5.42465248e-04f, 3.62814367e-02f, 6.76375329e-02f, 3.68581712e-02f, 3.45545448e-02f, 4.44002673e-02f, 1.48437871e-03f, 9.87806916e-03f,
  -3.42915911e-04f, -7.14559108e-02f, -1.26585728e-02f, 1.95243768e-02f, 7.05593228e-02f, 7.64575601e-02f, 6.89245686e-02f, -1.90282718e-03f, 7.86681324e-02f, 6.66005760e-02f,
  -9.40768328e-03f, -6.74182316e-04f, -4.13625836e-02f, 1.67662296e-02f, -2.80182511e-02f, -5.26458398e-03f, -2.38387901e-02f, 2.67953686e-02f, -3.50395255e-02f, 7.78891072e-02f,
  6.41896874e-02f, 5.81169035e-03f, 3.16292308e-02f, 3.51754650e-02f, 8.18295181e-02f, 2.87399074e-04f, 5.18738069e-02f, 5.49938064e-03f, 4.12945300e-02f, 7.06402585e-02f,
  7.06333220e-02f, 7.55893905e-03f, 4.80472893e-02f, -8.85406882e-02f, 1.90086029e-02f, 7.11442679e-02f, -8.64698812e-02f, -1.79107487e-02f, 6.34131022e-03f, 2.04977896e-02f,
  3.96626145e-02f, -1.67498186e-01f, -1.15846626e-01f, 1.99842930e-01f, 1.85348123e-01f, 5.93721047e-02f, -2.21864134e-01f, 7.65648335e-02f, -1.12263141e-02f, -2.72716135e-01f,
  6.54118285e-02f, -1.98047176e-01f, -2.70613879e-01f, 8.48943964e-02f, 8.15789178e-02f, -1.91835925e-01f, 9.39457044e-02f, 7.03644305e-02f, 7.41712674e-02f, 9.79451686e-02f,
  9.82666388e-02f, 1.19481631e-01f, 8.03652331e-02f, 2.58241326e-01f, 4.60692309e-02f, 1.58852309e-01f, 1.57037452e-01f, -5.06767109e-02f, 1.98687926e-01f, 1.48413345e-01f,
  4.06214632e-02f, -7.89924860e-02f, 6.06686026e-02f, 5.38844429e-02f, 4.84858565e-02f, -5.75030744e-02f, -8.65668282e-02f, -3.55275068e-03f, -2.19015940e-03f, -9.92078613e-03f,
  -6.97104484e-02f, 4.42083552e-02f, -4.41772118e-02f, 2.51424797e-02f, 4.48556021e-02f, 1.30634412e-01f, -4.73764949e-02f, -1.12609882e-02f, 1.35710165e-02f, -4.56550308e-02f,
  -7.93277770e-02f, -4.58468311e-02f, -6.18679225e-02f, -8.35981369e-02f, 3.27263363e-02f, 2.37271227e-02f, -6.57874942e-02f, -6.01607598e-02f, -8.83975439e-03f, 4.36824039e-02f,
  -8.21419433e-02f, -7.31242970e-02f, -6.35640770e-02f, 2.84666754e-02f, 6.27362356e-02f, 6.94301631e-03f, -6.91524744e-02f, -5.72612658e-02f, -9.37144235e-02f, 5.53268902e-02f,
  5.79169253e-03f, -7.85137489e-02f, -2.07197145e-02f, -5.23292832e-03f, -7.09937746e-03f, 3.54244299e-02f, -9.39216581e-04f, -5.82065657e-02f, -6.74501061e-02f, 1.12914532e-01f,
  2.27991566e-02f, 2.53250115e-02f, -5.43904230e-02f, 8.98468271e-02f, 3.30442307e-03f, -8.05085823e-02f, 6.76213428e-02f, 4.83967364e-02f, -2.18896624e-02f, 7.88570568e-03f,
  -1.27292275e-01f, -7.31190667e-02f, -9.26550329e-02f, -3.16745155e-02f, 4.85699885e-02f, 2.71241385e-02f, -6.90458864e-02f, 4.43250760e-02f, -1.33672297e-01f, -8.73135701e-02f,
  -4.01018746e-02f, -7.27390219e-03f, 4.02583405e-02f, 3.07446178e-02f, 7.95860514e-02f, 4.17087115e-02f, -8.51638466e-02f, 3.71126533e-02f, 3.30099910e-02f, -1.64879262e-02f,
  -3.97875682e-02f, 1.50785604e-02f, 4.66260053e-02f, -3.89546831e-03f, 7.27733597e-02f, -8.89297798e-02f, -4.53015342e-02f, -4.48855795e-02f, 3.86307575e-02f, 2.18325993e-03f,
  6.25197440e-02f, -2.39696324e-01f, 4.94889282e-02f, 1.38185382e-01f, 2.81963974e-01f, 1.22877741e-02f, 5.08502834e-02f, 1.71765596e-01f, 1.50970712e-01f, -1.75707549e-01f,
  -1.19369626e-01f, -2.36631036e-01f, -2.70390958e-01f, -1.46263000e-02f, 5.79894055e-03f, -1.20917298e-01f, 5.02288155e-02f, -1.47552580e-01f, 1.24950513e-01f, 1.21399695e-02f,
  2.20314085e-01f, 9.10343751e-02f, 8.72624367e-02f, 1.14487126e-01f, -2.50532851e-02f, -3.26677982e-04f, -1.14578389e-01f, -2.82103661e-02f, -1.50873931e-02f, -7.69892111e-02f,
  1.23672783e-01f, -3.55293490e-02f, 4.87774014e-02f, -6.76110908e-02f, -6.26698732e-02f, -1.05630644e-01f, -2.73137484e-02f, -4.70792465e-02f, 4.19911742e-02f, -3.80231664e-02f,
  -7.51700532e-03f, 3.33003979e-03f, 6.02607615e-02f, -2.23369733e-03f, 8.68440419e-02f, 7.71423131e-02f, 9.96201634e-02f, 8.99572968e-02f, -4.36246432e-02f, 7.33407438e-02f,
  7.56245330e-02f, -5.32291010e-02f, 7.26811364e-02f, -3.10278106e-02f, -2.52428222e-02f, 5.11668883e-02f, 4.34851721e-02f, -5.05438037e-02f, -8.73226859e-03f, 2.94837710e-02f,
  -5.45354187e-02f, 3.36181633e-02f, 2.00852491e-02f, 8.10863152e-02f, -8.29593837e-03f, 4.71497737e-02f, 5.46516702e-02f, -6.54579848e-02f, -8.36699037e-04f, -6.79700151e-02f,
  6.76320568e-02f, -4.88997474e-02f, 1.42939175e-02f, -6.06304370e-02f, -3.18937376e-02f, 2.98829675e-02f, 4.80660386e-02f, -1.41719095e-02f, -4.33083065e-02f, -3.74669991e-02f,
  -4.44443189e-02f, 1.40939346e-02f, -5.00619411e-02f, 7.17264367e-03f, -5.49119227e-02f, -4.29055616e-02f, 3.80529203e-02f, 2.85424781e-03f, -1.54671604e-02f, -1.06546935e-02f,
  -1.32318020e-01f, -2.55338043e-01f, -2.38713417e-02f, -5.30981869e-02f, -2.03632154e-02f, 7.83217978e-03f, -7.75707327e-03f, -2.39734594e-02f, -1.00966394e-01f, 8.59778300e-02f,
  -9.33613405e-02f, -3.98118906e-02f, -6.94715008e-02f, 1.48207806e-02f, -1.16350345e-01f, 4.36867177e-02f, -7.22019374e-02f, -4.91010137e-02f, -2.65278202e-02f, -7.92856440e-02f,
  -3.31023484e-02f, -4.39761281e-02f, 5.58629818e-02f, 1.00404680e-01f, -8.06682706e-02f, -2.73277331e-02f, 5.52219152e-02f, 9.63864289e-03f, -7.71190450e-02f, -3.86813581e-02f,
  -9.19710919e-02f, 5.60060851e-02f, -8.52176994e-02f, 7.65371174e-02f, -1.19574100e-01f, -9.44279358e-02f, -6.89988956e-02f, 4.90387455e-02f, 4.23382074e-02f, -2.09414568e-02f,
  9.38305818e-03f, 8.59040841e-02f, 2.77851596e-02f, 1.67787805e-01f, 4.01860550e-02f, 5.92284277e-02f, -2.08906736e-03f, 3.54115590e-02f, -3.69659029e-02f, -1.82601269e-02f,
  3.26648317e-02f, 4.31858227e-02f, 1.65098906e-03f, -1.78722683e-02f, -3.50856036e-02f, 7.00713648e-03f, 9.17827412e-02f, 3.41136078e-03f, 1.12642817e-01f, 9.59919021e-02f,
  2.11041160e-02f, -5.97074293e-02f, -2.05243342e-02f, -9.07366723e-02f, 5.69305234e-02f, -9.77440551e-02f, 2.58764112e-03f, -7.65066519e-02f, -4.14570607e-02f, -8.51489231e-02f,
  1.63632426e-02f, 6.48853257e-02f, 3.43943089e-02f, 5.04745264e-03f, -1.68341193e-02f, -2.65619755e-02f, -4.29254510e-02f, -7.89122507e-02f, 5.90363741e-02f, 3.63261253e-02f,
  5.22387447e-03f, 8.07327405e-02f, 5.50527908e-02f, 5.99655956e-02f, 6.67190924e-02f, 2.21124049e-02f, 4.67075093e-04f, -1.46001801e-02f, 1.99889764e-03f, -9.52264667e-02f,
  4.75205518e-02f, 4.00402471e-02f, 9.58205238e-02f, -5.80432750e-02f, -9.43030268e-02f, -5.32287210e-02f, 8.98777321e-02f, -2.73214225e-02f, -7.03871250e-02f, -7.00003132e-02f,
  -7.24136233e-02f, -4.03489992e-02f, -8.33822340e-02f, -7.48699382e-02f, 4.66445257e-04f, -6.55674562e-02f, 6.21637441e-02f, 3.20866555e-02f, -3.96793596e-02f, 2.27883365e-03f,
  -1.82309875e-03f, 7.72643909e-02f, 2.87575126e-02f, -4.86656986e-02f, -8.61913115e-02f, -6.19194061e-02f, -5.64437583e-02f, 6.49736216e-03f, -6.31256700e-02f, 8.24714005e-02f,
  -4.21726191e-03f, -6.88517019e-02f, -3.87606137e-02f, 7.12406181e-04f, -6.26763403e-02f, -7.87016079e-02f, -7.17382133e-02f, -1.69428661e-02f, -8.91657099e-02f, -8.34016949e-02f,
  2.62778569e-02f, 9.78704169e-03f, -5.74330911e-02f, 4.10221219e-02f, 4.20342050e-02f, 3.42366658e-02f, -3.45031396e-02f, -5.33331856e-02f, 8.45022872e-02f, -4.22861129e-02f,
  -7.67541081e-02f, -3.83499973e-02f, 1.64799746e-02f, -6.36196584e-02f, 2.86083408e-02f, -5.60532175e-02f, 6.15080725e-03f, -4.08537537e-02f, 5.12845516e-02f, -4.83917557e-02f,
  -1.01451702e-01f, -5.50418124e-02f, -1.93244796e-02f, -7.75953159e-02f, -9.09953341e-02f, 4.40392550e-03f, 1.23104468e-01f, -6.84039071e-02f, -3.18693742e-02f, -1.80028584e-02f,
  6.67996034e-02f, -1.01476341e-01f, 9.81643796e-02f, 4.58834916e-02f, 6.62160590e-02f, -5.29228768e-04f, -2.94748954e-02f, -5.05304337e-02f, -5.01765721e-02f, 9.92904324e-03f,
  -1.24732107e-01f, 3.83480899e-02f, 3.61550525e-02f, 1.99704021e-02f, 5.86186945e-02f, -1.12903811e-01f, -4.81936149e-02f, -2.89589278e-02f, 2.25725323e-02f, 4.08418924e-02f,
  1.07635424e-01f, 1.00969775e-02f, 1.08083449e-01f, 2.94085965e-02f, 7.18579860e-03f, -6.13163412e-02f, 6.95049763e-02f, -4.14159447e-02f, -3.60035412e-02f, -7.06712902e-02f,
  4.05928306e-02f, -3.38924788e-02f, -6.56036735e-02f, 1.57388002e-02f, -1.01970635e-01f, 4.50942293e-02f, -7.57766664e-02f, -6.95145503e-02f, 1.80497207e-02f, -3.52244526e-02f,
  7.92043842e-03f, 7.63137415e-02f, -7.31876343e-02f, 1.27049712e-02f, -1.60722062e-02f, 7.28407577e-02f, 5.59004396e-02f, -4.86972257e-02f, 1.64892226e-02f, -5.22567751e-03f,
  2.61500143e-02f, -9.34067890e-02f, 7.29605705e-02f, 2.95379963e-02f, -9.67637970e-05f, 5.05796634e-03f, -3.40923038e-03f, -2.17765700e-02f, -3.97771336e-02f, -1.49875730e-02f,
  6.10568337e-02f, -2.49068346e-02f, -2.41444986e-02f, 9.59999766e-03f, -5.80314249e-02f, 2.15713605e-02f, 8.26962739e-02f, -4.27525267e-02f, 4.10820171e-02f, 2.17119185e-03f,
  8.58505666e-02f, 6.57793134e-02f, -1.15947789e-02f, 7.31563121e-02f, -7.10660368e-02f, -3.90161797e-02f, 4.06595357e-02f, -9.15549230e-03f, 9.77151915e-02f, -4.21961360e-02f,
  5.56304306e-02f, 8.64368752e-02f, 3.59996930e-02f, 1.06119208e-01f, -3.60849090e-02f, -5.02456129e-02f, -3.75461504e-02f, -5.71281202e-02f, -9.02579799e-02f, -6.02731889e-04f,
  -9.24206674e-02f, -5.87248020e-02f, -4.70186584e-02f, -4.21402305e-02f, 4.10920754e-02f, 8.04885924e-02f, -1.32993776e-02f, -1.64478011e-02f, -8.51915255e-02f, -9.25028995e-02f,
  -7.78838024e-02f, 8.49063396e-02f, 1.05325645e-03f, 5.59112318e-02f, -3.63481194e-02f, 5.61794378e-02f, 3.41564715e-02f, -2.41623726e-02f, -1.58249913e-03f, 5.12569770e-02f,
  -3.08926016e-01f, 1.52783588e-01f, -3.45289893e-02f, -1.52136862e-01f, 1.74060687e-02f, -2.75733247e-02f, -2.58576758e-02f, 4.85232621e-02f, -7.82288834e-02f, 1.85229275e-02f,
  -1.37013721e-03f, -1.24560185e-01f, 1.54407203e-01f, 2.55290680e-02f, -2.00542033e-01f, 1.26334559e-02f, -1.47853279e-02f, -4.31512855e-02f, 3.12483832e-02f, -1.00213215e-01f,
  -9.91519541e-02f, 7.62721673e-02f, -2.68451367e-02f, 1.23673081e-01f, -2.51924223e-03f, -3.63076525e-03f, -4.89368737e-02f, 7.88877606e-02f, -5.88112995e-02f, 6.04982581e-03f,
  -1.49171310e-03f, -1.66985258e-01f, 4.27752063e-02f, -1.09505445e-01f, -9.26981717e-02f, -3.78464907e-02f, -8.38657320e-02f, -6.83186278e-02f, 1.19392639e-02f, -5.65113276e-02f,
  1.28345685e-02f, 1.06612891e-01f, 2.26674173e-02f, 2.64628697e-02f, -2.56659165e-02f, -1.09492652e-02f, -7.18303695e-02f, 8.33998919e-02f, -5.97016476e-02f, -7.96507485e-03f,
  2.47817859e-02f, 2.50836480e-02f, -8.11543390e-02f, -6.61614910e-02f, 6.94611371e-02f, 7.36495629e-02f, -9.89096835e-02f, -1.86022781e-02f, -5.56887686e-02f, 3.86156924e-02f,
  8.46744403e-02f, -1.96898840e-02f, 2.83578299e-02f, -2.84246542e-02f, 3.75094004e-02f, -6.21231692e-03f, -2.83318236e-02f, -5.27480952e-02f, 1.29232220e-02f, -9.02934931e-03f,
  4.56149364e-03f, -7.49905482e-02f, 4.97945808e-02f, -4.04314063e-02f, -1.09452158e-02f, 3.92515473e-02f, 4.48453836e-02f, -8.01215693e-03f, 4.77576964e-02f, -2.12769229e-02f,
  4.47922908e-02f, -2.49325298e-02f, -1.87058914e-02f, 1.89310648e-02f, -4.24203537e-02f, 4.42319028e-02f, -3.75397108e-03f, -7.18176663e-02f, 5.96237890e-02f, 5.60463332e-02f,
  -1.71943143e-01f, -9.94345099e-02f, -5.11413589e-02f, 4.11402509e-02f, 4.13665660e-02f, -1.64819648e-03f, 8.66534039e-02f, 9.71542858e-03f, -4.61741947e-02f, -4.76013198e-02f,
  -4.32197563e-02f, 2.54517160e-02f, -9.60186943e-02f, 7.49557763e-02f, 9.43498388e-02f, -3.56376171e-02f, 3.68656814e-02f, -8.05946663e-02f, -1.00816116e-01f, -1.57794040e-02f,
  -4.62132990e-02f, -2.76762228e-02f, -1.66268740e-02f, -1.45115759e-02f, -8.73414651e-02f, -1.77124329e-02f, -1.61623824e-02f, 2.80823149e-02f, 4.64643054e-02f, 2.04104669e-02f,
  -5.40969968e-02f, 1.11381665e-01f, -1.53092118e-02f, 4.62965220e-02f, -2.04602350e-02f, -1.19083963e-01f, 5.45288669e-03f, 9.43585560e-02f, 6.56222105e-02f, 3.87055948e-02f,
  6.78819418e-03f, 8.86433423e-02f, 4.24589068e-02f, 4.29836251e-02f, -1.97914615e-01f, -1.14080213e-01f, -8.62888470e-02f, -7.95371532e-02f, 2.26951856e-02f, -8.76509696e-02f,
  -1.85123459e-02f, -4.44645062e-02f, -6.15212023e-02f, 5.50897866e-02f, 4.05079089e-02f, 6.96025882e-03f, -2.11565699e-02f, 1.98078342e-02f, -6.17195182e-02f, 4.84062880e-02f,
  5.82325682e-02f, 4.50491905e-03f, 3.02292313e-02f, -2.90505923e-02f, -9.66263339e-02f, -1.44867850e-02f, -7.86152259e-02f, 4.20059636e-02f, -3.92436348e-02f, 5.75890467e-02f,
  4.05144654e-02f, -1.02716215e-01f, -7.63128027e-02f, -1.92961153e-02f, -5.61363325e-02f, -6.80102259e-02f, 4.43871878e-02f, 4.03090194e-02f, -5.38156815e-02f, 4.96311635e-02f,
  -6.39856234e-02f, 1.00181187e-02f, 1.78988799e-02f, -1.97222214e-02f, 1.96257997e-02f, -2.46617105e-02f, -9.28176865e-02f, -3.72700393e-02f, -1.62315965e-02f, 6.62115067e-02f,
  -6.24029599e-02f, -7.51946792e-02f, 1.07747633e-02f, 6.02952875e-02f, -4.76991152e-03f, 2.49964409e-02f, 9.59807448e-03f, -1.01343624e-03f, 4.42343988e-02f, 2.14689854e-03f,
  -2.77093798e-02f, 7.73031041e-02f, 7.49518815e-03f, 2.18546856e-02f, -2.37781950e-03f, -4.82778326e-02f, 7.08568171e-02f, -3.77175920e-02f, 4.41849157e-02f, -5.18976040e-02f,
  -1.98636204e-02f, -1.25608882e-02f, 7.31745362e-02f, -5.63664027e-02f, -6.19443990e-02f, -6.94787875e-02f, -3.45806405e-02f, 2.46580858e-02f, 4.97551747e-02f, -2.09112875e-02f,
  -3.13557908e-02f, -5.90819120e-02f, -6.47006836e-03f, -6.83332700e-03f, -6.09770939e-02f, 2.65334193e-02f, -5.63839599e-02f, -2.70833843e-03f, 3.16942111e-02f, 4.86542005e-03f,
  8.44330266e-02f, 3.76927517e-02f, -2.16775830e-03f, 7.77553320e-02f, -6.47346303e-02f, -3.68080176e-02f, -5.67639507e-02f, -6.96941838e-02f, 1.58259626e-02f, -5.91355637e-02f,
  -4.37221266e-02f, 6.81315809e-02f, 3.44168656e-02f, 7.53797367e-02f, -5.60877621e-02f, 6.22764230e-02f, 3.78558487e-02f, -5.65113537e-02f, 3.02357785e-02f, -9.65701789e-02f,
  1.02657244e-01f, 1.35640204e-02f, 6.00311309e-02f, 3.98879535e-02f, -1.17115200e-01f, -1.73890352e-01f, -5.84063446e-03f, -9.78383869e-02f, 6.95359856e-02f, -4.95374836e-02f,
  -1.06018268e-01f, 1.24070294e-01f, 5.82914539e-02f, -7.04124793e-02f, 1.23199128e-01f, 1.39681473e-01f, 1.70504916e-02f, -2.66645066e-02f, 1.11910133e-02f, 7.39548579e-02f,
  1.26221046e-01f, -1.05382182e-01f, 5.93486466e-02f, -4.60125282e-02f, -2.93132067e-02f, 1.12721764e-01f, 9.45094377e-02f, -1.87179875e-02f, 1.81134213e-02f, -1.03306018e-01f,
  -2.27339007e-03f, 8.10040012e-02f, -3.57969850e-02f, -5.62880598e-02f, 2.21596435e-02f, 1.25727551e-02f, -3.37325931e-02f, 2.65682451e-02f, -1.73645653e-02f, -1.37148658e-03f,
  5.38007468e-02f, -7.79350698e-02f, -2.37377211e-02f, 8.25649127e-02f, -5.97293414e-02f, -2.98049934e-02f, 6.01131432e-02f, -2.16283947e-02f, -5.19699603e-02f, -1.93470456e-02f,
  8.69561210e-02f, -7.00019998e-03f, 8.40660464e-03f, 3.53868641e-02f, -1.72204990e-02f, -2.10665837e-02f, 7.20936805e-02f, -2.73963083e-02f, -2.71816719e-02f, 1.10989520e-02f,
  -4.32307385e-02f, 4.83265296e-02f, -6.38187071e-03f, -1.65528320e-02f, -7.05803558e-02f, -8.19977298e-02f, 1.00428972e-03f, 1.48291083e-03f, 9.17746201e-02f, 4.33608852e-02f,
  -6.52628615e-02f, -1.83115769e-02f, 4.03638035e-02f, 5.65093234e-02f, 7.67022744e-02f, 5.13203628e-02f, 7.64426291e-02f, -5.76332361e-02f, 1.86463073e-02f, -1.34924185e-02f,
  -3.52358893e-02f, -3.86119261e-03f, -8.88537541e-02f, 3.03858519e-02f, 3.87053974e-02f, -6.94687665e-02f, 1.07881591e-01f, -2.53097750e-02f, 5.00169024e-02f, 2.72063799e-02f,
  9.95117472e-04f, 2.00010091e-01f, -4.32345457e-02f, -1.13255884e-02f, 3.55789438e-02f, 5.72038926e-02f, 6.75915629e-02f, 8.98386165e-03f, 1.80476662e-02f, 3.93906422e-02f,
  1.23773795e-03f, -7.12589547e-02f, -8.15375615e-03f, -6.52369112e-02f, 1.00365430e-02f, -4.93574813e-02f, 1.18951704e-02f, 7.76065066e-02f, -5.66149876e-02f, -5.21665402e-02f,
  -4.07717284e-03f, 6.42496794e-02f, 6.50525317e-02f, -1.04678415e-01f, 2.61015389e-02f, -3.64418048e-03f, -4.86321375e-02f, 4.39453200e-02f, 8.83603171e-02f, -4.21532393e-02f,
  -1.73761249e-01f, 1.04367621e-01f, -9.08323601e-02f, -1.41636819e-01f, -4.59188782e-02f, -1.25885710e-01f, 3.81154828e-02f, -3.88343930e-02f, -5.78078255e-02f, 1.09867919e-02f,
  8.85490775e-02f, -5.76301813e-02f, 9.44036841e-02f, 6.64435849e-02f, 1.03921276e-02f, 1.17008246e-01f, 2.24845856e-02f, 4.23444398e-02f, -9.63098630e-02f, -9.05093402e-02f,
  4.91401087e-03f, 6.57564541e-03f, 1.93121340e-02f, 2.18873583e-02f, -8.84758011e-02f, -4.19053212e-02f, -6.72687069e-02f, -5.54204807e-02f, 4.95305695e-02f, -1.20507767e-02f,
  -1.06959380e-01f, -1.01628199e-01f, -7.10911825e-02f, -2.25003697e-02f, -1.35421708e-01f, -1.18641309e-01f, -4.01996188e-02f, -3.18646990e-02f, -7.91891068e-02f, 9.97397769e-03f,
  -6.35228977e-02f, -4.29395847e-02f, -2.78550349e-02f, -6.75828382e-02f, 6.78234547e-02f, 1.98576264e-02f, -6.79596066e-02f, -2.47173123e-02f, -7.50282854e-02f, -1.08656464e-02f,
  4.67960276e-02f, -9.23067406e-02f, -4.60782535e-02f, 1.23111188e-01f, -1.14504043e-02f, 1.43822040e-02f, 9.69895050e-02f, -3.33210081e-02f, 1.84235105e-03f, -9.76716541e-03f,
  -1.20609924e-02f, -1.24385014e-01f, -5.37509695e-02f, -7.08609745e-02f, -4.43346128e-02f, 1.19567372e-01f, -4.67917211e-02f, 4.99171764e-02f, 2.24892795e-02f, 8.01250935e-02f,
  -5.19607365e-02f, 2.88654282e-03f, 4.29130383e-02f, -5.60852624e-02f, -6.54139509e-03f, -1.31082283e-02f, -6.43278882e-02f, -6.68711662e-02f, -3.99866737e-02f, -2.96315160e-02f,
  -6.79454356e-02f, -3.18648033e-02f, -3.70515063e-02f, 3.28258649e-02f, 3.14934589e-02f, 3.85633148e-02f, 6.04266338e-02f, 5.88806998e-03f, 1.12326918e-02f, -9.48977768e-02f,
  -8.17819536e-02f, -1.33617744e-01f, -1.01859402e-02f, -3.95463333e-02f, 2.00607609e-02f, -2.00301893e-02f, -5.61898872e-02f, -1.60933193e-02f, 3.23413573e-02f, 2.58155167e-02f,
  -5.50752319e-02f, -4.03391719e-02f, -9.14941430e-02f, -4.34146002e-02f, 8.88347253e-02f, 4.39860560e-02f, 8.15890208e-02f, 3.79149392e-02f, -6.75000325e-02f, 4.20249328e-02f,
  -6.41778260e-02f, -4.49668467e-02f, 4.43807170e-02f, -2.29537264e-02f, -8.55290443e-02f, 5.25487289e-02f, 3.57313529e-02f, 5.29120788e-02f, 8.71989131e-02f, 1.85010266e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.89894396e-02f, 2.07251444e-01f, 3.03938743e-02f, 7.31281703e-03f, -1.45253763e-02f, 6.61552474e-02f, -6.38429299e-02f, 1.40958615e-02f, -3.04563306e-02f, -1.74900703e-02f,
  1.72170699e-01f, -2.51279138e-02f, 1.07274719e-01f, 1.41980112e-01f, -9.44567099e-02f, 7.65927359e-02f, 5.19772880e-02f, -1.12038909e-03f, 7.78920427e-02f, 1.05377428e-01f,
  5.64155653e-02f, -2.30128299e-02f, 5.00859879e-02f, -7.65862316e-02f, 1.65222272e-01f, 2.10885536e-02f, 4.58042622e-02f, 1.53461978e-01f, -5.17778732e-02f, 1.19284205e-02f,
  1.48832619e-01f, 1.23756103e-01f, 2.34002352e-01f, 1.34604737e-01f, 6.08567558e-02f, -9.73204337e-03f, 6.00744188e-02f, -3.72385085e-02f, 1.10024363e-01f, 1.26243487e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.72103867e-01f, 6.39104694e-02f, -5.91162546e-03f, -1.29660908e-02f, -3.08452845e-02f, -1.81877643e-01f, 9.34625231e-03f, 1.89353637e-02f, 3.14310901e-02f, 1.24705404e-01f,
  -3.14313360e-02f, -7.90730715e-02f, -2.23661549e-02f, 1.19558796e-01f, -2.14537755e-01f, 8.61537755e-02f, 1.55901462e-01f, -3.11941579e-02f, 1.02848917e-01f, -1.71091616e-01f,
  -1.52174786e-01f, -7.62043074e-02f, -5.63882757e-04f, 1.31747872e-02f, 1.00200780e-01f, 2.06584170e-01f, 9.99410078e-02f, 1.67152300e-01f, 4.99213375e-02f, 2.88738251e-01f,
  -1.09551125e-03f, -9.78623554e-02f, -1.28352523e-01f, -2.10457653e-01f, 2.87539512e-02f, 1.16138004e-01f, 1.51072323e-01f, -1.48707911e-01f, -1.61144137e-01f, 4.39299121e-02f,
  1.17093541e-01f, -2.15938315e-02f, 5.05423509e-02f, 7.88344368e-02f, 6.23990893e-02f, 1.01786278e-01f, -2.50367168e-02f, -5.08687124e-02f, 7.09258467e-02f, -6.79274425e-02f,
  -6.82066306e-02f, -1.34583600e-02f, -5.13079576e-02f, -2.34578066e-02f, -6.25683963e-02f, -8.38726237e-02f, 6.73100352e-02f, -1.86466366e-01f, 1.53170779e-01f, 2.86486838e-02f,
  2.97029633e-02f, -6.06522486e-02f, 4.67480794e-02f, 4.56223525e-02f, -9.15783867e-02f, 3.63895968e-02f, 2.19982024e-03f, -1.62488723e-04f, -1.53311253e-01f, 1.59790479e-02f,
  -1.17676459e-01f, -1.67886503e-02f, -1.17663100e-01f, 1.44259613e-02f, 7.97197372e-02f, -1.29645079e-01f, -3.49557519e-01f, 2.27906421e-01f, 1.17308982e-01f, 1.50512263e-01f,
  -6.95683435e-02f, -1.44459471e-01f, -2.30839014e-01f, 1.38703182e-01f, -1.21673927e-01f, -6.27181977e-02f, -6.05093613e-02f, -9.51386616e-02f, 1.48110002e-01f, 5.19353636e-02f,
  -1.17440097e-01f, 7.66402483e-02f, -1.73624128e-01f, 1.67892668e-02f, 1.15467101e-01f, 1.92312405e-01f, -8.43039248e-03f, -1.40982270e-01f, -1.33994654e-01f, -4.76307012e-02f,
  5.27900681e-02f, 8.46416801e-02f, -2.02309098e-02f, 5.31908274e-02f, 8.56247991e-02f, 6.77092373e-02f, -3.75867151e-02f, 1.77166715e-01f, 1.79351345e-02f, 5.28953923e-03f,
  1.10282674e-01f, -4.44861837e-02f, -9.23009403e-03f, -1.06105516e-02f, 1.48639292e-01f, -2.06931502e-01f, -7.47722108e-03f, 8.62218887e-02f, 2.27756575e-02f, 1.97475422e-02f,
  -1.38983428e-01f, -1.44264266e-01f, 2.56352276e-02f, -1.85151491e-02f, -1.68057665e-01f, -8.26599896e-02f, 1.00113757e-01f, -8.88957642e-03f, 1.01244405e-01f, -6.52439445e-02f,
  4.18748297e-02f, 1.58395484e-01f, -5.81185631e-02f, 7.13804588e-02f, 5.25454581e-02f, 1.36169598e-01f, 1.04090482e-01f, -4.28835675e-02f, 3.15723605e-02f, 1.63249612e-01f,
  1.15366085e-02f, 1.46977246e-01f, 1.81111440e-01f, -1.89591497e-02f, -1.59144744e-01f, -2.90920496e-01f, 9.12715271e-02f, 2.97837973e-01f, -1.54676333e-01f, 7.05913082e-02f,
  3.71579565e-02f, -3.47107723e-02f, 9.72915888e-02f, -2.41802230e-01f, -3.08346786e-02f, -1.36041110e-02f, 4.32156809e-02f, -2.82846317e-02f, 4.66182455e-02f, 2.13712677e-01f,
  8.90691429e-02f, 8.24734792e-02f, 3.27948108e-02f, 8.51852261e-03f, 9.02949050e-02f, 3.65921929e-02f, -6.47469088e-02f, -2.05629412e-02f, 1.10662267e-01f, -7.99506828e-02f,
  9.72510129e-03f, -6.73423475e-03f, -7.61875808e-02f, 2.42174584e-02f, -1.54959559e-01f, -1.83763564e-01f, -2.12597847e-01f, -6.60732854e-03f, -1.25771284e-01f, -8.00404176e-02f,
  1.15296163e-01f, 1.00877300e-01f, -9.36380178e-02f, 6.59054890e-02f, -2.05319583e-01f, 2.75157429e-02f, -1.05768412e-01f, 6.64139912e-02f, -1.06420815e-01f, 6.54753149e-02f,
  1.18718654e-01f, 1.03623897e-01f, 1.38501851e-02f, 4.02307324e-02f, -5.84252477e-02f, -1.34861439e-01f, 1.63948357e-01f, 5.33483631e-04f, -7.85999373e-03f, 1.13952532e-01f,
  -4.21310775e-02f, 1.62906840e-01f, 9.87819508e-02f, -3.91116850e-02f, 1.90239817e-01f, -2.19219491e-01f, 1.22127412e-02f, 8.04619268e-02f, 1.61352351e-01f, 2.33798906e-01f,
  4.09625992e-02f, -1.04618303e-01f, 1.53183788e-01f, -6.66480139e-02f, -3.76128964e-02f, 1.57704338e-01f, -3.51925194e-02f, 5.77253103e-02f, 1.01718441e-01f, 5.13422154e-02f,
  1.26591563e-01f, -3.05941068e-02f, -1.23220585e-01f, -6.74825832e-02f, -3.38650160e-02f, 1.85159594e-01f, -6.33113608e-02f, 9.59259942e-02f, -2.26713659e-04f, -1.47693679e-01f,
  -4.18408178e-02f, -1.44526795e-01f, -1.68931842e-01f, 7.50463828e-02f, 8.66298676e-02f, 6.41008513e-03f, -1.20760314e-01f, -4.55703512e-02f, -1.14331767e-01f, -9.64556634e-02f,
  -9.21316519e-02f, 8.68044943e-02f, 8.03344473e-02f, 1.27334427e-02f, -5.24100214e-02f, -6.98483139e-02f, 1.59781650e-01f, -9.44284350e-02f, 1.12193398e-01f, 2.09359154e-01f,
  4.50213626e-02f, -1.30406097e-01f, 1.14275180e-01f, 1.55595824e-01f, -1.27531111e-01f, -1.00861371e-01f, -2.07098275e-01f, -7.10679740e-02f, -4.19943333e-02f, 1.97813675e-01f,
  -1.38982004e-02f, 1.61881566e-01f, 1.40613258e-01f, -4.86463085e-02f, 2.60716621e-02f, -9.17159244e-02f, 1.29127696e-01f, 3.31646837e-02f, -7.42781684e-02f, -1.45519540e-01f,
  3.46035361e-01f, 1.56851217e-01f, 2.95738410e-02f, -1.05095608e-02f, -4.02600050e-01f, 7.89507851e-02f, 8.22928399e-02f, -1.21923737e-01f, -5.35840876e-02f, -1.91358984e-01f,
  8.17066710e-03f, -1.99181840e-01f, 3.51853743e-02f, -4.76869103e-03f, -1.44004911e-01f, -2.24963829e-01f, 1.37148276e-01f, -1.04510926e-01f, 9.63419527e-02f, 1.37068123e-01f,
  -1.91674769e-01f, -6.81372955e-02f, 9.02522877e-02f, -2.10421141e-02f, 1.47927925e-02f, -2.71372534e-02f, 3.47099826e-02f, 1.47685960e-01f, -8.93560573e-02f, 2.01735437e-01f,
  2.86665908e-03f, -1.28560826e-01f, -1.43483117e-01f, 2.73887208e-03f, 3.05086393e-02f, 9.90794152e-02f, 1.19690485e-01f, -2.65017927e-01f, 1.00218117e-01f, -1.02343708e-01f,
  1.94683492e-01f, -8.14495906e-02f, 2.37548146e-02f, 9.28713456e-02f, -5.72594628e-02f, -7.02942908e-02f, -6.56254217e-02f, -5.72213233e-02f, 2.33079847e-02f, -8.75685960e-02f,
  9.93177593e-02f, -7.30050309e-03f, -1.05425321e-01f, -1.46047920e-01f, 2.71767639e-02f, 1.12067960e-01f, -4.99542989e-02f, -1.04492135e-01f, 4.62051481e-02f, -1.25900909e-01f,
  -7.11224973e-02f, 1.86347701e-02f, 2.24257633e-01f, -3.86918411e-02f, -5.23206033e-03f, -1.85888961e-01f, 3.76542844e-02f, 1.15645058e-01f, 5.32687344e-02f, 5.55924810e-02f,
  3.63446139e-02f, -2.45232377e-02f, 7.98174366e-02f, 2.54344046e-01f, -7.84974173e-02f, -1.45762593e-01f, -3.24939638e-02f, -6.26343861e-02f, 4.24539261e-02f, -1.57620117e-01f,
  -8.19857791e-02f, -2.13299200e-01f, -1.89329386e-02f, 1.45060822e-01f, 1.88053429e-01f, 3.70445661e-02f, 1.44790262e-01f, 1.69945695e-02f, 1.32081378e-03f, 4.80557345e-02f,
  -3.85684334e-02f, -1.01031393e-01f, 1.16916649e-01f, 1.19207827e-02f, 9.37485788e-03f, 6.11871295e-02f, -9.24082659e-03f, -9.53858420e-02f, 5.33352382e-02f, 1.24000698e-01f,
  -4.13120352e-02f, -4.31026854e-02f, -8.77755508e-02f, 4.39394191e-02f, 1.19281918e-01f, 9.62712094e-02f, 1.42182216e-01f, -1.33391088e-02f, -4.34089117e-02f, 1.03319138e-01f,
  1.06324703e-02f, 4.09120284e-02f, -3.02488655e-02f, -1.18074156e-01f, -1.32312208e-01f, -5.44889597e-03f, 6.69811517e-02f, 2.34085843e-01f, 1.19878806e-01f, 1.81241274e-01f,
  -1.67834330e-02f, 5.61531484e-02f, -4.53767832e-03f, -6.61209002e-02f, -1.33867070e-01f, 9.34087113e-02f, -2.69484818e-01f, 1.43051669e-01f, 4.02142759e-03f, -1.35020658e-01f,
  -1.75817207e-01f, 3.16329263e-02f, -2.34704047e-01f, -1.80332847e-02f, 3.76323722e-02f, 3.30522680e-03f, -2.33492285e-01f, -1.72340915e-01f, -3.04093063e-02f, -4.57176007e-02f,
  -3.28696892e-02f, -1.23960450e-01f, -1.80018857e-01f, -3.07439528e-02f, -2.04842761e-02f, 1.21485643e-01f, -3.45483869e-02f, -1.81300496e-03f, -2.65693218e-01f, 1.61314040e-01f,
  -1.71772733e-01f, 1.88823193e-01f, 5.95055111e-02f, 2.01877877e-02f, -6.84085414e-02f, 2.99885999e-02f, -2.84246691e-02f, 2.30926052e-02f, -2.88434536e-03f, -1.47178948e-01f,
  -1.05583081e-02f, -1.66781414e-02f, -7.14103356e-02f, -6.06992692e-02f, 2.34151781e-01f, 2.73656230e-02f, -3.13401818e-02f, 1.06696807e-01f, -8.08667094e-02f, -8.84398818e-02f,
  1.53775513e-01f, 1.96211338e-01f, -4.12648767e-02f, 4.14986461e-02f, 4.55001667e-02f, -9.21675414e-02f, -1.63590834e-01f, -7.75089487e-02f, 4.05614078e-02f, 2.86382884e-02f,
  -3.49502899e-02f, -1.49799818e-02f, -1.07700221e-01f, -1.63405791e-01f, 1.41239375e-01f, 1.00251086e-01f, -3.57903466e-02f, 7.84676671e-02f, -4.37481189e-03f, -4.94882651e-02f,
  -1.85230840e-02f, -5.44555373e-02f, -2.08759680e-01f, -9.74117070e-02f, 1.33601919e-01f, -6.74379244e-02f, 1.67445436e-01f, -2.45086983e-01f, -1.76754579e-01f, -5.86132519e-02f,
  1.90520942e-01f, -1.30635828e-01f, 4.19916473e-02f, -6.40765354e-02f, -1.71213523e-01f, -7.21116662e-02f, 1.50171265e-01f, 1.50515109e-01f, -9.61879175e-03f, 1.50759235e-01f,
  -1.54003829e-01f, -1.17783546e-01f, -9.93344747e-03f, 3.92001830e-02f, 5.72779253e-02f, -6.36410490e-02f, -5.57654798e-02f, -6.63015991e-02f, 7.85960034e-02f, -1.34719700e-01f,
  -8.86403397e-02f, -1.01717934e-01f, -7.35563040e-02f, -7.68471211e-02f, 1.71946153e-01f, 3.30982916e-02f, 1.35695815e-01f, 3.39901224e-02f, -1.71947971e-01f, 2.39594728e-01f,
  -2.82605533e-02f, 6.39250576e-02f, -5.16574979e-02f, 1.37487680e-01f, -1.98891908e-01f, -8.36710930e-02f, -3.63130793e-02f, 8.45531300e-02f, 1.14043020e-01f, -5.37636168e-02f,
  8.03918764e-02f, 8.52883458e-02f, 9.31601152e-02f, -5.68166226e-02f, -1.89869124e-02f, -1.04516841e-01f, 6.68448657e-02f, -8.10221881e-02f, -5.64666390e-02f, 1.27026051e-01f,
  3.60369794e-02f, 2.05640960e-02f, -5.21564446e-02f, -6.97466135e-02f, -3.02504636e-02f, -7.64159784e-02f, 1.31491065e-01f, 2.99339294e-01f, 1.30294532e-01f, -4.32996266e-02f,
  -7.15029389e-02f, 2.56401002e-02f, -2.83765458e-02f, -1.87309727e-01f, 3.70549522e-02f, -1.58425152e-01f, 1.31973382e-02f, 1.90620527e-01f, 2.62609199e-02f, 2.31803525e-02f,
  -4.20825221e-02f, 9.35074016e-02f, -1.38589954e-02f, -1.28130332e-01f, 5.12440428e-02f, 3.59352082e-02f, -2.17193142e-02f, 1.14674484e-02f, 1.24898907e-02f, -6.15709350e-02f,
  4.07221168e-02f, 5.39557934e-02f, -8.03488791e-02f, 3.08729731e-03f, -9.34920907e-02f, 6.50613233e-02f, -4.42667939e-02f, -9.13771093e-02f, -1.23632997e-01f, -3.58515717e-02f,
  1.85509380e-02f, -3.14508043e-02f, 1.16443492e-01f, -1.97034314e-01f, 3.21523435e-02f, -7.91923478e-02f, 1.93728298e-01f, -1.09332122e-01f, 1.65781714e-02f, -9.79109854e-02f,
  1.07304260e-01f, -2.87795532e-02f, -1.41132757e-01f, 1.02281578e-01f, 1.65478095e-01f, 1.26440879e-02f, 6.45273253e-02f, 1.98717296e-01f, 1.38607934e-01f, -1.05475999e-01f,
  2.08064735e-01f, 4.03430872e-02f, 3.89748737e-02f, 4.54011373e-02f, 2.33404506e-02f, 9.95211452e-02f, -1.80705506e-02f, -3.44569748e-03f, -3.48235331e-02f, -8.74162912e-02f,
  1.24929301e-01f, 2.25164816e-01f, 4.76131476e-02f, 1.03461176e-01f, -2.22222254e-01f, -1.20737173e-01f, 8.50649700e-02f, -9.88640338e-02f, -9.45432559e-02f, -1.48796722e-01f,
  -6.23606034e-02f, 1.42433211e-01f, 8.65308791e-02f, 3.90075371e-02f, -9.61437598e-02f, -8.19189176e-02f, 3.63200903e-02f, -9.47904885e-02f, 7.79557601e-02f, 3.83201391e-02f,
  -1.65815040e-01f, 2.31169141e-03f, 5.42867705e-02f, 4.06508856e-02f, -2.62908470e-02f, -7.59730637e-02f, -1.16504133e-02f, -1.43809272e-02f, -1.27639771e-02f, -2.10497789e-02f,
  -9.63222459e-02f, -1.18273795e-02f, 1.65979471e-02f, 9.27855745e-02f, 5.33721894e-02f, 8.59134793e-02f, 1.32762641e-01f, -1.69512436e-01f, -1.33524947e-02f, -1.05041042e-01f,
  1.91779077e-01f, 9.68096033e-02f, -2.70334235e-03f, -1.38582885e-02f, 6.68132827e-02f, -1.31437317e-01f, -1.49770856e-01f, -1.38427779e-01f, 8.17708969e-02f, -6.72804043e-02f,
  -1.75769165e-01f, 2.24929780e-01f, -1.29144520e-01f, -1.16940849e-01f, 1.99981838e-01f, -1.20600685e-02f, 1.64052900e-02f, -9.43607166e-02f, 1.19082578e-01f, 1.18128806e-01f,
  -3.63564380e-02f, -8.71621370e-02f, -7.05446675e-02f, -1.42951220e-01f, 1.39843136e-01f, -6.00499585e-02f, 1.42727435e-01f, 2.02112123e-01f, -2.45185018e-01f, -1.58443183e-01f,
  1.74445912e-01f, 4.93551046e-02f, 8.99533778e-02f, 1.29867345e-01f, -1.10143140e-01f, 5.36542386e-02f, -6.03874661e-02f, -1.37934461e-01f, 1.28385033e-02f, 9.54636931e-03f,
  1.02934718e-01f, -6.04279973e-02f, -3.94247770e-02f, 9.70536377e-03f, -1.57928526e-01f, -9.58005637e-02f, -1.76552370e-01f, -8.66497681e-02f, 4.21065316e-02f, 6.30144849e-02f,
  -1.22513212e-01f, 6.00988939e-02f, 1.12940967e-01f, -1.61671504e-01f, -6.19126856e-02f, 2.74716876e-02f, 1.29518658e-01f, -6.58935234e-02f, -2.47604884e-02f, -1.87629666e-02f,
  -3.16949710e-02f, -5.57019040e-02f, -1.57977697e-02f, -2.20252182e-02f, 1.58293635e-01f, -8.40130225e-02f, 2.56322861e-01f, 2.43946299e-01f, -6.42232448e-02f, -1.22602627e-01f,
  -1.36417657e-01f, 6.87708110e-02f, -5.28633706e-02f, -1.87029049e-01f, 1.28609225e-01f, -1.78896353e-01f, -2.40595127e-03f, 1.75696850e-01f, -2.64104605e-01f, 1.18762022e-02f,
  -9.39192623e-02f, -6.06278442e-02f, 2.62090564e-02f, -7.30540380e-02f, -6.59901723e-02f, 1.52641177e-01f, 1.09184444e-01f, 2.60156784e-02f, -1.52610853e-01f, -2.14131534e-01f,
  -2.12418377e-01f, -2.39627063e-01f, -3.35966772e-03f, 2.02448994e-01f, -5.81963807e-02f, 1.41405210e-01f, 1.15626961e-01f, 8.47556740e-02f, 3.50928642e-02f, -2.15630993e-01f,
  1.19642489e-01f, -3.73903923e-02f, 8.94962717e-03f, -1.50773704e-01f, 9.07739624e-02f, 1.29899114e-01f, 2.24458985e-02f, 4.20519486e-02f, 1.64452985e-01f, 6.51852563e-02f,
  1.38742775e-01f, 1.61960438e-01f, 1.07936054e-01f, 1.56870544e-01f, -5.34116849e-02f, -1.40933588e-01f, 1.69421099e-02f, 1.34282887e-01f, 3.11576505e-03f, 9.72548127e-03f,
  1.98712461e-02f, 4.88696620e-02f, -1.57534376e-01f, -9.09306705e-02f, 3.47488858e-02f, 4.23464924e-02f, 8.40600729e-02f, 1.14673926e-02f, -8.22077990e-02f, -1.18465880e-02f,
  1.65540203e-02f, 7.66435862e-02f, 6.08881451e-02f, 8.44844058e-02f, 1.68600127e-01f, -9.22220796e-02f, -1.41354293e-01f, 1.24551967e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.56102151e-02f, 1.03963219e-01f, 1.12692624e-01f, 1.38596684e-01f, 1.46875486e-01f, 7.58363008e-02f, -9.42653865e-02f, 3.35947871e-02f, 1.76258031e-02f, -4.94598001e-02f,
  1.49149135e-01f, -9.27547589e-02f, -1.93225399e-01f, 9.46427807e-02f, -1.50729427e-02f, -3.38819623e-02f, -5.90863265e-02f, 3.55804642e-03f, 9.57839377e-03f, 2.04672832e-02f,
  6.44346029e-02f, 1.36004150e-01f, 7.54080564e-02f, -1.67118497e-02f, -8.15318078e-02f, -1.35039866e-01f, 8.74841288e-02f, -4.24001552e-03f, 8.63981619e-03f, 5.42901643e-02f,
  -6.47850186e-02f, 2.58991513e-02f, -1.53319938e-02f, 6.46897107e-02f, -5.26120886e-04f, -6.76765013e-03f, -1.17137089e-01f, 1.42924517e-01f, 1.44770086e-01f, -7.30096400e-02f,
  4.62191477e-02f, -3.93171869e-02f, -3.46914977e-02f, -1.10840879e-01f, 6.02274016e-02f, -9.51626301e-02f, 1.32993208e-02f, 1.10850543e-01f, -5.51093854e-02f, 1.17020853e-01f,
  -1.03242323e-01f, -9.93220508e-03f, -1.10120751e-01f, 9.38073099e-02f, -5.20817637e-02f, -3.50283086e-02f, 3.61161269e-02f, 4.59417813e-02f, -5.85889816e-02f, 9.81043577e-02f,
  -4.50339839e-02f, 7.28733912e-02f, 1.06865302e-01f, -4.28050645e-02f, 6.86152931e-03f, 2.01290231e-02f, -1.11028530e-01f, 3.96382548e-02f, -3.17159779e-02f, 9.77928415e-02f,
  -4.22643162e-02f, -2.06827167e-02f, 5.27023105e-03f, -3.73303033e-02f, -7.62678832e-02f, 1.87960658e-02f, 1.34603962e-01f, 1.22673601e-01f, -1.19635202e-01f, 9.29984227e-02f,
  -6.60234913e-02f, -2.64790049e-03f, -5.34731597e-02f, 2.37194058e-02f, 3.99090461e-02f, -9.61692110e-02f, 1.06756255e-01f, 1.03954293e-01f, -3.81881297e-02f, -3.60164866e-02f,
  -4.87870611e-02f, 1.13749072e-01f, 9.25269052e-02f, 1.70942187e-01f, 1.01568870e-01f, 1.03492655e-01f, 3.71015370e-02f, -1.05615638e-01f, -9.54879969e-02f, -1.47331692e-03f,
  2.96201371e-02f, -3.67614627e-02f, -4.88632992e-02f, -9.44567919e-02f, -6.50144070e-02f, 3.14492621e-02f, 8.00091326e-02f, 6.91227317e-02f, -4.75761779e-02f, 6.06335290e-02f,
  1.09552719e-01f, -8.85883942e-02f, 1.32714668e-02f, -9.24602225e-02f, 7.46492594e-02f, -1.00984611e-01f, 4.50949892e-02f, -6.44732565e-02f, -2.98045040e-03f, 4.90682386e-02f,
  -2.34803781e-02f, -6.47587478e-02f, 9.11369771e-02f, 1.89623646e-02f, 3.73680703e-02f, 3.27357277e-02f, 6.26828745e-02f, 6.85087815e-02f, 6.02005646e-02f, 7.66325220e-02f,
  -1.81743205e-02f, -4.65404838e-02f, 1.20298326e-01f, 3.48786227e-02f, -8.06520134e-02f, 1.82263687e-01f, 1.99419320e-01f, 1.87251285e-01f, 3.25546339e-02f, 1.51124999e-01f,
  2.17698112e-01f, 7.94884004e-03f, -2.07796842e-01f, -1.18377678e-01f, -6.06038943e-02f, -4.41958308e-02f, 1.05566137e-01f, 2.09942698e-01f, -3.76764238e-02f, 2.97056208e-03f,
  1.06333390e-01f, 1.56933755e-01f, 1.43955380e-01f, -1.21085793e-01f, 1.47102684e-01f, -3.39504108e-02f, -5.75347170e-02f, 9.51344613e-03f, 8.81958753e-02f, 6.44453391e-02f,
  4.06662654e-03f, -1.00354344e-01f, 2.43864477e-01f, -1.31761253e-01f, -8.44323263e-02f, 1.95674524e-02f, -9.12117809e-02f, 9.72667411e-02f, -2.45060138e-02f, -3.97406667e-02f,
  -2.83858459e-02f, -5.13651557e-02f, -6.04396313e-02f, -7.86710009e-02f, 4.11029682e-02f, -5.83287850e-02f, -1.28987193e-01f, 1.31251395e-01f, 9.89044923e-03f, 1.20827384e-01f,
  -8.96556452e-02f, -1.17078088e-02f, 3.34285758e-02f, 1.86099738e-01f, -8.91769901e-02f, -9.89733487e-02f, 1.36263430e-01f, 1.14446253e-01f, 1.70969650e-01f, 1.45931154e-01f,
  -1.54481694e-01f, 4.86790724e-02f, -1.56711740e-03f, 1.78844891e-02f, -1.00606665e-01f, 1.03313606e-02f, -2.28540692e-02f, -4.79271039e-02f, -7.14491904e-02f, -9.35623348e-02f,
  3.24110128e-02f, -1.43034989e-03f, -4.86621261e-02f, -5.33564314e-02f, 4.91996333e-02f, 5.06433994e-02f, 8.02757591e-02f, 4.74761650e-02f, 4.01903577e-02f, -1.12741910e-01f,
  3.37752029e-02f, 3.04354168e-02f, -9.98117998e-02f, 9.28181484e-02f, -2.40162499e-02f, 3.86877358e-02f, 2.29950007e-02f, -6.26347363e-02f, -1.69626263e-03f, 6.62681609e-02f,
  -1.01952225e-01f, -8.24157149e-02f, 7.70399347e-02f, -1.00689366e-01f, -2.50822539e-03f, 1.03040278e-01f, 3.94929722e-02f, 2.86050346e-02f, 7.37205986e-03f, -8.25176612e-02f,
  -1.29676223e-01f, -8.80692750e-02f, 1.21992365e-01f, 1.08819157e-01f, -1.30411629e-02f, -9.71233547e-02f, -1.26704141e-01f, -2.61685438e-02f, 6.26707003e-02f, 3.32939178e-02f,
  -6.09269692e-03f, 1.31553948e-01f, -9.71077681e-02f, -1.22781858e-01f, 9.06243697e-02f, 4.93765883e-02f, 6.12444840e-02f, -2.05454864e-02f, 6.32445607e-03f, 4.93239239e-02f,
  -5.47135063e-02f, -1.04732290e-02f, -7.99483284e-02f, 2.22762246e-04f, 1.20235719e-01f, -6.21245764e-02f, 2.03416944e-01f, -5.11690080e-02f, 8.05293918e-02f, -5.97779006e-02f,
  1.63732693e-01f, -4.58435230e-02f, 8.89933901e-04f, 2.29953751e-02f, 1.18452147e-01f, 2.32659250e-01f, -2.23366264e-02f, -4.22439910e-02f, -2.31618322e-02f, -2.28135258e-01f,
  -3.88781577e-02f, 1.70375556e-02f, 1.14938043e-01f, -6.84178323e-02f, 1.26034230e-01f, 5.50536392e-03f, -4.97667454e-02f, -1.26462698e-01f, 2.28693619e-01f, 2.01312110e-01f,
  1.51004016e-01f, 9.89741366e-03f, 9.95371118e-02f, -1.63463573e-03f, 1.43101558e-01f, 5.25000058e-02f, -6.98063057e-03f, -9.06806663e-02f, -1.14467807e-01f, -8.88641179e-02f,
  2.99944997e-01f, 7.04517886e-02f, 1.95493251e-01f, 2.18385402e-02f, -4.07812856e-02f, 6.49577565e-03f, 6.64585382e-02f, 3.56136169e-03f, -7.79189449e-03f, -2.67298333e-02f,
  3.55473049e-02f, 4.95280027e-02f, 8.31611902e-02f, -1.09332196e-01f, -5.18124811e-02f, 1.38700321e-01f, -9.32167396e-02f, -6.75186962e-02f, 1.53771594e-01f, -2.63670608e-02f,
  1.25212312e-01f, 1.16287723e-01f, -2.40932032e-02f, -1.06013946e-01f, 6.92080706e-02f, 4.09270935e-02f, 1.57804981e-01f, 6.91573992e-02f, -5.51784225e-02f, 9.11807567e-02f,
  8.71759355e-02f, 1.49795711e-01f, 7.71119371e-02f, 6.69494718e-02f, 1.03286812e-02f, 1.65106684e-01f, 1.76573661e-03f, -2.84510497e-02f, 1.27743706e-01f, -2.16698535e-02f,
  1.45146504e-01f, -2.30741650e-02f, -2.01919049e-01f, 3.64248194e-02f, 6.90563917e-02f, 1.29177541e-01f, 4.42884155e-02f, -5.49090886e-03f, -2.00107932e-01f, -2.16543391e-01f,
  1.43236458e-01f, -1.23951405e-01f, -1.11246102e-01f, 3.85420658e-02f, 5.30272350e-02f, 1.93015203e-01f, 2.13414356e-02f, 9.40243974e-02f, -1.17816150e-01f, -4.91249328e-03f,
  2.23345589e-02f, -1.09694116e-01f, 7.96595588e-02f, 8.24399889e-02f, -3.27560455e-02f, -2.27898937e-02f, 6.61305338e-02f, 4.20289636e-02f, 6.18911758e-02f, -5.42876171e-03f,
  -1.93151124e-02f, 1.66678369e-01f, -9.54745859e-02f, -8.53034258e-02f, -1.03492215e-01f, 3.37751396e-02f, 1.12071298e-01f, -4.10134569e-02f, 1.46827117e-01f, -9.03616548e-02f,
  6.11307062e-02f, -3.57664120e-03f, -1.52159005e-01f, 7.99424499e-02f, 5.22089265e-02f, -1.58898620e-04f, 2.73446172e-01f, 3.60983610e-02f, 1.16098717e-01f, 1.70301720e-02f,
  -3.33654247e-02f, -1.20528683e-01f, -8.33030641e-02f, 9.52648744e-03f, 1.33732200e-01f, 1.09254003e-01f, -4.08648662e-02f, -4.74232771e-02f, 8.54296610e-02f, -1.25135407e-01f,
  1.45555139e-01f, -9.28231627e-02f, -1.96464825e-02f, 1.73586994e-01f, 9.30428877e-02f, -4.40956019e-02f, 2.46220767e-01f, -2.10829243e-01f, 2.64761578e-02f, 2.20202684e-01f,
  5.47029004e-02f, 2.62759387e-01f, -1.45782437e-02f, -8.66002142e-02f, -2.05148775e-02f, 2.05469802e-02f, 4.41145338e-02f, 9.74677280e-02f, -2.84527112e-02f, 3.48349512e-01f,
  -1.71527602e-02f, 1.00425586e-01f, 2.09519923e-01f, -1.45638630e-01f, 7.28165507e-02f, 1.02036009e-02f, 1.04086511e-01f, 1.04348809e-02f, 1.62936319e-02f, 3.24429013e-02f,
  1.31650880e-01f, -7.93077648e-02f, -4.77741696e-02f, -5.53001799e-02f, 6.62621334e-02f, -3.04030720e-02f, 6.45194128e-02f, -8.21768772e-03f, -1.03066014e-02f, 1.16279803e-01f,
  1.77745670e-02f, 1.21248990e-01f, -5.64022176e-02f, -1.16640314e-01f, -1.23545518e-02f, -1.41303360e-01f, -3.64935361e-02f, -1.14852600e-01f, 2.49006767e-02f, 5.36503196e-02f,
  1.77467942e-01f, 6.88916966e-02f, -7.01339915e-02f, 8.97457171e-03f, -4.98598143e-02f, 4.11935672e-02f, 2.15571091e-01f, 1.99136026e-02f, -3.51385772e-02f, 3.81503180e-02f,
  -9.11004394e-02f, 4.90579233e-02f, -7.10911080e-02f, -8.50941613e-02f, -7.66871199e-02f, 3.80169116e-02f, 7.87655115e-02f, -4.67359945e-02f, -6.06877431e-02f, -1.04255266e-01f,
  5.31051680e-02f, 5.56863584e-02f, -1.11073647e-02f, -4.58551534e-02f, -2.95957569e-02f, -1.15713492e-01f, 4.38818596e-02f, 1.30256340e-01f, -1.13428859e-02f, 9.77254063e-02f,
  9.45308525e-03f, -1.09292582e-01f, 1.05386578e-01f, -9.26323235e-02f, 1.19949751e-01f, -6.34784326e-02f, -5.37496321e-02f, 1.06281489e-01f, -8.49777386e-02f, -1.00070730e-01f,
  1.26451880e-01f, 7.84583762e-02f, -1.45738587e-01f, 1.11190215e-01f, -1.45450041e-01f, 8.19875598e-02f, 4.00569290e-02f, -1.17089286e-01f, 1.16888240e-01f, 7.82568567e-03f,
  -2.93134991e-03f, -8.41659587e-03f, 1.12789862e-01f, 8.67554992e-02f, -7.24380165e-02f, 1.15633458e-01f, 1.19433917e-01f, -1.70723107e-02f, 8.50324631e-02f, 5.76969460e-02f,
  -5.34965098e-02f, 5.96128367e-02f, -1.17146417e-01f, 1.12721473e-01f, 1.07306607e-01f, -3.64026688e-02f, 1.01804450e-01f, 4.21799161e-02f, -7.15956762e-02f, 9.74392965e-02f,
  3.65050174e-02f, 1.04429640e-01f, -3.95476483e-02f, 1.79558550e-03f, 6.09053299e-04f, 4.84451428e-02f, -7.28012770e-02f, -5.81340641e-02f, 1.15322366e-01f, -1.57562271e-01f,
  6.63364828e-02f, -9.83008817e-02f, -1.46193936e-01f, 1.05772540e-02f, 3.61231081e-02f, -1.68141499e-02f, 4.27285060e-02f, 1.01211950e-01f, -1.67490005e-01f, -1.57998919e-01f,
  -9.19355378e-02f, -2.03972086e-02f, -4.45998926e-03f, -7.82876164e-02f, -9.96020511e-02f, 8.70855302e-02f, 3.47856842e-02f, -6.01593331e-02f, 2.64279712e-02f, 1.16045410e-02f,
  -4.81657460e-02f, 3.12801152e-02f, -1.63011625e-02f, 4.32577953e-02f, 7.84327239e-02f, 4.75441441e-02f, 9.24136192e-02f, -1.08138219e-01f, 1.20824799e-01f, 6.79581165e-02f,
  1.16883382e-01f, -6.79614842e-02f, 1.22737288e-01f, -6.96149170e-02f, -6.63749650e-02f, 2.55004894e-02f, 2.44189687e-02f, -6.27180189e-03f, -9.68455896e-02f, 5.13919219e-02f,
  9.41088423e-02f, -5.71901500e-02f, 1.07972592e-01f, -1.15461335e-01f, -9.41050425e-03f, -5.91355599e-02f, 3.26584950e-02f, -3.49248201e-02f, 9.42109618e-03f, -8.71744081e-02f,
  -6.18975610e-02f, -2.12378297e-02f, 1.12673655e-01f, 2.73298360e-02f, 1.52369335e-01f, 1.09241605e-01f, 9.90167633e-02f, 9.23461020e-02f, 1.07517242e-01f, 8.79771560e-02f,
  1.77936822e-01f, 2.75341749e-01f, 2.16455013e-01f, 8.42986852e-02f, 1.64179772e-01f, 1.00872226e-01f, 2.55071193e-01f, 1.96579292e-01f, -1.75731629e-02f, 5.45007624e-02f,
  2.00192541e-01f, 6.97260424e-02f, -6.76669776e-02f, -2.73231138e-02f, 5.76927606e-03f, 8.73320103e-02f, 1.54587865e-01f, 5.54321632e-02f, -1.09554296e-02f, -2.62965739e-01f,
  -8.18292946e-02f, -1.99284390e-01f, 2.63048224e-02f, -9.36884731e-02f, -8.88051018e-02f, -1.10575333e-01f, -1.02223702e-01f, 1.65246755e-01f, -1.27919361e-01f, -1.88608821e-02f,
  -1.84682176e-01f, -1.94578078e-02f, -1.66062206e-01f, -1.95404775e-02f, 3.28906067e-03f, -1.28095075e-01f, -7.86262304e-02f, -7.71965832e-02f, 7.79610649e-02f, 1.44263029e-01f,
  9.64448031e-04f, -4.69879527e-03f, -7.93777853e-02f, -1.19983457e-01f, -1.19811855e-01f, 1.27127692e-01f, -5.78960665e-02f, -1.17154106e-01f, 1.08602278e-01f, -5.19230925e-02f,
  -6.36419952e-02f, 8.57259557e-02f, -3.44261900e-02f, 1.27807841e-01f, -1.91241987e-02f, -6.92315400e-02f, 5.81057258e-02f, -9.95138139e-02f, -6.31017387e-02f, -9.15492848e-02f,
  8.55145976e-02f, -3.69855799e-02f, 2.03720093e-01f, 2.26959929e-01f, 3.28234583e-03f, 8.12387392e-02f, 1.49904072e-01f, 3.66000831e-02f, 2.44214639e-01f, 1.50872335e-01f,
  -4.92086709e-02f, 3.17561716e-01f, 1.26579568e-01f, 2.00223818e-01f, -2.08553568e-01f, -2.34209836e-01f, -2.77167231e-01f, -2.07868502e-01f, 2.20755935e-01f, 1.87917352e-01f,
  -1.61082745e-01f, 2.32948288e-01f, -4.36014719e-02f, -9.40736849e-03f, 5.11824526e-02f, 1.44694913e-02f, -6.27898499e-02f, -3.64681222e-02f, -8.73086005e-02f, -2.33543050e-02f,
  7.71522671e-02f, 1.44021377e-01f, 6.53351173e-02f, -6.09643161e-02f, 3.39773148e-01f, -5.00454493e-02f, 1.89636290e-01f, 8.96242112e-02f, -6.21834658e-02f, 2.01640204e-01f,
  1.71506897e-01f, -6.32604435e-02f, 7.24574998e-02f, 1.37407675e-01f, 2.11251918e-02f, 2.82063172e-03f, 7.13082552e-02f, -3.86517830e-02f, -3.77315395e-02f, -1.19035646e-01f,
  1.63977623e-01f, 1.19875722e-01f, -2.86019184e-02f, 1.21287964e-01f, -4.03217934e-02f, 1.18893482e-01f, -2.22484674e-02f, 1.26234949e-01f, 1.12818129e-01f, 1.61234334e-01f,
  7.28261545e-02f, 1.27929389e-01f, -1.07342362e-01f, 2.17451155e-01f, 1.52960747e-01f, 7.37201720e-02f, 2.10355997e-01f, -1.04567476e-01f, -7.01887999e-03f, -1.13898152e-02f,
  3.93808223e-02f, -7.46090943e-03f, 1.18157610e-01f, 1.65297478e-01f, -2.08663405e-04f, 1.98730007e-01f, 1.11236252e-01f, 9.60413665e-02f, -1.33841410e-01f, 4.05589417e-02f,
  -1.17705636e-01f, 5.67147061e-02f, -1.58442274e-01f, -1.14472203e-01f, -6.52369484e-02f, -1.36264205e-01f, -1.12251624e-01f, 1.17379434e-01f, -1.06512800e-01f, 3.85008007e-01f,
  1.26726776e-01f, 1.95380636e-02f, -8.19511637e-02f, -1.08140804e-01f, 6.28283545e-02f, -1.13709211e-01f, -7.06725791e-02f, -9.38896462e-02f, 2.02547759e-01f, -3.94373313e-02f,
  2.40018144e-01f, 1.19669452e-01f, -7.32742250e-02f, 9.85128339e-03f, -9.15068090e-02f, 9.26486254e-02f, 1.34009141e-02f, 8.48063007e-02f, 1.60739257e-03f, -3.20440233e-02f,
  -8.39153975e-02f, -6.08083718e-02f, 9.00945887e-02f, -1.53847039e-01f, 2.30840355e-01f, -5.54094538e-02f, -4.79901880e-02f, 6.09675539e-04f, -3.63552980e-02f, -4.54189666e-02f,
  3.08040679e-01f, 2.85056662e-02f, 9.03662369e-02f, -1.17333621e-01f, -2.20641978e-02f, -1.15671329e-01f, -7.58716613e-02f, -4.18908969e-02f, 6.43601343e-02f, 3.19272429e-02f,
  2.63776933e-03f, 1.29141426e-02f, -9.07012746e-02f, 1.61817148e-01f, -1.88748576e-02f, -7.50696566e-03f, 1.52409866e-01f, 3.79420351e-03f, 8.49875808e-02f, 9.47330743e-02f,
  -5.53610064e-02f, -1.46288872e-02f, -1.11631796e-01f, -9.77108181e-02f, -4.27949987e-02f, -1.56705394e-01f, 1.14236414e-01f, -7.24081099e-02f, -5.23250401e-02f, 7.87713472e-03f,
  -3.68116540e-03f, 2.39275452e-02f, 1.44285755e-02f, 7.39189750e-03f, -5.15071489e-02f, 7.81747475e-02f, -8.50611180e-02f, 1.66197181e-01f, -1.83089394e-02f, 7.42162243e-02f,
  -7.01526329e-02f, -1.50409900e-03f, -8.54989812e-02f, -8.88599269e-03f, 2.26013474e-02f, 1.31953388e-01f, -1.34135395e-01f, -3.15509588e-02f, 5.07112257e-02f, -3.06190439e-02f,
  -6.64378256e-02f, 6.06196485e-02f, 1.25803202e-01f, 1.94976535e-02f, -7.98712224e-02f, 7.99388345e-03f, 5.29933907e-02f, 2.56004967e-02f, 6.38007894e-02f, 1.49267063e-01f,
  8.64977539e-02f, 2.42632674e-03f, -1.26679078e-01f, 2.41241585e-02f, -5.84746571e-03f, 5.84553070e-02f, -7.13352636e-02f, 5.61239310e-02f, 1.38608351e-01f, -4.68913987e-02f,
  -6.93394318e-02f, 7.87761733e-02f, -1.09638773e-01f, 2.57604092e-01f, 2.57753611e-01f, 3.09075773e-01f, 1.06440470e-01f, 2.00966492e-01f, -5.29064424e-02f, 5.50286695e-02f,
  7.76995793e-02f, 7.43565634e-02f, 2.14178525e-02f, 2.71031976e-01f, -3.60478103e-01f, 1.96312547e-01f, 2.82729179e-01f, 5.70517816e-02f, -3.47740710e-01f, -5.39020523e-02f,
  -4.50034708e-01f, 1.74654216e-01f, 6.83055893e-02f, -1.86051112e-02f, -3.05932224e-01f, -1.69508442e-01f, -4.51186672e-02f, 7.38078356e-03f, -8.85007307e-02f, -3.59313451e-02f,
  -1.85899377e-01f, -1.71454027e-02f, -1.19103052e-01f, 6.60323501e-02f, 7.81509206e-02f, 4.83745635e-02f, 6.15576096e-02f, 8.37079808e-02f, 2.89796572e-02f, 2.84880966e-01f,
  4.40341532e-02f, 1.75100744e-01f, -4.53160219e-02f, 1.86488971e-01f, 6.55031055e-02f, 9.74338800e-02f, -1.31044582e-01f, 6.48170635e-02f, 1.77149172e-03f, -7.40659088e-02f,
  1.89243276e-02f, -8.21181685e-02f, 3.13887775e-01f, -1.95896849e-01f, 5.22952527e-02f, 2.02923343e-01f, 6.10926524e-02f, -1.56785265e-01f, 2.95221567e-01f, 3.26929957e-01f,
  6.11544307e-03f, -9.72738042e-02f, 1.84606351e-02f, -5.01193330e-02f, 1.11985542e-01f, -1.20200470e-01f, 9.64809507e-02f, 2.15615213e-01f, 8.37461725e-02f, 3.17869663e-01f,
  1.34578243e-01f, 1.77966461e-01f, 8.46440047e-02f, 3.56125413e-03f, 2.32845649e-01f, 3.91328149e-02f, 4.09399047e-02f, 1.36836454e-01f, -3.55522156e-01f, 1.09990172e-01f,
  5.69303595e-02f, -5.90019003e-02f, 9.02230591e-02f, -1.06043465e-01f, -1.64951548e-01f, -2.65573412e-01f, 1.20709054e-01f, -1.68788791e-01f, -2.52479374e-01f, -3.33046168e-01f,
  1.49657717e-02f, 1.05300695e-01f, -9.57018323e-03f, 8.92477185e-02f, -1.87825248e-01f, 3.19355428e-01f, -9.16502327e-02f, -2.51933374e-02f, -4.20656763e-02f, -1.99424028e-02f,
  -1.33209288e-01f, 1.27803802e-01f, 1.15635442e-02f, 4.76326328e-03f, -6.19128495e-02f, -1.04232267e-01f, 1.87162310e-01f, -5.37460074e-02f, -1.32666200e-01f, -1.59283116e-01f,
  1.07855633e-01f, -1.77555546e-01f, 1.95678040e-01f, 1.57997116e-01f, 3.26822042e-01f, -6.74761310e-02f, 4.25314195e-02f, 4.24982905e-02f, -1.62301674e-01f, -6.66174963e-02f,
  -1.96653023e-01f, -1.19600117e-01f, 2.32547615e-02f, 1.97328284e-01f, -5.88385873e-02f, 1.01394266e-01f, -1.15898825e-01f, 2.74764188e-02f, -7.22504184e-02f, -4.86850329e-02f,
  5.06039448e-02f, 1.29230425e-01f, 1.77542359e-01f, -2.68348623e-02f, 8.64021108e-02f, -2.61765812e-02f, 5.52459061e-02f, 3.11794784e-02f, 1.67451054e-01f, -2.71550585e-02f,
  -6.16501532e-02f, -6.38057292e-02f, 3.65456007e-02f, 8.36896449e-02f, -9.30514783e-02f, 1.49824156e-03f, -1.10701635e-01f, -1.20915465e-01f, 5.02064116e-02f, 3.28672417e-02f,
  8.05447698e-02f, 8.88495073e-02f, -1.18117528e-02f, 8.72818902e-02f, -6.05341494e-02f, 1.17046922e-01f, -6.24973103e-02f, -3.95084023e-02f, -2.37301942e-02f, -3.33663151e-02f,
  -5.41754998e-03f, -1.04374431e-01f, 2.99209207e-02f, -1.08369306e-01f, 2.54818290e-01f, -6.20648637e-02f, 1.88271537e-01f, -9.60445479e-02f, -3.39451544e-02f, 1.80582389e-01f,
  -7.34294429e-02f, -6.59644371e-03f, 1.54464841e-01f, -1.55986054e-02f, 1.03745781e-01f, 1.10854678e-01f, -7.49625340e-02f, -8.62278715e-02f, 6.41696900e-02f, -3.59964147e-02f,
  -1.19266305e-02f, -6.42836690e-02f, -1.06379576e-01f, 8.85231420e-02f, 6.46476075e-02f, -1.34979906e-02f, 7.44519010e-03f, 1.28007501e-01f, 3.12880240e-03f, -1.04599796e-01f,
  1.37170419e-01f, -5.21023460e-02f, 4.17700224e-02f, -3.33171822e-02f, -1.07815504e-01f, 3.17680798e-02f, -8.55557024e-02f, -1.20471627e-01f, 5.44527620e-02f, -7.96205774e-02f,
  9.09569440e-04f, -2.41070446e-02f, -2.07534581e-02f, 9.28958505e-02f, 5.66927083e-02f, -6.03030324e-02f, -7.73110390e-02f, -9.18294955e-03f, -3.15389484e-02f, -8.07125047e-02f,
  7.40995109e-02f, -6.01495057e-02f, -7.37480372e-02f, 7.41433427e-02f, 3.15009826e-03f, 1.06641628e-01f, -8.29429924e-02f, -5.84677868e-02f, 7.00518563e-02f, 5.51720895e-02f,
  2.20578145e-02f, -1.14000686e-01f, 6.57265484e-02f, 1.43939272e-01f, 1.19177394e-01f, -7.94505253e-02f, -1.98475681e-02f, -2.98761227e-03f, 6.88938722e-02f, 8.36811028e-03f,
  4.72473726e-02f, -2.44807322e-02f, 1.43880481e-02f, 1.01226702e-01f, 1.30654842e-01f, 5.74528128e-02f, 4.91922908e-02f, -8.25603008e-02f, -1.15734994e-01f, -3.29897031e-02f,
  6.21450171e-02f, -7.30780959e-02f, 1.52260482e-01f, -8.84384476e-03f, -1.29210755e-01f, -1.55816255e-02f, 1.04680210e-02f, 9.97491404e-02f, 6.88768402e-02f, 7.55723938e-02f,
  2.24476564e-03f, 9.01207477e-02f, 2.55450364e-02f, -1.73232369e-02f, -3.86904255e-02f, -4.71673757e-02f, 8.81429836e-02f, -5.92998937e-02f, 8.50373805e-02f, 5.69673777e-02f,
  3.47029381e-02f, -8.40853453e-02f, 8.93951114e-03f, 3.99677316e-04f, -3.31761055e-02f, 9.24157165e-03f, -8.40003043e-03f, 8.47335234e-02f, 1.23492830e-01f, -3.55452299e-02f,
  1.27069699e-02f, 1.13525964e-01f, -2.02253342e-01f, 7.07503259e-02f, 1.11779414e-01f, 3.37304994e-02f, 5.86591326e-02f, -1.16161637e-01f, 8.24647546e-02f, 1.30285352e-01f,
  -4.76166457e-02f, 1.29165620e-01f, -6.46952391e-02f, 1.66071266e-01f, -8.07512254e-02f, 1.15721850e-02f, 7.98302069e-02f, -3.91497351e-02f, 8.57235193e-02f, -2.87812762e-02f,
  6.38718605e-02f, 4.36322205e-02f, -1.31647363e-01f, 2.50666253e-02f, 6.57524243e-02f, -9.07257870e-02f, -1.05776347e-01f, -1.17749549e-01f, -8.71267691e-02f, -3.62019129e-02f,
  4.42285240e-02f, 3.49688344e-02f, -1.18008172e-02f, 4.84187305e-02f, -8.73067826e-02f, 9.23838839e-02f, 1.38276890e-01f, -1.26711056e-01f, 7.76900351e-02f, 5.93745634e-02f,
  -1.14409059e-01f, 7.99700618e-02f, -9.91230309e-02f, -9.30474699e-02f, 4.13674712e-02f, -7.85635114e-02f, -8.89320374e-02f, -7.15127215e-02f, 4.31457162e-02f, -5.16614430e-02f,
  1.21280337e-02f, -8.96492749e-02f, 2.72132480e-03f, 8.99428651e-02f, 7.21120313e-02f, 8.35414529e-02f, 8.57207924e-02f, 9.01003461e-03f, 1.11831175e-02f, 3.39995436e-02f,
  6.10833727e-02f, 4.07435708e-02f, -6.15974255e-02f, 1.71635419e-01f, 1.36531994e-01f, -1.59438193e-01f, 1.26222134e-01f, 1.68282405e-01f, -2.97528505e-02f, 5.90643249e-02f,
  1.31567687e-01f, 1.62628591e-01f, 7.22270012e-02f, -1.30197674e-01f, -2.36964766e-02f, 1.65168062e-01f, 1.32172897e-01f, -8.41985806e-04f, 1.41631886e-01f, 6.60569370e-02f,
  1.41488105e-01f, -1.05058283e-01f, -6.37875963e-03f, 7.97749013e-02f, -1.33618340e-02f, 5.40919639e-02f, 1.62627205e-01f, -4.85130958e-02f, 2.12943047e-01f, 9.42331180e-02f,
  -1.21311180e-01f, 1.04176648e-01f, -1.19502313e-01f, 2.74936631e-02f, -5.26790135e-02f, 1.54516861e-01f, 9.97717753e-02f, 3.04589383e-02f, 8.48596245e-02f, -3.27892154e-02f,
  -6.13627285e-02f, 2.17356514e-02f, -1.09754175e-01f, -3.97326760e-02f, -5.33104688e-02f, 1.17302753e-01f, 1.69737816e-01f, 6.36764057e-03f, 8.34664702e-02f, -1.26029000e-01f,
  9.11481977e-02f, -6.84928000e-02f, 8.05781260e-02f, -2.37216838e-02f, 1.33681506e-01f, -7.01267347e-02f, 1.16972461e-01f, -1.11611485e-01f, 9.38156843e-02f, 1.48530424e-01f,
  4.79376540e-02f, 6.27350621e-03f, 2.68127248e-02f, 6.85875341e-02f, -2.89177652e-02f, 3.63398120e-02f, 1.66675568e-01f, 7.45565742e-02f, 3.57058801e-04f, 9.99444500e-02f,
  -1.30414113e-01f, 1.70139465e-02f, -1.80895045e-01f, -2.70643800e-01f, -2.86552478e-02f, 1.86912894e-01f, -2.07414508e-01f, 1.62712201e-01f, -8.55744258e-02f, -2.10216507e-01f,
  3.18848416e-02f, 3.56462002e-02f, 1.00544944e-01f, 1.06612436e-01f, -9.53712910e-02f, 1.79878324e-01f, 1.11795053e-01f, 1.26069307e-01f, -7.79620260e-02f, -7.69082755e-02f,
  -3.44985537e-02f, 1.28364071e-01f, 9.58391279e-02f, 1.17554702e-01f, -9.23392326e-02f, 7.26975675e-04f, 1.15686096e-01f, -1.23106502e-02f, -2.13137157e-02f, 1.74516395e-01f,
  -9.94219929e-02f, 8.66565481e-02f, 4.38530780e-02f, 5.79818003e-02f, -1.14110708e-02f, 2.26199571e-02f, -8.77495110e-02f, 9.52316150e-02f, -1.96711253e-02f, -8.74425918e-02f,
  3.41663114e-03f, 9.45769548e-02f, -4.81710173e-02f, -1.10510156e-01f, 9.64074209e-02f, 2.53285915e-02f, -1.25455353e-02f, -1.02103896e-01f, -8.36630613e-02f, 1.63409024e-01f,
  2.94791944e-02f, 2.88463500e-03f, 1.05899975e-01f, 6.52005002e-02f, 5.37281334e-02f, -8.28637853e-02f, 1.04372121e-01f, -3.26839276e-03f, 7.60784224e-02f, -8.51183459e-02f,
  1.20716147e-01f, -1.79692209e-02f, -1.07221514e-01f, 1.68399364e-01f, -1.33143246e-01f, -8.81723911e-02f, 1.07319035e-01f, -6.29763827e-02f, -1.36009350e-01f, -1.78145126e-01f,
  1.15315393e-01f, -1.36001017e-02f, -1.90191537e-01f, -1.10859133e-01f, -8.50750785e-03f, 1.65569544e-01f, -4.05171476e-02f, 8.07584673e-02f, 2.97073717e-03f, 5.29811427e-04f,
  1.61564369e-02f, -7.02878311e-02f, -7.37025067e-02f, -1.25530481e-01f, -1.19226255e-01f, 4.57800590e-02f, 2.29237019e-03f, -7.46274740e-02f, 9.82744768e-02f, 9.68757346e-02f,
  1.30151585e-01f, 6.23720232e-03f, 1.21980391e-01f, 7.99194071e-03f, 1.34842498e-02f, -5.92373461e-02f, -4.02340181e-02f, 9.18201879e-02f, 2.10005581e-01f, 7.30224028e-02f,
  9.62382481e-02f, 7.05940872e-02f, -1.22704580e-01f, -7.99921975e-02f, -9.60848108e-02f, -9.01950151e-02f, 6.44203722e-02f, 1.51416957e-01f, 1.93144064e-02f, 2.20388174e-02f,
  9.55034606e-03f, -7.56266490e-02f, -1.03905044e-01f, 1.15682613e-02f, 5.00527322e-02f, -3.02757155e-02f, 2.28297010e-01f, 1.63163781e-01f, -7.19697326e-02f, 2.49791473e-01f,
  -7.04255849e-02f, 1.53500721e-01f, 1.93609864e-01f, -3.66652049e-02f, 6.60553798e-02f, 5.84285259e-02f, 1.15781575e-01f, 2.07338229e-01f, -2.11627916e-01f, -2.22997829e-01f,
  -7.69330263e-02f, -1.84144318e-01f, 1.96992040e-01f, 3.06448042e-01f, -1.70712136e-02f, 1.67041302e-01f, 4.60198671e-02f, 4.10308354e-02f, 6.76618284e-03f, -9.92174074e-02f,
  -1.90539453e-02f, -9.25871953e-02f, -1.12276047e-01f, 2.60899104e-02f, -8.44066739e-02f, -3.79479527e-02f, 6.46819919e-02f, 7.94712380e-02f, 2.63613403e-01f, -1.05972722e-01f,
  1.25951305e-01f, 8.76866430e-02f, -3.98642831e-02f, 1.30244419e-01f, 9.52564627e-02f, -4.68897671e-02f, 5.41148707e-02f, -1.03595093e-01f, 9.62043554e-02f, -5.77830672e-02f,
  9.94084775e-02f, -6.54599443e-02f, -1.32020190e-01f, -1.13812372e-01f, 2.91800220e-02f, 5.60081005e-03f, -1.36377662e-02f, 1.77868694e-01f, -3.78753431e-02f, 1.45840764e-01f,
  1.10964164e-01f, 1.43768653e-01f, 5.01526780e-02f, 8.84298459e-02f, 1.95063144e-01f, -4.99683283e-02f, 9.09457356e-03f, 1.95105448e-01f, -9.28499028e-02f, 5.95496930e-02f,
  -1.75681803e-02f, -5.52988723e-02f, -4.16802950e-02f, 1.12314709e-01f, 4.18762192e-02f, -4.53857519e-03f, -7.96783790e-02f, -1.15524501e-01f, -2.89454032e-02f, -2.67507117e-02f,
  -2.10298714e-03f, -2.27901459e-04f, 3.75962965e-02f, 3.25661115e-02f, -8.70620012e-02f, -1.55875802e-01f, -4.44903523e-02f, 1.45981163e-01f, -3.90989557e-02f, 1.27438977e-01f,
  5.86642474e-02f, -9.16973650e-02f, -2.69399909e-03f, 9.50766876e-02f, 5.48053235e-02f, -8.64162669e-02f, -3.46116401e-04f, 1.32915601e-01f, -2.25588512e-02f, 9.31832008e-03f,
  1.17019720e-01f, 5.97298928e-02f, -9.54424143e-02f, 1.26734897e-01f, -1.09967202e-01f, -6.55591488e-02f, 1.09359831e-01f, 8.35728720e-02f, 5.94804250e-02f, -9.07901451e-02f,
  -1.10780418e-01f, 3.60207297e-02f, 1.31173329e-02f, -4.91686873e-02f, -1.14969447e-01f, 4.10272740e-03f, 1.26588225e-01f, -6.04785234e-02f, -1.22768246e-02f, 7.02679306e-02f,
  -1.58106610e-02f, -3.91109139e-02f, -1.24047272e-01f, -4.40588687e-03f, 6.61789328e-02f, 1.03689902e-01f, 5.39569370e-02f, -5.04999384e-02f, 2.46421397e-02f, -3.88499796e-02f,
  -6.40008375e-02f, 6.09063953e-02f, 6.97911754e-02f, 1.08421840e-01f, 4.24469821e-02f, -7.26133659e-02f, -4.93884012e-02f, -2.18077935e-02f, 8.37337747e-02f, 7.97580704e-02f,
  1.02909014e-01f, -9.21593921e-04f, 3.83203998e-02f, 1.54010564e-01f, -2.70149559e-02f, 9.02213231e-02f, -4.03146856e-02f, 1.43630961e-02f, -7.74171650e-02f, -6.94683120e-02f,
  1.59031168e-01f, -1.26214355e-01f, -1.77388936e-02f, 1.69537604e-01f, -5.08735999e-02f, -3.71681526e-02f, 2.64642034e-02f, 2.30250671e-03f, -8.40649754e-02f, -6.42894581e-02f,
  -4.66403738e-02f, 1.22280046e-01f, 1.03491239e-01f, 4.85037779e-03f, 9.90139619e-02f, -9.72792655e-02f, -1.81201681e-01f, 7.11985976e-02f, -7.66865835e-02f, -1.02484673e-01f,
  4.80524041e-02f, 1.18263222e-01f, 2.38038916e-02f, -1.05668202e-01f, 4.58130352e-02f, -1.24292359e-01f, -6.96971864e-02f, 6.89783171e-02f, 3.16073149e-02f, 1.53153529e-02f,
  9.57483649e-02f, -1.05613485e-01f, 5.38634844e-02f, 1.42727748e-01f, -3.84755507e-02f, 7.77731091e-03f, 1.50975715e-02f, 8.63169357e-02f, 1.15352504e-01f, 1.21282123e-01f,
  -2.42152959e-02f, -4.12386134e-02f, -9.78080407e-02f, -3.06279082e-02f, -7.17641711e-02f, 9.25147906e-02f, 8.89813751e-02f, -1.12413958e-01f, 1.64521366e-01f, 1.60227448e-01f,
  3.38811427e-02f, 3.81656103e-02f, 1.48265511e-01f, -3.20158317e-04f, 1.67588234e-01f, -2.86334399e-02f, -1.43405467e-01f, 1.75804630e-01f, -1.81186959e-01f, 3.01429719e-01f,
  1.28804386e-01f, 7.70771578e-02f, -3.22533369e-01f, -1.04649998e-01f, 2.03897785e-02f, 7.35281780e-02f, -1.21285208e-01f, -3.96843702e-02f, 6.04203790e-02f, -6.09427178e-03f,
  -5.95235899e-02f, -3.06429379e-02f, 1.32337987e-01f, 1.72557062e-04f, -7.60134459e-02f, -1.51255339e-01f, 1.34364173e-01f, -5.37114218e-02f, 1.32091552e-01f, -3.96530852e-02f,
  2.78184384e-01f, 2.05973405e-02f, 3.29508245e-01f, 1.17882594e-01f, -1.02800220e-01f, 1.59210280e-01f, 7.94227123e-02f, 8.05067457e-03f, 1.25105679e-01f, 2.01177910e-01f,
  7.78376684e-02f, -1.99139249e-02f, -9.18023884e-02f, -1.55050755e-02f, 4.77210134e-02f, 4.19902578e-02f, 1.10886201e-01f, 5.28053083e-02f, -1.34126460e-02f, 1.33355528e-01f,
  8.54511112e-02f, -7.03022555e-02f, 2.04293486e-02f, -8.18561167e-02f, -2.54131518e-02f, 1.00121491e-01f, -7.54335225e-02f, 4.27176021e-02f, 1.02468967e-01f, -2.01756731e-02f,
  -3.68415262e-04f, -1.01299666e-01f, -7.25997537e-02f, 6.36367872e-02f, 5.99856256e-03f, 1.33353755e-01f, 1.60942618e-02f, 7.96970911e-03f, -2.55918503e-03f, 8.43214989e-02f,
  1.39874950e-01f, 9.96327102e-02f, -5.94572574e-02f, -1.33635610e-01f, 1.55427560e-01f, 5.69273755e-02f, 3.99144143e-02f, -4.39328747e-03f, -1.11971833e-01f, 1.02060460e-01f,
  1.55677095e-01f, -7.21614882e-02f, 9.66213178e-03f, 1.81233082e-02f, -3.91569063e-02f, -4.99841385e-02f, -3.77612188e-02f, 1.27491906e-01f, 5.44744618e-02f, -1.40029967e-01f,
  1.04748383e-01f, -4.48786281e-02f, -5.20307459e-02f, 1.67662561e-01f, -6.93358853e-02f, -6.82060868e-02f, 5.25042787e-02f, -5.24527300e-03f, -1.08345516e-01f, 1.07396036e-01f,
  -9.05797929e-02f, -4.11341898e-02f, 4.62141968e-02f, 1.53852880e-01f, 9.35910046e-02f, -7.97197819e-02f, 1.96783002e-02f, -1.02917217e-01f, 7.44055631e-03f, 3.45678590e-02f,
  7.36123994e-02f, 1.81131717e-02f, -2.67815813e-02f, -5.68417460e-02f, 1.37158141e-01f, 7.56902844e-02f, -2.56589130e-02f, -9.15048718e-02f, -8.56511593e-02f, -8.03559348e-02f,
  -1.07709154e-01f, 3.06571648e-02f, 1.27646819e-01f, 1.05117401e-02f, 4.00816426e-02f, 8.46334547e-02f, 4.19122204e-02f, -3.43004502e-02f, -5.79159744e-02f, 3.50999460e-02f,
  1.26458719e-01f, -3.30571532e-02f, 1.65313438e-01f, 1.55258417e-01f, 5.50528206e-02f, 9.29402038e-02f, -2.13176399e-01f, 6.62355721e-02f, -1.07714377e-01f, 2.92331055e-02f,
  1.04911678e-01f, -5.48499115e-02f, 3.49215530e-02f, 2.63293814e-02f, -3.11721452e-02f, -1.05617233e-01f, -2.08596587e-01f, -2.59883940e-01f, -6.17655441e-02f, 2.29596585e-01f,
  -1.15680389e-01f, 8.20488110e-02f, 8.67417604e-02f, 1.89988449e-01f, -9.83127505e-02f, 1.43354148e-01f, 5.42093180e-02f, -7.46059641e-02f, -3.41525525e-02f, 1.07129857e-01f,
  -5.13526462e-02f, 1.16664775e-01f, -6.92768246e-02f, 9.91146360e-03f, 7.63052851e-02f, 1.27574150e-02f, 9.61132199e-02f, 5.27397916e-02f, -1.17261708e-01f, -5.55988587e-02f,
  1.05338462e-01f, -4.27152328e-02f, 1.68990999e-01f, 1.04626119e-01f, 1.64016280e-02f, 4.30866750e-03f, -7.37143531e-02f, -7.17615187e-02f, 2.68180878e-03f, 7.54460618e-02f,
  3.63875479e-02f, 1.54842958e-02f, 2.81631909e-02f, -4.24170196e-02f, 4.81586754e-02f, -3.76267955e-02f, 6.79688230e-02f, 1.39903858e-01f, 9.78017896e-02f, -1.53500009e-02f,
  1.40550688e-01f, -6.33190423e-02f, 1.58115909e-01f, 1.13773674e-01f, 3.02614700e-02f, 1.57250643e-01f, 1.03405528e-01f, -2.79655065e-02f, 2.04547420e-01f, 2.15519786e-01f,
  1.92298084e-01f, -1.11001186e-01f, -1.05642162e-01f, -2.82700449e-01f, 1.48345940e-02f, 1.30741060e-01f, 1.50365621e-01f, 1.15588799e-01f, -8.55072960e-02f, 2.25179836e-01f,
  3.87812220e-02f, 1.40744328e-01f, -1.27808126e-02f, -8.18246305e-02f, -2.67904326e-02f, 6.91839159e-02f, 1.25113890e-01f, -1.12372965e-01f, 6.73923716e-02f, -1.09113656e-01f,
  -7.48044774e-02f, -1.95353478e-02f, 1.01376943e-01f, -7.32806474e-02f, -1.69264093e-01f, -8.46779495e-02f, 1.39787763e-01f, 8.57485980e-02f, -9.60023999e-02f, -1.81483431e-03f,
  -3.12342588e-02f, -4.42133620e-02f, 3.08250058e-02f, -7.97978863e-02f, 5.24743907e-02f, 5.62029965e-02f, -7.03388676e-02f, -8.47232193e-02f, 8.93163905e-02f, 1.37943998e-01f,
  -1.09772421e-01f, 1.52290806e-01f, 9.21528339e-02f, 2.14691348e-02f, 1.66466117e-01f, 1.79608494e-01f, -1.18889645e-01f, -7.32065216e-02f, 2.48222843e-01f, 4.65587080e-02f,
  -1.37927324e-01f, 1.35494113e-01f, 3.59672010e-02f, 6.64631650e-02f, 8.24287608e-02f, 1.08589746e-01f, 8.33353214e-03f, 1.61235392e-01f, 3.45434844e-02f, 1.86129604e-02f,
  5.40369004e-02f, -2.53894459e-02f, 1.18953101e-01f, 6.47782087e-02f, -1.13790475e-01f, 1.76724643e-01f, 1.97942369e-02f, 1.03224218e-01f, -1.24543607e-02f, -1.26765326e-01f,
  3.27708200e-02f, 5.93698137e-02f, 5.21065928e-02f, -4.93643731e-02f, 3.93264554e-02f, -1.02531984e-01f, -6.80892393e-02f, -8.55171457e-02f, 4.94078211e-02f, 1.11621305e-01f,
  -1.10613674e-01f, 1.34050176e-01f, 7.05915242e-02f, 1.91914752e-01f, 9.37559456e-03f, -3.18414643e-02f, -1.15864508e-01f, 4.96243611e-02f, -9.29716509e-03f, 8.89282897e-02f,
  1.15172602e-01f, 8.81236494e-02f, 1.13967083e-01f, 3.86675559e-02f, -1.31708309e-02f, 1.09973304e-01f, -9.08150673e-02f, 3.54120545e-02f, 1.89022906e-02f, -9.80994198e-03f,
  -9.01995078e-02f, 6.02465495e-02f, -6.78151920e-02f, -3.29073146e-02f, 5.99131882e-02f, 7.69568831e-02f, -8.25299546e-02f, -9.11195278e-02f, -1.77272514e-01f, -9.34905708e-02f,
  3.18600386e-02f, 8.93804654e-02f, -8.61544609e-02f, -1.32641559e-02f, 7.83121809e-02f, -1.47403954e-02f, 1.78390056e-01f, -1.19542833e-02f, -1.18984291e-02f, -4.49716076e-02f,
  7.22891390e-02f, 1.02460630e-01f, 1.20593347e-02f, -3.29172760e-02f, 1.66883171e-01f, 1.09074302e-01f, 1.10778399e-01f, -2.24716514e-02f, -8.47416297e-02f, 1.63761377e-01f,
  -1.53390005e-01f, -1.97459776e-02f, 1.16389051e-01f, -2.56225437e-01f, 1.63625386e-02f, 8.29343498e-02f, -1.33080959e-01f, 9.05004516e-02f, 8.09335187e-02f, -1.29165277e-01f,
  -2.26558447e-02f, 4.59764972e-02f, 1.05423801e-01f, -2.32632598e-03f, -1.28307521e-01f, 2.74313092e-01f, 4.56296131e-02f, 1.85926244e-01f, -1.07470676e-01f, -5.40437736e-02f,
  1.88680425e-01f, -8.35181475e-02f, 1.23406328e-01f, -9.53002796e-02f, 1.54574532e-02f, 1.65161744e-01f, 8.76230970e-02f, -1.08308353e-01f, -1.33536831e-01f, -3.38658318e-02f,
  -1.12982221e-01f, 1.28238797e-01f, -9.22516510e-02f, 1.10506207e-01f, -3.55741940e-05f, -1.27449930e-01f, -1.16497084e-01f, 5.77063449e-02f, 6.33092001e-02f, -3.71014848e-02f,
  -8.38486571e-03f, -5.83488829e-02f, -2.94018391e-04f, -1.74359545e-01f, 5.79548888e-02f, 5.70052415e-02f, 1.12865724e-01f, -1.84248891e-02f, 1.31459549e-01f, -1.17753139e-02f,
  5.02624586e-02f, -1.03007585e-01f, -1.13511242e-01f, 4.39187000e-03f, -3.90304253e-02f, 2.71553695e-02f, -9.52399150e-02f, -3.40562463e-02f, 1.26748353e-01f, -2.81663123e-03f,
  6.46953359e-02f, -4.34949920e-02f, -1.56969547e-01f, 1.08958475e-01f, -1.12915643e-01f, -2.35667098e-02f, -1.08913213e-01f, -4.58876491e-02f, -2.28519421e-02f, 4.81130369e-02f,
  1.87752303e-02f, 4.30309996e-02f, 3.96680608e-02f, 7.19503686e-02f, -4.04377915e-02f, -2.27681287e-02f, -2.71060579e-02f, -2.96940506e-02f, -1.75773387e-03f, 2.01499611e-02f,
  8.61313939e-02f, 4.55687903e-02f, -9.81817842e-02f, -5.40011413e-02f, 2.82957964e-02f, -7.44318515e-02f, -1.25373170e-01f, 6.80634230e-02f, 9.68381688e-02f, -4.17426368e-03f,
  9.59992409e-02f, 1.19648138e-02f, -1.16197005e-01f, -3.74781676e-02f, -7.92645961e-02f, -1.08947754e-01f, -6.31459579e-02f, -1.82414129e-02f, 9.61149335e-02f, 9.03456360e-02f,
  5.95156476e-02f, -1.05878465e-01f, -6.58441558e-02f, -4.44641858e-02f, -1.84788927e-02f, -1.16427362e-01f, 3.83528806e-02f, -8.62775519e-02f, 1.03811145e-01f, 7.39806369e-02f,
  -3.67483608e-02f, -9.89264622e-02f, 3.05928942e-02f, 1.06773077e-05f, 1.23875149e-01f, -5.32212816e-02f, 2.00103268e-01f, 3.02733541e-01f, -4.91026491e-02f, 1.24246195e-01f,
  1.20527126e-01f, 1.28094584e-01f, 1.57049283e-01f, -3.79531793e-02f, 7.83910453e-02f, 2.60142088e-01f, 1.03443630e-01f, 1.45264715e-01f, 6.42218590e-02f, -1.47158012e-01f,
  -1.88140258e-01f, -8.04255456e-02f, -1.00802042e-01f, 2.37668484e-01f, -6.97003230e-02f, -1.54978959e-02f, -4.46393713e-02f, -1.48605436e-01f, 8.58616754e-02f, 8.62157121e-02f,
  1.30536154e-01f, -4.53214645e-02f, -7.56141096e-02f, -9.56026986e-02f, -3.58428322e-02f, -6.68614730e-02f, 1.82005271e-01f, 5.22963293e-02f, -1.44183710e-01f, -5.32910265e-02f,
  4.98224907e-02f, 2.38095313e-01f, -2.50435602e-02f, -2.56535858e-02f, 5.91280498e-02f, 1.65021140e-02f, 1.12674482e-01f, 6.83936924e-02f, -5.89774400e-02f, -4.13882174e-02f,
  -6.41317070e-02f, -3.82365026e-02f, -7.91428536e-02f, -3.59893367e-02f, 1.39648526e-03f, -7.26354495e-02f, 1.45374462e-01f, -2.56456919e-02f, -8.65654871e-02f, 8.54000524e-02f,
  1.12369269e-01f, 1.50887072e-01f, -7.23087415e-02f, -7.90516194e-03f, 1.24829940e-01f, -1.06455445e-01f, -1.36203229e-01f, 3.96334827e-02f, -5.06977784e-03f, 2.04548147e-02f,
  1.25967991e-02f, -8.70147794e-02f, -3.94167937e-02f, -1.07296012e-01f, 4.57774512e-02f, -9.00048539e-02f, 8.36401209e-02f, -4.05388884e-02f, -6.31177127e-02f, -1.77925602e-02f,
  3.28669772e-02f, 5.83982430e-02f, -4.76216152e-02f, -1.01191387e-01f, 8.84532835e-03f, 7.78097287e-02f, 1.09864809e-01f, -2.71097850e-02f, -1.03341095e-01f, 9.73070115e-02f,
  2.21340973e-02f, 5.48568927e-02f, -3.93850292e-04f, 9.94714350e-02f, -4.29580249e-02f, 2.43043546e-02f, 4.73600440e-02f, -6.38642013e-02f, 9.06515941e-02f, -4.34741452e-02f,
  -2.92564556e-02f, 1.05071485e-01f, 5.10260090e-02f, -4.74105999e-02f, 6.56032860e-02f, -5.51209562e-02f, -3.83589529e-02f, 3.12373955e-02f, 6.12911955e-02f, 2.91983597e-02f,
  7.86527693e-02f, 1.20694384e-01f, 5.40271075e-03f, -1.59660485e-02f, -4.48269062e-02f, 7.61780217e-02f, -8.10795370e-03f, -5.20600379e-03f, -8.09897855e-02f, -1.04404666e-01f,
  3.28244157e-02f, 9.14089009e-02f, 1.13091227e-02f, -1.75392870e-02f, -5.13333082e-02f, 4.53872979e-02f, 1.18403494e-01f, -1.27019761e-02f, -1.15820371e-01f, 4.45973128e-02f,
  -4.39900495e-02f, 1.12362681e-02f, 1.09792463e-01f, 9.25603881e-02f, 8.55312124e-03f, 1.34622067e-01f, -4.35633436e-02f, -2.58948989e-02f, 1.60875604e-01f, 1.66826416e-02f,
  6.11187257e-02f, 7.07711801e-02f, 7.04922900e-02f, -9.37295333e-02f, 3.89808640e-02f, -1.09961703e-02f, -3.88681069e-02f, 2.95733269e-02f, 1.08882576e-01f, 1.40359043e-03f,
  9.06488895e-02f, -1.13998828e-02f, -1.46265049e-02f, -1.00930966e-01f, 4.66196239e-03f, 4.72242050e-02f, -2.87523568e-02f, 1.38453618e-01f, -1.89535855e-03f, 9.21705663e-02f,
  1.04354747e-01f, 2.18449220e-01f, -7.90645331e-02f, 1.34452745e-01f, -1.40337616e-01f, -2.47628056e-02f, 1.81144103e-02f, 1.48819849e-01f, 7.37547725e-02f, -6.03794791e-02f,
  8.38423446e-02f, 6.82416260e-02f, 4.71548969e-03f, -7.44722560e-02f, -3.05727515e-02f, 8.55406448e-02f, 3.73860560e-02f, -1.19593874e-01f, 6.02105781e-02f, 1.05970375e-01f,
  1.33214921e-01f, -2.00008731e-02f, -1.46095335e-01f, 1.09811395e-01f, -1.03373162e-01f, -1.22534186e-01f, 9.32513643e-03f, 5.58684357e-02f, 8.49490613e-03f, -1.45635083e-01f,
  -5.23512512e-02f, -1.06439330e-01f, -1.65394954e-02f, 4.77861427e-02f, -8.14517513e-02f, 7.81589225e-02f, 4.52215858e-02f, 2.39672899e-01f, 2.35599130e-01f, 1.00937605e-01f,
  2.08549917e-01f, 3.64794098e-02f, 6.88708350e-02f, -2.28651017e-02f, 2.07759798e-01f, 1.91721886e-01f, 6.38828129e-02f, -9.28388759e-02f, -4.55002226e-02f, -1.57781437e-01f,
  8.19600374e-02f, 1.14363596e-01f, 1.65183172e-01f, 1.83966801e-01f, 4.86790203e-02f, -2.48164415e-01f, 1.66325420e-01f, -4.41777483e-02f, -1.76473320e-01f, -1.30455196e-01f,
  -6.31747916e-02f, 2.01772168e-01f, 3.21989022e-02f, 5.66473529e-02f, 3.15499119e-02f, 7.38796871e-03f, 2.36493796e-02f, 6.66976869e-02f, -1.57948826e-02f, -1.04300097e-01f,
  -1.52317792e-01f, 5.61316200e-02f, -5.69712780e-02f, -1.02879778e-01f, -4.11175080e-02f, -1.18042499e-01f, 4.41947058e-02f, -9.47548524e-02f, -1.08307444e-01f, -3.89236584e-02f,
  2.18042266e-02f, -8.12827274e-02f, 3.91821787e-02f, 8.82818848e-02f, 2.45269179e-01f, -1.19749054e-01f, 6.13694489e-02f, -4.60876487e-02f, -1.34072691e-01f, 1.35487199e-01f,
  8.39297548e-02f, 3.03375814e-02f, 1.98160738e-01f, -8.50939825e-02f, 5.28318360e-02f, 4.04737331e-03f, -1.21968761e-02f, -2.58613210e-02f, 1.56051308e-01f, 6.62563592e-02f,
  3.90536189e-02f, -1.94063512e-04f, -8.32402427e-03f, -1.95558276e-03f, 5.26798405e-02f, -8.84121209e-02f, 1.16652101e-01f, -1.43921133e-02f, 7.85963237e-02f, 2.78515019e-03f,
  1.48691148e-01f, -8.85203332e-02f, 4.81872670e-02f, 1.02981433e-01f, -1.67846635e-01f, 5.11486409e-03f, 4.49196175e-02f, 8.81956294e-02f, 2.53371224e-02f, -2.90828526e-01f,
  -1.42696440e-01f, 8.26174114e-03f, -1.77283347e-01f, 2.25572493e-02f, 1.32201493e-01f, 3.37168276e-01f, 7.52057210e-02f, 6.38262406e-02f, 6.52960390e-02f, 1.61896691e-01f,
  7.38113821e-02f, -6.40739948e-02f, 1.39184177e-01f, 2.32178606e-02f, 4.40414548e-02f, 1.21733859e-01f, -1.20953135e-01f, -8.21344741e-03f, -3.26011889e-02f, -7.49195218e-02f,
  2.44397856e-02f, -1.03883773e-01f, 2.91917995e-02f, -4.24640300e-03f, 6.45140633e-02f, 5.46125174e-02f, 1.45488322e-01f, 1.95813596e-01f, 1.96025655e-01f, -1.31342247e-01f,
  1.05861187e-01f, 1.37243688e-01f, 6.17837049e-02f, 7.94383958e-02f, 2.88864728e-02f, -1.24783374e-01f, 1.30207658e-01f, -9.70982984e-02f, 1.12535410e-01f, -1.30179049e-02f,
  -4.23177443e-02f, -1.17322110e-01f, 1.19470365e-01f, 7.74727166e-02f, -1.22327164e-01f, 1.23570003e-02f, 2.76105739e-02f, 1.13997556e-01f, -1.10566057e-01f, -1.22886308e-01f,
  -7.23769292e-02f, -1.34760970e-02f, -8.92234072e-02f, -8.53981525e-02f, 1.03347242e-01f, -1.99504402e-02f, 3.49342078e-02f, 1.64487567e-02f, -4.79199030e-02f, 3.50962542e-02f,
  7.25446418e-02f, -1.06553007e-02f, 3.79334576e-02f, 1.10866979e-01f, -7.09221289e-02f, -1.07078880e-01f, -6.28836378e-02f, 1.09803248e-02f, 3.97740528e-02f, 3.88032803e-03f,
  -7.65292570e-02f, 2.64822505e-02f, -5.56778722e-02f, -1.53651610e-02f, 8.99695605e-02f, -3.62566523e-02f, 1.89222340e-02f, 8.05285126e-02f, -2.77995542e-02f, -7.94293433e-02f,
  8.94131139e-02f, -9.98476595e-02f, -5.55111691e-02f, 5.73681220e-02f, -8.07981938e-02f, -1.60268974e-02f, 5.44126220e-02f, 1.23655498e-01f, 1.07493751e-01f, 7.58240744e-03f,
  7.58765871e-03f, 9.84083861e-02f, 8.79185647e-03f, 1.01840496e-01f, -1.20224670e-01f, -6.02106377e-02f, 9.88725945e-03f, -8.29197653e-03f, 4.92217205e-02f, -8.44155625e-02f,
  -1.39621034e-01f, -7.56431669e-02f, -3.88690084e-02f, -1.20372392e-01f, -2.42796894e-02f, 1.29181286e-02f, 5.95169738e-02f, 1.80295222e-02f, 2.87721921e-02f, -7.65910521e-02f,
  5.97601533e-02f, -6.40901402e-02f, -3.16888504e-02f, -1.28091156e-01f, 3.67682762e-02f, 5.75683489e-02f, -7.82560334e-02f, -5.89419566e-02f, -5.36678731e-02f, 1.02041505e-01f,
  1.03348441e-01f, -5.13347499e-02f, 4.38438207e-02f, 7.30504468e-03f, 2.04346105e-02f, -1.19141690e-01f, -3.23750377e-02f, 1.60331964e-01f, -4.40869518e-02f, -1.05999090e-01f,
  1.56628042e-01f, 1.61642395e-02f, 3.01913098e-02f, -4.26143408e-02f, -7.68650472e-02f, -3.87559943e-02f, 1.03207439e-01f, 1.90306325e-02f, -7.66703300e-03f, -8.42236914e-04f,
  -8.13942850e-02f, -1.04788326e-01f, 2.65189707e-01f, -4.33859713e-02f, 2.13778585e-01f, -7.48909563e-02f, -1.19892113e-01f, 1.67253762e-01f, 7.49134868e-02f, 7.39900116e-03f,
  1.15747482e-01f, 1.80389792e-01f, -2.97678635e-02f, 1.39693925e-02f, 1.27051577e-01f, 6.85286447e-02f, -8.35028887e-02f, 4.05835621e-02f, 3.81006487e-02f, -7.89463520e-02f,
  9.49410573e-02f, 9.03115124e-02f, -8.27354491e-02f, -8.62253457e-02f, -5.08334786e-02f, -8.75276923e-02f, -3.97635773e-02f, 2.77211275e-02f, -1.20699406e-01f, -7.88605735e-02f,
  1.54123992e-01f, -2.64993459e-02f, -9.01993439e-02f, 7.68561382e-03f, 1.60429683e-02f, -5.70504032e-02f, 4.20431718e-02f, 6.72306046e-02f, 5.32856956e-02f, -3.56930383e-02f,
  7.68202171e-03f, 2.84109451e-02f, -5.59211336e-02f, 1.01008549e-01f, -3.20285968e-02f, -1.88732278e-02f, -1.40930206e-01f, 5.91664538e-02f, 5.53400964e-02f, 1.56502336e-01f,
  -8.90147090e-02f, -1.26071453e-01f, 9.27088968e-03f, -9.68657658e-02f, -1.66635085e-02f, -2.09642686e-02f, -8.67910013e-02f, 1.74576551e-01f, -1.15955345e-01f, -8.39866325e-02f,
  9.62115359e-03f, -9.76942629e-02f, -9.10831541e-02f, -6.90432936e-02f, 9.25174281e-02f, 1.20635509e-01f, 1.00770146e-01f, 5.95238544e-02f, -5.14438972e-02f, -1.05394147e-01f,
  4.52305116e-02f, -6.32454380e-02f, 1.09866172e-01f, -8.48858058e-02f, 7.87047297e-03f, 8.20736401e-03f, -7.52839074e-02f, -5.20891584e-02f, 3.28772403e-02f, -6.45153821e-02f,
  1.33421078e-01f, -1.28269568e-01f, 1.48540139e-01f, -1.18146181e-01f, -2.88196336e-02f, -4.48948517e-02f, -5.55872321e-02f, -8.36743116e-02f, -1.11356005e-02f, -2.73438301e-02f,
  3.41601446e-02f, 5.21248318e-02f, -7.75734782e-02f, -9.24392715e-02f, -1.22134902e-01f, -8.94267857e-02f, 1.04527205e-01f, 1.38664275e-01f, 9.96401012e-02f, 1.43631613e-02f,
  1.34724125e-01f, 1.38237312e-01f, -7.77548626e-02f, 4.55039442e-02f, 1.85790837e-01f, -4.15291414e-02f, 1.40426606e-01f, 4.62800264e-02f, -2.19822332e-01f, 1.92171007e-01f,
  1.37034714e-01f, -4.48365435e-02f, -1.04390286e-01f, -9.36769918e-02f, -1.00343242e-01f, 2.04886064e-01f, -3.48830782e-02f, 1.03803866e-01f, 4.21558842e-02f, -1.59395799e-01f,
  -1.16264895e-01f, -1.11270741e-01f, 9.16412473e-02f, -1.00185476e-01f, -4.49098572e-02f, -7.69142136e-02f, -2.91579477e-02f, 3.50978263e-02f, -3.01308390e-02f, -4.33774702e-02f,
  -1.12360388e-01f, 1.61711629e-02f, -1.16983272e-01f, -1.46432612e-02f, 1.63200721e-02f, 5.24473842e-03f, 1.21191703e-01f, -2.50400510e-03f, -1.03291705e-01f, 4.64943126e-02f,
  -8.80911499e-02f, -1.27190605e-01f, 1.58983059e-02f, -7.07276464e-02f, -5.03668897e-02f, -1.15665130e-01f, -1.17982915e-02f, -1.25626817e-01f, 2.43420489e-02f, -6.67668357e-02f,
  6.78968728e-02f, -1.35339633e-01f, 9.90663916e-02f, 1.66551933e-01f, 3.14491391e-02f, -9.78225917e-02f, 1.08308651e-01f, -1.15216281e-02f, -4.16894853e-02f, 1.06701171e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  6.39288127e-02f, -1.08929187e-01f, 1.56103864e-01f, 3.76602225e-02f, 2.22464114e-01f, 5.22878543e-02f, 3.77206653e-02f, -2.34389096e-03f, -6.90321475e-02f, 5.08981124e-02f,
  8.59815106e-02f, 1.84901699e-01f, -1.63640466e-03f, 2.79746830e-01f, 2.65133411e-01f, 1.99442003e-02f, -2.86558680e-02f, 2.19776928e-02f, 9.94671253e-04f, -2.42284569e-03f,
  -3.43213491e-02f, 2.34053731e-02f, -1.04311965e-01f, 1.70228127e-02f, 1.84676901e-01f, 1.48146272e-01f, -1.67646389e-02f, 1.95041806e-01f, -2.10811663e-02f, -1.96349099e-02f,
  -3.84338498e-02f, 1.12699881e-01f, -1.20797411e-01f, -4.09183055e-02f, 1.92482397e-01f, 1.76449940e-01f, 1.68591295e-03f, -2.49973014e-02f, -3.14978212e-02f, 2.23395973e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.84330299e-01f, 8.97836089e-02f, -2.45527282e-01f, -2.26553932e-01f, -4.17660251e-02f, -1.63709104e-01f, -1.33949980e-01f, -7.37026110e-02f, -1.36640161e-01f, -1.96459234e-01f,
  -5.96172959e-02f, -1.79504633e-01f, 2.53789365e-01f, 9.05807242e-02f, 5.13225701e-03f, -1.35334581e-01f, -4.68115732e-02f, -1.04779139e-01f, -2.26981327e-01f, -1.25817787e-02f,
  2.76281267e-01f, 1.59228936e-01f, -1.90936550e-01f, -1.25086412e-01f, -1.92795455e-01f, 8.66088718e-02f, -1.37453139e-01f, 1.35255247e-01f, -7.34449252e-02f, 8.84420872e-02f,
  1.60948113e-01f, 1.52544109e-02f, 1.41784668e-01f, -8.67415294e-02f, -2.80109700e-02f, 1.28885340e-02f, -1.49923220e-01f, -1.72154337e-01f, -8.13383702e-03f, 9.46574509e-02f,
  9.72324517e-03f, -4.75497469e-02f, 1.56570524e-01f, 3.28044593e-02f, 9.52054709e-02f, 3.45695131e-02f, 6.07376732e-02f, -1.09178975e-01f, 4.42796163e-02f, 1.21793799e-01f,
  1.19289927e-01f, -1.73852056e-01f, 9.59095284e-02f, 1.33936659e-01f, -1.12157688e-01f, -6.81823567e-02f, 1.05755113e-01f, 6.61636069e-02f, -6.39152750e-02f, 1.18366562e-01f,
  1.30296543e-01f, 1.96353152e-01f, -7.69855175e-03f, -1.53243512e-01f, 9.46423337e-02f, -6.92135394e-02f, -1.23454809e-01f, -1.52043492e-01f, -8.22295472e-02f, 2.62521841e-02f,
  -1.67506933e-01f, 7.68920556e-02f, -7.79696628e-02f, -2.73732785e-02f, -2.34202612e-02f, 2.23949309e-02f, -2.21395001e-01f, 7.55721107e-02f, 3.70263979e-02f, 1.74545720e-01f,
  3.73147666e-01f, -7.25164935e-02f, 2.10483342e-01f, -3.23644280e-01f, 1.27416462e-01f, 5.86637808e-03f, 5.32562695e-02f, 3.43700498e-02f, -1.00654803e-01f, -1.77614912e-02f,
  -1.09233379e-01f, -5.02424734e-03f, -8.06207880e-02f, 1.32106528e-01f, 3.18272635e-02f, -8.48190337e-02f, -5.85896820e-02f, 1.68820873e-01f, 5.03618717e-02f, 8.88214186e-02f,
  -4.19485159e-02f, 2.61085957e-01f, -1.34600237e-01f, -1.08813770e-01f, -1.13395303e-02f, 1.19760551e-03f, -5.29225245e-02f, -1.58409938e-01f, -1.21986911e-01f, 7.47282207e-02f,
  -4.55886871e-02f, -8.61888751e-02f, 1.38517007e-01f, 5.67709245e-02f, -6.08982965e-02f, 6.47125989e-02f, 5.29411398e-02f, -1.25432998e-01f, 7.08037540e-02f, 1.39856681e-01f,
  -1.67666804e-02f, -2.04205811e-01f, 7.97962770e-02f, -3.22510414e-02f, 4.33684215e-02f, 4.86268029e-02f, -5.48486738e-03f, 1.73194841e-01f, -9.16291475e-02f, 1.75517455e-01f,
  1.21103078e-01f, -1.07963721e-03f, 1.27690822e-01f, 1.31753618e-02f, 2.61096004e-02f, 2.85530277e-03f, -1.83425210e-02f, -4.32355106e-02f, 9.81967524e-02f, 7.99134821e-02f,
  1.05822869e-01f, -9.52467173e-02f, -2.23208904e-01f, 1.27550885e-01f, -3.51115465e-01f, -4.20703776e-02f, -2.62182415e-01f, 1.69160947e-01f, 8.97267312e-02f, 8.76080766e-02f,
  2.95910854e-02f, -1.51662707e-01f, 3.68554071e-02f, 9.59814936e-02f, -3.66374664e-02f, 8.48705024e-02f, 1.68088809e-01f, -2.46473458e-02f, 9.59109738e-02f, -1.19197495e-01f,
  -1.42510101e-01f, 3.71504128e-02f, 3.58064920e-02f, 1.83810703e-02f, 9.49372724e-02f, -3.87691051e-01f, -4.45658304e-02f, 1.04057670e-01f, -1.96806956e-02f, 1.08588994e-01f,
  -5.23334704e-02f, 4.33333218e-02f, -4.63218242e-02f, -1.47367939e-01f, 3.94949317e-02f, -1.17472690e-02f, -1.39084131e-01f, -1.43174052e-01f, 3.64946295e-03f, -3.59344445e-02f,
  8.50911289e-02f, 1.15136512e-01f, -8.88159573e-02f, -9.79482830e-02f, -2.17748675e-02f, 2.00976342e-01f, 2.02400535e-01f, 1.38440996e-01f, -1.11343555e-01f, -1.46825895e-01f,
  7.66373202e-02f, -1.28213435e-01f, -7.49043375e-02f, -9.02589783e-02f, -8.71617049e-02f, 4.04167697e-02f, -1.74010426e-01f, -1.05777360e-01f, -7.62611479e-02f, -9.34223980e-02f,
  -4.79681045e-02f, -1.44047007e-01f, 2.28517689e-02f, 1.04481038e-02f, 1.13124989e-01f, -1.43391743e-01f, -3.15961123e-01f, 1.95089608e-01f, -2.22979084e-01f, -7.83956125e-02f,
  1.60227835e-01f, -1.07487842e-01f, -9.92174298e-02f, 1.50540937e-02f, 1.14990182e-01f, -1.23998336e-01f, -1.05549961e-01f, 4.18874994e-02f, 8.19763541e-02f, -1.22354984e-01f,
  -1.08835772e-01f, 1.41966879e-01f, -7.37315565e-02f, 3.95696200e-02f, -1.09346010e-01f, -1.77289650e-01f, -8.68172497e-02f, 6.18163347e-02f, -4.32284065e-02f, 5.54684810e-02f,
  1.06686570e-01f, 9.61192772e-02f, -6.86576515e-02f, 8.33567530e-02f, -2.12690264e-01f, -3.66975460e-03f, 9.89682153e-02f, 3.17972787e-02f, 1.09149776e-01f, -1.43726375e-02f,
  -2.16668963e-01f, -1.20626949e-01f, 1.25052795e-01f, 4.34295945e-02f, -1.16922617e-01f, 1.02032848e-01f, 3.62282023e-02f, -1.28661290e-01f, 2.36396845e-02f, 5.32070696e-02f,
  1.23484313e-01f, 1.87168196e-01f, 5.00515401e-02f, -1.95194840e-01f, 1.15471423e-01f, -9.54220258e-03f, 4.19234112e-02f, 1.79236324e-03f, -2.14693621e-01f, -1.24352679e-01f,
  1.12624846e-01f, -1.66175932e-01f, 1.00304885e-02f, -2.74403822e-02f, -8.02768767e-02f, -7.44321719e-02f, 6.75624534e-02f, -1.18716739e-01f, 2.29724735e-01f, 2.02504292e-01f,
  1.86884347e-02f, -1.13274604e-01f, -8.25906619e-02f, -1.24472745e-01f, 9.02148411e-02f, -5.48327006e-02f, 1.76384911e-01f, 1.68004856e-01f, 2.78025097e-03f, 3.05630658e-02f,
  2.83039771e-02f, -3.98251675e-02f, -1.55452369e-02f, -5.93341403e-02f, 9.36223641e-02f, 1.20617457e-01f, 9.57764611e-02f, -7.19836131e-02f, 1.02994479e-02f, -1.55343801e-01f,
  -1.07368685e-01f, 9.58239883e-02f, 6.85498863e-02f, 1.17934585e-01f, 6.81227520e-02f, -4.46853377e-02f, 2.22980324e-02f, 1.30551711e-01f, -4.41341586e-02f, 4.34075715e-03f,
  -6.29146546e-02f, -2.00977787e-01f, 1.00014471e-01f, -8.78235474e-02f, 1.73046395e-01f, -1.00313596e-01f, 1.59476966e-01f, -1.95482463e-01f, -3.91402841e-03f, 8.64868686e-02f,
  5.99538442e-03f, 3.71643603e-02f, -1.03894681e-01f, -5.46038114e-02f, 1.43789142e-01f, 1.40160367e-01f, 6.75979257e-02f, -7.73643283e-03f, 3.89427096e-02f, -1.49533704e-01f,
  -1.43297359e-01f, 2.04947978e-01f, -8.24391544e-02f, 9.06507522e-02f, 6.66106939e-02f, -3.81175727e-02f, 2.84662633e-03f, 5.17260134e-02f, 5.50656347e-03f, -2.05098651e-02f,
  7.81979337e-02f, -2.01278016e-01f, 3.70746166e-01f, 1.38475727e-02f, -1.79536849e-01f, -2.32419465e-03f, -3.03108722e-01f, -1.36526614e-01f, -2.67813891e-01f, 3.18965912e-01f,
  6.87557012e-02f, -8.07338953e-02f, -1.33929595e-01f, -2.09025770e-01f, -1.58268765e-01f, 4.60239351e-02f, 6.49361536e-02f, -5.80591895e-02f, 2.22850770e-01f, -1.31930828e-01f,
  6.90499023e-02f, -1.21892564e-01f, 3.13502401e-02f, -1.97770253e-01f, 9.91634950e-02f, -2.10077800e-02f, 1.10776806e-02f, -1.95852876e-01f, 3.29517536e-02f, -3.03994715e-02f,
  -6.94973348e-03f, 1.65650193e-02f, -8.41181353e-02f, 2.20530201e-02f, -2.66755391e-02f, -6.45778794e-03f, 1.84519850e-02f, -1.41518619e-02f, -6.94207326e-02f, -1.61153506e-02f,
  1.13193229e-01f, -1.65942386e-01f, -9.72825214e-02f, 1.42763823e-01f, -3.12929116e-02f, -2.27422550e-01f, -1.70248691e-02f, 1.72475576e-01f, 1.24612063e-01f, 1.31719440e-01f,
  4.25491482e-02f, 1.50119230e-01f, -4.14230768e-03f, 2.93194521e-02f, -9.84930545e-02f, 7.72075728e-02f, 1.74971908e-01f, 2.64814049e-02f, -8.75965692e-03f, -5.66145666e-02f,
  2.05366731e-01f, -3.88657581e-03f, 3.92292328e-02f, -2.35276408e-02f, 1.17449775e-01f, -6.43693730e-02f, 1.31038696e-01f, -3.08807433e-01f, 3.21483389e-02f, 1.25980824e-01f,
  -2.61870027e-01f, 2.35736161e-01f, -3.36123675e-01f, 1.10430434e-01f, -3.03447600e-02f, -2.94454582e-02f, -2.22945884e-02f, 1.00725040e-01f, 6.34076968e-02f, 7.60293938e-03f,
  1.49719685e-01f, -1.32745668e-01f, 1.70218289e-01f, -6.62245303e-02f, 1.81728438e-01f, -1.31460708e-02f, -1.37640238e-01f, 5.65221114e-03f, 1.68147311e-01f, 6.70188740e-02f,
  1.01217449e-01f, -3.08176279e-01f, -2.56505519e-01f, 8.05176944e-02f, -8.99325404e-03f, 1.12233937e-01f, 7.55745769e-02f, 6.43329322e-02f, -1.08455673e-01f, 1.20040007e-01f,
  -4.00797762e-02f, -8.35261587e-03f, 3.64595614e-02f, -4.89934422e-02f, -1.60259455e-01f, 1.77437291e-02f, -7.60177076e-02f, 1.42333703e-02f, 4.77805957e-02f, 3.38941291e-02f,
  1.76461209e-02f, 1.61444880e-02f, -1.16540574e-01f, -3.97710130e-02f, -8.30972046e-02f, -3.12085799e-03f, -1.48122445e-01f, -1.27247363e-01f, -2.94875558e-02f, 7.61498362e-02f,
  -7.10296258e-02f, -8.28824565e-02f, -2.02262085e-02f, 1.98222995e-02f, -2.24367142e-01f, 2.57920008e-02f, -5.65625876e-02f, -1.65936261e-01f, -8.80877227e-02f, -4.40436117e-02f,
  -2.58455276e-01f, 2.59072870e-01f, 2.15641886e-01f, -7.62863159e-02f, 2.45346099e-01f, -1.06977094e-02f, 2.17950016e-01f, -2.22758546e-01f, 1.91176102e-01f, 4.12866697e-02f,
  -2.44602934e-02f, 3.64124402e-02f, -3.02290209e-02f, 9.72795561e-02f, 3.95595655e-02f, -9.23918635e-02f, -2.53085457e-02f, -1.09995548e-02f, 2.11105309e-02f, -5.12374118e-02f,
  -3.85182388e-02f, 1.27471253e-01f, 1.50490552e-01f, 8.60189721e-02f, -9.20108780e-02f, 3.20929229e-01f, -2.87091918e-02f, -3.65689956e-02f, 3.40270549e-02f, -1.64866656e-01f,
  -7.19908178e-02f, 1.38056248e-01f, 4.86250743e-02f, 2.65141856e-02f, 1.43324703e-01f, 1.03616558e-01f, 1.75712764e-01f, 6.43657893e-02f, -7.67105445e-02f, -1.54304668e-01f,
  2.86306776e-02f, 3.01558487e-02f, -4.16618064e-02f, 1.70609355e-02f, -4.60600704e-02f, -1.32957250e-02f, -8.63608569e-02f, -2.28106111e-01f, 5.31398393e-02f, 2.70468798e-02f,
  -1.35215446e-01f, 1.50744915e-01f, -8.70994702e-02f, -3.85540985e-02f, -8.10764357e-02f, -1.13589972e-01f, -1.94121033e-01f, 1.48630049e-02f, -2.45488137e-02f, 2.43571252e-02f,
  3.09258588e-02f, -1.14249736e-01f, -1.50650114e-01f, 1.15914360e-01f, 2.98597217e-02f, 1.51924059e-01f, 2.82537162e-01f, -1.96885854e-01f, 2.20726818e-01f, -9.62129012e-02f,
  -1.37795769e-02f, -1.46190859e-02f, 1.30207896e-01f, 1.12174004e-02f, -3.06138724e-01f, 1.28569722e-01f, 6.91747293e-02f, 9.15189385e-02f, 9.55354422e-02f, 9.88705363e-03f,
  1.55281976e-01f, -1.38358757e-01f, -1.94753692e-01f, 1.23729199e-01f, 9.40844789e-02f, -7.36174583e-02f, 1.22879572e-01f, -3.90598066e-02f, 5.42187542e-02f, 7.96007738e-02f,
  4.03470919e-02f, -5.71237169e-02f, -1.36098012e-01f, -1.18884668e-01f, 1.72190014e-02f, 1.66481078e-01f, -6.03428036e-02f, -1.45702204e-02f, 1.06089339e-01f, -1.06148399e-01f,
  2.45476607e-02f, 1.23356543e-01f, 7.07449764e-02f, -2.21159264e-01f, 1.18403174e-01f, 1.10042356e-01f, -3.11629176e-02f, 1.51476592e-01f, -4.62725945e-02f, 2.06783204e-03f,
  -1.99627399e-01f, -1.49379775e-01f, 1.69473469e-01f, 8.52311775e-02f, -1.90569181e-02f, -1.76967643e-02f, -3.54072172e-03f, -6.10209070e-02f, 1.34827048e-02f, 6.12440258e-02f,
  -1.14504285e-01f, 1.39855947e-02f, 3.94644178e-02f, 3.39803658e-02f, -3.44114825e-02f, -1.02256440e-01f, -1.02370689e-02f, -8.71222988e-02f, -1.13625959e-01f, 1.21416211e-01f,
  6.17202856e-02f, -9.60815251e-02f, 1.59391537e-01f, -2.84377183e-03f, 3.78511012e-01f, -1.97668388e-01f, 8.40848163e-02f, -3.72006334e-02f, -1.46896124e-01f, 1.56639263e-01f,
  -7.87167698e-02f, -1.19851202e-01f, 5.64173982e-02f, -7.32394531e-02f, -2.40521729e-01f, 6.32073656e-02f, -6.86451346e-02f, -1.18665406e-02f, -5.06028309e-02f, 1.37752146e-01f,
  1.61544949e-01f, 7.25034624e-02f, -5.90907112e-02f, 3.22717130e-01f, 1.00492477e-01f, 6.42963871e-02f, -1.44977316e-01f, 3.76645103e-03f, -1.39287831e-02f, -2.69556064e-02f,
  9.74559784e-02f, 1.01910584e-01f, -1.25202443e-02f, 3.38462852e-02f, 7.98663404e-03f, 8.76020119e-02f, -1.56475037e-01f, -1.34159952e-01f, -2.51787417e-02f, -1.79571837e-01f,
  -5.47374822e-02f, 2.54616678e-01f, -9.72895399e-02f, -1.27249379e-02f, -2.01431200e-01f, 3.05510461e-02f, -5.29165529e-02f, -4.73502055e-02f, 9.03081223e-02f, 2.86484808e-02f,
  1.11458518e-01f, -1.23773977e-01f, -5.82130626e-03f, 1.25959247e-01f, 9.56152752e-02f, 3.84342670e-02f, 1.87297985e-02f, 3.44236591e-03f, 4.00912128e-02f, -6.85193092e-02f,
  1.03485025e-01f, -1.08521925e-02f, 1.28180802e-01f, -1.68408126e-01f, -1.85844317e-01f, 9.06596184e-02f, -2.64246643e-01f, 2.72639960e-01f, -3.88506562e-01f, 2.45402250e-02f,
  -6.10578209e-02f, -6.97091594e-02f, 9.65103135e-03f, -9.32090133e-02f, -6.26440253e-03f, 6.97229505e-02f, 1.70447633e-01f, -9.86030251e-02f, 1.47611156e-01f, 9.93801281e-03f,
  5.82471825e-02f, -9.77443233e-02f, -1.51367486e-01f, -1.07920215e-01f, -5.13894856e-03f, 6.82294369e-03f, -4.00930606e-02f, -2.20277682e-01f, -3.46952379e-02f, -5.62708639e-02f,
  6.55093929e-03f, -4.38773222e-02f, -7.58046210e-02f, -2.06334934e-01f, -8.26690197e-02f, -4.03601117e-03f, -7.74385408e-02f, -1.04326762e-01f, -1.26834765e-01f, -1.34534121e-01f,
  -4.36656363e-02f, 2.17865586e-01f, -2.13127345e-01f, -6.65966645e-02f, -1.26868486e-01f, -2.54192892e-02f, 1.37057677e-01f, -3.99062522e-02f, 1.88159421e-01f, 3.21112983e-02f,
  6.20815642e-02f, -8.20419639e-02f, -1.26830367e-02f, -2.08638415e-01f, -1.48085922e-01f, -1.09609410e-01f, -3.30319889e-02f, -5.39327972e-03f, -5.43163493e-02f, 2.19340157e-02f,
  -1.92474484e-01f, -3.19603831e-02f, 3.95247340e-02f, -6.04149420e-03f, -2.51453757e-01f, -2.90384050e-02f, -5.72158173e-02f, 3.12329471e-01f, -8.03854316e-02f, -2.61252433e-01f,
  1.79417785e-02f, -2.02463791e-01f, 2.54913151e-01f, -7.24581107e-02f, -4.13392708e-02f, 1.67050347e-01f, -6.23594150e-02f, 1.28045216e-01f, 8.46680552e-02f, -2.72547267e-02f,
  -1.95036501e-01f, 5.12763150e-02f, -1.06506012e-01f, 5.15209734e-02f, 8.38052630e-02f, -5.95237501e-02f, 1.12707308e-02f, 2.36825086e-02f, 1.39493242e-01f, 1.44422323e-01f,
  8.99309069e-02f, 2.93519050e-01f, 4.22507375e-02f, 5.79828508e-02f, -6.63462877e-02f, 7.34601915e-02f, 7.66130760e-02f, 1.43710449e-01f, -6.01690523e-02f, 6.72175288e-02f,
  -5.95526546e-02f, -2.79623754e-02f, 9.82172415e-02f, -8.05422813e-02f, 4.57390435e-02f, -2.40592230e-02f, 3.01748831e-02f, -5.15267700e-02f, 2.14891881e-02f, 1.27690136e-01f,
  6.83508217e-02f, -7.82810748e-02f, 6.27704188e-02f, -1.06284216e-01f, -4.20490168e-02f, -1.56462472e-02f, 1.40449414e-02f, 1.18892200e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.45908520e-01f, -1.07952259e-01f, 3.50508885e-03f, 1.37075083e-02f, -5.23471721e-02f, 9.05721560e-02f, 1.12312555e-01f, -1.57492943e-02f, 1.19228922e-01f, 1.39006257e-01f,
  -2.54954807e-02f, 5.90127967e-02f, -1.82500243e-01f, -1.46106228e-01f, 1.25570774e-01f, 8.07826668e-02f, 6.67476282e-02f, 9.56258401e-02f, 1.06149025e-01f, -1.28907233e-01f,
  -2.32380897e-01f, 4.48685661e-02f, 9.08875167e-02f, 1.37358963e-01f, -5.04828468e-02f, -8.46450180e-02f, 5.63539006e-02f, -3.97295281e-02f, 7.70342723e-02f, -6.65172115e-02f,
  1.92490276e-02f, -6.28092661e-02f, 1.19276736e-02f, -1.00000221e-02f, 1.95394352e-01f, 5.19559979e-02f, 4.26591607e-03f, 1.28931254e-01f, 3.43658477e-02f, 2.57868599e-02f,
  -1.25388920e-01f, -6.95034415e-02f, -8.37987065e-02f, -9.78289172e-02f, -5.18636480e-02f, 1.76821828e-01f, -1.46205854e-02f, -3.24391038e-03f, 1.46088181e-02f, 1.03741683e-01f,
  2.36606970e-02f, 1.31493345e-01f, 2.56921705e-02f, -6.77958578e-02f, -7.28582516e-02f, 1.30471036e-01f, 1.18375897e-01f, -5.33074327e-02f, 4.06779349e-03f, 3.00405249e-02f,
  7.91076645e-02f, 5.41587286e-02f, -3.28947790e-02f, -6.36947230e-02f, 1.85204759e-01f, -8.14806744e-02f, 2.09187403e-01f, 3.58294249e-02f, 3.04174498e-02f, 2.53596514e-01f,
  8.92834812e-02f, 8.27892199e-02f, 2.33142138e-01f, 2.33905941e-01f, 2.13761136e-01f, 2.59485215e-01f, -1.15622893e-01f, -1.58388391e-01f, -9.22360346e-02f, 6.44215271e-02f,
  1.29177906e-02f, 1.99190482e-01f, -3.96575034e-01f, 1.08667612e-01f, -1.58211350e-01f, -1.66595429e-01f, 6.04073592e-02f, 4.32964675e-02f, -1.17725739e-03f, 1.50660956e-02f,
  9.78122652e-02f, -5.16251847e-02f, 2.76974559e-01f, 7.33900294e-02f, 2.12408513e-01f, -7.24000782e-02f, -2.74250074e-03f, -1.27817631e-01f, 1.56171530e-01f, 1.39605626e-01f,
  -1.64359629e-01f, -1.66730329e-01f, -1.56498626e-01f, 1.44847825e-01f, -2.05137543e-02f, -9.70028862e-02f, 2.04463407e-01f, -1.76050186e-01f, -8.83112773e-02f, 1.19300801e-02f,
  -7.98449367e-02f, -9.77286175e-02f, 5.76223806e-02f, 6.97806180e-02f, -2.02909842e-01f, 1.08331352e-01f, -1.58421308e-01f, -7.70924687e-02f, -1.52382538e-01f, -2.84354202e-02f,
  1.24125026e-01f, 8.33219439e-02f, -8.90184566e-02f, -8.25160816e-02f, -1.84063874e-02f, 7.56164491e-02f, 5.51195331e-02f, 3.37198824e-02f, 2.09269393e-03f, 1.46175131e-01f,
  -6.74035549e-02f, 4.50503975e-02f, 1.31896123e-01f, 1.11853220e-01f, -1.19013056e-01f, -3.44481342e-03f, 1.40821517e-01f, -9.30305496e-02f, -6.51353523e-02f, -1.38489589e-01f,
  2.29549587e-01f, -1.39026999e-01f, -2.46365711e-01f, 9.33759883e-02f, -1.13867775e-01f, 2.78815103e-04f, 8.83904472e-02f, -1.70610324e-01f, 9.59257111e-02f, 1.09250009e-01f,
  8.20277780e-02f, -2.10812137e-01f, 1.43917594e-02f, 4.46907505e-02f, -7.21057728e-02f, -1.30132720e-01f, -9.98569131e-02f, 2.41364494e-01f, 1.23486862e-01f, -9.21293441e-03f,
  -1.92397293e-02f, -2.05151528e-01f, -1.11163549e-01f, 1.42882615e-01f, 6.96070492e-02f, 2.23597780e-01f, 2.50991881e-01f, -3.26621719e-02f, 3.55242826e-02f, 1.59816042e-01f,
  1.05232455e-01f, -1.46244287e-01f, 2.30573803e-01f, -2.12514494e-02f, -1.10958694e-02f, 5.61596639e-02f, -3.67251225e-03f, 8.84745568e-02f, 1.93764925e-01f, -8.43724012e-02f,
  -1.64862961e-01f, -8.58056471e-02f, -3.82541604e-02f, 4.32341360e-03f, 9.37374681e-02f, 1.22092150e-01f, 2.59541899e-01f, 2.31298670e-01f, 7.81006962e-02f, 6.80623874e-02f,
  1.83562517e-01f, -1.29452676e-01f, 2.11669952e-01f, 5.74210621e-02f, 5.90038672e-02f, 3.84357162e-02f, 9.59523916e-02f, 1.30897835e-01f, -2.06227705e-01f, 1.78171739e-01f,
  1.48928374e-01f, -8.03697258e-02f, 5.14193140e-02f, 1.44761220e-01f, -8.72833952e-02f, 1.71831712e-01f, 2.09225044e-01f, -1.44084796e-01f, 2.08549306e-01f, -2.86750905e-02f,
  3.73424627e-02f, -2.71144360e-01f, 4.46567200e-02f, 2.76296437e-02f, -1.64169997e-01f, 1.55647233e-01f, -8.26748610e-02f, -1.08845435e-01f, 7.12909549e-02f, 5.30067198e-02f,
  7.21035376e-02f, 1.57963917e-01f, -9.50205028e-02f, 4.94243801e-02f, -2.95695886e-02f, -3.77493091e-02f, 2.28532135e-01f, 2.56619722e-01f, 1.08151957e-01f, 3.23851377e-01f,
  -1.08191788e-01f, 1.44975811e-01f, -1.40573025e-01f, 9.28091109e-02f, 5.72314933e-02f, 1.83326885e-01f, -8.44126195e-02f, 7.60761602e-03f, 5.95099442e-02f, -7.72024766e-02f,
  2.38075823e-01f, -6.66517392e-02f, -1.37132518e-02f, 6.47994950e-02f, 3.79699096e-03f, -2.83751320e-02f, -7.63181830e-03f, 2.78511435e-01f, 1.51922950e-03f, -7.65497312e-02f,
  -2.98541542e-02f, 8.85106996e-02f, -8.40350389e-02f, 2.02169288e-02f, -5.46383963e-04f, 6.77848682e-02f, 1.58225983e-01f, 8.25358778e-02f, 4.13727500e-02f, 1.06478065e-01f,
  -3.80083732e-02f, 4.94947396e-02f, 1.37450203e-01f, 1.68561324e-01f, 7.39657506e-02f, 4.70858514e-02f, -1.48085579e-02f, 5.94632030e-02f, -2.31818557e-01f, -2.73121893e-01f,
  2.47917604e-02f, 1.82539284e-01f, -6.59720302e-02f, 2.67704368e-01f, -1.43092006e-01f, -4.33168337e-02f, -1.07030563e-01f, -9.49917957e-02f, -4.86239195e-02f, 1.64991289e-01f,
  1.25463068e-01f, -7.85912126e-02f, 1.02074869e-01f, -6.73988163e-02f, 1.68210998e-01f, -1.93993608e-03f, -8.17369372e-02f, 6.46162406e-02f, 6.10474236e-02f, -3.33741233e-02f,
  1.88092262e-01f, 8.27172995e-02f, -7.27341697e-02f, 1.06538266e-01f, -1.19368047e-01f, 1.48046613e-01f, -6.96054175e-02f, -1.43094659e-01f, 1.35629818e-01f, 3.55027542e-02f,
  1.77123162e-04f, 1.65009707e-01f, 9.46216658e-02f, -9.41040590e-02f, 1.42371058e-01f, -8.28383714e-02f, -1.72515944e-01f, 1.65660396e-01f, -8.41030106e-03f, -3.50611955e-02f,
  -1.31414190e-01f, -1.83521882e-02f, -8.14306512e-02f, -5.52617274e-02f, 5.73146949e-03f, -9.13401395e-02f, -5.58360778e-02f, 3.19404565e-02f, 3.81331742e-02f, -6.50138184e-02f,
  1.57171309e-01f, -6.79554716e-02f, 1.28818927e-02f, 9.77381468e-02f, 1.15228646e-01f, 3.87675725e-02f, 1.49916559e-01f, 2.08941907e-01f, -3.13888341e-02f, 2.17569798e-01f,
  1.07302815e-01f, -2.79150903e-03f, 3.45594697e-02f, 1.94910076e-02f, 2.30725601e-01f, -1.17428988e-01f, -2.26441264e-01f, -4.04467694e-02f, 4.36367504e-02f, 7.75041059e-02f,
  -2.40760356e-01f, -1.69937208e-01f, -2.87276447e-01f, 2.41688132e-01f, 5.00260293e-02f, -4.04173248e-02f, 1.64182872e-01f, -8.93403813e-02f, -5.17496169e-02f, -9.27418470e-02f,
  -1.27941832e-01f, 1.02835884e-02f, -1.70606524e-02f, -1.35814762e-02f, 2.61414200e-01f, -9.36911162e-03f, 1.68134660e-01f, 4.72411923e-02f, -7.28888139e-02f, -8.25713389e-03f,
  9.93016884e-02f, 1.65258925e-02f, 6.69996887e-02f, 1.35052100e-01f, 2.82502752e-02f, 3.34882945e-01f, 3.47500145e-02f, -1.37693323e-02f, 1.53453976e-01f, -3.26129347e-02f,
  -7.01564178e-02f, 1.34623662e-01f, -7.38486946e-02f, -1.75450724e-02f, 1.25280440e-01f, 1.47918046e-01f, -3.28000747e-02f, 4.71145585e-02f, -8.02276134e-02f, -3.60886268e-02f,
  -1.02763124e-01f, 3.76139358e-02f, -1.01207957e-01f, 7.67055824e-02f, 2.38258898e-01f, 2.20583737e-01f, 9.44241434e-02f, 1.54160842e-01f, 1.81568459e-01f, 1.06518738e-01f,
  7.45769814e-02f, 2.54260898e-01f, 2.21084982e-01f, 1.41676098e-01f, 8.33542421e-02f, 2.55995303e-01f, -2.64204353e-01f, -1.22212373e-01f, 1.55006096e-01f, 1.02700695e-01f,
  3.88538361e-01f, -1.12341695e-01f, 2.46498883e-01f, -2.13975564e-01f, -4.41093221e-02f, 2.72567242e-01f, 1.78476676e-01f, -1.73443317e-01f, 1.91464052e-01f, 4.62973826e-02f,
  -1.00223854e-01f, 1.10922143e-01f, 7.34614357e-02f, 7.98477679e-02f, -9.59457532e-02f, -1.13536991e-01f, -1.81828067e-02f, 3.18357468e-01f, -1.35307774e-01f, -1.50171563e-01f,
  -4.62658592e-02f, 3.18467468e-01f, 1.79259982e-02f, -1.35867037e-02f, 7.11500123e-02f, -1.38698652e-01f, 5.29859439e-02f, -9.25718248e-02f, -5.47034964e-02f, -1.97069701e-02f,
  -2.87156925e-02f, -7.41003975e-02f, -8.81916210e-02f, 1.39926712e-03f, 7.58162439e-02f, 1.47274509e-01f, -2.12399326e-02f, -1.28097206e-01f, -6.64425567e-02f, -4.05201279e-02f,
  3.48885916e-02f, 1.83888152e-02f, 1.16481401e-01f, -1.43878475e-01f, -7.51446933e-02f, -1.33119896e-01f, -7.00479969e-02f, 1.77222177e-01f, 5.47700375e-02f, -1.22861370e-01f,
  7.09025338e-02f, -4.20875438e-02f, -5.56176379e-02f, 7.21243322e-02f, -1.21602468e-01f, 5.45758121e-02f, 1.64241239e-01f, 1.39840052e-01f, 1.10183833e-02f, 1.78487785e-02f,
  3.20892185e-02f, -6.14272282e-02f, 1.99311808e-01f, -1.91240907e-01f, -2.92779952e-01f, -1.63206030e-02f, -2.04113871e-01f, 2.92670261e-02f, -2.22624838e-01f, -2.68300414e-01f,
  -1.90553024e-01f, 3.10347557e-01f, -8.32521543e-02f, -6.28223419e-02f, 2.44279549e-01f, 9.00839791e-02f, 1.60642371e-01f, -1.10968284e-01f, -1.27100006e-01f, -5.31098396e-02f,
  -5.94943352e-02f, -7.44232237e-02f, 3.93780440e-01f, -3.41928340e-02f, 1.90667305e-02f, 9.10896882e-02f, 7.73385465e-02f, 9.96825472e-02f, 2.00258493e-02f, -9.12253559e-02f,
  5.95082864e-02f, 5.84235005e-02f, 3.46230753e-02f, 3.28592271e-01f, 1.49049433e-02f, -3.97410393e-02f, 2.27046445e-01f, -3.19769159e-02f, 9.03394595e-02f, 1.33749351e-01f,
  5.14711179e-02f, 5.61314449e-02f, -1.14868768e-01f, 1.12908982e-01f, -3.86202261e-02f, 1.36125520e-01f, -1.45702899e-01f, 2.19463855e-02f, 1.37588391e-02f, 2.62430571e-02f,
  -7.36039057e-02f, 4.57726978e-02f, 3.77317332e-02f, 3.26369889e-02f, -3.50126624e-02f, 1.12178102e-01f, -1.09878272e-01f, 1.49423862e-02f, -8.67613256e-02f, -4.95376624e-02f,
  -8.52777213e-02f, -6.02667071e-02f, -9.87492427e-02f, 2.41962634e-02f, -9.29791853e-02f, 7.36754201e-03f, 1.02826260e-01f, 7.10466430e-02f, -2.17140019e-02f, -3.04358732e-02f,
  1.26902223e-01f, -1.61024258e-01f, -5.80881489e-03f, 2.18901765e-02f, -6.47849366e-02f, -1.38249982e-03f, 1.28060356e-01f, -7.20682973e-03f, -9.65248421e-02f, -1.65127087e-02f,
  -3.73912901e-02f, 1.54664814e-01f, 3.50947678e-02f, 4.89189513e-02f, 1.15515009e-01f, -3.56872333e-03f, 1.29318178e-01f, 1.44895166e-01f, -3.75768840e-02f, 6.68061003e-02f,
  1.21246884e-02f, -3.76823954e-02f, 9.60423127e-02f, -1.10476604e-02f, 4.11758982e-02f, -7.83800408e-02f, 5.37744537e-02f, 4.98047099e-02f, 4.07030135e-02f, 7.48322606e-02f,
  1.40366480e-01f, -4.00176831e-02f, 1.25567898e-01f, 1.45209536e-01f, -4.99444082e-03f, -1.23955771e-01f, 8.46516341e-02f, 1.55706614e-01f, 1.09474614e-01f, -1.40254736e-01f,
  -3.31343599e-02f, -6.74326941e-02f, -1.04874723e-01f, -1.18365638e-01f, -1.05950192e-01f, 1.47791743e-01f, 7.46958540e-04f, 4.87512760e-02f, 1.89112350e-01f, -3.39381583e-02f,
  -6.08177856e-02f, -1.72697641e-02f, 5.60787246e-02f, -1.30640045e-02f, 9.06817541e-02f, 4.49763872e-02f, 1.93793476e-01f, 4.89316545e-02f, -3.75654921e-02f, -1.98226601e-01f,
  -1.38423771e-01f, 5.05438410e-02f, -1.95353165e-01f, -1.88487675e-02f, -1.14654183e-01f, 8.56046826e-02f, 4.83818054e-02f, -6.11731149e-02f, 8.40779245e-02f, -1.53470844e-01f,
  -6.63632601e-02f, 8.21080655e-02f, -7.66258538e-02f, 8.42958987e-02f, 1.22284278e-01f, 1.12845473e-01f, 1.48170769e-01f, -8.06785673e-02f, 2.83624306e-02f, -1.02019206e-01f,
  -1.02123208e-01f, 1.34735897e-01f, 5.73489536e-03f, -1.71892643e-01f, -5.05241789e-02f, -8.87843743e-02f, 5.31887263e-02f, 1.33257836e-01f, 2.38503497e-02f, 5.66978045e-02f,
  4.83430550e-02f, -4.58850339e-02f, 5.02609760e-02f, 1.32378731e-02f, -9.64729264e-02f, -5.24068810e-02f, -5.09609990e-02f, 5.05899787e-02f, -4.00971547e-02f, 1.29909098e-01f,
  -4.95430604e-02f, 4.09772545e-02f, 6.41544117e-03f, 1.17835552e-01f, 1.43900931e-01f, 1.17146231e-01f, -1.35230273e-01f, 1.01107292e-01f, 8.54838192e-02f, -1.46356925e-01f,
  -1.81327835e-02f, 6.12005107e-02f, 5.62353283e-02f, -2.17135008e-02f, 7.96455294e-02f, -1.21841237e-01f, 9.22177956e-02f, -1.08585410e-01f, 4.47932333e-02f, 4.62190993e-02f,
  5.48388660e-02f, -4.67016436e-02f, 7.10883364e-02f, 4.26031873e-02f, 3.35407294e-02f, 1.12849874e-02f, -1.19327135e-01f, 4.51921113e-02f, 1.10005587e-01f, -4.25061248e-02f,
  -1.44843515e-02f, 7.12957531e-02f, -1.47270530e-01f, -1.33792996e-01f, -6.95022717e-02f, -6.05953671e-03f, -3.89801264e-02f, 4.14434001e-02f, -1.32681265e-01f, 1.17103569e-01f,
  -1.00091085e-01f, 7.90857524e-02f, -9.87309515e-02f, -6.86188489e-02f, 5.74691594e-02f, 1.17895402e-01f, 1.49621516e-01f, -6.99672699e-02f, 2.05053017e-01f, 3.03357393e-02f,
  -3.09282374e-02f, -9.28313658e-02f, -8.15245062e-02f, -3.02524008e-02f, 9.09854174e-02f, -7.84898475e-02f, -1.21610602e-02f, 9.67551619e-02f, 1.22684032e-01f, -1.21562146e-01f,
  6.81303302e-03f, 6.49322495e-02f, -8.82986411e-02f, 4.33653407e-02f, 2.02568527e-02f, 1.76427327e-02f, 5.61013445e-02f, 5.84124625e-02f, 9.50251967e-02f, 6.94525912e-02f,
  2.96886768e-02f, 7.37716258e-02f, 9.81448665e-02f, 3.04466244e-02f, 1.57772452e-02f, 1.23383760e-01f, 1.44522488e-01f, 6.78422302e-02f, -2.96133608e-02f, 7.02093467e-02f,
  -9.72997248e-02f, -8.04841220e-02f, 4.16712649e-02f, 1.16930790e-01f, 9.88775417e-02f, -8.85232538e-03f, -1.38594866e-01f, 1.13780715e-01f, -1.46725461e-01f, 4.84008826e-02f,
  1.13563530e-01f, -7.16212690e-02f, 1.81724578e-01f, 5.40358797e-02f, 7.61043001e-03f, 2.17872128e-01f, 1.99321762e-01f, -1.57858491e-01f, 4.51574028e-02f, -1.46444306e-01f,
  -5.28382808e-02f, 1.28988735e-02f, -6.96974024e-02f, 1.88729852e-01f, -7.03787878e-02f, 1.81094836e-03f, 1.03439726e-01f, 2.02138610e-02f, -1.39515400e-01f, 1.47007117e-02f,
  -9.78498682e-02f, 2.72787094e-01f, 2.67826557e-01f, -2.18580011e-02f, -9.37795918e-03f, -4.28203009e-02f, -2.09996803e-03f, -4.73902151e-02f, 2.09669210e-03f, -1.77741989e-01f,
  7.63149709e-02f, 1.60540696e-02f, -1.35811225e-01f, 1.35369673e-01f, -8.54737312e-02f, -6.20314432e-03f, -6.34424239e-02f, -1.29735216e-01f, 5.22564761e-02f, 2.07712296e-02f,
  -1.25649804e-02f, -2.18860749e-02f, 1.82356834e-01f, -1.42677370e-02f, -1.78010052e-03f, -9.20198392e-03f, 8.46288055e-02f, 5.44041395e-02f, 3.77368361e-01f, 6.27765656e-02f,
  -3.55472974e-02f, 2.10695062e-02f, 2.15291113e-01f, 1.33652270e-01f, 2.85192460e-01f, 3.29749972e-01f, 1.88043028e-01f, 1.56043870e-02f, 1.64898023e-01f, 2.11549569e-02f,
  -3.13541926e-02f, -2.68962644e-02f, 3.68099242e-01f, -4.71600052e-03f, 3.30624878e-01f, -7.60305151e-02f, 1.65642723e-01f, -1.54822767e-01f, 6.71991631e-02f, 1.36721238e-01f,
  -1.77847043e-01f, 1.09580353e-01f, -8.72422569e-03f, -1.47886050e-03f, 7.88158849e-02f, -3.33421603e-02f, 7.66658187e-02f, 7.57112578e-02f, -9.08260271e-02f, -3.20533887e-02f,
  -5.04837744e-02f, 3.28652859e-01f, -1.59571208e-02f, 2.35748161e-02f, 3.96752693e-02f, 8.66810828e-02f, -1.05869509e-01f, 1.91696566e-02f, -1.07482500e-01f, -1.33572981e-01f,
  1.13058627e-01f, 1.41008437e-01f, -1.87749371e-01f, 7.70316198e-02f, -1.13135181e-01f, -1.17570814e-02f, 1.45894885e-01f, 1.65609971e-01f, 2.29887906e-02f, -2.12534703e-02f,
  9.47942957e-02f, 7.84370527e-02f, -8.90177265e-02f, 2.73464859e-01f, -3.11263232e-03f, -1.63739491e-02f, 1.36648212e-02f, -2.08397120e-01f, -3.76843736e-02f, -1.06773740e-02f,
  -4.56800126e-02f, 5.07135876e-02f, -9.33742300e-02f, 2.30460279e-02f, 7.46376887e-02f, 2.02243254e-02f, 1.05913378e-01f, 2.81565133e-02f, 6.10005893e-02f, -3.20502333e-02f,
  -3.42990831e-02f, -8.17183256e-02f, 4.24688729e-03f, 1.94393136e-02f, 8.69898200e-02f, 1.01220697e-01f, -5.83939217e-02f, 4.70116548e-02f, -1.23286776e-01f, 3.75850685e-02f,
  -9.48696770e-03f, -9.72816627e-03f, 1.36944965e-01f, 1.84183102e-02f, 5.13923801e-02f, -8.29635113e-02f, -1.04753561e-01f, 7.77324513e-02f, -3.69906127e-02f, -9.37584788e-02f,
  9.63362399e-03f, 5.45954816e-02f, 3.73510644e-02f, -1.11282602e-01f, -4.10445556e-02f, -1.07191004e-01f, -3.07692159e-02f, 1.28824100e-01f, 1.81250796e-02f, 2.46052537e-02f,
  -1.11007646e-01f, 2.77001597e-02f, -6.43787980e-02f, -9.51771289e-02f, 6.80326521e-02f, 9.49517339e-02f, 2.75780056e-02f, -3.63982730e-02f, 4.45563532e-02f, -9.59018245e-02f,
  2.31702942e-02f, -7.47007802e-02f, -9.76430159e-03f, -2.81803943e-02f, 2.49872636e-02f, 2.37746537e-02f, 5.29449061e-02f, 9.52308029e-02f, 1.29383758e-01f, 6.12341203e-02f,
  -8.56270492e-02f, -9.02072862e-02f, 6.29478544e-02f, -6.45025820e-02f, 1.01625547e-01f, 2.02989355e-02f, -1.32691329e-02f, 1.47846520e-01f, -2.09614374e-02f, 3.24397571e-02f,
  7.52353817e-02f, 1.05511826e-02f, -4.89876568e-02f, 1.48046225e-01f, -3.27127278e-02f, -1.46777267e-02f, -1.97496414e-02f, 9.74472314e-02f, 2.01994568e-01f, 2.98194494e-02f,
  2.14188963e-01f, -2.45403901e-01f, -7.09975138e-02f, 1.03911133e-02f, -2.05200568e-01f, 1.95339680e-01f, 5.98822422e-02f, -1.32245600e-01f, -2.01011240e-01f, 1.07612722e-01f,
  -9.18016061e-02f, -2.65051480e-02f, 3.66464853e-02f, 8.35857391e-02f, 2.32800111e-01f, 3.63929756e-02f, -8.74552801e-02f, -8.26489329e-02f, 1.11468755e-01f, -4.56820130e-02f,
  7.18164593e-02f, 1.05848059e-01f, 6.21831305e-02f, 1.20037504e-01f, 7.68895745e-02f, 1.59917042e-01f, 4.26847562e-02f, -1.39716461e-01f, 5.33913076e-02f, 4.64678369e-02f,
  -8.38727728e-02f, -3.84850577e-02f, -2.98425201e-02f, -1.25300243e-01f, 2.16250762e-01f, 1.92510057e-02f, -3.94557640e-02f, -1.61194578e-01f, -3.25444117e-02f, 2.40791351e-01f,
  5.88854402e-02f, -8.63827392e-02f, 1.66562870e-02f, 4.83265333e-02f, 2.89198644e-02f, 5.96740028e-05f, -7.72179440e-02f, 2.26876348e-01f, -8.06036666e-02f, 1.74010228e-02f,
  -3.93177196e-02f, -1.72302481e-02f, 1.55035164e-02f, 1.00804701e-01f, 2.86977831e-02f, 2.95522530e-02f, -1.53076127e-01f, -8.11566710e-02f, 6.06766753e-02f, 6.61794692e-02f,
  1.34843752e-01f, -4.67704311e-02f, -1.01861149e-01f, -1.44883506e-02f, 1.52045250e-01f, -1.01290599e-01f, -6.73592091e-02f, 1.12573825e-01f, -7.48449117e-02f, 1.19653940e-01f,
  2.40234975e-02f, -1.75725386e-01f, 4.09686305e-02f, 1.22441880e-01f, 7.38593712e-02f, 3.88389900e-02f, 1.34912908e-01f, 3.09895705e-02f, 1.59327596e-01f, -6.37307912e-02f,
  6.02878369e-02f, -5.93258590e-02f, 9.13397148e-02f, -1.27390385e-01f, 5.02684601e-02f, 6.92703202e-02f, -2.55678203e-02f, -2.66891122e-02f, -1.50447771e-01f, 5.28229773e-02f,
  1.84640307e-02f, -2.52287518e-02f, 1.01447836e-01f, 1.23112291e-01f, 9.31515619e-02f, 5.35651809e-03f, -8.47341344e-02f, -8.36421251e-02f, 2.26281688e-01f, -9.42602605e-02f,
  -7.39282146e-02f, -8.68331864e-02f, 6.95170462e-02f, 9.84929278e-02f, 4.19329964e-02f, 7.28895068e-02f, 1.54439937e-02f, 4.52035218e-02f, -1.84532478e-01f, -5.38786314e-02f,
  1.12249106e-01f, -2.09185891e-02f, 9.57948938e-02f, -6.95766062e-02f, 1.77724570e-01f, 6.26089275e-02f, -5.00637107e-02f, 4.03197445e-02f, 4.88670431e-02f, 5.50115295e-02f,
  1.50564630e-02f, 1.33090153e-01f, -8.41647834e-02f, -7.86542594e-02f, 9.33974534e-02f, -2.35343841e-03f, -6.64361864e-02f, 4.49832482e-03f, 5.99008054e-02f, 1.22415558e-01f,
  1.27043948e-01f, -4.28827517e-02f, -6.96242154e-02f, -1.28455564e-01f, 9.66336280e-02f, 1.44032285e-01f, 5.33115678e-02f, -1.43955991e-01f, -1.03417806e-01f, 6.91018626e-02f,
  -5.92668913e-02f, -1.37224257e-01f, -1.13282837e-01f, -4.33332659e-02f, 7.14167356e-02f, 3.78526263e-02f, -7.05869049e-02f, 1.40912920e-01f, 2.78099347e-02f, -1.89197566e-02f,
  3.76134813e-02f, -2.07481347e-02f, -5.55075034e-02f, 1.02809653e-01f, 1.24613335e-02f, 1.26435667e-01f, 7.19010308e-02f, 1.09545894e-01f, -4.25185673e-02f, -9.58916396e-02f,
  -1.22625723e-01f, 6.72867224e-02f, 9.19163451e-02f, 1.08685844e-01f, 1.58280507e-02f, -7.20398426e-02f, -2.08353736e-02f, 3.33142094e-02f, 1.10165820e-01f, -6.84543848e-02f,
  -1.04645289e-01f, 6.45226091e-02f, -2.45225970e-02f, -6.26084954e-02f, 2.38962080e-02f, -9.45882201e-02f, 1.26743734e-01f, -9.37842205e-02f, -4.84498963e-02f, -1.12002872e-01f,
  8.55314266e-03f, -5.36033977e-03f, -1.40598333e-02f, -1.49290394e-02f, -1.29725989e-02f, -3.00621893e-03f, 1.14666484e-02f, 1.34519428e-01f, -7.45023936e-02f, 1.51371464e-01f,
  -1.31102800e-01f, -8.26029629e-02f, 3.58048044e-02f, 1.27216712e-01f, -7.14877024e-02f, 4.14090864e-02f, -1.54596977e-02f, -1.54374838e-01f, -1.55953132e-02f, -4.67588678e-02f,
  1.89598963e-01f, -1.22393690e-01f, 1.08581431e-01f, 8.44831094e-02f, 2.75316592e-02f, -1.10242128e-01f, -2.18198206e-02f, 1.49824336e-01f, -3.19306329e-02f, -7.64778629e-02f,
  8.47983360e-02f, -2.36611199e-02f, 8.43164772e-02f, 2.00451270e-01f, 3.17196324e-02f, 2.58123904e-01f, 1.18600279e-02f, 8.50992650e-02f, -4.04904522e-02f, 2.07334012e-02f,
  -1.03872299e-01f, -1.21462405e-01f, 1.47608563e-01f, -5.37237525e-02f, 5.80486208e-02f, -4.03413642e-03f, 3.46766934e-02f, 4.26661558e-02f, 1.53056467e-02f, 4.96983230e-02f,
  9.43562314e-02f, 1.95017317e-03f, 4.42300551e-02f, -7.05378056e-02f, -8.57171863e-02f, -1.36617035e-01f, 4.20068130e-02f, 6.87760562e-02f, -7.62789771e-02f, -1.68511048e-02f,
  1.03323936e-01f, -3.08148656e-02f, 9.34934840e-02f, 3.17206904e-02f, -8.16396698e-02f, -1.73557773e-02f, -1.32969379e-01f, -1.03029080e-01f, 3.56099792e-02f, -1.20503902e-01f,
  1.82745270e-02f, -2.99845971e-02f, 9.19616148e-02f, -4.82088700e-02f, -3.30141489e-03f, -8.12086537e-02f, -2.47147847e-02f, 3.21824886e-02f, -2.19134733e-01f, 6.96864873e-02f,
  -7.87135214e-02f, 1.07559133e-02f, 3.13441306e-02f, -1.94945589e-01f, -8.92916322e-02f, -5.12300543e-02f, 6.79370388e-02f, 8.12469274e-02f, 7.24461349e-03f, 1.01192847e-01f,
  2.61166040e-02f, 6.22823369e-03f, 9.02838409e-02f, 1.20909177e-01f, -3.94216105e-02f, -1.24600716e-01f, 1.15602590e-01f, 1.12063503e-02f, 1.53195653e-02f, -9.54613164e-02f,
  1.37493378e-02f, 6.67592287e-02f, 3.53252254e-02f, 3.50873955e-02f, -6.26368970e-02f, 1.07725240e-01f, -5.18433675e-02f, 9.84468013e-02f, -1.03045940e-01f, -8.10792297e-02f,
  -2.23800912e-02f, 8.37544799e-02f, 1.37851417e-01f, 2.23734677e-02f, 2.70278715e-02f, 1.47379488e-01f, 5.95088257e-03f, 9.50827599e-02f, 6.44860789e-02f, 8.22487846e-02f,
  3.96041460e-02f, 1.14831319e-02f, -8.97925869e-02f, -9.93023887e-02f, -4.52280119e-02f, -1.02607906e-01f, 5.94393909e-02f, -1.34115934e-01f, -5.53280786e-02f, 8.36153403e-02f,
  -2.44669579e-02f, -9.71741304e-02f, 8.10213238e-02f, 4.16204631e-02f, -4.95001078e-02f, -7.28142932e-02f, -3.72709893e-02f, -5.47720417e-02f, 2.43311394e-02f, -1.24956012e-01f,
  4.30468246e-02f, -1.20928213e-01f, -1.88714668e-01f, 2.26127058e-02f, -4.46155965e-02f, 4.37476523e-02f, -1.67288393e-01f, -6.22375421e-02f, -5.32041974e-02f, 2.61798985e-02f,
  -1.37440637e-02f, 1.12252198e-01f, 1.42284885e-01f, 7.22623896e-03f, -5.83848655e-02f, 1.32573932e-01f, 1.08405136e-01f, 1.13255672e-01f, -4.28379811e-02f, 6.32670969e-02f,
  9.00675058e-02f, 3.04044615e-02f, 8.14303532e-02f, -3.34341750e-02f, 1.04605980e-01f, 2.84152888e-02f, 1.20888412e-01f, 3.53043415e-02f, 5.77516370e-02f, 6.69097528e-02f,
  3.84397954e-02f, 1.36065334e-01f, 2.13828497e-02f, 1.11031100e-01f, -1.11084737e-01f, 1.08538494e-02f, 1.39592007e-01f, 8.07520896e-02f, -3.32510024e-02f, 6.92159608e-02f,
  9.27776545e-02f, 4.35147136e-02f, 3.68629880e-02f, -4.53190021e-02f, 1.61703840e-01f, 1.40702933e-01f, 3.15385731e-03f, -2.80073844e-02f, -8.37380812e-02f, 2.72675864e-02f,
  7.31868148e-02f, -7.99950883e-02f, -3.12503092e-02f, 6.33783787e-02f, 1.22183725e-01f, 2.92659085e-02f, -1.98586062e-02f, 6.40634894e-02f, -7.17791542e-02f, 1.48163708e-02f,
  1.21380709e-01f, -3.40450145e-02f, -1.31471679e-02f, 8.68134014e-03f, -1.65605083e-01f, 1.22591369e-01f, 6.09291866e-02f, 3.51109765e-02f, 2.41128281e-02f, -1.37451589e-01f,
  9.17670727e-02f, 4.49654572e-02f, 9.71580073e-02f, 6.71650395e-02f, 9.28137824e-02f, -5.16492799e-02f, -1.13583259e-01f, -2.67533935e-03f, -4.37655784e-02f, 1.46718979e-01f,
  -2.14865357e-02f, 1.18372124e-02f, 9.86005738e-02f, -3.79384160e-02f, 4.44022287e-03f, 1.24427728e-01f, -5.24537973e-02f, 8.48658755e-02f, -3.12884152e-02f, 1.35397911e-01f,
  8.48351493e-02f, -4.83745933e-02f, 7.99831003e-02f, -9.74725708e-02f, 2.31891386e-02f, -9.38737988e-02f, -8.08410197e-02f, -6.01115711e-02f, 3.61768045e-02f, -6.47618324e-02f,
  -1.15540447e-02f, 8.98568407e-02f, -1.43387184e-01f, -1.17407434e-01f, 2.16434374e-02f, -6.38993457e-03f, -3.14827338e-02f, -1.15807585e-01f, 1.58179879e-01f, 1.71268776e-01f,
  -1.08669445e-01f, -1.35063648e-01f, -1.35770729e-02f, 8.87311995e-02f, 4.28855307e-02f, 2.05035537e-01f, 3.48763727e-02f, 2.40600407e-01f, 2.25797459e-01f, 9.65940207e-02f,
  1.62106767e-01f, 2.02337518e-01f, 1.78848937e-01f, 2.17932630e-02f, 1.46965563e-01f, 8.73083696e-02f, 2.05851614e-01f, 2.92522255e-02f, -1.30389571e-01f, 7.06702098e-02f,
  1.57565311e-01f, -4.42070253e-02f, 1.45040706e-01f, 1.44848391e-01f, 1.32593274e-01f, 2.56003797e-01f, 4.79172096e-02f, -2.77982771e-01f, 1.20380506e-01f, 5.76823251e-03f,
  -8.31829458e-02f, 7.23035410e-02f, 1.59406811e-02f, 1.03695385e-01f, -1.14186600e-01f, -3.67118679e-02f, -9.24132764e-02f, 1.16255209e-01f, -7.82232359e-02f, 5.21647967e-02f,
  6.30558431e-02f, -4.04571928e-03f, 4.27517772e-01f, -4.04312387e-02f, 2.31133075e-03f, 2.89677512e-02f, -1.43921003e-01f, -1.79161597e-02f, 1.22126773e-01f, -1.87368602e-01f,
  -5.39989397e-02f, 5.29333167e-02f, 6.11961037e-02f, -2.22882945e-02f, 6.71470389e-02f, -6.53121322e-02f, 1.19558908e-01f, -6.08319752e-02f, 3.23458053e-02f, -1.14081472e-01f,
  -5.45903184e-02f, 7.87225813e-02f, 1.07509241e-01f, 6.87759146e-02f, 9.09621492e-02f, -1.28775150e-01f, -4.77873236e-02f, 4.68707690e-03f, 1.88715756e-01f, -6.77785203e-02f,
  2.04191469e-02f, 3.31776477e-02f, -7.79288113e-02f, 9.98470560e-02f, 1.10423535e-01f, -6.71922937e-02f, 1.23597436e-01f, -5.25179831e-03f, -3.19102667e-02f, 4.70854864e-02f,
  -1.66096762e-01f, -1.27113417e-01f, -9.98191908e-02f, -1.85379758e-02f, 1.32785752e-01f, 1.07488081e-01f, 1.09931573e-01f, -1.93236485e-01f, 1.39175160e-02f, 1.49003506e-01f,
  2.32657477e-01f, 5.13964184e-02f, 2.00218661e-03f, -2.82891896e-02f, -5.58213741e-02f, 6.21783966e-03f, 5.01108542e-02f, 2.77546607e-02f, -9.00491998e-02f, -6.06008172e-02f,
  7.57711679e-02f, -9.88229439e-02f, -1.46948174e-01f, 2.37404797e-02f, -3.46440114e-02f, 1.54546127e-01f, 2.46302530e-01f, 2.86371075e-02f, 1.19490348e-01f, 4.40290198e-02f,
  -9.13821384e-02f, -9.33912024e-02f, 1.90757290e-01f, -9.43545178e-02f, -7.12123737e-02f, 4.05943990e-02f, -4.25945595e-03f, 1.36142462e-01f, 4.45932597e-02f, -8.39492399e-03f,
  -1.21891722e-01f, -1.60622567e-01f, 2.70123780e-02f, 4.81457524e-02f, -6.28949180e-02f, -1.21321544e-01f, 8.59289095e-02f, 3.43851484e-02f, -1.01424351e-01f, -1.23869792e-01f,
  -3.22886780e-02f, 6.44122511e-02f, -1.03400955e-02f, -3.96731831e-02f, 1.02906823e-01f, -3.48185524e-02f, 3.54221538e-02f, -8.43172967e-02f, -1.28769413e-01f, -1.12528913e-01f,
  -8.39388222e-02f, -1.06495656e-01f, -2.80213319e-02f, 6.48934469e-02f, 3.31511088e-02f, 9.12237447e-03f, 7.53066465e-02f, 4.83539095e-03f, 1.93013594e-01f, -6.68138340e-02f,
  8.16714466e-02f, 2.93311328e-02f, 1.61407497e-02f, -1.47422841e-02f, 4.79387976e-02f, 9.00282338e-02f, -7.81272575e-02f, 5.09288870e-02f, -3.08503024e-02f, -7.98552632e-02f,
  -3.91890034e-02f, 4.82901111e-02f, 1.04373526e-02f, 6.78933561e-02f, -6.37345612e-02f, -1.17268180e-02f, -5.06875813e-02f, 1.27069518e-01f, -1.32854898e-02f, 2.20219687e-01f,
  9.37841386e-02f, -2.53418051e-02f, -5.85650690e-02f, 6.75450861e-02f, -7.46301189e-02f, -4.18501757e-02f, 4.93210405e-02f, -1.08726352e-01f, -4.75236587e-02f, 5.07457554e-02f,
  1.17764823e-01f, 1.95828080e-02f, -1.01225182e-01f, 2.80208122e-02f, -1.32320756e-02f, -1.11090034e-01f, -6.65194988e-02f, 1.06196649e-01f, -1.08130656e-01f, -8.49500597e-02f,
  7.00853467e-02f, -9.01110321e-02f, -9.77592990e-02f, 3.44982534e-03f, 1.32379472e-01f, 6.79663420e-02f, -9.08514038e-02f, -3.51322778e-02f, 1.35197612e-02f, -6.24230020e-02f,
  7.57769421e-02f, 1.36697486e-01f, 2.06719451e-02f, -1.84618048e-02f, 5.00007123e-02f, 1.01523444e-01f, -2.90684346e-02f, 5.45322448e-02f, 1.05143413e-02f, -7.08794445e-02f,
  -5.53345084e-02f, -5.21639921e-02f, -1.17230579e-01f, 1.49206698e-01f, -6.36047795e-02f, 1.10717222e-01f, 1.48010060e-01f, -7.16101751e-02f, 1.05019957e-01f, -2.68878285e-02f,
  -5.63415214e-02f, -9.92389023e-02f, 3.40685770e-02f, 8.01042765e-02f, 1.04437947e-01f, 1.23578440e-02f, 4.51984480e-02f, -2.23754421e-02f, 1.05070665e-01f, -5.05603328e-02f,
  3.58669199e-02f, 1.54764920e-01f, -1.64491069e-02f, -1.32450759e-01f, 5.38888276e-02f, 4.52897847e-02f, -7.30374306e-02f, -6.93434700e-02f, 1.03294089e-01f, -3.45037170e-02f,
  -3.53856422e-02f, -1.21922821e-01f, -9.00887251e-02f, -9.14734378e-02f, 2.84014829e-02f, 1.08460495e-02f, 2.80875154e-02f, 2.25442019e-03f, -8.51078555e-02f, -6.31628139e-03f,
  4.52395668e-03f, -1.39457971e-01f, -4.66921180e-02f, -6.17820024e-02f, 1.91881899e-02f, 1.62887037e-01f, 8.79891440e-02f, 9.47688073e-02f, 1.27432793e-01f, -5.28411865e-02f,
  7.13773370e-02f, 1.27812669e-01f, 2.91158236e-03f, -7.15055987e-02f, 1.15722351e-01f, 1.55456748e-03f, -8.13022032e-02f, 1.34015486e-01f, 2.50877365e-02f, 9.02191475e-02f,
  -1.24105297e-01f, -6.76818863e-02f, 1.65420957e-02f, -3.73264253e-02f, 6.35158569e-02f, -3.62066440e-02f, -2.04727769e-01f, -1.39369331e-02f, -4.92551103e-02f, 1.42447073e-02f,
  2.14753561e-02f, 2.43779030e-02f, -1.53404430e-01f, 7.20400214e-02f, -1.35428920e-01f, -9.88836735e-02f, -4.29333374e-03f, -1.98617894e-02f, 9.28811058e-02f, -3.18444036e-02f,
  -2.32457351e-02f, -1.09119892e-01f, 1.28515780e-01f, -8.73399004e-02f, 2.42638052e-01f, 9.04698297e-02f, -2.36058533e-02f, 4.32072543e-02f, 2.30935495e-02f, 1.54053092e-01f,
  1.10640349e-02f, -8.82064998e-02f, 1.08171612e-01f, 7.90628269e-02f, -8.95960853e-02f, 3.56023945e-02f, 7.65256658e-02f, 1.35825872e-01f, 1.72075197e-01f, 3.18498630e-03f,
  1.00178950e-01f, -1.15867645e-01f, 3.97938453e-02f, 7.17047453e-02f, -4.42453548e-02f, -7.94453360e-03f, -3.88079956e-02f, 6.39150813e-02f, 1.06365688e-01f, 5.68332449e-02f,
  1.02038875e-01f, 1.66524440e-01f, 5.05264895e-03f, 3.27039547e-02f, -7.13531077e-02f, 1.22348890e-01f, -3.18603292e-02f, 1.23731449e-01f, 1.59289256e-01f, -1.05712237e-02f,
  -1.24301314e-01f, 9.48263556e-02f, 8.66235718e-02f, 9.99004021e-02f, 1.17507406e-01f, -1.38515949e-01f, -3.98487896e-02f, 2.45745033e-02f, 4.14109454e-02f, -1.64273486e-01f,
  -1.28334105e-01f, 1.33866996e-01f, 6.53628185e-02f, -9.31550339e-02f, -1.41593471e-01f, 7.23621175e-02f, -5.72812185e-02f, 9.15953740e-02f, 5.75921126e-02f, -2.77870931e-02f,
  -1.35569155e-01f, -7.47641027e-02f, -1.35647207e-01f, 8.35904106e-02f, -4.90521081e-02f, 1.01133451e-01f, 3.80254649e-02f, -3.88790108e-02f, 1.92551523e-01f, 1.35595635e-01f,
  -5.23937084e-02f, 9.96828377e-02f, 1.75046921e-01f, 1.59870893e-01f, 1.25686094e-01f, 3.05995531e-02f, 1.18807415e-02f, -1.40468597e-01f, 9.52742770e-02f, 7.60128126e-02f,
  -3.51968743e-02f, -3.14174518e-02f, 1.60401300e-01f, -8.74751583e-02f, -3.80629264e-02f, 6.37391908e-03f, 9.13796052e-02f, 4.33171801e-02f, 3.07360347e-02f, -8.63436535e-02f,
  -6.00767322e-02f, -5.13878912e-02f, -1.96478516e-02f, 1.39749110e-01f, -8.52382332e-02f, -5.58885671e-02f, 1.50149371e-02f, -2.23280769e-02f, 4.98877019e-02f, 5.63465152e-03f,
  3.60999554e-01f, 2.74960697e-01f, -5.99517114e-02f, 2.04846129e-01f, 3.52602303e-01f, 2.59797901e-01f, 1.51082769e-01f, 3.45999777e-01f, 1.62675455e-01f, 3.48939210e-01f,
  -4.05137800e-02f, -3.96208674e-01f, 2.18055844e-01f, 1.89185679e-01f, -3.83091092e-01f, 2.00353950e-01f, -2.91704297e-01f, 1.49676418e-02f, -1.25453830e-01f, -2.73871124e-01f,
  -7.30316387e-04f, 2.05638021e-01f, -4.84663583e-02f, -2.27121804e-02f, 4.03038114e-01f, 6.33998588e-02f, 1.72834530e-01f, -1.49967819e-01f, -1.54613957e-01f, -1.02265678e-01f,
  -1.64389074e-01f, 1.53989628e-01f, 3.04543436e-01f, 3.53374742e-02f, 1.86657026e-01f, -2.56376773e-01f, -1.25134245e-01f, 4.71982881e-02f, -1.34694174e-01f, 9.19729099e-02f,
  6.79856017e-02f, -5.54307327e-02f, -1.38126075e-01f, 2.96431780e-01f, 9.78930369e-02f, 1.49421066e-01f, -1.43181443e-01f, 4.74397615e-02f, -5.05981222e-02f, 3.83915573e-01f,
  3.19359712e-02f, 3.96283604e-02f, 7.78763462e-03f, 1.56969398e-01f, -1.17471576e-01f, -2.88319681e-02f, 5.36624976e-02f, 5.64365722e-02f, -2.17921995e-02f, -1.09690771e-01f,
  1.09311333e-02f, 1.49748206e-01f, 9.75834504e-02f, 2.04401210e-01f, 1.49281278e-01f, 2.43604958e-01f, 1.01752251e-01f, 1.34837285e-01f, 3.17354649e-01f, 8.09638500e-02f,
  2.59998500e-01f, 1.71157405e-01f, 1.64234295e-01f, 2.07850039e-01f, 1.36379242e-01f, 2.81255066e-01f, 2.13169470e-01f, -4.08463031e-01f, -6.57553375e-02f, -3.71975809e-01f,
  2.38076612e-01f, 2.54685193e-01f, -1.04803912e-01f, 9.73654911e-02f, -3.34505469e-01f, -3.81580852e-02f, 1.66966930e-01f, 6.38572201e-02f, -6.98744953e-02f, -4.53493036e-02f,
  -1.26004219e-01f, 1.09252803e-01f, -2.79533505e-01f, 1.65691510e-01f, -1.11739397e-01f, 1.16565518e-01f, 1.82229355e-01f, -1.27785414e-01f, 4.74791490e-02f, 2.31650576e-01f,
  5.14734864e-01f, -1.01152688e-01f, 7.23483637e-02f, 2.28534620e-02f, -2.06318349e-01f, 2.62944937e-01f, 2.01689854e-01f, 2.93133371e-02f, 7.24356249e-02f, 8.19571465e-02f,
  8.56211707e-02f, -1.24386445e-01f, 3.08738500e-01f, -3.53297070e-02f, 2.88519770e-01f, 2.53445357e-01f, 9.57324058e-02f, 1.54811427e-01f, 2.39771977e-02f, 1.22356176e-01f,
  1.67633116e-01f, 7.33234212e-02f, -3.70000452e-02f, -1.23352043e-01f, -1.42931923e-01f, 2.44012937e-01f, 3.16680193e-01f, 2.37574905e-01f, 2.17305273e-01f, 1.50383443e-01f,
  1.75866529e-01f, 2.05586597e-01f, 1.57867730e-01f, 2.55143672e-01f, 3.03417534e-01f, 2.28735715e-01f, 4.02737498e-01f, 1.74944371e-01f, 2.48097166e-01f, -1.89695507e-01f,
  -4.11780298e-01f, 4.05748665e-01f, 2.36468613e-01f, 9.13140737e-03f, -1.01146348e-01f, -1.31088957e-01f, 2.44890079e-01f, 4.41525131e-01f, 3.48697960e-01f, -4.62161750e-01f,
  -9.47860479e-02f, -7.45372847e-02f, -5.98021895e-02f, 7.23199397e-02f, 2.94380784e-02f, 2.50149459e-01f, 4.36196476e-01f, -1.32799983e-01f, -1.21839032e-01f, -6.29288405e-02f,
  -2.07340315e-01f, 3.12275767e-01f, -1.49472579e-01f, -3.60338874e-02f, 7.29563460e-02f, -1.09601021e-02f, -1.03615373e-01f, 1.23235404e-01f, 1.45882800e-01f, -1.56754151e-01f,
  1.82923581e-02f, -3.15379411e-01f, -1.83220342e-01f, 9.97303519e-03f, -1.19168632e-01f, 1.28182098e-01f, 1.16914876e-01f, -3.52990478e-02f, -1.73314020e-01f, -1.72101393e-01f,
  -1.50748163e-01f, -1.05606832e-01f, -1.07514761e-01f, 1.45255491e-01f, 3.54663402e-01f, 2.09353626e-01f, -1.21869355e-01f, -2.60356739e-02f, 1.26425639e-01f, -5.92962094e-02f,
  -8.17476809e-02f, 3.16561200e-02f, -5.64624779e-02f, 5.81377335e-02f, -8.09683278e-02f, 7.02781826e-02f, 5.09439334e-02f, 2.79817730e-02f, 1.47282392e-01f, 6.91990480e-02f,
  1.03227869e-01f, -7.10398331e-02f, -1.02475613e-01f, -4.50782813e-02f, 5.11022806e-02f, 1.27728283e-01f, -6.28331602e-02f, 7.02491328e-02f, 1.98729336e-03f, 3.24035995e-02f,
  -6.57575056e-02f, -1.92820393e-02f, -3.04988995e-02f, 2.52760667e-02f, -8.52368250e-02f, 1.49838421e-02f, 8.52406546e-02f, -7.78974518e-02f, 3.87540460e-02f, -4.57687341e-02f,
  3.73047665e-02f, 1.06602997e-01f, -8.06977674e-02f, -8.36810693e-02f, 1.91427737e-01f, 3.49193439e-02f, -2.20705383e-02f, -1.06755815e-01f, -1.05649240e-01f, 1.41505480e-01f,
  -4.05944586e-02f, 7.55370036e-02f, 6.25118837e-02f, -7.91833699e-02f, -8.02228153e-02f, 1.73897773e-01f, -5.62678352e-02f, -9.22835544e-02f, 8.69893003e-03f, 7.53840506e-02f,
  1.43097658e-02f, -8.00308660e-02f, -7.87944999e-03f, 2.87648700e-02f, -8.55975449e-02f, -4.98437099e-02f, 1.23043776e-01f, 7.36031756e-02f, -1.40939847e-01f, 6.65283715e-03f,
  9.32090804e-02f, 6.84674755e-02f, 5.45286573e-02f, 5.52409850e-02f, -8.71397629e-02f, 4.96093445e-02f, -7.02506825e-02f, 1.64259318e-02f, -1.06612369e-01f, 3.70482877e-02f,
  -5.00383191e-02f, -1.16242647e-01f, -2.06704885e-02f, 5.95464297e-02f, 6.93905400e-03f, 8.63547847e-02f, -9.52612385e-02f, 2.62008999e-02f, 1.45233078e-02f, -4.94689047e-02f,
  8.89403187e-03f, -2.55382769e-02f, -4.22991841e-04f, -5.56468442e-02f, -1.26984283e-01f, 4.38016206e-02f, 7.64581412e-02f, -5.96458130e-02f, -8.02717507e-02f, -1.09908700e-01f,
  -3.96289974e-02f, 9.91974622e-02f, -6.68381304e-02f, -2.17278153e-02f, 1.42139122e-02f, -2.33677756e-02f, -3.66153345e-02f, 1.22629173e-01f, 8.47513005e-02f, -6.42894953e-02f,
  -7.23871887e-02f, 1.04893386e-01f, -4.15763296e-02f, 7.02920184e-02f, -4.58694547e-02f, -4.34191078e-02f, -5.19955605e-02f, 5.06684333e-02f, 4.46371399e-02f, -5.21321818e-02f,
  7.71932602e-02f, -1.20680049e-01f, 4.52494435e-02f, -9.37726069e-03f, -8.88598338e-02f, -1.09979408e-02f, 4.95310426e-02f, 8.74177963e-02f, -4.93260510e-02f, 1.41089335e-01f,
  -1.11819789e-01f, -7.79004395e-02f, -6.71935529e-02f, -1.78621747e-02f, -4.28033061e-03f, -3.39484140e-02f, 4.57069017e-02f, 7.03923181e-02f, 1.22645736e-01f, 2.03516394e-01f,
  1.09674960e-01f, 1.20985836e-01f, 1.23875871e-01f, 1.57188132e-01f, 4.51796763e-02f, 7.63638541e-02f, 2.14607194e-01f, 2.13067129e-01f, 1.79882988e-01f, 1.89135209e-01f,
  1.41228288e-01f, 1.00357831e-01f, 1.00559574e-02f, -5.10600768e-02f, -2.72158422e-02f, -1.11043818e-01f, 2.62340307e-01f, 2.73670375e-01f, -1.32013768e-01f, 2.85642538e-02f,
  -4.12780717e-02f, -1.27994880e-01f, 1.93378091e-01f, -8.56507868e-02f, 3.13394796e-03f, -4.32433635e-02f, -1.08516827e-01f, 1.25867486e-01f, 3.15886997e-02f, 4.44329195e-02f,
  -9.74280164e-02f, 1.67237923e-01f, 1.40502691e-01f, -1.20614663e-01f, 1.40128568e-01f, 5.56768104e-02f, 3.72126907e-01f, -1.43227160e-01f, 8.33767354e-02f, 5.14104925e-02f,
  -2.26137608e-01f, 4.95911464e-02f, 2.97764037e-02f, -1.95072088e-02f, 1.15302563e-01f, 2.05025747e-01f, -9.55696180e-02f, -1.65379480e-01f, 4.88127768e-02f, -6.27328627e-05f,
  -3.60212475e-02f, -4.95977094e-03f, 7.37293735e-02f, 8.70449394e-02f, -7.64121860e-02f, 2.59008706e-02f, 8.65347311e-02f, 3.24535519e-02f, -5.79308160e-02f, -1.39274120e-01f,
  -7.98074156e-02f, 1.88192338e-01f, 2.05740869e-01f, 7.17057139e-02f, 2.24934861e-01f, 1.68600410e-01f, 1.26031846e-01f, -2.57886644e-03f, 5.35568893e-02f, 1.74310863e-01f,
  2.22799614e-01f, 1.04066901e-01f, 7.33244568e-02f, 7.76731148e-02f, -2.87168443e-01f, 1.27103314e-01f, 1.39306322e-01f, 1.64295301e-01f, 3.85863185e-01f, 3.20052803e-02f,
  5.47868498e-02f, 2.90526189e-02f, 1.39793411e-01f, 2.04358190e-01f, 7.76597485e-02f, -1.41926169e-01f, -4.23367582e-02f, -1.13437265e-01f, 3.04292347e-02f, 9.33393613e-02f,
  1.25245983e-02f, 2.05455385e-02f, -9.19732153e-02f, 7.41523653e-02f, -1.07504271e-01f, 2.38694638e-01f, -1.23667873e-01f, -2.25427985e-01f, 5.23629412e-02f, 2.95322508e-01f,
  2.30861574e-01f, -1.81394681e-01f, 1.61689706e-02f, -1.46655843e-01f, -3.09085865e-02f, -1.18059807e-01f, -9.00815129e-02f, -1.01189665e-01f, -8.81958604e-02f, -1.51979819e-01f,
  -1.03906892e-01f, 1.78603202e-01f, 5.65019660e-02f, -1.37824118e-01f, 1.57313526e-01f, -7.31586888e-02f, -4.25878093e-02f, 1.69307850e-02f, -5.50919250e-02f, -7.01446040e-03f,
  1.03013732e-01f, -2.46979877e-01f, 1.06158152e-01f, -3.20986658e-02f, -5.56996949e-02f, 1.06805414e-01f, 2.36678701e-02f, -8.77702758e-02f, -8.48063380e-02f, -3.22636366e-02f,
  -2.23897677e-03f, -1.18871942e-01f, -1.07896149e-01f, 1.98349953e-02f, -4.49168459e-02f, 7.05080926e-02f, -1.21287517e-01f, 2.29435321e-02f, -1.36071831e-01f, -9.54157338e-02f,
  -7.03397468e-02f, -9.19046476e-02f, 9.91747081e-02f, 9.09775123e-02f, 3.07845920e-02f, -1.02749549e-01f, -1.58443290e-03f, 4.55322396e-03f, -4.77573648e-02f, -1.26472092e-03f,
  -1.46528846e-02f, -1.01530030e-01f, 7.46503249e-02f, 4.63714972e-02f, 5.83151355e-02f, -2.33249106e-02f, 7.49350190e-02f, 4.39285673e-02f, 4.04770970e-02f, 6.94230665e-03f,
  6.91151395e-02f, -9.46053937e-02f, 9.89977866e-02f, 2.16664169e-02f, -5.17841093e-02f, -2.37968173e-02f, -5.81037104e-02f, -1.71831017e-03f, 1.31159127e-02f, -1.29874408e-01f,
  5.80582656e-02f, -8.73216242e-02f, -4.94723953e-02f, -6.20265044e-02f, 1.12985194e-01f, -4.44335863e-03f, 8.18149596e-02f, -1.61676586e-03f, 5.66379502e-02f, 5.92627712e-02f,
  1.22887507e-01f, 5.30512929e-02f, 8.63253027e-02f, -1.05629832e-01f, 3.56246419e-02f, -8.49578679e-02f, -6.09090105e-02f, 9.06516686e-02f, 8.10614228e-03f, -2.38309763e-02f,
  2.90267151e-02f, -8.50994587e-02f, -5.81217892e-02f, 9.76073295e-02f, 7.95134678e-02f, 1.28146693e-01f, 1.47282198e-01f, -2.24310942e-02f, 8.44442025e-02f, -7.67203746e-03f,
  6.63984986e-03f, 1.14211790e-01f, 4.91334572e-02f, -1.43912584e-01f, 3.77052538e-02f, 8.52248818e-03f, 3.70840579e-02f, 1.07649386e-01f, 9.96253565e-02f, 7.45599419e-02f,
  -1.37725428e-01f, 1.22366901e-02f, 1.70901582e-01f, 9.48312599e-03f, -2.43294388e-02f, -9.73752514e-02f, -1.17805772e-01f, 3.64961699e-02f, 5.16747981e-02f, -1.05592325e-01f,
  -4.43205088e-02f, 3.79369631e-02f, -7.32397735e-02f, -5.11425883e-02f, -7.61550888e-02f, -1.03527717e-01f, 2.04762928e-02f, -2.13363729e-02f, -9.03384462e-02f, 1.05266988e-01f,
  -1.29209235e-01f, 9.16524753e-02f, -2.02987660e-02f, 1.52446236e-02f, 4.99791652e-02f, 1.63551494e-02f, 1.61894783e-02f, 1.23884581e-01f, -7.63894245e-02f, 1.97226238e-02f,
  -3.51031236e-02f, 1.15463249e-01f, 6.94803074e-02f, -4.49149981e-02f, -8.44644234e-02f, 3.21821943e-02f, -1.27782658e-01f, -5.68613894e-02f, 1.97898149e-02f, -1.09513171e-01f,
  -2.67429836e-02f, -5.38054816e-02f, -7.50255659e-02f, -8.27257261e-02f, 1.07500508e-01f, 5.28211035e-02f, -9.90057215e-02f, -4.30247970e-02f, -3.17187724e-03f, 1.35718659e-01f,
  -1.40421733e-01f, -9.47440490e-02f, 1.48731336e-01f, 9.83240381e-02f, 4.25790474e-02f, -1.20468177e-01f, 9.74443108e-02f, 9.16777328e-02f, -3.87528390e-02f, -2.90800408e-02f,
  9.37351212e-02f, 5.00136092e-02f, 1.62247196e-02f, -1.77418068e-01f, 2.65552048e-02f, -3.80400866e-02f, -1.26479432e-01f, -1.82929896e-02f, 9.62809175e-02f, 9.78928898e-03f,
  -5.75056076e-02f, 1.38100624e-01f, -4.83481884e-02f, 2.84261964e-02f, 5.41472659e-02f, -6.74776509e-02f, 6.51812777e-02f, -8.94388482e-02f, 2.29341075e-01f, 2.60316342e-01f,
  3.06066908e-02f, 3.23900014e-01f, 6.63588941e-02f, 8.63416493e-02f, -6.94893077e-02f, -1.41925253e-02f, 3.40303034e-02f, 3.03540248e-02f, -3.71756032e-02f, 1.05646119e-01f,
  -6.16347976e-02f, 1.91930849e-02f, 2.06850454e-01f, -9.39563587e-02f, 3.70239243e-02f, -1.02482051e-01f, -8.91640484e-02f, 1.19791657e-01f, -1.06344195e-02f, 1.15477428e-01f,
  1.95003524e-02f, -1.22261256e-01f, -4.80304435e-02f, -7.10817128e-02f, -2.64213588e-02f, 7.64147267e-02f, -2.94917785e-02f, 6.08332641e-02f, 9.76015627e-03f, -3.06829158e-02f,
  1.76072381e-02f, -3.87853608e-02f, 1.15398914e-01f, -6.73902780e-02f, -1.32883593e-01f, 3.03434450e-02f, 1.28819585e-01f, -1.49049759e-01f, -5.43850362e-02f, -8.88641253e-02f,
  4.90850285e-02f, 2.58269738e-02f, -5.49705401e-02f, -5.00664860e-02f, 2.02786978e-02f, -1.27974153e-01f, 7.83915073e-02f, 2.14192346e-02f, 1.33479774e-01f, 1.51253730e-01f,
  1.69855595e-01f, -8.98004770e-02f, -4.79574762e-02f, 4.44146655e-02f, -4.81216051e-02f, -1.80926602e-02f, 6.04195297e-02f, 1.10848777e-01f, 6.21982627e-02f, -2.04492211e-02f,
  -2.76193321e-02f, 4.16512638e-02f, 2.63754111e-02f, 1.17240973e-01f, -4.28695716e-02f, 1.33855537e-01f, 3.25604491e-02f, 1.06498919e-01f, 7.84199312e-02f, -6.17946573e-02f,
  9.64177847e-02f, 5.73263690e-02f, 2.27941442e-02f, 4.11516391e-02f, 8.50700832e-04f, 6.03959672e-02f, 5.86104989e-02f, -1.11830600e-01f, 2.99301017e-02f, 1.10577740e-01f,
  2.57688109e-02f, -8.34130496e-02f, 3.58985248e-03f, -8.21516737e-02f, -1.09545559e-01f, -1.25825945e-02f, -8.48784577e-03f, -9.06978101e-02f, -8.15185532e-02f, 2.82548051e-02f,
  -4.50159833e-02f, 8.50309730e-02f, -6.96917921e-02f, -3.61804254e-02f, -8.96382257e-02f, 1.61741357e-02f, 3.93387787e-02f, -1.06953733e-01f, 1.02104343e-01f, -9.83705968e-02f,
  -1.76832192e-02f, 4.18881103e-02f, -6.82851160e-03f, -4.50995080e-02f, 7.11109638e-02f, 2.74012927e-02f, 1.63854472e-02f, 1.17205204e-02f, -8.78701657e-02f, 2.78609470e-02f,
  -1.47797540e-01f, 5.19095222e-03f, 2.36233007e-02f, 9.69891250e-02f, -9.35072452e-02f, -1.96607299e-02f, 1.72092970e-02f, 1.29730001e-01f, -1.47595797e-02f, -4.24577966e-02f,
  1.35962591e-01f, 2.03389693e-02f, -8.85514617e-02f, 3.04199643e-02f, 3.86449732e-02f, -7.58829713e-03f, -2.99206749e-02f, 2.79918984e-02f, 7.45674819e-02f, -3.32151502e-02f,
  6.61610141e-02f, -1.18302010e-01f, -8.30460936e-02f, -2.30429862e-02f, -5.67609668e-02f, 1.38694003e-01f, -1.42613305e-02f, -2.44228132e-02f, 4.94063087e-02f, 1.33165106e-01f,
  -6.64948970e-02f, 4.50472794e-02f, 5.78390807e-02f, 1.01863004e-01f, -6.33651540e-02f, 9.37033892e-02f, 3.25127244e-02f, 9.15157981e-03f, -9.82771888e-02f, -8.03058818e-02f,
  -9.77256298e-02f, 1.16663188e-01f, 7.05781728e-02f, 5.86644001e-02f, 1.04357608e-01f, 5.60790440e-03f, 8.96462947e-02f, 1.27781838e-01f, -3.93714607e-02f, -6.28166497e-02f,
  1.57701224e-01f, -4.39763255e-02f, 5.89935258e-02f, 8.45784545e-02f, 1.21667117e-01f, -1.04407975e-02f, -6.00768924e-02f, -9.52015519e-02f, 5.86722568e-02f, -2.76330803e-02f,
  6.77890405e-02f, 9.84178632e-02f, -2.01579556e-02f, -5.36818616e-03f, 9.13179219e-02f, -7.25475401e-02f, 1.66389078e-01f, 1.93157986e-01f, -7.33543485e-02f, -3.67232636e-02f,
  3.61586474e-02f, 4.02844250e-02f, 5.95660061e-02f, 9.55630839e-02f, 6.62501305e-02f, -6.44545555e-02f, 2.21427027e-02f, 7.51886219e-02f, -4.18234058e-02f, -1.28419473e-04f,
  -9.94066596e-02f, -6.77334592e-02f, -2.02363208e-02f, 1.50676981e-01f, 9.83927324e-02f, -1.00488225e-02f, -1.82428723e-03f, -8.93906057e-02f, 1.28512606e-01f, -9.68689173e-02f,
  -2.05763895e-02f, -5.11316210e-02f, -1.44854588e-02f, 1.64401401e-02f, -4.72352169e-02f, 1.41350240e-01f, 1.52270749e-01f, -1.27323464e-01f, -6.88545406e-02f, 1.07679144e-01f,
  -7.41490796e-02f, 1.24817669e-01f, 4.89943847e-03f, -3.52554061e-02f, 1.44578457e-01f, 9.25839767e-02f, -4.77132834e-02f, 4.53839265e-02f, -8.98774937e-02f, -7.96295479e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  5.71175255e-02f, 7.46996477e-02f, 8.26226845e-02f, -5.61156273e-02f, 7.44195133e-02f, 1.39235765e-01f, 1.47017583e-01f, 8.70792791e-02f, -4.73649502e-02f, 6.94559216e-02f,
  3.29705402e-02f, 1.63168520e-01f, 1.75085291e-01f, 4.26331395e-03f, 8.22454840e-02f, -6.76515996e-02f, -2.43425518e-02f, -6.69763535e-02f, -2.73650698e-02f, 1.24646731e-01f,
  1.35266483e-02f, 2.02881470e-01f, 1.64130062e-01f, 6.47063702e-02f, -5.35678901e-02f, 1.42250821e-01f, -3.49899046e-02f, 2.28269234e-01f, 1.62604198e-01f, 3.15898120e-01f,
  -3.26251201e-02f, 5.13308384e-02f, 2.37173334e-01f, 2.56052315e-01f, -6.09166324e-02f, 5.73790297e-02f, -3.08341421e-02f, 6.85567707e-02f, 1.80170834e-02f, -7.09113926e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.55858004e-01f, -3.69580418e-01f, -1.02769181e-01f, 2.77856886e-01f, 1.17995821e-01f, -3.66228759e-01f, 2.47915417e-01f, 9.38129723e-02f, 2.84088075e-01f, 2.43941367e-01f,
  2.62656748e-01f, 2.64159292e-01f, -1.05371848e-02f, -2.82431513e-01f, 3.07122290e-01f, 2.73052365e-01f, -4.74283509e-02f, 4.46346134e-01f, 1.59519792e-01f, -2.25132704e-01f,
  2.60756224e-01f, -7.03518167e-02f, -9.73824635e-02f, 5.90963736e-02f, -1.73933461e-01f, -1.81697533e-01f, -5.93740158e-02f, -1.94815472e-01f, -2.06492886e-01f, 7.16921911e-02f,
  -4.27745044e-01f, 1.41456038e-01f, -9.44854878e-03f, 1.05068728e-01f, 1.42012730e-01f, -2.55076826e-01f, -3.00034583e-01f, 7.83615559e-02f, 1.15488343e-01f, -8.92016143e-02f,
  -9.19638872e-02f, -1.24552317e-01f, 2.22148553e-01f, 1.69615030e-01f, -2.76903003e-01f, 6.24581240e-02f, -1.34125128e-01f, 6.37553958e-03f, -4.68570963e-02f, 4.82099988e-02f,
  -1.30238891e-01f, 3.31282228e-01f, 6.22688234e-01f, -2.92836905e-01f, -1.72089282e-02f, 1.42059429e-03f, 2.69297034e-01f, -2.97084749e-01f, 9.07540694e-03f, -9.86353606e-02f,
  -1.36111766e-01f, -4.21530604e-02f, 1.82157934e-01f, -3.91575098e-02f, 9.32513028e-02f, 1.46396030e-02f, -5.28340004e-02f, -1.12888210e-01f, -1.24068886e-01f, -1.62183836e-01f,
  -8.78069848e-02f, -8.94303992e-03f, 1.59980953e-02f, 1.12011544e-01f, 8.57237950e-02f, 1.04169875e-01f, 1.20332874e-01f, -4.15608227e-01f, 1.05377823e-01f, 1.77127525e-01f,
  1.82802290e-01f, 3.99815440e-01f, -3.26183140e-01f, -3.22359800e-01f, -2.58020818e-01f, -1.83067545e-02f, 8.23606849e-02f, 3.70997414e-02f, -2.34686330e-01f, -2.05529243e-01f,
  2.94978976e-01f, -3.70560408e-01f, -1.56742916e-01f, -2.33158782e-01f, -1.50239334e-01f, -1.73482955e-01f, -1.86561674e-01f, 7.17919394e-02f, 1.79895550e-01f, 2.16368422e-01f,
  -3.77536207e-01f, -6.79762289e-02f, -3.76728526e-03f, -6.81364015e-02f, -1.77835435e-01f, -1.06955595e-01f, -8.27712566e-02f, 1.01001777e-01f, -4.78642061e-02f, 5.34726977e-01f,
  1.09845281e-01f, -4.35322076e-02f, 1.30213678e-01f, -2.99901352e-03f, 1.69628382e-01f, -4.94481027e-01f, 3.77966285e-01f, 2.86170512e-01f, -1.85871050e-01f, -1.32285282e-01f,
  2.70341814e-01f, 6.98088035e-02f, 5.29954582e-02f, -9.37725827e-02f, -2.40780357e-02f, 6.14282303e-02f, -4.85673882e-02f, 1.11382313e-01f, 8.70337710e-02f, -2.07671702e-01f,
  1.30427495e-01f, -3.42365891e-01f, -1.62462220e-01f, 1.71128988e-01f, -3.07150543e-01f, 4.24727686e-02f, -1.54572174e-01f, -2.54155934e-01f, -6.97685555e-02f, -3.57390046e-01f,
  -6.55125268e-03f, 3.38926673e-01f, -1.44523352e-01f, 4.32658195e-01f, 2.38655284e-01f, -3.80758673e-01f, -1.59338102e-01f, 3.49016756e-01f, -7.12219849e-02f, 3.04879844e-01f,
  -1.51336089e-01f, 1.65592879e-01f, -5.19360341e-02f, -2.46037245e-01f, 5.32650828e-01f, 2.12777555e-01f, -1.48750052e-01f, -2.11534008e-01f, -5.85545003e-02f, -2.13870347e-01f,
  4.40675467e-02f, -9.72140580e-02f, 1.55007929e-01f, 2.23388761e-01f, -1.10391445e-01f, 6.71057850e-02f, -1.78754389e-01f, -2.41016578e-02f, 1.28093004e-01f, 2.12705910e-01f,
  -5.31676188e-02f, 4.48444188e-02f, 2.32000470e-01f, 2.33550802e-01f, 2.57748991e-01f, 2.09010199e-01f, 4.50522043e-02f, -1.26329228e-01f, 1.50358379e-01f, -4.43914801e-01f,
  -1.32109553e-01f, 3.57886404e-01f, -4.96650748e-02f, -2.83554550e-02f, -4.32068445e-02f, -1.63962483e-01f, 5.45512103e-02f, -6.21692203e-02f, 2.49859139e-01f, 2.32180938e-01f,
  -6.25181943e-02f, 1.30052119e-01f, -1.01468116e-02f, -6.84900731e-02f, 1.10196665e-01f, 3.81567106e-02f, -1.61914155e-01f, -1.11491211e-01f, -1.80592135e-01f, -2.17388701e-02f,
  1.63423151e-01f, 9.56726149e-02f, -3.80701274e-01f, -5.51616959e-02f, -1.03205957e-01f, -1.72693744e-01f, 1.59648582e-01f, -1.94380675e-02f, -4.92466688e-02f, 4.10775431e-02f,
  7.51765147e-02f, -3.70587796e-01f, -1.05814651e-01f, -2.44162485e-01f, 3.92291754e-01f, -3.67760301e-01f, 8.28249156e-02f, 3.61557424e-01f, -2.27600232e-01f, 2.95708086e-02f,
  3.05551529e-01f, 3.23426664e-01f, -2.70499498e-01f, 5.03404319e-01f, -9.55563411e-02f, 2.76052952e-03f, -1.28106534e-01f, -1.78535238e-01f, -1.39769584e-01f, 4.81198542e-02f,
  -3.47628072e-02f, 2.28827611e-01f, -6.77566454e-02f, -4.06599194e-02f, 1.98553100e-01f, 1.58943072e-01f, 4.17018123e-02f, -4.89607692e-01f, -2.01490670e-01f, 1.18098278e-02f,
  9.81844291e-02f, -1.09867506e-01f, -1.30323753e-01f, 6.32262588e-01f, -6.17957234e-01f, -5.03388643e-01f, 1.93251356e-01f, 7.43963569e-02f, -3.67519408e-01f, -1.02955244e-01f,
  1.06671765e-01f, -7.45078400e-02f, -8.09959471e-02f, 4.16737399e-04f, 6.04807027e-02f, -1.02048613e-01f, -3.57430160e-01f, 1.53306812e-01f, 2.16069240e-02f, 1.47264926e-02f,
  2.14506849e-03f, 1.14240810e-01f, 2.03129262e-01f, 1.50612503e-01f, 2.85510421e-01f, 2.15491299e-02f, 3.33343893e-01f, 1.14638984e-01f, -1.05205223e-01f, 8.31419900e-02f,
  -1.75756440e-01f, -4.14425246e-02f, -2.03170538e-01f, -3.52062076e-01f, 1.97672904e-01f, 1.14244863e-01f, -2.61987913e-02f, 3.92429501e-01f, -1.04516596e-01f, 1.71107560e-01f,
  2.03079730e-01f, -1.37859941e-01f, -3.50528061e-02f, 1.44225031e-01f, 2.16430694e-01f, 4.47436154e-01f, 3.12900953e-02f, 1.97253525e-01f, 1.31703109e-01f, -2.33521327e-01f,
  1.13207230e-03f, -1.49621338e-01f, 2.76874602e-01f, -9.64124203e-02f, -2.08160251e-01f, -1.22581631e-01f, -1.04409687e-01f, 1.24358553e-02f, 3.86916450e-03f, 1.88941315e-01f,
  -2.95984335e-02f, -2.08747461e-01f, 3.13407667e-02f, -8.48972723e-02f, -1.82705358e-01f, 1.14837736e-01f, 1.97947189e-01f, 5.15564144e-01f, 1.64230138e-01f, -4.27260965e-01f,
  3.99236344e-02f, -7.49588907e-02f, 1.54168606e-01f, -2.38839030e-01f, -5.95972277e-02f, 1.15184121e-01f, 6.39991388e-02f, -1.12305567e-01f, -1.48453265e-01f, -3.00360471e-03f,
  8.66446197e-02f, 2.80326784e-01f, 3.33468676e-01f, 6.14506006e-02f, 4.50390540e-02f, 4.49628919e-01f, 1.66206643e-01f, 1.86504692e-01f, 1.77304268e-01f, 2.72735506e-01f,
  1.07433096e-01f, 2.63190418e-01f, -3.06351334e-01f, -6.55013472e-02f, 7.14127123e-02f, -2.74280101e-01f, 8.95552859e-02f, 8.46512914e-02f, -3.30236822e-01f, 2.97480971e-01f,
  1.39460981e-01f, 7.55299851e-02f, -3.96487296e-01f, 9.55451280e-02f, -2.58371562e-01f, -3.23124230e-01f, -2.42737740e-01f, -1.13422900e-01f, -2.25778043e-01f, 2.96124630e-02f,
  3.58625203e-01f, -1.84197932e-01f, -2.01491773e-01f, -1.48832694e-01f, -9.38738286e-02f, 1.53511465e-02f, 4.52757388e-01f, 5.61870029e-03f, 1.25271216e-01f, -1.57492712e-01f,
  1.50183216e-01f, -2.57734001e-01f, -7.90224448e-02f, -1.85208753e-01f, -1.42817736e-01f, 3.10628831e-01f, -1.69266224e-01f, -1.09651648e-01f, -1.38431981e-01f, -8.61073807e-02f,
  -1.23877257e-01f, -1.15939818e-01f, 4.08192754e-01f, 1.04948759e-01f, -2.26531029e-02f, -6.79403394e-02f, 2.71861494e-01f, 4.33281332e-01f, -1.40811920e-01f, 1.14271455e-01f,
  -2.40013197e-01f, 8.72512013e-02f, 3.06415148e-02f, 1.23359315e-01f, -4.69157249e-01f, -2.12815389e-01f, -2.44792655e-01f, 1.99036539e-01f, 7.76625499e-02f, -4.58488345e-01f,
  -2.78314769e-01f, -1.91267878e-01f, 1.68058887e-01f, -1.46787435e-01f, -2.60250241e-01f, -2.16474369e-01f, -6.38036728e-02f, 2.30737627e-01f, -3.20917994e-01f, 1.23140208e-01f,
  -1.21162169e-01f, -5.10910094e-01f, -1.99963450e-01f, 3.46833110e-01f, 9.02864784e-02f, 2.03039557e-01f, -2.37150371e-01f, 1.66015029e-01f, 4.97350469e-02f, -7.68001080e-02f,
  -4.04968932e-02f, 3.96709070e-02f, 2.48838235e-02f, -3.29910964e-01f, 6.06988370e-01f, -3.03606600e-01f, 1.40806258e-01f, -1.04835577e-01f, -1.70050889e-01f, 4.39102620e-01f,
  -1.57440946e-01f, -3.14999893e-02f, -1.44978046e-01f, -1.64691418e-01f, -9.51957554e-02f, 1.68965772e-01f, -3.28955054e-02f, -1.68510228e-01f, 4.79871370e-02f, 1.29967824e-01f,
  3.54054958e-01f, 2.18559563e-01f, -1.36830121e-01f, -2.69773453e-01f, 2.39976384e-02f, -2.79128194e-01f, 1.31241381e-01f, -1.43925101e-01f, 2.01513879e-02f, 1.96234614e-01f,
  2.21364096e-01f, 5.08903205e-01f, 1.05214469e-01f, 9.72905084e-02f, 5.95789328e-02f, 1.83098733e-01f, -6.79511353e-02f, 2.97161918e-02f, 3.28176260e-01f, -1.56825185e-02f,
  6.02650233e-02f, -3.20043147e-01f, 1.36510193e-01f, -2.08476022e-01f, 3.74654904e-02f, -1.18756637e-01f, -2.47666594e-02f, 6.21210672e-02f, -5.22123687e-02f, 6.01519644e-02f,
  3.58883083e-01f, -1.04709134e-01f, -1.36767104e-01f, -1.06267087e-01f, 8.35187435e-02f, 2.66987264e-01f, 3.05567294e-01f, 2.13059872e-01f, 5.21044433e-01f, -2.25520786e-02f,
  -3.78203988e-02f, 2.01747224e-01f, 8.17382336e-02f, 2.61602014e-01f, -3.58464047e-02f, 2.49698669e-01f, 1.44456148e-01f, 2.01634422e-01f, -3.98256034e-01f, 3.53559136e-01f,
  2.99127065e-02f, -1.02740444e-01f, -1.99551620e-02f, -1.78465813e-01f, 3.06238122e-02f, 5.50763384e-02f, 5.54924786e-01f, 2.41549194e-01f, -1.33785173e-01f, 1.02923356e-01f,
  7.69604370e-02f, -7.59729892e-02f, -1.18209481e-01f, -1.95384204e-01f, -8.81089270e-02f, 7.16786981e-02f, 2.54130345e-02f, 3.43480647e-01f, 2.27597937e-01f, -5.78009225e-02f,
  -1.74428299e-01f, -4.43213940e-01f, 2.08823949e-01f, 5.71781509e-02f, -3.60954851e-01f, -2.32473403e-01f, 1.32805824e-01f, -9.92015451e-02f, 3.32630217e-01f, 9.80042219e-02f,
  -1.21638766e-02f, -1.67361908e-02f, 2.78599590e-01f, 1.74538102e-02f, -3.30236614e-01f, -7.56408125e-02f, -4.11754996e-02f, -2.86296099e-01f, 1.00859612e-01f, -6.00672886e-02f,
  -3.61410588e-01f, -1.11271515e-01f, -1.50621593e-01f, 5.70097081e-02f, 5.22888958e-01f, -3.56200747e-02f, 2.17574820e-01f, 1.22530222e-01f, 1.97673142e-01f, 3.96601349e-01f,
  2.08406940e-01f, -3.26492071e-01f, -3.52425545e-01f, -2.87873119e-01f, 2.70418763e-01f, -1.19963810e-01f, -1.91020533e-01f, 2.33312137e-02f, 3.72581393e-01f, -1.08890943e-01f,
  -2.07371876e-01f, -2.01408640e-01f, -1.11510992e-01f, -3.07784140e-01f, -5.63322455e-02f, 2.23960385e-01f, -7.38945305e-02f, -8.64634663e-02f, -2.45683238e-01f, 1.43280312e-01f,
  -9.06273723e-02f, -1.43719211e-01f, 1.41069546e-01f, -7.36724511e-02f, -4.92770262e-02f, 6.09706305e-02f, 1.32581696e-01f, 5.89860566e-02f, -1.32008627e-01f, -1.38261229e-01f,
  2.10249126e-01f, 1.13305949e-01f, 1.67383871e-03f, -2.54829317e-01f, -4.69743013e-01f, 8.86747479e-01f, 6.36577308e-02f, -7.17452448e-03f, -2.01781660e-01f, -2.07719162e-01f,
  -1.32258296e-01f, -2.02607131e-03f, 1.97058935e-02f, 1.55882567e-01f, -2.47342288e-02f, 1.26921624e-01f, 1.34451725e-02f, 2.14888416e-02f, -3.63869965e-01f, -9.88332406e-02f,
  4.11232747e-02f, -1.44786745e-01f, -1.67959899e-01f, -1.81476146e-01f, -3.98955345e-01f, -2.75761485e-01f, -4.00742233e-01f, -4.51410264e-01f, 2.36728359e-02f, 1.73506990e-01f,
  -2.67256290e-01f, -3.50436985e-01f, 2.52311498e-01f, -3.52589488e-01f, -3.82469594e-01f, 3.74817461e-01f, 5.32006681e-01f, 1.89903438e-01f, -2.07767680e-01f, -1.45426849e-02f,
  2.90808920e-02f, -2.85520583e-01f, -2.83436269e-01f, 4.72147167e-01f, -2.25500122e-01f, 2.66966969e-01f, -8.74653459e-02f, 1.39347315e-01f, 1.07391611e-01f, -8.16407874e-02f,
  1.88315455e-02f, -2.06323341e-01f, 2.98297673e-01f, 4.65145260e-02f, 6.78766519e-03f, 1.02307513e-01f, 9.51688886e-02f, -7.97532350e-02f, -8.75192359e-02f, 8.64410847e-02f,
  -1.43734932e-01f, -5.27959391e-02f, -1.44935444e-01f, -2.11797911e-03f, -7.86283761e-02f, -5.01985848e-03f, 5.01482002e-02f, -3.45183074e-01f, 5.26232481e-01f, -5.93398929e-01f,
  -9.53015164e-02f, 1.68626636e-01f, 9.68605578e-02f, 1.13727547e-01f, 4.48080618e-03f, -4.19921577e-02f, 2.00284943e-01f, -1.88614503e-02f, -4.36310992e-02f, 6.40802905e-02f,
  -1.73750117e-01f, -2.25623474e-02f, -5.91293797e-02f, 2.75017977e-01f, 2.17952088e-01f, 2.94374764e-01f, -1.17072919e-02f, -2.79677898e-01f, -3.16173941e-01f, 1.74085442e-02f,
  -2.04797536e-01f, 1.08069196e-01f, -2.79827595e-01f, -3.13683271e-01f, 3.09887975e-01f, 2.10206449e-01f, -3.06575239e-01f, 1.55710071e-01f, 3.72027218e-01f, -4.85580772e-01f,
  -5.68041325e-01f, -2.89038181e-01f, 4.52542633e-01f, -4.51877356e-01f, 1.16500974e-01f, 4.09241438e-01f, -8.10766295e-02f, -2.90413141e-01f, 2.76433136e-02f, -3.96581404e-02f,
  -7.81523511e-02f, -1.67747527e-01f, -8.63752812e-02f, 2.36335009e-01f, -7.53970891e-02f, -1.05250381e-01f, -2.44096264e-01f, 1.99432764e-02f, -1.55175731e-01f, -1.09641463e-01f,
  5.96346147e-02f, 1.89291000e-01f, -8.89713243e-02f, 6.71755150e-02f, 4.12862748e-02f, 1.38432970e-02f, 9.86018032e-02f, -1.36204630e-01f, 8.10501724e-02f, -1.23953305e-01f,
  5.16924560e-02f, 5.10740399e-01f, -2.15450764e-01f, 3.99095237e-01f, -2.05978821e-03f, 1.06925465e-01f, 1.64486393e-01f, -7.23522976e-02f, -4.39904928e-02f, 2.65092582e-01f,
  -2.40247265e-01f, -2.49886140e-02f, -9.50666815e-02f, -2.22287625e-01f, 1.42373458e-01f, 9.34240595e-02f, 3.16982478e-01f, 2.56542843e-02f, 1.68422788e-01f, 1.42408550e-01f,
  3.12802583e-01f, 1.65087610e-01f, 3.24743956e-01f, 1.79982558e-01f, 3.25735122e-01f, 1.03321210e-01f, -6.23677298e-02f, 3.62590313e-01f, -3.82591747e-02f, -2.85452068e-01f,
  -2.95798957e-01f, -4.38508421e-01f, 2.20354080e-01f, -7.28032961e-02f, -1.04420543e-01f, 1.38699010e-01f, 2.12295592e-01f, -2.56655335e-01f, 6.59705698e-02f, 3.20661455e-01f,
  -1.16944790e-01f, 6.14552982e-02f, 1.73784867e-01f, -2.47950956e-01f, 3.27690393e-01f, -2.61213243e-01f, 2.60904408e-03f, -7.52974674e-03f, -9.23880711e-02f, -2.00906899e-02f,
  4.33951467e-01f, -3.20832878e-02f, -1.55899018e-01f, -3.87253352e-02f, 1.23877913e-01f, -1.50506450e-02f, -1.47043929e-01f, -2.34645158e-01f, -3.55632976e-02f, 2.35904977e-02f,
  1.41918734e-01f, 8.72778520e-02f, 2.25973427e-02f, -1.28357187e-01f, -2.47329190e-01f, 1.89760596e-01f, -4.89552259e-01f, 5.32415390e-01f, 9.70448181e-02f, 2.35830080e-02f,
  -3.33199382e-01f, 4.14451987e-01f, 5.48031107e-02f, 3.13132927e-02f, 1.74505524e-02f, -8.95501524e-02f, -1.42875463e-01f, 1.05810091e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.71279402e-02f, -3.74979228e-02f, -1.95728764e-01f, -1.28443807e-01f, -5.35334088e-02f, 1.06567770e-01f, -6.59871399e-02f, -1.64959487e-02f, 2.42760628e-02f, -7.62964636e-02f,
  1.72309414e-01f, 2.24517137e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    