/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.05144948e-02f, 8.85160938e-02f, -2.46080801e-01f, -5.50394841e-02f, -7.11340681e-02f, 3.96725023e-03f, -8.28007758e-02f, 1.30200591e-02f, -1.06139921e-01f, 2.63421327e-01f,
  3.86023521e-02f, -1.10332407e-01f, -4.45044674e-02f, 8.84827226e-02f, 2.69527566e-02f, -5.44222370e-02f, 1.35479122e-01f, 2.73859650e-02f, -1.28633045e-02f, 2.87698209e-02f,
  -1.14891462e-01f, 2.50360042e-01f, -1.59386739e-01f, 6.73867613e-02f, -1.33995935e-01f, -8.77946913e-02f, 2.20333084e-01f, -6.03495464e-02f, 2.52264030e-02f, 5.36387749e-02f,
  1.24062665e-01f, -8.38238280e-03f, -1.02215804e-01f, -8.95154998e-02f, 6.03957586e-02f, 1.93842724e-02f, -3.55945639e-02f, -8.27202946e-02f, -6.02572225e-02f, -5.92882335e-02f,
  2.34903069e-03f, -5.92030622e-02f, -6.59562722e-02f, -1.31926835e-02f, -1.00604944e-01f, -5.28875086e-03f, -6.11022227e-02f, -2.21357942e-02f, -5.06431721e-02f, -1.08830901e-02f,
  -9.14220065e-02f, -5.83359823e-02f, -4.62165140e-02f, 8.55629891e-03f, -8.36257562e-02f, 3.80945541e-02f, 4.84005734e-02f, -3.08921449e-02f, 2.39664055e-02f, -3.35610509e-02f,
  -6.29267842e-02f, 7.36788735e-02f, -3.81358259e-04f, 4.18061055e-02f, -1.11929001e-03f, 4.11685593e-02f, -1.21842222e-02f, 6.02744631e-02f, -1.91893168e-02f, 6.59309477e-02f,
  7.52860084e-02f, -2.13159639e-02f, -3.08554266e-02f, 4.50594053e-02f, 9.45452154e-02f, -2.68806685e-02f, 4.13312623e-03f, 9.56521928e-03f, 4.45395149e-03f, -6.90500252e-03f,
  -2.20635962e-02f, -3.75451557e-02f, -1.14747770e-02f, 2.79629063e-02f, 2.84886025e-02f, 7.97744840e-04f, 5.77773228e-02f, -2.96577066e-02f, -2.86851265e-03f, -1.49796540e-02f,
  1.38656467e-01f, 1.93522558e-01f, 8.49901810e-02f, 3.03696487e-02f, 3.26549858e-02f, 1.35386307e-02f, 5.23419119e-02f, -8.85429457e-02f, 1.45158991e-02f, -5.54274302e-03f,
  -2.37470139e-02f, -9.12826508e-03f, 2.58698612e-02f, 1.55247394e-02f, 4.57828343e-02f, 5.31817637e-02f, 9.71719474e-02f, 5.40169328e-02f, 6.66860417e-02f, 5.70391444e-03f,
  1.72310118e-02f, 6.40489459e-02f, -2.63901334e-02f, 5.48354834e-02f, 4.87227030e-02f, -1.62168685e-02f, -6.79277852e-02f, 2.32149847e-02f, 2.52664071e-02f, 5.66304941e-03f,
  -2.01938376e-01f, -5.93573833e-03f, -2.42164612e-01f, -1.03991598e-01f, -2.21371092e-02f, -2.09727183e-01f, -2.21332699e-01f, 1.62008051e-02f, -1.43756405e-01f, -5.94305666e-03f,
  1.20727614e-01f, -1.15056105e-01f, 1.04340591e-01f, 1.51635252e-03f, -2.04484895e-01f, 3.18606128e-03f, -1.24493139e-02f, 1.13078917e-03f, 1.03473790e-01f, 6.61425442e-02f,
  -2.12020408e-02f, 1.17345348e-01f, 3.37374881e-02f, 1.46920830e-01f, 1.30713731e-02f, 5.32937311e-02f, 1.47406727e-01f, 9.49448496e-02f, 5.29146418e-02f, 3.69610339e-02f,
  -6.50751218e-02f, 3.05597149e-02f, -7.55186826e-02f, -2.61248613e-04f, 7.61117786e-02f, -3.21517065e-02f, -1.26005774e-02f, -5.93545772e-02f, -2.97908448e-02f, 6.04276881e-02f,
  -4.39559445e-02f, -3.11120134e-03f, -3.83364945e-03f, 4.15070914e-02f, -1.19597569e-01f, -7.23343119e-02f, -2.73330063e-02f, -6.59115389e-02f, -9.09990445e-03f, -5.93807474e-02f,
  1.40905250e-02f, -1.13416739e-01f, 3.18332985e-02f, -2.74804048e-02f, 5.04459701e-02f, -4.98242825e-02f, -1.26318872e-01f, -4.94667403e-02f, -5.85795986e-03f, 1.54909873e-02f,
  -1.55715989e-02f, -6.06449991e-02f, 2.06471402e-02f, -7.87343737e-03f, 4.89987321e-02f, -2.47167461e-02f, 1.96891446e-02f, 6.76679611e-02f, -5.11498488e-02f, 1.86287835e-02f,
  4.97849807e-02f, 1.46961189e-03f, 5.35518280e-04f, -5.24707027e-02f, 3.55978943e-02f, 8.67068651e-04f, -1.71577244e-03f, 1.62685513e-02f, -7.87196010e-02f, -4.42032516e-02f,
  6.59990385e-02f, -5.96171841e-02f, -1.99568793e-02f, -4.80801500e-02f, -6.98325261e-02f, 6.16786722e-03f, 3.77309211e-02f, 1.15864398e-02f, 2.98374761e-02f, 1.11922892e-02f,
  3.33099999e-02f, 2.29662701e-01f, 2.31559463e-02f, -4.30154940e-03f, -3.78176160e-02f, -2.68080179e-02f, -9.03563201e-02f, 7.56652355e-02f, -7.27876797e-02f, -5.78235742e-03f,
  9.40396637e-02f, 4.64147553e-02f, 3.09664523e-03f, 2.14929581e-02f, 5.72484918e-03f, -4.07953523e-02f, 5.19661084e-02f, 6.99888309e-03f, 5.13449423e-02f, 1.14574004e-02f,
  -5.02698720e-02f, 5.93077317e-02f, -5.33991382e-02f, 3.16079482e-02f, 2.65474599e-02f, -6.90793339e-03f, -4.24103960e-02f, -3.17150205e-02f, 5.75322583e-02f, -3.05872746e-02f,
  2.51112934e-02f, -2.47912839e-01f, -1.78632438e-01f, 7.51410145e-03f, -7.44130760e-02f, -1.05414325e-02f, 7.54561052e-02f, -2.41933137e-01f, -1.95735008e-01f, -1.84726566e-02f,
  5.61719872e-02f, 3.12583968e-02f, -3.53683829e-02f, 3.96123454e-02f, 2.70184487e-01f, 3.68283950e-02f, 1.31318837e-01f, 8.10909867e-02f, -5.87318800e-02f, -3.01296497e-03f,
  2.37554517e-02f, 7.28482530e-02f, 7.75964409e-02f, -2.54414994e-02f, -4.95314226e-02f, -1.24207074e-02f, 5.62942661e-02f, -7.98932910e-02f, 8.57546404e-02f, 1.69522390e-01f,
  9.45213959e-02f, -4.23837341e-02f, 8.05118063e-04f, 3.28787491e-02f, -1.46962656e-02f, 1.69056188e-02f, 1.60816181e-02f, 5.45595475e-02f, 7.16716126e-02f, -1.28456010e-02f,
  5.64023778e-02f, -3.18686664e-02f, -5.85445464e-02f, 4.69113737e-02f, -3.42056639e-02f, 5.51736867e-03f, -7.49376938e-02f, -8.10842845e-04f, -1.48778073e-02f, -1.30625805e-02f,
  1.10154599e-03f, -9.68462750e-02f, -3.01615894e-02f, -1.83116645e-02f, -3.22691239e-02f, -5.24099581e-02f, 8.42150487e-03f, -1.47740105e-02f, -5.34871444e-02f, -1.18614370e-02f,
  -4.01608236e-02f, -5.79855554e-02f, -2.27936879e-02f, -3.59196891e-03f, 9.55904555e-03f, -2.70739812e-02f, -1.71033423e-02f, -1.16181439e-02f, -1.07887955e-02f, -6.30420893e-02f,
  -1.15036564e-02f, 7.93298241e-03f, -7.32736755e-03f, -8.03094059e-02f, 5.27673922e-02f, -3.46974060e-02f, -3.97761498e-04f, -6.66610524e-02f, -1.92994718e-02f, -2.35869754e-02f,
  -2.05896050e-02f, -5.04454132e-04f, 8.26625095e-04f, -2.46390663e-02f, -6.94291294e-02f, 1.82837509e-02f, -5.52540869e-02f, 4.42622490e-02f, -4.38091680e-02f, 3.68999057e-02f,
  1.34201217e-02f, -8.89597833e-02f, -5.81781054e-03f, -1.46921342e-02f, 4.39974554e-02f, 8.29143748e-02f, -5.25067840e-03f, -1.15492105e-01f, 4.26453538e-04f, -2.05398835e-02f,
  -7.38539174e-02f, -1.21741751e-02f, -7.45098367e-02f, 3.34598473e-03f, 6.45686761e-02f, 2.02933941e-02f, 3.84294465e-02f, 1.27058395e-03f, 5.57135930e-03f, 1.93556724e-03f,
  5.56206852e-02f, -3.31017151e-02f, 2.13336833e-02f, 3.07492763e-02f, -6.16679993e-03f, 6.53519668e-03f, -4.69746161e-03f, -7.88823981e-03f, 8.74798819e-02f, 3.30508798e-02f,
  -8.21286216e-02f, 9.97960381e-03f, -7.86662661e-03f, -1.27276048e-01f, -1.49962738e-01f, 4.23082002e-02f, -1.54127032e-02f, -1.14019819e-01f, 2.38900278e-02f, 1.60478324e-01f,
  7.04554394e-02f, 5.72966300e-02f, 8.07094947e-02f, 1.39129370e-01f, -3.63320448e-02f, 9.51632187e-02f, -6.60288632e-02f, -3.92394327e-02f, -7.83065632e-02f, -1.34280980e-01f,
  -5.41164391e-02f, -5.29648028e-02f, -1.92993565e-03f, -6.84477612e-02f, -2.40381975e-02f, -2.29072105e-02f, 7.06433430e-02f, 3.79342549e-02f, -5.62427491e-02f, 1.01557985e-01f,
  6.56606704e-02f, -1.17212646e-01f, -5.22044748e-02f, 2.80832686e-02f, -3.98149155e-02f, -1.68448370e-02f, 7.62049407e-02f, 1.20927736e-01f, 8.82269740e-02f, 4.68323715e-02f,
  -2.02053506e-02f, -8.85308981e-02f, -1.96784716e-02f, 2.98571512e-02f, 7.98640773e-02f, -2.98032295e-02f, -1.25832886e-01f, -2.77898293e-02f, -5.63554615e-02f, -1.52669800e-02f,
  -1.12078767e-02f, 3.07984632e-02f, -1.81447100e-02f, 8.65880474e-02f, -6.08834773e-02f, -1.21466881e-02f, -5.42392656e-02f, -6.65621683e-02f, 6.50666133e-02f, 5.05822748e-02f,
  -9.13447440e-02f, -1.90302264e-02f, 7.20474496e-03f, -5.83057897e-03f, -1.01897372e-02f, 2.12890636e-02f, 5.10154143e-02f, -5.34268608e-03f, 8.31356943e-02f, 9.51008312e-03f,
  -1.12614855e-02f, 3.20790932e-02f, -1.30939437e-02f, -6.98845610e-02f, 5.93085997e-02f, -7.85232335e-02f, 8.79176557e-02f, 8.05256292e-02f, -5.39268628e-02f, 7.74770975e-02f,
  1.31580113e-02f, 4.04062010e-02f, -1.62670761e-02f, 1.71982888e-02f, 1.21817002e-02f, 1.75808314e-02f, -5.23512810e-03f, 4.22618575e-02f, 8.09080675e-02f, -6.75180405e-02f,
  1.62796766e-01f, 8.89520720e-02f, -3.39638218e-02f, 6.56147301e-02f, 7.56180584e-02f, 1.28766954e-01f, 9.03489813e-02f, -2.63751894e-02f, 5.96537702e-02f, 5.25532151e-03f,
  -3.23606320e-02f, 6.17900044e-02f, 4.97066677e-02f, -1.07030980e-02f, -1.44414930e-03f, 5.96086048e-02f, 5.86806387e-02f, 5.18167689e-02f, 8.95044282e-02f, 7.62389228e-02f,
  1.93958431e-02f, 6.08580038e-02f, -3.38150561e-02f, -7.13029280e-02f, -2.89256275e-02f, -2.31980104e-02f, -4.67807762e-02f, 5.42720407e-02f, -6.47044033e-02f, -2.33868193e-02f,
  -1.70384318e-01f, 6.62917346e-02f, -8.89005065e-02f, -1.97851747e-01f, -9.66971964e-02f, 1.55477688e-01f, 1.23526603e-01f, -9.35404673e-02f, -1.21395327e-02f, 1.76904798e-01f,
  4.04687114e-02f, -1.17346182e-01f, 1.57497466e-01f, -4.33430187e-02f, -1.33790702e-01f, 1.22137211e-01f, -5.48623167e-02f, -4.81351428e-02f, -4.39756475e-02f, -1.27104074e-01f,
  -1.67173460e-01f, -4.09817547e-02f, -8.26086998e-02f, -2.56400034e-02f, -1.42041698e-01f, -1.06481992e-01f, -3.67363654e-02f, 4.38079871e-02f, 2.30554994e-02f, 7.31040314e-02f,
  1.36466905e-01f, -4.23919633e-02f, -4.05144431e-02f, 9.73487273e-02f, 1.28099683e-03f, 6.22162083e-03f, 8.73817280e-02f, 6.44701272e-02f, 4.09054942e-02f, 3.83549258e-02f,
  2.37777773e-02f, -4.69309725e-02f, 4.39958237e-02f, 7.25173876e-02f, 3.21047939e-02f, -2.83041317e-02f, 1.20499777e-02f, -4.62621562e-02f, 6.79128245e-02f, 3.21786180e-02f,
  3.11090574e-02f, 1.39114326e-02f, 3.13857235e-02f, 1.01331942e-01f, 3.95316295e-02f, -3.31161618e-02f, 5.95866218e-02f, 8.99428725e-02f, -6.57679513e-02f, -2.78294478e-02f,
  6.92379549e-02f, -4.27617766e-02f, -3.86092253e-02f, -6.89319000e-02f, 6.14547357e-03f, -9.31586325e-02f, 4.56243120e-02f, 6.66380301e-02f, -1.37561411e-02f, 1.96465552e-02f,
  -2.36554164e-02f, -3.17426659e-02f, 2.84230453e-03f, 2.69566737e-02f, -8.23331922e-02f, 4.58501885e-03f, -3.92354317e-02f, -1.50795151e-02f, -6.65127411e-02f, 2.89863814e-02f,
  2.86528617e-02f, -4.92318161e-02f, -7.48951435e-02f, -7.96691340e-04f, 1.27671938e-02f, -8.20371956e-02f, 3.40856090e-02f, 1.18193226e-02f, 4.69397344e-02f, 8.26378912e-03f,
  6.78399205e-03f, 6.58131093e-02f, -1.60415433e-02f, 4.37421314e-02f, 4.88602482e-02f, 1.05340676e-02f, -2.46472713e-02f, -7.41833150e-02f, 7.82651454e-03f, -7.12416843e-02f,
  3.67236733e-02f, -4.86746058e-02f, 2.09683850e-02f, -1.48192784e-02f, 5.97466948e-03f, 4.92461435e-02f, -2.04681815e-03f, 3.18691097e-02f, -5.12956409e-03f, -8.69842246e-03f,
  8.93673114e-03f, 5.64669892e-02f, -5.50135449e-02f, 1.83108449e-02f, -2.36796942e-02f, 2.28224769e-02f, -5.43393614e-03f, -4.55528796e-02f, 8.51508975e-02f, 1.75894815e-02f,
  -2.22728997e-02f, 1.25988960e-01f, 1.11770734e-01f, -5.24220094e-02f, -1.91892996e-01f, 7.40105957e-02f, 1.51374444e-01f, -7.60047883e-02f, 1.53860524e-01f, -3.65902856e-02f,
  -1.02648951e-01f, 2.65503917e-02f, 2.84665488e-02f, -5.83056808e-02f, -4.07346413e-02f, 7.45201577e-03f, 4.68491716e-03f, 8.66298079e-02f, 1.48327261e-01f, 6.23101257e-02f,
  2.52024252e-02f, -8.81354064e-02f, -1.70308203e-02f, -1.25158489e-01f, -5.14158159e-02f, -1.02317140e-01f, -2.12033659e-01f, -9.09750909e-02f, -1.56766728e-01f, -3.73102874e-02f,
  5.13361283e-02f, 6.42495230e-02f, -1.31878443e-03f, 4.88732420e-02f, -1.12007242e-02f, -7.93111995e-02f, 5.88974208e-02f, -7.21478835e-02f, -1.10296095e-02f, 7.50087202e-02f,
  -1.23444619e-02f, 4.06174175e-02f, 1.44406371e-02f, -3.87889557e-02f, 5.23693375e-02f, 1.45282112e-02f, -1.88311189e-02f, -5.16964048e-02f, -1.04315961e-02f, 4.25570756e-02f,
  6.87686056e-02f, 2.08031852e-02f, 4.86679561e-02f, -4.23950776e-02f, -4.72024903e-02f, -5.37238605e-02f, -8.45665298e-03f, 3.21568288e-02f, 5.45681268e-02f, 1.58561636e-02f,
  -8.08656812e-02f, -2.34779902e-02f, 6.37100860e-02f, -1.98593959e-02f, 3.31773572e-02f, -3.95185575e-02f, 3.56996618e-02f, -2.44341008e-02f, 4.58283089e-02f, 2.80021932e-02f,
  -1.77527759e-02f, -2.78430954e-02f, -9.42062959e-03f, 5.22697996e-03f, -9.63488221e-02f, -5.06434264e-03f, -5.84284216e-02f, -3.15578021e-02f, -7.31143579e-02f, -4.80141006e-02f,
  -4.87731323e-02f, -1.22362236e-02f, -8.87400433e-02f, -1.26398578e-02f, -2.46413760e-02f, 1.62989572e-02f, -8.30267072e-02f, 1.61021464e-02f, -1.56978648e-02f, 1.17061455e-02f,
  4.25273441e-02f, 3.45558785e-02f, 2.60512084e-02f, 5.85384201e-03f, -1.67432204e-02f, 2.58395709e-02f, 1.97834447e-02f, -4.35241647e-02f, -1.53182317e-02f, 2.19299924e-02f,
  -2.04070434e-02f, -9.24182907e-02f, -4.74324599e-02f, -5.09371806e-04f, -1.37373935e-02f, -1.65422522e-02f, 9.40316822e-03f, -2.68747006e-02f, -1.27555609e-01f, 4.16061562e-03f,
  -3.66557352e-02f, -1.00950204e-01f, -3.34839560e-02f, -5.81707396e-02f, -8.74237120e-02f, -1.00267202e-01f, -1.11990049e-01f, 3.32825212e-03f, 2.20591705e-02f, -3.13835219e-02f,
  1.05275899e-01f, 2.17610914e-02f, 1.33016691e-01f, 1.35191143e-01f, -9.19644013e-02f, 4.23218943e-02f, 4.53760438e-02f, 2.91406345e-02f, 1.36120796e-01f, -4.77217510e-02f,
  -2.56443806e-02f, -1.10439479e-03f, 1.16736032e-01f, -5.27169220e-02f, 3.90352160e-02f, -1.41073987e-02f, -6.11922219e-02f, 9.93919522e-02f, 6.46700412e-02f, 6.54844567e-02f,
  1.39899805e-01f, -2.56130248e-01f, -6.26921654e-02f, -1.51502773e-01f, 1.07494751e-02f, 9.53132212e-02f, -1.44451559e-01f, -4.50415676e-03f, -8.36895406e-02f, -5.20769767e-02f,
  -1.10170133e-01f, -4.43111882e-02f, 3.61748822e-02f, -3.09983380e-02f, -7.86332637e-02f, 2.38630939e-02f, -4.17695530e-02f, -8.25730525e-03f, -2.68766321e-02f, -3.07384562e-02f,
  4.19493653e-02f, -7.72156566e-02f, 5.18475398e-02f, 1.21054612e-01f, 5.88077586e-04f, -1.68163273e-02f, -8.95386413e-02f, -2.87735425e-02f, -2.95734257e-02f, -9.60208010e-03f,
  3.21106650e-02f, 1.37894778e-02f, 2.46649049e-02f, -4.40974571e-02f, 1.46441935e-02f, -9.28357169e-02f, 5.47351092e-02f, -2.05356926e-02f, -1.09170258e-01f, -4.20108661e-02f,
  -6.20093420e-02f, 5.88357151e-02f, 6.69424189e-03f, -4.02941033e-02f, -7.41844028e-02f, 3.24116908e-02f, -1.84093975e-02f, 3.56515683e-02f, -4.08038050e-02f, -1.21254586e-01f,
  -5.41677102e-02f, 3.18033770e-02f, 1.02364901e-03f, 1.42645791e-01f, 6.36844188e-02f, 5.53114787e-02f, -2.54602078e-02f, 9.96834412e-03f, -1.46535458e-02f, 2.63377242e-02f,
  -6.83722869e-02f, 2.89899185e-02f, -9.89813209e-02f, -2.68055722e-02f, -8.08860138e-02f, 3.88140455e-02f, 5.30388765e-02f, 1.32809266e-01f, -1.77241471e-02f, -1.73086207e-02f,
  -1.20972320e-01f, -4.88894284e-02f, -9.26765352e-02f, -6.89528650e-03f, -1.01242766e-01f, -1.97425764e-02f, 2.94152945e-02f, -5.89840813e-03f, -1.80010591e-02f, 7.60322735e-02f,
  5.65264225e-02f, -5.23915254e-02f, -4.27367650e-02f, 9.25018173e-03f, 1.39242727e-02f, 7.88788199e-02f, 1.11359656e-02f, -4.76170555e-02f, -1.26808345e-01f, -1.10194469e-02f,
  6.49466515e-02f, 3.57245607e-03f, -3.59793827e-02f, -5.35307527e-02f, -1.93621255e-02f, 1.60311051e-02f, 2.31541861e-02f, 5.28145358e-02f, 5.80127873e-02f, -2.87098549e-02f,
  -2.13060290e-01f, 1.19931363e-02f, 6.96683228e-02f, -1.01117983e-01f, -5.62047176e-02f, -1.25083566e-01f, -1.88895047e-01f, 4.99360785e-02f, 2.83697993e-03f, 7.89496526e-02f,
  -8.52003321e-02f, 8.06058645e-02f, -2.36345753e-02f, -1.54120401e-01f, -9.33346301e-02f, 1.04088783e-01f, -1.29760355e-01f, -4.34640683e-02f, 1.06583685e-01f, 2.44240602e-03f,
  -8.90627354e-02f, -5.96087910e-02f, -5.52097447e-02f, 6.69877380e-02f, -4.46046405e-02f, 1.86992120e-02f, -8.78617242e-02f, -2.30191741e-02f, 6.76442962e-03f, -5.81731880e-03f,
  -4.16227840e-02f, 7.79139027e-02f, 2.37357263e-02f, -8.36407952e-03f, -1.06073856e-01f, 1.55448066e-02f, -1.55125372e-02f, 6.87901303e-02f, -5.86776473e-02f, -1.76335797e-02f,
  5.47858663e-02f, 6.48685917e-02f, 3.65127847e-02f, -9.33461264e-03f, -3.02575957e-02f, 7.79054984e-02f, -6.07603230e-02f, 1.06702913e-02f, 5.65591641e-02f, 4.47173454e-02f,
  8.86099115e-02f, -4.60241176e-02f, -7.37237260e-02f, 1.00518372e-02f, -7.37690479e-02f, 2.09410209e-02f, -1.06790122e-02f, -4.95360047e-02f, -3.04413904e-02f, -1.76482592e-02f,
  -8.16678703e-02f, -3.91460881e-02f, -5.15696965e-02f, -3.07051130e-02f, -5.92606403e-02f, -5.74772917e-02f, 6.55882806e-03f, -1.22228935e-02f, 4.65988740e-02f, -1.36268288e-02f,
  -2.40037236e-02f, -1.03277108e-02f, -2.74467934e-02f, -1.30244121e-02f, -8.24702382e-02f, -1.51532721e-02f, -5.24223745e-02f, 7.21940696e-02f, -7.31739104e-02f, -9.96630080e-03f,
  3.02070472e-02f, -4.07513715e-02f, 1.82856750e-02f, -3.95029709e-02f, -1.07272272e-03f, 2.13210993e-02f, -1.28699318e-02f, 8.42367485e-02f, -4.93904389e-02f, -6.05002530e-02f,
  5.20798936e-02f, -5.72351040e-03f, 5.23141287e-02f, -2.88552642e-02f, 6.88752756e-02f, -1.34267658e-02f, -4.22088988e-02f, 5.15519194e-02f, -5.72391879e-03f, -3.94982882e-02f,
  -6.32977337e-02f, -5.90711907e-02f, -1.61088444e-02f, 3.37307751e-02f, 4.79035452e-02f, -5.77867366e-02f, -9.81869325e-02f, -5.77700436e-02f, -3.27748768e-02f, 2.73923054e-02f,
  -5.70014156e-02f, -7.33855274e-03f, 9.68690962e-03f, 4.14415672e-02f, 7.65400473e-03f, -2.19905414e-02f, -1.38238920e-02f, -7.20539168e-02f, -6.92652762e-02f, 4.96309511e-02f,
  1.55337225e-03f, 1.16195396e-01f, -1.81666255e-01f, 5.49824275e-02f, -1.02471776e-01f, -2.69547403e-02f, -3.26548964e-02f, -4.28450741e-02f, 1.54017121e-01f, 2.00481787e-01f,
  -3.87424268e-02f, 1.36556420e-02f, 7.54700974e-02f, 1.82030238e-02f, -1.89031318e-01f, 5.97868711e-02f, 4.18901816e-02f, 5.87519296e-02f, -1.38049228e-02f, 9.97047871e-02f,
  5.15316017e-02f, -5.48849478e-02f, -1.93690896e-01f, 4.70835119e-02f, -5.93049191e-02f, 6.02958612e-02f, -7.86901545e-03f, -1.08371943e-01f, -7.45989522e-03f, -1.11446939e-01f,
  8.06013271e-02f, 1.16652243e-01f, -8.47329795e-02f, 2.57901940e-02f, -8.69552493e-02f, -4.48510572e-02f, -4.25802954e-02f, -8.60683843e-02f, -1.31928420e-03f, 3.34984586e-02f,
  -2.06123833e-02f, 1.01127848e-01f, -2.45968718e-02f, 5.66993607e-03f, 8.17625225e-03f, -3.84245440e-03f, -1.18541010e-02f, -5.65423742e-02f, 4.82832231e-02f, -7.50775188e-02f,
  7.22936401e-03f, -6.73912140e-03f, 6.35981038e-02f, -6.30691880e-03f, -1.19707897e-01f, -4.79331836e-02f, -9.26635414e-03f, -8.88935328e-02f, 9.41917952e-03f, 9.49162059e-03f,
  -5.78568242e-02f, -3.49756703e-02f, -2.03725807e-02f, -2.68924311e-02f, -6.83028204e-03f, 2.03661714e-02f, 5.36246784e-02f, 2.79303417e-02f, 3.68113071e-02f, 4.50585876e-03f,
  -4.59585376e-02f, -4.79003713e-02f, 5.28142974e-02f, -2.75078714e-02f, 4.55099232e-02f, 3.56290750e-02f, 3.18330675e-02f, 7.53466934e-02f, -4.57819365e-02f, 2.61077341e-02f,
  1.17656840e-02f, -3.21726203e-02f, 4.04730961e-02f, 5.11511825e-02f, -2.10534390e-02f, -7.20235482e-02f, 2.28938498e-02f, 2.07250603e-02f, -3.19522172e-02f, -8.59553292e-02f,
  2.50999689e-01f, 2.76325971e-01f, 7.29819983e-02f, 6.20828150e-03f, 8.50865319e-02f, -2.87694354e-02f, 4.18829061e-02f, 6.18422441e-02f, 3.50491479e-02f, -2.68227644e-02f,
  -4.42683287e-02f, -3.43606318e-03f, 2.30626538e-02f, -6.10760972e-02f, -1.10838078e-02f, -3.47047970e-02f, 2.98304055e-02f, 8.90396163e-02f, 4.58306484e-02f, -1.54441893e-02f,
  6.35277256e-02f, 1.99826970e-03f, -4.36003096e-02f, 5.07999659e-02f, 5.57878725e-02f, 1.17212962e-02f, 9.40630957e-02f, 2.85385782e-03f, -1.10985218e-02f, 1.43571419e-03f,
  -3.31661403e-01f, -3.24605107e-02f, -2.66755838e-02f, -2.01368019e-01f, 8.52352474e-03f, 9.49854851e-02f, -6.60658479e-02f, -8.52190778e-02f, -4.18263562e-02f, 4.36846316e-02f,
  -5.14799878e-02f, -1.04716927e-01f, 9.03141871e-02f, 6.08430356e-02f, 1.03900544e-02f, 7.90588856e-02f, -8.30359105e-03f, -1.61354290e-03f, -1.86724477e-02f, 2.42585521e-02f,
  -7.14132339e-02f, 2.69534066e-03f, 6.62346184e-03f, 5.84379062e-02f, -2.76292972e-02f, 1.92286039e-03f, -3.61852199e-02f, 1.47867963e-01f, 3.29100639e-02f, -8.68985988e-03f,
  5.89237660e-02f, 6.87160669e-03f, -6.58789724e-02f, 2.81324536e-02f, -1.09241093e-02f, -2.53462754e-02f, -9.51456279e-02f, -6.96205869e-02f, -2.72897235e-03f, 1.97944921e-02f,
  -5.81635162e-03f, -4.14401367e-02f, -2.72641238e-02f, -4.34613377e-02f, -7.06418678e-02f, 2.59552430e-02f, 7.74610788e-02f, -8.53714719e-02f, -1.79199614e-02f, 4.57971543e-02f,
  -7.23655149e-02f, -2.98143309e-02f, 1.43465567e-02f, -1.70296468e-02f, -1.23020545e-01f, -1.49381217e-02f, 2.21403819e-02f, 4.88860607e-02f, 6.49902374e-02f, 1.91150513e-02f,
  7.03989044e-02f, 2.03536954e-02f, 1.18505852e-02f, 5.58036603e-02f, -2.49459147e-02f, -1.88123144e-03f, -1.72007438e-02f, 3.05798799e-02f, -8.73796344e-02f, 1.80408079e-02f,
  3.14178281e-02f, 4.22303053e-03f, 3.38874795e-02f, 1.22870244e-02f, 2.90089147e-03f, -6.59180433e-02f, 6.89437380e-03f, -4.57875570e-03f, -4.93220463e-02f, -5.39535992e-02f,
  3.33237089e-02f, 3.68785262e-02f, 5.49144559e-02f, 2.84064654e-02f, -3.70444842e-02f, 4.12473604e-02f, -5.05318418e-02f, 7.53372982e-02f, 7.08339587e-02f, 1.68927610e-02f,
  1.36640266e-01f, 1.02879144e-01f, 2.36067567e-02f, -3.40978354e-02f, 1.29812241e-01f, 4.64704968e-02f, -3.04947104e-02f, 2.62329429e-02f, 1.02459230e-01f, -3.74233648e-02f,
  -6.48042858e-02f, 4.28236388e-02f, -7.89596960e-02f, 1.67731438e-02f, -4.34634648e-02f, 7.12367967e-02f, -2.02985927e-02f, -2.56105996e-04f, -3.47596919e-03f, 2.33438313e-02f,
  2.41809781e-03f, -3.88823040e-02f, -2.00540219e-02f, -3.02956477e-02f, -6.23624250e-02f, 8.43380243e-02f, -2.51082797e-02f, 6.93769427e-03f, -2.24641729e-02f, -5.14764199e-03f,
  -3.98852021e-01f, -6.54142052e-02f, -6.68333024e-02f, -1.44150198e-01f, 3.50448377e-02f, 1.10401839e-01f, -8.20013601e-03f, 4.53974167e-03f, -1.37389600e-01f, 1.03789039e-01f,
  5.98063953e-02f, 1.31516056e-02f, 1.95926726e-02f, -7.13314638e-02f, 5.95044829e-02f, 9.27810445e-02f, -1.05225906e-01f, 3.48179899e-02f, -9.28511173e-02f, -5.23557141e-02f,
  -9.05751809e-02f, 5.51293679e-02f, -5.91723360e-02f, 6.17503934e-02f, -1.06107190e-01f, -4.57449779e-02f, 2.55173985e-02f, 7.75572518e-03f, -7.51176011e-03f, 9.66718197e-02f,
  3.15021584e-03f, -1.66721478e-01f, -5.88599686e-03f, -1.27754480e-01f, -7.60502964e-02f, -4.28768657e-02f, -8.01339969e-02f, 9.08592343e-02f, -1.90033577e-02f, -8.58236402e-02f,
  5.68124913e-02f, 5.54422755e-03f, -1.50925070e-02f, 1.03603443e-03f, 3.20942365e-02f, -5.24972416e-02f, 8.98281187e-02f, 1.11109987e-02f, 3.50463092e-02f, -1.42444819e-02f,
  7.76784718e-02f, 7.75537992e-05f, 8.13485235e-02f, 4.50583659e-02f, 4.91447598e-02f, -2.41831355e-02f, 4.40187827e-02f, 1.29842207e-01f, 3.38192694e-02f, 6.16138466e-02f,
  6.25708848e-02f, 1.57846464e-03f, 1.56536717e-02f, 2.61797197e-02f, -6.56666607e-03f, -3.40779610e-02f, 9.30961147e-02f, -2.00357959e-02f, 2.65795831e-02f, 1.25423782e-02f,
  -5.78341633e-02f, 5.73631488e-02f, -3.69831510e-02f, 4.04573046e-02f, 4.02956419e-02f, -5.19006625e-02f, 3.94593067e-02f, -3.71090556e-03f, -5.78257516e-02f, 3.47345658e-02f,
  -7.20361844e-02f, -4.25373130e-02f, 3.00708949e-03f, -2.36513861e-03f, 2.33399309e-02f, 8.76141787e-02f, 2.13113595e-02f, 1.01633020e-01f, 1.14888391e-02f, -4.40203957e-03f,
  6.07971512e-02f, -2.96853837e-02f, -1.11271255e-01f, -1.09025009e-01f, 8.81943852e-02f, 6.94980696e-02f, -9.62165967e-02f, 5.64437509e-02f, 4.33386452e-02f, 4.60953712e-02f,
  2.71957088e-02f, 3.36566865e-02f, -3.33235934e-02f, -8.76503065e-03f, 7.21218064e-03f, -6.91596232e-03f, -6.84652030e-02f, -2.01273244e-02f, 5.05887084e-02f, 1.23248938e-02f,
  2.10351255e-02f, -5.28286509e-02f, -3.22030450e-04f, -3.31265256e-02f, -2.64653973e-02f, 7.54816607e-02f, -2.63104904e-02f, 6.62022876e-03f, 1.18422620e-02f, 6.05480224e-02f,
  1.65043011e-01f, -1.82425678e-01f, -1.67376846e-01f, -5.25010191e-02f, 8.30202363e-03f, 1.96503121e-02f, 7.51694143e-02f, -8.70217681e-02f, 3.05483609e-01f, -1.07406363e-01f,
  8.04041475e-02f, 9.96166691e-02f, -1.62746310e-02f, 7.91862756e-02f, 2.16813624e-01f, 2.14249253e-01f, 1.63051650e-01f, 1.00329928e-01f, 1.06878430e-01f, -3.99116389e-02f,
  4.44400012e-02f, -1.96088925e-02f, -1.27299517e-01f, -1.72159314e-01f, -1.58557892e-01f, -2.82398045e-01f, -1.12302244e-01f, -1.75612465e-01f, -1.20110996e-01f, 1.90011747e-02f,
  1.74321793e-02f, -3.72675620e-03f, -9.64589119e-02f, -3.02511249e-02f, -5.86141795e-02f, -8.70322958e-02f, -5.72839491e-02f, -3.62941138e-02f, 1.07878745e-02f, -3.05315480e-02f,
  1.79958269e-02f, 4.50557098e-03f, 2.44744681e-02f, -3.73562728e-03f, 3.57698090e-02f, 5.49825989e-02f, 3.59981731e-02f, 4.46192473e-02f, -3.74197997e-02f, 7.05525046e-04f,
  3.11092753e-02f, -9.99580398e-02f, -2.09530760e-02f, 3.15561481e-02f, 2.44127735e-02f, 7.69252032e-02f, -8.86482298e-02f, -4.11817990e-02f, 1.18498690e-02f, -3.30956397e-03f,
  2.12081857e-02f, 1.24084461e-03f, -7.79717881e-03f, 5.97378239e-02f, 7.83602819e-02f, 7.73315132e-03f, 3.54432650e-02f, 2.89192628e-02f, -1.81780010e-02f, -5.39496616e-02f,
  6.75286204e-02f, -9.34696384e-03f, 8.08494985e-02f, 1.80698335e-02f, 4.39966470e-02f, -3.28977928e-02f, -3.99136543e-02f, -7.84382895e-02f, -1.67464241e-02f, -6.76311255e-02f,
  -1.31917289e-02f, 2.75716241e-02f, -7.67245516e-02f, -6.85381368e-02f, 3.51912379e-02f, 2.81671975e-02f, -8.46327990e-02f, -2.83478033e-02f, -2.00340264e-02f, 4.82109673e-02f,
  4.08595391e-02f, 4.23300862e-02f, -5.57378195e-02f, 3.52810062e-02f, 6.33689314e-02f, 5.24944626e-02f, 1.41091608e-02f, 2.47852840e-02f, -1.79773178e-02f, -1.78752486e-02f,
  -2.41070371e-02f, 1.68177839e-02f, 3.08010373e-02f, 2.30172519e-02f, -6.82258233e-02f, 9.64894239e-03f, -9.83699318e-03f, -1.69752557e-02f, -4.36764732e-02f, -7.57567286e-02f,
  -6.43633679e-02f, 6.94638416e-02f, -2.86294743e-02f, -4.60312851e-02f, -2.51609590e-02f, 5.33070834e-03f, 3.08792777e-02f, -3.23727801e-02f, -3.83075438e-02f, 6.53455481e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.80270731e-01f, -3.33007038e-01f, -3.84800620e-02f, 8.30094814e-02f, 1.09077498e-01f, 5.63436151e-02f, -2.79629584e-02f, -6.79898560e-02f, -2.30182245e-01f, -2.41916463e-01f,
  -3.03999037e-02f, 4.30932567e-02f, -9.43528414e-02f, 1.72071174e-01f, 1.72610372e-01f, -8.60366523e-02f, 1.88382566e-01f, 7.25126639e-02f, 9.56972167e-02f, 1.18418550e-02f,
  6.52113333e-02f, 2.11456016e-01f, 1.76924065e-01f, 5.09178750e-02f, 5.22779934e-02f, 2.31784396e-02f, -4.02016006e-02f, -2.67175529e-02f, 1.71874553e-01f, 9.37301740e-02f,
  -6.41724467e-02f, -1.81962699e-01f, 2.16532797e-02f, -4.00970206e-02f, -2.40110271e-02f, 2.09757127e-02f, 1.36220334e-02f, 1.06036365e-01f, 3.81467529e-02f, 1.26955137e-02f,
  -3.47169228e-02f, 3.29009630e-02f, 1.67070910e-01f, 2.43826304e-02f, -7.87637532e-02f, 2.98232684e-04f, -5.33308201e-02f, -7.20772939e-03f, -6.68991134e-02f, -8.66977964e-03f,
  -1.98215209e-02f, 3.44104543e-02f, -6.29977696e-03f, 9.78000015e-02f, -3.08852475e-02f, -3.62166204e-02f, 2.43610274e-02f, 5.81762381e-02f, 5.80501854e-02f, 2.78396774e-02f,
  6.37015551e-02f, -4.26421650e-02f, -5.87630868e-02f, 3.80975008e-02f, -2.25151260e-03f, -9.47472733e-03f, 7.27294907e-02f, 1.13268653e-02f, 5.76972142e-02f, -8.83126259e-02f,
  -3.37186316e-03f, -5.93297966e-02f, -8.46056640e-02f, -5.25889173e-02f, 3.00326571e-02f, 5.77593297e-02f, -9.67981480e-03f, 7.24990591e-02f, -1.18470304e-01f, -3.66634391e-02f,
  6.28786255e-03f, -1.54408207e-02f, 8.21828097e-03f, 2.96899118e-03f, 1.77261909e-03f, -1.98250804e-02f, -6.99348561e-03f, -3.80812660e-02f, 5.41894250e-02f, 7.85704553e-02f,
  -3.25663328e-01f, -2.42011026e-01f, 3.80853377e-02f, 1.82488523e-02f, 2.82477159e-02f, -1.40019476e-01f, 9.53321252e-03f, 3.48181613e-02f, 4.76382324e-04f, -5.72181307e-02f,
  -6.34687766e-02f, -2.03093737e-02f, -1.18412608e-02f, 1.37538090e-02f, 5.37536629e-02f, -3.22931409e-02f, -5.75152002e-02f, -1.42578047e-03f, -7.97470734e-02f, -1.08918492e-02f,
  -3.46433669e-02f, -4.57765609e-02f, -1.77292936e-02f, 8.49275813e-02f, 6.51092157e-02f, -3.16765951e-03f, 1.53380716e-02f, -7.91014545e-03f, 7.66132027e-02f, 1.20410174e-02f,
  -3.47745448e-01f, 6.11223839e-02f, -1.46967664e-01f, -1.68855608e-01f, -2.78430898e-02f, -2.41472259e-01f, -1.45816982e-01f, -8.28730837e-02f, -1.58521850e-02f, 3.94722335e-02f,
  2.59964541e-02f, -9.70480219e-02f, 2.02409238e-01f, -4.20654416e-02f, -4.25815172e-02f, 1.43860161e-01f, -1.00554965e-01f, -1.30015582e-01f, 8.08452293e-02f, -1.54489696e-01f,
  -2.19776691e-03f, 4.04861867e-02f, -5.00314645e-02f, 9.79757458e-02f, -1.97239801e-01f, -2.60589980e-02f, 1.74708385e-02f, 2.55037714e-02f, -6.41729012e-02f, 3.80853511e-04f,
  -1.47487640e-01f, -8.87559354e-02f, -4.18757126e-02f, -1.37587413e-01f, -1.16372906e-01f, 1.09761022e-02f, -9.00262967e-02f, 2.05403287e-02f, 3.67534235e-02f, -7.16507956e-02f,
  3.24244760e-02f, -6.37192801e-02f, -1.06144901e-02f, 1.85395451e-03f, -6.97102472e-02f, -6.23515509e-02f, -9.52059589e-03f, 5.57503197e-03f, 1.39770275e-02f, 7.42259203e-04f,
  -1.06935380e-02f, 5.12509942e-02f, -1.15622558e-01f, 5.71961282e-03f, -8.50929692e-03f, -1.02070756e-02f, 3.99929993e-02f, 3.53476778e-02f, -3.85097414e-02f, 4.88783829e-02f,
  4.12223302e-02f, -1.59914773e-02f, -3.65270302e-02f, 3.19684967e-02f, 3.19859423e-02f, 6.24903217e-02f, -4.52202447e-02f, -3.47882733e-02f, -4.40732948e-02f, 1.78686231e-02f,
  5.90815209e-03f, -2.72600166e-02f, -7.53419101e-02f, 6.07789941e-02f, 2.27207895e-02f, -1.12108728e-02f, 5.60095645e-02f, -5.07795215e-02f, 1.14302754e-01f, -6.32835180e-02f,
  -6.30192086e-02f, -6.20079860e-02f, -5.57213202e-02f, -2.46417522e-02f, -1.22636417e-02f, 6.44324496e-02f, -1.23837776e-02f, -6.90062344e-02f, 2.13300772e-02f, 3.80811766e-02f,
  -3.45389783e-01f, -2.62256891e-01f, 3.32478471e-02f, -7.24994093e-02f, 4.86389622e-02f, -9.84666273e-02f, 4.48494814e-02f, -1.24465577e-01f, -3.23554315e-02f, 2.93580610e-02f,
  -1.45215616e-01f, -7.95159042e-02f, -1.01686396e-01f, 1.21113807e-02f, -1.54532725e-02f, -1.45361284e-02f, 3.08264568e-02f, -6.97565973e-02f, -8.14715624e-02f, -7.42332637e-02f,
  -1.02179624e-01f, 5.33205047e-02f, 1.15399018e-01f, 2.87952106e-02f, 3.09300404e-02f, -7.41264746e-02f, -2.13018563e-02f, -3.54342870e-02f, -2.85148248e-02f, -4.10658419e-02f,
  2.33493060e-01f, 5.10144457e-02f, 2.34561469e-02f, 1.35233194e-01f, 7.41496310e-02f, 1.90280244e-01f, 1.07500434e-01f, 2.03295022e-01f, 1.68286934e-01f, -1.18562654e-01f,
  1.18917890e-01f, 3.09198387e-02f, -7.39708543e-02f, 7.62329204e-03f, 8.77112076e-02f, 3.36910971e-02f, 2.15040565e-01f, 1.59959674e-01f, 9.97052044e-02f, 4.34208056e-03f,
  8.99905413e-02f, 7.87805468e-02f, -6.81395084e-02f, -1.55694231e-01f, 6.17793649e-02f, -1.13311477e-01f, -1.58453509e-01f, 3.32851987e-03f, -1.03124864e-01f, 3.64979543e-02f,
  -1.31070301e-01f, -6.65700820e-04f, 6.85220119e-03f, -4.85893479e-03f, -5.80321178e-02f, -1.52797014e-01f, -3.45428623e-02f, -1.04975283e-01f, -7.10968450e-02f, 7.63813630e-02f,
  -5.73334247e-02f, -2.09539514e-02f, 2.11571045e-02f, 4.14087847e-02f, -2.25688424e-02f, -4.73067276e-02f, -7.67105371e-02f, -3.36372503e-03f, 5.34646921e-02f, 1.34007742e-05f,
  -4.06223871e-02f, -1.12907998e-01f, 1.36426995e-02f, 1.28270276e-02f, -8.26583803e-02f, 7.12215751e-02f, 8.87509137e-02f, -1.01029113e-01f, -6.92045465e-02f, -1.24228178e-02f,
  1.81427389e-01f, -4.36645560e-02f, -8.89017135e-02f, -7.52418414e-02f, -6.08395077e-02f, -5.70849702e-02f, -2.25629937e-03f, -8.16326737e-02f, 1.14455726e-02f, 5.35801612e-02f,
  5.46010733e-02f, 4.93180566e-02f, -5.08537479e-02f, 1.44141093e-02f, 4.59446311e-02f, -8.13805610e-02f, -7.73349330e-02f, -7.79658780e-02f, -5.05456813e-02f, 1.47087937e-02f,
  5.47622554e-02f, 9.48786852e-04f, -6.85845092e-02f, 2.73269787e-02f, -3.80535871e-02f, -5.26376963e-02f, 1.67368464e-02f, 7.91058391e-02f, 8.39184783e-03f, 2.66500097e-02f,
  1.03047967e-01f, 1.45603701e-01f, 2.33291294e-02f, -1.09362029e-01f, -6.84791058e-02f, -1.93411075e-02f, -3.45062502e-02f, -8.11631500e-04f, 5.58454208e-02f, 2.77277790e-02f,
  -9.83363464e-02f, 8.27179551e-02f, -5.87515458e-02f, 1.42867249e-02f, 9.60324481e-02f, 2.37549990e-02f, -6.63421974e-02f, 9.19472128e-02f, 3.80158909e-02f, 5.57798333e-02f,
  -4.72864509e-02f, 3.90095897e-02f, 2.19495520e-02f, -6.50724322e-02f, -3.12637947e-02f, 3.31954286e-02f, 4.82072346e-02f, -1.63458800e-03f, -7.54373968e-02f, 3.19002010e-02f,
  1.14183417e-02f, 2.22770423e-01f, 1.39956966e-01f, 1.38945252e-01f, 1.30484141e-02f, -2.93750584e-01f, -1.71625033e-01f, 1.09041251e-01f, 8.24308116e-03f, -4.66674417e-02f,
  -2.40611075e-03f, 1.82530850e-01f, -4.94150408e-02f, 1.50043517e-01f, -2.13480175e-01f, -9.69276391e-03f, -1.85362101e-01f, -5.27569540e-02f, -2.37406176e-02f, 1.62990019e-01f,
  -9.20214131e-03f, 1.02031663e-01f, -1.50021277e-02f, 5.66755198e-02f, -1.22023383e-02f, 1.13513082e-01f, 1.19141288e-01f, -1.12164272e-02f, 1.42891243e-01f, -5.69525175e-04f,
  -2.19362751e-02f, 1.38342669e-02f, 4.09061424e-02f, 3.63684222e-02f, -3.80809084e-02f, -4.24466841e-02f, -6.51957095e-02f, -4.68626469e-02f, -7.05531090e-02f, 4.07221876e-02f,
  2.12544370e-02f, 1.77008994e-02f, 3.78223136e-02f, 1.09790228e-01f, 7.48908669e-02f, 3.73092256e-02f, 7.15828612e-02f, 3.52326445e-02f, 3.04848719e-02f, -4.38182838e-02f,
  8.09490755e-02f, -1.61880665e-02f, -4.04651091e-02f, 2.24243738e-02f, 3.30896601e-02f, 9.87255126e-02f, -1.16975382e-01f, 7.46577680e-02f, 1.22554908e-02f, -1.71327256e-02f,
  1.23239672e-02f, 1.01754181e-02f, -1.86392050e-02f, 8.88466612e-02f, 3.18345167e-02f, -8.72481093e-02f, -2.96538807e-02f, -5.02486005e-02f, -2.54692901e-02f, -1.01220347e-02f,
  -6.99623004e-02f, 1.34414405e-01f, 6.91464543e-02f, 6.73808623e-04f, -1.75977759e-02f, -3.61303724e-02f, 2.84392480e-02f, -3.17653865e-02f, -6.89055696e-02f, 4.33072587e-03f,
  3.40230092e-02f, 2.01324057e-02f, 6.25769049e-02f, 1.40331537e-02f, 4.40222695e-02f, 8.37484449e-02f, -6.65414426e-03f, -4.13874313e-02f, 7.32755214e-02f, 3.93026741e-03f,
  -7.09980130e-02f, 5.37224077e-02f, 4.34196852e-02f, 1.54135982e-02f, 6.37479946e-02f, -6.17418699e-02f, 4.07797620e-02f, 3.60578261e-02f, 9.50065032e-02f, -6.11161701e-02f,
  2.71993335e-02f, -5.59132472e-02f, -5.91807850e-02f, -1.88603159e-02f, -4.64558564e-02f, 4.87395041e-02f, 1.09933123e-01f, -1.13721900e-02f, 9.64386910e-02f, 1.00471312e-02f,
  3.65696177e-02f, 2.54676677e-02f, 4.32717502e-02f, -4.14862409e-02f, -1.18716016e-01f, 2.99141258e-02f, 7.25706518e-02f, -6.68290704e-02f, 1.58954933e-02f, -4.10262682e-02f,
  2.15319261e-01f, 2.34823301e-02f, 1.68355048e-01f, 1.50828332e-01f, 1.62430272e-01f, 2.92237010e-02f, 2.48056352e-02f, 1.43560439e-01f, 1.83974400e-01f, -1.24652803e-01f,
  -4.47095670e-02f, 1.18062593e-01f, -1.23411834e-01f, 8.17877054e-03f, -1.65620968e-01f, -2.05003619e-01f, 5.34546785e-02f, -5.52902147e-02f, 3.55249383e-02f, -2.90253520e-04f,
  7.47158304e-02f, -1.73136424e-02f, 6.57431632e-02f, -9.22214165e-02f, 5.41441850e-02f, -1.05662486e-02f, -8.42781737e-02f, -8.63124430e-02f, -1.46215493e-02f, -1.63658321e-01f,
  -1.35887973e-02f, 1.02003716e-01f, 7.32935667e-02f, -2.97852438e-02f, 1.02490984e-01f, 6.32056743e-02f, -1.45579144e-01f, -1.42875105e-01f, 1.32275835e-01f, -9.62559655e-02f,
  -1.33611378e-03f, -5.11698574e-02f, 5.31058013e-02f, -9.73518789e-02f, 9.47032273e-02f, 1.67487580e-02f, 3.62088680e-02f, 9.89627689e-02f, 9.27473903e-02f, 4.64743488e-02f,
  -6.46771444e-03f, 1.70237906e-02f, 1.84503078e-01f, -1.26491934e-01f, -5.20252250e-02f, 8.55500922e-02f, -3.31233777e-02f, -3.34399901e-02f, 1.01006165e-01f, 6.87889010e-02f,
  4.79911119e-02f, 3.58353369e-02f, 9.85743925e-02f, 8.07235911e-02f, -8.28679837e-03f, -4.61614802e-02f, -1.76139679e-02f, -7.86021128e-02f, 8.07387382e-02f, 1.02742292e-01f,
  -1.69265252e-02f, -6.99519515e-02f, 6.82324171e-02f, -3.20877731e-02f, -5.00813201e-02f, 3.13588493e-02f, 2.85799820e-02f, -7.15150833e-02f, -1.33433482e-02f, 1.11905657e-01f,
  5.68597578e-02f, -4.98425588e-02f, -9.67659876e-02f, -2.04724688e-02f, 8.00601542e-02f, 4.73698899e-02f, -4.58474942e-02f, -1.80358533e-02f, 8.33534151e-02f, -8.60428065e-02f,
  -1.45313978e-01f, -7.08782151e-02f, 4.30659726e-02f, -4.84189652e-02f, 1.35140549e-02f, -6.43968303e-03f, -6.52999356e-02f, -5.04254065e-02f, -7.55473971e-02f, -6.61807805e-02f,
  2.77398229e-02f, 1.32019166e-02f, 3.55622033e-03f, -1.19654275e-01f, 5.30926660e-02f, -4.12702188e-02f, 2.75300816e-02f, -1.53376907e-02f, 2.92565878e-02f, -8.44116211e-02f,
  -7.26521295e-03f, -1.10820293e-01f, 4.67056818e-02f, 3.63328010e-02f, -2.54291575e-03f, -9.65872556e-02f, -1.04707643e-01f, 3.23826224e-02f, -1.33614764e-02f, -5.80885783e-02f,
  -4.26151305e-02f, 1.28077835e-01f, -2.92326748e-01f, 1.40223622e-01f, 1.46576032e-01f, -5.12926057e-02f, 8.84164795e-02f, 2.81215906e-02f, -1.02631800e-01f, 1.84936270e-01f,
  1.55100077e-01f, -8.19953978e-02f, -3.42973918e-02f, 4.02251333e-02f, 7.25818872e-02f, -4.27658893e-02f, 6.30652308e-02f, 5.75671531e-02f, -1.39075458e-01f, 2.00802162e-01f,
  7.82245994e-02f, 3.43041807e-01f, -2.07440443e-02f, 1.58390179e-01f, 1.98179424e-01f, 2.04669614e-03f, 2.47332811e-01f, -5.62155880e-02f, 2.20310062e-01f, -5.22453599e-02f,
  4.07443084e-02f, 6.86586574e-02f, -4.46314476e-02f, -7.88019001e-02f, 2.94948202e-02f, 8.98113474e-02f, -3.63672501e-03f, -8.09420645e-02f, -1.43479139e-01f, -8.52526724e-02f,
  1.63860656e-02f, 4.32193801e-02f, -4.02524211e-02f, -1.05406016e-01f, -3.46018281e-03f, -1.23446375e-01f, -8.84665735e-03f, -5.08716702e-02f, -2.98155546e-02f, 8.18328094e-03f,
  -7.18355998e-02f, 9.34104845e-02f, 3.75523567e-02f, 7.08818138e-02f, -7.43617266e-02f, 4.69188765e-02f, 5.82181439e-02f, -1.31334155e-03f, -9.01155523e-04f, 1.06138624e-02f,
  3.95204760e-02f, 1.35718603e-02f, 7.57559538e-02f, -5.67170940e-02f, -3.56120020e-02f, 4.52877693e-02f, -2.57986188e-02f, -5.19713312e-02f, -4.07880824e-03f, 6.76872134e-02f,
  5.85947186e-02f, -7.06318170e-02f, 5.59849851e-02f, 7.64157623e-02f, -1.02066025e-02f, 8.71804357e-02f, -3.33899856e-02f, 1.06674142e-01f, 8.63762796e-02f, -8.50809589e-02f,
  -6.76286360e-03f, -5.71185909e-02f, 1.42268250e-02f, -7.59647861e-02f, -7.33999815e-03f, 3.95724997e-02f, -1.73867680e-02f, 8.37784931e-02f, -2.04915050e-02f, -6.31119683e-02f,
  7.23692924e-02f, 1.46710411e-01f, -3.53620425e-02f, 4.23148721e-02f, -5.67583069e-02f, 7.49405622e-02f, 3.66666280e-02f, 5.72506674e-02f, 7.01999441e-02f, 1.89819671e-02f,
  7.20213577e-02f, -6.26571327e-02f, 4.55213189e-02f, 2.43280381e-02f, -2.78574694e-02f, 1.55831456e-01f, 4.21421304e-02f, -8.67226124e-02f, 2.64556427e-02f, 8.92203972e-02f,
  1.45851165e-01f, 6.16941154e-02f, -1.03715714e-02f, -2.94014476e-02f, 9.76618612e-04f, 2.10079551e-02f, 4.17791493e-02f, 5.45910820e-02f, 7.44349435e-02f, -4.42042351e-02f,
  1.44610286e-01f, 1.92232877e-01f, 1.56203836e-01f, 1.97826505e-01f, -3.95243131e-02f, -9.45454910e-02f, -1.63894489e-01f, 1.39928892e-01f, 1.35294527e-01f, 3.90195213e-02f,
  5.06168678e-02f, 2.36553699e-01f, -5.01408149e-03f, 6.70043752e-02f, 1.24149069e-01f, -4.00266461e-02f, 1.92081779e-01f, 2.62782983e-02f, 2.13559885e-02f, 1.77151129e-01f,
  1.58469811e-01f, -2.41731144e-02f, 9.71791595e-02f, 8.38562846e-02f, -1.09395292e-03f, 7.47369081e-02f, -1.24895170e-01f, -1.00377873e-02f, 3.98324523e-03f, -1.50636822e-01f,
  -1.25771031e-01f, 2.21754164e-02f, 5.84118143e-02f, -9.57112089e-02f, 1.29082166e-02f, -7.00286552e-02f, -1.99610763e-03f, -2.88966279e-02f, -6.73058257e-02f, -6.62625358e-02f,
  2.14713365e-02f, -4.96010706e-02f, 9.02895108e-02f, 1.01991128e-02f, -1.81091717e-03f, 1.11109190e-01f, 1.80849470e-02f, -7.58664384e-02f, 1.13601185e-01f, 7.42440000e-02f,
  -2.63947807e-02f, 2.14886013e-02f, -3.39265727e-02f, -8.89436752e-02f, 3.10625136e-03f, -5.62756695e-02f, 6.37537166e-02f, 1.73486173e-02f, -2.18702033e-02f, 1.04494132e-01f,
  -9.06268507e-02f, 8.21339190e-02f, -2.14634207e-03f, -8.22019484e-03f, -5.10300919e-02f, 7.69357905e-02f, 6.08718283e-02f, 7.19329864e-02f, -2.64195781e-02f, -2.82438640e-02f,
  -5.85417189e-02f, -7.50637129e-02f, 3.13208960e-02f, -4.56483550e-02f, 1.07329950e-01f, -7.15423152e-02f, -2.44336314e-02f, -3.47389467e-02f, 3.52804214e-02f, 5.54140247e-02f,
  -5.61405681e-02f, -1.46684404e-02f, 6.64957538e-02f, -4.28934135e-02f, -5.39366901e-02f, -7.73202255e-02f, -2.89208768e-03f, 7.09747225e-02f, -5.72546665e-03f, 1.18740134e-01f,
  6.25790507e-02f, 1.96294233e-01f, -3.93358897e-03f, -9.35645849e-02f, -3.07985749e-02f, 6.17566630e-02f, 5.28505147e-02f, 4.19455618e-02f, 9.56740379e-02f, -4.40778993e-02f,
  -1.27832852e-02f, 1.52403824e-02f, -7.41869509e-02f, 3.76605876e-02f, -1.62278395e-02f, 9.05087888e-02f, 4.10550945e-02f, -3.75288241e-02f, 5.02323397e-02f, -4.11651134e-02f,
  -4.06277254e-02f, -5.66924037e-03f, -5.38592562e-02f, 3.80798206e-02f, 4.68914844e-02f, -7.16337562e-03f, 3.73262726e-02f, 8.08431301e-03f, -5.30501641e-02f, -2.60211937e-02f,
  2.18978882e-01f, -3.11521403e-02f, 1.68942556e-01f, 1.40550211e-01f, -2.33950857e-02f, -8.84331837e-02f, -2.86372844e-03f, -2.49968339e-02f, 1.89146757e-01f, 6.69349283e-02f,
  -1.18617050e-01f, 2.05557406e-01f, -8.11067969e-02f, -1.01745769e-01f, -1.23231811e-02f, 3.23898271e-02f, -4.02743667e-02f, -4.77634482e-02f, 2.38290131e-02f, -4.00778465e-02f,
  -4.65026684e-02f, -1.65476963e-01f, -1.02384634e-01f, -1.72062948e-01f, -1.52367279e-01f, 6.94376305e-02f, -1.46015704e-01f, -1.47741348e-01f, -2.92596221e-02f, -1.38593614e-01f,
  -1.25138834e-01f, 8.23812634e-02f, 2.32421178e-02f, 5.54510169e-02f, 1.22855883e-02f, -1.00173606e-02f, -4.48799394e-02f, -5.22353426e-02f, 7.48046068e-03f, 1.22831296e-02f,
  7.13762268e-02f, -2.53660735e-02f, 5.04366383e-02f, -2.98385676e-02f, 3.64541542e-03f, 7.23277405e-02f, 6.41638339e-02f, -6.78612366e-02f, -1.50681790e-02f, -6.09668251e-03f,
  1.35260234e-02f, 4.31705564e-02f, 6.90411478e-02f, -4.52431384e-03f, -4.88171130e-02f, -5.82194813e-02f, 5.49692623e-02f, 4.56946641e-02f, 3.93026546e-02f, 1.44958705e-01f,
  2.46579982e-02f, 2.94442941e-02f, -1.90208983e-02f, -1.49351428e-03f, 2.63311248e-02f, 4.17294651e-02f, 9.13405865e-02f, -7.65682012e-02f, -2.99627595e-02f, 4.63420153e-02f,
  1.06083779e-02f, 1.02403508e-02f, -4.61601689e-02f, 1.00237876e-01f, 6.74420372e-02f, 8.05461258e-02f, 1.56421307e-02f, -2.86733042e-02f, 2.47449391e-02f, 3.93724628e-02f,
  9.52307731e-02f, -1.23797581e-01f, 6.89666718e-02f, -9.18489322e-02f, 4.87579219e-03f, 8.97995848e-03f, -3.61433439e-02f, 1.02480225e-01f, 2.07198374e-02f, -6.26636222e-02f,
  -1.41845345e-01f, -3.70277800e-02f, -4.45319228e-02f, -4.24167849e-02f, -4.68145944e-02f, -4.10946235e-02f, 3.29356231e-02f, 4.77382131e-02f, 1.96689665e-02f, 3.55141126e-02f,
  -6.87481612e-02f, 7.26486966e-02f, -6.41466677e-02f, 5.93632795e-02f, -3.08505297e-02f, 3.29973400e-02f, 1.26199052e-02f, -6.98944405e-02f, 7.91916158e-03f, -1.07049808e-01f,
  -3.60616744e-02f, 7.80179575e-02f, 6.98233694e-02f, 8.13151803e-03f, 1.24694472e-02f, 3.16221118e-02f, 1.19059552e-02f, -8.41494557e-03f, 1.77761205e-02f, 4.74771336e-02f,
  2.13869829e-02f, -3.25017944e-02f, -1.08428299e-01f, -1.29146218e-01f, -1.05440281e-01f, -2.83968598e-01f, -7.37696290e-02f, -1.86000854e-01f, 5.22778034e-02f, -1.12418741e-01f,
  -2.64076404e-02f, 2.10708715e-02f, 1.03265576e-01f, -1.76022291e-01f, 2.96571441e-02f, 9.64862630e-02f, -2.12609798e-01f, -7.66312480e-02f, 8.00027400e-02f, -1.87431499e-01f,
  -9.34226513e-02f, -1.17781371e-01f, -2.89369784e-02f, -9.02177915e-02f, -1.81613937e-01f, -2.37588007e-02f, 7.56745487e-02f, 3.23336311e-02f, -1.27270535e-01f, 6.61126450e-02f,
  -2.87440896e-01f, -1.16315067e-01f, -3.05902455e-02f, -1.15284778e-01f, -1.73114896e-01f, 1.87010635e-02f, -3.00563481e-02f, 1.05005614e-01f, 1.77232008e-02f, -8.18423331e-02f,
  8.38496238e-02f, 8.49606246e-02f, 5.48863187e-02f, 3.86491045e-02f, 4.26584715e-03f, 4.84867506e-02f, -1.36394620e-01f, -7.91733116e-02f, -8.02427828e-02f, 1.12209618e-01f,
  3.39685343e-02f, -9.25392881e-02f, -1.14554264e-01f, 9.45200212e-03f, -2.58150008e-02f, -4.13290188e-02f, -1.29470304e-02f, 8.90940428e-03f, -9.03866217e-02f, -8.02977458e-02f,
  -3.05029545e-02f, 1.25212863e-01f, -3.25237284e-03f, 9.61994566e-03f, -3.32075288e-03f, 5.43139093e-02f, 5.68143986e-02f, 1.07154049e-01f, -6.95673823e-02f, -8.72940570e-03f,
  -1.34261046e-02f, 3.61593999e-02f, 4.76514623e-02f, -3.08514293e-02f, -4.79566772e-03f, 2.65933946e-02f, 4.58703190e-03f, 4.87366505e-02f, -6.29096776e-02f, -7.74886757e-02f,
  2.08530687e-02f, -1.57990698e-02f, 1.02526426e-01f, 2.32848190e-02f, -3.21437456e-02f, -8.37595295e-03f, 4.13977914e-03f, -7.15480074e-02f, 3.80129032e-02f, 1.25222905e-02f,
  -3.65478158e-01f, -2.10038558e-01f, -5.16007058e-02f, -3.77258509e-02f, -2.61726752e-02f, -7.65547082e-02f, -2.53084917e-02f, -4.63723801e-02f, -9.55949649e-02f, -6.65982291e-02f,
  4.92213992e-03f, -2.98368017e-04f, -7.00579211e-03f, -4.66304738e-03f, 1.50231034e-01f, 1.55038396e-02f, -6.12937286e-03f, -4.66922745e-02f, -4.81061153e-02f, 3.11569348e-02f,
  2.10286006e-02f, 2.51440369e-02f, 2.90534999e-02f, -1.24557065e-02f, 3.48968245e-02f, -5.13762869e-02f, -5.67301102e-02f, 5.80831692e-02f, -2.98966467e-02f, 3.74518223e-02f,
  -3.60839784e-01f, -6.68130070e-02f, 5.16664311e-02f, -9.96049121e-02f, -3.83048095e-02f, 6.03134669e-02f, 1.90470114e-01f, -1.62064701e-01f, 1.42774312e-02f, 1.84733495e-01f,
  1.74237207e-01f, 2.37293150e-02f, 1.70817867e-01f, 1.19470119e-01f, 4.14513722e-02f, 2.18236253e-01f, 1.66355357e-01f, 9.81241316e-02f, -9.16807577e-02f, -9.06016529e-02f,
  -3.65346000e-02f, 4.36538272e-02f, 1.61808103e-01f, -9.01077539e-02f, -4.90968414e-02f, -4.41947505e-02f, 8.97573978e-02f, 5.70641495e-02f, 4.30552736e-02f, -2.07613558e-02f,
  -1.53820768e-01f, -1.85845643e-01f, -1.20281734e-01f, 1.05153648e-02f, -7.31699690e-02f, -3.16758826e-02f, 1.08841978e-01f, 1.26187047e-02f, -3.72299068e-02f, -1.63588971e-02f,
  -2.11418699e-02f, 2.10416857e-02f, -7.80536085e-02f, -3.15604396e-02f, -2.40888987e-02f, 1.76218823e-02f, 8.67959335e-02f, 1.03643872e-01f, 1.59726236e-02f, 8.18514153e-02f,
  8.73555336e-03f, 3.84288244e-02f, 3.90471853e-02f, 3.04435398e-02f, 6.70090467e-02f, 5.54220490e-02f, -9.29773226e-03f, 1.77899841e-02f, -4.78216521e-02f, -4.87492085e-02f,
  -6.39586449e-02f, 7.02353790e-02f, 4.35552597e-02f, -2.07328075e-03f, -2.65593957e-02f, -8.56826734e-03f, 4.14707847e-02f, 8.75108019e-02f, 8.32353830e-02f, 5.44990860e-02f,
  1.75512023e-02f, 1.90702677e-02f, 1.97603162e-02f, 1.75046298e-04f, -4.12061810e-04f, 8.25308859e-02f, -5.00543155e-02f, -4.79388144e-03f, -7.39342496e-02f, 1.56816549e-03f,
  6.22655340e-02f, -5.61078228e-02f, 8.71466249e-02f, 8.24702978e-02f, -1.67212002e-02f, 5.05900048e-02f, -8.18628743e-02f, 5.41439606e-03f, 7.60918483e-02f, -6.66879937e-02f,
  -1.99097350e-01f, -1.62853047e-01f, 3.42415944e-02f, -6.08484559e-02f, -2.28600372e-02f, -7.40742162e-02f, -8.59221518e-02f, 2.49505937e-02f, 6.94552734e-02f, 2.35849749e-02f,
  1.43223805e-02f, -3.33896466e-02f, -7.16996640e-02f, -4.38196771e-03f, -1.84866954e-02f, -1.66863073e-02f, -7.59105533e-02f, 4.20600772e-02f, 2.15006601e-02f, -4.84272987e-02f,
  -2.75905970e-02f, 2.87480950e-02f, -1.61015484e-02f, -2.28151623e-02f, 3.85956690e-02f, -3.16847079e-02f, -1.29653262e-02f, -6.75912425e-02f, 3.66080441e-02f, -2.34673568e-03f,
  -8.36389437e-02f, -1.37124546e-02f, -2.40510330e-01f, -1.57011524e-01f, -1.61724389e-02f, -2.27987155e-01f, -1.15989961e-01f, -7.26053445e-03f, -4.62026857e-02f, 1.18386276e-01f,
  -3.67213190e-02f, -1.61456428e-02f, 1.61603644e-01f, -1.60750479e-01f, -4.98343445e-02f, 2.36096174e-01f, -1.03696167e-01f, -1.77808583e-01f, -2.59457305e-02f, -6.71043769e-02f,
  6.86069801e-02f, -8.78166482e-02f, -1.25467405e-01f, -2.47621741e-02f, -1.55505598e-01f, -3.00299134e-02f, -4.22495827e-02f, -4.17123958e-02f, -1.94799498e-01f, -5.56545425e-03f,
  -1.30010724e-01f, 5.87537214e-02f, 2.32123062e-02f, 2.31253747e-02f, -1.16170436e-01f, -8.77542142e-03f, -1.98924961e-03f, 1.63580682e-02f, 2.44606528e-02f, 7.40425512e-02f,
  -6.02085292e-02f, 9.81575474e-02f, 1.23053789e-02f, 6.39827773e-02f, 6.52085394e-02f, -6.21236814e-03f, 9.58044082e-02f, 2.26787617e-03f, -6.97475160e-03f, -1.35415316e-01f,
  -9.85181779e-02f, 6.83056517e-03f, -1.21364463e-02f, -1.56705752e-02f, -5.70060350e-02f, 2.35786475e-02f, -6.18215241e-02f, -2.54169721e-02f, -3.94842774e-02f, -3.96463759e-02f,
  -7.56498948e-02f, -7.18119815e-02f, -2.91954242e-02f, -1.05392141e-02f, 2.83768773e-02f, -2.47418955e-02f, -6.90728873e-02f, 2.72513013e-02f, 3.21059451e-02f, 6.29742071e-02f,
  1.56810209e-02f, 2.92859357e-02f, 1.05462251e-02f, 2.59044524e-02f, -1.39490478e-02f, 6.19137175e-02f, 9.77838412e-02f, 9.08365548e-02f, -7.64064193e-02f, 2.90871467e-02f,
  1.33737564e-01f, -3.21293622e-02f, -1.27354935e-02f, 2.78058760e-02f, -4.74134237e-02f, 7.38696903e-02f, 4.66773584e-02f, -5.79443872e-02f, 8.98094997e-02f, -2.54297163e-02f,
  -1.46940369e-02f, -3.28704230e-02f, 1.15485804e-03f, 8.14386755e-02f, 1.36382908e-01f, 5.12272818e-03f, -1.30255044e-01f, -1.97344609e-02f, 9.60654486e-03f, -4.17540930e-02f,
  8.10822099e-03f, 3.40818204e-02f, -5.84895909e-02f, -3.84790525e-02f, 2.05240976e-02f, -3.39868516e-02f, -1.74203154e-03f, 3.77432741e-02f, -1.07983626e-01f, -4.10939120e-02f,
  -1.47138899e-02f, -5.39239161e-02f, -2.28182897e-02f, -1.74108204e-02f, -2.29085870e-02f, 9.45588872e-02f, -2.80624423e-02f, -5.48796030e-03f, -6.62461445e-02f, 7.03456765e-03f,
  -2.28039742e-01f, -1.57946885e-01f, -9.40220710e-03f, 1.48328349e-01f, -1.63644046e-01f, 1.28159925e-01f, 1.57816455e-01f, -2.16714680e-01f, -9.58511159e-02f, 8.65404680e-02f,
  -7.44415447e-02f, -3.95808369e-02f, 6.74664974e-02f, 1.69145092e-01f, 1.92339122e-01f, 1.17842093e-01f, 9.21804756e-02f, -4.72801812e-02f, -8.45271349e-02f, -7.46089220e-02f,
  2.44978592e-02f, 1.82279367e-02f, 5.43087386e-02f, -1.85863718e-01f, -1.10651858e-01f, -2.71691326e-02f, 1.53726369e-01f, -1.47070989e-01f, 1.50389597e-01f, 2.57830694e-02f,
  -1.73972189e-01f, -1.98356465e-01f, -1.14676870e-01f, -9.52364206e-02f, -1.31146312e-02f, -5.49233705e-02f, 1.18325669e-02f, 7.38455448e-03f, -8.40119794e-02f, -9.28886533e-02f,
  -1.76346935e-02f, -2.15555765e-02f, 1.16789877e-01f, 7.74149224e-02f, -2.58938335e-02f, -1.11773342e-01f, -4.89267372e-02f, -5.28416336e-02f, -2.16511693e-02f, -6.42783195e-02f,
  -9.47874784e-02f, 1.44350547e-02f, 6.53683245e-02f, 4.59830128e-02f, -5.33594489e-02f, -1.16633400e-02f, 9.12357345e-02f, 7.14115277e-02f, 2.05624811e-02f, 8.80365632e-03f,
  1.60869490e-02f, 5.11756465e-02f, -1.04070462e-01f, 1.94690395e-02f, -7.37679079e-02f, 9.25858915e-02f, 1.49787879e-02f, 8.51633027e-02f, -2.39800382e-03f, 5.70321120e-02f,
  -4.13238183e-02f, -5.02397455e-02f, -3.27640921e-02f, -5.47542702e-03f, 6.84717819e-02f, 5.90648539e-02f, 5.84767014e-02f, -1.15934499e-01f, 5.08146659e-02f, 6.12419359e-02f,
  3.69139872e-02f, 1.09619036e-01f, 9.91728995e-03f, 2.93649808e-02f, -1.13004364e-01f, -7.96257854e-02f, -6.72975034e-02f, 4.23747227e-02f, 1.12124540e-01f, -7.36374594e-03f,
  -3.02047938e-01f, -1.63229272e-01f, -5.99166118e-02f, -6.58470914e-02f, -2.54344102e-02f, -5.04696332e-02f, -7.61269033e-02f, -1.55921966e-01f, 2.96445824e-02f, 1.23445578e-02f,
  -4.16171141e-02f, 7.33205974e-02f, 2.62495894e-02f, 8.85183923e-03f, 6.83735758e-02f, 2.73509175e-02f, 5.47981784e-02f, -1.83497518e-02f, -6.50132447e-03f, -9.97589901e-02f,
  -8.72505978e-02f, -3.07021718e-02f, -3.28176208e-02f, -3.13798562e-02f, 7.96984285e-02f, 5.13886064e-02f, -4.42605726e-02f, 7.06026703e-02f, -5.04568852e-02f, 4.10141014e-02f,
  1.13441169e-01f, 1.27659410e-01f, 9.12086442e-02f, 1.32598862e-01f, -1.67555422e-01f, -2.22466677e-01f, -1.54577658e-01f, -6.23199902e-02f, 1.26530066e-01f, -9.11051631e-02f,
  -1.61745638e-01f, 1.77612826e-01f, -6.03075176e-02f, -5.34749590e-02f, 1.29503503e-01f, 6.49735108e-02f, 1.11339658e-01f, 7.26285130e-02f, 1.55427027e-02f, 1.01062141e-01f,
  9.65740979e-02f, -2.03426052e-02f, 8.39768350e-02f, 7.81567097e-02f, 9.40653086e-02f, 7.69715616e-03f, 1.69488013e-01f, 3.73336151e-02f, 4.81540412e-02f, -3.45213935e-02f,
  -4.24725786e-02f, 8.43157321e-02f, -2.96679866e-02f, -2.43945699e-02f, -2.39419471e-02f, 1.12070376e-02f, -3.57016213e-02f, 6.02658605e-03f, 7.43051097e-02f, -5.87352589e-02f,
  6.15636073e-02f, -3.12694497e-02f, 1.03314640e-02f, 1.99282933e-02f, -4.90471609e-02f, 9.38520115e-03f, 2.44641174e-02f, -5.88481091e-02f, 8.93162265e-02f, -4.87063974e-02f,
  8.34948346e-02f, -8.42159672e-04f, -2.21246225e-03f, 6.14158064e-02f, 1.23942666e-01f, -1.70887262e-02f, 1.29858823e-02f, -1.06535722e-02f, -1.49533013e-02f, 6.28841444e-05f,
  -1.16441604e-02f, -3.68791483e-02f, 5.12204990e-02f, -2.08415445e-02f, -2.88343668e-04f, 5.52280359e-02f, -6.41945302e-02f, -9.99933556e-02f, 4.91724797e-02f, -1.02720797e-01f,
  -1.72066689e-02f, -5.03038056e-02f, 5.64987436e-02f, -9.03130323e-03f, 1.76834054e-02f, 1.85038149e-02f, -7.13267291e-05f, -3.20699532e-03f, -8.04224163e-02f, 6.20087013e-02f,
  8.33927020e-02f, 5.85503206e-02f, 2.42927335e-02f, -8.69380832e-02f, 5.72313974e-03f, -4.62398008e-02f, 5.27094901e-02f, -6.56887740e-02f, 3.69613357e-02f, -2.87536718e-02f,
  -1.14357863e-02f, 1.91912726e-01f, -9.41433944e-03f, -3.29803564e-02f, 6.36576936e-02f, -1.09462505e-02f, 9.84669700e-02f, 4.12250534e-02f, 8.29491466e-02f, 2.79891584e-03f,
  -7.86861554e-02f, 2.72446759e-02f, -8.36199597e-02f, 3.46639156e-02f, -7.62850642e-02f, 4.45128344e-02f, -9.97496098e-02f, -1.02335000e-02f, 1.20928280e-01f, 6.21004738e-02f,
  7.16477633e-02f, -1.22602686e-01f, -6.25732765e-02f, -3.71405892e-02f, 4.62100059e-02f, 2.28647403e-02f, -2.41222661e-02f, 6.92781508e-02f, 9.32329372e-02f, 5.58883660e-02f,
  1.31174877e-01f, -2.17590243e-01f, -1.08883843e-01f, -3.49167828e-03f, -9.86106545e-02f, 1.78848594e-01f, 2.07276031e-01f, -2.08951965e-01f, -1.64961964e-01f, 1.04127720e-01f,
  2.79257130e-02f, 5.96420001e-03f, 2.65175980e-02f, 1.08208120e-01f, 1.42936066e-01f, 2.76031606e-02f, 8.57201293e-02f, 1.41743436e-01f, -1.82668597e-01f, 5.07026389e-02f,
  1.28934055e-03f, 2.64400303e-01f, 9.61807519e-02f, 5.50391935e-02f, 1.27234966e-01f, -2.28322789e-01f, -4.54012789e-02f, -8.18170011e-02f, 1.50480077e-01f, 7.43733719e-02f,
  2.29010135e-02f, -1.43098021e-02f, -6.24772720e-02f, 2.53005419e-02f, -3.22326645e-02f, -8.80401209e-03f, 1.01703033e-01f, 3.91459912e-02f, -8.36323798e-02f, -3.62471491e-02f,
  5.77280372e-02f, -6.04019649e-02f, 7.47248828e-02f, -3.00058927e-02f, 8.23261663e-02f, -6.73170481e-03f, -1.02043562e-01f, -7.25816637e-02f, -7.19677564e-03f, 3.17060202e-02f,
  5.16628772e-02f, -1.81255192e-02f, 1.95196159e-02f, 5.04281521e-02f, -2.67245043e-02f, -3.12496088e-02f, 1.70930400e-02f, -3.34323180e-04f, 6.68906048e-02f, -5.92461824e-02f,
  -2.06355341e-02f, 9.39444527e-02f, -6.07355572e-02f, -2.61671729e-02f, 2.63255537e-02f, -4.33052108e-02f, 1.50111327e-02f, -1.14640661e-01f, -9.25361738e-02f, -2.49557383e-02f,
  -4.24588993e-02f, -2.85197031e-02f, -6.16914518e-02f, 5.44353984e-02f, 3.05770338e-02f, -3.86025868e-02f, 4.80888784e-03f, -6.08326457e-02f, -7.62981325e-02f, -6.02155179e-02f,
  -2.75437832e-02f, -2.67550964e-02f, 1.79192275e-02f, -2.26685684e-02f, 3.69463973e-02f, 7.72207007e-02f, 8.54625483e-04f, -1.28313333e-01f, 1.88704263e-02f, 7.18438551e-02f,
  5.39233238e-02f, -5.69303669e-02f, 2.26076040e-02f, 4.42873426e-02f, -2.12799069e-02f, -4.12787125e-02f, 2.31757876e-04f, 6.89919516e-02f, 8.88942108e-02f, 5.18555678e-02f,
  6.20599985e-02f, -5.59574785e-03f, -2.24542934e-02f, -2.68658288e-02f, -2.11827513e-02f, 3.34766731e-02f, -7.00290594e-03f, -9.29069743e-02f, -3.26067582e-02f, 1.34498356e-02f,
  -1.75370779e-02f, 1.67713035e-02f, 4.54289615e-02f, -6.28217384e-02f, 2.26119552e-02f, -3.21589932e-02f, -9.96655375e-02f, -5.08715920e-02f, 1.16743948e-02f, -2.35931631e-02f,
  2.29948267e-01f, -9.74564068e-03f, 4.18320037e-02f, 1.49709001e-01f, -7.00018108e-02f, -1.75650090e-01f, -4.56754193e-02f, -8.95054340e-02f, 2.54515149e-02f, -9.59420055e-02f,
  -4.72076759e-02f, 4.85500507e-02f, -2.02447250e-01f, 1.09771006e-01f, 2.90247798e-01f, -1.80500045e-01f, 1.70043021e-01f, -3.05365231e-02f, 5.38228340e-02f, 4.20166776e-02f,
  -7.36750709e-03f, 1.76153898e-01f, 2.14899495e-01f, 4.58776429e-02f, 7.85762817e-02f, 3.22467126e-02f, 1.86657533e-01f, -9.72208455e-02f, 6.57787994e-02f, 8.53324533e-02f,
  -8.23440589e-03f, -1.26219261e-02f, -1.06900297e-02f, 6.38794601e-02f, 3.16242948e-02f, 4.99820970e-02f, 3.56389433e-02f, -8.19818396e-03f, 2.00399235e-02f, -7.48555809e-02f,
  -1.00639828e-01f, 6.02604449e-02f, 2.25206129e-02f, 3.83961946e-02f, 8.53433758e-02f, 6.48425892e-02f, 7.10266680e-02f, 5.79229258e-02f, -5.50599247e-02f, -1.44928349e-02f,
  6.10892996e-02f, -2.74064373e-02f, 1.49476409e-01f, 4.41800505e-02f, -1.53241754e-02f, 1.22350892e-02f, -2.27292627e-02f, 3.87103222e-02f, -3.98981944e-03f, 5.30346371e-02f,
  2.31635217e-02f, -2.46692002e-02f, -4.53214021e-03f, 1.12719452e-02f, 3.96600105e-02f, -7.06543848e-02f, 7.78433830e-02f, -4.43189144e-02f, -7.62025639e-02f, 3.98388021e-02f,
  3.26602235e-02f, 4.12990898e-02f, -5.23114279e-02f, 8.57413262e-02f, -5.33397235e-02f, -1.14743762e-01f, -8.33635628e-02f, -5.31907901e-02f, 3.59934941e-02f, -1.05030291e-01f,
  -1.40281487e-03f, 8.60843360e-02f, -1.96658280e-02f, -2.40847059e-02f, 1.09989420e-01f, 1.08055901e-02f, -5.94788641e-02f, -7.88150728e-03f, -6.27026185e-02f, -5.30157164e-02f,
  8.39924533e-03f, 9.72980261e-03f, -3.26685570e-02f, -8.04512873e-02f, 2.43217852e-02f, 4.32833396e-02f, -1.77216530e-02f, 2.93117333e-02f, -4.84806187e-02f, -5.59771620e-02f,
  -1.66116357e-02f, -2.92075388e-02f, -9.03905332e-02f, 5.84461028e-03f, 9.33547467e-02f, -5.62671460e-02f, 2.95510096e-03f, 5.28196096e-02f, 8.87419060e-02f, -2.82294210e-02f,
  -5.08751944e-02f, -8.97740647e-02f, 3.39637138e-02f, 1.29617183e-02f, 9.41735320e-03f, -9.35930759e-02f, 2.78938729e-02f, 1.19318422e-02f, -1.52498181e-03f, 6.32358491e-02f,
  1.80195183e-01f, -2.62852814e-02f, 6.27913624e-02f, 1.89541876e-01f, 1.02236129e-01f, 3.44298296e-02f, -6.81659430e-02f, -1.41117867e-04f, 1.63458452e-01f, -5.09429909e-02f,
  -3.38837765e-02f, 9.55190659e-02f, -1.05317440e-02f, 5.38035557e-02f, -1.23543534e-02f, 1.60777606e-02f, -5.02620339e-02f, 8.14317539e-02f, -8.88752192e-02f, 1.40895665e-01f,
  5.58218732e-02f, -2.24743843e-01f, -2.98368968e-02f, 3.00248768e-02f, 8.50363448e-03f, 1.04271710e-01f, -3.65970731e-02f, -3.96670997e-02f, 4.43463819e-03f, 3.77287157e-02f,
  2.32900735e-02f, 3.54566760e-02f, -2.71467604e-02f, -6.97325123e-03f, -3.00816577e-02f, -3.96191366e-02f, -8.75490233e-02f, 2.16003731e-02f, 7.43308617e-03f, 1.02048956e-01f,
  -4.75810245e-02f, -6.99288920e-02f, -8.03562477e-02f, -1.25402287e-01f, 7.09769055e-02f, -3.40535045e-02f, 6.11837097e-02f, -7.40777468e-04f, -1.61488317e-02f, 1.33783426e-02f,
  1.40059918e-01f, -6.94008023e-02f, 7.65429288e-02f, 3.91997620e-02f, 1.79125257e-02f, -7.89419115e-02f, 5.21795005e-02f, 3.26022506e-02f, 1.13454632e-01f, -6.96719512e-02f,
  -1.15136459e-01f, -3.28324586e-02f, 4.53827381e-02f, -2.32645590e-02f, 1.20930575e-01f, -1.99197680e-02f, -4.16123122e-03f, 4.51704785e-02f, 1.33900315e-01f, 1.09852634e-01f,
  2.73113977e-02f, 3.53508256e-02f, 6.62681982e-02f, 7.48693794e-02f, 1.00837427e-03f, -1.07359216e-01f, 3.41039747e-02f, 7.56723583e-02f, 1.13578446e-01f, 1.46581037e-02f,
  -1.48516685e-01f, -1.06677555e-01f, 6.57929778e-02f, 9.02525485e-02f, -1.67070590e-02f, 1.25120012e-02f, -1.19956039e-01f, 6.58821687e-02f, 5.14758751e-02f, 1.96883734e-02f,
  -4.24696468e-02f, -1.24938056e-01f, -1.25998482e-01f, 2.38355994e-02f, 3.60363275e-02f, -4.46766764e-02f, 2.47754529e-02f, 2.10707244e-02f, -1.02329008e-01f, -4.07816209e-02f,
  7.37029761e-02f, 1.32481545e-01f, -3.88104804e-02f, -1.53659964e-02f, -6.63782135e-02f, -4.42022085e-02f, 6.95879944e-03f, -3.83351892e-02f, -1.30403563e-01f, -5.78105189e-02f,
  -2.13745348e-02f, -7.45396912e-02f, -4.44394685e-02f, 3.98769183e-03f, -1.16286308e-01f, -4.05352451e-02f, 3.14197429e-02f, -3.12339868e-02f, 4.12373431e-02f, 2.43756548e-02f,
  -1.98084489e-01f, 1.66640818e-01f, 8.23915079e-02f, -1.82935849e-01f, 1.86086949e-02f, -4.76248972e-02f, -2.04545364e-01f, 1.16433874e-01f, -2.65274313e-03f, 1.35071948e-01f,
  1.03698885e-02f, 2.59885322e-02f, 1.38143077e-01f, -1.49818942e-01f, -4.11361367e-01f, -1.90692618e-01f, -2.92229861e-01f, -9.87400413e-02f, 1.05208615e-02f, -5.20262457e-02f,
  -1.13155730e-01f, -6.85970932e-02f, -7.24173114e-02f, 3.61279538e-03f, -3.36543731e-02f, 1.41362563e-01f, 1.04427651e-01f, 1.23714417e-01f, 3.39406333e-03f, 7.89356530e-02f,
  -1.28246784e-01f, 1.50407284e-01f, 1.15695735e-02f, -2.13180315e-02f, -5.36221527e-02f, 2.41500116e-03f, -6.28735870e-02f, -5.65008000e-02f, 5.03704660e-02f, -1.07660489e-02f,
  9.75718871e-02f, -8.96040276e-02f, 5.68313636e-02f, -5.50792292e-02f, 3.98367550e-03f, 1.24600917e-01f, -2.32609324e-02f, -5.32805510e-02f, -4.38395254e-02f, 2.42290776e-02f,
  1.30262282e-02f, -7.80973434e-02f, -4.21865238e-03f, -1.25804078e-02f, -8.25832412e-03f, -7.60199828e-03f, 4.05778475e-02f, -1.32108703e-02f, -3.03370673e-02f, -3.13273072e-02f,
  -7.92518854e-02f, 3.73546570e-03f, -5.71148396e-02f, -8.31048019e-05f, 4.67357831e-03f, -4.92951646e-02f, -1.84576996e-02f, 8.48236829e-02f, -3.53465267e-02f, 2.93745100e-02f,
  -2.20224005e-03f, 1.83875561e-02f, -1.70695467e-03f, -6.98192492e-02f, -3.24863493e-02f, -3.28559987e-02f, -4.74202335e-02f, -1.93358883e-02f, 2.28983928e-02f, 1.89755540e-02f,
  9.48675200e-02f, 3.07525899e-02f, -7.65375644e-02f, -3.89244296e-02f, 9.77083668e-02f, -2.45419741e-02f, -4.88079153e-02f, -1.04838334e-01f, 8.95748138e-02f, -9.00692940e-02f,
  2.22599767e-02f, 7.31842592e-02f, 4.31757681e-02f, 8.66091475e-02f, 6.09964654e-02f, 2.93353535e-02f, -6.61940426e-02f, 3.69147956e-02f, 5.13146333e-02f, 8.49007517e-02f,
  4.66591194e-02f, 6.50760978e-02f, 4.16578837e-02f, 3.62453088e-02f, 2.15206407e-02f, 7.78623298e-02f, 1.07539082e-02f, 4.32811081e-02f, -1.30471345e-02f, -5.93489073e-02f,
  -2.65756715e-02f, 5.05780876e-02f, -1.19795643e-01f, 3.73318940e-02f, -4.40255404e-02f, 2.75316294e-02f, -2.55313274e-02f, -6.75531477e-02f, -8.99224076e-03f, -3.73293087e-02f,
  1.54626772e-01f, -7.63218924e-02f, -1.09336078e-01f, -4.15635295e-02f, -1.30895898e-02f, 4.01422307e-02f, 1.12537496e-01f, -5.60263954e-02f, 2.57772863e-01f, -2.84994096e-02f,
  -1.57442600e-01f, 7.27407485e-02f, 1.61538586e-01f, -9.57229733e-02f, 1.91876948e-01f, 2.51194358e-01f, 8.97955149e-02f, 1.34755090e-01f, 9.12637860e-02f, -4.16715071e-02f,
  -6.26455545e-02f, -1.41108572e-01f, -2.06163079e-01f, -2.12408125e-01f, -1.98488414e-01f, -1.95618853e-01f, -9.93563533e-02f, -5.11527620e-02f, -1.06916800e-01f, 8.70746970e-02f,
  -4.56550643e-02f, -5.16763777e-02f, -2.47679166e-02f, -4.03333716e-02f, 4.53562997e-02f, 5.16030490e-02f, -3.72914411e-02f, -5.18837720e-02f, 6.56509325e-02f, 1.34726644e-01f,
  1.26068648e-02f, -3.83590907e-02f, -2.52723135e-02f, -1.64485704e-02f, -5.46262525e-02f, -2.10682955e-02f, -1.11596219e-01f, -8.55178665e-03f, 2.86930520e-03f, -1.04413792e-01f,
  -1.07416838e-01f, -1.40190627e-02f, 8.62764777e-04f, 6.83788806e-02f, -1.27605908e-03f, 1.18133621e-02f, -3.26826423e-02f, -2.89802160e-02f, -1.03744119e-02f, 7.11935610e-02f,
  -2.67681945e-02f, -9.94064752e-03f, -5.12483232e-02f, 5.59657579e-03f, 1.57244820e-02f, -1.22318581e-01f, -7.39626214e-02f, -3.81186679e-02f, 1.83690470e-02f, -4.36108783e-02f,
  -5.38417026e-02f, -1.57821495e-02f, -2.95769870e-02f, -1.08624525e-01f, 4.16987427e-02f, 3.13353240e-02f, 2.07116846e-02f, 4.77199964e-02f, 1.81388166e-02f, -2.18393132e-02f,
  -7.65852407e-02f, 2.11389139e-02f, -8.56102481e-02f, -4.93658148e-02f, -3.93971195e-03f, 5.65529102e-03f, -4.94328886e-02f, 5.99782243e-02f, 5.03606535e-03f, -2.80302987e-02f,
  6.94520324e-02f, 1.89940989e-01f, 1.11377634e-01f, 2.42671650e-02f, -6.77395016e-02f, -2.28799675e-02f, -5.48030175e-02f, 6.00816384e-02f, 5.75114973e-03f, -5.10546118e-02f,
  -8.18541944e-02f, -2.36641355e-02f, 1.03653092e-02f, 1.19761508e-02f, 3.34159359e-02f, 2.62981430e-02f, 8.87535065e-02f, 9.46230516e-02f, 8.34770594e-03f, -6.69670291e-03f,
  -2.50738952e-02f, 7.56263360e-02f, -2.48520877e-02f, 5.76071441e-02f, 3.23086791e-02f, 2.76070908e-02f, 6.64300621e-02f, 5.56388646e-02f, -4.56606820e-02f, 1.03114489e-02f,
  1.66277379e-01f, 1.81657299e-01f, 2.03703687e-01f, 1.13957234e-01f, -1.92757607e-01f, -1.48679465e-01f, -1.29303604e-01f, -1.00351408e-01f, 1.08556421e-02f, 7.71392435e-02f,
  -2.28116401e-02f, 3.45386714e-01f, -6.40468672e-02f, 5.21484166e-02f, -1.13052689e-01f, -1.39298066e-01f, -1.03202008e-01f, 8.31020325e-02f, -1.04579693e-02f, -1.61920153e-02f,
  -1.27080172e-01f, -2.56777555e-01f, -1.09472252e-01f, -1.19288616e-01f, 1.52880102e-01f, 9.78226140e-02f, -1.25686318e-01f, -1.09646851e-02f, 6.91952854e-02f, 9.66467336e-02f,
  -3.06589268e-02f, -7.26404190e-02f, -1.17603159e-02f, 6.58290908e-02f, 1.28800385e-02f, -1.15610575e-02f, 1.00273162e-01f, 4.89066876e-02f, 5.76145612e-02f, 7.87828416e-02f,
  -3.44310068e-02f, 4.03142236e-02f, 9.54455435e-02f, 5.98186031e-02f, 1.47446385e-03f, 1.36886954e-01f, -3.74904051e-02f, 3.28264087e-02f, 9.80684757e-02f, 8.58431682e-02f,
  8.29364918e-03f, 4.75057252e-02f, -1.42656919e-02f, 7.90319219e-03f, 1.89670064e-02f, 3.76773924e-02f, 3.58718783e-02f, 8.84550065e-02f, -2.25189310e-02f, -1.41842943e-02f,
  2.35806853e-02f, -2.80095730e-02f, 2.19907537e-02f, 6.54413253e-02f, -2.33379251e-04f, 4.38948860e-03f, 6.46233559e-02f, -2.04838756e-02f, -9.14324597e-02f, -1.19627994e-02f,
  -8.37782696e-02f, 9.23924893e-02f, -8.12866464e-02f, 6.59329593e-02f, -1.09964557e-01f, -1.36164976e-02f, -1.16866045e-02f, 2.11698171e-02f, -1.18769154e-01f, 5.39745949e-02f,
  -1.63766127e-02f, -1.28922567e-01f, 4.15993333e-02f, 5.09906076e-02f, -8.11793804e-02f, 3.70267592e-02f, -4.70772525e-03f, -7.75627932e-03f, -1.79200750e-02f, -3.65069024e-02f,
  -2.13313922e-01f, -1.43041968e-01f, -1.94638241e-02f, -7.34390095e-02f, 6.07831106e-02f, 1.02013104e-01f, 1.90737136e-02f, 8.50901157e-02f, -7.19798058e-02f, -7.74192512e-02f,
  -3.03942021e-02f, -1.40952170e-02f, -5.53852879e-02f, 9.74089839e-04f, -5.22809438e-02f, 2.81674396e-02f, -7.40294755e-02f, -6.14942089e-02f, -7.06808567e-02f, 2.59469319e-02f,
  -9.39924791e-02f, 1.76353715e-02f, -5.26799187e-02f, -6.62358105e-03f, -9.33789685e-02f, 6.61451742e-02f, -4.15628664e-02f, 9.33057349e-03f, 1.01902477e-01f, -6.31644949e-02f,
  -3.48671004e-02f, -1.75301209e-01f, -6.34432659e-02f, -1.62205920e-01f, 1.31755412e-01f, 1.25686094e-01f, -1.45386457e-01f, 7.83022344e-02f, -2.23453596e-01f, 6.51356280e-02f,
  1.17852697e-02f, -1.57267377e-01f, -1.67269722e-01f, -1.82866335e-01f, -2.67202705e-01f, -1.72684729e-01f, -1.99492797e-02f, -5.74088879e-02f, -1.34132385e-01f, -1.49373440e-02f,
  -1.11993447e-01f, -3.31936433e-04f, -1.63138852e-01f, 1.18237145e-01f, 6.17224015e-02f, 1.17412381e-01f, 1.94978088e-01f, 9.28026289e-02f, 1.59533247e-01f, 1.52930897e-02f,
  5.49553223e-02f, -4.14034650e-02f, -2.58518700e-02f, 1.96013059e-02f, 2.08519995e-02f, 8.35889503e-02f, 1.49245724e-01f, 1.56109091e-02f, 2.08601672e-02f, -7.41495416e-02f,
  3.06477528e-02f, -1.67239085e-02f, -1.16047123e-02f, -7.11779892e-02f, 1.85449217e-02f, 4.00668345e-02f, -5.57797812e-02f, -2.36550346e-02f, -6.21066391e-02f, -3.99278253e-02f,
  -4.36957367e-02f, 4.12758663e-02f, 2.27829139e-03f, -1.98652670e-02f, -4.44640592e-02f, -1.10327356e-01f, -3.30015458e-02f, 7.04257330e-03f, 4.37961705e-02f, 1.70419347e-02f,
  -4.65878248e-02f, 2.07103230e-02f, -5.01843281e-02f, -1.82835702e-02f, -3.99919786e-02f, 2.49206591e-02f, -2.67457478e-02f, 2.45681945e-02f, -1.09021170e-02f, -1.34427231e-02f,
  -4.05858941e-02f, -4.67239926e-03f, -6.93230366e-04f, 3.31477672e-02f, 1.03600077e-01f, -7.60138333e-02f, 2.70881574e-03f, -2.61671580e-02f, -4.94486392e-02f, 3.45567451e-03f,
  4.67009544e-02f, 6.12191334e-02f, -3.46865058e-02f, 3.13979760e-02f, -4.08821814e-02f, -3.37420106e-02f, 9.09047276e-02f, -6.48559704e-02f, 2.95097288e-03f, 7.59443194e-02f,
  -1.29234185e-02f, 1.35271519e-01f, 4.18412462e-02f, 5.98024279e-02f, 4.68432084e-02f, 1.21880084e-01f, 6.65532574e-02f, -7.62865990e-02f, 1.89580384e-03f, -3.93350013e-02f,
  3.45558599e-02f, 4.65809181e-03f, 7.79790133e-02f, 4.15669717e-02f, 6.83751032e-02f, -3.92661951e-02f, 9.11270529e-02f, 1.15347356e-01f, 1.38091883e-02f, -1.79267526e-02f,
  1.16271898e-01f, 5.10690585e-02f, 4.48429063e-02f, 6.25036806e-02f, 1.08645678e-01f, 1.17293023e-01f, 1.22095689e-01f, -7.24903271e-02f, 4.56361705e-03f, -6.53822124e-02f,
  1.40981525e-01f, 2.16507897e-01f, 1.86736315e-01f, 8.03253800e-02f, -1.11737654e-01f, -1.29980594e-01f, -1.30922630e-01f, 5.21565648e-03f, -3.53747956e-03f, 3.23920734e-02f,
  -5.91353402e-02f, 1.71850711e-01f, -4.69671469e-03f, 9.99634266e-02f, -6.74897283e-02f, -9.35083926e-02f, 1.13025017e-01f, 5.85211292e-02f, 1.07624188e-01f, 1.12491742e-01f,
  1.07247792e-01f, -8.84345174e-02f, 6.21583275e-02f, 4.93985936e-02f, 8.77884477e-02f, 1.77772105e-01f, -5.24514392e-02f, -9.77924243e-02f, -1.13963913e-02f, 2.39042696e-02f,
  -1.08542293e-01f, -9.50754434e-03f, 3.78518016e-03f, -4.84634675e-02f, 3.00707482e-02f, -6.81036785e-02f, 1.07355323e-02f, -4.09053192e-02f, 2.45436486e-02f, -6.74199313e-02f,
  5.10537364e-02f, -5.23480214e-03f, 3.22305202e-03f, 1.34740481e-02f, -7.29784369e-03f, -1.21018123e-02f, -5.84426373e-02f, 6.23986833e-02f, 2.70310268e-02f, 7.31901452e-02f,
  4.05679569e-02f, -7.18151107e-02f, -4.05399092e-02f, 3.56903337e-02f, 1.02121949e-01f, 8.31034780e-02f, -1.02959957e-03f, 1.23811569e-02f, -1.88182704e-02f, -3.91221829e-02f,
  9.71643701e-02f, -1.09682292e-01f, -8.87520760e-02f, -7.02040493e-02f, -1.38539970e-01f, -6.71951547e-02f, -1.25267170e-02f, 1.64054912e-02f, -4.78703193e-02f, 2.92162765e-02f,
  -1.18226811e-01f, 6.72650859e-02f, -8.32588077e-02f, 3.13255936e-02f, 4.09325510e-02f, 2.79568471e-02f, 1.11477617e-02f, -2.09613517e-02f, -6.81944191e-02f, -8.21723603e-03f,
  -4.54604998e-02f, -3.89416739e-02f, 1.24892443e-02f, -3.30667123e-02f, -1.11788362e-01f, -8.85380246e-03f, 9.12047327e-02f, -7.57197067e-02f, -2.20913924e-02f, -1.15014554e-03f,
  2.59124227e-02f, 7.96316639e-02f, 9.78819579e-02f, 6.24201167e-03f, 2.85927989e-02f, -6.04971685e-03f, -5.27057536e-02f, -1.12406453e-02f, 6.51703170e-03f, -4.25596237e-02f,
  1.77142452e-02f, -1.95999034e-02f, 1.39764817e-02f, -4.12215702e-02f, -2.47314852e-02f, 1.82560515e-02f, -7.19493479e-02f, 7.64653310e-02f, 5.32005690e-02f, 8.78337026e-02f,
  -5.98647213e-03f, 2.71071456e-02f, -8.06600600e-02f, 2.38597449e-02f, 1.05163701e-01f, -7.10424548e-03f, 3.65200266e-02f, 4.02751006e-02f, -3.77406292e-02f, 1.03736982e-01f,
  1.15172416e-01f, 4.07858752e-02f, -1.61187917e-01f, -9.01729167e-02f, 3.11544235e-03f, 1.16092071e-01f, 2.70869005e-02f, -5.72791509e-02f, -9.71671343e-02f, 2.18166217e-01f,
  6.13344051e-02f, -7.87395239e-02f, -1.33394390e-01f, 1.87098742e-01f, 2.27688793e-02f, 7.13341963e-03f, 2.32774466e-01f, 1.62687972e-01f, -6.38621375e-02f, 7.15781823e-02f,
  7.40759788e-05f, 2.39322126e-01f, -2.06063449e-01f, 2.63853613e-02f, 5.60018010e-02f, -5.92217147e-02f, 5.16656041e-02f, -1.32799014e-01f, 2.11675137e-01f, 7.78835863e-02f,
  9.34949666e-02f, -6.20165467e-03f, 1.17976237e-02f, -7.53399208e-02f, 1.99566968e-02f, 7.72091895e-02f, -3.26076746e-02f, 3.41803841e-02f, -1.06081575e-01f, 5.69847301e-02f,
  5.45258559e-02f, 2.49063745e-02f, 9.86892432e-02f, -2.87582688e-02f, 4.13348200e-04f, 2.73284018e-02f, -9.82662290e-02f, -3.94636393e-02f, -9.72392559e-02f, -8.59848112e-02f,
  -1.00420773e-01f, 4.71454626e-03f, -3.36051174e-02f, -3.15828659e-02f, 2.26890743e-02f, -6.67894632e-02f, -3.21530811e-02f, -3.25841941e-02f, 3.43866087e-02f, 3.51792537e-02f,
  7.36702681e-02f, -5.32158539e-02f, -3.12321354e-02f, -4.04357910e-02f, 1.13489116e-02f, -5.55351526e-02f, 1.02437483e-02f, -5.43288775e-02f, -6.56545758e-02f, 3.48872356e-02f,
  -2.01397128e-02f, -3.93375941e-02f, 1.17189893e-02f, 7.79286548e-02f, 1.26138836e-01f, -3.66424024e-02f, -4.14208174e-02f, -4.31745760e-02f, -9.12218466e-02f, 6.29446805e-02f,
  3.50602679e-02f, -1.18742958e-02f, -2.52740011e-02f, 5.83238974e-02f, -1.14472033e-02f, -9.80935693e-02f, -2.58118901e-02f, -2.40904242e-02f, -1.73145942e-02f, 6.36211112e-02f,
  9.05921385e-02f, 2.20556647e-01f, -8.32452625e-02f, -6.30256385e-02f, -4.77588223e-03f, -5.08368909e-02f, -8.38364009e-03f, 1.69941150e-02f, 4.41876128e-02f, -4.06655930e-02f,
  1.05381086e-01f, 1.69564355e-02f, 3.45716104e-02f, -1.27364755e-01f, 1.89500805e-02f, 5.62173314e-02f, 7.58761168e-02f, -2.55123782e-03f, -1.17737222e-02f, -4.14544083e-02f,
  -2.89315227e-02f, 6.62146509e-03f, 2.89676320e-02f, 6.23371601e-02f, 4.64724675e-02f, 5.63978590e-02f, -2.76246052e-02f, -5.95667474e-02f, 9.04335901e-02f, -4.87994924e-02f,
  -2.30443701e-01f, -3.10264397e-02f, 1.68763652e-01f, -3.32098782e-01f, 6.69894516e-02f, 1.54146895e-01f, -6.54406846e-02f, 4.67183627e-03f, -1.70180559e-01f, -2.09204122e-01f,
  -1.14188179e-01f, -1.28044263e-02f, 8.47276449e-02f, -1.72403932e-01f, 2.25990623e-01f, 1.19548365e-01f, -1.21087246e-01f, -1.11844592e-01f, 1.58915788e-01f, -8.37504342e-02f,
  -1.10555729e-02f, 2.13118177e-03f, 1.13777243e-01f, 1.32901231e-02f, -1.14292033e-01f, -2.01950386e-01f, -3.04481983e-02f, 1.75311819e-01f, -1.48850814e-01f, 4.67558540e-02f,
  -5.96651249e-02f, -6.05759732e-02f, 9.68585461e-02f, -2.05894671e-02f, 4.24781851e-02f, -4.88178730e-02f, -3.14173065e-02f, 6.12594187e-03f, -9.39158574e-02f, -2.38578599e-02f,
  -3.19656283e-02f, 4.00641421e-03f, -1.91203281e-01f, 1.57850105e-02f, -9.42337140e-02f, -1.46436356e-02f, 5.55964634e-02f, -1.75619461e-02f, -1.17062004e-02f, -3.41870892e-03f,
  6.91261515e-02f, -1.89054720e-02f, 1.82158668e-02f, -1.12610355e-01f, 7.72266760e-02f, -3.23282704e-02f, 5.89545034e-02f, -1.70110527e-03f, 1.65423360e-02f, -1.20859379e-02f,
  6.08220771e-02f, -2.95757484e-02f, 1.26359567e-01f, 4.24629673e-02f, -3.72100039e-03f, -6.51751310e-02f, -3.35789807e-02f, -1.06425723e-02f, -2.04854347e-02f, 4.38740812e-02f,
  -1.00382805e-01f, -8.89207199e-02f, -1.16823185e-02f, 4.96936440e-02f, 8.35323408e-02f, -8.80638957e-02f, 1.30145513e-02f, -3.43431346e-02f, -3.39716002e-02f, -5.10984249e-02f,
  -2.69314134e-03f, -2.84342375e-02f, -9.61637795e-02f, -2.00899132e-03f, 3.37736867e-02f, 1.00887381e-02f, -4.96389903e-02f, 6.89760521e-02f, -5.64312451e-02f, 3.33024040e-02f,
  -1.30784303e-01f, -1.95823237e-01f, 6.70843646e-02f, 2.45630499e-02f, 1.54735846e-02f, 2.25018878e-02f, 3.13050002e-02f, -4.86369841e-02f, -7.02886134e-02f, -1.77392606e-02f,
  3.18511836e-02f, -1.60892028e-02f, 1.20932544e-02f, 2.68887170e-02f, -1.25156008e-02f, 3.64530832e-02f, -1.37961078e-02f, -5.77242188e-02f, 3.86614129e-02f, -6.30229618e-03f,
  -9.81553365e-03f, -1.21344952e-02f, 2.49135345e-02f, -2.74764691e-02f, -7.29777757e-03f, -2.01343819e-02f, -4.93554138e-02f, -3.34163085e-02f, 4.30346057e-02f, -4.48095985e-02f,
  8.66405740e-02f, 1.69057921e-01f, -3.01957726e-02f, 1.01435058e-01f, -1.49056599e-01f, -2.20870554e-01f, -8.37623551e-02f, 2.34115985e-04f, 1.63522381e-02f, -8.78439322e-02f,
  -9.15025268e-03f, 7.62575865e-02f, 6.01107813e-02f, 2.13525705e-02f, -2.87531670e-02f, -2.89304107e-02f, 6.12943433e-03f, 1.63888064e-04f, 8.70399922e-02f, -3.72844115e-02f,
  9.57352445e-02f, -5.55789052e-03f, -2.64150370e-02f, -9.50199664e-02f, 6.71524629e-02f, 1.17428936e-01f, -5.17548807e-03f, -2.79888324e-02f, -2.98357252e-02f, 4.09609936e-02f,
  9.92294494e-03f, 1.65996954e-01f, 9.40453075e-03f, 2.15333719e-02f, -5.42102307e-02f, -7.24546611e-02f, -1.11671463e-02f, -3.99298109e-02f, -2.39188783e-02f, -8.97623040e-03f,
  -2.67869718e-02f, -6.80121556e-02f, 4.86318022e-02f, 3.83944139e-02f, -7.72188529e-02f, 1.57567393e-02f, 4.76249643e-02f, -2.67617982e-02f, -5.70984110e-02f, -1.52287455e-02f,
  5.29931486e-02f, -2.05156039e-02f, -3.28551829e-02f, -2.43249685e-02f, 4.49731899e-03f, -1.18949385e-02f, -4.94533964e-02f, -7.98528194e-02f, 8.11290070e-02f, 1.17049471e-01f,
  9.87297669e-02f, -9.20708664e-03f, 5.14113531e-02f, -8.67753625e-02f, 3.29318307e-02f, 7.10381791e-02f, -1.44444527e-02f, -1.56426914e-02f, 5.83475493e-02f, 5.49696386e-02f,
  -7.14107454e-02f, -6.78533092e-02f, -3.80285829e-02f, -5.76298013e-02f, -1.70055721e-02f, 4.43549529e-02f, 2.13759132e-02f, 1.94027349e-02f, -2.00383626e-02f, -1.12940624e-01f,
  -1.50345908e-02f, -7.21778423e-02f, 6.04499280e-02f, -1.25645511e-02f, -4.56213020e-02f, 9.16782543e-02f, 7.10844621e-02f, -3.67780663e-02f, -7.66379461e-02f, -1.04344143e-02f,
  9.70575586e-03f, 2.04639480e-01f, -4.57196720e-02f, 1.17652584e-03f, 7.88972452e-02f, 5.04213981e-02f, 2.21522409e-03f, 8.20924118e-02f, 7.51235783e-02f, 9.28498507e-02f,
  1.71136751e-03f, -6.42717853e-02f, 5.52514791e-02f, -4.70693558e-02f, 1.50839798e-02f, -8.10053796e-02f, -1.91890150e-02f, 9.73288417e-02f, -4.43173274e-02f, -2.73989383e-02f,
  3.06376107e-02f, 2.10229196e-02f, 8.99534672e-02f, -8.52698162e-02f, -1.31174669e-01f, -4.77429554e-02f, -6.46740422e-02f, -7.59867653e-02f, 5.54264188e-02f, 2.87650172e-02f,
  1.50042534e-01f, -3.22693020e-01f, 5.10114357e-02f, 1.52841628e-01f, 1.52029932e-01f, 7.96830654e-02f, 1.41595379e-01f, -1.60380110e-01f, 3.81512530e-02f, -2.43836328e-01f,
  8.63220617e-02f, 3.89508232e-02f, 8.17497298e-02f, 9.50609241e-03f, 3.15455824e-01f, 3.71480025e-02f, 1.35759577e-01f, 6.92545548e-02f, -4.86169979e-02f, -8.50247741e-02f,
  1.90563463e-02f, -4.09197956e-02f, -1.87620725e-02f, -1.42598674e-01f, 1.27197102e-01f, 1.79202687e-02f, 8.00647214e-03f, 1.76505335e-02f, -8.77617300e-03f, 1.17347732e-01f,
  2.60406639e-02f, -7.04225972e-02f, -3.23454291e-02f, -1.09739706e-01f, -4.71098647e-02f, -8.97423252e-02f, 4.00713757e-02f, 1.10747032e-02f, -6.86190976e-03f, -6.40970394e-02f,
  -2.06595976e-02f, 6.36603171e-03f, 2.17324346e-02f, -3.83615233e-02f, -7.70690963e-02f, 2.66632214e-02f, 1.90134570e-02f, 3.60866599e-02f, -1.04427859e-01f, 3.07564512e-02f,
  -2.71973312e-02f, -1.09943505e-02f, 1.54374251e-02f, -9.71511230e-02f, -4.80563492e-02f, 1.79548077e-02f, 3.47064696e-02f, 4.13090773e-02f, -1.39431924e-01f, 8.92743915e-02f,
  -3.74898724e-02f, 8.89289305e-02f, -2.28134077e-02f, -6.03181161e-02f, 2.93007344e-02f, -3.75015214e-02f, -1.67946629e-02f, 6.66128471e-02f, 1.09540805e-01f, 9.06227753e-02f,
  -1.58726145e-02f, -4.89246361e-02f, 6.76756203e-02f, 1.61216613e-02f, -3.28321382e-03f, -8.45779106e-02f, -1.65107846e-02f, 4.93785217e-02f, -6.30775187e-03f, 4.55400385e-02f,
  4.28727567e-02f, 2.16720384e-02f, 1.49573637e-02f, -1.43225770e-02f, -4.03511301e-02f, 4.19543721e-02f, -7.15774447e-02f, 4.79499325e-02f, 5.89750782e-02f, 6.37073815e-02f,
  -1.18850023e-01f, -2.54017234e-01f, -1.30301919e-02f, -4.45677042e-02f, 2.51682084e-02f, -6.75067902e-02f, 4.22520451e-02f, 3.14155743e-02f, -1.03858583e-01f, -2.67616590e-03f,
  2.23425077e-03f, 7.79109150e-02f, -1.01713687e-01f, -2.39913855e-02f, -5.70383407e-02f, -1.41536415e-01f, 1.11686841e-01f, -2.60175467e-02f, 1.23160100e-02f, 3.33132260e-02f,
  -4.44464684e-02f, -2.63474062e-02f, -2.65076887e-02f, 2.11711805e-02f, -7.17132986e-02f, 9.28525701e-02f, 2.21787002e-02f, -5.36454981e-03f, -2.98925955e-02f, -4.22698781e-02f,
  3.01868945e-01f, -1.19545229e-01f, -5.49054332e-03f, 5.81402667e-02f, 9.40415449e-03f, 8.12812224e-02f, 1.33987710e-01f, 8.02650228e-02f, 2.06882954e-01f, -2.69233108e-01f,
  -1.58947986e-02f, -5.94348125e-02f, -2.13646263e-01f, 2.82924473e-02f, 9.03668255e-02f, -1.33151591e-01f, 1.01356031e-02f, -6.65332675e-02f, -4.55984697e-02f, 4.08456326e-02f,
  1.39515489e-01f, 8.69480222e-02f, 4.64713126e-02f, -7.79021904e-02f, 9.33728367e-02f, 4.34636287e-02f, 4.64127120e-03f, -7.01046959e-02f, -1.73963085e-02f, -1.52778681e-02f,
  7.93723837e-02f, -3.63335311e-02f, 5.80153875e-02f, 1.67875364e-02f, -9.90120023e-02f, 3.38938273e-02f, 7.38909654e-03f, 7.22209960e-02f, 9.32485387e-02f, -1.22278690e-01f,
  -9.55225155e-02f, 7.09281787e-02f, -5.08829989e-02f, 9.41641331e-02f, 6.17928505e-02f, 6.31556660e-02f, -1.25781232e-02f, -3.39881293e-02f, 5.51199317e-02f, 5.46355210e-02f,
  2.91124638e-02f, -2.26384159e-02f, 5.59927523e-02f, 3.98323089e-02f, 4.28243428e-02f, 9.34692845e-02f, -7.68274218e-02f, -9.55802351e-02f, 1.27350558e-02f, 6.35927767e-02f,
  -1.32716879e-01f, -3.74677218e-02f, 2.24830974e-02f, 8.84229615e-02f, 4.60100956e-02f, 8.56153816e-02f, 2.99611837e-02f, 2.51419246e-02f, 6.99212253e-02f, -3.95506658e-02f,
  7.98240900e-02f, 6.84290305e-02f, 1.25483219e-02f, -1.91285722e-02f, 2.07632873e-02f, -3.39310877e-02f, 1.08015656e-01f, 2.24036239e-02f, -4.18799557e-02f, -1.64107718e-02f,
  -4.26511317e-02f, -2.05046460e-02f, -5.02014591e-04f, 7.72378743e-02f, -4.98114899e-02f, -3.21543962e-02f, 1.22453254e-02f, 1.92830376e-02f, 2.50438843e-02f, 8.33814219e-03f,
  -1.36305302e-01f, -2.75611341e-01f, 2.39659473e-02f, 7.06311911e-02f, -3.98946321e-03f, -9.03947800e-02f, -4.36637290e-02f, -1.25775561e-02f, 1.19466148e-02f, -2.70595606e-02f,
  5.64244436e-03f, -2.41888165e-02f, 2.29003467e-02f, 4.60065193e-02f, 2.02004071e-02f, 4.49840389e-02f, 6.96852431e-02f, 3.93797411e-03f, 5.64780608e-02f, -3.70543227e-02f,
  3.83742787e-02f, 2.78650615e-02f, -3.18751894e-02f, 4.75970954e-02f, -4.52253893e-02f, 1.61213037e-02f, 4.46529640e-03f, -5.98860858e-03f, 2.25933753e-02f, -2.76588695e-03f,
  2.29825556e-01f, -2.59182245e-01f, -1.68712601e-01f, -6.43658563e-02f, 1.42785907e-02f, 1.63476318e-01f, 1.23854667e-01f, 2.49309707e-02f, -3.86163108e-02f, -1.47848710e-01f,
  5.58406226e-02f, -1.16914019e-01f, -2.54701125e-03f, 1.63805500e-01f, 3.62830222e-01f, -1.08152978e-01f, 1.75144404e-01f, -3.28132287e-02f, 3.12779471e-02f, 3.25093083e-02f,
  8.98466110e-02f, 1.95787892e-01f, -8.32664520e-02f, -8.00362602e-02f, 1.04865931e-01f, -5.97408563e-02f, -5.53334877e-02f, -2.14698687e-02f, 1.03552900e-01f, 5.95525242e-02f,
  1.02197044e-01f, 2.85413302e-02f, -3.00802570e-02f, -9.26318094e-02f, -5.74665591e-02f, 3.21115069e-02f, -5.95518760e-02f, 1.12963729e-01f, 1.22185536e-02f, 4.76047285e-02f,
  -6.50014787e-04f, 6.10091165e-02f, 1.26497239e-01f, 7.60891214e-02f, -1.36681339e-02f, 2.63447911e-02f, 1.39355576e-02f, -1.14390366e-01f, -5.89972502e-03f, 1.10707439e-01f,
  -1.37994466e-02f, -9.94611904e-02f, -3.26722562e-02f, -9.75418836e-02f, 3.09025198e-02f, -2.53113024e-02f, -2.17267890e-02f, -2.82181101e-03f, -1.03323475e-01f, -5.18330857e-02f,
  1.06407836e-01f, -1.08175501e-01f, 9.48377922e-02f, 6.34503961e-02f, -2.65442207e-03f, -1.72288518e-03f, -6.07549213e-02f, -7.65852630e-02f, -8.70729461e-02f, 4.57484163e-02f,
  -9.08388048e-02f, 6.78496584e-02f, 4.04346846e-02f, -5.81078418e-02f, -5.94483549e-03f, 4.10634540e-02f, 1.14573669e-02f, 1.16134644e-01f, -9.42764163e-04f, 6.46598861e-02f,
  1.37069561e-02f, -1.34999137e-02f, -1.97709091e-02f, 1.09828174e-01f, -8.31999034e-02f, 8.14502779e-03f, 1.05368614e-01f, -5.93768619e-02f, 3.54664475e-02f, -1.15714230e-01f,
  -1.26258835e-01f, -2.85245366e-02f, -1.06748477e-01f, 3.26153561e-02f, -5.36317155e-02f, 5.25152311e-02f, 1.14815300e-02f, -4.71934862e-02f, -6.16698489e-02f, -4.76260902e-04f,
  -7.97224343e-02f, -1.18708201e-02f, -4.80681136e-02f, 1.02917403e-01f, -8.30340311e-02f, 6.16609938e-02f, -6.42681494e-02f, -3.33694066e-03f, 4.95532490e-02f, -1.11044616e-01f,
  -5.64582869e-02f, -1.30905099e-02f, -5.93924858e-02f, -5.64202666e-02f, -4.48985212e-02f, -8.70669559e-02f, 2.11708229e-02f, -7.01770931e-02f, -5.93200419e-03f, 3.88430171e-02f,
  -1.90363184e-01f, 4.49910909e-02f, -1.62451833e-01f, -1.97117940e-01f, -2.05526017e-02f, -2.85709828e-01f, -2.52388597e-01f, 6.52267411e-02f, -1.23877428e-01f, -1.46728279e-02f,
  -7.44074732e-02f, 1.63458511e-02f, -5.09424275e-03f, -1.90737575e-01f, -1.60709396e-01f, -7.37661049e-02f, -2.92002261e-01f, -2.73167342e-02f, -2.68381066e-03f, -1.66369826e-01f,
  1.06628360e-02f, -1.48090720e-01f, -8.62350240e-02f, 9.32412148e-02f, -1.22953095e-01f, 9.16567072e-02f, -5.60922995e-02f, 1.19783565e-01f, -9.15510803e-02f, -6.59104586e-02f,
  -1.65981293e-01f, 2.61319391e-02f, -5.43414466e-02f, 1.09020382e-01f, -1.36467561e-01f, -6.30813166e-02f, 2.84913871e-02f, -2.48866212e-02f, -5.50968535e-02f, -9.90007594e-02f,
  9.63107571e-02f, -1.55286277e-02f, 4.47180262e-03f, -1.17962928e-02f, 3.52647938e-02f, 9.16498825e-02f, 4.80875820e-02f, 5.68015641e-03f, -1.32649615e-02f, 5.09924144e-02f,
  -7.14030638e-02f, -1.76034980e-02f, -1.62440334e-02f, -7.00062886e-02f, 3.28906476e-02f, 3.68584357e-02f, -2.74254121e-02f, 9.44178179e-03f, -4.27429788e-02f, -1.11978807e-01f,
  7.86995217e-02f, -7.31127188e-02f, 5.61915152e-02f, 2.76785363e-02f, -8.86359587e-02f, 3.61486822e-02f, -4.14780863e-02f, -2.30161659e-02f, -8.44247453e-03f, -2.70215478e-02f,
  9.98279732e-03f, 2.31781192e-02f, 8.01597442e-03f, -6.34371266e-02f, -3.90571505e-02f, -1.99883301e-02f, -3.52583453e-02f, -4.28480804e-02f, 1.22754853e-02f, 9.50581022e-03f,
  -4.80446815e-02f, 1.69329662e-02f, -1.40391383e-02f, -1.18780294e-02f, -1.14093563e-02f, -2.95914169e-02f, 2.07373984e-02f, -4.35985345e-03f, -6.22308739e-02f, 2.26167031e-03f,
  -2.55224437e-01f, -7.88223445e-02f, 2.75787176e-03f, -3.64445746e-02f, -4.79046553e-02f, 4.49218899e-02f, 1.62693355e-02f, -1.50700688e-01f, -3.34581248e-02f, 5.26550040e-02f,
  -6.65092841e-02f, 3.07778199e-03f, -5.66815212e-02f, -1.89096443e-02f, 5.98899461e-03f, -1.05973080e-01f, 2.89443340e-02f, 9.75863356e-03f, -3.45673300e-02f, -4.09591272e-02f,
  3.89903784e-02f, -3.34590040e-02f, 5.84123358e-02f, -6.08178154e-02f, 4.01717946e-02f, -9.84175429e-02f, 2.97218617e-02f, 8.72408599e-03f, 5.14994003e-03f, -2.07202062e-02f,
  6.55293986e-02f, -1.39828488e-01f, 9.75804850e-02f, 2.23069534e-01f, 3.50270187e-03f, -2.33628184e-01f, -9.65793356e-02f, 1.16353044e-02f, 6.54209172e-04f, -4.93740626e-02f,
  3.70534696e-02f, -4.44217212e-02f, -2.33131677e-01f, -4.07584058e-03f, 1.51948497e-01f, -1.98458314e-01f, 4.09450568e-02f, -8.38876888e-02f, 2.69546714e-02f, 1.23333737e-01f,
  9.70561132e-02f, 1.00756306e-02f, 2.07729578e-01f, 2.35500976e-01f, 6.56503141e-02f, 2.27226034e-01f, 1.99178442e-01f, 4.03149761e-02f, 2.20885649e-01f, -4.84103151e-03f,
  9.13269911e-03f, -4.25289273e-02f, 4.52074148e-02f, -1.05813310e-01f, 3.99920940e-02f, -5.57791740e-02f, 1.27014052e-02f, -6.52753040e-02f, 1.56686939e-02f, -6.50775358e-02f,
  -9.54784453e-02f, 3.13995257e-02f, 4.63279057e-03f, -4.08591479e-02f, 5.53842448e-02f, 7.11640641e-02f, -3.23984027e-02f, 2.62585096e-02f, 3.09362449e-02f, -5.38856871e-02f,
  -6.57733455e-02f, 6.99311867e-03f, 1.37735084e-01f, -1.00168571e-01f, 8.62386748e-02f, 9.07601975e-03f, 7.00428560e-02f, -5.01134098e-02f, 1.92364398e-02f, 6.95857927e-02f,
  -1.23481266e-01f, -9.42436047e-03f, 3.24143693e-02f, -6.69820681e-02f, 3.16353887e-02f, 1.21460548e-02f, 8.90604705e-02f, 7.39386231e-02f, 8.59486386e-02f, 2.55824123e-02f,
  6.33556843e-02f, 9.49782729e-02f, 4.54968810e-02f, 2.09443029e-02f, -8.06486886e-03f, -6.76790299e-03f, 2.11969409e-02f, -5.50206155e-02f, -9.38102081e-02f, -2.46789288e-02f,
  2.86683049e-02f, -3.48476097e-02f, -4.06622002e-03f, -5.70241660e-02f, -7.09822103e-02f, -5.12817502e-03f, -6.16563577e-03f, -1.58932451e-02f, -1.02193311e-01f, 2.56774612e-02f,
  2.21445765e-02f, -9.82826129e-02f, 8.39368999e-03f, -3.26722451e-02f, -5.02847917e-02f, 4.33358699e-02f, -5.63300550e-02f, -5.11950143e-02f, -1.76996645e-02f, 1.00309225e-02f,
  -8.65209009e-03f, 2.19225828e-02f, 5.00085950e-03f, 5.76776266e-02f, 4.14467864e-02f, -2.92252824e-02f, -8.93162712e-02f, -7.78931007e-03f, -1.74808893e-02f, -1.93069433e-03f,
  -5.66917658e-02f, -1.38966352e-01f, -7.24236220e-02f, 2.94917990e-02f, -1.26754083e-02f, 1.19834691e-02f, 1.85558498e-02f, -1.53230503e-02f, -5.73176816e-02f, 1.97940040e-04f,
  -5.21948040e-01f, 3.63920599e-01f, -5.34262769e-02f, -1.26084045e-01f, 5.09069823e-02f, 9.43478942e-02f, 1.17475368e-01f, 6.70683235e-02f, -3.32806110e-02f, 1.08480886e-01f,
  -9.56309028e-03f, -1.28293514e-01f, 1.14796393e-01f, 9.23263729e-02f, -3.01786453e-01f, 8.87964368e-02f, 7.55330324e-02f, -3.58776413e-02f, 1.48223191e-02f, 7.59455701e-03f,
  8.91127717e-03f, 3.54694575e-02f, 2.05739383e-02f, 1.44051731e-01f, -2.39861757e-02f, 3.99086960e-02f, -1.26549616e-01f, -5.10262139e-02f, 1.34848446e-01f, -9.72642973e-02f,
  -2.14020997e-01f, -2.13232756e-01f, -1.74149871e-01f, -1.73561290e-01f, -1.42883196e-01f, -6.37471825e-02f, -1.03218317e-01f, -3.16925943e-02f, -5.16917780e-02f, -1.03391513e-01f,
  -4.84086312e-02f, 4.94326539e-02f, -4.26334329e-02f, 3.21341567e-02f, -2.22536922e-02f, 4.77698594e-02f, 6.33259583e-03f, 5.66788465e-02f, 2.42118165e-02f, 1.63193755e-02f,
  4.30991501e-02f, -2.60489956e-02f, 5.84561191e-02f, 6.36892170e-02f, 9.76463128e-03f, -2.98503134e-02f, -5.14141843e-02f, 1.21653946e-02f, -2.73371786e-02f, -5.04141487e-03f,
  -4.18440662e-02f, 6.76991127e-04f, 8.42242762e-02f, -9.70901772e-02f, 8.18060860e-02f, 7.11411936e-03f, 2.16722023e-02f, -3.37483697e-02f, 2.05520075e-02f, -7.35489503e-02f,
  -9.69563723e-02f, -1.10649176e-01f, 3.72601463e-03f, -4.26370241e-02f, 2.28877291e-02f, 1.53480452e-02f, -1.29049122e-02f, -1.00403942e-01f, 4.06271368e-02f, -5.73804490e-02f,
  -1.08346194e-02f, -1.00332789e-01f, 9.74997655e-02f, 5.43631501e-02f, 3.96114774e-02f, -7.71762803e-02f, -1.25033734e-02f, 6.48823055e-03f, -8.30280222e-03f, -3.90617289e-02f,
  -9.21488479e-02f, -2.03657061e-01f, -5.76157682e-02f, -4.16503521e-03f, -9.09682959e-02f, -2.10018959e-02f, 2.49903910e-02f, 6.75621703e-02f, -3.13767865e-02f, 6.08745739e-02f,
  -1.11886568e-01f, 2.71731541e-02f, 4.59444884e-04f, -3.04503832e-02f, 3.66399088e-03f, -3.80320624e-02f, -6.50487170e-02f, -1.23610482e-01f, -8.46075416e-02f, -4.30372208e-02f,
  7.22390506e-03f, 4.49781725e-03f, -5.26561700e-02f, -1.54552748e-02f, -3.58738638e-02f, 3.86821032e-02f, -6.31278604e-02f, -1.76496468e-02f, 5.45101613e-02f, 1.19337998e-01f,
  -1.28678218e-01f, -1.59411550e-01f, 9.16445628e-02f, -1.21440679e-01f, 1.54759064e-01f, 2.45115206e-01f, 1.10113114e-01f, -6.46511167e-02f, -2.08295643e-01f, -4.18823771e-02f,
  -8.46899766e-03f, -9.08566639e-02f, -5.37201315e-02f, -1.54503718e-01f, -1.02635697e-01f, -1.85063943e-01f, -2.60953568e-02f, -1.37777910e-01f, -8.36830735e-02f, -2.78747678e-02f,
  5.87890036e-02f, -1.02738850e-01f, 1.21695705e-01f, 3.40712629e-02f, 1.25526693e-02f, 6.28938675e-02f, 1.20088950e-01f, 1.83813825e-01f, 8.57555959e-03f, -6.16175793e-02f,
  3.14114541e-02f, -5.41504174e-02f, 1.10918783e-01f, -4.94638551e-03f, 7.41638765e-02f, 1.50018260e-02f, 7.25445524e-02f, 4.09669019e-02f, 3.78239155e-02f, 5.87625988e-02f,
  1.10074483e-01f, 6.01967387e-02f, -5.91218919e-02f, 6.97897300e-02f, -3.68589759e-02f, -4.04602997e-02f, 8.39149803e-02f, 1.01728261e-01f, 8.32429007e-02f, -6.30162209e-02f,
  -9.94944852e-03f, -4.68166079e-03f, -4.43462767e-02f, -8.45654085e-02f, -2.33169179e-02f, -5.23505919e-02f, 1.97556000e-02f, -4.05114256e-02f, -1.36193307e-02f, 2.31069922e-02f,
  2.23935675e-02f, 4.62097563e-02f, -1.16321810e-01f, -1.64169177e-01f, -8.88659880e-02f, -1.27656152e-03f, -4.15063389e-02f, -8.41266662e-02f, -6.52318820e-02f, 1.31671317e-03f,
  -2.07047500e-02f, -2.86807981e-03f, -8.22930261e-02f, 2.61442605e-02f, 4.68959054e-03f, 2.31328607e-02f, 7.07738474e-02f, 2.84302495e-02f, 5.20930663e-02f, 8.12125206e-02f,
  -4.04304340e-02f, 3.33756842e-02f, 5.01268283e-02f, -2.85548158e-02f, -5.71619086e-02f, 8.14143941e-02f, -6.13338919e-03f, -4.57001403e-02f, -1.58571042e-02f, 4.12306562e-03f,
  2.11229008e-02f, -6.13659285e-02f, -1.05936475e-01f, -4.79650050e-02f, -7.52584860e-02f, 8.17020237e-02f, 7.12510606e-04f, -9.84012038e-02f, -4.29945812e-03f, -6.21648394e-02f,
  1.17847286e-01f, 5.97436801e-02f, 2.48288345e-02f, -6.28948212e-02f, 3.71777378e-02f, 7.42940307e-02f, -3.61020267e-02f, -1.22054182e-02f, 1.31199911e-01f, -4.96886857e-03f,
  -5.11707179e-02f, -5.20114340e-02f, 2.58139204e-02f, -3.55983488e-02f, 5.94317429e-02f, -1.39639199e-01f, -2.00969148e-02f, 7.63057992e-02f, -1.31616704e-02f, 5.60689792e-02f,
  4.48761210e-02f, 1.25145674e-01f, -2.03513168e-02f, 4.82690819e-02f, -8.53341222e-02f, -2.51577169e-01f, -2.09077328e-01f, -7.85076022e-02f, 7.57856146e-02f, 1.64631400e-02f,
  -1.68315947e-01f, 2.07144707e-01f, -8.63045231e-02f, -2.35074316e-03f, 6.63628010e-03f, 7.12179840e-02f, -1.00677401e-01f, -1.61100589e-02f, 9.00434516e-03f, -3.82422321e-02f,
  -1.27225127e-02f, -5.46280146e-02f, 1.63016632e-01f, -7.47709572e-02f, -1.03024334e-01f, 6.14361577e-02f, 9.89624485e-02f, -4.30004671e-02f, -6.41735941e-02f, -8.05856287e-02f,
  -9.00439397e-02f, 1.50525421e-01f, 1.26083702e-01f, 2.55514178e-02f, 3.74216586e-02f, -9.14181769e-02f, -8.95754546e-02f, 6.95248023e-02f, -4.40053530e-02f, 2.36350950e-02f,
  4.18740697e-02f, -8.09961930e-03f, -8.98543894e-02f, -3.64626013e-02f, -5.94100263e-03f, -5.81488870e-02f, 8.90546218e-02f, 5.27689531e-02f, 7.85482377e-02f, -4.15172428e-02f,
  2.40609273e-02f, -7.54916668e-03f, -2.89288089e-02f, 1.49294421e-01f, 5.96758015e-02f, 1.87364258e-02f, -1.13871373e-01f, 2.64971182e-02f, -7.96488672e-03f, 5.78396656e-02f,
  1.48959807e-04f, -7.87631795e-02f, 2.61925571e-02f, 1.01270759e-02f, -3.41346785e-02f, -1.04213312e-01f, -2.87400540e-02f, -3.06271892e-02f, -4.19724286e-02f, 1.94318444e-02f,
  6.05899543e-02f, 3.83068323e-02f, 2.10653655e-02f, -6.59862831e-02f, 4.95064817e-02f, 8.51393938e-02f, 7.68974125e-02f, -5.69202602e-02f, 1.74787808e-02f, 7.64913345e-03f,
  7.39792660e-02f, -2.06596348e-02f, 3.39174047e-02f, 4.38822843e-02f, -8.42981786e-02f, -4.70221266e-02f, -2.11366471e-02f, 1.45363472e-02f, 8.89124498e-02f, 3.52671631e-02f,
  7.20853433e-02f, 7.25007355e-02f, 8.52827951e-02f, 1.15601793e-01f, 5.64356633e-02f, -6.02546073e-02f, -6.51591122e-02f, 6.93386123e-02f, 6.44014357e-03f, -9.27890316e-02f,
  -1.36404470e-01f, -2.15200670e-02f, -2.03598421e-02f, 1.41998287e-02f, 6.94049820e-02f, 1.64922662e-02f, -5.80604225e-02f, 6.22313432e-02f, 6.47899359e-02f, -1.88858830e-03f,
  -5.61310761e-02f, -1.26980729e-02f, 4.49266247e-02f, 5.00132190e-03f, 6.75154328e-02f, 1.02138788e-01f, 3.04488465e-02f, 9.68850479e-02f, 6.20216206e-02f, -8.99887532e-02f,
  2.04018936e-01f, -2.26936817e-01f, 2.60804053e-02f, 2.79849797e-01f, 1.82109103e-01f, 1.19542293e-01f, 1.31496131e-01f, 1.62458837e-01f, 2.76574105e-01f, -1.35579020e-01f,
  -1.80716775e-02f, -1.47195682e-01f, -1.08726904e-01f, 1.50777876e-01f, 2.41751850e-01f, -1.10413777e-02f, 9.77973416e-02f, -6.50880998e-03f, 8.04196149e-02f, 7.01209083e-02f,
  2.29862452e-01f, 2.17565596e-01f, -1.21246725e-01f, -4.30273414e-02f, -8.09337124e-02f, 6.60040602e-02f, -1.03772610e-01f, -9.41419601e-02f, -5.31998873e-02f, -4.12047654e-02f,
  -6.31713271e-02f, 8.71743783e-02f, -1.25267014e-01f, 6.81749545e-03f, -5.70144393e-02f, -3.76859233e-02f, -1.11842053e-02f, 4.27785963e-02f, 1.22152887e-01f, 1.68883484e-02f,
  2.20325217e-03f, -7.45921722e-03f, 1.21716596e-01f, 3.39158177e-02f, 6.19437620e-02f, -5.54566868e-02f, 3.67662194e-03f, 3.48536763e-03f, -6.33387715e-02f, -1.28776848e-01f,
  -3.74473855e-02f, -2.40567327e-02f, -5.89947887e-02f, -5.92453964e-02f, 7.64501095e-02f, -2.03597452e-03f, -7.05156997e-02f, 3.42441574e-02f, -1.15259960e-02f, -5.83667122e-03f,
  -1.29867680e-02f, -6.35961741e-02f, -4.27621156e-02f, 5.04891127e-02f, -4.39840332e-02f, -1.17767481e-02f, 7.44201615e-02f, 2.74730679e-02f, -3.87596153e-02f, -1.37254747e-03f,
  -8.40225518e-02f, 1.41302794e-02f, -5.71993664e-02f, -8.83275345e-02f, 5.05998656e-02f, -5.61095309e-03f, 1.68857239e-02f, -3.63536552e-02f, -5.32533973e-02f, 1.46223959e-02f,
  -1.00774374e-02f, -8.12610239e-03f, -1.15810223e-01f, -7.09485682e-03f, -4.08696476e-03f, -7.13008316e-03f, -1.87971275e-02f, 5.33186756e-02f, 3.79706845e-02f, -1.97432673e-05f,
  9.75466445e-02f, 4.93698334e-03f, -4.79367934e-02f, 3.79509218e-02f, 4.75609303e-02f, -2.16298327e-02f, -3.11164185e-02f, 1.43872619e-01f, 5.60078770e-03f, 6.13301359e-02f,
  2.80493665e-02f, 4.42114007e-03f, -1.07643954e-01f, 1.34484814e-02f, -1.05255686e-01f, -2.26777103e-02f, -1.84035376e-02f, -8.29639807e-02f, 3.77809294e-02f, 2.21207570e-02f,
  -2.05811183e-03f, 3.21969800e-02f, 5.36168590e-02f, 4.64800037e-02f, 6.00327402e-02f, -1.21225633e-01f, 3.25082876e-02f, -3.71057577e-02f, -5.28721735e-02f, -2.66681798e-02f,
  1.31705791e-01f, 7.81438723e-02f, 8.14997256e-02f, 1.85310498e-01f, -1.06903940e-01f, -1.01710871e-01f, -1.27165809e-01f, -2.63459533e-02f, 6.02767467e-02f, -2.80722883e-02f,
  -1.47531390e-01f, 9.05620232e-02f, 5.18118441e-02f, 8.55391696e-02f, 1.81811810e-01f, -6.02137996e-04f, 1.25695780e-01f, -3.78365144e-02f, 5.80005832e-02f, 1.24734744e-01f,
  3.44189927e-02f, 1.31840363e-01f, 1.51003420e-01f, 7.72884339e-02f, -7.21554179e-03f, 3.49337496e-02f, 2.06756815e-01f, -4.36275266e-03f, 9.14529562e-02f, 5.35088480e-02f,
  4.29249089e-03f, 1.47037446e-01f, 4.51250710e-02f, 1.65942311e-02f, 3.27560604e-02f, -4.54487652e-02f, -1.39616460e-01f, -5.90165406e-02f, -9.32023525e-02f, -3.18455212e-02f,
  -2.64762249e-02f, -1.81828253e-02f, -2.51865685e-02f, 3.59557080e-03f, -3.70417610e-02f, -2.88336864e-03f, -9.38438810e-04f, 4.62163500e-02f, -5.52307256e-02f, 6.48920834e-02f,
  -7.42365420e-02f, -3.58745120e-02f, 1.96268093e-02f, 6.92852587e-02f, 7.50979856e-02f, -1.85667537e-02f, 2.41009016e-02f, -4.39711511e-02f, -5.19783329e-03f, 2.46506520e-02f,
  9.14231390e-02f, 2.37103105e-02f, 5.79813914e-03f, 4.68931682e-02f, 5.84319001e-03f, -5.16945086e-02f, 2.22911802e-03f, -1.02226824e-01f, -2.16835979e-02f, -3.51006463e-02f,
  5.48237516e-03f, 2.92586219e-02f, -9.01211612e-03f, -1.03677936e-01f, -1.13073308e-02f, 1.36949439e-02f, -8.77292305e-02f, 2.16317698e-02f, 2.29055211e-02f, -6.55485839e-02f,
  1.09910883e-01f, 3.27814817e-02f, -9.03002694e-02f, -3.17849554e-02f, -9.36861336e-03f, 2.39299256e-02f, 1.28583193e-01f, 1.44865513e-02f, -1.42428890e-01f, -8.01774412e-02f,
  9.98715758e-02f, 2.19137475e-01f, -5.24177402e-02f, -6.24479167e-02f, -7.56930187e-02f, -8.75853561e-03f, -4.07358296e-02f, 3.87107953e-02f, 1.11071028e-01f, -3.24862897e-02f,
  5.79369850e-02f, -6.50654212e-02f, 1.90931096e-04f, 3.49418558e-02f, -3.34164612e-02f, 7.68697076e-03f, -3.28321867e-02f, 6.40804693e-02f, -7.76356133e-03f, 2.39675585e-02f,
  -8.78875051e-03f, -3.70310545e-02f, 8.37978348e-02f, -6.71136975e-02f, -3.85733880e-02f, -1.31917410e-02f, -4.48619723e-02f, -1.21011660e-02f, 1.01966187e-01f, 6.95839003e-02f,
  -2.21093565e-01f, 4.02838290e-02f, -1.34628877e-01f, -4.75385897e-02f, -1.54210657e-01f, 1.96985811e-01f, 2.05798596e-01f, 9.30780452e-03f, 7.27951080e-02f, 1.65033653e-01f,
  2.12613523e-01f, 3.31421867e-02f, 1.46929637e-01f, 2.66238004e-01f, 5.76441293e-04f, 1.60945311e-01f, 2.67808467e-01f, 1.23885095e-01f, -3.44970822e-02f, 2.37478036e-03f,
  -8.72051492e-02f, 1.98095307e-01f, 1.11576110e-01f, -1.86422914e-02f, 3.14039104e-02f, -1.19610474e-01f, 9.41393748e-02f, -2.16277704e-01f, 1.25860468e-01f, -4.26249802e-02f,
  6.91131726e-02f, 4.74515520e-02f, -1.07013425e-02f, 2.60942075e-02f, 1.23469932e-02f, -8.12361911e-02f, -2.50696968e-02f, 7.53939291e-03f, -3.14356796e-02f, 3.05938181e-02f,
  -1.18827574e-01f, -5.03641665e-02f, 1.02889873e-01f, -2.42435206e-02f, -7.92351440e-02f, -2.56173336e-03f, 1.39215570e-02f, -2.75833383e-02f, -1.93580019e-03f, 3.72627820e-03f,
  -1.38461674e-02f, -4.75958250e-02f, 3.36388685e-02f, -1.36201074e-02f, 8.55446756e-02f, 2.85523143e-02f, 9.57370996e-02f, -1.30193293e-01f, -1.46118319e-02f, 1.88084189e-02f,
  1.43629797e-02f, -9.48523283e-02f, 1.01066530e-01f, 8.21379051e-02f, -5.20186909e-02f, -1.47577673e-02f, 1.05211288e-01f, 8.58702585e-02f, -6.14402741e-02f, 2.02920567e-02f,
  -6.16854727e-02f, 8.96461159e-02f, 2.20132470e-02f, -3.87660949e-03f, 5.17971208e-03f, -2.65873503e-02f, -4.07622056e-03f, -7.46477302e-03f, 4.62054759e-02f, 6.08708337e-02f,
  -5.35637923e-02f, -2.70639807e-02f, 7.65825734e-02f, 6.65454613e-03f, -1.73950866e-02f, 2.38035712e-03f, 6.45935908e-02f, 1.29743374e-03f, 6.63330546e-03f, 1.17650051e-02f,
  7.66133592e-02f, -5.12350015e-02f, 6.10574195e-03f, -1.47119984e-02f, 5.30101880e-02f, -2.78015416e-02f, 4.78591258e-03f, 1.72438789e-02f, -7.26900846e-02f, -3.59373279e-02f,
  -2.55186558e-02f, 5.37422299e-02f, -9.46607664e-02f, 6.47691488e-02f, -3.17763761e-02f, 1.26840502e-01f, -4.47277837e-02f, 2.46983226e-02f, 3.35814133e-02f, -5.70229404e-02f,
  -4.50647390e-03f, -6.35474026e-02f, 2.81876232e-02f, -2.89331712e-02f, 3.66724990e-02f, 8.38130787e-02f, -1.80572998e-02f, -9.07616615e-02f, -5.99030871e-03f, 6.21679462e-02f,
  2.74000783e-02f, 3.91818993e-02f, 5.73027506e-02f, 3.66153717e-02f, 7.99927190e-02f, -8.35149139e-02f, -2.03231245e-01f, 1.67824179e-01f, -2.08326399e-01f, -2.22392520e-03f,
  1.33928820e-01f, 1.73612032e-03f, -2.13785231e-01f, -9.74556804e-02f, 3.31793055e-02f, -1.98465720e-01f, 1.00783847e-01f, 8.05300772e-02f, -3.81018259e-02f, 1.70603678e-01f,
  6.55810460e-02f, 6.39675781e-02f, 1.19441994e-01f, 2.85426289e-01f, 4.80909534e-02f, 1.82830244e-01f, 2.92699784e-01f, 2.49801092e-02f, 1.90426275e-01f, -3.13556045e-02f,
  -4.90367785e-02f, 2.29341164e-02f, -9.29138735e-02f, 5.75947051e-04f, -2.38615163e-02f, -3.18127475e-03f, 6.35489225e-02f, 9.48712528e-02f, 6.48763180e-02f, 4.51605394e-02f,
  -3.11587956e-02f, 4.77979332e-02f, -5.62231429e-02f, -6.46777824e-02f, 3.24727409e-02f, -1.35903414e-02f, 1.71711668e-02f, -8.05972319e-04f, 1.16298636e-02f, -2.33287159e-02f,
  -7.13907331e-02f, -2.43337881e-02f, 6.27539903e-02f, 9.39158946e-02f, -3.10393050e-02f, -8.76387134e-02f, -9.31006856e-03f, 2.04208493e-02f, -1.59222223e-02f, 5.97475981e-03f,
  5.72209284e-02f, 3.38750742e-02f, -1.06971465e-01f, -1.19885229e-01f, -3.38210873e-02f, -7.48278797e-02f, 7.23588804e-04f, -2.39749327e-02f, -5.53134643e-02f, -3.08660306e-02f,
  4.43546437e-02f, 9.15158838e-02f, -5.86731099e-02f, 1.87126920e-02f, -5.67012653e-03f, -4.03536595e-02f, 1.05973721e-01f, -2.01529302e-02f, 8.48120376e-02f, -3.49032730e-02f,
  5.49833942e-03f, 4.54037860e-02f, -7.32171908e-02f, 4.21040505e-02f, 1.27627263e-02f, 9.96271595e-02f, -2.98112445e-02f, -5.51434457e-02f, 1.67777762e-02f, 3.88580337e-02f,
  1.78481042e-02f, 9.10807624e-02f, 3.21129411e-02f, -1.69826392e-02f, 2.97191739e-03f, -2.67970599e-02f, -5.32636084e-02f, 1.26520887e-01f, 4.63147648e-02f, -1.69143174e-02f,
  2.83453930e-02f, 9.01376829e-02f, 6.52435645e-02f, 4.57382910e-02f, 5.09319529e-02f, 5.19546568e-02f, -5.12771122e-02f, -1.39150918e-02f, -6.73498586e-02f, 6.28113821e-02f,
  1.41363680e-01f, 2.55898945e-02f, -1.10453695e-01f, 2.30873730e-02f, -6.37664497e-02f, 1.15232833e-01f, -1.00463644e-01f, 6.21758290e-02f, 3.93400863e-02f, 3.16977091e-02f,
  3.87836690e-03f, 1.70323864e-01f, -1.67389601e-01f, -3.72319557e-02f, -1.86056316e-01f, 1.72131434e-01f, 2.99090356e-01f, -4.84622680e-02f, 1.34357318e-01f, 1.66214779e-01f,
  1.02952041e-01f, 6.68913126e-02f, 1.56209186e-01f, 7.97960535e-02f, 1.70704395e-01f, 1.96844384e-01f, 1.53392956e-01f, 1.59608677e-01f, -2.14469526e-03f, 4.57547344e-02f,
  -1.01008743e-01f, 1.70123994e-01f, -1.19262040e-01f, -4.35969904e-02f, 1.68518908e-02f, -1.15315102e-01f, -1.17722988e-01f, -1.24872766e-01f, -1.38713181e-01f, -6.61346093e-02f,
  3.53631340e-02f, 3.26458327e-02f, -7.21803308e-02f, 1.99081246e-02f, -3.93272005e-02f, 2.68940609e-02f, 4.19682898e-02f, 2.91951466e-02f, -1.43897876e-01f, -9.67302267e-03f,
  4.16416265e-02f, 1.99876893e-02f, 3.28132808e-02f, -7.87546337e-02f, -5.13990000e-02f, -1.36894003e-01f, -3.75830494e-02f, -1.41461182e-03f, 7.05704018e-02f, -4.46769670e-02f,
  -2.87597701e-02f, -1.76571850e-02f, -5.98593801e-02f, 6.65831789e-02f, -7.12619722e-02f, -6.92606792e-02f, -4.05886732e-02f, 1.03323884e-01f, -2.97904247e-03f, 6.41605258e-02f,
  -6.99963048e-02f, 9.33165029e-02f, 9.51134488e-02f, -9.56884697e-02f, -5.66962957e-02f, -5.56137115e-02f, -8.28513429e-02f, 3.24362740e-02f, 4.02140692e-02f, 5.69862910e-02f,
  3.79886739e-02f, 7.86556583e-03f, -6.12605400e-02f, 2.12181695e-02f, -6.12977818e-02f, 4.03917693e-02f, -1.10391349e-01f, 4.40623723e-02f, 7.68579841e-02f, -1.72213698e-03f,
  3.18089053e-02f, 6.39370009e-02f, -6.86322525e-03f, -3.81693430e-02f, 9.89646390e-02f, -2.03840081e-02f, 2.72316788e-03f, -1.23424031e-01f, -1.09978952e-01f, 2.29921099e-02f,
  9.84984115e-02f, 1.53710425e-01f, 6.26841262e-02f, -4.25667427e-02f, 7.20893890e-02f, -4.57523130e-02f, 7.24671315e-03f, -1.62062198e-02f, 1.40540404e-02f, 1.25915155e-01f,
  3.42723802e-02f, 1.82632990e-02f, 1.53924040e-02f, -6.39546141e-02f, 7.02732801e-02f, 6.47833049e-02f, 7.88720623e-02f, -8.00988674e-02f, 6.23614155e-03f, -6.40009195e-02f,
  -1.17273740e-01f, 5.21415137e-02f, 2.05649044e-02f, -3.42341028e-02f, -5.77981807e-02f, 4.52991612e-02f, 2.07513794e-02f, -2.59502120e-02f, 6.05001338e-02f, 4.22520228e-02f,
  6.34367466e-02f, -5.33867814e-02f, 1.76934853e-01f, 1.67209506e-02f, -1.13783523e-01f, -2.03365803e-01f, 5.56988232e-02f, -1.55384317e-01f, -7.03243306e-03f, -6.65113404e-02f,
  -1.63715228e-01f, 2.09322050e-01f, 2.88684759e-02f, -2.44501624e-02f, 2.83890933e-01f, 2.20453650e-01f, 5.33671565e-02f, 2.09612213e-03f, 8.99811834e-02f, -1.22378148e-01f,
  -7.93657452e-02f, -4.63174134e-02f, 1.53852165e-01f, -2.17709750e-01f, -5.97587861e-02f, 9.31766927e-02f, 2.19390705e-01f, 6.44028336e-02f, -9.61371511e-02f, 1.70982510e-01f,
  -1.05989620e-01f, 3.56728286e-02f, -3.86673026e-02f, -1.13176204e-01f, -3.73834968e-02f, -3.56326178e-02f, 1.62450492e-01f, 9.02044550e-02f, -2.78715622e-02f, -3.16046935e-04f,
  -6.10536989e-03f, 1.33703335e-03f, -4.57917191e-02f, -5.24117723e-02f, -1.11858904e-01f, -1.74275562e-02f, 4.00177874e-02f, -2.79831309e-02f, 2.51054894e-02f, -3.65488231e-02f,
  4.37202379e-02f, 2.08761469e-02f, 3.04382034e-02f, 5.20442501e-02f, 3.69834751e-02f, 1.51842823e-02f, 1.24586046e-01f, 6.67558471e-03f, 1.49065284e-02f, -4.53219078e-02f,
  5.97925112e-02f, 5.13157658e-02f, -2.18959861e-02f, -3.30405449e-03f, 5.00824712e-02f, -8.92261714e-02f, -2.97596678e-03f, 5.84748946e-02f, -3.48456241e-02f, -8.52360278e-02f,
  -1.80712100e-02f, 4.72685769e-02f, -4.79748752e-03f, -1.66815385e-01f, -9.77369994e-02f, -5.59116043e-02f, 1.64893840e-03f, -9.18727517e-02f, 2.69694440e-02f, 3.18032466e-02f,
  3.16766575e-02f, 5.07624485e-02f, 2.43121292e-02f, -3.51858027e-02f, 5.71727343e-02f, 7.58015141e-02f, 7.62833729e-02f, -4.50754017e-02f, -6.75362870e-02f, -3.33918184e-02f,
  -1.27520800e-01f, 7.38686547e-02f, -1.03061665e-02f, -2.81410869e-02f, 5.03776297e-02f, 5.60384654e-02f, -2.51717903e-02f, -3.03643718e-02f, 3.22587341e-02f, -1.61090389e-01f,
  -1.72101751e-01f, 2.25536191e-04f, 1.20832443e-01f, -5.04264534e-02f, -1.12868743e-02f, 5.72453514e-02f, 3.68645601e-02f, 3.93087305e-02f, -6.49785325e-02f, 2.68442780e-02f,
  3.04605626e-02f, 5.04128970e-02f, 2.79596224e-02f, 4.32486273e-02f, -1.12110719e-01f, -6.11803047e-02f, -1.34064540e-01f, 3.57538052e-02f, -6.61514997e-02f, -3.54920025e-03f,
  -1.56458229e-01f, -1.79990321e-01f, 1.27891637e-02f, -1.82009041e-01f, -1.14539705e-01f, -1.61902919e-01f, -3.56364660e-02f, -2.20946684e-01f, -1.83006778e-01f, -8.57056305e-02f,
  -2.66351383e-02f, 5.80738448e-02f, 2.85040975e-01f, -1.89937418e-03f, 1.49692401e-01f, 2.32710421e-01f, -1.05004422e-01f, 8.70703086e-02f, -4.53687832e-02f, -1.08447507e-01f,
  -5.16807772e-02f, 7.43695349e-03f, 1.70129508e-01f, -1.42612293e-01f, -2.23051831e-01f, -2.08414763e-01f, 7.13420659e-02f, 2.92356238e-02f, -1.31169096e-01f, -1.41265150e-02f,
  -3.43988054e-02f, -8.30094367e-02f, -4.95817997e-02f, 1.46569796e-02f, -1.04420511e-02f, 3.44054401e-02f, 2.11226474e-02f, 1.04502715e-01f, 5.02978787e-02f, 9.45679191e-03f,
  -1.74270123e-02f, -3.77715379e-02f, -2.09617056e-02f, -3.98302488e-02f, -4.23489176e-02f, -1.40446916e-01f, -9.72702540e-03f, -3.76050244e-03f, 2.15418786e-02f, -9.73734111e-02f,
  -1.07383847e-01f, -1.02607995e-01f, -2.70051938e-02f, -3.82463541e-03f, 4.00476716e-02f, -4.73495945e-02f, 2.78071202e-02f, 1.55958176e-01f, -8.39922354e-02f, -1.48408085e-01f,
  3.81737761e-02f, -4.23683524e-02f, -9.57083851e-02f, 2.05647200e-02f, -6.60818517e-02f, -3.49233672e-02f, -5.51453866e-02f, -3.45497131e-02f, 6.10474683e-02f, -1.17392419e-03f,
  4.96349717e-03f, -4.37395312e-02f, -3.65930074e-03f, -3.76606695e-02f, -1.92247313e-02f, -2.19749808e-02f, 6.94595054e-02f, -8.93905386e-02f, -3.79435867e-02f, 4.82403710e-02f,
  2.45273281e-02f, -3.07567399e-02f, -6.35405779e-02f, 5.76142296e-02f, -3.93235274e-02f, 2.51786225e-02f, -7.82724768e-02f, -9.63730440e-02f, -1.95316076e-02f, -1.16446556e-03f,
  -1.57570884e-01f, -1.00429073e-01f, 9.10108094e-04f, -2.00498123e-02f, -6.93030953e-02f, -2.43598055e-02f, 2.70238612e-03f, 2.66359076e-02f, 3.02967317e-02f, 7.96337649e-02f,
  1.47256972e-02f, -2.95090955e-02f, -2.22658645e-02f, -3.62161510e-02f, 7.97783881e-02f, -2.90748328e-02f, -1.81952082e-02f, 6.75527304e-02f, -1.90601666e-02f, -7.28601962e-02f,
  6.76302016e-02f, -4.52681296e-02f, 1.19337752e-01f, 2.09311098e-02f, -6.13616519e-02f, -1.69323757e-02f, -5.60053289e-02f, -6.66894950e-03f, 1.62661728e-03f, -1.03943367e-02f,
  1.90681055e-01f, 8.75299722e-02f, 9.24757943e-02f, 1.29133999e-01f, -3.80882360e-02f, 1.39310705e-02f, 1.03358500e-01f, 3.54995616e-02f, 2.26585954e-01f, 6.96794987e-02f,
  -8.08482915e-02f, 1.89287931e-01f, 9.89067331e-02f, -1.77569509e-01f, 1.52256340e-01f, 1.02715492e-01f, -4.68463898e-02f, 7.85919838e-03f, -2.29213908e-02f, 1.15421480e-02f,
  -7.15665706e-03f, -1.11286648e-01f, -5.12688309e-02f, -1.64993167e-01f, -5.97320981e-02f, -3.61023434e-02f, -1.35715306e-01f, -5.60174249e-02f, -4.05817889e-02f, -2.98779402e-02f,
  -5.44976071e-02f, 7.38441125e-02f, -8.94123316e-02f, -1.78672038e-02f, 1.80287585e-02f, -5.71988262e-02f, 1.07601687e-01f, 8.69394094e-02f, 3.37500945e-02f, 5.75852208e-02f,
  1.25542954e-01f, 1.39305741e-01f, 4.76009697e-02f, -5.75177139e-03f, 8.14025402e-02f, -5.67165054e-02f, 3.75655182e-02f, -7.65027776e-02f, -7.30742663e-02f, -1.22224413e-01f,
  -8.02649260e-02f, -6.25929683e-02f, -5.66981286e-02f, 7.11130276e-02f, 6.14577308e-02f, 5.38134016e-02f, 1.19545080e-01f, -7.29793590e-03f, 2.74731014e-02f, 3.71381231e-02f,
  3.75478417e-02f, 5.17906398e-02f, -3.86692919e-02f, -7.37911314e-02f, 8.03724304e-03f, -4.70966734e-02f, -6.56013638e-02f, -6.30204193e-03f, 1.75235391e-01f, -3.04254703e-02f,
  5.67594990e-02f, 1.01040624e-01f, -7.06474558e-02f, -5.56553435e-03f, 4.01560329e-02f, 5.06003350e-02f, -2.14186646e-02f, 5.12314495e-03f, 1.01311184e-01f, -6.29117638e-02f,
  5.57289235e-02f, 4.11094800e-02f, -1.20075457e-02f, -1.78787287e-03f, -1.41534945e-02f, 6.59441799e-02f, -1.63869545e-01f, -1.71679948e-02f, 4.54320721e-02f, -1.04679756e-01f,
  9.24527422e-02f, 6.93629831e-02f, -2.58991439e-02f, 8.99316594e-02f, 1.11673601e-01f, 4.40056399e-02f, 2.26537939e-02f, 3.17403525e-02f, 4.80892472e-02f, 7.11062551e-02f,
  -8.79139975e-02f, 5.98221421e-02f, 1.10097669e-01f, -7.56548569e-02f, 4.41496372e-02f, -7.47322589e-02f, 6.85270727e-02f, 1.50661208e-02f, 4.28452566e-02f, -1.31059393e-01f,
  9.96731874e-03f, 3.54467630e-02f, 7.89718479e-02f, 4.45986427e-02f, -8.06442369e-03f, -8.36359337e-02f, -1.14577757e-02f, -2.14780159e-02f, 6.32534847e-02f, -3.57607901e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -1.95304211e-02f, 3.04091759e-02f, 1.16979375e-01f, 6.63381517e-02f, 2.04429533e-02f, 9.93267968e-02f, 1.58592403e-01f, 1.59363791e-01f, 1.18640751e-01f, 9.02143028e-03f,
  9.22414362e-02f, 1.04380101e-01f, 2.13817712e-02f, 1.20900571e-01f, 1.44096151e-01f, 5.02718426e-02f, 1.33926168e-01f, 1.24696821e-01f, 1.67166237e-02f, 1.35208182e-02f,
  4.87937443e-02f, 1.32679313e-01f, 1.43442973e-01f, 1.78126529e-01f, 1.64977774e-01f, 3.54833491e-02f, 5.85452989e-02f, 1.64097503e-01f, 1.32469863e-01f, 1.51058510e-01f,
  1.92982808e-01f, 8.05203151e-03f, 1.08877867e-01f, 6.36592600e-03f, 6.98645562e-02f, 1.07714362e-01f, 1.55450702e-01f, 2.20769897e-01f, 1.21261127e-01f, 4.06503864e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.48028692e-02f, -1.04519702e-01f, -5.19878529e-02f, 1.60093635e-01f, 5.30827194e-02f, -5.04227914e-02f, -8.53712857e-02f, 8.74569174e-03f, 1.33678392e-01f, 3.55366319e-02f,
  1.13455296e-01f, 8.29282254e-02f, 2.02901125e-01f, 1.89781532e-01f, -7.21597597e-02f, 3.09722424e-02f, -3.01522780e-02f, -1.57727659e-01f, -1.67060912e-01f, 7.93689042e-02f,
  3.08026314e-01f, 4.27005999e-02f, 1.03537306e-01f, -5.51476851e-02f, -7.55192013e-03f, -5.11417240e-02f, 1.33067191e-01f, 5.97497560e-02f, -1.89357445e-01f, 1.49084896e-01f,
  2.87541449e-02f, -7.32981712e-02f, -2.91569941e-02f, 7.62826204e-02f, 1.13470048e-01f, 2.22590077e-03f, 3.78295779e-02f, -3.43335001e-03f, 2.86765471e-02f, -5.77130020e-02f,
  4.10188586e-02f, 7.57851899e-02f, -1.30321831e-01f, 6.92173690e-02f, -7.90553093e-02f, 2.08368912e-01f, -4.66616303e-02f, 7.94135630e-02f, -1.13775417e-01f, -2.25831002e-01f,
  -2.18628831e-02f, 1.73662722e-01f, 6.94218129e-02f, -9.67971832e-02f, -7.60605633e-02f, -3.85782793e-02f, 1.05003513e-01f, 2.06255242e-01f, 2.31419861e-01f, -6.98102564e-02f,
  3.08552049e-02f, -5.57982102e-02f, 2.63636168e-02f, -3.98015566e-02f, 2.31259428e-02f, 1.36009574e-01f, 7.23472312e-02f, -1.98413190e-02f, 3.25059071e-02f, -1.39175266e-01f,
  1.13390587e-01f, -5.02477437e-02f, -6.72137365e-02f, 1.04415812e-01f, 5.65912239e-02f, 1.53557017e-01f, 1.27156213e-01f, -5.08942306e-02f, 1.83588177e-01f, 1.50857583e-01f,
  1.00229658e-01f, 1.29189789e-01f, -6.84550256e-02f, -3.09076998e-02f, -6.10485673e-02f, 1.70205206e-01f, 2.05684334e-01f, 1.85974449e-01f, -4.49628159e-02f, 9.68679227e-03f,
  1.83819775e-02f, -1.05187565e-01f, -2.09512264e-01f, 4.39587049e-02f, -1.92819640e-01f, 2.47055646e-02f, 8.03977996e-02f, 1.92230940e-01f, 1.13859057e-01f, 3.02233035e-03f,
  -8.25878084e-02f, 1.53263614e-01f, -3.62855801e-03f, -1.24898605e-01f, 1.02756605e-01f, 1.72823399e-01f, -7.43659139e-02f, 1.17958672e-01f, -1.63698897e-01f, 1.48566797e-01f,
  1.91234555e-02f, 1.52120352e-01f, 3.53413969e-02f, -7.60969967e-02f, 5.38855158e-02f, 6.40280470e-02f, -1.79625317e-01f, 2.24161129e-02f, 2.55537499e-02f, 1.50894634e-02f,
  -8.69765058e-02f, -5.44815883e-03f, -5.18958457e-02f, -1.71479553e-01f, 1.74058139e-01f, 4.63275798e-03f, 1.90532040e-02f, 3.98670621e-02f, -7.73654059e-02f, -1.11614622e-01f,
  -4.48504882e-03f, -5.78753501e-02f, 2.84704529e-02f, 4.11142446e-02f, 6.33145943e-02f, -5.46872020e-02f, -1.13126524e-01f, 2.69354004e-02f, 2.23099869e-02f, 7.36583248e-02f,
  1.75710320e-02f, 1.64748579e-01f, -1.17428333e-01f, -6.84213266e-02f, -9.13520306e-02f, 1.47695079e-01f, -6.16513230e-02f, 2.20154017e-01f, -1.58405870e-01f, 1.19820811e-01f,
  -2.68282660e-04f, -1.87182248e-01f, 6.73055649e-02f, 2.19685093e-01f, -2.41299406e-01f, 6.45158067e-02f, 2.00112369e-02f, 3.08016706e-02f, 9.04651433e-02f, 7.15245903e-02f,
  1.34769037e-01f, -1.58708259e-01f, 6.77764565e-02f, -1.26478806e-01f, 1.15331911e-01f, -2.47538552e-01f, 1.48632592e-02f, 1.24484159e-01f, 6.18953221e-02f, -1.24434017e-01f,
  3.57191600e-02f, -9.58334059e-02f, 7.55813122e-02f, -1.73341081e-01f, 1.43450290e-01f, 1.14088982e-01f, -2.35749111e-01f, -7.51734674e-02f, -7.06285238e-02f, 2.40833819e-01f,
  -2.23069843e-02f, 2.67260079e-03f, -1.50405085e-02f, 1.95155740e-02f, -1.73923537e-01f, 5.82649000e-02f, -2.20957428e-01f, 6.37349719e-03f, -2.36400202e-01f, -6.39228597e-02f,
  -2.50240881e-02f, 4.52862568e-02f, 7.52420276e-02f, 1.43291773e-02f, 7.29556605e-02f, -1.21372968e-01f, -5.60809486e-02f, -8.34512583e-04f, 3.02932933e-02f, 1.67303815e-01f,
  -7.60928541e-02f, 5.45413457e-02f, -2.59128083e-02f, 1.56613827e-01f, -1.39061913e-01f, -3.04248445e-02f, 1.62794769e-01f, -8.21313709e-02f, 1.65920824e-01f, 2.02011634e-02f,
  2.48872172e-02f, -1.21334337e-01f, -2.44000286e-01f, -7.96136335e-02f, 3.57253104e-02f, -8.94767046e-02f, 3.41544710e-02f, -7.45953768e-02f, 4.26670872e-02f, -1.68077648e-01f,
  1.66124836e-01f, -9.46206227e-02f, -1.82561979e-01f, 1.38158165e-02f, -1.75288022e-01f, 2.46776760e-01f, -1.51155824e-02f, 1.70685947e-01f, -2.09414676e-01f, -4.90822382e-02f,
  -2.83311680e-02f, 5.33941574e-02f, -1.61838397e-01f, -8.28301087e-02f, 2.37930622e-02f, 4.18298431e-02f, -1.43037617e-01f, -1.32702410e-01f, 6.02191165e-02f, -1.58927202e-01f,
  3.46941538e-02f, 2.71287024e-01f, 1.60453826e-01f, -2.18189821e-01f, 8.90723839e-02f, 2.13610530e-02f, 7.13162571e-02f, -1.50754645e-01f, 1.80251464e-01f, 6.00786656e-02f,
  1.18519045e-01f, -1.00430869e-01f, 1.02343589e-01f, -1.75457820e-02f, 1.29594579e-01f, -7.92749226e-02f, 5.79580143e-02f, 1.24919280e-01f, -7.98415318e-02f, 1.33143514e-01f,
  -1.06585316e-01f, 5.07574044e-02f, 1.48697630e-01f, 6.70749173e-02f, -7.23425150e-02f, -5.06589822e-02f, 1.63445339e-01f, 6.14017844e-02f, -1.26805529e-01f, -1.59058332e-01f,
  -9.90143046e-03f, 1.40913697e-02f, -1.09200738e-01f, -1.76512107e-01f, -3.70189920e-02f, 1.35396436e-01f, -5.53926937e-02f, -1.05825692e-01f, 1.19528718e-01f, -4.81901132e-03f,
  2.36155301e-01f, 2.57141769e-01f, -1.77656293e-01f, -8.71584937e-02f, -5.46243181e-03f, -1.94856837e-01f, -2.27721408e-02f, 5.04365861e-02f, 1.88953191e-01f, 1.12055652e-01f,
  -3.77552435e-02f, 3.94721627e-02f, 3.83455269e-02f, 1.48986513e-03f, 8.42436682e-03f, 1.51590616e-01f, 2.56299153e-02f, -1.74860567e-01f, 2.06345275e-01f, 5.11759445e-02f,
  -5.16906604e-02f, -2.05013126e-01f, 1.30262405e-01f, -1.01254500e-01f, 1.27515897e-01f, 7.97207206e-02f, -3.83820944e-02f, 1.20988227e-01f, 1.73992246e-01f, 5.32294884e-02f,
  2.14849219e-01f, -5.69045134e-02f, -4.77822199e-02f, -1.68900922e-01f, -5.75899221e-02f, 8.49033073e-02f, -2.11407468e-01f, 1.29666105e-01f, 1.92490578e-01f, 4.33597937e-02f,
  1.35340374e-02f, 6.39476255e-02f, -1.21564195e-01f, -1.06165608e-04f, -8.39638803e-03f, -1.35835856e-01f, 5.39043285e-02f, -2.06873519e-03f, -1.17691249e-01f, -4.32706289e-02f,
  5.78809483e-03f, 9.07570496e-02f, 1.68933142e-02f, -6.60687238e-02f, -2.33086338e-03f, 2.96447016e-02f, 1.22332364e-01f, -9.55471620e-02f, -7.09771514e-02f, 3.94504443e-02f,
  -1.09883383e-01f, 4.33054455e-02f, 1.06662023e-03f, 1.85672626e-01f, 1.12027295e-01f, -2.18243018e-01f, 1.78867638e-01f, -2.05561414e-01f, -5.31365350e-02f, -1.15131820e-02f,
  -1.12705708e-01f, -1.12534299e-01f, -9.64797754e-03f, -2.73908339e-02f, -1.33157417e-01f, 6.74273297e-02f, -1.79083124e-01f, 1.97739959e-01f, -1.40877575e-01f, -1.10913940e-01f,
  -9.04791728e-02f, 1.25910312e-01f, -2.16871843e-01f, 1.79453567e-02f, -1.01311039e-02f, 1.35567412e-01f, 1.19472541e-01f, -1.23581767e-01f, 8.56516957e-02f, 7.44218305e-02f,
  6.23083413e-02f, -1.60465360e-01f, 4.99808639e-02f, -7.00468197e-02f, 1.88772231e-01f, -1.36828884e-01f, 7.82251507e-02f, -1.00783125e-01f, -1.73868872e-02f, 3.13259661e-02f,
  5.48342243e-02f, -1.82606697e-01f, 2.08421331e-02f, -9.80575904e-02f, 3.22120935e-02f, -1.38767600e-01f, -1.02760740e-01f, 2.85895020e-02f, -1.83670446e-01f, -8.05404708e-02f,
  -1.75607219e-01f, -2.01048613e-01f, -1.31798476e-01f, -2.63644708e-03f, 1.14903327e-04f, -1.68778390e-01f, 3.04747261e-02f, 2.18175098e-01f, 1.85004964e-01f, 8.57664943e-02f,
  6.78002685e-02f, -1.51991650e-01f, -5.77784404e-02f, 1.33736521e-01f, 1.65498793e-01f, -5.00476845e-02f, 1.02045037e-01f, -1.15024962e-01f, 4.88650165e-02f, 1.82001159e-01f,
  -1.58721983e-01f, 2.65054554e-01f, -1.46915466e-01f, -6.43275753e-02f, -3.36880311e-02f, -4.00857441e-02f, 1.59402505e-01f, -5.29413484e-02f, -1.59801003e-02f, 1.25833631e-01f,
  1.29897565e-01f, 1.23522570e-02f, 1.22396991e-01f, -1.31521612e-01f, 5.76860234e-02f, -5.14764921e-04f, -5.02951501e-04f, -8.10776278e-02f, 6.46316970e-04f, -1.08565569e-01f,
  -7.15876594e-02f, 5.19939931e-03f, -6.25691563e-02f, -1.91292018e-01f, -9.45094824e-02f, 2.90048122e-01f, 1.22098625e-01f, -6.61159083e-02f, -2.57134318e-01f, 5.63214608e-02f,
  -9.88393128e-02f, 2.56329626e-02f, 8.04913044e-03f, -1.09932631e-01f, -2.34686211e-02f, 2.01556310e-01f, 1.93001285e-01f, -6.73341230e-02f, -1.08675577e-01f, -1.50884013e-03f,
  4.77087907e-02f, -2.39413127e-01f, -9.83237848e-03f, -1.61292166e-01f, -1.50291324e-01f, 5.25855646e-02f, 6.10840740e-03f, -6.85500130e-02f, -9.69962254e-02f, 7.30098933e-02f,
  -9.76777226e-02f, 5.32555841e-02f, -6.02217503e-02f, 1.04361447e-02f, 6.97555915e-02f, 6.62690075e-03f, 2.45345477e-02f, 4.76872809e-02f, -1.84119239e-01f, 7.60077685e-02f,
  9.05053765e-02f, -1.12310030e-01f, -4.22866307e-02f, -1.14367887e-01f, -1.05538391e-01f, -1.21290646e-01f, 6.51233494e-02f, -1.81997791e-01f, -1.18136682e-01f, 6.53755590e-02f,
  -3.17101330e-02f, 9.66634601e-02f, -1.26187056e-01f, -1.43039316e-01f, -1.19542345e-01f, -7.77986646e-02f, -1.21450715e-01f, 1.09893471e-01f, -7.50106946e-02f, 3.94768715e-02f,
  4.79576401e-02f, 1.63470916e-02f, -2.58779414e-02f, -1.52362317e-01f, 1.06099553e-01f, -1.36039019e-01f, -1.24644898e-01f, 7.71834552e-02f, -1.25553519e-01f, -3.55714075e-02f,
  -1.16818033e-01f, -8.96890983e-02f, 1.05967045e-01f, -9.22874212e-02f, -1.63981393e-01f, -5.44172302e-02f, -2.71401465e-01f, 2.13372856e-02f, -6.58205971e-02f, 8.72517750e-02f,
  5.41389100e-02f, -8.34224597e-02f, 5.30286171e-02f, 1.14525566e-02f, 1.63576946e-01f, -9.98014510e-02f, -1.26033634e-01f, 1.56461969e-01f, -5.64192310e-02f, -4.66061532e-02f,
  7.98252523e-02f, 1.17639519e-01f, -4.23669107e-02f, 1.08306948e-02f, -1.56706795e-01f, -2.12331247e-02f, -2.84290940e-01f, -6.50389940e-02f, -7.89107829e-02f, 4.51781694e-03f,
  1.83674529e-01f, 1.20536730e-01f, 1.40867531e-01f, 1.08795594e-02f, -1.71640053e-01f, 4.50054593e-02f, -1.65573463e-01f, 1.05702616e-02f, 1.77336678e-01f, 1.92276910e-01f,
  1.96184844e-01f, -2.44034808e-02f, 3.38527262e-02f, 2.01372489e-01f, 2.60430221e-02f, -1.32328838e-01f, 1.75267115e-01f, 6.79547805e-03f, 1.68193221e-01f, -2.08417758e-01f,
  -4.07786854e-03f, 1.16062373e-01f, 1.23127528e-01f, 1.76045388e-01f, 2.62660254e-02f, 2.18337420e-02f, 4.25994024e-02f, -4.63454947e-02f, -1.17762908e-01f, -6.64225072e-02f,
  -1.50386542e-01f, -5.10424897e-02f, -1.53953880e-01f, 6.91147968e-02f, 1.13920659e-01f, -6.78035319e-02f, 4.21342328e-02f, 2.99483780e-02f, -2.81935874e-02f, 1.41422689e-01f,
  -1.88665256e-01f, 4.49482203e-02f, -4.76091094e-02f, -5.30925058e-02f, -1.03787623e-01f, 8.36831927e-02f, 3.11703570e-02f, -1.37194276e-01f, 6.16703667e-02f, 3.45032327e-02f,
  -6.90994561e-02f, 8.28205198e-02f, -1.55707285e-01f, 7.78170079e-02f, -4.48452197e-02f, -1.55859560e-01f, 5.27531840e-02f, 2.51065381e-02f, -1.80357680e-01f, -1.05223417e-01f,
  8.45209062e-02f, -6.67717010e-02f, -6.22296764e-04f, 1.29731655e-01f, 1.86595097e-01f, 4.90980484e-02f, -9.45750698e-02f, -1.30444735e-01f, -9.23428014e-02f, 1.39299938e-02f,
  -1.89001471e-01f, -9.73841920e-03f, 1.30849987e-01f, -8.17642063e-02f, 2.08132826e-02f, -2.13772222e-01f, 1.13188639e-01f, 1.27407432e-01f, 8.98829848e-02f, -1.81845397e-01f,
  -9.10644140e-03f, -3.21089774e-02f, 2.26566732e-01f, -8.77538323e-02f, 3.97518836e-02f, 2.36602604e-01f, -1.29857147e-02f, 2.06170365e-01f, 2.31858939e-01f, -1.82088226e-01f,
  2.38099545e-01f, -9.10485163e-02f, 1.26569524e-01f, 7.18336329e-02f, -4.64278273e-02f, 5.11195846e-02f, -1.57460973e-01f, -1.37777776e-01f, 7.15479925e-02f, -2.91434884e-01f,
  -1.02314398e-01f, 2.22632140e-01f, 8.63511339e-02f, 4.26773354e-03f, -1.31662920e-01f, 8.22935253e-02f, 7.23226666e-02f, 1.91883624e-01f, -6.77444506e-03f, 2.24351138e-01f,
  -4.30831946e-02f, -3.76502015e-02f, 5.97086474e-02f, 2.21607424e-02f, -9.49508771e-02f, 8.40940475e-02f, -1.10187471e-01f, -1.26474485e-01f, 3.20756412e-03f, 2.42179409e-02f,
  9.57695767e-02f, -1.49190664e-01f, -1.16394803e-01f, -1.06546627e-02f, 2.05166787e-02f, -9.90553945e-02f, -3.42651345e-02f, -6.67418018e-02f, 1.73895493e-01f, 2.93525271e-02f,
  8.13761204e-02f, -3.77756655e-02f, -1.90990388e-01f, 1.07462592e-01f, -1.31568804e-01f, -2.09785812e-02f, 1.63209975e-01f, 5.90463728e-02f, 1.17447279e-01f, -1.17776126e-01f,
  1.37386188e-01f, 1.70704603e-01f, 8.80082250e-02f, -1.99142411e-01f, 9.28730443e-02f, -7.04877153e-02f, 2.09162205e-01f, -1.29157320e-01f, -3.13437991e-02f, 1.15123793e-01f,
  -8.79981518e-02f, 6.63735718e-02f, 2.26156563e-01f, -2.23442256e-01f, 1.93858504e-01f, -1.83393031e-01f, -1.08031131e-01f, 1.58381626e-01f, 1.11582829e-02f, 8.95657837e-02f,
  -9.52151865e-02f, -3.53734717e-02f, -1.41932378e-02f, -1.92856044e-01f, -1.51658729e-01f, 1.63088828e-01f, 2.54124533e-02f, 5.80464415e-02f, -1.11696228e-01f, -2.52095480e-02f,
  -7.39208248e-04f, 6.53107315e-02f, -6.34094849e-02f, 2.10250139e-01f, 6.12291843e-02f, 1.99525835e-04f, 1.77295320e-02f, -9.54027623e-02f, 8.95770565e-02f, 2.70656534e-02f,
  -8.61963630e-02f, -5.63880168e-02f, -1.94766931e-02f, -1.09879605e-01f, -5.64797483e-02f, 3.80656794e-02f, -5.59677072e-02f, -3.96327190e-02f, -1.15442254e-01f, -6.38103038e-02f,
  -1.03271596e-01f, 5.88873886e-02f, -2.46159974e-02f, -1.65082738e-01f, -8.91240239e-02f, -1.15061432e-01f, -7.95252994e-02f, 3.93833406e-02f, -6.75777271e-02f, -2.36300364e-01f,
  8.83642584e-02f, 6.69354796e-02f, 1.80552199e-01f, 1.37961153e-02f, 1.81666121e-01f, 1.15676187e-01f, -2.57696360e-01f, -7.77127892e-02f, -1.19463727e-01f, -1.13392554e-01f,
  1.09215282e-01f, -1.96178686e-02f, 1.29491705e-02f, -1.83480587e-02f, -1.45622537e-01f, 8.76073539e-02f, 7.10893646e-02f, 9.31814536e-02f, 1.77401051e-01f, 7.13885725e-02f,
  -1.37404129e-01f, 9.15058777e-02f, -4.90313396e-02f, 5.86162582e-02f, 1.18502989e-01f, -2.45588571e-01f, 2.91593447e-02f, -2.39669643e-02f, 3.01027149e-02f, -2.21522208e-02f,
  1.15356378e-01f, 1.51748940e-01f, -1.89828023e-01f, 4.05938551e-02f, -1.74918137e-02f, -1.15473889e-01f, -1.14260301e-01f, 1.03557348e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  7.60143548e-02f, 2.07863823e-01f, 1.04724973e-01f, -5.86915470e-04f, 5.89984171e-02f, -7.90208131e-02f, 2.96568181e-02f, -2.19196067e-04f, 1.00569852e-01f, 6.69746026e-02f,
  2.43586488e-02f, -1.02903380e-03f, 3.81152555e-02f, -1.70486450e-01f, -1.21792339e-01f, -6.85793310e-02f, -6.52163997e-02f, 5.61252236e-02f, 2.98522115e-02f, 1.02303838e-02f,
  -1.18458066e-02f, -1.38315469e-01f, -2.78618217e-01f, 2.71748584e-02f, 9.20596868e-02f, -9.70325693e-02f, 1.30548254e-01f, 2.39098400e-01f, 2.12974533e-01f, 1.08498018e-02f,
  2.32599676e-01f, 2.55148172e-01f, -4.20225933e-02f, -3.97850834e-02f, -6.41273335e-02f, 6.17674999e-02f, 1.36661634e-01f, -4.66543958e-02f, 1.87001467e-01f, 2.46874347e-01f,
  -1.02393880e-01f, 7.82787874e-02f, 2.00615302e-01f, -1.46442920e-01f, 1.86052352e-01f, 1.84100010e-02f, -1.79681674e-01f, 4.77922447e-02f, 4.91167344e-02f, 1.63914025e-01f,
  1.65072098e-01f, -1.89790130e-01f, 2.42188781e-01f, -1.13747835e-01f, -8.45407099e-02f, 1.15167208e-01f, 2.19805181e-01f, -8.39329585e-02f, 2.69452538e-02f, 1.09257556e-01f,
  -1.93774551e-02f, -3.78221273e-02f, -9.98312701e-03f, 2.25472152e-01f, 2.74631288e-02f, 3.23443189e-02f, 2.07761958e-01f, 9.55657512e-02f, 1.92552581e-02f, 1.56511620e-01f,
  3.14224465e-03f, 1.07946910e-01f, 1.17158324e-01f, 1.10610172e-01f, 2.58076191e-02f, 5.39477058e-02f, -4.82038222e-02f, 4.57535312e-02f, -1.46052660e-02f, 1.57409504e-01f,
  1.14113458e-01f, 8.66716579e-02f, -5.14746793e-02f, 6.16179518e-02f, 1.01775173e-02f, 1.56077310e-01f, 1.31031081e-01f, 1.51452437e-01f, -7.25509897e-02f, 2.59127259e-01f,
  2.68734489e-02f, 3.18782381e-03f, -1.89980283e-01f, 3.92454416e-02f, 4.06564549e-02f, 7.60100558e-02f, 2.84813613e-01f, 1.48777813e-01f, 2.65469998e-01f, 1.54350713e-01f,
  1.95883349e-01f, -2.22254004e-02f, 4.01920676e-02f, 8.13682750e-02f, 1.36913598e-01f, 1.92639500e-01f, 1.08866096e-01f, -4.45440188e-02f, -1.04103424e-02f, 1.29259184e-01f,
  2.54234612e-01f, 1.46358266e-01f, -7.80616701e-02f, -1.80197239e-01f, -5.14366478e-02f, 2.68443823e-01f, -1.39948279e-01f, 2.08031595e-01f, -1.46873161e-01f, 1.82080701e-01f,
  -6.87597273e-03f, 5.67678660e-02f, 1.76050693e-01f, -1.91763759e-01f, 2.65230089e-01f, 7.50822723e-02f, 2.80390203e-01f, -8.01547337e-03f, -1.04653828e-01f, 3.08890734e-02f,
  -1.13522969e-01f, 1.33089900e-01f, -8.46006721e-02f, -4.16128337e-02f, -1.00828998e-01f, 1.49471983e-01f, 9.41607282e-02f, 1.74923778e-01f, -2.59853713e-03f, -1.79925978e-01f,
  2.61541158e-01f, 1.17456041e-01f, 6.05659112e-02f, 4.05595824e-02f, -2.25289315e-01f, -2.36521915e-01f, -2.41869122e-01f, -2.61709522e-02f, -1.19779348e-01f, -1.13304980e-01f,
  -5.28551005e-02f, 3.60852480e-02f, 2.80784696e-01f, -1.70117497e-01f, 6.49929941e-02f, 1.72702536e-01f, 4.61994857e-03f, 1.58982366e-01f, 1.18212685e-01f, -1.94146439e-01f,
  -1.83392450e-01f, -1.09481849e-01f, -1.20973431e-01f, 3.88881229e-02f, -5.51856421e-02f, 9.90580842e-02f, 1.17721930e-01f, 3.34339961e-02f, 1.23965442e-01f, 5.67334443e-02f,
  -2.48462990e-01f, 9.60553512e-02f, 8.80693197e-02f, 3.21819745e-02f, -1.96418092e-01f, 2.25946903e-02f, 2.26894155e-01f, 2.00233728e-01f, 1.74553961e-01f, 1.09610707e-01f,
  1.80446014e-01f, -3.67336385e-02f, 6.64653182e-02f, -1.04209416e-01f, 1.19011179e-01f, 1.44278049e-01f, 9.61983576e-02f, 3.52054358e-01f, -7.69833624e-02f, 1.17817819e-01f,
  9.16063786e-02f, -3.53477262e-02f, 2.10898235e-01f, -1.94606595e-02f, 1.22400951e-02f, 1.76825941e-01f, 6.03980534e-02f, 9.59554240e-02f, 2.01350406e-01f, -4.38023657e-02f,
  7.34684765e-02f, 1.61809415e-01f, 2.84808390e-02f, 4.40924279e-02f, -3.11264712e-02f, 1.04384460e-01f, -3.06278141e-03f, 6.95758685e-02f, 1.20429203e-01f, 6.77409172e-02f,
  -2.12137699e-02f, -5.22101298e-02f, 1.32620960e-01f, 5.85918538e-02f, 1.72585860e-01f, 1.91537037e-01f, 1.22737296e-01f, 2.35889599e-01f, 2.35164706e-02f, -3.75714526e-02f,
  -1.64636284e-01f, 1.75097883e-01f, 7.76219368e-02f, -4.56894189e-02f, 2.10494652e-01f, 2.97896951e-01f, 2.10575163e-01f, 1.60841629e-01f, -1.00200977e-02f, 1.21253140e-01f,
  -3.61014679e-02f, 5.11045475e-03f, 1.22359648e-01f, 2.14057922e-01f, -1.48126423e-01f, -2.41485700e-01f, 3.98291722e-02f, 3.79269272e-02f, 2.16249794e-01f, 1.63374379e-01f,
  -7.30736821e-04f, -1.42865553e-01f, -4.57262993e-02f, 7.26171434e-02f, -1.64338171e-01f, 2.75578141e-01f, -2.53337473e-01f, 1.84719071e-01f, 6.48630634e-02f, 1.35340020e-01f,
  1.03185929e-01f, 3.42740938e-02f, 1.63475558e-01f, 2.41583914e-01f, 2.63332844e-01f, 1.48773432e-01f, 8.49443749e-02f, 1.28165126e-01f, 1.27711087e-01f, 1.06826223e-01f,
  1.69414416e-01f, -7.96125978e-02f, 9.19775758e-03f, 1.35252669e-01f, 1.22769855e-01f, 1.82689473e-01f, 1.97006445e-02f, 1.29974231e-01f, 1.96080297e-01f, -1.50667220e-01f,
  6.57319650e-02f, -5.43293990e-02f, -9.24222991e-02f, -5.90663105e-02f, -5.85579388e-02f, -1.08564571e-01f, 1.14820898e-01f, -6.93952888e-02f, -4.66680480e-03f, 5.02695106e-02f,
  2.59441845e-02f, -2.11626530e-01f, 2.68736809e-01f, 2.84640724e-03f, 6.58174083e-02f, 2.00779811e-01f, 1.70862526e-01f, 1.20953329e-01f, -4.89061475e-02f, 7.07777441e-02f,
  -6.52193427e-02f, 9.78657231e-02f, 1.18427791e-01f, 1.97259679e-01f, 1.09451242e-01f, 1.25967674e-02f, 6.15429096e-02f, 7.21503049e-02f, -2.33396478e-02f, -9.70200375e-02f,
  -4.22828197e-02f, 1.76577829e-02f, -1.85430110e-01f, -6.05477169e-02f, 2.35098556e-01f, 1.22454785e-01f, 2.29627311e-01f, -3.65258045e-02f, 1.90305337e-01f, -1.20083913e-01f,
  -3.41362655e-02f, -6.91552460e-02f, 2.53267169e-01f, 3.16372444e-03f, 2.56713897e-01f, 1.82928413e-01f, 2.43817478e-01f, 1.32484093e-01f, 4.56830747e-02f, 9.40706432e-02f,
  3.05938981e-02f, -6.01586001e-03f, -6.40251860e-02f, 8.28096494e-02f, -1.84028428e-02f, 1.61553711e-01f, 1.22296870e-01f, 7.84983784e-02f, 1.71715289e-01f, -7.00148568e-03f,
  1.25722766e-01f, -9.14310217e-02f, 2.05893755e-01f, 1.21658631e-01f, 7.40228817e-02f, -4.60489281e-02f, -1.88462809e-01f, -2.13228226e-01f, -3.02705579e-02f, -4.14079539e-02f,
  4.08976935e-02f, -1.23688122e-02f, 8.82207379e-02f, -2.28643894e-01f, 3.36918458e-02f, -1.16854064e-01f, 7.02735782e-02f, 8.84535015e-02f, -1.42400727e-01f, 1.96031645e-01f,
  2.00393766e-01f, 2.90478468e-02f, -9.27622244e-02f, -2.10851893e-01f, -4.67201248e-02f, 7.42596760e-02f, 1.35935009e-01f, 1.20165080e-01f, 2.36430928e-01f, -1.40656736e-02f,
  2.10858047e-01f, -9.50872377e-02f, -8.62394720e-02f, 8.64607428e-05f, 6.66920170e-02f, 2.32823659e-02f, 3.55805382e-02f, -1.86265744e-02f, -6.36029691e-02f, -4.36938815e-02f,
  7.92954117e-02f, 1.72691524e-01f, 2.66757846e-01f, -2.09072277e-01f, 1.17780059e-03f, 1.39958695e-01f, -5.86251840e-02f, 9.75338370e-02f, -1.78810116e-02f, 4.53471579e-02f,
  -1.02746740e-01f, 2.79167965e-02f, -4.56803255e-02f, -2.47306023e-02f, -2.44286843e-02f, 1.41826421e-01f, 3.70815024e-02f, 2.91907117e-02f, -9.69410911e-02f, -2.50591412e-02f,
  4.34153304e-02f, 1.81770384e-01f, -9.93108749e-02f, 1.36806458e-01f, 1.82981530e-04f, -2.07750291e-01f, 2.83704977e-03f, 7.67952576e-03f, 1.81941867e-01f, -1.98742598e-01f,
  -1.42589614e-01f, -2.34073788e-01f, -1.76618248e-01f, -8.77636522e-02f, -7.55779222e-02f, -1.50392890e-01f, 9.58457589e-02f, -2.08318725e-01f, 3.16453159e-01f, -1.25777274e-01f,
  1.33086011e-01f, -3.95690687e-02f, 6.45476580e-02f, 1.17934689e-01f, -1.17649399e-01f, 9.05253142e-02f, -9.13826674e-02f, -1.65348962e-01f, -2.06498448e-02f, 1.83154464e-01f,
  1.02038950e-01f, 9.61691141e-02f, 2.07656115e-01f, -6.87751323e-02f, 6.61975518e-02f, -8.07397962e-02f, -2.12232679e-01f, 2.55201012e-01f, 9.01325718e-02f, 1.23969316e-01f,
  -9.36659724e-02f, -9.70217586e-02f, 2.42765859e-01f, 9.36741382e-02f, 1.01954654e-01f, 4.33110781e-02f, 2.30339408e-01f, -1.30604148e-01f, 2.35622257e-01f, -4.38938513e-02f,
  2.40493521e-01f, -4.88365591e-02f, 5.46208620e-02f, 2.80064434e-01f, -1.40366063e-01f, 1.00904539e-01f, -8.31535757e-02f, -9.87583697e-02f, 9.63325426e-02f, 6.08618259e-02f,
  1.61294684e-01f, 1.34812459e-01f, 5.02746068e-02f, 1.44841835e-01f, 5.39136082e-02f, 1.95894271e-01f, 2.15819091e-01f, 1.29690468e-02f, -7.50450976e-03f, 5.37010841e-02f,
  1.04187660e-01f, 8.67997184e-02f, 1.49351479e-02f, 1.50837719e-01f, 2.18438417e-01f, 2.92130634e-02f, 8.21641609e-02f, 8.47643092e-02f, 1.39413074e-01f, 4.49442603e-02f,
  7.78802186e-02f, 8.10057744e-02f, -1.00170728e-02f, 1.63934201e-01f, 8.53656530e-02f, -2.34249790e-04f, -9.84369144e-02f, 2.94969648e-01f, 1.10533915e-01f, -8.48842338e-02f,
  1.30397920e-02f, 6.95944577e-02f, 3.04810684e-02f, 2.66635746e-01f, -6.42685294e-02f, 1.76610589e-01f, -7.67716914e-02f, 4.08767760e-02f, 4.48954850e-02f, 9.40105692e-02f,
  -1.44995272e-01f, -1.64322168e-01f, -1.19193584e-01f, 1.10998541e-01f, -1.14092588e-01f, -4.86979187e-02f, -5.96267395e-02f, -1.46098018e-01f, -1.20069340e-01f, 7.01680854e-02f,
  -1.63536388e-02f, 1.65703744e-01f, -1.31301850e-01f, -2.33252663e-02f, -9.46559533e-02f, 4.28080186e-02f, 2.65268505e-01f, -1.26293704e-01f, 2.96892613e-01f, 9.57581177e-02f,
  1.69977486e-01f, 8.58788043e-02f, 1.59095272e-01f, 6.78198338e-02f, 1.23193979e-01f, 2.14629546e-01f, 8.89362488e-03f, -1.01756535e-01f, 1.11084767e-01f, 1.78996906e-01f,
  -6.54097041e-03f, 1.33102983e-01f, 1.90978929e-01f, 5.82009889e-02f, 2.35410500e-02f, -2.07073823e-01f, 1.08351387e-01f, -2.44534519e-02f, -1.34232372e-01f, -1.58808678e-01f,
  -1.50087655e-01f, -1.65159434e-01f, -6.14233827e-03f, -2.18993332e-02f, -7.02111274e-02f, 1.02232595e-03f, -5.40911667e-02f, -1.79799780e-01f, 1.79956898e-01f, -8.38949869e-04f,
  9.59781632e-02f, 8.21862593e-02f, 1.54176548e-01f, 4.68053184e-02f, 1.26680613e-01f, -1.17990218e-01f, -8.19497555e-02f, 5.32543026e-02f, 1.34935342e-02f, 2.13061944e-02f,
  1.17311470e-01f, 1.38004825e-01f, -7.62013197e-02f, 2.23130107e-01f, -2.43544374e-02f, 1.11613289e-01f, -1.19181443e-02f, -1.98251731e-03f, 1.09020688e-01f, 9.20829084e-03f,
  2.11401120e-01f, 1.91991106e-01f, 2.39090785e-01f, -1.25451490e-01f, 2.52583683e-01f, -1.32476792e-01f, 2.09519714e-01f, -6.00241609e-02f, 3.10702831e-01f, 8.32421333e-02f,
  3.93993920e-03f, 2.39821777e-01f, 1.40722021e-01f, 1.37370154e-01f, 1.37138635e-01f, 1.56448439e-01f, 5.89091983e-03f, -3.17421108e-02f, 4.86490596e-03f, 2.12120220e-01f,
  -4.05587591e-02f, 8.17968771e-02f, 2.31949627e-01f, 1.87996611e-01f, 2.10868269e-01f, 2.11784244e-01f, 1.10528089e-01f, -7.06733391e-02f, 5.00092618e-02f, 2.21532449e-01f,
  -1.10178575e-01f, -2.41814684e-02f, -8.64840522e-02f, -1.51217893e-01f, -4.93691266e-02f, 5.18300720e-02f, -1.97949335e-02f, -8.92881379e-02f, -8.04943126e-03f, -2.50339240e-01f,
  -3.74831147e-02f, -1.13563752e-02f, 5.45566157e-02f, 2.41860017e-01f, -4.98802103e-02f, 2.28578091e-01f, 1.74028903e-01f, -6.66520074e-02f, -9.30485427e-02f, -1.71275988e-01f,
  6.62470311e-02f, -9.24800113e-02f, 1.58488482e-01f, -2.19020303e-02f, 2.22361147e-01f, 8.00348371e-02f, 2.80549616e-01f, -9.36562568e-02f, 4.65571247e-02f, 1.23190962e-01f,
  7.08243102e-02f, 7.88295045e-02f, -3.20786126e-02f, 1.51384473e-01f, 9.22230110e-02f, -4.81933616e-02f, 4.78564315e-02f, 8.14976096e-02f, 6.44427687e-02f, 6.88676387e-02f,
  1.80140063e-02f, 1.30528644e-01f, 1.70771331e-01f, 8.03652331e-02f, -1.42221555e-01f, 2.27759659e-01f, -8.65424648e-02f, -6.23377087e-03f, -1.27059460e-01f, 3.25778313e-02f,
  1.27829194e-01f, 1.40488684e-01f, 1.13911860e-01f, 2.96024699e-02f, 2.09242970e-01f, 6.37232885e-02f, 1.25044912e-01f, -2.99616549e-02f, 2.42559444e-02f, -1.53756132e-02f,
  5.19550852e-02f, 2.13791803e-01f, -3.22488308e-01f, -2.31950834e-01f, -1.40372574e-01f, 1.37169734e-02f, 6.96107969e-02f, 2.11908519e-01f, 1.96617916e-01f, 2.30689347e-01f,
  -1.07914381e-01f, 9.46176276e-02f, 3.83857777e-03f, 5.46633154e-02f, -7.45464712e-02f, 1.42252088e-01f, 9.78090316e-02f, 1.97305366e-01f, 1.30995274e-01f, -2.52327263e-01f,
  4.51155007e-02f, 2.65155852e-01f, 3.22197489e-02f, -4.29694019e-02f, 1.79566666e-01f, -9.06066075e-02f, -2.40045656e-02f, -1.34169146e-01f, -7.92796090e-02f, 1.85907170e-01f,
  2.56712466e-01f, 5.62970378e-02f, 3.43174726e-01f, -7.31080920e-02f, 4.68197390e-02f, -7.42466897e-02f, 8.24339092e-02f, 2.66041346e-02f, 1.03707567e-01f, 1.16537444e-01f,
  3.83334979e-03f, 1.63241878e-01f, 3.11905351e-02f, 2.28396550e-01f, -1.17535941e-01f, 1.82481557e-01f, -1.04754291e-01f, 2.92287134e-02f, -1.80263761e-02f, -6.98390901e-02f,
  1.34624764e-01f, 7.00487122e-02f, 1.00618787e-01f, 7.74240717e-02f, 1.31962836e-01f, -9.71038733e-03f, 1.42971473e-02f, 1.39185578e-01f, -2.92085111e-03f, 9.90706980e-02f,
  1.22968410e-03f, 1.90513462e-01f, 1.31366566e-01f, 8.97994041e-02f, 3.36691439e-02f, -8.58022124e-02f, 9.09055993e-02f, 7.10279718e-02f, -2.60289431e-01f, -1.59747809e-01f,
  -9.97819602e-02f, -3.76346745e-02f, 4.66598794e-02f, -4.09640633e-02f, 4.54360768e-02f, -1.43564135e-01f, 2.95277275e-02f, -1.59991711e-01f, 2.05772847e-01f, -1.01922993e-02f,
  6.08472601e-02f, 1.70974627e-01f, 5.77109009e-02f, 2.20228489e-02f, 1.14958882e-01f, 4.11993675e-02f, -9.95967761e-02f, -2.42762528e-02f, 1.18876643e-01f, 4.29320112e-02f,
  1.57408118e-02f, 1.18887857e-01f, 6.70177042e-02f, -2.29111817e-02f, 3.15827966e-01f, -1.59273133e-01f, 1.38348475e-01f, 1.77488685e-01f, 1.69321045e-01f, 5.93965240e-02f,
  -1.79428354e-01f, 1.23274148e-01f, -8.67249817e-03f, 6.76768646e-02f, -2.23442465e-02f, 2.14226142e-01f, 2.43391544e-01f, 1.30709410e-01f, 1.55721039e-01f, -4.07347418e-02f,
  1.02650579e-02f, 8.09693933e-02f, 1.43906131e-01f, 3.07442844e-01f, 6.09731041e-02f, 1.16561493e-02f, -1.44177303e-01f, -1.38151467e-01f, -5.87363839e-02f, -1.03144897e-02f,
  8.11195839e-03f, 7.45195746e-02f, -5.78676984e-02f, 1.43242657e-01f, 7.73998955e-03f, 1.43640339e-01f, -7.79001787e-02f, -2.94388295e-03f, 1.05701841e-01f, 1.92375213e-01f,
  -2.19582003e-02f, -5.43947928e-02f, 1.74427301e-01f, 1.65952697e-01f, 1.35842115e-01f, 6.89546093e-02f, 2.36356743e-02f, 5.03890999e-02f, -7.34800026e-02f, 2.52485514e-01f,
  1.31992415e-01f, 1.19720869e-01f, 5.05901836e-02f, 2.12600991e-01f, -1.83478087e-01f, 1.25366205e-03f, -1.84592560e-01f, 1.29064441e-01f, -3.10543808e-03f, 4.95739132e-02f,
  2.21916676e-01f, 2.00163543e-01f, 1.70256019e-01f, 4.56664152e-02f, -3.62783717e-03f, 1.66624337e-01f, -1.50409758e-01f, -5.82387000e-02f, 4.69929390e-02f, 2.47161128e-02f,
  8.05193409e-02f, 6.68361709e-02f, -6.63910136e-02f, -8.03144425e-02f, 1.58510730e-01f, 2.91423388e-02f, 1.12453520e-01f, -9.42239687e-02f, 1.17009491e-01f, 4.63721305e-02f,
  1.99856665e-02f, 1.33725345e-01f, 1.46515042e-01f, -3.28971222e-02f, -1.68969080e-01f, -3.97997089e-02f, 1.38272136e-01f, -1.70067936e-01f, 6.77911043e-02f, 1.95634410e-01f,
  2.86773086e-01f, -2.79131643e-02f, 2.02022240e-01f, 1.30164504e-01f, 2.38296032e-01f, 2.31526092e-01f, 1.79852962e-01f, 5.34817837e-02f, 2.44695228e-02f, 1.00683503e-01f,
  1.66324392e-01f, 1.34815142e-01f, 1.57941237e-01f, 5.79360090e-02f, 1.37848035e-01f, -2.49454528e-02f, -8.26062784e-02f, 1.06486687e-02f, 1.46259502e-01f, 1.53712124e-01f,
  -9.67850618e-04f, 4.71564196e-02f, 2.35462204e-01f, -1.09744526e-01f, 6.98464885e-02f, 1.36151135e-01f, -5.93374595e-02f, 7.49304891e-02f, 2.57632285e-01f, -9.97154042e-03f,
  -1.42158428e-02f, 1.16254993e-01f, 1.07159242e-01f, 7.47985020e-02f, 2.02850476e-01f, 1.67480379e-01f, 2.30689961e-02f, 1.41126364e-01f, 1.08645447e-01f, 1.57890528e-01f,
  1.33769512e-01f, -4.08992283e-02f, 2.31802016e-02f, 1.15816355e-01f, -1.07234992e-01f, -9.02666524e-03f, -1.42266989e-01f, 1.41328603e-01f, -6.01194762e-02f, 1.65187597e-01f,
  -5.92483841e-02f, -1.12748787e-01f, 1.04872599e-01f, 9.42073166e-02f, -1.05505943e-01f, 1.73960641e-01f, -5.16496114e-02f, 8.31017736e-03f, 2.16505736e-01f, 1.45413712e-01f,
  2.45883614e-01f, 4.00904790e-02f, 3.06195945e-01f, 7.22496063e-02f, 2.31607389e-02f, 1.40170798e-01f, 2.85895308e-03f, 8.43977407e-02f, 2.00019091e-01f, -1.18217543e-02f,
  -1.35030309e-02f, 2.05526575e-01f, -1.89284515e-02f, 4.82301898e-02f, 9.02521238e-02f, -2.66095232e-02f, 9.32096876e-03f, -5.38473539e-02f, -1.90106645e-01f, -2.15345889e-01f,
  4.78740968e-03f, -1.79577723e-01f, -1.70836508e-01f, -7.18778521e-02f, 8.14643726e-02f, -3.63712832e-02f, -1.63099542e-01f, -1.81563988e-01f, -8.31676945e-02f, -9.78204757e-02f,
  1.98976602e-02f, -1.95149258e-02f, -7.47701852e-03f, 1.62987322e-01f, 2.07404166e-01f, -1.24869995e-01f, 2.16884598e-01f, 2.03983352e-01f, 3.98469232e-02f, 3.68931517e-02f,
  -1.36651024e-02f, 7.51116872e-02f, 1.62819639e-01f, -5.68833761e-02f, -3.94957215e-02f, 2.39265442e-01f, 1.58197824e-02f, 7.03186691e-02f, 2.77133167e-01f, -1.98668301e-01f,
  1.00510590e-01f, 4.59413528e-02f, 1.35072023e-01f, 5.44353109e-03f, -7.09056389e-03f, 1.97085798e-01f, 1.55685410e-01f, 8.26154798e-02f, -4.33485257e-03f, 3.59526053e-02f,
  1.60227031e-01f, 2.06929654e-01f, -1.01667186e-02f, -6.98502688e-03f, -1.73949063e-01f, 2.08087005e-02f, -1.13981880e-01f, 9.93350223e-02f, -4.76170629e-02f, -9.52247903e-03f,
  -1.39017182e-03f, 4.05842885e-02f, -2.25454047e-01f, 1.12847641e-01f, 1.38389403e-02f, -3.18089947e-02f, 6.24483728e-05f, 1.62828356e-01f, -5.65253086e-02f, -9.71679389e-03f,
  -1.02832742e-01f, 3.01677436e-01f, -4.27402049e-01f, -1.10708307e-02f, -2.07784791e-02f, -3.80581059e-02f, 3.43871973e-02f, 3.40880901e-02f, 8.66274759e-02f, 2.29784951e-01f,
  -5.20599365e-01f, 2.89179265e-01f, 2.64110267e-01f, 1.94433630e-01f, 4.03652281e-01f, 1.02412045e-01f, -2.49415692e-02f, -3.71730268e-01f, -2.84364879e-01f, -6.84659481e-02f,
  -1.27757773e-01f, 1.07136250e-01f, 1.14600278e-01f, 4.31044027e-02f, -2.18253911e-01f, -3.48503441e-02f, -1.03514813e-01f, -3.06571312e-02f, -1.91330925e-01f, 1.30360335e-01f,
  -7.36312196e-02f, -8.94527957e-02f, 1.81318391e-02f, -3.75124887e-02f, -2.27747723e-01f, -8.77870545e-02f, 4.37787533e-01f, 5.51022515e-02f, -9.20170173e-02f, -9.13270488e-02f,
  1.66005135e-01f, -1.40524805e-01f, -4.02189232e-02f, 2.41867989e-01f, 2.92726099e-01f, 3.86965871e-02f, -3.08486491e-01f, -2.82305237e-02f, -1.78254098e-01f, 2.50875317e-02f,
  -3.80222313e-02f, 2.83572733e-01f, 4.51959223e-02f, -6.44659847e-02f, 1.78027168e-01f, 8.06754008e-02f, 1.75619885e-01f, 3.80424894e-02f, 1.45153418e-01f, 6.33256882e-02f,
  4.26010899e-02f, -4.63492572e-02f, -4.58628079e-03f, 2.65831761e-02f, 6.99565187e-02f, 2.49992814e-02f, -4.18787971e-02f, -1.02344245e-01f, 2.29146600e-01f, 2.32248798e-01f,
  3.28994766e-02f, 1.27107993e-01f, 7.61883408e-02f, -8.74396488e-02f, 9.11558047e-02f, 6.47494718e-02f, 6.71674460e-02f, 1.75617740e-01f, -1.98560670e-01f, 1.07914254e-01f,
  -4.19412144e-02f, -2.20839113e-01f, -7.74749666e-02f, -1.47201642e-01f, -1.84659183e-01f, 1.00429744e-01f, 2.51608312e-01f, 1.25603586e-01f, 1.14300437e-01f, 2.19307467e-01f,
  1.39085308e-01f, 1.26152068e-01f, 2.13519987e-02f, 1.12809382e-01f, -2.07723066e-01f, 1.74515143e-01f, -8.56151879e-02f, -3.29269283e-02f, -4.56038266e-02f, -9.60167870e-02f,
  8.18910357e-03f, -2.36988682e-02f, 1.94826245e-01f, -1.41077414e-01f, -3.48195322e-02f, 2.00487096e-02f, -1.74314320e-01f, -2.31751859e-01f, -6.18264191e-02f, 1.24070942e-01f,
  -8.83680675e-03f, 8.84952024e-02f, 1.69245616e-01f, -2.33415470e-01f, 2.73015082e-01f, 2.86236763e-01f, 2.97715694e-01f, 1.46847293e-01f, -7.02123940e-02f, -7.57404789e-02f,
  -2.58811619e-02f, 1.16900094e-01f, -5.77611811e-02f, 1.48671940e-02f, -8.13541636e-02f, 4.01793718e-02f, 8.86886641e-02f, 1.64444566e-01f, 3.33998464e-02f, -1.20983876e-01f,
  1.31678849e-01f, 1.05269946e-01f, 3.55121680e-03f, -1.61752462e-01f, -2.98276484e-01f, -2.09949091e-01f, -2.22239852e-01f, -8.20350125e-02f, -1.13477945e-01f, -1.83863580e-01f,
  -1.16385095e-01f, -3.26298848e-02f, 2.13330060e-01f, -9.54189673e-02f, 1.02745838e-01f, 1.92441553e-01f, 3.03322752e-03f, 2.43692636e-01f, 4.17261384e-02f, -1.34480804e-01f,
  -1.89723164e-01f, -7.57976621e-02f, 2.52974816e-02f, -4.55105416e-02f, 1.91122875e-01f, 1.83349743e-01f, 2.09821329e-01f, 1.18925489e-01f, 4.81403358e-02f, -1.22814523e-02f,
  -2.43457630e-01f, 6.15779795e-02f, 1.39733016e-01f, 9.78946686e-03f, -1.77584529e-01f, 1.16182409e-01f, -1.49253299e-02f, 5.14787883e-02f, 2.19163328e-01f, -9.49160084e-02f,
  2.61835754e-01f, -7.62224272e-02f, 1.53746307e-02f, -9.32433382e-02f, 2.50250995e-01f, 1.51150525e-01f, -2.15649549e-02f, 3.11662346e-01f, -5.80867231e-02f, -1.02295075e-02f,
  -2.01885086e-02f, -2.09404647e-01f, -5.36016487e-02f, -2.57970877e-02f, 6.83171228e-02f, 1.15845241e-01f, -1.60091277e-02f, -6.12829104e-02f, -2.05839761e-02f, 1.09242007e-01f,
  1.33331135e-01f, -2.52594575e-02f, 4.85046953e-02f, -4.05772924e-02f, -1.28728315e-01f, -1.79032490e-01f, -4.68785614e-02f, 4.18098830e-03f, -5.97861223e-02f, 1.09490559e-01f,
  5.72875738e-02f, 9.23566446e-02f, -8.43260810e-02f, -1.27741858e-01f, -1.84023619e-01f, -1.20854236e-01f, -9.76488441e-02f, 7.55120665e-02f, 1.44411638e-01f, 1.82004422e-01f,
  4.74786945e-02f, -1.85186461e-01f, 8.21922794e-02f, 2.56067723e-01f, 1.23029716e-01f, 6.06698692e-02f, 7.94673115e-02f, 7.79019222e-02f, 1.19240351e-01f, -2.08060876e-01f,
  1.13869466e-01f, 1.71069309e-01f, 1.13312438e-01f, 1.57319590e-01f, 3.30707103e-01f, -1.64479271e-01f, 2.29574919e-01f, 2.21425854e-02f, 1.33505851e-01f, 1.90223530e-01f,
  1.02902696e-01f, 8.36908668e-02f, -1.77354604e-01f, 1.85489252e-01f, 7.41591528e-02f, 1.51821673e-02f, -1.19044557e-01f, 2.85072595e-01f, 9.77291018e-02f, 7.51298144e-02f,
  -1.00423824e-02f, -7.29032978e-02f, 9.51600447e-02f, 1.87278003e-01f, 9.18654427e-02f, 1.87583178e-01f, 1.34517312e-01f, 1.23507939e-01f, 7.65319094e-02f, 3.34024429e-02f,
  1.37568442e-02f, -1.96476169e-02f, 4.27604944e-04f, 1.89869195e-01f, 7.08881244e-02f, 2.25149561e-02f, 1.70112282e-01f, -8.89637228e-03f, 8.71760398e-02f, 7.74043724e-02f,
  -5.01945838e-02f, -1.93244606e-01f, -1.85378760e-01f, -1.44162923e-01f, -5.29363602e-02f, -1.41240478e-01f, 2.00396702e-02f, -2.19690189e-01f, -1.20409749e-01f, -1.54015765e-01f,
  1.92000479e-01f, -1.22915186e-01f, 1.81856290e-01f, 3.05658150e-02f, 1.04083106e-01f, -2.13283654e-02f, 2.05227777e-01f, -5.94827682e-02f, -1.37372008e-02f, -1.38324931e-01f,
  -5.05905822e-02f, -4.37876433e-02f, 7.13760108e-02f, -6.17949758e-03f, 3.52415182e-02f, 1.14492036e-01f, 4.15310729e-03f, 1.16756126e-01f, -9.63770747e-02f, 1.79648176e-01f,
  1.98964432e-01f, 1.20782413e-01f, -8.54841545e-02f, -1.31707922e-01f, 2.26038545e-01f, 1.57869384e-01f, 1.56467095e-01f, -1.10830650e-01f, 2.94034988e-01f, -4.95845787e-02f,
  1.02072908e-02f, -6.34545237e-02f, 2.02781215e-01f, 1.64899930e-01f, -5.25722653e-02f, 2.14609146e-01f, 6.07210621e-02f, -1.04075387e-01f, -1.04810506e-01f, 1.98104346e-04f,
  1.50727376e-01f, 1.50431067e-01f, 2.11746156e-01f, 7.52219558e-02f, -6.47357926e-02f, 6.41112700e-02f, -4.69826907e-02f, 1.24574810e-01f, 9.60117206e-02f, 1.37556210e-01f,
  3.45287658e-02f, 3.47164050e-02f, -1.27080396e-01f, -1.90266818e-01f, -1.79598927e-01f, -8.66043717e-02f, -1.74912110e-01f, 9.18306485e-02f, 2.31426328e-01f, -1.39995636e-02f,
  -1.64440088e-02f, -1.13287702e-01f, -3.71647291e-02f, 1.28576279e-01f, 1.23112679e-01f, -1.01834528e-01f, 2.01886401e-01f, 1.51242852e-01f, 1.51380733e-01f, -3.44644822e-02f,
  1.90697312e-01f, 1.85749710e-01f, 2.04839949e-02f, 4.47115190e-02f, -8.85067657e-02f, 1.05788969e-01f, 1.45742521e-01f, -3.74430511e-03f, 1.58120289e-01f, 2.46455148e-01f,
  -6.19994216e-02f, 2.47969225e-01f, 5.79905808e-02f, -2.05074653e-01f, 2.33988434e-01f, -6.60969839e-02f, -3.22539546e-02f, 1.16161548e-01f, 5.59839718e-02f, 2.25010529e-01f,
  6.02548905e-02f, -5.93549088e-02f, 2.01391190e-01f, -1.96382865e-01f, 2.22163200e-02f, 4.18293625e-02f, 1.81166545e-01f, -1.03125377e-02f, -1.39402732e-01f, 9.56509355e-03f,
  6.46672845e-02f, 1.23406537e-01f, 4.01751623e-02f, 2.74064809e-01f, 6.23047538e-03f, -1.37784483e-03f, 7.69090205e-02f, 2.49795523e-02f, 5.74532151e-03f, 9.88277979e-03f,
  -2.91679483e-02f, 6.47640377e-02f, 1.61860660e-02f, 9.01065245e-02f, 1.05925135e-01f, -1.96120162e-02f, -1.04538165e-01f, 1.40583768e-01f, 1.23124301e-01f, 1.04503453e-01f,
  -6.48347437e-02f, 1.04615189e-01f, 1.03855319e-01f, 1.74486846e-01f, 4.28048782e-02f, 1.48912624e-01f, 7.79189914e-02f, 1.12501748e-01f, -4.19698842e-02f, 2.49383017e-01f,
  7.15030059e-02f, -5.48010170e-02f, -2.01947123e-01f, 3.17279808e-02f, -4.43215668e-03f, 1.42608449e-01f, 3.19057703e-01f, -5.10702282e-02f, 2.10916296e-01f, 1.80996686e-01f,
  1.28330365e-01f, -2.04509050e-02f, 2.58903727e-02f, -3.16145010e-02f, 5.21334121e-03f, 6.79141060e-02f, -2.39917263e-02f, -6.06704988e-02f, 8.61185864e-02f, 9.61642638e-02f,
  2.43492261e-01f, 5.81657849e-02f, 6.09165384e-03f, -1.79133445e-01f, -4.45501469e-02f, 2.42993370e-01f, -8.54429603e-02f, 5.31505719e-02f, 7.32011441e-03f, 2.14575976e-01f,
  -1.71234086e-01f, 2.17628460e-02f, -1.46358714e-01f, -1.69172511e-02f, 3.60308739e-04f, 2.28077710e-01f, 6.77440166e-02f, 7.84578174e-02f, -5.25597110e-03f, 3.50030325e-02f,
  4.99088094e-02f, 3.68544236e-02f, 6.27531037e-02f, 1.23662136e-01f, 2.08202735e-01f, 1.03758596e-01f, -3.90898846e-02f, -2.04877835e-02f, 5.11133373e-02f, 2.61872053e-01f,
  -1.14913516e-01f, -1.11952767e-01f, -4.43865806e-02f, 6.72957227e-02f, 1.10672385e-01f, 8.93808603e-02f, 2.24019624e-02f, 8.09127018e-02f, -2.35365584e-01f, -2.35767961e-02f,
  -3.02120317e-02f, -1.65007606e-01f, 2.00191885e-01f, 7.24496245e-02f, -2.43051816e-02f, 4.00423780e-02f, 7.20898286e-02f, 1.79123378e-03f, 6.39801249e-02f, 1.70067921e-01f,
  -1.94335625e-01f, 2.79693514e-01f, -1.26123847e-02f, 2.20825657e-01f, 5.47772497e-02f, 1.93403482e-01f, 6.10062182e-02f, -8.38780999e-02f, 1.57009438e-01f, -2.60266308e-02f,
  5.84551729e-02f, 2.20798299e-01f, -9.31367353e-02f, 1.66309178e-01f, 1.98345780e-01f, -1.34811923e-01f, 6.58593401e-02f, 2.55618781e-01f, 1.64016157e-01f, 6.81658983e-02f,
  3.87588255e-02f, 2.77446508e-01f, 2.48865873e-01f, -1.06178917e-01f, 3.44971158e-02f, -1.85195416e-01f, 1.79445013e-01f, 1.46716475e-01f, 1.04847588e-01f, 1.48676774e-02f,
  -4.83595952e-02f, -5.18170781e-02f, -1.84109025e-02f, 3.39944288e-02f, -6.82315528e-02f, 4.50601429e-02f, 6.33769780e-02f, -1.29973724e-01f, -8.26901942e-02f, 1.62348449e-02f,
  -7.25215450e-02f, -7.28988051e-02f, 1.49742618e-01f, 1.01640806e-01f, -3.49617451e-02f, -5.59017286e-02f, 2.94791758e-01f, -1.42752275e-01f, -1.07579447e-01f, -7.21555874e-02f,
  8.57962668e-02f, 8.93976614e-02f, -2.66028434e-01f, 3.37592438e-02f, -7.85351917e-02f, 8.88682604e-02f, 2.06618324e-01f, -3.61867901e-03f, 4.29371484e-02f, -2.58870330e-02f,
  -4.45754081e-02f, -2.55984962e-01f, -1.18528299e-01f, -1.32516965e-01f, 8.48080665e-02f, 1.51272222e-01f, 1.39711937e-02f, 1.45728979e-02f, 3.11352611e-02f, 1.51637450e-01f,
  6.09885082e-02f, -5.23985103e-02f, -1.18386850e-01f, -1.28530309e-01f, 5.85388131e-02f, 5.14847189e-02f, -6.55345768e-02f, -1.07148044e-01f, 1.95161790e-01f, -1.22847810e-01f,
  7.82963037e-02f, 6.76938444e-02f, 8.18844810e-02f, -1.06881578e-02f, 5.47247976e-02f, -3.93097363e-02f, 2.50811040e-01f, -7.87790567e-02f, 1.04582801e-01f, -1.22562602e-01f,
  2.42140908e-02f, 1.60962284e-01f, -1.19760968e-01f, 1.95678413e-01f, 2.38026455e-01f, 6.95225000e-02f, -2.97167264e-02f, 1.90125450e-01f, -3.91540192e-02f, -1.02744848e-01f,
  1.39665917e-01f, -2.96158716e-02f, 2.68476065e-02f, -7.36643001e-02f, 2.39381008e-03f, -4.85146530e-02f, -4.61170264e-02f, -2.45744884e-02f, -2.94666618e-01f, 3.72171169e-03f,
  2.05248848e-01f, -1.12952754e-01f, -8.03292766e-02f, 3.79378704e-04f, 4.76636402e-02f, -9.07181203e-02f, -2.35376835e-01f, -3.67203094e-02f, -2.63954774e-02f, 7.81254284e-03f,
  2.05384463e-01f, -6.06614910e-02f, -5.95136955e-02f, -1.24024861e-02f, 1.90155074e-01f, -9.19119716e-02f, -9.05061513e-02f, -3.30728590e-02f, 1.01666585e-01f, 2.19465066e-02f,
  -4.24322039e-02f, -5.01343533e-02f, -1.34660169e-01f, -6.65229410e-02f, 8.69112164e-02f, 1.70465440e-01f, -1.44485682e-01f, -4.83736061e-02f, 4.37986329e-02f, 2.23171283e-02f,
  -9.73149687e-02f, -1.21219561e-01f, 2.44001210e-01f, -7.33075887e-02f, 1.79458976e-01f, 2.79130906e-01f, 5.66517077e-02f, -1.41868651e-01f, 1.73307702e-01f, -1.06110424e-02f,
  2.88442761e-01f, -6.31739497e-02f, 2.30930835e-01f, -9.36453938e-02f, -5.84717393e-02f, 4.00748029e-02f, -9.87782776e-02f, 7.12191761e-02f, 1.88688532e-01f, 4.21814658e-02f,
  -4.44824770e-02f, 1.42480567e-01f, 1.47467732e-01f, -5.48447296e-03f, 5.88475168e-02f, 9.69116464e-02f, 4.66693491e-02f, -2.09859870e-02f, -1.32142268e-02f, 1.36838704e-02f,
  2.78696474e-02f, 2.24764183e-01f, -2.31430873e-01f, -2.19339415e-01f, 4.12873141e-02f, -1.61680114e-02f, -1.31754026e-01f, 1.63273737e-01f, 1.01744913e-01f, 9.87042040e-02f,
  -8.53045732e-02f, -5.62483957e-03f, -9.50276013e-03f, 2.58260444e-02f, 8.91532078e-02f, 1.52910978e-01f, 1.34684434e-02f, 2.55002882e-02f, 2.40545258e-01f, -1.37676656e-01f,
  -7.08069056e-02f, 7.21852332e-02f, 2.51666307e-02f, 1.95366263e-01f, 1.15851425e-02f, 1.97790295e-01f, -5.64264767e-02f, -3.73662785e-02f, -8.61351117e-02f, -8.44093040e-03f,
  1.30471075e-02f, 3.68633084e-02f, 1.10597514e-01f, -1.79139957e-01f, 3.64598781e-02f, -3.43184695e-02f, 3.24476093e-01f, -3.58611159e-02f, 9.26499367e-02f, 1.79894850e-01f,
  -9.43751708e-02f, -7.04099145e-03f, 7.19769970e-02f, 1.76556967e-02f, 1.26178771e-01f, 3.92683409e-02f, -1.14748135e-01f, -6.91142604e-02f, 9.87568274e-02f, -2.33674701e-02f,
  -1.26201779e-01f, 1.30574688e-01f, 8.56572539e-02f, 9.09783617e-02f, 1.38922304e-01f, 3.79463956e-02f, 5.50150424e-02f, 1.68116361e-01f, 6.54434562e-02f, -3.67300771e-02f,
  1.13246471e-01f, -5.75468224e-03f, -1.25150767e-03f, 7.32661486e-02f, 6.85481951e-02f, 4.49091531e-02f, 1.98601812e-01f, -9.11985934e-02f, -7.43161812e-02f, 3.99330184e-02f,
  -5.57523668e-02f, 1.19693734e-01f, -2.33080864e-01f, -1.90963045e-01f, 1.80479169e-01f, -8.78165364e-02f, -6.43096343e-02f, 2.46438012e-01f, 2.38843262e-02f, -1.88366562e-01f,
  1.31359324e-01f, 2.60561686e-02f, -5.15435338e-02f, 1.47164255e-01f, 1.84155047e-01f, 3.48248072e-02f, -1.36851788e-01f, -7.02662319e-02f, -1.07145440e-02f, -2.10367907e-02f,
  1.79263756e-01f, 2.66109258e-01f, 1.60177916e-01f, 1.96895152e-02f, -2.09676668e-01f, 8.90096501e-02f, -2.10302129e-01f, -1.83805168e-01f, -8.83375034e-02f, 1.83465272e-01f,
  -1.60857081e-01f, 2.05621663e-02f, 1.17437549e-01f, -1.01950169e-02f, 2.44893283e-01f, -9.92072821e-02f, 1.06553592e-01f, 2.17127893e-02f, -2.70529836e-01f, -1.59818292e-01f,
  2.59609044e-01f, 1.32245749e-01f, 1.75864428e-01f, -2.70456052e-03f, 1.78181991e-01f, -2.37731151e-02f, 6.74206838e-02f, 2.38425434e-02f, 1.05649188e-01f, 8.05879757e-02f,
  8.52330625e-02f, 9.59567055e-02f, 1.81331933e-01f, 2.44984195e-01f, 1.08483955e-01f, 2.27598876e-01f, 5.19103855e-02f, -1.48851424e-02f, -4.81218984e-03f, 1.45521790e-01f,
  -9.36043486e-02f, 2.47609407e-01f, -3.48713458e-01f, -2.51056105e-02f, 2.36453027e-01f, -1.75875034e-02f, -1.20675474e-01f, 3.06807548e-01f, -3.56654115e-02f, 9.07814726e-02f,
  1.63015902e-01f, -2.62717724e-01f, 7.62592331e-02f, 7.25933760e-02f, -2.03779638e-01f, 1.74868926e-01f, 1.15873560e-01f, 7.06709251e-02f, -5.13547547e-02f, -8.30828473e-02f,
  -4.43708012e-03f, -1.31912321e-01f, 9.90912095e-02f, -1.52962968e-01f, -1.82903588e-01f, -1.80940956e-01f, -2.52231956e-01f, 1.57559693e-01f, 3.55754465e-01f, 3.26235220e-02f,
  2.03295261e-01f, 2.49596611e-01f, 1.49106771e-01f, 3.83407213e-02f, 1.99585289e-01f, 4.41679806e-02f, -1.90306038e-01f, -1.34379804e-01f, -1.18339010e-01f, 1.30405754e-01f,
  -1.02824323e-01f, 3.27216625e-01f, 3.03414732e-01f, -4.67949733e-02f, -2.15795875e-01f, -1.15568988e-01f, -2.24547327e-01f, 4.33876291e-02f, -1.12044439e-01f, -2.85928905e-01f,
  -4.99813817e-02f, -1.11672701e-03f, -1.55544244e-02f, 1.56021461e-01f, -8.14045444e-02f, 1.29888088e-01f, 7.49901906e-02f, -9.10071135e-02f, -2.64264550e-02f, 1.32976040e-01f,
  1.02501765e-01f, 1.47635281e-01f, 1.42250940e-01f, -2.69509405e-02f, -1.93944946e-01f, -1.90002441e-01f, 1.63093895e-01f, -6.24435628e-03f, -7.54535347e-02f, -1.68347478e-01f,
  9.52398479e-02f, -9.28788725e-03f, -2.63345033e-01f, 1.24575291e-02f, -6.51747510e-02f, -4.23119515e-02f, 1.44746944e-01f, 9.51868072e-02f, -4.74068783e-02f, -8.40455443e-02f,
  6.52532978e-03f, -2.02630997e-01f, -1.59296289e-01f, 1.51368633e-01f, -3.72388363e-02f, 2.09074646e-01f, -3.93127091e-02f, 2.22499415e-01f, -1.60917580e-01f, 1.68088302e-01f,
  5.65740876e-02f, 1.03460997e-01f, -1.93674475e-01f, 2.06486687e-01f, 1.50814235e-01f, -1.43301368e-01f, -6.75053895e-02f, -2.39630803e-01f, 1.96112216e-01f, -8.17516968e-02f,
  2.39702106e-01f, 9.30929109e-02f, 1.71764463e-01f, -1.96822554e-01f, 1.25090435e-01f, 2.94919778e-02f, 6.50395826e-02f, 5.07793650e-02f, 1.80575877e-01f, 2.76555959e-02f,
  -9.07069221e-02f, 4.05488648e-02f, -1.04056774e-02f, 2.54322857e-01f, 1.16407126e-01f, 5.31122647e-02f, 6.97468370e-02f, 1.59344703e-01f, 2.40393057e-01f, 3.48392837e-02f,
  1.47112340e-01f, 9.67557505e-02f, -1.01782696e-03f, 1.12058111e-01f, 1.80735052e-01f, 3.25089917e-02f, 5.69199212e-02f, 1.60011664e-01f, -6.13366999e-03f, 6.88335747e-02f,
  -9.64723006e-02f, 1.89433798e-01f, 1.69002175e-01f, 2.14672446e-01f, 2.21553490e-01f, 5.50388880e-02f, 6.06874451e-02f, 1.30044669e-01f, 6.53454512e-02f, 1.07549362e-01f,
  8.16216245e-02f, 3.41024309e-01f, 1.57492086e-01f, 2.26164058e-01f, -2.19013589e-03f, 2.43353471e-02f, 2.07616717e-01f, 1.72396004e-01f, 2.26222321e-01f, 2.03129038e-01f,
  2.31637761e-01f, -1.55859366e-02f, 7.92369023e-02f, 3.95028144e-02f, -1.79120828e-03f, 8.50446895e-02f, 8.42153677e-05f, 2.36483634e-01f, 8.01983178e-02f, -9.21620242e-03f,
  1.83449574e-02f, -2.46708710e-02f, 2.71804929e-01f, 2.17761159e-01f, -1.47739321e-01f, -1.25645950e-01f, -2.98863668e-02f, 1.88410550e-01f, -5.69323301e-02f, 2.86375791e-01f,
  -1.10327519e-01f, 2.28447363e-01f, -1.69546679e-01f, 2.04243749e-01f, 1.59816593e-01f, 2.15119477e-02f, 1.11264333e-01f, 4.17181179e-02f, 2.46760771e-01f, 2.15329885e-01f,
  -1.79283950e-03f, 8.66665468e-02f, 3.66849713e-02f, -4.74204980e-02f, 2.47634500e-02f, 6.82468042e-02f, 1.28588974e-01f, 9.53582898e-02f, 5.43219298e-02f, 1.07617624e-01f,
  -3.85179371e-03f, 9.70910713e-02f, -2.71644950e-01f, -1.80878028e-01f, 1.43174473e-02f, -1.00845277e-01f, -1.66429449e-02f, 1.50424674e-01f, 9.84475315e-02f, 6.43993029e-03f,
  -9.37888473e-02f, 3.70353311e-02f, -1.30119160e-01f, 3.02978698e-02f, 1.22119620e-01f, 6.11233935e-02f, 9.79168192e-02f, -1.98883214e-03f, 2.51592308e-01f, -1.30524337e-01f,
  1.37362689e-01f, 2.20938966e-01f, 1.17452033e-01f, -7.39981085e-02f, 4.79306839e-02f, 5.46116866e-02f, 9.86337811e-02f, 2.88548111e-03f, 2.75067687e-02f, 1.84119299e-01f,
  -3.48722190e-02f, 6.99562505e-02f, 2.14222103e-01f, 5.32356137e-03f, 2.19653249e-01f, -1.97172880e-01f, 7.86770806e-02f, -2.68599521e-02f, 1.92096248e-01f, 1.26322478e-01f,
  9.95206609e-02f, 5.09469770e-02f, 1.82490610e-02f, 5.59804030e-03f, 9.47917402e-02f, 2.06933871e-01f, 1.53378854e-02f, -1.39811754e-01f, -1.24975622e-01f, 8.54783282e-02f,
  -6.18916862e-02f, 7.04722926e-02f, -2.74542253e-02f, 6.91695139e-02f, 8.93857703e-02f, -2.87636556e-02f, 2.18437552e-01f, 1.29892543e-01f, 2.32998356e-02f, 1.14630580e-01f,
  1.87029794e-01f, 1.60800934e-01f, 2.09854469e-01f, 9.62048478e-04f, 8.84969458e-02f, 2.55081076e-02f, -1.59223706e-01f, 1.23642862e-01f, -1.86657220e-01f, -2.17337459e-02f,
  -6.02304190e-03f, -6.55873567e-02f, 3.66498381e-02f, -6.25223592e-02f, 7.70126954e-02f, 1.24285102e-01f, -1.28933907e-01f, -2.63430059e-01f, 2.05987796e-01f, 1.43974036e-01f,
  3.56496940e-03f, 2.80990660e-01f, 5.28055988e-02f, -1.20518850e-02f, 6.31693676e-02f, 1.13429399e-02f, 3.90669219e-02f, 2.08236128e-01f, 8.45279470e-02f, 1.28354430e-01f,
  1.47602245e-01f, -1.08403668e-01f, 1.41494796e-01f, 1.08249977e-01f, 1.78083166e-01f, -8.17443952e-02f, 2.72353828e-01f, -7.43133724e-02f, 2.15107530e-01f, 5.56957535e-02f,
  1.17123641e-01f, 1.14900023e-01f, 7.26346448e-02f, 5.50719956e-03f, -1.12993896e-01f, 1.66223153e-01f, 1.70185894e-01f, 2.32846901e-01f, 2.06535771e-01f, 1.47489369e-01f,
  -3.04152835e-02f, 1.17103346e-01f, 9.40592214e-02f, 4.19141613e-02f, 5.01417108e-02f, 1.27979860e-01f, 1.65594578e-01f, 1.36308655e-01f, 3.92486230e-02f, 6.85733110e-02f,
  -4.83399332e-02f, 1.11632407e-01f, 8.24954733e-02f, 1.40150845e-01f, 1.67934582e-01f, 5.20469435e-02f, 2.13764474e-01f, 1.03493750e-01f, 1.85726136e-01f, 2.61124849e-01f,
  -4.12147380e-02f, 1.06208444e-01f, -1.88724503e-01f, 5.89717701e-02f, 1.31292611e-01f, 1.32271573e-02f, -1.57155871e-01f, 1.18371747e-01f, -3.06199100e-02f, 2.46439233e-01f,
  1.66730180e-01f, -1.53340280e-01f, 1.67750984e-01f, 1.05334841e-01f, 2.46511828e-02f, 2.28896625e-02f, 1.47277601e-02f, 2.62570441e-01f, 9.42780729e-03f, -1.46670982e-01f,
  -2.23369561e-02f, 2.51639038e-01f, -1.30052278e-02f, -2.76781470e-02f, -1.28344983e-01f, 3.28164622e-02f, -2.25338582e-02f, -1.02034874e-01f, 1.55970976e-01f, -2.52064615e-02f,
  -1.49672478e-01f, 1.32101700e-01f, -4.81435470e-02f, 1.50328279e-01f, 1.35233611e-01f, 7.72145912e-02f, -4.92752902e-02f, -1.05743287e-02f, 8.32653493e-02f, 7.37553509e-03f,
  2.43892875e-02f, 3.77639711e-01f, 1.66626513e-01f, 7.61677250e-02f, -1.36115253e-01f, 1.00451149e-01f, 3.19680035e-01f, 1.14727117e-01f, 1.80535018e-01f, 2.79491413e-02f,
  1.41074266e-02f, -3.31108645e-02f, 1.32886589e-01f, 1.63737401e-01f, 1.39257029e-01f, 1.06697179e-01f, 1.11033522e-01f, 1.32506713e-01f, 1.66237071e-01f, 1.03171684e-01f,
  7.20531568e-02f, 1.95645735e-01f, 1.85275041e-02f, 1.62616119e-01f, 1.29508018e-01f, -2.40613610e-01f, -2.46049780e-02f, -8.75458866e-02f, -1.10249288e-01f, 1.28443018e-01f,
  -1.13790303e-01f, -9.35866758e-02f, 1.89781576e-01f, 2.24309079e-02f, -4.84954789e-02f, 2.46402338e-01f, -1.83351129e-01f, -2.58952349e-01f, 1.91096619e-01f, 4.66527678e-02f,
  4.90817763e-02f, 6.95336983e-02f, 1.39483586e-01f, -8.11501034e-03f, -8.82498473e-02f, -6.19744509e-02f, -1.05578909e-02f, -1.54573485e-01f, -9.39541832e-02f, 1.13846704e-01f,
  -6.91617839e-03f, -5.69367185e-02f, -1.15657255e-01f, 2.37491712e-01f, -8.35397691e-02f, -1.45913780e-01f, -1.41374152e-02f, -3.60185020e-02f, 2.26452574e-02f, 1.02151684e-01f,
  1.55766934e-01f, 8.15683603e-02f, 1.26047373e-01f, -1.81224179e-02f, 9.98403504e-03f, -9.31382328e-02f, -1.50575131e-01f, -8.23112652e-02f, 1.15488797e-01f, 3.57061699e-02f,
  2.31176559e-02f, -4.14311700e-02f, 1.70364037e-01f, -1.15329362e-01f, -1.22825436e-01f, 2.80441672e-01f, 1.12687208e-01f, 3.47773246e-02f, 9.52706933e-02f, 1.72834694e-01f,
  3.96277346e-02f, 8.85748565e-02f, -8.81983992e-03f, 1.83285236e-01f, 1.71301976e-01f, 2.39186045e-02f, 1.19786896e-01f, -3.59400106e-03f, 2.33603463e-01f, 2.16891602e-01f,
  -4.27876487e-02f, 1.46936998e-01f, -7.21991733e-02f, -3.34137790e-02f, 1.23348169e-01f, 2.60173976e-02f, 3.15178484e-01f, -1.36677027e-02f, 9.90718156e-02f, -1.74845420e-02f,
  -1.45007476e-01f, 2.11028293e-01f, -1.16521465e-02f, 8.93050805e-02f, -7.21572191e-02f, 1.05154745e-01f, 4.79666553e-02f, 6.40484318e-02f, 1.15424663e-01f, 4.70483117e-02f,
  2.11433396e-01f, -6.35139719e-02f, 5.25262132e-02f, 5.22490740e-02f, -5.19078150e-02f, -3.98300514e-02f, 3.45971771e-02f, 1.45689845e-01f, -1.63286954e-01f, 1.62148848e-02f,
  9.05030295e-02f, 1.09487638e-01f, 1.34420320e-02f, 2.09014446e-01f, -1.45454392e-01f, -1.57865301e-01f, -3.70179191e-02f, 2.42410794e-01f, 6.75085708e-02f, 1.01469263e-01f,
  2.59062275e-02f, 3.50437760e-02f, -6.69042915e-02f, 1.60743475e-01f, 1.30030900e-01f, 1.57189980e-01f, -7.53124012e-03f, 1.00097165e-01f, 1.44751489e-01f, 3.21097188e-02f,
  5.28970584e-02f, -4.49862555e-02f, -7.38690142e-03f, 1.31443352e-01f, -3.72063592e-02f, 1.15690231e-01f, 1.60915941e-01f, 1.19905271e-01f, 7.66338035e-02f, 6.45503923e-02f,
  -5.75374328e-02f, 6.24336489e-02f, 1.80759266e-01f, 5.56097217e-02f, 6.06492497e-02f, 5.62543496e-02f, -1.92533910e-01f, -8.32872242e-02f, -2.03858972e-01f, -1.96071461e-01f,
  2.43902970e-02f, -6.33660331e-02f, -7.75599033e-02f, 1.65957585e-02f, -6.60124049e-02f, -2.42886662e-01f, 2.59625405e-01f, 1.19386449e-01f, -1.98190570e-01f, 1.20327473e-02f,
  3.75634395e-02f, -7.44918734e-02f, -1.26427084e-01f, -2.32497361e-02f, -2.07224205e-01f, -1.73982769e-01f, 2.38513082e-01f, 1.59055382e-01f, 2.37831920e-01f, -5.14852218e-02f,
  -9.29994658e-02f, 1.91944663e-03f, -1.44366205e-01f, -1.63884789e-01f, -2.02115793e-02f, 2.04719961e-01f, -9.50895101e-02f, 1.06635414e-01f, -8.00480321e-02f, -2.99934112e-03f,
  1.67792976e-01f, -2.59727463e-02f, 2.41038874e-02f, -1.39324427e-01f, -2.66925305e-01f, -5.17476238e-02f, -1.21870160e-03f, 2.44560391e-01f, 4.81215538e-03f, 7.93869570e-02f,
  2.07984149e-02f, 7.81138539e-02f, -1.26002491e-01f, 9.88870673e-03f, 1.33583143e-01f, 9.82212424e-02f, 1.21758908e-01f, 1.41693994e-01f, 1.09243549e-01f, 1.19064212e-01f,
  9.21441466e-02f, 1.79747403e-01f, 9.64248702e-02f, 1.09805673e-01f, 5.34444116e-02f, 6.26635253e-02f, 6.50679544e-02f, 2.38324270e-01f, 1.27316877e-01f, 2.75165811e-02f,
  1.92573085e-01f, 8.88968166e-03f, -2.56474167e-01f, -1.46816909e-01f, 7.63010159e-02f, 1.84388712e-01f, 1.54697150e-01f, -1.04870975e-01f, 2.05157101e-01f, 1.56224817e-01f,
  -1.17139086e-01f, 2.94447336e-02f, -1.17834963e-01f, 3.04606050e-01f, 4.09796983e-02f, -1.79206178e-01f, 1.10898614e-01f, 2.30644450e-01f, -5.10193892e-02f, 2.34769195e-01f,
  -5.34686111e-02f, 2.58404851e-01f, -2.96920501e-02f, -4.28167125e-03f, 1.21932440e-01f, -9.28150583e-03f, -7.95634463e-02f, 1.39093891e-01f, -5.57349436e-03f, 2.33966798e-01f,
  -3.39525342e-02f, -9.08570513e-02f, -4.69572917e-02f, 8.82498547e-02f, 1.39550894e-01f, 1.33283183e-01f, -3.30727138e-02f, 2.11781323e-01f, 1.05744964e-02f, -7.04321414e-02f,
  -8.02694783e-02f, 1.65806636e-01f, 1.53710872e-01f, 1.02420665e-01f, -3.03821615e-03f, -9.01074931e-02f, 1.32282777e-02f, -1.12925358e-01f, 1.22534886e-01f, 1.84653893e-01f,
  1.32303193e-01f, 6.35927469e-02f, 2.11090550e-01f, 1.55490786e-01f, 2.75557600e-02f, -8.02353676e-03f, 1.91715196e-01f, 1.09178275e-01f, 1.84469283e-01f, -9.86409839e-03f,
  9.95201021e-02f, 2.88418442e-01f, -1.58597529e-01f, -9.17612165e-02f, 1.65964946e-01f, -7.67522827e-02f, 4.70710918e-02f, 1.03607655e-01f, 1.23256736e-03f, 1.22867599e-01f,
  2.10431069e-01f, -1.59387395e-01f, 5.81276082e-02f, 5.38039654e-02f, -6.66446015e-02f, 2.22440258e-01f, 1.01411559e-01f, 2.62168497e-01f, 3.72548699e-02f, 3.08522396e-02f,
  -1.02258191e-01f, -5.35789318e-02f, -3.04591618e-02f, 6.17733449e-02f, -4.10804227e-02f, -1.26367182e-01f, -1.52625293e-01f, 1.05559602e-02f, 3.61506760e-01f, -2.40369245e-01f,
  1.42371491e-01f, 1.02262199e-01f, 8.13950449e-02f, 1.22626811e-01f, 1.37353688e-01f, -4.91121821e-02f, -8.41126144e-02f, -1.49928406e-01f, -3.71238589e-02f, 2.77209759e-01f,
  6.65392876e-02f, 3.36702675e-01f, 1.12271905e-01f, -6.32367209e-02f, -1.67057052e-01f, -4.29564193e-02f, -6.02248609e-02f, 2.65835583e-01f, -2.77293473e-03f, -2.15909421e-01f,
  -1.92500487e-01f, -1.32889122e-01f, 2.99451184e-02f, -2.85246596e-03f, 1.71666145e-01f, 1.05814777e-01f, 1.21248677e-01f, 1.77865922e-02f, 1.19482413e-01f, 1.89215653e-02f,
  1.70017079e-01f, 1.98372044e-02f, 3.45447101e-02f, 1.22498646e-01f, -1.90928310e-01f, -2.29161814e-01f, -5.28087988e-02f, -1.25208095e-01f, -4.98752855e-02f, -3.50519195e-02f,
  1.64870024e-01f, -4.68330719e-02f, -7.39168450e-02f, -1.32123873e-01f, -4.65573855e-02f, 1.75781306e-02f, -6.35496750e-02f, 6.25810027e-02f, 1.86978415e-01f, -5.94428778e-02f,
  2.21641064e-01f, -5.96018322e-02f, 1.79949760e-01f, 1.81629911e-01f, 7.66771734e-02f, 4.90617938e-03f, 7.69998357e-02f, 4.91713770e-02f, 8.56813136e-03f, 5.23974858e-02f,
  3.31653282e-02f, 8.69672149e-02f, -1.56166375e-01f, 2.79273599e-01f, 1.66311041e-01f, -1.83233395e-01f, 1.18313849e-01f, -8.49229023e-02f, 8.42728764e-02f, 5.36343828e-02f,
  1.89591154e-01f, 4.61036861e-02f, -1.97659656e-02f, -5.02874441e-02f, 5.77699579e-02f, -2.76624948e-01f, -7.77975544e-02f, 2.24216375e-03f, 2.74228722e-01f, -2.99396571e-02f,
  -1.28857568e-01f, -1.27797276e-01f, 1.03266679e-01f, 2.14289740e-01f, 1.11650258e-01f, 2.62959301e-01f, 5.57284728e-02f, -3.91845256e-02f, 1.50111496e-01f, 1.16360970e-01f,
  1.76506825e-02f, 4.74722683e-02f, 1.47678837e-01f, 8.59296322e-02f, 1.67926922e-01f, 1.95841789e-01f, 1.04207113e-01f, -3.99978720e-02f, -7.16478825e-02f, 1.10463671e-01f,
  -1.17041245e-01f, 3.37034315e-02f, -4.89204675e-02f, 9.24857706e-02f, 1.11960553e-01f, 1.27804771e-01f, 1.51131481e-01f, 4.35511163e-03f, -9.29644182e-02f, -1.55022442e-01f,
  -4.55245003e-02f, 2.11637393e-01f, 3.80941853e-02f, 2.19733000e-01f, 1.47600204e-01f, 4.51862477e-02f, 1.57615751e-01f, 2.03726515e-02f, 2.43375033e-01f, -2.24783793e-01f,
  1.54932812e-01f, -1.89205781e-01f, 2.06504658e-01f, -2.16248557e-01f, 6.29608482e-02f, 3.19430716e-02f, 2.47330070e-01f, 1.29383862e-01f, 1.08846277e-01f, 3.44886929e-02f,
  1.85363457e-01f, -6.99652955e-02f, -2.52845958e-02f, 1.91597551e-01f, -6.42991364e-02f, -9.57461745e-02f, -1.24947965e-01f, 1.51231602e-01f, 8.91954824e-02f, 1.08288236e-01f,
  -4.83603142e-02f, 2.43333310e-01f, 2.11021565e-02f, 8.60819891e-02f, -1.20345153e-01f, 7.12793972e-03f, 1.03743793e-02f, 1.27661109e-01f, 1.04388064e-02f, 3.79175204e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.68678313e-01f, 6.38693348e-02f, -5.85811362e-02f, 1.27621368e-01f, 2.02472612e-01f, 3.24863493e-02f, 3.56666036e-02f, 8.52494314e-02f, 1.47710860e-01f, 2.11004429e-02f,
  5.65781221e-02f, 1.61372125e-01f, 1.29806072e-01f, 1.85914859e-01f, 5.26125059e-02f, 6.58199191e-02f, 5.52524328e-02f, 1.32890865e-01f, 1.25895977e-01f, 8.83133635e-02f,
  1.67598799e-01f, 1.45189017e-01f, 2.26178527e-01f, 5.54580092e-02f, 1.45513326e-01f, 1.84297621e-01f, 1.60104945e-01f, -3.07370629e-03f, 1.64712623e-01f, 2.49995694e-01f,
  4.48807590e-02f, 1.37553722e-01f, 1.05885886e-01f, -1.82229616e-02f, -4.58137505e-03f, -2.37251874e-02f, 1.86652124e-01f, 2.18639135e-01f, 1.50736526e-01f, 1.07441835e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.10409213e-02f, 3.47469468e-04f, -2.61696950e-02f, 1.64802030e-01f, -3.60569805e-02f, 1.75059348e-01f, 3.65187041e-02f, 5.17295673e-02f, -5.98950125e-02f, 1.78729347e-03f,
  -9.37948450e-02f, 1.07553840e-01f, -6.78563118e-03f, 9.28204432e-02f, -1.65281612e-02f, 2.01322451e-01f, 1.31880671e-01f, 1.27727896e-01f, -1.31345659e-01f, 4.77931760e-02f,
  -2.60319412e-01f, -2.81512409e-01f, -2.90733814e-01f, -2.15625569e-01f, -1.00769654e-01f, -5.58327660e-02f, 1.13206156e-01f, -4.46423441e-02f, 6.87453076e-02f, 4.35223989e-02f,
  1.24933772e-01f, -3.71216238e-02f, -6.16778061e-02f, -7.74131343e-02f, -1.60816237e-01f, -9.46105942e-02f, 8.73592943e-02f, -8.25872794e-02f, 2.46252529e-02f, 2.59467721e-01f,
  -4.62056622e-02f, -8.02837238e-02f, -1.72295377e-01f, -6.86747655e-02f, -1.87630698e-01f, 4.29192036e-02f, 1.28987461e-01f, 1.90005004e-01f, 8.52857903e-02f, -1.67823620e-02f,
  9.11755264e-02f, 7.16804564e-02f, 2.89886277e-02f, 9.74482372e-02f, -2.08380483e-02f, -6.09529763e-02f, 1.95933580e-01f, -1.04697958e-01f, -3.59470285e-02f, -6.87566325e-02f,
  1.28366753e-01f, 4.85965274e-02f, -8.73700082e-02f, -1.26003265e-01f, 1.39548928e-02f, 7.87327364e-02f, 4.73700240e-02f, 1.31065741e-01f, -1.06362998e-01f, 5.61523251e-03f,
  -2.24987734e-02f, 1.75707921e-01f, 1.50305122e-01f, 3.95246297e-02f, -6.48903176e-02f, 1.74299806e-01f, -9.94120613e-02f, -1.14681512e-01f, 9.52856094e-02f, 4.90641594e-02f,
  -3.25976200e-02f, 1.25818565e-01f, -1.28562897e-01f, 1.83746349e-02f, -4.31374945e-02f, 6.34692386e-02f, 3.98444347e-02f, 4.63643037e-02f, 1.10227250e-01f, -5.64864241e-02f,
  -1.20731838e-01f, -2.52423696e-02f, -1.83023550e-02f, -9.59901661e-02f, -3.24399509e-02f, -1.86567694e-01f, -2.28269119e-02f, -1.92852303e-01f, 1.32330686e-01f, 1.87082328e-02f,
  -7.85002932e-02f, -1.72199667e-01f, 1.41957566e-01f, 3.08765650e-01f, -5.72729968e-02f, 4.96610031e-02f, 6.33486360e-02f, 4.24902141e-02f, 5.94372526e-02f, -1.13053154e-02f,
  1.54655948e-01f, 4.18557562e-02f, 2.24361703e-01f, 4.91188541e-02f, -7.82255232e-02f, 2.00621694e-01f, 1.62968487e-01f, -4.36926261e-02f, -2.00121030e-02f, 2.74212845e-02f,
  9.10519883e-02f, 1.18715703e-01f, -2.33449981e-01f, -1.16600767e-01f, -1.40568167e-01f, -6.00713268e-02f, -3.27604488e-02f, 4.12309244e-02f, 4.70109619e-02f, 1.23047810e-02f,
  -1.20325191e-02f, 8.77321046e-03f, -3.21732201e-02f, -1.47613483e-02f, 1.10345364e-01f, -9.89940949e-03f, 7.71854147e-02f, -8.37063193e-02f, -1.90111343e-02f, -1.43063616e-03f,
  -1.73633378e-02f, 7.40314126e-02f, 1.82313640e-02f, 9.13045555e-02f, 1.36477621e-02f, -9.21844468e-02f, -1.06922843e-01f, 1.22852363e-01f, 6.50947914e-02f, -1.02234215e-01f,
  -1.89168558e-01f, -1.46748722e-01f, -8.11679661e-02f, -5.55828474e-02f, -1.85699500e-02f, -9.68867168e-02f, -1.55170515e-01f, -1.06069550e-01f, -4.44948711e-02f, 6.33175671e-02f,
  -6.26926273e-02f, -6.46060854e-02f, 5.32518812e-02f, 3.61583605e-02f, 5.27889505e-02f, -2.84624156e-02f, -1.10123679e-01f, -3.18243027e-01f, -3.60566890e-03f, -1.50407270e-01f,
  -1.04434907e-01f, -4.09496129e-02f, -9.56673771e-02f, 2.24028677e-02f, 6.55015782e-02f, 2.27060448e-02f, 7.44381920e-02f, 1.14119783e-01f, -2.35097393e-01f, 2.85286933e-01f,
  -5.70834316e-02f, -1.49895251e-02f, 2.88621727e-02f, 2.04197709e-02f, 1.12005226e-01f, -1.62290350e-01f, 7.55372494e-02f, -1.67761832e-01f, 3.56721804e-02f, 2.61291742e-01f,
  -5.89235984e-02f, 1.37324229e-01f, 1.61319628e-01f, 7.20690517e-03f, 1.69151038e-01f, 1.05810404e-01f, 9.82725099e-02f, 1.40955448e-01f, 9.03670490e-02f, 5.29699773e-02f,
  -7.11124018e-02f, -8.20194464e-03f, -1.07026458e-01f, 7.38662551e-04f, 1.06865585e-01f, 1.10478550e-01f, -1.59703359e-01f, 2.04667062e-01f, -2.98781600e-02f, 1.96762849e-02f,
  -1.81925401e-01f, 7.64883831e-02f, 2.49521248e-02f, -1.76044479e-01f, -1.72952712e-01f, -1.70282990e-01f, 2.78084762e-02f, 6.37320615e-03f, 3.77591476e-02f, 2.46475227e-02f,
  1.04561731e-01f, 5.88806160e-02f, -9.65149701e-02f, 1.27553910e-01f, 9.07194093e-02f, -1.78405464e-01f, -9.06228647e-02f, -7.88005963e-02f, 5.17581999e-02f, -3.63257565e-02f,
  -1.70848876e-01f, 1.30766146e-02f, 1.15543261e-01f, 3.15929092e-02f, -1.22608505e-01f, -3.00861560e-02f, -1.15659751e-01f, -9.48390812e-02f, 9.69706029e-02f, 1.57168821e-01f,
  1.48495629e-01f, 1.14544936e-01f, 9.80518106e-03f, -6.83805766e-03f, -1.50466841e-02f, -1.30156904e-01f, -8.48650783e-02f, -1.35784835e-01f, 4.18809503e-02f, 2.33973470e-02f,
  5.34341410e-02f, -1.73558283e-03f, 1.09112643e-01f, 2.32795607e-02f, 9.89006981e-02f, -1.47249758e-01f, 2.10475959e-02f, 5.50563820e-02f, 1.44067630e-01f, 1.04617618e-01f,
  7.26963580e-02f, 7.00106025e-02f, 1.75514311e-01f, 1.67573482e-01f, 9.90075096e-02f, 1.38721243e-01f, 1.65470868e-01f, -6.67239130e-02f, -2.84594744e-01f, -5.52972890e-02f,
  7.86549821e-02f, 5.61609603e-02f, 8.58904943e-02f, 9.34309363e-02f, 1.15991965e-01f, 1.20730214e-02f, -8.43250453e-02f, 5.25744073e-02f, 1.53750613e-01f, 1.25887781e-01f,
  4.16356921e-02f, -2.94745490e-02f, 7.98440650e-02f, -1.23994946e-01f, -1.14596067e-02f, 6.21588044e-02f, 1.64389059e-01f, -9.99030247e-02f, 1.31079063e-01f, -4.45739143e-02f,
  1.14324942e-01f, -3.25949192e-02f, 6.70845881e-02f, -1.60755500e-01f, 1.09007180e-01f, 2.89777875e-01f, -3.42625454e-02f, -4.02627364e-02f, 6.88811764e-02f, 1.78100929e-01f,
  3.67997065e-02f, -1.61641017e-01f, -1.67451259e-02f, 2.05918774e-01f, 1.88802302e-01f, -3.47433873e-02f, -1.75619841e-01f, -1.92619022e-02f, 1.73037499e-01f, -6.23688176e-02f,
  1.25019580e-01f, 2.45528426e-02f, 5.87139875e-02f, -9.94897783e-02f, -8.48682672e-02f, -2.18650382e-02f, -2.15058364e-02f, -3.32036205e-02f, 8.64332449e-03f, 2.93536894e-02f,
  -7.97757655e-02f, 7.13754743e-02f, 7.63116255e-02f, 4.93792119e-03f, -7.50463381e-02f, -1.14102863e-01f, -4.20083664e-02f, -5.14100865e-02f, 2.56868843e-02f, 7.69401938e-02f,
  -5.63626327e-02f, 6.14126846e-02f, -6.11147135e-02f, -1.49266064e-01f, -1.61945149e-01f, -1.18109703e-01f, -1.44106954e-01f, 1.04150653e-01f, -7.75182694e-02f, -7.39857480e-02f,
  -8.63995589e-03f, 1.10296249e-01f, 1.47023112e-01f, -5.97444251e-02f, 1.41840473e-01f, -1.35700494e-01f, 1.51754051e-01f, -1.14490213e-02f, 8.69370922e-02f, 6.29997328e-02f,
  -2.30246540e-02f, -6.12145476e-02f, 1.05476223e-01f, 4.02073958e-04f, -1.67246476e-01f, 2.78734472e-02f, -9.44572613e-02f, 3.95171978e-02f, 2.18069516e-02f, 2.15306431e-01f,
  1.22522235e-01f, 1.24463506e-01f, 1.25021651e-01f, -4.82599139e-02f, 4.88213301e-02f, 9.45536569e-02f, 1.45462446e-03f, 3.10659781e-02f, 1.04817832e-02f, 5.16863130e-02f,
  1.91629767e-01f, -1.05165534e-01f, 1.17993765e-01f, 1.21483309e-02f, -8.81620124e-02f, -4.10921499e-02f, -1.71484932e-01f, 1.66186482e-01f, 1.19878361e-02f, 2.47739449e-01f,
  -1.68501735e-02f, -1.12537466e-01f, -4.65137810e-02f, 1.17343608e-02f, 1.13238208e-01f, -6.89396635e-03f, 1.14840075e-01f, -1.13994256e-01f, -1.56972528e-01f, 4.88119908e-02f,
  -5.27305342e-02f, -1.67541225e-02f, -1.19161457e-02f, -6.31339028e-02f, 1.12835253e-02f, 4.10734564e-02f, -2.69275233e-02f, 4.65430096e-02f, -1.51178688e-01f, 1.35684803e-01f,
  -9.57564563e-02f, 2.63945125e-02f, -5.02198637e-02f, -6.81603104e-02f, -6.13812804e-02f, 2.20486727e-02f, 6.84819669e-02f, -4.73196665e-03f, 2.84570307e-02f, -2.69377399e-02f,
  3.85913290e-02f, -1.20308198e-01f, 1.63909405e-01f, -6.00393005e-02f, -7.64310826e-04f, -2.80487500e-02f, 1.59113333e-01f, 2.59907935e-02f, 2.83082612e-02f, -1.45809900e-03f,
  -7.54635781e-02f, 2.42981352e-02f, -8.36984366e-02f, 2.56263241e-02f, 2.82388125e-02f, 4.76096086e-02f, -1.42220840e-01f, 7.23381415e-02f, -2.24120561e-02f, -5.46300560e-02f,
  -3.12312841e-02f, 1.65297121e-01f, 1.67010278e-01f, -4.62246872e-02f, 1.89820006e-01f, -1.42423272e-01f, 1.48750380e-01f, -1.14459628e-02f, -1.14509687e-01f, -8.13825503e-02f,
  -4.50403169e-02f, 9.07324404e-02f, -1.23806998e-01f, 6.62015602e-02f, 2.34071771e-03f, -1.18516713e-01f, 3.65546048e-02f, -1.55458033e-01f, -1.14561260e-01f, -6.33644164e-02f,
  1.03633150e-01f, 3.11271497e-03f, 1.50514379e-01f, -1.10092647e-02f, 4.60099094e-02f, 2.48145424e-02f, -4.83180434e-02f, -4.89860140e-02f, 1.40286729e-01f, 5.97511753e-02f,
  -2.82687377e-02f, -3.80877033e-02f, -1.08610705e-01f, -1.80452272e-01f, -1.40859121e-02f, 1.28526315e-01f, 6.01048069e-03f, -5.98160923e-02f, 2.11602107e-01f, -6.61276355e-02f,
  6.12768382e-02f, 1.10539384e-01f, -3.03528029e-02f, -1.90828890e-02f, -4.26744893e-02f, -4.71225195e-02f, 5.60129806e-02f, 2.14789584e-01f, -3.73311229e-02f, -1.15120441e-01f,
  1.83352217e-01f, 9.52057615e-02f, -1.33326650e-01f, -2.96450593e-02f, -1.23696640e-01f, 2.02072367e-01f, -3.35903205e-02f, 1.80232134e-02f, 7.03836381e-02f, 4.80598807e-02f,
  -1.73322394e-01f, 1.81866348e-01f, 7.15288892e-02f, -5.95795549e-02f, -1.62116826e-01f, -1.54068947e-01f, -8.21823180e-02f, -1.85427219e-01f, 1.00705273e-01f, 6.56921044e-03f,
  -5.08160256e-02f, -1.45518273e-01f, 3.36078368e-02f, -1.17509544e-01f, -1.78730980e-01f, 1.59495771e-01f, 5.21043912e-02f, 1.71765655e-01f, -4.50008959e-02f, 1.53921293e-02f,
  4.08387790e-03f, 7.56612718e-02f, -8.07492882e-02f, -8.06380287e-02f, -3.98576297e-02f, 1.91800836e-02f, 7.02515915e-02f, -7.71979392e-02f, -1.19039237e-01f, 5.96266761e-02f,
  7.86856338e-02f, -1.18537128e-01f, 7.88789093e-02f, 2.71863788e-02f, 9.48676281e-03f, -1.39751270e-01f, 1.10808559e-01f, -1.21099584e-01f, -6.76027834e-02f, -1.80472713e-02f,
  6.48456290e-02f, 7.58590475e-02f, 2.49584615e-01f, 1.13518916e-01f, 1.54085621e-01f, 4.56029437e-02f, 8.62243474e-02f, 1.26223966e-01f, -1.64224342e-01f, -4.41046394e-02f,
  -3.91188934e-02f, 8.66366401e-02f, -1.31451964e-01f, -1.42558217e-01f, 1.04922459e-01f, 1.10798702e-01f, -1.19467899e-02f, 2.95298509e-02f, 3.20410822e-04f, 4.28054631e-02f,
  2.48127449e-02f, -9.82164815e-02f, 1.40238762e-01f, 4.29448411e-02f, 6.94424734e-02f, -1.50861975e-03f, -4.07515317e-02f, -1.04046330e-01f, -1.12483278e-01f, -1.05474532e-01f,
  1.02446407e-01f, -1.32897928e-01f, 7.27825463e-02f, -8.98562430e-04f, -1.29857451e-01f, -5.72588034e-02f, 4.07747999e-02f, 6.12905361e-02f, -1.17589585e-01f, -1.26818698e-02f,
  1.20145246e-01f, 9.62985829e-02f, -1.83288455e-01f, -8.65811780e-02f, 1.86276287e-01f, 1.55371577e-01f, 4.44920808e-02f, 3.34434360e-02f, 1.52984895e-02f, -4.27854359e-02f,
  -1.12360224e-01f, -6.78138509e-02f, 1.06816508e-01f, 1.13999493e-01f, -1.12771504e-01f, -1.63143873e-02f, -9.64960456e-02f, -4.27449914e-03f, -5.82185090e-02f, -2.01731026e-01f,
  1.09396018e-02f, -1.75438244e-02f, 2.66754515e-02f, -8.24282914e-02f, -5.41270152e-02f, -3.51139568e-02f, 2.26110712e-01f, 3.19229215e-01f, 2.47322306e-01f, 1.61249891e-01f,
  4.07440066e-02f, -8.37752074e-02f, -2.15120092e-02f, 7.91476481e-03f, 6.53592870e-02f, 1.74784690e-01f, -5.11511862e-02f, -1.29198954e-01f, -5.17485850e-03f, 1.64024040e-01f,
  -9.25722942e-02f, -1.52738661e-01f, 3.88006717e-02f, -1.15057692e-01f, 1.73423350e-01f, -9.42139998e-02f, 3.05874776e-02f, 9.08776075e-02f, 3.88595387e-02f, 1.01312712e-01f,
  1.91991776e-01f, 2.86647584e-02f, -7.39230737e-02f, 1.23241141e-01f, 1.08652301e-01f, -6.60962537e-02f, -8.92971009e-02f, -2.36211792e-01f, 7.06171542e-02f, 8.57003704e-02f,
  3.57701890e-02f, 3.17999311e-02f, -2.86097582e-02f, -2.40481552e-02f, 9.18787569e-02f, 6.17614798e-02f, -1.36831719e-02f, -2.45087966e-01f, 1.80588275e-01f, 1.09628901e-01f,
  5.61859943e-02f, 2.16348097e-02f, 3.50984745e-02f, -1.10184811e-01f, -5.84148839e-02f, -1.32123560e-01f, 4.26886156e-02f, -4.99612354e-02f, 3.34852412e-02f, -1.70141518e-01f,
  -4.06223610e-02f, -1.16111882e-01f, -1.20159931e-01f, -1.44245803e-01f, -6.94879070e-02f, -7.05068484e-02f, 9.61508155e-02f, -8.93678740e-02f, 1.66197941e-01f, 5.76849952e-02f,
  1.01873234e-01f, -1.02810390e-01f, 6.82103112e-02f, -1.94377631e-01f, -1.12769857e-01f, 1.06527507e-01f, -7.10017681e-02f, -2.34080665e-02f, -1.47830814e-01f, -6.45744205e-02f,
  -7.49347135e-02f, 1.31409973e-01f, 3.06029362e-03f, 4.58697975e-02f, 1.22529589e-01f, -5.82190081e-02f, 2.15856090e-01f, -1.23094879e-02f, 9.97803435e-02f, -1.28948078e-01f,
  1.33054495e-01f, -2.66617864e-01f, -2.93711312e-02f, -6.88018203e-02f, -7.60225430e-02f, 1.65895268e-01f, 6.20661639e-02f, 1.57578200e-01f, 5.06822988e-02f, 4.54402864e-02f,
  -2.50955373e-01f, -1.13985233e-01f, -4.45058849e-03f, -4.60017547e-02f, 6.07773755e-03f, 9.75801200e-02f, 9.36066583e-02f, -2.66966205e-02f, 1.30518451e-01f, -9.02273655e-02f,
  1.06550045e-01f, -5.66339828e-02f, -1.19647598e-02f, -6.99908957e-02f, 1.38962269e-01f, 1.17152505e-01f, 1.09081708e-01f, 1.31195858e-01f, -1.84482187e-02f, 6.04964048e-02f,
  2.51855049e-02f, 1.54091930e-02f, -6.79769814e-02f, 9.06365830e-03f, 2.92843813e-03f, 3.16390172e-02f, 1.21072575e-01f, 2.06517324e-01f, -1.60016790e-01f, 7.30242506e-02f,
  -8.22592080e-02f, -7.41706640e-02f, 8.16355571e-02f, -3.47869396e-02f, -2.17348054e-01f, 2.13624053e-02f, -1.52331367e-01f, -1.60997465e-01f, 1.01244971e-01f, -2.39324160e-02f,
  -9.74040031e-02f, -4.77658994e-02f, 1.88526049e-01f, 5.26070930e-02f, -1.14251480e-01f, 1.80289090e-01f, -3.79651203e-03f, -2.53525954e-02f, -1.32831171e-01f, 1.20176055e-01f,
  6.61379844e-02f, 9.50476155e-02f, 2.01636273e-02f, -4.39310633e-02f, 1.92298949e-01f, -3.57773453e-02f, -7.80765638e-02f, -5.50181419e-02f, -1.23283416e-02f, -1.15966663e-01f,
  1.13557331e-01f, 1.30146965e-01f, -6.69615120e-02f, 6.90218434e-02f, 2.04203308e-01f, -6.40225597e-03f, 1.30690724e-01f, -1.38331950e-01f, -1.33357957e-01f, -1.37386754e-01f,
  -2.44781561e-02f, -5.71525376e-03f, -3.28911021e-02f, 1.33572042e-01f, -6.16572276e-02f, -1.53271660e-01f, -4.80237417e-02f, -1.92586973e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.28634331e-02f, -7.54106119e-02f, -1.17818199e-01f, 3.71427909e-02f, -1.55125782e-01f, 9.77933779e-02f, -1.29020661e-01f, 6.55382425e-02f, -2.92076152e-02f, -1.10001475e-01f,
  9.22089219e-02f, -7.99164250e-02f, -4.83879410e-02f, 3.53677571e-02f, 5.28594479e-02f, 1.02970310e-01f, 7.19827786e-02f, -4.59178202e-02f, 9.68369320e-02f, -5.74014857e-02f,
  3.84764113e-02f, 9.93201360e-02f, 8.93613696e-02f, 3.03563327e-02f, 7.24623278e-02f, -7.29800835e-02f, -3.43884863e-02f, 2.78898031e-02f, 5.93857206e-02f, -1.07652701e-01f,
  -1.28328159e-01f, -2.95071863e-02f, 4.83458415e-02f, -6.14476576e-02f, -8.71449709e-02f, -1.55768722e-01f, 2.24237870e-02f, 7.17663318e-02f, 5.39584011e-02f, -5.87911457e-02f,
  -1.47506520e-01f, 1.13814687e-02f, -1.39505044e-03f, -6.79802969e-02f, -5.82442060e-02f, -1.02494501e-01f, -6.79091588e-02f, -1.46244273e-01f, -1.49943456e-01f, -1.69167489e-01f,
  1.03113122e-01f, -1.00591332e-02f, -7.31055364e-02f, 8.31090510e-02f, 1.92040682e-03f, 2.37983707e-02f, 1.05785884e-01f, -1.28833085e-01f, 2.75098253e-02f, 6.70954138e-02f,
  -1.02984510e-01f, -1.85296200e-02f, -2.95255315e-02f, -7.83342496e-02f, 1.83959842e-01f, 3.21423747e-02f, -3.01323906e-02f, -4.26264741e-02f, 1.31379575e-01f, 9.65905264e-02f,
  -1.04051447e-02f, 1.31056085e-01f, 1.24544434e-01f, 1.14508033e-01f, 5.07731565e-05f, 2.26110462e-02f, -5.99953085e-02f, 2.42171049e-01f, -3.60859960e-01f, 1.26496032e-01f,
  1.43861279e-01f, 1.85961112e-01f, -5.82840759e-03f, -7.58172050e-02f, -1.92093939e-01f, 7.53010586e-02f, -1.66243747e-01f, -4.69486229e-02f, -2.79054735e-02f, 1.95554122e-02f,
  2.50974685e-01f, 1.70201302e-01f, 8.75759646e-02f, 1.41896561e-01f, 1.58810258e-01f, 2.33421288e-02f, 1.60073727e-01f, -1.21182188e-01f, 7.59670213e-02f, 2.58668568e-02f,
  8.78437236e-02f, -1.97541760e-03f, -7.05230013e-02f, 2.88887136e-02f, 3.93788815e-02f, 2.22057506e-01f, -7.74212703e-02f, 2.14512125e-01f, 1.30224615e-01f, -1.64740935e-01f,
  2.16458812e-01f, 2.69538134e-01f, 1.92480743e-01f, 6.29399717e-02f, 1.90549657e-01f, -1.86378017e-01f, 2.74033099e-01f, 7.01590627e-02f, -7.64362589e-02f, 1.25552222e-01f,
  1.46183744e-01f, 1.92469180e-01f, -7.91974291e-02f, 6.92309886e-02f, 2.74884999e-02f, -4.11731005e-03f, 9.71121192e-02f, -1.57615796e-01f, -2.45132074e-01f, -2.52304733e-01f,
  -1.02082752e-01f, -2.23727874e-03f, 6.82301633e-03f, -4.20195945e-02f, 7.44558424e-02f, -1.09692477e-01f, 5.24170361e-02f, 5.59421629e-02f, 4.55566570e-02f, 6.73980415e-02f,
  1.54347748e-01f, 6.19594753e-02f, -1.10000232e-02f, -1.46696106e-01f, -2.40510255e-01f, 1.83110192e-01f, -9.70150828e-02f, 5.76827154e-02f, -1.59938157e-01f, -7.96198174e-02f,
  -5.94118051e-02f, 1.09233961e-01f, 3.01876608e-02f, 7.58324862e-02f, 7.31183961e-02f, 4.91517633e-02f, 1.06984809e-01f, 1.15582645e-02f, -3.82113010e-02f, -3.66865322e-02f,
  5.59211262e-02f, 2.67050918e-02f, -2.71075487e-01f, -5.89255169e-02f, 4.22846153e-02f, -5.04170433e-02f, -1.53993458e-01f, -2.41761170e-02f, -5.04800603e-02f, 1.94956258e-01f,
  -1.31691471e-01f, 3.22991540e-03f, -8.34176242e-02f, -7.07801282e-02f, -7.35671073e-02f, -2.16857612e-01f, -2.32510552e-01f, -2.84417599e-01f, 1.50790378e-01f, -5.23651615e-02f,
  -1.15672220e-02f, 8.20799470e-02f, -1.64040327e-01f, -1.81025162e-01f, 2.55130827e-02f, 1.49182752e-01f, -6.37649223e-02f, 1.94095060e-01f, 6.40842468e-02f, -9.20587927e-02f,
  3.78987403e-03f, 5.77155501e-02f, 4.45912033e-02f, 1.87805474e-01f, 1.35541305e-01f, 6.80460632e-02f, 1.07455812e-01f, 8.90547484e-02f, 1.44214049e-01f, -2.41084304e-02f,
  1.14684254e-01f, 1.70652434e-01f, 7.28867427e-02f, 1.12789251e-01f, 3.43186520e-02f, 2.18965158e-01f, 2.44364396e-01f, -5.66079393e-02f, 1.77514981e-02f, -6.15472719e-02f,
  -1.12223066e-02f, -3.71639356e-02f, 5.35508106e-03f, -2.83515811e-01f, -3.44904810e-01f, -2.51141101e-01f, 5.87401865e-03f, 1.07147090e-01f, -4.29541767e-02f, 3.30664329e-02f,
  -5.38736284e-02f, -5.35424501e-02f, 1.03972675e-02f, 3.67152281e-02f, -1.55565977e-01f, 1.66321114e-01f, 1.97356388e-01f, 2.61865944e-01f, 5.23319021e-02f, 1.74412653e-01f,
  -8.70397463e-02f, 2.54077554e-01f, -1.64518014e-01f, -5.08715138e-02f, -1.02488942e-01f, 1.09086111e-01f, -1.46303073e-01f, -5.31014614e-02f, 3.13931584e-01f, 9.51791275e-03f,
  1.13663211e-01f, 1.07795194e-01f, -9.63294059e-02f, 3.04206520e-01f, 5.58282249e-02f, 1.58853993e-01f, -7.49298632e-02f, 4.31873053e-02f, 3.35758448e-01f, -7.06747174e-02f,
  1.50474049e-02f, 4.10369709e-02f, 3.04990172e-01f, 2.53393054e-01f, -1.29480034e-01f, 1.06087893e-01f, 3.63775715e-02f, 2.66807415e-02f, 1.19587742e-02f, 5.05099371e-02f,
  1.57766566e-01f, -9.29907858e-02f, -2.31448095e-02f, -2.95822248e-02f, -1.09775871e-01f, 2.40865052e-02f, -5.74018471e-02f, -7.65492469e-02f, 2.80521587e-02f, 2.39839435e-01f,
  -2.24470437e-01f, -2.87675150e-02f, -1.26947254e-01f, -5.42307161e-02f, -1.03425579e-02f, -9.25115794e-02f, -1.11197382e-01f, 1.28924385e-01f, 7.77437314e-02f, -1.05818175e-01f,
  9.06694680e-02f, 2.61672348e-01f, -1.58767551e-01f, 1.48159653e-01f, 2.06552353e-02f, -3.92839722e-02f, -1.76571786e-01f, 3.03400606e-01f, -8.14482942e-02f, -8.28998759e-02f,
  2.15876788e-01f, -8.98628831e-02f, 3.20279859e-02f, 2.25037038e-01f, -5.22728153e-02f, -6.96834773e-02f, 1.36048004e-01f, -2.58786798e-01f, 1.81649581e-01f, -7.64696375e-02f,
  1.26860335e-01f, 1.35077775e-01f, 1.39818057e-01f, -1.78730384e-01f, -5.83947487e-02f, -1.94008369e-02f, 1.70605049e-01f, -2.21844837e-01f, -5.53708300e-02f, 1.20264553e-01f,
  -7.69662410e-02f, 1.29386961e-01f, 1.19613651e-02f, 1.50050715e-01f, 6.19375892e-02f, 3.46587785e-02f, 1.58047497e-01f, 1.23000471e-02f, -3.39428522e-02f, -1.15042608e-02f,
  -1.35929137e-02f, -9.43265930e-02f, -4.12217155e-02f, -1.01263978e-01f, 8.56335834e-02f, 7.59732444e-03f, -8.18744451e-02f, -1.30460083e-01f, -1.10871263e-01f, -1.54305071e-01f,
  -6.82727471e-02f, -1.31155744e-01f, 8.63173530e-02f, 9.10173804e-02f, -2.34332636e-01f, -1.29974529e-01f, 1.81923006e-02f, 1.58627294e-02f, 1.01145662e-01f, 9.43155773e-03f,
  -1.36545166e-01f, 1.30673200e-01f, 5.82533032e-02f, -1.36034399e-01f, 8.21085125e-02f, 2.43723974e-01f, -6.63833693e-02f, 2.12040514e-01f, -1.42946448e-02f, 4.72959056e-02f,
  -1.83023542e-01f, 2.80575275e-01f, -9.28650424e-02f, -1.29024342e-01f, 1.68379350e-03f, 1.89914312e-02f, 2.02436984e-01f, 2.05332875e-01f, -9.77971181e-02f, -2.08973676e-01f,
  2.29796395e-01f, -1.12609506e-01f, -4.35907207e-02f, -4.54860777e-02f, -4.13264073e-02f, 1.04240596e-01f, -6.60894737e-02f, -1.53153175e-02f, -7.41482154e-02f, 8.13193023e-02f,
  1.07264616e-01f, -1.11546278e-01f, 1.25619769e-01f, 2.26774663e-02f, -8.34003836e-02f, 1.16319172e-01f, -3.42890769e-02f, 4.95677777e-02f, 1.92260906e-01f, 1.00046523e-01f,
  2.06661201e-03f, -1.42993689e-01f, 1.77217379e-01f, 1.08475365e-01f, -9.45376903e-02f, 6.36075018e-03f, 2.22685095e-02f, -2.73048226e-02f, 1.82123303e-01f, -1.20110800e-02f,
  9.17155594e-02f, -1.20493412e-01f, 3.28129642e-02f, 1.23742335e-02f, 3.21375392e-02f, 1.20257996e-01f, 3.33305448e-01f, -8.58699232e-02f, -1.33951053e-01f, 3.77919935e-02f,
  -6.87479451e-02f, -1.15809046e-01f, -7.25013986e-02f, -2.39660650e-01f, 5.61525710e-02f, -1.12132341e-01f, -1.45030975e-01f, -1.84845068e-02f, 1.47032887e-01f, -1.45468622e-01f,
  3.38511735e-01f, -4.86623533e-02f, 1.82884514e-01f, 1.68598518e-01f, 2.34195262e-01f, 2.60305345e-01f, 1.64954558e-01f, 2.19162926e-01f, -2.57965446e-01f, 1.36043891e-01f,
  -1.56359524e-01f, 2.12939993e-01f, -5.79543114e-02f, -3.18991452e-01f, -1.36413619e-01f, 2.73714483e-01f, -2.05271952e-02f, 2.99081892e-01f, 1.50983348e-01f, -4.33416292e-02f,
  8.70423671e-03f, -1.17079899e-01f, -7.74471089e-02f, -2.47225523e-01f, 3.49290103e-01f, -1.23737112e-01f, -1.22356459e-01f, 4.19552475e-02f, -1.48773775e-01f, 6.48984611e-02f,
  1.93641275e-01f, 9.99197438e-02f, 1.13880783e-01f, 1.66475788e-01f, 2.27020696e-01f, 2.40777750e-02f, 2.10463591e-02f, 1.27773032e-01f, -4.63947393e-02f, 3.52091864e-02f,
  2.65480038e-02f, -1.31780859e-02f, 1.50191218e-01f, 1.18208886e-03f, -9.75427330e-02f, -4.39262549e-05f, 1.82444416e-02f, 4.69899327e-02f, 7.68868774e-02f, -5.54601550e-02f,
  1.94248885e-01f, -1.74857110e-01f, 1.17986418e-01f, -1.02237456e-01f, -1.13010719e-01f, 1.69145372e-02f, 1.84485514e-03f, 4.20596413e-02f, 2.19274804e-01f, -3.31389084e-02f,
  2.44703218e-02f, 1.70518696e-01f, 1.82922184e-01f, -7.56589994e-02f, 2.35069588e-01f, -1.05138250e-01f, 1.26658201e-01f, 1.82014391e-01f, 2.13196710e-01f, -5.38990721e-02f,
  1.19859129e-01f, 2.86608905e-01f, -1.47973448e-01f, 2.29480043e-01f, -1.69468626e-01f, 1.99621022e-02f, -4.75228624e-03f, -3.94186489e-02f, -2.31483892e-01f, 2.22018197e-01f,
  4.13793176e-02f, 2.44096279e-01f, 1.22348711e-01f, 3.63040753e-02f, 4.24849018e-02f, -1.05426937e-01f, 9.41300914e-02f, -2.17910588e-01f, 7.94023722e-02f, 1.39400691e-01f,
  -1.30127564e-01f, -5.79260290e-02f, -7.09009394e-02f, 1.37910470e-01f, 1.11768149e-01f, 8.31419826e-02f, 1.43919393e-01f, 1.36285618e-01f, 1.06112801e-01f, 1.83387130e-01f,
  7.02081621e-02f, 1.49432555e-01f, -8.84589329e-02f, 1.11511245e-01f, 4.27920558e-02f, 4.00737785e-02f, 1.88150644e-01f, 1.22779213e-01f, 5.73999546e-02f, -1.20031163e-01f,
  -7.73784444e-02f, 1.65041424e-02f, 8.03365260e-02f, 1.43122867e-01f, 3.09498906e-01f, 1.70174032e-01f, -1.08896062e-01f, -2.10722074e-01f, 8.31268355e-02f, 6.03230707e-02f,
  -1.24157928e-01f, -2.04650298e-01f, -1.22377284e-01f, -3.40247780e-01f, -3.52283537e-01f, 4.25327010e-02f, -5.44448420e-02f, 1.00098886e-02f, 1.71508670e-01f, 6.72010481e-02f,
  2.41449356e-01f, 1.73162043e-01f, 1.24450520e-01f, 9.40851644e-02f, 1.00457273e-01f, 2.94964135e-01f, -2.13703930e-01f, 8.63060579e-02f, 1.21071100e-01f, 2.21846044e-01f,
  -2.21294835e-01f, -1.64465271e-02f, -1.23177685e-01f, 2.75869042e-01f, -2.57815588e-02f, 9.04053450e-02f, -6.94006309e-02f, -5.54493107e-02f, 1.88321009e-01f, -1.27934664e-02f,
  -2.21947834e-01f, -1.93234235e-01f, 1.16288140e-01f, 1.88985705e-01f, -1.27716914e-01f, -6.31310791e-03f, -4.67645787e-02f, 1.62742272e-01f, 1.38884395e-01f, 1.24333285e-01f,
  1.66218117e-01f, 1.94466934e-01f, 2.41872683e-01f, 1.91845000e-01f, -2.15377212e-01f, -2.92375423e-02f, 6.00741804e-02f, -1.55961439e-01f, 1.43831789e-01f, -1.65230539e-02f,
  -1.79354906e-01f, 7.08656460e-02f, 2.03684077e-01f, 1.64863095e-01f, 2.59692743e-02f, 1.40834928e-01f, 8.36707726e-02f, 1.42845318e-01f, -1.80058926e-01f, 2.46683180e-01f,
  -3.27395126e-02f, 1.05319552e-01f, 1.18167244e-01f, 2.25609034e-01f, -1.09347910e-01f, 2.52213739e-02f, -5.06823123e-01f, 1.80983126e-01f, -1.72062322e-01f, -2.93176055e-01f,
  -2.59309560e-01f, 1.00417793e-01f, -2.50002176e-01f, 1.66273728e-01f, -1.19576760e-01f, -3.85452151e-01f, -1.14914782e-01f, -4.45378758e-02f, -3.80318798e-02f, -2.19540596e-01f,
  -1.14660710e-02f, -1.04458436e-01f, 3.68178666e-01f, 1.77992247e-02f, 4.57323007e-02f, 1.12926042e+00f, 1.93570122e-01f, -1.44362777e-01f, 4.96734902e-02f, -1.64731368e-01f,
  -6.19384013e-02f, 2.55471855e-01f, 2.25440264e-01f, 4.08577800e-01f, 2.46137366e-01f, 3.19406331e-01f, -2.42475763e-01f, -4.62404117e-02f, 2.89450854e-01f, 2.85961926e-02f,
  -3.93045601e-03f, 2.90157292e-02f, 2.39281982e-01f, -7.09294975e-02f, -6.82585016e-02f, -4.28896904e-01f, -1.98712014e-02f, 6.27346337e-02f, 1.38733208e-01f, -1.73410818e-01f,
  3.92365009e-02f, 2.14587912e-01f, 1.29012629e-01f, 9.73863229e-02f, 1.31498218e-01f, 1.65281579e-01f, 2.90678870e-02f, 8.00222158e-02f, 1.75564066e-02f, 5.12587614e-02f,
  1.39448568e-01f, 1.44338623e-01f, -1.92462057e-01f, -2.62324750e-01f, -8.30965191e-02f, 8.61404687e-02f, -9.24918707e-03f, 6.93666339e-02f, -2.50982881e-01f, -1.73812676e-02f,
  2.45822266e-01f, 2.02337459e-01f, 1.17922090e-01f, 7.70020559e-02f, 3.11136574e-01f, -1.59549937e-01f, 1.49352685e-01f, 3.33998911e-02f, 6.54500276e-02f, -8.93755034e-02f,
  1.22866377e-01f, -1.12348877e-01f, 1.92184329e-01f, 1.64931387e-01f, 1.74479440e-01f, 3.11013963e-02f, 5.94394952e-02f, -7.33786747e-02f, 3.20687294e-01f, 1.39087647e-01f,
  -1.24570571e-01f, 6.08335696e-02f, 1.99804410e-01f, 2.23427415e-01f, 2.69631088e-01f, -8.54255036e-02f, 1.03024036e-01f, 1.27412509e-02f, 1.41405910e-01f, 1.41038865e-01f,
  1.11398377e-01f, -7.02164555e-03f, 1.08620569e-01f, -1.03451237e-01f, 1.08877674e-01f, 1.80602476e-01f, 1.41643900e-02f, 1.80630654e-01f, -9.09862574e-03f, -7.07885474e-02f,
  -9.17367116e-02f, -1.47694042e-02f, 1.84287131e-01f, 1.40853897e-01f, 5.91802709e-02f, 4.46654223e-02f, 4.99297529e-02f, 1.21685214e-01f, 5.74148558e-02f, 3.89052480e-02f,
  -5.68764401e-04f, 6.27742335e-03f, 5.27913608e-02f, -1.83114000e-02f, 9.35204923e-02f, -7.70107210e-02f, 7.13534430e-02f, -1.59649864e-01f, 3.30900759e-01f, -2.01308548e-01f,
  1.69145092e-02f, -1.82975203e-01f, 1.07862532e-01f, -1.48957029e-01f, 2.83753365e-01f, 1.12547241e-01f, 1.79206774e-01f, -3.01561058e-02f, 1.03089474e-02f, 1.14805117e-01f,
  -1.97296441e-02f, 8.30311775e-02f, 2.44565378e-03f, 8.09437707e-02f, -1.48990631e-01f, 1.16750248e-01f, -1.11022152e-01f, 2.58962840e-01f, 2.40861535e-01f, 1.62523553e-01f,
  -4.74650152e-02f, 2.23810021e-02f, 2.12580919e-01f, 5.36708720e-02f, -1.78285062e-01f, -2.90201548e-02f, 2.50290215e-01f, -3.69545184e-02f, -5.61171286e-02f, 7.54588619e-02f,
  -7.09133297e-02f, -1.41939269e-02f, -8.48235264e-02f, -1.54078668e-02f, -1.75238624e-01f, 3.43783855e-01f, -1.74771830e-01f, 2.19525859e-01f, 1.65776893e-01f, 2.42456421e-01f,
  1.04273893e-01f, -1.21210895e-01f, 5.20339608e-02f, 1.67028636e-01f, -2.58642137e-02f, 2.11687893e-01f, 1.63841341e-02f, 2.90229499e-01f, -3.54488082e-02f, -1.54792085e-01f,
  -4.01570573e-02f, 9.31609794e-02f, 1.41262710e-01f, -8.84823501e-02f, 7.29112774e-02f, 2.27647871e-02f, 3.43314558e-02f, -1.20711826e-01f, -5.32381795e-02f, 7.16732070e-02f,
  2.26843432e-01f, 7.56386667e-02f, 3.41726169e-02f, -2.99949676e-01f, -9.49061126e-04f, -8.87597427e-02f, 7.23927617e-02f, -2.25930855e-01f, 1.21076405e-01f, -8.15701857e-02f,
  1.53650627e-01f, -1.02599308e-01f, 6.12477921e-02f, 1.81904241e-01f, 9.68555510e-02f, 2.46997923e-01f, 9.45321769e-02f, 1.95456743e-01f, -9.56517085e-02f, 2.69622654e-01f,
  -2.61994619e-02f, 2.71037370e-01f, 7.43742567e-03f, 1.72502533e-01f, -4.36749086e-02f, 1.51708573e-01f, 1.13730192e-01f, -7.94687942e-02f, -2.33285688e-02f, 8.39489512e-03f,
  1.12475798e-01f, -5.09866700e-02f, -1.22439656e-02f, 6.35682121e-02f, -1.14821412e-01f, -1.32732138e-01f, -2.35800073e-01f, -6.05971701e-02f, 2.49980196e-01f, -3.00755594e-02f,
  -5.25340326e-02f, 1.39968932e-01f, -1.29512131e-01f, 2.05430955e-01f, 1.74925223e-01f, -4.60293256e-02f, 2.96998739e-01f, 1.13010429e-01f, 9.97599289e-02f, 9.64837521e-02f,
  -1.29834637e-01f, 1.56981394e-01f, -1.47466496e-01f, -2.99677849e-01f, -2.94878781e-01f, -3.64013314e-01f, -2.94304341e-01f, -6.15091085e-01f, -2.79279888e-01f, -3.33834618e-01f,
  -1.10944323e-01f, -1.47238776e-01f, 2.93505639e-02f, -5.47041595e-01f, 2.44649097e-01f, -3.42727363e-01f, 6.30187035e-01f, -5.82313955e-01f, -6.95837215e-02f, -5.08372188e-01f,
  7.22012341e-01f, 1.84812486e-01f, 3.64521652e-01f, 3.74559611e-01f, 5.78165650e-01f, 2.60877371e-01f, 2.42168829e-01f, 2.20778316e-01f, -3.33232880e-01f, 2.34121591e-01f,
  -2.92318970e-01f, 2.55268127e-01f, -4.67806429e-01f, -1.34101808e-02f, -1.96913853e-01f, 2.89708585e-01f, 1.39942110e-01f, 1.30905330e-01f, 1.73702404e-01f, -1.02503888e-01f,
  2.70493150e-01f, -2.59690851e-01f, -2.12805606e-02f, 1.91642597e-01f, 2.42153317e-01f, -7.46273696e-02f, -2.67261686e-03f, 3.28327715e-01f, -2.63993770e-01f, -1.36523470e-01f,
  1.05187684e-01f, -1.37596712e-01f, -1.18419267e-01f, 8.26595202e-02f, -1.20530292e-01f, 1.39281049e-01f, 1.18101351e-01f, 9.12206471e-02f, -1.44079074e-01f, -1.89436376e-01f,
  3.35160643e-01f, 6.31691217e-01f, 3.12475692e-02f, -8.78030732e-02f, 2.37135757e-02f, 4.27420884e-01f, 8.19345862e-02f, 5.28938398e-02f, 9.97713581e-02f, -2.47541498e-02f,
  1.18930891e-01f, 6.86134398e-02f, -8.89948457e-02f, -3.86057571e-02f, 8.76367018e-02f, 1.25211179e-02f, 1.26318738e-01f, -6.05346896e-02f, -1.13457190e-02f, -1.22718588e-01f,
  -1.96748286e-01f, 9.43286046e-02f, -1.62756398e-01f, -1.55578628e-01f, 1.22203387e-01f, -1.02674462e-01f, 3.08559865e-01f, 2.48258397e-01f, 4.18966413e-01f, 1.85484231e-01f,
  1.65914789e-01f, 1.18492693e-01f, -6.71249554e-02f, -6.01740815e-02f, 1.54734895e-01f, 8.13172311e-02f, 5.82170859e-02f, -1.19282551e-01f, -4.11915183e-02f, 7.61917382e-02f,
  1.18687779e-01f, -8.63279961e-03f, 2.16209469e-03f, 2.78627072e-02f, 2.53258795e-01f, -2.13048875e-01f, 2.34050333e-01f, -7.19330981e-02f, 2.07734317e-01f, -7.86023214e-03f,
  2.18029678e-01f, 1.64131410e-02f, -1.97457359e-03f, -5.70137501e-02f, 7.11756796e-02f, 4.77292798e-02f, -2.26338636e-02f, -1.43547937e-01f, 1.65520608e-01f, 1.06705524e-01f,
  5.85494600e-02f, -1.92927830e-02f, -3.01376224e-01f, 1.77148595e-01f, 6.73913285e-02f, 1.05628585e-02f, -1.35095343e-01f, -1.63143829e-01f, 1.38244703e-01f, 1.16965860e-01f,
  -7.91270956e-02f, 5.82523644e-02f, -2.07926910e-02f, 1.44440487e-01f, 2.06176564e-01f, 2.11863127e-02f, -2.06331071e-03f, -1.49846554e-01f, 4.35939282e-02f, 7.68724382e-02f,
  -3.87120098e-02f, -4.58988547e-02f, 3.59895915e-01f, 2.78271258e-01f, -6.67683184e-02f, -2.12720796e-01f, -2.42017433e-01f, -1.23459391e-01f, -5.70093207e-02f, -1.19658574e-01f,
  -3.19998376e-02f, -1.04473241e-01f, -9.11509171e-02f, -1.20883837e-01f, 3.97762246e-02f, 1.71396986e-01f, -2.04354301e-01f, 1.95036039e-01f, 2.21176237e-01f, 2.65084375e-02f,
  -1.96335092e-01f, 3.34986717e-01f, 3.44359726e-02f, -4.04977202e-02f, -9.64661967e-03f, 1.21757902e-01f, 7.73793310e-02f, 1.49137944e-01f, -2.30170652e-01f, -1.89867094e-01f,
  1.80135176e-01f, -1.16694592e-01f, 3.95803489e-02f, -1.13420874e-01f, -9.29065570e-02f, 8.55290610e-03f, -5.13368845e-02f, -1.87438488e-01f, -3.06288153e-01f, -1.81582525e-01f,
  1.96614906e-01f, -1.45846814e-01f, -2.14833230e-01f, 2.38067359e-01f, -2.00605005e-01f, -1.76878572e-02f, 2.18685463e-01f, 2.82715172e-01f, 2.08653465e-01f, 2.09469602e-01f,
  8.90302137e-02f, -5.72327636e-02f, 7.53201544e-02f, 8.34197700e-02f, 1.05725065e-01f, 8.98068957e-03f, 2.23207340e-01f, 4.00496833e-02f, -4.32594158e-02f, 1.21831238e-01f,
  1.67563498e-01f, 1.76111124e-02f, 5.64524047e-02f, 4.94123548e-02f, 1.75504461e-01f, 2.16126859e-01f, 2.63940636e-02f, 8.93151313e-02f, -1.40675828e-01f, 7.57694095e-02f,
  2.33186454e-01f, 1.98416889e-01f, -2.06682444e-01f, -1.40009532e-02f, -1.93872824e-01f, -2.45333791e-01f, -2.82313615e-01f, -6.80187941e-02f, 4.36541066e-02f, -1.54728413e-01f,
  2.20501542e-01f, -6.04640357e-02f, 1.04958750e-01f, 2.59568483e-01f, 3.20984036e-01f, 3.91160920e-02f, 1.78403839e-01f, 2.53822565e-01f, -4.34694253e-02f, 2.68519640e-01f,
  -7.25938240e-03f, 6.22314550e-02f, 9.30542424e-02f, 4.74360287e-01f, 1.42065883e-02f, 3.02987397e-01f, 1.63067505e-02f, 2.32828960e-01f, 1.80077732e-01f, -1.22865610e-01f,
  1.82739481e-01f, 3.04686606e-01f, 3.30836654e-01f, 1.32263631e-01f, -1.74569637e-02f, 6.41597435e-02f, 2.64347225e-01f, 2.92714164e-02f, 1.38914278e-02f, 1.32970855e-01f,
  -2.56958660e-02f, -2.72216052e-02f, 1.70145649e-02f, 4.11395989e-02f, 1.36617079e-01f, 9.51549560e-02f, 1.63867287e-02f, 3.65324840e-02f, 8.34427848e-02f, -3.09099071e-03f,
  -2.61539184e-02f, 3.54348645e-02f, 4.46092151e-02f, 1.09051831e-01f, 5.66553511e-02f, -6.52965009e-02f, 6.06420860e-02f, 1.09797433e-01f, 2.24693120e-01f, 1.44713968e-01f,
  3.72375809e-02f, 1.32413715e-01f, 8.85206014e-02f, -1.55820340e-01f, -6.96539581e-02f, 3.28830385e-04f, -2.35280232e-03f, -8.28410238e-02f, 2.18611836e-01f, 2.88067222e-01f,
  9.61690769e-02f, 7.97438994e-03f, 5.47246784e-02f, 2.12240398e-01f, -1.08231783e-01f, 1.77865103e-01f, -2.97065061e-02f, 8.77296180e-03f, -5.76289669e-02f, -6.16792105e-02f,
  1.44811973e-01f, 1.07353084e-01f, 2.37970546e-01f, -8.17609504e-02f, 9.56954360e-02f, 2.11496979e-01f, 1.21049456e-01f, 2.23938879e-02f, 1.99604690e-01f, 8.95385742e-02f,
  7.38604590e-02f, 6.07122332e-02f, 2.66955584e-01f, 2.18516603e-01f, -8.61254185e-02f, -6.45090267e-02f, 1.32478401e-01f, 6.38031587e-02f, 2.17278168e-01f, -1.18433312e-01f,
  4.14443351e-02f, 1.35671571e-01f, 6.81053102e-02f, -3.92403826e-02f, -5.32832742e-02f, 2.77333558e-01f, 1.28318146e-01f, 1.46879494e-01f, -1.18724443e-01f, 1.76429376e-02f,
  2.92222708e-01f, 2.80027598e-01f, 1.05343387e-01f, 1.48025110e-01f, 1.55369997e-01f, 2.20935285e-01f, -4.52698693e-02f, 2.71842510e-01f, 1.70235671e-02f, 1.45907819e-01f,
  3.57819460e-02f, 1.37827858e-01f, -5.61686642e-02f, 3.87204550e-02f, -9.33725610e-02f, 1.85829237e-01f, -9.09357220e-02f, 2.85152406e-01f, 6.32803068e-02f, 3.54755111e-02f,
  -2.25543946e-01f, 5.57941478e-03f, -1.58400973e-04f, -4.80634235e-02f, -9.81007293e-02f, -5.92890643e-02f, 1.35951236e-01f, -1.08947698e-02f, -5.91751225e-02f, 1.23466313e-01f,
  6.78799748e-02f, -7.12659061e-02f, 1.34410530e-01f, 2.23599613e-01f, 4.67062891e-02f, -7.18616471e-02f, 1.90174907e-01f, -1.52303241e-02f, -4.82050935e-03f, 1.33500427e-01f,
  -1.22514954e-02f, 4.19647247e-01f, -7.60238692e-02f, -1.22323129e-02f, 5.27084023e-02f, 6.11740910e-02f, 1.05045721e-01f, -1.57875404e-01f, 2.71735638e-01f, 1.79847747e-01f,
  2.19275430e-01f, 1.60713419e-01f, 1.47233963e-01f, -3.54493186e-02f, 2.45439604e-01f, 8.97326693e-02f, 2.18923390e-01f, 7.73191312e-03f, 2.29014590e-01f, 9.55126956e-02f,
  -1.51348114e-01f, -3.12012453e-02f, 1.90595597e-01f, 4.32873815e-02f, 1.58106849e-01f, -8.27353001e-02f, -6.60446882e-02f, 8.19357783e-02f, 1.08734697e-01f, 1.86638162e-01f,
  6.46387339e-02f, 1.72856808e-01f, 2.03092605e-01f, -8.64585582e-03f, 9.59503204e-02f, -2.34374050e-02f, -1.23255318e-02f, 9.97142717e-02f, 6.67309985e-02f, 1.34910658e-01f,
  9.61208493e-02f, -7.59002790e-02f, 5.36429882e-02f, -2.40920782e-02f, -1.84547126e-01f, 6.16605878e-02f, -2.23181635e-01f, -1.39630452e-01f, -3.51949245e-01f, -3.31892937e-01f,
  -2.47343898e-01f, 1.34373114e-01f, 1.30406007e-01f, 2.03586742e-01f, 3.71671431e-02f, -4.49330993e-02f, 2.61029638e-02f, 2.08914831e-01f, 9.21618789e-02f, 1.32464290e-01f,
  4.64687236e-02f, -4.87328283e-02f, 2.74076134e-01f, 5.49433418e-02f, 1.01653472e-01f, 6.46762073e-01f, 1.50641620e-01f, -3.46942432e-02f, -8.76883864e-02f, -5.37185669e-02f,
  -8.31908807e-02f, 1.78916335e-01f, 9.04979929e-02f, 2.61617154e-01f, 5.40348217e-02f, 5.56596965e-02f, -8.55465606e-02f, 2.96435267e-01f, -6.00782707e-02f, 1.89118743e-01f,
  -8.35365728e-02f, 8.61158296e-02f, 2.61584640e-01f, -3.59985419e-02f, 2.30608910e-01f, -9.10767838e-02f, 2.27197066e-01f, 2.84867316e-01f, 4.00626585e-02f, 6.76577771e-03f,
  8.09425637e-02f, -2.87238676e-02f, 1.85503811e-01f, -6.14841692e-02f, -4.08456214e-02f, 8.56192335e-02f, -3.35166752e-02f, 2.36572951e-01f, 5.74130118e-02f, 1.97510034e-01f,
  1.27208218e-01f, -9.48317200e-02f, -1.50872380e-01f, -2.68518948e-03f, 5.40228002e-02f, -1.27070602e-02f, 9.19749811e-02f, -2.55199373e-01f, -1.07721381e-01f, -1.24826185e-01f,
  1.99999571e-01f, 2.16021642e-01f, 1.30913049e-01f, -2.34990284e-01f, 9.57947746e-02f, 3.08567405e-01f, -2.81530291e-01f, 2.02744156e-01f, -2.27069661e-01f, 4.40919660e-02f,
  -1.93486854e-01f, 2.12760881e-01f, 2.15503946e-02f, -2.84018740e-02f, 2.71806628e-01f, -8.39383453e-02f, 1.75300881e-01f, 5.56021631e-02f, 1.72132611e-01f, 3.75152916e-01f,
  1.15743630e-01f, -5.48716895e-02f, 2.39606559e-01f, -1.48757055e-01f, 1.15715660e-01f, 3.13504130e-01f, 1.23354197e-01f, 3.55317034e-02f, -5.48278615e-02f, 2.18013898e-01f,
  -1.16339028e-01f, 1.35966346e-01f, -8.45504925e-02f, 3.21811944e-01f, 1.62448362e-01f, 2.48458222e-01f, 2.34227329e-01f, -7.07696527e-02f, 1.73199892e-01f, -4.10154415e-03f,
  5.17133474e-02f, 1.30290389e-01f, 5.93963824e-02f, 2.71399707e-01f, 5.66979535e-02f, 9.72703099e-02f, 7.80568719e-02f, 1.47607908e-01f, 1.93068847e-01f, 1.82435572e-01f,
  -1.54176131e-01f, -3.02047171e-02f, 1.24479361e-01f, 6.93540275e-02f, 1.69149980e-01f, 9.69663337e-02f, -7.29823112e-02f, 1.99865899e-03f, -3.78062427e-02f, -1.12860389e-02f,
  -1.29755065e-01f, 1.62018638e-03f, -6.33144006e-02f, -1.15350060e-01f, 4.75386754e-02f, 1.72983110e-01f, 7.68429264e-02f, 4.83844914e-02f, 1.19595692e-01f, 3.00379515e-01f,
  -2.36345202e-01f, 8.76542330e-02f, -2.47233105e-03f, -1.14019416e-01f, -6.99234381e-02f, 1.86154217e-01f, 1.54946102e-02f, -1.16001882e-01f, 2.46792093e-01f, -1.07252076e-01f,
  4.65779714e-02f, 2.33698010e-01f, -2.50860974e-02f, 2.65851200e-01f, 1.76674530e-01f, 5.79941906e-02f, 3.96226458e-02f, -1.17138758e-01f, 2.00113744e-01f, 1.14407204e-01f,
  6.12761360e-03f, -5.44414222e-02f, -1.57152787e-01f, 1.73364550e-01f, 2.08335400e-01f, -7.56453723e-02f, -1.38295725e-01f, 2.43183047e-01f, 2.09386349e-02f, 1.21211551e-01f,
  1.51192859e-01f, 1.86079487e-01f, 2.05094159e-01f, 1.96846034e-02f, -6.27766326e-02f, -4.83686067e-02f, 1.32542118e-01f, 1.77348077e-01f, 1.67603359e-01f, 1.25791177e-01f,
  1.61915138e-01f, 3.81816253e-02f, -8.40913281e-02f, 2.61582881e-02f, 1.40744165e-01f, 3.84856202e-02f, 2.92224027e-02f, -1.74595811e-03f, 9.96796265e-02f, 6.44022040e-03f,
  -2.02226385e-01f, -7.57238045e-02f, -2.34873489e-01f, 2.11564496e-01f, 2.29725540e-01f, -6.88599870e-02f, 3.55796493e-03f, -4.42717457e-03f, -6.04555272e-02f, 1.93967223e-01f,
  2.17540517e-01f, 1.04704835e-01f, 1.56573161e-01f, -9.24554989e-02f, 1.61066279e-01f, 2.82098223e-02f, 2.53063679e-01f, 8.51936340e-02f, 2.70424664e-01f, -6.28312379e-02f,
  2.60580570e-01f, 3.23348902e-02f, 6.28437698e-02f, 7.88425468e-03f, -9.61824358e-02f, 4.75222543e-02f, 1.36020809e-01f, 7.61415344e-03f, 1.50143281e-01f, 1.47675440e-01f,
  2.75846541e-01f, 1.99108515e-02f, 2.80392915e-01f, -7.20727220e-02f, 1.90091301e-02f, 3.06740642e-01f, 2.99851030e-01f, 1.70016274e-01f, 1.58455536e-01f, -1.39790967e-01f,
  2.82747984e-01f, 3.39768864e-02f, 2.72927016e-01f, 1.02948308e-01f, -2.11045995e-01f, -2.57717725e-03f, -1.15999557e-01f, -8.06769878e-02f, 2.68289540e-02f, -1.00213990e-01f,
  2.48864919e-01f, -3.64918844e-03f, 9.84117538e-02f, 1.15256704e-01f, -6.72856495e-02f, -6.41989056e-03f, 3.67395319e-02f, 1.64534286e-01f, 1.35614455e-01f, -6.79906234e-02f,
  1.53502271e-01f, 1.57735661e-01f, 1.42235398e-01f, 1.31471768e-01f, -1.22957289e-01f, -3.71319614e-03f, -3.43448967e-01f, 2.82000333e-01f, 2.38752346e-02f, 8.88455212e-02f,
  -2.08321482e-01f, -1.97710916e-01f, -5.09782098e-02f, 4.26043533e-02f, 6.78681061e-02f, 2.20747113e-01f, 2.93612123e-01f, -1.16109937e-01f, 2.73836672e-01f, 1.79033011e-01f,
  3.73214573e-01f, 7.05721974e-02f, 1.30312264e-01f, 1.96845770e-01f, 9.28993449e-02f, -3.12134400e-02f, 1.49383798e-01f, -6.32808134e-02f, -2.10829489e-02f, 2.43184954e-01f,
  1.83142975e-01f, 2.61800550e-02f, 1.15332171e-01f, 2.07160130e-01f, 6.04230575e-02f, 2.95866787e-01f, 2.63116539e-01f, -1.90897230e-02f, 3.46907182e-03f, 1.24496721e-01f,
  2.36325815e-01f, 1.92947406e-02f, 1.98266938e-01f, -1.48255065e-01f, 1.58360720e-01f, -1.16454333e-03f, 2.13164464e-01f, 7.80341476e-02f, 9.50778946e-02f, 3.19510758e-01f,
  2.55724415e-02f, 4.33130600e-02f, -1.16248243e-03f, -9.57653299e-02f, 3.06453437e-01f, -1.27576292e-01f, -3.38997766e-02f, -1.86038673e-01f, -1.69767335e-01f, 8.39054361e-02f,
  7.59353489e-02f, 5.66147603e-02f, -1.69051990e-01f, -2.51919180e-01f, -2.55369246e-02f, 1.06965467e-01f, 7.16742054e-02f, -5.43070845e-02f, 7.01327696e-02f, 1.68880820e-01f,
  -6.20716028e-02f, 6.97897077e-02f, -1.47675365e-01f, 7.72264749e-02f, 2.06435751e-02f, -1.00814953e-01f, -1.57474950e-01f, -8.02496523e-02f, -1.54922344e-02f, 2.06585839e-01f,
  1.33235902e-01f, 1.85142428e-01f, 7.90691376e-02f, 1.10328145e-01f, 2.39918083e-01f, -5.15855383e-03f, -1.01239106e-03f, 1.00606494e-01f, 4.38533053e-02f, -4.31707874e-02f,
  -3.22518386e-02f, -1.22094221e-01f, 1.51378312e-03f, 2.63448179e-01f, -8.41586441e-02f, -1.98182419e-01f, 8.01502541e-02f, 1.38803527e-01f, -1.56010361e-03f, 1.06977031e-01f,
  7.68914595e-02f, 3.62111852e-02f, 4.77313399e-02f, -2.19621763e-01f, -1.65866554e-01f, -7.15509877e-02f, 9.35012251e-02f, -3.28587800e-01f, -1.49480840e-02f, 1.80779785e-01f,
  -9.33701172e-02f, -1.11084446e-01f, 9.85276327e-02f, 3.68486285e-01f, 1.41650662e-01f, 2.14820489e-01f, -3.19850817e-02f, -2.00036153e-01f, 1.01147182e-01f, 5.56451418e-02f,
  -3.87490802e-02f, -9.08647031e-02f, -2.84499452e-02f, 6.95211887e-02f, -1.11635052e-01f, -1.13999639e-02f, -5.72890155e-02f, -6.64419308e-02f, -1.29289627e-02f, -1.13167591e-01f,
  6.90145344e-02f, -1.20725550e-01f, -1.93894710e-02f, 8.66145045e-02f, 2.33877450e-02f, 7.59107023e-02f, -6.65875822e-02f, 2.97676623e-02f, 4.22487184e-02f, -5.30662499e-02f,
  -1.11153737e-01f, -6.55279681e-02f, 9.97985378e-02f, -3.40699367e-02f, 2.63390522e-02f, -5.89300692e-03f, -1.05554253e-01f, -1.22693613e-01f, -8.97250101e-02f, 1.03490703e-01f,
  2.66109109e-02f, -3.97525653e-02f, 7.12476997e-03f, -1.32524818e-02f, -9.45724994e-02f, 4.98172976e-02f, -1.09200448e-01f, -1.00474089e-01f, 1.53274992e-02f, -1.00283816e-01f,
  -1.12070546e-01f, 3.74638252e-02f, -3.21083106e-02f, -9.18475986e-02f, -7.33968765e-02f, 1.16642237e-01f, -7.65366033e-02f, -3.86065580e-02f, 7.03521147e-02f, 8.89316946e-03f,
  4.93859649e-02f, -2.34080106e-02f, 4.57203500e-02f, 6.58643395e-02f, -1.17890589e-01f, -1.10532425e-01f, 2.91532166e-02f, -1.03955172e-01f, -7.25463778e-02f, -5.59814833e-02f,
  -8.64090398e-02f, -1.13503769e-01f, -4.31067944e-02f, -4.37486023e-02f, 2.66094413e-02f, -3.65580916e-02f, 1.00172814e-02f, -6.35910183e-02f, -3.32526527e-02f, 2.30566025e-01f,
  4.70238961e-02f, 8.50292761e-03f, -2.87443027e-02f, 1.21975765e-01f, -2.18084343e-02f, 1.55780882e-01f, -2.09231734e-01f, 9.90134776e-02f, -3.01331282e-01f, 2.19634190e-01f,
  1.86648771e-01f, 9.79933143e-03f, -7.51231462e-02f, -4.54418957e-02f, -2.79875100e-01f, -1.22368701e-01f, -2.54256636e-01f, 4.30418402e-02f, 1.33663014e-01f, 4.08716090e-02f,
  1.78597197e-01f, 6.03216998e-02f, 2.13125557e-01f, -2.73951087e-02f, 1.12818919e-01f, -2.62749195e-03f, 8.08208063e-03f, -2.09834799e-02f, -1.20273881e-01f, 1.33232161e-01f,
  1.87306195e-01f, 1.35966316e-02f, 1.04721464e-01f, 3.17109436e-01f, 1.30883530e-01f, 5.85736968e-02f, -5.82608692e-02f, -2.15776507e-02f, 6.88185543e-02f, -1.03110231e-01f,
  1.50914118e-01f, 2.96418190e-01f, 9.93667245e-02f, 2.10250989e-01f, -8.89881253e-02f, -1.11649074e-01f, 1.18396595e-01f, 8.78909454e-02f, 7.86615089e-02f, 1.23767167e-01f,
  1.36749089e-01f, -1.25153363e-01f, -4.60624062e-02f, -1.09180570e-01f, 3.29072215e-02f, 9.74176601e-02f, -6.64791390e-02f, -2.38547102e-01f, 1.15814365e-01f, 1.14633068e-02f,
  6.91994801e-02f, -3.22104506e-02f, 8.35906938e-02f, 7.79568478e-02f, 2.55758744e-02f, 8.57004076e-02f, 9.59372073e-02f, 4.77349870e-02f, 2.36237440e-02f, -1.32047031e-02f,
  -1.47385061e-01f, 2.76523530e-01f, -2.59692550e-01f, 3.05411845e-01f, 1.37508750e-01f, 1.35831907e-01f, -4.59674262e-02f, -1.55983523e-01f, -3.23267132e-01f, -1.54728711e-01f,
  -2.72099942e-01f, -2.16599301e-01f, -2.87730824e-02f, 8.20853561e-02f, 2.46441856e-01f, 4.46933508e-02f, 4.42008115e-02f, 3.68127041e-03f, 1.45320132e-01f, 1.50014982e-01f,
  2.45538414e-01f, -8.90399292e-02f, -1.66639775e-01f, -2.27378868e-02f, 1.65199384e-01f, 4.12993878e-02f, -4.87452596e-02f, 7.70362327e-03f, 2.39871755e-01f, 9.19646695e-02f,
  3.01934257e-02f, 1.18589267e-01f, -3.24578322e-02f, -1.22174688e-01f, 1.75222591e-01f, 1.87342465e-01f, 1.51834160e-01f, 1.87945105e-02f, 1.10740727e-02f, -1.72455773e-01f,
  2.59749293e-01f, -9.14267451e-02f, 8.50084890e-03f, 1.37103096e-01f, 1.16615862e-01f, -6.26622513e-02f, -1.09949410e-01f, 1.16537139e-02f, 2.04933345e-01f, -7.51563981e-02f,
  1.56415150e-01f, -7.41474032e-02f, 1.67856365e-01f, 9.87488329e-02f, 2.27459967e-01f, 2.70302314e-03f, -2.60019507e-02f, 1.63549319e-01f, -7.86591694e-02f, 1.27796918e-01f,
  1.57348186e-01f, 1.46930769e-01f, 1.31914228e-01f, 2.45673768e-02f, -3.48035514e-01f, -5.08441366e-02f, 1.47841461e-02f, 2.03809842e-01f, 6.77194968e-02f, -1.16708785e-01f,
  -2.53458440e-01f, -1.26793459e-01f, 1.64787266e-02f, 1.53654456e-01f, 1.53765336e-01f, 1.76848292e-01f, -9.09605902e-03f, 2.91561894e-02f, -2.95087874e-01f, -4.13459875e-02f,
  -2.00657733e-02f, -1.07964270e-01f, -1.49447307e-01f, -4.20382693e-02f, 5.53060919e-02f, -1.22137688e-01f, 1.29439458e-01f, -1.19415179e-01f, 1.99145563e-02f, 8.52137357e-02f,
  2.75965035e-01f, 3.49545300e-01f, 2.25269347e-01f, -2.03334913e-01f, 1.27269626e-01f, -7.51581639e-02f, 2.01084808e-01f, 2.12473914e-01f, 1.53941572e-01f, 2.09526736e-02f,
  1.86836824e-01f, 2.21590817e-01f, -7.52613470e-02f, 9.14962664e-02f, 2.10332111e-01f, 1.47295430e-01f, 2.44329959e-01f, -4.79152463e-02f, -1.10089872e-02f, 9.35747772e-02f,
  -1.67753939e-02f, -7.78310746e-03f, 1.67178959e-02f, -1.72552332e-01f, 1.57871887e-01f, 4.65236716e-02f, 1.82867840e-01f, 1.71357691e-01f, 3.93276513e-02f, -3.30248810e-02f,
  1.72240660e-01f, -4.26215231e-02f, -4.00444143e-04f, 9.82658342e-02f, -2.15192847e-02f, -6.53409287e-02f, -6.60542119e-03f, 1.05461717e-01f, -2.72507817e-01f, -8.03616345e-02f,
  -1.02488309e-01f, 3.49587463e-02f, 1.08482979e-01f, 1.04158418e-02f, -1.27390012e-01f, -6.45517781e-02f, 2.59773344e-01f, 4.00087178e-01f, 2.34671012e-01f, 3.00667137e-01f,
  2.74828821e-01f, -3.47729167e-03f, -1.71445519e-01f, -6.04011342e-02f, 1.80910423e-01f, -2.04103470e-01f, -9.15504023e-02f, -1.22892238e-01f, 1.65186569e-01f, 1.58928111e-02f,
  2.06478506e-01f, 1.11506224e-01f, 5.37015796e-02f, 1.47626922e-01f, 1.33942440e-01f, 1.09542785e-02f, 6.44336268e-02f, -2.22924992e-01f, 2.46544406e-01f, 4.59133200e-02f,
  2.24758908e-01f, 6.97778463e-02f, 8.36359784e-02f, -4.57778648e-02f, 8.12018439e-02f, 1.75812900e-01f, -8.37982595e-02f, -2.59662047e-02f, 1.14844859e-01f, 1.22739710e-01f,
  2.07404137e-01f, 8.41886252e-02f, -1.37757108e-01f, 2.62283891e-01f, -1.66789964e-01f, -1.78930704e-02f, -1.32113630e-02f, -9.92995277e-02f, 1.97163910e-01f, 9.30783451e-02f,
  -1.37380168e-01f, 8.30825139e-03f, 1.83408894e-03f, -1.10339843e-01f, -1.39589682e-01f, -7.86150247e-02f, -1.06060682e-02f, -1.09490842e-01f, 3.09570674e-02f, -8.17945823e-02f,
  -6.31649643e-02f, 6.36756644e-02f, -5.11862859e-02f, -8.83198604e-02f, -6.13535978e-02f, -2.31502559e-02f, 1.02457166e-01f, -1.90458503e-02f, -2.97307149e-02f, -2.22774129e-02f,
  -6.84084892e-02f, -6.78653419e-02f, 9.68422219e-02f, -1.14483479e-02f, 9.38845351e-02f, 6.32700324e-03f, -1.03241637e-01f, 2.59253895e-03f, 3.32260840e-02f, -4.27352190e-02f,
  3.34024839e-02f, -1.09368466e-01f, 9.46979597e-03f, -1.05950058e-01f, -6.29502013e-02f, -1.09789349e-01f, -6.72662929e-02f, -7.10850507e-02f, -1.44380897e-01f, -3.51249874e-02f,
  -1.55193182e-02f, 1.71807148e-02f, 5.45997284e-02f, -7.11297691e-02f, 7.03764036e-02f, -7.28821009e-02f, -2.79706642e-02f, 1.03497036e-01f, -3.10226120e-02f, -8.62551108e-02f,
  4.32889350e-02f, -1.44067721e-03f, -7.22566396e-02f, -5.41525800e-03f, 6.86834827e-02f, -9.00074989e-02f, 2.53367424e-02f, -9.66099277e-02f, -3.72704230e-02f, -1.36545077e-01f,
  -3.16454880e-02f, 2.02361029e-02f, -1.14976779e-01f, -1.03263214e-01f, -6.26966432e-02f, -1.07975625e-01f, 1.66431256e-02f, 3.68428640e-02f, 7.53139239e-03f, -4.78451066e-02f,
  3.99053246e-02f, -2.23147534e-02f, 5.00843525e-02f, -8.73545408e-02f, 1.32418107e-02f, -6.51666746e-02f, -8.05685520e-02f, -5.36195673e-02f, -5.92049882e-02f, 2.09457558e-02f,
  -9.22806635e-02f, 8.19948539e-02f, 1.29752606e-01f, -1.00061476e-01f, 3.37674841e-02f, 3.79124843e-02f, -5.35829067e-02f, -1.12924151e-01f, -5.75293377e-02f, 9.85918045e-02f,
  3.94935608e-02f, 5.09736240e-02f, 7.07688108e-02f, -7.05070645e-02f, -2.87354048e-02f, -2.60982253e-02f, -7.12699145e-02f, 6.99299872e-02f, 3.13614905e-02f, -1.28956079e-01f,
  -1.15086958e-01f, 6.56300550e-03f, 1.11346588e-01f, 1.17656559e-01f, 3.38688791e-02f, -7.39536211e-02f, -1.25228256e-01f, -3.99966277e-02f, -9.00727659e-02f, -1.23006068e-01f,
  -1.19972853e-02f, -5.90922348e-02f, -6.17724322e-02f, 8.18477422e-02f, 1.23692965e-02f, 9.22570601e-02f, 5.75864129e-02f, -9.03872624e-02f, -9.44538265e-02f, -1.24734059e-01f,
  -1.20565429e-01f, 7.07797781e-02f, -3.32006924e-02f, 4.98488769e-02f, -5.02345264e-02f, -1.59339160e-02f, -9.24444497e-02f, 1.57129765e-03f, -4.15996574e-02f, -1.44308746e-01f,
  9.33917426e-03f, 7.58836605e-03f, -5.61413281e-02f, -1.44043654e-01f, -1.47282258e-02f, -8.97188112e-02f, 3.77516970e-02f, -3.26069468e-03f, 3.90197709e-02f, -1.78014219e-01f,
  3.00308377e-01f, 7.66458511e-02f, 4.82506528e-02f, -2.67770946e-01f, 2.68699024e-02f, -1.87083073e-02f, 2.98077375e-01f, -1.46820337e-01f, 1.95822746e-01f, 2.70057321e-01f,
  3.06901217e-01f, -1.30219283e-02f, 2.01968566e-01f, 5.69871776e-02f, 1.68102801e-01f, 2.21166030e-01f, 2.11437896e-01f, 3.03882718e-01f, 1.26528665e-02f, 1.61637902e-01f,
  8.75675455e-02f, 2.04154775e-02f, 6.17957255e-03f, 5.98248057e-02f, 1.41645139e-02f, 1.57268327e-02f, -9.35750827e-03f, -4.04307395e-01f, 5.17222844e-02f, 1.78138375e-01f,
  2.05014661e-01f, 1.67870343e-01f, 7.29732886e-02f, 1.57620311e-01f, -1.38648152e-01f, -1.31516363e-02f, -9.54228491e-02f, -1.15550593e-01f, 1.74129486e-01f, -2.37864554e-01f,
  -4.53650951e-03f, 1.53157443e-01f, 6.95476830e-02f, 1.69197828e-01f, -1.03359021e-01f, -2.86143273e-02f, 1.53660402e-01f, 2.01924562e-01f, 1.19829088e-01f, -1.03364237e-01f,
  1.06678694e-01f, 2.10844859e-01f, -4.70307805e-02f, -3.30287665e-02f, 1.04176469e-01f, 7.03359768e-02f, -2.23978632e-03f, -1.32031366e-01f, -2.49903332e-02f, -1.16060272e-01f,
  -1.02519058e-01f, 4.39677313e-02f, 2.25119125e-02f, -4.21666317e-02f, 8.24191198e-02f, 3.80885154e-02f, 4.91745956e-02f, -9.31281373e-02f, -3.43322270e-02f, -2.38483455e-02f,
  1.31364584e-01f, 3.26448493e-02f, 5.75187206e-02f, -2.04720963e-02f, 1.21761188e-02f, -9.76294726e-02f, -7.46504366e-02f, -8.06850195e-02f, -9.58931595e-02f, 6.95453510e-02f,
  9.30824056e-02f, -5.54933324e-02f, -2.24361774e-02f, -9.66662019e-02f, -9.10501033e-02f, -7.58418217e-02f, 1.38857486e-02f, 1.84667781e-02f, -1.02179371e-01f, -4.79135551e-02f,
  1.19517021e-01f, 1.13314956e-01f, 4.68640849e-02f, 3.06456238e-02f, 1.07161574e-01f, 4.06780094e-02f, -6.76844567e-02f, -1.11232631e-01f, 2.67448695e-03f, 6.34847656e-02f,
  1.09177724e-01f, -8.88163596e-02f, -5.39566576e-02f, -4.91806120e-02f, 1.05030231e-01f, -4.42794040e-02f, -2.77290028e-02f, -6.05848171e-02f, -5.34258969e-02f, -1.01148784e-02f,
  -7.10393265e-02f, 1.09073922e-01f, -2.26507206e-02f, -4.29790430e-02f, -1.07804686e-01f, 8.18168595e-02f, 4.52619605e-02f, 1.55367658e-01f, 5.05300425e-02f, 1.29672587e-01f,
  1.92229286e-01f, 1.38885185e-01f, -4.28043120e-02f, 2.09134638e-01f, 7.46435896e-02f, 2.06370458e-01f, -9.07261483e-03f, 1.47582069e-01f, -1.45275623e-01f, -2.91140497e-01f,
  -5.35918912e-03f, 2.07742210e-02f, 4.99232896e-02f, -2.13992283e-01f, 4.21427051e-03f, -1.36325240e-01f, 3.40451419e-01f, 5.13387434e-02f, 1.08544335e-01f, 6.50069639e-02f,
  2.57646888e-01f, -6.67869821e-02f, 1.24772005e-02f, -1.23027600e-01f, 2.66066026e-02f, 1.77130342e-01f, 2.43100300e-02f, -9.08146277e-02f, 5.10114916e-02f, 2.10297391e-01f,
  1.09381542e-01f, 2.80339837e-01f, -1.82963654e-01f, 6.05072975e-02f, 2.33280659e-01f, 2.50015706e-01f, -2.10043937e-01f, 1.60330445e-01f, 6.26997352e-02f, 2.09090099e-01f,
  1.47240192e-01f, -1.19492605e-01f, 1.62283584e-01f, -1.25474930e-01f, 5.72413765e-02f, -1.23428022e-02f, -9.85613540e-02f, 2.72403508e-01f, 2.24292092e-02f, 3.57216820e-02f,
  1.55972213e-01f, 2.04172820e-01f, -3.26801725e-02f, 3.92146260e-02f, 1.37404069e-01f, -8.97360593e-02f, -8.77519771e-02f, 2.64179409e-01f, 9.48155448e-02f, 1.92521885e-01f,
  -2.06609368e-02f, -9.07440707e-02f, 1.54718722e-03f, -1.32442415e-02f, -6.69479892e-02f, 1.49598598e-01f, -4.16814424e-02f, 7.71672949e-02f, 4.44675349e-02f, 5.41461296e-02f,
  5.36381528e-02f, 3.07091270e-02f, 9.85359699e-02f, 2.09773839e-01f, -1.81727484e-01f, -9.07512568e-03f, -5.77476136e-02f, -8.96509886e-02f, 6.77292570e-02f, -1.43395022e-01f,
  -1.01914190e-01f, -1.09034246e-02f, 2.69895215e-02f, -1.05960011e-01f, -2.00520113e-01f, 2.85531104e-01f, -1.56901002e-01f, 3.15798700e-01f, 6.14424646e-02f, -1.78250134e-01f,
  -5.23421131e-02f, 2.56810606e-01f, 1.86603311e-02f, -1.90844256e-02f, 6.19556606e-02f, -1.35288581e-01f, 3.11221898e-01f, 2.20508575e-01f, -1.90459311e-01f, 2.68191665e-01f,
  3.32957029e-01f, -8.73068795e-02f, 8.02337974e-02f, -2.36229915e-02f, 2.77972911e-02f, 2.78223008e-01f, 5.91671392e-02f, 5.58217755e-03f, 3.74058671e-02f, 8.22238922e-02f,
  -5.12333633e-03f, -7.33372197e-02f, 1.33689567e-01f, 2.38478824e-01f, 5.09119369e-02f, 1.14212021e-01f, 1.46601314e-03f, 9.59354416e-02f, 1.70245245e-01f, -1.62091345e-01f,
  5.58319427e-02f, -1.37317419e-01f, -1.66043714e-02f, 7.18764365e-02f, -5.98268397e-02f, -7.01454654e-02f, -9.97575223e-02f, 1.73583508e-01f, 9.43008885e-02f, 1.87409297e-01f,
  -1.60411391e-02f, -1.24203868e-01f, -1.07483372e-01f, -1.91265456e-02f, 6.24338537e-02f, 2.23135665e-01f, 1.24802902e-01f, 1.98232383e-01f, -1.32926807e-01f, -4.41508740e-02f,
  -2.29078189e-01f, 4.85913455e-02f, -7.24727958e-02f, -9.48620141e-02f, -1.37594432e-01f, -1.42048553e-01f, -1.72845155e-01f, 8.32356885e-02f, 1.17078006e-01f, 4.26124372e-02f,
  1.43043548e-01f, 4.47259657e-02f, -1.24494592e-02f, -2.98878048e-02f, -3.11105419e-02f, 7.86887184e-02f, 1.52951539e-01f, 7.04738200e-02f, -1.35803416e-01f, 7.37786815e-02f,
  -6.61797971e-02f, 1.93760127e-01f, 1.59366261e-02f, -1.10983945e-01f, 5.31258658e-02f, 1.50592282e-01f, -7.91589990e-02f, -6.53508911e-03f, 3.05470265e-02f, 3.15206721e-02f,
  1.31766096e-01f, -6.83265403e-02f, 1.26389153e-02f, -4.53588441e-02f, 1.21411346e-01f, 2.37485971e-02f, -1.55798793e-02f, -1.17025547e-01f, -6.81940932e-03f, -1.31263748e-01f,
  -6.83769360e-02f, 2.40166798e-01f, 1.14144012e-01f, 1.24184810e-01f, -2.08877958e-02f, 4.26017009e-02f, 8.22087601e-02f, -1.42289028e-01f, 6.56217262e-02f, -6.80436045e-02f,
  1.54601872e-01f, 1.64402515e-01f, 1.61335785e-02f, 4.23797518e-02f, -4.22622971e-02f, 1.03166886e-01f, 1.06213376e-01f, 9.29064974e-02f, 1.18951999e-01f, 5.72074167e-02f,
  8.78942832e-02f, 4.18180041e-02f, 1.88495055e-01f, -3.09799556e-02f, -4.89072800e-02f, 1.87521186e-02f, -2.53813684e-01f, -9.41257551e-02f, 1.01882428e-01f, -2.55638629e-01f,
  -3.56415391e-01f, -5.09148538e-02f, -1.75458893e-01f, 1.81531683e-01f, -3.49497539e-03f, 7.15763941e-02f, -5.65712489e-02f, -3.81946489e-02f, 8.94055702e-03f, 6.06941134e-02f,
  5.24903182e-04f, 1.48311064e-01f, 1.25748754e-01f, 6.19802997e-02f, 2.20225900e-01f, 1.92424074e-01f, -7.05566704e-02f, 4.14028108e-01f, 3.92246060e-02f, 2.07521599e-02f,
  -1.20513774e-01f, 3.77708636e-02f, -9.39293951e-02f, 7.79820606e-02f, 2.01580197e-01f, -1.16561785e-01f, -1.27471849e-01f, 1.25062615e-01f, -1.74898226e-02f, 2.48726711e-01f,
  -1.93212584e-01f, 1.71713993e-01f, 1.07702509e-01f, 3.35861780e-02f, 3.39875430e-01f, 8.79542530e-02f, 2.86785305e-01f, 1.64929777e-01f, 2.63178557e-01f, 3.23409617e-01f,
  -1.58292815e-01f, 1.14238240e-01f, 1.81992158e-01f, 1.25484273e-01f, 6.46333396e-02f, -1.01319775e-01f, -1.79897889e-01f, -6.85750321e-02f, 1.64017722e-01f, 1.96395233e-01f,
  5.02054617e-02f, 3.37103307e-02f, 9.77762714e-02f, -7.15566501e-02f, -3.64079028e-02f, 1.02776632e-01f, 2.80019522e-01f, -8.30634683e-02f, 2.35629946e-01f, -6.13255389e-02f,
  7.33368332e-03f, 8.12013894e-02f, -5.30223213e-02f, 1.93234429e-01f, 7.39033297e-02f, -1.94386944e-01f, 1.32024754e-02f, 2.74370253e-01f, -1.00555293e-01f, 1.10676870e-01f,
  -2.45763466e-01f, 1.37536060e-02f, -6.47087693e-02f, 8.77990425e-02f, -1.10465810e-01f, 1.14914432e-01f, 2.74165511e-01f, 5.98626733e-02f, 1.52394131e-01f, 8.26838091e-02f,
  3.03081684e-02f, 3.78924280e-01f, 3.21252346e-02f, -1.41336247e-02f, 1.78319022e-01f, -2.62659229e-02f, -7.87066817e-02f, 2.03249931e-01f, 1.87022723e-02f, 2.36519158e-01f,
  -1.14080980e-02f, 2.53120214e-01f, -1.10578649e-01f, 2.45983213e-01f, 1.52751252e-01f, 1.58043563e-01f, 2.09806830e-01f, 1.97366431e-01f, 4.35281917e-02f, -2.61833787e-01f,
  4.14885953e-02f, -1.48309708e-01f, 1.03498995e-01f, 5.03825955e-02f, -1.85460914e-02f, 2.38020256e-01f, 1.24042802e-01f, 1.80749536e-01f, 1.78485721e-01f, 1.09265648e-01f,
  -2.28380971e-02f, -3.11529785e-02f, 2.12986454e-01f, -3.93899046e-02f, 8.05479512e-02f, 1.29629299e-01f, -6.71870261e-02f, 1.63688555e-01f, 2.21132413e-01f, -4.68907245e-02f,
  2.53021270e-01f, -1.47805691e-01f, 1.15059920e-01f, -3.99589986e-02f, 2.00629365e-02f, -1.18585691e-01f, 1.52946070e-01f, -2.85402954e-01f, -4.10958566e-02f, -1.50530919e-01f,
  -3.49333435e-02f, -7.53506497e-02f, 2.71795988e-01f, 1.18301846e-01f, 1.65413488e-02f, 3.07986677e-01f, 2.53557324e-01f, 3.10784802e-02f, -7.24995881e-02f, 2.18736038e-01f,
  3.96517068e-02f, 3.16806465e-01f, -2.50408612e-03f, 5.09237591e-03f, -5.37305549e-02f, 9.77650657e-02f, -1.28865406e-01f, 2.39049256e-01f, -6.25403747e-02f, 7.90176690e-02f,
  3.89345102e-02f, -4.23652073e-03f, 1.68095395e-01f, -5.59602864e-02f, -1.06676869e-01f, -6.48797527e-02f, 1.54304415e-01f, 3.47357869e-01f, -1.16140909e-01f, -5.64656481e-02f,
  -4.25788760e-02f, 1.54528216e-01f, 1.10154971e-01f, 1.06963597e-01f, 1.48051977e-01f, 9.18577909e-02f, 1.57109603e-01f, 3.56006175e-01f, -1.18486136e-01f, 2.85529166e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -1.13258325e-01f, -4.24626134e-02f, -2.96983737e-02f, 1.45029724e-01f, 4.46737632e-02f, -2.46417690e-02f, 1.68364868e-01f, -2.71551795e-02f, 8.88764486e-03f, 1.11900687e-01f,
  2.05270126e-01f, 1.15307435e-01f, 1.18858740e-01f, -2.25892607e-02f, 3.38749699e-02f, 3.86063233e-02f, 1.27585575e-01f, 4.72715273e-02f, 1.47810012e-01f, 1.71795592e-01f,
  -1.26319211e-02f, -1.97495800e-02f, 2.21076123e-02f, 1.95309952e-01f, 6.55790865e-02f, 9.10115317e-02f, 1.51881352e-01f, 1.84474811e-01f, 8.60780701e-02f, 8.14216211e-02f,
  6.39140755e-02f, 9.52834357e-03f, -1.32533023e-02f, -1.41481971e-02f, 8.63180980e-02f, 1.00877881e-01f, 1.09707363e-01f, 6.12267032e-02f, 1.73719689e-01f, -7.97965750e-03f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -2.67865378e-02f, 1.10595874e-01f, -6.61174208e-02f, -1.18453085e-01f, -5.49859144e-02f, -6.38362318e-02f, 1.23537006e-02f, -6.72554374e-02f, -8.93195868e-02f, -4.28978540e-02f,
  -4.77904119e-02f, 1.46877542e-01f, -1.32122472e-01f, 1.51214302e-01f, 1.00167289e-01f, -1.56843692e-01f, -7.23124295e-02f, -8.01005214e-03f, 6.28231689e-02f, 8.22324399e-03f,
  9.39205289e-02f, 1.18131451e-01f, 6.98076785e-02f, -1.89131156e-01f, -9.08242241e-02f, 2.24384330e-02f, -1.34264901e-01f, 5.63277397e-04f, -5.35426997e-02f, 3.00296340e-02f,
  1.97026338e-02f, 5.58741614e-02f, -1.50284499e-01f, 1.08950838e-01f, 4.68564034e-02f, 1.90880969e-01f, 8.36112499e-02f, -6.22969680e-02f, 5.35219349e-02f, -8.19822624e-02f,
  -1.03174388e-01f, -1.20978996e-01f, 7.51722828e-02f, -7.52708241e-02f, -7.74523523e-03f, 1.13320546e-02f, 1.31637529e-01f, -9.65509713e-02f, 9.09878984e-02f, -1.16537660e-01f,
  3.31209488e-02f, -1.86004922e-01f, -5.01383096e-02f, 1.95317939e-02f, -1.10262774e-01f, 4.56461171e-03f, -2.38112407e-03f, 1.17993234e-02f, 1.99297115e-01f, -1.04088731e-01f,
  2.01284029e-02f, 1.14444174e-01f, -4.74383496e-02f, -1.18297353e-01f, -1.13333970e-01f, 3.37447808e-03f, -7.98759684e-02f, 5.33928275e-02f, 1.53979510e-02f, 1.28568904e-02f,
  8.63156840e-02f, 1.00798815e-01f, 1.21992074e-01f, 1.35511998e-03f, 6.91891834e-02f, -1.49885844e-02f, -1.56872871e-03f, -9.84084755e-02f, -1.98492020e-01f, -6.95077181e-02f,
  6.78110346e-02f, 1.56115726e-01f, 8.10119137e-02f, 1.51225716e-01f, 8.19810331e-02f, 1.05305970e-01f, -1.34130716e-01f, -5.61063690e-03f, 8.89373273e-02f, -1.26496091e-01f,
  3.99644263e-02f, -2.32709385e-02f, 7.31019899e-02f, 1.93536237e-01f, 1.58123329e-01f, 1.48011222e-02f, -1.12348497e-01f, 2.60695275e-02f, 5.08195385e-02f, 1.04433693e-01f,
  8.47951416e-03f, -8.17119703e-02f, -5.62614277e-02f, 1.10681735e-01f, -7.12006295e-04f, -1.80007108e-02f, -8.01018253e-02f, -1.07509129e-01f, -1.63472332e-02f, -8.90362859e-02f,
  1.00933522e-01f, 9.93106961e-02f, -1.41454311e-02f, -2.39756089e-02f, -3.33547476e-03f, -3.55500579e-02f, -1.33066457e-02f, -8.64795074e-02f, 1.26463011e-01f, 1.21398561e-01f,
  8.93303007e-02f, -5.69837615e-02f, 1.09413922e-01f, -4.87137064e-02f, 1.40600264e-01f, -1.06001765e-01f, -1.93670809e-01f, 9.19991583e-02f, 1.61799081e-02f, 1.75869539e-01f,
  4.15404588e-02f, 1.37582421e-01f, -1.33388549e-01f, -8.60920995e-02f, 7.60953873e-02f, 5.41119650e-03f, -1.07395435e-02f, -7.43561462e-02f, 1.96646396e-02f, 1.53890729e-01f,
  -1.98046342e-01f, 9.82179716e-02f, -3.99283729e-02f, 7.23735057e-03f, -1.54026225e-02f, -1.08168669e-01f, 8.74540582e-02f, 2.54311413e-02f, 1.33404478e-01f, 1.89974621e-01f,
  -4.93460186e-02f, -1.58566847e-01f, -5.33263981e-02f, -9.52699706e-02f, -1.40689686e-01f, -6.51863068e-02f, -1.50901377e-01f, -7.98083842e-02f, -1.08851537e-01f, 7.89994374e-02f,
  1.94377042e-02f, -1.13464594e-01f, 1.11726202e-01f, 1.00048788e-01f, -5.76220229e-02f, 4.61892516e-04f, 1.84460059e-02f, 7.36505464e-02f, -1.15053259e-01f, 1.82761639e-01f,
  -8.23201314e-02f, 6.11841716e-02f, 4.13615443e-02f, 1.00240439e-01f, -2.47195140e-02f, 1.39057115e-01f, -1.72403529e-01f, 7.01330900e-02f, -1.20414101e-01f, -4.01574187e-02f,
  1.28742337e-01f, 4.68401946e-02f, 5.72378598e-02f, -1.12068772e-01f, -4.19946499e-02f, 3.48416194e-02f, 8.78666714e-02f, 1.03349254e-01f, -6.10838570e-02f, 5.23900911e-02f,
  8.69649872e-02f, -9.37079042e-02f, 7.33234063e-02f, 6.63748942e-04f, -4.73706052e-02f, 1.28384501e-01f, -9.82349440e-02f, 3.91997844e-02f, 3.97793427e-02f, 6.73969612e-02f,
  -1.84805337e-02f, 8.92511830e-02f, 1.52889565e-01f, -3.79038602e-02f, 1.00079224e-01f, 1.47989020e-01f, 9.70557556e-02f, -6.45358041e-02f, 1.59381121e-01f, -9.75167602e-02f,
  -8.84016231e-02f, -1.46550104e-01f, -1.69044152e-01f, -9.11904573e-02f, 9.14620459e-02f, -9.96066816e-03f, -7.19813183e-02f, 5.10315858e-02f, -3.32999229e-02f, 1.20010018e-01f,
  -8.61937255e-02f, -2.62424387e-02f, -1.34370506e-01f, -5.15902825e-02f, -1.08472675e-01f, 1.05217136e-01f, 9.64817926e-02f, -1.06233312e-02f, -1.38632253e-01f, -8.99798423e-02f,
  2.27865092e-02f, -1.10665821e-01f, 2.42125615e-02f, -6.74124584e-02f, 1.48074090e-01f, -3.81958224e-02f, -6.66160658e-02f, 9.16959494e-02f, 4.74611707e-02f, -4.91562337e-02f,
  -1.08458951e-01f, -7.42230117e-02f, -2.07998026e-02f, 1.23985335e-01f, 1.87713161e-01f, 3.07537988e-02f, -4.37375344e-02f, -8.04808065e-02f, 5.26592843e-02f, 5.36129288e-02f,
  1.62928015e-01f, -1.19666964e-01f, -4.58384193e-02f, -2.46566981e-02f, -8.06771591e-02f, 3.51496525e-02f, 2.07833853e-02f, -8.86894464e-02f, -7.40259364e-02f, 1.84965506e-03f,
  8.35240935e-04f, -5.82654960e-02f, 8.50967765e-02f, -1.20222226e-01f, -5.48407026e-02f, 6.21903762e-02f, 1.03848964e-01f, -7.59858266e-02f, 2.80613117e-02f, 7.00558573e-02f,
  1.31563723e-01f, -1.11933835e-02f, -3.04133855e-02f, -3.13976184e-02f, -6.67285472e-02f, -1.49183542e-01f, -1.09395258e-01f, 1.49685308e-01f, 1.89125583e-01f, -8.77075177e-03f,
  -7.76394606e-02f, 5.50568104e-02f, -8.24240446e-02f, 1.51092503e-02f, -4.22484241e-02f, -5.61299883e-02f, -1.20892599e-01f, -1.16119847e-01f, -1.35640457e-01f, -1.24450676e-01f,
  6.55824617e-02f, 1.22191831e-01f, 1.12412848e-01f, -6.15449771e-02f, -7.93038215e-03f, 4.79823053e-02f, -2.66197920e-02f, -7.91026205e-02f, 9.50867757e-02f, -5.44201173e-02f,
  1.12166651e-01f, -3.44204120e-02f, 4.82525267e-02f, 1.06808163e-01f, -3.00104767e-02f, -2.65131462e-02f, 1.11306012e-01f, 1.71351910e-01f, -3.29185612e-02f, 1.46083347e-02f,
  4.30193841e-02f, -5.49250394e-02f, -3.36679965e-02f, 9.35744941e-02f, 1.89712904e-02f, 1.13047972e-01f, -1.80926412e-01f, -9.00277868e-02f, 1.85374632e-01f, -1.10206731e-01f,
  -5.10618847e-04f, -1.01445384e-01f, -4.03191596e-02f, -2.49434486e-02f, -6.87000006e-02f, -7.04708025e-02f, -4.86365706e-02f, 1.27939314e-01f, -3.46672013e-02f, 7.24521875e-02f,
  7.93099552e-02f, 1.62008703e-02f, 4.03484739e-02f, -6.33578561e-03f, 1.76702797e-01f, -4.20303121e-02f, 7.12085739e-02f, -6.56255186e-02f, -3.69141512e-02f, -6.51667244e-04f,
  1.28286770e-02f, 1.06596388e-01f, 1.03508122e-01f, -2.29516134e-01f, 3.71517576e-02f, 9.21535399e-03f, 7.54692480e-02f, -7.12413564e-02f, 1.01151206e-01f, -1.88244715e-01f,
  9.27773863e-02f, -2.08702087e-02f, -8.71373620e-03f, 1.09485760e-01f, 7.13450238e-02f, 1.96491435e-01f, 6.07284717e-02f, -1.37593910e-01f, -6.92048967e-02f, -3.05897091e-02f,
  -5.22289686e-02f, -6.97334483e-02f, -1.12440377e-01f, -1.14902444e-02f, 6.44739866e-02f, 7.02181309e-02f, -1.21394739e-01f, -1.39501290e-02f, 3.47095132e-02f, -1.81665402e-02f,
  -1.87112931e-02f, -1.90459415e-01f, -1.24789290e-01f, 4.93537001e-02f, -4.00112756e-02f, -4.91571985e-02f, -7.46592060e-02f, 2.93364637e-02f, 9.03911963e-02f, -1.42366648e-01f,
  -1.94936097e-02f, 5.06290495e-02f, 1.10087477e-01f, 9.98217687e-02f, -1.02289483e-01f, 8.13323259e-02f, 2.26509459e-02f, -1.98869258e-02f, 1.10745952e-01f, 7.45306024e-03f,
  -7.08417371e-02f, 1.13685876e-02f, 1.03995964e-01f, -5.78462891e-02f, 1.59883406e-02f, 5.33786006e-02f, -1.25771210e-01f, 1.56529825e-02f, -1.66006744e-01f, 3.85969020e-02f,
  -4.75376137e-02f, 1.52502403e-01f, 1.63793787e-02f, 1.77528784e-01f, 1.36930138e-01f, -2.81546414e-02f, -2.45241281e-02f, -4.59045880e-02f, -1.05431907e-01f, -1.55352503e-02f,
  7.57555291e-02f, -1.43880159e-01f, 9.28339660e-02f, 3.83498170e-03f, 1.10338323e-01f, 1.78657234e-01f, 1.66802444e-02f, 1.33217555e-02f, 6.09970614e-02f, 3.41302231e-02f,
  -4.75213155e-02f, -9.11548138e-02f, -4.72445413e-02f, 8.89546573e-02f, 2.06332449e-02f, -8.66341032e-03f, 5.47561236e-02f, -1.17583551e-01f, -2.66313236e-02f, 2.12195665e-02f,
  9.58302151e-03f, -4.82146144e-02f, 3.08798160e-02f, 1.01789370e-01f, -1.89729899e-01f, -1.26995444e-01f, 2.28754096e-02f, 5.95986843e-02f, -1.41515331e-02f, 1.27116963e-01f,
  1.05978340e-01f, 7.66762942e-02f, 1.60114706e-01f, -1.39483690e-01f, 1.19096920e-01f, 3.85950916e-02f, -7.89556280e-02f, 1.29144013e-01f, -1.40401527e-01f, 3.66539210e-02f,
  -1.46698281e-01f, -5.02329245e-02f, 7.09952274e-03f, -1.30367920e-01f, -2.86831241e-02f, -5.27659804e-02f, 1.78292599e-02f, -1.21837497e-01f, 8.39453414e-02f, 4.62382175e-02f,
  -2.07115248e-01f, 5.36299534e-02f, -1.55322969e-01f, -1.86978862e-01f, -1.13042079e-01f, 1.15093902e-01f, 6.01206273e-02f, 3.18000466e-02f, 8.20201859e-02f, 1.20118417e-01f,
  2.50763688e-02f, 5.46948388e-02f, -7.69410608e-03f, 7.52780959e-02f, -4.01755720e-02f, -1.23957597e-01f, 1.17116712e-01f, 1.04281187e-01f, 1.22406252e-01f, 2.05374919e-02f,
  -1.53942987e-01f, 5.51005006e-02f, 1.01616360e-01f, 1.04641356e-01f, 1.30343828e-02f, -6.94164168e-03f, 1.11788496e-01f, 1.00271381e-01f, -1.35768697e-01f, -4.35764045e-02f,
  -5.49957156e-02f, 2.35161104e-04f, 1.31021664e-01f, 5.23943864e-02f, 3.06471027e-02f, 8.51396024e-02f, -6.32219911e-02f, 6.08349293e-02f, -1.07633904e-01f, -6.58514798e-02f,
  -1.68840751e-01f, -1.46729723e-01f, -5.67467920e-02f, 8.87882113e-02f, 1.06561206e-01f, -6.21089861e-02f, 7.65601322e-02f, 4.55910526e-02f, -1.53433651e-01f, -9.10639688e-02f,
  -9.73371491e-02f, -1.72792617e-02f, -1.12973101e-01f, -1.28930941e-01f, -1.21586189e-01f, 8.86953399e-02f, 5.59849851e-02f, 4.97828908e-02f, 2.46750806e-02f, 8.43383819e-02f,
  3.36355790e-02f, -1.19201183e-01f, -1.29796699e-01f, -1.00738630e-01f, -1.39033690e-01f, 1.71991572e-01f, -6.29037097e-02f, -1.96702957e-01f, -7.21020475e-02f, 1.43257782e-01f,
  -5.51895797e-02f, -7.17774630e-02f, 1.88809231e-01f, 1.85666144e-01f, 7.91209936e-02f, -1.91404000e-01f, 6.34085909e-02f, -6.67608604e-02f, 9.37607214e-02f, -9.99477925e-04f,
  -2.53875591e-02f, -1.52958864e-02f, -1.09433874e-01f, 9.40189213e-02f, -6.89316466e-02f, -1.29672647e-01f, 1.57190084e-01f, -1.95649471e-02f, -5.00538945e-02f, 1.44928664e-01f,
  5.96424937e-02f, -7.36607164e-02f, -7.21093938e-02f, 3.95548642e-02f, -1.27397656e-01f, 3.45496684e-02f, 4.33481224e-02f, -5.13400398e-02f, 3.54618803e-02f, -4.89240773e-02f,
  1.96610272e-01f, -2.41098609e-02f, -9.52397808e-02f, -1.16494317e-02f, -5.98430587e-03f, -3.66564281e-02f, 9.68821943e-02f, 5.29105105e-02f, 9.07386541e-02f, -3.28196473e-02f,
  1.39081061e-01f, 1.52032282e-02f, -7.04320520e-02f, 2.09712964e-02f, 3.05826142e-02f, 1.32336533e-02f, 3.87966372e-02f, -1.11936726e-01f, 1.03066973e-01f, 1.55496597e-02f,
  6.89643472e-02f, -2.01629028e-02f, 1.66721463e-01f, 4.70449813e-02f, 2.30558543e-03f, -2.04421412e-02f, 1.10692978e-01f, 2.76672877e-02f, 1.04737297e-01f, -1.65859923e-01f,
  -7.45654255e-02f, 6.05968898e-03f, 4.45618369e-02f, 4.70812358e-02f, 6.68372139e-02f, 8.76929611e-02f, 7.24142343e-02f, 1.02283634e-01f, -7.56368190e-02f, 2.45110378e-01f,
  7.89557844e-02f, 9.51533541e-02f, -3.13136913e-02f, -1.13659263e-01f, -7.05963299e-02f, 1.57923356e-01f, 1.42072290e-01f, 9.44890678e-02f, -7.97873810e-02f, 3.62270139e-02f,
  3.07293754e-04f, -1.29623219e-01f, -4.15955521e-02f, 4.45242152e-02f, -4.60715778e-02f, 1.02671228e-01f, -9.65278745e-02f, -6.13733493e-02f, -4.09097448e-02f, 2.98705958e-02f,
  -8.33680704e-02f, 6.42258525e-02f, -3.80378054e-03f, 4.31781188e-02f, -1.35367541e-02f, 3.83491889e-02f, 2.48389691e-02f, 5.08673489e-02f, 1.61163524e-01f, 7.03089759e-02f,
  6.48710355e-02f, 3.35456133e-02f, 1.20873615e-01f, 1.03608280e-01f, -3.68669592e-02f, 1.16628759e-01f, 1.09843478e-01f, -8.49342253e-03f, -1.03626512e-01f, -4.15902026e-02f,
  1.16920574e-02f, -1.18008822e-01f, -9.95779708e-02f, -5.74148633e-03f, 1.11106537e-01f, -8.51810426e-02f, 1.53042525e-01f, 1.69637084e-01f, -4.72067930e-02f, 5.92106469e-02f,
  -9.44522992e-02f, -2.05052067e-02f, -1.61992073e-01f, -2.34459899e-02f, -2.21249446e-01f, -1.44892946e-01f, -4.48898338e-02f, 1.32539451e-01f, -6.69050068e-02f, 1.27255127e-01f,
  4.80176546e-02f, 1.20645188e-01f, -1.19330823e-01f, 3.23696644e-03f, 7.76332989e-03f, -1.71962008e-02f, 1.85787722e-01f, -1.30981822e-02f, 1.44975170e-01f, -3.08641023e-03f,
  1.42474860e-01f, 1.04160108e-01f, -7.82900602e-02f, -6.30401969e-02f, 1.32726997e-01f, 4.07234617e-02f, -4.45297286e-02f, -1.22108698e-01f, 1.10811882e-01f, -6.16975166e-02f,
  -1.10688202e-01f, 3.84806506e-02f, -8.46340209e-02f, 1.22674294e-02f, -4.63455841e-02f, 9.80652422e-02f, -7.71049336e-02f, -7.36063579e-03f, 1.00163147e-02f, 3.54368910e-02f,
  -2.05967292e-01f, -1.45100087e-01f, 3.09321843e-02f, 1.15184672e-01f, -8.66138935e-02f, -1.10499896e-02f, 1.00573778e-01f, 4.38280962e-02f, 8.50879401e-02f, 1.56437233e-02f,
  3.06455903e-02f, 3.45311314e-02f, -4.41562124e-02f, -8.99245963e-02f, 1.44571781e-01f, 5.93444481e-02f, 1.09990896e-03f, 1.11843757e-01f, -7.18684047e-02f, 1.21971905e-01f,
  8.73822812e-03f, -1.17153093e-01f, 7.30916262e-02f, 9.87473056e-02f, 4.19976078e-02f, 2.07064953e-02f, 1.02022916e-01f, 6.96921051e-02f, -8.22034627e-02f, 1.07967474e-01f,
  -6.43241853e-02f, 5.48708923e-02f, 4.32903431e-02f, -1.29705518e-01f, -9.76219922e-02f, -5.49915712e-03f, -1.54629266e-02f, 1.58698276e-01f, -6.19784184e-02f, 1.91277161e-01f,
  4.82900217e-02f, 6.62707686e-02f, 2.03749668e-02f, -6.64147660e-02f, -2.29561087e-02f, -9.68142748e-02f, -3.30799259e-02f, -1.06203362e-01f, 1.06804065e-01f, -1.32399306e-01f,
  -6.66333660e-02f, 4.10553440e-02f, -8.14730525e-02f, -9.89396125e-02f, -5.49133345e-02f, -2.70658359e-02f, 9.58691612e-02f, 6.11608438e-02f, -1.34263143e-01f, -1.00589450e-03f,
  -3.01583204e-03f, 1.26737552e-02f, 6.57650754e-02f, 1.04645558e-01f, 2.44362056e-02f, 8.40726495e-02f, 2.14652866e-01f, 7.53016323e-02f, 5.56566715e-02f, 3.69908884e-02f,
  6.19723760e-02f, 6.09195828e-02f, -1.54516175e-01f, -5.69285303e-02f, 7.56660029e-02f, 4.58577424e-02f, 1.13809377e-01f, -5.90427816e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -4.04082760e-02f, 3.09831593e-02f, -1.73674405e-01f, 1.71113908e-01f, 2.26105750e-02f, -2.51747891e-02f, 2.06091747e-01f, 9.21890289e-02f, 1.92627981e-01f, 5.27817234e-02f,
  1.74482986e-01f, 4.61659208e-02f, -2.37962604e-01f, -3.48293222e-02f, -2.24046797e-01f, 2.14404121e-01f, -1.40389398e-01f, 2.08268911e-01f, 2.33072087e-01f, 1.09330848e-01f,
  6.12452962e-02f, -1.01349009e-02f, -3.20061862e-01f, 1.81571245e-01f, 1.15027018e-01f, 2.21083816e-02f, 7.19823167e-02f, -1.57508641e-01f, 5.24066798e-02f, 1.91574935e-02f,
  2.65829295e-01f, 1.94474861e-01f, 2.11327568e-01f, -5.23029566e-01f, 8.63184258e-02f, -1.15376450e-01f, 9.48554352e-02f, -7.73571789e-01f, 1.37882158e-01f, 2.48534366e-01f,
  3.40588018e-02f, 1.88817859e-01f, 6.63522854e-02f, -1.76327135e-02f, -4.59281579e-02f, 1.07819557e-01f, 6.88101575e-02f, 1.32399097e-01f, 2.42655784e-01f, 4.11465466e-02f,
  -1.18825704e-01f, 1.42656863e-02f, 1.86802610e-03f, 1.86849181e-02f, -4.22052070e-02f, 1.66625939e-02f, 7.47534707e-02f, 4.65165526e-02f, 2.08620235e-01f, 2.14734375e-02f,
  1.29967645e-01f, 9.47112739e-02f, -2.27250040e-01f, 2.86313631e-02f, 9.50309932e-02f, -2.23954767e-01f, 2.58865058e-02f, -5.19260624e-03f, 1.13049354e-02f, 2.22868487e-01f,
  1.69310331e-01f, 1.34173572e-01f, -4.04019542e-02f, -1.65482014e-02f, 8.40308443e-02f, -1.16954790e-02f, 3.23510259e-01f, -1.89215690e-01f, -6.28289506e-02f, 6.56246915e-02f,
  -2.02250049e-01f, 7.61869773e-02f, -1.38339162e-01f, 5.38041927e-02f, -1.29296049e-01f, -2.18174458e-01f, -6.24053963e-02f, 6.43192530e-02f, 5.37934266e-02f, -7.51084983e-02f,
  2.64295097e-03f, 8.55183452e-02f, 5.08941785e-02f, 1.00674964e-01f, 7.81577975e-02f, -4.05009836e-02f, 1.89462632e-01f, -1.19924478e-01f, -1.33803636e-01f, -1.60385430e-01f,
  1.81585044e-01f, -7.08032370e-01f, -2.09944099e-01f, 6.58367425e-02f, 6.66273311e-02f, -9.94498357e-02f, -2.70646308e-02f, 1.86602488e-01f, -1.15243278e-01f, -4.55260389e-02f,
  -1.47658989e-01f, 1.34737909e-01f, 8.40871930e-02f, 8.13699812e-02f, 1.74896181e-01f, 9.15892795e-02f, -1.39005765e-01f, -1.61772132e-01f, -3.68292928e-02f, -5.70297055e-02f,
  -1.17161103e-01f, 7.47047216e-02f, -1.54927447e-01f, 8.75484198e-02f, 1.07132748e-01f, 2.02267483e-01f, 8.70535430e-03f, -5.14044650e-02f, -1.25986919e-01f, -8.55752379e-02f,
  -2.00931728e-02f, -1.25963151e-01f, -4.43036482e-02f, -4.63267080e-02f, 2.01166838e-01f, -2.01823696e-01f, -6.12241887e-02f, -1.85818180e-01f, 5.34520149e-02f, -1.56341121e-01f,
  9.21705812e-02f, -1.04520470e-01f, -8.20770860e-02f, 1.82941870e-03f, -1.76843807e-01f, 5.15534505e-02f, 1.58752445e-02f, -7.73770139e-02f, 1.65813453e-02f, 2.14447185e-01f,
  1.13335498e-01f, 1.86945274e-01f, -1.65642917e-01f, 1.34453312e-01f, -1.12604924e-01f, -4.15729098e-02f, 2.24649295e-01f, 3.07050794e-01f, 3.52908112e-02f, -7.43044466e-02f,
  4.56675552e-02f, 4.18044150e-01f, -7.68716037e-02f, 1.53378978e-01f, 1.35268912e-01f, 8.95718157e-01f, 1.31330907e-01f, 1.57829553e-01f, -1.55730575e-01f, 6.31553754e-02f,
  -1.06243789e-01f, -2.57162619e-02f, 1.39399290e-01f, 9.75271761e-02f, 7.95082897e-02f, 3.58442850e-02f, 1.94290187e-02f, -5.64818382e-02f, -5.21353632e-02f, -5.96932955e-02f,
  1.53510775e-02f, 1.45116091e-01f, -8.45690910e-03f, -5.88121228e-02f, 2.08799317e-01f, -9.79125202e-02f, -1.27697900e-01f, 2.21294060e-01f, -9.40815508e-02f, -1.47698540e-02f,
  2.22097691e-02f, -1.95678417e-02f, -5.83742037e-02f, 1.79735184e-01f, -1.70680195e-01f, 1.79758221e-01f, 6.36452958e-02f, 5.55000901e-02f, 1.86235476e-02f, -7.09875226e-02f,
  7.56602734e-02f, -2.88838334e-02f, 1.95635095e-01f, 1.94381654e-01f, -1.58688769e-01f, 1.10007532e-01f, 2.11053535e-01f, -8.15528780e-02f, 4.51410934e-02f, -1.16338536e-01f,
  -1.92074731e-01f, 9.65903550e-02f, 1.09923162e-01f, -1.70291647e-01f, 7.54084066e-02f, -2.81659693e-01f, -8.20216238e-02f, -6.82672635e-02f, -1.54556066e-01f, 2.54915327e-01f,
  -5.42219132e-02f, -2.18764231e-01f, -9.20761563e-03f, 2.16489658e-01f, -1.40816532e-03f, -1.00250982e-01f, 1.19962640e-01f, 2.56491810e-01f, 1.72975987e-01f, 6.63676113e-02f,
  -3.46043296e-02f, -8.65779296e-02f, -2.85620932e-02f, 6.81940168e-02f, 6.42373711e-02f, 7.98304826e-02f, 7.37443417e-02f, 1.29996598e-01f, -2.28043273e-01f, 1.12984264e-02f,
  -1.96132243e-01f, -1.05772555e-01f, -1.34005323e-01f, -1.87746510e-01f, 8.86723846e-02f, 3.20707783e-02f, 6.07408732e-02f, -3.35634500e-02f, -4.67203557e-02f, 1.70076564e-02f,
  3.84612918e-01f, 9.90540832e-02f, -1.70189857e-01f, 1.76315442e-01f, 1.97770655e-01f, 2.99012452e-01f, 3.41088921e-02f, 2.47874875e-02f, 1.13972060e-01f, 2.32704431e-02f,
  1.63444072e-01f, 7.79263601e-02f, 3.82796153e-02f, 6.38674572e-03f, 2.04579849e-02f, 1.05609685e-01f, 2.97335368e-02f, 1.19765520e-01f, 1.12291567e-01f, -2.45034829e-01f,
  6.98899552e-02f, 1.08190022e-01f, 2.57522371e-02f, -1.71873420e-02f, -1.21651083e-01f, -2.46218264e-01f, -1.20839439e-01f, -9.20822918e-02f, 1.36000648e-01f, 6.98143169e-02f,
  1.99896563e-02f, -5.25236875e-02f, -5.26952790e-03f, 1.45766467e-01f, 3.54486018e-01f, 2.35457033e-01f, -2.03398883e-01f, -2.07380205e-01f, -4.89513911e-02f, 4.27187264e-01f,
  -7.77212009e-02f, -1.50176324e-02f, 1.90301076e-01f, 7.16775954e-02f, 8.07482284e-03f, 3.08779806e-01f, 6.63712844e-02f, 1.09856807e-01f, 9.06154215e-02f, 2.15972871e-01f,
  2.48542249e-01f, 6.30853102e-02f, -1.15537301e-01f, -5.11796661e-02f, 2.94491500e-02f, -7.27371275e-02f, 8.08481053e-02f, 2.01633319e-01f, 1.63904682e-01f, 9.91441086e-02f,
  3.60008031e-02f, 2.14463696e-02f, 1.22155182e-01f, 4.63719331e-02f, -1.36662841e-01f, 2.96288222e-01f, 8.63961596e-03f, 1.97828248e-01f, 1.14833772e-01f, -8.64759907e-02f,
  2.88024563e-02f, 1.38427228e-01f, -1.66823685e-01f, -2.31574178e-02f, 1.56661391e-01f, -2.58312542e-02f, -1.14097044e-01f, 1.43803075e-01f, -3.74746099e-02f, 2.94128549e-04f,
  9.55467448e-02f, 6.47824630e-02f, -2.21083120e-01f, -2.72832006e-01f, -1.79420948e-01f, -1.47564173e-01f, -4.53149676e-02f, -1.06171984e-02f, -6.31579310e-02f, 1.15522727e-01f,
  1.77168474e-01f, 9.32468846e-02f, 1.43694237e-01f, -1.53439581e-01f, 5.12582995e-02f, 9.96655319e-03f, -1.99598655e-01f, 6.72167763e-02f, 4.20623133e-03f, 2.01133594e-01f,
  1.38432011e-01f, 6.76064417e-02f, 4.86985631e-02f, -4.05316919e-01f, 3.10263988e-02f, 2.43235543e-01f, 3.04248154e-01f, 8.69607449e-01f, 1.15649723e-01f, 1.95450678e-01f,
  -4.50704582e-02f, 2.07347706e-01f, -1.85279787e-01f, 9.53039061e-03f, 1.78362444e-01f, 1.57255083e-01f, -3.29836644e-02f, -1.34572491e-01f, -6.15035295e-02f, -1.16293952e-01f,
  -2.48382285e-01f, -2.31020972e-01f, -1.46816105e-01f, -1.62038989e-02f, 7.81961232e-02f, -1.19495392e-01f, 2.37586722e-01f, -9.85828564e-02f, -7.21227527e-02f, 1.17019648e-02f,
  -1.49406478e-01f, 5.56269698e-02f, 2.05977812e-01f, 1.47097990e-01f, 4.97580506e-02f, -6.73625916e-02f, -1.03589632e-01f, -8.72179586e-03f, -4.21622619e-02f, 9.81606245e-02f,
  -2.22014301e-02f, 2.74005588e-02f, 6.99862689e-02f, -3.13966572e-02f, 5.33354543e-02f, -1.26738861e-01f, 1.05669320e-01f, -7.64653692e-03f, 4.06834967e-02f, 4.75662202e-02f,
  9.48511437e-02f, -7.33364522e-02f, -5.51963039e-02f, -1.45451017e-02f, 3.65318321e-02f, 6.56356886e-02f, 1.62901692e-02f, -1.54344374e-02f, -9.78028178e-02f, -7.95012116e-02f,
  4.43552956e-02f, -1.11317551e-02f, -1.13581225e-01f, 9.66488197e-03f, 4.26908061e-02f, -6.48815259e-02f, 4.58854027e-02f, -1.24631124e-02f, -5.05007468e-02f, 6.26898780e-02f,
  4.63377275e-02f, 9.55795944e-02f, -1.04794346e-01f, 3.31660248e-02f, -8.09477568e-02f, 6.80624992e-02f, 8.73222295e-03f, -1.18420519e-01f, -6.31822944e-02f, -1.29134804e-01f,
  5.09122238e-02f, -2.42282040e-02f, 9.70987231e-03f, 7.83407986e-02f, -6.58205524e-02f, 4.51733321e-02f, 6.18766472e-02f, -1.42476827e-01f, -1.18831873e-01f, -6.54048324e-02f,
  -3.24848704e-02f, 4.97352630e-02f, -9.66355205e-02f, -1.24491401e-01f, 1.03902005e-01f, 2.18761116e-02f, -3.10819838e-02f, -2.28607990e-02f, 5.95769938e-03f, -1.39045864e-01f,
  5.95082566e-02f, 2.18234002e-03f, 4.47434522e-02f, 4.29725368e-03f, -2.87275948e-02f, -7.16957971e-02f, 9.89400223e-02f, -1.28147230e-01f, 7.05893561e-02f, 1.28134698e-01f,
  -2.54125297e-01f, 2.31564492e-01f, -1.48995087e-01f, -2.77951062e-01f, 1.21810086e-01f, 1.26572758e-01f, 4.73269448e-02f, -1.83972672e-01f, 2.12133452e-01f, 3.05935979e-01f,
  1.92340940e-01f, -2.46425688e-01f, 4.06349227e-02f, -2.89498288e-02f, 4.37177718e-02f, -1.30349129e-01f, 1.33496985e-01f, 8.93506482e-02f, -1.39179811e-01f, -4.19975296e-02f,
  -2.87477940e-01f, 6.60000384e-01f, 6.25222549e-02f, 9.97929201e-02f, 1.51280537e-01f, 7.23710299e-01f, 3.55866849e-01f, -4.27577756e-02f, -7.09249377e-02f, 2.71938026e-01f,
  1.39621690e-01f, -9.24265943e-03f, 2.70296305e-01f, 1.17779374e-01f, 2.29884788e-01f, 1.48132488e-01f, 1.40815914e-01f, 8.18493292e-02f, 4.10017483e-02f, 1.49170905e-02f,
  3.73259097e-01f, 3.88169229e-01f, -9.51969400e-02f, 5.96063137e-02f, 9.57573801e-02f, 1.15753643e-01f, 2.25124396e-02f, 1.31339595e-01f, -1.84436932e-01f, -3.83439064e-02f,
  1.31224036e-01f, -7.65464455e-02f, 2.00648326e-02f, -1.00776590e-01f, -1.02557197e-01f, -7.38042593e-02f, -6.92547709e-02f, 8.88283178e-02f, -9.14481878e-02f, 5.66787012e-02f,
  -3.25154178e-02f, 1.07053384e-01f, -6.68497235e-02f, 9.18848366e-02f, 2.56336704e-02f, -8.20222050e-02f, 4.28073294e-02f, -3.41800340e-02f, -1.36502057e-01f, -1.32643238e-01f,
  -6.07555024e-02f, 7.55764032e-03f, -5.47418073e-02f, 1.04492784e-01f, -7.78103545e-02f, 3.09405047e-02f, 7.06838071e-02f, 1.06550204e-02f, 2.89340951e-02f, -7.43462518e-02f,
  -1.00297749e-01f, 4.12997156e-02f, -8.16679671e-02f, -8.47999752e-02f, 1.04454450e-01f, 4.35122550e-02f, 3.77358869e-02f, 1.32357925e-02f, -8.76918361e-02f, 1.83997005e-02f,
  -6.21530116e-02f, -1.51451528e-02f, -2.24095061e-02f, -3.58634144e-02f, -4.50021811e-02f, -2.51979157e-02f, -3.47927213e-03f, 5.87461889e-03f, -2.85977721e-02f, 2.31157094e-02f,
  -6.58398196e-02f, -8.06686282e-03f, -1.06124036e-01f, 5.28767668e-02f, -4.78367321e-02f, 3.67425941e-02f, 6.52288795e-02f, 1.89762115e-02f, -2.96724774e-02f, 5.75051755e-02f,
  2.15685950e-03f, -1.36717185e-01f, 7.27404952e-02f, -7.52463415e-02f, -7.72806406e-02f, -5.44723030e-03f, -3.64114828e-02f, -8.71782526e-02f, -1.00194693e-01f, -1.04571216e-01f,
  9.11127478e-02f, -1.10990599e-01f, -4.57942039e-02f, -8.52767527e-02f, -8.59922767e-02f, 7.33005106e-02f, 8.16194937e-02f, -9.08638835e-02f, -6.28210604e-02f, -3.18510942e-02f,
  5.79468459e-02f, -7.39797130e-02f, -1.18879028e-01f, -8.23941901e-02f, -5.66342585e-02f, -3.38806324e-02f, 6.83160424e-02f, -2.11435161e-03f, 2.83820480e-02f, -6.43861145e-02f,
  -1.02215335e-01f, 4.69381437e-02f, 1.08294636e-02f, 2.02938132e-02f, -6.79880604e-02f, 5.24857305e-02f, -7.63522834e-02f, -6.16614446e-02f, -1.20765142e-01f, -6.51625246e-02f,
  9.04849917e-02f, -7.44295940e-02f, 3.93043198e-02f, -1.00717813e-01f, 4.48618084e-03f, -1.10588036e-01f, -6.13130908e-03f, -7.06384405e-02f, -2.23632902e-02f, -7.90146068e-02f,
  5.88595159e-02f, -4.90600169e-02f, -1.89157259e-02f, -1.15821078e-01f, 6.13838844e-02f, -3.34702879e-02f, 7.17109814e-02f, 6.46974593e-02f, -5.37883826e-02f, 7.01126605e-02f,
  -1.45294517e-02f, -7.37599581e-02f, 6.84091225e-02f, 4.83850390e-02f, -1.21557474e-01f, -7.71692619e-02f, 1.09870493e-01f, -1.21984467e-01f, -5.89776039e-02f, -2.22281981e-02f,
  1.60797432e-01f, 1.08796239e-01f, 2.24361420e-01f, 7.44426474e-02f, -4.80263010e-02f, 2.00031877e-01f, 2.83748400e-03f, 7.91575462e-02f, 1.41933197e-02f, -3.89257856e-02f,
  2.14544833e-01f, 2.51209408e-01f, 8.93168747e-02f, 3.66610050e-01f, 3.09878647e-01f, -4.15646844e-02f, 2.11520121e-01f, -4.42381762e-02f, -2.80840158e-01f, -2.56720990e-01f,
  -1.79858372e-01f, 9.75364596e-02f, 5.58755621e-02f, -1.37971267e-01f, -4.23369184e-02f, 1.50691167e-01f, -1.70635104e-01f, 1.30031914e-01f, 7.03652427e-02f, -2.90942024e-02f,
  7.35723507e-03f, -8.96748528e-02f, -1.55285493e-01f, 6.11263096e-01f, 3.29933345e-01f, -1.03820639e-03f, -2.03318954e-01f, -4.56852257e-01f, -2.38286089e-02f, -2.75801629e-01f,
  2.18324825e-01f, -7.88236633e-02f, 1.55155301e-01f, -4.99273837e-03f, 1.63739458e-01f, 1.26319900e-02f, 1.65969357e-01f, 2.37333328e-01f, -1.77026138e-01f, -9.61061716e-02f,
  1.92234114e-01f, 1.93394840e-01f, 3.06169480e-01f, 2.68849432e-01f, -1.97599996e-02f, 7.83350840e-02f, -1.61692530e-01f, -2.20499970e-02f, 2.18311489e-01f, -2.33276933e-02f,
  -7.61838704e-02f, 6.75272122e-02f, 9.32067484e-02f, 1.76103488e-02f, -9.92022455e-02f, -9.47371572e-02f, 1.31794274e-01f, -5.74281774e-02f, -1.28861323e-01f, -1.11580722e-01f,
  2.13207111e-01f, 2.07391679e-02f, 1.03257999e-01f, -1.32098243e-01f, 2.14024588e-01f, 8.64779763e-03f, -1.30975440e-01f, 8.44399408e-02f, -3.85380015e-02f, 1.65977646e-02f,
  2.25097820e-01f, 7.46106729e-02f, -1.40729219e-01f, -3.11844167e-04f, 1.23670787e-01f, 4.14183438e-02f, -2.18326077e-01f, 6.17311522e-02f, -8.25961754e-02f, 2.26235017e-01f,
  -1.98442772e-01f, -2.96895858e-02f, -1.02760896e-01f, -1.50169894e-01f, 2.88255304e-01f, 2.36285463e-01f, 1.31169826e-01f, -4.08184290e-01f, 2.84121096e-01f, 2.40656380e-02f,
  1.30864099e-01f, -2.51299679e-01f, 1.89790770e-01f, -7.47419447e-02f, 2.04297975e-01f, 8.73303860e-02f, 2.22157672e-01f, -8.96305069e-02f, -4.03473387e-03f, -6.96387887e-02f,
  2.51733720e-01f, 1.26357079e-01f, 3.62531096e-02f, 1.10572418e-02f, 1.48364350e-01f, 6.32961392e-02f, -3.99582274e-02f, 2.94884682e-01f, -5.55562563e-02f, -6.21607341e-03f,
  2.19386056e-01f, -5.75551651e-02f, 3.07325840e-01f, -1.69965461e-01f, 5.13018444e-02f, -1.46740377e-01f, -5.10440767e-02f, 7.38405660e-02f, 7.06337318e-02f, 2.07892150e-01f,
  2.32634991e-02f, 4.02279757e-02f, -8.09082240e-02f, 4.66344394e-02f, 9.04806182e-02f, 1.43577889e-01f, 4.85418402e-02f, 1.63888037e-01f, 1.45598143e-01f, 1.81934446e-01f,
  -7.82890394e-02f, 2.72753030e-01f, -2.17011268e-03f, 1.13159962e-01f, 3.11494023e-02f, 1.44671965e-02f, 1.46508932e-01f, -1.61202386e-01f, -5.61545715e-02f, 2.48321339e-01f,
  -1.70428865e-02f, 1.64174527e-01f, -3.23249755e-04f, 2.88766563e-01f, -5.39894728e-03f, -9.38610137e-02f, -1.37099596e-02f, 2.34490469e-01f, -1.71378925e-01f, -2.11859912e-01f,
  -1.05055116e-01f, 7.32418895e-01f, 2.47691631e-01f, -1.16831183e-01f, -1.39359087e-01f, -1.79436728e-01f, 7.50579610e-02f, 2.20402796e-03f, 1.11075051e-01f, 1.72862917e-01f,
  2.76963860e-01f, 1.03167512e-01f, 8.41792598e-02f, 9.75356400e-02f, 3.35226774e-01f, 1.66383326e-01f, -3.19337957e-02f, 9.70822275e-02f, 1.10244602e-01f, 1.19426519e-01f,
  2.65856892e-01f, 2.01753333e-01f, -7.45206256e-04f, -2.65924484e-02f, 1.54888138e-01f, 1.61035324e-03f, -1.04556948e-01f, 1.17916383e-01f, 3.08804251e-02f, -3.32752243e-02f,
  2.14278311e-01f, -2.69526064e-01f, 1.09460808e-01f, 3.92094590e-02f, -1.61240324e-01f, 7.74051845e-02f, -1.03505719e-02f, -1.11287110e-01f, 1.56544372e-01f, 1.97880208e-01f,
  1.15837216e-01f, 1.74607098e-01f, 1.24378406e-01f, -1.06826976e-01f, 6.41156435e-02f, -2.31792569e-01f, -3.21704596e-01f, 4.02065963e-02f, -1.57062337e-01f, 2.91241586e-01f,
  1.82054430e-01f, 2.99561173e-01f, 5.03621362e-02f, -1.33235961e-01f, -2.90538520e-01f, 1.87503293e-01f, 6.51755854e-02f, 1.22921288e-01f, 2.08297819e-01f, 2.49843765e-02f,
  9.79539081e-02f, 5.53959124e-02f, 3.36079538e-01f, 8.97520557e-02f, 2.05584466e-01f, -4.14376378e-01f, 3.31855156e-02f, -7.34150186e-02f, 1.85476825e-01f, -4.71645117e-01f,
  -5.72223589e-02f, 1.91901490e-01f, 1.43457636e-01f, 6.24687523e-02f, 1.04132108e-01f, -8.45752135e-02f, -1.17236733e-01f, 1.22895651e-01f, -5.90028092e-02f, 1.93613693e-01f,
  2.39697978e-01f, -1.29156644e-02f, -5.92153594e-02f, 2.87997238e-02f, -3.75017747e-02f, -3.93414088e-02f, 1.12646870e-01f, -1.66625939e-02f, 9.09669921e-02f, 8.54970962e-02f,
  -1.20306149e-01f, -1.16882265e-01f, 2.40125343e-01f, 8.78654197e-02f, -1.92178249e-01f, 7.09953755e-02f, 1.41808748e-01f, 9.37701240e-02f, 2.49942597e-02f, 2.41035055e-02f,
  1.89797103e-01f, 7.14910636e-03f, 1.56327635e-01f, -6.63414747e-02f, -1.14668552e-02f, 3.21713388e-02f, 1.33144110e-01f, -3.05328015e-02f, 5.22363707e-02f, -1.24197461e-01f,
  4.45685722e-02f, 2.53013760e-01f, -4.37672548e-02f, 2.21356004e-02f, -1.05245747e-01f, 1.55180126e-01f, 3.29577215e-02f, -2.49463245e-01f, -7.66227767e-02f, 1.14698164e-01f,
  -4.52844314e-02f, -1.08421758e-01f, 2.12069482e-01f, -1.30297616e-03f, 1.01790033e-01f, 1.51060075e-02f, 1.34536296e-01f, 1.71403363e-02f, 7.61295706e-02f, -2.88626887e-02f,
  -1.02079242e-01f, 4.50886451e-02f, 9.71133783e-02f, -7.69914925e-01f, -8.24812353e-02f, 1.94575116e-01f, -5.69403842e-02f, -5.57266781e-03f, 1.44940093e-01f, 1.40622333e-01f,
  5.52671514e-02f, 1.75511405e-01f, -2.02332124e-01f, 7.43644610e-02f, 1.63215965e-01f, -7.94186294e-02f, -6.13141656e-02f, -1.30017638e-01f, 6.38164505e-02f, -9.12338868e-02f,
  1.05663696e-02f, 1.07142903e-01f, -1.19041661e-02f, -8.02152008e-02f, -5.44569641e-02f, 9.93432403e-02f, 2.68149734e-01f, 1.39792725e-01f, 5.54050840e-02f, 1.10169174e-03f,
  1.86735004e-01f, -3.32434587e-02f, -1.69434515e-03f, -6.73245192e-02f, 2.09787250e-01f, -4.32509929e-02f, 3.75589468e-02f, -7.06661772e-03f, 1.07887588e-01f, -4.34579439e-02f,
  7.75931850e-02f, 1.22008495e-01f, 2.44490504e-01f, -9.59368125e-02f, 1.64862946e-01f, 2.64781654e-01f, -1.81075796e-01f, -2.32155934e-01f, -1.70549348e-01f, -9.77951661e-02f,
  -2.56150365e-01f, -2.79701531e-01f, 1.69743419e-01f, 9.00964737e-02f, 1.51279911e-01f, 1.36941254e-01f, -2.03971416e-02f, 3.23641628e-01f, 6.95087239e-02f, 5.62183931e-02f,
  2.46245086e-01f, 3.54260132e-02f, 3.40886623e-01f, 2.42279246e-01f, -1.97789773e-01f, 2.53862627e-02f, 7.54992664e-02f, -2.70821184e-01f, -2.29260951e-01f, 2.90899098e-01f,
  8.90125483e-02f, -7.26262033e-02f, 1.01299025e-01f, 2.96470881e-01f, -6.03272719e-03f, -1.41675649e-02f, -1.47673458e-01f, 2.25599650e-02f, 9.54804942e-02f, 2.46033370e-02f,
  6.85189515e-02f, 2.27014005e-01f, -1.12970151e-01f, -3.73652205e-02f, 4.70468327e-02f, -1.11055098e-01f, 1.12332376e-02f, -4.72738892e-02f, -8.16851780e-02f, 1.52191147e-01f,
  1.43574746e-02f, 2.64247596e-01f, -1.12351002e-02f, 3.04641157e-01f, 1.37707248e-01f, 1.21134594e-01f, 1.28553644e-01f, 4.91058752e-02f, -1.11744199e-02f, 7.33121112e-02f,
  -1.04001248e-02f, 1.21572413e-01f, 1.08920984e-01f, 1.55882522e-01f, -1.32164489e-02f, 1.21519253e-01f, -1.18519053e-01f, 2.02902362e-01f, -2.11207867e-01f, 1.48735210e-01f,
  1.61069036e-01f, 2.63181865e-01f, 1.72348529e-01f, 9.88765880e-02f, 9.48785394e-02f, 2.15309709e-01f, -1.44100249e-01f, 2.66764969e-01f, 1.59011260e-02f, 1.36799186e-01f,
  4.16778587e-02f, -8.77833292e-02f, 1.13308825e-01f, 1.75195727e-02f, -9.52999219e-02f, -9.43376049e-02f, -1.31248742e-01f, 2.76620537e-01f, 1.19944729e-01f, -1.95613235e-01f,
  -1.25285432e-01f, -1.11053631e-01f, 1.53058246e-01f, -4.55276743e-02f, 2.01347440e-01f, 2.66078264e-01f, 3.79225984e-02f, -1.08493362e-02f, 7.57729039e-02f, 1.70353904e-01f,
  2.16184035e-01f, 2.81344384e-01f, 1.96180135e-01f, 9.32577401e-02f, 1.50717020e-01f, 2.23164082e-01f, 3.26367944e-01f, 2.35737979e-01f, 3.50410007e-02f, 1.15688704e-01f,
  6.13302961e-02f, 5.51989228e-02f, -2.42589898e-02f, 2.08122745e-01f, 1.88739151e-01f, -5.02010025e-02f, 3.17685977e-02f, -1.59820423e-01f, 1.03873670e-01f, 1.58120230e-01f,
  1.30389901e-02f, -2.47398708e-02f, -1.78286016e-01f, 1.31730624e-02f, -3.85928750e-02f, 1.18698299e-01f, 2.08260138e-02f, 3.82747781e-03f, -3.38860750e-02f, -8.17053542e-02f,
  2.73752987e-01f, 7.91945755e-02f, 2.07239524e-01f, -6.82396814e-02f, 1.23274513e-01f, -7.89858922e-02f, -6.23812489e-02f, -1.68385178e-01f, -3.47898901e-02f, 1.09813809e-01f,
  1.64520949e-01f, 1.11396477e-01f, 1.22178607e-01f, 2.03527838e-01f, -1.92374110e-01f, 1.64112955e-01f, -7.16788173e-02f, -2.18458235e-01f, 1.44854069e-01f, 2.43476808e-01f,
  2.03474611e-01f, 2.13870630e-01f, 6.70752004e-02f, 6.97362572e-02f, -5.76085933e-02f, 1.53288126e-01f, -8.58523175e-02f, -2.72720963e-01f, 1.83166593e-01f, -1.44202232e-01f,
  -8.12783614e-02f, 1.66038856e-01f, 2.33905651e-02f, -2.23910287e-01f, 2.10962027e-01f, 1.21653996e-01f, -1.87911600e-01f, -8.74666795e-02f, 1.36425495e-01f, 1.73795044e-01f,
  -1.26761168e-01f, -1.73088554e-02f, -7.25399554e-02f, -4.35349867e-02f, -8.17741267e-03f, -1.45966420e-02f, 2.05628365e-01f, -3.15926634e-02f, -6.00598343e-02f, 3.16456854e-02f,
  1.89899936e-01f, 2.95487225e-01f, -4.09961306e-02f, 1.11121743e-03f, -2.03448744e-03f, 5.32838032e-02f, 8.61368254e-02f, 1.01138234e-01f, 7.51551166e-02f, 1.63182467e-01f,
  -2.11667586e-02f, 3.07113100e-02f, -7.53299221e-02f, 1.39154652e-02f, -1.92654982e-01f, 1.30044147e-01f, -4.27599102e-02f, 9.76770446e-02f, 7.58468136e-02f, 7.66591579e-02f,
  1.81811750e-01f, 6.41229525e-02f, -1.31698966e-01f, -4.27537709e-02f, -1.44481793e-01f, 2.20289126e-01f, -9.94227454e-02f, 2.49348000e-01f, -9.75273028e-02f, 4.83246939e-03f,
  1.84046343e-01f, 1.27058506e-01f, 1.99656352e-01f, -8.04006830e-02f, 1.72528803e-01f, -3.48342150e-01f, 1.23888366e-01f, -6.04795031e-02f, 9.64648649e-02f, -6.43275857e-01f,
  6.67652860e-02f, 1.95112780e-01f, 7.58929849e-02f, 2.37214426e-03f, 2.02324316e-01f, -1.01705685e-01f, -8.47089291e-02f, 1.28722176e-01f, 2.06188738e-01f, 2.50580817e-01f,
  1.63130924e-01f, 3.44603918e-02f, 1.98786318e-01f, 5.39378151e-02f, -2.37844256e-03f, 1.99972183e-01f, -6.53645843e-02f, -9.57998186e-02f, -4.05312292e-02f, 1.01482920e-01f,
  1.74475983e-01f, -7.74788065e-03f, 1.46323457e-01f, -9.08000842e-02f, -1.30807415e-01f, 8.15410167e-02f, -1.46277890e-01f, -1.68188587e-01f, -9.23877582e-02f, 7.63289779e-02f,
  -8.10955018e-02f, -1.04398690e-01f, 2.34283596e-01f, -1.10266365e-01f, 1.31029719e-02f, -1.53098285e-01f, -1.41037852e-01f, -9.22207013e-02f, -6.64805323e-02f, -2.94901162e-01f,
  4.75273579e-02f, -9.40691121e-03f, -6.64219707e-02f, -3.02550998e-02f, 6.65024668e-02f, 1.59961209e-01f, 9.73360017e-02f, -3.24338563e-02f, -1.64311245e-01f, 4.61047282e-03f,
  1.56187462e-02f, 7.65803605e-02f, -2.66618114e-02f, -1.34371430e-01f, 1.10623486e-01f, 2.52082139e-01f, 2.51634538e-01f, 1.47568449e-01f, 8.66779387e-02f, -2.18351141e-01f,
  -7.71186948e-02f, -7.45923892e-02f, 4.61133234e-02f, 6.47926256e-02f, -4.26292494e-02f, 1.05196141e-01f, 4.39439490e-02f, -2.76003070e-02f, 1.30919501e-01f, -6.26392737e-02f,
  -9.55545083e-02f, 6.50881603e-02f, -5.92543110e-02f, 1.79201096e-01f, 2.92259067e-01f, 1.95530653e-02f, 8.50517228e-02f, 1.16521589e-01f, -1.52867716e-02f, -1.00381896e-01f,
  -1.03124008e-01f, 8.54344964e-02f, 2.29124337e-01f, -9.30328816e-02f, -4.95861806e-02f, 1.51381671e-01f, 1.32304817e-01f, -3.81422900e-02f, 5.80261238e-02f, -9.81599763e-02f,
  -1.22698590e-01f, 2.37117652e-02f, 5.64224608e-02f, 1.00404568e-01f, -8.50919187e-02f, -4.34729941e-02f, -5.30400947e-02f, -9.69214663e-02f, -9.03074816e-02f, 7.62177408e-02f,
  -3.61592695e-02f, 6.36211336e-02f, -1.11137509e-01f, 1.21338535e-02f, 1.23204254e-01f, -1.13597982e-01f, 9.29155424e-02f, 8.05681050e-02f, -2.27459576e-02f, 1.40187979e-01f,
  2.66214032e-02f, -1.50244934e-02f, -6.06684983e-02f, 5.04495343e-04f, 1.10605434e-01f, -3.08105331e-02f, 6.46828115e-02f, 4.64272127e-02f, -5.70613407e-02f, 1.04495332e-01f,
  -3.84899564e-02f, -1.11635655e-01f, 2.83785146e-02f, 5.00811078e-02f, -1.43693551e-01f, 6.57909885e-02f, -3.81205492e-02f, 6.94684237e-02f, -4.78491671e-02f, 2.94842962e-02f,
  2.86974735e-03f, -1.19517788e-01f, 6.73084185e-02f, -7.15128779e-02f, 6.46415204e-02f, -1.09059490e-01f, -5.63429575e-03f, 6.86898381e-02f, -7.19106495e-02f, -3.42766643e-02f,
  2.13404298e-02f, -2.17166319e-02f, -1.03638597e-01f, -9.17054117e-02f, -8.29100609e-05f, 1.03634253e-01f, -1.29688889e-01f, -5.25326133e-02f, 7.10886791e-02f, -9.62834358e-02f,
  8.37327391e-02f, 1.96286291e-02f, 3.20531130e-02f, -1.11565597e-01f, 6.88736960e-02f, 1.34993494e-01f, 8.30434114e-02f, 1.78205654e-01f, 1.96393386e-01f, 1.63451642e-01f,
  -1.16715498e-01f, 9.87140555e-03f, -3.09044961e-03f, 1.31964907e-01f, 1.10837780e-01f, 3.27888317e-02f, 1.73450157e-01f, -1.57498747e-01f, 2.11103141e-01f, 3.17240842e-02f,
  4.36331406e-02f, -9.80617013e-03f, -3.30233127e-02f, -1.03099018e-01f, -1.66902512e-01f, -2.06267983e-01f, -5.26449039e-05f, 4.50587571e-02f, 7.15739354e-02f, 8.87103658e-03f,
  2.81689242e-02f, 3.41118425e-01f, -3.02234087e-02f, -1.84345916e-01f, 1.54933408e-01f, -3.97206992e-02f, 2.54474729e-01f, 1.28493188e-02f, 3.83546017e-02f, 7.97791481e-02f,
  2.02662777e-02f, -6.40867174e-01f, -1.21676356e-01f, 2.02444077e-01f, 1.79207337e-03f, 7.44588524e-02f, -5.14626689e-02f, 1.87623829e-01f, 1.98731989e-01f, 9.64620896e-03f,
  -1.68782011e-01f, -1.16056457e-01f, 7.63075501e-02f, -1.06505960e-01f, 1.05970398e-01f, -1.41911414e-02f, 3.30369584e-02f, -2.06711069e-01f, -5.13103008e-02f, -8.73193964e-02f,
  -1.48388401e-01f, -1.03359722e-01f, -6.98733702e-02f, 3.25855985e-02f, 4.33008969e-02f, 3.23044986e-01f, -2.43020114e-02f, 2.65561670e-01f, 3.48910242e-02f, 2.68210024e-02f,
  -1.19431771e-01f, -7.71095827e-02f, -1.18338570e-01f, -9.42056701e-02f, -2.30800658e-02f, -7.94630572e-02f, -1.61012355e-03f, 1.04871809e-01f, -7.93234333e-02f, 1.71807185e-02f,
  1.13556616e-01f, -1.25111207e-01f, -2.30758842e-02f, 5.35886958e-02f, 3.41887400e-02f, 2.09319592e-02f, -3.27794850e-02f, 9.88943204e-02f, 7.83013254e-02f, -2.18106415e-02f,
  1.95585843e-02f, -9.23514664e-02f, -7.45766461e-02f, -2.09555496e-02f, 3.68387103e-02f, -1.20769545e-01f, -8.43180493e-02f, -3.12860310e-03f, -5.60410805e-02f, 5.67735126e-03f,
  -9.99625698e-02f, 5.92004657e-02f, 9.68672261e-02f, -1.15834707e-02f, -1.38004720e-01f, -3.67931873e-02f, -9.40040499e-02f, -4.01979052e-02f, -1.20287202e-01f, -6.46961406e-02f,
  4.65866514e-02f, -1.46246552e-02f, -2.88727991e-02f, 5.48840985e-02f, 6.30912259e-02f, 8.71911421e-02f, 1.98724270e-02f, 4.33405042e-02f, 1.40338344e-02f, -2.50225570e-02f,
  -8.41593742e-02f, -7.74288550e-02f, -1.97052360e-02f, -1.01111323e-01f, 6.18788451e-02f, 1.08862579e-01f, -8.84381533e-02f, -4.15694714e-02f, -2.32419819e-02f, 5.79335801e-02f,
  -1.17922418e-01f, 9.01255310e-02f, -4.45005903e-03f, 1.22141182e-01f, 1.60357758e-01f, -1.36934295e-01f, 1.84194982e-01f, 8.07559490e-02f, 3.47745903e-02f, -1.19932987e-01f,
  1.05276462e-02f, 6.90059215e-02f, -2.34910119e-02f, 4.57447879e-02f, -4.10613194e-02f, 1.00695319e-01f, 2.98706174e-01f, -1.02244556e-01f, 1.09947048e-01f, -2.63451964e-01f,
  -3.47531378e-01f, -2.37858504e-01f, -4.56452072e-02f, -5.68528520e-03f, 6.75427392e-02f, -2.24495560e-01f, -4.46441211e-02f, -2.04792768e-01f, -4.54063490e-02f, 2.56544530e-01f,
  9.16084722e-02f, 1.27831861e-01f, -1.00256264e-01f, -1.09744035e-01f, 1.72655955e-01f, 1.64856285e-01f, -8.32637474e-02f, 3.24803710e-01f, 2.20144823e-01f, 1.05587363e+00f,
  -1.58254623e-01f, 2.11985797e-01f, -7.18504786e-02f, 1.54806390e-01f, 1.47192538e-01f, 9.75079611e-02f, 3.60514104e-01f, 2.25534916e-01f, -2.46795192e-01f, -7.51557807e-03f,
  3.08797956e-02f, 7.47607797e-02f, 2.22165659e-02f, -9.06970128e-02f, 9.76226013e-03f, -4.50995378e-02f, 1.13021135e-01f, -9.37523842e-02f, 1.17523775e-01f, 1.18309982e-01f,
  1.41307831e-01f, 8.31176415e-02f, -7.76573867e-02f, 2.81452596e-01f, 1.87734202e-01f, 9.30333212e-02f, -3.86178456e-02f, -2.39124000e-01f, 4.58722785e-02f, -2.53930628e-01f,
  -1.19632669e-01f, -4.28349450e-02f, 4.59093936e-02f, -1.09559692e-01f, -1.26535580e-01f, -4.52208482e-02f, -2.15736963e-02f, -1.22665465e-01f, 2.48917550e-01f, -2.40918323e-01f,
  -1.39085919e-01f, -8.94417688e-02f, -2.04472154e-01f, 3.69771803e-03f, 2.02749208e-01f, 1.53223678e-01f, 4.67053913e-02f, -7.76459649e-02f, -1.58158600e-01f, 4.23616841e-02f,
  2.04420574e-02f, 2.33777761e-02f, 9.75764841e-02f, -6.63423911e-02f, -6.06475770e-03f, 1.29805088e-01f, 2.09796414e-01f, 1.14411544e-02f, 9.10275206e-02f, -7.53260404e-02f,
  -1.44902065e-01f, -1.66068792e-01f, 1.75652042e-01f, 3.54278088e-01f, -6.50106696e-03f, 7.22373724e-02f, 8.76316130e-02f, 6.05774000e-02f, 5.56792505e-02f, -3.91738117e-02f,
  5.38500063e-02f, 1.41169233e-02f, 9.25472155e-02f, -5.27019054e-02f, 9.59138200e-02f, 1.12634137e-01f, 6.96234107e-02f, 1.55731872e-01f, -1.50578573e-01f, -1.70163110e-01f,
  -7.49769583e-02f, 8.18617344e-02f, 1.65850505e-01f, 3.45241874e-02f, -1.78014576e-01f, 1.08225465e-01f, 9.67127308e-02f, -2.40022559e-02f, 4.88136411e-02f, 9.86996964e-02f,
  -1.64527312e-01f, -1.59331679e-01f, 6.72279373e-02f, -1.37424484e-01f, -9.29017290e-02f, -3.77001278e-02f, 1.92190260e-01f, -1.76717147e-01f, -2.04186827e-01f, -1.27587482e-01f,
  9.41339210e-02f, -9.20229629e-02f, 1.58457205e-01f, -1.17210351e-01f, 1.30020827e-01f, 8.62161890e-02f, -1.46829635e-01f, -1.51535019e-01f, -5.16589209e-02f, -1.81410119e-01f,
  -3.33196260e-02f, -1.13437459e-01f, -2.61255186e-02f, 1.91683307e-01f, 2.68469602e-02f, 1.20112725e-01f, 1.65768545e-02f, -7.46525824e-02f, 2.34160155e-01f, 1.57407865e-01f,
  2.06815124e-01f, 3.02143674e-02f, -2.61978395e-02f, 4.28756811e-02f, -2.02838451e-01f, -1.03205830e-01f, 8.10355991e-02f, -9.14832205e-02f, -4.87785190e-02f, 1.95632428e-01f,
  -7.18682483e-02f, -9.12827998e-02f, 9.55789164e-02f, -4.07815464e-02f, 1.20171390e-01f, 1.41758174e-01f, -1.46561414e-01f, -5.53114153e-02f, 9.26146880e-02f, 8.56695920e-02f,
  2.09117010e-01f, 7.59874806e-02f, -9.32346657e-02f, -2.60356329e-02f, -2.34263688e-02f, -6.68642148e-02f, -1.02946848e-01f, -1.22580417e-01f, -2.22968712e-01f, 8.02410841e-02f,
  -8.99312794e-02f, 7.93103650e-02f, -4.36640754e-02f, -2.98229698e-02f, 7.87415504e-02f, 1.01840205e-01f, 5.54740382e-03f, -3.45450863e-02f, -1.09913349e-01f, -1.28631607e-01f,
  -2.47303531e-01f, 9.26452950e-02f, -5.58937639e-02f, -9.66721326e-02f, -3.06628291e-02f, -7.52494857e-02f, 1.94136128e-01f, -5.79818189e-02f, 3.69262844e-02f, 1.40397996e-01f,
  9.00459301e-04f, -8.83460194e-02f, 3.33147459e-02f, 9.26956087e-02f, -1.17076561e-01f, -2.31221065e-01f, 1.28570855e-01f, -4.44694422e-02f, 3.93650010e-02f, -2.18515247e-02f,
  6.51228148e-03f, 2.30818659e-01f, -1.05165362e-01f, 4.21518314e-04f, 3.11553836e-01f, 1.97993279e-01f, 3.33657026e-01f, -5.24259880e-02f, 6.90667331e-03f, 2.22910574e-04f,
  1.86185807e-01f, 3.01514000e-01f, -2.47686371e-01f, -8.48043337e-02f, 2.26330295e-01f, -6.26032799e-02f, -4.45026625e-03f, 1.91107541e-01f, -1.61137417e-01f, -2.14401692e-01f,
  -8.52568597e-02f, -2.90485204e-05f, -1.00006670e-01f, 5.81558868e-02f, 6.12302311e-02f, 7.11647198e-02f, -1.72742248e-01f, -2.51802742e-01f, -4.12205700e-03f, -6.97208345e-02f,
  1.58308908e-01f, -6.67433664e-02f, 7.91169554e-02f, 7.39030656e-04f, 2.61888672e-02f, 1.09328441e-01f, 3.51897441e-02f, 2.62111664e-01f, 1.66919276e-01f, 1.75609350e-01f,
  1.21065015e-02f, -1.36034433e-02f, 9.34353545e-02f, -1.23341739e-01f, 1.02807865e-01f, -8.92471969e-02f, 5.92705905e-02f, 2.44379062e-02f, 4.45298217e-02f, 4.77417000e-02f,
  -2.61663459e-02f, -1.15592085e-01f, 1.43225342e-02f, 8.57375562e-02f, 8.66559595e-02f, -5.64989224e-02f, 2.07084790e-01f, -1.52731434e-01f, -2.20260680e-01f, -8.67924094e-02f,
  2.41922531e-02f, 1.76281437e-01f, 6.50399327e-02f, 1.90112993e-01f, 2.52012610e-01f, 2.06629023e-01f, -4.31829169e-02f, -5.99857047e-02f, 1.56216808e-02f, 4.20775674e-02f,
  2.56538361e-01f, 3.44441205e-01f, -4.87174802e-02f, 4.56166789e-02f, -2.77851503e-02f, -1.29713699e-01f, -2.22378090e-01f, -7.15421652e-03f, 1.11951176e-02f, 1.81367695e-02f,
  7.39549622e-02f, 2.04269990e-01f, 1.16020203e-01f, 8.28776285e-02f, -5.43834157e-02f, 1.09554745e-01f, 1.52213126e-01f, 2.39198785e-02f, -2.87991203e-02f, 1.28123939e-01f,
  -6.72500506e-02f, -8.28028694e-02f, 7.17449114e-02f, -9.61220413e-02f, -1.07910693e-01f, -5.03597334e-02f, -1.30430654e-01f, -4.80572283e-02f, 1.57540902e-01f, 6.83820397e-02f,
  -9.04180259e-02f, 1.88780278e-01f, -1.70390517e-01f, 4.37775403e-02f, -5.71582876e-02f, 1.62493717e-02f, 2.18746588e-02f, -6.17124364e-02f, -1.76181085e-02f, 8.09231121e-03f,
  1.10611431e-01f, 5.24960011e-02f, -1.57061890e-01f, -1.32009566e-01f, -2.69708306e-01f, -2.17028588e-01f, 1.19015723e-01f, -1.62414059e-01f, -8.99700597e-02f, -1.60177618e-01f,
  1.66406423e-01f, -9.06390101e-02f, 1.43527895e-01f, 9.33336765e-02f, 2.11756647e-01f, -1.92369908e-01f, -8.96914229e-02f, -1.70068666e-01f, -2.15439841e-01f, 2.02017352e-02f,
  2.57237375e-01f, 2.13667512e-01f, -1.58440974e-02f, -1.91478789e-01f, 6.55516237e-02f, 3.13619375e-01f, -1.07095219e-01f, 1.78124771e-01f, 4.83758524e-02f, 9.69241261e-01f,
  1.07397996e-01f, 1.56657696e-01f, -1.11267015e-01f, 7.48876408e-02f, -6.44060671e-02f, 1.46503747e-01f, 2.43838742e-01f, 1.19645149e-01f, -1.32088572e-01f, 3.33926715e-02f,
  3.47612277e-02f, 8.72916728e-02f, -7.59991780e-02f, -1.42936543e-01f, 1.24458462e-01f, -9.40999365e-04f, -3.21994722e-02f, 2.97874566e-02f, 1.02750532e-01f, -3.82401496e-02f,
  1.73810087e-02f, 5.24858534e-02f, -5.40326461e-02f, 5.66029735e-02f, 1.78319365e-01f, 2.14136261e-02f, -1.10310890e-01f, -9.36134160e-02f, -8.42488278e-03f, -6.64813221e-02f,
  -8.68663043e-02f, 1.09346528e-02f, -1.87688973e-02f, 1.01902135e-01f, 2.42636018e-02f, -1.08767353e-01f, -6.10404275e-02f, -7.72231966e-02f, 1.21724904e-01f, -7.01150000e-02f,
  9.58877355e-02f, -1.66942701e-02f, -5.37640862e-02f, -3.86004546e-03f, 3.61914709e-02f, -1.56842209e-02f, 5.09129912e-02f, 3.62161105e-03f, -3.17763947e-02f, -5.23603857e-02f,
  -5.50287589e-02f, -7.72632286e-02f, 5.70966154e-02f, -1.20813310e-01f, -6.50810525e-02f, 5.98786622e-02f, 6.53438047e-02f, -1.31015912e-01f, -6.14104904e-02f, -6.01743609e-02f,
  1.63886249e-02f, 5.91561384e-03f, 9.42393243e-02f, 1.07882544e-01f, 9.97562259e-02f, -1.63676348e-02f, -8.67310315e-02f, -7.55520761e-02f, -9.06959698e-02f, 5.00994772e-02f,
  -4.10871916e-02f, 4.73228060e-02f, 9.01288763e-02f, 5.55021167e-02f, -2.01616883e-02f, 7.28271753e-02f, 2.65192389e-02f, 4.53848243e-02f, -2.31247004e-02f, -8.83023068e-02f,
  -2.16085017e-02f, 8.61357450e-02f, -8.26368406e-02f, 3.96819860e-02f, -5.55951931e-02f, -3.46985161e-02f, 4.20227796e-02f, -6.88297376e-02f, -1.53345149e-02f, -1.06169529e-01f,
  3.08523457e-02f, 5.52331656e-02f, -1.08745784e-01f, -4.08594087e-02f, -3.24159153e-02f, 8.56022611e-02f, 1.35219440e-01f, -1.30387932e-01f, 5.12059666e-02f, -2.10029371e-02f,
  6.55124187e-02f, 1.31777138e-01f, 9.31983814e-02f, 1.61891788e-01f, 2.65852094e-01f, 3.46786603e-02f, 5.45418598e-02f, -1.06349394e-01f, -3.53527963e-02f, 9.29169431e-02f,
  8.71692076e-02f, -1.33492112e-01f, 1.54657856e-01f, -9.51071158e-02f, -8.70933533e-02f, 1.02615245e-01f, 6.03706129e-02f, 1.56052969e-02f, -1.37197539e-01f, -1.92904830e-01f,
  7.21730813e-02f, 1.61274880e-01f, -8.58634114e-02f, 3.84130329e-01f, 1.89572915e-01f, 4.52789441e-02f, 2.86793541e-02f, -1.17191389e-01f, 1.13779955e-01f, -4.71042953e-02f,
  1.90193623e-01f, -1.00617908e-01f, 1.13996491e-01f, 1.39944136e-01f, 2.29400247e-02f, 4.41007167e-02f, 9.15595423e-03f, -5.52150384e-02f, -2.63239086e-01f, 8.40918645e-02f,
  1.44759551e-01f, 2.23539509e-02f, 1.45155922e-01f, -1.72300506e-02f, 1.77250523e-02f, 7.66094774e-02f, -1.16172254e-01f, 4.86369133e-02f, 2.02195928e-01f, -2.49922890e-02f,
  -2.18229875e-01f, 5.09542078e-02f, 1.26407994e-02f, 1.79686561e-01f, 1.15643501e-01f, 1.29299546e-02f, -1.02909431e-02f, 4.43460941e-02f, 3.21914256e-02f, 6.67380393e-02f,
  4.06402610e-02f, -1.48157459e-02f, -4.63570356e-02f, 1.37524471e-01f, 2.28391625e-02f, 2.65461169e-02f, 2.51751710e-02f, 1.81460083e-02f, -1.76828593e-01f, 2.47357577e-01f,
  -1.32120177e-01f, 1.92084357e-01f, 7.66305029e-02f, -6.44110739e-02f, -1.45194113e-01f, -4.87051010e-02f, -9.79172960e-02f, 1.98765010e-01f, -6.72964975e-02f, 2.75562108e-01f,
  -4.57056761e-02f, 4.12247069e-02f, 1.59084350e-01f, -8.81894771e-03f, 1.46873057e-01f, -2.01379672e-01f, 2.56920662e-02f, 4.17122930e-01f, 1.24946721e-01f, -2.73576587e-01f,
  -1.90986469e-02f, -7.34474063e-01f, 3.92931476e-02f, 9.42011178e-02f, -1.90880261e-02f, 7.73746818e-02f, 2.21120387e-01f, 6.28060028e-02f, -1.22757545e-02f, 4.60970141e-02f,
  7.52181336e-02f, 2.31497616e-01f, 1.78876609e-01f, -1.00552879e-01f, 2.90956765e-01f, 2.89885849e-01f, 2.83425179e-04f, 1.45676687e-01f, 7.99050704e-02f, 1.19197257e-01f,
  -8.80895182e-02f, 6.29027188e-03f, -1.87158242e-01f, 1.52595788e-01f, 6.96288943e-02f, -1.24038912e-01f, -1.02713741e-01f, -1.22786008e-01f, -5.35103977e-02f, -1.05825253e-01f,
  -1.02749862e-01f, 7.43045658e-02f, -5.52541167e-02f, 7.61320367e-02f, -6.19017854e-02f, 7.35982656e-02f, -1.21719865e-02f, 2.12929919e-02f, -1.38477562e-02f, 4.93857004e-02f,
  9.71038789e-02f, 8.87273178e-02f, -9.57843289e-02f, 1.28165007e-01f, -5.60224354e-02f, -2.76205186e-02f, 8.74506012e-02f, 1.95784178e-02f, 8.35830867e-02f, -8.44069570e-03f,
  7.77901262e-02f, -7.47930110e-02f, -9.08328444e-02f, -9.96921211e-02f, 4.23659608e-02f, -1.11976318e-01f, 3.08368504e-02f, -2.03379542e-02f, -1.18586041e-01f, 3.92454267e-02f,
  1.02991410e-01f, 1.79523677e-02f, 8.29166453e-03f, 3.28939036e-02f, -5.19179702e-02f, 1.01246417e-01f, 6.25069067e-02f, 3.56723554e-02f, 2.28107278e-03f, 1.99021422e-03f,
  9.86973494e-02f, 5.67595102e-02f, -4.90545705e-02f, -1.24904409e-01f, 6.30957335e-02f, 4.97959889e-02f, 3.79190594e-02f, 7.20767677e-02f, 3.99441645e-03f, -1.06134273e-01f,
  -1.29501522e-01f, -6.41177148e-02f, 4.35540080e-03f, -2.38181651e-02f, -3.24328654e-02f, 1.20243495e-02f, -6.42986074e-02f, -1.08708091e-01f, 1.00064501e-01f, -8.39113258e-03f,
  9.20842439e-02f, -2.92432606e-02f, 5.41414358e-02f, 1.61548033e-01f, 4.31636348e-02f, 1.86438456e-01f, 1.17141940e-01f, 1.66790485e-01f, 8.21413994e-02f, -9.12359804e-02f,
  1.47520825e-01f, 1.28540114e-01f, 1.71075091e-01f, 7.89390728e-02f, 2.89390832e-01f, -5.54154068e-02f, 3.26186180e-01f, 2.93588668e-01f, 3.66822351e-03f, -1.38652474e-01f,
  -2.69382358e-01f, -1.15255050e-01f, -2.71420032e-01f, -9.32435393e-02f, 1.82075456e-01f, 1.72090933e-01f, -4.73560505e-02f, 1.42010361e-01f, -6.49544820e-02f, 2.26753637e-01f,
  1.01584233e-01f, -2.96091996e-02f, -1.48352057e-01f, -1.66184038e-01f, 1.39832437e-01f, 6.35028183e-01f, -1.37990594e-01f, -1.92132369e-02f, -2.89783091e-03f, -2.87452251e-01f,
  -2.03930035e-01f, -2.53522508e-02f, 1.67519093e-01f, 1.18500724e-01f, 2.36328989e-01f, 2.92472243e-01f, 1.65233180e-01f, 8.29765275e-02f, -9.92210656e-02f, -4.57397588e-02f,
  -1.31901735e-02f, -6.67055398e-02f, 2.23343790e-01f, 1.19775988e-01f, 3.16643268e-02f, -1.76524535e-01f, -9.07293633e-02f, 5.71692176e-02f, -4.18215245e-02f, -9.51016396e-02f,
  -8.30194131e-02f, 2.73362935e-01f, 1.12969175e-01f, 3.07852417e-01f, 2.02008337e-01f, -5.12753474e-03f, 6.66492805e-03f, 1.04160188e-02f, -1.15720555e-01f, -4.59995903e-02f,
  1.25632748e-01f, 1.20142356e-01f, -1.33486837e-01f, 1.02321871e-01f, -5.14586121e-02f, 1.11570522e-01f, 1.08332366e-01f, 9.15006176e-02f, 4.56863875e-03f, 2.05446348e-01f,
  5.92043847e-02f, -1.30458459e-01f, 2.40670860e-01f, -5.49143553e-02f, -1.27859309e-01f, -1.30213663e-01f, -1.09892249e-01f, -1.19847320e-01f, 2.55314130e-02f, -3.01268488e-01f,
  -8.99539739e-02f, -1.15763277e-01f, 1.82465076e-01f, 1.10708840e-01f, -1.28972381e-01f, -2.29927257e-01f, -1.09269008e-01f, 4.15779129e-02f, 9.02242884e-02f, -7.19556585e-03f,
  1.25715896e-01f, 1.11492865e-01f, 2.16428768e-02f, 2.27795541e-01f, -2.57601924e-02f, -4.27450798e-02f, 1.73295364e-01f, 8.94954875e-02f, 1.02202803e-01f, 1.21701479e-01f,
  1.43894836e-01f, -1.22483738e-01f, 6.52073771e-02f, -8.70339274e-02f, -9.04565975e-02f, -3.22066322e-02f, 7.12587610e-02f, -1.10376291e-01f, 9.04730111e-02f, 8.32192972e-03f,
  1.01750389e-01f, -7.18207583e-02f, -1.42699420e-01f, -7.69256055e-03f, 2.81551778e-01f, -1.92923129e-01f, -1.25089839e-01f, 1.28094211e-01f, 2.02926114e-01f, 2.09907129e-01f,
  4.55120392e-02f, 1.19367793e-01f, -6.05084188e-02f, -3.21466811e-02f, 1.27070814e-01f, 3.65678817e-02f, 3.23629119e-02f, 2.32892521e-02f, 3.75182703e-02f, 1.73272807e-02f,
  -1.17712229e-01f, -7.05523342e-02f, -1.98001757e-01f, 1.43616334e-01f, -2.84090221e-01f, -2.43237674e-01f, 6.63732812e-02f, 1.15780570e-01f, -4.60021384e-02f, 2.88363919e-02f,
  1.89631477e-01f, -5.17763644e-02f, -7.25904107e-02f, -1.50621623e-01f, 2.78604869e-02f, -1.75055370e-01f, 1.83262214e-01f, 1.83703706e-01f, 2.96971440e-01f, -1.30150607e-02f,
  -4.44106124e-02f, -3.74072650e-03f, 5.60263395e-02f, -3.17468882e-01f, 7.84591809e-02f, 2.62070537e-01f, 2.37375483e-01f, 9.20917273e-01f, -1.11471154e-02f, 2.16714531e-01f,
  -1.50323426e-02f, 9.03604403e-02f, 1.06999815e-01f, -8.53703097e-02f, 7.89006650e-02f, 1.53821722e-01f, -4.48007174e-02f, -5.50835356e-02f, 1.78324252e-01f, 9.02855396e-03f,
  -1.83406040e-01f, -2.58408099e-01f, -2.88404170e-02f, 1.32689089e-01f, -1.10284209e-01f, 1.01328753e-01f, 1.92010537e-01f, -3.85902449e-02f, 3.83401103e-02f, 1.70620665e-01f,
  4.70857397e-02f, 1.19199336e-01f, 1.73312590e-01f, 3.48901264e-02f, 7.62409121e-02f, -4.77634892e-02f, -3.86177860e-02f, 5.81344552e-02f, -3.49808447e-02f, -3.53902467e-02f,
  -1.11434251e-01f, 9.37740877e-02f, 7.00815320e-02f, -2.49979366e-02f, -1.69665776e-02f, -9.81530547e-03f, 1.98967427e-01f, 1.18510880e-01f, -1.87418252e-01f, 1.64528057e-01f,
  7.61408508e-02f, 2.15218261e-01f, 3.02812546e-01f, -1.05680823e-01f, -1.96542397e-01f, -5.90809733e-02f, -6.17598854e-02f, 2.08788559e-01f, 1.15326792e-02f, 1.21242620e-01f,
  2.72271130e-02f, -2.95263473e-02f, -2.27579072e-01f, -1.11586809e-01f, -5.71187064e-02f, 1.01429202e-01f, 1.05584497e-02f, 4.90464091e-01f, 5.34762442e-02f, -3.30612034e-01f,
  -1.14146613e-01f, -1.13537526e+00f, 6.28912449e-02f, -2.27217883e-01f, 2.54073590e-01f, 3.54475044e-02f, 1.31500959e-01f, 1.73769277e-02f, -1.92530617e-01f, -1.19192064e-01f,
  1.92101508e-01f, 1.96813688e-01f, -9.00900811e-02f, -1.02970496e-01f, 3.38455468e-01f, 2.33650178e-01f, 4.50398363e-02f, -7.81343728e-02f, -9.68749821e-03f, 5.30547872e-02f,
  6.40633553e-02f, -3.67634073e-02f, 7.66905919e-02f, 3.27266566e-02f, 9.79375988e-02f, -3.98144387e-02f, 2.26738192e-02f, -1.84819907e-01f, -2.84185316e-02f, -1.60677105e-01f,
  -2.59157181e-01f, -2.86891460e-01f, -1.20277829e-01f, -1.93694964e-01f, -5.13317175e-02f, -4.99207638e-02f, 6.03514686e-02f, -4.36620638e-02f, -2.98516810e-01f, -2.71798939e-01f,
  1.49141908e-01f, -1.08388491e-01f, -1.14474468e-01f, -6.48268759e-02f, -1.55445680e-01f, 2.17127930e-02f, 4.47614580e-01f, -7.20941788e-03f, 3.59568037e-02f, -4.18344215e-02f,
  -3.96443531e-02f, 2.24054493e-02f, -4.74973731e-02f, 1.18162110e-02f, 2.67954081e-01f, -1.45527553e-02f, 4.00138982e-02f, 9.42000225e-02f, 7.96695426e-02f, 1.43628791e-01f,
  5.02951220e-02f, -6.71025589e-02f, -1.58783063e-01f, -1.23905875e-02f, 1.34156987e-01f, 1.08495796e+00f, -2.08555311e-01f, 1.78766847e-01f, 8.68936628e-02f, 5.40734691e-05f,
  -1.27045035e-01f, -8.96225795e-02f, -4.25290922e-03f, 7.93941393e-02f, -6.16367683e-02f, 1.16764143e-01f, 1.84674427e-01f, -1.12551063e-01f, 1.12566380e-02f, 1.49508774e-01f,
  -2.09878981e-01f, -3.82782035e-02f, 6.62509352e-02f, 4.89674956e-02f, 1.76679716e-01f, -3.03523540e-02f, -1.22079805e-01f, 1.08984686e-01f, 4.93519306e-02f, 1.21936455e-01f,
  -6.21410422e-02f, -2.08896678e-02f, -2.32810751e-01f, -2.09412500e-02f, 1.22588634e-01f, 7.45170116e-02f, -5.16459532e-03f, -4.21128832e-02f, 1.34016216e-01f, 1.00451812e-01f,
  1.21299483e-01f, 1.05160158e-02f, -7.24629834e-02f, 8.10872614e-02f, -2.42952093e-01f, 1.23303972e-01f, -9.88715738e-02f, -2.65134007e-01f, 2.24566922e-01f, 9.42563545e-03f,
  -1.29233390e-01f, -2.27763988e-02f, 1.60564005e-01f, 3.03134650e-01f, 1.37585327e-01f, -1.46695465e-01f, -1.14464886e-01f, -1.07909471e-01f, 2.16015745e-02f, -2.08646864e-01f,
  2.23394744e-02f, 2.22393781e-01f, 3.83493379e-02f, 1.13563174e-02f, -1.31468937e-01f, -1.71474796e-02f, 2.01928586e-01f, 9.07244608e-02f, 5.18136658e-02f, 4.72924650e-01f,
  2.53971010e-01f, -1.10243373e-01f, 1.03857201e-02f, 1.19808555e-01f, -1.21949129e-01f, 7.22948313e-02f, 1.27415285e-01f, 1.16108738e-01f, 1.15620479e-01f, 1.96435586e-01f,
  1.13794155e-01f, -5.95334284e-02f, 5.82567230e-03f, -1.12033956e-01f, 1.77315548e-01f, 2.41026103e-01f, 1.17279924e-02f, -7.34276772e-02f, 2.29856178e-01f, 8.42942894e-02f,
  1.44754246e-01f, 1.49393797e-01f, -2.23848112e-02f, -9.35896114e-02f, 1.11180646e-02f, -1.36298612e-01f, 1.00109681e-01f, -1.44096181e-01f, -2.84592569e-01f, -3.09376996e-02f,
  -3.76534760e-02f, -3.25823724e-01f, -1.11953102e-01f, 2.20555246e-01f, 7.67930597e-02f, -2.59962112e-01f, -9.44333598e-02f, -1.05778053e-01f, -8.71748291e-03f, -1.69100657e-01f,
  -1.06315054e-01f, -1.81760058e-01f, 2.86814081e-03f, 1.58113480e-01f, 2.14586705e-01f, 1.31174535e-01f, 2.22484440e-01f, -1.06168531e-01f, -1.43481255e-01f, -4.93582338e-02f,
  6.39557317e-02f, 1.20649664e-02f, 2.22468257e-01f, -3.61032449e-02f, -1.53602317e-01f, -1.66012004e-01f, 2.65881866e-01f, 2.89452046e-01f, 2.25161225e-01f, -8.00429940e-01f,
  1.25706598e-01f, 1.85662240e-01f, 3.68489958e-02f, 5.94316483e-01f, 1.25653043e-01f, -3.21730156e-03f, 1.15008034e-01f, 1.72439530e-01f, -1.09416403e-01f, 7.64329061e-02f,
  -2.67780107e-03f, -1.12781577e-01f, 7.68046081e-02f, 1.53387219e-01f, 1.25981763e-01f, 4.51677665e-02f, -7.97973573e-02f, -6.27640784e-02f, 4.33797948e-02f, 5.72866946e-02f,
  -3.71682160e-02f, -4.44351733e-02f, 1.62672877e-01f, -5.88194653e-02f, 2.88590819e-01f, -1.79039583e-01f, 2.18433559e-01f, 8.75615627e-02f, -1.33204654e-01f, 3.20957899e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  1.81301275e-05f, -2.23967843e-02f, 1.03479661e-01f, 1.63180381e-01f, 4.42082584e-02f, -8.88732634e-03f, -2.27027927e-02f, 9.09212157e-02f, -8.82252008e-02f, 1.48263210e-02f,
  -1.86692718e-02f, 3.27254422e-02f, 9.89378691e-02f, -8.90112892e-02f, 8.89446288e-02f, 1.05433606e-01f, 5.20164296e-02f, -1.59650892e-02f, 4.00138367e-03f, -5.96967153e-02f,
  -8.80154595e-02f, 1.05240010e-01f, -8.74641761e-02f, -6.61982000e-02f, -1.29033700e-01f, -8.26930162e-03f, 9.11704823e-02f, -7.13433251e-02f, -6.93750754e-02f, 7.24171326e-02f,
  -9.35559049e-02f, 1.21367902e-01f, -1.00383379e-01f, -1.47073623e-02f, 1.58306345e-01f, 1.43005461e-01f, -8.84748548e-02f, -8.20745006e-02f, 2.32776124e-02f, -7.04483464e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.63576528e-01f, 4.18763496e-02f, 7.88755119e-02f, -1.50067240e-01f, -5.85664399e-02f, -5.44556975e-02f, -4.29174602e-02f, 5.62789068e-02f, 6.92866445e-02f, -1.01712257e-01f,
  -1.02411345e-01f, 2.86267009e-02f, -2.08068993e-02f, -2.78859526e-01f, -2.62292385e-01f, -1.40606850e-01f, 2.20828727e-01f, -7.92392902e-03f, -2.98098475e-01f, -3.57219055e-02f,
  -1.28608465e-01f, 9.12840217e-02f, -1.73238695e-01f, 9.66916829e-02f, -2.11043909e-01f, 2.37742469e-01f, 1.81026787e-01f, -2.06666037e-01f, 1.71836197e-01f, -1.73470020e-01f,
  -1.11668222e-01f, -3.29395868e-02f, -2.55913008e-02f, -6.90966472e-02f, -1.17657455e-02f, -1.11561321e-01f, -1.42447621e-01f, -1.18499771e-01f, 6.35534972e-02f, 2.11529225e-01f,
  -2.02123061e-01f, -9.75388363e-02f, 7.95588270e-02f, 1.18591793e-01f, 1.67692769e-02f, 1.43849161e-02f, 5.88230677e-02f, 4.89650555e-02f, 1.79518446e-01f, 2.31870174e-01f,
  1.15176262e-02f, -6.00881036e-03f, 3.32796834e-02f, 5.57212718e-02f, -1.54175669e-01f, 1.01905920e-01f, -1.18242443e-01f, 9.34882015e-02f, -1.68183744e-01f, -7.21241683e-02f,
  -6.50410308e-03f, 5.17827943e-02f, -1.58360526e-01f, -4.45666701e-01f, -1.28020763e-01f, -8.71879086e-02f, -9.65252370e-02f, -1.18617266e-01f, -4.63375971e-02f, 8.58410373e-02f,
  -1.34960264e-02f, 1.88665852e-01f, 4.67118584e-02f, -1.41056299e-01f, 1.90790117e-01f, -5.79378717e-02f, 3.09639890e-02f, 2.51504004e-01f, -1.71045110e-01f, 2.58077271e-02f,
  -2.67057568e-01f, -1.14032641e-01f, 1.85951650e-01f, -1.19783282e-01f, -2.30033457e-01f, 1.82300657e-02f, 6.84769675e-02f, 3.32804769e-02f, 1.97445139e-01f, 1.76553473e-01f,
  -1.35488749e-01f, -2.04640299e-01f, -7.14273527e-02f, -1.21053927e-01f, -1.22365884e-01f, -1.80245548e-01f, -1.75146181e-02f, 3.45171988e-02f, -3.38280648e-01f, -7.60394707e-02f,
  -1.53445497e-01f, 2.79122233e-01f, 1.61470473e-01f, 1.10444248e-01f, -2.11279485e-02f, -1.81881994e-01f, 7.34644160e-02f, 7.44637102e-02f, 5.53357042e-02f, 1.13762394e-01f,
  -1.07140414e-01f, -1.40060261e-01f, 1.98002249e-01f, -1.25816846e-02f, 1.94094256e-02f, 1.54850662e-01f, -2.63508558e-01f, 9.87453982e-02f, -2.21406102e-01f, 3.79612856e-02f,
  -1.11562818e-01f, -2.17341371e-02f, -1.09222084e-01f, 2.03999244e-02f, 2.57672183e-02f, 2.12106973e-01f, -1.87376678e-01f, 1.01068309e-02f, 1.04778409e-01f, -1.29029647e-01f,
  9.26576853e-02f, 1.41920328e-01f, 1.41424105e-01f, -6.08880259e-02f, 1.85164697e-02f, 7.45255649e-02f, 6.95513636e-02f, 6.45823628e-02f, -8.75828117e-02f, -8.74473527e-02f,
  -1.72319561e-01f, 6.87908530e-02f, -3.04452449e-01f, 2.66046822e-01f, 1.18567251e-01f, -1.27259120e-01f, 4.24003154e-02f, -1.27762809e-01f, -2.06338242e-01f, 1.16205504e-02f,
  -1.79592758e-01f, 2.32988670e-02f, -8.34003389e-02f, -2.13645458e-01f, -3.45005989e-01f, -2.89781213e-01f, -2.98019677e-01f, -1.52867272e-01f, -4.74073105e-02f, -1.79402813e-01f,
  -7.79576525e-02f, -8.84326100e-02f, 6.72932714e-02f, 1.45256311e-01f, -4.65196483e-02f, 2.38860995e-02f, -2.46037468e-01f, -7.97529798e-03f, 1.04206085e-01f, 2.51974583e-01f,
  1.72854424e-01f, 2.11043525e-02f, -8.29110518e-02f, -1.14110939e-01f, -5.13561741e-02f, -3.49729866e-01f, 1.27219722e-01f, -4.01336819e-01f, 2.89410889e-01f, 5.95128499e-02f,
  -2.29557455e-01f, 8.99834745e-03f, -9.27146822e-02f, 8.18626955e-02f, 4.02067713e-02f, -7.49117360e-02f, -6.98034093e-03f, -2.86576927e-01f, 2.14595214e-01f, 2.35632733e-02f,
  -1.24491349e-01f, 2.13224292e-02f, -2.57364474e-03f, -5.87836700e-03f, -1.49327770e-01f, -1.90226555e-01f, 1.26428427e-02f, -1.13801442e-01f, 1.31975308e-01f, 7.85290822e-02f,
  -1.50728421e-02f, -1.43974632e-01f, -8.25702995e-02f, -9.68152732e-02f, 3.15630510e-02f, -1.23431414e-01f, 5.36764599e-02f, -8.21020752e-02f, 5.60431555e-02f, 1.57701835e-01f,
  -6.81877434e-02f, 1.51914954e-01f, 2.39340037e-01f, -1.43117994e-01f, -4.36989814e-02f, -7.67197534e-02f, -3.25150579e-01f, -2.62411535e-01f, -4.68075424e-02f, 2.05973506e-01f,
  6.95459545e-02f, 1.72330439e-01f, -3.59318815e-02f, -1.07433731e-02f, -3.35600935e-02f, 5.80104589e-02f, -2.14218304e-01f, -3.66685808e-01f, -2.59719133e-01f, -1.97145924e-01f,
  -7.06907362e-02f, 1.04614332e-01f, -3.06054413e-01f, -2.13548001e-02f, -3.43143672e-01f, -3.00757796e-01f, -1.62161943e-02f, 4.48663682e-02f, 8.06797761e-03f, 4.32135388e-02f,
  -1.02946907e-01f, -1.92353293e-01f, 6.35911599e-02f, 1.04206838e-01f, 2.02732325e-01f, 5.42393513e-02f, -1.07461907e-01f, -8.40487331e-02f, -5.46553917e-02f, 5.25593832e-02f,
  2.99427379e-02f, 1.82000011e-01f, -1.03795985e-02f, 1.07648864e-01f, -1.68686762e-01f, 2.16170680e-03f, 1.34123191e-01f, -3.88257578e-02f, 8.78020078e-02f, 7.01894164e-02f,
  -6.74700513e-02f, 1.84224084e-01f, 5.20971082e-02f, 1.62900165e-02f, 8.25099796e-02f, 6.97373375e-02f, -1.63641833e-02f, 8.12213719e-02f, -9.63614136e-02f, -7.66133368e-02f,
  1.16435051e-01f, 1.46188676e-01f, 1.82279814e-02f, 1.38884023e-01f, -1.45336136e-01f, -1.65022850e-01f, -7.46936351e-02f, -2.34356955e-01f, -7.96329677e-02f, 3.34250510e-01f,
  -3.26987088e-01f, -8.13592225e-02f, -1.84230149e-01f, 1.96718261e-01f, 5.01235202e-03f, -1.57144293e-01f, -1.20949022e-01f, 4.76355888e-02f, -6.96670860e-02f, -1.29539102e-01f,
  2.64271855e-01f, -8.96718279e-02f, 3.54613177e-02f, -2.85873622e-01f, 1.11982174e-01f, 4.20147553e-02f, -1.86012145e-02f, -3.25787030e-02f, -1.60351127e-01f, -2.84565389e-01f,
  -8.52642208e-02f, 1.32678881e-01f, 4.22095060e-02f, 1.63320631e-01f, -2.40753233e-01f, -1.15005888e-01f, -1.12718508e-01f, 7.98278227e-02f, -7.63818249e-02f, 2.84145419e-02f,
  1.61116764e-01f, -8.36145207e-02f, 8.19911286e-02f, 2.14177191e-01f, 2.14182571e-01f, -2.70790756e-02f, -1.08369417e-01f, -4.15440291e-01f, -1.62796781e-03f, -4.74462181e-01f,
  1.31351143e-01f, -4.30748425e-02f, -5.04347794e-02f, 1.67529032e-01f, 6.72324076e-02f, 8.65654051e-02f, 5.38590644e-03f, -1.41641185e-01f, 1.35935992e-01f, -1.47282660e-01f,
  -5.61559647e-02f, 8.27462748e-02f, -1.16730779e-01f, 3.35154459e-02f, 1.59844816e-01f, -1.77850872e-01f, 7.97605887e-02f, -2.73103803e-01f, 9.24822390e-02f, 1.35252982e-01f,
  -4.84629162e-02f, -4.51875031e-02f, 4.45672683e-02f, 3.35929473e-03f, 2.37024561e-01f, -2.52502054e-01f, 9.42580029e-02f, 3.14091593e-02f, 7.92204514e-02f, 1.27623498e-01f,
  -1.28550101e-02f, 5.31983450e-02f, 5.05358726e-02f, 1.05591439e-01f, -1.53601736e-01f, 6.71443790e-02f, 6.79943128e-04f, 4.99814041e-02f, 1.08419262e-01f, -7.20439032e-02f,
  1.91047952e-01f, -2.34359905e-01f, 1.81994662e-01f, 2.89140698e-02f, -6.25798926e-02f, -1.14866056e-01f, 1.13465963e-02f, -1.07525200e-01f, -1.27571657e-01f, -8.97470117e-02f,
  -3.26659232e-01f, 6.94069965e-03f, 5.85481189e-02f, -4.64096032e-02f, -2.89430231e-01f, 1.05522454e-01f, 2.36167461e-02f, -9.25171897e-02f, -2.91581452e-01f, 8.89001563e-02f,
  -2.50355721e-01f, -6.82255626e-02f, 6.93745390e-02f, -1.07502252e-01f, 1.34548083e-01f, -4.82184961e-02f, -1.31368056e-01f, -1.19373374e-01f, 2.53997594e-02f, 9.40780044e-02f,
  -8.10767710e-02f, -1.06132412e-02f, 9.94402692e-02f, -1.19884172e-02f, -1.05527960e-01f, -5.16566262e-02f, 3.24043363e-01f, 2.06180915e-01f, 1.16626322e-01f, 2.51043886e-01f,
  1.45623311e-01f, -1.17700458e-01f, 1.58700094e-01f, 7.69355521e-02f, 2.66427487e-01f, 1.45616814e-01f, 2.37666950e-01f, 7.62458593e-02f, 1.47821054e-01f, -2.09886074e-01f,
  -2.20430806e-01f, -8.01568329e-02f, -2.58670866e-01f, -3.05663645e-01f, -1.02898382e-01f, 1.62881494e-01f, 2.21762620e-03f, 2.04429720e-02f, 1.99270174e-01f, 1.73483267e-01f,
  2.70555988e-02f, -3.15180719e-02f, -1.03914097e-01f, -4.27942932e-01f, 2.08272487e-01f, -5.52781448e-02f, 1.57801762e-01f, -3.36953215e-02f, -6.10273853e-02f, -2.38746166e-01f,
  -7.67616332e-02f, -3.25685680e-01f, -1.14436746e-01f, -8.90303701e-02f, -2.47627646e-01f, -2.05528259e-01f, -2.81271696e-01f, -3.22324522e-02f, 5.71446866e-02f, 2.11010557e-02f,
  6.12438060e-02f, -3.05408597e-01f, -2.45827641e-02f, -1.28286883e-01f, 1.29708067e-01f, -2.17488647e-01f, 9.27328169e-02f, 1.30713373e-01f, 8.70552808e-02f, 1.03265248e-01f,
  5.93938679e-02f, -1.58747211e-01f, -1.42829278e-02f, 5.76306656e-02f, 1.27200857e-01f, -8.17708373e-02f, -1.01686805e-01f, 1.01919740e-01f, -8.34021345e-02f, 7.12956563e-02f,
  -5.03426567e-02f, -1.28201962e-01f, 3.68622430e-02f, 5.16646579e-02f, -2.47116275e-02f, -9.00638569e-03f, -3.45175602e-02f, 7.94012249e-02f, 9.01310518e-02f, -1.37613729e-01f,
  1.31505862e-01f, -1.48982048e-01f, -1.62084430e-01f, -2.23009139e-01f, 1.56032607e-01f, -1.31600797e-01f, 8.64959732e-02f, 1.94889158e-01f, -7.00168684e-02f, 2.08368152e-01f,
  8.27112049e-02f, -7.44975805e-02f, -3.18855405e-01f, -2.81694710e-01f, -4.02344577e-03f, -2.33860001e-01f, 2.23704949e-02f, -1.50805146e-01f, 9.64936614e-02f, -3.11762005e-01f,
  -2.73619235e-01f, 1.00126140e-01f, -1.28782853e-01f, -4.79300469e-02f, 7.62711093e-02f, 6.91977935e-03f, 2.02300340e-01f, -9.09574032e-02f, -2.38354966e-01f, -2.51012117e-01f,
  2.21313715e-01f, -8.44761878e-02f, -2.90798336e-01f, -1.76394120e-01f, -4.43724394e-02f, 3.38003486e-02f, -1.85100183e-01f, 3.06997634e-02f, -1.73045337e-01f, 5.96337728e-02f,
  2.36147419e-01f, -2.37377629e-01f, 6.66026771e-02f, -9.51987728e-02f, 5.84543496e-02f, -1.11947760e-01f, 6.99181557e-02f, 1.14155367e-01f, 3.77511457e-02f, -1.46529004e-01f,
  -9.79607552e-02f, -3.53186652e-02f, -1.54282495e-01f, -1.33903503e-01f, 2.01482341e-01f, 9.24307108e-02f, 7.15796202e-02f, -8.36582631e-02f, -2.12107331e-01f, 1.62101313e-01f,
  4.00472470e-02f, 1.09974295e-01f, 1.07086107e-01f, 1.03322141e-01f, 3.96084040e-02f, -3.02827433e-02f, 1.22320861e-01f, -1.80526733e-01f, 1.54273510e-01f, 1.15667343e-01f,
  -2.81736672e-01f, 1.70450449e-01f, 1.04024082e-01f, -1.31515292e-02f, 6.05901815e-02f, -8.17523990e-03f, -2.78087974e-01f, 1.88996643e-01f, -2.82496631e-01f, 4.93986271e-02f,
  -5.79126514e-02f, -1.12569526e-01f, -2.34839544e-01f, 7.07812980e-02f, -1.30053252e-01f, 1.46415889e-01f, -1.13344423e-01f, -2.02447787e-01f, -4.95853880e-03f, -5.50198965e-02f,
  1.43967181e-01f, 4.66617383e-02f, 1.45974934e-01f, -1.25426902e-02f, -1.08935080e-01f, -1.33726478e-01f, 1.25766829e-01f, -2.25505978e-01f, -4.09385897e-02f, -2.59023964e-01f,
  -9.95856375e-02f, -2.85048853e-03f, -2.02090785e-01f, 1.79135337e-01f, 9.17545334e-02f, 1.28155664e-01f, 4.03279886e-02f, -8.32785107e-03f, 1.40743166e-01f, -1.22828009e-02f,
  -1.24799341e-01f, -4.62264195e-02f, 1.62253365e-01f, 1.49962485e-01f, 1.14272036e-01f, -8.07130411e-02f, 1.11678421e-01f, -8.50728750e-02f, -2.22278595e-01f, -1.59988120e-01f,
  3.97935472e-02f, 1.31853968e-01f, 8.03158432e-02f, -3.07717584e-02f, -3.39192092e-01f, -1.94856644e-01f, -8.02611336e-02f, 1.69464722e-01f, -3.01936418e-01f, -5.95088340e-02f,
  -1.25856012e-01f, -1.48977250e-01f, 1.39608132e-02f, -2.92964876e-01f, 1.19710714e-01f, -1.63773179e-01f, 2.01686380e-05f, 1.06189094e-01f, 9.83938128e-02f, -6.85655251e-02f,
  1.66325748e-01f, -7.72197843e-02f, 2.17098027e-01f, -1.72890455e-01f, -2.41233975e-01f, -1.45103335e-01f, 2.40916893e-01f, 1.03094667e-01f, -6.75819218e-02f, -2.04757437e-01f,
  -1.09811082e-01f, -1.93907484e-01f, -4.76509482e-02f, -2.42102474e-01f, -1.10228851e-01f, -1.98457628e-01f, -2.22795442e-01f, 1.03776760e-01f, -1.24372303e-01f, -4.18560505e-02f,
  2.64827292e-02f, 1.23783395e-01f, -1.19950242e-01f, 9.39041302e-02f, -1.50948524e-01f, -1.55293807e-01f, 2.23236203e-01f, -1.49895221e-01f, 6.17238414e-03f, -3.13849717e-01f,
  -1.12567367e-02f, 1.66511208e-01f, 1.15244076e-01f, 3.78110819e-02f, 1.13695420e-01f, 6.65202644e-03f, 3.91330533e-02f, 1.76970903e-02f, 1.06530838e-01f, 1.24932388e-02f,
  5.40991351e-02f, 1.59112960e-02f, -1.45459503e-01f, -2.77824625e-02f, 1.69135444e-02f, -6.29583597e-02f, -2.43006364e-01f, 2.28789940e-01f, 1.95261151e-01f, -2.65139222e-01f,
  -9.90376472e-02f, -1.87668011e-01f, -5.22374399e-02f, -1.99963108e-01f, 2.18554605e-02f, 1.61998272e-01f, -2.70632386e-01f, 1.67584732e-01f, 1.83137847e-04f, 3.17514427e-02f,
  6.05734847e-02f, -3.12989742e-01f, 9.41821933e-03f, -2.21845997e-03f, 8.89241137e-03f, -5.40537499e-02f, -3.54886174e-01f, -1.46456957e-02f, 1.10039636e-01f, 1.79794028e-01f,
  -3.49656820e-01f, 1.39420450e-01f, -1.27398819e-01f, -1.08239256e-01f, 3.18645723e-02f, 1.93252042e-01f, -6.61531389e-02f, -1.42969992e-02f, -8.27220529e-02f, -1.14031032e-01f,
  2.11406201e-01f, -5.59254363e-03f, -5.55187277e-02f, -1.14816137e-01f, 1.92235023e-01f, -1.92938820e-01f, 5.90257049e-02f, 1.24867335e-01f, 6.35563955e-02f, -1.22581124e-01f,
  -6.10479452e-02f, -3.08616877e-01f, -1.99889407e-01f, 5.43423854e-02f, -2.11722441e-02f, 1.48318961e-01f, -2.76569230e-03f, 1.59426525e-01f, 5.37255183e-02f, 7.49689266e-02f,
  -1.44540682e-01f, 7.70180970e-02f, -1.53716803e-01f, 1.53864056e-01f, -1.77933052e-01f, 1.10930100e-01f, 2.31430009e-01f, 2.14598775e-01f, -1.19892016e-01f, 1.97097659e-01f,
  1.21482983e-02f, 2.46772677e-01f, 7.25110099e-02f, 2.07625359e-01f, 1.15686156e-01f, -1.66529968e-01f, 1.88683704e-01f, -1.70296118e-01f, -1.79684266e-01f, -1.09254636e-01f,
  3.73522453e-02f, 1.36583626e-01f, -7.51097500e-02f, 2.18010377e-02f, 6.48408756e-02f, 1.66539997e-01f, 2.45255139e-02f, -8.92318040e-02f, 2.07157329e-01f, 1.97572991e-01f,
  -8.16348344e-02f, -2.88847625e-01f, -1.67391166e-01f, -2.22372025e-01f, -1.16591193e-01f, 4.54176553e-02f, 4.36617993e-02f, -3.71714085e-01f, 7.56405145e-02f, -1.22890964e-01f,
  7.62332678e-02f, 8.32977742e-02f, -2.53135949e-01f, -1.90273106e-01f, -1.15379617e-01f, -1.95331722e-01f, -1.16324369e-02f, -6.22284263e-02f, -1.16597069e-02f, -2.61242032e-01f,
  -5.37527911e-02f, -2.47424155e-01f, 1.53821871e-01f, 1.99708045e-01f, -2.15280265e-01f, -2.94115275e-01f, 2.28633985e-01f, -7.40272924e-03f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.19566187e-01f, -6.53598085e-02f, 2.01655347e-02f, -7.05346465e-02f, -7.74085596e-02f, 7.42427632e-02f, 7.38840103e-02f, -5.52538522e-02f, 1.43704489e-02f, -1.17268622e-01f,
  1.25398263e-01f, -4.78522405e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    