/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.67348403e-01f, -2.08776325e-01f, 3.25064003e-01f, -2.46531963e-01f, -6.46413937e-02f, 3.62212867e-01f, 3.08410108e-01f, 6.89097643e-02f, -1.84817463e-01f, -8.08382034e-02f,
  -9.48568210e-02f, -2.69119978e-01f, -9.92677808e-02f, -3.11574619e-02f, 2.16720358e-01f, 8.27717707e-02f, -2.12777145e-02f, 2.20360965e-01f, 3.19544584e-01f, 1.06399551e-01f,
  -1.43507197e-01f, -6.32704124e-02f, 8.36077332e-03f, -1.23701632e-01f, -3.15193266e-01f, -2.75269568e-01f, -9.57833976e-02f, -7.93214217e-02f, -1.58004975e-03f, -2.83430398e-01f,
  2.56190658e-01f, 6.52462058e-03f, 7.44245853e-03f, -2.22248390e-01f, -1.31587699e-01f, -3.19115482e-02f, 2.25119380e-04f, -1.42019272e-01f, -1.22631997e-01f, -2.61513423e-02f,
  -8.05383325e-02f, -7.90953189e-02f, -1.24798842e-01f, -1.09319597e-01f, -3.54654603e-02f, 5.75685129e-02f, -9.61671993e-02f, -3.59768048e-02f, -6.85791299e-02f, -5.82661815e-02f,
  -1.82054505e-01f, 4.95589897e-03f, 1.29996523e-01f, -7.76421977e-03f, 1.85802244e-02f, 3.24302576e-02f, -9.45919752e-03f, 2.50775777e-02f, -2.86039636e-02f, -1.08309634e-01f,
  1.41256303e-02f, -6.02204911e-02f, -8.08993354e-02f, -4.83709127e-02f, -4.60446924e-02f, -6.70817196e-02f, 1.25022447e-02f, -5.72320223e-02f, 1.48215163e-02f, -3.26709412e-02f,
  -6.86458498e-02f, 3.13158408e-02f, -8.17182660e-03f, -3.07573844e-02f, -1.12975806e-01f, 2.31558923e-02f, 4.58006449e-02f, -4.35186699e-02f, 6.13455568e-03f, -7.61485994e-02f,
  -1.41322305e-02f, 2.12277398e-02f, -2.84888241e-02f, -6.65361732e-02f, -2.71223411e-02f, -2.54533086e-02f, -6.19037449e-03f, -3.31840776e-02f, -7.29253367e-02f, -1.79597754e-02f,
  -3.31813022e-02f, 1.93007171e-01f, 2.41678040e-02f, -7.38983080e-02f, -5.69052696e-02f, -7.60956556e-02f, -8.15473571e-02f, -5.23361489e-02f, -3.39760669e-02f, -4.14342340e-03f,
  4.03880812e-02f, 5.22749834e-02f, -6.86911345e-02f, -4.05612737e-02f, 7.81810880e-02f, 4.84734122e-03f, -6.90711737e-02f, -6.12834208e-02f, 2.44657136e-02f, -1.10363021e-01f,
  -7.00041652e-02f, 1.08458951e-01f, 1.97016716e-01f, 1.67622920e-02f, -2.15178579e-02f, 6.80226758e-02f, 3.83711644e-02f, 9.13827792e-02f, 1.68664306e-01f, 6.65080696e-02f,
  -7.22945094e-01f, -4.43615228e-01f, -1.15855284e-01f, -9.55650136e-02f, 3.67066652e-01f, 2.31505349e-01f, 2.17935275e-02f, -2.46259067e-02f, 1.80178642e-01f, -5.71450070e-02f,
  5.67990402e-03f, 2.92409752e-02f, -9.66363400e-02f, 4.94204182e-03f, -3.82191129e-02f, 6.20247843e-03f, 1.08488977e-01f, -1.06862254e-01f, 9.29000154e-02f, 2.51856774e-01f,
  2.58099258e-01f, 3.41903344e-02f, -1.22744747e-01f, -2.48361193e-02f, 1.26461387e-01f, 1.32115930e-01f, -9.63270590e-02f, 4.61077616e-02f, 2.70189699e-02f, -1.07871912e-01f,
  -2.96138674e-01f, -3.02731991e-01f, 1.31819025e-01f, 1.27380028e-01f, 1.37750298e-01f, -1.41007200e-01f, -1.86862666e-02f, -4.45315614e-02f, -2.81187333e-02f, -7.81657323e-02f,
  5.72095066e-02f, 4.35087383e-02f, 1.77471489e-02f, 9.40610543e-02f, 1.11035230e-02f, 7.10251555e-02f, 4.33772914e-02f, -3.53331417e-02f, -8.79560038e-02f, 4.90758084e-02f,
  2.21410364e-01f, 1.97221190e-01f, 2.21932940e-02f, -2.68346351e-02f, 7.51134306e-02f, 7.26554245e-02f, -5.72439954e-02f, -5.80311790e-02f, -5.35888039e-02f, -2.31508851e-01f,
  -5.37936948e-02f, -8.10092911e-02f, -7.03502595e-02f, -8.73080455e-03f, -1.76102307e-03f, 5.08535169e-02f, 2.80438811e-02f, 1.46632502e-02f, -2.96604540e-03f, -3.10919899e-02f,
  1.97284529e-03f, -4.61483449e-02f, 5.30805923e-02f, -5.59152924e-02f, -2.24501472e-02f, -4.21033315e-02f, -5.58463410e-02f, -9.93505027e-03f, 8.31299182e-03f, -7.43199438e-02f,
  -4.06551436e-02f, 4.20879312e-02f, 2.28979234e-02f, 1.81657299e-02f, 2.39644502e-03f, -7.37996325e-02f, -5.91323785e-02f, 6.46389946e-02f, 2.10993737e-02f, -1.31932229e-01f,
  -2.08884567e-01f, 7.31320307e-02f, -1.59817770e-01f, -3.62626314e-02f, 4.25531082e-02f, 2.90030334e-02f, -6.09143004e-02f, 1.47484569e-02f, -1.02456838e-01f, -9.28854290e-03f,
  7.81184137e-02f, -5.23657948e-02f, -1.52931297e-02f, 7.91627914e-02f, 4.17890921e-02f, 2.05045268e-02f, 2.55549364e-02f, 2.55906619e-02f, 7.90425688e-02f, 7.54125491e-02f,
  6.66814074e-02f, 1.74129836e-03f, -1.20972894e-01f, -1.17069267e-01f, 7.30188116e-02f, -1.14851490e-01f, -1.59403056e-01f, -1.26212388e-01f, -1.28885120e-01f, -1.65513560e-01f,
  4.99135613e-01f, -4.06240553e-01f, -1.84505761e-01f, 3.04025620e-01f, 3.82410213e-02f, 8.79032239e-02f, -2.26918980e-01f, -3.50351222e-02f, 2.52942681e-01f, -1.54165283e-01f,
  -3.24256867e-01f, 6.05663918e-02f, 1.56042635e-01f, 1.36143997e-01f, 2.68317550e-01f, 1.25949495e-02f, 2.83579141e-01f, 3.43584329e-01f, 3.44182014e-01f, 2.70817757e-01f,
  1.00306250e-01f, 1.09074190e-01f, 1.72912627e-01f, 2.06782967e-01f, -1.65805011e-03f, 2.39036918e-01f, -2.35643029e-01f, -1.08096838e-01f, -1.44326240e-01f, 1.50057925e-02f,
  -2.38803372e-01f, -2.26338014e-01f, 2.90295660e-01f, 5.94293587e-02f, -4.88665327e-02f, 7.50735104e-02f, 3.39879952e-02f, 3.68395564e-03f, 3.35287228e-02f, 2.81551783e-03f,
  -7.82716833e-03f, 9.58494376e-03f, 6.18828014e-02f, -9.91835352e-03f, 3.19759101e-02f, -1.25420112e-02f, -1.24530286e-01f, 5.62180914e-02f, 4.28598262e-02f, -8.10382143e-02f,
  -1.09008260e-01f, -1.13084100e-01f, -4.44113687e-02f, -1.64760175e-04f, 6.09080605e-02f, 6.67423531e-02f, -6.30920008e-02f, -8.30731541e-02f, -4.86778002e-03f, -1.84165891e-02f,
  1.25991866e-01f, 4.32808027e-02f, -1.50350323e-02f, -8.54441598e-02f, -3.11384853e-02f, -6.91379607e-02f, -3.45132165e-02f, 7.44138099e-03f, 4.52860928e-04f, -1.32697165e-01f,
  -5.23987710e-02f, 1.96259990e-02f, -1.11989200e-01f, -1.65883340e-02f, -4.22256216e-02f, -6.73132837e-02f, -9.45886075e-02f, -1.26093924e-01f, -1.29500300e-01f, -7.26014599e-02f,
  -9.14056823e-02f, -5.37679233e-02f, -1.13626249e-01f, -3.03058065e-02f, -9.22929421e-02f, -6.97258189e-02f, -5.14704660e-02f, -9.14243907e-02f, -1.25411242e-01f, -2.19185110e-02f,
  -1.07470462e-02f, 1.48828849e-01f, 7.29876161e-02f, 1.24587834e-01f, -2.42321175e-02f, 1.92916801e-03f, 1.12050222e-02f, 2.36682314e-03f, 1.31316576e-02f, 2.37926710e-02f,
  1.15239974e-02f, 1.08342469e-01f, -5.49950525e-02f, -2.75569297e-02f, 1.39717117e-01f, -8.47689901e-03f, 5.01054786e-02f, 7.61692151e-02f, 3.89826782e-02f, -7.68684074e-02f,
  -3.94678153e-02f, 1.67072013e-01f, 2.88986772e-01f, 1.24119848e-01f, -9.66028310e-03f, 2.98702538e-01f, 1.16712697e-01f, 7.05021843e-02f, 2.36327097e-01f, 2.30923370e-01f,
  -2.76442289e-01f, 3.53428066e-01f, 1.58100218e-01f, 1.17289759e-01f, -4.75514829e-02f, -3.98124605e-01f, -2.97255903e-01f, -1.47190556e-01f, 6.45559058e-02f, -5.91105968e-03f,
  3.47654670e-02f, -1.19276412e-01f, 8.79179239e-02f, -1.88844219e-01f, -1.79205477e-01f, 5.78753538e-02f, 1.56173825e-01f, -1.74715936e-01f, -3.83748651e-01f, -3.96710604e-01f,
  -1.09134376e-01f, 7.49463961e-03f, -2.71066781e-02f, -1.77850071e-02f, 1.91480026e-01f, 1.35366023e-01f, 1.68498516e-01f, 2.02195987e-01f, -6.41973242e-02f, 2.26520047e-01f,
  5.95709682e-02f, -1.10899717e-01f, -2.12907374e-01f, -1.81183264e-01f, -9.28566209e-04f, -9.91684124e-02f, -9.30141732e-02f, 8.99252594e-02f, -3.46763059e-02f, 4.63993754e-04f,
  -5.40867634e-02f, -1.13867246e-01f, -8.32355544e-02f, -8.02538008e-04f, -1.26975561e-02f, 3.15803778e-03f, -4.01107408e-02f, -3.91133130e-02f, -6.66920841e-02f, -2.91897804e-02f,
  -4.14232202e-02f, -4.87819016e-02f, -9.06708017e-02f, 2.87258811e-03f, -1.00528911e-01f, -1.86275423e-01f, -8.30957219e-02f, -1.42608762e-01f, -7.88789913e-02f, 8.64545058e-04f,
  -7.36800507e-02f, 5.71138337e-02f, 2.60263234e-02f, 7.69402608e-02f, 9.78046954e-02f, 9.18534547e-02f, 1.77250192e-01f, 2.59400979e-02f, 3.55443135e-02f, 1.64272666e-01f,
  8.09178129e-02f, 5.08429855e-02f, 1.07417211e-01f, 1.15557127e-01f, 1.27289683e-01f, 1.36380568e-01f, 6.49570152e-02f, 1.57055482e-01f, 6.08070455e-02f, 1.30161449e-01f,
  2.06393041e-02f, 6.80283830e-02f, 1.82807878e-01f, 2.25904211e-02f, 1.10290378e-01f, 3.48145068e-02f, 4.16396558e-02f, 5.92033938e-02f, 5.70574328e-02f, 1.13867082e-01f,
  2.38502882e-02f, -3.59562188e-01f, -1.15607366e-01f, -7.19347149e-02f, -3.13799605e-02f, -2.34198086e-02f, -3.45986672e-02f, -1.22425497e-01f, -5.43284230e-02f, -9.40251499e-02f,
  -1.89502418e-01f, -1.78037256e-01f, 5.70063442e-02f, -9.26987529e-02f, -2.06353158e-01f, -1.49910286e-01f, 3.15132514e-02f, -5.97751550e-02f, -1.36851162e-01f, -1.13436226e-02f,
  -1.82643579e-03f, -1.99869692e-01f, -2.36002982e-01f, -1.26018226e-01f, -4.39376906e-02f, -2.38982752e-01f, -1.14360109e-01f, -1.51328415e-01f, -2.73472577e-01f, -6.12624288e-02f,
  -4.26771343e-01f, 5.70103191e-02f, 5.09338617e-01f, -3.78889561e-01f, -1.03142612e-01f, -1.35359809e-01f, -6.41973838e-02f, -3.18404555e-01f, -2.86500752e-01f, -4.72011790e-03f,
  -4.48992029e-02f, -1.59904733e-02f, 1.09153688e-01f, 3.19857746e-01f, 1.01077288e-01f, 2.91795135e-01f, 3.62455249e-01f, 4.47387338e-01f, 1.12256974e-01f, -2.40169704e-01f,
  -1.15886763e-01f, -2.21241355e-01f, -1.21475175e-01f, 6.27765954e-02f, -2.79048830e-02f, 1.21258497e-01f, 1.88531965e-01f, -2.51450129e-02f, 2.23804310e-01f, 4.30275172e-01f,
  3.13003778e-01f, -1.98588043e-01f, 5.58150634e-02f, -8.42643157e-02f, 2.69845109e-02f, 3.56389619e-02f, 7.42519945e-02f, 6.94004295e-04f, -1.84525717e-02f, -5.25311716e-02f,
  -3.69915627e-02f, 8.15036818e-02f, -1.16089340e-02f, 8.57581571e-02f, -8.03854838e-02f, 3.34729761e-04f, -3.64379818e-03f, -3.09517346e-02f, 9.02272761e-02f, 1.33362627e-02f,
  6.92754518e-03f, -1.04430743e-01f, -1.28757775e-01f, -6.38172626e-02f, -1.03108391e-01f, 6.40696660e-02f, -3.62135023e-02f, -5.23812324e-02f, -6.58314722e-03f, -1.87099930e-02f,
  7.68616870e-02f, -2.86424812e-02f, 5.86776389e-03f, -4.02197838e-02f, -4.79482450e-02f, -4.34229374e-02f, 7.44248107e-02f, -7.93799907e-02f, -1.93181168e-03f, 6.24917494e-03f,
  -4.81130667e-02f, 4.53278199e-02f, 1.98396966e-02f, -6.44847453e-02f, 8.39885399e-02f, 5.48859760e-02f, -6.15491997e-03f, 2.70430315e-02f, 5.79986125e-02f, 9.13279876e-03f,
  1.33194411e-02f, 1.85485836e-02f, -5.43031394e-02f, 7.50158951e-02f, 3.67092937e-02f, -4.45032939e-02f, 1.31912678e-02f, -1.46827567e-02f, -7.74228945e-02f, -2.09334195e-02f,
  -2.14420110e-01f, 4.20162268e-03f, 1.37621373e-01f, 2.85610929e-02f, 1.16212284e-02f, 3.77427079e-02f, 6.40268102e-02f, -4.75529023e-03f, 1.96702704e-02f, 3.07265464e-02f,
  -3.74024846e-02f, -2.05306653e-02f, 2.52824593e-02f, 1.01492406e-04f, 1.63222663e-02f, -1.08710025e-02f, -1.59677044e-01f, 1.05703525e-01f, -4.13764380e-02f, 2.70965360e-02f,
  2.38652341e-02f, -1.26534835e-01f, -5.14599048e-02f, 4.58016545e-02f, -1.25749618e-01f, 9.86920148e-02f, 7.49396384e-02f, -4.38834652e-02f, 3.26589216e-03f, -1.29175857e-01f,
  8.25373977e-02f, 8.99703726e-02f, -3.72981280e-01f, -2.74640918e-01f, -1.80515930e-01f, 9.77144018e-03f, 1.84333414e-01f, 1.95079744e-01f, -4.92719635e-02f, 1.44647405e-01f,
  1.87648937e-01f, 1.44292220e-01f, -4.01594676e-02f, 1.61733940e-01f, 2.23275706e-01f, -4.76946384e-02f, -2.22586468e-01f, -1.25190482e-01f, 1.18234597e-01f, 3.26888382e-01f,
  1.43767089e-01f, -1.55799547e-02f, -1.17841046e-02f, 4.05351557e-02f, -3.15358900e-02f, -1.67937502e-02f, -1.96402073e-01f, -5.56192957e-02f, 8.23765472e-02f, -6.33827001e-02f,
  1.86135173e-01f, 7.88261667e-02f, 6.14695437e-02f, 1.71216652e-01f, -2.57230364e-03f, 1.21889219e-01f, 8.52924809e-02f, -1.25033055e-02f, 4.69404720e-02f, 4.08369265e-02f,
  -6.43218588e-03f, 1.03343099e-01f, -8.05036873e-02f, 4.83878255e-02f, 5.35693802e-02f, 2.23999232e-01f, 1.07530341e-01f, 8.94626081e-02f, 4.66978773e-02f, 1.04866244e-01f,
  1.19554587e-01f, 8.79183318e-03f, 5.79102710e-02f, 6.82060421e-02f, 2.45264862e-02f, -6.80307895e-02f, 1.76937282e-01f, 1.16672389e-01f, 1.27610579e-01f, 2.25584462e-01f,
  -1.19487755e-01f, -2.07951337e-01f, -1.11579895e-01f, -1.68033198e-01f, 3.86293000e-03f, -1.55045182e-01f, -9.94684547e-02f, 4.42355406e-03f, -7.00244159e-02f, -5.62318116e-02f,
  -1.04852356e-01f, -3.94969992e-02f, -1.41843706e-01f, -2.20740363e-01f, -7.36222640e-02f, -1.51309013e-01f, -7.78689384e-02f, -6.54601529e-02f, -2.61225216e-02f, -9.81723890e-02f,
  -5.94860613e-02f, 3.86316539e-03f, -1.41510248e-01f, -8.25900212e-03f, -1.17040522e-01f, -9.65527669e-02f, -6.21099882e-02f, -8.65667164e-02f, -8.68934393e-02f, -1.54137149e-01f,
  9.50205550e-02f, -6.20295778e-02f, 1.14354379e-01f, 1.42168075e-01f, -2.78951582e-02f, 1.21307634e-01f, 5.68587892e-02f, 5.06188050e-02f, 5.07207634e-03f, 1.17611267e-01f,
  1.41115472e-01f, 6.47089407e-02f, -2.45381501e-02f, 1.41173184e-01f, 1.51827201e-01f, 8.40571001e-02f, 5.50812446e-02f, 6.44669607e-02f, 3.31918485e-02f, 1.24265783e-01f,
  8.26380029e-02f, 6.97588548e-02f, 6.97573572e-02f, 1.10299535e-01f, 6.86825365e-02f, 4.85319383e-02f, 7.45308176e-02f, 9.68970358e-02f, 2.52069794e-02f, 3.18287581e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.54479885e-01f, 6.06835634e-02f, -8.54563773e-01f, -1.41695607e+00f, -8.94363105e-01f, 2.39174161e-02f, 2.76777178e-01f, -2.82870770e-01f, -7.32020438e-01f, -2.10853100e-01f,
  2.26147190e-01f, 4.13324952e-01f, 1.04226962e-01f, 4.35201824e-01f, 8.73780608e-01f, 1.21302500e-01f, -6.52614713e-01f, 3.57674286e-02f, 4.99961734e-01f, 3.36948395e-01f,
  1.77119330e-01f, -5.71813881e-01f, -3.54282856e-01f, -2.30262980e-01f, -8.57501030e-01f, -1.99958995e-01f, -9.81680930e-01f, -6.24710560e-01f, 1.38539046e-01f, -6.69222295e-01f,
  9.79056135e-02f, -8.39203477e-01f, 9.38405916e-02f, 1.65629297e-01f, -1.87280625e-01f, 2.27130637e-01f, 2.69937124e-02f, -3.59902084e-01f, 9.47312266e-03f, -1.93633318e-01f,
  -3.91272813e-01f, 2.23555844e-02f, -1.61322758e-01f, -4.14007455e-02f, -3.68436158e-01f, -4.83906716e-02f, -3.71229023e-01f, -5.42443953e-02f, -2.12030672e-02f, 1.99095160e-01f,
  1.77269593e-01f, 1.66779727e-01f, 1.54206604e-02f, 1.53099060e-01f, 1.40071735e-01f, 9.68346074e-02f, -4.95461859e-02f, 2.15819310e-02f, 1.09343298e-01f, -3.43270183e-01f,
  -7.52131715e-02f, 1.22494772e-01f, -4.15242910e-02f, -1.62546769e-01f, 2.01764971e-01f, -3.79065201e-02f, -1.02253027e-01f, 2.51207381e-01f, -4.51256596e-02f, -6.81882724e-02f,
  4.49370081e-03f, 1.49606258e-01f, 7.43694529e-02f, -5.84453382e-02f, 2.28013340e-02f, -3.85006741e-02f, 2.66141057e-01f, 3.11918203e-02f, -5.35947978e-02f, -1.16867758e-01f,
  3.52193043e-02f, -1.30157113e-01f, -2.26715490e-01f, -2.49708816e-02f, 7.61041418e-02f, 8.06485582e-03f, -3.00939996e-02f, 3.43881577e-01f, -2.09104996e-02f, 2.56309099e-02f,
  -1.10440455e-01f, 4.25032347e-01f, -9.39493924e-02f, 1.74579933e-01f, -3.83428782e-01f, -1.60220876e-01f, -2.33459473e-01f, 9.01702419e-02f, -3.11711729e-02f, -5.59352376e-02f,
  -1.06425859e-01f, 7.05413967e-02f, -1.08309031e-01f, -1.26846939e-01f, 3.99461798e-02f, -1.43914926e-03f, 9.61488858e-02f, -1.85013022e-02f, 2.67749559e-02f, -1.61570206e-01f,
  -3.93229276e-02f, 2.98044086e-01f, 5.05311310e-01f, 2.13034004e-01f, -8.76720920e-02f, 2.87818938e-01f, 1.48230582e-01f, 1.41877860e-01f, 5.01773000e-01f, 1.63131446e-01f,
  4.70090747e-01f, -2.08517998e-01f, -2.32476398e-01f, 3.80823970e-01f, 6.56342864e-01f, 1.71506628e-02f, -1.56673640e-01f, -4.72976565e-01f, 4.60300595e-03f, 1.86319679e-01f,
  4.93575037e-01f, 4.50651467e-01f, 2.98225075e-01f, 6.34168237e-02f, -3.44033062e-01f, -4.10468638e-01f, -3.15966278e-01f, -1.83489665e-01f, -1.05333522e-01f, 1.58745438e-01f,
  3.32153499e-01f, 2.80129313e-01f, -7.51197413e-02f, -2.47446865e-01f, 4.94690351e-02f, 4.88501161e-01f, -3.78041677e-02f, 1.35969341e-01f, 1.18659928e-01f, -1.69873968e-01f,
  4.08041507e-01f, -3.11054409e-01f, 1.02814309e-01f, 1.41997904e-01f, 2.84582265e-02f, -3.19811612e-01f, -7.85559043e-02f, -2.25721523e-01f, 7.15534538e-02f, -1.42005473e-01f,
  3.59533094e-02f, -1.11766092e-01f, 9.27323475e-02f, -9.03823301e-02f, -1.24364428e-01f, -5.22132479e-02f, -3.98601204e-01f, -5.54819882e-01f, -3.69588405e-01f, -2.00846761e-01f,
  -4.02807724e-03f, 1.06543913e-01f, -1.20832667e-01f, -2.80378878e-01f, -4.28534478e-01f, 2.23286733e-01f, -1.78348973e-01f, -2.77385026e-01f, -3.43977630e-01f, -4.63796735e-01f,
  1.51017383e-01f, 1.56191781e-01f, -7.27629513e-02f, -4.40567657e-02f, 8.93446431e-02f, -2.81419694e-01f, -2.28020772e-02f, 9.00887474e-02f, -6.74239770e-02f, -9.79722291e-02f,
  -1.54742375e-01f, 3.90180275e-02f, -1.22442208e-01f, -7.60281598e-03f, 2.83455908e-01f, 1.19502865e-01f, 1.66729063e-01f, 7.75979832e-02f, 2.00088173e-01f, 1.29653662e-01f,
  9.57006663e-02f, 1.46457674e-02f, 3.00019413e-01f, -1.69931740e-01f, 4.27524149e-02f, 2.02292427e-01f, 2.95533001e-01f, 1.40121281e-01f, 2.60536104e-01f, 1.38226971e-01f,
  2.99158275e-01f, -7.81274438e-02f, 1.47296907e-02f, -1.31967649e-01f, -1.66920852e-02f, -1.15254857e-02f, 2.54695237e-01f, 2.09705323e-01f, 2.63966560e-01f, 8.28925427e-03f,
  -2.29524113e-02f, -3.93073671e-02f, 9.21234637e-02f, -1.21437795e-01f, 2.22778004e-02f, 1.88641295e-01f, 2.05497772e-01f, 5.39152473e-02f, -1.90288857e-01f, -1.30550727e-01f,
  -3.19283493e-02f, -2.38223169e-02f, 1.63114324e-01f, 7.48687088e-02f, 9.14163608e-03f, 3.64139467e-01f, 1.71466675e-02f, 8.02171677e-02f, -7.86421001e-02f, -2.58343201e-02f,
  -5.17048478e-01f, -2.24216878e-01f, -7.06392884e-01f, 6.95807412e-02f, 2.44709123e-02f, 1.36632904e-01f, 4.59015697e-01f, 3.68889213e-01f, 1.26401544e-01f, -4.98288497e-02f,
  -2.39134327e-01f, -2.16584176e-01f, -4.18517709e-01f, -1.83524534e-01f, -1.27626911e-01f, -1.70455966e-02f, -2.95190305e-01f, -3.92238408e-01f, 3.52549076e-01f, 6.83590949e-01f,
  5.04310429e-01f, 5.23756027e-01f, 2.70960361e-01f, 4.93203439e-02f, 1.03049144e-01f, 4.36966084e-02f, -2.27222264e-01f, -1.76905468e-01f, -2.96550661e-01f, -7.62377799e-01f,
  -2.41975352e-01f, -4.23885554e-01f, -8.51231366e-02f, -2.06418350e-01f, -3.03026378e-01f, -1.10014610e-01f, 1.99195102e-01f, -1.56850740e-01f, -3.43505181e-02f, 4.72407900e-02f,
  -9.49900299e-02f, 5.81734963e-02f, -1.36609212e-01f, 4.01247554e-02f, 2.21205056e-01f, 2.43467137e-01f, 3.34991328e-02f, -1.73951864e-01f, -3.36469501e-01f, -2.27574259e-01f,
  -2.80830413e-01f, -4.41911817e-01f, -6.45934403e-01f, -9.89715755e-02f, -1.72262609e-01f, -3.04972142e-01f, -3.97027992e-02f, -1.13804162e-01f, -3.11301142e-01f, -6.77367002e-02f,
  6.17848150e-02f, 6.49188273e-03f, 4.14317176e-02f, 1.18468307e-01f, 1.67942345e-02f, -1.83986753e-01f, -1.30372673e-01f, -4.05677268e-03f, 1.17788799e-01f, 2.91708708e-01f,
  -1.52349427e-01f, 9.19522997e-03f, 1.47666529e-01f, 1.93160325e-01f, 6.81032389e-02f, -1.38695568e-01f, -1.73952002e-02f, 7.85908774e-02f, -9.02611762e-02f, 1.37344658e-01f,
  1.02643587e-01f, -4.66294028e-02f, -3.85051332e-02f, 6.87698424e-02f, -9.25796032e-02f, -1.52538761e-01f, 4.12204117e-02f, 3.64552811e-02f, 1.76184457e-02f, 1.76226616e-01f,
  4.75853592e-01f, -3.07446271e-01f, -6.23882338e-02f, -1.36608914e-01f, 4.79422845e-02f, -1.25525340e-01f, 3.91283780e-02f, -5.56875952e-02f, 3.02891973e-02f, 9.28210840e-02f,
  -1.97440926e-02f, 8.43147784e-02f, -1.43585742e-01f, 1.48005038e-01f, 2.51964539e-01f, 1.05267435e-01f, -1.85125656e-02f, -2.45126605e-01f, 1.38080716e-01f, 1.08089000e-01f,
  -2.84062810e-02f, 1.54649481e-01f, 1.74006671e-01f, 1.32984258e-02f, 1.73669085e-01f, 1.86280131e-01f, 3.04704130e-01f, 3.91633362e-01f, -2.16255467e-02f, 4.96786594e-01f,
  -9.99060869e-01f, -3.65186155e-01f, 3.16048890e-01f, -7.63531551e-02f, 3.95105004e-01f, 3.80989283e-01f, 3.94047946e-01f, 3.22439410e-02f, 1.10495850e-01f, -1.64923429e-01f,
  -3.23345691e-01f, -1.90023258e-01f, -1.14167616e-01f, -8.36746395e-03f, -1.00931369e-01f, 4.54015970e-01f, 5.88145256e-01f, 2.31915250e-01f, 3.53600174e-01f, 2.58161515e-01f,
  1.45077214e-01f, -7.80394208e-03f, -2.82911181e-01f, 2.33776402e-02f, 1.76456049e-01f, 2.53806591e-01f, 7.90979043e-02f, 1.03357308e-01f, 1.70797333e-01f, 3.18268865e-01f,
  2.59396553e-01f, -4.57972735e-01f, 1.50497437e-01f, -1.15849458e-01f, -1.04489185e-01f, -1.89780831e-01f, 6.47439137e-02f, -3.35379392e-02f, -1.17045119e-01f, 1.18315637e-01f,
  -6.48049414e-02f, -4.73170877e-02f, 6.73417374e-03f, 6.23530569e-03f, -1.04006700e-01f, -7.17209056e-02f, -2.80682087e-01f, -3.80119607e-02f, 1.33082837e-01f, -2.61922702e-02f,
  3.23587507e-02f, 1.25528917e-01f, 1.47656158e-01f, 1.20791152e-01f, -3.30293924e-02f, 1.10146381e-01f, -1.24185860e-01f, -9.25840586e-02f, 4.05002665e-03f, -1.49193034e-01f,
  7.38867968e-02f, -1.43238204e-02f, 1.37259960e-02f, -9.42209810e-02f, -7.72510143e-03f, -1.04780020e-02f, 2.07706857e-02f, 4.27633114e-02f, 3.36667933e-02f, -8.25998466e-03f,
  1.28331512e-01f, 1.01620995e-01f, 6.06867038e-02f, -4.43355627e-02f, -3.63905239e-03f, 1.22905970e-01f, 9.80480239e-02f, 2.16263197e-02f, -9.92796868e-02f, -3.53841996e-03f,
  -1.05864182e-02f, 9.61624756e-02f, -7.61520863e-02f, 2.77388636e-02f, 5.72732165e-02f, 8.67322311e-02f, 7.50242844e-02f, 8.31833556e-02f, -7.63371661e-02f, 6.76321909e-02f,
  9.06550065e-02f, -1.63696826e-01f, 2.14925837e-02f, -1.68808398e-03f, -4.75994125e-02f, -1.97651327e-01f, -4.54959311e-02f, -4.26345021e-02f, 7.72251412e-02f, 1.03538193e-01f,
  -1.22840576e-01f, -1.74397990e-01f, -2.08153054e-01f, -1.73084468e-01f, 5.29983547e-03f, -4.41641584e-02f, -2.72741616e-01f, 6.59009144e-02f, 7.61965290e-02f, -6.86047152e-02f,
  -7.40154237e-02f, 7.90120214e-02f, 2.00035185e-01f, 1.25365645e-01f, 3.73772345e-02f, 1.87037095e-01f, 1.80153102e-01f, 8.66084322e-02f, 1.47288032e-02f, 3.08420137e-02f,
  -6.61154687e-02f, -9.33010936e-01f, -6.90823346e-02f, -3.65091324e-01f, -2.92447340e-02f, 4.93209250e-03f, -2.68878222e-01f, 1.20363599e-02f, -6.93328232e-02f, -6.53373659e-01f,
  -4.90267366e-01f, 1.52085841e-01f, -2.05303177e-01f, -2.41971947e-02f, 7.19141886e-02f, -6.06359780e-01f, -4.70707297e-01f, 4.32264984e-01f, 9.97306168e-01f, 6.89270079e-01f,
  1.37496769e-01f, 2.69130558e-01f, 4.56741750e-01f, 2.27665693e-01f, -3.69278699e-01f, 7.32096210e-02f, -4.15639549e-01f, -1.20589614e-01f, -3.28884780e-01f, -7.66212463e-01f,
  1.62541755e-02f, -2.95929879e-01f, 1.68020293e-01f, -8.48242864e-02f, -8.39646161e-02f, -1.24906443e-01f, -1.40290996e-02f, 6.00609556e-02f, -9.34553370e-02f, -1.26874000e-01f,
  -6.66287392e-02f, -5.52914664e-02f, 1.12628594e-01f, -1.46308457e-02f, 4.35966849e-02f, 1.06855564e-01f, 9.63834673e-03f, -7.18880668e-02f, -8.08464885e-02f, -1.25831679e-01f,
  -1.63433239e-01f, -7.81095326e-02f, -6.36860132e-02f, -6.25001341e-02f, 5.00246212e-02f, 1.13505423e-01f, 3.94507013e-02f, -3.70652750e-02f, 1.14903942e-01f, -2.86256284e-01f,
  1.32754758e-01f, 1.61718810e-03f, 1.09004498e-01f, 2.25937679e-01f, 3.85636874e-02f, 3.38017405e-03f, -2.18027662e-02f, -4.52928022e-02f, 7.98570812e-02f, 5.44946902e-02f,
  -1.50748596e-01f, -1.40237942e-01f, 9.30859428e-03f, -1.53183490e-01f, -5.11443354e-02f, -1.79294899e-01f, -7.41734495e-03f, 1.87148526e-02f, -5.83863538e-03f, -1.98018685e-01f,
  2.92643122e-02f, -1.57553226e-01f, -1.69629212e-02f, 6.89597800e-02f, -2.09356740e-01f, 4.23399694e-02f, -9.97177213e-02f, 4.59302124e-03f, 3.73818353e-02f, -2.08755821e-01f,
  3.71413752e-02f, 1.56141296e-01f, -2.85154343e-01f, -2.22297870e-02f, -7.68454000e-02f, -8.54775310e-02f, -7.68457800e-02f, 6.91694915e-02f, -8.25552419e-02f, 2.09618770e-02f,
  5.90976886e-02f, 1.54411823e-01f, -3.83490697e-02f, 1.52906273e-02f, 2.06433326e-01f, 1.60588503e-01f, -7.25852102e-02f, -1.05771638e-01f, -6.86085224e-02f, -2.18435470e-02f,
  -1.11134425e-01f, -4.39919271e-02f, 1.28036842e-01f, -3.84163260e-02f, 8.16507488e-02f, 2.08827183e-01f, 2.45428815e-01f, 1.44535929e-01f, 1.86393589e-01f, -3.62798870e-02f,
  3.96610349e-01f, -7.05868721e-01f, 1.05905898e-01f, 1.67689011e-01f, -7.39004388e-02f, -1.49471551e-01f, -3.95995736e-01f, -2.07847595e-01f, 1.19855054e-01f, -4.36190143e-02f,
  2.22557522e-02f, 5.15723526e-01f, 3.98970634e-01f, 4.03355449e-01f, 3.26308727e-01f, -8.81644525e-03f, 1.65807754e-01f, 2.96136975e-01f, 2.61008441e-01f, -1.25186279e-01f,
  -8.75384137e-02f, -1.43993571e-01f, 1.05469823e-01f, 1.10940523e-01f, -3.78971636e-01f, 2.50789016e-01f, 2.23307218e-02f, -9.53625962e-02f, -1.36451453e-01f, -3.22791994e-01f,
  -4.64458495e-01f, -1.51182279e-01f, 2.49745041e-01f, 9.27011147e-02f, -2.88630687e-02f, -1.39098391e-01f, -3.80791947e-02f, -1.87694758e-01f, -8.63357484e-02f, -1.69000730e-01f,
  4.48124111e-02f, 4.84891832e-02f, 3.98859195e-02f, -7.93850422e-02f, -2.14121535e-01f, -1.29159406e-01f, -6.96557537e-02f, 6.49902821e-02f, 9.81350839e-02f, -1.70823112e-01f,
  -1.13695972e-01f, -4.99053374e-02f, 5.49203940e-02f, 1.95725799e-01f, 1.62675992e-01f, 2.04225063e-01f, 2.45452821e-02f, -1.24883680e-02f, 1.46445513e-01f, -1.83776654e-02f,
  1.63447753e-01f, -4.85360287e-02f, 2.90769376e-02f, 1.77438065e-01f, 1.21430807e-01f, -2.33531259e-02f, -7.75054619e-02f, 2.84761954e-02f, 3.53750110e-01f, -1.47339664e-02f,
  -1.76406682e-01f, 1.83775425e-01f, 1.58655047e-01f, -1.05869085e-01f, 1.05159789e-01f, -1.35195449e-01f, -1.62784114e-01f, -4.09439877e-02f, 2.22995698e-01f, 1.16587244e-02f,
  6.61964118e-02f, -1.08694658e-01f, -8.97286013e-02f, -1.88647136e-01f, -1.54771507e-01f, 6.26635328e-02f, -1.90243125e-02f, 5.01684695e-02f, 3.95293199e-02f, -2.80557960e-01f,
  -2.16526046e-01f, 4.79963869e-01f, 8.81161541e-02f, 6.57890663e-02f, -7.28105530e-02f, -6.60404339e-02f, 1.74737886e-01f, -1.40837999e-02f, -2.67087489e-01f, -1.51213318e-01f,
  -1.48419291e-01f, -1.14180677e-01f, -1.90561518e-01f, -8.49726051e-02f, 8.88319537e-02f, 5.68347611e-02f, 9.34125930e-02f, 4.83362153e-02f, 3.52474232e-03f, -1.71120629e-01f,
  -1.35955945e-01f, 7.49796778e-02f, 1.84724852e-01f, 1.58212349e-01f, 1.97099313e-01f, 2.79544801e-01f, -1.18344046e-01f, -1.15783662e-01f, 1.72682360e-01f, -7.04573654e-03f,
  6.32839262e-01f, -1.43047243e-01f, -2.88592815e-01f, 4.05938029e-01f, 6.80523589e-02f, -1.36644393e-01f, -2.81449407e-01f, -1.67862955e-03f, 1.95416093e-01f, 2.77003050e-01f,
  4.57728207e-01f, 6.80362642e-01f, 4.83584732e-01f, 3.84156227e-01f, 6.47522286e-02f, -1.43407270e-01f, -3.50860227e-03f, -2.80963909e-02f, 1.09306067e-01f, 1.43267363e-01f,
  3.27108234e-01f, 2.38122001e-01f, 1.94724992e-01f, 1.01009808e-01f, 1.02039978e-01f, 4.13382560e-01f, -8.39040801e-02f, 4.44600023e-02f, -7.69527443e-03f, 8.54137465e-02f,
  -1.92291290e-01f, -1.00344695e-01f, 2.64563560e-01f, 2.58727342e-01f, 1.63815841e-02f, -2.92654950e-02f, 9.32464153e-02f, -1.02822520e-02f, 6.99442178e-02f, -1.05318222e-02f,
  3.13931927e-02f, 2.53345892e-02f, 1.06485739e-01f, -7.73490891e-02f, -1.27113760e-01f, -1.03908531e-01f, -1.18031420e-01f, -1.51297480e-01f, 8.16941448e-03f, -9.31251198e-02f,
  1.18110560e-01f, -8.21972042e-02f, -2.78704554e-01f, -1.27278686e-01f, -4.65250127e-02f, -9.81120951e-03f, -1.39566898e-01f, -9.18412954e-02f, -9.19278413e-02f, 1.85056888e-02f,
  3.51679653e-01f, 8.01874846e-02f, 1.04786158e-01f, 7.45302066e-02f, 1.82062313e-02f, 1.49206528e-02f, -1.83198247e-02f, -8.81434381e-02f, -6.56280518e-02f, -5.18746674e-02f,
  -1.21930772e-02f, 4.78485115e-02f, -6.85651675e-02f, 6.63932338e-02f, 2.65829235e-01f, 6.73816279e-02f, -1.51225373e-01f, -7.92189389e-02f, -1.00298218e-01f, 8.54189228e-03f,
  5.96030653e-02f, -2.33757138e-01f, -9.34625864e-02f, -1.84491217e-01f, -6.92944005e-02f, 2.08832070e-01f, 2.28878960e-01f, 1.82713941e-01f, 1.69043884e-01f, 1.93056107e-01f,
  -9.56991613e-02f, 1.42488211e-01f, 7.28035718e-02f, -1.48950011e-01f, -1.60383567e-01f, -5.01096956e-02f, 3.44524905e-02f, -8.68261978e-02f, -1.07772909e-01f, -1.90719366e-01f,
  -1.69150040e-01f, -7.39778876e-02f, -1.44941844e-02f, -1.12517610e-01f, -1.26296803e-01f, -6.47241250e-02f, -3.81484032e-02f, -1.78300023e-01f, -5.42029478e-02f, -2.09082678e-01f,
  -6.25060052e-02f, -1.56803399e-01f, -2.62242079e-01f, -4.43021171e-02f, 1.72952842e-02f, 1.47842333e-01f, -1.29745409e-01f, -1.51462123e-01f, -1.57168545e-02f, -1.70178860e-01f,
  1.07742333e+00f, 4.92204241e-02f, -1.26604116e+00f, 6.01362646e-01f, -3.38376194e-01f, -8.54565442e-01f, -6.97783768e-01f, -1.03615686e-01f, 7.10262418e-01f, -5.05949743e-02f,
  -4.36682925e-02f, 4.80126366e-02f, -4.02022004e-01f, -6.34179235e-01f, -8.70607316e-01f, -9.94832993e-01f, -8.01838458e-01f, -1.00396931e+00f, -7.84970701e-01f, -8.33593979e-02f,
  1.37944415e-01f, 1.45881027e-01f, -2.22461402e-01f, -2.16693580e-01f, 2.76178122e-01f, -2.10828632e-01f, -5.06938338e-01f, -3.66614074e-01f, -6.35638475e-01f, -4.69762146e-01f,
  -8.11030328e-01f, -1.30142927e-01f, -4.15135205e-01f, 2.20947817e-01f, -2.50877552e-02f, 6.90026581e-02f, -1.93413466e-01f, -6.64872909e-03f, 4.22497600e-01f, -3.37878913e-02f,
  -1.55089218e-02f, -5.01456857e-03f, 5.16833551e-02f, -2.10561782e-01f, -1.69867381e-01f, -2.48860016e-01f, 2.97324918e-02f, -4.25624043e-01f, -1.75003603e-01f, -3.53610292e-02f,
  9.87739488e-02f, -3.63815695e-01f, -7.06720769e-01f, -2.50631928e-01f, -5.62639594e-01f, -3.13839227e-01f, -4.02457714e-01f, -3.52454484e-01f, -8.04139137e-01f, 3.19531500e-01f,
  1.08602578e-02f, -1.23944759e-01f, 5.06696217e-02f, 1.07787222e-01f, 2.16430292e-01f, 8.25198218e-02f, 1.09517567e-01f, -1.10967420e-02f, -4.88624126e-02f, 1.23714156e-01f,
  -2.73711309e-02f, -1.50694609e-01f, 1.62726417e-01f, -4.25523482e-02f, -1.25403464e-01f, -1.85303956e-01f, 8.35233182e-03f, 1.22354746e-01f, -1.26596009e-02f, 3.95070650e-02f,
  -1.27769690e-02f, -1.90274253e-01f, -1.81591790e-02f, 9.54499245e-02f, -1.27234146e-01f, -2.02726558e-01f, -5.19331694e-02f, 2.92604826e-02f, -2.87798569e-02f, -3.16284187e-02f,
  4.13627058e-01f, -4.63008165e-01f, 2.22069964e-01f, -2.57164836e-01f, -2.23884434e-01f, 5.97558506e-02f, 2.85448462e-01f, 1.20977715e-01f, -5.00039794e-02f, -1.07664704e-01f,
  -4.77640480e-01f, -2.24408060e-02f, -2.85378844e-02f, -1.30978711e-02f, -1.94337249e-01f, -4.23086546e-02f, 1.49404913e-01f, -4.47671935e-02f, -2.55078882e-01f, 1.87134176e-01f,
  3.02809179e-01f, 6.08361885e-02f, 8.38212147e-02f, 1.76549599e-01f, 1.60935119e-01f, -7.89878666e-02f, -2.51256168e-01f, -1.19756900e-01f, -4.02378410e-01f, 4.15349424e-01f,
  -2.06368536e-01f, 1.61356479e-01f, 1.99283704e-01f, -2.15475634e-01f, 7.87535131e-01f, 3.33926767e-01f, -4.81897593e-02f, -3.61440003e-01f, -5.40789604e-01f, -1.79887429e-01f,
  6.36511087e-01f, 1.84530511e-01f, -1.87306300e-01f, -2.22758681e-01f, -6.68554783e-01f, -6.26397848e-01f, -7.49432445e-01f, -4.96121258e-01f, -1.88526332e-01f, 3.90501201e-01f,
  2.46642619e-01f, -2.04515960e-02f, -2.49502823e-01f, -2.31445387e-01f, 1.80211142e-01f, 4.52586859e-02f, 1.18445389e-01f, 3.77634645e-01f, 5.05164117e-02f, 4.00045402e-02f,
  3.08194995e-01f, 1.11898787e-01f, -1.53581887e-01f, 1.17964663e-01f, 4.03873563e-01f, -2.13856712e-01f, -1.19098365e-01f, -2.37919301e-01f, -8.19864571e-02f, -1.85547620e-01f,
  4.96468306e-01f, 2.05863506e-01f, 7.98758045e-02f, -4.97748107e-02f, -8.70770589e-02f, -1.48289785e-01f, -2.12301821e-01f, -2.59588301e-01f, -3.41151536e-01f, 8.02322775e-02f,
  4.83334035e-01f, 4.32419628e-01f, 3.29089791e-01f, -2.20371589e-01f, -2.10249603e-01f, 1.02741286e-01f, 2.58946896e-01f, 1.21237099e-01f, -3.17776531e-01f, -1.72032565e-01f,
  -2.08468940e-02f, 1.47912964e-01f, 7.47487769e-02f, 8.64202604e-02f, 1.83246005e-02f, 1.41794220e-01f, 4.75858301e-02f, -2.72694882e-02f, 9.44380313e-02f, 9.50068459e-02f,
  1.75574999e-02f, 2.92331930e-02f, 1.70255572e-01f, -9.73400101e-02f, -1.09904945e-01f, -1.30627612e-02f, 1.07486043e-02f, -3.37586582e-01f, -5.81590086e-02f, -1.44398227e-01f,
  -1.28915310e-01f, -1.65747274e-02f, 1.84375532e-02f, -1.44611061e-01f, -1.07484370e-01f, -1.24689892e-01f, -9.98257920e-02f, -1.38989249e-02f, 1.13340775e-02f, 9.78533775e-02f,
  -9.47195366e-02f, 1.04060046e-01f, 2.23391838e-02f, -1.55282423e-01f, -3.76281515e-02f, 1.21073343e-01f, 3.11226957e-02f, -1.78631589e-01f, 7.38125667e-02f, -1.72091424e-01f,
  -2.20409799e-02f, -1.51525021e-01f, 1.58109963e-02f, -1.69649217e-02f, -1.93696283e-02f, -1.03879414e-01f, -1.66411087e-01f, 1.86132729e-01f, -2.05631211e-01f, 1.51734248e-01f,
  -2.65876740e-01f, -1.88396424e-01f, -2.48125970e-01f, -1.93241224e-01f, 1.64672256e-01f, -8.99874046e-02f, 1.06530106e-02f, 1.79820806e-01f, -1.62108615e-01f, -3.79595757e-01f,
  -6.60393655e-01f, 2.03168124e-01f, 3.10050577e-01f, -3.78937781e-01f, -4.26346302e-01f, -6.17993355e-01f, -6.37248039e-01f, -4.38586056e-01f, -2.48971283e-01f, -2.30223238e-01f,
  1.39960706e-01f, 3.82331669e-01f, 5.65895617e-01f, -3.62618640e-02f, -2.49487624e-01f, -2.61924893e-01f, -1.81281060e-01f, -4.28880155e-01f, -8.74244869e-01f, -9.86251533e-01f,
  -7.40383327e-01f, -8.36051941e-01f, -7.38984227e-01f, -4.02843833e-01f, 7.59674609e-02f, 2.50123646e-02f, 3.65292966e-01f, -2.18638167e-01f, -1.41182125e-01f, -2.32457817e-02f,
  3.26073676e-01f, 2.79196296e-02f, -1.23535514e-01f, -2.33602807e-01f, -4.95204553e-02f, -2.08124798e-02f, -7.35814944e-02f, -1.15159862e-02f, -5.43886460e-02f, -2.55049486e-02f,
  -8.03150609e-02f, -9.51170176e-02f, 1.04627743e-01f, 7.67780244e-02f, -8.04027915e-02f, -1.60371795e-01f, -1.28552034e-01f, -1.61426902e-01f, -1.70493722e-02f, 7.00725764e-02f,
  1.08962178e-01f, -3.37147504e-01f, 1.23105250e-01f, 1.61610827e-01f, 9.76972803e-02f, 4.75551337e-02f, 1.76244706e-01f, 9.97647643e-02f, 2.64372140e-01f, 1.60607263e-01f,
  -2.63465359e-03f, 2.47455776e-01f, 8.05132929e-03f, 3.59243639e-02f, -4.09867465e-02f, 1.50725573e-01f, -5.44022322e-02f, -3.13601270e-02f, -2.19866242e-02f, 6.42180219e-02f,
  4.27299179e-02f, 6.45115376e-02f, -7.61159286e-02f, -1.08430360e-03f, -5.38368225e-02f, 4.71288199e-03f, -2.61436477e-02f, -1.64421573e-02f, 6.88539967e-02f, -1.80739522e-01f,
  -1.07825741e-01f, -6.47679195e-02f, 4.25178334e-02f, -5.00239320e-02f, -5.44516891e-02f, 3.00219655e-03f, -8.05557123e-04f, -1.19622275e-02f, 3.09478715e-02f, 2.78162807e-02f,
  3.23160887e-01f, -6.34400174e-02f, 4.93332148e-02f, -1.11242011e-01f, 5.63393645e-02f, 3.09125073e-02f, 2.00447217e-01f, -5.58892600e-02f, -3.22459973e-02f, -3.57464738e-02f,
  5.03550433e-02f, -1.48426918e-02f, 2.10582912e-01f, 9.27874967e-02f, -1.20314226e-01f, -6.64712712e-02f, -1.52090520e-01f, -6.10004514e-02f, 6.14537857e-02f, 1.96962744e-01f,
  -2.95345462e-03f, -2.81635225e-01f, 7.15065226e-02f, 1.69768021e-01f, 8.43025893e-02f, 4.99530360e-02f, 3.15604299e-01f, 6.94439933e-02f, 1.46151945e-01f, 2.82199495e-02f,
  -1.10905266e+00f, 4.09612775e-01f, 9.27653790e-01f, -9.02877748e-01f, 2.81253099e-01f, 5.89201212e-01f, 7.73260236e-01f, 1.38764128e-01f, -3.18160444e-01f, 3.01206522e-02f,
  -2.39011250e-03f, -6.24716759e-01f, -3.25883120e-01f, -1.98993459e-01f, 4.73948456e-02f, 5.33667445e-01f, 5.52290976e-01f, 8.87373015e-02f, -2.11390167e-01f, -3.65160972e-01f,
  -2.68822104e-01f, -4.11598831e-01f, -4.74512428e-01f, -4.76171412e-02f, -3.81976187e-01f, -5.60588300e-01f, 2.64323503e-01f, -1.68974802e-01f, 2.66468197e-01f, -4.24177319e-01f,
  -7.10429132e-01f, -1.56927705e-01f, 1.36637524e-01f, -4.20291722e-01f, 2.52289455e-02f, -3.56103420e-01f, -3.65709071e-03f, -6.33538067e-02f, -5.23338374e-03f, 2.79474944e-01f,
  -2.38805726e-01f, -5.07926233e-02f, -2.63427317e-01f, -1.38823882e-01f, -1.87302440e-01f, -8.50359425e-02f, -1.07026733e-01f, -3.23416114e-01f, -1.27172887e-01f, -1.09514453e-01f,
  -1.22131526e-01f, -2.00278297e-01f, 3.54090258e-02f, 3.90340060e-01f, 3.44191134e-01f, -4.72325832e-02f, 2.21899822e-01f, -3.01022232e-01f, 2.77375579e-01f, -6.39323235e-01f,
  -1.96141958e-01f, 2.54922975e-02f, 4.70303111e-02f, 1.60783216e-01f, -1.02746598e-01f, -3.26251425e-02f, -5.04390523e-02f, -4.88607250e-02f, -9.53720883e-02f, -2.68073887e-01f,
  3.74726728e-02f, 1.51802108e-01f, 8.59537944e-02f, -2.29394045e-02f, 3.01951133e-02f, 1.07017718e-01f, -4.37661596e-02f, 1.47767454e-01f, 1.43974140e-01f, 1.22121058e-01f,
  -3.08699489e-01f, 6.59681037e-02f, 9.82247964e-02f, -1.89698711e-02f, 1.87398359e-01f, 4.47134227e-01f, 3.65572469e-03f, -5.31886220e-02f, 4.52525951e-02f, 4.32644993e-01f,
  -7.76615381e-01f, 8.28475654e-01f, -4.17076409e-01f, -2.31494963e-01f, -3.68606836e-01f, -1.49641275e-01f, 7.82971084e-02f, 7.04723522e-02f, 1.61633994e-02f, -1.25381947e-01f,
  5.13283797e-02f, -7.68567547e-02f, 1.07529193e-01f, 1.56665415e-01f, -1.60558209e-01f, -1.96023419e-01f, -1.45529956e-01f, -4.06555414e-01f, -1.31337158e-02f, -1.27650440e-01f,
  1.73326030e-01f, -1.70471266e-01f, -8.93017590e-01f, -2.79750764e-01f, -3.19840699e-01f, -5.44335246e-01f, -1.84355706e-01f, -5.25035083e-01f, -2.04401791e-01f, -8.01023126e-01f,
  1.37692308e+00f, 8.80711615e-01f, 5.68642914e-01f, 2.27118507e-01f, 1.58811793e-01f, 4.51513648e-01f, 6.56863153e-01f, 4.54114348e-01f, 4.19095792e-02f, 3.16822529e-01f,
  2.47817934e-01f, -2.40795895e-01f, -1.24156028e-02f, -1.80858895e-01f, 1.55528694e-01f, 1.22066982e-01f, -1.42448902e-01f, 5.04739843e-02f, 1.15542777e-01f, -3.52254547e-02f,
  -2.16751412e-01f, 2.22446486e-01f, 2.69100875e-01f, 1.56000361e-01f, -1.33139506e-01f, -2.99164265e-01f, 5.96112087e-02f, 2.63860434e-01f, 4.97603938e-02f, -7.42839202e-02f,
  -1.14973851e-01f, 7.10070491e-01f, -4.36274976e-01f, -1.93673715e-01f, -6.21192642e-02f, -5.59500679e-02f, -5.46957701e-02f, -5.95208816e-02f, -1.66479312e-02f, -2.25447528e-02f,
  -2.39188403e-01f, 4.42663170e-02f, 1.05279133e-01f, 6.05216399e-02f, 8.29347968e-02f, -8.69170427e-02f, 4.15220261e-02f, 9.23857689e-02f, 2.64270231e-02f, 2.57321484e-02f,
  -1.16676658e-01f, 4.05148566e-02f, 2.22912971e-02f, -5.84243685e-02f, 2.38950878e-01f, -1.78817451e-01f, 1.43116578e-01f, 1.08564779e-01f, 1.02841079e-01f, 2.98296481e-01f,
  9.84723642e-02f, 2.68190891e-01f, 9.85964835e-02f, 1.44850001e-01f, 5.90915456e-02f, 5.11715487e-02f, -7.14776665e-02f, -8.91752094e-02f, 3.41464914e-02f, 1.63269997e-01f,
  -6.31886870e-02f, -3.87578383e-02f, 1.32660896e-01f, -7.04036355e-02f, -1.30146310e-01f, 1.93892997e-02f, -1.07511126e-01f, -1.00857258e-01f, 5.60183078e-02f, -1.22115403e-01f,
  5.81295080e-02f, -8.08923542e-02f, 4.89310175e-02f, 1.32692367e-01f, -5.22181392e-02f, 7.64374807e-02f, 1.90092251e-02f, 2.24728435e-02f, 1.95053324e-01f, 1.10696713e-02f,
  -5.70937097e-01f, -8.94524995e-03f, -3.69303316e-01f, -3.41123017e-03f, -7.81098232e-02f, 3.47856730e-02f, 9.90496501e-02f, -9.56647471e-02f, -8.69951472e-02f, -1.33740798e-01f,
  -7.77969742e-03f, 1.26814499e-01f, 1.31502077e-01f, -3.88151743e-02f, -2.37393573e-01f, -9.49644372e-02f, -2.93697827e-02f, -4.46813703e-02f, -1.01307146e-01f, -2.15484232e-01f,
  -1.53439805e-01f, -1.34548530e-01f, -2.54278421e-01f, -1.39827743e-01f, -1.30252063e-01f, -2.38183841e-01f, -7.86491409e-02f, -1.12171158e-01f, 4.61388268e-02f, -1.58191901e-02f,
  5.42211533e-01f, 2.07524281e-02f, 1.01144515e-01f, 3.41306239e-01f, -9.66798723e-01f, -1.02411520e+00f, -1.16549361e+00f, -8.86317730e-01f, -2.72281051e-01f, -4.32728320e-01f,
  -7.36977220e-01f, -1.34140402e-01f, -7.13047711e-03f, -1.65466323e-01f, -3.50006670e-01f, -3.40909481e-01f, 3.83636475e-01f, 6.61188722e-01f, 1.67543739e-01f, -3.45826775e-01f,
  3.12095851e-01f, 5.99105120e-01f, 7.45516002e-01f, 4.67584461e-01f, 6.91997766e-01f, 3.25340003e-01f, 3.58681470e-01f, 4.43093657e-01f, -2.69067436e-02f, 9.47133064e-01f,
  1.81740686e-01f, -2.41654133e-03f, -3.83219033e-01f, 2.79247224e-01f, -1.21824570e-01f, 7.83716440e-02f, -2.31944740e-01f, 4.26659912e-01f, -1.88473135e-01f, 1.05078720e-01f,
  -1.99264400e-02f, -2.15915218e-02f, -1.12833351e-01f, 1.35608792e-01f, -1.68045819e-01f, -3.47404510e-01f, 2.53759414e-01f, 4.25475746e-01f, 1.92364082e-01f, -1.13836164e-02f,
  3.05859484e-02f, -1.83150440e-01f, -5.08736134e-01f, -4.23792601e-01f, -2.34052956e-01f, 2.70572100e-02f, -1.87186137e-01f, 2.92085819e-02f, -2.44713098e-01f, 4.99195397e-01f,
  -5.71489595e-02f, -6.76373392e-02f, -1.30671501e-01f, 1.58317375e-03f, -1.59741059e-01f, -2.15448603e-01f, 8.17282721e-02f, -5.55012301e-02f, -5.13464063e-02f, -1.24890462e-01f,
  -8.32377598e-02f, -1.61997631e-01f, 6.18182346e-02f, 3.17966677e-02f, -4.87503558e-02f, 1.29327983e-01f, 7.91383386e-02f, 1.46555737e-01f, -1.73789561e-02f, -2.51763258e-02f,
  4.77437973e-02f, -1.15311638e-01f, 1.18394323e-01f, 2.02240407e-01f, 2.08062053e-01f, 1.37805462e-01f, 2.60248274e-01f, 9.98545345e-03f, 1.55029833e-01f, -2.13299897e-02f,
  3.22240181e-02f, -4.95993346e-01f, -8.89815670e-03f, 3.82517189e-01f, -1.34661660e-01f, 2.14194775e-01f, -2.35478338e-02f, -2.40151118e-02f, -5.90963513e-02f, 1.36914760e-01f,
  -4.04635519e-01f, -3.95763338e-01f, -7.25590065e-02f, 8.84613618e-02f, -2.28997424e-01f, -2.01649696e-01f, -3.07679832e-01f, -2.13687956e-01f, -1.98549569e-01f, -2.95331683e-02f,
  -2.59942442e-01f, -5.51966727e-01f, -7.93530226e-01f, -8.04157376e-01f, -2.12148741e-01f, -7.76533306e-01f, -3.94423217e-01f, -3.43934447e-01f, -9.75249887e-01f, -8.34539354e-01f,
  -9.92813706e-01f, 5.91423988e-01f, -9.48392034e-01f, 3.46153863e-02f, 5.52289709e-02f, 1.90040663e-01f, 8.60179245e-01f, 3.16451550e-01f, 8.87339860e-02f, 2.93737054e-01f,
  -3.73908460e-01f, -5.35582423e-01f, -4.04067516e-01f, -1.95372090e-01f, 8.42506764e-04f, 8.45077991e-01f, 5.11224926e-01f, -5.90168118e-01f, -6.72047436e-01f, 2.36563668e-01f,
  6.41890526e-01f, 1.59700423e-01f, -4.06852990e-01f, -9.91873145e-02f, 1.18670739e-01f, -1.51744872e-01f, -1.25641823e-02f, -1.92577854e-01f, 2.14022890e-01f, 3.53031233e-02f,
  -5.20547926e-01f, -4.00150299e-01f, 1.60226859e-02f, -1.66956082e-01f, -2.03090414e-01f, -1.13210261e-01f, -7.87894949e-02f, -3.17365497e-01f, -2.15578452e-01f, -3.01466435e-02f,
  -2.47439146e-01f, -9.43844691e-02f, -2.38405332e-01f, -8.14619847e-03f, -4.71752658e-02f, -2.02072114e-01f, -6.42735837e-03f, -1.33984089e-01f, -1.25182457e-02f, -2.83199042e-01f,
  3.89533222e-01f, -3.11657518e-01f, -6.81568980e-01f, 1.85191795e-01f, -9.74286348e-02f, -3.55489641e-01f, -3.66807580e-01f, -4.79058415e-01f, -4.11870301e-01f, 6.85899111e-04f,
  1.72713116e-01f, -5.43414205e-02f, 2.89692748e-02f, 5.86166494e-02f, 2.26892963e-01f, 4.84964587e-02f, 1.32535890e-01f, 6.34942576e-02f, -2.11962648e-02f, 4.80457731e-02f,
  -9.41211581e-02f, -2.94465385e-02f, 1.49976742e-02f, -1.14855887e-02f, -9.21993181e-02f, -1.05572596e-01f, -3.16479728e-02f, 9.66737270e-02f, -4.45834128e-03f, 1.19862575e-02f,
  -7.33660758e-02f, 1.44977979e-02f, -6.80197701e-02f, 1.74325630e-01f, -4.74626683e-02f, -1.93110928e-01f, -1.06899269e-01f, -8.92628357e-02f, 2.09164228e-02f, 4.06951047e-02f,
  4.07528460e-01f, 6.05574772e-02f, 1.03913426e-01f, 2.07140878e-01f, -3.13831940e-02f, -3.55511382e-02f, 4.91602346e-02f, 1.49749592e-01f, -1.40908152e-01f, -3.70617807e-02f,
  -8.41179118e-02f, -1.75964683e-01f, 4.03484330e-02f, 1.16125464e-01f, -1.10845372e-01f, -9.63080078e-02f, 2.89840460e-01f, 7.99899846e-02f, 2.09082767e-01f, 2.84818634e-02f,
  4.18713093e-01f, 2.94119596e-01f, 1.81915909e-01f, 2.03515783e-01f, 2.24263623e-01f, -4.74137589e-02f, 2.74367295e-02f, 1.44756764e-01f, 1.66451149e-02f, 8.26015353e-01f,
  7.60891616e-01f, -3.73997867e-01f, -4.17781770e-01f, 5.19912899e-01f, 3.28803271e-01f, 2.44515508e-01f, 1.44809494e-02f, 2.60310441e-01f, 3.85995090e-01f, 2.80556059e-03f,
  -3.67194116e-01f, -4.32665616e-01f, -2.05273554e-01f, -3.04424971e-01f, -1.59617573e-01f, -1.54757909e-02f, 9.71581414e-02f, -5.32086045e-02f, -1.30777478e-01f, -4.40096036e-02f,
  5.60025871e-02f, 2.45902631e-02f, -3.65964249e-02f, -3.77800316e-02f, -9.48106572e-02f, 1.66451707e-02f, -2.47796729e-01f, -8.86868536e-02f, -2.07546964e-01f, -1.74397826e-01f,
  -5.81243694e-01f, -2.68360198e-01f, -2.14238148e-02f, -4.87447530e-02f, -1.69663280e-01f, -4.99808230e-02f, -1.23931512e-01f, -1.75572366e-01f, 5.02197035e-02f, -8.78242962e-03f,
  -1.96878985e-01f, -1.10288866e-01f, -1.85769960e-01f, -1.17535032e-01f, 1.15742693e-02f, 5.10572419e-02f, -2.87833884e-02f, -3.49165872e-02f, -1.43620506e-01f, -1.41825512e-01f,
  -2.16110006e-01f, 1.56623144e-02f, 1.10932522e-01f, 8.75824615e-02f, -9.18484628e-02f, 1.05756357e-01f, 3.51436883e-02f, 1.22062050e-01f, -1.06046321e-02f, 3.00223112e-01f,
  -4.07646559e-02f, 1.95600279e-02f, -1.87538657e-02f, 3.18904000e-04f, 1.00547537e-01f, 1.54395923e-01f, 1.81831270e-01f, 4.19057198e-02f, -8.38715658e-02f, 1.30965775e-02f,
  1.21858537e-01f, -1.39278695e-01f, -1.77797273e-01f, 2.10847389e-02f, -2.02380061e-01f, 2.12718267e-02f, -8.41427315e-03f, -8.40409473e-02f, -2.97685474e-01f, -1.17125846e-02f,
  -1.12791032e-01f, 1.39872298e-01f, 1.01491101e-01f, -9.93448496e-02f, -1.37296155e-01f, -1.25249615e-02f, -5.61093241e-02f, -2.23503977e-01f, 4.92172278e-02f, 1.23409763e-01f,
  -3.06681722e-01f, -3.90530348e-01f, -2.66643567e-03f, -1.37642622e-01f, 4.49633040e-02f, -4.01324704e-02f, -3.06102902e-01f, -6.37413338e-02f, -1.00112207e-01f, 4.92561795e-03f,
  -1.31768525e-01f, -2.27469597e-02f, -2.30618343e-01f, -4.36471477e-02f, 7.15690851e-02f, -5.94153441e-02f, -4.43940721e-02f, 7.21046189e-03f, -5.65127470e-02f, 7.81314149e-02f,
  6.93781599e-02f, 2.92180210e-01f, 3.72236788e-01f, 2.45439678e-01f, 2.81589270e-01f, 3.41249347e-01f, 1.69138968e-01f, 1.26913920e-01f, 2.71063566e-01f, 5.04956126e-01f,
  -1.15694666e+00f, -6.32402658e-01f, 4.81473893e-01f, -6.67985141e-01f, 6.77218884e-02f, 3.87965292e-01f, 1.73573822e-01f, 1.70610249e-01f, -1.10676782e-02f, 2.53146440e-01f,
  4.47729379e-02f, -1.56545267e-01f, -2.22597897e-01f, -3.51964533e-01f, -6.78496182e-01f, -9.71461833e-02f, -3.25939655e-01f, -5.31602442e-01f, -1.75972179e-01f, 1.50388762e-01f,
  -1.52111739e-01f, -8.07289779e-01f, -8.27396333e-01f, -2.56741256e-01f, 1.23594046e-01f, -4.61271182e-02f, -8.43110494e-03f, -4.72460359e-01f, -1.66784495e-01f, -3.46245587e-01f,
  3.30506057e-01f, -3.92052740e-01f, 7.46126026e-02f, -2.37361938e-01f, 4.06749435e-02f, -1.18306894e-02f, -6.58350140e-02f, -3.07995249e-02f, -5.75997494e-02f, 8.81213546e-02f,
  -1.66485384e-01f, -3.01002190e-02f, -1.65650874e-01f, 2.38554664e-02f, 2.54678596e-02f, 8.84970501e-02f, 5.91982305e-02f, -1.46937102e-01f, -6.87498227e-02f, 2.65717208e-01f,
  8.02609921e-02f, -3.40222754e-02f, 9.53047723e-02f, 2.25428313e-01f, 8.41402411e-02f, -1.26570627e-01f, 3.88112888e-02f, 1.20020002e-01f, 1.64237529e-01f, 2.09621608e-01f,
  2.45861962e-01f, 2.59802699e-01f, 9.58909616e-02f, -4.30870205e-02f, -2.92610284e-02f, 4.61910889e-02f, -4.69685048e-02f, -5.01692994e-03f, -6.02746233e-02f, -6.57923222e-02f,
  7.11408779e-02f, -7.16611445e-02f, -1.60075221e-02f, -5.70619255e-02f, 1.43351555e-01f, -1.70514286e-02f, -1.23620197e-01f, 7.77090415e-02f, 1.76891714e-01f, -1.06607787e-02f,
  -1.29316896e-01f, 8.02897364e-02f, 5.82065582e-02f, -3.91237512e-02f, 8.10071602e-02f, -8.44211429e-02f, -2.88973022e-02f, -2.14127004e-02f, -1.80093013e-02f, 6.47055432e-02f,
  -7.83952624e-02f, -3.84568155e-01f, -1.03047431e-01f, -1.33882239e-01f, 2.05256115e-03f, 1.61063403e-01f, -7.34970253e-03f, 2.97578871e-02f, -2.39101574e-01f, -2.95484308e-02f,
  -6.40975311e-02f, -4.02029566e-02f, -2.25409463e-01f, 5.66046052e-02f, 3.25332186e-03f, 1.27977505e-01f, -2.31227558e-03f, -1.19129777e-01f, 4.52194884e-02f, 2.20720083e-01f,
  7.61953518e-02f, 5.31831309e-02f, -3.68895195e-02f, 1.41959935e-01f, 1.15774963e-02f, -4.84609045e-02f, 4.07660566e-02f, 9.48928446e-02f, -5.69323599e-02f, 3.19546945e-02f,
  6.51606500e-01f, -2.52805762e-02f, 5.54166555e-01f, 5.08117378e-01f, 4.18554008e-01f, 5.24154305e-01f, 5.37684143e-01f, 4.52658802e-01f, 3.29691619e-01f, 1.81747600e-01f,
  -1.75093278e-01f, -1.10157825e-01f, -8.69776160e-02f, -4.04542983e-02f, 1.10467076e-01f, 4.13457900e-01f, 3.16224426e-01f, 3.22467655e-01f, 3.37295473e-01f, 3.17762852e-01f,
  1.30819023e-01f, 4.82639149e-02f, -1.44554615e-01f, 1.17226027e-01f, 1.15800872e-01f, 1.14318160e-02f, 1.28773451e-01f, 1.09388821e-01f, 2.82183308e-02f, 3.40460032e-01f,
  4.24482115e-02f, -6.55248668e-03f, -6.01460449e-02f, -2.19500780e-01f, -1.89989001e-01f, -7.86284283e-02f, 7.53999278e-02f, -1.23973452e-01f, -1.58783600e-01f, -7.57091120e-02f,
  -1.59704044e-01f, -6.54215962e-02f, -1.89631283e-02f, -6.40069693e-02f, -1.74439773e-02f, -6.63358644e-02f, -6.60546198e-02f, -3.65565345e-02f, -1.63084894e-01f, -1.17245093e-01f,
  -1.09534696e-01f, 2.31443383e-02f, 3.28157842e-02f, 4.42141220e-02f, -3.01388130e-02f, -1.83207989e-01f, -1.65895388e-01f, -1.27340198e-01f, -1.40536860e-01f, 3.08154486e-02f,
  3.57899778e-02f, 8.56695101e-02f, 1.85878232e-01f, 1.04645662e-01f, 1.72793210e-01f, 1.46426350e-01f, 1.20942339e-01f, 1.19854197e-01f, 8.58354568e-02f, 1.71761513e-01f,
  1.44390643e-01f, 1.51049301e-01f, 5.85886464e-02f, 1.79355666e-01f, -6.84163580e-03f, 8.99304226e-02f, 1.34655088e-01f, -5.86415641e-02f, 9.93061736e-02f, 2.67816260e-02f,
  2.31461272e-01f, 2.48473376e-01f, -3.71186063e-02f, 1.65029973e-01f, -2.34648436e-02f, 1.60349458e-01f, 1.82676703e-01f, 3.19962576e-02f, 1.18314810e-02f, 4.58317325e-02f,
  -4.38714683e-01f, -2.91161329e-01f, 2.08730191e-01f, -8.92817080e-02f, -1.55698713e-02f, -1.10740572e-01f, -8.56188312e-02f, -2.84488678e-01f, -3.20897251e-01f, 4.46166407e-04f,
  -8.81973952e-02f, 4.28820848e-02f, -5.08635640e-02f, -2.67805513e-02f, 1.15472458e-01f, -7.82686770e-02f, -1.84114441e-01f, -1.37912473e-02f, -1.62130773e-01f, -1.38336539e-01f,
  -7.62609467e-02f, 1.09417632e-01f, 6.88304976e-02f, 1.32630661e-01f, -8.42792019e-02f, -6.07005879e-02f, -1.36381179e-01f, -3.16585377e-02f, 3.38372812e-02f, 4.91704978e-02f,
  6.99634731e-01f, -3.02548647e-01f, 3.07058930e-01f, 4.20307368e-01f, 8.67714882e-02f, -2.37057284e-01f, -6.66370094e-02f, 4.23555821e-02f, 1.42357424e-01f, 2.98242420e-01f,
  -4.73221421e-01f, -7.14915454e-01f, -2.51984715e-01f, -3.09284210e-01f, -2.17039019e-01f, 4.83351171e-01f, 5.45491397e-01f, 2.73160692e-02f, -3.71115327e-01f, -6.69468045e-01f,
  -3.42068940e-01f, 1.55540556e-01f, 1.78940389e-02f, -2.04008222e-01f, -1.02746174e-01f, -3.23029794e-02f, 3.15185010e-01f, -5.33799268e-03f, -4.64610040e-01f, 1.50358081e-01f,
  2.82016367e-01f, -5.08127153e-01f, 1.42125234e-01f, -3.98576021e-01f, -3.43066491e-02f, 1.47580296e-01f, -1.71628162e-01f, 1.13469116e-01f, -1.65197387e-01f, 1.44188762e-01f,
  -3.95444512e-01f, -5.40809512e-01f, -1.38604686e-01f, -2.82619327e-01f, -1.68780446e-01f, -1.52596936e-01f, 3.63568328e-02f, -3.67387056e-01f, -1.72332138e-01f, -3.28386366e-01f,
  -7.71022081e-01f, -4.20046121e-01f, 2.15761811e-01f, -2.33661145e-01f, -3.08619499e-01f, -1.94921538e-01f, -1.80890664e-01f, -6.05904400e-01f, -4.74431515e-01f, 3.59673858e-01f,
  -1.51357517e-01f, 5.45185655e-02f, -9.94648486e-02f, 1.54033899e-01f, 1.00812718e-01f, 4.92204353e-02f, 7.29909837e-02f, -4.66804169e-02f, 6.10380014e-03f, 9.40891504e-02f,
  -1.49124831e-01f, 5.19315563e-02f, 2.28836372e-01f, 2.33128950e-01f, -6.31236136e-02f, -4.35354635e-02f, 2.22095070e-04f, 8.84786174e-02f, 2.53683459e-02f, 1.09055325e-01f,
  -2.20907986e-01f, -8.58644918e-02f, -5.30583672e-02f, 6.61426643e-03f, -1.53011493e-02f, -1.62473679e-01f, 4.54103388e-03f, -1.26470879e-01f, -1.28973341e-02f, -7.41297603e-02f,
  4.06592399e-01f, -4.45241898e-01f, 6.05015874e-01f, -1.86407775e-01f, 3.99536006e-02f, -3.47783446e-01f, -6.81621134e-02f, -1.46071553e-01f, -6.93723336e-02f, -1.60922244e-01f,
  -4.33835626e-01f, 2.00500153e-02f, 1.98359683e-01f, 8.74386802e-02f, -3.30293439e-02f, -7.57814571e-02f, 6.70489445e-02f, 1.48117408e-01f, -3.35328504e-02f, 1.68324843e-01f,
  2.50882506e-01f, 2.60016441e-01f, 7.84746945e-01f, 3.95644903e-01f, 6.28648847e-02f, 1.30568489e-01f, 5.68892539e-01f, 2.02459887e-01f, 1.02997094e-01f, 1.00436795e+00f,
  5.17695211e-02f, -9.47240293e-01f, -4.59355235e-01f, -4.09503669e-01f, -5.01821935e-01f, -2.32872218e-01f, -8.41174960e-01f, -1.27306376e-02f, 1.11134917e-01f, -8.41242671e-01f,
  -4.25763696e-01f, 5.89634180e-01f, 3.73268813e-01f, 3.75548750e-01f, 3.51242870e-01f, -1.03600371e+00f, -5.70951283e-01f, 3.31208169e-01f, 8.42092633e-01f, -5.80782741e-02f,
  -3.67437065e-01f, 1.82842351e-02f, 3.15038562e-01f, 9.62672979e-02f, -9.04626369e-01f, -3.88443507e-02f, -5.66558838e-01f, -3.86750311e-01f, -5.76942921e-01f, -8.66151989e-01f,
  -6.59458399e-01f, -4.38876525e-02f, 5.99688888e-01f, 5.48726678e-01f, -2.48580784e-01f, 1.86062232e-01f, -2.15626508e-02f, 1.10983379e-01f, 1.21398591e-01f, -3.25618148e-01f,
  -1.34761959e-01f, 7.73741379e-02f, 1.20198324e-01f, 4.84156981e-03f, -2.91818500e-01f, -4.60443310e-02f, 1.88649014e-01f, 2.85676092e-01f, 1.39233628e-02f, -1.21386319e-01f,
  -4.47820336e-01f, -2.95313537e-01f, 2.70119309e-02f, 4.59530130e-02f, 1.80016190e-01f, 5.58708668e-01f, -2.22631678e-01f, -1.61052272e-01f, 1.09293289e-01f, -1.03104424e+00f,
  -1.31077915e-01f, -3.47678959e-02f, -1.64140642e-01f, 7.28763640e-02f, 1.28994056e-03f, -8.92099962e-02f, 9.91827697e-02f, -1.17985331e-01f, -8.79226029e-02f, -1.06483564e-01f,
  1.88806765e-02f, -8.80350992e-02f, 1.42602175e-01f, -3.95986810e-02f, 6.30498379e-02f, -9.70055237e-02f, -2.83460379e-01f, -1.20827273e-01f, -2.77593490e-02f, 9.87451971e-02f,
  1.90768659e-01f, 1.16292216e-01f, -2.71183029e-02f, 8.22190046e-02f, 9.33213457e-02f, 4.84550186e-02f, -8.00422858e-03f, -7.93120041e-02f, -9.13697854e-02f, -1.29617462e-02f,
  5.25904857e-02f, 4.53726918e-01f, -3.85527998e-01f, 1.61262736e-01f, -2.11955518e-01f, -9.09737498e-02f, -1.83697477e-01f, 7.88072050e-02f, 2.61326700e-01f, -1.96928278e-01f,
  -1.44376278e-01f, -1.34102419e-01f, -1.03512466e-01f, -1.80146750e-02f, 2.80540008e-02f, -9.05325040e-02f, -2.81470180e-01f, -2.69345175e-02f, 2.41465896e-01f, -1.04276069e-01f,
  -2.33488888e-01f, -1.96023896e-01f, -1.03822604e-01f, -1.76798757e-02f, -2.67976105e-01f, 2.65181720e-01f, -3.78722429e-01f, -4.76979256e-01f, -6.89263716e-02f, -9.85905766e-01f,
  -7.74539292e-01f, 8.76363099e-01f, 3.08161765e-01f, -1.37233883e-01f, 5.06146371e-01f, 4.88905400e-01f, 5.76279104e-01f, -4.00426984e-02f, -2.86056906e-01f, 3.04344565e-01f,
  4.07681346e-01f, -3.55182976e-01f, -4.99240421e-02f, 8.37696996e-03f, -1.59718603e-01f, 4.31193620e-01f, 3.72854203e-01f, -3.06035280e-01f, -5.39736152e-01f, -3.87243181e-01f,
  1.92133591e-01f, -1.98967442e-01f, -5.95027804e-01f, -4.33604658e-01f, 1.88944519e-01f, -1.91994622e-01f, 1.21816590e-01f, 3.22422773e-01f, 5.07943869e-01f, 4.94673759e-01f,
  1.99684098e-01f, 3.57749462e-01f, -6.21602118e-01f, -7.29116797e-02f, 2.69905239e-01f, -2.58375943e-01f, -9.56650153e-02f, -1.38541982e-01f, 1.51921734e-01f, -4.75885645e-02f,
  3.99302453e-01f, 2.60930955e-01f, 2.92697340e-01f, 2.20503688e-01f, 6.47865236e-02f, -2.32139736e-01f, -2.54865080e-01f, -3.78576130e-01f, -2.45451882e-01f, 2.83822473e-02f,
  5.33459246e-01f, 2.40760475e-01f, 9.84602496e-02f, -6.91945255e-02f, -4.14346568e-02f, -3.34749311e-01f, 2.54836641e-02f, -1.48321956e-01f, -3.13492686e-01f, -1.83695272e-01f,
  2.15386767e-02f, 3.01779881e-02f, 1.86503530e-01f, 4.13653478e-02f, -8.71603265e-02f, -1.18477367e-01f, 6.49345741e-02f, 1.91432402e-01f, -1.37164006e-02f, 7.56324269e-03f,
  -1.24333069e-01f, -1.05069220e-01f, -2.57537752e-01f, 2.86686011e-02f, -1.38669550e-01f, -1.29261157e-02f, -7.08396658e-02f, -9.51074064e-02f, 1.43270478e-01f, -3.77150103e-02f,
  1.18524700e-01f, -2.57345028e-02f, -8.58906936e-03f, 5.00626005e-02f, -8.92546847e-02f, -1.49483502e-01f, -2.69551009e-01f, -2.23003030e-01f, -3.43184561e-01f, -3.03260572e-02f,
  -4.87338722e-01f, -1.21972799e-01f, -5.32265484e-01f, -2.97819413e-02f, 3.41654330e-01f, 1.68743834e-01f, 4.38445397e-02f, 2.31544554e-01f, 2.39650548e-01f, -2.24737301e-01f,
  -1.26299039e-01f, -2.80390203e-01f, 1.24966778e-01f, -1.21977113e-01f, -2.65840799e-01f, -9.62153748e-02f, 3.22929144e-01f, -2.02361479e-01f, -3.47209461e-02f, 3.44892521e-03f,
  -1.75911412e-02f, -4.18775916e-01f, -5.01084745e-01f, -4.26726848e-01f, -1.87776178e-01f, -9.39055145e-01f, -2.88199127e-01f, -3.23221862e-01f, -3.21041167e-01f, -5.91724217e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.51144934e-01f, 1.04446149e+00f, 7.34691799e-01f, 7.46946156e-01f, 5.71888983e-01f, 6.38015091e-01f, 7.36007273e-01f, 7.82648087e-01f, 9.27608967e-01f, 4.71499920e-01f,
  1.11241317e+00f, 7.99628377e-01f, 1.10391462e+00f, 8.79181564e-01f, 6.03840530e-01f, 8.40141773e-01f, 7.20080078e-01f, 1.25962245e+00f, 5.42322338e-01f, 6.04926586e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.92450106e-01f, -4.57103729e-01f, -1.42038595e-02f, -4.92723100e-02f, -7.31113136e-01f, -5.71794271e-01f, 5.65497242e-02f, 2.88873941e-01f, 5.84335960e-02f, -4.90189791e-01f,
  -6.38660312e-01f, -9.58548039e-02f, 2.18137354e-01f, -5.75301707e-01f, 7.43667543e-01f, -1.22897208e+00f, 4.85688657e-01f, -5.91821410e-02f, -2.93422222e-01f, 4.31434989e-01f,
  1.78408042e-01f, -4.97251183e-01f, -3.05522472e-01f, -4.99991953e-01f, -3.91253263e-01f, -3.56277794e-01f, -9.80296209e-02f, 1.26475468e-01f, -2.48415232e-01f, -1.48238468e+00f,
  5.53530872e-01f, -1.23649943e+00f, 8.61126580e-04f, 4.49430868e-02f, -1.44929036e-01f, -1.79186150e-01f, 1.14333943e-01f, 2.58470535e-01f, 2.08529696e-01f, -2.39810631e-01f,
  4.60235834e-01f, -1.00174338e-01f, -2.28816956e-01f, 1.44273773e-01f, 8.43750596e-01f, 4.68777895e-01f, -5.14885664e-01f, -6.79254949e-01f, 1.10569961e-01f, 8.23416948e-01f,
  3.47071618e-01f, -1.36760506e-03f, -1.14369833e+00f, 6.61034882e-02f, -1.55515552e+00f, 2.61543959e-01f, -1.08178329e+00f, -1.71205771e+00f, 1.67746142e-01f, -8.45759749e-01f,
  3.38845432e-01f, -6.08226880e-02f, 8.95006657e-01f, -9.74783540e-01f, 8.71118084e-02f, 2.19556570e-01f, 9.17843878e-02f, 1.00757591e-01f, 1.27619788e-01f, 1.23918047e-02f,
  3.11618000e-02f, 1.59325406e-01f, 3.19996208e-01f, 2.04486489e-01f, 4.97807622e-01f, -3.61216843e-01f, -4.59146798e-01f, -2.12705985e-01f, -4.65952784e-01f, -6.07546389e-01f,
  7.38194227e-01f, 3.44341099e-01f, -1.75194904e-01f, -1.09234083e+00f, -5.78206837e-01f, -3.78902107e-01f, 8.25069964e-01f, -8.80311370e-01f, 6.19814217e-01f, -7.48882592e-01f,
  -1.67440131e-01f, -6.11807287e-01f, -5.59369564e-01f, -1.76987246e-01f, 7.88527668e-01f, -5.34610271e-01f, 1.86411068e-01f, -1.61612049e-01f, -3.52253050e-01f, -2.80024507e-03f,
  2.36510500e-01f, -1.72886088e-01f, 3.63168120e-01f, 3.40849251e-01f, -1.12559251e-03f, -2.69807935e-01f, 4.52474326e-01f, 3.44029784e-01f, 9.93948579e-01f, -1.24748445e+00f,
  -1.68172792e-01f, 8.54450986e-02f, -7.95750260e-01f, -1.07483888e+00f, -5.25775850e-01f, -5.90851545e-01f, 7.51107857e-02f, -3.25788297e-02f, 8.74208033e-01f, -5.77050090e-01f,
  -1.22371304e+00f, 6.07404470e-01f, -3.10941577e-01f, 3.45840514e-01f, -3.92216772e-01f, -1.20041382e+00f, -1.05259895e-01f, 5.61563253e-01f, -1.87257096e-01f, 2.54726410e-01f,
  -3.98088723e-01f, -7.85771534e-02f, 2.36552164e-01f, 1.20577253e-01f, -4.58364606e-01f, 2.90323466e-01f, -3.23778063e-01f, 3.14036012e-01f, -7.79864118e-02f, 4.54993457e-01f,
  -1.02247667e+00f, -1.93268761e-01f, -5.35750389e-01f, 6.51156530e-02f, -1.06933904e+00f, 2.44867966e-01f, -4.96510088e-01f, 3.38223726e-01f, 1.50228590e-01f, 8.61893952e-01f,
  3.98788154e-02f, 2.99665570e-01f, -2.84901168e-02f, -1.00180674e+00f, -2.84026176e-01f, 5.65792382e-01f, -4.61131126e-01f, 1.94320068e-01f, 4.61473092e-02f, 3.01780291e-02f,
  3.68662804e-01f, 2.23847091e-01f, 2.94889957e-01f, 1.50745109e-01f, -1.77868038e-01f, -1.63301334e-01f, -1.81725249e-01f, -3.94189000e-01f, 2.24315956e-01f, 1.48155168e-01f,
  -7.86394417e-01f, 4.60499078e-01f, -1.35351673e-01f, 2.56621122e-01f, 7.79277444e-01f, -1.04875040e+00f, -1.03478706e+00f, -7.68393397e-01f, 6.47260070e-01f, 7.93807566e-01f,
  -1.05535960e+00f, -2.80186832e-01f, -1.04789174e+00f, -1.03088431e-02f, -1.62645996e-01f, 1.00775611e+00f, 6.54155433e-01f, -4.69324946e-01f, -5.10589361e-01f, 3.44070226e-01f,
  -3.86579067e-01f, -8.68005633e-01f, 7.10946918e-02f, -1.60440713e-01f, 5.21680474e-01f, -1.46160692e-01f, 3.64724249e-01f, 1.34438291e-01f, -1.35807991e-01f, -7.54615963e-01f,
  4.23681289e-02f, 4.03302282e-01f, 5.97051620e-01f, -7.58028179e-02f, 5.45127392e-02f, -1.45748687e+00f, -6.88628316e-01f, -1.52648807e+00f, -6.27599716e-01f, -6.40794933e-01f,
  -6.44953698e-02f, -7.39618838e-01f, -1.53308105e+00f, -8.22151005e-01f, -6.55726492e-01f, 2.86764145e-01f, 9.71876800e-01f, -5.88474095e-01f, -5.48889041e-01f, -6.04026854e-01f,
  4.82444078e-01f, 4.20107663e-01f, -9.35004592e-01f, 3.56476530e-02f, -2.60877967e-01f, -3.15814137e-01f, 8.90919007e-03f, -2.93738455e-01f, -1.01230279e-01f, -3.63503881e-02f,
  -3.02225590e-01f, 1.48132533e-01f, 2.30737239e-01f, -2.61916220e-02f, 2.22040072e-01f, -1.08151443e-01f, -1.08753455e+00f, -3.20918351e-01f, -1.17467694e-01f, 8.69339705e-01f,
  -4.74167705e-01f, 2.04873368e-01f, -1.16412766e-01f, -6.24384761e-01f, -6.16447985e-01f, -4.03180808e-01f, 5.15096247e-01f, -4.69509631e-01f, -4.98040825e-01f, 1.27300024e+00f,
  -5.92560649e-01f, -5.13488173e-01f, -1.17299169e-01f, -7.62496829e-01f, -5.36190808e-01f, 6.52064025e-01f, -2.20746234e-01f, -5.96137298e-03f, -3.51218939e-01f, -2.03653172e-01f,
  9.17722210e-02f, -6.91226795e-02f, 4.11101133e-01f, -1.25282332e-01f, 4.17729437e-01f, -3.28631043e-01f, 9.23022628e-02f, -1.78415224e-01f, -9.61175799e-01f, 2.90746331e-01f,
  4.48917896e-01f, 5.04223228e-01f, 7.63986945e-01f, -4.72755700e-01f, -7.39141464e-01f, -1.09509408e+00f, -1.53745070e-01f, -9.65891004e-01f, -1.39645860e-01f, -2.31907651e-01f,
  -7.90852547e-01f, 2.47333586e-01f, 3.48389298e-01f, -3.47284377e-02f, 5.38669705e-01f, 1.18363607e+00f, -4.51923311e-01f, -6.69490397e-01f, -2.60547161e-01f, 1.80908233e-01f,
  -4.01056930e-03f, 4.55317199e-02f, 9.49921831e-02f, -1.09542027e-01f, -4.59940076e-01f, 6.58873677e-01f, -9.18584764e-02f, 2.41268069e-01f, 3.39297712e-01f, 2.34867454e-01f,
  -5.94515204e-01f, 1.06202435e+00f, -1.25803363e+00f, -8.34242776e-02f, -8.29392433e-01f, -7.29305804e-01f, 4.07452792e-01f, 8.29278708e-01f, 1.17014360e+00f, -5.90319455e-01f,
  -1.11747420e+00f, -8.86275291e-01f, 4.65518445e-01f, -1.09152329e+00f, -4.02879983e-01f, -1.10248530e+00f, -1.91656649e-01f, -6.58177376e-01f, -6.28018498e-01f, 5.04322767e-01f,
  8.96222889e-02f, 1.37352079e-01f, 2.37588119e-02f, 1.25100896e-01f, -3.65462154e-01f, -9.42353830e-02f, 1.27247125e-01f, -1.20215803e-01f, -2.27659345e-02f, 1.14389174e-01f,
  5.67370117e-01f, 2.55609691e-01f, 5.87421000e-01f, 1.89639315e-01f, 7.58017600e-01f, 4.53180611e-01f, 6.95501804e-01f, -8.15029681e-01f, -5.25334239e-01f, -1.05338979e+00f,
  5.42488098e-01f, 3.68640482e-01f, -7.75349140e-01f, -6.70169890e-01f, -5.09771049e-01f, 2.65619546e-01f, -1.30308187e+00f, 2.86784228e-02f, -4.01005864e-01f, 8.13730419e-01f,
  -8.17593694e-01f, -7.52909720e-01f, 3.46505165e-01f, -1.07504919e-01f, -1.04586698e-01f, -2.86766756e-02f, 3.04728329e-01f, 2.14902148e-01f, 7.25242615e-01f, -8.45241323e-02f,
  -6.37241006e-01f, -7.57973194e-02f, -9.33221340e-01f, -4.02195007e-01f, -7.83908486e-01f, 1.76672265e-01f, -7.82405078e-01f, -5.42217493e-01f, -4.81798470e-01f, -1.46306026e+00f,
  -1.04266369e+00f, -5.96581042e-01f, 1.16542888e+00f, -4.77460235e-01f, 7.22735941e-01f, 8.07612777e-01f, -8.64675343e-01f, -8.96433294e-01f, -2.60307401e-01f, -5.77169716e-01f,
  1.02575220e-01f, -1.10403314e-01f, -8.19301784e-01f, 6.81116760e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.59496230e-01f, -4.22955513e-01f, 1.75691605e-01f, -1.12787235e+00f, 4.07021716e-02f, 3.17636549e-01f, 7.29008138e-01f, -5.11569858e-01f, -8.65889788e-01f, 1.13548502e-01f,
  -1.00063038e+00f, -8.30683559e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    