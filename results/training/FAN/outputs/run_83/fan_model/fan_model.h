/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.81280717e-01f, 5.24214134e-02f, -3.16920504e-02f, 1.76965460e-01f, -1.18967853e-01f, 2.66438067e-01f, 2.79939741e-01f, -1.28003493e-01f, 1.50504708e-01f, -1.15463555e-01f,
  5.63299004e-03f, 1.11618452e-02f, -1.14362806e-01f, 2.32607305e-01f, 3.09403867e-01f, 1.45964921e-01f, 8.41356590e-02f, -3.60319056e-02f, 1.60553560e-01f, -9.29489732e-02f,
  7.43378773e-02f, -1.39063418e-01f, 2.15915397e-01f, -2.17213184e-01f, 7.30733201e-02f, 2.60784552e-02f, -1.44794479e-01f, -1.48539856e-01f, -1.93432551e-02f, -7.15387836e-02f,
  -8.93670768e-02f, 6.86952993e-02f, -7.84470513e-02f, -1.06284283e-01f, -6.82500973e-02f, -8.60448554e-02f, -6.46600276e-02f, 4.33283821e-02f, 1.01290047e-01f, 8.92025456e-02f,
  8.22395235e-02f, 8.57152697e-03f, 6.65474162e-02f, 5.90682612e-04f, 1.09940164e-01f, -3.08017340e-02f, 2.49446929e-02f, 5.95967397e-02f, -1.33141251e-02f, 1.35414198e-01f,
  1.53740510e-01f, 1.35245264e-01f, 6.70588240e-02f, 2.42625158e-02f, 2.14827955e-02f, 9.68038514e-02f, -1.08859111e-02f, -1.95239671e-02f, 2.38396171e-02f, 6.04931591e-03f,
  -3.76185984e-03f, 1.57023668e-02f, -9.01607573e-02f, 5.39225638e-02f, -4.99973865e-03f, -8.53943173e-03f, -7.55689591e-02f, -9.98019576e-02f, 8.28790739e-02f, -1.87237933e-02f,
  1.07668771e-03f, 1.67848859e-02f, 4.02257964e-02f, -2.70253550e-02f, -4.37578298e-02f, 4.79500853e-02f, -3.35510485e-02f, 2.45106053e-02f, 6.04747012e-02f, 7.17675090e-02f,
  -1.68288015e-02f, -8.24436918e-03f, 7.25849718e-02f, -4.96041104e-02f, -1.46048814e-02f, 2.81628221e-02f, 4.92761843e-02f, 4.51603532e-02f, 7.30789974e-02f, -1.14272632e-01f,
  -2.41504759e-01f, -2.94501454e-01f, -4.94683869e-02f, -2.18593664e-02f, 1.96413938e-02f, 6.19247183e-02f, -2.90519529e-04f, 3.71932872e-02f, -8.60612020e-02f, 8.57761502e-03f,
  -1.89499334e-01f, -4.20167893e-02f, -4.56179604e-02f, 8.48352611e-02f, -8.62200335e-02f, -1.30112125e-02f, -1.10834062e-01f, -1.56600866e-02f, -1.57291479e-02f, -4.21637967e-02f,
  -9.48144719e-02f, -4.23323549e-02f, 9.19248089e-02f, -2.63004354e-03f, -5.55531159e-02f, 2.33302694e-02f, -1.16925072e-02f, 1.27646867e-02f, 8.77644271e-02f, -9.14447766e-04f,
  2.65377879e-01f, -1.13485083e-01f, -5.61468154e-02f, 9.40447822e-02f, 2.44908378e-01f, -8.50853398e-02f, -3.82211268e-01f, 3.34476237e-03f, -1.22258954e-01f, -2.05686495e-01f,
  -1.03275226e-02f, 4.11961898e-02f, -3.37600440e-01f, 2.65573382e-01f, 6.43782914e-02f, -3.23763579e-01f, 1.29147291e-01f, -8.22995156e-02f, -2.57379506e-02f, 1.11541338e-01f,
  7.53987134e-02f, 2.45722800e-01f, -1.64796710e-02f, 3.50660741e-01f, 9.74876285e-02f, -1.70462076e-02f, 2.46166289e-01f, -7.34355748e-02f, 1.86011061e-01f, 3.09146475e-02f,
  1.52773224e-03f, 3.67876068e-02f, -2.73133460e-02f, -2.51488294e-02f, -1.53038679e-02f, 5.04788794e-02f, -4.98224646e-02f, -7.84752816e-02f, 1.32572912e-02f, -3.24939676e-02f,
  -4.80557010e-02f, 8.89210496e-04f, -1.05085047e-02f, 5.91968698e-03f, 3.68445106e-02f, 5.39684203e-03f, 2.79390328e-02f, -5.15663438e-02f, -3.89186665e-02f, -8.33458379e-02f,
  -1.01184353e-01f, -1.91717036e-02f, 9.20618251e-02f, 3.42949219e-02f, 9.68289897e-02f, -2.85298657e-02f, -6.45716786e-02f, -3.04429457e-02f, -1.75050218e-02f, 3.20611261e-02f,
  5.86237274e-02f, 2.70779580e-02f, 8.76966305e-03f, -6.81821704e-02f, -4.97704744e-02f, -1.25192208e-02f, 2.99621150e-02f, -1.16596802e-03f, 3.26724239e-02f, -8.73978063e-02f,
  -1.87091604e-02f, 2.26585530e-02f, -4.79194336e-02f, -6.28338903e-02f, 3.67681682e-02f, -2.86225136e-02f, -3.26071084e-02f, 9.36178025e-03f, 3.60471494e-02f, -1.19513553e-02f,
  -6.55747056e-02f, -1.60710700e-02f, 2.72007380e-02f, 6.34907857e-02f, 5.11337928e-02f, 6.86015422e-03f, 9.77514014e-02f, 6.59618899e-02f, -5.30605428e-02f, 5.77144288e-02f,
  -9.65367444e-03f, 3.16751227e-02f, -7.66533762e-02f, -1.48461526e-02f, 6.08966090e-02f, 5.91324009e-02f, 7.01600909e-02f, 1.17280394e-01f, 6.47406578e-02f, 4.40655015e-02f,
  1.92174781e-02f, -1.80224180e-02f, 3.59161496e-02f, 7.76459798e-02f, 1.48515582e-01f, -5.88616915e-03f, 4.95629907e-02f, 2.48437077e-02f, 2.96619609e-02f, 8.14376697e-02f,
  5.54320738e-02f, 5.36470767e-03f, 6.72497675e-02f, 5.80364503e-02f, 3.61671858e-02f, 1.19341025e-02f, -1.27428230e-02f, -1.89842768e-02f, -3.44933905e-02f, -8.80024508e-02f,
  -5.31834625e-02f, -3.86426300e-01f, 2.01719955e-01f, -2.55754411e-01f, 3.12146097e-01f, 3.87531132e-01f, 1.41767234e-01f, -6.59736767e-02f, -1.46140158e-01f, -1.59751758e-01f,
  6.09102212e-02f, -1.07425191e-02f, -6.41574189e-02f, -7.44205192e-02f, 4.59065646e-01f, -2.47816727e-01f, -5.50787896e-03f, 3.14289145e-02f, -1.53734729e-01f, -5.59700467e-02f,
  -1.89892836e-02f, 5.39183803e-02f, 6.80648610e-02f, -9.81174782e-02f, 2.10365146e-01f, -7.07154199e-02f, 2.65220013e-02f, 1.34429201e-01f, 1.82964772e-01f, 7.76843727e-02f,
  7.33034089e-02f, -1.63975492e-01f, -3.77965607e-02f, -2.08423827e-02f, 1.37872443e-01f, 5.52985556e-02f, 1.13880076e-01f, 1.16339354e-02f, 1.10573262e-01f, 9.81185585e-03f,
  -2.85670962e-02f, 5.53603731e-02f, -8.72716457e-02f, 1.02540432e-02f, 8.04961845e-02f, -2.41091289e-02f, 6.38201609e-02f, 1.34408036e-02f, -3.06343473e-03f, 4.59868498e-02f,
  1.01457480e-02f, 1.54864360e-02f, 6.21234030e-02f, -2.77081653e-02f, 4.75004762e-02f, -2.92134415e-02f, -7.28019103e-02f, 1.11795202e-01f, 1.02807269e-01f, 1.88179091e-02f,
  1.76526159e-02f, -2.42951866e-02f, -6.00128397e-02f, -2.04807450e-03f, 2.52698325e-02f, 9.14004818e-02f, 5.39930984e-02f, 2.88519897e-02f, 1.01913661e-01f, -3.44535969e-02f,
  3.02742086e-02f, -1.16809141e-02f, -2.04978436e-02f, 3.01105753e-02f, -2.74899863e-02f, -1.61767174e-02f, -8.66181999e-02f, 2.65169311e-02f, 1.04558609e-01f, 1.76840313e-02f,
  2.27853470e-03f, 7.19352961e-02f, 1.52882561e-02f, 3.74076702e-02f, -5.19868694e-02f, -1.07224792e-01f, -5.95197715e-02f, 2.70849410e-02f, -4.40268628e-02f, 8.43275115e-02f,
  -4.96038161e-02f, -1.94701597e-01f, -9.46857259e-02f, 3.56436744e-02f, 1.57928921e-03f, 2.81555895e-02f, -2.97947377e-02f, -6.92562908e-02f, 6.69204816e-02f, 4.51147668e-02f,
  5.15376329e-02f, 2.57193670e-02f, 6.48619533e-02f, -5.92713729e-02f, 9.94019303e-03f, -2.35645566e-02f, 1.37077260e-03f, 7.93824643e-02f, 8.62564147e-02f, 5.69200190e-03f,
  -6.36721030e-02f, -1.42616751e-02f, 1.02892026e-01f, -4.81233299e-02f, 6.36528293e-03f, 4.70014215e-02f, 1.19857930e-01f, -7.93629661e-02f, 7.09611326e-02f, 1.07354634e-01f,
  5.10078728e-01f, 1.72297359e-01f, -7.49004679e-03f, 2.50358045e-01f, 1.17244057e-01f, -2.10308507e-02f, -7.46876970e-02f, 1.74949735e-01f, 4.15116735e-02f, 3.54138315e-02f,
  4.10195589e-02f, 1.39571920e-01f, -1.72456577e-01f, 1.27894223e-01f, 4.78814095e-02f, -1.95674598e-01f, 1.65134788e-01f, 4.20891633e-03f, -6.18574694e-02f, 1.29756689e-01f,
  4.19343524e-02f, 1.38667777e-01f, 1.83492452e-02f, -1.22363735e-02f, 1.21256575e-01f, -2.09490769e-02f, -2.79775895e-02f, -1.54346615e-01f, 2.07288548e-01f, 1.29607115e-02f,
  3.18206809e-02f, 5.00479639e-02f, 1.46476431e-02f, -8.47946033e-02f, 3.40372175e-02f, 2.05976740e-02f, 5.07334955e-02f, -9.97408405e-02f, -9.68778953e-02f, 4.93839160e-02f,
  2.01806650e-02f, 1.24039911e-02f, -4.33091959e-03f, -1.21499658e-01f, -6.31604120e-02f, 1.82886850e-02f, -5.70185110e-03f, 7.15053752e-02f, 7.27096573e-02f, -7.04294443e-02f,
  1.17611848e-02f, 7.52213746e-02f, 2.71436549e-03f, -5.33063263e-02f, -5.42516746e-02f, -3.17950845e-02f, 5.45467064e-02f, -4.45165392e-03f, 8.09791982e-02f, 8.61555561e-02f,
  1.06949089e-02f, -3.02669611e-02f, -3.14148329e-02f, 1.88266323e-03f, 8.89853761e-02f, 4.57881540e-02f, -1.12567879e-01f, -1.06429392e-02f, 5.00982348e-03f, 6.72279373e-02f,
  4.10328135e-02f, 2.68226583e-02f, 7.05714598e-02f, -6.57164454e-02f, 9.16434638e-03f, -1.83712430e-02f, -7.53163472e-02f, 2.31638551e-02f, -3.10276709e-02f, 6.64378107e-02f,
  -2.92537902e-02f, -9.10823513e-03f, 6.47843927e-02f, 2.89183874e-02f, 7.28057474e-02f, -5.85687310e-02f, -8.78585386e-04f, -1.62635092e-02f, 1.89566356e-03f, -1.64731906e-03f,
  1.71105430e-01f, 5.52991144e-02f, 5.36829652e-03f, 1.87993143e-02f, 5.93753867e-02f, -8.01298395e-02f, -3.87350880e-02f, 4.52017710e-02f, -5.51951006e-02f, 7.08931386e-02f,
  -8.06123018e-03f, -2.84500476e-02f, 4.61029224e-02f, -8.62951856e-03f, -6.10772558e-02f, -2.04035398e-02f, 2.78947614e-02f, 2.29030680e-02f, 3.01633216e-02f, 1.44840062e-01f,
  3.50187644e-02f, 2.14685649e-02f, -8.40301737e-02f, -1.28479507e-02f, -2.07608342e-02f, 9.70736668e-02f, -4.65577841e-02f, 5.11788577e-03f, -1.60862301e-02f, -7.53175095e-02f,
  -7.44661838e-02f, -5.89561798e-02f, 2.57299185e-01f, -8.27923417e-03f, 1.63995698e-01f, 8.74803811e-02f, 7.72038698e-02f, 8.74226689e-02f, 4.26140964e-01f, -5.57341337e-01f,
  -1.24302797e-01f, -1.52467340e-01f, -3.72156538e-02f, -1.78064436e-01f, 3.40560526e-01f, 2.91005880e-01f, -6.18609339e-02f, -9.21377167e-02f, 2.92418063e-01f, -8.91951025e-02f,
  -1.11704564e-03f, -3.05690199e-01f, 2.88148187e-02f, -9.47363079e-02f, -9.47439894e-02f, -5.02713360e-02f, -2.93429404e-01f, 4.01995294e-02f, -2.29061320e-01f, 1.62720725e-01f,
  1.01185434e-01f, 2.71666683e-02f, -6.57383725e-02f, 7.52059072e-02f, -8.22280198e-02f, -7.10143223e-02f, -5.50536588e-02f, 3.65586914e-02f, -1.23403724e-02f, 1.07074110e-02f,
  -3.31179649e-02f, -5.01937158e-02f, 7.35201240e-02f, 4.35819738e-02f, 8.39197263e-02f, 6.31772876e-02f, -8.87657404e-02f, 5.34173893e-03f, -1.26206502e-01f, 3.25061455e-02f,
  2.13764794e-02f, 4.20749635e-02f, -2.45898049e-02f, 9.98073816e-03f, 6.62225857e-02f, 1.15233632e-02f, -5.61312921e-02f, 1.18129924e-01f, -4.26980220e-02f, 3.06761712e-02f,
  4.47925031e-02f, 5.09026274e-02f, -7.51288757e-02f, -1.65806338e-02f, -4.43778522e-02f, -2.18775235e-02f, -5.23756519e-02f, 4.51836456e-03f, 2.92885378e-02f, 2.99590975e-02f,
  -4.17263582e-02f, -7.50400173e-03f, 8.21004733e-02f, 1.73672345e-02f, -2.48711426e-02f, -4.42299386e-03f, -6.87512849e-03f, -4.84628975e-02f, 5.08623496e-02f, 4.13470194e-02f,
  8.23995546e-02f, 8.47083479e-02f, -1.28999606e-01f, 1.06554134e-02f, 9.59150568e-02f, -1.27630243e-02f, -7.77194649e-02f, 3.19062658e-02f, 1.06726795e-01f, -1.05482616e-01f,
  -3.99461240e-02f, -1.14976458e-01f, -1.51299108e-02f, -3.99867296e-02f, 3.10153991e-04f, -8.11330751e-02f, 8.01717564e-02f, -5.76962903e-02f, -7.39431158e-02f, -6.35074303e-02f,
  -3.61896791e-02f, -1.44680709e-01f, -7.06146732e-02f, 3.57252359e-02f, -1.15964347e-02f, -2.93965563e-02f, -8.10896233e-02f, 1.20776016e-02f, -8.42951462e-02f, -2.56109871e-02f,
  -1.59155592e-01f, -6.41647354e-03f, -2.92717554e-02f, -1.74574330e-01f, -4.07622308e-02f, -1.86248813e-02f, -1.78191345e-02f, 4.18888638e-03f, -1.59430094e-02f, 6.41533062e-02f,
  3.24717094e-03f, -1.61268711e-01f, -8.55134428e-02f, 2.20142394e-01f, 7.51042515e-02f, 1.38480008e-01f, 9.46820304e-02f, 7.05472529e-02f, 6.65968135e-02f, 3.23228426e-02f,
  3.60138625e-01f, -6.08248003e-02f, 1.30155191e-01f, 3.93904746e-01f, 5.71955919e-01f, 4.25602272e-02f, 2.76239783e-01f, 1.34362951e-01f, 8.16195458e-02f, 7.76428357e-02f,
  9.59376544e-02f, 2.73159027e-01f, 1.61267668e-01f, 4.32524234e-02f, 1.42124310e-01f, -2.18554392e-01f, 2.96505719e-01f, -1.11728042e-01f, -2.88184341e-02f, 1.02996349e-01f,
  4.37269360e-02f, -3.18151042e-02f, 1.83512196e-02f, -4.07668855e-03f, 4.76702489e-02f, -8.82083625e-02f, -8.29277188e-03f, -1.12101166e-02f, -3.37527953e-02f, -1.11563586e-01f,
  -3.93631309e-02f, -5.58061339e-02f, 6.53909072e-02f, 1.47988414e-02f, 5.32099139e-03f, 5.36791002e-03f, -5.53083234e-03f, 5.82335815e-02f, -6.91817775e-02f, 5.51166832e-02f,
  -3.13240476e-02f, 2.37159012e-03f, 6.05973452e-02f, -3.65200937e-02f, 6.22424446e-02f, -5.01959138e-02f, -2.68747862e-02f, -4.60000373e-02f, -7.09770471e-02f, -7.42846280e-02f,
  -1.18479013e-01f, 3.72069553e-02f, 3.43070664e-02f, 5.14774933e-04f, 7.08239973e-02f, 2.27375664e-02f, -1.67480316e-02f, 8.08729455e-02f, 3.83879687e-03f, 1.73282460e-03f,
  -2.42778882e-02f, 4.22460921e-02f, 8.12075809e-02f, -4.12730686e-02f, -9.34719816e-02f, -1.86783858e-02f, 9.16217547e-03f, -5.58870286e-02f, -3.35125178e-02f, 9.85246152e-02f,
  5.81941158e-02f, 1.39269516e-01f, -2.08190419e-02f, 3.16238060e-04f, 5.91028333e-02f, -1.68094188e-02f, -5.52467331e-02f, -4.06861119e-02f, 1.45918550e-02f, -3.03559359e-02f,
  -3.16930655e-03f, -6.34312853e-02f, -1.02195153e-02f, 7.04064742e-02f, -7.32745379e-02f, 5.58290705e-02f, 1.17089875e-01f, -2.72780769e-02f, -2.32325476e-02f, 3.11594270e-03f,
  4.79446277e-02f, 2.34666690e-02f, -5.44598550e-02f, -6.56672344e-02f, 1.28430992e-01f, 8.22782815e-02f, -7.73103209e-03f, -3.95143516e-02f, 5.05108424e-02f, 7.23116994e-02f,
  8.58997647e-03f, -3.04402709e-02f, -3.15624960e-02f, -2.40002968e-03f, -1.44871222e-02f, -1.29313618e-01f, -8.15566778e-02f, 1.46245873e-02f, 8.60293359e-02f, 5.25103183e-03f,
  -7.48538911e-01f, 1.26005635e-01f, 6.20811880e-02f, -1.61123008e-01f, -1.03038311e-01f, 8.48837048e-02f, 8.33642930e-02f, 8.94508418e-03f, -7.48696774e-02f, 2.04550788e-01f,
  1.34768814e-01f, -2.73975227e-02f, 1.43839076e-01f, -6.16069920e-02f, -6.04626089e-02f, 1.02240399e-01f, -8.41150731e-02f, -1.22589059e-02f, -3.78330052e-03f, 1.65388770e-02f,
  -6.69742152e-02f, 1.19915139e-02f, -4.63592485e-02f, 4.26756255e-02f, -1.18229404e-01f, 6.73858915e-03f, 3.78647447e-02f, 6.10372014e-02f, -1.59326360e-01f, -3.01355943e-02f,
  4.60656025e-02f, 2.27609202e-02f, -1.88537594e-02f, 1.04489923e-01f, 7.56464005e-02f, 6.11930229e-02f, -1.01351589e-01f, 7.76476860e-02f, -2.16567367e-02f, -3.85340564e-02f,
  -2.80477405e-02f, -4.40895222e-02f, 1.12242453e-01f, 4.64395843e-02f, -1.26381442e-01f, -3.68364900e-02f, -5.48683554e-02f, -5.92704341e-02f, 7.46592181e-04f, 4.19099769e-03f,
  4.77069840e-02f, -3.06662004e-02f, -4.30843718e-02f, 8.91209617e-02f, -3.64365876e-02f, 3.86581309e-02f, -2.40582507e-03f, 2.23599188e-02f, -6.43550158e-02f, 7.91683272e-02f,
  -3.05178575e-02f, 3.88315134e-02f, -1.32811060e-02f, -4.08981182e-02f, 8.30428023e-03f, -6.75919428e-02f, -2.15531252e-02f, -4.82354760e-02f, -8.78307447e-02f, 3.62475142e-02f,
  -1.02391001e-02f, -4.16406803e-02f, 5.92654385e-02f, -4.98868600e-02f, -1.04462713e-01f, -8.02497007e-03f, -2.58191694e-02f, 5.33248484e-02f, 1.69032607e-02f, 7.51169622e-02f,
  1.69107690e-02f, 1.97591148e-02f, 5.28814271e-02f, 3.71602029e-02f, 4.45841812e-02f, -8.17766115e-02f, 6.99766446e-03f, -2.39171591e-02f, -1.48730185e-02f, -3.85749131e-03f,
  1.17469266e-01f, 2.88746208e-01f, 7.07079396e-02f, -3.56786288e-02f, 8.53577256e-02f, 2.31883326e-03f, -4.70264116e-03f, 7.18346909e-02f, -2.94265989e-02f, -8.49481672e-04f,
  7.43115961e-04f, -3.01497243e-02f, -7.80428178e-04f, 2.58183274e-02f, 2.49566250e-02f, 4.71595377e-02f, 5.59597164e-02f, 1.31618813e-01f, 2.98662833e-03f, 1.42465815e-01f,
  1.22019788e-02f, 6.62248284e-02f, -4.82971147e-02f, 5.50061166e-02f, 4.67965193e-02f, 8.95565376e-02f, 5.02861664e-03f, -3.87304798e-02f, 5.66674918e-02f, 1.29544690e-01f,
  -2.24794641e-01f, -1.55848235e-01f, 3.20099853e-02f, -2.22394764e-01f, -1.05644710e-01f, -1.31590605e-01f, 1.16450377e-01f, -1.88270405e-01f, -7.74201974e-02f, -1.97826087e-01f,
  2.79389340e-02f, 1.43795967e-01f, 2.89794832e-01f, -2.83109099e-01f, 4.31842923e-01f, 2.78851151e-01f, -9.04291645e-02f, -2.27779523e-02f, 1.11955993e-01f, 1.23973619e-02f,
  -4.89451960e-02f, -2.50633657e-01f, 7.19884336e-02f, -2.40243539e-01f, -2.41499409e-01f, -7.19463974e-02f, -8.68738741e-02f, 1.53872758e-01f, -2.50006437e-01f, 1.82867199e-02f,
  4.96437214e-02f, 4.58100531e-03f, -4.39852327e-02f, -4.96339314e-02f, -1.72114819e-02f, -3.70433778e-02f, 3.93889137e-02f, 1.02210097e-01f, -1.44805061e-02f, -2.53719259e-02f,
  -2.68520750e-02f, -4.09629829e-02f, -8.05514455e-02f, 2.98462007e-02f, -4.24765982e-03f, -5.83943948e-02f, -1.04428679e-02f, -3.26378979e-02f, -3.51823643e-02f, 2.65167211e-03f,
  5.24642467e-02f, -9.84285865e-03f, -7.62867858e-05f, -3.85281406e-02f, -7.42888544e-04f, 2.49488037e-02f, -3.29761058e-02f, 5.33963814e-02f, -1.12396337e-01f, -1.56850457e-01f,
  -9.27526802e-02f, -4.58121579e-03f, 1.27526941e-02f, 3.65617760e-02f, 6.25660568e-02f, -1.42436670e-02f, -2.78915223e-02f, -6.85494989e-02f, -5.60546666e-02f, -3.43903229e-02f,
  5.10877557e-02f, 8.85139219e-03f, 4.26489227e-02f, -6.20246977e-02f, -4.94270995e-02f, -1.19844630e-01f, 2.89938580e-02f, 1.24520073e-02f, 4.20064442e-02f, 7.77482986e-03f,
  7.30517581e-02f, 3.98597680e-02f, 2.69274786e-02f, -5.98590262e-02f, 3.21377884e-03f, -3.10946107e-02f, -2.73327697e-02f, -7.58195017e-03f, 8.08268338e-02f, 4.79797693e-03f,
  -4.88547096e-03f, -3.33036408e-02f, 4.66821045e-02f, -1.45234764e-02f, 7.45954290e-02f, 3.30686495e-02f, -6.40010387e-02f, -8.27804282e-02f, -9.53735132e-03f, 1.61727574e-02f,
  -1.29057784e-02f, -7.08303452e-02f, 7.66697824e-02f, -4.33064029e-02f, -1.05059827e-02f, 1.47544756e-03f, 8.96132067e-02f, 4.19828705e-02f, -7.12367147e-02f, -2.30208300e-02f,
  -1.61424857e-02f, 5.94350174e-02f, 3.12648062e-03f, 3.80662158e-02f, -6.14165626e-02f, 1.04844891e-01f, -7.53075704e-02f, -1.95015669e-02f, 8.03397298e-02f, 6.69249706e-03f,
  -4.86201197e-01f, -1.84674412e-01f, 4.11412567e-02f, -1.05316922e-01f, -2.29015037e-01f, -2.50715703e-01f, -2.90269405e-02f, -9.57772434e-02f, -3.31756532e-01f, -3.85055952e-02f,
  -5.37601449e-02f, 6.86335266e-02f, 7.45424107e-02f, 1.39165774e-01f, -4.24552411e-02f, 1.26600429e-01f, -1.64968863e-01f, -6.38599992e-02f, -9.39040780e-02f, -6.99975714e-02f,
  1.99628295e-04f, -2.17362326e-02f, 2.61973441e-01f, 2.32817214e-02f, -1.65926382e-01f, -1.84530735e-01f, 3.66316326e-02f, 5.27926795e-02f, 3.47276703e-02f, 1.09481409e-01f,
  -1.72460318e-01f, -9.14252829e-03f, -3.42070833e-02f, 2.48172246e-02f, -3.68044227e-02f, 1.17313759e-02f, 1.15012281e-01f, 9.96424332e-02f, 7.41641074e-02f, 8.79294574e-02f,
  2.22062133e-02f, -4.33475291e-03f, 7.56058022e-02f, -1.15298733e-01f, -1.02043055e-01f, 2.33016610e-02f, 5.56690898e-03f, -4.41031568e-02f, 4.27890234e-02f, -8.25541168e-02f,
  4.72854637e-02f, 3.90151963e-02f, -1.01219513e-01f, -7.32588544e-02f, 6.86267242e-02f, -4.27245907e-02f, 4.63771895e-02f, 8.41413960e-02f, 1.40485819e-02f, -1.37868583e-01f,
  6.68730363e-02f, 9.62257236e-02f, -4.20329859e-03f, 5.68789318e-02f, 2.83531994e-02f, -7.33270347e-02f, 9.57963429e-03f, 1.16027839e-01f, 4.09995541e-02f, 2.60514021e-02f,
  -1.57405883e-01f, 4.43290100e-02f, 3.57534289e-02f, -3.91602069e-02f, -7.31127113e-02f, -1.43435091e-01f, -3.63760851e-02f, -3.01636960e-02f, -1.27626508e-01f, -2.19747517e-02f,
  7.43529871e-02f, -1.01059936e-02f, 4.05280292e-03f, 7.30301216e-02f, 6.17974252e-02f, 1.28487825e-01f, -3.04167741e-03f, -3.58564220e-02f, 1.55596271e-01f, -1.86912492e-02f,
  -3.41241360e-01f, -1.88336939e-01f, 9.08522680e-02f, -1.03018004e-02f, -3.97862010e-02f, -2.29625665e-02f, 4.85702343e-02f, 5.90294860e-02f, 1.48908161e-02f, 1.57110356e-02f,
  -5.66508546e-02f, -6.39061406e-02f, -2.05432296e-01f, -7.60339350e-02f, -2.71513755e-03f, -5.23032434e-02f, 3.54716331e-02f, -5.26930764e-02f, -6.63901642e-02f, -3.18202078e-02f,
  -3.69131900e-02f, -1.52377021e-02f, 5.80176115e-02f, -5.56536764e-03f, 3.23677771e-02f, 3.53017710e-02f, -6.95298016e-02f, 8.14497937e-03f, -1.13293277e-02f, 2.43966412e-02f,
  5.45073953e-03f, -3.46711010e-01f, 1.43346479e-02f, -5.54685257e-02f, -1.28646791e-01f, 1.08685009e-01f, 5.18080555e-02f, -1.59298927e-01f, -2.53708903e-02f, -1.96447268e-01f,
  -1.42536592e-02f, 1.32360682e-01f, 7.54340142e-02f, -1.34479180e-01f, 6.31204665e-01f, 1.50240555e-01f, 7.87210912e-02f, 1.73324738e-02f, -4.54315962e-03f, -1.57475814e-01f,
  -2.54893769e-02f, -7.24360645e-02f, 1.17144234e-01f, -2.86103755e-01f, -2.76560515e-01f, -4.20807451e-02f, 3.25503126e-02f, -1.22177146e-01f, -4.84221019e-02f, 2.95496341e-02f,
  9.76222381e-02f, -7.35182464e-02f, -5.28109334e-02f, 4.80797552e-02f, 6.13608435e-02f, 1.27181699e-02f, -8.07921402e-03f, 1.44677078e-02f, 2.42784061e-02f, -3.62363979e-02f,
  7.21844286e-02f, 4.25778478e-02f, -3.57772447e-02f, 2.73862272e-03f, -1.61674302e-02f, -1.79376192e-02f, -8.78743529e-02f, 2.43430026e-02f, 4.58644331e-02f, 8.23961496e-02f,
  -3.63764027e-03f, 5.44778742e-02f, 2.12819111e-02f, 9.89570096e-02f, 7.17790797e-02f, 2.29498022e-03f, 9.57358405e-02f, -4.46828008e-02f, -8.62379521e-02f, 1.21487230e-02f,
  6.75953925e-02f, -4.22851965e-02f, -1.21586904e-01f, -4.64506298e-02f, -1.01011403e-01f, -7.24124908e-02f, -1.05746975e-02f, 3.33222072e-03f, -1.53562412e-01f, -4.08655666e-02f,
  2.30509602e-02f, -7.43240714e-02f, -6.56508356e-02f, -3.68240802e-03f, 8.52798298e-03f, 5.93946166e-02f, 2.42324024e-02f, -7.34030977e-02f, 4.77432981e-02f, 6.65678317e-03f,
  9.77674946e-02f, 3.13501544e-02f, -1.61804855e-01f, 4.17939462e-02f, 6.58767717e-03f, -1.09274220e-02f, -2.84939613e-02f, -8.87356102e-02f, -9.11499560e-02f, 8.41414109e-02f,
  6.52051270e-02f, -3.11773345e-02f, 1.12971421e-02f, -1.83009449e-02f, -2.20358446e-02f, -7.38452300e-02f, -1.73199698e-02f, -3.48345712e-02f, 1.26454988e-02f, -1.10419514e-02f,
  6.58932030e-02f, -4.67085056e-02f, 2.42823781e-03f, -6.71723485e-02f, -5.59768677e-02f, -5.94576932e-02f, 2.47242600e-02f, -5.28561510e-02f, 7.07576126e-02f, 2.64098644e-02f,
  -2.39522774e-02f, -5.92665747e-02f, -3.71503904e-02f, 7.08152801e-02f, 4.57163602e-02f, 9.39962119e-02f, -2.71613412e-02f, 6.91261899e-04f, 3.06237116e-02f, 9.46799442e-02f,
  -1.93273470e-01f, -4.65666503e-02f, 1.57620937e-01f, 3.29807177e-02f, 2.24451870e-02f, -1.16679579e-01f, 3.90648656e-02f, -4.62650955e-02f, -1.46752998e-01f, -1.13475800e-01f,
  -1.25643581e-01f, -2.24898336e-03f, -1.53628975e-01f, -1.75832525e-01f, -2.30579138e-01f, -1.25284508e-01f, -1.79410070e-01f, -1.97835080e-02f, -1.71980277e-01f, 3.92406397e-02f,
  1.24670081e-02f, -1.33169457e-01f, 1.78019390e-01f, 1.62450075e-01f, 4.83585373e-02f, 2.98283339e-01f, -1.51391355e-02f, 2.33643398e-01f, -2.10678438e-03f, 4.23791707e-02f,
  2.71936953e-02f, -1.78214889e-02f, 3.25717628e-02f, 2.97354273e-02f, 3.74794118e-02f, 4.90181744e-02f, 8.25776160e-02f, 2.26755459e-02f, -9.56183895e-02f, -1.05988130e-01f,
  -8.57651141e-03f, -3.91577519e-02f, -2.65192566e-03f, 8.28479454e-02f, -1.14730336e-02f, -7.88614713e-03f, -3.33139747e-02f, 1.94825046e-02f, 5.49518019e-02f, 7.53952041e-02f,
  -6.83907652e-03f, 1.20770345e-02f, -1.87504627e-02f, 7.10501820e-02f, -3.98736121e-03f, -3.73591334e-02f, 1.23745389e-01f, 7.46559128e-02f, -6.45924807e-02f, 8.47036168e-02f,
  -5.83205409e-02f, 6.89958706e-02f, 3.09769046e-02f, 4.31877300e-02f, -5.32568954e-02f, 5.54906726e-02f, -8.73475671e-02f, -2.69112438e-02f, 2.96364930e-02f, 2.39955224e-02f,
  -8.03179108e-03f, 8.33729431e-02f, -5.17860353e-02f, -5.23169339e-03f, -1.24724191e-02f, 1.63261849e-03f, -3.71783320e-03f, 6.66794507e-03f, 6.19661137e-02f, 8.82134959e-02f,
  7.53573850e-02f, -8.12674463e-02f, -2.23834722e-04f, -5.03518507e-02f, -6.52452558e-02f, 1.84262153e-02f, 6.09857962e-02f, -7.14307372e-03f, 1.95544418e-02f, 2.85946764e-02f,
  -1.29329905e-01f, -2.27740407e-01f, 5.34117930e-02f, 9.04335454e-02f, 7.75577724e-02f, -1.17657997e-01f, -9.25963223e-02f, -4.76091634e-03f, -9.02374387e-02f, 1.89104918e-02f,
  2.97227502e-02f, -1.79203658e-03f, 2.51900665e-02f, 2.83835474e-02f, 2.93596704e-02f, -1.18216630e-02f, 3.60255986e-02f, 6.17456213e-02f, -2.09936220e-02f, 1.07460180e-02f,
  -6.85615884e-03f, -1.17702514e-01f, 1.21405229e-01f, 7.04558864e-02f, 1.28241003e-01f, 9.81135294e-02f, -6.52469546e-02f, 7.00799525e-02f, 3.68548334e-02f, -4.56737056e-02f,
  -3.87614104e-03f, -3.79900724e-01f, 6.78154454e-02f, 2.65509248e-01f, 3.28119218e-01f, 2.26766050e-01f, 3.03767115e-01f, 1.55604392e-01f, 2.13588551e-01f, 1.05375545e-02f,
  1.44740343e-01f, 3.33005264e-02f, -1.29003301e-01f, 2.03712121e-01f, 3.81235778e-01f, -8.92556310e-02f, 6.85848147e-02f, 7.52721354e-02f, -1.15830712e-01f, -9.85831767e-02f,
  5.64872250e-02f, 1.55595094e-01f, -3.95906940e-02f, -1.74329549e-01f, -6.56196848e-02f, -1.50121599e-01f, -6.99424669e-02f, -1.17848702e-02f, -5.17410189e-02f, 9.47131440e-02f,
  -1.37546733e-01f, -4.07726429e-02f, 4.26348336e-02f, -1.00613378e-01f, -4.71392311e-02f, -5.07804416e-02f, -1.08621046e-01f, 1.31855845e-01f, 6.42941743e-02f, 6.54930100e-02f,
  1.58639401e-02f, 3.44381444e-02f, 2.78172158e-02f, 1.07447162e-01f, -1.19574601e-03f, 3.66222523e-02f, 8.54374189e-03f, -6.78700348e-03f, -1.68483362e-01f, -3.79726365e-02f,
  -3.53332818e-03f, 1.82876457e-02f, -4.55587767e-02f, -5.69440946e-02f, -4.79702285e-04f, 2.82042883e-02f, 6.38759658e-02f, -1.61428377e-02f, 3.98417749e-02f, 5.74336350e-02f,
  -9.57082585e-02f, -3.47381979e-02f, 2.56887432e-02f, -1.48650184e-02f, 1.06470613e-02f, -4.37734984e-02f, 2.89820158e-03f, -1.63171086e-02f, -1.36305364e-02f, 2.35597342e-02f,
  6.55420404e-03f, 5.31162657e-02f, -3.67958136e-02f, -1.06691264e-01f, 1.18013071e-02f, -4.24915887e-02f, -1.59676764e-02f, 5.42362966e-03f, 1.81100406e-02f, -8.68992358e-02f,
  -7.82998651e-02f, 1.67467408e-02f, -1.04318643e-02f, -1.00564517e-01f, 5.08313775e-02f, 1.13824487e-01f, 3.83370854e-02f, 2.43490934e-02f, 1.93697326e-02f, 4.34721261e-02f,
  -2.21383452e-01f, -8.00461620e-02f, 9.53042042e-03f, 6.33799285e-02f, -2.97779180e-02f, -3.18861045e-02f, -5.87648153e-02f, 2.86790989e-02f, -8.95641595e-02f, 5.96072376e-02f,
  6.68275505e-02f, -1.39287971e-02f, -2.30365316e-03f, 9.81146768e-02f, -8.24559852e-03f, 5.38230389e-02f, -9.17368196e-03f, 2.72299461e-02f, 4.37080786e-02f, -5.29622324e-02f,
  -4.87312339e-02f, -2.90155914e-02f, 7.94259161e-02f, 3.92698459e-02f, -2.79666223e-02f, -4.40817922e-02f, -1.87322125e-02f, -1.69604179e-02f, -5.22675700e-02f, 9.14011616e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.29466701e-01f, 2.92408854e-01f, -1.22446470e-01f, -3.80027831e-01f, -1.01457767e-01f, -2.07419991e-01f, -4.08721387e-01f, 7.54093975e-02f, 4.51103188e-02f, -1.17785178e-01f,
  -1.87786728e-01f, 1.41292050e-01f, 1.30497396e-01f, -3.43012601e-01f, 1.09857418e-01f, 3.45708996e-01f, -3.14893842e-01f, -1.23918965e-01f, 1.62079081e-01f, -1.08638734e-01f,
  -3.67586315e-02f, -1.11405909e-01f, -1.80987209e-01f, 1.81461886e-01f, -4.34654772e-01f, -1.17887206e-01f, -2.53800213e-01f, -7.50959143e-02f, -2.53768712e-01f, 2.28509940e-02f,
  -2.83435106e-01f, -2.72137284e-01f, -1.60905123e-01f, -8.98390412e-02f, -2.11316124e-01f, -7.31403232e-02f, -9.22608376e-02f, -1.00570306e-01f, -9.79885012e-02f, 4.49859127e-02f,
  -1.13204628e-01f, 3.26701603e-03f, -4.46994379e-02f, 8.39258432e-02f, -5.11286184e-02f, -1.28073379e-01f, -8.85611400e-03f, 1.44361230e-02f, -1.14155104e-02f, 8.85447413e-02f,
  1.84106648e-01f, -1.58759594e-01f, -2.01241419e-01f, -5.78630716e-02f, -5.69328591e-02f, -7.59316757e-02f, -5.23484424e-02f, -6.85431585e-02f, -6.53450787e-02f, -5.22581749e-02f,
  4.65153120e-02f, 1.20464660e-01f, 3.81679311e-02f, -6.94943666e-02f, 1.43933028e-01f, 2.75329370e-02f, -3.41699109e-03f, -3.54720652e-02f, 9.72732455e-02f, -3.12341899e-02f,
  -7.27133602e-02f, -4.41922545e-02f, -1.03473492e-01f, -6.70304447e-02f, 3.10694128e-02f, 2.14191750e-02f, -2.50055715e-02f, -1.86581925e-01f, 1.06033027e-01f, 1.26493067e-01f,
  -1.15757789e-02f, -1.98328905e-02f, 2.81489752e-02f, 4.68152668e-03f, 5.26772402e-02f, 3.10806464e-02f, 2.97978688e-02f, -9.23078209e-02f, -1.20882578e-01f, -2.02258863e-02f,
  -2.50422060e-01f, -3.45929623e-01f, -6.66284263e-02f, -6.77287057e-02f, 5.05608357e-02f, 1.60064455e-02f, -5.27564483e-03f, -4.24953848e-02f, -7.37969503e-02f, 3.35791968e-02f,
  -1.35953382e-01f, -1.24726839e-01f, -9.14428905e-02f, 1.53568126e-02f, 6.04803041e-02f, -8.77251998e-02f, -1.47423428e-02f, -8.88019949e-02f, -1.06668562e-01f, 2.51855720e-02f,
  2.15573655e-03f, 7.15330616e-02f, 1.82418168e-01f, -7.13715330e-02f, -1.02281235e-01f, -2.19221011e-01f, 2.47628689e-02f, 2.03671888e-03f, -4.54412363e-02f, 3.69820334e-02f,
  2.75633242e-02f, -2.91083246e-01f, -2.13329326e-02f, 5.48728593e-02f, -5.58751673e-02f, -2.53566355e-01f, -9.61619914e-02f, -2.52492189e-01f, -5.56734353e-02f, -2.27635428e-01f,
  -3.77807841e-02f, 1.41326427e-01f, 8.63580778e-02f, -1.73404515e-01f, 4.35518444e-01f, 1.58356056e-01f, -8.84234384e-02f, 7.75956586e-02f, -3.23247500e-02f, -2.12841406e-01f,
  -1.00003660e-01f, -1.99382141e-01f, 1.36665955e-01f, -3.46241921e-01f, -1.73093453e-01f, -6.34512231e-02f, 1.23545632e-01f, 1.16290350e-03f, -6.74974248e-02f, 1.27463579e-01f,
  8.98061246e-02f, 6.80061849e-03f, -3.26025710e-02f, -5.74577264e-02f, -2.72396598e-02f, -3.16232033e-02f, -5.48319072e-02f, 1.08090512e-01f, 1.84560984e-01f, 2.21929373e-03f,
  3.53121981e-02f, 1.56701759e-01f, -3.68028171e-02f, 8.64846483e-02f, 1.04283355e-02f, -8.83772876e-03f, -7.12732086e-03f, 1.17737159e-01f, 6.85210824e-02f, -6.28860295e-02f,
  -6.73968196e-02f, 5.81438541e-02f, 1.63211673e-02f, 1.23694606e-01f, -6.68728948e-02f, 7.27031976e-02f, 6.40318682e-03f, 2.13290490e-02f, 6.94777742e-02f, 4.08271514e-02f,
  -9.75718573e-02f, -8.93371329e-02f, -5.70473559e-02f, 5.15842950e-03f, -7.57462084e-02f, -1.29118159e-01f, -2.62900665e-02f, -7.61121735e-02f, -1.19441999e-02f, -2.45484281e-02f,
  1.21916346e-01f, 4.52215746e-02f, -8.62315821e-04f, 5.67026064e-02f, -8.52976516e-02f, 3.07358857e-02f, 6.55680895e-02f, 1.86429340e-02f, 1.77355241e-02f, -4.04924899e-02f,
  6.58078073e-03f, -9.49217472e-03f, -1.02327116e-01f, 4.81145047e-02f, -3.82976085e-02f, 1.91044547e-02f, -3.76329795e-02f, 1.73489116e-02f, 2.22740509e-02f, -4.41814493e-03f,
  4.33624610e-02f, -2.17488915e-01f, -3.16854231e-02f, 4.88657653e-02f, -4.48976923e-03f, 5.72883785e-02f, -1.73300639e-01f, -3.91850062e-03f, 1.09201884e-02f, -1.23945817e-01f,
  -6.53328896e-02f, 8.12022686e-02f, -3.18624452e-02f, 1.07263550e-01f, 4.28474434e-02f, -8.17735493e-02f, 1.36010451e-02f, 1.07848808e-01f, 2.54743863e-02f, -4.56964225e-02f,
  -1.42515218e-02f, 6.33809492e-02f, 1.29252449e-01f, -1.52906068e-02f, -1.87567398e-02f, 3.55453454e-02f, -1.84306651e-02f, -7.72706047e-03f, 7.21625015e-02f, 1.32100005e-02f,
  -1.35840133e-01f, 3.83211195e-01f, -1.91948727e-01f, 1.60529450e-01f, -4.06103522e-01f, 4.61950749e-01f, 4.01219368e-01f, 6.82277000e-03f, 8.08212906e-02f, 4.46091950e-01f,
  9.81503054e-02f, 1.49959877e-01f, 2.20745176e-01f, 5.15858710e-01f, 1.63778037e-01f, 3.94207865e-01f, 4.47553605e-01f, 2.69746751e-01f, -6.69035409e-03f, 8.41208771e-02f,
  -7.40731582e-02f, 2.44006082e-01f, -5.93882836e-02f, -1.44907027e-01f, -1.53869659e-01f, -2.94566840e-01f, -1.89218417e-01f, -3.37035745e-01f, -1.97213795e-02f, -2.59461068e-02f,
  3.04070897e-02f, -1.78180169e-02f, -1.48061544e-01f, 6.27185479e-02f, -3.35087962e-02f, 2.05733571e-02f, -7.21904566e-04f, 1.94218550e-02f, -1.08156249e-01f, -5.49287200e-02f,
  8.01936351e-03f, -3.99908125e-02f, 1.48009434e-01f, -5.67800105e-02f, 1.62882544e-02f, -9.98002216e-02f, -1.01448476e-01f, -1.05782196e-01f, -2.01795883e-02f, -7.84628987e-02f,
  -1.11366987e-01f, 5.22130057e-02f, -9.79338214e-02f, 3.36322524e-02f, -1.23465113e-01f, -1.45777855e-02f, 1.58273160e-01f, -3.77481766e-02f, 3.63492258e-02f, 2.93471348e-02f,
  -5.26187383e-02f, 1.15027793e-01f, 3.36085632e-03f, 4.21898589e-02f, 3.84985209e-02f, -2.48417053e-02f, 4.62970957e-02f, 3.67193297e-02f, -8.15349594e-02f, 3.34816724e-02f,
  -6.64958581e-02f, -6.51029730e-03f, 1.26941800e-01f, 6.25590142e-03f, 3.78947854e-02f, -3.17430906e-02f, 2.69409474e-02f, -8.91115144e-02f, 2.26535890e-02f, -5.55205531e-02f,
  8.89407322e-02f, 6.93805665e-02f, -1.34112656e-01f, -4.72000916e-04f, 1.29617676e-01f, 6.88235322e-03f, -2.71357433e-03f, -6.01190329e-02f, -4.14139926e-02f, -5.78550994e-02f,
  2.12019265e-01f, 1.74289525e-01f, -1.89421214e-02f, 3.33398730e-02f, -3.54881212e-02f, 4.49389778e-02f, 2.97595635e-02f, -3.62406000e-02f, -8.90756678e-03f, 6.57813773e-02f,
  1.71723627e-02f, 5.06933872e-03f, 3.77852097e-02f, -4.36780266e-02f, -6.92318380e-02f, 5.34495600e-02f, 9.29320902e-02f, -9.08894092e-02f, -8.25173259e-02f, 1.22446986e-03f,
  -1.51469141e-01f, -3.39549221e-02f, -4.07969803e-02f, -7.47310296e-02f, 2.38566250e-02f, 6.28373679e-03f, -4.88407575e-02f, -6.48374632e-02f, 5.08662406e-03f, 9.80295762e-02f,
  -3.89554530e-01f, 9.40530654e-03f, 1.17923550e-01f, 6.03566110e-01f, -3.51486415e-01f, -3.75651985e-01f, -3.23542684e-01f, -7.03254789e-02f, -1.28493086e-01f, -1.33961573e-01f,
  -1.28616160e-02f, 9.22444463e-02f, -1.35943636e-01f, 4.42930162e-01f, 3.05061102e-01f, 1.38935417e-01f, 1.71971545e-01f, 5.51569685e-02f, 6.52204156e-02f, 2.09055349e-01f,
  3.35368365e-01f, 2.78549552e-01f, 5.42954504e-01f, 1.80108845e-01f, 7.68777356e-02f, 2.51623213e-01f, 3.37546647e-01f, 1.59077093e-01f, 3.61729294e-01f, 1.03716098e-01f,
  -1.82207048e-01f, 2.11992592e-04f, 9.35469270e-02f, -8.63900350e-04f, -1.69826187e-02f, -1.96800500e-01f, -5.97342663e-02f, 9.42905433e-03f, 1.94249228e-02f, -2.65851915e-02f,
  -4.79290672e-02f, 2.85083242e-02f, 1.14219785e-01f, 7.75525570e-02f, -5.86342365e-02f, 1.52434623e-02f, -7.44622648e-02f, -2.84457896e-02f, -5.62426485e-02f, 4.88506746e-04f,
  -3.23974416e-02f, 1.29260700e-02f, -5.32925762e-02f, 1.20332561e-01f, 1.62635017e-02f, 1.04677991e-03f, 5.25792800e-02f, -4.21865657e-03f, 9.72407833e-02f, 8.92914981e-02f,
  -1.42134443e-01f, -1.64558161e-02f, -1.28778946e-02f, 1.98161677e-02f, 2.97887884e-02f, -1.93599029e-03f, 1.37835085e-01f, 6.81902617e-02f, 4.13665511e-02f, -4.11132686e-02f,
  1.32627055e-01f, 6.62015006e-02f, -1.62267853e-02f, 5.49345985e-02f, -3.19263227e-02f, -6.32331148e-02f, -2.15838198e-02f, 1.02665015e-01f, 6.96554035e-02f, 1.29951667e-02f,
  3.70055996e-02f, 9.97662619e-02f, -6.99034259e-02f, -8.13315623e-03f, -4.30563465e-02f, -9.31884255e-03f, 1.81073938e-02f, 4.57622968e-02f, 8.81918520e-02f, -4.41078246e-02f,
  5.81346191e-02f, 3.53334308e-01f, -6.97574839e-02f, -1.02547802e-01f, 9.06115919e-02f, -4.64228122e-03f, 6.35685325e-02f, -3.79582159e-02f, 6.08121678e-02f, -2.99361888e-02f,
  -1.41272828e-01f, -3.77883837e-02f, 2.26025693e-02f, 3.93640250e-02f, 8.45278651e-02f, 3.08120530e-03f, 8.38013589e-02f, 1.19210824e-01f, 9.80490297e-02f, 8.98896828e-02f,
  -3.36265974e-02f, -1.46479249e-01f, -1.51149809e-01f, -1.03120498e-01f, -2.85400860e-02f, -4.34609540e-02f, 1.95512269e-03f, -1.09842263e-01f, 3.47915106e-03f, 1.83661371e-01f,
  3.56154114e-01f, -4.39644754e-02f, 1.08152129e-01f, 2.84055740e-01f, 1.09642133e-01f, -9.29631814e-02f, 1.29821464e-01f, -8.02209452e-02f, 3.34805459e-01f, -2.79836744e-01f,
  -6.10605106e-02f, 1.51086688e-01f, -8.20991118e-03f, -1.20454796e-01f, 2.55447894e-01f, 8.86025652e-02f, -1.78450778e-01f, -3.57614346e-02f, 7.20161125e-02f, -4.84103486e-02f,
  9.57714245e-02f, -1.96600035e-01f, -7.47203678e-02f, -3.53981227e-01f, -1.72649592e-01f, -1.38364106e-01f, -1.90566331e-01f, -1.70503393e-01f, -3.60580176e-01f, -1.22468539e-01f,
  1.21145621e-02f, 1.29082734e-02f, -1.99914463e-02f, -8.24215487e-02f, -1.26497755e-02f, -1.53062372e-02f, 5.29032387e-02f, -1.90776885e-02f, 8.57555121e-02f, 1.25098735e-01f,
  -1.06447726e-03f, -3.85855511e-02f, -4.45149504e-02f, -4.99033704e-02f, 3.32047381e-02f, -3.66876684e-02f, 1.61280796e-01f, 7.00417757e-02f, -4.99508195e-02f, 4.24015671e-02f,
  1.56472638e-01f, 6.96504563e-02f, -5.37222484e-04f, 4.52976227e-02f, 1.26797244e-01f, 1.17819533e-02f, 2.66455170e-02f, 1.09340072e-01f, 4.97019291e-02f, 1.39338523e-01f,
  -1.58403143e-01f, -1.81286633e-02f, -1.33749526e-02f, -4.95877229e-02f, -3.65423001e-02f, 1.96669484e-03f, 2.82859411e-02f, 4.07761931e-02f, 8.10990408e-02f, -4.58454303e-02f,
  -7.29660615e-02f, 1.67746209e-02f, 1.15914203e-01f, 6.42283782e-02f, 3.41556035e-02f, 6.36438793e-03f, 2.43312996e-02f, 5.39609790e-02f, 6.75801709e-02f, 3.91794071e-02f,
  -2.88610980e-02f, -6.66497424e-02f, -7.25882575e-02f, 4.97081690e-02f, 1.56860407e-02f, 2.30314340e-02f, 2.14686468e-02f, -5.90889193e-02f, 4.22586426e-02f, -9.56186280e-02f,
  -7.36444145e-02f, -3.93577725e-01f, 1.11415200e-02f, -7.73191527e-02f, 1.03848577e-02f, 3.74608487e-02f, 9.45553705e-02f, -6.16223663e-02f, -8.13780949e-02f, -5.05396090e-02f,
  5.55602647e-02f, -4.38828915e-02f, -4.08373401e-02f, 1.41819298e-01f, -5.59492931e-02f, -5.03487736e-02f, -3.02331755e-04f, -3.62613015e-02f, 4.63469066e-02f, -2.23570894e-02f,
  2.24140808e-02f, 5.98331131e-02f, 2.52139196e-03f, 8.96353461e-03f, 1.10795870e-01f, 5.21013886e-02f, 1.25539988e-01f, 1.17962984e-02f, -1.43937379e-01f, 7.19844773e-02f,
  2.82961518e-01f, 5.71863234e-01f, 4.61873889e-01f, 6.19849265e-01f, -3.22663367e-01f, -1.74030527e-01f, 2.94649433e-02f, 1.19425781e-01f, 5.42902887e-01f, -7.14589581e-02f,
  -3.52479607e-01f, 5.77003241e-01f, -1.24580406e-01f, 2.55793154e-01f, -1.50242254e-01f, -3.45734358e-02f, 2.34688729e-01f, 1.70167699e-01f, 4.45945412e-02f, 2.85411716e-01f,
  1.48284405e-01f, -3.81051838e-01f, -5.49247041e-02f, -2.86023021e-01f, 4.58839685e-02f, 2.07082912e-01f, -3.66183043e-01f, -1.46556363e-01f, -9.06994846e-03f, -2.28365183e-01f,
  -9.96279642e-02f, 1.77255005e-01f, 4.25729752e-02f, 1.50181260e-02f, -3.51733863e-02f, -4.56058718e-02f, -4.45570871e-02f, -1.56696633e-01f, -1.48175741e-02f, 1.29123479e-01f,
  7.54647702e-02f, -1.04214944e-01f, 1.39720552e-02f, -5.30203655e-02f, 3.39024141e-02f, 6.26726747e-02f, 8.63035247e-02f, 7.10588172e-02f, 1.89439848e-01f, 1.01459160e-01f,
  1.90819293e-01f, 5.11096902e-02f, 9.12890434e-02f, 1.20660633e-01f, 7.54798055e-02f, 5.33267036e-02f, 3.11422106e-02f, 1.63658569e-03f, 1.05395049e-01f, 1.21291235e-01f,
  2.61761826e-02f, -2.53695045e-02f, -1.10760406e-01f, 6.20940281e-03f, -5.00579178e-02f, 2.95681949e-03f, 1.32073566e-01f, -7.90702179e-02f, 1.14738323e-01f, -1.31850779e-01f,
  -9.23571214e-02f, 8.98398757e-02f, 2.13754345e-02f, 5.78045025e-02f, -4.20902781e-02f, 5.99595383e-02f, -2.40377877e-02f, 3.28461714e-02f, 1.55727118e-01f, 7.21729035e-03f,
  8.92620720e-03f, -1.10071721e-02f, -1.33944629e-02f, 1.28647434e-02f, -1.07225440e-01f, -5.07548414e-02f, 4.40889075e-02f, 1.55777350e-01f, -1.36037618e-02f, -6.69663073e-03f,
  1.50489807e-01f, 4.23778683e-01f, 3.89040783e-02f, -1.00094536e-02f, 8.48187730e-02f, 4.75101769e-02f, 1.56571046e-02f, 8.34372938e-02f, 1.85162053e-01f, 6.93548378e-03f,
  -2.15602061e-03f, -5.57978963e-03f, -4.83972050e-04f, -3.04747708e-02f, -5.85130788e-03f, 2.52326094e-02f, 7.47453347e-02f, -3.16121764e-02f, 6.09826595e-02f, 6.07651696e-02f,
  2.09262967e-02f, -5.18053211e-02f, 5.89624457e-02f, 4.44402918e-02f, -1.46685606e-02f, 3.89398858e-02f, -4.53301892e-03f, 1.35585800e-01f, -1.60522535e-02f, 1.59582198e-02f,
  -1.53068930e-01f, 2.94122785e-01f, 2.41041034e-02f, -3.83331180e-02f, 4.74391319e-03f, -3.78182143e-01f, -3.49890679e-01f, 1.07054308e-01f, 2.61334121e-01f, 2.89318293e-01f,
  1.26367956e-01f, 2.37918392e-01f, 6.88581988e-02f, -1.70408681e-01f, -5.36575735e-01f, -2.13240445e-01f, -4.54677165e-01f, -1.48260698e-01f, 5.19018527e-03f, -2.02402726e-01f,
  -2.66115546e-01f, -2.72989839e-01f, -2.46245325e-01f, -1.45799235e-01f, -1.63212065e-02f, 4.31728363e-02f, -1.74004689e-01f, 2.64827106e-02f, 1.16718281e-02f, 1.16151951e-01f,
  1.00323349e-01f, 2.84395993e-01f, 1.40460536e-01f, 4.82823420e-03f, -7.42802396e-02f, -1.37354568e-01f, -5.16872630e-02f, -2.21959148e-02f, 4.89163809e-02f, 3.94961238e-03f,
  -4.73024659e-02f, 1.91914856e-01f, -5.01593910e-02f, 1.60519779e-01f, 3.73314284e-02f, 1.68670475e-01f, -1.31776836e-02f, 6.15067557e-02f, 1.57828361e-01f, 3.75326164e-02f,
  -8.02552328e-02f, 9.66413096e-02f, 1.53776975e-02f, 5.70644923e-02f, -1.82132318e-03f, 1.78547546e-01f, -1.18609145e-01f, -2.37591602e-02f, -3.45782042e-02f, 2.81702746e-02f,
  -1.34148523e-02f, -1.20297655e-01f, -1.23914942e-01f, 1.35294288e-01f, -5.67837544e-02f, 1.46888301e-01f, -1.13600641e-01f, -1.26886861e-02f, -3.60732786e-02f, -1.34476572e-02f,
  1.63331404e-01f, -1.51667837e-02f, 8.23500939e-03f, -7.02849478e-02f, -2.00006962e-01f, 1.86616275e-02f, -2.87128426e-02f, -9.91917774e-03f, -1.30120441e-01f, -5.10002077e-02f,
  -3.77643965e-02f, -7.94525072e-02f, 8.87755081e-02f, -6.66653961e-02f, -1.18277417e-02f, -9.11152512e-02f, 4.54688706e-02f, 5.73187694e-02f, -7.36930892e-02f, -1.55174702e-01f,
  -7.89233074e-02f, -9.21213999e-02f, 2.03641523e-02f, 2.00716645e-01f, -4.27870126e-03f, -1.11553054e-02f, -1.32364422e-01f, -1.44253820e-02f, -1.05440475e-01f, -1.03191644e-01f,
  -1.41267432e-02f, -4.17523980e-02f, -2.25710974e-04f, -1.87111441e-02f, -1.70489643e-02f, -1.05659530e-01f, -6.19029067e-02f, 1.99098643e-02f, -1.16207942e-01f, 1.26232288e-03f,
  3.74666303e-02f, 6.90541640e-02f, 4.62964773e-02f, -6.98751360e-02f, -9.61233974e-02f, 1.39968351e-01f, -4.69078869e-02f, 6.33233190e-02f, -1.42177297e-02f, 9.95625630e-02f,
  -9.57017362e-01f, 4.12975371e-01f, -3.35694045e-01f, 8.86438340e-02f, -1.01445504e-01f, 1.97041348e-01f, 4.80427295e-02f, 9.07518156e-03f, -1.09923072e-01f, 1.44251302e-01f,
  6.47625849e-02f, -1.24642640e-01f, 1.13694249e-02f, 2.45107099e-01f, -2.01637343e-01f, 2.17467561e-01f, 1.37745097e-01f, 4.60144766e-02f, 4.06028442e-02f, -1.05439380e-01f,
  -9.41504762e-02f, 2.32999116e-01f, 1.26356378e-01f, 3.09557300e-02f, -9.62389261e-03f, -1.69945955e-01f, 4.24179286e-02f, -1.13784671e-01f, 6.89779744e-02f, -5.73485307e-02f,
  -8.12452361e-02f, -3.38817358e-01f, -1.10162474e-01f, -1.89960375e-01f, -9.01139379e-02f, -1.29636005e-01f, -2.93455366e-02f, -5.65243438e-02f, -4.75656353e-02f, -1.91449858e-02f,
  1.55044124e-02f, -1.29841769e-03f, -8.31022561e-02f, 7.20223486e-02f, -3.39403115e-02f, 2.19432684e-03f, 9.13286060e-02f, 8.89470428e-02f, 1.03786610e-01f, 6.48876131e-02f,
  1.35067374e-01f, 1.22932242e-02f, 1.36804730e-01f, 2.58039106e-02f, 2.07515925e-01f, 2.29455866e-02f, 1.24978144e-02f, 3.89369274e-03f, 2.40865927e-02f, -3.80488671e-02f,
  1.40038524e-02f, 3.84663753e-02f, 6.49150601e-03f, -3.35809961e-02f, -5.52150384e-02f, -1.76208224e-02f, -2.07444206e-02f, -2.25413889e-02f, 2.35642176e-02f, 2.76463740e-02f,
  4.33563888e-02f, 1.19551597e-02f, -3.46725322e-02f, -4.71138209e-03f, -6.98061064e-02f, 8.46830085e-02f, -5.40634431e-02f, -1.85541008e-02f, 7.36349672e-02f, -1.31571423e-02f,
  -8.89604166e-02f, -7.58559853e-02f, -2.06631012e-02f, 1.18213616e-01f, -5.05373441e-03f, 7.11028557e-03f, -5.47673889e-02f, 3.66503559e-02f, -2.60862801e-02f, -7.50015229e-02f,
  -2.04378762e-03f, -3.39452356e-01f, -1.92026440e-02f, 3.22414525e-02f, 1.31786605e-02f, -1.97609961e-02f, 2.73598824e-02f, -1.22807182e-01f, -6.36481196e-02f, -9.52965617e-02f,
  -6.00432381e-02f, 1.65581086e-03f, -9.59300473e-02f, -9.09235701e-03f, 7.48494864e-02f, 3.83586697e-02f, 1.75588522e-02f, -9.97304767e-02f, 7.55742891e-03f, -1.25819027e-01f,
  3.03784814e-02f, -6.67012185e-02f, -4.74229129e-03f, 2.34049764e-02f, 5.48373684e-02f, 1.96740758e-02f, -1.01993129e-01f, 8.09360445e-02f, -6.94335923e-02f, 7.81827897e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.64474237e-01f, 1.10173687e-01f, 2.78362721e-01f, 9.73281190e-02f, 2.95270681e-01f, 6.08729541e-01f, 1.78791136e-01f, 1.70862749e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.20385516e-02f, 3.46650839e-01f, -2.01656058e-01f, 8.22231695e-02f, 9.07798856e-02f, 1.48079425e-01f, 7.66192377e-02f, -8.21969509e-02f, -6.07983069e-03f, -1.68457195e-01f,
  2.81886309e-01f, 1.31006807e-01f, -7.55797401e-02f, -1.05491102e-01f, 1.17077574e-01f, -3.27300280e-01f, -6.74070418e-02f, -8.97866860e-02f, 3.93755496e-01f, 2.21710399e-01f,
  2.17555255e-01f, -2.76586376e-02f, -9.18564126e-02f, -2.22988814e-01f, 3.20803046e-01f, 7.90050775e-02f, -2.64900066e-02f, -2.17125326e-01f, -3.99982966e-02f, -2.33890206e-01f,
  1.09731771e-01f, -4.86093871e-02f, 1.77270442e-01f, -1.69158861e-01f, 1.52387053e-01f, -4.48660143e-02f, 7.83264041e-02f, 9.10643116e-02f, -3.85049842e-02f, 1.13093391e-01f,
  -9.31141302e-02f, 3.15980054e-03f, -1.13401428e-01f, -7.34700030e-03f, 1.55565053e-01f, -2.61707772e-02f, -2.50075728e-01f, 2.96746373e-01f, 1.61299288e-01f, 2.31570810e-01f,
  -2.14188531e-01f, -9.94345322e-02f, -2.68108457e-01f, 3.06014329e-01f, -3.08698505e-01f, 2.57957786e-01f, 7.31771463e-04f, 1.51074216e-01f, 2.32118294e-01f, 1.28606379e-01f,
  2.15385154e-01f, 4.52099741e-01f, -1.18569247e-01f, -1.78616673e-01f, -6.06277771e-02f, 3.46113384e-01f, 2.19889402e-01f, 1.84723511e-01f, -1.86529338e-01f, -1.75024822e-01f,
  9.43068191e-02f, 1.94523320e-01f, 1.41628116e-01f, 3.15257549e-01f, -1.24794170e-01f, -1.09611087e-01f, -8.61032084e-02f, 2.66097397e-01f, 4.12847884e-02f, 3.39981258e-01f,
  -1.73208356e-01f, -2.42844850e-01f, -3.11038762e-01f, -3.48723024e-01f, -4.60704565e-01f, -1.93783909e-01f, 6.01969473e-02f, -1.61096081e-01f, -2.38646299e-01f, -6.86253160e-02f,
  1.23059534e-01f, -4.57468569e-01f, 2.05870152e-01f, 1.51664510e-01f, -1.61612540e-01f, -1.49198040e-01f, -2.01409221e-01f, 3.63983333e-01f, 2.43792664e-02f, 3.10134999e-02f,
  -8.86048451e-02f, 2.19951242e-01f, -9.63642150e-02f, 2.64489919e-01f, -1.29308263e-02f, 2.10390270e-01f, 2.99522132e-01f, 2.23060638e-01f, -6.71532899e-02f, -1.08213790e-01f,
  -7.22596943e-02f, -3.16359192e-01f, 2.55245149e-01f, -2.64617540e-02f, 4.24760818e-01f, 8.83988813e-02f, 1.25224203e-01f, -2.64957666e-01f, -4.37430814e-02f, 4.75989617e-02f,
  -9.26307142e-02f, -2.77247965e-01f, 7.01727197e-02f, -2.81167030e-01f, -7.15033561e-02f, -6.40957579e-02f, 2.27513239e-01f, 4.45747882e-01f, -2.94321805e-01f, 2.76297092e-01f,
  -2.46687774e-02f, 5.45242839e-02f, -1.74468428e-01f, -1.86779305e-01f, -1.83618680e-01f, -1.18742652e-01f, 1.96449876e-01f, -1.38701135e-02f, -3.30518372e-02f, 1.03335753e-01f,
  -1.54597223e-01f, -1.67351857e-01f, -1.68483078e-01f, -1.14034042e-02f, -9.39967930e-02f, -1.06885552e-01f, -1.20105945e-01f, -8.53030682e-02f, -2.06889957e-01f, -2.81371683e-01f,
  -1.02697439e-01f, -2.57716835e-01f, 1.87418848e-01f, -6.32821620e-02f, -2.30729714e-01f, -2.19933927e-01f, 1.80033654e-01f, 1.45410553e-01f, 5.72009124e-02f, -2.27134421e-01f,
  -9.14342515e-03f, 2.92734742e-01f, 3.95825803e-01f, 5.38151748e-02f, -1.86494708e-01f, 2.47480586e-01f, 1.35098934e-01f, 2.48369977e-01f, 3.23419049e-02f, 4.30549562e-01f,
  1.44128829e-01f, 5.86768202e-02f, 1.10359952e-01f, -1.16646595e-01f, 1.10503078e-01f, 1.91222444e-01f, 1.03667624e-01f, -2.11438984e-02f, -7.82750025e-02f, -1.94212362e-01f,
  -4.12235975e-01f, -1.93507358e-01f, -5.13280034e-02f, 1.08644336e-01f, -8.45288858e-02f, -1.67237580e-01f, 2.39283532e-01f, -4.04703110e-01f, 3.35209146e-02f, 2.66913474e-01f,
  -1.27527088e-01f, 1.62064299e-01f, 3.60352099e-01f, -2.50450432e-01f, -3.28106105e-01f, 6.40280321e-02f, 2.43579492e-01f, 4.35943246e-01f, 9.71632302e-02f, 1.84253380e-02f,
  -3.50250825e-02f, -1.00494236e-01f, 1.16647370e-01f, 1.78695962e-01f, 1.85773849e-01f, -3.91704023e-01f, -8.21508765e-02f, -4.09124851e-01f, 2.72182822e-01f, 9.08663273e-02f,
  2.52816319e-01f, 2.47207761e-01f, 4.68081564e-01f, 3.25969696e-01f, -6.71195090e-02f, 8.03815350e-02f, 1.84992954e-01f, 8.71036872e-02f, 8.39878768e-02f, 2.76571512e-01f,
  -2.25931853e-02f, -4.78253327e-02f, 8.72862712e-02f, 9.53808799e-02f, -1.21626966e-01f, -3.27028900e-01f, 1.39783591e-01f, 5.95370717e-02f, 1.18520176e-02f, 3.17693055e-02f,
  -1.91514254e-01f, 7.01882243e-02f, -1.93396449e-01f, -2.46970914e-02f, -4.48059812e-02f, -2.24119984e-02f, -4.87716831e-02f, 5.36800921e-02f, -2.21306294e-01f, 9.69343483e-02f,
  -1.36860326e-01f, 2.00845346e-01f, 2.21127123e-01f, -5.92718013e-02f, -1.97073981e-01f, 2.06466258e-01f, -1.61075950e-01f, 1.47965297e-01f, -3.19093019e-01f, 6.64904490e-02f,
  3.62856239e-01f, 1.09869331e-01f, -1.25978053e-01f, 1.30447611e-01f, -3.59964728e-01f, 8.72576982e-02f, -1.65392235e-01f, 2.29472905e-01f, -9.26264450e-02f, -1.05577432e-01f,
  -2.43674740e-01f, -1.25307634e-01f, -1.29972091e-02f, 1.47648647e-01f, 2.16223090e-03f, -1.30177066e-01f, -7.47899041e-02f, 1.11027285e-01f, -1.80755913e-01f, 2.34036595e-02f,
  -3.09683710e-01f, -4.29659784e-02f, 1.52044013e-01f, -3.04835171e-01f, 4.11623046e-02f, -3.53703722e-02f, -7.58170038e-02f, -2.24877164e-01f, -9.38776433e-02f, -3.55919093e-01f,
  2.91360140e-01f, -1.61890045e-01f, -3.52865219e-01f, 1.02848195e-01f, 6.59095570e-02f, 3.55928272e-01f, -1.21307757e-03f, -7.84602091e-02f, -1.64527386e-01f, 1.88028738e-01f,
  -2.90562540e-01f, -8.50168392e-02f, -2.63892375e-02f, -8.09910744e-02f, -3.91125269e-02f, -2.34442949e-01f, -1.83017820e-01f, -1.39842167e-01f, 2.60767519e-01f, 3.52746993e-02f,
  -7.70630389e-02f, 1.17519148e-01f, 1.12793587e-01f, -3.44316065e-01f, -8.53238031e-02f, -1.19734824e-01f, 3.15943152e-01f, 2.76569963e-01f, 3.57055485e-01f, 4.35948931e-02f,
  8.28470960e-02f, -2.09359840e-01f, 1.77576408e-01f, -3.81578468e-02f, -1.33354932e-01f, -8.93055648e-02f, 3.47264074e-02f, -4.49962974e-01f, 2.43308038e-01f, 2.32447758e-01f,
  4.92285103e-01f, -1.43766120e-01f, -2.26680487e-02f, 1.63380697e-01f, 1.23302691e-01f, 3.28900844e-01f, 1.81960717e-01f, 1.22355320e-01f, -4.58240546e-02f, 2.42797971e-01f,
  4.41061258e-02f, -2.73385961e-02f, 3.32819164e-01f, -2.44688809e-01f, 2.86611587e-01f, -2.89802607e-02f, 5.08453131e-01f, 1.49539217e-01f, 2.34656274e-01f, 9.06350985e-02f,
  -8.63790885e-02f, 9.39291641e-02f, -1.56681567e-01f, 4.45762932e-01f, -9.29233953e-02f, -1.38248831e-01f, 3.52428526e-01f, -6.47670627e-02f, 2.17592586e-02f, 1.10436417e-01f,
  -1.68604121e-01f, 1.10151149e-01f, 1.01752533e-02f, 4.93993936e-03f, 1.91083923e-01f, -3.70640233e-02f, 1.04589947e-01f, -2.47050419e-01f, -9.38651934e-02f, -1.85146444e-02f,
  5.93404062e-02f, 5.41112758e-03f, -6.98230118e-02f, -2.44730219e-01f, 2.58384019e-01f, 1.10642657e-01f, 4.93214339e-01f, 6.81317598e-02f, -3.22784364e-01f, 2.33906820e-01f,
  -3.24302375e-01f, -1.41504377e-01f, 5.16864099e-02f, -4.04261611e-02f, 3.10600370e-01f, 7.43368641e-02f, -3.14864963e-01f, -7.40247127e-03f, -1.04117751e-01f, -1.32310018e-01f,
  2.20323190e-01f, -3.13952357e-01f, -1.27594054e-01f, 1.53278574e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.46145451e-01f, 1.77353919e-01f, 2.85144389e-01f, 4.86778587e-01f, 1.23022795e-01f, 3.69485527e-01f, 4.35489446e-01f, -2.34789297e-01f, 1.79816961e-01f, 9.31901559e-02f,
  2.90860474e-01f, 2.69557089e-01f, 3.68208557e-01f, -2.47338369e-01f, 1.57112613e-01f, -2.94341952e-01f, 7.65091538e-01f, 2.81385239e-03f, -4.53220189e-01f, 4.53773856e-01f,
  6.31574914e-02f, 4.87715960e-01f, -1.08615709e-02f, 6.21456094e-02f, 5.07135689e-01f, 5.74943006e-01f, 8.87324810e-02f, -1.61699802e-01f, 6.89147949e-01f, 3.23882937e-01f,
  3.75185981e-02f, -5.03615081e-01f, 4.64018993e-02f, -7.19632506e-02f, -2.09040478e-01f, -2.51458287e-01f, 3.48518491e-01f, -1.48859978e-01f, 9.25292075e-02f, 1.53839231e-01f,
  1.40744552e-01f, -1.42589226e-01f, 6.67560101e-02f, 4.30439919e-01f, -7.79901296e-02f, -2.28308171e-01f, -5.17429531e-01f, -2.32788250e-01f, -2.50296861e-01f, -1.56448334e-01f,
  3.42948250e-02f, 6.33218959e-02f, 4.24021661e-01f, -2.91185915e-01f, 5.80126159e-02f, -6.80679232e-02f, 4.77679282e-01f, 1.31978422e-01f, -4.80581932e-02f, 4.11537647e-01f,
  -1.23978183e-01f, 4.60459083e-01f, 4.30953443e-01f, 2.34524444e-01f, 7.77056143e-02f, -2.94240028e-01f, 2.45655879e-01f, -8.07120278e-02f, -1.75231732e-02f, 1.39549568e-01f,
  1.93750024e-01f, 4.31088060e-01f, 2.40827296e-02f, 3.49258929e-01f, 6.15750253e-02f, 7.90435597e-02f, -1.69273689e-01f, 1.74418479e-01f, -3.80293101e-01f, 2.09314078e-01f,
  -3.95712078e-01f, 1.59784868e-01f, 4.99099255e-01f, -9.15873349e-02f, -2.51398861e-01f, 4.06171709e-01f, -6.33227766e-01f, 1.93302870e-01f, 1.36031508e-02f, -7.33849034e-02f,
  7.37192571e-01f, 3.89992505e-01f, -2.62174726e-01f, 1.93128496e-01f, -4.32392091e-01f, 4.94728804e-01f, 1.68005005e-01f, 2.03735173e-01f, 4.00422513e-01f, 3.33558381e-01f,
  -4.19681482e-02f, 4.63863999e-01f, 3.44444126e-01f, 5.82943916e-01f, 1.35653883e-01f, 4.42639768e-01f, 2.61555970e-01f, 3.30142409e-01f, -8.58690441e-02f, -1.12371899e-01f,
  -2.71898985e-01f, -1.67970777e-01f, 5.21714807e-01f, -2.76869535e-01f, 2.77142346e-01f, 6.02160692e-02f, -1.96341366e-01f, -2.10765317e-01f, -5.33905551e-02f, -1.47328541e-01f,
  4.87356246e-01f, -2.20528737e-01f, 4.26846445e-02f, 1.30303323e-01f, 2.27147758e-01f, 8.69668424e-01f, 4.45173055e-01f, -1.44694194e-01f, 4.85071868e-01f, -3.41082215e-01f,
  4.92827259e-02f, 4.59236652e-02f, 3.82955551e-01f, -1.60355002e-01f, 2.39854634e-01f, -9.66678932e-02f, 3.62088352e-01f, -8.31294879e-02f, 2.53820959e-02f, 7.30007514e-02f,
  1.43542945e-01f, 1.97319701e-01f, 1.13560438e-01f, 3.54323179e-01f, -2.62032986e-01f, 1.48000941e-01f, -7.48903453e-01f, -1.41375914e-01f, 1.05622001e-01f, 4.90398146e-02f,
  1.95234179e-01f, 1.43429443e-01f, 3.15929472e-01f, 3.11443090e-01f, -1.17321517e-02f, 6.86923444e-01f, 1.61986664e-01f, 2.82841206e-01f, 3.42468739e-01f, -1.03592247e-01f,
  2.74266005e-01f, -5.12363808e-03f, 1.55748188e-01f, -2.31303158e-03f, 1.34702787e-01f, -3.44408929e-01f, 1.88317686e-01f, 5.98529167e-02f, 2.32504040e-01f, -2.24750072e-01f,
  1.42002732e-01f, 1.13110833e-01f, -1.27057150e-01f, -1.91764846e-01f, -3.74569863e-01f, 9.53310877e-02f, -4.62646723e-01f, -1.56568065e-01f, -1.49325147e-01f, -2.03725368e-01f,
  1.90379202e-01f, -3.42919707e-01f, 2.09414974e-01f, -5.74710727e-01f, 3.92689519e-02f, 6.39255270e-02f, -5.04252136e-01f, 2.61521727e-01f, 5.55307567e-02f, 6.25880957e-01f,
  4.03559446e-01f, -2.78365850e-01f, -1.33610234e-01f, 2.73019612e-01f, 2.02901393e-01f, 3.40433568e-01f, 2.45738346e-02f, 1.28126979e-01f, 3.61208498e-01f, 3.38876188e-01f,
  2.47189209e-01f, 1.77212715e-01f, 4.01030898e-01f, 2.85180926e-01f, -3.46326888e-01f, 1.39877349e-01f, 2.25200042e-01f, -2.66435802e-01f, -4.29322831e-02f, -4.60636795e-01f,
  4.15253907e-01f, 2.77697723e-02f, 1.65088903e-02f, -3.86328995e-01f, 4.44670528e-01f, -3.30619395e-01f, 1.57770142e-01f, -2.90094644e-01f, -3.28750074e-01f, -2.04598829e-01f,
  -1.61195248e-01f, -2.18080729e-01f, 4.28652853e-01f, 1.81156099e-01f, 2.74482705e-02f, 1.58508718e-02f, 1.19717360e-01f, -1.89900428e-01f, 2.44204357e-01f, 9.85009223e-03f,
  1.81384608e-01f, 3.72512549e-01f, -1.00256512e-02f, 7.67502859e-02f, 4.68675971e-01f, 4.30607766e-01f, -1.14960253e-01f, -2.24515542e-01f, -2.31794968e-01f, -4.21678305e-01f,
  -1.02124192e-01f, -9.82169062e-03f, 3.44210178e-01f, -7.95257986e-02f, 4.66195941e-01f, -1.23414420e-01f, -9.76748168e-02f, -5.86077124e-02f, 4.46536541e-01f, -5.92876710e-02f,
  2.05745891e-01f, 4.52966183e-01f, -2.78588146e-01f, 2.52290338e-01f, 4.42323565e-01f, 5.19190371e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.70353931e-01f, 1.99288130e-01f, 4.21299130e-01f, 3.46203208e-01f, 2.76726931e-01f, 1.19550742e-01f, 3.32549930e-01f, 3.40123743e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.07136153e-02f, -1.53982460e-01f, 2.20620543e-01f, -1.71223611e-01f, 8.37907009e-03f, 9.37919766e-02f, -1.81919217e-01f, -4.43841033e-02f, 5.76121248e-02f, -1.61573961e-02f,
  -1.44149944e-01f, -1.55550763e-01f, 2.87504554e-01f, -1.11693859e-01f, -2.17177212e-01f, 1.26253352e-01f, -4.36155759e-02f, -1.36353776e-01f, 5.70062064e-02f, 1.03260204e-01f,
  1.18254296e-01f, 8.42415392e-02f, -3.01119477e-01f, -3.26253384e-01f, -1.19455136e-01f, 1.15207031e-01f, 1.90939188e-01f, 1.07250951e-01f, -2.77919382e-01f, -1.70838628e-02f,
  6.20289147e-03f, 1.83135167e-01f, -2.47017480e-02f, -3.51354480e-01f, 7.43267462e-02f, 3.11081782e-02f, -8.72780606e-02f, -1.39931425e-01f, 5.51371686e-02f, -1.88832417e-01f,
  2.42172964e-02f, -6.42142445e-02f, -3.79279181e-02f, -9.09921899e-02f, -1.77363306e-01f, 2.03323141e-01f, 1.13441952e-01f, -7.81419948e-02f, 1.59899339e-01f, -1.14800751e-01f,
  -1.41015559e-01f, 2.83224165e-01f, 4.57159728e-02f, -2.26647466e-01f, -5.11513710e-01f, -1.32205307e-01f, -3.11028659e-01f, 2.67796218e-01f, 2.88905799e-01f, 1.18687026e-01f,
  -1.32682145e-01f, 5.37869856e-02f, 3.58607899e-03f, -1.24207497e-01f, -3.45825367e-02f, 1.53470904e-01f, 9.14205760e-02f, -2.85312206e-01f, -1.63490579e-01f, -9.15771574e-02f,
  -4.52473126e-02f, -2.31392026e-01f, 3.14653665e-03f, 1.10581927e-01f, -6.02302738e-02f, -1.22566104e-01f, -3.20799462e-02f, -1.29507631e-01f, -3.07313293e-01f, 1.00109786e-01f,
  -8.75674933e-02f, -1.40708089e-01f, 2.54225373e-01f, -2.34863222e-01f, 1.68364689e-01f, 3.56080145e-01f, 1.07718356e-01f, -1.55941501e-01f, 2.81995125e-02f, 1.57592073e-01f,
  -3.40863079e-01f, -8.78870711e-02f, 7.40028620e-02f, -3.13253820e-01f, 7.30220601e-02f, 8.10899362e-02f, -4.32103463e-02f, -4.54837196e-02f, 1.63422629e-01f, -2.47066572e-01f,
  -2.01976731e-01f, 6.57400340e-02f, -1.36833310e-01f, 3.73702534e-02f, -1.05620064e-01f, -7.30644017e-02f, 4.51787151e-02f, -2.80922055e-01f, 1.42054200e-01f, -1.09016888e-01f,
  -3.06963235e-01f, -3.17446887e-01f, 1.44215643e-01f, -4.03796792e-01f, 8.00378174e-02f, 6.17605224e-02f, 8.02705362e-02f, 1.01524562e-01f, -2.41034135e-01f, -1.23500451e-01f,
  -1.02547921e-01f, 1.09411880e-01f, 8.68940651e-02f, -6.68038577e-02f, 1.01724625e-01f, 8.64354894e-02f, 1.46091254e-02f, 1.79231450e-01f, -4.46871482e-02f, -1.09424628e-01f,
  -1.24097146e-01f, -6.82729706e-02f, -2.22267926e-01f, 1.03386492e-01f, 1.53500186e-02f, -1.04992636e-01f, 7.28665963e-02f, 1.92242879e-02f, 2.13706255e-01f, 1.49736732e-01f,
  -1.50589347e-01f, -2.53435224e-01f, 1.84333995e-01f, -3.10351122e-02f, 2.32330471e-01f, -4.94881533e-02f, -2.53860235e-01f, -1.24423876e-01f, 1.83936432e-01f, -9.06793475e-02f,
  -1.53636426e-01f, 2.66674399e-01f, -3.25762630e-01f, -5.48946783e-02f, 6.58779517e-02f, -2.30775997e-01f, 1.74347177e-01f, 2.94892520e-01f, 7.34584779e-02f, -1.08311541e-01f,
  1.16788797e-01f, -2.09927097e-01f, -2.90345363e-02f, 1.00139767e-01f, 1.33910224e-01f, 1.73087344e-01f, 1.42592207e-01f, 4.95328233e-02f, 1.67419210e-01f, 1.24096833e-01f,
  1.13246031e-01f, 2.33492896e-01f, -2.16389596e-01f, -4.61378992e-02f, 2.61782199e-01f, 9.62227210e-02f, -1.04091078e-01f, 1.54120907e-01f, -3.90193015e-01f, 3.50981444e-01f,
  -1.09859258e-01f, -1.16920568e-01f, -5.57562225e-02f, 1.66977197e-02f, -1.43005192e-01f, -1.17242657e-01f, 3.71963501e-01f, -4.70977761e-02f, -1.17444195e-01f, -6.49962053e-02f,
  1.62403345e-01f, 2.39291206e-01f, -5.57944551e-02f, 5.70389302e-03f, 2.63680428e-01f, -9.55576375e-02f, -8.23860581e-04f, 1.72214895e-01f, -3.23793083e-01f, 7.41075724e-02f,
  -3.86972092e-02f, -1.22131489e-01f, -2.84656316e-01f, -2.75781810e-01f, 1.13096051e-01f, 2.55797878e-02f, -3.91292311e-02f, -1.09836914e-01f, -2.58572608e-01f, -1.61504209e-01f,
  4.24268752e-01f, 2.75252853e-02f, -1.99449167e-01f, 6.20636493e-02f, 3.55916023e-02f, -1.23741977e-01f, 2.78911859e-01f, -2.57361621e-01f, -3.14970650e-02f, -1.37611581e-02f,
  1.95528850e-01f, -1.58572689e-01f, -1.24440573e-01f, -3.17375749e-01f, -2.55778134e-02f, 4.74171750e-02f, -7.29404241e-02f, -4.32904549e-02f, 1.05798610e-01f, -1.38538852e-01f,
  -4.53145951e-02f, 1.24707468e-01f, 1.84871674e-01f, -2.49411821e-01f, -9.32406187e-02f, -2.56752312e-01f, -2.71618426e-01f, 1.87468052e-01f, -1.43210456e-01f, -1.71810210e-01f,
  -1.63996622e-01f, -1.03123792e-01f, 2.34748647e-01f, -2.11460114e-01f, -1.38810530e-01f, -1.30907655e-01f, 1.97953463e-01f, -5.37975645e-03f, 4.16044235e-01f, -1.60630330e-01f,
  -1.36927173e-01f, -5.83828390e-02f, 2.98355252e-01f, 5.25012240e-02f, -1.70746773e-01f, -2.65613168e-01f, -1.06830694e-01f, -2.44993001e-01f, -2.72334576e-01f, -2.25438163e-01f,
  -1.58152387e-01f, -9.76200402e-03f, 1.96431488e-01f, 7.93189779e-02f, 1.64602339e-01f, -2.14776635e-01f, 4.93098609e-02f, -1.42011017e-01f, -5.93407862e-02f, -3.18410516e-01f,
  2.14285210e-01f, 2.68326521e-01f, 1.35070100e-01f, 5.41288517e-02f, -4.72844429e-02f, -3.09796631e-01f, 1.65427148e-01f, -6.23007677e-02f, -5.71908243e-02f, 2.06268951e-01f,
  -2.54361868e-01f, -9.37684700e-02f, -2.98986971e-01f, 2.10007712e-01f, -2.59873979e-02f, -6.12484738e-02f, 3.00250798e-01f, -7.06984699e-02f, -9.79209840e-02f, 1.86339602e-01f,
  -2.53960460e-01f, 1.10978544e-01f, 2.15011369e-02f, -1.99347585e-02f, 1.12985335e-01f, -9.82701555e-02f, -2.02630684e-01f, -2.80705481e-05f, 1.60612941e-01f, 9.43952352e-02f,
  3.15008424e-02f, 1.44771673e-02f, 2.39201292e-01f, -8.07669461e-02f, 1.66550860e-01f, 9.41483583e-03f, -2.13546172e-01f, -1.62615925e-01f, 1.95182994e-01f, -1.01980433e-01f,
  -1.79495722e-01f, 4.16173637e-01f, 2.22432971e-01f, -2.02093452e-01f, -2.61000037e-01f, -2.28772715e-01f, 2.22702205e-01f, 2.01061681e-01f, -5.34882247e-02f, -2.31353343e-01f,
  -2.49912396e-01f, 6.30385652e-02f, -4.52299789e-02f, -5.12351431e-02f, -3.39165442e-02f, -5.95436385e-03f, 1.51348189e-01f, 3.00817452e-02f, -1.29152685e-01f, -1.29596442e-01f,
  1.24901496e-01f, -8.94689746e-03f, 9.54801962e-02f, -8.96197706e-02f, -5.88073432e-02f, -1.50867283e-01f, 3.22201967e-01f, -1.49503171e-01f, 7.25799575e-02f, -3.30441654e-01f,
  1.11700401e-01f, -1.23428799e-01f, 2.72721685e-02f, 1.33439079e-01f, 1.96659207e-01f, 9.99299586e-02f, -4.09263402e-01f, -3.75800095e-02f, 6.88177496e-02f, 2.71290541e-01f,
  1.42775476e-01f, 7.15734437e-02f, -1.36002898e-01f, 1.69666186e-01f, 2.58998662e-01f, -1.91998720e-01f, -9.03851166e-02f, 2.74865746e-01f, -1.66234136e-01f, 1.33139029e-01f,
  -2.31756628e-01f, 4.75954339e-02f, -2.12239474e-03f, 2.23890081e-01f, 1.18328936e-01f, -1.35809839e-01f, -3.67998630e-01f, 4.90192547e-02f, -2.83998936e-01f, 2.91307885e-02f,
  3.47318381e-01f, -1.69639707e-01f, -1.74794763e-01f, 1.83927298e-01f, 3.66040409e-01f, 1.00863829e-01f, 1.73116953e-03f, 4.30428013e-02f, -1.58340156e-01f, -1.07914045e-01f,
  8.93480983e-03f, -3.69996369e-01f, 9.13258195e-02f, 1.64409995e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.40570539e-01f, 1.23090118e-01f, 1.28246844e-01f, 2.42493257e-01f, 3.95036638e-01f, -2.15642899e-01f, -1.25479341e-01f, 2.40878984e-01f, 5.71888626e-01f, 1.69285432e-01f,
  -1.34302884e-01f, 3.89280826e-01f, 1.63000450e-01f, 7.59244189e-02f, 3.15235794e-01f, 5.60406506e-01f, -3.97471577e-01f, 6.87867999e-01f, 2.39249617e-02f, 9.80099663e-02f,
  -3.11999261e-01f, -1.05825782e-01f, 5.77764511e-01f, -4.34267551e-01f, 2.83888876e-01f, -5.22038937e-01f, 7.56096005e-01f, 6.60805285e-01f, -4.12851065e-01f, -5.41574359e-01f,
  2.07300365e-01f, 3.38842422e-01f, 1.50686294e-01f, 8.12371373e-02f, 3.59195024e-01f, -2.96236008e-01f, -2.03974590e-01f, 6.59237131e-02f, 2.61622280e-01f, 4.33091223e-02f,
  -3.61146867e-01f, -7.44948760e-02f, 1.86576664e-01f, 4.26569022e-02f, -2.69437641e-01f, 3.01187843e-01f, -1.97172299e-01f, -1.87439486e-01f, -2.26135910e-01f, 1.27808705e-01f,
  2.25351006e-01f, 4.25763249e-01f, -1.92156881e-01f, -2.91499376e-01f, 3.86539042e-01f, 4.43333499e-02f, -7.45362520e-01f, 5.02561212e-01f, 8.05844486e-01f, 1.73464432e-01f,
  4.09208357e-01f, 3.22995126e-01f, -1.74982592e-01f, 6.20019257e-01f, 2.03983650e-01f, -1.19966850e-01f, -1.88216254e-01f, 2.35126585e-01f, 3.11838478e-01f, -4.67633316e-03f,
  1.43923014e-01f, 2.68469751e-01f, 2.76233733e-01f, 2.22270917e-02f, 1.40049502e-01f, -2.39482056e-02f, 2.44787738e-01f, -2.82215387e-01f, 3.34189087e-01f, 5.36250472e-01f,
  3.85410249e-01f, 4.10339922e-01f, 5.49225099e-02f, -7.50995815e-01f, 2.21412882e-01f, -1.96043402e-01f, 1.05003892e-02f, -3.13811392e-01f, 1.05259454e+00f, -1.38067752e-02f,
  -5.25108218e-01f, 9.21517611e-01f, 1.88142478e-01f, 7.57957220e-01f, 5.41623354e-01f, -7.03464122e-03f, -9.71942693e-02f, 5.15431225e-01f, 2.85176009e-01f, -1.73545167e-01f,
  -1.13598794e-01f, 2.82271564e-01f, -9.07336697e-02f, -3.09933126e-01f, 7.41905672e-03f, 1.24921845e-02f, 2.71313757e-01f, 7.81728178e-02f, -3.03088836e-02f, 9.92992222e-02f,
  -7.20698953e-01f, -4.97493833e-01f, -7.05106631e-02f, -4.03435081e-01f, 4.97892767e-01f, -1.96975678e-01f, 1.34607077e-01f, 2.14822784e-01f, 7.32835531e-02f, 5.82371876e-02f,
  1.90039620e-01f, 8.23206782e-01f, -1.16090521e-01f, 2.83272993e-02f, 7.77512312e-01f, 4.72233266e-01f, -2.17850477e-01f, 4.65737551e-01f, 3.88304070e-02f, 4.35288697e-01f,
  2.00698346e-01f, -2.81226188e-01f, 1.21165738e-01f, 4.27111387e-01f, -1.29536226e-01f, 2.48181432e-01f, 1.93960294e-01f, 4.41714913e-01f, 1.78931177e-01f, 3.48451614e-01f,
  5.45983732e-01f, -5.35345972e-01f, -2.41413027e-01f, 4.37063813e-01f, -9.25469324e-02f, 2.13175222e-01f, 2.47602567e-01f, -3.31688315e-01f, 3.07691488e-02f, 6.48781419e-01f,
  -2.53788452e-03f, -5.35383783e-02f, -5.35049364e-02f, 3.67602199e-01f, -7.75058046e-02f, 9.98509377e-02f, -1.51925951e-01f, 5.26853651e-02f, 9.29715514e-01f, 4.70666409e-01f,
  1.61920205e-01f, 4.36332464e-01f, 4.25640583e-01f, 1.98836461e-01f, 2.17681125e-01f, 3.82036626e-01f, -2.07047686e-01f, 2.99795896e-01f, -1.30783364e-01f, 3.84757191e-01f,
  -3.10073614e-01f, 1.31545737e-01f, 2.86992610e-01f, 4.08371985e-01f, -4.53978807e-01f, -1.86390623e-01f, -5.11656225e-01f, -1.25251964e-01f, 6.37762964e-01f, 1.96542278e-01f,
  -5.13459742e-01f, 5.57067320e-02f, 3.89527470e-01f, -1.23164870e-01f, 9.26898718e-01f, -9.08673108e-02f, 4.90651757e-01f, 5.69307841e-02f, 4.87434894e-01f, -5.48551738e-01f,
  -3.14600855e-01f, 2.05220401e-01f, 3.00288498e-01f, -8.06737915e-02f, -1.48728296e-01f, 6.13328993e-01f, 3.13851148e-01f, -3.61901015e-01f, 5.61543107e-01f, 2.80079752e-01f,
  2.20715463e-01f, -1.33629635e-01f, 3.44163716e-01f, 1.79590911e-01f, -6.99565053e-01f, 5.97550571e-01f, 5.81365228e-01f, -2.83898979e-01f, 1.91051755e-02f, 3.15781802e-01f,
  -3.56899947e-01f, 2.68976480e-01f, -2.21992046e-01f, -7.09344923e-01f, -1.70691907e-02f, 5.59336357e-02f, 2.68473536e-01f, -2.64720440e-01f, 2.94897556e-01f, 2.91452080e-01f,
  8.34897220e-01f, 4.99048680e-01f, -2.45314971e-01f, -1.61071926e-01f, -3.81758779e-01f, -4.68711257e-01f, 2.11582109e-01f, -3.93138289e-01f, 2.55486071e-01f, -1.87509552e-01f,
  -1.72084317e-01f, -1.70273185e-01f, 3.14345211e-01f, -2.94225007e-01f, -9.41889361e-02f, -5.40375769e-01f, 9.36236829e-02f, -2.39345878e-01f, -4.85878259e-01f, -2.11767070e-02f,
  -7.00167492e-02f, -3.57922405e-01f, 5.19343436e-01f, 9.75526795e-02f, 2.61395454e-01f, 2.95286894e-01f, -7.35167384e-01f, -7.38685548e-01f, 4.50949073e-02f, 7.23765075e-01f,
  2.34962121e-01f, 6.92544937e-01f, -7.16867894e-02f, 3.01192820e-01f, 2.54766941e-02f, 5.56574106e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.15559417e-01f, 1.90847635e-01f, 1.54922828e-01f, -5.22734039e-02f, 3.60809803e-01f, 3.50418746e-01f, 3.28544796e-01f, -1.25814900e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -4.61808294e-02f, 2.11517677e-01f, -4.86042202e-02f, 1.35543808e-01f, -3.49816084e-01f, -4.27249283e-01f, -6.63046315e-02f, -3.71805549e-01f, -2.51735836e-01f, -3.40833694e-01f,
  -1.10853277e-01f, -9.82920080e-02f, 2.24437699e-01f, 1.28744662e-01f, -1.46987125e-01f, 4.09855545e-02f, -1.75996855e-01f, 5.52088134e-02f, -5.10531887e-02f, -1.59526646e-01f,
  1.40540496e-01f, 3.12255830e-01f, -2.26920903e-01f, 4.11744416e-01f, 2.62509137e-01f, 5.19970834e-01f, -8.87077868e-01f, -1.16887257e-01f, 1.16124570e-01f, 2.40287110e-01f,
  -6.32785201e-01f, -4.50968966e-02f, 2.04569295e-01f, 1.29771546e-01f, -1.40288979e-01f, 5.30174673e-02f, 3.70343894e-01f, -4.20483768e-01f, 1.74465463e-01f, 3.75714719e-01f,
  -1.99967399e-01f, 2.70541847e-01f, -1.75043762e-01f, 2.98874736e-01f, -4.21704024e-01f, 3.82798314e-01f, -1.19210705e-01f, -3.78377169e-01f, 2.00919248e-02f, -1.08799219e-01f,
  -5.78344584e-01f, -7.64344573e-01f, -1.93744034e-01f, -6.05843477e-02f, -3.27878565e-01f, -4.94092733e-01f, 3.80059868e-01f, 3.40063721e-01f, -8.37816417e-01f, -4.83760089e-01f,
  -3.00812691e-01f, 1.02723010e-01f, 5.22357583e-01f, -8.78053665e-01f, -3.53718728e-01f, 1.28207117e-01f, 1.33140624e-01f, 2.25669950e-01f, 1.82650626e-01f, 2.36187354e-01f,
  8.95562768e-02f, -1.94353029e-01f, -9.56427585e-03f, 8.31039026e-02f, 8.01016092e-02f, 1.47185415e-01f, -3.65008652e-01f, -2.52390862e-01f, -2.57749051e-01f, 2.27355108e-01f,
  2.04480842e-01f, 2.48478428e-01f, 5.17360628e-01f, 4.19425607e-01f, -2.61644125e-01f, 2.48370528e-01f, 1.59140944e-01f, 5.50767899e-01f, -7.19064415e-01f, 4.18879211e-01f,
  -7.82552719e-01f, 2.88284719e-01f, -4.15139586e-01f, 3.87742460e-01f, 2.53188848e-01f, -7.95102417e-01f, -3.67959648e-01f, 2.86534224e-02f, -1.92838028e-01f, -3.73145878e-01f,
  7.73301125e-02f, 1.95046529e-01f, -2.33955249e-01f, -1.47628561e-01f, -2.80137174e-02f, -3.20056647e-01f, -3.22200865e-01f, 3.05510256e-02f, -1.68807179e-01f, 3.13826770e-01f,
  3.27416211e-01f, 2.18623102e-01f, -2.25094095e-01f, -2.12907627e-01f, -1.69179395e-01f, 9.57892165e-02f, 3.13767523e-01f, -2.98423052e-01f, -1.88871077e-03f, 2.42755249e-01f,
  -6.42053604e-01f, 6.71706572e-02f, 4.34417576e-02f, 6.51325658e-02f, 3.09287876e-01f, -9.78015661e-01f, -7.15427279e-01f, 4.52698171e-01f, 2.85583753e-02f, -4.25249875e-01f,
  -1.21333681e-01f, 1.58437669e-01f, -1.56962812e-01f, 4.64131176e-01f, 4.47262615e-01f, 4.68450844e-01f, 4.78512257e-01f, -4.57385153e-01f, 4.04125810e-01f, -2.50246912e-01f,
  5.40090382e-01f, -4.54637259e-01f, 6.40539110e-01f, 7.54276365e-02f, -2.02223584e-01f, -3.54146697e-02f, 1.19024970e-01f, -5.07136226e-01f, -3.22897047e-01f, -3.10379654e-01f,
  1.13989308e-01f, 5.15086889e-01f, 3.99781972e-01f, -1.99814215e-01f, 1.15392417e-01f, 1.18667364e-01f, 3.67818534e-01f, -1.90428216e-02f, -9.18139458e-01f, 8.28874705e-04f,
  1.94062948e-01f, 1.91645622e-01f, -2.08497718e-01f, 4.86308448e-02f, -3.52235973e-01f, -1.59712493e-01f, -1.45968080e-01f, 3.10670704e-01f, 1.04325913e-01f, -3.40770304e-01f,
  1.14977419e-01f, -2.83837169e-01f, 2.16131106e-01f, 4.09612894e-01f, -5.02735786e-02f, -2.21191809e-01f, -1.57533839e-01f, 4.38871920e-01f, 4.68964487e-01f, 3.78067195e-01f,
  1.58170573e-02f, -3.90989244e-01f, -5.18170416e-01f, -1.87222600e-01f, 3.13159257e-01f, -1.65584177e-01f, 4.94302697e-02f, -7.28446424e-01f, -6.92117512e-01f, 1.38279766e-01f,
  -2.51581743e-02f, 5.99770248e-01f, -5.07531047e-01f, -2.96996713e-01f, 3.09857447e-02f, -4.55626637e-01f, 2.34770611e-01f, 2.22369477e-01f, 9.76475850e-02f, -2.22399071e-01f,
  2.28376240e-01f, -5.20917475e-02f, 7.45630562e-02f, 2.66979814e-01f, -2.86382258e-01f, -5.74317515e-01f, -1.64595619e-01f, -8.71816725e-02f, -2.61126161e-01f, 1.86471999e-01f,
  -2.85327137e-01f, 3.22056979e-01f, 1.70506194e-01f, 4.10259753e-01f, 6.07091248e-01f, -3.80411744e-01f, 2.77118862e-01f, -5.78154325e-01f, 3.08903456e-01f, -7.43808031e-01f,
  -6.39108777e-01f, -1.20306551e-01f, 5.07296801e-01f, -8.41692805e-01f, 2.95040101e-01f, -4.25542938e-03f, -1.01442471e-01f, -1.66490272e-01f, -1.97256967e-01f, -3.19379687e-01f,
  3.38953912e-01f, 3.40928547e-02f, -1.08195104e-01f, 1.21434644e-01f, -1.17754877e-01f, 1.26001313e-01f, 2.15493083e-01f, -1.54513523e-01f, 2.71454841e-01f, 3.24031234e-01f,
  -8.84135664e-02f, -2.11345062e-01f, 2.63314992e-01f, 4.06973392e-01f, -3.99524927e-01f, 4.16123986e-01f, 1.24502108e-02f, -3.23370814e-01f, -8.47089529e-01f, -6.47453368e-01f,
  1.72891915e-02f, 4.01510745e-01f, -5.31059615e-02f, 1.78707674e-01f, -7.09941760e-02f, 2.94650704e-01f, 1.90217718e-01f, -1.18122779e-01f, -2.50850976e-01f, -9.96703804e-02f,
  -2.20579561e-02f, -1.78441942e-01f, -2.28087157e-01f, 5.06557897e-02f, -1.05011702e-01f, -7.88001120e-02f, 1.07162334e-01f, -2.63801366e-01f, 2.57063597e-01f, 4.98868406e-01f,
  -1.29056290e-01f, 3.96129340e-01f, 3.09696168e-01f, 2.98043787e-01f, -1.85176700e-01f, 1.19302094e-01f, -1.18909841e-02f, -3.26189756e-01f, 2.00248703e-01f, -3.75486046e-01f,
  -5.09832919e-01f, 3.49778205e-01f, -4.14555907e-01f, 3.42400938e-01f, -4.01419312e-01f, -3.47022235e-01f, 3.08297537e-02f, 4.59868729e-01f, 2.68723935e-01f, -2.69682020e-01f,
  2.47256696e-01f, -2.22636357e-01f, -4.28240031e-01f, 7.28439316e-02f, -2.32446477e-01f, -7.51764849e-02f, -3.87261391e-01f, 1.49160087e-01f, -1.00156054e-01f, -9.11426321e-02f,
  -4.26208496e-01f, 2.49376059e-01f, 3.79460230e-02f, -4.25512403e-01f, -1.03673823e-01f, -5.57820618e-01f, 4.74408358e-01f, 2.16930121e-01f, -1.46406695e-01f, 3.71028006e-01f,
  2.71479517e-01f, 3.70444983e-01f, 9.06475261e-02f, -5.19003808e-01f, 2.02772230e-01f, -1.49891779e-01f, 3.91964316e-02f, 6.00466251e-01f, -4.34703261e-01f, -9.03737009e-01f,
  -7.14872405e-02f, 2.15739593e-01f, 1.90125853e-01f, 3.57524306e-01f, 3.06717634e-01f, -3.82793576e-01f, -4.98909652e-01f, -5.87164402e-01f, 8.77179112e-03f, 2.89741874e-01f,
  4.04098660e-01f, 2.59810150e-01f, 3.67892504e-01f, -3.21681276e-02f, -4.15636033e-01f, 3.58366743e-02f, 5.17796397e-01f, 5.16413033e-01f, -3.75982434e-01f, -5.16487546e-02f,
  4.95061010e-01f, -1.89496234e-01f, 2.17023060e-01f, -5.29432595e-01f, 2.20491394e-01f, -4.35681462e-01f, 4.03776646e-01f, -7.33285844e-01f, 5.73085606e-01f, -7.32266486e-01f,
  -4.74235594e-01f, -1.69612959e-01f, 8.08610488e-03f, 4.32897806e-02f, -1.13352261e-01f, 1.06221244e-01f, 6.85844272e-02f, -8.00448563e-03f, -4.20338213e-01f, 1.93029657e-01f,
  2.28236541e-01f, 1.87661871e-02f, -4.65320379e-01f, -3.46202821e-01f, -7.61324987e-02f, -1.00112103e-01f, -2.40288794e-01f, 5.49826324e-02f, 2.52075344e-01f, -4.67013538e-01f,
  -5.41099086e-02f, -1.38259947e-01f, 2.42513627e-01f, 3.51975590e-01f, -1.11866668e-01f, 3.73141803e-02f, -4.83298063e-01f, 2.40269750e-02f, 4.73328799e-01f, 1.98628753e-01f,
  -1.92246675e-01f, -8.59126151e-01f, 2.18868971e-01f, -1.21899985e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.43300249e-02f, 2.12332219e-01f, 1.67088702e-01f, -1.35978371e-01f, -1.05104700e-01f, -1.62805647e-01f, 1.38770849e-01f, 1.11565024e-01f, 1.89549699e-02f, 1.91952884e-01f,
  1.33658424e-01f, -1.08379908e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    