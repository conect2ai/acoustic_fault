/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.92711263e-03f, 1.64391957e-02f, 6.79219440e-02f, -1.43328547e-01f, -8.67239758e-03f, 1.02882214e-01f, 2.23644286e-01f, 2.46003317e-03f, -8.55601206e-02f, 4.09531221e-02f,
  1.30444271e-02f, -1.20768264e-01f, 1.20879663e-02f, 4.79234457e-02f, -2.00290252e-02f, 4.04090714e-03f, 1.76471863e-02f, 1.00957006e-01f, 3.41168568e-02f, 7.05996156e-02f,
  -6.99172840e-02f, -1.02326043e-01f, -1.34042814e-01f, 1.49756484e-02f, -4.85817902e-02f, -2.96780616e-02f, -1.22343838e-01f, -4.29837257e-02f, 2.32129917e-02f, 6.00359514e-02f,
  3.07346106e-01f, -8.68332162e-02f, 4.80761081e-02f, -3.48901190e-02f, 3.81781571e-02f, 3.67996320e-02f, 2.05083322e-02f, -2.44916882e-02f, -7.45082945e-02f, 7.63345435e-02f,
  -4.05222736e-03f, 2.45269667e-02f, 8.40941146e-02f, -3.58936265e-02f, -1.73152983e-02f, 4.01228592e-02f, -1.52128071e-01f, -2.22062063e-03f, -6.59128428e-02f, -3.30708921e-02f,
  -5.48875146e-02f, -4.34490964e-02f, 4.29565832e-03f, 3.79526094e-02f, 5.26780859e-02f, 7.37254396e-02f, 4.12170477e-02f, 9.70907658e-02f, -8.06669444e-02f, 4.84902225e-02f,
  -5.54001257e-02f, -4.05255996e-04f, 1.45286312e-02f, 6.59401529e-03f, 1.88285601e-03f, 2.20828317e-02f, -3.15152742e-02f, 4.39653993e-02f, 3.91432121e-02f, 3.05672549e-02f,
  -1.53325591e-02f, -6.38899058e-02f, -4.16829325e-02f, 1.81735586e-02f, -1.58854611e-02f, 7.28289485e-02f, 3.40938866e-02f, -4.13377658e-02f, -3.10482830e-02f, -5.05953953e-02f,
  -4.99283522e-02f, 4.61058579e-02f, -2.72513516e-02f, 3.33085135e-02f, 2.52154283e-02f, 2.21757367e-02f, 6.08139951e-03f, 5.61379902e-02f, -5.64463064e-03f, -2.13133786e-02f,
  3.34591568e-02f, -1.06522493e-01f, -3.09976516e-03f, -5.31674139e-02f, 4.79091518e-02f, 5.14583439e-02f, -1.75642259e-02f, -2.44772173e-02f, 4.17224504e-02f, -2.65647862e-02f,
  6.15443364e-02f, 6.79153427e-02f, 5.79150692e-02f, 6.73040077e-02f, 3.60264517e-02f, -2.13686703e-03f, -6.07296675e-02f, 2.48457193e-02f, -5.79576846e-03f, -1.85000449e-02f,
  8.92430369e-04f, 2.00140309e-02f, 6.83829486e-02f, 6.11853115e-02f, -4.91780937e-02f, -2.47470029e-02f, 6.43943250e-03f, -4.47648428e-02f, 5.13140336e-02f, -2.90094484e-02f,
  -1.11883722e-01f, -4.62967783e-01f, 1.46564469e-01f, 1.92178246e-02f, 7.24753439e-02f, 2.15064555e-01f, 2.84194555e-02f, 1.13027245e-01f, 9.86853428e-03f, -2.22406220e-02f,
  -4.43374179e-02f, -4.16063853e-02f, -4.53948639e-02f, -7.58513808e-02f, -2.04978175e-02f, -1.40191987e-02f, -1.12124354e-01f, 9.71186608e-02f, 2.42902458e-01f, -5.33397496e-03f,
  -1.42347187e-01f, -6.54760301e-02f, -1.07935958e-01f, 8.98880363e-02f, -6.61050528e-02f, 3.51571850e-02f, 4.78887483e-02f, -7.19829872e-02f, -1.09316453e-01f, -3.86393815e-01f,
  8.87523517e-02f, -2.26996794e-01f, 4.11334969e-02f, -1.42198309e-01f, -5.53138740e-02f, 4.41130660e-02f, 1.70411691e-02f, 3.77095379e-02f, 3.54251750e-02f, -4.07627746e-02f,
  2.01616250e-02f, 4.21450427e-03f, -2.68718842e-02f, 5.52915633e-02f, 1.38682444e-02f, -7.79930577e-02f, -6.72174245e-02f, -1.42283244e-02f, -8.16544332e-03f, -7.72594288e-02f,
  -9.59043875e-02f, -5.61877638e-02f, 1.80450846e-02f, -2.72063762e-02f, -1.11720785e-01f, 1.17037585e-02f, 3.11504826e-02f, -9.83498544e-02f, -3.83489691e-02f, -1.48815230e-01f,
  8.38597945e-04f, -4.46660146e-02f, 1.60061251e-02f, 3.43131796e-02f, 4.60206456e-02f, -2.82377079e-02f, 6.16251081e-02f, 6.54960647e-02f, 2.06344705e-02f, -8.19089785e-02f,
  5.44037521e-02f, 2.00762767e-02f, 5.17664663e-02f, 8.22987407e-03f, 9.12262872e-02f, -9.46945604e-03f, 4.94951643e-02f, -1.67488772e-02f, 7.44043142e-02f, -2.57253572e-02f,
  -3.70907672e-02f, -5.08269807e-03f, 3.21901068e-02f, -7.35494271e-02f, -6.73078895e-02f, 1.80148836e-02f, -1.84224080e-02f, -6.58608079e-02f, -1.01311877e-01f, -2.61971317e-02f,
  2.66266644e-01f, 8.18512440e-02f, 7.44313672e-02f, 3.20871710e-03f, 2.04970818e-02f, -3.30800116e-02f, 7.57383788e-03f, -1.04434833e-01f, -5.09017147e-02f, -5.24499379e-02f,
  1.66326705e-02f, 2.92385742e-03f, 3.19247320e-02f, 6.97747096e-02f, 2.15211716e-02f, -6.52396977e-02f, 1.88900344e-02f, 7.29767904e-02f, 1.98052879e-02f, 1.57703068e-02f,
  -2.80546956e-02f, 5.35702035e-02f, 1.21015646e-01f, 2.73377728e-02f, 2.54615657e-02f, 1.21698245e-01f, 1.21053539e-01f, 1.24818072e-01f, 5.87837622e-02f, 2.43375301e-01f,
  -5.74103137e-03f, -6.16754629e-02f, 3.51539031e-02f, -1.04724057e-01f, -3.75159010e-02f, 1.51046515e-01f, 9.54870433e-02f, 2.92109884e-02f, -1.46045908e-01f, -9.55956429e-02f,
  -1.35574177e-01f, -3.83997522e-02f, -5.44554666e-02f, -1.73909534e-02f, 4.89774011e-02f, 1.07498109e-01f, -1.96782919e-03f, 5.05434945e-02f, 9.69924256e-02f, 1.12352848e-01f,
  3.70239168e-02f, 5.52635407e-03f, 1.47573063e-02f, -4.19618115e-02f, -3.20521891e-02f, 6.11495133e-03f, 6.25233352e-02f, -7.59648904e-02f, 2.71669161e-02f, -4.40137684e-02f,
  7.39821196e-02f, -1.61876276e-01f, 1.11137755e-01f, -1.33959046e-02f, -6.08249381e-02f, 3.81504185e-02f, -4.88954820e-02f, -1.05482139e-01f, -9.81513690e-03f, 5.00882715e-02f,
  -7.43526146e-02f, -1.16991714e-01f, -5.10736443e-02f, 6.26646057e-02f, -8.64424258e-02f, 2.96301786e-02f, 2.45631915e-02f, 4.46844436e-02f, 2.92687099e-02f, 2.26560831e-02f,
  -3.86762526e-03f, -6.99674413e-02f, 2.40205191e-02f, 7.19770342e-02f, 3.75300497e-02f, -2.56271288e-02f, 1.44458622e-01f, -2.74232589e-02f, -3.56530994e-02f, 1.01133429e-01f,
  3.22226770e-02f, -1.31180435e-02f, -2.29399046e-03f, 3.36811654e-02f, -7.33584957e-03f, -1.95929296e-02f, -5.44218533e-02f, -3.21780629e-02f, 6.47077262e-02f, 3.36199976e-03f,
  5.04101217e-02f, -1.31669492e-02f, -6.24927785e-03f, 5.30373829e-04f, -6.16810992e-02f, 1.19372234e-02f, 2.90448591e-02f, 1.22461863e-01f, -2.52100807e-02f, -2.89730374e-02f,
  6.59732595e-02f, -2.08361335e-02f, -2.40458157e-02f, -7.40930364e-02f, 7.42949918e-02f, 8.27698223e-03f, -5.06034344e-02f, -2.06899010e-02f, 5.50787635e-02f, -5.78270368e-02f,
  4.22638766e-02f, -1.83520302e-01f, 1.05266578e-01f, 3.93444784e-02f, 6.31036833e-02f, 7.27007538e-03f, -6.90763444e-02f, 2.66101696e-02f, 1.48866475e-02f, 1.03613250e-01f,
  4.84499708e-02f, 1.52653893e-02f, -2.92271618e-02f, -3.55308540e-02f, -4.33263667e-02f, 8.52497816e-02f, 8.83948803e-02f, 5.25895990e-02f, 7.02408478e-02f, 1.25600044e-02f,
  8.76108557e-02f, 9.26178023e-02f, 2.32150704e-01f, 1.56043977e-01f, -5.40067106e-02f, 9.33801010e-02f, 1.23517193e-01f, 7.97642618e-02f, 2.12423578e-01f, 2.46954978e-01f,
  -9.85215604e-02f, 1.16269905e-02f, -1.12309948e-01f, 1.18340865e-01f, 5.51560074e-02f, 3.10178217e-03f, -1.50881484e-01f, -1.84977189e-01f, -9.32922736e-02f, -2.44478788e-02f,
  4.15671468e-02f, -6.07399009e-02f, -3.15643772e-02f, 6.41630441e-02f, -1.82784125e-01f, -7.06135780e-02f, 1.27993999e-02f, -3.20232920e-02f, -1.63270608e-01f, -4.74573970e-02f,
  4.21544053e-02f, -1.42963668e-02f, -6.61645159e-02f, 5.90471700e-02f, 1.53618589e-01f, 3.40280756e-02f, 5.87513484e-02f, 4.77454588e-02f, 8.40987936e-02f, 1.47063151e-01f,
  2.57244986e-02f, 9.61177498e-02f, -3.19221453e-03f, 5.61378151e-02f, 3.72912250e-02f, 5.76007515e-02f, 4.60779434e-03f, -6.46981299e-02f, 2.94007198e-03f, -4.41952385e-02f,
  -4.62218709e-02f, 1.30547155e-02f, 4.15854752e-02f, 2.28347722e-02f, -1.11767538e-01f, -3.41294818e-02f, -8.01550283e-04f, 9.44280811e-03f, -1.28878718e-02f, -7.75288744e-03f,
  -3.10971402e-02f, 9.91504714e-02f, -4.24900316e-02f, 9.14781094e-02f, 1.49427475e-02f, 1.39795795e-01f, 5.95293753e-02f, 1.44435270e-02f, 6.63303360e-02f, -8.10542703e-02f,
  -4.63494584e-02f, -3.75919379e-02f, 1.03495859e-01f, 1.68777462e-02f, 8.52987636e-03f, -8.17492530e-02f, 5.74356206e-02f, 2.99075549e-03f, 2.91544236e-02f, -6.64384142e-02f,
  4.09084894e-02f, -6.43636193e-03f, 2.07185801e-02f, -1.68405846e-02f, 2.52488372e-03f, 3.67170274e-02f, 7.94481784e-02f, 3.81578915e-02f, -1.60369352e-02f, 1.59157775e-02f,
  -3.17536518e-02f, 8.85086656e-02f, -7.64398426e-02f, -1.49571272e-02f, 7.70644620e-02f, 6.83184788e-02f, -3.92211452e-02f, 5.10911085e-02f, -6.85720369e-02f, 4.55689318e-02f,
  -1.24428317e-01f, 1.00123674e-01f, 4.61406186e-02f, 1.18019776e-02f, -8.62651840e-02f, 6.39180988e-02f, 1.30252093e-01f, 7.46656284e-02f, 1.28007486e-01f, -4.78492044e-02f,
  7.05936700e-02f, 7.72581203e-03f, 1.26371622e-01f, -4.24830131e-02f, 1.09250434e-02f, -3.54310758e-02f, 4.05055285e-02f, 1.40293958e-02f, 3.60051319e-02f, 1.75199062e-02f,
  4.17743772e-02f, -1.15724705e-01f, 3.32508607e-05f, -6.09485358e-02f, 3.97364236e-02f, 1.21800639e-02f, -5.83474301e-02f, -8.30853730e-02f, 1.30798155e-02f, -2.38566443e-01f,
  -4.43268985e-01f, 9.00180936e-02f, -1.96428031e-01f, -4.17755023e-02f, 7.78843760e-02f, -5.54149188e-02f, 4.26424704e-02f, -8.40126052e-02f, -7.45393783e-02f, 1.17473386e-01f,
  1.12520987e-02f, 8.91316384e-02f, 2.62899604e-02f, 2.88470108e-02f, -1.34756327e-01f, 2.14153808e-02f, 1.43348068e-01f, -9.71090719e-02f, -2.47902125e-01f, 4.59493650e-03f,
  1.58762962e-01f, 8.56745616e-03f, -2.91892022e-01f, -2.28458270e-01f, 9.23775509e-02f, -9.83733907e-02f, -9.79766715e-03f, -6.21768497e-02f, 3.61578800e-02f, 3.02263886e-01f,
  -5.35102077e-02f, -1.14219628e-01f, -4.78996783e-02f, 1.03442870e-01f, 4.87564830e-03f, -1.31325880e-02f, -9.59790871e-03f, -1.72827002e-02f, 8.21536127e-03f, -1.03502944e-01f,
  7.46268705e-02f, 5.91893196e-02f, -5.48209809e-02f, 5.20769432e-02f, -7.84886032e-02f, 3.01705543e-02f, -4.73307297e-02f, -8.33755508e-02f, -9.44749713e-02f, -6.39438778e-02f,
  1.01025015e-01f, 1.70787890e-02f, 3.84995528e-02f, -5.51019609e-02f, -1.23819135e-01f, 6.76124319e-02f, 5.15476288e-03f, -4.37586904e-02f, -4.98192869e-02f, -2.61015981e-03f,
  7.29535520e-02f, 4.10829410e-02f, 1.12247951e-01f, 1.97437685e-02f, 8.63120239e-03f, -5.52587956e-02f, 1.25889093e-01f, 2.10166741e-02f, -1.33651868e-02f, 3.27977948e-02f,
  -4.85764779e-02f, -5.03778830e-02f, 1.14095189e-01f, -1.72819234e-02f, -4.08681901e-03f, -3.44739179e-03f, -3.33159268e-02f, -6.87788427e-02f, 1.20510897e-02f, 1.15477694e-02f,
  9.05258209e-02f, -5.03849573e-02f, -5.65060694e-03f, -9.45245028e-02f, 2.39591002e-02f, 5.27085364e-02f, -3.21411900e-02f, 4.07346077e-02f, -9.40445904e-03f, 1.58305690e-02f,
  -5.14746942e-02f, -1.11048698e-01f, 1.90430153e-02f, 8.28776956e-02f, -3.56270857e-02f, -3.84254083e-02f, -5.87064726e-03f, -4.55683172e-02f, -8.23974386e-02f, -2.92457882e-02f,
  -3.15006897e-02f, -5.94008826e-02f, 5.62667809e-02f, -1.35720829e-02f, 1.39704030e-02f, 6.16250336e-02f, 1.49736315e-01f, 6.24779947e-02f, 2.93727349e-02f, 2.83525418e-02f,
  -4.16974947e-02f, -6.77955300e-02f, 3.69192101e-02f, 6.69768751e-02f, -3.78246047e-02f, -1.26723558e-01f, -1.45275384e-01f, -9.77557674e-02f, -1.95383579e-01f, -7.65374899e-02f,
  1.20624050e-01f, 7.51765743e-02f, 3.16738367e-01f, 1.11192442e-01f, 2.26080902e-02f, -5.63792735e-02f, 5.44020720e-02f, -9.06331763e-02f, -1.49453297e-01f, 6.52037412e-02f,
  -1.62415009e-03f, -1.42661348e-01f, -2.32221261e-01f, -1.37365729e-01f, 8.61314032e-03f, 1.22372163e-02f, 2.14785054e-01f, 1.46265283e-01f, 1.55157465e-02f, 3.96697856e-02f,
  -6.26598373e-02f, 1.79945871e-01f, 1.88083440e-01f, 7.70153850e-02f, 7.45155811e-02f, -2.08940312e-01f, 1.24383248e-01f, 2.55161263e-02f, 4.84467149e-02f, 2.49526113e-01f,
  -5.39691225e-02f, 2.32525185e-01f, 3.04642301e-02f, 5.03473403e-03f, -6.98638931e-02f, -1.49219427e-02f, -1.42769497e-02f, 2.53613498e-02f, 1.37818903e-02f, 1.07847191e-02f,
  8.24774057e-02f, -5.51792458e-02f, -2.26478949e-02f, 2.47316472e-02f, 2.04686411e-02f, 3.69428284e-02f, -2.33799350e-02f, 1.00495957e-01f, 6.23918604e-03f, -5.96913546e-02f,
  1.93772987e-02f, 8.91043171e-02f, 3.18984427e-02f, -8.27468336e-02f, -5.50276712e-02f, -1.65910963e-02f, -1.87098160e-02f, 8.28984678e-02f, 3.20782885e-02f, -2.78204922e-02f,
  -1.11927889e-01f, 5.20402230e-02f, 2.98615973e-02f, 9.91576165e-02f, -6.12208135e-02f, 6.67406097e-02f, 3.70830134e-03f, -1.39982309e-02f, -1.27796698e-02f, 3.08921319e-02f,
  -2.07649413e-02f, 1.81053299e-02f, 1.74347479e-02f, 6.02261052e-02f, 6.46994915e-04f, 2.70245876e-02f, -3.36203985e-02f, -5.42659461e-02f, 6.58924654e-02f, 4.50235978e-03f,
  -1.18351683e-01f, -3.76494266e-02f, 7.24994615e-02f, -3.60060446e-02f, 3.77348736e-02f, 7.54759684e-02f, -4.65281047e-02f, -8.18709657e-02f, 3.63312173e-03f, 8.63662735e-02f,
  -2.83189416e-01f, 3.08208726e-02f, -6.19307011e-02f, -1.52027821e-02f, -6.35832995e-02f, -3.48382001e-03f, -5.74670024e-02f, 2.00647786e-02f, -1.40324114e-02f, -8.17694589e-02f,
  4.38663661e-02f, -7.19384756e-04f, 1.74242258e-02f, -1.21124620e-02f, -9.03978385e-03f, -2.26976648e-02f, -3.44380550e-02f, -1.99778024e-02f, -3.11387163e-02f, -7.67194182e-02f,
  -6.02137893e-02f, -1.62742555e-01f, -9.42974240e-02f, -7.93766975e-02f, -5.56699038e-02f, -1.17116995e-01f, -6.96450621e-02f, -3.57471779e-02f, -2.40974307e-01f, -2.75822788e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.15171382e-01f, -1.28834054e-01f, -1.18680403e-01f, -5.92993498e-02f, 8.19610432e-02f, 1.02256723e-01f, -1.75253972e-02f, 4.07265201e-02f, 4.82641757e-02f, -6.48361165e-03f,
  1.45932391e-01f, 1.35526538e-01f, 1.42807871e-01f, 6.55937418e-02f, 1.30360648e-01f, -8.10108632e-02f, -2.07556393e-02f, -2.71309204e-02f, -4.77564614e-03f, 1.43437102e-01f,
  -2.46996041e-02f, 8.27787295e-02f, -3.39025632e-03f, -5.61751202e-02f, -7.08371475e-02f, 2.53492985e-02f, -1.25477031e-01f, -1.26235545e-01f, 6.29346743e-02f, -1.05807401e-01f,
  -8.33926499e-02f, 1.45936862e-03f, 1.01432189e-01f, 9.54015255e-02f, -1.03999786e-01f, 3.50453034e-02f, -1.03311308e-01f, -1.54262073e-02f, -3.91271599e-02f, -3.11211031e-02f,
  -1.73173957e-02f, 1.11657400e-02f, -3.39054614e-02f, 8.30525085e-02f, 9.61480662e-03f, 6.44270852e-02f, -2.96542756e-02f, -1.78514014e-03f, 3.70017514e-02f, -6.04254426e-03f,
  -5.13393544e-02f, -6.07832186e-02f, -1.11072607e-01f, -8.42619780e-03f, 4.05130833e-02f, 1.11733802e-01f, 3.94256413e-02f, 1.51555948e-02f, 3.67098488e-02f, -7.54551664e-02f,
  6.73332214e-02f, -6.84305280e-02f, 3.14824060e-02f, 5.71924029e-03f, -4.02464233e-02f, 8.35297164e-03f, 7.46610854e-03f, -9.11944732e-02f, -8.48118141e-02f, 3.86761427e-02f,
  1.98991932e-02f, -5.57135344e-02f, 6.23216704e-02f, 5.81242815e-02f, -5.64010516e-02f, -7.72954971e-02f, 2.76705697e-02f, -6.91597760e-02f, 1.84964407e-02f, -2.33425107e-02f,
  8.49155486e-02f, 4.09665704e-02f, 5.24317008e-03f, 9.76654217e-02f, 3.75044625e-03f, -6.10125670e-03f, 3.04243807e-02f, -3.03686131e-03f, 3.73019725e-02f, -1.40950838e-02f,
  -9.29678455e-02f, -3.30621228e-02f, 2.74125375e-02f, 8.21398851e-03f, -8.03784728e-02f, -1.08389057e-01f, -1.17602581e-02f, -2.37332587e-03f, -2.58583650e-02f, -2.16663908e-02f,
  4.39846702e-02f, -4.09456603e-02f, -9.20243114e-02f, 3.84586640e-02f, 2.86458917e-02f, -1.22077428e-04f, -1.93779133e-02f, 5.31601310e-02f, 4.67155650e-02f, 4.01533619e-02f,
  -5.18678091e-02f, 2.81523261e-02f, -7.27923214e-02f, 9.17502958e-03f, 6.50864467e-03f, 5.66626247e-03f, 2.71038711e-02f, 5.75814880e-02f, 6.92782691e-03f, -4.94890613e-03f,
  -4.44144271e-02f, -9.49009322e-03f, 8.26432034e-02f, -1.88704245e-02f, 9.74935591e-02f, -4.57722396e-02f, -9.21771005e-02f, -5.92663437e-02f, -8.78967345e-02f, 4.19784933e-02f,
  -1.81935113e-02f, 6.75904974e-02f, 3.55134271e-02f, 1.82748716e-02f, -1.50546301e-02f, -5.19039668e-02f, -7.70450011e-02f, -7.74712563e-02f, 1.35628544e-02f, 2.76744515e-02f,
  1.30184395e-02f, 8.46822113e-02f, 5.14346473e-02f, -1.29735712e-02f, 1.20566152e-02f, 2.77892761e-02f, -3.32190245e-02f, 1.97269507e-02f, 1.18860155e-01f, 1.09962165e-01f,
  1.42357573e-01f, 4.85770479e-02f, 4.16317023e-02f, -4.40076739e-02f, -4.96703982e-02f, -8.79464522e-02f, -4.65683006e-02f, 2.59448756e-02f, -3.94734852e-02f, 6.69488609e-02f,
  -1.10196387e-02f, -2.43627839e-02f, -6.97938576e-02f, 2.60716639e-02f, -6.85633048e-02f, -3.17634195e-02f, -5.14703058e-02f, -7.41861090e-02f, -7.22196475e-02f, -5.01637608e-02f,
  -3.10089383e-02f, -5.19394781e-03f, 1.70493275e-02f, -7.42711052e-02f, -3.03775016e-02f, -1.41766919e-02f, -4.03573960e-02f, -4.52669263e-02f, 4.98158894e-02f, -3.51200216e-02f,
  -6.66332692e-02f, -4.12411205e-02f, -8.05512443e-02f, -6.88875616e-02f, -2.61243656e-02f, -4.70151901e-02f, 2.84052063e-02f, 1.35885077e-02f, -8.92251655e-02f, -6.62557855e-02f,
  6.70804679e-02f, 5.96168004e-02f, -9.28312168e-02f, 1.93825699e-02f, -2.76050288e-02f, 7.05049932e-02f, -2.54384466e-02f, 6.35446236e-02f, -6.09678067e-02f, -5.92023917e-02f,
  -3.17402892e-02f, -5.89820892e-02f, -3.66240852e-02f, -1.42696183e-02f, 4.48553786e-02f, -1.00333825e-01f, 7.77980760e-02f, -1.73468981e-02f, -3.50644626e-02f, -3.74146700e-02f,
  3.63980159e-02f, -9.32844803e-02f, 5.03519140e-02f, -6.33899271e-02f, 5.28382659e-02f, 7.15442300e-02f, -4.92783412e-02f, -8.42161626e-02f, 4.77648638e-02f, 2.82918867e-02f,
  3.54693905e-02f, 9.56423301e-03f, 7.29508474e-02f, -7.61367083e-02f, -1.93360914e-02f, 2.68380949e-03f, -6.62554428e-03f, -3.43060284e-03f, 4.01403420e-02f, -6.12467751e-02f,
  -1.02245644e-01f, -8.01704377e-02f, 2.40749083e-02f, 2.84887087e-02f, -9.08417180e-02f, 5.12852613e-03f, 8.41204450e-02f, 3.80298682e-02f, 2.17386167e-02f, 4.81895134e-02f,
  -2.80746907e-01f, -2.67678667e-02f, -3.61200608e-02f, -1.31139737e-02f, 8.30979422e-02f, 4.74035321e-03f, 1.39266670e-01f, 5.36234751e-02f, 6.25872053e-03f, -1.19911209e-02f,
  -3.70688587e-02f, 1.02848466e-02f, 4.31489162e-02f, -4.91937213e-02f, 4.09076326e-02f, 9.56881344e-02f, 2.53595714e-03f, -4.81895283e-02f, 9.05475300e-03f, -4.60992604e-02f,
  -5.95714971e-02f, -1.44619763e-01f, -1.79000914e-01f, -4.66865376e-02f, -5.20285219e-02f, -1.09927142e-02f, -2.98948269e-02f, 6.90350011e-02f, 1.48273874e-02f, -3.35979164e-02f,
  1.74077854e-01f, -5.52614592e-02f, 4.06269468e-02f, 3.16930562e-02f, 3.42161045e-03f, -1.03361048e-01f, 6.22598380e-02f, 4.45691869e-03f, -5.88016324e-02f, 6.85656667e-02f,
  -9.63004157e-02f, -4.54279296e-02f, 3.39112878e-02f, 7.56348222e-02f, 3.59981991e-02f, -6.06023185e-02f, -6.43190518e-02f, 8.42776746e-02f, 1.70134827e-02f, 1.06246620e-01f,
  8.39080103e-03f, 3.32812816e-02f, -1.20224645e-02f, 7.41223693e-02f, 1.21896006e-02f, 1.16640814e-01f, -3.39992978e-02f, 9.73461419e-02f, 1.00986257e-01f, -9.97282639e-02f,
  2.56914459e-03f, -8.64966810e-02f, -3.09247710e-02f, 4.58787791e-02f, -3.42876911e-02f, 3.28192227e-02f, -2.66554542e-02f, -6.88375235e-02f, -9.49733891e-03f, -1.25954658e-01f,
  -2.26120707e-02f, 4.57227230e-02f, -4.80192266e-02f, 2.95975693e-02f, 7.38366619e-02f, -2.18026359e-02f, -8.50429609e-02f, 8.94805193e-02f, 2.67620441e-02f, 9.99960005e-02f,
  -2.59233676e-02f, -7.37643521e-03f, -5.41143157e-02f, 6.55226782e-02f, 6.71008900e-02f, 4.76908684e-03f, -5.63194081e-02f, 2.36738902e-02f, -5.43452725e-02f, -5.26582226e-02f,
  2.95449253e-02f, -2.20266692e-02f, -8.77806768e-02f, -7.93107301e-02f, 5.55968173e-02f, -7.73303956e-02f, -4.38452349e-04f, -8.66536275e-02f, 1.42888371e-02f, 6.87393174e-02f,
  1.85905378e-02f, -8.63983035e-02f, -8.90778080e-02f, 3.40150520e-02f, -1.06397875e-01f, 3.07153631e-02f, -6.08250424e-02f, -5.05267363e-03f, 3.33181880e-02f, 3.84635441e-02f,
  7.59354085e-02f, 1.02542371e-01f, -6.14583446e-03f, 6.43236712e-02f, 1.10387154e-01f, -5.48220128e-02f, -2.74655614e-02f, 4.10299934e-02f, 4.87416238e-02f, -3.56831886e-02f,
  -7.95743465e-02f, 2.23725781e-01f, 2.75213420e-02f, 2.68615242e-02f, 1.35879338e-01f, 1.56682029e-01f, 2.59798884e-01f, 1.65670663e-01f, -2.36700084e-02f, 3.79269496e-02f,
  -8.97584334e-02f, -9.66548547e-02f, -5.83097376e-02f, -1.11315399e-01f, 3.85465808e-02f, 1.01216406e-01f, -1.95990000e-02f, -8.82861689e-02f, -2.15606764e-02f, -8.32149833e-02f,
  4.57641147e-02f, 5.84838800e-02f, -4.67259660e-02f, -2.56962031e-02f, 8.91525671e-02f, -4.58557270e-02f, -6.34735599e-02f, -2.88277864e-02f, -6.19351752e-02f, 3.97383533e-02f,
  -8.44705626e-02f, -4.01500352e-02f, -4.87854965e-02f, -5.35619557e-02f, -9.52842310e-02f, -7.12053999e-02f, 2.48962566e-02f, -3.68426405e-02f, 2.65095737e-02f, 1.55170681e-02f,
  1.05522908e-01f, -6.23187199e-02f, 5.54932207e-02f, 7.44328648e-02f, 1.37195855e-01f, 4.72299121e-02f, -2.02851370e-02f, 6.07011877e-02f, 3.07308156e-02f, -4.48880158e-02f,
  5.36707304e-02f, -1.54701024e-02f, 2.73109097e-02f, 1.20108306e-01f, 6.00863546e-02f, -6.23979047e-02f, -1.17233144e-02f, -1.93517953e-02f, 9.08309370e-02f, -4.86334190e-02f,
  -1.31464541e-01f, -7.64933676e-02f, -1.16638318e-02f, 6.32745773e-02f, -1.45156002e-02f, -1.28954658e-02f, 2.78658401e-02f, 3.08687389e-02f, -1.88208222e-02f, 9.96866450e-02f,
  -4.23370376e-02f, 3.62501107e-02f, 4.90087457e-02f, 2.99921837e-02f, 5.62471151e-02f, 9.62848142e-02f, 1.94521341e-02f, 1.04061775e-01f, 5.98796047e-02f, -4.20343652e-02f,
  -3.55842188e-02f, 1.35181509e-02f, -3.05437837e-02f, -1.24814399e-02f, 3.64682153e-02f, 4.40607667e-02f, -8.58096220e-03f, 3.69654186e-02f, 1.20790703e-02f, -2.38229521e-03f,
  -1.79188058e-01f, -4.87360246e-02f, -1.79161038e-02f, 4.40093465e-02f, -9.72022340e-02f, -8.75811093e-03f, -5.05694598e-02f, -5.15327267e-02f, -9.63510722e-02f, 1.11791871e-01f,
  5.12416437e-02f, 2.48912349e-02f, 6.08472228e-02f, 6.83003617e-03f, -1.70117384e-03f, -8.36607292e-02f, -8.63773599e-02f, 1.63603872e-02f, -1.09289043e-01f, -1.10326491e-01f,
  2.09708661e-02f, -9.86843407e-02f, -7.57949948e-02f, 2.71249358e-02f, -1.14828581e-02f, -8.15167576e-02f, -7.92062283e-02f, -1.00219306e-02f, -3.75029854e-02f, -4.05655578e-02f,
  1.39660090e-01f, 9.89020523e-03f, 5.43100983e-02f, 1.11854196e-01f, 7.53108561e-02f, 2.10071743e-01f, 2.13934407e-01f, 8.78206193e-02f, 1.00553364e-01f, 2.40087602e-02f,
  2.23611388e-02f, 5.57507873e-02f, 6.45000562e-02f, -1.16853818e-01f, 4.63019013e-02f, 9.74419806e-03f, 1.84247401e-02f, -3.25707570e-02f, -7.38237947e-02f, 6.48793504e-02f,
  -9.23658162e-02f, -1.71826463e-02f, -7.13251755e-02f, 2.13483777e-02f, 5.05141206e-02f, -5.48497289e-02f, -1.23260384e-02f, -5.29202372e-02f, 1.35055380e-02f, 3.99849238e-03f,
  3.61629389e-02f, 1.46222308e-01f, 9.10237990e-03f, -6.36147410e-02f, -6.82338923e-02f, 2.55435854e-02f, -7.55048469e-02f, 3.81092019e-02f, -6.79775178e-02f, -6.01583114e-03f,
  3.81111018e-02f, 3.10408580e-03f, -6.76268712e-02f, -8.33016038e-02f, 3.83506082e-02f, 7.14027807e-02f, 4.04579453e-02f, -3.52344438e-02f, 1.93364397e-02f, -8.78882259e-02f,
  -6.41261935e-02f, -1.73457875e-03f, 1.19328819e-01f, 9.43987742e-02f, 7.43216425e-02f, 1.00768439e-01f, -1.00751827e-02f, 1.47618109e-03f, 1.16238184e-01f, 5.44415005e-02f,
  -2.34250613e-02f, 7.45316222e-02f, -2.07548845e-03f, -2.96275243e-02f, 7.14520440e-02f, 2.56969165e-02f, -3.69285047e-02f, -6.95972741e-02f, 1.00344308e-02f, -1.22526847e-01f,
  -4.29739766e-02f, 1.02691956e-01f, 8.44696537e-02f, 1.09533109e-02f, 7.39548877e-02f, 1.67448465e-02f, -4.26414460e-02f, -2.49374397e-02f, 6.77479580e-02f, -8.04229528e-02f,
  -1.03144981e-02f, -5.74429054e-03f, -2.48975288e-02f, 6.06377013e-02f, 2.41415258e-02f, 8.01081862e-03f, -3.36064622e-02f, -1.95746962e-02f, -9.08699259e-03f, -8.85452852e-02f,
  -3.34194526e-02f, 1.22905180e-01f, -1.95576232e-02f, 6.18695887e-03f, -4.19320278e-02f, -1.26112491e-01f, 7.68318921e-02f, 9.18845236e-02f, 3.05353161e-02f, -2.53734440e-02f,
  4.27266434e-02f, -5.19605689e-02f, 5.99243008e-02f, -1.30929220e-02f, -7.70303681e-02f, -5.62051944e-02f, 2.22966671e-02f, 1.89786796e-02f, -3.21940184e-02f, -1.14201337e-01f,
  -8.04831535e-02f, -2.34876703e-02f, 3.90344448e-02f, -2.57907324e-02f, 1.01701645e-02f, 3.80324498e-02f, -3.81020494e-02f, 4.89860140e-02f, -1.78657228e-03f, -9.17775184e-02f,
  -8.77759159e-02f, -4.75367308e-02f, 8.51268992e-02f, -1.06387138e-01f, -5.06949797e-02f, 1.19671533e-02f, 1.45324692e-01f, 7.92580843e-02f, -3.00131943e-02f, 8.03033337e-02f,
  -3.39939669e-02f, 6.13929778e-02f, -9.32338089e-02f, -4.54615429e-02f, -6.85979519e-03f, 4.48742043e-03f, 4.89832498e-02f, -7.61070773e-02f, -5.44772707e-02f, -4.47339080e-02f,
  9.25273169e-03f, -1.18567817e-01f, -1.12884782e-01f, -4.03207988e-02f, -4.01216112e-02f, -9.46966410e-02f, -7.93064684e-02f, -3.26987356e-02f, -6.14392720e-02f, -6.50396273e-02f,
  6.30062371e-02f, 7.05228969e-02f, 2.18998715e-02f, 7.77905248e-03f, -4.93625589e-02f, -7.85120502e-02f, -2.98974924e-02f, 7.55039006e-02f, 4.35613319e-02f, 2.71783862e-03f,
  -2.49243584e-02f, -2.75649000e-02f, 4.08656448e-02f, -5.56993391e-03f, 6.80804551e-02f, -7.82506075e-03f, -5.36820367e-02f, 3.27125713e-02f, 4.31007557e-02f, 1.24927461e-01f,
  8.30539241e-02f, 4.40436304e-02f, 2.06106659e-02f, 4.96496446e-02f, -4.31499071e-02f, -8.62148777e-02f, 4.69178855e-02f, 6.51293993e-02f, -7.47953802e-02f, -7.23142624e-02f,
  -6.00742176e-03f, -8.01471397e-02f, 6.28537983e-02f, -5.04440404e-02f, -9.30697322e-02f, -6.52364045e-02f, -3.55275348e-02f, -7.37933964e-02f, 1.01119168e-02f, -5.72734103e-02f,
  3.50792557e-02f, 9.62235704e-02f, 1.04381926e-02f, -7.79175088e-02f, -4.33190726e-02f, 1.42972255e-02f, 4.40656133e-02f, 2.54833661e-02f, -3.08700837e-02f, -1.18079688e-02f,
  8.44534263e-02f, 3.26881036e-02f, -2.36897934e-02f, -3.93346976e-03f, 2.35854276e-02f, 6.73102364e-02f, 1.68225020e-02f, 1.89084765e-02f, 1.01614902e-02f, 4.27541733e-02f,
  8.61318111e-02f, 2.12282203e-02f, 6.53249249e-02f, 4.41970723e-03f, 5.93634322e-02f, -2.69757006e-02f, -7.02883489e-03f, -1.14328424e-02f, 8.31143633e-02f, -6.54971693e-03f,
  9.82174799e-02f, -1.86696518e-02f, 7.47701600e-02f, 7.64769614e-02f, -2.28430033e-02f, 1.18741557e-01f, 9.30363610e-02f, -1.38184559e-02f, -2.10792851e-02f, 6.40209764e-02f,
  -8.89899582e-03f, 4.24165279e-02f, -3.37177254e-02f, -6.32846579e-02f, -2.20285319e-02f, -3.08012590e-02f, 3.64693478e-02f, 7.69404173e-02f, 3.84229841e-03f, -2.05479679e-03f,
  -3.08522284e-01f, 1.19085819e-01f, -1.76283225e-01f, 7.98066929e-02f, 1.61209524e-01f, 5.79946190e-02f, 1.62501216e-01f, -7.29922857e-03f, 7.16654882e-02f, 1.09773755e-01f,
  -1.83612909e-02f, 6.18935600e-02f, 1.49904951e-01f, 9.99983102e-02f, 9.98768508e-02f, 2.19432265e-02f, 4.95634452e-02f, -4.46610823e-02f, -1.07589036e-01f, 5.08175604e-02f,
  1.02558494e-01f, 5.00057377e-02f, -1.27976671e-01f, -8.93438980e-03f, 6.15489334e-02f, 1.28369659e-01f, -9.33428779e-02f, 8.14708099e-02f, 3.15093482e-03f, 1.63933784e-01f,
  -1.78807918e-02f, -1.79577678e-01f, -7.70311728e-02f, -4.88099121e-02f, -4.39448170e-02f, -9.04832259e-02f, -9.20525789e-02f, -1.16101548e-01f, -7.33554782e-03f, -9.31197628e-02f,
  -9.75846313e-03f, 1.94598697e-02f, -5.95270051e-03f, -4.01739776e-02f, 5.38564399e-02f, -5.13722450e-02f, -7.50722224e-03f, -1.66285843e-01f, -1.46577671e-01f, 6.39981031e-03f,
  9.75410044e-02f, -3.38600613e-02f, -1.30940825e-01f, -9.19084102e-02f, -9.37414076e-03f, 7.03932866e-02f, -4.86050472e-02f, -3.55689228e-02f, -1.58660516e-01f, 2.44610664e-02f,
  -4.57597487e-02f, 8.93149897e-02f, -8.39375556e-02f, 5.36180921e-02f, -3.21061425e-02f, 4.68822867e-02f, 1.98377799e-02f, 9.82624218e-02f, -6.71506673e-02f, 1.08249718e-02f,
  -7.65086338e-02f, -1.19194664e-01f, -7.99519122e-02f, -7.44822398e-02f, -3.52030993e-02f, 1.17205326e-02f, 3.65874618e-02f, -7.35636353e-02f, -7.11643770e-02f, -4.53783162e-02f,
  -4.63794060e-02f, -8.14045593e-03f, 3.73322703e-02f, 6.32921234e-02f, -6.89818384e-03f, 3.66544095e-03f, -8.43834877e-02f, -7.50612989e-02f, -9.00969952e-02f, -6.27243798e-03f,
  -4.92573567e-02f, 4.56618071e-02f, -1.95041802e-02f, -2.26238184e-02f, -2.75594033e-02f, 2.45599523e-02f, -5.81402220e-02f, -5.18491566e-02f, -1.97455119e-02f, -2.67584808e-02f,
  -2.68158633e-02f, 1.00149950e-02f, 1.35465814e-02f, -8.49267170e-02f, -8.54258612e-02f, -2.70189214e-02f, -7.91350901e-02f, -5.50788194e-02f, -6.31435588e-03f, -1.87574234e-02f,
  -2.91698743e-02f, -1.37284650e-02f, -1.54436186e-01f, -4.20309640e-02f, 6.87107220e-02f, -8.27476382e-03f, 5.15237562e-02f, 1.49330404e-02f, -1.47955105e-01f, -6.07768148e-02f,
  -3.43556553e-02f, 2.50633564e-02f, -1.20374886e-02f, 6.63351864e-02f, -6.49707690e-02f, 1.73753593e-02f, -8.16643611e-02f, 8.33925754e-02f, 9.39449742e-02f, 4.49759364e-02f,
  -6.78672418e-02f, -3.48503962e-02f, 3.32518704e-02f, -6.30529597e-02f, -5.84796518e-02f, -8.60180929e-02f, -2.16018111e-01f, -1.60000145e-01f, -1.88908666e-01f, -9.45963189e-02f,
  -1.41602069e-01f, -1.29480302e-01f, -1.02996074e-01f, -6.26097023e-02f, 1.24649361e-01f, -1.24574509e-02f, 6.48723096e-02f, -4.12596688e-02f, -2.55056191e-02f, -7.23698130e-03f,
  -1.17314555e-01f, -4.77241836e-02f, -1.31783903e-01f, -1.28859341e-01f, -2.35334709e-02f, 1.46728260e-02f, -1.41184628e-02f, 3.01888548e-02f, 2.39595864e-02f, -3.05163562e-02f,
  -1.24633141e-01f, 7.31575042e-02f, -4.17790325e-05f, -4.27827053e-02f, -2.80553531e-02f, -4.40518968e-02f, -5.21050766e-02f, 1.33280980e-03f, 6.27269521e-02f, 7.59166405e-02f,
  -1.05550893e-01f, -9.46963727e-02f, 5.92317805e-02f, 1.28194630e-01f, -5.94600067e-02f, -6.93436265e-02f, -1.92385297e-02f, 1.00327387e-01f, 1.00568302e-01f, 1.36157319e-01f,
  -4.87722792e-02f, -8.72026235e-02f, -4.12287340e-02f, 2.13905666e-02f, -9.15149003e-02f, 2.02245265e-02f, 3.20327729e-02f, -4.22678739e-02f, 2.11559664e-02f, -9.57824141e-02f,
  -4.07820977e-02f, -4.02262732e-02f, 4.87517007e-02f, 3.68263647e-02f, 1.71683691e-02f, -3.19433920e-02f, -9.98801589e-02f, -9.42232646e-03f, 3.20160724e-02f, -3.14750858e-02f,
  -2.15444546e-02f, -7.90052414e-02f, 5.04676588e-02f, 6.31480739e-02f, 5.52651333e-03f, -5.48403412e-02f, 3.43423970e-02f, -9.31597650e-02f, 7.74658052e-03f, -1.14781365e-01f,
  1.04086809e-01f, -3.80468965e-02f, -7.03456923e-02f, -2.22415216e-02f, -6.39847666e-02f, 1.33268367e-02f, 6.28758296e-02f, 3.47784497e-02f, -8.49172249e-02f, -4.67927530e-02f,
  -1.03211768e-01f, -2.83856820e-02f, -4.59214412e-02f, -1.52984681e-02f, -4.50709835e-02f, -4.08804938e-02f, 2.30136625e-02f, -4.60171700e-02f, -3.27279791e-02f, 3.49938944e-02f,
  5.17728440e-02f, -3.43552344e-02f, 5.50232306e-02f, 5.21397777e-03f, -1.26008861e-04f, 8.90888944e-02f, 6.25317916e-02f, 1.16665579e-01f, -2.16315910e-02f, 1.10705264e-01f,
  1.61203310e-01f, -1.30478278e-01f, -2.93205768e-01f, -1.46130547e-01f, -5.83978035e-02f, 7.33637076e-04f, -7.21175820e-02f, 1.05184503e-01f, -5.36483265e-02f, -1.51236892e-01f,
  -1.00597348e-02f, 1.78043798e-01f, 3.30826528e-02f, 5.58770001e-02f, 1.64627001e-01f, -1.00399651e-01f, -1.48474872e-01f, 3.05736084e-02f, 7.92633072e-02f, 5.86283021e-02f,
  3.32201160e-02f, -6.31290227e-02f, 6.99113170e-03f, 1.11836337e-01f, -9.06800106e-02f, 1.67068783e-02f, -1.58890530e-01f, -6.87403902e-02f, -7.11846072e-03f, -2.54511178e-01f,
  -1.25700429e-01f, 9.72454026e-02f, 7.77723864e-02f, 5.66933192e-02f, -1.04760587e-01f, 2.87016723e-02f, -9.02658608e-03f, 4.93929535e-03f, 1.34842731e-02f, -4.91249599e-02f,
  1.16032399e-01f, 6.12929426e-02f, -7.11142644e-02f, 3.82814719e-03f, -5.86162917e-02f, 5.63162100e-03f, -1.09327734e-01f, -7.10857138e-02f, -4.27019931e-02f, 5.91765121e-02f,
  -3.00395060e-02f, -3.39632258e-02f, -1.01732656e-01f, -2.47507188e-02f, 9.92995780e-03f, 5.84745221e-02f, -1.08913034e-02f, 2.59890202e-02f, 4.61113229e-02f, -8.22184086e-02f,
  -7.14639714e-03f, -3.50147411e-02f, 5.59651181e-02f, 1.70959663e-02f, -6.18499629e-02f, -1.39926327e-02f, 2.83043645e-02f, 3.96746770e-02f, 1.15625551e-02f, -9.91847739e-02f,
  5.55026159e-02f, 4.32834774e-02f, 5.86825982e-02f, 2.99807508e-02f, 5.50696105e-02f, -4.67861630e-02f, 3.81231159e-02f, 5.03347628e-02f, 3.80495638e-02f, 2.33356841e-02f,
  -4.28642100e-03f, 3.37255411e-02f, -3.07568070e-02f, 5.66935651e-02f, -1.25511326e-02f, -5.49091734e-02f, -3.19893174e-02f, -1.03060566e-01f, -5.39014786e-02f, 5.23314662e-02f,
  -4.32832129e-02f, 1.22608617e-01f, -2.03297604e-02f, 4.24022414e-03f, 1.60367470e-02f, 4.81104515e-02f, -5.48748970e-02f, -2.40938887e-02f, -1.85126085e-02f, -7.81440064e-02f,
  -3.04824058e-02f, -9.29843727e-03f, -2.02632556e-03f, 3.31465416e-02f, 7.04137459e-02f, 6.86146393e-02f, -1.03867665e-01f, 9.27537233e-02f, 9.53857228e-02f, 6.29863143e-02f,
  6.59584478e-02f, -9.51245576e-02f, -2.70633921e-02f, 3.05192061e-02f, 7.22936243e-02f, 3.21409926e-02f, -4.48463112e-02f, -2.05980483e-02f, 9.50593203e-02f, -1.38370812e-01f,
  -1.43692091e-01f, -5.84558526e-04f, -4.13187034e-02f, 6.05445132e-02f, 1.99990738e-02f, 4.81385887e-02f, -4.39072438e-02f, -2.10856157e-03f, 2.45882608e-02f, 8.61934498e-02f,
  -8.62873532e-03f, 1.24958940e-01f, -6.57531172e-02f, 5.44097610e-02f, 6.13047741e-02f, 5.34074530e-02f, -2.88418029e-02f, 1.52337570e-02f, -8.88634920e-02f, 7.07249045e-02f,
  1.13407686e-01f, 8.53877887e-02f, -1.18399940e-01f, -5.87710626e-02f, -4.58932295e-03f, -2.24134400e-02f, 7.42628351e-02f, -5.51792383e-02f, -6.80182129e-02f, 6.06700443e-02f,
  -4.65504127e-03f, 6.36125624e-04f, -9.03719291e-02f, 6.66280016e-02f, -1.87557787e-02f, -5.41541539e-02f, 1.26244854e-02f, -3.40688787e-02f, -3.37683745e-02f, 4.60917279e-02f,
  3.68357487e-02f, -9.66813341e-02f, 1.88698806e-02f, -3.81407514e-02f, -3.81448818e-03f, -5.88809624e-02f, 1.92394760e-02f, -1.27247721e-01f, 4.01278194e-05f, -9.52824354e-02f,
  3.26305665e-02f, 9.18119177e-02f, 9.83656198e-03f, 6.73005655e-02f, -2.17443407e-02f, 1.42171597e-02f, -5.91222346e-02f, -1.01931162e-01f, -1.25315383e-01f, -9.53889936e-02f,
  -3.35051566e-02f, -5.96698262e-02f, -5.01504503e-02f, 1.00866342e-02f, -6.70134127e-02f, 7.46912286e-02f, -6.73238263e-02f, 6.13920987e-02f, -5.44469878e-02f, -1.60116795e-02f,
  1.65187642e-02f, -9.59953219e-02f, 5.06795186e-04f, 8.74752998e-02f, 1.26368150e-01f, -2.96751950e-02f, 4.18935493e-02f, -4.18140627e-02f, 8.37920830e-02f, -2.55218614e-02f,
  7.88705423e-02f, -3.17924321e-02f, 8.04146752e-02f, 9.09245834e-02f, 3.40628214e-02f, 2.67274561e-03f, 1.54124163e-02f, -4.42038197e-03f, 8.39795023e-02f, -2.17656195e-02f,
  -9.80624650e-03f, 6.42141104e-02f, -9.21816081e-02f, -1.67305861e-02f, 7.29617700e-02f, -6.61670640e-02f, 2.38737911e-02f, 7.58859515e-02f, 7.10308850e-02f, 1.21576404e-02f,
  -5.73245957e-02f, -1.71215017e-03f, 2.96838023e-02f, 3.74929979e-02f, 6.99434103e-03f, -4.41931048e-03f, -2.43418161e-02f, -5.82078025e-02f, 4.02231477e-02f, -5.09881638e-02f,
  7.09304470e-04f, -2.26369151e-03f, 6.38665725e-03f, 2.49616876e-02f, -7.28177354e-02f, 2.71691289e-02f, 3.90371457e-02f, -2.04886235e-02f, -1.29584461e-01f, -2.75942311e-03f,
  4.29644585e-01f, 1.89300943e-02f, 7.37512559e-02f, 1.58526927e-01f, 9.80926529e-02f, 7.61159807e-02f, 1.42237261e-01f, 6.62161559e-02f, 2.60415990e-02f, 5.60483448e-02f,
  1.32604212e-01f, -2.92303823e-02f, -5.29256724e-02f, -5.70583642e-02f, 1.35578495e-02f, -4.33509909e-02f, -1.50668502e-01f, -8.95425826e-02f, 8.27123523e-02f, 8.32113847e-02f,
  2.02438608e-02f, 5.66894673e-02f, -4.28597722e-03f, -2.48839818e-02f, -1.82415605e-01f, 5.97660914e-02f, 2.30987873e-02f, -1.23978741e-01f, 4.00367118e-02f, -2.04219744e-01f,
  -2.34879404e-02f, 1.21161431e-01f, 5.50336018e-02f, 3.41372043e-02f, 9.10876170e-02f, 5.90767860e-02f, -4.36477698e-02f, -3.64918858e-02f, -5.28145321e-02f, -1.22810014e-01f,
  -6.57254606e-02f, -6.82302788e-02f, 1.00062311e-01f, -6.46832511e-02f, -7.82695785e-03f, -8.52238908e-02f, 1.56847779e-02f, 8.24323669e-02f, 1.47595271e-01f, 8.77528936e-02f,
  -2.33706441e-02f, 1.06146351e-01f, 1.25190616e-01f, 1.22485861e-01f, 9.78665948e-02f, 1.06810078e-01f, 3.03714089e-02f, 9.45781544e-02f, 1.20588327e-02f, 3.68284769e-02f,
  -6.36313558e-02f, 5.13837598e-02f, 6.72124550e-02f, 7.90689960e-02f, 8.45338404e-02f, -4.97329235e-02f, 2.09650956e-02f, 6.26188889e-02f, -7.08108954e-03f, 2.19969302e-02f,
  2.72335280e-02f, 5.43288440e-02f, -5.06324731e-02f, 7.10211545e-02f, -4.12104875e-02f, 2.81703062e-02f, 6.68234844e-03f, -5.31906709e-02f, -6.94060102e-02f, 5.45403287e-02f,
  2.41527651e-02f, 9.57311913e-02f, -1.40985586e-02f, -1.07260495e-01f, 1.20660685e-01f, -7.04923198e-02f, -9.26713422e-02f, -1.94076987e-04f, -4.25639115e-02f, -3.84540390e-03f,
  -1.40432626e-01f, 2.38580525e-01f, -3.66521366e-02f, 3.03009450e-02f, -1.07824188e-02f, -9.56419855e-02f, -1.59118623e-02f, -1.24989718e-01f, -5.48223369e-02f, -9.19577554e-02f,
  4.02852222e-02f, 9.27554164e-03f, 5.80946952e-02f, -6.07037246e-02f, -3.70448828e-02f, -6.47977600e-03f, -5.27108088e-02f, 6.21714117e-03f, -1.44808255e-02f, 6.36201054e-02f,
  -4.89587560e-02f, -5.22901900e-02f, 3.64685506e-02f, -3.96401286e-02f, 7.09442496e-02f, 1.62423268e-01f, 1.85193978e-02f, 4.63383384e-02f, 1.06118187e-01f, -5.77043109e-02f,
  9.17145908e-02f, 1.10616818e-01f, -5.84989153e-02f, 7.33357668e-02f, -1.52375596e-02f, -7.00013936e-02f, 4.96968068e-03f, 8.50372389e-02f, -5.26498444e-02f, -2.56420095e-02f,
  -7.44832754e-02f, -5.22732474e-02f, 1.01895928e-02f, -5.14277704e-02f, 9.29021016e-02f, 2.14721709e-02f, 4.31646071e-02f, -9.19330586e-03f, 1.49186486e-02f, 4.61147772e-03f,
  1.47056784e-02f, 3.91361937e-02f, -3.96022275e-02f, 2.66077686e-02f, 6.06611893e-02f, 3.70271951e-02f, -1.00118835e-02f, 1.09269945e-02f, -1.86938830e-02f, -2.37304699e-02f,
  -4.71922606e-02f, 4.44295332e-02f, -1.05967768e-01f, 4.23576310e-02f, -5.75820915e-02f, -1.70050096e-02f, 2.79921014e-02f, 8.60973727e-03f, 3.65500487e-02f, 8.07967186e-02f,
  -7.16756806e-02f, -5.84662221e-02f, 5.75077347e-02f, -5.44881634e-02f, -1.17662391e-02f, 7.70750940e-02f, 2.16986276e-02f, 4.98356344e-03f, 1.64166391e-02f, 6.19521784e-03f,
  6.13337616e-03f, 4.85269316e-02f, -4.24578029e-04f, 8.83520171e-02f, -2.70481035e-02f, 4.69507687e-02f, 8.06502700e-02f, -1.38314022e-02f, 6.08708449e-02f, 2.09964197e-02f,
  -4.07561958e-02f, -2.53169313e-02f, -1.62079986e-02f, -8.58588740e-02f, -9.43825543e-02f, 1.21066971e-02f, -5.30096032e-02f, -2.92805508e-02f, 8.14164579e-02f, -3.30519937e-02f,
  2.41785753e-03f, -2.07996592e-02f, -5.90562895e-02f, -8.26147720e-02f, -7.05482066e-02f, -1.00916903e-02f, 5.58949709e-02f, -3.74142975e-02f, 6.11543842e-02f, 7.21331015e-02f,
  2.84136329e-02f, 7.23390952e-02f, 3.66186611e-02f, 4.15782444e-02f, -1.01971091e-03f, -1.26017851e-03f, -1.50295990e-02f, -4.23375666e-02f, 5.87963033e-03f, 1.85900014e-02f,
  3.21609117e-02f, -3.86482873e-03f, -6.15206212e-02f, -4.82902192e-02f, 7.19991773e-02f, -7.34565109e-02f, -7.19927996e-02f, -8.31875578e-02f, -5.43507971e-02f, -6.35878146e-02f,
  -3.07992147e-03f, -3.89454812e-02f, 9.44068562e-03f, 6.93477914e-02f, 4.49011959e-02f, -8.28125572e-04f, -8.67042691e-02f, -6.23566061e-02f, 3.51576810e-03f, 4.44785394e-02f,
  -4.70821299e-02f, -2.65657976e-02f, -7.87648037e-02f, -1.13900825e-01f, -1.71430986e-02f, -1.20877899e-01f, 1.13757188e-02f, -1.77331157e-02f, -5.26682697e-02f, -1.17191382e-01f,
  -9.25922245e-02f, -4.03620442e-03f, -4.97009419e-02f, 4.97232787e-02f, 4.41495851e-02f, -5.93716092e-02f, 1.23771388e-04f, 8.26965347e-02f, 6.23876862e-02f, 1.00500956e-01f,
  -1.95765961e-02f, -2.57046754e-03f, 7.45578632e-02f, 4.02681977e-02f, -1.22275330e-01f, -2.04901565e-02f, -7.21635073e-02f, -5.79674132e-02f, -8.89798626e-02f, 2.72286823e-03f,
  -8.23138840e-03f, -1.11958571e-01f, -1.00742048e-02f, -1.00052737e-01f, 1.50253698e-02f, 1.87390260e-02f, 7.45087489e-02f, 8.63461103e-03f, -2.94975080e-02f, 4.87013832e-02f,
  -5.59465773e-02f, -9.10914615e-02f, 3.00554652e-02f, 7.94906635e-03f, -6.87104240e-02f, -3.37402825e-03f, 6.21329360e-02f, -1.23621568e-01f, 1.68746319e-02f, 1.89277604e-02f,
  3.91668417e-02f, -5.18032946e-02f, 4.79272008e-02f, 8.30575973e-02f, -8.11860189e-02f, -7.84722194e-02f, -1.18073441e-01f, -1.34297296e-01f, -1.24189667e-01f, 6.44859334e-04f,
  -5.78684174e-02f, -9.82963294e-02f, -6.13357574e-02f, 1.33073945e-02f, 2.60181334e-02f, -9.15531442e-03f, -3.36187668e-02f, 9.44559127e-02f, -3.02218385e-02f, 1.66745856e-02f,
  5.54078557e-02f, -5.45351878e-02f, -8.25759172e-02f, -5.42693660e-02f, 6.32620156e-02f, 6.05900101e-02f, -2.05090400e-02f, -1.44826574e-02f, 8.99372995e-02f, 7.79970596e-03f,
  8.38345885e-02f, 5.68690486e-02f, 4.30525020e-02f, 6.04601093e-02f, -4.50221114e-02f, 6.61093295e-02f, -8.74090008e-03f, -3.88734043e-02f, 4.34508035e-03f, 7.21975043e-02f,
  -1.02904253e-02f, 7.57066831e-02f, 6.06231950e-02f, 1.72658674e-02f, -6.65519238e-02f, -1.86315980e-02f, 8.76073986e-02f, 5.11580594e-02f, -6.57764599e-02f, -9.00749862e-02f,
  5.87768853e-02f, 5.81110008e-02f, -9.11587267e-04f, -4.85406369e-02f, -2.89910231e-02f, 6.19478002e-02f, 7.91430473e-02f, -9.86071676e-02f, 1.80657730e-02f, 6.22315239e-03f,
  4.58694855e-03f, -2.69093364e-02f, -1.04408211e-03f, -3.31313200e-02f, -1.66362580e-02f, -5.58427721e-02f, 3.29827555e-02f, -1.24957718e-01f, -2.00981423e-02f, -3.16279829e-02f,
  -6.56386837e-02f, 3.45464535e-02f, 2.78830044e-02f, 1.44430259e-02f, -5.33494502e-02f, -2.16707750e-03f, 1.82179771e-02f, -4.64055799e-02f, 1.07200118e-02f, -1.10048100e-01f,
  2.86093876e-02f, -1.76080137e-01f, -2.32867837e-01f, -1.53999358e-01f, -1.85179487e-01f, -1.39107287e-01f, -1.02087207e-01f, 9.06283222e-03f, -5.91708021e-03f, -7.11768195e-02f,
  -7.19350651e-02f, -1.87922046e-02f, -4.70858961e-02f, -4.57154475e-02f, 3.00277825e-02f, -1.70605555e-01f, -2.20112383e-01f, -1.68331996e-01f, -6.00531399e-02f, 1.32770278e-02f,
  5.34621961e-02f, -9.94315669e-02f, -4.54127006e-02f, 3.35061066e-02f, -7.73158446e-02f, 2.10417341e-03f, -6.17351457e-02f, -4.89704609e-02f, 1.81340612e-02f, -1.53459594e-01f,
  -2.63298988e-01f, 1.20250173e-01f, 9.51235816e-02f, 1.46252066e-02f, -3.60255502e-02f, -1.82561781e-02f, -4.59328368e-02f, -4.27475981e-02f, 9.96748880e-02f, 2.31141876e-02f,
  4.81855012e-02f, 6.24436028e-02f, -2.72911806e-02f, 7.11928606e-02f, -2.70557441e-02f, -5.97452372e-02f, 1.44850492e-01f, -6.27302080e-02f, 2.48693004e-02f, 1.85245310e-03f,
  3.69339846e-02f, 1.07723102e-02f, 8.58061090e-02f, 1.14210002e-01f, 2.69345436e-02f, 9.73122641e-02f, 6.85372576e-02f, 5.45041226e-02f, 1.03245318e-01f, -5.40333875e-02f,
  -4.93675694e-02f, -4.61729504e-02f, -6.28834516e-02f, 9.30641368e-02f, 7.43839666e-02f, 1.42449737e-02f, 5.46377674e-02f, -4.12852243e-02f, 2.94072106e-02f, -7.28319585e-02f,
  -9.96124446e-02f, -8.32030699e-02f, -2.59564742e-02f, -9.61598456e-02f, -6.70116097e-02f, 1.92276631e-02f, -1.02048246e-02f, -5.03483638e-02f, 3.23752537e-02f, 7.21926466e-02f,
  -5.07105663e-02f, 6.87465072e-02f, -4.06962782e-02f, 8.00871179e-02f, 4.99088392e-02f, 3.07455398e-02f, -8.27449281e-03f, 2.51943674e-02f, -2.60589253e-02f, -3.48285735e-02f,
  -3.76121290e-02f, -6.63981885e-02f, -6.76731467e-02f, 5.57784624e-02f, 2.90018506e-02f, 2.57686432e-02f, -5.73279411e-02f, 5.42543642e-02f, 5.05925715e-02f, 3.45477648e-02f,
  8.93956795e-02f, -3.89104448e-02f, -1.02082908e-01f, 2.86624599e-02f, -1.08190536e-01f, -2.83095781e-02f, 1.25882089e-01f, 1.37177641e-02f, 8.23304206e-02f, -1.06931351e-01f,
  -9.25835744e-02f, 4.21656594e-02f, 7.76807964e-02f, -1.44632999e-02f, 6.84622079e-02f, -8.59855562e-02f, -2.03661788e-02f, 1.15010478e-02f, 9.12028998e-02f, -4.17397507e-02f,
  -1.13149248e-02f, -5.90441748e-02f, -2.35890616e-02f, 8.64566788e-02f, -5.27039394e-02f, 5.85217588e-02f, -9.04832780e-02f, -1.52119230e-02f, 8.55168626e-02f, 7.10580200e-02f,
  8.85993168e-02f, 3.23838629e-02f, 9.94079374e-03f, -9.40898508e-02f, -7.85711557e-02f, -8.28159377e-02f, -2.53540017e-02f, 3.63981351e-02f, 5.69138862e-02f, -6.43059611e-02f,
  4.93216701e-02f, -6.00217991e-02f, 2.99055055e-02f, -6.27049478e-03f, 8.30724761e-02f, 3.81102450e-02f, 7.30174407e-02f, -6.64552674e-02f, -5.42859659e-02f, 9.26354155e-02f,
  3.71212251e-02f, 4.25699539e-03f, -2.01863404e-02f, -6.44884482e-02f, -4.43219133e-02f, 3.53810117e-02f, 1.88098643e-02f, 8.22889283e-02f, 7.68907890e-02f, 1.24784019e-02f,
  5.19492663e-02f, -1.55947311e-02f, -7.99375176e-02f, 4.02161554e-02f, 5.65635413e-03f, 2.71500386e-02f, -6.08830191e-02f, 6.49995282e-02f, 3.06233056e-02f, -8.82321969e-03f,
  5.48040085e-02f, -1.95943601e-02f, 5.92894219e-02f, -2.35871393e-02f, -9.82046574e-02f, -7.31007522e-03f, -8.07590336e-02f, 6.28238097e-02f, -1.09863833e-01f, 4.17876504e-02f,
  -9.28183049e-02f, 3.62366214e-02f, -4.70751151e-03f, -7.00963065e-02f, -9.70593393e-02f, 3.09082121e-02f, 3.06483470e-02f, -4.15752418e-02f, -4.18443270e-02f, -5.63401692e-02f,
  7.47280493e-02f, 1.54571328e-02f, -7.04296455e-02f, 1.33881699e-02f, 3.76481302e-02f, 5.04488917e-03f, -5.53345941e-02f, 6.17901199e-02f, 1.42913748e-04f, -3.15396264e-02f,
  3.90526354e-02f, 2.79303025e-02f, -4.05794941e-02f, 4.69264649e-02f, -4.79439236e-02f, -1.19981088e-01f, -4.59091999e-02f, -5.59526011e-02f, -1.61448885e-02f, -7.69293085e-02f,
  -8.19263756e-02f, -1.04342125e-01f, 1.31173655e-02f, -1.02430219e-02f, 2.46347394e-02f, 4.99793841e-03f, -5.37150726e-02f, -2.99659222e-02f, 5.08853570e-02f, -7.44819269e-02f,
  -9.67600197e-02f, -7.55053312e-02f, 6.35999590e-02f, -1.38484845e-02f, -2.71746051e-02f, -5.70403747e-02f, 4.96927463e-02f, 4.04886715e-02f, -6.39058650e-02f, -2.78498810e-02f,
  4.63703014e-02f, -7.08288774e-02f, 6.84168786e-02f, 3.96144055e-02f, 3.74618284e-02f, -1.02816567e-01f, 2.23197434e-02f, 2.97276583e-02f, -6.69100657e-02f, -6.19130060e-02f,
  -6.99973200e-03f, 6.90929824e-03f, -2.00013909e-03f, 5.50057786e-03f, -6.76238015e-02f, -1.08635135e-01f, -3.41587067e-02f, -2.71904692e-02f, -3.74296010e-02f, -2.45390832e-02f,
  6.24697767e-02f, -3.88135575e-03f, -1.78057719e-02f, -4.95022237e-02f, -1.12253904e-01f, -5.07972278e-02f, -5.96102215e-02f, 2.81452332e-02f, -3.83612737e-02f, -7.99087435e-02f,
  -6.06198162e-02f, 7.79146925e-02f, -4.56921607e-02f, -4.76571545e-03f, 1.13620430e-01f, 3.76446173e-02f, -2.20186953e-02f, 3.03621148e-03f, -6.97911158e-02f, 5.91687970e-02f,
  7.55962059e-02f, 5.42666242e-02f, -7.03126863e-02f, -7.78041035e-02f, -6.22428134e-02f, -1.14081793e-01f, -3.38128805e-02f, -5.53505681e-02f, -6.75812736e-02f, -3.05898152e-02f,
  -6.05806559e-02f, 7.10954424e-03f, 1.51148736e-02f, -2.13980116e-02f, -7.97505863e-03f, -8.64223763e-02f, 6.74910983e-03f, -2.23089140e-02f, -6.12141490e-02f, -9.95377675e-02f,
  -1.72585528e-02f, 2.32746843e-02f, 3.29588428e-02f, -8.64934996e-02f, -1.12745069e-01f, 5.24087548e-02f, -5.92058189e-02f, -2.54746713e-02f, 5.93039207e-02f, 7.94759765e-02f,
  -1.16871789e-01f, -9.59264264e-02f, 3.42635787e-03f, 2.98245419e-02f, 6.13073893e-02f, -4.48716320e-02f, -5.67942299e-02f, -5.72320409e-02f, 3.73845547e-02f, -5.20349406e-02f,
  -7.79219940e-02f, -6.53535649e-02f, -3.47372442e-02f, 3.42982784e-02f, -2.30684225e-02f, -1.20740626e-02f, -3.22465301e-02f, -6.28779233e-02f, -4.60369326e-02f, -4.29084860e-02f,
  -4.90697883e-02f, 7.20249787e-02f, -3.74475829e-02f, -8.85744020e-02f, 6.35358915e-02f, 7.36133084e-02f, -1.26095433e-02f, 2.50250734e-02f, -3.62883285e-02f, 2.25582253e-02f,
  1.42105296e-01f, -3.79806794e-02f, 3.03221401e-02f, 8.90756696e-02f, -8.69257972e-02f, -4.84246761e-02f, 1.26124290e-03f, -3.81488129e-02f, 6.04871847e-02f, 3.37941316e-03f,
  4.96794321e-02f, -5.57757728e-02f, 7.05730170e-02f, 9.65894237e-02f, -5.38829900e-02f, 5.08072637e-02f, -1.45221159e-01f, -3.50308022e-04f, -6.04640041e-03f, -6.78358898e-02f,
  -1.03400871e-01f, -9.31985825e-02f, -6.56150058e-02f, -3.84609327e-02f, 6.63622245e-02f, 3.64905559e-02f, 4.19859253e-02f, 6.09322563e-02f, -3.06886658e-02f, 6.58652782e-02f,
  3.22555512e-01f, -3.20361912e-01f, 6.02453090e-02f, -3.85827050e-02f, -1.51953548e-02f, -3.63606773e-02f, 6.12338223e-02f, -8.15377757e-02f, -1.15751915e-01f, -6.00365596e-03f,
  -6.04159087e-02f, -9.27434936e-02f, -2.82315351e-02f, -1.40106417e-02f, 2.96052229e-02f, -2.11908631e-02f, 8.86158869e-02f, 1.31008059e-01f, 1.42511144e-01f, 3.39668952e-02f,
  -1.80302575e-01f, -1.06469505e-02f, 4.67278287e-02f, -2.72831526e-02f, -7.73982033e-02f, -6.61531389e-02f, -1.00961559e-01f, 7.10865157e-03f, -1.26932040e-01f, -1.50006309e-01f,
  -6.17503561e-02f, -1.18193269e-01f, 9.77970008e-03f, 3.53336670e-02f, -7.23056942e-02f, -2.18303185e-02f, 4.09767367e-02f, 3.07488088e-02f, 1.04650445e-02f, -9.72811505e-02f,
  -1.29796013e-01f, 1.78076364e-02f, -9.78736132e-02f, 2.86239386e-02f, -6.59673139e-02f, -2.33848859e-02f, -4.89640646e-02f, -6.94328025e-02f, 2.30332445e-02f, -1.10280640e-01f,
  -6.39940500e-02f, 3.23843881e-02f, 6.08008504e-02f, -1.12605363e-01f, -1.10496387e-01f, 5.47958240e-02f, -1.80983409e-01f, -6.08187057e-02f, 6.10073172e-02f, -1.37558922e-01f,
  4.20628004e-02f, -2.59982161e-02f, 6.32115267e-03f, -3.08878720e-02f, -1.73671078e-03f, -1.63339339e-02f, 7.19103664e-02f, -4.12082560e-02f, -5.68769388e-02f, 5.96118532e-02f,
  -7.98079185e-03f, -2.57760268e-02f, 7.08537400e-02f, -1.76847894e-02f, 4.46358323e-03f, -6.71463385e-02f, 2.69371644e-03f, -1.28225178e-01f, -5.62426858e-02f, 7.93843418e-02f,
  6.58104047e-02f, 3.07131726e-02f, -2.73275729e-02f, -1.20015061e-02f, 6.44915104e-02f, 3.11052683e-03f, -2.48842463e-02f, 6.48447275e-02f, -4.41100970e-02f, -1.98123865e-02f,
  -5.21619394e-02f, -2.99511272e-02f, -3.84854665e-03f, 6.75477460e-02f, -4.31123452e-04f, -2.26052813e-02f, -1.64956544e-02f, -2.38904115e-02f, -3.46925482e-02f, 4.91125435e-02f,
  -2.31305920e-02f, -3.10171433e-02f, -2.70393100e-02f, -1.71046834e-02f, 3.59095708e-02f, 6.39601797e-02f, 6.87041646e-03f, -2.16515772e-02f, 1.53784407e-02f, 5.75680025e-02f,
  -1.03296384e-01f, 1.20881870e-01f, 9.70974341e-02f, 7.20827505e-02f, -5.82162701e-02f, 2.58490145e-02f, -9.51944068e-02f, 5.81803136e-02f, 1.17508084e-01f, 7.88415316e-03f,
  -4.06094417e-02f, -1.68996118e-02f, -4.94210683e-02f, 1.66247655e-02f, 1.03224143e-02f, 2.26845555e-02f, -8.61626044e-02f, 7.42454454e-02f, -2.15118900e-02f, -5.43845221e-02f,
  -4.33146246e-02f, 2.32318789e-03f, -7.59369284e-02f, -4.05763462e-02f, -6.47118166e-02f, 3.90674770e-02f, -2.14942973e-02f, 3.49245742e-02f, 6.16417788e-02f, -9.33830366e-02f,
  -7.41796196e-02f, -1.63426436e-02f, -3.28780748e-02f, -5.45941805e-03f, -2.99725286e-03f, 1.99131994e-03f, 4.49151956e-02f, -4.31352779e-02f, -1.32750627e-02f, 4.95779775e-02f,
  9.32637975e-02f, -8.50410983e-02f, 6.01327121e-02f, -1.21362537e-01f, -7.12056533e-02f, 3.89258489e-02f, 2.51361728e-02f, 2.05746181e-02f, -4.47478816e-02f, 1.80393422e-03f,
  4.33778018e-03f, -6.18157871e-02f, -4.17051949e-02f, -6.22224063e-02f, -7.75380060e-02f, -5.03165051e-02f, -8.62007141e-02f, 2.21433453e-02f, 3.93204913e-02f, 6.32765070e-02f,
  -9.58644785e-04f, -1.16984889e-01f, 4.50724065e-02f, 6.60364628e-02f, -7.43644908e-02f, 6.42718673e-02f, -3.86721604e-02f, 2.21385472e-02f, -2.18714438e-02f, 7.36683980e-02f,
  -5.04395328e-02f, 5.04729263e-02f, 1.95218865e-02f, -5.98510280e-02f, 1.97631735e-02f, -6.65322132e-03f, 3.68267372e-02f, -5.76978847e-02f, -4.41005118e-02f, 5.51470146e-02f,
  5.67079000e-02f, 4.96994518e-02f, 1.08484663e-01f, 7.39127100e-02f, -4.97984327e-02f, 2.72483192e-02f, 3.48874591e-02f, -1.72729008e-02f, -1.37540838e-02f, -2.23318767e-02f,
  5.22724725e-02f, -4.97470945e-02f, 8.77415687e-02f, -4.77139056e-02f, -9.11623612e-02f, -3.48289870e-02f, -1.57445762e-02f, -2.16297945e-03f, -4.24839742e-02f, -8.38583894e-03f,
  1.76547654e-02f, -1.09939501e-01f, 1.51250763e-02f, -3.60424891e-02f, 7.67251058e-03f, -3.74573357e-02f, 3.69639546e-02f, -9.66473762e-03f, 5.08786440e-02f, -7.40221813e-02f,
  -5.29670678e-02f, 9.15030986e-02f, -1.38148805e-02f, -1.58326968e-03f, -1.93433315e-02f, -5.87073267e-02f, -7.95356408e-02f, 8.35742336e-03f, 4.27329540e-02f, -7.63972178e-02f,
  4.82792519e-02f, -7.33803809e-02f, 8.10016096e-02f, 3.19477990e-02f, 8.11234936e-02f, 4.69639786e-02f, 6.11437857e-02f, -6.00170866e-02f, 5.25330529e-02f, -3.75618376e-02f,
  -9.60524976e-02f, -1.37186879e-02f, 4.23256829e-02f, 3.13394666e-02f, -7.74033666e-02f, 4.63861264e-02f, -6.50871471e-02f, 4.64247391e-02f, -8.82346481e-02f, -3.37954089e-02f,
  1.68204159e-02f, 3.97714451e-02f, -4.95601296e-02f, 4.77043651e-02f, -6.62861243e-02f, 5.66984303e-02f, 2.69750375e-02f, -1.01598492e-02f, -2.60570478e-02f, -5.93312569e-02f,
  1.71604822e-03f, -1.18769482e-01f, 9.43421503e-04f, -7.04082847e-02f, -1.19313508e-01f, -1.03421032e-03f, -2.52474435e-02f, -6.40242100e-02f, -9.51763168e-02f, -8.60159472e-02f,
  -1.00220360e-01f, 3.47768888e-02f, 5.69396466e-02f, 1.01923816e-01f, -6.54025599e-02f, -5.15821464e-02f, 1.12662455e-02f, 7.57649988e-02f, 2.70327944e-02f, -3.64237241e-02f,
  7.01848567e-02f, -1.97062325e-02f, 4.79110889e-02f, -4.39840415e-03f, 2.29936391e-02f, 9.14073922e-03f, 1.36230690e-02f, -4.02586721e-02f, 2.55731735e-02f, -2.44077947e-02f,
  4.64479625e-02f, 9.62262601e-02f, 7.56161436e-02f, 1.82459094e-02f, -4.32832539e-02f, -7.33928308e-02f, 7.41491914e-02f, -2.02069264e-02f, 6.25384748e-02f, 8.73381644e-02f,
  -7.51690269e-02f, -7.52764121e-02f, 5.28942235e-02f, 1.59584973e-02f, -3.04015959e-03f, 2.41554412e-03f, 1.29757533e-02f, -5.33856750e-02f, 6.48760349e-02f, -4.44904119e-02f,
  5.55029474e-02f, -2.30460940e-03f, 9.02988762e-02f, -4.50458191e-02f, 9.32220593e-02f, 2.30161436e-02f, -4.17702422e-02f, 7.34573603e-02f, -5.18205017e-02f, -2.84700487e-02f,
  5.37501201e-02f, 5.51003404e-03f, 1.09150195e-02f, 5.13862073e-02f, 5.16712926e-02f, -2.10852474e-02f, -7.54204616e-02f, -9.61414874e-02f, -2.12849993e-02f, -3.36535126e-02f,
  -8.53293911e-02f, 3.60045978e-03f, -5.55221923e-02f, -8.01328123e-02f, -3.53543982e-02f, 2.22946387e-02f, 6.17347732e-02f, 3.27940881e-02f, 3.80473025e-02f, -8.66115466e-02f,
  -6.87317327e-02f, -5.35795726e-02f, 6.60674125e-02f, -6.03123344e-02f, 4.59357369e-04f, -5.31791300e-02f, 4.28068228e-02f, -3.06652971e-02f, -5.19500896e-02f, -1.69021860e-02f,
  -3.00378967e-02f, 6.54117092e-02f, -6.55153021e-02f, 6.00035898e-02f, -3.73324589e-03f, 3.10435221e-02f, -4.83235829e-02f, -6.51098788e-02f, 7.50200599e-02f, 3.36210653e-02f,
  7.11553905e-04f, -4.15192805e-02f, -1.93009768e-02f, -1.08412635e-02f, -2.30152588e-02f, -7.57683739e-02f, 6.00525215e-02f, 5.65083474e-02f, -7.10100830e-02f, -6.66129217e-02f,
  5.71485758e-02f, -4.31970395e-02f, 2.17841007e-02f, 8.02204832e-02f, 8.74367803e-02f, -7.47589245e-02f, -9.86444578e-02f, -9.52241942e-02f, -6.42387569e-02f, 2.87575182e-02f,
  -3.67743485e-02f, -7.21333697e-02f, 8.68410394e-02f, -6.80966750e-02f, 2.80002244e-02f, -2.32736878e-02f, 2.73263901e-02f, 5.82674658e-03f, -5.24077788e-02f, -7.44958594e-02f,
  2.60736644e-02f, 1.03920817e-01f, -1.79073587e-02f, 1.21466622e-01f, 8.19094852e-02f, 2.28073653e-02f, 7.33452737e-02f, -4.45412621e-02f, -2.99402722e-03f, -8.37085173e-02f,
  -4.37342236e-03f, -1.12520326e-02f, -3.46026756e-02f, -8.31885934e-02f, -9.02687833e-02f, -7.30996206e-02f, -4.48210463e-02f, 5.13779856e-02f, 4.80546989e-02f, -4.19110358e-02f,
  -6.39747232e-02f, -6.38956204e-02f, -9.00403224e-03f, 1.70187429e-02f, 2.38089468e-02f, 7.26356283e-02f, 3.70068513e-02f, -4.99160886e-02f, -4.78528021e-03f, -3.58954668e-02f,
  -6.94142208e-02f, -1.60316899e-02f, -5.85734956e-02f, -4.12540771e-02f, -1.17252895e-03f, 8.66589718e-04f, -1.22592608e-02f, 7.30508519e-03f, 3.56792361e-02f, -1.82225592e-02f,
  -1.25262085e-02f, -4.36829068e-02f, 1.14606284e-02f, 2.04251558e-02f, 1.09379860e-02f, 1.33169582e-02f, 3.41104269e-02f, 3.10448073e-02f, -2.68155858e-02f, 4.26167473e-02f,
  -8.91423225e-02f, -2.13288628e-02f, 5.68415821e-02f, -2.74753533e-02f, -2.13595829e-03f, 6.27862066e-02f, -2.68192813e-02f, 2.99827941e-02f, -6.80447891e-02f, -9.05667022e-02f,
  -6.86583668e-02f, 1.37080997e-01f, 8.19325894e-02f, 4.47869599e-02f, 5.65691991e-03f, 6.34064153e-02f, 2.66586114e-02f, 6.56630248e-02f, -1.93872210e-02f, -5.43068387e-02f,
  2.23994125e-02f, -5.28565124e-02f, -5.00789993e-02f, -5.58106638e-02f, 6.35577738e-02f, 5.22976480e-02f, 3.50796990e-02f, 7.31002912e-03f, -6.36913925e-02f, -5.76841384e-02f,
  -3.21231671e-02f, 1.87364388e-02f, 1.88349169e-02f, 7.90476054e-02f, -6.93978369e-02f, 2.73493752e-02f, 7.20475465e-02f, -8.73646140e-03f, 4.67163622e-02f, -1.78267173e-02f,
  -9.59860235e-02f, -3.96535769e-02f, 5.14997952e-02f, 8.32486972e-02f, 6.50478154e-02f, 5.83301112e-02f, 1.05905406e-01f, -5.74681559e-04f, 3.48753668e-02f, 1.21540129e-02f,
  1.14478581e-01f, 1.12941340e-01f, 1.32812951e-02f, 4.62511182e-02f, -5.52160852e-02f, 1.52576584e-02f, -2.73232311e-02f, 1.03796609e-01f, 5.61655536e-02f, 5.86185902e-02f,
  -2.84634680e-02f, 4.30205315e-02f, -7.12075084e-02f, -6.39753118e-02f, 7.59714469e-02f, 7.11167157e-02f, -4.24510166e-02f, 3.41447480e-02f, 3.44690606e-02f, 5.15066460e-02f,
  1.01101018e-01f, -4.74669114e-02f, 9.11000222e-02f, 2.90947407e-02f, -3.48984748e-02f, 4.81424034e-02f, 7.08417445e-02f, -1.21828327e-02f, 5.81663102e-02f, 1.30474884e-02f,
  -1.42163346e-02f, -2.27986369e-02f, 4.08843085e-02f, -4.67918701e-02f, 9.25786942e-02f, 9.88491625e-02f, 8.63135755e-02f, 8.31944030e-03f, 8.78960360e-03f, 3.46678756e-02f,
  -4.58764611e-03f, -8.75831954e-03f, -2.29581539e-02f, -4.40734476e-02f, 1.81986112e-02f, 9.43128690e-02f, 4.55753691e-02f, 5.00467643e-02f, 1.00451022e-01f, 1.12832256e-01f,
  -5.27106188e-02f, -9.02076811e-02f, 5.71262613e-02f, 6.56024367e-02f, -4.22472209e-02f, -5.53663820e-02f, -9.89312083e-02f, -4.88732904e-02f, 4.08091322e-02f, -5.18354401e-02f,
  -7.09862784e-02f, 5.10102957e-02f, -5.58375157e-02f, 3.61939445e-02f, 2.03285087e-03f, 2.82351971e-02f, 6.16877824e-02f, -6.04871139e-02f, 8.03290457e-02f, -6.87838197e-02f,
  -7.93985352e-02f, -6.96470216e-02f, -5.71718104e-02f, 1.41249876e-02f, 1.46066472e-02f, -6.23390004e-02f, -3.23637053e-02f, 1.04743734e-01f, -7.12962374e-02f, -1.75457299e-02f,
  -1.21562248e-02f, 7.02045262e-02f, 5.58773652e-02f, 5.15962504e-02f, -4.47065383e-02f, -7.59335794e-03f, 7.18613118e-02f, -2.00600866e-02f, 9.23559535e-03f, 4.71610837e-02f,
  7.77976513e-02f, 4.26741987e-02f, -1.14026228e-02f, 7.80120492e-02f, 7.95668550e-03f, -2.98971161e-02f, 7.59467781e-02f, 8.66309255e-02f, -4.06313539e-02f, 2.98438985e-02f,
  2.74326857e-02f, -4.89863455e-02f, -3.46282497e-02f, -2.88639795e-02f, -3.90206166e-02f, -1.91633645e-02f, 3.75653878e-02f, 2.65275985e-02f, 8.43219161e-02f, 4.41625752e-02f,
  -1.29257962e-01f, 2.70790886e-02f, 3.43837552e-02f, 2.71415859e-02f, 1.63299516e-02f, -2.76967697e-02f, 3.60996723e-02f, 2.86663920e-02f, 1.02652751e-01f, 9.70299020e-02f,
  -5.79346828e-02f, 6.65275976e-02f, -5.61012961e-02f, 7.90913403e-02f, -1.26726720e-02f, 2.76879612e-02f, 1.13275632e-01f, 7.93050304e-02f, -7.81677961e-02f, -1.87418330e-02f,
  3.75957042e-02f, -7.04521164e-02f, 5.88172711e-02f, 3.03346626e-02f, -1.10587124e-02f, -3.34651954e-02f, -1.55255813e-02f, -5.78129888e-02f, -5.54227792e-02f, -5.28314337e-02f,
  4.54165116e-02f, -7.79665560e-02f, -2.65727453e-02f, -8.30461551e-03f, -3.99077274e-02f, 6.21060934e-03f, -2.50633638e-02f, 9.01798159e-02f, 4.77424674e-02f, -1.49583519e-02f,
  -6.92099240e-03f, -5.57973236e-02f, 5.46413064e-02f, 4.91977073e-02f, 4.50022370e-02f, -5.60453348e-02f, 7.16274697e-03f, 8.59846398e-02f, -4.48194845e-03f, -6.66985009e-03f,
  1.14180900e-01f, -4.02534753e-02f, 4.09478433e-02f, -3.03489193e-02f, 2.66201440e-02f, -3.94790526e-03f, -5.84423356e-02f, -1.48689200e-03f, 5.67221269e-02f, -1.76931806e-02f,
  6.22361191e-02f, 1.85678881e-02f, -4.65737805e-02f, -2.37755310e-02f, -6.48660287e-02f, 2.31174054e-03f, 4.16988600e-03f, 5.85866161e-02f, 7.18779191e-02f, 2.37252470e-02f,
  -2.74241995e-02f, -2.44582985e-02f, -3.18164527e-02f, 3.10770739e-02f, -8.76653343e-02f, 6.78202286e-02f, -6.87653422e-02f, -7.75672197e-02f, 5.65233221e-03f, -3.88099998e-02f,
  -3.81531417e-02f, 8.29413161e-03f, -3.66587825e-02f, -4.97871004e-02f, -1.81450322e-02f, -8.12867284e-02f, -5.27941575e-03f, -5.26079126e-02f, 6.31920174e-02f, -9.39667597e-03f,
  6.90521598e-02f, 4.51260209e-02f, -9.13881585e-02f, -4.49217930e-02f, -9.74278711e-03f, 7.35362098e-02f, 5.66848218e-02f, -4.55060378e-02f, 5.89145953e-03f, 7.31825233e-02f,
  4.06442173e-02f, 6.36849180e-02f, 7.99584948e-03f, 1.02524459e-01f, 5.21323085e-03f, 4.07097340e-02f, -2.55412247e-04f, 3.32236104e-02f, -3.10332365e-02f, 1.07439831e-02f,
  9.49881524e-02f, 1.07966378e-01f, -1.31667471e-02f, 2.97416206e-02f, 8.96730572e-02f, -4.51471731e-02f, -8.31413735e-03f, 7.05498531e-02f, 2.08284110e-02f, 8.16094037e-03f,
  -1.46667674e-01f, 2.10541636e-02f, -7.14017674e-02f, -4.72192764e-02f, -5.51544800e-02f, -8.46120180e-04f, -7.67633244e-02f, -2.35180487e-03f, 6.76131472e-02f, -4.08123955e-02f,
  -2.18445342e-03f, 1.92195997e-02f, 6.73509911e-02f, 1.41672101e-02f, -1.28816575e-01f, -7.66474083e-02f, -1.52328759e-01f, -9.19567421e-02f, -1.27872095e-01f, 3.37157026e-02f,
  -1.19896874e-01f, -2.05286387e-02f, -1.63830355e-01f, -1.29973993e-01f, 1.00960337e-01f, -3.57293226e-02f, -8.09205398e-02f, 3.57463062e-02f, -3.97258587e-02f, -8.31594169e-02f,
  1.66497603e-01f, 4.29169312e-02f, 3.72670963e-02f, -1.24295957e-01f, 1.88408345e-02f, 6.22706264e-02f, 7.51211196e-02f, 2.58087534e-02f, -7.62436688e-02f, 1.32901417e-02f,
  5.36916479e-02f, 8.62190425e-02f, -1.77291241e-02f, 9.88417119e-02f, 7.82566667e-02f, 3.22559774e-02f, -7.27738813e-02f, -1.42901421e-01f, -6.64187968e-02f, 8.93424675e-02f,
  3.64865810e-02f, 2.01392546e-02f, -7.47337714e-02f, 9.46542919e-02f, 6.58302084e-02f, -5.69515489e-02f, 7.06674978e-02f, 4.01223935e-02f, -7.85360932e-02f, 3.78863839e-03f,
  -2.21463037e-03f, 6.75462512e-03f, 2.42782775e-02f, 5.05239367e-02f, -2.86845602e-02f, -3.64975655e-03f, 4.97351587e-02f, 4.41526957e-02f, -1.01327851e-01f, 2.24363450e-02f,
  5.25373332e-02f, 1.01135388e-01f, 4.16954942e-02f, -5.16681001e-02f, 3.93249504e-02f, 5.06892912e-02f, -8.90563801e-02f, -4.18905690e-02f, -9.18512270e-02f, 1.11247279e-01f,
  3.91205586e-02f, 1.15896918e-01f, 1.05058856e-01f, -7.46289175e-03f, -5.99929616e-02f, -2.22346894e-02f, -2.47631930e-02f, -4.59730253e-02f, -7.40407500e-03f, -4.18148451e-02f,
  1.28113806e-01f, -1.25342503e-01f, -5.36860265e-02f, 3.85420932e-03f, -1.14674672e-01f, 5.11257015e-02f, 5.21267503e-02f, -6.11927733e-02f, 4.81805280e-02f, 5.49456663e-02f,
  2.21608039e-02f, -1.97047624e-03f, -5.79209719e-03f, 6.81092814e-02f, 2.89530284e-03f, -1.58338174e-02f, -4.31273542e-02f, -7.41511583e-02f, 1.03053274e-02f, 9.67392921e-02f,
  7.75788277e-02f, -2.48449054e-02f, -3.33517380e-02f, 2.80614607e-02f, -1.93569083e-02f, -5.53690316e-03f, 6.92771003e-03f, -1.84370503e-02f, 4.03909273e-02f, -2.57702135e-02f,
  -1.85589090e-01f, 4.56283465e-02f, -1.54378116e-01f, -1.09437294e-01f, -2.39784390e-01f, -7.81406611e-02f, -1.41492456e-01f, 5.18159233e-02f, -1.39311804e-02f, -1.32661164e-02f,
  -1.05974181e-02f, 7.34103248e-02f, -1.59417372e-03f, 7.00048357e-02f, -6.27444014e-02f, -1.94494650e-01f, -1.36030138e-01f, -1.73256293e-01f, 4.64545414e-02f, 2.82151960e-02f,
  -1.90013610e-02f, -1.54408187e-01f, -6.89201355e-02f, 2.73581650e-02f, -5.77453859e-02f, 1.67594016e-01f, 2.93534975e-02f, -1.27958164e-01f, -1.19188232e-02f, -2.21649975e-01f,
  1.44928712e-02f, -8.27042460e-02f, -2.29406133e-02f, -6.59381300e-02f, 2.62973811e-02f, -3.49988081e-02f, 1.78747065e-02f, -1.16047496e-03f, -8.47723521e-03f, -2.99973655e-02f,
  -8.04479644e-02f, 6.20137230e-02f, 3.94635722e-02f, 6.65145833e-03f, 9.30797532e-02f, 4.64757346e-03f, -8.21245164e-02f, -2.61826068e-02f, 1.95642896e-02f, -4.03261147e-02f,
  -9.06026289e-02f, -1.00601494e-01f, 2.35229824e-02f, 6.40582591e-02f, -3.22509184e-02f, -9.32838768e-02f, 6.90280052e-04f, 1.00210540e-01f, 4.42983434e-02f, 1.14390485e-01f,
  -1.76142622e-02f, 7.52364770e-02f, 5.44661796e-03f, 6.36331141e-02f, 7.95492083e-02f, 1.02487653e-01f, 6.30942583e-02f, 8.41961130e-02f, 2.37060152e-02f, 1.26116663e-01f,
  -4.23595645e-02f, -1.07640408e-01f, -1.88863911e-02f, 2.00576857e-02f, -6.71830103e-02f, -2.88410485e-02f, -5.64378910e-02f, 1.17807556e-02f, -6.93092272e-02f, -3.97161692e-02f,
  2.02612169e-02f, 7.03078741e-03f, -4.45707627e-02f, 1.10620201e-01f, -1.19678818e-01f, -2.88263503e-02f, 1.69040430e-02f, 3.19503397e-02f, -1.13486517e-02f, -2.85397414e-02f,
  2.37205014e-01f, -2.02676535e-01f, 1.15153799e-02f, 2.32958496e-02f, -1.00878887e-01f, -9.41104516e-02f, 6.72887489e-02f, 4.65657674e-02f, 6.43815696e-02f, -7.71073028e-02f,
  5.07210493e-02f, 1.23781778e-01f, 5.33836111e-02f, -4.73735631e-02f, 4.23895894e-03f, -8.60761013e-03f, -2.81380228e-04f, 3.87078039e-02f, -5.70773706e-02f, 5.69478609e-02f,
  4.45293412e-02f, -4.45096120e-02f, 1.39975965e-01f, 1.63888596e-02f, 2.97045801e-02f, 1.00242980e-02f, 1.16216607e-01f, 1.03148758e-01f, -1.78492106e-02f, 1.32620290e-01f,
  -6.13458417e-02f, 3.33568268e-02f, -1.21309184e-01f, -6.31090552e-02f, 3.92560735e-02f, 8.78129005e-02f, 1.25224769e-01f, 5.01546785e-02f, 8.27221274e-02f, -3.31501029e-02f,
  -3.89786288e-02f, 5.50753176e-02f, -5.81054427e-02f, 8.96751285e-02f, 6.98274821e-02f, -4.63892147e-03f, -3.63131128e-02f, 3.11358701e-02f, 7.64072910e-02f, 4.12299447e-02f,
  -3.78308147e-02f, -2.58452389e-02f, -6.13295063e-02f, -5.31157255e-02f, -1.05338089e-01f, -4.03040722e-02f, -1.27215981e-01f, -1.05926253e-01f, 2.98465323e-02f, -1.21986881e-01f,
  -2.55903266e-02f, 2.78797280e-02f, -2.95629874e-02f, 6.75573424e-02f, 1.38452509e-02f, 2.38454081e-02f, -6.75736219e-02f, -8.65373984e-02f, -7.17241690e-03f, -2.64947060e-02f,
  3.78014110e-02f, 2.73904335e-02f, -1.35219142e-01f, 8.15081373e-02f, -1.45792635e-03f, 4.20389522e-04f, -6.56633079e-02f, -9.39835459e-02f, -1.21409044e-01f, 1.17083453e-02f,
  4.59050818e-04f, -8.89893025e-02f, -8.24882165e-02f, 1.35377422e-03f, -1.18708938e-01f, -1.12582490e-01f, -8.57875347e-02f, -7.77021646e-02f, -1.04584940e-01f, -4.33743410e-02f,
  -6.54771701e-02f, 7.29794726e-02f, -7.61701688e-02f, -3.14395875e-02f, -4.84203883e-02f, 4.38739173e-02f, 1.55327432e-02f, 5.13996556e-02f, 1.90513153e-02f, -9.62351188e-02f,
  -2.27298085e-02f, 8.53367522e-02f, 8.30768645e-02f, 4.95103933e-02f, -6.03059586e-03f, -2.19120849e-02f, -5.16842231e-02f, 6.31353185e-02f, -6.36630505e-02f, -3.53916436e-02f,
  -7.30167925e-02f, 1.05460025e-02f, -1.07043572e-01f, 2.31021121e-02f, 7.08786473e-02f, -2.65291482e-02f, 1.35335047e-02f, 5.76699227e-02f, 1.35901449e-02f, -1.00478679e-01f,
  -4.20114659e-02f, 3.63906957e-02f, -1.55625865e-02f, 2.94188205e-02f, -1.23478904e-01f, -6.20439798e-02f, 1.27000129e-02f, -3.32138352e-02f, -5.68159744e-02f, -4.25922945e-02f,
  -6.81867078e-02f, 2.78148986e-02f, -4.41173017e-02f, 5.26709892e-02f, 5.53483553e-02f, -2.06279885e-02f, -1.10768341e-02f, 5.19312732e-02f, -2.91986875e-02f, -1.30831927e-01f,
  -7.77997896e-02f, -5.05610630e-02f, -5.46111092e-02f, -8.26032087e-02f, 5.57351951e-03f, -4.53696912e-03f, -1.72513630e-02f, 9.90813505e-03f, -6.50496483e-02f, -1.11709617e-01f,
  -1.90820560e-01f, -1.04619497e-02f, -4.04347256e-02f, 1.06855907e-01f, 1.44140929e-01f, 7.71359205e-02f, 2.12031439e-01f, 1.99199244e-01f, 1.78856447e-01f, 8.17824341e-03f,
  6.37083426e-02f, 9.20977145e-02f, 5.95017225e-02f, 1.67103291e-01f, 1.52206376e-01f, 1.09592624e-01f, 1.37172684e-01f, 4.89712171e-02f, 8.63764957e-02f, 9.52483490e-02f,
  3.19991037e-02f, 5.03419638e-02f, -7.26115108e-02f, 4.58200052e-02f, -2.88568990e-04f, 1.04915693e-01f, 8.10455605e-02f, 8.26942176e-02f, 4.93250974e-02f, 1.10518426e-01f,
  -2.32415437e-03f, 1.75235253e-02f, 1.04222432e-01f, -4.72272523e-02f, -5.64235821e-02f, -9.76139959e-03f, -3.21612321e-02f, 4.59031342e-03f, -9.70412002e-05f, 4.17993031e-02f,
  -3.16607840e-02f, -1.34459347e-01f, -4.33347262e-02f, -6.35122284e-02f, -1.02281526e-01f, -5.41405939e-02f, -1.21762887e-01f, -2.08749287e-02f, 7.43941292e-02f, -1.82099435e-02f,
  -2.69747488e-02f, 7.53839873e-03f, -6.29818738e-02f, -4.16099504e-02f, 9.11722258e-02f, -5.70912957e-02f, -2.86206082e-02f, 5.97727150e-02f, -8.90871435e-02f, -9.13625136e-02f,
  -5.03961146e-02f, -1.50655862e-02f, -1.96330696e-02f, -7.42836446e-02f, 2.97135003e-02f, 1.87032379e-03f, -4.82732765e-02f, -6.75506592e-02f, 1.70149338e-02f, 3.00246011e-02f,
  1.02710417e-02f, -6.62621036e-02f, 6.58572614e-02f, 7.88031816e-02f, 3.89831290e-02f, 6.92960322e-02f, -7.09948912e-02f, -4.90532853e-02f, -7.53420368e-02f, 3.64633240e-02f,
  3.91466357e-02f, -7.14474842e-02f, 4.87212539e-02f, 5.39551228e-02f, 4.71195839e-02f, -7.19264196e-03f, -7.74040520e-02f, -3.59238237e-02f, 6.61327690e-02f, -3.36036682e-02f,
  1.80189069e-02f, 1.49994558e-02f, 8.81093591e-02f, 3.15686576e-02f, 5.72717153e-02f, -1.06448255e-01f, 3.43546718e-02f, 1.89177394e-02f, 5.55072501e-02f, -6.08485714e-02f,
  5.16129704e-03f, -8.12366754e-02f, 2.08985340e-02f, -5.47840856e-02f, -1.16509654e-01f, 4.25423756e-02f, -3.88241224e-02f, -3.87852043e-02f, -6.06403314e-02f, -7.38925263e-02f,
  -5.14996201e-02f, -7.06087425e-02f, -2.19372325e-02f, 4.62371111e-02f, 1.50712766e-02f, 3.20222639e-02f, -4.51106429e-02f, 4.42985154e-04f, -7.58313993e-03f, -1.58708598e-02f,
  -2.26884454e-01f, 2.84406245e-02f, -1.16040088e-01f, -2.17608381e-02f, 1.60242856e-01f, 1.56342555e-02f, -4.22805920e-02f, -1.13045769e-02f, 8.48650094e-03f, 3.86171117e-02f,
  -3.67565602e-02f, -2.46519763e-02f, 4.63687174e-04f, -1.50141537e-01f, -2.12794691e-01f, -1.97163075e-01f, -1.78777874e-01f, -1.92728698e-01f, -1.89413458e-01f, -5.07499427e-02f,
  -2.85979938e-02f, -2.32507825e-01f, -1.89996466e-01f, -5.48681431e-02f, 7.92635307e-02f, 8.28790516e-02f, 2.24394016e-02f, 3.53099220e-02f, -2.49623302e-02f, 7.12667592e-03f,
  -6.29134402e-02f, 1.48404375e-01f, 6.19259477e-02f, 2.05397177e-02f, -2.47219205e-02f, 1.60151254e-02f, -6.08668961e-02f, -4.59763780e-02f, 6.60928339e-02f, 3.15959826e-02f,
  -2.30925921e-02f, 4.72749062e-02f, 7.16053993e-02f, -5.00244983e-02f, 6.80571198e-02f, 2.54590362e-02f, -1.88507028e-02f, -1.09195240e-01f, 2.75261421e-03f, -2.15016138e-02f,
  3.29240598e-03f, -6.86922446e-02f, -1.12963162e-01f, 7.02186581e-03f, 2.69754548e-02f, -5.36091104e-02f, -2.06911713e-02f, 9.54248477e-03f, 8.23297426e-02f, 2.92081889e-02f,
  2.78093554e-02f, 2.70624682e-02f, -1.64860170e-02f, -8.21802691e-02f, -6.23806193e-02f, 5.83479293e-02f, -1.91252846e-02f, 5.68558536e-02f, 1.01704299e-02f, -7.16743544e-02f,
  4.19488065e-02f, 9.85192582e-02f, 6.15756847e-02f, 1.07468866e-01f, -3.49247605e-02f, 2.18096524e-02f, 5.21879271e-02f, -1.85538810e-02f, 6.20833947e-04f, -1.31631065e-02f,
  -2.42727157e-02f, -4.11584899e-02f, -3.21507826e-03f, -3.41896825e-02f, 5.76112978e-02f, 3.48671004e-02f, -3.62669080e-02f, 2.69813407e-02f, -5.09750135e-02f, 4.84165130e-03f,
  -1.20801702e-01f, -1.50236199e-02f, -6.59709126e-02f, -8.32304507e-02f, 7.12839812e-02f, 4.96691950e-02f, -4.38022465e-02f, 7.01586891e-04f, 1.86053459e-02f, 2.02101190e-02f,
  6.04709536e-02f, -2.02748436e-03f, -5.91308214e-02f, 5.44643961e-02f, 6.49450645e-02f, -3.94586362e-02f, 2.69544367e-02f, -3.00731808e-02f, -1.28373384e-01f, 4.78713661e-02f,
  -8.86522308e-02f, -1.61038801e-01f, -7.40252957e-02f, 7.28065968e-02f, -3.55948582e-02f, -8.39409456e-02f, -3.53239588e-02f, 3.27706784e-02f, -1.41529486e-01f, -1.11932466e-02f,
  -9.74744335e-02f, 5.90851419e-02f, 2.68890299e-02f, -4.86028753e-02f, 1.32428706e-02f, 9.34867561e-02f, 1.42700210e-01f, 1.15820114e-02f, -1.32293971e-02f, -3.02884844e-03f,
  -1.76107287e-02f, -5.77397197e-02f, -4.03046831e-02f, -4.44068611e-02f, 7.34884618e-03f, 4.87908497e-02f, 8.30826536e-02f, -8.37269202e-02f, -9.04135481e-02f, -4.70734090e-02f,
  2.61192676e-02f, 4.98243682e-02f, -7.58593157e-02f, 1.81551520e-02f, -5.84282279e-02f, -4.76669297e-02f, -9.46771353e-03f, -3.33617963e-02f, 6.69503435e-02f, 2.37273574e-02f,
  8.42909738e-02f, -3.88853699e-02f, -5.03454953e-02f, -6.90198839e-02f, 3.26614939e-02f, -5.29779904e-02f, 1.89187247e-02f, 3.85517702e-02f, -4.47300486e-02f, -1.42216997e-03f,
  -1.67444851e-02f, 6.37813881e-02f, -3.26599479e-02f, -4.54042219e-02f, -1.20972507e-02f, 2.57832464e-02f, -4.79329042e-02f, -8.19118470e-02f, -6.35057017e-02f, 6.72311289e-03f,
  -3.51109728e-02f, -6.88403472e-02f, -5.29653691e-02f, -6.37323260e-02f, 6.24618530e-02f, -1.33779517e-03f, -5.16907461e-02f, 3.69038284e-02f, -2.00656578e-02f, 5.76086529e-03f,
  -2.70774383e-02f, -7.35823205e-03f, 4.49055433e-02f, -2.94519477e-02f, 4.58253808e-02f, 4.50627729e-02f, 7.57528096e-02f, 5.46239242e-02f, -5.46283536e-02f, 5.75272106e-02f,
  -2.77083982e-02f, 2.71328771e-03f, -1.81125011e-02f, 4.69123237e-02f, -7.19915107e-02f, 4.29439992e-02f, -2.73337606e-02f, -6.22834377e-02f, 2.04360262e-02f, 7.73211271e-02f,
  7.11228028e-02f, 1.18647360e-04f, 6.72952682e-02f, 5.36796600e-02f, -3.19074877e-02f, -2.24523135e-02f, 8.93707275e-02f, -5.28202988e-02f, 1.34899113e-02f, 8.10671821e-02f,
  -7.98454434e-02f, -1.14452867e-02f, 5.93649223e-02f, 8.21401402e-02f, 3.32357921e-02f, -1.22547299e-02f, -2.59408187e-02f, 8.48980695e-02f, 8.04027915e-02f, -4.45338562e-02f,
  -2.65525244e-02f, 1.54431770e-02f, -2.90988944e-02f, 7.27149770e-02f, -3.39993797e-02f, 1.94404852e-02f, 5.87802865e-02f, 8.06707218e-02f, 6.20452054e-02f, 6.23534992e-02f,
  -2.46346500e-02f, -5.10064028e-02f, -2.36508660e-02f, -9.49509442e-02f, -6.15789257e-02f, -1.99690871e-02f, -4.53297235e-02f, 4.55850810e-02f, -3.26997675e-02f, -2.99729686e-02f,
  7.44584054e-02f, 2.94761509e-02f, 1.63432851e-01f, -4.13331762e-02f, 7.65723139e-02f, 1.55229792e-01f, 1.38301134e-01f, 6.11842349e-02f, 8.11041370e-02f, 8.50352123e-02f,
  4.99119908e-02f, 3.73430736e-03f, -1.14162810e-01f, -5.88875897e-02f, -4.73600663e-02f, -2.44624466e-02f, -6.42286763e-02f, 9.15641189e-02f, 4.87701828e-03f, 4.15745303e-02f,
  -8.25439095e-02f, -5.85513897e-02f, -4.08499241e-02f, -7.30518857e-03f, 2.19952054e-02f, 2.84446608e-02f, 2.84074433e-02f, -7.60190040e-02f, 3.69597375e-02f, -6.47292584e-02f,
  -7.58821368e-02f, 3.27727497e-02f, -7.93520361e-02f, 2.62383856e-02f, -6.19331514e-03f, -1.06820818e-02f, 4.78343330e-02f, 1.10576320e-02f, -4.39691804e-02f, -5.82270883e-02f,
  -4.70377132e-02f, -9.05618444e-03f, 8.94233733e-02f, 4.92154844e-02f, 1.42607503e-02f, -6.37938529e-02f, -8.77909586e-02f, -8.19235221e-02f, 2.51734965e-02f, 4.01106700e-02f,
  3.58609818e-02f, 1.82976518e-02f, 1.42576266e-02f, 1.38782077e-02f, -6.97113499e-02f, -3.17973793e-02f, -7.88690373e-02f, -6.66525727e-03f, 4.29369174e-02f, 2.35359278e-02f,
  -5.47822900e-02f, 7.78417066e-02f, -1.34748304e-02f, 8.89082998e-02f, -3.44772264e-02f, 1.26596451e-01f, -3.29890884e-02f, -9.99177545e-02f, 7.62927234e-02f, -5.44641167e-02f,
  -5.02162911e-02f, -4.69334461e-02f, -3.25289592e-02f, 6.05754480e-02f, 6.29443154e-02f, 8.22283328e-02f, -4.97674495e-02f, 1.52695617e-02f, 8.23925361e-02f, -6.83338344e-02f,
  -3.36902253e-02f, -3.20184743e-03f, 7.75063261e-02f, 6.20188154e-02f, 5.56402579e-02f, 3.89783308e-02f, 7.79447556e-02f, 7.53052533e-02f, -6.90892711e-02f, 6.83048293e-02f,
  -1.36747599e-01f, 1.04627587e-01f, 1.88365784e-02f, -9.46393237e-02f, 1.20739877e-01f, -8.46249163e-02f, 2.22932566e-02f, -3.20961550e-02f, -3.98428692e-03f, -3.42174945e-03f,
  1.43289999e-05f, -4.76237424e-02f, 7.73269534e-02f, -4.44215350e-02f, 1.18865035e-01f, -3.21630910e-02f, 7.45757520e-02f, 9.06678289e-03f, 3.70193385e-02f, -6.53797016e-02f,
  -1.09262891e-01f, 6.93241367e-03f, 7.90058598e-02f, 1.83845423e-02f, -1.02763906e-01f, 6.37175813e-02f, 6.07828535e-02f, 6.26482815e-02f, 2.38832012e-02f, -1.05186291e-01f,
  -1.11751162e-01f, 2.98677292e-03f, -1.01857483e-01f, -1.11664934e-02f, -4.43044566e-02f, -7.44688064e-02f, -4.69885804e-02f, 3.11723817e-03f, -4.44286801e-02f, 2.42452510e-03f,
  8.44685640e-03f, 3.89904715e-03f, -2.61636265e-02f, 2.41435114e-02f, 8.15526024e-03f, -5.03315069e-02f, -1.11680962e-01f, -9.67472792e-02f, -8.05750862e-02f, 6.54459372e-02f,
  7.40596130e-02f, -1.29255652e-01f, -4.67321016e-02f, -4.53233309e-02f, 9.42869037e-02f, 1.17372721e-01f, 6.55309632e-02f, 2.40654461e-02f, -1.41275609e-02f, 8.02015513e-02f,
  1.29949063e-01f, 5.01539633e-02f, 1.13843665e-01f, -9.40160006e-02f, -4.36539650e-02f, 1.32021578e-02f, 1.70487221e-02f, -7.28241354e-02f, -9.44483839e-03f, -4.22093607e-02f,
  6.97065890e-02f, -8.12145919e-02f, -1.53892124e-02f, 6.67128339e-02f, 3.77910510e-02f, 6.58525005e-02f, -6.71852678e-02f, 4.29765135e-02f, 3.71350572e-02f, -1.56338364e-02f,
  3.10872924e-02f, 9.69509557e-02f, 1.08559817e-01f, 5.29649034e-02f, -1.87947936e-02f, 5.80696482e-03f, 1.22964211e-01f, 1.19528055e-01f, 8.65121707e-02f, -5.69675565e-02f,
  1.63768865e-02f, 2.06159335e-02f, 4.46746945e-02f, -8.84426385e-02f, -7.62969181e-02f, -1.02933235e-01f, 1.99803207e-02f, -1.08775839e-01f, 1.51684415e-02f, -1.33482680e-01f,
  -4.49344553e-02f, 1.30261686e-02f, 1.49963116e-02f, 6.39715940e-02f, 7.12438077e-02f, -2.22923290e-02f, 5.45530058e-02f, 4.51280586e-02f, 9.62051079e-02f, 4.89382669e-02f,
  3.18718813e-02f, -8.79900604e-02f, -8.66874494e-03f, -3.45191099e-02f, 7.66279269e-03f, 6.62920624e-02f, 5.58808334e-02f, 9.34260190e-02f, 1.97040383e-02f, 3.54825109e-02f,
  1.00214683e-01f, 2.69156490e-02f, 3.76035757e-02f, -3.26122828e-02f, -3.01489636e-04f, 3.82525031e-03f, -1.67032760e-02f, 5.03224470e-02f, 5.17920703e-02f, 1.55258775e-02f,
  -6.79221973e-02f, -4.48506735e-02f, -4.75187004e-02f, -9.98729840e-02f, 4.59110551e-02f, -3.52078006e-02f, 8.81879963e-03f, 4.12846841e-02f, 9.39137340e-02f, -3.78743038e-02f,
  -2.71788612e-02f, -2.98529956e-02f, 3.35434526e-02f, 4.87643220e-02f, -1.04134895e-01f, -1.16190417e-02f, 1.26594871e-01f, 2.21179947e-02f, -5.24246208e-02f, -8.15707743e-02f,
  6.51097298e-02f, -8.96718130e-02f, 2.39444580e-02f, -9.56572127e-03f, 1.19410314e-01f, 2.45890245e-02f, -3.24898288e-02f, 4.53259982e-02f, 1.08704358e-01f, 1.87999550e-02f,
  1.46236422e-03f, 5.69127388e-02f, -4.15671468e-02f, 5.45441136e-02f, 3.79879251e-02f, -3.98324616e-02f, 1.28838629e-01f, 1.33221641e-01f, 1.10606857e-01f, 3.71641852e-02f,
  -1.55211138e-02f, 9.44547355e-02f, 3.29691581e-02f, 8.52076858e-02f, 2.11101174e-02f, 1.06106207e-01f, -4.62706201e-02f, 7.76848421e-02f, -4.43567224e-02f, 5.78637794e-03f,
  1.16975583e-01f, 3.20673063e-02f, -2.36876085e-02f, -6.58991262e-02f, -5.58491517e-03f, -8.24200884e-02f, -8.45874101e-02f, 2.17410624e-02f, 5.49237318e-02f, -6.40692040e-02f,
  -2.39809770e-02f, -2.06736550e-02f, -2.83019282e-02f, -8.76358449e-02f, -1.06118128e-01f, 3.18928920e-02f, 6.14046305e-03f, 2.41507427e-03f, 4.80631590e-02f, -3.78942825e-02f,
  2.79203132e-02f, -8.21235124e-03f, -9.05305445e-02f, -4.88525070e-02f, 1.26191592e-02f, 6.09615818e-02f, 5.52797392e-02f, 6.50106370e-02f, 1.34753939e-02f, 4.28347886e-02f,
  -2.53060926e-02f, -3.88239995e-02f, 3.53678465e-02f, 2.47073304e-02f, -7.31151029e-02f, -7.01418817e-02f, -5.12022376e-02f, -5.13674133e-02f, -1.12111215e-02f, -1.05498649e-01f,
  4.22010496e-02f, -4.95462306e-02f, -5.97750396e-02f, -5.15355505e-02f, 5.29815555e-02f, 8.19198564e-02f, -6.66433796e-02f, -7.75620192e-02f, -3.29091102e-02f, 1.02041196e-02f,
  6.03341125e-02f, -3.11515722e-02f, -3.54513177e-03f, 5.83539531e-03f, -5.11506088e-02f, 5.66798002e-02f, 1.59872491e-02f, 4.66418006e-02f, 3.15335914e-02f, 1.06377006e-02f,
  1.30889276e-02f, 1.08805269e-01f, 5.26204892e-02f, -4.86294180e-03f, 1.99374203e-02f, -2.58510187e-02f, 3.36053967e-02f, -2.45613586e-02f, 7.99354091e-02f, 4.01875712e-02f,
  8.91395509e-02f, 3.58923227e-02f, 3.72501127e-02f, -3.60522904e-02f, -8.33506361e-02f, -6.63651228e-02f, 5.97077888e-04f, 3.83632518e-02f, -6.12510405e-02f, -6.90051019e-02f,
  6.01365380e-02f, 1.60783045e-02f, 6.57811910e-02f, -7.72666186e-02f, 2.60475930e-02f, 2.71013342e-02f, 4.75813821e-03f, -3.34683582e-02f, -5.23087904e-02f, -4.32488769e-02f,
  2.51581222e-01f, -1.92535311e-01f, 3.49536203e-02f, 1.47014797e-01f, 4.35869694e-02f, 1.13698050e-01f, 1.56809956e-01f, 6.75432608e-02f, 1.05234146e-01f, 5.85684367e-02f,
  1.10596105e-01f, -3.93957980e-02f, -2.98574544e-03f, -2.63983142e-02f, 6.83640987e-02f, -1.86652131e-02f, -1.06650434e-01f, 4.71127145e-02f, 1.37901664e-01f, 1.00436985e-01f,
  5.26195392e-02f, 4.87235673e-02f, -1.01290112e-02f, 2.72485595e-02f, 1.20131718e-02f, 4.99835536e-02f, -9.30187851e-02f, -8.22641253e-02f, -5.93139306e-02f, -2.14333087e-01f,
  -1.09380495e-03f, -9.13034901e-02f, 1.05040804e-01f, 8.14545900e-02f, 2.77742948e-02f, 4.72616553e-02f, 1.92214716e-02f, -1.12024747e-01f, -1.50050325e-02f, -5.88198751e-02f,
  5.02007902e-02f, -9.49817076e-02f, -9.08317417e-02f, -2.41330341e-02f, 5.34326350e-03f, 2.87816618e-02f, -1.30511587e-02f, -6.80388212e-02f, -3.64629738e-02f, -5.93981445e-02f,
  -1.10416055e-01f, -7.88636655e-02f, -3.55739780e-02f, 5.77056892e-02f, -1.58654731e-02f, 5.85767627e-02f, -2.43007373e-02f, -9.60521474e-02f, 5.25712185e-02f, -1.31444260e-01f,
  -7.11117387e-02f, -2.77475007e-02f, 9.65874866e-02f, -4.73008171e-04f, 5.40716201e-03f, 1.15226351e-01f, -2.91818799e-03f, -1.19368233e-01f, 4.78039943e-02f, -8.20380300e-02f,
  2.77560111e-02f, 5.64433038e-02f, -1.02179833e-01f, 7.39789829e-02f, -6.72457889e-02f, -4.75747697e-02f, -5.49512543e-03f, -6.35663643e-02f, 8.88570920e-02f, 7.56121203e-02f,
  6.09549545e-02f, -4.33296710e-02f, 9.43334773e-02f, -9.31477025e-02f, 2.05513053e-02f, -5.21156229e-02f, -2.51865759e-02f, -7.39845186e-02f, -8.22300464e-03f, 4.89965193e-02f,
  -8.77194630e-04f, 3.32126580e-02f, -6.34941235e-02f, -2.29202472e-02f, -8.62494577e-03f, 1.53775280e-02f, 1.34873658e-01f, -1.86081510e-02f, -7.63479695e-02f, 1.27999455e-01f,
  -6.35015815e-02f, -1.03158444e-01f, 6.65355381e-03f, -7.93980807e-02f, 3.07810791e-02f, 3.11244652e-02f, -7.24804029e-02f, -4.66935942e-03f, 4.43735793e-02f, -6.33324981e-02f,
  -8.70315805e-02f, 8.46908148e-03f, -5.58216721e-02f, 1.05098121e-01f, 6.13907091e-02f, 1.22739904e-01f, 4.89779785e-02f, -3.11641414e-02f, 7.81156942e-02f, 5.92696555e-02f,
  1.97672821e-03f, -2.76879538e-02f, -1.23987213e-01f, -3.70815583e-02f, 8.04232508e-02f, 3.35276425e-02f, -1.96243003e-01f, -3.99415642e-02f, 9.52307042e-03f, -1.93067628e-03f,
  5.39030172e-02f, 1.44683510e-01f, -3.53824697e-03f, -7.75003880e-02f, -7.26394653e-02f, -1.68334484e-01f, -9.98414308e-02f, -1.55703843e-01f, -7.54714757e-02f, 2.86713839e-02f,
  -2.87457593e-02f, 4.57908884e-02f, -6.42160624e-02f, 6.66401759e-02f, 1.13782577e-01f, 8.16417187e-02f, -4.96997871e-02f, -7.24958181e-02f, 1.60392765e-02f, 1.77083574e-02f,
  2.42603458e-02f, 4.55641299e-02f, 1.23694008e-02f, -4.52321768e-03f, -2.29667500e-02f, -1.44842155e-02f, -9.00291279e-02f, 3.88962291e-02f, -4.09864384e-04f, 5.07209115e-02f,
  -9.23722330e-03f, -4.83376980e-02f, -3.47605832e-02f, 1.03359148e-01f, -4.55407389e-02f, -5.75853847e-02f, 8.24854523e-03f, -7.80470222e-02f, -5.83057888e-02f, -8.92095789e-02f,
  -5.87559724e-03f, 1.88312139e-02f, -5.07924929e-02f, 4.66283597e-03f, -6.50546998e-02f, 8.49857256e-02f, -8.19833949e-02f, -3.03758625e-02f, 6.44541755e-02f, 4.84030806e-02f,
  -3.09795961e-02f, 8.78682062e-02f, 4.60411981e-02f, -5.06433137e-02f, 9.29963440e-02f, 2.52669714e-02f, 2.60930322e-02f, 6.13161772e-02f, -3.91358025e-02f, 6.29101172e-02f,
  -3.66757028e-02f, 1.10343657e-02f, 1.02115780e-01f, -8.09891671e-02f, 9.06493142e-02f, -6.81847632e-02f, 3.64208408e-02f, 5.42443283e-02f, -1.73185244e-02f, 3.86426337e-02f,
  7.43403062e-02f, -5.22178598e-02f, 6.43669367e-02f, 7.98917487e-02f, 2.92177219e-02f, -3.96609344e-02f, 8.88902228e-03f, 1.26387561e-02f, 2.90465578e-02f, -8.46681371e-03f,
  -3.88317443e-02f, -4.64191996e-02f, 1.24310084e-01f, 7.75977969e-02f, 4.73742746e-02f, 2.81913504e-02f, 6.53124368e-03f, -9.32602957e-02f, 9.94491205e-02f, -5.78066334e-02f,
  7.80707523e-02f, 3.95003706e-02f, -6.14288300e-02f, 7.92411119e-02f, -3.30820284e-03f, -4.21433672e-02f, -4.27649058e-02f, 2.71280259e-02f, -5.48399240e-02f, 5.83824627e-02f,
  -8.68511796e-02f, -5.19405417e-02f, 5.09872548e-02f, -9.13318023e-02f, 8.49217698e-02f, 3.17740999e-02f, 3.16876695e-02f, -8.36859345e-02f, -9.59237143e-02f, -1.51272178e-01f,
  -3.52093160e-01f, 1.36077702e-01f, 1.48636520e-01f, -3.15105952e-02f, 1.95789054e-01f, 4.16901499e-01f, 5.24730623e-01f, 7.23308772e-02f, -2.21935123e-01f, 1.21705659e-01f,
  1.01362370e-01f, -1.36218980e-01f, -1.42729387e-01f, -6.47773743e-02f, 1.40508309e-01f, 2.60861695e-01f, 1.51214138e-01f, -1.50900587e-01f, -7.80944228e-02f, 6.80139512e-02f,
  -2.44033672e-02f, -1.02562867e-01f, -3.14376801e-01f, -1.73558295e-01f, -7.79093876e-02f, -1.35839835e-01f, 2.21744422e-02f, -6.48803636e-02f, 1.17875203e-01f, -6.12305775e-02f,
  -1.00361295e-02f, 1.10275581e-01f, 1.79693364e-02f, -1.53350264e-01f, 3.72709520e-02f, -1.58389688e-01f, -3.55543382e-02f, -1.11808665e-01f, -4.32092920e-02f, -4.49494570e-02f,
  -6.20641038e-02f, -2.61886418e-02f, -3.27599086e-02f, 6.09539784e-02f, 1.04857618e-02f, -4.33481932e-02f, -9.25313309e-02f, -1.13576226e-01f, -2.68077161e-02f, 1.64853752e-01f,
  1.05799176e-01f, 5.62626012e-02f, -2.90313028e-02f, 9.90779623e-02f, 1.01172715e-01f, -1.14126794e-01f, 1.21088147e-01f, 5.16975336e-02f, 1.55369550e-01f, -1.34853482e-01f,
  4.59718481e-02f, -3.83164808e-02f, 1.12923883e-01f, -1.01129524e-01f, 2.12501492e-02f, -6.93743750e-02f, -1.69085972e-02f, 6.93782989e-04f, 6.87177703e-02f, -1.04864970e-01f,
  4.95832786e-02f, 7.80687407e-02f, -4.81801406e-02f, -3.06315050e-02f, 2.95776781e-03f, 2.15429328e-02f, 1.57442372e-02f, 9.86109823e-02f, -4.64601293e-02f, 6.06308468e-02f,
  2.26214156e-03f, 4.29845881e-03f, -1.11192809e-02f, 7.22997040e-02f, -5.50845861e-02f, -6.38518035e-02f, -7.04929978e-02f, -2.85970755e-02f, -8.81592035e-02f, -6.20505959e-02f,
  -2.57719427e-01f, 1.64680868e-01f, -2.26618633e-01f, -8.48426744e-02f, -7.53446445e-02f, -3.42909619e-02f, 7.08010495e-02f, 2.48266011e-02f, 5.35946265e-02f, 1.64629165e-02f,
  5.88087477e-02f, -5.90960076e-03f, -3.17587033e-02f, 5.24963178e-02f, 7.25937169e-03f, 6.16886951e-02f, 6.51748031e-02f, 7.31396908e-03f, 1.30356982e-01f, -3.83805134e-03f,
  7.81228766e-02f, -2.82203499e-02f, -2.09014341e-01f, -4.41205576e-02f, -7.22121522e-02f, -4.24685335e-04f, -4.95810434e-02f, -9.65497196e-02f, 3.90954502e-03f, -9.18765515e-02f,
  -5.82314320e-02f, -2.96131894e-02f, -4.06472385e-02f, -8.96837637e-02f, -5.29205007e-03f, 5.05264364e-02f, 7.17386007e-02f, -1.78904682e-02f, -4.35198098e-02f, -7.55911544e-02f,
  -6.99746758e-02f, 5.58365397e-02f, 5.88862970e-02f, 4.95289229e-02f, 4.70876060e-02f, 5.04994532e-03f, 7.88234640e-03f, -7.90524855e-02f, -5.48842363e-02f, -1.48351444e-03f,
  6.55265376e-02f, 2.67665833e-02f, -9.58569199e-02f, -3.11008142e-03f, -1.11005232e-01f, 2.91285403e-02f, -4.74622473e-02f, -2.67262887e-02f, -6.34536743e-02f, -1.10559747e-01f,
  6.47552982e-02f, -5.07741943e-02f, -2.03000773e-02f, 3.65179181e-02f, -9.26915258e-02f, 2.67108362e-02f, -7.77327493e-02f, -1.14888683e-01f, 2.55182963e-02f, -5.33606671e-02f,
  -7.26327747e-02f, 8.89593586e-02f, -4.29663323e-02f, 4.65494916e-02f, 1.84624363e-02f, 7.75003657e-02f, -4.79828492e-02f, 3.29751410e-02f, 7.38181323e-02f, 3.59612182e-02f,
  5.35211824e-02f, -9.54476148e-02f, -3.09498049e-03f, -1.39695536e-02f, 7.46922493e-02f, -3.86644006e-02f, -1.93998795e-02f, -7.53589943e-02f, 3.46312076e-02f, -1.01821624e-01f,
  5.90747558e-02f, 6.87685758e-02f, -3.81046273e-02f, -7.35168904e-02f, -2.14175358e-02f, 4.84761409e-02f, -5.20728528e-02f, -9.15594846e-02f, -9.25205573e-02f, -5.54658298e-04f,
  6.95694983e-02f, -4.19067480e-02f, -2.44677011e-02f, -7.40215555e-02f, -4.39859927e-02f, 7.99053907e-03f, -5.56740165e-02f, 5.20645082e-02f, -2.97032576e-02f, -2.68235393e-02f,
  1.51499733e-02f, -6.02625385e-02f, -5.06965593e-02f, 3.64366658e-02f, -1.98844355e-02f, 4.50573489e-02f, 8.35836828e-02f, -2.12943312e-02f, -5.20183928e-02f, -3.66408974e-02f,
  1.55272742e-03f, -8.58589336e-02f, -8.89343992e-02f, 2.94059999e-02f, 3.59749049e-02f, -1.17792115e-02f, 3.87615040e-02f, -8.33389610e-02f, 3.01842391e-02f, 1.49928825e-02f,
  5.09198681e-02f, 4.32708375e-02f, 2.83750389e-02f, -2.44047977e-02f, -6.95222616e-02f, 2.91708596e-02f, -3.11918613e-02f, -7.78082609e-02f, -3.15734535e-04f, -4.26956778e-03f,
  6.98062629e-02f, -2.09763516e-02f, 1.70282517e-02f, -1.10783903e-02f, 8.19326937e-03f, 5.67267612e-02f, -8.20086524e-02f, -8.65667127e-04f, -8.01627561e-02f, -3.48465219e-02f,
  -1.14758179e-01f, -5.46817593e-02f, -1.66053966e-01f, 1.01647034e-01f, -1.77088659e-02f, 5.92619590e-02f, -6.37746900e-02f, 6.43888265e-02f, -5.02590686e-02f, -6.88564777e-02f,
  1.36801541e-01f, 1.59133762e-01f, 1.13226339e-01f, 2.11279024e-03f, -1.03335097e-01f, -8.73625353e-02f, -6.72491714e-02f, -1.03306569e-01f, 4.73566130e-02f, 4.34891917e-02f,
  8.79999176e-02f, -4.64731008e-02f, 2.86321826e-02f, 2.69595850e-02f, 1.19451635e-01f, 1.92512274e-01f, 6.02481812e-02f, 5.95036708e-03f, 1.87047524e-03f, -3.36553305e-02f,
  9.68195405e-03f, 6.02226797e-03f, -3.06228478e-03f, 8.88686255e-02f, 9.79659483e-02f, -8.49760696e-02f, -6.81995973e-03f, -1.00673459e-01f, 5.45998197e-03f, -3.08564045e-02f,
  -5.13670640e-03f, -7.70058855e-02f, 5.48274815e-02f, 4.17850390e-02f, 5.27233183e-02f, -1.10382788e-01f, -5.03633767e-02f, -8.24645832e-02f, -1.00144349e-01f, -2.94935354e-03f,
  7.35665485e-02f, -8.30611959e-02f, -6.21520216e-03f, 1.02884078e-03f, -9.26039219e-02f, -7.14244917e-02f, -1.60002187e-02f, 1.82283614e-02f, -1.19580505e-02f, 7.68025145e-02f,
  7.40313232e-02f, -7.04446137e-02f, -8.53345767e-02f, 1.37512377e-02f, -1.26056112e-02f, 4.43475246e-02f, -3.66164744e-02f, 6.56112731e-02f, 2.23512538e-02f, 2.24433262e-02f,
  -3.10250111e-02f, -5.68386214e-03f, -7.83380419e-02f, 3.99908572e-02f, 1.03274755e-01f, 5.48972040e-02f, 7.77382106e-02f, -1.94012877e-02f, 1.47891538e-02f, 3.55353281e-02f,
  -4.66925576e-02f, 5.82729583e-04f, -2.35539787e-02f, -9.10840649e-03f, -1.41972139e-01f, 1.09971408e-03f, -3.62682939e-02f, -9.83692929e-02f, -1.19993398e-02f, -3.25439982e-02f,
  1.07066303e-01f, -1.93628594e-02f, 3.97381075e-02f, -2.85891350e-02f, 6.32793605e-02f, -9.10239667e-03f, 5.47693186e-02f, -2.71071121e-02f, -9.42121595e-02f, 7.60625303e-02f,
  9.96151846e-03f, 7.70783499e-02f, 1.80298984e-02f, -3.17139365e-02f, 1.60526354e-02f, 2.70292326e-03f, -6.45039976e-02f, -6.57071918e-02f, -4.39590327e-02f, -8.05742741e-02f,
  -9.78369713e-02f, -8.19881707e-02f, -1.07571602e-01f, -6.22323900e-02f, -5.10419672e-03f, 5.45766205e-02f, 5.58092818e-02f, 2.57556718e-02f, -5.42684346e-02f, 1.79146063e-02f,
  -2.00939327e-01f, -1.27626415e-02f, -2.75601242e-02f, -7.52233565e-02f, 6.59871697e-02f, -3.64215635e-02f, -1.58154771e-01f, 4.27025221e-02f, 4.37668711e-02f, -1.21988982e-01f,
  -4.10238933e-03f, -6.32488430e-02f, -9.66317058e-02f, -8.57105181e-02f, -1.48333356e-01f, -5.81686758e-02f, -1.96102798e-01f, -6.60800710e-02f, 6.60509765e-02f, 1.38672009e-01f,
  4.01530825e-02f, -4.39261720e-02f, 2.98052374e-03f, 1.14099272e-01f, 3.80791984e-02f, -4.97407466e-02f, -6.32498115e-02f, -7.16119930e-02f, -9.89164412e-02f, -1.82012200e-01f,
  -2.23112866e-01f, 2.39231978e-02f, 2.27527483e-03f, -5.44612296e-02f, 2.56943493e-03f, 5.28870709e-02f, -1.04346268e-01f, 2.12726127e-02f, 3.86156477e-02f, 2.05933228e-02f,
  -3.91725227e-02f, -1.56690031e-02f, 7.52357021e-02f, 7.31779411e-02f, -8.40961859e-02f, 6.80892617e-02f, -1.07708049e-03f, 3.74538228e-02f, 3.18672135e-02f, 4.11805138e-02f,
  1.04522906e-01f, -2.17799265e-02f, 2.61392109e-02f, -4.75339359e-03f, 8.95304903e-02f, -7.09516034e-02f, -9.83937085e-03f, -1.91642810e-02f, -3.43229249e-02f, -1.65858358e-01f,
  2.24129502e-02f, 3.35423164e-02f, 7.43812621e-02f, 7.38662779e-02f, -8.03051963e-02f, 1.65495574e-02f, -6.23648055e-02f, -5.97131625e-02f, 8.06310773e-02f, 4.46175225e-02f,
  2.87544690e-02f, 5.74425198e-02f, -1.04765020e-01f, -4.98940237e-02f, 7.34247193e-02f, 3.70018072e-02f, 3.04561984e-02f, 5.72459884e-02f, 2.06810422e-02f, -2.55063502e-03f,
  7.17863366e-02f, 4.03558202e-02f, -1.87943876e-02f, -3.87384631e-02f, -4.73945737e-02f, -1.52189508e-02f, -3.38776037e-02f, -1.40327355e-02f, 7.35575259e-02f, 9.71660838e-02f,
  -3.49931866e-02f, 3.15238833e-02f, -1.22698471e-01f, -2.13547163e-02f, 1.48809161e-02f, -9.99162719e-03f, -1.48153035e-02f, 2.27993242e-02f, -4.35353406e-02f, 5.88236973e-02f,
  7.09529594e-02f, 3.14242430e-02f, -3.59818642e-03f, 8.64229649e-02f, -4.51466478e-02f, -1.65421460e-02f, 1.13642300e-02f, 7.39171356e-03f, 1.08993754e-01f, 1.76975399e-01f,
  1.29729612e-02f, 7.10875168e-02f, 4.31693345e-02f, -6.15292527e-02f, 4.10941169e-02f, -1.04445770e-01f, -9.51271206e-02f, -9.65495333e-02f, -1.37288764e-01f, -1.35211259e-01f,
  -1.85130998e-01f, -5.84054440e-02f, -1.37461796e-01f, -1.21558927e-01f, 5.49836718e-02f, 1.46276709e-02f, 8.49941000e-02f, 9.71080363e-02f, 6.61729053e-02f, 3.40195708e-02f,
  3.26886661e-02f, -3.49306799e-02f, -9.17160660e-02f, -5.06082550e-02f, -5.73709942e-02f, -9.40285251e-02f, -1.52096376e-01f, -1.01013921e-01f, -6.49258941e-02f, -4.26804647e-02f,
  2.73062903e-02f, -1.71246499e-01f, -7.74224475e-02f, -5.64727224e-02f, -1.64152626e-02f, 1.64807830e-02f, -1.07722372e-01f, -1.03001282e-01f, 4.21644701e-03f, -1.43476008e-02f,
  -8.70536193e-02f, 5.17610088e-02f, -7.93466792e-02f, -8.91012419e-03f, 3.24960835e-02f, 8.16542879e-02f, -4.14710119e-02f, -1.12343155e-01f, -2.79226191e-02f, -5.07041253e-02f,
  -1.18629321e-01f, -8.41817111e-02f, 7.40660913e-03f, -3.32293957e-02f, -6.72383085e-02f, 4.59916983e-03f, -4.96609323e-02f, -6.27219975e-02f, 3.05914432e-02f, 1.18975036e-01f,
  1.21844612e-01f, 6.22285306e-02f, 4.87951003e-02f, 1.75690670e-02f, -3.94037887e-02f, 7.72867128e-02f, -4.51503694e-02f, 6.30198121e-02f, -4.01157364e-02f, 5.37323952e-02f,
  -1.87418200e-02f, -9.33797359e-02f, 4.82876711e-02f, -2.09828676e-03f, -4.74400818e-02f, 6.13438375e-02f, -5.61977252e-02f, -4.15948927e-02f, -8.82891491e-02f, -3.16791586e-03f,
  -3.41437478e-03f, -5.30819129e-03f, 9.50522721e-02f, -5.02840355e-02f, -3.29896919e-02f, -6.15312085e-02f, 5.28583899e-02f, 7.07156211e-02f, -1.46963233e-02f, -6.21799491e-02f,
  -2.41923872e-02f, 7.78887048e-02f, -7.29242638e-02f, -7.27638677e-02f, -3.92879397e-02f, 3.07538360e-02f, 5.92703652e-03f, 4.94489968e-02f, 1.53397322e-02f, -7.99005330e-02f,
  -1.52806818e-01f, 1.32596493e-02f, 2.36888900e-02f, -1.25939116e-01f, -6.64915219e-02f, -3.91238518e-02f, 9.09920782e-02f, -5.25684934e-03f, -1.13848567e-01f, 4.38450910e-02f,
  7.44769126e-02f, 2.35674139e-02f, 2.83460654e-02f, -7.53542632e-02f, 1.72384176e-02f, -4.85478574e-03f, -2.58429125e-02f, -2.91421339e-02f, -5.31364270e-02f, -1.14266882e-02f,
  6.62325099e-02f, 5.72494268e-02f, -7.03514740e-02f, -8.16298649e-02f, -4.86450419e-02f, 5.92583977e-03f, 2.76594628e-02f, 7.31564462e-02f, 2.97814850e-02f, -5.86625859e-02f,
  2.51768023e-01f, -9.04573947e-02f, 2.04128353e-03f, 7.62724057e-02f, 7.68118203e-02f, 4.15956192e-02f, 3.83126587e-02f, -5.09594753e-02f, -8.92701279e-03f, 6.65386319e-02f,
  2.30391845e-02f, 1.75073519e-01f, 1.70469686e-01f, 6.61932826e-02f, 9.41936150e-02f, 2.43298989e-02f, -5.87629490e-02f, 4.62842248e-02f, 3.17720585e-02f, -2.09670886e-02f,
  -3.96155007e-02f, -5.41063324e-02f, 8.46216753e-02f, -1.01242974e-01f, -5.69585524e-03f, 7.64567554e-02f, -1.15434512e-01f, -1.36962816e-01f, -2.01243870e-02f, -9.80368033e-02f,
  4.66888584e-02f, -1.58193167e-02f, 4.52409079e-03f, 9.34860036e-02f, -4.22182493e-02f, 6.90418780e-02f, 4.86810394e-02f, -7.29918629e-02f, 6.13921732e-02f, -9.44321007e-02f,
  -5.25518991e-02f, 5.86263537e-02f, -1.42282033e-02f, -8.79754946e-02f, 1.83886681e-02f, 4.79740053e-02f, -5.28837964e-02f, 2.78410204e-02f, -8.32536891e-02f, 2.57579386e-02f,
  1.79444347e-02f, -4.37703282e-02f, 1.76408440e-02f, 6.14068508e-02f, -6.28561294e-03f, 8.58999602e-03f, 1.50610134e-02f, 5.63398749e-02f, 2.62028128e-02f, -6.66801631e-02f,
  6.01728596e-02f, -7.19558960e-03f, -4.15360816e-02f, -5.30823097e-02f, -4.33057211e-02f, -1.87516939e-02f, -3.32427546e-02f, 7.44902641e-02f, 6.01908565e-02f, -1.01200603e-01f,
  -3.16550806e-02f, 8.10641199e-02f, 6.88034445e-02f, 5.58261480e-03f, -3.98434214e-02f, -6.43865466e-02f, -6.97277114e-02f, -7.91770313e-03f, 2.34773085e-02f, 3.66323739e-02f,
  -6.36095181e-02f, -9.31021571e-02f, -1.06891813e-02f, 5.02289645e-02f, -1.32957874e-02f, 7.37121701e-02f, 6.48017526e-02f, 3.52766067e-02f, 4.62939851e-02f, -8.16660374e-02f,
  2.41765529e-02f, 1.55758590e-01f, 1.09513924e-01f, -5.15003912e-02f, -3.33268493e-02f, 1.28205204e-02f, 1.03394268e-03f, -1.21104466e-02f, 2.50009187e-02f, -1.17977522e-01f,
  -2.85000112e-02f, -5.75460196e-02f, -1.66916564e-01f, 1.51856663e-02f, 6.18686713e-02f, -8.53437409e-02f, -3.58958393e-02f, 9.07814875e-02f, 2.40021627e-02f, -8.10073093e-02f,
  -2.66489889e-02f, 5.07129766e-02f, 6.64801598e-02f, 3.08478493e-02f, -6.69469684e-02f, 1.31846398e-01f, -2.65509426e-03f, -6.46088198e-02f, 9.14871320e-02f, 6.51352033e-02f,
  8.37435424e-02f, 4.24770638e-03f, -2.15347037e-01f, 2.38082912e-02f, -1.63465649e-01f, -1.27866805e-01f, -9.19715911e-02f, -5.55610657e-02f, -6.33420721e-02f, 1.87586881e-02f,
  -9.65803266e-02f, 3.13850977e-02f, 5.51635139e-02f, 9.29038301e-02f, -7.68628065e-03f, -5.97459003e-02f, -2.63989922e-02f, -7.77079090e-02f, 5.25190830e-02f, -5.95352650e-02f,
  -3.37343360e-03f, -6.71315864e-02f, -5.35067357e-02f, 1.76034519e-04f, -6.86048120e-02f, -3.89591455e-02f, -4.64410987e-03f, 1.90877076e-02f, -1.63131803e-02f, -1.93445995e-01f,
  1.52467212e-04f, -7.34052286e-02f, -1.04909703e-01f, -1.55999819e-02f, -8.57591331e-02f, -1.81574989e-02f, 1.24634346e-02f, 3.34238671e-02f, 7.10845590e-02f, -1.11933030e-01f,
  7.42243007e-02f, -4.41415012e-02f, 6.17932677e-02f, -8.17874819e-02f, 1.84707772e-02f, -4.11703065e-02f, -8.56086612e-03f, 5.85350506e-02f, -5.59369661e-02f, -5.86111695e-02f,
  -1.69504937e-02f, -7.70075396e-02f, -5.10208867e-02f, -3.53194363e-02f, -1.43563058e-02f, 7.16401041e-02f, -5.30874617e-02f, -1.94074214e-02f, -1.16649717e-01f, -6.95885196e-02f,
  -9.79880542e-02f, 4.62341644e-02f, 4.52192314e-02f, -3.58371846e-02f, 5.23250476e-02f, 3.74699831e-02f, -3.50346081e-02f, -4.03217785e-02f, 1.18645374e-02f, 5.36037274e-02f,
  3.55252326e-02f, -6.91402256e-02f, 4.55464460e-02f, 8.29721428e-03f, 6.66089430e-02f, -5.53342551e-02f, 2.48305630e-02f, 1.32106012e-02f, -3.00674606e-03f, 5.72682098e-02f,
  7.38031715e-02f, -4.95517738e-02f, 3.83172594e-02f, -2.33227778e-02f, -3.34441848e-02f, 3.88503112e-02f, 6.52086362e-02f, -1.06242999e-01f, 8.22896287e-02f, 1.62419572e-03f,
  1.29839301e-01f, -3.81938852e-02f, -8.94422084e-03f, 5.81890717e-02f, -3.05970665e-02f, 4.91498448e-02f, 4.22328748e-02f, -6.35852069e-02f, 4.14397679e-02f, 4.60780488e-04f,
  6.46879673e-02f, -4.00863923e-02f, 5.58857583e-02f, -8.88458043e-02f, -7.96988234e-02f, -4.25253063e-02f, 7.34939286e-03f, 9.16187540e-02f, -8.24250281e-02f, -8.18460211e-02f,
  4.61727343e-02f, 1.85355097e-02f, 5.25956601e-02f, 8.68020803e-02f, 2.66199037e-02f, 7.88720325e-02f, 4.33884151e-02f, -2.65521146e-02f, 9.14937034e-02f, 6.28612423e-03f,
  -5.70103861e-02f, 4.23423573e-03f, -8.57681483e-02f, -1.17570929e-01f, -1.09325007e-01f, 5.32859080e-02f, -1.17649183e-01f, 7.26359412e-02f, -5.09788096e-02f, -1.51541382e-01f,
  -4.42983769e-02f, 3.76528911e-02f, -5.77329919e-02f, -4.17658836e-02f, 6.58573071e-03f, 1.53347086e-02f, -9.00888443e-02f, 3.40607502e-02f, 1.14337228e-01f, 5.63927032e-02f,
  -5.93362935e-02f, -4.05309387e-02f, 9.70047060e-03f, 4.61532734e-02f, -1.15616538e-01f, -2.56424695e-02f, -1.14143454e-01f, 4.34054472e-02f, -8.73626992e-02f, -1.77948564e-01f,
  -9.29588675e-02f, -2.80637406e-02f, -7.27248145e-03f, 4.14362513e-02f, 8.05836692e-02f, 7.53023177e-02f, 1.05504189e-02f, 1.94281666e-03f, 1.29215345e-01f, 5.43712378e-02f,
  5.77997081e-02f, -2.06298102e-02f, -1.72248390e-02f, 1.06051117e-01f, -4.75735739e-02f, 2.54598837e-02f, 4.92004231e-02f, 1.14858812e-02f, 1.95859130e-02f, 2.10684240e-02f,
  9.41078216e-02f, 4.04213890e-02f, 6.24773325e-03f, 4.96239923e-02f, 2.28255242e-02f, -6.54866099e-02f, -1.30743310e-02f, 1.10141821e-01f, 8.07075202e-02f, 9.96654555e-02f,
  4.97881658e-02f, -4.08641174e-02f, -4.87300605e-02f, -3.15608643e-02f, -3.55048962e-02f, 5.45456782e-02f, 7.79909119e-02f, -3.35291098e-03f, 7.96217695e-02f, -4.53319065e-02f,
  3.14554572e-02f, -1.11867830e-01f, 4.21708897e-02f, 8.21914598e-02f, -3.79407518e-02f, -7.89116696e-02f, 1.60485394e-02f, 3.90997343e-02f, 6.62030205e-02f, -3.24066877e-02f,
  5.12308218e-02f, -9.92570370e-02f, -1.57879908e-02f, -4.69381437e-02f, 5.35432808e-02f, 4.09577154e-02f, -1.86340231e-02f, 6.10714369e-02f, -5.13089038e-02f, 6.97756633e-02f,
  -8.12700465e-02f, 5.51931635e-02f, -1.41095728e-01f, -3.03291697e-02f, 2.32783165e-02f, 6.77258223e-02f, -1.31410554e-01f, 1.49233509e-02f, -8.94842595e-02f, 3.32637280e-02f,
  -2.82416698e-02f, -3.46722605e-04f, 1.15147652e-02f, 4.76137772e-02f, -1.09503288e-02f, 1.56952851e-02f, -5.15477657e-02f, 3.67158605e-03f, -6.60497919e-02f, -4.22370136e-02f,
  1.28766477e-01f, 1.20249487e-01f, 5.26977964e-02f, 5.68835363e-02f, 2.40198076e-02f, -9.49041396e-02f, -4.49567251e-02f, -6.83485568e-02f, -4.30463143e-02f, 3.48531939e-02f,
  2.65518397e-01f, -1.49303600e-01f, -1.58047006e-01f, 1.49137437e-01f, -9.10897031e-02f, 8.42414349e-02f, -3.23087350e-02f, 9.36890915e-02f, 2.25884065e-01f, -6.83745593e-02f,
  1.45545483e-01f, 1.08267300e-01f, 1.36782229e-01f, 3.02617084e-02f, 1.30368799e-01f, -1.41051292e-01f, -2.12836012e-01f, -1.49114057e-01f, 1.67296648e-01f, 1.15734145e-01f,
  1.19891964e-01f, 4.29602452e-02f, 6.38308451e-02f, 1.37437567e-01f, -1.02111518e-01f, 2.25262213e-02f, -1.97471440e-01f, -1.28461882e-01f, -7.16062412e-02f, -3.49945873e-01f,
  -1.92357838e-01f, -2.60549542e-02f, 2.67841425e-02f, 7.16924891e-02f, -2.32808702e-02f, 2.05201600e-02f, 1.11792078e-02f, -8.33156258e-02f, -9.24493745e-03f, -3.43807638e-02f,
  1.46743748e-02f, 1.73774380e-02f, 5.61294742e-02f, 4.18341868e-02f, 6.10588603e-02f, 5.11747738e-03f, -7.28815943e-02f, -2.88010985e-02f, -4.86499667e-02f, -6.00306243e-02f,
  -2.86184009e-02f, -2.03229282e-02f, -9.83043909e-02f, -5.95146976e-02f, -7.17452988e-02f, -7.96148926e-02f, -1.89195037e-01f, -1.53174788e-01f, -1.10114671e-01f, -1.88388765e-01f,
  -7.68795386e-02f, 1.51684799e-04f, 3.51325460e-02f, -6.59261420e-02f, -1.64470561e-02f, -3.30427326e-02f, -7.41755366e-02f, 1.32008502e-03f, -5.31578623e-02f, -1.61196589e-02f,
  -2.32463591e-02f, 5.25083877e-02f, -1.37855485e-02f, 3.36689837e-02f, 5.48445918e-02f, -6.19146135e-03f, -1.83315296e-02f, -1.03692457e-01f, 4.40006144e-02f, -9.52049941e-02f,
  3.44612524e-02f, -7.44151771e-02f, -4.17565480e-02f, 1.18653467e-02f, 1.66241731e-02f, -3.02379727e-02f, 4.26815683e-03f, 1.53086126e-01f, 8.54372904e-02f, 6.72362894e-02f,
  2.18516290e-01f, 8.45237076e-03f, 2.20511779e-02f, 4.14428972e-02f, -7.96220377e-02f, 1.88780259e-02f, 9.66433994e-03f, 3.27240191e-02f, -1.67484526e-02f, 2.03767251e-02f,
  -1.67171136e-02f, 5.02742790e-02f, 9.74302273e-03f, -2.88549997e-02f, 1.14060014e-01f, 1.49322182e-01f, 1.85706057e-02f, -6.19459674e-02f, 3.11534796e-02f, -1.36035383e-02f,
  2.52919234e-02f, -3.01735401e-02f, -4.63012308e-02f, 1.20894704e-02f, -3.56538743e-02f, 1.05074726e-01f, -9.10149887e-02f, -7.01610520e-02f, -2.19661351e-02f, -3.79642025e-02f,
  6.95483610e-02f, 3.23100910e-02f, 1.52120935e-02f, -7.31348470e-02f, 8.83572847e-02f, 1.09688044e-01f, 1.45246625e-01f, 4.93355270e-04f, -7.18255118e-02f, -3.41175608e-02f,
  3.79941873e-02f, -9.14370641e-02f, 5.34780882e-03f, 8.94676447e-02f, 4.54271622e-02f, 5.27034812e-02f, 8.73018876e-02f, -4.99433503e-02f, -2.22231131e-02f, -5.44125065e-02f,
  -2.26763226e-02f, 8.48986730e-02f, 3.99768837e-02f, 5.52195460e-02f, 1.25724953e-02f, 7.65518099e-02f, -5.45972511e-02f, -2.05435753e-02f, 8.04038048e-02f, 5.63356280e-02f,
  -5.88269830e-02f, 6.48750961e-02f, -7.04630166e-02f, -3.19485106e-02f, -7.82192200e-02f, -7.37710893e-02f, 9.48966146e-02f, -6.52393550e-02f, 2.41452754e-02f, -1.12170139e-02f,
  -7.88015053e-02f, 1.27626266e-02f, -7.72330016e-02f, 3.18367891e-02f, -4.90231179e-02f, 8.73295665e-02f, 1.28811197e-02f, 7.99177065e-02f, -7.87215903e-02f, 6.86543211e-02f,
  3.52248759e-03f, 6.30938262e-02f, -7.07967626e-03f, 7.70983147e-03f, -5.65489791e-02f, 7.47662559e-02f, -3.36093046e-02f, 3.80220055e-03f, -5.95851205e-02f, -1.83675550e-02f,
  2.82961549e-03f, 5.78170232e-02f, -6.14826158e-02f, 4.22226824e-02f, -7.22750276e-02f, 7.53426850e-02f, -3.00390087e-02f, 3.84938368e-03f, 4.39822264e-02f, 3.50627154e-02f,
  -4.26807217e-02f, -9.33765154e-03f, 1.04462216e-02f, -4.88412641e-02f, -7.57321492e-02f, -3.56440954e-02f, 1.76123790e-02f, -6.57323226e-02f, -3.32657285e-02f, -6.59322143e-02f,
  -3.87676023e-02f, 1.17240623e-02f, -4.51068534e-03f, 8.39979202e-02f, -7.85259530e-02f, -1.74326319e-02f, 5.78327514e-02f, 7.70560205e-02f, 8.50621983e-02f, 6.86906800e-02f,
  7.28573743e-03f, 1.08159278e-02f, -4.42735776e-02f, -7.25373477e-02f, -5.31518944e-02f, 7.04922900e-02f, 5.74260242e-02f, -7.37722814e-02f, 3.54956239e-02f, -1.63403749e-02f,
  -8.78464505e-02f, -6.62108958e-02f, 4.15442027e-02f, 3.47933546e-02f, -4.86399494e-02f, -4.37886417e-02f, 6.24361150e-02f, -7.27635026e-02f, -6.48698062e-02f, -1.79683734e-02f,
  5.01150973e-02f, 1.95027050e-02f, 3.02737877e-02f, 3.41289751e-02f, 7.10920319e-02f, 3.85274738e-02f, -8.43356624e-02f, -6.70098141e-02f, -2.24265512e-02f, 1.91312563e-02f,
  -1.33169815e-01f, 3.29937972e-02f, -1.04157440e-01f, -7.61122489e-03f, 1.89488672e-03f, 6.75088018e-02f, -1.12688974e-01f, 8.13744664e-02f, -3.84250190e-03f, 2.13323198e-02f,
  1.08606227e-01f, -1.69822201e-02f, -5.58568090e-02f, 8.29169303e-02f, -2.31078472e-02f, -6.02542572e-02f, -2.64910962e-02f, 1.04386592e-02f, -7.76658878e-02f, -5.75703979e-02f,
  -2.93631610e-02f, 5.82909398e-02f, 1.43226830e-03f, -4.94233333e-02f, 1.70791231e-03f, 6.45881221e-02f, 4.21829522e-02f, 9.16772708e-02f, 4.97565828e-02f, -1.53022129e-02f,
  -1.15340590e-01f, 3.54084447e-02f, 7.18841404e-02f, -8.25689360e-03f, -8.74101445e-02f, -7.79104326e-03f, -5.21810260e-03f, 5.23067154e-02f, 4.59247455e-02f, -1.79505982e-02f,
  -9.14093852e-02f, 9.08008777e-03f, -3.05933841e-02f, -5.60287088e-02f, -7.66609386e-02f, 3.64025645e-02f, -9.22600925e-02f, -6.37121871e-02f, -5.34474179e-02f, 7.47437077e-03f,
  5.67716435e-02f, 1.13306642e-01f, 2.55015423e-03f, -2.56544203e-02f, 2.76880618e-02f, 7.66587481e-02f, 7.30985478e-02f, 1.15563646e-01f, 7.97907412e-02f, -1.21950973e-02f,
  -8.49879067e-03f, -1.21324830e-01f, 1.03413843e-01f, -4.97469716e-02f, -7.60876201e-03f, 4.30887379e-02f, -6.45701736e-02f, -2.74126716e-02f, -3.77722420e-02f, -1.02316581e-01f,
  5.98682575e-02f, -8.39213803e-02f, -4.30169329e-02f, -2.79460344e-02f, -7.77795166e-02f, 2.78126672e-02f, 5.08231148e-02f, 6.34040684e-02f, -4.20913734e-02f, -2.48708967e-02f,
  -7.13209659e-02f, -3.47785205e-02f, 3.67067219e-03f, 3.97008136e-02f, 1.17892064e-01f, 4.17910777e-02f, -3.89303714e-02f, 1.05372764e-01f, 7.17773885e-02f, 5.22695035e-02f,
  9.47768390e-02f, -1.19939689e-02f, -5.65251112e-02f, -4.27685939e-02f, 3.91581617e-02f, -2.26549599e-02f, -1.45799397e-02f, 3.25806513e-02f, 5.76555282e-02f, -5.84707782e-02f,
  4.49594529e-03f, -8.80600512e-02f, 2.60436777e-02f, 2.51126364e-02f, -9.55435261e-02f, -5.79146072e-02f, 5.77465631e-02f, -6.77277073e-02f, -1.09880399e-02f, 8.70447680e-02f,
  1.02573514e-01f, -4.22836654e-02f, -5.66304289e-03f, 8.42355639e-02f, -2.74203392e-03f, -2.35179756e-02f, 3.49987298e-02f, 4.20615869e-03f, -2.04016734e-02f, 2.97818221e-02f,
  -9.22711641e-02f, 4.41484973e-02f, -9.05775130e-02f, -6.86782878e-03f, 9.69500542e-02f, 9.64085162e-02f, 1.30781800e-01f, -4.53309482e-03f, -1.23422474e-01f, -1.55485328e-02f,
  -4.49015424e-02f, -2.93901023e-02f, -4.06866297e-02f, 3.29968221e-02f, -3.77015583e-02f, 3.53301503e-02f, 4.85424623e-02f, -6.39574528e-02f, -2.60913353e-02f, -6.11617230e-02f,
  1.28544211e-01f, -1.34546027e-01f, -1.08649023e-01f, -9.09129977e-02f, 4.27902937e-02f, -9.50554684e-02f, 3.88978645e-02f, -7.82430992e-02f, 1.29208922e-01f, 1.43059477e-01f,
  2.65226122e-02f, -2.58971527e-02f, 1.93953272e-02f, 3.62535194e-02f, 4.10356596e-02f, 3.59218568e-02f, 6.04978111e-03f, -3.48466523e-02f, -3.83802596e-03f, 3.26630985e-03f,
  1.40603393e-01f, 1.64109897e-02f, -2.30286382e-02f, -4.42451686e-02f, 7.79230073e-02f, -4.14511897e-02f, 6.85074255e-02f, 1.71460696e-02f, 1.66213494e-02f, 6.12602197e-02f,
  1.70978531e-01f, 2.29146779e-02f, 9.21330228e-03f, -5.30509278e-03f, 2.87875254e-02f, -8.32124054e-02f, 2.81046070e-02f, -8.48953892e-03f, -6.75788820e-02f, -1.09522484e-01f,
  6.82127550e-02f, 9.59252268e-02f, -5.43445088e-02f, 6.52938634e-02f, 6.37693554e-02f, 3.83003242e-02f, 7.25505948e-02f, 2.28710789e-02f, 7.06093311e-02f, -5.96252047e-02f,
  5.50984591e-02f, -4.63930964e-02f, 1.66049451e-02f, -5.73983006e-02f, -5.20344973e-02f, -5.21004312e-02f, -8.39391537e-03f, 2.07630694e-02f, 1.53573509e-02f, 5.43523245e-02f,
  9.32974815e-02f, -3.46399136e-02f, 2.22921651e-02f, 1.33445999e-02f, 6.88796490e-02f, 1.94770779e-04f, -4.08277474e-02f, -3.54731530e-02f, -7.00124353e-02f, 1.96996164e-02f,
  -8.52156952e-02f, -1.71150360e-03f, 3.66294123e-02f, 6.08604290e-02f, 8.30449071e-03f, 5.65952063e-02f, 3.82215045e-02f, -4.23307456e-02f, 1.75661631e-02f, 2.15909630e-02f,
  1.49378078e-02f, -7.53104612e-02f, -4.31683473e-02f, -3.64227593e-02f, -3.25376354e-02f, -3.78832482e-02f, 1.49644958e-02f, 6.13168553e-02f, -4.86810915e-02f, 4.56644371e-02f,
  -3.23218629e-02f, -1.41625017e-01f, -1.26575246e-01f, -6.79802746e-02f, 5.03449850e-02f, -8.31281319e-02f, -1.36745766e-01f, 2.36508232e-02f, -6.78456202e-02f, -1.41732693e-01f,
  9.32573751e-02f, -5.81122413e-02f, 1.07184544e-01f, 2.50740405e-02f, -1.75318085e-02f, -6.96104839e-02f, -1.87530760e-02f, 1.04522007e-02f, -8.11246112e-02f, -3.41831218e-03f,
  1.16844121e-02f, -2.94252373e-02f, -1.00150079e-01f, 2.16224045e-02f, 7.79595971e-02f, 4.92397919e-02f, 7.18397722e-02f, 9.50379521e-02f, -5.10209415e-04f, -7.03676715e-02f,
  -9.32079107e-02f, -2.89239511e-02f, 1.12432567e-03f, 7.37563819e-02f, 2.63843425e-02f, -1.35341694e-03f, -9.28328466e-03f, -6.40210435e-02f, -6.25372976e-02f, 1.14693148e-02f,
  -2.84036156e-02f, 5.18015660e-02f, 6.88990653e-02f, -8.39447677e-02f, 6.76543787e-02f, -5.70539758e-02f, 2.72770207e-02f, -5.73271923e-02f, -7.84235597e-02f, 3.78062911e-02f,
  9.14504565e-03f, -7.91317001e-02f, 1.04310781e-01f, 1.73341651e-02f, 3.40379812e-02f, 4.39018644e-02f, -4.41134796e-02f, 9.07769203e-02f, 2.93733701e-02f, -6.65466860e-02f,
  1.17294705e-02f, 4.28851023e-02f, 6.86379001e-02f, -7.42352903e-02f, 6.96058869e-02f, 6.83052093e-02f, -2.15857700e-02f, 3.55940908e-02f, -9.46696475e-03f, 6.96249306e-02f,
  1.54621331e-02f, 8.54245573e-02f, -4.05494384e-02f, -7.02641718e-03f, 3.73160280e-02f, -6.35739788e-03f, 1.03754960e-01f, 5.30054979e-03f, 1.94375869e-02f, 5.27240969e-02f,
  -2.64478717e-02f, 3.43132988e-02f, -1.04929386e-02f, 7.86965415e-02f, -9.03019533e-02f, -8.42730477e-02f, 4.08497974e-02f, -5.62630485e-05f, -2.71596462e-02f, 5.94937764e-02f,
  -7.61010647e-02f, 3.78592834e-02f, -7.82401562e-02f, -3.14040408e-02f, -1.72151886e-02f, -7.83709958e-02f, 5.55366166e-02f, -3.92975174e-02f, -3.85906151e-03f, 1.41868806e-02f,
  -6.77860379e-02f, 1.24013431e-01f, 4.96020205e-02f, 5.43469265e-02f, 3.09383329e-02f, 8.68879855e-02f, -3.07216425e-04f, 2.46309284e-02f, 3.95563729e-02f, 2.23250631e-02f,
  -2.24866942e-02f, 7.10443966e-03f, 5.56298755e-02f, 6.88787028e-02f, -5.59805296e-02f, 9.42353718e-03f, -7.79451877e-02f, 6.09526634e-02f, -6.14808276e-02f, -1.87881440e-02f,
  5.80896661e-02f, -5.33667095e-02f, 2.92161461e-02f, 7.73191676e-02f, 3.36640328e-02f, 1.01376057e-01f, 9.13084894e-02f, -4.10213545e-02f, 5.22096315e-03f, -3.43317240e-02f,
  -1.63321018e-01f, 3.47467847e-02f, 5.36574647e-02f, -3.10895555e-02f, -1.22777373e-02f, 7.50326067e-02f, 4.47362475e-02f, 1.06091592e-02f, 1.18709914e-01f, 1.15984827e-01f,
  -4.58785966e-02f, 1.28298059e-01f, 4.72158706e-03f, 1.57641415e-02f, 1.13400541e-01f, 1.11656316e-01f, 4.26776372e-02f, 1.00944027e-01f, 1.05701862e-02f, 7.24733323e-02f,
  1.18586935e-01f, 5.59233911e-02f, 4.68926467e-02f, 6.02405481e-02f, 1.17713764e-01f, 3.33224200e-02f, 8.29415545e-02f, 2.98724826e-02f, 7.15041086e-02f, 2.12947521e-02f,
  1.59343973e-01f, -1.52524933e-01f, -5.22940643e-02f, -7.49124214e-02f, -2.51921322e-02f, -8.02013725e-02f, -5.59151247e-02f, -2.56463885e-02f, 3.13744508e-02f, -4.89033051e-02f,
  -6.45794570e-02f, 7.31594767e-03f, 4.79626320e-02f, -4.85305600e-02f, 8.60662833e-02f, -3.08915153e-02f, -1.29629016e-01f, 5.32104224e-02f, 8.36894214e-02f, -1.45516358e-02f,
  1.37994802e-02f, -3.98222767e-02f, 7.50515386e-02f, 4.52087894e-02f, -8.59839916e-02f, 1.12573942e-02f, 8.31567794e-02f, -1.99519414e-02f, -5.24269976e-02f, 9.96660255e-03f,
  -3.67962383e-03f, -1.08790388e-02f, 3.01378258e-02f, -3.65408473e-02f, -2.67684404e-02f, -3.25342715e-02f, -1.34651773e-02f, 8.73289928e-02f, 9.62302834e-02f, -6.11746944e-02f,
  -5.39303720e-02f, 5.05401120e-02f, 1.16730019e-01f, -3.65249924e-02f, -3.56660858e-02f, 5.00089414e-02f, -1.35342556e-03f, 9.62821394e-02f, -6.66039288e-02f, 3.99191529e-02f,
  2.46887598e-02f, -1.90237947e-02f, 7.21362829e-02f, -3.87703665e-02f, -6.39729425e-02f, 5.58882803e-02f, 3.24830823e-02f, -5.21425791e-02f, 4.20661420e-02f, 1.11811962e-02f,
  6.05644956e-02f, -1.08447008e-01f, 5.19693606e-02f, 1.64409429e-02f, -4.66158018e-02f, -1.02370754e-01f, -7.95484241e-03f, -1.20668538e-01f, -6.42356351e-02f, 4.37995940e-02f,
  -4.42917906e-02f, -7.58669153e-02f, 6.99544847e-02f, 9.31166485e-02f, 5.37354266e-03f, 2.06805132e-02f, -3.97781543e-02f, 9.06881243e-02f, -8.27624127e-02f, 5.98972067e-02f,
  2.16412209e-02f, -3.62176038e-02f, 1.76073853e-02f, 9.41871554e-02f, 1.78465266e-02f, -3.61604020e-02f, -3.14533450e-02f, 1.04552470e-01f, -3.81306652e-03f, -2.66257953e-02f,
  -3.50908143e-04f, -4.16720053e-03f, -2.09398083e-02f, -4.03893217e-02f, 6.80896193e-02f, -1.12611121e-02f, -7.64046460e-02f, 9.96524375e-03f, 9.19625908e-03f, -3.61011177e-02f,
  -4.42048013e-02f, -8.77687149e-03f, 6.65126322e-03f, 3.68991382e-02f, -6.04770426e-03f, 5.46210818e-02f, -4.63089421e-02f, -6.40968680e-02f, 6.51675910e-02f, -4.32699323e-02f,
  -1.21480115e-02f, -6.24494031e-02f, -6.97199181e-02f, -4.81148921e-02f, -1.63872615e-02f, -7.07880631e-02f, 1.32384151e-02f, 3.97538468e-02f, 3.82802673e-02f, -5.27407601e-02f,
  8.61825943e-02f, -2.63979174e-02f, 1.45895854e-02f, -3.87819856e-02f, -1.87278651e-02f, 1.06105367e-02f, 5.39308339e-02f, -5.71858808e-02f, 8.67621675e-02f, 4.03200053e-02f,
  2.51717996e-02f, 2.83593796e-02f, -7.28842020e-02f, -4.63917665e-02f, -5.65356985e-02f, 2.33521243e-03f, -3.08055859e-02f, -5.49983373e-03f, 8.14928934e-02f, -4.77010943e-02f,
  -2.85362545e-02f, -6.92412164e-03f, -2.83865002e-03f, 3.79597619e-02f, -1.88464541e-02f, 1.34026818e-02f, 5.15664555e-02f, -6.82958290e-02f, 1.71932206e-02f, 4.92926985e-02f,
  4.67147827e-02f, -4.11907025e-02f, -6.00136556e-02f, -5.52838631e-02f, -8.47003534e-02f, -7.58635998e-02f, 3.79082598e-02f, 5.83881326e-02f, -4.44699489e-02f, -5.17372563e-02f,
  4.70876209e-02f, -5.96946031e-02f, -4.67634313e-02f, -3.65517773e-02f, 6.52596727e-02f, 7.17238486e-02f, -1.66610945e-02f, -8.52658451e-02f, 3.94622795e-02f, -3.01895663e-02f,
  7.82079175e-02f, -4.48401682e-02f, 1.83779385e-03f, -6.39960989e-02f, 6.78013489e-02f, 1.68469921e-02f, -4.62261997e-02f, 7.14805350e-02f, -1.50711825e-02f, 4.98928204e-02f,
  -4.76562046e-02f, 5.16201230e-03f, -1.20840138e-02f, 2.46168785e-02f, 1.61453635e-02f, 4.77909297e-02f, 6.14214614e-02f, 4.62246910e-02f, -3.59452926e-02f, 1.41072702e-02f,
  1.54045783e-02f, 1.25550190e-02f, 8.96010101e-02f, -5.76589955e-03f, -3.88334654e-02f, -2.36637555e-02f, -1.83171630e-02f, 1.04532565e-03f, -5.72992042e-02f, 6.83921762e-03f,
  -6.32159933e-02f, -7.98301399e-02f, -3.11416145e-02f, -5.88455759e-02f, 1.24405818e-02f, -2.76564453e-02f, 8.82581547e-02f, -5.54711595e-02f, -3.87838967e-02f, -8.09136182e-02f,
  -2.91086286e-01f, -1.59153149e-01f, -6.26671836e-02f, -8.02960545e-02f, -1.38939626e-03f, 1.34774059e-01f, 3.66876908e-02f, 7.77945891e-02f, -4.25498150e-02f, -1.23898521e-01f,
  -3.97289731e-02f, 4.74816654e-03f, 1.96433552e-02f, -1.08636111e-01f, -7.45362267e-02f, -1.61916792e-01f, -6.05858676e-02f, -5.61562628e-02f, -5.80134466e-02f, 5.17213754e-02f,
  6.28858197e-06f, -1.80709437e-01f, -7.58120865e-02f, -3.18029150e-02f, -5.78845181e-02f, -4.70202975e-02f, 5.26330573e-03f, 9.84969549e-03f, 4.20687981e-02f, -1.91883162e-01f,
  -1.29041061e-01f, 6.72913506e-04f, 6.50622174e-02f, -1.21445164e-01f, 2.72433683e-02f, -2.32347623e-02f, 8.53827745e-02f, 6.60352483e-02f, 6.15188889e-02f, 7.13278577e-02f,
  -4.43483666e-02f, 9.27383825e-02f, 5.24495468e-02f, -4.19348218e-02f, 7.91638270e-02f, -7.19128624e-02f, 3.63535546e-02f, -7.21841902e-02f, 2.81690340e-02f, -9.58832633e-03f,
  8.27780291e-02f, -9.65016633e-02f, -1.69287369e-01f, 8.93023610e-02f, 9.42864418e-02f, 3.86423059e-02f, 3.32410187e-02f, 1.08510315e-01f, -8.39765072e-02f, -6.19244538e-02f,
  -1.87442470e-02f, 3.85123231e-02f, -6.21380359e-02f, 6.61279485e-02f, -2.88077667e-02f, 2.74507422e-02f, -8.02068859e-02f, -5.18348441e-02f, 6.44167960e-02f, 1.94300860e-02f,
  4.08756323e-02f, -8.34693611e-02f, 9.06725135e-03f, -7.16902241e-02f, -2.49213707e-02f, -6.90430328e-02f, -1.12631798e-01f, -1.08286478e-01f, -1.02248028e-01f, 8.10947046e-02f,
  -1.84512809e-02f, -5.16056307e-02f, 1.57544520e-02f, 2.81919856e-02f, -6.23781160e-02f, -9.00521234e-04f, -1.54561307e-02f, -4.36981432e-02f, -3.60185131e-02f, 1.15168639e-01f,
  -1.98748454e-01f, 5.91634437e-02f, -5.63854091e-02f, -1.01093307e-01f, 1.88862719e-02f, -5.26464581e-02f, -5.38856201e-02f, -2.37075798e-02f, 6.54492825e-02f, -1.75275444e-03f,
  8.26543495e-02f, -9.82311815e-02f, -8.02444518e-02f, -3.01812179e-02f, -1.26150288e-02f, 1.12234101e-01f, -1.28754020e-01f, -1.11105144e-01f, 5.22782877e-02f, -1.44023756e-02f,
  -8.06235448e-02f, -1.06300808e-01f, -1.26018018e-01f, -1.22494563e-01f, 9.20410156e-02f, -1.55887231e-01f, -8.08694139e-02f, -1.18210696e-01f, -3.95634398e-02f, -1.94977254e-01f,
  5.04505411e-02f, -1.24414101e-01f, -1.95286840e-01f, -3.31083941e-03f, -5.66164292e-02f, -1.22150913e-01f, -3.34297307e-02f, 4.21160087e-02f, 1.62174869e-02f, -1.55327931e-01f,
  3.98259684e-02f, 1.04791060e-01f, 2.71988790e-02f, -2.95040924e-02f, 1.42551465e-02f, -1.46126688e-01f, -1.07645944e-01f, -1.20218154e-02f, 7.99670964e-02f, 9.06626359e-02f,
  1.02649741e-01f, 3.80033925e-02f, 7.25213364e-02f, 9.51482952e-02f, 1.26326201e-03f, -4.55340482e-02f, -7.77473003e-02f, -1.40246019e-01f, 4.90164980e-02f, -2.49436364e-01f,
  -1.29283220e-01f, -1.09085009e-01f, -7.95089174e-03f, -6.78272769e-02f, -1.03207342e-01f, -1.37298517e-02f, -3.56785990e-02f, 5.27216680e-02f, 9.59779695e-02f, 1.49233919e-03f,
  -4.17748615e-02f, 6.72912747e-02f, 9.30918157e-02f, -6.29942939e-02f, -8.29808712e-02f, -1.52648725e-02f, 9.16989222e-02f, -8.82419348e-02f, -7.77051598e-03f, -2.21892018e-02f,
  -2.15427615e-02f, 3.27441134e-02f, 1.42960474e-02f, -2.58300230e-02f, 6.37304708e-02f, -3.30020972e-02f, -1.26560479e-01f, 3.18521149e-02f, 2.35083122e-02f, -6.30216449e-02f,
  -2.42261216e-02f, -3.66268679e-02f, -3.53607610e-02f, 2.65896000e-04f, -8.61556455e-03f, 2.80813337e-03f, -1.60924122e-02f, 1.01860110e-02f, -4.43183817e-02f, -5.37461899e-02f,
  8.01192075e-02f, -5.31764962e-02f, 3.78980152e-02f, 8.70133657e-03f, -1.07452989e-01f, 1.00142352e-01f, -1.69147737e-02f, -3.60769890e-02f, -4.05802764e-02f, -2.05697734e-02f,
  3.32725085e-02f, 4.88674007e-02f, -8.38251710e-02f, 1.59974908e-03f, 3.95678030e-03f, 3.95691358e-02f, -3.00393067e-02f, -8.75369553e-03f, 7.94043317e-02f, 8.56571943e-02f,
  2.90400274e-02f, 9.92836803e-03f, 3.12936194e-02f, 8.47579911e-02f, 1.32223302e-02f, -6.10563681e-02f, 5.35002872e-02f, -2.64853076e-03f, 5.10902330e-02f, 6.44257665e-02f,
  3.09966691e-02f, 3.72350961e-02f, 4.38129976e-02f, 5.26845120e-02f, -4.57848310e-02f, -3.64362774e-03f, 1.10754341e-01f, -4.83200932e-03f, -2.53424160e-02f, 5.10001667e-02f,
  -8.32178667e-02f, 6.15262017e-02f, -1.51767605e-03f, 1.87926833e-02f, -5.00185303e-02f, -5.95443398e-02f, 4.37537357e-02f, -4.84273508e-02f, 6.16556890e-02f, 2.86068451e-02f,
  4.07157660e-01f, -1.90871924e-01f, 1.88767850e-01f, 1.00882433e-01f, 5.01547456e-02f, 5.37268296e-02f, 1.20658271e-01f, 4.36678901e-02f, -5.95488735e-02f, -3.52154784e-02f,
  -9.20517594e-02f, -1.32058173e-01f, -1.74127042e-01f, -1.03993356e-01f, 1.67722609e-02f, 3.78609970e-02f, 9.44290869e-03f, 1.03755854e-01f, 9.38899443e-02f, 2.14128979e-02f,
  -1.36569813e-01f, -1.00184508e-01f, 6.54940531e-02f, 9.20248032e-03f, -6.89441338e-02f, 3.86626385e-02f, -1.08912192e-01f, -5.38806878e-02f, 5.95217086e-02f, -1.85070753e-01f,
  1.57353394e-02f, 1.80227667e-01f, 2.41250303e-02f, -3.70302089e-02f, -3.83810811e-02f, -2.78771129e-02f, 1.90210380e-02f, -6.48192987e-02f, 7.67925754e-02f, 4.27930616e-02f,
  -5.16045950e-02f, 1.03034871e-02f, -1.07306860e-01f, -9.36720520e-02f, 6.19772449e-02f, 4.71786074e-02f, 5.05948104e-02f, 3.12824659e-02f, -6.28909767e-02f, -2.34331917e-02f,
  -2.40268279e-02f, 1.25875428e-01f, 1.47850409e-01f, -3.33357006e-02f, -4.00854461e-03f, -6.48052692e-02f, 4.85570394e-02f, -6.01995876e-03f, 1.60803534e-02f, 3.05122379e-02f,
  1.39706973e-02f, -8.26941989e-03f, -4.13867645e-02f, -8.31954479e-02f, -8.92586187e-02f, -9.18074995e-02f, -5.63068762e-02f, 3.64908315e-02f, 3.46603952e-02f, 2.38545593e-02f,
  -1.26242131e-01f, -1.77312493e-02f, 2.75133103e-02f, -7.54969567e-02f, -3.61251552e-03f, 5.18804900e-02f, 6.80735037e-02f, 1.31404540e-02f, -1.81581359e-02f, -3.26045714e-02f,
  -6.19601458e-02f, 4.58986126e-02f, 5.32136969e-02f, -9.46300700e-02f, -8.40627626e-02f, -1.06578311e-02f, -8.92411824e-03f, -7.08713755e-02f, -1.38002485e-02f, 2.52153762e-02f,
  -1.37955144e-01f, 1.45702213e-01f, -7.69309998e-02f, -1.10183887e-01f, 9.05477814e-03f, -1.31089939e-02f, 4.41670343e-02f, -4.68738750e-02f, 1.89248789e-02f, -7.85598531e-02f,
  2.10865550e-02f, 8.63680318e-02f, -1.08194295e-02f, -4.60543334e-02f, -4.16362163e-04f, 5.23990691e-02f, -4.67396574e-03f, -2.61190031e-02f, -1.02938466e-01f, -5.91623411e-02f,
  -1.74247250e-01f, 2.77429335e-02f, -2.88959369e-02f, 3.33272703e-02f, 2.15098485e-02f, -3.77970934e-02f, -9.53599960e-02f, -3.01311966e-02f, -1.44665828e-03f, -9.25441552e-03f,
  8.73872917e-03f, 7.46143684e-02f, -1.41746143e-03f, 4.00430374e-02f, 8.38336647e-02f, -5.87737300e-02f, 4.94944938e-02f, -7.68561214e-02f, -6.22186400e-02f, 6.50392249e-02f,
  -4.01905216e-02f, -6.37304112e-02f, -9.39294919e-02f, -8.35421458e-02f, 7.03514069e-02f, 6.79315999e-02f, -4.85605113e-02f, 6.37204200e-02f, 4.45863744e-03f, 3.99108324e-03f,
  -8.64538699e-02f, 1.71995983e-02f, 4.66248281e-02f, 1.79238226e-02f, 3.72873992e-02f, 3.94874662e-02f, 4.82172593e-02f, -6.95212483e-02f, -8.02415907e-02f, -6.18881024e-02f,
  -9.06409323e-02f, 3.24475840e-02f, -8.67689773e-02f, -6.20009229e-02f, -5.66826984e-02f, 2.04471145e-02f, 6.08041473e-02f, -6.24598749e-02f, 3.65960831e-03f, 8.98458436e-02f,
  -9.97567899e-04f, 4.03340310e-02f, 3.86779197e-02f, -5.61119169e-02f, 4.53652814e-03f, -2.03725901e-02f, -2.93373093e-02f, -7.13831335e-02f, -4.52982336e-02f, -8.26181993e-02f,
  -8.24206471e-02f, 9.28120613e-02f, 4.00440171e-02f, 3.18613425e-02f, -1.76556818e-02f, 1.13300113e-02f, 2.93472447e-02f, -5.06543964e-02f, 2.37916093e-02f, 9.26789492e-02f,
  -7.96553269e-02f, -6.81656897e-02f, 6.13290444e-02f, 7.99196362e-02f, 5.22710234e-02f, -7.21273422e-02f, 8.81091654e-02f, 7.12531880e-02f, 8.79252423e-03f, 3.33579369e-02f,
  3.81013751e-02f, 3.48640345e-02f, 3.32355350e-02f, 9.44148302e-02f, 8.39715898e-02f, 2.93707475e-02f, -6.63730130e-03f, -7.26039261e-02f, 1.46198133e-02f, -9.10513103e-02f,
  9.52390768e-03f, -3.27871135e-03f, -3.25548947e-02f, 1.86369605e-02f, 9.91887152e-02f, -2.53965501e-02f, 6.52980357e-02f, 7.15459213e-02f, 7.02094957e-02f, 2.32639927e-02f,
  -7.69248009e-02f, -6.19857907e-02f, 5.15191890e-02f, 8.56731459e-02f, 1.04426071e-01f, -4.37113307e-02f, -6.21233322e-02f, 1.30582834e-02f, -6.34795651e-02f, -2.28117146e-02f,
  4.96435491e-03f, 7.88631514e-02f, -8.24910477e-02f, 1.04700752e-01f, 6.66823015e-02f, 6.13436773e-02f, -5.50752059e-02f, 6.01151474e-02f, -6.61811903e-02f, -4.52350415e-02f,
  7.83244371e-02f, 3.32980305e-02f, 9.06819254e-02f, 8.06873143e-02f, 5.61892912e-02f, 6.65619001e-02f, 3.12029906e-02f, -1.89640429e-02f, -1.62690766e-02f, 2.07531583e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.53574850e-02f, -7.97325522e-02f, 1.49586588e-01f, 1.31387729e-02f, 7.45062679e-02f, -1.03946894e-01f, -2.87806033e-03f, 1.70069262e-02f, 1.58485115e-01f, 1.47765994e-01f,
  6.70874864e-02f, 1.30271524e-01f, 1.66771263e-01f, 3.90788987e-02f, -1.14112208e-02f, -4.87725250e-02f, 2.66588122e-01f, 1.57095678e-02f, -4.75151315e-02f, 2.23071240e-02f,
  2.74202172e-02f, -1.67266093e-02f, 4.14130688e-02f, 2.04999834e-01f, 9.16080549e-02f, -5.97939603e-02f, 4.69702296e-02f, -2.17224453e-02f, -6.51936233e-02f, -2.82795224e-02f,
  3.98745239e-02f, 1.35388196e-01f, 1.40229732e-01f, 1.60281122e-01f, 6.01994283e-02f, 1.70309827e-01f, 6.05705827e-02f, 1.07767649e-01f, 2.31039897e-02f, 1.11113727e-01f,
  1.32128641e-01f, 2.07363129e-01f, 1.30073940e-02f, -9.38396528e-03f, 1.00814402e-01f, -3.30930054e-02f, -3.70896258e-03f, -5.88237345e-02f, -5.98163810e-03f, 1.51787594e-01f,
  1.96810275e-01f, 4.88012098e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.58654451e-01f, 5.89975528e-02f, -1.37864098e-01f, -8.75775814e-02f, 2.70523187e-02f, 1.05054282e-01f, -1.54024810e-01f, 1.70406457e-02f, -9.02418643e-02f, 1.87393621e-01f,
  -3.80855873e-02f, 8.23352039e-02f, 6.60833567e-02f, -1.04241833e-01f, -1.59382001e-01f, -9.87524688e-02f, -1.70944139e-01f, 8.56669098e-02f, -5.43126985e-02f, 1.32778049e-01f,
  1.94583312e-01f, -3.30177578e-03f, -5.20181060e-02f, 4.62161005e-02f, 9.45977420e-02f, 6.10308386e-02f, -1.63774267e-02f, -1.25175491e-01f, -1.31490335e-01f, -1.22761466e-01f,
  9.64563936e-02f, 1.18213966e-01f, -4.88602445e-02f, 2.22943183e-02f, -7.73381814e-02f, -5.84848002e-02f, -2.62497105e-02f, -1.62571803e-01f, 1.81266934e-01f, 1.00486040e-01f,
  5.73769361e-02f, 1.52255734e-02f, -1.84118792e-01f, -1.37434393e-01f, 8.44696164e-02f, -1.52881285e-02f, -1.20185547e-01f, -1.14223026e-01f, 1.25058383e-01f, 1.51492640e-01f,
  -1.58884376e-01f, -2.84409821e-02f, 2.04958066e-01f, 1.17838964e-01f, 6.23626113e-02f, 9.96077508e-02f, -2.15261392e-02f, 2.80463956e-02f, -2.04595417e-01f, -3.05768196e-02f,
  1.29825652e-01f, 9.71870944e-02f, -4.46770852e-03f, 5.67146316e-02f, 1.14285603e-01f, -5.38900122e-02f, -3.58456336e-02f, 6.38731336e-03f, -1.42308518e-01f, 1.18733726e-01f,
  -1.28889948e-01f, -4.18656617e-02f, -6.12071827e-02f, -1.91299841e-02f, 1.62979692e-01f, 2.23440051e-01f, -1.43881030e-02f, 9.12310630e-02f, -6.14570826e-02f, 8.08907896e-02f,
  -2.19982746e-03f, 7.58750737e-02f, -1.41334080e-03f, -6.99492618e-02f, -8.93824771e-02f, 6.33345619e-02f, 1.61294416e-01f, -9.49337427e-03f, -2.93948371e-02f, -1.50680274e-01f,
  8.29344690e-02f, 5.56984805e-02f, 2.79298425e-02f, -4.05650362e-02f, 1.37470871e-01f, -1.26700297e-01f, 4.38356213e-02f, 3.49650271e-02f, -1.04629546e-02f, -2.70396739e-01f,
  2.54570935e-02f, -1.38571123e-02f, 3.65471281e-02f, 8.75527710e-02f, -5.83728664e-02f, -9.87631679e-02f, 2.31539495e-02f, -1.52031198e-01f, 7.45666074e-03f, 1.25434980e-01f,
  9.09343213e-02f, -1.22801811e-01f, -9.82069671e-02f, 9.81514454e-02f, -1.30643579e-03f, -5.49744107e-02f, 1.62772066e-03f, -1.79657057e-01f, -7.75349736e-02f, 9.44099799e-02f,
  1.54753610e-01f, -2.38183979e-02f, -1.54377088e-01f, -3.85212228e-02f, 1.07299052e-01f, -1.15050480e-01f, 3.23599949e-02f, 7.54625425e-02f, -6.16621375e-02f, 3.91800515e-02f,
  -1.51899219e-01f, -1.89290777e-01f, -9.01132748e-02f, -1.60785653e-02f, -6.45156056e-02f, 3.31023112e-02f, -7.96724558e-02f, 9.25194006e-03f, -1.64265737e-01f, 3.94381620e-02f,
  1.72369312e-02f, -7.26055577e-02f, -5.79097904e-02f, -3.35843638e-02f, -1.45982474e-01f, -7.10118860e-02f, -1.27334535e-01f, -1.12860866e-01f, 1.07172206e-01f, 3.11495773e-02f,
  -5.66829704e-02f, -2.40906719e-02f, -5.07036410e-02f, 1.42026171e-01f, 9.20205191e-02f, -2.24809088e-02f, -4.23294306e-02f, -4.59352806e-02f, -6.14697114e-03f, 6.42516911e-02f,
  -1.16219141e-01f, 9.34621617e-02f, -2.09239051e-02f, -2.88538486e-02f, -1.54362977e-01f, -1.12246379e-01f, -7.70538896e-02f, -1.39458299e-01f, -6.79413453e-02f, 2.71136593e-02f,
  9.40034389e-02f, -1.34642184e-01f, 8.12872797e-02f, 2.93444581e-02f, 6.92269430e-02f, 1.13403000e-01f, 1.24259971e-01f, -9.04280245e-02f, -1.08977877e-01f, 7.68438913e-03f,
  1.12235576e-01f, 9.76643637e-02f, -3.38918157e-02f, -5.14450036e-02f, -3.85211259e-02f, -4.72902395e-02f, 8.17550998e-03f, -1.32684737e-01f, 1.33719906e-01f, 8.15730840e-02f,
  2.80996095e-02f, 4.21505421e-02f, -4.28294539e-02f, 5.12044765e-02f, -3.67294885e-02f, 2.02120692e-02f, 3.47053148e-02f, -8.68716240e-02f, -1.04255415e-03f, 1.99606836e-01f,
  2.02740207e-01f, -6.38740063e-02f, -1.62432447e-01f, -2.58059949e-01f, -6.77533746e-02f, -4.76265550e-02f, -6.68275431e-02f, -9.85620394e-02f, -1.10357463e-01f, -2.30590906e-03f,
  7.44401589e-02f, -3.84084061e-02f, -5.57902828e-03f, 1.05662920e-01f, -1.41293958e-01f, -1.58677563e-01f, -4.85149212e-02f, 5.23418821e-02f, 1.03279710e-01f, -4.16034572e-02f,
  -7.40536749e-02f, 5.87210581e-02f, -8.11083913e-02f, -2.74624508e-02f, 1.08848670e-02f, 8.55443627e-02f, 1.03060693e-01f, 2.67245412e-01f, 8.55750144e-02f, 7.22069805e-03f,
  -7.12543502e-02f, -6.38830215e-02f, 1.08543657e-01f, 7.51157477e-02f, -7.12669790e-02f, 1.19997986e-01f, 3.75748500e-02f, 8.41276348e-03f, 6.12197444e-02f, 9.51973945e-02f,
  -7.98824877e-02f, -1.21777393e-01f, 1.16906678e-02f, -6.18189387e-02f, 6.09823354e-02f, -1.60620300e-04f, 1.04259528e-01f, -1.30816057e-01f, -1.54164821e-01f, -7.77568610e-04f,
  4.56871763e-02f, -2.50311643e-02f, -4.65910770e-02f, 1.55502617e-01f, -1.79569516e-02f, 3.64921172e-03f, -4.42103203e-03f, -4.26801620e-03f, -5.41880541e-02f, -1.18290400e-03f,
  -5.80149516e-02f, 2.75573861e-02f, 5.54994754e-02f, 8.86575039e-03f, -5.57429008e-02f, 1.11766919e-01f, 1.32061809e-01f, -1.84844688e-01f, -6.36050031e-02f, 6.12458214e-02f,
  1.30026951e-01f, -1.41592428e-01f, 1.59108918e-03f, -8.26843604e-02f, 1.53710440e-01f, 8.34736973e-02f, 1.45823406e-02f, 1.40653610e-01f, -9.07783434e-02f, 2.38622129e-02f,
  1.08219959e-01f, 9.08730105e-02f, 4.33010720e-02f, -3.56593803e-02f, -2.40627646e-01f, 1.26008451e-01f, -1.20297089e-01f, -1.19642153e-01f, 3.04209944e-02f, -3.87242511e-02f,
  5.92479557e-02f, 1.85857549e-01f, 5.13480641e-02f, 1.71191677e-01f, 4.70165499e-02f, 1.13040954e-01f, -7.46234208e-02f, 1.39058784e-01f, -7.74407834e-02f, 1.04379304e-01f,
  7.22809732e-02f, 8.02673772e-02f, 1.41304638e-02f, 1.59837559e-01f, 1.06425695e-01f, 1.48930639e-01f, 1.15404129e-01f, 1.07367702e-01f, 6.96168616e-02f, 1.44446149e-01f,
  -2.43702698e-02f, 6.07806332e-02f, 1.41712233e-01f, -2.97189523e-02f, -8.66712828e-04f, 8.92377272e-02f, 1.79014444e-01f, -8.39669406e-02f, -2.18927428e-01f, -1.76097336e-03f,
  1.02737620e-01f, 5.41113317e-02f, -1.71521068e-01f, -1.68711871e-01f, 4.24665175e-02f, 1.75038993e-01f, -1.46877781e-01f, -1.34475946e-01f, -1.58110887e-01f, 1.55035391e-01f,
  1.04709022e-01f, -5.84674440e-03f, -1.82622373e-02f, 1.65554415e-02f, -1.26732275e-01f, 7.12253433e-03f, -1.18583784e-01f, 1.11952521e-01f, 1.34103745e-01f, 1.12621784e-01f,
  -1.27861546e-02f, -6.46781325e-02f, -9.16289389e-02f, 2.98895650e-02f, -2.40891464e-02f, 8.48147646e-02f, 1.05785474e-01f, -4.43986878e-02f, -1.86262354e-01f, 4.15324531e-02f,
  -3.87797803e-02f, -6.78839833e-02f, -4.79913540e-02f, -2.85724681e-02f, -8.47643390e-02f, 2.95618060e-03f, 2.63486858e-02f, 1.04188181e-01f, 4.50347252e-02f, -1.48195131e-02f,
  -1.07630625e-01f, -2.10837126e-02f, -5.14987968e-02f, -7.19863921e-02f, 1.08388461e-01f, -2.03304484e-01f, -1.26753733e-01f, 1.66772548e-02f, 1.82282224e-01f, 2.42118016e-02f,
  -1.20097503e-01f, -7.31864646e-02f, -9.52567682e-02f, -9.65395346e-02f, 3.71803381e-02f, 3.70498421e-03f, -6.64004013e-02f, -4.90413420e-02f, -8.41925815e-02f, -1.89347863e-02f,
  1.74770892e-01f, -4.31511030e-02f, -2.32792959e-01f, 9.40653905e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.47828793e-02f, -1.10691197e-01f, -8.22568312e-02f, -7.54336081e-03f, 6.92510605e-02f, -1.06489807e-01f, 7.50815794e-02f, 6.58805445e-02f, 2.02260148e-02f, 9.93830785e-02f,
  3.78813893e-02f, -1.37818351e-01f, -6.25885427e-02f, -3.41560505e-02f, 1.16226114e-01f, 1.00241713e-01f, -8.32210574e-03f, -7.08539784e-02f, -9.01786983e-02f, 7.64872134e-02f,
  7.73681700e-02f, -6.36165962e-02f, -3.80159095e-02f, 9.55517218e-02f, 2.00653151e-02f, -1.29159525e-01f, -8.19358155e-02f, -3.44973058e-02f, 4.37677018e-02f, -2.84565017e-02f,
  -3.95699367e-02f, 1.73591245e-02f, -5.34604900e-02f, -1.09447859e-01f, -1.26663167e-02f, -1.56675112e-02f, -8.72960240e-02f, -2.02302355e-02f, 1.96474418e-02f, -1.04069345e-01f,
  1.08262412e-02f, 6.68478087e-02f, -1.69961471e-02f, 2.81552114e-02f, 7.40189245e-03f, -5.75496852e-02f, -1.01933815e-01f, 1.03754491e-01f, -6.81622922e-02f, -5.89645375e-03f,
  1.26049101e-01f, 6.90485910e-02f, -2.24850494e-02f, 6.55145268e-04f, -4.14248789e-03f, -7.30864704e-02f, -6.66897222e-02f, -1.16950469e-02f, 1.04614891e-01f, 8.01585317e-02f,
  -1.12583153e-01f, -3.10108792e-02f, -2.10349425e-03f, 1.07160076e-01f, -2.67086849e-02f, 1.12676479e-01f, 1.06391989e-01f, -8.21297392e-02f, 7.09114447e-02f, -4.31874674e-03f,
  4.43480862e-03f, 1.14174433e-01f, -5.51932119e-02f, 9.58330780e-02f, 3.51439454e-02f, 1.17109470e-01f, 8.97901356e-02f, -1.08506819e-02f, 1.16743403e-03f, -1.10738844e-01f,
  5.33042476e-02f, -2.72416845e-02f, 8.44042450e-02f, -6.69214949e-02f, 1.85196966e-01f, -4.66678776e-02f, 1.56213373e-01f, 8.23612604e-03f, 6.27235621e-02f, 1.30856365e-01f,
  7.19515532e-02f, -7.68308714e-02f, 7.25469552e-03f, -5.62436245e-02f, -9.11614448e-02f, 1.13235582e-02f, 2.28782976e-03f, -2.73064133e-02f, 5.46468794e-02f, 5.86339869e-02f,
  -7.43564591e-03f, -1.25150457e-01f, 4.18164991e-02f, 3.20818499e-02f, 7.93816820e-02f, 5.74383438e-02f, -3.63683291e-02f, -1.48967886e-02f, 3.24283279e-02f, -6.70048520e-02f,
  1.06843255e-01f, 6.46382989e-03f, 1.70577928e-01f, 1.11888282e-01f, 2.90672644e-03f, -5.30211963e-02f, 4.09662090e-02f, 4.23435643e-02f, 9.75809917e-02f, 6.92705140e-02f,
  3.37033793e-02f, -3.21750864e-02f, 4.52979803e-02f, 5.47963902e-02f, 1.88969761e-01f, 1.48805991e-01f, 1.17193833e-01f, 2.39302404e-02f, 2.24633720e-02f, 2.32654102e-02f,
  -1.03511125e-01f, 6.83105662e-02f, 1.43555962e-02f, 5.34881167e-02f, -2.61104703e-02f, -1.22327827e-01f, -9.06483606e-02f, -1.08508363e-01f, 1.13430493e-01f, -1.30131498e-01f,
  -1.10304020e-01f, 8.92093852e-02f, 7.64581487e-02f, 3.32244933e-02f, -4.41114511e-03f, 3.03947479e-02f, -6.92426576e-04f, 6.18988276e-02f, 7.50651509e-02f, 7.37912059e-02f,
  6.44620582e-02f, -8.17632973e-02f, -4.70599234e-02f, 6.89248294e-02f, -5.60182258e-02f, 3.78059596e-02f, 4.01095711e-02f, -8.22722241e-02f, 1.17635489e-01f, 4.32319567e-02f,
  -5.62699549e-02f, 2.14973763e-02f, 2.65940055e-02f, -5.60859181e-02f, 6.10011676e-03f, -4.08052318e-02f, -6.51319046e-03f, -1.04423463e-01f, -8.07209164e-02f, 9.14653242e-02f,
  -8.43721330e-02f, -7.51889199e-02f, 1.74631514e-02f, 6.95575029e-03f, -3.22800167e-02f, 9.18218568e-02f, -1.05309719e-02f, 2.32896619e-02f, -8.31301212e-02f, -9.77466032e-02f,
  -1.06888376e-02f, -1.00727871e-01f, 1.21519797e-01f, -5.88095225e-02f, -7.48169720e-02f, -7.58101419e-02f, -1.15553746e-02f, 3.69509086e-02f, -4.67808098e-02f, -1.05369814e-01f,
  1.20332809e-02f, 1.13449372e-01f, -2.71243267e-02f, 1.55401468e-01f, 3.34014893e-02f, 9.69045162e-02f, 4.89750840e-02f, 1.67426184e-01f, -1.54655680e-01f, 1.42809778e-01f,
  1.23536699e-02f, -8.07263143e-03f, -1.51092917e-01f, -1.23625189e-01f, -7.48170316e-02f, -8.35979283e-02f, -4.40663993e-02f, 4.65446301e-02f, -1.09994590e-01f, -1.34387359e-01f,
  3.74990888e-02f, 8.72084200e-02f, 2.77792007e-01f, 8.89355242e-02f, -9.32202563e-02f, 1.49066508e-01f, -8.33449736e-02f, 2.21273378e-01f, -4.64030355e-02f, 3.55909988e-02f,
  -6.39042258e-02f, -1.75740775e-02f, -9.48636211e-04f, -1.04492577e-03f, -1.47274926e-01f, 7.67425373e-02f, 2.07920838e-02f, 3.95330116e-02f, 4.59488966e-02f, -1.16154023e-01f,
  7.75352940e-02f, -2.87832022e-02f, -6.66188076e-02f, 1.71100888e-02f, -1.26001984e-01f, -2.58682505e-03f, -1.94848850e-02f, -9.09614190e-02f, -1.02803290e-01f, 6.79994375e-02f,
  2.09747002e-01f, 8.94784108e-02f, -4.88481484e-02f, 1.34052306e-01f, 1.57188982e-01f, 2.94315606e-01f, -1.13653563e-01f, 1.06482759e-01f, -4.93202284e-02f, 9.39464197e-02f,
  -1.18447490e-01f, -4.38374542e-02f, 1.46949232e-01f, 9.94711593e-02f, -1.21789216e-03f, 4.90814038e-02f, 8.09833705e-02f, 2.86099780e-02f, -7.53793865e-02f, 5.79942092e-02f,
  -4.21643928e-02f, -5.89225963e-02f, -1.26018062e-01f, 5.84168024e-02f, 2.87828576e-02f, 4.32807095e-02f, 6.51915520e-02f, 2.00117398e-02f, 2.30772048e-02f, -6.39842972e-02f,
  1.94924641e-02f, 9.06120092e-02f, -2.20940448e-04f, 1.42692745e-01f, 1.04942344e-01f, 7.73085132e-02f, -7.75945932e-02f, 7.43063316e-02f, -3.04192491e-02f, 5.90158030e-02f,
  -6.74716979e-02f, 2.44051367e-02f, 4.20544855e-02f, 5.72128110e-02f, 5.24278544e-02f, -4.26158533e-02f, -9.42701753e-03f, -7.32151419e-02f, 1.32466719e-01f, -7.70758018e-02f,
  7.09043816e-02f, 6.73245220e-03f, 1.06511876e-01f, 5.39002866e-02f, -6.25323430e-02f, 1.23920105e-01f, 3.07565928e-02f, 6.70419913e-03f, 3.22197825e-02f, -3.71658169e-02f,
  -9.11214650e-02f, -7.45391920e-02f, -1.28821712e-02f, -8.09897557e-02f, -3.17078978e-02f, 2.61384957e-02f, 5.15423119e-02f, -2.37375870e-02f, 1.06507234e-01f, -1.16267622e-01f,
  1.11619987e-01f, 8.95974264e-02f, -5.54040857e-02f, -6.44921213e-02f, 4.46006544e-02f, -3.16524599e-03f, -8.43185931e-02f, -5.24884835e-03f, -6.46123141e-02f, 1.01448886e-01f,
  6.73938915e-02f, 1.18578589e-02f, 1.40618578e-01f, 4.65082340e-02f, 1.33975774e-01f, 7.87956044e-02f, 3.96054797e-02f, -1.03996217e-01f, 6.13145530e-02f, 9.11170989e-02f,
  -1.37532398e-01f, 2.27034599e-01f, -8.28034654e-02f, 5.62456734e-02f, 3.00337765e-02f, -8.40269327e-02f, 6.28095418e-02f, -6.12711869e-02f, 9.99950841e-02f, -1.13895364e-01f,
  -4.82931212e-02f, 9.41680819e-02f, 1.03030153e-01f, -5.67433313e-02f, -4.27310131e-02f, 6.95020482e-02f, 1.28462777e-01f, 1.80812851e-02f, -5.82625121e-02f, 2.36887820e-02f,
  8.69384035e-02f, -9.15639699e-02f, 2.61103269e-02f, 4.47116420e-02f, 4.09902819e-02f, -1.79366574e-01f, -6.62041968e-03f, -8.74918401e-02f, -6.70727491e-02f, 5.64375632e-02f,
  -5.44625856e-02f, -1.03666060e-01f, 1.13499448e-01f, 1.18619837e-01f, -8.49397201e-03f, -1.14093665e-02f, -5.56566659e-03f, 5.80174774e-02f, 1.97786391e-02f, -4.00665402e-02f,
  -6.87908009e-02f, 3.25414375e-03f, -2.68585049e-02f, -1.49269132e-02f, -3.16094756e-02f, -8.31020176e-02f, -2.88477838e-02f, 1.15932524e-01f, -1.01523481e-01f, -1.63793992e-02f,
  7.12483153e-02f, -1.17636085e-01f, 1.51866734e-01f, -2.32234262e-02f, 1.39814720e-01f, -1.00251295e-01f, -2.49364190e-02f, -2.86479481e-02f, 1.21919112e-02f, 7.42473602e-02f,
  1.55184805e-01f, 3.48712951e-02f, 1.36142045e-01f, -1.00432843e-01f, -7.34894276e-02f, -1.84468985e-01f, 5.90497553e-02f, 1.08500339e-01f, 8.25193077e-02f, 1.10477977e-01f,
  -6.45758286e-02f, 9.19964686e-02f, 1.32656813e-01f, -9.61584132e-03f, -8.77503306e-02f, 6.31188229e-02f, -9.98427272e-02f, -1.92209668e-02f, 1.23867616e-01f, -1.45159915e-01f,
  -2.51394734e-02f, 2.82639042e-02f, -2.55061556e-02f, -4.24119979e-02f, 5.46933971e-02f, 3.75265330e-02f, 1.99665986e-02f, 2.48060059e-02f, 1.23514116e-01f, 1.70960471e-01f,
  -3.57421637e-02f, 6.67223334e-02f, 3.50407697e-02f, -1.44158807e-02f, 5.05000260e-03f, 1.57598063e-01f, -7.81108886e-02f, 8.27558935e-02f, 9.23724696e-02f, 8.34140629e-02f,
  4.88906801e-02f, 3.46520804e-02f, 2.24737953e-02f, 8.30338374e-02f, 7.05822706e-02f, 1.34997204e-01f, -1.16963983e-01f, 3.51411477e-02f, 8.27196389e-02f, 4.82968912e-02f,
  2.91686170e-02f, -2.93484377e-03f, 9.58507061e-02f, -3.42571251e-02f, 3.25416774e-02f, 6.33281767e-02f, 3.42332721e-02f, -1.17973804e-01f, 1.45716488e-01f, 5.10543920e-02f,
  1.19634017e-01f, 1.06272899e-01f, -1.74436793e-01f, 7.48481229e-02f, 1.65282130e-01f, -1.69076063e-02f, -6.95005134e-02f, 1.35588109e-01f, 1.05202839e-01f, -2.28980854e-02f,
  -6.36406317e-02f, 3.31408679e-02f, 1.19971678e-01f, 2.17688948e-01f, 1.52552530e-01f, -6.42897710e-02f, 1.90338612e-01f, -8.83736908e-02f, 1.07731521e-01f, 5.39655164e-02f,
  8.30787048e-02f, 1.23722153e-02f, 1.18968464e-01f, -4.85017262e-02f, 2.19621579e-03f, -7.37383589e-02f, 4.91160117e-02f, -5.68753928e-02f, 1.26628712e-01f, 4.50688526e-02f,
  -4.40465026e-02f, -3.54999267e-02f, 6.85510933e-02f, -5.72846830e-02f, 1.79501131e-01f, 1.33966506e-01f, -2.95719635e-02f, 1.03392676e-01f, -3.72587629e-02f, 1.07236207e-02f,
  7.87399933e-02f, 1.39468461e-01f, -1.10486202e-01f, 4.08553243e-01f, 1.17103472e-01f, -5.12690879e-02f, -1.17387496e-01f, 2.48246342e-02f, -4.25305292e-02f, -2.54900344e-02f,
  -7.43598714e-02f, 5.29223643e-02f, -6.24862947e-02f, 7.86889251e-03f, 1.86052471e-01f, 1.09405257e-01f, -5.26596680e-02f, -6.68923706e-02f, -5.96460886e-02f, -7.19163045e-02f,
  8.20579454e-02f, 6.93234503e-02f, 6.34065717e-02f, 1.22973863e-02f, 3.26432772e-02f, 1.55297637e-01f, -2.05545947e-02f, -1.20503819e-02f, -1.34209823e-02f, 9.50629413e-02f,
  1.28762618e-01f, 4.13697623e-02f, -2.31450543e-01f, -8.58301148e-02f, 1.68218195e-01f, -3.32875699e-02f, -1.50012910e-01f, -1.10309675e-01f, -1.15324995e-02f, -2.22483184e-03f,
  7.49421073e-03f, 4.31822836e-02f, 1.37472376e-01f, -9.93076712e-02f, 9.96328369e-02f, 2.42904276e-02f, -1.16965272e-01f, 1.61055878e-01f, -1.68072022e-02f, 5.25205918e-02f,
  9.90264416e-02f, -4.30281051e-02f, 7.11560994e-02f, 1.08563498e-01f, -1.21709846e-01f, -7.85022229e-02f, -3.97560187e-02f, -1.69280861e-02f, 8.63715261e-02f, 1.44389763e-01f,
  -6.71855807e-02f, 9.61199496e-03f, 9.21272188e-02f, 1.02807179e-01f, 1.81288533e-02f, 1.53126419e-01f, 1.13342687e-01f, 2.63317041e-02f, -1.22795543e-02f, 1.41443908e-01f,
  7.58666694e-02f, 4.18534912e-02f, 1.89711228e-01f, 1.18440270e-01f, 9.78706032e-02f, 2.37534121e-01f, 1.65195856e-02f, -1.49155855e-01f, -1.25810429e-01f, 5.87369055e-02f,
  7.38828033e-02f, 7.87168220e-02f, -6.61829710e-02f, 9.51398462e-02f, 1.02375887e-01f, -7.28775710e-02f, 8.60188678e-02f, 9.32899714e-02f, 1.43616706e-01f, 1.56883359e-01f,
  9.74983424e-02f, -3.23260576e-02f, -4.41195518e-02f, 2.54732259e-02f, 1.71749741e-01f, -8.19238648e-02f, -1.65500835e-01f, -1.26381353e-01f, -3.52867059e-02f, -9.09983590e-02f,
  2.23172810e-02f, -5.42061888e-02f, -1.23827150e-02f, -4.57056165e-02f, -8.60048532e-02f, -3.86544839e-02f, -1.11099355e-01f, 1.22528791e-01f, -1.13870025e-01f, 5.35744056e-03f,
  1.76212506e-03f, 4.11336273e-02f, 1.32725120e-01f, -1.26344645e-02f, -6.07167110e-02f, -7.76887760e-02f, 7.82495961e-02f, -6.66185841e-02f, 1.41796201e-01f, -8.12579021e-02f,
  3.42042893e-02f, 2.02286035e-01f, -3.89536284e-02f, -3.01425289e-02f, 4.29841541e-02f, 8.08407217e-02f, -5.71858473e-02f, -9.77855325e-02f, -8.25387761e-02f, 6.11519720e-03f,
  6.10042438e-02f, -8.98999199e-02f, 1.64647512e-02f, -1.17811211e-03f, -4.30566296e-02f, 5.78346886e-02f, 6.82736188e-02f, 1.25722408e-01f, 6.67663738e-02f, 1.25361770e-01f,
  -6.67562932e-02f, 3.59067060e-02f, -9.05881673e-02f, 4.60318774e-02f, -9.55303386e-02f, 8.11014250e-02f, -8.50094035e-02f, -3.20877507e-02f, 6.07969090e-02f, -8.37205723e-02f,
  8.49776436e-03f, -8.15346241e-02f, 1.00807160e-01f, 1.10319536e-03f, -6.14408962e-02f, -3.01241912e-02f, -1.90848839e-02f, 3.14494334e-02f, 6.15413710e-02f, 1.62873026e-02f,
  1.19777411e-01f, 7.12471232e-02f, -8.10105205e-02f, 8.95462707e-02f, -2.54671369e-02f, 7.94629604e-02f, 1.49600031e-02f, -6.90111965e-02f, -4.76683900e-02f, 1.30997553e-01f,
  -9.79925692e-02f, -4.73154932e-02f, -7.91711137e-02f, -5.62639721e-02f, 7.72381797e-02f, -1.06610999e-01f, 9.82018188e-02f, 8.10207427e-02f, 1.01353101e-01f, 1.78536512e-02f,
  -4.78817597e-02f, 3.69378924e-02f, -7.99012780e-02f, 4.51535471e-02f, 4.02465537e-02f, 1.54371336e-01f, -4.67917435e-02f, 4.52440567e-02f, 4.92960401e-02f, -2.87535079e-02f,
  6.73218369e-02f, -1.00036502e-01f, -1.05519317e-01f, -3.69327776e-02f, 1.18088566e-01f, -1.58620119e-01f, 9.50550437e-02f, 3.38755995e-02f, -9.27987695e-02f, 9.65495631e-02f,
  -1.27222622e-03f, -6.10720851e-02f, -9.38123614e-02f, 7.87517279e-02f, 6.93773925e-02f, -1.10752489e-02f, -9.42224229e-04f, 7.95271620e-03f, 7.24338554e-03f, -4.52981591e-02f,
  -9.79643464e-02f, 6.55651167e-02f, 8.66695493e-02f, -1.45965926e-02f, 2.42456004e-01f, 1.24416210e-01f, 6.63603246e-02f, 3.95588763e-02f, 1.05216205e-01f, 1.02222122e-01f,
  -1.01421304e-01f, -5.89422137e-02f, -2.11800680e-01f, 1.43312305e-01f, 8.33410174e-02f, 1.17567085e-01f, 1.02383107e-01f, -1.25887524e-02f, -1.08229749e-01f, -3.21686920e-03f,
  -1.00618094e-01f, 4.82985936e-02f, 7.80072138e-02f, -3.18403505e-02f, -1.12247579e-01f, -1.11511489e-02f, 3.06176580e-02f, 1.44665197e-01f, 7.30073676e-02f, 6.45956248e-02f,
  1.03962578e-01f, 6.55306652e-02f, -1.20239533e-01f, 8.19704831e-02f, -1.20764419e-01f, -2.07384955e-02f, 1.04078345e-01f, -1.44531682e-01f, 2.07282100e-02f, -1.10776462e-01f,
  -2.97822263e-02f, 7.34431809e-03f, -7.12031201e-02f, 5.10242693e-02f, -3.02481442e-03f, 1.30566761e-01f, 1.21550024e-01f, -2.47656126e-02f, 7.61443973e-02f, 1.42216403e-02f,
  1.28260395e-02f, 1.01272568e-01f, -6.56438693e-02f, -4.58264090e-02f, 2.37390101e-02f, -7.10868388e-02f, -1.27973750e-01f, -7.56287947e-02f, -9.66896340e-02f, 9.16161686e-02f,
  1.37277573e-01f, 5.45332655e-02f, -1.04133092e-01f, -2.61266921e-02f, 1.01749018e-01f, -2.95180865e-02f, 1.24806248e-01f, -7.82452375e-02f, 6.92286640e-02f, -2.16047727e-02f,
  -1.03408232e-01f, -1.29731461e-01f, -1.98270176e-02f, 6.09383062e-02f, -1.09009758e-01f, 5.31231165e-02f, -1.08712554e-01f, 1.02350796e-02f, 8.15206096e-02f, 7.45003000e-02f,
  5.13358004e-02f, 4.37992997e-02f, 1.27314962e-02f, -9.11880434e-02f, -1.08348168e-01f, -2.88444366e-02f, 5.82233258e-02f, -2.40594558e-02f, 9.94437039e-02f, 1.05608823e-02f,
  1.18641764e-01f, -2.50500701e-02f, -2.04271413e-02f, -1.86184160e-02f, 6.50074854e-02f, -1.06968120e-01f, -1.19490400e-01f, -7.84018040e-02f, -5.93778025e-03f, 3.86607572e-02f,
  -9.38041434e-02f, -1.20616212e-01f, 1.49527201e-02f, -5.98569773e-02f, -1.26930540e-02f, -4.52427156e-02f, -1.09442420e-01f, -1.24215588e-01f, 2.44803820e-02f, -2.26299670e-02f,
  -4.35680784e-02f, -1.12232633e-01f, -2.15785019e-03f, -8.46418142e-02f, 5.57008758e-03f, 8.54256973e-02f, -1.13864057e-01f, 1.14357911e-01f, 4.74944450e-02f, 6.53335005e-02f,
  -2.55444553e-02f, 4.07819375e-02f, -8.75300393e-02f, 6.94401711e-02f, -7.48987019e-04f, -1.33742038e-02f, 2.94451844e-02f, -2.18403731e-02f, 6.26894608e-02f, -1.13023691e-01f,
  3.10682715e-03f, -1.31434072e-02f, 7.95907900e-02f, 6.54253960e-02f, -2.08320445e-03f, -1.08338907e-01f, -3.59901763e-03f, 3.64700258e-02f, 7.92348906e-02f, -4.02043399e-04f,
  -1.15646847e-01f, 7.41146356e-02f, 4.14741561e-02f, -1.02469489e-01f, 8.10883865e-02f, -1.88729388e-03f, -1.23835333e-01f, 4.79141772e-02f, -7.23293573e-02f, 6.61179200e-02f,
  8.40329677e-02f, 1.33488446e-01f, -9.70307887e-02f, -8.82557943e-04f, -6.13795668e-02f, -5.21710850e-02f, 6.45175762e-03f, -1.10340051e-01f, -3.41601148e-02f, 2.95890123e-02f,
  4.04669754e-02f, -2.39865258e-02f, -6.54832553e-03f, 8.79765302e-02f, 7.37584978e-02f, -1.42753318e-01f, -5.19440398e-02f, -4.23011780e-02f, -1.16128482e-01f, -4.47618999e-02f,
  6.21120259e-02f, 9.70591009e-02f, -9.62973163e-02f, -8.06008801e-02f, 3.07575967e-02f, -2.64500435e-02f, -1.69867761e-02f, -1.13208130e-01f, -1.59956831e-02f, -5.30935302e-02f,
  -1.88209638e-02f, 3.91211361e-02f, -9.17836204e-02f, 1.09592974e-01f, -1.93754991e-03f, -2.51501845e-03f, -2.86393184e-02f, 9.27784145e-02f, 8.82755294e-02f, 8.34672377e-02f,
  -1.02173932e-01f, 8.45253989e-02f, -6.29012585e-02f, -7.50362501e-02f, -3.97081897e-02f, 8.23547617e-02f, 1.50817037e-01f, 1.61510885e-01f, 8.51429701e-02f, 1.35184914e-01f,
  -1.43792436e-01f, 1.44582465e-01f, 5.23219779e-02f, 6.98590372e-03f, -1.04836613e-01f, 1.63419172e-01f, -3.54808196e-02f, -1.61629066e-01f, 1.70935005e-01f, -7.08537176e-02f,
  9.50846598e-02f, -6.59826547e-02f, 1.15690477e-01f, -3.14457640e-02f, 2.21294582e-01f, -7.51968622e-02f, 1.18109114e-01f, -1.06724901e-02f, 2.30888456e-01f, 1.11020543e-01f,
  8.56870692e-03f, 1.97464645e-01f, 1.13338893e-02f, -9.00218412e-02f, -1.04693271e-01f, 9.86470953e-02f, -8.36007856e-03f, 1.17388599e-01f, -2.81641502e-02f, -1.05393931e-01f,
  -2.29017716e-02f, -3.63100134e-02f, 1.35380998e-01f, 1.27209742e-02f, -5.03566563e-02f, 1.91782098e-02f, -6.19166642e-02f, 1.26900245e-02f, 4.98176292e-02f, -5.28610498e-02f,
  -1.03615835e-01f, 3.36972445e-01f, 3.17740962e-02f, 1.05814353e-01f, 2.06136152e-01f, 1.75373524e-01f, -2.50937324e-02f, -9.41086113e-02f, 1.90723658e-01f, 4.97718379e-02f,
  6.31102994e-02f, 8.31238329e-02f, -5.02530532e-03f, -6.38125986e-02f, -1.17875315e-01f, -8.42541009e-02f, 1.14527084e-01f, 6.97250217e-02f, -1.04219522e-02f, 3.14989723e-02f,
  1.13382988e-01f, 9.34980363e-02f, -1.01641808e-02f, -3.99216972e-02f, 1.41850173e-01f, 6.42994568e-02f, 6.89137205e-02f, -1.00588202e-01f, -1.77130699e-02f, -9.11526754e-02f,
  7.43643343e-02f, 4.72365133e-02f, -2.50030980e-02f, 4.26082052e-02f, 1.28736133e-02f, 8.37792233e-02f, 1.23813026e-01f, 4.99084964e-02f, -6.63472041e-02f, -9.52455178e-02f,
  2.96790209e-02f, -7.26548433e-02f, 7.88233951e-02f, 9.85800400e-02f, -4.19680923e-02f, 1.20386176e-01f, -9.42315087e-02f, -2.32498273e-02f, 2.92005260e-02f, -5.14488667e-02f,
  1.31787926e-01f, 6.09614775e-02f, -9.92059484e-02f, -8.56608674e-02f, 6.96148500e-02f, -1.01185761e-01f, 1.02690041e-01f, -8.21657553e-02f, -1.08864143e-01f, 1.08795121e-01f,
  7.82758370e-02f, 6.81165904e-02f, -7.48106018e-02f, -2.26886682e-02f, -4.43228930e-02f, 1.45634422e-02f, -9.08716321e-02f, -1.01434886e-01f, -2.00516470e-02f, 1.17093273e-01f,
  1.16198465e-01f, 2.28753556e-02f, 3.03980149e-02f, -3.29776444e-02f, 1.20972581e-01f, 1.20635435e-01f, 9.72120315e-02f, -2.28327829e-02f, -8.68516639e-02f, -5.70880286e-02f,
  1.24236075e-02f, 9.99634042e-02f, 8.66663083e-02f, -9.54911783e-02f, 2.01099277e-01f, 3.64816904e-01f, 2.64584750e-01f, 2.35832602e-01f, 1.76850319e-01f, 8.97011161e-02f,
  1.30033359e-01f, 2.17993394e-01f, -7.32378438e-02f, -2.89823301e-02f, -2.15783834e-01f, -5.00902124e-02f, 3.06192378e-04f, -1.05793253e-01f, -1.06043808e-01f, 1.13255903e-01f,
  1.46149352e-01f, -1.41548738e-01f, -1.05593234e-01f, -1.53164461e-01f, 2.17268825e-01f, 8.66673887e-02f, 2.91178763e-01f, 3.81148756e-02f, -8.42543021e-02f, 2.35324606e-01f,
  -1.42179295e-01f, -1.91024855e-01f, 3.51094127e-01f, -2.48003304e-02f, 9.05577019e-02f, 8.12195912e-02f, -1.13127947e-01f, -1.03028543e-01f, -2.39824951e-01f, 5.80075197e-03f,
  8.45058858e-02f, -1.33411765e-01f, -1.23502158e-01f, -3.44056189e-02f, 1.64679751e-01f, -1.89009383e-01f, -5.34657352e-02f, 2.92979747e-01f, -7.11086392e-02f, 4.54169095e-01f,
  2.56271008e-02f, -2.09502071e-01f, -8.41103960e-04f, -1.24223500e-01f, 1.87329233e-01f, 1.62307084e-01f, 9.31755006e-02f, 9.92667079e-02f, -9.10911709e-02f, -6.48433641e-02f,
  -5.73702082e-02f, 1.15216129e-01f, -5.74984262e-03f, 3.49309668e-02f, 4.17576805e-02f, 2.07374871e-01f, 2.55841017e-01f, 1.60201341e-01f, 3.87400202e-02f, 7.51706734e-02f,
  1.78872377e-01f, 1.08095624e-01f, -1.49254888e-01f, -2.67050415e-02f, 7.72688165e-02f, 9.86703858e-02f, -3.01461015e-02f, 3.48574645e-03f, -1.69315398e-01f, -1.63736209e-01f,
  2.14508191e-01f, -1.15811713e-01f, -1.01659082e-01f, 5.12595028e-02f, -1.00868857e-02f, -1.44495994e-01f, 6.74143657e-02f, -8.71500447e-02f, 3.13830465e-01f, -6.76217452e-02f,
  1.78583577e-01f, -1.29715249e-01f, 4.52341996e-02f, 2.70559967e-01f, 3.61273140e-02f, -1.22626424e-01f, -1.60890017e-02f, -1.23088807e-02f, -5.62827587e-02f, 6.94794059e-02f,
  -5.65920770e-02f, -1.68401197e-01f, -7.79291987e-02f, -1.03459597e-01f, 4.15817648e-02f, 1.48056954e-01f, -7.45129436e-02f, -4.55950908e-02f, 1.60201922e-01f, -1.14709800e-02f,
  6.81635216e-02f, 2.36504272e-01f, 7.47306943e-02f, 1.50424629e-01f, -1.66175757e-02f, -3.21378820e-02f, 1.28095344e-01f, 4.97011393e-02f, 1.96865365e-01f, 1.41192541e-01f,
  -1.27324043e-02f, 2.39263475e-01f, 8.05210769e-02f, -1.06504103e-02f, 1.37199620e-02f, 4.05503763e-03f, -5.82850091e-02f, 1.02378158e-02f, 1.53457403e-01f, 1.87608421e-01f,
  1.21565178e-01f, -1.34862363e-01f, 8.38893801e-02f, 1.11363657e-01f, -7.96580538e-02f, 2.89980024e-02f, -8.53050798e-02f, 9.69922915e-03f, 1.08729452e-01f, 8.08697566e-02f,
  -6.87635839e-02f, -7.82429986e-03f, 1.63421839e-01f, 3.92357223e-02f, -8.39102119e-02f, 1.10043712e-01f, 1.58950567e-01f, 9.08446833e-02f, -3.01055051e-02f, -1.02306856e-02f,
  2.01258227e-01f, 1.11818798e-01f, 2.94869356e-02f, -7.89585933e-02f, -1.64086875e-02f, -9.37991068e-02f, 5.63480742e-02f, 1.82741247e-02f, 9.98606831e-02f, -1.33425519e-02f,
  -8.01058114e-02f, 8.76212418e-02f, 5.19106165e-02f, -1.90158412e-02f, -2.93199345e-02f, 1.28222153e-01f, 1.27417266e-01f, 1.08956620e-01f, -7.26376548e-02f, 1.79089040e-01f,
  -3.63854412e-03f, -1.40579129e-02f, 3.80945913e-02f, -4.83477674e-02f, -4.74219471e-02f, -4.13209945e-02f, -6.09235615e-02f, -2.95077264e-02f, -9.11073461e-02f, 5.95496558e-02f,
  5.69233485e-02f, -5.28193600e-02f, -7.63821900e-02f, 9.17373896e-02f, 2.32657255e-03f, 7.17928857e-02f, -2.36487109e-02f, -1.91983264e-02f, 1.05095536e-01f, -1.17792144e-01f,
  1.46499902e-01f, 2.56352760e-02f, -4.93112803e-02f, -1.20954759e-01f, -6.71029761e-02f, 1.03505835e-01f, 1.80885464e-01f, 6.90482333e-02f, 1.12400435e-01f, 1.60034120e-01f,
  -1.90780103e-01f, 2.48604249e-02f, 1.66310474e-01f, -1.25716463e-01f, 4.64411676e-02f, 1.21153899e-01f, 1.22795671e-01f, 1.42228886e-01f, -1.11620359e-01f, -3.63927037e-02f,
  9.46630761e-02f, 1.58518538e-01f, 1.42071992e-01f, 1.14250168e-01f, 2.57369787e-01f, -1.34936616e-01f, 1.33057386e-02f, 1.37405202e-01f, 4.53183129e-02f, -5.92392385e-02f,
  3.74978967e-02f, -6.10917248e-02f, -1.47486106e-01f, -1.19110487e-01f, -5.74927963e-02f, -9.81374383e-02f, -2.37277094e-02f, 7.25186169e-02f, -5.35375206e-03f, 6.58521354e-02f,
  3.35672237e-02f, -1.23091616e-01f, 6.24750964e-02f, 3.19189169e-02f, 1.31349370e-01f, 1.69178024e-01f, -3.26675512e-02f, 1.26076669e-01f, 1.43764671e-02f, -1.36010781e-01f,
  7.16470182e-02f, 4.23967898e-01f, 5.47597650e-03f, 7.88134187e-02f, -8.00359473e-02f, 1.36538908e-01f, -1.25863089e-03f, -1.47661835e-01f, -7.14363158e-02f, -4.39552628e-02f,
  1.28724381e-01f, 2.70810593e-02f, 1.93312496e-01f, 5.72508387e-02f, 1.30937546e-01f, 6.26156703e-02f, 9.89075080e-02f, -1.18023276e-01f, 6.57649338e-02f, -9.66729075e-02f,
  6.92297593e-02f, 3.49413268e-02f, 1.65508181e-01f, 1.73727766e-01f, 1.06313579e-01f, -5.66181503e-02f, 8.06955993e-02f, -6.81637004e-02f, 1.62937865e-02f, 1.14428610e-01f,
  -3.48885059e-02f, 2.29041487e-01f, -6.60276785e-02f, -1.01148136e-01f, 1.32704616e-01f, 1.59005046e-01f, 1.36980072e-01f, 1.00182712e-01f, -1.77148506e-02f, -1.17498197e-01f,
  5.70729375e-02f, 2.38373056e-02f, 1.52936608e-01f, 1.27465948e-01f, 1.04684509e-01f, -1.06845377e-02f, 7.27728531e-02f, -5.12187183e-02f, 1.08908162e-01f, -6.63356707e-02f,
  -8.75615925e-02f, 1.05912149e-01f, -1.55826032e-01f, -3.49043459e-02f, -1.05137125e-01f, -8.52639228e-02f, -2.02428978e-02f, 1.39017794e-02f, 8.33261684e-02f, 5.20529076e-02f,
  1.52616918e-01f, -4.30745631e-02f, -4.95654047e-02f, 1.26334012e-01f, -1.49648964e-01f, 3.00217450e-01f, -5.56475148e-02f, -1.37754858e-01f, 1.44553045e-02f, 1.21188566e-01f,
  -7.69598931e-02f, -8.30682963e-02f, 9.44171101e-02f, -8.90399292e-02f, 1.36612803e-01f, -7.47972652e-02f, 9.04613361e-02f, -9.37384889e-02f, 6.94394410e-02f, 7.20450208e-02f,
  -2.14436091e-02f, 3.12520601e-02f, 6.01901785e-02f, -2.19597016e-02f, -1.13432913e-03f, -5.67328632e-02f, 1.54381409e-01f, 1.70577958e-01f, 1.28878713e-01f, 3.66867357e-03f,
  1.20456465e-01f, 1.11815102e-01f, 6.14301153e-02f, -1.26438528e-01f, -1.44276291e-01f, -6.30757436e-02f, -9.15187299e-02f, 2.34175287e-02f, 6.01076968e-02f, 2.11078525e-02f,
  9.75431725e-02f, 1.06099673e-01f, -6.03436790e-02f, 6.53761402e-02f, 5.76429144e-02f, -1.09673560e-01f, 1.14788122e-01f, -2.02463660e-02f, -5.14717400e-02f, -5.02798818e-02f,
  -5.92080168e-02f, 8.63798335e-02f, 2.17173621e-01f, 1.17571406e-01f, 2.91686486e-02f, -6.44033626e-02f, -7.44115561e-02f, -1.15887545e-01f, -9.27035660e-02f, 1.37849241e-01f,
  -3.09896879e-02f, 1.14674084e-01f, -1.18351407e-01f, 1.12323083e-01f, -1.92193110e-02f, -1.11857757e-01f, -2.42763460e-02f, 1.23056676e-02f, 9.17153656e-02f, 1.24314561e-01f,
  6.49754480e-02f, -1.00631788e-01f, 7.41427317e-02f, 1.12125479e-01f, -9.19130817e-02f, 1.10667333e-01f, 2.72129048e-02f, 7.23869950e-02f, 6.03797100e-02f, -1.45168483e-01f,
  -3.73044275e-02f, -4.64855582e-02f, -6.27837479e-02f, -5.67995496e-02f, -1.49687588e-01f, 5.41878454e-02f, 1.92071363e-01f, -8.84443801e-03f, 9.05194283e-02f, 1.69156343e-01f,
  1.45684600e-01f, 1.21490099e-01f, 2.41158709e-01f, 1.07780576e-01f, -5.17266802e-02f, 2.17137896e-02f, 1.06888689e-01f, -1.48523137e-01f, -3.42990346e-02f, -6.03016540e-02f,
  -6.39720680e-03f, 5.81234321e-03f, -1.08677015e-01f, 4.64715138e-02f, -2.33263914e-02f, -1.08782530e-01f, 9.07896534e-02f, 1.40027612e-01f, -1.02986261e-01f, 1.09460361e-01f,
  -6.44702986e-02f, 1.13156289e-02f, 1.34084150e-01f, -4.06414680e-02f, 7.64943585e-02f, 1.14702500e-01f, 7.89133981e-02f, 1.94762778e-02f, 4.57382388e-02f, -8.25920776e-02f,
  5.75002730e-02f, -1.64315142e-02f, 5.18102050e-02f, 1.58774570e-01f, -3.25177945e-02f, 8.86359140e-02f, 1.17218778e-01f, -1.12341389e-01f, 9.24973041e-02f, 6.72449097e-02f,
  -1.03338130e-01f, 1.73860956e-02f, 1.01110108e-01f, -1.88833326e-01f, 4.31157537e-02f, -2.61057448e-02f, 8.96580145e-02f, -1.05694689e-01f, -4.66739908e-02f, 1.71309650e-01f,
  -1.86675880e-02f, 2.04303622e-01f, 9.33113396e-02f, 8.33707489e-03f, -7.65543655e-02f, -1.20986626e-01f, 5.11254705e-02f, -1.55589934e-02f, 7.65522271e-02f, 1.09919913e-01f,
  8.94702598e-02f, 1.38414726e-01f, 1.80763617e-01f, 6.87359050e-02f, 7.64781535e-02f, -2.71422118e-02f, -1.06622986e-01f, 9.03694630e-02f, 1.44957483e-01f, -2.32897192e-01f,
  -1.20091774e-02f, 1.28928229e-01f, 1.79669306e-01f, 1.37650624e-01f, 1.18810795e-01f, 4.20455374e-02f, 1.24055147e-01f, 1.80002898e-01f, -5.22427782e-02f, 1.53750569e-01f,
  1.87809214e-01f, -3.08887480e-04f, 1.21767316e-02f, 1.02897890e-01f, -2.07236689e-03f, 1.28573189e-02f, -6.79694489e-02f, -9.98620018e-02f, 1.75028630e-02f, 4.44899499e-03f,
  4.83296774e-02f, -1.14076182e-01f, -6.25580102e-02f, 3.76345478e-02f, -1.03977457e-01f, -8.89998004e-02f, 7.28080347e-02f, 5.56898043e-02f, -6.78172559e-02f, 1.90866161e-02f,
  6.67729601e-02f, -2.19808035e-02f, 9.90718603e-02f, 8.86332542e-02f, -7.31867477e-02f, 2.33596731e-02f, 5.12809157e-02f, 3.67604375e-01f, 4.04607365e-03f, -9.31152627e-02f,
  -8.50790516e-02f, 1.17156908e-01f, 9.54557490e-03f, 4.36317474e-02f, 1.60306580e-02f, -1.77862942e-01f, 1.60177097e-01f, -5.77314310e-02f, 1.98070869e-01f, 2.32763011e-02f,
  -1.20934518e-02f, -2.07443838e-04f, 5.91518879e-02f, -9.47689544e-03f, 5.13179228e-02f, -4.43051457e-02f, 1.80329636e-01f, 3.64939809e-01f, 1.70552060e-01f, 1.99880108e-01f,
  2.25965440e-01f, 1.46960005e-01f, -1.12510778e-01f, 1.92787066e-01f, -1.09524995e-01f, 3.75943407e-02f, -1.37610286e-01f, -1.89404011e-01f, 1.57575995e-01f, 3.82289618e-05f,
  8.47868025e-02f, 3.30941156e-02f, 7.57047459e-02f, -6.95763007e-02f, -1.08331323e-01f, -5.04970290e-02f, 7.23780096e-02f, -9.20033753e-02f, 2.08734572e-01f, -4.87680510e-02f,
  4.34897989e-02f, 2.04831615e-01f, 6.98984116e-02f, -1.67790473e-01f, 1.61978200e-01f, -6.32731169e-02f, 1.64404169e-01f, -2.22288119e-03f, 6.08549081e-03f, 2.57960837e-02f,
  -1.00999177e-01f, 9.73769128e-02f, 1.67249873e-01f, -7.84838200e-02f, 1.74388602e-01f, 4.30411436e-02f, 7.57011352e-04f, -1.13479301e-01f, -6.49420097e-02f, 1.03072003e-01f,
  -1.65482253e-01f, 1.81234375e-01f, 9.09252390e-02f, -1.10050268e-01f, 1.64883792e-01f, 7.83906579e-02f, -4.49726498e-03f, -9.20831319e-03f, 1.83371529e-01f, 3.13336432e-01f,
  -3.78841870e-02f, -3.41231786e-02f, 5.86428866e-02f, -5.31963520e-02f, -1.14017539e-01f, 1.09065734e-02f, 1.92863271e-01f, 1.87052786e-01f, 1.23309828e-01f, -8.02518129e-02f,
  2.74631202e-01f, 1.48880631e-01f, 6.02504797e-02f, 1.08160675e-01f, 1.31405428e-01f, 1.20753981e-01f, -1.57691434e-01f, -1.96151286e-01f, -1.25848100e-01f, 1.60831451e-01f,
  1.47386715e-01f, 1.79780528e-01f, -1.35111287e-01f, 5.93851954e-02f, 4.25135419e-02f, 1.03234490e-02f, 7.14736581e-02f, -7.46911615e-02f, 1.15445323e-01f, 1.58487827e-01f,
  -8.75692591e-02f, 6.19602855e-03f, -1.33687295e-02f, 1.02296665e-01f, 5.89147434e-02f, 1.72143914e-02f, 2.08228733e-02f, 1.74791008e-01f, 9.27488208e-02f, 4.63791043e-02f,
  -9.57435556e-03f, 7.97278211e-02f, -1.11544959e-01f, 5.83075844e-02f, -2.18554772e-02f, -1.49920762e-01f, 1.50408978e-02f, -7.98879713e-02f, 1.80457681e-01f, -3.54949348e-02f,
  -1.91943944e-02f, -5.91304526e-03f, -1.99710317e-02f, -4.55574766e-02f, 1.04261070e-01f, 2.75508706e-02f, 3.05300318e-02f, -2.60518119e-02f, -4.26708274e-02f, 2.66379137e-02f,
  -4.88954112e-02f, 1.60808431e-03f, 3.04156169e-02f, -1.57405138e-01f, 9.96475518e-02f, -3.87156419e-02f, 1.68629348e-01f, -9.55904722e-02f, -1.70508195e-02f, -8.10780376e-02f,
  1.23024493e-01f, 7.50418827e-02f, 1.15331173e-01f, -2.31203623e-02f, 7.62914941e-02f, -8.91964212e-02f, -8.22205003e-03f, 1.36597872e-01f, 9.06942785e-02f, -5.33605665e-02f,
  6.05737120e-02f, 1.58187062e-01f, 7.36411810e-02f, -3.22238766e-02f, 5.60064800e-02f, -1.04537636e-01f, 6.71524331e-02f, -9.40222666e-02f, 1.39742181e-01f, 1.84446126e-01f,
  -7.27818906e-02f, -3.54333259e-02f, 1.37483537e-01f, -8.91206861e-02f, -1.15242451e-01f, 5.36550879e-02f, 1.10312603e-01f, 2.95435395e-02f, 9.59964022e-02f, -1.03539012e-01f,
  6.26782924e-02f, -5.45379780e-02f, 1.31609663e-01f, 8.03247690e-02f, -1.00072689e-01f, -5.46389073e-02f, -1.63102150e-02f, -4.06810082e-02f, 3.55647469e-04f, 1.45610765e-01f,
  9.08533409e-02f, 1.22086689e-01f, 1.01170421e-01f, 7.52125829e-02f, 1.07875198e-01f, 2.65343469e-02f, 1.31367490e-01f, 8.64451677e-02f, -1.07408501e-01f, 1.44058526e-01f,
  9.14227143e-02f, -1.00197949e-01f, 8.08017626e-02f, 1.00380145e-01f, -1.61637142e-02f, 1.85108418e-03f, -1.38718471e-01f, -1.61138535e-01f, 4.60350566e-04f, 9.32314098e-02f,
  -1.02481388e-01f, -2.34688390e-02f, 1.50375232e-01f, -1.11401826e-01f, -4.21885736e-02f, -8.05795565e-02f, 1.55853525e-01f, 8.00307989e-02f, -2.51509752e-02f, -1.04695350e-01f,
  4.37415205e-02f, 3.45748253e-02f, 6.19535968e-02f, 6.63358420e-02f, 7.82511160e-02f, 4.62433742e-03f, -3.95777896e-02f, -7.68928006e-02f, 9.18207690e-02f, 1.28319964e-01f,
  -7.34045878e-02f, 1.03776954e-01f, 8.88268352e-02f, -5.72209135e-02f, -9.98359919e-02f, 6.31658453e-03f, 4.02416587e-02f, 9.75254457e-03f, -5.28738182e-03f, -1.08903654e-01f,
  1.03045739e-01f, 1.12686856e-02f, 5.39062880e-02f, -1.14883438e-01f, -8.03907514e-02f, -7.34629780e-02f, 4.99129482e-02f, 7.36988038e-02f, 8.47539082e-02f, -1.25689223e-01f,
  1.69660613e-01f, 1.15118854e-01f, 3.16635445e-02f, 4.37239893e-02f, -1.00346826e-01f, -9.48003456e-02f, 4.92946059e-02f, -1.59104224e-02f, 8.91283751e-02f, 2.28757015e-03f,
  -7.04028979e-02f, -1.14986442e-01f, -5.58623895e-02f, -8.39272588e-02f, -1.16093643e-01f, -9.09409113e-03f, -3.82703170e-02f, -9.50025618e-02f, -4.14080322e-02f, -3.29760760e-02f,
  6.06585033e-02f, 2.68019661e-02f, 5.69425263e-02f, -5.67303859e-02f, 1.01102851e-01f, 1.44355163e-01f, -1.09183267e-01f, 9.22803879e-02f, -1.00655437e-01f, -1.08157545e-01f,
  -2.91829812e-03f, 8.29655901e-02f, 9.30081755e-02f, -1.30447075e-01f, 4.48741950e-02f, -3.84056084e-02f, -1.18094385e-01f, 5.05947322e-03f, -1.17757665e-02f, -7.06461743e-02f,
  -1.20433971e-01f, 9.02252793e-02f, -4.80213715e-03f, 2.45734267e-02f, -1.87243596e-02f, -1.54202050e-02f, -3.49431820e-02f, -2.16154251e-02f, 8.17543119e-02f, -4.78529092e-03f,
  4.24428880e-02f, 1.39164655e-02f, 6.05607703e-02f, -1.23130232e-01f, 1.01356760e-01f, -1.12762796e-02f, -5.74196950e-02f, 2.02458864e-03f, 3.38987149e-02f, 6.35689422e-02f,
  5.34055643e-02f, 9.55765396e-02f, -3.43194567e-02f, 8.24061409e-02f, -1.28895000e-01f, -5.31447046e-02f, 8.49025697e-03f, -1.88065600e-02f, -1.05292976e-01f, -4.82746167e-03f,
  -1.12048291e-01f, 9.87006500e-02f, 8.28770176e-02f, 8.61329120e-03f, 5.39720617e-02f, 1.27145290e-01f, -2.98741390e-03f, -3.59007530e-02f, 1.17775865e-01f, 5.26707955e-02f,
  -8.27543251e-03f, 5.75180352e-03f, 4.45534755e-03f, 7.17382059e-02f, 6.14173301e-02f, 3.80198983e-03f, -1.87685248e-02f, 1.06856100e-01f, -7.23624751e-02f, -2.11209590e-05f,
  1.11648351e-01f, -1.55345164e-02f, -3.14630717e-02f, 1.00058116e-01f, -2.74193510e-02f, -9.31758583e-02f, 7.75660425e-02f, 3.38001065e-02f, -3.59562300e-02f, -2.23902729e-03f,
  2.87931822e-02f, 1.13801688e-01f, 4.47589345e-03f, -1.56308055e-01f, -8.67923498e-02f, -4.98819239e-02f, 7.40407631e-02f, -1.70142937e-03f, 2.23899931e-02f, 3.33980508e-02f,
  1.84855070e-02f, -7.48764724e-02f, -9.12038907e-02f, -4.82137641e-03f, 1.02626540e-01f, 1.54905424e-01f, 2.26087589e-02f, 4.65316921e-02f, -2.91723269e-03f, -4.43162583e-02f,
  8.62408504e-02f, 4.21488173e-02f, 5.35768047e-02f, 5.46091124e-02f, -1.63259670e-01f, 6.09612316e-02f, 1.30400747e-01f, -1.76579822e-02f, 3.98500264e-03f, 6.71186764e-03f,
  1.25805184e-01f, -4.37512435e-02f, 1.22753456e-01f, -8.01615566e-02f, 1.69150174e-01f, -7.20979199e-02f, 9.88591928e-03f, 1.38553828e-01f, -2.39497814e-02f, 1.07866280e-01f,
  1.04630865e-01f, -4.55119461e-02f, 1.40092999e-01f, 5.34722209e-02f, 2.42263421e-01f, 9.55282524e-02f, 2.66829878e-03f, -7.68206418e-02f, 6.23029023e-02f, 2.13517234e-01f,
  1.38403196e-02f, -4.41902876e-02f, 3.71963419e-02f, 2.83193290e-02f, -6.68189526e-02f, 1.35694489e-01f, 2.92932004e-01f, 1.21947624e-01f, 3.45539488e-02f, -7.40849897e-02f,
  -5.21601290e-02f, 1.08842663e-02f, 8.22505206e-02f, 9.64409113e-02f, 3.48002128e-02f, 4.48225513e-02f, -2.44862190e-03f, 1.02622882e-02f, 7.62457177e-02f, 5.12210540e-02f,
  -1.04814745e-01f, -1.34571940e-01f, 2.06054691e-02f, 6.44880906e-02f, -1.64705589e-02f, -1.15637958e-01f, -5.33914566e-02f, 4.62939963e-02f, 2.27471720e-02f, 6.53628707e-02f,
  -2.73990463e-02f, -1.04780219e-01f, 1.18224606e-01f, 6.60369024e-02f, -2.27525346e-02f, -7.17136115e-02f, -5.09314053e-02f, -4.93590645e-02f, -2.46636961e-02f, 2.27774065e-02f,
  7.47074932e-02f, 4.63776924e-02f, -8.47589821e-02f, -2.01214105e-03f, 1.57424957e-01f, 2.14382425e-01f, 7.89020881e-02f, -6.83679581e-02f, 4.49565016e-02f, 1.30105084e-02f,
  -3.43895517e-02f, -5.02903722e-02f, 9.39209089e-02f, 7.19643533e-02f, 4.75620963e-02f, -1.96574926e-02f, -7.72976428e-02f, 9.32224244e-02f, 7.20265210e-02f, -5.67245744e-02f,
  3.51916961e-02f, 5.93837425e-02f, 9.11667868e-02f, 1.91902682e-01f, -1.15176611e-01f, 9.86534357e-02f, 1.72497556e-02f, -7.11578056e-02f, 1.42519876e-01f, -1.06552370e-01f,
  -8.29554200e-02f, 1.01446524e-01f, -1.71199515e-02f, -7.31535852e-02f, 6.58152252e-02f, 9.27207246e-02f, -8.12493414e-02f, -6.91275969e-02f, -8.66583064e-02f, 1.24967724e-01f,
  -7.36512020e-02f, -1.47684693e-01f, 7.36884493e-03f, -7.78749511e-02f, 8.32201689e-02f, 5.01192063e-02f, -2.04117019e-02f, 1.35565862e-01f, 9.08802971e-02f, -1.20991737e-01f,
  1.52939841e-01f, 4.13437374e-02f, -4.68615182e-02f, 1.11877685e-02f, -1.22382656e-01f, 1.14302211e-01f, -5.38801551e-02f, 1.06281720e-01f, 3.24027538e-02f, 7.21147135e-02f,
  -4.69007716e-02f, -6.78202361e-02f, -1.27543017e-01f, -6.44363165e-02f, -8.01225007e-02f, 5.90953231e-02f, 1.91467613e-01f, 1.05685145e-01f, 1.26145557e-01f, 5.43588065e-02f,
  -5.46931736e-02f, 7.77132018e-03f, 1.58665657e-01f, 2.53032465e-02f, -2.55291406e-02f, 4.73727062e-02f, -9.04047675e-03f, -7.78952539e-02f, 1.40043080e-01f, 6.11139312e-02f,
  -8.20636749e-02f, 9.91646945e-02f, -4.18628789e-02f, 9.71816480e-03f, -3.21482606e-02f, 2.62046568e-02f, -4.69080321e-02f, 1.05365686e-01f, -8.85587931e-02f, 4.01095748e-02f,
  3.62262726e-02f, 6.42005503e-02f, 1.05019726e-01f, -8.78348649e-02f, 1.94606930e-02f, 9.47792307e-02f, -9.28169936e-02f, 1.12894796e-01f, 6.50985911e-03f, 1.77427799e-01f,
  1.01165108e-01f, 3.92583869e-02f, 1.61117777e-01f, 1.53338192e-02f, -2.18483265e-02f, -4.62592468e-02f, 1.42497167e-01f, -9.06583145e-02f, -1.65268689e-01f, -5.16360328e-02f,
  1.22681186e-01f, -5.02620004e-02f, 1.00841038e-01f, -6.81797862e-02f, -2.84496341e-02f, 4.44304869e-02f, -3.09399441e-02f, 4.31825258e-02f, 1.58579886e-01f, -2.32275166e-02f,
  1.38785362e-01f, 1.02352828e-01f, 9.73974615e-02f, -1.05058607e-02f, 2.61132941e-02f, -1.30543038e-01f, 1.63013577e-01f, -4.15384658e-02f, -7.84165412e-02f, 8.42758920e-03f,
  -5.32151908e-02f, 1.94088146e-02f, -8.73292163e-02f, 1.73632398e-01f, 1.18893325e-01f, -1.64876748e-02f, -1.97529662e-02f, -4.22899686e-02f, 9.06943604e-02f, -1.44028321e-01f,
  9.58861411e-02f, 1.49523035e-01f, 4.27841842e-02f, -3.69299613e-02f, 1.17197596e-01f, 4.84752320e-02f, 1.21908151e-01f, 6.13440340e-03f, -3.10871676e-02f, -5.28815277e-02f,
  1.46686703e-01f, 1.76063642e-01f, -4.54658009e-02f, -6.88595101e-02f, 7.00441375e-02f, -5.38591519e-02f, -4.34009843e-02f, 2.16389131e-02f, -8.54186267e-02f, 4.59307246e-02f,
  1.25001267e-01f, 8.89039040e-02f, 2.79608727e-01f, 3.65666091e-01f, 2.64544249e-01f, 2.40599364e-01f, 2.23408580e-01f, 2.69864917e-01f, -7.81170428e-02f, 8.18877574e-03f,
  1.98135786e-02f, 3.33606228e-02f, 1.52221382e-01f, -2.91821569e-01f, 1.06524497e-01f, 1.02774613e-01f, 3.50902118e-02f, -1.83534682e-01f, -3.93443890e-02f, -3.23833004e-02f,
  1.78257123e-01f, 2.26739287e-01f, 8.05526972e-02f, 1.69898465e-01f, 1.51444525e-01f, -1.22661307e-01f, 2.08165362e-01f, 3.60428363e-01f, -5.06256558e-02f, 1.00085579e-01f,
  -7.60323331e-02f, -7.71019459e-02f, 6.51094466e-02f, 1.55162796e-01f, -5.57695106e-02f, 3.30814347e-03f, 2.11718604e-01f, 2.29355991e-01f, 2.27330476e-01f, 6.73187524e-02f,
  3.06139559e-01f, -1.13539726e-01f, -7.99561068e-02f, 1.15543522e-01f, 7.85895064e-02f, -3.96645777e-02f, 2.36018002e-01f, -9.27540998e-04f, 1.71266347e-01f, 2.54812896e-01f,
  2.70736128e-01f, 2.01041952e-01f, 1.48833692e-01f, 5.94070442e-02f, 5.40617742e-02f, 2.53393531e-01f, -3.69559564e-02f, 2.27203369e-01f, 1.37599319e-01f, -1.65666327e-01f,
  2.89100707e-02f, 1.28572518e-02f, 3.06282163e-01f, 1.61406383e-01f, -2.80143261e-01f, -1.39623597e-01f, 9.60928723e-02f, 6.78256378e-02f, -6.13541603e-02f, 4.92314771e-02f,
  7.16468841e-02f, 1.45815417e-01f, -5.59333265e-02f, -6.24063723e-02f, 2.34525558e-02f, 4.09486368e-02f, -7.28981644e-02f, 6.23349361e-02f, 1.00814916e-01f, -1.02502964e-01f,
  -1.22657053e-01f, 8.04989226e-03f, 1.22190468e-01f, -3.10822781e-02f, -1.07414030e-01f, 1.13500804e-01f, -3.77443843e-02f, 7.42347538e-02f, -8.41803998e-02f, 4.06520702e-02f,
  -1.21873587e-01f, 3.72230671e-02f, 4.39289063e-02f, -9.28343907e-02f, 1.66509926e-01f, 2.38097645e-02f, -2.20752601e-02f, -1.36022205e-02f, -4.68028486e-02f, 8.91244113e-02f,
  -1.33662507e-01f, 8.80206674e-02f, 8.29657689e-02f, -1.04083240e-01f, 8.02132301e-03f, -3.94392498e-02f, -7.31151626e-02f, 6.59853891e-02f, -9.28108394e-02f, 1.44053474e-01f,
  4.95841429e-02f, 3.20944563e-02f, -1.06981643e-01f, -1.20461263e-01f, 1.15357086e-01f, 9.54236314e-02f, 3.82041954e-03f, -9.85675380e-02f, 9.15236026e-02f, 2.63360776e-02f,
  -7.90890604e-02f, -1.28607705e-01f, -4.59818505e-02f, 9.59011614e-02f, 3.65527347e-02f, 5.22662364e-02f, -1.11939542e-01f, 2.31110062e-02f, 4.29472029e-02f, 4.75991778e-02f,
  3.75850387e-02f, 1.43035501e-01f, 7.62632191e-02f, 1.88899636e-01f, -6.74681365e-02f, 8.26442838e-02f, -5.86704537e-02f, 1.65888786e-01f, 1.48899898e-01f, -1.64827049e-01f,
  -1.29813954e-01f, -1.75819144e-01f, 1.62914991e-01f, -1.15135178e-01f, -9.84454677e-02f, -3.36495787e-02f, 1.67501140e-02f, -7.56741390e-02f, 5.65812662e-02f, -7.96484854e-03f,
  1.03491217e-01f, 1.79554299e-02f, 7.55520817e-03f, -4.21188846e-02f, 5.22241034e-02f, 1.95136517e-01f, -7.38568529e-02f, -1.05844634e-02f, 2.11667299e-01f, 9.02079865e-02f,
  -1.51776755e-02f, 1.35142148e-01f, -5.93381897e-02f, -7.62818381e-02f, -1.25305891e-01f, 1.78033248e-01f, 6.07750267e-02f, 5.22103813e-03f, -1.07097015e-01f, -1.18515894e-01f,
  -8.64502192e-02f, 3.10991667e-02f, 9.14641693e-02f, 9.98122171e-02f, 1.04552679e-01f, 1.52258530e-01f, -3.02000977e-02f, 9.44308564e-02f, -9.95800048e-02f, -3.74881970e-03f,
  2.02449962e-01f, 2.11469069e-01f, -2.22829189e-02f, 2.12541446e-01f, 9.42847133e-02f, 5.38957454e-02f, 2.34372094e-02f, 9.87132341e-02f, -6.58466071e-02f, -1.03660695e-01f,
  7.41682760e-03f, 1.54565498e-01f, 2.98257284e-02f, 7.94094428e-03f, 3.66340652e-02f, -2.60685589e-02f, -1.61819197e-02f, -7.58037120e-02f, 5.27138896e-02f, 7.39187375e-02f,
  2.24819276e-02f, -1.19862482e-01f, 7.60255232e-02f, -7.38255586e-03f, 2.99175363e-02f, 8.50007962e-03f, 6.01733401e-02f, 5.17662168e-02f, 1.13269687e-01f, 3.87544222e-02f,
  -3.52648124e-02f, -1.23890042e-01f, 1.28228724e-01f, -2.59496905e-02f, 1.94022097e-02f, -9.53488722e-02f, -9.86798182e-02f, -3.87450233e-02f, -2.23937090e-02f, 9.76761803e-02f,
  -3.32693406e-03f, 6.68822974e-02f, 1.70361847e-02f, -7.47931376e-02f, -7.74993002e-02f, -7.18768081e-03f, -2.37999037e-02f, -5.48854396e-02f, 7.26231262e-02f, 3.91312912e-02f,
  1.07794568e-01f, 1.42762624e-02f, -5.28249294e-02f, -3.01320050e-02f, -9.76912454e-02f, -2.09000371e-02f, -2.13273093e-02f, 9.28224623e-02f, -1.20310709e-02f, 6.37562200e-03f,
  -2.74530333e-02f, 6.14586473e-02f, -5.05672060e-02f, -8.36658478e-02f, -7.82008767e-02f, -1.16072170e-01f, 7.83930644e-02f, -1.19103707e-01f, 8.50086585e-02f, 8.05746987e-02f,
  -1.02590509e-01f, 4.82629575e-02f, 6.40614778e-02f, -1.11354306e-01f, 1.33472839e-02f, 4.28697690e-02f, -9.09010321e-02f, -8.14050883e-02f, 1.92087874e-01f, -2.71062460e-02f,
  -8.98707076e-04f, 1.60594452e-02f, 4.07665744e-02f, 1.92817047e-01f, 7.13362098e-02f, 8.77614506e-03f, 9.98225212e-02f, 1.61933482e-01f, 1.68069556e-01f, 2.04891637e-01f,
  -2.95313094e-02f, 4.94888127e-02f, 1.13993585e-01f, 1.34199858e-01f, 8.67297351e-02f, -1.14498936e-01f, 2.33909145e-01f, -6.16052262e-02f, -8.73464346e-02f, 1.20428257e-01f,
  -1.00869946e-01f, -3.66374501e-03f, 9.79656726e-02f, -7.11202696e-02f, 1.06273413e-01f, -3.93671095e-02f, 8.73127431e-02f, -7.02995583e-02f, 3.68230641e-02f, 3.18623856e-02f,
  3.50763425e-02f, 5.79502732e-02f, 8.87901485e-02f, -1.19650096e-01f, 3.98996472e-02f, 2.00111851e-01f, -1.11026175e-01f, 1.14862300e-01f, -8.61228779e-02f, -5.32994531e-02f,
  1.18298866e-01f, -5.88726290e-02f, 1.05868749e-01f, 1.65397495e-01f, -4.10978422e-02f, 1.69503331e-01f, 1.52007891e-02f, -6.18538894e-02f, -6.90415353e-02f, -2.39740461e-02f,
  -7.14726523e-02f, -4.92929742e-02f, -5.10188639e-02f, 9.41434503e-02f, 3.86150181e-02f, -2.77021136e-02f, 1.80779114e-01f, -4.14249860e-02f, -2.24560741e-02f, -1.09458208e-01f,
  -1.16076067e-01f, -2.69215903e-03f, 2.43991703e-01f, -1.41203273e-02f, -1.62761528e-02f, 1.45601392e-01f, -1.35772318e-01f, 2.59451956e-01f, -7.81130269e-02f, -2.54298747e-01f,
  -1.59905374e-01f, 1.25204638e-01f, 2.32020721e-01f, 1.41824201e-01f, -7.30521977e-02f, -2.42035463e-02f, 1.15064986e-01f, -8.39831308e-02f, 3.49660553e-02f, -1.66172702e-02f,
  1.01506054e-01f, 8.89197960e-02f, 1.50342569e-01f, 1.64114118e-01f, 3.46873477e-02f, -1.14060231e-01f, 9.46377665e-02f, 6.25553280e-02f, 1.31924257e-01f, 1.41604230e-01f,
  -1.07164249e-01f, 4.02546534e-03f, 1.20270483e-01f, -2.96215918e-02f, 2.28103921e-02f, -6.28151000e-02f, 4.96950857e-02f, -3.71392304e-03f, 2.11287453e-03f, 1.87549382e-01f,
  2.17837170e-01f, 2.31916178e-02f, 5.27517796e-02f, 5.99961542e-03f, 1.56001925e-01f, -3.56014371e-02f, 8.83404315e-02f, 1.43535674e-01f, 2.89683342e-02f, 5.30406460e-02f,
  -1.51488129e-02f, 1.76820099e-01f, -1.04129396e-01f, 2.73906905e-02f, 1.59870740e-02f, 8.13409910e-02f, 1.55737633e-02f, 6.72849715e-02f, 1.40150607e-01f, -6.67085648e-02f,
  9.00220126e-02f, -8.35094601e-02f, 1.62051797e-01f, 3.81588899e-02f, -1.10877208e-01f, -8.32661539e-02f, 7.34691992e-02f, 8.01749453e-02f, 1.96161252e-02f, 3.30677442e-02f,
  -9.72188264e-02f, 6.68147579e-02f, 4.02193405e-02f, -1.39696412e-02f, 1.27133116e-01f, -1.19510710e-01f, -4.43179384e-02f, -7.36171156e-02f, 1.38537541e-01f, -1.03829928e-01f,
  8.33738036e-03f, 6.99926615e-02f, -1.35733765e-02f, 9.93718058e-02f, 9.46650654e-02f, 5.26829809e-02f, -1.00975754e-02f, -8.61784518e-02f, -3.22404020e-02f, -2.07748474e-03f,
  -1.19657265e-02f, -2.79188845e-02f, 2.53770817e-02f, -8.99947807e-02f, -6.37722909e-02f, 1.02357648e-01f, -3.39921713e-02f, -2.48234961e-02f, 2.26780847e-02f, -6.82209283e-02f,
  -1.04233108e-01f, 1.24854259e-02f, 2.40548663e-02f, 1.50251120e-01f, -9.32459661e-04f, 5.04534878e-02f, 1.42119713e-02f, -1.08009316e-01f, -2.34312136e-02f, 1.24380305e-01f,
  -9.04443413e-02f, 1.53334476e-02f, 3.78586166e-02f, 2.55695134e-02f, -1.28451765e-01f, 8.46708417e-02f, 1.16935886e-01f, -3.94459628e-02f, 7.01934695e-02f, 5.94495572e-02f,
  1.45460591e-02f, -6.60147890e-02f, -8.91058967e-02f, -2.27257404e-02f, 1.52882552e-02f, 9.68073606e-02f, 1.94137227e-02f, 4.19523083e-02f, 8.99337679e-02f, 1.00777216e-01f,
  2.35633314e-01f, -2.05636909e-03f, 9.44703072e-02f, 2.63521880e-01f, -2.92985532e-02f, 3.21322381e-02f, 1.85630277e-01f, -3.78858335e-02f, 9.41351354e-02f, 1.38752505e-01f,
  2.89559904e-02f, -9.81144831e-02f, 1.11662500e-01f, 1.08812042e-02f, 1.30875215e-01f, 1.47522211e-01f, 1.86481878e-01f, -7.48121738e-02f, 2.12675154e-01f, -1.46615595e-01f,
  2.14498818e-01f, -5.44078350e-02f, 2.52781332e-01f, 5.26432209e-02f, -1.17004914e-02f, 1.33525133e-01f, -5.52922301e-02f, -6.04850873e-02f, 1.16913624e-01f, -1.13234602e-01f,
  2.34797895e-02f, 4.56974693e-02f, -1.53777460e-02f, 5.62601276e-02f, -1.29469410e-01f, -6.45931959e-02f, 1.62550077e-01f, 2.02660248e-01f, -6.18236214e-02f, -1.54623650e-02f,
  5.66380024e-02f, 1.20998099e-02f, -7.39952549e-02f, 3.82091142e-02f, 4.04257253e-02f, 4.71595258e-01f, 8.91451910e-02f, -1.08757816e-01f, 7.12395506e-03f, -2.56950017e-02f,
  1.32740512e-01f, -6.24867901e-02f, -1.92691479e-02f, -2.45719403e-02f, 4.41346504e-03f, -3.16360174e-03f, 4.58050519e-02f, 8.99283141e-02f, -9.65116322e-02f, 9.89585370e-02f,
  -9.59869940e-03f, -5.58259636e-02f, 5.82209304e-02f, 6.50916323e-02f, -3.62567380e-02f, -7.26962686e-02f, -5.68885915e-02f, -5.34282811e-02f, 7.17751458e-02f, -3.94231863e-02f,
  2.56546475e-02f, 8.60882699e-02f, -6.17421828e-02f, 1.10978089e-01f, 1.25295609e-01f, -7.62441531e-02f, 1.85876235e-03f, -7.74891451e-02f, -6.65106922e-02f, -9.91768390e-02f,
  2.20449958e-02f, -1.74902175e-02f, 6.23453148e-02f, 8.41000080e-02f, -1.06431201e-01f, 7.51869828e-02f, -5.15224673e-02f, 6.13909774e-03f, 8.72593522e-02f, 9.08812806e-02f,
  3.64535674e-02f, -1.12231441e-01f, -3.13942954e-02f, 1.00438014e-01f, -7.40127191e-02f, 3.48764621e-02f, -6.46273419e-02f, -3.99311539e-03f, 2.60707475e-02f, 1.10488071e-03f,
  1.03383221e-01f, -8.03166777e-02f, -2.16766028e-03f, 8.68518874e-02f, -1.03219181e-01f, 1.16297856e-01f, -3.95185277e-02f, -8.44859034e-02f, -5.36557063e-02f, -1.08199671e-01f,
  -3.86742875e-02f, 3.30626778e-02f, 3.99102503e-03f, 1.21350884e-01f, -6.30717129e-02f, -1.19248576e-01f, -1.04089729e-01f, -8.25338587e-02f, 5.20667955e-02f, -1.03070997e-01f,
  -7.97509328e-02f, 2.24337876e-02f, 6.35254458e-02f, 7.89267663e-03f, -1.35892583e-02f, -1.23017207e-01f, 8.49931911e-02f, -6.78990334e-02f, 2.23479476e-02f, 4.37398255e-02f,
  -5.82160689e-02f, -1.26055419e-01f, -1.12017408e-01f, -1.31704718e-01f, -1.17249228e-01f, 1.01496711e-01f, -3.80691662e-02f, -1.07192576e-01f, -1.37985170e-01f, 8.19531158e-02f,
  5.80637716e-02f, -7.42684752e-02f, -3.22284810e-02f, 5.06305660e-04f, 1.03492670e-01f, -6.48083463e-02f, -3.46280932e-02f, -8.23885426e-02f, -2.03086492e-02f, -2.61291005e-02f,
  2.90732309e-02f, -6.02798015e-02f, 1.04459919e-01f, 7.74499401e-02f, 6.47866800e-02f, 4.38677743e-02f, 1.20058529e-01f, 6.12488799e-02f, 4.45927270e-02f, 5.20714819e-02f,
  -6.74524829e-02f, 6.50767460e-02f, 5.78079894e-02f, -4.63582687e-02f, 2.93382127e-02f, 1.35802217e-02f, 4.45615947e-02f, 1.05566181e-01f, 1.32496431e-01f, -1.01276664e-02f,
  7.86342695e-02f, -5.58022447e-02f, -5.59717678e-02f, 9.58480909e-02f, 2.29788069e-02f, -4.99282107e-02f, -4.32318561e-02f, 1.07222266e-01f, -4.02876223e-03f, -1.26993865e-01f,
  -6.49850070e-03f, -6.52640536e-02f, -7.64957890e-02f, 2.17801463e-02f, 7.34928623e-02f, 1.74888540e-02f, 7.58981928e-02f, -1.19921811e-01f, 9.59057268e-03f, -1.12966619e-01f,
  -7.02752545e-02f, 3.53652947e-02f, 1.81652606e-01f, -5.40370271e-02f, 1.87862650e-01f, 2.08482951e-01f, 1.78924009e-01f, 8.20081159e-02f, 2.43496969e-02f, 4.47014645e-02f,
  1.49891302e-01f, -9.58279222e-02f, -7.14237839e-02f, 3.19437794e-02f, -1.01935633e-01f, 1.18176509e-02f, -1.08424924e-01f, -7.52400011e-02f, -1.49455303e-02f, -8.17570984e-02f,
  -7.43255392e-02f, 1.40316054e-01f, -7.11205602e-02f, 1.02190875e-01f, 1.04961253e-03f, -5.65309674e-02f, 6.03080057e-02f, -8.79826620e-02f, 3.45599814e-03f, -5.90747409e-02f,
  1.68709859e-01f, 1.47391990e-01f, -8.58958736e-02f, 1.36235822e-02f, 7.28458613e-02f, 1.21086203e-02f, 4.05433476e-02f, 4.87659350e-02f, 3.39339375e-02f, 7.88843110e-02f,
  -6.42778948e-02f, -6.44913316e-02f, 1.19253181e-01f, 8.07632972e-03f, 8.29878449e-02f, 1.63288806e-02f, 8.59459415e-02f, -1.57711841e-03f, 2.38484256e-02f, -9.02986452e-02f,
  -5.88956811e-02f, -3.92186604e-02f, -8.95222053e-02f, -3.08128912e-02f, -1.54214241e-02f, -1.75118759e-01f, 6.66906238e-02f, -1.08630113e-01f, 3.45785432e-02f, -3.31238005e-03f,
  1.49384007e-01f, -9.86760557e-02f, 2.13965476e-02f, 2.97576245e-02f, 1.06848702e-01f, 7.12468326e-02f, -3.43562141e-02f, -3.20510268e-02f, 1.53514549e-01f, 1.36851698e-01f,
  8.25042874e-02f, -5.25132269e-02f, 1.55940475e-02f, 1.14746755e-02f, -2.76043583e-02f, 1.27810046e-01f, -7.26474589e-03f, 1.98633075e-01f, 1.13855988e-01f, -2.73099300e-02f,
  -8.18977058e-02f, -5.12154177e-02f, -3.33841294e-02f, 2.94596124e-02f, 1.30354002e-01f, -1.70197394e-02f, -4.02542017e-02f, -9.45396721e-02f, 2.53211334e-02f, 8.98273960e-02f,
  -5.66799715e-02f, 1.68052651e-02f, 8.83239657e-02f, -7.86223933e-02f, 4.57492620e-02f, 6.83668256e-02f, -4.21846136e-02f, -7.71880224e-02f, -1.15910672e-01f, 9.11536664e-02f,
  -8.76430571e-02f, -7.53246322e-02f, 5.59924170e-02f, 1.15233943e-01f, 2.66844733e-03f, -1.15345502e-02f, -8.38078260e-02f, 3.05130593e-02f, -8.29710588e-02f, -1.33803755e-01f,
  2.95687281e-02f, 4.14607264e-02f, -1.27820838e-02f, -6.26930967e-02f, -7.01163784e-02f, 3.75100076e-02f, -1.15360253e-01f, -1.11231357e-01f, -1.31334141e-01f, -1.35659263e-01f,
  1.52280135e-02f, 2.30197739e-02f, 3.34926620e-02f, -6.44175708e-02f, -2.42562648e-02f, 8.46006274e-02f, -9.10166427e-02f, -6.57197312e-02f, 7.37241060e-02f, 5.41321076e-02f,
  -1.43221617e-02f, 7.54605159e-02f, -5.54882511e-02f, 9.76344049e-02f, 1.18136667e-01f, -9.95738991e-03f, 2.67426781e-02f, 1.29681528e-01f, 1.26721216e-02f, -9.93103832e-02f,
  -1.16356954e-01f, -8.80126953e-02f, -8.16223249e-02f, -4.47923243e-02f, -4.27089781e-02f, -4.57775593e-03f, -9.90240797e-02f, 7.61501119e-02f, 6.18235059e-02f, -5.85735887e-02f,
  1.25559673e-01f, 4.32300866e-02f, -3.63279805e-02f, 7.37003237e-02f, 1.06633008e-01f, -6.94554299e-02f, -3.30701955e-02f, 3.48527804e-02f, 4.66677360e-02f, 3.91889773e-02f,
  1.74341146e-02f, -3.99818309e-02f, -1.00116849e-01f, 3.14704254e-02f, 9.96049270e-02f, 7.02872127e-02f, -7.77283087e-02f, -2.78727151e-02f, -4.26651165e-02f, 3.98495011e-02f,
  1.30567548e-03f, -1.20447859e-01f, -7.75208324e-02f, 1.21371940e-01f, 8.40339139e-02f, -9.43896770e-02f, 1.83720738e-02f, -2.08738409e-02f, -1.30907774e-01f, -2.29787584e-02f,
  1.00065753e-01f, 3.49852853e-02f, 7.08533525e-02f, -2.50342190e-02f, 2.56879199e-02f, 3.87357101e-02f, -1.00622736e-01f, 1.03015400e-01f, 5.46798036e-02f, -4.50255424e-02f,
  8.24417025e-02f, -5.75914048e-02f, 5.70519790e-02f, 4.31720391e-02f, 5.87290525e-02f, 3.86367086e-03f, -6.13189582e-03f, 9.79735777e-02f, 8.46204609e-02f, 8.12579878e-03f,
  -8.78029615e-02f, 8.37397799e-02f, 1.67032704e-01f, -1.05834402e-01f, -2.11051628e-01f, -2.20667422e-01f, 2.03696370e-01f, 1.20849669e-01f, -1.40768439e-01f, 1.87936437e-03f,
  6.84123635e-02f, -1.41878039e-01f, 5.42360283e-02f, -8.40143487e-02f, 2.30882600e-01f, -1.12695128e-01f, 1.18941054e-01f, -4.47102152e-02f, 3.09560336e-02f, 2.24635191e-02f,
  -4.40007932e-02f, -9.03671235e-02f, 1.07048906e-01f, 5.15513942e-02f, -1.07859239e-01f, -9.74261537e-02f, 1.44098073e-01f, 8.96563083e-02f, -7.20750391e-02f, 1.94608212e-01f,
  -1.56266540e-02f, 5.58695570e-02f, -1.30822524e-01f, -4.12313873e-03f, -8.96570832e-02f, -1.28190443e-01f, 3.45874988e-02f, 1.02622502e-01f, 1.28523797e-01f, -7.78366327e-02f,
  -6.88468525e-03f, 3.24980170e-02f, 7.24131986e-02f, -1.09068751e-01f, 2.73388736e-02f, 1.49822533e-01f, 9.62257981e-02f, 2.92517126e-01f, 2.93269493e-02f, 1.90421622e-02f,
  -1.58566162e-01f, 1.40491486e-01f, 1.21318273e-01f, 7.69190341e-02f, 5.56337908e-02f, 1.32135168e-01f, 1.52172163e-01f, -4.33932915e-02f, -4.62426730e-02f, 1.16083391e-01f,
  7.53951818e-02f, -9.74612404e-03f, -3.68466005e-02f, 1.36893421e-01f, -1.20706432e-01f, -7.20892567e-03f, -7.71125257e-02f, 6.33520680e-03f, 1.44327253e-01f, 8.13882202e-02f,
  4.14940864e-02f, -3.88015881e-02f, 1.26084566e-01f, -1.25780195e-01f, -1.60076022e-02f, 5.80086634e-02f, 8.32048059e-03f, 6.27188981e-02f, 1.78618222e-01f, 5.51143028e-02f,
  -3.35851572e-02f, 6.28373325e-02f, -3.60998213e-02f, 6.23750500e-03f, -1.82192009e-02f, -1.13200016e-01f, 4.21548449e-02f, -3.61827500e-02f, -6.92192093e-02f, 8.59633163e-02f,
  -9.01608020e-02f, -2.42298804e-02f, -1.86022557e-02f, -8.26731399e-02f, 1.58829287e-01f, -1.08389229e-01f, 1.87779486e-01f, -2.67484784e-02f, -9.16615650e-02f, 1.39833651e-02f,
  6.57098293e-02f, 3.52039076e-02f, 1.15487307e-01f, -1.25596090e-03f, 5.68108559e-02f, 5.69986701e-02f, 6.10042736e-02f, 1.28703967e-01f, 8.62144753e-02f, -8.76294076e-02f,
  5.57851903e-02f, 1.12583525e-01f, -4.50251187e-04f, 9.57280323e-02f, -8.35765526e-02f, -2.01503802e-02f, 1.00233495e-01f, -3.71122696e-02f, 2.33831182e-01f, 6.45169914e-02f,
  3.30691761e-03f, 6.61643371e-02f, 6.45890385e-02f, 9.93841067e-02f, -6.91009387e-02f, -5.88756613e-02f, 5.89108914e-02f, -5.85729070e-02f, -5.99436723e-02f, 9.11441669e-02f,
  -6.24831319e-02f, -9.18519795e-02f, 6.40151799e-02f, -3.85599770e-02f, 3.76273692e-02f, -6.37046024e-02f, 1.13719106e-01f, -1.00372449e-01f, 1.61754072e-01f, 2.92808395e-02f,
  -8.90451223e-02f, 2.84698606e-02f, 1.52816221e-01f, 1.03226326e-01f, 1.45045400e-01f, 9.99079049e-02f, 6.19812645e-02f, 1.00840420e-01f, -1.21336408e-01f, 1.09377138e-01f,
  -1.50061205e-01f, -4.11444344e-02f, -7.05187023e-02f, -2.08599959e-03f, 1.34930775e-01f, 6.69640899e-02f, 1.37672583e-02f, 7.94660524e-02f, 9.48265791e-02f, -2.96315327e-02f,
  5.10744229e-02f, 2.81561725e-03f, -2.97262780e-02f, -1.17621012e-02f, -6.66365847e-02f, 1.09664641e-01f, 8.22404493e-03f, -9.23292115e-02f, 3.58172469e-02f, -6.93864077e-02f,
  8.46865214e-03f, 1.34239811e-02f, 1.56038314e-01f, -1.12112008e-01f, 6.69745877e-02f, 1.20038092e-01f, -1.19976085e-02f, -2.69485656e-02f, -9.79623348e-02f, -8.81677493e-02f,
  -9.37233642e-02f, 5.71658462e-02f, 1.08589880e-01f, -3.31178531e-02f, -9.89004448e-02f, -1.34027511e-01f, -7.14191198e-02f, 1.52502880e-01f, 9.55575630e-02f, 8.59019719e-03f,
  4.73104492e-02f, 1.63745254e-01f, -9.10699442e-02f, -4.55225408e-02f, -1.02229908e-01f, 2.56257877e-02f, -9.57725719e-02f, -3.43561522e-03f, -1.14802219e-01f, -1.15350615e-02f,
  -1.14555083e-01f, -7.83730820e-02f, 6.57321736e-02f, 3.64164300e-02f, -1.14603259e-01f, 4.96957786e-02f, -5.42863682e-02f, 1.27438143e-01f, -8.20948929e-02f, 5.05541936e-02f,
  -8.97520746e-04f, 1.02998853e-01f, -7.47144893e-02f, 9.66691300e-02f, 6.30863830e-02f, 9.81625766e-02f, -1.04500085e-01f, -4.64052111e-02f, -9.81965065e-02f, -6.09371765e-03f,
  -5.26541397e-02f, 2.26218347e-02f, 8.74538347e-02f, -5.77006117e-02f, -2.06354782e-02f, -3.25537217e-03f, -3.81645486e-02f, 6.32553771e-02f, 1.24770753e-01f, -3.02817356e-02f,
  -2.67677777e-03f, 5.42630292e-02f, -1.00489631e-01f, 4.28882381e-03f, 9.83319804e-02f, 1.26442850e-01f, -1.01585627e-01f, -1.57792345e-02f, -5.28499857e-03f, 8.43225867e-02f,
  5.00285588e-02f, 2.36492082e-02f, -1.04132682e-01f, 1.86619963e-02f, 3.03922556e-02f, -1.16180100e-01f, 1.33776575e-01f, -1.01848572e-01f, 6.42514750e-02f, -8.40338171e-02f,
  -1.13780394e-01f, 1.20021410e-01f, 1.10881209e-01f, 6.89107180e-02f, 5.63479848e-02f, 1.15948126e-01f, -1.05625257e-01f, 2.41547842e-02f, 5.11010513e-02f, 6.06548302e-02f,
  4.33220193e-02f, 1.90473143e-02f, -4.51115295e-02f, -4.43302207e-02f, 1.10113181e-01f, -1.29878461e-01f, -8.52127299e-02f, 3.79473269e-02f, -1.00345872e-02f, -7.53744394e-02f,
  2.92778108e-02f, 5.13696782e-02f, -3.22120935e-02f, -4.37617302e-02f, 3.22249904e-02f, -7.49897137e-02f, 9.58030820e-02f, -1.08159371e-01f, 9.99899060e-02f, 4.66245301e-02f,
  -3.43203172e-02f, -5.08451834e-03f, 6.59625083e-02f, -7.01299757e-02f, 1.23679861e-01f, -1.01369448e-01f, 1.04804605e-01f, -1.21850939e-02f, -3.28657962e-03f, -2.99781840e-02f,
  5.13897538e-02f, -2.89227068e-03f, -3.57597903e-03f, 3.87779884e-02f, -4.72689327e-03f, -1.02674857e-01f, -1.16971880e-01f, 8.50010514e-02f, 1.44504979e-02f, -4.39451151e-02f,
  1.11561827e-01f, -7.71365613e-02f, -1.62588917e-02f, 1.17902026e-01f, -9.45603997e-02f, 5.82782850e-02f, 3.29663679e-02f, 1.25980284e-02f, -5.41500468e-03f, 9.70828831e-02f,
  1.14594335e-02f, -9.57708955e-02f, -9.13600996e-02f, -5.01615740e-02f, 3.93009596e-02f, 1.40933543e-01f, 1.17889985e-01f, 6.36382774e-02f, 2.04184338e-01f, 6.30122274e-02f,
  1.20853737e-01f, 5.45080714e-02f, 7.36056566e-02f, -2.32667644e-02f, 4.86584269e-02f, -7.61837810e-02f, 9.17257592e-02f, -4.40472364e-02f, 1.00216672e-01f, -7.58724362e-02f,
  6.27172440e-02f, 1.17444329e-01f, 1.21800683e-01f, 1.00453325e-01f, 4.03296053e-02f, 1.40622348e-01f, -7.34291375e-02f, -3.79291847e-02f, 7.80754834e-02f, -7.71472603e-02f,
  9.19989049e-02f, -3.40731889e-02f, 4.71944883e-02f, 1.33882403e-01f, -1.10813767e-01f, -1.18677661e-01f, -1.80945564e-02f, -2.90030595e-02f, 2.05860194e-02f, 1.94658831e-01f,
  1.63627654e-01f, -1.44586727e-01f, 1.63380921e-01f, 3.07207592e-02f, 7.19128549e-03f, 9.14103538e-02f, -1.39657587e-01f, -5.40989898e-02f, -2.38303142e-03f, 3.10103083e-03f,
  6.25649616e-02f, 1.17179297e-01f, 1.75079763e-01f, 7.11271465e-02f, -8.03101808e-02f, 1.01659521e-02f, -1.96903516e-02f, 1.51576832e-01f, -6.38580248e-02f, -5.42654581e-02f,
  -3.45342560e-03f, 4.44888845e-02f, -8.89691897e-03f, 1.62751619e-02f, -4.81609404e-02f, 9.40607041e-02f, -1.10664010e-01f, 7.98116252e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -2.91141700e-02f, -3.32008190e-02f, -1.26551315e-01f, -1.73363108e-02f, -1.23412386e-02f, 1.71767101e-01f, -5.93842156e-02f, 1.64662257e-01f, -8.08077976e-02f, 1.32025421e-01f,
  6.50139451e-02f, 1.16779722e-01f, 5.45471907e-02f, -2.27575153e-02f, -1.41575176e-03f, 9.20580793e-03f, 1.95823222e-01f, -4.46703937e-03f, -3.01934853e-02f, 5.69015481e-02f,
  7.46962503e-02f, 7.70247579e-02f, 2.14109957e-01f, 1.91112205e-01f, 1.85024112e-01f, 1.01527758e-01f, 6.49438500e-02f, -7.12607279e-02f, -1.24209724e-01f, -2.82730050e-02f,
  1.95635241e-02f, -2.18174756e-02f, 1.53433442e-01f, 3.68034214e-01f, 2.92176716e-02f, 1.06933057e-01f, 6.71962127e-02f, 2.29437590e-01f, 2.55388737e-01f, -7.82520697e-02f,
  1.35437390e-02f, 4.66692299e-02f, -6.46161512e-02f, 1.43146411e-01f, 1.35669624e-03f, 1.68161944e-01f, 1.29626945e-01f, 1.50693078e-02f, -9.44767892e-02f, 4.37207036e-02f,
  8.37312341e-02f, 8.14495087e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.35652676e-01f, 1.87805027e-01f, 2.20696703e-02f, 1.13610573e-01f, 8.14011917e-02f, 1.16138600e-01f, 1.45622060e-01f, 1.65184125e-01f, -6.55640736e-02f, -2.40874842e-01f,
  8.04017857e-02f, 2.57360160e-01f, -3.67436595e-02f, -1.28819227e-01f, 3.74278519e-04f, -1.32615315e-02f, -5.72978184e-02f, -3.28754410e-02f, -1.13735564e-01f, 2.45261062e-02f,
  -1.46631345e-01f, -1.47676930e-01f, 1.57815646e-02f, 3.56348377e-04f, 7.96371251e-02f, 9.37027577e-03f, 3.12891938e-02f, -4.45735306e-02f, -1.53157309e-01f, -1.36180729e-01f,
  -4.91494089e-02f, 2.19458580e-01f, -8.35732208e-04f, -1.33807287e-01f, -1.35971844e-01f, 3.76108177e-02f, 4.50879820e-02f, 2.15289831e-01f, 3.68842557e-02f, 2.54514664e-02f,
  8.18863213e-02f, 7.87396431e-02f, -1.06385171e-01f, 2.23475937e-02f, 1.42601691e-02f, 1.16225947e-02f, 8.75780825e-03f, -1.29018843e-01f, 1.08150348e-01f, 1.34981304e-01f,
  1.60731807e-01f, -3.67136523e-02f, 4.50090580e-02f, 8.78962427e-02f, -7.64326528e-02f, 1.06187062e-02f, -2.79294103e-02f, -1.63240969e-01f, -9.17618200e-02f, -3.42513137e-02f,
  -3.25195268e-02f, 5.42272143e-02f, 4.01468128e-02f, 4.38975543e-02f, -5.94115444e-02f, -1.11689806e-01f, 1.03582956e-01f, -3.23386975e-02f, -1.04938738e-01f, -1.01216018e-01f,
  5.26981875e-02f, -2.00806126e-01f, 1.59129888e-01f, 9.99410753e-04f, -1.75528452e-01f, -9.28994492e-02f, 8.46159533e-02f, 6.55052140e-02f, 1.57584548e-02f, 1.92656413e-01f,
  -1.07911386e-01f, -7.88054392e-02f, -7.03053027e-02f, 2.11210456e-02f, 2.09994748e-01f, 7.94322044e-02f, -1.25375792e-01f, -8.89956427e-04f, -2.66268430e-03f, 3.50506157e-02f,
  -6.00347295e-02f, -1.29775768e-02f, 2.37409070e-01f, -1.90443301e-03f, -1.55061588e-01f, -2.19589353e-01f, 3.68845984e-02f, 1.02809466e-01f, 1.21660724e-01f, -1.68196395e-01f,
  -5.36832260e-03f, -2.58761551e-02f, -8.93920809e-02f, -1.09075867e-01f, -7.21930414e-02f, -3.55751626e-02f, -6.64382875e-02f, -6.31558523e-02f, -5.13127372e-02f, -1.10777214e-01f,
  -5.35804555e-02f, 1.12675436e-01f, 8.64179581e-02f, -1.74229413e-01f, -2.53017005e-02f, -7.20583275e-02f, -1.18271179e-01f, 7.19339103e-02f, -2.15179790e-02f, -4.91668507e-02f,
  -4.45355251e-02f, -6.72187805e-02f, 1.84053078e-01f, 5.01422118e-03f, -8.34936649e-02f, 9.30837616e-02f, 1.06756620e-01f, -6.11408353e-02f, -9.87265557e-02f, 2.45440844e-02f,
  -1.11589774e-01f, 1.05074778e-01f, -1.15863793e-01f, -8.19529891e-02f, -1.42904803e-01f, 1.59112632e-01f, -1.99901670e-01f, -1.98148608e-01f, -1.93665475e-01f, -2.87075657e-02f,
  -4.88774627e-02f, 4.53490280e-02f, 3.89111862e-02f, -1.32684737e-01f, 1.19182013e-01f, 1.32519066e-01f, -7.09716696e-03f, 2.33990535e-01f, -1.18324563e-01f, -1.78308338e-01f,
  5.08643985e-02f, 1.26896694e-01f, -3.43592204e-02f, 1.24489710e-01f, 1.63025975e-01f, 9.65630915e-03f, 2.04763506e-02f, -1.14700925e-02f, -1.30503932e-02f, 1.80694446e-01f,
  1.65700555e-01f, 4.94154319e-02f, -1.77940205e-01f, 1.13679655e-01f, 3.88103910e-02f, 3.86713967e-02f, 2.01885104e-01f, 1.12021863e-02f, -4.36726138e-02f, -1.92299914e-02f,
  3.87048982e-02f, 1.32098213e-01f, -1.49741739e-01f, -2.37477750e-01f, 6.21141605e-02f, -4.56468463e-02f, -5.89939132e-02f, 1.52056411e-01f, 1.55340254e-01f, 1.37019604e-01f,
  2.17366070e-01f, 1.24705970e-01f, 1.40735626e-01f, 6.86347485e-03f, 2.66102087e-02f, -6.52948022e-02f, -3.31844091e-02f, 1.35524236e-02f, -2.44820174e-02f, -1.17632234e-02f,
  -8.97063464e-02f, -5.65579422e-02f, -1.54157922e-01f, -1.29832968e-01f, 5.08652702e-02f, 8.43183398e-02f, 5.23792319e-02f, 7.29522631e-02f, 9.10072997e-02f, -1.34524629e-01f,
  3.22564170e-02f, 1.44553483e-01f, 1.65702477e-01f, -9.94942486e-02f, -6.89667910e-02f, -7.30658621e-02f, -1.23320565e-01f, 1.61921605e-01f, 2.78765596e-02f, -9.74346548e-02f,
  3.33267376e-02f, -3.74445617e-02f, 1.47638828e-01f, -3.36715654e-02f, -4.45249379e-02f, -8.92856643e-02f, -1.21938944e-01f, -2.50702985e-02f, 8.41032788e-02f, -6.31540194e-02f,
  3.74235027e-02f, 1.05368584e-01f, 7.71706030e-02f, -1.32524222e-02f, -1.65759802e-01f, -1.65497363e-02f, -1.07136384e-01f, -7.73783699e-02f, 7.96188414e-02f, -1.62449941e-01f,
  -1.15808658e-01f, -6.80195540e-02f, -1.24527551e-01f, 3.01404148e-02f, 1.26741454e-01f, -6.13904558e-02f, 1.58851236e-01f, 2.45366216e-01f, -1.23727135e-01f, -8.01132619e-03f,
  -1.62635488e-03f, -4.52391356e-02f, -1.24365695e-01f, 1.42296314e-01f, -1.11451678e-01f, 8.35780129e-02f, 2.80174557e-02f, 7.97952041e-02f, -1.26438558e-01f, -4.55041304e-02f,
  9.44908038e-02f, 7.76814967e-02f, 1.57518774e-01f, -3.94501276e-02f, 1.49850436e-02f, 1.39668599e-01f, -1.20835397e-02f, -1.13873826e-02f, 6.19994029e-02f, -1.42447734e-02f,
  3.93414535e-02f, -3.67253274e-02f, 5.93473949e-02f, 1.32654458e-02f, -5.34985214e-02f, 4.59824391e-02f, -8.79130289e-02f, -2.00496688e-01f, -3.08324248e-02f, 1.29022107e-01f,
  1.02378711e-01f, 1.87504202e-01f, -1.29787654e-01f, 1.20256796e-01f, -3.89693603e-02f, 6.66210800e-02f, 6.90670237e-02f, 8.44776779e-02f, -1.30119488e-01f, -7.62762427e-02f,
  6.50366098e-02f, -1.38559699e-01f, 4.98408675e-02f, 6.18136041e-02f, 2.42772803e-01f, 2.00795546e-01f, -1.63939878e-01f, -8.34539756e-02f, 1.96826272e-02f, 4.53692749e-02f,
  -9.62673351e-02f, 6.08089268e-02f, 2.62676716e-01f, -1.01865277e-01f, -1.10449731e-01f, 3.55549976e-02f, 7.89787024e-02f, -3.34035717e-02f, 5.81889674e-02f, -1.29380092e-01f,
  2.06972197e-01f, -8.36088732e-02f, -7.34122768e-02f, 7.33297616e-02f, 1.32374628e-03f, -1.57895386e-01f, -1.59265429e-01f, 1.70951635e-02f, 9.67912301e-02f, 8.86582434e-02f,
  1.31503657e-01f, -1.47261739e-01f, -9.00689587e-02f, 9.27788764e-02f, 1.25244513e-01f, 8.69837031e-02f, 6.04225090e-03f, 7.61189461e-02f, -9.82844532e-02f, 7.36086965e-02f,
  5.85005805e-03f, -4.53064665e-02f, 9.05231759e-02f, -4.65886593e-02f, -9.40463394e-02f, -8.08400735e-02f, -1.07827418e-01f, -2.38807648e-02f, -1.73078448e-01f, -1.41404755e-02f,
  -2.44235232e-01f, -1.04561560e-01f, 3.47347022e-03f, -1.12255476e-01f, 2.19149143e-02f, 7.43877217e-02f, 3.18594836e-03f, 9.28869992e-02f, -1.14584729e-01f, 1.83788627e-01f,
  1.35318115e-01f, -7.70546347e-02f, 2.53060479e-02f, 1.20154314e-01f, -6.91550747e-02f, -1.01280794e-01f, -5.69566041e-02f, 4.03361730e-02f, 2.70137399e-01f, 2.19198689e-01f,
  4.19246070e-02f, 1.56235266e-02f, 1.85447171e-01f, 1.45769849e-01f, -1.48762271e-01f, -1.06004905e-02f, -3.26488316e-02f, -4.64679375e-02f, -4.55257185e-02f, -1.02620102e-01f,
  -4.70151454e-02f, 5.93978167e-02f, 1.29970685e-02f, -3.01331598e-02f, -5.66534810e-02f, -1.79170281e-01f, 6.16654707e-03f, 4.61307131e-02f, -9.47404653e-02f, 9.40671042e-02f,
  8.96847844e-02f, 9.99473482e-02f, 2.10461140e-01f, -4.78698760e-02f, 7.78932348e-02f, 8.04247111e-02f, -1.93366557e-02f, -7.87525717e-03f, 1.21258952e-01f, -1.69124529e-01f,
  -9.20421481e-02f, 6.68432564e-02f, 7.02893303e-04f, -1.48062825e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.40575248e-02f, -9.70139354e-02f, 9.71707329e-02f, -7.43976980e-02f, 1.33655565e-02f, -4.29502390e-02f, 6.30614385e-02f, 4.88925949e-02f, -8.89790431e-02f, 1.12750746e-01f,
  -9.18322429e-02f, -1.41123950e-01f, 8.46604779e-02f, -1.19252043e-04f, -2.83296946e-02f, 7.95370266e-02f, -2.49740761e-02f, -1.28471941e-01f, -1.61756333e-02f, 2.66070098e-01f,
  1.05767764e-01f, -1.19990222e-01f, -1.42703176e-01f, 1.56986918e-02f, -1.21187702e-01f, -1.14578240e-01f, 1.20441526e-01f, -3.05655021e-02f, 3.35936457e-01f, 2.53676593e-01f,
  1.03459597e-01f, 2.30655119e-01f, 2.31241539e-01f, 3.12837474e-02f, -1.17816322e-01f, 1.83012381e-01f, 2.41127357e-01f, -5.80563806e-02f, 1.53876498e-01f, -1.32098958e-01f,
  -1.70811005e-02f, -1.13869675e-01f, -9.44185480e-02f, -5.68644628e-02f, 1.78495333e-01f, 9.60772298e-03f, 5.33674769e-02f, 1.08187698e-01f, -1.03186116e-01f, -3.69151682e-02f,
  -8.92573968e-02f, 6.52232692e-02f, 2.48782545e-01f, -1.35586828e-01f, 5.18250950e-02f, -2.96936054e-02f, -9.02613476e-02f, -1.11902341e-01f, 5.63210547e-02f, 3.18883955e-02f,
  1.72022637e-02f, -1.04687393e-01f, -2.65472359e-03f, 5.46392985e-02f, -5.10313585e-02f, 1.72906145e-02f, -1.61772929e-02f, 1.27166271e-01f, -7.18509108e-02f, 1.37355775e-01f,
  -8.67013633e-02f, 1.58686731e-02f, -4.76305932e-02f, -2.94889393e-03f, 6.15616739e-02f, 3.66666354e-02f, 2.36353856e-02f, 1.04486868e-01f, -8.35708454e-02f, -1.99161959e-03f,
  8.14963281e-02f, 1.08982928e-01f, 7.12671652e-02f, -4.73736078e-02f, 8.81787241e-02f, 1.10634685e-01f, 8.47077295e-02f, 1.04125276e-01f, -3.31295766e-02f, 3.49573269e-02f,
  -8.74490961e-02f, -2.64866948e-02f, -1.32729247e-01f, -1.04439817e-01f, 2.88340300e-02f, 9.95601434e-03f, -7.50026181e-02f, 7.58498386e-02f, 2.22257227e-02f, -8.68711546e-02f,
  -1.33963034e-01f, 1.58029854e-01f, 6.25444874e-02f, 3.99133489e-02f, -4.37765270e-02f, -7.30228052e-02f, -5.32494411e-02f, 1.04685761e-01f, 2.35965904e-02f, 1.39225051e-01f,
  -4.47357781e-02f, -1.19073391e-02f, 5.62744066e-02f, -7.99084362e-03f, 7.21074194e-02f, 7.42488578e-02f, 1.14810303e-01f, -1.15699530e-01f, 7.77749270e-02f, 1.49717495e-01f,
  -7.64384642e-02f, -6.33829087e-02f, -7.72404149e-02f, -8.94697681e-02f, 1.56039387e-01f, 9.05395299e-02f, 9.10312235e-02f, 6.83522671e-02f, 1.76279008e-01f, 5.51612601e-02f,
  -4.74679992e-02f, -5.03729433e-02f, 9.62912068e-02f, -5.95763093e-03f, -6.29895777e-02f, 2.68639643e-02f, -6.32183403e-02f, 6.28459305e-02f, -7.17941299e-02f, 3.76673043e-02f,
  1.16795450e-01f, 5.76822758e-02f, -7.26307705e-02f, 1.04042783e-01f, 7.32225999e-02f, -2.65110377e-02f, -1.75799821e-02f, 1.71423152e-01f, 9.06783491e-02f, 1.32816896e-01f,
  -8.90725851e-02f, -1.14348583e-01f, -7.96207115e-02f, -5.78265125e-03f, 5.07247262e-02f, 2.63374187e-02f, 2.53537267e-01f, -8.15984756e-02f, -8.34533200e-02f, 1.00106850e-01f,
  1.60414457e-01f, 1.46096408e-01f, -4.69567738e-02f, -2.10703295e-02f, 1.00716330e-01f, -4.53443751e-02f, 2.44072173e-02f, -1.11691587e-01f, -1.03148036e-01f, -7.10603967e-02f,
  -9.70959812e-02f, -1.29837379e-01f, -4.47406583e-02f, 3.72936614e-02f, 9.14345379e-04f, -2.33620107e-02f, -3.07593886e-02f, 1.13596365e-01f, 3.98726985e-02f, 9.37900916e-02f,
  -2.15369128e-02f, -4.89461347e-02f, -1.16868623e-01f, -5.78317940e-02f, 5.44835106e-02f, 1.10333286e-01f, 1.18190274e-01f, -4.46590409e-02f, -1.10335752e-01f, -4.11478318e-02f,
  4.08992618e-02f, -2.65364088e-02f, -6.03861138e-02f, -5.19279353e-02f, 1.47258013e-01f, 9.19526368e-02f, 1.31013960e-01f, -5.95115358e-03f, 1.05831563e-01f, 9.91549566e-02f,
  -8.36800337e-02f, -1.04248136e-01f, 1.43508255e-01f, -6.80046752e-02f, 5.25900535e-02f, 1.34419948e-01f, -1.01547830e-01f, 7.15845302e-02f, -1.08905002e-01f, -3.26850116e-02f,
  7.97566846e-02f, 2.09888984e-02f, -6.46121502e-02f, 7.06767663e-02f, -6.61940351e-02f, 1.26370251e-01f, -5.76593913e-02f, -3.83023657e-02f, 1.27291307e-01f, -9.62886736e-02f,
  -7.77607486e-02f, -6.51308522e-02f, 1.31096423e-01f, -6.17118366e-02f, 6.95756301e-02f, 1.22366957e-01f, -2.07765307e-03f, 9.17201340e-02f, -6.05342947e-02f, 1.16560780e-01f,
  -1.45059722e-02f, -2.88404692e-02f, -6.56864792e-02f, -4.68343422e-02f, -1.78064518e-02f, 1.30513702e-02f, -1.01189084e-01f, 7.68039450e-02f, -3.07394061e-02f, 1.79631133e-02f,
  -5.92023022e-02f, -5.37858531e-02f, 1.63826138e-01f, 8.93391743e-02f, -2.09197681e-02f, -8.45929906e-02f, 4.52135801e-02f, 9.99820307e-02f, 3.40602733e-02f, 3.29329893e-02f,
  -8.15396234e-02f, 9.97982323e-02f, -4.37262729e-02f, 6.99630333e-03f, 4.20264974e-02f, -8.18075985e-02f, 2.27293760e-01f, 2.13725984e-01f, 2.21026510e-01f, 2.05206901e-01f,
  1.89327642e-01f, 1.01824729e-02f, -1.47115156e-01f, -5.23846745e-02f, -1.24680199e-01f, -6.88212039e-03f, 7.52673158e-03f, -6.36176765e-02f, -7.19170123e-02f, 1.87968966e-02f,
  -6.12328686e-02f, 9.94771495e-02f, -2.30372697e-02f, 1.39386714e-01f, 3.91168818e-02f, -7.16078877e-02f, 1.03879124e-01f, 2.06970081e-01f, -1.62104461e-02f, 6.33642972e-02f,
  -1.26429722e-01f, -1.42683461e-01f, -1.20560601e-01f, -8.86141434e-02f, 1.68976083e-01f, 1.38588935e-01f, 1.07827976e-01f, -1.38990596e-01f, 5.64955315e-03f, 6.11222200e-02f,
  1.84057370e-01f, -5.18937744e-02f, 5.76338470e-02f, -1.45738468e-01f, 6.53361082e-02f, 1.18014002e-02f, 8.69437456e-02f, 6.31234189e-03f, 1.24795437e-01f, -9.22913402e-02f,
  1.17778033e-01f, 2.10552081e-01f, -7.70451874e-02f, 2.52592117e-01f, 6.14009276e-02f, -1.18557811e-02f, -1.52512193e-01f, 1.07465662e-01f, 1.35148391e-01f, -1.39149442e-01f,
  -8.38033482e-02f, 1.36687145e-01f, -1.08196490e-01f, 9.53524634e-02f, 2.36286849e-01f, -7.62797520e-02f, -1.17799573e-01f, 6.56615128e-04f, 9.43167135e-02f, -1.29636703e-02f,
  1.49640724e-01f, -6.27880171e-02f, 1.69926137e-01f, -3.51934955e-02f, 6.48070425e-02f, 2.71244254e-02f, 2.88034491e-02f, -1.16247505e-01f, 9.97237861e-02f, -7.52246305e-02f,
  1.66044697e-01f, 2.40858942e-02f, 4.30376176e-03f, -8.32445696e-02f, 8.68066121e-03f, 9.29329246e-02f, 7.89731741e-02f, -8.07674527e-02f, 7.17010871e-02f, 4.80547957e-02f,
  3.62440646e-02f, 6.74560890e-02f, -9.46286544e-02f, 3.23555209e-02f, 4.01145183e-02f, -6.94874972e-02f, -8.34441781e-02f, 2.95443293e-02f, 1.64971426e-01f, 1.19519763e-01f,
  1.71994721e-03f, -9.03422832e-02f, 8.57984871e-02f, -5.61604761e-02f, 1.57544807e-01f, -7.48869181e-02f, 6.19402789e-02f, 8.30441490e-02f, 1.14850290e-02f, -1.11349382e-01f,
  8.01980272e-02f, -2.91470736e-02f, 1.23203322e-01f, 7.74118006e-02f, 3.94549854e-02f, 2.88849384e-01f, 2.10879352e-02f, 3.80390435e-02f, -1.18562795e-01f, 1.71078276e-02f,
  1.30136475e-01f, 7.54695013e-02f, -5.70837706e-02f, 8.11708346e-02f, -4.43757102e-02f, 3.56095247e-02f, -1.24749355e-01f, 1.39889926e-01f, -6.13254495e-02f, -5.10134511e-02f,
  -2.49843989e-02f, -2.11473890e-02f, -1.00867823e-01f, 1.01005845e-01f, -1.52235143e-02f, 8.65927190e-02f, -5.30326553e-03f, 5.85673489e-02f, -7.97702372e-02f, -8.06536525e-02f,
  8.65846127e-03f, -1.08096205e-01f, -1.19509570e-01f, -1.00243747e-01f, -1.54237941e-01f, -1.22914515e-01f, -2.95314156e-02f, -2.62273625e-02f, 8.30715969e-02f, -5.47506213e-02f,
  -2.76153293e-02f, -4.26242724e-02f, -1.25688076e-01f, -6.31764010e-02f, 7.41039664e-02f, -1.01568773e-01f, -6.56186119e-02f, -5.37130758e-02f, 6.31399602e-02f, 6.40921947e-03f,
  1.31083369e-01f, 5.45420591e-03f, 1.00632794e-01f, 6.21941760e-02f, -1.56770684e-02f, 7.36684864e-03f, -2.19783466e-02f, -6.57697320e-02f, -5.57779614e-03f, 1.33959269e-02f,
  -4.73974422e-02f, 3.52320820e-02f, 1.31747261e-01f, -9.63838100e-02f, 7.21774111e-03f, 1.51935779e-03f, -2.70387381e-02f, -1.38698727e-01f, 1.01876348e-01f, -5.03199920e-02f,
  1.24409810e-01f, 7.22877905e-02f, -6.12092540e-02f, -8.85947198e-02f, 1.06320128e-01f, 1.26968041e-01f, 5.08090891e-02f, 5.17438129e-02f, -5.29783517e-02f, 1.37572229e-01f,
  6.00720830e-02f, -6.29909411e-02f, 5.94218485e-02f, -1.31601229e-01f, 4.75334451e-02f, 1.28112426e-02f, -1.01319633e-01f, 7.32765198e-02f, 1.60963446e-01f, 6.50926605e-02f,
  3.28122154e-02f, 8.58567879e-02f, 7.42482096e-02f, 1.91740841e-01f, -8.51792917e-02f, 1.25160649e-01f, -1.18057216e-02f, -1.37150288e-01f, -8.95050988e-02f, 3.96520980e-02f,
  -1.25734016e-01f, 1.08806238e-01f, -2.56681740e-02f, -4.10895981e-02f, 1.31646574e-01f, -8.16159919e-02f, -1.06575012e-01f, -4.20722291e-02f, 1.26401689e-02f, -6.88058808e-02f,
  -3.67839895e-02f, 1.26862377e-01f, 1.11685658e-03f, -9.08656195e-02f, 6.88505024e-02f, -3.51041742e-02f, 4.40268181e-02f, -6.97991997e-02f, -6.60645515e-02f, 4.71387431e-02f,
  6.21282533e-02f, 8.92607048e-02f, 7.07959086e-02f, 6.54755831e-02f, -6.00386374e-02f, 7.30505511e-02f, -1.02304131e-01f, 1.30591452e-01f, -9.97186601e-02f, -4.17491198e-02f,
  -5.73963523e-02f, -1.13835847e-02f, 2.23549921e-02f, -4.58505675e-02f, -1.16755947e-01f, 6.90482855e-02f, 1.05840512e-01f, -7.60569051e-02f, -4.37420374e-03f, -4.51876223e-02f,
  2.75431923e-03f, -8.56879819e-03f, -1.06307399e-02f, -1.05483301e-01f, 1.39315054e-01f, -1.32458419e-01f, -7.52878338e-02f, 9.71833691e-02f, -3.65747809e-02f, 7.86434263e-02f,
  7.76446424e-03f, -1.07201554e-01f, 1.12918124e-01f, -4.46932018e-02f, 7.87378252e-02f, 8.04203376e-02f, -1.56144574e-02f, 1.06177591e-01f, -3.72508611e-03f, 1.00463614e-01f,
  -6.25088364e-02f, 1.98323000e-02f, -3.73836383e-02f, 2.23708320e-02f, -1.21584833e-01f, -6.86255768e-02f, -4.84765768e-02f, 6.75630942e-02f, 5.26712202e-02f, -1.87050644e-02f,
  -9.93528683e-03f, 1.72439322e-01f, -6.62372038e-02f, 8.43201876e-02f, -1.18066944e-01f, 1.92842111e-02f, -1.23584986e-01f, -8.78666900e-03f, 3.22979651e-02f, -7.10803941e-02f,
  -1.00182556e-01f, -1.07886873e-01f, -1.56738386e-02f, 1.48992121e-01f, -8.04128274e-02f, -6.84860274e-02f, 1.12359345e-01f, 1.86001197e-01f, -1.40511781e-01f, 1.31421193e-01f,
  2.47069336e-02f, 9.90467295e-02f, -2.11969856e-02f, -9.43804719e-03f, -1.11947350e-01f, -3.94141562e-02f, -7.89369084e-03f, 2.29609152e-03f, 5.97728975e-02f, 3.74024548e-02f,
  4.51878123e-02f, 2.92413644e-02f, 2.24827118e-02f, -5.55469468e-03f, 8.85913000e-02f, 1.80334710e-02f, -1.31588876e-01f, -6.80339057e-03f, 1.42108247e-01f, -1.09422892e-01f,
  2.73797493e-02f, 7.55984485e-02f, -2.17844499e-03f, -4.26761992e-02f, -8.20436627e-02f, -1.47270868e-02f, -1.06034512e-02f, -7.99531341e-02f, -9.54826400e-02f, -1.10676400e-01f,
  4.46974523e-02f, -2.60924064e-02f, -1.02783896e-01f, -5.14585059e-03f, -8.74817297e-02f, 9.20440555e-02f, 1.49454176e-01f, -6.18017372e-03f, 1.04871765e-02f, 6.59932569e-02f,
  -1.16206475e-01f, 3.17608006e-02f, -6.48371577e-02f, -6.96238577e-02f, 1.08316801e-01f, -1.70186197e-03f, 1.80101767e-01f, -6.34589884e-03f, -8.02014768e-02f, -1.18572861e-01f,
  7.96322227e-02f, -4.59528603e-02f, 1.38058573e-01f, -9.75815579e-02f, 1.24070197e-01f, 1.57799572e-01f, -1.98550522e-02f, 1.22512840e-01f, 7.41933957e-02f, 8.74809697e-02f,
  -2.91856080e-02f, -5.00872545e-02f, -7.96889514e-02f, -1.72431499e-01f, -5.40571064e-02f, 6.50672242e-02f, 5.27974702e-02f, -7.06040561e-02f, 9.24515724e-02f, -1.30719189e-02f,
  1.38368011e-02f, 2.14853302e-01f, 9.59346518e-02f, 1.10240839e-01f, -6.21471331e-02f, 1.69143081e-01f, 1.20601781e-01f, 6.33053109e-02f, 5.70722446e-02f, -3.87428999e-02f,
  5.08102439e-02f, 3.38314772e-02f, -1.34036876e-02f, 9.62433368e-02f, 4.96822186e-02f, -4.05905135e-02f, -9.08494070e-02f, 8.71499628e-02f, 1.12375692e-01f, 3.91692333e-02f,
  2.11783901e-01f, 1.91913530e-01f, 1.76194593e-01f, 9.62408781e-02f, 1.03193477e-01f, 1.43672720e-01f, 2.46205077e-01f, 2.20992610e-01f, 5.80495130e-03f, -2.21565455e-01f,
  1.07971877e-01f, 2.50905305e-01f, -5.96842542e-02f, -1.80624425e-02f, 1.22239880e-01f, 9.18943286e-02f, 9.19440016e-02f, 1.27288550e-01f, -3.53807174e-02f, 1.79321095e-01f,
  -5.20745069e-02f, -1.14362463e-01f, -1.51240304e-01f, 2.03117672e-02f, -7.32798725e-02f, 9.68833044e-02f, 3.33649069e-01f, 1.51567474e-01f, 1.99842080e-01f, 2.08346009e-01f,
  9.06821713e-02f, 1.31440863e-01f, 2.80072750e-03f, -1.24240205e-01f, -1.02967963e-01f, 2.57472306e-01f, 2.52141893e-01f, 2.21023455e-01f, -1.35194078e-01f, -1.46090671e-01f,
  -2.89119929e-02f, 1.92520261e-01f, -9.85903218e-02f, -9.15032327e-02f, 9.11078304e-02f, 3.55018944e-01f, 3.47376391e-02f, 4.17761318e-02f, -5.10229431e-02f, 3.66421156e-02f,
  2.97185749e-01f, -4.19186614e-02f, 1.91115960e-01f, -6.64094137e-03f, 5.84154315e-02f, -1.99217737e-01f, 4.59528007e-02f, -1.18671425e-01f, -8.06734040e-02f, 1.96142197e-01f,
  -4.49186424e-04f, 1.87711548e-02f, 4.64285053e-02f, -3.64016518e-02f, 1.35375842e-01f, 1.06700823e-01f, -2.25512255e-02f, 5.94415627e-02f, -7.25758299e-02f, -5.44822440e-02f,
  7.21267685e-02f, -4.99341488e-02f, 1.14476271e-01f, 1.13279797e-01f, -2.34702658e-02f, 5.16233854e-02f, -1.02398150e-01f, 6.09519966e-02f, -8.28142539e-02f, 1.44335777e-01f,
  -6.14228882e-02f, 5.55420890e-02f, -1.14300281e-01f, 4.79729846e-02f, 4.32173908e-02f, -8.14160630e-02f, -2.41743363e-02f, -1.76856369e-02f, 9.50782280e-03f, 8.10253695e-02f,
  1.45336822e-01f, -1.08369611e-01f, 3.89847998e-03f, 4.18401584e-02f, 1.84249021e-02f, 3.54038775e-02f, -8.81598294e-02f, -8.34260732e-02f, -7.85828456e-02f, -1.03874892e-01f,
  6.89443201e-02f, 1.20988280e-01f, 7.03206891e-03f, 5.26646189e-02f, 5.21422662e-02f, 1.23505414e-01f, 8.85951221e-02f, 7.29841664e-02f, 1.13437399e-01f, 2.21476614e-01f,
  -5.94808385e-02f, 1.15305528e-01f, 7.81743005e-02f, -1.15056723e-01f, 4.80567180e-02f, 1.53536890e-02f, -5.75236157e-02f, 2.98302285e-02f, -1.19121462e-01f, -6.47805259e-02f,
  -1.24904871e-01f, -3.24962358e-03f, 1.25263743e-02f, -3.70910726e-02f, -6.47844598e-02f, 1.05487611e-02f, 1.14682719e-01f, -3.57556678e-02f, 1.71851501e-01f, 3.05852860e-01f,
  3.05089802e-01f, 1.18214808e-01f, 2.15347141e-01f, 2.20417053e-01f, 2.43311942e-01f, 1.33357078e-01f, -1.26733994e-02f, -1.73110962e-01f, -5.91455363e-02f, 1.32045910e-01f,
  -1.22494977e-02f, 1.02701083e-01f, -3.38318292e-04f, 4.16231947e-03f, -1.16791531e-01f, 2.00624526e-01f, -8.62606391e-02f, -8.23177695e-02f, -1.38276279e-01f, 5.56808896e-02f,
  -6.08268864e-02f, 1.52786851e-01f, -6.75042272e-02f, 1.35404855e-01f, -3.59144807e-02f, 6.97495937e-02f, 1.57598838e-01f, -1.92754820e-01f, -9.19401646e-02f, -6.74996153e-02f,
  1.64478436e-01f, 5.96939661e-02f, 1.62728205e-01f, 2.07590330e-02f, 2.12341428e-01f, 2.52735555e-01f, -5.22165485e-02f, 3.32906991e-02f, 8.89177844e-02f, 8.97597224e-02f,
  -9.79883671e-02f, -8.23098123e-02f, -2.58737504e-02f, -1.05078379e-02f, 1.20923191e-01f, -1.62135184e-01f, -2.06018202e-02f, -1.08658627e-01f, 1.72028825e-01f, -1.42982572e-01f,
  -1.69325441e-01f, 7.83322826e-02f, -5.45615470e-03f, 1.91649407e-01f, 6.24731136e-03f, 8.83387588e-03f, -2.41219252e-01f, 2.84343362e-02f, -2.20998265e-02f, 1.20136693e-01f,
  9.70776938e-03f, 8.02307948e-02f, -3.73697537e-03f, 4.74916846e-02f, -2.38822848e-02f, -3.61175090e-02f, 1.23585537e-01f, 1.59939632e-01f, -1.52772576e-01f, -1.11193933e-01f,
  -2.93589663e-02f, 7.92282373e-02f, 2.42967889e-01f, -9.09262300e-02f, 9.36800689e-02f, -1.34808317e-01f, 8.46391171e-02f, -5.68787083e-02f, 6.98280707e-02f, -1.33726835e-01f,
  2.06561401e-01f, 1.45875350e-01f, 5.20948507e-03f, -4.72593196e-02f, 1.09670565e-01f, -1.02564231e-01f, -2.61742081e-02f, -4.58326982e-03f, -2.98372488e-02f, -5.55017684e-03f,
  -1.37421831e-01f, 1.86543576e-02f, 1.48341373e-01f, -5.95941618e-02f, -7.13523924e-02f, 4.30822521e-02f, 1.26099661e-01f, 1.35220122e-02f, -5.70571236e-02f, -1.04230285e-01f,
  1.66224867e-01f, -1.29519522e-01f, -1.29117355e-01f, 1.66153073e-01f, 1.24880105e-01f, 2.32410096e-02f, 1.18564017e-01f, 3.88795078e-01f, -1.64699495e-01f, 1.52130798e-01f,
  4.43568118e-02f, 1.82415724e-01f, 1.40060961e-01f, -3.50124873e-02f, 5.55976108e-02f, 9.00459588e-02f, -8.63611326e-02f, -6.30692067e-03f, -1.00292325e-01f, -2.64005437e-02f,
  4.49383967e-02f, 2.93029808e-02f, 1.22374251e-01f, -1.21239454e-01f, -4.31418195e-02f, 1.87491864e-01f, -1.00973025e-01f, 1.16583288e-01f, 5.33017963e-02f, -4.79798615e-02f,
  -9.89501830e-03f, 7.48409927e-02f, 6.03663288e-02f, 2.80357320e-02f, -2.27270033e-02f, 2.98596192e-02f, -6.42544925e-02f, 7.87349418e-02f, -1.10472552e-01f, -4.87990640e-02f,
  -9.21572968e-02f, 4.95879613e-02f, 4.61429916e-02f, 1.27907470e-01f, -5.23387268e-02f, -7.15258792e-02f, -8.37455392e-02f, -6.29818738e-02f, 9.30077508e-02f, -4.91883978e-02f,
  5.12169562e-02f, 1.08268775e-01f, -5.56413196e-02f, 6.83505982e-02f, -8.08286145e-02f, 8.03746134e-02f, -2.36711707e-02f, -3.76789011e-02f, -2.96310824e-03f, -5.84118553e-02f,
  -7.69849792e-02f, -6.28365502e-02f, 2.09596884e-02f, -1.17136739e-01f, -4.25284691e-02f, -1.69615466e-02f, 5.25931790e-02f, 8.08190554e-02f, -9.92864221e-02f, 6.16400540e-02f,
  -1.31682068e-01f, -9.26937014e-02f, -4.17248532e-02f, 7.96994790e-02f, 1.26990825e-01f, -1.19179703e-01f, 4.64380085e-02f, 1.16353981e-01f, 5.40890545e-02f, 5.13401031e-02f,
  -8.52547660e-02f, 3.99016403e-02f, -3.60551360e-03f, 5.14532626e-02f, 8.66874754e-02f, 1.91870257e-02f, -1.12947032e-01f, -5.09971045e-02f, -2.34319922e-02f, -1.04030587e-01f,
  2.05283359e-01f, 4.47587706e-02f, 1.85743630e-01f, 3.53301726e-02f, 1.44710347e-01f, 1.63438067e-01f, 9.49355494e-03f, 2.53583454e-02f, -9.03946981e-02f, -5.93951344e-02f,
  -6.50075078e-02f, 1.77141488e-01f, -1.28492236e-01f, -1.46742277e-02f, -5.39687946e-02f, 1.12186223e-01f, 1.24634266e-01f, -5.57656698e-02f, -1.58915464e-02f, -2.30644867e-02f,
  -1.32587969e-01f, 8.59148204e-02f, 1.33937836e-01f, 1.73811570e-01f, 1.30781950e-02f, 6.44554719e-02f, -1.78620473e-01f, -5.14003448e-03f, -1.71453759e-01f, -1.59711465e-01f,
  -1.14794150e-02f, -1.56633481e-01f, -1.10640518e-01f, -1.34489059e-01f, 1.10046215e-01f, 2.41034199e-02f, -1.79158039e-02f, 1.59622923e-01f, -2.15899497e-02f, 1.02320820e-01f,
  -1.18008867e-01f, -5.79943135e-02f, 6.49958029e-02f, 1.00855649e-01f, 9.93725061e-02f, 2.36108154e-01f, 1.04387760e-01f, -8.74714181e-02f, -5.86781949e-02f, 1.03919119e-01f,
  2.14388341e-01f, -8.56707394e-02f, -1.52591139e-01f, 1.85228065e-02f, -4.09782715e-02f, 2.46823113e-02f, 4.09424044e-02f, 8.86303559e-02f, 5.61137050e-02f, 2.91563608e-02f,
  -1.05920680e-01f, 1.04760624e-01f, 2.09918302e-02f, -2.82562468e-02f, 1.25487477e-01f, 1.30824178e-01f, -1.16713852e-01f, 5.26266396e-02f, 4.89706099e-02f, -8.29761699e-02f,
  4.51765861e-03f, 3.74237597e-02f, 5.51375262e-02f, -1.07468739e-01f, 9.07717943e-02f, -1.01564169e-01f, 4.12904983e-03f, -8.31018090e-02f, -7.99768493e-02f, 8.29381943e-02f,
  -1.13479048e-01f, 9.72991362e-02f, 1.08882099e-01f, 7.69688413e-02f, -1.04058556e-01f, 4.87018451e-02f, -2.32045390e-02f, -2.85996906e-02f, 7.02535659e-02f, -1.13415018e-01f,
  6.95978701e-02f, -4.57869619e-02f, -1.41028866e-01f, 3.36002894e-02f, 2.99801230e-02f, 1.52327865e-01f, 1.29566267e-01f, -1.02877833e-01f, -3.73757817e-02f, 1.60717249e-01f,
  -1.34768903e-01f, -2.43848190e-02f, 1.29908502e-01f, -1.32979691e-01f, -7.53202289e-02f, -6.64607510e-02f, 1.19826563e-01f, -5.11932820e-02f, 6.51185662e-02f, -1.92078091e-02f,
  3.72134745e-02f, -1.19921990e-01f, -6.81291744e-02f, 4.04616706e-02f, 9.91324261e-02f, 8.94281194e-02f, 3.89405452e-02f, 3.32248025e-02f, -7.13461563e-02f, 1.23441629e-02f,
  1.63973477e-02f, -4.77297008e-02f, 2.17011049e-02f, -2.79412568e-02f, 5.13902381e-02f, 5.70623763e-02f, -4.68411529e-03f, 1.49944369e-02f, 4.85762730e-02f, -6.45662993e-02f,
  -1.89624242e-02f, 1.05355978e-02f, 1.03375167e-01f, 3.48398238e-02f, 1.03168137e-01f, 2.28192415e-02f, -5.64199537e-02f, 5.10986894e-02f, 1.82553634e-01f, -5.42395972e-02f,
  8.82726833e-02f, 4.69390377e-02f, -3.30793858e-02f, 6.78286776e-02f, -1.07913345e-01f, -2.09424272e-02f, -1.88280120e-02f, -9.31503437e-03f, -8.64209011e-02f, -3.81393917e-02f,
  -1.24331795e-01f, 4.47195582e-02f, 1.20153911e-01f, 3.28631178e-02f, 5.26637100e-02f, 1.03557952e-01f, 3.06724124e-02f, 1.46094799e-01f, -1.03607297e-01f, 1.36860922e-01f,
  2.21862067e-02f, -7.65478387e-02f, 4.78798226e-02f, 3.91597450e-02f, 2.29775324e-01f, -9.77736861e-02f, 4.90595102e-02f, -6.59537539e-02f, 5.65826632e-02f, 1.99906215e-01f,
  1.18156165e-01f, -3.25096808e-02f, -7.69610256e-02f, 2.23188549e-01f, -5.26030175e-02f, -4.79223626e-03f, 5.59340380e-02f, -1.07552662e-01f, 9.74936187e-02f, 1.31245747e-01f,
  3.59671786e-02f, 1.12648875e-01f, 2.33385898e-02f, -1.15546182e-01f, -7.65711889e-02f, -6.36443077e-03f, -4.33963686e-02f, 1.82523921e-01f, -1.56912897e-02f, 4.48792689e-02f,
  -5.70955984e-02f, 1.50734544e-01f, -1.16557419e-01f, -1.20412834e-01f, -7.04707950e-02f, -3.87181640e-02f, 2.15693749e-02f, -1.08854666e-01f, -5.14706858e-02f, -1.28647760e-01f,
  5.02005070e-02f, -7.87872672e-02f, -1.32534325e-01f, 8.93652961e-02f, -7.60993659e-02f, 3.14034638e-03f, 6.47514984e-02f, 5.62894978e-02f, 6.04262203e-02f, 5.73433898e-02f,
  4.14203331e-02f, -1.80708654e-02f, 1.48116946e-01f, 1.16796643e-01f, 1.16053686e-01f, -3.78174223e-02f, -3.76194790e-02f, -7.96174705e-02f, 6.21070601e-02f, 9.54472870e-02f,
  1.28449937e-02f, 1.89790204e-01f, 4.87421490e-02f, -3.99830416e-02f, 2.15905905e-02f, 8.83752108e-02f, 1.35301426e-01f, 2.69506853e-02f, 1.12205036e-01f, -4.31529572e-03f,
  -1.49834370e-02f, 8.15014392e-02f, 2.31225938e-02f, -5.10759279e-02f, -1.08608834e-01f, -1.00450903e-01f, -7.06285685e-02f, 1.04523450e-01f, 1.31753549e-01f, 3.98167176e-03f,
  -4.39484082e-02f, -2.75337417e-03f, 6.21384308e-02f, 1.13407917e-01f, 1.51011199e-01f, -6.73793629e-03f, -8.95106494e-02f, 1.07788399e-01f, 7.46372789e-02f, 1.76361408e-02f,
  9.78849158e-02f, -6.04524277e-02f, -2.76654549e-02f, 8.01090226e-02f, 7.86850601e-02f, -1.23436131e-01f, -1.11304313e-01f, -2.36258563e-03f, 1.38300866e-01f, 1.99419409e-02f,
  -1.06850892e-01f, 1.00382753e-01f, -7.11149424e-02f, -1.37766197e-01f, -1.35116186e-02f, 1.51726589e-01f, 1.71250492e-01f, 1.06138043e-01f, -1.64848324e-02f, 9.67299193e-02f,
  1.19013630e-01f, 1.72700480e-01f, -7.73229916e-03f, 1.18608855e-01f, 1.40668573e-02f, 2.13769302e-02f, 9.06151533e-02f, 9.22298208e-02f, -4.00143530e-04f, 1.06025137e-01f,
  7.23060360e-03f, -6.19475134e-02f, 4.37787212e-02f, -7.25349337e-02f, -1.49927899e-01f, 2.88216379e-02f, -4.72857431e-02f, 9.21241418e-02f, -1.55128002e-01f, 3.39075252e-02f,
  1.60933897e-01f, -7.37599283e-02f, 2.34420761e-01f, 2.99936477e-02f, -6.54272586e-02f, 5.46533279e-02f, -1.24654531e-01f, 2.29829773e-01f, 3.89611721e-02f, 8.88090059e-02f,
  8.95837918e-02f, 3.97693485e-01f, -3.01201101e-02f, 3.46239768e-02f, -8.87416229e-02f, 1.02931201e-01f, 1.86900571e-01f, -4.04896438e-02f, -9.77319404e-02f, 1.18977711e-01f,
  -6.94663823e-02f, 9.83632281e-02f, -8.02102834e-02f, 6.67276233e-02f, 1.41559079e-01f, 1.06914211e-02f, 9.16817337e-02f, 8.26723725e-02f, -3.37954871e-02f, 1.18506439e-01f,
  1.04013309e-01f, 7.79203791e-03f, 8.35854337e-02f, 9.52969193e-02f, 4.04291563e-02f, 4.98591252e-02f, 5.68530671e-02f, 1.66340157e-01f, 3.33829634e-02f, -1.41267672e-01f,
  -5.74905910e-02f, 1.22433431e-01f, -3.42469774e-02f, 8.59409869e-02f, -9.26185325e-02f, 1.33311525e-01f, -3.11412886e-02f, 3.12456116e-02f, -1.15681268e-01f, -1.59465279e-02f,
  1.08995348e-01f, -3.43606435e-02f, 1.14891576e-02f, 1.43337518e-01f, 7.40759494e-03f, 7.08612334e-03f, 2.01059636e-02f, 4.58663888e-02f, 1.62194118e-01f, 3.54025550e-02f,
  -8.20660219e-02f, 1.18256904e-01f, 1.58917069e-01f, -4.08533178e-02f, -5.45032732e-02f, 8.95527601e-02f, 7.80212432e-02f, 1.94059629e-02f, -1.48141887e-02f, 4.13483568e-02f,
  -3.68658975e-02f, 4.70847636e-02f, 1.04888357e-01f, -1.12496614e-01f, -3.00103035e-02f, 1.03663459e-01f, 1.12624913e-01f, -8.86212289e-02f, 8.24929401e-02f, 1.40626147e-01f,
  9.79621261e-02f, -1.14059210e-01f, 1.35031998e-01f, -8.44751000e-02f, -5.41530624e-02f, 6.99011907e-02f, 1.29046710e-02f, -2.24478892e-03f, -9.74368975e-02f, -5.77654094e-02f,
  -1.16975285e-01f, 4.79512103e-02f, -3.61092724e-02f, -8.51032734e-02f, 1.14694629e-02f, -1.33751184e-02f, -4.06271219e-02f, 1.34779572e-01f, 7.93292150e-02f, 6.72865510e-02f,
  -9.39009935e-02f, -1.59762651e-01f, -9.88864377e-02f, 1.39868990e-01f, -2.64801588e-02f, 1.07297497e-02f, 6.14045709e-02f, 2.93384232e-02f, 5.42091951e-02f, 1.22668974e-01f,
  3.70436981e-02f, -5.32114506e-02f, 4.36447337e-02f, 2.17808411e-02f, -5.96161373e-02f, 3.77678014e-02f, 8.99174958e-02f, -1.34785905e-01f, -7.62462094e-02f, -2.49356795e-02f,
  -7.49046206e-02f, -2.13542972e-02f, 6.42012730e-02f, -1.10482521e-01f, -3.72838154e-02f, 8.76820907e-02f, -8.92263278e-02f, 1.07216239e-01f, 7.54385665e-02f, 8.10312480e-02f,
  8.52451324e-02f, -5.75565696e-02f, 8.14143277e-04f, -7.88845718e-02f, 2.46646907e-02f, -8.91177431e-02f, 7.65212402e-02f, 1.60019880e-03f, 1.85366925e-02f, 6.03396706e-02f,
  6.27151206e-02f, 1.67206317e-01f, 4.93914001e-02f, -5.87129518e-02f, -1.14776269e-02f, 1.04551069e-01f, 8.78636912e-02f, -1.27678156e-01f, -1.17064126e-01f, 2.93980055e-02f,
  -9.89869237e-02f, 5.00307605e-02f, 1.61119610e-01f, -1.17480770e-01f, -6.53253198e-02f, -4.51898575e-02f, -2.90223700e-03f, -3.70373428e-02f, 1.75331727e-01f, 2.57553220e-01f,
  2.74827540e-01f, 2.28305563e-01f, 2.47431383e-01f, 1.44318908e-01f, -1.29817024e-01f, 2.32699662e-01f, -9.59895328e-02f, -1.70580372e-01f, -1.09050326e-01f, -4.96016406e-02f,
  3.89525890e-02f, -7.28231519e-02f, 1.23646399e-02f, -8.07241052e-02f, 1.57376826e-02f, 1.83138907e-01f, -1.27646357e-01f, 8.13220069e-02f, 3.20965536e-02f, -1.54209465e-01f,
  -9.26046371e-02f, 2.15129644e-01f, 5.88822067e-02f, -3.64279114e-02f, 6.66996539e-02f, -3.31064090e-02f, 1.01612240e-01f, 8.43372941e-02f, 1.20275822e-02f, 2.97905028e-01f,
  1.34325132e-01f, 7.20037296e-02f, 2.49857698e-02f, 2.49551028e-01f, -9.01985839e-02f, 9.83876735e-02f, 5.55880181e-03f, -1.09667867e-01f, 2.28211042e-02f, -9.40511450e-02f,
  1.80864595e-02f, -4.75651510e-02f, 2.91154590e-02f, -7.86484554e-02f, 6.11439794e-02f, 2.02362286e-03f, -1.08885979e-02f, 2.61482656e-01f, 3.54221016e-02f, 9.95939746e-02f,
  1.96766034e-01f, 4.46756743e-02f, -7.81909190e-03f, 4.55556363e-02f, 6.28671199e-02f, 8.06769822e-03f, -1.85349226e-01f, -1.12748304e-02f, -4.18133149e-03f, 3.95573191e-02f,
  -6.26316071e-02f, 4.40245718e-02f, 7.25398958e-02f, 7.64751732e-02f, 6.97709322e-02f, 1.57693893e-01f, 8.29802305e-02f, 1.33173063e-01f, -9.15135443e-02f, 6.57550544e-02f,
  3.43906209e-02f, -2.87236851e-02f, -3.26599240e-01f, -2.71047503e-01f, -1.27082393e-01f, 4.06726971e-02f, -1.29126340e-01f, 1.61469579e-01f, 3.82157303e-02f, 1.10200495e-02f,
  -1.46712527e-01f, 1.48157671e-01f, 1.29276574e-01f, -9.25524309e-02f, -7.77169093e-02f, 3.35320011e-02f, -1.04392730e-01f, -1.12390064e-01f, 1.03665344e-01f, 1.04865476e-01f,
  5.79537749e-01f, 2.34566867e-01f, -1.32701859e-01f, 5.22262156e-02f, 1.51178747e-01f, 2.14504004e-01f, 3.03325728e-02f, 9.02656913e-02f, 2.97902316e-01f, -8.17130953e-02f,
  -6.93695918e-02f, 7.79640079e-02f, -9.62260067e-02f, -3.89608811e-03f, 7.43046030e-02f, -8.70909393e-02f, 2.53153086e-01f, -1.32348254e-01f, 3.88826504e-02f, 2.71625668e-01f,
  -1.44904122e-01f, -1.25527710e-01f, -2.08658010e-01f, 1.17244860e-02f, 3.55576389e-02f, -1.27215758e-01f, -8.64456519e-02f, 1.55419201e-01f, 4.48856279e-02f, 7.95542151e-02f,
  1.72260419e-01f, -9.34595317e-02f, -1.94845438e-01f, 1.29527688e-01f, -1.40647860e-02f, -2.37245224e-02f, 1.57709807e-01f, 2.33121008e-01f, 2.43775830e-01f, 2.55559117e-01f,
  7.49456733e-02f, 1.75256535e-01f, -1.70396522e-01f, 9.17637050e-02f, -8.52979049e-02f, -1.81761295e-01f, 6.52772188e-02f, 6.24855012e-02f, -5.49061820e-02f, -9.41415876e-02f,
  4.75751609e-02f, -1.38582543e-01f, 2.53485143e-02f, 1.10251963e-01f, 1.13118432e-01f, 1.94186196e-01f, -1.51633948e-01f, 4.66588959e-02f, 8.26101692e-04f, 2.44054526e-01f,
  -1.09096505e-01f, -5.55251539e-02f, 1.44525528e-01f, 1.43351212e-01f, -2.11208016e-01f, -1.23652592e-01f, 1.21948048e-01f, 2.84882575e-01f, 2.00275213e-01f, -1.12127937e-01f,
  -2.22973824e-02f, 2.24802792e-01f, -2.15352982e-01f, 2.02660099e-01f, 3.29761915e-02f, -9.64758471e-02f, -7.35389963e-02f, 9.20952516e-05f, -6.15417212e-02f, 9.87958387e-02f,
  -1.90277576e-01f, 2.09702820e-01f, -6.92528039e-02f, -1.58966109e-01f, 4.28874902e-02f, 3.10994565e-01f, 3.17417204e-01f, -1.08275399e-01f, 1.13659605e-01f, 4.62708948e-03f,
  -1.05989829e-01f, 1.04416057e-01f, 6.52186275e-02f, -6.22900799e-02f, -1.94590971e-01f, -5.76919038e-03f, -1.47760749e-01f, 4.61369902e-02f, -4.33019623e-02f, -6.87938556e-02f,
  -2.08326858e-02f, 4.43194211e-02f, -6.79028705e-02f, -8.28894451e-02f, -1.01227701e-01f, -3.96169759e-02f, 1.21089153e-03f, -3.68435569e-02f, -9.82197300e-02f, -8.62986594e-02f,
  1.35410845e-01f, 5.57422452e-02f, -3.61932553e-02f, 7.04683661e-02f, 9.05669555e-02f, 5.20569123e-02f, -1.22705407e-01f, -6.70193881e-02f, 3.96129638e-02f, 1.05453379e-01f,
  -1.12949342e-01f, -3.52768670e-03f, 4.95103076e-02f, 1.02638327e-01f, 5.68353422e-02f, -3.86179350e-02f, 8.14946890e-02f, -1.82685442e-02f, 9.47754830e-03f, -7.59922713e-02f,
  6.45944104e-02f, 2.38245614e-02f, -5.64113399e-03f, -6.32147714e-02f, -2.96836682e-02f, -5.46843335e-02f, -6.39356626e-03f, -1.65344328e-02f, -4.04805802e-02f, 8.59944150e-02f,
  8.50726217e-02f, -4.42255437e-02f, 8.10842663e-02f, -2.25688331e-02f, -1.74884815e-02f, -8.57587904e-02f, 6.09044433e-02f, 3.35779488e-02f, 4.26525138e-02f, 1.38320606e-02f,
  1.39810234e-01f, 9.57855731e-02f, -5.89189269e-02f, -1.14643358e-01f, 2.64017265e-02f, -4.42604721e-02f, 2.79532168e-02f, -6.47656694e-02f, 6.88377246e-02f, -2.63564158e-02f,
  -5.02230600e-02f, 4.99606915e-02f, 2.24631950e-02f, -2.09628940e-02f, 1.28353596e-01f, 1.95507511e-01f, 1.52732417e-01f, 2.01270372e-01f, -9.26660672e-02f, 5.44550680e-02f,
  1.06795639e-01f, -2.84225419e-02f, 1.29882697e-04f, 3.26881036e-02f, 1.85410038e-01f, 8.77228156e-02f, -7.11463392e-02f, 7.30821788e-02f, -7.65084475e-02f, 1.25455454e-01f,
  -4.72542793e-02f, 8.28391612e-02f, -1.40555993e-01f, -8.89681950e-02f, -4.08581644e-02f, 2.17981339e-02f, 1.46480836e-02f, -1.51347108e-02f, -2.47585736e-02f, -1.11963816e-01f,
  -3.38562913e-02f, -4.75813076e-02f, -6.22670399e-03f, -4.75897901e-02f, 8.04775357e-02f, -8.58584642e-02f, -2.65559517e-02f, -9.80408862e-02f, -4.05874066e-02f, -9.10604894e-02f,
  1.11191235e-01f, 1.31386876e-01f, -1.11428075e-01f, -1.43831700e-01f, -1.23020999e-01f, 2.07214311e-01f, 4.75957282e-02f, -1.82696134e-02f, 1.01471037e-01f, 3.62851530e-01f,
  -9.22945738e-02f, -1.03934251e-01f, 5.16939759e-02f, 7.20810816e-02f, 5.52774891e-02f, -8.92859399e-02f, -1.74798802e-01f, -1.15369502e-02f, -9.83905420e-02f, -9.65627730e-02f,
  -8.42962340e-02f, 6.57258406e-02f, 8.07323679e-02f, 1.45951390e-01f, -2.76729595e-02f, -4.98674586e-02f, 7.86978565e-03f, 1.95043579e-01f, 1.37104556e-01f, 1.09853648e-01f,
  -4.66041155e-02f, -1.04617029e-01f, 1.05293684e-01f, -1.30806193e-02f, -8.34983811e-02f, -1.13134615e-01f, -1.38385653e-01f, 1.49815738e-01f, 1.00227201e-03f, -1.74475297e-01f,
  -1.16543844e-01f, -1.19228857e-02f, 4.86778617e-02f, -1.34553418e-01f, -5.95072657e-02f, -6.24336824e-02f, 1.29197195e-01f, -1.82808787e-02f, -3.62716019e-02f, 1.00446709e-01f,
  -8.17532614e-02f, -3.25872228e-02f, -3.36216800e-02f, 6.92426190e-02f, 3.41332294e-02f, 5.22832498e-02f, 6.97684614e-03f, 6.89098332e-03f, 1.01366907e-01f, 4.39452045e-02f,
  8.50629956e-02f, -7.86394998e-02f, 9.51052085e-02f, 1.25698999e-01f, 7.36249611e-02f, 6.54295161e-02f, 6.82600662e-02f, -7.70431012e-02f, -1.58290658e-02f, -6.02407269e-02f,
  -7.73518234e-02f, 9.06753764e-02f, 1.19863071e-01f, 1.04780175e-01f, 8.44249800e-02f, -4.83344533e-02f, -7.05511793e-02f, -4.73810397e-02f, -3.56210433e-02f, 1.19995050e-01f,
  -7.14002028e-02f, -9.20922831e-02f, -7.53836036e-02f, 1.42055452e-01f, 1.13075323e-01f, -3.64797786e-02f, -2.73749810e-02f, -9.12741423e-02f, 7.83312768e-02f, -2.33553052e-02f,
  4.45345752e-02f, 1.19900085e-01f, -7.66953304e-02f, 2.38302648e-02f, 2.57674381e-02f, 2.76186615e-02f, 9.77200195e-02f, 1.20967060e-01f, -1.18281536e-01f, 1.90894846e-02f,
  3.30027901e-02f, 4.35125232e-02f, -6.49236664e-02f, -3.85819166e-03f, -2.24769674e-02f, -7.41212368e-02f, -8.27567419e-04f, -6.79160953e-02f, 1.16340078e-01f, 1.05600633e-01f,
  7.44530857e-02f, -9.66734290e-02f, -7.32030347e-02f, -1.12597622e-01f, 6.60972223e-02f, -1.02629505e-01f, 2.21332163e-02f, 7.60357454e-02f, -1.29471272e-01f, 2.89571155e-02f,
  1.82441920e-01f, 3.93850990e-02f, 2.92104967e-02f, -3.95047180e-02f, 1.10099800e-01f, -7.94900581e-02f, 7.49753714e-02f, -3.07640284e-02f, 1.22784786e-01f, 1.16288409e-01f,
  1.04742952e-01f, 1.05742082e-01f, -3.00827678e-02f, -2.10409164e-02f, -8.72602761e-02f, -7.01932311e-02f, 8.94980505e-02f, -1.05910197e-01f, -3.25892903e-02f, -6.78479522e-02f,
  -9.93223339e-02f, -7.63869882e-02f, -3.23775709e-02f, -4.00187522e-02f, 3.94787975e-02f, -1.13348141e-01f, 9.82660577e-02f, 1.71069250e-01f, -6.74083158e-02f, -1.51135335e-02f,
  1.00519940e-01f, -1.21871345e-01f, -3.96167440e-03f, -4.98458967e-02f, -8.41260329e-02f, 8.92227665e-02f, -1.10726207e-01f, 3.35139968e-02f, -5.61547242e-02f, -1.28727518e-02f,
  5.08127771e-02f, 5.05020320e-02f, 9.18425471e-02f, 2.20618155e-02f, -7.59856328e-02f, -6.40643835e-02f, 1.12250291e-01f, -6.34178370e-02f, 1.00024633e-01f, 1.48895964e-01f,
  6.77989796e-03f, 5.99130876e-02f, -1.20711327e-02f, 1.30606845e-01f, -1.09312192e-01f, -4.13988754e-02f, -5.32108918e-02f, -9.84208584e-02f, 8.81647021e-02f, 7.07688034e-02f,
  1.77773426e-03f, -7.07013682e-02f, 1.11033887e-01f, -7.28828320e-03f, -2.99816988e-02f, 5.60571589e-02f, 1.50640449e-02f, 7.99668208e-02f, 2.50378530e-02f, 3.61454557e-03f,
  7.36359432e-02f, -6.84262766e-03f, 3.40281315e-02f, -9.25033242e-02f, 3.20800929e-03f, -1.27981156e-02f, -7.19811618e-02f, 3.39336954e-02f, 1.06844798e-01f, -1.03164755e-01f,
  -7.46376514e-02f, 7.54816458e-02f, 7.25136325e-02f, 8.44849646e-02f, 4.95453030e-02f, -7.66877457e-02f, -9.75915231e-03f, 1.04946844e-01f, 7.61365741e-02f, 1.11844502e-01f,
  -1.20282575e-01f, -9.08321664e-02f, -9.33916345e-02f, -5.04622236e-02f, -6.98639750e-02f, 1.58985898e-01f, 2.38558277e-02f, 1.15404949e-01f, -4.77872491e-02f, 1.21146128e-01f,
  -7.75768384e-02f, -6.18968196e-02f, 4.19839993e-02f, 9.51848030e-02f, -8.52617025e-02f, 8.91431719e-02f, -1.31480381e-01f, -5.73959611e-02f, -7.12745711e-02f, -7.89012909e-02f,
  5.06794872e-03f, 5.28515615e-02f, -1.11323029e-01f, -3.10437456e-02f, -8.48104879e-02f, 1.24978937e-01f, -1.47834998e-02f, -1.87492594e-02f, 9.83096287e-02f, 1.59703061e-01f,
  7.36271441e-02f, -1.63349267e-02f, 7.78988376e-02f, -2.84204520e-02f, -2.34581754e-02f, -8.70122239e-02f, 1.93557498e-04f, 6.40503615e-02f, 7.60551244e-02f, 7.43758753e-02f,
  -1.34227080e-02f, 5.11432216e-02f, -2.06516255e-02f, 9.22333300e-02f, 3.59126814e-02f, 3.96275744e-02f, 3.20106349e-03f, 1.46408640e-02f, -6.73706904e-02f, -7.32580572e-02f,
  5.00829071e-02f, -1.02205940e-01f, 1.15302898e-01f, -9.76700336e-02f, -1.12916417e-01f, 1.01566248e-01f, 1.11644059e-01f, 2.91684307e-02f, -1.46614034e-02f, 6.50048256e-02f,
  1.24141634e-01f, 2.44841874e-02f, 1.55596524e-01f, -1.64036117e-02f, -3.58108021e-02f, -1.19324632e-01f, 4.26766165e-02f, -1.08501926e-01f, -8.91076475e-02f, -6.77515417e-02f,
  -8.21906254e-02f, -9.81618986e-02f, -6.12298921e-02f, -7.95440376e-02f, 1.34100974e-01f, 4.71505858e-02f, -8.40606168e-02f, 2.07824428e-02f, 7.14540482e-02f, 6.10284507e-02f,
  -9.70682651e-02f, -5.75853251e-02f, 4.75544818e-02f, 9.23273042e-02f, 4.79463581e-03f, -1.86903879e-01f, 1.11448765e-01f, 9.10250768e-02f, 3.93481180e-02f, -8.06436837e-02f,
  -9.94986966e-02f, 7.99532384e-02f, 1.33702800e-01f, 7.24531934e-02f, 2.00559378e-01f, 1.37562141e-01f, 5.94131202e-02f, -1.95486974e-02f, 3.17889899e-02f, -9.86879971e-03f,
  1.51780441e-01f, 1.48323759e-01f, 2.87871629e-01f, 2.03580394e-01f, -6.21604547e-02f, -5.30253574e-02f, 4.91857762e-03f, 7.05461502e-02f, -1.26837969e-01f, 7.01079071e-02f,
  1.94478244e-01f, -1.87368914e-02f, 1.16865866e-01f, 3.46901119e-02f, 3.05950362e-02f, -6.45691082e-02f, 1.45760685e-01f, -7.05829561e-02f, 6.18519001e-02f, 1.11231476e-01f,
  -6.29541203e-02f, 8.55306983e-02f, 1.69261973e-02f, -8.22097734e-02f, -1.62603140e-01f, -6.75629068e-04f, 1.96468249e-01f, 8.36229473e-02f, 7.50040859e-02f, -9.85291600e-02f,
  9.45888739e-03f, 1.24112472e-01f, -9.07108840e-03f, 1.00152865e-01f, 1.52072273e-02f, -3.76734347e-03f, -6.32710084e-02f, 8.90474394e-02f, -9.15298536e-02f, -8.95365179e-02f,
  -7.14803264e-02f, -3.20851654e-02f, 1.01903684e-01f, -1.09192513e-01f, 9.89969596e-02f, -1.21988267e-01f, 2.18204707e-02f, -1.20162696e-01f, -2.91066132e-02f, -4.40485254e-02f,
  -4.38142493e-02f, -1.21839099e-01f, 1.12480327e-01f, 4.71240319e-02f, -2.51529701e-02f, -5.13546690e-02f, -8.45259503e-02f, 5.77759668e-02f, -1.20193094e-01f, -1.00722872e-01f,
  1.21916503e-01f, -4.60053943e-02f, -1.04527110e-02f, 4.32485528e-02f, -4.94928136e-02f, 3.56939435e-02f, -4.65819836e-02f, 3.53115401e-03f, -1.03437744e-01f, -8.57084692e-02f,
  -2.53349598e-02f, -6.21596016e-02f, -9.74449366e-02f, 3.65716149e-03f, -9.53931138e-02f, 1.07416093e-01f, 2.34405156e-02f, -9.42007452e-02f, -1.10549621e-01f, -9.04594064e-02f,
  -9.57906321e-02f, -1.19396485e-01f, -6.76013157e-02f, 5.48010878e-02f, -3.12285870e-02f, -8.85105878e-02f, -1.22696400e-01f, -8.67627263e-02f, 1.49251474e-02f, 2.22417712e-02f,
  -1.94130912e-02f, -3.51322293e-02f, 1.06280945e-01f, -1.14332348e-01f, -7.62911234e-03f, 3.80801260e-02f, -5.72645525e-03f, -3.85075919e-02f, -3.60783376e-02f, -5.11911474e-02f,
  -2.36305818e-02f, 7.12184384e-02f, 1.40846685e-01f, -3.12704928e-02f, 1.07390441e-01f, -6.90526962e-02f, -8.91257543e-03f, 1.14642330e-01f, 1.07321203e-01f, 3.00113633e-02f,
  1.10534430e-01f, 5.05643375e-02f, 1.62621439e-01f, 2.10695285e-02f, 3.74603681e-02f, 1.27015254e-02f, 2.77846772e-02f, 4.10113409e-02f, -8.01452920e-02f, -9.77415293e-02f,
  -2.82154996e-02f, -4.63508219e-02f, 1.60961170e-02f, 1.13156531e-02f, 6.53852820e-02f, 8.46400484e-02f, 7.80386329e-02f, -4.32042591e-02f, 7.89648294e-02f, -1.56616867e-02f,
  -7.00884387e-02f, 4.13105445e-04f, -5.84259816e-02f, 1.44693470e-02f, 2.08145846e-03f, -7.47248307e-02f, -4.70280312e-02f, -2.12300234e-02f, 1.60388038e-01f, 1.28048062e-01f,
  9.79786217e-02f, 4.74717468e-02f, -2.72170417e-02f, 9.74226668e-02f, 6.85537755e-02f, -7.46939778e-02f, -3.88768315e-02f, 2.52873480e-01f, -4.17427234e-02f, -4.24838327e-02f,
  -7.25870579e-02f, 1.10434704e-01f, 1.66113943e-01f, 4.47147526e-02f, 1.79810785e-02f, 3.21721695e-02f, 7.96442106e-02f, -2.29550228e-02f, -2.94341724e-02f, -1.56439841e-02f,
  3.35882790e-02f, 2.09329929e-02f, 1.31827861e-01f, -2.03877129e-02f, -6.39142767e-02f, 6.68713972e-02f, -3.23589658e-03f, -5.48654199e-02f, -1.01029336e-01f, -8.86351019e-02f,
  -6.18697405e-02f, -2.89939530e-02f, -1.01232911e-02f, 6.03857189e-02f, -4.86208610e-02f, -9.44431648e-02f, -6.96631372e-02f, -6.38497472e-02f, 3.65842786e-03f, -2.25918368e-02f,
  -5.03664874e-02f, 1.06784061e-01f, -3.50172520e-02f, -4.65412363e-02f, 1.99380871e-02f, 6.13209270e-02f, -3.59260589e-02f, 9.20774788e-02f, 3.48064257e-03f, 6.15804940e-02f,
  -2.27525607e-02f, -5.89530468e-02f, -5.91835193e-02f, -1.07768238e-01f, 3.81094292e-02f, 3.30606080e-03f, -7.43838400e-02f, -8.34110081e-02f, 2.29287706e-03f, 7.03380555e-02f,
  -6.19780598e-03f, -9.23382044e-02f, 7.21976012e-02f, 2.31901761e-02f, -1.20136216e-01f, -1.21884584e-01f, 4.28224765e-02f, 1.35664036e-02f, -7.12250620e-02f, -5.47712184e-02f,
  -6.41715452e-02f, 6.49028495e-02f, 3.25327441e-02f, 9.01313648e-02f, -3.46741686e-03f, -1.11350097e-01f, -4.12893249e-03f, 7.03983828e-02f, 7.32384771e-02f, -7.52639249e-02f,
  2.05653552e-02f, 3.10838800e-02f, -1.00698411e-01f, -3.61734554e-02f, -2.29810942e-02f, 6.92738891e-02f, 5.62835671e-02f, -7.39922673e-02f, 4.23408784e-02f, -8.46439153e-02f,
  1.20921493e-01f, -4.89151943e-03f, 9.29266494e-03f, 2.23233268e-01f, -7.02227727e-02f, 1.03169583e-01f, 2.27320343e-01f, -1.36480361e-01f, 7.06153736e-02f, 1.80439800e-01f,
  2.95969754e-01f, 1.74746290e-01f, -1.28339499e-01f, 1.92635611e-01f, 3.32432054e-02f, 2.95629621e-01f, -6.92271255e-03f, -1.48854554e-01f, -3.95029821e-02f, -1.44932736e-02f,
  5.34198023e-02f, 1.07004335e-02f, -1.05495967e-01f, 5.37588447e-02f, -3.88999507e-02f, 7.90946335e-02f, 1.63241073e-01f, 9.60579291e-02f, -2.09489539e-02f, 1.26271933e-01f,
  8.10416974e-03f, -1.72908142e-01f, -1.01377107e-02f, 9.64570418e-03f, 2.56402701e-01f, -1.42960936e-01f, 3.98871511e-01f, -2.80453674e-02f, -9.85677913e-02f, -1.04581393e-01f,
  1.73749272e-02f, 2.69824028e-01f, 1.24353938e-01f, 1.44555509e-01f, 5.17000519e-02f, 6.20756984e-01f, 6.15630560e-02f, 1.32293671e-01f, -9.29362476e-02f, -4.44783866e-02f,
  2.40547165e-01f, 2.44132299e-02f, -9.07339975e-02f, -1.17536604e-01f, -1.32027745e-01f, -7.79077634e-02f, -1.90877408e-01f, -3.90051719e-04f, -1.03904493e-02f, 2.03915372e-01f,
  1.03428699e-01f, 1.37750164e-01f, 8.93927589e-02f, 2.28360176e-01f, -5.51573113e-02f, 4.00211178e-02f, 7.07034953e-04f, -1.28432691e-01f, 1.22146951e-02f, -8.97620544e-02f,
  -7.92518854e-02f, 1.29877226e-02f, -9.67814699e-02f, -1.28349764e-02f, 7.96489716e-02f, -4.47172932e-02f, -4.66334820e-02f, -3.97941545e-02f, 1.90970358e-02f, -4.78173606e-02f,
  2.57693529e-02f, 5.60058979e-03f, 4.05306891e-02f, -8.28256160e-02f, -1.02681950e-01f, -1.17818996e-01f, -7.60849789e-02f, -6.08745851e-02f, -2.59668306e-02f, -6.11240231e-02f,
  -9.10130143e-02f, -8.21181834e-02f, 6.22129515e-02f, -4.61542048e-02f, 2.96553858e-02f, -8.84661451e-02f, 9.87293944e-02f, -1.16687499e-01f, 5.74610829e-02f, -8.86571556e-02f,
  -8.11484084e-02f, -1.15422308e-01f, 1.67191625e-02f, 1.17329292e-01f, 1.10005684e-01f, -9.80734006e-02f, 7.07324743e-02f, -8.51693824e-02f, -1.00574434e-01f, -4.53420505e-02f,
  -1.27459556e-01f, -6.10252842e-02f, 3.88390273e-02f, -5.13597429e-02f, -3.42141241e-02f, 2.43803300e-03f, 1.38662718e-02f, 4.27545235e-02f, 4.55654785e-02f, -1.26841366e-01f,
  8.37822538e-03f, -2.96840183e-02f, -3.31289656e-02f, 9.65007115e-03f, 1.13265082e-01f, -1.92136858e-02f, -1.51769631e-02f, 5.27430736e-02f, -1.70269504e-03f, -5.48933342e-04f,
  -6.47553355e-02f, 8.22739378e-02f, 1.73535384e-02f, -5.80438375e-02f, -5.97165599e-02f, -1.76358502e-02f, 5.79319894e-02f, -1.01471364e-01f, -1.22078434e-02f, -5.18166833e-02f,
  -1.32781178e-01f, 6.42961040e-02f, 1.46588814e-02f, 1.41417652e-01f, 1.41997430e-02f, 7.26752430e-02f, 7.68133178e-02f, 2.22002402e-01f, 1.12168469e-01f, 4.46997583e-03f,
  -9.16975290e-02f, -8.46066773e-02f, -3.31110694e-02f, 4.89748381e-02f, 2.33936027e-01f, 8.14441368e-02f, 3.66449535e-01f, 3.14466029e-01f, 6.20381767e-03f, 1.95322677e-01f,
  1.98214836e-02f, -5.60792349e-02f, -2.90845823e-03f, 1.10357016e-01f, 1.54710412e-01f, -9.85576510e-02f, 6.34961948e-02f, -9.49564949e-02f, 1.72021333e-02f, 3.21353599e-02f,
  1.39350994e-02f, -8.49803314e-02f, -2.32647136e-02f, 2.34694351e-02f, 3.26650664e-02f, 2.44401038e-01f, 8.47652275e-03f, 1.29699672e-03f, 1.15737319e-01f, 4.40410636e-02f,
  3.45649958e-01f, -1.24023825e-01f, -3.25093903e-02f, -1.40233608e-02f, 3.88353802e-02f, -8.75842571e-02f, 1.95841923e-01f, 6.02445845e-03f, 1.01631589e-01f, 3.03194243e-02f,
  -3.86619084e-02f, -1.27045155e-01f, 7.87777752e-02f, 2.24013161e-02f, 1.33521989e-01f, -9.82058048e-02f, 3.66699882e-02f, -7.24616200e-02f, -1.22812949e-01f, 3.51525471e-02f,
  -1.11345351e-01f, -4.23761876e-03f, 9.15124491e-02f, -8.38333964e-02f, 1.05405077e-01f, 9.54665840e-02f, -2.54586376e-02f, -1.28032044e-01f, -7.04833046e-02f, 1.82978977e-02f,
  -6.04031645e-02f, 7.67336637e-02f, 5.79723977e-02f, -9.39893052e-02f, 1.26497105e-01f, -4.86615673e-02f, -6.69759233e-03f, 2.88743004e-02f, 6.12897836e-02f, -4.23473418e-02f,
  -2.02733763e-02f, 5.48323132e-02f, 8.62722564e-03f, -1.16534226e-01f, -5.66917397e-02f, -2.48580463e-02f, -7.36171901e-02f, 8.53323340e-02f, -1.06972121e-01f, -1.20457545e-01f,
  9.25425366e-02f, 1.04883477e-01f, 6.73702657e-02f, 1.17138792e-02f, -7.68013299e-02f, -3.30344923e-02f, -1.27379559e-02f, 6.45349622e-02f, 3.47773917e-02f, 5.48809581e-02f,
  -4.13358696e-02f, -6.86127916e-02f, -5.23503087e-02f, -4.23224643e-02f, -1.17836356e-01f, 4.64778021e-02f, -1.22892641e-01f, 2.44974997e-02f, -3.04818414e-02f, 3.16252969e-02f,
  -2.24834792e-02f, -4.40233983e-02f, 4.09059562e-02f, -4.64095958e-02f, 1.05393216e-01f, -5.54551480e-05f, -3.24249230e-02f, 8.24803263e-02f, 1.90785035e-01f, 9.70497504e-02f,
  1.60906076e-01f, 2.07152829e-01f, -1.47599876e-01f, 1.24650516e-01f, -1.68508127e-01f, -6.17327131e-02f, 8.61006137e-03f, 1.09302536e-01f, 8.65048319e-02f, 4.67436463e-02f,
  -6.10432439e-02f, -3.45522165e-02f, 1.63486302e-02f, 5.26865050e-02f, 8.71470012e-03f, 1.34885013e-02f, -1.16330028e-01f, -1.19394436e-01f, 1.10810250e-01f, 9.48560610e-02f,
  -5.60008548e-02f, -4.01913896e-02f, 3.15474011e-02f, -4.92302962e-02f, -1.99156523e-01f, -8.67756642e-03f, 6.19879626e-02f, 1.04729183e-01f, -1.50712309e-02f, -1.44081280e-01f,
  -6.28299117e-02f, 2.78989654e-02f, -2.04622615e-02f, 5.45432456e-02f, -7.56225809e-02f, -3.93692553e-02f, 1.42161380e-02f, 3.34317051e-03f, 8.09251517e-02f, -4.15794179e-02f,
  -1.70972589e-02f, 1.37140438e-01f, -4.77796495e-02f, 3.31985913e-02f, -4.24003042e-02f, 2.21791998e-01f, 1.14404052e-01f, -5.16837575e-02f, 2.84393150e-02f, 7.77287409e-02f,
  1.74781531e-02f, 5.99642470e-02f, 7.81688765e-02f, -6.16712607e-02f, -1.23672746e-01f, 6.64625913e-02f, -5.37057072e-02f, 6.67618513e-02f, -3.97224352e-02f, -3.82366069e-02f,
  8.68802741e-02f, 2.80600470e-02f, -6.43418506e-02f, 1.67424843e-01f, -2.60897987e-02f, 2.24884003e-02f, -1.86373547e-01f, -4.58290651e-02f, -1.46290660e-01f, 9.83186960e-02f,
  -8.45615640e-02f, 1.88623685e-02f, 8.27388614e-02f, -6.82597533e-02f, -7.14357756e-03f, 7.78187141e-02f, 1.29426911e-01f, -4.21169400e-02f, 1.12605698e-01f, 1.37161627e-01f,
  -1.38415530e-01f, -5.99056482e-02f, -3.36046107e-02f, -4.81575206e-02f, -1.17641449e-01f, -1.00801602e-01f, -7.41328448e-02f, -4.31480370e-02f, -1.03245281e-01f, -1.14260867e-01f,
  1.09627604e-01f, -7.59612620e-02f, 1.15302518e-01f, -8.89349505e-02f, 1.61487088e-01f, -3.18415537e-02f, 1.19404653e-02f, 4.31100093e-02f, -8.38108957e-02f, -7.94744715e-02f,
  -4.60873684e-03f, -2.24351324e-02f, 8.17389935e-02f, 2.00529397e-02f, 1.55518409e-02f, 1.33541882e-01f, -1.21996798e-01f, 1.31759077e-01f, 1.22376025e-01f, 7.22460076e-02f,
  1.38735354e-01f, 9.54267085e-02f, 1.04654513e-01f, -6.96046883e-03f, 4.95414138e-02f, -1.02017913e-03f, 5.15329540e-02f, -9.32590738e-02f, -3.79795097e-02f, -1.19651891e-01f,
  -9.26402733e-02f, -8.09596926e-02f, 5.69723547e-03f, 1.38131812e-01f, -7.14861671e-04f, 4.95980047e-02f, -7.57004842e-02f, -6.80802986e-02f, -3.96262668e-02f, 9.97374132e-02f,
  1.06538914e-01f, -5.30325770e-02f, -5.74773997e-02f, -1.28323376e-01f, 8.48511606e-02f, 5.89051060e-02f, 9.73223001e-02f, 2.22936925e-02f, 1.29828826e-01f, -4.23929989e-02f,
  2.49585565e-02f, -1.29528999e-01f, -4.06938381e-02f, 1.69030711e-01f, -3.63352634e-02f, 5.84900714e-02f, 1.15317434e-01f, -9.75304022e-02f, -1.20720223e-01f, 8.70458409e-02f,
  1.42084390e-01f, -8.13795328e-02f, 6.84936643e-02f, -6.59864247e-02f, 2.97966599e-02f, 1.40276715e-01f, 1.00889541e-01f, -3.48612778e-02f, 3.40511440e-03f, 6.73519596e-02f,
  -1.07503094e-01f, -5.60967326e-02f, 3.12003493e-02f, 3.81997451e-02f, 1.24921873e-01f, 1.41352728e-01f, 4.24927995e-02f, -4.91512194e-02f, 8.66905302e-02f, 2.02167422e-01f,
  2.00336203e-02f, -1.06037125e-01f, 1.05212614e-01f, -2.95771975e-02f, 5.47150001e-02f, -7.53908306e-02f, 1.29101232e-01f, 3.69970240e-02f, -3.35693955e-02f, -1.86552964e-02f,
  -3.68598215e-02f, -1.87918823e-02f, -1.21678144e-01f, -7.62334317e-02f, -2.51545049e-02f, -1.75483990e-02f, 6.31177053e-02f, 1.26474231e-01f, 1.32985190e-01f, -1.44359954e-02f,
  -7.54558807e-03f, 4.61326502e-02f, 8.91805738e-02f, -4.32099216e-02f, 7.46458620e-02f, 1.29159829e-02f, 3.03825904e-02f, 5.61838821e-02f, 1.68337852e-01f, 6.84502199e-02f,
  8.23788345e-02f, 1.07296526e-01f, -2.20919624e-02f, -4.79860008e-02f, 1.16093688e-01f, 8.61824304e-02f, -8.05513859e-02f, 4.46273461e-02f, -2.49087643e-02f, -1.66315399e-02f,
  -1.03922360e-01f, -9.01512876e-02f, 8.48018825e-02f, 1.69965010e-02f, -8.18202831e-03f, -1.94307640e-02f, -1.14107959e-01f, -1.28401406e-02f, 1.26037985e-01f, 3.58279347e-02f,
  2.68448656e-03f, -1.12067282e-01f, 6.80469126e-02f, 1.58876032e-02f, 7.67452717e-02f, 5.67251071e-02f, -2.77699064e-03f, -2.90392078e-02f, 8.06180667e-03f, 1.33486792e-01f,
  -3.87775004e-02f, -9.53674987e-02f, -9.68566015e-02f, 3.48928347e-02f, 7.20184064e-03f, -8.40442851e-02f, 5.30738421e-02f, 6.59957230e-02f, -6.18695107e-04f, -5.22633344e-02f,
  8.18360895e-02f, -1.07993558e-01f, -6.14139950e-03f, -1.57728512e-02f, 3.96547168e-02f, 8.13411996e-02f, -1.26620099e-01f, -8.50818232e-02f, -7.13890269e-02f, 1.22198783e-01f,
  -2.17781216e-02f, 1.21831700e-01f, -2.39462089e-02f, -1.07848004e-01f, 1.39721087e-03f, -4.54046465e-02f, -5.75622059e-02f, -1.12625100e-02f, -5.73649593e-02f, -1.53928753e-02f,
  3.04729696e-02f, -8.95370096e-02f, -1.12789921e-01f, 4.29964019e-03f, 7.05606639e-02f, -1.97175350e-02f, 3.24169993e-02f, 8.78824387e-03f, -4.04455736e-02f, 4.11288477e-02f,
  -3.38817984e-02f, -5.20409010e-02f, -8.10184851e-02f, -1.14427179e-01f, -1.20909967e-01f, -8.39622393e-02f, 9.58224460e-02f, -1.86405070e-02f, -1.31308079e-01f, 1.48068052e-02f,
  -2.99902987e-02f, -9.49812457e-02f, 1.20175146e-01f, -1.36624217e-01f, 7.92025626e-02f, 7.73732737e-02f, -3.33749019e-02f, -1.06564969e-01f, 2.69678403e-02f, -1.65435877e-02f,
  1.50273647e-02f, -7.80337527e-02f, -1.00891806e-01f, 4.64943498e-02f, 4.07167263e-02f, 1.02674007e-01f, -1.06038518e-01f, -6.13592081e-02f, -4.32405770e-02f, 1.07746445e-01f,
  -5.98735362e-02f, 7.01690391e-02f, -5.41409180e-02f, 5.08256704e-02f, -8.69396403e-02f, 1.10582523e-01f, -5.42730540e-02f, 8.27078447e-02f, 9.31381732e-02f, -5.85166477e-02f,
  7.75049925e-02f, -2.95573920e-02f, 1.20279141e-01f, -1.27234384e-01f, -4.97583300e-02f, 5.24441600e-02f, 2.10286096e-01f, 7.80402869e-02f, 2.67918617e-01f, 1.04763873e-01f,
  1.80153430e-01f, 1.66121975e-01f, -1.41319662e-01f, -1.26320064e-01f, -1.99443832e-01f, -6.33886158e-02f, -4.48080264e-02f, -1.98735386e-01f, 1.63435899e-02f, -1.18462436e-01f,
  -1.38958320e-01f, -5.01926243e-02f, -8.69953558e-02f, -6.75195223e-03f, -2.03070566e-02f, 1.24668904e-01f, -2.10475344e-02f, 4.42656949e-02f, 2.21061744e-02f, 5.09159043e-02f,
  -2.45296936e-02f, 3.88756883e-03f, -1.75652936e-01f, 1.25857210e-02f, 9.38157663e-02f, -5.25848791e-02f, 5.34862913e-02f, -4.13311794e-02f, 1.37505442e-01f, 1.14736877e-01f,
  1.14750884e-01f, -4.84294724e-03f, 4.22771536e-02f, 4.85135987e-02f, 1.33579075e-01f, 2.37099398e-02f, -1.36319576e-02f, -7.95881003e-02f, 6.50520399e-02f, -1.38583452e-01f,
  1.62237734e-01f, -6.50651604e-02f, 1.10809788e-01f, 8.64884630e-03f, 2.75980532e-02f, -1.50628285e-02f, -8.87998939e-02f, 6.45404533e-02f, -1.78278377e-03f, -5.44692129e-02f,
  -8.20539370e-02f, 6.23526238e-02f, -8.10502768e-02f, 2.66318712e-02f, 3.58600914e-02f, 4.06568795e-02f, -7.68604055e-02f, -4.62355241e-02f, -9.19259936e-02f, -2.65790173e-03f,
  2.45315675e-02f, -8.70790258e-02f, -1.02475449e-01f, 5.14306128e-02f, -6.42916933e-02f, -9.48926434e-02f, 1.40633240e-01f, 7.17959926e-03f, 6.23712726e-02f, -4.35694046e-02f,
  1.19416542e-01f, -1.13599434e-01f, -9.53045413e-02f, 1.12735406e-01f, -2.86662076e-02f, 1.88229278e-01f, -3.07353642e-02f, -4.34287228e-02f, -7.11631030e-02f, -4.64139991e-02f,
  1.38056144e-01f, 1.00050375e-01f, 1.84721760e-02f, -9.06592607e-02f, -9.05372053e-02f, -1.58219971e-03f, 1.51857704e-01f, -7.47252926e-02f, 1.66686952e-01f, 2.71370918e-01f,
  -1.07721686e-01f, 5.60824946e-02f, -1.27173379e-01f, -1.45948544e-01f, 6.62027970e-02f, -1.30021289e-01f, 1.15647763e-01f, -1.19389936e-01f, 1.14860516e-02f, 1.07811004e-01f,
  -6.90194741e-02f, 1.07085004e-01f, -2.35512778e-02f, -6.03452735e-02f, 1.66821346e-01f, 1.42487869e-01f, 1.24824271e-01f, 1.76849023e-01f, -3.47943231e-02f, -2.53412295e-02f,
  1.23294070e-01f, 6.81894124e-02f, 1.94454417e-01f, 7.22566545e-02f, 6.58892170e-02f, -1.04469039e-01f, -1.36612609e-01f, 2.52471562e-03f, 2.20705330e-01f, 6.30534515e-02f,
  1.88542500e-01f, 1.11646093e-01f, 8.95550549e-02f, -9.89987031e-02f, -6.07680865e-02f, 1.79898534e-02f, 4.83252704e-02f, -1.15768041e-03f, 1.07522435e-01f, 8.46710131e-02f,
  8.92627537e-02f, -3.57955620e-02f, 4.02420461e-02f, -6.32467344e-02f, 7.71390721e-02f, 1.65133610e-01f, -1.21060297e-01f, 5.66237755e-02f, -5.62825426e-02f, 1.91943765e-01f,
  5.51404655e-02f, 2.08878201e-02f, -1.11150980e-01f, -1.03570245e-01f, 9.98130590e-02f, -7.17288926e-02f, -1.66161731e-02f, 1.34571195e-01f, 1.28455972e-02f, 9.52551141e-02f,
  1.24730319e-01f, 2.55099535e-02f, 1.89821366e-02f, -8.93136263e-02f, 3.76788490e-02f, -4.58522178e-02f, -1.29764363e-01f, -6.81502372e-02f, 1.71262652e-01f, -1.48629218e-01f,
  1.78939655e-01f, 1.05147436e-01f, -3.18774693e-02f, -1.36291478e-02f, 9.66861621e-02f, -8.62860121e-03f, 8.54082257e-02f, 7.80584887e-02f, 2.54187807e-02f, 2.27437779e-01f,
  1.00103095e-01f, 6.90131113e-02f, -2.19427869e-02f, -9.59023088e-02f, 6.02925494e-02f, 4.53302376e-02f, -1.01281805e-02f, 3.31546785e-03f, -2.71827988e-02f, 9.18579996e-02f,
  -2.53506750e-02f, 1.17563598e-01f, 5.88031411e-02f, 5.11928201e-02f, 1.91850066e-01f, -5.88075770e-03f, 2.31839181e-03f, 4.55766656e-02f, -2.57515423e-02f, 6.60112947e-02f,
  -8.41615200e-02f, 7.42897391e-02f, 5.56768775e-02f, -1.92409772e-02f, -1.19595140e-01f, 1.63785309e-01f, 2.18103603e-02f, 6.48332620e-03f, -7.09951296e-02f, -1.04975335e-01f,
  -9.76836123e-03f, -1.55253409e-04f, 1.34720874e-03f, 2.58811563e-03f, 1.33378610e-01f, -1.35987541e-02f, -9.69159901e-02f, 1.40424103e-01f, -8.13644379e-02f, 9.26703215e-02f,
  7.10693598e-02f, -6.05951343e-03f, 5.55559322e-02f, 3.85425054e-02f, 1.54435143e-01f, 5.86748831e-02f, 1.27029330e-01f, 5.72085045e-02f, 7.87643939e-02f, 1.82052106e-01f,
  1.46863028e-01f, -4.62951250e-02f, -4.43345606e-02f, 1.35591939e-01f, -9.34961252e-03f, -4.48139496e-02f, 6.07892089e-02f, 2.54479442e-02f, -6.33952990e-02f, -8.09163824e-02f,
  -4.21579480e-02f, 2.23370679e-02f, -5.94916567e-02f, -8.70111398e-03f, -9.20869503e-03f, -1.12405643e-01f, 8.90433639e-02f, 7.19951838e-02f, 1.12532437e-01f, 1.51172662e-02f,
  9.06783640e-02f, -4.96105440e-02f, 8.08452442e-03f, -2.96370294e-02f, -4.28642184e-02f, 1.99036077e-02f, -7.65916556e-02f, 2.69819368e-02f, 8.95200111e-03f, 5.17338440e-02f,
  -1.40289031e-02f, 6.23436756e-02f, 2.89867073e-01f, 1.81674391e-01f, 1.52495533e-01f, 1.97570138e-02f, 1.90205932e-01f, 2.20821097e-01f, -2.05727115e-01f, -2.62363404e-02f,
  -4.90554199e-02f, 1.59272581e-01f, -8.68081748e-02f, -3.56266469e-01f, 1.06074534e-01f, -1.36482939e-01f, -8.21894035e-02f, -3.21327299e-02f, -3.64684537e-02f, 3.50226164e-02f,
  1.06606700e-01f, -2.21528504e-02f, 4.17152569e-02f, 2.17925176e-01f, -4.29035397e-03f, -1.12772539e-01f, -1.37763500e-01f, 2.60235518e-02f, -1.77012101e-01f, 6.49172589e-02f,
  3.40561777e-01f, -9.98869017e-02f, 1.75734621e-03f, 2.62337308e-02f, 1.86101988e-01f, 2.17846528e-01f, 2.30913773e-01f, -1.08219497e-01f, 2.20253125e-01f, 1.78785101e-02f,
  2.41345406e-01f, 1.00308627e-01f, 8.63309205e-02f, -1.80023029e-01f, 3.53931002e-02f, -6.67777583e-02f, 5.71500435e-02f, -3.22906487e-02f, 1.33140147e-01f, 2.88670123e-01f,
  1.39049329e-02f, 1.25316724e-01f, -1.38196409e-01f, 3.13797668e-02f, 4.97800149e-02f, 7.19984770e-02f, 1.03802443e-01f, 2.61183411e-01f, 3.37195434e-02f, 1.66977361e-01f,
  1.17264017e-01f, -7.78835043e-02f, -1.68200836e-01f, 4.18500938e-02f, -2.28059068e-02f, 1.51921332e-01f, -1.10526018e-01f, 4.38345857e-02f, -1.31846458e-01f, -1.99165195e-02f,
  -9.53000709e-02f, 5.04195318e-03f, -2.14458406e-02f, 2.04909630e-02f, -5.96451648e-02f, -1.03238121e-01f, 2.46392284e-02f, 7.34538957e-02f, 4.50731777e-02f, 1.51230544e-02f,
  -4.71191816e-02f, 7.28642493e-02f, 8.09367076e-02f, 3.89208570e-02f, -9.59607363e-02f, 2.33505834e-02f, -5.73799573e-02f, 3.93539444e-02f, -1.39709264e-02f, -7.65333101e-02f,
  -8.27392936e-02f, 5.46071418e-02f, 8.79228413e-02f, -3.74763422e-02f, -4.05215211e-02f, -2.95673274e-02f, 2.09776592e-02f, 2.92675532e-02f, -7.54661858e-02f, -9.95247904e-03f,
  3.06403283e-02f, -4.54097055e-02f, -8.16086233e-02f, 6.00854158e-02f, -1.30697004e-02f, -4.43420708e-02f, 7.78189376e-02f, 9.58888531e-02f, 1.44580342e-02f, 7.36412359e-03f,
  -6.91109672e-02f, -5.05357273e-02f, 8.11176840e-03f, -1.23255633e-01f, -4.11857478e-02f, -6.97821900e-02f, 8.79732221e-02f, 8.98986906e-02f, -4.79529500e-02f, -5.92894033e-02f,
  -1.08738102e-01f, -5.23878410e-02f, 8.91974568e-02f, 5.69244251e-02f, -1.99938025e-02f, -1.25908569e-01f, -3.85455042e-02f, -1.18708625e-01f, 1.14170589e-01f, -7.22282678e-02f,
  -7.06602335e-02f, 1.60562489e-02f, -1.25418603e-01f, -1.24631986e-01f, -2.14807075e-02f, 8.85157436e-02f, -7.71642029e-02f, -9.52331796e-02f, -9.59418863e-02f, 5.96765839e-02f,
  -1.25918649e-02f, 9.50747952e-02f, 1.76065452e-02f, -2.00392473e-02f, 4.52854186e-02f, -1.10331461e-01f, 2.74996813e-02f, 7.10725039e-02f, 4.31730896e-02f, 3.02705038e-02f,
  -1.23801395e-01f, 3.52759361e-02f, 3.38542983e-02f, 4.09027077e-02f, -8.11555013e-02f, -1.66787077e-02f, 3.56455967e-02f, -9.44098458e-02f, -7.12449253e-02f, 9.85210910e-02f,
  1.26189962e-01f, -8.08156207e-02f, 6.74365908e-02f, 1.15611881e-01f, -8.59082490e-02f, -1.01763971e-01f, 1.04751207e-01f, -6.31822422e-02f, -4.87178154e-02f, 7.59678707e-02f,
  4.27860133e-02f, -5.58954738e-02f, 4.99577411e-02f, -8.86889547e-02f, -5.47871813e-02f, -1.06044754e-01f, 9.18588489e-02f, 5.12463562e-02f, -7.33489096e-02f, 4.91801836e-02f,
  1.86373591e-02f, -3.84531915e-02f, -7.96679705e-02f, -8.14590454e-02f, -1.98925305e-02f, -6.28525838e-02f, -1.08110569e-01f, -1.10815436e-01f, 1.96354687e-02f, 5.55946156e-02f,
  -3.78411487e-02f, 5.58981076e-02f, -1.90097485e-02f, -8.54227021e-02f, -9.76336524e-02f, -1.23343877e-02f, 6.03408031e-02f, -9.56914723e-02f, 6.83350638e-02f, -1.93427522e-02f,
  3.42988223e-02f, 1.53465897e-01f, -7.90239424e-02f, 2.01690756e-02f, 2.41786074e-02f, 9.13592204e-02f, 4.71406095e-02f, 2.56475825e-02f, -6.14110827e-02f, -6.39291182e-02f,
  9.42559913e-02f, -1.17096268e-01f, 1.27333492e-01f, 1.77485570e-01f, 9.61929411e-02f, -1.34082422e-01f, -8.01889598e-02f, 6.76497295e-02f, 2.23889947e-02f, 7.28511810e-02f,
  3.06159966e-02f, -3.55862118e-02f, -8.31712931e-02f, -6.62042126e-02f, -1.49043538e-02f, 1.13224000e-01f, 3.40167619e-02f, -9.01215337e-03f, 7.83837587e-02f, 9.38394740e-02f,
  -1.35585908e-02f, -8.96398351e-02f, -5.21385483e-02f, 3.31409760e-02f, 1.15317136e-01f, 1.00017138e-01f, -8.14074948e-02f, -4.36821692e-02f, 4.81496491e-02f, 9.64347050e-02f,
  7.00559765e-02f, 6.08106740e-02f, 8.09485093e-02f, -7.81775340e-02f, 1.13129780e-01f, 1.16934694e-01f, -6.95791095e-02f, -3.42712663e-02f, -9.56326425e-02f, -5.44581190e-02f,
  5.75938635e-02f, 1.08912267e-01f, -7.82622918e-02f, -1.13175876e-01f, 4.41572592e-02f, -1.15890495e-01f, -7.47424588e-02f, 3.89639963e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -3.56189236e-02f, 6.63771406e-02f, -4.63275686e-02f, -5.22089861e-02f, 2.30920076e-01f, 5.56038283e-02f, 1.22308291e-01f, 1.08059354e-01f, 1.55685559e-01f, -4.92513254e-02f,
  5.93068227e-02f, 9.11597013e-02f, 2.53462970e-01f, 4.10809368e-02f, -3.20600346e-04f, 1.18916333e-01f, -5.38704321e-02f, -4.99549694e-03f, 6.59120008e-02f, 3.63949761e-02f,
  1.08709320e-01f, -3.70561816e-02f, 2.41011709e-01f, 1.02678604e-01f, 8.92833918e-02f, -1.00774311e-01f, 8.77809227e-02f, -2.49988269e-02f, -3.74177843e-02f, -7.72716627e-02f,
  1.18193261e-01f, -8.59812945e-02f, -5.52323870e-02f, 1.53292343e-01f, 8.37542787e-02f, 1.79278359e-01f, -5.30849621e-02f, 6.65990859e-02f, 1.23253159e-01f, 7.84116909e-02f,
  -2.46248059e-02f, -5.33298925e-02f, 1.39754474e-01f, -4.36111465e-02f, 2.42247418e-01f, 7.14252815e-02f, 1.10432416e-01f, -1.19378515e-01f, 8.69352072e-02f, -9.39949825e-02f,
  -8.20235237e-02f, 1.24114342e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.51843987e-02f, 5.20196259e-02f, 3.81810777e-02f, 9.04252008e-02f, 2.68422097e-01f, 2.54840076e-01f, 2.10099980e-01f, -1.84459109e-02f, -5.50973527e-02f, 1.52995110e-01f,
  -1.77884340e-01f, 1.75259206e-02f, -2.09055975e-01f, 3.36266011e-02f, -1.03920616e-01f, -4.22257977e-03f, -8.06139037e-02f, 8.92060697e-02f, -1.53033882e-01f, 8.17821994e-02f,
  1.39656723e-01f, -2.21060254e-02f, -1.29109979e-01f, -7.76609406e-02f, 6.76643699e-02f, 9.15127993e-02f, -3.45856547e-02f, 1.50434077e-01f, 3.36807668e-02f, -4.28932384e-02f,
  4.76234145e-02f, 7.46529037e-03f, 1.19059145e-01f, 4.82136458e-02f, 3.58714722e-03f, -1.91955149e-01f, 3.22762728e-01f, 1.86869055e-02f, -4.88856621e-03f, -2.82334313e-02f,
  -3.12821344e-02f, -1.20200269e-01f, -6.44265637e-02f, -1.94224238e-01f, -2.63976436e-02f, 1.18554600e-01f, -3.75791155e-02f, -1.92321546e-03f, -1.23659801e-02f, -1.25652447e-01f,
  6.41751215e-02f, 1.15212590e-01f, 5.51585592e-02f, 3.84163447e-02f, 1.37230411e-01f, -8.06434751e-02f, 6.09790161e-02f, -2.02638865e-01f, 7.19271749e-02f, -2.01965403e-02f,
  6.94860667e-02f, -7.74000958e-02f, -6.92602620e-02f, 1.41334170e-02f, 1.68214403e-02f, -7.80066550e-02f, 2.41593253e-02f, 6.22394793e-02f, 5.36633395e-02f, 1.62798196e-01f,
  8.98505270e-04f, -5.99752292e-02f, 1.02691635e-01f, -6.92942217e-02f, 1.79362670e-02f, 1.57620743e-01f, 7.13808015e-02f, -8.20213407e-02f, -2.20603426e-03f, -1.69508886e-02f,
  -5.48475310e-02f, -1.47247508e-01f, 8.53296146e-02f, 4.41498011e-02f, 1.30538568e-01f, -6.44095168e-02f, 9.70449969e-02f, -4.69153048e-04f, 1.19730867e-01f, -1.28719017e-01f,
  4.41589281e-02f, 3.87413017e-02f, -9.43764374e-02f, -3.05096582e-02f, -1.19735837e-01f, -5.45154028e-02f, 1.25973701e-01f, -2.08550952e-02f, 1.43908054e-01f, -6.55667260e-02f,
  1.45829573e-01f, -9.14422572e-02f, 8.53116624e-03f, 3.90586369e-02f, 2.28984151e-02f, -7.43611455e-02f, -6.07462898e-02f, -3.46380807e-02f, 9.58247185e-02f, -4.92013097e-02f,
  -1.05478996e-02f, -1.66932195e-01f, -3.53531837e-02f, 6.10018373e-02f, 5.37465923e-02f, 1.49230629e-01f, 1.52464256e-01f, 1.01971880e-01f, 1.14867106e-01f, -1.18652051e-02f,
  1.13706596e-01f, -1.58910602e-01f, -6.41747937e-02f, 3.09130605e-02f, 5.02228700e-02f, 1.11109018e-01f, 2.35882327e-02f, 1.11303195e-01f, -1.78389661e-02f, -1.54595986e-01f,
  -2.12253422e-01f, -5.74330240e-02f, -1.35186732e-01f, -6.92388974e-04f, -7.07540438e-02f, 5.24380915e-02f, -1.58247501e-01f, -9.62101594e-02f, -7.75713474e-02f, -3.31950411e-02f,
  2.62971725e-02f, 4.06506807e-02f, -7.89311156e-02f, -1.14777625e-01f, 3.23801525e-02f, -3.55897471e-02f, -1.03849530e-01f, 9.23456699e-02f, -8.41516769e-04f, -1.47628989e-02f,
  2.98250578e-02f, 5.35185263e-02f, 4.24990579e-02f, 1.86375111e-01f, 1.06165148e-01f, 7.65462890e-02f, 4.26547660e-04f, 2.54117288e-02f, -6.45535113e-03f, 3.97378840e-02f,
  5.82014546e-02f, -1.42686829e-01f, 1.18756279e-01f, -2.72569865e-01f, 1.33902431e-01f, 1.30902722e-01f, 5.83226606e-02f, -3.94294895e-02f, 5.54191880e-03f, -8.02965611e-02f,
  -2.88790725e-02f, -1.12777390e-01f, -4.29431200e-02f, 5.95874600e-02f, -1.02487784e-02f, 2.43762527e-02f, 1.31170318e-01f, 6.90491917e-03f, -8.47945735e-02f, -6.22092653e-03f,
  2.22944450e-02f, 3.51608768e-02f, 9.68396887e-02f, -8.91658440e-02f, -6.17435016e-02f, 1.56440228e-01f, 1.51713639e-01f, 1.43018857e-01f, -2.16404215e-01f, -6.58489838e-02f,
  4.65370044e-02f, 1.20837055e-02f, -4.85582836e-03f, -4.56755050e-02f, 6.68493211e-02f, 1.76289156e-01f, 1.67069454e-02f, 2.04574019e-01f, -2.15996597e-02f, -9.14140865e-02f,
  9.64730009e-02f, -2.14680016e-01f, -6.09906241e-02f, 2.41596341e-01f, 1.78351447e-01f, 5.16503677e-03f, 5.55458590e-02f, 4.57507558e-03f, -7.81230405e-02f, -1.32243738e-01f,
  1.16210632e-01f, 8.83521810e-02f, 1.39917687e-01f, 2.07612030e-02f, 3.48816141e-02f, 3.61009059e-03f, 1.06610730e-01f, -7.00735152e-02f, 8.86926651e-02f, 2.43612546e-02f,
  -9.52076986e-02f, -1.52146727e-01f, -4.13357578e-02f, -5.67289479e-02f, 4.74444218e-02f, -4.99568023e-02f, 1.42081827e-01f, 1.31132677e-01f, 1.72195703e-01f, 9.52889025e-03f,
  -9.54657346e-02f, -1.54767083e-02f, -5.24014458e-02f, 8.29684511e-02f, -2.04534698e-02f, -1.08545497e-01f, 5.09854518e-02f, -1.59779966e-01f, -1.24673665e-01f, -2.57917851e-01f,
  -1.10898972e-01f, 1.16399437e-01f, -1.00876726e-01f, 9.14781634e-03f, 5.07784933e-02f, -5.75007088e-02f, -1.12913750e-01f, -7.03827590e-02f, 2.75773425e-02f, 7.00360015e-02f,
  3.88746969e-02f, 2.04563677e-01f, 6.78187907e-02f, 2.70554740e-02f, 1.01954117e-02f, 5.34095876e-02f, 1.07376024e-01f, -5.68129420e-02f, 2.90572941e-01f, 2.02486694e-01f,
  2.00793356e-01f, 3.85753274e-01f, 1.91377386e-01f, 4.96320166e-02f, -6.99911565e-02f, 1.40261710e-01f, -2.05394730e-01f, -1.13426864e-01f, -2.18267903e-01f, 1.27223566e-01f,
  -5.08408099e-02f, 9.53473076e-02f, 2.29490977e-02f, -6.28981320e-03f, -3.62925939e-02f, 1.23630241e-01f, 1.63124964e-01f, -1.02588460e-01f, -1.08256415e-02f, 3.04671209e-02f,
  9.40689817e-03f, 3.14816833e-02f, 2.09883582e-02f, 1.26010537e-01f, 1.13646127e-01f, -1.65494934e-01f, -6.66999891e-02f, -8.72486532e-02f, -7.48351077e-03f, 3.89856324e-02f,
  1.35534525e-01f, -1.78202942e-01f, 2.06193373e-01f, 4.86245900e-02f, -7.25377873e-02f, -2.02740636e-02f, -2.50228345e-02f, -1.69712324e-02f, 9.20588225e-02f, -9.92539376e-02f,
  -1.38803748e-02f, 4.00078259e-02f, 6.58381134e-02f, -3.11853383e-02f, 7.27311224e-02f, -2.13819742e-02f, 5.37013263e-02f, 1.88268334e-01f, 1.22667156e-01f, -1.11724257e-01f,
  6.95855841e-02f, 8.95641558e-03f, 6.09866083e-02f, -1.25274837e-01f, -5.44441715e-02f, -6.99356124e-02f, 1.58427209e-01f, -8.52028653e-02f, 7.25172609e-02f, 3.23085822e-02f,
  3.65466587e-02f, -2.02947840e-01f, -2.32028753e-01f, -2.19082773e-01f, -1.83201343e-01f, -1.66724846e-01f, -1.63005944e-02f, 1.31409913e-01f, 1.92795873e-01f, -2.15908483e-01f,
  1.60958827e-01f, 2.43272424e-01f, 2.73958325e-01f, 2.42481306e-02f, 4.18050364e-02f, -1.09649636e-01f, -7.84786940e-02f, -1.09011970e-01f, -2.95773894e-02f, 3.13167460e-02f,
  8.10065046e-02f, -4.62496318e-02f, 9.60012302e-02f, 1.71769701e-03f, -2.07035154e-01f, -1.47692353e-01f, -2.79187001e-02f, -2.06557885e-01f, 5.04902937e-02f, -5.66081516e-02f,
  1.31660774e-01f, -1.33367598e-01f, -2.40603257e-02f, 1.20703444e-01f, -4.44903746e-02f, 1.89291596e-01f, 5.28603867e-02f, 4.83666137e-02f, -5.88635355e-02f, -4.94581535e-02f,
  -5.87426908e-02f, -8.40947181e-02f, -9.38197523e-02f, 1.38982579e-01f, 5.72558567e-02f, 6.69423342e-02f, 2.41317619e-02f, -1.63482592e-01f, -7.24075586e-02f, 2.94306457e-01f,
  -1.11478642e-01f, -4.90061380e-02f, 5.96760362e-02f, -9.23179239e-02f, 6.66153803e-02f, 1.07225619e-01f, 6.65222183e-02f, 8.28542039e-02f, -1.09795881e-02f, 1.87375858e-01f,
  1.17885605e-01f, 6.82741180e-02f, 7.84267336e-02f, 9.37945545e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  5.37111461e-02f, 1.39208183e-01f, 2.70335615e-01f, 2.35374480e-01f, 8.49683434e-02f, 1.73191100e-01f, 1.19823791e-01f, -1.27525851e-01f, 2.05975443e-01f, -1.35711253e-01f,
  5.42451292e-02f, 1.59811169e-01f, -3.80960554e-02f, 2.14272514e-02f, 1.27590567e-01f, 2.10361052e-02f, 4.29135300e-02f, -7.57641047e-02f, -7.80246705e-02f, 5.72911873e-02f,
  6.86950609e-02f, -1.57392412e-01f, 1.51658595e-01f, 1.95067301e-02f, 7.57349357e-02f, -5.26180640e-02f, -8.98939297e-02f, 3.61275114e-02f, -1.20324053e-01f, -1.18511982e-01f,
  -8.42065811e-02f, -1.89637467e-01f, 1.15170563e-02f, 6.43317550e-02f, 3.40629935e-01f, 2.14548826e-01f, 2.95369983e-01f, -6.01475723e-02f, -6.00402094e-02f, 1.07024059e-01f,
  1.28496647e-01f, -8.33546147e-02f, 1.36860147e-01f, 5.50682135e-02f, 1.27734523e-02f, -1.33187957e-02f, -8.41329992e-02f, -1.18240211e-02f, 5.34554385e-02f, 9.78250429e-02f,
  -8.39104950e-02f, 9.97914672e-02f, 4.93814498e-02f, 4.44968753e-02f, 4.15918045e-02f, 2.32411660e-02f, 4.45076860e-02f, -1.82614833e-01f, -7.77342543e-02f, 1.43511295e-01f,
  1.24515384e-01f, 4.59616520e-02f, -9.16356295e-02f, -8.45194012e-02f, 1.03024319e-01f, 1.18875198e-01f, -8.03804845e-02f, 1.30957887e-01f, 1.10697873e-01f, 1.48517653e-01f,
  2.07239985e-01f, -1.16393603e-01f, 2.39832267e-01f, -2.80530095e-01f, -6.00191345e-03f, 1.12757400e-01f, 1.26383051e-01f, 5.29434904e-02f, 1.28403530e-01f, 1.27250373e-01f,
  2.60265637e-02f, -4.00187261e-02f, 7.11587295e-02f, -1.83201190e-02f, 1.01554371e-01f, -1.19883358e-01f, 1.44606248e-01f, -7.25484788e-02f, 8.41199756e-02f, -3.89798656e-02f,
  -1.04552381e-01f, 6.82988539e-02f, 7.07027912e-02f, 1.19270170e-02f, 8.06513950e-02f, -2.01197565e-01f, 9.40329805e-02f, -7.13630440e-03f, 2.28159979e-01f, -7.51122683e-02f,
  1.90130666e-01f, 1.08950928e-01f, -4.87532802e-02f, 1.10393561e-01f, -7.52159208e-02f, 1.02039389e-01f, -1.27991159e-02f, -5.51836044e-02f, -4.08774056e-02f, -4.73461896e-02f,
  2.97395475e-02f, -3.51293348e-02f, -8.83757100e-02f, -4.25837897e-02f, 2.04667076e-02f, -9.61964671e-03f, -1.00537173e-01f, 3.79676819e-02f, 2.42765360e-02f, -8.79342332e-02f,
  1.12122335e-02f, -5.94918802e-02f, -4.70316075e-02f, 1.34337932e-01f, 1.50470808e-02f, -1.09383501e-01f, -4.53902408e-02f, 1.06396012e-01f, -8.28863606e-02f, 7.17775002e-02f,
  2.29472239e-02f, 1.05843186e-01f, -2.93605644e-02f, -9.88961607e-02f, 4.93990742e-02f, -1.50566325e-01f, -9.79349241e-02f, -9.46269408e-02f, 1.62006561e-02f, -1.54984947e-02f,
  -1.46169984e-03f, -1.00611569e-02f, 1.87761988e-02f, -7.98833743e-02f, 7.20845535e-02f, 1.20818309e-01f, 1.05244935e-01f, 8.74087363e-02f, 3.74252813e-05f, -9.80955288e-02f,
  -1.34105003e-02f, 3.36952507e-02f, -3.64315435e-02f, 2.94526592e-02f, -6.28320053e-02f, 8.49176720e-02f, -1.12151228e-01f, 4.33322601e-02f, -5.15596867e-02f, -7.65988305e-02f,
  6.40387135e-03f, 6.87076850e-03f, 1.41537726e-01f, -7.47689903e-02f, -6.95383698e-02f, 6.74250126e-02f, 5.87686077e-02f, -8.81862789e-02f, 1.60097145e-02f, 8.16879272e-02f,
  -1.26431659e-02f, -1.36100084e-01f, 2.68139895e-02f, 1.06044613e-01f, -7.72106275e-03f, -8.66057873e-02f, -5.60679585e-02f, 1.67552587e-02f, -1.93090942e-02f, -3.41970399e-02f,
  4.50727008e-02f, 5.50091173e-03f, -1.14094295e-01f, -1.15375005e-01f, -8.08788911e-02f, -4.85448502e-02f, -2.23364327e-02f, 7.91871995e-02f, -1.14840448e-01f, 5.82992397e-02f,
  1.11364700e-01f, -6.97230687e-04f, 3.57156843e-02f, -1.53950676e-02f, -2.27661669e-01f, -8.01089555e-02f, -1.74400896e-01f, -7.28867352e-02f, -1.05325833e-01f, 4.46907245e-02f,
  5.34016490e-02f, 5.99033125e-02f, -1.32873893e-01f, 3.89389694e-02f, 1.51427880e-01f, -3.31785493e-02f, 3.87703776e-02f, -1.20746620e-01f, 5.66750206e-02f, -1.24674551e-02f,
  1.29606649e-01f, -6.19941503e-02f, -1.02626055e-01f, 1.75535366e-01f, 6.21478893e-02f, -8.75498401e-04f, -2.42671538e-02f, 9.65274964e-03f, 6.96205944e-02f, -6.21731803e-02f,
  3.02798524e-02f, 1.29456744e-01f, 8.92654881e-02f, -1.32996067e-02f, 6.48005605e-02f, 3.74297053e-02f, 3.95133160e-02f, 1.85014844e-01f, 1.09341249e-01f, 6.02047853e-02f,
  -5.84314694e-04f, -8.86326209e-02f, -5.82789779e-02f, 1.04467548e-01f, 1.01718299e-01f, 3.18515413e-02f, 3.75266038e-02f, -3.71716954e-02f, 1.15547813e-02f, 1.51897848e-01f,
  6.62721694e-02f, 2.52882898e-01f, -5.25687225e-02f, -1.14416204e-01f, 8.82181339e-03f, -7.07020164e-02f, -3.05900089e-02f, -3.43377516e-02f, -4.49087135e-02f, 1.09913610e-01f,
  -1.64065138e-02f, 5.74762225e-02f, -4.22925502e-02f, 2.35836580e-02f, 1.24061562e-01f, 6.01309910e-02f, 1.03513286e-01f, 9.12602916e-02f, 6.96084127e-02f, -3.63064632e-02f,
  -1.52272120e-01f, 3.21741626e-02f, 9.17974934e-02f, 9.97776464e-02f, -2.59475503e-02f, 2.51386315e-02f, 1.02882966e-01f, -1.46131560e-01f, 7.36871958e-02f, 2.54087187e-02f,
  5.80193214e-02f, 3.44549082e-02f, -9.31888819e-02f, 1.64919794e-01f, 8.33199918e-02f, -1.26873925e-01f, -8.61136317e-02f, 1.00012803e-02f, 1.32626280e-01f, 1.65560320e-01f,
  5.18608578e-02f, 2.13006437e-02f, 1.12109333e-01f, -4.36759852e-02f, 9.06232744e-02f, -5.87957874e-02f, -5.83831184e-02f, -6.46510050e-02f, 8.05616751e-02f, 2.92418841e-02f,
  9.23596472e-02f, 4.44318503e-02f, -1.16778046e-01f, -4.76720184e-02f, -2.50190925e-02f, 1.12031354e-02f, -4.96348180e-02f, 1.33842513e-01f, 5.55931451e-03f, 3.98357362e-02f,
  -1.15499943e-01f, 5.33966795e-02f, 7.35730901e-02f, 1.42486811e-01f, -9.44377761e-03f, 1.59619883e-01f, -1.02288738e-01f, -1.20054789e-01f, -7.47240111e-02f, -6.46290854e-02f,
  8.81212428e-02f, -4.96354178e-02f, -2.48137619e-02f, -3.33756412e-04f, 3.99163514e-02f, -6.91984966e-02f, -4.53590453e-02f, -6.31633550e-02f, -7.98615068e-03f, 5.64448945e-02f,
  -7.49647617e-02f, -6.09181784e-02f, 4.33275662e-03f, -9.51815546e-02f, -9.47991461e-02f, -4.50267158e-02f, 4.90579680e-02f, -1.30991703e-02f, -4.97177653e-02f, 1.44345254e-01f,
  1.27628043e-01f, -1.02971628e-01f, -5.40471561e-02f, 7.33207390e-02f, -4.57034670e-02f, -9.40312967e-02f, -9.23737362e-02f, 6.54355586e-02f, 1.03179015e-01f, -7.79977860e-03f,
  2.35633980e-02f, -1.13515951e-01f, -1.08908407e-01f, 7.39171654e-02f, -5.68718463e-02f, -8.55764821e-02f, -9.02336910e-02f, -1.52269742e-02f, -1.01184055e-01f, 6.24620579e-02f,
  -6.11746795e-02f, -3.34807113e-02f, 6.71520457e-02f, -1.04877330e-01f, -4.70182523e-02f, 6.54588491e-02f, 6.24613017e-02f, -5.09390347e-02f, 7.47895986e-02f, 1.52125666e-02f,
  -1.00246467e-01f, -9.66430008e-02f, 3.38530205e-02f, -7.46524483e-02f, -1.16964102e-01f, -7.32654259e-02f, 1.30821662e-02f, 9.08819214e-02f, 1.05057076e-01f, -1.14044078e-01f,
  -1.10954158e-01f, 5.94284758e-02f, -5.06816879e-02f, -8.06906521e-02f, -4.79672961e-02f, -2.04276363e-03f, -3.65688726e-02f, -6.08402416e-02f, 3.47572751e-02f, -2.83435490e-02f,
  6.00891076e-02f, 5.95908277e-02f, -1.26137242e-01f, 9.30288956e-02f, -9.72824171e-02f, -2.61497796e-02f, -9.58603993e-02f, -6.29469454e-02f, -7.91573003e-02f, -1.02718472e-01f,
  1.93598978e-02f, -3.37162428e-02f, 1.11425497e-01f, -5.78076579e-02f, 1.32609054e-01f, 8.15017447e-02f, 9.97228324e-02f, -4.45886590e-02f, -1.10427639e-03f, -6.66942149e-02f,
  2.96648052e-02f, 1.31918862e-01f, 8.78558587e-03f, 7.19708875e-02f, 2.31006779e-02f, 2.72746906e-02f, 4.74841259e-02f, 3.18882242e-02f, -9.00106281e-02f, -3.44116651e-02f,
  1.13021592e-02f, -1.02692202e-01f, 4.57631797e-02f, 9.49594937e-03f, -9.26993415e-02f, 2.78055090e-02f, 1.50751606e-01f, 3.40720043e-02f, 5.95791079e-02f, 6.47026971e-02f,
  1.28873691e-01f, -1.06023543e-01f, -2.66924202e-02f, 3.20375487e-02f, -8.65020752e-02f, -1.02000117e-01f, -7.57297128e-02f, -2.40791775e-02f, 3.77718918e-02f, 9.89971161e-02f,
  -1.00875214e-01f, -2.62202900e-02f, 9.27338526e-02f, 1.95294857e-01f, 8.05139020e-02f, 9.11243036e-02f, -3.47268172e-02f, 7.00799078e-02f, 9.22662988e-02f, 3.32507975e-02f,
  -1.54027222e-02f, 8.89528245e-02f, 1.08256660e-01f, -3.91809046e-02f, -2.42396677e-03f, -3.54507528e-02f, -4.00377139e-02f, 7.99109936e-02f, 8.93385559e-02f, 2.13193558e-02f,
  4.26360704e-02f, 1.94912061e-01f, 1.38913646e-01f, 1.06185220e-01f, 5.67800552e-02f, 3.22570652e-02f, 4.07452183e-03f, 6.54071271e-02f, 1.62199438e-01f, 5.34534082e-02f,
  -1.92229658e-01f, -9.77365375e-02f, 2.13777404e-02f, 1.71017498e-02f, 1.49825171e-01f, 1.24335125e-01f, 1.03607453e-01f, -4.20621149e-02f, -1.16859332e-01f, -1.48210749e-01f,
  3.59399728e-02f, 1.27232686e-01f, 2.80351639e-01f, 5.10806777e-02f, -1.21789463e-01f, 2.35276148e-01f, 4.11248580e-02f, -9.76453871e-02f, 1.04428224e-01f, -1.00397810e-01f,
  1.34820146e-02f, 3.23414765e-02f, 2.20345426e-02f, -4.33008969e-02f, -1.33783028e-01f, -3.91217321e-02f, 1.51305750e-01f, 1.89052187e-02f, 5.50235324e-02f, -6.90042451e-02f,
  -1.07086942e-01f, -5.02441488e-02f, -1.17920585e-01f, -7.27276579e-02f, 9.49026421e-02f, -1.21033499e-02f, -6.26352197e-03f, -1.33010402e-01f, -9.72952545e-02f, 3.16300355e-02f,
  7.39054754e-02f, -1.08294241e-01f, -4.49503250e-02f, -1.02499612e-01f, -4.41024303e-02f, 4.04605083e-02f, 1.81151927e-01f, 5.95578849e-02f, 3.82679328e-02f, 8.62866640e-02f,
  1.04152143e-01f, -7.25850984e-02f, -3.80612984e-02f, -1.11439176e-01f, -1.63538620e-01f, 3.32664065e-02f, -1.37149945e-01f, -6.87662959e-02f, 4.73522283e-02f, 1.95858344e-01f,
  5.58854342e-02f, 5.89924902e-02f, 1.29557522e-02f, -7.04201385e-02f, 1.28454566e-01f, 1.66511945e-02f, -1.38821211e-02f, -7.89766163e-02f, 9.87073928e-02f, -5.37929945e-02f,
  -4.78170775e-02f, 5.52910492e-02f, -3.34455408e-02f, 1.08066581e-01f, -1.58303883e-02f, 1.47387341e-01f, -1.99097425e-01f, 6.65358901e-02f, -6.13201112e-02f, -8.42503831e-02f,
  1.04709856e-01f, -8.31101183e-03f, 1.41266078e-01f, 5.12115471e-02f, 1.06076032e-01f, -2.57448647e-02f, -1.39443383e-01f, -1.78294964e-02f, -1.46843985e-01f, -8.16191956e-02f,
  1.17611766e-01f, -6.30063042e-02f, -2.84891017e-02f, 3.40755396e-02f, 1.03948705e-01f, 1.55583590e-01f, -4.77271006e-02f, -1.79945994e-02f, 9.65749398e-02f, 1.19942747e-01f,
  1.24951690e-01f, 1.63890749e-01f, -6.82176203e-02f, 9.10724280e-04f, 6.56065717e-02f, -7.11327866e-02f, -1.27576943e-03f, -8.33465811e-03f, -8.05150494e-02f, 1.91560552e-01f,
  1.55358747e-01f, 8.87412503e-02f, -1.06203675e-01f, 1.16366826e-01f, 3.14244479e-02f, 3.12390681e-02f, 1.10806450e-01f, 3.52675691e-02f, 4.24504392e-02f, 9.54378843e-02f,
  -1.29031176e-02f, -1.29017502e-01f, 1.59051031e-01f, -5.39689511e-02f, 9.69068259e-02f, -1.42278716e-01f, 5.96851520e-02f, -1.90358851e-02f, -4.95658303e-03f, -7.11332727e-03f,
  -5.89622147e-02f, 1.07462101e-01f, 2.40588803e-02f, 4.45026569e-02f, 5.58832213e-02f, 1.40325487e-01f, 6.33864254e-02f, -9.34517905e-02f, 2.46084243e-01f, -9.33288932e-02f,
  -6.77587464e-02f, -3.77414376e-02f, -4.15827846e-03f, -2.36497223e-02f, 9.84642580e-02f, -4.66751903e-02f, 1.52070485e-02f, -1.27627015e-01f, 1.74555972e-01f, -6.15126975e-02f,
  1.22939497e-01f, 5.94044067e-02f, 2.13818997e-01f, -1.26474977e-01f, -1.51250944e-01f, -1.90681666e-02f, -1.38887122e-01f, 3.30722481e-02f, 1.65865049e-01f, 3.90926711e-02f,
  -6.64748847e-02f, 1.35006264e-01f, -1.30763082e-02f, 1.20435283e-02f, 3.20655294e-02f, 6.90113800e-03f, -4.20796089e-02f, 8.05908218e-02f, -1.13554671e-01f, 5.20983860e-02f,
  1.18525699e-02f, 1.61590800e-02f, 4.47881706e-02f, -9.86107904e-03f, -7.50863254e-02f, -6.12253062e-02f, -7.31747374e-02f, 3.83600369e-02f, -6.95382431e-02f, -1.36545589e-02f,
  2.06269771e-01f, 5.53267747e-02f, -2.81709488e-02f, 1.80078838e-02f, 9.26600322e-02f, 7.16399699e-02f, 1.61065966e-01f, 1.24667294e-01f, -9.41917822e-02f, 1.19284347e-01f,
  2.38215029e-01f, -2.00445056e-02f, 5.06735109e-02f, 7.97766969e-02f, 8.42444450e-02f, 1.26390174e-01f, 4.09730934e-02f, 1.18181936e-01f, 1.15459055e-01f, 9.66314375e-02f,
  2.13080831e-02f, -1.04469135e-01f, 1.93251535e-01f, -7.50333369e-02f, 2.49174476e-01f, -1.77690759e-01f, 1.05676495e-01f, 2.03001946e-02f, -8.60696435e-02f, -8.29269588e-02f,
  -9.54043642e-02f, -9.54548046e-02f, 4.13848041e-03f, 8.28868151e-02f, -8.20905045e-02f, 7.93908834e-02f, -1.22609086e-01f, 6.13678396e-02f, 3.59218381e-02f, 1.12496406e-01f,
  -1.33909397e-02f, 3.04605421e-02f, 6.45230338e-02f, -3.07377391e-02f, -5.75087257e-02f, 6.22261167e-02f, 3.82385924e-02f, -5.54369837e-02f, -7.34105408e-02f, -1.97367393e-03f,
  -1.09952606e-01f, -3.60333361e-02f, 7.24241287e-02f, 3.47705521e-02f, 1.10063493e-01f, 4.79328930e-02f, 5.83832189e-02f, -1.57383293e-01f, 1.12831198e-01f, -8.63527060e-02f,
  7.79105946e-02f, -1.18756078e-01f, -5.48218153e-02f, -2.45282445e-02f, -6.44742846e-02f, -5.39766345e-03f, 1.10308856e-01f, -8.08038469e-03f, 1.86871756e-02f, 2.28692461e-02f,
  4.71879356e-02f, 3.41856219e-02f, 7.32465088e-02f, 1.05212569e-01f, 3.95433931e-03f, -3.33176851e-02f, 4.38115709e-02f, 3.35175619e-02f, -6.89589605e-02f, 1.14557505e-01f,
  -9.51636806e-02f, 8.63046423e-02f, -5.10774776e-02f, 3.28361690e-02f, -1.71966646e-02f, 1.06617130e-01f, 7.54777193e-02f, 9.11154598e-02f, -3.23085493e-04f, -8.64858851e-02f,
  -6.44508451e-02f, -1.47320405e-01f, 2.19485094e-03f, 1.08909495e-01f, 5.48372641e-02f, 9.51939896e-02f, -2.06845459e-02f, 9.04850736e-02f, -3.15723382e-02f, 1.86353639e-01f,
  -1.31298043e-02f, 1.13167293e-01f, -7.98440247e-04f, -9.32718664e-02f, 3.37711126e-02f, 6.66442662e-02f, 4.39493991e-02f, 6.07504360e-02f, 2.73164921e-02f, -3.57272997e-02f,
  -1.13691892e-02f, -1.02193974e-01f, -1.36759747e-02f, 1.23375282e-02f, -1.14426538e-01f, 1.19727097e-01f, -8.44339281e-02f, 2.46166717e-02f, 1.38314171e-02f, 1.20371021e-01f,
  8.48657414e-02f, -5.08701876e-02f, -1.54342912e-02f, -8.64658952e-02f, 1.22376028e-02f, -9.80794281e-02f, -7.17478320e-02f, -6.71537593e-02f, -1.02547891e-02f, -9.72529128e-02f,
  2.11842552e-01f, 1.09270841e-01f, 2.54685760e-01f, 7.91792870e-02f, 2.26071984e-01f, -3.04212034e-01f, 2.26502344e-01f, -1.06002003e-01f, -1.28565311e-01f, -1.80023517e-02f,
  -3.37747112e-03f, 7.98273608e-02f, 3.71545292e-02f, 7.82712325e-02f, -5.84134050e-02f, 2.24358868e-02f, -9.06066447e-02f, 1.55983031e-01f, 1.95821807e-01f, -9.07717180e-03f,
  4.42395300e-01f, -5.61479181e-02f, 1.63133919e-01f, 1.21493362e-01f, 7.92778581e-02f, 5.02768308e-02f, 1.96667269e-01f, 1.20921172e-01f, -4.88837063e-02f, -3.30875963e-02f,
  1.39472649e-01f, -1.67843327e-01f, 4.70865250e-01f, -1.57144368e-01f, 5.07161975e-01f, 9.25014988e-02f, 9.57214385e-02f, 1.14725158e-01f, -8.44163671e-02f, 2.60821935e-02f,
  6.52839541e-02f, -4.48494628e-02f, -2.14208122e-02f, -5.78961754e-03f, -7.32391849e-02f, -1.17532179e-01f, -8.73610079e-02f, 8.77952129e-02f, -6.26256038e-03f, 1.97180152e-01f,
  1.21095225e-01f, 1.48827240e-01f, 9.15536284e-02f, -1.49684012e-01f, 1.71845526e-01f, -2.36664951e-01f, -4.81444746e-02f, 5.00642583e-02f, -1.83064356e-01f, -1.31857529e-01f,
  -1.26849666e-01f, 9.52640250e-02f, 1.66233256e-01f, 3.17882858e-02f, 1.90441504e-01f, 4.36782576e-02f, 2.37793356e-01f, 5.45095466e-02f, 1.95477515e-01f, 3.57213095e-02f,
  1.18563950e-01f, -1.04138374e-01f, 9.31612626e-02f, -2.21867543e-02f, -7.21721584e-03f, 1.07582463e-02f, 1.22641630e-01f, -1.17909759e-01f, 5.35205491e-02f, -9.36689973e-02f,
  -9.84252710e-03f, -2.57318933e-02f, 3.49150784e-02f, -3.07909455e-02f, 1.50982395e-01f, 1.33976592e-02f, 1.41935542e-01f, -1.17412850e-01f, -1.19302362e-01f, 6.44527376e-03f,
  4.06276397e-02f, -1.55569166e-01f, -1.27075985e-01f, -3.96433510e-02f, 1.69201344e-02f, -6.38387278e-02f, 2.28219882e-01f, 7.89290965e-02f, 5.45966141e-02f, -6.93210438e-02f,
  -9.44538936e-02f, -1.01930127e-01f, 4.72034588e-02f, -7.39978626e-02f, -1.10343816e-02f, -1.69116091e-02f, 2.51580551e-02f, -7.65527710e-02f, -1.28446952e-01f, -1.16777048e-01f,
  -4.85576354e-02f, 2.58342922e-03f, -1.04787841e-01f, 1.37156069e-01f, -4.79383469e-02f, -1.37583971e-01f, 5.26905879e-02f, 2.13682391e-02f, 1.62975535e-01f, -3.92083451e-02f,
  3.89080048e-02f, -5.11575080e-02f, 7.83692859e-03f, 2.42933184e-02f, -1.37682095e-01f, -1.08222410e-01f, -3.84781361e-02f, 2.58414559e-02f, -3.16970237e-02f, -9.29015502e-02f,
  3.73256095e-02f, -2.64238790e-02f, -7.67438486e-02f, 5.86540718e-03f, 3.75413476e-03f, 1.22283332e-01f, 1.82889983e-01f, 5.99731058e-02f, -6.88907132e-02f, -6.23054244e-02f,
  6.51377887e-02f, 1.06280848e-01f, 9.16970894e-02f, -1.79870892e-02f, 7.72178546e-03f, -1.06636174e-01f, -3.28046381e-02f, 1.10941499e-01f, -9.65984687e-02f, 8.81055444e-02f,
  9.97949317e-02f, 1.68675929e-01f, 4.44552973e-02f, 5.59924431e-02f, -9.25137550e-02f, 1.34913221e-01f, -1.37637481e-02f, 1.07229326e-03f, -1.14423260e-02f, -8.11223760e-02f,
  3.34393829e-02f, 2.75853425e-02f, -7.65480623e-02f, -6.43451065e-02f, -2.80360617e-02f, 9.98121649e-02f, 1.94864571e-02f, -3.64792137e-03f, 8.58291909e-02f, -3.36932461e-03f,
  5.80625236e-02f, 7.11313635e-02f, -8.11832547e-02f, 8.29098839e-03f, -3.77280638e-02f, 1.32980973e-01f, -2.03808211e-02f, -5.89039363e-02f, 1.37271592e-02f, 3.59464027e-02f,
  -5.93725406e-02f, 3.64520997e-02f, 8.38371217e-02f, -1.17806252e-02f, -5.22464328e-02f, -4.63204123e-02f, 7.02278763e-02f, -6.31722957e-02f, -1.17333859e-01f, 3.68423983e-02f,
  5.34444340e-02f, 9.85588296e-04f, 1.92423258e-02f, 1.11274227e-01f, 1.08728893e-01f, 1.33352384e-01f, -2.35887431e-02f, 1.37977824e-02f, 6.07113019e-02f, 8.17248374e-02f,
  1.56582147e-02f, -5.74606881e-02f, -1.73921734e-02f, -7.70777389e-02f, -7.51077831e-02f, 9.20559652e-03f, 3.62876095e-02f, 9.75114759e-03f, -1.28396526e-01f, -3.07843741e-03f,
  6.24513738e-02f, 5.32920323e-02f, -1.53357089e-01f, 4.36909832e-02f, 3.32452618e-02f, 9.10871997e-02f, 4.80688736e-02f, 9.21218917e-02f, 1.10009149e-01f, 7.21071586e-02f,
  -2.91882432e-03f, -2.10863054e-02f, -1.27948821e-01f, -4.91732694e-02f, -1.21095153e-02f, -1.79287381e-02f, 1.29289981e-02f, -3.43795270e-02f, 7.14243576e-03f, 1.04674496e-01f,
  1.08744800e-01f, -1.32407993e-01f, -5.25495559e-02f, 1.32111013e-01f, 8.12536776e-02f, 4.42853607e-02f, 1.04424648e-01f, 7.59610310e-02f, -2.24120673e-02f, -6.38595000e-02f,
  -6.93414882e-02f, -8.09074342e-02f, 5.74563518e-02f, 2.38594841e-02f, 1.19013928e-01f, 1.17022589e-01f, 6.51007444e-02f, -1.56558633e-01f, 7.85226375e-02f, -1.99180786e-02f,
  2.12584306e-02f, -9.87352803e-02f, -7.71960765e-02f, 9.00129378e-02f, 2.55408734e-01f, 1.32316455e-01f, 2.48691306e-01f, 1.59321383e-01f, 1.63387116e-02f, -1.29490905e-02f,
  3.10834637e-03f, 6.88553005e-02f, 1.14060804e-01f, -2.32528523e-01f, 1.94035932e-01f, 3.07782322e-01f, 1.91116288e-01f, 7.22038895e-02f, 1.69239029e-01f, -1.47251813e-02f,
  1.49484023e-01f, -1.17241539e-01f, 5.91119640e-02f, 1.10596545e-01f, -6.51125982e-02f, -1.23171680e-01f, -3.52092125e-02f, -1.27667293e-01f, 2.14740381e-01f, -2.24302962e-01f,
  -7.19629452e-02f, -6.08201697e-02f, -1.41371369e-01f, -6.62873089e-02f, 6.39746711e-02f, -9.23581049e-02f, 7.90123269e-02f, -1.21763907e-02f, 1.70973912e-01f, 3.04349095e-01f,
  6.48720637e-02f, -1.76759660e-02f, -8.90718699e-02f, -6.77314773e-02f, 5.49904630e-02f, -4.02921848e-02f, -7.13144615e-02f, 6.02312833e-02f, -1.18086502e-01f, -5.28395288e-02f,
  -5.14727421e-02f, -2.70934671e-01f, 9.82431322e-02f, 4.43412177e-02f, 1.06878363e-01f, -1.33884281e-01f, -1.34436041e-01f, -4.76167053e-02f, 6.41877949e-02f, -7.41329193e-02f,
  2.11224571e-01f, -7.67536238e-02f, 7.73763880e-02f, -6.41315728e-02f, 2.92255074e-01f, -1.28268585e-01f, -5.85344546e-02f, -3.00301500e-02f, -1.66654706e-01f, -1.29880607e-01f,
  -1.23675682e-01f, -8.72805864e-02f, -1.46898180e-01f, -1.38982341e-01f, 8.45008716e-02f, 1.86800376e-01f, 1.67143807e-01f, -7.71225523e-03f, -3.52360122e-02f, 1.68369725e-01f,
  2.84206182e-01f, -7.27147758e-02f, -3.05514745e-02f, 1.17017411e-01f, 2.56365743e-02f, 4.28420566e-02f, 3.45860273e-02f, 2.30868720e-02f, -9.26973820e-02f, 9.14755685e-04f,
  3.12291831e-01f, 1.51687056e-01f, 1.62633304e-02f, -3.25056762e-02f, -1.20853089e-01f, -1.05438404e-01f, -3.13158915e-03f, 3.05968383e-03f, 5.82445562e-02f, 9.50587541e-02f,
  4.31707203e-02f, -3.58089022e-02f, -1.58643182e-02f, 1.20130911e-01f, -1.22072272e-01f, 3.69056277e-02f, -3.88546921e-02f, -1.15912907e-01f, 2.37240158e-02f, 5.71147688e-02f,
  1.43347219e-01f, 8.93221498e-02f, 1.16186179e-01f, -4.09335904e-02f, 2.42396514e-03f, 2.43278965e-01f, -8.82530138e-02f, 2.96012491e-01f, -1.28564984e-01f, 7.64216557e-02f,
  -7.48130307e-02f, 3.55799794e-02f, 9.68925953e-02f, -4.54223668e-03f, -1.23969853e-01f, 6.23454154e-02f, 4.29627821e-02f, -1.29996845e-02f, 3.88382562e-02f, 3.54012251e-02f,
  -1.17769860e-01f, -6.54557273e-02f, 3.68222818e-02f, 1.90626010e-01f, 1.22624286e-01f, 4.26904447e-02f, 1.15349896e-01f, 1.76879764e-01f, 9.17655379e-02f, 3.21885198e-02f,
  -1.92150846e-01f, 9.49438289e-02f, -6.10068962e-02f, -1.72049209e-01f, -1.74901813e-01f, -1.92923266e-02f, -5.89275435e-02f, 3.82325947e-02f, 4.34634201e-02f, 1.49593502e-01f,
  -3.22821513e-02f, 1.18675865e-01f, 4.14419472e-02f, -5.59206121e-02f, 2.55940199e-01f, -3.92011516e-02f, 2.47615218e-01f, -1.85781419e-01f, 5.52650355e-02f, 1.86191678e-01f,
  -9.99321565e-02f, 1.32235914e-01f, -1.18239909e-01f, 1.56362578e-01f, 5.70105091e-02f, -5.62559292e-02f, 7.06558079e-02f, -4.91830185e-02f, -6.48114979e-02f, -2.67555267e-02f,
  1.14636153e-01f, -8.63641575e-02f, -1.30955487e-01f, -5.73104210e-02f, -3.54200788e-02f, -7.99887404e-02f, -1.00933895e-01f, 1.15464911e-01f, 5.81394881e-03f, 2.79712468e-01f,
  4.64325398e-02f, 7.20089599e-02f, 4.15361188e-02f, 3.75698023e-02f, -1.56687096e-01f, -1.02266945e-01f, -3.11144888e-02f, -1.42451495e-01f, -5.23236245e-02f, 6.04763329e-02f,
  1.40153855e-01f, 5.71104698e-02f, -1.27930999e-01f, -1.21209718e-01f, 3.08006220e-02f, -6.80276901e-02f, 1.28669143e-01f, 5.20297438e-02f, -6.47193566e-02f, -1.48226827e-01f,
  -1.00303397e-01f, 4.23140228e-02f, -1.33690730e-01f, 2.96183247e-02f, 1.21142574e-01f, -8.12454373e-02f, -1.57059804e-02f, -1.90646201e-02f, 2.93269813e-01f, -9.54844058e-02f,
  1.26409739e-01f, -5.34364432e-02f, 9.53673199e-02f, 1.64202705e-01f, 7.99684972e-02f, 3.04662250e-02f, -5.80412820e-02f, 8.39907378e-02f, 1.31159112e-01f, -9.27523151e-03f,
  -1.23219788e-01f, 4.27168570e-02f, -8.32177177e-02f, -1.72476754e-01f, -7.43611380e-02f, -4.25523259e-02f, 1.30342925e-02f, -1.00040168e-01f, -4.52082902e-02f, 1.13401391e-01f,
  2.18877178e-02f, 2.36606508e-01f, -9.74868983e-02f, -1.27485814e-02f, -1.31657466e-01f, 6.88260272e-02f, 1.19659647e-01f, 1.69947483e-02f, -6.69722738e-07f, 1.55194029e-01f,
  -6.10922836e-02f, 8.27300325e-02f, 3.31096374e-03f, 1.39094174e-01f, 8.31742510e-02f, 2.69887000e-01f, -3.67830917e-02f, -7.02602193e-02f, -1.72539372e-02f, 1.64736509e-02f,
  -1.28947049e-01f, -1.10072017e-01f, -5.25710657e-02f, 1.76276475e-01f, 4.80745770e-02f, 1.53000057e-01f, 1.77592188e-01f, -1.70244239e-02f, 8.71400461e-02f, 5.69429509e-02f,
  -4.87259887e-02f, 1.34114884e-02f, 3.74365151e-02f, 1.05799019e-01f, 1.84338018e-01f, 1.18196812e-02f, 6.43702298e-02f, 5.78599833e-02f, -1.79254726e-01f, 2.97109913e-02f,
  1.06787026e-01f, -1.83881491e-01f, -2.17270732e-01f, 1.37596071e-01f, -2.69188881e-02f, -1.14784110e-02f, 1.74933940e-01f, 1.17913499e-01f, -7.13027045e-02f, 9.97421984e-03f,
  6.70836912e-03f, 1.17229009e-02f, 6.52574450e-02f, -7.06319958e-02f, 4.14355472e-02f, 1.12678491e-01f, -8.10836181e-02f, -1.55961392e-02f, -1.18552722e-01f, 1.37313530e-01f,
  -2.86785681e-02f, 2.21955612e-01f, 2.69878693e-02f, -4.84967902e-02f, -9.77939740e-02f, -1.92667037e-01f, -9.03296694e-02f, 6.91945013e-03f, 9.87203345e-02f, -4.47665751e-02f,
  -9.86804888e-02f, 8.57575685e-02f, -1.87724512e-02f, -1.12967990e-01f, 8.48583132e-02f, 7.57972598e-02f, 4.40410450e-02f, 2.76658803e-01f, -6.82758689e-02f, -1.67207211e-01f,
  5.15560396e-02f, 1.34419486e-01f, 1.43127158e-01f, -9.53680053e-02f, 2.15684548e-02f, -5.34227304e-02f, -4.53788042e-02f, -1.49511635e-01f, 1.27436653e-01f, -1.40860751e-01f,
  2.70767454e-02f, -6.73074201e-02f, 6.40279800e-02f, 5.84408157e-02f, 1.07038490e-01f, 2.81525049e-02f, 1.53638676e-01f, 1.52949765e-01f, 1.87115148e-01f, 7.94350505e-02f,
  2.76419044e-01f, -6.25629127e-02f, -7.76762143e-02f, -8.65756199e-02f, -2.34358907e-01f, -1.30780861e-01f, -2.75431126e-01f, 1.98646232e-01f, -1.88949838e-01f, -5.90754338e-02f,
  1.09841071e-01f, 5.87288737e-02f, -8.60582739e-02f, 5.61601408e-02f, 6.16082847e-02f, 3.40022482e-02f, 2.22345084e-01f, 1.57019824e-01f, 2.96630502e-01f, -8.51897672e-02f,
  7.64624402e-02f, 3.00332308e-01f, -1.24483854e-01f, -9.36932117e-02f, 6.58922344e-02f, 2.47812450e-01f, 1.10069945e-01f, -1.09885804e-01f, 6.63330331e-02f, -2.24648386e-01f,
  2.71620750e-01f, -4.06365916e-02f, 1.73525319e-01f, -1.23474725e-01f, 3.80942263e-02f, 1.27043992e-01f, -3.30362692e-02f, -2.42446214e-01f, 5.62294424e-02f, 2.20034659e-01f,
  -1.19360186e-01f, 1.68815896e-01f, -1.32861733e-01f, -5.28369397e-02f, -5.85315004e-02f, 1.56145066e-01f, 3.42131332e-02f, 3.32600204e-03f, 1.48308456e-01f, 1.29365893e-02f,
  6.23583235e-02f, 1.19580984e-01f, 1.56024843e-01f, -3.86672541e-02f, -2.29743302e-01f, 6.81758672e-02f, 5.73488772e-02f, -1.14252754e-02f, 9.03635249e-02f, 1.20804198e-01f,
  -4.40340303e-02f, 1.15948766e-02f, -7.89473206e-02f, -8.67455155e-02f, 1.56171009e-01f, 5.75871058e-02f, -6.15602359e-03f, -1.56935696e-02f, -7.54283667e-02f, -6.97679296e-02f,
  -1.25561282e-01f, 7.76172499e-04f, 7.90635869e-03f, -7.08018467e-02f, 1.30831599e-01f, -4.89531048e-02f, -9.22784805e-02f, 3.19016948e-02f, 2.15873756e-02f, 1.06531784e-01f,
  4.59629446e-02f, -2.35935804e-02f, -8.35277587e-02f, 3.67811844e-02f, 7.28122517e-02f, 3.29071432e-02f, -8.82968828e-02f, -8.48593339e-02f, 7.67169818e-02f, 2.02881377e-02f,
  2.18073912e-02f, -6.51726872e-02f, -9.58150346e-03f, -4.25572023e-02f, -6.46952912e-03f, -2.28163041e-02f, 1.46621153e-01f, 8.97146985e-02f, 1.19853213e-01f, 8.90690610e-02f,
  4.40287888e-02f, -6.16517663e-02f, 1.38899740e-02f, 6.34958223e-02f, -5.98837957e-02f, -9.64430198e-02f, -1.21360183e-01f, 1.97251756e-02f, 5.39290942e-02f, 4.78375852e-02f,
  -6.26771599e-02f, -1.21576436e-01f, 8.02440941e-02f, 4.39454652e-02f, 5.45270853e-02f, -7.35673681e-03f, 5.97698092e-02f, -7.83020705e-02f, -5.10885939e-02f, -6.86152801e-02f,
  2.85017956e-02f, 3.14956680e-02f, -2.44865008e-02f, -5.54466806e-02f, 1.10886425e-01f, 6.78696260e-02f, 1.44837365e-01f, 1.50704950e-01f, 1.53290465e-01f, -8.15279856e-02f,
  -5.51256239e-02f, -1.01354688e-01f, -1.87642440e-01f, 1.38250785e-02f, -1.31322414e-01f, -7.70252049e-02f, -3.44376117e-02f, 4.87055667e-02f, 4.89893816e-02f, 2.02144757e-02f,
  -3.12581100e-02f, 2.81334296e-02f, -3.39256600e-02f, 1.11011013e-01f, 1.17219880e-01f, 5.46668731e-02f, -3.63796167e-02f, 1.18985251e-01f, -7.73303583e-02f, 2.28985157e-02f,
  1.23202838e-01f, -5.40372217e-03f, -6.26907870e-02f, 5.84643744e-02f, 6.84127212e-02f, -8.99928734e-02f, -3.25872493e-03f, -1.00883506e-01f, 1.84292868e-01f, 1.73926447e-02f,
  1.62531108e-01f, -3.87696251e-02f, -8.32390636e-02f, -4.54366393e-02f, 5.38261468e-03f, -9.68930796e-02f, -8.27036574e-02f, 8.25146809e-02f, 4.44452278e-02f, -2.21171454e-02f,
  -9.75793153e-02f, -2.49592774e-02f, -7.16260495e-03f, 1.82927698e-01f, -2.24908832e-02f, 4.28785272e-02f, -3.44756693e-02f, -1.07927561e-01f, 9.33372006e-02f, -1.14061221e-01f,
  -4.11180081e-03f, -1.64893363e-02f, 6.96904659e-02f, 3.05711031e-02f, -4.58022160e-03f, -4.13499288e-02f, 1.01321407e-01f, 5.76773919e-02f, -1.46144927e-01f, -9.79752317e-02f,
  1.91261619e-02f, -1.42246619e-01f, -1.11775562e-01f, 9.56429020e-02f, -2.18274957e-03f, 1.57931417e-01f, 1.37594625e-01f, -1.39138371e-01f, 6.73006549e-02f, -1.14485912e-01f,
  1.43517694e-02f, -3.57277803e-02f, 1.60200328e-01f, 9.21965465e-02f, 4.88097556e-02f, 7.75035992e-02f, 7.28195682e-02f, -5.37278242e-02f, -1.00122035e-01f, 1.02964550e-01f,
  -1.72919780e-01f, 1.30904332e-01f, 1.19057596e-02f, 9.70153064e-02f, 4.57968265e-02f, -6.70891702e-02f, 1.00446314e-01f, -5.54897357e-03f, -4.35793363e-02f, -9.13342386e-02f,
  -2.15774681e-02f, 1.27682075e-01f, -1.74488500e-01f, -4.05128673e-02f, 1.25674337e-01f, 8.61140415e-02f, -9.02192965e-02f, -7.39955306e-02f, 2.19999906e-02f, 1.49409965e-01f,
  3.47369500e-02f, -6.94258586e-02f, -7.62863457e-02f, 1.12173215e-01f, 4.32306379e-02f, 1.35153309e-01f, -1.23312384e-01f, -1.55979037e-01f, -4.48389351e-02f, -1.28957644e-01f,
  -5.92879429e-02f, 9.20805112e-02f, 9.74008068e-02f, -1.16766728e-02f, 1.23727657e-01f, 4.12194133e-02f, -8.54583830e-03f, 7.81160146e-02f, -1.00990675e-01f, -9.28880125e-02f,
  5.38287386e-02f, 1.29437402e-01f, 2.48178139e-01f, 7.91699439e-02f, 1.94034949e-01f, 1.82123497e-01f, 6.13881312e-02f, 2.78062411e-02f, 2.15232342e-01f, -2.48405114e-01f,
  2.86526922e-02f, 2.73703665e-01f, -4.83966917e-02f, -4.03652601e-02f, -8.72562677e-02f, 1.07360579e-01f, 1.29932955e-01f, 3.74729210e-03f, 7.54174367e-02f, 1.42868489e-01f,
  -7.65100168e-03f, -1.50841147e-01f, 1.24708541e-01f, -2.36899219e-03f, 2.48995721e-01f, -2.28403658e-01f, -3.15649807e-02f, 4.65154313e-02f, 6.02917299e-02f, -1.83135539e-01f,
  9.96740013e-02f, -1.79146320e-01f, 1.58392757e-01f, -3.48519012e-02f, 3.46189409e-01f, 1.51192814e-01f, 1.70852661e-01f, -1.02734184e-02f, 3.13332155e-02f, -4.66411188e-02f,
  1.43323824e-01f, -6.72778264e-02f, 1.04577065e-01f, 9.97357219e-02f, 6.73142774e-03f, 3.32364254e-02f, 4.15259860e-02f, -2.88005263e-01f, -8.47575068e-02f, 4.94491160e-02f,
  8.18306282e-02f, 6.58579287e-04f, 8.81716609e-02f, 3.93923298e-02f, 2.26865690e-02f, -1.08627349e-01f, 9.34831947e-02f, -1.73785076e-01f, -1.61351189e-01f, 6.04802975e-03f,
  1.92020372e-01f, 7.20393956e-02f, 3.26332524e-02f, -6.39977530e-02f, 9.04572476e-03f, -3.92786860e-02f, -1.24348037e-01f, 8.03364739e-02f, 5.39854951e-02f, 6.67191818e-02f,
  3.79883982e-02f, -1.20121792e-01f, -3.92446555e-02f, -4.09650542e-02f, -1.08531065e-01f, 8.07958990e-02f, 1.52132273e-01f, -1.81297548e-02f, -1.95580740e-02f, -1.91488490e-02f,
  -1.08387815e-02f, 4.05762121e-02f, 1.02508336e-01f, -1.20723873e-01f, -3.65825407e-02f, 1.43820539e-01f, 1.68081429e-02f, -1.01355277e-01f, -8.29748958e-02f, -4.07896973e-02f,
  -8.35603774e-02f, 2.25666687e-02f, -7.99342021e-02f, 7.48788565e-02f, 1.13267466e-01f, -1.36897564e-01f, 6.33757263e-02f, -6.54283985e-02f, 5.48616275e-02f, -1.39848396e-01f,
  9.48452111e-03f, -1.86721217e-02f, -7.27605224e-02f, -1.28367603e-01f, 3.87286507e-02f, -5.69485947e-02f, 1.26533121e-01f, -5.77668324e-02f, 9.38906446e-02f, 7.55466223e-02f,
  7.82263950e-02f, -9.74107534e-02f, 1.01507440e-01f, 1.61194742e-01f, 2.59062834e-02f, 4.33757016e-03f, 1.33236364e-01f, -9.68183670e-03f, 6.73725680e-02f, 1.05506994e-01f,
  1.26655120e-03f, -3.83932926e-02f, -1.49035722e-01f, 1.34703949e-01f, 4.51363772e-02f, 7.14946613e-02f, 6.15507215e-02f, 4.62186672e-02f, -4.01540688e-04f, 2.39224210e-02f,
  2.92507969e-02f, 1.66604724e-02f, 1.44490823e-01f, 5.01326844e-03f, -1.03175662e-01f, 4.81764637e-02f, -7.09169284e-02f, 1.30830824e-01f, -5.48583977e-02f, -1.36115178e-01f,
  -5.16956449e-02f, 8.18860829e-02f, -3.16159539e-02f, 1.16676971e-01f, -4.98304563e-03f, -5.12579596e-03f, -6.05267510e-02f, -1.26699641e-01f, 1.09120451e-01f, 1.18844800e-01f,
  1.10761382e-01f, 8.79633650e-02f, -1.72105148e-01f, 2.22098410e-01f, -7.37695619e-02f, 1.90466736e-02f, 1.00016840e-01f, -7.48921484e-02f, -1.52953323e-02f, 2.23137856e-01f,
  -2.83057410e-02f, 1.34088784e-01f, 1.43958092e-01f, -2.15080619e-01f, 2.16075063e-01f, 1.82961207e-02f, 4.16132398e-02f, -9.04424936e-02f, -3.60697694e-02f, -5.49218506e-02f,
  1.77598614e-02f, 2.55706552e-02f, 1.53892245e-02f, 1.34319618e-01f, -3.78624760e-02f, 7.02808201e-02f, -5.90986349e-02f, 5.24646975e-02f, 1.12983383e-01f, 1.36134073e-01f,
  8.08703750e-02f, 1.38662368e-01f, -2.36948226e-02f, 1.47249084e-04f, -8.06476548e-02f, -2.81765312e-02f, 5.74101061e-02f, 2.34217290e-02f, -1.07344925e-01f, -4.40174155e-02f,
  2.45602503e-02f, 2.42161416e-02f, -1.04541153e-01f, -1.47982284e-01f, -2.56770790e-01f, -1.86575711e-01f, -9.73814949e-02f, 4.07465734e-02f, -6.15491485e-03f, 9.77010727e-02f,
  -8.72385949e-02f, 9.43762287e-02f, -3.60563025e-02f, 1.26551077e-01f, 1.53402805e-01f, -1.19091213e-01f, 1.20922901e-01f, 1.02120131e-01f, 1.65618420e-01f, 1.12653626e-02f,
  -1.04981564e-01f, -1.55086413e-01f, 1.10480607e-01f, 2.22671449e-01f, 1.57593876e-01f, -6.74360842e-02f, -2.42853865e-01f, 1.57121867e-02f, 7.68991038e-02f, -1.36495188e-01f,
  4.38815244e-02f, 1.72264382e-01f, -5.99538609e-02f, 1.42899394e-01f, 1.05091371e-02f, 2.32698526e-02f, 1.87089685e-02f, 1.35052457e-01f, -1.77770797e-02f, -1.86164901e-02f,
  8.66017640e-02f, 9.38148946e-02f, -7.05501530e-03f, 5.05687483e-02f, 1.56573355e-01f, 1.87727168e-01f, -8.83439630e-02f, 1.67415306e-01f, -3.15574463e-03f, 1.42004237e-01f,
  7.53069762e-03f, 2.76232988e-01f, -3.99973355e-02f, -3.89071330e-02f, 1.24434922e-02f, 1.23826861e-01f, 3.92760476e-03f, 5.93449064e-02f, 1.82209723e-02f, 1.57598853e-01f,
  -2.52229813e-02f, 9.97863412e-02f, 5.87931387e-02f, 1.07932016e-02f, -5.44008650e-02f, -3.73228118e-02f, 5.27035519e-02f, 8.58328789e-02f, -1.17779411e-01f, -7.62640610e-02f,
  5.55363670e-02f, 1.33281901e-01f, -1.76216774e-02f, 7.16132075e-02f, -1.30904838e-01f, 1.28958747e-01f, 2.40750432e-01f, -1.56512156e-01f, -9.26591381e-02f, -2.02269033e-02f,
  -7.53662214e-02f, 6.61949292e-02f, 3.87859121e-02f, 1.51015371e-02f, -1.60357170e-02f, 3.58161442e-02f, -4.85411659e-02f, -1.14134967e-01f, 1.10982493e-01f, 1.70319796e-01f,
  1.45081699e-01f, -1.87688507e-02f, 3.14432010e-02f, -1.18010290e-01f, -1.26092061e-02f, 2.06556737e-01f, 9.83549803e-02f, 1.55659288e-01f, 5.30169625e-03f, 8.93433690e-02f,
  -1.60142988e-01f, 5.70886657e-02f, -6.03015199e-02f, -3.53125818e-02f, 1.65823996e-01f, -2.73721758e-02f, -1.09482929e-01f, 1.45547062e-01f, -5.59594147e-02f, -5.45135885e-02f,
  9.51046646e-02f, 1.86682746e-01f, -4.53130901e-02f, 3.43084365e-01f, 2.47335099e-02f, 3.90275046e-02f, -6.81290179e-02f, -1.61826178e-01f, 4.29781862e-02f, -3.96574512e-02f,
  9.77603719e-02f, 7.78552592e-02f, -3.83524336e-02f, 1.80724323e-01f, 1.54955283e-01f, -4.20995168e-02f, -2.58956533e-02f, -5.53045608e-02f, -5.79042472e-02f, -7.50561431e-03f,
  -4.16939035e-02f, -1.97713107e-01f, -1.36097029e-01f, -1.68539718e-01f, 3.00916359e-02f, -1.03408530e-01f, 8.39175060e-02f, 1.04790978e-01f, 1.20357372e-01f, -3.76264006e-03f,
  8.08665752e-02f, 3.94720472e-02f, 2.59862132e-02f, 3.02112661e-02f, 8.20657425e-03f, 1.16015427e-01f, -1.89011637e-02f, -5.73971570e-02f, -8.22527781e-02f, 9.40841530e-03f,
  8.47282857e-02f, -6.13423772e-02f, 1.10650763e-01f, 3.14320177e-02f, 5.12917414e-02f, 8.62730592e-02f, -8.70141536e-02f, -1.84473425e-01f, 1.20638013e-01f, 1.58909589e-01f,
  1.00967012e-01f, -5.96860470e-03f, 1.19650602e-01f, -2.37901602e-03f, 1.04750030e-01f, 1.11368872e-01f, 2.18156338e-01f, 1.19412154e-01f, 7.70466849e-02f, -4.68915189e-03f,
  4.00424190e-02f, 3.93907018e-02f, 1.62172452e-01f, 1.45298302e-01f, 1.08309679e-01f, -7.27435648e-02f, 1.47376638e-02f, -8.37236736e-03f, 1.61750391e-02f, 9.67644006e-02f,
  -6.58818483e-02f, 6.02321653e-03f, -8.73792097e-02f, 3.13875712e-02f, 4.21645418e-02f, 8.22524130e-02f, -3.65525968e-02f, -8.12080726e-02f, -6.06526360e-02f, 1.62536010e-01f,
  -3.34707685e-02f, -1.19005635e-01f, 5.06779402e-02f, -6.13755211e-02f, -1.00105949e-01f, 1.63831040e-02f, -7.73899769e-03f, 8.58097151e-02f, -5.63257700e-03f, -2.71931067e-02f,
  -2.70895995e-02f, 5.01960982e-03f, 2.71561183e-02f, -3.76420021e-02f, -1.07775757e-03f, 8.92583728e-02f, 5.59875928e-02f, 2.16253493e-02f, -1.79787688e-02f, 2.06309836e-02f,
  -7.03533664e-02f, -1.08303152e-01f, 2.11696364e-02f, 2.87017990e-02f, 2.10197493e-02f, 4.89826798e-02f, -7.80351982e-02f, 1.24356382e-01f, 1.36862844e-01f, 9.15501732e-03f,
  -1.18770190e-01f, -3.32716410e-03f, -1.18547969e-01f, -1.05593100e-01f, -3.31378095e-02f, -6.20751418e-02f, 1.16487756e-01f, 5.76135442e-02f, 2.32436452e-02f, 7.81139210e-02f,
  -4.72498871e-02f, -5.00177294e-02f, -7.16967359e-02f, -5.86261414e-02f, -1.04918391e-01f, -8.86157155e-02f, -1.08685464e-01f, -1.75529253e-02f, 3.16957645e-02f, -2.07392294e-02f,
  1.16029300e-01f, -2.15395521e-02f, -7.54272193e-02f, 5.04692458e-03f, -9.87944305e-02f, -2.24724803e-02f, 1.18855417e-01f, -1.13342404e-01f, -5.70846498e-02f, -9.48736295e-02f,
  7.55917057e-02f, -3.10440455e-02f, 1.35004222e-01f, -1.12306820e-02f, -2.48310585e-02f, -2.81963423e-02f, 2.93643214e-02f, 9.74836126e-02f, 1.52121544e-01f, 1.69335064e-02f,
  2.10480988e-02f, 1.51817948e-01f, -1.21020056e-01f, 7.65655637e-02f, 1.30826265e-01f, -4.52537462e-03f, -1.18790343e-01f, 6.49673492e-03f, 9.14505571e-02f, -1.93914130e-01f,
  2.51537114e-02f, -1.03962824e-01f, -1.09149180e-01f, 6.31557927e-02f, -2.46401299e-02f, 2.16632225e-02f, -7.17391372e-02f, 7.76917785e-02f, 7.92977028e-03f, -1.10796027e-01f,
  2.59056538e-01f, 1.26473099e-01f, 2.28100538e-01f, -1.59274161e-01f, -5.39017282e-02f, 2.32162382e-02f, -9.78900641e-02f, 1.74781486e-01f, 9.54261720e-02f, 1.17357448e-01f,
  1.04814902e-01f, -5.46468161e-02f, -1.12043813e-01f, 1.05676875e-01f, -1.29733890e-01f, -2.94481330e-02f, 2.60476291e-01f, -9.10877436e-02f, 5.82834752e-03f, 1.15582747e-02f,
  -7.49834767e-03f, -5.48821501e-03f, 9.82923061e-02f, 1.26396343e-01f, -2.48192232e-02f, 4.76738185e-01f, 3.81144583e-02f, 1.11985065e-01f, -5.90829700e-02f, -1.50952622e-01f,
  -1.99744627e-01f, -3.60017759e-03f, -8.09028074e-02f, -4.42750156e-02f, -1.79988936e-01f, 3.05290759e-01f, 1.59855947e-01f, -1.28123999e-01f, -1.56739607e-01f, -1.03378914e-01f,
  -9.70201716e-02f, -1.01712868e-02f, 1.15627185e-01f, 8.94334316e-02f, 1.52130648e-01f, 7.93774650e-02f, 9.83959809e-02f, 5.16489753e-03f, -1.61502138e-01f, 5.84641211e-02f,
  -9.96714532e-02f, 1.30924597e-01f, 1.45154744e-01f, -1.08059667e-01f, 1.05614699e-01f, 1.18390294e-02f, -4.59509492e-02f, -2.47491524e-02f, 1.76557094e-01f, 9.96261761e-02f,
  -7.73757473e-02f, 2.51968019e-02f, 8.18656459e-02f, -3.01381890e-02f, -1.35470316e-01f, -1.12261660e-01f, -4.29699942e-02f, 1.96874604e-01f, 2.29304656e-03f, -6.22805692e-02f,
  -1.21959060e-01f, 1.01183601e-01f, -1.38737634e-01f, 1.16387293e-01f, -1.74585298e-01f, 1.35086104e-01f, -3.81697938e-02f, 1.19960820e-02f, 9.81962010e-02f, -9.46344882e-02f,
  -8.84254053e-02f, 1.73521310e-01f, 1.11392826e-01f, 4.19696122e-02f, 1.08889602e-01f, -4.92440388e-02f, 3.06018200e-02f, -2.77755037e-02f, 7.44192079e-02f, -8.95892922e-03f,
  -1.27304019e-03f, -1.29760697e-01f, -8.09456259e-02f, -1.17136367e-01f, 1.39579281e-01f, 9.29159969e-02f, 1.18233740e-01f, 8.90740082e-02f, 1.65087342e-01f, -1.28767744e-01f,
  -1.07515380e-01f, 4.80021490e-03f, 2.89702564e-01f, -4.91690859e-02f, 1.12694897e-01f, 5.76877929e-02f, -3.38803828e-02f, -5.48709407e-02f, -5.67108616e-02f, 4.10628952e-02f,
  -4.31248583e-02f, 9.79515240e-02f, 3.99524420e-02f, -9.52638835e-02f, -5.41842543e-02f, -8.42140466e-02f, -5.24406657e-02f, 2.58926395e-02f, 9.97323841e-02f, 2.73172613e-02f,
  8.46446864e-03f, 3.59893851e-02f, 1.31610148e-02f, 1.08488046e-01f, 4.43560816e-02f, 5.66345491e-02f, -1.49918012e-02f, 4.92101163e-02f, -1.09312497e-02f, -9.79778096e-02f,
  -7.61238709e-02f, 1.27697915e-01f, 4.64323163e-02f, 1.01801790e-01f, 1.10931583e-01f, -9.08695012e-02f, 1.15474604e-01f, -2.22393107e-02f, -1.97613295e-02f, 1.31724566e-01f,
  6.98744357e-02f, -1.67424027e-02f, 2.53838152e-01f, -7.59206489e-02f, -8.92421156e-02f, -1.36926565e-02f, -5.74121717e-03f, -7.49765942e-03f, 3.93189024e-03f, -6.12851791e-02f,
  -1.13429442e-01f, 2.24865172e-02f, 2.35203281e-02f, 6.58540651e-02f, 1.03634320e-01f, 4.95524295e-02f, 8.19506124e-02f, 1.77070662e-01f, 5.75775374e-03f, 4.71579656e-02f,
  2.47477293e-02f, -2.67316797e-03f, -8.66133496e-02f, -1.97771471e-02f, -1.19463742e-01f, -3.63587588e-02f, 1.07411727e-01f, 1.15635805e-01f, 5.01064807e-02f, -4.88354750e-02f,
  -4.76373695e-02f, -1.10431224e-01f, -3.34333144e-02f, -3.60162891e-02f, 4.03787158e-02f, -7.69298747e-02f, -4.13412228e-02f, -3.98176201e-02f, -4.60337400e-02f, -1.08236112e-01f,
  -1.54288923e-02f, 4.16172855e-02f, -9.60735008e-02f, 8.99688080e-02f, -9.94824618e-02f, 1.05313130e-01f, -9.28993523e-02f, -3.44498158e-02f, 1.65462121e-02f, -8.59530121e-02f,
  1.19067363e-01f, 9.26359277e-03f, -8.45452026e-02f, 2.51833014e-02f, -1.13353014e-01f, -5.96556142e-02f, 4.96193469e-02f, -1.14869930e-01f, -5.34327962e-02f, -4.66312328e-03f,
  -3.92831024e-03f, -9.50048491e-02f, -1.22617185e-01f, -1.81462038e-02f, 1.90594848e-02f, 1.04087777e-01f, -1.10878140e-01f, 6.80890232e-02f, 5.82446530e-02f, -7.31037110e-02f,
  4.63589467e-02f, 1.11775855e-02f, 5.76821640e-02f, 1.49176558e-02f, -9.77356508e-02f, -5.85762411e-02f, 1.12135429e-03f, -9.64946374e-02f, 1.60744227e-02f, -8.49621966e-02f,
  -3.49957086e-02f, 2.40501631e-02f, 8.50432366e-02f, 7.34826699e-02f, -8.14227611e-02f, -9.64239389e-02f, -9.06128511e-02f, -1.03108063e-01f, 7.05926819e-03f, 1.10351793e-01f,
  -4.60684970e-02f, 1.15197793e-01f, 1.14590622e-01f, 1.00097358e-01f, 1.34491205e-01f, 1.87375173e-01f, 9.01210904e-02f, 8.96398202e-02f, 3.18300009e-01f, -1.12997424e-02f,
  2.31039524e-01f, -1.76182300e-01f, -3.74820530e-01f, 2.95252830e-01f, 5.96806519e-02f, -3.36616695e-01f, -1.59800295e-02f, -4.17230390e-02f, -8.53846408e-03f, 1.42500043e-01f,
  7.89386556e-02f, 7.64119476e-02f, 5.04495986e-02f, 1.91764464e-03f, -1.29470170e-01f, 5.39335310e-02f, 2.69919515e-01f, 1.28119186e-01f, 2.17780873e-01f, 2.43013218e-01f,
  -3.49343307e-02f, 7.15349838e-02f, -8.55623335e-02f, 1.23616688e-01f, 2.86978148e-02f, 2.49745995e-01f, 4.53463160e-02f, 8.29295740e-02f, -1.77118897e-01f, -2.01490790e-01f,
  -1.13202706e-01f, 7.26246536e-02f, 3.71402502e-01f, 3.43948649e-03f, -9.20836329e-02f, 1.40278667e-01f, -7.55978227e-02f, 8.02803934e-02f, -6.18232563e-02f, 1.27730548e-01f,
  1.44527256e-02f, 4.41374391e-01f, -1.29742235e-01f, -4.82039861e-02f, -7.00866058e-02f, 2.43954863e-02f, 7.66294152e-02f, 1.26102105e-01f, 5.66612035e-02f, -1.26025721e-01f,
  -4.14408296e-02f, -5.95828779e-02f, 8.99376497e-02f, -1.31096885e-01f, -8.66339356e-02f, 1.06332332e-01f, 6.60351366e-02f, -1.23623069e-02f, 7.37374574e-02f, 1.10750243e-01f,
  1.17382351e-02f, 9.41030458e-02f, 1.08789191e-01f, -1.06693222e-03f, -1.98916346e-01f, 1.29989861e-02f, 1.71268322e-02f, 1.08115599e-01f, 1.25018984e-01f, 1.67325109e-01f,
  1.47200713e-03f, -1.41123027e-01f, 9.46927741e-02f, -7.32083693e-02f, 3.10037524e-01f, 1.49644792e-01f, 9.58775431e-02f, -9.22679827e-02f, -1.10548034e-01f, 9.57478136e-02f,
  -5.33548258e-02f, 9.51479375e-03f, -9.69419852e-02f, 3.87894958e-02f, -1.87408179e-02f, -1.21977575e-01f, -9.68713239e-02f, 7.61948451e-02f, 1.07450761e-01f, 3.12917978e-02f,
  2.30363365e-02f, 9.54997465e-02f, 6.10022172e-02f, 2.74631649e-01f, -1.91844091e-01f, -6.97444007e-02f, -8.43254626e-02f, 7.78619051e-02f, -3.62967849e-02f, -9.91250947e-02f,
  9.65577643e-03f, 1.98165119e-01f, -7.48584494e-02f, -1.70526356e-02f, 9.03200358e-02f, 9.20818537e-04f, -4.16187644e-02f, 1.82021484e-01f, 2.67552640e-02f, -2.72462307e-03f,
  3.09952465e-03f, -1.15910619e-01f, -1.14170060e-01f, 1.97466258e-02f, 1.68836698e-01f, 1.94835052e-01f, 9.06787738e-02f, -1.11656338e-01f, 1.74806952e-01f, 7.14127123e-02f,
  2.10566968e-02f, -6.77036718e-02f, 7.27751777e-02f, 4.06240188e-02f, -1.84214011e-01f, -1.34631202e-01f, -2.51112860e-02f, 1.26835167e-01f, -9.94804278e-02f, 1.09001458e-01f,
  -1.30343780e-01f, -9.37414588e-05f, -3.75878997e-02f, 4.15870845e-02f, 3.17500234e-02f, -1.22675888e-01f, 9.40878168e-02f, -4.07981388e-02f, 1.00850046e-01f, 8.64484459e-02f,
  -1.07400184e-02f, -8.17163102e-03f, -2.60098223e-02f, 1.87464178e-01f, 7.19216987e-02f, 8.95973593e-02f, -1.59609437e-01f, 1.48114011e-01f, -9.63717923e-02f, -1.28690690e-01f,
  1.41181573e-01f, -2.83115637e-02f, 1.42891342e-02f, -2.27995273e-02f, 1.46733999e-01f, 8.89292136e-02f, 4.50968966e-02f, 1.71818852e-01f, -6.09972700e-02f, 6.75492585e-02f,
  -4.70994748e-02f, -4.18696068e-02f, -2.19327677e-02f, 1.09111190e-01f, 9.21535790e-02f, 2.12437063e-01f, -1.26829535e-01f, 1.06865659e-01f, 1.20635144e-01f, -2.67866254e-02f,
  -8.74534696e-02f, 2.15978757e-01f, 8.66673291e-02f, -3.33887078e-02f, 3.32157947e-02f, 1.26783460e-01f, -1.32724375e-01f, 2.38457900e-02f, -4.57649790e-02f, 4.83664609e-02f,
  3.54389325e-02f, -4.22136150e-02f, 1.74964830e-01f, -5.18440716e-02f, 6.60047159e-02f, 1.28056472e-02f, -7.75802433e-02f, 2.27131043e-02f, 3.44452560e-02f, -4.64382619e-02f,
  -5.32422550e-02f, -3.08569856e-02f, -1.39742428e-02f, -2.20987350e-02f, 1.55230343e-01f, 9.25388113e-02f, 3.72239873e-02f, -5.45589104e-02f, 2.45880514e-01f, -9.93062928e-02f,
  1.26649946e-01f, 2.73859017e-02f, 6.32438343e-03f, -5.13796769e-02f, 4.43440164e-03f, 4.59759682e-02f, -2.97811814e-02f, 9.94514972e-02f, 2.50311255e-01f, -8.09005722e-02f,
  1.68654263e-01f, -1.61749676e-01f, 1.18314236e-01f, 3.14006619e-02f, -9.03620347e-02f, 4.30405214e-02f, -1.03135124e-01f, -3.60367075e-02f, 1.58502921e-01f, -5.73020354e-02f,
  1.74263626e-01f, 1.51063129e-01f, 1.69105381e-02f, 9.94127826e-04f, 7.26915002e-02f, -1.15696192e-01f, 9.23249200e-02f, 2.33536828e-02f, -8.30652863e-02f, 1.83789223e-01f,
  -2.40515005e-02f, -8.73956159e-02f, 5.39671257e-02f, 1.13670506e-01f, -4.12530042e-02f, -1.12477634e-02f, -4.76128012e-02f, 6.88778758e-02f, 9.53417271e-02f, -6.47486225e-02f,
  -1.82805024e-02f, -5.57489879e-02f, 1.55309075e-02f, -4.68071289e-02f, -1.45502090e-01f, 6.95558786e-02f, 1.94868535e-01f, 2.95030459e-05f, 4.87018526e-02f, -5.39899170e-02f,
  -6.37203157e-02f, 1.14299335e-01f, 9.84897371e-03f, -8.73844977e-03f, 4.93835919e-02f, -1.17504589e-01f, 9.29240789e-03f, 9.17403474e-02f, -4.42092642e-02f, -1.37179613e-01f,
  -1.87766887e-02f, 2.86661331e-02f, -6.10865466e-02f, -5.79479039e-02f, 1.10927604e-01f, -2.54422855e-02f, 1.09010354e-01f, 5.90959638e-02f, 8.63128006e-02f, 1.07220709e-01f,
  -1.26710743e-01f, 1.03592917e-01f, 2.65736319e-02f, -3.39717828e-02f, 4.28470597e-02f, -2.79038493e-03f, -2.20236685e-02f, -6.84074387e-02f, -8.44501480e-02f, 4.30025347e-02f,
  -3.77107039e-02f, -1.37255089e-02f, 3.24426442e-02f, 1.36331357e-02f, -7.21159354e-02f, 8.56221318e-02f, -7.54532218e-02f, -1.30514828e-02f, -8.32915381e-02f, -1.75109524e-02f,
  1.20618135e-01f, 3.27779427e-02f, 1.35171944e-02f, 3.19944099e-02f, 3.05585749e-02f, -7.20324665e-02f, -6.76426291e-02f, -3.45903775e-03f, 5.76509908e-03f, 1.24965817e-01f,
  -8.70570391e-02f, 9.74954292e-03f, 8.07370916e-02f, 5.43525927e-02f, -6.39600828e-02f, 8.71945769e-02f, 9.58846286e-02f, -4.64689499e-03f, 6.00644574e-02f, 9.91470180e-03f,
  -5.86786121e-03f, 9.06858966e-02f, -5.31531796e-02f, -9.29567888e-02f, 1.26208842e-01f, -5.40711284e-02f, 1.18937232e-02f, 1.68892834e-02f, -1.52745754e-01f, -9.60124210e-02f,
  -7.15344101e-02f, 1.21995248e-01f, -7.39148865e-03f, -6.63397983e-02f, -3.63510251e-02f, -4.86246459e-02f, -3.02676633e-02f, 3.37969363e-02f, 1.09026700e-01f, -3.17870313e-03f,
  -2.10599159e-03f, 7.48837441e-02f, -4.06602770e-02f, 6.71574920e-02f, 3.06160860e-02f, 7.27836266e-02f, 1.50212824e-01f, 8.20247605e-02f, -1.04441017e-01f, -1.17321694e-02f,
  -1.12376980e-01f, -4.86449860e-02f, -2.70864386e-02f, -7.09390342e-02f, 1.23184711e-01f, -4.02782932e-02f, -1.09775914e-02f, 4.26795036e-02f, -3.24209989e-03f, 1.26849890e-01f,
  1.38310343e-02f, -2.57425178e-02f, -5.52865602e-02f, 4.14435230e-02f, 7.71996900e-02f, 4.15488072e-02f, 2.74431128e-02f, 2.10045073e-02f, -2.34502424e-02f, -9.07932743e-02f,
  7.40747675e-02f, 1.67697921e-01f, 5.16124330e-02f, 5.52165471e-02f, -9.39009264e-02f, 3.47099751e-02f, 2.96982378e-02f, -1.16955951e-01f, 1.33825624e-02f, -8.92329216e-02f,
  5.67634925e-02f, -3.24478373e-02f, -5.47785908e-02f, -8.48237500e-02f, 1.16024457e-01f, -2.19103135e-02f, 6.43285140e-02f, -1.33293048e-01f, 5.10693155e-03f, 3.53064016e-02f,
  -5.75514138e-02f, 1.16264418e-01f, 5.37713198e-03f, 1.16228491e-01f, -1.03237703e-01f, 1.59127545e-02f, -9.44611430e-02f, 1.40016794e-01f, 1.28162548e-01f, -7.55470917e-02f,
  -9.06535834e-02f, -3.44170667e-02f, -1.26050308e-01f, 8.96501094e-02f, 1.11207709e-01f, 8.46377239e-02f, -4.96657416e-02f, -7.18884617e-02f, -6.04369864e-02f, 1.24891832e-01f,
  -4.82808575e-02f, 4.76399660e-02f, -4.84920479e-02f, -1.83981769e-02f, -5.19222654e-02f, 4.51451726e-02f, 2.31215917e-02f, 2.14988329e-02f, -1.25798825e-02f, 9.62334275e-02f,
  -7.48484880e-02f, 1.08686484e-01f, -3.26341353e-02f, 4.19548564e-02f, -6.19351901e-02f, -1.96120515e-02f, 1.29204407e-01f, 4.72868495e-02f, -3.29487547e-02f, 5.58010079e-02f,
  8.63840729e-02f, 7.61891603e-02f, 8.40010196e-02f, -8.95993486e-02f, 2.68688202e-02f, 2.22284332e-01f, -8.23888481e-02f, 4.35328893e-02f, 8.67945030e-02f, -2.30894424e-02f,
  2.97164940e-03f, -4.94331270e-02f, 6.91554546e-02f, 7.76371360e-02f, -3.16559374e-02f, 8.85331035e-02f, -1.77046489e-02f, -6.43654019e-02f, 2.40664184e-01f, 6.83801100e-02f,
  7.83853382e-02f, -1.04869314e-01f, 6.96559846e-02f, -9.74465311e-02f, 1.26414239e-01f, 8.22554156e-02f, 7.26235509e-02f, -1.10392690e-01f, 2.09286921e-02f, 7.14786118e-03f,
  -1.59979194e-01f, -8.52774642e-03f, 2.90969741e-02f, -2.42519025e-02f, 1.14526622e-01f, -1.08109154e-01f, -7.95513093e-02f, -9.92871597e-02f, -1.15055718e-01f, -8.38318244e-02f,
  6.61392957e-02f, -1.00568803e-02f, 8.71629193e-02f, 9.51821208e-02f, 1.41227236e-02f, -6.74579144e-02f, -4.75646593e-02f, 5.69001101e-02f, -1.73313133e-02f, 2.40845028e-02f,
  -1.30771231e-02f, 5.64391054e-02f, -9.83049124e-02f, -7.76189193e-02f, 1.04545811e-02f, -1.20895579e-01f, -5.82502186e-02f, 6.06310070e-02f, -5.94347008e-02f, 1.10470466e-01f,
  -1.22161387e-02f, -6.19586837e-03f, -5.71853220e-02f, -2.72184815e-02f, -6.39490485e-02f, -8.38749632e-02f, 1.13856882e-01f, 5.04401140e-02f, 8.60923156e-02f, 1.05203666e-01f,
  -1.17187619e-01f, -9.52502564e-02f, 1.47376508e-02f, -9.99057814e-02f, -9.08095986e-02f, 1.03891261e-01f, 4.04059999e-02f, -8.73680711e-02f, -1.28316984e-01f, -8.05391297e-02f,
  1.14751086e-01f, -1.16349593e-01f, -8.47384892e-03f, -5.36585366e-03f, 2.69085029e-03f, -6.88042268e-02f, 2.72698820e-01f, 4.14948076e-01f, 2.09580570e-01f, 3.18098426e-01f,
  3.17988962e-01f, 2.08472520e-01f, -1.62864581e-01f, 1.95760325e-01f, 1.31766498e-01f, -5.94856031e-02f, 1.95642173e-01f, 5.96425608e-02f, 6.24241009e-02f, 6.14190996e-02f,
  1.31989956e-01f, -9.74376649e-02f, 4.64379877e-01f, 1.45202711e-01f, 8.32628012e-02f, -9.84779671e-02f, 4.09853011e-02f, 2.80398764e-02f, -3.06084603e-01f, -4.33914810e-02f,
  1.07425548e-01f, 7.06340885e-03f, 8.04677904e-02f, -8.33808724e-03f, 4.25859503e-02f, -1.83457911e-01f, 1.37354344e-01f, -1.55241892e-01f, 7.69223496e-02f, 1.20326042e-01f,
  1.09312885e-01f, 5.11908114e-01f, -1.96897522e-01f, -1.42247111e-01f, -3.38083953e-02f, 9.37699527e-02f, 1.07895829e-01f, 1.93245914e-02f, -4.16291803e-02f, 1.03188358e-01f,
  7.52294064e-02f, 3.78409796e-03f, 8.65104422e-02f, -6.22529946e-02f, -1.16263136e-01f, 4.86534759e-02f, 7.82682821e-02f, -1.14890091e-01f, 2.94252485e-02f, -2.05830351e-01f,
  -1.28028378e-01f, -7.15807900e-02f, 3.35324079e-01f, -1.49473390e-02f, -8.85767937e-02f, 3.45813669e-02f, 5.42056501e-01f, -1.02065876e-01f, -2.35334858e-02f, -1.82427257e-01f,
  6.47650734e-02f, 6.75694942e-02f, 3.98460627e-02f, 6.72307462e-02f, 1.03495367e-01f, 5.19607551e-02f, -1.89675584e-01f, -7.15695471e-02f, -1.83815449e-01f, 1.52430505e-01f,
  7.97811523e-02f, 6.28610887e-03f, 3.15153934e-02f, 1.26328021e-01f, 4.06064913e-02f, 5.24821766e-02f, 2.52274185e-01f, 6.46958277e-02f, 5.90120628e-02f, -1.61171049e-01f,
  -5.56377918e-02f, 8.43016878e-02f, -2.14694768e-01f, -6.19136579e-02f, -1.35313228e-01f, 2.33073428e-01f, -1.00503176e-01f, 1.87623559e-03f, -5.27252480e-02f, -1.18273966e-01f,
  -6.06291853e-02f, 1.88513786e-01f, -1.61937013e-01f, 9.18230936e-02f, -2.53716819e-02f, -1.05219454e-01f, -1.32907256e-01f, 4.59677055e-02f, 3.86644267e-02f, 6.46833405e-02f,
  -2.70141903e-02f, -9.29820761e-02f, 2.38998104e-02f, 1.66071728e-01f, -1.19134918e-01f, 4.40266868e-03f, -1.09437473e-01f, 1.67876452e-01f, 6.02719076e-02f, 6.94844425e-02f,
  4.99789715e-02f, -8.56732354e-02f, -3.19265313e-02f, 4.83353548e-02f, -5.51449461e-03f, 7.48845339e-02f, 1.45736665e-01f, 1.26747072e-01f, 3.79157215e-02f, -1.41903013e-01f,
  2.70816922e-01f, 1.00266725e-01f, 5.07905744e-02f, -1.10373169e-01f, 1.27759263e-01f, 3.60246859e-02f, 6.27136156e-02f, -4.16151173e-02f, 6.68410808e-02f, -1.10917859e-01f,
  1.60872806e-02f, 1.17427800e-02f, 1.55435801e-01f, -5.57061918e-02f, 8.00923631e-02f, -5.83458343e-04f, -5.31346425e-02f, 7.64100626e-02f, 9.66693461e-02f, 2.56457161e-02f,
  -9.82321426e-02f, -3.70743163e-02f, 2.80045848e-02f, 1.05034418e-01f, 1.37000173e-01f, -8.48244205e-02f, -5.68850674e-02f, -2.91705653e-02f, 1.14789203e-01f, 5.55341877e-03f,
  4.08135913e-02f, 5.28922193e-02f, 1.29072517e-01f, 7.57823884e-02f, -2.52344832e-02f, 3.45673971e-02f, -2.14390308e-02f, 9.68915503e-03f, -3.69108422e-03f, -6.50091246e-02f,
  1.59723133e-01f, 3.03791035e-02f, -1.14444628e-01f, -4.08696942e-02f, -9.21743736e-02f, 4.86877076e-02f, 6.30334094e-02f, 1.98873468e-02f, -1.25196829e-01f, -3.36846113e-02f,
  1.17269568e-01f, -1.04602054e-01f, 4.96623740e-02f, 1.50075421e-01f, -2.96400096e-02f, -1.16454938e-03f, -4.89039719e-03f, 1.28135338e-01f, -7.43436217e-02f, 9.52428281e-02f,
  8.80399346e-02f, 6.92489818e-02f, -5.91612533e-02f, -3.59355053e-03f, -7.36661032e-02f, 1.09690599e-01f, -2.87180464e-03f, -7.73302242e-02f, 5.90077490e-02f, -8.28994140e-02f,
  1.62797600e-01f, -3.68034728e-02f, -4.91666198e-02f, 2.39444170e-02f, 6.30437210e-02f, -7.70800486e-02f, -8.84445161e-02f, 3.73490527e-02f, 8.99661407e-02f, -3.70530114e-02f,
  -4.77158427e-02f, -2.02153139e-02f, 1.26669453e-02f, 7.93801155e-03f, 2.18010992e-02f, 6.37018681e-02f, -7.42561445e-02f, 1.97088029e-02f, 9.98071656e-02f, -1.33693919e-01f,
  6.46082014e-02f, 4.90321815e-02f, 1.44750208e-01f, -9.15213302e-03f, -1.03343494e-01f, 2.34059021e-02f, 8.65474567e-02f, 1.30437598e-01f, 6.04546033e-02f, -6.50039166e-02f,
  -6.98200837e-02f, -3.81676853e-02f, -4.63719256e-02f, 5.63019216e-02f, 3.75183523e-02f, -4.06527659e-03f, 1.24773920e-01f, -6.88502612e-03f, -1.01235546e-01f, -5.16946949e-02f,
  7.47949705e-02f, 1.64038483e-02f, -2.44233105e-02f, 3.59658338e-02f, 6.39719516e-02f, -3.72594558e-02f, 9.77609903e-02f, -1.25742704e-01f, -3.72685492e-02f, -2.45138407e-02f,
  -1.13625430e-01f, -9.62663889e-02f, 5.42487539e-02f, 4.48674448e-02f, -7.66816139e-02f, 3.38347955e-03f, 7.74797276e-02f, -8.29298981e-03f, 6.01880327e-02f, 6.74787583e-03f,
  -6.57548830e-02f, 9.98060480e-02f, 2.48459250e-01f, 8.58810917e-02f, 7.57957622e-02f, 1.32652789e-01f, 9.86057147e-02f, 7.09957555e-02f, -9.96287987e-02f, -5.36862575e-02f,
  -1.60904482e-01f, 1.23616703e-01f, 1.06247082e-01f, 1.12001345e-01f, -6.90288618e-02f, 1.11541882e-01f, 3.28385197e-02f, -5.48619181e-02f, 2.04399988e-01f, -8.24746192e-02f,
  -3.61600183e-02f, 5.67526035e-02f, -9.32980031e-02f, 5.81482463e-02f, -9.67560485e-02f, -8.95528197e-02f, 1.41749591e-01f, 1.87375657e-02f, -1.87456738e-02f, 1.78770751e-01f,
  9.46624056e-02f, 6.03330098e-02f, -1.15204833e-01f, 7.41053075e-02f, -9.97495726e-02f, 7.79851824e-02f, 1.16584981e-02f, -2.91584544e-02f, -9.01190415e-02f, -1.40068196e-02f,
  8.04900005e-02f, -3.03324014e-02f, -9.16604251e-02f, -9.79832709e-02f, -6.46144450e-02f, -1.37405813e-01f, -1.39518484e-01f, -1.31920844e-01f, -1.22778766e-01f, 1.22131236e-01f,
  -1.35582834e-01f, -5.54602705e-02f, 1.95223875e-02f, -4.87971865e-02f, 3.95681858e-02f, 5.24104200e-02f, -1.19286701e-01f, -1.00509949e-01f, 2.26466045e-01f, -1.76577970e-01f,
  7.50893578e-02f, -1.23857126e-01f, 2.75766075e-01f, 5.50257191e-02f, -1.26180604e-01f, 5.74243255e-02f, -8.58960822e-02f, 2.64748149e-02f, -7.10042194e-02f, 7.06541091e-02f,
  7.00119883e-02f, 1.46649390e-01f, -7.04128295e-02f, 4.85267751e-02f, 3.52893956e-02f, -1.11643389e-01f, -1.11792006e-01f, 1.98429637e-02f, -9.78466049e-02f, 4.30580974e-02f,
  1.84953846e-02f, 1.16401181e-01f, 6.54113740e-02f, -1.00581385e-02f, 1.08082645e-01f, -1.00105658e-01f, -5.55376075e-02f, 6.89254608e-03f, 4.27813604e-02f, 1.83748025e-02f,
  -7.00437203e-02f, 9.44507718e-02f, 4.30654921e-02f, 1.42482491e-02f, 1.02951983e-02f, -5.06470352e-02f, 7.29458928e-02f, -7.53668621e-02f, 1.30093798e-01f, -2.80110426e-02f,
  -9.32294950e-02f, -5.24932984e-03f, -1.05497420e-01f, -6.46724403e-02f, -1.12462208e-01f, -7.03717768e-02f, 1.08751513e-01f, -1.20069899e-01f, 7.65888020e-02f, -9.25314724e-02f,
  6.73605949e-02f, -1.12709440e-01f, 1.13823235e-01f, -9.81673300e-02f, -1.00571923e-01f, -1.24303019e-02f, -1.09249979e-01f, 8.31994414e-02f, -2.10418366e-03f, 1.93768069e-02f,
  -1.86316911e-02f, 1.16853878e-01f, -8.12693685e-03f, -4.79599051e-02f, -3.65830474e-02f, -2.46443748e-02f, -8.64350870e-02f, 8.38976055e-02f, -1.21093784e-02f, 1.35415439e-02f,
  9.98704582e-02f, 1.38794724e-02f, -3.94731462e-02f, -2.63244603e-02f, -1.51201531e-01f, -6.66704923e-02f, -1.13541745e-01f, -8.16261694e-02f, -2.17018407e-02f, 6.06334908e-03f,
  6.88558519e-02f, 1.36120245e-01f, -5.76275401e-04f, -1.12057276e-01f, 9.81799588e-02f, -3.87609862e-02f, -4.26437743e-02f, -1.68346576e-02f, 1.06165402e-01f, -1.03403986e-01f,
  1.13281026e-01f, -7.88876563e-02f, -6.32518902e-02f, -1.10596798e-01f, 4.22267728e-02f, -1.24957003e-01f, 4.10587601e-02f, -9.78966728e-02f, -1.33682638e-02f, 3.05741224e-02f,
  -4.76645157e-02f, -8.01010579e-02f, -9.44425762e-02f, 9.90644172e-02f, 4.82022911e-02f, 3.68757695e-02f, -1.36955855e-02f, 4.98440191e-02f, 2.54204646e-02f, -2.98567209e-02f,
  8.03534538e-02f, -7.37459511e-02f, -9.80703756e-02f, 3.24056633e-02f, 6.26331661e-03f, 1.12499632e-01f, 1.62314977e-02f, -7.66403750e-02f, 6.31964505e-02f, 4.13270928e-02f,
  9.22245532e-02f, -4.26327856e-03f, 5.51137030e-02f, -1.05140269e-01f, -1.59850568e-02f, -1.00156143e-01f, 4.84059192e-02f, -7.69826695e-02f, -9.53658670e-02f, 1.02694646e-01f,
  8.18277448e-02f, 9.08142999e-02f, -1.12103418e-01f, 8.33791271e-02f, 4.47814688e-02f, -1.65576831e-01f, -3.47126313e-02f, -8.71149525e-02f, -4.01860327e-02f, -2.12914310e-02f,
  1.09745815e-01f, -5.55034950e-02f, -1.90231591e-01f, 6.25917688e-02f, -5.62967993e-02f, -4.01954092e-02f, 8.04776028e-02f, 9.84326843e-03f, -1.05595462e-01f, 7.29519352e-02f,
  5.63952476e-02f, 1.62063017e-01f, -2.12298632e-02f, -1.56485602e-01f, 6.05021529e-02f, -1.54319126e-02f, 2.72237599e-01f, -2.61682384e-02f, -1.01598121e-01f, 6.13560304e-02f,
  -1.27345890e-01f, 4.38715890e-02f, -8.90578777e-02f, 1.91627488e-01f, 5.40577658e-02f, 1.14330620e-01f, -3.42199281e-02f, 6.32963032e-02f, -2.62888763e-02f, 4.88423090e-03f,
  -1.45873562e-01f, 5.97182624e-02f, 1.20618388e-01f, 9.02606640e-03f, -1.00784555e-01f, 6.41765147e-02f, 7.34945238e-02f, 8.63679275e-02f, 1.28898606e-01f, 6.45644031e-04f,
  1.29145145e-01f, 4.18758601e-01f, -2.22549271e-02f, 1.59262002e-01f, -6.46656230e-02f, 1.48853455e-02f, 3.49969231e-02f, 1.09706111e-01f, 1.02977715e-01f, 1.29532078e-02f,
  -1.67955250e-01f, 1.69542551e-01f, 4.04828265e-02f, -2.74097547e-03f, -9.96330604e-02f, 1.16865702e-01f, -9.45022563e-04f, 2.88366172e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  2.82923698e-01f, 2.33365986e-02f, 1.92656007e-03f, -7.21684769e-02f, 7.80512616e-02f, 9.51825306e-02f, -1.16661072e-01f, 1.91399500e-01f, -5.47868311e-02f, -8.50269049e-02f,
  1.45109445e-01f, -5.09746671e-02f, 1.10999458e-01f, 1.78884402e-01f, -4.09509204e-02f, -1.88032128e-02f, 3.28101330e-02f, 6.70411438e-02f, 4.13289033e-02f, -9.55316350e-02f,
  -1.92315895e-02f, -7.13209296e-03f, -3.91193219e-02f, -3.08949919e-03f, 4.00539637e-02f, 2.43334830e-01f, 2.63215415e-02f, 4.72066104e-02f, -6.25721738e-02f, 8.35182294e-02f,
  -1.25553772e-01f, -5.16047003e-03f, -3.61914821e-02f, 1.35606781e-01f, 1.67321526e-02f, -1.15183994e-01f, 1.54903129e-01f, 2.98259612e-02f, 9.75631252e-02f, -4.30921391e-02f,
  5.13323694e-02f, -7.32692406e-02f, 1.78653851e-01f, 3.50930472e-03f, 2.56000876e-01f, 1.72721073e-01f, -8.14475641e-02f, 6.45518601e-02f, 1.17463879e-01f, 4.70667705e-02f,
  6.99831620e-02f, -4.16917242e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -3.26521933e-01f, -4.31020230e-01f, -3.04936528e-01f, -2.35517129e-01f, -5.40034473e-01f, -6.67035058e-02f, -3.51624079e-02f, 2.08287463e-01f, 8.53843018e-02f, 3.59991379e-02f,
  1.79160997e-01f, 7.39083812e-02f, -2.48782799e-01f, -1.58299580e-01f, -4.83227074e-02f, 1.30339533e-01f, 1.24944039e-01f, 2.13645548e-02f, 2.37444788e-03f, -1.41419724e-01f,
  3.63328665e-01f, -8.45188126e-02f, -1.28336713e-01f, -1.08724006e-01f, -3.18282425e-01f, -1.98298842e-02f, 2.63231173e-02f, -7.05326945e-02f, 5.83950523e-03f, 2.34389007e-01f,
  4.28484790e-02f, 1.51351959e-01f, 2.12273538e-01f, 9.87552777e-02f, 4.78483215e-02f, -1.30227283e-01f, 1.88002929e-01f, -1.24769226e-01f, -8.47886801e-02f, 9.64652747e-02f,
  1.33536503e-01f, 2.70630538e-01f, -1.69888102e-02f, -7.30449380e-03f, 3.29000384e-01f, -1.93363085e-01f, -1.55588403e-01f, -3.81314941e-02f, 6.93421438e-02f, 5.59469163e-02f,
  -1.56033663e-02f, -1.75221309e-01f, 6.25353530e-02f, 1.29665419e-01f, 9.10959989e-02f, 1.55778471e-02f, -4.16040093e-01f, -3.03106327e-02f, 8.07269141e-02f, -5.86022530e-03f,
  -1.30703539e-01f, -5.22713661e-02f, 4.46414249e-03f, 3.02763045e-01f, -1.77295402e-01f, -1.89625934e-01f, 9.71395075e-02f, 1.09761216e-01f, -3.32616836e-01f, -1.62126809e-01f,
  -1.17903404e-01f, -2.75773793e-01f, -6.35965317e-02f, -2.36564055e-01f, -2.77275771e-01f, 5.01527369e-01f, -3.29531640e-01f, -2.03529503e-02f, 1.25986934e-01f, 3.46577913e-01f,
  4.86934409e-02f, -6.43027127e-02f, 6.73829317e-02f, -2.44560108e-01f, 3.81350368e-01f, 1.02597989e-01f, -1.95729852e-01f, 3.44662480e-02f, -2.03842893e-01f, -7.77268335e-02f,
  8.80691856e-02f, -1.61916226e-01f, -1.23731308e-01f, 3.52586508e-01f, -1.84124559e-01f, 2.79896230e-01f, -2.00508729e-01f, -4.23811525e-01f, 3.69485207e-02f, -1.60071433e-01f,
  2.15410918e-01f, -1.38763532e-01f, 3.52093093e-02f, -2.37943809e-02f, 3.91647518e-01f, -3.83189544e-02f, -1.93860587e-02f, 4.18816395e-02f, 1.31385937e-01f, -2.22638354e-01f,
  4.70503457e-02f, 3.52625176e-02f, -2.60845900e-01f, 2.94486642e-01f, 3.62122834e-01f, 6.41704947e-02f, 1.10151961e-01f, 1.66007996e-01f, 1.62615806e-01f, 8.66214111e-02f,
  1.24450224e-02f, 9.87477899e-02f, -3.12806852e-02f, -1.00318909e-01f, -1.54717460e-01f, -8.02247599e-02f, 1.92050878e-02f, 1.21553116e-01f, 2.30901480e-01f, 4.44784105e-01f,
  1.61362559e-01f, 3.47167611e-01f, 3.42038929e-01f, 2.39134192e-01f, 9.86701548e-02f, 2.21585944e-01f, -7.94142559e-02f, 3.21564734e-01f, 3.89014721e-01f, -3.52134109e-01f,
  1.61088556e-01f, -7.92849809e-02f, 2.76385155e-02f, -1.28050655e-01f, 1.64733574e-01f, -2.82743294e-02f, -3.35334726e-02f, 3.02398682e-01f, -8.55664685e-02f, -1.19796015e-01f,
  3.16777557e-01f, 2.21024677e-02f, -1.27292275e-01f, 1.44783795e-01f, -6.04735203e-02f, 1.20632984e-02f, 1.81413203e-01f, 2.74735745e-02f, 3.67391884e-01f, -9.49682146e-02f,
  3.89326587e-02f, 1.41844749e-01f, 4.51054722e-02f, 4.18028794e-03f, -1.52076706e-01f, 1.01738371e-01f, -2.87214722e-02f, -1.94780961e-01f, -1.15660749e-01f, 7.48977363e-02f,
  -1.04661465e-01f, 3.75455022e-02f, 3.90704691e-01f, -2.04076305e-01f, -1.83405966e-01f, 3.15303765e-02f, 9.81922373e-02f, 7.68282935e-02f, -4.90010083e-02f, 8.12095404e-02f,
  2.79298909e-02f, 8.44327435e-02f, 8.36959258e-02f, 4.90527190e-02f, 3.79776388e-01f, -1.51273414e-01f, -6.85116947e-02f, 1.51185632e-01f, 1.88224137e-01f, -8.58002305e-02f,
  -8.80825594e-02f, -1.12957850e-01f, 5.78541718e-02f, -1.56291593e-02f, -4.67193499e-02f, 7.23615438e-02f, 8.00917223e-02f, 4.66392152e-02f, -1.61040351e-01f, -1.61146998e-01f,
  -1.67478807e-02f, -4.30865496e-01f, -3.36185247e-01f, -1.89072326e-01f, 5.16939051e-02f, -8.75330418e-02f, 9.88985747e-02f, 2.50234511e-02f, 1.39662296e-01f, 1.33764237e-01f,
  1.24735765e-01f, -2.24220678e-01f, -1.00768194e-01f, 6.38556406e-02f, 3.35138142e-02f, 8.82212631e-03f, 3.64122301e-01f, -1.58618823e-01f, 8.43680725e-02f, -3.44893746e-02f,
  -2.17683986e-01f, 1.83000177e-01f, 3.66856903e-02f, 6.56369776e-02f, -1.73948240e-02f, -1.42844409e-01f, 3.40411849e-02f, 3.51089693e-04f, -8.22235271e-02f, -1.23848148e-01f,
  -1.83524728e-01f, 1.07673919e-02f, 1.45881057e-01f, 1.74512506e-01f, 2.09584698e-01f, -2.20819190e-02f, 2.06956059e-01f, -1.55387418e-02f, -9.32284631e-03f, 1.16647609e-01f,
  3.76013935e-01f, -1.30175874e-01f, 8.68557021e-02f, 3.01425755e-01f, -1.12919427e-01f, 2.52863225e-02f, -2.73247976e-02f, 1.05905615e-01f, -3.88218254e-01f, -1.58843338e-01f,
  -1.47045106e-01f, 7.29143918e-02f, -1.43510520e-01f, 2.70892140e-02f, -1.96967386e-02f, 1.45651311e-01f, 5.43338396e-02f, -1.18500188e-01f, -1.91465780e-01f, -4.21981841e-01f,
  1.68427244e-01f, -5.89596331e-01f, 2.63864368e-01f, -3.32588941e-01f, -5.55621088e-03f, -3.28889787e-01f, -3.30084205e-01f, 1.75312608e-01f, -3.42944950e-01f, -1.96757615e-01f,
  3.29326987e-02f, -4.62442525e-02f, 8.58021602e-02f, 1.12884440e-01f, -7.71631077e-02f, 1.80035025e-01f, 8.02804623e-03f, -3.32928151e-02f, 1.27752587e-01f, -1.40951604e-01f,
  4.15141834e-03f, -1.36101976e-01f, -8.74966457e-02f, -7.77481915e-03f, -2.95601860e-02f, 6.19628802e-02f, 2.33079180e-01f, -3.44737321e-01f, 3.32113147e-01f, 4.63532686e-01f,
  4.90858629e-02f, 7.97795802e-02f, -3.91481631e-02f, -2.62725860e-01f, 2.26030778e-02f, 1.63395405e-01f, -2.30702870e-02f, 1.45331755e-01f, -5.53834625e-02f, 6.30654693e-02f,
  2.57462502e-01f, -1.06522143e-01f, -3.00504919e-02f, -8.83159339e-02f, 4.72265929e-01f, -2.74432600e-01f, -2.37545803e-01f, -2.02376366e-01f, -1.14271618e-01f, -8.82596225e-02f,
  -2.08295900e-02f, 1.06757782e-01f, -4.89851177e-01f, 3.08305807e-02f, -6.58793449e-02f, 1.45883843e-01f, -1.52384653e-03f, -9.78926420e-02f, 1.87664162e-02f, 2.29969189e-01f,
  1.93571687e-01f, 1.31310508e-01f, 1.40178159e-01f, -1.35728251e-02f, 3.06514055e-01f, 3.77725184e-01f, -4.97716904e-01f, -2.78201044e-01f, -1.12727694e-01f, -6.58774078e-02f,
  -5.11391163e-01f, 5.46808802e-02f, -1.66714191e-01f, -1.91263989e-01f, -6.42112121e-02f, 1.71353780e-02f, 6.54622316e-02f, 4.18738462e-02f, 2.28241459e-02f, 2.44176790e-01f,
  8.78474768e-03f, -1.29134879e-01f, 2.55703866e-01f, -1.14398740e-01f, -4.11599427e-01f, -1.63093492e-01f, 1.86107025e-01f, -6.96706474e-02f, -1.20478004e-01f, 7.20250129e-04f,
  7.73428977e-02f, 1.38300478e-01f, 1.34364218e-01f, -1.99088320e-01f, -1.10892363e-01f, -1.77715406e-01f, 2.32765764e-01f, -2.10345283e-01f, -4.56931628e-02f, -1.28442407e-01f,
  -2.52245069e-02f, 2.83310473e-01f, -1.49474904e-01f, 1.07952133e-01f, 1.20618701e-01f, 7.76844844e-02f, 4.98498790e-02f, 1.93754733e-02f, 2.40391418e-01f, 1.51353762e-01f,
  1.14201382e-01f, 6.24446273e-02f, 2.59161349e-02f, 1.39282644e-01f, 1.78249151e-01f, -1.75883174e-02f, 1.70358017e-01f, 1.35278672e-01f, -7.61770532e-02f, 3.28951366e-02f,
  2.65317708e-01f, -1.22049801e-01f, 9.02890861e-02f, 1.86746150e-01f, 5.61651923e-02f, 7.16510192e-02f, 2.01241806e-01f, -1.89466085e-02f, -1.58310115e-01f, 4.79987293e-01f,
  3.80194426e-01f, 4.44597334e-01f, -6.26048297e-02f, 4.18510467e-01f, 5.45063913e-01f, -9.79093909e-02f, 4.64336336e-01f, 1.43565565e-01f, 2.80723684e-02f, -1.71618402e-01f,
  -1.83910787e-01f, 3.27426605e-02f, -1.79485962e-01f, 9.96692702e-02f, -9.21661928e-02f, 6.12063669e-02f, 2.88739502e-02f, -3.15544531e-02f, 2.57173926e-01f, 3.90550315e-01f,
  -8.03922415e-02f, 2.34126467e-02f, 4.24612761e-01f, -2.19170675e-01f, -1.87249526e-01f, -2.48861372e-01f, -2.93178171e-01f, 1.37237012e-01f, 3.81891392e-02f, 7.19642788e-02f,
  -3.90054584e-02f, 5.68409383e-01f, -1.24090977e-01f, -1.09471969e-01f, -3.64232659e-01f, -3.15853357e-01f, -2.27008656e-01f, 5.76570928e-02f, -4.46061969e-01f, -2.32855491e-02f,
  2.59099733e-02f, -1.51721090e-01f, -3.36863667e-01f, -8.64746571e-02f, -2.08621949e-01f, -6.37224391e-02f, -7.01874122e-02f, 1.44403633e-02f, -1.31523892e-01f, -1.41663358e-01f,
  2.77816772e-01f, -1.84626594e-01f, -2.99415719e-02f, -3.25487112e-03f, 1.39043882e-01f, 4.96776998e-02f, -6.70613199e-02f, -3.76768380e-01f, -1.58985540e-01f, -4.04282272e-01f,
  -2.95461744e-01f, -1.93087131e-01f, -2.54592389e-01f, 2.03545205e-02f, 1.04721323e-01f, 7.11278096e-02f, 2.69584432e-02f, 6.63470477e-02f, 2.83958763e-01f, 4.22517955e-01f,
  1.67811602e-01f, 2.01340824e-01f, 2.90840361e-02f, 1.19979925e-01f, 1.02680400e-02f, 5.06351553e-02f, 1.78893641e-01f, -6.55529201e-02f, 3.80417146e-02f, 1.10189363e-01f,
  -2.00734317e-01f, 2.89368071e-02f, 4.84436244e-01f, -1.61794443e-02f, -6.51009381e-02f, -1.01232976e-01f, -2.23465338e-01f, 1.77211300e-01f, -2.32099205e-01f, 2.26688311e-02f,
  1.09567624e-02f, -4.97331806e-02f, -4.58590835e-02f, 1.88366190e-01f, -1.06003784e-01f, 2.10972838e-02f, 2.65906513e-01f, 2.74473935e-01f, 2.36190200e-01f, -2.88676888e-01f,
  2.38843292e-01f, -9.10843611e-02f, -3.00818980e-01f, -1.03965402e-01f, 2.86686808e-01f, 5.44850640e-02f, -3.20286065e-01f, -1.87550485e-01f, 3.69803570e-02f, -1.74249113e-02f,
  -9.66714397e-02f, 2.25950610e-02f, -2.11192876e-01f, -1.10729359e-01f, -5.16246855e-01f, -1.87594429e-01f, 1.36093780e-01f, -5.56292944e-02f, -2.38201946e-01f, -2.42568105e-02f,
  -4.01449064e-03f, 5.33979796e-02f, 1.54696247e-02f, 2.71658659e-01f, -2.90704787e-01f, -4.36994880e-02f, 1.62707180e-01f, 8.51703212e-02f, -1.57251582e-01f, 1.33485630e-01f,
  -2.59381264e-01f, 1.97208554e-01f, -2.75800705e-01f, 1.88451812e-01f, 1.22104302e-01f, -8.50396678e-02f, -8.93944949e-02f, -7.24914297e-02f, -2.57474221e-02f, 5.77913076e-02f,
  -8.11938643e-02f, 8.94616842e-02f, -7.10103288e-02f, -1.93170607e-01f, -5.99934645e-02f, 3.72408479e-02f, -4.99518484e-01f, -3.19451205e-02f, 7.63387159e-02f, -2.39946339e-02f,
  4.30662155e-01f, 8.66541862e-02f, -3.74712020e-01f, 1.13011397e-01f, -7.56015331e-02f, -5.99755198e-02f, -6.98072230e-03f, 7.40165077e-03f, 4.34268750e-02f, 2.07754314e-01f,
  3.82370092e-02f, -1.19658351e-01f, -2.65692212e-02f, -3.02182078e-01f, -1.15265816e-01f, 4.03252915e-02f, -3.05815309e-01f, 2.27371454e-01f, 2.34226640e-02f, -1.11470267e-01f,
  -5.76011837e-01f, 3.67801487e-01f, -4.06752639e-02f, 8.04430619e-02f, 1.33426473e-01f, 9.67155844e-02f, 6.24272823e-02f, -4.87025920e-03f, 6.86007679e-01f, 2.16234580e-01f,
  -9.41775441e-02f, 8.38687867e-02f, 3.72454710e-02f, 9.69550312e-02f, 1.82292536e-01f, -2.55907655e-01f, -6.94421679e-02f, 2.32315168e-01f, 2.54309297e-01f, 1.93544418e-01f,
  -1.81522518e-01f, -1.79677323e-01f, 1.71011150e-01f, 2.79859394e-01f, 2.26728305e-01f, 3.05468172e-01f, 1.49333596e-01f, -4.42369223e-01f, 1.63127929e-01f, 1.86755821e-01f,
  1.37908921e-01f, -1.67501718e-01f, -1.41120762e-01f, -2.13722531e-02f, -1.81861505e-01f, 9.55590978e-02f, -2.21145786e-02f, 1.34215176e-01f, -1.33892491e-01f, -1.24814704e-01f,
  5.38942814e-01f, 3.11414208e-02f, -1.07265613e-03f, -3.23309377e-02f, -3.12282145e-01f, -5.23009300e-02f, 2.81462371e-01f, -3.46947223e-01f, 1.22753017e-01f, 5.45422256e-01f,
  8.93813446e-02f, 1.94401875e-01f, -2.45578676e-01f, 1.25342056e-01f, 5.10918535e-02f, 2.00091317e-01f, -3.84243190e-01f, -1.90735817e-01f, -1.45024791e-01f, -5.25155710e-03f,
  -1.12706283e-02f, -1.05185322e-01f, 1.25376344e-01f, 9.26563144e-02f, 1.54851496e-01f, -3.11115593e-01f, -2.51896322e-01f, 5.84068857e-02f, -1.57107916e-02f, -9.39254910e-02f,
  -1.27675280e-03f, -6.41219616e-02f, -4.16390300e-01f, -1.63790867e-01f, 3.90304774e-02f, 1.39812917e-01f, -1.59563690e-01f, -1.84066966e-02f, 2.39311438e-03f, -1.50211006e-01f,
  3.39484632e-01f, 2.12782204e-01f, 1.15812786e-01f, 1.82061806e-01f, 3.96049619e-01f, 1.45748466e-01f, 2.68893421e-01f, -3.02530259e-01f, -2.88538467e-02f, -3.72540057e-01f,
  3.91671900e-04f, -5.10165453e-01f, -1.86957449e-01f, -2.48623148e-01f, -1.49592459e-01f, -2.78153539e-01f, -1.36788681e-01f, 8.13691989e-02f, -1.19199574e-01f, 2.94359424e-03f,
  -1.64871708e-01f, -2.42018059e-01f, -5.65547533e-02f, -1.98127832e-02f, -2.61418372e-01f, -2.02904612e-01f, 1.62472039e-01f, 2.17920870e-01f, -3.13895553e-01f, -4.70203847e-01f,
  -1.52084604e-01f, -9.36747491e-02f, 3.25118005e-01f, -1.84823230e-01f, 2.90968660e-02f, 5.90246283e-02f, 9.29338485e-02f, -3.59180748e-01f, -1.25199571e-01f, 1.93339065e-01f,
  -5.22604138e-02f, 5.83179779e-02f, -1.00702234e-01f, -7.64522925e-02f, -2.67575473e-01f, 4.23768580e-01f, 8.65299180e-02f, -2.15514060e-02f, 3.14693481e-01f, 1.44734114e-01f,
  1.13068208e-01f, -2.50466406e-01f, 2.93948203e-02f, -5.85335530e-02f, 2.83808649e-01f, -8.37576166e-02f, 3.18568051e-01f, 5.11826038e-01f, -6.77219108e-02f, -1.53528405e-02f,
  3.57395560e-01f, -1.33638397e-01f, -1.28870904e-01f, -1.54521525e-01f, 1.49476364e-01f, -7.95267895e-02f, 1.35898823e-03f, -8.00519809e-02f, 3.66195500e-01f, -4.48075403e-03f,
  -1.06402785e-01f, 2.03553393e-01f, -1.09426536e-01f, -2.16510892e-02f, 1.41266054e-02f, 1.20577663e-01f, 2.65549988e-01f, 3.67478758e-01f, 2.76764985e-02f, 6.43641129e-02f,
  9.19821933e-02f, -1.21881604e-01f, 1.49354339e-01f, -4.40047570e-02f, -1.23532988e-01f, 2.79887438e-01f, 1.31781518e-01f, 7.48439878e-02f, 1.27980039e-01f, 2.04092458e-01f,
  8.26677382e-02f, 1.68745518e-02f, 3.89695138e-01f, 9.26001966e-02f, -2.40277141e-01f, 1.63062826e-01f, -7.91095495e-02f, -4.15553510e-01f, -1.49642214e-01f, -1.71001107e-01f,
  -3.97646129e-02f, 3.99230450e-01f, 2.08615661e-02f, -2.20692083e-01f, -1.09621234e-01f, -1.18899025e-01f, 1.85864761e-01f, 8.18916634e-02f, -1.76908478e-01f, -3.41562033e-02f,
  -2.97186207e-02f, -1.18901856e-01f, -4.16498899e-01f, 5.70254400e-03f, 2.41788514e-02f, 2.13213444e-01f, 1.17955640e-01f, 6.37586713e-02f, -2.51843870e-01f, -1.17685996e-01f,
  7.82204345e-02f, -3.19911242e-01f, 1.44411668e-01f, 1.69474203e-02f, -1.23098195e-01f, -1.78323295e-02f, 4.63588014e-02f, -2.62184888e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.66077584e-01f, -2.00264633e-01f, 1.16689667e-01f, -4.95363474e-02f, -1.11641452e-01f, 2.92993877e-02f, 9.84636843e-02f, -1.37621939e-01f, -1.24410465e-01f, 8.28803778e-02f,
  -1.21873908e-03f, -1.83819737e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    