/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.16471630e-01f, 3.48826759e-02f, -4.75950688e-02f, 3.23181510e-01f, 1.14775315e-01f, 5.54816686e-02f, -3.11576158e-01f, 3.46085101e-01f, 6.77559823e-02f, -1.29909965e-03f,
  1.32095248e-01f, 8.21598433e-03f, -3.50850642e-01f, 1.47909999e-01f, 6.65127039e-02f, -2.79652774e-01f, 1.90005153e-01f, 7.54137859e-02f, -4.08002883e-02f, 1.02235757e-01f,
  1.89851627e-01f, 2.06045032e-01f, 9.59693920e-03f, 1.22603640e-01f, 1.43090799e-01f, -1.45699596e-04f, 4.70352219e-03f, -1.90357476e-01f, 9.63498428e-02f, 3.16770263e-02f,
  -1.00505263e-01f, -4.86026257e-02f, 1.13954529e-01f, -5.48928566e-02f, 2.49154735e-02f, 5.33584356e-02f, -8.85514319e-02f, -1.65973991e-01f, -2.33827885e-02f, -3.79565777e-03f,
  -6.28858432e-02f, 1.57572970e-01f, 8.70766193e-02f, 1.32029671e-02f, -2.81974673e-02f, -1.08810188e-03f, -1.21779237e-02f, 9.49350670e-02f, 2.64144968e-02f, 3.99220847e-02f,
  -2.11185198e-02f, 1.79935936e-02f, 1.06832355e-01f, -2.94921696e-02f, 3.50486189e-02f, 1.28989458e-01f, -6.77084550e-02f, -5.69069944e-02f, 5.49342483e-02f, 3.98180634e-02f,
  4.55544181e-02f, -4.89956029e-02f, -1.27016995e-02f, 4.16295417e-03f, 3.47501673e-02f, 2.33805981e-02f, -4.83967364e-02f, -6.86232969e-02f, -2.46479977e-02f, 5.55031048e-03f,
  3.93315405e-02f, 3.65204960e-02f, 4.27684933e-02f, -4.65269610e-02f, 4.66489270e-02f, 6.88883364e-02f, -2.75117159e-03f, 2.26032399e-02f, -1.18896728e-02f, 6.00997061e-02f,
  -6.30519763e-02f, 8.03496391e-02f, -1.78209431e-02f, -2.46586297e-02f, -7.17826337e-02f, -9.33398679e-03f, 7.39338323e-02f, -9.69009195e-03f, -2.28309445e-02f, 5.63344685e-03f,
  -4.50246260e-02f, 4.62108403e-02f, -5.39740548e-02f, 8.08092281e-02f, -1.04042195e-01f, 9.78833809e-03f, 3.17786355e-04f, 1.72484413e-01f, -8.37007686e-02f, 4.54597315e-03f,
  1.09143093e-01f, -7.86127672e-02f, -4.39031199e-02f, 1.30256042e-02f, 2.76167057e-02f, 5.58812125e-03f, -4.59759459e-02f, -1.04761705e-01f, 3.70627902e-02f, 2.23601665e-02f,
  3.49278376e-02f, -9.37564895e-02f, -4.90709692e-02f, 1.24835379e-01f, 9.63745415e-02f, -9.20641199e-02f, 9.02799293e-02f, -4.11628373e-02f, -8.07019845e-02f, 3.56134810e-02f,
  -5.04449248e-01f, 1.91871122e-01f, -3.20243388e-01f, -8.81172195e-02f, -9.32741091e-02f, 1.24153055e-01f, -6.87465146e-02f, 8.27084631e-02f, -7.16741309e-02f, 1.03044264e-01f,
  4.70341779e-02f, 3.85169946e-02f, -1.08315744e-01f, 1.32678315e-01f, -1.54212862e-01f, 1.77702904e-01f, 6.10677227e-02f, 2.71474216e-02f, 1.84057489e-01f, 7.12449383e-03f,
  4.80339304e-02f, 2.19829634e-01f, -2.85812672e-02f, 1.16568573e-01f, -3.77879329e-02f, 1.47952950e-02f, 4.29873262e-03f, -2.26246715e-02f, 5.05124740e-02f, 1.20259086e-02f,
  1.12417407e-01f, -1.73323855e-01f, -1.37106478e-01f, -8.38202517e-03f, -1.18632354e-01f, -2.28700731e-02f, 3.01644504e-02f, -6.08431324e-02f, 7.84523878e-03f, 2.94004399e-02f,
  2.24703131e-03f, 7.07038417e-02f, -6.65426254e-03f, -6.61829561e-02f, -8.92570987e-02f, -2.52159461e-02f, 1.36816390e-02f, 2.50142813e-02f, 1.27532676e-01f, 3.07113994e-02f,
  6.69625252e-02f, 8.08411613e-02f, -1.93021316e-02f, 3.83405574e-02f, 1.56651309e-03f, -2.05817446e-02f, -4.56900895e-02f, 5.45996567e-03f, 3.92574035e-02f, -1.07619181e-01f,
  -5.11687510e-02f, 4.16019140e-03f, 2.71201134e-02f, 7.16598555e-02f, -2.51225233e-02f, -1.22602470e-02f, 8.57873335e-02f, -6.89413846e-02f, -2.51966249e-02f, 6.98966254e-03f,
  2.65621860e-02f, -7.83908239e-04f, -1.80546511e-02f, 1.61268841e-02f, 2.24185307e-02f, -6.59940764e-02f, 4.31369618e-03f, -1.79795157e-02f, 3.62687297e-02f, -5.51053062e-02f,
  8.63162205e-02f, -9.16977897e-02f, 3.04655958e-04f, 1.11882696e-02f, 7.89748281e-02f, -7.39844935e-03f, 4.37919796e-02f, 9.29266866e-03f, 2.89170276e-02f, -3.58982645e-02f,
  3.78933437e-02f, -2.73524702e-01f, 4.50473391e-02f, 6.55700192e-02f, 1.48676950e-02f, -1.89898107e-02f, 4.51892056e-02f, 2.29058713e-02f, -5.23093008e-02f, -5.20973615e-02f,
  -2.75528356e-02f, -1.08264066e-01f, -1.34437410e-02f, 2.52342913e-02f, 1.01256527e-01f, 3.51148807e-02f, 3.69513221e-03f, 4.38045152e-02f, -8.70161876e-02f, 6.49816692e-02f,
  -1.45990923e-02f, 4.71666642e-03f, 4.07889821e-02f, -3.47486064e-02f, -2.70103086e-02f, 1.61047261e-02f, -9.68586206e-02f, 3.29567194e-02f, -4.19543236e-02f, 1.17363065e-01f,
  6.50280267e-02f, -3.76309268e-02f, -3.62857014e-01f, 1.44832889e-02f, -9.39896777e-02f, 3.19197923e-01f, 2.28871122e-01f, -1.61613435e-01f, -2.47682929e-01f, 3.41633528e-01f,
  6.40525222e-02f, -4.45966423e-02f, -6.28587306e-02f, 1.76315382e-01f, -1.30218789e-01f, -2.83317622e-02f, 1.05767012e-01f, 8.36218446e-02f, -1.36911213e-01f, -9.47574228e-02f,
  -2.13452399e-01f, 2.09391192e-01f, -1.94172308e-01f, -7.15563307e-03f, -7.68461972e-02f, -5.86565174e-02f, 1.21012516e-02f, -3.41953747e-02f, 1.34513035e-01f, 1.58640027e-01f,
  5.63481525e-02f, -6.75095990e-03f, 3.24724801e-02f, -8.95925909e-02f, -2.45579239e-02f, 3.17955241e-02f, 1.81902513e-01f, 8.08747038e-02f, -8.04269835e-02f, 1.66335218e-02f,
  2.57893782e-02f, 1.00860000e-02f, -2.77222581e-02f, 4.57392037e-02f, 6.69361139e-03f, -2.18728017e-02f, 1.27423862e-02f, -8.21516011e-03f, -1.25952378e-01f, -4.22350084e-03f,
  -1.48101062e-01f, -5.51819354e-02f, -3.75580788e-02f, 1.13501310e-01f, -1.25100181e-01f, 2.57605668e-02f, 1.09036855e-01f, -7.72128021e-03f, 5.42693865e-03f, 6.89030364e-02f,
  5.24370745e-02f, -6.20429590e-02f, 1.89175678e-03f, -4.38631773e-02f, -1.85305700e-02f, -2.60982625e-02f, -1.29653603e-01f, 1.02236263e-01f, -1.25142308e-02f, 4.20904048e-02f,
  5.61175421e-02f, -2.77338680e-02f, -2.34702951e-03f, -6.95431307e-02f, -8.57872143e-03f, 4.15191986e-03f, -2.54084114e-02f, 1.38774171e-01f, -5.87835573e-02f, 1.90062460e-03f,
  -4.20556478e-02f, 1.06735146e-02f, -6.42670393e-02f, -1.64327724e-03f, -1.63208432e-02f, -1.61705371e-02f, 2.89041642e-03f, -4.11396772e-02f, -4.33607586e-02f, -3.42233665e-02f,
  5.11792861e-02f, 6.06100522e-02f, -5.85615411e-02f, 2.58628670e-02f, 7.25136176e-02f, 2.85166427e-02f, -1.69108912e-01f, -3.55052482e-03f, 2.33449950e-03f, 7.12904185e-02f,
  6.76358715e-02f, 4.90801502e-03f, 5.65222800e-02f, -3.60897258e-02f, -9.60747972e-02f, 3.77162942e-03f, 6.36658818e-03f, 2.01676902e-03f, 3.34550701e-02f, -4.83425632e-02f,
  9.92806330e-02f, -4.33904454e-02f, -8.86208657e-03f, -5.64939566e-02f, 7.67443329e-02f, 4.84057851e-02f, -3.44124697e-02f, 3.61867286e-02f, 3.77563685e-02f, -8.01473260e-02f,
  4.56503987e-01f, -6.06936455e-01f, -2.15137973e-01f, 1.38412282e-01f, 2.63085037e-01f, -4.53697890e-02f, 1.68056279e-01f, -3.90844569e-02f, 8.00714083e-03f, -9.97763574e-02f,
  1.22479886e-01f, -2.11210195e-02f, -6.88768402e-02f, -9.91685987e-02f, 2.97739089e-01f, -3.70690785e-02f, -1.66962249e-03f, -1.52673321e-02f, -1.01558767e-01f, -5.60923964e-02f,
  1.20284036e-01f, -9.22650006e-03f, -3.90353687e-02f, -1.91859782e-01f, 8.44955295e-02f, -8.47692415e-02f, 8.29672366e-02f, -7.74513483e-02f, -8.37957114e-02f, 4.69820611e-02f,
  6.76850677e-02f, -8.03336650e-02f, -8.23907480e-02f, -7.53063932e-02f, -7.80470520e-02f, 2.68311221e-02f, 4.27349173e-02f, 5.67020290e-02f, 4.19733599e-02f, -1.04894087e-01f,
  2.59380769e-02f, 1.50227742e-02f, 2.38673035e-02f, 8.32951665e-02f, 5.48444949e-02f, -1.00401282e-01f, -4.56495956e-02f, -7.45382905e-03f, -4.55687903e-02f, 7.03575537e-02f,
  -9.85769108e-02f, 2.38765646e-02f, 5.01199765e-03f, 3.03363912e-02f, 2.47034766e-02f, -5.56016676e-02f, 6.38016686e-02f, -1.92706827e-02f, -5.71186468e-02f, 4.41926084e-02f,
  4.14931290e-02f, 4.15547863e-02f, 1.22001884e-03f, -4.67020925e-03f, -7.00877011e-02f, 1.03710033e-02f, 6.86528757e-02f, -1.06452545e-02f, -2.97085638e-03f, 2.21008230e-02f,
  3.57456431e-02f, 4.47853794e-03f, 7.40939379e-02f, 7.20526502e-02f, 5.17257936e-02f, 4.02621143e-02f, -4.13334090e-03f, 9.54316874e-06f, 1.52456025e-02f, -6.43682852e-02f,
  3.80379446e-02f, -3.28315347e-02f, 2.90018809e-03f, -2.27699839e-02f, 3.51352580e-02f, 3.16757858e-02f, -5.96534796e-02f, 7.55931512e-02f, 5.50777651e-03f, 7.27296919e-02f,
  -1.12005010e-01f, -2.18299493e-01f, -3.00280917e-02f, 5.93702570e-02f, -8.99626222e-03f, 4.34458256e-02f, 1.00459300e-04f, 9.04601160e-03f, -9.41183120e-02f, 2.64044236e-02f,
  -1.68228783e-02f, 3.50957992e-03f, -3.28582115e-02f, 4.10086103e-02f, -6.13828450e-02f, 2.78802663e-02f, 2.42844019e-02f, 8.80910978e-02f, 2.25565806e-02f, -7.48490021e-02f,
  5.18332310e-02f, 4.63234680e-03f, 7.22758248e-02f, -2.14385651e-02f, -2.40874980e-02f, 8.03778023e-02f, -6.78945407e-02f, 2.45142337e-02f, 9.42875072e-02f, -5.71247973e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.07675025e-01f, 6.71324015e-01f, 6.35944486e-01f, 7.10236907e-01f, -2.28183642e-02f, 5.65530479e-01f, 4.03343588e-01f, 4.91977811e-01f, 9.69666600e-01f, 5.64455520e-04f,
  -4.88946736e-01f, -9.97432023e-02f, -1.56765096e-02f, 1.94046706e-01f, -2.27884889e-01f, 3.73960823e-01f, 3.03488344e-01f, 1.94110384e-03f, 3.22918594e-01f, -7.18700215e-02f,
  1.24755606e-01f, -3.66665035e-01f, -2.31427342e-01f, -3.31714898e-01f, -2.43206456e-01f, 1.21100418e-01f, -5.81669092e-01f, -1.13876201e-01f, -3.27993393e-01f, -1.16276495e-01f,
  -1.07268207e-01f, 1.62079614e-02f, -2.21020758e-01f, 8.48173723e-02f, -8.76717046e-02f, 3.98466215e-02f, -1.07784517e-01f, -3.65226567e-02f, -1.25820003e-02f, 8.58853534e-02f,
  -6.92335293e-02f, -7.96771701e-03f, 2.63964217e-02f, 4.23876680e-02f, 1.34378254e-01f, 3.76919135e-02f, 1.29768588e-02f, 1.12502724e-01f, 6.83910400e-02f, 1.34411409e-01f,
  3.79909836e-02f, 4.78263274e-02f, 4.81667593e-02f, 5.17015718e-02f, -4.23242114e-02f, 1.13904297e-01f, 2.62829121e-02f, -8.35689455e-02f, -1.81602444e-02f, 7.84637332e-02f,
  7.15075061e-02f, 1.03532843e-01f, -6.52770251e-02f, -8.80932659e-02f, -3.97621132e-02f, -2.98947357e-02f, -3.64353061e-02f, -1.83218658e-01f, 1.98963028e-03f, -1.24175819e-02f,
  -4.28291596e-02f, -9.50613096e-02f, 3.31571139e-02f, 5.25514819e-02f, -3.36317942e-02f, 2.13933736e-02f, -9.90852565e-02f, 1.34572675e-02f, 8.32307562e-02f, -1.04210526e-01f,
  5.17658219e-02f, 6.64993897e-02f, -8.21310356e-02f, 6.74576834e-02f, 7.50836134e-02f, -1.72610711e-02f, -8.61765072e-03f, 1.42171353e-01f, -9.32936445e-02f, -3.05329803e-02f,
  1.16741441e-01f, 8.77378508e-02f, -1.03660248e-01f, -4.98080775e-02f, 6.05920469e-03f, -1.34252071e-01f, 8.04589391e-02f, 1.15317591e-01f, 9.48583633e-02f, -6.60359710e-02f,
  -4.33287211e-02f, -2.78641880e-02f, -1.49224952e-01f, -1.34793818e-02f, -5.49865589e-02f, -8.94977823e-02f, -4.62945923e-02f, 1.00674443e-01f, -1.09688029e-01f, -1.60636574e-01f,
  -8.64497051e-02f, -3.50865871e-02f, 4.90100011e-02f, -6.51035234e-02f, -4.72514331e-02f, -2.22787008e-01f, -7.54299248e-03f, 1.79900657e-02f, -1.27122834e-01f, -7.20408512e-03f,
  2.75740623e-01f, 2.78158039e-01f, -2.00894654e-01f, -1.34133339e-01f, -2.85116971e-01f, -3.68648201e-01f, -2.73777306e-01f, 1.76195711e-01f, 3.80577773e-01f, 1.94063008e-01f,
  -3.96830663e-02f, 7.34237134e-01f, 2.97296315e-01f, -4.86616880e-01f, -2.91456599e-02f, 1.22812934e-01f, -4.47343558e-01f, -1.11996561e-01f, 1.08099945e-01f, -2.74092585e-01f,
  -2.02940717e-01f, -4.25758272e-01f, -2.69652694e-01f, -1.43254235e-01f, -5.38949668e-01f, 1.19748339e-01f, -3.20886791e-01f, -2.15653211e-01f, -2.47053251e-01f, 1.60663053e-01f,
  4.16967012e-02f, 2.80561745e-01f, 2.84515750e-02f, -4.36190749e-03f, -1.79495215e-01f, -7.92061090e-02f, -1.11647353e-01f, 7.28264078e-02f, 5.61197177e-02f, 2.00289071e-01f,
  7.44091943e-02f, 9.27185491e-02f, 4.98673767e-02f, -1.06801735e-02f, -7.88069218e-02f, 3.25098746e-02f, -9.81322378e-02f, -1.02269500e-01f, 1.88320175e-01f, 8.29855874e-02f,
  1.67769957e-02f, 9.68096685e-03f, -2.39579454e-01f, 5.18812202e-02f, -1.41578808e-01f, 6.72509745e-02f, -2.23950241e-02f, -1.83537096e-01f, 8.40823948e-02f, 5.99754229e-03f,
  -1.22009046e-01f, -6.04938865e-02f, 3.49115916e-02f, 4.09438051e-02f, -4.34048548e-02f, 4.07487154e-02f, -1.02344170e-01f, -1.10954672e-01f, -3.31879011e-03f, 1.57000780e-01f,
  7.36588836e-02f, -4.81474795e-04f, -6.23812117e-02f, -1.01759486e-01f, -5.78671023e-02f, 1.04596898e-01f, -6.96360972e-03f, 2.23688096e-01f, -2.98243389e-02f, -5.16453087e-02f,
  -4.92072515e-02f, -6.29619062e-02f, 1.25722038e-02f, -1.55241475e-01f, 3.43743488e-02f, -4.06754911e-02f, 4.24707308e-03f, 3.18640694e-02f, 1.77164804e-02f, -1.25658780e-01f,
  -4.40289900e-02f, -4.12462279e-02f, 2.12570578e-01f, 2.99143195e-01f, -3.93885970e-02f, 8.89737159e-02f, -8.84271562e-02f, -1.69543773e-01f, 9.78339184e-03f, -1.65485963e-01f,
  1.64016820e-02f, 7.02299699e-02f, -3.85030508e-02f, -2.48905793e-01f, -6.18225597e-02f, 6.35476634e-02f, 1.12180181e-01f, 1.01451419e-01f, -1.31858543e-01f, -2.98430864e-02f,
  -3.30315270e-02f, 6.26008958e-02f, 1.86702877e-01f, 1.02271989e-01f, 2.95955362e-03f, -2.18442660e-02f, -8.67401510e-02f, 1.01819336e-01f, -1.19865492e-01f, -9.33077186e-02f,
  -2.71617591e-01f, 1.69683337e-01f, 7.00385347e-02f, -5.25716066e-01f, -2.46425211e-01f, 3.15188468e-01f, 1.92559108e-01f, -2.90899482e-02f, -3.15065205e-01f, 5.80265522e-01f,
  -2.52218783e-01f, 3.49195778e-01f, -8.09721202e-02f, -5.59695959e-01f, -8.42665255e-01f, -5.07544279e-01f, -3.49486291e-01f, -1.63425114e-02f, -2.96803623e-01f, 1.58494323e-01f,
  -3.68893623e-01f, -5.57763517e-01f, -3.63914400e-01f, 4.07575583e-03f, 1.27294093e-01f, 3.36881816e-01f, 1.06468402e-01f, 3.08924709e-02f, 1.96707532e-01f, -2.36415625e-01f,
  -1.41760871e-01f, -3.78223330e-01f, 1.48213148e-01f, 7.33808279e-02f, 9.35138762e-02f, 6.91507310e-02f, 2.76461869e-01f, -1.41502485e-01f, -6.62459359e-02f, 2.69588996e-02f,
  1.62248835e-01f, -3.28022130e-02f, -1.37019664e-01f, -1.36602059e-01f, 5.60875833e-02f, -4.75252718e-02f, -8.03103819e-02f, 6.88786358e-02f, 1.22925140e-01f, -6.72822744e-02f,
  -4.80762534e-02f, 3.94002087e-02f, 9.15354565e-02f, 2.79698800e-02f, -2.80539542e-02f, -9.45578888e-03f, 9.76201221e-02f, 9.82230902e-02f, 1.55500814e-01f, -1.07802399e-01f,
  -7.35541880e-02f, -3.39582041e-02f, 7.91687146e-02f, -1.06040329e-01f, -1.31948367e-01f, -1.26386825e-02f, -2.66837664e-02f, -8.67491737e-02f, 1.97823003e-01f, 8.86373147e-02f,
  1.35814324e-01f, 4.51086275e-02f, -4.11188342e-02f, 7.36687034e-02f, 1.01268282e-02f, -7.38231316e-02f, 2.52904464e-02f, 1.53055251e-01f, 1.17600802e-02f, 4.69885617e-02f,
  -1.39475718e-01f, -5.52127585e-02f, 1.41535578e-02f, 1.70126483e-02f, -4.18361910e-02f, 9.24989507e-02f, 1.13422563e-02f, 1.73302129e-01f, -2.99698114e-02f, 1.23609081e-02f,
  1.30437970e-01f, 1.78631052e-01f, 3.23611982e-02f, 4.54321131e-02f, -5.47726564e-02f, 7.11312667e-02f, -2.35678315e-01f, 1.16853766e-01f, -8.24017376e-02f, -8.33413899e-02f,
  6.14005253e-02f, 9.96409506e-02f, 2.17237324e-01f, -1.61119610e-01f, -1.63167894e-01f, -2.43785023e-03f, 1.61651805e-01f, 1.34979412e-01f, 1.81274548e-01f, 1.38882935e-01f,
  2.21927971e-01f, 5.79947643e-02f, 6.20766878e-02f, 8.88959244e-02f, 1.19401418e-01f, 5.82060479e-02f, 1.17681630e-01f, -4.28457148e-02f, 2.50949105e-03f, 3.31395343e-02f,
  -4.50843751e-01f, 5.63106179e-01f, 2.47587502e-01f, 7.11661726e-02f, -5.38641177e-02f, -5.10509193e-01f, -4.11387473e-01f, 5.58203459e-01f, -2.84214646e-01f, 2.41610110e-01f,
  1.54237926e-01f, -1.61629841e-02f, 4.95536357e-01f, -1.70641333e-01f, -2.41536289e-01f, -2.51272351e-01f, -4.39635843e-01f, -1.85244545e-01f, -9.69586968e-02f, 4.14033681e-01f,
  6.98832199e-02f, 9.25009027e-02f, 2.10550338e-01f, 2.94422299e-01f, 1.15869150e-01f, 3.07835907e-01f, 5.40361226e-01f, 2.73282945e-01f, 3.95209193e-01f, -1.66033000e-01f,
  1.11380322e-02f, 1.86638534e-01f, -5.10440394e-02f, 7.71807600e-03f, 1.94692835e-01f, 6.40681535e-02f, 8.52166209e-03f, -3.44592263e-03f, -1.54099632e-02f, 1.26348948e-02f,
  -8.11867118e-02f, -2.61152312e-02f, -6.30059168e-02f, -4.83603217e-02f, -1.61019400e-01f, 6.23685233e-02f, -3.44936503e-03f, -2.62583852e-01f, 4.76230830e-02f, -1.19560808e-01f,
  -3.64692099e-02f, 5.42029552e-02f, -3.22904140e-02f, -1.28515273e-01f, 3.74892689e-02f, 4.26371656e-02f, -3.26514021e-02f, -2.12093182e-02f, -1.22866638e-01f, -1.06392801e-01f,
  -2.64766347e-02f, -6.06844276e-02f, -6.39191046e-02f, -6.16018698e-02f, 4.18890826e-03f, 8.60922411e-03f, -3.63672636e-02f, -5.94335720e-02f, -8.84692073e-02f, -6.52977228e-02f,
  9.82309505e-02f, 1.24866897e-02f, -6.74338266e-02f, -4.01372425e-02f, -3.04004978e-02f, -1.77655462e-02f, 1.45887095e-03f, 6.21078275e-02f, -1.94972064e-02f, -3.95110585e-02f,
  -3.69780371e-03f, -1.84940509e-02f, 1.79803818e-01f, -9.54918936e-02f, 1.68057792e-02f, 8.93790424e-02f, 6.54207394e-02f, -5.74737089e-03f, 5.66659495e-02f, 4.47111167e-02f,
  2.28085354e-01f, 6.90297961e-01f, 3.37655023e-02f, -1.20516509e-01f, -5.75789325e-02f, -3.27065475e-02f, -1.29811659e-01f, 1.06471861e-02f, 2.62385398e-01f, 5.55279292e-03f,
  1.42263547e-01f, -2.22554225e-02f, 5.94393089e-02f, -8.03839266e-02f, 5.48318401e-02f, 5.68287820e-02f, 1.55600905e-01f, 1.01323381e-01f, 1.83826480e-02f, 2.05996111e-01f,
  2.49733806e-01f, 7.64073655e-02f, -1.28878146e-01f, 7.24308044e-02f, 6.27460554e-02f, -2.03857385e-02f, -1.17564350e-02f, 3.62690389e-02f, 1.62002161e-01f, 1.53879166e-01f,
  -1.30330908e+00f, -1.50587142e-01f, 4.00514483e-01f, -6.52540028e-01f, -1.75183341e-01f, -3.06636654e-02f, 3.30495149e-01f, -3.34989488e-01f, -5.01587689e-01f, -1.04744164e-02f,
  7.78888613e-02f, -1.30062789e-01f, 7.37680376e-01f, -1.55552521e-01f, 2.99490809e-01f, 4.57280844e-01f, -1.57092094e-01f, -1.02138117e-01f, -1.23424694e-01f, -3.84523511e-01f,
  -2.28894845e-01f, -2.41263896e-01f, 4.40135986e-01f, -1.58646867e-01f, -3.14337313e-01f, -4.20484126e-01f, -2.16442104e-02f, 1.95089981e-01f, -1.40528381e-01f, 1.79086238e-01f,
  -5.63829482e-01f, -4.11762685e-01f, -6.91616982e-02f, -3.97788845e-02f, -6.74452111e-02f, 8.75771567e-02f, 1.21876344e-01f, 1.96429610e-01f, -9.96425152e-02f, -5.34937494e-02f,
  8.38832483e-02f, 3.43998671e-02f, -2.76387393e-01f, 4.61479612e-02f, -1.99990004e-01f, -1.54538900e-01f, -8.58769566e-02f, -3.92028317e-03f, -4.67007942e-02f, 1.30965754e-01f,
  1.07377015e-01f, -5.70315495e-02f, 1.59732737e-02f, 2.81950552e-02f, 1.06441319e-01f, -1.04566962e-01f, 1.74474716e-02f, 1.64175346e-01f, -8.24385658e-02f, -1.66941255e-01f,
  1.12982370e-01f, -4.15676050e-02f, -1.76677350e-02f, -6.47385344e-02f, 1.02576621e-01f, 8.06727167e-03f, -1.48024512e-04f, 1.51128462e-02f, -5.46476655e-02f, -2.09051091e-02f,
  -1.73850983e-01f, -7.77871460e-02f, -8.03125128e-02f, 4.21787091e-02f, 6.26449808e-02f, 9.63825174e-03f, 1.51218444e-01f, -6.48446232e-02f, -4.37743217e-03f, -5.76995797e-02f,
  -7.06551746e-02f, 4.84154187e-02f, 1.04787610e-01f, 6.91652671e-02f, -8.17756504e-02f, 1.12875551e-01f, -5.82257025e-02f, 6.16225190e-02f, -4.85415608e-02f, 6.51909485e-02f,
  -8.64380360e-01f, -5.27283251e-01f, -2.73471326e-02f, -9.84951034e-02f, -9.16242599e-02f, -5.32227308e-02f, -1.31176144e-01f, -8.89390633e-02f, -1.39159024e-01f, -1.21863633e-01f,
  -1.24402031e-01f, -1.44289676e-04f, -1.20372266e-01f, 6.76702634e-02f, 1.30376831e-01f, 2.21804269e-02f, -4.06268314e-02f, -1.34949952e-01f, -1.11569695e-01f, -4.70228493e-02f,
  -1.39779821e-01f, -1.26267627e-01f, 1.60185665e-01f, -8.76115561e-02f, 2.26591360e-02f, 2.36664694e-02f, -2.24658877e-01f, -4.14857268e-02f, 1.40962703e-02f, 7.83061907e-02f,
  2.97620054e-02f, 8.71411920e-01f, -4.46825832e-01f, 5.33064842e-01f, -4.15310681e-01f, 4.66163397e-01f, 5.00357628e-01f, 1.52559936e-01f, 2.14719951e-01f, 7.93376088e-01f,
  2.95072377e-01f, 2.69561470e-01f, 3.40687186e-01f, 6.44824326e-01f, 6.53777793e-02f, 4.59863007e-01f, 4.04359519e-01f, 3.53084385e-01f, -1.46446094e-01f, 3.05506557e-01f,
  -2.81585194e-02f, 4.94687617e-01f, -7.66065121e-02f, 6.59822822e-02f, 7.99553376e-03f, -3.24688882e-01f, 1.25914201e-01f, -3.21417570e-01f, 9.44627598e-02f, -1.60576522e-01f,
  -1.19947654e-03f, 1.22356884e-01f, -8.62395763e-02f, -3.37591060e-02f, -2.18332987e-02f, -1.47746671e-02f, -9.46009606e-02f, -1.25648871e-01f, -7.98824951e-02f, -4.27212790e-02f,
  1.76062100e-02f, -8.55009779e-02f, 5.83096743e-02f, -6.56445250e-02f, -7.28814080e-02f, -2.09716558e-01f, -8.02206621e-02f, -8.30379352e-02f, 4.36880589e-02f, -1.87487714e-02f,
  -1.31345257e-01f, -6.69045225e-02f, 7.19672143e-02f, 1.60679236e-01f, -1.02890760e-01f, 1.23613581e-01f, 6.90033957e-02f, -1.28940582e-01f, 8.30780566e-02f, 6.10023513e-02f,
  9.80043635e-02f, -4.17617932e-02f, 1.42249078e-01f, -1.07262641e-01f, 4.99727130e-02f, -9.40473750e-02f, 1.23512946e-01f, -9.01883096e-02f, 5.21588605e-03f, 1.73894595e-02f,
  -7.30016455e-02f, 3.20961252e-02f, 9.09190848e-02f, -1.48250349e-02f, 1.34065107e-01f, 1.02893315e-01f, -4.56486531e-02f, 1.00101931e-02f, -8.77047554e-02f, -3.19829211e-02f,
  5.27771376e-02f, 3.65801901e-02f, 3.22715193e-02f, -6.68533891e-02f, 3.47690657e-02f, 6.61178306e-03f, 9.95356888e-02f, 6.46597072e-02f, -6.16940558e-02f, -5.39922491e-02f,
  2.91228920e-01f, 5.40512323e-01f, 5.02339676e-02f, -1.28472764e-02f, 1.98046193e-02f, 8.99708197e-02f, 1.17259696e-02f, 1.66184440e-01f, 1.48263976e-01f, 3.26639898e-02f,
  -1.41324941e-03f, 1.18785679e-01f, -2.87373969e-03f, -2.96565145e-03f, 6.80349395e-02f, 1.63347080e-01f, 1.15240522e-01f, -3.05227451e-02f, 1.05418921e-01f, -6.08713031e-02f,
  5.56271113e-02f, 1.42568499e-01f, -3.67954895e-02f, 1.32942088e-02f, 1.20263040e-01f, -9.33328494e-02f, 5.81511520e-02f, -9.93305296e-02f, -1.26512021e-01f, 4.46026996e-02f,
  2.87441790e-01f, 7.14418054e-01f, 1.13729872e-01f, 1.76942378e-01f, -5.13339043e-01f, -4.38244045e-01f, -3.94798309e-01f, -1.88278943e-01f, 1.88905165e-01f, 2.95944512e-01f,
  -4.78491962e-01f, 8.06922257e-01f, -1.38247479e-03f, -3.27784538e-01f, -4.91468638e-01f, -3.22197407e-01f, -3.91735524e-01f, 3.22291814e-02f, 1.01070136e-01f, -2.15497553e-01f,
  -1.97277829e-01f, -7.01470315e-01f, -4.10024405e-01f, -2.59422094e-01f, -1.72537282e-01f, 3.17410141e-01f, -4.92725223e-01f, -2.03752086e-01f, 6.09608479e-02f, -9.63021889e-02f,
  -1.60995856e-01f, 9.32795629e-02f, 4.33718339e-02f, -2.11524069e-01f, -1.86826065e-01f, -4.77744918e-03f, 5.55868819e-03f, 3.36435325e-02f, -1.56189352e-02f, 2.19967291e-01f,
  1.46209314e-01f, 6.40277937e-02f, -1.21084735e-01f, 1.35077149e-01f, 7.71819577e-02f, 5.48459999e-02f, 1.52870342e-01f, -7.52950460e-02f, 2.76604444e-02f, 2.74851471e-02f,
  8.40712339e-02f, 1.57431290e-01f, -6.19930178e-02f, 1.29235193e-01f, -7.33308122e-02f, 4.41558585e-02f, 2.70985067e-02f, 1.54144123e-01f, 1.32614344e-01f, 1.07112899e-01f,
  4.41423580e-02f, -1.64864719e-01f, -8.33987594e-02f, 5.94547428e-02f, -4.55110706e-02f, -5.36636040e-02f, -4.17640060e-02f, -5.50052635e-02f, 7.74284527e-02f, -1.09127238e-01f,
  -9.90497470e-02f, 8.57240632e-02f, 2.61293836e-02f, -6.54528812e-02f, 1.10234097e-01f, 1.07945979e-01f, -8.01094100e-02f, 1.56063110e-01f, -8.72887895e-02f, -4.75731790e-02f,
  2.23845597e-02f, -7.76340365e-02f, 1.29893810e-01f, -7.66713172e-02f, -7.54268281e-03f, 1.49501935e-01f, 1.49890199e-01f, 2.66682416e-01f, -1.55212030e-01f, -1.59684137e-01f,
  -3.49758595e-01f, -1.71916932e-01f, -1.24421436e-02f, 1.24150239e-01f, 4.41732332e-02f, 6.51863813e-02f, -1.23984389e-01f, 2.56128311e-01f, -7.47552291e-02f, -5.60725294e-02f,
  -1.16210707e-01f, -1.03727408e-01f, -5.88559285e-02f, 1.23448774e-01f, 2.93743573e-02f, -6.73025027e-02f, -2.15608522e-01f, 1.16108602e-03f, -9.64935273e-02f, 1.25938281e-01f,
  1.19580589e-01f, -1.18736677e-01f, 7.55315870e-02f, -1.13872699e-01f, 9.34463888e-02f, -6.60086945e-02f, 9.21531320e-02f, 1.94370583e-01f, -1.09057091e-01f, -6.45778924e-02f,
  -9.01113212e-01f, 2.56618261e-01f, -4.67893988e-01f, -6.31419897e-01f, 3.12704928e-02f, -6.03805780e-01f, -4.02666539e-01f, 1.13120535e-02f, -2.63193473e-02f, 5.15105665e-01f,
  -3.66682038e-02f, -3.12791139e-01f, 4.39975262e-01f, -4.06535745e-01f, -9.64335144e-01f, -3.92217115e-02f, -1.00241840e+00f, -2.82482952e-01f, -1.55527201e-02f, -4.75197226e-01f,
  -4.44937617e-01f, -3.28983098e-01f, -5.09600401e-01f, 3.05787802e-01f, -3.05811226e-01f, 4.76873154e-03f, 1.77931696e-01f, 3.97547364e-01f, -4.10246253e-01f, -7.12029636e-02f,
  -3.20305854e-01f, 8.20430443e-02f, 6.17436192e-04f, 1.65470801e-02f, -3.47133905e-01f, -4.62592877e-02f, -1.32562459e-01f, 2.07571611e-02f, -7.38835633e-02f, -1.92399830e-01f,
  -1.71780195e-02f, 1.02455802e-02f, -3.57399657e-02f, 1.76401347e-01f, 3.02597694e-02f, -8.11226889e-02f, -3.78978588e-02f, -2.82411696e-03f, 5.01775146e-02f, -1.48290858e-01f,
  -1.49513498e-01f, -1.32711276e-01f, 3.24290358e-02f, 2.41809152e-02f, -2.85099130e-02f, -1.36227887e-02f, -1.49158388e-01f, -4.67040055e-02f, -1.54971108e-01f, -9.79985148e-02f,
  -2.12111607e-01f, 3.18350345e-02f, -3.80688235e-02f, -1.31514087e-01f, -5.10560162e-03f, 1.42279670e-01f, -6.88838959e-02f, 2.72158440e-02f, 1.41506325e-02f, -6.27763616e-03f,
  -1.17602356e-01f, -4.33608294e-02f, 4.35079895e-02f, -5.63397296e-02f, -1.03421465e-01f, 2.50622351e-02f, -6.53987601e-02f, -3.57276946e-02f, -6.44783452e-02f, -1.06454805e-01f,
  1.68411985e-01f, 5.11339530e-02f, -4.77435328e-02f, 1.48281097e-01f, -2.87084617e-02f, -4.62847902e-03f, 6.86742291e-02f, 1.05040036e-01f, -1.07708395e-01f, -2.03994438e-02f,
  -3.78497362e-01f, -1.75304398e-01f, 8.12530816e-02f, -3.10399150e-03f, 5.09292670e-02f, -9.63839218e-02f, -5.90145998e-02f, -6.04985654e-02f, -1.69061989e-01f, -3.57354470e-02f,
  -7.48623982e-02f, -8.04308429e-03f, -8.72423127e-02f, -8.39554444e-02f, -1.15828849e-01f, -5.81714101e-02f, -3.47800590e-02f, 6.06534407e-02f, -7.93461278e-02f, 2.88716634e-03f,
  2.39793751e-02f, 2.13996936e-02f, 1.11794323e-02f, 1.35708246e-02f, 9.17197466e-02f, -5.55055104e-02f, -3.25643457e-02f, -4.69705686e-02f, -1.98224820e-02f, -2.68636364e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.84152865e-01f, 6.39993489e-01f, 5.31315982e-01f, 5.22667468e-01f, 6.70019448e-01f, 4.69100386e-01f, 3.94051015e-01f, 3.87334198e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.76172906e-01f, -3.26643378e-01f, -7.50139654e-01f, -3.25685918e-01f, -9.03776586e-02f, 6.94071412e-01f, -1.62880883e-01f, 3.83682027e-02f, -2.77797639e-01f, 2.82465070e-01f,
  -5.52096188e-01f, 1.94096372e-01f, -8.01748931e-02f, 4.76721674e-01f, 1.76408336e-01f, 2.63182908e-01f, 5.46416402e-01f, -9.10640776e-01f, -6.56253025e-02f, 1.13924056e-01f,
  -3.77969831e-01f, 1.95085853e-02f, 4.48353797e-01f, -2.20174611e-01f, 1.95416659e-01f, -4.01996709e-02f, -8.11253265e-02f, -3.91901910e-01f, 3.59287530e-01f, 2.54326344e-01f,
  -3.44324380e-01f, -1.47710294e-01f, 7.81533837e-01f, -2.82009482e-01f, 2.51421392e-01f, 1.96822539e-01f, -6.27558589e-01f, -6.83472574e-01f, 2.54086256e-01f, -1.75252751e-01f,
  2.61264175e-01f, 8.13160688e-02f, 3.07244897e-01f, -4.60963070e-01f, 1.75375864e-01f, 2.15844125e-01f, -2.60260582e-01f, -4.17285770e-01f, -1.60596699e-01f, 1.94933683e-01f,
  -3.36947858e-01f, 5.32015443e-01f, 6.01801157e-01f, 9.06332731e-01f, 3.50314915e-01f, -2.16420949e-01f, -6.15803041e-02f, -6.23544872e-01f, 1.82534933e-01f, 3.46679032e-01f,
  -2.51644880e-01f, 5.02558053e-01f, 6.12279288e-02f, 3.33058298e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -4.25902754e-02f, -8.44605044e-02f, 5.02639949e-01f, 1.04378438e+00f, -1.22537184e+00f, 1.09371555e+00f, -1.96826592e-01f, -1.46256959e+00f, 7.81179905e-01f, -2.02683695e-02f,
  -1.33154482e-01f, 7.85577297e-02f, 1.01725006e+00f, 1.68864667e-01f, -3.62319171e-01f, -5.46018839e-01f, 5.73629975e-01f, 5.15901208e-01f, 6.12352192e-01f, 6.56791449e-01f,
  4.42322940e-01f, 9.57513392e-01f, 2.17109188e-01f, -7.09822178e-01f, -5.51469587e-02f, -8.34428847e-01f, 9.86482978e-01f, 8.99795353e-01f, 8.45872909e-02f, -6.71741962e-01f,
  -5.08971095e-01f, 9.27676857e-01f, 9.60207656e-02f, -1.25701696e-01f, 4.75137383e-01f, -2.51357764e-01f, -8.83044600e-01f, 8.27142656e-01f, -1.34798300e+00f, -6.53587520e-01f,
  3.42936218e-02f, 1.08017027e+00f, -4.60684985e-01f, 9.15962681e-02f, 1.02334452e+00f, -1.22907948e+00f, 1.11175418e+00f, 8.28157067e-01f, 9.11821246e-01f, -8.51823628e-01f,
  -5.23173928e-01f, 4.00230229e-01f, -5.71428478e-01f, 1.36371744e+00f, 1.06677592e+00f, -1.60468793e+00f, 5.17262161e-01f, 3.13918710e-01f, 1.47156194e-01f, 6.36938632e-01f,
  1.80270493e-01f, 1.54511774e+00f, -3.71204883e-01f, 1.16515291e+00f, 2.26036444e-01f, 1.12596643e+00f, 6.76596224e-01f, 9.18882132e-01f, 1.42190981e+00f, -5.97496271e-01f,
  -5.62191784e-01f, 1.57512951e+00f, 9.54921842e-01f, -6.41033873e-02f, -7.37469196e-01f, 4.56364810e-01f, -6.63339317e-01f, 8.79385173e-01f, -7.43420839e-01f, -8.60421658e-01f,
  5.75808764e-01f, 4.93011981e-01f, 6.88202083e-01f, 2.56463528e-01f, 7.58389652e-01f, -5.84934890e-01f, -1.34522724e+00f, -8.53688955e-01f, 6.62925959e-01f, -2.13452503e-01f,
  1.28884864e+00f, 1.01060343e+00f, 4.96486798e-02f, -4.35699314e-01f, 3.08011264e-01f, -3.28029692e-01f, -1.00412972e-01f, 8.62228096e-01f, 9.40535724e-01f, 9.52704921e-02f,
  -4.74680841e-01f, 3.71727347e-02f, 1.04510963e+00f, 1.71512794e+00f, -5.10952175e-01f, 2.24579740e-02f, 2.70075530e-01f, 9.58217755e-02f, 1.33686054e+00f, -1.59853548e-01f,
  1.32756634e-02f, 1.01369262e+00f, 4.86783475e-01f, 7.93327153e-01f, 8.90586257e-01f, 8.06985140e-01f, -4.08203423e-01f, -1.18070436e+00f, -1.01425636e+00f, -4.99387592e-01f,
  1.10619617e+00f, 9.33525562e-01f, 7.74665952e-01f, -6.04728580e-01f, -3.32515478e-01f, -4.01137024e-02f, 1.36725140e+00f, -3.60948443e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -1.19924592e-02f, 5.92110991e-01f, 1.22618936e-01f, 4.89355475e-01f, 1.10755312e+00f, 6.05131030e-01f, 9.49032128e-01f, -3.55856903e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -3.52314085e-01f, -9.98004138e-01f, -3.85362148e-01f, -9.85523522e-01f, -3.77894081e-02f, -6.11667395e-01f, 2.56030113e-02f, 5.59447110e-01f, 8.20031703e-01f, -3.76672506e-01f,
  -9.01904464e-01f, 8.60944569e-01f, -6.76399529e-01f, -1.07063997e+00f, -1.24916779e-02f, -7.93484807e-01f, 6.25789389e-02f, 7.26950109e-01f, 1.26352859e+00f, -4.22388852e-01f,
  1.46404266e+00f, 1.77510703e+00f, 1.20709085e+00f, -5.21265805e-01f, -6.95531189e-01f, -2.90522665e-01f, 3.13414186e-01f, 8.25890601e-01f, 5.32072127e-01f, -1.44629395e+00f,
  -6.51736081e-01f, -9.54245448e-01f, 2.53676981e-01f, 2.20297039e-01f, 6.65432632e-01f, 8.50068331e-01f, -5.29547215e-01f, -8.87995780e-01f, -1.30609584e+00f, 1.16091013e+00f,
  -7.77643025e-01f, 2.98536509e-01f, -1.19764984e+00f, -1.29440260e+00f, 7.16167033e-01f, -3.68531257e-01f, 9.78967071e-01f, -1.38868368e+00f, 2.40134865e-01f, -2.10662752e-01f,
  -8.73531520e-01f, -1.56805441e-01f, 1.24215925e+00f, -3.04597825e-01f, -5.76943636e-01f, 7.50936806e-01f, -1.12190807e+00f, 3.01604658e-01f, 5.81747115e-01f, 3.38674664e-01f,
  -9.20512497e-01f, -2.93448061e-01f, -7.44379386e-02f, -4.34080690e-01f, 2.71633387e-01f, 2.93350279e-01f, 5.02668202e-01f, 4.96067941e-01f, -8.03654015e-01f, 3.99306864e-01f,
  2.32632935e-01f, -5.47400475e-01f, 1.15300536e+00f, 6.89890161e-02f, 4.35176820e-01f, -1.42739028e-01f, -1.43458116e+00f, 7.79846683e-02f, -4.54044759e-01f, -2.25040182e-01f,
  8.67207795e-02f, 5.27749695e-02f, -9.30220306e-01f, 7.41647184e-01f, -4.36561555e-01f, 4.31451440e-01f, 2.22707585e-01f, 1.24104178e+00f, 4.94668126e-01f, -1.12291586e+00f,
  -7.76404560e-01f, 2.24867955e-01f, 6.64133877e-02f, -5.91916859e-01f, -8.30341935e-01f, 8.65145147e-01f, -2.64189601e-01f, 5.75279295e-01f, 1.11970283e-01f, 4.05079037e-01f,
  -5.82351625e-01f, -1.12234086e-01f, 1.00222707e+00f, -1.28973317e+00f, -8.15953135e-01f, -6.81745410e-01f, -1.01043832e+00f, -1.83098364e+00f, 8.15574348e-01f, 6.32612884e-01f,
  -8.77573907e-01f, 3.73244941e-01f, -5.87475896e-01f, -5.57188570e-01f, 2.95903981e-01f, -4.44176525e-01f, 6.99035823e-01f, -8.72844875e-01f, -8.44471395e-01f, -5.59730589e-01f,
  -1.13080585e+00f, -1.02423370e+00f, 8.73461604e-01f, -5.56941450e-01f, -8.00653398e-01f, -1.30678999e+00f, 5.86173356e-01f, 3.45762908e-01f, -2.72347718e-01f, -6.91067100e-01f,
  -2.00958475e-01f, -5.26296973e-01f, 1.01031280e+00f, -7.24290311e-01f, -7.18599260e-01f, 1.81596413e-01f, -6.63028240e-01f, 3.39243084e-01f, -3.20831627e-01f, -7.38406554e-04f,
  5.07323265e-01f, 8.12972963e-01f, -1.56288838e+00f, -8.58141720e-01f, 1.22506164e-01f, 5.20241976e-01f, -5.68428159e-01f, -9.68862653e-01f, -1.09879827e+00f, 8.72344434e-01f,
  9.31407928e-01f, -8.53473008e-01f, 2.52200305e-01f, -1.51862264e+00f, 2.18832180e-01f, -1.74119520e+00f, -4.37557846e-01f, -3.46396327e-01f, 1.18200815e+00f, -1.77500173e-01f,
  -3.11272204e-01f, -3.12510580e-01f, 5.49073100e-01f, -5.65828443e-01f, -1.41690195e+00f, -4.64095205e-01f, -6.15313649e-01f, 1.27182871e-01f, -1.08854902e+00f, 9.03975725e-01f,
  -8.90564144e-01f, 5.12550436e-02f, -1.37367177e+00f, 4.35188979e-01f, 1.00275010e-01f, -4.57342595e-01f, -4.03662771e-01f, -4.42172706e-01f, -1.83680460e-01f, 3.41036648e-01f,
  -3.67425591e-01f, -6.92004263e-01f, -1.30053803e-01f, 2.99529463e-01f, -6.88254058e-01f, -4.39711899e-01f, -1.49372295e-01f, -9.34310734e-01f, -1.17758465e+00f, 7.64365375e-01f,
  -7.30740190e-01f, 9.47033763e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.43044472e-01f, 7.90635824e-01f, 1.32582575e-01f, -7.87169278e-01f, -5.28962314e-02f, -1.98967651e-01f, 1.43672153e-01f, -1.63988501e-01f, -3.60643029e-01f, 3.80878270e-01f,
  -1.84699982e-01f, 1.30038736e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    