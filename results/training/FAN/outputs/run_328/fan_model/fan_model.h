/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.40958771e-01f, 3.72885019e-02f, 3.15306991e-01f, -1.01738796e-01f, 1.65783882e-01f, 8.89217574e-03f, 7.82822147e-02f, 1.45228520e-01f, 3.53230685e-01f, -1.30113989e-01f,
  -8.63985792e-02f, 6.67758957e-02f, 1.27512321e-01f, -8.99466872e-02f, -6.44062907e-02f, -3.55453864e-02f, -7.87485167e-02f, -1.89797282e-02f, 1.73383906e-01f, -4.72369045e-03f,
  1.17353443e-02f, -2.08253801e-01f, 3.79678956e-03f, -1.99438423e-01f, 1.43989278e-02f, -1.10240374e-02f, -2.00351685e-01f, 2.22997125e-02f, -1.20917864e-01f, -1.05738295e-02f,
  -2.83243861e-02f, 1.82274833e-01f, 1.23615362e-01f, -2.53241765e-03f, -1.03068426e-02f, -2.41457373e-02f, -3.49218436e-02f, 7.95605704e-02f, 8.65381137e-02f, -1.22215059e-02f,
  -6.09095357e-02f, 4.71277395e-03f, -6.14816621e-02f, 6.40538558e-02f, 9.74658951e-02f, -1.49600254e-02f, 7.66280219e-02f, 1.55498283e-02f, 1.36731461e-01f, 4.50404510e-02f,
  2.34418828e-03f, 4.31571975e-02f, -5.06790308e-03f, -8.29812046e-03f, 2.59756874e-02f, 3.79243866e-02f, 1.05154710e-02f, -2.55744755e-02f, 6.81480672e-03f, -1.10841049e-02f,
  2.39942390e-02f, 5.40563948e-02f, -8.09740126e-02f, 2.58357171e-02f, -1.63016003e-02f, -4.97283675e-02f, -8.79680514e-02f, -4.15883586e-02f, -1.98636036e-02f, -5.93017898e-02f,
  -9.15555060e-02f, 1.63351465e-02f, 1.02125313e-02f, 4.42316793e-02f, 8.99326708e-03f, 1.72865316e-02f, -5.82877994e-02f, -1.11250900e-01f, 1.66732538e-02f, -2.53727324e-02f,
  -1.61275137e-02f, 7.49444589e-02f, -6.13605045e-02f, -3.52572314e-02f, 7.21834004e-02f, 5.50488569e-02f, -1.54726822e-02f, 3.60951051e-02f, 2.84937117e-02f, 5.13084866e-02f,
  -9.25589353e-02f, -3.53673436e-02f, -5.27012050e-02f, 6.94755139e-03f, -3.99095453e-02f, -8.54143202e-02f, 6.31635860e-02f, -4.73503582e-02f, 2.12076996e-02f, 1.44801298e-02f,
  -1.64187066e-02f, -9.32130069e-02f, 8.88628438e-02f, 3.30486754e-03f, -1.93749368e-02f, -1.13080096e-04f, -7.75688142e-02f, 1.16445394e-02f, -6.00548759e-02f, 3.15346159e-02f,
  -3.35034914e-02f, -4.48709950e-02f, 1.08567055e-03f, -4.47017252e-02f, -5.34757227e-02f, -1.11493893e-01f, -2.74192356e-02f, 2.78746970e-02f, -4.13312875e-02f, -1.95489335e-03f,
  -2.26675704e-01f, 2.56768286e-01f, 8.23772687e-04f, 1.28252050e-02f, 1.17351592e-01f, 1.69280276e-01f, 2.86530051e-02f, 1.09577306e-01f, 2.23009527e-01f, 1.28940176e-02f,
  -2.48206444e-02f, -3.45067196e-02f, -1.46922134e-02f, 8.56255889e-02f, -1.03017800e-01f, 1.93639711e-01f, 1.27827883e-01f, 3.10108569e-02f, 1.53970808e-01f, -5.52668497e-02f,
  -2.54093446e-02f, 6.12519197e-02f, -6.71885582e-03f, -3.06345541e-02f, 4.26087976e-02f, -5.53733995e-03f, -1.36071190e-01f, 3.09346747e-02f, -9.16904509e-02f, 5.61230257e-02f,
  -6.67624250e-02f, -1.17692664e-01f, -4.93689515e-02f, -3.72399949e-02f, -6.24849722e-02f, -1.65831000e-01f, 5.73231885e-03f, -9.01822373e-02f, -2.49202456e-02f, -6.27566921e-03f,
  1.19112143e-02f, 2.12013442e-02f, -6.94622993e-02f, -1.31245228e-02f, 7.91859478e-02f, 1.76066533e-02f, 5.89172728e-02f, 3.35640237e-02f, -4.01258729e-02f, -1.16390157e-02f,
  2.63432767e-02f, 1.59602463e-02f, -1.61255605e-03f, -8.85413087e-04f, 5.81120588e-02f, 3.79409753e-02f, 3.52354534e-02f, -2.40402315e-02f, 2.14492343e-02f, 3.92359979e-02f,
  -6.60827523e-03f, -6.86694160e-02f, -6.48351163e-02f, -5.62616102e-02f, 1.30717317e-02f, -7.15091750e-02f, -4.17647734e-02f, -8.08188617e-02f, 2.32120398e-02f, -3.76144126e-02f,
  3.55918054e-03f, 4.91716899e-02f, 6.09572716e-02f, 1.68816801e-02f, 7.26338848e-02f, -5.97893037e-02f, -3.90220946e-03f, 8.55183080e-02f, 7.41045922e-02f, -4.49231220e-03f,
  1.02973253e-01f, 4.49984409e-02f, -4.42875363e-02f, 3.78068984e-02f, -9.94713884e-03f, 1.94982700e-02f, -1.80043355e-02f, 3.58073749e-02f, -1.86832845e-02f, -3.78570962e-03f,
  8.54251683e-02f, -3.65449637e-02f, -3.73157673e-02f, -8.30300385e-04f, -3.20848860e-02f, -1.78009942e-02f, 3.55739705e-02f, 3.21259312e-02f, -1.87712386e-02f, -5.38932644e-02f,
  5.93116693e-02f, -2.75305137e-02f, -3.91094573e-02f, 6.37462810e-02f, -2.21066214e-02f, -3.61392759e-02f, -5.65962158e-02f, 7.07232058e-02f, 5.09236902e-02f, 6.66854158e-02f,
  -2.94360262e-03f, -1.62308384e-02f, -4.45924047e-03f, -5.98293692e-02f, -7.16332644e-02f, -1.99158210e-02f, -1.64754931e-02f, 5.57194054e-02f, -1.61282755e-02f, -3.71043198e-02f,
  -2.30589643e-01f, 4.21532132e-02f, 1.98258758e-01f, -1.22121640e-01f, -2.01919660e-01f, -2.80428696e-02f, 4.37433496e-02f, -1.25916064e-01f, 3.88670005e-02f, -6.70279860e-02f,
  -4.22976688e-02f, 9.61935222e-02f, 2.10867211e-01f, 4.57643121e-02f, 8.87117833e-02f, 2.87151575e-01f, -4.77240272e-02f, -1.04838563e-02f, 1.00392520e-01f, -7.44416490e-02f,
  1.15955696e-02f, -1.39370695e-01f, 1.55674413e-01f, -8.20463002e-02f, -1.62640005e-01f, -9.68151167e-02f, -9.36111882e-02f, 6.27543330e-02f, -1.87157020e-01f, 2.12359168e-02f,
  5.18100224e-02f, 3.58110555e-02f, -2.13736612e-02f, 4.97440882e-02f, -7.04048723e-02f, -6.26894012e-02f, -3.39624584e-02f, 3.42514785e-03f, -2.08424404e-02f, 4.57457155e-02f,
  1.82930119e-02f, -1.71566550e-02f, -7.95843080e-03f, -5.48551558e-03f, -8.63149762e-02f, -7.09221885e-02f, 3.85704860e-02f, -5.56548452e-03f, -3.35406363e-02f, -2.95378342e-02f,
  3.64813693e-02f, -2.16917694e-03f, -5.00850659e-03f, -4.54737619e-03f, -7.62507841e-02f, 4.10773419e-03f, 2.62543876e-02f, 1.08425114e-02f, -7.05775619e-03f, -1.72020998e-02f,
  -6.13266230e-02f, 4.92569655e-02f, 5.57646342e-02f, -4.02160920e-03f, 5.24157919e-02f, -2.11503226e-02f, 5.91408312e-02f, 2.78315917e-02f, -3.25098843e-03f, 4.00984660e-02f,
  -1.58092019e-03f, -2.05803681e-02f, 1.08352387e-02f, 1.50112975e-02f, -6.53889477e-02f, 5.34388870e-02f, -1.03703327e-02f, 1.04105135e-03f, 1.38628134e-03f, 4.46242727e-02f,
  -8.84455070e-03f, 2.12050532e-03f, 2.37889644e-02f, 5.13337888e-02f, 3.42290252e-02f, -6.52215385e-04f, -4.92090881e-02f, 9.11571011e-02f, -2.75822934e-02f, -3.19434404e-02f,
  8.03029258e-03f, 1.02494247e-01f, 1.50108775e-02f, 1.58742815e-02f, 2.56485660e-02f, -6.07576072e-02f, 4.59261090e-02f, 6.66598370e-03f, 3.62267829e-02f, 5.00045251e-03f,
  -1.10114343e-01f, -8.09247270e-02f, -4.48195003e-02f, -4.91977595e-02f, -3.23722810e-02f, 4.87855785e-02f, -1.07492246e-02f, -2.43018102e-02f, -6.35048896e-02f, -2.77365483e-02f,
  -5.67795895e-02f, -6.25571609e-02f, -8.86810943e-03f, -9.54365134e-02f, -2.64857970e-02f, 3.94740477e-02f, -7.38834292e-02f, 4.35095280e-02f, -1.74975954e-02f, 1.04372784e-01f,
  1.52836710e-01f, -7.36543685e-02f, 4.86822100e-03f, -4.49914150e-02f, -8.64197984e-02f, 2.65394319e-02f, -6.12166189e-02f, 3.09681557e-02f, -1.25133112e-01f, 2.10482962e-02f,
  4.33903076e-02f, -8.26308504e-02f, -7.87260476e-03f, -2.34961696e-03f, 1.56977907e-01f, 2.58278456e-02f, 4.24944907e-02f, 1.28238776e-03f, 2.55203282e-04f, -2.40225028e-02f,
  8.67805332e-02f, 4.58010584e-02f, 1.14064932e-01f, 4.48679775e-02f, -2.07934286e-02f, 3.83164510e-02f, -8.12742021e-03f, -4.48970720e-02f, 3.33150779e-03f, 1.14065185e-02f,
  -6.92640617e-02f, -8.02639127e-02f, -5.36915995e-02f, 2.42446940e-02f, -6.30381182e-02f, 8.76770914e-02f, 6.75851628e-02f, 1.26322154e-02f, 5.61026298e-03f, -4.62590158e-02f,
  2.69677956e-02f, -7.21221510e-03f, -5.51850572e-02f, 6.24957979e-02f, 5.84900863e-02f, -6.96882373e-03f, 7.69803580e-03f, 2.56963279e-02f, 2.19574869e-02f, -8.58020503e-03f,
  9.79551859e-03f, -5.01686297e-02f, -5.03298007e-02f, -7.57181179e-03f, -8.30016509e-02f, 4.29009311e-02f, 4.82774526e-02f, 1.05601759e-03f, 1.32318772e-02f, 7.21263289e-02f,
  1.90158710e-02f, -3.54721174e-02f, 2.42820270e-02f, 7.22076837e-03f, 4.66865711e-02f, -6.38851523e-02f, 2.88414415e-02f, 3.30318585e-02f, 7.04377443e-02f, -8.49263929e-03f,
  -3.89786102e-02f, -2.63406709e-02f, -4.21339646e-02f, -3.30316797e-02f, 3.06301750e-02f, -2.32906770e-02f, -7.83488452e-02f, 5.26080355e-02f, 5.19017950e-02f, -8.78226198e-03f,
  7.91431218e-03f, 6.20395876e-03f, -2.34821346e-02f, 4.40046936e-02f, 1.15616247e-02f, 5.29338345e-02f, -4.20882478e-02f, 4.12180722e-02f, 1.98577046e-02f, 7.17820376e-02f,
  8.13309327e-02f, 5.02730682e-02f, -1.70742795e-02f, -7.04904944e-02f, 5.84514439e-02f, 1.25195822e-02f, 1.63196903e-02f, -4.68417741e-02f, -6.46008328e-02f, 1.07946498e-02f,
  -4.21802513e-02f, -1.15613472e-02f, 1.01993289e-02f, 5.24567142e-02f, 2.21208413e-03f, 2.07728595e-02f, 2.80801151e-02f, -1.42468968e-02f, -8.66850019e-02f, 5.96939698e-02f,
  -1.30024999e-02f, -1.09960243e-01f, -3.87713462e-02f, -1.81133151e-02f, 1.66929439e-02f, -7.81209171e-02f, -4.49095443e-02f, -9.24902409e-02f, -1.39123844e-02f, 2.21357625e-02f,
  -2.33402520e-01f, -5.97794391e-02f, -1.59730852e-01f, 7.05165491e-02f, 1.59862787e-01f, 1.88823551e-01f, 4.97392863e-02f, 1.12216279e-01f, 1.56122774e-01f, 7.98341855e-02f,
  -1.58012081e-02f, -7.85724670e-02f, -9.51116681e-02f, -1.21797025e-02f, 6.32918626e-02f, -4.72482853e-02f, 8.75813738e-02f, 5.79027459e-02f, 7.25614950e-02f, -9.39030796e-02f,
  -1.03157528e-01f, 2.44765934e-02f, -1.77016184e-01f, -9.69123840e-03f, 1.14878202e-02f, -5.17562926e-02f, 4.67804410e-02f, -9.30987448e-02f, -4.20077518e-02f, 6.96957037e-02f,
  -3.06592621e-02f, -2.20525116e-02f, 1.82962343e-02f, -1.57365888e-01f, -1.09978862e-01f, -7.16585666e-02f, -5.86456805e-02f, -1.02662787e-01f, 2.68052710e-04f, 2.03030873e-02f,
  -6.56483397e-02f, -4.07225974e-02f, -1.16420407e-02f, 3.34064588e-02f, -9.61866155e-02f, -6.12539612e-02f, -5.70901856e-03f, 1.47790819e-01f, 5.90744987e-02f, 2.49075200e-02f,
  -5.85737731e-03f, -4.45694569e-03f, 3.68490862e-03f, 5.29547818e-02f, 6.32444769e-02f, 7.39753768e-02f, 6.93119168e-02f, -3.58402953e-02f, -7.59574994e-02f, 2.12469269e-02f,
  -3.76433805e-02f, -5.08039631e-02f, -4.42791507e-02f, 2.09672675e-02f, -5.74644022e-02f, -2.77962233e-03f, 7.67384842e-02f, 2.90787946e-02f, 3.50928330e-03f, 2.09212694e-02f,
  -5.85779324e-02f, 7.15618432e-02f, -2.19230540e-02f, -4.00031582e-02f, 4.21120450e-02f, 5.13816290e-02f, 6.64463192e-02f, -3.83666418e-02f, 7.79855847e-02f, 8.63941163e-02f,
  1.26170730e-02f, 9.03194770e-03f, -8.72412771e-02f, -2.26717326e-03f, 6.00612387e-02f, 3.35626341e-02f, 5.04930355e-02f, 9.47190672e-02f, 7.31542110e-02f, 3.68609205e-02f,
  1.88207924e-01f, 2.10309736e-02f, 3.00988206e-03f, 5.51541746e-02f, -1.63042005e-02f, -3.21996026e-02f, -5.17782271e-02f, -2.42748316e-02f, -8.48915130e-02f, -7.68081471e-02f,
  3.52064185e-02f, -8.39869399e-03f, -2.15766439e-03f, -3.58100310e-02f, -2.24559139e-02f, 5.73796108e-02f, 8.00644979e-02f, 8.30393005e-03f, 5.60913198e-02f, -2.96164900e-02f,
  -5.63854240e-02f, 5.62750362e-02f, -7.13463724e-02f, -2.23333221e-02f, 3.53028416e-03f, -3.54383662e-02f, -9.87440720e-03f, 4.25361805e-02f, 4.86396775e-02f, 2.31789798e-02f,
  -6.64755553e-02f, 1.30711779e-01f, 8.95502344e-02f, 1.51239978e-02f, -8.12998563e-02f, -5.05221672e-02f, -1.05285123e-02f, 1.67244785e-02f, 3.34700197e-02f, -4.80643399e-02f,
  -1.73957348e-01f, 7.61486888e-02f, 1.93545856e-02f, -4.55458052e-02f, -5.40453605e-02f, -1.05474722e-02f, -6.28610030e-02f, -1.01106435e-01f, -1.02746682e-02f, -7.11959526e-02f,
  3.55584803e-03f, -1.26433372e-01f, 2.48088352e-02f, -5.91336973e-02f, 2.76195947e-02f, 1.19024433e-01f, -1.16653711e-01f, -7.52222165e-03f, -9.60439220e-02f, -2.39318125e-02f,
  4.01768796e-02f, 2.04646308e-02f, -2.80117523e-02f, 7.34028891e-02f, -2.76027527e-02f, -5.39553314e-02f, -1.50795415e-04f, -6.07284047e-02f, 1.32815009e-02f, -5.03936857e-02f,
  1.43619357e-02f, -1.01722563e-02f, -9.33388025e-02f, 1.09731853e-02f, 2.43395921e-02f, 7.34087899e-02f, 5.75142913e-02f, 3.18372995e-02f, -1.03101038e-05f, 8.96594375e-02f,
  3.07338852e-02f, 1.94101073e-02f, 8.16162750e-02f, 2.86941305e-02f, 5.23868389e-02f, -1.79160405e-02f, 3.21917720e-02f, 4.73740213e-02f, 2.39318740e-02f, 2.41273288e-02f,
  -3.75152826e-02f, -6.06583781e-04f, -6.53155074e-02f, 5.38785942e-02f, 7.66228065e-02f, 2.30340026e-02f, 3.84149104e-02f, 5.69319411e-04f, 9.13453549e-02f, 2.89154127e-02f,
  -3.80946696e-02f, -1.67593043e-02f, -5.88940978e-02f, -9.08463821e-02f, -4.08442765e-02f, -3.78905721e-02f, -5.18299378e-02f, 5.31987147e-03f, 1.55093316e-02f, 4.23191041e-02f,
  2.57632211e-02f, -2.59110779e-02f, -3.26521583e-02f, 1.49776302e-02f, 5.48186153e-02f, -1.05477730e-03f, -1.14379741e-01f, -4.98369802e-03f, 2.96551436e-02f, -6.49601147e-02f,
  -9.40966699e-03f, -3.27079557e-02f, 9.90081578e-02f, -1.22991130e-02f, 8.05674680e-03f, 3.96972038e-02f, 3.22748087e-02f, 1.80109739e-02f, -3.52443568e-02f, 4.06501777e-02f,
  -2.41952874e-02f, 1.08853411e-02f, 5.13001680e-02f, -6.06566742e-02f, 3.63939293e-02f, -3.51549834e-02f, 3.21170129e-02f, 1.26153361e-02f, 4.32405435e-02f, 3.76126170e-02f,
  -3.63066718e-02f, -1.26685873e-02f, -7.41589665e-02f, 6.19919524e-02f, -5.33540361e-02f, -9.26390365e-02f, 5.34480363e-02f, -2.41528526e-02f, -4.42362353e-02f, -2.64858529e-02f,
  1.88544720e-01f, -1.85045585e-01f, 4.77976538e-02f, -1.86862480e-02f, 8.63584876e-02f, 3.27902675e-01f, 2.00610027e-01f, 4.56992127e-02f, 1.48493618e-01f, -1.31335318e-01f,
  -1.00368494e-02f, -1.11422330e-01f, 2.81182248e-02f, -5.62250130e-02f, 4.55599308e-01f, 1.97056621e-01f, 1.46001466e-02f, -3.41415070e-02f, 3.71696241e-02f, 1.11824209e-02f,
  2.74462551e-02f, 1.10770434e-01f, 1.01179875e-01f, -8.80868267e-03f, -1.56699345e-02f, -1.83328792e-01f, -1.11815028e-01f, 1.74743962e-02f, -1.46911621e-01f, 1.11483984e-01f,
  9.20927376e-02f, -7.78370425e-02f, -2.17547659e-02f, -3.97568271e-02f, -3.85571569e-02f, -4.34416085e-02f, -2.16843300e-02f, 2.27778461e-02f, 2.88614817e-02f, -5.93597293e-02f,
  -1.04958549e-01f, 6.85715973e-02f, 5.68342349e-03f, 7.77044296e-02f, -7.08433241e-03f, 1.62434038e-02f, 7.96037167e-02f, -2.81440765e-02f, -3.66175771e-02f, 2.75786743e-02f,
  -1.31683156e-03f, -6.28002957e-02f, 6.58442127e-03f, -4.10361066e-02f, -1.52040477e-04f, -1.66573655e-02f, -4.85553965e-02f, -4.32585105e-02f, -4.53403816e-02f, 2.81532276e-02f,
  -1.18203815e-02f, -8.27402342e-03f, -1.23775881e-02f, -2.88835331e-03f, 2.39790659e-02f, 4.18760069e-02f, -1.83279850e-02f, 1.12075992e-02f, -5.36353048e-03f, -3.65314856e-02f,
  -6.86800806e-04f, 2.12793276e-02f, 3.06855217e-02f, -2.60952637e-02f, 6.65709563e-03f, -5.84055074e-02f, -3.03648580e-02f, -7.99901485e-02f, -4.75174263e-02f, 3.58604186e-04f,
  2.91633210e-03f, 4.58954386e-02f, -6.81504309e-02f, -1.07840888e-01f, 6.02097716e-04f, -3.68773118e-02f, -2.53212242e-03f, -1.92316044e-02f, -2.41797026e-02f, 1.87992807e-02f,
  1.38899144e-02f, -1.03475273e-01f, -5.32258339e-02f, -2.55959947e-02f, -2.67248023e-02f, -8.46250057e-02f, -1.68477930e-02f, -4.62735482e-02f, 3.58778760e-02f, 1.14747420e-01f,
  -3.20994407e-02f, -8.28009695e-02f, -8.20001140e-02f, -1.69318095e-02f, 1.93081535e-02f, 4.68959985e-03f, -6.38075694e-02f, -6.18155152e-02f, 1.23590464e-02f, -3.91316153e-02f,
  -6.28341436e-02f, -5.73066957e-02f, 3.40974480e-02f, 6.28275052e-02f, -1.04708597e-01f, -1.98805928e-02f, 8.18710774e-03f, -4.86692507e-03f, 4.05402891e-02f, -3.27422917e-02f,
  3.23729925e-02f, 1.08559452e-01f, 2.05230013e-01f, -8.92300084e-02f, -1.00686565e-01f, -1.36668652e-01f, -6.36096075e-02f, -1.56000871e-02f, -4.24208939e-02f, -1.36665165e-01f,
  -6.39245808e-02f, 2.04147220e-01f, -2.35970248e-03f, -1.68590937e-02f, 8.79135877e-02f, 7.22655803e-02f, -1.48842961e-01f, 5.44220805e-02f, 8.29959139e-02f, -6.09287135e-02f,
  2.71751303e-02f, -7.46106058e-02f, 2.55337302e-02f, -5.04191145e-02f, 4.74906303e-02f, -6.72677979e-02f, -6.96224123e-02f, 1.03630655e-01f, 1.18035804e-02f, 4.40055393e-02f,
  -1.05412915e-01f, 3.86011116e-02f, 2.50924705e-03f, -4.32729609e-02f, -8.10827315e-02f, -5.15503548e-02f, 9.63995047e-03f, 3.23725957e-03f, 1.27836466e-02f, -3.22507881e-02f,
  9.20730457e-02f, -2.38299537e-02f, 1.99426971e-02f, -8.04229006e-02f, 3.36492136e-02f, 4.26731445e-02f, 3.28819416e-02f, -5.79894185e-02f, 6.38862699e-02f, 2.37552095e-02f,
  4.11614515e-02f, -5.19667529e-02f, 3.22908200e-02f, 8.89393326e-04f, 6.58928901e-02f, -1.37299579e-02f, -4.95686121e-02f, 9.20600221e-02f, -2.97423732e-02f, -7.08117262e-02f,
  6.91271499e-02f, -1.00128777e-01f, -1.79730803e-02f, 2.01311847e-03f, -1.81910358e-02f, -4.44423929e-02f, -2.41502002e-02f, -1.32856453e-02f, -1.81764793e-02f, -3.22699770e-02f,
  -6.89356625e-02f, 3.30183804e-02f, -2.88067455e-03f, -1.18575338e-02f, 7.45857134e-02f, 1.24934325e-02f, 4.55936342e-02f, 3.25500895e-03f, -5.39777726e-02f, 1.93082523e-02f,
  2.10863911e-02f, -2.75878478e-02f, 8.27158317e-02f, -2.22576223e-02f, -3.79839316e-02f, 1.20558310e-02f, 6.21427968e-03f, -2.57783160e-02f, 6.84939623e-02f, 3.40232700e-02f,
  -2.45902359e-01f, -2.82892119e-02f, -6.54898807e-02f, -5.40320016e-03f, 7.53385248e-03f, -6.73472062e-02f, -3.52506340e-02f, 1.01753557e-03f, -1.41879851e-02f, 1.95093881e-02f,
  -1.43484641e-02f, -1.43926051e-02f, -8.23419448e-03f, 1.22615555e-02f, 9.23816785e-02f, -2.90347058e-02f, 4.36447673e-02f, 6.57575950e-02f, -7.82842413e-02f, -3.95532176e-02f,
  1.37279835e-02f, 5.82300611e-02f, -1.14781708e-02f, -9.93334353e-02f, -8.23435634e-02f, -3.16416249e-02f, 1.22885061e-02f, -4.17182818e-02f, 8.11420903e-02f, 1.77359805e-02f,
  -2.38310844e-01f, 1.84434682e-01f, -1.79287761e-01f, -1.90761954e-01f, -1.51558295e-01f, 2.20471993e-01f, 5.43363653e-02f, 9.34363455e-02f, -3.22188921e-02f, 2.17154250e-01f,
  1.58551298e-02f, 1.47700720e-02f, 2.14048728e-01f, 1.27511218e-01f, -5.85422367e-02f, 1.47239298e-01f, 6.37834519e-02f, -6.08769804e-03f, -1.18281484e-01f, -1.15462933e-02f,
  -1.28047332e-01f, 7.60351121e-02f, -1.51309222e-01f, -8.63570645e-02f, -1.26301378e-01f, -2.38482594e-01f, 3.43555748e-03f, -9.22178030e-02f, -1.99142117e-02f, 2.68279779e-04f,
  -6.44759610e-02f, -4.86144833e-02f, -7.00486302e-02f, 2.18974445e-02f, 4.29322477e-03f, -1.44078378e-02f, 4.47381176e-02f, -3.67880762e-02f, -1.16044180e-02f, 3.16109322e-02f,
  2.13048626e-02f, -9.64753330e-03f, -2.39094999e-02f, -2.24881596e-03f, 2.03015767e-02f, -5.70728183e-02f, -2.20054965e-02f, -3.97573821e-02f, 3.23896371e-02f, -3.16610234e-03f,
  -5.40474169e-02f, 3.12295067e-03f, -2.96317842e-02f, -3.04807145e-02f, -4.80249375e-02f, -1.57932285e-02f, 1.10017611e-02f, -1.36984857e-02f, 4.29215170e-02f, 3.18211950e-02f,
  8.11697766e-02f, 1.55379670e-02f, 2.67991759e-02f, 2.82724313e-02f, -5.64810000e-02f, -2.92833373e-02f, 4.35057431e-02f, -3.32131758e-02f, 3.41517031e-02f, 4.08691727e-03f,
  -1.69870239e-02f, -5.00893034e-02f, 2.14683283e-02f, 1.21957771e-02f, -8.02463386e-03f, 3.49388383e-02f, 1.18347565e-02f, 1.16863102e-02f, -9.60803106e-02f, -3.29225548e-02f,
  2.38124728e-02f, 7.38258660e-02f, -2.00485019e-03f, 1.29651828e-02f, 3.79358232e-02f, -9.58396271e-02f, 5.71042784e-02f, -4.03464623e-02f, -2.36305278e-02f, 2.97438097e-03f,
  1.34050772e-01f, 2.45262533e-01f, -4.68777353e-03f, 6.34854957e-02f, -1.43942516e-02f, 7.01830089e-02f, 9.24320817e-02f, 7.03817755e-02f, -6.48038229e-03f, 1.66998859e-02f,
  1.32746827e-02f, 3.66262048e-02f, 1.15670078e-01f, 5.01713231e-02f, 1.76664814e-02f, 5.93572743e-02f, 1.79983838e-03f, 1.22595625e-02f, 8.70422497e-02f, -3.06101739e-02f,
  -2.37770975e-02f, 3.74838598e-02f, -4.07574996e-02f, -3.27603333e-02f, 2.96264458e-02f, -4.27178107e-02f, 1.03618978e-02f, -9.27212238e-02f, -2.75649969e-02f, 1.96295464e-03f,
  -4.47923094e-01f, -1.25576658e-02f, -1.80826262e-01f, -1.53927177e-01f, -1.23989340e-02f, -7.64965639e-02f, -1.03417467e-02f, -1.46878557e-02f, -1.67541429e-01f, 1.50339991e-01f,
  9.39064249e-02f, -2.88545072e-01f, 1.44851029e-01f, -9.93759185e-02f, -5.32490537e-02f, 1.14738062e-01f, -6.51374683e-02f, -1.74016375e-02f, 5.58125675e-02f, -1.39093129e-02f,
  -1.86755732e-02f, 1.24680646e-01f, -1.21003240e-02f, 1.26933739e-01f, -1.46981746e-01f, -2.04700083e-02f, 1.22380681e-01f, 4.25938927e-02f, 2.73974463e-02f, 1.89900044e-02f,
  -7.19811842e-02f, 1.02633163e-01f, 1.36016747e-02f, -1.33760804e-02f, 2.54702028e-02f, -2.23285593e-02f, -1.51975919e-02f, 9.85411182e-03f, -4.39890511e-02f, -3.35976705e-02f,
  -6.51306137e-02f, 1.07764946e-02f, -2.66798530e-02f, -1.32471454e-04f, 3.10917795e-02f, -5.33667766e-02f, -4.19798680e-02f, -1.91743337e-02f, -8.32108036e-02f, -7.70860314e-02f,
  -7.79590532e-02f, -4.30277474e-02f, -1.08301369e-02f, -7.80776888e-02f, -3.36075872e-02f, -8.54513049e-02f, -3.88337299e-02f, -1.82420984e-02f, -2.02714428e-02f, -8.68290570e-03f,
  8.26386958e-02f, 5.75487204e-02f, 6.51139468e-02f, 1.76712722e-02f, 1.71804242e-02f, -2.81556100e-02f, 6.03968336e-04f, -3.30884419e-02f, -4.40488048e-02f, 1.71922715e-04f,
  -4.52710204e-02f, -3.63778509e-02f, 4.45496254e-02f, -1.40087660e-02f, 1.17427893e-02f, -7.65214562e-02f, -5.05662411e-02f, -8.71377438e-02f, -2.77962927e-02f, 4.73686010e-02f,
  -1.73848532e-02f, -7.60871079e-03f, 3.20406421e-03f, -4.61820550e-02f, -4.62771095e-02f, -5.25031053e-03f, 5.94913326e-02f, -7.00629354e-02f, 5.64045236e-02f, 1.69771463e-02f,
  1.07765593e-01f, 1.36273041e-01f, 4.64085676e-02f, 1.05131101e-02f, 5.09969331e-02f, 3.30509506e-02f, -2.98779435e-03f, -3.88213433e-02f, 1.28060849e-02f, 8.43331441e-02f,
  2.99184043e-02f, -4.73407395e-02f, 1.40064685e-02f, -1.20979369e-01f, 8.04017708e-02f, 2.25163978e-02f, 2.62722336e-02f, 4.91821691e-02f, 6.92510419e-03f, 3.79469506e-02f,
  1.19229285e-02f, -2.80498830e-03f, -2.06728629e-03f, 2.40012947e-02f, -1.13240443e-02f, 5.91165125e-02f, -7.73286968e-02f, -4.21988703e-02f, 4.69168648e-02f, -1.02091832e-02f,
  -2.45139241e-01f, 3.96196365e-01f, 1.00677721e-01f, 1.90078080e-01f, -7.57466629e-02f, -3.33510600e-02f, -9.05691534e-02f, 1.23411372e-01f, 2.16423661e-01f, 6.11684993e-02f,
  3.03422380e-02f, 1.05339974e-01f, 4.63288352e-02f, 1.78082421e-01f, -2.12651908e-01f, 6.43618405e-02f, 2.45978702e-02f, 9.29486975e-02f, 1.09257005e-01f, 7.97944069e-02f,
  -6.95169345e-02f, 3.10195214e-03f, 1.38316620e-02f, 3.12124006e-02f, 9.68207046e-02f, -2.71903072e-03f, -1.73612401e-01f, -2.49004364e-02f, -2.20899004e-02f, -6.58307821e-02f,
  1.05020791e-01f, 1.17128827e-01f, 9.45809484e-02f, -1.83413811e-02f, -1.90806277e-02f, -3.66920270e-02f, -5.02240732e-02f, 7.92399514e-03f, 3.31915542e-02f, -4.69750091e-02f,
  3.47540900e-02f, 6.47458732e-02f, 9.83888283e-03f, 2.30399184e-02f, -2.54699681e-02f, -3.07466462e-03f, 4.41714674e-02f, -1.71724241e-02f, 1.03108115e-01f, 1.03629574e-01f,
  5.52286254e-03f, 3.39144133e-02f, 1.92952175e-02f, 9.89639983e-02f, 3.91066968e-02f, 3.92097309e-02f, 5.12775406e-02f, 2.83417013e-02f, 5.29404804e-02f, 3.68807390e-02f,
  -7.33098947e-03f, -8.39563012e-02f, -1.02022728e-02f, 3.35751288e-02f, 2.55760513e-02f, 6.11011088e-02f, -5.29517718e-02f, 3.35665531e-02f, -4.91860732e-02f, 4.58967164e-02f,
  -2.82551348e-02f, 2.55058729e-03f, 3.12360954e-02f, 3.79942358e-02f, 4.29057516e-02f, 7.31901824e-02f, -2.72052120e-02f, 6.36798050e-03f, -8.16770736e-03f, 1.61318928e-02f,
  -2.31357105e-02f, 3.26815210e-02f, 7.13182166e-02f, -3.27662565e-02f, 9.70045850e-02f, -4.11475450e-02f, 1.58347096e-02f, 1.05133913e-01f, -2.25141142e-02f, -5.61218411e-02f,
  2.18803864e-02f, 2.81702373e-02f, -1.73443509e-03f, -3.87069141e-03f, 8.32503941e-03f, -5.33359200e-02f, -2.29309872e-02f, -4.08276170e-03f, 5.00906259e-02f, 8.19136724e-02f,
  -1.00116976e-01f, -1.02870733e-01f, -3.76423374e-02f, -4.63795923e-02f, -2.55207438e-02f, 2.83570942e-02f, 8.10343772e-03f, -8.28633457e-03f, -1.13269173e-01f, 1.76515952e-02f,
  7.63529241e-02f, -6.77313507e-02f, -1.67569797e-03f, 3.20920497e-02f, -4.44961749e-02f, 1.02460058e-03f, -4.47008647e-02f, 1.05756475e-02f, 1.48419011e-02f, -3.58580835e-02f,
  1.47469431e-01f, 7.70600513e-02f, -1.84485480e-01f, 2.24546403e-01f, -1.61877483e-01f, 1.75300792e-01f, 1.40469536e-01f, -2.57163569e-02f, 1.16633177e-01f, -4.47741896e-02f,
  7.69223692e-03f, -6.94182813e-02f, 8.26046690e-02f, 2.46046975e-01f, 1.86632752e-01f, 1.50678501e-01f, 1.97030962e-01f, 1.33291811e-01f, 5.91421127e-02f, 7.58817792e-02f,
  1.16694473e-01f, 1.79364726e-01f, 6.01364784e-02f, -1.75822787e-02f, -1.22403102e-02f, -1.13288142e-01f, -5.21654300e-02f, -1.46460369e-01f, 5.79839274e-02f, -1.53315030e-02f,
  -2.13086139e-02f, -2.35727411e-02f, -2.35761832e-02f, 4.91568595e-02f, -2.64866580e-03f, 1.64484605e-02f, -9.02836248e-02f, -4.66680042e-02f, -1.04713805e-01f, -5.40425032e-02f,
  5.82762389e-03f, 1.94964639e-04f, 5.83211556e-02f, -2.70179398e-02f, -9.23214853e-03f, -2.90024523e-02f, -4.51331865e-03f, -8.96014497e-02f, -3.89141077e-03f, -4.13066372e-02f,
  3.85719165e-02f, 4.55967337e-02f, 5.80556691e-02f, 2.12451015e-02f, -6.76488355e-02f, -4.52400045e-03f, 4.05079983e-02f, 6.90890069e-04f, -1.01175057e-02f, 6.08013012e-02f,
  2.40970291e-02f, 3.18540744e-02f, -5.12659587e-02f, 1.18547892e-02f, 1.01400107e-01f, 1.83627792e-02f, -1.53143248e-02f, -7.20260814e-02f, -3.06029059e-02f, 6.69948831e-02f,
  -4.33492847e-02f, -8.00467283e-02f, -1.49155855e-02f, 4.27612923e-02f, -3.65025885e-02f, 8.33868980e-02f, 1.84895508e-02f, -7.62654562e-03f, 4.66645174e-02f, 1.75520424e-02f,
  -2.03557704e-02f, -3.54913361e-02f, -2.13885773e-03f, -1.50258583e-03f, 2.28443071e-02f, -6.30378053e-02f, 1.32551296e-02f, -2.94642076e-02f, 1.64614730e-02f, 1.37588512e-02f,
  4.81083207e-02f, 3.15215960e-02f, -7.23005447e-04f, 3.79194017e-03f, -5.22664152e-02f, -3.89137468e-03f, 4.94478382e-02f, 1.08576482e-02f, 3.94328497e-02f, 4.10788245e-02f,
  -3.14854942e-02f, 2.74732597e-02f, -1.44838104e-02f, 1.39750503e-02f, 6.61739409e-02f, 2.98432298e-02f, 9.04885009e-02f, 4.94611915e-03f, 6.06291462e-04f, -6.85049817e-02f,
  -4.09905910e-02f, 1.07634431e-02f, 1.92943495e-02f, 4.18712907e-02f, 3.07855103e-02f, -4.21736315e-02f, -2.17469293e-03f, -5.17901555e-02f, -5.96066304e-02f, -5.20883277e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.41575855e-04f, -2.34803222e-02f, 3.23819630e-02f, 7.58245811e-02f, 5.01360837e-03f, -4.48884889e-02f, 7.24975690e-02f, 3.72260772e-02f, 3.01756039e-02f, -8.79466347e-03f,
  -5.89614734e-04f, 2.19766553e-02f, -6.03081882e-02f, -2.50426400e-02f, -1.46845102e-01f, -2.02622518e-01f, -7.33678937e-02f, -1.27158333e-02f, 1.17926523e-02f, 1.08314961e-01f,
  -9.78179500e-02f, -1.11397177e-01f, -5.55930287e-02f, 3.22987288e-02f, -3.98830101e-02f, 1.56180441e-01f, -3.67268622e-02f, 8.21962431e-02f, 1.38047559e-03f, 6.38147891e-02f,
  4.43539098e-02f, 7.64747569e-03f, -5.43836057e-02f, 7.47472979e-03f, 6.40445063e-03f, -5.04990704e-02f, -6.43923432e-02f, -7.07865432e-02f, 9.59177613e-02f, 1.12996642e-02f,
  2.56066788e-02f, -6.74040467e-02f, 1.01148486e-01f, -7.51706287e-02f, 6.06912747e-02f, 3.03218868e-02f, 2.25135637e-03f, -5.86162135e-02f, -3.92569415e-02f, -4.68992814e-02f,
  4.19806764e-02f, 3.34379151e-02f, -1.15012017e-03f, 5.28693348e-02f, -2.92208456e-02f, -5.82301281e-02f, 5.89558594e-02f, 5.64653203e-02f, -4.70686518e-02f, 5.81067009e-03f,
  -5.20382561e-02f, 5.12431189e-02f, -6.06631935e-02f, 4.17578630e-02f, 3.51822004e-02f, 8.00758153e-02f, 3.80490534e-02f, -5.79629317e-02f, -1.72277428e-02f, -7.97929913e-02f,
  -5.88607378e-02f, -4.20736196e-03f, 3.23925167e-02f, -1.80004854e-02f, -4.71310616e-02f, -4.36168611e-02f, -7.89944306e-02f, 2.48977188e-02f, -1.17852855e-02f, -1.54346935e-02f,
  -7.62147829e-02f, 5.07144816e-02f, -4.60091121e-02f, 1.73488371e-02f, -5.14891185e-02f, -7.89796710e-02f, -8.15489702e-03f, 2.19837204e-02f, 2.16435306e-02f, 4.59540784e-02f,
  -3.53588834e-02f, 6.63742609e-03f, 1.10011920e-02f, 4.71731350e-02f, 6.20871559e-02f, 6.46815449e-02f, 5.14841974e-02f, -2.60354113e-02f, -7.44039519e-03f, 2.97356229e-02f,
  -1.58759281e-02f, -9.61771794e-03f, 4.08011079e-02f, -7.73492828e-02f, 7.74307351e-04f, 1.99131500e-02f, 2.62200944e-02f, 2.11794991e-02f, 3.40726338e-02f, -1.63203739e-02f,
  1.75157450e-02f, -2.29454879e-02f, -2.45707706e-02f, 6.69097379e-02f, 3.09857037e-02f, 9.29820612e-02f, -5.75067103e-02f, -5.42412279e-03f, -1.70245599e-02f, -2.82365978e-02f,
  -2.91792274e-01f, 9.81375352e-02f, -1.61129132e-01f, -1.07001066e-01f, -1.45009786e-01f, -5.76418489e-02f, -2.26569008e-02f, -7.27596208e-02f, -7.33684450e-02f, -9.43053234e-03f,
  1.34534566e-02f, -3.86885032e-02f, 5.11317626e-02f, -6.36431351e-02f, -1.61741465e-01f, 1.78040385e-01f, -3.88953164e-02f, -2.66930964e-02f, 6.46865368e-02f, -6.68470412e-02f,
  -2.58048400e-02f, 6.51865005e-02f, 3.97481443e-03f, 4.54951171e-03f, -1.22678451e-01f, -1.02379836e-01f, -7.36068413e-02f, 2.30329204e-02f, 1.01109054e-02f, -9.16483924e-02f,
  -2.12082520e-01f, -1.76537573e-01f, -1.13920040e-01f, -5.02236150e-02f, -6.38554618e-02f, -1.12588242e-01f, -8.22879374e-02f, 5.30378707e-02f, -5.37702516e-02f, -3.93255726e-02f,
  -7.19161779e-02f, -1.45366862e-02f, 6.20133011e-03f, 1.11677796e-01f, -3.45229171e-03f, -3.86133753e-02f, 3.77585851e-02f, -4.87484708e-02f, 6.78996220e-02f, 5.86756319e-02f,
  -1.42705068e-02f, -5.03991656e-02f, -4.11295220e-02f, 1.21778943e-01f, 2.19890736e-02f, 1.91051625e-02f, -2.94013284e-02f, -7.47742727e-02f, -1.16169252e-01f, -9.89604965e-02f,
  -3.04990634e-02f, 4.69073281e-02f, -3.72310095e-02f, -5.88806346e-03f, -6.58177957e-03f, 6.04676716e-02f, -6.43454269e-02f, 8.17742720e-02f, 2.24239733e-02f, -2.71221204e-03f,
  -6.12357445e-03f, 2.10095830e-02f, 4.42864895e-02f, -4.13377360e-02f, -7.69542977e-02f, -4.26274631e-03f, -5.27288252e-03f, -4.13347818e-02f, 7.00736418e-02f, -2.54275165e-02f,
  -5.36255576e-02f, 3.08141895e-02f, -2.33934838e-02f, 2.57020164e-02f, 2.19072439e-02f, 5.15943840e-02f, -3.66973020e-02f, -3.41320895e-02f, 2.09247805e-02f, -7.46917725e-02f,
  -1.87263355e-01f, -2.06894234e-01f, -6.97678700e-02f, -1.24835320e-01f, 1.64179374e-02f, -6.24663159e-02f, -2.52691526e-02f, 2.36319397e-02f, -4.81357984e-02f, -7.98686668e-02f,
  -3.90066989e-02f, 1.72132310e-02f, 3.32978251e-03f, -4.69588190e-02f, -7.87699297e-02f, -3.83975171e-03f, -1.03747584e-02f, -3.70745398e-02f, -4.51687314e-02f, -1.18390270e-01f,
  -5.67302071e-02f, 4.46591862e-02f, 8.44472945e-02f, -1.22666983e-02f, 2.60113440e-02f, -5.81936426e-02f, 3.41726765e-02f, 4.39617038e-02f, -9.45339128e-02f, 6.69563487e-02f,
  9.54536423e-02f, -7.29318559e-02f, 1.20884189e-02f, -5.28842618e-04f, -1.32303247e-02f, 7.71841481e-02f, 1.03169382e-01f, -1.84521656e-02f, 1.25213072e-01f, -7.58476779e-02f,
  -3.36636230e-02f, -1.04633920e-01f, 6.38663694e-02f, -6.00560270e-02f, 2.73310654e-02f, -4.43360582e-02f, 6.82063252e-02f, -1.17520474e-01f, -3.79945291e-03f, 4.62880805e-02f,
  3.64004783e-02f, -6.86910897e-02f, -7.96042234e-02f, -6.59783632e-02f, -9.50424820e-02f, 1.26513587e-02f, -1.04567282e-01f, -1.03592545e-01f, -1.26093119e-01f, -1.10590689e-01f,
  2.07991991e-02f, 6.88249245e-02f, -5.30311093e-02f, 2.43199673e-02f, -3.30662727e-02f, 5.27697317e-02f, -6.57108277e-02f, -3.34055573e-02f, 5.97269200e-02f, 3.45213301e-02f,
  -9.01082605e-02f, 4.56290320e-02f, 1.87263563e-02f, 2.05757730e-02f, 8.15537050e-02f, 5.09355739e-02f, -2.86802128e-02f, -1.91664824e-03f, -7.44410157e-02f, 7.11196885e-02f,
  -4.13712077e-02f, -1.10531272e-02f, 8.95935223e-02f, 5.60129434e-02f, 6.49807006e-02f, 3.00263744e-02f, -2.53171623e-02f, 4.36832793e-02f, 1.75497942e-02f, -5.30110225e-02f,
  5.58192702e-03f, -8.19387380e-03f, 1.05767988e-03f, 8.48859176e-02f, -6.07846640e-02f, 1.51963020e-02f, -5.01215719e-02f, 3.18683200e-02f, 2.54030991e-02f, 1.32457968e-02f,
  4.68645804e-03f, -7.14654401e-02f, 2.47167815e-02f, -7.63932094e-02f, 6.57821679e-03f, -3.69728729e-02f, -2.13833507e-02f, 3.25024314e-02f, 3.11807320e-02f, 1.11351544e-02f,
  -4.74265330e-02f, -4.01675962e-02f, -7.74010047e-02f, -7.21823871e-02f, 5.08865304e-02f, -9.02942494e-02f, -8.22131187e-02f, -7.77797550e-02f, 5.03111146e-02f, -9.11384448e-02f,
  -2.20859926e-02f, -8.90337154e-02f, -5.20807914e-02f, -8.47790986e-02f, -1.09112142e-02f, 4.58460152e-02f, -4.19755653e-02f, -3.15284170e-02f, -1.39441863e-02f, -5.73687302e-03f,
  -6.47298396e-02f, 4.87431735e-02f, 4.31693979e-02f, -7.37802265e-03f, 2.07317565e-02f, -1.14466287e-02f, -7.11328313e-02f, 8.51429999e-02f, 1.37570035e-02f, 5.49372509e-02f,
  -5.29333279e-02f, 4.71028760e-02f, 5.44018149e-02f, -6.37264550e-02f, -6.21028058e-02f, -4.39712182e-02f, 5.70098050e-02f, -9.57740098e-02f, -1.19143948e-01f, -5.76678403e-02f,
  2.87395939e-02f, -2.53748804e-01f, 5.60673559e-03f, 1.13718532e-01f, 1.56600788e-01f, -1.06323939e-02f, 1.99795160e-02f, -5.12262657e-02f, -1.32326275e-01f, -1.38379350e-01f,
  1.08658053e-01f, -6.44377945e-03f, 3.50331003e-03f, -1.06928749e-02f, 2.28677019e-01f, 6.74250647e-02f, -1.20474175e-01f, 9.79636889e-03f, 3.63238156e-02f, -3.65267098e-02f,
  -1.46470331e-02f, 3.07221543e-02f, 7.00552464e-02f, -1.15162745e-01f, 2.85134912e-02f, -9.13230032e-02f, 1.37221858e-01f, 4.87871990e-02f, 3.31596136e-02f, 1.14582889e-01f,
  -3.16252001e-02f, -5.98653331e-02f, -5.49689084e-02f, -1.10090442e-01f, -5.84937893e-02f, -8.73877704e-02f, 5.53870387e-02f, 8.87902975e-02f, -7.72076994e-02f, -2.24272180e-02f,
  -1.79485325e-02f, -1.85191091e-02f, -3.16926353e-02f, 1.12324469e-02f, -5.10719791e-02f, -2.67058648e-02f, -5.01669273e-02f, -5.04895374e-02f, 1.65251158e-02f, 5.29111177e-02f,
  -1.85991433e-02f, 3.15938555e-02f, 1.93166211e-02f, -5.09153381e-02f, 8.14870372e-02f, -7.83308297e-02f, -1.26345744e-02f, -3.66492234e-02f, -4.30841930e-02f, -1.10204145e-01f,
  5.85877411e-02f, -2.42825542e-02f, -3.02197188e-02f, 5.05164415e-02f, -5.78651503e-02f, 4.75664251e-02f, -2.66503114e-02f, -1.65130552e-02f, 3.69357616e-02f, 9.78214815e-02f,
  -8.81489590e-02f, 7.05749318e-02f, 4.44312952e-02f, -9.52383876e-03f, -9.67672281e-03f, 1.59200355e-02f, 4.39109877e-02f, 7.00777248e-02f, 6.99627623e-02f, 5.32183908e-02f,
  4.84373458e-02f, 2.76310872e-02f, 1.10652624e-02f, -9.36643779e-03f, 4.98146787e-02f, -9.54091921e-03f, 4.73112650e-02f, 2.26332434e-03f, 1.58323292e-02f, -3.11365854e-02f,
  -2.08899993e-02f, -1.22701958e-01f, -5.57528203e-03f, 3.13802361e-02f, -3.98649722e-02f, 4.30684537e-02f, -6.25625299e-03f, 1.84860658e-02f, 3.14368568e-02f, 3.14515047e-02f,
  6.32794425e-02f, 6.80403560e-02f, -1.25329727e-02f, -2.82954630e-02f, 4.31727506e-02f, 5.17943595e-03f, 8.47500935e-02f, 7.77196959e-02f, -3.38155478e-02f, 4.34525311e-02f,
  2.91519798e-02f, 1.93737261e-02f, -1.65619105e-02f, 4.08245139e-02f, 2.41139065e-02f, 7.42285252e-02f, -5.57271279e-02f, -7.91703835e-02f, 2.81690806e-02f, -1.55865243e-02f,
  -1.61131456e-01f, -4.03641500e-02f, 3.69104855e-02f, -1.22413665e-01f, -4.43237200e-02f, 1.07016243e-01f, 5.23589924e-02f, 7.99691752e-02f, -7.61969835e-02f, 1.25287235e-01f,
  8.67794827e-03f, 3.12955938e-02f, 8.05003345e-02f, -1.66618954e-02f, -7.86480606e-02f, 8.16830695e-02f, 5.69253266e-02f, 9.09938887e-02f, 2.43097488e-02f, -5.88719454e-03f,
  3.88761349e-02f, 3.48984054e-03f, -1.82856545e-02f, -2.79563311e-02f, -1.60304103e-02f, 3.43463346e-02f, -9.97012854e-02f, -2.70725545e-02f, 1.02282064e-02f, 2.31210366e-02f,
  -1.13410823e-01f, -6.46331012e-02f, 3.93510908e-02f, -5.89703098e-02f, 6.60228059e-02f, 1.18582137e-02f, 2.36196350e-02f, 7.01368600e-02f, 1.60972029e-02f, 1.50795626e-02f,
  -6.85062259e-02f, -8.50400552e-02f, 9.36780646e-02f, -2.29390394e-02f, 2.82002669e-02f, -1.61099155e-02f, 4.21191342e-02f, 8.53304416e-02f, -7.48221651e-02f, 1.03376852e-02f,
  1.09615680e-02f, 4.26874906e-02f, -1.89387007e-03f, 9.73029435e-02f, -1.40157351e-02f, -3.79246250e-02f, 4.13050242e-02f, 3.76316421e-02f, -8.59882683e-02f, -1.30995465e-02f,
  6.29353672e-02f, -2.66946778e-02f, -4.08479013e-02f, 7.79843479e-02f, -3.47572044e-02f, 8.07921216e-02f, -4.32151891e-02f, 3.11249048e-02f, 2.79221050e-02f, -4.58384007e-02f,
  -3.74069661e-02f, -1.50173455e-02f, 3.64591554e-02f, 2.63006445e-02f, -6.37221262e-02f, 8.11309144e-02f, 3.21892872e-02f, -8.70382413e-02f, 5.27527444e-02f, -8.82437453e-02f,
  -6.52501211e-02f, -4.27367538e-02f, -5.11774458e-02f, 4.21602614e-02f, -7.09454715e-02f, 8.22989643e-02f, 4.04548505e-03f, -8.71154591e-02f, -7.05937743e-02f, -1.67723708e-02f,
  -2.05306895e-02f, -1.16603315e-01f, -7.58455992e-02f, 6.57851691e-04f, -3.37110348e-02f, 2.45807343e-03f, 2.95440350e-02f, -7.00547993e-02f, -6.84696361e-02f, 8.67571607e-02f,
  -4.07159775e-02f, 7.93995112e-02f, 4.78313006e-02f, -6.08405471e-02f, 2.55917385e-02f, 5.48547171e-02f, -7.76826516e-02f, -8.09646472e-02f, -5.16810454e-02f, 8.72325301e-02f,
  1.59380045e-02f, -5.33139370e-02f, -4.48626466e-02f, 9.57576334e-02f, 1.17118191e-02f, 4.14404459e-02f, 1.15084127e-02f, -1.01889521e-02f, 1.64265633e-02f, -2.46387701e-02f,
  -1.60077304e-01f, 5.04702032e-02f, -2.74208393e-02f, -1.26328856e-01f, 8.84968862e-02f, 2.84713134e-02f, -5.55183850e-02f, 2.96544284e-02f, 6.48868009e-02f, -3.19543183e-02f,
  3.77460308e-02f, 1.35721648e-02f, 9.68609676e-02f, -6.19039387e-02f, -2.24379823e-02f, -1.40864216e-02f, -5.55359013e-02f, -1.09856345e-01f, 5.12550473e-02f, -6.64766803e-02f,
  -1.25153616e-01f, 5.31877764e-02f, -8.96700770e-02f, 6.60011126e-03f, 1.05344262e-02f, 3.41400318e-02f, -6.31475002e-02f, -3.01548690e-02f, 2.13701446e-02f, 4.73627523e-02f,
  -7.98480138e-02f, -7.89141804e-02f, -7.61165470e-02f, -1.97290946e-02f, 3.89006548e-02f, -3.01102046e-02f, -7.21543953e-02f, -8.16684961e-02f, 6.52369261e-02f, 2.48308014e-02f,
  -1.46508748e-02f, 5.74416406e-02f, 6.83652088e-02f, 7.69797117e-02f, -6.90195560e-02f, 1.71964373e-02f, -5.98382279e-02f, 2.97590997e-02f, 1.75535008e-02f, 4.05676253e-02f,
  -5.12023941e-02f, -3.61334831e-02f, -7.22725019e-02f, 4.83326949e-02f, -2.59747524e-02f, 7.61535689e-02f, -8.20945725e-02f, -1.07520871e-01f, -5.08223213e-02f, 5.82422763e-02f,
  6.42535985e-02f, 7.25924000e-02f, -5.14232367e-02f, 4.05112132e-02f, -5.89539409e-02f, -6.11874349e-02f, -4.93315309e-02f, -4.30895574e-02f, 5.31974621e-03f, -4.72320095e-02f,
  7.00178966e-02f, -8.40467140e-02f, -2.52774134e-02f, -5.67608848e-02f, 6.09731637e-02f, 5.90732396e-02f, -5.30722365e-02f, -1.55002885e-02f, 4.80012111e-02f, -6.35565594e-02f,
  7.86184669e-02f, -5.92093333e-04f, 3.38690057e-02f, -1.47646517e-02f, 7.27735385e-02f, 4.58650738e-02f, -6.33955700e-03f, 7.11122379e-02f, 3.25135328e-02f, 3.65855061e-02f,
  -9.89657417e-02f, -7.23531470e-02f, 3.78617458e-02f, 3.47475521e-02f, -6.92297742e-02f, -3.58921140e-02f, -2.53479332e-02f, -7.21386299e-02f, -2.91188080e-02f, -7.10613877e-02f,
  -2.66991090e-02f, 1.01372689e-01f, 5.54300547e-02f, 8.51485431e-02f, 8.49015713e-02f, 4.73179892e-02f, -1.20140724e-02f, -7.21146241e-02f, -1.94888674e-02f, 5.17893694e-02f,
  -9.25094588e-04f, 1.85599290e-02f, 3.31520960e-02f, -8.19821954e-02f, 3.54250632e-02f, 6.83833510e-02f, -6.08241521e-02f, 4.70675230e-02f, 6.98540583e-02f, -6.87799007e-02f,
  5.38602397e-02f, 1.30276410e-02f, 2.39940863e-02f, 1.02580123e-01f, -9.83111784e-02f, -3.13011080e-01f, -1.27139807e-01f, 6.09465353e-02f, 1.64672453e-02f, 5.07211648e-02f,
  9.23749730e-02f, 2.49290410e-02f, 1.65384442e-01f, 1.53373793e-01f, -9.48743448e-02f, 7.72198215e-02f, -1.19306318e-01f, -1.45805985e-01f, -7.89128011e-04f, 1.88307658e-01f,
  -4.15890850e-03f, 1.81395426e-01f, 8.69833753e-02f, 1.37985617e-01f, 1.19046494e-01f, 1.10305287e-01f, 1.14969648e-01f, 1.01222813e-01f, 1.79192331e-02f, 1.60546396e-02f,
  1.64769702e-02f, 4.10286598e-02f, -6.72523901e-02f, 6.98620752e-02f, -5.27192168e-02f, -6.52920827e-02f, 3.63844051e-03f, -4.57931086e-02f, 2.80586183e-02f, 4.04661931e-02f,
  -7.56052211e-02f, 3.14966738e-02f, 5.12753148e-03f, -2.59741619e-02f, 7.70487636e-02f, 1.99561403e-03f, -3.56960855e-02f, -4.86726277e-02f, -5.67052029e-02f, 1.43359946e-02f,
  1.53726591e-02f, 1.72424037e-02f, 5.19211739e-02f, -4.21510860e-02f, 3.85498838e-03f, -7.05863256e-03f, -5.36053218e-02f, -2.66423691e-02f, -5.55976108e-02f, -4.76450361e-02f,
  4.75402251e-02f, 3.39891054e-02f, 8.64230767e-02f, -3.91066168e-03f, 1.11579185e-03f, 5.99650405e-02f, -4.81162295e-02f, -4.79883254e-02f, -1.65910367e-03f, 7.07811536e-03f,
  5.45610227e-02f, 2.28259545e-02f, -3.18316482e-02f, 1.30187934e-02f, -3.99344787e-02f, -3.25570367e-02f, 8.12406838e-02f, 3.52605470e-02f, 3.68247362e-04f, -3.62584405e-02f,
  -3.72158773e-02f, 1.17740529e-02f, -3.90002094e-02f, 2.16194596e-02f, 8.19880068e-02f, 5.55204898e-02f, -2.14072298e-02f, 3.41894198e-03f, 3.93940173e-02f, -4.07937616e-02f,
  -6.48768619e-02f, 1.41255006e-01f, 3.15181650e-02f, -8.54258314e-02f, 1.88398901e-02f, -4.79812659e-02f, 1.17725774e-03f, 2.52003018e-02f, 4.07352783e-02f, -6.98511153e-02f,
  3.65408398e-02f, -1.37446329e-01f, 7.82175735e-02f, 9.04671326e-02f, 3.21471356e-02f, 5.16311824e-02f, 7.94763118e-02f, 2.26037409e-02f, 5.11816032e-02f, 1.87076817e-04f,
  3.25847901e-02f, -6.38985261e-02f, -2.40100306e-02f, -1.41064465e-01f, 2.87613999e-02f, 2.15344261e-02f, -3.38733867e-02f, -6.44208342e-02f, 1.15418923e-03f, -9.08378419e-03f,
  -1.20329082e-01f, -7.23029524e-02f, 9.12080854e-02f, 1.40893131e-01f, -6.68720752e-02f, -2.11559132e-01f, -1.91269711e-01f, -2.40257718e-02f, -1.03542671e-01f, -1.24320909e-01f,
  -2.29514260e-02f, 3.67109925e-02f, 4.28228006e-02f, 6.53058365e-02f, 2.12662533e-01f, 3.37565131e-02f, 2.22692508e-02f, 1.14427749e-02f, 1.67698115e-01f, 1.26754254e-01f,
  4.93273437e-02f, 1.44055441e-01f, 1.74459457e-01f, 9.24548507e-02f, -6.64627552e-02f, 7.62682185e-02f, 1.85629517e-01f, 1.47622572e-02f, -1.52775599e-02f, 2.40118708e-02f,
  -1.15501145e-02f, 1.63019344e-01f, 1.08826272e-02f, 5.83838634e-02f, 7.48203918e-02f, 5.18144332e-02f, -8.68287757e-02f, 1.49004906e-02f, 9.09762904e-02f, 5.45972772e-02f,
  -9.63196233e-02f, -5.21759801e-02f, 1.67419098e-03f, -3.74603085e-02f, 8.07132572e-03f, 6.32482395e-02f, 3.46502624e-02f, 5.47120050e-02f, -1.39567349e-02f, 5.21992557e-02f,
  5.72314532e-03f, -8.25347006e-02f, -7.05245361e-02f, 2.67863441e-02f, 9.66026410e-02f, -4.80964296e-02f, -6.27237782e-02f, 8.91156197e-02f, 5.88208325e-02f, 6.52238503e-02f,
  -7.29612187e-02f, -5.26073053e-02f, -3.84318233e-02f, -1.59820151e-02f, 6.22525290e-02f, 7.83905312e-02f, 4.22938615e-02f, 7.12316111e-02f, 3.61547768e-02f, 2.19659228e-02f,
  1.84308812e-02f, 5.63387871e-02f, -5.82774505e-02f, -4.06756029e-02f, 1.77008100e-02f, 4.72467393e-02f, -9.39605087e-02f, 4.10979614e-02f, 7.06715137e-02f, 6.53003994e-03f,
  7.21893013e-02f, -6.21200949e-02f, -6.02490641e-02f, 1.47714065e-02f, 2.07000542e-02f, -6.80883899e-02f, 3.11043416e-03f, 6.72327413e-04f, -7.75921792e-02f, -5.35473041e-02f,
  4.82596308e-02f, 1.19842581e-01f, 1.44691654e-02f, -6.90628737e-02f, -9.62544605e-03f, -6.26424104e-02f, -1.49731869e-02f, 5.95366545e-02f, 3.79560702e-02f, 3.06811668e-02f,
  -2.62588225e-02f, 6.02881648e-02f, 7.48221725e-02f, -4.80307341e-02f, -4.36089337e-02f, -2.84342188e-02f, 3.85622196e-02f, 3.34029756e-02f, -7.54750967e-02f, 8.34061131e-02f,
  -3.94087061e-02f, 1.63850263e-02f, 3.65860388e-02f, -7.05466941e-02f, 2.33619232e-02f, -2.81700250e-02f, -2.30115894e-02f, -4.68879901e-02f, 7.23215640e-02f, 3.71592157e-02f,
  2.66160637e-01f, -8.30388591e-02f, -5.08034602e-03f, 5.36534041e-02f, 2.02314854e-02f, 9.11269560e-02f, 7.46158659e-02f, -4.86519784e-02f, 5.56822531e-02f, -1.19748630e-01f,
  -6.48947284e-02f, -7.52604306e-02f, -3.94465774e-02f, -8.67647864e-03f, -5.35844676e-02f, -8.36661756e-02f, -2.47817282e-02f, 1.28589654e-02f, 1.05740145e-01f, 2.48642564e-02f,
  7.68231228e-02f, 1.40367031e-01f, -9.56053287e-02f, 6.49770275e-02f, 4.35423339e-03f, 3.08813676e-02f, -4.01888676e-02f, -4.72483747e-02f, -4.80268039e-02f, 2.78270971e-02f,
  1.05376586e-01f, -2.96758153e-02f, 5.74917123e-02f, 3.84215941e-03f, 5.91725670e-02f, -3.58654894e-02f, -1.71746127e-02f, 3.09021845e-02f, 6.60521537e-02f, 4.93096523e-02f,
  -1.30273059e-01f, -2.78664567e-02f, 8.36565271e-02f, -6.79678619e-02f, 8.42968673e-02f, 3.72581705e-02f, -5.60084917e-02f, -8.79484869e-04f, -1.03645101e-01f, 1.55735975e-02f,
  -3.34672630e-02f, 2.08900776e-02f, -3.91411595e-02f, 2.02393159e-02f, 3.54668610e-02f, -5.27185984e-02f, -3.15823220e-02f, -8.88054073e-02f, 2.92863641e-02f, -8.59314054e-02f,
  5.19989617e-02f, -7.42904842e-03f, 8.69352594e-02f, 5.38878888e-02f, -7.09019378e-02f, 7.59425759e-02f, 3.98874991e-02f, 3.54311918e-03f, 8.57291222e-02f, -2.94593032e-02f,
  6.13096915e-02f, 4.83005419e-02f, 4.62655686e-02f, -4.08410691e-02f, -2.04910263e-02f, -1.89753119e-02f, -5.19560575e-02f, 4.86275516e-02f, 1.63661372e-02f, -9.42328125e-02f,
  -7.60702044e-03f, 5.43618202e-03f, 6.30417019e-02f, 3.62689309e-02f, -3.98343913e-02f, 3.85565124e-02f, 3.67999673e-02f, -5.35716116e-02f, -5.09256758e-02f, -2.28840485e-02f,
  -3.58809344e-02f, 6.91356808e-02f, -5.71655435e-03f, 1.67867858e-02f, 4.73463759e-02f, 6.45707175e-02f, 7.95309097e-02f, 7.87145942e-02f, 9.12488848e-02f, 6.46534711e-02f,
  -7.00559840e-02f, 5.69433719e-03f, 5.37521206e-02f, -3.09078880e-02f, -6.96745217e-02f, 4.17889096e-03f, -6.18304685e-02f, -3.49614210e-02f, -3.57383154e-02f, -4.39325310e-02f,
  -6.76278397e-02f, -1.64481271e-02f, -2.41236296e-02f, 3.10600512e-02f, 3.82712074e-02f, -5.65126166e-02f, -7.00484440e-02f, 1.33121265e-02f, -3.34549509e-02f, 5.52107543e-02f,
  -2.17123330e-02f, -9.56271514e-02f, 8.79962295e-02f, -5.53419031e-02f, -4.90959473e-02f, -8.39855373e-02f, 3.29463109e-02f, -7.27140307e-02f, -1.12597488e-01f, -1.06661528e-01f,
  8.08269754e-02f, -1.58430487e-02f, 2.25235075e-02f, -2.54300982e-02f, 1.61140412e-01f, 8.91961344e-03f, -3.69119123e-02f, 5.26950918e-02f, -2.54901443e-02f, -8.84164199e-02f,
  6.76709041e-02f, -1.13079987e-01f, 1.03754029e-01f, 1.19840447e-02f, -2.20987890e-02f, -4.11870554e-02f, -4.86342050e-02f, 1.04064047e-01f, -4.16950881e-02f, 4.46009040e-02f,
  2.62067020e-02f, -8.84329975e-02f, 5.67078777e-02f, -7.60671347e-02f, 2.16620639e-02f, -2.96559166e-02f, 7.26406276e-02f, -5.65740801e-02f, -6.72125816e-02f, 5.55070974e-02f,
  -2.66742799e-02f, 1.67949323e-03f, 5.17648011e-02f, 7.80029371e-02f, 1.91416927e-02f, 1.99914407e-02f, 3.54527533e-02f, -7.24937320e-02f, -5.83047569e-02f, 2.38331333e-02f,
  -1.35117732e-02f, 4.88475151e-02f, -3.66599932e-02f, 4.29417454e-02f, 1.60278659e-02f, 3.03158797e-02f, 4.58841547e-02f, -6.11435696e-02f, -2.24928837e-02f, 4.02108282e-02f,
  -2.44601090e-02f, -1.36930961e-02f, -2.41012629e-02f, -5.76127693e-02f, -7.81494305e-02f, 7.53805414e-02f, -1.00259669e-02f, -5.76398894e-02f, -7.80678242e-02f, -6.28750175e-02f,
  -1.67075632e-04f, 6.53409064e-02f, 5.95986890e-03f, 1.10277710e-02f, 1.65408999e-02f, 5.29596731e-02f, -3.70387509e-02f, -3.09338942e-02f, 2.41224319e-02f, 8.14619884e-02f,
  -5.15857665e-03f, -3.25742848e-02f, -4.41652760e-02f, -4.06764448e-02f, 6.27621412e-02f, -5.84073970e-03f, -6.16534390e-02f, 6.56376407e-02f, 5.92661873e-02f, 1.00776188e-01f,
  4.94746864e-02f, 3.59997377e-02f, -9.33950394e-02f, -6.69879513e-03f, -8.67690668e-02f, 6.60403520e-02f, 5.39720394e-02f, -9.38207954e-02f, -4.29578573e-02f, 5.21602966e-02f,
  -4.69858795e-02f, -6.16678037e-02f, 5.33164367e-02f, -4.72875126e-02f, -6.55358136e-02f, 4.78003360e-02f, -6.54141083e-02f, 1.88989993e-02f, 2.56990008e-02f, -5.13497815e-02f,
  7.68662170e-02f, -7.34587312e-02f, 8.73505995e-02f, -9.14691836e-02f, 7.26331249e-02f, -1.14617366e-02f, 9.23597137e-04f, 5.35811409e-02f, -6.35567084e-02f, -6.90519661e-02f,
  -1.47029936e-01f, 6.66488893e-03f, -1.25391245e-01f, -1.20923705e-01f, 1.67698059e-02f, -1.48335189e-01f, -4.37060595e-02f, 6.81886151e-02f, 3.40847299e-02f, 4.10483927e-02f,
  4.11035977e-02f, -5.18048070e-02f, 1.33817211e-01f, -2.13680342e-02f, -4.41728309e-02f, 7.36257210e-02f, -1.28534093e-01f, 1.86125021e-02f, -6.23239987e-02f, -3.04393210e-02f,
  1.91856106e-03f, -8.41182694e-02f, -3.76641490e-02f, -2.93482989e-02f, -1.40996784e-01f, -8.03581849e-02f, 1.41462451e-02f, 1.54687501e-02f, 1.22600365e-02f, 3.87038738e-02f,
  -8.72036815e-02f, -1.07719481e-01f, -3.00340522e-02f, 7.32968897e-02f, -4.37180735e-02f, 5.60670830e-02f, -2.61587417e-03f, 5.41322306e-02f, 3.34244221e-02f, -7.23379105e-02f,
  -8.29576924e-02f, -8.38157684e-02f, -7.13917539e-02f, -7.16659278e-02f, -4.58494574e-02f, 4.46062209e-03f, -4.12817299e-02f, 2.19710525e-02f, -3.77376974e-02f, -4.56257578e-04f,
  4.88555469e-02f, -7.97838997e-03f, -6.75659105e-02f, 1.42275402e-02f, 9.01931450e-02f, 4.33646850e-02f, 2.53028851e-02f, 6.81057274e-02f, -2.98997648e-02f, -8.66595283e-02f,
  4.44602035e-02f, -1.50861237e-02f, -4.62477207e-02f, -1.35561349e-02f, 7.06153363e-02f, -1.41672278e-02f, 2.32738606e-03f, 5.20781390e-02f, 3.68249267e-02f, 4.76769060e-02f,
  5.88227995e-02f, 4.84736226e-02f, 9.82920174e-03f, -9.16243121e-02f, 3.15239020e-02f, -5.81244305e-02f, 8.94858167e-02f, 7.42196143e-02f, -1.01796463e-01f, 7.36040995e-02f,
  4.26939912e-02f, -3.23391706e-02f, 9.30576771e-02f, 1.50465444e-02f, 3.60995065e-03f, -2.26224903e-02f, 6.84703365e-02f, 5.71993738e-02f, 3.91842686e-02f, -6.04779758e-02f,
  -6.71778023e-02f, -1.67357400e-02f, -9.84295234e-02f, 4.86291945e-02f, -3.69940586e-02f, 6.89351978e-03f, -5.85821792e-02f, -8.26440230e-02f, 1.46686649e-02f, -3.83189432e-02f,
  9.29551292e-03f, 6.21577688e-02f, 1.74218118e-02f, -3.49815078e-02f, 9.38677881e-03f, -7.65527114e-02f, -8.56821146e-03f, -9.71873105e-02f, -9.82948542e-02f, -1.57197788e-02f,
  -2.66415644e-02f, -1.52775692e-02f, 1.17277587e-02f, -1.24340830e-02f, -2.06565373e-02f, 1.26039693e-02f, -1.72928572e-02f, -9.02452990e-02f, -6.14363663e-02f, -3.43311206e-02f,
  -3.76212507e-01f, 4.53312434e-02f, 1.78689644e-01f, -1.00201041e-01f, -8.64183158e-02f, 6.75317049e-02f, 5.25301695e-02f, 2.85878964e-02f, -1.55534940e-02f, 3.59998755e-02f,
  2.84660794e-02f, -1.15294084e-01f, 1.00837201e-01f, 7.50577226e-02f, -3.57825607e-02f, 1.71032578e-01f, 1.84971392e-02f, -2.66689528e-02f, 6.00306019e-02f, -1.21126249e-01f,
  -1.03028834e-01f, 7.09112138e-02f, 1.15428396e-01f, 1.20590873e-01f, -1.89126674e-02f, -1.03433833e-01f, -8.25227275e-02f, 3.70977372e-02f, -4.88343574e-02f, 2.87050307e-02f,
  -1.31367510e-02f, 7.50790387e-02f, 3.05347294e-02f, 2.19369736e-02f, 4.35561035e-03f, 1.99243091e-02f, 4.05352190e-03f, -7.30688646e-02f, 5.75003028e-02f, -2.44795717e-02f,
  -1.17478892e-02f, -5.44457138e-02f, -4.29756865e-02f, 1.25100404e-01f, 4.08460796e-02f, 4.56755571e-02f, -1.05272811e-02f, 4.76528220e-02f, 2.06013769e-02f, -6.95572887e-03f,
  7.24691376e-02f, 7.02628419e-02f, -2.09854450e-02f, -1.30277162e-03f, 2.73542069e-02f, 8.25728755e-03f, -6.12273216e-02f, -7.75504336e-02f, -5.17773256e-02f, 1.73251312e-02f,
  -1.76296383e-02f, 1.94304027e-02f, -5.48253581e-03f, -7.79836066e-03f, -3.06180548e-02f, 2.33867392e-02f, 5.84233180e-02f, -2.43817586e-02f, 2.67478973e-02f, -8.18078667e-02f,
  -9.10149515e-02f, -8.72613043e-02f, -6.73172027e-02f, 3.05182375e-02f, -5.74725941e-02f, -7.06728920e-02f, -1.77615825e-02f, 2.71863444e-03f, 7.53578469e-02f, -6.50431886e-02f,
  5.08697517e-02f, -1.20788971e-02f, 2.17727646e-02f, -3.09448354e-02f, -3.53394412e-02f, -1.70795433e-02f, -5.53982928e-02f, -7.10784048e-02f, -7.18690874e-03f, 2.99804229e-02f,
  -7.21909851e-02f, -1.71043705e-02f, 8.23133588e-02f, 1.38581488e-02f, -4.22214232e-02f, 6.97139278e-03f, -5.17455004e-02f, -1.60894077e-02f, 7.27719292e-02f, -6.50967807e-02f,
  -4.04999368e-02f, 5.53451572e-03f, -7.02485666e-02f, -3.08299828e-02f, -8.91923383e-02f, -5.41660488e-02f, 7.91664720e-02f, 1.22341532e-02f, -5.35194203e-02f, -9.55876485e-02f,
  -3.91052961e-02f, 2.51760948e-02f, 5.14470935e-02f, -2.25867350e-02f, -1.45467203e-02f, 7.04861060e-03f, -6.76351488e-02f, 7.12879747e-02f, -1.17090577e-03f, 1.17013650e-02f,
  -1.10999547e-01f, -6.91973343e-02f, 2.21219976e-02f, 5.35548925e-02f, 1.04822762e-01f, 6.44577518e-02f, 3.93657014e-02f, 8.13372247e-03f, -7.40099326e-02f, 6.71231672e-02f,
  5.78945018e-02f, 2.16430873e-02f, 5.72346523e-02f, 3.88839026e-03f, -7.91776255e-02f, -8.52056295e-02f, 4.04873341e-02f, -4.13177609e-02f, -7.10736886e-02f, -5.28923534e-02f,
  5.38424514e-02f, -1.45416688e-02f, -1.43387411e-02f, 9.80678871e-02f, -3.18655511e-03f, -2.87845172e-02f, 1.71440486e-02f, 4.12731282e-02f, -2.09494513e-02f, -4.09834720e-02f,
  5.25665991e-02f, -5.77980131e-02f, -1.65555794e-02f, -2.92920321e-02f, -6.85873702e-02f, -3.05560306e-02f, 6.28537610e-02f, -7.76424929e-02f, -2.34917235e-02f, 7.76489079e-02f,
  -9.10597593e-02f, 4.33673430e-03f, -1.29629755e-02f, 4.36574556e-02f, -7.71418661e-02f, -5.28980903e-02f, 2.16109324e-02f, 5.33031672e-03f, 8.23635831e-02f, -4.34056967e-02f,
  8.60453621e-02f, 6.66062953e-03f, -1.15040895e-02f, 4.11598235e-02f, -3.20349522e-02f, -2.85600498e-02f, -3.93058285e-02f, 8.89108703e-02f, -3.21261771e-02f, -8.57697576e-02f,
  3.81993217e-04f, -7.85361528e-02f, -1.00648098e-01f, 5.78203537e-02f, -7.12853670e-02f, 3.49636003e-02f, 4.46974821e-02f, 3.82910781e-02f, 4.99657616e-02f, 8.15258101e-02f,
  4.39448655e-03f, -4.74952161e-02f, -1.85287632e-02f, 6.30403385e-02f, 7.85022750e-02f, -7.27279559e-02f, -3.55377719e-02f, -2.54948922e-02f, 1.67452767e-02f, -4.74665090e-02f,
  -8.80412236e-02f, -2.62888391e-02f, -6.44473881e-02f, -4.95383106e-02f, -3.79605815e-02f, 7.42005929e-02f, -6.56112432e-02f, -1.36245796e-02f, -3.63873988e-02f, -8.31347480e-02f,
  -4.65354174e-02f, -6.52109273e-03f, 4.43306081e-02f, -9.17175561e-02f, 2.50487849e-02f, -8.28104317e-02f, -5.90753928e-02f, 3.28570567e-02f, 4.71706688e-02f, -8.56851935e-02f,
  -7.97112007e-03f, 9.36135743e-03f, -4.79598679e-02f, 4.39287163e-02f, 6.06030226e-02f, -8.28491971e-02f, 1.77212600e-02f, -5.00397198e-02f, -3.56810130e-02f, 8.71924013e-02f,
  -9.57237557e-02f, 1.30032497e-02f, 6.22959398e-02f, 3.45620885e-02f, -7.82840103e-02f, 3.00857276e-02f, 3.68347252e-03f, 5.41186705e-02f, 2.76733618e-02f, -8.09860304e-02f,
  1.73281897e-02f, -3.18156853e-02f, -1.35989264e-01f, -1.39278024e-01f, -1.31323712e-03f, -1.26180172e-01f, -2.56204996e-02f, -1.03636339e-01f, 1.50005585e-02f, 4.34464328e-02f,
  -2.40462255e-02f, -1.03150018e-01f, 8.11487958e-02f, -2.10840091e-01f, -6.54779896e-02f, -9.29052457e-02f, -7.53742605e-02f, -4.66528125e-02f, -4.24751155e-02f, -3.08867563e-02f,
  -6.47969320e-02f, -2.54385024e-02f, -1.52087390e-01f, 3.36387157e-02f, -1.91165179e-01f, 2.69026379e-03f, 9.02978331e-02f, -7.12505961e-03f, -2.84644328e-02f, -2.50965713e-05f,
  -3.09296902e-02f, -7.46446252e-02f, -4.83799726e-02f, -7.11257607e-02f, -4.60677184e-02f, 5.91280572e-02f, -3.99415568e-02f, 1.70457002e-03f, -1.66875385e-02f, 7.36104026e-02f,
  6.77271783e-02f, -5.14195301e-02f, -9.72787514e-02f, -5.32653229e-03f, -3.77424620e-02f, -6.92320019e-02f, -5.25355116e-02f, 9.69941076e-03f, -4.69220914e-02f, -5.55102713e-02f,
  4.21842374e-02f, 6.91557825e-02f, 4.33224216e-02f, -6.35394529e-02f, -7.18994141e-02f, 2.97055673e-02f, -4.62871157e-02f, -7.19085038e-02f, 4.23443876e-02f, 5.07567897e-02f,
  1.44586973e-02f, -5.78590482e-02f, -7.52907544e-02f, 5.19129112e-02f, -1.69282779e-04f, 2.10964084e-02f, 8.28677937e-02f, -9.53422952e-03f, 6.63094521e-02f, -3.72277312e-02f,
  -3.05130277e-02f, -6.25272766e-02f, 3.05101965e-02f, 2.19509029e-03f, -2.34267227e-02f, 2.38056649e-02f, 1.42625766e-02f, -7.81476311e-03f, -1.33376122e-02f, 4.74217795e-02f,
  5.24512306e-03f, -8.28666613e-02f, -2.54415236e-02f, 6.64835870e-02f, -5.36053702e-02f, 8.78736153e-02f, -6.69276044e-02f, -8.49409681e-03f, -2.74143629e-02f, 3.93757224e-02f,
  6.41880333e-02f, -3.96333672e-02f, -4.57217656e-02f, 1.22277299e-02f, 6.00553900e-02f, -3.51739069e-03f, 3.80613133e-02f, -3.08462214e-02f, 8.17370340e-02f, -4.62260954e-02f,
  -4.75425944e-02f, -5.89533560e-02f, 7.10953400e-02f, 4.62675542e-02f, -8.35475996e-02f, -7.60823190e-02f, -3.57024278e-03f, 9.15623531e-02f, 6.88690618e-02f, 3.53565626e-02f,
  -1.93902422e-02f, 2.53410302e-02f, -7.74891376e-02f, 6.26387168e-03f, 9.49757323e-02f, -5.56138949e-03f, 4.20834944e-02f, -6.06728764e-03f, -3.93963493e-02f, 4.58994769e-02f,
  -4.26084688e-03f, 2.14899965e-02f, 9.70281959e-02f, -3.35100330e-02f, 5.55769019e-02f, 5.35367690e-02f, -7.18884990e-02f, 5.41782156e-02f, -1.08110309e-01f, 2.53241044e-02f,
  -9.71049070e-04f, -6.59671202e-02f, 1.08794674e-01f, -6.29620925e-02f, 1.47011653e-02f, -1.92833524e-02f, 9.80685372e-03f, -4.27261693e-04f, 3.23258191e-02f, -1.35296155e-02f,
  -7.33511150e-02f, -6.68769032e-02f, 6.93495944e-02f, -6.25780374e-02f, -9.70018730e-02f, -5.40696718e-02f, -5.21429889e-02f, 5.08573987e-02f, 5.88973574e-02f, -8.32010359e-02f,
  -6.45897686e-02f, -4.07376215e-02f, 9.06670988e-02f, 3.66408774e-03f, -2.77361739e-02f, -1.56927072e-02f, -4.45615090e-02f, 3.45675088e-03f, -1.17049133e-02f, -1.59777571e-02f,
  1.94026232e-02f, 6.72434196e-02f, -8.14766735e-02f, 6.43457472e-02f, -4.23192941e-02f, 7.87208006e-02f, -5.74229211e-02f, 2.44624782e-02f, -4.04800735e-02f, -3.86469886e-02f,
  -5.03439605e-02f, -2.18275487e-02f, 5.52434288e-02f, 6.05020747e-02f, 3.57987508e-02f, 8.29831064e-02f, 6.32719994e-02f, 9.37542692e-02f, -3.15850154e-02f, 2.12213323e-02f,
  -8.06504488e-02f, 2.44549122e-02f, -8.57023075e-02f, -5.33358194e-02f, -3.31927352e-02f, -2.69130208e-02f, 3.08430977e-02f, -7.53378421e-02f, 3.37857008e-02f, 1.14997290e-01f,
  -7.93053508e-02f, -5.14104329e-02f, -6.21313378e-02f, 6.98720291e-02f, 5.78831509e-02f, 3.48246656e-02f, 6.45205304e-02f, 4.25665714e-02f, 4.29218337e-02f, -7.34559372e-02f,
  1.07834376e-02f, 1.35393869e-02f, 1.88033320e-02f, 1.89037453e-02f, 1.37685016e-02f, 9.07113105e-02f, 5.24874181e-02f, -6.22654259e-02f, -5.44220954e-02f, -6.05154373e-02f,
  -1.41076013e-01f, 3.56841413e-03f, -1.86934345e-03f, -3.87892202e-02f, 4.86936569e-02f, -3.79943438e-02f, 6.88733160e-02f, 2.94461232e-02f, 3.98249850e-02f, 7.61901140e-02f,
  4.08171825e-02f, -3.73596624e-02f, -5.70095778e-02f, 1.65057220e-02f, -2.41298825e-02f, 7.22582862e-02f, -1.03954915e-02f, -1.19929202e-02f, -7.66256228e-02f, -5.82936443e-02f,
  1.20665422e-02f, -6.12469614e-02f, 9.23524871e-02f, -1.97133347e-02f, -2.26955619e-02f, -3.90152335e-02f, -4.23408151e-02f, -4.80836406e-02f, 1.15034327e-01f, -1.69420969e-02f,
  3.76602039e-02f, -2.27455962e-02f, 1.72743395e-01f, 4.89678197e-02f, 3.20850573e-02f, 1.68173432e-01f, 9.29980651e-02f, 1.22370780e-01f, 1.21909201e-01f, -1.27616316e-01f,
  -7.44899213e-02f, -1.26523688e-01f, -1.81273744e-02f, -1.03649691e-01f, 9.31861401e-02f, 5.02194278e-02f, 3.79595347e-02f, -8.05377588e-02f, 7.16302171e-02f, -3.64181548e-02f,
  6.98285922e-02f, 5.70629630e-03f, -1.15821157e-02f, -2.14136094e-02f, -6.40929192e-02f, -1.05440423e-01f, -1.61409482e-01f, -5.69342487e-02f, -9.17004198e-02f, -5.65878488e-03f,
  -9.59984064e-02f, -4.21469398e-02f, -1.11419961e-01f, -2.62610316e-02f, -5.72003648e-02f, -3.57550308e-02f, -5.69317788e-02f, 3.34847644e-02f, -7.89913908e-02f, -1.56845096e-02f,
  -1.37978969e-02f, -2.14008614e-02f, -2.16001533e-02f, 4.57774010e-03f, 4.74810414e-02f, -4.99261878e-02f, -6.97828503e-03f, 4.05154116e-02f, -3.70243471e-03f, 5.19057177e-02f,
  -2.59827357e-03f, -2.81143673e-02f, -3.16504352e-02f, -7.42933303e-02f, -2.11494360e-02f, -5.39444946e-02f, -7.99570174e-04f, -3.52065871e-03f, -6.98037073e-02f, 1.36153596e-02f,
  2.76292227e-02f, 8.49850476e-03f, -3.76664586e-02f, -7.15996251e-02f, -1.86653715e-03f, 9.34716500e-03f, 4.92485724e-02f, -3.75755131e-02f, 7.24452883e-02f, -1.29070347e-02f,
  -2.27743201e-02f, -7.92347714e-02f, -1.59562100e-02f, -4.00072783e-02f, 1.00695640e-01f, 6.26791641e-02f, 5.31437248e-02f, -2.46938467e-02f, 1.67218130e-02f, -4.72550094e-02f,
  -4.85219695e-02f, -3.26718092e-02f, 3.66154648e-02f, 2.35686684e-03f, -5.64293675e-02f, 1.41870547e-02f, -4.68544886e-02f, -4.43651248e-03f, 3.58924903e-02f, -5.36946617e-02f,
  -5.67951053e-02f, 4.97497134e-02f, 7.41686439e-03f, 2.88840458e-02f, -4.44800742e-02f, -3.23466659e-02f, 1.16051571e-03f, -1.02782138e-01f, 1.23901162e-02f, -5.59719512e-04f,
  7.79108927e-02f, -1.30974334e-02f, 5.44015691e-02f, -2.14344207e-02f, 4.24889736e-02f, -2.68430766e-02f, 4.39802893e-02f, 4.67663035e-02f, -4.77947518e-02f, 1.15402229e-03f,
  -9.18524340e-02f, 7.70079121e-02f, 8.25786311e-03f, -6.31561726e-02f, 8.51846859e-03f, 2.94842161e-02f, -6.78062811e-02f, -9.30217505e-02f, 1.27114486e-02f, 4.81222197e-02f,
  -2.74429210e-02f, -1.87193513e-01f, -1.66807994e-02f, -8.79231244e-02f, -1.10378280e-01f, 3.42539549e-02f, -3.76744755e-02f, -1.55233532e-01f, -5.63296005e-02f, 1.75417643e-02f,
  -6.70078546e-02f, -1.07561693e-01f, 5.80003392e-03f, 6.61565661e-02f, 5.49892969e-02f, 1.58918351e-01f, -2.01270878e-02f, 8.20392221e-02f, -6.78140372e-02f, 1.42685426e-02f,
  -3.14962082e-02f, -3.29645500e-02f, -4.04093005e-02f, -2.51366328e-02f, -3.33442353e-02f, 3.98733132e-02f, -5.44600282e-03f, -4.41433210e-03f, -6.65287599e-02f, 1.81890223e-02f,
  -7.31875002e-02f, 1.13991424e-02f, -8.62369896e-04f, 9.76846218e-02f, 4.86814454e-02f, -7.63549516e-03f, 7.33467415e-02f, 1.52132288e-02f, 1.31385727e-02f, -7.16466904e-02f,
  4.74036187e-02f, -4.57922965e-02f, -4.41920012e-02f, -1.32196685e-02f, -6.57036304e-02f, -1.04498759e-01f, 3.07288487e-02f, -3.43927369e-02f, -4.18471657e-02f, 6.81759976e-03f,
  -5.14122359e-02f, -4.18748967e-02f, 5.05532809e-02f, 3.85765433e-02f, -5.08713648e-02f, -7.57833123e-02f, 1.11406734e-02f, 3.19983736e-02f, 5.91152394e-03f, 3.84265021e-03f,
  -7.65561908e-02f, 1.08580753e-01f, -2.47210823e-02f, 4.17172872e-02f, 6.61968533e-03f, 7.83784240e-02f, -6.57835901e-02f, 7.43553042e-02f, -5.69221564e-02f, -5.32907322e-02f,
  -1.37611628e-02f, -1.25205899e-02f, 2.86751762e-02f, -6.51724860e-02f, 1.75255835e-02f, 1.02762356e-01f, 7.89684355e-02f, 2.09261496e-02f, -1.04915191e-04f, 4.88090701e-02f,
  3.92066948e-02f, -2.46220492e-02f, 7.16252029e-02f, -6.98695183e-02f, -1.51747959e-02f, -6.38019368e-02f, -9.19907987e-02f, 6.37408672e-03f, 2.23894846e-02f, 4.05736417e-02f,
  -2.51509957e-02f, 2.95309648e-02f, 9.83419362e-04f, -8.18510428e-02f, -3.08222207e-03f, 6.46210834e-02f, 7.23431259e-02f, -2.90843602e-02f, 5.46942763e-02f, -6.48926124e-02f,
  8.95422697e-02f, 7.50571564e-02f, -3.14651150e-03f, 4.38968018e-02f, -4.18050289e-02f, -9.26969200e-02f, -5.79513982e-02f, 1.52140232e-02f, -7.00483471e-02f, -6.80808499e-02f,
  -7.79035687e-02f, -7.11134523e-02f, 5.89522049e-02f, -3.60058919e-02f, 1.01782253e-03f, -4.13093008e-02f, -1.47662479e-02f, 1.91002749e-02f, -2.68821996e-02f, -1.68779753e-02f,
  -7.73804188e-02f, -2.28313673e-02f, 4.40208726e-02f, 7.02706873e-02f, -1.51570402e-02f, -2.68100470e-01f, -2.03249365e-01f, 9.13694873e-02f, -3.69543657e-02f, -4.26596031e-02f,
  1.31971333e-02f, 7.14800656e-02f, 1.71918627e-02f, 7.10883662e-02f, 1.02603883e-01f, -5.01194037e-02f, 1.72402582e-03f, -9.66041908e-02f, 1.44911483e-01f, 1.12071134e-01f,
  5.96511401e-02f, -3.22545953e-02f, 4.50362414e-02f, -2.88519543e-02f, 3.38364355e-02f, 1.30313873e-01f, 1.85932517e-01f, -5.05357757e-02f, 6.78631216e-02f, -8.22140947e-02f,
  -7.30062649e-02f, 7.92103261e-03f, 2.88106065e-04f, -4.12629582e-02f, -5.60083077e-04f, -1.04547396e-01f, -5.73396916e-03f, -2.30110250e-02f, 1.06832527e-01f, 6.55671023e-03f,
  3.03112306e-02f, 8.31213444e-02f, 5.51358648e-02f, 4.10755053e-02f, -4.69493568e-02f, 3.12877074e-02f, -1.65654123e-02f, -5.04485257e-02f, 2.54651848e-02f, -6.71099573e-02f,
  8.72771516e-02f, -3.24603617e-02f, -5.91633357e-02f, 1.99118778e-02f, -2.08868340e-04f, 9.08087101e-03f, 2.83847027e-03f, -1.85467564e-02f, -1.16864610e-02f, 2.79763974e-02f,
  -6.34358823e-02f, 1.62250549e-02f, 9.11079049e-02f, 2.07070634e-03f, -9.00707170e-02f, -2.78006643e-02f, 4.66907136e-02f, 4.12111953e-02f, 8.51958841e-02f, 2.12038066e-02f,
  -7.41319954e-02f, 1.60927828e-02f, 4.98691723e-02f, -4.43219058e-02f, 6.56596422e-02f, -1.19425785e-02f, -1.04348147e-02f, -8.17091838e-02f, 2.99920235e-02f, -2.56750211e-02f,
  -5.30130416e-02f, 3.91443856e-02f, 7.74739310e-02f, -8.75002593e-02f, -1.06541244e-02f, 1.50081078e-02f, 2.34423131e-02f, 1.12611465e-02f, -4.99427803e-02f, -3.13920416e-02f,
  -2.71789599e-02f, 1.29776135e-01f, -8.47814754e-02f, 3.98153774e-02f, 3.75395045e-02f, -4.68020700e-02f, -3.10711446e-03f, -5.26408926e-02f, 4.44604270e-02f, -7.09228888e-02f,
  -4.94656451e-02f, 1.40616959e-02f, -2.32038163e-02f, 1.87980440e-02f, -4.11080057e-03f, -4.64815199e-02f, -1.61592476e-02f, 4.28686440e-02f, -4.71363515e-02f, 4.96150590e-02f,
  3.39961275e-02f, -4.80346903e-02f, -6.73002824e-02f, -2.88377460e-02f, 1.99448112e-02f, 4.63000908e-02f, -2.52024084e-02f, 7.50954002e-02f, -3.08303516e-02f, 3.65251936e-02f,
  -1.57410473e-01f, 5.58067448e-02f, 4.49796431e-02f, 1.07829675e-01f, -1.03950147e-02f, -2.13758871e-02f, -7.19024837e-02f, -5.88078685e-02f, 1.02004223e-01f, 5.82126714e-02f,
  -4.19692807e-02f, -9.38208774e-03f, 8.02576169e-02f, 9.48015004e-02f, 4.97145671e-03f, -2.81467941e-02f, -6.50298893e-02f, -2.22992711e-02f, 7.09961774e-03f, 2.23807748e-02f,
  4.91458066e-02f, 3.90610173e-02f, 4.65537980e-02f, 7.14503601e-02f, -2.72688530e-02f, -3.32772434e-02f, -6.87593967e-02f, -3.38101387e-02f, 5.94652183e-02f, 5.16001061e-02f,
  -5.37835024e-02f, 9.45396051e-02f, -1.19432164e-02f, -8.53395388e-02f, 6.78450568e-03f, -5.23572564e-02f, 3.84519771e-02f, -2.18813289e-02f, 4.84171510e-02f, -5.33559695e-02f,
  -2.00636089e-02f, 6.94246739e-02f, -3.89005952e-02f, 2.09955983e-02f, -5.52057661e-02f, 6.08408935e-02f, -9.44877416e-02f, 3.66272219e-02f, 6.53553903e-02f, -4.58830129e-03f,
  -8.16706419e-02f, -2.40756925e-02f, 8.35507140e-02f, -5.12137972e-02f, 4.66144532e-02f, -3.50488015e-02f, 4.83642593e-02f, 6.82692826e-02f, 1.03261374e-01f, -4.34644967e-02f,
  -1.02493465e-02f, 8.05277750e-02f, 7.11970497e-03f, 1.07954796e-02f, 5.94039150e-02f, 3.16690318e-02f, 2.30937228e-02f, 2.12276317e-02f, -3.95589918e-02f, 3.26903090e-02f,
  -5.14919125e-02f, 8.05460215e-02f, -6.76455796e-02f, -7.17064515e-02f, -1.73378568e-02f, 4.60001752e-02f, -9.61522460e-02f, 2.84774713e-02f, 6.77906275e-02f, -3.06313280e-02f,
  -1.40762120e-03f, -4.17772643e-02f, 8.02718103e-02f, 5.62475249e-02f, 6.10167123e-02f, -2.57489476e-02f, 1.02617070e-01f, 8.92389417e-02f, 9.16331038e-02f, -9.37857926e-02f,
  -2.87370961e-02f, 1.28173064e-02f, -8.44461173e-02f, 3.96635905e-02f, -2.19271006e-03f, -5.58366440e-02f, -4.02781405e-02f, -2.90260073e-02f, -2.92766164e-03f, 2.94727217e-02f,
  3.34790684e-02f, -4.36202474e-02f, -3.86950038e-02f, 7.52837723e-03f, -7.22574294e-02f, -1.96603108e-02f, 5.37742637e-02f, -5.69999814e-02f, -4.14286926e-02f, -3.62969674e-02f,
  7.61310235e-02f, 3.82548640e-03f, -6.54203668e-02f, -5.55310100e-02f, -4.21446264e-02f, -7.92506561e-02f, 6.68638796e-02f, 2.69365720e-02f, -6.39054626e-02f, 6.62785172e-02f,
  2.07357451e-01f, -1.72644686e-02f, 4.29398715e-02f, 6.80162013e-02f, -5.25072627e-02f, -2.72923578e-02f, 4.15189657e-03f, -3.27675752e-02f, -1.04859672e-01f, -2.68188231e-02f,
  5.15784696e-02f, -1.02482326e-01f, -7.53610358e-02f, 6.31086901e-02f, -1.71044301e-02f, 5.25841266e-02f, -1.94113553e-02f, 3.28623578e-02f, 8.44754353e-02f, -6.27518892e-02f,
  2.54084356e-02f, 8.76799375e-02f, 1.25695691e-01f, 5.02226353e-02f, -6.86894683e-03f, 1.09150276e-01f, -2.97079943e-02f, 4.23297025e-02f, 2.22505145e-02f, 2.38407757e-02f,
  9.90218967e-02f, -4.55649905e-02f, 7.36423442e-03f, -4.32219282e-02f, -5.30185737e-02f, 4.18006703e-02f, -8.65023903e-05f, 5.77688497e-03f, 1.44207533e-02f, -2.11623553e-02f,
  -2.31719017e-02f, -5.85724823e-02f, -4.19259779e-02f, 5.68939336e-02f, -9.39044170e-03f, 7.42509728e-03f, -1.38220163e-02f, -5.33121973e-02f, -4.92015108e-02f, -8.33692309e-03f,
  -3.53169963e-02f, -8.99789110e-02f, -6.90437183e-02f, 3.89023237e-02f, -1.58102158e-02f, -4.79235239e-02f, -2.79906485e-02f, -1.10854907e-02f, 6.85764551e-02f, -4.43388037e-02f,
  1.05250038e-01f, 3.95496227e-02f, 4.14423943e-02f, -1.77470278e-02f, 7.78030381e-02f, 2.67895926e-02f, 2.10895054e-02f, -9.28776935e-02f, 6.78839162e-02f, -1.15042888e-02f,
  -3.69841307e-02f, 2.65744831e-02f, -3.84580009e-02f, 3.76941636e-02f, 7.07825497e-02f, -5.58194891e-02f, -5.77157475e-02f, -8.04596022e-03f, 1.91873331e-02f, -1.53489402e-02f,
  -3.92313600e-02f, -3.97856869e-02f, 3.20491195e-02f, 6.34317696e-02f, 3.96579951e-02f, 3.63078937e-02f, -1.86795350e-02f, 8.53144675e-02f, 2.42801551e-02f, -2.43347045e-02f,
  -2.04601809e-02f, 9.06221867e-02f, 1.00388914e-01f, 1.51552008e-02f, 4.20980416e-02f, -4.96592605e-03f, 9.18455720e-02f, -3.75963971e-02f, 4.74817008e-02f, 5.36497869e-03f,
  1.61067154e-02f, -1.33358752e-02f, 2.13084631e-02f, -3.83993685e-02f, -4.16858569e-02f, -8.29568598e-03f, 6.17139088e-03f, 5.97856827e-02f, 5.46147004e-02f, 7.81365931e-02f,
  2.45157126e-02f, 3.24661694e-02f, -1.80761218e-02f, 1.99677888e-02f, 2.51383539e-02f, 2.21185144e-02f, 4.63142395e-02f, 2.91620884e-02f, 8.68054107e-02f, 2.02570148e-02f,
  1.74011420e-02f, -1.93351015e-01f, -9.01108161e-02f, 8.40553790e-02f, 1.35270670e-01f, 5.11744358e-02f, 5.22360131e-02f, -6.22369014e-02f, 9.42873012e-04f, -1.72067404e-01f,
  -3.70195098e-02f, -2.91636847e-02f, -1.21595263e-01f, 2.35028677e-02f, -1.26167620e-02f, -6.45406917e-02f, -2.32642703e-02f, 3.84523086e-02f, -8.66483375e-02f, 2.12599561e-02f,
  4.93524421e-04f, -1.09995138e-02f, -1.78225562e-02f, -5.63051142e-02f, 1.33115903e-01f, 1.54020246e-02f, 8.04044120e-03f, 5.19440800e-04f, 9.32903960e-02f, -2.32291277e-02f,
  -5.94824888e-02f, -4.02061306e-02f, 1.53386220e-02f, 4.39598188e-02f, -3.74026410e-02f, 5.88696487e-02f, 4.67608906e-02f, -1.74583327e-02f, 1.00817174e-01f, -3.15623060e-02f,
  -7.56401718e-02f, 3.27246785e-02f, -2.54575908e-02f, 7.85584897e-02f, -6.78491443e-02f, -2.20777020e-02f, -4.42489386e-02f, 2.21337080e-02f, 4.28346582e-02f, 1.56397931e-02f,
  -7.32335895e-02f, -5.81909865e-02f, 1.15467412e-02f, 3.09436787e-02f, -2.77314130e-02f, 5.02689406e-02f, -4.15543392e-02f, 1.83729585e-02f, 5.77522144e-02f, -2.84659062e-02f,
  -2.27317736e-02f, -2.67205704e-02f, 9.54957586e-03f, 1.70927131e-04f, -1.69328377e-02f, 1.01674736e-01f, 5.58462134e-03f, 7.35071376e-02f, 5.54706380e-02f, -2.83801053e-02f,
  3.76262851e-02f, -1.49429534e-02f, -9.64932740e-02f, 3.50567698e-02f, -2.51618288e-02f, 5.65799102e-02f, -5.81530146e-02f, -7.82023445e-02f, -7.30782598e-02f, 5.99415088e-03f,
  -3.66686061e-02f, 8.05679485e-02f, -6.22139946e-02f, 1.03879735e-01f, -2.46207090e-03f, -6.48325831e-02f, -3.38878706e-02f, 1.27749108e-02f, 5.69932275e-02f, -3.36394459e-02f,
  -9.17689055e-02f, -9.38721523e-02f, -1.02238782e-01f, 7.04324916e-02f, 4.36858349e-02f, -7.34454393e-02f, 3.72268744e-02f, 5.30214310e-02f, 2.38998719e-02f, 2.57943254e-02f,
  3.18826661e-02f, 1.74059197e-02f, -1.89137291e-02f, -3.77243720e-02f, 1.34325353e-02f, -3.95564847e-02f, 4.20073606e-02f, -8.63528054e-04f, -5.26080327e-03f, -4.46225107e-02f,
  -8.24021082e-03f, -4.63193208e-02f, -1.30115924e-02f, -4.39154208e-02f, -7.98277091e-03f, 3.29214521e-02f, -1.69039331e-02f, 8.66775587e-02f, -8.21746364e-02f, -5.12403026e-02f,
  -5.77281136e-03f, -4.56947573e-02f, -2.31712889e-02f, 6.42483085e-02f, -7.35561596e-04f, -1.02350749e-01f, -1.46779120e-01f, 1.61442794e-02f, -2.90666688e-02f, -6.35304376e-02f,
  -7.20029622e-02f, 6.53051808e-02f, 2.17122957e-02f, -1.78850740e-02f, 1.24797180e-01f, 6.83955848e-02f, 4.63527180e-02f, -8.02438334e-02f, -2.20123120e-02f, 5.72940037e-02f,
  -2.67202556e-02f, -5.40598705e-02f, 8.56059119e-02f, -2.93576624e-02f, -6.71553835e-02f, 7.00333416e-02f, 4.50893715e-02f, 2.09887829e-02f, 5.10145910e-02f, -2.07425980e-03f,
  -5.34770824e-02f, 4.16888259e-02f, 3.77087900e-03f, -9.13084224e-02f, 5.83445393e-02f, 6.09229393e-02f, -7.50356391e-02f, -6.91798180e-02f, 1.98891107e-02f, 1.62713956e-02f,
  -4.04179655e-03f, -5.96800521e-02f, -2.66828369e-02f, 2.52741370e-02f, -7.73325711e-02f, -3.87757607e-02f, 1.55407758e-02f, -4.69379872e-02f, 4.80251536e-02f, 1.07802581e-02f,
  -1.22199571e-02f, 9.43155959e-02f, 4.42505255e-02f, -3.62651795e-02f, 6.59523681e-02f, -6.45181090e-02f, -6.85714558e-02f, -1.95297543e-02f, 5.83568141e-02f, -2.58588474e-02f,
  3.96182910e-02f, -5.08755706e-02f, -6.98666424e-02f, -6.41113967e-02f, -3.75024602e-02f, 1.30167501e-02f, 2.88640875e-02f, 1.88701525e-02f, -4.41520587e-02f, -8.39512348e-02f,
  -3.52952653e-03f, -9.45006963e-03f, -1.84130378e-03f, 3.20348553e-02f, -4.57556099e-02f, -2.75481548e-02f, -1.09657405e-04f, 3.92079987e-02f, -6.28909320e-02f, 1.99533086e-02f,
  -7.99373463e-02f, 7.70084187e-02f, 2.71839853e-02f, 3.34484912e-02f, -6.84582144e-02f, -1.27430055e-02f, 3.77370976e-02f, -7.54946917e-02f, 5.19080386e-02f, -3.90948504e-02f,
  1.05246380e-02f, 2.58050133e-02f, -6.96058348e-02f, -5.12211658e-02f, 6.08692237e-04f, 4.36179165e-04f, 4.72675962e-03f, 1.05576050e-02f, 4.00099456e-02f, 4.76354919e-02f,
  -6.77814037e-02f, -5.26153669e-02f, -3.87911685e-02f, 3.25594805e-02f, -8.24417546e-03f, -5.57311624e-02f, 5.81317991e-02f, -6.68980777e-02f, 8.27429071e-02f, -5.78910783e-02f,
  4.83592786e-02f, -2.56408937e-02f, -1.07865585e-02f, 4.01358306e-02f, -9.18171369e-03f, -3.30932112e-03f, -2.22090865e-03f, 1.81933604e-02f, -5.12050539e-02f, 5.25831692e-02f,
  -9.27993208e-02f, 1.52492644e-02f, -5.15267961e-02f, -4.04821895e-02f, -7.15645999e-02f, -6.15571663e-02f, -1.21942528e-01f, -2.21850928e-02f, -2.69416291e-02f, 6.35358095e-02f,
  -7.53038004e-02f, -7.90448487e-02f, 4.47911620e-02f, -2.23033503e-02f, 5.08195944e-02f, -7.54677430e-02f, -8.25221315e-02f, -8.38427916e-02f, -9.02976003e-03f, 4.53778952e-02f,
  -3.81545760e-02f, -1.39970351e-02f, -6.49912134e-02f, -7.87301362e-02f, 3.04738190e-02f, -7.12162408e-04f, 6.65578293e-03f, -6.91701695e-02f, -3.71172875e-02f, -1.17641829e-01f,
  5.56883886e-02f, 4.31713462e-02f, -2.29432080e-02f, -3.29671316e-02f, 2.35379525e-02f, -7.11466372e-02f, 4.89755273e-02f, -5.80733828e-02f, 7.95986429e-02f, -3.65382172e-02f,
  -3.50091085e-02f, -8.10606405e-02f, -6.28812015e-02f, -8.41383170e-03f, -3.62702608e-02f, -3.06373872e-02f, -1.54402740e-02f, -3.26549597e-02f, 5.48923351e-02f, -3.27236354e-02f,
  1.93245464e-03f, 5.16401678e-02f, 3.70323062e-02f, 7.10592046e-02f, 2.90876348e-02f, 4.03363770e-03f, 1.07580628e-02f, -4.27982435e-02f, 7.08717853e-02f, 1.77006181e-02f,
  4.80492152e-02f, -7.12340921e-02f, 3.27783860e-02f, -3.59265208e-02f, -1.02420542e-02f, -4.17549536e-02f, -2.50555594e-02f, -5.32430150e-02f, -6.83260784e-02f, -9.33791399e-02f,
  -4.57035787e-02f, -4.10737805e-02f, 8.51127040e-03f, -9.65566467e-03f, -4.65019085e-02f, 4.57827039e-02f, -7.74152800e-02f, 4.21465598e-02f, -6.78177774e-02f, -6.55175671e-02f,
  5.59591986e-02f, -1.01361632e-01f, -4.10498772e-03f, -7.24901399e-03f, 4.76971865e-02f, -6.86749369e-02f, -2.20980253e-02f, -6.57956973e-02f, 9.59705338e-02f, 3.56233530e-02f,
  7.45941550e-02f, 6.11775592e-02f, 2.30981316e-02f, 1.80503055e-02f, -4.64694202e-02f, 7.67200664e-02f, 7.80657381e-02f, -8.61568749e-02f, 3.93595137e-02f, -8.43904093e-02f,
  1.94284767e-02f, 3.57736498e-02f, -4.29240465e-02f, 7.73332417e-02f, 8.05651769e-02f, -4.11284827e-02f, -7.17489943e-02f, 7.72761367e-03f, 6.51076511e-02f, 7.95474499e-02f,
  6.23015352e-02f, -2.15673521e-02f, -1.73517335e-02f, -1.66263692e-02f, 5.22391498e-02f, 3.28142308e-02f, 3.67037207e-02f, -1.69409206e-03f, 8.19602609e-02f, -4.03800495e-02f,
  3.96494791e-02f, -1.46693699e-02f, 4.89561781e-02f, -8.87898952e-02f, -8.10346752e-02f, -5.78975454e-02f, -6.71556368e-02f, -7.11510405e-02f, 9.77542549e-02f, -4.98449244e-02f,
  6.57714084e-02f, -4.38027792e-02f, -8.04819912e-02f, -7.94683248e-02f, -4.21616547e-02f, -7.12717650e-03f, -9.80577990e-02f, 6.34462684e-02f, 9.49264616e-02f, -9.13585350e-02f,
  3.91259380e-02f, -1.34764209e-01f, -5.94954416e-02f, -4.34929244e-02f, 5.54592796e-02f, -9.40509960e-02f, -3.91592383e-02f, 5.74829206e-02f, -1.21766910e-01f, 5.89259341e-02f,
  1.77125074e-02f, -8.01740400e-03f, 6.11710846e-02f, 1.10100351e-01f, 9.43772271e-02f, 3.88544314e-02f, -1.91551503e-02f, -6.76986650e-02f, -6.58119395e-02f, 7.60273188e-02f,
  -7.32885301e-02f, 5.45665137e-02f, -3.84538099e-02f, -4.12284629e-03f, -2.32910719e-02f, -1.43780550e-02f, -7.16792643e-02f, -3.88284661e-02f, -3.71039063e-02f, 5.83620444e-02f,
  1.04725689e-01f, 9.84682739e-02f, 5.16883750e-03f, -4.29754667e-02f, -3.51722911e-02f, 7.61042535e-02f, -3.81635837e-02f, -5.42565882e-02f, 2.26444192e-02f, -6.90277340e-03f,
  -7.48538822e-02f, -6.13411106e-02f, 5.77098913e-02f, -2.19881702e-02f, 1.05048291e-01f, -5.87544478e-02f, -4.31776308e-02f, 7.66376927e-02f, -3.21409963e-02f, -3.12269703e-02f,
  3.93266752e-02f, 3.40676643e-02f, -3.15552875e-02f, 2.62326412e-02f, -7.16471002e-02f, -8.66160616e-02f, -3.71016301e-02f, -4.16880585e-02f, 5.66967800e-02f, 6.98381141e-02f,
  -2.17357874e-02f, 2.47971341e-02f, 3.65648270e-02f, 6.07780889e-02f, 3.64489257e-02f, 6.62220046e-02f, -5.12152463e-02f, 1.98200047e-02f, -7.01047331e-02f, 1.09737776e-02f,
  9.08857659e-02f, -5.82741154e-03f, 3.17155980e-02f, 3.29740159e-02f, -3.41766700e-02f, 3.71825807e-02f, 5.26357628e-02f, 6.78251758e-02f, -6.39138594e-02f, 8.01964663e-03f,
  1.92883220e-02f, 7.48150749e-03f, 5.81835844e-02f, 1.04536358e-02f, 6.17683232e-02f, 1.78307313e-02f, 1.52485818e-02f, -2.90231984e-02f, 2.98279561e-02f, -4.37944802e-03f,
  4.94597405e-02f, -2.81196479e-02f, 8.80859196e-02f, -1.48384236e-02f, 1.94093883e-02f, 6.07136823e-02f, 2.67284326e-02f, 7.76508152e-02f, -1.32151721e-02f, 5.49369156e-02f,
  -1.09793782e-01f, -4.29767370e-02f, 1.91157728e-01f, -1.01119742e-01f, -3.75741012e-02f, 1.03209890e-01f, -5.00951894e-02f, 8.57536718e-02f, 1.21666707e-01f, 7.49381408e-02f,
  -2.27047652e-02f, -1.64020415e-02f, 5.65189235e-02f, -3.94078232e-02f, 2.38890182e-02f, 3.99203748e-02f, -1.23479711e-02f, -9.68170911e-02f, -2.79607009e-02f, -2.08084043e-02f,
  -1.12287045e-01f, -2.36911122e-02f, 1.88587215e-02f, -3.78318615e-02f, 3.99078466e-02f, 5.24979606e-02f, -7.59740127e-03f, 1.92663595e-02f, -6.50969893e-03f, -2.78632808e-02f,
  1.67187266e-02f, -7.39785582e-02f, 1.09990180e-01f, 7.48244673e-02f, 2.89196838e-02f, -2.58333851e-02f, -4.43277210e-02f, 3.67828421e-02f, 6.51008710e-02f, 1.17085293e-01f,
  -1.08968422e-01f, 8.08164328e-02f, -5.56994937e-02f, 2.20081992e-02f, -2.93379463e-02f, 1.04481407e-01f, 7.17093870e-02f, 2.08631493e-02f, 9.91448686e-02f, 8.04012343e-02f,
  -2.88705006e-02f, 8.83161873e-02f, 7.30280590e-04f, 2.26987600e-02f, 3.43973935e-02f, -2.92616384e-03f, -3.47088501e-02f, -1.26527682e-01f, -7.79892057e-02f, -7.92362541e-03f,
  -2.38127261e-03f, 4.24138121e-02f, -5.84034435e-02f, 6.47241101e-02f, -3.32682906e-03f, -7.31912702e-02f, 1.24700870e-02f, -4.45060804e-02f, 1.11732894e-04f, -2.00742241e-02f,
  5.92637770e-02f, 3.02526485e-02f, -5.99992648e-02f, -6.92963898e-02f, 7.54044065e-03f, -8.28121826e-02f, 4.01136093e-02f, 6.60415292e-02f, 6.05155621e-03f, 3.80398072e-02f,
  9.45061743e-02f, 6.76023066e-02f, -1.04253635e-01f, 3.98758054e-03f, -4.50967178e-02f, -7.55220931e-03f, -4.71831718e-03f, 2.53479872e-02f, -7.40714371e-04f, -7.22899884e-02f,
  -1.14958063e-01f, -3.25713903e-02f, -5.79899289e-02f, 5.13727218e-02f, 4.29250970e-02f, 7.02118278e-02f, -5.20573407e-02f, 3.67575102e-02f, -4.36544381e-02f, -5.99834099e-02f,
  -7.29892254e-02f, -5.27779609e-02f, 4.01529372e-02f, 5.80763184e-02f, -3.45919132e-02f, -2.19431091e-02f, -1.04044698e-01f, -2.16010977e-02f, -3.77830630e-03f, -5.35549931e-02f,
  -6.93489760e-02f, 7.87961259e-02f, -6.41900674e-02f, 6.51038960e-02f, -5.06961159e-02f, -7.93652982e-02f, -6.18094057e-02f, 4.15212065e-02f, -4.55348752e-02f, 6.14714399e-02f,
  9.41291749e-02f, -1.37461320e-01f, -8.84808078e-02f, 6.38093799e-02f, -2.51504034e-02f, -2.05537587e-01f, -9.98157337e-02f, 1.76626779e-02f, -9.31826681e-02f, -1.79520920e-01f,
  9.65359211e-02f, -5.87635972e-02f, -1.61225140e-01f, 2.00436130e-01f, 2.18201846e-01f, -8.63551050e-02f, 1.70902386e-01f, 6.23190887e-02f, -4.83504608e-02f, 4.37078206e-03f,
  6.48591071e-02f, 2.43333697e-01f, 1.55450553e-01f, 6.30725697e-02f, 4.20209207e-02f, 1.97472926e-02f, 2.14662388e-01f, -9.69146416e-02f, 1.99306414e-01f, 1.48866534e-01f,
  9.12845042e-03f, -6.11863844e-03f, -2.12235656e-02f, 1.65323485e-02f, 9.06625413e-04f, -2.97139212e-02f, -5.01348190e-02f, -6.36791438e-03f, -4.34112689e-03f, -1.23150162e-02f,
  3.33888154e-03f, 1.92218795e-02f, -9.85595863e-03f, -1.50686689e-02f, -2.28875931e-02f, -5.24606332e-02f, 5.32196946e-02f, -4.74074446e-02f, -2.84302663e-02f, 7.82677531e-02f,
  -1.64861977e-02f, -2.58866958e-02f, 1.68050919e-02f, 1.97234526e-02f, -5.13395295e-02f, 1.60489883e-02f, -4.74890992e-02f, -4.97290902e-02f, 5.37306443e-02f, -1.50696945e-03f,
  2.01588646e-02f, 4.00795117e-02f, -9.75458845e-02f, 4.05807095e-03f, 5.25808036e-02f, -6.70069158e-02f, -7.99212828e-02f, 6.47133496e-03f, 2.52131745e-02f, 5.09475321e-02f,
  1.79361738e-02f, 3.00755892e-02f, -2.43205838e-02f, 6.96612671e-02f, -4.45114784e-02f, -6.98718723e-05f, 8.90168827e-03f, 7.41072595e-02f, 1.65417651e-03f, -4.90869470e-02f,
  -4.94554564e-02f, 8.99619609e-02f, -4.79450114e-02f, 2.17659064e-02f, -6.29863739e-02f, 5.48260063e-02f, 7.36926571e-02f, 1.94204208e-02f, -3.36779095e-02f, 6.81830058e-03f,
  1.50635438e-02f, 5.53991981e-02f, -5.77150173e-02f, -5.77128977e-02f, -3.03636249e-02f, -2.96687577e-02f, -2.75225844e-02f, 5.19650169e-02f, -9.96996183e-03f, 3.42289396e-02f,
  4.08367394e-03f, -3.72166447e-02f, -2.66372766e-02f, 2.87591014e-02f, -1.89442802e-02f, 4.58807833e-02f, -3.60025540e-02f, -2.86565758e-02f, 9.23446044e-02f, 7.43945315e-02f,
  6.20548017e-02f, 4.32173200e-02f, 4.79376465e-02f, -2.22564638e-02f, -3.93062979e-02f, -5.64943664e-02f, -2.70479042e-02f, -2.50794515e-02f, -2.95507219e-02f, 8.56853276e-03f,
  2.06333511e-02f, -2.79297470e-04f, 4.78778370e-02f, -5.18529937e-02f, -2.01884843e-02f, 5.25557026e-02f, -1.50280725e-02f, 1.07930407e-01f, 4.25158888e-02f, -3.51574197e-02f,
  -8.46884921e-02f, -4.12903465e-02f, -8.76121968e-02f, 5.72734745e-03f, 1.33424141e-02f, -5.55675887e-02f, -3.27468514e-02f, 6.73129037e-02f, 9.37381685e-02f, 5.79958893e-02f,
  -2.54182722e-02f, 5.57501754e-03f, 3.84837240e-02f, 3.61281969e-02f, -2.64713913e-02f, -5.35639049e-03f, -9.51573700e-02f, -3.03706657e-02f, -4.70481105e-02f, -1.37854209e-02f,
  -4.99579124e-03f, -2.01375093e-02f, 6.98953122e-02f, -1.04272582e-01f, 5.67084178e-02f, 3.21955942e-02f, -1.55513175e-03f, -8.50459412e-02f, 3.43242586e-02f, -6.32505566e-02f,
  -2.40990464e-02f, -4.37351083e-03f, 6.34491518e-02f, -4.39357385e-02f, 1.33928340e-02f, 2.79399641e-02f, -3.44118886e-02f, 4.28069048e-02f, -2.82872356e-02f, 1.97180193e-02f,
  6.49398640e-02f, -1.81905273e-02f, -4.06665690e-02f, -3.65385935e-02f, 7.23088011e-02f, -7.80613199e-02f, 6.45241737e-02f, -4.46094107e-03f, 5.91489412e-02f, 1.20763220e-02f,
  7.79848620e-02f, -1.50905233e-02f, 6.23070076e-02f, 4.80734818e-02f, -6.82386905e-02f, -4.84791435e-02f, -3.54922377e-02f, 5.65938130e-02f, 6.18433319e-02f, 8.95394459e-02f,
  -5.55498265e-02f, 3.84529978e-02f, -3.24317366e-02f, -9.46449637e-02f, -4.08493541e-02f, 2.71538664e-02f, 4.19652648e-02f, -4.24457081e-02f, 7.30360374e-02f, 5.35700880e-02f,
  2.55437307e-02f, -4.02918421e-02f, 2.32773833e-02f, -1.50655638e-02f, 2.31276769e-02f, -5.50428294e-02f, -9.10681020e-03f, 5.90758994e-02f, 7.59076998e-02f, -1.01884268e-02f,
  2.02541128e-02f, -4.63066734e-02f, -5.44046536e-02f, 8.16796944e-02f, 5.20569198e-02f, -6.09487370e-02f, 2.42413655e-02f, 4.34043966e-02f, -2.51636095e-02f, 8.13829061e-03f,
  6.87156944e-03f, -5.06713875e-02f, 2.42751502e-02f, -2.25909352e-02f, 7.10457191e-02f, -7.79851303e-02f, 4.14051227e-02f, -3.43788713e-02f, -2.80185509e-02f, 2.30982993e-02f,
  -1.08204782e-02f, 3.19170463e-03f, 6.51065558e-02f, 1.18323449e-04f, 8.83078799e-02f, 2.45826077e-02f, -4.14651856e-02f, 1.09227253e-02f, -2.13965736e-02f, 6.79605305e-02f,
  9.14813504e-02f, -1.05454393e-01f, 9.54605043e-02f, 7.29956701e-02f, 1.12871744e-01f, 6.48375088e-03f, 1.01773605e-01f, -6.47736713e-02f, 1.35462075e-01f, -1.26660585e-01f,
  -4.68655229e-02f, -2.82065914e-04f, -5.28904423e-03f, 2.73323152e-02f, 1.08776428e-01f, -6.08016178e-02f, -3.71056311e-02f, 7.60890320e-02f, 3.88240702e-02f, 1.48805846e-02f,
  -3.38805877e-02f, 6.13747686e-02f, 3.55903320e-02f, -3.87526304e-02f, -4.19319943e-02f, 3.52724642e-02f, 4.04199911e-03f, 4.83080596e-02f, -1.00170314e-01f, -1.19580694e-01f,
  -3.95360589e-02f, -8.10346156e-02f, -2.87118908e-02f, -1.59657393e-02f, 9.66033489e-02f, -1.21048592e-01f, 7.37772090e-03f, -5.93631640e-02f, -5.21579050e-02f, -6.82063177e-02f,
  9.84208658e-02f, -6.97631016e-02f, -4.54061627e-02f, 8.19110647e-02f, -2.56261043e-03f, -2.13858578e-02f, -2.79616419e-04f, -3.69643643e-02f, -2.04761438e-02f, -7.16443434e-02f,
  3.65409143e-02f, -4.95120175e-02f, 4.86171916e-02f, -6.73069730e-02f, -6.80362200e-03f, -7.97224492e-02f, 3.62660736e-02f, -5.74183725e-02f, 1.84540972e-02f, 5.16761728e-02f,
  -1.01893125e-02f, 3.15223411e-02f, 6.39889613e-02f, 6.22550435e-02f, 9.00078043e-02f, 1.38640394e-02f, 4.02458571e-02f, -5.04970886e-02f, -3.64865782e-03f, -1.57367103e-02f,
  7.61040226e-02f, -8.15454647e-02f, 2.31400970e-02f, 2.20355876e-02f, -4.55372073e-02f, -2.30082008e-03f, 4.77575958e-02f, 3.53886522e-02f, 5.36120459e-02f, 5.03208749e-02f,
  3.29323076e-02f, 6.80934861e-02f, 2.50332244e-02f, -6.78978786e-02f, 5.35701029e-02f, 5.45973107e-02f, 4.96195294e-02f, -4.62688133e-02f, 3.97181250e-02f, 4.97149341e-02f,
  5.05055934e-02f, -3.18314321e-02f, 8.56933650e-03f, -3.78705785e-02f, -1.56783201e-02f, -5.65109141e-02f, -7.92073086e-02f, -8.12786818e-03f, -8.83325860e-02f, -4.46033701e-02f,
  3.10803391e-02f, 5.62972017e-02f, -7.59858033e-03f, -5.19991927e-02f, -9.07062963e-02f, -6.93409890e-02f, 8.13983195e-03f, -3.08418274e-02f, -4.28339541e-02f, 6.27571940e-02f,
  -5.29401377e-02f, -3.72610092e-02f, -1.11252517e-02f, 1.82329665e-03f, 2.58793011e-02f, 2.30500940e-02f, -1.27169993e-02f, -1.17091974e-02f, -1.27582215e-02f, -2.14726999e-02f,
  -3.39775123e-02f, 7.31716082e-02f, 8.10823068e-02f, 3.69974710e-02f, -5.41317835e-02f, 2.46960651e-02f, -8.13037306e-02f, -7.90754333e-02f, -2.97039468e-02f, -4.86598276e-02f,
  -1.16354767e-02f, -3.32189649e-02f, 3.89911495e-02f, -7.94717763e-03f, 1.23166926e-01f, 1.37018546e-01f, -9.12893284e-03f, -5.09305038e-02f, 8.63344595e-02f, -5.58968671e-02f,
  1.14386663e-01f, 5.68691082e-03f, 5.05027138e-02f, -1.03258938e-02f, -9.02448408e-03f, -1.83501188e-02f, 3.14480327e-02f, 3.88059095e-02f, 1.57740631e-03f, 3.97387184e-02f,
  -9.40170661e-02f, -8.69278759e-02f, -5.00237234e-02f, 6.69739917e-02f, -7.61588514e-02f, 4.38249037e-02f, 7.87851736e-02f, 3.75208408e-02f, -5.10339998e-02f, -2.49423087e-02f,
  8.85344949e-03f, -3.34784910e-02f, 5.39840087e-02f, 1.30794048e-02f, -9.10160169e-02f, -1.99648570e-02f, -2.08713729e-02f, 2.79712453e-02f, 2.55489163e-03f, -8.62365365e-02f,
  5.74311763e-02f, 8.48897845e-02f, 2.87120771e-02f, 1.17647434e-02f, 9.17357802e-02f, -3.21011581e-02f, -3.91484648e-02f, 8.93742405e-03f, 5.46388067e-02f, -7.96173438e-02f,
  8.29521269e-02f, 1.62547212e-02f, 3.92302684e-02f, 1.65341850e-02f, 5.22241332e-02f, 6.22271560e-02f, 4.49868515e-02f, 2.60213204e-02f, 2.87722005e-03f, -5.47659816e-04f,
  9.42843929e-02f, 6.32315874e-02f, 4.20014448e-02f, 2.46847160e-02f, 5.22108451e-02f, 4.34258543e-02f, -4.91909422e-02f, 5.27093634e-02f, -6.40015081e-02f, -4.97017317e-02f,
  6.78213984e-02f, -1.23184202e-02f, -7.41875032e-04f, -3.86714302e-02f, 1.18718231e-02f, -5.31035513e-02f, 5.18354587e-02f, -4.78315428e-02f, 2.90782321e-02f, 7.19103888e-02f,
  4.28650156e-02f, 5.11526305e-04f, 1.46130957e-02f, -1.02205556e-02f, -7.28249699e-02f, -6.50596246e-02f, 3.20830848e-03f, 5.53553067e-02f, 2.51578819e-02f, 5.66090122e-02f,
  2.91031599e-02f, -9.51571018e-02f, -9.62835848e-02f, 4.04863693e-02f, 5.88731281e-02f, 4.44521271e-02f, -8.65641236e-02f, 3.77093535e-03f, -2.02371497e-02f, -1.34197995e-02f,
  -7.11635500e-02f, -5.88398911e-02f, -9.43920985e-02f, -2.00999845e-02f, 6.25560209e-02f, -8.93789083e-02f, -5.60710430e-02f, -4.66143787e-02f, 5.67208184e-03f, -8.79744962e-02f,
  1.00253550e-02f, 6.57065287e-02f, -1.11171089e-01f, -1.86625775e-02f, 5.29281981e-02f, -1.46319922e-02f, -2.45362651e-02f, 5.26231006e-02f, 5.09543978e-02f, 8.98869559e-02f,
  5.51122017e-02f, 2.69696433e-02f, 8.23114589e-02f, 7.09828436e-02f, -4.74753976e-03f, -6.78669885e-02f, 6.56276122e-02f, 9.74233449e-02f, -7.37569481e-02f, -1.84425327e-03f,
  -6.94011673e-02f, -1.07408613e-02f, -1.92520358e-02f, -4.41827578e-03f, -6.75919652e-02f, -9.01849270e-02f, -2.58251801e-02f, 9.78710279e-02f, 1.00106604e-01f, -5.88643178e-03f,
  4.27103601e-03f, 9.12171975e-02f, -8.96739364e-02f, -5.01225656e-03f, 7.53736049e-02f, 6.91002533e-02f, 2.37532798e-02f, 3.16446647e-02f, -5.29535450e-02f, 1.82141420e-02f,
  -7.95047507e-02f, -7.17673600e-02f, -2.97101438e-02f, 3.86791453e-02f, 9.01037902e-02f, 4.64061499e-02f, -6.05135188e-02f, -7.77886286e-02f, 8.40370059e-02f, -6.81953505e-03f,
  8.27856362e-02f, -9.22157690e-02f, -2.46986151e-02f, -2.50780284e-02f, -6.99909963e-03f, -3.38951200e-02f, -2.14765668e-02f, -7.35553578e-02f, -5.51462211e-02f, -2.16273461e-02f,
  2.31383704e-02f, -9.45471525e-02f, -3.45927663e-02f, -6.77978098e-02f, 1.68243367e-02f, -2.34774612e-02f, 2.74342485e-02f, 5.49553335e-02f, 1.26533923e-05f, 8.53632092e-02f,
  6.45963848e-02f, -2.99265087e-02f, 9.21914726e-02f, -2.97627086e-03f, 5.44791706e-02f, 9.48782116e-02f, -5.41435555e-02f, 3.70356739e-02f, -6.87880293e-02f, -2.48774490e-03f,
  -2.29158951e-03f, 7.63202384e-02f, 4.32587378e-02f, -7.08243921e-02f, 8.95506516e-02f, -7.54916221e-02f, -2.61970907e-02f, -5.44631779e-02f, 6.04190156e-02f, 2.21743509e-02f,
  -1.31105930e-02f, -5.20380437e-02f, -9.91533604e-03f, -3.44091877e-02f, 2.10469030e-02f, 2.36628065e-03f, 1.15233166e-02f, -5.36573641e-02f, 6.65157959e-02f, -2.65738629e-02f,
  6.69174939e-02f, -1.44338794e-02f, -1.84725076e-02f, 8.15102383e-02f, -2.58309934e-02f, -9.39434692e-02f, 8.50040615e-02f, 5.52353375e-02f, 5.62178828e-02f, 7.29403272e-02f,
  4.74857390e-02f, -4.49390523e-02f, -7.98466355e-02f, -3.52460928e-02f, -1.21509619e-02f, 8.73610750e-02f, -1.15128607e-02f, 2.31959429e-02f, -9.74375531e-02f, -1.10951262e-02f,
  -1.79906532e-01f, 2.34147653e-01f, 9.12648067e-02f, -6.15580827e-02f, 3.07639223e-02f, -5.02100214e-02f, 6.34917766e-02f, 3.70079093e-02f, 1.07615069e-02f, 6.28591105e-02f,
  -2.23512650e-02f, 1.48163274e-01f, -2.03471091e-02f, 5.87271154e-02f, -2.18723923e-01f, -4.26980741e-02f, -3.58265527e-02f, 3.84422322e-03f, 3.92975360e-02f, -2.29231548e-02f,
  -2.34205313e-02f, -3.42771709e-02f, -7.77507350e-02f, 8.20384547e-02f, 5.90395555e-02f, 9.48955044e-02f, -1.18989259e-01f, 5.65366121e-04f, -5.02618477e-02f, 8.99425969e-02f,
  -1.42067913e-02f, -4.83629778e-02f, 8.55299458e-02f, 3.04786470e-02f, -9.48649645e-02f, 4.35680188e-02f, -1.75327584e-02f, 1.19784549e-02f, -3.86280529e-02f, 6.77383244e-02f,
  2.53091697e-02f, 4.36819391e-03f, 1.70336738e-02f, 2.69025490e-02f, -4.35985364e-02f, 7.64588788e-02f, -4.08485830e-02f, 2.87585519e-02f, -4.55553904e-02f, 1.02178128e-02f,
  6.37857541e-02f, 1.79180223e-02f, -5.17796353e-02f, -4.38807830e-02f, -6.49829656e-02f, 6.04514927e-02f, 2.55805366e-02f, -4.80704643e-02f, 4.79424000e-02f, -1.53769143e-02f,
  -4.99095693e-02f, -8.58619530e-03f, 6.52894005e-02f, 5.39614297e-02f, 1.68608539e-02f, 1.00315280e-01f, -3.45745906e-02f, 9.31879785e-03f, -6.81897684e-04f, -6.08485863e-02f,
  5.71639799e-02f, 8.80439393e-03f, -7.48931095e-02f, -3.62381414e-02f, -8.65615159e-03f, 7.48035312e-02f, -3.42138223e-02f, -4.55232561e-02f, -2.59050522e-02f, -8.24243575e-02f,
  4.85137776e-02f, -5.29974103e-02f, -2.87399665e-02f, -5.96604422e-02f, 6.53969646e-02f, -5.36397807e-02f, 3.40907909e-02f, 7.79800490e-02f, -3.39886174e-02f, 4.30993922e-03f,
  -8.48461092e-02f, -1.52678952e-01f, -6.25768825e-02f, -3.36770117e-02f, -5.13485186e-02f, -5.23002706e-02f, -1.81701630e-02f, 7.31751323e-02f, -8.90258998e-02f, 6.52758032e-02f,
  2.46176850e-02f, 1.18496306e-02f, -1.17700055e-01f, 5.00147790e-02f, -2.23158840e-02f, -2.33802050e-02f, 1.81746259e-02f, -5.47934771e-02f, 4.59487997e-02f, 2.36375313e-02f,
  1.34864887e-02f, -2.04953216e-02f, 3.34928036e-02f, -7.58324414e-02f, -2.62789452e-03f, -7.47641176e-02f, 3.64815816e-02f, -4.51378711e-03f, -6.91366792e-02f, -1.05477357e-02f,
  1.22857295e-01f, 1.28304288e-01f, -1.10623717e-01f, -1.93229057e-02f, 8.97130072e-02f, 2.20087737e-01f, 2.37747170e-02f, 9.80365425e-02f, 1.69525027e-01f, 2.49066819e-02f,
  5.55073023e-02f, 9.99225602e-02f, -1.43373869e-02f, 9.74712819e-02f, 1.23909719e-01f, 7.12839887e-02f, 2.05839410e-01f, 6.94621429e-02f, 1.26729444e-01f, 1.13549367e-01f,
  4.43039946e-02f, 1.67708192e-03f, -1.41206205e-01f, -3.49228531e-02f, -1.19662106e-01f, -1.16466224e-01f, -2.20579326e-01f, -4.90088202e-02f, -1.20418578e-01f, 4.86163460e-02f,
  -2.24507861e-02f, -3.36320959e-02f, -9.09173191e-02f, -3.02846227e-02f, 3.25390697e-02f, -7.42817223e-02f, -1.46089522e-02f, -8.09402540e-02f, 9.02634412e-02f, 3.95801850e-02f,
  3.08153834e-02f, -4.99953404e-02f, 3.06213684e-02f, -4.50425595e-02f, 6.58433437e-02f, -7.06447428e-03f, -5.57388440e-02f, -4.46995534e-02f, 7.20028952e-02f, -2.48690695e-02f,
  3.09115481e-02f, -7.04271672e-03f, 2.32254118e-02f, -2.60844640e-02f, 7.89991347e-04f, 8.87779072e-02f, 5.25179319e-02f, 7.46690785e-04f, 2.44062231e-03f, 4.24252674e-02f,
  3.01301610e-02f, 5.29806502e-02f, 4.23578219e-03f, 3.78850810e-02f, 4.95092273e-02f, -6.56213760e-02f, 7.24031851e-02f, 3.21577117e-02f, 7.76276886e-02f, -1.99893638e-02f,
  1.13382123e-01f, -5.95079958e-02f, 2.29611918e-02f, 7.60709271e-02f, -5.43539971e-02f, 4.52209525e-02f, 5.94496261e-03f, -6.91567212e-02f, -3.10027916e-02f, 4.41727825e-02f,
  -2.29516588e-02f, -2.35327724e-02f, -4.74130623e-02f, 3.89661058e-03f, 2.82825977e-02f, -7.27900863e-02f, 2.64322646e-02f, 4.11426416e-03f, -1.69730615e-02f, -2.62009874e-02f,
  1.53003722e-01f, 1.51699662e-01f, 1.36844134e-02f, -4.04985473e-02f, -5.91796823e-03f, 3.18464600e-02f, -2.82404199e-02f, 7.68415481e-02f, 4.72391993e-02f, 1.48869096e-03f,
  4.66356799e-02f, 3.32313180e-02f, 1.75898410e-02f, -4.80645038e-02f, -1.84414759e-02f, 1.03678228e-02f, 4.39268798e-02f, 8.42620581e-02f, -7.27204680e-02f, 3.13917845e-02f,
  6.22847080e-02f, 2.42154188e-02f, 2.28418875e-02f, -1.34769008e-02f, 5.84190451e-02f, -1.87708512e-02f, 5.42820850e-03f, 6.89341724e-02f, 4.00896929e-02f, 7.03207850e-02f,
  2.58027669e-02f, -1.10992759e-01f, 3.02084126e-02f, -4.70847152e-02f, 1.20081559e-01f, 4.46990728e-02f, 1.83023080e-01f, -5.03030699e-03f, -1.17421962e-01f, -1.22821450e-01f,
  6.31607696e-02f, -3.86714935e-02f, 1.51383504e-01f, -1.11148231e-01f, 1.59652248e-01f, 9.32520255e-02f, -2.54615620e-02f, -2.37837993e-02f, -7.18673766e-02f, -6.75781667e-02f,
  7.08060339e-02f, -1.18632674e-01f, 8.18183739e-03f, -7.74585605e-02f, -6.73513263e-02f, -1.72593258e-02f, 6.06407300e-02f, 8.58620554e-02f, -9.47486982e-02f, 4.02739160e-02f,
  -9.06389952e-02f, -2.43099518e-02f, 4.78575900e-02f, 1.26642012e-03f, 9.31903347e-02f, 2.43023671e-02f, 4.84232269e-02f, 8.22646543e-03f, 9.05507952e-02f, -1.96335297e-02f,
  4.77230810e-02f, 2.82105815e-04f, -6.25215247e-02f, -6.92550279e-03f, -7.11216331e-02f, -6.79380447e-02f, -7.65257701e-02f, 5.84549122e-02f, -1.70097668e-02f, -9.03685950e-03f,
  -1.01443693e-01f, 1.68067142e-02f, -3.04133985e-02f, -2.63549145e-02f, 9.45691466e-02f, -4.12361100e-02f, 1.90887973e-02f, 2.22452004e-02f, -1.63800120e-02f, 6.66716415e-03f,
  2.41349060e-02f, 6.17625527e-02f, 5.52351475e-02f, -7.75019005e-02f, 1.88430250e-02f, -8.51283371e-02f, -4.92438041e-02f, -8.66273791e-02f, -7.60830790e-02f, 3.13495845e-02f,
  -5.54760061e-02f, 6.68334141e-02f, 4.75395620e-02f, -8.21049958e-02f, 5.55438735e-02f, 5.29824011e-02f, -7.86573663e-02f, 1.75217111e-02f, 7.14895204e-02f, -2.63537820e-02f,
  2.97785383e-02f, 4.46671098e-02f, -2.10909639e-03f, -1.55453440e-02f, 2.32968591e-02f, 7.04313489e-03f, 6.47252891e-05f, 5.29895127e-02f, 5.26807569e-02f, -2.72765737e-02f,
  -2.16440130e-02f, -2.49903817e-02f, 1.60136912e-02f, 2.06421353e-02f, 4.04233895e-02f, 4.40244377e-02f, 4.35598418e-02f, -1.05501309e-01f, -7.34932274e-02f, -6.30903915e-02f,
  7.25909546e-02f, 1.99193321e-02f, 2.99237333e-02f, -5.41501455e-02f, -5.80658428e-02f, -2.46075466e-02f, -2.97557010e-04f, -2.95848716e-02f, -7.75154531e-02f, -6.42769262e-02f,
  1.55010466e-02f, -4.05636355e-02f, 1.90364476e-02f, -9.02732983e-02f, -8.96507204e-02f, 4.68295924e-02f, 5.57386167e-02f, 2.53769513e-02f, -4.68893088e-02f, 7.50746876e-02f,
  2.82151047e-02f, -8.82746205e-02f, 1.38556361e-01f, -1.05005853e-01f, 7.04300478e-02f, 9.70431641e-02f, 3.09479702e-02f, -2.22491071e-01f, -1.09575830e-01f, -1.68151110e-01f,
  -7.40483329e-02f, 2.90725566e-02f, 9.10571814e-02f, -1.02501430e-01f, 1.00533225e-01f, 4.21820991e-02f, -6.21092431e-02f, -1.73040442e-02f, 7.69976601e-02f, -1.18294200e-02f,
  -3.38077135e-02f, -1.48320824e-01f, 9.85227376e-02f, -1.29190490e-01f, -2.27421150e-02f, -3.48766930e-02f, -8.93010423e-02f, -4.50239964e-02f, -1.05437078e-01f, 4.87819090e-02f,
  -6.73009083e-02f, -1.40611641e-02f, 1.27266735e-01f, -7.47223571e-02f, -8.83372501e-02f, -5.03108837e-02f, -2.23043859e-02f, -3.11519522e-02f, 3.57640535e-02f, 1.03761442e-02f,
  -4.77884002e-02f, -4.96703647e-02f, 1.57954153e-02f, -4.78458963e-02f, -1.02351479e-01f, -6.74369410e-02f, -3.19542326e-02f, -2.38411352e-02f, 4.61659059e-02f, 5.50818779e-02f,
  9.38090608e-02f, 9.10141990e-02f, -6.94171041e-02f, 2.32083793e-03f, 2.04130448e-03f, -2.92365644e-02f, 1.05207875e-01f, 1.18396975e-01f, -2.34740321e-02f, 1.77085716e-02f,
  -7.97062889e-02f, -4.04024571e-02f, 2.61468850e-02f, -9.69181359e-02f, -2.57465476e-03f, 1.76182184e-02f, -3.81791964e-02f, 4.44770902e-02f, 5.76673672e-02f, -5.35520054e-02f,
  -3.39233056e-02f, -7.49710128e-02f, 7.09101260e-02f, 1.14239782e-01f, -5.63158244e-02f, 4.21685725e-03f, 7.80294463e-02f, -7.20651671e-02f, 8.03681388e-02f, -1.18817333e-02f,
  4.40223841e-03f, -3.40807321e-03f, -2.32787039e-02f, 6.37550503e-02f, 7.99959823e-02f, -3.88157256e-02f, 7.96004012e-02f, 5.11861667e-02f, 2.40763370e-02f, 1.47398133e-02f,
  -1.52532831e-01f, -1.81207418e-01f, -1.51209850e-02f, 2.60166712e-02f, -6.03840351e-02f, 3.87372300e-02f, 3.95282581e-02f, 1.33729139e-02f, -9.53750983e-02f, -1.30489752e-01f,
  -7.28680938e-02f, 2.02403329e-02f, 3.04218382e-02f, 6.07659370e-02f, 5.80706783e-02f, -1.83890890e-02f, -5.85356317e-02f, -3.33542260e-03f, 8.00902098e-02f, -6.63173869e-02f,
  6.56855553e-02f, -4.37695446e-04f, -3.90559658e-02f, 4.01522033e-02f, 4.08857092e-02f, 4.97634560e-02f, 1.80421453e-02f, 8.33290443e-02f, 5.92921115e-02f, -5.16035557e-02f,
  1.08751260e-01f, -6.30102009e-02f, -7.44225383e-02f, 5.70676215e-02f, 1.13164194e-01f, 6.12034984e-02f, 9.29646045e-02f, 3.04630511e-02f, 7.01326951e-02f, -5.48428446e-02f,
  -1.45795569e-02f, -1.13296304e-02f, -7.02397972e-02f, 1.72018614e-02f, -6.93265796e-02f, -6.13383241e-02f, 1.26747489e-01f, -7.52708092e-02f, 6.52225018e-02f, 4.87997606e-02f,
  -1.46507518e-02f, 5.41343819e-03f, -2.38751192e-04f, 6.22207969e-02f, 3.68796028e-02f, -3.10789477e-02f, 7.11345002e-02f, -5.76062463e-02f, -6.91316128e-02f, -3.05550592e-03f,
  3.41324471e-02f, 3.05083003e-02f, -7.28085041e-02f, 5.43814376e-02f, -3.26945707e-02f, -3.31595130e-02f, -3.14855948e-02f, -9.23270509e-02f, -7.01242536e-02f, -1.93394497e-02f,
  9.20635276e-03f, -1.39481742e-02f, 7.50524178e-02f, -5.34509402e-03f, 9.58290300e-04f, 1.21465605e-02f, 5.98446988e-02f, 5.30069657e-02f, -7.44220149e-03f, -6.91976920e-02f,
  6.60543889e-02f, -3.07373479e-02f, -3.54382284e-02f, -3.63876969e-02f, 9.81062874e-02f, 2.96546295e-02f, -3.10892612e-02f, 4.69028316e-02f, -6.50359392e-02f, 6.03148490e-02f,
  -1.49559146e-02f, 8.51222426e-02f, -1.64661873e-02f, -6.28635213e-02f, -7.28509128e-02f, 2.60469131e-02f, -2.21107360e-02f, -6.38394058e-02f, -7.35394508e-02f, -4.05645035e-02f,
  -1.02455586e-01f, 8.22499767e-02f, 5.04476167e-02f, -1.17079122e-02f, 7.56192580e-02f, 1.40939364e-02f, 5.74748889e-02f, 4.59012762e-02f, -6.05620556e-02f, -2.37687752e-02f,
  -3.48258913e-02f, 1.52908340e-02f, -1.78506672e-02f, -2.35100724e-02f, -5.48201129e-02f, -3.65239196e-02f, -5.58569171e-02f, 4.26562503e-02f, 5.42185130e-03f, -3.64440270e-02f,
  8.74281861e-03f, -1.95308088e-03f, 1.40220793e-02f, 9.78015661e-02f, -9.73148271e-02f, -1.44491466e-02f, -5.17485440e-02f, -5.40344194e-02f, 1.53599521e-02f, -9.26237181e-02f,
  2.73577981e-02f, -2.08549458e-03f, -6.40905872e-02f, 7.50134047e-03f, 2.11203620e-02f, 3.01263644e-03f, -8.42519999e-02f, 6.45171180e-02f, -3.29882614e-02f, -2.30827350e-02f,
  3.37465517e-02f, -4.65470143e-02f, 2.43901219e-02f, -6.06434941e-02f, -4.64013405e-03f, -6.12879656e-02f, 1.49755422e-02f, 6.32746741e-02f, -8.49300250e-03f, 2.31010225e-02f,
  1.84148066e-02f, -1.12925060e-02f, -1.80732399e-01f, -2.53597349e-01f, -2.13332828e-02f, -1.60047010e-01f, -2.61405945e-01f, -4.18742523e-02f, 2.02946037e-01f, -2.73491554e-02f,
  -2.03338355e-01f, 1.19799353e-01f, -7.66946375e-02f, -2.18512267e-01f, 1.75266005e-02f, 1.28750086e-01f, -2.08484933e-01f, -6.86304793e-02f, -7.06291124e-02f, -2.53737658e-01f,
  -6.58095405e-02f, -1.28909260e-01f, -1.42523468e-01f, -9.72373486e-02f, -1.82198152e-01f, 9.71206836e-03f, 9.99229550e-02f, -1.05794922e-01f, -9.22836810e-02f, 3.91058587e-02f,
  2.23399140e-03f, -1.85852684e-02f, -4.15976159e-02f, -1.67613123e-02f, -5.56842200e-02f, -6.15372695e-02f, 1.26749538e-02f, 1.33914752e-02f, 5.05903326e-02f, -9.74975228e-02f,
  -7.89251029e-02f, 4.78954911e-02f, -8.42613354e-02f, 8.42942297e-02f, -3.11894459e-03f, 1.59228649e-02f, 3.84172797e-02f, 6.75224811e-02f, 2.58187745e-02f, -4.43735868e-02f,
  -1.03070267e-01f, 1.19418083e-02f, -8.76432732e-02f, 7.94651657e-02f, 5.63298054e-02f, 2.67594215e-02f, 6.96057873e-03f, -8.66917744e-02f, -6.57117739e-03f, 2.34771036e-02f,
  6.46054372e-02f, -2.55199149e-02f, -5.90683483e-02f, 2.21574344e-02f, -2.06655506e-02f, 2.73711085e-02f, -1.01748519e-02f, -5.64581938e-02f, -1.62257254e-02f, -7.46594835e-03f,
  2.74742823e-02f, -5.13086319e-02f, 5.56483530e-02f, -4.90559973e-02f, -1.01984441e-01f, 5.91826020e-03f, 8.28857571e-02f, -2.87754051e-02f, 1.77816767e-02f, -1.45396611e-04f,
  3.54847871e-02f, 6.09700195e-02f, -4.23754901e-02f, -5.69213703e-02f, -3.22892033e-02f, 6.99408501e-02f, -1.38614215e-02f, 6.58624768e-02f, -4.20557521e-02f, -6.99385768e-03f,
  3.25126871e-02f, -1.06617004e-01f, 5.82155623e-02f, 5.73478639e-02f, 1.02724396e-02f, -2.62326468e-02f, -7.58029297e-02f, -2.74209268e-02f, -4.51768339e-02f, 1.96971036e-02f,
  8.48420616e-03f, 5.35079576e-02f, -5.93874371e-03f, 2.27037538e-02f, -2.65002474e-02f, 3.47711146e-02f, 7.76877999e-02f, 4.89818789e-02f, -4.57776338e-02f, 6.12734891e-02f,
  -4.50634360e-02f, -4.47168164e-02f, 2.58094985e-02f, 7.35938922e-02f, -1.80066079e-02f, 1.47632451e-03f, 3.92526723e-02f, 2.70959847e-02f, 2.33869553e-02f, -5.90394177e-02f,
  -3.45269893e-03f, -8.09619501e-02f, 2.90341172e-02f, 1.42688453e-01f, 1.35569610e-02f, -2.09011585e-02f, -1.46721363e-01f, 7.74839073e-02f, -6.89181238e-02f, -4.06518579e-02f,
  -7.23182596e-03f, -6.05302714e-02f, -5.24282679e-02f, 1.24206282e-01f, 1.73500702e-01f, -8.54108259e-02f, 9.73446742e-02f, -4.52170894e-02f, -2.98884474e-02f, -4.28974107e-02f,
  1.68542847e-01f, 5.00394329e-02f, 1.69818580e-01f, 2.69321185e-02f, 1.14560783e-01f, 1.17442064e-01f, 1.89169675e-01f, 7.41234422e-02f, 1.30372792e-01f, -2.17797887e-02f,
  4.56673950e-02f, 3.11221145e-02f, -3.42164151e-02f, -1.74487419e-02f, 7.79571533e-02f, 1.26279602e-02f, 4.02934253e-02f, -2.09876355e-02f, -3.93710732e-02f, 1.41790020e-03f,
  -3.19270864e-02f, 1.29133761e-02f, -4.38550264e-02f, 1.02446880e-02f, -4.56618629e-02f, 3.09582502e-02f, -7.53813237e-02f, 6.47214428e-02f, 4.80523780e-02f, -5.97445257e-02f,
  -3.39513384e-02f, -1.85018796e-02f, 5.05263126e-03f, -3.36152948e-02f, -3.04267779e-02f, -6.81449845e-03f, 9.69680101e-02f, -3.76804546e-02f, -2.90628206e-02f, -6.89737201e-02f,
  4.32514027e-02f, -4.16444847e-03f, -2.24533249e-02f, 3.20298783e-02f, 4.50552218e-02f, -3.88159938e-02f, -1.92266740e-02f, -2.24302392e-02f, 8.43821764e-02f, -4.93886769e-02f,
  9.04845074e-02f, -1.11742644e-02f, -3.75356972e-02f, -2.90739909e-02f, 6.34378120e-02f, -3.31777260e-02f, -1.76888723e-02f, -4.57081087e-02f, -3.88392657e-02f, 6.05141371e-03f,
  9.09886230e-03f, 1.08372758e-03f, 5.58488406e-02f, 3.90614457e-02f, 2.37994827e-02f, 2.81745177e-02f, 5.98549470e-03f, 1.05727930e-02f, 4.03838158e-02f, 7.75170028e-02f,
  -2.42237281e-02f, 8.97481441e-02f, -4.85677943e-02f, 4.91073318e-02f, -3.14937867e-02f, -2.13362239e-02f, 4.14938629e-02f, 2.53630914e-02f, 7.49376928e-03f, 5.05566522e-02f,
  1.08387038e-01f, -7.88148493e-03f, 1.30662741e-02f, -3.11319367e-03f, 9.40291435e-02f, -5.42413741e-02f, -1.78655516e-02f, 1.23556275e-02f, -1.30610196e-02f, 7.29204863e-02f,
  -6.34754216e-03f, -3.89190428e-02f, 7.18263388e-02f, -9.85067785e-02f, -5.89822698e-03f, 9.50699858e-03f, 5.87903894e-02f, 6.62197694e-02f, 7.10851848e-02f, -6.62018582e-02f,
  -6.71531484e-02f, -6.86886460e-02f, -1.24884568e-01f, -3.24370223e-03f, 7.32402727e-02f, -1.13090463e-01f, -7.26051703e-02f, -6.98409453e-02f, 2.84749293e-03f, 4.00345959e-02f,
  -6.39487505e-02f, -2.43678428e-02f, 1.20206662e-02f, -1.03174575e-01f, -1.39912263e-01f, 1.78626869e-02f, -9.03450325e-02f, 5.55748604e-02f, -6.80494159e-02f, -9.33540314e-02f,
  -9.56787243e-02f, 2.26250384e-02f, -5.70930354e-02f, -3.93539257e-02f, 3.20742279e-02f, 1.61188617e-02f, 7.51631483e-02f, 8.86088312e-02f, -1.04104504e-01f, 6.59306347e-02f,
  -1.11033265e-02f, 7.21633285e-02f, 3.41467629e-03f, -4.01438884e-02f, -4.22014222e-02f, 6.70013204e-02f, 6.59791799e-03f, 4.47404087e-02f, -3.28023247e-02f, -6.09384589e-02f,
  6.93292916e-02f, 4.32631448e-02f, 3.25384587e-02f, 9.12463814e-02f, 4.88115698e-02f, 9.75910053e-02f, 4.51643541e-02f, -6.52070530e-03f, 5.22054173e-03f, -3.90083976e-02f,
  -8.14891905e-02f, 7.25184679e-02f, 6.04983512e-03f, 7.53927743e-03f, 5.91623783e-02f, -5.09202620e-03f, -5.11076823e-02f, -4.23996449e-02f, -5.49779972e-03f, 5.15650958e-02f,
  -6.93549663e-02f, -2.22596829e-03f, -1.28571671e-02f, 4.98972945e-02f, -3.14063691e-02f, 5.61385937e-02f, -6.39047846e-02f, 3.67307924e-02f, -4.11332259e-03f, -7.38520101e-02f,
  3.33699211e-02f, 3.88624892e-02f, 6.92672506e-02f, 2.36795638e-02f, 2.00232281e-03f, -3.96005763e-03f, -2.40591485e-02f, 5.94219454e-02f, -7.09666833e-02f, 2.38978714e-02f,
  4.49727774e-02f, 8.22301507e-02f, -8.53669271e-02f, -2.34901868e-02f, 1.68263912e-02f, -3.04225944e-02f, 2.74516962e-04f, 3.80492322e-02f, 2.91778445e-02f, -5.01972549e-02f,
  -7.64439553e-02f, -3.37667242e-02f, 4.80864421e-02f, -3.49609889e-02f, -6.23948202e-02f, 2.29416904e-03f, -4.08445857e-02f, -1.69946216e-02f, -5.22635616e-02f, -6.58755749e-02f,
  5.88618591e-02f, 7.01505542e-02f, 4.90782261e-02f, -8.34817514e-02f, 2.02716663e-02f, 5.30596152e-02f, -5.21658398e-02f, 8.58207047e-02f, 5.99909537e-02f, 4.90909778e-02f,
  7.19175860e-02f, 1.01123773e-01f, 1.04446867e-02f, 5.73185571e-02f, -3.04946098e-02f, -4.98442613e-02f, 2.10697837e-02f, 4.20457125e-02f, 2.98398314e-03f, 6.70321062e-02f,
  1.99910048e-02f, -9.74008814e-02f, -8.72972161e-02f, -1.89700082e-01f, -3.40735614e-02f, -7.70710558e-02f, -1.75762162e-01f, 4.41420488e-02f, -1.98950190e-02f, 4.05055732e-02f,
  -1.30122706e-01f, -6.59105927e-02f, 5.56286536e-02f, -1.00340858e-01f, -1.02788880e-01f, -1.01168100e-02f, -2.08323687e-01f, -1.35246798e-01f, 4.92475070e-02f, -4.94275615e-02f,
  -8.44054297e-02f, -2.71152034e-02f, -1.23330332e-01f, -3.46179977e-02f, -2.43498012e-02f, -6.30001873e-02f, 6.78063333e-02f, -1.31404504e-01f, -9.10390094e-02f, -1.21558923e-02f,
  -8.00021663e-02f, -2.30237916e-02f, -3.39131095e-02f, 9.53634977e-02f, -4.75197881e-02f, 1.23032210e-02f, -5.52957952e-02f, 3.08591593e-02f, 4.36774790e-02f, -4.92803231e-02f,
  4.30894010e-02f, 4.22849283e-02f, 5.85402586e-02f, -2.70792078e-02f, -1.46881090e-02f, -1.37823587e-02f, -7.81812295e-02f, 4.66914885e-02f, 6.30747527e-02f, -5.23354784e-02f,
  -1.55415926e-02f, -3.99681181e-03f, 6.63927794e-02f, 4.51530740e-02f, -7.43695498e-02f, -5.01125492e-03f, 1.75478533e-02f, 2.33675521e-02f, -6.79448396e-02f, 3.12250946e-03f,
  7.28896484e-02f, 2.28970312e-02f, -8.41698572e-02f, -4.80220504e-02f, -3.12708542e-02f, 8.21875930e-02f, -4.68890974e-03f, 8.21949765e-02f, 6.17154501e-03f, 2.31845006e-02f,
  -2.91828383e-02f, -2.40638424e-02f, -5.44488728e-02f, -5.79159334e-02f, 7.85309896e-02f, -2.66904347e-02f, 2.17145924e-02f, -2.16707364e-02f, -8.02427530e-02f, -3.61071378e-02f,
  6.51985705e-02f, -7.34517649e-02f, 7.85688907e-02f, 5.21635599e-02f, -2.16214601e-02f, -8.47559646e-02f, 3.33513413e-03f, -1.04883626e-01f, -1.51761267e-02f, -2.71670241e-02f,
  -2.90880520e-02f, 6.44810349e-02f, -2.28865687e-02f, -3.59888338e-02f, 2.04165317e-02f, -3.71186137e-02f, 1.67399608e-02f, 3.79159935e-02f, -3.24449502e-02f, -9.28312168e-02f,
  5.04641160e-02f, -1.07628265e-02f, -6.08092397e-02f, -6.60301000e-02f, 1.06396079e-01f, 2.13455688e-02f, 3.46269854e-03f, -5.70060238e-02f, -1.07741207e-01f, 9.13815424e-02f,
  -1.28470222e-02f, 7.45011568e-02f, 3.10533345e-02f, -9.47251245e-02f, 2.90049687e-02f, -3.64065380e-03f, -7.17169493e-02f, 1.56629551e-02f, -6.60394952e-02f, 9.93762445e-03f,
  -3.00335586e-01f, 8.78160521e-02f, 3.76327075e-02f, -9.38857496e-02f, -1.77889206e-02f, 1.65679008e-01f, 3.76088880e-02f, -4.30945493e-03f, -1.93823859e-01f, -6.90199435e-02f,
  -9.03612375e-02f, -1.25663742e-01f, 1.08986199e-01f, -6.67007267e-03f, 9.55292359e-02f, 1.27447754e-01f, -6.30910567e-04f, 5.41231968e-03f, 2.19277684e-02f, -2.62787137e-02f,
  -3.14922258e-02f, -6.81886598e-02f, 1.31947622e-01f, 9.17290598e-02f, -6.86605126e-02f, -1.14569351e-01f, -7.86173269e-02f, 9.82664227e-02f, -9.62886959e-02f, -5.30279092e-02f,
  -1.83974914e-02f, -2.19619408e-01f, -1.23281807e-01f, -7.94321522e-02f, 3.68188731e-02f, -3.91206052e-03f, -6.29081652e-02f, 6.16679676e-02f, 5.15417987e-03f, 7.45218247e-02f,
  5.87666072e-02f, 1.71792135e-02f, -2.77267676e-02f, -1.35138230e-02f, 2.38100868e-02f, -4.32938486e-02f, -3.33187054e-03f, -4.24439320e-03f, 3.36127803e-02f, 2.56621279e-02f,
  9.68831331e-02f, -4.06467021e-02f, -5.35505079e-02f, -3.98456790e-02f, 1.62561722e-02f, 3.62454094e-02f, 5.76710142e-02f, 5.69602475e-02f, -5.03105149e-02f, -1.09911546e-01f,
  2.21943185e-02f, 2.32147276e-02f, -6.50134385e-02f, 3.70993800e-02f, -5.95990047e-02f, -8.16207677e-02f, -5.59342094e-03f, -3.95310223e-02f, -3.27946134e-02f, 1.02032423e-01f,
  5.79638369e-02f, -8.33336730e-03f, -3.72417644e-02f, 5.93695454e-02f, -8.12439471e-02f, -3.11154369e-02f, 3.55823524e-02f, 4.36962135e-02f, -2.28639338e-02f, 5.50091229e-02f,
  -8.94511864e-03f, -4.50055376e-02f, 1.37541788e-02f, 4.37705070e-02f, 3.25370440e-03f, 3.33054364e-02f, 2.52933782e-02f, 9.28658321e-02f, -2.46516988e-03f, 3.53682926e-03f,
  -1.38437971e-01f, -2.39268601e-01f, -2.88415067e-02f, 2.30266321e-02f, -2.45445594e-02f, -2.92366035e-02f, 9.26111042e-02f, -5.92770539e-02f, -2.45022587e-03f, -3.69941890e-02f,
  -7.80605059e-03f, -5.20245731e-02f, -4.25313450e-02f, -3.84860709e-02f, 2.07990035e-02f, -5.80786578e-02f, -7.43186697e-02f, -1.84662025e-02f, -8.08496401e-02f, 5.20955734e-02f,
  -5.02762347e-02f, -2.19241418e-02f, -9.08755288e-02f, 6.20108796e-03f, 7.68855773e-03f, -3.73789929e-02f, 1.26090227e-03f, -5.81046753e-02f, -3.76908444e-02f, 5.19198216e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.43174413e-02f, 8.98826048e-02f, 3.79762352e-02f, 1.19638309e-01f, -5.68724088e-02f, -6.90664863e-03f, 1.35934249e-01f, -6.27917349e-02f, 4.01155949e-02f, -5.47821969e-02f,
  7.62074962e-02f, 9.37527716e-02f, -2.19879895e-02f, 6.46452829e-02f, 9.75958481e-02f, 5.81066795e-02f, 5.90680279e-02f, -7.20950589e-02f, -6.32992852e-03f, -6.56694099e-02f,
  -6.15032688e-02f, -6.27474338e-02f, 8.19546357e-02f, 2.34039524e-03f, 4.20762189e-02f, 1.29041597e-01f, -5.76503053e-02f, -1.66638382e-02f, -1.36794858e-02f, -2.57854760e-02f,
  4.36554849e-02f, 8.18482116e-02f, 1.04316249e-01f, 7.27824643e-02f, -4.41838540e-02f, -6.96454868e-02f, 6.28477111e-02f, 2.96808556e-02f, 7.02473596e-02f, 1.42793372e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.75519258e-02f, 6.58361539e-02f, 7.28351697e-02f, -3.23373564e-02f, 5.44558105e-04f, -6.30726814e-02f, -1.06126457e-01f, -9.87286214e-03f, 2.35101022e-02f, -8.05884600e-02f,
  7.09279403e-02f, -4.18451615e-02f, 2.82381549e-02f, -1.27507702e-01f, 9.60180983e-02f, 3.69955339e-02f, -5.48928641e-02f, -8.02500099e-02f, -1.40635967e-01f, 1.70170084e-01f,
  -9.86433700e-02f, -9.60000157e-02f, 5.95072401e-04f, -1.34757325e-01f, 1.01582393e-01f, 5.63005917e-02f, 3.07024196e-02f, 1.30474299e-01f, -9.05077904e-02f, -2.99520027e-02f,
  1.02271229e-01f, -2.53831595e-02f, -5.67763075e-02f, 2.77834646e-02f, 7.08128512e-02f, 9.34911445e-02f, -5.14400080e-02f, 5.18210046e-02f, 3.38869244e-02f, -1.03037171e-02f,
  -5.59045859e-02f, -1.76204890e-02f, -5.31507693e-02f, 4.49065305e-02f, -6.77970573e-02f, 8.38311240e-02f, -4.32431959e-02f, 5.80101879e-03f, -1.44750834e-01f, 4.48628031e-02f,
  2.68408302e-02f, 3.69478390e-02f, -5.83572239e-02f, 4.29914407e-02f, 3.59557453e-03f, -1.26588225e-01f, 9.49057713e-02f, 8.52459297e-02f, -4.69128378e-02f, 1.23427294e-01f,
  -5.96106201e-02f, 4.36315611e-02f, -8.36831108e-02f, -1.15430921e-01f, 8.88219941e-03f, -6.96875304e-02f, 2.59143934e-02f, -1.07825406e-01f, 9.70364884e-02f, 5.41362166e-02f,
  6.18223986e-03f, 1.90011840e-02f, 5.86384796e-02f, -4.43251505e-02f, -1.16847754e-01f, -5.08471727e-02f, -9.91277304e-03f, 8.15428123e-02f, -5.57872280e-03f, 8.69999081e-02f,
  3.55774648e-02f, -1.76788529e-03f, 1.00663766e-01f, -2.95541100e-02f, 1.01550683e-01f, 2.77234372e-02f, -3.52175608e-02f, 5.98504916e-02f, 3.49471867e-02f, 1.29833579e-01f,
  6.67264387e-02f, -5.57056703e-02f, -5.51031083e-02f, -6.00757338e-02f, 1.05267661e-02f, 4.77610491e-02f, -4.50233296e-02f, 2.24115346e-02f, 1.03741251e-02f, -5.79785835e-03f,
  3.91379409e-02f, 8.96000937e-02f, -2.75208764e-02f, 1.08668089e-01f, 1.13813139e-01f, -5.03238775e-02f, -1.22355213e-02f, 3.76979932e-02f, -9.72717330e-02f, -3.56729366e-02f,
  -1.17566623e-02f, -1.31305680e-01f, -2.03276332e-02f, -7.10308850e-02f, 5.24014309e-02f, 2.20358763e-02f, 6.76869899e-02f, 4.98249903e-02f, -2.02005841e-02f, -1.15366623e-01f,
  -3.10193151e-02f, -9.29862633e-02f, 1.16123118e-01f, 1.61928479e-02f, -7.78254643e-02f, 2.42436286e-02f, -8.17035958e-02f, 4.20051664e-02f, -3.39010842e-02f, -8.74579176e-02f,
  9.29411277e-02f, -8.01265463e-02f, -1.49954567e-02f, -3.47989984e-02f, -5.37188835e-02f, -2.56818198e-02f, 4.81033511e-03f, -1.49970204e-01f, -9.39227715e-02f, -1.08544372e-01f,
  1.99515149e-01f, 2.13854134e-01f, 9.89481136e-02f, -1.01698712e-01f, -2.89374217e-02f, 1.94376215e-01f, 1.63123142e-02f, 6.56720763e-03f, -1.19387500e-01f, -1.07726650e-02f,
  2.08933443e-01f, -2.84025650e-02f, -9.00801942e-02f, 7.03261420e-02f, -1.02947526e-01f, -2.35657975e-01f, 8.12664852e-02f, 2.57954802e-02f, -1.43493801e-01f, -1.01511739e-01f,
  1.26367629e-01f, 6.56107739e-02f, -8.55943188e-02f, 1.39874086e-01f, 1.63876340e-02f, -1.09850951e-01f, 6.05308963e-03f, 1.46373764e-01f, -1.21184655e-01f, -1.41448185e-01f,
  6.30253479e-02f, -1.01069100e-01f, -1.50743708e-01f, -9.33035463e-02f, -1.51857466e-01f, 1.03866301e-01f, 1.40474752e-01f, -2.44240925e-01f, 6.96565434e-02f, -6.01858227e-03f,
  -4.47342806e-02f, 6.83147740e-03f, 1.20431766e-01f, -5.12936059e-03f, -5.30872345e-02f, -1.68314669e-02f, -9.96316299e-02f, -7.87216648e-02f, -4.40308191e-02f, -7.16011524e-02f,
  -1.41973674e-01f, 9.14560035e-02f, -8.23524222e-02f, -8.38368610e-02f, 1.07309580e-01f, -9.09576416e-02f, -1.03623122e-01f, -2.57892329e-02f, 8.24936032e-02f, -7.67266192e-03f,
  7.01139793e-02f, 1.85922664e-02f, -6.69418946e-02f, 1.05111577e-01f, 5.70240058e-02f, 1.34321228e-01f, 2.30544619e-02f, -9.42028314e-02f, -1.12309299e-01f, 1.12105355e-01f,
  2.33624682e-01f, 1.15025476e-01f, -1.44479111e-01f, -2.20722124e-01f, -1.36606142e-01f, 8.60185176e-02f, -8.04411918e-02f, -1.27103001e-01f, -1.12946006e-02f, -9.56654996e-02f,
  -1.39845565e-01f, -2.06463635e-02f, -1.37355417e-01f, 1.76288113e-02f, 1.02118075e-01f, 9.22326818e-02f, -5.41729517e-02f, 1.15039222e-01f, 3.58264633e-02f, -1.01011336e-01f,
  -5.72593808e-02f, -6.02635667e-02f, 2.46792603e-02f, -1.81397602e-01f, -1.30699322e-01f, -5.92631921e-02f, 3.61146145e-02f, -1.34366378e-02f, -1.03830971e-01f, -2.14854665e-02f,
  5.19138984e-02f, -1.54560626e-01f, 1.17835678e-01f, 1.17125079e-01f, 2.56230775e-02f, -1.07552921e-02f, -2.00906936e-02f, 1.13617577e-01f, 5.26280105e-02f, -4.80560064e-02f,
  1.12990670e-01f, -8.35209042e-02f, -1.12412035e-01f, -6.24865619e-03f, -6.21091649e-02f, 7.41377994e-02f, 1.88915245e-02f, 1.73132822e-01f, -7.82076716e-02f, 1.04897238e-01f,
  1.11664154e-01f, 2.27985741e-03f, -8.60608295e-02f, 1.26956359e-01f, 7.39621222e-02f, -1.33605888e-02f, -1.81059577e-02f, 4.71152365e-02f, 2.39000365e-01f, -2.41215885e-01f,
  -1.77014247e-01f, 9.61592272e-02f, -1.37790993e-01f, -1.10258669e-01f, -4.47225645e-02f, -3.64136510e-02f, -2.52960056e-01f, -1.43827751e-01f, -1.74635574e-01f, 5.09377830e-02f,
  1.17555223e-01f, -1.52497709e-01f, 3.80835868e-02f, 1.72518939e-01f, -1.55652672e-01f, -1.37013823e-01f, -4.82946932e-02f, 5.58848977e-02f, -1.79467335e-01f, 8.42168629e-02f,
  3.07518691e-02f, -1.90438092e-01f, 3.32190283e-02f, -6.59784749e-02f, 9.61176902e-02f, 1.38070107e-01f, -1.39402077e-01f, 1.08798414e-01f, -5.74133545e-02f, -1.39605910e-01f,
  1.72208473e-01f, 7.03649446e-02f, 2.23128535e-02f, -8.88228938e-02f, -4.19278815e-02f, 1.06140077e-01f, 1.16273753e-01f, 1.81197345e-01f, -3.94251943e-02f, -1.54265448e-01f,
  2.59341337e-02f, 2.03245040e-03f, 3.43434028e-02f, 6.93884343e-02f, 1.00674652e-01f, 1.64790988e-01f, 7.66588375e-02f, 1.20032057e-01f, -5.02236523e-02f, -1.10631287e-01f,
  -1.07719839e-01f, -7.44724870e-02f, 1.00525040e-02f, 1.09686710e-01f, -1.40069500e-01f, -1.37876850e-02f, 7.98359588e-02f, 1.15295075e-01f, -9.37527567e-02f, -3.34922597e-02f,
  1.28862351e-01f, -1.40906930e-01f, -9.22120512e-02f, 1.73669249e-01f, -1.40158042e-01f, -1.09259531e-01f, 2.88079865e-02f, 3.07368841e-02f, -1.72720268e-01f, 5.56588583e-02f,
  1.16649248e-01f, 8.05209056e-02f, 1.35907814e-01f, 1.01187982e-01f, 8.24872404e-02f, 1.13368500e-02f, -2.64846743e-03f, -1.59579694e-01f, -1.66384759e-03f, -4.86340187e-02f,
  2.22149238e-01f, 1.51711628e-02f, 6.26143590e-02f, -2.78624296e-02f, -6.05794191e-02f, 1.63718656e-01f, 7.19987974e-02f, 1.06218467e-02f, -5.75674251e-02f, -1.63900852e-01f,
  1.26070112e-01f, -7.10942596e-02f, 1.25137612e-01f, 4.96694446e-02f, -1.25430465e-01f, -4.77814376e-02f, -6.56970143e-02f, 4.95517328e-02f, 7.68637732e-02f, 4.15196232e-02f,
  -6.56711757e-02f, 7.78651461e-02f, -8.46141949e-02f, 1.30737005e-02f, 8.89783427e-02f, -5.11875674e-02f, -7.93436728e-03f, -1.54363722e-01f, 5.62568642e-02f, -1.50237441e-01f,
  5.67898154e-02f, -6.97397888e-02f, -6.72019720e-02f, 7.50864893e-02f, 5.09315953e-02f, -4.36624922e-02f, -6.43205792e-02f, -3.99606153e-02f, 5.44614606e-02f, -5.81712425e-02f,
  2.84989141e-02f, 1.07808389e-01f, 8.40330422e-02f, 4.18899469e-02f, 6.09766990e-02f, 8.03394541e-02f, 6.86362758e-02f, 2.74088308e-02f, 1.62022516e-01f, 7.76798502e-02f,
  -2.18223602e-01f, 1.15542412e-01f, 9.81150642e-02f, 3.02724037e-02f, 3.94661948e-02f, -1.35977924e-01f, -4.56841215e-02f, -7.42694363e-02f, -1.58166707e-01f, 3.14174965e-02f,
  1.15930878e-01f, 9.00298432e-02f, 2.42316611e-02f, 8.68889466e-02f, -2.19732985e-01f, -1.68697000e-01f, -1.40416028e-04f, 9.15202871e-02f, 6.54971153e-02f, -6.90358058e-02f,
  -9.32403952e-02f, -3.10950689e-02f, -1.04172722e-01f, 1.79230094e-01f, -4.48917486e-02f, -1.19230278e-01f, -2.03466117e-02f, 3.65228625e-03f, 9.33188573e-02f, 3.10424510e-02f,
  -1.06839485e-01f, -1.59507617e-02f, -4.37838510e-02f, -5.74766956e-02f, 2.23429687e-02f, 5.07210090e-04f, 3.19890082e-02f, 2.40270179e-02f, 1.11713195e-02f, 5.37711056e-03f,
  -2.09798347e-02f, 1.60370275e-01f, -6.38494790e-02f, 1.21716045e-01f, -1.34533837e-01f, -1.08817101e-01f, 3.36229801e-04f, 1.11953281e-01f, -1.33869901e-01f, 9.66743082e-02f,
  1.22329295e-01f, -6.14971109e-03f, -7.82733634e-02f, 1.65898055e-02f, 9.35980752e-02f, 2.17951462e-02f, 1.62953138e-02f, -9.32384282e-03f, 6.03577634e-03f, 5.60724512e-02f,
  5.26710413e-02f, -1.04088761e-01f, -3.07563785e-03f, 1.06263561e-02f, 3.52934413e-02f, 8.39060768e-02f, -7.40241036e-02f, 2.78205071e-02f, 7.09348246e-02f, 1.56636387e-01f,
  5.57692982e-02f, 3.19682211e-02f, 1.12929724e-01f, 1.02501169e-01f, 4.17822450e-02f, -9.19525996e-02f, 2.08397652e-03f, 8.59665275e-02f, -5.50427139e-02f, 8.59874785e-02f,
  -6.86945394e-02f, 1.21284045e-01f, 1.21304139e-01f, 1.02257922e-01f, 2.49801353e-02f, -8.62326548e-02f, 7.32422173e-02f, 1.09924436e-01f, 2.35144254e-02f, -1.12697944e-01f,
  1.16043374e-01f, 3.26521955e-02f, -7.66466185e-02f, -2.64618658e-02f, 1.41899027e-02f, -1.95305329e-02f, -6.53378293e-02f, -1.43473431e-01f, -3.32569666e-02f, 9.57105309e-02f,
  -1.05575971e-01f, 4.49560359e-02f, 3.30252503e-03f, -1.53856367e-01f, -4.29218858e-02f, 1.99257489e-03f, 1.84231326e-02f, -3.37466821e-02f, -1.39346896e-02f, 9.09184590e-02f,
  2.15649605e-02f, -3.07088043e-03f, -7.74817318e-02f, -9.84522514e-03f, -1.04255304e-01f, 5.64630330e-02f, -9.95377302e-02f, -8.81479010e-02f, 7.71716833e-02f, 1.29658021e-02f,
  -1.84618875e-01f, -7.71347992e-03f, 1.74558923e-01f, -1.13898978e-01f, -2.00828493e-01f, 1.68955699e-01f, -1.26739115e-01f, 3.53781022e-02f, 1.62682667e-01f, -3.83468159e-02f,
  2.43614018e-01f, -2.21766472e-01f, 1.52823448e-01f, -1.26909196e-01f, 3.34912539e-02f, 1.98869660e-01f, -4.79198359e-02f, -4.80354354e-02f, 2.44302116e-02f, -1.29264608e-01f,
  3.59816216e-02f, 4.12178263e-02f, 2.19647773e-03f, -1.08597413e-01f, 2.33373091e-01f, -3.88725549e-02f, -1.96212474e-02f, -1.24832885e-02f, 8.36951435e-02f, -1.11115977e-01f,
  -3.71150188e-02f, 5.69388457e-02f, 9.72552672e-02f, -8.01035091e-02f, 5.47398217e-02f, 8.42292905e-02f, -1.34528987e-02f, -7.97917843e-02f, -2.44612060e-02f, 3.69289331e-02f,
  9.52100158e-02f, -3.55638695e-05f, -7.54896030e-02f, -4.65039164e-02f, 4.90980688e-03f, 1.33504733e-01f, -1.74523994e-01f, 1.88751534e-01f, -9.88422707e-02f, 9.66221374e-03f,
  1.23297833e-01f, -1.86202347e-01f, -1.72946956e-02f, -5.14190234e-02f, -5.23545258e-02f, -3.59020792e-02f, 1.14182085e-01f, 3.65813263e-02f, -4.06920873e-02f, 7.16962293e-02f,
  -3.26491846e-03f, -8.59215707e-02f, 4.67841364e-02f, -1.13208964e-01f, -2.96176039e-02f, 9.86788273e-02f, -1.70228347e-01f, 6.53573424e-02f, -6.75934702e-02f, -9.05865356e-02f,
  1.26141399e-01f, 9.41555053e-02f, 4.54235859e-02f, -2.71482989e-02f, 9.34070498e-02f, 5.28497435e-02f, -1.27497688e-01f, -6.89770058e-02f, -1.83055252e-01f, 1.30538046e-01f,
  -1.41477987e-01f, -2.91082207e-02f, -1.66117717e-02f, 5.89105561e-02f, -3.34311351e-02f, -1.16600469e-01f, 9.56471488e-02f, 2.20444918e-01f, -1.41867772e-01f, 1.03394955e-01f,
  -7.87919089e-02f, -1.60091117e-01f, -1.03106812e-01f, 5.56806140e-02f, 1.24212606e-02f, -1.22935541e-01f, 9.31226760e-02f, 1.92381918e-01f, 5.74922599e-02f, 4.88864295e-02f,
  8.09474960e-02f, 1.38433322e-01f, 1.16751440e-01f, -7.59744123e-02f, -1.71304017e-01f, 1.25602663e-01f, 3.50171216e-02f, -9.33356136e-02f, 5.91425896e-02f, -3.86843979e-02f,
  -1.72877133e-01f, -5.65364324e-02f, -1.27749722e-02f, 2.14313045e-02f, -1.16611399e-01f, 1.77224189e-01f, 1.48137184e-02f, -1.02039248e-01f, 6.28194064e-02f, -6.50063083e-02f,
  5.58534227e-02f, 7.61315003e-02f, -2.45734695e-02f, 7.21595734e-02f, -1.03970356e-01f, -4.80572991e-02f, -7.32986927e-02f, 2.96488125e-02f, -9.58779231e-02f, 1.29012391e-01f,
  -7.74068385e-02f, 3.79812531e-02f, -1.65675536e-01f, -1.18383951e-01f, -1.70518950e-01f, 1.48508295e-01f, 1.50519088e-01f, -9.21348110e-02f, 5.44653162e-02f, -1.29392624e-01f,
  6.54162988e-02f, 2.13679522e-02f, -9.61840525e-02f, -7.99369067e-03f, 3.01247407e-02f, 2.27062702e-02f, -1.04803585e-01f, 1.88067392e-01f, 4.04620133e-02f, -5.79552986e-02f,
  9.28538218e-02f, 1.83991976e-02f, 6.27852082e-02f, 9.64544341e-02f, -5.82159534e-02f, -1.36239484e-01f, -1.66276153e-02f, 9.60356742e-02f, -1.09379262e-01f, -1.11127943e-02f,
  -2.24423520e-02f, 5.54432422e-02f, -6.04758225e-02f, -3.92709114e-02f, -3.92366620e-03f, -5.74967377e-02f, -8.15290287e-02f, -9.25236642e-02f, -1.45019427e-01f, 1.65566385e-01f,
  -4.86821830e-02f, -8.34925920e-02f, 7.85629898e-02f, -8.53317603e-02f, -5.17275110e-02f, 9.15871486e-02f, 1.22911148e-01f, 7.68786296e-02f, 2.71691568e-02f, -5.56627586e-02f,
  1.26439035e-01f, 5.80197126e-02f, -7.29807913e-02f, -1.22976497e-01f, -6.49103820e-02f, 7.44624659e-02f, -7.48726800e-02f, -1.26859015e-02f, 7.56955072e-02f, 1.50408887e-03f,
  -9.44127962e-02f, 8.38734657e-02f, -4.02778573e-02f, -6.15005568e-02f, -1.45187274e-01f, 1.65799372e-02f, -6.94783404e-03f, -3.69616114e-02f, 1.54873922e-01f, 6.24579936e-02f,
  -7.53707588e-02f, 1.18521810e-01f, 5.69773465e-02f, 1.81534976e-01f, -6.61367998e-02f, -1.38427824e-01f, 3.27861942e-02f, 3.31064351e-02f, -1.52660877e-01f, 9.33439061e-02f,
  -1.08241327e-01f, 5.10168895e-02f, -8.03229585e-02f, 4.49134037e-03f, -1.91913545e-02f, 2.04798713e-01f, 5.04020788e-02f, 1.10202126e-01f, -3.41669917e-02f, 1.14390343e-01f,
  3.08459364e-02f, -1.18289612e-01f, 8.98188278e-02f, -2.59022936e-02f, -1.23845331e-01f, 1.49412692e-01f, 2.03775112e-02f, 1.13709822e-01f, -5.72973378e-02f, 9.35791805e-02f,
  4.62126024e-02f, -1.42524522e-02f, 3.59012932e-02f, 1.44430861e-01f, 8.83786231e-02f, 1.17831759e-01f, 6.30079210e-02f, -7.56024793e-02f, -1.11861780e-01f, -6.06963225e-02f,
  2.01481916e-02f, -6.29708357e-03f, 6.49240166e-02f, -3.42131518e-02f, 1.18757449e-01f, -4.35862727e-02f, 6.45796731e-02f, -2.83499975e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.11973457e-01f, 9.71236825e-02f, 3.22421789e-02f, 1.46396339e-01f, 1.80353686e-01f, 1.80811122e-01f, -1.02432817e-01f, 1.57417431e-01f, -6.19775020e-02f, -8.62729698e-02f,
  1.31752774e-01f, 1.04875013e-01f, -5.95101155e-03f, 5.61116003e-02f, -1.48766339e-01f, -1.44740999e-01f, 1.38108522e-01f, 4.47128154e-02f, -9.73160118e-02f, -7.33521506e-02f,
  -8.17481577e-02f, -9.64745805e-02f, -4.13954593e-02f, -1.98417567e-02f, 1.27208456e-01f, -1.62776038e-01f, -6.13376126e-03f, -1.14369486e-02f, -1.62144250e-04f, 1.56872068e-02f,
  -1.26229953e-02f, -1.68358952e-01f, 1.01130076e-01f, -1.21352419e-01f, -5.24814799e-02f, -4.65223044e-02f, 9.94819328e-02f, 1.24025427e-01f, -8.90225619e-02f, 1.12736672e-01f,
  -1.30087703e-01f, 7.45861009e-02f, -4.04000543e-02f, 2.59295236e-02f, 1.76921383e-01f, -6.94879517e-02f, -1.37025025e-02f, 2.33537499e-02f, 7.86088407e-02f, -1.04543440e-01f,
  2.00930722e-02f, 9.14772823e-02f, -1.09941520e-01f, -5.85237108e-02f, -3.03773656e-02f, 9.67515856e-02f, -5.49836736e-03f, 9.31317285e-02f, 1.25629067e-01f, 4.86618765e-02f,
  5.34030469e-03f, 4.73062284e-02f, 1.09502368e-01f, -6.59929737e-02f, 1.84020065e-02f, 5.42345904e-02f, 1.66320071e-01f, 1.56079352e-01f, 1.62116706e-01f, 2.61202380e-02f,
  -2.90549989e-03f, -7.19084889e-02f, 5.71199842e-02f, 6.56839758e-02f, 7.64975622e-02f, 1.74591064e-01f, -6.05701432e-02f, -1.65169537e-01f, 2.93958664e-01f, -1.12674525e-02f,
  -1.95313409e-01f, 1.31927624e-01f, -3.34269851e-02f, 1.83615446e-01f, 1.11144975e-01f, 1.86378986e-01f, -8.52170661e-02f, -1.43346936e-01f, -1.49043649e-02f, 2.31025696e-01f,
  -5.06572938e-03f, -4.39566374e-02f, 1.23754129e-01f, -7.50444010e-02f, -1.58961952e-01f, 1.54600143e-01f, 1.55492136e-02f, 1.29257083e-01f, 2.03063369e-01f, 1.74281597e-01f,
  1.28808275e-01f, 5.19754924e-02f, 1.53689370e-01f, 9.65727493e-02f, 2.54975297e-02f, -8.25010389e-02f, 4.01165634e-02f, -9.41453725e-02f, -3.41808088e-02f, -1.31045040e-02f,
  2.32695024e-02f, 1.81393057e-01f, 4.68937904e-02f, -7.58434609e-02f, -6.75164014e-02f, 2.75308266e-03f, 1.38626307e-01f, -1.07134497e-02f, 5.27670160e-02f, -1.14990316e-01f,
  1.90114632e-01f, 2.69601673e-01f, 1.81243755e-03f, 2.30013967e-01f, 6.16495311e-02f, 9.67731550e-02f, -4.29303832e-02f, 2.96085417e-01f, 3.70305032e-02f, 8.30583274e-03f,
  1.83365226e-01f, 1.81508541e-01f, 1.96099542e-02f, 1.68528676e-01f, 1.22500710e-01f, 7.91000426e-02f, 7.32651949e-02f, -5.31824045e-02f, -4.34058383e-02f, 5.82470186e-03f,
  1.26917139e-01f, 1.50121123e-01f, -3.56255062e-02f, -3.63187562e-03f, -4.78564091e-02f, 4.58290502e-02f, -7.08267912e-02f, 1.21977597e-01f, 2.02435292e-02f, -3.28691266e-02f,
  7.63945729e-02f, -3.13033611e-02f, 2.62175426e-02f, 9.19466093e-02f, 8.00416525e-03f, 4.04430293e-02f, 1.96500290e-02f, -1.39085930e-02f, -1.19770780e-01f, 6.07493035e-02f,
  1.94702169e-03f, 7.05999928e-03f, -8.22770819e-02f, 1.77724108e-01f, 6.72352538e-02f, 4.89322320e-02f, -4.07934450e-02f, -9.48258862e-03f, -9.80848968e-02f, -6.68657795e-02f,
  1.25773087e-01f, -1.09630771e-01f, -9.17644724e-02f, -6.08241893e-02f, -1.20260693e-01f, 6.75664619e-02f, 1.37167156e-01f, -1.15129873e-01f, -9.52106714e-02f, 3.72690856e-02f,
  7.92208388e-02f, -4.05917056e-02f, 4.16465178e-02f, 6.24281354e-03f, -1.03297293e-01f, 1.24086842e-01f, -7.62708113e-02f, -8.03937986e-02f, -2.32793782e-02f, -1.10056058e-01f,
  7.96005502e-02f, 1.00821286e-01f, 1.08724296e-01f, -1.05357938e-01f, -1.88681763e-02f, -3.47114503e-02f, 8.48905295e-02f, 1.35780498e-01f, 1.61870614e-01f, 7.04018446e-03f,
  -1.45826593e-01f, 4.59640510e-02f, 1.16407469e-01f, 1.10316597e-01f, -1.46549821e-01f, 1.97457939e-01f, 1.20683223e-01f, -5.08575998e-02f, 1.61967218e-01f, 1.25031583e-02f,
  1.21844366e-01f, -8.03425983e-02f, 1.43119872e-01f, -6.55848607e-02f, 1.20801702e-01f, 2.12952629e-01f, 6.72142729e-02f, 1.47826776e-01f, 4.43199165e-02f, -1.37945697e-01f,
  9.42722112e-02f, -9.76795778e-02f, 8.65958631e-02f, 1.44079956e-03f, -6.02866299e-02f, -8.00333470e-02f, 1.06244013e-01f, 5.74511364e-02f, 9.70086679e-02f, -8.18239376e-02f,
  -1.03264585e-01f, 1.57371536e-01f, -1.53611386e-02f, 5.57360649e-02f, -3.51889469e-02f, 4.16895151e-02f, -9.68697593e-02f, -1.09212972e-01f, 6.13630228e-02f, -1.95400044e-02f,
  -6.17678873e-02f, -4.03398126e-02f, 5.51732928e-02f, -2.45728139e-02f, 7.72132725e-02f, 1.72893573e-02f, 8.02002475e-02f, 4.55076583e-02f, -4.80561488e-04f, -2.79973894e-02f,
  7.16943294e-02f, -2.77856793e-02f, 4.04197313e-02f, -8.57651234e-02f, -9.40891355e-02f, -3.11884992e-02f, -9.85449627e-02f, 1.14730768e-01f, 1.82523075e-02f, 2.28176676e-02f,
  1.11617558e-01f, 4.43641059e-02f, 1.74044237e-01f, 1.45951465e-01f, 1.50584042e-01f, 7.97682479e-02f, 1.16439223e-01f, -6.08096160e-02f, -1.84364945e-01f, 1.00750461e-01f,
  1.25632778e-01f, -1.08748138e-01f, -3.68682817e-02f, 5.93282804e-02f, -1.75832212e-01f, -1.38162300e-01f, 7.03832209e-02f, 1.94469616e-01f, 2.86307126e-01f, 9.64400396e-02f,
  -6.90406263e-02f, 1.44297227e-01f, -2.93327216e-03f, -1.80711318e-02f, 6.97287098e-02f, -2.85156700e-03f, 1.19272560e-01f, -1.01736318e-02f, 7.83908740e-02f, 8.07842240e-02f,
  4.95919585e-02f, 2.04383314e-01f, 5.23239672e-02f, 2.86973901e-02f, 8.09821635e-02f, 9.44985524e-02f, -4.68908399e-02f, -1.78728048e-02f, 6.91498164e-03f, -7.85398707e-02f,
  6.99728653e-02f, -5.76354526e-02f, 2.77532469e-02f, -1.09355718e-01f, 5.28804325e-02f, -6.39880970e-02f, -9.80453715e-02f, 3.12036406e-02f, -8.88257250e-02f, 8.35449249e-02f,
  1.03134498e-01f, 1.06999390e-01f, -1.18974254e-01f, -1.48339748e-01f, -5.74710146e-02f, 4.94157849e-03f, 2.46654917e-02f, 7.12687373e-02f, -1.04106814e-01f, 1.22292794e-01f,
  -1.16176367e-01f, -2.11095382e-02f, -3.23791020e-02f, 1.07985049e-01f, -2.65753781e-03f, -9.09343362e-02f, 1.30501822e-01f, 4.69823964e-02f, -1.53048024e-01f, 1.25559554e-01f,
  8.82528648e-02f, 6.27946556e-02f, -6.85426891e-02f, -2.76248343e-02f, -1.28900409e-01f, 6.54767305e-02f, -3.70287225e-02f, -1.33488938e-01f, 1.41280353e-01f, -1.58666417e-01f,
  1.35223165e-01f, -7.12641329e-02f, 1.40597090e-01f, 1.39593467e-01f, -1.20721549e-01f, -2.75886022e-02f, 1.03807049e-02f, 3.89404558e-02f, 8.26367661e-02f, 9.24716741e-02f,
  6.86876699e-02f, -1.11203771e-02f, 1.49890512e-01f, 6.03319667e-02f, -6.67588115e-02f, 7.20923301e-03f, 2.10331380e-03f, 3.21268253e-02f, -1.27415052e-02f, 8.37174356e-02f,
  1.31291032e-01f, 5.19986451e-02f, -6.06464781e-02f, -6.02762327e-02f, 2.45272797e-02f, -8.80379975e-02f, -9.83977243e-02f, 5.33833392e-02f, -3.27068307e-02f, 1.50023118e-01f,
  1.22920377e-02f, -6.49899468e-02f, -3.03939614e-03f, 1.41222477e-01f, -9.22636613e-02f, 9.88535360e-02f, 7.07572028e-02f, -4.24324349e-02f, -4.42077629e-02f, -5.32790609e-02f,
  -7.24982917e-02f, -8.19479823e-02f, 6.05235845e-02f, -1.21369414e-01f, 1.73351690e-02f, 1.55850559e-01f, 2.27519885e-01f, 1.42039612e-01f, 2.00381160e-01f, 3.74881737e-02f,
  -6.98524117e-02f, 9.18913037e-02f, 9.70755965e-02f, -8.04478079e-02f, 1.03032775e-01f, 1.86714604e-01f, 2.14793384e-01f, 1.91974882e-02f, 1.15315847e-01f, 7.38822594e-02f,
  -7.24028647e-02f, 1.28520355e-01f, 2.36029066e-02f, 1.77730411e-01f, 4.95123379e-02f, 1.67218316e-02f, 2.44647972e-02f, -1.99816182e-01f, 8.53724256e-02f, 4.79991995e-02f,
  -3.94824445e-02f, -1.39143700e-02f, 9.36712921e-02f, 1.78567246e-01f, 2.37837303e-02f, -1.25891477e-01f, -5.90110384e-02f, -8.24354589e-02f, 4.16238420e-02f, 1.02795828e-02f,
  1.10080287e-01f, 9.25028399e-02f, -2.72626244e-02f, -6.60526603e-02f, -5.77985458e-02f, 3.86185269e-03f, -4.12595607e-02f, -6.58555254e-02f, -3.33423316e-02f, -8.30245018e-02f,
  1.50459528e-01f, 1.84263512e-01f, 2.27854569e-02f, -4.36346978e-02f, -1.49225676e-02f, 1.25256911e-01f, 1.03410266e-01f, 6.39369860e-02f, 1.02950642e-02f, -5.70961088e-02f,
  -3.63957211e-02f, 1.51157692e-01f, 3.24880816e-02f, 4.67806160e-02f, -1.29861355e-01f, 1.25516206e-01f, 1.57494694e-01f, 1.48945868e-01f, 1.60146236e-01f, -4.57926566e-04f,
  -8.51316601e-02f, -3.81441088e-03f, -1.66255850e-02f, 1.42008469e-01f, 3.34864371e-02f, 1.44699916e-01f, 5.59346713e-02f, 2.02998757e-01f, -3.58446874e-02f, 1.13942198e-01f,
  -2.24842861e-01f, 1.84318367e-02f, -4.14469317e-02f, -7.97178820e-02f, 1.20714419e-01f, 3.40885185e-02f, -1.49134457e-01f, -2.33411510e-02f, 1.48408517e-01f, 2.13372394e-01f,
  -1.05158396e-01f, 2.74881776e-02f, -5.84489619e-03f, 1.14888631e-01f, -3.41218933e-02f, -2.64228955e-02f, 1.16275460e-01f, 1.12962581e-01f, 1.59589410e-01f, 6.70159832e-02f,
  2.57192496e-02f, 4.36675958e-02f, -7.61695355e-02f, -6.91419188e-03f, -2.40660515e-02f, 1.88019350e-01f, 1.05223142e-01f, 7.79317766e-02f, 4.38993052e-02f, -5.85083850e-02f,
  -9.94684622e-02f, -4.18511145e-02f, 8.66580978e-02f, -7.14318305e-02f, -6.20151032e-03f, 1.51680701e-03f, -1.05265476e-01f, 6.71590045e-02f, -1.23658434e-01f, 2.26431265e-02f,
  7.10525587e-02f, 6.82361722e-02f, -8.46990347e-02f, -1.00918204e-01f, 1.32544070e-01f, 8.75862092e-02f, 9.34969261e-02f, -7.36901015e-02f, 1.13087378e-01f, 1.01203002e-01f,
  1.32728621e-01f, 7.06988126e-02f, 1.66609228e-01f, 1.00934952e-01f, 6.88815936e-02f, 8.44498202e-02f, 6.51093274e-02f, 4.95412648e-02f, 7.68452436e-02f, -2.57137269e-02f,
  5.05356640e-02f, -8.73579159e-02f, 6.20560944e-02f, -6.21342845e-02f, -3.51283588e-02f, -4.55722138e-02f, 1.49148151e-01f, -2.53092032e-02f, -1.12577468e-01f, -3.59955281e-02f,
  -1.44697890e-01f, 5.70214093e-02f, 1.41276747e-01f, 2.63948828e-01f, -6.71235919e-02f, -6.74313828e-02f, 5.94133884e-02f, 1.76283702e-01f, -1.07919596e-01f, 7.41882399e-02f,
  -9.32525098e-03f, 7.62626529e-02f, 7.21126124e-02f, 1.46258831e-01f, -1.11736208e-01f, -7.57041946e-02f, 1.25906602e-01f, 1.39366686e-01f, 1.05228528e-01f, 2.00426757e-01f,
  1.24167755e-01f, -6.03295267e-02f, 1.43730327e-01f, -6.85941875e-02f, -4.43598256e-02f, -1.04335494e-01f, -7.41414428e-02f, 1.10831939e-01f, 1.82319596e-01f, 4.84732501e-02f,
  8.16873014e-02f, -7.00087994e-02f, -2.30941214e-02f, -1.01022674e-02f, -1.25327900e-01f, -3.69394161e-02f, 1.36098802e-01f, -1.62176937e-01f, 9.21624079e-02f, 1.16268501e-01f,
  4.81380895e-02f, 2.72942632e-01f, -4.27547768e-02f, 1.55157104e-01f, 1.34961754e-01f, 1.37101054e-01f, -1.11465067e-01f, -1.11908615e-01f, 1.16092905e-01f, 8.88133273e-02f,
  8.08698833e-02f, -4.38317694e-02f, 1.19948767e-01f, 1.08469412e-01f, -2.61340961e-02f, -4.83176485e-02f, 4.11880501e-02f, -7.53070191e-02f, -1.16423823e-01f, 1.33356571e-01f,
  -3.11809815e-02f, -4.09987643e-02f, 1.48799032e-01f, 4.80318209e-03f, 6.55979738e-02f, -1.56281725e-01f, -4.12710495e-02f, -4.24799398e-02f, 7.24270865e-02f, 3.73147689e-02f,
  1.34204216e-02f, 7.65818208e-02f, 3.78414877e-02f, -2.38791257e-02f, 1.53931519e-02f, 5.46025969e-02f, 5.58083504e-02f, 8.83548334e-03f, 1.51361555e-01f, -3.14888880e-02f,
  -1.29202139e-02f, 5.45812435e-02f, 7.46399984e-02f, -4.25238051e-02f, 7.13102818e-02f, -7.38971382e-02f, -8.50860029e-02f, -1.32199675e-01f, 1.52937844e-02f, -6.55833483e-02f,
  1.95057783e-02f, -8.89795274e-03f, -6.45559430e-02f, 5.32498956e-02f, -5.97987846e-02f, 5.34645133e-02f, -3.83566953e-02f, 5.42881303e-02f, 9.71216857e-02f, -4.10076454e-02f,
  -1.11380532e-01f, 4.27658297e-02f, 5.36857918e-02f, -2.62281182e-03f, 1.05179802e-01f, 9.09293517e-02f, -2.93223374e-02f, -6.48923311e-03f, 1.04957409e-01f, -1.76670067e-02f,
  1.13881804e-01f, 6.82642981e-02f, 1.06212288e-01f, 7.88227841e-02f, 3.75274569e-02f, -6.26233742e-02f, -7.88352825e-03f, 1.06344156e-01f, 8.46319050e-02f, 1.37523606e-01f,
  1.30749881e-01f, 3.94562678e-03f, -1.18118105e-02f, 1.74715854e-02f, -2.20375583e-02f, -1.30446767e-02f, -1.65603124e-02f, 3.49263661e-02f, -2.36704215e-01f, 1.27910346e-01f,
  5.19104414e-02f, 1.31502032e-01f, 2.51964480e-01f, -1.10751860e-01f, -2.39977408e-02f, 2.39614159e-01f, -1.31392226e-01f, -1.32279447e-03f, -6.82488009e-02f, 4.73933369e-02f,
  1.79402143e-01f, -1.99339502e-02f, -5.25139384e-02f, 3.47361378e-02f, 1.42376170e-01f, 2.57815141e-02f, 6.42745718e-02f, 4.87641133e-02f, 3.04661691e-02f, 3.52309160e-02f,
  9.08797681e-02f, 1.45426959e-01f, 9.60217640e-02f, 4.51277047e-02f, -1.05535790e-01f, 5.10011204e-02f, 1.15987644e-01f, 7.67492428e-02f, -5.83816506e-02f, 7.60575980e-02f,
  -2.08497681e-02f, -1.15025565e-01f, -2.15230379e-02f, -9.37117562e-02f, 1.07060194e-01f, -1.35148793e-01f, -1.44350946e-01f, -9.08403024e-02f, 8.78601596e-02f, 1.37664452e-01f,
  -4.04208750e-02f, -5.86492568e-02f, 1.89692199e-01f, 3.12535353e-02f, -4.33115102e-02f, -9.98937264e-02f, 4.65004705e-03f, 2.16875579e-02f, 8.57388005e-02f, 5.37696555e-02f,
  2.68420037e-02f, 5.31169139e-02f, 4.16968539e-02f, -1.48935458e-02f, 8.03536829e-03f, -3.80752198e-02f, 1.20152436e-01f, -1.57362118e-01f, -2.01980192e-02f, -1.19375348e-01f,
  -1.83033988e-01f, 8.89419094e-02f, 5.03373854e-02f, 1.44565523e-01f, -1.40887722e-01f, -2.19016805e-01f, 9.86706913e-02f, 1.51714636e-02f, 6.12049140e-02f, 7.26353377e-02f,
  5.62702417e-02f, 5.54689877e-02f, 1.47572774e-02f, -7.28287399e-02f, 3.05794347e-02f, -1.49505988e-01f, -1.76425930e-02f, 8.27927981e-03f, 2.91677769e-02f, -5.94878905e-02f,
  -8.69633034e-02f, -1.17505230e-01f, 1.09495796e-01f, -4.55576591e-02f, 5.36623448e-02f, 5.87588176e-02f, -4.67456542e-02f, -2.40114480e-02f, 5.31636365e-02f, -9.62565392e-02f,
  -2.81381737e-02f, 1.17681064e-01f, 8.42941254e-02f, -1.09240748e-01f, -8.63105711e-03f, 1.07780136e-01f, -1.00615181e-01f, 7.01695830e-02f, 5.09230010e-02f, -1.15845464e-01f,
  1.10367402e-01f, 1.78172007e-01f, -1.20270535e-01f, -4.32071649e-02f, -7.65967742e-02f, -1.07020875e-02f, -1.26508862e-01f, -2.25931499e-02f, -7.03712478e-02f, 7.24433223e-03f,
  1.17289394e-01f, 1.34795934e-01f, -3.32919210e-02f, -9.48526636e-02f, 1.74632579e-01f, -2.41444539e-02f, -2.96107749e-03f, 1.22999638e-01f, -5.44349812e-02f, -3.87593247e-02f,
  -1.08187264e-02f, 1.26076967e-01f, 1.63273439e-01f, 8.68528429e-03f, 8.81148577e-02f, 7.15321675e-02f, 1.36717046e-02f, 1.02490999e-01f, 1.08026579e-01f, 9.55246612e-02f,
  2.29495838e-02f, 1.03483111e-01f, -5.27554415e-02f, -6.39666279e-04f, 6.03472441e-02f, 3.74978371e-02f, 1.35211989e-01f, -3.36644985e-02f, 1.33670166e-01f, -5.26981764e-02f,
  -2.55410057e-02f, 6.88548982e-02f, -7.50238448e-02f, 5.33243790e-02f, 8.55242312e-02f, 2.03362247e-03f, 1.41977623e-01f, 1.00762300e-01f, -2.18830220e-02f, 4.20865454e-02f,
  1.02581792e-01f, 1.03791662e-01f, -4.82206754e-02f, 4.94258255e-02f, 5.56502827e-02f, 3.61156184e-03f, -3.28153595e-02f, 1.94085967e-02f, 2.18912959e-02f, 1.30534815e-02f,
  4.81980182e-02f, 6.13810234e-02f, 1.54717460e-01f, -2.57021599e-02f, -1.16303258e-01f, 2.84991004e-02f, -6.58385903e-02f, 1.05345316e-01f, -1.16700396e-01f, -7.88465664e-02f,
  -2.35852748e-02f, 3.31770219e-02f, -6.99624047e-03f, 9.15539488e-02f, -1.00282140e-01f, 9.19191167e-02f, 1.28712699e-01f, 7.21971784e-03f, 7.72207379e-02f, -8.45058635e-02f,
  6.56481758e-02f, 7.85230622e-02f, -1.15448676e-01f, 1.35624886e-01f, 5.72604276e-02f, -8.29666704e-02f, -4.69703563e-02f, 6.81545213e-02f, 3.62941995e-02f, -4.75475341e-02f,
  1.27079652e-03f, 4.26721573e-03f, 1.09073520e-02f, 5.79692535e-02f, -1.60447001e-01f, -8.65778923e-02f, -7.81298429e-02f, -3.78322750e-02f, -7.98846185e-02f, 1.70357991e-02f,
  -1.07000247e-02f, -7.15622604e-02f, -9.10902992e-02f, 3.72919478e-02f, -5.65686151e-02f, 8.68398473e-02f, 6.47545755e-02f, 2.69048288e-02f, 3.07653584e-02f, 1.44809663e-01f,
  9.72466096e-02f, -2.73825806e-02f, 1.38630018e-01f, 9.81167778e-02f, -8.23523775e-02f, -9.27627310e-02f, 5.05100563e-03f, -1.85471177e-02f, -2.14220397e-02f, 6.27016202e-02f,
  -1.12355046e-01f, -7.27556497e-02f, -1.98884178e-02f, -3.00532989e-02f, 1.83407757e-02f, -9.54182521e-02f, -4.68911463e-03f, 9.32958443e-03f, 1.49064749e-01f, 8.68743137e-02f,
  2.83933692e-02f, 2.95637250e-02f, -9.11622867e-02f, 1.12378314e-01f, -1.19579062e-02f, 5.71100302e-02f, 3.47363465e-02f, 1.33174821e-03f, 1.80667162e-01f, 3.61546502e-02f,
  -4.64001149e-02f, -3.24982516e-02f, 1.99076235e-01f, 1.65688261e-01f, -4.74955812e-02f, 1.85753390e-01f, 1.67450011e-01f, -8.72341450e-03f, -2.23126277e-01f, 1.80732459e-01f,
  1.07306622e-01f, 1.20689467e-01f, 8.68780166e-02f, -7.14150071e-02f, 1.32133827e-01f, -1.15348101e-01f, 2.18123645e-01f, 1.01476103e-01f, 1.40569523e-01f, 1.84520259e-01f,
  -7.38745630e-02f, 7.76675195e-02f, 7.72696510e-02f, -2.12434605e-02f, 9.53400284e-02f, 6.08998984e-02f, 1.34715915e-01f, -1.64850429e-02f, 8.27030540e-02f, 1.47380501e-01f,
  -1.39036002e-02f, 1.02029100e-01f, -4.02520075e-02f, 3.18769850e-02f, -6.28073812e-02f, -5.68296164e-02f, 2.33168947e-03f, 3.05148419e-02f, 4.99871001e-02f, -5.26927831e-03f,
  -5.28680161e-03f, 6.58367723e-02f, -6.69346452e-02f, 9.61942524e-02f, -2.99137123e-02f, 9.41601470e-02f, 3.67309935e-02f, -6.17536120e-02f, -4.26415540e-02f, -5.81877083e-02f,
  -1.24550395e-01f, 6.83716536e-02f, 1.03106633e-01f, 8.96935537e-02f, 4.64058183e-02f, -1.55515492e-01f, 5.47895841e-02f, 2.61508320e-02f, 1.35742715e-02f, 2.90939622e-02f,
  6.27897903e-02f, 1.38917908e-01f, 4.98168878e-02f, -1.74892582e-02f, -1.08709469e-01f, 1.04581183e-02f, 1.41132236e-01f, 9.30498093e-02f, -8.34264234e-02f, -3.19527142e-04f,
  -1.52511029e-02f, 1.10675842e-01f, -8.14374387e-02f, 4.89254631e-02f, 4.97897230e-02f, 7.95308724e-02f, -1.12203643e-01f, -1.24079339e-01f, -1.01123244e-01f, 8.58114213e-02f,
  7.13625923e-02f, 8.91099721e-02f, 1.13849729e-01f, 1.34763613e-01f, 1.77776907e-02f, 2.08794978e-02f, 4.83474024e-02f, 6.53122067e-02f, 2.04790812e-02f, -1.26514351e-02f,
  9.97090861e-02f, 1.67370230e-01f, 2.88229175e-02f, 3.52870077e-02f, -9.23997089e-02f, 7.89855123e-02f, -4.78725918e-02f, -1.03011943e-01f, 6.11616783e-02f, -3.14526968e-02f,
  -7.90087208e-02f, 1.77634746e-01f, 1.63929194e-01f, 1.30093008e-01f, 9.12194923e-02f, -7.84904212e-02f, 1.66278128e-02f, -1.99523531e-02f, -3.34753655e-02f, 1.94698513e-01f,
  -1.25368625e-01f, 6.57908618e-02f, 1.38953149e-01f, -1.41350850e-02f, 9.51210409e-02f, -1.28622130e-01f, -2.04456318e-02f, 9.31179672e-02f, -1.21575318e-01f, -1.44474030e-01f,
  1.91310212e-01f, 1.26565704e-02f, -1.39494836e-01f, 1.96181238e-02f, 5.67850797e-03f, 1.45037666e-01f, 6.03960268e-02f, -8.41468852e-03f, 3.74942124e-02f, -5.34934402e-02f,
  1.64622925e-02f, 2.29889993e-02f, 1.17317535e-01f, -9.31897983e-02f, -5.47446012e-02f, 6.76197335e-02f, -8.67205486e-03f, -6.89919293e-02f, -3.76309231e-02f, 2.47137863e-02f,
  3.57180252e-03f, -4.14619426e-04f, -1.25973701e-01f, 1.08635254e-01f, -1.23523902e-02f, 9.91099849e-02f, 1.46309584e-01f, -1.08450525e-01f, 6.52925596e-02f, 1.49630815e-01f,
  -9.77961197e-02f, -1.30295724e-01f, 2.05681827e-02f, 3.55092362e-02f, 9.95514616e-02f, 1.24243751e-01f, -1.31177545e-01f, -1.25837177e-01f, 4.80353273e-02f, -1.11174146e-02f,
  -1.05203502e-02f, -1.08782142e-01f, -8.11686665e-02f, 1.12645805e-01f, -1.01595856e-01f, 9.34333354e-02f, 1.30470872e-01f, 6.43729642e-02f, -6.29762944e-04f, 6.55692890e-02f,
  2.05463134e-02f, -1.05276704e-01f, 3.27669457e-02f, -8.12659934e-02f, -1.69007331e-02f, 9.05421078e-02f, -6.69332817e-02f, -8.88900310e-02f, 1.22526862e-01f, -1.15397751e-01f,
  3.65328826e-02f, 5.59828766e-02f, -1.00218154e-01f, -1.11749589e-01f, -4.67377678e-02f, 1.30578764e-02f, 1.02923162e-01f, -1.59027055e-02f, -6.35814294e-02f, -4.42842990e-02f,
  7.33062774e-02f, 1.07156731e-01f, 3.34655005e-03f, 3.26753072e-02f, -7.43649667e-03f, -3.20939831e-02f, -7.27067590e-02f, 1.40149221e-01f, 1.06465235e-01f, -1.59381852e-02f,
  4.95685153e-02f, 1.20819367e-01f, 9.72901980e-05f, 2.62788665e-02f, 1.07747376e-01f, -4.97514978e-02f, 1.40252426e-01f, -1.08078033e-01f, 1.22240648e-01f, 8.80520865e-02f,
  1.66658685e-02f, 1.47708103e-01f, 9.80553702e-02f, 1.03529498e-01f, 1.09635137e-01f, -1.20998271e-01f, -4.67330664e-02f, -3.04866452e-02f, -7.44178295e-02f, 3.67545115e-04f,
  -2.47662570e-02f, 8.13934132e-02f, 1.47514641e-01f, 1.50675535e-01f, 1.02339620e-02f, -1.15635268e-01f, 1.00141257e-01f, 3.63570973e-02f, 1.01461537e-01f, -2.02799612e-03f,
  3.34590301e-02f, 5.81586845e-02f, -5.04927672e-02f, -9.92828682e-02f, -1.02590196e-01f, -1.65915117e-02f, 1.63583696e-01f, -4.50349636e-02f, -3.66874188e-02f, 1.12092517e-01f,
  4.08955328e-02f, 5.53307161e-02f, -4.56270911e-02f, 1.83436528e-01f, 1.09502897e-01f, 1.25997245e-01f, -8.75855833e-02f, -2.06332672e-02f, -7.83316940e-02f, -9.78937820e-02f,
  -3.89559602e-04f, 7.30501413e-02f, 3.58036980e-02f, 5.79214469e-03f, 9.51648876e-02f, -6.10142713e-03f, 5.48195466e-02f, -6.46264404e-02f, 5.90062402e-02f, 1.64469808e-01f,
  3.97409014e-02f, 1.94629654e-01f, 8.44070390e-02f, -6.35493994e-02f, -2.41929963e-02f, 2.18741879e-01f, 1.73670217e-01f, 6.49700090e-02f, 1.51862100e-01f, -7.33950883e-02f,
  4.06554714e-02f, -6.32100254e-02f, 2.11713716e-01f, 1.33289173e-01f, 1.69796556e-01f, 8.23492706e-02f, -9.41454619e-02f, 2.06929557e-02f, -2.75239497e-02f, -1.37265146e-01f,
  1.50593236e-01f, -4.95786369e-02f, 1.55106738e-01f, 1.35953762e-02f, -2.88578626e-02f, -6.62790760e-02f, 7.35534728e-02f, 7.72117525e-02f, 9.05825011e-03f, 4.88708802e-02f,
  1.14590377e-01f, -1.09408103e-01f, 3.18970904e-02f, -1.01703107e-02f, 2.69321154e-05f, 1.11812912e-01f, 6.61826953e-02f, -1.07112266e-01f, 8.31225291e-02f, -2.24403497e-02f,
  5.58001623e-02f, 3.29194479e-02f, -8.95756781e-02f, 3.48672047e-02f, 8.55465904e-02f, 1.62380174e-01f, 4.65429714e-03f, 1.51460350e-01f, -1.09323710e-01f, -1.09267943e-01f,
  1.32343825e-02f, -1.19187534e-01f, -1.31876647e-01f, 3.84832062e-02f, 1.74262049e-03f, 1.04563028e-01f, 1.02459580e-01f, 9.50097889e-02f, 1.14976928e-01f, -9.40112583e-03f,
  7.94131905e-02f, 1.17119558e-01f, -2.82476116e-02f, -5.36291450e-02f, 6.79645613e-02f, 3.94300409e-02f, 1.24661058e-01f, 7.59219304e-02f, -6.95866533e-03f, 2.24196836e-02f,
  5.31909615e-02f, 4.29444425e-02f, -2.31942385e-02f, 5.25671840e-02f, -1.67472869e-01f, -2.56309118e-02f, 1.44638553e-01f, 2.04696715e-01f, 3.61970551e-02f, 8.00607055e-02f,
  5.83567582e-02f, 4.01772596e-02f, -2.39419583e-02f, 1.37410755e-03f, 8.36455226e-02f, 1.66747384e-02f, 1.61104962e-01f, 2.07574055e-01f, -1.46149620e-01f, 9.60156247e-02f,
  1.83281258e-01f, -3.25899310e-02f, 1.15627892e-01f, -4.33366792e-03f, 1.79012436e-02f, -1.30340293e-01f, 1.25187203e-01f, 1.23670854e-01f, 1.96926147e-02f, -1.02635533e-01f,
  7.83762559e-02f, 1.31703407e-01f, 4.59988825e-02f, -1.09697618e-01f, -9.47005600e-02f, 1.20728664e-01f, 3.58791649e-02f, -1.29348068e-02f, 1.32502168e-01f, 4.01633494e-02f,
  1.33626014e-02f, -7.48825958e-03f, -8.80014524e-02f, -3.87065485e-02f, -1.29989788e-01f, 1.75858848e-02f, 1.09008171e-01f, 9.93278623e-02f, 1.54626429e-01f, 1.01887859e-01f,
  1.40398264e-01f, 1.48502469e-01f, -2.60313805e-02f, -3.20912674e-02f, 1.17380053e-01f, 1.58906624e-01f, 6.84696734e-02f, 9.00103375e-02f, 8.85297209e-02f, -3.26307826e-02f,
  1.42624915e-01f, 5.70500530e-02f, 3.75569761e-02f, -1.88827351e-01f, -1.14797883e-01f, 3.86704728e-02f, -2.64509711e-02f, 4.51283343e-02f, 1.21840619e-01f, -2.43198201e-02f,
  -2.00741738e-01f, -1.81055859e-01f, -2.05154091e-01f, 1.15129113e-01f, -4.83512655e-02f, -1.71127811e-01f, -5.83597235e-02f, 2.45229736e-01f, -1.08651752e-02f, 3.82815078e-02f,
  1.54381171e-01f, 2.26111099e-01f, -9.02777910e-02f, 1.56645045e-01f, 9.01551917e-02f, -5.58089092e-02f, 1.23571880e-01f, 1.14494391e-01f, 7.81319737e-02f, 2.77139302e-02f,
  9.23513472e-02f, 9.94272754e-02f, -1.02645956e-01f, -9.89412144e-02f, 1.38401374e-01f, 1.50885120e-01f, -1.01439998e-01f, -3.17809470e-02f, -1.04938280e-02f, 2.79870898e-01f,
  -7.70381987e-02f, 4.66183275e-02f, 1.65862307e-01f, -9.00946781e-02f, -1.29377693e-01f, -3.36447507e-02f, 5.40351830e-02f, 1.40192047e-01f, 1.55090287e-01f, 1.03050761e-01f,
  1.72980100e-01f, -1.66899264e-02f, -1.04230881e-01f, 4.57821898e-02f, 1.74301669e-01f, 4.94604409e-02f, 1.09341495e-01f, 1.36261880e-01f, 1.57805011e-01f, -4.62558009e-02f,
  2.77097449e-02f, -1.59688126e-02f, 1.88592255e-01f, -1.15029342e-01f, 6.00996008e-03f, 2.45626867e-02f, 3.08383517e-02f, -1.14700869e-02f, 4.08014245e-02f, -8.18804577e-02f,
  2.10351720e-02f, 1.26786068e-01f, -1.37492955e-01f, 1.34912670e-01f, -1.44354925e-01f, 2.68561784e-02f, -5.41387834e-02f, -1.83053017e-01f, -1.32677350e-02f, 9.91063341e-02f,
  5.29173985e-02f, -3.01505234e-02f, 9.36215818e-02f, 1.45225197e-01f, 9.74068418e-03f, 3.40000205e-02f, -1.32383958e-01f, 8.09074566e-02f, 3.61061357e-02f, 2.40386557e-02f,
  5.28617948e-02f, 3.52673866e-02f, -8.50690827e-02f, -8.18172172e-02f, -6.47902954e-03f, 1.24785103e-01f, -2.48710979e-02f, -3.52961086e-02f, -1.05805002e-01f, 9.26563218e-02f,
  -6.13400713e-02f, 8.62743482e-02f, -3.54429968e-02f, 9.34971198e-02f, -1.11508429e-01f, -1.14813119e-01f, -5.95590658e-02f, 5.77031821e-02f, 5.07919714e-02f, -5.35540804e-02f,
  2.98973229e-02f, -4.50363867e-02f, -2.18269657e-02f, 2.56364465e-01f, -8.83670673e-02f, 6.54870924e-03f, 1.86361715e-01f, -3.49061750e-02f, -6.18419424e-02f, 6.08152971e-02f,
  1.32287711e-01f, -7.95519426e-02f, 4.61871289e-02f, 8.91202018e-02f, -1.17773553e-02f, -7.82481283e-02f, -7.10902782e-03f, 8.45593400e-03f, 9.70183462e-02f, -2.24321336e-02f,
  -9.83989388e-02f, 7.80594349e-02f, -3.96738015e-02f, 6.18876293e-02f, 1.00391179e-01f, 5.69399726e-03f, 1.97776228e-01f, -2.10735109e-02f, 2.74773799e-02f, 4.81881388e-02f,
  7.67778978e-02f, 1.81105942e-01f, -8.96411687e-02f, 2.84677669e-02f, 1.29451647e-01f, 4.00504190e-03f, -3.01368558e-03f, 4.89509813e-02f, 2.25378390e-05f, 1.57225385e-01f,
  9.06367376e-02f, -6.40598983e-02f, -4.49847430e-03f, 2.94862483e-02f, 9.38555226e-02f, 4.11286578e-02f, -8.13545361e-02f, 1.42140821e-01f, 8.32196698e-02f, 8.61577913e-02f,
  2.01018546e-02f, -7.81455636e-03f, -8.38719085e-02f, 6.96925148e-02f, 1.00038029e-01f, 9.71076414e-02f, -2.43485952e-03f, 8.50315858e-03f, -1.08263493e-02f, 6.94792196e-02f,
  1.49005381e-02f, -4.71215397e-02f, -6.27659261e-03f, 1.21639650e-02f, 1.25416771e-01f, 1.17011089e-02f, 1.53258247e-02f, -1.95360463e-02f, 1.14029877e-01f, 3.11130751e-02f,
  -1.49490926e-02f, 2.11324282e-02f, -9.13983956e-02f, 3.27585563e-02f, 5.76622970e-03f, 2.49807592e-02f, 7.92443678e-02f, -8.14540088e-02f, 1.27191404e-02f, -3.71663831e-02f,
  -8.36889297e-02f, -9.24975201e-02f, -1.04228705e-01f, 8.97476524e-02f, 5.54760769e-02f, -6.13751709e-02f, 1.16247654e-01f, -7.24738762e-02f, 4.68112007e-02f, 4.98638451e-02f,
  1.49588762e-02f, 1.10788994e-01f, -5.07795922e-02f, -1.27541155e-01f, 1.58340763e-02f, -1.21314801e-01f, 9.28154029e-03f, -1.60795785e-02f, 2.49885395e-03f, 2.15705521e-02f,
  -5.91327436e-02f, 1.46278664e-02f, -1.01467513e-01f, -9.96770635e-02f, -7.81826973e-02f, 2.16920767e-02f, 2.66167335e-02f, 8.73943940e-02f, 9.69893187e-02f, 1.31107196e-01f,
  -9.69724879e-02f, -8.26461762e-02f, 1.35765364e-02f, -1.34090241e-02f, -5.34697622e-02f, 9.02689844e-02f, 9.41726640e-02f, -8.70955586e-02f, -1.09451137e-01f, 7.29668662e-02f,
  -1.16369776e-01f, -1.05750024e-01f, 1.30024385e-02f, 6.74504414e-02f, 5.74922264e-02f, -5.40141463e-02f, 5.39251044e-02f, -1.11603081e-01f, 1.13578744e-01f, -2.12330744e-02f,
  9.10035968e-02f, 1.45252615e-01f, -5.24642728e-02f, -5.56871705e-02f, 7.10334778e-02f, 1.74393505e-02f, 9.95326205e-04f, -1.13919210e-02f, 5.72315194e-02f, 8.51237476e-02f,
  3.02963071e-02f, 4.31983881e-02f, -6.35685176e-02f, -1.00105934e-01f, 4.27909493e-02f, 6.15140721e-02f, -6.44336715e-02f, -9.55012068e-02f, -4.79196422e-02f, 1.14133932e-01f,
  3.65408845e-02f, 3.72797586e-02f, -7.99279138e-02f, 6.47825673e-02f, 8.04658234e-02f, -1.03497334e-01f, -7.59222507e-02f, 2.31039710e-02f, 4.34878953e-02f, 1.05155319e-01f,
  -1.08752124e-01f, 1.42133078e-02f, -5.33319637e-02f, -1.02732368e-01f, -3.40719447e-02f, 6.87753595e-03f, -5.60093075e-02f, -1.02843903e-01f, -8.22773203e-02f, -8.88926685e-02f,
  -2.41976492e-02f, 9.71058533e-02f, 6.14697039e-02f, -9.76379290e-02f, -1.04894958e-01f, 8.25552866e-02f, 7.60762990e-02f, 1.13045357e-01f, -1.15869053e-01f, 4.12924886e-02f,
  4.92668487e-02f, 9.99885127e-02f, -4.84069549e-02f, -6.74773231e-02f, 1.55384606e-02f, 4.30325083e-02f, -1.03906430e-02f, -8.53273422e-02f, 5.24407113e-03f, 1.23551697e-01f,
  -7.95452073e-02f, -6.04786389e-02f, 1.27998414e-02f, -2.93851588e-02f, -6.24556914e-02f, 3.38870808e-02f, -3.46511863e-02f, 7.09840208e-02f, 3.29505466e-02f, -1.71850417e-02f,
  7.90146291e-02f, -3.33603919e-02f, -1.16573326e-01f, 1.09995805e-01f, 5.00653312e-02f, -9.27253142e-02f, -6.79248944e-02f, -1.03344038e-01f, 2.43208371e-02f, 1.05350792e-01f,
  3.56312916e-02f, -2.03129835e-02f, 4.63560112e-02f, 7.85766020e-02f, -4.70517613e-02f, 1.11835532e-01f, -1.06271818e-01f, 9.49114338e-02f, 9.11881626e-02f, -2.39617117e-02f,
  -5.10535315e-02f, -8.79522711e-02f, -1.34068877e-01f, -3.24214920e-02f, -1.10003337e-01f, -8.02804623e-03f, -4.81201299e-02f, 1.06370822e-01f, -4.86065168e-03f, 6.25819936e-02f,
  1.09442882e-01f, -1.30075902e-01f, -6.78788722e-02f, 3.46226245e-02f, -1.04200229e-01f, 6.74199760e-02f, 9.83733833e-02f, -2.68562534e-03f, -5.57851084e-02f, 6.32730573e-02f,
  -6.03982201e-03f, -7.54592270e-02f, 6.33782148e-02f, 4.15597931e-02f, 5.82271181e-02f, -1.17479928e-01f, -1.12633429e-01f, 2.44271066e-02f, -8.91724005e-02f, 1.15386605e-01f,
  4.34696339e-02f, 2.80696135e-02f, -6.09525368e-02f, 3.63709144e-02f, -9.22859162e-02f, -2.86003537e-02f, 4.44950089e-02f, 7.42801204e-02f, -7.64640346e-02f, -4.96720783e-02f,
  6.58180937e-02f, 1.28629923e-01f, -7.66883865e-02f, 4.58488017e-02f, -5.01844883e-02f, 1.97982285e-02f, 1.29195256e-02f, 6.53284043e-02f, 6.98856860e-02f, 1.27496973e-01f,
  5.51010706e-02f, 5.82267996e-03f, 1.60540327e-01f, 1.18131094e-01f, 4.37643006e-02f, 3.37975100e-02f, -1.15905859e-01f, -1.14227355e-01f, 2.17074126e-01f, 1.39806733e-01f,
  -7.14239925e-02f, -5.40011078e-02f, 5.74192330e-02f, 1.00609474e-02f, -4.82797101e-02f, 1.34609357e-01f, -1.89705566e-01f, 5.03720599e-04f, -1.14796355e-01f, 5.02749644e-02f,
  6.95334673e-02f, -3.35569419e-02f, 4.24052402e-02f, 6.16601184e-02f, -1.80493295e-01f, -7.86970705e-02f, -6.41257837e-02f, 1.04928382e-01f, 6.17702864e-02f, 3.30854557e-03f,
  1.02833636e-01f, 1.48698390e-01f, 1.46297097e-01f, 1.57213122e-01f, 2.04390120e-02f, -8.30872878e-02f, -4.76449169e-02f, 1.15369052e-01f, 4.50337753e-02f, -5.75234070e-02f,
  2.81663798e-02f, -8.05378258e-02f, 1.11258790e-01f, 3.43538225e-02f, 8.15013722e-02f, -3.61755565e-02f, 1.17268905e-01f, -3.16768810e-02f, -1.17355160e-01f, -1.35409594e-01f,
  1.71844631e-01f, 8.31817910e-02f, -8.05173516e-02f, 2.20594779e-01f, -1.20818261e-02f, 3.15198451e-02f, 3.39956060e-02f, 2.22783417e-01f, 2.64846105e-02f, 2.19712760e-02f,
  -3.04206572e-02f, 1.37586057e-01f, 1.50736436e-01f, 1.67469736e-02f, -7.66716450e-02f, 4.76100184e-02f, -3.51490383e-03f, -7.26938769e-02f, -3.63343805e-02f, -4.83817905e-02f,
  7.49239884e-03f, -1.24002986e-01f, -1.74736679e-02f, 5.87162375e-02f, -1.02000749e-02f, -1.07060462e-01f, 1.41103165e-02f, 7.04724435e-03f, -7.54536167e-02f, 1.50124431e-01f,
  -1.48912579e-01f, -7.43952915e-02f, -9.42284912e-02f, -3.68474424e-02f, -2.82678902e-02f, -8.91861469e-02f, -3.98158591e-04f, 1.22980624e-01f, -6.93394542e-02f, 1.34617820e-01f,
  -1.11028634e-01f, -2.03537568e-02f, 6.25860766e-02f, 6.80819303e-02f, 7.35094622e-02f, 1.14500612e-01f, -1.08843232e-02f, -1.61701143e-02f, 2.38160454e-02f, 8.99796486e-02f,
  -4.43776362e-02f, -1.89177506e-02f, 9.28687453e-02f, -1.24319848e-02f, -2.10184585e-02f, 6.33588433e-02f, -7.01739639e-02f, 4.23045494e-02f, 9.88003090e-02f, -8.99249688e-02f,
  3.34063582e-02f, -8.17580745e-02f, 5.62895127e-02f, 1.15529776e-01f, -3.01338211e-02f, -1.01035342e-01f, -5.98941855e-02f, 1.45958990e-01f, 1.03225574e-01f, -9.10708457e-02f,
  1.28171220e-01f, 6.55012280e-02f, 1.48813158e-01f, -1.01122990e-01f, 1.82440858e-02f, 1.00865632e-01f, 1.83025002e-01f, 1.73330024e-01f, 1.60208955e-01f, -5.05261682e-02f,
  2.22437575e-01f, 5.95341176e-02f, 1.48429170e-01f, 2.24745460e-02f, -1.60576567e-01f, -7.91169181e-02f, 2.49365330e-01f, -5.33630326e-02f, -5.45345843e-02f, 9.66977794e-03f,
  -5.96873499e-02f, 6.72775656e-02f, 1.70184493e-01f, 1.94934621e-01f, -6.91868216e-02f, -1.01254977e-01f, 8.98950472e-02f, 2.04619303e-01f, 9.87652093e-02f, -6.54758736e-02f,
  1.22499034e-01f, 1.69778302e-01f, -8.93318057e-02f, 7.00352490e-02f, -1.07127331e-01f, 1.25201523e-01f, 6.53469712e-02f, 2.10867122e-01f, 2.97331363e-02f, 5.57549745e-02f,
  1.00592606e-01f, -9.96898338e-02f, 1.31940663e-01f, -1.57570355e-02f, -6.97039738e-02f, -1.06702857e-01f, -7.01359734e-02f, 1.64921619e-02f, -6.99212030e-02f, 3.40387486e-02f,
  6.14155121e-02f, -1.22898579e-01f, 2.81044915e-02f, -1.11289851e-01f, 3.43737639e-02f, 1.19138539e-01f, 1.21128365e-01f, -1.11437798e-01f, 1.30030587e-01f, 2.02660993e-01f,
  -1.35179520e-01f, 2.37241179e-01f, 3.66893150e-02f, 5.84116466e-02f, 1.95331171e-01f, 2.69388616e-01f, 7.54438266e-02f, -1.17756175e-02f, 1.29042938e-01f, 1.84387434e-02f,
  -1.20646141e-01f, 7.76714832e-02f, 1.28526315e-01f, 8.00775811e-02f, 1.25540480e-01f, 9.32500437e-02f, 9.74408686e-02f, -7.78395459e-02f, -2.07026526e-01f, 6.69918507e-02f,
  1.00908548e-01f, -5.06487004e-02f, 1.33226901e-01f, -6.16689548e-02f, -5.63782938e-02f, -2.44497601e-02f, 1.57352105e-01f, 2.17510074e-01f, -3.62458937e-02f, -2.67101079e-02f,
  -1.04731187e-01f, 1.80201083e-01f, -9.44873691e-03f, 4.48539965e-02f, -5.81917092e-02f, 5.71723171e-02f, 1.17745116e-01f, 1.90075740e-01f, 2.64222305e-02f, 1.62484334e-03f,
  7.88217112e-02f, 1.05011448e-01f, -8.93447101e-02f, -2.50608521e-03f, -8.76140818e-02f, -1.33680226e-02f, 1.37020364e-01f, 1.77090332e-01f, 6.41149357e-02f, 1.52097583e-01f,
  -3.13147046e-02f, -4.75813039e-02f, 9.02939662e-02f, -7.70427510e-02f, 3.78197990e-02f, 1.59175932e-01f, -4.37952466e-02f, -2.62210350e-02f, 1.16592862e-01f, 8.52238983e-02f,
  -1.11869052e-01f, -1.10341147e-01f, -3.65780853e-02f, 2.10938435e-02f, -5.69516420e-02f, 2.92080862e-04f, 8.70316252e-02f, 6.44060597e-02f, -5.82908988e-02f, 1.00862630e-01f,
  4.25347220e-03f, 2.63423976e-02f, 8.08434114e-02f, 1.28057539e-01f, 1.45083582e-02f, 1.80632412e-01f, -4.08083424e-02f, 1.30691364e-01f, 1.76376291e-02f, 9.24451202e-02f,
  1.23406522e-01f, 1.42263949e-01f, 1.63496554e-01f, -1.06184408e-01f, 5.57221286e-02f, -2.29925830e-02f, -1.75879061e-01f, 6.52070642e-02f, 2.69858509e-01f, 1.49354041e-01f,
  -8.13851431e-02f, -5.71954399e-02f, -1.74674556e-01f, -4.86165099e-02f, -5.85828722e-02f, 8.05463120e-02f, 1.28042832e-01f, 7.96827003e-02f, -1.36462571e-02f, 6.27327934e-02f,
  -7.42895901e-02f, -6.66890815e-02f, 1.49573117e-01f, -2.23369244e-02f, -5.38811758e-02f, 4.96059470e-02f, 5.24078570e-02f, -6.60387278e-02f, 4.04024832e-02f, 2.22378135e-01f,
  1.06942728e-01f, -3.04475781e-02f, -7.92733580e-02f, 7.72476047e-02f, 1.12025321e-01f, -8.64354074e-02f, -2.97798421e-02f, 1.25788987e-01f, 1.50054663e-01f, -9.26071778e-02f,
  5.92235699e-02f, 1.11285970e-01f, 1.51350070e-02f, -6.72672242e-02f, -5.27969562e-02f, 3.25149707e-02f, 6.50307611e-02f, 1.52510852e-01f, 3.33619528e-02f, -8.48763343e-03f,
  -1.35569394e-01f, -1.13534063e-01f, 5.28674126e-02f, 2.38653719e-01f, 9.41042881e-03f, -6.98031113e-02f, 1.44010827e-01f, 3.18866447e-02f, 1.71235621e-01f, 1.87784526e-02f,
  -2.17509028e-02f, 1.11542232e-01f, -6.18621930e-02f, 8.47672597e-02f, 1.46935105e-01f, 4.37661707e-02f, 2.52396613e-01f, -4.32051904e-02f, 8.31924155e-02f, 6.52280450e-02f,
  -3.82242911e-02f, -4.01272736e-02f, 2.66860753e-01f, 1.31783873e-01f, -9.39039737e-02f, -2.47497782e-01f, -1.55403554e-01f, 8.31421167e-02f, 1.04820028e-01f, -1.62735190e-02f,
  1.97585784e-02f, 1.40290409e-01f, -2.59981044e-02f, -9.82042030e-03f, -8.30765963e-02f, -6.41401485e-02f, 4.85339500e-02f, -6.66793361e-02f, 8.59149918e-02f, 1.50378235e-02f,
  7.95650929e-02f, -1.06386960e-01f, 8.92484412e-02f, 1.05402127e-01f, -9.52839404e-02f, -1.91058405e-02f, -5.60712181e-02f, -4.66934629e-02f, 1.35446638e-01f, -4.72598784e-02f,
  9.21782777e-02f, 1.08847797e-01f, 5.44568971e-02f, 9.50699747e-02f, 8.80251080e-02f, 1.43948048e-01f, 5.30674420e-02f, -7.34185204e-02f, 3.15769799e-02f, 6.67106137e-02f,
  -7.92006217e-03f, 1.53480023e-01f, 4.75704893e-02f, -2.83111725e-02f, -1.40454665e-01f, -5.73368780e-02f, -2.79157385e-02f, -9.45991799e-02f, 9.54136923e-02f, -1.02937371e-01f,
  7.98699632e-02f, 1.62220925e-01f, 1.12875678e-01f, -3.19203548e-02f, 1.83551595e-01f, 5.17702810e-02f, 8.89692679e-02f, 4.43494990e-02f, 1.51698589e-01f, -9.64041576e-02f,
  -1.79771855e-01f, 1.76989496e-01f, 9.78151932e-02f, -6.22005900e-03f, -8.43942240e-02f, -4.80448939e-02f, 9.48857293e-02f, -4.11709510e-02f, 2.32593626e-01f, 1.87534660e-01f,
  2.10360542e-01f, 1.91961333e-01f, -8.76950175e-02f, 7.18509927e-02f, -1.22122936e-01f, -1.05291963e-01f, 1.02382608e-01f, 1.24331295e-01f, 4.80976002e-03f, -5.70871234e-02f,
  -7.39089251e-02f, -7.18778819e-02f, 1.38059840e-01f, 1.98107675e-01f, -7.21742511e-02f, -6.25309497e-02f, -2.49441527e-02f, 6.89303176e-03f, 5.74304396e-03f, 4.87553515e-02f,
  -3.67092667e-03f, 3.41511588e-03f, -3.94813120e-02f, 8.98161158e-02f, -4.99307103e-02f, -8.62455294e-02f, 4.93572913e-02f, -8.97193626e-02f, -1.30821630e-01f, 5.25041893e-02f,
  1.37715012e-01f, -6.39204010e-02f, 9.74093750e-02f, 1.29466876e-01f, -7.13874325e-02f, -6.16424195e-02f, 4.48554941e-02f, -1.00879721e-01f, 1.51116140e-02f, -6.28920645e-02f,
  -3.95134166e-02f, 7.56504163e-02f, 1.29275784e-01f, 1.28583491e-01f, 1.17827393e-01f, 1.08381137e-01f, -1.52659016e-02f, 1.46382660e-01f, 5.62340133e-02f, -1.93945840e-02f,
  -1.99742094e-02f, -4.17788886e-02f, 9.12766457e-02f, 3.38441581e-02f, -6.41088635e-02f, -1.01035528e-01f, -7.89657980e-02f, -5.53017445e-02f, 3.74087058e-02f, -2.19871607e-02f,
  -1.37860626e-01f, 1.28158629e-01f, 8.89580622e-02f, 2.47316919e-02f, 7.52404183e-02f, -1.06411703e-01f, 1.69668555e-01f, 9.29676741e-02f, 3.35095823e-02f, 1.29280090e-01f,
  -3.24534997e-02f, 7.00624511e-02f, -5.79492114e-02f, 2.03997884e-02f, -9.14591625e-02f, -7.01913908e-02f, 2.78657619e-02f, 9.36565101e-02f, -4.15371209e-02f, 2.84038726e-02f,
  -1.78986974e-02f, -9.18532833e-02f, 3.56523022e-02f, 1.02208823e-01f, -2.62859296e-02f, -9.80610847e-02f, -8.54919255e-02f, -1.02813326e-01f, 7.49461204e-02f, 1.29156709e-01f,
  -1.17902339e-01f, 2.06526238e-02f, -5.72862439e-02f, 8.99111107e-02f, 4.68949638e-02f, 1.15999900e-01f, -3.46881486e-02f, -1.26540989e-01f, 6.23201951e-02f, 5.67502528e-02f,
  -1.14492215e-01f, -4.45581079e-02f, 1.36211351e-01f, 5.25855049e-02f, -2.65496355e-02f, -1.30510882e-01f, 1.39054418e-01f, 3.57557945e-02f, -1.71433464e-02f, 1.61712140e-01f,
  7.46028572e-02f, 1.60708383e-01f, -3.68071254e-03f, -4.82095852e-02f, 1.55935019e-01f, -2.38449052e-02f, 1.59626473e-02f, 5.20012379e-02f, 1.97424263e-01f, 4.52458337e-02f,
  2.41957709e-01f, -7.38745779e-02f, -2.16427311e-01f, 1.96075767e-01f, 2.92711198e-01f, 2.12211326e-01f, -1.56749055e-01f, -2.45103270e-01f, -1.67125948e-02f, 6.22081310e-02f,
  -9.63168889e-02f, -7.93402456e-03f, 1.79823250e-01f, 1.33419618e-01f, 2.85819080e-02f, -1.16433248e-01f, -2.12509826e-01f, 1.32347196e-02f, 8.52297097e-02f, -6.77025365e-03f,
  -1.45990267e-01f, 1.19675182e-01f, -1.06793121e-01f, 6.97232708e-02f, 5.27126901e-02f, 2.43922904e-01f, 1.12821668e-01f, -8.27972814e-02f, 7.46348128e-02f, 3.54775675e-02f,
  -6.43031225e-02f, -2.58964971e-02f, 6.62757307e-02f, 7.34061226e-02f, 3.55504379e-02f, -1.43176153e-01f, -2.33238023e-02f, 1.12251714e-01f, 3.47585902e-02f, 2.90126912e-02f,
  1.01420276e-01f, 1.40484616e-01f, 1.92211643e-01f, 1.29260644e-01f, -9.47123021e-02f, -7.36148208e-02f, -1.13718376e-01f, -4.96076159e-02f, 6.51278272e-02f, 2.23735392e-01f,
  1.51263744e-01f, -6.54014647e-02f, -8.51100087e-02f, -7.24655855e-03f, -5.01721129e-02f, 1.07335433e-01f, 4.57844771e-02f, -8.98023844e-02f, 3.10967322e-02f, -3.24181542e-02f,
  -5.42949550e-02f, 1.35505065e-01f, 1.02750018e-01f, -5.34336455e-02f, -1.49126515e-01f, -1.09247133e-01f, -4.99995686e-02f, -5.21508493e-02f, -5.84775582e-03f, 6.72588125e-02f,
  3.98787782e-02f, 9.52122808e-02f, 3.51017490e-02f, -1.51369557e-01f, -7.80447200e-02f, 2.40911748e-02f, 1.07158802e-01f, -2.60898285e-02f, -5.22036292e-02f, -6.09231889e-02f,
  -9.09414440e-02f, -4.96877506e-02f, -3.01032737e-02f, 5.33206202e-02f, 5.87518960e-02f, -4.95937746e-03f, 3.83987390e-02f, 7.44339526e-02f, 4.23627160e-02f, -4.59397808e-02f,
  -8.62539280e-03f, 4.58199829e-02f, -1.18202873e-01f, -6.10011220e-02f, 3.69490101e-03f, 1.02792196e-01f, 1.36073336e-01f, 4.43551391e-02f, 7.86828101e-02f, -7.68201798e-02f,
  2.85212137e-02f, -1.51811484e-02f, 7.79669732e-02f, -6.15186095e-02f, -6.88318089e-02f, 4.73319963e-02f, -5.15791588e-03f, -8.37259367e-03f, 1.38277607e-02f, 1.02850720e-01f,
  -6.55461699e-02f, 9.76499692e-02f, 1.02926366e-01f, -3.10663749e-02f, 3.17185856e-02f, 8.40812922e-02f, 1.25931986e-02f, 4.61343713e-02f, -4.81843464e-02f, 1.71415627e-01f,
  1.22979470e-01f, 9.05650333e-02f, 3.54882479e-02f, 3.49007696e-02f, 2.26325989e-02f, 1.09199975e-02f, 1.84590772e-01f, -7.78562129e-02f, 6.74154609e-02f, 6.34834468e-02f,
  1.31554725e-02f, 2.93755252e-02f, 5.95018081e-03f, -1.19784370e-01f, 2.98167504e-02f, -5.55738546e-02f, -1.24677867e-02f, -4.81167324e-02f, 3.93528156e-02f, -1.32705197e-01f,
  1.26559705e-01f, -3.92124467e-02f, -4.04785909e-02f, 8.13590959e-02f, -6.25113584e-03f, -8.58213082e-02f, -4.91545573e-02f, -1.10716306e-01f, 3.20122726e-02f, -2.49340124e-02f,
  3.45609896e-02f, -6.60192370e-02f, -2.18003057e-02f, -6.22953810e-02f, -6.39508888e-02f, -1.19944610e-01f, 1.37326922e-02f, 3.87749746e-02f, -3.91072035e-02f, -1.32574616e-02f,
  3.25204507e-02f, -9.15614665e-02f, 3.32391262e-02f, -1.58315122e-01f, 8.89795423e-02f, -5.70876710e-02f, 5.69812767e-02f, 8.61810520e-02f, 1.48063321e-02f, 1.32021904e-01f,
  7.88029805e-02f, 9.56974253e-02f, 1.25785410e-01f, -1.20843761e-01f, 3.80289666e-02f, 1.00524761e-01f, 8.20395127e-02f, -4.26019244e-02f, 1.11456260e-01f, 1.08770736e-01f,
  1.15988262e-01f, 1.79847255e-01f, 1.05155647e-01f, 8.91673714e-02f, 1.98081613e-01f, 5.58595806e-02f, 1.52015284e-01f, -6.35108948e-02f, 7.90145025e-02f, 1.36538759e-01f,
  2.07909942e-01f, -7.24429786e-02f, 2.57736057e-01f, -6.16864152e-02f, -4.69165817e-02f, 1.53658107e-01f, -4.50444669e-02f, 2.31315717e-01f, -1.16680274e-02f, -1.39308935e-02f,
  1.97617978e-01f, -1.63254544e-01f, 6.74268929e-03f, 2.58792430e-01f, -5.61874770e-02f, 1.47364056e-02f, 1.22126535e-01f, 1.71861306e-01f, 3.17750103e-03f, 1.11047952e-02f,
  -7.06840008e-02f, 8.67425427e-02f, 1.42795667e-01f, 1.46596715e-01f, -3.42640206e-02f, 3.61970104e-02f, 9.37986895e-02f, -6.12581521e-02f, 5.83830439e-02f, 1.16098650e-01f,
  1.17713965e-01f, -9.26106423e-02f, -5.45662828e-02f, -8.54685828e-02f, 6.83177859e-02f, 7.23212808e-02f, 1.80758581e-01f, -2.05217805e-02f, 6.16787821e-02f, -5.40668219e-02f,
  7.94901028e-02f, -8.98512080e-02f, 1.70960903e-01f, -1.58779353e-01f, 1.00074388e-01f, 2.12393358e-01f, -8.27593133e-02f, 1.82139680e-01f, -1.16756439e-01f, 8.98130685e-02f,
  1.30301952e-01f, 7.06649199e-02f, 3.05222850e-02f, -9.39396117e-03f, 7.33361691e-02f, 1.53933004e-01f, 1.44419298e-01f, 2.00673833e-01f, 1.31775066e-01f, 1.64757058e-01f,
  7.72532523e-02f, 1.68104291e-01f, 1.45138651e-01f, -1.78947710e-02f, -1.15600720e-01f, -9.94518772e-02f, 8.02594498e-02f, 9.27627236e-02f, 6.29869774e-02f, -7.01318160e-02f,
  2.42432818e-01f, -1.07524551e-01f, 9.52348784e-02f, -7.30185062e-02f, -2.15796784e-01f, 1.24075629e-01f, -9.46020782e-02f, -3.62711470e-03f, 1.82278827e-01f, -1.15142269e-02f,
  -4.65206839e-02f, -5.85259348e-02f, -1.23640016e-01f, -1.48973539e-02f, 1.77751482e-02f, 5.70567958e-02f, 2.56217644e-02f, 3.53921801e-02f, 9.54518914e-02f, -3.81870046e-02f,
  -1.60131175e-02f, 2.10819021e-01f, 1.42601550e-01f, -8.28771442e-02f, 6.48254603e-02f, 2.11919919e-02f, 5.26631949e-03f, -9.78995115e-02f, 1.34543926e-01f, 9.80297700e-02f,
  1.00430705e-01f, 5.24070347e-04f, 1.12300739e-02f, 9.33392569e-02f, -3.43253873e-02f, -3.99260186e-02f, -1.44506022e-01f, 1.30322725e-01f, 2.03098461e-01f, -3.80295366e-02f,
  -2.68183164e-02f, -8.89392421e-02f, -3.43604051e-02f, -8.19682237e-03f, -2.16624364e-02f, 8.24117810e-02f, -8.29342529e-02f, -5.16307168e-02f, 4.91294861e-02f, -8.29722211e-02f,
  -3.91188078e-03f, 1.37570277e-01f, 9.09290537e-02f, 4.82830964e-02f, 1.13667268e-03f, 3.04304063e-02f, 9.18946862e-02f, 6.65945048e-03f, -1.40596628e-01f, -3.76657844e-02f,
  -2.22184062e-02f, -3.35949846e-02f, 3.65612917e-02f, -6.83121160e-02f, 1.30429253e-01f, 3.24169844e-02f, -6.08342737e-02f, 6.61043227e-02f, 6.15804270e-02f, 1.07870974e-01f,
  5.23516424e-02f, 9.10772085e-02f, -7.61690587e-02f, -3.38784717e-02f, -4.60669957e-02f, 5.54831885e-02f, 1.91018218e-03f, 1.65289976e-02f, 1.17986456e-01f, -3.78803723e-02f,
  7.67619982e-02f, 1.92283466e-02f, 1.50078756e-03f, -1.26403198e-01f, 1.19796559e-01f, 5.56337200e-02f, -4.66966443e-02f, -6.51265457e-02f, -1.23357885e-02f, 1.50318846e-01f,
  4.48594987e-03f, -7.93848708e-02f, 7.76351988e-02f, -7.56327882e-02f, -6.94153756e-02f, 1.85993493e-01f, -6.28230646e-02f, 2.42366921e-02f, 1.24041408e-01f, 4.42579873e-02f,
  -1.27054214e-01f, 9.53074470e-02f, -1.78208463e-02f, 1.16733583e-02f, -3.19036692e-02f, -5.46523705e-02f, 1.03422880e-01f, 4.84598391e-02f, -4.82250713e-02f, -6.28078058e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.50104716e-01f, 8.73849690e-02f, -3.75807732e-02f, 7.74227455e-02f, -2.32429672e-02f, 1.03444599e-01f, 9.44940373e-02f, 1.73077315e-01f, 1.45529673e-01f, 1.21630028e-01f,
  9.62470174e-02f, 1.25437394e-01f, 1.28013834e-01f, 3.85905616e-02f, 1.92011386e-01f, -6.43700734e-02f, 1.16933525e-01f, 1.81769997e-01f, 3.41894962e-02f, -2.25781519e-02f,
  1.37459129e-01f, 1.51961744e-01f, 5.20303398e-02f, -8.82432330e-03f, 6.91958815e-02f, 3.33297215e-02f, -5.51544093e-02f, 6.61255792e-02f, 1.38592392e-01f, 1.80067688e-01f,
  1.81444064e-01f, 1.28984392e-01f, 1.27292629e-02f, -3.86359133e-02f, -8.86502955e-03f, 1.53144687e-01f, 1.54308513e-01f, 1.25764117e-01f, 1.18951194e-01f, 2.08816286e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -8.15881565e-02f, -2.23951228e-02f, 2.00084690e-02f, -8.69034007e-02f, 1.24866571e-02f, -3.66352089e-02f, -3.99844460e-02f, 3.47560784e-03f, 6.49837852e-02f, -5.75027466e-02f,
  4.81275991e-02f, -5.63189983e-02f, 1.08341269e-01f, 4.74416278e-02f, -2.28144005e-02f, 8.84193778e-02f, -1.41934752e-01f, -4.92174551e-02f, 1.42168149e-01f, 1.32262617e-01f,
  -6.17473274e-02f, -2.93114334e-02f, -1.32350281e-01f, 3.81210484e-02f, -1.25022829e-01f, 1.24513179e-01f, 3.73952382e-04f, -1.01647682e-01f, -9.87630635e-02f, -1.42128682e-02f,
  -8.96082669e-02f, -8.59607831e-02f, 1.21739350e-01f, 3.35651562e-02f, 3.91926542e-02f, -6.01942502e-02f, 2.45654173e-02f, 2.35485919e-02f, 6.26680329e-02f, -4.22986560e-02f,
  3.06120422e-03f, -8.34957063e-02f, 7.45460987e-02f, 1.96576491e-02f, -1.70454070e-01f, 1.55486330e-01f, 1.12228270e-03f, -6.37497604e-02f, -4.47591729e-02f, -5.68800792e-02f,
  1.46576807e-01f, -7.03275353e-02f, 1.73052579e-01f, 9.54859257e-02f, 1.29901990e-01f, -9.28400550e-03f, 1.90261118e-02f, -3.58353509e-03f, 1.52624086e-01f, 9.39632058e-02f,
  3.48845981e-02f, -2.72873393e-03f, 3.00936587e-02f, 6.59000054e-02f, 5.42022325e-02f, 5.37861697e-02f, -1.65021822e-01f, 2.62239259e-02f, 2.67364644e-02f, 4.15407531e-02f,
  9.75765809e-02f, -9.34083364e-04f, -1.49951443e-01f, 7.95847028e-02f, -7.84677565e-02f, -1.54693320e-01f, -3.18500362e-02f, 7.79757053e-02f, -7.00932443e-02f, -1.79347739e-01f,
  -1.69953495e-01f, 1.52907595e-01f, -2.81393886e-01f, 1.36026531e-01f, 1.33972555e-01f, -4.16938253e-02f, 2.02292114e-01f, -1.13094047e-01f, -2.29747463e-02f, -1.72620237e-01f,
  -1.23674914e-01f, 9.96712595e-02f, 1.14433527e-01f, 1.08084999e-01f, -1.26393020e-01f, 1.56308159e-01f, 9.93885845e-02f, 7.80453831e-02f, 1.66650236e-01f, -1.61709517e-01f,
  -4.52360213e-02f, -4.58139628e-02f, 9.46998075e-02f, 2.08065584e-01f, -7.79331708e-03f, -9.33903307e-02f, 1.79539993e-01f, -2.30099652e-02f, -1.34150665e-02f, -8.13289918e-03f,
  6.96437880e-02f, 3.28635871e-02f, -8.03970620e-02f, -5.17695323e-02f, -1.52223438e-01f, 7.83712883e-03f, -7.01332465e-02f, 7.65800104e-02f, -6.17657863e-02f, -1.10350244e-01f,
  1.30387083e-01f, 2.37396881e-02f, -2.68201977e-01f, 7.05455169e-02f, -9.22112912e-02f, -4.13532294e-02f, -9.82867479e-02f, 1.12518124e-01f, -2.35352982e-02f, 2.05613226e-02f,
  -4.06068042e-02f, -3.58709134e-02f, 9.44058448e-02f, 7.34978691e-02f, 1.16618946e-01f, 7.99653083e-02f, -3.46600153e-02f, 1.45193368e-01f, -6.06599450e-02f, -6.62827045e-02f,
  -1.27620727e-01f, 1.51157333e-02f, 1.15944549e-01f, 1.28484771e-01f, 1.55249834e-01f, -7.72823244e-02f, -5.10370098e-02f, -2.81568393e-02f, -3.74982459e-03f, -1.38096958e-01f,
  4.82456088e-02f, -1.88835394e-02f, 2.29751170e-01f, -1.69071659e-01f, -6.98659495e-02f, -5.85574955e-02f, -5.50373197e-02f, -1.10027187e-01f, 1.05913654e-01f, -1.67164072e-01f,
  -1.30472174e-02f, 8.23512226e-02f, -8.94425958e-02f, 6.29994348e-02f, -7.57438466e-02f, 1.16946280e-01f, -4.83319573e-02f, -1.41687423e-01f, -1.61630690e-01f, -8.98430645e-02f,
  2.10038293e-02f, -1.69448316e-01f, -1.20170461e-02f, 7.39036649e-02f, 7.03495089e-03f, -9.62657705e-02f, -1.22734085e-01f, -1.13273121e-01f, -1.64322644e-01f, 7.79999942e-02f,
  -2.04591602e-01f, -1.35632560e-01f, 6.99105731e-04f, 1.48952916e-01f, -2.36925781e-02f, 9.51569621e-03f, 1.13014869e-01f, 4.51852679e-02f, 1.16529949e-01f, -1.15985774e-01f,
  -6.73097596e-02f, -5.74687235e-02f, 9.30703580e-02f, 6.83456510e-02f, -3.20717692e-03f, 2.18749568e-02f, 9.72657204e-02f, -3.51995938e-02f, -3.16472165e-02f, -7.23292679e-02f,
  -1.31510094e-01f, 6.65379986e-02f, -2.48992033e-02f, -1.21473067e-01f, -3.31912120e-03f, 7.45441765e-02f, -4.74402308e-02f, -1.33811727e-01f, -1.09185591e-01f, 5.10132797e-02f,
  -7.96769280e-03f, -1.06514953e-01f, -2.62373555e-02f, 1.82507917e-01f, 1.97581932e-01f, 1.15998231e-01f, -5.99576384e-02f, -1.32870063e-01f, -1.21867806e-01f, 9.31530446e-02f,
  2.46599317e-02f, 1.40066579e-01f, -1.69616237e-01f, 1.21378623e-01f, -1.09922037e-01f, -8.90982673e-02f, 5.51955812e-02f, -1.85091197e-01f, 6.99909702e-02f, -1.06967716e-02f,
  1.36693805e-01f, 7.66822472e-02f, -3.84620205e-02f, 9.75637734e-02f, -5.49214147e-02f, 1.17964214e-02f, 1.49939179e-01f, -3.17087658e-02f, 1.12008005e-01f, 8.78867805e-02f,
  3.76734547e-02f, -6.02350682e-02f, -9.11438689e-02f, -4.25086990e-02f, -1.54440314e-01f, 9.95932221e-02f, -2.05714002e-01f, -1.15611427e-01f, 2.06851996e-02f, 4.11731303e-02f,
  -1.77048072e-01f, 8.93162116e-02f, -2.90659792e-03f, -2.12693021e-01f, -4.59785983e-02f, 6.75322860e-02f, -1.17682770e-01f, 8.36226270e-02f, 9.76658463e-02f, 3.99830230e-02f,
  -1.07171759e-01f, -7.91029632e-02f, -8.74594897e-02f, 1.04481712e-01f, 1.07631207e-01f, 1.16326705e-01f, 2.29571033e-02f, 1.26222476e-01f, -1.16442181e-02f, 6.46568686e-02f,
  9.29991528e-02f, -9.91157219e-02f, -1.49637312e-01f, 2.76932810e-02f, 1.54920086e-01f, 1.56905856e-02f, -6.96849078e-02f, -1.73928544e-01f, -1.89543352e-01f, 3.17451432e-02f,
  2.90871672e-02f, 2.29820147e-01f, 5.02707027e-02f, 1.00847572e-01f, 1.10475877e-02f, -1.49210189e-02f, 1.61905855e-01f, -5.10293059e-02f, 1.72344983e-01f, -1.14723168e-01f,
  -2.30225753e-02f, -4.55307476e-02f, -4.63266596e-02f, 8.83875638e-02f, -3.09168156e-02f, -9.39752758e-02f, 7.54181668e-02f, 5.05273007e-02f, -2.70652329e-03f, -7.14863762e-02f,
  -1.80412218e-01f, 6.46991050e-03f, -1.44689023e-01f, 9.37965810e-02f, -4.85658385e-02f, -1.00821249e-01f, 1.24952391e-01f, 1.22332409e-01f, 5.95624782e-02f, -1.15192637e-01f,
  -3.93360145e-02f, 4.38345596e-03f, -9.22652259e-02f, -1.62799358e-02f, 6.29601553e-02f, 2.73827440e-03f, -1.07159883e-01f, 2.13715509e-01f, -1.49979144e-01f, -1.08870409e-01f,
  7.32362792e-02f, 6.25058860e-02f, 4.68434617e-02f, -9.56552625e-02f, -9.96586084e-02f, -8.76187757e-02f, -1.59857180e-02f, -5.58338240e-02f, 5.98414913e-02f, 5.81974573e-02f,
  7.04954490e-02f, 8.54805186e-02f, 3.69103514e-02f, -3.19703035e-02f, 1.36310458e-01f, 3.91561240e-02f, 6.34009317e-02f, -1.28605053e-01f, 9.28700492e-02f, 6.83728829e-02f,
  -1.80147901e-01f, -6.92735910e-02f, -3.70474420e-02f, -7.22786561e-02f, -6.11622557e-02f, -1.54914679e-02f, 1.10661015e-01f, -1.14948183e-01f, -1.62829950e-01f, -1.79150596e-01f,
  1.53799474e-01f, -9.70048308e-02f, -5.11951335e-02f, -1.18325464e-01f, -1.00953370e-01f, -1.04126427e-02f, 9.83397961e-02f, 1.21160068e-01f, -2.02423021e-01f, -3.00908796e-02f,
  -1.15955405e-01f, -2.26885416e-02f, 7.51172565e-03f, -1.01847455e-01f, -9.57992487e-03f, 8.61753225e-02f, 4.63902019e-02f, -1.25127062e-02f, -1.25718694e-02f, 5.66950738e-02f,
  1.81444004e-01f, 1.03025496e-01f, 6.39800355e-02f, -1.87099501e-01f, 7.65341520e-02f, 1.22503430e-01f, -1.03104860e-01f, -7.02812076e-02f, 2.28848234e-01f, 1.05624706e-01f,
  8.59320536e-02f, 6.88600466e-02f, 1.06460720e-01f, -2.23160703e-02f, -1.75693676e-01f, 2.61056274e-02f, -1.45432830e-01f, -1.24401011e-01f, -1.33783281e-01f, -1.56925060e-02f,
  -5.92393354e-02f, -1.18877701e-01f, -1.81585491e-01f, 2.87927110e-02f, -6.03224002e-02f, 6.51707649e-02f, 1.03354149e-01f, 2.75988877e-02f, 8.29620287e-02f, 3.04504838e-02f,
  -1.73974931e-02f, 1.12014003e-01f, -1.73040032e-01f, -1.14951497e-02f, -7.79349655e-02f, 3.57192382e-02f, 3.70995142e-02f, 6.14257008e-02f, -1.52290896e-01f, -9.59954709e-02f,
  -1.39300182e-01f, 1.14803247e-01f, -6.38723001e-02f, 8.92177671e-02f, -1.05158478e-01f, 6.01380877e-02f, 1.24045335e-01f, -9.03166980e-02f, 1.27220973e-01f, -1.02596842e-01f,
  -3.57266814e-02f, -9.48457792e-02f, 2.63337232e-02f, 6.05959706e-02f, 7.49732032e-02f, 5.35053462e-02f, 8.70308056e-02f, 1.85190160e-02f, -1.81219116e-01f, 7.61996582e-02f,
  1.10790312e-01f, -9.37746018e-02f, 7.53354356e-02f, -2.96455976e-02f, -8.56140908e-03f, -8.37489367e-02f, 7.97214359e-02f, 9.38552022e-02f, -1.32814556e-01f, -1.60806358e-01f,
  1.47086918e-01f, 2.59735864e-02f, -2.22212896e-01f, 1.92171186e-02f, -8.05111900e-02f, -1.22668326e-01f, 2.07763240e-02f, 1.02583952e-01f, -1.35232778e-02f, 4.32902798e-02f,
  1.62993953e-01f, -9.12870914e-02f, 1.15613744e-01f, 1.51780039e-01f, -4.30338234e-02f, -3.48771103e-02f, 1.15795456e-01f, 1.16248772e-01f, -6.33276179e-02f, 1.36902928e-01f,
  9.46751423e-03f, 7.38494992e-02f, 7.10688978e-02f, 7.57628754e-02f, -9.40308869e-02f, 1.27989426e-01f, -6.87605366e-02f, 1.86804421e-02f, 1.49728134e-01f, -2.17368856e-01f,
  3.28503624e-02f, -4.11516950e-02f, 1.37097955e-01f, -2.25596428e-01f, -1.08275376e-01f, 1.80366039e-02f, 1.10118777e-01f, 1.41967386e-01f, 1.08037628e-01f, 1.27448156e-01f,
  6.91219270e-02f, 1.22984648e-01f, -6.34946823e-02f, -1.69647306e-01f, 3.30996066e-02f, -1.60298914e-01f, 1.19261639e-02f, -3.90149280e-02f, 1.05708120e-02f, 1.22833841e-01f,
  1.29493296e-01f, -9.37352926e-02f, -2.34267488e-01f, -4.64757718e-02f, -6.13316558e-02f, -9.75724533e-02f, 1.54610751e-02f, -7.50287250e-02f, -1.22161388e-01f, 5.72876334e-02f,
  -5.35323918e-02f, -2.28074342e-02f, -2.01512482e-02f, -2.05034390e-02f, 8.91180336e-02f, 5.67955673e-02f, -1.38620704e-01f, 8.81145522e-02f, 1.34784490e-01f, -4.81351241e-02f,
  2.99180262e-02f, 2.07401402e-02f, -5.59212081e-03f, -4.58546691e-02f, 8.07958364e-04f, 2.94402856e-02f, -1.72142368e-02f, -8.66923109e-02f, -1.35062322e-01f, 1.32062122e-01f,
  3.40383053e-02f, 8.76111463e-02f, 6.67599887e-02f, 3.71052660e-02f, -5.79343401e-02f, 4.49369028e-02f, 3.97444628e-02f, 7.18158185e-02f, 9.94687676e-02f, 7.77815059e-02f,
  -1.25638023e-01f, -1.77592169e-02f, 1.97198614e-01f, 1.83161154e-01f, 1.63896218e-01f, 1.93947598e-01f, -1.59021288e-01f, 1.11657605e-01f, -8.32460672e-02f, 1.50059417e-01f,
  -3.80534418e-02f, 1.38081267e-01f, -1.79810658e-01f, -7.06125647e-02f, -8.18811432e-02f, 2.11063027e-02f, -1.04120567e-01f, -4.26348448e-02f, 9.11337361e-02f, -1.99645441e-02f,
  2.21670479e-01f, 1.85737535e-01f, -5.34140645e-03f, 1.05095439e-01f, 1.00376956e-01f, -1.24736112e-02f, 1.49460688e-01f, -9.07038674e-02f, 1.09617993e-01f, -6.91254362e-02f,
  -4.03941683e-02f, -1.09924622e-01f, 1.11364618e-01f, 9.33048427e-02f, -1.20441764e-04f, 5.72369471e-02f, 9.47684944e-02f, 1.28441185e-01f, 1.34056613e-01f, 9.43458453e-02f,
  3.00482437e-02f, -5.44957370e-02f, -2.78708562e-02f, -1.82776228e-01f, 1.71390280e-01f, -2.83070654e-02f, -9.94271636e-02f, -1.47733420e-01f, -6.10527061e-02f, 8.69171694e-02f,
  7.58751035e-02f, 2.60510463e-02f, -2.31634937e-02f, -1.43905124e-02f, -1.63112022e-02f, 9.87373069e-02f, -3.72982770e-02f, 6.43736795e-02f, -2.98149195e-02f, 6.01017363e-02f,
  1.69669002e-01f, 1.67002931e-01f, 1.03408143e-01f, -1.68416545e-01f, 1.27469480e-01f, 2.57860906e-02f, -6.32772446e-02f, -8.06656405e-02f, -2.38181919e-01f, 9.65756625e-02f,
  -1.32467747e-02f, 9.21158046e-02f, 4.87708673e-03f, -8.22966248e-02f, -1.73746049e-01f, 4.42116857e-02f, 1.11256279e-01f, -4.37003374e-02f, -4.35988568e-02f, -5.85410336e-04f,
  -1.24269709e-01f, 3.40474546e-02f, 1.09731006e-02f, -3.45240012e-02f, -8.27473477e-02f, -3.25601287e-02f, 4.09393162e-02f, -4.33430895e-02f, -1.16340771e-01f, -2.23300606e-01f,
  -3.54353674e-02f, 3.99845392e-02f, 2.44291406e-02f, 5.41313365e-03f, -6.23703189e-02f, 4.44152802e-02f, 1.42161166e-02f, -1.02028333e-01f, 1.22646689e-01f, -1.26789108e-01f,
  2.56660819e-01f, 1.86328813e-01f, -4.80005518e-02f, -2.70917616e-03f, 1.75815955e-01f, -5.54586388e-02f, 1.59655169e-01f, 5.72033301e-02f, 7.39132613e-02f, -8.38275850e-02f,
  1.19173832e-01f, -9.76497680e-02f, -5.47690168e-02f, 1.41198531e-01f, 1.83640867e-02f, 5.22209480e-02f, 4.49472480e-02f, 1.01368643e-01f, -4.45048548e-02f, -5.54394722e-02f,
  8.00472274e-02f, 3.72806937e-02f, -1.49481326e-01f, -7.41480216e-02f, 8.69044662e-02f, -4.35813749e-03f, -4.60608155e-02f, 7.08623149e-04f, -6.12454005e-02f, 9.58942100e-02f,
  1.85117841e-01f, -5.53218909e-02f, 1.10764839e-01f, -6.55019358e-02f, -6.61663786e-02f, -4.23666090e-03f, 3.61003564e-03f, -1.56146595e-02f, -2.02973634e-02f, -1.04789129e-02f,
  3.79564648e-04f, 1.11309521e-01f, 9.69755575e-02f, 1.03664123e-01f, -8.63646865e-02f, -7.49011412e-02f, -1.04679354e-01f, -4.95948887e-04f, 1.43946841e-01f, -8.92302692e-02f,
  8.37793872e-02f, 3.28401141e-02f, 1.40547916e-01f, -1.00053392e-01f, -9.04854536e-02f, -1.62842963e-02f, 9.92494375e-02f, -1.92377176e-02f, 8.76154974e-02f, 3.41644138e-03f,
  -7.14600924e-03f, 9.64467973e-02f, -8.19425434e-02f, 1.42036825e-01f, 8.27111155e-02f, -2.52093151e-02f, 1.20844916e-01f, -6.84153065e-02f, 4.83930409e-02f, -1.23982392e-01f,
  -8.12330395e-02f, -4.56026979e-02f, 1.02842584e-01f, 8.53867307e-02f, -4.86576892e-02f, 7.53471404e-02f, -2.40185894e-02f, 2.38112397e-02f, 5.41537292e-02f, -1.33726493e-01f,
  -3.28510925e-02f, -1.02329761e-01f, 8.39181151e-03f, -1.90900132e-01f, -1.39165893e-01f, -1.57598764e-01f, 3.98647077e-02f, -6.52951673e-02f, 7.86418393e-02f, -1.22456461e-01f,
  -1.25696510e-01f, -8.59098583e-02f, -8.93936120e-03f, 1.43150330e-01f, -2.02676952e-01f, 1.33562967e-01f, -7.46703371e-02f, -6.23014718e-02f, 1.02101192e-02f, 1.12786368e-01f,
  -4.57683392e-02f, -6.01757057e-02f, 3.06707006e-02f, -7.48211443e-02f, 5.82044832e-02f, 1.44976480e-02f, 1.93372682e-01f, 1.00641131e-01f, 1.68704510e-01f, 9.55996886e-02f,
  6.80901334e-02f, 6.66791424e-02f, -6.85088560e-02f, 1.15632914e-01f, 1.65853918e-01f, -8.72343704e-02f, 1.05849996e-01f, 7.15340599e-02f, -8.57703388e-02f, 9.63693392e-03f,
  -8.04904476e-02f, 1.26230240e-01f, -1.19979656e-03f, -8.34169909e-02f, 3.32108885e-02f, -3.54509801e-02f, 1.38285488e-01f, 2.97602322e-02f, -1.67856842e-01f, -1.76706031e-01f,
  1.06331863e-01f, 1.29906833e-01f, -5.40539026e-02f, 3.05578136e-03f, -4.23940569e-02f, 1.97670490e-01f, -2.88557913e-02f, -8.61484632e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.81920771e-02f, -8.89395028e-02f, -5.20594195e-02f, 1.09308124e-01f, 7.42212385e-02f, -8.94079916e-03f, -4.12412547e-03f, -1.08771011e-01f, -1.24521822e-01f, -2.87575405e-02f,
  6.02436773e-02f, -1.01946515e-03f, -9.36014229e-04f, 9.88860726e-02f, 1.18140839e-01f, 7.68014835e-03f, -8.81493166e-02f, -9.30965394e-02f, 1.19884945e-01f, -3.59974168e-02f,
  -8.74960050e-02f, -1.07981283e-02f, 1.20010361e-01f, 1.40386606e-02f, 7.60694072e-02f, -1.07317537e-01f, -1.61471926e-02f, -9.27556828e-02f, 1.14956766e-01f, -8.73186067e-02f,
  -5.37200198e-02f, -1.54320942e-02f, -8.76760185e-02f, 2.29740012e-02f, -1.00369625e-01f, 7.51380324e-02f, -6.98612630e-02f, 1.20490054e-02f, 1.36983795e-02f, 7.28376284e-02f,
  -1.09769329e-01f, -3.34136793e-03f, -1.05033010e-01f, 1.10575058e-01f, 9.79626626e-02f, 1.06662527e-01f, 8.17537233e-02f, 9.52325910e-02f, -8.92014056e-02f, 2.90260054e-02f,
  1.22199394e-01f, 4.87668589e-02f, -6.55066362e-03f, -1.06501170e-01f, -8.52430388e-02f, 2.20042169e-02f, -7.37218037e-02f, -1.51839694e-02f, 6.10784395e-03f, 6.07949048e-02f,
  1.79862455e-02f, -1.19945280e-01f, -5.19123562e-02f, -8.52918550e-02f, 7.86165670e-02f, 5.07453792e-02f, 1.50841465e-02f, 1.60796624e-02f, -3.02390978e-02f, 1.26944453e-01f,
  8.93532336e-02f, -9.97027308e-02f, 3.22399959e-02f, -9.18953642e-02f, -3.97674851e-02f, 1.40960375e-02f, 1.09285645e-01f, 1.38146207e-01f, -2.36534756e-02f, -1.95419282e-01f,
  -1.09264635e-01f, -7.26428777e-02f, -4.44027260e-02f, 1.19545065e-01f, -7.52036721e-02f, 4.19770600e-03f, 7.39196166e-02f, -1.20740362e-01f, 7.62633532e-02f, 1.12638585e-01f,
  -8.48510340e-02f, -1.07315905e-01f, 1.36663005e-01f, -1.49431661e-01f, 5.32526709e-02f, 1.97485507e-01f, 9.41287130e-02f, -3.47442217e-02f, 4.93669510e-02f, -3.83955687e-02f,
  -2.76713707e-02f, -5.17523736e-02f, -7.93755054e-02f, 9.81702209e-02f, 1.25318959e-01f, -8.79352763e-02f, 1.09569646e-01f, 1.38002485e-01f, 1.85833164e-02f, 7.99833760e-02f,
  3.00476439e-02f, 1.29908159e-01f, -3.79126593e-02f, 4.98673432e-02f, -1.32697774e-02f, 8.30602199e-02f, 1.94080755e-01f, 9.15969908e-02f, 4.95930202e-02f, -1.21362619e-01f,
  -4.84828539e-02f, 1.67671114e-01f, -1.18586347e-01f, 4.45470773e-02f, 7.30280057e-02f, -2.17367876e-02f, 4.93091755e-02f, -1.20308474e-01f, 1.86446190e-01f, 5.51693104e-02f,
  -2.07983807e-01f, -7.87905157e-02f, -6.03549927e-02f, 1.46301433e-01f, 4.88841981e-02f, 6.79824948e-02f, 7.36068860e-02f, 1.56696662e-01f, 8.77828747e-02f, 1.35487253e-02f,
  -5.86347915e-02f, -1.47912025e-01f, -3.18642050e-01f, -1.68710589e-01f, 9.55330431e-02f, 5.37562966e-02f, -1.93627745e-01f, -4.47260290e-02f, -8.43981132e-02f, 1.59187779e-01f,
  8.86823609e-02f, -3.00508067e-02f, 6.15020171e-02f, -1.87228937e-02f, -1.62622873e-02f, -6.59703985e-02f, -1.42755225e-01f, 1.56559646e-01f, -7.79841244e-02f, 1.92121819e-01f,
  -2.39443034e-02f, -1.27437944e-02f, -3.11292503e-02f, -5.74572906e-02f, -1.52185723e-01f, 1.54402331e-01f, 1.19336829e-01f, 3.78632620e-02f, -1.03694111e-01f, -2.70585641e-02f,
  -3.85813368e-03f, 4.05580960e-02f, 2.81496823e-01f, 4.85398695e-02f, -3.32973711e-02f, -1.72845982e-02f, 5.49559519e-02f, 3.59363481e-02f, 3.55847776e-02f, 1.26112357e-01f,
  1.36881635e-01f, 1.61727548e-01f, 2.15749051e-02f, -2.57700449e-03f, -1.63285166e-01f, 1.63284183e-01f, -1.78443670e-01f, 8.85032192e-02f, -7.38857463e-02f, -1.28868297e-01f,
  1.65381491e-01f, 4.59165778e-03f, 5.24997562e-02f, -5.88145554e-02f, 3.61893773e-02f, 1.16786845e-01f, -6.04402414e-03f, 7.23262951e-02f, 3.33503708e-02f, -3.78498025e-02f,
  -8.31246376e-02f, 2.28740219e-02f, -1.29498877e-02f, -1.10336952e-02f, -1.30615503e-01f, 9.38944444e-02f, 8.23177919e-02f, 7.93986470e-02f, -8.46618041e-02f, 1.42819108e-02f,
  1.47076339e-01f, -5.28439730e-02f, 5.81454709e-02f, 7.47829005e-02f, 1.35150373e-01f, -1.80494674e-02f, 4.62440923e-02f, -2.62913797e-02f, -2.02411916e-02f, 1.07405610e-01f,
  -1.13818320e-02f, 1.05895221e-01f, 5.68841882e-02f, 7.58697987e-02f, 1.45612014e-02f, 1.87007226e-02f, -1.02225371e-01f, -5.83492219e-02f, 1.30950771e-02f, -9.20061693e-02f,
  1.31230921e-01f, 6.08778186e-02f, -1.58337444e-01f, 1.29481271e-01f, 1.53889805e-01f, -5.91081157e-02f, -1.95055269e-02f, -1.46044344e-02f, 1.49571478e-01f, 8.27472955e-02f,
  -7.84102827e-02f, -5.87180443e-02f, 5.32167666e-02f, -4.08445932e-02f, 1.30672036e-02f, 1.13592662e-01f, 1.48364857e-01f, 1.28813133e-01f, -3.80078033e-02f, -1.67084366e-01f,
  1.33763909e-01f, -6.65902719e-02f, 1.47217028e-02f, 6.38474301e-02f, 2.13092417e-01f, 9.86079648e-02f, -6.61240593e-02f, -1.20457970e-01f, -3.51567939e-03f, -9.12865549e-02f,
  2.43710494e-03f, -7.91583508e-02f, 2.73760152e-03f, -8.21281150e-02f, -8.09268132e-02f, -9.39373374e-02f, 5.60921878e-02f, 8.04404393e-02f, 1.48498835e-02f, -3.26615572e-02f,
  -3.79844978e-02f, -1.01463646e-01f, -1.14242718e-01f, -6.09565005e-02f, 2.02966575e-02f, 3.48655246e-02f, 6.33236617e-02f, 8.68889466e-02f, -2.54277214e-02f, -5.36831766e-02f,
  7.15914220e-02f, -3.64490077e-02f, -1.16776720e-01f, -3.50255184e-02f, -2.68966779e-02f, 9.41968523e-03f, -4.44269218e-02f, 5.21594733e-02f, -6.58921376e-02f, 1.36825619e-02f,
  6.26114309e-02f, 6.60014525e-02f, 3.06129940e-02f, -1.01740345e-01f, -9.24138278e-02f, -1.61845237e-02f, 8.49211868e-03f, 8.83461609e-02f, 7.17061460e-02f, -1.15848966e-02f,
  -9.38299447e-02f, -8.76792148e-02f, -1.09229781e-01f, 1.07839882e-01f, 9.63377357e-02f, -9.01573077e-02f, 8.04300085e-02f, -1.68329310e-02f, 8.94012228e-02f, -1.07584416e-03f,
  -1.01781309e-01f, 3.23666871e-04f, -5.51733933e-02f, 9.23025161e-02f, 2.26204190e-02f, 4.66154050e-03f, -8.75776336e-02f, -9.40163136e-02f, 2.82647205e-03f, 1.55321881e-02f,
  8.64773542e-02f, 9.65430513e-02f, 7.87904784e-02f, -2.95406338e-02f, 5.19998418e-03f, 9.26379412e-02f, -2.16387194e-02f, 9.03483853e-02f, 8.70167688e-02f, -4.65771072e-02f,
  -4.90831435e-02f, -6.08672500e-02f, -7.21121114e-03f, -1.25750199e-01f, -4.86214943e-02f, 6.57652766e-02f, -1.35955848e-02f, -1.23697981e-01f, 3.68746407e-02f, 1.13255233e-01f,
  -4.76462916e-02f, 9.67893153e-02f, -4.37265858e-02f, 1.32916138e-01f, -9.60101411e-02f, 4.65247408e-02f, 1.05457634e-01f, 5.09862080e-02f, -9.54358205e-02f, -1.06964938e-01f,
  1.74142674e-01f, 6.53066188e-02f, -5.88295422e-03f, 8.16487521e-03f, 7.18292743e-02f, 1.64178342e-01f, -7.33832642e-02f, -5.02132513e-02f, -2.43157838e-02f, 1.39764741e-01f,
  -7.72240162e-02f, -1.90817902e-03f, -3.70650515e-02f, -4.99054790e-02f, 1.63377926e-01f, 9.45655331e-02f, -9.37645063e-02f, -5.76276216e-04f, 6.15390316e-02f, -2.79980488e-02f,
  -4.32731062e-02f, 6.44242093e-02f, 3.59516516e-02f, 6.82427883e-02f, 1.12685680e-01f, 1.08540654e-01f, 1.00641027e-01f, 8.93677473e-02f, 1.65657192e-01f, -2.42723264e-02f,
  -8.78184587e-02f, 1.81744352e-01f, 1.25091031e-01f, -2.89185494e-02f, 4.14090864e-02f, -1.50446352e-02f, -7.51767308e-02f, 4.86844853e-02f, 4.15401049e-02f, 6.12498894e-02f,
  7.75719583e-02f, -5.86710982e-02f, 5.32599092e-02f, -7.31081590e-02f, 3.91981341e-02f, -6.28702044e-02f, 1.75752759e-01f, -1.73212700e-02f, -3.49660143e-02f, -8.32395777e-02f,
  2.01078635e-02f, 3.38650160e-02f, 2.19376311e-02f, 6.97640330e-02f, -2.44631931e-01f, 7.61988908e-02f, -1.01386897e-01f, 9.99149755e-02f, 5.88473119e-02f, 2.66883940e-01f,
  -1.23694027e-02f, -9.25713405e-02f, 4.97483276e-02f, -1.95623845e-01f, 1.89248502e-01f, -4.84279916e-02f, 9.54469219e-02f, -5.98368831e-02f, 5.77750430e-02f, -2.25226060e-02f,
  8.22691768e-02f, -6.18731268e-02f, -1.12065643e-01f, 1.18262455e-01f, 6.50141686e-02f, -1.30800596e-02f, -1.59986708e-02f, 1.24048248e-01f, 5.96021041e-02f, 1.69323698e-01f,
  -8.56772289e-02f, -8.68523680e-03f, -2.85771750e-02f, -6.58611301e-03f, -2.05483958e-02f, 1.22918047e-01f, 1.85818583e-01f, 1.08402714e-01f, 1.28254980e-01f, -6.21535033e-02f,
  1.57975778e-02f, -3.43751386e-02f, -6.59377873e-02f, 1.30875126e-01f, -7.67507702e-02f, 2.66706288e-01f, -1.89810887e-01f, -1.46230310e-01f, 1.12854026e-03f, 8.10580105e-02f,
  -8.02073181e-02f, -5.08190505e-02f, 1.19235642e-01f, -3.23787928e-02f, 2.90977079e-02f, 8.53351057e-02f, -9.18268785e-02f, 1.32484697e-02f, 1.17314853e-01f, -4.91288677e-03f,
  1.35561943e-01f, -4.11737002e-02f, -3.18574533e-02f, 1.90680474e-02f, 1.01118349e-01f, -1.27376527e-01f, 1.30029485e-01f, -1.20662294e-01f, -1.37348011e-01f, 1.24477550e-01f,
  7.08395541e-02f, 9.19026658e-02f, -1.31385654e-01f, 2.44497925e-01f, -7.03988001e-02f, -2.56657898e-02f, -2.86900699e-02f, -8.10835510e-02f, -7.29857339e-03f, 3.96914184e-02f,
  1.05032362e-01f, -1.39237260e-02f, 1.67333916e-01f, -2.78088776e-03f, 5.24652153e-02f, 1.15931258e-01f, 1.07243143e-01f, 6.95410371e-02f, -9.47809666e-02f, -1.15096860e-01f,
  -1.37322456e-01f, -4.55909036e-02f, 1.01029836e-01f, 1.17423922e-01f, 1.00959711e-01f, 5.42086847e-02f, 9.74651054e-02f, -2.61153411e-02f, 1.62771672e-01f, 7.38071054e-02f,
  8.58437344e-02f, -2.81839296e-02f, -6.92663118e-02f, 9.65083390e-02f, -1.17634200e-01f, -6.58751279e-02f, 5.42458519e-02f, -7.70330941e-03f, -5.96517436e-02f, 2.82909200e-02f,
  1.20205887e-01f, -3.48832868e-02f, 1.02348655e-01f, 9.24968347e-02f, 1.10206887e-01f, -5.39217554e-02f, 1.05803050e-01f, -1.27987117e-01f, 2.12757699e-02f, -4.56308797e-02f,
  -5.47472537e-02f, -4.98989858e-02f, 1.33749805e-02f, 2.30048839e-02f, 4.35330495e-02f, 1.00800514e-01f, 1.20511986e-02f, -8.65014363e-03f, -1.35285094e-01f, 1.15467384e-02f,
  -9.06363428e-02f, 7.12473094e-02f, -4.57614213e-02f, -1.25569656e-01f, -1.22680724e-01f, -5.43916561e-02f, 2.65364088e-02f, 1.56362683e-01f, 9.03092548e-02f, 1.36189565e-01f,
  1.24457367e-01f, 5.03070317e-02f, 1.24288671e-01f, 1.38541739e-02f, 2.45682836e-01f, -1.28633417e-02f, 1.86835408e-01f, -4.70847897e-02f, 1.19454347e-01f, -1.63279846e-02f,
  4.77372594e-02f, -8.81632641e-02f, -5.08103892e-02f, -1.00380361e-01f, 1.13098659e-01f, 3.52018699e-02f, 3.85974161e-02f, 2.15347167e-02f, -1.70959830e-02f, 6.51382804e-02f,
  1.13369919e-01f, -5.59457205e-02f, 1.40690804e-01f, 7.60455653e-02f, 2.84954727e-01f, 1.65875927e-01f, -6.04982488e-02f, -1.66848823e-01f, 1.46972597e-01f, 1.15226209e-01f,
  5.58855385e-03f, 1.34662971e-01f, -6.97258338e-02f, 6.85103685e-02f, 3.19518819e-02f, -1.01546407e-01f, 1.51618570e-01f, 1.26704320e-01f, 5.66508844e-02f, 1.30482852e-01f,
  -4.62927409e-02f, 1.77817230e-04f, 1.77477106e-01f, 5.88598177e-02f, 1.53459804e-02f, 2.36605421e-01f, 3.06446720e-02f, 1.46745175e-01f, -7.75798634e-02f, -1.07178846e-02f,
  2.04138421e-02f, 4.88333218e-02f, 9.26455706e-02f, -4.21991460e-02f, 4.85978872e-02f, -8.37352313e-03f, 1.44655898e-01f, -2.70689512e-03f, 3.61531861e-02f, -5.68308793e-02f,
  9.83215272e-02f, 1.22746848e-01f, 1.02186605e-01f, -9.85656306e-03f, -7.57928416e-02f, -8.51602480e-02f, 9.86710116e-02f, 7.21854493e-02f, -7.22441077e-02f, -1.35100130e-02f,
  -1.20900273e-01f, 2.45095436e-02f, 5.59671745e-02f, 3.72830331e-02f, 1.06210917e-01f, -1.37283325e-01f, 4.22563665e-02f, 1.41080692e-01f, -7.27950856e-02f, -1.21443905e-03f,
  -5.01429066e-02f, -1.17093008e-02f, -5.98149076e-02f, -1.16329886e-01f, -1.08217299e-01f, -9.08420309e-02f, -6.24272712e-02f, -4.04803418e-02f, 1.88361155e-03f, 1.24796994e-01f,
  4.20096628e-02f, -3.84013839e-02f, -7.95729533e-02f, -7.72374868e-02f, -7.03685954e-02f, -3.13781463e-02f, 1.35416061e-01f, -1.52508840e-01f, 1.39758334e-01f, 4.38648555e-03f,
  8.18090513e-02f, -1.79385021e-02f, -1.65769845e-01f, 7.88405910e-02f, -9.11660641e-02f, 1.77787215e-01f, 3.95224430e-02f, 1.04543455e-01f, 2.46969108e-02f, 1.15322717e-01f,
  2.20781863e-02f, 1.87765136e-01f, 9.09657553e-02f, -7.10164532e-02f, -1.82029739e-01f, -4.19411436e-02f, 2.85451502e-01f, -3.85279991e-02f, -4.81413119e-02f, -4.91529517e-02f,
  3.87101769e-02f, 1.24700502e-01f, 1.17564484e-01f, 8.31626132e-02f, 1.13173112e-01f, 6.00892305e-02f, -1.21379688e-01f, -5.99870756e-02f, -5.23809455e-02f, -3.07731587e-03f,
  -5.45332022e-02f, 7.23755583e-02f, 6.17535673e-02f, 3.64917368e-02f, -1.46415653e-02f, 1.37234945e-03f, -1.49456352e-01f, -2.37645134e-02f, -1.89452823e-02f, 9.07010809e-02f,
  7.12343231e-02f, -1.32673725e-01f, -7.69467801e-02f, 1.23344526e-01f, 2.45221868e-01f, 1.25387728e-01f, 2.77671292e-02f, 6.10217415e-02f, -3.91110890e-02f, 1.03993021e-01f,
  2.28545349e-02f, 3.80296037e-02f, 7.04961941e-02f, -4.58800122e-02f, -6.23373240e-02f, 8.98388252e-02f, -8.43440890e-02f, 1.29075423e-01f, -5.76553904e-02f, 8.02486166e-02f,
  -1.12622157e-02f, -7.01463595e-02f, -2.53220517e-02f, 1.27695039e-01f, 1.22689672e-01f, -7.75668249e-02f, -6.06078170e-02f, 8.08492228e-02f, -2.85239536e-02f, -1.05146337e-02f,
  -1.03409886e-01f, -3.57406102e-02f, 4.99716997e-02f, -2.22781114e-02f, -3.77929248e-02f, -4.98970672e-02f, -7.80111253e-02f, 1.05319500e-01f, 7.52018616e-02f, 9.15833935e-03f,
  1.66143570e-02f, 6.81786090e-02f, 6.15569763e-02f, -1.17321715e-01f, -1.22082531e-01f, -5.46767525e-02f, -7.47285113e-02f, 4.50062603e-02f, -1.05031423e-01f, -1.01168185e-01f,
  4.43789661e-02f, -1.00427389e-01f, 1.25568792e-01f, 1.17315546e-01f, 8.80813748e-02f, -1.77956857e-02f, -1.96051430e-02f, 7.04779010e-03f, 9.68742222e-02f, 9.34307426e-02f,
  -5.11378683e-02f, -1.04806401e-01f, 4.90176901e-02f, -4.71517630e-02f, 5.64062502e-04f, 3.52496803e-02f, -1.16816223e-01f, -3.87275256e-02f, -5.97211644e-02f, 8.79966170e-02f,
  1.03927225e-01f, 7.21141770e-02f, 1.05348211e-02f, 8.48804191e-02f, 6.86355680e-02f, 1.05037183e-01f, 7.23956600e-02f, -1.10104173e-01f, -8.99951905e-02f, 4.63007204e-02f,
  -6.82406500e-02f, -3.10051329e-02f, 5.49611785e-02f, -1.91613920e-02f, 4.81838174e-02f, -1.20091744e-01f, -1.12580471e-02f, 6.78770319e-02f, 6.77816421e-02f, 1.26690984e-01f,
  1.41354995e-02f, -2.76114307e-02f, 1.29510924e-01f, 7.94516057e-02f, 1.50914550e-01f, 2.84871198e-02f, -3.72498557e-02f, 1.16322182e-01f, 3.65425162e-02f, 1.25631467e-01f,
  -4.40511815e-02f, -1.30863376e-02f, 3.30859125e-02f, -2.44030403e-03f, 1.70496508e-01f, -3.08697931e-02f, 1.80914644e-02f, -1.13623708e-01f, -1.47218198e-01f, -7.98610151e-02f,
  4.92234416e-02f, -1.52444178e-02f, 2.18145564e-01f, 7.02759251e-02f, -4.59580086e-02f, 4.69614333e-03f, 4.18304466e-02f, -9.17736143e-02f, 1.82640731e-01f, -5.60242729e-03f,
  -3.59927900e-02f, -8.66358355e-02f, -1.07657000e-01f, 1.09044008e-01f, -5.99484816e-02f, -8.93974379e-02f, 7.98970833e-02f, -1.04706615e-01f, 2.06226278e-02f, -8.95400196e-02f,
  -2.85524037e-02f, -7.87941143e-02f, 1.51540682e-01f, -3.70592042e-03f, -3.84970792e-02f, -1.03792481e-01f, -7.61454850e-02f, 3.46697196e-02f, -5.27982749e-02f, 3.97788063e-02f,
  -9.03814659e-03f, 3.44698764e-02f, -3.38590592e-02f, 1.42739132e-01f, -1.04147933e-01f, 1.18823729e-01f, 1.74694702e-01f, -1.46114174e-02f, 7.25032110e-03f, 6.44029751e-02f,
  1.40130341e-01f, -5.36428913e-02f, 1.31711185e-01f, 6.95087984e-02f, 3.30081210e-02f, 7.37492964e-02f, 1.08635738e-01f, 1.78963542e-01f, -3.90473113e-04f, 1.11027136e-01f,
  5.73861003e-02f, 1.25993267e-01f, -3.14958729e-02f, 6.36043176e-02f, 9.31106880e-02f, 7.52163157e-02f, 2.07377207e-02f, -7.02278167e-02f, 2.24319428e-01f, 6.76047206e-02f,
  -9.45936143e-02f, -1.48691628e-02f, -2.20532402e-01f, -7.80990347e-02f, 1.23012319e-01f, 1.59795567e-01f, 1.61412403e-01f, -5.00377491e-02f, -4.24822755e-02f, -2.94273756e-02f,
  -5.67195751e-03f, -1.19813643e-01f, 1.13555945e-01f, 2.23587472e-02f, -7.71838352e-02f, -1.08187065e-01f, 1.62826627e-01f, 7.84754455e-02f, -1.35880589e-01f, -9.86983478e-02f,
  8.06288198e-02f, 8.79082084e-02f, 5.81878908e-02f, -1.53833494e-01f, -1.23072721e-01f, -4.56271581e-02f, 2.33252287e-01f, 1.80095226e-01f, -7.77478144e-02f, 2.76902616e-02f,
  -5.50875161e-03f, -1.66264661e-02f, -6.60664681e-03f, -9.00707170e-02f, -4.43121567e-02f, 4.83610146e-02f, -1.34217637e-02f, -4.42913324e-02f, -9.07619074e-02f, -7.33137503e-03f,
  1.12571018e-02f, -2.29466930e-02f, -3.15145664e-02f, 1.76424339e-01f, -1.17847800e-01f, -1.14035368e-01f, 1.17099144e-01f, -1.03537105e-01f, 7.79458955e-02f, -1.21325448e-01f,
  -9.31616947e-02f, -4.21341881e-02f, 1.35741951e-02f, 3.06219999e-02f, 1.38113583e-02f, -7.16971317e-06f, -9.33075845e-02f, -1.51782930e-02f, -4.32272628e-03f, -3.52904536e-02f,
  -4.02651094e-02f, -7.94036388e-02f, -5.26476977e-03f, -1.71337679e-01f, 4.30945493e-02f, -2.02639457e-02f, -1.78677514e-01f, 1.27066493e-01f, -2.86150927e-04f, -1.37662172e-01f,
  -1.03612021e-01f, 7.78678730e-02f, -5.32940635e-03f, -9.40115973e-02f, -1.15115196e-01f, -1.13962747e-01f, 1.00374959e-01f, 1.44304976e-01f, 1.63663343e-01f, 2.77905930e-02f,
  4.07081731e-02f, 1.05494283e-01f, -2.87668388e-02f, -2.33421102e-02f, -6.16424307e-02f, -5.87288775e-02f, -9.29429606e-02f, 7.17930272e-02f, -1.22923292e-01f, 1.05551831e-01f,
  2.65994255e-04f, 1.09850779e-01f, -6.92159543e-03f, 1.35336533e-01f, -6.38183430e-02f, 1.20326571e-01f, 1.05471872e-02f, 1.42091975e-01f, 1.92330822e-01f, -7.07715824e-02f,
  1.98374386e-03f, 9.00957957e-02f, -1.35092542e-01f, 8.81287307e-02f, 8.29031914e-02f, 1.31186649e-01f, -1.08984187e-01f, 1.36861533e-01f, -1.02081485e-01f, -1.18979692e-01f,
  7.87186250e-02f, -7.87919536e-02f, 7.96326026e-02f, 5.28939217e-02f, -1.04567431e-01f, 1.23370655e-01f, -5.04785702e-02f, 1.33762866e-01f, -3.61652337e-02f, 8.09169374e-03f,
  1.26192555e-01f, -3.86988297e-02f, -7.81572014e-02f, 7.36908093e-02f, -1.10887185e-01f, -8.57143551e-02f, 7.30304495e-02f, -1.34994723e-02f, -1.12836435e-01f, -7.47395754e-02f,
  9.98896807e-02f, -4.57699858e-02f, -1.10248709e-02f, 5.05494932e-03f, 7.46180639e-02f, -9.20861866e-03f, 5.25846938e-03f, 5.39616272e-02f, -2.47383676e-02f, -9.64250490e-02f,
  -7.97725096e-02f, 1.04625791e-03f, 2.49696081e-03f, 1.47677407e-01f, -2.27252385e-04f, -1.95997767e-03f, -5.22011966e-02f, -4.91024777e-02f, 7.73044974e-02f, 6.21849820e-02f,
  -7.20984265e-02f, -1.03884069e-02f, 8.63544457e-03f, -6.91303015e-02f, 5.27925305e-02f, 6.66254386e-02f, 8.49116128e-03f, 5.39496029e-03f, -1.18345797e-01f, -1.03045285e-01f,
  -4.75209616e-02f, -1.15778521e-01f, -8.38530213e-02f, 6.48006946e-02f, 5.61858378e-02f, -2.95959767e-02f, 6.50091469e-02f, -7.11518377e-02f, -3.22316810e-02f, -6.72174841e-02f,
  4.30206247e-02f, -7.89181795e-03f, 4.64976318e-02f, -5.38398251e-02f, -3.43066361e-03f, 4.25819941e-02f, 1.78367883e-01f, 1.95931971e-01f, 8.02617334e-03f, -3.17577571e-02f,
  1.40896261e-01f, 1.12019859e-01f, 1.55857489e-01f, 1.12596273e-01f, 5.76404482e-02f, 9.73230749e-02f, -1.46893308e-01f, 1.18054867e-01f, -4.80496213e-02f, 1.90750495e-01f,
  -8.15035552e-02f, -4.69571054e-02f, 1.95965186e-01f, -6.31950647e-02f, 2.77024567e-01f, -1.03349611e-03f, 1.03661001e-01f, -5.12396172e-02f, -6.98999688e-02f, -1.15202079e-02f,
  -5.45129031e-02f, 2.36206412e-01f, 1.48525536e-01f, 4.16421667e-02f, -1.08992249e-01f, 5.01516275e-03f, -1.21825121e-01f, 2.25647762e-02f, -6.49505556e-02f, -1.06726579e-01f,
  -4.28184830e-02f, -2.74136290e-02f, 2.23906741e-01f, -1.07245170e-01f, -3.13715860e-02f, 2.06924140e-01f, 4.05451953e-02f, 9.02012398e-04f, 8.02924782e-02f, -1.91629037e-01f,
  1.62955865e-01f, -1.02435827e-01f, -5.09069376e-02f, 2.27149334e-02f, 1.12337939e-01f, -6.09309599e-02f, 6.87978566e-02f, 1.50004610e-01f, 2.42586792e-01f, -3.15828919e-02f,
  8.83794501e-02f, -1.74574286e-01f, 2.26620793e-01f, -1.32455394e-01f, 7.09469523e-03f, 3.07991635e-02f, 2.29604870e-01f, 1.49407938e-01f, 1.43034205e-01f, -4.47461829e-02f,
  6.67821467e-02f, 1.81857422e-01f, 2.37435475e-01f, 1.13784105e-01f, 1.16216354e-01f, 1.39622316e-01f, 1.33025467e-01f, 1.53143987e-01f, 6.19224384e-02f, 1.59525439e-01f,
  -2.04558417e-01f, -1.76388882e-02f, 7.55443275e-02f, -1.47032320e-01f, -2.99410224e-01f, 1.16703488e-01f, -1.34888012e-02f, 2.26039602e-03f, 1.61914125e-01f, -2.06910640e-01f,
  -4.94250879e-02f, -7.39817098e-02f, 7.75813833e-02f, 6.95755407e-02f, 1.12964585e-01f, 1.58650696e-01f, 2.93972820e-01f, 9.78436321e-02f, -8.21102411e-03f, 4.91341352e-02f,
  -3.71558368e-02f, 1.97828874e-01f, 1.38497487e-01f, -1.45473927e-01f, 1.30734473e-01f, 3.78737855e-03f, 2.84818232e-01f, -6.88828751e-02f, 1.27993181e-01f, -6.01447839e-03f,
  2.94700623e-01f, 7.11143464e-02f, -1.13956802e-01f, -1.06256686e-01f, 5.24731576e-02f, -1.75231490e-02f, -1.08070467e-02f, 2.95977239e-02f, 4.10837084e-02f, -3.49084362e-02f,
  1.97439745e-01f, 1.78496063e-01f, -9.00466219e-02f, -2.82153785e-02f, 2.56377131e-01f, 7.09815398e-02f, -3.68140489e-02f, 1.05934618e-02f, 6.16800301e-02f, -6.54725954e-02f,
  4.97939251e-02f, -4.91085127e-02f, 1.03720412e-01f, 1.74199969e-01f, -1.49926975e-01f, -1.98378749e-02f, -9.93093997e-02f, 1.21643366e-02f, 1.13533370e-01f, 1.61189735e-01f,
  -5.96369896e-03f, 5.38093075e-02f, 2.57781409e-02f, 1.75128222e-01f, 7.53911585e-02f, -4.67678867e-02f, -1.62523240e-01f, -7.46944323e-02f, 2.73727596e-01f, -1.21907488e-01f,
  1.00632958e-01f, -1.23775356e-01f, 5.56663461e-02f, 1.08869776e-01f, 1.58519939e-01f, -3.01481504e-02f, 1.63817368e-02f, 9.89366919e-02f, -1.54321466e-03f, -8.15306529e-02f,
  -1.69963270e-01f, -6.45567104e-02f, 2.38060802e-02f, 1.26437813e-01f, 6.46940097e-02f, 6.92060217e-02f, -5.96373454e-02f, -7.13665560e-02f, -7.08797574e-02f, 3.67598794e-02f,
  -2.02697478e-02f, 1.02588739e-02f, -7.08776712e-02f, 9.11891460e-02f, -5.78356870e-02f, 5.47628067e-02f, 2.45467380e-01f, -5.59166484e-02f, -1.92574575e-03f, -1.07063405e-01f,
  8.83286744e-02f, 9.97372642e-02f, 4.91352454e-02f, 8.49028826e-02f, -1.10416315e-01f, 6.26090541e-02f, 1.12655804e-01f, 9.59338099e-02f, -1.65344447e-01f, 9.01786759e-02f,
  1.58306181e-01f, 1.36491522e-01f, -7.41798580e-02f, 8.15559551e-02f, 4.08197343e-02f, -3.18401381e-02f, 6.76643476e-02f, 4.24830243e-02f, -1.03327990e-01f, -1.08103983e-01f,
  1.09757490e-01f, 1.28872305e-01f, 1.02117352e-01f, -1.07190438e-01f, -8.85408372e-02f, 1.37873385e-02f, -7.33643863e-03f, -1.66655276e-02f, 1.24684118e-01f, -4.31764610e-02f,
  -3.72473933e-02f, 3.10164895e-02f, 8.98217931e-02f, 1.31422132e-01f, -1.31406531e-01f, 8.43844935e-02f, 1.01348147e-01f, 4.67888564e-02f, -5.47338314e-02f, -8.67106020e-02f,
  -7.57423341e-02f, -1.49334893e-02f, -1.13173969e-01f, 4.35358733e-02f, -1.99645478e-02f, 6.90599978e-02f, 9.94998589e-02f, 1.13509439e-01f, -7.42494017e-02f, -6.11350685e-02f,
  -6.34873807e-02f, 9.29655507e-02f, 3.01196054e-02f, -7.90515989e-02f, 1.61452457e-01f, 9.83463749e-02f, 3.67726125e-02f, -5.54209575e-02f, -1.97565127e-02f, 1.27149031e-01f,
  1.29693776e-01f, -7.37374201e-02f, -8.64250865e-03f, -9.93641466e-02f, 7.78143331e-02f, -5.30652553e-02f, 4.50903289e-02f, -4.53255232e-03f, -1.22457296e-01f, 3.63253206e-02f,
  2.98208911e-02f, -4.25381400e-02f, 5.42901009e-02f, -1.09839156e-01f, -4.16906513e-02f, 1.00930065e-01f, 7.65381083e-02f, -1.03727408e-01f, -9.89824161e-02f, 1.09544806e-01f,
  -2.12465748e-02f, 8.48961398e-02f, 3.57827693e-02f, -3.29722324e-03f, 3.00236158e-02f, 1.40840679e-01f, 1.29847601e-01f, 1.11536987e-01f, -6.69081733e-02f, 1.84939772e-01f,
  6.53882846e-02f, -4.63593639e-02f, 1.71559513e-01f, 4.65041362e-02f, 2.46450324e-02f, -1.02215372e-01f, 1.96736544e-01f, -1.47311702e-01f, -2.20329612e-02f, -1.32066486e-02f,
  -1.52034402e-01f, -8.38811100e-02f, 5.18115275e-02f, -1.46665737e-01f, 1.31316394e-01f, 8.52254406e-02f, 1.07615590e-01f, -1.66592553e-01f, -2.84134992e-03f, -4.73975539e-02f,
  8.73442367e-02f, -1.46460067e-02f, 1.81624323e-01f, 6.85093626e-02f, 1.15743935e-01f, 5.06821051e-02f, -8.15223157e-02f, 1.30975410e-01f, -1.56176105e-01f, -1.98463038e-01f,
  4.02297080e-02f, 3.85591723e-02f, -1.23674765e-01f, -4.96922934e-04f, -5.65339625e-02f, -1.69799794e-02f, -9.41240937e-02f, 4.47827429e-02f, -5.49318306e-02f, 3.92396040e-02f,
  4.16506752e-02f, 1.21912723e-02f, 4.01716381e-02f, -1.51750997e-01f, 1.98561832e-01f, 1.94597438e-01f, -9.46013927e-02f, 9.18726102e-02f, 1.58190787e-01f, 1.44337505e-01f,
  1.54134080e-01f, 2.01684996e-01f, 3.11035756e-02f, -1.75351769e-01f, 1.99045949e-02f, 5.71266003e-02f, -6.60124421e-02f, -6.39395341e-02f, 9.22197253e-02f, -6.87020943e-02f,
  1.67831611e-02f, 1.62793949e-01f, 8.80123898e-02f, -6.86823279e-02f, 1.26372203e-01f, -5.32557927e-02f, -6.82494119e-02f, -1.20710641e-01f, -1.56788871e-01f, -7.24896863e-02f,
  -3.54629681e-02f, -6.98139742e-02f, -1.03581078e-01f, -8.40492994e-02f, 9.88333672e-02f, 1.68749001e-02f, 1.00763574e-01f, -1.44149259e-01f, 1.12309225e-01f, 6.26633700e-04f,
  -7.50478804e-02f, -4.66685556e-02f, -3.03783230e-02f, 6.70106933e-02f, -3.42102274e-02f, 1.62651435e-01f, 6.33059964e-02f, -2.54619662e-02f, 5.12775965e-02f, -3.05101853e-02f,
  5.37572280e-02f, 9.40741375e-02f, 3.46492939e-02f, -2.88714077e-02f, 1.06411055e-01f, -7.41567165e-02f, -1.14341974e-01f, -6.56948835e-02f, 9.39162150e-02f, 7.87433162e-02f,
  1.13767788e-01f, 6.11051396e-02f, 2.96599623e-02f, 1.68320676e-03f, -7.28883669e-02f, -3.28592882e-02f, -4.30954387e-03f, 3.32525894e-02f, 1.03791215e-01f, -5.98626733e-02f,
  -8.77270475e-02f, -1.33796278e-02f, -1.31039381e-01f, 9.15559456e-02f, -1.03423201e-01f, -1.39293939e-01f, -2.10432429e-03f, -9.27080512e-02f, 1.05395108e-01f, 5.99960536e-02f,
  -2.15220787e-02f, -4.65766266e-02f, 7.99151361e-02f, 5.24373315e-02f, -5.86299486e-02f, -6.24839030e-02f, 1.01590246e-01f, -3.25824134e-02f, 1.26164243e-01f, 7.68184364e-02f,
  -5.11944667e-02f, 1.30150272e-02f, 5.06415926e-02f, -1.01085149e-01f, -1.18085958e-01f, -1.86291095e-02f, 6.13876432e-03f, 6.98389933e-02f, -2.55353361e-01f, 7.88503215e-02f,
  -3.13709937e-02f, 8.06193203e-02f, -1.43440470e-01f, 3.74971926e-01f, 5.71744815e-02f, 1.18980706e-02f, 6.48342669e-02f, -1.47521883e-01f, 9.80731398e-02f, 1.50328964e-01f,
  3.55266124e-01f, 4.07519974e-02f, 2.28843018e-01f, 3.79710132e-03f, 9.62596759e-02f, 1.30842984e-01f, 8.14122260e-02f, 4.24343534e-02f, 2.42961757e-02f, 6.80612847e-02f,
  -4.00234200e-03f, 2.36082777e-01f, -8.25332329e-02f, 2.63864279e-01f, -1.13144272e-03f, -3.35619189e-02f, 6.42381385e-02f, -1.35650679e-01f, 1.35514170e-01f, 9.12169293e-02f,
  4.04335916e-01f, 2.47398928e-01f, -4.79052179e-02f, -8.61089826e-02f, -4.39204350e-02f, 2.66870800e-02f, -3.18111889e-02f, 2.20457483e-02f, -7.22429156e-02f, 3.35824043e-01f,
  -1.65877491e-01f, 5.49538247e-02f, 1.06829606e-01f, -8.84360448e-03f, 7.06014782e-02f, 7.87317455e-02f, -4.84708883e-02f, -3.66116292e-03f, -1.05421662e-01f, 6.31504832e-03f,
  -3.98422852e-02f, -9.76865217e-02f, 7.67535390e-03f, 6.21420816e-02f, -7.86250755e-02f, 5.73568754e-02f, 9.54502970e-02f, -6.38636723e-02f, -5.67610599e-02f, -8.48938301e-02f,
  4.92234454e-02f, -1.01556450e-01f, 5.31894974e-02f, 4.98152412e-02f, -1.07252546e-01f, -6.95771873e-02f, 6.55735806e-02f, 4.39677387e-02f, -6.86837360e-02f, -1.15308233e-01f,
  -7.39062531e-03f, 4.06988636e-02f, -1.10454038e-01f, -1.39473993e-02f, 6.68721944e-02f, 1.00668080e-01f, 2.79087052e-02f, -9.27451178e-02f, 2.60670483e-02f, 5.00890054e-02f,
  -7.79803097e-02f, 6.22421969e-03f, -2.24968810e-02f, -4.38480936e-02f, 6.63846508e-02f, 1.09433858e-02f, -6.29308298e-02f, 1.62234232e-02f, 3.36378552e-02f, -2.10494865e-02f,
  -9.72046703e-02f, -1.22149393e-01f, 2.64533283e-03f, 5.20115718e-02f, 9.15550813e-02f, -6.46660626e-02f, 1.00159496e-02f, -6.03518412e-02f, -3.23967747e-02f, 7.86645263e-02f,
  -7.97095373e-02f, 7.19846189e-02f, 7.55806938e-02f, 3.96989994e-02f, -3.88623290e-02f, -3.33264121e-03f, 9.51836407e-02f, 1.51416482e-02f, 1.24746427e-01f, 1.43943042e-01f,
  1.08342376e-02f, 9.43909511e-02f, 5.28987348e-02f, 3.30091119e-02f, 4.60950211e-02f, 2.00443327e-01f, 1.73713371e-01f, -4.76296246e-02f, -1.46134421e-01f, 1.05450405e-02f,
  -7.46354982e-02f, 4.57725637e-02f, -6.85251430e-02f, -1.16850518e-01f, -1.42669594e-02f, 5.54502122e-02f, 1.64385065e-01f, -1.82037503e-01f, -5.91895320e-02f, -2.29302626e-02f,
  1.60170630e-01f, 1.34075582e-01f, -6.00663014e-02f, -4.04689601e-03f, -1.01654530e-01f, 1.43628968e-02f, -3.95895801e-02f, 1.21788621e-01f, -2.55411267e-02f, 1.16690062e-02f,
  -6.97892606e-02f, -5.04972711e-02f, -1.03334807e-01f, 6.44894466e-02f, 1.09447211e-01f, -8.74318706e-04f, 2.23753322e-02f, 1.31509200e-01f, -1.05779041e-02f, -4.46602963e-02f,
  -1.22494064e-02f, -2.61806939e-02f, -1.81958545e-02f, 8.97280946e-02f, -3.20444331e-02f, 1.35368317e-01f, 1.72736451e-01f, 9.70278904e-02f, 9.86720622e-02f, -1.26458034e-01f,
  2.22148359e-01f, 5.91386994e-03f, -2.27835495e-02f, -1.27668023e-01f, -4.84931888e-03f, 6.37654811e-02f, 1.22571953e-01f, 2.08877064e-02f, 2.13602647e-01f, 1.05160572e-01f,
  1.84557423e-01f, -9.28712450e-03f, 2.15325341e-01f, 1.28957838e-01f, 1.10204205e-01f, 6.34221286e-02f, 1.22740872e-01f, 2.74291448e-02f, 2.32605800e-01f, 1.12593129e-01f,
  1.56033024e-01f, 1.97047874e-01f, -1.90463178e-02f, -7.39715695e-02f, 1.87002704e-01f, 1.04880929e-01f, 3.94931324e-02f, -2.93702353e-02f, 1.02679133e-01f, 1.04859732e-01f,
  7.87798613e-02f, -2.01555863e-01f, -1.14783935e-01f, 6.11288957e-02f, 4.07739058e-02f, 4.61891517e-02f, 1.35443166e-01f, 1.89604029e-01f, -3.63707133e-02f, 9.78081767e-03f,
  -5.51795959e-02f, -8.43758434e-02f, -1.62968919e-01f, 1.37205794e-01f, -1.18079269e-02f, -3.26172858e-02f, 1.42216846e-01f, 1.52660683e-02f, 1.43305436e-01f, 9.95109752e-02f,
  -2.60228459e-02f, 3.91991064e-03f, 2.53145769e-02f, -1.80351004e-01f, -2.57827304e-02f, -1.31818682e-01f, 1.22278761e-02f, 1.13650545e-01f, -3.94774117e-02f, 5.46191297e-02f,
  -8.19917694e-02f, -3.46904509e-02f, 2.54035685e-02f, -4.94920090e-02f, 1.29272968e-01f, 2.06330061e-01f, 8.41157287e-02f, 6.85168058e-02f, 2.74959028e-01f, 2.37572156e-02f,
  1.17303237e-01f, 4.68042567e-02f, 1.05213001e-01f, -8.01970512e-02f, 2.27143336e-02f, 8.82116184e-02f, -1.96985714e-02f, -9.89177614e-04f, -8.75067636e-02f, 1.74644310e-02f,
  7.87385404e-02f, -1.10337898e-01f, -1.51307434e-01f, 1.18934251e-01f, 9.82511640e-02f, 7.28065819e-02f, -1.06265947e-01f, -9.92547199e-02f, -1.00488670e-01f, -4.48558619e-03f,
  -1.46676213e-01f, 6.86761737e-02f, 5.73980659e-02f, 4.71365713e-02f, -1.63778886e-01f, 2.79248394e-02f, 3.40166725e-02f, -8.69007334e-02f, -1.33063599e-01f, 2.22678661e-01f,
  4.53977138e-02f, 8.64320174e-02f, -5.02527924e-03f, -8.56146961e-03f, 5.46579026e-02f, 1.44440591e-01f, 2.21388966e-01f, 2.73578856e-02f, 7.40914345e-02f, -6.09458238e-02f,
  1.16842613e-01f, 1.63856477e-01f, 2.46848948e-02f, -1.63675010e-01f, 5.86256124e-02f, 1.20334379e-01f, -3.11015802e-03f, 8.01077262e-02f, 3.49534154e-02f, 6.64595515e-02f,
  -3.74038145e-02f, 7.26898164e-02f, 9.47348475e-02f, 1.13130972e-01f, 1.82912350e-01f, -6.09694719e-02f, 1.72612041e-01f, 1.29547611e-01f, 4.78007235e-02f, -1.07612042e-02f,
  2.64526047e-02f, -4.49042730e-02f, -3.05116996e-02f, 1.28054675e-02f, -4.19063400e-03f, -1.45421065e-02f, 8.51615518e-02f, -9.81244221e-02f, 1.14247091e-01f, 1.22786589e-01f,
  1.93455815e-01f, -2.95992829e-02f, 1.50669843e-01f, 1.76813528e-01f, -3.68620381e-02f, 1.42304704e-01f, 3.85837927e-02f, 1.67705357e-01f, 8.66760239e-02f, -2.18792893e-02f,
  1.71538457e-01f, -4.69278805e-02f, 9.55135524e-02f, 6.27222434e-02f, 1.68062091e-01f, 1.00339435e-01f, 3.89557667e-02f, -8.27883258e-02f, -2.31977418e-01f, 5.15023544e-02f,
  -8.94465819e-02f, -1.12181315e-02f, -2.62768031e-03f, 1.08304918e-01f, 8.97817463e-02f, -1.26214966e-01f, 7.75880143e-02f, -1.44069046e-01f, 2.62716949e-01f, 1.55191524e-02f,
  1.23759151e-01f, -1.37737408e-01f, 1.36786476e-01f, 2.17354193e-01f, -8.62384886e-02f, -9.75028891e-03f, 4.86993976e-03f, -2.95617692e-02f, 1.96174800e-01f, -8.39282647e-02f,
  8.20802525e-03f, -2.06403267e-02f, -1.14193177e-02f, 2.10071921e-01f, -4.06415835e-02f, 7.07993507e-02f, 5.43422485e-03f, 5.69633208e-02f, -1.60470009e-01f, 1.62175950e-02f,
  2.04581022e-02f, -9.36521217e-02f, 1.33477747e-01f, 1.00278892e-01f, -9.58684161e-02f, -3.24200988e-02f, 3.00733838e-02f, 9.92395505e-02f, 8.43053013e-02f, 3.07390124e-01f,
  -1.73686698e-01f, 4.89213988e-02f, 1.02793342e-02f, 1.74178660e-01f, 2.69369155e-01f, 2.21226290e-01f, 1.53698519e-01f, 2.22673461e-01f, 2.97542006e-01f, 6.06083609e-02f,
  1.79505795e-01f, 2.11139709e-01f, 1.24992549e-01f, 1.06735773e-01f, -2.34653763e-02f, -6.11760430e-02f, -3.11731566e-02f, -2.99962536e-02f, -1.95614770e-01f, 1.97071254e-01f,
  5.37920147e-02f, -1.70465317e-02f, 2.25739956e-01f, -2.06080079e-01f, -1.06842779e-01f, -2.20917210e-01f, 1.18728667e-01f, -1.21663712e-01f, 1.55460969e-01f, 2.51639783e-01f,
  1.82059139e-01f, 4.63289693e-02f, 6.16699904e-02f, 2.00062077e-02f, -6.59672469e-02f, 1.64548114e-01f, 1.21842563e-01f, -4.79177274e-02f, 1.94532182e-02f, -1.27829507e-01f,
  1.35058746e-01f, -2.45350599e-02f, -4.52085212e-02f, 1.95690319e-01f, 2.67403692e-01f, -4.10469621e-03f, -1.06457353e-01f, -8.42562818e-04f, -5.83489351e-02f, -9.21515077e-02f,
  8.81720781e-02f, -7.88493231e-02f, 5.40391207e-02f, -7.65146092e-02f, -1.35656362e-02f, 1.04923733e-02f, -5.80844507e-02f, 8.63478929e-02f, 8.60998109e-02f, -6.07863851e-02f,
  -1.14531815e-01f, -8.30839425e-02f, 3.60728540e-02f, -2.96961386e-02f, 2.81390157e-02f, -5.75017519e-02f, 1.09828368e-01f, 1.36564523e-01f, -1.82243753e-02f, 5.20283803e-02f,
  -7.39910826e-02f, 4.82900664e-02f, -8.69572908e-02f, 1.07997451e-02f, 1.30871013e-01f, -4.67610769e-02f, 8.38371515e-02f, -2.82516684e-02f, 2.05424465e-02f, -6.05906919e-02f,
  -5.49237728e-02f, -3.05796508e-02f, -1.82032995e-02f, -8.40331614e-02f, 1.04627110e-01f, -6.00424595e-02f, -8.79590437e-02f, 5.35592157e-03f, 6.29553273e-02f, 3.30128404e-03f,
  8.98543224e-02f, 1.45155609e-01f, 4.71199639e-02f, -1.18654422e-01f, -1.66618586e-01f, 6.95409179e-02f, 1.01460241e-01f, 9.87346694e-02f, -4.05634604e-02f, 3.47641148e-02f,
  -1.49844348e-01f, 3.12344953e-02f, -1.18234858e-01f, 1.41099626e-02f, 5.25722355e-02f, -4.17195670e-02f, -9.38604549e-02f, 5.79579063e-02f, -5.38887829e-02f, -5.91717437e-02f,
  1.10758832e-02f, -6.38057590e-02f, 1.32755369e-01f, 1.20541930e-01f, 4.48253602e-02f, 7.68828019e-02f, 1.51239157e-01f, 1.92310140e-02f, 1.19298682e-01f, -6.06994554e-02f,
  2.38559231e-01f, 2.00592414e-01f, 3.36298235e-02f, -9.00901183e-02f, 2.39612103e-01f, -9.48629007e-02f, -4.30850908e-02f, -1.05292611e-01f, 2.24786982e-01f, 1.04726404e-01f,
  1.65692896e-01f, 5.75598218e-02f, -5.41632855e-03f, 1.37556288e-02f, 1.23021603e-02f, 4.56482805e-02f, -2.46272832e-02f, 1.75901666e-01f, 1.42526418e-01f, 5.04744463e-02f,
  3.16858068e-02f, 1.78531602e-01f, -9.31537971e-02f, 1.83141530e-02f, -1.45442128e-01f, -2.22782522e-01f, -2.68593818e-01f, 2.12038249e-01f, -1.09547250e-01f, -4.02312949e-02f,
  1.02358274e-01f, 6.62264228e-03f, -9.28114876e-02f, -1.72102433e-02f, -6.39895871e-02f, -3.25328596e-02f, -3.76114361e-02f, 1.21678889e-01f, 2.42625117e-01f, 4.04215977e-02f,
  -7.29885623e-02f, 2.45590746e-01f, 1.01190038e-01f, 1.74751095e-02f, 1.56688631e-01f, -7.32736290e-02f, 1.49490163e-01f, -4.22284193e-02f, 2.82767355e-01f, 1.72490701e-01f,
  2.48481873e-02f, 1.16763532e-01f, 1.56572908e-01f, 1.96718141e-01f, -1.59205005e-01f, 6.65935175e-03f, 1.74406976e-01f, -9.96356830e-02f, 4.38304506e-02f, 7.80938268e-02f,
  -7.62758777e-02f, 1.09779775e-01f, 1.99145243e-01f, 6.91399947e-02f, -1.37436286e-01f, -8.35546181e-02f, 2.23267242e-01f, -2.13615391e-02f, -1.73188999e-01f, -2.18953565e-02f,
  -4.47031995e-03f, 4.95252647e-02f, 1.40479326e-01f, 6.51065707e-02f, 6.56463392e-03f, -1.10728599e-01f, 7.55422413e-02f, 7.63429329e-02f, -1.05323210e-01f, -5.79218455e-02f,
  -1.17534794e-01f, -1.91541705e-02f, 7.88658634e-02f, -1.78261437e-02f, -5.45415431e-02f, -1.98824294e-02f, 9.82999150e-03f, -8.75333920e-02f, -1.07675297e-02f, 9.81184542e-02f,
  1.03822961e-01f, -5.49228452e-02f, -4.47975099e-02f, 5.42447120e-02f, -8.36655647e-02f, -4.09567058e-02f, 1.14334300e-01f, 5.93875870e-02f, -5.85326478e-02f, 2.01009330e-03f,
  7.74466917e-02f, 1.13559529e-01f, -5.10772467e-02f, -4.99384999e-02f, -1.15407914e-01f, -7.61331916e-02f, -1.64925270e-02f, 1.19765967e-01f, -1.07833281e-01f, 7.54578859e-02f,
  -3.29554714e-02f, 1.55184383e-03f, -6.42144755e-02f, 4.05330285e-02f, 1.11624680e-01f, 1.90805700e-02f, 1.87717157e-03f, 1.19448878e-01f, -4.10346203e-02f, -6.13910742e-02f,
  -6.69658780e-02f, -1.99693758e-02f, 5.91745935e-02f, 5.93975224e-02f, 8.45600143e-02f, 9.17446613e-02f, -4.35699262e-02f, 5.83479255e-02f, -3.97998765e-02f, 2.85714269e-02f,
  -7.92362019e-02f, -2.67043728e-02f, 4.15156446e-02f, -9.39084142e-02f, 4.25071493e-02f, -1.11182354e-01f, 1.97482686e-02f, -6.08828217e-02f, -1.02096409e-01f, -2.96496283e-02f,
  1.31687894e-01f, -9.08424482e-02f, 9.03698802e-03f, 8.38118047e-02f, -6.46746811e-03f, 2.75932290e-02f, 1.42129615e-01f, 8.03700015e-02f, -7.92095661e-02f, 1.85300577e-02f,
  -1.00753605e-01f, 6.49032667e-02f, 1.23869658e-01f, -6.05336390e-02f, 5.72024211e-02f, -1.64063483e-01f, 2.04538718e-01f, -2.58716457e-02f, -7.43408874e-02f, -6.15571402e-02f,
  3.07204425e-02f, -8.83735716e-02f, 7.60228559e-02f, 1.76704615e-01f, 6.17898516e-02f, -6.08139671e-02f, -1.27136648e-01f, 1.62650701e-02f, 1.71075955e-01f, 6.67311251e-02f,
  1.72461763e-01f, -5.46144173e-02f, 3.99357863e-02f, -5.42451143e-02f, -2.16375105e-02f, 8.28672349e-02f, -1.98958516e-02f, 4.58645299e-02f, -1.26141518e-01f, 1.18809566e-01f,
  4.10099588e-02f, -1.09110177e-01f, 9.75681618e-02f, 1.18060768e-01f, -7.50218928e-02f, -5.53802177e-02f, 6.23071082e-02f, 3.94374095e-02f, 1.77284852e-01f, 7.37662911e-02f,
  1.82957798e-01f, -1.19884163e-01f, 2.25628495e-01f, -1.90040991e-02f, -8.25219695e-03f, -5.30661121e-02f, 2.38122910e-01f, 7.09125772e-02f, -4.95058671e-02f, 1.73328668e-01f,
  1.31931037e-01f, -1.09059066e-01f, -2.96099409e-02f, -6.02861494e-02f, 2.86750421e-02f, -3.38702723e-02f, 8.68814066e-02f, 6.02381974e-02f, 1.36626214e-01f, -9.26809385e-02f,
  -3.75403985e-02f, -1.21879699e-02f, 7.01855645e-02f, 9.16532576e-02f, 2.52729678e-03f, 2.73244269e-02f, 1.07115760e-01f, -9.73450840e-02f, -2.30399951e-01f, 7.08604679e-02f,
  -3.11053097e-02f, 6.35733306e-02f, -1.45199046e-01f, -7.93961808e-02f, -1.43083725e-02f, 2.37030387e-02f, -1.69097662e-01f, 2.56536901e-01f, 1.83889195e-01f, 1.02639861e-01f,
  5.53649366e-02f, -1.56574428e-01f, 1.93298146e-01f, 2.02923504e-04f, 2.68857867e-01f, 1.44459419e-02f, 2.05565467e-01f, -7.58286193e-02f, 1.29798539e-02f, -9.68262330e-02f,
  2.22125147e-02f, 6.06852397e-02f, -2.31724996e-02f, 1.44047588e-01f, 6.91113528e-03f, 1.82979062e-01f, -1.49570897e-01f, 9.57089588e-02f, -3.79497260e-02f, 3.12609714e-03f,
  1.13237336e-01f, -3.99607755e-02f, 9.39229280e-02f, 1.08773716e-01f, 2.71050960e-01f, 2.14118049e-01f, 6.35546744e-02f, -7.99986348e-02f, 1.42036691e-01f, 1.52414009e-01f,
  -8.88761040e-03f, -4.28153621e-03f, -6.72950298e-02f, 3.61420423e-01f, -7.98527673e-02f, 5.13793677e-02f, 9.41070616e-02f, -2.34375112e-02f, -1.36184707e-01f, 1.38022527e-01f,
  1.17933929e-01f, 1.25659481e-02f, 9.27314609e-02f, -5.62859885e-03f, 1.04175806e-01f, 1.29629418e-01f, -3.44290324e-02f, 3.69085334e-02f, 4.06957194e-02f, 3.60180214e-02f,
  -2.39747390e-01f, -1.82712868e-01f, 2.77506262e-01f, -1.41415760e-01f, -1.50073275e-01f, 6.20299280e-02f, -4.25075367e-02f, 6.67193606e-02f, 1.20726772e-01f, -1.41463235e-01f,
  1.13445371e-01f, -9.22103822e-02f, -6.27163798e-02f, -6.57286122e-02f, 2.05273535e-02f, 7.78320953e-02f, -4.42717574e-04f, 1.04866326e-01f, -2.00614054e-02f, 9.91980061e-02f,
  9.59451273e-02f, -6.87752441e-02f, -1.44070119e-01f, -3.12040541e-02f, -1.29802227e-01f, 9.36505198e-02f, -8.47680792e-02f, -1.24481305e-01f, -1.25727788e-01f, 2.34979521e-02f,
  9.06318426e-02f, 1.12674244e-01f, -9.61747468e-02f, 7.63111487e-02f, -4.08078432e-02f, 1.32828474e-01f, 1.21823311e-01f, 1.67058498e-01f, 6.87665045e-02f, 5.85266165e-02f,
  -9.23303962e-02f, 9.39460024e-02f, -1.53927356e-01f, 1.49807811e-01f, -3.85162570e-02f, 1.22873925e-01f, 6.38664588e-02f, 6.80086575e-03f, 1.58018455e-01f, 9.16354544e-03f,
  -9.25717726e-02f, -3.27210650e-02f, -9.63810012e-02f, -7.34283924e-02f, 7.88496211e-02f, -1.20770559e-01f, -1.40687572e-02f, 5.22903465e-02f, -9.73794386e-02f, -9.73854288e-02f,
  9.77830365e-02f, -3.78769934e-02f, -5.23144677e-02f, -3.60703431e-02f, 1.07653759e-01f, -6.82631433e-02f, -9.56448466e-02f, -2.66612461e-03f, -3.17580327e-02f, 1.15792222e-01f,
  -3.31189185e-02f, 1.36307515e-02f, 7.18259737e-02f, 1.32654220e-01f, -2.56988499e-02f, 2.62166653e-02f, 1.10918261e-01f, 9.75664798e-03f, -5.89474402e-02f, 1.05866805e-01f,
  -1.47182038e-02f, 1.08637266e-01f, -9.30576548e-02f, -1.07402783e-02f, 1.20357633e-01f, -5.48334718e-02f, -1.16604036e-02f, 6.04471713e-02f, -3.35408635e-02f, 1.22404695e-01f,
  -9.83045176e-02f, 7.71104693e-02f, -1.81126334e-02f, -2.43933219e-02f, 1.96517892e-02f, 9.22480747e-02f, 5.60627282e-02f, 2.13287212e-02f, 9.69574377e-02f, -8.73447210e-02f,
  2.56958939e-02f, 1.23888794e-02f, 5.68924565e-03f, -8.58250484e-02f, 6.54130057e-02f, -7.87966251e-02f, -5.22816777e-02f, 1.63808092e-02f, -2.12963037e-02f, 1.31922048e-02f,
  1.04925543e-01f, 9.19757932e-02f, 8.68501887e-03f, 4.21469994e-02f, -2.62406338e-02f, -1.12461388e-01f, -1.49454847e-02f, -7.67490640e-02f, 1.06905453e-01f, 7.07256198e-02f,
  -1.30090090e-02f, -3.55408750e-02f, 1.68188512e-02f, 3.77260447e-02f, 3.81228700e-02f, 1.61353499e-02f, -1.08463742e-01f, -6.15260564e-02f, 2.30612960e-02f, 7.91325569e-02f,
  -5.74420542e-02f, -3.62407379e-02f, 1.73161980e-02f, 7.11065624e-03f, -3.78908664e-02f, 7.85448626e-02f, -2.28086077e-02f, 5.91289550e-02f, 6.67495877e-02f, -6.24518259e-04f,
  4.60996442e-02f, -3.52707878e-02f, 5.77585846e-02f, 7.64135048e-02f, -7.33391717e-02f, 5.41720167e-02f, -5.26179112e-02f, 8.49127099e-02f, 7.06156790e-02f, -1.46765122e-02f,
  -1.43968603e-02f, 5.30012771e-02f, -1.22426748e-01f, 7.57371262e-02f, 3.19431312e-02f, -4.51813973e-02f, -1.03757650e-01f, -1.15199268e-01f, -6.02927953e-02f, 3.67224440e-02f,
  -1.00410491e-01f, 8.71198848e-02f, 5.82664162e-02f, -1.05772562e-01f, -9.52825174e-02f, -6.28334880e-02f, -5.59143946e-02f, 9.83466357e-02f, 9.28754956e-02f, -5.45137040e-02f,
  2.86296438e-02f, 1.23101719e-01f, 1.23322353e-01f, 8.33331421e-02f, -1.06761172e-01f, -8.24990869e-02f, -1.16608605e-01f, 3.95028293e-02f, -2.81830523e-02f, 1.32980749e-01f,
  -4.88109887e-02f, 1.08174279e-01f, -3.64210270e-02f, 8.84474665e-02f, -6.78510172e-03f, 1.83619455e-01f, -2.58389544e-02f, 1.43137679e-01f, 1.17113069e-01f, 4.54703756e-02f,
  7.85963982e-02f, 4.12297174e-02f, -8.47536027e-02f, 1.54401273e-01f, 5.63349687e-02f, -1.56189412e-01f, 8.40628669e-02f, 8.88711065e-02f, -2.92338505e-02f, 1.25542253e-01f,
  -6.13076501e-02f, 8.00019503e-02f, 2.35204790e-02f, 7.97196776e-02f, -4.35298402e-03f, -6.18149564e-02f, -1.15493290e-01f, -1.23285512e-02f, 3.40834842e-03f, -1.85328592e-02f,
  -1.24571025e-02f, 1.08297430e-01f, -1.60474613e-01f, 8.91571715e-02f, 3.87310609e-03f, 8.99904370e-02f, 2.59917136e-02f, 1.25622516e-02f, -1.46227822e-01f, 5.01315761e-03f,
  6.71269521e-02f, -1.04172952e-01f, 2.71188617e-01f, -5.56824803e-02f, 1.61376804e-01f, 1.10503927e-01f, -5.53536154e-02f, -6.30840510e-02f, 1.70621634e-01f, -1.17308050e-02f,
  9.78298038e-02f, -6.11001477e-02f, 2.12159067e-01f, 1.86594710e-01f, -2.71829702e-02f, -1.76105127e-02f, 1.90511301e-01f, 1.06513955e-01f, -6.62814826e-02f, -5.41648939e-02f,
  2.03705609e-01f, -6.29426241e-02f, 1.04994765e-02f, 1.33609295e-01f, 8.25455263e-02f, 1.67901322e-01f, -1.92394704e-02f, 7.12648556e-02f, 8.37501436e-02f, -2.05756277e-02f,
  9.51011330e-02f, 1.22848511e-01f, 1.85518295e-01f, 7.95197561e-02f, -5.71127310e-02f, -8.78448039e-02f, -3.74549394e-03f, 1.39522120e-01f, 7.62985870e-02f, -4.77240235e-02f,
  4.19168994e-02f, 1.24254778e-01f, 2.14388482e-02f, -1.86097696e-01f, -9.74592417e-02f, -1.09069340e-01f, 1.38546526e-01f, -7.64240921e-02f, 1.51632102e-02f, 1.41107291e-01f,
  -4.06015590e-02f, -1.27685443e-01f, 1.21880144e-01f, 2.81680562e-02f, 1.05854996e-01f, 9.51749552e-03f, -2.45131049e-02f, 9.89249647e-02f, 5.96899353e-02f, -4.02397886e-02f,
  -3.94036202e-03f, 2.58459579e-02f, 7.40196407e-02f, 1.20964199e-01f, 8.35121572e-02f, -1.32541195e-01f, 3.27334739e-02f, -2.57839598e-02f, -5.05553698e-03f, 1.96162071e-02f,
  6.83438852e-02f, 3.01873386e-02f, -6.15224056e-02f, 5.26565984e-02f, -5.99691237e-04f, -1.09134160e-01f, 2.09693000e-01f, 1.73844665e-01f, 9.12726671e-03f, 7.13168606e-02f,
  1.81626022e-01f, 3.33609362e-03f, 1.45740271e-01f, 1.85229242e-01f, -8.45253989e-02f, -9.99101475e-02f, -2.32288633e-02f, 7.28869587e-02f, -2.93933749e-02f, -5.42761665e-03f,
  -2.62623150e-02f, -7.91878030e-02f, -1.18399188e-01f, -8.50801468e-02f, -8.50186273e-02f, 4.36469018e-02f, 7.52917677e-02f, -6.17223978e-02f, 3.41192856e-02f, 9.62589961e-03f,
  -5.79149425e-02f, -5.01095578e-02f, 6.77328706e-02f, 3.90196033e-02f, -9.97327268e-03f, -2.54441239e-02f, 5.61081320e-02f, -1.60958711e-02f, 2.14284696e-02f, 6.05661143e-03f,
  -9.39514339e-02f, 5.24568604e-03f, -2.51159747e-03f, 6.45019952e-03f, 2.05244701e-02f, -9.19627585e-03f, 1.04138404e-01f, 1.03192739e-01f, -5.42577505e-02f, -8.69023353e-02f,
  -1.24189533e-01f, -4.59106453e-03f, 3.69711481e-02f, 1.05515145e-01f, 6.16491102e-02f, 1.38772698e-02f, -9.36607122e-02f, -1.25413924e-01f, 6.43726587e-02f, 1.12178251e-01f,
  -1.21992730e-01f, 7.93638304e-02f, -5.72728440e-02f, -6.69972301e-02f, -4.71502021e-02f, 8.56330097e-02f, 4.99382317e-02f, 9.54802036e-02f, -3.92928906e-02f, -3.44782546e-02f,
  3.81200481e-03f, 8.64274427e-02f, -1.33068124e-02f, -8.10101554e-02f, -1.00298509e-01f, -1.03416629e-01f, 3.71836238e-02f, -3.01895924e-02f, -5.24056740e-02f, -8.43532905e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.12678088e-01f, -3.86153497e-02f, 5.28551303e-02f, -4.52947877e-02f, -4.79781926e-02f, -1.27342455e-02f, 1.29017577e-01f, -3.55952494e-02f, 7.00292960e-02f, 1.29587278e-01f,
  1.88299194e-01f, 7.03691244e-02f, -5.81643283e-02f, 7.10406601e-02f, 8.55334103e-02f, -2.50738952e-02f, 1.68796480e-01f, 6.76596612e-02f, 4.17264961e-02f, 6.66694492e-02f,
  8.92815366e-02f, 1.59106955e-01f, -6.91530555e-02f, -7.40393400e-02f, 7.59194121e-02f, 6.75459430e-02f, -1.71894282e-02f, 9.68691185e-02f, 1.77222699e-01f, 9.59351286e-02f,
  1.98977012e-02f, 3.63502353e-02f, 5.09188399e-02f, 1.34076893e-01f, 1.23561859e-01f, 6.67781010e-02f, -6.65154681e-02f, 5.50825521e-02f, 1.22628532e-01f, 8.87736604e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.44048825e-01f, -2.60887574e-02f, -1.68621212e-01f, -6.21722080e-02f, -2.60554184e-03f, -1.93091426e-02f, 1.40006691e-01f, 1.19519942e-01f, -1.13590002e-01f, -1.30672619e-01f,
  -2.86067016e-02f, -9.24274921e-02f, -7.71284923e-02f, 2.52485663e-01f, -1.44888982e-01f, 1.52577057e-01f, -1.76631019e-01f, -2.56792516e-01f, 4.94088046e-02f, -2.99657173e-02f,
  2.76874322e-02f, -2.22950727e-01f, 9.78065655e-02f, 4.79271784e-02f, -7.17409933e-03f, 1.02258511e-01f, 3.17595946e-03f, 4.30435985e-02f, 6.83928058e-02f, -7.90476725e-02f,
  -1.22290678e-01f, -1.04501121e-01f, -1.02399990e-01f, -3.65877971e-02f, -4.38801870e-02f, -6.90943375e-02f, -1.55234471e-01f, 1.63251553e-02f, -1.36610821e-01f, 6.04488999e-02f,
  -9.40834880e-02f, -3.42716314e-02f, 3.01143224e-03f, 1.40103281e-01f, -2.15534553e-01f, 6.96922243e-02f, 3.77897248e-02f, 5.27705997e-02f, -8.89210105e-02f, -7.28406459e-02f,
  -8.98448229e-02f, -1.39133900e-01f, 1.06687896e-01f, -2.67675072e-02f, 9.22098011e-02f, 1.12024128e-01f, -1.83898911e-01f, 3.16944942e-02f, -2.06649285e-02f, -1.19055994e-01f,
  -7.96683505e-02f, 3.36987549e-03f, -6.63545132e-02f, 7.92328045e-02f, -6.61809370e-02f, 3.50249000e-02f, -7.49403685e-02f, -6.32769912e-02f, 1.48104196e-02f, -1.06179386e-01f,
  -1.19342640e-01f, 4.32857871e-02f, -2.53872648e-02f, -5.01543321e-02f, -2.57121641e-02f, -8.83236676e-02f, 9.23298374e-02f, -1.98534235e-01f, -1.02544367e-01f, -8.88963267e-02f,
  1.96233273e-01f, 8.27756524e-02f, -8.90227035e-03f, -1.40108421e-01f, -1.26908228e-01f, -3.59339640e-02f, -1.98977783e-01f, 1.38052374e-01f, -1.00543611e-02f, -1.27624840e-01f,
  -5.41015565e-02f, -1.33944690e-01f, 6.39537275e-02f, 1.52125269e-01f, 1.56853467e-01f, 8.37967247e-02f, -8.80697668e-02f, -1.08020134e-01f, -7.90095553e-02f, -1.31213861e-02f,
  1.30392209e-01f, 1.30831882e-01f, 8.97466242e-02f, 8.54193941e-02f, -8.72148126e-02f, -2.26132467e-01f, 6.73505617e-03f, -9.06430110e-02f, 1.11136518e-01f, 7.96411037e-02f,
  1.01705842e-01f, 9.37623829e-02f, -1.93058804e-01f, 5.43365218e-02f, -3.00044958e-02f, 1.09685652e-01f, -1.93339005e-01f, -1.50284953e-02f, -9.51835420e-03f, 4.71895561e-02f,
  7.75444061e-02f, 1.60754293e-01f, 2.55261548e-02f, -8.66644159e-02f, -6.60625696e-02f, 5.42574488e-02f, 2.13060016e-03f, 8.65095928e-02f, 1.74218938e-02f, 1.87372729e-01f,
  1.62557781e-01f, -4.78128000e-04f, 9.88722034e-03f, 4.89922650e-02f, -9.58714113e-02f, 9.21654105e-02f, -4.70987186e-02f, -3.14950920e-03f, 1.09310493e-01f, -2.81259771e-02f,
  -1.44321784e-01f, -1.50967106e-01f, 1.20226003e-01f, -2.48383209e-01f, 8.53377860e-03f, 1.15193159e-03f, -1.40839487e-01f, 1.52150244e-01f, -1.76576748e-01f, 8.12410265e-02f,
  -1.49479032e-01f, -1.74693301e-01f, 4.04307507e-02f, -1.06175635e-02f, 1.94472428e-02f, -1.07969135e-01f, 1.01117432e-01f, 5.60192391e-03f, -9.25512612e-03f, -9.86793563e-02f,
  4.13371883e-02f, 5.51920161e-02f, 4.83006537e-02f, 2.73778047e-02f, 9.37129930e-02f, 1.08190119e-01f, 3.98924723e-02f, -5.92481680e-02f, -1.86309606e-01f, 1.88874416e-02f,
  -4.57589794e-03f, -1.08989000e-01f, 1.50103778e-01f, 1.59340501e-02f, -2.09699705e-01f, 5.25188446e-02f, 9.33882445e-02f, 1.22666515e-01f, -6.74119815e-02f, 1.85157180e-01f,
  1.64668292e-01f, -1.05252504e-01f, -8.05863515e-02f, -1.22845970e-01f, 5.37192784e-02f, -1.45865858e-01f, 9.47538614e-02f, -4.25598472e-02f, -2.66380608e-02f, -1.06003903e-01f,
  5.76345660e-02f, -4.10996713e-02f, -1.14759110e-01f, -7.22114816e-02f, -6.94771484e-02f, 7.00116307e-02f, -1.26526847e-01f, -4.31208918e-03f, -5.36166839e-02f, -1.56422704e-01f,
  5.53837838e-03f, 5.33078425e-03f, 2.52767205e-02f, -1.60317138e-01f, -9.78763327e-02f, 5.47261983e-02f, 8.90391171e-02f, -1.54173197e-02f, -4.78056818e-02f, -6.23718128e-02f,
  4.26753648e-02f, 1.03095146e-02f, -2.29749948e-01f, -5.20726293e-02f, -1.24671243e-01f, 1.64710924e-01f, 7.81833306e-02f, 5.15563563e-02f, 1.79363806e-02f, -1.72178537e-01f,
  7.09429756e-02f, 3.97087969e-02f, 1.50661886e-01f, -1.02672420e-01f, 7.40162143e-03f, -1.46668822e-01f, 8.20485204e-02f, -5.01819886e-02f, 6.26727343e-02f, -6.91543221e-02f,
  -3.49196643e-02f, -5.18660359e-02f, -2.84460247e-01f, -1.26299337e-01f, 9.42408815e-02f, 2.81569622e-02f, 1.40902802e-01f, -2.81439535e-02f, 2.04989716e-01f, -9.08688307e-02f,
  -1.20826729e-01f, -1.73330575e-01f, -5.76449372e-02f, 1.75126091e-01f, -1.34156749e-01f, -1.87385678e-01f, -1.15167618e-01f, 1.17407002e-01f, -1.36599123e-01f, 1.64656475e-01f,
  1.50258616e-01f, -1.14403188e-01f, -1.23856394e-02f, -1.38572410e-01f, 1.04110111e-02f, 3.88747863e-02f, 2.30828542e-02f, 1.75010219e-01f, 6.65194094e-02f, -6.25188053e-02f,
  1.15359485e-01f, 9.57094356e-02f, -1.11261889e-01f, 1.05740428e-01f, 1.27792194e-01f, 1.59367725e-01f, 1.41758129e-01f, -3.49957217e-03f, -1.36318937e-01f, 7.74106523e-03f,
  5.39790839e-02f, -1.86434500e-02f, -9.03644115e-02f, 6.65343925e-03f, -2.05191255e-01f, -4.50431556e-02f, -1.75182998e-01f, 1.44953012e-01f, -7.02978224e-02f, -1.42240360e-01f,
  -1.16411991e-01f, -2.13710917e-03f, 1.02098443e-01f, -2.78445892e-02f, 5.80955930e-02f, 5.44450320e-02f, 7.97472522e-02f, -1.16660573e-01f, -6.46332875e-02f, 1.13037683e-03f,
  3.78132202e-02f, 1.17739595e-01f, 1.47982523e-01f, 1.24764137e-01f, -7.17929825e-02f, 5.53558245e-02f, -1.19188063e-01f, -1.55236095e-01f, 1.26682878e-01f, -1.00800306e-01f,
  2.35369965e-01f, -7.95980096e-02f, -5.89251667e-02f, 8.52392092e-02f, -4.15019915e-02f, -1.12392031e-01f, -7.77278189e-03f, 8.28434229e-02f, 1.44464914e-02f, -6.02062559e-03f,
  -1.79077551e-01f, -3.41262072e-02f, -3.19555844e-03f, -7.12670460e-02f, 1.09688744e-01f, -5.83879277e-02f, -1.20942898e-01f, 2.96083838e-02f, 1.49517015e-01f, 4.15088944e-02f,
  -4.64729741e-02f, 6.60521761e-02f, 2.93158051e-02f, -1.16289869e-01f, 4.58663777e-02f, 4.32816446e-02f, -2.03882620e-01f, -1.20481424e-01f, 1.25984624e-01f, -3.80573049e-02f,
  -1.30532086e-01f, -1.64969027e-01f, 1.34268254e-02f, -2.49114498e-01f, 4.09717523e-02f, -2.71580309e-01f, 2.43749231e-01f, 2.58086711e-01f, -1.15203343e-01f, -3.48581225e-02f,
  -2.14898556e-01f, 1.17669769e-01f, 1.71490069e-02f, 1.40308887e-01f, 4.69832361e-04f, 8.29220563e-02f, -2.46500969e-02f, 8.07709098e-02f, 8.78447965e-02f, 1.34999976e-01f,
  -7.25025386e-02f, 9.49901864e-02f, 6.84629455e-02f, 3.40591744e-02f, 6.86456263e-02f, 2.49687657e-02f, 1.17348395e-02f, 4.63865958e-02f, 6.79117918e-04f, 1.73251349e-02f,
  -1.59035757e-01f, -1.35762289e-01f, 3.24085318e-02f, -7.43034929e-02f, 1.94532098e-03f, -8.84818584e-02f, -6.74396232e-02f, 3.17453630e-02f, 7.58040100e-02f, -6.81834966e-02f,
  2.63938028e-02f, 1.87481835e-01f, -4.57675271e-02f, 3.15216519e-02f, -2.03069195e-01f, -1.04441412e-01f, 2.37666816e-01f, 1.38866052e-01f, -1.28384545e-01f, -4.86137532e-02f,
  5.76615557e-02f, 1.03666103e-02f, 1.15953609e-01f, 1.50942132e-02f, 6.92142844e-02f, 1.06332853e-01f, 5.18963449e-02f, 5.43429591e-02f, 4.79843207e-02f, -2.08817367e-02f,
  6.25698715e-02f, 4.82635610e-02f, 1.29227057e-01f, 1.56841621e-01f, 5.87483123e-02f, 5.35945296e-02f, 8.98435116e-02f, 1.34597853e-01f, 1.67881861e-01f, -4.62209322e-02f,
  7.90478811e-02f, 7.63661042e-02f, 9.43718292e-03f, 1.92819163e-01f, -3.76318395e-02f, -1.18627831e-01f, 4.38808426e-02f, -2.04691499e-01f, -1.17917478e-01f, 2.90312376e-02f,
  -4.64613289e-02f, 1.40835509e-01f, 4.75463867e-02f, -1.53481156e-01f, -1.37434721e-01f, -1.69993475e-01f, -1.40541971e-01f, 8.32116976e-02f, -2.07533706e-02f, -4.14209291e-02f,
  6.39737770e-02f, -2.69837659e-02f, -1.03473291e-01f, -3.64426262e-04f, 1.52959049e-01f, 1.32656544e-01f, -1.41877010e-01f, -6.69312403e-02f, 1.16121203e-01f, 1.28585950e-01f,
  -1.30127981e-01f, 7.14171231e-02f, 1.95984960e-01f, -1.96675453e-02f, 7.88242966e-02f, -2.30136007e-01f, 2.15457812e-01f, 1.17200278e-01f, 1.36343807e-01f, -9.39825699e-02f,
  -4.78769578e-02f, -1.24159008e-01f, 8.51781592e-02f, -1.00330539e-01f, 8.32250416e-02f, 2.39945184e-02f, 6.57839477e-02f, -6.76054955e-02f, 1.67859450e-01f, 8.84668306e-02f,
  4.39895615e-02f, 6.81559294e-02f, 1.21323921e-01f, 1.06248878e-01f, -6.66629151e-03f, 2.16937885e-01f, 1.19892769e-01f, 2.57377159e-02f, 5.22809960e-02f, 1.07645914e-01f,
  -1.08667023e-01f, -1.68088734e-01f, 5.33218272e-02f, -7.71091580e-02f, 1.16714403e-01f, 1.31779462e-01f, -2.28733569e-01f, 1.78370811e-02f, 1.89855441e-01f, 1.18979923e-01f,
  -7.95808136e-02f, -1.68446928e-01f, 2.41757389e-02f, -1.36828020e-01f, -1.73530489e-01f, -1.58471726e-02f, -9.91804004e-02f, 9.15718079e-02f, 2.11727861e-02f, 9.10362005e-02f,
  5.26616760e-02f, -2.10060347e-02f, -3.59611101e-02f, 5.12568019e-02f, 6.96227476e-02f, 4.75752205e-02f, -1.10695079e-01f, -9.48436037e-02f, 2.06444427e-01f, 1.97231069e-01f,
  -1.54828325e-01f, -2.67712418e-02f, -1.16143994e-01f, -1.32688925e-01f, -1.74020022e-01f, 7.01520070e-02f, 8.33247602e-02f, 2.55554974e-01f, -1.39134765e-01f, -2.66798120e-02f,
  2.76250154e-01f, 7.50533268e-02f, 5.22507280e-02f, 9.19071119e-03f, -9.83945206e-02f, -5.97593933e-02f, -1.31645843e-01f, 7.37679228e-02f, -5.42669110e-02f, 1.12838894e-02f,
  1.56447873e-01f, -1.01967424e-04f, -2.49745920e-02f, -1.05413876e-01f, 5.90836704e-02f, 6.12467714e-02f, -3.46565582e-02f, 7.30195269e-02f, 4.57230024e-02f, -6.90908656e-02f,
  6.23883083e-02f, 8.99325758e-02f, 6.36648014e-02f, 8.29694793e-02f, -1.07028790e-01f, -1.57762393e-01f, 1.84282705e-01f, 3.43397148e-02f, -1.10775866e-01f, -4.48134020e-02f,
  -1.28311142e-01f, 8.60040784e-02f, 3.94237898e-02f, 1.45130798e-01f, 1.20813839e-01f, -1.61189511e-01f, 8.95244926e-02f, 1.34055375e-03f, 6.31559491e-02f, -2.19887756e-02f,
  1.79000460e-02f, 2.16963906e-02f, -5.69064021e-02f, 6.09842595e-03f, -2.07016543e-01f, 5.32818101e-02f, 1.42664969e-01f, -5.59242219e-02f, 9.41076428e-02f, -8.59620571e-02f,
  -5.70169762e-02f, 4.07225043e-02f, -6.68878853e-02f, 3.41104791e-02f, 2.71805432e-02f, -2.51956808e-04f, 8.77849311e-02f, 1.42230690e-01f, -1.87050223e-01f, -8.77605826e-02f,
  1.31639615e-01f, 8.86609554e-02f, -2.03927234e-02f, 5.76444417e-02f, -3.38612758e-02f, -6.45781681e-02f, -2.01856807e-01f, 1.83550362e-02f, 1.06981426e-01f, -2.18464121e-01f,
  1.14156611e-01f, -1.02558755e-03f, 1.63895276e-03f, 7.07600862e-02f, 6.23771176e-02f, -9.03025195e-02f, 8.97129998e-02f, 1.68674067e-02f, -3.64362672e-02f, 2.41323393e-02f,
  -5.99045642e-02f, 4.83641811e-02f, 1.14236265e-01f, 2.20472552e-02f, 2.41527613e-02f, 9.06236023e-02f, 7.58566484e-02f, -9.71619636e-02f, 8.10522586e-02f, 1.45616516e-01f,
  -8.64603519e-02f, -1.37775317e-01f, 2.05857903e-01f, -2.70921569e-02f, 3.97732742e-02f, -1.10754475e-01f, -7.66968131e-02f, -1.74179405e-01f, -3.78709212e-02f, 1.73066080e-01f,
  2.64898855e-02f, 6.45778850e-02f, -1.04521744e-01f, -7.98820257e-02f, -1.85204111e-02f, -1.12029247e-01f, 9.90502760e-02f, 9.17805359e-02f, 6.98494837e-02f, 3.29337157e-02f,
  -3.14516425e-02f, -7.31134191e-02f, -6.42698407e-02f, -9.50633585e-02f, 1.12003453e-01f, 7.68565759e-02f, -1.09116688e-01f, 1.46386474e-02f, -1.05071262e-01f, -1.20272130e-01f,
  1.26983643e-01f, 1.06736533e-01f, 1.84019923e-01f, -2.70923059e-02f, 7.75949657e-02f, -1.09865911e-01f, 6.18698783e-02f, 1.42804235e-01f, 1.90596923e-03f, -6.57602772e-02f,
  1.88507102e-02f, -9.53757539e-02f, -8.43982846e-02f, 1.92208201e-01f, 4.62007485e-02f, -9.19400528e-02f, -3.97470640e-03f, -6.46737963e-02f, -1.23581588e-01f, -2.85535809e-02f,
  -9.32211578e-02f, 5.85576482e-02f, -1.49100289e-01f, -6.89021647e-02f, -1.76772922e-01f, 2.93124951e-02f, -8.10402557e-02f, -6.79423138e-02f, -4.52934578e-02f, 6.76252916e-02f,
  -5.55515615e-03f, -1.89439021e-03f, 1.34820119e-01f, -1.56545475e-01f, -2.58681178e-02f, -1.62928298e-01f, 9.16752741e-02f, -7.86895975e-02f, -1.20209634e-01f, 2.48317663e-02f,
  -1.52784526e-01f, -3.52689214e-02f, -1.30315330e-02f, 1.62899777e-01f, -2.98366154e-04f, 3.25322822e-02f, -2.41849363e-01f, -1.79468989e-02f, 1.11219250e-01f, 9.15300399e-02f,
  1.17234513e-01f, -1.05029799e-01f, 1.51395053e-01f, -1.69450372e-01f, -2.01827362e-01f, -1.86151601e-02f, -3.43407854e-03f, -1.39365226e-01f, -9.77246836e-02f, 7.36841932e-02f,
  -7.47871995e-02f, 4.90037724e-02f, -8.66158307e-02f, 6.00174926e-02f, -1.62902057e-01f, -1.32196873e-01f, 2.02917337e-01f, -6.78512752e-02f, 5.12815267e-02f, 5.34492396e-02f,
  5.87026104e-02f, -6.88958466e-02f, -8.21574479e-02f, -1.50239885e-01f, 1.97525546e-02f, -8.21444765e-02f, 5.16573600e-02f, 2.01269656e-01f, -1.10845074e-01f, -9.13715586e-02f,
  1.00511909e-01f, -6.63157776e-02f, 3.58567238e-02f, 4.67404835e-02f, -9.39206406e-03f, -5.51130436e-02f, -6.42370805e-02f, 5.62090091e-02f, 1.14995008e-02f, -8.42898991e-03f,
  -1.74662054e-01f, -1.77239656e-01f, 4.46710363e-02f, -3.92184108e-02f, -1.24828972e-01f, 7.60133788e-02f, 1.25497535e-01f, -2.58750021e-01f, -1.01680785e-01f, -5.98253123e-02f,
  -4.18059118e-02f, 7.93283358e-02f, -8.76089409e-02f, -5.17003089e-02f, -1.08896181e-01f, 8.63345116e-02f, -6.04813136e-02f, -8.28910023e-02f, -8.39124396e-02f, -1.80771396e-01f,
  -1.51719796e-02f, 4.05038707e-02f, 5.23672551e-02f, 1.26240417e-01f, 9.36219767e-02f, 1.87153786e-01f, 3.48559283e-02f, -2.37360485e-02f, 1.65434778e-01f, 3.67309451e-02f,
  5.13078682e-02f, -1.05071828e-01f, 1.10984355e-01f, -5.68481684e-02f, 8.00637379e-02f, -9.68004316e-02f, 8.34003761e-02f, -7.35743577e-03f, 1.30333751e-01f, 3.09540741e-02f,
  5.94112314e-02f, -4.40978184e-02f, -1.15602359e-01f, -2.94628944e-02f, 1.09053999e-01f, 1.85709435e-03f, -2.61093795e-01f, 1.13429129e-01f, -2.56767035e-01f, -1.19279101e-01f,
  3.24629545e-02f, -1.44745484e-01f, -6.04304001e-02f, 1.51143344e-02f, 1.03809223e-01f, 3.77445556e-02f, 1.07384108e-01f, 8.69480595e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.51649341e-01f, 1.14895016e-01f, 6.38075694e-02f, 1.85347423e-01f, 2.21852705e-01f, 2.05651700e-01f, -8.63123164e-02f, 1.37309060e-01f, 1.04546688e-01f, 3.59159112e-02f,
  4.98240814e-03f, 7.85950273e-02f, 9.01882648e-02f, -1.32167801e-01f, 5.09757875e-03f, -1.05458699e-01f, 1.98138226e-02f, 2.47658715e-02f, -2.32266307e-01f, 3.87756974e-02f,
  1.96922019e-01f, 2.95518879e-02f, 7.60931289e-03f, -1.13921195e-01f, 1.20388210e-01f, -1.46417888e-02f, -3.78413536e-02f, -3.01772468e-02f, 3.02812066e-02f, 1.21881321e-01f,
  -1.06500030e-01f, -1.58854648e-02f, 7.02773109e-02f, 1.17353477e-01f, 3.86155061e-02f, -3.24596427e-02f, 4.05680612e-02f, -7.74391517e-02f, -3.41001945e-03f, -8.19333363e-03f,
  1.69518337e-01f, 1.51710317e-01f, 9.36562568e-02f, 3.67991452e-05f, 5.41791171e-02f, 2.88120620e-02f, -1.77482262e-01f, -1.07778065e-01f, 2.57469982e-01f, 1.93991408e-01f,
  6.64955005e-02f, 8.03162064e-03f, 8.02649036e-02f, 1.26087263e-01f, -4.24988791e-02f, 1.14578970e-01f, 1.97942052e-02f, -1.65787593e-01f, 1.22952424e-01f, -1.36685744e-02f,
  3.00231352e-02f, -8.59733298e-03f, 6.39017969e-02f, -1.08255716e-02f, -1.15487069e-01f, -2.83603929e-02f, 3.64076570e-02f, -3.37847956e-02f, 1.84835438e-02f, -2.23613884e-02f,
  -1.81647912e-02f, -7.98767656e-02f, 1.04365259e-01f, -1.11981578e-01f, 1.18369408e-01f, -9.19777527e-02f, -9.77957770e-02f, -5.65554202e-02f, -3.27839293e-02f, -1.21425074e-02f,
  -8.73622149e-02f, 5.47768399e-02f, -1.33659825e-01f, -5.26338443e-02f, 6.22819029e-02f, 1.34491473e-01f, 7.43816644e-02f, -4.83951792e-02f, 2.32644137e-02f, -1.00208960e-01f,
  -1.05749629e-01f, 1.07157737e-01f, 9.75975841e-02f, 1.50626048e-01f, -5.45624830e-02f, -5.51172765e-03f, 7.17201531e-02f, -8.48667324e-03f, -8.30089375e-02f, 1.83722237e-03f,
  -6.92869946e-02f, 5.63354343e-02f, 5.49826473e-02f, -8.82351585e-03f, 3.39459032e-02f, -4.47666608e-02f, -7.05375969e-02f, 1.08145483e-01f, 6.58879951e-02f, -6.70967028e-02f,
  8.26480240e-02f, -2.99224420e-03f, -1.78294023e-03f, 1.27030343e-01f, -1.00954592e-01f, -1.40197081e-02f, 8.34524184e-02f, -4.20789160e-02f, 1.51602970e-02f, 5.64795211e-02f,
  7.93968663e-02f, 4.39912863e-02f, -5.14471456e-02f, -5.02523370e-02f, 9.62835103e-02f, 1.09104030e-01f, 1.44397393e-01f, -7.52900913e-02f, -9.18682758e-03f, -3.91958915e-02f,
  -1.74812190e-02f, 1.36577906e-02f, -6.97895959e-02f, 7.39415288e-02f, -7.97095150e-02f, -8.21708217e-02f, -9.50913504e-02f, -1.11217402e-01f, 8.98032710e-02f, -5.28412387e-02f,
  8.16206411e-02f, 1.39550772e-02f, 6.45970032e-02f, 7.24020973e-02f, 9.71486792e-02f, 2.91270092e-02f, -6.11383617e-02f, -6.32050112e-02f, -1.14876561e-01f, -1.17097087e-01f,
  -2.15959679e-02f, 7.75878504e-02f, -7.08754808e-02f, -1.22067571e-01f, 4.29630689e-02f, -9.99133363e-02f, -2.95965839e-03f, 8.02025720e-02f, -9.98720154e-02f, -9.59285200e-02f,
  3.87596451e-02f, 4.33775857e-02f, 1.11441769e-01f, -1.47191836e-02f, 1.83283892e-02f, -3.72833870e-02f, 3.09589878e-03f, 1.41259246e-02f, 5.85142476e-03f, -9.58440378e-02f,
  -2.18249019e-03f, 4.87909466e-03f, 5.11219837e-02f, -1.51941087e-02f, 4.86713275e-02f, 2.06332114e-02f, -2.54798904e-02f, 1.01258121e-02f, 1.97882392e-03f, -1.13162130e-01f,
  6.90740813e-03f, 1.45737464e-02f, -6.78890795e-02f, 1.24802448e-01f, -1.85594652e-02f, 7.57136941e-02f, 1.00708902e-01f, 7.78422728e-02f, -4.33665551e-02f, -3.68397310e-02f,
  -5.44958152e-02f, -2.10129451e-02f, -5.20232059e-02f, 7.71285817e-02f, -3.16794366e-02f, 1.90342981e-02f, -3.64494883e-02f, -2.96757370e-02f, 8.93493742e-02f, -1.17928393e-01f,
  -1.53362285e-03f, -4.89889346e-02f, 1.50662921e-02f, -1.58521143e-04f, -9.70528275e-02f, -5.94400540e-02f, -8.08268189e-02f, 2.19212975e-02f, 4.78502661e-02f, -7.18863308e-02f,
  -7.59685040e-02f, -4.71579321e-02f, 8.04659128e-02f, 9.21056420e-02f, 3.78911123e-02f, -1.09796137e-01f, -6.61187246e-02f, 1.47224274e-02f, 1.74581613e-02f, 4.70445789e-02f,
  6.17030598e-02f, -1.10678449e-02f, -5.96251227e-02f, -8.53525922e-02f, 6.75342903e-02f, -1.07709199e-01f, 3.72767337e-02f, -1.24390572e-01f, -1.27342762e-02f, 1.36862332e-02f,
  -9.38492119e-02f, -1.20303869e-01f, -8.30662698e-02f, 3.72483656e-02f, -3.48154977e-02f, -1.02359261e-02f, 8.35419372e-02f, -6.16194215e-03f, -1.16839111e-01f, 8.62070099e-02f,
  7.36675709e-02f, -3.14688198e-02f, 1.42577710e-02f, 2.11843234e-02f, -4.09522280e-03f, 6.59689233e-02f, -1.09201200e-01f, -1.31993536e-02f, -7.39771351e-02f, 1.18444143e-02f,
  7.69946054e-02f, -3.99602354e-02f, 5.59168942e-02f, -1.44398992e-03f, 9.49495658e-02f, -5.06284386e-02f, -2.66551767e-02f, 5.84927537e-02f, -5.21160848e-02f, 7.41644800e-02f,
  3.34073752e-02f, -7.43028671e-02f, 1.32258818e-01f, 7.24886432e-02f, 2.39978582e-02f, 3.81690711e-02f, 1.72180027e-01f, 8.40279832e-02f, -1.46340162e-01f, 1.31166026e-01f,
  4.02519144e-02f, 6.32003546e-02f, -3.60273803e-03f, -5.70893176e-02f, 4.75605354e-02f, -2.39408389e-03f, -1.35989234e-01f, -1.78591892e-01f, -1.42955139e-01f, 7.61173591e-02f,
  -1.01295613e-01f, 1.58306330e-01f, 1.75407112e-01f, -8.49037096e-02f, -1.04240447e-01f, 1.41223088e-01f, 1.78643316e-01f, 9.89745334e-02f, -1.06212934e-02f, -1.31254703e-01f,
  1.83271617e-01f, -9.38026682e-02f, 1.02677189e-01f, 1.44591391e-01f, -9.57974494e-02f, 6.28150478e-02f, -1.00964881e-01f, 7.37216771e-02f, 6.35789707e-02f, 1.46051824e-01f,
  -4.35395911e-02f, -1.99015960e-02f, 1.41421765e-01f, -1.45643819e-02f, -1.53516782e-02f, 3.02556995e-02f, -9.60280523e-02f, 2.16027543e-01f, 7.78933405e-04f, -1.48231417e-01f,
  -4.84209582e-02f, -8.55400488e-02f, -1.44529894e-01f, 3.37050995e-03f, 4.70828451e-02f, 5.75238355e-02f, 9.12991539e-02f, 4.57632132e-02f, 1.89554133e-02f, 8.80472586e-02f,
  1.69750080e-01f, 6.52100518e-02f, -1.67822525e-01f, 3.72820981e-02f, 1.06919229e-01f, -1.80027224e-02f, 2.59806812e-01f, 3.02725155e-02f, 1.19658362e-03f, -1.45776207e-02f,
  2.90402137e-02f, 1.43856272e-01f, 1.18738905e-01f, 3.58637869e-01f, -1.14593945e-01f, 1.94585830e-01f, -3.19334418e-02f, -1.58871785e-01f, 6.17882162e-02f, 2.20434785e-01f,
  1.42750189e-01f, -2.49408394e-01f, 1.64465293e-01f, 1.53983787e-01f, -2.21342929e-02f, 7.08564147e-02f, -1.23434022e-01f, 6.85255155e-02f, 9.89941359e-02f, 1.15668990e-01f,
  3.77877839e-02f, -2.87703127e-02f, 1.83542952e-01f, 6.52939081e-02f, -1.90100819e-01f, -6.81779608e-02f, -6.26114458e-02f, -1.24501050e-01f, -1.77415386e-01f, -7.19731301e-03f,
  2.84803033e-01f, 4.85907793e-01f, -2.26266071e-01f, -3.56232375e-02f, -1.99425414e-01f, -2.10194029e-02f, 2.23113924e-01f, -1.13536835e-01f, -2.33514514e-02f, -1.22350054e-02f,
  1.09606221e-01f, -1.86871067e-02f, 1.62730008e-01f, -1.61228403e-01f, 4.54051346e-01f, 3.23088504e-02f, -3.58061641e-02f, 2.59813637e-01f, -2.17652842e-01f, -5.35536706e-02f,
  -3.55331115e-02f, -1.00596242e-01f, 5.37496060e-02f, 2.52437964e-02f, 1.81327760e-01f, 2.12899111e-02f, 1.77220464e-01f, -8.28965232e-02f, 1.54387817e-01f, 1.24620751e-01f,
  -3.46772932e-02f, 4.38531972e-02f, -1.22973062e-02f, 1.49514318e-01f, 1.49332779e-02f, 6.15536757e-02f, 1.18661895e-01f, -4.96920496e-02f, -1.29832536e-01f, -6.64697364e-02f,
  1.26809388e-01f, -4.08254527e-02f, -2.84904987e-02f, 1.34116083e-01f, 1.26322165e-01f, 1.02062598e-01f, -4.36146697e-03f, -3.09719108e-02f, -1.40817398e-02f, -1.03094377e-01f,
  -1.61359549e-01f, 8.98660049e-02f, 9.89705026e-02f, 6.21415786e-02f, 1.05454177e-01f, -1.15019530e-01f, -3.43785509e-02f, -5.24421670e-02f, -1.41424671e-01f, 2.29374375e-02f,
  1.59749776e-01f, -1.11317612e-01f, -1.12670735e-01f, -9.45858955e-02f, 1.14441179e-01f, 2.21615106e-01f, -1.30384967e-01f, 9.21909173e-04f, -7.92227164e-02f, -1.47334844e-01f,
  4.82100286e-02f, 8.23003426e-02f, -4.81114276e-02f, 2.69735217e-01f, -3.46584767e-02f, 2.06024930e-01f, 1.58885151e-01f, -8.41998030e-03f, -7.30378786e-03f, -2.39799637e-02f,
  -3.08807455e-02f, 3.42488997e-02f, -1.43907055e-01f, -4.08928916e-02f, -2.45792326e-02f, -3.45934480e-02f, 9.39507633e-02f, 3.77406031e-02f, -2.40383931e-02f, -4.47966717e-02f,
  7.60780647e-03f, 1.11579984e-01f, -5.37276901e-02f, 9.32149664e-02f, 1.21924713e-01f, 3.65057178e-02f, -9.78794247e-02f, 8.14983025e-02f, 1.11580648e-01f, -6.20829314e-02f,
  6.99279308e-02f, 1.63786456e-01f, -1.55909613e-01f, 1.37676433e-01f, -2.49489963e-01f, -4.29037064e-02f, -2.83088628e-02f, 8.03214498e-03f, 1.37416288e-01f, -1.32574379e-01f,
  1.90702062e-02f, -1.25786901e-01f, -4.80880477e-02f, -1.02389462e-01f, 1.80666819e-01f, 1.00743979e-01f, -8.72032996e-03f, 1.44929603e-01f, 1.20689005e-01f, 1.76854834e-01f,
  -3.91547121e-02f, -2.92384960e-02f, 9.22283307e-02f, -7.72083253e-02f, 1.02787472e-01f, 8.72936547e-02f, -1.10215090e-01f, 1.23486340e-01f, -1.58182513e-02f, -8.69058296e-02f,
  -3.11310943e-02f, 1.20845981e-01f, -1.03992149e-01f, 6.46591559e-02f, 7.00575113e-02f, 1.04539871e-01f, -2.29175892e-02f, -9.59610790e-02f, 4.52448986e-02f, -4.16110083e-02f,
  2.85344645e-02f, -8.13828036e-02f, 2.03954473e-01f, 1.43226394e-02f, 1.22741442e-02f, 6.65395036e-02f, 1.93912741e-02f, 1.22137718e-01f, -1.13617629e-01f, 1.33371845e-01f,
  -3.37525532e-02f, 8.12127143e-02f, 1.11382864e-01f, -5.36958352e-02f, 3.77524123e-02f, -9.16237757e-02f, 8.48813262e-03f, 8.09733272e-02f, 2.24345308e-02f, -6.54880032e-02f,
  -8.81142393e-02f, 3.65094729e-02f, -4.46912227e-03f, -6.57598972e-02f, -4.28433195e-02f, -9.56466608e-03f, 5.05586304e-02f, -1.26262456e-01f, 7.10872412e-02f, 1.13920346e-01f,
  6.70933574e-02f, -1.14993401e-01f, 5.36752790e-02f, 8.76689702e-02f, 1.15769781e-01f, -9.06611979e-02f, 1.03632852e-01f, 9.93704870e-02f, -1.42939851e-01f, 1.31174564e-01f,
  -1.17176004e-01f, 1.14181437e-01f, 6.72366619e-02f, 4.93905619e-02f, -1.14285082e-01f, 1.20098360e-01f, -4.73559238e-02f, -5.12608001e-03f, 7.38807861e-03f, -4.30223346e-02f,
  8.42893198e-02f, 1.14377379e-01f, 1.99793413e-01f, -7.73538053e-02f, -1.27663452e-05f, 5.14797866e-02f, 4.85886484e-02f, -2.55899858e-02f, -8.87403637e-02f, 5.44873737e-02f,
  1.31374553e-01f, 3.07083018e-02f, -7.62975588e-02f, 7.59682357e-02f, 9.34505835e-02f, 8.28548074e-02f, 1.09004423e-01f, 7.61956796e-02f, 2.47707758e-02f, -8.65907874e-03f,
  -5.27816713e-02f, -5.58843426e-02f, 1.21574793e-02f, 1.18885234e-01f, 9.89599824e-02f, -7.64387008e-03f, -5.25750453e-03f, -1.13675758e-01f, -1.50303602e-01f, 1.11255556e-01f,
  1.11414865e-01f, -1.13609016e-01f, 1.30726397e-01f, 6.81263506e-02f, 7.79268891e-02f, -9.04571488e-02f, 1.32652760e-01f, -9.80154648e-02f, 2.46616397e-02f, 7.49706402e-02f,
  -2.22362846e-01f, 1.19686924e-01f, 1.25990445e-02f, -2.97910776e-02f, -3.22712027e-02f, -1.83389843e-01f, -2.73703020e-02f, 2.73496448e-03f, -3.06243375e-02f, 1.26118749e-01f,
  6.23026714e-02f, 2.13052779e-01f, 5.29603772e-02f, 9.78955650e-04f, -7.95626119e-02f, 1.91432014e-01f, 2.88614541e-01f, 1.33043781e-01f, 1.02968395e-01f, -1.61000058e-01f,
  1.91382602e-01f, 6.13113008e-02f, -9.59954932e-02f, 1.13243476e-01f, 2.40853071e-01f, -1.06069490e-01f, -2.65382696e-02f, -1.10943004e-01f, 7.56923482e-02f, 7.33018368e-02f,
  1.53632686e-01f, -1.12602301e-02f, 3.82907122e-01f, 6.43115267e-02f, 1.03625823e-02f, -1.78004384e-01f, 9.35855955e-02f, 8.51156637e-02f, -2.42397144e-01f, 1.58333350e-02f,
  1.31081328e-01f, -1.21216424e-01f, 7.06778020e-02f, 2.35092252e-01f, -1.60982809e-03f, -8.12293068e-02f, -8.83581489e-02f, 3.01623857e-03f, -4.13727388e-03f, -4.51216847e-02f,
  3.91543545e-02f, -1.34590566e-02f, 5.91484495e-02f, -3.16409022e-02f, -1.03605162e-05f, -1.09801158e-01f, -9.03570130e-02f, -8.25288966e-02f, 6.29191548e-02f, -4.61593270e-03f,
  1.12367921e-01f, 9.07463580e-02f, 7.38450512e-02f, 2.68189088e-02f, 1.52135929e-02f, -2.47070827e-02f, 5.76771796e-02f, -1.44893304e-01f, 1.08658476e-03f, -1.30731598e-01f,
  7.28750601e-02f, -1.11395188e-01f, -5.61623238e-02f, -5.58917224e-02f, 8.94149765e-02f, -1.36499954e-02f, 1.80438623e-01f, -6.49828240e-02f, 4.39942367e-02f, -1.15593420e-02f,
  5.38983308e-02f, 1.14799589e-01f, 3.91257405e-02f, 2.69253571e-02f, 6.87935799e-02f, 1.07152738e-01f, 5.18689193e-02f, 1.92996822e-02f, 4.81253564e-02f, -1.01042241e-01f,
  -7.90839642e-02f, 8.80230069e-02f, 8.58306361e-04f, 7.50063211e-02f, -6.06995225e-02f, -8.68168473e-02f, 1.87260121e-01f, -1.13644436e-01f, -1.12229541e-01f, -5.91991134e-02f,
  1.42675474e-01f, 4.98530418e-02f, 9.92443338e-02f, -4.38769571e-02f, 7.27248983e-03f, 4.57856916e-02f, 6.37017861e-02f, -3.27693783e-02f, 1.71114087e-01f, 6.56292588e-03f,
  -5.80842011e-02f, 2.48797797e-03f, 7.69409686e-02f, -1.26312487e-02f, 2.05927510e-02f, 2.26507075e-02f, 1.19212426e-01f, -3.92013229e-02f, 4.12797928e-02f, 1.01365149e-01f,
  1.42341763e-01f, -6.95903227e-02f, -5.63343987e-02f, -9.55468863e-02f, 5.73590621e-02f, -2.97697373e-02f, -2.18354557e-02f, -6.06687665e-02f, -8.21431130e-02f, -1.93326978e-03f,
  1.02049470e-01f, -8.12427029e-02f, 7.21142963e-02f, 6.60894737e-02f, -1.02322638e-01f, 5.78614436e-02f, -1.39010549e-01f, 1.56185389e-01f, 3.54071893e-02f, 1.83519185e-01f,
  1.31124202e-02f, -1.30737916e-01f, -3.69507028e-03f, -7.20201945e-03f, 1.29814029e-01f, 5.26319295e-02f, -2.83756237e-02f, -1.20719716e-01f, 1.02902234e-01f, -4.68912609e-02f,
  1.01340577e-01f, 1.84799597e-01f, 1.51838750e-01f, 1.11006774e-01f, -1.92487910e-01f, 8.57454240e-02f, -1.24024086e-01f, -8.11851490e-03f, 2.02193096e-01f, 5.54984733e-02f,
  -2.17051501e-03f, 8.78867060e-02f, 7.01445155e-03f, -9.91120860e-02f, 7.77942911e-02f, 1.44314915e-01f, -1.08191453e-01f, 1.96112860e-02f, 5.07419780e-02f, -1.33557878e-02f,
  -1.23489417e-01f, -1.65287983e-02f, 1.47604480e-01f, 9.02899802e-02f, 2.86380891e-02f, -1.29412547e-01f, 4.88321669e-02f, 6.43376783e-02f, 7.56609365e-02f, 2.04493299e-01f,
  1.64472371e-01f, 1.46953046e-01f, -7.15397345e-03f, 5.19606918e-02f, 1.47042155e-01f, 7.28304163e-02f, -1.07105114e-01f, -2.85131503e-02f, 4.20763902e-03f, -1.43640280e-01f,
  -6.33475855e-02f, 2.26674136e-02f, -1.02854535e-01f, 2.31460258e-02f, 8.31062626e-03f, 8.20904300e-02f, -1.30377278e-01f, -1.00623004e-01f, -1.36995167e-01f, -5.16615063e-02f,
  7.97432009e-03f, -6.20885119e-02f, -2.77019683e-02f, 3.12113552e-03f, -1.97546161e-03f, 3.08084805e-02f, -4.56735045e-02f, 1.44388333e-01f, 9.32652429e-02f, 1.20560832e-01f,
  6.97122291e-02f, 8.14863220e-02f, 1.16216436e-01f, 1.88051425e-02f, 1.10799477e-01f, 9.11581367e-02f, -4.77279946e-02f, 7.12168515e-02f, -9.66526121e-02f, -1.10995613e-01f,
  -2.90980265e-02f, -8.86974633e-02f, 7.50294700e-02f, 1.07316568e-01f, 5.80761805e-02f, -8.51117671e-02f, -3.67608331e-02f, -6.66710064e-02f, 9.71744508e-02f, 1.66410819e-01f,
  -1.19263075e-01f, -1.06056705e-01f, 7.00088367e-02f, 8.01563337e-02f, -6.57921061e-02f, 3.01503502e-02f, 2.07543835e-01f, -1.13325074e-01f, -7.91088715e-02f, 4.41896245e-02f,
  4.10416424e-02f, 6.62864521e-02f, -1.65670179e-02f, -6.52526170e-02f, -1.08669437e-02f, 9.34835747e-02f, 1.16499834e-01f, -5.53830937e-02f, 1.98263317e-01f, 1.91974174e-02f,
  5.51672317e-02f, 1.30180165e-01f, 2.44037993e-02f, 4.48946245e-02f, -1.38999298e-01f, 2.29022145e-01f, -6.54478837e-03f, 7.47465715e-02f, -5.16512059e-02f, -2.16577798e-01f,
  -8.82216915e-02f, -1.05400860e-01f, 5.26789576e-02f, -2.54795738e-02f, 7.34690577e-02f, -1.73259795e-01f, -5.10394908e-02f, -5.73160723e-02f, 1.20698810e-01f, 7.04654157e-02f,
  1.22104391e-01f, -5.24151139e-02f, 4.76098321e-02f, -8.42547342e-02f, 6.91499561e-02f, 3.61231938e-02f, 8.12030882e-02f, -1.21800430e-01f, -6.48435801e-02f, 6.72212839e-02f,
  -2.62835082e-02f, 2.10359599e-02f, 7.95699656e-02f, 1.70108765e-01f, -5.81818074e-02f, 1.42017096e-01f, -1.33227661e-01f, 5.30932061e-02f, -1.86599453e-03f, 6.22545891e-02f,
  -1.01571634e-01f, -1.30426874e-02f, -2.45797392e-02f, 5.47158942e-02f, 1.92444161e-01f, 6.26292229e-02f, 1.93032801e-01f, -1.41691882e-04f, -1.46745786e-01f, 3.75158787e-02f,
  8.43796059e-02f, 1.11684904e-01f, 2.15541553e-02f, -1.16201587e-01f, -1.03013515e-01f, 6.54003173e-02f, 4.43244241e-02f, 1.17618121e-01f, -6.09664656e-02f, 8.18677992e-03f,
  8.97115469e-02f, -9.85839441e-02f, -3.45338398e-04f, -6.10888153e-02f, -1.05377190e-01f, -6.52047247e-02f, 5.73182963e-02f, -1.17602564e-01f, 1.42477170e-01f, -4.03175317e-02f,
  -1.17280319e-01f, -5.86071052e-02f, -4.30109398e-03f, 2.50424799e-02f, 7.24029308e-03f, 1.41472936e-01f, 2.87998356e-02f, -6.68574199e-02f, -3.64815108e-02f, -3.54946367e-02f,
  6.69105127e-02f, 1.31626666e-01f, -5.00317551e-02f, 2.18915585e-02f, -8.58171936e-03f, -1.80205889e-02f, -1.31618574e-01f, 4.52702446e-03f, -2.47578137e-02f, -5.10477349e-02f,
  -1.25423297e-01f, -9.71455947e-02f, -1.08461104e-01f, -8.37045833e-02f, 8.35512355e-02f, -8.97353608e-03f, 4.67522927e-02f, 1.41738564e-01f, -1.54530019e-01f, 3.97946425e-02f,
  -6.01466820e-02f, -5.14863506e-02f, 7.45585710e-02f, -1.13096600e-02f, -2.78158206e-03f, 4.39510159e-02f, 1.06720619e-01f, -4.94577326e-02f, 1.16721177e-02f, -3.94179747e-02f,
  8.46637487e-02f, -1.00529663e-01f, 5.22452667e-02f, 1.61280230e-01f, 3.65802124e-02f, 2.32824422e-02f, -4.15685177e-02f, 5.62889017e-02f, 1.11680202e-01f, 3.98544036e-02f,
  -1.83812510e-02f, -1.12610839e-01f, 3.26193534e-02f, -8.04041997e-02f, 5.18440641e-02f, -8.43927190e-02f, -8.54627043e-02f, -1.18035562e-01f, -9.10533890e-02f, -3.79111618e-02f,
  7.97265023e-02f, -3.61995399e-02f, 5.37304953e-02f, 3.83031741e-02f, -4.06563319e-02f, 1.12429254e-01f, 5.99043965e-02f, 1.07258614e-02f, 4.14172001e-02f, -1.08531266e-01f,
  -9.94006172e-02f, 6.53929869e-03f, -1.25242516e-01f, 1.17548071e-01f, -8.46207738e-02f, 3.82765150e-03f, 4.62322347e-02f, 1.27844751e-01f, 5.14682978e-02f, 8.57047141e-02f,
  7.89644122e-02f, 9.71192345e-02f, -6.81894124e-02f, -4.21031043e-02f, -7.85937160e-02f, -1.15926415e-01f, 1.01389676e-01f, -1.60027534e-01f, 1.18838526e-01f, -9.05192830e-03f,
  4.22771983e-02f, 9.75022558e-03f, 2.38853153e-02f, -3.74820866e-02f, 1.04043834e-01f, 7.29360953e-02f, -7.12394267e-02f, -8.22816193e-02f, -1.03623517e-01f, 1.77378729e-02f,
  -8.62224177e-02f, 2.09371895e-02f, -1.00522012e-01f, 2.16902774e-02f, 5.65242097e-02f, -1.96350850e-02f, -4.61185817e-03f, 1.66629218e-02f, -4.52954434e-02f, -1.67238805e-02f,
  -3.97327468e-02f, 3.50183025e-02f, 5.95886372e-02f, -5.47491834e-02f, 9.26904306e-02f, 3.66546912e-03f, 2.53049344e-01f, 1.47033781e-01f, 1.90454319e-01f, 1.73686072e-01f,
  -1.94996558e-02f, 9.71725509e-02f, 1.35101438e-01f, 1.03588738e-01f, 8.71059597e-02f, 1.18273012e-01f, 7.37212896e-02f, -3.42063308e-01f, 1.59294024e-01f, -3.02183270e-01f,
  2.88497001e-01f, 2.93338060e-01f, -1.21943355e-01f, -3.24907377e-02f, -1.27187192e-01f, 3.01894993e-01f, 1.60011277e-02f, 2.47334968e-02f, -5.97723238e-02f, -1.15419654e-02f,
  -2.01712787e-01f, 1.28243584e-02f, -3.67636606e-02f, -1.37093756e-02f, 2.45480984e-02f, -5.79261966e-02f, -9.23783556e-02f, 7.13414922e-02f, -9.18629393e-02f, 2.57315822e-02f,
  2.08946377e-01f, 1.26713127e-01f, -9.92354155e-02f, -1.21015683e-01f, 9.27325562e-02f, -8.81893262e-02f, 8.28224421e-03f, 4.12412770e-02f, 2.43049413e-01f, 6.66396841e-02f,
  -4.78622213e-04f, -6.74058050e-02f, 1.90249681e-01f, 2.38711938e-01f, -7.40162283e-02f, 1.91517100e-01f, 1.39918879e-01f, 1.25170186e-01f, -8.42711478e-02f, -4.98605967e-02f,
  2.16394857e-01f, -2.90116929e-02f, -6.61522448e-02f, 1.92866307e-02f, -1.53671615e-02f, 2.31411666e-01f, 2.56103814e-01f, 2.74378271e-03f, 1.31953433e-02f, 6.46464825e-02f,
  -8.08563754e-02f, -8.39082971e-02f, -9.81976613e-02f, -7.96676129e-02f, 1.38021633e-01f, 2.10135616e-02f, 5.41863963e-02f, -1.07765935e-01f, 1.41359940e-01f, 3.65212522e-02f,
  -1.41464537e-02f, 1.84769288e-01f, -1.39802545e-02f, -5.10905273e-02f, -3.19790356e-02f, -1.61675915e-01f, -5.06073050e-02f, -8.74141082e-02f, 1.92910209e-02f, -1.95569411e-01f,
  8.60183034e-03f, 1.20360769e-01f, -1.19249903e-01f, 1.86998248e-02f, 6.52152821e-02f, 5.57254106e-02f, -1.75611954e-02f, -1.70409959e-02f, -7.46473297e-02f, 1.55576831e-02f,
  -2.07666978e-02f, 1.87153220e-02f, 3.51543166e-02f, 1.59758125e-02f, -6.60829572e-03f, 7.99651518e-02f, 2.88060252e-02f, -2.07505617e-02f, -4.46988307e-02f, 1.58402979e-01f,
  -9.93629694e-02f, 1.20793290e-01f, -1.14948876e-01f, 1.02527790e-01f, 9.55056995e-02f, -5.84531296e-03f, -3.36121419e-03f, 1.45318583e-02f, -1.55915003e-02f, -1.10341288e-01f,
  3.68802473e-02f, -1.40620053e-01f, 1.58600986e-01f, -9.77499634e-02f, -8.62935558e-03f, 1.02449462e-01f, 2.98554469e-02f, 6.81191385e-02f, -9.92471948e-02f, 9.06308275e-03f,
  -4.54524197e-02f, -7.51088336e-02f, 2.33485937e-01f, 3.89540009e-02f, 2.04628661e-01f, 4.69419509e-02f, 1.02794334e-01f, 5.88983484e-03f, 1.49349928e-01f, 1.45545214e-01f,
  1.10292144e-01f, 1.67345032e-01f, 1.54366225e-01f, 1.67341560e-01f, -4.73531894e-02f, 8.11892003e-02f, 6.41316101e-02f, -1.69362559e-03f, -1.54313251e-01f, -1.95996910e-02f,
  -9.88813713e-02f, -1.00075282e-01f, -1.18404880e-01f, -1.83050826e-01f, -6.66149929e-02f, 1.46711394e-01f, -8.79386216e-02f, -5.54992370e-02f, 2.27830768e-01f, -1.50634170e-01f,
  -1.24149024e-01f, 8.25279877e-02f, -3.48116569e-02f, 6.02602400e-02f, -3.44156399e-02f, 1.44341022e-01f, 2.61127442e-01f, 2.30702199e-02f, 3.01255789e-02f, 1.24676824e-01f,
  -5.93626464e-04f, 1.17962264e-01f, -1.50482580e-01f, 3.23033594e-02f, 1.81085944e-01f, 1.05877183e-02f, 1.52934743e-02f, 3.64577805e-04f, -8.83128569e-02f, -3.56536582e-02f,
  -1.23739347e-01f, 7.94768631e-02f, 1.13907978e-02f, 1.46946669e-01f, 7.39542115e-03f, 4.32867184e-02f, 1.01442195e-01f, -4.97666709e-02f, 7.75935873e-02f, -1.37044072e-01f,
  1.02903865e-01f, 3.01670167e-04f, -7.89931193e-02f, -2.05223560e-02f, 1.18182838e-01f, -9.50975642e-02f, -9.21436846e-02f, -3.14653441e-02f, 6.19632937e-02f, 8.45287293e-02f,
  -8.39299485e-02f, -2.60496736e-02f, -1.58925578e-02f, -9.47038233e-02f, -5.62560651e-03f, -8.95940289e-02f, -4.91133444e-02f, -8.73855725e-02f, -1.23979554e-01f, -6.04733042e-02f,
  5.59867583e-02f, -6.56927675e-02f, -1.12416610e-01f, 3.65169607e-02f, -8.56041461e-02f, 9.02161449e-02f, -1.17636640e-02f, -1.06725477e-01f, 7.80841559e-02f, 1.15509450e-01f,
  9.45204943e-02f, 8.03925912e-04f, -6.84011206e-02f, -5.03242165e-02f, 2.69643739e-02f, 2.54886411e-02f, -1.14226306e-03f, 2.13695187e-02f, -6.37302175e-02f, -7.17949718e-02f,
  1.21351540e-01f, 1.10580353e-02f, 6.74965978e-02f, 6.88048154e-02f, 9.08085331e-02f, -1.04582146e-01f, -6.07963577e-02f, 4.26438935e-02f, 2.76876856e-02f, -3.43765579e-02f,
  -4.89057191e-02f, -4.30997647e-02f, 2.98030265e-02f, 4.38608117e-02f, -9.30002555e-02f, -1.61738484e-04f, -7.89336301e-03f, 2.10322402e-02f, -4.41813618e-02f, -5.73489405e-02f,
  -5.29774427e-02f, -3.26459557e-02f, -1.05516456e-01f, -5.91633320e-02f, 3.97679769e-02f, 5.39325364e-02f, -2.88573951e-02f, -1.08060472e-01f, 5.44144511e-02f, 1.20754652e-01f,
  -9.21697076e-03f, 1.52928486e-01f, -4.92846444e-02f, 1.33324623e-01f, 1.50909409e-01f, 2.99043357e-02f, 7.31424913e-02f, 1.86499938e-01f, 1.38383716e-01f, 1.69239104e-01f,
  5.75733818e-02f, 1.21574011e-02f, 1.42229304e-01f, 1.94867998e-01f, -1.65159687e-01f, -9.81763303e-02f, 1.83698699e-01f, -5.12110256e-02f, -5.29890247e-02f, 2.49399349e-01f,
  -2.85698622e-01f, -2.13324115e-01f, 1.10224500e-01f, 2.74981320e-01f, 9.93345305e-02f, 2.25781426e-01f, 1.23832993e-01f, -1.33338168e-01f, -1.16702422e-01f, -3.20586823e-02f,
  1.16772853e-01f, -2.69307513e-02f, 3.39113742e-01f, 8.66479948e-02f, -1.11767672e-01f, 1.13941103e-01f, 4.15454917e-02f, 8.14487189e-02f, 4.55571935e-02f, -4.48162444e-02f,
  -1.09261863e-01f, 3.66853327e-01f, -1.39007166e-01f, -2.65814308e-02f, 5.65620475e-02f, 4.10424434e-02f, 1.59989730e-01f, 3.16277407e-02f, -3.70031632e-02f, -1.12692848e-01f,
  1.19745336e-01f, 7.27247223e-02f, 3.47827703e-01f, -1.88145846e-01f, 2.56491125e-01f, 8.45256299e-02f, 3.13215479e-02f, 2.41639182e-01f, -5.18016331e-02f, -1.33329108e-01f,
  1.21682495e-01f, -3.05983514e-01f, 7.41645619e-02f, -8.89707822e-03f, 1.11544259e-01f, 9.09582302e-02f, -5.51654398e-02f, 7.00000301e-02f, -6.05398603e-02f, 1.57238007e-01f,
  1.18109159e-01f, 5.29962853e-02f, 1.26894414e-01f, 2.53602620e-02f, -8.66274238e-02f, 1.39247030e-01f, 4.10517231e-02f, 1.06025919e-01f, -1.37475014e-01f, -1.12208508e-01f,
  -8.09491426e-03f, -5.10468818e-02f, 3.11330073e-02f, 2.51968354e-01f, -2.67372839e-02f, 9.85770524e-02f, 9.75502953e-02f, -9.32029337e-02f, -8.26538727e-02f, -1.08899973e-01f,
  -2.24624991e-01f, 2.07011417e-01f, -9.86965559e-03f, 2.86117475e-02f, -1.46178931e-01f, -2.60733105e-02f, 1.39605105e-01f, -3.97444284e-03f, -2.53777444e-01f, 1.82286315e-02f,
  -3.61204296e-02f, -2.46802151e-01f, -1.67512819e-01f, 1.16701901e-01f, 2.40742311e-01f, 3.58413875e-01f, -2.95710176e-01f, 7.73852170e-02f, -8.19322243e-02f, -1.85432181e-01f,
  9.70694795e-02f, -8.68573040e-02f, 1.06292814e-01f, 2.85191506e-01f, 5.10762967e-02f, -3.50605920e-02f, 4.42715526e-01f, 4.07207161e-02f, 2.78506637e-01f, -3.45478505e-02f,
  8.30787495e-02f, 2.10521460e-01f, -2.32044399e-01f, -9.59494933e-02f, 4.54456080e-03f, -5.43072373e-02f, 1.92705452e-01f, 6.75740764e-02f, 5.96642941e-02f, -9.27487272e-05f,
  -1.68211430e-01f, -2.83877854e-03f, -7.25086704e-02f, -8.44247043e-02f, -1.03104815e-01f, 5.78642227e-02f, -9.10917372e-02f, 4.42602150e-02f, 3.82932685e-02f, -1.37116358e-01f,
  3.79808024e-02f, -1.98459886e-02f, -1.41571060e-01f, -8.23106840e-02f, 8.90913308e-02f, 1.11608483e-01f, -6.40457198e-02f, -1.08383626e-01f, 3.30601931e-02f, 9.71745625e-02f,
  -2.48520747e-02f, 1.54824957e-01f, -3.47113945e-02f, 1.31351277e-01f, -3.39581147e-02f, 1.14827700e-01f, 9.09894556e-02f, -9.59569216e-02f, 1.67766616e-01f, -3.78913209e-02f,
  -4.49785963e-03f, -1.65131409e-02f, -1.49979725e-01f, -9.15666521e-02f, -9.01075453e-02f, 6.36167824e-02f, -6.37910292e-02f, 4.29820605e-02f, -5.93323484e-02f, -6.47958592e-02f,
  8.04733485e-02f, 1.03618450e-01f, 6.49071038e-02f, 3.08533907e-02f, 5.22546619e-02f, -1.42675890e-02f, 5.36241308e-02f, -9.71629545e-02f, 1.33683696e-01f, 6.62733242e-02f,
  -6.02819435e-02f, 4.03679535e-02f, -6.71045408e-02f, 1.00204386e-01f, 1.51783466e-01f, 1.18313655e-01f, -1.42797530e-01f, 1.98096633e-02f, -3.50588076e-02f, -7.19290525e-02f,
  1.13506964e-03f, -3.20735313e-02f, 7.08843768e-03f, -7.92023391e-02f, -1.15207531e-01f, -4.06956188e-02f, 6.53158724e-02f, 7.61794746e-02f, 4.20971960e-02f, -4.30792682e-02f,
  -9.43467617e-02f, 1.77646000e-02f, 4.92631197e-02f, 2.45248787e-02f, 7.76876807e-02f, 7.77846575e-02f, -1.20078616e-01f, 1.62484437e-01f, 6.12500459e-02f, 4.53428850e-02f,
  -6.03368133e-02f, -1.50683418e-01f, 3.76808383e-02f, -5.03952429e-02f, 5.00470214e-02f, 1.33469060e-01f, -6.93747250e-04f, 1.14113845e-01f, -5.79148065e-03f, -6.97948635e-02f,
  -1.25523694e-02f, -7.99641237e-02f, 3.74819450e-02f, 1.34001210e-01f, 1.26897797e-01f, -8.13497677e-02f, 4.82178740e-02f, 1.24255091e-01f, -3.62521708e-02f, 1.47293434e-01f,
  -9.83831882e-02f, 1.22571541e-02f, 4.17732075e-03f, 3.01974807e-02f, 6.96356222e-02f, 4.63164859e-02f, -1.71534449e-01f, -6.08978327e-03f, -4.57227677e-02f, 1.01829745e-01f,
  -1.08208105e-01f, -1.09155886e-01f, 9.06219110e-02f, 7.06363097e-02f, -1.19159341e-01f, -7.18888417e-02f, -1.76690705e-02f, -9.14089009e-02f, -4.77606095e-02f, -3.86529565e-02f,
  -5.14312834e-02f, 5.28265201e-02f, 8.54696557e-02f, 5.64497747e-02f, 3.67458537e-02f, -9.70021039e-02f, -1.67112274e-03f, -1.19561188e-01f, 7.42481202e-02f, 1.20969415e-01f,
  3.52280997e-02f, -1.16808809e-01f, -9.04024467e-02f, 4.38353382e-02f, -1.14044189e-01f, 2.61568632e-02f, 4.65070046e-02f, -7.11589456e-02f, 6.98737726e-02f, 7.14014173e-02f,
  -3.42824943e-02f, 6.24918677e-02f, 1.20127186e-01f, -6.87431842e-02f, 5.56564443e-02f, 1.03505135e-01f, 4.21823561e-02f, 1.24621794e-01f, -9.06711519e-02f, -8.21970925e-02f,
  7.57249594e-02f, 1.21174373e-01f, -7.00299665e-02f, 9.88620445e-02f, 8.28308286e-04f, -9.45068449e-02f, 6.26787469e-02f, 5.69242649e-02f, -4.93812338e-02f, -9.63845327e-02f,
  -1.01345129e-01f, -6.32061735e-02f, -8.14143494e-02f, 4.72396947e-02f, -1.98174585e-02f, -9.82431769e-02f, 9.32353809e-02f, -6.92146318e-03f, -5.35546876e-02f, 7.39404336e-02f,
  6.61179563e-03f, 1.15488790e-01f, 1.75369680e-02f, -3.22454572e-02f, 4.85599525e-02f, 1.60750728e-02f, -2.77154371e-02f, 6.33562431e-02f, -1.04867645e-01f, -1.20820709e-01f,
  2.27232389e-02f, 1.17811710e-01f, -2.85679828e-02f, -1.23985987e-02f, -1.03616424e-01f, -1.46054514e-02f, 1.90079231e-02f, 2.98492834e-02f, -1.12342887e-01f, 6.89046085e-02f,
  -5.91052836e-03f, -3.42069939e-03f, 2.08940282e-01f, 2.20271405e-02f, 1.90324947e-01f, 1.64683595e-01f, 3.54557112e-02f, 1.05759330e-01f, 1.77828744e-01f, 1.81602519e-02f,
  7.69305825e-02f, 1.08814120e-01f, -6.87513277e-02f, -4.50549461e-03f, -1.42491087e-01f, 1.29823629e-02f, -1.07270107e-01f, 9.33853984e-02f, -2.09596127e-01f, -1.33834183e-01f,
  6.89275637e-02f, 1.47770559e-02f, 1.41463071e-01f, -6.75163865e-02f, 6.46080673e-02f, -1.50655247e-02f, 2.25722447e-01f, 4.87414561e-02f, -1.20903037e-01f, 1.22083262e-01f,
  -1.19223483e-01f, 6.45317510e-02f, -9.13426653e-02f, 1.16199017e-01f, 1.23861901e-01f, 3.79200689e-02f, 2.23737702e-01f, 1.39714051e-02f, -1.02808699e-01f, 8.06135535e-02f,
  2.14249045e-01f, 5.64625300e-02f, 2.48273060e-01f, -3.97868939e-02f, 5.31904176e-02f, 8.05971622e-02f, -1.06255531e-01f, 9.56170708e-02f, 1.92211196e-01f, 1.98191777e-01f,
  1.14040323e-01f, -5.80497608e-02f, -4.10216451e-02f, 1.30741596e-01f, -1.21622629e-01f, -2.01458223e-02f, 2.17814311e-01f, -2.01156765e-01f, 1.04068749e-01f, 8.20128471e-02f,
  5.69415540e-02f, 1.79033041e-01f, 5.47592118e-02f, 1.16591349e-01f, -3.42499986e-02f, -1.73965481e-03f, -7.77201653e-02f, 3.56155895e-02f, -6.95342422e-02f, 7.91321024e-02f,
  -1.14284538e-01f, 6.36938289e-02f, 4.24198061e-02f, -9.25043225e-02f, -7.25442097e-02f, -1.08743161e-01f, 9.77172703e-02f, 8.88107494e-02f, 4.67799418e-02f, -7.91219547e-02f,
  1.13677740e-01f, -4.54171449e-02f, 5.37380800e-02f, 9.66620892e-02f, 4.89603467e-02f, 9.85669438e-03f, -5.97584397e-02f, 4.33313958e-02f, 8.49591941e-02f, -1.03441358e-01f,
  4.18494418e-02f, 2.90319454e-02f, -1.17113329e-02f, 4.40650573e-03f, -1.31698728e-01f, 6.92602769e-02f, 6.54991716e-02f, -1.14496914e-03f, 6.81618154e-02f, 1.03282958e-01f,
  -5.83910085e-02f, 1.03550799e-01f, -4.27950919e-02f, -2.91211475e-02f, 6.48758560e-02f, 8.21834579e-02f, -8.76339674e-02f, 9.22593474e-02f, 2.58534146e-03f, 3.42730171e-04f,
  -8.70986059e-02f, 1.72635037e-02f, 5.41890447e-04f, 1.67971015e-01f, 8.90032351e-02f, -7.93739334e-02f, 1.26872674e-01f, -2.40160991e-02f, 9.57091302e-02f, -1.05201550e-01f,
  1.87065452e-02f, -1.54913431e-02f, -7.05981255e-02f, -9.96267274e-02f, -1.04042813e-01f, -2.33327318e-02f, 5.26597761e-02f, 7.95854107e-02f, 1.00738190e-01f, 1.11518733e-01f,
  2.73079187e-01f, -1.83111557e-03f, 2.24145368e-01f, 3.12430691e-02f, 8.58098343e-02f, 2.28294641e-01f, 7.03602955e-02f, 5.48147187e-02f, 1.24585919e-01f, 1.45700097e-01f,
  -5.67701086e-02f, -6.70782849e-02f, -2.91556828e-02f, 1.56377465e-01f, -7.57623240e-02f, -5.79102002e-02f, -4.71036881e-02f, 1.60929129e-01f, 1.12994820e-01f, -6.47263825e-02f,
  2.10631430e-01f, -2.90348291e-01f, -8.81932899e-02f, -2.35540569e-02f, 1.04598187e-01f, 1.35972351e-01f, -5.65492809e-02f, -3.92790399e-02f, -1.09874852e-01f, 7.47845322e-02f,
  -7.93876350e-02f, 2.44348526e-01f, 2.55556822e-01f, -1.10585310e-01f, 9.57265347e-02f, 6.49251193e-02f, 1.49623957e-02f, 1.02433778e-01f, 2.97383547e-01f, 2.19293267e-01f,
  2.45411202e-01f, 1.40189186e-01f, 2.76092254e-02f, 1.29636437e-01f, -2.65778959e-01f, -6.71594515e-02f, 1.39576957e-01f, 6.40597567e-02f, -7.87379667e-02f, -3.25751230e-02f,
  3.00995946e-01f, 1.24932133e-01f, 6.03523478e-02f, -3.15096490e-02f, 5.00759017e-03f, -2.70500451e-01f, 2.40523100e-01f, -1.00405917e-01f, -7.07550123e-02f, 1.89969927e-01f,
  1.69589937e-01f, -6.97128847e-02f, -8.49058032e-02f, -4.86622676e-02f, -2.37349823e-01f, -4.29762192e-02f, -3.93248387e-02f, 4.83906753e-02f, 5.02260663e-02f, 6.55959696e-02f,
  2.42467206e-02f, -2.35051103e-03f, 1.03387609e-01f, 1.42678218e-02f, 1.53642401e-01f, -1.46439373e-01f, -1.98311925e-01f, 8.87549147e-02f, 1.43357947e-01f, -3.94101478e-02f,
  5.86415343e-02f, -1.74805969e-01f, -9.71417055e-02f, 8.83072913e-02f, -3.52230519e-02f, 2.81949550e-01f, -1.17077411e-03f, 1.60902500e-01f, 6.93047494e-02f, -2.86823623e-02f,
  1.00270018e-01f, 1.02248732e-02f, 1.94718286e-01f, 2.18281955e-01f, 2.76492029e-01f, -2.95437500e-02f, -7.27972835e-02f, 1.08273216e-02f, 7.90698528e-02f, -8.23173150e-02f,
  1.89607427e-01f, 5.79203032e-02f, -6.81297183e-02f, 1.03928022e-01f, -2.29436513e-02f, 6.64118156e-02f, 9.35966298e-02f, -6.27248287e-02f, 3.69989753e-01f, 1.31921319e-03f,
  1.08082004e-01f, -1.26191139e-01f, 1.84887975e-01f, 1.85463559e-02f, -1.05290003e-01f, -5.54288831e-03f, 1.14536814e-01f, 7.07891658e-02f, 2.36402854e-01f, 2.20230281e-01f,
  -3.06116305e-02f, 8.76565352e-02f, 6.88874209e-03f, -2.39724610e-02f, -6.07489347e-02f, 2.80657485e-02f, -4.94636856e-02f, -3.24388742e-02f, 1.25403643e-01f, -9.08201933e-02f,
  -4.43332799e-04f, -6.80230930e-02f, -7.65227377e-02f, 1.94533411e-02f, 1.09848380e-01f, 1.16334334e-01f, 1.51268423e-01f, 1.72150418e-01f, 1.09715797e-01f, -1.83624938e-01f,
  1.59777384e-02f, -9.70359519e-02f, 2.18260050e-01f, 6.22179098e-02f, -1.67540535e-01f, -6.66020066e-02f, -7.04401657e-02f, 1.99289531e-01f, -7.07880259e-02f, 7.58326501e-02f,
  -8.31654593e-02f, 2.16028616e-02f, -1.26762539e-01f, -7.99982250e-02f, 4.27718200e-02f, 1.87558413e-01f, 1.67868048e-01f, 1.19411796e-02f, 1.04077123e-01f, 1.39095634e-01f,
  -8.06004927e-02f, 1.01554766e-01f, -7.27767721e-02f, -8.97021517e-02f, -3.53686104e-04f, -1.29587427e-01f, 4.84229624e-02f, 1.99990086e-02f, -8.87114778e-02f, 7.25162551e-02f,
  1.86272472e-01f, -3.75787280e-02f, 2.67211199e-01f, -1.17487960e-01f, -4.15901728e-02f, 1.43958390e-01f, 1.89977273e-01f, 2.04100743e-01f, -2.70910021e-02f, 3.55465934e-02f,
  -9.56896767e-02f, 3.43625024e-02f, 1.60437331e-01f, 1.78051576e-01f, -1.24885574e-01f, -3.18350904e-02f, 7.75527135e-02f, 1.85892880e-01f, 1.30718410e-01f, 2.49314196e-02f,
  6.82415813e-02f, -1.58814657e-02f, -7.38194883e-02f, 2.16310233e-01f, 1.19406141e-01f, 1.63464278e-01f, 2.14347795e-01f, 1.14542119e-01f, 1.26843199e-01f, 1.08603701e-01f,
  4.07683365e-02f, 2.77816635e-02f, -3.82764861e-02f, 1.70930788e-01f, -3.79297584e-02f, 1.61680579e-01f, 4.96377386e-02f, -6.60080835e-02f, -3.46716959e-03f, 1.21768579e-01f,
  -7.17494171e-03f, -2.08333105e-01f, 1.63573641e-02f, 1.39865801e-01f, 8.52148328e-03f, 2.06051588e-01f, 2.79359311e-01f, -3.32327671e-02f, 1.33479573e-02f, -1.20747566e-01f,
  -9.12936479e-02f, 1.29143357e-01f, 1.91690736e-02f, -7.12599233e-02f, 2.18069311e-02f, -8.78975019e-02f, 3.94932851e-02f, -9.40961987e-02f, 5.10984585e-02f, 1.03617616e-01f,
  -3.46458554e-02f, 1.72873214e-01f, 3.04349065e-02f, -6.16670214e-03f, 1.17348749e-02f, -7.31846550e-03f, 2.50937164e-01f, 1.24578573e-01f, 1.18486919e-01f, -1.31629840e-01f,
  1.60756364e-01f, -1.60604402e-01f, -6.01255372e-02f, 1.45205334e-01f, 9.00153518e-02f, 8.02719221e-03f, -2.68654968e-03f, 6.22943006e-02f, 1.62340820e-01f, -8.21868249e-04f,
  -6.04105229e-03f, 5.57670444e-02f, -7.66584883e-03f, -1.00254565e-01f, 9.62683707e-02f, 8.91460851e-02f, -8.76316652e-02f, 2.50869952e-02f, 3.55385430e-02f, 1.17673568e-01f,
  1.86618343e-02f, 6.74776509e-02f, -5.40488027e-03f, 1.88317299e-02f, 1.19906574e-01f, -3.84343714e-02f, 1.06090300e-01f, -1.42540619e-01f, 6.09712768e-03f, 1.06997816e-02f,
  1.86799958e-01f, 1.18432127e-01f, -2.38460265e-02f, 2.88729556e-02f, -3.29862610e-02f, 1.91413760e-01f, 2.31990907e-02f, -3.65284532e-02f, 6.83910400e-02f, -3.89528722e-02f,
  -1.74330354e-01f, -8.00068751e-02f, -7.23762903e-03f, -3.32753174e-02f, 7.83932880e-02f, -1.40367225e-01f, -1.04432903e-01f, -8.65735263e-02f, -3.39132063e-02f, 3.03653833e-02f,
  -5.90972267e-02f, 8.07233378e-02f, 5.71900159e-02f, -2.02252138e-02f, -1.56178832e-01f, 5.73505685e-02f, -4.48062122e-02f, 9.12884437e-03f, 8.58465955e-02f, -1.75166994e-01f,
  8.52527544e-02f, -7.23556429e-03f, -1.63088202e-01f, 1.15413323e-01f, -1.37171507e-01f, 2.58328706e-01f, 1.01897687e-01f, -1.15803191e-02f, -1.76033229e-01f, 5.38473800e-02f,
  9.86275077e-02f, 1.55705348e-01f, -2.14705020e-02f, 9.09958929e-02f, -7.15243742e-02f, -1.10214561e-01f, 1.46785975e-01f, -4.85794023e-02f, 5.11454232e-02f, -9.55237374e-02f,
  1.32812262e-01f, -1.21563867e-01f, 1.36087373e-01f, -6.73530623e-02f, -1.35129377e-01f, 1.47872970e-01f, -3.55305374e-02f, 8.41700956e-02f, 1.56525075e-01f, 2.09926069e-02f,
  1.38360783e-01f, -2.48548836e-01f, 6.49103746e-02f, -4.57283966e-02f, 2.55273022e-02f, 9.79348868e-02f, -1.19092606e-01f, -1.64826095e-01f, 3.34666390e-03f, 1.04402818e-01f,
  -1.19807862e-01f, -1.70156091e-01f, -6.37511089e-02f, -1.37897516e-02f, -1.42233474e-02f, 1.94461234e-02f, 7.62292296e-02f, 1.49702772e-01f, 5.39344735e-03f, 1.44365028e-01f,
  -1.54637471e-01f, 3.21152504e-03f, -9.44284126e-02f, 3.67064290e-02f, 1.63850859e-01f, 1.76916167e-01f, -6.22044988e-02f, 5.59227392e-02f, 2.28531584e-02f, -1.36288136e-01f,
  1.67640224e-02f, -7.30773285e-02f, 1.62226945e-01f, -1.10441118e-01f, 3.66343483e-02f, 1.13475926e-01f, 4.68180589e-02f, 3.34182382e-02f, -1.36195347e-01f, 1.66675776e-01f,
  -1.37778163e-01f, 1.24041684e-01f, -1.67330652e-01f, 7.85194412e-02f, -9.75956302e-03f, -3.38994116e-02f, -3.89145426e-02f, -6.84200041e-03f, -1.21155724e-01f, 1.41444877e-01f,
  1.24070413e-01f, 4.97905649e-02f, 4.02681231e-02f, -2.69707553e-02f, -1.03738196e-01f, -1.35882080e-01f, 1.81106161e-02f, -1.59244239e-02f, -5.39746992e-02f, -5.13697453e-02f,
  3.15278731e-02f, -6.19980916e-02f, 3.09083164e-02f, -3.59163135e-02f, -7.34668970e-02f, 1.00112990e-01f, -4.36487608e-02f, 5.98116294e-02f, -2.96942443e-02f, -3.29675935e-02f,
  1.02502525e-01f, -9.30414796e-02f, 1.59070231e-02f, 1.53817097e-02f, 1.18121821e-02f, 9.46050286e-02f, 4.42511477e-02f, -6.12227097e-02f, 6.32338449e-02f, -6.81448579e-02f,
  -4.83307391e-02f, 7.44096041e-02f, -3.12810726e-02f, -2.77545825e-02f, -1.10665143e-01f, -1.15909472e-01f, -2.68493760e-02f, 8.99712518e-02f, 2.40032226e-02f, 1.30950138e-01f,
  -8.77197925e-03f, 1.30190542e-02f, -4.26959321e-02f, -8.88814256e-02f, 4.49640490e-02f, 2.34845541e-02f, -1.75169203e-02f, 8.28488320e-02f, 2.30780095e-02f, -5.00365859e-03f,
  1.00914039e-01f, -4.73928750e-02f, 6.15721829e-02f, 6.69584870e-02f, 9.43484679e-02f, -1.01031505e-01f, 8.15108493e-02f, 8.98588374e-02f, 6.06029592e-02f, -1.20644793e-02f,
  -1.11432262e-01f, 1.01139247e-01f, -6.85907826e-02f, 4.92081000e-03f, -1.02826618e-01f, 8.87910426e-02f, -2.95963828e-02f, 8.29506293e-02f, 1.91406962e-02f, -7.52192289e-02f,
  -8.20832402e-02f, 4.48389677e-03f, 1.91605929e-02f, -1.02400072e-01f, 4.30398248e-02f, 1.22680686e-01f, 1.20876014e-01f, 1.66927829e-01f, 1.78844228e-01f, -2.39293948e-01f,
  -1.82663098e-01f, -1.98594809e-01f, 2.62141794e-01f, 2.04738975e-01f, -2.89549772e-02f, -2.40671143e-01f, -5.54991812e-02f, 1.98853523e-01f, -6.91987947e-02f, 1.62934989e-01f,
  4.80816066e-02f, 2.94820988e-04f, -1.41469821e-01f, -4.06379113e-03f, -1.21901967e-02f, 8.10800493e-02f, 2.91363209e-01f, 2.60172367e-01f, 2.19542325e-01f, 2.63803657e-02f,
  9.70576108e-02f, 4.70600352e-02f, 2.96543166e-02f, 1.15115143e-01f, 1.82050064e-01f, 2.03052000e-03f, -9.00419950e-02f, -8.46752152e-02f, 1.17921010e-01f, -1.96072627e-02f,
  1.87727422e-01f, -5.47897220e-02f, 2.98767835e-01f, 9.60065424e-02f, 8.98443311e-02f, -8.77468102e-03f, 1.96382806e-01f, 2.19566479e-01f, -7.29720816e-02f, 1.94644108e-01f,
  -1.41275883e-01f, 7.37029314e-02f, 1.53250635e-01f, 2.45080113e-01f, 1.22245185e-01f, -1.03378870e-01f, -7.11754849e-03f, 1.30338848e-01f, -1.49987070e-02f, 3.45947109e-02f,
  -7.18561858e-02f, -8.81217867e-02f, -1.02331005e-01f, -1.23154618e-01f, 8.24119076e-02f, -7.05822781e-02f, -1.12395555e-01f, -8.53550620e-03f, 6.36441633e-02f, 5.63299693e-02f,
  -6.93106204e-02f, -7.85809234e-02f, -6.28555194e-02f, -5.43406941e-02f, -2.54060738e-02f, -4.79319841e-02f, 6.76762313e-02f, 2.04170011e-02f, -3.13988142e-02f, 1.02723978e-01f,
  -9.69765410e-02f, -1.24163248e-01f, 3.88416573e-02f, 2.46504359e-02f, -1.10151060e-01f, -5.40662110e-02f, -1.00943685e-01f, -1.03312269e-01f, 3.89645323e-02f, -3.82590108e-02f,
  1.14196688e-01f, -9.40375924e-02f, -5.98663948e-02f, 1.13763995e-01f, 9.08643976e-02f, 1.14701591e-01f, -7.71082640e-02f, 4.11606692e-02f, -9.30448472e-02f, 2.89626326e-02f,
  4.05222736e-02f, -8.91321376e-02f, 1.93690881e-02f, 8.02955404e-02f, -2.43799686e-02f, -9.99504030e-02f, -1.06373906e-01f, -6.41652644e-02f, -3.10520604e-02f, -1.23138905e-01f,
  1.03455447e-01f, -1.21762745e-01f, 2.52180304e-02f, -5.58937900e-02f, 8.78596827e-02f, 8.06054939e-03f, 1.20735228e-01f, -5.80464005e-02f, -4.22545969e-02f, 5.06664664e-02f,
  -7.54636824e-02f, 1.03928253e-01f, 7.66308382e-02f, 5.02326488e-02f, 6.17466047e-02f, -6.22166321e-02f, 1.78393275e-01f, 4.03945409e-02f, 9.53698233e-02f, 1.47009715e-01f,
  -1.32760167e-01f, 1.81270331e-01f, 1.03470199e-01f, 4.93179671e-02f, 1.60788104e-01f, 4.93131243e-02f, -1.00739219e-03f, -6.87334910e-02f, 2.73104608e-02f, -1.28119262e-02f,
  1.09515414e-01f, 2.05018427e-02f, -1.09913677e-01f, 1.57327577e-01f, 4.80733812e-03f, 2.02237919e-01f, -4.27867845e-02f, -1.53051168e-01f, 3.36422548e-02f, -5.33185787e-02f,
  -6.88726753e-02f, 1.91266716e-01f, 3.59064434e-03f, 1.23267390e-01f, 3.18074562e-02f, -5.55442497e-02f, 6.83479235e-02f, 1.15851231e-01f, -5.08366935e-02f, -7.97846317e-02f,
  1.26597106e-01f, -1.26048297e-01f, -1.50445327e-01f, -2.02910807e-02f, 2.18918964e-01f, -9.25911590e-03f, 6.79719597e-02f, 8.82270858e-02f, -1.27070685e-04f, -6.15236200e-02f,
  -5.83392605e-02f, 2.42783036e-02f, 2.27588892e-01f, 2.61309803e-01f, 8.02267641e-02f, 2.20413245e-02f, 7.47188926e-02f, 1.14175655e-01f, -4.46009934e-02f, -1.66042317e-02f,
  1.45399883e-01f, 2.80179679e-02f, 2.69109965e-03f, 8.46860483e-02f, 2.93442421e-02f, 1.44109979e-01f, 1.35941446e-01f, 4.51007411e-02f, -5.09750210e-02f, 1.19032077e-01f,
  -6.78639710e-02f, -1.89387649e-02f, -3.86801083e-03f, 9.94797200e-02f, 1.34512708e-01f, 1.87570170e-01f, 1.16242811e-01f, -2.72955354e-02f, 1.58593208e-01f, 7.62071609e-02f,
  4.45634313e-02f, 9.83849168e-03f, 4.37708944e-02f, -2.12534696e-01f, 1.45817846e-01f, 1.06255174e-01f, -1.32467330e-01f, -1.13467909e-01f, -2.73738772e-01f, 9.80256498e-02f,
  6.30793422e-02f, 2.06088126e-01f, -2.19666865e-02f, -1.91768557e-02f, -2.21771240e-01f, -1.10098690e-01f, -6.04785196e-02f, -1.65654961e-02f, 1.61000744e-01f, 1.28340172e-02f,
  5.49259176e-03f, 1.29820704e-01f, -3.16749699e-02f, 1.23828147e-02f, 4.28887233e-02f, 1.09964110e-01f, -8.04243311e-02f, 1.21259220e-01f, -1.26949642e-02f, 1.82905734e-01f,
  -4.03552875e-02f, -9.58293825e-02f, 1.23122588e-01f, -1.35226071e-01f, 1.85184613e-01f, 2.00200770e-02f, -7.82053173e-02f, 4.75563928e-02f, 8.26308429e-02f, 1.96371764e-01f,
  8.49053562e-02f, -1.69588909e-01f, 8.45749155e-02f, -6.91027641e-02f, 7.10365474e-02f, 7.23796040e-02f, -9.02520046e-02f, 7.44562224e-02f, -2.02308297e-02f, -1.79816231e-01f,
  1.36911660e-01f, 2.68266983e-02f, 1.48576602e-01f, -6.81836307e-02f, 1.24836311e-01f, 1.20041579e-01f, 9.08623487e-02f, 6.85156276e-03f, 7.94128142e-03f, 1.54202785e-02f,
  -1.57345068e-02f, -1.14075772e-01f, 1.56421453e-01f, 1.71207204e-01f, -6.71167225e-02f, -4.63128574e-02f, 1.37921032e-02f, -1.02708057e-01f, -5.07255346e-02f, 8.64513516e-02f,
  2.57226322e-02f, -6.31664470e-02f, 3.22555751e-02f, -1.17717674e-02f, -7.70163462e-02f, -9.65470225e-02f, 7.37398937e-02f, 6.90681860e-02f, 1.79800048e-01f, -1.22090064e-01f,
  -3.12334150e-02f, 1.28657939e-02f, 5.61809763e-02f, 3.61158289e-02f, 2.85717119e-02f, 2.25424785e-02f, 3.97284143e-02f, 1.54656414e-02f, 8.32218900e-02f, 1.56444013e-01f,
  1.10830300e-01f, 3.71426940e-02f, -1.28999799e-01f, -1.69809863e-01f, 1.34963930e-01f, 8.31598043e-02f, 1.16885565e-01f, -1.03376038e-01f, -1.10617042e-01f, -1.91268176e-04f,
  9.86436754e-02f, -1.66941732e-02f, -7.79013038e-02f, 1.15249202e-01f, -9.04382989e-02f, 1.51328132e-01f, -3.72066535e-02f, 4.36655134e-02f, -9.08719897e-02f, -1.67513266e-02f,
  -1.30824335e-02f, -6.12093508e-02f, 1.04523167e-01f, 6.00520559e-02f, 1.40598997e-01f, 8.34991708e-02f, -6.23425692e-02f, -1.25764251e-01f, -4.07001674e-02f, -6.14945218e-02f,
  3.89596410e-02f, -1.42386198e-01f, 1.82030499e-02f, -1.48872241e-01f, 9.20333248e-03f, -1.34234682e-01f, 4.62656133e-02f, 6.49101706e-03f, 1.00468546e-01f, -1.06517762e-01f,
  -9.51573104e-02f, -6.83003440e-02f, -8.56772214e-02f, 1.42612129e-01f, 1.17794298e-01f, -8.86605307e-02f, 3.70746255e-02f, 1.10760398e-01f, -6.38587251e-02f, 6.69370368e-02f,
  -9.47704986e-02f, -8.78605153e-03f, 1.83671370e-01f, 1.38404146e-01f, 4.50967886e-02f, 1.19176554e-02f, -5.07861078e-02f, 1.48279980e-01f, -5.07656112e-02f, 6.90699443e-02f,
  -3.74093652e-02f, 5.47797047e-02f, 1.45419255e-01f, -3.23391818e-02f, 1.70306722e-03f, -1.12737633e-01f, 1.66606143e-01f, 2.28727814e-02f, 1.77443758e-01f, -4.31812108e-02f,
  1.44522220e-01f, -2.95776296e-02f, -1.14029348e-02f, 1.14940248e-01f, 1.13767624e-01f, -5.69879077e-02f, 1.57125309e-01f, -8.41154978e-02f, -1.33157462e-01f, 1.62663400e-01f,
  -6.71253353e-02f, 1.09994346e-02f, 1.85503900e-01f, 5.79805113e-03f, 1.03755876e-01f, -1.13515794e-01f, -6.25607818e-02f, 4.86743301e-02f, -6.39859885e-02f, -1.22860871e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  1.11961225e-02f, 9.48794782e-02f, 9.84802321e-02f, -1.19942844e-01f, 4.62075993e-02f, 1.57533996e-02f, 1.76603034e-01f, -2.19954969e-03f, 4.57417518e-02f, -9.72265657e-03f,
  -8.35071355e-02f, 1.16636083e-02f, -3.49771343e-02f, 3.10118478e-02f, -9.81121883e-02f, 4.56538238e-02f, 1.78016752e-01f, 1.03010029e-01f, -3.29261646e-02f, -3.31945084e-02f,
  3.48190474e-03f, -1.16373729e-02f, 5.71597889e-02f, -2.51206774e-02f, -4.96665612e-02f, 1.71854749e-01f, -1.49532855e-02f, 1.90058917e-01f, -1.20501250e-01f, 4.66301776e-02f,
  -1.87192969e-02f, 4.54492867e-02f, -4.78656823e-03f, 1.11297324e-01f, 8.19582492e-02f, 1.04473360e-01f, -7.40076229e-02f, -6.13062829e-02f, 1.59625560e-01f, 2.59521436e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.62065417e-01f, -4.66853417e-02f, -6.93195090e-02f, -8.22973177e-02f, -3.52712750e-01f, 1.50785241e-02f, -9.70011577e-02f, -2.06189603e-01f, -2.59091854e-01f, -9.21546221e-02f,
  -1.19308978e-02f, -1.88517272e-01f, 8.22921544e-02f, -2.19253451e-01f, -3.04058939e-01f, 2.91309814e-04f, -1.65870458e-01f, -3.04728001e-01f, 1.45189434e-01f, 1.61819026e-01f,
  -1.38823867e-01f, 1.34531528e-01f, 3.15149784e-01f, -1.30966946e-01f, 1.22213922e-02f, -4.32281196e-02f, -8.08139816e-02f, -5.19250408e-02f, -1.53827518e-01f, 5.57615995e-01f,
  1.88214274e-03f, -1.12454273e-01f, 1.46918427e-02f, -6.98055625e-02f, -1.60928797e-02f, -2.01786712e-01f, -2.79656202e-01f, 1.67523891e-01f, 2.41126180e-01f, -6.97709993e-02f,
  -3.28336596e-01f, 8.13715011e-02f, -3.33042830e-01f, 8.00085142e-02f, 2.79983163e-01f, 4.98474538e-01f, -3.68577242e-02f, 6.49905503e-02f, -4.31305096e-02f, -2.40288109e-01f,
  1.59187555e-01f, -3.21901977e-01f, 1.93473831e-01f, -1.74064375e-02f, 1.53421745e-01f, -1.70981750e-01f, -8.16220045e-03f, 8.38541314e-02f, -2.44343475e-01f, -9.28909332e-02f,
  -4.75293323e-02f, 7.54909888e-02f, 6.81562396e-03f, -8.75053182e-02f, 3.21109533e-01f, -2.50638783e-01f, 2.90235579e-02f, -1.97900325e-01f, -6.42616227e-02f, -3.33009094e-01f,
  1.07722832e-02f, -3.86316217e-02f, 3.04848820e-01f, 1.87094897e-01f, 6.65448904e-02f, -5.66833094e-02f, 3.34429979e-01f, -1.01704068e-01f, -2.53207147e-01f, -1.99440807e-01f,
  -3.96005929e-01f, -1.93506733e-01f, 8.79703909e-02f, 9.38171223e-02f, -1.11951157e-01f, -1.10756099e-01f, -3.96184027e-01f, -2.48848796e-01f, 7.14407302e-03f, 9.26463492e-03f,
  -1.02642179e-01f, 2.14940235e-02f, -1.15602426e-01f, 5.09881258e-01f, 7.42044374e-02f, 1.93692237e-01f, -7.73707181e-02f, -2.29358792e-01f, 5.39759174e-02f, 5.10809608e-02f,
  -1.67309329e-01f, 3.53133261e-01f, -4.05843742e-02f, 1.21291742e-01f, -3.47443640e-01f, 1.18444294e-01f, 3.90936472e-02f, -1.14393547e-01f, 1.41461626e-01f, 3.56051326e-01f,
  6.45675883e-02f, -2.41169538e-02f, -2.59750485e-02f, 3.24509591e-02f, 2.26800144e-02f, 4.00661528e-01f, -2.52756953e-01f, -4.15531456e-01f, 1.13423318e-01f, -6.81153089e-02f,
  -4.94969524e-02f, 1.81739684e-02f, -4.84030098e-01f, -7.59150237e-02f, -2.30503939e-02f, -3.73979986e-01f, -1.49592593e-01f, -2.23971028e-02f, 3.29631746e-01f, 1.91153169e-01f,
  9.81022194e-02f, -9.88746956e-02f, 1.87342212e-01f, 4.18295804e-03f, 1.74185991e-01f, 2.23720655e-01f, 2.13315606e-01f, 2.00268686e-01f, -1.39542162e-01f, 2.23242983e-01f,
  -1.49350449e-01f, -3.43304962e-01f, 1.41184747e-01f, -3.15472245e-01f, 3.30238491e-01f, -2.44918734e-01f, 3.09993446e-01f, 3.17517936e-01f, 2.80703366e-01f, -2.47838974e-01f,
  -1.95691332e-01f, -3.58111821e-02f, 2.17338994e-01f, -2.63812523e-02f, -2.74011493e-03f, -2.86246883e-03f, 2.18371555e-01f, -2.59202212e-01f, -2.00304121e-01f, 1.49191752e-01f,
  -4.77550775e-02f, -1.60850346e-01f, -4.86785248e-02f, -1.45685345e-01f, 2.01671392e-01f, 2.90831625e-01f, -6.79772198e-02f, 6.79903552e-02f, -1.59555763e-01f, -4.95512912e-04f,
  2.49956697e-01f, 8.40329826e-02f, -2.81269789e-01f, -2.47912556e-01f, 8.61051381e-02f, 1.30159212e-02f, -1.04679473e-01f, 4.65654314e-01f, -7.68464059e-02f, 4.70619023e-01f,
  -3.14036161e-01f, -2.96415478e-01f, 1.51287407e-01f, -1.37508228e-01f, -6.34296089e-02f, -5.90085275e-02f, -2.32530132e-01f, 1.00412846e-01f, 4.67958897e-02f, -1.20592982e-01f,
  1.41213402e-01f, 8.02693367e-02f, -1.45581588e-01f, -1.45617545e-01f, 1.44280925e-01f, 1.30749466e-02f, 1.32765114e-01f, -5.36022820e-02f, 1.54130356e-02f, 3.48452777e-01f,
  -2.16711938e-01f, -1.22743145e-01f, -3.04751635e-01f, 1.07379258e-01f, -3.26143056e-02f, 3.36766362e-01f, 1.66688636e-01f, 4.51116532e-01f, 2.90708784e-02f, 1.47569478e-01f,
  -1.42502546e-01f, -1.17891639e-01f, 3.12391110e-02f, -8.06973353e-02f, 1.75663009e-01f, -1.80986673e-01f, -3.88361156e-01f, -1.10762849e-01f, -1.20457321e-01f, -8.08073301e-03f,
  1.74729258e-01f, 2.17761308e-01f, -2.31748205e-02f, -1.43760622e-01f, -1.20071411e-01f, 2.06761330e-01f, -1.07921779e-01f, 1.78767860e-01f, 1.91892609e-01f, 5.44499457e-02f,
  3.41616832e-02f, -1.06403641e-01f, -7.44380876e-02f, 5.18199094e-02f, -1.79923773e-01f, 7.80924261e-02f, 4.62220818e-01f, 9.93131846e-02f, 2.06515700e-01f, -1.14780609e-02f,
  1.11832760e-01f, -4.50721949e-01f, -5.41459247e-02f, -5.21692336e-01f, 1.39056787e-01f, 3.97741375e-03f, -8.78063217e-02f, 2.74029702e-01f, -2.35517353e-01f, 3.23874205e-02f,
  1.02545373e-01f, 6.07396886e-02f, -1.03357948e-01f, 2.98321426e-01f, -1.98276550e-01f, -1.83979124e-01f, -1.35340825e-01f, 1.82179049e-01f, 5.33067212e-02f, -1.19472645e-01f,
  -2.10655667e-02f, -8.28700811e-02f, 2.31808648e-01f, -1.76975608e-01f, -1.30739853e-01f, -4.62160744e-02f, -1.93196803e-01f, 9.09833238e-02f, 1.11175314e-01f, 7.63057694e-02f,
  -1.86084747e-01f, -3.51109505e-01f, -2.13442579e-01f, 1.79775506e-01f, 4.33847234e-02f, 2.36297920e-01f, -2.40817994e-01f, 1.77158296e-01f, 2.94655740e-01f, 8.69990587e-02f,
  5.67294545e-02f, 1.80882514e-01f, -3.75055782e-02f, 3.43840122e-02f, -1.59053370e-01f, 2.07652196e-01f, 1.31464452e-01f, -6.48601353e-02f, 2.98881829e-02f, -3.65777425e-02f,
  -1.12535693e-01f, -2.49487549e-01f, -1.28761336e-01f, -1.35932624e-01f, -3.86443408e-03f, 2.84479093e-02f, 1.94977298e-01f, -1.21502757e-01f, -2.27146029e-01f, 6.52892143e-02f,
  -4.85987291e-02f, 2.74907351e-01f, 1.67015970e-01f, 2.22512502e-02f, -9.85018313e-02f, -4.88372482e-02f, 7.80769363e-02f, -2.49406919e-01f, 2.66635329e-01f, 2.93957919e-01f,
  -1.06578484e-01f, 9.52077359e-02f, -1.40565131e-02f, 7.37593845e-02f, 2.75487095e-01f, -9.83940065e-02f, 9.38314497e-02f, 1.31500795e-01f, -2.61537224e-01f, 5.21093123e-02f,
  -1.68275803e-01f, 3.14370655e-02f, 1.68159723e-01f, -1.08448729e-01f, 1.21258251e-01f, 3.11755478e-01f, -1.40630305e-01f, -6.51564524e-02f, 1.44754782e-01f, 2.04159990e-01f,
  1.63600504e-01f, 1.99197024e-01f, -2.06450865e-01f, -3.18807065e-01f, 2.20257416e-01f, -6.98878914e-02f, -9.37737152e-02f, -1.43078759e-01f, 1.65878937e-01f, -1.37220845e-01f,
  -7.56479204e-02f, -2.02207100e-02f, 2.53708325e-02f, -2.17690438e-01f, 3.28008622e-01f, 2.82691307e-02f, -1.23096481e-01f, -6.39317930e-02f, -2.16429010e-01f, 1.67111143e-01f,
  2.89257675e-01f, -1.29936054e-01f, -2.48991419e-02f, -2.99943686e-01f, 3.24690491e-02f, -3.58058438e-02f, 3.97057012e-02f, -6.44115778e-03f, 2.73022577e-02f, -4.83484715e-02f,
  3.27438861e-01f, -1.59151793e-01f, -1.34861380e-01f, -1.18839905e-01f, -2.53050048e-02f, 4.96510446e-01f, -1.65046751e-01f, -7.75467530e-02f, 1.15532644e-01f, 1.18514843e-01f,
  5.16320355e-02f, 1.28993288e-01f, -3.07937473e-01f, 1.23515271e-01f, -2.07036901e-02f, -6.71344250e-02f, -2.26444781e-01f, -3.72864939e-02f, -1.81853831e-01f, -1.83999464e-02f,
  3.41268361e-01f, -2.98156273e-02f, -1.22611985e-01f, -9.59889740e-02f, -1.74096957e-01f, 1.10891685e-01f, -1.43519402e-01f, -2.30005354e-01f, -1.19637847e-01f, 3.00030857e-02f,
  -4.95989025e-02f, -3.79662842e-01f, -4.44943123e-02f, 6.51430199e-03f, -1.55744761e-01f, 1.60272822e-01f, -8.70788768e-02f, -8.63358527e-02f, 2.88607031e-01f, -1.07917547e-01f,
  3.02241035e-02f, 1.64910585e-01f, 2.83448339e-01f, -2.06809603e-02f, 3.25216800e-01f, -4.24638957e-01f, -2.48091608e-01f, 2.32638001e-01f, 2.19541132e-01f, 1.76203147e-01f,
  7.75580555e-02f, 6.34261221e-02f, -1.53063655e-01f, -4.86343175e-01f, 4.05116640e-02f, -1.83808252e-01f, 1.98308110e-01f, -3.87225658e-01f, -2.71690995e-01f, -8.26208740e-02f,
  -3.40165347e-02f, -1.04993455e-01f, -1.17204450e-02f, -1.36637703e-01f, 5.35206974e-01f, -1.74593389e-01f, -3.84445898e-02f, 2.62831524e-02f, -4.42579478e-01f, -8.52083415e-03f,
  -1.74391568e-01f, 8.80628526e-02f, 1.34446612e-02f, 2.41726801e-01f, 1.34844467e-01f, 3.82007569e-01f, -3.66912752e-01f, -6.96202666e-02f, -2.61446387e-01f, 9.26045477e-02f,
  3.07149798e-01f, 1.17200807e-01f, -1.68446362e-01f, -6.67501837e-02f, 3.68541986e-01f, -2.15894543e-02f, 1.16351962e-01f, 7.58547485e-02f, -1.79347128e-01f, -1.87356025e-01f,
  -9.00354683e-02f, -1.01712132e-02f, -1.49680087e-02f, -2.01265320e-01f, -1.37517810e-01f, 6.38591051e-02f, -8.59275386e-02f, -2.72075564e-01f, -9.06476602e-02f, -1.84893176e-01f,
  2.73783095e-02f, 2.01184735e-01f, -2.24089965e-01f, 6.18687011e-02f, -2.07239166e-02f, 1.57176107e-01f, -2.40631863e-01f, -5.57404697e-01f, -1.22168481e-01f, 9.46177319e-02f,
  1.68086570e-02f, 3.78430009e-01f, -2.09577769e-01f, 1.21061742e-01f, -6.27820492e-02f, 1.64514575e-02f, -8.22825208e-02f, -3.07883322e-01f, -3.53980064e-01f, 1.74383968e-02f,
  -1.04777031e-01f, 3.63131613e-01f, 1.11515954e-01f, 6.86390474e-02f, 1.67080969e-01f, -8.86631459e-02f, -3.55902389e-02f, 1.23169392e-01f, -2.79755235e-01f, -8.77560452e-02f,
  -1.39478490e-01f, 8.53558555e-02f, -1.55203149e-01f, -3.30016583e-01f, 1.58949688e-01f, 9.03989822e-02f, 1.01923756e-01f, -1.29567578e-01f, 3.15902382e-02f, -2.79436111e-01f,
  4.64605242e-01f, 2.08498508e-01f, 1.99370727e-01f, -1.00041933e-01f, -5.47304824e-02f, -8.18252414e-02f, 4.58271295e-01f, 1.09225034e-03f, -1.38077810e-01f, -1.84806399e-02f,
  -1.11017734e-01f, 2.01512769e-01f, 3.06191653e-01f, 1.71177164e-02f, -1.44171761e-02f, 2.20127776e-01f, 1.51265144e-01f, -1.17037199e-01f, -1.57404188e-02f, 2.03833655e-01f,
  -9.01897177e-02f, 3.07576149e-03f, 1.57294810e-01f, 1.12684213e-01f, 3.15612376e-01f, 4.85343225e-02f, -3.36816162e-01f, 2.52176881e-01f, -1.81483239e-01f, -3.76902163e-01f,
  -3.70790362e-01f, -1.97329596e-01f, -2.33291298e-01f, 5.36211580e-02f, -1.61068156e-01f, -2.45638534e-01f, -3.18831116e-01f, -2.29310598e-02f, -9.87495705e-02f, 6.02017976e-02f,
  3.54982704e-01f, 3.34813148e-01f, -1.84355572e-01f, 2.75515407e-01f, -2.03104958e-01f, 4.32893157e-01f, 1.30212367e-01f, 1.19752571e-01f, 1.32965833e-01f, 2.31063321e-01f,
  -8.73187408e-02f, -8.85111988e-02f, -4.26146477e-01f, 1.94485143e-01f, 1.77097425e-01f, -1.09615803e-01f, 2.16767322e-02f, -3.64760965e-01f, -9.65215489e-02f, 2.41457820e-01f,
  1.02311485e-01f, -1.01702578e-01f, -3.98254134e-02f, -1.59290105e-01f, 9.69072953e-02f, -1.75738394e-01f, 1.74955070e-01f, -1.61320474e-02f, -9.83937010e-02f, 1.46958172e-01f,
  -5.16481213e-02f, 8.06071833e-02f, -3.92322212e-01f, -6.55266941e-02f, 8.88728723e-02f, -5.45700379e-02f, -4.25666757e-02f, -1.24080457e-01f, 1.66785643e-01f, -2.54016723e-02f,
  -6.80212826e-02f, -7.85304755e-02f, 2.22437218e-01f, 2.58477330e-02f, 1.36573225e-01f, 2.65145600e-01f, -8.34445134e-02f, -3.88062358e-01f, 1.24614470e-01f, 3.01755935e-01f,
  9.84203294e-02f, -2.48398304e-01f, 6.37907758e-02f, 2.39657357e-01f, -1.27659097e-01f, 2.29532897e-01f, 2.21529528e-01f, -1.53373390e-01f, -3.62209752e-02f, 1.52265206e-01f,
  4.12914380e-02f, 1.33415889e-02f, -6.61485493e-02f, 6.01937398e-02f, -1.09621517e-01f, -2.75695115e-01f, -1.15899555e-01f, -7.21470565e-02f, 3.17557715e-02f, 1.98962003e-01f,
  5.84935732e-02f, -8.67166668e-02f, -7.09654242e-02f, -5.80286607e-02f, -8.42723399e-02f, 4.45136167e-02f, 2.64460564e-01f, -4.11627302e-03f, -6.53726794e-03f, -2.66086236e-02f,
  -5.68657577e-01f, -3.27544004e-01f, -1.08516421e-02f, 6.22126535e-02f, -6.60234094e-02f, 2.91372329e-01f, -1.48822919e-01f, -1.15832001e-01f, -7.34958192e-03f, 2.35254154e-01f,
  -1.93183362e-01f, -2.32875682e-02f, 3.10126334e-01f, 3.79572213e-02f, 3.88108581e-01f, 3.10104992e-02f, 1.79572254e-01f, -1.93764791e-01f, 2.32478768e-01f, 3.77994448e-01f,
  -6.28579920e-03f, 2.74620146e-01f, 8.25530812e-02f, 3.34665418e-01f, 1.56862289e-01f, 3.50177139e-01f, 2.10493669e-01f, 3.53061289e-01f, 1.14448160e-01f, -2.50114083e-01f,
  1.07589446e-01f, 4.61670347e-02f, -3.47661346e-01f, 5.26762381e-02f, 1.69323102e-01f, 1.08045876e-01f, 2.74560392e-01f, 1.39498189e-01f, 2.04982072e-01f, -8.07942227e-02f,
  3.30036506e-03f, 1.76212624e-01f, -1.51663318e-01f, -1.19022608e-01f, 9.79926586e-02f, -2.21167937e-01f, 1.44112846e-02f, 1.20875455e-01f, -2.81996988e-02f, -1.05681017e-01f,
  -2.79855758e-01f, -1.31604657e-01f, -1.57594621e-01f, 7.60372058e-02f, 1.19939454e-01f, 1.60852134e-01f, 9.60088447e-02f, -7.83343241e-02f, -7.54490271e-02f, 6.25692010e-02f,
  6.15343377e-02f, 2.43645464e-03f, 2.57882953e-01f, -8.83773118e-02f, 5.01674473e-01f, -2.77353227e-01f, -8.39759931e-02f, -1.64676279e-01f, -5.98405488e-02f, 1.05060197e-01f,
  -2.81597301e-02f, 9.13211629e-02f, 4.84373644e-02f, 1.47374552e-02f, 3.86243403e-01f, -1.79822251e-01f, -2.27217823e-01f, -1.20384775e-01f, 1.54137328e-01f, 1.48165496e-02f,
  -4.77339588e-02f, 1.20913811e-01f, 9.09338295e-02f, -1.55813405e-02f, -2.03400910e-01f, -1.17754422e-01f, -1.98569506e-01f, 3.81106347e-01f, -1.05519496e-01f, -9.88244340e-02f,
  1.99276462e-01f, -1.08784415e-01f, 2.19445780e-01f, -3.90543826e-02f, 1.92196488e-01f, 1.38905466e-01f, 3.90754789e-02f, 2.91015983e-01f, 3.85336012e-01f, 4.40646335e-02f,
  2.41612390e-01f, 2.74201035e-01f, -1.77143484e-01f, 2.81798065e-01f, 2.72195805e-02f, 1.30931124e-01f, 2.29955658e-01f, 3.08963835e-01f, 3.15135866e-02f, 5.76703027e-02f,
  -1.14991777e-01f, -7.98958912e-02f, 1.30992740e-01f, -3.75810742e-01f, 1.17743202e-01f, -1.46527812e-01f, -8.12433884e-02f, -1.04709193e-01f, 5.86734340e-03f, 2.24438488e-01f,
  1.00665860e-01f, -9.17462930e-02f, -1.19695105e-01f, -5.84073290e-02f, 3.84655416e-01f, -1.98293194e-01f, 2.77853787e-01f, -5.45632914e-02f, -3.75620723e-02f, -1.20890789e-01f,
  -6.51594698e-02f, -4.46481742e-02f, 8.95332992e-02f, -1.40409470e-01f, 8.21176544e-03f, -2.12763935e-01f, -4.95125018e-02f, 3.30986351e-01f, -3.27603489e-01f, 3.96998465e-01f,
  2.86306798e-01f, 3.06596644e-02f, 2.92557985e-01f, 8.03833380e-02f, -3.26120332e-02f, 4.24908727e-01f, 1.89300492e-01f, -1.53376430e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.05895840e-01f, 1.54470503e-01f, 7.71284923e-02f, 4.38768305e-02f, 3.64465229e-02f, -1.01148985e-01f, 3.23990844e-02f, -9.48361680e-03f, 1.69314489e-01f, -1.49039879e-01f,
  1.02835380e-01f, 1.08372927e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    