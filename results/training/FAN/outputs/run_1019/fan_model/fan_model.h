/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.75653392e-01f, 3.89441252e-01f, 1.02893695e-01f, -2.64607202e-02f, -1.52760774e-01f, -8.26974586e-02f, 3.16342078e-02f, 7.95001686e-02f, -1.33394539e-01f, -1.50258234e-02f,
  -1.87813610e-01f, -2.41820812e-01f, -1.59271508e-01f, -1.63178608e-01f, 3.04002054e-02f, 1.61157668e-01f, 2.33508989e-01f, 6.29264116e-02f, -1.39231995e-01f, -3.42061251e-01f,
  -5.84646538e-02f, 1.45476341e-01f, 1.38337910e-01f, 4.37856093e-02f, 1.19852632e-01f, -1.17423140e-01f, 3.14729273e-01f, 1.74155101e-01f, 1.71479583e-01f, 3.09442043e-01f,
  -2.33997807e-01f, 1.23005860e-01f, -1.74562603e-01f, -2.36815512e-02f, 6.49012178e-02f, 5.16336262e-02f, -1.19600026e-02f, 5.60350530e-02f, -4.67330217e-02f, 7.46406540e-02f,
  6.05690889e-02f, 2.35959478e-02f, 3.78985554e-02f, 7.27728605e-02f, 8.69729668e-02f, -8.34068656e-02f, 1.55868068e-01f, 1.38685644e-01f, 1.30564779e-01f, 4.53831926e-02f,
  -1.07467845e-01f, 1.30127147e-01f, 7.31009096e-02f, 7.32741132e-02f, 1.29149422e-01f, 6.33448316e-03f, 9.81341824e-02f, 1.12852240e-02f, 1.48970857e-01f, 9.17718187e-02f,
  1.10056205e-02f, -9.14561898e-02f, 3.84063125e-02f, -2.96000466e-02f, -2.91565862e-02f, 3.82616594e-02f, 4.42423634e-02f, -5.54816052e-02f, 8.14366248e-03f, 4.87411842e-02f,
  2.36530192e-02f, 1.09252725e-02f, 1.79920364e-02f, 7.23431306e-03f, -9.70607176e-02f, 1.39221773e-02f, -3.13006877e-03f, 2.39836741e-02f, -8.11510235e-02f, 1.11512104e-02f,
  -1.06684864e-01f, -8.42590630e-02f, -3.23818773e-02f, -1.52533054e-02f, -3.83399837e-02f, -1.89215727e-02f, 2.49885675e-02f, -3.87852406e-03f, 7.46158790e-03f, -4.75004166e-02f,
  -2.24765703e-01f, 6.64382335e-03f, -8.88373703e-02f, -4.51432168e-02f, 3.43724750e-02f, -1.01654343e-02f, -7.01057985e-02f, -2.57436503e-02f, -8.15169960e-02f, -9.64179933e-02f,
  -4.94933687e-03f, 9.80801210e-02f, 7.76670948e-02f, 7.77683258e-02f, -6.58867210e-02f, -4.20127586e-02f, -3.29102278e-02f, -4.27062772e-02f, -3.37750241e-02f, -3.60683799e-02f,
  4.43265028e-02f, -1.08860254e-01f, -1.49216160e-01f, -9.64298695e-02f, -7.40042329e-02f, -2.05244809e-01f, -7.57758617e-02f, -3.89882885e-02f, -1.21937506e-01f, 1.22527659e-01f,
  -4.82265711e-01f, 1.15930706e-01f, -5.22008240e-01f, -4.64212522e-02f, 1.46348447e-01f, -8.72479826e-02f, -7.26715773e-02f, -1.38724193e-01f, 8.32142830e-02f, 6.64690062e-02f,
  1.24759458e-01f, 1.16391189e-01f, 4.66695204e-02f, -1.27022527e-03f, -1.55827537e-01f, 6.50209934e-02f, 7.08792359e-02f, -2.48654693e-01f, -2.80874848e-01f, -5.06988168e-03f,
  2.68651366e-01f, 6.64488897e-02f, -1.55772299e-01f, -3.74890901e-02f, 7.78440386e-02f, 1.71044394e-01f, -9.95348170e-02f, 4.72378060e-02f, 1.04077034e-01f, 2.00759798e-01f,
  -3.36620390e-01f, -2.51487523e-01f, 3.96397188e-02f, 1.99382305e-01f, 4.54123169e-02f, 8.39923974e-03f, -4.83666025e-02f, -9.26480293e-02f, 3.07054520e-02f, 6.85848668e-02f,
  1.28121808e-01f, 5.15361466e-02f, 9.89643708e-02f, 4.49354313e-02f, -1.13264911e-01f, -5.98113239e-02f, 6.71032071e-02f, -1.68595493e-01f, -1.05528437e-01f, -6.72345161e-02f,
  3.45076889e-01f, -1.60169583e-02f, -1.96824268e-01f, -7.75034958e-03f, 9.03537124e-02f, 1.38680875e-01f, -2.97340285e-02f, -9.69306193e-03f, -1.12681240e-01f, -6.74156984e-03f,
  1.10467695e-01f, 1.02175735e-01f, -3.10116354e-02f, -5.07145338e-02f, 8.11104402e-02f, 6.38744161e-02f, -1.15366355e-01f, -2.83395350e-02f, 3.25166471e-02f, -4.02576514e-02f,
  -6.14127144e-02f, -4.94964160e-02f, -1.61051899e-02f, -5.79258837e-02f, 7.28879198e-02f, 3.79299186e-02f, 6.10863827e-02f, 1.03210442e-01f, -1.54034477e-02f, 5.99577352e-02f,
  -1.01032397e-02f, -9.81725007e-03f, -1.03528515e-01f, -1.17441021e-01f, 3.29638496e-02f, 1.48626184e-02f, 7.44442344e-02f, 1.07179686e-01f, 5.86273186e-02f, 6.62463978e-02f,
  -7.63377398e-02f, 8.77274200e-02f, -5.37245795e-02f, 2.34599970e-02f, -2.63331439e-02f, 2.65589003e-02f, 3.81526537e-02f, 3.53105031e-02f, 2.79912446e-03f, -7.40607902e-02f,
  5.94688281e-02f, 4.33209771e-03f, -3.45969037e-03f, -1.74278952e-03f, -6.23567440e-02f, -4.80253957e-02f, 1.07225910e-01f, -5.75138815e-02f, 2.86941919e-02f, 9.09356102e-02f,
  1.72697052e-01f, 3.37459752e-03f, -1.15735680e-01f, -8.66227448e-02f, 5.38733862e-02f, -9.96058509e-02f, -1.52371556e-01f, -6.59129322e-02f, -1.52106091e-01f, -9.86193269e-02f,
  1.30493417e-01f, 1.31879449e-01f, 2.74944872e-01f, 1.79039061e-01f, 3.62000525e-01f, 2.98839927e-01f, 3.45743358e-01f, -7.34338444e-03f, 1.05680250e-01f, 1.58779919e-01f,
  1.30624935e-01f, 4.97996248e-03f, -1.03401043e-01f, -2.31404998e-03f, -1.94612648e-02f, 2.42589951e-01f, 2.68652558e-01f, 6.29772395e-02f, -1.14558659e-01f, 7.88679570e-02f,
  1.21606693e-01f, 8.41121152e-02f, -2.49706227e-02f, 2.54965294e-03f, 5.74736074e-02f, -1.10189700e-02f, 3.38307247e-02f, 8.61290321e-02f, 1.35013491e-01f, 3.00009817e-01f,
  2.37931743e-01f, 7.67748654e-02f, 1.02988379e-02f, -4.57423441e-02f, 1.11978076e-01f, -3.62431146e-02f, 1.36870705e-02f, -1.14195496e-01f, -5.37686646e-02f, -2.45559905e-02f,
  9.26754102e-02f, -3.02988123e-02f, -4.80914637e-02f, -5.37219942e-02f, -2.08551325e-02f, -8.09168816e-03f, -5.50830290e-02f, -9.25516412e-02f, -1.68110859e-02f, 7.32338205e-02f,
  9.03598815e-02f, 9.51464847e-02f, 5.87743744e-02f, 1.77704189e-02f, -1.19417801e-01f, -2.11199224e-02f, 3.62223051e-02f, -2.95881052e-02f, -5.38368933e-02f, -1.07790180e-01f,
  2.14650780e-02f, -4.91122454e-02f, -1.21309809e-01f, -5.51640615e-02f, -3.09863836e-02f, -1.66349113e-01f, -6.39073178e-02f, -9.40090865e-02f, -1.73756912e-01f, -8.56908560e-02f,
  -5.49098104e-02f, 4.27732170e-02f, -7.83446282e-02f, 4.94663157e-02f, -2.93871909e-02f, -5.70384450e-02f, 1.29990205e-02f, -2.43639462e-02f, -1.37310594e-01f, -5.29513843e-02f,
  -9.74017475e-03f, -9.09632295e-02f, -3.88092250e-02f, -1.25154138e-01f, 4.99237031e-02f, -4.05613594e-02f, -6.33463189e-02f, -1.70567129e-02f, -2.71866769e-02f, -7.37041757e-02f,
  -2.06689328e-01f, -1.05229683e-01f, -7.02334642e-02f, -1.05964176e-01f, -3.82517800e-02f, -1.34774819e-01f, -8.31995904e-02f, -8.26417729e-02f, 2.24576015e-02f, -9.61989239e-02f,
  -3.56558748e-02f, -9.71183926e-02f, -7.87055120e-02f, -9.65491012e-02f, -4.17505130e-02f, 1.64205208e-02f, 2.69125104e-02f, 2.08178815e-02f, -6.10849820e-02f, -7.79979602e-02f,
  1.39236180e-02f, -4.60465550e-02f, -1.70110583e-01f, -1.69354990e-01f, -8.97803679e-02f, -7.92559013e-02f, -1.37639791e-01f, -1.26588881e-01f, -1.44959673e-01f, -1.43973082e-01f,
  5.59971988e-01f, 4.36679810e-01f, 2.50032425e-01f, 3.14706415e-02f, -3.20198864e-01f, -3.25820684e-01f, 2.19054762e-02f, -5.47158755e-02f, -1.06461406e-01f, 2.73945421e-01f,
  1.47256017e-01f, -1.41625285e-01f, 9.07810107e-02f, -3.96833718e-02f, 1.22431684e-02f, 1.70013875e-01f, 2.93030106e-02f, -3.81063633e-02f, -2.69150406e-01f, -1.93475172e-01f,
  -8.14984888e-02f, 1.50999591e-01f, 4.95702326e-02f, -5.86796738e-02f, 2.47356951e-01f, -3.18375751e-02f, 1.46611616e-01f, 1.18603334e-01f, 1.70262873e-01f, 4.72262889e-01f,
  3.98256630e-01f, 3.23654771e-01f, -1.20588131e-01f, 4.25168164e-02f, 1.00927837e-01f, 1.11266039e-01f, 1.01310313e-01f, 1.01726070e-01f, 1.06849775e-01f, 1.47655323e-01f,
  1.00177236e-01f, 5.26433326e-02f, 5.41109592e-02f, -7.53181428e-03f, 4.01488841e-02f, 9.51794609e-02f, 3.40469852e-02f, 9.62319747e-02f, 1.44615039e-01f, 1.04766965e-01f,
  4.41675521e-02f, 7.30831251e-02f, 1.68688580e-01f, 4.86885421e-02f, 6.51078671e-03f, -1.63321905e-02f, 1.96374640e-01f, 7.62593523e-02f, 1.26120687e-01f, 4.23730850e-01f,
  -3.17896158e-02f, -3.65081765e-02f, -9.89031270e-02f, 1.78464279e-02f, -4.76742536e-02f, -8.27139765e-02f, -2.21458077e-02f, -1.15406374e-02f, -4.04720269e-02f, -2.49837600e-02f,
  -1.06250204e-01f, -4.02077213e-02f, -2.27164589e-02f, 2.22577248e-02f, -7.41204917e-02f, -5.51408902e-02f, -1.34416535e-01f, -4.22460511e-02f, -1.80261984e-01f, -5.75280525e-02f,
  -2.14557145e-02f, -6.84858412e-02f, -1.05148248e-01f, -9.98462439e-02f, -9.13794786e-02f, -1.04112804e-01f, -1.30939469e-01f, -8.42017680e-02f, -1.30901515e-01f, -1.34426504e-01f,
  1.70967251e-01f, -2.04685524e-01f, 2.22248137e-01f, 2.30136011e-02f, -5.07538989e-02f, -9.36379656e-02f, -7.76411220e-02f, 5.53496368e-02f, 8.73760283e-02f, 1.92184716e-01f,
  8.42893347e-02f, 3.34986150e-02f, 1.48614600e-01f, -2.26661694e-04f, -2.27855090e-02f, 5.28939674e-03f, -3.83983515e-02f, 1.12157650e-02f, 2.73898933e-02f, 1.38386652e-01f,
  1.04855359e-01f, -2.64141802e-02f, 1.67114511e-01f, 1.28301978e-01f, 1.23347238e-01f, 9.37324576e-03f, 1.77369535e-01f, 1.47296473e-01f, 6.87256306e-02f, 3.26601446e-01f,
  2.42088571e-01f, -3.22347075e-01f, 4.65992332e-01f, -2.04615831e-01f, -1.09545365e-01f, 8.40811878e-02f, 5.64361103e-02f, 1.93511136e-02f, -4.62902375e-02f, -1.78766996e-01f,
  -3.24587464e-01f, -9.50331688e-02f, -1.07274232e-02f, 1.64590672e-01f, 3.67746592e-01f, 1.95973098e-01f, 3.01911950e-01f, 6.03258371e-01f, 5.07479131e-01f, 5.98492287e-02f,
  -1.00468524e-01f, -1.02692135e-01f, 1.33866534e-01f, 7.97808096e-02f, -1.64173096e-01f, -7.77815431e-02f, -2.06720918e-01f, -1.64302617e-01f, -5.36375642e-02f, -6.03982061e-02f,
  1.66646257e-01f, -8.02353621e-02f, 2.91567389e-02f, -1.01650283e-01f, -1.25977084e-01f, -1.39834192e-02f, 6.08661994e-02f, -9.50610936e-02f, -9.62187499e-02f, -9.04310420e-02f,
  -1.07206516e-01f, 3.79679468e-03f, 1.03296349e-02f, 2.20436770e-02f, -9.98876914e-02f, -8.96598548e-02f, -7.34816045e-02f, 9.23938453e-02f, 6.38531670e-02f, -8.18105265e-02f,
  -1.09750278e-01f, -5.22494949e-02f, 4.53247949e-02f, -7.53939375e-02f, 6.63039982e-02f, 6.02618717e-02f, -1.38509704e-03f, 3.79879810e-02f, 1.18621670e-01f, -1.37460142e-01f,
  -1.53216377e-01f, 7.05330223e-02f, 1.14684924e-02f, -1.84217468e-02f, -9.34835374e-02f, -2.06825081e-02f, 4.78042290e-02f, 1.79764573e-02f, 3.75558180e-03f, -1.60346348e-02f,
  4.41246480e-02f, -2.65518483e-02f, -1.42850745e-02f, -2.02522501e-02f, -4.67384793e-02f, 1.86479390e-02f, 1.41915783e-01f, -5.89438677e-02f, 9.74616676e-04f, 1.27527695e-02f,
  5.63303940e-02f, -3.47668156e-02f, -4.53611203e-02f, -2.34856680e-02f, -2.20493712e-02f, 5.27847894e-02f, 3.26260962e-02f, -8.92445296e-02f, 3.51802185e-02f, -1.10768475e-01f,
  -3.67730200e-01f, 1.82573438e-01f, 7.97543824e-02f, 3.32178101e-02f, -3.79276462e-02f, -2.48798523e-02f, -1.40008722e-02f, -9.77098420e-02f, -5.42366505e-02f, -8.07715282e-02f,
  -1.55323027e-02f, 6.89918250e-02f, -5.63473143e-02f, -4.04599868e-02f, 8.49094540e-02f, -8.39135125e-02f, -5.24256676e-02f, -3.88877504e-02f, 6.87545836e-02f, -7.42104799e-02f,
  -1.28859580e-01f, 3.16468216e-02f, 1.02103412e-01f, -7.51574486e-02f, -4.60170880e-02f, 1.62478268e-01f, 5.42919245e-03f, -9.53513384e-02f, 1.59199253e-01f, -1.84253737e-01f,
  1.50025561e-01f, 2.62683898e-01f, 3.26825917e-01f, 1.02450363e-02f, 1.16644517e-01f, 1.76100269e-01f, 4.30424005e-01f, 7.53184333e-02f, -2.26628900e-01f, 2.41441801e-01f,
  1.67297721e-01f, -3.46619412e-02f, -5.53315841e-02f, -8.65662098e-02f, 9.54277348e-03f, 2.13329673e-01f, 2.10767061e-01f, 5.15066972e-03f, -2.97900051e-01f, -9.77444649e-02f,
  -8.98276046e-02f, -2.20768359e-02f, -4.25823852e-02f, -1.36093512e-01f, 3.22167799e-02f, -5.30570634e-02f, 1.29530117e-01f, 7.62553960e-02f, 9.09699947e-02f, 2.90143430e-01f,
  8.92794877e-02f, 2.04209208e-01f, -6.47712350e-02f, -4.05517966e-02f, 3.06822918e-03f, 3.34011689e-02f, -2.29687430e-03f, -3.20240483e-02f, 1.85271967e-02f, -5.39611392e-02f,
  4.85534854e-02f, 5.07698320e-02f, 4.72218245e-02f, 1.90319736e-02f, 1.11316189e-01f, 1.24686798e-02f, -1.79172549e-02f, 5.52845150e-02f, 8.49039182e-02f, 1.23900570e-01f,
  1.65831059e-01f, 2.14021236e-01f, 1.76875591e-01f, 3.94021440e-03f, 7.85392448e-02f, -1.93511024e-02f, 1.25791049e-02f, 4.39360850e-02f, 4.88693565e-02f, -4.50263843e-02f,
  -1.00780893e-02f, 8.19558743e-03f, -7.94901699e-03f, -1.96487568e-02f, -2.62240153e-02f, 2.25338843e-02f, 1.15424851e-02f, -3.82212922e-03f, -1.28301173e-01f, -4.46775509e-03f,
  2.89350841e-02f, 7.61103816e-03f, -7.97519460e-03f, 1.01807332e-02f, -5.61540090e-02f, 5.98107465e-03f, 6.53170720e-02f, -2.21664682e-02f, 6.42026076e-03f, -1.25986077e-02f,
  2.43190769e-03f, 2.37531327e-02f, 5.17420545e-02f, -3.70040014e-02f, 5.20492345e-02f, 3.40696014e-02f, -8.74240603e-03f, -1.58286560e-02f, -8.19495618e-02f, 1.81725696e-01f,
  -2.85106629e-01f, 2.00073183e-01f, 3.97491306e-02f, 4.07714956e-03f, 6.78079277e-02f, -4.82099764e-02f, 3.49076390e-02f, 7.08611077e-03f, 4.44592498e-02f, 5.48609421e-02f,
  -2.26003490e-02f, 5.99121116e-02f, 1.88257739e-01f, 1.29252836e-01f, 2.33617220e-02f, -8.76378641e-03f, 1.31620467e-01f, 4.00547571e-02f, 1.95511952e-02f, -2.89894138e-02f,
  4.82900217e-02f, 4.54087481e-02f, 4.09649611e-02f, 5.05301519e-04f, 8.59097913e-02f, 3.10573820e-02f, -6.43254817e-02f, -5.74029535e-02f, 1.23852920e-02f, -9.49659497e-02f,
  -8.45579684e-01f, -1.44405857e-01f, 9.29235220e-02f, -3.97055268e-01f, 3.52547169e-01f, 3.74766052e-01f, 4.27405834e-01f, -4.14491910e-03f, -2.66767085e-01f, 8.32148641e-03f,
  2.38575805e-02f, -7.62884924e-03f, -1.37901798e-01f, -1.91015936e-02f, 2.22581513e-02f, 2.91292161e-01f, 1.61157846e-01f, -4.69301865e-02f, 1.03692718e-01f, 1.75817251e-01f,
  2.15747088e-01f, -2.76770920e-01f, -4.29196864e-01f, -1.95108920e-01f, -1.32859349e-02f, 1.12307139e-01f, 3.94520909e-02f, -1.40248269e-01f, 2.53459662e-01f, -1.33776709e-01f,
  3.12386174e-02f, -2.84508169e-01f, 9.52234939e-02f, -9.96258706e-02f, -9.18490253e-03f, -1.63793415e-01f, -1.21602044e-02f, -1.00748047e-01f, -7.07926750e-02f, -5.47728054e-02f,
  1.81718636e-02f, -6.41720593e-02f, -3.58534716e-02f, -4.10745032e-02f, -1.37828132e-02f, 7.17626303e-04f, -1.31987959e-01f, -1.08868442e-01f, -8.57031345e-02f, -4.65984643e-02f,
  1.10829897e-01f, 9.17473286e-02f, 1.14782944e-01f, 1.23285815e-01f, -1.05132475e-01f, 6.36143982e-02f, -4.33350354e-03f, -1.56638429e-01f, -7.96313211e-02f, -2.94573933e-01f,
  2.31557209e-02f, -2.87169907e-02f, 8.30229558e-03f, -7.77394399e-02f, 5.01079578e-03f, 3.57974544e-02f, 2.07370729e-03f, 4.02910374e-02f, -4.65271324e-02f, -6.08347580e-02f,
  -2.02132273e-03f, -3.51305082e-02f, -6.25724047e-02f, -5.32587152e-03f, 1.58511400e-02f, -3.98675278e-02f, 1.18987923e-02f, -2.21925713e-02f, 4.75223772e-02f, -6.84316903e-02f,
  -9.44893956e-02f, -4.07845667e-03f, -6.52516931e-02f, -9.70706418e-02f, 2.00878177e-02f, -4.95858788e-02f, -1.85277332e-02f, -4.49222773e-02f, -2.54480187e-02f, -2.04924196e-02f,
  -3.66995335e-02f, 1.34036645e-01f, -1.54238179e-01f, -4.81574982e-02f, 4.38974035e-04f, -1.26745701e-02f, 2.01576836e-02f, -4.28015701e-02f, -3.43034789e-02f, -7.53618106e-02f,
  -5.53082898e-02f, -7.26755410e-02f, -2.44779959e-02f, 1.05769187e-02f, 7.58623332e-02f, 1.72568262e-02f, 2.70733330e-02f, 5.54402778e-03f, -2.61614937e-02f, -5.77758327e-02f,
  -1.21713623e-01f, 1.16396964e-01f, 2.09422093e-02f, 1.71390194e-02f, -9.03250277e-03f, 5.73645197e-02f, 1.71221733e-01f, 9.99919251e-02f, 8.32097903e-02f, 9.72428080e-03f,
  1.74389690e-01f, 1.86363578e-01f, -3.54992971e-02f, 8.13535452e-02f, -1.76399961e-01f, -2.40702450e-01f, -1.88346341e-01f, 2.82885619e-02f, 4.55608033e-02f, -1.33935243e-01f,
  1.50956765e-01f, 1.93895996e-01f, 1.90010756e-01f, 7.67761841e-02f, 3.45192067e-02f, -1.29094660e-01f, -2.14255840e-01f, 3.85763831e-02f, -1.49952946e-02f, -1.69196635e-01f,
  -1.79273665e-01f, -1.36363387e-01f, -1.07600717e-02f, -3.29285003e-02f, -2.28018224e-01f, -2.39405647e-01f, -1.46650270e-01f, -1.85100123e-01f, -2.28327185e-01f, -4.32491869e-01f,
  -1.61584079e-01f, 1.80305198e-01f, 5.14305271e-02f, 7.81055316e-02f, 5.18748239e-02f, 7.34217241e-02f, 7.25611448e-02f, 6.30828887e-02f, 1.13984056e-01f, 2.98813954e-02f,
  7.32775256e-02f, 5.36663607e-02f, 5.66820651e-02f, -4.68106605e-02f, 6.86931834e-02f, 2.34235451e-02f, 1.82782099e-01f, 5.62786832e-02f, 1.05099939e-01f, 8.92811343e-02f,
  -4.42944728e-02f, -3.04129813e-02f, 6.85360357e-02f, 5.78070320e-02f, 5.18380068e-02f, 9.52490568e-02f, -8.55288804e-02f, -6.83235005e-02f, -5.22596799e-02f, -1.57707155e-01f,
  5.46635687e-02f, -7.11160675e-02f, 1.02461884e-02f, 5.58269732e-02f, -4.39669788e-02f, 6.00619502e-02f, -6.06783703e-02f, -5.17541654e-02f, -3.65362037e-03f, -1.69771947e-02f,
  2.24919189e-02f, -1.48943653e-02f, 1.16166170e-03f, -1.69094503e-02f, -6.97869286e-02f, 1.05868867e-02f, -2.62096059e-03f, 2.07331888e-02f, 6.58478122e-03f, -3.36469300e-02f,
  -8.94653983e-03f, 5.88031672e-02f, 8.07740446e-03f, -6.29764795e-02f, 1.08431717e-02f, 4.11906205e-02f, 2.07579490e-02f, 1.29047958e-02f, 7.30109289e-02f, 4.73554544e-02f,
  1.75614700e-01f, 1.21936470e-01f, -1.03669591e-01f, 5.47602177e-02f, -2.45354008e-02f, 5.77548891e-02f, -5.42047201e-03f, -8.76741670e-03f, 5.23244254e-02f, -1.81441812e-03f,
  7.23581156e-03f, 2.17522550e-02f, -1.04568908e-02f, -5.10524176e-02f, -1.07115142e-01f, 2.84674810e-03f, 2.16862746e-02f, -7.11109564e-02f, -6.19538724e-02f, 1.35835921e-02f,
  7.35389441e-02f, -5.75212538e-02f, 1.40399230e-03f, 3.64039615e-02f, 2.35632583e-02f, -2.77361590e-02f, -8.21979418e-02f, -1.11859046e-01f, -1.04061365e-01f, -3.11250597e-01f,
  -3.26937556e-01f, 4.31656949e-02f, 4.55234826e-01f, 2.99381286e-01f, -4.04493064e-02f, -2.99769849e-01f, -3.40036392e-01f, -6.12099878e-02f, 1.14569902e-01f, 2.01693922e-02f,
  -1.56629011e-01f, -1.05127387e-01f, 5.57734668e-02f, -1.59747705e-01f, -2.15842605e-01f, 5.13076559e-02f, 2.62793601e-01f, 1.07689932e-01f, -2.75417507e-01f, -1.89133748e-01f,
  -1.06202461e-01f, 3.50100473e-02f, 7.83391744e-02f, 1.41843066e-01f, 2.85542309e-01f, 1.84573717e-02f, 3.94267648e-01f, 1.55806065e-01f, -8.60701799e-02f, 5.06261528e-01f,
  5.22226915e-02f, 6.91471547e-02f, -9.46603045e-02f, -1.07623786e-01f, 8.13201889e-02f, -4.82845604e-02f, -1.02118984e-01f, 9.35150832e-02f, 2.14045905e-02f, 9.83137190e-02f,
  9.88484770e-02f, 4.27965336e-02f, 2.63927951e-02f, 1.09751180e-01f, 1.77393612e-02f, -1.72503665e-02f, 1.73963293e-01f, 1.18667275e-01f, 6.63874596e-02f, 1.53604634e-02f,
  6.77199811e-02f, -8.60645771e-02f, -5.14862537e-02f, -4.64824326e-02f, 1.14798114e-01f, -5.80143519e-02f, -7.21066957e-03f, -3.00406553e-02f, -7.42725730e-02f, 8.68021399e-02f,
  -1.03188641e-01f, 1.19033838e-02f, -1.68887693e-02f, -4.08520065e-02f, -6.61814138e-02f, 5.26004508e-02f, 5.36620319e-02f, -1.02750570e-01f, -1.55075509e-02f, 6.01451732e-02f,
  -3.29095200e-02f, -3.28532010e-02f, 3.59818526e-02f, 3.42084207e-02f, -2.34584957e-02f, 9.85021740e-02f, -4.39512655e-02f, -5.87316714e-02f, 1.31685054e-03f, -1.01571623e-02f,
  -8.25197343e-03f, -5.33817383e-03f, 1.03899539e-01f, 3.64786014e-02f, -1.89862754e-02f, 7.79809728e-02f, 2.88111661e-02f, -1.32880555e-02f, 2.15739347e-02f, 3.00134923e-02f,
  -2.19332296e-02f, -3.46643955e-01f, -1.62764564e-02f, -9.84668806e-02f, 2.23548505e-02f, 4.67978138e-03f, -2.46375799e-02f, -1.17512532e-02f, -3.64964455e-02f, 6.92727556e-03f,
  -1.09768651e-01f, -9.03855041e-02f, -2.09469013e-02f, -1.17395418e-02f, -1.02470756e-01f, -7.68104643e-02f, -1.40744746e-01f, -6.40899017e-02f, -5.16723357e-02f, 4.58357595e-02f,
  -1.97917526e-03f, -1.03430294e-01f, -2.55550474e-01f, -2.69934926e-02f, -5.60536459e-02f, -2.51637518e-01f, -2.85976753e-02f, 3.68379964e-03f, -2.82765776e-01f, -4.73657548e-02f,
  1.40916958e-01f, -7.19108284e-02f, 4.27211262e-02f, 2.92268962e-01f, -3.94766480e-02f, -1.08659364e-01f, -1.21941477e-01f, -9.67695005e-03f, 1.98829263e-01f, 1.69048414e-01f,
  -3.11611712e-01f, -3.52972820e-02f, 7.38570467e-02f, 2.37801298e-02f, 5.20198718e-02f, 2.38736212e-01f, 4.14532721e-01f, 1.68582976e-01f, 5.89577369e-02f, 4.71663848e-02f,
  1.84182435e-01f, 8.01116079e-02f, -9.22131911e-02f, 3.98517475e-02f, 1.43432111e-01f, 1.70711920e-01f, -4.66310307e-02f, -2.34810278e-01f, -9.79138613e-02f, 3.87182534e-01f,
  1.23125732e-01f, -1.75647944e-01f, 3.24144587e-02f, -4.38223071e-02f, -1.51864916e-01f, 8.79465952e-04f, 5.27698845e-02f, -4.74047326e-02f, -3.95921478e-03f, 7.31043294e-02f,
  2.89983582e-03f, 3.31152827e-02f, 9.72440317e-02f, -2.63229348e-02f, -1.71124730e-02f, -5.81278056e-02f, 3.76038179e-02f, -5.81176318e-02f, 2.33374946e-02f, -7.20283985e-02f,
  6.36906400e-02f, -1.26987305e-02f, 4.47730832e-02f, 2.58924384e-02f, -8.21311846e-02f, 6.16436265e-02f, -1.09667249e-01f, -3.20952199e-02f, -1.52662069e-01f, 1.40577331e-01f,
  -3.10366713e-02f, -5.69007769e-02f, -8.10082033e-02f, -9.47070122e-02f, -5.38097136e-02f, -2.30009202e-02f, 1.55886739e-01f, 1.09742194e-01f, 4.04204726e-02f, -4.08410765e-02f,
  -5.49786724e-02f, -3.64962779e-02f, -1.40726240e-02f, 6.16315976e-02f, 4.27196585e-02f, -1.62584670e-02f, 5.15755191e-02f, -1.07965115e-02f, -6.16084449e-02f, -7.87419155e-02f,
  -6.66533690e-03f, 2.92476844e-02f, 5.45615563e-04f, -7.58073851e-02f, 1.15784016e-02f, -4.05021608e-02f, 3.44407670e-02f, -4.21536565e-02f, -6.57104328e-02f, -3.25997621e-02f,
  6.71737343e-02f, -2.92929232e-01f, 2.28558525e-01f, 7.75378896e-03f, -3.83548662e-02f, -5.52281365e-02f, -1.52509645e-01f, -5.94902635e-02f, -8.99986997e-02f, 4.04286124e-02f,
  -4.13688459e-02f, 2.33585797e-02f, -3.39089110e-02f, 2.63122451e-02f, 1.16908170e-01f, 5.08353263e-02f, -9.62763745e-03f, 8.36368203e-02f, 3.33711617e-02f, 2.13746168e-02f,
  8.20112601e-02f, 2.74400026e-01f, 2.49314114e-01f, 1.66502386e-01f, 7.41378814e-02f, 2.38976598e-01f, 1.60642505e-01f, 1.31785706e-01f, 1.19658493e-01f, 4.20155317e-01f,
  1.48696601e-01f, 3.32926422e-01f, 3.14062744e-01f, -5.35302088e-02f, -1.63083673e-02f, 2.26867229e-01f, 4.28909957e-01f, 2.68931035e-02f, -1.90328166e-01f, 1.49449959e-01f,
  -8.08550566e-02f, -3.52847308e-01f, -3.09665591e-01f, -8.57012570e-02f, -1.11566512e-02f, 1.98100880e-01f, 1.24362446e-01f, -8.35640952e-02f, -4.69782725e-02f, 6.59976527e-02f,
  -6.33238554e-02f, 4.89248037e-02f, 8.69882628e-02f, -1.28315479e-01f, -7.43562803e-02f, -2.61877418e-01f, -7.97783583e-02f, -9.01617333e-02f, -3.28985155e-02f, -1.05766512e-01f,
  -2.81092346e-01f, 4.29190844e-02f, -7.52372742e-02f, -1.10705987e-01f, 1.60972234e-02f, 2.32325383e-02f, -6.25328198e-02f, -9.53103825e-02f, 4.66245338e-02f, 9.92349982e-02f,
  1.32473083e-02f, 8.83193091e-02f, -1.47486702e-01f, 2.73010079e-02f, 1.70945838e-01f, 5.47541454e-02f, 6.11035526e-02f, -5.02077974e-02f, 4.75419387e-02f, 9.96396784e-03f,
  -2.98236944e-02f, 1.54158816e-01f, 2.21473500e-01f, 9.42261517e-02f, -1.32824574e-03f, -1.30413130e-01f, 1.00131936e-01f, 3.51430103e-03f, 1.43540114e-01f, 8.40889011e-03f,
  9.83921885e-02f, 8.02322328e-02f, -8.11408535e-02f, 2.67592054e-02f, -1.46369096e-02f, -6.57061562e-02f, -6.58157021e-02f, 3.54453363e-03f, -7.76119083e-02f, 6.15274236e-02f,
  2.47591659e-02f, 4.60945256e-02f, 3.79612371e-02f, 3.62159684e-02f, -3.30314338e-02f, 6.06896915e-02f, 9.05686691e-02f, 4.23648022e-02f, 2.04359964e-02f, 9.77475867e-02f,
  -2.55824868e-02f, -3.97704467e-02f, -5.93655221e-02f, -8.02713335e-02f, -7.59755960e-03f, 4.45530899e-02f, -2.50001103e-02f, 2.77157128e-02f, 6.63734647e-03f, 1.58418760e-01f,
  -1.25758484e-01f, 9.92375519e-03f, -1.43819332e-01f, 2.53615621e-03f, 2.28992365e-02f, -5.44810183e-02f, -8.94845277e-02f, -9.66067240e-03f, -2.21687965e-02f, 1.25282362e-01f,
  4.41630185e-03f, 2.11492013e-02f, 3.61989252e-02f, 2.55332272e-02f, -1.33961141e-02f, 1.90434027e-02f, -9.99480337e-02f, -8.23646560e-02f, -1.52996629e-02f, 3.29481550e-02f,
  1.15597956e-01f, 1.05439946e-01f, 1.64625347e-02f, 8.17398168e-03f, -9.52765197e-02f, -1.11941516e-01f, -4.64693159e-02f, -1.17863044e-01f, -1.48993162e-02f, 2.07234889e-01f,
  -9.03280020e-01f, -1.22630365e-01f, 5.73851883e-01f, -3.29309732e-01f, 2.52468288e-01f, 3.73822927e-01f, 3.02215368e-01f, -4.25923206e-02f, -1.51418298e-01f, -2.40397360e-03f,
  -1.08124651e-01f, -3.25687706e-01f, -1.63696572e-01f, -1.48928851e-01f, -1.14383578e-01f, 3.14353228e-01f, 2.90119439e-01f, -2.29171943e-02f, -5.10800770e-03f, -1.77256301e-01f,
  -1.99925601e-01f, -1.01361915e-01f, -2.06689313e-01f, -1.31064594e-01f, -2.18475964e-02f, -6.51783198e-02f, 3.60146046e-01f, 2.05201700e-01f, 1.98610678e-01f, 3.95714752e-02f,
  9.56746340e-02f, -5.79443984e-02f, -1.85007043e-02f, -1.04926676e-01f, 1.13034122e-01f, -1.10258803e-01f, 5.08652115e-03f, 2.36048060e-03f, -6.29560947e-02f, 1.56464875e-02f,
  7.28630796e-02f, -8.73694755e-03f, 2.75756717e-02f, 5.04628494e-02f, 7.89767578e-02f, -5.20010367e-02f, -6.07943051e-02f, -7.40979388e-02f, 8.85089859e-02f, 5.78588918e-02f,
  -4.26006224e-03f, -3.05864550e-02f, 8.72109309e-02f, 8.26867744e-02f, 2.94545237e-02f, -3.98199866e-03f, 6.19633310e-02f, 1.75765138e-02f, 2.23383810e-02f, -1.41983315e-01f,
  6.26795292e-02f, 1.34843530e-03f, 4.39150706e-02f, -1.28251594e-03f, -6.11960441e-02f, 3.03289853e-02f, 4.52914461e-03f, 3.48002501e-02f, -1.38339717e-02f, -3.27367685e-03f,
  -4.36310470e-02f, 4.90601398e-02f, -2.01321691e-02f, -6.30049109e-02f, -2.73974929e-02f, 7.39342943e-02f, -2.78812442e-02f, 1.03568565e-02f, 6.09405302e-02f, -3.14339586e-02f,
  -4.60115634e-02f, 2.03977451e-02f, -4.55132723e-02f, -8.35811812e-03f, 6.11239709e-02f, -2.49132346e-02f, 5.58146834e-02f, -1.15833022e-02f, 7.75155500e-02f, 2.73016859e-02f,
  -7.57476538e-02f, 1.98252171e-01f, -1.08700991e-01f, -3.37201692e-02f, 1.02430493e-01f, 9.83546022e-03f, -1.68458764e-02f, -2.10306309e-02f, 5.09349778e-02f, -5.44773340e-02f,
  1.56886764e-02f, 6.39122026e-03f, 5.79911359e-02f, 2.07526665e-02f, 4.64023538e-02f, 1.97634362e-02f, -3.14647779e-02f, -6.36452287e-02f, -3.06092408e-02f, 3.98885272e-02f,
  -3.66062820e-02f, -1.01122819e-01f, -4.73420061e-02f, -3.66868563e-02f, -8.55475366e-02f, -9.73166153e-03f, 5.21715917e-02f, 9.75312367e-02f, 7.16768503e-02f, -1.74656227e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.50353217e+00f, -1.03918934e+00f, -1.03393424e+00f, 8.71911585e-01f, 4.83381957e-01f, 3.40254873e-01f, 9.39091854e-03f, 4.43968296e-01f, 7.64950156e-01f, -1.04826666e-01f,
  -5.63103437e-01f, -1.55259654e-01f, -5.22111952e-01f, -6.28661752e-01f, -4.38761026e-01f, -5.21289706e-01f, -3.75034034e-01f, -3.21145147e-01f, 5.48658550e-01f, 6.51630938e-01f,
  2.42893994e-01f, 5.11069298e-01f, 4.14399087e-01f, 4.68598455e-02f, -1.92999780e-01f, 1.03444494e-01f, -5.28433383e-01f, -5.63356996e-01f, -7.61212528e-01f, -8.27693224e-01f,
  -6.72766626e-01f, -4.09022689e-01f, 2.87400723e-01f, -5.95883466e-02f, -1.58942252e-01f, 1.65481567e-01f, 9.41504762e-02f, -2.30272245e-02f, 7.20469728e-02f, 9.09976214e-02f,
  -1.15049139e-01f, 1.25317101e-03f, -4.36096173e-03f, -6.70228153e-02f, 2.66646683e-01f, 5.71188368e-02f, -1.45276710e-02f, -2.06723198e-01f, -1.01046458e-01f, -1.94053307e-01f,
  -3.28374296e-01f, -2.13133648e-01f, -1.71856638e-02f, -1.66716263e-01f, -1.91005006e-01f, -4.61983271e-02f, -3.85033816e-01f, -7.18087330e-02f, -2.60078102e-01f, 1.06768809e-01f,
  -8.29366595e-02f, -8.02198425e-02f, 3.59213315e-02f, 2.12143790e-02f, 3.70896757e-02f, 2.82680336e-02f, 3.94401215e-02f, -4.52307723e-02f, 7.08757043e-02f, 1.05212666e-02f,
  -2.55787047e-03f, -5.53965047e-02f, 9.87135768e-02f, 1.02127306e-01f, -1.84314817e-01f, -2.06592493e-03f, -1.06580816e-02f, -8.54447484e-02f, -2.06816658e-01f, 5.93738928e-02f,
  -7.08343759e-02f, 8.37312713e-02f, 4.12123911e-02f, -1.17293179e-01f, -2.26617351e-01f, -1.33049190e-01f, -3.78453056e-03f, -4.72310707e-02f, 1.88443795e-01f, 8.52815211e-02f,
  4.80543554e-01f, -3.39109123e-01f, 8.07889402e-02f, -4.37885672e-02f, -5.30671738e-02f, -1.19812459e-01f, -2.08704785e-01f, -3.48654054e-02f, -3.72501537e-02f, 8.78091455e-02f,
  -8.33253115e-02f, -5.77766076e-02f, -1.81150794e-01f, 2.57416870e-02f, 3.40383708e-01f, 5.64487241e-02f, -7.19030052e-02f, -1.15674384e-01f, -7.46733099e-02f, 1.41798764e-01f,
  4.41780407e-03f, 2.66974300e-01f, 3.50190967e-01f, 1.42946064e-01f, 1.17250212e-01f, 2.63400018e-01f, 8.94874632e-02f, 2.41721615e-01f, 2.48604923e-01f, 5.65939188e-01f,
  9.62533891e-01f, -7.45066226e-01f, -6.61205828e-01f, 5.81807911e-01f, -1.91856220e-01f, -9.05206680e-01f, -1.61369455e+00f, -4.79034334e-01f, 4.08289999e-01f, -7.92180419e-01f,
  -1.70964617e-02f, 1.05576766e+00f, 7.83520758e-01f, 6.69577539e-01f, 2.72023708e-01f, -1.09472013e+00f, -3.93523127e-01f, 4.61517781e-01f, 5.55379152e-01f, -8.00989792e-02f,
  -1.24721341e-01f, 4.18898940e-01f, 6.53661370e-01f, 7.35183805e-02f, -4.39137250e-01f, 3.73737067e-01f, -5.30904472e-01f, -3.66038159e-02f, -6.79524958e-01f, -5.37033856e-01f,
  -2.61221856e-01f, -8.94143879e-01f, 7.95856193e-02f, 6.45789325e-01f, 1.76410973e-01f, -1.87218666e-01f, -2.22872123e-01f, -1.52811790e-02f, -1.72496855e-01f, -2.40814239e-01f,
  2.05696717e-01f, -2.08296534e-02f, 3.41911763e-02f, 2.69808900e-02f, 3.49223316e-02f, -3.11341345e-01f, -7.01164752e-02f, -1.29456371e-01f, -1.47664398e-01f, -6.06758535e-01f,
  1.07689761e-01f, -2.09758827e-03f, -3.02946717e-01f, -4.63183075e-01f, -3.04384053e-01f, 5.29916763e-01f, -4.47626442e-01f, -3.76957685e-01f, -2.35578537e-01f, -7.23419428e-01f,
  7.28219897e-02f, -1.03233986e-01f, -4.08200286e-02f, -1.77458689e-01f, 1.72564939e-01f, -3.50578986e-02f, -7.62108015e-03f, 1.12455403e-02f, -8.46080631e-02f, -1.45721063e-01f,
  -1.34195909e-01f, 9.44453776e-02f, -9.04163942e-02f, -1.95642576e-01f, 7.77563974e-02f, -5.77978939e-02f, -1.08446591e-01f, 8.82640257e-02f, 1.32335529e-01f, 3.83058190e-02f,
  1.55441925e-01f, -3.19532678e-02f, -8.77448078e-03f, -2.56995838e-02f, -1.93999037e-02f, 2.30192453e-01f, 5.36307469e-02f, 1.85425907e-01f, 2.23463267e-01f, -1.91747978e-01f,
  5.75012565e-01f, 5.57389617e-01f, -1.84883878e-01f, 2.47540753e-02f, -2.59493738e-01f, 1.10491393e-02f, -5.53994179e-02f, 1.47159562e-01f, 5.95202371e-02f, -2.34956518e-02f,
  -1.66294441e-01f, 5.49812019e-02f, -1.97965845e-01f, -1.02527976e-01f, -1.05509616e-01f, -2.12728754e-01f, -1.50833264e-01f, 1.07284598e-02f, -4.45428789e-02f, -9.84239653e-02f,
  1.93570018e-01f, 1.78377246e-04f, 1.94722161e-01f, -1.49752228e-02f, 1.78375596e-03f, 2.74062544e-01f, -5.84984720e-01f, -2.69505709e-01f, -1.20247185e-01f, -6.45027697e-01f,
  -1.81464121e-01f, 4.17988747e-01f, 2.14789718e-01f, -1.11628905e-01f, 1.39297438e+00f, 5.04221201e-01f, 3.41811180e-02f, -3.23967427e-01f, 1.96405560e-01f, 2.83511728e-01f,
  1.23534191e+00f, 2.10074425e-01f, -1.36114210e-01f, -6.71491981e-01f, -1.54019248e+00f, -9.95038092e-01f, -1.02115178e+00f, -1.30562747e+00f, -1.20188999e+00f, -2.81787694e-01f,
  2.24293731e-02f, -3.39058042e-01f, -7.68196106e-01f, -2.71356344e-01f, 5.11395037e-01f, 6.83716163e-02f, 2.92355329e-01f, 4.65389520e-01f, 3.28616828e-01f, -1.65092275e-01f,
  6.91952705e-02f, 3.82171869e-01f, -2.00614646e-01f, -1.52186915e-01f, 4.25241977e-01f, -2.96096325e-01f, -1.24917708e-01f, 1.54686514e-02f, -1.24323413e-01f, -1.67138979e-01f,
  7.71456897e-01f, 1.23034589e-01f, 1.61688983e-01f, -1.93507031e-01f, 4.17839028e-02f, -6.06064320e-01f, -1.70962080e-01f, -8.17403615e-01f, -8.85672212e-01f, -3.82123530e-01f,
  1.91559419e-01f, 5.86168706e-01f, -5.95175177e-02f, -6.40435442e-02f, -2.50073344e-01f, -1.01892039e-01f, 2.60721475e-01f, 8.82676765e-02f, -1.09918326e-01f, -1.87011182e-01f,
  -2.77188063e-01f, -6.44486472e-02f, 5.35200350e-02f, 3.95508744e-02f, -1.48819298e-01f, 1.20828733e-01f, -6.89534321e-02f, 2.78386362e-02f, -1.49577344e-02f, -3.83388251e-02f,
  -1.67259946e-01f, 3.19508672e-01f, -1.41798556e-01f, 1.85059179e-02f, -3.96610610e-02f, 9.43921879e-02f, -1.37566537e-01f, -2.64707774e-01f, -1.79474875e-01f, -9.07702371e-03f,
  -1.55547798e-01f, 1.69565484e-01f, 3.72722328e-01f, -4.15608764e-01f, 1.43531784e-01f, -8.21647793e-02f, 8.58301669e-02f, 1.21807352e-01f, 1.05096333e-01f, 2.23696813e-01f,
  -3.04448128e-01f, 8.07965249e-02f, -2.43137151e-01f, -1.95136607e-01f, -1.57447577e-01f, -6.32912889e-02f, 1.62749067e-01f, 2.19381943e-01f, 2.37571210e-01f, -8.65999386e-02f,
  -1.62922740e-02f, -4.57145751e-01f, 1.91368297e-01f, -1.22524522e-01f, -1.07070848e-01f, 6.06696047e-02f, -1.85621023e-01f, 3.34223434e-02f, -7.81195238e-02f, 3.13624889e-01f,
  -2.18040913e-01f, -6.53241932e-01f, -4.92394179e-01f, -2.13306367e-01f, -5.61005399e-02f, -4.76094097e-01f, -4.45998371e-01f, -3.46017748e-01f, -4.09136474e-01f, -1.07878816e+00f,
  -1.01308811e+00f, -1.07793939e+00f, -3.33676785e-01f, -1.49194789e+00f, -5.41727066e-01f, 4.38515127e-01f, -5.12999237e-01f, 1.57488376e-01f, -8.24460462e-02f, -6.05932415e-01f,
  1.19257249e-01f, -2.98539530e-02f, -2.27115974e-01f, 4.02719229e-01f, 5.08194447e-01f, -5.12628913e-01f, -4.46589559e-01f, 3.89290631e-01f, 7.41733313e-01f, 4.25925463e-01f,
  -5.94936684e-02f, -6.71960950e-01f, -1.14808753e-01f, 5.35494834e-03f, -1.06101513e+00f, -2.45251730e-01f, -8.86999607e-01f, -4.34985995e-01f, 3.04995716e-01f, -1.07027161e+00f,
  -6.63989067e-01f, -2.90376246e-01f, 3.86751622e-01f, 1.15336113e-01f, -2.95572519e-01f, 1.58994928e-01f, -1.52303308e-01f, -1.24211073e-01f, 1.00123852e-01f, -1.25589091e-02f,
  -1.54836237e-01f, 2.31463045e-01f, -2.10330978e-01f, 9.41201895e-02f, -3.77879798e-01f, 1.48709016e-02f, 1.00516789e-01f, 7.43257031e-02f, 6.31348714e-02f, -5.50113209e-02f,
  8.08641016e-02f, 5.44896014e-02f, 1.06619574e-01f, 3.43906254e-01f, 2.99588054e-01f, 1.83752164e-01f, -4.48943190e-02f, 2.44079828e-01f, 5.00150740e-01f, -6.69331729e-01f,
  4.36312892e-02f, -1.23464629e-01f, -2.80071944e-02f, 5.26812673e-03f, 2.31923595e-01f, -3.90099101e-02f, -2.18814462e-01f, -3.86714973e-02f, -2.63685063e-02f, -1.14911214e-01f,
  5.00353351e-02f, 2.81428639e-02f, 3.14712860e-02f, -1.58728004e-01f, -4.18727249e-02f, 1.05191562e-02f, 1.93687845e-02f, -4.00028229e-02f, 6.35171235e-02f, -1.21407412e-01f,
  1.38417810e-01f, 8.13331082e-02f, -2.09655583e-01f, 4.39718626e-02f, 9.47392955e-02f, 5.50012570e-03f, 2.99649835e-02f, 1.90106571e-01f, -1.31011352e-01f, 7.95526952e-02f,
  -7.97258019e-01f, 8.62730443e-01f, -6.47499025e-01f, 6.24388307e-02f, -3.08571130e-01f, -2.09929608e-02f, -2.26595670e-01f, 1.84725851e-01f, -9.17301923e-02f, -1.91106468e-01f,
  2.08724231e-01f, -1.32459417e-01f, -2.06677571e-01f, 5.67809911e-03f, -6.54819701e-03f, 1.16488717e-01f, -9.15082991e-02f, -2.59505033e-01f, 1.81658149e-01f, -5.16408123e-02f,
  -2.47199573e-02f, 4.69817556e-02f, -2.97275335e-01f, -1.11042745e-01f, -7.78349563e-02f, 1.17702022e-01f, -2.60259867e-01f, -9.63891223e-02f, 1.19659044e-01f, -7.12777615e-01f,
  -5.24415016e-01f, -2.62205303e-01f, -5.08495569e-01f, 4.07558382e-02f, -6.73278272e-02f, -4.85393524e-01f, -6.94812953e-01f, -4.11669046e-01f, -1.14064828e-01f, -2.19579846e-01f,
  -2.42616579e-01f, 3.80474553e-02f, -7.67997578e-02f, -5.08573428e-02f, -9.21446458e-02f, -7.55403861e-02f, 3.11906666e-01f, 2.45186418e-01f, 2.54739244e-02f, 3.16403747e-01f,
  5.35463572e-01f, 2.41809323e-01f, 1.01333655e-01f, 1.40477479e-01f, 3.58496726e-01f, 2.61877745e-01f, -1.50655687e-01f, 2.28136078e-01f, 1.39774516e-01f, 7.29819000e-01f,
  2.91501015e-01f, -1.09848604e-02f, -2.27756556e-02f, 2.14633852e-01f, 1.21879227e-01f, 6.17842786e-02f, 1.20774761e-01f, 2.15860352e-01f, 2.37931415e-01f, 2.40166783e-01f,
  1.70450002e-01f, 2.07241684e-01f, 1.67671070e-01f, 2.75726199e-01f, -1.75878964e-02f, -3.24616760e-01f, -4.44003902e-02f, -6.69436529e-02f, -4.56293046e-01f, -9.42779779e-02f,
  5.38990915e-01f, 2.88109452e-01f, -5.08480012e-01f, -5.78838527e-01f, -1.68121383e-01f, 4.35723178e-02f, -9.01331306e-02f, 4.00726259e-01f, -5.89712083e-01f, 3.67657006e-01f,
  -2.28968505e-02f, 2.25036182e-02f, -2.57900935e-02f, -1.47076115e-01f, 1.25591770e-01f, 1.90396160e-01f, 1.52401859e-02f, 3.18482369e-02f, 5.25586400e-03f, 5.23679741e-02f,
  -1.29709914e-01f, 3.43126617e-02f, -3.88338454e-02f, -1.46035505e-02f, 1.38450012e-01f, -2.20150664e-01f, 3.14322174e-01f, 1.36311967e-02f, -9.38731711e-03f, -1.82068735e-01f,
  -5.62888123e-02f, 4.43140566e-02f, -5.25183193e-02f, 1.90585837e-01f, -1.44306961e-02f, 3.34222466e-02f, 1.07914373e-01f, 1.05307721e-01f, -2.05850661e-01f, -3.31280380e-01f,
  -2.52583593e-01f, -5.58575749e-01f, 4.78724055e-02f, 1.17058903e-01f, -8.36616475e-03f, 3.23720947e-02f, -1.97326448e-02f, 1.06518149e-01f, -3.56009454e-01f, -2.31499001e-01f,
  -3.44005257e-01f, -2.39491120e-01f, -3.13632429e-01f, 4.77735363e-02f, -2.39784926e-01f, -1.24486275e-01f, 1.33034945e-01f, 3.54197361e-02f, 3.97042446e-02f, 8.11892897e-02f,
  -2.02082112e-01f, -4.22936291e-01f, -4.83310342e-01f, -5.54730773e-01f, -5.27962089e-01f, -6.70034528e-01f, -5.86561918e-01f, -1.72378927e-01f, -9.80026960e-01f, -8.83393228e-01f,
  -1.49954605e+00f, 2.65117258e-01f, -7.75524676e-02f, -9.69751179e-01f, -9.13414598e-01f, -8.00968945e-01f, -2.63081472e-02f, -4.35397446e-01f, -4.13642108e-01f, 5.70253313e-01f,
  3.18685561e-01f, -8.95741135e-02f, 4.94684577e-01f, -9.25849527e-02f, -2.00756684e-01f, 7.79778421e-01f, 1.07840940e-01f, -3.91830236e-01f, -1.03447688e+00f, -1.06690454e+00f,
  -3.88362765e-01f, -6.06639326e-01f, -8.30727637e-01f, -3.06344002e-01f, 6.00319356e-02f, -1.21170744e-01f, 4.90624607e-01f, -3.94983649e-01f, -2.14917302e-01f, 1.59397542e-01f,
  6.02682650e-01f, -4.84013170e-01f, -1.90966815e-01f, -4.44071800e-01f, 1.53820124e-02f, -1.10028528e-01f, -1.19267613e-01f, -9.99537483e-02f, 4.24535424e-02f, -7.01096505e-02f,
  -5.94349913e-02f, -1.05608620e-01f, -3.20873052e-01f, -6.24401085e-02f, -3.28199774e-01f, -1.46277755e-01f, 2.05128584e-02f, -2.65726447e-01f, -9.01485905e-02f, 3.56955856e-01f,
  3.16679657e-01f, -1.66611508e-01f, -7.87586719e-02f, 6.16517961e-02f, -9.88936573e-02f, -3.91655296e-01f, 1.09212950e-01f, -3.42909694e-01f, -2.77698159e-01f, 3.86995018e-01f,
  1.58746526e-01f, 2.17947006e-01f, -7.45237395e-02f, -3.22912671e-02f, -4.99189012e-02f, 1.12978980e-01f, 2.47390360e-01f, -1.77147295e-02f, -6.19467944e-02f, 2.70316482e-01f,
  -6.72066733e-02f, 1.95659339e-01f, -8.31924677e-02f, 1.22605518e-01f, 1.47607639e-01f, -1.72739163e-01f, 1.14780866e-01f, 9.26103815e-02f, -3.00647039e-03f, -1.75345346e-01f,
  -2.94602126e-01f, -1.75251290e-01f, 3.01694702e-02f, -2.24400423e-02f, 3.06180902e-02f, -6.88144937e-02f, 8.01814348e-02f, -4.08375561e-02f, -9.95891467e-02f, -2.78172761e-01f,
  5.81776440e-01f, -2.77394503e-01f, 4.49451298e-01f, -9.30180997e-02f, 1.73992798e-01f, 1.96484104e-01f, 2.14460604e-02f, -3.34200845e-03f, 1.48367584e-02f, -7.05868602e-02f,
  -4.10791069e-01f, -4.41695638e-02f, 7.32605234e-02f, 1.52538061e-01f, -2.54369736e-01f, -2.83739548e-02f, 2.01599449e-01f, 2.39723530e-02f, -1.52063996e-01f, 7.11537227e-02f,
  2.19970480e-01f, 7.29715973e-02f, 2.32145905e-01f, 3.10324758e-01f, -7.23773837e-02f, -7.84868151e-02f, 5.18850207e-01f, 7.52001852e-02f, 1.25511065e-01f, 6.93888724e-01f,
  -1.26998723e+00f, 3.63779306e-01f, -1.22940350e+00f, 7.36967027e-02f, -2.01924786e-01f, -1.62991300e-01f, 5.75865507e-01f, 3.60718399e-01f, 2.34475091e-01f, 3.14961463e-01f,
  -5.32089055e-01f, -3.43242198e-01f, -2.04290986e-01f, -1.82922438e-01f, -1.70192532e-02f, 6.16508961e-01f, 5.52888095e-01f, -4.65609968e-01f, -8.73221457e-01f, -1.65539294e-01f,
  5.37696540e-01f, 2.75565118e-01f, 1.61941778e-02f, -1.43314898e-02f, -6.18807897e-02f, -2.57119387e-01f, 1.79058731e-01f, -4.83280748e-01f, -1.58224016e-01f, -6.65978268e-02f,
  -1.13739645e+00f, -5.06035507e-01f, -1.85082555e-01f, -1.14028975e-01f, -4.59498107e-01f, -2.14226589e-01f, -2.24109128e-01f, -2.83810645e-01f, -2.48851299e-01f, 2.46748894e-01f,
  -5.85001945e-01f, 1.21089645e-01f, -4.57977623e-01f, -1.69857726e-01f, -3.64396155e-01f, -2.75106221e-01f, 1.69384226e-01f, -8.15169588e-02f, -1.52322754e-01f, -3.52555782e-01f,
  3.11119109e-01f, -7.26759613e-01f, -9.52541471e-01f, 3.01944047e-01f, 1.78816661e-01f, -7.27327168e-02f, -4.53204215e-01f, -4.46443737e-01f, -2.40428746e-01f, -2.62720644e-01f,
  6.29677027e-02f, -2.28810892e-01f, -8.05912241e-02f, -1.12359459e-02f, 9.73066092e-02f, -8.32523480e-02f, 6.09552041e-02f, 4.97798249e-02f, 7.01586977e-02f, -1.65199056e-01f,
  -1.72432754e-02f, -1.07634097e-01f, 6.39777705e-02f, -1.33129567e-01f, -5.83084561e-02f, 8.49285256e-03f, -2.40927964e-01f, 3.52880716e-01f, -6.43149838e-02f, 5.66712059e-02f,
  -6.61886409e-02f, -2.12195098e-01f, 1.44044444e-01f, -8.29185173e-03f, 1.43245697e-01f, 1.71888173e-01f, 3.66588868e-02f, -1.31829545e-01f, -3.36374566e-02f, 1.73148930e-01f,
  2.97670007e-01f, 2.27943361e-01f, -3.76488954e-01f, -2.43940949e-03f, -1.56954661e-01f, -1.82195399e-02f, 1.51541810e-02f, 2.10905701e-01f, 6.23750277e-02f, -1.21303357e-01f,
  2.59946100e-02f, -3.51841688e-01f, 1.41586974e-01f, 3.17567110e-01f, -8.70893747e-02f, -1.40343383e-02f, 1.67344421e-01f, -3.96509767e-01f, 7.06937462e-02f, -9.51146707e-02f,
  5.08262873e-01f, 1.01733655e-02f, -4.33574975e-01f, -6.06555343e-02f, -2.16778927e-02f, -4.62134331e-01f, -3.65215927e-01f, -3.72061700e-01f, -2.57825166e-01f, 3.02170455e-01f,
  4.84146416e-01f, -3.94060016e-01f, 9.85564068e-02f, 4.25379276e-01f, 5.10854125e-01f, 5.89210987e-01f, 5.37108004e-01f, 3.51655513e-01f, 2.48189926e-01f, 1.46693572e-01f,
  2.02778831e-01f, 2.99060434e-01f, 1.67078108e-01f, 2.23940030e-01f, 1.97667733e-01f, 2.23806724e-01f, 1.83788821e-01f, -2.90718451e-02f, 8.59476626e-02f, 1.48607790e-01f,
  1.40361145e-01f, -1.10985912e-01f, -2.59443521e-01f, -1.29487319e-02f, 4.50334558e-03f, 1.31999210e-01f, -8.66050348e-02f, -2.17205286e-01f, -1.60284176e-01f, -3.03243220e-01f,
  -3.40991408e-01f, 2.07545906e-01f, 3.23481977e-01f, -1.33731319e-02f, -2.85519306e-02f, -2.12012887e-01f, -9.26528871e-03f, -2.26702616e-01f, -3.61218125e-01f, -1.95324525e-01f,
  -1.88147068e-01f, -2.04746678e-01f, 4.28636596e-02f, -1.00761332e-01f, -1.44443810e-01f, -1.01420306e-01f, -6.80146040e-03f, 4.77974825e-02f, 1.44416228e-01f, -1.11832939e-01f,
  -4.61630709e-02f, -9.68860555e-03f, 8.38624537e-02f, 1.91524148e-01f, 2.39816114e-01f, 1.06902532e-01f, -9.65905115e-02f, -1.55743212e-02f, 4.80548758e-03f, -2.79618124e-03f,
  4.24867094e-01f, 1.60307929e-01f, 1.52695701e-01f, 3.09424877e-01f, 1.55782655e-01f, 6.95429519e-02f, 8.70516226e-02f, 1.28101036e-01f, 2.36574098e-01f, 6.43638149e-02f,
  -7.45990351e-02f, 7.26038888e-02f, -2.73513719e-02f, 6.58908337e-02f, 1.53306887e-01f, -7.45803192e-02f, -9.43826437e-02f, 7.51498491e-02f, -1.48453079e-02f, -5.10918302e-03f,
  1.26372566e-02f, -1.00317910e-01f, -2.11594358e-01f, -8.36427212e-02f, -1.85276330e-01f, 3.71157192e-02f, -4.55168858e-02f, -5.53624555e-02f, -1.25116616e-01f, -1.65889233e-01f,
  -1.35818243e-01f, 4.25345272e-01f, 2.62036473e-01f, 7.53814355e-02f, -1.06741004e-01f, -2.74325848e-01f, 1.04352601e-01f, -5.87819777e-02f, -3.66451621e-01f, -1.41787007e-01f,
  -1.19662598e-01f, -1.32343322e-01f, 3.70039493e-02f, -1.45016938e-01f, -2.06307247e-01f, -4.37770262e-02f, -4.15239669e-02f, 1.80114850e-01f, 3.26921209e-03f, -8.69358256e-02f,
  -1.82160109e-01f, 6.07563108e-02f, 1.28180459e-01f, 2.00110286e-01f, 4.98049483e-02f, 1.06653117e-01f, 5.65826148e-03f, -8.13474122e-04f, 5.23661636e-03f, -3.18326801e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.41195178e+00f, 1.08810484e+00f, 7.70981014e-01f, 5.85578024e-01f, 8.62117112e-01f, 1.33349144e+00f, 1.34471524e+00f, 5.67210913e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.77252609e-01f, -1.86621323e-01f, -5.12670457e-01f, -5.91082156e-01f, -1.83298469e-01f, -7.99586952e-01f, 3.79890576e-02f, -3.11413318e-01f, 1.30846694e-01f, -1.82981297e-01f,
  -3.06593210e-01f, 2.33586162e-01f, -2.47763693e-01f, 3.62638205e-01f, -1.91799849e-02f, 9.87360533e-03f, -2.93469012e-01f, -2.09299967e-01f, -1.36603387e-02f, -2.98975199e-01f,
  -6.94382131e-01f, -2.83501297e-01f, 1.10665061e-01f, -8.64258409e-01f, 4.70963657e-01f, 1.64054334e-01f, -1.97195448e-02f, 5.86016953e-01f, -8.17787647e-02f, -8.32128346e-01f,
  -1.02672242e-01f, -1.34968626e+00f, 1.23260148e-01f, -1.37824088e-01f, -3.70348036e-01f, 1.12188205e-01f, 1.21073171e-01f, 4.24656346e-02f, 1.50898159e-01f, -2.71709353e-01f,
  -3.70475829e-01f, 4.33808938e-02f, 4.12742734e-01f, -4.76345122e-01f, -4.26195621e-01f, -2.86320090e-01f, 3.96459885e-02f, -3.02762091e-01f, 2.47475907e-01f, 8.18308219e-02f,
  -1.69182166e-01f, 4.08949435e-01f, -3.93687069e-01f, 1.51234686e-01f, -8.20744336e-01f, -1.48736286e+00f, 2.51911551e-01f, 9.63453412e-01f, -1.64393795e+00f, 7.51101434e-01f,
  -1.26745749e+00f, -3.95710528e-01f, -2.04976892e+00f, 4.19794917e-01f, 1.95200711e-01f, -3.26391682e-02f, 5.61677277e-01f, 1.56396016e-01f, -3.06770980e-01f, 1.07688762e-01f,
  1.97003260e-01f, 3.84795964e-01f, 2.09266767e-01f, -1.59272492e-01f, 1.28948838e-01f, 1.03645802e+00f, 7.75725693e-02f, -1.09334607e-02f, -3.56823891e-01f, -8.38137448e-01f,
  6.62958324e-01f, -3.62927377e-01f, -2.10851759e-01f, 3.53741497e-01f, 3.32774520e-01f, -2.18774050e-01f, -5.74600756e-01f, 6.70014262e-01f, -1.03930068e+00f, 1.27706206e+00f,
  -1.34504366e+00f, 6.77239895e-01f, -1.77215979e-01f, -1.47809708e+00f, -3.30981523e-01f, -1.25092614e+00f, -1.41092137e-01f, -1.77673444e-01f, 2.40163714e-01f, -3.55107844e-01f,
  -4.63013574e-02f, 6.36162758e-02f, -6.31975472e-01f, 1.92656636e-01f, -1.26031190e-01f, -8.73846784e-02f, -1.11917853e-02f, -1.28198004e+00f, -1.42521635e-01f, 3.17678958e-01f,
  -6.27889410e-02f, -3.74315977e-01f, 3.96372199e-01f, 1.93076313e-01f, 1.06427562e+00f, 1.10214509e-01f, -3.60315263e-01f, -9.66721401e-02f, 4.79597360e-01f, 1.11827385e+00f,
  -1.66733062e+00f, -2.15195441e+00f, 1.86480105e-01f, 1.00486708e+00f, -2.50453681e-01f, 3.21120650e-01f, 5.27573347e-01f, -8.42662513e-01f, 1.52013481e-01f, -1.16881430e-01f,
  9.44538936e-02f, 2.64543921e-01f, -5.19442081e-01f, 4.36278105e-01f, 2.33659714e-01f, -3.90733272e-01f, -3.66714090e-01f, -2.96968728e-01f, -4.18906897e-01f, 5.25402725e-01f,
  -1.09891266e-01f, 3.24054807e-01f, -9.35818925e-02f, -3.34796190e-01f, -2.33772829e-01f, -3.77538413e-01f, -4.96345043e-01f, 5.29745221e-01f, 8.34399521e-01f, -5.24815433e-02f,
  -8.24437663e-03f, 4.37357336e-01f, -6.30338132e-01f, -3.62567753e-01f, 7.39296496e-01f, -4.23158586e-01f, -2.48544991e-01f, 5.79104066e-01f, 1.85408164e-02f, 5.61975241e-02f,
  2.61947632e-01f, 2.06028223e-01f, -2.27604046e-01f, 1.73014209e-01f, -9.29052755e-02f, 1.41400322e-01f, 3.67287278e-01f, 8.28044564e-02f, 7.94775710e-02f, 9.21951160e-02f,
  -1.57602623e-01f, -5.69895387e-01f, -9.17635560e-02f, 4.61596787e-01f, -3.77256572e-01f, 1.13818049e-01f, -6.12809122e-01f, -4.61386472e-01f, -6.57313526e-01f, 4.26230729e-01f,
  -2.30427071e-01f, 1.83336198e-01f, 4.17023271e-01f, -1.48230004e+00f, 9.77083504e-01f, -7.98785836e-02f, -7.52349615e-01f, -1.36209166e+00f, -1.16646719e+00f, 2.51274735e-01f,
  9.44965720e-01f, -3.10354382e-01f, -7.28324056e-01f, 3.82068604e-01f, -2.14622077e-02f, -2.37305850e-01f, 3.64082366e-01f, 4.26470309e-01f, -9.06254649e-01f, 3.99256229e-01f,
  -3.89480591e-01f, 2.57082134e-01f, 1.02266276e+00f, -9.19612721e-02f, 4.24761862e-01f, -1.01899552e+00f, 6.32426143e-01f, 8.30252588e-01f, 6.63219452e-01f, 4.61540788e-01f,
  -4.78234082e-01f, -5.33784330e-01f, 5.99603236e-01f, 4.20078099e-01f, 3.06013525e-01f, -1.04366982e+00f, -1.26405799e+00f, -3.13131571e-01f, -1.21139431e+00f, -1.58982110e+00f,
  9.22562420e-01f, -1.26323998e+00f, -7.27525502e-02f, -8.10128033e-01f, -6.41370267e-02f, -4.52864110e-01f, -2.12900221e-01f, -4.99892607e-02f, 6.66678771e-02f, 6.32893890e-02f,
  -1.33575812e-01f, -2.22788051e-01f, -3.21235806e-01f, -3.30388099e-01f, 4.15966511e-01f, -5.20264208e-01f, -1.24568559e-01f, 1.74923822e-01f, 2.18591429e-02f, -3.20822507e-01f,
  -8.60853419e-02f, 1.23048097e-01f, 3.83815438e-01f, -3.92120816e-02f, -2.07798160e-03f, 2.43677765e-01f, -7.19841719e-02f, 1.32780206e+00f, -1.01642418e+00f, -1.34833264e+00f,
  -1.54210880e-01f, -8.74312580e-01f, 2.97060698e-01f, -9.78322148e-01f, 1.39687526e+00f, 2.75604635e-01f, 1.65550217e-01f, -1.26525998e-01f, 6.78171888e-02f, 3.99767548e-01f,
  -9.64319333e-02f, 3.76085937e-01f, 1.06682107e-01f, -2.00794861e-01f, 4.32185829e-03f, -3.93535614e-01f, 3.22058439e-01f, 2.67365396e-01f, -2.73957551e-01f, -4.09243256e-01f,
  -1.26214802e-01f, -2.51496702e-01f, 6.11487329e-01f, -1.33338511e-01f, 7.45482624e-01f, -4.77875501e-01f, -1.77899808e-01f, 4.22367275e-01f, 2.49983490e-01f, 1.32958961e+00f,
  1.50298631e+00f, -1.13535738e+00f, -7.77524352e-01f, -6.04187548e-01f, 1.33036822e-01f, -8.34953010e-01f, -6.33288860e-01f, -1.31824485e-03f, 7.92155921e-01f, -1.31423548e-01f,
  8.30452740e-02f, 4.09537591e-02f, -3.23826969e-01f, 5.06207168e-01f, 4.30474460e-01f, -4.46044147e-01f, -3.29647101e-02f, -2.15492204e-01f, -7.20607102e-01f, -8.78610834e-02f,
  -2.63409436e-01f, 1.06736135e+00f, 4.46734503e-02f, 2.44295701e-01f, -8.50031435e-01f, 2.55787551e-01f, -3.81104678e-01f, -1.63232833e-01f, 4.49127167e-01f, -9.09335315e-02f,
  -6.80849671e-01f, -7.37773299e-01f, -1.04204047e+00f, 8.42004001e-01f, 8.43116760e-01f, -1.72727215e+00f, 7.61298537e-01f, -1.26994157e+00f, -1.01457298e+00f, -6.16977751e-01f,
  -5.77699780e-01f, 2.88266152e-01f, 1.01808794e-01f, 1.48581967e-01f, 5.74227333e-01f, -9.51543227e-02f, -3.12943250e-01f, 7.77435601e-01f, 2.54982024e-01f, 1.17137119e-01f,
  6.05737150e-01f, -1.55910358e-01f, -5.57025969e-01f, -6.36878371e-01f, -4.15953547e-01f, 1.11701645e-01f, -1.78199857e-01f, -3.31836611e-01f, 1.08929491e+00f, -2.41119266e-01f,
  -4.13646251e-01f, 2.06933469e-02f, -8.26997161e-01f, 9.55036998e-01f, -4.87300009e-01f, -5.19517899e-01f, -4.13368225e-01f, -9.92124259e-01f, -7.63365030e-01f, 1.05342638e+00f,
  -4.03205872e-01f, -7.28696108e-01f, -1.21189348e-01f, 4.81469780e-01f, -2.73559898e-01f, 2.64732596e-02f, 5.20445645e-01f, -9.63287532e-01f, 6.37355566e-01f, 2.75813311e-01f,
  4.86541837e-01f, 7.05656350e-01f, -9.77913201e-01f, 5.14201581e-01f, 6.96331978e-01f, -5.14574587e-01f, 1.45002440e-01f, 6.86419964e-01f, 2.93239146e-01f, 5.18765450e-01f,
  -4.26334620e-01f, -9.31733698e-02f, -1.69652596e-01f, -4.73930091e-01f, 9.57957983e-01f, 1.60766053e+00f, -9.06491160e-01f, -1.05674255e+00f, 1.51480854e+00f, -6.71500981e-01f,
  -1.35382199e+00f, -1.29013097e+00f, -6.66251704e-02f, -2.20318839e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.47181541e-01f, 2.10346386e-01f, 5.93663931e-01f, -1.23189020e+00f, -3.77731510e-02f, 9.64847654e-02f, 2.83785760e-01f, -1.23729527e-01f, -6.49981260e-01f, -4.54204530e-02f,
  -8.64831746e-01f, 4.46773231e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    