/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.62281746e-01f, -1.57746579e-03f, 1.14090040e-01f, 1.71258807e-01f, -1.17765687e-01f, 8.97333119e-03f, 9.53250378e-02f, -1.30693465e-01f, 1.21566564e-01f, -3.97987552e-02f,
  -1.32001728e-01f, 2.25753918e-01f, -1.02664150e-01f, -1.82776406e-01f, 3.64023536e-01f, 2.41920818e-02f, 4.28497531e-02f, 1.36460483e-01f, -1.16268180e-01f, -6.99440530e-03f,
  2.08746884e-02f, -2.03533098e-01f, 7.17194229e-02f, -2.78502166e-01f, -9.12342314e-03f, -3.73519920e-02f, 1.27449214e-01f, -9.11182836e-02f, 1.79089978e-03f, -1.63986217e-02f,
  4.25061025e-02f, -2.31578290e-01f, 2.36826222e-02f, -1.20647490e-01f, -3.82671840e-02f, -1.08139624e-03f, 2.68693585e-02f, 1.67904701e-02f, -5.52418903e-02f, 7.34019186e-03f,
  1.18362375e-01f, -9.65969544e-03f, -9.00512412e-02f, -3.60917784e-02f, 5.60231581e-02f, 2.39393767e-02f, -1.12583470e-02f, 6.15649335e-02f, -1.22317471e-01f, 1.25305261e-02f,
  -5.89403361e-02f, 1.65533982e-02f, 5.49438223e-02f, 3.20504270e-02f, 7.31845060e-03f, 5.57374544e-02f, 7.65973255e-02f, 6.84850439e-02f, 7.10006207e-02f, 6.12035505e-02f,
  -7.84401689e-03f, -6.10651746e-02f, 2.21454334e-02f, -2.27033393e-03f, -9.05849263e-02f, -2.17461288e-02f, -2.04805918e-02f, -1.97427813e-02f, 1.06344000e-01f, 2.04901677e-02f,
  1.01281129e-01f, 1.22064808e-02f, -5.60765639e-02f, -7.66747817e-03f, 4.18080837e-02f, -4.41462472e-02f, 1.02250755e-01f, 5.92911765e-02f, 6.62428588e-02f, 6.08204566e-02f,
  -2.10169386e-02f, 7.77290836e-02f, -7.31508806e-02f, -1.40170427e-02f, -3.15701142e-02f, -1.68396272e-02f, -1.13347925e-01f, -7.20227789e-03f, 7.01421546e-03f, 5.23654483e-02f,
  -4.68935706e-02f, -8.68737549e-02f, -4.51717302e-02f, -1.04822386e-02f, 8.52016583e-02f, 5.76727055e-02f, 1.14822397e-02f, -1.46448158e-03f, -3.17171998e-02f, -5.88909984e-02f,
  -2.09305100e-02f, 1.15640685e-02f, 9.90406647e-02f, 4.45222482e-02f, -5.44946734e-03f, 6.35368377e-02f, 8.31376091e-02f, -2.85749491e-02f, -1.05476202e-02f, 1.54063711e-02f,
  4.99722101e-02f, 5.35162874e-02f, 5.52627109e-02f, 1.31652616e-02f, 7.30530694e-02f, 5.00423135e-03f, 5.78881912e-02f, -1.04182260e-02f, 2.19722986e-02f, -1.76576041e-02f,
  5.09077728e-01f, -3.98547985e-02f, 3.66192311e-02f, 3.16264406e-02f, 1.43847048e-01f, 1.87285125e-01f, 8.64891037e-02f, -4.28547226e-02f, -7.05091655e-02f, -2.15442657e-01f,
  -1.10050149e-01f, 2.42654264e-01f, -2.36633062e-01f, 8.38059932e-02f, 2.60422647e-01f, -1.70869038e-01f, 1.35145381e-01f, 9.63266641e-02f, 2.20644102e-02f, -3.94981727e-02f,
  -2.17591729e-02f, 1.18868472e-02f, 4.74073514e-02f, -5.71200512e-02f, 1.89062998e-01f, 6.44539520e-02f, -1.95607990e-01f, -6.13220483e-02f, 6.04003035e-02f, 1.83808893e-01f,
  6.11870103e-02f, -2.00404618e-02f, 3.79335657e-02f, -1.90883745e-02f, -3.39701101e-02f, 7.08207041e-02f, 5.15435562e-02f, 3.17667536e-02f, 1.24825072e-02f, -6.01398945e-02f,
  4.41214740e-02f, 1.03703298e-01f, -3.85973528e-02f, 2.61727739e-02f, 4.45562266e-02f, -8.01476371e-03f, 1.04570044e-02f, 9.55118686e-02f, 3.13030556e-03f, 1.21127948e-01f,
  2.70152092e-02f, 8.70029628e-02f, -1.19867940e-02f, -1.22852884e-02f, 8.17897692e-02f, 2.69867517e-02f, 6.14094250e-02f, 2.98517514e-02f, 1.04416003e-02f, 9.20040980e-02f,
  -5.97767085e-02f, -1.87431946e-02f, 5.96083403e-02f, -3.52044106e-02f, -9.22291353e-02f, -7.32572796e-03f, -2.53610201e-02f, -3.58129665e-02f, 2.75653806e-02f, 4.46441257e-03f,
  -1.60036534e-02f, 2.87212767e-02f, -2.67153680e-02f, 1.80340442e-03f, -1.31860022e-02f, 7.48535693e-02f, 3.39964181e-02f, 3.05254068e-02f, -2.54256073e-02f, 4.41314243e-02f,
  -5.22069708e-02f, 8.63634124e-02f, -7.58735603e-03f, -4.02023308e-02f, 1.46426051e-03f, 9.59761534e-03f, -1.54535295e-02f, 2.03450527e-02f, -9.89174023e-02f, 4.75356635e-03f,
  -1.09226525e-01f, -1.86229393e-01f, -1.32478714e-01f, 4.86497246e-02f, -5.34720980e-02f, -1.93175599e-02f, -2.71361489e-02f, 8.26834887e-02f, -8.13936293e-02f, 2.67911819e-03f,
  1.05051044e-02f, -5.54355495e-02f, -4.67677973e-02f, -8.63618450e-04f, 2.25611068e-02f, -6.30016923e-02f, -2.13233698e-02f, 1.40916491e-02f, -4.41323109e-02f, -1.01776887e-02f,
  9.72076971e-03f, -2.65517831e-02f, 4.97919843e-02f, 1.27408386e-03f, -1.53800016e-02f, 2.05137059e-02f, -2.23196857e-03f, -4.27390309e-03f, -8.81761312e-03f, -7.00874580e-03f,
  1.24486424e-01f, -1.99499413e-01f, -1.16263323e-01f, 1.14485942e-01f, 5.36927767e-02f, 2.74439692e-01f, 4.69092131e-01f, -1.69632822e-01f, 2.31950507e-01f, 9.24009681e-02f,
  2.87875473e-01f, -1.80680386e-03f, 1.61529958e-01f, 1.84600934e-01f, 3.45980406e-01f, 1.42011672e-01f, 2.13396534e-01f, 1.04075558e-01f, -8.88041779e-02f, 2.30363514e-02f,
  -6.33356627e-03f, 1.00454472e-01f, 9.74938506e-04f, -1.68181956e-01f, -9.21812728e-02f, -2.45243728e-01f, -1.24463521e-01f, -8.41749161e-02f, -1.71037316e-01f, 1.02598947e-02f,
  5.02203256e-02f, 7.41603002e-02f, -1.14574611e-01f, -9.95761994e-03f, 8.98205042e-02f, 2.78535541e-02f, 6.80053746e-03f, 6.71676099e-02f, 1.41860070e-02f, -3.36568169e-02f,
  -5.60838319e-02f, -3.61509286e-02f, -2.65335869e-02f, -1.51734957e-02f, -3.97622474e-02f, 9.23365261e-03f, -6.27475828e-02f, -7.23708123e-02f, -7.39077255e-02f, 2.48769484e-02f,
  9.61558074e-02f, -6.10819757e-02f, -1.19735971e-02f, -5.19869067e-02f, 8.88893008e-03f, 1.71333514e-02f, 1.72909647e-02f, 1.59853436e-02f, 2.57956684e-02f, 5.45417331e-02f,
  -3.33621241e-02f, -4.86127846e-03f, 8.38251412e-03f, -1.46136969e-01f, 7.65941218e-02f, -2.65525710e-02f, 4.68009673e-02f, -3.48024592e-02f, -3.02611720e-02f, 7.59144276e-02f,
  9.25118253e-02f, 2.93511059e-03f, -2.51146816e-02f, 6.76609948e-02f, 2.55303420e-02f, -5.27770855e-02f, 1.50627838e-02f, -1.15177460e-01f, 1.49846971e-02f, 3.45201194e-02f,
  7.27246553e-02f, -1.14885373e-02f, 1.96175240e-02f, -7.03281462e-02f, 1.12776369e-01f, -4.65615503e-02f, -9.35840309e-02f, -6.23311959e-02f, -1.14416301e-01f, 1.30793452e-02f,
  1.40221966e-02f, 4.12457287e-02f, 6.90491498e-02f, -4.67333160e-02f, 2.53096893e-02f, 6.21465705e-02f, 9.55459028e-02f, -5.89901470e-02f, -1.81077737e-02f, 2.72763688e-02f,
  -5.98685257e-02f, 2.58487258e-02f, -4.79994565e-02f, -4.29333299e-02f, -7.72142187e-02f, 4.85650264e-02f, 1.91327557e-02f, 6.06097914e-02f, 3.63042578e-02f, -5.25567718e-02f,
  2.51387600e-02f, 8.29995275e-02f, 5.86049743e-02f, 6.35277331e-02f, -2.44539278e-03f, 1.01333588e-01f, -4.94728759e-02f, -4.74555157e-02f, -3.17471102e-02f, 5.35462685e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.84353507e-01f, -2.16696076e-02f, 3.75545919e-01f, 3.65358740e-01f, 1.83285400e-01f, -8.24896619e-02f, 7.25742131e-02f, 2.14926705e-01f, 5.89162469e-01f, -1.54396594e-01f,
  -4.48404588e-02f, 5.54729886e-02f, -2.24863186e-01f, 9.47666615e-02f, -3.70115548e-01f, -2.00336367e-01f, 4.52562943e-02f, -1.90619770e-02f, 1.95370972e-01f, 1.84494525e-01f,
  2.10932329e-01f, -3.51043731e-01f, -1.20009914e-01f, -3.53466868e-01f, 2.33310580e-01f, 1.72533959e-01f, -3.30886751e-01f, -1.98214605e-01f, -9.54266340e-02f, -2.26306766e-01f,
  9.40211266e-02f, 2.81793952e-01f, 1.08717792e-02f, -1.76735315e-03f, 1.32018790e-01f, -6.24660663e-02f, -1.14647247e-01f, -1.43537104e-01f, 9.18188095e-02f, 1.02658771e-01f,
  -8.35107565e-02f, 4.10095742e-03f, -7.90261999e-02f, -8.50993171e-02f, 1.34339735e-01f, 1.88940719e-01f, 1.25810325e-01f, 2.60450989e-01f, 6.08594529e-02f, 3.49388085e-02f,
  1.33477151e-01f, 9.47185233e-02f, 1.62597746e-01f, -5.21502644e-02f, 3.14090177e-02f, 6.05347604e-02f, 1.85372028e-02f, -5.27928621e-02f, 8.05253014e-02f, 3.78409550e-02f,
  -1.70697555e-01f, -1.30938828e-01f, -1.47714708e-02f, 1.29854634e-01f, 4.96496931e-02f, 1.17650315e-01f, 5.03702722e-02f, -1.09953489e-02f, 9.90114287e-02f, -7.91433267e-03f,
  2.16735546e-02f, 2.47505493e-02f, 5.44303358e-02f, 5.98658137e-02f, 8.30549374e-03f, 1.05224654e-01f, -6.64366111e-02f, 4.73679136e-03f, 8.73632059e-02f, 3.03870067e-02f,
  -4.49916087e-02f, -4.11492288e-02f, -4.22153901e-03f, 4.38094027e-02f, -4.07181121e-02f, 5.90557456e-02f, 3.63794491e-02f, 1.44585520e-01f, -2.85938196e-02f, -1.68778926e-01f,
  -1.98511750e-01f, -4.61522371e-01f, -4.22152504e-02f, -1.09162880e-02f, -8.64109620e-02f, -2.83293594e-02f, -3.23760584e-02f, 6.60599470e-02f, -5.02832569e-02f, -8.38794783e-02f,
  -2.15146523e-02f, 3.12436074e-02f, 2.24407576e-02f, 7.06098750e-02f, -1.07542992e-01f, -3.88175361e-02f, -1.10490099e-01f, -1.73713714e-01f, -2.23893240e-01f, -1.32146806e-01f,
  -1.68566376e-01f, 6.60238415e-03f, -3.38666141e-02f, -4.45200922e-03f, -7.17181787e-02f, -4.83018570e-02f, 7.72467256e-02f, -1.50524722e-02f, -1.40289709e-01f, -8.35338905e-02f,
  -3.36806089e-01f, -3.15793216e-01f, 4.27174628e-01f, -2.02273265e-01f, 2.33081743e-01f, 3.99957061e-01f, 5.28854541e-02f, 1.93230174e-02f, -3.34863067e-01f, -3.82338494e-01f,
  -2.27236047e-01f, 1.15318194e-01f, -2.75673687e-01f, 2.40086913e-02f, 3.63789886e-01f, -5.99341504e-02f, 1.77420080e-02f, 3.65040787e-02f, 2.23337710e-02f, -8.01132470e-02f,
  5.51437065e-02f, -3.68875414e-02f, 2.07957655e-01f, 1.76979497e-01f, 7.34233782e-02f, -5.20496890e-02f, -5.74217141e-02f, 1.76841408e-01f, 1.51268795e-01f, 2.60801524e-01f,
  -2.36326218e-01f, -1.74317926e-01f, -8.26550461e-03f, 6.16375357e-02f, -1.52280433e-02f, 4.39155139e-02f, 9.45761278e-02f, 7.87078664e-02f, -4.17290106e-02f, -2.46549640e-02f,
  -1.21136211e-01f, 1.36899333e-02f, 9.07504186e-02f, -1.43268900e-02f, -7.63387457e-02f, -8.36679712e-03f, 4.69293445e-02f, -4.26610671e-02f, -2.65750196e-03f, 1.04737744e-01f,
  -3.01922485e-03f, -8.85517076e-02f, 4.45656329e-02f, 2.52963416e-02f, -1.62596523e-03f, -4.51496542e-02f, 5.05430214e-02f, 1.11422032e-01f, -5.92591800e-02f, -3.35362181e-02f,
  1.21999331e-01f, 3.30580287e-02f, -6.70503965e-03f, -1.02030359e-01f, 2.16641668e-02f, -5.76384366e-03f, -1.68282129e-02f, -2.18597502e-02f, -1.19460467e-02f, -1.47206694e-01f,
  -3.69755514e-02f, 2.40995325e-02f, -3.45012359e-02f, -1.39324561e-01f, -4.34557498e-02f, 3.05297878e-02f, -1.83657033e-03f, -1.11606419e-02f, -3.71727981e-02f, 6.85410202e-02f,
  -1.07382886e-01f, 6.75661638e-02f, 4.02017906e-02f, 5.26558720e-02f, -3.87810208e-02f, 1.07544689e-02f, -1.52925536e-01f, -1.68391522e-02f, -8.42539817e-02f, 3.66181247e-02f,
  -5.25137126e-01f, -3.95170599e-01f, -2.87295002e-02f, -1.83799475e-01f, -6.13782322e-04f, -4.61727753e-02f, 5.49918273e-03f, -5.98669983e-02f, -1.56636655e-01f, 6.67043962e-03f,
  -8.22031647e-02f, 2.87551135e-02f, -5.37603013e-02f, 2.39174757e-02f, 1.20023198e-01f, -1.03112593e-01f, -9.65458676e-02f, -7.15316683e-02f, -2.07327399e-02f, -4.08428116e-03f,
  -1.23086020e-01f, -2.26653833e-02f, 5.60289584e-02f, 3.21076773e-02f, 6.33915067e-02f, 1.24794273e-02f, 2.35557314e-02f, -2.47835685e-02f, 1.03169233e-01f, 3.19813415e-02f,
  4.89319302e-02f, 6.23989664e-02f, 6.35302737e-02f, 4.59270217e-02f, 2.82347411e-01f, 3.91646363e-02f, -9.00155902e-02f, 1.93860218e-01f, -2.76730269e-01f, 1.63325652e-01f,
  1.26480132e-01f, -1.84643894e-01f, -1.99195251e-01f, -7.14569390e-02f, -2.70002604e-01f, -3.40886503e-01f, 7.46569186e-02f, -1.66785061e-01f, -3.10371429e-01f, 2.46778667e-01f,
  1.36006176e-01f, 9.31558758e-02f, 5.45585863e-02f, 2.45406330e-01f, 8.39778334e-02f, 3.35287392e-01f, 4.46782887e-01f, 9.73988250e-02f, 1.80788398e-01f, -2.33384311e-01f,
  -1.03984125e-01f, -4.03285287e-02f, 3.52614298e-02f, -9.28887278e-02f, 2.56706417e-01f, 2.72833228e-01f, 1.69252306e-01f, -1.79711357e-01f, 5.85385934e-02f, 3.00732814e-02f,
  -8.13093502e-03f, -9.48596746e-02f, -2.61884063e-01f, -1.75659969e-01f, 7.17871562e-02f, 8.13008565e-03f, -4.56622383e-03f, 3.41436490e-02f, -2.79113017e-02f, -1.56289041e-01f,
  5.85396625e-02f, -9.33251251e-03f, 6.27480000e-02f, -1.72561094e-01f, -8.50165859e-02f, -8.26650485e-02f, 8.28465261e-03f, 1.55089036e-01f, -3.05945072e-02f, -4.22319546e-02f,
  -1.21912584e-01f, 1.89556211e-01f, 8.12304541e-02f, -6.92888629e-03f, -2.02372600e-03f, 2.31063552e-02f, -8.78894851e-02f, -9.83886719e-02f, -7.89719298e-02f, 5.94187416e-02f,
  1.38967142e-01f, 4.76162545e-02f, -1.65349841e-01f, 7.27838278e-02f, 4.70665609e-03f, 7.71248806e-03f, 9.50958952e-02f, 6.89853504e-02f, 1.48540840e-01f, 7.90111944e-02f,
  -8.06094855e-02f, 1.26220044e-02f, 1.01627052e-01f, -9.41000059e-02f, -2.53697950e-02f, 7.23880753e-02f, 7.02774897e-02f, -1.34435460e-01f, 1.62279740e-01f, 4.17821743e-02f,
  1.99095637e-01f, 6.54817298e-02f, -7.03529790e-02f, -8.18877965e-02f, 4.51226383e-02f, 1.18949749e-01f, -9.61321145e-02f, -7.83265978e-02f, -2.55069565e-02f, -9.57720801e-02f,
  1.34270042e-01f, 1.65648639e-01f, 2.67005078e-02f, -1.13877743e-01f, 4.25450951e-02f, 8.82143378e-02f, 3.23121361e-02f, -1.50433807e-02f, 1.20011427e-01f, 1.87288597e-01f,
  2.35369548e-01f, 5.44324666e-02f, -3.93127687e-02f, 1.29536241e-01f, -9.59923200e-04f, 1.39995262e-01f, 4.15956378e-02f, 1.81424856e-01f, -1.01399338e-02f, 8.54038373e-02f,
  -7.43658423e-01f, 4.15896952e-01f, -6.32872358e-02f, -3.04490149e-01f, 1.27179533e-01f, -1.93379745e-01f, -1.01329118e-01f, 1.37552872e-01f, 1.20937154e-01f, 9.30268615e-02f,
  3.49202268e-02f, -5.24271578e-02f, 2.42834091e-01f, -1.56798571e-01f, -1.57943323e-01f, 2.44680956e-01f, -3.52419138e-01f, -2.27267653e-01f, 1.37639850e-01f, -1.65367246e-01f,
  -1.36973605e-01f, -1.53229997e-01f, -1.18650116e-01f, 8.32833722e-02f, -1.76316589e-01f, -4.11804393e-02f, -2.94713229e-01f, 1.94985822e-01f, -1.94647029e-01f, 1.06714986e-01f,
  -4.91229832e-01f, -3.06474358e-01f, -3.28077406e-01f, -3.31718087e-01f, -2.20557511e-01f, -1.11547828e-01f, -2.85047263e-01f, 2.80061252e-02f, -1.51994172e-02f, -2.24407706e-02f,
  -6.52698874e-02f, 1.28916837e-03f, 2.60824468e-02f, 3.73026952e-02f, 4.79523800e-02f, 3.22793648e-02f, 5.37704900e-02f, -5.89723922e-02f, -4.56777439e-02f, 9.94812325e-02f,
  4.51732464e-02f, 3.33274975e-02f, -1.02142945e-01f, -9.23534408e-02f, 6.44228905e-02f, 1.02447988e-02f, -1.06327021e-02f, -1.36727706e-01f, -1.96766257e-01f, -2.99200956e-02f,
  1.15229346e-01f, 7.46755898e-02f, 6.88278079e-02f, 1.16801634e-01f, -9.48209781e-03f, 4.60908227e-02f, -6.53589815e-02f, 4.58089635e-03f, 3.54249664e-02f, 9.80266705e-02f,
  4.00402956e-02f, -5.54081686e-02f, 2.87889875e-02f, -5.20110913e-02f, -6.59899563e-02f, -2.09392374e-03f, -1.32465258e-01f, -1.90157332e-02f, -1.36805919e-03f, -3.49604078e-02f,
  -6.47639185e-02f, 1.10632367e-01f, 7.29148686e-02f, -6.18427694e-02f, -1.38403596e-02f, -1.41982445e-02f, -4.63641174e-02f, 7.01140016e-02f, -6.22815304e-02f, -2.78330613e-02f,
  -6.47045195e-01f, -4.21298236e-01f, -1.00658730e-01f, -1.84536844e-01f, -1.66107360e-02f, -9.20872986e-02f, 7.44247111e-03f, -4.92261462e-02f, -3.06935571e-02f, -5.73716611e-02f,
  -5.85877411e-02f, -7.04683959e-02f, -4.48417179e-02f, -5.40114716e-02f, -3.81773934e-02f, -8.80040135e-03f, -1.37660831e-01f, -1.62840739e-01f, -1.53519630e-01f, -4.55459114e-03f,
  -9.14084017e-02f, 3.49132140e-04f, 9.30408575e-03f, -6.81926012e-02f, -1.62130490e-01f, -1.24172159e-01f, -7.97818378e-02f, -2.16792300e-02f, -8.99602175e-02f, 2.27079801e-02f,
  1.07730910e-01f, 4.17573273e-01f, -2.33148143e-01f, 1.49334297e-01f, -2.59698540e-01f, 4.62952465e-01f, 5.32868445e-01f, -1.36057315e-02f, 1.79834470e-01f, 3.44028324e-01f,
  -4.87386659e-02f, 1.92059577e-01f, 1.82687119e-01f, 2.66395420e-01f, 2.47189537e-01f, 4.23729599e-01f, 3.05371255e-01f, 3.77926528e-01f, -1.39255691e-02f, 1.89706430e-01f,
  -6.21445244e-03f, 4.00928646e-01f, -1.89857453e-01f, -5.93549013e-02f, -4.17546071e-02f, -2.35120907e-01f, -1.98896274e-01f, -3.09597254e-01f, 1.69395059e-02f, -9.44712106e-03f,
  4.42423075e-02f, -2.62470245e-02f, -2.56721508e-02f, -2.92668715e-02f, -1.56019032e-02f, -5.42390458e-02f, -4.57231551e-02f, 1.00219548e-02f, -1.28272235e-01f, -5.33929020e-02f,
  1.90860540e-01f, 8.80889073e-02f, 1.01306498e-01f, -1.41372040e-01f, 5.50149307e-02f, -4.87449355e-02f, 1.50994270e-03f, -8.18151459e-02f, -2.73664352e-02f, -8.53272229e-02f,
  -5.31828627e-02f, 3.38102202e-03f, -9.11672693e-03f, 4.48811315e-02f, -1.16936982e-01f, -1.85297560e-02f, 1.59179106e-01f, -2.71263346e-02f, 1.02756351e-01f, 1.39000621e-02f,
  -3.18921432e-02f, 9.76742879e-02f, -1.17755635e-02f, -1.04541659e-01f, 9.44383517e-02f, -1.07196584e-01f, -2.60111615e-02f, -4.04395238e-02f, 4.04632278e-02f, 8.88101682e-02f,
  -7.35835880e-02f, 4.16977936e-03f, 1.06355445e-02f, 7.56016746e-03f, 1.31419539e-01f, 6.63109720e-02f, -3.28204334e-02f, 2.73629557e-02f, -2.66172108e-03f, -7.75996074e-02f,
  -1.10452347e-01f, 6.34056106e-02f, 6.28455803e-02f, -7.76191503e-02f, -2.55242493e-02f, -8.01792815e-02f, 1.56951286e-02f, -6.59165457e-02f, -2.48816870e-02f, -8.31389613e-03f,
  1.26493782e-01f, 3.20850372e-01f, -1.61860324e-02f, 6.87299669e-02f, -1.87770799e-02f, -3.09181511e-02f, 4.61121425e-02f, 8.10172707e-02f, 6.46024123e-02f, 1.56966791e-01f,
  -3.54521908e-03f, 1.33027360e-01f, 4.50855903e-02f, -6.15508668e-02f, -7.16298772e-03f, 1.26153663e-01f, 1.04647130e-01f, -7.89197683e-02f, -4.67908680e-02f, -1.06687397e-02f,
  7.81087251e-03f, 1.83685139e-01f, 1.39220208e-01f, 1.03771292e-01f, 8.01827759e-03f, 3.81380320e-02f, 1.99016985e-02f, -3.24380659e-02f, -6.36407686e-03f, -4.90110144e-02f,
  4.16782871e-02f, 4.31806266e-01f, 2.15585321e-01f, -2.06004813e-01f, -3.59013885e-01f, -2.61537760e-01f, -2.75903434e-01f, 3.49545404e-02f, 2.40820050e-01f, 4.64705974e-01f,
  -2.64470845e-01f, 5.16751707e-01f, 1.75088912e-01f, -2.53582485e-02f, -3.82907957e-01f, 7.28204697e-02f, -1.71217427e-01f, 3.38893570e-02f, -8.35939795e-02f, -1.94294170e-01f,
  -1.49439648e-01f, -3.82016629e-01f, -2.30514675e-01f, -2.16140062e-01f, -1.58197477e-01f, 2.30684746e-02f, -3.54253322e-01f, -2.66980201e-01f, -1.78842843e-02f, -1.45308390e-01f,
  -2.70926148e-01f, 7.56011978e-02f, 1.22395471e-01f, 1.68448240e-01f, -5.73405549e-02f, 9.38650370e-02f, -3.01410034e-02f, -5.91210872e-02f, -1.32271647e-01f, 1.48797810e-01f,
  8.57356414e-02f, 9.56497937e-02f, 5.33522926e-02f, 9.22053158e-02f, -3.54263396e-03f, 1.92139879e-01f, 4.06020544e-02f, -7.62521476e-02f, 9.13223401e-02f, 6.48717508e-02f,
  1.51447266e-01f, 5.94579391e-02f, -1.62097011e-02f, 3.67753468e-02f, -3.34330946e-02f, 3.62532400e-02f, -8.58814493e-02f, -4.91854642e-03f, 1.37189612e-01f, 2.20120456e-02f,
  -3.44011895e-02f, -9.73275676e-02f, -3.02786119e-02f, 1.11192495e-01f, 2.21922435e-02f, -5.24429046e-02f, 4.80886362e-02f, -1.28388986e-01f, -3.21125425e-02f, -1.57556415e-01f,
  -7.02921525e-02f, 8.72173756e-02f, 3.85418907e-02f, -2.88886558e-02f, -1.27519444e-01f, 1.57291546e-01f, -2.05535311e-02f, 4.04523388e-02f, 3.78067768e-03f, -1.69665590e-02f,
  2.58119218e-02f, 3.69683579e-02f, 8.46106708e-02f, -3.88388522e-02f, -4.85291705e-02f, 4.46721576e-02f, 1.19141147e-01f, 1.61110446e-01f, 3.78815057e-05f, -1.42615035e-01f,
  -4.56881851e-01f, -1.85418233e-01f, 5.51913902e-02f, 1.09756902e-01f, 4.38392200e-02f, 2.13840753e-02f, 3.28290276e-02f, 7.19881132e-02f, -1.17584653e-01f, 4.84598279e-02f,
  -9.01880395e-03f, 6.29182756e-02f, -1.02718882e-01f, -2.49090437e-02f, 7.34148696e-02f, -1.27597898e-01f, -1.97816640e-01f, -1.07195772e-01f, -1.96440354e-01f, 1.28133995e-02f,
  4.99393195e-02f, -7.59738535e-02f, 9.10051763e-02f, -7.09459707e-02f, -2.71409545e-02f, -2.23082602e-02f, 2.11100541e-02f, 1.83025464e-01f, -9.48779061e-02f, -4.93247285e-02f,
  2.65748471e-01f, -4.59479541e-01f, -1.68163434e-01f, 3.55471462e-01f, 2.83223361e-01f, -1.87533244e-01f, -7.32669607e-02f, 3.65963072e-01f, 1.87409353e-02f, -3.26014936e-01f,
  4.36462574e-02f, -3.58657032e-01f, -3.28072548e-01f, 1.36052340e-01f, 3.45462680e-01f, -3.92817318e-01f, 1.25012919e-01f, -1.17084935e-01f, -2.26997398e-02f, 4.15837094e-02f,
  3.01018298e-01f, 5.01654685e-01f, 2.83507764e-01f, 3.55458707e-01f, 8.96058828e-02f, 3.60474765e-01f, 3.69966030e-01f, 3.62424105e-02f, 3.73880267e-01f, 4.00728993e-02f,
  -4.14231606e-02f, -1.67938210e-02f, 2.26015449e-02f, -3.28435190e-02f, 6.91192374e-02f, 5.03375418e-02f, -7.73098469e-02f, 4.41093072e-02f, 1.00787334e-01f, -2.71638408e-02f,
  -3.67042199e-02f, 7.59321749e-02f, 5.01301959e-02f, 1.75597742e-02f, -1.20598346e-03f, 3.09087709e-02f, 6.50091143e-03f, -6.82680309e-02f, 6.87773302e-02f, -1.71833307e-01f,
  -1.40444830e-01f, -4.99945916e-02f, -5.23035936e-02f, -2.72534210e-02f, -9.18516889e-02f, -7.23365620e-02f, -1.71498638e-02f, -5.38629182e-02f, -1.05242744e-01f, -4.26504202e-02f,
  3.80922928e-02f, 9.09654703e-03f, -2.77337115e-02f, -3.62270698e-03f, 3.32601890e-02f, -9.08634812e-02f, -1.23588471e-02f, -1.34196147e-01f, -8.50793198e-02f, -1.49269611e-01f,
  8.81110802e-02f, 1.80675182e-02f, -2.67509278e-02f, 6.10204600e-02f, 5.83663508e-02f, 1.22442834e-01f, 9.11543816e-02f, -5.35146035e-02f, 3.35589349e-02f, -2.63943017e-04f,
  -2.00278983e-02f, 3.23921964e-02f, 1.37826987e-02f, 8.73916522e-02f, 4.77408469e-02f, -5.14954962e-02f, 5.73333614e-02f, -1.21328652e-01f, 9.34010372e-02f, -1.42270727e-02f,
  -2.06277981e-01f, -1.68234974e-01f, 6.47230968e-02f, 1.29612476e-01f, -3.85707505e-02f, -5.36051318e-02f, 3.36243957e-02f, 2.59632827e-03f, -5.38992584e-02f, -5.99592514e-02f,
  8.17279294e-02f, 1.98729903e-01f, -8.11756775e-02f, 1.82900801e-02f, 1.21562041e-01f, -6.32279972e-03f, 5.10063097e-02f, 4.82638702e-02f, 1.52976498e-01f, -4.46164832e-02f,
  5.48632964e-02f, 1.36959804e-02f, -1.15962385e-03f, 9.78384614e-02f, -2.83917263e-02f, -1.51238693e-02f, 7.33267069e-02f, -8.90822932e-02f, -3.69393900e-02f, -5.10138869e-02f,
  3.19211423e-01f, -3.21909547e-01f, -4.31939125e-01f, -2.90821522e-01f, -1.53496727e-01f, -3.79750013e-01f, -2.36920148e-01f, -3.34770441e-01f, -2.67916381e-01f, -7.00030401e-02f,
  -4.98308092e-02f, -2.17408054e-02f, 2.82312751e-01f, -3.64257783e-01f, 9.57900435e-02f, 3.44629824e-01f, -4.94545162e-01f, -1.57549068e-01f, -5.56806149e-03f, -1.50277391e-01f,
  -8.97641033e-02f, -9.93296430e-02f, -7.63574615e-02f, -1.23439491e-01f, -2.30949894e-01f, -1.55379340e-01f, 1.35387719e-01f, 1.79219469e-01f, -3.18819612e-01f, -2.74628866e-02f,
  -5.55201317e-04f, 1.65931523e-01f, -6.59361929e-02f, 9.74935386e-03f, 2.67235860e-02f, 1.06946863e-01f, 1.11578204e-01f, 1.63188249e-01f, 5.88478334e-02f, -3.77152674e-02f,
  7.05036595e-02f, 1.39809564e-01f, -2.41515502e-01f, 1.54811025e-01f, 6.26593654e-04f, -5.47349937e-02f, -9.23429132e-02f, -6.42104074e-02f, -1.07245952e-01f, 1.44490361e-01f,
  -4.86695543e-02f, -7.45382626e-03f, 5.46117835e-02f, 2.30291300e-02f, -9.01990980e-02f, -1.37450650e-01f, 6.78646266e-02f, 1.33934960e-01f, -5.11794426e-02f, -1.30934771e-02f,
  6.67805523e-02f, 1.83631361e-01f, 5.44870012e-02f, -3.76991071e-02f, 1.78154390e-02f, 2.27133408e-02f, 1.00067435e-02f, 1.52927101e-01f, -3.44577730e-02f, 1.41319633e-02f,
  -1.64896831e-01f, -6.98636770e-02f, 1.13249637e-01f, -1.48476306e-02f, -8.09539706e-02f, 9.57614630e-02f, 6.10102378e-02f, -4.42453548e-02f, -1.41258195e-01f, -2.20046759e-01f,
  7.78570026e-02f, 4.52878550e-02f, -9.09047574e-02f, 2.90446915e-02f, -3.71179730e-02f, -3.81052420e-02f, 5.73245995e-02f, 2.09683031e-02f, -5.31294793e-02f, 9.04785842e-03f,
  -1.72312468e-01f, 7.34777302e-02f, -1.45299897e-01f, -5.55328168e-02f, 2.15314049e-02f, -5.01925908e-02f, -8.83160010e-02f, -2.61792749e-01f, -1.97620213e-01f, -1.10041620e-02f,
  -9.66186449e-02f, 3.84174287e-02f, -1.05309740e-01f, -6.61809370e-02f, -8.53776038e-02f, -2.17938513e-01f, 1.54666483e-01f, 2.89924685e-02f, -8.10176358e-02f, -8.03375915e-02f,
  8.12668633e-03f, 1.35465175e-01f, 8.59648138e-02f, -4.75560548e-03f, 7.16726354e-05f, 1.24932509e-02f, -3.25199179e-02f, 9.79111269e-02f, 7.75675923e-02f, -6.43018633e-02f,
  -4.67128396e-01f, 6.89902306e-02f, -4.69066590e-01f, 2.03089088e-01f, -4.63337861e-02f, 1.26358464e-01f, 2.78800160e-01f, 6.49084300e-02f, -1.50235355e-01f, 3.33556592e-01f,
  2.97445685e-01f, -3.34845543e-01f, -4.02811728e-02f, 4.51000273e-01f, -5.36357872e-02f, 1.96705312e-01f, 4.38053995e-01f, 2.82070369e-01f, -1.91893205e-02f, -1.45511076e-01f,
  -1.22353017e-01f, 3.63843739e-01f, 5.68511970e-02f, 7.84154832e-02f, 7.93427676e-02f, -2.55251884e-01f, 1.34407267e-01f, -3.17932039e-01f, 3.09607655e-01f, -4.12334763e-02f,
  -1.18976317e-01f, -1.44223645e-01f, -9.03975591e-03f, -1.73553944e-01f, -2.00563241e-02f, -9.78090912e-02f, -2.92008799e-02f, -7.43384613e-03f, -1.13488786e-01f, -8.88357759e-02f,
  -1.28525287e-01f, -1.36674583e-01f, -6.31712005e-02f, -8.25237632e-02f, -2.75897905e-02f, -5.97429238e-02f, -7.62242898e-02f, 1.68610573e-01f, -5.66374976e-03f, -5.56599908e-03f,
  -1.35633528e-01f, 6.03140965e-02f, 8.92508551e-02f, 8.87134597e-02f, -8.28577131e-02f, 1.90802477e-02f, 6.09148666e-02f, -1.05145521e-01f, 2.65554059e-02f, -7.17626698e-03f,
  -3.18554975e-02f, -1.52443931e-01f, -1.35570895e-02f, -6.97944760e-02f, -6.93903938e-02f, 4.45831232e-02f, 6.75088018e-02f, 1.47905052e-01f, -5.87353185e-02f, 6.54710084e-02f,
  5.46354149e-03f, 2.10345886e-03f, 5.51333129e-02f, 2.13840492e-02f, 8.24032649e-02f, 1.19302049e-02f, -4.14479002e-02f, -5.01396284e-02f, -1.11395470e-03f, 1.36582375e-01f,
  6.17845654e-02f, 4.59271260e-02f, -5.98973222e-02f, 3.41820866e-02f, -5.42837754e-02f, -1.03493460e-01f, 3.34234722e-02f, 4.30611633e-02f, 6.09966591e-02f, 1.09083694e-03f,
  4.46491614e-02f, -2.06653222e-01f, -9.65834931e-02f, -7.73946345e-02f, -3.31692770e-02f, 2.04143170e-02f, 6.60891235e-02f, 6.55252393e-03f, -1.46060735e-02f, -7.09751621e-02f,
  -6.96915686e-02f, 1.33502617e-01f, -3.76115739e-02f, -8.65632072e-02f, -1.92100145e-02f, -6.46461695e-02f, -1.29455090e-01f, -8.10911208e-02f, 1.33020371e-01f, -2.64920238e-02f,
  6.31363317e-02f, -1.12499014e-01f, -5.32263599e-04f, -5.17527498e-02f, 1.75881535e-01f, 3.97090018e-02f, -8.03722590e-02f, -7.54167214e-02f, -3.30230035e-02f, -1.75440405e-02f,
  -1.56668022e-01f, 1.08049095e-01f, 2.21243631e-02f, 1.41163096e-01f, 2.38549292e-01f, 1.44384354e-01f, 3.80493969e-01f, 2.83109576e-01f, 5.38684845e-01f, 1.43378943e-01f,
  -5.08907400e-02f, 2.05647826e-01f, -4.92140986e-02f, 2.52808649e-02f, -1.78333998e-01f, -1.91999048e-01f, -1.87254008e-02f, 9.86173749e-02f, 4.34281260e-01f, -4.50252108e-02f,
  -4.43969816e-02f, -2.38839444e-02f, -2.82865435e-01f, 1.96996126e-02f, -4.01554145e-02f, 1.25208989e-01f, -2.63378918e-01f, 1.49867684e-01f, -1.56191781e-01f, 6.33271337e-02f,
  -3.96273360e-02f, 1.87038347e-01f, -2.10349727e-03f, 2.57013552e-02f, -9.48760286e-02f, -8.06726329e-03f, -1.21106535e-01f, -6.95363246e-03f, 1.37263328e-01f, 1.02571316e-01f,
  3.31363641e-02f, -9.90909487e-02f, -8.85362998e-02f, 9.73434653e-03f, 1.46724761e-01f, -3.10820770e-02f, 7.48527870e-02f, 1.49285886e-02f, 1.46483764e-01f, -1.79938767e-02f,
  -1.97203130e-01f, -1.57089114e-01f, -8.85851756e-02f, 1.11315615e-01f, 2.46085320e-02f, 1.53146043e-01f, 1.17181540e-02f, -1.37381941e-01f, -2.71382704e-02f, 1.06244624e-01f,
  -1.86826987e-03f, -6.82212086e-03f, 8.38380828e-02f, -2.07076129e-02f, -5.50314039e-02f, -9.40954760e-02f, -2.26649512e-02f, -9.20505449e-02f, 7.15216473e-02f, -5.41300327e-02f,
  1.64289288e-02f, 1.46106020e-01f, -1.58927608e-02f, -4.95917350e-02f, 4.33927141e-02f, 2.72921324e-02f, -8.78038816e-03f, -7.08130673e-02f, 5.35249077e-02f, -8.48674849e-02f,
  -4.93424525e-03f, -5.08589260e-02f, -5.69541529e-02f, 6.56528398e-03f, -6.79202005e-02f, 1.27394214e-01f, -1.04394726e-01f, -2.87178624e-03f, 7.38843624e-03f, -9.43896621e-02f,
  1.42162457e-01f, 3.48231196e-01f, 1.18479103e-01f, 5.89857176e-02f, 1.41912000e-02f, -3.50388624e-02f, 1.10701762e-01f, -1.19227758e-02f, 9.65876132e-02f, 6.99550137e-02f,
  -7.71008134e-02f, 2.74033658e-02f, -2.08632365e-01f, -1.69967990e-02f, -8.22393373e-02f, 1.11812249e-01f, -4.42683473e-02f, 1.23097353e-01f, 2.63316389e-02f, -1.05823979e-01f,
  -1.21788315e-01f, 2.97448020e-02f, 6.68825433e-02f, 1.39400110e-01f, -2.60667894e-02f, -3.20654013e-03f, 9.19598639e-02f, 8.45926628e-02f, -2.66069025e-02f, 2.08539772e-03f,
  3.27123165e-01f, 2.97878981e-01f, 3.71619403e-01f, 2.53479809e-01f, -3.73420715e-01f, -5.58938563e-01f, -4.17784363e-01f, 1.64802019e-02f, -9.80938971e-02f, 6.69170171e-02f,
  -1.01408716e-02f, 3.22162002e-01f, 1.13841318e-01f, 2.25332111e-01f, -1.17361121e-01f, -2.43171334e-01f, 5.69864288e-02f, 1.66569520e-02f, -4.34155427e-02f, 2.77800500e-01f,
  1.59148619e-01f, -6.17616959e-02f, 2.46706828e-01f, 6.13505626e-03f, 4.37342823e-02f, 2.54516035e-01f, 2.24929839e-01f, 7.02321976e-02f, 1.96305260e-01f, -1.50167793e-01f,
  -1.06223315e-01f, 1.98353738e-01f, 8.97931308e-02f, 2.20751502e-02f, 4.95799538e-03f, -9.60558802e-02f, -1.66337844e-02f, -7.96001926e-02f, -7.56084248e-02f, -7.80509189e-02f,
  7.04565719e-02f, -2.36501750e-02f, -2.39779633e-02f, -9.66019258e-02f, 5.47961630e-02f, -5.97778559e-02f, 1.10411480e-01f, 3.03503275e-02f, 8.48570764e-02f, 1.87133327e-01f,
  1.93595380e-01f, -2.67064068e-02f, 1.20176449e-01f, -2.76809148e-02f, 8.14790875e-02f, -5.05189374e-02f, -8.25577788e-03f, 1.46193773e-01f, -1.27362572e-02f, 3.64443399e-02f,
  8.22954476e-02f, -1.55807501e-02f, 1.45725207e-02f, -4.28949073e-02f, -3.75322178e-02f, -1.31832615e-01f, -3.54016833e-02f, -1.76460575e-02f, -6.15329891e-02f, -2.40969509e-02f,
  -6.96317255e-02f, 4.44780216e-02f, -5.88654131e-02f, 4.27884310e-02f, 1.15631647e-01f, -2.11752187e-02f, -2.02195197e-02f, -4.42349166e-02f, 2.65656188e-02f, -8.07979181e-02f,
  -7.94394687e-02f, 9.40690283e-03f, -3.42557393e-02f, 2.61689760e-02f, -1.32147849e-01f, 9.80233587e-03f, 2.13617459e-01f, 7.30806515e-02f, -2.04277895e-02f, -2.50172652e-02f,
  4.17250246e-02f, 4.38145310e-01f, -2.34358571e-03f, -1.75383702e-01f, -1.20825142e-01f, -9.16443467e-02f, -5.46126105e-02f, 3.02065592e-02f, 8.78845006e-02f, -4.29399610e-02f,
  3.07744592e-02f, -3.64881195e-02f, -1.40841797e-01f, 3.09237931e-03f, -2.31516324e-02f, 5.52156158e-02f, 6.67040870e-02f, -4.26552668e-02f, 4.02327292e-02f, 9.04168263e-02f,
  1.45434558e-01f, -5.54518215e-03f, -8.05078540e-03f, -1.54723719e-01f, 6.29696026e-02f, -3.24855484e-02f, -7.24757910e-02f, 8.25468153e-02f, 1.28307238e-01f, 1.03299469e-02f,
  3.11141580e-01f, 2.69920766e-01f, 6.47845045e-02f, -1.10265076e-01f, -3.93217862e-01f, -3.02904248e-01f, -4.61015493e-01f, -7.25506842e-02f, -2.99893260e-01f, -2.71029323e-01f,
  -4.07378256e-01f, -2.56656278e-02f, 7.44125023e-02f, -1.00039475e-01f, 4.35009629e-01f, 1.73093095e-01f, 2.39263862e-01f, -3.01581174e-01f, 2.31335819e-01f, 2.56131500e-01f,
  3.02938789e-01f, 2.03500152e-01f, 4.72657293e-01f, 1.98259160e-01f, 1.24072075e-01f, 7.43911713e-02f, 1.58309460e-01f, -1.22772016e-01f, -1.99972957e-01f, -8.18262026e-02f,
  2.40741484e-02f, 2.27008626e-01f, 1.10416383e-01f, 1.34161413e-01f, 1.71108484e-01f, -5.46056479e-02f, -1.68126971e-01f, -9.35792699e-02f, -1.65214270e-01f, -1.44947812e-01f,
  3.12095378e-02f, 1.64959822e-02f, -1.88699886e-02f, 2.26510819e-02f, -8.75220895e-02f, -9.21437517e-02f, 3.62618873e-03f, -3.69850025e-02f, -1.21460401e-01f, 1.86579987e-01f,
  2.61100996e-02f, -1.15226857e-01f, -1.00322999e-02f, 2.58386340e-02f, -1.50924638e-01f, -1.16654731e-01f, -4.85799164e-02f, -8.80972892e-02f, -1.23512939e-01f, -4.02709506e-02f,
  1.96697444e-01f, 4.00642529e-02f, 1.22644357e-01f, -5.58811203e-02f, 8.20826516e-02f, -9.93052125e-02f, 2.31335368e-02f, -6.05012849e-02f, 2.88590640e-02f, -2.58951411e-02f,
  -1.94063410e-01f, 1.45092299e-02f, -1.13145329e-01f, -6.90589026e-02f, 1.58822000e-01f, 2.90992141e-01f, -3.55432071e-02f, -8.63406584e-02f, -1.64450169e-01f, 5.81698772e-03f,
  -1.70116723e-02f, 6.18577749e-02f, 2.80364733e-02f, -2.26292714e-01f, -2.31689692e-01f, -5.20882457e-02f, 1.22786313e-02f, 8.17177165e-03f, 7.61306360e-02f, 3.31273563e-02f,
  -5.68347275e-02f, 3.60148460e-01f, -9.76915192e-03f, -9.52278227e-02f, 5.11105470e-02f, 1.07822254e-01f, -3.76221025e-03f, -2.79656816e-02f, -3.20963711e-02f, 1.60128385e-01f,
  1.98021601e-03f, -1.85356483e-01f, -1.17399938e-01f, -1.40589215e-02f, 2.54101697e-02f, 2.98255403e-02f, -1.26335725e-01f, -1.26955807e-01f, 2.95786024e-03f, 1.42951488e-01f,
  -5.23586497e-02f, -8.15984830e-02f, 1.12625979e-01f, 1.40149472e-02f, -4.25746590e-02f, -2.02713773e-01f, 1.39693245e-01f, -1.27079606e-01f, 1.15214869e-01f, 4.03466374e-02f,
  1.33295894e-01f, 3.35212708e-01f, 1.27071038e-01f, -5.48256785e-02f, 1.29503459e-01f, -1.67272493e-01f, -2.96621565e-02f, 1.06609888e-01f, -1.33609995e-01f, 1.87522784e-01f,
  -2.56983429e-01f, 1.76118314e-01f, -9.77999866e-02f, -3.68820250e-01f, -6.42074943e-01f, -4.71238881e-01f, -2.14547619e-01f, -2.56349221e-02f, -1.50190160e-01f, 1.60031602e-01f,
  -2.07611874e-01f, -2.58517951e-01f, -1.86891347e-01f, 5.04229628e-02f, 3.63838434e-01f, 3.37574303e-01f, 1.68108027e-02f, 7.62190223e-02f, 1.42553270e-01f, -1.10629424e-01f,
  -2.85317041e-02f, -5.13582900e-02f, 1.95990071e-01f, -3.52051519e-02f, -5.62811792e-02f, 2.08578184e-01f, 8.50742385e-02f, -1.44026391e-02f, -1.39859229e-01f, -3.35985161e-02f,
  1.30203560e-01f, -5.02763130e-02f, 4.37275842e-02f, -7.22927079e-02f, 6.40244037e-02f, 1.71102900e-02f, -4.09765616e-02f, 9.84745398e-02f, -1.29343697e-03f, 1.03116047e-03f,
  -6.83192387e-02f, 5.00917360e-02f, 4.33732197e-02f, 5.74083105e-02f, -1.27084777e-01f, -1.05385119e-02f, 6.66581467e-02f, 1.00544110e-01f, 6.65222183e-02f, 7.16674030e-02f,
  2.09892899e-01f, 7.78385624e-02f, -8.60648230e-02f, -8.33286345e-02f, 5.90215344e-03f, -1.42127264e-03f, -7.03368410e-02f, -3.61289382e-02f, 1.75527353e-02f, 8.30474403e-03f,
  -4.78569418e-02f, 1.44091994e-01f, -3.14060599e-02f, 1.11612067e-01f, 7.10735470e-02f, 8.17204416e-02f, 2.41858717e-02f, -7.77057186e-02f, -2.26299204e-02f, -6.39098957e-02f,
  1.82160940e-02f, -6.22400045e-02f, 7.26386765e-03f, 6.14788011e-02f, -1.63362682e-01f, -5.58420196e-02f, 3.75706963e-02f, 1.01437951e-02f, -6.53710589e-02f, 1.38524041e-01f,
  6.79289624e-02f, 7.45234191e-02f, -3.19834352e-02f, -1.23569984e-02f, -2.18716953e-02f, -3.42484415e-02f, -6.04993254e-02f, 2.52010510e-03f, -1.23166787e-02f, -7.86503702e-02f,
  9.58099142e-02f, 7.52436370e-03f, 1.20386407e-01f, 4.57716249e-02f, -7.54969791e-02f, 1.80475053e-03f, -3.40863317e-02f, 3.93669344e-02f, 1.33291528e-01f, 5.19731129e-03f,
  1.70053184e-01f, -2.86340583e-02f, 2.19046846e-02f, 5.16654477e-02f, 8.59019160e-02f, 3.09413299e-02f, 2.29075016e-03f, -7.01292083e-02f, 5.11546731e-02f, -2.32434161e-02f,
  -1.74112231e-01f, 1.50873557e-01f, -1.65444598e-01f, -3.46286178e-01f, -2.17229389e-02f, -1.22561224e-01f, -3.13750863e-01f, -3.89447622e-02f, -2.95296479e-02f, -2.40290120e-01f,
  -3.27181160e-01f, 4.27964069e-02f, 2.77848393e-01f, -3.84325713e-01f, 3.82651150e-01f, 2.99654365e-01f, -2.16866761e-01f, -3.54414016e-01f, 1.83469847e-01f, -3.11081558e-01f,
  -9.68179852e-03f, -3.26149464e-01f, -8.20718333e-02f, -1.19091533e-01f, -1.59693062e-01f, -9.02026966e-02f, -4.64829355e-02f, 6.17931336e-02f, -2.59086043e-01f, 6.71099350e-02f,
  -4.57561063e-03f, -3.08036685e-01f, -1.19180866e-02f, -1.09238297e-01f, -1.52795985e-01f, -4.11785692e-02f, -1.25309601e-01f, 6.49289228e-03f, 2.43024919e-02f, -1.21502466e-02f,
  6.94232583e-02f, -3.74239124e-02f, 9.25136823e-03f, 7.24222139e-02f, 8.04831982e-02f, -5.53042777e-02f, 1.67637039e-02f, 1.42301582e-02f, 6.42053857e-02f, 1.46750405e-01f,
  3.00904606e-02f, 5.64915277e-02f, -1.42044440e-01f, -6.95768669e-02f, 3.51548195e-02f, -4.24376018e-02f, 4.68049981e-02f, 1.50639296e-01f, 4.30600755e-02f, -1.60050113e-02f,
  -2.66243722e-02f, -6.02061637e-02f, -5.34008518e-02f, -1.58819836e-02f, 1.50868781e-02f, -3.37408595e-02f, 4.17263955e-02f, -7.06045032e-02f, -1.26013398e-01f, 1.06283370e-02f,
  -1.71089638e-02f, -1.18343830e-02f, -5.55046201e-02f, -1.18893571e-02f, -3.54427099e-02f, -6.94381744e-02f, -6.95984662e-02f, 7.92125519e-03f, 2.45076958e-02f, 4.83756997e-02f,
  -7.92814866e-02f, -7.30947703e-02f, -5.17461561e-02f, -1.50876418e-01f, -7.69958179e-03f, 1.42243654e-01f, 5.81056513e-02f, 2.60733292e-02f, -9.83433612e-03f, 7.94243291e-02f,
  -1.00825531e-02f, -4.34841245e-01f, -7.90386647e-03f, -1.56246293e-02f, -5.65033108e-02f, 3.25744553e-03f, -3.58965769e-02f, 1.37884006e-01f, -5.48935868e-03f, -1.45184681e-01f,
  -3.66790742e-02f, -1.39401853e-01f, -3.51868011e-02f, -4.68048528e-02f, 1.30538493e-01f, 4.41197008e-02f, -5.19360490e-02f, 1.09548949e-01f, -1.41055062e-01f, -2.51996182e-02f,
  -3.47121842e-02f, -3.63000296e-02f, 1.25177605e-02f, -1.34188652e-01f, -6.88158274e-02f, -1.15361392e-01f, -5.78336306e-02f, 1.11131176e-01f, 2.24860199e-02f, -5.88238500e-02f,
  -8.77278090e-01f, 3.78330410e-01f, -1.07142337e-01f, -1.96057618e-01f, 2.05634177e-01f, -1.18237250e-01f, -3.02173458e-02f, -2.07317453e-02f, -6.44880310e-02f, 3.22899222e-01f,
  1.53123260e-01f, -9.07584578e-02f, 2.97278732e-01f, 1.14557065e-01f, -6.40276849e-01f, -1.84612889e-02f, -2.28634030e-01f, -1.77087292e-01f, 2.73418035e-02f, -1.41150177e-01f,
  -2.15338469e-01f, 1.91254035e-01f, -6.76453412e-02f, 4.95342076e-01f, -8.70456249e-02f, 8.34763888e-03f, -7.50860721e-02f, 3.11757743e-01f, -2.30792776e-01f, 3.81829776e-02f,
  -3.49083543e-01f, 6.50914833e-02f, 4.57890984e-03f, -2.19551977e-02f, -1.53669700e-01f, -6.85637966e-02f, -5.84422797e-02f, -6.64962158e-02f, -2.22967677e-02f, -1.03068218e-01f,
  -7.61161968e-02f, 7.95087963e-02f, -5.02026752e-02f, 9.67133865e-02f, 3.19146970e-03f, 1.11994371e-01f, 9.96562392e-02f, -4.03174348e-02f, 2.42424719e-02f, -6.34772480e-02f,
  -3.91299184e-03f, -4.10134718e-02f, -7.27141649e-02f, -1.13979824e-01f, -9.52634141e-02f, 5.77517673e-02f, 2.94064414e-02f, -4.71115112e-03f, -6.11367933e-02f, -4.62353453e-02f,
  5.92627302e-02f, -1.47240281e-01f, 5.95652387e-02f, -4.59910370e-02f, 1.25419609e-02f, 2.48321351e-02f, 5.49385436e-02f, -1.75580033e-03f, -2.86773499e-03f, 2.83154584e-02f,
  2.21349229e-03f, -8.09460059e-02f, 2.07615495e-02f, -3.16181816e-02f, 1.58779621e-02f, -7.44918510e-02f, 4.69717942e-02f, 5.96982017e-02f, -9.86088961e-02f, -4.28983718e-02f,
  7.43149780e-03f, -1.97850894e-02f, 1.48839466e-02f, 1.15692746e-02f, 7.48080686e-02f, -3.20030786e-02f, 3.14869322e-02f, 4.81270626e-02f, -2.66221743e-02f, -5.35969622e-02f,
  -4.73030120e-01f, -2.96202093e-01f, 3.38598974e-02f, 6.98283613e-02f, -1.21325324e-03f, -4.57263738e-02f, -7.15513006e-02f, -7.46588409e-02f, -4.40309979e-02f, 1.50922481e-02f,
  -2.37207301e-02f, 2.54635606e-02f, -2.23806217e-01f, 2.10843403e-02f, 1.41657889e-02f, -1.14472926e-01f, -5.59740607e-03f, -4.15056609e-02f, -1.16501898e-01f, 2.74579134e-03f,
  8.63337815e-02f, 9.02078748e-02f, 7.11960047e-02f, 3.93382944e-02f, -4.32409309e-02f, -1.15385745e-02f, -1.13604896e-01f, 4.33032475e-02f, -5.62222563e-02f, 2.47145295e-02f,
  6.71964884e-01f, -3.87491137e-01f, -1.46019265e-01f, 2.75158376e-01f, 3.66392106e-01f, 3.78856689e-01f, 4.07299757e-01f, -1.57200232e-01f, -3.37843294e-03f, -3.71154666e-01f,
  1.65499523e-01f, -9.33011919e-02f, -1.09295517e-01f, 2.80906290e-01f, 6.44420207e-01f, -6.07292168e-02f, 2.44678944e-01f, 4.31991145e-02f, -6.34063408e-02f, 1.78075761e-01f,
  2.88306147e-01f, 5.58127165e-01f, -1.40214130e-01f, -2.60638684e-01f, 3.32930595e-01f, -3.76242816e-01f, -2.72805959e-01f, -7.46615902e-02f, -9.09471661e-02f, 1.54812664e-01f,
  1.11335553e-01f, 2.95315012e-02f, 4.87578884e-02f, -2.05216389e-02f, -5.55942655e-02f, 6.05422519e-02f, 1.33485803e-02f, 4.02674600e-02f, 9.53283384e-02f, -6.30037338e-02f,
  6.38783053e-02f, 1.17269017e-01f, 4.29484770e-02f, 1.00604132e-01f, 1.94396302e-01f, 2.34286394e-02f, -6.03872165e-02f, -6.37145936e-02f, -2.23839775e-01f, 1.12971932e-01f,
  -3.84737328e-02f, -9.86168087e-02f, 1.28708988e-01f, -2.06243873e-01f, -4.40904498e-02f, 1.26259085e-02f, -2.74607465e-02f, -8.72068852e-02f, -1.27056137e-01f, -1.29706254e-02f,
  6.69138432e-02f, 7.13536069e-02f, 6.83405697e-02f, 2.37656757e-02f, 1.00209504e-01f, 3.26035507e-02f, 6.68368563e-02f, -1.22698005e-02f, -7.67969415e-02f, 6.33621290e-02f,
  -4.14184593e-02f, 1.13064125e-01f, 2.67863143e-02f, 7.90737495e-02f, 9.69167501e-02f, 8.08545109e-03f, -2.87804590e-03f, -4.94746193e-02f, -4.45899107e-02f, -1.28020242e-01f,
  -9.35883354e-03f, 5.85045628e-02f, -4.46899943e-02f, -5.78804836e-02f, -1.86252799e-02f, 6.42820634e-03f, 5.24507686e-02f, 3.06581613e-02f, -5.10020405e-02f, 7.17128962e-02f,
  -8.42002854e-02f, -2.57538617e-01f, -1.37442291e-01f, -6.83098510e-02f, -8.57918337e-02f, 4.42697182e-02f, -2.76807006e-02f, -4.28721681e-02f, -1.02311783e-01f, 1.13640584e-01f,
  3.24407555e-02f, -2.23832875e-02f, -1.32574365e-01f, 3.39017324e-02f, 3.70949507e-02f, -3.89615968e-02f, -4.33666110e-02f, -1.62277564e-01f, -1.77491307e-02f, -9.63864401e-02f,
  -1.67228952e-02f, 6.53283149e-02f, 5.11453226e-02f, -3.35104726e-02f, -5.50528914e-02f, -9.02234539e-02f, -8.31710920e-02f, -4.66166716e-03f, 4.85997312e-02f, -8.20642710e-02f,
  -4.54288155e-01f, -4.38534245e-02f, 4.07859772e-01f, -1.48951292e-01f, 1.74585402e-01f, 4.36433613e-01f, 3.35892737e-01f, -2.19803929e-01f, -3.06824505e-01f, -1.84331551e-01f,
  -1.69152409e-01f, 9.81576219e-02f, 4.87036668e-02f, -1.90538049e-01f, 1.96990713e-01f, -5.54516204e-02f, -2.52436727e-01f, -4.30838130e-02f, -4.64018136e-02f, -4.99760546e-02f,
  -7.34631792e-02f, -2.39992470e-01f, 2.03362092e-01f, -8.14468861e-02f, 2.39545461e-02f, -8.44791345e-03f, -1.87920675e-01f, 2.72767782e-01f, 5.98925725e-02f, 1.56155586e-01f,
  1.53954998e-01f, -1.02654576e-01f, 5.57143241e-02f, 1.03981316e-01f, 4.47052345e-02f, 1.00083955e-01f, 4.93412092e-02f, 1.83841497e-01f, 2.45054826e-01f, -7.56016560e-03f,
  6.78996146e-02f, 9.08336267e-02f, -7.95501098e-02f, 2.05778219e-02f, -1.07454576e-01f, 3.15679424e-02f, 1.17918171e-01f, 1.10418789e-01f, 1.21665448e-01f, 6.35234565e-02f,
  8.83088931e-02f, 2.18553647e-01f, -7.57685490e-03f, -4.28893045e-02f, 6.68835863e-02f, 2.39804182e-02f, 7.72370696e-02f, 1.34215668e-01f, 3.24447751e-02f, 7.91958421e-02f,
  -1.19660310e-01f, -2.51747742e-02f, 3.06768734e-02f, 3.73195186e-02f, -1.08862385e-01f, -1.33504122e-01f, -6.35865256e-02f, -1.73887014e-02f, 3.05949319e-02f, -4.64414023e-02f,
  -3.37032080e-02f, -7.75495470e-02f, -2.76072063e-02f, 1.23586487e-02f, -5.38299643e-02f, -2.21641764e-01f, 4.65674587e-02f, 5.32723265e-03f, -2.16114707e-02f, 5.09704389e-02f,
  8.87442939e-03f, 9.38036516e-02f, -1.29394308e-01f, 1.59171540e-02f, 1.14657313e-01f, 8.82700682e-02f, 2.11076215e-01f, 3.50905061e-02f, -4.25471514e-02f, 4.57857922e-02f,
  1.06126219e-01f, -2.83368230e-01f, 9.37158614e-02f, 6.73268437e-02f, 3.38939093e-02f, -4.05557565e-02f, 3.85351703e-02f, -3.54053676e-02f, 1.03871591e-01f, -1.47851542e-01f,
  -8.73682424e-02f, 3.52147818e-02f, 1.87177896e-01f, -5.27675189e-02f, -8.61521158e-03f, -3.49500366e-02f, 4.93679866e-02f, -1.04133010e-01f, 1.58248559e-01f, -3.60205839e-03f,
  8.15381557e-02f, 1.71760432e-02f, -1.39194965e-01f, -2.00410202e-01f, -1.56317651e-01f, 6.16003796e-02f, -1.34632260e-01f, 7.57593587e-02f, 6.27858266e-02f, 1.76684093e-02f,
  -6.16673380e-02f, -1.95742592e-01f, 1.27694741e-01f, 2.20956892e-01f, -1.51516140e-01f, -7.87603483e-02f, -1.14316687e-01f, -7.57833123e-02f, -2.36453518e-01f, -2.82490462e-01f,
  9.45090577e-02f, 2.87796408e-01f, -1.15119755e-01f, 4.17169571e-01f, 5.69986641e-01f, -3.38246077e-02f, 3.08226079e-01f, 1.93078786e-01f, 9.73620638e-02f, 9.93526652e-02f,
  1.15906700e-01f, 2.25131989e-01f, 2.91569561e-01f, 2.04353735e-01f, 1.57251433e-01f, 1.66860744e-01f, 3.64024818e-01f, 2.73524433e-01f, 3.03311110e-01f, 3.16352576e-01f,
  -3.33973989e-02f, 1.85985845e-02f, -7.10901320e-02f, 3.01954057e-02f, 1.41851194e-02f, -8.51785615e-02f, 7.23194480e-02f, 1.16378471e-01f, 1.31689012e-01f, 5.81064858e-02f,
  -2.48106476e-02f, 1.29529878e-01f, 5.07272184e-02f, 1.11080892e-01f, -1.37558147e-01f, 6.37081861e-02f, -7.19381794e-02f, -2.79524177e-02f, -6.71099052e-02f, -1.33595198e-01f,
  -1.04862146e-01f, -4.06216383e-02f, -6.86477637e-03f, 1.37755871e-01f, -2.69455947e-02f, -6.64329007e-02f, 3.80633771e-02f, -7.25762397e-02f, 3.91957872e-02f, -9.63217542e-02f,
  7.11447224e-02f, -5.79285249e-02f, -1.50167912e-01f, -1.92952882e-02f, 7.09080324e-02f, -3.61895151e-02f, -1.74790360e-02f, 1.40313447e-01f, 5.80009632e-02f, 6.91144019e-02f,
  -1.06966449e-02f, 4.61242646e-02f, -8.19656178e-02f, -4.54018824e-02f, -3.34099233e-02f, -1.44236773e-01f, -3.78164537e-02f, 4.02149856e-02f, -1.13875307e-01f, 1.80985685e-03f,
  2.84260092e-03f, 5.73623041e-03f, -4.51920442e-02f, 9.06521007e-02f, -7.19594657e-02f, 2.57568457e-03f, -4.33183722e-02f, 6.05732091e-02f, -1.00489156e-02f, -5.03132446e-03f,
  3.81242372e-02f, 1.24340653e-01f, 9.42984447e-02f, -1.33808358e-02f, -3.57610472e-02f, 9.11209360e-02f, 7.57300705e-02f, 9.00597572e-02f, 1.31724790e-01f, 5.85155152e-02f,
  6.59101009e-02f, 2.72511225e-02f, -1.22672759e-01f, 7.12799430e-02f, 1.31610632e-01f, -1.48329511e-01f, 5.39270155e-02f, 1.21106490e-01f, 5.91021264e-03f, 1.78480707e-02f,
  5.98523170e-02f, -1.17687061e-01f, 1.50697082e-01f, 1.95775200e-02f, 1.66308247e-02f, 2.96298042e-02f, -4.85800654e-02f, -6.85202181e-02f, 9.04540252e-03f, 4.97660860e-02f,
  -7.46034691e-03f, -9.14287567e-02f, -6.16229713e-01f, -2.10255459e-01f, 5.19867837e-01f, 6.55942500e-01f, 1.47527799e-01f, 2.40080103e-01f, -5.89279607e-02f, 3.68829131e-01f,
  3.31621647e-01f, -1.93733513e-01f, -1.13469757e-01f, -1.07086711e-01f, -1.22779988e-01f, -4.07541037e-01f, 8.54924470e-02f, 3.01115261e-03f, -1.27404362e-01f, 1.14612788e-01f,
  -1.53132126e-01f, 3.28729540e-01f, -4.38356221e-01f, 3.24018359e-01f, 1.95073485e-01f, 3.63820530e-02f, 3.09860557e-01f, 1.09217204e-01f, 2.55489558e-01f, 1.83820829e-01f,
  -8.68752599e-02f, -1.08026512e-01f, -8.91740099e-02f, -1.07071273e-01f, 1.11626334e-01f, -2.18489617e-02f, 8.06801245e-02f, -9.74252522e-02f, -1.10977456e-01f, -3.28306593e-02f,
  6.09024987e-02f, -4.31965366e-02f, -3.70506360e-03f, -3.36661190e-02f, 1.10883601e-01f, -1.26873655e-02f, -7.33982027e-02f, 7.20779151e-02f, -7.51342475e-02f, -7.25752339e-02f,
  -1.33791730e-01f, -1.29281953e-01f, 1.09571721e-02f, -5.04727885e-02f, -4.74527571e-03f, 4.62298356e-02f, 2.25474183e-02f, -1.78100821e-02f, 1.93877250e-01f, 9.11708549e-02f,
  1.80183008e-01f, 7.28936419e-02f, -1.36100760e-04f, -4.42089215e-02f, 1.37811275e-02f, -1.15385026e-01f, 1.29333571e-01f, 9.48234741e-03f, -2.46544294e-02f, 3.00302152e-02f,
  1.63030833e-01f, -7.56238326e-02f, -4.61555123e-02f, 1.04126520e-01f, 6.71329871e-02f, -2.43462529e-02f, 5.24645187e-02f, 1.06923722e-01f, 5.18889762e-02f, -6.71637878e-02f,
  -5.56150302e-02f, 1.08345315e-01f, 1.85923409e-02f, 4.51213121e-02f, -6.54398231e-03f, 6.00637384e-02f, 2.47511622e-02f, 4.78576161e-02f, -7.00179264e-02f, 7.12515935e-02f,
  1.59538820e-01f, 2.14536995e-01f, 1.94170401e-02f, -1.70459710e-02f, 4.73985188e-02f, 1.07851759e-01f, -2.49589961e-02f, -4.10418846e-02f, 1.18003570e-01f, 8.29994529e-02f,
  1.03902305e-02f, 1.69422105e-02f, 2.46895343e-01f, 4.48086224e-02f, 2.86485087e-02f, 9.63230208e-02f, 1.17785342e-01f, -7.04523828e-03f, 1.95050105e-01f, 4.14950214e-02f,
  8.78540725e-02f, 1.85536116e-01f, 1.22635933e-02f, -1.46898050e-02f, 4.22650203e-02f, 4.03998718e-02f, 2.63445139e-01f, -9.95222032e-02f, 2.56380327e-02f, -1.19628705e-01f,
  1.38917686e-02f, 4.01697643e-02f, -3.48565191e-01f, 1.83992088e-01f, 2.78136671e-01f, 1.91546589e-01f, -1.96210921e-01f, 3.09456736e-01f, -1.98766798e-01f, 1.40062645e-01f,
  1.94341943e-01f, 1.87569428e-02f, -3.54699790e-01f, 5.01974404e-01f, 4.70609367e-01f, -1.78013757e-01f, 3.94002706e-01f, 1.65984049e-01f, 3.64537239e-02f, 1.96510360e-01f,
  1.16058916e-01f, 4.30960327e-01f, 6.34570420e-02f, 1.82681099e-01f, 1.73050612e-01f, -2.04938188e-01f, 1.37714863e-01f, -2.30761960e-01f, 1.88803524e-01f, 2.30864257e-01f,
  1.39214203e-01f, -9.93154123e-02f, -2.65643913e-02f, -1.75349966e-01f, -7.97317475e-02f, -5.38601093e-02f, -1.92064270e-01f, 1.02411900e-02f, -6.73554314e-04f, 1.60881951e-02f,
  -1.24139726e-01f, 7.66249448e-02f, 1.18435234e-01f, 1.14456393e-01f, 5.82455471e-02f, 1.09317727e-01f, 1.22394841e-02f, -2.12223828e-02f, -3.53575535e-02f, -1.59619749e-02f,
  -4.91241403e-02f, 3.79309282e-02f, -3.55262645e-02f, -2.66710706e-02f, 5.18644713e-02f, -3.46789584e-02f, -5.79927862e-02f, 4.17112596e-02f, 2.62902677e-02f, 5.45104630e-02f,
  8.87809321e-02f, -9.46805701e-02f, -2.82669589e-02f, 3.83313745e-02f, 8.31909012e-03f, 3.83268334e-02f, -8.94353017e-02f, -1.22956662e-02f, -7.31617212e-02f, 7.10624307e-02f,
  -4.55577945e-04f, 3.93002369e-02f, 2.11141668e-02f, -3.13717723e-02f, 4.35334668e-02f, -7.00831711e-02f, -6.33497909e-02f, 1.70674622e-01f, -1.18120080e-02f, 2.93679647e-02f,
  -1.42844126e-01f, 5.89167885e-03f, -4.86522429e-02f, -6.05763793e-02f, 2.77084950e-02f, -4.44580317e-02f, 9.99122933e-02f, 4.53931354e-02f, -3.22703756e-02f, -6.58682920e-03f,
  1.85545683e-01f, 1.36120453e-01f, -1.18293256e-01f, 7.96636865e-02f, -2.85515236e-03f, -7.17217755e-03f, -6.34729713e-02f, 3.39771956e-02f, -3.50503363e-02f, -7.53683923e-03f,
  4.50988561e-02f, -1.01184361e-01f, 1.91900544e-02f, 4.64939661e-02f, 5.92522621e-02f, 6.13947511e-02f, -1.11921340e-01f, -2.36011334e-02f, 1.19948678e-01f, 1.65283337e-01f,
  -5.59090935e-02f, 1.64399343e-03f, -6.20850595e-03f, -4.36168611e-02f, 1.36804074e-01f, -1.68713275e-02f, 6.47194013e-02f, 2.88523082e-02f, 5.30297719e-02f, 8.52901712e-02f,
  -9.12658989e-01f, -1.30226184e-02f, 4.00607854e-01f, -2.98200071e-01f, -2.09650293e-01f, 4.50417221e-01f, 3.65354091e-01f, 6.75588921e-02f, -1.09746687e-01f, 1.65805429e-01f,
  1.35686114e-01f, -2.72423983e-01f, 3.16732168e-01f, 2.39599243e-01f, 2.08882615e-01f, 3.64151448e-01f, 1.79486364e-01f, 1.83907285e-01f, -1.21088633e-02f, -1.97411701e-01f,
  -1.38435483e-01f, -5.90617545e-02f, 2.92889953e-01f, -1.88394964e-01f, -5.20432591e-02f, -2.90499270e-01f, -8.07979256e-02f, 7.23052174e-02f, -1.00313738e-01f, 4.36205082e-02f,
  -7.64586180e-02f, -2.40783364e-01f, 6.74822405e-02f, 1.09769225e-01f, -2.03239475e-03f, -2.41212081e-02f, 5.44346422e-02f, 1.02321446e-01f, -1.30154938e-01f, -8.50348324e-02f,
  -1.66569293e-01f, -5.93528114e-02f, -2.36196756e-01f, 7.53622875e-02f, -1.60066918e-01f, -1.09500773e-02f, -1.77566241e-02f, 9.27641764e-02f, 4.04353701e-02f, 8.00558850e-02f,
  1.76113874e-01f, 7.95837864e-02f, 1.67043284e-01f, 7.37565979e-02f, 7.19472989e-02f, -4.01682556e-02f, 1.35140643e-01f, 4.71198298e-02f, 2.86861658e-02f, -1.05916606e-02f,
  -2.95952875e-02f, 7.91930556e-02f, 1.02669939e-01f, 7.44796991e-02f, -3.83333340e-02f, 7.92685747e-02f, 8.82841721e-02f, -5.11161201e-02f, -5.56714050e-02f, -8.20841175e-03f,
  -5.30617051e-02f, -8.98828823e-03f, -6.05243184e-02f, 8.32663924e-02f, -1.95170138e-02f, -3.06564402e-02f, 6.56437427e-02f, -1.21373296e-01f, 6.05631471e-02f, -3.63173932e-02f,
  -5.90646500e-03f, -2.62629222e-02f, -1.01960450e-02f, -2.26343591e-02f, 4.95534278e-02f, 4.44943979e-02f, -9.83515233e-02f, 1.06453113e-01f, -2.81438585e-02f, 1.25593855e-03f,
  -4.00261655e-02f, -3.52008402e-01f, -2.07437482e-02f, -1.08517870e-01f, 1.71192456e-02f, 1.05550420e-02f, -1.37560228e-02f, -1.07745407e-02f, -9.14206877e-02f, -4.78349589e-02f,
  7.37585574e-02f, 6.52296320e-02f, -1.44169211e-01f, -1.52687123e-02f, 4.27121632e-02f, 1.00734062e-01f, -4.25068252e-02f, -9.45548713e-02f, 1.36947064e-02f, 7.59188831e-03f,
  -2.11175010e-02f, -1.24729224e-01f, 7.53345639e-02f, -4.15828452e-02f, -4.45946828e-02f, 5.95138259e-02f, -1.89519167e-01f, -8.56045261e-02f, -1.32691696e-01f, -4.19244915e-03f,
  -5.04786149e-02f, 9.85398740e-02f, 1.37011141e-01f, 3.50846946e-01f, 3.48429978e-01f, 1.64148703e-01f, -1.65100276e-01f, 5.39635718e-01f, 2.97023356e-01f, -4.59795266e-01f,
  -3.27509046e-02f, -3.07603270e-01f, -2.39137664e-01f, 2.07306534e-01f, 4.28987920e-01f, 1.30712196e-01f, 4.39596117e-01f, 2.11205743e-02f, 3.78127635e-01f, 2.80265808e-01f,
  3.36585939e-01f, 2.39597291e-01f, 3.50218534e-01f, 4.11508441e-01f, 9.90718305e-02f, 7.59434476e-02f, -1.23324022e-01f, -9.07287747e-02f, -9.37130824e-02f, -1.86618827e-02f,
  -1.87759966e-01f, 1.03977732e-01f, -9.40962061e-02f, -1.53110042e-01f, 1.32674053e-01f, -1.85181722e-01f, -1.25686035e-01f, -8.81570801e-02f, -1.93871800e-02f, -4.71391156e-02f,
  -1.49662480e-01f, 1.38975024e-01f, 1.56480130e-02f, 1.97950695e-02f, -7.39351511e-02f, 8.07968751e-02f, 1.87370807e-01f, 3.18576433e-02f, 8.26183856e-02f, 1.54509276e-01f,
  1.31927475e-01f, 1.15416564e-01f, 6.89600930e-02f, -3.12670805e-02f, 1.95320264e-01f, 4.64813188e-02f, -5.55981658e-02f, -5.79096489e-02f, 3.66235860e-02f, 8.04300606e-02f,
  1.06822088e-01f, -1.97201390e-02f, -6.70146272e-02f, -1.77870933e-02f, 7.96511211e-03f, 3.16496268e-02f, 1.90014411e-02f, -6.79992586e-02f, 2.78689750e-02f, -7.68078640e-02f,
  2.18877178e-02f, 5.44583984e-02f, 1.21893644e-01f, -5.83936721e-02f, -1.00809366e-01f, 6.15446530e-02f, -2.64247903e-03f, -4.42904048e-02f, 2.84701083e-02f, -1.32988635e-02f,
  7.18005979e-03f, 2.19464265e-02f, -3.86776812e-02f, -5.99659868e-02f, 5.14758527e-02f, 5.88696625e-04f, 1.32161304e-01f, 1.62109733e-02f, -6.33383915e-02f, 1.82737112e-02f,
  -5.63611649e-02f, 2.67409176e-01f, -2.25848798e-02f, -9.63298008e-02f, -2.82109249e-02f, 8.11156482e-02f, 1.06259331e-01f, 2.07430542e-01f, 2.81142369e-02f, 1.29101187e-01f,
  -1.75379291e-02f, -9.45118070e-02f, 9.27468855e-03f, -7.34450147e-02f, -9.20064747e-02f, 4.10541296e-02f, -7.86901489e-02f, -5.90626150e-02f, -1.53111480e-02f, 5.74215986e-02f,
  6.05206825e-02f, -4.64580153e-05f, -1.88312456e-02f, 1.16934538e-01f, -1.02517098e-01f, -1.18656173e-01f, -7.77953537e-03f, -2.80340947e-02f, 8.32474753e-02f, 2.17544436e-02f,
  7.36417919e-02f, 2.57635325e-01f, -3.58611524e-01f, -5.30112907e-02f, -2.23307401e-01f, 3.65022451e-01f, 2.87244797e-01f, 3.73631753e-02f, -2.47850925e-01f, 3.80240917e-01f,
  2.84193099e-01f, -1.48616672e-01f, 3.33616495e-01f, 4.49331999e-01f, -3.46113667e-02f, 3.75093490e-01f, 3.86285245e-01f, 2.28853106e-01f, -1.03354290e-01f, 1.95565507e-01f,
  4.81300615e-02f, 4.54586655e-01f, 1.52401313e-01f, 5.94089702e-02f, 1.95688784e-01f, -3.14129382e-01f, -8.49285871e-02f, -1.24334656e-01f, 5.35439663e-02f, -2.08438281e-02f,
  1.20059341e-01f, 2.40850206e-02f, -5.76567948e-02f, -3.52118514e-03f, -5.46685047e-03f, -9.09624994e-03f, -7.24712461e-02f, -8.96667093e-02f, -7.57988319e-02f, 5.89369684e-02f,
  2.78062429e-02f, -7.77148083e-02f, 3.46796103e-02f, -1.53263614e-01f, -1.14455648e-01f, -1.74829185e-01f, 3.00827101e-02f, -9.17635262e-02f, -2.18811184e-02f, 2.49909014e-02f,
  -1.43474070e-02f, -7.82386214e-03f, -6.34302050e-02f, -1.35961478e-03f, -1.10672943e-01f, -3.83375175e-02f, -4.08882499e-02f, -4.47161682e-02f, -4.62373234e-02f, -3.77217866e-02f,
  2.80158594e-02f, -5.65438857e-03f, 2.13377550e-01f, 6.65562823e-02f, 6.11535721e-02f, 7.95773696e-03f, 2.68611275e-02f, 1.53822824e-02f, -1.08968616e-01f, 8.88894349e-02f,
  -2.43227351e-02f, -9.50198993e-02f, 6.11767061e-02f, 5.82044087e-02f, 4.95010577e-02f, 2.50545936e-03f, -8.23713094e-02f, -2.74726786e-02f, 6.78640697e-03f, 1.65844951e-02f,
  -3.28246802e-02f, -1.26145140e-03f, 9.80120152e-03f, 7.33897090e-02f, 7.15976879e-02f, 9.65343136e-03f, 1.53586552e-01f, 6.24755025e-02f, -8.20952095e-03f, -5.23758233e-02f,
  9.89219993e-02f, -1.41329303e-01f, 9.61253792e-03f, -4.73616784e-03f, -2.59445030e-02f, 1.91082321e-02f, 7.09666312e-02f, 3.65241766e-02f, 1.33728273e-02f, 3.33486050e-02f,
  5.00348993e-02f, -4.96818274e-02f, -3.88496108e-02f, -3.42055485e-02f, -1.06039770e-01f, 8.14113319e-02f, 9.97142941e-02f, -1.72883309e-02f, -9.85117927e-02f, -3.68337929e-02f,
  -3.24066766e-02f, 1.56878997e-02f, -4.41837646e-02f, -5.65464161e-02f, -8.72028321e-02f, -2.34626811e-02f, -9.53714550e-02f, -5.93449734e-02f, -9.56160873e-02f, 3.30920406e-02f,
  6.25479817e-01f, -1.32687569e-01f, 3.42075109e-01f, 5.30630171e-01f, 3.63886267e-01f, 4.06526595e-01f, 5.37616968e-01f, 2.41582289e-01f, 5.99200487e-01f, -3.04134339e-01f,
  -3.30491751e-01f, -8.49298686e-02f, -1.88971777e-02f, 2.37328168e-02f, 3.24592113e-01f, 4.92510684e-02f, 2.39193320e-01f, 1.51211068e-01f, 2.81969160e-01f, -1.64486598e-02f,
  7.32235089e-02f, -2.10175887e-01f, -1.17118686e-01f, -2.17890531e-01f, 4.05611992e-02f, -1.20259784e-01f, -3.60564560e-01f, 4.69579063e-02f, -4.47443038e-01f, 3.61706726e-02f,
  -2.23517250e-02f, 1.11776493e-01f, -4.30716760e-02f, -7.93598816e-02f, 2.72421911e-03f, -1.90798882e-02f, -4.98517528e-02f, 1.82112139e-02f, 1.19613014e-01f, -2.00475127e-01f,
  -8.01074877e-02f, -8.30219761e-02f, 7.57409865e-03f, -4.37674411e-02f, -4.95970109e-03f, -1.73132673e-01f, -3.24425697e-02f, -1.81191474e-01f, 1.08823650e-01f, -1.10847048e-01f,
  -3.19455713e-02f, 2.53855884e-02f, 7.89825746e-04f, -2.27761254e-01f, -4.63400073e-02f, 1.39038730e-02f, 1.14070885e-02f, -2.48111505e-02f, -9.00036916e-02f, 1.56943351e-01f,
  1.52963743e-01f, 1.45667747e-01f, -6.70312718e-02f, -5.36375083e-02f, -2.89831012e-02f, -2.51810905e-02f, -1.26196846e-01f, -7.75742233e-02f, -1.39807373e-01f, -8.04440454e-02f,
  6.37264773e-02f, -5.12280203e-02f, 1.46879390e-01f, -8.59659817e-03f, 1.47317797e-01f, 1.95207130e-02f, -8.52635130e-02f, -6.88551366e-02f, -1.39172776e-02f, 1.18380807e-01f,
  9.58310738e-02f, 5.86724356e-02f, 7.59265665e-03f, -7.72162899e-02f, 8.24117393e-04f, 1.73106454e-02f, -1.00560404e-01f, 3.93687375e-02f, -2.03616079e-02f, -2.79073361e-02f,
  -1.69440761e-01f, -8.07504728e-02f, 2.16316059e-02f, -2.66529769e-01f, 1.17322132e-02f, -2.02483580e-01f, 2.07401183e-03f, 1.76416878e-02f, 3.91600840e-02f, -8.06195959e-02f,
  -1.95404828e-01f, 2.56781224e-02f, -2.37066876e-02f, -1.06654428e-02f, -6.22190014e-02f, -1.81899935e-01f, -6.32973462e-02f, 2.26654056e-02f, 1.58406600e-01f, -6.97001517e-02f,
  -1.28470749e-01f, -5.45173027e-02f, -9.86600108e-03f, 1.31135131e-03f, -2.02596243e-02f, -9.45529416e-02f, -6.16273135e-02f, -5.26394770e-02f, -1.42664909e-01f, 6.50925264e-02f,
  -5.22850633e-01f, 3.14140409e-01f, 3.81380796e-01f, 1.98637828e-01f, 1.33540958e-01f, 5.46796262e-01f, 3.48004520e-01f, 3.90345484e-01f, 5.89087844e-01f, 2.40468215e-02f,
  -3.12237114e-01f, -1.13466926e-01f, -8.22400302e-02f, -2.12623831e-02f, 1.25085950e-01f, 1.80207774e-01f, 2.72028118e-01f, 2.06326932e-01f, 1.90115094e-01f, 2.36067791e-02f,
  1.18934624e-01f, -1.37201056e-01f, -1.91305310e-01f, -1.60263449e-01f, -1.40278399e-01f, 2.33173724e-02f, -4.05431598e-01f, 4.21086401e-02f, -2.37045348e-01f, 8.77927318e-02f,
  -8.58924612e-02f, -4.39900570e-02f, -3.51822764e-01f, 6.89215735e-02f, -6.50058612e-02f, 6.23429641e-02f, 4.93482128e-02f, -4.92626876e-02f, -2.24502198e-02f, 9.66527537e-02f,
  2.16681305e-02f, -4.23760004e-02f, 2.23242845e-02f, 6.20888956e-02f, 2.28321239e-01f, 9.12584830e-04f, -5.48255257e-02f, 1.14676906e-02f, -6.31463751e-02f, 6.78116158e-02f,
  6.95354119e-02f, 5.19019738e-02f, -3.06194443e-02f, 9.70772281e-02f, -1.15459239e-04f, 7.95604140e-02f, 1.15990765e-01f, -1.47833964e-02f, -1.32496646e-02f, 1.30276114e-01f,
  7.61161149e-02f, 1.18653677e-01f, -6.59260899e-02f, -6.48593530e-02f, 1.82383470e-02f, -4.71214484e-03f, -8.97235423e-03f, -5.50146960e-02f, -1.07199922e-02f, -1.19061004e-02f,
  -2.62277611e-02f, -1.72243062e-02f, 4.82246466e-02f, 1.38589159e-01f, -3.97078097e-02f, 6.05906546e-03f, -7.56670907e-02f, 8.56758952e-02f, 1.34979442e-01f, -9.84499604e-02f,
  -1.74574628e-02f, 8.95936787e-02f, -1.82334408e-01f, -5.22949435e-02f, 6.37335032e-02f, -3.96043360e-02f, -1.46231810e-02f, 7.22612080e-04f, -4.83422056e-02f, 2.86994744e-02f,
  4.02286857e-01f, 2.56587654e-01f, -1.61159843e-01f, -6.72626942e-02f, 2.85158902e-02f, -5.99247254e-02f, 6.87809065e-02f, -1.45638352e-02f, 2.00440273e-01f, 2.49353307e-03f,
  8.86893794e-02f, -8.16116203e-03f, -6.36798069e-02f, -5.48267178e-02f, 8.01775083e-02f, 7.67000690e-02f, 3.74530256e-02f, 1.18719652e-01f, 7.27750212e-02f, -1.31557837e-01f,
  -1.80322111e-01f, 7.38851652e-02f, -3.83288413e-02f, -2.10287228e-01f, 2.70435289e-02f, -1.72846913e-01f, 4.62404639e-02f, -7.99709409e-02f, -1.66001618e-02f, 2.68810662e-03f,
  -9.96716172e-02f, -4.71592128e-01f, 2.18567461e-01f, 8.26915130e-02f, 1.40242204e-01f, 3.64635229e-01f, 4.51264858e-01f, -1.29487542e-02f, -4.18237261e-02f, -2.62809038e-01f,
  -8.08948949e-02f, -1.85846046e-01f, 3.69258404e-01f, -1.97870255e-01f, 4.78761435e-01f, 2.32364282e-01f, 5.06527051e-02f, 5.82549721e-03f, 1.05258361e-01f, -7.52174780e-02f,
  1.53132286e-02f, -1.85997963e-01f, 2.83941388e-01f, -3.51895332e-01f, -1.97954312e-01f, -1.99583709e-01f, -1.47895783e-01f, 2.92255022e-02f, -3.24717790e-01f, 1.18439505e-02f,
  -3.46252471e-01f, -1.99746996e-01f, -1.79603174e-01f, -1.08243585e-01f, -1.18091971e-01f, -7.73730576e-02f, -7.88610708e-03f, 1.13739297e-01f, 4.51988503e-02f, 3.94427739e-02f,
  -2.31180172e-02f, -1.27250254e-02f, -1.59859404e-01f, -4.48534489e-02f, 1.76630318e-02f, -9.87892672e-02f, -4.84869024e-03f, -7.85998255e-03f, -4.50013094e-02f, 7.57067651e-02f,
  -4.10137232e-03f, -4.84167039e-02f, 1.25001390e-02f, 3.41488905e-02f, 2.83910260e-02f, -1.37934893e-01f, 1.11685447e-01f, 1.13366254e-01f, -7.07412288e-02f, -1.20451786e-01f,
  5.00441901e-02f, -9.75079276e-03f, -2.69540178e-04f, -8.57902691e-02f, 5.75613901e-02f, -9.13026109e-02f, -6.87353462e-02f, 5.55793978e-02f, 5.68368658e-02f, 6.74303696e-02f,
  -3.48647311e-02f, 7.64199495e-02f, 4.20018584e-02f, 1.26556292e-01f, -1.30182682e-02f, 9.49742869e-02f, 2.57222541e-02f, -2.94767693e-03f, -7.85679817e-02f, -7.80779198e-02f,
  -5.86592406e-02f, 4.74785380e-02f, 6.59887418e-02f, 2.87994929e-02f, -1.78668484e-01f, 1.14984848e-01f, -1.71743885e-01f, 1.04230031e-01f, 1.10516846e-01f, 3.68879437e-02f,
  -5.05709648e-01f, -3.51536393e-01f, -1.40273646e-01f, -4.19555120e-02f, -1.28799632e-01f, -1.54204875e-01f, -1.83553491e-02f, -1.26722842e-01f, -5.91019727e-02f, 1.08642660e-01f,
  -4.55869958e-02f, 3.39267515e-02f, -3.54206599e-02f, 1.44249694e-02f, -1.17600357e-04f, 9.75502189e-03f, -1.32715613e-01f, -8.94475132e-02f, -6.98712692e-02f, -1.16376378e-01f,
  -8.18807185e-02f, -1.93734225e-02f, 1.18571155e-01f, -9.70815867e-02f, -8.95277224e-03f, 3.21613215e-02f, -9.52880010e-02f, 5.00200912e-02f, 5.68684451e-02f, -3.24222334e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.30940127e-01f, 3.61136645e-01f, 4.97614294e-01f, 3.86789411e-01f, 3.48104268e-01f, 5.94260216e-01f, 2.55858630e-01f, 2.46497899e-01f, 2.59715527e-01f, 2.88589239e-01f,
  3.50800663e-01f, 4.37724322e-01f, 3.57882798e-01f, 3.28632742e-01f, 4.19097692e-01f, 4.32088971e-01f, 4.78981882e-01f, 4.15764093e-01f, 4.08394724e-01f, 1.93320394e-01f,
  1.84219539e-01f, 5.18300354e-01f, 3.13959837e-01f, 3.73965681e-01f, 3.27762574e-01f, 3.72303188e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.20829217e-01f, 1.78521842e-01f, -1.60129949e-01f, 1.45114332e-01f, 1.84040397e-01f, -3.19295600e-02f, -1.18225262e-01f, 1.26976743e-01f, -9.89352986e-02f, -4.48615216e-02f,
  1.56910837e-01f, 2.41564944e-01f, -2.07361013e-01f, -3.10288310e-01f, 1.54605240e-01f, -1.06021889e-01f, 8.27142149e-02f, 2.30824247e-01f, -1.34905130e-01f, 2.41226535e-02f,
  -1.16246253e-01f, -3.25518966e-01f, 1.37866717e-02f, 2.04874218e-01f, -9.42290053e-02f, 2.31725261e-01f, 1.11027122e-01f, 1.86563566e-01f, 2.79174536e-01f, -1.89146563e-01f,
  2.19030246e-01f, -2.41298541e-01f, 3.00178453e-02f, 4.77387756e-02f, -1.34055257e-01f, 1.51254728e-01f, 3.60007286e-01f, -1.43238693e-01f, -4.65111673e-01f, 2.38214806e-01f,
  -1.72281668e-01f, -1.12924069e-01f, 2.57120952e-02f, -3.60243469e-01f, -7.82286301e-02f, 1.71376169e-01f, -3.15785557e-02f, -2.41008714e-01f, -1.91385716e-01f, -4.07873131e-02f,
  -7.39089102e-02f, -4.02026176e-02f, -2.47036889e-01f, 3.38299513e-01f, 1.56895649e-02f, 1.04528978e-01f, 1.36208922e-01f, 2.13653862e-01f, 3.09420489e-02f, -4.72088233e-02f,
  8.37044567e-02f, -2.04280660e-01f, -2.55802989e-01f, -3.18724811e-02f, 1.37743652e-01f, -1.37907326e-01f, -5.26304916e-02f, -1.02782518e-01f, -2.41911307e-01f, 2.42688179e-01f,
  -8.29682574e-02f, -2.83395171e-01f, 2.55926400e-01f, -3.13594371e-01f, 1.70150995e-01f, -2.97033824e-02f, 1.25628442e-01f, -2.73150623e-01f, 2.50804901e-01f, 1.03640981e-01f,
  -1.60989657e-01f, -1.41017839e-01f, -1.53511167e-01f, -2.17178941e-01f, -9.44520906e-02f, -4.66669574e-02f, -2.36515015e-01f, -2.50970609e-02f, 2.59188473e-01f, 2.37490267e-01f,
  1.60636008e-02f, 7.19309151e-02f, 1.73452973e-01f, 2.17351243e-01f, 6.89660460e-02f, -2.82105375e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.47907013e-01f, 2.37215877e-01f, 3.03859822e-02f, 2.97223210e-01f, 3.92893076e-01f, -3.38859886e-01f, 6.99508488e-01f, -1.94746077e-01f, 1.91134006e-01f, -1.29795998e-01f,
  -1.31090842e-02f, -5.71593223e-03f, 9.67795625e-02f, -1.61232829e-01f, 2.27551386e-01f, 2.09633578e-02f, 3.10217619e-01f, 1.56411141e-01f, 4.27215159e-01f, -3.27606231e-01f,
  -2.42915794e-01f, 3.61704648e-01f, -2.87666302e-02f, -2.74690449e-01f, 1.61844969e-01f, 6.55606166e-02f, -3.29324603e-01f, 1.35225639e-01f, 1.83225170e-01f, 2.92920470e-01f,
  4.14999872e-02f, 6.06793165e-02f, -2.56859899e-01f, -1.49034277e-01f, 1.73086643e-01f, 2.43267193e-01f, 2.55903929e-01f, -5.34854770e-01f, 4.05141592e-01f, -8.84851266e-04f,
  -8.81217346e-02f, 3.92493188e-01f, -7.75295869e-02f, 6.44895077e-01f, -5.20202816e-01f, 4.68403727e-01f, -3.83261293e-01f, 2.66274393e-01f, 3.51658195e-01f, 1.25040546e-01f,
  1.57372653e-01f, 4.97292221e-01f, 5.29771388e-01f, -2.86838450e-02f, -1.05490079e-02f, -2.22069487e-01f, -3.88723940e-01f, -1.52699977e-01f, -4.59433585e-01f, -3.74962091e-01f,
  -3.42927903e-01f, 5.37507087e-02f, -8.32110420e-02f, -1.61464959e-01f, 3.67619753e-01f, 2.36133412e-01f, 2.58651584e-01f, -1.38963506e-01f, -6.32695317e-01f, -4.35132802e-01f,
  -2.77730435e-01f, -2.76922494e-01f, 5.48713863e-01f, -2.77519852e-01f, -8.68137032e-02f, -4.00018662e-01f, 6.06825948e-01f, -3.92055139e-02f, 2.59716451e-01f, -3.27228606e-01f,
  1.51774779e-01f, 2.02751413e-01f, 3.09355557e-01f, -4.38872457e-01f, -4.51024733e-02f, -3.93404812e-01f, -2.57438481e-01f, 4.71166939e-01f, 5.74680030e-01f, 3.63794506e-01f,
  -5.15502930e-01f, 4.99897301e-01f, -5.96358664e-02f, -1.52969420e-01f, -2.16582105e-01f, -2.85869479e-01f, 4.73645210e-01f, 2.42917299e-01f, 2.76963383e-01f, -3.52723211e-01f,
  -4.32911098e-01f, -1.98853508e-01f, -8.43872726e-02f, -3.69888753e-01f, 6.49289429e-01f, -4.60667629e-03f, -6.92325011e-02f, -4.17002708e-01f, 5.80189168e-01f, 2.26599663e-01f,
  6.38051271e-01f, -6.01255894e-02f, -5.80485612e-02f, -1.76221400e-01f, 3.40804875e-01f, -2.37823740e-01f, 2.47421563e-01f, 4.54388440e-01f, -1.34838805e-01f, -5.49608842e-02f,
  6.35534108e-01f, 2.44600937e-01f, 1.70400158e-01f, -2.29264945e-01f, 5.04550219e-01f, -2.21349075e-01f, -3.00473630e-01f, -3.51162106e-02f, -3.82047915e-03f, 7.34911487e-02f,
  3.09508801e-01f, -4.40970026e-02f, -2.50566244e-01f, 3.72662157e-01f, -3.80453378e-01f, 1.16921052e-01f, -1.36779040e-01f, 2.50295132e-01f, 3.81157368e-01f, 1.44043133e-01f,
  -4.87928957e-01f, 1.13164611e-01f, -4.67200309e-01f, 2.48304904e-01f, 7.73950592e-02f, 1.46876514e-01f, -1.79293260e-01f, 9.52498466e-02f, 2.34884322e-01f, -4.30196698e-04f,
  4.67336655e-01f, 4.24120694e-01f, 1.35108596e-02f, -2.72440523e-01f, 1.53902322e-01f, -1.92125887e-01f, -2.57988218e-02f, 1.72057077e-01f, 1.85368091e-01f, 4.01031494e-01f,
  4.89361554e-01f, 3.29428405e-01f, 2.66735945e-02f, 9.18592662e-02f, 4.41464275e-01f, -2.78167725e-01f, 2.13047117e-01f, -2.25085557e-01f, -8.78939554e-02f, -9.31776017e-02f,
  1.17839858e-01f, 6.46514148e-02f, -7.02123642e-02f, 6.16278015e-02f, 1.20937802e-01f, 4.15968388e-01f, 5.25648296e-01f, 3.43067408e-01f, 2.47028038e-01f, -3.00174266e-01f,
  -3.44846487e-01f, 1.73980549e-01f, -2.72891194e-01f, 2.50675768e-01f, 3.16382706e-01f, 1.65223941e-01f, -4.21022654e-01f, 4.63800758e-01f, 1.42452076e-01f, 4.41975296e-01f,
  3.80240917e-01f, -4.81114000e-01f, 3.03921819e-01f, 8.92453715e-02f, 2.66344488e-01f, 2.38281786e-01f, 3.04276735e-01f, -1.45210296e-01f, 4.62107927e-01f, 6.81304157e-01f,
  4.37453747e-01f, -1.03666440e-01f, -3.74464571e-01f, 2.13752955e-01f, 2.59525895e-01f, -3.94321322e-01f, 3.51434708e-01f, -2.57856876e-01f, 2.24304572e-01f, -2.44775638e-01f,
  3.63800824e-01f, -1.02856711e-01f, 8.75378326e-02f, 1.60723478e-01f, 5.96092165e-01f, 1.39452323e-01f, -1.93152890e-01f, -2.18846917e-01f, 4.88948733e-01f, -7.31919855e-02f,
  -1.52907625e-03f, 1.53343230e-01f, 4.44759987e-02f, 5.10303259e-01f, 2.72080183e-01f, 1.79967120e-01f, 3.80691588e-01f, 3.21156979e-01f, 4.55716372e-01f, 5.05234241e-01f,
  2.85208169e-02f, 5.27248442e-01f, -1.40820727e-01f, 7.74766058e-02f, 2.98817337e-01f, 1.83752645e-02f, 3.49414885e-01f, 2.25014254e-01f, -2.44492367e-01f, 3.15871924e-01f,
  -5.51902056e-01f, 3.93079132e-01f, -4.61395651e-01f, 2.64632881e-01f, -2.10661978e-01f, 6.20186031e-01f, 4.06632066e-01f, 1.37779415e-01f, 3.23641598e-01f, -2.23931558e-02f,
  9.47458595e-02f, 2.91014105e-01f, 4.78531085e-02f, 5.96067786e-01f, 5.34966409e-01f, 4.42761511e-01f, 2.57164687e-01f, 4.74706471e-01f, 2.93561220e-01f, -4.39485431e-01f,
  -1.72066856e-02f, -1.33461952e-01f, 3.48499306e-02f, -1.53576443e-02f, 1.20197304e-01f, 1.34046093e-01f, 5.11526465e-01f, 5.68432271e-01f, -6.50444150e-01f, 2.23326627e-02f,
  2.04247415e-01f, 5.21596730e-01f, -9.75929499e-02f, 1.04754224e-01f, 4.27857429e-01f, 3.40670735e-01f, 5.67905247e-01f, -3.77886385e-01f, 2.52040535e-01f, -5.11895902e-02f,
  4.51984227e-01f, 2.03492388e-01f, 7.42550567e-02f, 4.83629620e-03f, 3.37067515e-01f, 7.20317364e-02f, 5.98948240e-01f, -3.69110674e-01f, -1.78747699e-01f, -2.29979336e-01f,
  1.26697600e-01f, -5.80425084e-01f, -1.56361893e-01f, -1.96936920e-01f, -3.52807939e-01f, 2.33330175e-01f, -2.31176950e-02f, 4.85103548e-01f, 1.12642489e-01f, 9.94009990e-03f,
  3.50778341e-01f, -1.70776770e-01f, 4.91840005e-01f, 6.44316003e-02f, 9.49531272e-02f, 2.60522366e-01f, -5.66229187e-02f, -1.01215191e-01f, 5.54651082e-01f, 3.68580937e-01f,
  -1.33632883e-01f, 3.46595287e-01f, 7.79830590e-02f, 5.66427648e-01f, 4.23357010e-01f, 3.16827655e-01f, 3.85211825e-01f, -4.82913077e-01f, -3.06890517e-01f, -2.69946307e-01f,
  -9.36668962e-02f, 8.66744220e-02f, -3.01245693e-02f, 2.64434099e-01f, 5.78722544e-02f, -3.86748552e-01f, 7.11229444e-01f, -5.59797063e-02f, 1.42859176e-01f, 3.88493180e-01f,
  -2.66552180e-01f, 4.74932045e-01f, 3.31704229e-01f, 8.15048441e-02f, 2.99496185e-02f, -2.74404258e-01f, 3.92700255e-01f, 4.04531270e-01f, 1.11989230e-01f, 4.51839656e-01f,
  -2.34856874e-01f, -2.89666831e-01f, -1.90302908e-01f, 2.36777499e-01f, -6.20795608e-01f, 4.35980588e-01f, -2.34486759e-01f, 5.42687416e-01f, -2.62232840e-01f, 2.64892191e-01f,
  1.22012019e-01f, 1.67415246e-01f, -1.24688707e-02f, 6.36550114e-02f, -9.97097418e-03f, -2.57290959e-01f, -1.73548311e-01f, 1.32011533e-01f, -2.69504279e-01f, 2.76753396e-01f,
  1.26283139e-01f, 1.77178279e-01f, 8.73131771e-03f, -4.08937782e-02f, 1.99546963e-01f, -4.29150581e-01f, 6.13392830e-01f, -2.03229159e-01f, -5.48152387e-01f, -1.58423156e-01f,
  6.37698025e-02f, -1.03318244e-02f, 4.66187149e-01f, -6.56607887e-03f, 6.42381608e-02f, 2.67247587e-01f, 7.85676390e-02f, 4.78673875e-01f, 4.38248187e-01f, -2.84614414e-02f,
  3.85961682e-01f, -2.24355951e-01f, -1.91839829e-01f, -1.87970921e-01f, 1.28329257e-02f, 2.31601939e-01f, 3.29110205e-01f, -2.87407815e-01f, 1.23511188e-01f, -2.83214301e-01f,
  -1.31135970e-01f, 6.68392777e-01f, 3.71739380e-02f, 3.85374725e-01f, -3.42234999e-01f, -4.56643365e-02f, 6.41546369e-01f, -8.00493896e-01f, -2.91135728e-01f, -4.56377417e-02f,
  -1.69970356e-02f, 1.64869428e-01f, -1.26761183e-01f, 1.76000461e-01f, 4.63818371e-01f, 2.72894382e-01f, 5.09693921e-01f, 5.15405595e-01f, -2.59283960e-01f, 1.69173211e-01f,
  9.73303393e-02f, 5.43486774e-01f, -5.12766957e-01f, 1.56266823e-01f, -1.15418183e-02f, 2.44019464e-01f, 2.04149395e-01f, 5.33547401e-02f, -5.62564991e-02f, 3.65689173e-02f,
  3.46435100e-01f, 8.75025764e-02f, -3.29789430e-01f, 1.97032139e-01f, 7.30111524e-02f, -1.88310474e-01f, -8.42015631e-03f, -4.76900220e-01f, 3.19483519e-01f, 1.96078002e-01f,
  5.29740393e-01f, -2.55315781e-01f, -1.11287013e-01f, 4.62520123e-02f, -5.09805866e-02f, -3.54530513e-02f, -4.48469967e-02f, 8.53025317e-01f, 4.04324457e-02f, 9.98029411e-02f,
  2.56258070e-01f, 4.35869664e-01f, 1.45772874e-01f, -1.71497092e-02f, 4.50488597e-01f, -7.60403350e-02f, -2.81691939e-01f, 2.13236928e-01f, 1.57297999e-01f, 2.86343753e-01f,
  3.94393653e-01f, -4.32624876e-01f, -5.58205009e-01f, -4.90886047e-02f, 4.12052482e-01f, -4.35202420e-01f, 5.44086516e-01f, 2.16731012e-01f, 1.95653588e-01f, 4.41259325e-01f,
  -2.96699494e-01f, -3.73563945e-01f, 1.16297260e-01f, 5.84511936e-01f, 5.14625192e-01f, 1.59631729e-01f, 3.91952962e-01f, -3.53233695e-01f, 5.03560364e-01f, -1.85100436e-01f,
  1.54926986e-01f, 1.20328322e-01f, -1.20352790e-01f, 2.00694986e-02f, -1.64650176e-02f, 3.68548274e-01f, 2.20354423e-01f, 3.07265252e-01f, 5.00173271e-01f, 6.62857071e-02f,
  1.18533336e-01f, 4.15921323e-02f, 1.22465059e-01f, 1.00693941e-01f, 3.59213024e-01f, -5.22081554e-01f, -8.89096260e-02f, 1.94098845e-01f, 3.41348380e-01f, 4.38446254e-02f,
  -1.19362347e-01f, 5.42849541e-01f, 2.14142710e-01f, 4.50291276e-01f, 3.26526463e-01f, -1.41930521e-01f, -5.19258007e-02f, -4.32563484e-01f, 6.09622478e-01f, 2.28194833e-01f,
  4.17413473e-01f, 1.22451641e-01f, 1.84944332e-01f, 2.80601323e-01f, 4.68103915e-01f, 3.67777824e-01f, -7.08275676e-01f, -2.11521104e-01f, -3.61320466e-01f, -5.14058173e-02f,
  -5.77509880e-01f, -2.00564325e-01f, 6.58898577e-02f, 1.57554567e-01f, 9.23470929e-02f, 8.12690496e-01f, 1.84933826e-01f, 6.25863910e-01f, -5.94646215e-01f, 6.93445876e-02f,
  -2.87067831e-01f, 2.72092521e-01f, 2.72238284e-01f, 3.49286109e-01f, -1.53423935e-01f, 4.25862849e-01f, -4.29283641e-02f, 4.17902088e-03f, 1.00648515e-01f, 1.15509979e-01f,
  -6.01267338e-01f, 4.32687312e-01f, -4.30242896e-01f, 2.68659711e-01f, 3.98184776e-01f, 4.52601433e-01f, -2.02739954e-01f, -6.10638186e-02f, 4.30620462e-01f, -5.95257699e-01f,
  -6.01153374e-02f, 2.39329293e-01f, 1.23972990e-01f, 3.05068135e-01f, 2.27708563e-01f, 1.84612706e-01f, -1.29331127e-01f, 3.32446605e-01f, 1.65996805e-01f, 2.50401169e-01f,
  2.11653531e-01f, -3.35479200e-01f, 1.48947183e-02f, 9.95370597e-02f, 2.79357046e-01f, -6.05123006e-02f, 6.66739494e-02f, 3.52678269e-01f, 8.31429586e-02f, -9.54118297e-02f,
  2.80401409e-01f, 3.38546962e-01f, -2.11065918e-01f, 3.11160058e-01f, -4.13695931e-01f, 4.57884818e-01f, -3.59390080e-01f, 1.37941062e-01f, 1.29600437e-02f, 1.78620696e-01f,
  1.94699556e-01f, 5.35229333e-02f, 3.84113878e-01f, 2.47957602e-01f, -3.32540348e-02f, 4.56012487e-01f, 1.55989930e-01f, 4.26408827e-01f, 3.06524336e-01f, 2.70051479e-01f,
  -3.44835371e-01f, 6.03049934e-01f, -4.22110796e-01f, 4.01308775e-01f, -6.33140057e-02f, 2.11119622e-01f, 2.10955858e-01f, 2.93789148e-01f, -2.41163939e-01f, 2.84758508e-01f,
  3.98744017e-01f, -1.57180861e-01f, -3.94118309e-01f, 2.79040694e-01f, -6.04327142e-01f, 1.57240584e-01f, -2.75109131e-02f, -4.64148313e-01f, 4.49627906e-01f, 4.34117854e-01f,
  -5.79780936e-02f, 8.63036886e-02f, 7.50706613e-01f, -1.94306269e-01f, 4.42582518e-01f, -3.46712656e-02f, 4.85675663e-01f, 3.95223379e-01f, 1.00772500e-01f, 1.20191917e-01f,
  2.52436727e-01f, 1.81156218e-01f, 3.68471771e-01f, 5.99907227e-02f, 5.92324495e-01f, 3.05451870e-01f, 9.30024032e-03f, 3.80695999e-01f, -1.56212747e-01f, -4.94699851e-02f,
  4.65582758e-01f, -3.64278078e-01f, -3.20283294e-01f, 3.33081871e-01f, -5.67472637e-01f, 2.28180923e-02f, 9.97159537e-03f, 4.60168600e-01f, 1.48763612e-01f, 5.53874612e-01f,
  1.51617542e-01f, -2.38346398e-01f, -4.58382070e-02f, -1.58531651e-01f, 1.19302377e-01f, 2.99129456e-01f, -1.91901103e-01f, 3.95625025e-01f, 1.60106584e-01f, 5.84515512e-01f,
  1.42907435e-02f, 2.26478770e-01f, 2.84236789e-01f, -1.02560848e-01f, -4.90888983e-01f, 4.13437247e-01f, 1.12248756e-01f, 3.75356562e-02f, 1.00810356e-01f, 3.75753909e-01f,
  2.97903240e-01f, 2.32944906e-01f, -1.78276505e-02f, -4.25507575e-02f, 1.98889390e-01f, 2.29290783e-01f, -1.84779167e-01f, 3.77356529e-01f, -3.97799224e-01f, 2.41372123e-01f,
  2.92099863e-01f, -5.02755761e-01f, 3.27999681e-01f, -1.16723537e-01f, -4.11295354e-01f, -3.54573280e-01f, 4.90217656e-01f, 2.73929179e-01f, 4.01254445e-01f, 1.66396812e-01f,
  4.77772176e-01f, 4.16013241e-01f, -1.19748585e-01f, 7.86382854e-02f, 4.37297761e-01f, -5.48241436e-01f, -2.73290843e-01f, -4.16820943e-01f, 1.80417046e-01f, 3.75960290e-01f,
  -1.08098872e-01f, 5.18682837e-01f, -4.14302379e-01f, 4.95195091e-01f, -2.19912708e-01f, 2.15717629e-01f, -5.62527597e-01f, 4.02446628e-01f, -5.73295727e-02f, 4.13844466e-01f,
  3.23080458e-02f, 5.22667587e-01f, 3.69574964e-01f, -4.20449257e-01f, 1.71795353e-01f, -3.60601008e-01f, 1.23849679e-02f, 1.24776345e-02f, 1.57994181e-01f, 3.69996279e-01f,
  -1.62298247e-01f, -2.56044000e-01f, -4.35238108e-02f, 2.30443571e-02f, 2.58119822e-01f, 3.39428306e-01f, -5.63655086e-02f, 4.20571566e-01f, 6.29276633e-01f, -7.05136359e-02f,
  2.44227678e-01f, -3.55097167e-02f, -4.46322449e-02f, -3.14923346e-01f, 3.52805257e-01f, 2.14444414e-01f, 3.82462323e-01f, -3.33293974e-01f, 7.71593601e-02f, 3.27482879e-01f,
  3.49606395e-01f, 2.95145124e-01f, 1.23490565e-01f, -2.88093895e-01f, -5.19278646e-01f, 7.01209903e-01f, -2.05273330e-01f, 3.50662440e-01f, 2.41819724e-01f, 4.35429454e-01f,
  -3.14689159e-01f, 5.22247195e-01f, 4.31032404e-02f, 6.47820413e-01f, 4.49419111e-01f, -3.01010340e-01f, 3.91198277e-01f, 3.32272232e-01f, 2.80811846e-01f, -5.94033897e-01f,
  -2.17612982e-01f, 6.70073926e-02f, -4.99570996e-01f, -1.01498820e-01f, 3.57927918e-01f, 4.15323347e-01f, 4.09362823e-01f, 3.40987407e-02f, -4.62836713e-01f, 2.20682457e-01f,
  1.94119856e-01f, 4.70541835e-01f, 1.99354127e-01f, 2.59637505e-01f, 1.10107265e-01f, -8.78409892e-02f, 4.82375383e-01f, -5.96325062e-02f, 7.53820315e-02f, -2.24524140e-02f,
  5.35887361e-01f, 3.17087322e-01f, 3.58791053e-01f, 2.44223341e-01f, 4.63307709e-01f, -2.17768729e-01f, 4.94721621e-01f, -2.74344623e-01f, 1.63159251e-01f, 1.20592818e-01f,
  2.49145240e-01f, 2.30265573e-01f, 4.89699244e-01f, 4.78686243e-01f, 5.50859809e-01f, 3.58672619e-01f, 2.28152275e-01f, -1.41796902e-01f, 5.61207414e-01f, 2.52317399e-01f,
  2.33203471e-01f, -3.19762468e-01f, 7.54040033e-02f, 2.06075296e-01f, 5.08824810e-02f, 3.50302979e-02f, -6.26294166e-02f, -1.55763596e-01f, -1.62704751e-01f, 6.40303969e-01f,
  -5.89179099e-02f, 4.47349876e-01f, -2.58796513e-01f, 2.07625598e-01f, 1.39008567e-01f, 3.93909931e-01f, 3.47896636e-01f, 5.09552062e-01f, 2.77746975e-01f, 3.65661770e-01f,
  3.73592854e-01f, 4.79650229e-01f, 2.90924877e-01f, 2.03432888e-01f, 1.76574335e-01f, -4.69854832e-01f, 1.16833061e-01f, 6.85689628e-01f, 3.88911039e-01f, 3.15433741e-02f,
  -5.76946974e-01f, 6.59847632e-02f, 2.14090198e-01f, -2.56407470e-01f, -1.68074131e-01f, -2.61313975e-01f, 1.97088152e-01f, 4.42567468e-01f, 2.96842277e-01f, 2.03838155e-01f,
  -1.10248767e-01f, -3.16128463e-01f, 5.82618237e-01f, 3.90962660e-01f, 1.27068460e-01f, 1.46847546e-01f, 2.00830147e-01f, 1.88511342e-01f, -1.87377170e-01f, 5.20433448e-02f,
  1.37605006e-02f, 4.61003810e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.54217526e-01f, 7.29675069e-02f, 1.53254136e-01f, 7.41849914e-02f, 3.92978847e-01f, 1.47346854e-01f, 2.66024321e-01f, 1.54181004e-01f, 3.20613176e-01f, 8.16467106e-02f,
  1.03977002e-01f, 1.04711734e-01f, 2.00907812e-02f, -5.14243729e-02f, 1.99538961e-01f, 3.97091448e-01f, 2.41469350e-02f, -1.79801043e-03f, 3.13208580e-01f, 2.60530651e-01f,
  2.89536834e-01f, 3.00766736e-01f, 1.29355311e-01f, 1.53343305e-01f, 3.70441198e-01f, 2.73992449e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.24125622e-01f, 7.17568323e-02f, -1.26198873e-01f, 3.64702106e-01f, -2.12041065e-01f, 3.45790446e-01f, -5.35699666e-01f, -3.86868268e-01f, -3.52606267e-01f, 3.64801556e-01f,
  -5.98058775e-02f, -7.76617706e-01f, 1.17544793e-01f, -3.18621427e-01f, 6.58193827e-02f, 3.81574601e-01f, -6.22051537e-01f, 5.01731336e-01f, -6.06983364e-01f, 2.69846410e-01f,
  1.58489302e-01f, -4.81877238e-01f, 4.89634424e-02f, 1.03717387e-01f, 5.16065598e-01f, -2.97706574e-01f, 3.73825401e-01f, -5.81269145e-01f, -6.16179407e-01f, 2.10762843e-01f,
  4.86462042e-02f, -7.26627946e-01f, -7.33239502e-02f, -1.33608043e-01f, -1.61081716e-01f, 2.64017254e-01f, 6.92601144e-01f, -3.09943706e-01f, 1.86540231e-01f, -3.68113145e-02f,
  -1.02918357e-01f, 3.44151616e-01f, -3.11068267e-01f, 3.85074377e-01f, -5.64211965e-01f, 1.12418309e-01f, 2.98492750e-03f, 3.54321122e-01f, -3.32951814e-01f, 2.12459818e-01f,
  -6.39847517e-01f, 5.80946326e-01f, -2.20639020e-01f, -2.41571262e-01f, -9.29281786e-02f, 3.12590808e-01f, -2.46934429e-01f, -3.31883162e-01f, -4.45020854e-01f, -5.65215528e-01f,
  2.81618953e-01f, 3.06006521e-01f, 5.67647479e-02f, -3.64174426e-01f, 8.37062486e-04f, -8.54342952e-02f, 4.55315821e-02f, 1.64003059e-01f, 4.49029803e-01f, 3.63600940e-01f,
  -3.16423565e-01f, -1.60279468e-01f, 8.18810984e-02f, -4.09353990e-03f, -3.32926273e-01f, -1.40795469e-01f, 4.15872261e-02f, 1.09210841e-01f, -6.63143933e-01f, 4.30440813e-01f,
  -4.34825346e-02f, 4.51537669e-01f, 4.21529114e-01f, 3.53410810e-01f, -6.36234283e-01f, 5.56778073e-01f, -1.63911894e-01f, -3.51110458e-01f, -3.09953421e-01f, -5.68154939e-02f,
  -4.50111926e-01f, -4.79752809e-01f, 2.78898835e-01f, -6.09956682e-01f, 2.97345579e-01f, 1.00300513e-01f, 2.19286442e-01f, -6.71803579e-02f, -6.09504320e-02f, -4.79215950e-01f,
  -9.27504227e-02f, -2.13336080e-01f, -6.75875485e-01f, 6.14248633e-01f, -4.92267311e-01f, -1.03114657e-01f, 3.13396484e-01f, -1.03518896e-01f, -5.56818843e-01f, -5.56264877e-01f,
  2.24718586e-01f, 4.51658189e-01f, -1.50503397e-01f, 4.70420942e-02f, 2.73164749e-01f, -1.96788624e-01f, 3.62384737e-01f, 1.54198885e-01f, -5.35338879e-01f, -4.57193553e-01f,
  -4.47736830e-01f, -5.28622307e-02f, -5.25928363e-02f, 5.13875186e-01f, -3.18464905e-01f, 3.00609469e-01f, -4.78046834e-01f, -7.74750829e-01f, 2.14796156e-01f, 3.92715484e-02f,
  1.20173924e-01f, 3.26468587e-01f, 3.33934017e-02f, -6.19491279e-01f, -3.83058727e-01f, -2.45184585e-01f, 8.67529437e-02f, -2.12070197e-01f, 1.10240817e-01f, -1.16028436e-01f,
  1.47257477e-01f, 1.87458634e-01f, 1.34170130e-01f, 1.03024729e-01f, 2.44905762e-02f, 3.52602117e-02f, 4.76107180e-01f, -2.26615891e-01f, -3.03458031e-02f, -8.46881211e-01f,
  -1.76266268e-01f, -3.10113490e-01f, 3.24846148e-01f, 1.18930086e-01f, 3.33790421e-01f, 4.14416850e-01f, -7.08523989e-01f, 8.10400248e-02f, -2.21773684e-01f, 3.70387167e-01f,
  1.18843891e-01f, -1.56886563e-01f, 9.14787799e-02f, 3.44471186e-01f, -2.15635732e-01f, 5.51630795e-01f, -2.02629372e-01f, -4.22446877e-01f, -5.41643560e-01f, -6.45060539e-01f,
  4.16959673e-01f, 2.48474702e-01f, -5.02609730e-01f, 3.87899607e-01f, 3.57586086e-01f, -3.78339887e-01f, -3.87336433e-01f, -5.34665883e-01f, -2.42967278e-01f, -5.21173418e-01f,
  2.70131111e-01f, -4.66369838e-01f, 1.96557432e-01f, -4.14998159e-02f, 1.71193942e-01f, -7.16056526e-02f, 2.93587148e-01f, -4.50125515e-01f, 2.69135207e-01f, 1.49583727e-01f,
  2.55632550e-01f, -4.88545746e-01f, -2.91506834e-02f, -1.84336424e-01f, 1.89516202e-01f, -4.71129626e-01f, -4.85369354e-01f, 3.78943533e-01f, 4.77773041e-01f, -5.98893404e-01f,
  -2.44975194e-01f, 1.63195908e-01f, -4.16559160e-01f, 8.25360976e-03f, 1.36990026e-01f, 2.51092583e-01f, -4.89233851e-01f, -3.94493282e-01f, 2.24918410e-01f, -2.43857518e-01f,
  1.00125015e-01f, -1.27488047e-01f, 8.07212591e-02f, -4.18024540e-01f, -4.36142474e-01f, 2.14486450e-01f, -8.91703188e-01f, 5.04868627e-01f, -1.59189443e-03f, -1.81483477e-01f,
  1.75147176e-01f, -7.04672813e-01f, 4.02137786e-01f, -1.50409728e-01f, 8.78712460e-02f, 1.16755821e-01f, -7.15021119e-02f, 1.38912201e-01f, -2.89796516e-02f, -2.41644114e-01f,
  -3.59510928e-01f, 4.47895706e-01f, -3.81713092e-01f, -5.17815888e-01f, -6.75766319e-02f, -1.67200938e-01f, -5.71878314e-01f, 4.64798436e-02f, 1.39367711e-02f, -5.47461689e-01f,
  5.04539549e-01f, -2.05689088e-01f, -4.34555352e-01f, -1.42039284e-01f, -6.38736844e-01f, 2.72182822e-01f, 5.47686398e-01f, 3.03036273e-01f, 2.92704761e-01f, 2.84363553e-02f,
  5.01479395e-02f, 3.54286581e-01f, -2.43143275e-01f, -2.63173491e-01f, -4.58613932e-01f, 1.40665332e-02f, -1.81206927e-01f, 8.78138691e-02f, -7.64672309e-02f, 3.66466224e-01f,
  -2.13142753e-01f, 9.89304483e-02f, 1.20874561e-01f, -3.95826012e-01f, 5.18002987e-01f, -6.62841275e-02f, -2.63452351e-01f, 3.57060134e-01f, -1.06344700e-01f, -6.06495023e-01f,
  -5.92674077e-01f, 2.09318176e-01f, 5.45415163e-01f, -1.47337243e-01f, 2.44929984e-01f, -1.90189809e-01f, 2.99957931e-01f, -3.30069572e-01f, -4.73016202e-01f, 1.98344707e-01f,
  -4.21745062e-01f, -6.10561669e-01f, -2.28203550e-01f, -4.50791001e-01f, 2.54713625e-01f, -1.61313683e-01f, 5.82703836e-02f, 2.34802052e-01f, 1.60736844e-01f, 7.85680115e-02f,
  5.44906966e-02f, -3.97731870e-01f, 5.34486711e-01f, -4.87346709e-01f, -2.45768532e-01f, -2.53212899e-01f, -3.01665813e-01f, -2.61431068e-01f, 5.17939508e-01f, -4.48661923e-01f,
  2.68127382e-01f, 3.82183164e-01f, -6.76078558e-01f, -4.41863209e-01f, -4.50251311e-01f, -4.40766692e-01f, 2.39804894e-01f, 3.10148060e-01f, -6.17084026e-01f, -4.25088182e-02f,
  7.09081888e-01f, 1.31369531e-01f, 2.71553636e-01f, 1.54515654e-01f, -6.43143291e-03f, -5.44686139e-01f, -2.90630639e-01f, -7.65289068e-01f, 2.09834456e-01f, 2.09916174e-01f,
  2.66060621e-01f, 2.47883692e-01f, 3.03564101e-01f, -4.78069872e-01f, -4.26095843e-01f, 4.39946979e-01f, 1.91906895e-02f, -3.78647566e-01f, 6.32811308e-01f, 6.38123572e-01f,
  -3.30498904e-01f, 6.16226345e-02f, 1.31858781e-01f, -5.08376658e-01f, 1.83862790e-01f, -2.71196514e-01f, -6.83092356e-01f, -7.18044909e-03f, -4.07964587e-01f, -7.32317865e-02f,
  2.20940769e-01f, 5.13668120e-01f, -1.60915345e-01f, -5.05791545e-01f, -1.85354501e-01f, -4.95751858e-01f, -4.92186248e-01f, -2.03447059e-01f, -2.81069100e-01f, 3.06139141e-01f,
  -5.69715381e-01f, 1.74544647e-01f, 1.58669084e-01f, 4.11456749e-02f, -9.75628495e-02f, 2.92864114e-01f, -1.73495188e-01f, -4.40585881e-01f, 5.15862405e-01f, 3.77887934e-01f,
  -5.01972079e-01f, -3.58552933e-01f, -4.18430835e-01f, 2.65348494e-01f, 4.77336437e-01f, -5.24373591e-01f, 2.40045354e-01f, -5.35336971e-01f, 3.22106332e-01f, -2.31952831e-01f,
  -3.11908424e-01f, -5.14794409e-01f, 2.74340540e-01f, 3.83145660e-01f, -3.42253178e-01f, -3.89414966e-01f, -4.19116586e-01f, -1.83779940e-01f, -3.51243347e-01f, -9.95251611e-02f,
  1.51808172e-01f, -5.63160419e-01f, 1.76024497e-01f, 2.68093258e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.63260061e-02f, -1.75434098e-01f, -1.95910096e-01f, -7.44713396e-02f, 2.82260142e-02f, 6.82899505e-02f, 5.65747954e-02f, -5.19002117e-02f, -2.15787634e-01f, -1.67031381e-02f,
  1.62217647e-01f, -4.23546769e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    