/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.98920453e-01f, 6.32496551e-02f, 1.85614005e-01f, -4.70018201e-03f, 3.92266586e-02f, -4.25605215e-02f, 2.57086843e-01f, 1.61518544e-01f, -8.11930522e-02f, 1.37338385e-01f,
  -1.66456774e-01f, -2.64531076e-01f, -1.78895265e-01f, -1.79683298e-01f, 4.12529781e-02f, 1.83128908e-01f, 1.94715261e-01f, 1.69181138e-01f, 8.61293748e-02f, 9.00192261e-02f,
  6.98246714e-03f, 8.83368368e-04f, 7.93235153e-02f, 5.79719618e-03f, 8.50143582e-02f, -1.88385949e-01f, 8.58289152e-02f, 7.23880762e-03f, -2.73515023e-02f, 1.53552130e-01f,
  1.31982625e-01f, 2.45488822e-01f, 1.81381553e-02f, -3.31354588e-02f, -6.71179667e-02f, 6.84968904e-02f, 1.32677391e-01f, 1.22864798e-01f, -3.05709965e-03f, 5.38289137e-02f,
  -8.77762511e-02f, -3.35691199e-02f, -3.02689942e-03f, 4.79565114e-02f, 1.59690157e-01f, 6.33825585e-02f, 8.52803960e-02f, 6.42895699e-02f, 5.56288920e-02f, 1.53546140e-01f,
  -1.11086175e-01f, -6.85874075e-02f, 7.13257641e-02f, -9.23843384e-02f, 3.11434884e-02f, -1.63793981e-01f, 3.18654329e-02f, 4.37216684e-02f, -5.60359731e-02f, 1.38971224e-01f,
  -3.32690068e-02f, 3.78499962e-02f, -2.07653213e-02f, -2.25660927e-03f, -3.26881222e-02f, -1.30286189e-02f, 1.33506628e-02f, -1.28400391e-02f, 1.61008369e-02f, 1.59977805e-02f,
  -6.45033792e-02f, 8.31021741e-02f, 2.53958814e-02f, 3.32648568e-02f, -7.49046262e-03f, 2.02539545e-02f, 5.83189260e-03f, 3.83391753e-02f, 1.71220233e-03f, 4.23499718e-02f,
  -8.46420601e-02f, -4.33713803e-03f, 3.00363190e-02f, 3.31315817e-03f, -3.88087891e-02f, -2.79103201e-02f, -1.35686425e-02f, 2.42381655e-02f, 9.28691030e-03f, -4.68339287e-02f,
  -1.18340850e-01f, -2.85936266e-01f, 4.07184511e-02f, -2.87648942e-02f, 1.51739288e-02f, -9.87071246e-02f, -7.94233233e-02f, -5.76777868e-02f, -1.06274612e-01f, -4.75893617e-02f,
  -3.27899344e-02f, 6.26228079e-02f, -2.18374133e-02f, -3.32615301e-02f, 2.61778235e-02f, -2.93331854e-02f, -3.82764786e-02f, -3.53545398e-02f, -1.00881778e-01f, -7.99760129e-03f,
  -5.67486025e-02f, 2.25170739e-02f, -4.36140187e-02f, 4.98050749e-02f, -7.86185563e-02f, 1.02662900e-02f, 2.07704045e-02f, -2.17851391e-03f, -1.47695094e-02f, -3.02318390e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.38875112e-01f, 3.01458269e-01f, 3.88156436e-02f, -8.65060929e-03f, -6.69485331e-02f, -8.35758448e-02f, 1.24521181e-01f, 1.56298250e-01f, -1.72768518e-01f, 4.50838283e-02f,
  8.59012902e-02f, -1.81714937e-01f, -5.61669245e-02f, -3.99562865e-02f, 1.37673467e-01f, 1.24874540e-01f, 1.01164944e-01f, -2.15124600e-02f, -1.94961190e-01f, -2.40996858e-04f,
  -7.63451532e-02f, 1.74941588e-02f, 9.56519798e-04f, 7.30886012e-02f, 6.71349689e-02f, -7.12599084e-02f, 4.79628853e-02f, 1.36903688e-01f, 5.04475273e-02f, 1.08494349e-01f,
  -4.75090444e-02f, 1.95958614e-01f, -1.76433250e-01f, 7.87096750e-03f, -1.37460483e-02f, 4.69840467e-02f, -4.28279005e-02f, -6.16194494e-02f, -7.13189170e-02f, 2.09371299e-02f,
  7.52908736e-02f, -5.44787645e-02f, 6.74583018e-03f, -8.70356932e-02f, 4.54516299e-02f, 6.83128834e-02f, 2.80864388e-02f, 9.95639265e-02f, -2.42071208e-02f, -5.65621965e-02f,
  1.05270572e-01f, 3.25802453e-02f, 2.45605242e-02f, 1.21661186e-01f, -9.48138721e-03f, -9.92691815e-02f, 8.51931050e-02f, 4.20431271e-02f, 1.34431412e-02f, 2.25253925e-02f,
  -1.05874874e-02f, -4.67366241e-02f, -9.65481531e-03f, 8.87826532e-02f, 5.43889403e-03f, 6.93611288e-03f, -2.27840338e-02f, -1.19428420e-02f, -2.04273816e-02f, 6.29327744e-02f,
  -5.66226952e-02f, -7.72844851e-02f, 1.74324270e-02f, 5.65724187e-02f, -2.29703262e-02f, -2.97663566e-02f, -3.96042243e-02f, 3.19827646e-02f, -3.71809304e-02f, -7.31051937e-02f,
  5.27287014e-02f, 8.70974958e-02f, -1.30065596e-02f, 5.70464879e-03f, -7.48019293e-02f, -3.83868366e-02f, -8.83225426e-02f, -5.27411848e-02f, -6.96103722e-02f, 1.09528964e-02f,
  -1.43229783e-01f, -4.05885950e-02f, -1.19095124e-01f, 7.56649897e-02f, -1.12780919e-02f, 3.55746672e-02f, -1.85782555e-02f, 9.09992866e-03f, -2.64503974e-02f, 8.36963579e-03f,
  1.06522411e-01f, 3.43296714e-02f, -1.01578355e-01f, 1.28837721e-02f, -9.49098989e-02f, 1.66712906e-02f, 1.19272647e-02f, -3.15106139e-02f, -6.71275035e-02f, 7.30098933e-02f,
  -4.35757637e-02f, -9.43086818e-02f, -1.12262703e-01f, -7.52794668e-02f, -9.35942214e-03f, -1.98444918e-01f, -3.15323025e-02f, -9.67794955e-02f, -6.46556541e-02f, -1.67633295e-01f,
  -1.09270789e-01f, -1.44775569e-01f, 1.02035806e-01f, 6.80425540e-02f, 4.40584198e-02f, -4.34936397e-02f, -1.17243722e-01f, -1.04573838e-01f, -9.17318463e-02f, -1.65538073e-01f,
  -3.40606868e-02f, -7.02787861e-02f, -2.05024239e-02f, -4.24813200e-03f, 9.28622037e-02f, -4.93538678e-02f, 1.50741905e-01f, 1.64684147e-01f, 1.26031578e-01f, -5.17375618e-02f,
  1.21563539e-01f, 8.74884054e-02f, 1.27487689e-01f, 2.87865791e-02f, -5.06706163e-02f, 1.63883641e-02f, 1.26154900e-01f, 1.34523483e-02f, 1.31942481e-01f, -2.61259489e-02f,
  -2.11545691e-01f, -9.64115411e-02f, 3.58604011e-04f, 8.11403766e-02f, 2.35926379e-02f, -6.52536703e-03f, 6.56401441e-02f, -6.37458712e-02f, 4.09638360e-02f, -7.28923604e-02f,
  2.63572298e-02f, 7.85290301e-02f, -6.52025715e-02f, 2.55874041e-02f, 3.46056260e-02f, -9.24992934e-02f, 4.45281565e-02f, -6.41483348e-04f, 9.13173053e-03f, -9.51635558e-03f,
  -2.29861829e-02f, 8.94354135e-02f, 1.54839084e-02f, -2.63058189e-02f, -7.69905970e-02f, -1.05869591e-01f, 3.19560505e-02f, -4.69130203e-02f, -1.10574411e-02f, -9.10339132e-02f,
  9.04959440e-03f, 5.62797189e-02f, 5.52817173e-02f, 3.12227625e-02f, 9.92854536e-02f, 3.81974503e-02f, 2.63914862e-03f, 7.09895566e-02f, 4.26821820e-02f, -1.17639964e-03f,
  -3.47459279e-02f, -4.32008728e-02f, 7.15692341e-02f, -3.01852613e-03f, 7.08840415e-02f, -6.58572018e-02f, 5.78108579e-02f, 6.74246624e-02f, -1.26451850e-02f, 2.48415899e-02f,
  -1.00046173e-01f, 6.20235093e-02f, 1.33538973e-02f, -9.26454067e-02f, -9.40506905e-02f, 5.68722785e-02f, 5.93192503e-03f, -9.05958116e-02f, -6.23563714e-02f, -6.13820441e-02f,
  -1.44100040e-01f, 9.64790657e-02f, -1.41187504e-01f, -5.66036403e-02f, -3.16106640e-02f, -1.07680494e-03f, 8.83093774e-02f, -7.41891488e-02f, -1.17968500e-01f, -3.54903787e-02f,
  -1.30585637e-02f, -1.22689002e-03f, -4.05006930e-02f, 1.14548495e-02f, -1.02677532e-01f, 8.28253850e-03f, -3.97380181e-02f, -4.07571672e-03f, -1.34603336e-01f, -5.20312972e-02f,
  -5.89178428e-02f, -1.76779047e-01f, -1.66966766e-01f, -1.93829849e-01f, -7.44826347e-02f, -8.58926550e-02f, -5.14953882e-02f, -2.06632391e-02f, -1.24500263e-02f, -1.36684999e-01f,
  9.36265528e-01f, -1.85006022e-01f, -6.30138099e-01f, 3.45529646e-01f, -3.87078106e-01f, 4.32557054e-02f, -2.98440248e-01f, 1.02860585e-01f, 2.83082068e-01f, -2.43675262e-01f,
  -8.66366401e-02f, 2.73714364e-01f, 1.39822155e-01f, -2.14045811e-02f, 1.64669827e-01f, -2.98401833e-01f, -4.69059050e-01f, -2.41997987e-01f, 1.39467090e-01f, 1.05396524e-01f,
  1.51699716e-02f, -8.17696452e-02f, 7.65908211e-02f, 1.23891331e-01f, -1.33300260e-01f, 1.31026596e-01f, -5.07360935e-01f, -1.81832597e-01f, -1.60632834e-01f, -6.20067179e-01f,
  -1.52280480e-01f, -4.38254885e-02f, 7.05415606e-02f, 2.10863128e-02f, -1.11517891e-01f, 1.09222874e-01f, 4.28354405e-02f, -1.42060384e-01f, 2.87541766e-02f, -9.43675414e-02f,
  -2.04084776e-02f, -9.48786456e-03f, 5.63679321e-04f, -1.39901638e-02f, -5.40463813e-03f, -2.76923925e-02f, -1.56245129e-02f, -3.20263058e-02f, 4.40361490e-03f, -6.83529377e-02f,
  -6.18751049e-02f, -1.14328854e-01f, -1.91783145e-01f, 4.31528650e-02f, 9.81721804e-02f, -1.78906471e-01f, -1.52335733e-01f, -5.37129492e-02f, -1.14970908e-01f, -2.48465121e-01f,
  -3.97299007e-02f, -2.57721040e-02f, 6.21541888e-02f, 6.19774945e-02f, 1.58632770e-02f, 1.71428677e-02f, -1.07705124e-01f, -2.85050925e-02f, 3.86642069e-02f, -5.67398332e-02f,
  -3.05924006e-02f, 8.05014092e-03f, 4.13658656e-02f, 4.22882196e-03f, -2.88678911e-02f, -4.89752404e-02f, 3.55855674e-02f, -7.08026141e-02f, 4.15278077e-02f, 2.24945135e-02f,
  1.18325101e-02f, 3.14655788e-02f, -1.19937100e-02f, 4.71376702e-02f, -5.50967008e-02f, -3.82262394e-02f, -1.97607167e-02f, 1.21921487e-02f, 9.46424305e-02f, -4.74637747e-02f,
  2.13664889e-01f, -9.04114842e-02f, 4.03587967e-02f, -1.19211068e-02f, -1.02924667e-02f, -1.92736126e-02f, 3.81779596e-02f, 1.72578450e-02f, 4.07221578e-02f, 5.31663187e-02f,
  -7.54639506e-02f, 1.08866863e-01f, -4.96679209e-02f, -7.11023659e-02f, 7.47228786e-02f, 1.08992830e-02f, -4.91905175e-02f, 3.15340199e-02f, 1.68778859e-02f, 3.32693420e-02f,
  -1.78679023e-02f, 3.43366899e-02f, 1.56715527e-01f, 7.05809146e-02f, 7.32199922e-02f, 1.89554229e-01f, 1.31956805e-02f, 1.12224087e-01f, 2.35178322e-01f, 1.92979053e-01f,
  3.85467000e-02f, -1.72659814e-01f, 3.16497892e-01f, 1.98944509e-01f, 3.23327214e-01f, 4.24435139e-01f, 5.07862628e-01f, 2.77881622e-01f, 3.40053327e-02f, 3.62551138e-02f,
  -1.44104213e-02f, -1.43332452e-01f, -2.46737018e-01f, -1.81631416e-01f, -4.05563451e-02f, 1.54928401e-01f, 1.21861294e-01f, -7.00325146e-02f, -3.06307478e-03f, -1.39151877e-02f,
  -7.75640160e-02f, -5.91037935e-03f, -8.22767019e-02f, -1.14385612e-01f, 1.42538808e-02f, -7.30608851e-02f, 6.73639029e-02f, -4.38507982e-02f, -1.13464937e-01f, -8.54537860e-02f,
  -1.61333740e-01f, 1.21031910e-01f, -5.52234724e-02f, -1.25535473e-01f, 7.91282505e-02f, -1.27909362e-01f, 1.29655264e-02f, -4.26067896e-02f, -9.65737402e-02f, -3.89729091e-03f,
  -3.92899513e-02f, -8.23347047e-02f, 5.26396073e-02f, -1.31124882e-02f, 7.06126466e-02f, 4.16410295e-03f, -1.38397157e-01f, -6.88156933e-02f, -1.62053127e-02f, -1.03489034e-01f,
  -1.63051277e-01f, 3.83695401e-02f, 2.79008567e-01f, 2.04490304e-01f, 1.27669215e-01f, -8.83201808e-02f, 6.80921227e-02f, -5.87337688e-02f, 3.38163860e-02f, -6.26978725e-02f,
  9.01512709e-03f, 8.75798836e-02f, 1.34543076e-01f, 1.62888058e-02f, 6.62775487e-02f, 2.57852394e-02f, 1.17210202e-01f, 4.27878723e-02f, 9.54659879e-02f, -4.12101950e-03f,
  3.94420661e-02f, 2.97882874e-02f, -3.05670667e-02f, 6.34597614e-02f, -6.51211143e-02f, 6.70391247e-02f, 3.28788580e-03f, -9.68023613e-02f, -3.87327932e-02f, -2.64820755e-02f,
  -7.48457611e-02f, -1.17789367e-02f, 1.14933379e-01f, 3.58761288e-02f, -1.60533993e-03f, -2.35446319e-02f, 5.67117892e-02f, -6.80640712e-02f, 5.27732857e-02f, -3.40365246e-02f,
  -2.31615350e-01f, 2.13192865e-01f, -2.58510560e-03f, -9.67737511e-02f, 4.62972708e-02f, -1.01753891e-01f, 3.34436423e-03f, -5.95968701e-02f, -8.05965886e-02f, -9.38278995e-03f,
  -4.50682044e-02f, 4.80246209e-02f, 9.77462903e-02f, -6.91710413e-02f, 4.74389456e-02f, 5.00298403e-02f, -5.08925207e-02f, -1.00233508e-02f, -5.30031584e-02f, -1.19462237e-01f,
  -7.32065290e-02f, 9.54026952e-02f, 1.10119417e-01f, 9.15146917e-02f, -5.02430573e-02f, -1.24130305e-02f, -8.21799785e-03f, 6.29685074e-02f, 1.27657518e-01f, -5.74977025e-02f,
  -2.29320228e-01f, -3.70243751e-02f, -1.47212893e-01f, -1.43634140e-01f, -3.65480334e-02f, 9.51434001e-02f, 1.60876848e-02f, 1.21737294e-01f, 2.83837803e-02f, 2.75433902e-02f,
  -2.39072349e-02f, -1.07409701e-01f, -1.67395785e-01f, -1.32355303e-01f, -1.17814064e-01f, -3.60662043e-02f, -1.34750113e-01f, -2.83729881e-01f, -1.32634729e-01f, -2.10319757e-02f,
  -9.20838024e-03f, -1.69440955e-01f, -1.68349907e-01f, -2.50454363e-03f, -4.13684025e-02f, -1.96009111e-02f, -1.11308560e-01f, 4.61082421e-02f, 1.39777377e-01f, -1.40200043e-02f,
  -2.25761518e-01f, -3.06480732e-02f, -3.53186321e-03f, 2.59184837e-02f, 1.62130203e-02f, 1.82922836e-02f, -7.15696514e-02f, 2.78856009e-02f, -6.49450161e-03f, -4.93948944e-02f,
  -5.29722422e-02f, -7.18516633e-02f, -6.15679249e-02f, 4.34794649e-02f, -5.84650598e-02f, 4.17258404e-02f, -5.67022711e-02f, -7.24651515e-02f, 1.16852999e-01f, 8.35949108e-02f,
  9.98966992e-02f, 1.60952672e-01f, -7.83910789e-03f, 1.18872248e-01f, 1.11280635e-01f, -3.66705507e-02f, 1.61520123e-01f, 1.43415689e-01f, 1.67343691e-01f, 2.33297154e-01f,
  -6.77783340e-02f, 3.06889787e-02f, 2.93084513e-02f, 7.07025174e-03f, 2.59099249e-02f, 3.65594728e-03f, -3.91446091e-02f, -7.73343816e-02f, -8.56156368e-03f, 6.08854964e-02f,
  -2.37771384e-02f, -6.15189336e-02f, -7.67995566e-02f, 1.11220395e-02f, 1.95851792e-02f, 2.34706532e-02f, 2.43425854e-02f, -2.22990718e-02f, 5.14517492e-03f, 5.39133884e-02f,
  -4.24510464e-02f, 9.56337228e-02f, -4.83290218e-02f, 4.94629368e-02f, -5.69210649e-02f, 1.18100820e-02f, -3.12338173e-02f, 2.82274392e-02f, -7.74019957e-02f, 4.75635640e-02f,
  -1.31883293e-01f, 4.38749930e-03f, 7.08140582e-02f, 2.57128254e-02f, -3.49950828e-02f, -5.13854735e-02f, -1.44664487e-02f, -1.18829317e-01f, -8.30208063e-02f, 4.22714576e-02f,
  -2.28594076e-02f, -2.31767260e-02f, -5.48734888e-02f, -3.83771285e-02f, -3.14765833e-02f, 3.47372964e-02f, -6.02212548e-02f, 1.23396125e-02f, 7.17551857e-02f, -7.34868124e-02f,
  -3.59756425e-02f, 1.48645923e-01f, -9.28593725e-02f, -1.48226535e-02f, 1.16537705e-01f, -6.99035972e-02f, 3.48400734e-02f, 1.31396502e-01f, -3.62050235e-02f, 1.02742419e-01f,
  -3.80811095e-01f, 4.07857776e-01f, 3.20036672e-02f, -3.54003310e-02f, 2.34260246e-01f, 2.87112713e-01f, 5.04667938e-01f, 1.54852390e-01f, -9.93011370e-02f, 1.27950817e-01f,
  1.32083505e-01f, -8.12400877e-02f, -1.81570500e-01f, -1.44040659e-01f, 1.40389070e-01f, 1.83000237e-01f, 1.33185610e-01f, -2.95079887e-01f, -2.50531316e-01f, -1.63394406e-01f,
  3.74059379e-02f, -7.50940889e-02f, -2.50645489e-01f, -1.02039583e-01f, -8.64410549e-02f, -2.39547685e-01f, 5.63371889e-02f, 2.41555646e-03f, 2.49364559e-04f, -4.33760844e-02f,
  -1.36801705e-01f, 1.83360681e-01f, -1.22349367e-01f, -1.70423552e-01f, 3.51041853e-02f, -1.51895434e-01f, -2.86870617e-02f, -4.10184227e-02f, -2.68509910e-02f, -1.52906599e-02f,
  5.92946000e-02f, -5.67363873e-02f, 5.36491461e-02f, -7.80965993e-03f, 1.82079226e-02f, -4.87333350e-02f, 4.29838896e-03f, -1.06555551e-01f, -4.45800349e-02f, 6.15376607e-02f,
  2.24153891e-01f, 2.24584388e-03f, 4.65008318e-02f, 1.44345805e-01f, 1.95038661e-01f, 5.03552221e-02f, 1.87938824e-01f, -3.59634086e-02f, 1.36752248e-01f, -9.95693281e-02f,
  -6.91941753e-02f, 7.97460973e-03f, 1.41184134e-02f, -1.17547838e-02f, 2.20036390e-03f, -7.18242228e-02f, 1.31122591e-02f, -2.34392881e-02f, 3.29682752e-02f, -4.25146036e-02f,
  -8.92833248e-02f, 5.19817397e-02f, 3.43658440e-02f, 1.59906670e-02f, -4.53577712e-02f, 7.91571394e-04f, 4.15964313e-02f, 4.92671169e-02f, -1.00240290e-01f, 5.39481454e-02f,
  -1.55827645e-02f, 6.27294108e-02f, 2.83251777e-02f, 9.53473896e-02f, 1.42834699e-02f, 3.01823355e-02f, -5.89051172e-02f, 1.26670390e-01f, -1.95475053e-02f, -8.28679651e-02f,
  -2.91700754e-02f, 1.09863892e-01f, -1.91212296e-01f, -3.47198136e-02f, 9.35177132e-02f, -1.13076298e-02f, 2.54448820e-02f, 2.49510016e-02f, 7.81147704e-02f, 2.92808954e-02f,
  6.86282963e-02f, -1.29545704e-02f, 8.81497785e-02f, -6.29492253e-02f, -3.63920145e-02f, -3.05089820e-02f, 1.52778663e-02f, -1.49264649e-01f, -3.00815958e-03f, -7.94227794e-03f,
  4.79955003e-02f, -6.28438741e-02f, -2.14691848e-01f, -1.10353574e-01f, -4.65405552e-04f, -7.43018687e-02f, 3.74835990e-02f, -7.55254179e-02f, -5.67704514e-02f, -1.74393445e-01f,
  1.56250477e-01f, -6.80372417e-02f, -1.26180798e-01f, 8.35219175e-02f, 1.25850989e-02f, 9.91179645e-02f, 5.69828879e-03f, -1.95074696e-02f, 1.36339650e-01f, 8.87934715e-02f,
  1.45685047e-01f, 1.91929668e-01f, 2.16787711e-01f, 1.58193797e-01f, 1.01280034e-01f, 1.08500168e-01f, 4.25822921e-02f, 7.01525509e-02f, 2.28701457e-02f, 5.00987582e-02f,
  -7.27562681e-02f, -1.80276051e-01f, -8.64854530e-02f, -4.88761812e-02f, 3.23761953e-03f, -1.46173453e-02f, 4.77532973e-04f, -8.90881643e-02f, -1.13432989e-01f, -8.96933228e-02f,
  1.23570234e-01f, 4.38626632e-02f, 1.44466966e-01f, -3.63959074e-02f, -1.21336073e-01f, 3.02031692e-02f, 2.51883455e-02f, -3.65407811e-03f, -9.54187363e-02f, -1.14626186e-02f,
  1.26215033e-02f, -4.09483053e-02f, -1.37930214e-01f, -1.89017262e-02f, -1.15154013e-01f, -2.82664839e-02f, -7.30748102e-02f, 1.20921791e-01f, 1.81091860e-01f, 3.49458493e-02f,
  4.51873280e-02f, 8.86651576e-02f, 1.08487129e-01f, 1.34374723e-01f, 5.69006242e-02f, 7.87204951e-02f, -9.44886580e-02f, -4.45900601e-04f, 1.44925844e-02f, 6.34462014e-02f,
  8.98442864e-02f, 3.88178825e-02f, -1.26530193e-02f, -8.21832791e-02f, 3.38349752e-02f, -3.90218422e-02f, -4.81032655e-02f, 1.12428358e-02f, 7.33224824e-02f, -1.16742939e-01f,
  1.39794098e-02f, 7.18096346e-02f, 2.69499049e-02f, 4.97198254e-02f, 1.58171859e-02f, -8.09958130e-02f, 3.21440324e-02f, -6.95281401e-02f, 5.32688200e-02f, -6.53924746e-03f,
  6.24650158e-02f, -6.30366281e-02f, -1.01310939e-01f, 2.75462624e-02f, 2.71759965e-02f, 1.20143838e-01f, 3.17450427e-02f, -1.86419506e-02f, -8.96096379e-02f, -7.46788383e-02f,
  -6.70896396e-02f, 2.70597428e-01f, 4.90938500e-02f, 3.32183316e-02f, -4.93024662e-02f, -5.89569435e-02f, -5.94923215e-04f, -5.31305857e-02f, 2.25579981e-02f, 5.76668233e-03f,
  -6.92275465e-02f, -3.58582176e-02f, -1.55901074e-01f, 3.48603614e-02f, -6.26138151e-02f, 3.11789475e-02f, -6.41252249e-02f, 6.93069398e-02f, 6.59750178e-02f, 1.41386492e-02f,
  6.38399720e-02f, 6.31831586e-02f, 1.57254916e-02f, 3.60479578e-02f, 1.50679380e-01f, 8.57723206e-02f, -5.67557923e-02f, -3.78900319e-02f, 1.04796745e-01f, -7.38020763e-02f,
  -1.46292493e-01f, -1.12594254e-01f, -1.14529178e-01f, 1.21335283e-01f, 1.21745810e-01f, 2.05583632e-01f, 2.38770977e-01f, 1.89447314e-01f, 6.71459436e-02f, 5.08936755e-02f,
  9.23095271e-02f, 1.91806272e-01f, 1.97472095e-01f, 1.33013025e-01f, -2.95969401e-03f, 1.13609955e-01f, 1.59136370e-01f, 1.96853001e-02f, -8.04818943e-02f, 6.35282025e-02f,
  1.91859230e-01f, -4.40221392e-02f, -9.79404300e-02f, 1.45433415e-02f, 5.60361743e-02f, 7.63975978e-02f, 7.74420276e-02f, -1.55913070e-01f, 7.98878726e-03f, -2.80156615e-03f,
  -1.27495915e-01f, -2.92241365e-01f, 5.18891960e-02f, -2.30384743e-04f, -1.13683201e-01f, -1.64651826e-01f, -8.72795004e-03f, -1.01223737e-01f, -1.99855100e-02f, -7.32615292e-02f,
  -1.40072010e-03f, -4.26748507e-02f, 6.53326139e-02f, -1.78050306e-02f, -2.73375884e-02f, 1.07254609e-01f, 5.57159297e-02f, 4.26319316e-02f, -9.56577994e-03f, -2.70272791e-02f,
  7.43958727e-02f, -1.10610843e-01f, -3.57195325e-02f, 1.17054172e-01f, -3.59471393e-04f, 6.01190627e-02f, -7.68701807e-02f, -5.82533889e-02f, 1.70329269e-02f, -1.04865460e-02f,
  3.01940162e-02f, 1.00960873e-01f, -5.11531569e-02f, -1.70511883e-02f, 8.91432911e-02f, 8.03967123e-04f, 1.04198396e-01f, 7.01063946e-02f, 3.02540995e-02f, -3.17668691e-02f,
  -4.57383394e-02f, 2.68542580e-02f, 1.49012972e-02f, 2.50584576e-02f, 1.04109719e-01f, -4.44944277e-02f, -4.13198546e-02f, 2.88712550e-02f, 3.91856097e-02f, -1.86564366e-03f,
  1.04011379e-01f, -1.00928135e-01f, -1.22171789e-01f, 5.16001917e-02f, 4.22925465e-02f, 1.40437186e-01f, 1.12370532e-02f, -5.74294925e-02f, -5.77162346e-03f, -9.00540277e-02f,
  -4.06183079e-02f, 7.36638680e-02f, 1.15205586e-01f, 1.08618088e-01f, -6.64267614e-02f, -5.00925519e-02f, 2.60864440e-02f, -1.10985562e-01f, -1.15022212e-01f, -1.09136060e-01f,
  -8.58256146e-02f, -3.17118093e-02f, 6.72985986e-02f, 1.25124946e-01f, -8.33462831e-03f, 1.15334786e-01f, 8.61229450e-02f, 1.03908196e-01f, -3.04604080e-02f, -4.16286662e-02f,
  7.26758242e-02f, 3.09563112e-02f, -9.91535410e-02f, 1.27662928e-03f, 5.69055863e-02f, 8.87436718e-02f, -7.01128319e-02f, -6.58504441e-02f, -8.87764152e-03f, -7.07276762e-02f,
  -4.59767789e-01f, -3.59165072e-01f, 7.54911676e-02f, -2.26726964e-01f, -9.01332125e-02f, 1.50960982e-02f, -9.27531943e-02f, 6.56622797e-02f, -1.16387836e-03f, -1.31764933e-01f,
  -1.01634502e-01f, 4.49179783e-02f, 7.19811860e-03f, 3.89499925e-02f, 1.25054661e-02f, -1.67072460e-01f, -1.32966042e-01f, 1.10712208e-01f, 1.76246241e-01f, 9.80422497e-02f,
  -3.38410190e-03f, -1.85358394e-02f, 5.03433608e-02f, 1.15565062e-01f, -2.66567826e-01f, 1.55890649e-02f, -5.17185666e-02f, -1.09276019e-01f, -4.25559990e-02f, -4.40115005e-01f,
  -9.39358771e-02f, 1.09786922e-02f, 1.51200801e-01f, -7.88652897e-02f, -4.02122736e-02f, 3.71117890e-03f, 1.47470329e-02f, -2.38349568e-02f, 4.83961180e-02f, 2.89247986e-02f,
  -6.07411936e-02f, 4.91714664e-02f, -5.74689694e-02f, 9.62726250e-02f, 4.29008789e-02f, 6.35557156e-03f, 8.20927322e-03f, 4.66988161e-02f, 6.15291148e-02f, 3.41789536e-02f,
  -1.60962075e-01f, -7.52291754e-02f, 8.29895958e-03f, 4.32063863e-02f, 1.13268778e-01f, 1.49269039e-02f, 9.61980596e-02f, -1.14979714e-01f, -1.73066685e-03f, -2.77758092e-01f,
  8.23248848e-02f, -8.42571259e-02f, 3.77121270e-02f, 2.35934108e-02f, -4.47883569e-02f, -5.52226268e-02f, -3.48601653e-03f, -8.24627057e-02f, 4.32230160e-03f, -1.24535136e-01f,
  1.19172834e-01f, -7.58309674e-04f, 8.88555422e-02f, -8.89444798e-02f, -3.88224125e-02f, 7.96621814e-02f, -4.84657213e-02f, 2.34414563e-02f, 1.84813067e-02f, -3.99492420e-02f,
  -1.55997381e-03f, 9.17434134e-03f, -1.89304501e-02f, 6.58059269e-02f, -2.10202336e-02f, -9.06515568e-02f, 1.40747903e-02f, 1.60368942e-02f, -2.34144814e-02f, 4.94489186e-02f,
  -2.44870186e-01f, 1.67584315e-01f, -2.09341764e-01f, 7.54533559e-02f, -1.22005781e-02f, 1.14671132e-02f, -9.46644619e-02f, -6.11490384e-02f, -3.24250497e-02f, -7.13750273e-02f,
  -1.31908758e-03f, 3.18484101e-03f, -1.20736705e-02f, 3.05361580e-02f, 1.39600858e-02f, -1.07682729e-02f, -5.79366349e-02f, -5.60342371e-02f, 3.25188376e-02f, 6.78943098e-02f,
  7.19410076e-04f, -7.64177814e-02f, -8.14698637e-02f, -1.48595423e-02f, -3.29664424e-02f, 1.95674133e-03f, -1.43540129e-01f, -1.53470524e-02f, -1.22657962e-01f, -3.56389701e-01f,
  -2.89761513e-01f, 6.80236071e-02f, -6.93310425e-02f, -1.46646693e-01f, -1.35016859e-01f, -2.19058674e-02f, -1.22533210e-01f, 1.03363194e-01f, 7.34264255e-02f, -5.36506027e-02f,
  5.83435446e-02f, -6.99952170e-02f, -3.02368756e-02f, 8.99638087e-02f, -1.15870222e-01f, -1.17180750e-01f, -1.49925232e-01f, -1.08441040e-01f, 4.04820628e-02f, 2.06849203e-02f,
  -1.13818362e-01f, -2.66623706e-01f, -2.32686549e-01f, 3.85907330e-02f, -1.39369339e-01f, -1.15900636e-01f, -2.23559886e-01f, -3.00938159e-01f, -8.09533373e-02f, -3.68338287e-01f,
  -1.70857623e-01f, -1.74003944e-01f, -2.72085760e-02f, 1.64325945e-02f, -1.05767250e-01f, 1.39143080e-01f, -1.96756236e-02f, -5.87847643e-03f, 7.42290989e-02f, 1.43350333e-01f,
  -5.47531396e-02f, 6.95859939e-02f, 1.33009087e-02f, -1.22584924e-02f, -6.46093115e-02f, -4.31295251e-03f, 1.18005760e-01f, -1.53102987e-02f, -8.58782530e-02f, 5.87497763e-02f,
  -7.65450373e-02f, -8.17409754e-02f, -1.24243097e-02f, 3.08702383e-02f, -2.87318397e-02f, 5.15733566e-03f, -4.30353358e-02f, 5.51138856e-02f, -5.98305464e-02f, -1.15669355e-01f,
  -6.93483651e-02f, -5.87594397e-02f, -7.36702010e-02f, -4.52906229e-02f, -1.85914226e-02f, 5.21658026e-02f, 3.17416675e-02f, 1.67918000e-02f, 8.92332494e-02f, -7.63423368e-02f,
  6.81989565e-02f, -6.36947826e-02f, -1.42287007e-02f, -9.41207558e-02f, 6.10300899e-02f, -3.31929028e-02f, 6.90511316e-02f, -6.78849742e-02f, 5.10535873e-02f, -7.42948428e-02f,
  1.07368693e-01f, -1.27721280e-02f, -4.62340489e-02f, -2.75256429e-02f, 8.50280523e-02f, 8.27060360e-03f, 2.86670458e-02f, 4.83740605e-02f, 7.19215274e-02f, 4.97052372e-02f,
  1.76898375e-01f, -7.51612782e-02f, -7.24186525e-02f, 3.80587578e-02f, 3.77316102e-02f, 4.19940501e-02f, 9.88229588e-02f, 1.25006750e-01f, 4.11862358e-02f, 4.99350578e-02f,
  1.09095596e-01f, 5.97140577e-04f, -1.02372896e-02f, 5.44574223e-02f, 6.29267916e-02f, 6.00659586e-02f, 9.34414566e-02f, 1.79038588e-02f, 2.83829460e-04f, 1.05394527e-01f,
  1.03871021e-02f, 3.98547389e-02f, -1.05939910e-03f, -7.30368346e-02f, -3.54658104e-02f, -1.64861143e-01f, 1.64678097e-02f, -1.29509047e-01f, -1.16798347e-02f, -2.78718583e-02f,
  -4.94321734e-01f, 4.22005296e-01f, -3.26068103e-02f, -2.98945457e-01f, -2.77523130e-01f, 9.34200548e-03f, 1.34667084e-01f, 7.72623345e-02f, -2.14412026e-02f, 2.81295747e-01f,
  7.05052018e-02f, -7.48715922e-02f, 1.04798377e-01f, -2.29859240e-02f, -2.35449802e-02f, 4.72540855e-02f, -2.86544144e-01f, -3.53492647e-01f, -3.90292048e-01f, -2.44388729e-01f,
  -1.67728871e-01f, -3.21679205e-01f, -3.13443542e-01f, -2.38380842e-02f, 3.90914902e-02f, 2.91625615e-02f, 2.58628801e-02f, -2.01185703e-01f, 5.26202731e-02f, -6.03131987e-02f,
  7.53442645e-02f, -2.43501723e-01f, -2.84650214e-02f, -2.48744875e-01f, 9.08334404e-02f, -2.53196973e-02f, 1.62831265e-02f, -6.58314079e-02f, -4.48682234e-02f, -2.80728042e-02f,
  -1.40768930e-01f, -4.47210893e-02f, -6.83790296e-02f, -4.12508547e-02f, -3.23991664e-02f, -4.83970456e-02f, -4.07521240e-02f, -1.10587902e-01f, 4.30856906e-02f, 5.63494861e-02f,
  5.90926707e-02f, -1.38883844e-01f, -1.54467225e-01f, 1.25694171e-01f, 6.71173707e-02f, -1.98751137e-01f, -2.85087544e-02f, 1.32573452e-02f, 1.16029521e-02f, 3.14626962e-01f,
  6.39231950e-02f, -1.39539074e-02f, 1.56548731e-02f, 1.03154510e-01f, -1.92354135e-02f, -9.70458239e-03f, -5.49524724e-02f, 7.21943602e-02f, 9.66386590e-03f, 3.54805961e-02f,
  4.75433841e-02f, 6.12763315e-02f, 6.11245111e-02f, -4.60611843e-03f, 2.04716809e-02f, -5.15924348e-03f, -7.71452487e-02f, 3.34466016e-03f, -2.09641904e-02f, -9.44607928e-02f,
  5.12658358e-02f, -1.06252506e-01f, 8.23087618e-02f, 3.09882723e-02f, -5.83399236e-02f, -4.57550101e-02f, -7.94791058e-02f, 3.58841792e-02f, 4.77376916e-02f, -9.80994105e-02f,
  3.37341160e-01f, -1.34529203e-01f, 6.13027364e-02f, 4.03632000e-02f, -4.74002548e-02f, 5.25670424e-02f, 1.85903236e-02f, 4.54013646e-02f, 4.77886349e-02f, 2.80409819e-04f,
  -7.58052245e-02f, 1.52640548e-02f, 5.02517335e-02f, 4.13645469e-02f, -4.11176942e-02f, 2.10839044e-02f, 5.41699398e-03f, -1.17276236e-01f, -7.43327364e-02f, -5.41854789e-03f,
  9.16365013e-02f, 7.33102858e-02f, 1.64008141e-02f, 8.89763385e-02f, -1.53940152e-02f, -9.06092525e-02f, 3.36779617e-02f, 4.93677184e-02f, -1.23032503e-01f, 5.23469687e-01f,
  7.48248175e-02f, -1.20942809e-01f, 2.47145832e-01f, -6.62631318e-02f, 1.33092493e-01f, 1.60742939e-01f, 1.62115246e-01f, 9.77455080e-02f, -2.82555316e-02f, -1.28028598e-02f,
  -7.14010447e-02f, -1.27249926e-01f, -1.53265953e-01f, -3.18173543e-02f, -9.07119587e-02f, -3.49944294e-03f, 1.00744776e-01f, 9.02879983e-02f, 7.14089274e-02f, 6.24214374e-02f,
  5.53401373e-02f, 4.90355752e-02f, -2.67974306e-02f, -8.80804434e-02f, -6.51498809e-02f, 3.53990905e-02f, 3.99099477e-02f, -1.04596786e-01f, -4.20649014e-02f, 5.55145834e-03f,
  2.12281495e-01f, -4.90699597e-02f, 1.06715932e-01f, -1.31056085e-01f, 8.83791819e-02f, -5.43408617e-02f, -1.73180830e-02f, -6.09065369e-02f, 3.15374807e-02f, 3.61206643e-02f,
  -2.68255696e-02f, 3.90569903e-02f, 1.39403511e-02f, -8.89067650e-02f, 1.05391152e-01f, 8.51070955e-02f, -1.96708608e-02f, -1.33031860e-01f, -2.04696017e-03f, 6.00625761e-02f,
  -1.90191697e-02f, -8.71216431e-02f, 3.69173400e-02f, -6.67780340e-02f, 4.44192737e-02f, -8.27486068e-02f, -3.20007391e-02f, -8.97747502e-02f, -2.90028267e-02f, -3.75601836e-02f,
  -3.86772794e-03f, 7.55066946e-02f, -5.49838990e-02f, 1.38428705e-02f, -1.09745376e-02f, 3.38162892e-02f, 6.80856267e-03f, 3.81975598e-03f, -4.12545279e-02f, 9.71676875e-03f,
  -5.95020168e-02f, 5.25257783e-03f, 3.90413776e-02f, 2.71158926e-02f, -5.69148315e-03f, 3.79036367e-02f, 6.46457300e-02f, -9.35687050e-02f, -5.25188595e-02f, -1.00301113e-02f,
  2.66426168e-02f, -6.63263425e-02f, 8.34663119e-03f, -6.14361316e-02f, -8.79634619e-02f, -2.97704060e-03f, -8.18820298e-02f, 1.92998983e-02f, -4.91100326e-02f, 2.64855437e-02f,
  3.67780477e-02f, -9.08031315e-02f, 3.43349427e-02f, -1.54984668e-01f, 4.82615903e-02f, -6.64864108e-02f, -1.83703732e-02f, -4.77574840e-02f, 3.47133204e-02f, 4.80339490e-02f,
  -7.70751685e-02f, 9.84829501e-04f, 4.91506129e-04f, -9.51034483e-03f, 2.01666690e-02f, 1.19626984e-01f, -8.11799541e-02f, 5.92995696e-02f, 7.88217634e-02f, 9.23604816e-02f,
  5.60462801e-03f, 1.86993897e-01f, 7.71400928e-02f, 4.30635661e-02f, 3.68954195e-03f, 1.58694029e-01f, 2.49841422e-01f, 7.01774210e-02f, 1.34552583e-01f, 2.53400981e-01f,
  -4.02973920e-01f, 2.69070715e-01f, -1.45839885e-01f, -2.32624799e-01f, 7.55403191e-02f, 1.54969335e-01f, 2.41789550e-01f, 1.95558131e-01f, -7.32278228e-02f, 5.71685322e-02f,
  -4.87180091e-02f, -7.15247495e-03f, 6.86554937e-03f, 6.75570741e-02f, 1.94968939e-01f, 1.69116288e-01f, 2.41998821e-01f, -2.77079381e-02f, -2.12888062e-01f, -7.93731026e-03f,
  -5.76783754e-02f, -1.34537697e-01f, -2.37026945e-01f, -1.29368931e-01f, 6.11484013e-02f, -1.28564283e-01f, -1.87574700e-02f, -5.48362434e-02f, 2.93965060e-02f, 6.74642920e-02f,
  -1.52447820e-01f, 1.00140966e-01f, 1.74948089e-02f, -5.19495718e-02f, -6.04703091e-02f, 3.60823497e-02f, 4.50640470e-02f, 2.43034922e-02f, 1.50134601e-02f, -1.01779876e-02f,
  -1.02915794e-01f, 7.19932765e-02f, -1.73406228e-02f, -7.19126612e-02f, -8.82228762e-02f, -6.58238828e-02f, 3.53818499e-02f, 1.01089003e-02f, 8.40477273e-02f, -3.17042917e-02f,
  3.26535143e-02f, 2.28919275e-02f, -4.75290120e-02f, 9.20391753e-02f, 3.05310600e-02f, -3.66069796e-03f, 8.72077718e-02f, -1.01802023e-02f, 6.16173930e-02f, -6.59329593e-02f,
  4.39243624e-03f, 6.34120256e-02f, 4.14773859e-02f, -2.62847394e-02f, -4.27750945e-02f, 4.60972525e-02f, -7.52569288e-02f, 5.16742729e-02f, 7.02969283e-02f, -7.38205165e-02f,
  6.10439926e-02f, -7.95919355e-03f, -4.74598184e-02f, 1.14072403e-02f, -1.15204982e-01f, -9.78726335e-03f, 9.68903769e-03f, 5.41910231e-02f, -6.11277763e-04f, 8.37957487e-03f,
  -6.22109510e-03f, -1.15199126e-02f, 4.76914160e-02f, 4.16267402e-02f, 1.82174575e-02f, 2.66976263e-02f, 4.12006769e-03f, 4.76122983e-02f, 5.78623712e-02f, 3.06904968e-02f,
  -2.02823937e-01f, 4.62250039e-02f, -2.95943953e-02f, -4.14741114e-02f, -6.31134138e-02f, -2.11921856e-02f, -3.70553024e-02f, 3.22792605e-02f, 3.17218574e-03f, -3.13254930e-02f,
  -2.35814950e-03f, -1.96873415e-02f, 1.57909244e-02f, 3.86954844e-02f, 3.35065927e-03f, -3.49512026e-02f, -2.36916952e-02f, 5.41803204e-02f, 1.32533953e-01f, 1.62167810e-02f,
  8.56083166e-03f, -1.04118688e-02f, -5.91126531e-02f, 1.00591704e-02f, 8.22840258e-04f, -6.71513677e-02f, -1.33060500e-01f, -5.38664162e-02f, -6.87946454e-02f, -2.45874435e-01f,
  -8.55290964e-02f, -6.81737289e-02f, 3.65162864e-02f, 2.81440556e-01f, 2.75521398e-01f, 2.57107913e-01f, 1.79701820e-01f, 1.47654146e-01f, 1.70799434e-01f, 4.25383113e-02f,
  6.96452409e-02f, 1.84332177e-01f, 1.19109266e-01f, 7.19600245e-02f, 4.21419693e-03f, 8.97444487e-02f, 6.00728802e-02f, 4.03048247e-02f, 8.91770720e-02f, -1.90346166e-02f,
  1.66267902e-01f, 7.27366582e-02f, -8.05200264e-02f, -3.93593349e-02f, 1.00819275e-01f, 7.01502860e-02f, -3.06001082e-02f, -7.85184056e-02f, 8.92675817e-02f, -6.33540303e-02f,
  3.62701379e-02f, -2.71635875e-02f, 4.24422659e-02f, -7.63140991e-02f, -1.12040542e-01f, -1.42317221e-01f, -5.97142130e-02f, -8.54579508e-02f, 2.20428091e-02f, 2.97279097e-02f,
  4.11601253e-02f, -1.52855337e-01f, 2.89543439e-02f, -3.85057330e-02f, 1.16215274e-02f, 4.40731794e-02f, -4.88905311e-02f, -8.41038674e-02f, -3.82397436e-02f, -1.01949824e-02f,
  4.22431044e-02f, -9.29242298e-02f, -7.03063831e-02f, 7.68996179e-02f, 2.17310283e-02f, -2.10026093e-02f, -8.39426182e-03f, -9.77425277e-02f, -9.03080627e-02f, 1.08731759e-03f,
  9.48311202e-03f, 3.24833696e-03f, 1.26418229e-02f, -8.73560980e-02f, -4.44933847e-02f, -3.77388746e-02f, -7.36761764e-02f, 3.41454074e-02f, -5.16300313e-02f, -3.35186236e-02f,
  -2.66934093e-02f, -3.22481128e-03f, 4.00824621e-02f, 1.13155566e-01f, 1.05050839e-01f, -9.04778391e-02f, -7.77986869e-02f, -7.11106285e-02f, -7.02208355e-02f, -1.19683603e-02f,
  -7.74895772e-02f, 2.67140176e-02f, 1.94425583e-02f, -1.05754837e-01f, -5.25483005e-02f, -3.99751626e-02f, -1.60277002e-02f, -5.16132312e-03f, 7.64226615e-02f, -6.34788256e-03f,
  3.02208290e-02f, 7.55385160e-02f, 2.26179808e-02f, -1.02831768e-02f, -4.57587130e-02f, 5.42412065e-02f, 6.62209913e-02f, -3.92021388e-02f, -5.47185875e-02f, 5.69165349e-02f,
  1.55235780e-02f, -8.43666587e-03f, -2.11886168e-02f, -3.09342351e-02f, -6.18209578e-02f, -5.69831841e-02f, -7.08790869e-02f, -6.26518056e-02f, -4.79427874e-02f, -7.15598688e-02f,
  -2.59036385e-02f, -1.08784072e-01f, -1.17551327e-01f, 3.78687195e-02f, -6.24815188e-02f, -2.30625421e-02f, -5.24028204e-03f, 2.84871347e-02f, -1.18950047e-01f, 2.60862634e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.97636738e-01f, 2.05125347e-01f, 4.71331567e-01f, 6.43062219e-02f, 7.08098710e-02f, 1.59879833e-01f, 3.96824330e-02f, 6.12218194e-02f, 4.00713921e-01f, 5.02891660e-01f,
  4.84629840e-01f, 4.40608375e-02f, 1.16197392e-01f, 1.96269989e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.48001873e-01f, 1.42764390e-01f, 2.12793872e-01f, -6.73855767e-02f, -5.58311522e-01f, -1.25096083e-01f, 4.04749304e-01f, 3.30253422e-01f, -3.40388119e-01f, 2.87635982e-01f,
  -9.86251608e-02f, -3.74760479e-01f, 1.95955291e-01f, -3.05984885e-01f, 4.43114370e-01f, -1.88572973e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.03200266e-01f, 2.38145739e-01f, 3.01556498e-01f, 1.55888006e-01f, -2.30922744e-01f, 3.95542979e-01f, -1.12477727e-01f, 5.70216238e-01f, -1.31876677e-01f, -1.70332734e-02f,
  -9.04363319e-02f, -2.85615623e-02f, -2.06825674e-01f, 1.30800739e-01f, 4.40391183e-01f, -1.10650986e-01f, 1.23487554e-01f, -1.61019772e-01f, 5.94426654e-02f, -2.05555171e-01f,
  -5.79737984e-02f, 2.42265854e-02f, -1.14028208e-01f, -2.16742754e-01f, -1.88029736e-01f, -3.39193344e-02f, 7.40208104e-02f, -1.96030915e-01f, -2.63728220e-02f, 1.18381947e-01f,
  -4.25620861e-02f, 1.65238485e-01f, 1.29475474e-01f, 1.96471423e-01f, 7.39674503e-03f, -5.42871878e-02f, 6.90156460e-01f, 3.45950782e-01f, -2.43507132e-01f, -3.91364515e-01f,
  -2.08989963e-01f, 3.44549827e-02f, -5.80764174e-01f, 6.37823418e-02f, 5.90601861e-01f, 9.60226953e-02f, -3.52725357e-01f, 8.16044956e-02f, 1.51206553e-01f, -9.06633958e-02f,
  -9.80306342e-02f, 2.95550972e-02f, 5.51773071e-01f, -1.85594112e-01f, 1.17578499e-01f, -1.53663918e-01f, 1.34021461e-01f, 6.23341165e-02f, -1.49960946e-02f, 2.03906149e-02f,
  9.12286155e-03f, -2.54787713e-01f, -2.10751161e-01f, 1.02234408e-01f, -1.22941144e-01f, -2.39866599e-01f, -2.96677977e-01f, -2.31302842e-01f, 6.30125225e-01f, 1.00063391e-01f,
  2.79360324e-01f, -6.20941035e-02f, 1.16454102e-01f, 7.84045085e-02f, 1.70092866e-01f, 8.21009651e-02f, -4.28645253e-01f, -1.80135533e-01f, -1.55422926e-01f, 1.60616130e-01f,
  1.04558006e-01f, -1.35008827e-01f, -2.93070972e-01f, -1.57521173e-01f, 1.74002215e-01f, 3.53093058e-01f, 8.83310512e-02f, -8.13874677e-02f, 5.43596983e-01f, 4.41919118e-01f,
  -2.40705237e-01f, -4.14261855e-02f, -1.33385971e-01f, -4.77076098e-02f, -1.56858549e-01f, 2.64818490e-01f, 2.08951924e-02f, -1.20166808e-01f, -2.54663259e-01f, 4.20675240e-02f,
  -4.81754392e-01f, 3.58395949e-02f, 2.69497305e-01f, -6.07464183e-03f, 1.96087793e-01f, 2.72175018e-02f, 3.72228563e-01f, 3.84118170e-01f, 7.22485006e-01f, 2.02958621e-02f,
  2.13501155e-01f, 1.58038676e-01f, 9.29354504e-02f, -5.93988076e-02f, -1.89032525e-01f, -2.95374125e-01f, 4.19071555e-01f, 4.81509902e-02f, -1.15475871e-01f, -2.38677844e-01f,
  -3.83302689e-01f, 1.36345908e-01f, -3.62359524e-01f, 3.93578589e-01f, 5.46366334e-01f, 2.30334431e-01f, -1.96711823e-01f, 2.99711972e-01f, 1.70474842e-01f, 2.62765437e-01f,
  2.75079519e-01f, 2.91338339e-02f, 8.52456093e-01f, 3.99811178e-01f, 8.61585960e-02f, 5.35555243e-01f, 4.73393425e-02f, 1.66222915e-01f, 5.50522879e-02f, 8.73970464e-02f,
  -4.16968942e-01f, -1.49390370e-01f, 2.00186148e-01f, 1.44361600e-01f, 5.21447249e-02f, 3.84604692e-01f, 3.55207741e-01f, -2.31206775e-01f, 9.70614105e-02f, 1.95463419e-01f,
  7.21726343e-02f, 4.18444514e-01f, -1.14400521e-01f, 2.70751566e-01f, -1.53116256e-01f, -1.19095527e-01f, -2.21183807e-01f, 5.00814132e-02f, 3.20425093e-01f, 3.09208602e-01f,
  7.62005985e-01f, -4.63633567e-01f, -1.34193525e-01f, 4.42963779e-01f, 2.64672339e-01f, -1.59740180e-01f, 3.58019054e-01f, 1.17073804e-01f, -2.17045635e-01f, 3.78452510e-01f,
  7.30845511e-01f, 7.29009271e-01f, 6.24369144e-01f, -3.19447249e-01f, 3.73732857e-02f, 4.01767701e-01f, 4.43635099e-02f, -1.03927650e-01f, -5.65094948e-02f, -3.84869456e-01f,
  8.27237785e-01f, -2.09440701e-02f, 4.26309198e-01f, -2.03164533e-01f, 7.33598247e-02f, 3.50431055e-02f, 6.13064133e-02f, 3.82024169e-01f, 5.50725222e-01f, -1.77120507e-01f,
  -4.39724535e-01f, 1.20789316e-02f, 1.27520829e-01f, 4.16394293e-01f, 2.90183514e-01f, 1.74129903e-02f, -2.46264398e-01f, 5.24978578e-01f, -5.47560416e-02f, 4.40717280e-01f,
  9.04666781e-02f, 3.69571716e-01f, -2.76488960e-01f, -2.14600250e-01f, -8.48374367e-02f, 1.90119952e-01f, 2.45152026e-01f, 1.61431450e-03f, 8.30897167e-02f, 3.94839585e-01f,
  -3.72573100e-02f, -5.71285700e-03f, 1.38371170e-01f, 4.71406877e-01f, 1.38603374e-01f, -2.87273675e-01f, -2.77845830e-01f, -1.94738619e-02f, -2.65982717e-01f, -3.17092687e-02f,
  1.77587628e-01f, 3.36501598e-01f, -8.19055736e-02f, -8.52611959e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.13717996e-01f, 4.70334515e-02f, 7.00046182e-01f, -1.70674190e-01f, -2.57892977e-03f, 2.41827425e-02f, 1.30643085e-01f, 4.36902463e-01f, 2.57039398e-01f, 2.67608970e-01f,
  9.20759976e-01f, 2.93288857e-01f, 4.88838926e-02f, -1.33998126e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -5.39442718e-01f, 2.14349449e-01f, 1.67761222e-01f, 1.03061922e-01f, -1.58770114e-01f, 2.65047941e-02f, 3.55149299e-01f, 1.67782232e-01f, 4.00266461e-02f, -2.51818240e-01f,
  1.25254244e-01f, 1.78203091e-01f, 1.45631149e-01f, 1.56105444e-01f, 1.39740884e-01f, -2.93362945e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  6.08279765e-01f, -2.02700943e-01f, -6.39391020e-02f, 1.63483784e-01f, 2.50861794e-01f, 5.04203960e-02f, -3.53224367e-01f, -1.82209313e-01f, -3.79879102e-02f, 3.19591677e-03f,
  -2.60479748e-01f, -3.24839860e-01f, 7.39515722e-01f, -1.86535761e-01f, -3.44517022e-01f, -3.32734883e-01f, 2.49007028e-02f, -1.27908900e-01f, 4.29610431e-01f, 1.08886808e-02f,
  3.95177424e-01f, 4.39509183e-01f, 4.23285365e-01f, 1.57035381e-01f, -5.29944837e-01f, 3.24402630e-01f, 8.02612484e-01f, 4.95312303e-01f, 2.18301550e-01f, 4.23023999e-01f,
  8.20860863e-01f, -2.28717357e-01f, -4.79131639e-01f, 1.85120404e-01f, -6.32338002e-02f, 1.76557183e-01f, -8.48447718e-03f, 1.33226112e-01f, 2.68138081e-01f, -2.34049056e-02f,
  -7.51524745e-03f, 1.18625492e-01f, 2.26217985e-01f, -9.61680040e-02f, 5.99390984e-01f, 5.01677692e-01f, -2.88534854e-02f, -3.47746402e-01f, -8.32446069e-02f, -9.89090800e-02f,
  2.18702868e-01f, -1.62862644e-01f, -1.09466806e-01f, 1.18417256e-01f, 2.14677647e-01f, 2.30102733e-01f, 2.81221658e-01f, -1.56891808e-01f, -1.59890339e-01f, -1.46061018e-01f,
  4.15589005e-01f, 4.06588018e-01f, -8.68838504e-02f, -1.95393160e-01f, 5.93934000e-01f, -4.22681183e-01f, 2.26112995e-02f, -2.22783267e-01f, 6.29687190e-01f, -1.59156218e-01f,
  -4.10010874e-01f, -1.61100492e-01f, 5.10989726e-01f, 5.71429551e-01f, -4.61083621e-01f, -1.22955106e-01f, 3.07854086e-01f, 4.23072904e-01f, -1.46067087e-02f, 3.52329910e-01f,
  -2.36578822e-01f, -6.98783517e-01f, 1.50336564e-01f, 1.93629190e-01f, 9.58291769e-01f, 1.19133629e-01f, 3.64388108e-01f, 3.88736963e-01f, -1.71508715e-01f, 7.70638347e-01f,
  3.62366915e-01f, 1.96013302e-01f, 4.43241060e-01f, 8.48917305e-01f, 1.40480191e-01f, 3.78410853e-02f, 4.65750366e-01f, 1.29813418e-01f, -3.02851945e-02f, -1.71610504e-01f,
  -5.93920462e-02f, -9.26449373e-02f, -3.34523976e-01f, -2.80069977e-01f, 4.59507167e-01f, -1.57042854e-02f, -2.43567631e-01f, 6.59936368e-02f, 7.85736263e-01f, -1.40809655e-01f,
  -3.10124069e-01f, -2.82935470e-01f, 8.31145495e-02f, -2.53729999e-01f, -1.02955140e-01f, 2.01526746e-01f, -2.74358213e-01f, -1.91044122e-01f, -2.83225715e-01f, -3.71823162e-02f,
  1.98338613e-01f, 2.65734017e-01f, -1.74233973e-01f, -3.04494165e-02f, 3.95315051e-01f, 8.65472406e-02f, -1.56540245e-01f, 1.89704776e-01f, -2.72131473e-01f, 5.12572564e-02f,
  2.74809062e-01f, 8.67028385e-02f, -2.26616964e-01f, -1.10228062e-01f, 7.70571008e-02f, 3.52035731e-01f, 4.79498625e-01f, 1.80345714e-01f, 3.36111002e-02f, -9.45012420e-02f,
  4.76981521e-01f, 3.31571475e-02f, -2.20302828e-02f, 1.33889556e-01f, 6.08204186e-01f, 4.25004095e-01f, 5.73314369e-01f, -1.69969633e-01f, -1.13579944e-01f, -2.24340260e-01f,
  -3.03943962e-01f, -5.82455754e-01f, -2.96988457e-01f, 9.15706307e-02f, 5.81524193e-01f, 5.82087457e-01f, -7.66810030e-02f, -2.08678648e-01f, 2.89860547e-01f, -1.26566991e-01f,
  -2.11159796e-01f, -2.06647620e-01f, -2.21511453e-01f, -9.63995159e-02f, -1.03301600e-01f, -2.21673459e-01f, -2.07307965e-01f, -2.51349121e-01f, -1.81659371e-01f, -2.43181914e-01f,
  1.11902945e-01f, -2.20372781e-01f, 3.12129930e-02f, -3.26565690e-02f, -7.87229910e-02f, 2.22398713e-01f, -2.89989233e-01f, 2.34121427e-01f, -2.31155246e-01f, -5.14009967e-02f,
  -1.84211880e-01f, -1.77955162e-02f, -2.16396019e-01f, 3.23839068e-01f, -1.75695926e-01f, 1.11276306e-01f, -1.95046306e-01f, -8.36152807e-02f, 8.41239244e-02f, 1.08421162e-01f,
  1.83336958e-01f, 6.24656565e-02f, -1.61258772e-01f, 5.81240915e-02f, 1.23645157e-01f, -1.17022082e-01f, -3.46464664e-01f, -2.24794239e-01f, 1.40800327e-01f, -4.40340564e-02f,
  2.01081604e-01f, 6.56258166e-02f, -2.04914674e-01f, 1.59225062e-01f, 3.40914786e-01f, 1.43430725e-01f, -1.73897147e-01f, -2.20809937e-01f, -3.83653305e-02f, 8.90613124e-02f,
  -7.45616555e-02f, -9.76491943e-02f, -3.30271274e-01f, -1.77185804e-01f, -6.61446080e-02f, 1.10088222e-01f, 3.78805071e-01f, -2.93785930e-01f, 1.98600397e-01f, 2.04514056e-01f,
  1.06361282e+00f, 1.06481858e-01f, -2.69156337e-01f, -3.50779295e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.70149004e-01f, 1.74520314e-01f, -1.04777940e-01f, -1.86598867e-01f, -7.08639845e-02f, 2.46516511e-01f, 4.08936858e-01f, -1.80705070e-01f, -1.08507842e-01f, 3.10569525e-01f,
  -1.35226503e-01f, 2.37433296e-02f, -1.36868313e-01f, 3.03384691e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -5.11142969e-01f, -3.13384868e-02f, 1.47727787e-01f, 1.88713759e-01f, -1.01255877e-02f, 3.06550384e-01f, -2.23028928e-01f, -6.73547834e-02f, 8.69905874e-02f, 7.85133541e-02f,
  3.58328640e-01f, -5.78421116e-01f, 2.79408157e-01f, 2.95455456e-01f, 1.56015053e-01f, 8.83306786e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.74398744e-01f, 2.01664399e-02f, 1.69212565e-01f, 3.15697826e-02f, -9.35213119e-02f, -3.64949591e-02f, 7.42515102e-02f, -5.30033149e-02f, -1.20866537e-01f, -1.24666795e-01f,
  -1.38936862e-01f, 4.41380627e-02f, 1.72180489e-01f, 4.98127714e-02f, -2.20002793e-02f, -8.10960531e-02f, 1.51898101e-01f, -1.78741351e-01f, 3.13501686e-01f, -3.47112864e-01f,
  -2.17032671e-01f, -5.74322008e-02f, 7.37754047e-01f, 9.49822441e-02f, 4.87297833e-01f, 3.39089960e-01f, 9.10859257e-02f, -2.27346390e-01f, -1.93191156e-01f, -5.89486398e-03f,
  2.45802090e-01f, 2.21367687e-01f, -3.02766234e-01f, 1.41711235e-01f, 3.52453262e-01f, 1.32395893e-01f, 3.94302726e-01f, 3.77997726e-01f, 2.73601972e-02f, 8.97492468e-02f,
  3.20160866e-01f, 3.66189372e-04f, 3.25799376e-01f, -1.36737749e-01f, -1.12613931e-01f, -2.34894797e-01f, 8.71523470e-02f, 4.58671719e-01f, -1.34398550e-01f, -2.13651836e-01f,
  2.08746135e-01f, -3.98131227e-03f, -1.69709492e-02f, -1.34165853e-01f, -1.29293352e-01f, -2.94765502e-01f, 1.75946265e-01f, 1.32269517e-01f, -2.23615453e-01f, -1.38265297e-01f,
  -8.69123861e-02f, 8.72856677e-02f, 5.36758788e-02f, -1.83358565e-01f, 1.03224480e+00f, -3.04583851e-02f, 6.22131944e-01f, 2.45262787e-01f, 9.03790165e-03f, -1.74415424e-01f,
  -4.53396052e-01f, -4.43302572e-01f, 4.33828086e-01f, -3.42685074e-01f, -3.76322359e-01f, 3.17450345e-01f, -1.09531984e-01f, 1.61578581e-02f, -2.08126783e-01f, 4.36308116e-01f,
  -2.31279526e-02f, 8.52757245e-02f, -4.09905799e-02f, 4.44097146e-02f, 2.06934661e-02f, 1.85918331e-01f, -1.15640074e-01f, 2.02609047e-01f, -1.99262366e-01f, -9.36664194e-02f,
  -1.74280703e-01f, -1.35303631e-01f, 1.25179231e-01f, -1.82486534e-01f, -1.67793125e-01f, -1.98466122e-01f, -3.57897431e-01f, 4.31141853e-01f, -2.79034406e-01f, 4.01984036e-01f,
  4.95932400e-01f, -1.21319272e-01f, -4.00501102e-01f, 4.86372858e-01f, -3.17257524e-01f, -1.45816505e-01f, -4.72611785e-02f, 2.23690003e-01f, 3.99130918e-02f, -1.82514787e-01f,
  -6.52450919e-02f, 2.03344166e-01f, 1.63664386e-01f, -1.61820814e-01f, 8.41174349e-02f, 2.31827945e-01f, 1.92969263e-01f, 2.41919056e-01f, 4.07890320e-01f, 7.50444949e-01f,
  -4.59483117e-01f, -3.08414996e-02f, 2.36210916e-02f, -3.39440137e-01f, -1.64364159e-01f, -1.82191227e-02f, 5.64889163e-02f, -4.11468118e-01f, 8.23778093e-01f, -4.89767134e-01f,
  6.80207551e-01f, 5.12800515e-02f, -2.43437082e-01f, -3.80181491e-01f, 6.06533170e-01f, 7.11083353e-01f, 2.80929446e-01f, -7.50049502e-02f, -1.76186822e-02f, -3.72846961e-01f,
  -2.28176117e-01f, -2.05983132e-01f, -4.07360703e-01f, -2.92435497e-01f, 6.99196011e-02f, 4.73044246e-01f, 6.38691723e-01f, -3.52482587e-01f, 3.82871449e-01f, 3.18060458e-01f,
  5.30330777e-01f, 2.21650302e-01f, 7.08710015e-01f, 4.10362244e-01f, 4.07626033e-01f, -4.68282104e-01f, 1.01736486e-02f, -1.52264848e-01f, 3.20047140e-01f, 8.57198179e-01f,
  -2.77991176e-01f, 3.06726426e-01f, -1.46746919e-01f, 7.53596067e-01f, -3.28837521e-02f, 1.82895750e-01f, -4.65722263e-01f, -1.74685046e-01f, -3.17443222e-01f, -7.99273998e-02f,
  1.32608637e-01f, 8.90023172e-01f, -1.79803640e-01f, -2.23842397e-01f, -1.15421347e-01f, -3.16627398e-02f, -4.19589162e-01f, 2.67695665e-01f, 1.00906163e-01f, 4.35778469e-01f,
  4.44186151e-01f, 1.24082744e-01f, -3.30457300e-01f, 3.77073586e-01f, -1.18163154e-01f, -6.88284412e-02f, -1.89490512e-01f, -1.22097082e-01f, 1.69146046e-01f, 2.11810604e-01f,
  -1.52028620e-01f, 2.31939748e-01f, 9.04647052e-01f, -3.75886112e-01f, -1.55912086e-01f, 1.06879008e+00f, 7.39616007e-02f, -3.71592104e-01f, 4.35540438e-01f, 1.09609020e+00f,
  -2.44429603e-01f, -1.81822434e-01f, -3.21944505e-01f, 5.23306787e-01f, -1.45173624e-01f, -1.69536173e-01f, -3.99537474e-01f, -5.40536225e-01f, -9.04183865e-01f, 2.25861177e-01f,
  -2.31204927e-01f, 5.81684709e-01f, 6.40598178e-01f, 3.11331779e-01f, 1.67641193e-01f, 6.86437845e-01f, -3.72512750e-02f, -6.38181865e-02f, 1.54784679e-01f, -1.62915453e-01f,
  -1.60456255e-01f, -7.64276013e-02f, 1.71858773e-01f, 4.95377891e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  6.70697093e-02f, -3.01535651e-02f, -2.94965178e-01f, -2.13768125e-01f, 1.05273259e+00f, 4.45496440e-01f, -1.78854182e-01f, -2.47895494e-01f, 3.95639569e-01f, 9.92741063e-02f,
  2.52248228e-01f, -1.62744433e-01f, 7.79128850e-01f, -4.81579244e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  2.07684457e-01f, 2.68346518e-01f, 6.95407167e-02f, -2.43726760e-01f, 3.55407059e-01f, -5.31810634e-02f, -1.69662714e-01f, 1.91600025e-02f, 1.12190314e-01f, 2.85195082e-01f,
  -4.38278943e-01f, 9.55859721e-02f, -4.55973804e-01f, 3.28903407e-01f, -7.01471090e-01f, 9.20361578e-01f, -8.28482032e-01f, 4.97708797e-01f, 1.02534279e-01f, -5.62352896e-01f,
  2.66028792e-01f, 2.49852445e-02f, -4.55111325e-01f, 2.42986873e-01f, 5.69268644e-01f, 3.86135519e-01f, -1.89334422e-01f, -5.12464106e-01f, -7.43511021e-02f, 2.65532881e-01f,
  1.62084162e-01f, 4.08983022e-01f, 3.23884130e-01f, 8.65429282e-01f, -1.26315281e-01f, 2.16953218e-01f, 1.82754353e-01f, -1.37790561e-01f, 4.19945300e-01f, 9.92819853e-03f,
  -3.18651587e-01f, -1.77616671e-01f, 3.03468049e-01f, 6.64257050e-01f, -3.15101206e-01f, -1.44776747e-01f, -8.34890604e-01f, -6.49462640e-01f, -3.36561590e-01f, 1.69084653e-01f,
  2.71796852e-01f, 4.79301155e-01f, 4.32751447e-01f, 1.71453580e-01f, -3.96799028e-01f, -2.78349183e-02f, 1.26379177e-01f, -5.47330081e-01f, -4.87164706e-01f, 6.50871933e-01f,
  1.14841364e-01f, -2.18613729e-01f, -1.09716177e+00f, 1.09611608e-01f, -9.48607981e-01f, -5.07008076e-01f, 1.34701356e-01f, 6.76449910e-02f, 2.86700636e-01f, 2.02467591e-01f,
  -5.35357296e-01f, 1.76941186e-01f, -2.88285255e-01f, 1.98232159e-01f, -3.00562046e-02f, 5.17954051e-01f, 9.29043069e-02f, -4.59772237e-02f, -3.95484596e-01f, 1.79265320e-01f,
  -1.55726209e-01f, 4.64395165e-01f, -8.13035071e-02f, 1.63454667e-01f, -1.23235218e-01f, -2.06238046e-01f, -1.20052427e-01f, 6.66119382e-02f, 1.09399222e-01f, 4.87261742e-01f,
  3.09767544e-01f, -1.70341164e-01f, -5.44782579e-01f, 2.34319821e-01f, 4.51305896e-01f, -1.02044359e-01f, 6.80121899e-01f, -9.65691745e-01f, -4.79398631e-02f, -4.23785090e-01f,
  -3.91185492e-01f, -2.54107922e-01f, 1.03674996e+00f, 2.83138752e-01f, -2.62292713e-01f, -4.78124201e-01f, 1.57407433e-01f, -9.38603759e-01f, 7.39624277e-02f, -6.24699891e-01f,
  8.74486923e-01f, -7.37309277e-01f, 2.83737332e-01f, 4.00966257e-02f, 6.47992566e-02f, -2.42157266e-01f, 4.33114737e-01f, 1.77633002e-01f, -2.65549719e-01f, -3.77496220e-02f,
  4.70184267e-01f, -3.47809076e-01f, -8.99745405e-01f, -3.24965447e-01f, 4.49607998e-01f, 1.29837245e-01f, 4.14736532e-02f, 6.75160170e-01f, 5.18472493e-01f, -3.40237707e-01f,
  -8.49762186e-02f, -1.69402748e-01f, -5.85057795e-01f, -1.75389960e-01f, -5.39981723e-01f, 2.53894299e-01f, -1.44305199e-01f, 2.37158000e-01f, 3.65233064e-01f, -8.66458893e-01f,
  -3.60766798e-01f, -3.95578027e-01f, 1.06822002e+00f, -5.91303483e-02f, 1.31973827e+00f, -3.50317806e-02f, 4.60544080e-02f, 2.64316276e-02f, 7.99257979e-02f, 5.13460487e-02f,
  8.94633651e-01f, 1.17717884e-01f, -1.03452474e-01f, -1.66686729e-01f, 5.23657680e-01f, 4.88028526e-02f, -3.39452237e-01f, -4.86053862e-02f, 2.61218786e-01f, -4.38625425e-01f,
  -6.30639791e-01f, 9.06324387e-01f, -1.90235361e-01f, 5.77880979e-01f, -1.72688365e-02f, 9.39290300e-02f, -5.26989937e-01f, -2.02279985e-01f, -6.97421372e-01f, 3.87694687e-01f,
  7.33500779e-01f, 9.90889519e-02f, -3.76900107e-01f, -5.05791187e-01f, -2.73431819e-02f, -1.66316301e-01f, 2.45913416e-01f, -5.62232137e-01f, 2.20878199e-01f, -3.01905572e-01f,
  -2.99902767e-01f, 9.98121575e-02f, 4.04444858e-02f, -3.11874580e-02f, 2.42500007e-01f, -1.90408275e-01f, -7.33518183e-01f, -5.56112707e-01f, 9.04150605e-01f, -2.04889283e-01f,
  6.45134330e-01f, -3.90025139e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.74423975e-01f, -3.40760440e-01f, 4.05364811e-01f, -4.04356837e-01f, 1.06000220e-02f, -4.15659398e-01f, 8.29213679e-01f, -2.03097776e-01f, -7.09370300e-02f, 8.92286897e-01f,
  1.35440649e-02f, 2.50322968e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    